C {devices/lab_pin.sym} 106490 -5910 0 0 {name=p106182 lab=_83508_/CLK }
C {devices/lab_pin.sym} 106490 -5890 0 0 {name=p106183 lab=_71412_/X }
C {devices/lab_pin.sym} 106670 -5910 0 1 {name=p106184 lab=_83508_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -5900 0 0 {name=X_83508_ }
C {devices/lab_pin.sym} 106500 -5800 0 0 {name=p106185 lab=_41168_/Y }
C {devices/lab_pin.sym} 106500 -5760 0 0 {name=p106186 lab=_44464_/X }
C {devices/lab_pin.sym} 106500 -5720 0 0 {name=p106187 lab=_87092_/Q }
C {devices/lab_pin.sym} 106500 -5680 0 0 {name=p106188 lab=_44466_/X }
C {devices/lab_pin.sym} 106660 -5740 0 1 {name=p106189 lab=_44470_/X }
C {sky130_stdcells/a2bb2o_4.sym} 106580 -5740 0 0 {name=X_44470_ }
C {devices/lab_pin.sym} 106540 -5590 0 0 {name=p106190 lab=_56456_/A }
C {devices/lab_pin.sym} 106620 -5590 0 1 {name=p106191 lab=_57364_/D }
C {sky130_stdcells/buf_2.sym} 106580 -5590 0 0 {name=X_56456_ }
C {devices/lab_pin.sym} 106540 -5470 0 0 {name=p106192 lab=_75289_/Y }
C {devices/lab_pin.sym} 106620 -5470 0 1 {name=p106193 lab=_75291_/C }
C {sky130_stdcells/inv_2.sym} 106580 -5470 0 0 {name=X_75290_ }
C {devices/lab_pin.sym} 106540 -5350 0 0 {name=p106194 lab=_41799_/A }
C {devices/lab_pin.sym} 106620 -5350 0 1 {name=p106195 lab=_41682_/X }
C {sky130_stdcells/buf_2.sym} 106580 -5350 0 0 {name=X_41682_ }
C {devices/lab_pin.sym} 106490 -5230 0 0 {name=p106196 lab=_88056_/CLK }
C {devices/lab_pin.sym} 106490 -5210 0 0 {name=p106197 lab=_43766_/Y }
C {devices/lab_pin.sym} 106670 -5230 0 1 {name=p106198 lab=_69236_/B }
C {sky130_stdcells/dfxtp_4.sym} 106580 -5220 0 0 {name=X_87276_ }
C {devices/lab_pin.sym} 106500 -5110 0 0 {name=p106199 lab=_53664_/Y }
C {devices/lab_pin.sym} 106500 -5070 0 0 {name=p106200 lab=_53653_/X }
C {devices/lab_pin.sym} 106500 -5030 0 0 {name=p106201 lab=_53667_/X }
C {devices/lab_pin.sym} 106660 -5070 0 1 {name=p106202 lab=_53668_/Y }
C {sky130_stdcells/a21oi_4.sym} 106580 -5070 0 0 {name=X_53668_ }
C {devices/lab_pin.sym} 106490 -4930 0 0 {name=p106203 lab=_84487_/CLK }
C {devices/lab_pin.sym} 106490 -4910 0 0 {name=p106204 lab=_84488_/D }
C {devices/lab_pin.sym} 106670 -4930 0 1 {name=p106205 lab=_84488_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -4920 0 0 {name=X_84488_ }
C {sky130_stdcells/decap_3.sym} 106580 -4760 0 0 {name=XPHY_210 }
C {devices/lab_pin.sym} 106540 -4610 0 0 {name=p106206 lab=_40362_/X }
C {devices/lab_pin.sym} 106620 -4610 0 1 {name=p106207 lab=_43518_/A }
C {sky130_stdcells/buf_2.sym} 106580 -4610 0 0 {name=X_43421_ }
C {devices/lab_pin.sym} 106540 -4490 0 0 {name=p106208 lab=_55405_/X }
C {devices/lab_pin.sym} 106620 -4490 0 1 {name=p106209 lab=_55408_/B }
C {sky130_stdcells/inv_2.sym} 106580 -4490 0 0 {name=X_55407_ }
C {devices/lab_pin.sym} 106520 -4380 0 0 {name=p106210 lab=_74241_/A }
C {devices/lab_pin.sym} 106520 -4340 0 0 {name=p106211 lab=_74241_/B }
C {devices/lab_pin.sym} 106640 -4360 0 1 {name=p106212 lab=_74241_/Y }
C {sky130_stdcells/xnor2_4.sym} 106580 -4360 0 0 {name=X_74241_ }
C {devices/lab_pin.sym} 106490 -4230 0 0 {name=p106213 lab=_86578_/CLK }
C {devices/lab_pin.sym} 106490 -4210 0 0 {name=p106214 lab=_86227_/D }
C {devices/lab_pin.sym} 106670 -4230 0 1 {name=p106215 lab=_86227_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -4220 0 0 {name=X_86227_ }
C {sky130_stdcells/decap_3.sym} 106580 -4060 0 0 {name=XPHY_221 }
C {devices/lab_pin.sym} 106540 -3910 0 0 {name=p106216 lab=_52619_/A }
C {devices/lab_pin.sym} 106620 -3910 0 1 {name=p106217 lab=_52619_/X }
C {sky130_stdcells/buf_2.sym} 106580 -3910 0 0 {name=X_52619_ }
C {devices/lab_pin.sym} 106540 -3790 0 0 {name=p106218 lab=_40632_/Y }
C {devices/lab_pin.sym} 106620 -3790 0 1 {name=p106219 lab=_40633_/X }
C {sky130_stdcells/buf_2.sym} 106580 -3790 0 0 {name=X_40633_ }
C {devices/lab_pin.sym} 106500 -3690 0 0 {name=p106220 lab=_71445_/X }
C {devices/lab_pin.sym} 106500 -3650 0 0 {name=p106221 lab=_83494_/Q }
C {devices/lab_pin.sym} 106500 -3610 0 0 {name=p106222 lab=_71452_/Y }
C {devices/lab_pin.sym} 106660 -3650 0 1 {name=p106223 lab=_71453_/X }
C {sky130_stdcells/a21o_4.sym} 106580 -3650 0 0 {name=X_71453_ }
C {devices/lab_pin.sym} 106500 -3530 0 0 {name=p106224 lab=_59135_/X }
C {devices/lab_pin.sym} 106500 -3490 0 0 {name=p106225 lab=_85651_/Q }
C {devices/lab_pin.sym} 106500 -3450 0 0 {name=p106226 lab=_59070_/X }
C {devices/lab_pin.sym} 106660 -3490 0 1 {name=p106227 lab=_59175_/X }
C {sky130_stdcells/o21a_4.sym} 106580 -3490 0 0 {name=X_59175_ }
C {devices/lab_pin.sym} 106490 -3350 0 0 {name=p106228 lab=_83402_/CLK }
C {devices/lab_pin.sym} 106490 -3330 0 0 {name=p106229 lab=_71613_/X }
C {devices/lab_pin.sym} 106670 -3350 0 1 {name=p106230 lab=_83439_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -3340 0 0 {name=X_83439_ }
C {sky130_stdcells/decap_3.sym} 106580 -3180 0 0 {name=XPHY_232 }
C {devices/lab_pin.sym} 106500 -3050 0 0 {name=p106231 lab=_56020_/X }
C {devices/lab_pin.sym} 106500 -3010 0 0 {name=p106232 lab=_56378_/X }
C {devices/lab_pin.sym} 106500 -2970 0 0 {name=p106233 lab=_56386_/Y }
C {devices/lab_pin.sym} 106660 -3010 0 1 {name=p106234 lab=_56387_/Y }
C {sky130_stdcells/o21ai_4.sym} 106580 -3010 0 0 {name=X_56387_ }
C {devices/lab_pin.sym} 106520 -2880 0 0 {name=p106235 lab=_53604_/A }
C {devices/lab_pin.sym} 106520 -2840 0 0 {name=p106236 lab=_52079_/B }
C {devices/lab_pin.sym} 106640 -2860 0 1 {name=p106237 lab=_53599_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -2860 0 0 {name=X_53599_ }
C {sky130_stdcells/decap_3.sym} 106580 -2700 0 0 {name=XPHY_243 }
C {sky130_stdcells/decap_3.sym} 106580 -2520 0 0 {name=XPHY_254 }
C {devices/lab_pin.sym} 106540 -2370 0 0 {name=p106238 lab=DATA_TO_HASH[0] }
C {devices/lab_pin.sym} 106620 -2370 0 1 {name=p106239 lab=_71090_/A }
C {sky130_stdcells/buf_2.sym} 106580 -2370 0 0 {name=X_70404_ }
C {devices/lab_pin.sym} 106500 -2280 0 0 {name=p106240 lab=_46195_/A }
C {devices/lab_pin.sym} 106500 -2240 0 0 {name=p106241 lab=_46135_/Y }
C {devices/lab_pin.sym} 106500 -2200 0 0 {name=p106242 lab=_57657_/B }
C {devices/lab_pin.sym} 106500 -2160 0 0 {name=p106243 lab=_46139_/Y }
C {devices/lab_pin.sym} 106660 -2220 0 1 {name=p106244 lab=_46140_/X }
C {sky130_stdcells/a211o_4.sym} 106580 -2220 0 0 {name=X_46140_ }
C {devices/lab_pin.sym} 106540 -2070 0 0 {name=p106245 lab=_58126_/A }
C {devices/lab_pin.sym} 106620 -2070 0 1 {name=p106246 lab=_58126_/X }
C {sky130_stdcells/buf_2.sym} 106580 -2070 0 0 {name=X_58126_ }
C {sky130_stdcells/decap_3.sym} 106580 -1920 0 0 {name=XPHY_265 }
C {devices/lab_pin.sym} 106540 -1770 0 0 {name=p106247 lab=_43352_/A }
C {devices/lab_pin.sym} 106620 -1770 0 1 {name=p106248 lab=_87465_/D }
C {sky130_stdcells/inv_2.sym} 106580 -1770 0 0 {name=X_43352_ }
C {devices/lab_pin.sym} 106500 -1680 0 0 {name=p106249 lab=_82992_/Q }
C {devices/lab_pin.sym} 106500 -1640 0 0 {name=p106250 lab=_44061_/X }
C {devices/lab_pin.sym} 106500 -1600 0 0 {name=p106251 lab=_55312_/X }
C {devices/lab_pin.sym} 106500 -1560 0 0 {name=p106252 lab=_55337_/X }
C {devices/lab_pin.sym} 106660 -1620 0 1 {name=p106253 lab=_55365_/B }
C {sky130_stdcells/a211o_4.sym} 106580 -1620 0 0 {name=X_55338_ }
C {devices/lab_pin.sym} 106520 -1480 0 0 {name=p106254 lab=_74232_/A }
C {devices/lab_pin.sym} 106520 -1440 0 0 {name=p106255 lab=_66283_/B }
C {devices/lab_pin.sym} 106640 -1460 0 1 {name=p106256 lab=_74172_/X }
C {sky130_stdcells/and2_4.sym} 106580 -1460 0 0 {name=X_74172_ }
C {devices/lab_pin.sym} 106490 -1330 0 0 {name=p106257 lab=_85555_/CLK }
C {devices/lab_pin.sym} 106490 -1310 0 0 {name=p106258 lab=_86158_/D }
C {devices/lab_pin.sym} 106670 -1330 0 1 {name=p106259 lab=_86158_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -1320 0 0 {name=X_86158_ }
C {devices/lab_pin.sym} 106540 -1190 0 0 {name=p106260 lab=_40563_/X }
C {devices/lab_pin.sym} 106620 -1190 0 1 {name=p106261 lab=_48162_/A }
C {sky130_stdcells/buf_2.sym} 106580 -1190 0 0 {name=X_40564_ }
C {sky130_stdcells/decap_3.sym} 106580 -1040 0 0 {name=XPHY_276 }
C {devices/lab_pin.sym} 106500 -910 0 0 {name=p106262 lab=_71373_/X }
C {devices/lab_pin.sym} 106500 -870 0 0 {name=p106263 lab=_83518_/Q }
C {devices/lab_pin.sym} 106500 -830 0 0 {name=p106264 lab=_71383_/Y }
C {devices/lab_pin.sym} 106660 -870 0 1 {name=p106265 lab=_71384_/X }
C {sky130_stdcells/a21o_4.sym} 106580 -870 0 0 {name=X_71384_ }
C {sky130_stdcells/decap_3.sym} 106580 -700 0 0 {name=XPHY_287 }
C {sky130_stdcells/decap_3.sym} 107500 -42120 0 0 {name=XPHY_298 }
C {devices/lab_pin.sym} 107460 -41970 0 0 {name=p106266 lab=_42290_/A }
C {devices/lab_pin.sym} 107540 -41970 0 1 {name=p106267 lab=_42303_/X }
C {sky130_stdcells/buf_2.sym} 107500 -41970 0 0 {name=X_42303_ }
C {devices/lab_pin.sym} 107420 -41870 0 0 {name=p106268 lab=_83164_/Q }
C {devices/lab_pin.sym} 107420 -41830 0 0 {name=p106269 lab=_73079_/X }
C {devices/lab_pin.sym} 107420 -41790 0 0 {name=p106270 lab=_73122_/X }
C {devices/lab_pin.sym} 107580 -41830 0 1 {name=p106271 lab=_73123_/X }
C {sky130_stdcells/a21o_4.sym} 107500 -41830 0 0 {name=X_73123_ }
C {devices/lab_pin.sym} 107410 -41690 0 0 {name=p106272 lab=_85074_/CLK }
C {devices/lab_pin.sym} 107410 -41670 0 0 {name=p106273 lab=_85109_/D }
C {devices/lab_pin.sym} 107590 -41690 0 1 {name=p106274 lab=_45582_/A }
C {sky130_stdcells/dfxtp_4.sym} 107500 -41680 0 0 {name=X_85109_ }
C {devices/lab_pin.sym} 107420 -41580 0 0 {name=p106275 lab=_41580_/A }
C {devices/lab_pin.sym} 107420 -41540 0 0 {name=p106276 lab=_46061_/X }
C {devices/lab_pin.sym} 107420 -41500 0 0 {name=p106277 lab=_67123_/B }
C {devices/lab_pin.sym} 107420 -41460 0 0 {name=p106278 lab=_46062_/X }
C {devices/lab_pin.sym} 107580 -41520 0 1 {name=p106279 lab=_86783_/D }
C {sky130_stdcells/a2bb2o_4.sym} 107500 -41520 0 0 {name=X_46071_ }
C {devices/lab_pin.sym} 107420 -41400 0 0 {name=p106280 lab=_58048_/Y }
C {devices/lab_pin.sym} 107420 -41360 0 0 {name=p106281 lab=_57981_/X }
C {devices/lab_pin.sym} 107420 -41320 0 0 {name=p106282 lab=_58053_/X }
C {devices/lab_pin.sym} 107420 -41280 0 0 {name=p106283 lab=_58056_/X }
C {devices/lab_pin.sym} 107580 -41340 0 1 {name=p106284 lab=_84929_/D }
C {sky130_stdcells/a22oi_4.sym} 107500 -41340 0 0 {name=X_58057_ }
C {devices/lab_pin.sym} 107440 -41220 0 0 {name=p106285 lab=_70338_/A }
C {devices/lab_pin.sym} 107440 -41180 0 0 {name=p106286 lab=_70333_/B }
C {devices/lab_pin.sym} 107440 -41140 0 0 {name=p106287 lab=_83089_/Q }
C {devices/lab_pin.sym} 107440 -41100 0 0 {name=p106288 lab=_70332_/X }
C {devices/lab_pin.sym} 107560 -41160 0 1 {name=p106289 lab=_70335_/X }
C {sky130_stdcells/and4_4.sym} 107500 -41160 0 0 {name=X_70335_ }
C {devices/lab_pin.sym} 107440 -41020 0 0 {name=p106290 lab=_55276_/A }
C {devices/lab_pin.sym} 107440 -40980 0 0 {name=p106291 lab=_57210_/B }
C {devices/lab_pin.sym} 107560 -41000 0 1 {name=p106292 lab=_55269_/X }
C {sky130_stdcells/and2_4.sym} 107500 -41000 0 0 {name=X_55269_ }
C {devices/lab_pin.sym} 107420 -40900 0 0 {name=p106293 lab=_41151_/X }
C {devices/lab_pin.sym} 107420 -40860 0 0 {name=p106294 lab=_43277_/X }
C {devices/lab_pin.sym} 107420 -40820 0 0 {name=p106295 lab=_87500_/Q }
C {devices/lab_pin.sym} 107420 -40780 0 0 {name=p106296 lab=_43278_/X }
C {devices/lab_pin.sym} 107580 -40840 0 1 {name=p106297 lab=_87500_/D }
C {sky130_stdcells/a2bb2o_4.sym} 107500 -40840 0 0 {name=X_43283_ }
C {devices/lab_pin.sym} 107420 -40710 0 0 {name=p106298 lab=_78968_/A }
C {devices/lab_pin.sym} 107420 -40670 0 0 {name=p106299 lab=_78967_/Y }
C {devices/lab_pin.sym} 107420 -40630 0 0 {name=p106300 lab=_78979_/X }
C {devices/lab_pin.sym} 107580 -40670 0 1 {name=p106301 lab=_78981_/B }
C {sky130_stdcells/o21ai_4.sym} 107500 -40670 0 0 {name=X_78980_ }
C {devices/lab_pin.sym} 107410 -40530 0 0 {name=p106302 lab=_86089_/CLK }
C {devices/lab_pin.sym} 107410 -40510 0 0 {name=p106303 lab=_86089_/D }
C {devices/lab_pin.sym} 107590 -40530 0 1 {name=p106304 lab=_86089_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -40520 0 0 {name=X_86089_ }
C {devices/lab_pin.sym} 107440 -40400 0 0 {name=p106305 lab=_40416_/A }
C {devices/lab_pin.sym} 107440 -40360 0 0 {name=p106306 lab=_81164_/Q }
C {devices/lab_pin.sym} 107560 -40380 0 1 {name=p106307 lab=_40495_/X }
C {sky130_stdcells/or2_4.sym} 107500 -40380 0 0 {name=X_40495_ }
C {devices/lab_pin.sym} 107460 -40250 0 0 {name=p106308 lab=_56991_/Y }
C {devices/lab_pin.sym} 107540 -40250 0 1 {name=p106309 lab=_57024_/D }
C {sky130_stdcells/buf_2.sym} 107500 -40250 0 0 {name=X_57008_ }
C {devices/lab_pin.sym} 107460 -40130 0 0 {name=p106310 lab=_64294_/B }
C {devices/lab_pin.sym} 107540 -40130 0 1 {name=p106311 lab=_61417_/B }
C {sky130_stdcells/buf_2.sym} 107500 -40130 0 0 {name=X_45022_ }
C {devices/lab_pin.sym} 107420 -40050 0 0 {name=p106312 lab=_42231_/X }
C {devices/lab_pin.sym} 107420 -40010 0 0 {name=p106313 lab=_42226_/X }
C {devices/lab_pin.sym} 107420 -39970 0 0 {name=p106314 lab=_41387_/X }
C {devices/lab_pin.sym} 107420 -39930 0 0 {name=p106315 lab=_87968_/Q }
C {devices/lab_pin.sym} 107420 -39890 0 0 {name=p106316 lab=_42228_/X }
C {devices/lab_pin.sym} 107580 -39970 0 1 {name=p106317 lab=_42234_/Y }
C {sky130_stdcells/o32ai_4.sym} 107500 -39970 0 0 {name=X_42234_ }
C {devices/lab_pin.sym} 107420 -39830 0 0 {name=p106318 lab=_77920_/A }
C {devices/lab_pin.sym} 107420 -39790 0 0 {name=p106319 lab=_77919_/Y }
C {devices/lab_pin.sym} 107420 -39750 0 0 {name=p106320 lab=_77930_/X }
C {devices/lab_pin.sym} 107580 -39790 0 1 {name=p106321 lab=_77931_/Y }
C {sky130_stdcells/a21oi_4.sym} 107500 -39790 0 0 {name=X_77931_ }
C {devices/lab_pin.sym} 107420 -39680 0 0 {name=p106322 lab=_42011_/Y }
C {devices/lab_pin.sym} 107420 -39640 0 0 {name=p106323 lab=_72921_/X }
C {devices/lab_pin.sym} 107420 -39600 0 0 {name=p106324 lab=_72944_/X }
C {devices/lab_pin.sym} 107420 -39560 0 0 {name=p106325 lab=_73053_/Y }
C {devices/lab_pin.sym} 107580 -39620 0 1 {name=p106326 lab=_73054_/X }
C {sky130_stdcells/a211o_4.sym} 107500 -39620 0 0 {name=X_73054_ }
C {devices/lab_pin.sym} 107420 -39490 0 0 {name=p106327 lab=_70255_/X }
C {devices/lab_pin.sym} 107420 -39450 0 0 {name=p106328 lab=_74720_/B }
C {devices/lab_pin.sym} 107420 -39410 0 0 {name=p106329 lab=_70265_/X }
C {devices/lab_pin.sym} 107580 -39450 0 1 {name=p106330 lab=_70266_/X }
C {sky130_stdcells/a21o_4.sym} 107500 -39450 0 0 {name=X_70266_ }
C {devices/lab_pin.sym} 107440 -39330 0 0 {name=p106331 lab=_48978_/A }
C {devices/lab_pin.sym} 107440 -39290 0 0 {name=p106332 lab=_71959_/X }
C {devices/lab_pin.sym} 107440 -39250 0 0 {name=p106333 lab=_71964_/X }
C {devices/lab_pin.sym} 107560 -39290 0 1 {name=p106334 lab=_72005_/X }
C {sky130_stdcells/and3_4.sym} 107500 -39290 0 0 {name=X_72005_ }
C {devices/lab_pin.sym} 107440 -39180 0 0 {name=p106335 lab=_49830_/A }
C {devices/lab_pin.sym} 107440 -39140 0 0 {name=p106336 lab=_49830_/B }
C {devices/lab_pin.sym} 107440 -39100 0 0 {name=p106337 lab=_49830_/C }
C {devices/lab_pin.sym} 107440 -39060 0 0 {name=p106338 lab=_53044_/D }
C {devices/lab_pin.sym} 107560 -39120 0 1 {name=p106339 lab=_49830_/X }
C {sky130_stdcells/and4_4.sym} 107500 -39120 0 0 {name=X_49830_ }
C {devices/lab_pin.sym} 107420 -39010 0 0 {name=p106340 lab=_42154_/X }
C {devices/lab_pin.sym} 107420 -38970 0 0 {name=p106341 lab=_42141_/X }
C {devices/lab_pin.sym} 107420 -38930 0 0 {name=p106342 lab=_41209_/X }
C {devices/lab_pin.sym} 107420 -38890 0 0 {name=p106343 lab=_88001_/Q }
C {devices/lab_pin.sym} 107420 -38850 0 0 {name=p106344 lab=_42142_/X }
C {devices/lab_pin.sym} 107580 -38930 0 1 {name=p106345 lab=_42166_/A }
C {sky130_stdcells/o32ai_4.sym} 107500 -38930 0 0 {name=X_42165_ }
C {devices/lab_pin.sym} 107440 -38780 0 0 {name=p106346 lab=_82160_/Q }
C {devices/lab_pin.sym} 107440 -38740 0 0 {name=p106347 lab=_77862_/B }
C {devices/lab_pin.sym} 107560 -38760 0 1 {name=p106348 lab=_82128_/D }
C {sky130_stdcells/xor2_4.sym} 107500 -38760 0 0 {name=X_77862_ }
C {devices/lab_pin.sym} 107420 -38650 0 0 {name=p106349 lab=_70195_/X }
C {devices/lab_pin.sym} 107420 -38610 0 0 {name=p106350 lab=_83841_/Q }
C {devices/lab_pin.sym} 107420 -38570 0 0 {name=p106351 lab=_70196_/X }
C {devices/lab_pin.sym} 107580 -38610 0 1 {name=p106352 lab=_70197_/X }
C {sky130_stdcells/a21o_4.sym} 107500 -38610 0 0 {name=X_70197_ }
C {devices/lab_pin.sym} 107440 -38480 0 0 {name=p106353 lab=_79605_/A }
C {devices/lab_pin.sym} 107440 -38440 0 0 {name=p106354 lab=_79605_/B }
C {devices/lab_pin.sym} 107560 -38460 0 1 {name=p106355 lab=_79601_/X }
C {sky130_stdcells/xor2_4.sym} 107500 -38460 0 0 {name=X_79601_ }
C {devices/lab_pin.sym} 107460 -38330 0 0 {name=p106356 lab=_41115_/X }
C {devices/lab_pin.sym} 107540 -38330 0 1 {name=p106357 lab=_41116_/X }
C {sky130_stdcells/buf_2.sym} 107500 -38330 0 0 {name=X_41116_ }
C {devices/lab_pin.sym} 107460 -38210 0 0 {name=p106358 lab=_76812_/X }
C {devices/lab_pin.sym} 107540 -38210 0 1 {name=p106359 lab=_76818_/A }
C {sky130_stdcells/inv_2.sym} 107500 -38210 0 0 {name=X_76813_ }
C {devices/lab_pin.sym} 107440 -38120 0 0 {name=p106360 lab=_49779_/A }
C {devices/lab_pin.sym} 107440 -38080 0 0 {name=p106361 lab=_49750_/X }
C {devices/lab_pin.sym} 107440 -38040 0 0 {name=p106362 lab=_49761_/C }
C {devices/lab_pin.sym} 107440 -38000 0 0 {name=p106363 lab=_52977_/D }
C {devices/lab_pin.sym} 107560 -38060 0 1 {name=p106364 lab=_49761_/X }
C {sky130_stdcells/and4_4.sym} 107500 -38060 0 0 {name=X_49761_ }
C {devices/lab_pin.sym} 107440 -37940 0 0 {name=p106365 lab=_46981_/A }
C {devices/lab_pin.sym} 107440 -37900 0 0 {name=p106366 lab=_46944_/B }
C {devices/lab_pin.sym} 107440 -37860 0 0 {name=p106367 lab=_46981_/C }
C {devices/lab_pin.sym} 107440 -37820 0 0 {name=p106368 lab=_52779_/D }
C {devices/lab_pin.sym} 107560 -37880 0 1 {name=p106369 lab=_46973_/X }
C {sky130_stdcells/and4_4.sym} 107500 -37880 0 0 {name=X_46973_ }
C {devices/lab_pin.sym} 107460 -37730 0 0 {name=p106370 lab=_58603_/A }
C {devices/lab_pin.sym} 107540 -37730 0 1 {name=p106371 lab=_58959_/X }
C {sky130_stdcells/buf_2.sym} 107500 -37730 0 0 {name=X_58959_ }
C {devices/lab_pin.sym} 107460 -37610 0 0 {name=p106372 lab=_42096_/A }
C {devices/lab_pin.sym} 107540 -37610 0 1 {name=p106373 lab=_42096_/X }
C {sky130_stdcells/buf_2.sym} 107500 -37610 0 0 {name=X_42096_ }
C {devices/lab_pin.sym} 107460 -37490 0 0 {name=p106374 lab=_82058_/Q }
C {devices/lab_pin.sym} 107540 -37490 0 1 {name=p106375 lab=_77809_/A }
C {sky130_stdcells/inv_2.sym} 107500 -37490 0 0 {name=X_77793_ }
C {devices/lab_pin.sym} 107420 -37390 0 0 {name=p106376 lab=_48707_/Y }
C {devices/lab_pin.sym} 107420 -37350 0 0 {name=p106377 lab=_48403_/X }
C {devices/lab_pin.sym} 107420 -37310 0 0 {name=p106378 lab=_48711_/Y }
C {devices/lab_pin.sym} 107580 -37350 0 1 {name=p106379 lab=_48712_/Y }
C {sky130_stdcells/a21boi_4.sym} 107500 -37350 0 0 {name=X_48712_ }
C {devices/lab_pin.sym} 107440 -37220 0 0 {name=p106380 lab=_65421_/C }
C {devices/lab_pin.sym} 107440 -37180 0 0 {name=p106381 lab=_83250_/Q }
C {devices/lab_pin.sym} 107560 -37200 0 1 {name=p106382 lab=_79532_/Y }
C {sky130_stdcells/nand2_4.sym} 107500 -37200 0 0 {name=X_79532_ }
C {devices/lab_pin.sym} 107460 -37070 0 0 {name=p106383 lab=_45924_/A }
C {devices/lab_pin.sym} 107540 -37070 0 1 {name=p106384 lab=_65034_/A }
C {sky130_stdcells/buf_2.sym} 107500 -37070 0 0 {name=X_45924_ }
C {devices/lab_pin.sym} 107460 -36950 0 0 {name=p106385 lab=_41047_/A }
C {devices/lab_pin.sym} 107540 -36950 0 1 {name=p106386 lab=_88288_/D }
C {sky130_stdcells/inv_2.sym} 107500 -36950 0 0 {name=X_41047_ }
C {devices/lab_pin.sym} 107440 -36840 0 0 {name=p106387 lab=_76744_/A }
C {devices/lab_pin.sym} 107440 -36800 0 0 {name=p106388 lab=_76743_/Y }
C {devices/lab_pin.sym} 107560 -36820 0 1 {name=p106389 lab=_76745_/B }
C {sky130_stdcells/xor2_4.sym} 107500 -36820 0 0 {name=X_76744_ }
C {devices/lab_pin.sym} 107440 -36720 0 0 {name=p106390 lab=_49685_/A }
C {devices/lab_pin.sym} 107440 -36680 0 0 {name=p106391 lab=_49669_/B }
C {devices/lab_pin.sym} 107440 -36640 0 0 {name=p106392 lab=_49685_/C }
C {devices/lab_pin.sym} 107440 -36600 0 0 {name=p106393 lab=_51214_/D }
C {devices/lab_pin.sym} 107560 -36660 0 1 {name=p106394 lab=_49692_/X }
C {sky130_stdcells/and4_4.sym} 107500 -36660 0 0 {name=X_49692_ }
C {devices/lab_pin.sym} 107460 -36510 0 0 {name=p106395 lab=_61747_/X }
C {devices/lab_pin.sym} 107540 -36510 0 1 {name=p106396 lab=_61971_/D }
C {sky130_stdcells/buf_2.sym} 107500 -36510 0 0 {name=X_61970_ }
C {devices/lab_pin.sym} 107440 -36400 0 0 {name=p106397 lab=_73956_/A }
C {devices/lab_pin.sym} 107440 -36360 0 0 {name=p106398 lab=_73955_/X }
C {devices/lab_pin.sym} 107560 -36380 0 1 {name=p106399 lab=_73957_/B }
C {sky130_stdcells/nand2_4.sym} 107500 -36380 0 0 {name=X_73956_ }
C {devices/lab_pin.sym} 107420 -36270 0 0 {name=p106400 lab=_48606_/X }
C {devices/lab_pin.sym} 107420 -36230 0 0 {name=p106401 lab=_49139_/B }
C {devices/lab_pin.sym} 107420 -36190 0 0 {name=p106402 lab=_48642_/Y }
C {devices/lab_pin.sym} 107580 -36230 0 1 {name=p106403 lab=_48644_/A }
C {sky130_stdcells/o21ai_4.sym} 107500 -36230 0 0 {name=X_48643_ }
C {devices/lab_pin.sym} 107460 -36090 0 0 {name=p106404 lab=_63761_/A }
C {devices/lab_pin.sym} 107540 -36090 0 1 {name=p106405 lab=_60921_/X }
C {sky130_stdcells/buf_2.sym} 107500 -36090 0 0 {name=X_60921_ }
C {devices/lab_pin.sym} 107420 -36000 0 0 {name=p106406 lab=_72870_/X }
C {devices/lab_pin.sym} 107420 -35960 0 0 {name=p106407 lab=_86204_/Q }
C {devices/lab_pin.sym} 107420 -35920 0 0 {name=p106408 lab=_72905_/X }
C {devices/lab_pin.sym} 107420 -35880 0 0 {name=p106409 lab=_72906_/X }
C {devices/lab_pin.sym} 107580 -35940 0 1 {name=p106410 lab=_72907_/X }
C {sky130_stdcells/a211o_4.sym} 107500 -35940 0 0 {name=X_72907_ }
C {devices/lab_pin.sym} 107440 -35800 0 0 {name=p106411 lab=_79481_/A }
C {devices/lab_pin.sym} 107440 -35760 0 0 {name=p106412 lab=_79462_/Y }
C {devices/lab_pin.sym} 107560 -35780 0 1 {name=p106413 lab=_82844_/D }
C {sky130_stdcells/xor2_4.sym} 107500 -35780 0 0 {name=X_79463_ }
C {devices/lab_pin.sym} 107420 -35680 0 0 {name=p106414 lab=_55221_/B }
C {devices/lab_pin.sym} 107420 -35640 0 0 {name=p106415 lab=_45394_/X }
C {devices/lab_pin.sym} 107420 -35600 0 0 {name=p106416 lab=_45571_/X }
C {devices/lab_pin.sym} 107420 -35560 0 0 {name=p106417 lab=_45854_/Y }
C {devices/lab_pin.sym} 107580 -35620 0 1 {name=p106418 lab=_45855_/X }
C {sky130_stdcells/a211o_4.sym} 107500 -35620 0 0 {name=X_45855_ }
C {devices/lab_pin.sym} 107440 -35480 0 0 {name=p106419 lab=_76675_/A }
C {devices/lab_pin.sym} 107440 -35440 0 0 {name=p106420 lab=_76674_/X }
C {devices/lab_pin.sym} 107560 -35460 0 1 {name=p106421 lab=_81540_/D }
C {sky130_stdcells/xor2_4.sym} 107500 -35460 0 0 {name=X_76675_ }
C {devices/lab_pin.sym} 107420 -35350 0 0 {name=p106422 lab=_73888_/B }
C {devices/lab_pin.sym} 107420 -35310 0 0 {name=p106423 lab=_73888_/C }
C {devices/lab_pin.sym} 107420 -35270 0 0 {name=p106424 lab=_73886_/X }
C {devices/lab_pin.sym} 107580 -35310 0 1 {name=p106425 lab=_73887_/X }
C {sky130_stdcells/a21o_4.sym} 107500 -35310 0 0 {name=X_73887_ }
C {devices/lab_pin.sym} 107420 -35190 0 0 {name=p106426 lab=_78400_/B }
C {devices/lab_pin.sym} 107420 -35150 0 0 {name=p106427 lab=_78426_/C }
C {devices/lab_pin.sym} 107420 -35110 0 0 {name=p106428 lab=_78426_/B }
C {devices/lab_pin.sym} 107580 -35150 0 1 {name=p106429 lab=_78414_/Y }
C {sky130_stdcells/a21boi_4.sym} 107500 -35150 0 0 {name=X_78414_ }
C {devices/lab_pin.sym} 107460 -35010 0 0 {name=p106430 lab=_40554_/X }
C {devices/lab_pin.sym} 107540 -35010 0 1 {name=p106431 lab=_45980_/A }
C {sky130_stdcells/buf_2.sym} 107500 -35010 0 0 {name=X_44806_ }
C {devices/lab_pin.sym} 107420 -34930 0 0 {name=p106432 lab=_58277_/A }
C {devices/lab_pin.sym} 107420 -34890 0 0 {name=p106433 lab=_60748_/X }
C {devices/lab_pin.sym} 107420 -34850 0 0 {name=p106434 lab=_60724_/A }
C {devices/lab_pin.sym} 107420 -34810 0 0 {name=p106435 lab=_62544_/Y }
C {devices/lab_pin.sym} 107420 -34770 0 0 {name=p106436 lab=_60671_/B }
C {devices/lab_pin.sym} 107580 -34850 0 1 {name=p106437 lab=_63640_/Y }
C {sky130_stdcells/o32ai_4.sym} 107500 -34850 0 0 {name=X_63640_ }
C {devices/lab_pin.sym} 107420 -34710 0 0 {name=p106438 lab=_75620_/Y }
C {devices/lab_pin.sym} 107420 -34670 0 0 {name=p106439 lab=_75621_/X }
C {devices/lab_pin.sym} 107420 -34630 0 0 {name=p106440 lab=_75625_/Y }
C {devices/lab_pin.sym} 107580 -34670 0 1 {name=p106441 lab=_75632_/B }
C {sky130_stdcells/a21oi_4.sym} 107500 -34670 0 0 {name=X_75626_ }
C {devices/lab_pin.sym} 107440 -34550 0 0 {name=p106442 lab=_60406_/B }
C {devices/lab_pin.sym} 107440 -34510 0 0 {name=p106443 lab=_60174_/D }
C {devices/lab_pin.sym} 107440 -34470 0 0 {name=p106444 lab=_61075_/B }
C {devices/lab_pin.sym} 107560 -34510 0 1 {name=p106445 lab=_60852_/X }
C {sky130_stdcells/and3_4.sym} 107500 -34510 0 0 {name=X_60852_ }
C {devices/lab_pin.sym} 107420 -34390 0 0 {name=p106446 lab=_86510_/Q }
C {devices/lab_pin.sym} 107420 -34350 0 0 {name=p106447 lab=_48536_/X }
C {devices/lab_pin.sym} 107420 -34310 0 0 {name=p106448 lab=_48573_/Y }
C {devices/lab_pin.sym} 107580 -34350 0 1 {name=p106449 lab=_48574_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -34350 0 0 {name=X_48574_ }
C {devices/lab_pin.sym} 107460 -34210 0 0 {name=p106450 lab=_72838_/A }
C {devices/lab_pin.sym} 107540 -34210 0 1 {name=p106451 lab=_73092_/A }
C {sky130_stdcells/buf_2.sym} 107500 -34210 0 0 {name=X_72838_ }
C {devices/lab_pin.sym} 107440 -34100 0 0 {name=p106452 lab=_79394_/A }
C {devices/lab_pin.sym} 107440 -34060 0 0 {name=p106453 lab=_79394_/B }
C {devices/lab_pin.sym} 107560 -34080 0 1 {name=p106454 lab=_79395_/B }
C {sky130_stdcells/xor2_4.sym} 107500 -34080 0 0 {name=X_79394_ }
C {devices/lab_pin.sym} 107460 -33950 0 0 {name=p106455 lab=_82984_/Q }
C {devices/lab_pin.sym} 107540 -33950 0 1 {name=p106456 lab=_45787_/A }
C {sky130_stdcells/inv_2.sym} 107500 -33950 0 0 {name=X_45786_ }
C {devices/lab_pin.sym} 107460 -33830 0 0 {name=p106457 lab=_42998_/A }
C {devices/lab_pin.sym} 107540 -33830 0 1 {name=p106458 lab=_87613_/D }
C {sky130_stdcells/inv_2.sym} 107500 -33830 0 0 {name=X_42998_ }
C {devices/lab_pin.sym} 107460 -33710 0 0 {name=p106459 lab=_47525_/A }
C {devices/lab_pin.sym} 107540 -33710 0 1 {name=p106460 lab=_47553_/A }
C {sky130_stdcells/buf_2.sym} 107500 -33710 0 0 {name=X_47525_ }
C {devices/lab_pin.sym} 107420 -33610 0 0 {name=p106461 lab=_78343_/Y }
C {devices/lab_pin.sym} 107420 -33570 0 0 {name=p106462 lab=_78344_/Y }
C {devices/lab_pin.sym} 107420 -33530 0 0 {name=p106463 lab=_82789_/Q }
C {devices/lab_pin.sym} 107580 -33570 0 1 {name=p106464 lab=_78345_/X }
C {sky130_stdcells/a21o_4.sym} 107500 -33570 0 0 {name=X_78345_ }
C {devices/lab_pin.sym} 107420 -33470 0 0 {name=p106465 lab=_49210_/A }
C {devices/lab_pin.sym} 107420 -33430 0 0 {name=p106466 lab=_50731_/B }
C {devices/lab_pin.sym} 107420 -33390 0 0 {name=p106467 lab=_40733_/Y }
C {devices/lab_pin.sym} 107420 -33350 0 0 {name=p106468 lab=_44735_/Y }
C {devices/lab_pin.sym} 107420 -33310 0 0 {name=p106469 lab=_44736_/X }
C {devices/lab_pin.sym} 107580 -33390 0 1 {name=p106470 lab=_44737_/Y }
C {sky130_stdcells/o32ai_4.sym} 107500 -33390 0 0 {name=X_44737_ }
C {devices/lab_pin.sym} 107440 -33240 0 0 {name=p106471 lab=_63523_/A }
C {devices/lab_pin.sym} 107440 -33200 0 0 {name=p106472 lab=_61997_/X }
C {devices/lab_pin.sym} 107560 -33220 0 1 {name=p106473 lab=_63571_/X }
C {sky130_stdcells/and2_4.sym} 107500 -33220 0 0 {name=X_63571_ }
C {devices/lab_pin.sym} 107440 -33100 0 0 {name=p106474 lab=_81089_/Q }
C {devices/lab_pin.sym} 107440 -33060 0 0 {name=p106475 lab=_75557_/B }
C {devices/lab_pin.sym} 107560 -33080 0 1 {name=p106476 lab=_75557_/X }
C {sky130_stdcells/xor2_4.sym} 107500 -33080 0 0 {name=X_75557_ }
C {devices/lab_pin.sym} 107420 -32990 0 0 {name=p106477 lab=_41932_/X }
C {devices/lab_pin.sym} 107420 -32950 0 0 {name=p106478 lab=_41927_/X }
C {devices/lab_pin.sym} 107420 -32910 0 0 {name=p106479 lab=_40702_/X }
C {devices/lab_pin.sym} 107420 -32870 0 0 {name=p106480 lab=_74031_/A }
C {devices/lab_pin.sym} 107420 -32830 0 0 {name=p106481 lab=_41928_/X }
C {devices/lab_pin.sym} 107580 -32910 0 1 {name=p106482 lab=_41950_/A }
C {sky130_stdcells/o32ai_4.sym} 107500 -32910 0 0 {name=X_41949_ }
C {devices/lab_pin.sym} 107460 -32750 0 0 {name=p106483 lab=_63400_/C }
C {devices/lab_pin.sym} 107540 -32750 0 1 {name=p106484 lab=_63384_/C }
C {sky130_stdcells/buf_2.sym} 107500 -32750 0 0 {name=X_60783_ }
C {devices/lab_pin.sym} 107440 -32640 0 0 {name=p106485 lab=_72769_/A }
C {devices/lab_pin.sym} 107440 -32600 0 0 {name=p106486 lab=_72769_/B }
C {devices/lab_pin.sym} 107560 -32620 0 1 {name=p106487 lab=_72769_/Y }
C {sky130_stdcells/nor2_4.sym} 107500 -32620 0 0 {name=X_72769_ }
C {devices/lab_pin.sym} 107460 -32490 0 0 {name=p106488 lab=clkbuf_4_7_0_CLK/X }
C {devices/lab_pin.sym} 107540 -32490 0 1 {name=p106489 lab=clkbuf_4_7_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 107500 -32490 0 0 {name=Xclkbuf_4_7_1_CLK }
C {devices/lab_pin.sym} 107440 -32380 0 0 {name=p106490 lab=_57770_/A }
C {devices/lab_pin.sym} 107440 -32340 0 0 {name=p106491 lab=_65310_/B }
C {devices/lab_pin.sym} 107560 -32360 0 1 {name=p106492 lab=_65310_/X }
C {sky130_stdcells/and2_4.sym} 107500 -32360 0 0 {name=X_65310_ }
C {devices/lab_pin.sym} 107440 -32260 0 0 {name=p106493 lab=_62288_/X }
C {devices/lab_pin.sym} 107440 -32220 0 0 {name=p106494 lab=_62522_/B }
C {devices/lab_pin.sym} 107440 -32180 0 0 {name=p106495 lab=_64458_/B }
C {devices/lab_pin.sym} 107440 -32140 0 0 {name=p106496 lab=_62609_/D }
C {devices/lab_pin.sym} 107560 -32200 0 1 {name=p106497 lab=_62522_/X }
C {sky130_stdcells/and4_4.sym} 107500 -32200 0 0 {name=X_62522_ }
C {devices/lab_pin.sym} 107420 -32070 0 0 {name=p106498 lab=_83051_/Q }
C {devices/lab_pin.sym} 107420 -32030 0 0 {name=p106499 lab=_46250_/X }
C {devices/lab_pin.sym} 107420 -31990 0 0 {name=p106500 lab=_74507_/Y }
C {devices/lab_pin.sym} 107580 -32030 0 1 {name=p106501 lab=_74508_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -32030 0 0 {name=X_74508_ }
C {devices/lab_pin.sym} 107440 -31920 0 0 {name=p106502 lab=_47437_/X }
C {devices/lab_pin.sym} 107440 -31880 0 0 {name=p106503 lab=_47415_/X }
C {devices/lab_pin.sym} 107440 -31840 0 0 {name=p106504 lab=_47466_/C }
C {devices/lab_pin.sym} 107440 -31800 0 0 {name=p106505 lab=_53058_/D }
C {devices/lab_pin.sym} 107560 -31860 0 1 {name=p106506 lab=_47456_/X }
C {sky130_stdcells/and4_4.sym} 107500 -31860 0 0 {name=X_47456_ }
C {devices/lab_pin.sym} 107440 -31730 0 0 {name=p106507 lab=_66287_/X }
C {devices/lab_pin.sym} 107440 -31690 0 0 {name=p106508 lab=_66385_/B }
C {devices/lab_pin.sym} 107440 -31650 0 0 {name=p106509 lab=_66289_/X }
C {devices/lab_pin.sym} 107560 -31690 0 1 {name=p106510 lab=_66290_/Y }
C {sky130_stdcells/nand3_4.sym} 107500 -31690 0 0 {name=X_66290_ }
C {devices/lab_pin.sym} 107420 -31570 0 0 {name=p106511 lab=_78268_/Y }
C {devices/lab_pin.sym} 107420 -31530 0 0 {name=p106512 lab=_78262_/X }
C {devices/lab_pin.sym} 107420 -31490 0 0 {name=p106513 lab=_78275_/Y }
C {devices/lab_pin.sym} 107580 -31530 0 1 {name=p106514 lab=_78276_/Y }
C {sky130_stdcells/a21boi_4.sym} 107500 -31530 0 0 {name=X_78276_ }
C {devices/lab_pin.sym} 107420 -31420 0 0 {name=p106515 lab=_41107_/Y }
C {devices/lab_pin.sym} 107420 -31380 0 0 {name=p106516 lab=_44665_/X }
C {devices/lab_pin.sym} 107420 -31340 0 0 {name=p106517 lab=_87008_/Q }
C {devices/lab_pin.sym} 107420 -31300 0 0 {name=p106518 lab=_44666_/X }
C {devices/lab_pin.sym} 107580 -31360 0 1 {name=p106519 lab=_44668_/X }
C {sky130_stdcells/a2bb2o_4.sym} 107500 -31360 0 0 {name=X_44668_ }
C {devices/lab_pin.sym} 107440 -31220 0 0 {name=p106520 lab=_75487_/Y }
C {devices/lab_pin.sym} 107440 -31180 0 0 {name=p106521 lab=_75506_/D }
C {devices/lab_pin.sym} 107560 -31200 0 1 {name=p106522 lab=_75488_/Y }
C {sky130_stdcells/nand2_4.sym} 107500 -31200 0 0 {name=X_75488_ }
C {devices/lab_pin.sym} 107460 -31070 0 0 {name=p106523 lab=_46407_/A }
C {devices/lab_pin.sym} 107540 -31070 0 1 {name=p106524 lab=_46407_/X }
C {sky130_stdcells/buf_2.sym} 107500 -31070 0 0 {name=X_46407_ }
C {devices/lab_pin.sym} 107420 -30980 0 0 {name=p106525 lab=_65178_/X }
C {devices/lab_pin.sym} 107420 -30940 0 0 {name=p106526 lab=_86729_/Q }
C {devices/lab_pin.sym} 107420 -30900 0 0 {name=p106527 lab=_65239_/X }
C {devices/lab_pin.sym} 107420 -30860 0 0 {name=p106528 lab=_65240_/X }
C {devices/lab_pin.sym} 107580 -30920 0 1 {name=p106529 lab=_65241_/X }
C {sky130_stdcells/a211o_4.sym} 107500 -30920 0 0 {name=X_65241_ }
C {devices/lab_pin.sym} 107440 -30790 0 0 {name=p106530 lab=_77223_/A }
C {devices/lab_pin.sym} 107440 -30750 0 0 {name=p106531 lab=_77222_/Y }
C {devices/lab_pin.sym} 107440 -30710 0 0 {name=p106532 lab=_77227_/C }
C {devices/lab_pin.sym} 107560 -30750 0 1 {name=p106533 lab=_77230_/C }
C {sky130_stdcells/nand3_4.sym} 107500 -30750 0 0 {name=X_77227_ }
C {devices/lab_pin.sym} 107420 -30640 0 0 {name=p106534 lab=_40633_/X }
C {devices/lab_pin.sym} 107420 -30600 0 0 {name=p106535 lab=_43604_/X }
C {devices/lab_pin.sym} 107420 -30560 0 0 {name=p106536 lab=_73752_/A }
C {devices/lab_pin.sym} 107420 -30520 0 0 {name=p106537 lab=_43607_/X }
C {devices/lab_pin.sym} 107580 -30580 0 1 {name=p106538 lab=_43619_/X }
C {sky130_stdcells/a2bb2o_4.sym} 107500 -30580 0 0 {name=X_43619_ }
C {devices/lab_pin.sym} 107440 -30450 0 0 {name=p106539 lab=_48533_/A }
C {devices/lab_pin.sym} 107440 -30410 0 0 {name=p106540 lab=_46620_/A }
C {devices/lab_pin.sym} 107440 -30370 0 0 {name=p106541 lab=_46428_/C }
C {devices/lab_pin.sym} 107560 -30410 0 1 {name=p106542 lab=_74439_/Y }
C {sky130_stdcells/nand3_4.sym} 107500 -30410 0 0 {name=X_74439_ }
C {devices/lab_pin.sym} 107420 -30310 0 0 {name=p106543 lab=_61521_/B }
C {devices/lab_pin.sym} 107420 -30270 0 0 {name=p106544 lab=_62390_/X }
C {devices/lab_pin.sym} 107420 -30230 0 0 {name=p106545 lab=_62436_/X }
C {devices/lab_pin.sym} 107420 -30190 0 0 {name=p106546 lab=_62407_/X }
C {devices/lab_pin.sym} 107420 -30160 0 0 {name=p106547 lab=_62452_/X }
C {devices/lab_pin.sym} 107580 -30230 0 1 {name=p106548 lab=_62453_/X }
C {sky130_stdcells/a41o_4.sym} 107500 -30230 0 0 {name=X_62453_ }
C {devices/lab_pin.sym} 107440 -30080 0 0 {name=p106549 lab=_47404_/A }
C {devices/lab_pin.sym} 107440 -30040 0 0 {name=p106550 lab=_53017_/B }
C {devices/lab_pin.sym} 107560 -30060 0 1 {name=p106551 lab=_47387_/Y }
C {sky130_stdcells/nand2_4.sym} 107500 -30060 0 0 {name=X_47387_ }
C {devices/lab_pin.sym} 107420 -29970 0 0 {name=p106552 lab=_44593_/X }
C {devices/lab_pin.sym} 107420 -29930 0 0 {name=p106553 lab=_44594_/X }
C {devices/lab_pin.sym} 107420 -29890 0 0 {name=p106554 lab=_40924_/Y }
C {devices/lab_pin.sym} 107420 -29850 0 0 {name=p106555 lab=_44598_/Y }
C {devices/lab_pin.sym} 107420 -29810 0 0 {name=p106556 lab=_44596_/X }
C {devices/lab_pin.sym} 107580 -29890 0 1 {name=p106557 lab=_44599_/Y }
C {sky130_stdcells/o32ai_4.sym} 107500 -29890 0 0 {name=X_44599_ }
C {devices/lab_pin.sym} 107440 -29740 0 0 {name=p106558 lab=_49117_/A }
C {devices/lab_pin.sym} 107440 -29700 0 0 {name=p106559 lab=_49125_/X }
C {devices/lab_pin.sym} 107560 -29720 0 1 {name=p106560 lab=_49126_/Y }
C {sky130_stdcells/nand2_4.sym} 107500 -29720 0 0 {name=X_49126_ }
C {devices/lab_pin.sym} 107460 -29590 0 0 {name=p106561 lab=_72550_/A }
C {devices/lab_pin.sym} 107540 -29590 0 1 {name=p106562 lab=_61404_/X }
C {sky130_stdcells/buf_2.sym} 107500 -29590 0 0 {name=X_61404_ }
C {devices/lab_pin.sym} 107420 -29490 0 0 {name=p106563 lab=_46262_/X }
C {devices/lab_pin.sym} 107420 -29450 0 0 {name=p106564 lab=_48959_/A }
C {devices/lab_pin.sym} 107420 -29410 0 0 {name=p106565 lab=_46337_/X }
C {devices/lab_pin.sym} 107580 -29450 0 1 {name=p106566 lab=_46339_/A }
C {sky130_stdcells/o21ai_4.sym} 107500 -29450 0 0 {name=X_46338_ }
C {devices/lab_pin.sym} 107460 -29310 0 0 {name=p106567 lab=_64817_/A }
C {devices/lab_pin.sym} 107540 -29310 0 1 {name=p106568 lab=_65172_/X }
C {sky130_stdcells/buf_2.sym} 107500 -29310 0 0 {name=X_65172_ }
C {devices/lab_pin.sym} 107420 -29210 0 0 {name=p106569 lab=_77149_/Y }
C {devices/lab_pin.sym} 107420 -29170 0 0 {name=p106570 lab=_77156_/Y }
C {devices/lab_pin.sym} 107420 -29130 0 0 {name=p106571 lab=_77157_/Y }
C {devices/lab_pin.sym} 107580 -29170 0 1 {name=p106572 lab=_77159_/B }
C {sky130_stdcells/o21a_4.sym} 107500 -29170 0 0 {name=X_77158_ }
C {devices/lab_pin.sym} 107460 -29030 0 0 {name=p106573 lab=_62218_/A }
C {devices/lab_pin.sym} 107540 -29030 0 1 {name=p106574 lab=_62565_/C }
C {sky130_stdcells/buf_2.sym} 107500 -29030 0 0 {name=X_62384_ }
C {devices/lab_pin.sym} 107440 -28940 0 0 {name=p106575 lab=_58187_/X }
C {devices/lab_pin.sym} 107440 -28900 0 0 {name=p106576 lab=_64158_/B }
C {devices/lab_pin.sym} 107440 -28860 0 0 {name=p106577 lab=_64158_/C }
C {devices/lab_pin.sym} 107440 -28820 0 0 {name=p106578 lab=_64045_/X }
C {devices/lab_pin.sym} 107560 -28880 0 1 {name=p106579 lab=_64123_/Y }
C {sky130_stdcells/nand4_4.sym} 107500 -28880 0 0 {name=X_64123_ }
C {devices/lab_pin.sym} 107440 -28740 0 0 {name=p106580 lab=_81723_/D }
C {devices/lab_pin.sym} 107440 -28700 0 0 {name=p106581 lab=_76109_/B }
C {devices/lab_pin.sym} 107560 -28720 0 1 {name=p106582 lab=_76109_/Y }
C {sky130_stdcells/nor2_4.sym} 107500 -28720 0 0 {name=X_76109_ }
C {devices/lab_pin.sym} 107420 -28610 0 0 {name=p106583 lab=_65066_/B }
C {devices/lab_pin.sym} 107420 -28570 0 0 {name=p106584 lab=_49052_/X }
C {devices/lab_pin.sym} 107420 -28530 0 0 {name=p106585 lab=_49056_/Y }
C {devices/lab_pin.sym} 107580 -28570 0 1 {name=p106586 lab=_49057_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -28570 0 0 {name=X_49057_ }
C {devices/lab_pin.sym} 107460 -28430 0 0 {name=p106587 lab=_72550_/A }
C {devices/lab_pin.sym} 107540 -28430 0 1 {name=p106588 lab=_61367_/B }
C {sky130_stdcells/buf_2.sym} 107500 -28430 0 0 {name=X_61335_ }
C {devices/lab_pin.sym} 107420 -28330 0 0 {name=p106589 lab=_46257_/Y }
C {devices/lab_pin.sym} 107420 -28290 0 0 {name=p106590 lab=_46258_/X }
C {devices/lab_pin.sym} 107420 -28250 0 0 {name=p106591 lab=_46268_/Y }
C {devices/lab_pin.sym} 107580 -28290 0 1 {name=p106592 lab=_86752_/D }
C {sky130_stdcells/a21boi_4.sym} 107500 -28290 0 0 {name=X_46269_ }
C {devices/lab_pin.sym} 107420 -28170 0 0 {name=p106593 lab=_83881_/Q }
C {devices/lab_pin.sym} 107420 -28130 0 0 {name=p106594 lab=_69955_/X }
C {devices/lab_pin.sym} 107420 -28090 0 0 {name=p106595 lab=_69979_/X }
C {devices/lab_pin.sym} 107580 -28130 0 1 {name=p106596 lab=_69980_/X }
C {sky130_stdcells/a21bo_4.sym} 107500 -28130 0 0 {name=X_69980_ }
C {devices/lab_pin.sym} 107440 -28000 0 0 {name=p106597 lab=_82094_/Q }
C {devices/lab_pin.sym} 107440 -27960 0 0 {name=p106598 lab=_77089_/B }
C {devices/lab_pin.sym} 107560 -27980 0 1 {name=p106599 lab=_77089_/X }
C {sky130_stdcells/xor2_4.sym} 107500 -27980 0 0 {name=X_77089_ }
C {devices/lab_pin.sym} 107460 -27850 0 0 {name=p106600 lab=clkbuf_9_225_0_CLK/X }
C {devices/lab_pin.sym} 107540 -27850 0 1 {name=p106601 lab=_83707_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 107500 -27850 0 0 {name=Xclkbuf_10_450_0_CLK }
C {devices/lab_pin.sym} 107460 -27730 0 0 {name=p106602 lab=_82353_/Q }
C {devices/lab_pin.sym} 107540 -27730 0 1 {name=p106603 lab=_48542_/B }
C {sky130_stdcells/inv_2.sym} 107500 -27730 0 0 {name=X_48008_ }
C {devices/lab_pin.sym} 107420 -27650 0 0 {name=p106604 lab=_64047_/X }
C {devices/lab_pin.sym} 107420 -27610 0 0 {name=p106605 lab=_64048_/X }
C {devices/lab_pin.sym} 107420 -27570 0 0 {name=p106606 lab=_64050_/Y }
C {devices/lab_pin.sym} 107420 -27530 0 0 {name=p106607 lab=_64052_/Y }
C {devices/lab_pin.sym} 107420 -27500 0 0 {name=p106608 lab=_64053_/X }
C {devices/lab_pin.sym} 107580 -27570 0 1 {name=p106609 lab=_64054_/X }
C {sky130_stdcells/a41o_4.sym} 107500 -27570 0 0 {name=X_64054_ }
C {devices/lab_pin.sym} 107440 -27420 0 0 {name=p106610 lab=_69021_/A }
C {devices/lab_pin.sym} 107440 -27380 0 0 {name=p106611 lab=_74097_/A }
C {devices/lab_pin.sym} 107560 -27400 0 1 {name=p106612 lab=_68931_/X }
C {sky130_stdcells/and2_4.sym} 107500 -27400 0 0 {name=X_68931_ }
C {devices/lab_pin.sym} 107420 -27310 0 0 {name=p106613 lab=_61194_/X }
C {devices/lab_pin.sym} 107420 -27270 0 0 {name=p106614 lab=_61182_/X }
C {devices/lab_pin.sym} 107420 -27230 0 0 {name=p106615 lab=_61202_/B }
C {devices/lab_pin.sym} 107420 -27190 0 0 {name=p106616 lab=_61264_/Y }
C {devices/lab_pin.sym} 107420 -27150 0 0 {name=p106617 lab=_61265_/X }
C {devices/lab_pin.sym} 107580 -27230 0 1 {name=p106618 lab=_61266_/X }
C {sky130_stdcells/o41a_4.sym} 107500 -27230 0 0 {name=X_61266_ }
C {devices/lab_pin.sym} 107420 -27110 0 0 {name=p106619 lab=_62997_/X }
C {devices/lab_pin.sym} 107420 -27070 0 0 {name=p106620 lab=_62998_/Y }
C {devices/lab_pin.sym} 107420 -27030 0 0 {name=p106621 lab=_63000_/X }
C {devices/lab_pin.sym} 107420 -26990 0 0 {name=p106622 lab=_63003_/Y }
C {devices/lab_pin.sym} 107420 -26950 0 0 {name=p106623 lab=_63004_/X }
C {devices/lab_pin.sym} 107580 -27030 0 1 {name=p106624 lab=_63005_/Y }
C {sky130_stdcells/o41ai_4.sym} 107500 -27030 0 0 {name=X_63005_ }
C {devices/lab_pin.sym} 107460 -26870 0 0 {name=p106625 lab=_60217_/A }
C {devices/lab_pin.sym} 107540 -26870 0 1 {name=p106626 lab=_60221_/A }
C {sky130_stdcells/buf_2.sym} 107500 -26870 0 0 {name=X_60217_ }
C {devices/lab_pin.sym} 107420 -26780 0 0 {name=p106627 lab=_74033_/A }
C {devices/lab_pin.sym} 107420 -26740 0 0 {name=p106628 lab=_68493_/X }
C {devices/lab_pin.sym} 107420 -26700 0 0 {name=p106629 lab=_68494_/X }
C {devices/lab_pin.sym} 107420 -26660 0 0 {name=p106630 lab=_68861_/Y }
C {devices/lab_pin.sym} 107580 -26720 0 1 {name=p106631 lab=_68862_/X }
C {sky130_stdcells/a211o_4.sym} 107500 -26720 0 0 {name=X_68862_ }
C {devices/lab_pin.sym} 107460 -26570 0 0 {name=p106632 lab=_64377_/A }
C {devices/lab_pin.sym} 107540 -26570 0 1 {name=p106633 lab=_64545_/A }
C {sky130_stdcells/buf_2.sym} 107500 -26570 0 0 {name=X_61197_ }
C {devices/lab_pin.sym} 107440 -26460 0 0 {name=p106634 lab=_67790_/A }
C {devices/lab_pin.sym} 107440 -26420 0 0 {name=p106635 lab=_67813_/B }
C {devices/lab_pin.sym} 107560 -26440 0 1 {name=p106636 lab=_67813_/X }
C {sky130_stdcells/and2_4.sym} 107500 -26440 0 0 {name=X_67813_ }
C {devices/lab_pin.sym} 107440 -26330 0 0 {name=p106637 lab=_72527_/A }
C {devices/lab_pin.sym} 107440 -26290 0 0 {name=p106638 lab=_72527_/B }
C {devices/lab_pin.sym} 107440 -26250 0 0 {name=p106639 lab=_60148_/C }
C {devices/lab_pin.sym} 107560 -26290 0 1 {name=p106640 lab=_60148_/Y }
C {sky130_stdcells/nand3_4.sym} 107500 -26290 0 0 {name=X_60148_ }
C {devices/lab_pin.sym} 107420 -26170 0 0 {name=p106641 lab=_49956_/Y }
C {devices/lab_pin.sym} 107420 -26130 0 0 {name=p106642 lab=_49951_/X }
C {devices/lab_pin.sym} 107420 -26090 0 0 {name=p106643 lab=_49958_/X }
C {devices/lab_pin.sym} 107580 -26130 0 1 {name=p106644 lab=_49959_/Y }
C {sky130_stdcells/a21oi_4.sym} 107500 -26130 0 0 {name=X_49959_ }
C {devices/lab_pin.sym} 107440 -26000 0 0 {name=p106645 lab=_68770_/X }
C {devices/lab_pin.sym} 107440 -25960 0 0 {name=p106646 lab=_68793_/B }
C {devices/lab_pin.sym} 107560 -25980 0 1 {name=p106647 lab=_68793_/X }
C {sky130_stdcells/and2_4.sym} 107500 -25980 0 0 {name=X_68793_ }
C {devices/lab_pin.sym} 107460 -25850 0 0 {name=p106648 lab=clkbuf_9_232_0_CLK/X }
C {devices/lab_pin.sym} 107540 -25850 0 1 {name=p106649 lab=_83660_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 107500 -25850 0 0 {name=Xclkbuf_10_465_0_CLK }
C {devices/lab_pin.sym} 107410 -25730 0 0 {name=p106650 lab=_82743_/CLK }
C {devices/lab_pin.sym} 107410 -25710 0 0 {name=p106651 lab=_82842_/Q }
C {devices/lab_pin.sym} 107590 -25730 0 1 {name=p106652 lab=_82810_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -25720 0 0 {name=X_82810_ }
C {devices/lab_pin.sym} 107440 -25600 0 0 {name=p106653 lab=_67790_/A }
C {devices/lab_pin.sym} 107440 -25560 0 0 {name=p106654 lab=_88162_/Q }
C {devices/lab_pin.sym} 107560 -25580 0 1 {name=p106655 lab=_67744_/X }
C {sky130_stdcells/and2_4.sym} 107500 -25580 0 0 {name=X_67744_ }
C {devices/lab_pin.sym} 107420 -25470 0 0 {name=p106656 lab=_85721_/Q }
C {devices/lab_pin.sym} 107420 -25430 0 0 {name=p106657 lab=_52957_/X }
C {devices/lab_pin.sym} 107420 -25390 0 0 {name=p106658 lab=_52969_/Y }
C {devices/lab_pin.sym} 107580 -25430 0 1 {name=p106659 lab=_52970_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -25430 0 0 {name=X_52970_ }
C {devices/lab_pin.sym} 107460 -25290 0 0 {name=p106660 lab=_64803_/A }
C {devices/lab_pin.sym} 107540 -25290 0 1 {name=p106661 lab=_65002_/A }
C {sky130_stdcells/buf_2.sym} 107500 -25290 0 0 {name=X_64956_ }
C {devices/lab_pin.sym} 107440 -25190 0 0 {name=p106662 lab=_59938_/Y }
C {devices/lab_pin.sym} 107440 -25150 0 0 {name=p106663 lab=_60079_/B }
C {devices/lab_pin.sym} 107440 -25110 0 0 {name=p106664 lab=_60027_/X }
C {devices/lab_pin.sym} 107560 -25150 0 1 {name=p106665 lab=_60079_/Y }
C {sky130_stdcells/nand3_4.sym} 107500 -25150 0 0 {name=X_60079_ }
C {devices/lab_pin.sym} 107410 -25010 0 0 {name=p106666 lab=_81259_/CLK }
C {devices/lab_pin.sym} 107410 -24990 0 0 {name=p106667 lab=_83790_/D }
C {devices/lab_pin.sym} 107590 -25010 0 1 {name=p106668 lab=_74780_/A }
C {sky130_stdcells/dfxtp_4.sym} 107500 -25000 0 0 {name=X_83790_ }
C {devices/lab_pin.sym} 107460 -24870 0 0 {name=p106669 lab=_52398_/A }
C {devices/lab_pin.sym} 107540 -24870 0 1 {name=p106670 lab=_52322_/A }
C {sky130_stdcells/buf_2.sym} 107500 -24870 0 0 {name=X_51921_ }
C {devices/lab_pin.sym} 107460 -24750 0 0 {name=p106671 lab=_63761_/A }
C {devices/lab_pin.sym} 107540 -24750 0 1 {name=p106672 lab=_63908_/D }
C {sky130_stdcells/buf_2.sym} 107500 -24750 0 0 {name=X_63907_ }
C {devices/lab_pin.sym} 107410 -24630 0 0 {name=p106673 lab=_82152_/CLK }
C {devices/lab_pin.sym} 107410 -24610 0 0 {name=p106674 lab=_84125_/Q }
C {devices/lab_pin.sym} 107590 -24630 0 1 {name=p106675 lab=_82741_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -24620 0 0 {name=X_82741_ }
C {devices/lab_pin.sym} 107440 -24500 0 0 {name=p106676 lab=_67675_/A }
C {devices/lab_pin.sym} 107440 -24460 0 0 {name=p106677 lab=_67675_/B }
C {devices/lab_pin.sym} 107560 -24480 0 1 {name=p106678 lab=_67675_/X }
C {sky130_stdcells/and2_4.sym} 107500 -24480 0 0 {name=X_67675_ }
C {devices/lab_pin.sym} 107420 -24380 0 0 {name=p106679 lab=_64835_/X }
C {devices/lab_pin.sym} 107420 -24340 0 0 {name=p106680 lab=_83303_/Q }
C {devices/lab_pin.sym} 107420 -24300 0 0 {name=p106681 lab=_44171_/X }
C {devices/lab_pin.sym} 107420 -24260 0 0 {name=p106682 lab=_64886_/X }
C {devices/lab_pin.sym} 107580 -24320 0 1 {name=p106683 lab=_64887_/X }
C {sky130_stdcells/a211o_4.sym} 107500 -24320 0 0 {name=X_64887_ }
C {devices/lab_pin.sym} 107460 -24170 0 0 {name=p106684 lab=_68394_/A }
C {devices/lab_pin.sym} 107540 -24170 0 1 {name=p106685 lab=_69414_/X }
C {sky130_stdcells/buf_2.sym} 107500 -24170 0 0 {name=X_69414_ }
C {devices/lab_pin.sym} 107420 -24070 0 0 {name=p106686 lab=_54637_/Y }
C {devices/lab_pin.sym} 107420 -24030 0 0 {name=p106687 lab=_54638_/X }
C {devices/lab_pin.sym} 107420 -23990 0 0 {name=p106688 lab=_54639_/X }
C {devices/lab_pin.sym} 107580 -24030 0 1 {name=p106689 lab=_85405_/D }
C {sky130_stdcells/a21oi_4.sym} 107500 -24030 0 0 {name=X_54640_ }
C {devices/lab_pin.sym} 107440 -23900 0 0 {name=p106690 lab=_66651_/A }
C {devices/lab_pin.sym} 107440 -23860 0 0 {name=p106691 lab=_66626_/B }
C {devices/lab_pin.sym} 107560 -23880 0 1 {name=p106692 lab=_66626_/X }
C {sky130_stdcells/and2_4.sym} 107500 -23880 0 0 {name=X_66626_ }
C {devices/lab_pin.sym} 107410 -23750 0 0 {name=p106693 lab=_85459_/CLK }
C {devices/lab_pin.sym} 107410 -23730 0 0 {name=p106694 lab=_85460_/D }
C {devices/lab_pin.sym} 107590 -23750 0 1 {name=p106695 lab=_85460_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -23740 0 0 {name=X_85460_ }
C {devices/lab_pin.sym} 107420 -23630 0 0 {name=p106696 lab=_51849_/Y }
C {devices/lab_pin.sym} 107420 -23590 0 0 {name=p106697 lab=_51850_/X }
C {devices/lab_pin.sym} 107420 -23550 0 0 {name=p106698 lab=_51851_/X }
C {devices/lab_pin.sym} 107580 -23590 0 1 {name=p106699 lab=_51852_/Y }
C {sky130_stdcells/a21oi_4.sym} 107500 -23590 0 0 {name=X_51852_ }
C {devices/lab_pin.sym} 107410 -23450 0 0 {name=p106700 lab=_82923_/CLK }
C {devices/lab_pin.sym} 107410 -23430 0 0 {name=p106701 lab=_82672_/D }
C {devices/lab_pin.sym} 107590 -23450 0 1 {name=p106702 lab=_78182_/A }
C {sky130_stdcells/dfxtp_4.sym} 107500 -23440 0 0 {name=X_82672_ }
C {devices/lab_pin.sym} 107440 -23340 0 0 {name=p106703 lab=_59501_/X }
C {devices/lab_pin.sym} 107440 -23300 0 0 {name=p106704 lab=_63820_/B }
C {devices/lab_pin.sym} 107440 -23260 0 0 {name=p106705 lab=_63900_/C }
C {devices/lab_pin.sym} 107440 -23220 0 0 {name=p106706 lab=_63820_/D }
C {devices/lab_pin.sym} 107560 -23280 0 1 {name=p106707 lab=_63838_/Y }
C {sky130_stdcells/nand4_4.sym} 107500 -23280 0 0 {name=X_63838_ }
C {devices/lab_pin.sym} 107410 -23130 0 0 {name=p106708 lab=_84409_/CLK }
C {devices/lab_pin.sym} 107410 -23110 0 0 {name=p106709 lab=_84411_/D }
C {devices/lab_pin.sym} 107590 -23130 0 1 {name=p106710 lab=_62426_/C }
C {sky130_stdcells/dfxtp_4.sym} 107500 -23120 0 0 {name=X_84411_ }
C {devices/lab_pin.sym} 107420 -23010 0 0 {name=p106711 lab=_50800_/Y }
C {devices/lab_pin.sym} 107420 -22970 0 0 {name=p106712 lab=_50801_/X }
C {devices/lab_pin.sym} 107420 -22930 0 0 {name=p106713 lab=_50802_/X }
C {devices/lab_pin.sym} 107580 -22970 0 1 {name=p106714 lab=_50803_/Y }
C {sky130_stdcells/a21oi_4.sym} 107500 -22970 0 0 {name=X_50803_ }
C {devices/lab_pin.sym} 107410 -22830 0 0 {name=p106715 lab=_81304_/CLK }
C {devices/lab_pin.sym} 107410 -22810 0 0 {name=p106716 lab=_76469_/B }
C {devices/lab_pin.sym} 107590 -22830 0 1 {name=p106717 lab=_81815_/D }
C {sky130_stdcells/dfxtp_4.sym} 107500 -22820 0 0 {name=X_81623_ }
C {devices/lab_pin.sym} 107420 -22720 0 0 {name=p106718 lab=_87524_/Q }
C {devices/lab_pin.sym} 107420 -22680 0 0 {name=p106719 lab=_69205_/X }
C {devices/lab_pin.sym} 107420 -22640 0 0 {name=p106720 lab=_69343_/X }
C {devices/lab_pin.sym} 107420 -22600 0 0 {name=p106721 lab=_69344_/X }
C {devices/lab_pin.sym} 107580 -22660 0 1 {name=p106722 lab=_69345_/X }
C {sky130_stdcells/a211o_4.sym} 107500 -22660 0 0 {name=X_69345_ }
C {devices/lab_pin.sym} 107440 -22540 0 0 {name=p106723 lab=_54565_/A }
C {devices/lab_pin.sym} 107440 -22500 0 0 {name=p106724 lab=_54559_/B }
C {devices/lab_pin.sym} 107440 -22460 0 0 {name=p106725 lab=_54565_/C }
C {devices/lab_pin.sym} 107440 -22420 0 0 {name=p106726 lab=_54571_/D }
C {devices/lab_pin.sym} 107560 -22480 0 1 {name=p106727 lab=_54571_/X }
C {sky130_stdcells/and4_4.sym} 107500 -22480 0 0 {name=X_54571_ }
C {devices/lab_pin.sym} 107440 -22340 0 0 {name=p106728 lab=_69853_/A }
C {devices/lab_pin.sym} 107440 -22300 0 0 {name=p106729 lab=_88211_/Q }
C {devices/lab_pin.sym} 107560 -22320 0 1 {name=p106730 lab=_66557_/X }
C {sky130_stdcells/and2_4.sym} 107500 -22320 0 0 {name=X_66557_ }
C {devices/lab_pin.sym} 107410 -22190 0 0 {name=p106731 lab=_85489_/CLK }
C {devices/lab_pin.sym} 107410 -22170 0 0 {name=p106732 lab=_54717_/Y }
C {devices/lab_pin.sym} 107590 -22190 0 1 {name=p106733 lab=_85391_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -22180 0 0 {name=X_85391_ }
C {devices/lab_pin.sym} 107420 -22070 0 0 {name=p106734 lab=_51780_/Y }
C {devices/lab_pin.sym} 107420 -22030 0 0 {name=p106735 lab=_51767_/X }
C {devices/lab_pin.sym} 107420 -21990 0 0 {name=p106736 lab=_51782_/X }
C {devices/lab_pin.sym} 107580 -22030 0 1 {name=p106737 lab=_85947_/D }
C {sky130_stdcells/a21oi_4.sym} 107500 -22030 0 0 {name=X_51783_ }
C {devices/lab_pin.sym} 107440 -21910 0 0 {name=p106738 lab=_63800_/A }
C {devices/lab_pin.sym} 107440 -21870 0 0 {name=p106739 lab=_63800_/B }
C {devices/lab_pin.sym} 107440 -21830 0 0 {name=p106740 lab=_80241_/B }
C {devices/lab_pin.sym} 107560 -21870 0 1 {name=p106741 lab=_63769_/Y }
C {sky130_stdcells/nor3_4.sym} 107500 -21870 0 0 {name=X_63769_ }
C {devices/lab_pin.sym} 107420 -21750 0 0 {name=p106742 lab=_56284_/X }
C {devices/lab_pin.sym} 107420 -21710 0 0 {name=p106743 lab=_56050_/X }
C {devices/lab_pin.sym} 107420 -21670 0 0 {name=p106744 lab=_56309_/Y }
C {devices/lab_pin.sym} 107580 -21710 0 1 {name=p106745 lab=_56310_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -21710 0 0 {name=X_56310_ }
C {devices/lab_pin.sym} 107410 -21570 0 0 {name=p106746 lab=_87950_/CLK }
C {devices/lab_pin.sym} 107410 -21550 0 0 {name=p106747 lab=_87130_/D }
C {devices/lab_pin.sym} 107590 -21570 0 1 {name=p106748 lab=_87130_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -21560 0 0 {name=X_87130_ }
C {devices/lab_pin.sym} 107440 -21440 0 0 {name=p106749 lab=_53509_/A }
C {devices/lab_pin.sym} 107440 -21400 0 0 {name=p106750 lab=_47967_/Y }
C {devices/lab_pin.sym} 107560 -21420 0 1 {name=p106751 lab=_53522_/Y }
C {sky130_stdcells/nand2_4.sym} 107500 -21420 0 0 {name=X_53522_ }
C {devices/lab_pin.sym} 107460 -21290 0 0 {name=p106752 lab=_64834_/A }
C {devices/lab_pin.sym} 107540 -21290 0 1 {name=p106753 lab=_65663_/B }
C {sky130_stdcells/buf_2.sym} 107500 -21290 0 0 {name=X_65508_ }
C {devices/lab_pin.sym} 107410 -21170 0 0 {name=p106754 lab=_84877_/CLK }
C {devices/lab_pin.sym} 107410 -21150 0 0 {name=p106755 lab=_84342_/D }
C {devices/lab_pin.sym} 107590 -21170 0 1 {name=p106756 lab=_79310_/A }
C {sky130_stdcells/dfxtp_4.sym} 107500 -21160 0 0 {name=X_84342_ }
C {devices/lab_pin.sym} 107420 -21050 0 0 {name=p106757 lab=_86144_/Q }
C {devices/lab_pin.sym} 107420 -21010 0 0 {name=p106758 lab=_50706_/X }
C {devices/lab_pin.sym} 107420 -20970 0 0 {name=p106759 lab=_50733_/Y }
C {devices/lab_pin.sym} 107580 -21010 0 1 {name=p106760 lab=_50734_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -21010 0 0 {name=X_50734_ }
C {devices/lab_pin.sym} 107410 -20870 0 0 {name=p106761 lab=_84087_/CLK }
C {devices/lab_pin.sym} 107410 -20850 0 0 {name=p106762 lab=_76802_/X }
C {devices/lab_pin.sym} 107590 -20870 0 1 {name=p106763 lab=_76200_/B }
C {sky130_stdcells/dfxtp_4.sym} 107500 -20860 0 0 {name=X_81554_ }
C {devices/lab_pin.sym} 107440 -20760 0 0 {name=p106764 lab=_57290_/A }
C {devices/lab_pin.sym} 107440 -20720 0 0 {name=p106765 lab=_57023_/X }
C {devices/lab_pin.sym} 107440 -20680 0 0 {name=p106766 lab=_57149_/C }
C {devices/lab_pin.sym} 107440 -20640 0 0 {name=p106767 lab=_57149_/D }
C {devices/lab_pin.sym} 107560 -20700 0 1 {name=p106768 lab=_57290_/X }
C {sky130_stdcells/and4_4.sym} 107500 -20700 0 0 {name=X_57290_ }
C {devices/lab_pin.sym} 107420 -20570 0 0 {name=p106769 lab=_69272_/X }
C {devices/lab_pin.sym} 107420 -20530 0 0 {name=p106770 lab=_69275_/X }
C {devices/lab_pin.sym} 107420 -20490 0 0 {name=p106771 lab=_69251_/X }
C {devices/lab_pin.sym} 107580 -20530 0 1 {name=p106772 lab=_69276_/X }
C {sky130_stdcells/a21o_4.sym} 107500 -20530 0 0 {name=X_69276_ }
C {devices/lab_pin.sym} 107420 -20410 0 0 {name=p106773 lab=_66475_/X }
C {devices/lab_pin.sym} 107420 -20370 0 0 {name=p106774 lab=_66258_/Y }
C {devices/lab_pin.sym} 107420 -20330 0 0 {name=p106775 lab=_66487_/Y }
C {devices/lab_pin.sym} 107580 -20370 0 1 {name=p106776 lab=_66488_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -20370 0 0 {name=X_66488_ }
C {devices/lab_pin.sym} 107460 -20230 0 0 {name=p106777 lab=clkbuf_9_201_0_CLK/X }
C {devices/lab_pin.sym} 107540 -20230 0 1 {name=p106778 lab=_85378_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 107500 -20230 0 0 {name=Xclkbuf_10_403_0_CLK }
C {devices/lab_pin.sym} 107440 -20120 0 0 {name=p106779 lab=_84766_/Q }
C {devices/lab_pin.sym} 107440 -20080 0 0 {name=p106780 lab=_84158_/Q }
C {devices/lab_pin.sym} 107560 -20100 0 1 {name=p106781 lab=_80505_/X }
C {sky130_stdcells/xor2_4.sym} 107500 -20100 0 0 {name=X_80505_ }
C {devices/lab_pin.sym} 107420 -19990 0 0 {name=p106782 lab=_56103_/X }
C {devices/lab_pin.sym} 107420 -19950 0 0 {name=p106783 lab=_56225_/X }
C {devices/lab_pin.sym} 107420 -19910 0 0 {name=p106784 lab=_56240_/Y }
C {devices/lab_pin.sym} 107580 -19950 0 1 {name=p106785 lab=_85263_/D }
C {sky130_stdcells/o21ai_4.sym} 107500 -19950 0 0 {name=X_56241_ }
C {devices/lab_pin.sym} 107420 -19830 0 0 {name=p106786 lab=_84007_/Q }
C {devices/lab_pin.sym} 107420 -19790 0 0 {name=p106787 lab=_68220_/X }
C {devices/lab_pin.sym} 107420 -19750 0 0 {name=p106788 lab=_68226_/X }
C {devices/lab_pin.sym} 107580 -19790 0 1 {name=p106789 lab=_68227_/X }
C {sky130_stdcells/a21bo_4.sym} 107500 -19790 0 0 {name=X_68227_ }
C {devices/lab_pin.sym} 107410 -19650 0 0 {name=p106790 lab=_88108_/CLK }
C {devices/lab_pin.sym} 107410 -19630 0 0 {name=p106791 lab=_44542_/Y }
C {devices/lab_pin.sym} 107590 -19650 0 1 {name=p106792 lab=_73024_/A }
C {sky130_stdcells/dfxtp_4.sym} 107500 -19640 0 0 {name=X_87061_ }
C {devices/lab_pin.sym} 107440 -19520 0 0 {name=p106793 lab=_53460_/A }
C {devices/lab_pin.sym} 107440 -19480 0 0 {name=p106794 lab=_73591_/A }
C {devices/lab_pin.sym} 107560 -19500 0 1 {name=p106795 lab=_53453_/Y }
C {sky130_stdcells/nand2_4.sym} 107500 -19500 0 0 {name=X_53453_ }
C {devices/lab_pin.sym} 107440 -19380 0 0 {name=p106796 lab=_65184_/A }
C {devices/lab_pin.sym} 107440 -19340 0 0 {name=p106797 lab=_65439_/B }
C {devices/lab_pin.sym} 107560 -19360 0 1 {name=p106798 lab=_65439_/X }
C {sky130_stdcells/and2_4.sym} 107500 -19360 0 0 {name=X_65439_ }
C {devices/lab_pin.sym} 107410 -19230 0 0 {name=p106799 lab=_84273_/CLK }
C {devices/lab_pin.sym} 107410 -19210 0 0 {name=p106800 lab=_84273_/D }
C {devices/lab_pin.sym} 107590 -19230 0 1 {name=p106801 lab=_79998_/B }
C {sky130_stdcells/dfxtp_4.sym} 107500 -19220 0 0 {name=X_84273_ }
C {devices/lab_pin.sym} 107420 -19110 0 0 {name=p106802 lab=_50663_/Y }
C {devices/lab_pin.sym} 107420 -19070 0 0 {name=p106803 lab=_50644_/X }
C {devices/lab_pin.sym} 107420 -19030 0 0 {name=p106804 lab=_50664_/Y }
C {devices/lab_pin.sym} 107580 -19070 0 1 {name=p106805 lab=_86158_/D }
C {sky130_stdcells/a21boi_4.sym} 107500 -19070 0 0 {name=X_50665_ }
C {devices/lab_pin.sym} 107410 -18930 0 0 {name=p106806 lab=_81428_/CLK }
C {devices/lab_pin.sym} 107410 -18910 0 0 {name=p106807 lab=_81485_/D }
C {devices/lab_pin.sym} 107590 -18930 0 1 {name=p106808 lab=_76746_/A }
C {sky130_stdcells/dfxtp_4.sym} 107500 -18920 0 0 {name=X_81485_ }
C {devices/lab_pin.sym} 107410 -18790 0 0 {name=p106809 lab=_85725_/CLK }
C {devices/lab_pin.sym} 107410 -18770 0 0 {name=p106810 lab=_86012_/D }
C {devices/lab_pin.sym} 107590 -18790 0 1 {name=p106811 lab=_86012_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -18780 0 0 {name=X_86012_ }
C {devices/lab_pin.sym} 107420 -18670 0 0 {name=p106812 lab=_52402_/Y }
C {devices/lab_pin.sym} 107420 -18630 0 0 {name=p106813 lab=_52390_/X }
C {devices/lab_pin.sym} 107420 -18590 0 0 {name=p106814 lab=_52403_/X }
C {devices/lab_pin.sym} 107580 -18630 0 1 {name=p106815 lab=_52404_/Y }
C {sky130_stdcells/a21oi_4.sym} 107500 -18630 0 0 {name=X_52404_ }
C {devices/lab_pin.sym} 107410 -18490 0 0 {name=p106816 lab=_84487_/CLK }
C {devices/lab_pin.sym} 107410 -18470 0 0 {name=p106817 lab=_72594_/Y }
C {devices/lab_pin.sym} 107590 -18490 0 1 {name=p106818 lab=_79330_/B }
C {sky130_stdcells/dfxtp_4.sym} 107500 -18480 0 0 {name=X_83224_ }
C {devices/lab_pin.sym} 107460 -18350 0 0 {name=p106819 lab=_56172_/A }
C {devices/lab_pin.sym} 107540 -18350 0 1 {name=p106820 lab=_56175_/A }
C {sky130_stdcells/inv_2.sym} 107500 -18350 0 0 {name=X_56172_ }
C {devices/lab_pin.sym} 107440 -18240 0 0 {name=p106821 lab=_80436_/A }
C {devices/lab_pin.sym} 107440 -18200 0 0 {name=p106822 lab=_80436_/B }
C {devices/lab_pin.sym} 107560 -18220 0 1 {name=p106823 lab=_80436_/X }
C {sky130_stdcells/or2_4.sym} 107500 -18220 0 0 {name=X_80436_ }
C {devices/lab_pin.sym} 107420 -18110 0 0 {name=p106824 lab=_84024_/Q }
C {devices/lab_pin.sym} 107420 -18070 0 0 {name=p106825 lab=_68140_/X }
C {devices/lab_pin.sym} 107420 -18030 0 0 {name=p106826 lab=_68157_/X }
C {devices/lab_pin.sym} 107580 -18070 0 1 {name=p106827 lab=_84024_/D }
C {sky130_stdcells/a21bo_4.sym} 107500 -18070 0 0 {name=X_68158_ }
C {devices/lab_pin.sym} 107440 -17960 0 0 {name=p106828 lab=_53371_/A }
C {devices/lab_pin.sym} 107440 -17920 0 0 {name=p106829 lab=_53388_/B }
C {devices/lab_pin.sym} 107440 -17880 0 0 {name=p106830 lab=_53388_/C }
C {devices/lab_pin.sym} 107440 -17840 0 0 {name=p106831 lab=_52867_/D }
C {devices/lab_pin.sym} 107560 -17900 0 1 {name=p106832 lab=_53384_/X }
C {sky130_stdcells/and4_4.sym} 107500 -17900 0 0 {name=X_53384_ }
C {devices/lab_pin.sym} 107460 -17750 0 0 {name=p106833 lab=_50596_/A }
C {devices/lab_pin.sym} 107540 -17750 0 1 {name=p106834 lab=_50597_/A }
C {sky130_stdcells/buf_2.sym} 107500 -17750 0 0 {name=X_50596_ }
C {devices/lab_pin.sym} 107460 -17630 0 0 {name=p106835 lab=_73195_/A }
C {devices/lab_pin.sym} 107540 -17630 0 1 {name=p106836 lab=_73124_/B }
C {sky130_stdcells/buf_2.sym} 107500 -17630 0 0 {name=X_55123_ }
C {devices/lab_pin.sym} 107420 -17530 0 0 {name=p106837 lab=_67105_/X }
C {devices/lab_pin.sym} 107420 -17490 0 0 {name=p106838 lab=_67108_/X }
C {devices/lab_pin.sym} 107420 -17450 0 0 {name=p106839 lab=_67085_/X }
C {devices/lab_pin.sym} 107580 -17490 0 1 {name=p106840 lab=_67109_/X }
C {sky130_stdcells/a21o_4.sym} 107500 -17490 0 0 {name=X_67109_ }
C {devices/lab_pin.sym} 107420 -17370 0 0 {name=p106841 lab=_85843_/Q }
C {devices/lab_pin.sym} 107420 -17330 0 0 {name=p106842 lab=_52324_/X }
C {devices/lab_pin.sym} 107420 -17290 0 0 {name=p106843 lab=_52334_/Y }
C {devices/lab_pin.sym} 107580 -17330 0 1 {name=p106844 lab=_52335_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -17330 0 0 {name=X_52335_ }
C {devices/lab_pin.sym} 107410 -17190 0 0 {name=p106845 lab=_86535_/CLK }
C {devices/lab_pin.sym} 107410 -17170 0 0 {name=p106846 lab=_83155_/D }
C {devices/lab_pin.sym} 107590 -17190 0 1 {name=p106847 lab=_83155_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -17180 0 0 {name=X_83155_ }
C {devices/lab_pin.sym} 107440 -17060 0 0 {name=p106848 lab=_84752_/Q }
C {devices/lab_pin.sym} 107440 -17020 0 0 {name=p106849 lab=_84144_/Q }
C {devices/lab_pin.sym} 107560 -17040 0 1 {name=p106850 lab=_80367_/Y }
C {sky130_stdcells/nand2_4.sym} 107500 -17040 0 0 {name=X_80367_ }
C {devices/lab_pin.sym} 107460 -16910 0 0 {name=p106851 lab=_68089_/A }
C {devices/lab_pin.sym} 107540 -16910 0 1 {name=p106852 lab=_68089_/X }
C {sky130_stdcells/buf_2.sym} 107500 -16910 0 0 {name=X_68089_ }
C {devices/lab_pin.sym} 107460 -16790 0 0 {name=p106853 lab=clkbuf_9_209_0_CLK/X }
C {devices/lab_pin.sym} 107540 -16790 0 1 {name=p106854 lab=_82248_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 107500 -16790 0 0 {name=Xclkbuf_10_418_0_CLK }
C {devices/lab_pin.sym} 107420 -16700 0 0 {name=p106855 lab=_83514_/Q }
C {devices/lab_pin.sym} 107420 -16660 0 0 {name=p106856 lab=_83162_/Q }
C {devices/lab_pin.sym} 107420 -16620 0 0 {name=p106857 lab=_83502_/Q }
C {devices/lab_pin.sym} 107420 -16580 0 0 {name=p106858 lab=_83150_/Q }
C {devices/lab_pin.sym} 107580 -16640 0 1 {name=p106859 lab=_70127_/C }
C {sky130_stdcells/a22oi_4.sym} 107500 -16640 0 0 {name=X_70120_ }
C {devices/lab_pin.sym} 107410 -16490 0 0 {name=p106860 lab=_82343_/CLK }
C {devices/lab_pin.sym} 107410 -16470 0 0 {name=p106861 lab=_82118_/Q }
C {devices/lab_pin.sym} 107590 -16490 0 1 {name=p106862 lab=_82106_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -16480 0 0 {name=X_82106_ }
C {devices/lab_pin.sym} 107440 -16360 0 0 {name=p106863 lab=_55054_/A }
C {devices/lab_pin.sym} 107440 -16320 0 0 {name=p106864 lab=_54885_/B }
C {devices/lab_pin.sym} 107560 -16340 0 1 {name=p106865 lab=_55054_/Y }
C {sky130_stdcells/nand2_4.sym} 107500 -16340 0 0 {name=X_55054_ }
C {devices/lab_pin.sym} 107460 -16210 0 0 {name=p106866 lab=_59931_/A }
C {devices/lab_pin.sym} 107540 -16210 0 1 {name=p106867 lab=_59931_/X }
C {sky130_stdcells/buf_2.sym} 107500 -16210 0 0 {name=X_59931_ }
C {devices/lab_pin.sym} 107420 -16110 0 0 {name=p106868 lab=_85856_/Q }
C {devices/lab_pin.sym} 107420 -16070 0 0 {name=p106869 lab=_52239_/X }
C {devices/lab_pin.sym} 107420 -16030 0 0 {name=p106870 lab=_52265_/Y }
C {devices/lab_pin.sym} 107580 -16070 0 1 {name=p106871 lab=_52266_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -16070 0 0 {name=X_52266_ }
C {devices/lab_pin.sym} 107410 -15930 0 0 {name=p106872 lab=_87195_/CLK }
C {devices/lab_pin.sym} 107410 -15910 0 0 {name=p106873 lab=_87963_/D }
C {devices/lab_pin.sym} 107590 -15930 0 1 {name=p106874 lab=_87963_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -15920 0 0 {name=X_87963_ }
C {devices/lab_pin.sym} 107410 -15790 0 0 {name=p106875 lab=_81603_/CLK }
C {devices/lab_pin.sym} 107410 -15770 0 0 {name=p106876 lab=_83086_/D }
C {devices/lab_pin.sym} 107590 -15790 0 1 {name=p106877 lab=_83086_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -15780 0 0 {name=X_83086_ }
C {devices/lab_pin.sym} 107440 -15670 0 0 {name=p106878 lab=_80298_/A }
C {devices/lab_pin.sym} 107440 -15630 0 0 {name=p106879 lab=_80292_/A }
C {devices/lab_pin.sym} 107440 -15590 0 0 {name=p106880 lab=_80292_/B }
C {devices/lab_pin.sym} 107560 -15630 0 1 {name=p106881 lab=_80299_/B }
C {sky130_stdcells/nand3_4.sym} 107500 -15630 0 0 {name=X_80298_ }
C {devices/lab_pin.sym} 107420 -15510 0 0 {name=p106882 lab=_85524_/Q }
C {devices/lab_pin.sym} 107420 -15470 0 0 {name=p106883 lab=_53989_/X }
C {devices/lab_pin.sym} 107420 -15430 0 0 {name=p106884 lab=_54004_/Y }
C {devices/lab_pin.sym} 107580 -15470 0 1 {name=p106885 lab=_54005_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -15470 0 0 {name=X_54005_ }
C {devices/lab_pin.sym} 107420 -15350 0 0 {name=p106886 lab=_86052_/Q }
C {devices/lab_pin.sym} 107420 -15310 0 0 {name=p106887 lab=_51209_/X }
C {devices/lab_pin.sym} 107420 -15270 0 0 {name=p106888 lab=_51216_/Y }
C {devices/lab_pin.sym} 107580 -15310 0 1 {name=p106889 lab=_51217_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -15310 0 0 {name=X_51217_ }
C {devices/lab_pin.sym} 107420 -15190 0 0 {name=p106890 lab=_82543_/D }
C {devices/lab_pin.sym} 107420 -15150 0 0 {name=p106891 lab=_70048_/X }
C {devices/lab_pin.sym} 107420 -15110 0 0 {name=p106892 lab=_70050_/X }
C {devices/lab_pin.sym} 107580 -15150 0 1 {name=p106893 lab=_70051_/X }
C {sky130_stdcells/a21bo_4.sym} 107500 -15150 0 0 {name=X_70051_ }
C {devices/lab_pin.sym} 107410 -15010 0 0 {name=p106894 lab=_86914_/CLK }
C {devices/lab_pin.sym} 107410 -14990 0 0 {name=p106895 lab=_44862_/X }
C {devices/lab_pin.sym} 107590 -15010 0 1 {name=p106896 lab=_68020_/B }
C {sky130_stdcells/dfxtp_4.sym} 107500 -15000 0 0 {name=X_86914_ }
C {devices/lab_pin.sym} 107410 -14870 0 0 {name=p106897 lab=_82008_/CLK }
C {devices/lab_pin.sym} 107410 -14850 0 0 {name=p106898 lab=_82037_/D }
C {devices/lab_pin.sym} 107590 -14870 0 1 {name=p106899 lab=_82005_/D }
C {sky130_stdcells/dfxtp_4.sym} 107500 -14860 0 0 {name=X_82037_ }
C {devices/lab_pin.sym} 107420 -14750 0 0 {name=p106900 lab=_59836_/D }
C {devices/lab_pin.sym} 107420 -14710 0 0 {name=p106901 lab=_59733_/Y }
C {devices/lab_pin.sym} 107420 -14670 0 0 {name=p106902 lab=_59680_/Y }
C {devices/lab_pin.sym} 107580 -14710 0 1 {name=p106903 lab=_59862_/X }
C {sky130_stdcells/o21a_4.sym} 107500 -14710 0 0 {name=X_59862_ }
C {devices/lab_pin.sym} 107420 -14590 0 0 {name=p106904 lab=_85870_/Q }
C {devices/lab_pin.sym} 107420 -14550 0 0 {name=p106905 lab=_52178_/X }
C {devices/lab_pin.sym} 107420 -14510 0 0 {name=p106906 lab=_52196_/Y }
C {devices/lab_pin.sym} 107580 -14550 0 1 {name=p106907 lab=_52197_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -14550 0 0 {name=X_52197_ }
C {devices/lab_pin.sym} 107410 -14410 0 0 {name=p106908 lab=_87382_/CLK }
C {devices/lab_pin.sym} 107410 -14390 0 0 {name=p106909 lab=_87894_/D }
C {devices/lab_pin.sym} 107590 -14410 0 1 {name=p106910 lab=_87894_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -14400 0 0 {name=X_87894_ }
C {devices/lab_pin.sym} 107460 -14270 0 0 {name=p106911 lab=_58813_/A }
C {devices/lab_pin.sym} 107540 -14270 0 1 {name=p106912 lab=_58813_/X }
C {sky130_stdcells/buf_2.sym} 107500 -14270 0 0 {name=X_58813_ }
C {devices/lab_pin.sym} 107460 -14150 0 0 {name=p106913 lab=_51012_/A }
C {devices/lab_pin.sym} 107540 -14150 0 1 {name=p106914 lab=_51149_/A }
C {sky130_stdcells/buf_2.sym} 107500 -14150 0 0 {name=X_51148_ }
C {devices/lab_pin.sym} 107410 -14030 0 0 {name=p106915 lab=_81117_/CLK }
C {devices/lab_pin.sym} 107410 -14010 0 0 {name=p106916 lab=_45907_/Y }
C {devices/lab_pin.sym} 107590 -14030 0 1 {name=p106917 lab=_40350_/A }
C {sky130_stdcells/dfxtp_4.sym} 107500 -14020 0 0 {name=X_86845_ }
C {devices/lab_pin.sym} 107440 -13910 0 0 {name=p106918 lab=_59680_/A }
C {devices/lab_pin.sym} 107440 -13870 0 0 {name=p106919 lab=_59731_/Y }
C {devices/lab_pin.sym} 107440 -13830 0 0 {name=p106920 lab=_59754_/D }
C {devices/lab_pin.sym} 107560 -13870 0 1 {name=p106921 lab=_59794_/A }
C {sky130_stdcells/nand3_4.sym} 107500 -13870 0 0 {name=X_59793_ }
C {devices/lab_pin.sym} 107460 -13730 0 0 {name=p106922 lab=clkbuf_8_93_0_CLK/A }
C {devices/lab_pin.sym} 107540 -13730 0 1 {name=p106923 lab=clkbuf_8_92_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 107500 -13730 0 0 {name=Xclkbuf_8_92_0_CLK }
C {devices/lab_pin.sym} 107440 -13620 0 0 {name=p106924 lab=_73742_/A }
C {devices/lab_pin.sym} 107440 -13580 0 0 {name=p106925 lab=_86551_/Q }
C {devices/lab_pin.sym} 107560 -13600 0 1 {name=p106926 lab=_73810_/X }
C {sky130_stdcells/and2_4.sym} 107500 -13600 0 0 {name=X_73810_ }
C {devices/lab_pin.sym} 107420 -13490 0 0 {name=p106927 lab=_58667_/X }
C {devices/lab_pin.sym} 107420 -13450 0 0 {name=p106928 lab=_86099_/Q }
C {devices/lab_pin.sym} 107420 -13410 0 0 {name=p106929 lab=_58743_/X }
C {devices/lab_pin.sym} 107580 -13450 0 1 {name=p106930 lab=_58744_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -13450 0 0 {name=X_58744_ }
C {devices/lab_pin.sym} 107460 -13310 0 0 {name=p106931 lab=_43970_/A }
C {devices/lab_pin.sym} 107540 -13310 0 1 {name=p106932 lab=_59571_/C }
C {sky130_stdcells/buf_2.sym} 107500 -13310 0 0 {name=X_43970_ }
C {devices/lab_pin.sym} 107420 -13210 0 0 {name=p106933 lab=_51077_/Y }
C {devices/lab_pin.sym} 107420 -13170 0 0 {name=p106934 lab=_51065_/X }
C {devices/lab_pin.sym} 107420 -13130 0 0 {name=p106935 lab=_51078_/X }
C {devices/lab_pin.sym} 107580 -13170 0 1 {name=p106936 lab=_86078_/D }
C {sky130_stdcells/a21oi_4.sym} 107500 -13170 0 0 {name=X_51079_ }
C {devices/lab_pin.sym} 107440 -13060 0 0 {name=p106937 lab=_55956_/A }
C {devices/lab_pin.sym} 107440 -13020 0 0 {name=p106938 lab=_55956_/B }
C {devices/lab_pin.sym} 107440 -12980 0 0 {name=p106939 lab=_74297_/C }
C {devices/lab_pin.sym} 107440 -12940 0 0 {name=p106940 lab=_56003_/B }
C {devices/lab_pin.sym} 107560 -13000 0 1 {name=p106941 lab=_55957_/A }
C {sky130_stdcells/and4_4.sym} 107500 -13000 0 0 {name=X_55956_ }
C {devices/lab_pin.sym} 107440 -12880 0 0 {name=p106942 lab=_74764_/A }
C {devices/lab_pin.sym} 107440 -12840 0 0 {name=p106943 lab=_74790_/B }
C {devices/lab_pin.sym} 107440 -12800 0 0 {name=p106944 lab=_71010_/X }
C {devices/lab_pin.sym} 107440 -12760 0 0 {name=p106945 lab=_71735_/D }
C {devices/lab_pin.sym} 107560 -12820 0 1 {name=p106946 lab=_74790_/X }
C {sky130_stdcells/and4_4.sym} 107500 -12820 0 0 {name=X_74790_ }
C {devices/lab_pin.sym} 107410 -12670 0 0 {name=p106947 lab=_86784_/CLK }
C {devices/lab_pin.sym} 107410 -12650 0 0 {name=p106948 lab=_46082_/Y }
C {devices/lab_pin.sym} 107590 -12670 0 1 {name=p106949 lab=_67296_/B }
C {sky130_stdcells/dfxtp_4.sym} 107500 -12660 0 0 {name=X_86776_ }
C {devices/lab_pin.sym} 107410 -12530 0 0 {name=p106950 lab=_87671_/CLK }
C {devices/lab_pin.sym} 107410 -12510 0 0 {name=p106951 lab=_83988_/D }
C {devices/lab_pin.sym} 107590 -12530 0 1 {name=p106952 lab=_83988_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -12520 0 0 {name=X_83988_ }
C {devices/lab_pin.sym} 107460 -12390 0 0 {name=p106953 lab=_42680_/A }
C {devices/lab_pin.sym} 107540 -12390 0 1 {name=p106954 lab=_42951_/A }
C {sky130_stdcells/buf_2.sym} 107500 -12390 0 0 {name=X_42921_ }
C {devices/lab_pin.sym} 107440 -12280 0 0 {name=p106955 lab=_54893_/X }
C {devices/lab_pin.sym} 107440 -12240 0 0 {name=p106956 lab=_54907_/B }
C {devices/lab_pin.sym} 107560 -12260 0 1 {name=p106957 lab=_54907_/Y }
C {sky130_stdcells/nand2_4.sym} 107500 -12260 0 0 {name=X_54907_ }
C {devices/lab_pin.sym} 107460 -12130 0 0 {name=p106958 lab=_72874_/A }
C {devices/lab_pin.sym} 107540 -12130 0 1 {name=p106959 lab=_73742_/A }
C {sky130_stdcells/buf_2.sym} 107500 -12130 0 0 {name=X_73741_ }
C {devices/lab_pin.sym} 107410 -12010 0 0 {name=p106960 lab=_85727_/CLK }
C {devices/lab_pin.sym} 107410 -11990 0 0 {name=p106961 lab=_52939_/Y }
C {devices/lab_pin.sym} 107590 -12010 0 1 {name=p106962 lab=_85727_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -12000 0 0 {name=X_85727_ }
C {devices/lab_pin.sym} 107420 -11890 0 0 {name=p106963 lab=_51261_/B }
C {devices/lab_pin.sym} 107420 -11850 0 0 {name=p106964 lab=_70936_/X }
C {devices/lab_pin.sym} 107420 -11810 0 0 {name=p106965 lab=_70952_/Y }
C {devices/lab_pin.sym} 107580 -11850 0 1 {name=p106966 lab=_83652_/D }
C {sky130_stdcells/o21ai_4.sym} 107500 -11850 0 0 {name=X_70953_ }
C {devices/lab_pin.sym} 107440 -11720 0 0 {name=p106967 lab=_58687_/A }
C {devices/lab_pin.sym} 107440 -11680 0 0 {name=p106968 lab=_86392_/Q }
C {devices/lab_pin.sym} 107560 -11700 0 1 {name=p106969 lab=_58675_/Y }
C {sky130_stdcells/nor2_4.sym} 107500 -11700 0 0 {name=X_58675_ }
C {devices/lab_pin.sym} 107410 -11570 0 0 {name=p106970 lab=_84981_/CLK }
C {devices/lab_pin.sym} 107410 -11550 0 0 {name=p106971 lab=_82939_/D }
C {devices/lab_pin.sym} 107590 -11570 0 1 {name=p106972 lab=_82939_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -11560 0 0 {name=X_82939_ }
C {devices/lab_pin.sym} 107420 -11450 0 0 {name=p106973 lab=_55884_/X }
C {devices/lab_pin.sym} 107420 -11410 0 0 {name=p106974 lab=_55886_/X }
C {devices/lab_pin.sym} 107420 -11370 0 0 {name=p106975 lab=_44115_/A }
C {devices/lab_pin.sym} 107580 -11410 0 1 {name=p106976 lab=_55891_/A }
C {sky130_stdcells/a21o_4.sym} 107500 -11410 0 0 {name=X_55887_ }
C {devices/lab_pin.sym} 107460 -11270 0 0 {name=p106977 lab=_63182_/B }
C {devices/lab_pin.sym} 107540 -11270 0 1 {name=p106978 lab=_61513_/A }
C {sky130_stdcells/buf_2.sym} 107500 -11270 0 0 {name=X_45640_ }
C {devices/lab_pin.sym} 107420 -11170 0 0 {name=p106979 lab=_84966_/Q }
C {devices/lab_pin.sym} 107420 -11130 0 0 {name=p106980 lab=_57603_/X }
C {devices/lab_pin.sym} 107420 -11090 0 0 {name=p106981 lab=_57625_/Y }
C {devices/lab_pin.sym} 107580 -11130 0 1 {name=p106982 lab=_57626_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -11130 0 0 {name=X_57626_ }
C {devices/lab_pin.sym} 107440 -11000 0 0 {name=p106983 lab=_76458_/Y }
C {devices/lab_pin.sym} 107440 -10960 0 0 {name=p106984 lab=_76459_/Y }
C {devices/lab_pin.sym} 107560 -10980 0 1 {name=p106985 lab=_76460_/X }
C {sky130_stdcells/and2_4.sym} 107500 -10980 0 0 {name=X_76460_ }
C {devices/lab_pin.sym} 107460 -10850 0 0 {name=p106986 lab=_42820_/X }
C {devices/lab_pin.sym} 107540 -10850 0 1 {name=p106987 lab=_42852_/X }
C {sky130_stdcells/buf_2.sym} 107500 -10850 0 0 {name=X_42852_ }
C {devices/lab_pin.sym} 107420 -10750 0 0 {name=p106988 lab=_54834_/Y }
C {devices/lab_pin.sym} 107420 -10710 0 0 {name=p106989 lab=_54830_/X }
C {devices/lab_pin.sym} 107420 -10670 0 0 {name=p106990 lab=_54837_/X }
C {devices/lab_pin.sym} 107580 -10710 0 1 {name=p106991 lab=_85369_/D }
C {sky130_stdcells/a21oi_4.sym} 107500 -10710 0 0 {name=X_54838_ }
C {devices/lab_pin.sym} 107420 -10590 0 0 {name=p106992 lab=_73670_/X }
C {devices/lab_pin.sym} 107420 -10550 0 0 {name=p106993 lab=_73671_/Y }
C {devices/lab_pin.sym} 107420 -10510 0 0 {name=p106994 lab=_73546_/X }
C {devices/lab_pin.sym} 107580 -10550 0 1 {name=p106995 lab=_73672_/X }
C {sky130_stdcells/a21o_4.sym} 107500 -10550 0 0 {name=X_73672_ }
C {devices/lab_pin.sym} 107410 -10410 0 0 {name=p106996 lab=_85433_/CLK }
C {devices/lab_pin.sym} 107410 -10390 0 0 {name=p106997 lab=_53308_/Y }
C {devices/lab_pin.sym} 107590 -10410 0 1 {name=p106998 lab=_85658_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -10400 0 0 {name=X_85658_ }
C {devices/lab_pin.sym} 107440 -10290 0 0 {name=p106999 lab=_70884_/A }
C {devices/lab_pin.sym} 107440 -10250 0 0 {name=p107000 lab=_70884_/B }
C {devices/lab_pin.sym} 107440 -10210 0 0 {name=p107001 lab=_70695_/A }
C {devices/lab_pin.sym} 107560 -10250 0 1 {name=p107002 lab=_70885_/A }
C {sky130_stdcells/nor3_4.sym} 107500 -10250 0 0 {name=X_70884_ }
C {devices/lab_pin.sym} 107440 -10120 0 0 {name=p107003 lab=_75411_/A }
C {devices/lab_pin.sym} 107440 -10080 0 0 {name=p107004 lab=_80965_/Q }
C {devices/lab_pin.sym} 107560 -10100 0 1 {name=p107005 lab=_75411_/Y }
C {sky130_stdcells/nand2_4.sym} 107500 -10100 0 0 {name=X_75411_ }
C {devices/lab_pin.sym} 107460 -9970 0 0 {name=p107006 lab=_41825_/A }
C {devices/lab_pin.sym} 107540 -9970 0 1 {name=p107007 lab=_41803_/X }
C {sky130_stdcells/buf_2.sym} 107500 -9970 0 0 {name=X_41803_ }
C {devices/lab_pin.sym} 107460 -9850 0 0 {name=p107008 lab=_79184_/B }
C {devices/lab_pin.sym} 107540 -9850 0 1 {name=p107009 lab=_79183_/A }
C {sky130_stdcells/inv_2.sym} 107500 -9850 0 0 {name=X_72623_ }
C {devices/lab_pin.sym} 107410 -9730 0 0 {name=p107010 lab=_84606_/CLK }
C {devices/lab_pin.sym} 107410 -9710 0 0 {name=p107011 lab=_60511_/Y }
C {devices/lab_pin.sym} 107590 -9730 0 1 {name=p107012 lab=_79149_/A }
C {sky130_stdcells/dfxtp_4.sym} 107500 -9720 0 0 {name=X_84609_ }
C {devices/lab_pin.sym} 107460 -9590 0 0 {name=p107013 lab=_45720_/A }
C {devices/lab_pin.sym} 107540 -9590 0 1 {name=p107014 lab=_45571_/X }
C {sky130_stdcells/buf_2.sym} 107500 -9590 0 0 {name=X_45571_ }
C {devices/lab_pin.sym} 107420 -9490 0 0 {name=p107015 lab=_57554_/Y }
C {devices/lab_pin.sym} 107420 -9450 0 0 {name=p107016 lab=_57543_/X }
C {devices/lab_pin.sym} 107420 -9410 0 0 {name=p107017 lab=_57556_/Y }
C {devices/lab_pin.sym} 107580 -9450 0 1 {name=p107018 lab=_84980_/D }
C {sky130_stdcells/a21boi_4.sym} 107500 -9450 0 0 {name=X_57557_ }
C {devices/lab_pin.sym} 107420 -9330 0 0 {name=p107019 lab=_76377_/Y }
C {devices/lab_pin.sym} 107420 -9290 0 0 {name=p107020 lab=_76389_/Y }
C {devices/lab_pin.sym} 107420 -9250 0 0 {name=p107021 lab=_76390_/Y }
C {devices/lab_pin.sym} 107580 -9290 0 1 {name=p107022 lab=_76391_/X }
C {sky130_stdcells/o21a_4.sym} 107500 -9290 0 0 {name=X_76391_ }
C {devices/lab_pin.sym} 107410 -9150 0 0 {name=p107023 lab=_87865_/CLK }
C {devices/lab_pin.sym} 107410 -9130 0 0 {name=p107024 lab=_88377_/D }
C {devices/lab_pin.sym} 107590 -9150 0 1 {name=p107025 lab=_88377_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -9140 0 0 {name=X_88377_ }
C {devices/lab_pin.sym} 107460 -9010 0 0 {name=p107026 lab=_42782_/Y }
C {devices/lab_pin.sym} 107540 -9010 0 1 {name=p107027 lab=_87721_/D }
C {sky130_stdcells/inv_2.sym} 107500 -9010 0 0 {name=X_42783_ }
C {devices/lab_pin.sym} 107420 -8910 0 0 {name=p107028 lab=_85381_/Q }
C {devices/lab_pin.sym} 107420 -8870 0 0 {name=p107029 lab=_54757_/X }
C {devices/lab_pin.sym} 107420 -8830 0 0 {name=p107030 lab=_54768_/Y }
C {devices/lab_pin.sym} 107580 -8870 0 1 {name=p107031 lab=_54769_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -8870 0 0 {name=X_54769_ }
C {devices/lab_pin.sym} 107410 -8730 0 0 {name=p107032 lab=_86193_/CLK }
C {devices/lab_pin.sym} 107410 -8710 0 0 {name=p107033 lab=_85589_/D }
C {devices/lab_pin.sym} 107590 -8730 0 1 {name=p107034 lab=_85589_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -8720 0 0 {name=X_85589_ }
C {devices/lab_pin.sym} 107460 -8590 0 0 {name=p107035 lab=_47310_/A }
C {devices/lab_pin.sym} 107540 -8590 0 1 {name=p107036 lab=_52977_/D }
C {sky130_stdcells/buf_2.sym} 107500 -8590 0 0 {name=X_47310_ }
C {devices/lab_pin.sym} 107440 -8500 0 0 {name=p107037 lab=_78130_/A }
C {devices/lab_pin.sym} 107440 -8460 0 0 {name=p107038 lab=_78130_/B }
C {devices/lab_pin.sym} 107440 -8420 0 0 {name=p107039 lab=_78130_/C }
C {devices/lab_pin.sym} 107440 -8380 0 0 {name=p107040 lab=_78130_/D }
C {devices/lab_pin.sym} 107560 -8440 0 1 {name=p107041 lab=_78131_/B }
C {sky130_stdcells/and4_4.sym} 107500 -8440 0 0 {name=X_78130_ }
C {devices/lab_pin.sym} 107460 -8290 0 0 {name=p107042 lab=_87068_/Q }
C {devices/lab_pin.sym} 107540 -8290 0 1 {name=p107043 lab=_44522_/Y }
C {sky130_stdcells/inv_2.sym} 107500 -8290 0 0 {name=X_44522_ }
C {devices/lab_pin.sym} 107420 -8190 0 0 {name=p107044 lab=_56545_/A }
C {devices/lab_pin.sym} 107420 -8150 0 0 {name=p107045 lab=_56094_/A }
C {devices/lab_pin.sym} 107420 -8110 0 0 {name=p107046 lab=_56507_/Y }
C {devices/lab_pin.sym} 107580 -8150 0 1 {name=p107047 lab=_85169_/D }
C {sky130_stdcells/o21ai_4.sym} 107500 -8150 0 0 {name=X_56508_ }
C {devices/lab_pin.sym} 107440 -8030 0 0 {name=p107048 lab=_75309_/A }
C {devices/lab_pin.sym} 107440 -7990 0 0 {name=p107049 lab=_75324_/Y }
C {devices/lab_pin.sym} 107440 -7950 0 0 {name=p107050 lab=_75322_/X }
C {devices/lab_pin.sym} 107560 -7990 0 1 {name=p107051 lab=_75342_/X }
C {sky130_stdcells/and3_4.sym} 107500 -7990 0 0 {name=X_75342_ }
C {devices/lab_pin.sym} 107410 -7850 0 0 {name=p107052 lab=_87595_/CLK }
C {devices/lab_pin.sym} 107410 -7830 0 0 {name=p107053 lab=_87328_/D }
C {devices/lab_pin.sym} 107590 -7850 0 1 {name=p107054 lab=_87328_/Q }
C {sky130_stdcells/dfxtp_4.sym} 107500 -7840 0 0 {name=X_87328_ }
C {devices/lab_pin.sym} 107420 -7730 0 0 {name=p107055 lab=_40402_/A }
C {devices/lab_pin.sym} 107420 -7690 0 0 {name=p107056 lab=_81741_/Q }
C {devices/lab_pin.sym} 107420 -7650 0 0 {name=p107057 lab=_41733_/X }
C {devices/lab_pin.sym} 107580 -7690 0 1 {name=p107058 lab=_41734_/X }
C {sky130_stdcells/o21a_4.sym} 107500 -7690 0 0 {name=X_41734_ }
C {devices/lab_pin.sym} 107420 -7570 0 0 {name=p107059 lab=_86541_/Q }
C {devices/lab_pin.sym} 107420 -7530 0 0 {name=p107060 lab=_48263_/X }
C {devices/lab_pin.sym} 107420 -7490 0 0 {name=p107061 lab=_48289_/Y }
C {devices/lab_pin.sym} 107580 -7530 0 1 {name=p107062 lab=_48290_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -7530 0 0 {name=X_48290_ }
C {devices/lab_pin.sym} 107460 -7390 0 0 {name=p107063 lab=_72539_/B }
C {devices/lab_pin.sym} 107540 -7390 0 1 {name=p107064 lab=_72579_/A }
C {sky130_stdcells/buf_2.sym} 107500 -7390 0 0 {name=X_72554_ }
C {devices/lab_pin.sym} 107420 -7300 0 0 {name=p107065 lab=_84994_/Q }
C {devices/lab_pin.sym} 107420 -7260 0 0 {name=p107066 lab=_57380_/X }
C {devices/lab_pin.sym} 107420 -7220 0 0 {name=p107067 lab=_57486_/Y }
C {devices/lab_pin.sym} 107420 -7180 0 0 {name=p107068 lab=_57487_/X }
C {devices/lab_pin.sym} 107580 -7240 0 1 {name=p107069 lab=_84994_/D }
C {sky130_stdcells/a211o_4.sym} 107500 -7240 0 0 {name=X_57488_ }
C {devices/lab_pin.sym} 107460 -7090 0 0 {name=p107070 lab=clkbuf_8_31_0_CLK/A }
C {devices/lab_pin.sym} 107540 -7090 0 1 {name=p107071 lab=clkbuf_9_61_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 107500 -7090 0 0 {name=Xclkbuf_8_30_0_CLK }
C {devices/lab_pin.sym} 107460 -6970 0 0 {name=p107072 lab=_47147_/A }
C {devices/lab_pin.sym} 107540 -6970 0 1 {name=p107073 lab=_47241_/X }
C {sky130_stdcells/buf_2.sym} 107500 -6970 0 0 {name=X_47241_ }
C {devices/lab_pin.sym} 107420 -6870 0 0 {name=p107074 lab=_58463_/Y }
C {devices/lab_pin.sym} 107420 -6830 0 0 {name=p107075 lab=_71486_/A }
C {devices/lab_pin.sym} 107420 -6790 0 0 {name=p107076 lab=_71504_/Y }
C {devices/lab_pin.sym} 107580 -6830 0 1 {name=p107077 lab=_71505_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -6830 0 0 {name=X_71505_ }
C {devices/lab_pin.sym} 107420 -6730 0 0 {name=p107078 lab=_59152_/X }
C {devices/lab_pin.sym} 107420 -6690 0 0 {name=p107079 lab=_59224_/Y }
C {devices/lab_pin.sym} 107420 -6650 0 0 {name=p107080 lab=_59226_/Y }
C {devices/lab_pin.sym} 107420 -6610 0 0 {name=p107081 lab=_59169_/X }
C {devices/lab_pin.sym} 107420 -6570 0 0 {name=p107082 lab=_59156_/X }
C {devices/lab_pin.sym} 107580 -6650 0 1 {name=p107083 lab=_59227_/X }
C {sky130_stdcells/o32a_4.sym} 107500 -6650 0 0 {name=X_59227_ }
C {devices/lab_pin.sym} 107440 -6500 0 0 {name=p107084 lab=_84566_/Q }
C {devices/lab_pin.sym} 107440 -6460 0 0 {name=p107085 lab=_78061_/B }
C {devices/lab_pin.sym} 107560 -6480 0 1 {name=p107086 lab=_78061_/X }
C {sky130_stdcells/xor2_4.sym} 107500 -6480 0 0 {name=X_78061_ }
C {devices/lab_pin.sym} 107460 -6350 0 0 {name=p107087 lab=_44602_/A }
C {devices/lab_pin.sym} 107540 -6350 0 1 {name=p107088 lab=_44453_/X }
C {sky130_stdcells/buf_2.sym} 107500 -6350 0 0 {name=X_44453_ }
C {devices/lab_pin.sym} 107460 -6230 0 0 {name=p107089 lab=_56439_/A }
C {devices/lab_pin.sym} 107540 -6230 0 1 {name=p107090 lab=_56439_/X }
C {sky130_stdcells/buf_2.sym} 107500 -6230 0 0 {name=X_56439_ }
C {devices/lab_pin.sym} 107420 -6130 0 0 {name=p107091 lab=_75254_/Y }
C {devices/lab_pin.sym} 107420 -6090 0 0 {name=p107092 lab=_75258_/B }
C {devices/lab_pin.sym} 107420 -6050 0 0 {name=p107093 lab=_75256_/Y }
C {devices/lab_pin.sym} 107580 -6090 0 1 {name=p107094 lab=_75274_/A }
C {sky130_stdcells/o21a_4.sym} 107500 -6090 0 0 {name=X_75273_ }
C {devices/lab_pin.sym} 107440 -5960 0 0 {name=p107095 lab=_41319_/B }
C {devices/lab_pin.sym} 107440 -5920 0 0 {name=p107096 lab=_41653_/X }
C {devices/lab_pin.sym} 107560 -5940 0 1 {name=p107097 lab=_41665_/X }
C {sky130_stdcells/or2_4.sym} 107500 -5940 0 0 {name=X_41665_ }
C {devices/lab_pin.sym} 107410 -5810 0 0 {name=p107098 lab=_87273_/CLK }
C {devices/lab_pin.sym} 107410 -5790 0 0 {name=p107099 lab=_87259_/D }
C {devices/lab_pin.sym} 107590 -5810 0 1 {name=p107100 lab=_69469_/B }
C {sky130_stdcells/dfxtp_4.sym} 107500 -5800 0 0 {name=X_87259_ }
C {devices/lab_pin.sym} 107460 -5670 0 0 {name=p107101 lab=_59398_/A }
C {devices/lab_pin.sym} 107540 -5670 0 1 {name=p107102 lab=_72488_/B }
C {sky130_stdcells/buf_2.sym} 107500 -5670 0 0 {name=X_72485_ }
C {devices/lab_pin.sym} 107440 -5560 0 0 {name=p107103 lab=_77013_/A }
C {devices/lab_pin.sym} 107440 -5520 0 0 {name=p107104 lab=_77013_/B }
C {devices/lab_pin.sym} 107560 -5540 0 1 {name=p107105 lab=_77012_/Y }
C {sky130_stdcells/nor2_4.sym} 107500 -5540 0 0 {name=X_77012_ }
C {devices/lab_pin.sym} 107460 -5410 0 0 {name=p107106 lab=_43305_/A }
C {devices/lab_pin.sym} 107540 -5410 0 1 {name=p107107 lab=_43404_/X }
C {sky130_stdcells/buf_2.sym} 107500 -5410 0 0 {name=X_43404_ }
C {devices/lab_pin.sym} 107440 -5300 0 0 {name=p107108 lab=_74224_/A }
C {devices/lab_pin.sym} 107440 -5260 0 0 {name=p107109 lab=_73152_/X }
C {devices/lab_pin.sym} 107560 -5280 0 1 {name=p107110 lab=_74224_/Y }
C {sky130_stdcells/nor2_4.sym} 107500 -5280 0 0 {name=X_74224_ }
C {devices/lab_pin.sym} 107420 -5170 0 0 {name=p107111 lab=_40585_/X }
C {devices/lab_pin.sym} 107420 -5130 0 0 {name=p107112 lab=_82875_/Q }
C {devices/lab_pin.sym} 107420 -5090 0 0 {name=p107113 lab=_40615_/X }
C {devices/lab_pin.sym} 107580 -5130 0 1 {name=p107114 lab=_40616_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -5130 0 0 {name=X_40616_ }
C {devices/lab_pin.sym} 107420 -5010 0 0 {name=p107115 lab=_47168_/Y }
C {devices/lab_pin.sym} 107420 -4970 0 0 {name=p107116 lab=_47128_/X }
C {devices/lab_pin.sym} 107420 -4930 0 0 {name=p107117 lab=_47171_/X }
C {devices/lab_pin.sym} 107580 -4970 0 1 {name=p107118 lab=_47172_/Y }
C {sky130_stdcells/a21oi_4.sym} 107500 -4970 0 0 {name=X_47172_ }
C {devices/lab_pin.sym} 107420 -4860 0 0 {name=p107119 lab=_59143_/Y }
C {devices/lab_pin.sym} 107420 -4820 0 0 {name=p107120 lab=_59145_/X }
C {devices/lab_pin.sym} 107420 -4780 0 0 {name=p107121 lab=_59151_/X }
C {devices/lab_pin.sym} 107420 -4740 0 0 {name=p107122 lab=_59157_/X }
C {devices/lab_pin.sym} 107580 -4800 0 1 {name=p107123 lab=_84765_/D }
C {sky130_stdcells/a22oi_4.sym} 107500 -4800 0 0 {name=X_59158_ }
C {devices/lab_pin.sym} 107420 -4670 0 0 {name=p107124 lab=_71419_/Y }
C {devices/lab_pin.sym} 107420 -4630 0 0 {name=p107125 lab=_83500_/Q }
C {devices/lab_pin.sym} 107420 -4590 0 0 {name=p107126 lab=_71435_/X }
C {devices/lab_pin.sym} 107580 -4630 0 1 {name=p107127 lab=_83500_/D }
C {sky130_stdcells/a21o_4.sym} 107500 -4630 0 0 {name=X_71436_ }
C {devices/lab_pin.sym} 107420 -4530 0 0 {name=p107128 lab=_44381_/X }
C {devices/lab_pin.sym} 107420 -4490 0 0 {name=p107129 lab=_44382_/X }
C {devices/lab_pin.sym} 107420 -4450 0 0 {name=p107130 lab=_41786_/X }
C {devices/lab_pin.sym} 107420 -4410 0 0 {name=p107131 lab=_87137_/Q }
C {devices/lab_pin.sym} 107420 -4370 0 0 {name=p107132 lab=_44383_/X }
C {devices/lab_pin.sym} 107580 -4450 0 1 {name=p107133 lab=_44385_/A }
C {sky130_stdcells/o32ai_4.sym} 107500 -4450 0 0 {name=X_44384_ }
C {devices/lab_pin.sym} 107460 -4290 0 0 {name=p107134 lab=_41595_/X }
C {devices/lab_pin.sym} 107540 -4290 0 1 {name=p107135 lab=_41596_/X }
C {sky130_stdcells/buf_2.sym} 107500 -4290 0 0 {name=X_41596_ }
C {devices/lab_pin.sym} 107460 -4170 0 0 {name=p107136 lab=_58793_/A }
C {devices/lab_pin.sym} 107540 -4170 0 1 {name=p107137 lab=_58109_/X }
C {sky130_stdcells/buf_2.sym} 107500 -4170 0 0 {name=X_58109_ }
C {devices/lab_pin.sym} 107440 -4060 0 0 {name=p107138 lab=_46138_/A }
C {devices/lab_pin.sym} 107440 -4020 0 0 {name=p107139 lab=_46119_/A }
C {devices/lab_pin.sym} 107560 -4040 0 1 {name=p107140 lab=_46124_/A }
C {sky130_stdcells/and2_4.sym} 107500 -4040 0 0 {name=X_46123_ }
C {devices/lab_pin.sym} 107420 -3940 0 0 {name=p107141 lab=_41294_/X }
C {devices/lab_pin.sym} 107420 -3900 0 0 {name=p107142 lab=_43325_/X }
C {devices/lab_pin.sym} 107420 -3860 0 0 {name=p107143 lab=_87474_/Q }
C {devices/lab_pin.sym} 107420 -3820 0 0 {name=p107144 lab=_43326_/X }
C {devices/lab_pin.sym} 107580 -3880 0 1 {name=p107145 lab=_87474_/D }
C {sky130_stdcells/a2bb2o_4.sym} 107500 -3880 0 0 {name=X_43335_ }
C {devices/lab_pin.sym} 107460 -3730 0 0 {name=p107146 lab=_73163_/A }
C {devices/lab_pin.sym} 107540 -3730 0 1 {name=p107147 lab=_74155_/X }
C {sky130_stdcells/buf_2.sym} 107500 -3730 0 0 {name=X_74155_ }
C {devices/lab_pin.sym} 107420 -3630 0 0 {name=p107148 lab=_40463_/X }
C {devices/lab_pin.sym} 107420 -3590 0 0 {name=p107149 lab=_41624_/A }
C {devices/lab_pin.sym} 107420 -3550 0 0 {name=p107150 lab=_40546_/X }
C {devices/lab_pin.sym} 107580 -3590 0 1 {name=p107151 lab=_40547_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -3590 0 0 {name=X_40547_ }
C {devices/lab_pin.sym} 107440 -3460 0 0 {name=p107152 lab=_58941_/A }
C {devices/lab_pin.sym} 107440 -3420 0 0 {name=p107153 lab=_86362_/Q }
C {devices/lab_pin.sym} 107560 -3440 0 1 {name=p107154 lab=_59089_/Y }
C {sky130_stdcells/nor2_4.sym} 107500 -3440 0 0 {name=X_59089_ }
C {devices/lab_pin.sym} 107420 -3330 0 0 {name=p107155 lab=_71344_/A }
C {devices/lab_pin.sym} 107420 -3290 0 0 {name=p107156 lab=_83523_/Q }
C {devices/lab_pin.sym} 107420 -3250 0 0 {name=p107157 lab=_71366_/X }
C {devices/lab_pin.sym} 107580 -3290 0 1 {name=p107158 lab=_71367_/X }
C {sky130_stdcells/a21o_4.sym} 107500 -3290 0 0 {name=X_71367_ }
C {devices/lab_pin.sym} 107460 -3150 0 0 {name=p107159 lab=clkbuf_8_45_0_CLK/A }
C {devices/lab_pin.sym} 107540 -3150 0 1 {name=p107160 lab=clkbuf_8_45_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 107500 -3150 0 0 {name=Xclkbuf_8_45_0_CLK }
C {devices/lab_pin.sym} 107440 -3050 0 0 {name=p107161 lab=_61083_/C }
C {devices/lab_pin.sym} 107440 -3010 0 0 {name=p107162 lab=_61112_/X }
C {devices/lab_pin.sym} 107440 -2970 0 0 {name=p107163 lab=_61205_/A }
C {devices/lab_pin.sym} 107560 -3010 0 1 {name=p107164 lab=_61120_/Y }
C {sky130_stdcells/nand3_4.sym} 107500 -3010 0 0 {name=X_61120_ }
C {devices/lab_pin.sym} 107440 -2880 0 0 {name=p107165 lab=_73106_/A }
C {devices/lab_pin.sym} 107440 -2840 0 0 {name=p107166 lab=_44127_/X }
C {devices/lab_pin.sym} 107560 -2860 0 1 {name=p107167 lab=_73106_/Y }
C {sky130_stdcells/nor2_4.sym} 107500 -2860 0 0 {name=X_73106_ }
C {devices/lab_pin.sym} 107460 -2730 0 0 {name=p107168 lab=_43030_/A }
C {devices/lab_pin.sym} 107540 -2730 0 1 {name=p107169 lab=_46054_/X }
C {sky130_stdcells/buf_2.sym} 107500 -2730 0 0 {name=X_46054_ }
C {devices/lab_pin.sym} 107440 -2640 0 0 {name=p107170 lab=_70318_/A }
C {devices/lab_pin.sym} 107440 -2600 0 0 {name=p107171 lab=_70183_/A }
C {devices/lab_pin.sym} 107440 -2560 0 0 {name=p107172 lab=_70183_/B }
C {devices/lab_pin.sym} 107440 -2520 0 0 {name=p107173 lab=_70183_/D }
C {devices/lab_pin.sym} 107560 -2580 0 1 {name=p107174 lab=_70318_/Y }
C {sky130_stdcells/nand4_4.sym} 107500 -2580 0 0 {name=X_70318_ }
C {devices/lab_pin.sym} 107420 -2460 0 0 {name=p107175 lab=_41098_/X }
C {devices/lab_pin.sym} 107420 -2420 0 0 {name=p107176 lab=_43264_/X }
C {devices/lab_pin.sym} 107420 -2380 0 0 {name=p107177 lab=_87510_/Q }
C {devices/lab_pin.sym} 107420 -2340 0 0 {name=p107178 lab=_43265_/X }
C {devices/lab_pin.sym} 107580 -2400 0 1 {name=p107179 lab=_87510_/D }
C {sky130_stdcells/a2bb2o_4.sym} 107500 -2400 0 0 {name=X_43266_ }
C {devices/lab_pin.sym} 107420 -2270 0 0 {name=p107180 lab=_74082_/X }
C {devices/lab_pin.sym} 107420 -2230 0 0 {name=p107181 lab=_74084_/X }
C {devices/lab_pin.sym} 107420 -2190 0 0 {name=p107182 lab=_74085_/X }
C {devices/lab_pin.sym} 107580 -2230 0 1 {name=p107183 lab=_74090_/A }
C {sky130_stdcells/a21o_4.sym} 107500 -2230 0 0 {name=X_74086_ }
C {devices/lab_pin.sym} 107420 -2110 0 0 {name=p107184 lab=_78957_/B }
C {devices/lab_pin.sym} 107420 -2070 0 0 {name=p107185 lab=_78957_/A }
C {devices/lab_pin.sym} 107420 -2030 0 0 {name=p107186 lab=_78962_/Y }
C {devices/lab_pin.sym} 107580 -2070 0 1 {name=p107187 lab=_78964_/B }
C {sky130_stdcells/a21oi_4.sym} 107500 -2070 0 0 {name=X_78963_ }
C {devices/lab_pin.sym} 107440 -1940 0 0 {name=p107188 lab=_82319_/Q }
C {devices/lab_pin.sym} 107440 -1900 0 0 {name=p107189 lab=_40471_/X }
C {devices/lab_pin.sym} 107560 -1920 0 1 {name=p107190 lab=_40478_/X }
C {sky130_stdcells/or2_4.sym} 107500 -1920 0 0 {name=X_40478_ }
C {devices/lab_pin.sym} 107440 -1810 0 0 {name=p107191 lab=_71303_/A }
C {devices/lab_pin.sym} 107440 -1770 0 0 {name=p107192 lab=_71303_/B }
C {devices/lab_pin.sym} 107440 -1730 0 0 {name=p107193 lab=_71297_/X }
C {devices/lab_pin.sym} 107560 -1770 0 1 {name=p107194 lab=_71298_/Y }
C {sky130_stdcells/nand3_4.sym} 107500 -1770 0 0 {name=X_71298_ }
C {devices/lab_pin.sym} 107420 -1650 0 0 {name=p107195 lab=_55934_/B }
C {devices/lab_pin.sym} 107420 -1610 0 0 {name=p107196 lab=_44963_/X }
C {devices/lab_pin.sym} 107420 -1570 0 0 {name=p107197 lab=_45004_/X }
C {devices/lab_pin.sym} 107580 -1610 0 1 {name=p107198 lab=_45005_/X }
C {sky130_stdcells/o21a_4.sym} 107500 -1610 0 0 {name=X_45005_ }
C {devices/lab_pin.sym} 107460 -1470 0 0 {name=p107199 lab=_42217_/A }
C {devices/lab_pin.sym} 107540 -1470 0 1 {name=p107200 lab=_42217_/Y }
C {sky130_stdcells/inv_2.sym} 107500 -1470 0 0 {name=X_42217_ }
C {devices/lab_pin.sym} 107420 -1370 0 0 {name=p107201 lab=_60918_/X }
C {devices/lab_pin.sym} 107420 -1330 0 0 {name=p107202 lab=_60921_/X }
C {devices/lab_pin.sym} 107420 -1290 0 0 {name=p107203 lab=_60911_/X }
C {devices/lab_pin.sym} 107580 -1330 0 1 {name=p107204 lab=_61051_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -1330 0 0 {name=X_61051_ }
C {devices/lab_pin.sym} 107420 -1210 0 0 {name=p107205 lab=_82069_/Q }
C {devices/lab_pin.sym} 107420 -1170 0 0 {name=p107206 lab=_81941_/D }
C {devices/lab_pin.sym} 107420 -1130 0 0 {name=p107207 lab=_77913_/X }
C {devices/lab_pin.sym} 107580 -1170 0 1 {name=p107208 lab=_77914_/Y }
C {sky130_stdcells/o21ai_4.sym} 107500 -1170 0 0 {name=X_77914_ }
C {devices/lab_pin.sym} 107420 -1060 0 0 {name=p107209 lab=_69700_/B }
C {devices/lab_pin.sym} 107420 -1020 0 0 {name=p107210 lab=_44235_/X }
C {devices/lab_pin.sym} 107420 -980 0 0 {name=p107211 lab=_73035_/X }
C {devices/lab_pin.sym} 107420 -940 0 0 {name=p107212 lab=_73036_/Y }
C {devices/lab_pin.sym} 107580 -1000 0 1 {name=p107213 lab=_73037_/X }
C {sky130_stdcells/a211o_4.sym} 107500 -1000 0 0 {name=X_73037_ }
C {devices/lab_pin.sym} 107460 -850 0 0 {name=p107214 lab=_70134_/X }
C {devices/lab_pin.sym} 107540 -850 0 1 {name=p107215 lab=_70249_/X }
C {sky130_stdcells/buf_2.sym} 107500 -850 0 0 {name=X_70249_ }
C {devices/lab_pin.sym} 107420 -770 0 0 {name=p107216 lab=_43196_/X }
C {devices/lab_pin.sym} 107420 -730 0 0 {name=p107217 lab=_43167_/X }
C {devices/lab_pin.sym} 107420 -690 0 0 {name=p107218 lab=_40914_/X }
C {devices/lab_pin.sym} 107420 -650 0 0 {name=p107219 lab=_73465_/A }
C {devices/lab_pin.sym} 107420 -610 0 0 {name=p107220 lab=_43172_/X }
C {devices/lab_pin.sym} 107580 -690 0 1 {name=p107221 lab=_43197_/Y }
C {sky130_stdcells/o32ai_4.sym} 107500 -690 0 0 {name=X_43197_ }
C {devices/lab_pin.sym} 108360 -42160 0 0 {name=p107222 lab=_78880_/Y }
C {devices/lab_pin.sym} 108360 -42120 0 0 {name=p107223 lab=_78893_/X }
C {devices/lab_pin.sym} 108480 -42140 0 1 {name=p107224 lab=_78894_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -42140 0 0 {name=X_78894_ }
C {devices/lab_pin.sym} 108380 -42010 0 0 {name=p107225 lab=_59977_/B }
C {devices/lab_pin.sym} 108460 -42010 0 1 {name=p107226 lab=_60091_/C }
C {sky130_stdcells/buf_2.sym} 108420 -42010 0 0 {name=X_60002_ }
C {devices/lab_pin.sym} 108360 -41900 0 0 {name=p107227 lab=_49809_/A }
C {devices/lab_pin.sym} 108360 -41860 0 0 {name=p107228 lab=_53025_/B }
C {devices/lab_pin.sym} 108480 -41880 0 1 {name=p107229 lab=_49813_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -41880 0 0 {name=X_49813_ }
C {devices/lab_pin.sym} 108380 -41750 0 0 {name=p107230 lab=_42137_/A }
C {devices/lab_pin.sym} 108460 -41750 0 1 {name=p107231 lab=_42148_/X }
C {sky130_stdcells/buf_2.sym} 108420 -41750 0 0 {name=X_42148_ }
C {devices/lab_pin.sym} 108360 -41640 0 0 {name=p107232 lab=_82271_/Q }
C {devices/lab_pin.sym} 108360 -41600 0 0 {name=p107233 lab=_81983_/Q }
C {devices/lab_pin.sym} 108480 -41620 0 1 {name=p107234 lab=_77845_/Y }
C {sky130_stdcells/xnor2_4.sym} 108420 -41620 0 0 {name=X_77845_ }
C {devices/lab_pin.sym} 108360 -41500 0 0 {name=p107235 lab=_64810_/A }
C {devices/lab_pin.sym} 108360 -41460 0 0 {name=p107236 lab=_86458_/Q }
C {devices/lab_pin.sym} 108480 -41480 0 1 {name=p107237 lab=_64810_/X }
C {sky130_stdcells/and2_4.sym} 108420 -41480 0 0 {name=X_64810_ }
C {devices/lab_pin.sym} 108360 -41360 0 0 {name=p107238 lab=_49757_/A }
C {devices/lab_pin.sym} 108360 -41320 0 0 {name=p107239 lab=_52959_/B }
C {devices/lab_pin.sym} 108480 -41340 0 1 {name=p107240 lab=_49744_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -41340 0 0 {name=X_49744_ }
C {devices/lab_pin.sym} 108380 -41210 0 0 {name=p107241 lab=_46909_/X }
C {devices/lab_pin.sym} 108460 -41210 0 1 {name=p107242 lab=_46959_/A }
C {sky130_stdcells/buf_2.sym} 108420 -41210 0 0 {name=X_46956_ }
C {devices/lab_pin.sym} 108340 -41130 0 0 {name=p107243 lab=_42052_/X }
C {devices/lab_pin.sym} 108340 -41090 0 0 {name=p107244 lab=_42077_/X }
C {devices/lab_pin.sym} 108340 -41050 0 0 {name=p107245 lab=_40972_/X }
C {devices/lab_pin.sym} 108340 -41010 0 0 {name=p107246 lab=_88044_/Q }
C {devices/lab_pin.sym} 108340 -40970 0 0 {name=p107247 lab=_42078_/X }
C {devices/lab_pin.sym} 108500 -41050 0 1 {name=p107248 lab=_42080_/A }
C {sky130_stdcells/o32ai_4.sym} 108420 -41050 0 0 {name=X_42079_ }
C {devices/lab_pin.sym} 108380 -40890 0 0 {name=p107249 lab=_65790_/A }
C {devices/lab_pin.sym} 108460 -40890 0 1 {name=p107250 lab=_65790_/X }
C {sky130_stdcells/buf_2.sym} 108420 -40890 0 0 {name=X_65790_ }
C {devices/lab_pin.sym} 108360 -40780 0 0 {name=p107251 lab=_77776_/A }
C {devices/lab_pin.sym} 108360 -40740 0 0 {name=p107252 lab=_81928_/D }
C {devices/lab_pin.sym} 108480 -40760 0 1 {name=p107253 lab=_77796_/A }
C {sky130_stdcells/xnor2_4.sym} 108420 -40760 0 0 {name=X_77776_ }
C {devices/lab_pin.sym} 108360 -40640 0 0 {name=p107254 lab=_74988_/A }
C {devices/lab_pin.sym} 108360 -40600 0 0 {name=p107255 lab=_74988_/B }
C {devices/lab_pin.sym} 108480 -40620 0 1 {name=p107256 lab=_74988_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -40620 0 0 {name=X_74988_ }
C {devices/lab_pin.sym} 108360 -40500 0 0 {name=p107257 lab=_84816_/Q }
C {devices/lab_pin.sym} 108360 -40460 0 0 {name=p107258 lab=_84136_/Q }
C {devices/lab_pin.sym} 108480 -40480 0 1 {name=p107259 lab=_79515_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -40480 0 0 {name=X_79515_ }
C {devices/lab_pin.sym} 108380 -40350 0 0 {name=p107260 lab=_45907_/A }
C {devices/lab_pin.sym} 108460 -40350 0 1 {name=p107261 lab=_45907_/Y }
C {sky130_stdcells/inv_2.sym} 108420 -40350 0 0 {name=X_45907_ }
C {devices/lab_pin.sym} 108360 -40250 0 0 {name=p107262 lab=_64870_/A }
C {devices/lab_pin.sym} 108360 -40210 0 0 {name=p107263 lab=_64741_/B }
C {devices/lab_pin.sym} 108360 -40170 0 0 {name=p107264 lab=_64741_/C }
C {devices/lab_pin.sym} 108480 -40210 0 1 {name=p107265 lab=_64741_/Y }
C {sky130_stdcells/nor3_4.sym} 108420 -40210 0 0 {name=X_64741_ }
C {devices/lab_pin.sym} 108380 -40070 0 0 {name=p107266 lab=_81483_/Q }
C {devices/lab_pin.sym} 108460 -40070 0 1 {name=p107267 lab=_76727_/Y }
C {sky130_stdcells/inv_2.sym} 108420 -40070 0 0 {name=X_76727_ }
C {devices/lab_pin.sym} 108360 -39960 0 0 {name=p107268 lab=_49661_/X }
C {devices/lab_pin.sym} 108360 -39920 0 0 {name=p107269 lab=_52889_/B }
C {devices/lab_pin.sym} 108480 -39940 0 1 {name=p107270 lab=_49675_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -39940 0 0 {name=X_49675_ }
C {devices/lab_pin.sym} 108380 -39810 0 0 {name=p107271 lab=_73939_/A }
C {devices/lab_pin.sym} 108460 -39810 0 1 {name=p107272 lab=_73939_/X }
C {sky130_stdcells/buf_2.sym} 108420 -39810 0 0 {name=X_73939_ }
C {devices/lab_pin.sym} 108360 -39720 0 0 {name=p107273 lab=_61499_/B }
C {devices/lab_pin.sym} 108360 -39680 0 0 {name=p107274 lab=_61953_/B }
C {devices/lab_pin.sym} 108360 -39640 0 0 {name=p107275 lab=_61953_/C }
C {devices/lab_pin.sym} 108360 -39600 0 0 {name=p107276 lab=_61937_/X }
C {devices/lab_pin.sym} 108480 -39660 0 1 {name=p107277 lab=_61953_/Y }
C {sky130_stdcells/nand4_4.sym} 108420 -39660 0 0 {name=X_61953_ }
C {devices/lab_pin.sym} 108380 -39510 0 0 {name=p107278 lab=_52732_/B }
C {devices/lab_pin.sym} 108460 -39510 0 1 {name=p107279 lab=_51043_/B }
C {sky130_stdcells/buf_2.sym} 108420 -39510 0 0 {name=X_46887_ }
C {devices/lab_pin.sym} 108380 -39390 0 0 {name=p107280 lab=_83569_/Q }
C {devices/lab_pin.sym} 108460 -39390 0 1 {name=p107281 lab=_48627_/A }
C {sky130_stdcells/inv_2.sym} 108420 -39390 0 0 {name=X_48626_ }
C {devices/lab_pin.sym} 108380 -39270 0 0 {name=p107282 lab=_60879_/B }
C {devices/lab_pin.sym} 108460 -39270 0 1 {name=p107283 lab=_64081_/C }
C {sky130_stdcells/buf_2.sym} 108420 -39270 0 0 {name=X_60904_ }
C {devices/lab_pin.sym} 108360 -39160 0 0 {name=p107284 lab=_67460_/A }
C {devices/lab_pin.sym} 108360 -39120 0 0 {name=p107285 lab=_87662_/Q }
C {devices/lab_pin.sym} 108480 -39140 0 1 {name=p107286 lab=_67460_/X }
C {sky130_stdcells/and2_4.sym} 108420 -39140 0 0 {name=X_67460_ }
C {devices/lab_pin.sym} 108360 -39020 0 0 {name=p107287 lab=_84811_/Q }
C {devices/lab_pin.sym} 108360 -38980 0 0 {name=p107288 lab=_84131_/Q }
C {devices/lab_pin.sym} 108480 -39000 0 1 {name=p107289 lab=_79446_/X }
C {sky130_stdcells/xor2_4.sym} 108420 -39000 0 0 {name=X_79446_ }
C {devices/lab_pin.sym} 108340 -38890 0 0 {name=p107290 lab=_45829_/X }
C {devices/lab_pin.sym} 108340 -38850 0 0 {name=p107291 lab=_45833_/Y }
C {devices/lab_pin.sym} 108340 -38810 0 0 {name=p107292 lab=_45837_/Y }
C {devices/lab_pin.sym} 108500 -38850 0 1 {name=p107293 lab=_45838_/Y }
C {sky130_stdcells/a21oi_4.sym} 108420 -38850 0 0 {name=X_45838_ }
C {devices/lab_pin.sym} 108340 -38730 0 0 {name=p107294 lab=_64669_/X }
C {devices/lab_pin.sym} 108340 -38690 0 0 {name=p107295 lab=_64671_/X }
C {devices/lab_pin.sym} 108340 -38650 0 0 {name=p107296 lab=_64619_/X }
C {devices/lab_pin.sym} 108500 -38690 0 1 {name=p107297 lab=_64672_/X }
C {sky130_stdcells/a21o_4.sym} 108420 -38690 0 0 {name=X_64672_ }
C {devices/lab_pin.sym} 108360 -38560 0 0 {name=p107298 lab=_76657_/Y }
C {devices/lab_pin.sym} 108360 -38520 0 0 {name=p107299 lab=_81395_/Q }
C {devices/lab_pin.sym} 108480 -38540 0 1 {name=p107300 lab=_76658_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -38540 0 0 {name=X_76658_ }
C {devices/lab_pin.sym} 108380 -38410 0 0 {name=p107301 lab=_59721_/X }
C {devices/lab_pin.sym} 108460 -38410 0 1 {name=p107302 lab=_61915_/A }
C {sky130_stdcells/buf_2.sym} 108420 -38410 0 0 {name=X_61884_ }
C {devices/lab_pin.sym} 108380 -38290 0 0 {name=p107303 lab=_66411_/A }
C {devices/lab_pin.sym} 108460 -38290 0 1 {name=p107304 lab=_66411_/X }
C {sky130_stdcells/buf_2.sym} 108420 -38290 0 0 {name=X_66411_ }
C {devices/lab_pin.sym} 108340 -38190 0 0 {name=p107305 lab=_63621_/Y }
C {devices/lab_pin.sym} 108340 -38150 0 0 {name=p107306 lab=_63578_/X }
C {devices/lab_pin.sym} 108340 -38110 0 0 {name=p107307 lab=_63622_/Y }
C {devices/lab_pin.sym} 108500 -38150 0 1 {name=p107308 lab=_63623_/Y }
C {sky130_stdcells/a21oi_4.sym} 108420 -38150 0 0 {name=X_63623_ }
C {devices/lab_pin.sym} 108340 -38030 0 0 {name=p107309 lab=_75602_/Y }
C {devices/lab_pin.sym} 108340 -37990 0 0 {name=p107310 lab=_75607_/Y }
C {devices/lab_pin.sym} 108340 -37950 0 0 {name=p107311 lab=_75608_/Y }
C {devices/lab_pin.sym} 108500 -37990 0 1 {name=p107312 lab=_75609_/Y }
C {sky130_stdcells/a21oi_4.sym} 108420 -37990 0 0 {name=X_75609_ }
C {devices/lab_pin.sym} 108360 -37860 0 0 {name=p107313 lab=_48557_/A }
C {devices/lab_pin.sym} 108360 -37820 0 0 {name=p107314 lab=_52188_/B }
C {devices/lab_pin.sym} 108480 -37840 0 1 {name=p107315 lab=_48557_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -37840 0 0 {name=X_48557_ }
C {devices/lab_pin.sym} 108380 -37710 0 0 {name=p107316 lab=_60422_/A }
C {devices/lab_pin.sym} 108460 -37710 0 1 {name=p107317 lab=_60835_/X }
C {sky130_stdcells/buf_2.sym} 108420 -37710 0 0 {name=X_60835_ }
C {devices/lab_pin.sym} 108380 -37590 0 0 {name=p107318 lab=_67270_/X }
C {devices/lab_pin.sym} 108460 -37590 0 1 {name=p107319 lab=_67391_/X }
C {sky130_stdcells/buf_2.sym} 108420 -37590 0 0 {name=X_67391_ }
C {devices/lab_pin.sym} 108360 -37480 0 0 {name=p107320 lab=_79361_/X }
C {devices/lab_pin.sym} 108360 -37440 0 0 {name=p107321 lab=_79364_/Y }
C {devices/lab_pin.sym} 108480 -37460 0 1 {name=p107322 lab=_79377_/X }
C {sky130_stdcells/or2_4.sym} 108420 -37460 0 0 {name=X_79377_ }
C {devices/lab_pin.sym} 108360 -37340 0 0 {name=p107323 lab=_85065_/Q }
C {devices/lab_pin.sym} 108360 -37300 0 0 {name=p107324 lab=_45736_/B }
C {devices/lab_pin.sym} 108480 -37320 0 1 {name=p107325 lab=_45769_/Y }
C {sky130_stdcells/nor2_4.sym} 108420 -37320 0 0 {name=X_45769_ }
C {devices/lab_pin.sym} 108380 -37190 0 0 {name=p107326 lab=_76588_/X }
C {devices/lab_pin.sym} 108460 -37190 0 1 {name=p107327 lab=_76589_/Y }
C {sky130_stdcells/inv_2.sym} 108420 -37190 0 0 {name=X_76589_ }
C {devices/lab_pin.sym} 108340 -37100 0 0 {name=p107328 lab=_87072_/Q }
C {devices/lab_pin.sym} 108340 -37060 0 0 {name=p107329 lab=_69058_/X }
C {devices/lab_pin.sym} 108340 -37020 0 0 {name=p107330 lab=_69103_/X }
C {devices/lab_pin.sym} 108340 -36980 0 0 {name=p107331 lab=_69129_/X }
C {devices/lab_pin.sym} 108500 -37040 0 1 {name=p107332 lab=_69130_/X }
C {sky130_stdcells/a211o_4.sym} 108420 -37040 0 0 {name=X_69130_ }
C {devices/lab_pin.sym} 108340 -36910 0 0 {name=p107333 lab=_58132_/A }
C {devices/lab_pin.sym} 108340 -36870 0 0 {name=p107334 lab=_47478_/X }
C {devices/lab_pin.sym} 108340 -36830 0 0 {name=p107335 lab=_47507_/Y }
C {devices/lab_pin.sym} 108500 -36870 0 1 {name=p107336 lab=_47508_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -36870 0 0 {name=X_47508_ }
C {devices/lab_pin.sym} 108340 -36750 0 0 {name=p107337 lab=_66282_/X }
C {devices/lab_pin.sym} 108340 -36710 0 0 {name=p107338 lab=_65884_/Y }
C {devices/lab_pin.sym} 108340 -36670 0 0 {name=p107339 lab=_66341_/Y }
C {devices/lab_pin.sym} 108500 -36710 0 1 {name=p107340 lab=_66342_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -36710 0 0 {name=X_66342_ }
C {devices/lab_pin.sym} 108360 -36580 0 0 {name=p107341 lab=_78330_/A }
C {devices/lab_pin.sym} 108360 -36540 0 0 {name=p107342 lab=_78330_/B }
C {devices/lab_pin.sym} 108480 -36560 0 1 {name=p107343 lab=_78329_/A }
C {sky130_stdcells/nor2_4.sym} 108420 -36560 0 0 {name=X_78328_ }
C {devices/lab_pin.sym} 108360 -36450 0 0 {name=p107344 lab=_63554_/A }
C {devices/lab_pin.sym} 108360 -36410 0 0 {name=p107345 lab=_63554_/B }
C {devices/lab_pin.sym} 108360 -36370 0 0 {name=p107346 lab=_63554_/C }
C {devices/lab_pin.sym} 108480 -36410 0 1 {name=p107347 lab=_63554_/Y }
C {sky130_stdcells/nor3_4.sym} 108420 -36410 0 0 {name=X_63554_ }
C {devices/lab_pin.sym} 108380 -36270 0 0 {name=p107348 lab=_48545_/A }
C {devices/lab_pin.sym} 108460 -36270 0 1 {name=p107349 lab=_48533_/C }
C {sky130_stdcells/buf_2.sym} 108420 -36270 0 0 {name=X_48488_ }
C {devices/lab_pin.sym} 108360 -36180 0 0 {name=p107350 lab=_60652_/X }
C {devices/lab_pin.sym} 108360 -36140 0 0 {name=p107351 lab=_60724_/B }
C {devices/lab_pin.sym} 108360 -36100 0 0 {name=p107352 lab=_60624_/X }
C {devices/lab_pin.sym} 108360 -36060 0 0 {name=p107353 lab=_60659_/A }
C {devices/lab_pin.sym} 108480 -36120 0 1 {name=p107354 lab=_60766_/X }
C {sky130_stdcells/and4_4.sym} 108420 -36120 0 0 {name=X_60766_ }
C {devices/lab_pin.sym} 108360 -36000 0 0 {name=p107355 lab=_61570_/B }
C {devices/lab_pin.sym} 108360 -35960 0 0 {name=p107356 lab=_62504_/X }
C {devices/lab_pin.sym} 108360 -35920 0 0 {name=p107357 lab=_62449_/X }
C {devices/lab_pin.sym} 108360 -35880 0 0 {name=p107358 lab=_62475_/X }
C {devices/lab_pin.sym} 108480 -35940 0 1 {name=p107359 lab=_62506_/D }
C {sky130_stdcells/nand4_4.sym} 108420 -35940 0 0 {name=X_62505_ }
C {devices/lab_pin.sym} 108380 -35790 0 0 {name=p107360 lab=_68737_/A }
C {devices/lab_pin.sym} 108460 -35790 0 1 {name=p107361 lab=_69061_/X }
C {sky130_stdcells/buf_2.sym} 108420 -35790 0 0 {name=X_69061_ }
C {devices/lab_pin.sym} 108380 -35670 0 0 {name=p107362 lab=_54739_/D }
C {devices/lab_pin.sym} 108460 -35670 0 1 {name=p107363 lab=_53048_/D }
C {sky130_stdcells/buf_2.sym} 108420 -35670 0 0 {name=X_47439_ }
C {devices/lab_pin.sym} 108360 -35560 0 0 {name=p107364 lab=_66326_/A }
C {devices/lab_pin.sym} 108360 -35520 0 0 {name=p107365 lab=_86536_/Q }
C {devices/lab_pin.sym} 108480 -35540 0 1 {name=p107366 lab=_66273_/X }
C {sky130_stdcells/and2_4.sym} 108420 -35540 0 0 {name=X_66273_ }
C {devices/lab_pin.sym} 108340 -35430 0 0 {name=p107367 lab=_78251_/A }
C {devices/lab_pin.sym} 108340 -35390 0 0 {name=p107368 lab=_78256_/B }
C {devices/lab_pin.sym} 108340 -35350 0 0 {name=p107369 lab=_78250_/A }
C {devices/lab_pin.sym} 108500 -35390 0 1 {name=p107370 lab=_78259_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -35390 0 0 {name=X_78259_ }
C {devices/lab_pin.sym} 108360 -35280 0 0 {name=p107371 lab=_63496_/A }
C {devices/lab_pin.sym} 108360 -35240 0 0 {name=p107372 lab=_58511_/A }
C {devices/lab_pin.sym} 108360 -35200 0 0 {name=p107373 lab=_63458_/X }
C {devices/lab_pin.sym} 108360 -35160 0 0 {name=p107374 lab=_63496_/D }
C {devices/lab_pin.sym} 108480 -35220 0 1 {name=p107375 lab=_63485_/X }
C {sky130_stdcells/and4_4.sym} 108420 -35220 0 0 {name=X_63485_ }
C {devices/lab_pin.sym} 108360 -35080 0 0 {name=p107376 lab=_60660_/X }
C {devices/lab_pin.sym} 108360 -35040 0 0 {name=p107377 lab=_60697_/B }
C {devices/lab_pin.sym} 108480 -35060 0 1 {name=p107378 lab=_60697_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -35060 0 0 {name=X_60697_ }
C {devices/lab_pin.sym} 108380 -34930 0 0 {name=p107379 lab=_67657_/X }
C {devices/lab_pin.sym} 108460 -34930 0 1 {name=p107380 lab=_68371_/A }
C {sky130_stdcells/buf_2.sym} 108420 -34930 0 0 {name=X_68012_ }
C {devices/lab_pin.sym} 108380 -34810 0 0 {name=p107381 lab=_65400_/A }
C {devices/lab_pin.sym} 108460 -34810 0 1 {name=p107382 lab=_65224_/X }
C {sky130_stdcells/buf_2.sym} 108420 -34810 0 0 {name=X_65224_ }
C {devices/lab_pin.sym} 108340 -34710 0 0 {name=p107383 lab=_86198_/Q }
C {devices/lab_pin.sym} 108340 -34670 0 0 {name=p107384 lab=_50437_/X }
C {devices/lab_pin.sym} 108340 -34630 0 0 {name=p107385 lab=_50449_/Y }
C {devices/lab_pin.sym} 108500 -34670 0 1 {name=p107386 lab=_50450_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -34670 0 0 {name=X_50450_ }
C {devices/lab_pin.sym} 108380 -34530 0 0 {name=p107387 lab=_59950_/C }
C {devices/lab_pin.sym} 108460 -34530 0 1 {name=p107388 lab=_62436_/X }
C {sky130_stdcells/buf_2.sym} 108420 -34530 0 0 {name=X_62436_ }
C {devices/lab_pin.sym} 108330 -34410 0 0 {name=p107389 lab=_81697_/CLK }
C {devices/lab_pin.sym} 108330 -34390 0 0 {name=p107390 lab=_81270_/D }
C {devices/lab_pin.sym} 108510 -34410 0 1 {name=p107391 lab=_76459_/A }
C {sky130_stdcells/dfxtp_4.sym} 108420 -34400 0 0 {name=X_81270_ }
C {devices/lab_pin.sym} 108340 -34290 0 0 {name=p107392 lab=_86443_/Q }
C {devices/lab_pin.sym} 108340 -34250 0 0 {name=p107393 lab=_49104_/X }
C {devices/lab_pin.sym} 108340 -34210 0 0 {name=p107394 lab=_49108_/Y }
C {devices/lab_pin.sym} 108500 -34250 0 1 {name=p107395 lab=_49109_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -34250 0 0 {name=X_49109_ }
C {devices/lab_pin.sym} 108360 -34120 0 0 {name=p107396 lab=_80221_/A }
C {devices/lab_pin.sym} 108360 -34080 0 0 {name=p107397 lab=_80221_/B }
C {devices/lab_pin.sym} 108480 -34100 0 1 {name=p107398 lab=_80221_/X }
C {sky130_stdcells/and2_4.sym} 108420 -34100 0 0 {name=X_80221_ }
C {devices/lab_pin.sym} 108360 -33980 0 0 {name=p107399 lab=_65155_/A }
C {devices/lab_pin.sym} 108360 -33940 0 0 {name=p107400 lab=_65155_/B }
C {devices/lab_pin.sym} 108480 -33960 0 1 {name=p107401 lab=_65155_/X }
C {sky130_stdcells/and2_4.sym} 108420 -33960 0 0 {name=X_65155_ }
C {devices/lab_pin.sym} 108360 -33840 0 0 {name=p107402 lab=_50381_/A }
C {devices/lab_pin.sym} 108360 -33800 0 0 {name=p107403 lab=_50381_/B }
C {devices/lab_pin.sym} 108480 -33820 0 1 {name=p107404 lab=_50381_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -33820 0 0 {name=X_50381_ }
C {devices/lab_pin.sym} 108380 -33690 0 0 {name=p107405 lab=_62214_/A }
C {devices/lab_pin.sym} 108460 -33690 0 1 {name=p107406 lab=_62367_/X }
C {sky130_stdcells/buf_2.sym} 108420 -33690 0 0 {name=X_62367_ }
C {devices/lab_pin.sym} 108340 -33590 0 0 {name=p107407 lab=_52116_/Y }
C {devices/lab_pin.sym} 108340 -33550 0 0 {name=p107408 lab=_52117_/X }
C {devices/lab_pin.sym} 108340 -33510 0 0 {name=p107409 lab=_52119_/Y }
C {devices/lab_pin.sym} 108500 -33550 0 1 {name=p107410 lab=_52120_/Y }
C {sky130_stdcells/a21boi_4.sym} 108420 -33550 0 0 {name=X_52120_ }
C {devices/lab_pin.sym} 108360 -33420 0 0 {name=p107411 lab=_84842_/Q }
C {devices/lab_pin.sym} 108360 -33380 0 0 {name=p107412 lab=_64136_/B }
C {devices/lab_pin.sym} 108480 -33400 0 1 {name=p107413 lab=_64106_/X }
C {sky130_stdcells/or2_4.sym} 108420 -33400 0 0 {name=X_64106_ }
C {devices/lab_pin.sym} 108380 -33270 0 0 {name=p107414 lab=_61313_/A }
C {devices/lab_pin.sym} 108460 -33270 0 1 {name=p107415 lab=_72575_/A }
C {sky130_stdcells/buf_2.sym} 108420 -33270 0 0 {name=X_61318_ }
C {devices/lab_pin.sym} 108360 -33160 0 0 {name=p107416 lab=_84944_/Q }
C {devices/lab_pin.sym} 108360 -33120 0 0 {name=p107417 lab=_84192_/Q }
C {devices/lab_pin.sym} 108480 -33140 0 1 {name=p107418 lab=_80154_/A }
C {sky130_stdcells/xor2_4.sym} 108420 -33140 0 0 {name=X_80152_ }
C {devices/lab_pin.sym} 108340 -33030 0 0 {name=p107419 lab=_65083_/X }
C {devices/lab_pin.sym} 108340 -32990 0 0 {name=p107420 lab=_65085_/X }
C {devices/lab_pin.sym} 108340 -32950 0 0 {name=p107421 lab=_64989_/X }
C {devices/lab_pin.sym} 108500 -32990 0 1 {name=p107422 lab=_65086_/X }
C {sky130_stdcells/a21o_4.sym} 108420 -32990 0 0 {name=X_65086_ }
C {devices/lab_pin.sym} 108340 -32870 0 0 {name=p107423 lab=_69960_/X }
C {devices/lab_pin.sym} 108340 -32830 0 0 {name=p107424 lab=_69962_/X }
C {devices/lab_pin.sym} 108340 -32790 0 0 {name=p107425 lab=_60371_/A }
C {devices/lab_pin.sym} 108500 -32830 0 1 {name=p107426 lab=_69963_/Y }
C {sky130_stdcells/a21oi_4.sym} 108420 -32830 0 0 {name=X_69963_ }
C {devices/lab_pin.sym} 108360 -32720 0 0 {name=p107427 lab=_61387_/X }
C {devices/lab_pin.sym} 108360 -32680 0 0 {name=p107428 lab=_62309_/B }
C {devices/lab_pin.sym} 108360 -32640 0 0 {name=p107429 lab=_62309_/C }
C {devices/lab_pin.sym} 108360 -32600 0 0 {name=p107430 lab=_62211_/D }
C {devices/lab_pin.sym} 108480 -32660 0 1 {name=p107431 lab=_62298_/Y }
C {sky130_stdcells/nand4_4.sym} 108420 -32660 0 0 {name=X_62298_ }
C {devices/lab_pin.sym} 108340 -32530 0 0 {name=p107432 lab=_52048_/Y }
C {devices/lab_pin.sym} 108340 -32490 0 0 {name=p107433 lab=_52049_/X }
C {devices/lab_pin.sym} 108340 -32450 0 0 {name=p107434 lab=_52050_/X }
C {devices/lab_pin.sym} 108500 -32490 0 1 {name=p107435 lab=_52051_/Y }
C {sky130_stdcells/a21oi_4.sym} 108420 -32490 0 0 {name=X_52051_ }
C {devices/lab_pin.sym} 108360 -32370 0 0 {name=p107436 lab=_64074_/A }
C {devices/lab_pin.sym} 108360 -32330 0 0 {name=p107437 lab=_64074_/B }
C {devices/lab_pin.sym} 108360 -32290 0 0 {name=p107438 lab=_64037_/C }
C {devices/lab_pin.sym} 108480 -32330 0 1 {name=p107439 lab=_64037_/Y }
C {sky130_stdcells/nor3_4.sym} 108420 -32330 0 0 {name=X_64037_ }
C {devices/lab_pin.sym} 108340 -32220 0 0 {name=p107440 lab=_44725_/A }
C {devices/lab_pin.sym} 108340 -32180 0 0 {name=p107441 lab=_68472_/X }
C {devices/lab_pin.sym} 108340 -32140 0 0 {name=p107442 lab=_44246_/A }
C {devices/lab_pin.sym} 108340 -32100 0 0 {name=p107443 lab=_68913_/X }
C {devices/lab_pin.sym} 108500 -32160 0 1 {name=p107444 lab=_68914_/X }
C {sky130_stdcells/a211o_4.sym} 108420 -32160 0 0 {name=X_68914_ }
C {devices/lab_pin.sym} 108340 -32050 0 0 {name=p107445 lab=_60371_/X }
C {devices/lab_pin.sym} 108340 -32010 0 0 {name=p107446 lab=_59901_/A }
C {devices/lab_pin.sym} 108340 -31970 0 0 {name=p107447 lab=_63004_/B }
C {devices/lab_pin.sym} 108340 -31930 0 0 {name=p107448 lab=_44003_/X }
C {devices/lab_pin.sym} 108340 -31900 0 0 {name=p107449 lab=_59802_/X }
C {devices/lab_pin.sym} 108500 -31970 0 1 {name=p107450 lab=_61249_/Y }
C {sky130_stdcells/a41oi_4.sym} 108420 -31970 0 0 {name=X_61249_ }
C {devices/lab_pin.sym} 108330 -31810 0 0 {name=p107451 lab=_84960_/CLK }
C {devices/lab_pin.sym} 108330 -31790 0 0 {name=p107452 lab=_84960_/D }
C {devices/lab_pin.sym} 108510 -31810 0 1 {name=p107453 lab=_84960_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -31800 0 0 {name=X_84960_ }
C {devices/lab_pin.sym} 108360 -31680 0 0 {name=p107454 lab=_80081_/X }
C {devices/lab_pin.sym} 108360 -31640 0 0 {name=p107455 lab=_80088_/B }
C {devices/lab_pin.sym} 108480 -31660 0 1 {name=p107456 lab=_80083_/Y }
C {sky130_stdcells/xnor2_4.sym} 108420 -31660 0 0 {name=X_80083_ }
C {devices/lab_pin.sym} 108380 -31530 0 0 {name=p107457 lab=_69988_/A }
C {devices/lab_pin.sym} 108460 -31530 0 1 {name=p107458 lab=_69894_/X }
C {sky130_stdcells/buf_2.sym} 108420 -31530 0 0 {name=X_69894_ }
C {devices/lab_pin.sym} 108340 -31430 0 0 {name=p107459 lab=_50999_/Y }
C {devices/lab_pin.sym} 108340 -31390 0 0 {name=p107460 lab=_50983_/X }
C {devices/lab_pin.sym} 108340 -31350 0 0 {name=p107461 lab=_51001_/X }
C {devices/lab_pin.sym} 108500 -31390 0 1 {name=p107462 lab=_51002_/Y }
C {sky130_stdcells/a21oi_4.sym} 108420 -31390 0 0 {name=X_51002_ }
C {devices/lab_pin.sym} 108330 -31250 0 0 {name=p107463 lab=_81933_/CLK }
C {devices/lab_pin.sym} 108330 -31230 0 0 {name=p107464 lab=_83911_/D }
C {devices/lab_pin.sym} 108510 -31250 0 1 {name=p107465 lab=_81983_/D }
C {sky130_stdcells/dfxtp_4.sym} 108420 -31240 0 0 {name=X_83911_ }
C {devices/lab_pin.sym} 108340 -31140 0 0 {name=p107466 lab=_44719_/A }
C {devices/lab_pin.sym} 108340 -31100 0 0 {name=p107467 lab=_68472_/X }
C {devices/lab_pin.sym} 108340 -31060 0 0 {name=p107468 lab=_44246_/A }
C {devices/lab_pin.sym} 108340 -31020 0 0 {name=p107469 lab=_68844_/X }
C {devices/lab_pin.sym} 108500 -31080 0 1 {name=p107470 lab=_68845_/X }
C {sky130_stdcells/a211o_4.sym} 108420 -31080 0 0 {name=X_68845_ }
C {devices/lab_pin.sym} 108330 -30930 0 0 {name=p107471 lab=_84250_/CLK }
C {devices/lab_pin.sym} 108330 -30910 0 0 {name=p107472 lab=_84891_/D }
C {devices/lab_pin.sym} 108510 -30930 0 1 {name=p107473 lab=_84891_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -30920 0 0 {name=X_84891_ }
C {devices/lab_pin.sym} 108380 -30790 0 0 {name=p107474 lab=_85555_/CLK }
C {devices/lab_pin.sym} 108460 -30790 0 1 {name=p107475 lab=_85553_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 108420 -30790 0 0 {name=Xclkbuf_opt_20_CLK }
C {devices/lab_pin.sym} 108360 -30680 0 0 {name=p107476 lab=_55807_/X }
C {devices/lab_pin.sym} 108360 -30640 0 0 {name=p107477 lab=_55809_/X }
C {devices/lab_pin.sym} 108480 -30660 0 1 {name=p107478 lab=_55811_/A }
C {sky130_stdcells/and2_4.sym} 108420 -30660 0 0 {name=X_55810_ }
C {devices/lab_pin.sym} 108330 -30530 0 0 {name=p107479 lab=_85990_/CLK }
C {devices/lab_pin.sym} 108330 -30510 0 0 {name=p107480 lab=_86630_/D }
C {devices/lab_pin.sym} 108510 -30530 0 1 {name=p107481 lab=_86630_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -30520 0 0 {name=X_86630_ }
C {devices/lab_pin.sym} 108330 -30390 0 0 {name=p107482 lab=_83842_/CLK }
C {devices/lab_pin.sym} 108330 -30370 0 0 {name=p107483 lab=_83842_/D }
C {devices/lab_pin.sym} 108510 -30390 0 1 {name=p107484 lab=_83842_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -30380 0 0 {name=X_83842_ }
C {devices/lab_pin.sym} 108340 -30290 0 0 {name=p107485 lab=_56787_/X }
C {devices/lab_pin.sym} 108340 -30250 0 0 {name=p107486 lab=_56766_/X }
C {devices/lab_pin.sym} 108340 -30210 0 0 {name=p107487 lab=_57163_/C }
C {devices/lab_pin.sym} 108340 -30170 0 0 {name=p107488 lab=_56788_/X }
C {devices/lab_pin.sym} 108340 -30140 0 0 {name=p107489 lab=_57170_/A }
C {devices/lab_pin.sym} 108500 -30210 0 1 {name=p107490 lab=_56790_/X }
C {sky130_stdcells/a41o_4.sym} 108420 -30210 0 0 {name=X_56790_ }
C {devices/lab_pin.sym} 108340 -30080 0 0 {name=p107491 lab=_87087_/Q }
C {devices/lab_pin.sym} 108340 -30040 0 0 {name=p107492 lab=_68353_/X }
C {devices/lab_pin.sym} 108340 -30000 0 0 {name=p107493 lab=_68354_/X }
C {devices/lab_pin.sym} 108340 -29960 0 0 {name=p107494 lab=_68775_/X }
C {devices/lab_pin.sym} 108500 -30020 0 1 {name=p107495 lab=_68776_/X }
C {sky130_stdcells/a211o_4.sym} 108420 -30020 0 0 {name=X_68776_ }
C {devices/lab_pin.sym} 108360 -29890 0 0 {name=p107496 lab=_65970_/A }
C {devices/lab_pin.sym} 108360 -29850 0 0 {name=p107497 lab=_65970_/B }
C {devices/lab_pin.sym} 108360 -29810 0 0 {name=p107498 lab=_84164_/Q }
C {devices/lab_pin.sym} 108480 -29850 0 1 {name=p107499 lab=_65988_/X }
C {sky130_stdcells/and3_4.sym} 108420 -29850 0 0 {name=X_65988_ }
C {devices/lab_pin.sym} 108360 -29720 0 0 {name=p107500 lab=_67793_/A }
C {devices/lab_pin.sym} 108360 -29680 0 0 {name=p107501 lab=_67727_/B }
C {devices/lab_pin.sym} 108480 -29700 0 1 {name=p107502 lab=_67727_/X }
C {sky130_stdcells/and2_4.sym} 108420 -29700 0 0 {name=X_67727_ }
C {devices/lab_pin.sym} 108360 -29580 0 0 {name=p107503 lab=_55741_/A }
C {devices/lab_pin.sym} 108360 -29540 0 0 {name=p107504 lab=_55741_/B }
C {devices/lab_pin.sym} 108480 -29560 0 1 {name=p107505 lab=_55741_/X }
C {sky130_stdcells/and2_4.sym} 108420 -29560 0 0 {name=X_55741_ }
C {devices/lab_pin.sym} 108330 -29430 0 0 {name=p107506 lab=_83561_/CLK }
C {devices/lab_pin.sym} 108330 -29410 0 0 {name=p107507 lab=_86561_/D }
C {devices/lab_pin.sym} 108510 -29430 0 1 {name=p107508 lab=_73568_/B }
C {sky130_stdcells/dfxtp_4.sym} 108420 -29420 0 0 {name=X_86561_ }
C {devices/lab_pin.sym} 108380 -29290 0 0 {name=p107509 lab=_53062_/A }
C {devices/lab_pin.sym} 108460 -29290 0 1 {name=p107510 lab=_52977_/C }
C {sky130_stdcells/buf_2.sym} 108420 -29290 0 0 {name=X_52953_ }
C {devices/lab_pin.sym} 108380 -29170 0 0 {name=p107511 lab=_64939_/A }
C {devices/lab_pin.sym} 108460 -29170 0 1 {name=p107512 lab=_64939_/X }
C {sky130_stdcells/buf_2.sym} 108420 -29170 0 0 {name=X_64939_ }
C {devices/lab_pin.sym} 108330 -29050 0 0 {name=p107513 lab=_84981_/CLK }
C {devices/lab_pin.sym} 108330 -29030 0 0 {name=p107514 lab=_70443_/Y }
C {devices/lab_pin.sym} 108510 -29050 0 1 {name=p107515 lab=_47959_/A }
C {sky130_stdcells/dfxtp_4.sym} 108420 -29040 0 0 {name=X_83773_ }
C {devices/lab_pin.sym} 108330 -28910 0 0 {name=p107516 lab=_80813_/CLK }
C {devices/lab_pin.sym} 108330 -28890 0 0 {name=p107517 lab=_80985_/D }
C {devices/lab_pin.sym} 108510 -28910 0 1 {name=p107518 lab=_80985_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -28900 0 0 {name=X_80985_ }
C {devices/lab_pin.sym} 108330 -28770 0 0 {name=p107519 lab=_88097_/CLK }
C {devices/lab_pin.sym} 108330 -28750 0 0 {name=p107520 lab=_40974_/Y }
C {devices/lab_pin.sym} 108510 -28770 0 1 {name=p107521 lab=_88300_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -28760 0 0 {name=X_88300_ }
C {devices/lab_pin.sym} 108330 -28630 0 0 {name=p107522 lab=_85800_/CLK }
C {devices/lab_pin.sym} 108330 -28610 0 0 {name=p107523 lab=_85512_/D }
C {devices/lab_pin.sym} 108510 -28630 0 1 {name=p107524 lab=_85512_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -28620 0 0 {name=X_85512_ }
C {devices/lab_pin.sym} 108380 -28490 0 0 {name=p107525 lab=_51823_/A }
C {devices/lab_pin.sym} 108460 -28490 0 1 {name=p107526 lab=_51904_/X }
C {sky130_stdcells/buf_2.sym} 108420 -28490 0 0 {name=X_51904_ }
C {devices/lab_pin.sym} 108380 -28370 0 0 {name=p107527 lab=_58459_/Y }
C {devices/lab_pin.sym} 108460 -28370 0 1 {name=p107528 lab=_58461_/A }
C {sky130_stdcells/buf_2.sym} 108420 -28370 0 0 {name=X_58460_ }
C {devices/lab_pin.sym} 108330 -28250 0 0 {name=p107529 lab=_84115_/CLK }
C {devices/lab_pin.sym} 108330 -28230 0 0 {name=p107530 lab=_84108_/Q }
C {devices/lab_pin.sym} 108510 -28250 0 1 {name=p107531 lab=_78831_/A }
C {sky130_stdcells/dfxtp_4.sym} 108420 -28240 0 0 {name=X_82724_ }
C {devices/lab_pin.sym} 108360 -28120 0 0 {name=p107532 lab=_55287_/A }
C {devices/lab_pin.sym} 108360 -28080 0 0 {name=p107533 lab=_55674_/B }
C {devices/lab_pin.sym} 108480 -28100 0 1 {name=p107534 lab=_55672_/X }
C {sky130_stdcells/and2_4.sym} 108420 -28100 0 0 {name=X_55672_ }
C {devices/lab_pin.sym} 108380 -27970 0 0 {name=p107535 lab=_67657_/X }
C {devices/lab_pin.sym} 108460 -27970 0 1 {name=p107536 lab=_67658_/X }
C {sky130_stdcells/buf_2.sym} 108420 -27970 0 0 {name=X_67658_ }
C {devices/lab_pin.sym} 108330 -27850 0 0 {name=p107537 lab=_85596_/CLK }
C {devices/lab_pin.sym} 108330 -27830 0 0 {name=p107538 lab=_86492_/D }
C {devices/lab_pin.sym} 108510 -27850 0 1 {name=p107539 lab=_72911_/B }
C {sky130_stdcells/dfxtp_4.sym} 108420 -27840 0 0 {name=X_86492_ }
C {devices/lab_pin.sym} 108340 -27730 0 0 {name=p107540 lab=_52882_/Y }
C {devices/lab_pin.sym} 108340 -27690 0 0 {name=p107541 lab=_52865_/X }
C {devices/lab_pin.sym} 108340 -27650 0 0 {name=p107542 lab=_52883_/X }
C {devices/lab_pin.sym} 108500 -27690 0 1 {name=p107543 lab=_52884_/Y }
C {sky130_stdcells/a21oi_4.sym} 108420 -27690 0 0 {name=X_52884_ }
C {devices/lab_pin.sym} 108360 -27560 0 0 {name=p107544 lab=_56694_/Y }
C {devices/lab_pin.sym} 108360 -27520 0 0 {name=p107545 lab=_57400_/X }
C {devices/lab_pin.sym} 108480 -27540 0 1 {name=p107546 lab=_57411_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -27540 0 0 {name=X_57411_ }
C {devices/lab_pin.sym} 108330 -27410 0 0 {name=p107547 lab=_86930_/CLK }
C {devices/lab_pin.sym} 108330 -27390 0 0 {name=p107548 lab=_41353_/X }
C {devices/lab_pin.sym} 108510 -27410 0 1 {name=p107549 lab=_88231_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -27400 0 0 {name=X_88231_ }
C {devices/lab_pin.sym} 108360 -27280 0 0 {name=p107550 lab=_54636_/A }
C {devices/lab_pin.sym} 108360 -27240 0 0 {name=p107551 lab=_54097_/B }
C {devices/lab_pin.sym} 108480 -27260 0 1 {name=p107552 lab=_54623_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -27260 0 0 {name=X_54623_ }
C {devices/lab_pin.sym} 108360 -27140 0 0 {name=p107553 lab=_66683_/A }
C {devices/lab_pin.sym} 108360 -27100 0 0 {name=p107554 lab=_66609_/B }
C {devices/lab_pin.sym} 108480 -27120 0 1 {name=p107555 lab=_66609_/X }
C {sky130_stdcells/and2_4.sym} 108420 -27120 0 0 {name=X_66609_ }
C {devices/lab_pin.sym} 108330 -26990 0 0 {name=p107556 lab=_85764_/CLK }
C {devices/lab_pin.sym} 108330 -26970 0 0 {name=p107557 lab=_85443_/D }
C {devices/lab_pin.sym} 108510 -26990 0 1 {name=p107558 lab=_85443_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -26980 0 0 {name=X_85443_ }
C {devices/lab_pin.sym} 108360 -26860 0 0 {name=p107559 lab=_51820_/A }
C {devices/lab_pin.sym} 108360 -26820 0 0 {name=p107560 lab=_50971_/B }
C {devices/lab_pin.sym} 108480 -26840 0 1 {name=p107561 lab=_51835_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -26840 0 0 {name=X_51835_ }
C {devices/lab_pin.sym} 108330 -26710 0 0 {name=p107562 lab=_81756_/CLK }
C {devices/lab_pin.sym} 108330 -26690 0 0 {name=p107563 lab=_84007_/Q }
C {devices/lab_pin.sym} 108510 -26710 0 1 {name=p107564 lab=_82655_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -26700 0 0 {name=X_82655_ }
C {devices/lab_pin.sym} 108360 -26580 0 0 {name=p107565 lab=_58391_/A }
C {devices/lab_pin.sym} 108360 -26540 0 0 {name=p107566 lab=_58403_/B }
C {devices/lab_pin.sym} 108480 -26560 0 1 {name=p107567 lab=_58391_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -26560 0 0 {name=X_58391_ }
C {devices/lab_pin.sym} 108340 -26460 0 0 {name=p107568 lab=_67496_/X }
C {devices/lab_pin.sym} 108340 -26420 0 0 {name=p107569 lab=_67577_/Y }
C {devices/lab_pin.sym} 108340 -26380 0 0 {name=p107570 lab=_67507_/X }
C {devices/lab_pin.sym} 108340 -26340 0 0 {name=p107571 lab=_67588_/Y }
C {devices/lab_pin.sym} 108500 -26400 0 1 {name=p107572 lab=_67589_/X }
C {sky130_stdcells/a211o_4.sym} 108420 -26400 0 0 {name=X_67589_ }
C {devices/lab_pin.sym} 108380 -26250 0 0 {name=p107573 lab=clkbuf_9_171_0_CLK/X }
C {devices/lab_pin.sym} 108460 -26250 0 1 {name=p107574 lab=_85645_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 108420 -26250 0 0 {name=Xclkbuf_10_342_0_CLK }
C {devices/lab_pin.sym} 108330 -26130 0 0 {name=p107575 lab=_81257_/CLK }
C {devices/lab_pin.sym} 108330 -26110 0 0 {name=p107576 lab=_76213_/B }
C {devices/lab_pin.sym} 108510 -26130 0 1 {name=p107577 lab=_81606_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -26120 0 0 {name=X_81606_ }
C {devices/lab_pin.sym} 108380 -25990 0 0 {name=p107578 lab=_57341_/Y }
C {devices/lab_pin.sym} 108460 -25990 0 1 {name=p107579 lab=_57342_/Y }
C {sky130_stdcells/inv_2.sym} 108420 -25990 0 0 {name=X_57342_ }
C {devices/lab_pin.sym} 108330 -25870 0 0 {name=p107580 lab=_87652_/CLK }
C {devices/lab_pin.sym} 108330 -25850 0 0 {name=p107581 lab=_88162_/D }
C {devices/lab_pin.sym} 108510 -25870 0 1 {name=p107582 lab=_88162_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -25860 0 0 {name=X_88162_ }
C {devices/lab_pin.sym} 108340 -25750 0 0 {name=p107583 lab=_81396_/D }
C {devices/lab_pin.sym} 108340 -25710 0 0 {name=p107584 lab=_69299_/X }
C {devices/lab_pin.sym} 108340 -25670 0 0 {name=p107585 lab=_69327_/X }
C {devices/lab_pin.sym} 108500 -25710 0 1 {name=p107586 lab=_83932_/D }
C {sky130_stdcells/a21bo_4.sym} 108420 -25710 0 0 {name=X_69328_ }
C {devices/lab_pin.sym} 108340 -25590 0 0 {name=p107587 lab=_54552_/Y }
C {devices/lab_pin.sym} 108340 -25550 0 0 {name=p107588 lab=_54530_/X }
C {devices/lab_pin.sym} 108340 -25510 0 0 {name=p107589 lab=_54553_/X }
C {devices/lab_pin.sym} 108500 -25550 0 1 {name=p107590 lab=_54554_/Y }
C {sky130_stdcells/a21oi_4.sym} 108420 -25550 0 0 {name=X_54554_ }
C {devices/lab_pin.sym} 108330 -25410 0 0 {name=p107591 lab=_83711_/CLK }
C {devices/lab_pin.sym} 108330 -25390 0 0 {name=p107592 lab=_54811_/Y }
C {devices/lab_pin.sym} 108510 -25410 0 1 {name=p107593 lab=_85374_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -25400 0 0 {name=X_85374_ }
C {devices/lab_pin.sym} 108340 -25290 0 0 {name=p107594 lab=_85950_/Q }
C {devices/lab_pin.sym} 108340 -25250 0 0 {name=p107595 lab=_51763_/X }
C {devices/lab_pin.sym} 108340 -25210 0 0 {name=p107596 lab=_51765_/Y }
C {devices/lab_pin.sym} 108500 -25250 0 1 {name=p107597 lab=_51766_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -25250 0 0 {name=X_51766_ }
C {devices/lab_pin.sym} 108330 -25110 0 0 {name=p107598 lab=_82589_/CLK }
C {devices/lab_pin.sym} 108330 -25090 0 0 {name=p107599 lab=_82586_/D }
C {devices/lab_pin.sym} 108510 -25110 0 1 {name=p107600 lab=_78248_/A }
C {sky130_stdcells/dfxtp_4.sym} 108420 -25100 0 0 {name=X_82586_ }
C {devices/lab_pin.sym} 108380 -24970 0 0 {name=p107601 lab=clkbuf_9_486_0_CLK/X }
C {devices/lab_pin.sym} 108460 -24970 0 1 {name=p107602 lab=_83282_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 108420 -24970 0 0 {name=Xclkbuf_10_972_0_CLK }
C {devices/lab_pin.sym} 108330 -24850 0 0 {name=p107603 lab=_87421_/CLK }
C {devices/lab_pin.sym} 108330 -24830 0 0 {name=p107604 lab=_87113_/D }
C {devices/lab_pin.sym} 108510 -24850 0 1 {name=p107605 lab=_87113_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -24840 0 0 {name=X_87113_ }
C {devices/lab_pin.sym} 108340 -24730 0 0 {name=p107606 lab=_53502_/Y }
C {devices/lab_pin.sym} 108340 -24690 0 0 {name=p107607 lab=_53498_/X }
C {devices/lab_pin.sym} 108340 -24650 0 0 {name=p107608 lab=_53504_/Y }
C {devices/lab_pin.sym} 108500 -24690 0 1 {name=p107609 lab=_85624_/D }
C {sky130_stdcells/a21boi_4.sym} 108420 -24690 0 0 {name=X_53505_ }
C {devices/lab_pin.sym} 108330 -24550 0 0 {name=p107610 lab=_84321_/CLK }
C {devices/lab_pin.sym} 108330 -24530 0 0 {name=p107611 lab=_63421_/Y }
C {devices/lab_pin.sym} 108510 -24550 0 1 {name=p107612 lab=_80579_/B }
C {sky130_stdcells/dfxtp_4.sym} 108420 -24540 0 0 {name=X_84325_ }
C {devices/lab_pin.sym} 108340 -24430 0 0 {name=p107613 lab=_86147_/Q }
C {devices/lab_pin.sym} 108340 -24390 0 0 {name=p107614 lab=_50706_/X }
C {devices/lab_pin.sym} 108340 -24350 0 0 {name=p107615 lab=_50716_/Y }
C {devices/lab_pin.sym} 108500 -24390 0 1 {name=p107616 lab=_50717_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -24390 0 0 {name=X_50717_ }
C {devices/lab_pin.sym} 108360 -24280 0 0 {name=p107617 lab=_57270_/X }
C {devices/lab_pin.sym} 108360 -24240 0 0 {name=p107618 lab=_57273_/B }
C {devices/lab_pin.sym} 108360 -24200 0 0 {name=p107619 lab=_57149_/B }
C {devices/lab_pin.sym} 108360 -24160 0 0 {name=p107620 lab=_56733_/X }
C {devices/lab_pin.sym} 108480 -24220 0 1 {name=p107621 lab=_57273_/Y }
C {sky130_stdcells/nand4_4.sym} 108420 -24220 0 0 {name=X_57273_ }
C {devices/lab_pin.sym} 108330 -24070 0 0 {name=p107622 lab=_83940_/CLK }
C {devices/lab_pin.sym} 108330 -24050 0 0 {name=p107623 lab=_81537_/D }
C {devices/lab_pin.sym} 108510 -24070 0 1 {name=p107624 lab=_81537_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -24060 0 0 {name=X_81537_ }
C {devices/lab_pin.sym} 108360 -23940 0 0 {name=p107625 lab=_69191_/A }
C {devices/lab_pin.sym} 108360 -23900 0 0 {name=p107626 lab=_87786_/Q }
C {devices/lab_pin.sym} 108480 -23920 0 1 {name=p107627 lab=_69259_/X }
C {sky130_stdcells/and2_4.sym} 108420 -23920 0 0 {name=X_69259_ }
C {devices/lab_pin.sym} 108330 -23790 0 0 {name=p107628 lab=_87588_/CLK }
C {devices/lab_pin.sym} 108330 -23770 0 0 {name=p107629 lab=_88093_/D }
C {devices/lab_pin.sym} 108510 -23790 0 1 {name=p107630 lab=_41957_/A }
C {sky130_stdcells/dfxtp_4.sym} 108420 -23780 0 0 {name=X_88093_ }
C {devices/lab_pin.sym} 108380 -23650 0 0 {name=p107631 lab=_54376_/A }
C {devices/lab_pin.sym} 108460 -23650 0 1 {name=p107632 lab=_54485_/X }
C {sky130_stdcells/buf_2.sym} 108420 -23650 0 0 {name=X_54485_ }
C {devices/lab_pin.sym} 108360 -23540 0 0 {name=p107633 lab=_51697_/A }
C {devices/lab_pin.sym} 108360 -23500 0 0 {name=p107634 lab=_53219_/B }
C {devices/lab_pin.sym} 108480 -23520 0 1 {name=p107635 lab=_51697_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -23520 0 0 {name=X_51697_ }
C {devices/lab_pin.sym} 108380 -23390 0 0 {name=p107636 lab=clkbuf_8_231_0_CLK/X }
C {devices/lab_pin.sym} 108460 -23390 0 1 {name=p107637 lab=clkbuf_9_463_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 108420 -23390 0 0 {name=Xclkbuf_9_463_0_CLK }
C {devices/lab_pin.sym} 108340 -23290 0 0 {name=p107638 lab=_58925_/X }
C {devices/lab_pin.sym} 108340 -23250 0 0 {name=p107639 lab=_85440_/Q }
C {devices/lab_pin.sym} 108340 -23210 0 0 {name=p107640 lab=_59011_/X }
C {devices/lab_pin.sym} 108500 -23250 0 1 {name=p107641 lab=_59012_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -23250 0 0 {name=X_59012_ }
C {devices/lab_pin.sym} 108340 -23130 0 0 {name=p107642 lab=_56070_/X }
C {devices/lab_pin.sym} 108340 -23090 0 0 {name=p107643 lab=_56210_/X }
C {devices/lab_pin.sym} 108340 -23050 0 0 {name=p107644 lab=_56223_/Y }
C {devices/lab_pin.sym} 108500 -23090 0 1 {name=p107645 lab=_56224_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -23090 0 0 {name=X_56224_ }
C {devices/lab_pin.sym} 108330 -22950 0 0 {name=p107646 lab=_88326_/CLK }
C {devices/lab_pin.sym} 108330 -22930 0 0 {name=p107647 lab=_87044_/D }
C {devices/lab_pin.sym} 108510 -22950 0 1 {name=p107648 lab=_87044_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -22940 0 0 {name=X_87044_ }
C {devices/lab_pin.sym} 108380 -22810 0 0 {name=p107649 lab=_51822_/A }
C {devices/lab_pin.sym} 108460 -22810 0 1 {name=p107650 lab=_53436_/X }
C {sky130_stdcells/buf_2.sym} 108420 -22810 0 0 {name=X_53436_ }
C {devices/lab_pin.sym} 108380 -22690 0 0 {name=p107651 lab=_40947_/A }
C {devices/lab_pin.sym} 108460 -22690 0 1 {name=p107652 lab=_41482_/A }
C {sky130_stdcells/buf_2.sym} 108420 -22690 0 0 {name=X_41450_ }
C {devices/lab_pin.sym} 108380 -22570 0 0 {name=p107653 lab=_44171_/X }
C {devices/lab_pin.sym} 108460 -22570 0 1 {name=p107654 lab=_72270_/X }
C {sky130_stdcells/buf_2.sym} 108420 -22570 0 0 {name=X_72270_ }
C {devices/lab_pin.sym} 108330 -22450 0 0 {name=p107655 lab=_83766_/CLK }
C {devices/lab_pin.sym} 108330 -22430 0 0 {name=p107656 lab=_84256_/D }
C {devices/lab_pin.sym} 108510 -22450 0 1 {name=p107657 lab=_79784_/B }
C {sky130_stdcells/dfxtp_4.sym} 108420 -22440 0 0 {name=X_84256_ }
C {devices/lab_pin.sym} 108340 -22330 0 0 {name=p107658 lab=_50643_/Y }
C {devices/lab_pin.sym} 108340 -22290 0 0 {name=p107659 lab=_50644_/X }
C {devices/lab_pin.sym} 108340 -22250 0 0 {name=p107660 lab=_50647_/Y }
C {devices/lab_pin.sym} 108500 -22290 0 1 {name=p107661 lab=_50648_/Y }
C {sky130_stdcells/a21boi_4.sym} 108420 -22290 0 0 {name=X_50648_ }
C {devices/lab_pin.sym} 108330 -22150 0 0 {name=p107662 lab=_84064_/CLK }
C {devices/lab_pin.sym} 108330 -22130 0 0 {name=p107663 lab=_81468_/D }
C {devices/lab_pin.sym} 108510 -22150 0 1 {name=p107664 lab=_81468_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -22140 0 0 {name=X_81468_ }
C {devices/lab_pin.sym} 108380 -22010 0 0 {name=p107665 lab=clkbuf_9_178_0_CLK/X }
C {devices/lab_pin.sym} 108460 -22010 0 1 {name=p107666 lab=_84766_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 108420 -22010 0 0 {name=Xclkbuf_10_357_0_CLK }
C {devices/lab_pin.sym} 108340 -21920 0 0 {name=p107667 lab=_40400_/X }
C {devices/lab_pin.sym} 108340 -21880 0 0 {name=p107668 lab=_40342_/X }
C {devices/lab_pin.sym} 108340 -21840 0 0 {name=p107669 lab=_88397_/Q }
C {devices/lab_pin.sym} 108340 -21800 0 0 {name=p107670 lab=_40355_/X }
C {devices/lab_pin.sym} 108500 -21860 0 1 {name=p107671 lab=_88397_/D }
C {sky130_stdcells/a2bb2o_4.sym} 108420 -21860 0 0 {name=X_40401_ }
C {devices/lab_pin.sym} 108380 -21710 0 0 {name=p107672 lab=_71221_/A }
C {devices/lab_pin.sym} 108460 -21710 0 1 {name=p107673 lab=_71232_/A }
C {sky130_stdcells/buf_2.sym} 108420 -21710 0 0 {name=X_71221_ }
C {devices/lab_pin.sym} 108330 -21590 0 0 {name=p107674 lab=_83843_/CLK }
C {devices/lab_pin.sym} 108330 -21570 0 0 {name=p107675 lab=_83207_/D }
C {devices/lab_pin.sym} 108510 -21590 0 1 {name=p107676 lab=_70178_/C }
C {sky130_stdcells/dfxtp_4.sym} 108420 -21580 0 0 {name=X_83207_ }
C {devices/lab_pin.sym} 108360 -21460 0 0 {name=p107677 lab=_84757_/Q }
C {devices/lab_pin.sym} 108360 -21420 0 0 {name=p107678 lab=_80419_/B }
C {devices/lab_pin.sym} 108480 -21440 0 1 {name=p107679 lab=_80419_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -21440 0 0 {name=X_80419_ }
C {devices/lab_pin.sym} 108340 -21330 0 0 {name=p107680 lab=_56142_/X }
C {devices/lab_pin.sym} 108340 -21290 0 0 {name=p107681 lab=_56153_/X }
C {devices/lab_pin.sym} 108340 -21250 0 0 {name=p107682 lab=_56154_/Y }
C {devices/lab_pin.sym} 108500 -21290 0 1 {name=p107683 lab=_85286_/D }
C {sky130_stdcells/o21ai_4.sym} 108420 -21290 0 0 {name=X_56155_ }
C {devices/lab_pin.sym} 108340 -21170 0 0 {name=p107684 lab=_41373_/X }
C {devices/lab_pin.sym} 108340 -21130 0 0 {name=p107685 lab=_41725_/A }
C {devices/lab_pin.sym} 108340 -21090 0 0 {name=p107686 lab=_41380_/X }
C {devices/lab_pin.sym} 108500 -21130 0 1 {name=p107687 lab=_41381_/X }
C {sky130_stdcells/o21a_4.sym} 108420 -21130 0 0 {name=X_41381_ }
C {devices/lab_pin.sym} 108360 -21020 0 0 {name=p107688 lab=_53371_/A }
C {devices/lab_pin.sym} 108360 -20980 0 0 {name=p107689 lab=_53371_/B }
C {devices/lab_pin.sym} 108360 -20940 0 0 {name=p107690 lab=_53371_/C }
C {devices/lab_pin.sym} 108360 -20900 0 0 {name=p107691 lab=_52853_/D }
C {devices/lab_pin.sym} 108480 -20960 0 1 {name=p107692 lab=_53367_/X }
C {sky130_stdcells/and4_4.sym} 108420 -20960 0 0 {name=X_53367_ }
C {devices/lab_pin.sym} 108380 -20810 0 0 {name=p107693 lab=clkbuf_9_493_0_CLK/X }
C {devices/lab_pin.sym} 108460 -20810 0 1 {name=p107694 lab=_83305_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 108420 -20810 0 0 {name=Xclkbuf_10_987_0_CLK }
C {devices/lab_pin.sym} 108330 -20690 0 0 {name=p107695 lab=_84187_/CLK }
C {devices/lab_pin.sym} 108330 -20670 0 0 {name=p107696 lab=_84187_/D }
C {devices/lab_pin.sym} 108510 -20690 0 1 {name=p107697 lab=_84187_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -20680 0 0 {name=X_84187_ }
C {devices/lab_pin.sym} 108380 -20550 0 0 {name=p107698 lab=_50578_/X }
C {devices/lab_pin.sym} 108460 -20550 0 1 {name=p107699 lab=_71974_/B }
C {sky130_stdcells/buf_2.sym} 108420 -20550 0 0 {name=X_50579_ }
C {devices/lab_pin.sym} 108330 -20430 0 0 {name=p107700 lab=_81351_/CLK }
C {devices/lab_pin.sym} 108330 -20410 0 0 {name=p107701 lab=_83935_/Q }
C {devices/lab_pin.sym} 108510 -20430 0 1 {name=p107702 lab=_76690_/B }
C {sky130_stdcells/dfxtp_4.sym} 108420 -20420 0 0 {name=X_81399_ }
C {devices/lab_pin.sym} 108340 -20330 0 0 {name=p107703 lab=_43105_/X }
C {devices/lab_pin.sym} 108340 -20290 0 0 {name=p107704 lab=_43106_/X }
C {devices/lab_pin.sym} 108340 -20250 0 0 {name=p107705 lab=_40781_/X }
C {devices/lab_pin.sym} 108340 -20210 0 0 {name=p107706 lab=_43119_/Y }
C {devices/lab_pin.sym} 108340 -20170 0 0 {name=p107707 lab=_43108_/X }
C {devices/lab_pin.sym} 108500 -20250 0 1 {name=p107708 lab=_43120_/Y }
C {sky130_stdcells/o32ai_4.sym} 108420 -20250 0 0 {name=X_43120_ }
C {devices/lab_pin.sym} 108360 -20100 0 0 {name=p107709 lab=_55118_/A }
C {devices/lab_pin.sym} 108360 -20060 0 0 {name=p107710 lab=_47788_/A }
C {devices/lab_pin.sym} 108480 -20080 0 1 {name=p107711 lab=_55106_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -20080 0 0 {name=X_55106_ }
C {devices/lab_pin.sym} 108380 -19950 0 0 {name=p107712 lab=_41863_/A }
C {devices/lab_pin.sym} 108460 -19950 0 1 {name=p107713 lab=_40332_/Y }
C {sky130_stdcells/inv_2.sym} 108420 -19950 0 0 {name=X_40332_ }
C {devices/lab_pin.sym} 108340 -19850 0 0 {name=p107714 lab=_64904_/B }
C {devices/lab_pin.sym} 108340 -19810 0 0 {name=p107715 lab=_52297_/X }
C {devices/lab_pin.sym} 108340 -19770 0 0 {name=p107716 lab=_52317_/Y }
C {devices/lab_pin.sym} 108500 -19810 0 1 {name=p107717 lab=_52318_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -19810 0 0 {name=X_52318_ }
C {devices/lab_pin.sym} 108360 -19700 0 0 {name=p107718 lab=_71178_/A }
C {devices/lab_pin.sym} 108360 -19660 0 0 {name=p107719 lab=_71155_/B }
C {devices/lab_pin.sym} 108360 -19620 0 0 {name=p107720 lab=_71152_/C }
C {devices/lab_pin.sym} 108360 -19580 0 0 {name=p107721 lab=_71160_/D }
C {devices/lab_pin.sym} 108480 -19640 0 1 {name=p107722 lab=_71152_/Y }
C {sky130_stdcells/nand4_4.sym} 108420 -19640 0 0 {name=X_71152_ }
C {devices/lab_pin.sym} 108330 -19490 0 0 {name=p107723 lab=_83141_/CLK }
C {devices/lab_pin.sym} 108330 -19470 0 0 {name=p107724 lab=_73749_/Y }
C {devices/lab_pin.sym} 108510 -19490 0 1 {name=p107725 lab=_83138_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -19480 0 0 {name=X_83138_ }
C {devices/lab_pin.sym} 108360 -19370 0 0 {name=p107726 lab=_56100_/A }
C {devices/lab_pin.sym} 108360 -19330 0 0 {name=p107727 lab=_56086_/B }
C {devices/lab_pin.sym} 108360 -19290 0 0 {name=p107728 lab=_55851_/B }
C {devices/lab_pin.sym} 108480 -19330 0 1 {name=p107729 lab=_56086_/Y }
C {sky130_stdcells/nand3_4.sym} 108420 -19330 0 0 {name=X_56086_ }
C {devices/lab_pin.sym} 108380 -19190 0 0 {name=p107730 lab=clkbuf_9_479_0_CLK/A }
C {devices/lab_pin.sym} 108460 -19190 0 1 {name=p107731 lab=clkbuf_9_478_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 108420 -19190 0 0 {name=Xclkbuf_9_478_0_CLK }
C {devices/lab_pin.sym} 108360 -19080 0 0 {name=p107732 lab=_53298_/A }
C {devices/lab_pin.sym} 108360 -19040 0 0 {name=p107733 lab=_54473_/B }
C {devices/lab_pin.sym} 108480 -19060 0 1 {name=p107734 lab=_53298_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -19060 0 0 {name=X_53298_ }
C {devices/lab_pin.sym} 108380 -18930 0 0 {name=p107735 lab=_70103_/A }
C {devices/lab_pin.sym} 108460 -18930 0 1 {name=p107736 lab=_70107_/A }
C {sky130_stdcells/inv_2.sym} 108420 -18930 0 0 {name=X_70103_ }
C {devices/lab_pin.sym} 108340 -18850 0 0 {name=p107737 lab=_43038_/X }
C {devices/lab_pin.sym} 108340 -18810 0 0 {name=p107738 lab=_43050_/X }
C {devices/lab_pin.sym} 108340 -18770 0 0 {name=p107739 lab=_40641_/X }
C {devices/lab_pin.sym} 108340 -18730 0 0 {name=p107740 lab=_73773_/A }
C {devices/lab_pin.sym} 108340 -18690 0 0 {name=p107741 lab=_43025_/X }
C {devices/lab_pin.sym} 108500 -18770 0 1 {name=p107742 lab=_43052_/A }
C {sky130_stdcells/o32ai_4.sym} 108420 -18770 0 0 {name=X_43051_ }
C {devices/lab_pin.sym} 108380 -18610 0 0 {name=p107743 lab=_59552_/B }
C {devices/lab_pin.sym} 108460 -18610 0 1 {name=p107744 lab=_61293_/B }
C {sky130_stdcells/buf_2.sym} 108420 -18610 0 0 {name=X_59914_ }
C {devices/lab_pin.sym} 108360 -18500 0 0 {name=p107745 lab=_55037_/A }
C {devices/lab_pin.sym} 108360 -18460 0 0 {name=p107746 lab=_54871_/B }
C {devices/lab_pin.sym} 108480 -18480 0 1 {name=p107747 lab=_55037_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -18480 0 0 {name=X_55037_ }
C {devices/lab_pin.sym} 108340 -18370 0 0 {name=p107748 lab=_52246_/Y }
C {devices/lab_pin.sym} 108340 -18330 0 0 {name=p107749 lab=_52232_/X }
C {devices/lab_pin.sym} 108340 -18290 0 0 {name=p107750 lab=_52248_/X }
C {devices/lab_pin.sym} 108500 -18330 0 1 {name=p107751 lab=_85860_/D }
C {sky130_stdcells/a21oi_4.sym} 108420 -18330 0 0 {name=X_52249_ }
C {devices/lab_pin.sym} 108340 -18210 0 0 {name=p107752 lab=_49006_/X }
C {devices/lab_pin.sym} 108340 -18170 0 0 {name=p107753 lab=_71070_/X }
C {devices/lab_pin.sym} 108340 -18130 0 0 {name=p107754 lab=_71082_/Y }
C {devices/lab_pin.sym} 108500 -18170 0 1 {name=p107755 lab=_71083_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -18170 0 0 {name=X_71083_ }
C {devices/lab_pin.sym} 108330 -18030 0 0 {name=p107756 lab=_83572_/CLK }
C {devices/lab_pin.sym} 108330 -18010 0 0 {name=p107757 lab=_74427_/Y }
C {devices/lab_pin.sym} 108510 -18030 0 1 {name=p107758 lab=_83069_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -18020 0 0 {name=X_83069_ }
C {devices/lab_pin.sym} 108360 -17900 0 0 {name=p107759 lab=_81704_/D }
C {devices/lab_pin.sym} 108360 -17860 0 0 {name=p107760 lab=_75968_/B }
C {devices/lab_pin.sym} 108480 -17880 0 1 {name=p107761 lab=_75961_/A }
C {sky130_stdcells/xor2_4.sym} 108420 -17880 0 0 {name=X_75960_ }
C {devices/lab_pin.sym} 108330 -17750 0 0 {name=p107762 lab=_87950_/CLK }
C {devices/lab_pin.sym} 108330 -17730 0 0 {name=p107763 lab=_87946_/D }
C {devices/lab_pin.sym} 108510 -17750 0 1 {name=p107764 lab=_87946_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -17740 0 0 {name=X_87946_ }
C {devices/lab_pin.sym} 108380 -17610 0 0 {name=p107765 lab=clkbuf_9_455_0_CLK/X }
C {devices/lab_pin.sym} 108460 -17610 0 1 {name=p107766 lab=_88104_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 108420 -17610 0 0 {name=Xclkbuf_10_910_0_CLK }
C {devices/lab_pin.sym} 108380 -17490 0 0 {name=p107767 lab=_42002_/A }
C {devices/lab_pin.sym} 108460 -17490 0 1 {name=p107768 lab=_42002_/Y }
C {sky130_stdcells/inv_2.sym} 108420 -17490 0 0 {name=X_42002_ }
C {devices/lab_pin.sym} 108360 -17380 0 0 {name=p107769 lab=_80939_/Q }
C {devices/lab_pin.sym} 108360 -17340 0 0 {name=p107770 lab=_74911_/B }
C {devices/lab_pin.sym} 108480 -17360 0 1 {name=p107771 lab=_81188_/D }
C {sky130_stdcells/xor2_4.sym} 108420 -17360 0 0 {name=X_74911_ }
C {devices/lab_pin.sym} 108340 -17250 0 0 {name=p107772 lab=_68734_/X }
C {devices/lab_pin.sym} 108340 -17210 0 0 {name=p107773 lab=_68736_/X }
C {devices/lab_pin.sym} 108340 -17170 0 0 {name=p107774 lab=_70005_/X }
C {devices/lab_pin.sym} 108500 -17210 0 1 {name=p107775 lab=_70034_/Y }
C {sky130_stdcells/a21oi_4.sym} 108420 -17210 0 0 {name=X_70034_ }
C {devices/lab_pin.sym} 108380 -17070 0 0 {name=p107776 lab=_59801_/A }
C {devices/lab_pin.sym} 108460 -17070 0 1 {name=p107777 lab=_60781_/A }
C {sky130_stdcells/buf_2.sym} 108420 -17070 0 0 {name=X_59845_ }
C {devices/lab_pin.sym} 108380 -16950 0 0 {name=p107778 lab=_75891_/A }
C {devices/lab_pin.sym} 108460 -16950 0 1 {name=p107779 lab=_80773_/D }
C {sky130_stdcells/inv_2.sym} 108420 -16950 0 0 {name=X_75891_ }
C {devices/lab_pin.sym} 108330 -16830 0 0 {name=p107780 lab=_87883_/CLK }
C {devices/lab_pin.sym} 108330 -16810 0 0 {name=p107781 lab=_87877_/D }
C {devices/lab_pin.sym} 108510 -16830 0 1 {name=p107782 lab=_87877_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -16820 0 0 {name=X_87877_ }
C {devices/lab_pin.sym} 108380 -16690 0 0 {name=p107783 lab=clkbuf_8_200_0_CLK/X }
C {devices/lab_pin.sym} 108460 -16690 0 1 {name=p107784 lab=clkbuf_9_401_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 108420 -16690 0 0 {name=Xclkbuf_9_401_0_CLK }
C {devices/lab_pin.sym} 108380 -16570 0 0 {name=p107785 lab=_46809_/Y }
C {devices/lab_pin.sym} 108460 -16570 0 1 {name=p107786 lab=_46810_/X }
C {sky130_stdcells/buf_2.sym} 108420 -16570 0 0 {name=X_46810_ }
C {devices/lab_pin.sym} 108380 -16450 0 0 {name=p107787 lab=_84914_/CLK }
C {devices/lab_pin.sym} 108460 -16450 0 1 {name=p107788 lab=_84885_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 108420 -16450 0 0 {name=Xclkbuf_opt_11_CLK }
C {devices/lab_pin.sym} 108360 -16340 0 0 {name=p107789 lab=_77630_/A }
C {devices/lab_pin.sym} 108360 -16300 0 0 {name=p107790 lab=_82109_/D }
C {devices/lab_pin.sym} 108480 -16320 0 1 {name=p107791 lab=_77633_/B }
C {sky130_stdcells/nor2_4.sym} 108420 -16320 0 0 {name=X_77630_ }
C {devices/lab_pin.sym} 108360 -16210 0 0 {name=p107792 lab=_46183_/X }
C {devices/lab_pin.sym} 108360 -16170 0 0 {name=p107793 lab=_74842_/B }
C {devices/lab_pin.sym} 108360 -16130 0 0 {name=p107794 lab=_46184_/Y }
C {devices/lab_pin.sym} 108480 -16170 0 1 {name=p107795 lab=_80672_/D }
C {sky130_stdcells/and3_4.sym} 108420 -16170 0 0 {name=X_74842_ }
C {devices/lab_pin.sym} 108330 -16030 0 0 {name=p107796 lab=_86824_/CLK }
C {devices/lab_pin.sym} 108330 -16010 0 0 {name=p107797 lab=_45984_/Y }
C {devices/lab_pin.sym} 108510 -16030 0 1 {name=p107798 lab=_66810_/B }
C {sky130_stdcells/dfxtp_4.sym} 108420 -16020 0 0 {name=X_86828_ }
C {devices/lab_pin.sym} 108340 -15910 0 0 {name=p107799 lab=_72447_/A }
C {devices/lab_pin.sym} 108340 -15870 0 0 {name=p107800 lab=_47760_/X }
C {devices/lab_pin.sym} 108340 -15830 0 0 {name=p107801 lab=_47789_/Y }
C {devices/lab_pin.sym} 108500 -15870 0 1 {name=p107802 lab=_47790_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -15870 0 0 {name=X_47790_ }
C {devices/lab_pin.sym} 108380 -15730 0 0 {name=p107803 lab=_59770_/A }
C {devices/lab_pin.sym} 108460 -15730 0 1 {name=p107804 lab=_72176_/A }
C {sky130_stdcells/buf_2.sym} 108420 -15730 0 0 {name=X_59776_ }
C {devices/lab_pin.sym} 108340 -15630 0 0 {name=p107805 lab=_56982_/X }
C {devices/lab_pin.sym} 108340 -15590 0 0 {name=p107806 lab=_56986_/X }
C {devices/lab_pin.sym} 108340 -15550 0 0 {name=p107807 lab=_56987_/Y }
C {devices/lab_pin.sym} 108500 -15590 0 1 {name=p107808 lab=_56988_/Y }
C {sky130_stdcells/a21oi_4.sym} 108420 -15590 0 0 {name=X_56988_ }
C {devices/lab_pin.sym} 108360 -15460 0 0 {name=p107809 lab=_46733_/A }
C {devices/lab_pin.sym} 108360 -15420 0 0 {name=p107810 lab=_46740_/X }
C {devices/lab_pin.sym} 108480 -15440 0 1 {name=p107811 lab=_46741_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -15440 0 0 {name=X_46741_ }
C {devices/lab_pin.sym} 108360 -15320 0 0 {name=p107812 lab=_58727_/A }
C {devices/lab_pin.sym} 108360 -15280 0 0 {name=p107813 lab=_58688_/B }
C {devices/lab_pin.sym} 108480 -15300 0 1 {name=p107814 lab=_58727_/Y }
C {sky130_stdcells/nor2_4.sym} 108420 -15300 0 0 {name=X_58727_ }
C {devices/lab_pin.sym} 108360 -15200 0 0 {name=p107815 lab=_77561_/A }
C {devices/lab_pin.sym} 108360 -15160 0 0 {name=p107816 lab=_77561_/B }
C {devices/lab_pin.sym} 108360 -15120 0 0 {name=p107817 lab=_77561_/C }
C {devices/lab_pin.sym} 108360 -15080 0 0 {name=p107818 lab=_77561_/D }
C {devices/lab_pin.sym} 108480 -15140 0 1 {name=p107819 lab=_77561_/X }
C {sky130_stdcells/and4_4.sym} 108420 -15140 0 0 {name=X_77561_ }
C {devices/lab_pin.sym} 108340 -15010 0 0 {name=p107820 lab=_43949_/X }
C {devices/lab_pin.sym} 108340 -14970 0 0 {name=p107821 lab=_43952_/X }
C {devices/lab_pin.sym} 108340 -14930 0 0 {name=p107822 lab=_80669_/Q }
C {devices/lab_pin.sym} 108500 -14970 0 1 {name=p107823 lab=_43959_/A }
C {sky130_stdcells/a21o_4.sym} 108420 -14970 0 0 {name=X_43953_ }
C {devices/lab_pin.sym} 108340 -14860 0 0 {name=p107824 lab=_56206_/C }
C {devices/lab_pin.sym} 108340 -14820 0 0 {name=p107825 lab=_55605_/X }
C {devices/lab_pin.sym} 108340 -14780 0 0 {name=p107826 lab=_44090_/B }
C {devices/lab_pin.sym} 108340 -14740 0 0 {name=p107827 lab=_55938_/X }
C {devices/lab_pin.sym} 108500 -14800 0 1 {name=p107828 lab=_55939_/X }
C {sky130_stdcells/a211o_4.sym} 108420 -14800 0 0 {name=X_55939_ }
C {devices/lab_pin.sym} 108380 -14650 0 0 {name=p107829 lab=clkbuf_9_462_0_CLK/X }
C {devices/lab_pin.sym} 108460 -14650 0 1 {name=p107830 lab=_83544_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 108420 -14650 0 0 {name=Xclkbuf_10_925_0_CLK }
C {devices/lab_pin.sym} 108360 -14560 0 0 {name=p107831 lab=_74753_/X }
C {devices/lab_pin.sym} 108360 -14520 0 0 {name=p107832 lab=_70637_/A }
C {devices/lab_pin.sym} 108360 -14480 0 0 {name=p107833 lab=_74773_/C }
C {devices/lab_pin.sym} 108360 -14440 0 0 {name=p107834 lab=_74739_/B }
C {devices/lab_pin.sym} 108480 -14500 0 1 {name=p107835 lab=_74773_/X }
C {sky130_stdcells/and4_4.sym} 108420 -14500 0 0 {name=X_74773_ }
C {devices/lab_pin.sym} 108330 -14350 0 0 {name=p107836 lab=_80854_/CLK }
C {devices/lab_pin.sym} 108330 -14330 0 0 {name=p107837 lab=_46220_/Y }
C {devices/lab_pin.sym} 108510 -14350 0 1 {name=p107838 lab=_44174_/A }
C {sky130_stdcells/dfxtp_4.sym} 108420 -14340 0 0 {name=X_86759_ }
C {devices/lab_pin.sym} 108380 -14210 0 0 {name=p107839 lab=_71985_/A }
C {devices/lab_pin.sym} 108460 -14210 0 1 {name=p107840 lab=_71985_/X }
C {sky130_stdcells/buf_2.sym} 108420 -14210 0 0 {name=X_71985_ }
C {devices/lab_pin.sym} 108360 -14100 0 0 {name=p107841 lab=_84797_/Q }
C {devices/lab_pin.sym} 108360 -14060 0 0 {name=p107842 lab=_66469_/C }
C {devices/lab_pin.sym} 108480 -14080 0 1 {name=p107843 lab=_79302_/A }
C {sky130_stdcells/xor2_4.sym} 108420 -14080 0 0 {name=X_79300_ }
C {devices/lab_pin.sym} 108380 -13950 0 0 {name=p107844 lab=_76511_/X }
C {devices/lab_pin.sym} 108460 -13950 0 1 {name=p107845 lab=_76517_/A }
C {sky130_stdcells/buf_2.sym} 108420 -13950 0 0 {name=X_76512_ }
C {devices/lab_pin.sym} 108380 -13830 0 0 {name=p107846 lab=_42903_/Y }
C {devices/lab_pin.sym} 108460 -13830 0 1 {name=p107847 lab=_87660_/D }
C {sky130_stdcells/inv_2.sym} 108420 -13830 0 0 {name=X_42904_ }
C {devices/lab_pin.sym} 108380 -13710 0 0 {name=p107848 lab=_49434_/A }
C {devices/lab_pin.sym} 108460 -13710 0 1 {name=p107849 lab=_49460_/X }
C {sky130_stdcells/buf_2.sym} 108420 -13710 0 0 {name=X_49460_ }
C {devices/lab_pin.sym} 108340 -13620 0 0 {name=p107850 lab=_42475_/Y }
C {devices/lab_pin.sym} 108340 -13580 0 0 {name=p107851 lab=_73674_/X }
C {devices/lab_pin.sym} 108340 -13540 0 0 {name=p107852 lab=_73698_/X }
C {devices/lab_pin.sym} 108340 -13500 0 0 {name=p107853 lab=_73723_/Y }
C {devices/lab_pin.sym} 108500 -13560 0 1 {name=p107854 lab=_73724_/X }
C {sky130_stdcells/a211o_4.sym} 108420 -13560 0 0 {name=X_73724_ }
C {devices/lab_pin.sym} 108380 -13410 0 0 {name=p107855 lab=_46719_/A }
C {devices/lab_pin.sym} 108460 -13410 0 1 {name=p107856 lab=_46672_/X }
C {sky130_stdcells/buf_2.sym} 108420 -13410 0 0 {name=X_46672_ }
C {devices/lab_pin.sym} 108340 -13310 0 0 {name=p107857 lab=_58655_/Y }
C {devices/lab_pin.sym} 108340 -13270 0 0 {name=p107858 lab=_58657_/Y }
C {devices/lab_pin.sym} 108340 -13230 0 0 {name=p107859 lab=_58646_/X }
C {devices/lab_pin.sym} 108500 -13270 0 1 {name=p107860 lab=_58658_/X }
C {sky130_stdcells/a21o_4.sym} 108420 -13270 0 0 {name=X_58658_ }
C {devices/lab_pin.sym} 108380 -13130 0 0 {name=p107861 lab=_70935_/X }
C {devices/lab_pin.sym} 108460 -13130 0 1 {name=p107862 lab=_70936_/X }
C {sky130_stdcells/buf_2.sym} 108420 -13130 0 0 {name=X_70936_ }
C {devices/lab_pin.sym} 108340 -13030 0 0 {name=p107863 lab=_77473_/Y }
C {devices/lab_pin.sym} 108340 -12990 0 0 {name=p107864 lab=_77475_/A }
C {devices/lab_pin.sym} 108340 -12950 0 0 {name=p107865 lab=_77472_/A }
C {devices/lab_pin.sym} 108500 -12990 0 1 {name=p107866 lab=_77493_/A }
C {sky130_stdcells/o21a_4.sym} 108420 -12990 0 0 {name=X_77492_ }
C {devices/lab_pin.sym} 108340 -12880 0 0 {name=p107867 lab=_41298_/X }
C {devices/lab_pin.sym} 108340 -12840 0 0 {name=p107868 lab=_43879_/X }
C {devices/lab_pin.sym} 108340 -12800 0 0 {name=p107869 lab=_67395_/B }
C {devices/lab_pin.sym} 108340 -12760 0 0 {name=p107870 lab=_43880_/X }
C {devices/lab_pin.sym} 108500 -12820 0 1 {name=p107871 lab=_87217_/D }
C {sky130_stdcells/a2bb2o_4.sym} 108420 -12820 0 0 {name=X_43884_ }
C {devices/lab_pin.sym} 108380 -12670 0 0 {name=p107872 lab=clkbuf_8_208_0_CLK/X }
C {devices/lab_pin.sym} 108460 -12670 0 1 {name=p107873 lab=clkbuf_9_416_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 108420 -12670 0 0 {name=Xclkbuf_9_416_0_CLK }
C {devices/lab_pin.sym} 108380 -12550 0 0 {name=p107874 lab=_74389_/B }
C {devices/lab_pin.sym} 108460 -12550 0 1 {name=p107875 lab=_52121_/B }
C {sky130_stdcells/buf_2.sym} 108420 -12550 0 0 {name=X_48411_ }
C {devices/lab_pin.sym} 108360 -12440 0 0 {name=p107876 lab=_79231_/A }
C {devices/lab_pin.sym} 108360 -12400 0 0 {name=p107877 lab=_79231_/B }
C {devices/lab_pin.sym} 108480 -12420 0 1 {name=p107878 lab=_79232_/B }
C {sky130_stdcells/xnor2_4.sym} 108420 -12420 0 0 {name=X_79231_ }
C {devices/lab_pin.sym} 108360 -12300 0 0 {name=p107879 lab=_57608_/X }
C {devices/lab_pin.sym} 108360 -12260 0 0 {name=p107880 lab=_57609_/B }
C {devices/lab_pin.sym} 108480 -12280 0 1 {name=p107881 lab=_57609_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -12280 0 0 {name=X_57609_ }
C {devices/lab_pin.sym} 108380 -12150 0 0 {name=p107882 lab=_63168_/B }
C {devices/lab_pin.sym} 108460 -12150 0 1 {name=p107883 lab=_61502_/A }
C {sky130_stdcells/buf_2.sym} 108420 -12150 0 0 {name=X_45623_ }
C {devices/lab_pin.sym} 108380 -12030 0 0 {name=p107884 lab=_76443_/A }
C {devices/lab_pin.sym} 108460 -12030 0 1 {name=p107885 lab=_76443_/Y }
C {sky130_stdcells/inv_2.sym} 108420 -12030 0 0 {name=X_76443_ }
C {devices/lab_pin.sym} 108380 -11910 0 0 {name=p107886 lab=_42579_/A }
C {devices/lab_pin.sym} 108460 -11910 0 1 {name=p107887 lab=_42835_/X }
C {sky130_stdcells/buf_2.sym} 108420 -11910 0 0 {name=X_42835_ }
C {devices/lab_pin.sym} 108340 -11810 0 0 {name=p107888 lab=_58633_/B }
C {devices/lab_pin.sym} 108340 -11770 0 0 {name=p107889 lab=_49388_/X }
C {devices/lab_pin.sym} 108340 -11730 0 0 {name=p107890 lab=_49390_/Y }
C {devices/lab_pin.sym} 108500 -11770 0 1 {name=p107891 lab=_49391_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -11770 0 0 {name=X_49391_ }
C {devices/lab_pin.sym} 108340 -11650 0 0 {name=p107892 lab=_73651_/X }
C {devices/lab_pin.sym} 108340 -11610 0 0 {name=p107893 lab=_73654_/X }
C {devices/lab_pin.sym} 108340 -11570 0 0 {name=p107894 lab=_56549_/X }
C {devices/lab_pin.sym} 108500 -11610 0 1 {name=p107895 lab=_73655_/X }
C {sky130_stdcells/a21o_4.sym} 108420 -11610 0 0 {name=X_73655_ }
C {devices/lab_pin.sym} 108360 -11500 0 0 {name=p107896 lab=_70867_/A }
C {devices/lab_pin.sym} 108360 -11460 0 0 {name=p107897 lab=_70869_/B }
C {devices/lab_pin.sym} 108360 -11420 0 0 {name=p107898 lab=_70869_/C }
C {devices/lab_pin.sym} 108360 -11380 0 0 {name=p107899 lab=_70869_/D }
C {devices/lab_pin.sym} 108480 -11440 0 1 {name=p107900 lab=_70867_/Y }
C {sky130_stdcells/nand4_4.sym} 108420 -11440 0 0 {name=X_70867_ }
C {devices/lab_pin.sym} 108380 -11290 0 0 {name=p107901 lab=_58701_/A }
C {devices/lab_pin.sym} 108460 -11290 0 1 {name=p107902 lab=_58589_/X }
C {sky130_stdcells/buf_2.sym} 108420 -11290 0 0 {name=X_58589_ }
C {devices/lab_pin.sym} 108380 -11170 0 0 {name=p107903 lab=_48342_/A }
C {devices/lab_pin.sym} 108460 -11170 0 1 {name=p107904 lab=_50381_/B }
C {sky130_stdcells/buf_2.sym} 108420 -11170 0 0 {name=X_48342_ }
C {devices/lab_pin.sym} 108360 -11070 0 0 {name=p107905 lab=_60353_/B }
C {devices/lab_pin.sym} 108360 -11030 0 0 {name=p107906 lab=_60620_/B }
C {devices/lab_pin.sym} 108360 -10990 0 0 {name=p107907 lab=_60620_/C }
C {devices/lab_pin.sym} 108480 -11030 0 1 {name=p107908 lab=_60620_/Y }
C {sky130_stdcells/nand3_4.sym} 108420 -11030 0 0 {name=X_60620_ }
C {devices/lab_pin.sym} 108340 -10910 0 0 {name=p107909 lab=_72579_/A }
C {devices/lab_pin.sym} 108340 -10870 0 0 {name=p107910 lab=_72510_/C }
C {devices/lab_pin.sym} 108340 -10830 0 0 {name=p107911 lab=_59846_/X }
C {devices/lab_pin.sym} 108500 -10870 0 1 {name=p107912 lab=_72606_/X }
C {sky130_stdcells/a21o_4.sym} 108420 -10870 0 0 {name=X_72606_ }
C {devices/lab_pin.sym} 108360 -10740 0 0 {name=p107913 lab=_84786_/Q }
C {devices/lab_pin.sym} 108360 -10700 0 0 {name=p107914 lab=_66524_/C }
C {devices/lab_pin.sym} 108480 -10720 0 1 {name=p107915 lab=_79524_/A }
C {sky130_stdcells/or2_4.sym} 108420 -10720 0 0 {name=X_79162_ }
C {devices/lab_pin.sym} 108340 -10620 0 0 {name=p107916 lab=_45551_/Y }
C {devices/lab_pin.sym} 108340 -10580 0 0 {name=p107917 lab=_45489_/X }
C {devices/lab_pin.sym} 108340 -10540 0 0 {name=p107918 lab=_45520_/X }
C {devices/lab_pin.sym} 108340 -10500 0 0 {name=p107919 lab=_45553_/Y }
C {devices/lab_pin.sym} 108500 -10560 0 1 {name=p107920 lab=_45554_/X }
C {sky130_stdcells/a211o_4.sym} 108420 -10560 0 0 {name=X_45554_ }
C {devices/lab_pin.sym} 108360 -10420 0 0 {name=p107921 lab=_76381_/A }
C {devices/lab_pin.sym} 108360 -10380 0 0 {name=p107922 lab=_76373_/X }
C {devices/lab_pin.sym} 108480 -10400 0 1 {name=p107923 lab=_81617_/D }
C {sky130_stdcells/xnor2_4.sym} 108420 -10400 0 0 {name=X_76374_ }
C {devices/lab_pin.sym} 108380 -10270 0 0 {name=p107924 lab=clkbuf_6_1_0_CLK/A }
C {devices/lab_pin.sym} 108460 -10270 0 1 {name=p107925 lab=clkbuf_7_3_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 108420 -10270 0 0 {name=Xclkbuf_6_1_0_CLK }
C {devices/lab_pin.sym} 108340 -10180 0 0 {name=p107926 lab=_41298_/X }
C {devices/lab_pin.sym} 108340 -10140 0 0 {name=p107927 lab=_42757_/X }
C {devices/lab_pin.sym} 108340 -10100 0 0 {name=p107928 lab=_67392_/B }
C {devices/lab_pin.sym} 108340 -10060 0 0 {name=p107929 lab=_42759_/X }
C {devices/lab_pin.sym} 108500 -10120 0 1 {name=p107930 lab=_87729_/D }
C {sky130_stdcells/a2bb2o_4.sym} 108420 -10120 0 0 {name=X_42766_ }
C {devices/lab_pin.sym} 108340 -10000 0 0 {name=p107931 lab=_73449_/X }
C {devices/lab_pin.sym} 108340 -9960 0 0 {name=p107932 lab=_85632_/Q }
C {devices/lab_pin.sym} 108340 -9920 0 0 {name=p107933 lab=_73450_/X }
C {devices/lab_pin.sym} 108340 -9880 0 0 {name=p107934 lab=_73585_/X }
C {devices/lab_pin.sym} 108500 -9940 0 1 {name=p107935 lab=_73586_/X }
C {sky130_stdcells/a211o_4.sym} 108420 -9940 0 0 {name=X_73586_ }
C {devices/lab_pin.sym} 108360 -9820 0 0 {name=p107936 lab=_70356_/Y }
C {devices/lab_pin.sym} 108360 -9780 0 0 {name=p107937 lab=_70423_/X }
C {devices/lab_pin.sym} 108360 -9740 0 0 {name=p107938 lab=_70907_/B }
C {devices/lab_pin.sym} 108360 -9700 0 0 {name=p107939 lab=MACRO_WR_SELECT }
C {devices/lab_pin.sym} 108480 -9760 0 1 {name=p107940 lab=_70798_/X }
C {sky130_stdcells/and4_4.sym} 108420 -9760 0 0 {name=X_70798_ }
C {devices/lab_pin.sym} 108360 -9630 0 0 {name=p107941 lab=_78105_/Y }
C {devices/lab_pin.sym} 108360 -9590 0 0 {name=p107942 lab=_78130_/A }
C {devices/lab_pin.sym} 108360 -9550 0 0 {name=p107943 lab=_78130_/B }
C {devices/lab_pin.sym} 108480 -9590 0 1 {name=p107944 lab=_78120_/A }
C {sky130_stdcells/nand3_4.sym} 108420 -9590 0 0 {name=X_78113_ }
C {devices/lab_pin.sym} 108340 -9480 0 0 {name=p107945 lab=_41264_/A }
C {devices/lab_pin.sym} 108340 -9440 0 0 {name=p107946 lab=_44502_/X }
C {devices/lab_pin.sym} 108340 -9400 0 0 {name=p107947 lab=_87076_/Q }
C {devices/lab_pin.sym} 108340 -9360 0 0 {name=p107948 lab=_44503_/X }
C {devices/lab_pin.sym} 108500 -9420 0 1 {name=p107949 lab=_44505_/X }
C {sky130_stdcells/a2bb2o_4.sym} 108420 -9420 0 0 {name=X_44505_ }
C {devices/lab_pin.sym} 108360 -9280 0 0 {name=p107950 lab=_75322_/X }
C {devices/lab_pin.sym} 108360 -9240 0 0 {name=p107951 lab=_75324_/Y }
C {devices/lab_pin.sym} 108480 -9260 0 1 {name=p107952 lab=_75325_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -9260 0 0 {name=X_75325_ }
C {devices/lab_pin.sym} 108380 -9130 0 0 {name=p107953 lab=_40421_/X }
C {devices/lab_pin.sym} 108460 -9130 0 1 {name=p107954 lab=_41717_/X }
C {sky130_stdcells/buf_2.sym} 108420 -9130 0 0 {name=X_41717_ }
C {devices/lab_pin.sym} 108380 -9010 0 0 {name=p107955 lab=_48226_/A }
C {devices/lab_pin.sym} 108460 -9010 0 1 {name=p107956 lab=_48273_/X }
C {sky130_stdcells/buf_2.sym} 108420 -9010 0 0 {name=X_48273_ }
C {devices/lab_pin.sym} 108340 -8910 0 0 {name=p107957 lab=_60570_/C }
C {devices/lab_pin.sym} 108340 -8870 0 0 {name=p107958 lab=_60602_/B }
C {devices/lab_pin.sym} 108340 -8830 0 0 {name=p107959 lab=_60267_/A }
C {devices/lab_pin.sym} 108500 -8870 0 1 {name=p107960 lab=_60551_/X }
C {sky130_stdcells/o21a_4.sym} 108420 -8870 0 0 {name=X_60551_ }
C {devices/lab_pin.sym} 108360 -8740 0 0 {name=p107961 lab=_72535_/Y }
C {devices/lab_pin.sym} 108360 -8700 0 0 {name=p107962 lab=_72537_/B }
C {devices/lab_pin.sym} 108480 -8720 0 1 {name=p107963 lab=_72537_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -8720 0 0 {name=X_72537_ }
C {devices/lab_pin.sym} 108340 -8610 0 0 {name=p107964 lab=_79088_/Y }
C {devices/lab_pin.sym} 108340 -8570 0 0 {name=p107965 lab=_79070_/B }
C {devices/lab_pin.sym} 108340 -8530 0 0 {name=p107966 lab=_79092_/Y }
C {devices/lab_pin.sym} 108500 -8570 0 1 {name=p107967 lab=_79095_/B }
C {sky130_stdcells/o21ai_4.sym} 108420 -8570 0 0 {name=X_79093_ }
C {devices/lab_pin.sym} 108380 -8430 0 0 {name=p107968 lab=_85083_/Q }
C {devices/lab_pin.sym} 108460 -8430 0 1 {name=p107969 lab=_45485_/Y }
C {sky130_stdcells/inv_2.sym} 108420 -8430 0 0 {name=X_45485_ }
C {devices/lab_pin.sym} 108340 -8340 0 0 {name=p107970 lab=_41104_/X }
C {devices/lab_pin.sym} 108340 -8300 0 0 {name=p107971 lab=_42695_/X }
C {devices/lab_pin.sym} 108340 -8260 0 0 {name=p107972 lab=_69542_/B }
C {devices/lab_pin.sym} 108340 -8220 0 0 {name=p107973 lab=_42696_/X }
C {devices/lab_pin.sym} 108500 -8280 0 1 {name=p107974 lab=_87765_/D }
C {sky130_stdcells/a2bb2o_4.sym} 108420 -8280 0 0 {name=X_42697_ }
C {devices/lab_pin.sym} 108380 -8130 0 0 {name=p107975 lab=_47128_/A }
C {devices/lab_pin.sym} 108460 -8130 0 1 {name=p107976 lab=_47224_/X }
C {sky130_stdcells/buf_2.sym} 108420 -8130 0 0 {name=X_47224_ }
C {devices/lab_pin.sym} 108380 -8010 0 0 {name=p107977 lab=_78044_/A }
C {devices/lab_pin.sym} 108460 -8010 0 1 {name=p107978 lab=_81922_/D }
C {sky130_stdcells/inv_2.sym} 108420 -8010 0 0 {name=X_78044_ }
C {devices/lab_pin.sym} 108340 -7930 0 0 {name=p107979 lab=_44425_/X }
C {devices/lab_pin.sym} 108340 -7890 0 0 {name=p107980 lab=_44427_/X }
C {devices/lab_pin.sym} 108340 -7850 0 0 {name=p107981 lab=_41596_/X }
C {devices/lab_pin.sym} 108340 -7810 0 0 {name=p107982 lab=_87109_/Q }
C {devices/lab_pin.sym} 108340 -7770 0 0 {name=p107983 lab=_44428_/X }
C {devices/lab_pin.sym} 108500 -7850 0 1 {name=p107984 lab=_44437_/A }
C {sky130_stdcells/o32ai_4.sym} 108420 -7850 0 0 {name=X_44436_ }
C {devices/lab_pin.sym} 108360 -7700 0 0 {name=p107985 lab=_75255_/A }
C {devices/lab_pin.sym} 108360 -7660 0 0 {name=p107986 lab=_80943_/D }
C {devices/lab_pin.sym} 108480 -7680 0 1 {name=p107987 lab=_75256_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -7680 0 0 {name=X_75256_ }
C {devices/lab_pin.sym} 108340 -7580 0 0 {name=p107988 lab=_58277_/A }
C {devices/lab_pin.sym} 108340 -7540 0 0 {name=p107989 lab=_62999_/X }
C {devices/lab_pin.sym} 108340 -7500 0 0 {name=p107990 lab=_61607_/B }
C {devices/lab_pin.sym} 108340 -7460 0 0 {name=p107991 lab=_60608_/X }
C {devices/lab_pin.sym} 108500 -7520 0 1 {name=p107992 lab=_63270_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 108420 -7520 0 0 {name=X_63270_ }
C {devices/lab_pin.sym} 108340 -7400 0 0 {name=p107993 lab=_41647_/X }
C {devices/lab_pin.sym} 108340 -7360 0 0 {name=p107994 lab=_41638_/X }
C {devices/lab_pin.sym} 108340 -7320 0 0 {name=p107995 lab=_67421_/B }
C {devices/lab_pin.sym} 108340 -7280 0 0 {name=p107996 lab=_41639_/X }
C {devices/lab_pin.sym} 108500 -7340 0 1 {name=p107997 lab=_88176_/D }
C {sky130_stdcells/a2bb2o_4.sym} 108420 -7340 0 0 {name=X_41648_ }
C {devices/lab_pin.sym} 108380 -7190 0 0 {name=p107998 lab=_60482_/A }
C {devices/lab_pin.sym} 108460 -7190 0 1 {name=p107999 lab=_60482_/Y }
C {sky130_stdcells/inv_2.sym} 108420 -7190 0 0 {name=X_60482_ }
C {devices/lab_pin.sym} 108340 -7090 0 0 {name=p108000 lab=_72361_/X }
C {devices/lab_pin.sym} 108340 -7050 0 0 {name=p108001 lab=_85667_/Q }
C {devices/lab_pin.sym} 108340 -7010 0 0 {name=p108002 lab=_72362_/X }
C {devices/lab_pin.sym} 108500 -7050 0 1 {name=p108003 lab=_72468_/X }
C {sky130_stdcells/o21a_4.sym} 108420 -7050 0 0 {name=X_72468_ }
C {devices/lab_pin.sym} 108380 -6910 0 0 {name=p108004 lab=_62572_/A }
C {devices/lab_pin.sym} 108460 -6910 0 1 {name=p108005 lab=_62362_/A }
C {sky130_stdcells/buf_2.sym} 108420 -6910 0 0 {name=X_62221_ }
C {devices/lab_pin.sym} 108340 -6820 0 0 {name=p108006 lab=_69055_/B }
C {devices/lab_pin.sym} 108340 -6780 0 0 {name=p108007 lab=_73030_/X }
C {devices/lab_pin.sym} 108340 -6740 0 0 {name=p108008 lab=_73035_/X }
C {devices/lab_pin.sym} 108340 -6700 0 0 {name=p108009 lab=_74206_/Y }
C {devices/lab_pin.sym} 108500 -6760 0 1 {name=p108010 lab=_74207_/X }
C {sky130_stdcells/a211o_4.sym} 108420 -6760 0 0 {name=X_74207_ }
C {devices/lab_pin.sym} 108360 -6640 0 0 {name=p108011 lab=_47152_/X }
C {devices/lab_pin.sym} 108360 -6600 0 0 {name=p108012 lab=_47133_/B }
C {devices/lab_pin.sym} 108360 -6560 0 0 {name=p108013 lab=_47143_/C }
C {devices/lab_pin.sym} 108360 -6520 0 0 {name=p108014 lab=_51192_/D }
C {devices/lab_pin.sym} 108480 -6580 0 1 {name=p108015 lab=_47155_/X }
C {sky130_stdcells/and4_4.sym} 108420 -6580 0 0 {name=X_47155_ }
C {devices/lab_pin.sym} 108380 -6430 0 0 {name=p108016 lab=_71419_/A }
C {devices/lab_pin.sym} 108460 -6430 0 1 {name=p108017 lab=_71419_/Y }
C {sky130_stdcells/inv_2.sym} 108420 -6430 0 0 {name=X_71419_ }
C {devices/lab_pin.sym} 108340 -6340 0 0 {name=p108018 lab=_41745_/X }
C {devices/lab_pin.sym} 108340 -6300 0 0 {name=p108019 lab=_44364_/X }
C {devices/lab_pin.sym} 108340 -6260 0 0 {name=p108020 lab=_87145_/Q }
C {devices/lab_pin.sym} 108340 -6220 0 0 {name=p108021 lab=_44365_/X }
C {devices/lab_pin.sym} 108500 -6280 0 1 {name=p108022 lab=_44367_/X }
C {sky130_stdcells/a2bb2o_4.sym} 108420 -6280 0 0 {name=X_44367_ }
C {devices/lab_pin.sym} 108340 -6150 0 0 {name=p108023 lab=_75172_/Y }
C {devices/lab_pin.sym} 108340 -6110 0 0 {name=p108024 lab=_75169_/Y }
C {devices/lab_pin.sym} 108340 -6070 0 0 {name=p108025 lab=_75175_/C }
C {devices/lab_pin.sym} 108500 -6110 0 1 {name=p108026 lab=_75188_/A }
C {sky130_stdcells/o21a_4.sym} 108420 -6110 0 0 {name=X_75187_ }
C {devices/lab_pin.sym} 108340 -5990 0 0 {name=p108027 lab=_41577_/X }
C {devices/lab_pin.sym} 108340 -5950 0 0 {name=p108028 lab=_81162_/Q }
C {devices/lab_pin.sym} 108340 -5910 0 0 {name=p108029 lab=_41578_/X }
C {devices/lab_pin.sym} 108500 -5950 0 1 {name=p108030 lab=_41580_/A }
C {sky130_stdcells/o21ai_4.sym} 108420 -5950 0 0 {name=X_41579_ }
C {devices/lab_pin.sym} 108340 -5830 0 0 {name=p108031 lab=_72396_/Y }
C {devices/lab_pin.sym} 108340 -5790 0 0 {name=p108032 lab=_72398_/Y }
C {devices/lab_pin.sym} 108340 -5750 0 0 {name=p108033 lab=_57718_/A }
C {devices/lab_pin.sym} 108500 -5790 0 1 {name=p108034 lab=_72399_/X }
C {sky130_stdcells/a21o_4.sym} 108420 -5790 0 0 {name=X_72399_ }
C {devices/lab_pin.sym} 108380 -5650 0 0 {name=p108035 lab=_46085_/A }
C {devices/lab_pin.sym} 108460 -5650 0 1 {name=p108036 lab=_46107_/A }
C {sky130_stdcells/buf_2.sym} 108420 -5650 0 0 {name=X_46106_ }
C {devices/lab_pin.sym} 108380 -5530 0 0 {name=p108037 lab=_43318_/A }
C {devices/lab_pin.sym} 108460 -5530 0 1 {name=p108038 lab=_87484_/D }
C {sky130_stdcells/inv_2.sym} 108420 -5530 0 0 {name=X_43318_ }
C {devices/lab_pin.sym} 108360 -5440 0 0 {name=p108039 lab=_62151_/X }
C {devices/lab_pin.sym} 108360 -5400 0 0 {name=p108040 lab=_62175_/B }
C {devices/lab_pin.sym} 108360 -5360 0 0 {name=p108041 lab=_61761_/C }
C {devices/lab_pin.sym} 108360 -5320 0 0 {name=p108042 lab=_62046_/D }
C {devices/lab_pin.sym} 108480 -5380 0 1 {name=p108043 lab=_62152_/Y }
C {sky130_stdcells/nand4_4.sym} 108420 -5380 0 0 {name=X_62152_ }
C {devices/lab_pin.sym} 108340 -5250 0 0 {name=p108044 lab=_70128_/C }
C {devices/lab_pin.sym} 108340 -5210 0 0 {name=p108045 lab=_73549_/X }
C {devices/lab_pin.sym} 108340 -5170 0 0 {name=p108046 lab=_74137_/Y }
C {devices/lab_pin.sym} 108500 -5210 0 1 {name=p108047 lab=_83121_/D }
C {sky130_stdcells/a21o_4.sym} 108420 -5210 0 0 {name=X_74138_ }
C {devices/lab_pin.sym} 108340 -5090 0 0 {name=p108048 lab=_47080_/Y }
C {devices/lab_pin.sym} 108340 -5050 0 0 {name=p108049 lab=_47081_/X }
C {devices/lab_pin.sym} 108340 -5010 0 0 {name=p108050 lab=_47085_/X }
C {devices/lab_pin.sym} 108500 -5050 0 1 {name=p108051 lab=_86672_/D }
C {sky130_stdcells/a21oi_4.sym} 108420 -5050 0 0 {name=X_47086_ }
C {devices/lab_pin.sym} 108380 -4910 0 0 {name=p108052 lab=_69442_/A }
C {devices/lab_pin.sym} 108460 -4910 0 1 {name=p108053 lab=_44299_/A }
C {sky130_stdcells/buf_2.sym} 108420 -4910 0 0 {name=X_44298_ }
C {devices/lab_pin.sym} 108340 -4810 0 0 {name=p108054 lab=_79985_/A }
C {devices/lab_pin.sym} 108340 -4770 0 0 {name=p108055 lab=_79985_/B }
C {devices/lab_pin.sym} 108340 -4730 0 0 {name=p108056 lab=_79994_/Y }
C {devices/lab_pin.sym} 108500 -4770 0 1 {name=p108057 lab=_79995_/Y }
C {sky130_stdcells/a21boi_4.sym} 108420 -4770 0 0 {name=X_79995_ }
C {devices/lab_pin.sym} 108380 -4630 0 0 {name=p108058 lab=_61102_/X }
C {devices/lab_pin.sym} 108460 -4630 0 1 {name=p108059 lab=_61103_/X }
C {sky130_stdcells/buf_2.sym} 108420 -4630 0 0 {name=X_61103_ }
C {devices/lab_pin.sym} 108340 -4550 0 0 {name=p108060 lab=_46013_/X }
C {devices/lab_pin.sym} 108340 -4510 0 0 {name=p108061 lab=_46032_/X }
C {devices/lab_pin.sym} 108340 -4470 0 0 {name=p108062 lab=_41492_/X }
C {devices/lab_pin.sym} 108340 -4430 0 0 {name=p108063 lab=_86800_/Q }
C {devices/lab_pin.sym} 108340 -4390 0 0 {name=p108064 lab=_46014_/X }
C {devices/lab_pin.sym} 108500 -4470 0 1 {name=p108065 lab=_46038_/A }
C {sky130_stdcells/o32ai_4.sym} 108420 -4470 0 0 {name=X_46037_ }
C {devices/lab_pin.sym} 108340 -4340 0 0 {name=p108066 lab=_41050_/X }
C {devices/lab_pin.sym} 108340 -4300 0 0 {name=p108067 lab=_43247_/X }
C {devices/lab_pin.sym} 108340 -4260 0 0 {name=p108068 lab=_87519_/Q }
C {devices/lab_pin.sym} 108340 -4220 0 0 {name=p108069 lab=_43248_/X }
C {devices/lab_pin.sym} 108500 -4280 0 1 {name=p108070 lab=_43249_/X }
C {sky130_stdcells/a2bb2o_4.sym} 108420 -4280 0 0 {name=X_43249_ }
C {devices/lab_pin.sym} 108340 -4160 0 0 {name=p108071 lab=_87939_/Q }
C {devices/lab_pin.sym} 108340 -4120 0 0 {name=p108072 lab=_66935_/X }
C {devices/lab_pin.sym} 108340 -4080 0 0 {name=p108073 lab=_66911_/X }
C {devices/lab_pin.sym} 108340 -4040 0 0 {name=p108074 lab=_66959_/X }
C {devices/lab_pin.sym} 108500 -4100 0 1 {name=p108075 lab=_66960_/X }
C {sky130_stdcells/a211o_4.sym} 108420 -4100 0 0 {name=X_66960_ }
C {devices/lab_pin.sym} 108360 -3980 0 0 {name=p108076 lab=_61730_/X }
C {devices/lab_pin.sym} 108360 -3940 0 0 {name=p108077 lab=_62094_/B }
C {devices/lab_pin.sym} 108360 -3900 0 0 {name=p108078 lab=_59722_/X }
C {devices/lab_pin.sym} 108360 -3860 0 0 {name=p108079 lab=_62083_/D }
C {devices/lab_pin.sym} 108480 -3920 0 1 {name=p108080 lab=_62083_/X }
C {sky130_stdcells/and4_4.sym} 108420 -3920 0 0 {name=X_62083_ }
C {devices/lab_pin.sym} 108340 -3790 0 0 {name=p108081 lab=_74067_/X }
C {devices/lab_pin.sym} 108340 -3750 0 0 {name=p108082 lab=_74068_/Y }
C {devices/lab_pin.sym} 108340 -3710 0 0 {name=p108083 lab=_73982_/X }
C {devices/lab_pin.sym} 108500 -3750 0 1 {name=p108084 lab=_74069_/X }
C {sky130_stdcells/a21o_4.sym} 108420 -3750 0 0 {name=X_74069_ }
C {devices/lab_pin.sym} 108360 -3620 0 0 {name=p108085 lab=_78946_/A }
C {devices/lab_pin.sym} 108360 -3580 0 0 {name=p108086 lab=_78945_/Y }
C {devices/lab_pin.sym} 108480 -3600 0 1 {name=p108087 lab=_78947_/B }
C {sky130_stdcells/xnor2_4.sym} 108420 -3600 0 0 {name=X_78946_ }
C {devices/lab_pin.sym} 108360 -3480 0 0 {name=p108088 lab=_65896_/A }
C {devices/lab_pin.sym} 108360 -3440 0 0 {name=p108089 lab=_73568_/B }
C {devices/lab_pin.sym} 108480 -3460 0 1 {name=p108090 lab=_65911_/X }
C {sky130_stdcells/and2_4.sym} 108420 -3460 0 0 {name=X_65911_ }
C {devices/lab_pin.sym} 108340 -3370 0 0 {name=p108091 lab=_60967_/X }
C {devices/lab_pin.sym} 108340 -3330 0 0 {name=p108092 lab=_60995_/Y }
C {devices/lab_pin.sym} 108340 -3290 0 0 {name=p108093 lab=_61024_/Y }
C {devices/lab_pin.sym} 108340 -3250 0 0 {name=p108094 lab=_61032_/X }
C {devices/lab_pin.sym} 108340 -3210 0 0 {name=p108095 lab=_61033_/X }
C {devices/lab_pin.sym} 108500 -3290 0 1 {name=p108096 lab=_84534_/D }
C {sky130_stdcells/o41a_4.sym} 108420 -3290 0 0 {name=X_61034_ }
C {devices/lab_pin.sym} 108340 -3150 0 0 {name=p108097 lab=_66888_/X }
C {devices/lab_pin.sym} 108340 -3110 0 0 {name=p108098 lab=_66890_/X }
C {devices/lab_pin.sym} 108340 -3070 0 0 {name=p108099 lab=_66843_/X }
C {devices/lab_pin.sym} 108500 -3110 0 1 {name=p108100 lab=_66891_/X }
C {sky130_stdcells/a21o_4.sym} 108420 -3110 0 0 {name=X_66891_ }
C {devices/lab_pin.sym} 108360 -2980 0 0 {name=p108101 lab=_78877_/A }
C {devices/lab_pin.sym} 108360 -2940 0 0 {name=p108102 lab=_78877_/B }
C {devices/lab_pin.sym} 108480 -2960 0 1 {name=p108103 lab=_78877_/X }
C {sky130_stdcells/and2_4.sym} 108420 -2960 0 0 {name=X_78877_ }
C {devices/lab_pin.sym} 108380 -2830 0 0 {name=p108104 lab=_68993_/A }
C {devices/lab_pin.sym} 108460 -2830 0 1 {name=p108105 lab=_68630_/X }
C {sky130_stdcells/buf_2.sym} 108420 -2830 0 0 {name=X_68630_ }
C {devices/lab_pin.sym} 108380 -2710 0 0 {name=p108106 lab=_65842_/A }
C {devices/lab_pin.sym} 108460 -2710 0 1 {name=p108107 lab=_65842_/X }
C {sky130_stdcells/buf_2.sym} 108420 -2710 0 0 {name=X_65842_ }
C {devices/lab_pin.sym} 108360 -2600 0 0 {name=p108108 lab=_77828_/A }
C {devices/lab_pin.sym} 108360 -2560 0 0 {name=p108109 lab=_77814_/Y }
C {devices/lab_pin.sym} 108480 -2580 0 1 {name=p108110 lab=_77828_/Y }
C {sky130_stdcells/nor2_4.sym} 108420 -2580 0 0 {name=X_77828_ }
C {devices/lab_pin.sym} 108360 -2460 0 0 {name=p108111 lab=_47988_/A }
C {devices/lab_pin.sym} 108360 -2420 0 0 {name=p108112 lab=_50306_/B }
C {devices/lab_pin.sym} 108480 -2440 0 1 {name=p108113 lab=_47988_/Y }
C {sky130_stdcells/nand2_4.sym} 108420 -2440 0 0 {name=X_47988_ }
C {devices/lab_pin.sym} 108340 -2330 0 0 {name=p108114 lab=_86334_/Q }
C {devices/lab_pin.sym} 108340 -2290 0 0 {name=p108115 lab=_49715_/X }
C {devices/lab_pin.sym} 108340 -2250 0 0 {name=p108116 lab=_49726_/Y }
C {devices/lab_pin.sym} 108500 -2290 0 1 {name=p108117 lab=_49727_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -2290 0 0 {name=X_49727_ }
C {devices/lab_pin.sym} 108340 -2180 0 0 {name=p108118 lab=_44688_/A }
C {devices/lab_pin.sym} 108340 -2140 0 0 {name=p108119 lab=_68455_/X }
C {devices/lab_pin.sym} 108340 -2100 0 0 {name=p108120 lab=_68509_/X }
C {devices/lab_pin.sym} 108340 -2060 0 0 {name=p108121 lab=_68560_/X }
C {devices/lab_pin.sym} 108500 -2120 0 1 {name=p108122 lab=_68561_/X }
C {sky130_stdcells/a211o_4.sym} 108420 -2120 0 0 {name=X_68561_ }
C {devices/lab_pin.sym} 108340 -1990 0 0 {name=p108123 lab=_59019_/A }
C {devices/lab_pin.sym} 108340 -1950 0 0 {name=p108124 lab=_46908_/X }
C {devices/lab_pin.sym} 108340 -1910 0 0 {name=p108125 lab=_46938_/Y }
C {devices/lab_pin.sym} 108500 -1950 0 1 {name=p108126 lab=_46939_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -1950 0 0 {name=X_46939_ }
C {devices/lab_pin.sym} 108380 -1810 0 0 {name=p108127 lab=_64961_/A }
C {devices/lab_pin.sym} 108460 -1810 0 1 {name=p108128 lab=_65969_/A }
C {sky130_stdcells/buf_2.sym} 108420 -1810 0 0 {name=X_65773_ }
C {devices/lab_pin.sym} 108340 -1710 0 0 {name=p108129 lab=_77758_/Y }
C {devices/lab_pin.sym} 108340 -1670 0 0 {name=p108130 lab=_77745_/Y }
C {devices/lab_pin.sym} 108340 -1630 0 0 {name=p108131 lab=_77752_/A }
C {devices/lab_pin.sym} 108500 -1670 0 1 {name=p108132 lab=_77759_/Y }
C {sky130_stdcells/o21ai_4.sym} 108420 -1670 0 0 {name=X_77759_ }
C {devices/lab_pin.sym} 108380 -1530 0 0 {name=p108133 lab=_59961_/A }
C {devices/lab_pin.sym} 108460 -1530 0 1 {name=p108134 lab=_64328_/A }
C {sky130_stdcells/buf_2.sym} 108420 -1530 0 0 {name=X_62985_ }
C {devices/lab_pin.sym} 108380 -1410 0 0 {name=p108135 lab=_67987_/A }
C {devices/lab_pin.sym} 108460 -1410 0 1 {name=p108136 lab=_67512_/X }
C {sky130_stdcells/buf_2.sym} 108420 -1410 0 0 {name=X_67512_ }
C {devices/lab_pin.sym} 108380 -1290 0 0 {name=p108137 lab=_65718_/A }
C {devices/lab_pin.sym} 108460 -1290 0 1 {name=p108138 lab=_64724_/X }
C {sky130_stdcells/buf_2.sym} 108420 -1290 0 0 {name=X_64724_ }
C {devices/lab_pin.sym} 108360 -1200 0 0 {name=p108139 lab=_49651_/X }
C {devices/lab_pin.sym} 108360 -1160 0 0 {name=p108140 lab=_49642_/B }
C {devices/lab_pin.sym} 108360 -1120 0 0 {name=p108141 lab=_49669_/C }
C {devices/lab_pin.sym} 108360 -1080 0 0 {name=p108142 lab=_52872_/D }
C {devices/lab_pin.sym} 108480 -1140 0 1 {name=p108143 lab=_49658_/X }
C {sky130_stdcells/and4_4.sym} 108420 -1140 0 0 {name=X_49658_ }
C {devices/lab_pin.sym} 108380 -990 0 0 {name=p108144 lab=_61708_/X }
C {devices/lab_pin.sym} 108460 -990 0 1 {name=p108145 lab=_61953_/C }
C {sky130_stdcells/buf_2.sym} 108420 -990 0 0 {name=X_61936_ }
C {devices/lab_pin.sym} 108330 -870 0 0 {name=p108146 lab=_80854_/CLK }
C {devices/lab_pin.sym} 108330 -850 0 0 {name=p108147 lab=_75887_/Y }
C {devices/lab_pin.sym} 108510 -870 0 1 {name=p108148 lab=_80770_/Q }
C {sky130_stdcells/dfxtp_4.sym} 108420 -860 0 0 {name=X_80770_ }
C {devices/lab_pin.sym} 108340 -760 0 0 {name=p108149 lab=_73675_/A }
C {devices/lab_pin.sym} 108340 -720 0 0 {name=p108150 lab=_68414_/X }
C {devices/lab_pin.sym} 108340 -680 0 0 {name=p108151 lab=_68379_/X }
C {devices/lab_pin.sym} 108340 -640 0 0 {name=p108152 lab=_68491_/Y }
C {devices/lab_pin.sym} 108500 -700 0 1 {name=p108153 lab=_68492_/X }
C {sky130_stdcells/a211o_4.sym} 108420 -700 0 0 {name=X_68492_ }
C {devices/lab_pin.sym} 109300 -42150 0 0 {name=p108154 lab=_48609_/A }
C {devices/lab_pin.sym} 109380 -42150 0 1 {name=p108155 lab=_50511_/A }
C {sky130_stdcells/buf_2.sym} 109340 -42150 0 0 {name=X_48609_ }
C {devices/lab_pin.sym} 109280 -42040 0 0 {name=p108156 lab=_79429_/A }
C {devices/lab_pin.sym} 109280 -42000 0 0 {name=p108157 lab=_79428_/Y }
C {devices/lab_pin.sym} 109400 -42020 0 1 {name=p108158 lab=_79429_/X }
C {sky130_stdcells/xor2_4.sym} 109340 -42020 0 0 {name=X_79429_ }
C {devices/lab_pin.sym} 109260 -41910 0 0 {name=p108159 lab=_67438_/X }
C {devices/lab_pin.sym} 109260 -41870 0 0 {name=p108160 lab=_67441_/X }
C {devices/lab_pin.sym} 109260 -41830 0 0 {name=p108161 lab=_67442_/X }
C {devices/lab_pin.sym} 109420 -41870 0 1 {name=p108162 lab=_67443_/X }
C {sky130_stdcells/a21o_4.sym} 109340 -41870 0 0 {name=X_67443_ }
C {devices/lab_pin.sym} 109260 -41750 0 0 {name=p108163 lab=_64652_/X }
C {devices/lab_pin.sym} 109260 -41710 0 0 {name=p108164 lab=_64654_/X }
C {devices/lab_pin.sym} 109260 -41670 0 0 {name=p108165 lab=_64629_/X }
C {devices/lab_pin.sym} 109420 -41710 0 1 {name=p108166 lab=_64655_/X }
C {sky130_stdcells/a21o_4.sym} 109340 -41710 0 0 {name=X_64655_ }
C {devices/lab_pin.sym} 109260 -41590 0 0 {name=p108167 lab=_49586_/Y }
C {devices/lab_pin.sym} 109260 -41550 0 0 {name=p108168 lab=_49570_/X }
C {devices/lab_pin.sym} 109260 -41510 0 0 {name=p108169 lab=_49588_/X }
C {devices/lab_pin.sym} 109420 -41550 0 1 {name=p108170 lab=_86360_/D }
C {sky130_stdcells/a21oi_4.sym} 109340 -41550 0 0 {name=X_49589_ }
C {devices/lab_pin.sym} 109300 -41410 0 0 {name=p108171 lab=_59765_/A }
C {devices/lab_pin.sym} 109380 -41410 0 1 {name=p108172 lab=_61915_/B }
C {sky130_stdcells/buf_2.sym} 109340 -41410 0 0 {name=X_61867_ }
C {devices/lab_pin.sym} 109260 -41310 0 0 {name=p108173 lab=_51618_/Y }
C {devices/lab_pin.sym} 109260 -41270 0 0 {name=p108174 lab=_51613_/X }
C {devices/lab_pin.sym} 109260 -41230 0 0 {name=p108175 lab=_51619_/X }
C {devices/lab_pin.sym} 109420 -41270 0 1 {name=p108176 lab=_85977_/D }
C {sky130_stdcells/a21oi_4.sym} 109340 -41270 0 0 {name=X_51620_ }
C {devices/lab_pin.sym} 109300 -41130 0 0 {name=p108177 lab=_60731_/A }
C {devices/lab_pin.sym} 109380 -41130 0 1 {name=p108178 lab=_63655_/A }
C {sky130_stdcells/buf_2.sym} 109340 -41130 0 0 {name=X_63606_ }
C {devices/lab_pin.sym} 109250 -41010 0 0 {name=p108179 lab=_82452_/CLK }
C {devices/lab_pin.sym} 109250 -40990 0 0 {name=p108180 lab=_79132_/X }
C {devices/lab_pin.sym} 109430 -41010 0 1 {name=p108181 lab=_82440_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -41000 0 0 {name=X_82440_ }
C {devices/lab_pin.sym} 109260 -40910 0 0 {name=p108182 lab=_60616_/Y }
C {devices/lab_pin.sym} 109260 -40870 0 0 {name=p108183 lab=_60704_/Y }
C {devices/lab_pin.sym} 109260 -40830 0 0 {name=p108184 lab=_60815_/X }
C {devices/lab_pin.sym} 109260 -40790 0 0 {name=p108185 lab=_60794_/Y }
C {devices/lab_pin.sym} 109260 -40760 0 0 {name=p108186 lab=_60817_/Y }
C {devices/lab_pin.sym} 109420 -40830 0 1 {name=p108187 lab=_84559_/D }
C {sky130_stdcells/a41oi_4.sym} 109340 -40830 0 0 {name=X_60818_ }
C {devices/lab_pin.sym} 109260 -40700 0 0 {name=p108188 lab=_86974_/Q }
C {devices/lab_pin.sym} 109260 -40660 0 0 {name=p108189 lab=_67348_/X }
C {devices/lab_pin.sym} 109260 -40620 0 0 {name=p108190 lab=_67278_/X }
C {devices/lab_pin.sym} 109260 -40580 0 0 {name=p108191 lab=_67373_/X }
C {devices/lab_pin.sym} 109420 -40640 0 1 {name=p108192 lab=_67374_/X }
C {sky130_stdcells/a211o_4.sym} 109340 -40640 0 0 {name=X_67374_ }
C {devices/lab_pin.sym} 109300 -40490 0 0 {name=p108193 lab=_64777_/A }
C {devices/lab_pin.sym} 109380 -40490 0 1 {name=p108194 lab=_64676_/A }
C {sky130_stdcells/buf_2.sym} 109340 -40490 0 0 {name=X_64586_ }
C {devices/lab_pin.sym} 109280 -40400 0 0 {name=p108195 lab=_61796_/X }
C {devices/lab_pin.sym} 109280 -40360 0 0 {name=p108196 lab=_61765_/B }
C {devices/lab_pin.sym} 109280 -40320 0 0 {name=p108197 lab=_61846_/C }
C {devices/lab_pin.sym} 109280 -40280 0 0 {name=p108198 lab=_61748_/X }
C {devices/lab_pin.sym} 109400 -40340 0 1 {name=p108199 lab=_61798_/Y }
C {sky130_stdcells/nand4_4.sym} 109340 -40340 0 0 {name=X_61798_ }
C {devices/lab_pin.sym} 109300 -40190 0 0 {name=p108200 lab=_68385_/A }
C {devices/lab_pin.sym} 109380 -40190 0 1 {name=p108201 lab=_69113_/X }
C {sky130_stdcells/buf_2.sym} 109340 -40190 0 0 {name=X_69113_ }
C {devices/lab_pin.sym} 109260 -40090 0 0 {name=p108202 lab=_66322_/X }
C {devices/lab_pin.sym} 109260 -40050 0 0 {name=p108203 lab=_66324_/X }
C {devices/lab_pin.sym} 109260 -40010 0 0 {name=p108204 lab=_58882_/A }
C {devices/lab_pin.sym} 109420 -40050 0 1 {name=p108205 lab=_66325_/X }
C {sky130_stdcells/a21o_4.sym} 109340 -40050 0 0 {name=X_66325_ }
C {devices/lab_pin.sym} 109260 -39930 0 0 {name=p108206 lab=_85989_/Q }
C {devices/lab_pin.sym} 109260 -39890 0 0 {name=p108207 lab=_51539_/X }
C {devices/lab_pin.sym} 109260 -39850 0 0 {name=p108208 lab=_51550_/Y }
C {devices/lab_pin.sym} 109420 -39890 0 1 {name=p108209 lab=_51551_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -39890 0 0 {name=X_51551_ }
C {devices/lab_pin.sym} 109280 -39770 0 0 {name=p108210 lab=_63512_/A }
C {devices/lab_pin.sym} 109280 -39730 0 0 {name=p108211 lab=_57680_/A }
C {devices/lab_pin.sym} 109280 -39690 0 0 {name=p108212 lab=_63537_/C }
C {devices/lab_pin.sym} 109400 -39730 0 1 {name=p108213 lab=_63537_/X }
C {sky130_stdcells/and3_4.sym} 109340 -39730 0 0 {name=X_63537_ }
C {devices/lab_pin.sym} 109250 -39590 0 0 {name=p108214 lab=_84951_/CLK }
C {devices/lab_pin.sym} 109250 -39570 0 0 {name=p108215 lab=_82371_/D }
C {devices/lab_pin.sym} 109430 -39590 0 1 {name=p108216 lab=_82371_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -39580 0 0 {name=X_82371_ }
C {devices/lab_pin.sym} 109280 -39470 0 0 {name=p108217 lab=_60646_/Y }
C {devices/lab_pin.sym} 109280 -39430 0 0 {name=p108218 lab=_63417_/A }
C {devices/lab_pin.sym} 109280 -39390 0 0 {name=p108219 lab=_60725_/A }
C {devices/lab_pin.sym} 109400 -39430 0 1 {name=p108220 lab=_60749_/Y }
C {sky130_stdcells/nand3_4.sym} 109340 -39430 0 0 {name=X_60749_ }
C {devices/lab_pin.sym} 109250 -39290 0 0 {name=p108221 lab=_84111_/CLK }
C {devices/lab_pin.sym} 109250 -39270 0 0 {name=p108222 lab=_84110_/D }
C {devices/lab_pin.sym} 109430 -39290 0 1 {name=p108223 lab=_84110_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -39280 0 0 {name=X_84110_ }
C {devices/lab_pin.sym} 109260 -39170 0 0 {name=p108224 lab=_86188_/Q }
C {devices/lab_pin.sym} 109260 -39130 0 0 {name=p108225 lab=_50499_/X }
C {devices/lab_pin.sym} 109260 -39090 0 0 {name=p108226 lab=_50501_/Y }
C {devices/lab_pin.sym} 109420 -39130 0 1 {name=p108227 lab=_50502_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -39130 0 0 {name=X_50502_ }
C {devices/lab_pin.sym} 109250 -38990 0 0 {name=p108228 lab=_81322_/CLK }
C {devices/lab_pin.sym} 109250 -38970 0 0 {name=p108229 lab=_76274_/X }
C {devices/lab_pin.sym} 109430 -38990 0 1 {name=p108230 lab=_81698_/D }
C {sky130_stdcells/dfxtp_4.sym} 109340 -38980 0 0 {name=X_81322_ }
C {devices/lab_pin.sym} 109300 -38850 0 0 {name=p108231 lab=_69442_/A }
C {devices/lab_pin.sym} 109380 -38850 0 1 {name=p108232 lab=_69044_/X }
C {sky130_stdcells/buf_2.sym} 109340 -38850 0 0 {name=X_69044_ }
C {devices/lab_pin.sym} 109280 -38760 0 0 {name=p108233 lab=_54286_/A }
C {devices/lab_pin.sym} 109280 -38720 0 0 {name=p108234 lab=_54246_/X }
C {devices/lab_pin.sym} 109280 -38680 0 0 {name=p108235 lab=_54286_/C }
C {devices/lab_pin.sym} 109280 -38640 0 0 {name=p108236 lab=_46619_/A }
C {devices/lab_pin.sym} 109400 -38700 0 1 {name=p108237 lab=_54270_/X }
C {sky130_stdcells/and4_4.sym} 109340 -38700 0 0 {name=X_54270_ }
C {devices/lab_pin.sym} 109280 -38560 0 0 {name=p108238 lab=_66326_/A }
C {devices/lab_pin.sym} 109280 -38520 0 0 {name=p108239 lab=_66256_/B }
C {devices/lab_pin.sym} 109400 -38540 0 1 {name=p108240 lab=_66256_/X }
C {sky130_stdcells/and2_4.sym} 109340 -38540 0 0 {name=X_66256_ }
C {devices/lab_pin.sym} 109250 -38410 0 0 {name=p108241 lab=_85031_/CLK }
C {devices/lab_pin.sym} 109250 -38390 0 0 {name=p108242 lab=_57085_/X }
C {devices/lab_pin.sym} 109430 -38410 0 1 {name=p108243 lab=_85090_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -38400 0 0 {name=X_85090_ }
C {devices/lab_pin.sym} 109260 -38290 0 0 {name=p108244 lab=_86002_/Q }
C {devices/lab_pin.sym} 109260 -38250 0 0 {name=p108245 lab=_51458_/X }
C {devices/lab_pin.sym} 109260 -38210 0 0 {name=p108246 lab=_51481_/Y }
C {devices/lab_pin.sym} 109420 -38250 0 1 {name=p108247 lab=_51482_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -38250 0 0 {name=X_51482_ }
C {devices/lab_pin.sym} 109300 -38110 0 0 {name=p108248 lab=_63468_/A }
C {devices/lab_pin.sym} 109380 -38110 0 1 {name=p108249 lab=_63517_/B }
C {sky130_stdcells/buf_2.sym} 109340 -38110 0 0 {name=X_63468_ }
C {devices/lab_pin.sym} 109300 -37990 0 0 {name=p108250 lab=_53221_/A }
C {devices/lab_pin.sym} 109380 -37990 0 1 {name=p108251 lab=_53302_/A }
C {sky130_stdcells/buf_2.sym} 109340 -37990 0 0 {name=X_53221_ }
C {devices/lab_pin.sym} 109260 -37900 0 0 {name=p108252 lab=_65099_/X }
C {devices/lab_pin.sym} 109260 -37860 0 0 {name=p108253 lab=_83290_/Q }
C {devices/lab_pin.sym} 109260 -37820 0 0 {name=p108254 lab=_65028_/X }
C {devices/lab_pin.sym} 109260 -37780 0 0 {name=p108255 lab=_65206_/X }
C {devices/lab_pin.sym} 109420 -37840 0 1 {name=p108256 lab=_65207_/X }
C {sky130_stdcells/a211o_4.sym} 109340 -37840 0 0 {name=X_65207_ }
C {devices/lab_pin.sym} 109250 -37690 0 0 {name=p108257 lab=_81169_/CLK }
C {devices/lab_pin.sym} 109250 -37670 0 0 {name=p108258 lab=_68092_/X }
C {devices/lab_pin.sym} 109430 -37690 0 1 {name=p108259 lab=_82081_/D }
C {sky130_stdcells/dfxtp_4.sym} 109340 -37680 0 0 {name=X_84041_ }
C {devices/lab_pin.sym} 109260 -37570 0 0 {name=p108260 lab=_86201_/Q }
C {devices/lab_pin.sym} 109260 -37530 0 0 {name=p108261 lab=_50403_/X }
C {devices/lab_pin.sym} 109260 -37490 0 0 {name=p108262 lab=_50432_/Y }
C {devices/lab_pin.sym} 109420 -37530 0 1 {name=p108263 lab=_50433_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -37530 0 0 {name=X_50433_ }
C {devices/lab_pin.sym} 109280 -37410 0 0 {name=p108264 lab=_62448_/A }
C {devices/lab_pin.sym} 109280 -37370 0 0 {name=p108265 lab=_58528_/A }
C {devices/lab_pin.sym} 109280 -37330 0 0 {name=p108266 lab=_62375_/C }
C {devices/lab_pin.sym} 109400 -37370 0 1 {name=p108267 lab=_62421_/C }
C {sky130_stdcells/nand3_4.sym} 109340 -37370 0 0 {name=X_62419_ }
C {devices/lab_pin.sym} 109250 -37230 0 0 {name=p108268 lab=_81288_/CLK }
C {devices/lab_pin.sym} 109250 -37210 0 0 {name=p108269 lab=_81285_/Q }
C {devices/lab_pin.sym} 109430 -37230 0 1 {name=p108270 lab=_76187_/A }
C {sky130_stdcells/dfxtp_4.sym} 109340 -37220 0 0 {name=X_81253_ }
C {devices/lab_pin.sym} 109280 -37100 0 0 {name=p108271 lab=_66226_/A }
C {devices/lab_pin.sym} 109280 -37060 0 0 {name=p108272 lab=_86542_/Q }
C {devices/lab_pin.sym} 109400 -37080 0 1 {name=p108273 lab=_66187_/X }
C {sky130_stdcells/and2_4.sym} 109340 -37080 0 0 {name=X_66187_ }
C {devices/lab_pin.sym} 109280 -36960 0 0 {name=p108274 lab=_63427_/A }
C {devices/lab_pin.sym} 109280 -36920 0 0 {name=p108275 lab=_61780_/X }
C {devices/lab_pin.sym} 109400 -36940 0 1 {name=p108276 lab=_63399_/X }
C {sky130_stdcells/and2_4.sym} 109340 -36940 0 0 {name=X_63399_ }
C {devices/lab_pin.sym} 109260 -36830 0 0 {name=p108277 lab=_80196_/A }
C {devices/lab_pin.sym} 109260 -36790 0 0 {name=p108278 lab=_80195_/X }
C {devices/lab_pin.sym} 109260 -36750 0 0 {name=p108279 lab=_80203_/Y }
C {devices/lab_pin.sym} 109420 -36790 0 1 {name=p108280 lab=_80204_/Y }
C {sky130_stdcells/a21boi_4.sym} 109340 -36790 0 0 {name=X_80204_ }
C {devices/lab_pin.sym} 109260 -36670 0 0 {name=p108281 lab=_53149_/Y }
C {devices/lab_pin.sym} 109260 -36630 0 0 {name=p108282 lab=_53137_/X }
C {devices/lab_pin.sym} 109260 -36590 0 0 {name=p108283 lab=_53151_/X }
C {devices/lab_pin.sym} 109420 -36630 0 1 {name=p108284 lab=_53152_/Y }
C {sky130_stdcells/a21oi_4.sym} 109340 -36630 0 0 {name=X_53152_ }
C {devices/lab_pin.sym} 109260 -36520 0 0 {name=p108285 lab=_65065_/X }
C {devices/lab_pin.sym} 109260 -36480 0 0 {name=p108286 lab=_83293_/Q }
C {devices/lab_pin.sym} 109260 -36440 0 0 {name=p108287 lab=_65108_/X }
C {devices/lab_pin.sym} 109260 -36400 0 0 {name=p108288 lab=_65137_/X }
C {devices/lab_pin.sym} 109420 -36460 0 1 {name=p108289 lab=_65138_/X }
C {sky130_stdcells/a211o_4.sym} 109340 -36460 0 0 {name=X_65138_ }
C {devices/lab_pin.sym} 109300 -36310 0 0 {name=p108290 lab=_50500_/A }
C {devices/lab_pin.sym} 109380 -36310 0 1 {name=p108291 lab=_50383_/A }
C {sky130_stdcells/buf_2.sym} 109340 -36310 0 0 {name=X_50364_ }
C {devices/lab_pin.sym} 109250 -36190 0 0 {name=p108292 lab=_86758_/CLK }
C {devices/lab_pin.sym} 109250 -36170 0 0 {name=p108293 lab=_75066_/B }
C {devices/lab_pin.sym} 109430 -36190 0 1 {name=p108294 lab=_81184_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -36180 0 0 {name=X_81184_ }
C {devices/lab_pin.sym} 109280 -36070 0 0 {name=p108295 lab=_52103_/A }
C {devices/lab_pin.sym} 109280 -36030 0 0 {name=p108296 lab=_52135_/B }
C {devices/lab_pin.sym} 109280 -35990 0 0 {name=p108297 lab=_52097_/X }
C {devices/lab_pin.sym} 109400 -36030 0 1 {name=p108298 lab=_52103_/X }
C {sky130_stdcells/and3_4.sym} 109340 -36030 0 0 {name=X_52103_ }
C {devices/lab_pin.sym} 109250 -35890 0 0 {name=p108299 lab=_87544_/CLK }
C {devices/lab_pin.sym} 109250 -35870 0 0 {name=p108300 lab=_87800_/D }
C {devices/lab_pin.sym} 109430 -35890 0 1 {name=p108301 lab=_69917_/A }
C {sky130_stdcells/dfxtp_4.sym} 109340 -35880 0 0 {name=X_87800_ }
C {devices/lab_pin.sym} 109280 -35760 0 0 {name=p108302 lab=_80131_/Y }
C {devices/lab_pin.sym} 109280 -35720 0 0 {name=p108303 lab=_80134_/Y }
C {devices/lab_pin.sym} 109400 -35740 0 1 {name=p108304 lab=_80135_/X }
C {sky130_stdcells/xor2_4.sym} 109340 -35740 0 0 {name=X_80135_ }
C {devices/lab_pin.sym} 109300 -35610 0 0 {name=p108305 lab=_53112_/A }
C {devices/lab_pin.sym} 109380 -35610 0 1 {name=p108306 lab=_53107_/A }
C {sky130_stdcells/buf_2.sym} 109340 -35610 0 0 {name=X_53083_ }
C {devices/lab_pin.sym} 109280 -35500 0 0 {name=p108307 lab=_86640_/Q }
C {devices/lab_pin.sym} 109280 -35460 0 0 {name=p108308 lab=_58039_/B }
C {devices/lab_pin.sym} 109400 -35480 0 1 {name=p108309 lab=_57960_/Y }
C {sky130_stdcells/nor2_4.sym} 109340 -35480 0 0 {name=X_57960_ }
C {devices/lab_pin.sym} 109280 -35360 0 0 {name=p108310 lab=_65056_/Y }
C {devices/lab_pin.sym} 109280 -35320 0 0 {name=p108311 lab=_65068_/Y }
C {devices/lab_pin.sym} 109400 -35340 0 1 {name=p108312 lab=_65069_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -35340 0 0 {name=X_65069_ }
C {devices/lab_pin.sym} 109280 -35220 0 0 {name=p108313 lab=_44149_/A }
C {devices/lab_pin.sym} 109280 -35180 0 0 {name=p108314 lab=_42620_/Y }
C {devices/lab_pin.sym} 109400 -35200 0 1 {name=p108315 lab=_69946_/Y }
C {sky130_stdcells/nor2_4.sym} 109340 -35200 0 0 {name=X_69946_ }
C {devices/lab_pin.sym} 109280 -35080 0 0 {name=p108316 lab=_50279_/X }
C {devices/lab_pin.sym} 109280 -35040 0 0 {name=p108317 lab=_53520_/B }
C {devices/lab_pin.sym} 109400 -35060 0 1 {name=p108318 lab=_50295_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -35060 0 0 {name=X_50295_ }
C {devices/lab_pin.sym} 109250 -34930 0 0 {name=p108319 lab=_85704_/CLK }
C {devices/lab_pin.sym} 109250 -34910 0 0 {name=p108320 lab=_85992_/D }
C {devices/lab_pin.sym} 109430 -34930 0 1 {name=p108321 lab=_85992_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -34920 0 0 {name=X_85992_ }
C {devices/lab_pin.sym} 109280 -34810 0 0 {name=p108322 lab=_48287_/A }
C {devices/lab_pin.sym} 109280 -34770 0 0 {name=p108323 lab=_51972_/X }
C {devices/lab_pin.sym} 109280 -34730 0 0 {name=p108324 lab=_52033_/X }
C {devices/lab_pin.sym} 109400 -34770 0 1 {name=p108325 lab=_52034_/X }
C {sky130_stdcells/and3_4.sym} 109340 -34770 0 0 {name=X_52034_ }
C {devices/lab_pin.sym} 109280 -34640 0 0 {name=p108326 lab=_56876_/X }
C {devices/lab_pin.sym} 109280 -34600 0 0 {name=p108327 lab=_83330_/Q }
C {devices/lab_pin.sym} 109400 -34620 0 1 {name=p108328 lab=_56985_/D }
C {sky130_stdcells/nor2_4.sym} 109340 -34620 0 0 {name=X_56911_ }
C {devices/lab_pin.sym} 109250 -34490 0 0 {name=p108329 lab=_88180_/CLK }
C {devices/lab_pin.sym} 109250 -34470 0 0 {name=p108330 lab=_87731_/D }
C {devices/lab_pin.sym} 109430 -34490 0 1 {name=p108331 lab=_67333_/B }
C {sky130_stdcells/dfxtp_4.sym} 109340 -34480 0 0 {name=X_87731_ }
C {devices/lab_pin.sym} 109250 -34350 0 0 {name=p108332 lab=_82386_/CLK }
C {devices/lab_pin.sym} 109250 -34330 0 0 {name=p108333 lab=_84943_/D }
C {devices/lab_pin.sym} 109430 -34350 0 1 {name=p108334 lab=_84943_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -34340 0 0 {name=X_84943_ }
C {devices/lab_pin.sym} 109280 -34220 0 0 {name=p108335 lab=_84935_/Q }
C {devices/lab_pin.sym} 109280 -34180 0 0 {name=p108336 lab=_65713_/C }
C {devices/lab_pin.sym} 109400 -34200 0 1 {name=p108337 lab=_80066_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -34200 0 0 {name=X_80066_ }
C {devices/lab_pin.sym} 109280 -34080 0 0 {name=p108338 lab=_57952_/A }
C {devices/lab_pin.sym} 109280 -34040 0 0 {name=p108339 lab=_57891_/B }
C {devices/lab_pin.sym} 109400 -34060 0 1 {name=p108340 lab=_57891_/Y }
C {sky130_stdcells/nor2_4.sym} 109340 -34060 0 0 {name=X_57891_ }
C {devices/lab_pin.sym} 109280 -33940 0 0 {name=p108341 lab=_69877_/A }
C {devices/lab_pin.sym} 109280 -33900 0 0 {name=p108342 lab=_88316_/Q }
C {devices/lab_pin.sym} 109400 -33920 0 1 {name=p108343 lab=_69877_/X }
C {sky130_stdcells/and2_4.sym} 109340 -33920 0 0 {name=X_69877_ }
C {devices/lab_pin.sym} 109300 -33790 0 0 {name=p108344 lab=_59961_/A }
C {devices/lab_pin.sym} 109380 -33790 0 1 {name=p108345 lab=_65680_/A }
C {sky130_stdcells/buf_2.sym} 109340 -33790 0 0 {name=X_59630_ }
C {devices/lab_pin.sym} 109300 -33670 0 0 {name=p108346 lab=_56842_/A }
C {devices/lab_pin.sym} 109380 -33670 0 1 {name=p108347 lab=_56842_/X }
C {sky130_stdcells/buf_2.sym} 109340 -33670 0 0 {name=X_56842_ }
C {devices/lab_pin.sym} 109300 -33550 0 0 {name=p108348 lab=_57803_/A }
C {devices/lab_pin.sym} 109380 -33550 0 1 {name=p108349 lab=_69648_/A }
C {sky130_stdcells/buf_2.sym} 109340 -33550 0 0 {name=X_68828_ }
C {devices/lab_pin.sym} 109250 -33430 0 0 {name=p108350 lab=_87915_/CLK }
C {devices/lab_pin.sym} 109250 -33410 0 0 {name=p108351 lab=_87662_/D }
C {devices/lab_pin.sym} 109430 -33430 0 1 {name=p108352 lab=_87662_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -33420 0 0 {name=X_87662_ }
C {devices/lab_pin.sym} 109250 -33290 0 0 {name=p108353 lab=_83451_/CLK }
C {devices/lab_pin.sym} 109250 -33270 0 0 {name=p108354 lab=_84874_/D }
C {devices/lab_pin.sym} 109430 -33290 0 1 {name=p108355 lab=_58338_/A }
C {sky130_stdcells/dfxtp_4.sym} 109340 -33280 0 0 {name=X_84874_ }
C {devices/lab_pin.sym} 109250 -33150 0 0 {name=p108356 lab=_85969_/CLK }
C {devices/lab_pin.sym} 109250 -33130 0 0 {name=p108357 lab=_86613_/D }
C {devices/lab_pin.sym} 109430 -33150 0 1 {name=p108358 lab=_86613_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -33140 0 0 {name=X_86613_ }
C {devices/lab_pin.sym} 109280 -33030 0 0 {name=p108359 lab=_59557_/X }
C {devices/lab_pin.sym} 109280 -32990 0 0 {name=p108360 lab=_59598_/A }
C {devices/lab_pin.sym} 109280 -32950 0 0 {name=p108361 lab=_59890_/C }
C {devices/lab_pin.sym} 109400 -32990 0 1 {name=p108362 lab=_59751_/A }
C {sky130_stdcells/nand3_4.sym} 109340 -32990 0 0 {name=X_59561_ }
C {devices/lab_pin.sym} 109250 -32850 0 0 {name=p108363 lab=_83187_/CLK }
C {devices/lab_pin.sym} 109250 -32830 0 0 {name=p108364 lab=_83825_/D }
C {devices/lab_pin.sym} 109430 -32850 0 1 {name=p108365 lab=_74804_/B }
C {sky130_stdcells/dfxtp_4.sym} 109340 -32840 0 0 {name=X_83825_ }
C {devices/lab_pin.sym} 109260 -32730 0 0 {name=p108366 lab=_56771_/X }
C {devices/lab_pin.sym} 109260 -32690 0 0 {name=p108367 lab=_56772_/Y }
C {devices/lab_pin.sym} 109260 -32650 0 0 {name=p108368 lab=_44292_/A }
C {devices/lab_pin.sym} 109420 -32690 0 1 {name=p108369 lab=_56773_/Y }
C {sky130_stdcells/a21oi_4.sym} 109340 -32690 0 0 {name=X_56773_ }
C {devices/lab_pin.sym} 109280 -32560 0 0 {name=p108370 lab=_68759_/A }
C {devices/lab_pin.sym} 109280 -32520 0 0 {name=p108371 lab=_87236_/Q }
C {devices/lab_pin.sym} 109400 -32540 0 1 {name=p108372 lab=_68759_/X }
C {sky130_stdcells/and2_4.sym} 109340 -32540 0 0 {name=X_68759_ }
C {devices/lab_pin.sym} 109250 -32410 0 0 {name=p108373 lab=_87595_/CLK }
C {devices/lab_pin.sym} 109250 -32390 0 0 {name=p108374 lab=_43056_/Y }
C {devices/lab_pin.sym} 109430 -32410 0 1 {name=p108375 lab=_87593_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -32400 0 0 {name=X_87593_ }
C {devices/lab_pin.sym} 109280 -32280 0 0 {name=p108376 lab=_53956_/X }
C {devices/lab_pin.sym} 109280 -32240 0 0 {name=p108377 lab=_53985_/B }
C {devices/lab_pin.sym} 109400 -32260 0 1 {name=p108378 lab=_53985_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -32260 0 0 {name=X_53985_ }
C {devices/lab_pin.sym} 109260 -32150 0 0 {name=p108379 lab=_58492_/X }
C {devices/lab_pin.sym} 109260 -32110 0 0 {name=p108380 lab=_58508_/Y }
C {devices/lab_pin.sym} 109260 -32070 0 0 {name=p108381 lab=_58511_/Y }
C {devices/lab_pin.sym} 109420 -32110 0 1 {name=p108382 lab=_58512_/Y }
C {sky130_stdcells/a21oi_4.sym} 109340 -32110 0 0 {name=X_58512_ }
C {devices/lab_pin.sym} 109280 -31980 0 0 {name=p108383 lab=_55245_/A }
C {devices/lab_pin.sym} 109280 -31940 0 0 {name=p108384 lab=_55724_/B }
C {devices/lab_pin.sym} 109400 -31960 0 1 {name=p108385 lab=_55724_/X }
C {sky130_stdcells/and2_4.sym} 109340 -31960 0 0 {name=X_55724_ }
C {devices/lab_pin.sym} 109250 -31830 0 0 {name=p108386 lab=_86549_/CLK }
C {devices/lab_pin.sym} 109250 -31810 0 0 {name=p108387 lab=_48278_/Y }
C {devices/lab_pin.sym} 109430 -31830 0 1 {name=p108388 lab=_66159_/B }
C {sky130_stdcells/dfxtp_4.sym} 109340 -31820 0 0 {name=X_86544_ }
C {devices/lab_pin.sym} 109280 -31700 0 0 {name=p108389 lab=_52944_/A }
C {devices/lab_pin.sym} 109280 -31660 0 0 {name=p108390 lab=_52936_/B }
C {devices/lab_pin.sym} 109400 -31680 0 1 {name=p108391 lab=_52936_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -31680 0 0 {name=X_52936_ }
C {devices/lab_pin.sym} 109300 -31550 0 0 {name=p108392 lab=_40950_/A }
C {devices/lab_pin.sym} 109380 -31550 0 1 {name=p108393 lab=_40950_/X }
C {sky130_stdcells/buf_2.sym} 109340 -31550 0 0 {name=X_40950_ }
C {devices/lab_pin.sym} 109280 -31450 0 0 {name=p108394 lab=_71763_/X }
C {devices/lab_pin.sym} 109280 -31410 0 0 {name=p108395 lab=_70476_/X }
C {devices/lab_pin.sym} 109280 -31370 0 0 {name=p108396 lab=_70794_/X }
C {devices/lab_pin.sym} 109400 -31410 0 1 {name=p108397 lab=_71770_/X }
C {sky130_stdcells/and3_4.sym} 109340 -31410 0 0 {name=X_71770_ }
C {devices/lab_pin.sym} 109250 -31270 0 0 {name=p108398 lab=_83756_/CLK }
C {devices/lab_pin.sym} 109250 -31250 0 0 {name=p108399 lab=_83756_/D }
C {devices/lab_pin.sym} 109430 -31270 0 1 {name=p108400 lab=_57674_/A }
C {sky130_stdcells/dfxtp_4.sym} 109340 -31260 0 0 {name=X_83756_ }
C {devices/lab_pin.sym} 109300 -31130 0 0 {name=p108401 lab=_84717_/Q }
C {devices/lab_pin.sym} 109380 -31130 0 1 {name=p108402 lab=_63410_/B }
C {sky130_stdcells/buf_2.sym} 109340 -31130 0 0 {name=X_59492_ }
C {devices/lab_pin.sym} 109250 -31010 0 0 {name=p108403 lab=_80968_/CLK }
C {devices/lab_pin.sym} 109250 -30990 0 0 {name=p108404 lab=_80968_/D }
C {devices/lab_pin.sym} 109430 -31010 0 1 {name=p108405 lab=_80956_/D }
C {sky130_stdcells/dfxtp_4.sym} 109340 -31000 0 0 {name=X_80968_ }
C {devices/lab_pin.sym} 109300 -30870 0 0 {name=p108406 lab=clkbuf_9_140_0_CLK/X }
C {devices/lab_pin.sym} 109380 -30870 0 1 {name=p108407 lab=_83421_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 109340 -30870 0 0 {name=Xclkbuf_10_281_0_CLK }
C {devices/lab_pin.sym} 109300 -30750 0 0 {name=p108408 lab=_70721_/A }
C {devices/lab_pin.sym} 109380 -30750 0 1 {name=p108409 lab=_70769_/D }
C {sky130_stdcells/buf_2.sym} 109340 -30750 0 0 {name=X_70721_ }
C {devices/lab_pin.sym} 109260 -30650 0 0 {name=p108410 lab=_58423_/X }
C {devices/lab_pin.sym} 109260 -30610 0 0 {name=p108411 lab=_83479_/Q }
C {devices/lab_pin.sym} 109260 -30570 0 0 {name=p108412 lab=_58442_/Y }
C {devices/lab_pin.sym} 109420 -30610 0 1 {name=p108413 lab=_84847_/D }
C {sky130_stdcells/o21a_4.sym} 109340 -30610 0 0 {name=X_58443_ }
C {devices/lab_pin.sym} 109250 -30470 0 0 {name=p108414 lab=_82665_/CLK }
C {devices/lab_pin.sym} 109250 -30450 0 0 {name=p108415 lab=_78965_/X }
C {devices/lab_pin.sym} 109430 -30470 0 1 {name=p108416 lab=_82663_/D }
C {sky130_stdcells/dfxtp_4.sym} 109340 -30460 0 0 {name=X_82707_ }
C {devices/lab_pin.sym} 109280 -30340 0 0 {name=p108417 lab=_55655_/A }
C {devices/lab_pin.sym} 109280 -30300 0 0 {name=p108418 lab=_55655_/B }
C {devices/lab_pin.sym} 109400 -30320 0 1 {name=p108419 lab=_55656_/A }
C {sky130_stdcells/and2_4.sym} 109340 -30320 0 0 {name=X_55655_ }
C {devices/lab_pin.sym} 109250 -30190 0 0 {name=p108420 lab=_86505_/CLK }
C {devices/lab_pin.sym} 109250 -30170 0 0 {name=p108421 lab=_86475_/D }
C {devices/lab_pin.sym} 109430 -30190 0 1 {name=p108422 lab=_86475_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -30180 0 0 {name=X_86475_ }
C {devices/lab_pin.sym} 109300 -30050 0 0 {name=p108423 lab=_40881_/A }
C {devices/lab_pin.sym} 109380 -30050 0 1 {name=p108424 lab=_40881_/X }
C {sky130_stdcells/buf_2.sym} 109340 -30050 0 0 {name=X_40881_ }
C {devices/lab_pin.sym} 109280 -29960 0 0 {name=p108425 lab=_52867_/A }
C {devices/lab_pin.sym} 109280 -29920 0 0 {name=p108426 lab=_52853_/B }
C {devices/lab_pin.sym} 109280 -29880 0 0 {name=p108427 lab=_52853_/C }
C {devices/lab_pin.sym} 109280 -29840 0 0 {name=p108428 lab=_52867_/D }
C {devices/lab_pin.sym} 109400 -29900 0 1 {name=p108429 lab=_52867_/X }
C {sky130_stdcells/and4_4.sym} 109340 -29900 0 0 {name=X_52867_ }
C {devices/lab_pin.sym} 109250 -29750 0 0 {name=p108430 lab=_82394_/CLK }
C {devices/lab_pin.sym} 109250 -29730 0 0 {name=p108431 lab=_70840_/Y }
C {devices/lab_pin.sym} 109430 -29750 0 1 {name=p108432 lab=_83687_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -29740 0 0 {name=X_83687_ }
C {devices/lab_pin.sym} 109250 -29610 0 0 {name=p108433 lab=_84074_/CLK }
C {devices/lab_pin.sym} 109250 -29590 0 0 {name=p108434 lab=_80899_/D }
C {devices/lab_pin.sym} 109430 -29610 0 1 {name=p108435 lab=_80899_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -29600 0 0 {name=X_80899_ }
C {devices/lab_pin.sym} 109250 -29470 0 0 {name=p108436 lab=_88208_/CLK }
C {devices/lab_pin.sym} 109250 -29450 0 0 {name=p108437 lab=_41444_/Y }
C {devices/lab_pin.sym} 109430 -29470 0 1 {name=p108438 lab=_88214_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -29460 0 0 {name=X_88214_ }
C {devices/lab_pin.sym} 109300 -29330 0 0 {name=p108439 lab=_73484_/A }
C {devices/lab_pin.sym} 109380 -29330 0 1 {name=p108440 lab=_42620_/Y }
C {sky130_stdcells/inv_2.sym} 109340 -29330 0 0 {name=X_42620_ }
C {devices/lab_pin.sym} 109260 -29230 0 0 {name=p108441 lab=_85411_/Q }
C {devices/lab_pin.sym} 109260 -29190 0 0 {name=p108442 lab=_54593_/X }
C {devices/lab_pin.sym} 109260 -29150 0 0 {name=p108443 lab=_54605_/Y }
C {devices/lab_pin.sym} 109420 -29190 0 1 {name=p108444 lab=_54606_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -29190 0 0 {name=X_54606_ }
C {devices/lab_pin.sym} 109280 -29060 0 0 {name=p108445 lab=_73440_/A }
C {devices/lab_pin.sym} 109280 -29020 0 0 {name=p108446 lab=_73577_/B }
C {devices/lab_pin.sym} 109400 -29040 0 1 {name=p108447 lab=_73440_/Y }
C {sky130_stdcells/nor2_4.sym} 109340 -29040 0 0 {name=X_73440_ }
C {devices/lab_pin.sym} 109250 -28910 0 0 {name=p108448 lab=_85651_/CLK }
C {devices/lab_pin.sym} 109250 -28890 0 0 {name=p108449 lab=_54527_/Y }
C {devices/lab_pin.sym} 109430 -28910 0 1 {name=p108450 lab=_85426_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -28900 0 0 {name=X_85426_ }
C {devices/lab_pin.sym} 109300 -28770 0 0 {name=p108451 lab=_50063_/A }
C {devices/lab_pin.sym} 109380 -28770 0 1 {name=p108452 lab=_53269_/A }
C {sky130_stdcells/buf_2.sym} 109340 -28770 0 0 {name=X_51818_ }
C {devices/lab_pin.sym} 109300 -28650 0 0 {name=p108453 lab=_70638_/A }
C {devices/lab_pin.sym} 109380 -28650 0 1 {name=p108454 lab=_70656_/D }
C {sky130_stdcells/buf_2.sym} 109340 -28650 0 0 {name=X_70652_ }
C {devices/lab_pin.sym} 109300 -28530 0 0 {name=p108455 lab=clkbuf_9_31_0_CLK/X }
C {devices/lab_pin.sym} 109380 -28530 0 1 {name=p108456 lab=_83335_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 109340 -28530 0 0 {name=Xclkbuf_10_63_0_CLK }
C {devices/lab_pin.sym} 109280 -28420 0 0 {name=p108457 lab=_58374_/A }
C {devices/lab_pin.sym} 109280 -28380 0 0 {name=p108458 lab=_58344_/B }
C {devices/lab_pin.sym} 109400 -28400 0 1 {name=p108459 lab=_58374_/Y }
C {sky130_stdcells/nor2_4.sym} 109340 -28400 0 0 {name=X_58374_ }
C {devices/lab_pin.sym} 109250 -28270 0 0 {name=p108460 lab=_84003_/CLK }
C {devices/lab_pin.sym} 109250 -28250 0 0 {name=p108461 lab=_82638_/D }
C {devices/lab_pin.sym} 109430 -28270 0 1 {name=p108462 lab=_82638_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -28260 0 0 {name=X_82638_ }
C {devices/lab_pin.sym} 109260 -28160 0 0 {name=p108463 lab=_45460_/A }
C {devices/lab_pin.sym} 109260 -28120 0 0 {name=p108464 lab=_55571_/X }
C {devices/lab_pin.sym} 109260 -28080 0 0 {name=p108465 lab=_55610_/A }
C {devices/lab_pin.sym} 109260 -28040 0 0 {name=p108466 lab=_55585_/Y }
C {devices/lab_pin.sym} 109420 -28100 0 1 {name=p108467 lab=_55586_/X }
C {sky130_stdcells/a211o_4.sym} 109340 -28100 0 0 {name=X_55586_ }
C {devices/lab_pin.sym} 109260 -27970 0 0 {name=p108468 lab=_52795_/Y }
C {devices/lab_pin.sym} 109260 -27930 0 0 {name=p108469 lab=_52783_/X }
C {devices/lab_pin.sym} 109260 -27890 0 0 {name=p108470 lab=_52797_/X }
C {devices/lab_pin.sym} 109420 -27930 0 1 {name=p108471 lab=_52798_/Y }
C {sky130_stdcells/a21oi_4.sym} 109340 -27930 0 0 {name=X_52798_ }
C {sky130_stdcells/decap_3.sym} 109340 -27760 0 0 {name=XPHY_30 }
C {devices/lab_pin.sym} 109260 -27630 0 0 {name=p108472 lab=_57324_/X }
C {devices/lab_pin.sym} 109260 -27590 0 0 {name=p108473 lab=_57318_/Y }
C {devices/lab_pin.sym} 109260 -27550 0 0 {name=p108474 lab=_56704_/X }
C {devices/lab_pin.sym} 109420 -27590 0 1 {name=p108475 lab=_57325_/Y }
C {sky130_stdcells/a21oi_4.sym} 109340 -27590 0 0 {name=X_57325_ }
C {sky130_stdcells/decap_3.sym} 109340 -27420 0 0 {name=XPHY_41 }
C {devices/lab_pin.sym} 109250 -27270 0 0 {name=p108476 lab=_88398_/CLK }
C {devices/lab_pin.sym} 109250 -27250 0 0 {name=p108477 lab=_41805_/Y }
C {devices/lab_pin.sym} 109430 -27270 0 1 {name=p108478 lab=_66621_/B }
C {sky130_stdcells/dfxtp_4.sym} 109340 -27260 0 0 {name=X_88145_ }
C {devices/lab_pin.sym} 109260 -27170 0 0 {name=p108479 lab=_42536_/X }
C {devices/lab_pin.sym} 109260 -27130 0 0 {name=p108480 lab=_42547_/X }
C {devices/lab_pin.sym} 109260 -27090 0 0 {name=p108481 lab=_40781_/X }
C {devices/lab_pin.sym} 109260 -27050 0 0 {name=p108482 lab=_42550_/Y }
C {devices/lab_pin.sym} 109260 -27010 0 0 {name=p108483 lab=_42538_/X }
C {devices/lab_pin.sym} 109420 -27090 0 1 {name=p108484 lab=_42551_/Y }
C {sky130_stdcells/o32ai_4.sym} 109340 -27090 0 0 {name=X_42551_ }
C {devices/lab_pin.sym} 109300 -26930 0 0 {name=p108485 lab=_54537_/A }
C {devices/lab_pin.sym} 109380 -26930 0 1 {name=p108486 lab=_54538_/C }
C {sky130_stdcells/buf_2.sym} 109340 -26930 0 0 {name=X_54537_ }
C {devices/lab_pin.sym} 109260 -26830 0 0 {name=p108487 lab=_69888_/B }
C {devices/lab_pin.sym} 109260 -26790 0 0 {name=p108488 lab=_73026_/X }
C {devices/lab_pin.sym} 109260 -26750 0 0 {name=p108489 lab=_73028_/X }
C {devices/lab_pin.sym} 109420 -26790 0 1 {name=p108490 lab=_73371_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -26790 0 0 {name=X_73371_ }
C {devices/lab_pin.sym} 109250 -26650 0 0 {name=p108491 lab=_86282_/CLK }
C {devices/lab_pin.sym} 109250 -26630 0 0 {name=p108492 lab=_85357_/D }
C {devices/lab_pin.sym} 109430 -26650 0 1 {name=p108493 lab=_85357_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -26640 0 0 {name=X_85357_ }
C {sky130_stdcells/decap_3.sym} 109340 -26480 0 0 {name=XPHY_52 }
C {devices/lab_pin.sym} 109300 -26330 0 0 {name=p108494 lab=_51814_/A }
C {devices/lab_pin.sym} 109380 -26330 0 1 {name=p108495 lab=_51749_/X }
C {sky130_stdcells/buf_2.sym} 109340 -26330 0 0 {name=X_51749_ }
C {devices/lab_pin.sym} 109300 -26210 0 0 {name=p108496 lab=_70582_/X }
C {devices/lab_pin.sym} 109380 -26210 0 1 {name=p108497 lab=_70583_/X }
C {sky130_stdcells/buf_2.sym} 109340 -26210 0 0 {name=X_70583_ }
C {devices/lab_pin.sym} 109250 -26090 0 0 {name=p108498 lab=_82879_/CLK }
C {devices/lab_pin.sym} 109250 -26070 0 0 {name=p108499 lab=_82569_/D }
C {devices/lab_pin.sym} 109430 -26090 0 1 {name=p108500 lab=_82569_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -26080 0 0 {name=X_82569_ }
C {sky130_stdcells/decap_3.sym} 109340 -25920 0 0 {name=XPHY_63 }
C {devices/lab_pin.sym} 109300 -25770 0 0 {name=p108501 lab=clkbuf_6_54_0_CLK/X }
C {devices/lab_pin.sym} 109380 -25770 0 1 {name=p108502 lab=clkbuf_8_217_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 109340 -25770 0 0 {name=Xclkbuf_7_108_0_CLK }
C {devices/lab_pin.sym} 109300 -25650 0 0 {name=p108503 lab=clkbuf_9_148_0_CLK/X }
C {devices/lab_pin.sym} 109380 -25650 0 1 {name=p108504 lab=_84299_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 109340 -25650 0 0 {name=Xclkbuf_10_296_0_CLK }
C {sky130_stdcells/decap_3.sym} 109340 -25500 0 0 {name=XPHY_74 }
C {devices/lab_pin.sym} 109300 -25350 0 0 {name=p108505 lab=_75110_/A }
C {devices/lab_pin.sym} 109380 -25350 0 1 {name=p108506 lab=_75113_/A }
C {sky130_stdcells/inv_2.sym} 109340 -25350 0 0 {name=X_75110_ }
C {devices/lab_pin.sym} 109260 -25250 0 0 {name=p108507 lab=_41481_/X }
C {devices/lab_pin.sym} 109260 -25210 0 0 {name=p108508 lab=_82329_/Q }
C {devices/lab_pin.sym} 109260 -25170 0 0 {name=p108509 lab=_41501_/X }
C {devices/lab_pin.sym} 109420 -25210 0 1 {name=p108510 lab=_41502_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -25210 0 0 {name=X_41502_ }
C {sky130_stdcells/decap_3.sym} 109340 -25040 0 0 {name=XPHY_85 }
C {devices/lab_pin.sym} 109260 -24920 0 0 {name=p108511 lab=_72313_/Y }
C {devices/lab_pin.sym} 109260 -24880 0 0 {name=p108512 lab=_72237_/X }
C {devices/lab_pin.sym} 109260 -24840 0 0 {name=p108513 lab=_72318_/X }
C {devices/lab_pin.sym} 109260 -24800 0 0 {name=p108514 lab=_72321_/X }
C {devices/lab_pin.sym} 109420 -24860 0 1 {name=p108515 lab=_83265_/D }
C {sky130_stdcells/a22oi_4.sym} 109340 -24860 0 0 {name=X_72322_ }
C {devices/lab_pin.sym} 109250 -24710 0 0 {name=p108516 lab=_84308_/CLK }
C {devices/lab_pin.sym} 109250 -24690 0 0 {name=p108517 lab=_63623_/Y }
C {devices/lab_pin.sym} 109430 -24710 0 1 {name=p108518 lab=_80400_/B }
C {sky130_stdcells/dfxtp_4.sym} 109340 -24700 0 0 {name=X_84308_ }
C {devices/lab_pin.sym} 109260 -24590 0 0 {name=p108519 lab=_85289_/Q }
C {devices/lab_pin.sym} 109260 -24550 0 0 {name=p108520 lab=_45269_/X }
C {devices/lab_pin.sym} 109260 -24510 0 0 {name=p108521 lab=_45229_/X }
C {devices/lab_pin.sym} 109420 -24550 0 1 {name=p108522 lab=_45270_/X }
C {sky130_stdcells/o21a_4.sym} 109340 -24550 0 0 {name=X_45270_ }
C {devices/lab_pin.sym} 109260 -24440 0 0 {name=p108523 lab=_57243_/X }
C {devices/lab_pin.sym} 109260 -24400 0 0 {name=p108524 lab=_56619_/X }
C {devices/lab_pin.sym} 109260 -24360 0 0 {name=p108525 lab=_85048_/Q }
C {devices/lab_pin.sym} 109260 -24320 0 0 {name=p108526 lab=_57245_/X }
C {devices/lab_pin.sym} 109420 -24380 0 1 {name=p108527 lab=_85048_/D }
C {sky130_stdcells/a2bb2o_4.sym} 109340 -24380 0 0 {name=X_57256_ }
C {devices/lab_pin.sym} 109280 -24240 0 0 {name=p108528 lab=_81529_/Q }
C {devices/lab_pin.sym} 109280 -24200 0 0 {name=p108529 lab=_76090_/B }
C {devices/lab_pin.sym} 109400 -24220 0 1 {name=p108530 lab=_76090_/X }
C {sky130_stdcells/xor2_4.sym} 109340 -24220 0 0 {name=X_76090_ }
C {sky130_stdcells/decap_3.sym} 109340 -24060 0 0 {name=XPHY_96 }
C {devices/lab_pin.sym} 109300 -23910 0 0 {name=p108531 lab=_42482_/A }
C {devices/lab_pin.sym} 109380 -23910 0 1 {name=p108532 lab=_42482_/Y }
C {sky130_stdcells/inv_2.sym} 109340 -23910 0 0 {name=X_42482_ }
C {devices/lab_pin.sym} 109250 -23790 0 0 {name=p108533 lab=_87821_/CLK }
C {devices/lab_pin.sym} 109250 -23770 0 0 {name=p108534 lab=_88076_/D }
C {devices/lab_pin.sym} 109430 -23790 0 1 {name=p108535 lab=_88076_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -23780 0 0 {name=X_88076_ }
C {devices/lab_pin.sym} 109260 -23670 0 0 {name=p108536 lab=_54465_/Y }
C {devices/lab_pin.sym} 109260 -23630 0 0 {name=p108537 lab=_54448_/X }
C {devices/lab_pin.sym} 109260 -23590 0 0 {name=p108538 lab=_54467_/X }
C {devices/lab_pin.sym} 109420 -23630 0 1 {name=p108539 lab=_85437_/D }
C {sky130_stdcells/a21oi_4.sym} 109340 -23630 0 0 {name=X_54468_ }
C {devices/lab_pin.sym} 109250 -23490 0 0 {name=p108540 lab=_83016_/CLK }
C {devices/lab_pin.sym} 109250 -23470 0 0 {name=p108541 lab=_85288_/D }
C {devices/lab_pin.sym} 109430 -23490 0 1 {name=p108542 lab=_56145_/C }
C {sky130_stdcells/dfxtp_4.sym} 109340 -23480 0 0 {name=X_85288_ }
C {devices/lab_pin.sym} 109300 -23350 0 0 {name=p108543 lab=_44146_/A }
C {devices/lab_pin.sym} 109380 -23350 0 1 {name=p108544 lab=_68057_/A }
C {sky130_stdcells/buf_2.sym} 109340 -23350 0 0 {name=X_44221_ }
C {devices/lab_pin.sym} 109260 -23250 0 0 {name=p108545 lab=_56031_/X }
C {devices/lab_pin.sym} 109260 -23210 0 0 {name=p108546 lab=_56195_/X }
C {devices/lab_pin.sym} 109260 -23170 0 0 {name=p108547 lab=_56206_/Y }
C {devices/lab_pin.sym} 109420 -23210 0 1 {name=p108548 lab=_56207_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -23210 0 0 {name=X_56207_ }
C {devices/lab_pin.sym} 109300 -23070 0 0 {name=p108549 lab=clkbuf_9_39_0_CLK/X }
C {devices/lab_pin.sym} 109380 -23070 0 1 {name=p108550 lab=_86873_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 109340 -23070 0 0 {name=Xclkbuf_10_78_0_CLK }
C {devices/lab_pin.sym} 109280 -22960 0 0 {name=p108551 lab=_75039_/X }
C {devices/lab_pin.sym} 109280 -22920 0 0 {name=p108552 lab=_75051_/B }
C {devices/lab_pin.sym} 109400 -22940 0 1 {name=p108553 lab=_75041_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -22940 0 0 {name=X_75041_ }
C {devices/lab_pin.sym} 109300 -22810 0 0 {name=p108554 lab=_41432_/Y }
C {devices/lab_pin.sym} 109380 -22810 0 1 {name=p108555 lab=_41433_/X }
C {sky130_stdcells/buf_2.sym} 109340 -22810 0 0 {name=X_41433_ }
C {devices/lab_pin.sym} 109250 -22690 0 0 {name=p108556 lab=_87032_/CLK }
C {devices/lab_pin.sym} 109250 -22670 0 0 {name=p108557 lab=_44629_/Y }
C {devices/lab_pin.sym} 109430 -22690 0 1 {name=p108558 lab=_87027_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -22680 0 0 {name=X_87027_ }
C {devices/lab_pin.sym} 109300 -22550 0 0 {name=p108559 lab=_53418_/X }
C {devices/lab_pin.sym} 109380 -22550 0 1 {name=p108560 lab=_53420_/A }
C {sky130_stdcells/buf_2.sym} 109340 -22550 0 0 {name=X_53419_ }
C {devices/lab_pin.sym} 109280 -22440 0 0 {name=p108561 lab=_86614_/Q }
C {devices/lab_pin.sym} 109280 -22400 0 0 {name=p108562 lab=_72348_/B }
C {devices/lab_pin.sym} 109400 -22420 0 1 {name=p108563 lab=_72253_/Y }
C {sky130_stdcells/nor2_4.sym} 109340 -22420 0 0 {name=X_72253_ }
C {devices/lab_pin.sym} 109250 -22290 0 0 {name=p108564 lab=_84603_/CLK }
C {devices/lab_pin.sym} 109250 -22270 0 0 {name=p108565 lab=_64510_/Y }
C {devices/lab_pin.sym} 109430 -22290 0 1 {name=p108566 lab=_79605_/B }
C {sky130_stdcells/dfxtp_4.sym} 109340 -22280 0 0 {name=X_84239_ }
C {devices/lab_pin.sym} 109300 -22150 0 0 {name=p108567 lab=_57187_/A }
C {devices/lab_pin.sym} 109380 -22150 0 1 {name=p108568 lab=_57188_/A }
C {sky130_stdcells/buf_2.sym} 109340 -22150 0 0 {name=X_57187_ }
C {devices/lab_pin.sym} 109300 -22030 0 0 {name=p108569 lab=_54399_/A }
C {devices/lab_pin.sym} 109380 -22030 0 1 {name=p108570 lab=_54399_/X }
C {sky130_stdcells/buf_2.sym} 109340 -22030 0 0 {name=X_54399_ }
C {devices/lab_pin.sym} 109300 -21910 0 0 {name=p108571 lab=clkbuf_8_225_0_CLK/A }
C {devices/lab_pin.sym} 109380 -21910 0 1 {name=p108572 lab=clkbuf_8_224_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 109340 -21910 0 0 {name=Xclkbuf_8_224_0_CLK }
C {devices/lab_pin.sym} 109300 -21790 0 0 {name=p108573 lab=_70387_/A }
C {devices/lab_pin.sym} 109380 -21790 0 1 {name=p108574 lab=_71228_/B }
C {sky130_stdcells/buf_2.sym} 109340 -21790 0 0 {name=X_71204_ }
C {devices/lab_pin.sym} 109300 -21670 0 0 {name=p108575 lab=_44152_/A }
C {devices/lab_pin.sym} 109380 -21670 0 1 {name=p108576 lab=_44265_/D }
C {sky130_stdcells/buf_2.sym} 109340 -21670 0 0 {name=X_44152_ }
C {devices/lab_pin.sym} 109280 -21560 0 0 {name=p108577 lab=_55773_/D }
C {devices/lab_pin.sym} 109280 -21520 0 0 {name=p108578 lab=_56138_/B }
C {devices/lab_pin.sym} 109400 -21540 0 1 {name=p108579 lab=_56138_/Y }
C {sky130_stdcells/xnor2_4.sym} 109340 -21540 0 0 {name=X_56138_ }
C {devices/lab_pin.sym} 109260 -21440 0 0 {name=p108580 lab=_41361_/X }
C {devices/lab_pin.sym} 109260 -21400 0 0 {name=p108581 lab=_41362_/X }
C {devices/lab_pin.sym} 109260 -21360 0 0 {name=p108582 lab=_67672_/B }
C {devices/lab_pin.sym} 109260 -21320 0 0 {name=p108583 lab=_41363_/X }
C {devices/lab_pin.sym} 109420 -21380 0 1 {name=p108584 lab=_88229_/D }
C {sky130_stdcells/a2bb2o_4.sym} 109340 -21380 0 0 {name=X_41364_ }
C {devices/lab_pin.sym} 109260 -21250 0 0 {name=p108585 lab=_59368_/X }
C {devices/lab_pin.sym} 109260 -21210 0 0 {name=p108586 lab=_85980_/Q }
C {devices/lab_pin.sym} 109260 -21170 0 0 {name=p108587 lab=_72183_/X }
C {devices/lab_pin.sym} 109420 -21210 0 1 {name=p108588 lab=_72184_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -21210 0 0 {name=X_72184_ }
C {devices/lab_pin.sym} 109300 -21070 0 0 {name=p108589 lab=_43103_/A }
C {devices/lab_pin.sym} 109380 -21070 0 1 {name=p108590 lab=_43103_/Y }
C {sky130_stdcells/inv_2.sym} 109340 -21070 0 0 {name=X_43103_ }
C {devices/lab_pin.sym} 109280 -20970 0 0 {name=p108591 lab=_78797_/A }
C {devices/lab_pin.sym} 109280 -20930 0 0 {name=p108592 lab=_78798_/A }
C {devices/lab_pin.sym} 109280 -20890 0 0 {name=p108593 lab=_78797_/B }
C {devices/lab_pin.sym} 109400 -20930 0 1 {name=p108594 lab=_78801_/B }
C {sky130_stdcells/nand3_4.sym} 109340 -20930 0 0 {name=X_78800_ }
C {devices/lab_pin.sym} 109300 -20790 0 0 {name=p108595 lab=_70428_/A }
C {devices/lab_pin.sym} 109380 -20790 0 1 {name=p108596 lab=_71137_/A }
C {sky130_stdcells/buf_2.sym} 109340 -20790 0 0 {name=X_71135_ }
C {devices/lab_pin.sym} 109260 -20690 0 0 {name=p108597 lab=_50599_/A }
C {devices/lab_pin.sym} 109260 -20650 0 0 {name=p108598 lab=_50599_/B }
C {devices/lab_pin.sym} 109260 -20610 0 0 {name=p108599 lab=_48917_/X }
C {devices/lab_pin.sym} 109420 -20650 0 1 {name=p108600 lab=_48960_/X }
C {sky130_stdcells/o21a_4.sym} 109340 -20650 0 0 {name=X_48960_ }
C {devices/lab_pin.sym} 109300 -20510 0 0 {name=p108601 lab=_55620_/A }
C {devices/lab_pin.sym} 109380 -20510 0 1 {name=p108602 lab=_44085_/C }
C {sky130_stdcells/buf_2.sym} 109340 -20510 0 0 {name=X_44083_ }
C {devices/lab_pin.sym} 109280 -20400 0 0 {name=p108603 lab=_74317_/C }
C {devices/lab_pin.sym} 109280 -20360 0 0 {name=p108604 lab=_56068_/X }
C {devices/lab_pin.sym} 109400 -20380 0 1 {name=p108605 lab=_56069_/Y }
C {sky130_stdcells/xnor2_4.sym} 109340 -20380 0 0 {name=X_56069_ }
C {devices/lab_pin.sym} 109280 -20260 0 0 {name=p108606 lab=_79777_/X }
C {devices/lab_pin.sym} 109280 -20220 0 0 {name=p108607 lab=_79780_/B }
C {devices/lab_pin.sym} 109400 -20240 0 1 {name=p108608 lab=_79780_/Y }
C {sky130_stdcells/xnor2_4.sym} 109340 -20240 0 0 {name=X_79780_ }
C {devices/lab_pin.sym} 109260 -20140 0 0 {name=p108609 lab=_41294_/X }
C {devices/lab_pin.sym} 109260 -20100 0 0 {name=p108610 lab=_41283_/X }
C {devices/lab_pin.sym} 109260 -20060 0 0 {name=p108611 lab=_67373_/B }
C {devices/lab_pin.sym} 109260 -20020 0 0 {name=p108612 lab=_41284_/X }
C {devices/lab_pin.sym} 109420 -20080 0 1 {name=p108613 lab=_88242_/D }
C {sky130_stdcells/a2bb2o_4.sym} 109340 -20080 0 0 {name=X_41295_ }
C {devices/lab_pin.sym} 109280 -19940 0 0 {name=p108614 lab=_84544_/Q }
C {devices/lab_pin.sym} 109280 -19900 0 0 {name=p108615 lab=_84416_/Q }
C {devices/lab_pin.sym} 109400 -19920 0 1 {name=p108616 lab=_76992_/X }
C {sky130_stdcells/xor2_4.sym} 109340 -19920 0 0 {name=X_76992_ }
C {devices/lab_pin.sym} 109300 -19790 0 0 {name=p108617 lab=clkbuf_9_341_0_CLK/A }
C {devices/lab_pin.sym} 109380 -19790 0 1 {name=p108618 lab=clkbuf_9_340_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 109340 -19790 0 0 {name=Xclkbuf_9_340_0_CLK }
C {devices/lab_pin.sym} 109300 -19670 0 0 {name=p108619 lab=_57523_/B }
C {devices/lab_pin.sym} 109380 -19670 0 1 {name=p108620 lab=_50268_/B }
C {sky130_stdcells/buf_2.sym} 109340 -19670 0 0 {name=X_47911_ }
C {devices/lab_pin.sym} 109300 -19550 0 0 {name=p108621 lab=_43058_/A }
C {devices/lab_pin.sym} 109380 -19550 0 1 {name=p108622 lab=_43034_/X }
C {sky130_stdcells/buf_2.sym} 109340 -19550 0 0 {name=X_43034_ }
C {devices/lab_pin.sym} 109300 -19430 0 0 {name=p108623 lab=_78731_/A }
C {devices/lab_pin.sym} 109380 -19430 0 1 {name=p108624 lab=_78732_/C }
C {sky130_stdcells/inv_2.sym} 109340 -19430 0 0 {name=X_78731_ }
C {devices/lab_pin.sym} 109280 -19330 0 0 {name=p108625 lab=_71058_/A }
C {devices/lab_pin.sym} 109280 -19290 0 0 {name=p108626 lab=_71066_/B }
C {devices/lab_pin.sym} 109280 -19250 0 0 {name=p108627 lab=_71066_/C }
C {devices/lab_pin.sym} 109400 -19290 0 1 {name=p108628 lab=_71066_/Y }
C {sky130_stdcells/nand3_4.sym} 109340 -19290 0 0 {name=X_71066_ }
C {devices/lab_pin.sym} 109280 -19160 0 0 {name=p108629 lab=_75940_/Y }
C {devices/lab_pin.sym} 109280 -19120 0 0 {name=p108630 lab=_75942_/Y }
C {devices/lab_pin.sym} 109400 -19140 0 1 {name=p108631 lab=_75944_/B }
C {sky130_stdcells/xor2_4.sym} 109340 -19140 0 0 {name=X_75943_ }
C {devices/lab_pin.sym} 109250 -19010 0 0 {name=p108632 lab=_87417_/CLK }
C {devices/lab_pin.sym} 109250 -18990 0 0 {name=p108633 lab=_87929_/D }
C {devices/lab_pin.sym} 109430 -19010 0 1 {name=p108634 lab=_87929_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -19000 0 0 {name=X_87929_ }
C {devices/lab_pin.sym} 109280 -18880 0 0 {name=p108635 lab=_48642_/A }
C {devices/lab_pin.sym} 109280 -18840 0 0 {name=p108636 lab=_48891_/B }
C {devices/lab_pin.sym} 109400 -18860 0 1 {name=p108637 lab=_48891_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -18860 0 0 {name=X_48891_ }
C {devices/lab_pin.sym} 109300 -18730 0 0 {name=p108638 lab=clkbuf_8_239_0_CLK/A }
C {devices/lab_pin.sym} 109380 -18730 0 1 {name=p108639 lab=clkbuf_9_479_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 109340 -18730 0 0 {name=Xclkbuf_8_239_0_CLK }
C {devices/lab_pin.sym} 109300 -18610 0 0 {name=p108640 lab=clkbuf_9_117_0_CLK/X }
C {devices/lab_pin.sym} 109380 -18610 0 1 {name=p108641 lab=_80817_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 109340 -18610 0 0 {name=Xclkbuf_10_234_0_CLK }
C {devices/lab_pin.sym} 109260 -18520 0 0 {name=p108642 lab=_70011_/X }
C {devices/lab_pin.sym} 109260 -18480 0 0 {name=p108643 lab=_68597_/Y }
C {devices/lab_pin.sym} 109260 -18440 0 0 {name=p108644 lab=_70012_/X }
C {devices/lab_pin.sym} 109260 -18400 0 0 {name=p108645 lab=_70016_/Y }
C {devices/lab_pin.sym} 109420 -18460 0 1 {name=p108646 lab=_70017_/X }
C {sky130_stdcells/a211o_4.sym} 109340 -18460 0 0 {name=X_70017_ }
C {devices/lab_pin.sym} 109300 -18310 0 0 {name=p108647 lab=_47842_/A }
C {devices/lab_pin.sym} 109380 -18310 0 1 {name=p108648 lab=_73591_/A }
C {sky130_stdcells/inv_2.sym} 109340 -18310 0 0 {name=X_47842_ }
C {devices/lab_pin.sym} 109300 -18190 0 0 {name=p108649 lab=_59512_/A }
C {devices/lab_pin.sym} 109380 -18190 0 1 {name=p108650 lab=_59875_/A }
C {sky130_stdcells/buf_2.sym} 109340 -18190 0 0 {name=X_59828_ }
C {devices/lab_pin.sym} 109300 -18070 0 0 {name=p108651 lab=_78661_/Y }
C {devices/lab_pin.sym} 109380 -18070 0 1 {name=p108652 lab=_78663_/C }
C {sky130_stdcells/inv_2.sym} 109340 -18070 0 0 {name=X_78662_ }
C {devices/lab_pin.sym} 109280 -17960 0 0 {name=p108653 lab=_75870_/Y }
C {devices/lab_pin.sym} 109280 -17920 0 0 {name=p108654 lab=_75873_/Y }
C {devices/lab_pin.sym} 109400 -17940 0 1 {name=p108655 lab=_75876_/A }
C {sky130_stdcells/nand2_4.sym} 109340 -17940 0 0 {name=X_75874_ }
C {devices/lab_pin.sym} 109300 -17810 0 0 {name=p108656 lab=clkbuf_9_432_0_CLK/X }
C {devices/lab_pin.sym} 109380 -17810 0 1 {name=p108657 lab=_86553_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 109340 -17810 0 0 {name=Xclkbuf_10_864_0_CLK }
C {devices/lab_pin.sym} 109300 -17690 0 0 {name=p108658 lab=_77612_/Y }
C {devices/lab_pin.sym} 109380 -17690 0 1 {name=p108659 lab=_77614_/C }
C {sky130_stdcells/inv_2.sym} 109340 -17690 0 0 {name=X_77613_ }
C {devices/lab_pin.sym} 109300 -17570 0 0 {name=p108660 lab=clkbuf_9_8_0_CLK/X }
C {devices/lab_pin.sym} 109380 -17570 0 1 {name=p108661 lab=_85167_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 109340 -17570 0 0 {name=Xclkbuf_10_16_0_CLK }
C {devices/lab_pin.sym} 109280 -17460 0 0 {name=p108662 lab=_74829_/A }
C {devices/lab_pin.sym} 109280 -17420 0 0 {name=p108663 lab=_46087_/A }
C {devices/lab_pin.sym} 109400 -17440 0 1 {name=p108664 lab=_74826_/A }
C {sky130_stdcells/nand2_4.sym} 109340 -17440 0 0 {name=X_74825_ }
C {devices/lab_pin.sym} 109280 -17320 0 0 {name=p108665 lab=_47799_/A }
C {devices/lab_pin.sym} 109280 -17280 0 0 {name=p108666 lab=_53236_/B }
C {devices/lab_pin.sym} 109400 -17300 0 1 {name=p108667 lab=_47773_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -17300 0 0 {name=X_47773_ }
C {devices/lab_pin.sym} 109300 -17170 0 0 {name=p108668 lab=_59806_/A }
C {devices/lab_pin.sym} 109380 -17170 0 1 {name=p108669 lab=_59761_/A }
C {sky130_stdcells/buf_2.sym} 109340 -17170 0 0 {name=X_59759_ }
C {devices/lab_pin.sym} 109280 -17060 0 0 {name=p108670 lab=_78600_/B }
C {devices/lab_pin.sym} 109280 -17020 0 0 {name=p108671 lab=_78593_/B }
C {devices/lab_pin.sym} 109400 -17040 0 1 {name=p108672 lab=_82773_/D }
C {sky130_stdcells/xnor2_4.sym} 109340 -17040 0 0 {name=X_78593_ }
C {devices/lab_pin.sym} 109300 -16910 0 0 {name=p108673 lab=_44887_/X }
C {devices/lab_pin.sym} 109380 -16910 0 1 {name=p108674 lab=_45212_/A }
C {sky130_stdcells/buf_2.sym} 109340 -16910 0 0 {name=X_44985_ }
C {devices/lab_pin.sym} 109300 -16790 0 0 {name=p108675 lab=clkbuf_9_355_0_CLK/A }
C {devices/lab_pin.sym} 109380 -16790 0 1 {name=p108676 lab=clkbuf_9_355_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 109340 -16790 0 0 {name=Xclkbuf_9_355_0_CLK }
C {devices/lab_pin.sym} 109280 -16680 0 0 {name=p108677 lab=_49502_/A }
C {devices/lab_pin.sym} 109280 -16640 0 0 {name=p108678 lab=_51037_/B }
C {devices/lab_pin.sym} 109400 -16660 0 1 {name=p108679 lab=_49512_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -16660 0 0 {name=X_49512_ }
C {devices/lab_pin.sym} 109260 -16550 0 0 {name=p108680 lab=_58700_/A }
C {devices/lab_pin.sym} 109260 -16510 0 0 {name=p108681 lab=_46719_/X }
C {devices/lab_pin.sym} 109260 -16470 0 0 {name=p108682 lab=_46723_/Y }
C {devices/lab_pin.sym} 109420 -16510 0 1 {name=p108683 lab=_46724_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -16510 0 0 {name=X_46724_ }
C {devices/lab_pin.sym} 109280 -16380 0 0 {name=p108684 lab=_77520_/B }
C {devices/lab_pin.sym} 109280 -16340 0 0 {name=p108685 lab=_77516_/X }
C {devices/lab_pin.sym} 109400 -16360 0 1 {name=p108686 lab=_77561_/B }
C {sky130_stdcells/nand2_4.sym} 109340 -16360 0 0 {name=X_77544_ }
C {devices/lab_pin.sym} 109260 -16270 0 0 {name=p108687 lab=_43916_/X }
C {devices/lab_pin.sym} 109260 -16230 0 0 {name=p108688 lab=_43924_/X }
C {devices/lab_pin.sym} 109260 -16190 0 0 {name=p108689 lab=_41442_/X }
C {devices/lab_pin.sym} 109260 -16150 0 0 {name=p108690 lab=_87190_/Q }
C {devices/lab_pin.sym} 109260 -16110 0 0 {name=p108691 lab=_43917_/X }
C {devices/lab_pin.sym} 109420 -16190 0 1 {name=p108692 lab=_43937_/A }
C {sky130_stdcells/o32ai_4.sym} 109340 -16190 0 0 {name=X_43936_ }
C {devices/lab_pin.sym} 109280 -16060 0 0 {name=p108693 lab=_74775_/A }
C {devices/lab_pin.sym} 109280 -16020 0 0 {name=p108694 lab=_74756_/B }
C {devices/lab_pin.sym} 109280 -15980 0 0 {name=p108695 lab=_70884_/A }
C {devices/lab_pin.sym} 109280 -15940 0 0 {name=p108696 lab=_70662_/X }
C {devices/lab_pin.sym} 109400 -16000 0 1 {name=p108697 lab=_74756_/X }
C {sky130_stdcells/and4_4.sym} 109340 -16000 0 0 {name=X_74756_ }
C {devices/lab_pin.sym} 109280 -15880 0 0 {name=p108698 lab=_62819_/A }
C {devices/lab_pin.sym} 109280 -15840 0 0 {name=p108699 lab=_64335_/C }
C {devices/lab_pin.sym} 109280 -15800 0 0 {name=p108700 lab=_62737_/X }
C {devices/lab_pin.sym} 109280 -15760 0 0 {name=p108701 lab=_62738_/D }
C {devices/lab_pin.sym} 109400 -15820 0 1 {name=p108702 lab=_62770_/X }
C {sky130_stdcells/and4_4.sym} 109340 -15820 0 0 {name=X_62770_ }
C {devices/lab_pin.sym} 109260 -15690 0 0 {name=p108703 lab=_83311_/Q }
C {devices/lab_pin.sym} 109260 -15650 0 0 {name=p108704 lab=_57635_/X }
C {devices/lab_pin.sym} 109260 -15610 0 0 {name=p108705 lab=_71967_/Y }
C {devices/lab_pin.sym} 109420 -15650 0 1 {name=p108706 lab=_71968_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -15650 0 0 {name=X_71968_ }
C {devices/lab_pin.sym} 109300 -15510 0 0 {name=p108707 lab=clkbuf_9_124_0_CLK/X }
C {devices/lab_pin.sym} 109380 -15510 0 1 {name=p108708 lab=_81883_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 109340 -15510 0 0 {name=Xclkbuf_10_249_0_CLK }
C {devices/lab_pin.sym} 109300 -15390 0 0 {name=p108709 lab=_49415_/A }
C {devices/lab_pin.sym} 109380 -15390 0 1 {name=p108710 lab=_49443_/X }
C {sky130_stdcells/buf_2.sym} 109340 -15390 0 0 {name=X_49443_ }
C {devices/lab_pin.sym} 109300 -15270 0 0 {name=p108711 lab=_61412_/A }
C {devices/lab_pin.sym} 109380 -15270 0 1 {name=p108712 lab=_61722_/A }
C {sky130_stdcells/buf_2.sym} 109340 -15270 0 0 {name=X_61721_ }
C {devices/lab_pin.sym} 109280 -15160 0 0 {name=p108713 lab=_73607_/A }
C {devices/lab_pin.sym} 109280 -15120 0 0 {name=p108714 lab=_73707_/B }
C {devices/lab_pin.sym} 109400 -15140 0 1 {name=p108715 lab=_73707_/X }
C {sky130_stdcells/and2_4.sym} 109340 -15140 0 0 {name=X_73707_ }
C {devices/lab_pin.sym} 109300 -15010 0 0 {name=p108716 lab=_46892_/A }
C {devices/lab_pin.sym} 109380 -15010 0 1 {name=p108717 lab=_46845_/A }
C {sky130_stdcells/buf_2.sym} 109340 -15010 0 0 {name=X_46655_ }
C {devices/lab_pin.sym} 109280 -14920 0 0 {name=p108718 lab=_70867_/A }
C {devices/lab_pin.sym} 109280 -14880 0 0 {name=p108719 lab=_70914_/B }
C {devices/lab_pin.sym} 109280 -14840 0 0 {name=p108720 lab=_70914_/C }
C {devices/lab_pin.sym} 109280 -14800 0 0 {name=p108721 lab=_70919_/D }
C {devices/lab_pin.sym} 109400 -14860 0 1 {name=p108722 lab=_70919_/Y }
C {sky130_stdcells/nand4_4.sym} 109340 -14860 0 0 {name=X_70919_ }
C {devices/lab_pin.sym} 109300 -14710 0 0 {name=p108723 lab=clkbuf_9_439_0_CLK/X }
C {devices/lab_pin.sym} 109380 -14710 0 1 {name=p108724 lab=_86149_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 109340 -14710 0 0 {name=Xclkbuf_10_879_0_CLK }
C {devices/lab_pin.sym} 109280 -14600 0 0 {name=p108725 lab=_77475_/A }
C {devices/lab_pin.sym} 109280 -14560 0 0 {name=p108726 lab=_77475_/B }
C {devices/lab_pin.sym} 109400 -14580 0 1 {name=p108727 lab=_77476_/A }
C {sky130_stdcells/nor2_4.sym} 109340 -14580 0 0 {name=X_77475_ }
C {devices/lab_pin.sym} 109300 -14450 0 0 {name=p108728 lab=_43867_/A }
C {devices/lab_pin.sym} 109380 -14450 0 1 {name=p108729 lab=_43867_/Y }
C {sky130_stdcells/inv_2.sym} 109340 -14450 0 0 {name=X_43867_ }
C {devices/lab_pin.sym} 109300 -14330 0 0 {name=p108730 lab=_74687_/A }
C {devices/lab_pin.sym} 109380 -14330 0 1 {name=p108731 lab=_74687_/Y }
C {sky130_stdcells/inv_2.sym} 109340 -14330 0 0 {name=X_74687_ }
C {devices/lab_pin.sym} 109260 -14230 0 0 {name=p108732 lab=_56842_/X }
C {devices/lab_pin.sym} 109260 -14190 0 0 {name=p108733 lab=_71892_/X }
C {devices/lab_pin.sym} 109260 -14150 0 0 {name=p108734 lab=_71898_/Y }
C {devices/lab_pin.sym} 109420 -14190 0 1 {name=p108735 lab=_83336_/D }
C {sky130_stdcells/o21ai_4.sym} 109340 -14190 0 0 {name=X_71899_ }
C {devices/lab_pin.sym} 109280 -14060 0 0 {name=p108736 lab=_84790_/Q }
C {devices/lab_pin.sym} 109280 -14020 0 0 {name=p108737 lab=_84110_/Q }
C {devices/lab_pin.sym} 109400 -14040 0 1 {name=p108738 lab=_79215_/A }
C {sky130_stdcells/or2_4.sym} 109340 -14040 0 0 {name=X_79214_ }
C {devices/lab_pin.sym} 109260 -13930 0 0 {name=p108739 lab=_45604_/Y }
C {devices/lab_pin.sym} 109260 -13890 0 0 {name=p108740 lab=_45605_/Y }
C {devices/lab_pin.sym} 109260 -13850 0 0 {name=p108741 lab=_44939_/B }
C {devices/lab_pin.sym} 109420 -13890 0 1 {name=p108742 lab=_45606_/X }
C {sky130_stdcells/o21a_4.sym} 109340 -13890 0 0 {name=X_45606_ }
C {devices/lab_pin.sym} 109300 -13750 0 0 {name=p108743 lab=_64440_/A }
C {devices/lab_pin.sym} 109380 -13750 0 1 {name=p108744 lab=_64440_/X }
C {sky130_stdcells/buf_2.sym} 109340 -13750 0 0 {name=X_64440_ }
C {devices/lab_pin.sym} 109300 -13630 0 0 {name=p108745 lab=_76426_/A }
C {devices/lab_pin.sym} 109380 -13630 0 1 {name=p108746 lab=_76430_/A }
C {sky130_stdcells/inv_2.sym} 109340 -13630 0 0 {name=X_76426_ }
C {devices/lab_pin.sym} 109260 -13550 0 0 {name=p108747 lab=_42816_/X }
C {devices/lab_pin.sym} 109260 -13510 0 0 {name=p108748 lab=_42817_/X }
C {devices/lab_pin.sym} 109260 -13470 0 0 {name=p108749 lab=_41442_/X }
C {devices/lab_pin.sym} 109260 -13430 0 0 {name=p108750 lab=_87702_/Q }
C {devices/lab_pin.sym} 109260 -13390 0 0 {name=p108751 lab=_42805_/X }
C {devices/lab_pin.sym} 109420 -13470 0 1 {name=p108752 lab=_42818_/Y }
C {sky130_stdcells/o32ai_4.sym} 109340 -13470 0 0 {name=X_42818_ }
C {devices/lab_pin.sym} 109280 -13330 0 0 {name=p108753 lab=_61608_/X }
C {devices/lab_pin.sym} 109280 -13290 0 0 {name=p108754 lab=_61652_/B }
C {devices/lab_pin.sym} 109280 -13250 0 0 {name=p108755 lab=_61675_/C }
C {devices/lab_pin.sym} 109400 -13290 0 1 {name=p108756 lab=_61652_/Y }
C {sky130_stdcells/nand3_4.sym} 109340 -13290 0 0 {name=X_61652_ }
C {devices/lab_pin.sym} 109280 -13180 0 0 {name=p108757 lab=_49374_/A }
C {devices/lab_pin.sym} 109280 -13140 0 0 {name=p108758 lab=_49369_/X }
C {devices/lab_pin.sym} 109280 -13100 0 0 {name=p108759 lab=_49380_/C }
C {devices/lab_pin.sym} 109280 -13060 0 0 {name=p108760 lab=_51761_/D }
C {devices/lab_pin.sym} 109400 -13120 0 1 {name=p108761 lab=_49374_/X }
C {sky130_stdcells/and4_4.sym} 109340 -13120 0 0 {name=X_49374_ }
C {devices/lab_pin.sym} 109280 -12980 0 0 {name=p108762 lab=_73638_/A }
C {devices/lab_pin.sym} 109280 -12940 0 0 {name=p108763 lab=_73638_/B }
C {devices/lab_pin.sym} 109400 -12960 0 1 {name=p108764 lab=_73638_/X }
C {sky130_stdcells/and2_4.sym} 109340 -12960 0 0 {name=X_73638_ }
C {devices/lab_pin.sym} 109300 -12830 0 0 {name=p108765 lab=_46585_/Y }
C {devices/lab_pin.sym} 109380 -12830 0 1 {name=p108766 lab=_51389_/B }
C {sky130_stdcells/buf_2.sym} 109340 -12830 0 0 {name=X_46586_ }
C {devices/lab_pin.sym} 109260 -12750 0 0 {name=p108767 lab=_43790_/X }
C {devices/lab_pin.sym} 109260 -12710 0 0 {name=p108768 lab=_43797_/X }
C {devices/lab_pin.sym} 109260 -12670 0 0 {name=p108769 lab=_41054_/X }
C {devices/lab_pin.sym} 109260 -12630 0 0 {name=p108770 lab=_69427_/B }
C {devices/lab_pin.sym} 109260 -12590 0 0 {name=p108771 lab=_43791_/X }
C {devices/lab_pin.sym} 109420 -12670 0 1 {name=p108772 lab=_43799_/A }
C {sky130_stdcells/o32ai_4.sym} 109340 -12670 0 0 {name=X_43798_ }
C {devices/lab_pin.sym} 109280 -12540 0 0 {name=p108773 lab=_60435_/C }
C {devices/lab_pin.sym} 109280 -12500 0 0 {name=p108774 lab=_60341_/A }
C {devices/lab_pin.sym} 109280 -12460 0 0 {name=p108775 lab=_60603_/C }
C {devices/lab_pin.sym} 109280 -12420 0 0 {name=p108776 lab=_60578_/Y }
C {devices/lab_pin.sym} 109400 -12480 0 1 {name=p108777 lab=_60603_/X }
C {sky130_stdcells/and4_4.sym} 109340 -12480 0 0 {name=X_60603_ }
C {devices/lab_pin.sym} 109280 -12340 0 0 {name=p108778 lab=_48348_/A }
C {devices/lab_pin.sym} 109280 -12300 0 0 {name=p108779 lab=_50368_/B }
C {devices/lab_pin.sym} 109400 -12320 0 1 {name=p108780 lab=_48325_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -12320 0 0 {name=X_48325_ }
C {devices/lab_pin.sym} 109280 -12200 0 0 {name=p108781 lab=_79145_/A }
C {devices/lab_pin.sym} 109280 -12160 0 0 {name=p108782 lab=_84477_/Q }
C {devices/lab_pin.sym} 109400 -12180 0 1 {name=p108783 lab=_79145_/X }
C {sky130_stdcells/xor2_4.sym} 109340 -12180 0 0 {name=X_79145_ }
C {devices/lab_pin.sym} 109300 -12050 0 0 {name=p108784 lab=_85016_/Q }
C {devices/lab_pin.sym} 109380 -12050 0 1 {name=p108785 lab=_55539_/B }
C {sky130_stdcells/inv_2.sym} 109340 -12050 0 0 {name=X_45537_ }
C {devices/lab_pin.sym} 109260 -11950 0 0 {name=p108786 lab=_64360_/Y }
C {devices/lab_pin.sym} 109260 -11910 0 0 {name=p108787 lab=_64370_/X }
C {devices/lab_pin.sym} 109260 -11870 0 0 {name=p108788 lab=_64328_/X }
C {devices/lab_pin.sym} 109420 -11910 0 1 {name=p108789 lab=_64371_/X }
C {sky130_stdcells/o21a_4.sym} 109340 -11910 0 0 {name=X_64371_ }
C {devices/lab_pin.sym} 109300 -11770 0 0 {name=p108790 lab=_76338_/A }
C {devices/lab_pin.sym} 109380 -11770 0 1 {name=p108791 lab=_76357_/Y }
C {sky130_stdcells/inv_2.sym} 109340 -11770 0 0 {name=X_76357_ }
C {devices/lab_pin.sym} 109300 -11650 0 0 {name=p108792 lab=_42749_/A }
C {devices/lab_pin.sym} 109380 -11650 0 1 {name=p108793 lab=_42749_/Y }
C {sky130_stdcells/inv_2.sym} 109340 -11650 0 0 {name=X_42749_ }
C {devices/lab_pin.sym} 109260 -11570 0 0 {name=p108794 lab=_61317_/X }
C {devices/lab_pin.sym} 109260 -11530 0 0 {name=p108795 lab=_72575_/A }
C {devices/lab_pin.sym} 109260 -11490 0 0 {name=p108796 lab=_61260_/X }
C {devices/lab_pin.sym} 109260 -11450 0 0 {name=p108797 lab=_61319_/X }
C {devices/lab_pin.sym} 109260 -11420 0 0 {name=p108798 lab=_61283_/Y }
C {devices/lab_pin.sym} 109420 -11490 0 1 {name=p108799 lab=_61583_/Y }
C {sky130_stdcells/a41oi_4.sym} 109340 -11490 0 0 {name=X_61583_ }
C {devices/lab_pin.sym} 109260 -11360 0 0 {name=p108800 lab=_73566_/X }
C {devices/lab_pin.sym} 109260 -11320 0 0 {name=p108801 lab=_84993_/Q }
C {devices/lab_pin.sym} 109260 -11280 0 0 {name=p108802 lab=_73385_/X }
C {devices/lab_pin.sym} 109260 -11240 0 0 {name=p108803 lab=_73568_/X }
C {devices/lab_pin.sym} 109420 -11300 0 1 {name=p108804 lab=_73569_/X }
C {sky130_stdcells/a211o_4.sym} 109340 -11300 0 0 {name=X_73569_ }
C {devices/lab_pin.sym} 109300 -11150 0 0 {name=p108805 lab=clkbuf_9_401_0_CLK/X }
C {devices/lab_pin.sym} 109380 -11150 0 1 {name=p108806 lab=_82015_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 109340 -11150 0 0 {name=Xclkbuf_10_802_0_CLK }
C {devices/lab_pin.sym} 109260 -11050 0 0 {name=p108807 lab=_66106_/Y }
C {devices/lab_pin.sym} 109260 -11010 0 0 {name=p108808 lab=_66065_/X }
C {devices/lab_pin.sym} 109260 -10970 0 0 {name=p108809 lab=_66109_/Y }
C {devices/lab_pin.sym} 109420 -11010 0 1 {name=p108810 lab=_84156_/D }
C {sky130_stdcells/a21o_4.sym} 109340 -11010 0 0 {name=X_66110_ }
C {devices/lab_pin.sym} 109280 -10900 0 0 {name=p108811 lab=_60454_/A }
C {devices/lab_pin.sym} 109280 -10860 0 0 {name=p108812 lab=_64524_/B }
C {devices/lab_pin.sym} 109280 -10820 0 0 {name=p108813 lab=_60441_/B }
C {devices/lab_pin.sym} 109280 -10780 0 0 {name=p108814 lab=_63237_/X }
C {devices/lab_pin.sym} 109400 -10840 0 1 {name=p108815 lab=_63322_/X }
C {sky130_stdcells/and4_4.sym} 109340 -10840 0 0 {name=X_63322_ }
C {devices/lab_pin.sym} 109260 -10710 0 0 {name=p108816 lab=_75304_/Y }
C {devices/lab_pin.sym} 109260 -10670 0 0 {name=p108817 lab=_75283_/Y }
C {devices/lab_pin.sym} 109260 -10630 0 0 {name=p108818 lab=_75307_/X }
C {devices/lab_pin.sym} 109420 -10670 0 1 {name=p108819 lab=_75308_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -10670 0 0 {name=X_75308_ }
C {devices/lab_pin.sym} 109300 -10530 0 0 {name=p108820 lab=_47984_/B }
C {devices/lab_pin.sym} 109380 -10530 0 1 {name=p108821 lab=_48257_/B }
C {sky130_stdcells/buf_2.sym} 109340 -10530 0 0 {name=X_48256_ }
C {devices/lab_pin.sym} 109260 -10430 0 0 {name=p108822 lab=_60533_/Y }
C {devices/lab_pin.sym} 109260 -10390 0 0 {name=p108823 lab=_60566_/A }
C {devices/lab_pin.sym} 109260 -10350 0 0 {name=p108824 lab=_65842_/A }
C {devices/lab_pin.sym} 109420 -10390 0 1 {name=p108825 lab=_60534_/Y }
C {sky130_stdcells/a21oi_4.sym} 109340 -10390 0 0 {name=X_60534_ }
C {devices/lab_pin.sym} 109260 -10280 0 0 {name=p108826 lab=_66947_/X }
C {devices/lab_pin.sym} 109260 -10240 0 0 {name=p108827 lab=_67078_/Y }
C {devices/lab_pin.sym} 109260 -10200 0 0 {name=p108828 lab=_67031_/X }
C {devices/lab_pin.sym} 109260 -10160 0 0 {name=p108829 lab=_67089_/Y }
C {devices/lab_pin.sym} 109420 -10220 0 1 {name=p108830 lab=_67090_/X }
C {sky130_stdcells/a211o_4.sym} 109340 -10220 0 0 {name=X_67090_ }
C {devices/lab_pin.sym} 109280 -10080 0 0 {name=p108831 lab=_79064_/A }
C {devices/lab_pin.sym} 109280 -10040 0 0 {name=p108832 lab=_79064_/B }
C {devices/lab_pin.sym} 109400 -10060 0 1 {name=p108833 lab=_79076_/Y }
C {sky130_stdcells/nor2_4.sym} 109340 -10060 0 0 {name=X_79076_ }
C {devices/lab_pin.sym} 109260 -9950 0 0 {name=p108834 lab=_45434_/X }
C {devices/lab_pin.sym} 109260 -9910 0 0 {name=p108835 lab=_61378_/A }
C {devices/lab_pin.sym} 109260 -9870 0 0 {name=p108836 lab=_45452_/X }
C {devices/lab_pin.sym} 109420 -9910 0 1 {name=p108837 lab=_45468_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -9910 0 0 {name=X_45468_ }
C {devices/lab_pin.sym} 109260 -9790 0 0 {name=p108838 lab=_81259_/Q }
C {devices/lab_pin.sym} 109260 -9750 0 0 {name=p108839 lab=_81515_/D }
C {devices/lab_pin.sym} 109260 -9710 0 0 {name=p108840 lab=_76282_/C }
C {devices/lab_pin.sym} 109420 -9750 0 1 {name=p108841 lab=_76288_/Y }
C {sky130_stdcells/a21boi_4.sym} 109340 -9750 0 0 {name=X_76288_ }
C {devices/lab_pin.sym} 109260 -9630 0 0 {name=p108842 lab=_59373_/A }
C {devices/lab_pin.sym} 109260 -9590 0 0 {name=p108843 lab=_47192_/X }
C {devices/lab_pin.sym} 109260 -9550 0 0 {name=p108844 lab=_47206_/Y }
C {devices/lab_pin.sym} 109420 -9590 0 1 {name=p108845 lab=_47207_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -9590 0 0 {name=X_47207_ }
C {devices/lab_pin.sym} 109280 -9460 0 0 {name=p108846 lab=_65980_/X }
C {devices/lab_pin.sym} 109280 -9420 0 0 {name=p108847 lab=_66041_/B }
C {devices/lab_pin.sym} 109400 -9440 0 1 {name=p108848 lab=_66041_/X }
C {sky130_stdcells/and2_4.sym} 109340 -9440 0 0 {name=X_66041_ }
C {devices/lab_pin.sym} 109280 -9320 0 0 {name=p108849 lab=_78021_/C }
C {devices/lab_pin.sym} 109280 -9280 0 0 {name=p108850 lab=_78027_/B }
C {devices/lab_pin.sym} 109400 -9300 0 1 {name=p108851 lab=_78031_/A }
C {sky130_stdcells/nand2_4.sym} 109340 -9300 0 0 {name=X_78027_ }
C {devices/lab_pin.sym} 109260 -9200 0 0 {name=p108852 lab=_41552_/X }
C {devices/lab_pin.sym} 109260 -9160 0 0 {name=p108853 lab=_44412_/X }
C {devices/lab_pin.sym} 109260 -9120 0 0 {name=p108854 lab=_87118_/Q }
C {devices/lab_pin.sym} 109260 -9080 0 0 {name=p108855 lab=_44413_/X }
C {devices/lab_pin.sym} 109420 -9140 0 1 {name=p108856 lab=_87118_/D }
C {sky130_stdcells/a2bb2o_4.sym} 109340 -9140 0 0 {name=X_44419_ }
C {devices/lab_pin.sym} 109280 -9020 0 0 {name=p108857 lab=_84844_/Q }
C {devices/lab_pin.sym} 109280 -8980 0 0 {name=p108858 lab=_63281_/B }
C {devices/lab_pin.sym} 109280 -8940 0 0 {name=p108859 lab=_63301_/C }
C {devices/lab_pin.sym} 109280 -8900 0 0 {name=p108860 lab=_63281_/D }
C {devices/lab_pin.sym} 109400 -8960 0 1 {name=p108861 lab=_63253_/X }
C {sky130_stdcells/or4_4.sym} 109340 -8960 0 0 {name=X_63253_ }
C {devices/lab_pin.sym} 109280 -8820 0 0 {name=p108862 lab=_75239_/A }
C {devices/lab_pin.sym} 109280 -8780 0 0 {name=p108863 lab=_80986_/Q }
C {devices/lab_pin.sym} 109400 -8800 0 1 {name=p108864 lab=_75251_/A }
C {sky130_stdcells/xor2_4.sym} 109340 -8800 0 0 {name=X_75239_ }
C {devices/lab_pin.sym} 109300 -8670 0 0 {name=p108865 lab=_48535_/A }
C {devices/lab_pin.sym} 109380 -8670 0 1 {name=p108866 lab=_48478_/A }
C {sky130_stdcells/buf_2.sym} 109340 -8670 0 0 {name=X_48187_ }
C {devices/lab_pin.sym} 109260 -8590 0 0 {name=p108867 lab=_60421_/B }
C {devices/lab_pin.sym} 109260 -8550 0 0 {name=p108868 lab=_60488_/A }
C {devices/lab_pin.sym} 109260 -8510 0 0 {name=p108869 lab=_60488_/B }
C {devices/lab_pin.sym} 109260 -8470 0 0 {name=p108870 lab=_60476_/C }
C {devices/lab_pin.sym} 109260 -8440 0 0 {name=p108871 lab=_59980_/X }
C {devices/lab_pin.sym} 109420 -8510 0 1 {name=p108872 lab=_60465_/Y }
C {sky130_stdcells/a41oi_4.sym} 109340 -8510 0 0 {name=X_60465_ }
C {devices/lab_pin.sym} 109260 -8380 0 0 {name=p108873 lab=_45393_/Y }
C {devices/lab_pin.sym} 109260 -8340 0 0 {name=p108874 lab=_45394_/X }
C {devices/lab_pin.sym} 109260 -8300 0 0 {name=p108875 lab=_45396_/X }
C {devices/lab_pin.sym} 109260 -8260 0 0 {name=p108876 lab=_45398_/Y }
C {devices/lab_pin.sym} 109420 -8320 0 1 {name=p108877 lab=_45399_/X }
C {sky130_stdcells/a211o_4.sym} 109340 -8320 0 0 {name=X_45399_ }
C {devices/lab_pin.sym} 109300 -8170 0 0 {name=p108878 lab=_62203_/Y }
C {devices/lab_pin.sym} 109380 -8170 0 1 {name=p108879 lab=_62620_/A }
C {sky130_stdcells/buf_2.sym} 109340 -8170 0 0 {name=X_62204_ }
C {devices/lab_pin.sym} 109260 -8070 0 0 {name=p108880 lab=_86666_/Q }
C {devices/lab_pin.sym} 109260 -8030 0 0 {name=p108881 lab=_47096_/X }
C {devices/lab_pin.sym} 109260 -7990 0 0 {name=p108882 lab=_47137_/Y }
C {devices/lab_pin.sym} 109420 -8030 0 1 {name=p108883 lab=_47138_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -8030 0 0 {name=X_47138_ }
C {devices/lab_pin.sym} 109260 -7930 0 0 {name=p108884 lab=_63177_/Y }
C {devices/lab_pin.sym} 109260 -7890 0 0 {name=p108885 lab=_63179_/X }
C {devices/lab_pin.sym} 109260 -7850 0 0 {name=p108886 lab=_63180_/X }
C {devices/lab_pin.sym} 109260 -7810 0 0 {name=p108887 lab=_63182_/X }
C {devices/lab_pin.sym} 109260 -7770 0 0 {name=p108888 lab=_63183_/X }
C {devices/lab_pin.sym} 109420 -7850 0 1 {name=p108889 lab=_63184_/Y }
C {sky130_stdcells/o41ai_4.sym} 109340 -7850 0 0 {name=X_63184_ }
C {devices/lab_pin.sym} 109300 -7690 0 0 {name=p108890 lab=clkbuf_9_408_0_CLK/X }
C {devices/lab_pin.sym} 109380 -7690 0 1 {name=p108891 lab=_82923_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 109340 -7690 0 0 {name=Xclkbuf_10_817_0_CLK }
C {devices/lab_pin.sym} 109300 -7570 0 0 {name=p108892 lab=_60395_/X }
C {devices/lab_pin.sym} 109380 -7570 0 1 {name=p108893 lab=_60459_/B }
C {sky130_stdcells/buf_2.sym} 109340 -7570 0 0 {name=X_60396_ }
C {devices/lab_pin.sym} 109280 -7460 0 0 {name=p108894 lab=_69795_/X }
C {devices/lab_pin.sym} 109280 -7420 0 0 {name=p108895 lab=_69800_/B }
C {devices/lab_pin.sym} 109400 -7440 0 1 {name=p108896 lab=_69800_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -7440 0 0 {name=X_69800_ }
C {devices/lab_pin.sym} 109280 -7340 0 0 {name=p108897 lab=_62037_/X }
C {devices/lab_pin.sym} 109280 -7300 0 0 {name=p108898 lab=_62021_/B }
C {devices/lab_pin.sym} 109280 -7260 0 0 {name=p108899 lab=_63672_/B }
C {devices/lab_pin.sym} 109280 -7220 0 0 {name=p108900 lab=_62020_/X }
C {devices/lab_pin.sym} 109400 -7280 0 1 {name=p108901 lab=_62135_/X }
C {sky130_stdcells/and4_4.sym} 109340 -7280 0 0 {name=X_62135_ }
C {devices/lab_pin.sym} 109300 -7130 0 0 {name=p108902 lab=_47069_/A }
C {devices/lab_pin.sym} 109380 -7130 0 1 {name=p108903 lab=_53353_/B }
C {sky130_stdcells/inv_2.sym} 109340 -7130 0 0 {name=X_47069_ }
C {devices/lab_pin.sym} 109280 -7020 0 0 {name=p108904 lab=_67992_/A }
C {devices/lab_pin.sym} 109280 -6980 0 0 {name=p108905 lab=_67992_/B }
C {devices/lab_pin.sym} 109400 -7000 0 1 {name=p108906 lab=_67992_/X }
C {sky130_stdcells/and2_4.sym} 109340 -7000 0 0 {name=X_67992_ }
C {devices/lab_pin.sym} 109280 -6880 0 0 {name=p108907 lab=_79973_/Y }
C {devices/lab_pin.sym} 109280 -6840 0 0 {name=p108908 lab=_79976_/Y }
C {devices/lab_pin.sym} 109400 -6860 0 1 {name=p108909 lab=_79978_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -6860 0 0 {name=X_79978_ }
C {devices/lab_pin.sym} 109300 -6730 0 0 {name=p108910 lab=clkbuf_8_154_0_CLK/X }
C {devices/lab_pin.sym} 109380 -6730 0 1 {name=p108911 lab=clkbuf_9_308_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 109340 -6730 0 0 {name=Xclkbuf_9_308_0_CLK }
C {devices/lab_pin.sym} 109260 -6630 0 0 {name=p108912 lab=_83901_/Q }
C {devices/lab_pin.sym} 109260 -6590 0 0 {name=p108913 lab=_69696_/X }
C {devices/lab_pin.sym} 109260 -6550 0 0 {name=p108914 lab=_69730_/X }
C {devices/lab_pin.sym} 109420 -6590 0 1 {name=p108915 lab=_83901_/D }
C {sky130_stdcells/a21bo_4.sym} 109340 -6590 0 0 {name=X_69731_ }
C {devices/lab_pin.sym} 109280 -6460 0 0 {name=p108916 lab=_50084_/A }
C {devices/lab_pin.sym} 109280 -6420 0 0 {name=p108917 lab=_52287_/B }
C {devices/lab_pin.sym} 109400 -6440 0 1 {name=p108918 lab=_50080_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -6440 0 0 {name=X_50080_ }
C {devices/lab_pin.sym} 109260 -6340 0 0 {name=p108919 lab=_88388_/Q }
C {devices/lab_pin.sym} 109260 -6300 0 0 {name=p108920 lab=_66868_/X }
C {devices/lab_pin.sym} 109260 -6260 0 0 {name=p108921 lab=_66919_/X }
C {devices/lab_pin.sym} 109260 -6220 0 0 {name=p108922 lab=_66942_/X }
C {devices/lab_pin.sym} 109420 -6280 0 1 {name=p108923 lab=_66943_/X }
C {sky130_stdcells/a211o_4.sym} 109340 -6280 0 0 {name=X_66943_ }
C {devices/lab_pin.sym} 109280 -6160 0 0 {name=p108924 lab=_59794_/X }
C {devices/lab_pin.sym} 109280 -6120 0 0 {name=p108925 lab=_62088_/B }
C {devices/lab_pin.sym} 109280 -6080 0 0 {name=p108926 lab=_62061_/Y }
C {devices/lab_pin.sym} 109280 -6040 0 0 {name=p108927 lab=_62066_/D }
C {devices/lab_pin.sym} 109400 -6100 0 1 {name=p108928 lab=_62066_/Y }
C {sky130_stdcells/nand4_4.sym} 109340 -6100 0 0 {name=X_62066_ }
C {devices/lab_pin.sym} 109280 -5960 0 0 {name=p108929 lab=_82848_/Q }
C {devices/lab_pin.sym} 109280 -5920 0 0 {name=p108930 lab=_82560_/Q }
C {devices/lab_pin.sym} 109400 -5940 0 1 {name=p108931 lab=_78930_/B }
C {sky130_stdcells/xnor2_4.sym} 109340 -5940 0 0 {name=X_78929_ }
C {devices/lab_pin.sym} 109260 -5850 0 0 {name=p108932 lab=_61036_/C }
C {devices/lab_pin.sym} 109260 -5810 0 0 {name=p108933 lab=_61016_/Y }
C {devices/lab_pin.sym} 109260 -5770 0 0 {name=p108934 lab=_60952_/X }
C {devices/lab_pin.sym} 109260 -5730 0 0 {name=p108935 lab=_76987_/A }
C {devices/lab_pin.sym} 109260 -5690 0 0 {name=p108936 lab=_60898_/X }
C {devices/lab_pin.sym} 109420 -5770 0 1 {name=p108937 lab=_84539_/D }
C {sky130_stdcells/o32a_4.sym} 109340 -5770 0 0 {name=X_61017_ }
C {devices/lab_pin.sym} 109250 -5610 0 0 {name=p108938 lab=_82131_/CLK }
C {devices/lab_pin.sym} 109250 -5590 0 0 {name=p108939 lab=_81940_/D }
C {devices/lab_pin.sym} 109430 -5610 0 1 {name=p108940 lab=_81940_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -5600 0 0 {name=X_81940_ }
C {devices/lab_pin.sym} 109260 -5500 0 0 {name=p108941 lab=_88076_/Q }
C {devices/lab_pin.sym} 109260 -5460 0 0 {name=p108942 lab=_68640_/X }
C {devices/lab_pin.sym} 109260 -5420 0 0 {name=p108943 lab=_69088_/X }
C {devices/lab_pin.sym} 109260 -5380 0 0 {name=p108944 lab=_69661_/Y }
C {devices/lab_pin.sym} 109420 -5440 0 1 {name=p108945 lab=_69662_/X }
C {sky130_stdcells/a211o_4.sym} 109340 -5440 0 0 {name=X_69662_ }
C {devices/lab_pin.sym} 109260 -5310 0 0 {name=p108946 lab=_80917_/D }
C {devices/lab_pin.sym} 109260 -5270 0 0 {name=p108947 lab=_66850_/X }
C {devices/lab_pin.sym} 109260 -5230 0 0 {name=p108948 lab=_66873_/X }
C {devices/lab_pin.sym} 109420 -5270 0 1 {name=p108949 lab=_84093_/D }
C {sky130_stdcells/a21bo_4.sym} 109340 -5270 0 0 {name=X_66874_ }
C {devices/lab_pin.sym} 109300 -5130 0 0 {name=p108950 lab=_66540_/A }
C {devices/lab_pin.sym} 109380 -5130 0 1 {name=p108951 lab=_68613_/X }
C {sky130_stdcells/buf_2.sym} 109340 -5130 0 0 {name=X_68613_ }
C {devices/lab_pin.sym} 109280 -5020 0 0 {name=p108952 lab=_65825_/A }
C {devices/lab_pin.sym} 109280 -4980 0 0 {name=p108953 lab=_86503_/Q }
C {devices/lab_pin.sym} 109400 -5000 0 1 {name=p108954 lab=_65825_/X }
C {sky130_stdcells/and2_4.sym} 109340 -5000 0 0 {name=X_65825_ }
C {devices/lab_pin.sym} 109260 -4900 0 0 {name=p108955 lab=_87569_/Q }
C {devices/lab_pin.sym} 109260 -4860 0 0 {name=p108956 lab=_69506_/X }
C {devices/lab_pin.sym} 109260 -4820 0 0 {name=p108957 lab=_68436_/X }
C {devices/lab_pin.sym} 109260 -4780 0 0 {name=p108958 lab=_69592_/X }
C {devices/lab_pin.sym} 109420 -4840 0 1 {name=p108959 lab=_69593_/X }
C {sky130_stdcells/a211o_4.sym} 109340 -4840 0 0 {name=X_69593_ }
C {devices/lab_pin.sym} 109250 -4690 0 0 {name=p108960 lab=_81872_/CLK }
C {devices/lab_pin.sym} 109250 -4670 0 0 {name=p108961 lab=_78062_/X }
C {devices/lab_pin.sym} 109430 -4690 0 1 {name=p108962 lab=_81839_/D }
C {sky130_stdcells/dfxtp_4.sym} 109340 -4680 0 0 {name=X_81871_ }
C {devices/lab_pin.sym} 109250 -4550 0 0 {name=p108963 lab=_83613_/CLK }
C {devices/lab_pin.sym} 109250 -4530 0 0 {name=p108964 lab=_71092_/Y }
C {devices/lab_pin.sym} 109430 -4550 0 1 {name=p108965 lab=_83610_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -4540 0 0 {name=X_83610_ }
C {devices/lab_pin.sym} 109250 -4410 0 0 {name=p108966 lab=_81994_/CLK }
C {devices/lab_pin.sym} 109250 -4390 0 0 {name=p108967 lab=_80822_/D }
C {devices/lab_pin.sym} 109430 -4410 0 1 {name=p108968 lab=_75605_/B }
C {sky130_stdcells/dfxtp_4.sym} 109340 -4400 0 0 {name=X_80822_ }
C {devices/lab_pin.sym} 109260 -4300 0 0 {name=p108969 lab=_88012_/Q }
C {devices/lab_pin.sym} 109260 -4260 0 0 {name=p108970 lab=_69796_/A }
C {devices/lab_pin.sym} 109260 -4220 0 0 {name=p108971 lab=_68540_/X }
C {devices/lab_pin.sym} 109260 -4180 0 0 {name=p108972 lab=_68543_/X }
C {devices/lab_pin.sym} 109420 -4240 0 1 {name=p108973 lab=_68544_/X }
C {sky130_stdcells/a211o_4.sym} 109340 -4240 0 0 {name=X_68544_ }
C {devices/lab_pin.sym} 109280 -4100 0 0 {name=p108974 lab=_53766_/A }
C {devices/lab_pin.sym} 109280 -4060 0 0 {name=p108975 lab=_48694_/A }
C {devices/lab_pin.sym} 109400 -4080 0 1 {name=p108976 lab=_53770_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -4080 0 0 {name=X_53770_ }
C {devices/lab_pin.sym} 109280 -3960 0 0 {name=p108977 lab=_65747_/Y }
C {devices/lab_pin.sym} 109280 -3920 0 0 {name=p108978 lab=_65756_/B }
C {devices/lab_pin.sym} 109400 -3940 0 1 {name=p108979 lab=_65756_/Y }
C {sky130_stdcells/nand2_4.sym} 109340 -3940 0 0 {name=X_65756_ }
C {devices/lab_pin.sym} 109250 -3810 0 0 {name=p108980 lab=_84590_/CLK }
C {devices/lab_pin.sym} 109250 -3790 0 0 {name=p108981 lab=_60601_/Y }
C {devices/lab_pin.sym} 109430 -3810 0 1 {name=p108982 lab=_79130_/A }
C {sky130_stdcells/dfxtp_4.sym} 109340 -3800 0 0 {name=X_84590_ }
C {devices/lab_pin.sym} 109260 -3690 0 0 {name=p108983 lab=_86095_/Q }
C {devices/lab_pin.sym} 109260 -3650 0 0 {name=p108984 lab=_50965_/X }
C {devices/lab_pin.sym} 109260 -3610 0 0 {name=p108985 lab=_50981_/Y }
C {devices/lab_pin.sym} 109420 -3650 0 1 {name=p108986 lab=_50982_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -3650 0 0 {name=X_50982_ }
C {devices/lab_pin.sym} 109260 -3550 0 0 {name=p108987 lab=_62964_/Y }
C {devices/lab_pin.sym} 109260 -3510 0 0 {name=p108988 lab=_62886_/X }
C {devices/lab_pin.sym} 109260 -3470 0 0 {name=p108989 lab=_62965_/Y }
C {devices/lab_pin.sym} 109260 -3430 0 0 {name=p108990 lab=_62966_/Y }
C {devices/lab_pin.sym} 109260 -3400 0 0 {name=p108991 lab=_62967_/X }
C {devices/lab_pin.sym} 109420 -3470 0 1 {name=p108992 lab=_62968_/X }
C {sky130_stdcells/a41o_4.sym} 109340 -3470 0 0 {name=X_62968_ }
C {devices/lab_pin.sym} 109260 -3330 0 0 {name=p108993 lab=_52719_/Y }
C {devices/lab_pin.sym} 109260 -3290 0 0 {name=p108994 lab=_52702_/X }
C {devices/lab_pin.sym} 109260 -3250 0 0 {name=p108995 lab=_52720_/X }
C {devices/lab_pin.sym} 109420 -3290 0 1 {name=p108996 lab=_52721_/Y }
C {sky130_stdcells/a21oi_4.sym} 109340 -3290 0 0 {name=X_52721_ }
C {devices/lab_pin.sym} 109300 -3150 0 0 {name=p108997 lab=_64980_/A }
C {devices/lab_pin.sym} 109380 -3150 0 1 {name=p108998 lab=_64707_/X }
C {sky130_stdcells/buf_2.sym} 109340 -3150 0 0 {name=X_64707_ }
C {devices/lab_pin.sym} 109250 -3030 0 0 {name=p108999 lab=_86541_/CLK }
C {devices/lab_pin.sym} 109250 -3010 0 0 {name=p109000 lab=_71307_/Y }
C {devices/lab_pin.sym} 109430 -3030 0 1 {name=p109001 lab=_48039_/A }
C {sky130_stdcells/dfxtp_4.sym} 109340 -3020 0 0 {name=X_83541_ }
C {devices/lab_pin.sym} 109300 -2890 0 0 {name=p109002 lab=clkbuf_4_4_1_CLK/X }
C {devices/lab_pin.sym} 109380 -2890 0 1 {name=p109003 lab=clkbuf_5_8_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 109340 -2890 0 0 {name=Xclkbuf_5_8_0_CLK }
C {devices/lab_pin.sym} 109280 -2800 0 0 {name=p109004 lab=_61481_/X }
C {devices/lab_pin.sym} 109280 -2760 0 0 {name=p109005 lab=_61874_/B }
C {devices/lab_pin.sym} 109280 -2720 0 0 {name=p109006 lab=_61907_/C }
C {devices/lab_pin.sym} 109280 -2680 0 0 {name=p109007 lab=_61874_/D }
C {devices/lab_pin.sym} 109400 -2740 0 1 {name=p109008 lab=_61919_/Y }
C {sky130_stdcells/nand4_4.sym} 109340 -2740 0 0 {name=X_61919_ }
C {devices/lab_pin.sym} 109250 -2590 0 0 {name=p109009 lab=_80746_/CLK }
C {devices/lab_pin.sym} 109250 -2570 0 0 {name=p109010 lab=_75297_/X }
C {devices/lab_pin.sym} 109430 -2590 0 1 {name=p109011 lab=_81129_/D }
C {sky130_stdcells/dfxtp_4.sym} 109340 -2580 0 0 {name=X_80753_ }
C {devices/lab_pin.sym} 109280 -2460 0 0 {name=p109012 lab=_69004_/A }
C {devices/lab_pin.sym} 109280 -2420 0 0 {name=p109013 lab=_88367_/Q }
C {devices/lab_pin.sym} 109400 -2440 0 1 {name=p109014 lab=_68475_/X }
C {sky130_stdcells/and2_4.sym} 109340 -2440 0 0 {name=X_68475_ }
C {devices/lab_pin.sym} 109280 -2320 0 0 {name=p109015 lab=_65702_/A }
C {devices/lab_pin.sym} 109280 -2280 0 0 {name=p109016 lab=_85872_/Q }
C {devices/lab_pin.sym} 109400 -2300 0 1 {name=p109017 lab=_65687_/X }
C {sky130_stdcells/and2_4.sym} 109340 -2300 0 0 {name=X_65687_ }
C {devices/lab_pin.sym} 109280 -2180 0 0 {name=p109018 lab=_84844_/Q }
C {devices/lab_pin.sym} 109280 -2140 0 0 {name=p109019 lab=_62642_/B }
C {devices/lab_pin.sym} 109400 -2160 0 1 {name=p109020 lab=_62899_/Y }
C {sky130_stdcells/nor2_4.sym} 109340 -2160 0 0 {name=X_62899_ }
C {devices/lab_pin.sym} 109280 -2040 0 0 {name=p109021 lab=_55439_/Y }
C {devices/lab_pin.sym} 109280 -2000 0 0 {name=p109022 lab=_55387_/X }
C {devices/lab_pin.sym} 109400 -2020 0 1 {name=p109023 lab=_55441_/B }
C {sky130_stdcells/nand2_4.sym} 109340 -2020 0 0 {name=X_55440_ }
C {devices/lab_pin.sym} 109260 -1910 0 0 {name=p109024 lab=_81502_/D }
C {devices/lab_pin.sym} 109260 -1870 0 0 {name=p109025 lab=_67331_/X }
C {devices/lab_pin.sym} 109260 -1830 0 0 {name=p109026 lab=_67425_/X }
C {devices/lab_pin.sym} 109420 -1870 0 1 {name=p109027 lab=_84070_/D }
C {sky130_stdcells/a21bo_4.sym} 109340 -1870 0 0 {name=X_67426_ }
C {devices/lab_pin.sym} 109250 -1730 0 0 {name=p109028 lab=_85555_/CLK }
C {devices/lab_pin.sym} 109250 -1710 0 0 {name=p109029 lab=_86260_/D }
C {devices/lab_pin.sym} 109430 -1730 0 1 {name=p109030 lab=_64948_/B }
C {sky130_stdcells/dfxtp_4.sym} 109340 -1720 0 0 {name=X_86260_ }
C {devices/lab_pin.sym} 109260 -1610 0 0 {name=p109031 lab=_85779_/Q }
C {devices/lab_pin.sym} 109260 -1570 0 0 {name=p109032 lab=_52629_/X }
C {devices/lab_pin.sym} 109260 -1530 0 0 {name=p109033 lab=_52651_/Y }
C {devices/lab_pin.sym} 109420 -1570 0 1 {name=p109034 lab=_52652_/Y }
C {sky130_stdcells/o21ai_4.sym} 109340 -1570 0 0 {name=X_52652_ }
C {devices/lab_pin.sym} 109280 -1450 0 0 {name=p109035 lab=_64637_/X }
C {devices/lab_pin.sym} 109280 -1410 0 0 {name=p109036 lab=_64638_/B }
C {devices/lab_pin.sym} 109280 -1370 0 0 {name=p109037 lab=_81024_/D }
C {devices/lab_pin.sym} 109400 -1410 0 1 {name=p109038 lab=_64638_/X }
C {sky130_stdcells/and3_4.sym} 109340 -1410 0 0 {name=X_64638_ }
C {devices/lab_pin.sym} 109250 -1270 0 0 {name=p109039 lab=_86600_/CLK }
C {devices/lab_pin.sym} 109250 -1250 0 0 {name=p109040 lab=_83472_/D }
C {devices/lab_pin.sym} 109430 -1270 0 1 {name=p109041 lab=_83472_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -1260 0 0 {name=X_83472_ }
C {devices/lab_pin.sym} 109250 -1130 0 0 {name=p109042 lab=_80681_/CLK }
C {devices/lab_pin.sym} 109250 -1110 0 0 {name=p109043 lab=_80716_/Q }
C {devices/lab_pin.sym} 109430 -1130 0 1 {name=p109044 lab=_80684_/Q }
C {sky130_stdcells/dfxtp_4.sym} 109340 -1120 0 0 {name=X_80684_ }
C {devices/lab_pin.sym} 109250 -990 0 0 {name=p109045 lab=_85244_/CLK }
C {devices/lab_pin.sym} 109250 -970 0 0 {name=p109046 lab=_85211_/D }
C {devices/lab_pin.sym} 109430 -990 0 1 {name=p109047 lab=_56392_/C }
C {sky130_stdcells/dfxtp_4.sym} 109340 -980 0 0 {name=X_85211_ }
C {devices/lab_pin.sym} 109280 -880 0 0 {name=p109048 lab=_51619_/A }
C {devices/lab_pin.sym} 109280 -840 0 0 {name=p109049 lab=_51603_/B }
C {devices/lab_pin.sym} 109280 -800 0 0 {name=p109050 lab=_51603_/C }
C {devices/lab_pin.sym} 109280 -760 0 0 {name=p109051 lab=_53129_/D }
C {devices/lab_pin.sym} 109400 -820 0 1 {name=p109052 lab=_51603_/X }
C {sky130_stdcells/and4_4.sym} 109340 -820 0 0 {name=X_51603_ }
C {devices/lab_pin.sym} 109250 -670 0 0 {name=p109053 lab=_82463_/CLK }
C {devices/lab_pin.sym} 109250 -650 0 0 {name=p109054 lab=_82455_/Q }
C {devices/lab_pin.sym} 109430 -670 0 1 {name=p109055 lab=_78611_/A }
C {sky130_stdcells/dfxtp_4.sym} 109340 -660 0 0 {name=X_82423_ }
C {devices/lab_pin.sym} 110200 -42160 0 0 {name=p109056 lab=_55325_/X }
C {devices/lab_pin.sym} 110200 -42120 0 0 {name=p109057 lab=_55384_/A }
C {devices/lab_pin.sym} 110320 -42140 0 1 {name=p109058 lab=_55371_/X }
C {sky130_stdcells/and2_4.sym} 110260 -42140 0 0 {name=X_55371_ }
C {devices/lab_pin.sym} 110180 -42040 0 0 {name=p109059 lab=_87922_/Q }
C {devices/lab_pin.sym} 110180 -42000 0 0 {name=p109060 lab=_67355_/X }
C {devices/lab_pin.sym} 110180 -41960 0 0 {name=p109061 lab=_67284_/X }
C {devices/lab_pin.sym} 110180 -41920 0 0 {name=p109062 lab=_67356_/X }
C {devices/lab_pin.sym} 110340 -41980 0 1 {name=p109063 lab=_67357_/X }
C {sky130_stdcells/a211o_4.sym} 110260 -41980 0 0 {name=X_67357_ }
C {devices/lab_pin.sym} 110170 -41830 0 0 {name=p109064 lab=_86191_/CLK }
C {devices/lab_pin.sym} 110170 -41810 0 0 {name=p109065 lab=_50488_/Y }
C {devices/lab_pin.sym} 110350 -41830 0 1 {name=p109066 lab=_86191_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -41820 0 0 {name=X_86191_ }
C {devices/lab_pin.sym} 110180 -41710 0 0 {name=p109067 lab=_85792_/Q }
C {devices/lab_pin.sym} 110180 -41670 0 0 {name=p109068 lab=_52575_/X }
C {devices/lab_pin.sym} 110180 -41630 0 0 {name=p109069 lab=_52582_/Y }
C {devices/lab_pin.sym} 110340 -41670 0 1 {name=p109070 lab=_52583_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -41670 0 0 {name=X_52583_ }
C {sky130_stdcells/decap_3.sym} 110260 -41500 0 0 {name=XPHY_606 }
C {devices/lab_pin.sym} 110200 -41360 0 0 {name=p109071 lab=_64611_/A }
C {devices/lab_pin.sym} 110200 -41320 0 0 {name=p109072 lab=_85825_/Q }
C {devices/lab_pin.sym} 110320 -41340 0 1 {name=p109073 lab=_64569_/X }
C {sky130_stdcells/and2_4.sym} 110260 -41340 0 0 {name=X_64569_ }
C {sky130_stdcells/decap_3.sym} 110260 -41180 0 0 {name=XPHY_617 }
C {sky130_stdcells/decap_3.sym} 110260 -41000 0 0 {name=XPHY_628 }
C {devices/lab_pin.sym} 110220 -40850 0 0 {name=p109074 lab=_57221_/A }
C {devices/lab_pin.sym} 110300 -40850 0 1 {name=p109075 lab=_57110_/X }
C {sky130_stdcells/buf_2.sym} 110260 -40850 0 0 {name=X_57110_ }
C {devices/lab_pin.sym} 110220 -40730 0 0 {name=p109076 lab=_54322_/A }
C {devices/lab_pin.sym} 110300 -40730 0 1 {name=p109077 lab=_54332_/A }
C {sky130_stdcells/buf_2.sym} 110260 -40730 0 0 {name=X_54322_ }
C {sky130_stdcells/decap_3.sym} 110260 -40580 0 0 {name=XPHY_639 }
C {devices/lab_pin.sym} 110200 -40440 0 0 {name=p109078 lab=_66267_/X }
C {devices/lab_pin.sym} 110200 -40400 0 0 {name=p109079 lab=_85893_/Q }
C {devices/lab_pin.sym} 110320 -40420 0 1 {name=p109080 lab=_66308_/X }
C {sky130_stdcells/and2_4.sym} 110260 -40420 0 0 {name=X_66308_ }
C {devices/lab_pin.sym} 110170 -40290 0 0 {name=p109081 lab=_85144_/CLK }
C {devices/lab_pin.sym} 110170 -40270 0 0 {name=p109082 lab=_85142_/D }
C {devices/lab_pin.sym} 110350 -40290 0 1 {name=p109083 lab=_55529_/B }
C {sky130_stdcells/dfxtp_4.sym} 110260 -40280 0 0 {name=X_85142_ }
C {devices/lab_pin.sym} 110180 -40170 0 0 {name=p109084 lab=_51530_/Y }
C {devices/lab_pin.sym} 110180 -40130 0 0 {name=p109085 lab=_51531_/X }
C {devices/lab_pin.sym} 110180 -40090 0 0 {name=p109086 lab=_51533_/X }
C {devices/lab_pin.sym} 110340 -40130 0 1 {name=p109087 lab=_85993_/D }
C {sky130_stdcells/a21oi_4.sym} 110260 -40130 0 0 {name=X_51534_ }
C {devices/lab_pin.sym} 110180 -40010 0 0 {name=p109088 lab=_58065_/X }
C {devices/lab_pin.sym} 110180 -39970 0 0 {name=p109089 lab=_85702_/Q }
C {devices/lab_pin.sym} 110180 -39930 0 0 {name=p109090 lab=_58089_/X }
C {devices/lab_pin.sym} 110340 -39970 0 1 {name=p109091 lab=_58090_/X }
C {sky130_stdcells/o21a_4.sym} 110260 -39970 0 0 {name=X_58090_ }
C {devices/lab_pin.sym} 110170 -39830 0 0 {name=p109092 lab=_82558_/CLK }
C {devices/lab_pin.sym} 110170 -39810 0 0 {name=p109093 lab=_77168_/X }
C {devices/lab_pin.sym} 110350 -39830 0 1 {name=p109094 lab=_82354_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -39820 0 0 {name=X_82354_ }
C {devices/lab_pin.sym} 110180 -39720 0 0 {name=p109095 lab=_87349_/Q }
C {devices/lab_pin.sym} 110180 -39680 0 0 {name=p109096 lab=_67239_/X }
C {devices/lab_pin.sym} 110180 -39640 0 0 {name=p109097 lab=_67240_/X }
C {devices/lab_pin.sym} 110180 -39600 0 0 {name=p109098 lab=_67287_/X }
C {devices/lab_pin.sym} 110340 -39660 0 1 {name=p109099 lab=_67288_/X }
C {sky130_stdcells/a211o_4.sym} 110260 -39660 0 0 {name=X_67288_ }
C {devices/lab_pin.sym} 110220 -39510 0 0 {name=p109100 lab=_56838_/A }
C {devices/lab_pin.sym} 110300 -39510 0 1 {name=p109101 lab=_57331_/A }
C {sky130_stdcells/buf_2.sym} 110260 -39510 0 0 {name=X_57041_ }
C {devices/lab_pin.sym} 110170 -39390 0 0 {name=p109102 lab=_81689_/CLK }
C {devices/lab_pin.sym} 110170 -39370 0 0 {name=p109103 lab=_76993_/X }
C {devices/lab_pin.sym} 110350 -39390 0 1 {name=p109104 lab=_81305_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -39380 0 0 {name=X_81305_ }
C {devices/lab_pin.sym} 110200 -39260 0 0 {name=p109105 lab=_69027_/A }
C {devices/lab_pin.sym} 110200 -39220 0 0 {name=p109106 lab=_88344_/Q }
C {devices/lab_pin.sym} 110320 -39240 0 1 {name=p109107 lab=_69027_/X }
C {sky130_stdcells/and2_4.sym} 110260 -39240 0 0 {name=X_69027_ }
C {devices/lab_pin.sym} 110220 -39110 0 0 {name=p109108 lab=_54253_/A }
C {devices/lab_pin.sym} 110300 -39110 0 1 {name=p109109 lab=_54253_/X }
C {sky130_stdcells/buf_2.sym} 110260 -39110 0 0 {name=X_54253_ }
C {devices/lab_pin.sym} 110180 -39020 0 0 {name=p109110 lab=_66236_/X }
C {devices/lab_pin.sym} 110180 -38980 0 0 {name=p109111 lab=_85610_/Q }
C {devices/lab_pin.sym} 110180 -38940 0 0 {name=p109112 lab=_66096_/X }
C {devices/lab_pin.sym} 110180 -38900 0 0 {name=p109113 lab=_66238_/X }
C {devices/lab_pin.sym} 110340 -38960 0 1 {name=p109114 lab=_66239_/X }
C {sky130_stdcells/a211o_4.sym} 110260 -38960 0 0 {name=X_66239_ }
C {devices/lab_pin.sym} 110170 -38810 0 0 {name=p109115 lab=_85071_/CLK }
C {devices/lab_pin.sym} 110170 -38790 0 0 {name=p109116 lab=_85073_/D }
C {devices/lab_pin.sym} 110350 -38810 0 1 {name=p109117 lab=_57137_/A }
C {sky130_stdcells/dfxtp_4.sym} 110260 -38800 0 0 {name=X_85073_ }
C {devices/lab_pin.sym} 110180 -38690 0 0 {name=p109118 lab=_86005_/Q }
C {devices/lab_pin.sym} 110180 -38650 0 0 {name=p109119 lab=_51458_/X }
C {devices/lab_pin.sym} 110180 -38610 0 0 {name=p109120 lab=_51464_/Y }
C {devices/lab_pin.sym} 110340 -38650 0 1 {name=p109121 lab=_51465_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -38650 0 0 {name=X_51465_ }
C {devices/lab_pin.sym} 110170 -38510 0 0 {name=p109122 lab=_82301_/CLK }
C {devices/lab_pin.sym} 110170 -38490 0 0 {name=p109123 lab=_82285_/D }
C {devices/lab_pin.sym} 110350 -38510 0 1 {name=p109124 lab=_41048_/A }
C {sky130_stdcells/dfxtp_4.sym} 110260 -38500 0 0 {name=X_82285_ }
C {devices/lab_pin.sym} 110180 -38390 0 0 {name=p109125 lab=_53201_/Y }
C {devices/lab_pin.sym} 110180 -38350 0 0 {name=p109126 lab=_53189_/X }
C {devices/lab_pin.sym} 110180 -38310 0 0 {name=p109127 lab=_53203_/X }
C {devices/lab_pin.sym} 110340 -38350 0 1 {name=p109128 lab=_85678_/D }
C {sky130_stdcells/a21oi_4.sym} 110260 -38350 0 0 {name=X_53204_ }
C {devices/lab_pin.sym} 110170 -38210 0 0 {name=p109129 lab=_81169_/CLK }
C {devices/lab_pin.sym} 110170 -38190 0 0 {name=p109130 lab=_84024_/D }
C {devices/lab_pin.sym} 110350 -38210 0 1 {name=p109131 lab=_84024_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -38200 0 0 {name=X_84024_ }
C {devices/lab_pin.sym} 110220 -38070 0 0 {name=p109132 lab=_50572_/A }
C {devices/lab_pin.sym} 110300 -38070 0 1 {name=p109133 lab=_50556_/A }
C {sky130_stdcells/buf_2.sym} 110260 -38070 0 0 {name=X_50416_ }
C {devices/lab_pin.sym} 110170 -37950 0 0 {name=p109134 lab=_85332_/CLK }
C {devices/lab_pin.sym} 110170 -37930 0 0 {name=p109135 lab=_81044_/Q }
C {devices/lab_pin.sym} 110350 -37950 0 1 {name=p109136 lab=_47653_/A }
C {sky130_stdcells/dfxtp_4.sym} 110260 -37940 0 0 {name=X_81236_ }
C {devices/lab_pin.sym} 110200 -37820 0 0 {name=p109137 lab=_54184_/A }
C {devices/lab_pin.sym} 110200 -37780 0 0 {name=p109138 lab=_47385_/Y }
C {devices/lab_pin.sym} 110320 -37800 0 1 {name=p109139 lab=_54184_/Y }
C {sky130_stdcells/nand2_4.sym} 110260 -37800 0 0 {name=X_54184_ }
C {devices/lab_pin.sym} 110200 -37690 0 0 {name=p109140 lab=_51396_/A }
C {devices/lab_pin.sym} 110200 -37650 0 0 {name=p109141 lab=_51352_/B }
C {devices/lab_pin.sym} 110200 -37610 0 0 {name=p109142 lab=_51352_/C }
C {devices/lab_pin.sym} 110320 -37650 0 1 {name=p109143 lab=_51396_/X }
C {sky130_stdcells/and3_4.sym} 110260 -37650 0 0 {name=X_51396_ }
C {devices/lab_pin.sym} 110200 -37520 0 0 {name=p109144 lab=_53121_/X }
C {devices/lab_pin.sym} 110200 -37480 0 0 {name=p109145 lab=_53135_/B }
C {devices/lab_pin.sym} 110320 -37500 0 1 {name=p109146 lab=_53135_/Y }
C {sky130_stdcells/nand2_4.sym} 110260 -37500 0 0 {name=X_53135_ }
C {devices/lab_pin.sym} 110200 -37390 0 0 {name=p109147 lab=_52050_/A }
C {devices/lab_pin.sym} 110200 -37350 0 0 {name=p109148 lab=_50331_/B }
C {devices/lab_pin.sym} 110200 -37310 0 0 {name=p109149 lab=_50338_/X }
C {devices/lab_pin.sym} 110320 -37350 0 1 {name=p109150 lab=_50347_/X }
C {sky130_stdcells/and3_4.sym} 110260 -37350 0 0 {name=X_50347_ }
C {devices/lab_pin.sym} 110170 -37210 0 0 {name=p109151 lab=_81179_/CLK }
C {devices/lab_pin.sym} 110170 -37190 0 0 {name=p109152 lab=_74940_/B }
C {devices/lab_pin.sym} 110350 -37210 0 1 {name=p109153 lab=_81167_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -37200 0 0 {name=X_81167_ }
C {devices/lab_pin.sym} 110180 -37090 0 0 {name=p109154 lab=_58982_/X }
C {devices/lab_pin.sym} 110180 -37050 0 0 {name=p109155 lab=_83435_/Q }
C {devices/lab_pin.sym} 110180 -37010 0 0 {name=p109156 lab=_58991_/Y }
C {devices/lab_pin.sym} 110340 -37050 0 1 {name=p109157 lab=_58992_/X }
C {sky130_stdcells/o21a_4.sym} 110260 -37050 0 0 {name=X_58992_ }
C {devices/lab_pin.sym} 110220 -36910 0 0 {name=p109158 lab=clkbuf_7_70_0_CLK/A }
C {devices/lab_pin.sym} 110300 -36910 0 1 {name=p109159 lab=clkbuf_7_70_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 110260 -36910 0 0 {name=Xclkbuf_7_70_0_CLK }
C {devices/lab_pin.sym} 110180 -36810 0 0 {name=p109160 lab=_80105_/X }
C {devices/lab_pin.sym} 110180 -36770 0 0 {name=p109161 lab=_80116_/X }
C {devices/lab_pin.sym} 110180 -36730 0 0 {name=p109162 lab=_80117_/X }
C {devices/lab_pin.sym} 110340 -36770 0 1 {name=p109163 lab=_80118_/Y }
C {sky130_stdcells/a21oi_4.sym} 110260 -36770 0 0 {name=X_80118_ }
C {devices/lab_pin.sym} 110200 -36640 0 0 {name=p109164 lab=_40901_/B }
C {devices/lab_pin.sym} 110200 -36600 0 0 {name=p109165 lab=_41079_/X }
C {devices/lab_pin.sym} 110320 -36620 0 1 {name=p109166 lab=_41080_/X }
C {sky130_stdcells/or2_4.sym} 110260 -36620 0 0 {name=X_41080_ }
C {devices/lab_pin.sym} 110220 -36490 0 0 {name=p109167 lab=_53147_/A }
C {devices/lab_pin.sym} 110300 -36490 0 1 {name=p109168 lab=_53080_/A }
C {sky130_stdcells/buf_2.sym} 110260 -36490 0 0 {name=X_53066_ }
C {devices/lab_pin.sym} 110180 -36400 0 0 {name=p109169 lab=_84938_/Q }
C {devices/lab_pin.sym} 110180 -36360 0 0 {name=p109170 lab=_57896_/X }
C {devices/lab_pin.sym} 110180 -36320 0 0 {name=p109171 lab=_57936_/X }
C {devices/lab_pin.sym} 110180 -36280 0 0 {name=p109172 lab=_57942_/X }
C {devices/lab_pin.sym} 110340 -36340 0 1 {name=p109173 lab=_57943_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 110260 -36340 0 0 {name=X_57943_ }
C {devices/lab_pin.sym} 110220 -36190 0 0 {name=p109174 lab=_69929_/A }
C {devices/lab_pin.sym} 110300 -36190 0 1 {name=p109175 lab=_69929_/Y }
C {sky130_stdcells/inv_2.sym} 110260 -36190 0 0 {name=X_69929_ }
C {devices/lab_pin.sym} 110180 -36090 0 0 {name=p109176 lab=_86232_/Q }
C {devices/lab_pin.sym} 110180 -36050 0 0 {name=p109177 lab=_50250_/X }
C {devices/lab_pin.sym} 110180 -36010 0 0 {name=p109178 lab=_50277_/Y }
C {devices/lab_pin.sym} 110340 -36050 0 1 {name=p109179 lab=_50278_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -36050 0 0 {name=X_50278_ }
C {devices/lab_pin.sym} 110170 -35910 0 0 {name=p109180 lab=_85688_/CLK }
C {devices/lab_pin.sym} 110170 -35890 0 0 {name=p109181 lab=_51631_/Y }
C {devices/lab_pin.sym} 110350 -35910 0 1 {name=p109182 lab=_85975_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -35900 0 0 {name=X_85975_ }
C {devices/lab_pin.sym} 110170 -35770 0 0 {name=p109183 lab=_81065_/CLK }
C {devices/lab_pin.sym} 110170 -35750 0 0 {name=p109184 lab=_79645_/X }
C {devices/lab_pin.sym} 110350 -35770 0 1 {name=p109185 lab=_81098_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -35760 0 0 {name=X_81098_ }
C {devices/lab_pin.sym} 110200 -35650 0 0 {name=p109186 lab=_50314_/A }
C {devices/lab_pin.sym} 110200 -35610 0 0 {name=p109187 lab=_51972_/X }
C {devices/lab_pin.sym} 110200 -35570 0 0 {name=p109188 lab=_51958_/C }
C {devices/lab_pin.sym} 110320 -35610 0 1 {name=p109189 lab=_52017_/X }
C {sky130_stdcells/and3_4.sym} 110260 -35610 0 0 {name=X_52017_ }
C {devices/lab_pin.sym} 110170 -35470 0 0 {name=p109190 lab=_87210_/CLK }
C {devices/lab_pin.sym} 110170 -35450 0 0 {name=p109191 lab=_87714_/D }
C {devices/lab_pin.sym} 110350 -35470 0 1 {name=p109192 lab=_87714_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -35460 0 0 {name=X_87714_ }
C {devices/lab_pin.sym} 110200 -35350 0 0 {name=p109193 lab=_72938_/X }
C {devices/lab_pin.sym} 110200 -35310 0 0 {name=p109194 lab=_72926_/X }
C {devices/lab_pin.sym} 110200 -35270 0 0 {name=p109195 lab=_72928_/X }
C {devices/lab_pin.sym} 110320 -35310 0 1 {name=p109196 lab=_72940_/Y }
C {sky130_stdcells/nand3_4.sym} 110260 -35310 0 0 {name=X_72940_ }
C {devices/lab_pin.sym} 110170 -35170 0 0 {name=p109197 lab=_84926_/CLK }
C {devices/lab_pin.sym} 110170 -35150 0 0 {name=p109198 lab=_84926_/D }
C {devices/lab_pin.sym} 110350 -35170 0 1 {name=p109199 lab=_84926_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -35160 0 0 {name=X_84926_ }
C {devices/lab_pin.sym} 110200 -35040 0 0 {name=p109200 lab=_60097_/C }
C {devices/lab_pin.sym} 110200 -35000 0 0 {name=p109201 lab=_80049_/B }
C {devices/lab_pin.sym} 110320 -35020 0 1 {name=p109202 lab=_80057_/B }
C {sky130_stdcells/xor2_4.sym} 110260 -35020 0 0 {name=X_80049_ }
C {devices/lab_pin.sym} 110220 -34890 0 0 {name=p109203 lab=_58834_/A }
C {devices/lab_pin.sym} 110300 -34890 0 1 {name=p109204 lab=_58703_/A }
C {sky130_stdcells/buf_2.sym} 110260 -34890 0 0 {name=X_57874_ }
C {devices/lab_pin.sym} 110220 -34770 0 0 {name=p109205 lab=clkbuf_1_0_0_CLK/X }
C {devices/lab_pin.sym} 110300 -34770 0 1 {name=p109206 lab=clkbuf_1_0_2_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 110260 -34770 0 0 {name=Xclkbuf_1_0_1_CLK }
C {devices/lab_pin.sym} 110200 -34660 0 0 {name=p109207 lab=_60627_/A }
C {devices/lab_pin.sym} 110200 -34620 0 0 {name=p109208 lab=_60626_/A }
C {devices/lab_pin.sym} 110320 -34640 0 1 {name=p109209 lab=_59613_/Y }
C {sky130_stdcells/nor2_4.sym} 110260 -34640 0 0 {name=X_59613_ }
C {devices/lab_pin.sym} 110200 -34520 0 0 {name=p109210 lab=_56824_/X }
C {devices/lab_pin.sym} 110200 -34480 0 0 {name=p109211 lab=_85130_/Q }
C {devices/lab_pin.sym} 110320 -34500 0 1 {name=p109212 lab=_56825_/Y }
C {sky130_stdcells/nand2_4.sym} 110260 -34500 0 0 {name=X_56825_ }
C {devices/lab_pin.sym} 110170 -34370 0 0 {name=p109213 lab=_87195_/CLK }
C {devices/lab_pin.sym} 110170 -34350 0 0 {name=p109214 lab=_42932_/X }
C {devices/lab_pin.sym} 110350 -34370 0 1 {name=p109215 lab=_87645_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -34360 0 0 {name=X_87645_ }
C {devices/lab_pin.sym} 110220 -34230 0 0 {name=p109216 lab=clkbuf_7_85_0_CLK/A }
C {devices/lab_pin.sym} 110300 -34230 0 1 {name=p109217 lab=clkbuf_7_85_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 110260 -34230 0 0 {name=Xclkbuf_7_85_0_CLK }
C {devices/lab_pin.sym} 110200 -34120 0 0 {name=p109218 lab=_73040_/A }
C {devices/lab_pin.sym} 110200 -34080 0 0 {name=p109219 lab=_85885_/Q }
C {devices/lab_pin.sym} 110320 -34100 0 1 {name=p109220 lab=_72871_/X }
C {sky130_stdcells/and2_4.sym} 110260 -34100 0 0 {name=X_72871_ }
C {devices/lab_pin.sym} 110170 -33970 0 0 {name=p109221 lab=_84360_/CLK }
C {devices/lab_pin.sym} 110170 -33950 0 0 {name=p109222 lab=_84857_/D }
C {devices/lab_pin.sym} 110350 -33970 0 1 {name=p109223 lab=_84857_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -33960 0 0 {name=X_84857_ }
C {devices/lab_pin.sym} 110180 -33860 0 0 {name=p109224 lab=_74605_/X }
C {devices/lab_pin.sym} 110180 -33820 0 0 {name=p109225 lab=_74599_/X }
C {devices/lab_pin.sym} 110180 -33780 0 0 {name=p109226 lab=_56144_/A }
C {devices/lab_pin.sym} 110180 -33740 0 0 {name=p109227 lab=_74600_/X }
C {devices/lab_pin.sym} 110340 -33800 0 1 {name=p109228 lab=_74610_/X }
C {sky130_stdcells/a211o_4.sym} 110260 -33800 0 0 {name=X_74610_ }
C {devices/lab_pin.sym} 110180 -33670 0 0 {name=p109229 lab=_71804_/Y }
C {devices/lab_pin.sym} 110180 -33630 0 0 {name=p109230 lab=_83362_/Q }
C {devices/lab_pin.sym} 110180 -33590 0 0 {name=p109231 lab=_71821_/X }
C {devices/lab_pin.sym} 110340 -33630 0 1 {name=p109232 lab=_71822_/X }
C {sky130_stdcells/a21o_4.sym} 110260 -33630 0 0 {name=X_71822_ }
C {devices/lab_pin.sym} 110170 -33490 0 0 {name=p109233 lab=_81807_/CLK }
C {devices/lab_pin.sym} 110170 -33470 0 0 {name=p109234 lab=_83808_/D }
C {devices/lab_pin.sym} 110350 -33490 0 1 {name=p109235 lab=_74796_/A }
C {sky130_stdcells/dfxtp_4.sym} 110260 -33480 0 0 {name=X_83808_ }
C {devices/lab_pin.sym} 110200 -33380 0 0 {name=p109236 lab=_59544_/A }
C {devices/lab_pin.sym} 110200 -33340 0 0 {name=p109237 lab=_59544_/B }
C {devices/lab_pin.sym} 110200 -33300 0 0 {name=p109238 lab=_59890_/B }
C {devices/lab_pin.sym} 110200 -33260 0 0 {name=p109239 lab=_59544_/D }
C {devices/lab_pin.sym} 110320 -33320 0 1 {name=p109240 lab=_59545_/A }
C {sky130_stdcells/and4_4.sym} 110260 -33320 0 0 {name=X_59544_ }
C {devices/lab_pin.sym} 110220 -33170 0 0 {name=p109241 lab=_44770_/A }
C {devices/lab_pin.sym} 110300 -33170 0 1 {name=p109242 lab=_44770_/Y }
C {sky130_stdcells/inv_2.sym} 110260 -33170 0 0 {name=X_44770_ }
C {devices/lab_pin.sym} 110220 -33050 0 0 {name=p109243 lab=_56755_/X }
C {devices/lab_pin.sym} 110300 -33050 0 1 {name=p109244 lab=_56756_/X }
C {sky130_stdcells/buf_2.sym} 110260 -33050 0 0 {name=X_56756_ }
C {devices/lab_pin.sym} 110200 -32940 0 0 {name=p109245 lab=_75889_/A }
C {devices/lab_pin.sym} 110200 -32900 0 0 {name=p109246 lab=_75589_/Y }
C {devices/lab_pin.sym} 110320 -32920 0 1 {name=p109247 lab=_75590_/X }
C {sky130_stdcells/or2_4.sym} 110260 -32920 0 0 {name=X_75590_ }
C {devices/lab_pin.sym} 110170 -32790 0 0 {name=p109248 lab=_87577_/CLK }
C {devices/lab_pin.sym} 110170 -32770 0 0 {name=p109249 lab=_87576_/D }
C {devices/lab_pin.sym} 110350 -32790 0 1 {name=p109250 lab=_43098_/A }
C {sky130_stdcells/dfxtp_4.sym} 110260 -32780 0 0 {name=X_87576_ }
C {devices/lab_pin.sym} 110220 -32650 0 0 {name=p109251 lab=_41998_/A }
C {devices/lab_pin.sym} 110300 -32650 0 1 {name=p109252 lab=_41982_/X }
C {sky130_stdcells/buf_2.sym} 110260 -32650 0 0 {name=X_41982_ }
C {devices/lab_pin.sym} 110220 -32530 0 0 {name=p109253 lab=_51814_/A }
C {devices/lab_pin.sym} 110300 -32530 0 1 {name=p109254 lab=_53969_/C }
C {sky130_stdcells/buf_2.sym} 110260 -32530 0 0 {name=X_53968_ }
C {devices/lab_pin.sym} 110170 -32410 0 0 {name=p109255 lab=_86695_/CLK }
C {devices/lab_pin.sym} 110170 -32390 0 0 {name=p109256 lab=_58945_/Y }
C {devices/lab_pin.sym} 110350 -32410 0 1 {name=p109257 lab=_84788_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -32400 0 0 {name=X_84788_ }
C {devices/lab_pin.sym} 110220 -32270 0 0 {name=p109258 lab=_87296_/Q }
C {devices/lab_pin.sym} 110300 -32270 0 1 {name=p109259 lab=_69823_/B }
C {sky130_stdcells/inv_2.sym} 110260 -32270 0 0 {name=X_43721_ }
C {devices/lab_pin.sym} 110200 -32160 0 0 {name=p109260 lab=_55252_/A }
C {devices/lab_pin.sym} 110200 -32120 0 0 {name=p109261 lab=_55707_/B }
C {devices/lab_pin.sym} 110320 -32140 0 1 {name=p109262 lab=_55707_/X }
C {sky130_stdcells/and2_4.sym} 110260 -32140 0 0 {name=X_55707_ }
C {devices/lab_pin.sym} 110200 -32030 0 0 {name=p109263 lab=_74541_/A }
C {devices/lab_pin.sym} 110200 -31990 0 0 {name=p109264 lab=_56535_/X }
C {devices/lab_pin.sym} 110200 -31950 0 0 {name=p109265 lab=_74541_/C }
C {devices/lab_pin.sym} 110320 -31990 0 1 {name=p109266 lab=_74541_/Y }
C {sky130_stdcells/nand3_4.sym} 110260 -31990 0 0 {name=X_74541_ }
C {devices/lab_pin.sym} 110170 -31850 0 0 {name=p109267 lab=_86523_/CLK }
C {devices/lab_pin.sym} 110170 -31830 0 0 {name=p109268 lab=_48389_/Y }
C {devices/lab_pin.sym} 110350 -31850 0 1 {name=p109269 lab=_72817_/B }
C {sky130_stdcells/dfxtp_4.sym} 110260 -31840 0 0 {name=X_86527_ }
C {devices/lab_pin.sym} 110200 -31720 0 0 {name=p109270 lab=_82305_/Q }
C {devices/lab_pin.sym} 110200 -31680 0 0 {name=p109271 lab=_40932_/X }
C {devices/lab_pin.sym} 110320 -31700 0 1 {name=p109272 lab=_40933_/X }
C {sky130_stdcells/or2_4.sym} 110260 -31700 0 0 {name=X_40933_ }
C {devices/lab_pin.sym} 110180 -31590 0 0 {name=p109273 lab=_85730_/Q }
C {devices/lab_pin.sym} 110180 -31550 0 0 {name=p109274 lab=_52902_/X }
C {devices/lab_pin.sym} 110180 -31510 0 0 {name=p109275 lab=_52918_/Y }
C {devices/lab_pin.sym} 110340 -31550 0 1 {name=p109276 lab=_52919_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -31550 0 0 {name=X_52919_ }
C {devices/lab_pin.sym} 110200 -31440 0 0 {name=p109277 lab=_71181_/A }
C {devices/lab_pin.sym} 110200 -31400 0 0 {name=p109278 lab=_71753_/B }
C {devices/lab_pin.sym} 110200 -31360 0 0 {name=p109279 lab=_71744_/C }
C {devices/lab_pin.sym} 110200 -31320 0 0 {name=p109280 lab=_71753_/D }
C {devices/lab_pin.sym} 110320 -31380 0 1 {name=p109281 lab=_71753_/Y }
C {sky130_stdcells/nand4_4.sym} 110260 -31380 0 0 {name=X_71753_ }
C {devices/lab_pin.sym} 110180 -31250 0 0 {name=p109282 lab=_59462_/X }
C {devices/lab_pin.sym} 110180 -31210 0 0 {name=p109283 lab=_83458_/Q }
C {devices/lab_pin.sym} 110180 -31170 0 0 {name=p109284 lab=_59474_/Y }
C {devices/lab_pin.sym} 110340 -31210 0 1 {name=p109285 lab=_84722_/D }
C {sky130_stdcells/o21a_4.sym} 110260 -31210 0 0 {name=X_59475_ }
C {devices/lab_pin.sym} 110170 -31070 0 0 {name=p109286 lab=_83736_/CLK }
C {devices/lab_pin.sym} 110170 -31050 0 0 {name=p109287 lab=_83739_/D }
C {devices/lab_pin.sym} 110350 -31070 0 1 {name=p109288 lab=_83739_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -31060 0 0 {name=X_83739_ }
C {devices/lab_pin.sym} 110180 -30950 0 0 {name=p109289 lab=_56671_/X }
C {devices/lab_pin.sym} 110180 -30910 0 0 {name=p109290 lab=_56685_/X }
C {devices/lab_pin.sym} 110180 -30870 0 0 {name=p109291 lab=_56686_/X }
C {devices/lab_pin.sym} 110340 -30910 0 1 {name=p109292 lab=_56687_/X }
C {sky130_stdcells/o21a_4.sym} 110260 -30910 0 0 {name=X_56687_ }
C {devices/lab_pin.sym} 110180 -30790 0 0 {name=p109293 lab=_85546_/Q }
C {devices/lab_pin.sym} 110180 -30750 0 0 {name=p109294 lab=_53896_/X }
C {devices/lab_pin.sym} 110180 -30710 0 0 {name=p109295 lab=_53898_/Y }
C {devices/lab_pin.sym} 110340 -30750 0 1 {name=p109296 lab=_53899_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -30750 0 0 {name=X_53899_ }
C {devices/lab_pin.sym} 110180 -30630 0 0 {name=p109297 lab=_46435_/Y }
C {devices/lab_pin.sym} 110180 -30590 0 0 {name=p109298 lab=_46399_/X }
C {devices/lab_pin.sym} 110180 -30550 0 0 {name=p109299 lab=_46439_/Y }
C {devices/lab_pin.sym} 110340 -30590 0 1 {name=p109300 lab=_46440_/Y }
C {sky130_stdcells/a21boi_4.sym} 110260 -30590 0 0 {name=X_46440_ }
C {devices/lab_pin.sym} 110220 -30450 0 0 {name=p109301 lab=_70935_/A }
C {devices/lab_pin.sym} 110300 -30450 0 1 {name=p109302 lab=_70716_/A }
C {sky130_stdcells/buf_2.sym} 110260 -30450 0 0 {name=X_70704_ }
C {devices/lab_pin.sym} 110220 -30330 0 0 {name=p109303 lab=_58984_/A }
C {devices/lab_pin.sym} 110300 -30330 0 1 {name=p109304 lab=_58426_/X }
C {sky130_stdcells/buf_2.sym} 110260 -30330 0 0 {name=X_58426_ }
C {devices/lab_pin.sym} 110200 -30220 0 0 {name=p109305 lab=_77260_/A }
C {devices/lab_pin.sym} 110200 -30180 0 0 {name=p109306 lab=_77259_/Y }
C {devices/lab_pin.sym} 110320 -30200 0 1 {name=p109307 lab=_77260_/Y }
C {sky130_stdcells/nor2_4.sym} 110260 -30200 0 0 {name=X_77260_ }
C {devices/lab_pin.sym} 110180 -30100 0 0 {name=p109308 lab=_40707_/A }
C {devices/lab_pin.sym} 110180 -30060 0 0 {name=p109309 lab=_43634_/X }
C {devices/lab_pin.sym} 110180 -30020 0 0 {name=p109310 lab=_68888_/B }
C {devices/lab_pin.sym} 110180 -29980 0 0 {name=p109311 lab=_43636_/X }
C {devices/lab_pin.sym} 110340 -30040 0 1 {name=p109312 lab=_43652_/X }
C {sky130_stdcells/a2bb2o_4.sym} 110260 -30040 0 0 {name=X_43652_ }
C {devices/lab_pin.sym} 110180 -29920 0 0 {name=p109313 lab=_85057_/Q }
C {devices/lab_pin.sym} 110180 -29880 0 0 {name=p109314 lab=_55617_/X }
C {devices/lab_pin.sym} 110180 -29840 0 0 {name=p109315 lab=_55610_/X }
C {devices/lab_pin.sym} 110180 -29800 0 0 {name=p109316 lab=_55637_/Y }
C {devices/lab_pin.sym} 110340 -29860 0 1 {name=p109317 lab=_55638_/X }
C {sky130_stdcells/a211o_4.sym} 110260 -29860 0 0 {name=X_55638_ }
C {devices/lab_pin.sym} 110170 -29710 0 0 {name=p109318 lab=_85555_/CLK }
C {devices/lab_pin.sym} 110170 -29690 0 0 {name=p109319 lab=_86458_/D }
C {devices/lab_pin.sym} 110350 -29710 0 1 {name=p109320 lab=_86458_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -29700 0 0 {name=X_86458_ }
C {devices/lab_pin.sym} 110200 -29590 0 0 {name=p109321 lab=_48609_/A }
C {devices/lab_pin.sym} 110200 -29550 0 0 {name=p109322 lab=_74478_/B }
C {devices/lab_pin.sym} 110200 -29510 0 0 {name=p109323 lab=_74478_/C }
C {devices/lab_pin.sym} 110320 -29550 0 1 {name=p109324 lab=_74472_/X }
C {sky130_stdcells/and3_4.sym} 110260 -29550 0 0 {name=X_74472_ }
C {devices/lab_pin.sym} 110200 -29420 0 0 {name=p109325 lab=_40864_/A }
C {devices/lab_pin.sym} 110200 -29380 0 0 {name=p109326 lab=_40883_/B }
C {devices/lab_pin.sym} 110320 -29400 0 1 {name=p109327 lab=_40864_/X }
C {sky130_stdcells/or2_4.sym} 110260 -29400 0 0 {name=X_40864_ }
C {devices/lab_pin.sym} 110180 -29290 0 0 {name=p109328 lab=_71682_/Y }
C {devices/lab_pin.sym} 110180 -29250 0 0 {name=p109329 lab=_83412_/Q }
C {devices/lab_pin.sym} 110180 -29210 0 0 {name=p109330 lab=_71683_/Y }
C {devices/lab_pin.sym} 110340 -29250 0 1 {name=p109331 lab=_71684_/X }
C {sky130_stdcells/a21o_4.sym} 110260 -29250 0 0 {name=X_71684_ }
C {devices/lab_pin.sym} 110180 -29130 0 0 {name=p109332 lab=_76194_/Y }
C {devices/lab_pin.sym} 110180 -29090 0 0 {name=p109333 lab=_76192_/X }
C {devices/lab_pin.sym} 110180 -29050 0 0 {name=p109334 lab=_76210_/Y }
C {devices/lab_pin.sym} 110340 -29090 0 1 {name=p109335 lab=_76211_/Y }
C {sky130_stdcells/a21oi_4.sym} 110260 -29090 0 0 {name=X_76211_ }
C {devices/lab_pin.sym} 110220 -28950 0 0 {name=p109336 lab=_42603_/A }
C {devices/lab_pin.sym} 110300 -28950 0 1 {name=p109337 lab=_42603_/Y }
C {sky130_stdcells/inv_2.sym} 110260 -28950 0 0 {name=X_42603_ }
C {devices/lab_pin.sym} 110170 -28830 0 0 {name=p109338 lab=_85505_/CLK }
C {devices/lab_pin.sym} 110170 -28810 0 0 {name=p109339 lab=_85409_/D }
C {devices/lab_pin.sym} 110350 -28830 0 1 {name=p109340 lab=_85409_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -28820 0 0 {name=X_85409_ }
C {devices/lab_pin.sym} 110180 -28710 0 0 {name=p109341 lab=_44583_/Y }
C {devices/lab_pin.sym} 110180 -28670 0 0 {name=p109342 lab=_73420_/X }
C {devices/lab_pin.sym} 110180 -28630 0 0 {name=p109343 lab=_73422_/Y }
C {devices/lab_pin.sym} 110340 -28670 0 1 {name=p109344 lab=_73434_/C }
C {sky130_stdcells/a21o_4.sym} 110260 -28670 0 0 {name=X_73423_ }
C {devices/lab_pin.sym} 110200 -28540 0 0 {name=p109345 lab=_46371_/A }
C {devices/lab_pin.sym} 110200 -28500 0 0 {name=p109346 lab=_46380_/B }
C {devices/lab_pin.sym} 110320 -28520 0 1 {name=p109347 lab=_46371_/X }
C {sky130_stdcells/or2_4.sym} 110260 -28520 0 0 {name=X_46371_ }
C {devices/lab_pin.sym} 110220 -28390 0 0 {name=p109348 lab=_70635_/A }
C {devices/lab_pin.sym} 110300 -28390 0 1 {name=p109349 lab=_70639_/B }
C {sky130_stdcells/buf_2.sym} 110260 -28390 0 0 {name=X_70635_ }
C {devices/lab_pin.sym} 110180 -28290 0 0 {name=p109350 lab=_58334_/X }
C {devices/lab_pin.sym} 110180 -28250 0 0 {name=p109351 lab=_61656_/A }
C {devices/lab_pin.sym} 110180 -28210 0 0 {name=p109352 lab=_58356_/Y }
C {devices/lab_pin.sym} 110340 -28250 0 1 {name=p109353 lab=_84870_/D }
C {sky130_stdcells/a21oi_4.sym} 110260 -28250 0 0 {name=X_58357_ }
C {devices/lab_pin.sym} 110200 -28120 0 0 {name=p109354 lab=_82108_/Q }
C {devices/lab_pin.sym} 110200 -28080 0 0 {name=p109355 lab=_77191_/B }
C {devices/lab_pin.sym} 110320 -28100 0 1 {name=p109356 lab=_77191_/X }
C {sky130_stdcells/xor2_4.sym} 110260 -28100 0 0 {name=X_77191_ }
C {devices/lab_pin.sym} 110220 -27970 0 0 {name=p109357 lab=_48144_/A }
C {devices/lab_pin.sym} 110300 -27970 0 1 {name=p109358 lab=_43583_/Y }
C {sky130_stdcells/inv_2.sym} 110260 -27970 0 0 {name=X_43583_ }
C {devices/lab_pin.sym} 110200 -27880 0 0 {name=p109359 lab=_56595_/A }
C {devices/lab_pin.sym} 110200 -27840 0 0 {name=p109360 lab=_55562_/X }
C {devices/lab_pin.sym} 110200 -27800 0 0 {name=p109361 lab=_56595_/B }
C {devices/lab_pin.sym} 110200 -27760 0 0 {name=p109362 lab=_55568_/X }
C {devices/lab_pin.sym} 110320 -27820 0 1 {name=p109363 lab=_55570_/D }
C {sky130_stdcells/and4_4.sym} 110260 -27820 0 0 {name=X_55569_ }
C {devices/lab_pin.sym} 110170 -27670 0 0 {name=p109364 lab=_83676_/CLK }
C {devices/lab_pin.sym} 110170 -27650 0 0 {name=p109365 lab=_49430_/Y }
C {devices/lab_pin.sym} 110350 -27670 0 1 {name=p109366 lab=_58720_/B }
C {sky130_stdcells/dfxtp_4.sym} 110260 -27660 0 0 {name=X_86389_ }
C {devices/lab_pin.sym} 110180 -27560 0 0 {name=p109367 lab=_40792_/X }
C {devices/lab_pin.sym} 110180 -27520 0 0 {name=p109368 lab=_40793_/X }
C {devices/lab_pin.sym} 110180 -27480 0 0 {name=p109369 lab=_88334_/Q }
C {devices/lab_pin.sym} 110180 -27440 0 0 {name=p109370 lab=_40794_/X }
C {devices/lab_pin.sym} 110340 -27500 0 1 {name=p109371 lab=_88334_/D }
C {sky130_stdcells/a2bb2o_4.sym} 110260 -27500 0 0 {name=X_40795_ }
C {devices/lab_pin.sym} 110200 -27360 0 0 {name=p109372 lab=_48110_/A }
C {devices/lab_pin.sym} 110200 -27320 0 0 {name=p109373 lab=_48086_/B }
C {devices/lab_pin.sym} 110320 -27340 0 1 {name=p109374 lab=_48110_/X }
C {sky130_stdcells/or2_4.sym} 110260 -27340 0 0 {name=X_48110_ }
C {devices/lab_pin.sym} 110180 -27230 0 0 {name=p109375 lab=_45277_/X }
C {devices/lab_pin.sym} 110180 -27190 0 0 {name=p109376 lab=_61649_/B }
C {devices/lab_pin.sym} 110180 -27150 0 0 {name=p109377 lab=_45294_/X }
C {devices/lab_pin.sym} 110340 -27190 0 1 {name=p109378 lab=_45322_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -27190 0 0 {name=X_45322_ }
C {devices/lab_pin.sym} 110180 -27070 0 0 {name=p109379 lab=_57306_/Y }
C {devices/lab_pin.sym} 110180 -27030 0 0 {name=p109380 lab=_57307_/Y }
C {devices/lab_pin.sym} 110180 -26990 0 0 {name=p109381 lab=_57280_/X }
C {devices/lab_pin.sym} 110340 -27030 0 1 {name=p109382 lab=_57308_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -27030 0 0 {name=X_57308_ }
C {devices/lab_pin.sym} 110200 -26900 0 0 {name=p109383 lab=_76142_/A }
C {devices/lab_pin.sym} 110200 -26860 0 0 {name=p109384 lab=_76142_/B }
C {devices/lab_pin.sym} 110320 -26880 0 1 {name=p109385 lab=_76142_/X }
C {sky130_stdcells/xor2_4.sym} 110260 -26880 0 0 {name=X_76142_ }
C {devices/lab_pin.sym} 110170 -26750 0 0 {name=p109386 lab=_88128_/CLK }
C {devices/lab_pin.sym} 110170 -26730 0 0 {name=p109387 lab=_41838_/X }
C {devices/lab_pin.sym} 110350 -26750 0 1 {name=p109388 lab=_67028_/B }
C {sky130_stdcells/dfxtp_4.sym} 110260 -26740 0 0 {name=X_88128_ }
C {devices/lab_pin.sym} 110220 -26610 0 0 {name=p109389 lab=_74224_/A }
C {devices/lab_pin.sym} 110300 -26610 0 1 {name=p109390 lab=_42534_/Y }
C {sky130_stdcells/inv_2.sym} 110260 -26610 0 0 {name=X_42534_ }
C {devices/lab_pin.sym} 110180 -26520 0 0 {name=p109391 lab=_73257_/X }
C {devices/lab_pin.sym} 110180 -26480 0 0 {name=p109392 lab=_86186_/Q }
C {devices/lab_pin.sym} 110180 -26440 0 0 {name=p109393 lab=_73351_/X }
C {devices/lab_pin.sym} 110180 -26400 0 0 {name=p109394 lab=_73353_/X }
C {devices/lab_pin.sym} 110340 -26460 0 1 {name=p109395 lab=_73354_/X }
C {sky130_stdcells/a211o_4.sym} 110260 -26460 0 0 {name=X_73354_ }
C {devices/lab_pin.sym} 110220 -26310 0 0 {name=p109396 lab=_48623_/A }
C {devices/lab_pin.sym} 110300 -26310 0 1 {name=p109397 lab=_49091_/C }
C {sky130_stdcells/buf_2.sym} 110260 -26310 0 0 {name=X_49090_ }
C {devices/lab_pin.sym} 110220 -26190 0 0 {name=p109398 lab=DATA_TO_HASH[1] }
C {devices/lab_pin.sym} 110300 -26190 0 1 {name=p109399 lab=_71887_/A }
C {sky130_stdcells/inv_2.sym} 110260 -26190 0 0 {name=X_70566_ }
C {devices/lab_pin.sym} 110220 -26070 0 0 {name=p109400 lab=clkbuf_7_23_0_CLK/A }
C {devices/lab_pin.sym} 110300 -26070 0 1 {name=p109401 lab=clkbuf_8_47_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 110260 -26070 0 0 {name=Xclkbuf_7_23_0_CLK }
C {devices/lab_pin.sym} 110200 -25960 0 0 {name=p109402 lab=_58287_/Y }
C {devices/lab_pin.sym} 110200 -25920 0 0 {name=p109403 lab=_58280_/B }
C {devices/lab_pin.sym} 110320 -25940 0 1 {name=p109404 lab=_58288_/Y }
C {sky130_stdcells/nand2_4.sym} 110260 -25940 0 0 {name=X_58288_ }
C {devices/lab_pin.sym} 110220 -25810 0 0 {name=p109405 lab=_57759_/X }
C {devices/lab_pin.sym} 110300 -25810 0 1 {name=p109406 lab=_72305_/X }
C {sky130_stdcells/buf_2.sym} 110260 -25810 0 0 {name=X_72305_ }
C {devices/lab_pin.sym} 110200 -25700 0 0 {name=p109407 lab=_48004_/A }
C {devices/lab_pin.sym} 110200 -25660 0 0 {name=p109408 lab=_52036_/B }
C {devices/lab_pin.sym} 110320 -25680 0 1 {name=p109409 lab=_48041_/Y }
C {sky130_stdcells/nand2_4.sym} 110260 -25680 0 0 {name=X_48041_ }
C {devices/lab_pin.sym} 110220 -25550 0 0 {name=p109410 lab=clkbuf_7_81_0_CLK/X }
C {devices/lab_pin.sym} 110300 -25550 0 1 {name=p109411 lab=clkbuf_9_326_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 110260 -25550 0 0 {name=Xclkbuf_8_163_0_CLK }
C {devices/lab_pin.sym} 110180 -25450 0 0 {name=p109412 lab=_85162_/Q }
C {devices/lab_pin.sym} 110180 -25410 0 0 {name=p109413 lab=_45209_/X }
C {devices/lab_pin.sym} 110180 -25370 0 0 {name=p109414 lab=_45189_/X }
C {devices/lab_pin.sym} 110340 -25410 0 1 {name=p109415 lab=_45253_/X }
C {sky130_stdcells/o21a_4.sym} 110260 -25410 0 0 {name=X_45253_ }
C {devices/lab_pin.sym} 110180 -25300 0 0 {name=p109416 lab=_44288_/X }
C {devices/lab_pin.sym} 110180 -25260 0 0 {name=p109417 lab=_56571_/X }
C {devices/lab_pin.sym} 110180 -25220 0 0 {name=p109418 lab=_45413_/A }
C {devices/lab_pin.sym} 110180 -25180 0 0 {name=p109419 lab=_57238_/X }
C {devices/lab_pin.sym} 110340 -25240 0 1 {name=p109420 lab=_57239_/X }
C {sky130_stdcells/a2bb2o_4.sym} 110260 -25240 0 0 {name=X_57239_ }
C {devices/lab_pin.sym} 110200 -25100 0 0 {name=p109421 lab=_76073_/A }
C {devices/lab_pin.sym} 110200 -25060 0 0 {name=p109422 lab=_76073_/B }
C {devices/lab_pin.sym} 110320 -25080 0 1 {name=p109423 lab=_76074_/B }
C {sky130_stdcells/xnor2_4.sym} 110260 -25080 0 0 {name=X_76073_ }
C {devices/lab_pin.sym} 110170 -24950 0 0 {name=p109424 lab=_87553_/CLK }
C {devices/lab_pin.sym} 110170 -24930 0 0 {name=p109425 lab=_42046_/Y }
C {devices/lab_pin.sym} 110350 -24950 0 1 {name=p109426 lab=_73372_/A }
C {sky130_stdcells/dfxtp_4.sym} 110260 -24940 0 0 {name=X_88059_ }
C {devices/lab_pin.sym} 110220 -24810 0 0 {name=p109427 lab=_42465_/A }
C {devices/lab_pin.sym} 110300 -24810 0 1 {name=p109428 lab=_42610_/A }
C {sky130_stdcells/buf_2.sym} 110260 -24810 0 0 {name=X_42465_ }
C {devices/lab_pin.sym} 110200 -24700 0 0 {name=p109429 lab=_73260_/A }
C {devices/lab_pin.sym} 110200 -24660 0 0 {name=p109430 lab=_86477_/Q }
C {devices/lab_pin.sym} 110320 -24680 0 1 {name=p109431 lab=_73285_/X }
C {sky130_stdcells/and2_4.sym} 110260 -24680 0 0 {name=X_73285_ }
C {devices/lab_pin.sym} 110220 -24550 0 0 {name=p109432 lab=HASH_ADDR[5] }
C {devices/lab_pin.sym} 110300 -24550 0 1 {name=p109433 lab=_70700_/A }
C {sky130_stdcells/buf_2.sym} 110260 -24550 0 0 {name=X_70497_ }
C {devices/lab_pin.sym} 110220 -24430 0 0 {name=p109434 lab=_44166_/Y }
C {devices/lab_pin.sym} 110300 -24430 0 1 {name=p109435 lab=_44204_/Y }
C {sky130_stdcells/inv_2.sym} 110260 -24430 0 0 {name=X_44204_ }
C {devices/lab_pin.sym} 110200 -24320 0 0 {name=p109436 lab=_80954_/Q }
C {devices/lab_pin.sym} 110200 -24280 0 0 {name=p109437 lab=_75024_/B }
C {devices/lab_pin.sym} 110320 -24300 0 1 {name=p109438 lab=_75024_/X }
C {sky130_stdcells/xor2_4.sym} 110260 -24300 0 0 {name=X_75024_ }
C {devices/lab_pin.sym} 110200 -24180 0 0 {name=p109439 lab=_84922_/Q }
C {devices/lab_pin.sym} 110200 -24140 0 0 {name=p109440 lab=_65901_/C }
C {devices/lab_pin.sym} 110320 -24160 0 1 {name=p109441 lab=_80263_/B }
C {sky130_stdcells/nand2_4.sym} 110260 -24160 0 0 {name=X_79901_ }
C {devices/lab_pin.sym} 110220 -24030 0 0 {name=p109442 lab=_41415_/Y }
C {devices/lab_pin.sym} 110300 -24030 0 1 {name=p109443 lab=_41416_/X }
C {sky130_stdcells/buf_2.sym} 110260 -24030 0 0 {name=X_41416_ }
C {devices/lab_pin.sym} 110200 -23930 0 0 {name=p109444 lab=_60170_/A }
C {devices/lab_pin.sym} 110200 -23890 0 0 {name=p109445 lab=_60218_/A }
C {devices/lab_pin.sym} 110200 -23850 0 0 {name=p109446 lab=_60324_/B }
C {devices/lab_pin.sym} 110320 -23890 0 1 {name=p109447 lab=_60367_/C }
C {sky130_stdcells/nand3_4.sym} 110260 -23890 0 0 {name=X_60250_ }
C {devices/lab_pin.sym} 110220 -23750 0 0 {name=p109448 lab=_72236_/A }
C {devices/lab_pin.sym} 110300 -23750 0 1 {name=p109449 lab=_72236_/Y }
C {sky130_stdcells/inv_2.sym} 110260 -23750 0 0 {name=X_72236_ }
C {devices/lab_pin.sym} 110220 -23630 0 0 {name=p109450 lab=_64420_/B }
C {devices/lab_pin.sym} 110300 -23630 0 1 {name=p109451 lab=_61548_/B }
C {sky130_stdcells/buf_2.sym} 110260 -23630 0 0 {name=X_45184_ }
C {devices/lab_pin.sym} 110180 -23540 0 0 {name=p109452 lab=_40418_/X }
C {devices/lab_pin.sym} 110180 -23500 0 0 {name=p109453 lab=_42388_/X }
C {devices/lab_pin.sym} 110180 -23460 0 0 {name=p109454 lab=_87882_/Q }
C {devices/lab_pin.sym} 110180 -23420 0 0 {name=p109455 lab=_42389_/X }
C {devices/lab_pin.sym} 110340 -23480 0 1 {name=p109456 lab=_87882_/D }
C {sky130_stdcells/a2bb2o_4.sym} 110260 -23480 0 0 {name=X_42396_ }
C {devices/lab_pin.sym} 110220 -23330 0 0 {name=p109457 lab=_44134_/X }
C {devices/lab_pin.sym} 110300 -23330 0 1 {name=p109458 lab=_44135_/X }
C {sky130_stdcells/buf_2.sym} 110260 -23330 0 0 {name=X_44135_ }
C {devices/lab_pin.sym} 110220 -23210 0 0 {name=p109459 lab=clkbuf_7_39_0_CLK/A }
C {devices/lab_pin.sym} 110300 -23210 0 1 {name=p109460 lab=clkbuf_8_77_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 110260 -23210 0 0 {name=Xclkbuf_7_38_0_CLK }
C {devices/lab_pin.sym} 110180 -23110 0 0 {name=p109461 lab=_79812_/Y }
C {devices/lab_pin.sym} 110180 -23070 0 0 {name=p109462 lab=_79852_/B }
C {devices/lab_pin.sym} 110180 -23030 0 0 {name=p109463 lab=_79831_/X }
C {devices/lab_pin.sym} 110340 -23070 0 1 {name=p109464 lab=_79832_/Y }
C {sky130_stdcells/a21boi_4.sym} 110260 -23070 0 0 {name=X_79832_ }
C {devices/lab_pin.sym} 110220 -22930 0 0 {name=p109465 lab=_41346_/X }
C {devices/lab_pin.sym} 110300 -22930 0 1 {name=p109466 lab=_41347_/X }
C {sky130_stdcells/buf_2.sym} 110260 -22930 0 0 {name=X_41347_ }
C {devices/lab_pin.sym} 110180 -22830 0 0 {name=p109467 lab=_59292_/X }
C {devices/lab_pin.sym} 110180 -22790 0 0 {name=p109468 lab=_85341_/Q }
C {devices/lab_pin.sym} 110180 -22750 0 0 {name=p109469 lab=_59365_/X }
C {devices/lab_pin.sym} 110340 -22790 0 1 {name=p109470 lab=_72167_/X }
C {sky130_stdcells/o21a_4.sym} 110260 -22790 0 0 {name=X_72167_ }
C {devices/lab_pin.sym} 110220 -22650 0 0 {name=p109471 lab=_60291_/C }
C {devices/lab_pin.sym} 110300 -22650 0 1 {name=p109472 lab=_60324_/A }
C {sky130_stdcells/buf_2.sym} 110260 -22650 0 0 {name=X_60181_ }
C {devices/lab_pin.sym} 110200 -22540 0 0 {name=p109473 lab=_50001_/A }
C {devices/lab_pin.sym} 110200 -22500 0 0 {name=p109474 lab=_53205_/B }
C {devices/lab_pin.sym} 110320 -22520 0 1 {name=p109475 lab=_49992_/Y }
C {sky130_stdcells/nand2_4.sym} 110260 -22520 0 0 {name=X_49992_ }
C {devices/lab_pin.sym} 110220 -22390 0 0 {name=p109476 lab=clkbuf_7_89_0_CLK/X }
C {devices/lab_pin.sym} 110300 -22390 0 1 {name=p109477 lab=clkbuf_8_178_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 110260 -22390 0 0 {name=Xclkbuf_8_178_0_CLK }
C {devices/lab_pin.sym} 110220 -22270 0 0 {name=p109478 lab=clkbuf_9_86_0_CLK/X }
C {devices/lab_pin.sym} 110300 -22270 0 1 {name=p109479 lab=_81794_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 110260 -22270 0 0 {name=Xclkbuf_10_173_0_CLK }
C {devices/lab_pin.sym} 110220 -22150 0 0 {name=p109480 lab=_70913_/A }
C {devices/lab_pin.sym} 110300 -22150 0 1 {name=p109481 lab=_71119_/C }
C {sky130_stdcells/buf_2.sym} 110260 -22150 0 0 {name=X_71118_ }
C {devices/lab_pin.sym} 110220 -22030 0 0 {name=p109482 lab=_71987_/B }
C {devices/lab_pin.sym} 110300 -22030 0 1 {name=p109483 lab=_48944_/B }
C {sky130_stdcells/buf_2.sym} 110260 -22030 0 0 {name=X_48943_ }
C {devices/lab_pin.sym} 110220 -21910 0 0 {name=p109484 lab=_44086_/A }
C {devices/lab_pin.sym} 110300 -21910 0 1 {name=p109485 lab=_44116_/B }
C {sky130_stdcells/buf_2.sym} 110260 -21910 0 0 {name=X_44066_ }
C {devices/lab_pin.sym} 110200 -21800 0 0 {name=p109486 lab=_84222_/Q }
C {devices/lab_pin.sym} 110200 -21760 0 0 {name=p109487 lab=_83270_/Q }
C {devices/lab_pin.sym} 110320 -21780 0 1 {name=p109488 lab=_79763_/X }
C {sky130_stdcells/xor2_4.sym} 110260 -21780 0 0 {name=X_79763_ }
C {devices/lab_pin.sym} 110180 -21690 0 0 {name=p109489 lab=_41239_/X }
C {devices/lab_pin.sym} 110180 -21650 0 0 {name=p109490 lab=_41241_/X }
C {devices/lab_pin.sym} 110180 -21610 0 0 {name=p109491 lab=_41277_/X }
C {devices/lab_pin.sym} 110180 -21570 0 0 {name=p109492 lab=_69104_/B }
C {devices/lab_pin.sym} 110180 -21530 0 0 {name=p109493 lab=_41236_/X }
C {devices/lab_pin.sym} 110340 -21610 0 1 {name=p109494 lab=_41279_/A }
C {sky130_stdcells/o32ai_4.sym} 110260 -21610 0 0 {name=X_41278_ }
C {devices/lab_pin.sym} 110220 -21450 0 0 {name=p109495 lab=_46259_/A }
C {devices/lab_pin.sym} 110300 -21450 0 1 {name=p109496 lab=_74391_/A }
C {sky130_stdcells/buf_2.sym} 110260 -21450 0 0 {name=X_72098_ }
C {devices/lab_pin.sym} 110200 -21340 0 0 {name=p109497 lab=_76975_/A }
C {devices/lab_pin.sym} 110200 -21300 0 0 {name=p109498 lab=_84399_/Q }
C {devices/lab_pin.sym} 110320 -21320 0 1 {name=p109499 lab=_76975_/X }
C {sky130_stdcells/xor2_4.sym} 110260 -21320 0 0 {name=X_76975_ }
C {devices/lab_pin.sym} 110220 -21190 0 0 {name=p109500 lab=_43017_/A }
C {devices/lab_pin.sym} 110300 -21190 0 1 {name=p109501 lab=_43017_/X }
C {sky130_stdcells/buf_2.sym} 110260 -21190 0 0 {name=X_43017_ }
C {devices/lab_pin.sym} 110180 -21090 0 0 {name=p109502 lab=_78713_/B }
C {devices/lab_pin.sym} 110180 -21050 0 0 {name=p109503 lab=_78712_/Y }
C {devices/lab_pin.sym} 110180 -21010 0 0 {name=p109504 lab=_78709_/Y }
C {devices/lab_pin.sym} 110340 -21050 0 1 {name=p109505 lab=_78718_/C }
C {sky130_stdcells/o21ai_4.sym} 110260 -21050 0 0 {name=X_78714_ }
C {devices/lab_pin.sym} 110200 -20940 0 0 {name=p109506 lab=_61922_/X }
C {devices/lab_pin.sym} 110200 -20900 0 0 {name=p109507 lab=_63876_/B }
C {devices/lab_pin.sym} 110200 -20860 0 0 {name=p109508 lab=_63905_/C }
C {devices/lab_pin.sym} 110200 -20820 0 0 {name=p109509 lab=_63892_/D }
C {devices/lab_pin.sym} 110320 -20880 0 1 {name=p109510 lab=_63940_/Y }
C {sky130_stdcells/nand4_4.sym} 110260 -20880 0 0 {name=X_63940_ }
C {devices/lab_pin.sym} 110220 -20730 0 0 {name=p109511 lab=_71049_/A }
C {devices/lab_pin.sym} 110300 -20730 0 1 {name=p109512 lab=_71055_/C }
C {sky130_stdcells/buf_2.sym} 110260 -20730 0 0 {name=X_71049_ }
C {devices/lab_pin.sym} 110200 -20620 0 0 {name=p109513 lab=_81698_/D }
C {devices/lab_pin.sym} 110200 -20580 0 0 {name=p109514 lab=_75924_/B }
C {devices/lab_pin.sym} 110320 -20600 0 1 {name=p109515 lab=_75928_/A }
C {sky130_stdcells/nand2_4.sym} 110260 -20600 0 0 {name=X_75926_ }
C {devices/lab_pin.sym} 110200 -20480 0 0 {name=p109516 lab=_50069_/A }
C {devices/lab_pin.sym} 110200 -20440 0 0 {name=p109517 lab=_48874_/B }
C {devices/lab_pin.sym} 110320 -20460 0 1 {name=p109518 lab=_48874_/X }
C {sky130_stdcells/and2_4.sym} 110260 -20460 0 0 {name=X_48874_ }
C {devices/lab_pin.sym} 110200 -20340 0 0 {name=p109519 lab=_79678_/X }
C {devices/lab_pin.sym} 110200 -20300 0 0 {name=p109520 lab=_79682_/B }
C {devices/lab_pin.sym} 110320 -20320 0 1 {name=p109521 lab=_79694_/X }
C {sky130_stdcells/or2_4.sym} 110260 -20320 0 0 {name=X_79694_ }
C {devices/lab_pin.sym} 110220 -20190 0 0 {name=p109522 lab=clkbuf_9_295_0_CLK/A }
C {devices/lab_pin.sym} 110300 -20190 0 1 {name=p109523 lab=clkbuf_9_294_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 110260 -20190 0 0 {name=Xclkbuf_9_294_0_CLK }
C {devices/lab_pin.sym} 110220 -20070 0 0 {name=p109524 lab=clkbuf_7_50_0_CLK/X }
C {devices/lab_pin.sym} 110300 -20070 0 1 {name=p109525 lab=clkbuf_9_203_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 110260 -20070 0 0 {name=Xclkbuf_8_101_0_CLK }
C {devices/lab_pin.sym} 110220 -19950 0 0 {name=p109526 lab=_47825_/A }
C {devices/lab_pin.sym} 110300 -19950 0 1 {name=p109527 lab=_48914_/A }
C {sky130_stdcells/buf_2.sym} 110260 -19950 0 0 {name=X_47825_ }
C {devices/lab_pin.sym} 110220 -19830 0 0 {name=p109528 lab=_82809_/Q }
C {devices/lab_pin.sym} 110300 -19830 0 1 {name=p109529 lab=_78645_/Y }
C {sky130_stdcells/inv_2.sym} 110260 -19830 0 0 {name=X_78645_ }
C {devices/lab_pin.sym} 110200 -19740 0 0 {name=p109530 lab=_64305_/B }
C {devices/lab_pin.sym} 110200 -19700 0 0 {name=p109531 lab=_63920_/B }
C {devices/lab_pin.sym} 110200 -19660 0 0 {name=p109532 lab=_63840_/C }
C {devices/lab_pin.sym} 110200 -19620 0 0 {name=p109533 lab=_63920_/D }
C {devices/lab_pin.sym} 110320 -19680 0 1 {name=p109534 lab=_63871_/Y }
C {sky130_stdcells/nand4_4.sym} 110260 -19680 0 0 {name=X_63871_ }
C {devices/lab_pin.sym} 110180 -19560 0 0 {name=p109535 lab=_75838_/Y }
C {devices/lab_pin.sym} 110180 -19520 0 0 {name=p109536 lab=_75840_/B }
C {devices/lab_pin.sym} 110180 -19480 0 0 {name=p109537 lab=_80926_/Q }
C {devices/lab_pin.sym} 110180 -19440 0 0 {name=p109538 lab=_80798_/D }
C {devices/lab_pin.sym} 110340 -19500 0 1 {name=p109539 lab=_75857_/X }
C {sky130_stdcells/a2bb2o_4.sym} 110260 -19500 0 0 {name=X_75857_ }
C {devices/lab_pin.sym} 110220 -19350 0 0 {name=p109540 lab=clkbuf_9_94_0_CLK/X }
C {devices/lab_pin.sym} 110300 -19350 0 1 {name=p109541 lab=_80719_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 110260 -19350 0 0 {name=Xclkbuf_10_188_0_CLK }
C {devices/lab_pin.sym} 110180 -19260 0 0 {name=p109542 lab=_65438_/X }
C {devices/lab_pin.sym} 110180 -19220 0 0 {name=p109543 lab=_86197_/Q }
C {devices/lab_pin.sym} 110180 -19180 0 0 {name=p109544 lab=_65576_/X }
C {devices/lab_pin.sym} 110180 -19140 0 0 {name=p109545 lab=_65609_/X }
C {devices/lab_pin.sym} 110340 -19200 0 1 {name=p109546 lab=_65610_/X }
C {sky130_stdcells/a211o_4.sym} 110260 -19200 0 0 {name=X_65610_ }
C {devices/lab_pin.sym} 110200 -19080 0 0 {name=p109547 lab=_61500_/X }
C {devices/lab_pin.sym} 110200 -19040 0 0 {name=p109548 lab=_62834_/B }
C {devices/lab_pin.sym} 110200 -19000 0 0 {name=p109549 lab=_62801_/X }
C {devices/lab_pin.sym} 110200 -18960 0 0 {name=p109550 lab=_62834_/D }
C {devices/lab_pin.sym} 110320 -19020 0 1 {name=p109551 lab=_62822_/Y }
C {sky130_stdcells/nand4_4.sym} 110260 -19020 0 0 {name=X_62822_ }
C {devices/lab_pin.sym} 110200 -18890 0 0 {name=p109552 lab=_74723_/X }
C {devices/lab_pin.sym} 110200 -18850 0 0 {name=p109553 lab=_74808_/B }
C {devices/lab_pin.sym} 110200 -18810 0 0 {name=p109554 lab=_74745_/D }
C {devices/lab_pin.sym} 110320 -18850 0 1 {name=p109555 lab=_74810_/C }
C {sky130_stdcells/nand3_4.sym} 110260 -18850 0 0 {name=X_74808_ }
C {devices/lab_pin.sym} 110220 -18710 0 0 {name=p109556 lab=_81225_/Q }
C {devices/lab_pin.sym} 110300 -18710 0 1 {name=p109557 lab=_47757_/A }
C {sky130_stdcells/inv_2.sym} 110260 -18710 0 0 {name=X_47756_ }
C {devices/lab_pin.sym} 110200 -18600 0 0 {name=p109558 lab=_68999_/A }
C {devices/lab_pin.sym} 110200 -18560 0 0 {name=p109559 lab=_86805_/Q }
C {devices/lab_pin.sym} 110320 -18580 0 1 {name=p109560 lab=_66590_/X }
C {sky130_stdcells/and2_4.sym} 110260 -18580 0 0 {name=X_66590_ }
C {devices/lab_pin.sym} 110220 -18450 0 0 {name=p109561 lab=_78575_/X }
C {devices/lab_pin.sym} 110300 -18450 0 1 {name=p109562 lab=_78600_/A }
C {sky130_stdcells/inv_2.sym} 110260 -18450 0 0 {name=X_78576_ }
C {devices/lab_pin.sym} 110220 -18330 0 0 {name=p109563 lab=_45734_/A }
C {devices/lab_pin.sym} 110300 -18330 0 1 {name=p109564 lab=_44968_/X }
C {sky130_stdcells/buf_2.sym} 110260 -18330 0 0 {name=X_44968_ }
C {devices/lab_pin.sym} 110200 -18220 0 0 {name=p109565 lab=_75771_/A }
C {devices/lab_pin.sym} 110200 -18180 0 0 {name=p109566 lab=_75784_/A }
C {devices/lab_pin.sym} 110320 -18200 0 1 {name=p109567 lab=_75788_/Y }
C {sky130_stdcells/nand2_4.sym} 110260 -18200 0 0 {name=X_75788_ }
C {devices/lab_pin.sym} 110220 -18070 0 0 {name=p109568 lab=_46706_/Y }
C {devices/lab_pin.sym} 110300 -18070 0 1 {name=p109569 lab=_46707_/X }
C {sky130_stdcells/buf_2.sym} 110260 -18070 0 0 {name=X_46707_ }
C {devices/lab_pin.sym} 110200 -17960 0 0 {name=p109570 lab=_65474_/X }
C {devices/lab_pin.sym} 110200 -17920 0 0 {name=p109571 lab=_86522_/Q }
C {devices/lab_pin.sym} 110320 -17940 0 1 {name=p109572 lab=_65541_/X }
C {sky130_stdcells/and2_4.sym} 110260 -17940 0 0 {name=X_65541_ }
C {devices/lab_pin.sym} 110200 -17820 0 0 {name=p109573 lab=_77520_/X }
C {devices/lab_pin.sym} 110200 -17780 0 0 {name=p109574 lab=_77526_/Y }
C {devices/lab_pin.sym} 110320 -17800 0 1 {name=p109575 lab=_82198_/D }
C {sky130_stdcells/xor2_4.sym} 110260 -17800 0 0 {name=X_77527_ }
C {devices/lab_pin.sym} 110220 -17670 0 0 {name=p109576 lab=_43918_/Y }
C {devices/lab_pin.sym} 110300 -17670 0 1 {name=p109577 lab=_87200_/D }
C {sky130_stdcells/inv_2.sym} 110260 -17670 0 0 {name=X_43919_ }
C {devices/lab_pin.sym} 110200 -17570 0 0 {name=p109578 lab=_62727_/A }
C {devices/lab_pin.sym} 110200 -17530 0 0 {name=p109579 lab=_62762_/B }
C {devices/lab_pin.sym} 110200 -17490 0 0 {name=p109580 lab=_61861_/X }
C {devices/lab_pin.sym} 110320 -17530 0 1 {name=p109581 lab=_62753_/Y }
C {sky130_stdcells/nand3_4.sym} 110260 -17530 0 0 {name=X_62753_ }
C {devices/lab_pin.sym} 110200 -17410 0 0 {name=p109582 lab=_74716_/A }
C {devices/lab_pin.sym} 110200 -17370 0 0 {name=p109583 lab=_74739_/B }
C {devices/lab_pin.sym} 110200 -17330 0 0 {name=p109584 lab=_70732_/X }
C {devices/lab_pin.sym} 110320 -17370 0 1 {name=p109585 lab=_74739_/Y }
C {sky130_stdcells/nand3_4.sym} 110260 -17370 0 0 {name=X_74739_ }
C {devices/lab_pin.sym} 110220 -17230 0 0 {name=p109586 lab=_54880_/B }
C {devices/lab_pin.sym} 110300 -17230 0 1 {name=p109587 lab=_53187_/B }
C {sky130_stdcells/buf_2.sym} 110260 -17230 0 0 {name=X_47687_ }
C {devices/lab_pin.sym} 110180 -17130 0 0 {name=p109588 lab=_55990_/C }
C {devices/lab_pin.sym} 110180 -17090 0 0 {name=p109589 lab=_45876_/B }
C {devices/lab_pin.sym} 110180 -17050 0 0 {name=p109590 lab=_44898_/X }
C {devices/lab_pin.sym} 110340 -17090 0 1 {name=p109591 lab=_44899_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -17090 0 0 {name=X_44899_ }
C {devices/lab_pin.sym} 110220 -16950 0 0 {name=p109592 lab=clkbuf_7_58_0_CLK/X }
C {devices/lab_pin.sym} 110300 -16950 0 1 {name=p109593 lab=clkbuf_8_116_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 110260 -16950 0 0 {name=Xclkbuf_8_116_0_CLK }
C {devices/lab_pin.sym} 110200 -16850 0 0 {name=p109594 lab=_59651_/B }
C {devices/lab_pin.sym} 110200 -16810 0 0 {name=p109595 lab=_59600_/X }
C {devices/lab_pin.sym} 110200 -16770 0 0 {name=p109596 lab=_59721_/A }
C {devices/lab_pin.sym} 110320 -16810 0 1 {name=p109597 lab=_61704_/Y }
C {sky130_stdcells/nand3_4.sym} 110260 -16810 0 0 {name=X_61704_ }
C {devices/lab_pin.sym} 110180 -16690 0 0 {name=p109598 lab=_49423_/Y }
C {devices/lab_pin.sym} 110180 -16650 0 0 {name=p109599 lab=_49405_/X }
C {devices/lab_pin.sym} 110180 -16610 0 0 {name=p109600 lab=_49425_/X }
C {devices/lab_pin.sym} 110340 -16650 0 1 {name=p109601 lab=_49426_/Y }
C {sky130_stdcells/a21oi_4.sym} 110260 -16650 0 0 {name=X_49426_ }
C {devices/lab_pin.sym} 110220 -16510 0 0 {name=p109602 lab=clkbuf_9_55_0_CLK/X }
C {devices/lab_pin.sym} 110300 -16510 0 1 {name=p109603 lab=_86841_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 110260 -16510 0 0 {name=Xclkbuf_10_111_0_CLK }
C {devices/lab_pin.sym} 110220 -16390 0 0 {name=p109604 lab=_68106_/A }
C {devices/lab_pin.sym} 110300 -16390 0 1 {name=p109605 lab=_68260_/X }
C {sky130_stdcells/buf_2.sym} 110260 -16390 0 0 {name=X_68260_ }
C {devices/lab_pin.sym} 110220 -16270 0 0 {name=p109606 lab=_46638_/A }
C {devices/lab_pin.sym} 110300 -16270 0 1 {name=p109607 lab=_51761_/D }
C {sky130_stdcells/buf_2.sym} 110260 -16270 0 0 {name=X_46638_ }
C {devices/lab_pin.sym} 110180 -16180 0 0 {name=p109608 lab=_65453_/X }
C {devices/lab_pin.sym} 110180 -16140 0 0 {name=p109609 lab=_85598_/Q }
C {devices/lab_pin.sym} 110180 -16100 0 0 {name=p109610 lab=_65470_/X }
C {devices/lab_pin.sym} 110180 -16060 0 0 {name=p109611 lab=_65471_/X }
C {devices/lab_pin.sym} 110340 -16120 0 1 {name=p109612 lab=_65472_/X }
C {sky130_stdcells/a211o_4.sym} 110260 -16120 0 0 {name=X_65472_ }
C {devices/lab_pin.sym} 110200 -15980 0 0 {name=p109613 lab=_77454_/X }
C {devices/lab_pin.sym} 110200 -15940 0 0 {name=p109614 lab=_77458_/B }
C {devices/lab_pin.sym} 110320 -15960 0 1 {name=p109615 lab=_77458_/X }
C {sky130_stdcells/xor2_4.sym} 110260 -15960 0 0 {name=X_77458_ }
C {devices/lab_pin.sym} 110220 -15830 0 0 {name=p109616 lab=_62667_/X }
C {devices/lab_pin.sym} 110300 -15830 0 1 {name=p109617 lab=_62704_/C }
C {sky130_stdcells/buf_2.sym} 110260 -15830 0 0 {name=X_62684_ }
C {devices/lab_pin.sym} 110220 -15710 0 0 {name=p109618 lab=clkbuf_9_370_0_CLK/X }
C {devices/lab_pin.sym} 110300 -15710 0 1 {name=p109619 lab=_88012_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 110260 -15710 0 0 {name=Xclkbuf_10_741_0_CLK }
C {devices/lab_pin.sym} 110220 -15590 0 0 {name=p109620 lab=_66971_/A }
C {devices/lab_pin.sym} 110300 -15590 0 1 {name=p109621 lab=_67211_/X }
C {sky130_stdcells/buf_2.sym} 110260 -15590 0 0 {name=X_67211_ }
C {devices/lab_pin.sym} 110220 -15470 0 0 {name=p109622 lab=_64367_/A }
C {devices/lab_pin.sym} 110300 -15470 0 1 {name=p109623 lab=_64423_/X }
C {sky130_stdcells/buf_2.sym} 110260 -15470 0 0 {name=X_64423_ }
C {devices/lab_pin.sym} 110200 -15360 0 0 {name=p109624 lab=_76410_/A }
C {devices/lab_pin.sym} 110200 -15320 0 0 {name=p109625 lab=_81568_/Q }
C {devices/lab_pin.sym} 110320 -15340 0 1 {name=p109626 lab=_76409_/Y }
C {sky130_stdcells/nor2_4.sym} 110260 -15340 0 0 {name=X_76409_ }
C {devices/lab_pin.sym} 110180 -15230 0 0 {name=p109627 lab=_86402_/Q }
C {devices/lab_pin.sym} 110180 -15190 0 0 {name=p109628 lab=_49300_/X }
C {devices/lab_pin.sym} 110180 -15150 0 0 {name=p109629 lab=_49356_/Y }
C {devices/lab_pin.sym} 110340 -15190 0 1 {name=p109630 lab=_49357_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -15190 0 0 {name=X_49357_ }
C {devices/lab_pin.sym} 110180 -15070 0 0 {name=p109631 lab=_61633_/X }
C {devices/lab_pin.sym} 110180 -15030 0 0 {name=p109632 lab=_61576_/X }
C {devices/lab_pin.sym} 110180 -14990 0 0 {name=p109633 lab=_61634_/Y }
C {devices/lab_pin.sym} 110340 -15030 0 1 {name=p109634 lab=_61635_/Y }
C {sky130_stdcells/a21oi_4.sym} 110260 -15030 0 0 {name=X_61635_ }
C {devices/lab_pin.sym} 110180 -14920 0 0 {name=p109635 lab=_68188_/X }
C {devices/lab_pin.sym} 110180 -14880 0 0 {name=p109636 lab=_67175_/Y }
C {devices/lab_pin.sym} 110180 -14840 0 0 {name=p109637 lab=_68189_/X }
C {devices/lab_pin.sym} 110180 -14800 0 0 {name=p109638 lab=_68190_/Y }
C {devices/lab_pin.sym} 110340 -14860 0 1 {name=p109639 lab=_68191_/X }
C {sky130_stdcells/a211o_4.sym} 110260 -14860 0 0 {name=X_68191_ }
C {devices/lab_pin.sym} 110220 -14710 0 0 {name=p109640 lab=_51380_/B }
C {devices/lab_pin.sym} 110300 -14710 0 1 {name=p109641 lab=_54079_/B }
C {sky130_stdcells/buf_2.sym} 110260 -14710 0 0 {name=X_46569_ }
C {devices/lab_pin.sym} 110200 -14600 0 0 {name=p109642 lab=_77396_/A }
C {devices/lab_pin.sym} 110200 -14560 0 0 {name=p109643 lab=_77388_/Y }
C {devices/lab_pin.sym} 110320 -14580 0 1 {name=p109644 lab=_82189_/D }
C {sky130_stdcells/xnor2_4.sym} 110260 -14580 0 0 {name=X_77389_ }
C {devices/lab_pin.sym} 110220 -14450 0 0 {name=p109645 lab=clkbuf_8_116_0_CLK/X }
C {devices/lab_pin.sym} 110300 -14450 0 1 {name=p109646 lab=clkbuf_9_232_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 110260 -14450 0 0 {name=Xclkbuf_9_232_0_CLK }
C {devices/lab_pin.sym} 110200 -14340 0 0 {name=p109647 lab=_48275_/X }
C {devices/lab_pin.sym} 110200 -14300 0 0 {name=p109648 lab=_57609_/B }
C {devices/lab_pin.sym} 110320 -14320 0 1 {name=p109649 lab=_48308_/Y }
C {sky130_stdcells/nand2_4.sym} 110260 -14320 0 0 {name=X_48308_ }
C {devices/lab_pin.sym} 110200 -14200 0 0 {name=p109650 lab=_67095_/A }
C {devices/lab_pin.sym} 110200 -14160 0 0 {name=p109651 lab=_67142_/B }
C {devices/lab_pin.sym} 110320 -14180 0 1 {name=p109652 lab=_67142_/X }
C {sky130_stdcells/and2_4.sym} 110260 -14180 0 0 {name=X_67142_ }
C {devices/lab_pin.sym} 110200 -14060 0 0 {name=p109653 lab=_79128_/A }
C {devices/lab_pin.sym} 110200 -14020 0 0 {name=p109654 lab=_79128_/B }
C {devices/lab_pin.sym} 110320 -14040 0 1 {name=p109655 lab=_79128_/X }
C {sky130_stdcells/xor2_4.sym} 110260 -14040 0 0 {name=X_79128_ }
C {devices/lab_pin.sym} 110200 -13930 0 0 {name=p109656 lab=_64344_/X }
C {devices/lab_pin.sym} 110200 -13890 0 0 {name=p109657 lab=_64307_/B }
C {devices/lab_pin.sym} 110200 -13850 0 0 {name=p109658 lab=_84829_/Q }
C {devices/lab_pin.sym} 110320 -13890 0 1 {name=p109659 lab=_64354_/X }
C {sky130_stdcells/and3_4.sym} 110260 -13890 0 0 {name=X_64354_ }
C {devices/lab_pin.sym} 110180 -13770 0 0 {name=p109660 lab=_65029_/B }
C {devices/lab_pin.sym} 110180 -13730 0 0 {name=p109661 lab=_49285_/X }
C {devices/lab_pin.sym} 110180 -13690 0 0 {name=p109662 lab=_49287_/Y }
C {devices/lab_pin.sym} 110340 -13730 0 1 {name=p109663 lab=_49288_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -13730 0 0 {name=X_49288_ }
C {devices/lab_pin.sym} 110200 -13610 0 0 {name=p109664 lab=_61546_/A }
C {devices/lab_pin.sym} 110200 -13570 0 0 {name=p109665 lab=_61546_/B }
C {devices/lab_pin.sym} 110200 -13530 0 0 {name=p109666 lab=_79138_/B }
C {devices/lab_pin.sym} 110320 -13570 0 1 {name=p109667 lab=_61566_/Y }
C {sky130_stdcells/nor3_4.sym} 110260 -13570 0 0 {name=X_61566_ }
C {devices/lab_pin.sym} 110220 -13430 0 0 {name=p109668 lab=clkbuf_9_63_0_CLK/X }
C {devices/lab_pin.sym} 110300 -13430 0 1 {name=p109669 lab=_84430_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 110260 -13430 0 0 {name=Xclkbuf_10_126_0_CLK }
C {devices/lab_pin.sym} 110220 -13310 0 0 {name=p109670 lab=_63528_/A }
C {devices/lab_pin.sym} 110300 -13310 0 1 {name=p109671 lab=_63305_/X }
C {sky130_stdcells/buf_2.sym} 110260 -13310 0 0 {name=X_63305_ }
C {devices/lab_pin.sym} 110200 -13200 0 0 {name=p109672 lab=_48229_/A }
C {devices/lab_pin.sym} 110200 -13160 0 0 {name=p109673 lab=_53516_/B }
C {devices/lab_pin.sym} 110320 -13180 0 1 {name=p109674 lab=_48239_/Y }
C {sky130_stdcells/nand2_4.sym} 110260 -13180 0 0 {name=X_48239_ }
C {devices/lab_pin.sym} 110220 -13050 0 0 {name=p109675 lab=_60516_/Y }
C {devices/lab_pin.sym} 110300 -13050 0 1 {name=p109676 lab=_60517_/Y }
C {sky130_stdcells/inv_2.sym} 110260 -13050 0 0 {name=X_60517_ }
C {devices/lab_pin.sym} 110180 -12950 0 0 {name=p109677 lab=_67070_/X }
C {devices/lab_pin.sym} 110180 -12910 0 0 {name=p109678 lab=_67072_/X }
C {devices/lab_pin.sym} 110180 -12870 0 0 {name=p109679 lab=_67026_/X }
C {devices/lab_pin.sym} 110340 -12910 0 1 {name=p109680 lab=_67078_/A }
C {sky130_stdcells/a21o_4.sym} 110260 -12910 0 0 {name=X_67073_ }
C {devices/lab_pin.sym} 110180 -12790 0 0 {name=p109681 lab=_79058_/A }
C {devices/lab_pin.sym} 110180 -12750 0 0 {name=p109682 lab=_79058_/B }
C {devices/lab_pin.sym} 110180 -12710 0 0 {name=p109683 lab=_82749_/Q }
C {devices/lab_pin.sym} 110340 -12750 0 1 {name=p109684 lab=_79059_/X }
C {sky130_stdcells/a21o_4.sym} 110260 -12750 0 0 {name=X_79059_ }
C {devices/lab_pin.sym} 110220 -12610 0 0 {name=p109685 lab=_64285_/A }
C {devices/lab_pin.sym} 110300 -12610 0 1 {name=p109686 lab=_64295_/A }
C {sky130_stdcells/buf_2.sym} 110260 -12610 0 0 {name=X_64285_ }
C {devices/lab_pin.sym} 110180 -12510 0 0 {name=p109687 lab=_61495_/X }
C {devices/lab_pin.sym} 110180 -12470 0 0 {name=p109688 lab=_61455_/X }
C {devices/lab_pin.sym} 110180 -12430 0 0 {name=p109689 lab=_61496_/Y }
C {devices/lab_pin.sym} 110340 -12470 0 1 {name=p109690 lab=_61497_/Y }
C {sky130_stdcells/a21oi_4.sym} 110260 -12470 0 0 {name=X_61497_ }
C {devices/lab_pin.sym} 110220 -12330 0 0 {name=p109691 lab=clkbuf_9_378_0_CLK/X }
C {devices/lab_pin.sym} 110300 -12330 0 1 {name=p109692 lab=_87789_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 110260 -12330 0 0 {name=Xclkbuf_10_756_0_CLK }
C {devices/lab_pin.sym} 110200 -12220 0 0 {name=p109693 lab=_65878_/A }
C {devices/lab_pin.sym} 110200 -12180 0 0 {name=p109694 lab=_66024_/B }
C {devices/lab_pin.sym} 110320 -12200 0 1 {name=p109695 lab=_66024_/X }
C {sky130_stdcells/and2_4.sym} 110260 -12200 0 0 {name=X_66024_ }
C {devices/lab_pin.sym} 110180 -12090 0 0 {name=p109696 lab=_64670_/B }
C {devices/lab_pin.sym} 110180 -12050 0 0 {name=p109697 lab=_51233_/X }
C {devices/lab_pin.sym} 110180 -12010 0 0 {name=p109698 lab=_51249_/Y }
C {devices/lab_pin.sym} 110340 -12050 0 1 {name=p109699 lab=_51250_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -12050 0 0 {name=X_51250_ }
C {devices/lab_pin.sym} 110180 -11950 0 0 {name=p109700 lab=_58391_/A }
C {devices/lab_pin.sym} 110180 -11910 0 0 {name=p109701 lab=_63190_/X }
C {devices/lab_pin.sym} 110180 -11870 0 0 {name=p109702 lab=_63234_/X }
C {devices/lab_pin.sym} 110180 -11830 0 0 {name=p109703 lab=_58264_/Y }
C {devices/lab_pin.sym} 110180 -11790 0 0 {name=p109704 lab=_63235_/X }
C {devices/lab_pin.sym} 110340 -11870 0 1 {name=p109705 lab=_63236_/Y }
C {sky130_stdcells/o32ai_4.sym} 110260 -11870 0 0 {name=X_63236_ }
C {devices/lab_pin.sym} 110170 -11710 0 0 {name=p109706 lab=_81154_/CLK }
C {devices/lab_pin.sym} 110170 -11690 0 0 {name=p109707 lab=_82070_/D }
C {devices/lab_pin.sym} 110350 -11710 0 1 {name=p109708 lab=_77906_/A }
C {sky130_stdcells/dfxtp_4.sym} 110260 -11700 0 0 {name=X_82070_ }
C {devices/lab_pin.sym} 110220 -11570 0 0 {name=p109709 lab=_60529_/B }
C {devices/lab_pin.sym} 110300 -11570 0 1 {name=p109710 lab=_60572_/A }
C {sky130_stdcells/inv_2.sym} 110260 -11570 0 0 {name=X_60448_ }
C {devices/lab_pin.sym} 110220 -11450 0 0 {name=p109711 lab=clkbuf_9_247_0_CLK/A }
C {devices/lab_pin.sym} 110300 -11450 0 1 {name=p109712 lab=clkbuf_9_247_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 110260 -11450 0 0 {name=Xclkbuf_9_247_0_CLK }
C {devices/lab_pin.sym} 110200 -11340 0 0 {name=p109713 lab=_51242_/A }
C {devices/lab_pin.sym} 110200 -11300 0 0 {name=p109714 lab=_50714_/B }
C {devices/lab_pin.sym} 110320 -11320 0 1 {name=p109715 lab=_50201_/X }
C {sky130_stdcells/and2_4.sym} 110260 -11320 0 0 {name=X_50201_ }
C {devices/lab_pin.sym} 110170 -11190 0 0 {name=p109716 lab=_85315_/CLK }
C {devices/lab_pin.sym} 110170 -11170 0 0 {name=p109717 lab=_79836_/A }
C {devices/lab_pin.sym} 110350 -11190 0 1 {name=p109718 lab=_81021_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -11180 0 0 {name=X_81021_ }
C {devices/lab_pin.sym} 110200 -11080 0 0 {name=p109719 lab=_51177_/A }
C {devices/lab_pin.sym} 110200 -11040 0 0 {name=p109720 lab=_51192_/B }
C {devices/lab_pin.sym} 110200 -11000 0 0 {name=p109721 lab=_51192_/C }
C {devices/lab_pin.sym} 110200 -10960 0 0 {name=p109722 lab=_52872_/D }
C {devices/lab_pin.sym} 110320 -11020 0 1 {name=p109723 lab=_51181_/X }
C {sky130_stdcells/and4_4.sym} 110260 -11020 0 0 {name=X_51181_ }
C {devices/lab_pin.sym} 110200 -10900 0 0 {name=p109724 lab=_63144_/X }
C {devices/lab_pin.sym} 110200 -10860 0 0 {name=p109725 lab=_64379_/C }
C {devices/lab_pin.sym} 110200 -10820 0 0 {name=p109726 lab=_63146_/C }
C {devices/lab_pin.sym} 110200 -10780 0 0 {name=p109727 lab=_63135_/D }
C {devices/lab_pin.sym} 110320 -10840 0 1 {name=p109728 lab=_63167_/X }
C {sky130_stdcells/and4_4.sym} 110260 -10840 0 0 {name=X_63167_ }
C {devices/lab_pin.sym} 110220 -10690 0 0 {name=p109729 lab=_60378_/Y }
C {devices/lab_pin.sym} 110300 -10690 0 1 {name=p109730 lab=_60392_/C }
C {sky130_stdcells/inv_2.sym} 110260 -10690 0 0 {name=X_60379_ }
C {devices/lab_pin.sym} 110180 -10590 0 0 {name=p109731 lab=_50129_/Y }
C {devices/lab_pin.sym} 110180 -10550 0 0 {name=p109732 lab=_50117_/X }
C {devices/lab_pin.sym} 110180 -10510 0 0 {name=p109733 lab=_50131_/X }
C {devices/lab_pin.sym} 110340 -10550 0 1 {name=p109734 lab=_86258_/D }
C {sky130_stdcells/a21oi_4.sym} 110260 -10550 0 0 {name=X_50132_ }
C {devices/lab_pin.sym} 110180 -10450 0 0 {name=p109735 lab=_62104_/X }
C {devices/lab_pin.sym} 110180 -10410 0 0 {name=p109736 lab=_62109_/X }
C {devices/lab_pin.sym} 110180 -10370 0 0 {name=p109737 lab=_62116_/Y }
C {devices/lab_pin.sym} 110180 -10330 0 0 {name=p109738 lab=_84872_/Q }
C {devices/lab_pin.sym} 110180 -10290 0 0 {name=p109739 lab=_62117_/X }
C {devices/lab_pin.sym} 110340 -10370 0 1 {name=p109740 lab=_62118_/Y }
C {sky130_stdcells/o32ai_4.sym} 110260 -10370 0 0 {name=X_62118_ }
C {devices/lab_pin.sym} 110200 -10220 0 0 {name=p109741 lab=_68044_/A }
C {devices/lab_pin.sym} 110200 -10180 0 0 {name=p109742 lab=_67975_/B }
C {devices/lab_pin.sym} 110320 -10200 0 1 {name=p109743 lab=_67975_/X }
C {sky130_stdcells/and2_4.sym} 110260 -10200 0 0 {name=X_67975_ }
C {devices/lab_pin.sym} 110200 -10100 0 0 {name=p109744 lab=_63088_/A }
C {devices/lab_pin.sym} 110200 -10060 0 0 {name=p109745 lab=_64307_/C }
C {devices/lab_pin.sym} 110200 -10020 0 0 {name=p109746 lab=_63087_/X }
C {devices/lab_pin.sym} 110200 -9980 0 0 {name=p109747 lab=_63077_/D }
C {devices/lab_pin.sym} 110320 -10040 0 1 {name=p109748 lab=_63098_/X }
C {sky130_stdcells/and4_4.sym} 110260 -10040 0 0 {name=X_63098_ }
C {devices/lab_pin.sym} 110180 -9920 0 0 {name=p109749 lab=_44543_/A }
C {devices/lab_pin.sym} 110180 -9880 0 0 {name=p109750 lab=_69690_/X }
C {devices/lab_pin.sym} 110180 -9840 0 0 {name=p109751 lab=_69611_/X }
C {devices/lab_pin.sym} 110180 -9800 0 0 {name=p109752 lab=_69713_/X }
C {devices/lab_pin.sym} 110340 -9860 0 1 {name=p109753 lab=_69714_/X }
C {sky130_stdcells/a211o_4.sym} 110260 -9860 0 0 {name=X_69714_ }
C {devices/lab_pin.sym} 110220 -9710 0 0 {name=p109754 lab=_50063_/A }
C {devices/lab_pin.sym} 110300 -9710 0 1 {name=p109755 lab=_50064_/A }
C {sky130_stdcells/buf_2.sym} 110260 -9710 0 0 {name=X_50063_ }
C {devices/lab_pin.sym} 110180 -9610 0 0 {name=p109756 lab=_85349_/Q }
C {devices/lab_pin.sym} 110180 -9570 0 0 {name=p109757 lab=_54918_/X }
C {devices/lab_pin.sym} 110180 -9530 0 0 {name=p109758 lab=_54939_/Y }
C {devices/lab_pin.sym} 110340 -9570 0 1 {name=p109759 lab=_54940_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -9570 0 0 {name=X_54940_ }
C {devices/lab_pin.sym} 110220 -9430 0 0 {name=p109760 lab=_67046_/A }
C {devices/lab_pin.sym} 110300 -9430 0 1 {name=p109761 lab=_66926_/X }
C {sky130_stdcells/buf_2.sym} 110260 -9430 0 0 {name=X_66926_ }
C {devices/lab_pin.sym} 110180 -9350 0 0 {name=p109762 lab=_62038_/X }
C {devices/lab_pin.sym} 110180 -9310 0 0 {name=p109763 lab=_62040_/X }
C {devices/lab_pin.sym} 110180 -9270 0 0 {name=p109764 lab=_62047_/Y }
C {devices/lab_pin.sym} 110180 -9230 0 0 {name=p109765 lab=_84845_/Q }
C {devices/lab_pin.sym} 110180 -9190 0 0 {name=p109766 lab=_62048_/X }
C {devices/lab_pin.sym} 110340 -9270 0 1 {name=p109767 lab=_62049_/Y }
C {sky130_stdcells/o32ai_4.sym} 110260 -9270 0 0 {name=X_62049_ }
C {devices/lab_pin.sym} 110170 -9110 0 0 {name=p109768 lab=_85761_/CLK }
C {devices/lab_pin.sym} 110170 -9090 0 0 {name=p109769 lab=_52759_/Y }
C {devices/lab_pin.sym} 110350 -9110 0 1 {name=p109770 lab=_85760_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -9100 0 0 {name=X_85760_ }
C {devices/lab_pin.sym} 110170 -8970 0 0 {name=p109771 lab=_83783_/CLK }
C {devices/lab_pin.sym} 110170 -8950 0 0 {name=p109772 lab=_82780_/Q }
C {devices/lab_pin.sym} 110350 -8970 0 1 {name=p109773 lab=_82972_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -8960 0 0 {name=X_82972_ }
C {devices/lab_pin.sym} 110170 -8830 0 0 {name=p109774 lab=_84355_/CLK }
C {devices/lab_pin.sym} 110170 -8810 0 0 {name=p109775 lab=_59697_/Y }
C {devices/lab_pin.sym} 110350 -8830 0 1 {name=p109776 lab=_80605_/A }
C {sky130_stdcells/dfxtp_4.sym} 110260 -8820 0 0 {name=X_84711_ }
C {devices/lab_pin.sym} 110170 -8690 0 0 {name=p109777 lab=_82124_/CLK }
C {devices/lab_pin.sym} 110170 -8670 0 0 {name=p109778 lab=_81923_/D }
C {devices/lab_pin.sym} 110350 -8690 0 1 {name=p109779 lab=_81923_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -8680 0 0 {name=X_81923_ }
C {devices/lab_pin.sym} 110220 -8550 0 0 {name=p109780 lab=_69645_/A }
C {devices/lab_pin.sym} 110300 -8550 0 1 {name=p109781 lab=_69645_/X }
C {sky130_stdcells/buf_2.sym} 110260 -8550 0 0 {name=X_69645_ }
C {devices/lab_pin.sym} 110200 -8440 0 0 {name=p109782 lab=_54885_/A }
C {devices/lab_pin.sym} 110200 -8400 0 0 {name=p109783 lab=_54871_/B }
C {devices/lab_pin.sym} 110320 -8420 0 1 {name=p109784 lab=_54871_/Y }
C {sky130_stdcells/nand2_4.sym} 110260 -8420 0 0 {name=X_54871_ }
C {devices/lab_pin.sym} 110200 -8300 0 0 {name=p109785 lab=_66769_/A }
C {devices/lab_pin.sym} 110200 -8260 0 0 {name=p109786 lab=_66857_/B }
C {devices/lab_pin.sym} 110320 -8280 0 1 {name=p109787 lab=_66857_/X }
C {sky130_stdcells/and2_4.sym} 110260 -8280 0 0 {name=X_66857_ }
C {devices/lab_pin.sym} 110170 -8150 0 0 {name=p109788 lab=_85692_/CLK }
C {devices/lab_pin.sym} 110170 -8130 0 0 {name=p109789 lab=_53134_/Y }
C {devices/lab_pin.sym} 110350 -8150 0 1 {name=p109790 lab=_85691_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -8140 0 0 {name=X_85691_ }
C {devices/lab_pin.sym} 110200 -8020 0 0 {name=p109791 lab=_55546_/X }
C {devices/lab_pin.sym} 110200 -7980 0 0 {name=p109792 lab=_55550_/X }
C {devices/lab_pin.sym} 110320 -8000 0 1 {name=p109793 lab=_72654_/C }
C {sky130_stdcells/and2_4.sym} 110260 -8000 0 0 {name=X_56610_ }
C {devices/lab_pin.sym} 110170 -7870 0 0 {name=p109794 lab=_86796_/CLK }
C {devices/lab_pin.sym} 110170 -7850 0 0 {name=p109795 lab=_43419_/X }
C {devices/lab_pin.sym} 110350 -7870 0 1 {name=p109796 lab=_87430_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -7860 0 0 {name=X_87430_ }
C {devices/lab_pin.sym} 110180 -7750 0 0 {name=p109797 lab=_53820_/Y }
C {devices/lab_pin.sym} 110180 -7710 0 0 {name=p109798 lab=_53799_/X }
C {devices/lab_pin.sym} 110180 -7670 0 0 {name=p109799 lab=_53821_/Y }
C {devices/lab_pin.sym} 110340 -7710 0 1 {name=p109800 lab=_53822_/Y }
C {sky130_stdcells/a21boi_4.sym} 110260 -7710 0 0 {name=X_53822_ }
C {devices/lab_pin.sym} 110180 -7600 0 0 {name=p109801 lab=_65717_/X }
C {devices/lab_pin.sym} 110180 -7560 0 0 {name=p109802 lab=_85576_/Q }
C {devices/lab_pin.sym} 110180 -7520 0 0 {name=p109803 lab=_65718_/X }
C {devices/lab_pin.sym} 110180 -7480 0 0 {name=p109804 lab=_65807_/X }
C {devices/lab_pin.sym} 110340 -7540 0 1 {name=p109805 lab=_65808_/X }
C {sky130_stdcells/a211o_4.sym} 110260 -7540 0 0 {name=X_65808_ }
C {devices/lab_pin.sym} 110170 -7390 0 0 {name=p109806 lab=_84645_/CLK }
C {devices/lab_pin.sym} 110170 -7370 0 0 {name=p109807 lab=_60279_/Y }
C {devices/lab_pin.sym} 110350 -7390 0 1 {name=p109808 lab=_79806_/A }
C {sky130_stdcells/dfxtp_4.sym} 110260 -7380 0 0 {name=X_84642_ }
C {devices/lab_pin.sym} 110200 -7260 0 0 {name=p109809 lab=_57564_/X }
C {devices/lab_pin.sym} 110200 -7220 0 0 {name=p109810 lab=_57590_/B }
C {devices/lab_pin.sym} 110320 -7240 0 1 {name=p109811 lab=_57590_/Y }
C {sky130_stdcells/nand2_4.sym} 110260 -7240 0 0 {name=X_57590_ }
C {devices/lab_pin.sym} 110180 -7130 0 0 {name=p109812 lab=_69139_/X }
C {devices/lab_pin.sym} 110180 -7090 0 0 {name=p109813 lab=_69141_/X }
C {devices/lab_pin.sym} 110180 -7050 0 0 {name=p109814 lab=_69575_/X }
C {devices/lab_pin.sym} 110340 -7090 0 1 {name=p109815 lab=_69576_/Y }
C {sky130_stdcells/a21oi_4.sym} 110260 -7090 0 0 {name=X_69576_ }
C {devices/lab_pin.sym} 110170 -6950 0 0 {name=p109816 lab=_82531_/CLK }
C {devices/lab_pin.sym} 110170 -6930 0 0 {name=p109817 lab=_81886_/Q }
C {devices/lab_pin.sym} 110350 -6950 0 1 {name=p109818 lab=_77652_/A }
C {sky130_stdcells/dfxtp_4.sym} 110260 -6940 0 0 {name=X_81854_ }
C {devices/lab_pin.sym} 110180 -6830 0 0 {name=p109819 lab=_66783_/X }
C {devices/lab_pin.sym} 110180 -6790 0 0 {name=p109820 lab=_66786_/X }
C {devices/lab_pin.sym} 110180 -6750 0 0 {name=p109821 lab=_66787_/X }
C {devices/lab_pin.sym} 110340 -6790 0 1 {name=p109822 lab=_66791_/A }
C {sky130_stdcells/a21o_4.sym} 110260 -6790 0 0 {name=X_66788_ }
C {devices/lab_pin.sym} 110180 -6670 0 0 {name=p109823 lab=_56164_/X }
C {devices/lab_pin.sym} 110180 -6630 0 0 {name=p109824 lab=_56462_/X }
C {devices/lab_pin.sym} 110180 -6590 0 0 {name=p109825 lab=_56540_/Y }
C {devices/lab_pin.sym} 110340 -6630 0 1 {name=p109826 lab=_56541_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -6630 0 0 {name=X_56541_ }
C {devices/lab_pin.sym} 110170 -6490 0 0 {name=p109827 lab=_80931_/CLK }
C {devices/lab_pin.sym} 110170 -6470 0 0 {name=p109828 lab=_83949_/Q }
C {devices/lab_pin.sym} 110350 -6490 0 1 {name=p109829 lab=_75743_/B }
C {sky130_stdcells/dfxtp_4.sym} 110260 -6480 0 0 {name=X_80805_ }
C {devices/lab_pin.sym} 110220 -6350 0 0 {name=p109830 lab=_69007_/A }
C {devices/lab_pin.sym} 110300 -6350 0 1 {name=p109831 lab=_68527_/X }
C {sky130_stdcells/buf_2.sym} 110260 -6350 0 0 {name=X_68527_ }
C {devices/lab_pin.sym} 110170 -6230 0 0 {name=p109832 lab=_86796_/CLK }
C {devices/lab_pin.sym} 110170 -6210 0 0 {name=p109833 lab=_87361_/D }
C {devices/lab_pin.sym} 110350 -6230 0 1 {name=p109834 lab=_87361_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -6220 0 0 {name=X_87361_ }
C {devices/lab_pin.sym} 110180 -6110 0 0 {name=p109835 lab=_53751_/Y }
C {devices/lab_pin.sym} 110180 -6070 0 0 {name=p109836 lab=_53747_/X }
C {devices/lab_pin.sym} 110180 -6030 0 0 {name=p109837 lab=_53752_/X }
C {devices/lab_pin.sym} 110340 -6070 0 1 {name=p109838 lab=_53753_/Y }
C {sky130_stdcells/a21oi_4.sym} 110260 -6070 0 0 {name=X_53753_ }
C {devices/lab_pin.sym} 110200 -5940 0 0 {name=p109839 lab=_65753_/A }
C {devices/lab_pin.sym} 110200 -5900 0 0 {name=p109840 lab=_86509_/Q }
C {devices/lab_pin.sym} 110320 -5920 0 1 {name=p109841 lab=_65739_/X }
C {sky130_stdcells/and2_4.sym} 110260 -5920 0 0 {name=X_65739_ }
C {devices/lab_pin.sym} 110170 -5790 0 0 {name=p109842 lab=_84583_/CLK }
C {devices/lab_pin.sym} 110170 -5770 0 0 {name=p109843 lab=_84573_/D }
C {devices/lab_pin.sym} 110350 -5790 0 1 {name=p109844 lab=_84573_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -5780 0 0 {name=X_84573_ }
C {devices/lab_pin.sym} 110220 -5650 0 0 {name=p109845 lab=_50819_/X }
C {devices/lab_pin.sym} 110300 -5650 0 1 {name=p109846 lab=_50965_/X }
C {sky130_stdcells/buf_2.sym} 110260 -5650 0 0 {name=X_50965_ }
C {devices/lab_pin.sym} 110170 -5530 0 0 {name=p109847 lab=_81475_/CLK }
C {devices/lab_pin.sym} 110170 -5510 0 0 {name=p109848 lab=_76142_/X }
C {devices/lab_pin.sym} 110350 -5530 0 1 {name=p109849 lab=_48448_/A }
C {sky130_stdcells/dfxtp_4.sym} 110260 -5520 0 0 {name=X_81785_ }
C {devices/lab_pin.sym} 110170 -5390 0 0 {name=p109850 lab=_86312_/CLK }
C {devices/lab_pin.sym} 110170 -5370 0 0 {name=p109851 lab=_86312_/D }
C {devices/lab_pin.sym} 110350 -5390 0 1 {name=p109852 lab=_58058_/B }
C {sky130_stdcells/dfxtp_4.sym} 110260 -5380 0 0 {name=X_86312_ }
C {devices/lab_pin.sym} 110200 -5280 0 0 {name=p109853 lab=_52704_/A }
C {devices/lab_pin.sym} 110200 -5240 0 0 {name=p109854 lab=_52694_/B }
C {devices/lab_pin.sym} 110200 -5200 0 0 {name=p109855 lab=_52694_/C }
C {devices/lab_pin.sym} 110200 -5160 0 0 {name=p109856 lab=_52704_/D }
C {devices/lab_pin.sym} 110320 -5220 0 1 {name=p109857 lab=_52704_/X }
C {sky130_stdcells/and4_4.sym} 110260 -5220 0 0 {name=X_52704_ }
C {devices/lab_pin.sym} 110220 -5070 0 0 {name=p109858 lab=_59033_/A }
C {devices/lab_pin.sym} 110300 -5070 0 1 {name=p109859 lab=_59260_/X }
C {sky130_stdcells/buf_2.sym} 110260 -5070 0 0 {name=X_59260_ }
C {devices/lab_pin.sym} 110170 -4950 0 0 {name=p109860 lab=_83526_/CLK }
C {devices/lab_pin.sym} 110170 -4930 0 0 {name=p109861 lab=_71364_/X }
C {devices/lab_pin.sym} 110350 -4950 0 1 {name=p109862 lab=_83524_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -4940 0 0 {name=X_83524_ }
C {devices/lab_pin.sym} 110200 -4830 0 0 {name=p109863 lab=_56545_/A }
C {devices/lab_pin.sym} 110200 -4790 0 0 {name=p109864 lab=_56472_/B }
C {devices/lab_pin.sym} 110200 -4750 0 0 {name=p109865 lab=_85183_/Q }
C {devices/lab_pin.sym} 110320 -4790 0 1 {name=p109866 lab=_56472_/Y }
C {sky130_stdcells/nand3_4.sym} 110260 -4790 0 0 {name=X_56472_ }
C {devices/lab_pin.sym} 110180 -4670 0 0 {name=p109867 lab=_68454_/X }
C {devices/lab_pin.sym} 110180 -4630 0 0 {name=p109868 lab=_68457_/X }
C {devices/lab_pin.sym} 110180 -4590 0 0 {name=p109869 lab=_68331_/X }
C {devices/lab_pin.sym} 110340 -4630 0 1 {name=p109870 lab=_68458_/Y }
C {sky130_stdcells/a21oi_4.sym} 110260 -4630 0 0 {name=X_68458_ }
C {devices/lab_pin.sym} 110170 -4490 0 0 {name=p109871 lab=_81104_/CLK }
C {devices/lab_pin.sym} 110170 -4470 0 0 {name=p109872 lab=_75922_/X }
C {devices/lab_pin.sym} 110350 -4490 0 1 {name=p109873 lab=_80704_/D }
C {sky130_stdcells/dfxtp_4.sym} 110260 -4480 0 0 {name=X_80736_ }
C {devices/lab_pin.sym} 110170 -4350 0 0 {name=p109874 lab=_88062_/CLK }
C {devices/lab_pin.sym} 110170 -4330 0 0 {name=p109875 lab=_43731_/X }
C {devices/lab_pin.sym} 110350 -4350 0 1 {name=p109876 lab=_87292_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -4340 0 0 {name=X_87292_ }
C {devices/lab_pin.sym} 110180 -4230 0 0 {name=p109877 lab=_85588_/Q }
C {devices/lab_pin.sym} 110180 -4190 0 0 {name=p109878 lab=_53660_/X }
C {devices/lab_pin.sym} 110180 -4150 0 0 {name=p109879 lab=_53683_/Y }
C {devices/lab_pin.sym} 110340 -4190 0 1 {name=p109880 lab=_53684_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -4190 0 0 {name=X_53684_ }
C {devices/lab_pin.sym} 110220 -4050 0 0 {name=p109881 lab=clkbuf_9_354_0_CLK/X }
C {devices/lab_pin.sym} 110300 -4050 0 1 {name=p109882 lab=_88267_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 110260 -4050 0 0 {name=Xclkbuf_10_709_0_CLK }
C {devices/lab_pin.sym} 110220 -3930 0 0 {name=p109883 lab=_51033_/A }
C {devices/lab_pin.sym} 110300 -3930 0 1 {name=p109884 lab=_50952_/A }
C {sky130_stdcells/buf_2.sym} 110260 -3930 0 0 {name=X_50896_ }
C {devices/lab_pin.sym} 110200 -3820 0 0 {name=p109885 lab=_58210_/X }
C {devices/lab_pin.sym} 110200 -3780 0 0 {name=p109886 lab=_58238_/B }
C {devices/lab_pin.sym} 110320 -3800 0 1 {name=p109887 lab=_58211_/Y }
C {sky130_stdcells/nor2_4.sym} 110260 -3800 0 0 {name=X_58211_ }
C {devices/lab_pin.sym} 110200 -3680 0 0 {name=p109888 lab=_55422_/Y }
C {devices/lab_pin.sym} 110200 -3640 0 0 {name=p109889 lab=_55423_/B }
C {devices/lab_pin.sym} 110320 -3660 0 1 {name=p109890 lab=_55423_/Y }
C {sky130_stdcells/nand2_4.sym} 110260 -3660 0 0 {name=X_55423_ }
C {devices/lab_pin.sym} 110180 -3560 0 0 {name=p109891 lab=_87472_/Q }
C {devices/lab_pin.sym} 110180 -3520 0 0 {name=p109892 lab=_67358_/X }
C {devices/lab_pin.sym} 110180 -3480 0 0 {name=p109893 lab=_67360_/X }
C {devices/lab_pin.sym} 110180 -3440 0 0 {name=p109894 lab=_67408_/X }
C {devices/lab_pin.sym} 110340 -3500 0 1 {name=p109895 lab=_67409_/X }
C {sky130_stdcells/a211o_4.sym} 110260 -3500 0 0 {name=X_67409_ }
C {devices/lab_pin.sym} 110170 -3350 0 0 {name=p109896 lab=_83594_/CLK }
C {devices/lab_pin.sym} 110170 -3330 0 0 {name=p109897 lab=_50206_/Y }
C {devices/lab_pin.sym} 110350 -3350 0 1 {name=p109898 lab=_86243_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -3340 0 0 {name=X_86243_ }
C {devices/lab_pin.sym} 110200 -3240 0 0 {name=p109899 lab=_52643_/A }
C {devices/lab_pin.sym} 110200 -3200 0 0 {name=p109900 lab=_52654_/B }
C {devices/lab_pin.sym} 110200 -3160 0 0 {name=p109901 lab=_52643_/C }
C {devices/lab_pin.sym} 110200 -3120 0 0 {name=p109902 lab=_46716_/X }
C {devices/lab_pin.sym} 110320 -3180 0 1 {name=p109903 lab=_52635_/X }
C {sky130_stdcells/and4_4.sym} 110260 -3180 0 0 {name=X_52635_ }
C {devices/lab_pin.sym} 110180 -3060 0 0 {name=p109904 lab=_59182_/Y }
C {devices/lab_pin.sym} 110180 -3020 0 0 {name=p109905 lab=_59145_/X }
C {devices/lab_pin.sym} 110180 -2980 0 0 {name=p109906 lab=_59187_/X }
C {devices/lab_pin.sym} 110180 -2940 0 0 {name=p109907 lab=_59190_/X }
C {devices/lab_pin.sym} 110340 -3000 0 1 {name=p109908 lab=_84762_/D }
C {sky130_stdcells/a22oi_4.sym} 110260 -3000 0 0 {name=X_59191_ }
C {devices/lab_pin.sym} 110170 -2850 0 0 {name=p109909 lab=_83457_/CLK }
C {devices/lab_pin.sym} 110170 -2830 0 0 {name=p109910 lab=_71564_/X }
C {devices/lab_pin.sym} 110350 -2850 0 1 {name=p109911 lab=_83455_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -2840 0 0 {name=X_83455_ }
C {devices/lab_pin.sym} 110170 -2710 0 0 {name=p109912 lab=_84531_/CLK }
C {devices/lab_pin.sym} 110170 -2690 0 0 {name=p109913 lab=_80667_/D }
C {devices/lab_pin.sym} 110350 -2710 0 1 {name=p109914 lab=_80667_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -2700 0 0 {name=X_80667_ }
C {devices/lab_pin.sym} 110220 -2570 0 0 {name=p109915 lab=_68389_/A }
C {devices/lab_pin.sym} 110300 -2570 0 1 {name=p109916 lab=_69678_/A }
C {sky130_stdcells/buf_2.sym} 110260 -2570 0 0 {name=X_68389_ }
C {sky130_stdcells/decap_3.sym} 110260 -2420 0 0 {name=XPHY_403 }
C {sky130_stdcells/decap_3.sym} 110260 -2240 0 0 {name=XPHY_414 }
C {devices/lab_pin.sym} 110200 -2110 0 0 {name=p109917 lab=_71162_/B }
C {devices/lab_pin.sym} 110200 -2070 0 0 {name=p109918 lab=_70358_/X }
C {devices/lab_pin.sym} 110200 -2030 0 0 {name=p109919 lab=_71287_/C }
C {devices/lab_pin.sym} 110320 -2070 0 1 {name=p109920 lab=_70854_/A }
C {sky130_stdcells/nand3_4.sym} 110260 -2070 0 0 {name=X_70420_ }
C {devices/lab_pin.sym} 110180 -1950 0 0 {name=p109921 lab=_58140_/X }
C {devices/lab_pin.sym} 110180 -1910 0 0 {name=p109922 lab=_85986_/Q }
C {devices/lab_pin.sym} 110180 -1870 0 0 {name=p109923 lab=_58141_/X }
C {devices/lab_pin.sym} 110340 -1910 0 1 {name=p109924 lab=_58142_/Y }
C {sky130_stdcells/o21ai_4.sym} 110260 -1910 0 0 {name=X_58142_ }
C {devices/lab_pin.sym} 110170 -1770 0 0 {name=p109925 lab=_82443_/CLK }
C {devices/lab_pin.sym} 110170 -1750 0 0 {name=p109926 lab=_82438_/Q }
C {devices/lab_pin.sym} 110350 -1770 0 1 {name=p109927 lab=_78358_/A }
C {sky130_stdcells/dfxtp_4.sym} 110260 -1760 0 0 {name=X_82406_ }
C {sky130_stdcells/decap_3.sym} 110260 -1600 0 0 {name=XPHY_425 }
C {devices/lab_pin.sym} 110220 -1450 0 0 {name=p109928 lab=_55445_/D }
C {devices/lab_pin.sym} 110300 -1450 0 1 {name=p109929 lab=_55354_/Y }
C {sky130_stdcells/inv_2.sym} 110260 -1450 0 0 {name=X_55354_ }
C {devices/lab_pin.sym} 110170 -1330 0 0 {name=p109930 lab=_83307_/CLK }
C {devices/lab_pin.sym} 110170 -1310 0 0 {name=p109931 lab=_50581_/Y }
C {devices/lab_pin.sym} 110350 -1330 0 1 {name=p109932 lab=_86174_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -1320 0 0 {name=X_86174_ }
C {sky130_stdcells/decap_3.sym} 110260 -1160 0 0 {name=XPHY_436 }
C {devices/lab_pin.sym} 110180 -1030 0 0 {name=p109933 lab=_40577_/X }
C {devices/lab_pin.sym} 110180 -990 0 0 {name=p109934 lab=_82879_/Q }
C {devices/lab_pin.sym} 110180 -950 0 0 {name=p109935 lab=_40579_/X }
C {devices/lab_pin.sym} 110340 -990 0 1 {name=p109936 lab=_40581_/A }
C {sky130_stdcells/o21a_4.sym} 110260 -990 0 0 {name=X_40580_ }
C {devices/lab_pin.sym} 110180 -870 0 0 {name=p109937 lab=_52564_/Y }
C {devices/lab_pin.sym} 110180 -830 0 0 {name=p109938 lab=_51951_/X }
C {devices/lab_pin.sym} 110180 -790 0 0 {name=p109939 lab=_52565_/Y }
C {devices/lab_pin.sym} 110340 -830 0 1 {name=p109940 lab=_85796_/D }
C {sky130_stdcells/a21boi_4.sym} 110260 -830 0 0 {name=X_52566_ }
C {devices/lab_pin.sym} 110170 -690 0 0 {name=p109941 lab=_84945_/CLK }
C {devices/lab_pin.sym} 110170 -670 0 0 {name=p109942 lab=_83386_/D }
C {devices/lab_pin.sym} 110350 -690 0 1 {name=p109943 lab=_83386_/Q }
C {sky130_stdcells/dfxtp_4.sym} 110260 -680 0 0 {name=X_83386_ }
C {sky130_stdcells/decap_3.sym} 111180 -42120 0 0 {name=XPHY_447 }
C {devices/lab_pin.sym} 111120 -41990 0 0 {name=p109944 lab=_80598_/A }
C {devices/lab_pin.sym} 111120 -41950 0 0 {name=p109945 lab=_80598_/B }
C {devices/lab_pin.sym} 111120 -41910 0 0 {name=p109946 lab=_80598_/C }
C {devices/lab_pin.sym} 111240 -41950 0 1 {name=p109947 lab=_80598_/X }
C {sky130_stdcells/and3_4.sym} 111180 -41950 0 0 {name=X_80598_ }
C {sky130_stdcells/decap_3.sym} 111180 -41780 0 0 {name=XPHY_458 }
C {devices/lab_pin.sym} 111120 -41640 0 0 {name=p109948 lab=_54314_/A }
C {devices/lab_pin.sym} 111120 -41600 0 0 {name=p109949 lab=_46685_/A }
C {devices/lab_pin.sym} 111240 -41620 0 1 {name=p109950 lab=_54305_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -41620 0 0 {name=X_54305_ }
C {sky130_stdcells/decap_3.sym} 111180 -41460 0 0 {name=XPHY_469 }
C {devices/lab_pin.sym} 111090 -41310 0 0 {name=p109951 lab=_85128_/CLK }
C {devices/lab_pin.sym} 111090 -41290 0 0 {name=p109952 lab=_85125_/D }
C {devices/lab_pin.sym} 111270 -41310 0 1 {name=p109953 lab=_55207_/A }
C {sky130_stdcells/dfxtp_4.sym} 111180 -41300 0 0 {name=X_85125_ }
C {devices/lab_pin.sym} 111100 -41190 0 0 {name=p109954 lab=_51515_/Y }
C {devices/lab_pin.sym} 111100 -41150 0 0 {name=p109955 lab=_51503_/X }
C {devices/lab_pin.sym} 111100 -41110 0 0 {name=p109956 lab=_51516_/X }
C {devices/lab_pin.sym} 111260 -41150 0 1 {name=p109957 lab=_85996_/D }
C {sky130_stdcells/a21oi_4.sym} 111180 -41150 0 0 {name=X_51517_ }
C {devices/lab_pin.sym} 111100 -41030 0 0 {name=p109958 lab=_58030_/X }
C {devices/lab_pin.sym} 111100 -40990 0 0 {name=p109959 lab=_85479_/Q }
C {devices/lab_pin.sym} 111100 -40950 0 0 {name=p109960 lab=_58062_/X }
C {devices/lab_pin.sym} 111260 -40990 0 1 {name=p109961 lab=_58073_/X }
C {sky130_stdcells/o21a_4.sym} 111180 -40990 0 0 {name=X_58073_ }
C {devices/lab_pin.sym} 111100 -40870 0 0 {name=p109962 lab=_70209_/A }
C {devices/lab_pin.sym} 111100 -40830 0 0 {name=p109963 lab=_74727_/A }
C {devices/lab_pin.sym} 111100 -40790 0 0 {name=p109964 lab=_70350_/X }
C {devices/lab_pin.sym} 111260 -40830 0 1 {name=p109965 lab=_70351_/X }
C {sky130_stdcells/a21o_4.sym} 111180 -40830 0 0 {name=X_70351_ }
C {devices/lab_pin.sym} 111090 -40690 0 0 {name=p109966 lab=_86758_/CLK }
C {devices/lab_pin.sym} 111090 -40670 0 0 {name=p109967 lab=_77228_/X }
C {devices/lab_pin.sym} 111270 -40690 0 1 {name=p109968 lab=_82337_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -40680 0 0 {name=X_82337_ }
C {devices/lab_pin.sym} 111120 -40570 0 0 {name=p109969 lab=_55285_/A }
C {devices/lab_pin.sym} 111120 -40530 0 0 {name=p109970 lab=_83318_/Q }
C {devices/lab_pin.sym} 111120 -40490 0 0 {name=p109971 lab=_55274_/X }
C {devices/lab_pin.sym} 111240 -40530 0 1 {name=p109972 lab=_55674_/B }
C {sky130_stdcells/nand3_4.sym} 111180 -40530 0 0 {name=X_55285_ }
C {devices/lab_pin.sym} 111140 -40390 0 0 {name=p109973 lab=_50946_/A }
C {devices/lab_pin.sym} 111220 -40390 0 1 {name=p109974 lab=_52498_/C }
C {sky130_stdcells/buf_2.sym} 111180 -40390 0 0 {name=X_52497_ }
C {devices/lab_pin.sym} 111120 -40300 0 0 {name=p109975 lab=_57023_/X }
C {devices/lab_pin.sym} 111120 -40260 0 0 {name=p109976 lab=_56729_/X }
C {devices/lab_pin.sym} 111120 -40220 0 0 {name=p109977 lab=_56810_/X }
C {devices/lab_pin.sym} 111120 -40180 0 0 {name=p109978 lab=_57024_/D }
C {devices/lab_pin.sym} 111240 -40240 0 1 {name=p109979 lab=_57024_/Y }
C {sky130_stdcells/nand4_4.sym} 111180 -40240 0 0 {name=X_57024_ }
C {devices/lab_pin.sym} 111140 -40090 0 0 {name=p109980 lab=_54316_/A }
C {devices/lab_pin.sym} 111220 -40090 0 1 {name=p109981 lab=_54255_/A }
C {sky130_stdcells/buf_2.sym} 111180 -40090 0 0 {name=X_54236_ }
C {devices/lab_pin.sym} 111100 -40000 0 0 {name=p109982 lab=_41433_/X }
C {devices/lab_pin.sym} 111100 -39960 0 0 {name=p109983 lab=_42248_/X }
C {devices/lab_pin.sym} 111100 -39920 0 0 {name=p109984 lab=_87960_/Q }
C {devices/lab_pin.sym} 111100 -39880 0 0 {name=p109985 lab=_42249_/X }
C {devices/lab_pin.sym} 111260 -39940 0 1 {name=p109986 lab=_87960_/D }
C {sky130_stdcells/a2bb2o_4.sym} 111180 -39940 0 0 {name=X_42250_ }
C {devices/lab_pin.sym} 111120 -39800 0 0 {name=p109987 lab=_73239_/A }
C {devices/lab_pin.sym} 111120 -39760 0 0 {name=p109988 lab=_73070_/B }
C {devices/lab_pin.sym} 111240 -39780 0 1 {name=p109989 lab=_73070_/X }
C {sky130_stdcells/and2_4.sym} 111180 -39780 0 0 {name=X_73070_ }
C {devices/lab_pin.sym} 111090 -39650 0 0 {name=p109990 lab=_85152_/CLK }
C {devices/lab_pin.sym} 111090 -39630 0 0 {name=p109991 lab=_57239_/X }
C {devices/lab_pin.sym} 111270 -39650 0 1 {name=p109992 lab=_45413_/A }
C {sky130_stdcells/dfxtp_4.sym} 111180 -39640 0 0 {name=X_85056_ }
C {devices/lab_pin.sym} 111140 -39510 0 0 {name=p109993 lab=_51557_/A }
C {devices/lab_pin.sym} 111220 -39510 0 1 {name=p109994 lab=_51448_/X }
C {sky130_stdcells/buf_2.sym} 111180 -39510 0 0 {name=X_51448_ }
C {devices/lab_pin.sym} 111140 -39390 0 0 {name=p109995 lab=_70246_/A }
C {devices/lab_pin.sym} 111220 -39390 0 1 {name=p109996 lab=_70292_/A }
C {sky130_stdcells/buf_2.sym} 111180 -39390 0 0 {name=X_70282_ }
C {devices/lab_pin.sym} 111090 -39270 0 0 {name=p109997 lab=_83515_/CLK }
C {devices/lab_pin.sym} 111090 -39250 0 0 {name=p109998 lab=_82268_/D }
C {devices/lab_pin.sym} 111270 -39270 0 1 {name=p109999 lab=_82268_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -39260 0 0 {name=X_82268_ }
C {devices/lab_pin.sym} 111120 -39140 0 0 {name=p110000 lab=_81712_/Q }
C {devices/lab_pin.sym} 111120 -39100 0 0 {name=p110001 lab=_41197_/B }
C {devices/lab_pin.sym} 111240 -39120 0 1 {name=p110002 lab=_41201_/X }
C {sky130_stdcells/or2_4.sym} 111180 -39120 0 0 {name=X_41201_ }
C {devices/lab_pin.sym} 111100 -39010 0 0 {name=p110003 lab=_72019_/Y }
C {devices/lab_pin.sym} 111100 -38970 0 0 {name=p110004 lab=_72009_/X }
C {devices/lab_pin.sym} 111100 -38930 0 0 {name=p110005 lab=_72020_/Y }
C {devices/lab_pin.sym} 111260 -38970 0 1 {name=p110006 lab=_72021_/Y }
C {sky130_stdcells/a21boi_4.sym} 111180 -38970 0 0 {name=X_72021_ }
C {devices/lab_pin.sym} 111090 -38830 0 0 {name=p110007 lab=_81746_/CLK }
C {devices/lab_pin.sym} 111090 -38810 0 0 {name=p110008 lab=_68227_/X }
C {devices/lab_pin.sym} 111270 -38830 0 1 {name=p110009 lab=_84007_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -38820 0 0 {name=X_84007_ }
C {devices/lab_pin.sym} 111090 -38690 0 0 {name=p110010 lab=_85317_/CLK }
C {devices/lab_pin.sym} 111090 -38670 0 0 {name=p110011 lab=_81027_/Q }
C {devices/lab_pin.sym} 111270 -38690 0 1 {name=p110012 lab=_81219_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -38680 0 0 {name=X_81219_ }
C {devices/lab_pin.sym} 111100 -38580 0 0 {name=p110013 lab=_41250_/X }
C {devices/lab_pin.sym} 111100 -38540 0 0 {name=p110014 lab=_42161_/X }
C {devices/lab_pin.sym} 111100 -38500 0 0 {name=p110015 lab=_87994_/Q }
C {devices/lab_pin.sym} 111100 -38460 0 0 {name=p110016 lab=_42162_/X }
C {devices/lab_pin.sym} 111260 -38520 0 1 {name=p110017 lab=_42181_/X }
C {sky130_stdcells/a2bb2o_4.sym} 111180 -38520 0 0 {name=X_42181_ }
C {devices/lab_pin.sym} 111140 -38370 0 0 {name=p110018 lab=_54249_/A }
C {devices/lab_pin.sym} 111220 -38370 0 1 {name=p110019 lab=_54167_/X }
C {sky130_stdcells/buf_2.sym} 111180 -38370 0 0 {name=X_54167_ }
C {devices/lab_pin.sym} 111100 -38270 0 0 {name=p110020 lab=_65337_/B }
C {devices/lab_pin.sym} 111100 -38230 0 0 {name=p110021 lab=_51362_/X }
C {devices/lab_pin.sym} 111100 -38190 0 0 {name=p110022 lab=_51378_/Y }
C {devices/lab_pin.sym} 111260 -38230 0 1 {name=p110023 lab=_51379_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -38230 0 0 {name=X_51379_ }
C {devices/lab_pin.sym} 111090 -38090 0 0 {name=p110024 lab=_82390_/CLK }
C {devices/lab_pin.sym} 111090 -38070 0 0 {name=p110025 lab=_82199_/D }
C {devices/lab_pin.sym} 111270 -38090 0 1 {name=p110026 lab=_82391_/D }
C {sky130_stdcells/dfxtp_4.sym} 111180 -38080 0 0 {name=X_82199_ }
C {devices/lab_pin.sym} 111120 -37960 0 0 {name=p110027 lab=_81725_/Q }
C {devices/lab_pin.sym} 111120 -37920 0 0 {name=p110028 lab=_41102_/B }
C {devices/lab_pin.sym} 111240 -37940 0 1 {name=p110029 lab=_41132_/X }
C {sky130_stdcells/or2_4.sym} 111180 -37940 0 0 {name=X_41132_ }
C {devices/lab_pin.sym} 111120 -37840 0 0 {name=p110030 lab=_53133_/A }
C {devices/lab_pin.sym} 111120 -37800 0 0 {name=p110031 lab=_53113_/B }
C {devices/lab_pin.sym} 111120 -37760 0 0 {name=p110032 lab=_53133_/C }
C {devices/lab_pin.sym} 111120 -37720 0 0 {name=p110033 lab=_53118_/D }
C {devices/lab_pin.sym} 111240 -37780 0 1 {name=p110034 lab=_53118_/X }
C {sky130_stdcells/and4_4.sym} 111180 -37780 0 0 {name=X_53118_ }
C {devices/lab_pin.sym} 111100 -37650 0 0 {name=p110035 lab=_85504_/Q }
C {devices/lab_pin.sym} 111100 -37610 0 0 {name=p110036 lab=_53431_/X }
C {devices/lab_pin.sym} 111100 -37570 0 0 {name=p110037 lab=_54097_/Y }
C {devices/lab_pin.sym} 111260 -37610 0 1 {name=p110038 lab=_54098_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -37610 0 0 {name=X_54098_ }
C {devices/lab_pin.sym} 111140 -37470 0 0 {name=p110039 lab=_62948_/C }
C {devices/lab_pin.sym} 111220 -37470 0 1 {name=p110040 lab=_58976_/A }
C {sky130_stdcells/inv_2.sym} 111180 -37470 0 0 {name=X_58975_ }
C {devices/lab_pin.sym} 111140 -37350 0 0 {name=p110041 lab=_58796_/A }
C {devices/lab_pin.sym} 111220 -37350 0 1 {name=p110042 lab=_57926_/X }
C {sky130_stdcells/buf_2.sym} 111180 -37350 0 0 {name=X_57926_ }
C {devices/lab_pin.sym} 111100 -37250 0 0 {name=p110043 lab=_41061_/X }
C {devices/lab_pin.sym} 111100 -37210 0 0 {name=p110044 lab=_82282_/Q }
C {devices/lab_pin.sym} 111100 -37170 0 0 {name=p110045 lab=_41062_/X }
C {devices/lab_pin.sym} 111260 -37210 0 1 {name=p110046 lab=_41064_/A }
C {sky130_stdcells/o21ai_4.sym} 111180 -37210 0 0 {name=X_41063_ }
C {devices/lab_pin.sym} 111140 -37070 0 0 {name=p110047 lab=_44008_/A }
C {devices/lab_pin.sym} 111220 -37070 0 1 {name=p110048 lab=_45941_/A }
C {sky130_stdcells/inv_2.sym} 111180 -37070 0 0 {name=X_45940_ }
C {devices/lab_pin.sym} 111100 -36970 0 0 {name=p110049 lab=_53047_/Y }
C {devices/lab_pin.sym} 111100 -36930 0 0 {name=p110050 lab=_53028_/X }
C {devices/lab_pin.sym} 111100 -36890 0 0 {name=p110051 lab=_53048_/X }
C {devices/lab_pin.sym} 111260 -36930 0 1 {name=p110052 lab=_53049_/Y }
C {sky130_stdcells/a21oi_4.sym} 111180 -36930 0 0 {name=X_53049_ }
C {devices/lab_pin.sym} 111100 -36820 0 0 {name=p110053 lab=_76746_/Y }
C {devices/lab_pin.sym} 111100 -36780 0 0 {name=p110054 lab=_76747_/Y }
C {devices/lab_pin.sym} 111100 -36740 0 0 {name=p110055 lab=_76734_/A }
C {devices/lab_pin.sym} 111100 -36700 0 0 {name=p110056 lab=_76749_/Y }
C {devices/lab_pin.sym} 111260 -36760 0 1 {name=p110057 lab=_76760_/X }
C {sky130_stdcells/a2bb2o_4.sym} 111180 -36760 0 0 {name=X_76760_ }
C {devices/lab_pin.sym} 111090 -36610 0 0 {name=p110058 lab=_85957_/CLK }
C {devices/lab_pin.sym} 111090 -36590 0 0 {name=p110059 lab=_85958_/D }
C {devices/lab_pin.sym} 111270 -36610 0 1 {name=p110060 lab=_85958_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -36600 0 0 {name=X_85958_ }
C {devices/lab_pin.sym} 111140 -36470 0 0 {name=p110061 lab=_72757_/A }
C {devices/lab_pin.sym} 111220 -36470 0 1 {name=p110062 lab=_73972_/X }
C {sky130_stdcells/buf_2.sym} 111180 -36470 0 0 {name=X_73972_ }
C {devices/lab_pin.sym} 111120 -36360 0 0 {name=p110063 lab=_75711_/A }
C {devices/lab_pin.sym} 111120 -36320 0 0 {name=p110064 lab=_75710_/Y }
C {devices/lab_pin.sym} 111240 -36340 0 1 {name=p110065 lab=_75712_/B }
C {sky130_stdcells/xnor2_4.sym} 111180 -36340 0 0 {name=X_75711_ }
C {devices/lab_pin.sym} 111090 -36210 0 0 {name=p110066 lab=_84714_/CLK }
C {devices/lab_pin.sym} 111090 -36190 0 0 {name=p110067 lab=_84909_/D }
C {devices/lab_pin.sym} 111270 -36210 0 1 {name=p110068 lab=_58201_/A }
C {sky130_stdcells/dfxtp_4.sym} 111180 -36200 0 0 {name=X_84909_ }
C {devices/lab_pin.sym} 111100 -36100 0 0 {name=p110069 lab=_41996_/Y }
C {devices/lab_pin.sym} 111100 -36060 0 0 {name=p110070 lab=_72921_/X }
C {devices/lab_pin.sym} 111100 -36020 0 0 {name=p110071 lab=_72725_/X }
C {devices/lab_pin.sym} 111100 -35980 0 0 {name=p110072 lab=_72922_/Y }
C {devices/lab_pin.sym} 111260 -36040 0 1 {name=p110073 lab=_72923_/X }
C {sky130_stdcells/a211o_4.sym} 111180 -36040 0 0 {name=X_72923_ }
C {devices/lab_pin.sym} 111120 -35900 0 0 {name=p110074 lab=_84994_/Q }
C {devices/lab_pin.sym} 111120 -35860 0 0 {name=p110075 lab=_45740_/B }
C {devices/lab_pin.sym} 111240 -35880 0 1 {name=p110076 lab=_45871_/Y }
C {sky130_stdcells/nor2_4.sym} 111180 -35880 0 0 {name=X_45871_ }
C {devices/lab_pin.sym} 111120 -35760 0 0 {name=p110077 lab=_57806_/X }
C {devices/lab_pin.sym} 111120 -35720 0 0 {name=p110078 lab=_57857_/B }
C {devices/lab_pin.sym} 111240 -35740 0 1 {name=p110079 lab=_57857_/Y }
C {sky130_stdcells/nor2_4.sym} 111180 -35740 0 0 {name=X_57857_ }
C {devices/lab_pin.sym} 111120 -35620 0 0 {name=p110080 lab=_76691_/A }
C {devices/lab_pin.sym} 111120 -35580 0 0 {name=p110081 lab=_81351_/D }
C {devices/lab_pin.sym} 111240 -35600 0 1 {name=p110082 lab=_76694_/A }
C {sky130_stdcells/xnor2_4.sym} 111180 -35600 0 0 {name=X_76691_ }
C {devices/lab_pin.sym} 111090 -35470 0 0 {name=p110083 lab=_85888_/CLK }
C {devices/lab_pin.sym} 111090 -35450 0 0 {name=p110084 lab=_85889_/D }
C {devices/lab_pin.sym} 111270 -35470 0 1 {name=p110085 lab=_65423_/B }
C {sky130_stdcells/dfxtp_4.sym} 111180 -35460 0 0 {name=X_85889_ }
C {devices/lab_pin.sym} 111140 -35330 0 0 {name=p110086 lab=_47610_/A }
C {devices/lab_pin.sym} 111220 -35330 0 1 {name=p110087 lab=_53148_/B }
C {sky130_stdcells/buf_2.sym} 111180 -35330 0 0 {name=X_47610_ }
C {devices/lab_pin.sym} 111120 -35220 0 0 {name=p110088 lab=_78450_/C }
C {devices/lab_pin.sym} 111120 -35180 0 0 {name=p110089 lab=_78429_/Y }
C {devices/lab_pin.sym} 111240 -35200 0 1 {name=p110090 lab=_82762_/D }
C {sky130_stdcells/xnor2_4.sym} 111180 -35200 0 0 {name=X_78430_ }
C {devices/lab_pin.sym} 111100 -35110 0 0 {name=p110091 lab=_44807_/X }
C {devices/lab_pin.sym} 111100 -35070 0 0 {name=p110092 lab=_44821_/X }
C {devices/lab_pin.sym} 111100 -35030 0 0 {name=p110093 lab=_41666_/X }
C {devices/lab_pin.sym} 111100 -34990 0 0 {name=p110094 lab=_86936_/Q }
C {devices/lab_pin.sym} 111100 -34950 0 0 {name=p110095 lab=_44808_/X }
C {devices/lab_pin.sym} 111260 -35030 0 1 {name=p110096 lab=_44822_/Y }
C {sky130_stdcells/o32ai_4.sym} 111180 -35030 0 0 {name=X_44822_ }
C {devices/lab_pin.sym} 111140 -34870 0 0 {name=p110097 lab=_56808_/A }
C {devices/lab_pin.sym} 111220 -34870 0 1 {name=p110098 lab=_56808_/Y }
C {sky130_stdcells/inv_2.sym} 111180 -34870 0 0 {name=X_56808_ }
C {devices/lab_pin.sym} 111120 -34760 0 0 {name=p110099 lab=_75630_/A }
C {devices/lab_pin.sym} 111120 -34720 0 0 {name=p110100 lab=_75629_/X }
C {devices/lab_pin.sym} 111240 -34740 0 1 {name=p110101 lab=_75642_/X }
C {sky130_stdcells/or2_4.sym} 111180 -34740 0 0 {name=X_75642_ }
C {devices/lab_pin.sym} 111090 -34610 0 0 {name=p110102 lab=_88144_/CLK }
C {devices/lab_pin.sym} 111090 -34590 0 0 {name=p110103 lab=_42964_/X }
C {devices/lab_pin.sym} 111270 -34610 0 1 {name=p110104 lab=_87628_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -34600 0 0 {name=X_87628_ }
C {devices/lab_pin.sym} 111120 -34490 0 0 {name=p110105 lab=_52204_/A }
C {devices/lab_pin.sym} 111120 -34450 0 0 {name=p110106 lab=_48624_/B }
C {devices/lab_pin.sym} 111120 -34410 0 0 {name=p110107 lab=_48610_/C }
C {devices/lab_pin.sym} 111240 -34450 0 1 {name=p110108 lab=_48590_/X }
C {sky130_stdcells/and3_4.sym} 111180 -34450 0 0 {name=X_48590_ }
C {devices/lab_pin.sym} 111140 -34310 0 0 {name=p110109 lab=_44305_/X }
C {devices/lab_pin.sym} 111220 -34310 0 1 {name=p110110 lab=_73438_/B }
C {sky130_stdcells/buf_2.sym} 111180 -34310 0 0 {name=X_72854_ }
C {devices/lab_pin.sym} 111140 -34190 0 0 {name=p110111 lab=_64616_/A }
C {devices/lab_pin.sym} 111220 -34190 0 1 {name=p110112 lab=_57788_/X }
C {sky130_stdcells/buf_2.sym} 111180 -34190 0 0 {name=X_57788_ }
C {devices/lab_pin.sym} 111120 -34100 0 0 {name=p110113 lab=_47530_/X }
C {devices/lab_pin.sym} 111120 -34060 0 0 {name=p110114 lab=_47549_/B }
C {devices/lab_pin.sym} 111120 -34020 0 0 {name=p110115 lab=_47519_/X }
C {devices/lab_pin.sym} 111120 -33980 0 0 {name=p110116 lab=_53107_/D }
C {devices/lab_pin.sym} 111240 -34040 0 1 {name=p110117 lab=_47541_/X }
C {sky130_stdcells/and4_4.sym} 111180 -34040 0 0 {name=X_47541_ }
C {devices/lab_pin.sym} 111140 -33890 0 0 {name=p110118 lab=_71804_/Y }
C {devices/lab_pin.sym} 111220 -33890 0 1 {name=p110119 lab=_71805_/X }
C {sky130_stdcells/buf_2.sym} 111180 -33890 0 0 {name=X_71805_ }
C {devices/lab_pin.sym} 111140 -33770 0 0 {name=p110120 lab=_59602_/C }
C {devices/lab_pin.sym} 111220 -33770 0 1 {name=p110121 lab=_60175_/A }
C {sky130_stdcells/buf_2.sym} 111180 -33770 0 0 {name=X_59527_ }
C {devices/lab_pin.sym} 111100 -33670 0 0 {name=p110122 lab=_78343_/Y }
C {devices/lab_pin.sym} 111100 -33630 0 0 {name=p110123 lab=_82789_/Q }
C {devices/lab_pin.sym} 111100 -33590 0 0 {name=p110124 lab=_78344_/Y }
C {devices/lab_pin.sym} 111260 -33630 0 1 {name=p110125 lab=_78361_/Y }
C {sky130_stdcells/a21boi_4.sym} 111180 -33630 0 0 {name=X_78361_ }
C {devices/lab_pin.sym} 111100 -33520 0 0 {name=p110126 lab=_41298_/A }
C {devices/lab_pin.sym} 111100 -33480 0 0 {name=p110127 lab=_44665_/X }
C {devices/lab_pin.sym} 111100 -33440 0 0 {name=p110128 lab=_86973_/Q }
C {devices/lab_pin.sym} 111100 -33400 0 0 {name=p110129 lab=_44666_/X }
C {devices/lab_pin.sym} 111260 -33460 0 1 {name=p110130 lab=_86973_/D }
C {sky130_stdcells/a2bb2o_4.sym} 111180 -33460 0 0 {name=X_44753_ }
C {devices/lab_pin.sym} 111140 -33310 0 0 {name=p110131 lab=_56739_/A }
C {devices/lab_pin.sym} 111220 -33310 0 1 {name=p110132 lab=_56739_/X }
C {sky130_stdcells/buf_2.sym} 111180 -33310 0 0 {name=X_56739_ }
C {devices/lab_pin.sym} 111120 -33200 0 0 {name=p110133 lab=_75573_/A }
C {devices/lab_pin.sym} 111120 -33160 0 0 {name=p110134 lab=_75574_/A }
C {devices/lab_pin.sym} 111240 -33180 0 1 {name=p110135 lab=_75573_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -33180 0 0 {name=X_75573_ }
C {devices/lab_pin.sym} 111090 -33050 0 0 {name=p110136 lab=_87813_/CLK }
C {devices/lab_pin.sym} 111090 -33030 0 0 {name=p110137 lab=_43145_/Y }
C {devices/lab_pin.sym} 111270 -33050 0 1 {name=p110138 lab=_73083_/A }
C {sky130_stdcells/dfxtp_4.sym} 111180 -33040 0 0 {name=X_87559_ }
C {devices/lab_pin.sym} 111140 -32910 0 0 {name=p110139 lab=_41998_/A }
C {devices/lab_pin.sym} 111220 -32910 0 1 {name=p110140 lab=_41965_/X }
C {sky130_stdcells/buf_2.sym} 111180 -32910 0 0 {name=X_41965_ }
C {devices/lab_pin.sym} 111140 -32790 0 0 {name=p110141 lab=_73238_/A }
C {devices/lab_pin.sym} 111220 -32790 0 1 {name=p110142 lab=_72785_/X }
C {sky130_stdcells/buf_2.sym} 111180 -32790 0 0 {name=X_72785_ }
C {devices/lab_pin.sym} 111140 -32670 0 0 {name=p110143 lab=_77312_/A }
C {devices/lab_pin.sym} 111220 -32670 0 1 {name=p110144 lab=_77312_/Y }
C {sky130_stdcells/inv_2.sym} 111180 -32670 0 0 {name=X_77312_ }
C {devices/lab_pin.sym} 111100 -32580 0 0 {name=p110145 lab=_40831_/A }
C {devices/lab_pin.sym} 111100 -32540 0 0 {name=p110146 lab=_43698_/X }
C {devices/lab_pin.sym} 111100 -32500 0 0 {name=p110147 lab=_69737_/B }
C {devices/lab_pin.sym} 111100 -32460 0 0 {name=p110148 lab=_43700_/X }
C {devices/lab_pin.sym} 111260 -32520 0 1 {name=p110149 lab=_43705_/A }
C {sky130_stdcells/a2bb2o_4.sym} 111180 -32520 0 0 {name=X_43704_ }
C {devices/lab_pin.sym} 111100 -32390 0 0 {name=p110150 lab=_52803_/B }
C {devices/lab_pin.sym} 111100 -32350 0 0 {name=p110151 lab=_74517_/X }
C {devices/lab_pin.sym} 111100 -32310 0 0 {name=p110152 lab=_74523_/Y }
C {devices/lab_pin.sym} 111260 -32350 0 1 {name=p110153 lab=_74524_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -32350 0 0 {name=X_74524_ }
C {devices/lab_pin.sym} 111140 -32210 0 0 {name=p110154 lab=_40995_/A }
C {devices/lab_pin.sym} 111220 -32210 0 1 {name=p110155 lab=_40916_/X }
C {sky130_stdcells/buf_2.sym} 111180 -32210 0 0 {name=X_40916_ }
C {devices/lab_pin.sym} 111140 -32090 0 0 {name=p110156 lab=_47565_/A }
C {devices/lab_pin.sym} 111220 -32090 0 1 {name=p110157 lab=_47513_/C }
C {sky130_stdcells/buf_2.sym} 111180 -32090 0 0 {name=X_47472_ }
C {devices/lab_pin.sym} 111140 -31970 0 0 {name=p110158 lab=_71735_/X }
C {devices/lab_pin.sym} 111220 -31970 0 1 {name=p110159 lab=_71736_/X }
C {sky130_stdcells/buf_2.sym} 111180 -31970 0 0 {name=X_71736_ }
C {devices/lab_pin.sym} 111100 -31870 0 0 {name=p110160 lab=_59426_/X }
C {devices/lab_pin.sym} 111100 -31830 0 0 {name=p110161 lab=_59456_/Y }
C {devices/lab_pin.sym} 111100 -31790 0 0 {name=p110162 lab=_59457_/Y }
C {devices/lab_pin.sym} 111260 -31830 0 1 {name=p110163 lab=_84727_/D }
C {sky130_stdcells/a21oi_4.sym} 111180 -31830 0 0 {name=X_59458_ }
C {devices/lab_pin.sym} 111120 -31700 0 0 {name=p110164 lab=_78292_/A }
C {devices/lab_pin.sym} 111120 -31660 0 0 {name=p110165 lab=_78291_/Y }
C {devices/lab_pin.sym} 111240 -31680 0 1 {name=p110166 lab=_78293_/B }
C {sky130_stdcells/xor2_4.sym} 111180 -31680 0 0 {name=X_78292_ }
C {devices/lab_pin.sym} 111140 -31550 0 0 {name=p110167 lab=_87001_/Q }
C {devices/lab_pin.sym} 111220 -31550 0 1 {name=p110168 lab=_44684_/Y }
C {sky130_stdcells/inv_2.sym} 111180 -31550 0 0 {name=X_44684_ }
C {devices/lab_pin.sym} 111140 -31430 0 0 {name=p110169 lab=_41895_/Y }
C {devices/lab_pin.sym} 111220 -31430 0 1 {name=p110170 lab=_41896_/Y }
C {sky130_stdcells/inv_2.sym} 111180 -31430 0 0 {name=X_41896_ }
C {devices/lab_pin.sym} 111100 -31330 0 0 {name=p110171 lab=_49208_/Y }
C {devices/lab_pin.sym} 111100 -31290 0 0 {name=p110172 lab=_49189_/X }
C {devices/lab_pin.sym} 111100 -31250 0 0 {name=p110173 lab=_49210_/Y }
C {devices/lab_pin.sym} 111260 -31290 0 1 {name=p110174 lab=_49211_/Y }
C {sky130_stdcells/a21oi_4.sym} 111180 -31290 0 0 {name=X_49211_ }
C {devices/lab_pin.sym} 111140 -31150 0 0 {name=p110175 lab=_47867_/A }
C {devices/lab_pin.sym} 111220 -31150 0 1 {name=p110176 lab=_46423_/X }
C {sky130_stdcells/buf_2.sym} 111180 -31150 0 0 {name=X_46423_ }
C {devices/lab_pin.sym} 111120 -31040 0 0 {name=p110177 lab=_58409_/A }
C {devices/lab_pin.sym} 111120 -31000 0 0 {name=p110178 lab=_58415_/B }
C {devices/lab_pin.sym} 111240 -31020 0 1 {name=p110179 lab=_58409_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -31020 0 0 {name=X_58409_ }
C {devices/lab_pin.sym} 111100 -30910 0 0 {name=p110180 lab=_77241_/Y }
C {devices/lab_pin.sym} 111100 -30870 0 0 {name=p110181 lab=_77234_/A }
C {devices/lab_pin.sym} 111100 -30830 0 0 {name=p110182 lab=_77242_/Y }
C {devices/lab_pin.sym} 111260 -30870 0 1 {name=p110183 lab=_77243_/X }
C {sky130_stdcells/a21bo_4.sym} 111180 -30870 0 0 {name=X_77243_ }
C {devices/lab_pin.sym} 111140 -30730 0 0 {name=p110184 lab=_87333_/Q }
C {devices/lab_pin.sym} 111220 -30730 0 1 {name=p110185 lab=_68732_/B }
C {sky130_stdcells/inv_2.sym} 111180 -30730 0 0 {name=X_43635_ }
C {devices/lab_pin.sym} 111100 -30630 0 0 {name=p110186 lab=_74452_/Y }
C {devices/lab_pin.sym} 111100 -30590 0 0 {name=p110187 lab=_74430_/X }
C {devices/lab_pin.sym} 111100 -30550 0 0 {name=p110188 lab=_74454_/X }
C {devices/lab_pin.sym} 111260 -30590 0 1 {name=p110189 lab=_83063_/D }
C {sky130_stdcells/a21oi_4.sym} 111180 -30590 0 0 {name=X_74455_ }
C {devices/lab_pin.sym} 111120 -30460 0 0 {name=p110190 lab=_82865_/Q }
C {devices/lab_pin.sym} 111120 -30420 0 0 {name=p110191 lab=_40847_/B }
C {devices/lab_pin.sym} 111240 -30440 0 1 {name=p110192 lab=_40847_/X }
C {sky130_stdcells/or2_4.sym} 111180 -30440 0 0 {name=X_40847_ }
C {devices/lab_pin.sym} 111100 -30330 0 0 {name=p110193 lab=_58530_/Y }
C {devices/lab_pin.sym} 111100 -30290 0 0 {name=p110194 lab=_71649_/A }
C {devices/lab_pin.sym} 111100 -30250 0 0 {name=p110195 lab=_71666_/Y }
C {devices/lab_pin.sym} 111260 -30290 0 1 {name=p110196 lab=_71667_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -30290 0 0 {name=X_71667_ }
C {devices/lab_pin.sym} 111100 -30170 0 0 {name=p110197 lab=_58982_/X }
C {devices/lab_pin.sym} 111100 -30130 0 0 {name=p110198 lab=_83489_/Q }
C {devices/lab_pin.sym} 111100 -30090 0 0 {name=p110199 lab=_59388_/Y }
C {devices/lab_pin.sym} 111260 -30130 0 1 {name=p110200 lab=_59389_/X }
C {sky130_stdcells/o21a_4.sym} 111180 -30130 0 0 {name=X_59389_ }
C {devices/lab_pin.sym} 111140 -29990 0 0 {name=p110201 lab=clkbuf_9_506_0_CLK/X }
C {devices/lab_pin.sym} 111220 -29990 0 1 {name=p110202 lab=_83623_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 111180 -29990 0 0 {name=Xclkbuf_10_1013_0_CLK }
C {devices/lab_pin.sym} 111140 -29870 0 0 {name=p110203 lab=_73238_/A }
C {devices/lab_pin.sym} 111220 -29870 0 1 {name=p110204 lab=_73406_/X }
C {sky130_stdcells/buf_2.sym} 111180 -29870 0 0 {name=X_73406_ }
C {devices/lab_pin.sym} 111100 -29770 0 0 {name=p110205 lab=_49137_/Y }
C {devices/lab_pin.sym} 111100 -29730 0 0 {name=p110206 lab=_49138_/X }
C {devices/lab_pin.sym} 111100 -29690 0 0 {name=p110207 lab=_49141_/X }
C {devices/lab_pin.sym} 111260 -29730 0 1 {name=p110208 lab=_86440_/D }
C {sky130_stdcells/a21oi_4.sym} 111180 -29730 0 0 {name=X_49142_ }
C {devices/lab_pin.sym} 111120 -29610 0 0 {name=p110209 lab=_61429_/A }
C {devices/lab_pin.sym} 111120 -29570 0 0 {name=p110210 lab=_61419_/X }
C {devices/lab_pin.sym} 111120 -29530 0 0 {name=p110211 lab=_61429_/C }
C {devices/lab_pin.sym} 111240 -29570 0 1 {name=p110212 lab=_61420_/Y }
C {sky130_stdcells/nand3_4.sym} 111180 -29570 0 0 {name=X_61420_ }
C {devices/lab_pin.sym} 111100 -29450 0 0 {name=p110213 lab=_46345_/Y }
C {devices/lab_pin.sym} 111100 -29410 0 0 {name=p110214 lab=_46346_/X }
C {devices/lab_pin.sym} 111100 -29370 0 0 {name=p110215 lab=_46353_/Y }
C {devices/lab_pin.sym} 111260 -29410 0 1 {name=p110216 lab=_86745_/D }
C {sky130_stdcells/a21boi_4.sym} 111180 -29410 0 0 {name=X_46354_ }
C {devices/lab_pin.sym} 111100 -29290 0 0 {name=p110217 lab=_52995_/B }
C {devices/lab_pin.sym} 111100 -29250 0 0 {name=p110218 lab=_70583_/X }
C {devices/lab_pin.sym} 111100 -29210 0 0 {name=p110219 lab=_70617_/Y }
C {devices/lab_pin.sym} 111260 -29250 0 1 {name=p110220 lab=_83740_/D }
C {sky130_stdcells/o21ai_4.sym} 111180 -29250 0 0 {name=X_70618_ }
C {devices/lab_pin.sym} 111120 -29130 0 0 {name=p110221 lab=_77173_/B }
C {devices/lab_pin.sym} 111120 -29090 0 0 {name=p110222 lab=_77174_/B }
C {devices/lab_pin.sym} 111120 -29050 0 0 {name=p110223 lab=_81920_/Q }
C {devices/lab_pin.sym} 111240 -29090 0 1 {name=p110224 lab=_77175_/A }
C {sky130_stdcells/nand3_4.sym} 111180 -29090 0 0 {name=X_77174_ }
C {devices/lab_pin.sym} 111100 -28980 0 0 {name=p110225 lab=_40497_/X }
C {devices/lab_pin.sym} 111100 -28940 0 0 {name=p110226 lab=_43560_/X }
C {devices/lab_pin.sym} 111100 -28900 0 0 {name=p110227 lab=_87358_/Q }
C {devices/lab_pin.sym} 111100 -28860 0 0 {name=p110228 lab=_43561_/X }
C {devices/lab_pin.sym} 111260 -28920 0 1 {name=p110229 lab=_87358_/D }
C {sky130_stdcells/a2bb2o_4.sym} 111180 -28920 0 0 {name=X_43566_ }
C {devices/lab_pin.sym} 111100 -28790 0 0 {name=p110230 lab=_74384_/Y }
C {devices/lab_pin.sym} 111100 -28750 0 0 {name=p110231 lab=_72107_/X }
C {devices/lab_pin.sym} 111100 -28710 0 0 {name=p110232 lab=_74385_/Y }
C {devices/lab_pin.sym} 111260 -28750 0 1 {name=p110233 lab=_83077_/D }
C {sky130_stdcells/a21boi_4.sym} 111180 -28750 0 0 {name=X_74386_ }
C {devices/lab_pin.sym} 111140 -28610 0 0 {name=p110234 lab=_40736_/A }
C {devices/lab_pin.sym} 111220 -28610 0 1 {name=p110235 lab=_40779_/B }
C {sky130_stdcells/buf_2.sym} 111180 -28610 0 0 {name=X_40778_ }
C {devices/lab_pin.sym} 111120 -28510 0 0 {name=p110236 lab=_71865_/A }
C {devices/lab_pin.sym} 111120 -28470 0 0 {name=p110237 lab=_71626_/B }
C {devices/lab_pin.sym} 111120 -28430 0 0 {name=p110238 lab=_71598_/C }
C {devices/lab_pin.sym} 111240 -28470 0 1 {name=p110239 lab=_71598_/Y }
C {sky130_stdcells/nor3_4.sym} 111180 -28470 0 0 {name=X_71598_ }
C {devices/lab_pin.sym} 111140 -28330 0 0 {name=p110240 lab=_83015_/Q }
C {devices/lab_pin.sym} 111220 -28330 0 1 {name=p110241 lab=_45305_/Y }
C {sky130_stdcells/inv_2.sym} 111180 -28330 0 0 {name=X_45305_ }
C {devices/lab_pin.sym} 111120 -28220 0 0 {name=p110242 lab=_76110_/X }
C {devices/lab_pin.sym} 111120 -28180 0 0 {name=p110243 lab=_76124_/Y }
C {devices/lab_pin.sym} 111240 -28200 0 1 {name=p110244 lab=_76125_/X }
C {sky130_stdcells/or2_4.sym} 111180 -28200 0 0 {name=X_76125_ }
C {devices/lab_pin.sym} 111140 -28070 0 0 {name=p110245 lab=_42554_/A }
C {devices/lab_pin.sym} 111220 -28070 0 1 {name=p110246 lab=_42517_/X }
C {sky130_stdcells/buf_2.sym} 111180 -28070 0 0 {name=X_42517_ }
C {devices/lab_pin.sym} 111140 -27950 0 0 {name=p110247 lab=_53877_/B }
C {devices/lab_pin.sym} 111220 -27950 0 1 {name=p110248 lab=_49073_/X }
C {sky130_stdcells/buf_2.sym} 111180 -27950 0 0 {name=X_49073_ }
C {devices/lab_pin.sym} 111140 -27830 0 0 {name=p110249 lab=_61414_/A }
C {devices/lab_pin.sym} 111220 -27830 0 1 {name=p110250 lab=_61384_/B }
C {sky130_stdcells/buf_2.sym} 111180 -27830 0 0 {name=X_61351_ }
C {devices/lab_pin.sym} 111120 -27720 0 0 {name=p110251 lab=_48602_/Y }
C {devices/lab_pin.sym} 111120 -27680 0 0 {name=p110252 lab=_73336_/Y }
C {devices/lab_pin.sym} 111240 -27700 0 1 {name=p110253 lab=_73337_/X }
C {sky130_stdcells/xor2_4.sym} 111180 -27700 0 0 {name=X_73337_ }
C {devices/lab_pin.sym} 111120 -27580 0 0 {name=p110254 lab=_46285_/A }
C {devices/lab_pin.sym} 111120 -27540 0 0 {name=p110255 lab=_46328_/B }
C {devices/lab_pin.sym} 111240 -27560 0 1 {name=p110256 lab=_46285_/X }
C {sky130_stdcells/or2_4.sym} 111180 -27560 0 0 {name=X_46285_ }
C {devices/lab_pin.sym} 111140 -27430 0 0 {name=p110257 lab=_71012_/A }
C {devices/lab_pin.sym} 111220 -27430 0 1 {name=p110258 lab=_70549_/X }
C {sky130_stdcells/buf_2.sym} 111180 -27430 0 0 {name=X_70549_ }
C {devices/lab_pin.sym} 111140 -27310 0 0 {name=p110259 lab=_43497_/A }
C {devices/lab_pin.sym} 111220 -27310 0 1 {name=p110260 lab=_43497_/Y }
C {sky130_stdcells/inv_2.sym} 111180 -27310 0 0 {name=X_43497_ }
C {devices/lab_pin.sym} 111120 -27200 0 0 {name=p110261 lab=_48004_/A }
C {devices/lab_pin.sym} 111120 -27160 0 0 {name=p110262 lab=_48024_/B }
C {devices/lab_pin.sym} 111240 -27180 0 1 {name=p110263 lab=_48024_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -27180 0 0 {name=X_48024_ }
C {devices/lab_pin.sym} 111140 -27050 0 0 {name=p110264 lab=_60179_/A }
C {devices/lab_pin.sym} 111220 -27050 0 1 {name=p110265 lab=_60302_/X }
C {sky130_stdcells/buf_2.sym} 111180 -27050 0 0 {name=X_60302_ }
C {devices/lab_pin.sym} 111100 -26950 0 0 {name=p110266 lab=_45227_/X }
C {devices/lab_pin.sym} 111100 -26910 0 0 {name=p110267 lab=_45233_/Y }
C {devices/lab_pin.sym} 111100 -26870 0 0 {name=p110268 lab=_45235_/Y }
C {devices/lab_pin.sym} 111260 -26910 0 1 {name=p110269 lab=_45236_/Y }
C {sky130_stdcells/a21oi_4.sym} 111180 -26910 0 0 {name=X_45236_ }
C {devices/lab_pin.sym} 111120 -26780 0 0 {name=p110270 lab=_81717_/D }
C {devices/lab_pin.sym} 111120 -26740 0 0 {name=p110271 lab=_76056_/B }
C {devices/lab_pin.sym} 111240 -26760 0 1 {name=p110272 lab=_76063_/C }
C {sky130_stdcells/nand2_4.sym} 111180 -26760 0 0 {name=X_76056_ }
C {devices/lab_pin.sym} 111140 -26630 0 0 {name=p110273 lab=_63734_/A }
C {devices/lab_pin.sym} 111220 -26630 0 1 {name=p110274 lab=_64162_/A }
C {sky130_stdcells/buf_2.sym} 111180 -26630 0 0 {name=X_64070_ }
C {devices/lab_pin.sym} 111140 -26510 0 0 {name=p110275 lab=_42447_/X }
C {devices/lab_pin.sym} 111220 -26510 0 1 {name=p110276 lab=_52398_/A }
C {sky130_stdcells/buf_2.sym} 111180 -26510 0 0 {name=X_42448_ }
C {devices/lab_pin.sym} 111120 -26400 0 0 {name=p110277 lab=_48572_/A }
C {devices/lab_pin.sym} 111120 -26360 0 0 {name=p110278 lab=_73267_/Y }
C {devices/lab_pin.sym} 111240 -26380 0 1 {name=p110279 lab=_73268_/X }
C {sky130_stdcells/xor2_4.sym} 111180 -26380 0 0 {name=X_73268_ }
C {devices/lab_pin.sym} 111140 -26250 0 0 {name=p110280 lab=_61281_/X }
C {devices/lab_pin.sym} 111220 -26250 0 1 {name=p110281 lab=_72507_/A }
C {sky130_stdcells/buf_2.sym} 111180 -26250 0 0 {name=X_61282_ }
C {devices/lab_pin.sym} 111120 -26140 0 0 {name=p110282 lab=_80952_/Q }
C {devices/lab_pin.sym} 111120 -26100 0 0 {name=p110283 lab=_75007_/B }
C {devices/lab_pin.sym} 111240 -26120 0 1 {name=p110284 lab=_75007_/X }
C {sky130_stdcells/xor2_4.sym} 111180 -26120 0 0 {name=X_75007_ }
C {devices/lab_pin.sym} 111100 -26030 0 0 {name=p110285 lab=_63011_/Y }
C {devices/lab_pin.sym} 111100 -25990 0 0 {name=p110286 lab=_63012_/X }
C {devices/lab_pin.sym} 111100 -25950 0 0 {name=p110287 lab=_63014_/X }
C {devices/lab_pin.sym} 111100 -25910 0 0 {name=p110288 lab=_63017_/X }
C {devices/lab_pin.sym} 111100 -25870 0 0 {name=p110289 lab=_63020_/X }
C {devices/lab_pin.sym} 111260 -25950 0 1 {name=p110290 lab=_63021_/Y }
C {sky130_stdcells/o41ai_4.sym} 111180 -25950 0 0 {name=X_63021_ }
C {devices/lab_pin.sym} 111120 -25800 0 0 {name=p110291 lab=_60189_/A }
C {devices/lab_pin.sym} 111120 -25760 0 0 {name=p110292 lab=_60239_/A }
C {devices/lab_pin.sym} 111240 -25780 0 1 {name=p110293 lab=_60233_/Y }
C {sky130_stdcells/nor2_4.sym} 111180 -25780 0 0 {name=X_60233_ }
C {devices/lab_pin.sym} 111100 -25670 0 0 {name=p110294 lab=_72216_/Y }
C {devices/lab_pin.sym} 111100 -25630 0 0 {name=p110295 lab=_72218_/Y }
C {devices/lab_pin.sym} 111100 -25590 0 0 {name=p110296 lab=_72185_/X }
C {devices/lab_pin.sym} 111260 -25630 0 1 {name=p110297 lab=_72219_/X }
C {sky130_stdcells/a21o_4.sym} 111180 -25630 0 0 {name=X_72219_ }
C {devices/lab_pin.sym} 111100 -25510 0 0 {name=p110298 lab=_85296_/Q }
C {devices/lab_pin.sym} 111100 -25470 0 0 {name=p110299 lab=_45120_/X }
C {devices/lab_pin.sym} 111100 -25430 0 0 {name=p110300 lab=_45153_/X }
C {devices/lab_pin.sym} 111260 -25470 0 1 {name=p110301 lab=_45167_/X }
C {sky130_stdcells/o21a_4.sym} 111180 -25470 0 0 {name=X_45167_ }
C {devices/lab_pin.sym} 111100 -25370 0 0 {name=p110302 lab=_42378_/X }
C {devices/lab_pin.sym} 111100 -25330 0 0 {name=p110303 lab=_42369_/X }
C {devices/lab_pin.sym} 111100 -25290 0 0 {name=p110304 lab=_41786_/X }
C {devices/lab_pin.sym} 111100 -25250 0 0 {name=p110305 lab=_87893_/Q }
C {devices/lab_pin.sym} 111100 -25210 0 0 {name=p110306 lab=_42370_/X }
C {devices/lab_pin.sym} 111260 -25290 0 1 {name=p110307 lab=_42379_/Y }
C {sky130_stdcells/o32ai_4.sym} 111180 -25290 0 0 {name=X_42379_ }
C {devices/lab_pin.sym} 111100 -25160 0 0 {name=p110308 lab=_69793_/B }
C {devices/lab_pin.sym} 111100 -25120 0 0 {name=p110309 lab=_57377_/X }
C {devices/lab_pin.sym} 111100 -25080 0 0 {name=p110310 lab=_73055_/X }
C {devices/lab_pin.sym} 111100 -25040 0 0 {name=p110311 lab=_73198_/Y }
C {devices/lab_pin.sym} 111260 -25100 0 1 {name=p110312 lab=_73199_/X }
C {sky130_stdcells/a211o_4.sym} 111180 -25100 0 0 {name=X_73199_ }
C {devices/lab_pin.sym} 111120 -24970 0 0 {name=p110313 lab=_44107_/X }
C {devices/lab_pin.sym} 111120 -24930 0 0 {name=p110314 lab=_44118_/B }
C {devices/lab_pin.sym} 111120 -24890 0 0 {name=p110315 lab=_44117_/Y }
C {devices/lab_pin.sym} 111240 -24930 0 1 {name=p110316 lab=_44119_/A }
C {sky130_stdcells/nand3_4.sym} 111180 -24930 0 0 {name=X_44118_ }
C {devices/lab_pin.sym} 111100 -24810 0 0 {name=p110317 lab=_79807_/A }
C {devices/lab_pin.sym} 111100 -24770 0 0 {name=p110318 lab=_79807_/B }
C {devices/lab_pin.sym} 111100 -24730 0 0 {name=p110319 lab=_79814_/Y }
C {devices/lab_pin.sym} 111260 -24770 0 1 {name=p110320 lab=_79819_/A }
C {sky130_stdcells/a21boi_4.sym} 111180 -24770 0 0 {name=X_79815_ }
C {devices/lab_pin.sym} 111140 -24630 0 0 {name=p110321 lab=_59830_/Y }
C {devices/lab_pin.sym} 111220 -24630 0 1 {name=p110322 lab=_60164_/Y }
C {sky130_stdcells/inv_2.sym} 111180 -24630 0 0 {name=X_60164_ }
C {devices/lab_pin.sym} 111120 -24520 0 0 {name=p110323 lab=_49981_/A }
C {devices/lab_pin.sym} 111120 -24480 0 0 {name=p110324 lab=_53187_/B }
C {devices/lab_pin.sym} 111240 -24500 0 1 {name=p110325 lab=_49975_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -24500 0 0 {name=X_49975_ }
C {devices/lab_pin.sym} 111100 -24390 0 0 {name=p110326 lab=_45052_/X }
C {devices/lab_pin.sym} 111100 -24350 0 0 {name=p110327 lab=_61479_/B }
C {devices/lab_pin.sym} 111100 -24310 0 0 {name=p110328 lab=_45070_/X }
C {devices/lab_pin.sym} 111260 -24350 0 1 {name=p110329 lab=_45098_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -24350 0 0 {name=X_45098_ }
C {devices/lab_pin.sym} 111140 -24210 0 0 {name=p110330 lab=_48926_/A }
C {devices/lab_pin.sym} 111220 -24210 0 1 {name=p110331 lab=_48928_/A }
C {sky130_stdcells/buf_2.sym} 111180 -24210 0 0 {name=X_48926_ }
C {devices/lab_pin.sym} 111140 -24090 0 0 {name=p110332 lab=_44048_/X }
C {devices/lab_pin.sym} 111220 -24090 0 1 {name=p110333 lab=_44049_/X }
C {sky130_stdcells/buf_2.sym} 111180 -24090 0 0 {name=X_44049_ }
C {devices/lab_pin.sym} 111120 -23980 0 0 {name=p110334 lab=_79735_/X }
C {devices/lab_pin.sym} 111120 -23940 0 0 {name=p110335 lab=_79724_/X }
C {devices/lab_pin.sym} 111240 -23960 0 1 {name=p110336 lab=_79746_/X }
C {sky130_stdcells/and2_4.sym} 111180 -23960 0 0 {name=X_79746_ }
C {devices/lab_pin.sym} 111100 -23850 0 0 {name=p110337 lab=_84056_/Q }
C {devices/lab_pin.sym} 111100 -23810 0 0 {name=p110338 lab=_67688_/X }
C {devices/lab_pin.sym} 111100 -23770 0 0 {name=p110339 lab=_67759_/X }
C {devices/lab_pin.sym} 111260 -23810 0 1 {name=p110340 lab=_84056_/D }
C {sky130_stdcells/a21bo_4.sym} 111180 -23810 0 0 {name=X_67760_ }
C {devices/lab_pin.sym} 111140 -23670 0 0 {name=p110341 lab=_64766_/A }
C {devices/lab_pin.sym} 111220 -23670 0 1 {name=p110342 lab=_64972_/X }
C {sky130_stdcells/buf_2.sym} 111180 -23670 0 0 {name=X_64972_ }
C {devices/lab_pin.sym} 111140 -23550 0 0 {name=p110343 lab=_60094_/X }
C {devices/lab_pin.sym} 111220 -23550 0 1 {name=p110344 lab=_60095_/X }
C {sky130_stdcells/buf_2.sym} 111180 -23550 0 0 {name=X_60095_ }
C {devices/lab_pin.sym} 111120 -23440 0 0 {name=p110345 lab=_76958_/A }
C {devices/lab_pin.sym} 111120 -23400 0 0 {name=p110346 lab=_76958_/B }
C {devices/lab_pin.sym} 111240 -23420 0 1 {name=p110347 lab=_76958_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -23420 0 0 {name=X_76958_ }
C {devices/lab_pin.sym} 111100 -23320 0 0 {name=p110348 lab=_87949_/Q }
C {devices/lab_pin.sym} 111100 -23280 0 0 {name=p110349 lab=_66639_/X }
C {devices/lab_pin.sym} 111100 -23240 0 0 {name=p110350 lab=_66688_/X }
C {devices/lab_pin.sym} 111100 -23200 0 0 {name=p110351 lab=_66710_/X }
C {devices/lab_pin.sym} 111260 -23260 0 1 {name=p110352 lab=_66711_/X }
C {sky130_stdcells/a211o_4.sym} 111180 -23260 0 0 {name=X_66711_ }
C {devices/lab_pin.sym} 111120 -23140 0 0 {name=p110353 lab=_61909_/X }
C {devices/lab_pin.sym} 111120 -23100 0 0 {name=p110354 lab=_63876_/B }
C {devices/lab_pin.sym} 111120 -23060 0 0 {name=p110355 lab=_63905_/C }
C {devices/lab_pin.sym} 111120 -23020 0 0 {name=p110356 lab=_63892_/D }
C {devices/lab_pin.sym} 111240 -23080 0 1 {name=p110357 lab=_63923_/Y }
C {sky130_stdcells/nand4_4.sym} 111180 -23080 0 0 {name=X_63923_ }
C {devices/lab_pin.sym} 111120 -22940 0 0 {name=p110358 lab=_75909_/A }
C {devices/lab_pin.sym} 111120 -22900 0 0 {name=p110359 lab=_62825_/C }
C {devices/lab_pin.sym} 111240 -22920 0 1 {name=p110360 lab=_80723_/D }
C {sky130_stdcells/xor2_4.sym} 111180 -22920 0 0 {name=X_75909_ }
C {devices/lab_pin.sym} 111100 -22810 0 0 {name=p110361 lab=_86469_/Q }
C {devices/lab_pin.sym} 111100 -22770 0 0 {name=p110362 lab=_48836_/X }
C {devices/lab_pin.sym} 111100 -22730 0 0 {name=p110363 lab=_48856_/Y }
C {devices/lab_pin.sym} 111260 -22770 0 1 {name=p110364 lab=_48857_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -22770 0 0 {name=X_48857_ }
C {devices/lab_pin.sym} 111120 -22640 0 0 {name=p110365 lab=_67690_/X }
C {devices/lab_pin.sym} 111120 -22600 0 0 {name=p110366 lab=_67691_/B }
C {devices/lab_pin.sym} 111240 -22620 0 1 {name=p110367 lab=_67691_/X }
C {sky130_stdcells/and2_4.sym} 111180 -22620 0 0 {name=X_67691_ }
C {devices/lab_pin.sym} 111120 -22500 0 0 {name=p110368 lab=_79670_/X }
C {devices/lab_pin.sym} 111120 -22460 0 0 {name=p110369 lab=_79677_/B }
C {devices/lab_pin.sym} 111240 -22480 0 1 {name=p110370 lab=_79677_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -22480 0 0 {name=X_79677_ }
C {devices/lab_pin.sym} 111120 -22360 0 0 {name=p110371 lab=_76901_/A }
C {devices/lab_pin.sym} 111120 -22320 0 0 {name=p110372 lab=_76889_/B }
C {devices/lab_pin.sym} 111240 -22340 0 1 {name=p110373 lab=_76889_/X }
C {sky130_stdcells/and2_4.sym} 111180 -22340 0 0 {name=X_76889_ }
C {devices/lab_pin.sym} 111140 -22210 0 0 {name=p110374 lab=_44245_/A }
C {devices/lab_pin.sym} 111220 -22210 0 1 {name=p110375 lab=_69430_/X }
C {sky130_stdcells/buf_2.sym} 111180 -22210 0 0 {name=X_69430_ }
C {devices/lab_pin.sym} 111140 -22090 0 0 {name=p110376 lab=_47808_/A }
C {devices/lab_pin.sym} 111220 -22090 0 1 {name=p110377 lab=_47809_/A }
C {sky130_stdcells/inv_2.sym} 111180 -22090 0 0 {name=X_47808_ }
C {devices/lab_pin.sym} 111140 -21970 0 0 {name=p110378 lab=_66642_/A }
C {devices/lab_pin.sym} 111220 -21970 0 1 {name=p110379 lab=_66642_/X }
C {sky130_stdcells/buf_2.sym} 111180 -21970 0 0 {name=X_66642_ }
C {devices/lab_pin.sym} 111140 -21850 0 0 {name=p110380 lab=_82808_/Q }
C {devices/lab_pin.sym} 111220 -21850 0 1 {name=p110381 lab=_78628_/Y }
C {sky130_stdcells/inv_2.sym} 111180 -21850 0 0 {name=X_78628_ }
C {devices/lab_pin.sym} 111140 -21730 0 0 {name=p110382 lab=_64026_/A }
C {devices/lab_pin.sym} 111220 -21730 0 1 {name=p110383 lab=_63900_/B }
C {sky130_stdcells/buf_2.sym} 111180 -21730 0 0 {name=X_63854_ }
C {devices/lab_pin.sym} 111120 -21620 0 0 {name=p110384 lab=_48793_/A }
C {devices/lab_pin.sym} 111120 -21580 0 0 {name=p110385 lab=_48788_/B }
C {devices/lab_pin.sym} 111240 -21600 0 1 {name=p110386 lab=_48788_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -21600 0 0 {name=X_48788_ }
C {devices/lab_pin.sym} 111100 -21510 0 0 {name=p110387 lab=_62798_/Y }
C {devices/lab_pin.sym} 111100 -21470 0 0 {name=p110388 lab=_62772_/X }
C {devices/lab_pin.sym} 111100 -21430 0 0 {name=p110389 lab=_62799_/Y }
C {devices/lab_pin.sym} 111100 -21390 0 0 {name=p110390 lab=_62802_/Y }
C {devices/lab_pin.sym} 111100 -21360 0 0 {name=p110391 lab=_62804_/X }
C {devices/lab_pin.sym} 111260 -21430 0 1 {name=p110392 lab=_62805_/X }
C {sky130_stdcells/a41o_4.sym} 111180 -21430 0 0 {name=X_62805_ }
C {devices/lab_pin.sym} 111140 -21270 0 0 {name=p110393 lab=_69611_/A }
C {devices/lab_pin.sym} 111220 -21270 0 1 {name=p110394 lab=_69361_/X }
C {sky130_stdcells/buf_2.sym} 111180 -21270 0 0 {name=X_69361_ }
C {devices/lab_pin.sym} 111120 -21180 0 0 {name=p110395 lab=_47758_/A }
C {devices/lab_pin.sym} 111120 -21140 0 0 {name=p110396 lab=_47739_/B }
C {devices/lab_pin.sym} 111120 -21100 0 0 {name=p110397 lab=_47749_/C }
C {devices/lab_pin.sym} 111120 -21060 0 0 {name=p110398 lab=_53217_/D }
C {devices/lab_pin.sym} 111240 -21120 0 1 {name=p110399 lab=_47739_/X }
C {sky130_stdcells/and4_4.sym} 111180 -21120 0 0 {name=X_47739_ }
C {devices/lab_pin.sym} 111140 -20970 0 0 {name=p110400 lab=_66572_/X }
C {devices/lab_pin.sym} 111220 -20970 0 1 {name=p110401 lab=_69779_/A }
C {sky130_stdcells/buf_2.sym} 111180 -20970 0 0 {name=X_66573_ }
C {devices/lab_pin.sym} 111140 -20850 0 0 {name=p110402 lab=_78558_/X }
C {devices/lab_pin.sym} 111220 -20850 0 1 {name=p110403 lab=_78560_/B }
C {sky130_stdcells/inv_2.sym} 111180 -20850 0 0 {name=X_78559_ }
C {devices/lab_pin.sym} 111100 -20750 0 0 {name=p110404 lab=_63783_/X }
C {devices/lab_pin.sym} 111100 -20710 0 0 {name=p110405 lab=_63744_/X }
C {devices/lab_pin.sym} 111100 -20670 0 0 {name=p110406 lab=_63784_/Y }
C {devices/lab_pin.sym} 111260 -20710 0 1 {name=p110407 lab=_84295_/D }
C {sky130_stdcells/a21oi_4.sym} 111180 -20710 0 0 {name=X_63785_ }
C {devices/lab_pin.sym} 111140 -20570 0 0 {name=p110408 lab=_60997_/A }
C {devices/lab_pin.sym} 111220 -20570 0 1 {name=p110409 lab=_64182_/C }
C {sky130_stdcells/buf_2.sym} 111180 -20570 0 0 {name=X_60997_ }
C {devices/lab_pin.sym} 111100 -20470 0 0 {name=p110410 lab=_67918_/X }
C {devices/lab_pin.sym} 111100 -20430 0 0 {name=p110411 lab=_67920_/X }
C {devices/lab_pin.sym} 111100 -20390 0 0 {name=p110412 lab=_68295_/X }
C {devices/lab_pin.sym} 111260 -20430 0 1 {name=p110413 lab=_68312_/Y }
C {sky130_stdcells/a21oi_4.sym} 111180 -20430 0 0 {name=X_68312_ }
C {devices/lab_pin.sym} 111140 -20290 0 0 {name=p110414 lab=clkbuf_9_340_0_CLK/X }
C {devices/lab_pin.sym} 111220 -20290 0 1 {name=p110415 lab=_87394_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 111180 -20290 0 0 {name=Xclkbuf_10_680_0_CLK }
C {devices/lab_pin.sym} 111140 -20170 0 0 {name=p110416 lab=_65660_/A }
C {devices/lab_pin.sym} 111220 -20170 0 1 {name=p110417 lab=_65524_/X }
C {sky130_stdcells/buf_2.sym} 111180 -20170 0 0 {name=X_65524_ }
C {devices/lab_pin.sym} 111140 -20050 0 0 {name=p110418 lab=_50538_/A }
C {devices/lab_pin.sym} 111220 -20050 0 1 {name=p110419 lab=_50751_/C }
C {sky130_stdcells/buf_2.sym} 111180 -20050 0 0 {name=X_50750_ }
C {devices/lab_pin.sym} 111100 -19950 0 0 {name=p110420 lab=_62732_/X }
C {devices/lab_pin.sym} 111100 -19910 0 0 {name=p110421 lab=_62721_/X }
C {devices/lab_pin.sym} 111100 -19870 0 0 {name=p110422 lab=_62735_/Y }
C {devices/lab_pin.sym} 111260 -19910 0 1 {name=p110423 lab=_84387_/D }
C {sky130_stdcells/a21oi_4.sym} 111180 -19910 0 0 {name=X_62736_ }
C {devices/lab_pin.sym} 111090 -19770 0 0 {name=p110424 lab=_81346_/CLK }
C {devices/lab_pin.sym} 111090 -19750 0 0 {name=p110425 lab=_65901_/C }
C {devices/lab_pin.sym} 111270 -19770 0 1 {name=p110426 lab=_81570_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -19760 0 0 {name=X_81570_ }
C {devices/lab_pin.sym} 111100 -19660 0 0 {name=p110427 lab=_87028_/Q }
C {devices/lab_pin.sym} 111100 -19620 0 0 {name=p110428 lab=_69277_/X }
C {devices/lab_pin.sym} 111100 -19580 0 0 {name=p110429 lab=_69278_/X }
C {devices/lab_pin.sym} 111100 -19540 0 0 {name=p110430 lab=_69291_/X }
C {devices/lab_pin.sym} 111260 -19600 0 1 {name=p110431 lab=_69292_/X }
C {sky130_stdcells/a211o_4.sym} 111180 -19600 0 0 {name=X_69292_ }
C {devices/lab_pin.sym} 111100 -19470 0 0 {name=p110432 lab=_49404_/Y }
C {devices/lab_pin.sym} 111100 -19430 0 0 {name=p110433 lab=_49405_/X }
C {devices/lab_pin.sym} 111100 -19390 0 0 {name=p110434 lab=_49408_/X }
C {devices/lab_pin.sym} 111260 -19430 0 1 {name=p110435 lab=_86393_/D }
C {sky130_stdcells/a21oi_4.sym} 111180 -19430 0 0 {name=X_49409_ }
C {devices/lab_pin.sym} 111140 -19290 0 0 {name=p110436 lab=clkbuf_8_85_0_CLK/X }
C {devices/lab_pin.sym} 111220 -19290 0 1 {name=p110437 lab=clkbuf_9_171_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 111180 -19290 0 0 {name=Xclkbuf_9_171_0_CLK }
C {devices/lab_pin.sym} 111100 -19190 0 0 {name=p110438 lab=_80512_/Y }
C {devices/lab_pin.sym} 111100 -19150 0 0 {name=p110439 lab=_80513_/A }
C {devices/lab_pin.sym} 111100 -19110 0 0 {name=p110440 lab=_80520_/X }
C {devices/lab_pin.sym} 111260 -19150 0 1 {name=p110441 lab=_80522_/B }
C {sky130_stdcells/a21boi_4.sym} 111180 -19150 0 0 {name=X_80521_ }
C {devices/lab_pin.sym} 111100 -19030 0 0 {name=p110442 lab=_67515_/X }
C {devices/lab_pin.sym} 111100 -18990 0 0 {name=p110443 lab=_67518_/X }
C {devices/lab_pin.sym} 111100 -18950 0 0 {name=p110444 lab=_68239_/X }
C {devices/lab_pin.sym} 111260 -18990 0 1 {name=p110445 lab=_68243_/Y }
C {sky130_stdcells/a21oi_4.sym} 111180 -18990 0 0 {name=X_68243_ }
C {devices/lab_pin.sym} 111120 -18860 0 0 {name=p110446 lab=_65592_/A }
C {devices/lab_pin.sym} 111120 -18820 0 0 {name=p110447 lab=_65455_/B }
C {devices/lab_pin.sym} 111240 -18840 0 1 {name=p110448 lab=_65455_/X }
C {sky130_stdcells/and2_4.sym} 111180 -18840 0 0 {name=X_65455_ }
C {devices/lab_pin.sym} 111140 -18710 0 0 {name=p110449 lab=_50596_/A }
C {devices/lab_pin.sym} 111220 -18710 0 1 {name=p110450 lab=_50682_/A }
C {sky130_stdcells/buf_2.sym} 111180 -18710 0 0 {name=X_50681_ }
C {devices/lab_pin.sym} 111140 -18590 0 0 {name=p110451 lab=_60360_/X }
C {devices/lab_pin.sym} 111220 -18590 0 1 {name=p110452 lab=_62667_/X }
C {sky130_stdcells/buf_2.sym} 111180 -18590 0 0 {name=X_62667_ }
C {devices/lab_pin.sym} 111120 -18490 0 0 {name=p110453 lab=_50209_/A }
C {devices/lab_pin.sym} 111120 -18450 0 0 {name=p110454 lab=_52446_/B }
C {devices/lab_pin.sym} 111120 -18410 0 0 {name=p110455 lab=_52369_/X }
C {devices/lab_pin.sym} 111240 -18450 0 1 {name=p110456 lab=_52420_/X }
C {sky130_stdcells/and3_4.sym} 111180 -18450 0 0 {name=X_52420_ }
C {devices/lab_pin.sym} 111100 -18350 0 0 {name=p110457 lab=_64400_/Y }
C {devices/lab_pin.sym} 111100 -18310 0 0 {name=p110458 lab=_64401_/X }
C {devices/lab_pin.sym} 111100 -18270 0 0 {name=p110459 lab=_64403_/X }
C {devices/lab_pin.sym} 111100 -18230 0 0 {name=p110460 lab=_64405_/Y }
C {devices/lab_pin.sym} 111100 -18190 0 0 {name=p110461 lab=_64384_/X }
C {devices/lab_pin.sym} 111260 -18270 0 1 {name=p110462 lab=_64406_/X }
C {sky130_stdcells/o41a_4.sym} 111180 -18270 0 0 {name=X_64406_ }
C {devices/lab_pin.sym} 111090 -18110 0 0 {name=p110463 lab=_83229_/CLK }
C {devices/lab_pin.sym} 111090 -18090 0 0 {name=p110464 lab=_72521_/X }
C {devices/lab_pin.sym} 111270 -18110 0 1 {name=p110465 lab=_79502_/B }
C {sky130_stdcells/dfxtp_4.sym} 111180 -18100 0 0 {name=X_83240_ }
C {devices/lab_pin.sym} 111140 -17970 0 0 {name=p110466 lab=_59423_/A }
C {devices/lab_pin.sym} 111220 -17970 0 1 {name=p110467 lab=_61618_/X }
C {sky130_stdcells/buf_2.sym} 111180 -17970 0 0 {name=X_61618_ }
C {devices/lab_pin.sym} 111120 -17860 0 0 {name=p110468 lab=_80452_/A }
C {devices/lab_pin.sym} 111120 -17820 0 0 {name=p110469 lab=_80452_/B }
C {devices/lab_pin.sym} 111240 -17840 0 1 {name=p110470 lab=_80452_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -17840 0 0 {name=X_80452_ }
C {devices/lab_pin.sym} 111100 -17730 0 0 {name=p110471 lab=_67086_/X }
C {devices/lab_pin.sym} 111100 -17690 0 0 {name=p110472 lab=_67088_/X }
C {devices/lab_pin.sym} 111100 -17650 0 0 {name=p110473 lab=_68173_/X }
C {devices/lab_pin.sym} 111260 -17690 0 1 {name=p110474 lab=_68174_/Y }
C {sky130_stdcells/a21oi_4.sym} 111180 -17690 0 0 {name=X_68174_ }
C {devices/lab_pin.sym} 111140 -17550 0 0 {name=p110475 lab=_64725_/A }
C {devices/lab_pin.sym} 111220 -17550 0 1 {name=p110476 lab=_65387_/A }
C {sky130_stdcells/buf_2.sym} 111180 -17550 0 0 {name=X_65386_ }
C {devices/lab_pin.sym} 111120 -17450 0 0 {name=p110477 lab=_62620_/A }
C {devices/lab_pin.sym} 111120 -17410 0 0 {name=p110478 lab=_58296_/A }
C {devices/lab_pin.sym} 111120 -17370 0 0 {name=p110479 lab=_62532_/X }
C {devices/lab_pin.sym} 111240 -17410 0 1 {name=p110480 lab=_62600_/C }
C {sky130_stdcells/nand3_4.sym} 111180 -17410 0 0 {name=X_62598_ }
C {devices/lab_pin.sym} 111140 -17270 0 0 {name=p110481 lab=clkbuf_9_347_0_CLK/X }
