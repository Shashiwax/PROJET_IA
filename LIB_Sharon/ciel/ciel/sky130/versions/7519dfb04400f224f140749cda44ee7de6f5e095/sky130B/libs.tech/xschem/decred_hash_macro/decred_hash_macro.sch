C {devices/lab_pin.sym} 80760 -39940 0 0 {name=p79833 lab=_61354_/B }
C {devices/lab_pin.sym} 80760 -39900 0 0 {name=p79834 lab=_61795_/B }
C {devices/lab_pin.sym} 80760 -39860 0 0 {name=p79835 lab=_61761_/C }
C {devices/lab_pin.sym} 80760 -39820 0 0 {name=p79836 lab=_62130_/D }
C {devices/lab_pin.sym} 80880 -39880 0 1 {name=p79837 lab=_61761_/Y }
C {sky130_stdcells/nand4_4.sym} 80820 -39880 0 0 {name=X_61761_ }
C {devices/lab_pin.sym} 80760 -39750 0 0 {name=p79838 lab=_73745_/X }
C {devices/lab_pin.sym} 80760 -39710 0 0 {name=p79839 lab=_73727_/X }
C {devices/lab_pin.sym} 80760 -39670 0 0 {name=p79840 lab=_73730_/X }
C {devices/lab_pin.sym} 80880 -39710 0 1 {name=p79841 lab=_73747_/Y }
C {sky130_stdcells/nand3_4.sym} 80820 -39710 0 0 {name=X_73747_ }
C {devices/lab_pin.sym} 80740 -39590 0 0 {name=p79842 lab=_58672_/A }
C {devices/lab_pin.sym} 80740 -39550 0 0 {name=p79843 lab=_46672_/X }
C {devices/lab_pin.sym} 80740 -39510 0 0 {name=p79844 lab=_46694_/Y }
C {devices/lab_pin.sym} 80900 -39550 0 1 {name=p79845 lab=_46695_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -39550 0 0 {name=X_46695_ }
C {devices/lab_pin.sym} 80760 -39440 0 0 {name=p79846 lab=_70506_/A }
C {devices/lab_pin.sym} 80760 -39400 0 0 {name=p79847 lab=_70959_/B }
C {devices/lab_pin.sym} 80760 -39360 0 0 {name=p79848 lab=_70959_/C }
C {devices/lab_pin.sym} 80760 -39320 0 0 {name=p79849 lab=_71115_/B }
C {devices/lab_pin.sym} 80880 -39380 0 1 {name=p79850 lab=_70959_/X }
C {sky130_stdcells/and4_4.sym} 80820 -39380 0 0 {name=X_70959_ }
C {devices/lab_pin.sym} 80760 -39240 0 0 {name=p79851 lab=_63488_/A }
C {devices/lab_pin.sym} 80760 -39200 0 0 {name=p79852 lab=_61909_/X }
C {devices/lab_pin.sym} 80880 -39220 0 1 {name=p79853 lab=_63500_/X }
C {sky130_stdcells/and2_4.sym} 80820 -39220 0 0 {name=X_63500_ }
C {devices/lab_pin.sym} 80780 -39090 0 0 {name=p79854 lab=_53651_/B }
C {devices/lab_pin.sym} 80860 -39090 0 1 {name=p79855 lab=_48435_/B }
C {sky130_stdcells/buf_2.sym} 80820 -39090 0 0 {name=X_48434_ }
C {devices/lab_pin.sym} 80760 -38990 0 0 {name=p79856 lab=_60722_/A }
C {devices/lab_pin.sym} 80760 -38950 0 0 {name=p79857 lab=_60712_/B }
C {devices/lab_pin.sym} 80760 -38910 0 0 {name=p79858 lab=_60711_/X }
C {devices/lab_pin.sym} 80880 -38950 0 1 {name=p79859 lab=_60820_/A }
C {sky130_stdcells/nand3_4.sym} 80820 -38950 0 0 {name=X_60712_ }
C {devices/lab_pin.sym} 80760 -38820 0 0 {name=p79860 lab=_79250_/Y }
C {devices/lab_pin.sym} 80760 -38780 0 0 {name=p79861 lab=_79253_/Y }
C {devices/lab_pin.sym} 80880 -38800 0 1 {name=p79862 lab=_82824_/D }
C {sky130_stdcells/xor2_4.sym} 80820 -38800 0 0 {name=X_79254_ }
C {devices/lab_pin.sym} 80740 -38700 0 0 {name=p79863 lab=_45643_/Y }
C {devices/lab_pin.sym} 80740 -38660 0 0 {name=p79864 lab=_45627_/X }
C {devices/lab_pin.sym} 80740 -38620 0 0 {name=p79865 lab=_45644_/X }
C {devices/lab_pin.sym} 80740 -38580 0 0 {name=p79866 lab=_45645_/Y }
C {devices/lab_pin.sym} 80900 -38640 0 1 {name=p79867 lab=_45646_/X }
C {sky130_stdcells/a211o_4.sym} 80820 -38640 0 0 {name=X_45646_ }
C {devices/lab_pin.sym} 80740 -38530 0 0 {name=p79868 lab=_64473_/Y }
C {devices/lab_pin.sym} 80740 -38490 0 0 {name=p79869 lab=_64477_/Y }
C {devices/lab_pin.sym} 80740 -38450 0 0 {name=p79870 lab=_64479_/Y }
C {devices/lab_pin.sym} 80740 -38410 0 0 {name=p79871 lab=_58465_/A }
C {devices/lab_pin.sym} 80740 -38370 0 0 {name=p79872 lab=_64213_/X }
C {devices/lab_pin.sym} 80900 -38450 0 1 {name=p79873 lab=_64480_/Y }
C {sky130_stdcells/o32ai_4.sym} 80820 -38450 0 0 {name=X_64480_ }
C {devices/lab_pin.sym} 80740 -38310 0 0 {name=p79874 lab=_76429_/A }
C {devices/lab_pin.sym} 80740 -38270 0 0 {name=p79875 lab=_76430_/X }
C {devices/lab_pin.sym} 80740 -38230 0 0 {name=p79876 lab=_76440_/X }
C {devices/lab_pin.sym} 80900 -38270 0 1 {name=p79877 lab=_76482_/A }
C {sky130_stdcells/a21o_4.sym} 80820 -38270 0 0 {name=X_76466_ }
C {devices/lab_pin.sym} 80780 -38130 0 0 {name=p79878 lab=_42835_/X }
C {devices/lab_pin.sym} 80860 -38130 0 1 {name=p79879 lab=_42858_/X }
C {sky130_stdcells/buf_2.sym} 80820 -38130 0 0 {name=X_42858_ }
C {devices/lab_pin.sym} 80760 -38030 0 0 {name=p79880 lab=_61305_/A }
C {devices/lab_pin.sym} 80760 -37990 0 0 {name=p79881 lab=_61692_/B }
C {devices/lab_pin.sym} 80760 -37950 0 0 {name=p79882 lab=_61682_/C }
C {devices/lab_pin.sym} 80880 -37990 0 1 {name=p79883 lab=_61692_/Y }
C {sky130_stdcells/nand3_4.sym} 80820 -37990 0 0 {name=X_61692_ }
C {devices/lab_pin.sym} 80740 -37880 0 0 {name=p79884 lab=_68495_/B }
C {devices/lab_pin.sym} 80740 -37840 0 0 {name=p79885 lab=_73597_/X }
C {devices/lab_pin.sym} 80740 -37800 0 0 {name=p79886 lab=_73652_/X }
C {devices/lab_pin.sym} 80740 -37760 0 0 {name=p79887 lab=_73677_/Y }
C {devices/lab_pin.sym} 80900 -37820 0 1 {name=p79888 lab=_73678_/X }
C {sky130_stdcells/a211o_4.sym} 80820 -37820 0 0 {name=X_73678_ }
C {devices/lab_pin.sym} 80760 -37680 0 0 {name=p79889 lab=_78205_/A }
C {devices/lab_pin.sym} 80760 -37640 0 0 {name=p79890 lab=_78205_/B }
C {devices/lab_pin.sym} 80880 -37660 0 1 {name=p79891 lab=_78209_/A }
C {sky130_stdcells/nand2_4.sym} 80820 -37660 0 0 {name=X_78205_ }
C {devices/lab_pin.sym} 80740 -37570 0 0 {name=p79892 lab=_63368_/X }
C {devices/lab_pin.sym} 80740 -37530 0 0 {name=p79893 lab=_63424_/X }
C {devices/lab_pin.sym} 80740 -37490 0 0 {name=p79894 lab=_63425_/X }
C {devices/lab_pin.sym} 80740 -37450 0 0 {name=p79895 lab=_63429_/X }
C {devices/lab_pin.sym} 80740 -37410 0 0 {name=p79896 lab=_63430_/Y }
C {devices/lab_pin.sym} 80900 -37490 0 1 {name=p79897 lab=_63431_/Y }
C {sky130_stdcells/o41ai_4.sym} 80820 -37490 0 0 {name=X_63431_ }
C {devices/lab_pin.sym} 80740 -37350 0 0 {name=p79898 lab=_75413_/X }
C {devices/lab_pin.sym} 80740 -37310 0 0 {name=p79899 lab=_75414_/Y }
C {devices/lab_pin.sym} 80740 -37270 0 0 {name=p79900 lab=_75416_/Y }
C {devices/lab_pin.sym} 80900 -37310 0 1 {name=p79901 lab=_75435_/B }
C {sky130_stdcells/a21o_4.sym} 80820 -37310 0 0 {name=X_75417_ }
C {devices/lab_pin.sym} 80780 -37170 0 0 {name=p79902 lab=_41808_/Y }
C {devices/lab_pin.sym} 80860 -37170 0 1 {name=p79903 lab=_88142_/D }
C {sky130_stdcells/inv_2.sym} 80820 -37170 0 0 {name=X_41809_ }
C {devices/lab_pin.sym} 80740 -37070 0 0 {name=p79904 lab=_59877_/X }
C {devices/lab_pin.sym} 80740 -37030 0 0 {name=p79905 lab=_59705_/X }
C {devices/lab_pin.sym} 80740 -36990 0 0 {name=p79906 lab=_60298_/C }
C {devices/lab_pin.sym} 80900 -37030 0 1 {name=p79907 lab=_60644_/C }
C {sky130_stdcells/a21boi_4.sym} 80820 -37030 0 0 {name=X_60643_ }
C {devices/lab_pin.sym} 80760 -36910 0 0 {name=p79908 lab=_53620_/A }
C {devices/lab_pin.sym} 80760 -36870 0 0 {name=p79909 lab=_48364_/X }
C {devices/lab_pin.sym} 80760 -36830 0 0 {name=p79910 lab=_48354_/X }
C {devices/lab_pin.sym} 80880 -36870 0 1 {name=p79911 lab=_48365_/X }
C {sky130_stdcells/and3_4.sym} 80820 -36870 0 0 {name=X_48365_ }
C {devices/lab_pin.sym} 80740 -36770 0 0 {name=p79912 lab=_72537_/Y }
C {devices/lab_pin.sym} 80740 -36730 0 0 {name=p79913 lab=_60123_/Y }
C {devices/lab_pin.sym} 80740 -36690 0 0 {name=p79914 lab=_72579_/Y }
C {devices/lab_pin.sym} 80740 -36650 0 0 {name=p79915 lab=_79158_/A }
C {devices/lab_pin.sym} 80740 -36610 0 0 {name=p79916 lab=_59868_/X }
C {devices/lab_pin.sym} 80900 -36690 0 1 {name=p79917 lab=_72629_/Y }
C {sky130_stdcells/a32oi_4.sym} 80820 -36690 0 0 {name=X_72629_ }
C {devices/lab_pin.sym} 80760 -36550 0 0 {name=p79918 lab=_79185_/A }
C {devices/lab_pin.sym} 80760 -36510 0 0 {name=p79919 lab=_79185_/B }
C {devices/lab_pin.sym} 80760 -36470 0 0 {name=p79920 lab=_79185_/C }
C {devices/lab_pin.sym} 80880 -36510 0 1 {name=p79921 lab=_79188_/A }
C {sky130_stdcells/nand3_4.sym} 80820 -36510 0 0 {name=X_79185_ }
C {devices/lab_pin.sym} 80740 -36390 0 0 {name=p79922 lab=_45575_/Y }
C {devices/lab_pin.sym} 80740 -36350 0 0 {name=p79923 lab=_45576_/Y }
C {devices/lab_pin.sym} 80740 -36310 0 0 {name=p79924 lab=_44939_/B }
C {devices/lab_pin.sym} 80900 -36350 0 1 {name=p79925 lab=_45577_/X }
C {sky130_stdcells/o21a_4.sym} 80820 -36350 0 0 {name=X_45577_ }
C {devices/lab_pin.sym} 80760 -36220 0 0 {name=p79926 lab=_76392_/Y }
C {devices/lab_pin.sym} 80760 -36180 0 0 {name=p79927 lab=_76394_/Y }
C {devices/lab_pin.sym} 80880 -36200 0 1 {name=p79928 lab=_76398_/A }
C {sky130_stdcells/nor2_4.sym} 80820 -36200 0 0 {name=X_76397_ }
C {devices/lab_pin.sym} 80740 -36100 0 0 {name=p79929 lab=_41356_/X }
C {devices/lab_pin.sym} 80740 -36060 0 0 {name=p79930 lab=_42787_/X }
C {devices/lab_pin.sym} 80740 -36020 0 0 {name=p79931 lab=_87718_/Q }
C {devices/lab_pin.sym} 80740 -35980 0 0 {name=p79932 lab=_42788_/X }
C {devices/lab_pin.sym} 80900 -36040 0 1 {name=p79933 lab=_42789_/X }
C {sky130_stdcells/a2bb2o_4.sym} 80820 -36040 0 0 {name=X_42789_ }
C {devices/lab_pin.sym} 80740 -35910 0 0 {name=p79934 lab=_86647_/Q }
C {devices/lab_pin.sym} 80740 -35870 0 0 {name=p79935 lab=_47286_/X }
C {devices/lab_pin.sym} 80740 -35830 0 0 {name=p79936 lab=_47315_/Y }
C {devices/lab_pin.sym} 80900 -35870 0 1 {name=p79937 lab=_47316_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -35870 0 0 {name=X_47316_ }
C {devices/lab_pin.sym} 80780 -35730 0 0 {name=p79938 lab=_66003_/A }
C {devices/lab_pin.sym} 80860 -35730 0 1 {name=p79939 lab=_66151_/B }
C {sky130_stdcells/buf_2.sym} 80820 -35730 0 0 {name=X_66150_ }
C {devices/lab_pin.sym} 80740 -35630 0 0 {name=p79940 lab=_78120_/C }
C {devices/lab_pin.sym} 80740 -35590 0 0 {name=p79941 lab=_78132_/Y }
C {devices/lab_pin.sym} 80740 -35550 0 0 {name=p79942 lab=_78135_/Y }
C {devices/lab_pin.sym} 80900 -35590 0 1 {name=p79943 lab=_78136_/X }
C {sky130_stdcells/o21a_4.sym} 80820 -35590 0 0 {name=X_78136_ }
C {devices/lab_pin.sym} 80780 -35450 0 0 {name=p79944 lab=_44528_/A }
C {devices/lab_pin.sym} 80860 -35450 0 1 {name=p79945 lab=_44529_/A }
C {sky130_stdcells/buf_2.sym} 80820 -35450 0 0 {name=X_44528_ }
C {devices/lab_pin.sym} 80780 -35330 0 0 {name=p79946 lab=_63357_/X }
C {devices/lab_pin.sym} 80860 -35330 0 1 {name=p79947 lab=_63363_/A }
C {sky130_stdcells/inv_2.sym} 80820 -35330 0 0 {name=X_63362_ }
C {devices/lab_pin.sym} 80780 -35210 0 0 {name=p79948 lab=_75348_/A }
C {devices/lab_pin.sym} 80860 -35210 0 1 {name=p79949 lab=_75348_/Y }
C {sky130_stdcells/inv_2.sym} 80820 -35210 0 0 {name=X_75348_ }
C {devices/lab_pin.sym} 80740 -35110 0 0 {name=p79950 lab=_66214_/B }
C {devices/lab_pin.sym} 80740 -35070 0 0 {name=p79951 lab=_48293_/X }
C {devices/lab_pin.sym} 80740 -35030 0 0 {name=p79952 lab=_48295_/Y }
C {devices/lab_pin.sym} 80900 -35070 0 1 {name=p79953 lab=_48296_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -35070 0 0 {name=X_48296_ }
C {devices/lab_pin.sym} 80760 -34950 0 0 {name=p79954 lab=_60610_/A }
C {devices/lab_pin.sym} 80760 -34910 0 0 {name=p79955 lab=_60513_/B }
C {devices/lab_pin.sym} 80760 -34870 0 0 {name=p79956 lab=_79137_/A }
C {devices/lab_pin.sym} 80880 -34910 0 1 {name=p79957 lab=_60574_/X }
C {sky130_stdcells/or3_4.sym} 80820 -34910 0 0 {name=X_60574_ }
C {devices/lab_pin.sym} 80740 -34800 0 0 {name=p79958 lab=_65099_/X }
C {devices/lab_pin.sym} 80740 -34760 0 0 {name=p79959 lab=_83294_/Q }
C {devices/lab_pin.sym} 80740 -34720 0 0 {name=p79960 lab=_65028_/X }
C {devices/lab_pin.sym} 80740 -34680 0 0 {name=p79961 lab=_65100_/X }
C {devices/lab_pin.sym} 80900 -34740 0 1 {name=p79962 lab=_65102_/B }
C {sky130_stdcells/a211o_4.sym} 80820 -34740 0 0 {name=X_65101_ }
C {devices/lab_pin.sym} 80740 -34610 0 0 {name=p79963 lab=_62311_/Y }
C {devices/lab_pin.sym} 80740 -34570 0 0 {name=p79964 lab=_62253_/X }
C {devices/lab_pin.sym} 80740 -34530 0 0 {name=p79965 lab=_62312_/Y }
C {devices/lab_pin.sym} 80900 -34570 0 1 {name=p79966 lab=_84419_/D }
C {sky130_stdcells/a21oi_4.sym} 80820 -34570 0 0 {name=X_62313_ }
C {devices/lab_pin.sym} 80780 -34430 0 0 {name=p79967 lab=_81823_/Q }
C {devices/lab_pin.sym} 80860 -34430 0 1 {name=p79968 lab=_54630_/D }
C {sky130_stdcells/inv_2.sym} 80820 -34430 0 0 {name=X_47247_ }
C {devices/lab_pin.sym} 80760 -34330 0 0 {name=p79969 lab=_65615_/X }
C {devices/lab_pin.sym} 80760 -34290 0 0 {name=p79970 lab=_66195_/B }
C {devices/lab_pin.sym} 80760 -34250 0 0 {name=p79971 lab=_65617_/X }
C {devices/lab_pin.sym} 80880 -34290 0 1 {name=p79972 lab=_66081_/Y }
C {sky130_stdcells/nand3_4.sym} 80820 -34290 0 0 {name=X_66081_ }
C {devices/lab_pin.sym} 80760 -34160 0 0 {name=p79973 lab=_84572_/Q }
C {devices/lab_pin.sym} 80760 -34120 0 0 {name=p79974 lab=_78067_/B }
C {devices/lab_pin.sym} 80880 -34140 0 1 {name=p79975 lab=_78067_/X }
C {sky130_stdcells/xor2_4.sym} 80820 -34140 0 0 {name=X_78067_ }
C {devices/lab_pin.sym} 80740 -34040 0 0 {name=p79976 lab=_41133_/Y }
C {devices/lab_pin.sym} 80740 -34000 0 0 {name=p79977 lab=_44453_/X }
C {devices/lab_pin.sym} 80740 -33960 0 0 {name=p79978 lab=_87099_/Q }
C {devices/lab_pin.sym} 80740 -33920 0 0 {name=p79979 lab=_44454_/X }
C {devices/lab_pin.sym} 80900 -33980 0 1 {name=p79980 lab=_44459_/X }
C {sky130_stdcells/a2bb2o_4.sym} 80820 -33980 0 0 {name=X_44459_ }
C {devices/lab_pin.sym} 80740 -33870 0 0 {name=p79981 lab=_63287_/Y }
C {devices/lab_pin.sym} 80740 -33830 0 0 {name=p79982 lab=_63288_/X }
C {devices/lab_pin.sym} 80740 -33790 0 0 {name=p79983 lab=_63291_/X }
C {devices/lab_pin.sym} 80740 -33750 0 0 {name=p79984 lab=_63292_/X }
C {devices/lab_pin.sym} 80740 -33710 0 0 {name=p79985 lab=_63242_/X }
C {devices/lab_pin.sym} 80900 -33790 0 1 {name=p79986 lab=_63293_/Y }
C {sky130_stdcells/o41ai_4.sym} 80820 -33790 0 0 {name=X_63293_ }
C {devices/lab_pin.sym} 80760 -33640 0 0 {name=p79987 lab=_75241_/Y }
C {devices/lab_pin.sym} 80760 -33600 0 0 {name=p79988 lab=_75279_/B }
C {devices/lab_pin.sym} 80880 -33620 0 1 {name=p79989 lab=_75279_/Y }
C {sky130_stdcells/nor2_4.sym} 80820 -33620 0 0 {name=X_75279_ }
C {devices/lab_pin.sym} 80760 -33500 0 0 {name=p79990 lab=_64929_/A }
C {devices/lab_pin.sym} 80760 -33460 0 0 {name=p79991 lab=_65032_/B }
C {devices/lab_pin.sym} 80880 -33480 0 1 {name=p79992 lab=_65032_/X }
C {sky130_stdcells/and2_4.sym} 80820 -33480 0 0 {name=X_65032_ }
C {devices/lab_pin.sym} 80760 -33360 0 0 {name=p79993 lab=_77018_/A }
C {devices/lab_pin.sym} 80760 -33320 0 0 {name=p79994 lab=_82277_/D }
C {devices/lab_pin.sym} 80880 -33340 0 1 {name=p79995 lab=_77021_/A }
C {sky130_stdcells/xnor2_4.sym} 80820 -33340 0 0 {name=X_77018_ }
C {devices/lab_pin.sym} 80760 -33240 0 0 {name=p79996 lab=_62194_/A }
C {devices/lab_pin.sym} 80760 -33200 0 0 {name=p79997 lab=_58225_/X }
C {devices/lab_pin.sym} 80760 -33160 0 0 {name=p79998 lab=_62244_/C }
C {devices/lab_pin.sym} 80760 -33120 0 0 {name=p79999 lab=_62244_/D }
C {devices/lab_pin.sym} 80880 -33180 0 1 {name=p80000 lab=_62244_/X }
C {sky130_stdcells/and4_4.sym} 80820 -33180 0 0 {name=X_62244_ }
C {devices/lab_pin.sym} 80780 -33030 0 0 {name=p80001 lab=_47130_/A }
C {devices/lab_pin.sym} 80860 -33030 0 1 {name=p80002 lab=_47181_/B }
C {sky130_stdcells/buf_2.sym} 80820 -33030 0 0 {name=X_47178_ }
C {devices/lab_pin.sym} 80780 -32910 0 0 {name=p80003 lab=_46129_/A }
C {devices/lab_pin.sym} 80860 -32910 0 1 {name=p80004 lab=_46164_/A }
C {sky130_stdcells/buf_2.sym} 80820 -32910 0 0 {name=X_46129_ }
C {devices/lab_pin.sym} 80740 -32810 0 0 {name=p80005 lab=_69836_/X }
C {devices/lab_pin.sym} 80740 -32770 0 0 {name=p80006 lab=_69839_/X }
C {devices/lab_pin.sym} 80740 -32730 0 0 {name=p80007 lab=_69768_/X }
C {devices/lab_pin.sym} 80900 -32770 0 1 {name=p80008 lab=_69840_/X }
C {sky130_stdcells/a21o_4.sym} 80820 -32770 0 0 {name=X_69840_ }
C {devices/lab_pin.sym} 80760 -32660 0 0 {name=p80009 lab=_62174_/X }
C {devices/lab_pin.sym} 80760 -32620 0 0 {name=p80010 lab=_62175_/B }
C {devices/lab_pin.sym} 80760 -32580 0 0 {name=p80011 lab=_61761_/C }
C {devices/lab_pin.sym} 80760 -32540 0 0 {name=p80012 lab=_62060_/X }
C {devices/lab_pin.sym} 80880 -32600 0 1 {name=p80013 lab=_62175_/Y }
C {sky130_stdcells/nand4_4.sym} 80820 -32600 0 0 {name=X_62175_ }
C {devices/lab_pin.sym} 80780 -32450 0 0 {name=p80014 lab=_61188_/B }
C {devices/lab_pin.sym} 80860 -32450 0 1 {name=p80015 lab=_61254_/B }
C {sky130_stdcells/buf_2.sym} 80820 -32450 0 0 {name=X_61126_ }
C {devices/lab_pin.sym} 80740 -32360 0 0 {name=p80016 lab=_44556_/A }
C {devices/lab_pin.sym} 80740 -32320 0 0 {name=p80017 lab=_69664_/X }
C {devices/lab_pin.sym} 80740 -32280 0 0 {name=p80018 lab=_69665_/X }
C {devices/lab_pin.sym} 80740 -32240 0 0 {name=p80019 lab=_69770_/X }
C {devices/lab_pin.sym} 80900 -32300 0 1 {name=p80020 lab=_69772_/B }
C {sky130_stdcells/a211o_4.sym} 80820 -32300 0 0 {name=X_69771_ }
C {devices/lab_pin.sym} 80780 -32150 0 0 {name=p80021 lab=clkbuf_7_61_0_CLK/A }
C {devices/lab_pin.sym} 80860 -32150 0 1 {name=p80022 lab=clkbuf_7_60_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 80820 -32150 0 0 {name=Xclkbuf_7_60_0_CLK }
C {devices/lab_pin.sym} 80740 -32060 0 0 {name=p80023 lab=_87938_/Q }
C {devices/lab_pin.sym} 80740 -32020 0 0 {name=p80024 lab=_66935_/X }
C {devices/lab_pin.sym} 80740 -31980 0 0 {name=p80025 lab=_66911_/X }
C {devices/lab_pin.sym} 80740 -31940 0 0 {name=p80026 lab=_66982_/X }
C {devices/lab_pin.sym} 80900 -32000 0 1 {name=p80027 lab=_66983_/X }
C {sky130_stdcells/a211o_4.sym} 80820 -32000 0 0 {name=X_66983_ }
C {devices/lab_pin.sym} 80780 -31850 0 0 {name=p80028 lab=_78969_/A }
C {devices/lab_pin.sym} 80860 -31850 0 1 {name=p80029 lab=_78979_/A }
C {sky130_stdcells/inv_2.sym} 80820 -31850 0 0 {name=X_78969_ }
C {devices/lab_pin.sym} 80780 -31730 0 0 {name=p80030 lab=_69956_/A }
C {devices/lab_pin.sym} 80860 -31730 0 1 {name=p80031 lab=_68938_/A }
C {sky130_stdcells/buf_2.sym} 80820 -31730 0 0 {name=X_68722_ }
C {devices/lab_pin.sym} 80780 -31610 0 0 {name=p80032 lab=_65158_/A }
C {devices/lab_pin.sym} 80860 -31610 0 1 {name=p80033 lab=_65934_/X }
C {sky130_stdcells/buf_2.sym} 80820 -31610 0 0 {name=X_65934_ }
C {devices/lab_pin.sym} 80760 -31510 0 0 {name=p80034 lab=_61055_/A }
C {devices/lab_pin.sym} 80760 -31470 0 0 {name=p80035 lab=_59771_/X }
C {devices/lab_pin.sym} 80760 -31430 0 0 {name=p80036 lab=_61057_/C }
C {devices/lab_pin.sym} 80880 -31470 0 1 {name=p80037 lab=_61057_/X }
C {sky130_stdcells/or3_4.sym} 80820 -31470 0 0 {name=X_61057_ }
C {devices/lab_pin.sym} 80730 -31330 0 0 {name=p80038 lab=_83905_/CLK }
C {devices/lab_pin.sym} 80730 -31310 0 0 {name=p80039 lab=_81980_/D }
C {devices/lab_pin.sym} 80910 -31330 0 1 {name=p80040 lab=_77814_/B }
C {sky130_stdcells/dfxtp_4.sym} 80820 -31320 0 0 {name=X_81980_ }
C {devices/lab_pin.sym} 80780 -31190 0 0 {name=p80041 lab=_59977_/A }
C {devices/lab_pin.sym} 80860 -31190 0 1 {name=p80042 lab=_60079_/B }
C {sky130_stdcells/buf_2.sym} 80820 -31190 0 0 {name=X_60008_ }
C {devices/lab_pin.sym} 80740 -31090 0 0 {name=p80043 lab=_49814_/Y }
C {devices/lab_pin.sym} 80740 -31050 0 0 {name=p80044 lab=_49815_/X }
C {devices/lab_pin.sym} 80740 -31010 0 0 {name=p80045 lab=_49818_/X }
C {devices/lab_pin.sym} 80900 -31050 0 1 {name=p80046 lab=_86318_/D }
C {sky130_stdcells/a21oi_4.sym} 80820 -31050 0 0 {name=X_49819_ }
C {devices/lab_pin.sym} 80740 -30940 0 0 {name=p80047 lab=_88008_/Q }
C {devices/lab_pin.sym} 80740 -30900 0 0 {name=p80048 lab=_68650_/X }
C {devices/lab_pin.sym} 80740 -30860 0 0 {name=p80049 lab=_68651_/X }
C {devices/lab_pin.sym} 80740 -30820 0 0 {name=p80050 lab=_68652_/X }
C {devices/lab_pin.sym} 80900 -30880 0 1 {name=p80051 lab=_68653_/X }
C {sky130_stdcells/a211o_4.sym} 80820 -30880 0 0 {name=X_68653_ }
C {devices/lab_pin.sym} 80730 -30730 0 0 {name=p80052 lab=_80931_/CLK }
C {devices/lab_pin.sym} 80730 -30710 0 0 {name=p80053 lab=_75082_/B }
C {devices/lab_pin.sym} 80910 -30730 0 1 {name=p80054 lab=_80931_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -30720 0 0 {name=X_80931_ }
C {devices/lab_pin.sym} 80780 -30590 0 0 {name=p80055 lab=_65768_/A }
C {devices/lab_pin.sym} 80860 -30590 0 1 {name=p80056 lab=_65865_/X }
C {sky130_stdcells/buf_2.sym} 80820 -30590 0 0 {name=X_65865_ }
C {devices/lab_pin.sym} 80740 -30500 0 0 {name=p80057 lab=_87912_/Q }
C {devices/lab_pin.sym} 80740 -30460 0 0 {name=p80058 lab=_67533_/X }
C {devices/lab_pin.sym} 80740 -30420 0 0 {name=p80059 lab=_67508_/X }
C {devices/lab_pin.sym} 80740 -30380 0 0 {name=p80060 lab=_67603_/X }
C {devices/lab_pin.sym} 80900 -30440 0 1 {name=p80061 lab=_67604_/X }
C {sky130_stdcells/a211o_4.sym} 80820 -30440 0 0 {name=X_67604_ }
C {devices/lab_pin.sym} 80740 -30310 0 0 {name=p80062 lab=_85747_/Q }
C {devices/lab_pin.sym} 80740 -30270 0 0 {name=p80063 lab=_52821_/X }
C {devices/lab_pin.sym} 80740 -30230 0 0 {name=p80064 lab=_52829_/Y }
C {devices/lab_pin.sym} 80900 -30270 0 1 {name=p80065 lab=_52830_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -30270 0 0 {name=X_52830_ }
C {devices/lab_pin.sym} 80740 -30150 0 0 {name=p80066 lab=_64813_/Y }
C {devices/lab_pin.sym} 80740 -30110 0 0 {name=p80067 lab=_64814_/X }
C {devices/lab_pin.sym} 80740 -30070 0 0 {name=p80068 lab=_64815_/X }
C {devices/lab_pin.sym} 80900 -30110 0 1 {name=p80069 lab=_84226_/D }
C {sky130_stdcells/a21o_4.sym} 80820 -30110 0 0 {name=X_64816_ }
C {devices/lab_pin.sym} 80780 -29970 0 0 {name=p80070 lab=clkbuf_7_74_0_CLK/A }
C {devices/lab_pin.sym} 80860 -29970 0 1 {name=p80071 lab=clkbuf_7_75_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 80820 -29970 0 0 {name=Xclkbuf_7_75_0_CLK }
C {devices/lab_pin.sym} 80730 -29850 0 0 {name=p80072 lab=_85529_/CLK }
C {devices/lab_pin.sym} 80730 -29830 0 0 {name=p80073 lab=_70958_/Y }
C {devices/lab_pin.sym} 80910 -29850 0 1 {name=p80074 lab=_83650_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -29840 0 0 {name=X_83650_ }
C {devices/lab_pin.sym} 80730 -29710 0 0 {name=p80075 lab=_80961_/CLK }
C {devices/lab_pin.sym} 80730 -29690 0 0 {name=p80076 lab=_80894_/Q }
C {devices/lab_pin.sym} 80910 -29710 0 1 {name=p80077 lab=_75046_/B }
C {sky130_stdcells/dfxtp_4.sym} 80820 -29700 0 0 {name=X_80862_ }
C {devices/lab_pin.sym} 80740 -29600 0 0 {name=p80078 lab=_68516_/X }
C {devices/lab_pin.sym} 80740 -29560 0 0 {name=p80079 lab=_68574_/Y }
C {devices/lab_pin.sym} 80740 -29520 0 0 {name=p80080 lab=_68447_/X }
C {devices/lab_pin.sym} 80740 -29480 0 0 {name=p80081 lab=_68583_/Y }
C {devices/lab_pin.sym} 80900 -29540 0 1 {name=p80082 lab=_68584_/X }
C {sky130_stdcells/a211o_4.sym} 80820 -29540 0 0 {name=X_68584_ }
C {devices/lab_pin.sym} 80740 -29410 0 0 {name=p80083 lab=_65793_/X }
C {devices/lab_pin.sym} 80740 -29370 0 0 {name=p80084 lab=_65795_/X }
C {devices/lab_pin.sym} 80740 -29330 0 0 {name=p80085 lab=_65566_/X }
C {devices/lab_pin.sym} 80900 -29370 0 1 {name=p80086 lab=_65796_/X }
C {sky130_stdcells/a21o_4.sym} 80820 -29370 0 0 {name=X_65796_ }
C {devices/lab_pin.sym} 80730 -29230 0 0 {name=p80087 lab=_82924_/CLK }
C {devices/lab_pin.sym} 80730 -29210 0 0 {name=p80088 lab=_78869_/B }
C {devices/lab_pin.sym} 80910 -29230 0 1 {name=p80089 lab=_82569_/D }
C {sky130_stdcells/dfxtp_4.sym} 80820 -29220 0 0 {name=X_82601_ }
C {devices/lab_pin.sym} 80740 -29120 0 0 {name=p80090 lab=_87915_/Q }
C {devices/lab_pin.sym} 80740 -29080 0 0 {name=p80091 lab=_67533_/X }
C {devices/lab_pin.sym} 80740 -29040 0 0 {name=p80092 lab=_67508_/X }
C {devices/lab_pin.sym} 80740 -29000 0 0 {name=p80093 lab=_67534_/X }
C {devices/lab_pin.sym} 80900 -29060 0 1 {name=p80094 lab=_67535_/X }
C {sky130_stdcells/a211o_4.sym} 80820 -29060 0 0 {name=X_67535_ }
C {devices/lab_pin.sym} 80740 -28930 0 0 {name=p80095 lab=_85759_/Q }
C {devices/lab_pin.sym} 80740 -28890 0 0 {name=p80096 lab=_52737_/X }
C {devices/lab_pin.sym} 80740 -28850 0 0 {name=p80097 lab=_52760_/Y }
C {devices/lab_pin.sym} 80900 -28890 0 1 {name=p80098 lab=_52761_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -28890 0 0 {name=X_52761_ }
C {devices/lab_pin.sym} 80740 -28770 0 0 {name=p80099 lab=_64744_/X }
C {devices/lab_pin.sym} 80740 -28730 0 0 {name=p80100 lab=_64746_/X }
C {devices/lab_pin.sym} 80740 -28690 0 0 {name=p80101 lab=_64629_/X }
C {devices/lab_pin.sym} 80900 -28730 0 1 {name=p80102 lab=_64747_/X }
C {sky130_stdcells/a21o_4.sym} 80820 -28730 0 0 {name=X_64747_ }
C {devices/lab_pin.sym} 80730 -28590 0 0 {name=p80103 lab=_83068_/CLK }
C {devices/lab_pin.sym} 80730 -28570 0 0 {name=p80104 lab=_71179_/Y }
C {devices/lab_pin.sym} 80910 -28590 0 1 {name=p80105 lab=_83581_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -28580 0 0 {name=X_83581_ }
C {devices/lab_pin.sym} 80780 -28450 0 0 {name=p80106 lab=_61645_/A }
C {devices/lab_pin.sym} 80860 -28450 0 1 {name=p80107 lab=_61959_/X }
C {sky130_stdcells/buf_2.sym} 80820 -28450 0 0 {name=X_61959_ }
C {devices/lab_pin.sym} 80730 -28330 0 0 {name=p80108 lab=_80968_/CLK }
C {devices/lab_pin.sym} 80730 -28310 0 0 {name=p80109 lab=_75789_/Y }
C {devices/lab_pin.sym} 80910 -28330 0 1 {name=p80110 lab=_80793_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -28320 0 0 {name=X_80793_ }
C {devices/lab_pin.sym} 80760 -28200 0 0 {name=p80111 lab=_54486_/X }
C {devices/lab_pin.sym} 80760 -28160 0 0 {name=p80112 lab=_47023_/Y }
C {devices/lab_pin.sym} 80880 -28180 0 1 {name=p80113 lab=_54500_/Y }
C {sky130_stdcells/nand2_4.sym} 80820 -28180 0 0 {name=X_54500_ }
C {devices/lab_pin.sym} 80730 -28050 0 0 {name=p80114 lab=_85351_/CLK }
C {devices/lab_pin.sym} 80730 -28030 0 0 {name=p80115 lab=_85320_/D }
C {devices/lab_pin.sym} 80910 -28050 0 1 {name=p80116 lab=_85320_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -28040 0 0 {name=X_85320_ }
C {devices/lab_pin.sym} 80760 -27920 0 0 {name=p80117 lab=_51717_/A }
C {devices/lab_pin.sym} 80760 -27880 0 0 {name=p80118 lab=_53236_/B }
C {devices/lab_pin.sym} 80880 -27900 0 1 {name=p80119 lab=_51712_/Y }
C {sky130_stdcells/nand2_4.sym} 80820 -27900 0 0 {name=X_51712_ }
C {devices/lab_pin.sym} 80730 -27770 0 0 {name=p80120 lab=_82532_/CLK }
C {devices/lab_pin.sym} 80730 -27750 0 0 {name=p80121 lab=_83852_/Q }
C {devices/lab_pin.sym} 80910 -27770 0 1 {name=p80122 lab=_82532_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -27760 0 0 {name=X_82532_ }
C {devices/lab_pin.sym} 80780 -27630 0 0 {name=p80123 lab=_85074_/Q }
C {devices/lab_pin.sym} 80860 -27630 0 1 {name=p80124 lab=_55481_/B }
C {sky130_stdcells/inv_2.sym} 80820 -27630 0 0 {name=X_55480_ }
C {devices/lab_pin.sym} 80780 -27510 0 0 {name=p80125 lab=_69751_/A }
C {devices/lab_pin.sym} 80860 -27510 0 1 {name=p80126 lab=_67466_/X }
C {sky130_stdcells/buf_2.sym} 80820 -27510 0 0 {name=X_67466_ }
C {devices/lab_pin.sym} 80760 -27400 0 0 {name=p80127 lab=_52706_/A }
C {devices/lab_pin.sym} 80760 -27360 0 0 {name=p80128 lab=_52692_/B }
C {devices/lab_pin.sym} 80880 -27380 0 1 {name=p80129 lab=_52692_/Y }
C {sky130_stdcells/nand2_4.sym} 80820 -27380 0 0 {name=X_52692_ }
C {devices/lab_pin.sym} 80780 -27250 0 0 {name=p80130 lab=_64678_/A }
C {devices/lab_pin.sym} 80860 -27250 0 1 {name=p80131 lab=_64678_/X }
C {sky130_stdcells/buf_2.sym} 80820 -27250 0 0 {name=X_64678_ }
C {devices/lab_pin.sym} 80780 -27130 0 0 {name=p80132 lab=_68384_/A }
C {devices/lab_pin.sym} 80860 -27130 0 1 {name=p80133 lab=_69205_/X }
C {sky130_stdcells/buf_2.sym} 80820 -27130 0 0 {name=X_69205_ }
C {devices/lab_pin.sym} 80780 -27010 0 0 {name=p80134 lab=_54376_/A }
C {devices/lab_pin.sym} 80860 -27010 0 1 {name=p80135 lab=_54431_/X }
C {sky130_stdcells/buf_2.sym} 80820 -27010 0 0 {name=X_54431_ }
C {devices/lab_pin.sym} 80760 -26910 0 0 {name=p80136 lab=_64876_/X }
C {devices/lab_pin.sym} 80760 -26870 0 0 {name=p80137 lab=_66417_/B }
C {devices/lab_pin.sym} 80760 -26830 0 0 {name=p80138 lab=_64879_/X }
C {devices/lab_pin.sym} 80880 -26870 0 1 {name=p80139 lab=_66417_/Y }
C {sky130_stdcells/nand3_4.sym} 80820 -26870 0 0 {name=X_66417_ }
C {devices/lab_pin.sym} 80730 -26730 0 0 {name=p80140 lab=_85186_/CLK }
C {devices/lab_pin.sym} 80730 -26710 0 0 {name=p80141 lab=_56271_/Y }
C {devices/lab_pin.sym} 80910 -26730 0 1 {name=p80142 lab=_56270_/C }
C {sky130_stdcells/dfxtp_4.sym} 80820 -26720 0 0 {name=X_85251_ }
C {devices/lab_pin.sym} 80760 -26600 0 0 {name=p80143 lab=_51627_/A }
C {devices/lab_pin.sym} 80760 -26560 0 0 {name=p80144 lab=_53167_/B }
C {devices/lab_pin.sym} 80880 -26580 0 1 {name=p80145 lab=_51643_/Y }
C {sky130_stdcells/nand2_4.sym} 80820 -26580 0 0 {name=X_51643_ }
C {devices/lab_pin.sym} 80760 -26460 0 0 {name=p80146 lab=_63657_/A }
C {devices/lab_pin.sym} 80760 -26420 0 0 {name=p80147 lab=_63629_/B }
C {devices/lab_pin.sym} 80880 -26440 0 1 {name=p80148 lab=_63629_/X }
C {sky130_stdcells/and2_4.sym} 80820 -26440 0 0 {name=X_63629_ }
C {devices/lab_pin.sym} 80730 -26310 0 0 {name=p80149 lab=_82463_/CLK }
C {devices/lab_pin.sym} 80730 -26290 0 0 {name=p80150 lab=_79155_/X }
C {devices/lab_pin.sym} 80910 -26310 0 1 {name=p80151 lab=_82463_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -26300 0 0 {name=X_82463_ }
C {devices/lab_pin.sym} 80740 -26190 0 0 {name=p80152 lab=_67393_/X }
C {devices/lab_pin.sym} 80740 -26150 0 0 {name=p80153 lab=_67396_/X }
C {devices/lab_pin.sym} 80740 -26110 0 0 {name=p80154 lab=_67322_/X }
C {devices/lab_pin.sym} 80900 -26150 0 1 {name=p80155 lab=_67397_/X }
C {sky130_stdcells/a21o_4.sym} 80820 -26150 0 0 {name=X_67397_ }
C {devices/lab_pin.sym} 80730 -26010 0 0 {name=p80156 lab=_85315_/CLK }
C {devices/lab_pin.sym} 80730 -25990 0 0 {name=p80157 lab=_84202_/D }
C {devices/lab_pin.sym} 80910 -26010 0 1 {name=p80158 lab=_65421_/C }
C {sky130_stdcells/dfxtp_4.sym} 80820 -26000 0 0 {name=X_84202_ }
C {devices/lab_pin.sym} 80740 -25890 0 0 {name=p80159 lab=_57149_/X }
C {devices/lab_pin.sym} 80740 -25850 0 0 {name=p80160 lab=_57141_/X }
C {devices/lab_pin.sym} 80740 -25810 0 0 {name=p80161 lab=_58981_/A }
C {devices/lab_pin.sym} 80900 -25850 0 1 {name=p80162 lab=_57150_/Y }
C {sky130_stdcells/a21oi_4.sym} 80820 -25850 0 0 {name=X_57150_ }
C {devices/lab_pin.sym} 80730 -25710 0 0 {name=p80163 lab=_82053_/CLK }
C {devices/lab_pin.sym} 80730 -25690 0 0 {name=p80164 lab=_81446_/Q }
C {devices/lab_pin.sym} 80910 -25710 0 1 {name=p80165 lab=_75952_/B }
C {sky130_stdcells/dfxtp_4.sym} 80820 -25700 0 0 {name=X_81414_ }
C {devices/lab_pin.sym} 80760 -25580 0 0 {name=p80166 lab=_69236_/A }
C {devices/lab_pin.sym} 80760 -25540 0 0 {name=p80167 lab=_87283_/Q }
C {devices/lab_pin.sym} 80880 -25560 0 1 {name=p80168 lab=_69136_/X }
C {sky130_stdcells/and2_4.sym} 80820 -25560 0 0 {name=X_69136_ }
C {devices/lab_pin.sym} 80760 -25460 0 0 {name=p80169 lab=_54362_/A }
C {devices/lab_pin.sym} 80760 -25420 0 0 {name=p80170 lab=_54362_/B }
C {devices/lab_pin.sym} 80760 -25380 0 0 {name=p80171 lab=_54362_/C }
C {devices/lab_pin.sym} 80760 -25340 0 0 {name=p80172 lab=_54362_/D }
C {devices/lab_pin.sym} 80880 -25400 0 1 {name=p80173 lab=_54362_/X }
C {sky130_stdcells/and4_4.sym} 80820 -25400 0 0 {name=X_54362_ }
C {devices/lab_pin.sym} 80740 -25280 0 0 {name=p80174 lab=_66266_/X }
C {devices/lab_pin.sym} 80740 -25240 0 0 {name=p80175 lab=_86210_/Q }
C {devices/lab_pin.sym} 80740 -25200 0 0 {name=p80176 lab=_66295_/X }
C {devices/lab_pin.sym} 80740 -25160 0 0 {name=p80177 lab=_66347_/X }
C {devices/lab_pin.sym} 80900 -25220 0 1 {name=p80178 lab=_66348_/X }
C {sky130_stdcells/a211o_4.sym} 80820 -25220 0 0 {name=X_66348_ }
C {devices/lab_pin.sym} 80730 -25070 0 0 {name=p80179 lab=_85248_/CLK }
C {devices/lab_pin.sym} 80730 -25050 0 0 {name=p80180 lab=_56476_/Y }
C {devices/lab_pin.sym} 80910 -25070 0 1 {name=p80181 lab=_55960_/B }
C {sky130_stdcells/dfxtp_4.sym} 80820 -25060 0 0 {name=X_85182_ }
C {devices/lab_pin.sym} 80780 -24930 0 0 {name=p80182 lab=_51629_/A }
C {devices/lab_pin.sym} 80860 -24930 0 1 {name=p80183 lab=_51580_/A }
C {sky130_stdcells/buf_2.sym} 80820 -24930 0 0 {name=X_51574_ }
C {devices/lab_pin.sym} 80730 -24810 0 0 {name=p80184 lab=_82394_/CLK }
C {devices/lab_pin.sym} 80730 -24790 0 0 {name=p80185 lab=_82202_/Q }
C {devices/lab_pin.sym} 80910 -24810 0 1 {name=p80186 lab=_82394_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -24800 0 0 {name=X_82394_ }
C {devices/lab_pin.sym} 80740 -24690 0 0 {name=p80187 lab=_56082_/X }
C {devices/lab_pin.sym} 80740 -24650 0 0 {name=p80188 lab=_56099_/X }
C {devices/lab_pin.sym} 80740 -24610 0 0 {name=p80189 lab=_56100_/Y }
C {devices/lab_pin.sym} 80900 -24650 0 1 {name=p80190 lab=_85296_/D }
C {sky130_stdcells/o21ai_4.sym} 80820 -24650 0 0 {name=X_56101_ }
C {devices/lab_pin.sym} 80740 -24530 0 0 {name=p80191 lab=_53310_/Y }
C {devices/lab_pin.sym} 80740 -24490 0 0 {name=p80192 lab=_53301_/X }
C {devices/lab_pin.sym} 80740 -24450 0 0 {name=p80193 lab=_53312_/X }
C {devices/lab_pin.sym} 80900 -24490 0 1 {name=p80194 lab=_85657_/D }
C {sky130_stdcells/a21oi_4.sym} 80820 -24490 0 0 {name=X_53313_ }
C {devices/lab_pin.sym} 80730 -24350 0 0 {name=p80195 lab=_82748_/CLK }
C {devices/lab_pin.sym} 80730 -24330 0 0 {name=p80196 lab=_84133_/D }
C {devices/lab_pin.sym} 80910 -24350 0 1 {name=p80197 lab=_84133_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -24340 0 0 {name=X_84133_ }
C {devices/lab_pin.sym} 80780 -24210 0 0 {name=p80198 lab=_50551_/A }
C {devices/lab_pin.sym} 80860 -24210 0 1 {name=p80199 lab=_50525_/X }
C {sky130_stdcells/buf_2.sym} 80820 -24210 0 0 {name=X_50525_ }
C {devices/lab_pin.sym} 80740 -24110 0 0 {name=p80200 lab=_56910_/X }
C {devices/lab_pin.sym} 80740 -24070 0 0 {name=p80201 lab=_56915_/Y }
C {devices/lab_pin.sym} 80740 -24030 0 0 {name=p80202 lab=_56982_/X }
C {devices/lab_pin.sym} 80900 -24070 0 1 {name=p80203 lab=_57081_/Y }
C {sky130_stdcells/a21oi_4.sym} 80820 -24070 0 0 {name=X_57081_ }
C {devices/lab_pin.sym} 80730 -23930 0 0 {name=p80204 lab=_83940_/CLK }
C {devices/lab_pin.sym} 80730 -23910 0 0 {name=p80205 lab=_76645_/Y }
C {devices/lab_pin.sym} 80910 -23930 0 1 {name=p80206 lab=_81721_/D }
C {sky130_stdcells/dfxtp_4.sym} 80820 -23920 0 0 {name=X_81345_ }
C {devices/lab_pin.sym} 80780 -23790 0 0 {name=p80207 lab=clkbuf_6_6_0_CLK/X }
C {devices/lab_pin.sym} 80860 -23790 0 1 {name=p80208 lab=clkbuf_8_27_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 80820 -23790 0 0 {name=Xclkbuf_7_13_0_CLK }
C {devices/lab_pin.sym} 80760 -23680 0 0 {name=p80209 lab=_69067_/A }
C {devices/lab_pin.sym} 80760 -23640 0 0 {name=p80210 lab=_74226_/A }
C {devices/lab_pin.sym} 80880 -23660 0 1 {name=p80211 lab=_69067_/X }
C {sky130_stdcells/and2_4.sym} 80820 -23660 0 0 {name=X_69067_ }
C {devices/lab_pin.sym} 80740 -23550 0 0 {name=p80212 lab=_54289_/Y }
C {devices/lab_pin.sym} 80740 -23510 0 0 {name=p80213 lab=_54285_/X }
C {devices/lab_pin.sym} 80740 -23470 0 0 {name=p80214 lab=_54292_/X }
C {devices/lab_pin.sym} 80900 -23510 0 1 {name=p80215 lab=_54293_/Y }
C {sky130_stdcells/a21oi_4.sym} 80820 -23510 0 0 {name=X_54293_ }
C {devices/lab_pin.sym} 80780 -23370 0 0 {name=p80216 lab=_66003_/A }
C {devices/lab_pin.sym} 80860 -23370 0 1 {name=p80217 lab=_66319_/B }
C {sky130_stdcells/buf_2.sym} 80820 -23370 0 0 {name=X_66279_ }
C {devices/lab_pin.sym} 80780 -23250 0 0 {name=p80218 lab=clkbuf_7_76_0_CLK/X }
C {devices/lab_pin.sym} 80860 -23250 0 1 {name=p80219 lab=clkbuf_9_307_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 80820 -23250 0 0 {name=Xclkbuf_8_153_0_CLK }
C {devices/lab_pin.sym} 80760 -23140 0 0 {name=p80220 lab=_67972_/A }
C {devices/lab_pin.sym} 80760 -23100 0 0 {name=p80221 lab=_68018_/B }
C {devices/lab_pin.sym} 80880 -23120 0 1 {name=p80222 lab=_68018_/X }
C {sky130_stdcells/and2_4.sym} 80820 -23120 0 0 {name=X_68018_ }
C {devices/lab_pin.sym} 80760 -23010 0 0 {name=p80223 lab=_56023_/A }
C {devices/lab_pin.sym} 80760 -22970 0 0 {name=p80224 lab=_56017_/B }
C {devices/lab_pin.sym} 80760 -22930 0 0 {name=p80225 lab=_55943_/B }
C {devices/lab_pin.sym} 80880 -22970 0 1 {name=p80226 lab=_56032_/Y }
C {sky130_stdcells/nand3_4.sym} 80820 -22970 0 0 {name=X_56032_ }
C {devices/lab_pin.sym} 80760 -22860 0 0 {name=p80227 lab=_53243_/X }
C {devices/lab_pin.sym} 80760 -22820 0 0 {name=p80228 lab=_53244_/B }
C {devices/lab_pin.sym} 80760 -22780 0 0 {name=p80229 lab=_53222_/X }
C {devices/lab_pin.sym} 80760 -22740 0 0 {name=p80230 lab=_53244_/D }
C {devices/lab_pin.sym} 80880 -22800 0 1 {name=p80231 lab=_53244_/X }
C {sky130_stdcells/and4_4.sym} 80820 -22800 0 0 {name=X_53244_ }
C {devices/lab_pin.sym} 80730 -22650 0 0 {name=p80232 lab=_84064_/CLK }
C {devices/lab_pin.sym} 80730 -22630 0 0 {name=p80233 lab=_67567_/X }
C {devices/lab_pin.sym} 80910 -22650 0 1 {name=p80234 lab=_84064_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -22640 0 0 {name=X_84064_ }
C {devices/lab_pin.sym} 80760 -22530 0 0 {name=p80235 lab=_52161_/A }
C {devices/lab_pin.sym} 80760 -22490 0 0 {name=p80236 lab=_50456_/B }
C {devices/lab_pin.sym} 80760 -22450 0 0 {name=p80237 lab=_50462_/C }
C {devices/lab_pin.sym} 80880 -22490 0 1 {name=p80238 lab=_50456_/X }
C {sky130_stdcells/and3_4.sym} 80820 -22490 0 0 {name=X_50456_ }
C {devices/lab_pin.sym} 80730 -22350 0 0 {name=p80239 lab=_81627_/CLK }
C {devices/lab_pin.sym} 80730 -22330 0 0 {name=p80240 lab=_81276_/D }
C {devices/lab_pin.sym} 80910 -22350 0 1 {name=p80241 lab=_81276_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -22340 0 0 {name=X_81276_ }
C {devices/lab_pin.sym} 80730 -22210 0 0 {name=p80242 lab=_83013_/CLK }
C {devices/lab_pin.sym} 80730 -22190 0 0 {name=p80243 lab=_83015_/D }
C {devices/lab_pin.sym} 80910 -22210 0 1 {name=p80244 lab=_83015_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -22200 0 0 {name=X_83015_ }
C {devices/lab_pin.sym} 80740 -22090 0 0 {name=p80245 lab=_80189_/A }
C {devices/lab_pin.sym} 80740 -22050 0 0 {name=p80246 lab=_80221_/X }
C {devices/lab_pin.sym} 80740 -22010 0 0 {name=p80247 lab=_80226_/Y }
C {devices/lab_pin.sym} 80900 -22050 0 1 {name=p80248 lab=_80227_/Y }
C {sky130_stdcells/a21oi_4.sym} 80820 -22050 0 0 {name=X_80227_ }
C {devices/lab_pin.sym} 80740 -21930 0 0 {name=p80249 lab=_85683_/Q }
C {devices/lab_pin.sym} 80740 -21890 0 0 {name=p80250 lab=_53172_/X }
C {devices/lab_pin.sym} 80740 -21850 0 0 {name=p80251 lab=_53174_/Y }
C {devices/lab_pin.sym} 80900 -21890 0 1 {name=p80252 lab=_53175_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -21890 0 0 {name=X_53175_ }
C {devices/lab_pin.sym} 80780 -21750 0 0 {name=p80253 lab=_50594_/A }
C {devices/lab_pin.sym} 80860 -21750 0 1 {name=p80254 lab=_50387_/X }
C {sky130_stdcells/buf_2.sym} 80820 -21750 0 0 {name=X_50387_ }
C {devices/lab_pin.sym} 80780 -21630 0 0 {name=p80255 lab=clkbuf_7_28_0_CLK/A }
C {devices/lab_pin.sym} 80860 -21630 0 1 {name=p80256 lab=clkbuf_8_57_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 80820 -21630 0 0 {name=Xclkbuf_7_28_0_CLK }
C {devices/lab_pin.sym} 80780 -21510 0 0 {name=p80257 lab=_52126_/A }
C {devices/lab_pin.sym} 80860 -21510 0 1 {name=p80258 lab=_52215_/A }
C {sky130_stdcells/buf_2.sym} 80820 -21510 0 0 {name=X_52126_ }
C {devices/lab_pin.sym} 80730 -21390 0 0 {name=p80259 lab=_87288_/CLK }
C {devices/lab_pin.sym} 80730 -21370 0 0 {name=p80260 lab=_42553_/Y }
C {devices/lab_pin.sym} 80910 -21390 0 1 {name=p80261 lab=_87823_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -21380 0 0 {name=X_87823_ }
C {devices/lab_pin.sym} 80760 -21260 0 0 {name=p80262 lab=_80142_/X }
C {devices/lab_pin.sym} 80760 -21220 0 0 {name=p80263 lab=_80145_/Y }
C {devices/lab_pin.sym} 80880 -21240 0 1 {name=p80264 lab=_80158_/X }
C {sky130_stdcells/or2_4.sym} 80820 -21240 0 0 {name=X_80158_ }
C {devices/lab_pin.sym} 80780 -21110 0 0 {name=p80265 lab=_58858_/A }
C {devices/lab_pin.sym} 80860 -21110 0 1 {name=p80266 lab=_57983_/X }
C {sky130_stdcells/buf_2.sym} 80820 -21110 0 0 {name=X_57983_ }
C {devices/lab_pin.sym} 80760 -21000 0 0 {name=p80267 lab=_68360_/X }
C {devices/lab_pin.sym} 80760 -20960 0 0 {name=p80268 lab=_69969_/B }
C {devices/lab_pin.sym} 80880 -20980 0 1 {name=p80269 lab=_69969_/Y }
C {sky130_stdcells/nor2_4.sym} 80820 -20980 0 0 {name=X_69969_ }
C {devices/lab_pin.sym} 80780 -20850 0 0 {name=p80270 lab=clkbuf_7_84_0_CLK/X }
C {devices/lab_pin.sym} 80860 -20850 0 1 {name=p80271 lab=clkbuf_8_168_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 80820 -20850 0 0 {name=Xclkbuf_8_168_0_CLK }
C {devices/lab_pin.sym} 80780 -20730 0 0 {name=p80272 lab=clkbuf_9_81_0_CLK/X }
C {devices/lab_pin.sym} 80860 -20730 0 1 {name=p80273 lab=_81257_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 80820 -20730 0 0 {name=Xclkbuf_10_163_0_CLK }
C {devices/lab_pin.sym} 80780 -20610 0 0 {name=p80274 lab=_59722_/A }
C {devices/lab_pin.sym} 80860 -20610 0 1 {name=p80275 lab=_59722_/X }
C {sky130_stdcells/buf_2.sym} 80820 -20610 0 0 {name=X_59722_ }
C {devices/lab_pin.sym} 80780 -20490 0 0 {name=p80276 lab=_56933_/X }
C {devices/lab_pin.sym} 80860 -20490 0 1 {name=p80277 lab=_56934_/X }
C {sky130_stdcells/buf_2.sym} 80820 -20490 0 0 {name=X_56934_ }
C {devices/lab_pin.sym} 80740 -20390 0 0 {name=p80278 lab=_74127_/B }
C {devices/lab_pin.sym} 80740 -20350 0 0 {name=p80279 lab=_52041_/X }
C {devices/lab_pin.sym} 80740 -20310 0 0 {name=p80280 lab=_52056_/Y }
C {devices/lab_pin.sym} 80900 -20350 0 1 {name=p80281 lab=_52057_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -20350 0 0 {name=X_52057_ }
C {devices/lab_pin.sym} 80730 -20210 0 0 {name=p80282 lab=_87757_/CLK }
C {devices/lab_pin.sym} 80730 -20190 0 0 {name=p80283 lab=_42715_/X }
C {devices/lab_pin.sym} 80910 -20210 0 1 {name=p80284 lab=_87754_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -20200 0 0 {name=X_87754_ }
C {devices/lab_pin.sym} 80760 -20080 0 0 {name=p80285 lab=_87307_/Q }
C {devices/lab_pin.sym} 80760 -20040 0 0 {name=p80286 lab=_72744_/X }
C {devices/lab_pin.sym} 80880 -20060 0 1 {name=p80287 lab=_72980_/Y }
C {sky130_stdcells/nor2_4.sym} 80820 -20060 0 0 {name=X_72980_ }
C {devices/lab_pin.sym} 80730 -19930 0 0 {name=p80288 lab=_86534_/CLK }
C {devices/lab_pin.sym} 80730 -19910 0 0 {name=p80289 lab=_84966_/D }
C {devices/lab_pin.sym} 80910 -19930 0 1 {name=p80290 lab=_84966_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -19920 0 0 {name=X_84966_ }
C {devices/lab_pin.sym} 80740 -19810 0 0 {name=p80291 lab=_57944_/Y }
C {devices/lab_pin.sym} 80740 -19770 0 0 {name=p80292 lab=_65683_/C }
C {devices/lab_pin.sym} 80740 -19730 0 0 {name=p80293 lab=_80088_/Y }
C {devices/lab_pin.sym} 80900 -19770 0 1 {name=p80294 lab=_80089_/X }
C {sky130_stdcells/o21a_4.sym} 80820 -19770 0 0 {name=X_80089_ }
C {devices/lab_pin.sym} 80780 -19630 0 0 {name=p80295 lab=clkbuf_9_396_0_CLK/X }
C {devices/lab_pin.sym} 80860 -19630 0 1 {name=p80296 lab=_82715_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 80820 -19630 0 0 {name=Xclkbuf_10_793_0_CLK }
C {devices/lab_pin.sym} 80760 -19520 0 0 {name=p80297 lab=_51003_/A }
C {devices/lab_pin.sym} 80760 -19480 0 0 {name=p80298 lab=_51008_/B }
C {devices/lab_pin.sym} 80880 -19500 0 1 {name=p80299 lab=_51008_/Y }
C {sky130_stdcells/nand2_4.sym} 80820 -19500 0 0 {name=X_51008_ }
C {devices/lab_pin.sym} 80730 -19370 0 0 {name=p80300 lab=_86384_/CLK }
C {devices/lab_pin.sym} 80730 -19350 0 0 {name=p80301 lab=_86705_/D }
C {devices/lab_pin.sym} 80910 -19370 0 1 {name=p80302 lab=_58776_/A }
C {sky130_stdcells/dfxtp_4.sym} 80820 -19360 0 0 {name=X_86705_ }
C {devices/lab_pin.sym} 80740 -19250 0 0 {name=p80303 lab=_71920_/Y }
C {devices/lab_pin.sym} 80740 -19210 0 0 {name=p80304 lab=_57170_/A }
C {devices/lab_pin.sym} 80740 -19170 0 0 {name=p80305 lab=_71930_/Y }
C {devices/lab_pin.sym} 80900 -19210 0 1 {name=p80306 lab=_71931_/X }
C {sky130_stdcells/a21o_4.sym} 80820 -19210 0 0 {name=X_71931_ }
C {devices/lab_pin.sym} 80780 -19070 0 0 {name=p80307 lab=_59961_/A }
C {devices/lab_pin.sym} 80860 -19070 0 1 {name=p80308 lab=_66064_/A }
C {sky130_stdcells/buf_2.sym} 80820 -19070 0 0 {name=X_59653_ }
C {devices/lab_pin.sym} 80730 -18950 0 0 {name=p80309 lab=_83918_/CLK }
C {devices/lab_pin.sym} 80730 -18930 0 0 {name=p80310 lab=_83917_/D }
C {devices/lab_pin.sym} 80910 -18950 0 1 {name=p80311 lab=_81381_/D }
C {sky130_stdcells/dfxtp_4.sym} 80820 -18940 0 0 {name=X_83917_ }
C {devices/lab_pin.sym} 80740 -18830 0 0 {name=p80312 lab=_58517_/A }
C {devices/lab_pin.sym} 80740 -18790 0 0 {name=p80313 lab=_55282_/B }
C {devices/lab_pin.sym} 80740 -18750 0 0 {name=p80314 lab=_56864_/X }
C {devices/lab_pin.sym} 80900 -18790 0 1 {name=p80315 lab=_56865_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -18790 0 0 {name=X_56865_ }
C {devices/lab_pin.sym} 80730 -18650 0 0 {name=p80316 lab=_88128_/CLK }
C {devices/lab_pin.sym} 80730 -18630 0 0 {name=p80317 lab=_87685_/D }
C {devices/lab_pin.sym} 80910 -18650 0 1 {name=p80318 lab=_66900_/B }
C {sky130_stdcells/dfxtp_4.sym} 80820 -18640 0 0 {name=X_87685_ }
C {devices/lab_pin.sym} 80730 -18510 0 0 {name=p80319 lab=_84897_/CLK }
C {devices/lab_pin.sym} 80730 -18490 0 0 {name=p80320 lab=_58252_/X }
C {devices/lab_pin.sym} 80910 -18510 0 1 {name=p80321 lab=_61985_/A }
C {sky130_stdcells/dfxtp_4.sym} 80820 -18500 0 0 {name=X_84897_ }
C {devices/lab_pin.sym} 80780 -18370 0 0 {name=p80322 lab=clkbuf_9_285_0_CLK/A }
C {devices/lab_pin.sym} 80860 -18370 0 1 {name=p80323 lab=clkbuf_9_284_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 80820 -18370 0 0 {name=Xclkbuf_9_284_0_CLK }
C {devices/lab_pin.sym} 80740 -18290 0 0 {name=p80324 lab=_58585_/X }
C {devices/lab_pin.sym} 80740 -18250 0 0 {name=p80325 lab=_58600_/Y }
C {devices/lab_pin.sym} 80740 -18210 0 0 {name=p80326 lab=_58601_/Y }
C {devices/lab_pin.sym} 80740 -18170 0 0 {name=p80327 lab=_58603_/X }
C {devices/lab_pin.sym} 80740 -18130 0 0 {name=p80328 lab=_58589_/X }
C {devices/lab_pin.sym} 80900 -18210 0 1 {name=p80329 lab=_58604_/X }
C {sky130_stdcells/o32a_4.sym} 80820 -18210 0 0 {name=X_58604_ }
C {devices/lab_pin.sym} 80740 -18070 0 0 {name=p80330 lab=_55813_/X }
C {devices/lab_pin.sym} 80740 -18030 0 0 {name=p80331 lab=_55815_/X }
C {devices/lab_pin.sym} 80740 -17990 0 0 {name=p80332 lab=_55309_/X }
C {devices/lab_pin.sym} 80900 -18030 0 1 {name=p80333 lab=_55816_/X }
C {sky130_stdcells/a21o_4.sym} 80820 -18030 0 0 {name=X_55816_ }
C {devices/lab_pin.sym} 80780 -17890 0 0 {name=p80334 lab=_43830_/A }
C {devices/lab_pin.sym} 80860 -17890 0 1 {name=p80335 lab=_43830_/Y }
C {sky130_stdcells/inv_2.sym} 80820 -17890 0 0 {name=X_43830_ }
C {devices/lab_pin.sym} 80760 -17780 0 0 {name=p80336 lab=_74642_/X }
C {devices/lab_pin.sym} 80760 -17740 0 0 {name=p80337 lab=_45560_/A }
C {devices/lab_pin.sym} 80880 -17760 0 1 {name=p80338 lab=_74650_/Y }
C {sky130_stdcells/nand2_4.sym} 80820 -17760 0 0 {name=X_74650_ }
C {devices/lab_pin.sym} 80730 -17630 0 0 {name=p80339 lab=_86637_/CLK }
C {devices/lab_pin.sym} 80730 -17610 0 0 {name=p80340 lab=_86636_/D }
C {devices/lab_pin.sym} 80910 -17630 0 1 {name=p80341 lab=_86636_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -17620 0 0 {name=X_86636_ }
C {devices/lab_pin.sym} 80740 -17510 0 0 {name=p80342 lab=_71848_/X }
C {devices/lab_pin.sym} 80740 -17470 0 0 {name=p80343 lab=_83349_/Q }
C {devices/lab_pin.sym} 80740 -17430 0 0 {name=p80344 lab=_71861_/Y }
C {devices/lab_pin.sym} 80900 -17470 0 1 {name=p80345 lab=_83349_/D }
C {sky130_stdcells/a21o_4.sym} 80820 -17470 0 0 {name=X_71862_ }
C {devices/lab_pin.sym} 80730 -17330 0 0 {name=p80346 lab=_83843_/CLK }
C {devices/lab_pin.sym} 80730 -17310 0 0 {name=p80347 lab=_83848_/D }
C {devices/lab_pin.sym} 80910 -17330 0 1 {name=p80348 lab=_83848_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -17320 0 0 {name=X_83848_ }
C {devices/lab_pin.sym} 80760 -17210 0 0 {name=p80349 lab=_57686_/A }
C {devices/lab_pin.sym} 80760 -17170 0 0 {name=p80350 lab=_44003_/A }
C {devices/lab_pin.sym} 80760 -17130 0 0 {name=p80351 lab=_59584_/C }
C {devices/lab_pin.sym} 80880 -17170 0 1 {name=p80352 lab=_59585_/A }
C {sky130_stdcells/nor3_4.sym} 80820 -17170 0 0 {name=X_59584_ }
C {devices/lab_pin.sym} 80760 -17040 0 0 {name=p80353 lab=_72765_/A }
C {devices/lab_pin.sym} 80760 -17000 0 0 {name=p80354 lab=_56796_/B }
C {devices/lab_pin.sym} 80880 -17020 0 1 {name=p80355 lab=_56796_/Y }
C {sky130_stdcells/nand2_4.sym} 80820 -17020 0 0 {name=X_56796_ }
C {devices/lab_pin.sym} 80780 -16890 0 0 {name=p80356 lab=clkbuf_9_89_0_CLK/X }
C {devices/lab_pin.sym} 80860 -16890 0 1 {name=p80357 lab=_81603_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 80820 -16890 0 0 {name=Xclkbuf_10_178_0_CLK }
C {devices/lab_pin.sym} 80740 -16790 0 0 {name=p80358 lab=_73596_/X }
C {devices/lab_pin.sym} 80740 -16750 0 0 {name=p80359 lab=_73600_/X }
C {devices/lab_pin.sym} 80740 -16710 0 0 {name=p80360 lab=_56549_/X }
C {devices/lab_pin.sym} 80900 -16750 0 1 {name=p80361 lab=_73601_/X }
C {sky130_stdcells/a21o_4.sym} 80820 -16750 0 0 {name=X_73601_ }
C {devices/lab_pin.sym} 80740 -16630 0 0 {name=p80362 lab=_52889_/B }
C {devices/lab_pin.sym} 80740 -16590 0 0 {name=p80363 lab=_70802_/X }
C {devices/lab_pin.sym} 80740 -16550 0 0 {name=p80364 lab=_70812_/Y }
C {devices/lab_pin.sym} 80900 -16590 0 1 {name=p80365 lab=_83695_/D }
C {sky130_stdcells/o21ai_4.sym} 80820 -16590 0 0 {name=X_70813_ }
C {devices/lab_pin.sym} 80780 -16450 0 0 {name=p80366 lab=_58535_/A }
C {devices/lab_pin.sym} 80860 -16450 0 1 {name=p80367 lab=_58535_/Y }
C {sky130_stdcells/inv_2.sym} 80820 -16450 0 0 {name=X_58535_ }
C {devices/lab_pin.sym} 80740 -16370 0 0 {name=p80368 lab=_43005_/X }
C {devices/lab_pin.sym} 80740 -16330 0 0 {name=p80369 lab=_43760_/X }
C {devices/lab_pin.sym} 80740 -16290 0 0 {name=p80370 lab=_40959_/X }
C {devices/lab_pin.sym} 80740 -16250 0 0 {name=p80371 lab=_87279_/Q }
C {devices/lab_pin.sym} 80740 -16210 0 0 {name=p80372 lab=_43756_/X }
C {devices/lab_pin.sym} 80900 -16290 0 1 {name=p80373 lab=_43762_/A }
C {sky130_stdcells/o32ai_4.sym} 80820 -16290 0 0 {name=X_43761_ }
C {devices/lab_pin.sym} 80780 -16130 0 0 {name=p80374 lab=_55174_/X }
C {devices/lab_pin.sym} 80860 -16130 0 1 {name=p80375 lab=_55747_/X }
C {sky130_stdcells/buf_2.sym} 80820 -16130 0 0 {name=X_55747_ }
C {devices/lab_pin.sym} 80740 -16030 0 0 {name=p80376 lab=_45124_/A }
C {devices/lab_pin.sym} 80740 -15990 0 0 {name=p80377 lab=_74568_/X }
C {devices/lab_pin.sym} 80740 -15950 0 0 {name=p80378 lab=_74580_/X }
C {devices/lab_pin.sym} 80900 -15990 0 1 {name=p80379 lab=_74581_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -15990 0 0 {name=X_74581_ }
C {devices/lab_pin.sym} 80730 -15850 0 0 {name=p80380 lab=_86213_/CLK }
C {devices/lab_pin.sym} 80730 -15830 0 0 {name=p80381 lab=_48113_/Y }
C {devices/lab_pin.sym} 80910 -15850 0 1 {name=p80382 lab=_66285_/B }
C {sky130_stdcells/dfxtp_4.sym} 80820 -15840 0 0 {name=X_86567_ }
C {devices/lab_pin.sym} 80740 -15750 0 0 {name=p80383 lab=_40944_/X }
C {devices/lab_pin.sym} 80740 -15710 0 0 {name=p80384 lab=_40946_/X }
C {devices/lab_pin.sym} 80740 -15670 0 0 {name=p80385 lab=_40972_/X }
C {devices/lab_pin.sym} 80740 -15630 0 0 {name=p80386 lab=_88300_/Q }
C {devices/lab_pin.sym} 80740 -15590 0 0 {name=p80387 lab=_40916_/X }
C {devices/lab_pin.sym} 80900 -15670 0 1 {name=p80388 lab=_40973_/Y }
C {sky130_stdcells/o32ai_4.sym} 80820 -15670 0 0 {name=X_40973_ }
C {devices/lab_pin.sym} 80760 -15520 0 0 {name=p80389 lab=_52979_/A }
C {devices/lab_pin.sym} 80760 -15480 0 0 {name=p80390 lab=_52959_/B }
C {devices/lab_pin.sym} 80880 -15500 0 1 {name=p80391 lab=_52959_/Y }
C {sky130_stdcells/nand2_4.sym} 80820 -15500 0 0 {name=X_52959_ }
C {devices/lab_pin.sym} 80740 -15390 0 0 {name=p80392 lab=_58196_/Y }
C {devices/lab_pin.sym} 80740 -15350 0 0 {name=p80393 lab=_71784_/X }
C {devices/lab_pin.sym} 80740 -15310 0 0 {name=p80394 lab=_71792_/Y }
C {devices/lab_pin.sym} 80900 -15350 0 1 {name=p80395 lab=_71793_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -15350 0 0 {name=X_71793_ }
C {devices/lab_pin.sym} 80730 -15210 0 0 {name=p80396 lab=_85953_/CLK }
C {devices/lab_pin.sym} 80730 -15190 0 0 {name=p80397 lab=_70403_/Y }
C {devices/lab_pin.sym} 80910 -15210 0 1 {name=p80398 lab=_83779_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -15200 0 0 {name=X_83779_ }
C {devices/lab_pin.sym} 80780 -15070 0 0 {name=p80399 lab=_45500_/A }
C {devices/lab_pin.sym} 80860 -15070 0 1 {name=p80400 lab=_45500_/Y }
C {sky130_stdcells/inv_2.sym} 80820 -15070 0 0 {name=X_45500_ }
C {devices/lab_pin.sym} 80780 -14950 0 0 {name=p80401 lab=_76299_/Y }
C {devices/lab_pin.sym} 80860 -14950 0 1 {name=p80402 lab=_76320_/Y }
C {sky130_stdcells/inv_2.sym} 80820 -14950 0 0 {name=X_76320_ }
C {devices/lab_pin.sym} 80740 -14860 0 0 {name=p80403 lab=_41147_/X }
C {devices/lab_pin.sym} 80740 -14820 0 0 {name=p80404 lab=_42710_/X }
C {devices/lab_pin.sym} 80740 -14780 0 0 {name=p80405 lab=_68528_/B }
C {devices/lab_pin.sym} 80740 -14740 0 0 {name=p80406 lab=_42711_/X }
C {devices/lab_pin.sym} 80900 -14800 0 1 {name=p80407 lab=_87757_/D }
C {sky130_stdcells/a2bb2o_4.sym} 80820 -14800 0 0 {name=X_42712_ }
C {devices/lab_pin.sym} 80730 -14650 0 0 {name=p80408 lab=_86989_/CLK }
C {devices/lab_pin.sym} 80730 -14630 0 0 {name=p80409 lab=_88306_/D }
C {devices/lab_pin.sym} 80910 -14650 0 1 {name=p80410 lab=_88306_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -14640 0 0 {name=X_88306_ }
C {devices/lab_pin.sym} 80740 -14530 0 0 {name=p80411 lab=_73528_/X }
C {devices/lab_pin.sym} 80740 -14490 0 0 {name=p80412 lab=_73531_/X }
C {devices/lab_pin.sym} 80740 -14450 0 0 {name=p80413 lab=_56549_/X }
C {devices/lab_pin.sym} 80900 -14490 0 1 {name=p80414 lab=_73532_/X }
C {sky130_stdcells/a21o_4.sym} 80820 -14490 0 0 {name=X_73532_ }
C {devices/lab_pin.sym} 80730 -14350 0 0 {name=p80415 lab=_86030_/CLK }
C {devices/lab_pin.sym} 80730 -14330 0 0 {name=p80416 lab=_54040_/Y }
C {devices/lab_pin.sym} 80910 -14350 0 1 {name=p80417 lab=_85518_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -14340 0 0 {name=X_85518_ }
C {devices/lab_pin.sym} 80780 -14210 0 0 {name=p80418 lab=_70755_/A }
C {devices/lab_pin.sym} 80860 -14210 0 1 {name=p80419 lab=_70753_/A }
C {sky130_stdcells/buf_2.sym} 80820 -14210 0 0 {name=X_70744_ }
C {devices/lab_pin.sym} 80780 -14090 0 0 {name=p80420 lab=_82925_/Q }
C {devices/lab_pin.sym} 80860 -14090 0 1 {name=p80421 lab=_48044_/B }
C {sky130_stdcells/inv_2.sym} 80820 -14090 0 0 {name=X_46480_ }
C {devices/lab_pin.sym} 80740 -13990 0 0 {name=p80422 lab=_58341_/X }
C {devices/lab_pin.sym} 80740 -13950 0 0 {name=p80423 lab=_58463_/Y }
C {devices/lab_pin.sym} 80740 -13910 0 0 {name=p80424 lab=_58465_/Y }
C {devices/lab_pin.sym} 80900 -13950 0 1 {name=p80425 lab=_58466_/Y }
C {sky130_stdcells/a21oi_4.sym} 80820 -13950 0 0 {name=X_58466_ }
C {devices/lab_pin.sym} 80780 -13810 0 0 {name=p80426 lab=_87305_/Q }
C {devices/lab_pin.sym} 80860 -13810 0 1 {name=p80427 lab=_69700_/B }
C {sky130_stdcells/inv_2.sym} 80820 -13810 0 0 {name=X_43692_ }
C {devices/lab_pin.sym} 80760 -13700 0 0 {name=p80428 lab=_55678_/A }
C {devices/lab_pin.sym} 80760 -13660 0 0 {name=p80429 lab=_55290_/A }
C {devices/lab_pin.sym} 80880 -13680 0 1 {name=p80430 lab=_55678_/X }
C {sky130_stdcells/and2_4.sym} 80820 -13680 0 0 {name=X_55678_ }
C {devices/lab_pin.sym} 80730 -13550 0 0 {name=p80431 lab=_86498_/CLK }
C {devices/lab_pin.sym} 80730 -13530 0 0 {name=p80432 lab=_48712_/Y }
C {devices/lab_pin.sym} 80910 -13550 0 1 {name=p80433 lab=_86498_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -13540 0 0 {name=X_86498_ }
C {devices/lab_pin.sym} 80780 -13410 0 0 {name=p80434 lab=clkbuf_9_299_0_CLK/A }
C {devices/lab_pin.sym} 80860 -13410 0 1 {name=p80435 lab=clkbuf_9_299_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 80820 -13410 0 0 {name=Xclkbuf_9_299_0_CLK }
C {devices/lab_pin.sym} 80780 -13290 0 0 {name=p80436 lab=clkbuf_7_53_0_CLK/X }
C {devices/lab_pin.sym} 80860 -13290 0 1 {name=p80437 lab=clkbuf_8_106_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 80820 -13290 0 0 {name=Xclkbuf_8_106_0_CLK }
C {devices/lab_pin.sym} 80780 -13170 0 0 {name=p80438 lab=clkbuf_9_50_0_CLK/X }
C {devices/lab_pin.sym} 80860 -13170 0 1 {name=p80439 lab=_84538_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 80820 -13170 0 0 {name=Xclkbuf_10_101_0_CLK }
C {devices/lab_pin.sym} 80740 -13070 0 0 {name=p80440 lab=_83007_/Q }
C {devices/lab_pin.sym} 80740 -13030 0 0 {name=p80441 lab=_45401_/X }
C {devices/lab_pin.sym} 80740 -12990 0 0 {name=p80442 lab=_45430_/X }
C {devices/lab_pin.sym} 80900 -13030 0 1 {name=p80443 lab=_45431_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -13030 0 0 {name=X_45431_ }
C {devices/lab_pin.sym} 80740 -12910 0 0 {name=p80444 lab=_57408_/X }
C {devices/lab_pin.sym} 80740 -12870 0 0 {name=p80445 lab=_57415_/X }
C {devices/lab_pin.sym} 80740 -12830 0 0 {name=p80446 lab=_57416_/Y }
C {devices/lab_pin.sym} 80900 -12870 0 1 {name=p80447 lab=_57417_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -12870 0 0 {name=X_57417_ }
C {devices/lab_pin.sym} 80730 -12730 0 0 {name=p80448 lab=_88164_/CLK }
C {devices/lab_pin.sym} 80730 -12710 0 0 {name=p80449 lab=_88237_/D }
C {devices/lab_pin.sym} 80910 -12730 0 1 {name=p80450 lab=_88237_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -12720 0 0 {name=X_88237_ }
C {devices/lab_pin.sym} 80760 -12610 0 0 {name=p80451 lab=_76250_/Y }
C {devices/lab_pin.sym} 80760 -12570 0 0 {name=p80452 lab=_81641_/Q }
C {devices/lab_pin.sym} 80760 -12530 0 0 {name=p80453 lab=_76251_/C }
C {devices/lab_pin.sym} 80880 -12570 0 1 {name=p80454 lab=_76254_/B }
C {sky130_stdcells/nand3_4.sym} 80820 -12570 0 0 {name=X_76251_ }
C {devices/lab_pin.sym} 80740 -12460 0 0 {name=p80455 lab=_40964_/X }
C {devices/lab_pin.sym} 80740 -12420 0 0 {name=p80456 lab=_42631_/X }
C {devices/lab_pin.sym} 80740 -12380 0 0 {name=p80457 lab=_69203_/B }
C {devices/lab_pin.sym} 80740 -12340 0 0 {name=p80458 lab=_42634_/X }
C {devices/lab_pin.sym} 80900 -12400 0 1 {name=p80459 lab=_87790_/D }
C {sky130_stdcells/a2bb2o_4.sym} 80820 -12400 0 0 {name=X_42643_ }
C {devices/lab_pin.sym} 80780 -12250 0 0 {name=p80460 lab=_54521_/A }
C {devices/lab_pin.sym} 80860 -12250 0 1 {name=p80461 lab=_54645_/B }
C {sky130_stdcells/buf_2.sym} 80820 -12250 0 0 {name=X_54629_ }
C {devices/lab_pin.sym} 80730 -12130 0 0 {name=p80462 lab=_85770_/CLK }
C {devices/lab_pin.sym} 80730 -12110 0 0 {name=p80463 lab=_54403_/Y }
C {devices/lab_pin.sym} 80910 -12130 0 1 {name=p80464 lab=_85449_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -12120 0 0 {name=X_85449_ }
C {devices/lab_pin.sym} 80740 -12020 0 0 {name=p80465 lab=_69929_/Y }
C {devices/lab_pin.sym} 80740 -11980 0 0 {name=p80466 lab=_73224_/X }
C {devices/lab_pin.sym} 80740 -11940 0 0 {name=p80467 lab=_73393_/X }
C {devices/lab_pin.sym} 80740 -11900 0 0 {name=p80468 lab=_73462_/Y }
C {devices/lab_pin.sym} 80900 -11960 0 1 {name=p80469 lab=_73463_/X }
C {sky130_stdcells/a211o_4.sym} 80820 -11960 0 0 {name=X_73463_ }
C {devices/lab_pin.sym} 80780 -11810 0 0 {name=p80470 lab=_71857_/A }
C {devices/lab_pin.sym} 80860 -11810 0 1 {name=p80471 lab=_70676_/A }
C {sky130_stdcells/buf_2.sym} 80820 -11810 0 0 {name=X_70675_ }
C {devices/lab_pin.sym} 80760 -11700 0 0 {name=p80472 lab=_58396_/Y }
C {devices/lab_pin.sym} 80760 -11660 0 0 {name=p80473 lab=_58403_/B }
C {devices/lab_pin.sym} 80880 -11680 0 1 {name=p80474 lab=_58397_/Y }
C {sky130_stdcells/nand2_4.sym} 80820 -11680 0 0 {name=X_58397_ }
C {devices/lab_pin.sym} 80780 -11550 0 0 {name=p80475 lab=clkbuf_9_365_0_CLK/X }
C {devices/lab_pin.sym} 80860 -11550 0 1 {name=p80476 lab=_87253_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 80820 -11550 0 0 {name=Xclkbuf_10_731_0_CLK }
C {devices/lab_pin.sym} 80760 -11440 0 0 {name=p80477 lab=_80682_/Q }
C {devices/lab_pin.sym} 80760 -11400 0 0 {name=p80478 lab=_80938_/D }
C {devices/lab_pin.sym} 80880 -11420 0 1 {name=p80479 lab=_75202_/Y }
C {sky130_stdcells/nand2_4.sym} 80820 -11420 0 0 {name=X_75202_ }
C {devices/lab_pin.sym} 80780 -11290 0 0 {name=p80480 lab=_48781_/A }
C {devices/lab_pin.sym} 80860 -11290 0 1 {name=p80481 lab=_48150_/X }
C {sky130_stdcells/buf_2.sym} 80820 -11290 0 0 {name=X_48150_ }
C {devices/lab_pin.sym} 80780 -11170 0 0 {name=p80482 lab=_59255_/A }
C {devices/lab_pin.sym} 80860 -11170 0 1 {name=p80483 lab=_72414_/X }
C {sky130_stdcells/buf_2.sym} 80820 -11170 0 0 {name=X_72414_ }
C {devices/lab_pin.sym} 80740 -11070 0 0 {name=p80484 lab=_45356_/Y }
C {devices/lab_pin.sym} 80740 -11030 0 0 {name=p80485 lab=_45359_/Y }
C {devices/lab_pin.sym} 80740 -10990 0 0 {name=p80486 lab=_45361_/X }
C {devices/lab_pin.sym} 80900 -11030 0 1 {name=p80487 lab=_45362_/X }
C {sky130_stdcells/a21o_4.sym} 80820 -11030 0 0 {name=X_45362_ }
C {devices/lab_pin.sym} 80740 -10920 0 0 {name=p80488 lab=_57346_/Y }
C {devices/lab_pin.sym} 80740 -10880 0 0 {name=p80489 lab=_56857_/X }
C {devices/lab_pin.sym} 80740 -10840 0 0 {name=p80490 lab=_46155_/A }
C {devices/lab_pin.sym} 80740 -10800 0 0 {name=p80491 lab=_57347_/Y }
C {devices/lab_pin.sym} 80900 -10860 0 1 {name=p80492 lab=_57348_/X }
C {sky130_stdcells/a211o_4.sym} 80820 -10860 0 0 {name=X_57348_ }
C {devices/lab_pin.sym} 80760 -10720 0 0 {name=p80493 lab=_76179_/Y }
C {devices/lab_pin.sym} 80760 -10680 0 0 {name=p80494 lab=_76182_/B }
C {devices/lab_pin.sym} 80880 -10700 0 1 {name=p80495 lab=_76182_/Y }
C {sky130_stdcells/nor2_4.sym} 80820 -10700 0 0 {name=X_76182_ }
C {devices/lab_pin.sym} 80730 -10570 0 0 {name=p80496 lab=_86934_/CLK }
C {devices/lab_pin.sym} 80730 -10550 0 0 {name=p80497 lab=_41694_/X }
C {devices/lab_pin.sym} 80910 -10570 0 1 {name=p80498 lab=_67608_/B }
C {sky130_stdcells/dfxtp_4.sym} 80820 -10560 0 0 {name=X_88168_ }
C {devices/lab_pin.sym} 80780 -10430 0 0 {name=p80499 lab=_42574_/A }
C {devices/lab_pin.sym} 80860 -10430 0 1 {name=p80500 lab=_42574_/X }
C {sky130_stdcells/buf_2.sym} 80820 -10430 0 0 {name=X_42574_ }
C {devices/lab_pin.sym} 80760 -10320 0 0 {name=p80501 lab=_73394_/A }
C {devices/lab_pin.sym} 80760 -10280 0 0 {name=p80502 lab=_73053_/B }
C {devices/lab_pin.sym} 80880 -10300 0 1 {name=p80503 lab=_73394_/Y }
C {sky130_stdcells/nor2_4.sym} 80820 -10300 0 0 {name=X_73394_ }
C {devices/lab_pin.sym} 80740 -10190 0 0 {name=p80504 lab=_59240_/A }
C {devices/lab_pin.sym} 80740 -10150 0 0 {name=p80505 lab=_47096_/X }
C {devices/lab_pin.sym} 80740 -10110 0 0 {name=p80506 lab=_47100_/Y }
C {devices/lab_pin.sym} 80900 -10150 0 1 {name=p80507 lab=_47101_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -10150 0 0 {name=X_47101_ }
C {devices/lab_pin.sym} 80780 -10010 0 0 {name=p80508 lab=clkbuf_9_222_0_CLK/A }
C {devices/lab_pin.sym} 80860 -10010 0 1 {name=p80509 lab=clkbuf_9_222_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 80820 -10010 0 0 {name=Xclkbuf_9_222_0_CLK }
C {devices/lab_pin.sym} 80760 -9910 0 0 {name=p80510 lab=_44313_/A }
C {devices/lab_pin.sym} 80760 -9870 0 0 {name=p80511 lab=_44313_/B }
C {devices/lab_pin.sym} 80760 -9830 0 0 {name=p80512 lab=_46228_/A }
C {devices/lab_pin.sym} 80880 -9870 0 1 {name=p80513 lab=_44313_/Y }
C {sky130_stdcells/nand3_4.sym} 80820 -9870 0 0 {name=X_44313_ }
C {devices/lab_pin.sym} 80760 -9740 0 0 {name=p80514 lab=_75130_/Y }
C {devices/lab_pin.sym} 80760 -9700 0 0 {name=p80515 lab=_75133_/B }
C {devices/lab_pin.sym} 80880 -9720 0 1 {name=p80516 lab=_75133_/Y }
C {sky130_stdcells/nor2_4.sym} 80820 -9720 0 0 {name=X_75133_ }
C {devices/lab_pin.sym} 80730 -9590 0 0 {name=p80517 lab=_87684_/CLK }
C {devices/lab_pin.sym} 80730 -9570 0 0 {name=p80518 lab=_87119_/D }
C {devices/lab_pin.sym} 80910 -9590 0 1 {name=p80519 lab=_87119_/Q }
C {sky130_stdcells/dfxtp_4.sym} 80820 -9580 0 0 {name=X_87119_ }
C {devices/lab_pin.sym} 80780 -9450 0 0 {name=p80520 lab=_41524_/Y }
C {devices/lab_pin.sym} 80860 -9450 0 1 {name=p80521 lab=_41525_/X }
C {sky130_stdcells/buf_2.sym} 80820 -9450 0 0 {name=X_41525_ }
C {devices/lab_pin.sym} 80740 -9350 0 0 {name=p80522 lab=_72341_/Y }
C {devices/lab_pin.sym} 80740 -9310 0 0 {name=p80523 lab=_72343_/Y }
C {devices/lab_pin.sym} 80740 -9270 0 0 {name=p80524 lab=_72344_/X }
C {devices/lab_pin.sym} 80900 -9310 0 1 {name=p80525 lab=_72345_/X }
C {sky130_stdcells/a21o_4.sym} 80820 -9310 0 0 {name=X_72345_ }
C {devices/lab_pin.sym} 80780 -9170 0 0 {name=p80526 lab=_83537_/Q }
C {devices/lab_pin.sym} 80860 -9170 0 1 {name=p80527 lab=_48081_/Y }
C {sky130_stdcells/inv_2.sym} 80820 -9170 0 0 {name=X_48081_ }
C {devices/lab_pin.sym} 80780 -9050 0 0 {name=p80528 lab=_64494_/B }
C {devices/lab_pin.sym} 80860 -9050 0 1 {name=p80529 lab=_61627_/B }
C {sky130_stdcells/buf_2.sym} 80820 -9050 0 0 {name=X_45293_ }
C {devices/lab_pin.sym} 80740 -8950 0 0 {name=p80530 lab=_56696_/A }
C {devices/lab_pin.sym} 80740 -8910 0 0 {name=p80531 lab=_44277_/X }
C {devices/lab_pin.sym} 80740 -8870 0 0 {name=p80532 lab=_57278_/Y }
C {devices/lab_pin.sym} 80900 -8910 0 1 {name=p80533 lab=_85041_/D }
C {sky130_stdcells/a21oi_4.sym} 80820 -8910 0 0 {name=X_57279_ }
C {devices/lab_pin.sym} 80730 -8770 0 0 {name=p80534 lab=_88104_/CLK }
C {devices/lab_pin.sym} 80730 -8750 0 0 {name=p80535 lab=_88099_/D }
C {devices/lab_pin.sym} 80910 -8770 0 1 {name=p80536 lab=_41941_/A }
C {sky130_stdcells/dfxtp_4.sym} 80820 -8760 0 0 {name=X_88099_ }
C {devices/lab_pin.sym} 80780 -8630 0 0 {name=p80537 lab=clkbuf_9_58_0_CLK/X }
C {devices/lab_pin.sym} 80860 -8630 0 1 {name=p80538 lab=_84905_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 80820 -8630 0 0 {name=Xclkbuf_10_116_0_CLK }
C {devices/lab_pin.sym} 80780 -8510 0 0 {name=p80539 lab=_53332_/B }
C {devices/lab_pin.sym} 80860 -8510 0 1 {name=p80540 lab=_52813_/B }
C {sky130_stdcells/buf_2.sym} 80820 -8510 0 0 {name=X_47032_ }
C {devices/lab_pin.sym} 80760 -8400 0 0 {name=p80541 lab=_58920_/A }
C {devices/lab_pin.sym} 80760 -8360 0 0 {name=p80542 lab=_86367_/Q }
C {devices/lab_pin.sym} 80880 -8380 0 1 {name=p80543 lab=_59018_/Y }
C {sky130_stdcells/nor2_4.sym} 80820 -8380 0 0 {name=X_59018_ }
C {devices/lab_pin.sym} 80780 -8250 0 0 {name=p80544 lab=_44244_/A }
C {devices/lab_pin.sym} 80860 -8250 0 1 {name=p80545 lab=_44245_/A }
C {sky130_stdcells/buf_2.sym} 80820 -8250 0 0 {name=X_44244_ }
C {devices/lab_pin.sym} 80740 -8150 0 0 {name=p80546 lab=_75062_/Y }
C {devices/lab_pin.sym} 80740 -8110 0 0 {name=p80547 lab=_75059_/B }
C {devices/lab_pin.sym} 80740 -8070 0 0 {name=p80548 lab=_75063_/Y }
C {devices/lab_pin.sym} 80900 -8110 0 1 {name=p80549 lab=_75067_/A }
C {sky130_stdcells/o21ai_4.sym} 80820 -8110 0 0 {name=X_75064_ }
C {devices/lab_pin.sym} 80760 -7980 0 0 {name=p80550 lab=_84925_/Q }
C {devices/lab_pin.sym} 80760 -7940 0 0 {name=p80551 lab=_65855_/C }
C {devices/lab_pin.sym} 80880 -7960 0 1 {name=p80552 lab=_79941_/Y }
C {sky130_stdcells/nand2_4.sym} 80820 -7960 0 0 {name=X_79941_ }
C {devices/lab_pin.sym} 80780 -7830 0 0 {name=p80553 lab=_40565_/Y }
C {devices/lab_pin.sym} 80860 -7830 0 1 {name=p80554 lab=_41457_/A }
C {sky130_stdcells/buf_2.sym} 80820 -7830 0 0 {name=X_41456_ }
C {devices/lab_pin.sym} 80740 -7730 0 0 {name=p80555 lab=_60259_/B }
C {devices/lab_pin.sym} 80740 -7690 0 0 {name=p80556 lab=_60350_/A }
C {devices/lab_pin.sym} 80740 -7650 0 0 {name=p80557 lab=_61286_/A }
C {devices/lab_pin.sym} 80900 -7690 0 1 {name=p80558 lab=_60290_/Y }
C {sky130_stdcells/a21oi_4.sym} 80820 -7690 0 0 {name=X_60290_ }
C {devices/lab_pin.sym} 80740 -7580 0 0 {name=p80559 lab=_72263_/Y }
C {devices/lab_pin.sym} 80740 -7540 0 0 {name=p80560 lab=_72237_/X }
C {devices/lab_pin.sym} 80740 -7500 0 0 {name=p80561 lab=_72269_/X }
C {devices/lab_pin.sym} 80740 -7460 0 0 {name=p80562 lab=_72275_/X }
C {devices/lab_pin.sym} 80900 -7520 0 1 {name=p80563 lab=_83269_/D }
C {sky130_stdcells/a22oi_4.sym} 80820 -7520 0 0 {name=X_72276_ }
C {devices/lab_pin.sym} 80780 -7370 0 0 {name=p80564 lab=clkbuf_9_373_0_CLK/X }
C {devices/lab_pin.sym} 80860 -7370 0 1 {name=p80565 lab=_87484_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 80820 -7370 0 0 {name=Xclkbuf_10_746_0_CLK }
C {devices/lab_pin.sym} 80740 -7280 0 0 {name=p80566 lab=_74012_/X }
C {devices/lab_pin.sym} 80740 -7240 0 0 {name=p80567 lab=_86222_/Q }
C {devices/lab_pin.sym} 80740 -7200 0 0 {name=p80568 lab=_73948_/X }
C {devices/lab_pin.sym} 80740 -7160 0 0 {name=p80569 lab=_74014_/X }
C {devices/lab_pin.sym} 80900 -7220 0 1 {name=p80570 lab=_74015_/X }
C {sky130_stdcells/a211o_4.sym} 80820 -7220 0 0 {name=X_74015_ }
C {devices/lab_pin.sym} 80740 -7090 0 0 {name=p80571 lab=_40381_/X }
C {devices/lab_pin.sym} 80740 -7050 0 0 {name=p80572 lab=_81177_/Q }
C {devices/lab_pin.sym} 80740 -7010 0 0 {name=p80573 lab=_40406_/X }
C {devices/lab_pin.sym} 80900 -7050 0 1 {name=p80574 lab=_40407_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -7050 0 0 {name=X_40407_ }
C {devices/lab_pin.sym} 80740 -6930 0 0 {name=p80575 lab=_48851_/B }
C {devices/lab_pin.sym} 80740 -6890 0 0 {name=p80576 lab=_71216_/X }
C {devices/lab_pin.sym} 80740 -6850 0 0 {name=p80577 lab=_71226_/Y }
C {devices/lab_pin.sym} 80900 -6890 0 1 {name=p80578 lab=_71227_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -6890 0 0 {name=X_71227_ }
C {devices/lab_pin.sym} 80780 -6750 0 0 {name=p80579 lab=_44175_/A }
C {devices/lab_pin.sym} 80860 -6750 0 1 {name=p80580 lab=_64679_/A }
C {sky130_stdcells/buf_2.sym} 80820 -6750 0 0 {name=X_44175_ }
C {devices/lab_pin.sym} 80760 -6640 0 0 {name=p80581 lab=_79872_/A }
C {devices/lab_pin.sym} 80760 -6600 0 0 {name=p80582 lab=_79872_/B }
C {devices/lab_pin.sym} 80880 -6620 0 1 {name=p80583 lab=_79873_/B }
C {sky130_stdcells/xor2_4.sym} 80820 -6620 0 0 {name=X_79872_ }
C {devices/lab_pin.sym} 80780 -6490 0 0 {name=p80584 lab=_41387_/A }
C {devices/lab_pin.sym} 80860 -6490 0 1 {name=p80585 lab=_41387_/X }
C {sky130_stdcells/buf_2.sym} 80820 -6490 0 0 {name=X_41387_ }
C {devices/lab_pin.sym} 80780 -6370 0 0 {name=p80586 lab=clkbuf_8_118_0_CLK/X }
C {devices/lab_pin.sym} 80860 -6370 0 1 {name=p80587 lab=clkbuf_9_237_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 80820 -6370 0 0 {name=Xclkbuf_9_237_0_CLK }
C {devices/lab_pin.sym} 80780 -6250 0 0 {name=p80588 lab=_43126_/A }
C {devices/lab_pin.sym} 80860 -6250 0 1 {name=p80589 lab=_43126_/Y }
C {sky130_stdcells/inv_2.sym} 80820 -6250 0 0 {name=X_43126_ }
C {devices/lab_pin.sym} 80780 -6130 0 0 {name=p80590 lab=_79123_/B }
C {devices/lab_pin.sym} 80860 -6130 0 1 {name=p80591 lab=_78825_/A }
C {sky130_stdcells/inv_2.sym} 80820 -6130 0 0 {name=X_78823_ }
C {devices/lab_pin.sym} 80780 -6010 0 0 {name=p80592 lab=_40337_/X }
C {devices/lab_pin.sym} 80860 -6010 0 1 {name=p80593 lab=_46259_/A }
C {sky130_stdcells/buf_2.sym} 80820 -6010 0 0 {name=X_40338_ }
C {devices/lab_pin.sym} 80740 -5910 0 0 {name=p80594 lab=_52128_/B }
C {devices/lab_pin.sym} 80740 -5870 0 0 {name=p80595 lab=_71138_/A }
C {devices/lab_pin.sym} 80740 -5830 0 0 {name=p80596 lab=_71157_/Y }
C {devices/lab_pin.sym} 80900 -5870 0 1 {name=p80597 lab=_83587_/D }
C {sky130_stdcells/o21ai_4.sym} 80820 -5870 0 0 {name=X_71158_ }
C {devices/lab_pin.sym} 80760 -5740 0 0 {name=p80598 lab=_48964_/A }
C {devices/lab_pin.sym} 80760 -5700 0 0 {name=p80599 lab=_48982_/X }
C {devices/lab_pin.sym} 80880 -5720 0 1 {name=p80600 lab=_48983_/Y }
C {sky130_stdcells/nand2_4.sym} 80820 -5720 0 0 {name=X_48983_ }
C {devices/lab_pin.sym} 80780 -5590 0 0 {name=p80601 lab=_83126_/Q }
C {devices/lab_pin.sym} 80860 -5590 0 1 {name=p80602 lab=_70109_/Y }
C {sky130_stdcells/inv_2.sym} 80820 -5590 0 0 {name=X_70109_ }
C {devices/lab_pin.sym} 80780 -5470 0 0 {name=p80603 lab=_47857_/X }
C {devices/lab_pin.sym} 80860 -5470 0 1 {name=p80604 lab=_47946_/A }
C {sky130_stdcells/buf_2.sym} 80820 -5470 0 0 {name=X_47934_ }
C {devices/lab_pin.sym} 80780 -5350 0 0 {name=p80605 lab=_43057_/A }
C {devices/lab_pin.sym} 80860 -5350 0 1 {name=p80606 lab=_43057_/Y }
C {sky130_stdcells/inv_2.sym} 80820 -5350 0 0 {name=X_43057_ }
C {devices/lab_pin.sym} 80740 -5250 0 0 {name=p80607 lab=_78753_/B }
C {devices/lab_pin.sym} 80740 -5210 0 0 {name=p80608 lab=_78753_/C }
C {devices/lab_pin.sym} 80740 -5170 0 0 {name=p80609 lab=_78749_/Y }
C {devices/lab_pin.sym} 80900 -5210 0 1 {name=p80610 lab=_78758_/C }
C {sky130_stdcells/o21ai_4.sym} 80820 -5210 0 0 {name=X_78754_ }
C {devices/lab_pin.sym} 80760 -5100 0 0 {name=p80611 lab=_58533_/A }
C {devices/lab_pin.sym} 80760 -5060 0 0 {name=p80612 lab=_63934_/X }
C {devices/lab_pin.sym} 80760 -5020 0 0 {name=p80613 lab=_63949_/C }
C {devices/lab_pin.sym} 80760 -4980 0 0 {name=p80614 lab=_64027_/D }
C {devices/lab_pin.sym} 80880 -5040 0 1 {name=p80615 lab=_63980_/Y }
C {sky130_stdcells/nand4_4.sym} 80820 -5040 0 0 {name=X_63980_ }
C {devices/lab_pin.sym} 80740 -4910 0 0 {name=p80616 lab=_49025_/X }
C {devices/lab_pin.sym} 80740 -4870 0 0 {name=p80617 lab=_71070_/A }
C {devices/lab_pin.sym} 80740 -4830 0 0 {name=p80618 lab=_71088_/Y }
C {devices/lab_pin.sym} 80900 -4870 0 1 {name=p80619 lab=_71089_/Y }
C {sky130_stdcells/o21ai_4.sym} 80820 -4870 0 0 {name=X_71089_ }
C {devices/lab_pin.sym} 80760 -4740 0 0 {name=p80620 lab=_81512_/Q }
C {devices/lab_pin.sym} 80760 -4700 0 0 {name=p80621 lab=_81736_/D }
C {devices/lab_pin.sym} 80880 -4720 0 1 {name=p80622 lab=_75966_/X }
C {sky130_stdcells/xor2_4.sym} 80820 -4720 0 0 {name=X_75966_ }
C {devices/lab_pin.sym} 80740 -4630 0 0 {name=p80623 lab=_41960_/X }
C {devices/lab_pin.sym} 80740 -4590 0 0 {name=p80624 lab=_42006_/X }
C {devices/lab_pin.sym} 80740 -4550 0 0 {name=p80625 lab=_40814_/X }
C {devices/lab_pin.sym} 80740 -4510 0 0 {name=p80626 lab=_73033_/A }
C {devices/lab_pin.sym} 80740 -4470 0 0 {name=p80627 lab=_42007_/X }
C {devices/lab_pin.sym} 80900 -4550 0 1 {name=p80628 lab=_42009_/A }
C {sky130_stdcells/o32ai_4.sym} 80820 -4550 0 0 {name=X_42008_ }
C {devices/lab_pin.sym} 80760 -4400 0 0 {name=p80629 lab=_77704_/Y }
C {devices/lab_pin.sym} 80760 -4360 0 0 {name=p80630 lab=_77702_/A }
C {devices/lab_pin.sym} 80880 -4380 0 1 {name=p80631 lab=_77710_/A }
C {sky130_stdcells/nand2_4.sym} 80820 -4380 0 0 {name=X_77705_ }
C {devices/lab_pin.sym} 80740 -4270 0 0 {name=p80632 lab=_62929_/Y }
C {devices/lab_pin.sym} 80740 -4230 0 0 {name=p80633 lab=_62893_/X }
C {devices/lab_pin.sym} 80740 -4190 0 0 {name=p80634 lab=_62930_/Y }
C {devices/lab_pin.sym} 80900 -4230 0 1 {name=p80635 lab=_84369_/D }
C {sky130_stdcells/a21oi_4.sym} 80820 -4230 0 0 {name=X_62931_ }
C {devices/lab_pin.sym} 80740 -4110 0 0 {name=p80636 lab=_74908_/Y }
C {devices/lab_pin.sym} 80740 -4070 0 0 {name=p80637 lab=_74915_/Y }
C {devices/lab_pin.sym} 80740 -4030 0 0 {name=p80638 lab=_74916_/Y }
C {devices/lab_pin.sym} 80900 -4070 0 1 {name=p80639 lab=_74917_/X }
C {sky130_stdcells/o21a_4.sym} 80820 -4070 0 0 {name=X_74917_ }
C {devices/lab_pin.sym} 80760 -3940 0 0 {name=p80640 lab=_47855_/A }
C {devices/lab_pin.sym} 80760 -3900 0 0 {name=p80641 lab=_51947_/B }
C {devices/lab_pin.sym} 80880 -3920 0 1 {name=p80642 lab=_47865_/Y }
C {sky130_stdcells/nand2_4.sym} 80820 -3920 0 0 {name=X_47865_ }
C {devices/lab_pin.sym} 80760 -3800 0 0 {name=p80643 lab=_78685_/A }
C {devices/lab_pin.sym} 80760 -3760 0 0 {name=p80644 lab=_78684_/X }
C {devices/lab_pin.sym} 80880 -3780 0 1 {name=p80645 lab=_78701_/A }
C {sky130_stdcells/xnor2_4.sym} 80820 -3780 0 0 {name=X_78685_ }
C {devices/lab_pin.sym} 80760 -3660 0 0 {name=p80646 lab=_61262_/C }
C {devices/lab_pin.sym} 80760 -3620 0 0 {name=p80647 lab=_84367_/Q }
C {devices/lab_pin.sym} 80880 -3640 0 1 {name=p80648 lab=_75897_/X }
C {sky130_stdcells/xor2_4.sym} 80820 -3640 0 0 {name=X_75897_ }
C {devices/lab_pin.sym} 80740 -3530 0 0 {name=p80649 lab=_49601_/Y }
C {devices/lab_pin.sym} 80740 -3490 0 0 {name=p80650 lab=_49596_/X }
C {devices/lab_pin.sym} 80740 -3450 0 0 {name=p80651 lab=_49603_/X }
C {devices/lab_pin.sym} 80900 -3490 0 1 {name=p80652 lab=_49604_/Y }
C {sky130_stdcells/a21oi_4.sym} 80820 -3490 0 0 {name=X_49604_ }
C {devices/lab_pin.sym} 80780 -3350 0 0 {name=p80653 lab=_52692_/B }
C {devices/lab_pin.sym} 80860 -3350 0 1 {name=p80654 lab=_50998_/B }
C {sky130_stdcells/buf_2.sym} 80820 -3350 0 0 {name=X_46816_ }
C {devices/lab_pin.sym} 80780 -3230 0 0 {name=p80655 lab=_84187_/Q }
C {devices/lab_pin.sym} 80860 -3230 0 1 {name=p80656 lab=_65651_/C }
C {sky130_stdcells/inv_2.sym} 80820 -3230 0 0 {name=X_65650_ }
C {devices/lab_pin.sym} 80780 -3110 0 0 {name=p80657 lab=_77635_/X }
C {devices/lab_pin.sym} 80860 -3110 0 1 {name=p80658 lab=_77636_/Y }
C {sky130_stdcells/inv_2.sym} 80820 -3110 0 0 {name=X_77636_ }
C {devices/lab_pin.sym} 80760 -3020 0 0 {name=p80659 lab=_62847_/X }
C {devices/lab_pin.sym} 80760 -2980 0 0 {name=p80660 lab=_63209_/A }
C {devices/lab_pin.sym} 80760 -2940 0 0 {name=p80661 lab=_62911_/C }
C {devices/lab_pin.sym} 80760 -2900 0 0 {name=p80662 lab=_62880_/D }
C {devices/lab_pin.sym} 80880 -2960 0 1 {name=p80663 lab=_62862_/X }
C {sky130_stdcells/and4_4.sym} 80820 -2960 0 0 {name=X_62862_ }
C {devices/lab_pin.sym} 80760 -2820 0 0 {name=p80664 lab=_81122_/D }
C {devices/lab_pin.sym} 80760 -2780 0 0 {name=p80665 lab=_74848_/B }
C {devices/lab_pin.sym} 80880 -2800 0 1 {name=p80666 lab=_74849_/B }
C {sky130_stdcells/xor2_4.sym} 80820 -2800 0 0 {name=X_74848_ }
C {devices/lab_pin.sym} 80740 -2690 0 0 {name=p80667 lab=_47790_/Y }
C {devices/lab_pin.sym} 80740 -2650 0 0 {name=p80668 lab=_47791_/X }
C {devices/lab_pin.sym} 80740 -2610 0 0 {name=p80669 lab=_47795_/X }
C {devices/lab_pin.sym} 80900 -2650 0 1 {name=p80670 lab=_47796_/Y }
C {sky130_stdcells/a21oi_4.sym} 80820 -2650 0 0 {name=X_47796_ }
C {devices/lab_pin.sym} 80780 -2510 0 0 {name=p80671 lab=_64601_/A }
C {devices/lab_pin.sym} 80860 -2510 0 1 {name=p80672 lab=_64602_/A }
C {sky130_stdcells/buf_2.sym} 80820 -2510 0 0 {name=X_64601_ }
C {devices/lab_pin.sym} 80760 -2400 0 0 {name=p80673 lab=_49546_/A }
C {devices/lab_pin.sym} 80760 -2360 0 0 {name=p80674 lab=_52748_/B }
C {devices/lab_pin.sym} 80880 -2380 0 1 {name=p80675 lab=_49535_/Y }
C {sky130_stdcells/nand2_4.sym} 80820 -2380 0 0 {name=X_49535_ }
C {devices/lab_pin.sym} 80760 -2280 0 0 {name=p80676 lab=_61811_/X }
C {devices/lab_pin.sym} 80760 -2240 0 0 {name=p80677 lab=_61765_/B }
C {devices/lab_pin.sym} 80760 -2200 0 0 {name=p80678 lab=_61846_/C }
C {devices/lab_pin.sym} 80760 -2160 0 0 {name=p80679 lab=_61846_/D }
C {devices/lab_pin.sym} 80880 -2220 0 1 {name=p80680 lab=_61813_/Y }
C {sky130_stdcells/nand4_4.sym} 80820 -2220 0 0 {name=X_61813_ }
C {devices/lab_pin.sym} 80780 -2070 0 0 {name=p80681 lab=_83675_/Q }
C {devices/lab_pin.sym} 80860 -2070 0 1 {name=p80682 lab=_52651_/B }
C {sky130_stdcells/inv_2.sym} 80820 -2070 0 0 {name=X_46747_ }
C {devices/lab_pin.sym} 80740 -1980 0 0 {name=p80683 lab=_65503_/X }
C {devices/lab_pin.sym} 80740 -1940 0 0 {name=p80684 lab=_85591_/Q }
C {devices/lab_pin.sym} 80740 -1900 0 0 {name=p80685 lab=_65504_/X }
C {devices/lab_pin.sym} 80740 -1860 0 0 {name=p80686 lab=_65580_/X }
C {devices/lab_pin.sym} 80900 -1920 0 1 {name=p80687 lab=_65581_/X }
C {sky130_stdcells/a211o_4.sym} 80820 -1920 0 0 {name=X_65581_ }
C {devices/lab_pin.sym} 80760 -1780 0 0 {name=p80688 lab=_77568_/A }
C {devices/lab_pin.sym} 80760 -1740 0 0 {name=p80689 lab=_82105_/D }
C {devices/lab_pin.sym} 80880 -1760 0 1 {name=p80690 lab=_77567_/Y }
C {sky130_stdcells/nor2_4.sym} 80820 -1760 0 0 {name=X_77567_ }
C {devices/lab_pin.sym} 80760 -1640 0 0 {name=p80691 lab=_43959_/A }
C {devices/lab_pin.sym} 80760 -1600 0 0 {name=p80692 lab=_43959_/B }
C {devices/lab_pin.sym} 80880 -1620 0 1 {name=p80693 lab=_59538_/D }
C {sky130_stdcells/and2_4.sym} 80820 -1620 0 0 {name=X_43959_ }
C {devices/lab_pin.sym} 80780 -1490 0 0 {name=p80694 lab=_62672_/A }
C {devices/lab_pin.sym} 80860 -1490 0 1 {name=p80695 lab=_62839_/B }
C {sky130_stdcells/buf_2.sym} 80820 -1490 0 0 {name=X_62793_ }
C {devices/lab_pin.sym} 80740 -1400 0 0 {name=p80696 lab=_70180_/Y }
C {devices/lab_pin.sym} 80740 -1360 0 0 {name=p80697 lab=_70692_/C }
C {devices/lab_pin.sym} 80740 -1320 0 0 {name=p80698 lab=_83830_/Q }
C {devices/lab_pin.sym} 80740 -1280 0 0 {name=p80699 lab=_74716_/X }
C {devices/lab_pin.sym} 80900 -1340 0 1 {name=p80700 lab=_74779_/X }
C {sky130_stdcells/a2bb2o_4.sym} 80820 -1340 0 0 {name=X_74779_ }
C {devices/lab_pin.sym} 80760 -1200 0 0 {name=p80701 lab=_67320_/A }
C {devices/lab_pin.sym} 80760 -1160 0 0 {name=p80702 lab=_86775_/Q }
C {devices/lab_pin.sym} 80880 -1180 0 1 {name=p80703 lab=_67320_/X }
C {sky130_stdcells/and2_4.sym} 80820 -1180 0 0 {name=X_67320_ }
C {devices/lab_pin.sym} 80760 -1060 0 0 {name=p80704 lab=_79303_/X }
C {devices/lab_pin.sym} 80760 -1020 0 0 {name=p80705 lab=_79306_/B }
C {devices/lab_pin.sym} 80880 -1040 0 1 {name=p80706 lab=_82829_/D }
C {sky130_stdcells/xor2_4.sym} 80820 -1040 0 0 {name=X_79306_ }
C {devices/lab_pin.sym} 80780 -910 0 0 {name=p80707 lab=_72381_/A }
C {devices/lab_pin.sym} 80860 -910 0 1 {name=p80708 lab=_64532_/X }
C {sky130_stdcells/buf_2.sym} 80820 -910 0 0 {name=X_64532_ }
C {devices/lab_pin.sym} 80760 -800 0 0 {name=p80709 lab=_76518_/A }
C {devices/lab_pin.sym} 80760 -760 0 0 {name=p80710 lab=_76518_/B }
C {devices/lab_pin.sym} 80880 -780 0 1 {name=p80711 lab=_76518_/X }
C {sky130_stdcells/xor2_4.sym} 80820 -780 0 0 {name=X_76518_ }
C {devices/lab_pin.sym} 81700 -42150 0 0 {name=p80712 lab=_84728_/Q }
C {devices/lab_pin.sym} 81780 -42150 0 1 {name=p80713 lab=_61744_/X }
C {sky130_stdcells/buf_2.sym} 81740 -42150 0 0 {name=X_61744_ }
C {devices/lab_pin.sym} 81700 -42030 0 0 {name=p80714 lab=_49493_/A }
C {devices/lab_pin.sym} 81780 -42030 0 1 {name=p80715 lab=_49467_/C }
C {sky130_stdcells/buf_2.sym} 81740 -42030 0 0 {name=X_49466_ }
C {devices/lab_pin.sym} 81660 -41930 0 0 {name=p80716 lab=_58649_/A }
C {devices/lab_pin.sym} 81660 -41890 0 0 {name=p80717 lab=_46672_/X }
C {devices/lab_pin.sym} 81660 -41850 0 0 {name=p80718 lab=_46677_/Y }
C {devices/lab_pin.sym} 81820 -41890 0 1 {name=p80719 lab=_46678_/Y }
C {sky130_stdcells/o21ai_4.sym} 81740 -41890 0 0 {name=X_46678_ }
C {devices/lab_pin.sym} 81680 -41770 0 0 {name=p80720 lab=_77458_/X }
C {devices/lab_pin.sym} 81680 -41730 0 0 {name=p80721 lab=_77480_/Y }
C {devices/lab_pin.sym} 81680 -41690 0 0 {name=p80722 lab=_77478_/X }
C {devices/lab_pin.sym} 81800 -41730 0 1 {name=p80723 lab=_77498_/X }
C {sky130_stdcells/and3_4.sym} 81740 -41730 0 0 {name=X_77498_ }
C {devices/lab_pin.sym} 81680 -41600 0 0 {name=p80724 lab=_48557_/A }
C {devices/lab_pin.sym} 81680 -41560 0 0 {name=p80725 lab=_52123_/B }
C {devices/lab_pin.sym} 81800 -41580 0 1 {name=p80726 lab=_48417_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -41580 0 0 {name=X_48417_ }
C {devices/lab_pin.sym} 81660 -41480 0 0 {name=p80727 lab=_87415_/Q }
C {devices/lab_pin.sym} 81660 -41440 0 0 {name=p80728 lab=_67156_/X }
C {devices/lab_pin.sym} 81660 -41400 0 0 {name=p80729 lab=_67226_/X }
C {devices/lab_pin.sym} 81660 -41360 0 0 {name=p80730 lab=_67250_/X }
C {devices/lab_pin.sym} 81820 -41420 0 1 {name=p80731 lab=_67251_/X }
C {sky130_stdcells/a211o_4.sym} 81740 -41420 0 0 {name=X_67251_ }
C {devices/lab_pin.sym} 81660 -41290 0 0 {name=p80732 lab=_79213_/Y }
C {devices/lab_pin.sym} 81660 -41250 0 0 {name=p80733 lab=_79215_/X }
C {devices/lab_pin.sym} 81660 -41210 0 0 {name=p80734 lab=_79236_/Y }
C {devices/lab_pin.sym} 81820 -41250 0 1 {name=p80735 lab=_79239_/A }
C {sky130_stdcells/a21oi_4.sym} 81740 -41250 0 0 {name=X_79237_ }
C {devices/lab_pin.sym} 81680 -41120 0 0 {name=p80736 lab=_85074_/Q }
C {devices/lab_pin.sym} 81680 -41080 0 0 {name=p80737 lab=_45801_/A }
C {devices/lab_pin.sym} 81800 -41100 0 1 {name=p80738 lab=_45629_/Y }
C {sky130_stdcells/nor2_4.sym} 81740 -41100 0 0 {name=X_45629_ }
C {devices/lab_pin.sym} 81660 -40990 0 0 {name=p80739 lab=_64461_/Y }
C {devices/lab_pin.sym} 81660 -40950 0 0 {name=p80740 lab=_64186_/X }
C {devices/lab_pin.sym} 81660 -40910 0 0 {name=p80741 lab=_64462_/Y }
C {devices/lab_pin.sym} 81820 -40950 0 1 {name=p80742 lab=_64463_/Y }
C {sky130_stdcells/a21oi_4.sym} 81740 -40950 0 0 {name=X_64463_ }
C {devices/lab_pin.sym} 81680 -40820 0 0 {name=p80743 lab=_81366_/Q }
C {devices/lab_pin.sym} 81680 -40780 0 0 {name=p80744 lab=_76449_/B }
C {devices/lab_pin.sym} 81800 -40800 0 1 {name=p80745 lab=_76449_/X }
C {sky130_stdcells/xor2_4.sym} 81740 -40800 0 0 {name=X_76449_ }
C {devices/lab_pin.sym} 81680 -40700 0 0 {name=p80746 lab=_49397_/A }
C {devices/lab_pin.sym} 81680 -40660 0 0 {name=p80747 lab=_49420_/B }
C {devices/lab_pin.sym} 81680 -40620 0 0 {name=p80748 lab=_49408_/C }
C {devices/lab_pin.sym} 81680 -40580 0 0 {name=p80749 lab=_50919_/D }
C {devices/lab_pin.sym} 81800 -40640 0 1 {name=p80750 lab=_49397_/X }
C {sky130_stdcells/and4_4.sym} 81740 -40640 0 0 {name=X_49397_ }
C {devices/lab_pin.sym} 81680 -40510 0 0 {name=p80751 lab=_61292_/A }
C {devices/lab_pin.sym} 81680 -40470 0 0 {name=p80752 lab=_61675_/B }
C {devices/lab_pin.sym} 81680 -40430 0 0 {name=p80753 lab=_61675_/C }
C {devices/lab_pin.sym} 81800 -40470 0 1 {name=p80754 lab=_61675_/Y }
C {sky130_stdcells/nand3_4.sym} 81740 -40470 0 0 {name=X_61675_ }
C {devices/lab_pin.sym} 81660 -40360 0 0 {name=p80755 lab=_57761_/X }
C {devices/lab_pin.sym} 81660 -40320 0 0 {name=p80756 lab=_84973_/Q }
C {devices/lab_pin.sym} 81660 -40280 0 0 {name=p80757 lab=_65950_/X }
C {devices/lab_pin.sym} 81660 -40240 0 0 {name=p80758 lab=_66201_/X }
C {devices/lab_pin.sym} 81820 -40300 0 1 {name=p80759 lab=_66203_/C }
C {sky130_stdcells/a211o_4.sym} 81740 -40300 0 0 {name=X_66202_ }
C {devices/lab_pin.sym} 81680 -40170 0 0 {name=p80760 lab=_63400_/A }
C {devices/lab_pin.sym} 81680 -40130 0 0 {name=p80761 lab=_58232_/A }
C {devices/lab_pin.sym} 81680 -40090 0 0 {name=p80762 lab=_63463_/C }
C {devices/lab_pin.sym} 81800 -40130 0 1 {name=p80763 lab=_63414_/X }
C {sky130_stdcells/and3_4.sym} 81740 -40130 0 0 {name=X_63414_ }
C {devices/lab_pin.sym} 81680 -40000 0 0 {name=p80764 lab=_48348_/A }
C {devices/lab_pin.sym} 81680 -39960 0 0 {name=p80765 lab=_50385_/B }
C {devices/lab_pin.sym} 81800 -39980 0 1 {name=p80766 lab=_48348_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -39980 0 0 {name=X_48348_ }
C {devices/lab_pin.sym} 81700 -39850 0 0 {name=p80767 lab=_60626_/A }
C {devices/lab_pin.sym} 81780 -39850 0 1 {name=p80768 lab=_60628_/A }
C {sky130_stdcells/inv_2.sym} 81740 -39850 0 0 {name=X_60626_ }
C {devices/lab_pin.sym} 81700 -39730 0 0 {name=p80769 lab=_67062_/X }
C {devices/lab_pin.sym} 81780 -39730 0 1 {name=p80770 lab=_67183_/A }
C {sky130_stdcells/buf_2.sym} 81740 -39730 0 0 {name=X_67182_ }
C {devices/lab_pin.sym} 81700 -39610 0 0 {name=p80771 lab=_79168_/A }
C {devices/lab_pin.sym} 81780 -39610 0 1 {name=p80772 lab=_79169_/A }
C {sky130_stdcells/inv_2.sym} 81740 -39610 0 0 {name=X_79168_ }
C {devices/lab_pin.sym} 81680 -39510 0 0 {name=p80773 lab=_64380_/X }
C {devices/lab_pin.sym} 81680 -39470 0 0 {name=p80774 lab=_84818_/Q }
C {devices/lab_pin.sym} 81680 -39430 0 0 {name=p80775 lab=_64381_/X }
C {devices/lab_pin.sym} 81800 -39470 0 1 {name=p80776 lab=_64394_/Y }
C {sky130_stdcells/nand3_4.sym} 81740 -39470 0 0 {name=X_64394_ }
C {devices/lab_pin.sym} 81660 -39360 0 0 {name=p80777 lab=_66040_/X }
C {devices/lab_pin.sym} 81660 -39320 0 0 {name=p80778 lab=_84978_/Q }
C {devices/lab_pin.sym} 81660 -39280 0 0 {name=p80779 lab=_66027_/X }
C {devices/lab_pin.sym} 81660 -39240 0 0 {name=p80780 lab=_66132_/X }
C {devices/lab_pin.sym} 81820 -39300 0 1 {name=p80781 lab=_66133_/X }
C {sky130_stdcells/a211o_4.sym} 81740 -39300 0 0 {name=X_66133_ }
C {devices/lab_pin.sym} 81660 -39170 0 0 {name=p80782 lab=_78120_/A }
C {devices/lab_pin.sym} 81660 -39130 0 0 {name=p80783 lab=_78120_/C }
C {devices/lab_pin.sym} 81660 -39090 0 0 {name=p80784 lab=_78120_/B }
C {devices/lab_pin.sym} 81820 -39130 0 1 {name=p80785 lab=_78119_/X }
C {sky130_stdcells/a21o_4.sym} 81740 -39130 0 0 {name=X_78119_ }
C {devices/lab_pin.sym} 81660 -39010 0 0 {name=p80786 lab=_63343_/Y }
C {devices/lab_pin.sym} 81660 -38970 0 0 {name=p80787 lab=_63344_/X }
C {devices/lab_pin.sym} 81660 -38930 0 0 {name=p80788 lab=_63317_/X }
C {devices/lab_pin.sym} 81820 -38970 0 1 {name=p80789 lab=_63345_/X }
C {sky130_stdcells/a21o_4.sym} 81740 -38970 0 0 {name=X_63345_ }
C {devices/lab_pin.sym} 81680 -38840 0 0 {name=p80790 lab=_48244_/A }
C {devices/lab_pin.sym} 81680 -38800 0 0 {name=p80791 lab=_48024_/B }
C {devices/lab_pin.sym} 81800 -38820 0 1 {name=p80792 lab=_48279_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -38820 0 0 {name=X_48279_ }
C {devices/lab_pin.sym} 81700 -38690 0 0 {name=p80793 lab=_60556_/Y }
C {devices/lab_pin.sym} 81780 -38690 0 1 {name=p80794 lab=_60557_/Y }
C {sky130_stdcells/inv_2.sym} 81740 -38690 0 0 {name=X_60557_ }
C {devices/lab_pin.sym} 81700 -38570 0 0 {name=p80795 lab=_79099_/A }
C {devices/lab_pin.sym} 81780 -38570 0 1 {name=p80796 lab=_79099_/Y }
C {sky130_stdcells/inv_2.sym} 81740 -38570 0 0 {name=X_79099_ }
C {devices/lab_pin.sym} 81680 -38460 0 0 {name=p80797 lab=_50240_/A }
C {devices/lab_pin.sym} 81680 -38420 0 0 {name=p80798 lab=_50310_/B }
C {devices/lab_pin.sym} 81800 -38440 0 1 {name=p80799 lab=_50310_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -38440 0 0 {name=X_50310_ }
C {devices/lab_pin.sym} 81650 -38310 0 0 {name=p80800 lab=_81130_/CLK }
C {devices/lab_pin.sym} 81650 -38290 0 0 {name=p80801 lab=_81130_/D }
C {devices/lab_pin.sym} 81830 -38310 0 1 {name=p80802 lab=_40714_/A }
C {sky130_stdcells/dfxtp_4.sym} 81740 -38300 0 0 {name=X_81130_ }
C {devices/lab_pin.sym} 81700 -38170 0 0 {name=p80803 lab=_66064_/A }
C {devices/lab_pin.sym} 81780 -38170 0 1 {name=p80804 lab=_66065_/A }
C {sky130_stdcells/buf_2.sym} 81740 -38170 0 0 {name=X_66064_ }
C {devices/lab_pin.sym} 81680 -38060 0 0 {name=p80805 lab=_51298_/A }
C {devices/lab_pin.sym} 81680 -38020 0 0 {name=p80806 lab=_51290_/B }
C {devices/lab_pin.sym} 81800 -38040 0 1 {name=p80807 lab=_51290_/X }
C {sky130_stdcells/and2_4.sym} 81740 -38040 0 0 {name=X_51290_ }
C {devices/lab_pin.sym} 81680 -37930 0 0 {name=p80808 lab=_63285_/A }
C {devices/lab_pin.sym} 81680 -37890 0 0 {name=p80809 lab=_63285_/B }
C {devices/lab_pin.sym} 81680 -37850 0 0 {name=p80810 lab=_79267_/A }
C {devices/lab_pin.sym} 81800 -37890 0 1 {name=p80811 lab=_63276_/Y }
C {sky130_stdcells/nor3_4.sym} 81740 -37890 0 0 {name=X_63276_ }
C {devices/lab_pin.sym} 81680 -37770 0 0 {name=p80812 lab=_60488_/A }
C {devices/lab_pin.sym} 81680 -37730 0 0 {name=p80813 lab=_60488_/B }
C {devices/lab_pin.sym} 81680 -37690 0 0 {name=p80814 lab=_60488_/C }
C {devices/lab_pin.sym} 81800 -37730 0 1 {name=p80815 lab=_60488_/Y }
C {sky130_stdcells/nand3_4.sym} 81740 -37730 0 0 {name=X_60488_ }
C {devices/lab_pin.sym} 81700 -37590 0 0 {name=p80816 lab=_64600_/A }
C {devices/lab_pin.sym} 81780 -37590 0 1 {name=p80817 lab=_65015_/X }
C {sky130_stdcells/buf_2.sym} 81740 -37590 0 0 {name=X_65015_ }
C {devices/lab_pin.sym} 81660 -37490 0 0 {name=p80818 lab=_86238_/Q }
C {devices/lab_pin.sym} 81660 -37450 0 0 {name=p80819 lab=_50238_/X }
C {devices/lab_pin.sym} 81660 -37410 0 0 {name=p80820 lab=_50240_/Y }
C {devices/lab_pin.sym} 81820 -37450 0 1 {name=p80821 lab=_50241_/Y }
C {sky130_stdcells/o21ai_4.sym} 81740 -37450 0 0 {name=X_50241_ }
C {devices/lab_pin.sym} 81700 -37310 0 0 {name=p80822 lab=_62620_/A }
C {devices/lab_pin.sym} 81780 -37310 0 1 {name=p80823 lab=_62632_/A }
C {sky130_stdcells/buf_2.sym} 81740 -37310 0 0 {name=X_62227_ }
C {devices/lab_pin.sym} 81650 -37190 0 0 {name=p80824 lab=_81061_/CLK }
C {devices/lab_pin.sym} 81650 -37170 0 0 {name=p80825 lab=_81093_/Q }
C {devices/lab_pin.sym} 81830 -37190 0 1 {name=p80826 lab=_81061_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -37180 0 0 {name=X_81061_ }
C {devices/lab_pin.sym} 81660 -37070 0 0 {name=p80827 lab=_79988_/A }
C {devices/lab_pin.sym} 81660 -37030 0 0 {name=p80828 lab=_80011_/D }
C {devices/lab_pin.sym} 81660 -36990 0 0 {name=p80829 lab=_80011_/B }
C {devices/lab_pin.sym} 81820 -37030 0 1 {name=p80830 lab=_80012_/X }
C {sky130_stdcells/a21bo_4.sym} 81740 -37030 0 0 {name=X_80012_ }
C {devices/lab_pin.sym} 81680 -36900 0 0 {name=p80831 lab=_69908_/A }
C {devices/lab_pin.sym} 81680 -36860 0 0 {name=p80832 lab=_69823_/B }
C {devices/lab_pin.sym} 81800 -36880 0 1 {name=p80833 lab=_69823_/Y }
C {sky130_stdcells/nor2_4.sym} 81740 -36880 0 0 {name=X_69823_ }
C {devices/lab_pin.sym} 81660 -36770 0 0 {name=p80834 lab=_50170_/Y }
C {devices/lab_pin.sym} 81660 -36730 0 0 {name=p80835 lab=_50166_/X }
C {devices/lab_pin.sym} 81660 -36690 0 0 {name=p80836 lab=_50171_/X }
C {devices/lab_pin.sym} 81820 -36730 0 1 {name=p80837 lab=_86250_/D }
C {sky130_stdcells/a21oi_4.sym} 81740 -36730 0 0 {name=X_50172_ }
C {devices/lab_pin.sym} 81680 -36620 0 0 {name=p80838 lab=_59730_/A }
C {devices/lab_pin.sym} 81680 -36580 0 0 {name=p80839 lab=_62170_/B }
C {devices/lab_pin.sym} 81680 -36540 0 0 {name=p80840 lab=_62158_/C }
C {devices/lab_pin.sym} 81680 -36500 0 0 {name=p80841 lab=_63333_/B }
C {devices/lab_pin.sym} 81800 -36560 0 1 {name=p80842 lab=_62158_/X }
C {sky130_stdcells/and4_4.sym} 81740 -36560 0 0 {name=X_62158_ }
C {devices/lab_pin.sym} 81700 -36410 0 0 {name=p80843 lab=_61108_/Y }
C {devices/lab_pin.sym} 81780 -36410 0 1 {name=p80844 lab=_61109_/X }
C {sky130_stdcells/buf_2.sym} 81740 -36410 0 0 {name=X_61109_ }
C {devices/lab_pin.sym} 81650 -36290 0 0 {name=p80845 lab=_83451_/CLK }
C {devices/lab_pin.sym} 81650 -36270 0 0 {name=p80846 lab=_58555_/X }
C {devices/lab_pin.sym} 81830 -36290 0 1 {name=p80847 lab=_84820_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -36280 0 0 {name=X_84820_ }
C {devices/lab_pin.sym} 81660 -36170 0 0 {name=p80848 lab=_69750_/X }
C {devices/lab_pin.sym} 81660 -36130 0 0 {name=p80849 lab=_69753_/X }
C {devices/lab_pin.sym} 81660 -36090 0 0 {name=p80850 lab=_68697_/X }
C {devices/lab_pin.sym} 81820 -36130 0 1 {name=p80851 lab=_69758_/A }
C {sky130_stdcells/a21o_4.sym} 81740 -36130 0 0 {name=X_69754_ }
C {devices/lab_pin.sym} 81660 -36010 0 0 {name=p80852 lab=_54977_/Y }
C {devices/lab_pin.sym} 81660 -35970 0 0 {name=p80853 lab=_54971_/X }
C {devices/lab_pin.sym} 81660 -35930 0 0 {name=p80854 lab=_54979_/X }
C {devices/lab_pin.sym} 81820 -35970 0 1 {name=p80855 lab=_54980_/Y }
C {sky130_stdcells/a21oi_4.sym} 81740 -35970 0 0 {name=X_54980_ }
C {devices/lab_pin.sym} 81680 -35840 0 0 {name=p80856 lab=_66942_/A }
C {devices/lab_pin.sym} 81680 -35800 0 0 {name=p80857 lab=_66966_/B }
C {devices/lab_pin.sym} 81800 -35820 0 1 {name=p80858 lab=_66966_/X }
C {sky130_stdcells/and2_4.sym} 81740 -35820 0 0 {name=X_66966_ }
C {devices/lab_pin.sym} 81660 -35730 0 0 {name=p80859 lab=_62082_/X }
C {devices/lab_pin.sym} 81660 -35690 0 0 {name=p80860 lab=_62084_/X }
C {devices/lab_pin.sym} 81660 -35650 0 0 {name=p80861 lab=_62088_/Y }
C {devices/lab_pin.sym} 81660 -35610 0 0 {name=p80862 lab=_58465_/A }
C {devices/lab_pin.sym} 81660 -35570 0 0 {name=p80863 lab=_62048_/X }
C {devices/lab_pin.sym} 81820 -35650 0 1 {name=p80864 lab=_62089_/Y }
C {sky130_stdcells/o32ai_4.sym} 81740 -35650 0 0 {name=X_62089_ }
C {devices/lab_pin.sym} 81660 -35520 0 0 {name=p80865 lab=_87494_/Q }
C {devices/lab_pin.sym} 81660 -35480 0 0 {name=p80866 lab=_68626_/X }
C {devices/lab_pin.sym} 81660 -35440 0 0 {name=p80867 lab=_68601_/X }
C {devices/lab_pin.sym} 81660 -35400 0 0 {name=p80868 lab=_68704_/X }
C {devices/lab_pin.sym} 81820 -35460 0 1 {name=p80869 lab=_68705_/X }
C {sky130_stdcells/a211o_4.sym} 81740 -35460 0 0 {name=X_68705_ }
C {devices/lab_pin.sym} 81660 -35330 0 0 {name=p80870 lab=_53928_/Y }
C {devices/lab_pin.sym} 81660 -35290 0 0 {name=p80871 lab=_53914_/X }
C {devices/lab_pin.sym} 81660 -35250 0 0 {name=p80872 lab=_53930_/Y }
C {devices/lab_pin.sym} 81820 -35290 0 1 {name=p80873 lab=_53931_/Y }
C {sky130_stdcells/a21boi_4.sym} 81740 -35290 0 0 {name=X_53931_ }
C {devices/lab_pin.sym} 81660 -35170 0 0 {name=p80874 lab=_65914_/Y }
C {devices/lab_pin.sym} 81660 -35130 0 0 {name=p80875 lab=_65915_/X }
C {devices/lab_pin.sym} 81660 -35090 0 0 {name=p80876 lab=_65916_/X }
C {devices/lab_pin.sym} 81820 -35130 0 1 {name=p80877 lab=_84169_/D }
C {sky130_stdcells/a21o_4.sym} 81740 -35130 0 0 {name=X_65917_ }
C {devices/lab_pin.sym} 81650 -34990 0 0 {name=p80878 lab=_84757_/CLK }
C {devices/lab_pin.sym} 81650 -34970 0 0 {name=p80879 lab=_59324_/Y }
C {devices/lab_pin.sym} 81830 -34990 0 1 {name=p80880 lab=_84751_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -34980 0 0 {name=X_84751_ }
C {devices/lab_pin.sym} 81650 -34850 0 0 {name=p80881 lab=_82299_/CLK }
C {devices/lab_pin.sym} 81650 -34830 0 0 {name=p80882 lab=_81963_/D }
C {devices/lab_pin.sym} 81830 -34850 0 1 {name=p80883 lab=_81963_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -34840 0 0 {name=X_81963_ }
C {devices/lab_pin.sym} 81680 -34720 0 0 {name=p80884 lab=_69685_/A }
C {devices/lab_pin.sym} 81680 -34680 0 0 {name=p80885 lab=_87306_/Q }
C {devices/lab_pin.sym} 81800 -34700 0 1 {name=p80886 lab=_69685_/X }
C {sky130_stdcells/and2_4.sym} 81740 -34700 0 0 {name=X_69685_ }
C {devices/lab_pin.sym} 81700 -34570 0 0 {name=p80887 lab=_69654_/A }
C {devices/lab_pin.sym} 81780 -34570 0 1 {name=p80888 lab=_69156_/A }
C {sky130_stdcells/buf_2.sym} 81740 -34570 0 0 {name=X_66897_ }
C {devices/lab_pin.sym} 81650 -34450 0 0 {name=p80889 lab=_83703_/CLK }
C {devices/lab_pin.sym} 81650 -34430 0 0 {name=p80890 lab=_83702_/D }
C {devices/lab_pin.sym} 81830 -34450 0 1 {name=p80891 lab=_83702_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -34440 0 0 {name=X_83702_ }
C {devices/lab_pin.sym} 81680 -34320 0 0 {name=p80892 lab=_56649_/X }
C {devices/lab_pin.sym} 81680 -34280 0 0 {name=p80893 lab=_56650_/B }
C {devices/lab_pin.sym} 81800 -34300 0 1 {name=p80894 lab=_56650_/Y }
C {sky130_stdcells/nor2_4.sym} 81740 -34300 0 0 {name=X_56650_ }
C {devices/lab_pin.sym} 81650 -34170 0 0 {name=p80895 lab=_81507_/CLK }
C {devices/lab_pin.sym} 81650 -34150 0 0 {name=p80896 lab=_80914_/D }
C {devices/lab_pin.sym} 81830 -34170 0 1 {name=p80897 lab=_80914_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -34160 0 0 {name=X_80914_ }
C {devices/lab_pin.sym} 81700 -34030 0 0 {name=p80898 lab=clkbuf_3_5_1_CLK/X }
C {devices/lab_pin.sym} 81780 -34030 0 1 {name=p80899 lab=clkbuf_4_10_1_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 81740 -34030 0 0 {name=Xclkbuf_4_10_0_CLK }
C {devices/lab_pin.sym} 81700 -33910 0 0 {name=p80900 lab=_69747_/A }
C {devices/lab_pin.sym} 81780 -33910 0 1 {name=p80901 lab=_68636_/X }
C {sky130_stdcells/buf_2.sym} 81740 -33910 0 0 {name=X_68636_ }
C {devices/lab_pin.sym} 81650 -33790 0 0 {name=p80902 lab=_86934_/CLK }
C {devices/lab_pin.sym} 81650 -33770 0 0 {name=p80903 lab=_87470_/D }
C {devices/lab_pin.sym} 81830 -33790 0 1 {name=p80904 lab=_87470_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -33780 0 0 {name=X_87470_ }
C {devices/lab_pin.sym} 81700 -33650 0 0 {name=p80905 lab=_53838_/A }
C {devices/lab_pin.sym} 81780 -33650 0 1 {name=p80906 lab=_53862_/X }
C {sky130_stdcells/buf_2.sym} 81740 -33650 0 0 {name=X_53862_ }
C {devices/lab_pin.sym} 81680 -33540 0 0 {name=p80907 lab=_65807_/A }
C {devices/lab_pin.sym} 81680 -33500 0 0 {name=p80908 lab=_86469_/Q }
C {devices/lab_pin.sym} 81800 -33520 0 1 {name=p80909 lab=_65848_/X }
C {sky130_stdcells/and2_4.sym} 81740 -33520 0 0 {name=X_65848_ }
C {devices/lab_pin.sym} 81650 -33390 0 0 {name=p80910 lab=_84713_/CLK }
C {devices/lab_pin.sym} 81650 -33370 0 0 {name=p80911 lab=_59874_/Y }
C {devices/lab_pin.sym} 81830 -33390 0 1 {name=p80912 lab=_80266_/B }
C {sky130_stdcells/dfxtp_4.sym} 81740 -33380 0 0 {name=X_84682_ }
C {devices/lab_pin.sym} 81650 -33250 0 0 {name=p80913 lab=_82139_/CLK }
C {devices/lab_pin.sym} 81650 -33230 0 0 {name=p80914 lab=_77291_/X }
C {devices/lab_pin.sym} 81830 -33250 0 1 {name=p80915 lab=_82302_/D }
C {sky130_stdcells/dfxtp_4.sym} 81740 -33240 0 0 {name=X_81894_ }
C {devices/lab_pin.sym} 81680 -33120 0 0 {name=p80916 lab=_55601_/A }
C {devices/lab_pin.sym} 81680 -33080 0 0 {name=p80917 lab=_55601_/B }
C {devices/lab_pin.sym} 81800 -33100 0 1 {name=p80918 lab=_55601_/X }
C {sky130_stdcells/and2_4.sym} 81740 -33100 0 0 {name=X_55601_ }
C {devices/lab_pin.sym} 81650 -32970 0 0 {name=p80919 lab=_86422_/CLK }
C {devices/lab_pin.sym} 81650 -32950 0 0 {name=p80920 lab=_49268_/Y }
C {devices/lab_pin.sym} 81830 -32970 0 1 {name=p80921 lab=_86421_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -32960 0 0 {name=X_86421_ }
C {devices/lab_pin.sym} 81680 -32840 0 0 {name=p80922 lab=_52803_/A }
C {devices/lab_pin.sym} 81680 -32800 0 0 {name=p80923 lab=_52813_/B }
C {devices/lab_pin.sym} 81800 -32820 0 1 {name=p80924 lab=_52813_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -32820 0 0 {name=X_52813_ }
C {devices/lab_pin.sym} 81650 -32690 0 0 {name=p80925 lab=_83275_/CLK }
C {devices/lab_pin.sym} 81650 -32670 0 0 {name=p80926 lab=_83633_/D }
C {devices/lab_pin.sym} 81830 -32690 0 1 {name=p80927 lab=_47597_/A }
C {sky130_stdcells/dfxtp_4.sym} 81740 -32680 0 0 {name=X_83633_ }
C {devices/lab_pin.sym} 81700 -32550 0 0 {name=p80928 lab=_56618_/B }
C {devices/lab_pin.sym} 81780 -32550 0 1 {name=p80929 lab=_56582_/A }
C {sky130_stdcells/inv_2.sym} 81740 -32550 0 0 {name=X_56581_ }
C {devices/lab_pin.sym} 81650 -32430 0 0 {name=p80930 lab=_80754_/CLK }
C {devices/lab_pin.sym} 81650 -32410 0 0 {name=p80931 lab=_80877_/Q }
C {devices/lab_pin.sym} 81830 -32430 0 1 {name=p80932 lab=_74921_/B }
C {sky130_stdcells/dfxtp_4.sym} 81740 -32420 0 0 {name=X_80845_ }
C {devices/lab_pin.sym} 81680 -32300 0 0 {name=p80933 lab=_66053_/A }
C {devices/lab_pin.sym} 81680 -32260 0 0 {name=p80934 lab=_68567_/B }
C {devices/lab_pin.sym} 81800 -32280 0 1 {name=p80935 lab=_68567_/Y }
C {sky130_stdcells/nor2_4.sym} 81740 -32280 0 0 {name=X_68567_ }
C {devices/lab_pin.sym} 81700 -32150 0 0 {name=p80936 lab=_53793_/A }
C {devices/lab_pin.sym} 81780 -32150 0 1 {name=p80937 lab=_53825_/A }
C {sky130_stdcells/buf_2.sym} 81740 -32150 0 0 {name=X_53793_ }
C {devices/lab_pin.sym} 81680 -32040 0 0 {name=p80938 lab=_65779_/A }
C {devices/lab_pin.sym} 81680 -32000 0 0 {name=p80939 lab=_86474_/Q }
C {devices/lab_pin.sym} 81800 -32020 0 1 {name=p80940 lab=_65779_/X }
C {sky130_stdcells/and2_4.sym} 81740 -32020 0 0 {name=X_65779_ }
C {devices/lab_pin.sym} 81680 -31900 0 0 {name=p80941 lab=_58320_/A }
C {devices/lab_pin.sym} 81680 -31860 0 0 {name=p80942 lab=_58326_/B }
C {devices/lab_pin.sym} 81800 -31880 0 1 {name=p80943 lab=_58320_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -31880 0 0 {name=X_58320_ }
C {devices/lab_pin.sym} 81700 -31750 0 0 {name=p80944 lab=_44097_/X }
C {devices/lab_pin.sym} 81780 -31750 0 1 {name=p80945 lab=_55532_/X }
C {sky130_stdcells/buf_2.sym} 81740 -31750 0 0 {name=X_55532_ }
C {devices/lab_pin.sym} 81660 -31660 0 0 {name=p80946 lab=_86968_/Q }
C {devices/lab_pin.sym} 81660 -31620 0 0 {name=p80947 lab=_67467_/X }
C {devices/lab_pin.sym} 81660 -31580 0 0 {name=p80948 lab=_67516_/X }
C {devices/lab_pin.sym} 81660 -31540 0 0 {name=p80949 lab=_67517_/X }
C {devices/lab_pin.sym} 81820 -31600 0 1 {name=p80950 lab=_67518_/X }
C {sky130_stdcells/a211o_4.sym} 81740 -31600 0 0 {name=X_67518_ }
C {devices/lab_pin.sym} 81650 -31450 0 0 {name=p80951 lab=_86353_/CLK }
C {devices/lab_pin.sym} 81650 -31430 0 0 {name=p80952 lab=_86352_/D }
C {devices/lab_pin.sym} 81830 -31450 0 1 {name=p80953 lab=_86352_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -31440 0 0 {name=X_86352_ }
C {devices/lab_pin.sym} 81680 -31320 0 0 {name=p80954 lab=_52744_/A }
C {devices/lab_pin.sym} 81680 -31280 0 0 {name=p80955 lab=_52744_/B }
C {devices/lab_pin.sym} 81800 -31300 0 1 {name=p80956 lab=_52744_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -31300 0 0 {name=X_52744_ }
C {devices/lab_pin.sym} 81650 -31170 0 0 {name=p80957 lab=_83564_/CLK }
C {devices/lab_pin.sym} 81650 -31150 0 0 {name=p80958 lab=_71231_/Y }
C {devices/lab_pin.sym} 81830 -31170 0 1 {name=p80959 lab=_48682_/A }
C {sky130_stdcells/dfxtp_4.sym} 81740 -31160 0 0 {name=X_83564_ }
C {devices/lab_pin.sym} 81650 -31030 0 0 {name=p80960 lab=_80776_/CLK }
C {devices/lab_pin.sym} 81650 -31010 0 0 {name=p80961 lab=_80776_/D }
C {devices/lab_pin.sym} 81830 -31030 0 1 {name=p80962 lab=_80776_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -31020 0 0 {name=X_80776_ }
C {devices/lab_pin.sym} 81680 -30900 0 0 {name=p80963 lab=_69877_/A }
C {devices/lab_pin.sym} 81680 -30860 0 0 {name=p80964 lab=_68498_/B }
C {devices/lab_pin.sym} 81800 -30880 0 1 {name=p80965 lab=_68498_/X }
C {sky130_stdcells/and2_4.sym} 81740 -30880 0 0 {name=X_68498_ }
C {devices/lab_pin.sym} 81650 -30750 0 0 {name=p80966 lab=_85269_/CLK }
C {devices/lab_pin.sym} 81650 -30730 0 0 {name=p80967 lab=_85303_/D }
C {devices/lab_pin.sym} 81830 -30750 0 1 {name=p80968 lab=_55900_/B }
C {sky130_stdcells/dfxtp_4.sym} 81740 -30740 0 0 {name=X_85303_ }
C {devices/lab_pin.sym} 81680 -30620 0 0 {name=p80969 lab=_58251_/A }
C {devices/lab_pin.sym} 81680 -30580 0 0 {name=p80970 lab=_58217_/B }
C {devices/lab_pin.sym} 81800 -30600 0 1 {name=p80971 lab=_58251_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -30600 0 0 {name=X_58251_ }
C {devices/lab_pin.sym} 81650 -30470 0 0 {name=p80972 lab=_82515_/CLK }
C {devices/lab_pin.sym} 81650 -30450 0 0 {name=p80973 lab=_82515_/D }
C {devices/lab_pin.sym} 81830 -30470 0 1 {name=p80974 lab=_82515_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -30460 0 0 {name=X_82515_ }
C {devices/lab_pin.sym} 81700 -30330 0 0 {name=p80975 lab=_55323_/A }
C {devices/lab_pin.sym} 81780 -30330 0 1 {name=p80976 lab=_55826_/A }
C {sky130_stdcells/buf_2.sym} 81740 -30330 0 0 {name=X_55463_ }
C {devices/lab_pin.sym} 81700 -30210 0 0 {name=p80977 lab=_67806_/A }
C {devices/lab_pin.sym} 81780 -30210 0 1 {name=p80978 lab=_67449_/X }
C {sky130_stdcells/buf_2.sym} 81740 -30210 0 0 {name=X_67449_ }
C {devices/lab_pin.sym} 81650 -30090 0 0 {name=p80979 lab=_85962_/CLK }
C {devices/lab_pin.sym} 81650 -30070 0 0 {name=p80980 lab=_86283_/D }
C {devices/lab_pin.sym} 81830 -30090 0 1 {name=p80981 lab=_86283_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -30080 0 0 {name=X_86283_ }
C {devices/lab_pin.sym} 81680 -29980 0 0 {name=p80982 lab=_52674_/X }
C {devices/lab_pin.sym} 81680 -29940 0 0 {name=p80983 lab=_52661_/B }
C {devices/lab_pin.sym} 81680 -29900 0 0 {name=p80984 lab=_52654_/C }
C {devices/lab_pin.sym} 81680 -29860 0 0 {name=p80985 lab=_46791_/X }
C {devices/lab_pin.sym} 81800 -29920 0 1 {name=p80986 lab=_52675_/X }
C {sky130_stdcells/and4_4.sym} 81740 -29920 0 0 {name=X_52675_ }
C {devices/lab_pin.sym} 81650 -29770 0 0 {name=p80987 lab=_83495_/CLK }
C {devices/lab_pin.sym} 81650 -29750 0 0 {name=p80988 lab=_83495_/D }
C {devices/lab_pin.sym} 81830 -29770 0 1 {name=p80989 lab=_83495_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -29760 0 0 {name=X_83495_ }
C {devices/lab_pin.sym} 81660 -29650 0 0 {name=p80990 lab=_57087_/X }
C {devices/lab_pin.sym} 81660 -29610 0 0 {name=p80991 lab=_57200_/Y }
C {devices/lab_pin.sym} 81660 -29570 0 0 {name=p80992 lab=_57201_/Y }
C {devices/lab_pin.sym} 81820 -29610 0 1 {name=p80993 lab=_57203_/A }
C {sky130_stdcells/o21ai_4.sym} 81740 -29610 0 0 {name=X_57202_ }
C {devices/lab_pin.sym} 81650 -29470 0 0 {name=p80994 lab=_87253_/CLK }
C {devices/lab_pin.sym} 81650 -29450 0 0 {name=p80995 lab=_88022_/D }
C {devices/lab_pin.sym} 81830 -29470 0 1 {name=p80996 lab=_88022_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -29460 0 0 {name=X_88022_ }
C {devices/lab_pin.sym} 81660 -29350 0 0 {name=p80997 lab=_54411_/Y }
C {devices/lab_pin.sym} 81660 -29310 0 0 {name=p80998 lab=_54394_/X }
C {devices/lab_pin.sym} 81660 -29270 0 0 {name=p80999 lab=_54413_/X }
C {devices/lab_pin.sym} 81820 -29310 0 1 {name=p81000 lab=_85447_/D }
C {sky130_stdcells/a21oi_4.sym} 81740 -29310 0 0 {name=X_54414_ }
C {devices/lab_pin.sym} 81650 -29170 0 0 {name=p81001 lab=_85167_/CLK }
C {devices/lab_pin.sym} 81650 -29150 0 0 {name=p81002 lab=_56329_/Y }
C {devices/lab_pin.sym} 81830 -29170 0 1 {name=p81003 lab=_55846_/B }
C {sky130_stdcells/dfxtp_4.sym} 81740 -29160 0 0 {name=X_85234_ }
C {devices/lab_pin.sym} 81660 -29050 0 0 {name=p81004 lab=_51624_/Y }
C {devices/lab_pin.sym} 81660 -29010 0 0 {name=p81005 lab=_51613_/X }
C {devices/lab_pin.sym} 81660 -28970 0 0 {name=p81006 lab=_51625_/X }
C {devices/lab_pin.sym} 81820 -29010 0 1 {name=p81007 lab=_51626_/Y }
C {sky130_stdcells/a21oi_4.sym} 81740 -29010 0 0 {name=X_51626_ }
C {devices/lab_pin.sym} 81700 -28870 0 0 {name=p81008 lab=_71337_/A }
C {devices/lab_pin.sym} 81780 -28870 0 1 {name=p81009 lab=_71323_/A }
C {sky130_stdcells/buf_2.sym} 81740 -28870 0 0 {name=X_70460_ }
C {devices/lab_pin.sym} 81700 -28750 0 0 {name=p81010 lab=_84913_/Q }
C {devices/lab_pin.sym} 81780 -28750 0 1 {name=p81011 lab=_58184_/A }
C {sky130_stdcells/buf_2.sym} 81740 -28750 0 0 {name=X_58182_ }
C {devices/lab_pin.sym} 81650 -28630 0 0 {name=p81012 lab=_82452_/CLK }
C {devices/lab_pin.sym} 81650 -28610 0 0 {name=p81013 lab=_79138_/X }
C {devices/lab_pin.sym} 81830 -28630 0 1 {name=p81014 lab=_82446_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -28620 0 0 {name=X_82446_ }
C {devices/lab_pin.sym} 81680 -28500 0 0 {name=p81015 lab=_55370_/X }
C {devices/lab_pin.sym} 81680 -28460 0 0 {name=p81016 lab=_55394_/B }
C {devices/lab_pin.sym} 81800 -28480 0 1 {name=p81017 lab=_55394_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -28480 0 0 {name=X_55394_ }
C {devices/lab_pin.sym} 81700 -28350 0 0 {name=p81018 lab=clkbuf_9_501_0_CLK/X }
C {devices/lab_pin.sym} 81780 -28350 0 1 {name=p81019 lab=_86490_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 81740 -28350 0 0 {name=Xclkbuf_10_1003_0_CLK }
C {devices/lab_pin.sym} 81680 -28260 0 0 {name=p81020 lab=_57133_/A }
C {devices/lab_pin.sym} 81680 -28220 0 0 {name=p81021 lab=_56739_/A }
C {devices/lab_pin.sym} 81680 -28180 0 0 {name=p81022 lab=_57155_/D }
C {devices/lab_pin.sym} 81680 -28140 0 0 {name=p81023 lab=_56803_/A }
C {devices/lab_pin.sym} 81800 -28200 0 1 {name=p81024 lab=_57133_/X }
C {sky130_stdcells/and4_4.sym} 81740 -28200 0 0 {name=X_57133_ }
C {devices/lab_pin.sym} 81660 -28080 0 0 {name=p81025 lab=_86976_/Q }
C {devices/lab_pin.sym} 81660 -28040 0 0 {name=p81026 lab=_68864_/X }
C {devices/lab_pin.sym} 81660 -28000 0 0 {name=p81027 lab=_68891_/X }
C {devices/lab_pin.sym} 81660 -27960 0 0 {name=p81028 lab=_69118_/X }
C {devices/lab_pin.sym} 81820 -28020 0 1 {name=p81029 lab=_69119_/X }
C {sky130_stdcells/a211o_4.sym} 81740 -28020 0 0 {name=X_69119_ }
C {devices/lab_pin.sym} 81700 -27870 0 0 {name=p81030 lab=_54399_/A }
C {devices/lab_pin.sym} 81780 -27870 0 1 {name=p81031 lab=_54362_/A }
C {sky130_stdcells/buf_2.sym} 81740 -27870 0 0 {name=X_54345_ }
C {devices/lab_pin.sym} 81650 -27750 0 0 {name=p81032 lab=_85257_/CLK }
C {devices/lab_pin.sym} 81650 -27730 0 0 {name=p81033 lab=_85165_/D }
C {devices/lab_pin.sym} 81830 -27750 0 1 {name=p81034 lab=_56518_/C }
C {sky130_stdcells/dfxtp_4.sym} 81740 -27740 0 0 {name=X_85165_ }
C {devices/lab_pin.sym} 81700 -27610 0 0 {name=p81035 lab=_51557_/A }
C {devices/lab_pin.sym} 81780 -27610 0 1 {name=p81036 lab=_51557_/X }
C {sky130_stdcells/buf_2.sym} 81740 -27610 0 0 {name=X_51557_ }
C {devices/lab_pin.sym} 81700 -27490 0 0 {name=p81037 lab=_71003_/A }
C {devices/lab_pin.sym} 81780 -27490 0 1 {name=p81038 lab=_70944_/A }
C {sky130_stdcells/buf_2.sym} 81740 -27490 0 0 {name=X_70391_ }
C {devices/lab_pin.sym} 81650 -27370 0 0 {name=p81039 lab=_85635_/CLK }
C {devices/lab_pin.sym} 81650 -27350 0 0 {name=p81040 lab=_82185_/Q }
C {devices/lab_pin.sym} 81830 -27370 0 1 {name=p81041 lab=_82377_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -27360 0 0 {name=X_82377_ }
C {devices/lab_pin.sym} 81680 -27240 0 0 {name=p81042 lab=_41310_/A }
C {devices/lab_pin.sym} 81680 -27200 0 0 {name=p81043 lab=_41292_/B }
C {devices/lab_pin.sym} 81800 -27220 0 1 {name=p81044 lab=_41310_/X }
C {sky130_stdcells/or2_4.sym} 81740 -27220 0 0 {name=X_41310_ }
C {devices/lab_pin.sym} 81660 -27130 0 0 {name=p81045 lab=_59325_/X }
C {devices/lab_pin.sym} 81660 -27090 0 0 {name=p81046 lab=_72128_/Y }
C {devices/lab_pin.sym} 81660 -27050 0 0 {name=p81047 lab=_72129_/Y }
C {devices/lab_pin.sym} 81660 -27010 0 0 {name=p81048 lab=_59342_/X }
C {devices/lab_pin.sym} 81660 -26970 0 0 {name=p81049 lab=_59329_/X }
C {devices/lab_pin.sym} 81820 -27050 0 1 {name=p81050 lab=_72130_/X }
C {sky130_stdcells/o32a_4.sym} 81740 -27050 0 0 {name=X_72130_ }
C {devices/lab_pin.sym} 81650 -26890 0 0 {name=p81051 lab=_84161_/CLK }
C {devices/lab_pin.sym} 81650 -26870 0 0 {name=p81052 lab=_84116_/D }
C {devices/lab_pin.sym} 81830 -26890 0 1 {name=p81053 lab=_84116_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -26880 0 0 {name=X_84116_ }
C {devices/lab_pin.sym} 81680 -26760 0 0 {name=p81054 lab=_50513_/A }
C {devices/lab_pin.sym} 81680 -26720 0 0 {name=p81055 lab=_50508_/B }
C {devices/lab_pin.sym} 81800 -26740 0 1 {name=p81056 lab=_50508_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -26740 0 0 {name=X_50508_ }
C {devices/lab_pin.sym} 81660 -26630 0 0 {name=p81057 lab=_56885_/A }
C {devices/lab_pin.sym} 81660 -26590 0 0 {name=p81058 lab=_56884_/Y }
C {devices/lab_pin.sym} 81660 -26550 0 0 {name=p81059 lab=_56982_/X }
C {devices/lab_pin.sym} 81820 -26590 0 1 {name=p81060 lab=_57064_/Y }
C {sky130_stdcells/a21oi_4.sym} 81740 -26590 0 0 {name=X_57064_ }
C {devices/lab_pin.sym} 81650 -26450 0 0 {name=p81061 lab=_81492_/CLK }
C {devices/lab_pin.sym} 81650 -26430 0 0 {name=p81062 lab=_76363_/X }
C {devices/lab_pin.sym} 81830 -26450 0 1 {name=p81063 lab=_81704_/D }
C {sky130_stdcells/dfxtp_4.sym} 81740 -26440 0 0 {name=X_81328_ }
C {devices/lab_pin.sym} 81660 -26330 0 0 {name=p81064 lab=_54273_/Y }
C {devices/lab_pin.sym} 81660 -26290 0 0 {name=p81065 lab=_54051_/X }
C {devices/lab_pin.sym} 81660 -26250 0 0 {name=p81066 lab=_54275_/X }
C {devices/lab_pin.sym} 81820 -26290 0 1 {name=p81067 lab=_85472_/D }
C {sky130_stdcells/a21oi_4.sym} 81740 -26290 0 0 {name=X_54276_ }
C {devices/lab_pin.sym} 81700 -26150 0 0 {name=p81068 lab=_42290_/A }
C {devices/lab_pin.sym} 81780 -26150 0 1 {name=p81069 lab=_42290_/X }
C {sky130_stdcells/buf_2.sym} 81740 -26150 0 0 {name=X_42290_ }
C {devices/lab_pin.sym} 81650 -26030 0 0 {name=p81070 lab=_85096_/CLK }
C {devices/lab_pin.sym} 81650 -26010 0 0 {name=p81071 lab=_85096_/D }
C {devices/lab_pin.sym} 81830 -26030 0 1 {name=p81072 lab=_85096_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -26020 0 0 {name=X_85096_ }
C {devices/lab_pin.sym} 81660 -25910 0 0 {name=p81073 lab=_86001_/Q }
C {devices/lab_pin.sym} 81660 -25870 0 0 {name=p81074 lab=_51485_/X }
C {devices/lab_pin.sym} 81660 -25830 0 0 {name=p81075 lab=_51487_/Y }
C {devices/lab_pin.sym} 81820 -25870 0 1 {name=p81076 lab=_51488_/Y }
C {sky130_stdcells/o21ai_4.sym} 81740 -25870 0 0 {name=X_51488_ }
C {devices/lab_pin.sym} 81680 -25740 0 0 {name=p81077 lab=_55975_/X }
C {devices/lab_pin.sym} 81680 -25700 0 0 {name=p81078 lab=_56015_/B }
C {devices/lab_pin.sym} 81800 -25720 0 1 {name=p81079 lab=_56016_/A }
C {sky130_stdcells/xor2_4.sym} 81740 -25720 0 0 {name=X_56015_ }
C {devices/lab_pin.sym} 81680 -25600 0 0 {name=p81080 lab=_53246_/A }
C {devices/lab_pin.sym} 81680 -25560 0 0 {name=p81081 lab=_53227_/B }
C {devices/lab_pin.sym} 81800 -25580 0 1 {name=p81082 lab=_53227_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -25580 0 0 {name=X_53227_ }
C {devices/lab_pin.sym} 81700 -25450 0 0 {name=p81083 lab=_41490_/A }
C {devices/lab_pin.sym} 81780 -25450 0 1 {name=p81084 lab=_41241_/X }
C {sky130_stdcells/buf_2.sym} 81740 -25450 0 0 {name=X_41241_ }
C {devices/lab_pin.sym} 81660 -25350 0 0 {name=p81085 lab=_72058_/Y }
C {devices/lab_pin.sym} 81660 -25310 0 0 {name=p81086 lab=_72059_/X }
C {devices/lab_pin.sym} 81660 -25270 0 0 {name=p81087 lab=_72060_/X }
C {devices/lab_pin.sym} 81820 -25310 0 1 {name=p81088 lab=_83293_/D }
C {sky130_stdcells/a21oi_4.sym} 81740 -25310 0 0 {name=X_72061_ }
C {devices/lab_pin.sym} 81650 -25170 0 0 {name=p81089 lab=_88116_/CLK }
C {devices/lab_pin.sym} 81650 -25150 0 0 {name=p81090 lab=_84047_/D }
C {devices/lab_pin.sym} 81830 -25170 0 1 {name=p81091 lab=_81479_/D }
C {sky130_stdcells/dfxtp_4.sym} 81740 -25160 0 0 {name=X_84047_ }
C {devices/lab_pin.sym} 81700 -25030 0 0 {name=p81092 lab=_50534_/A }
C {devices/lab_pin.sym} 81780 -25030 0 1 {name=p81093 lab=_50439_/X }
C {sky130_stdcells/buf_2.sym} 81740 -25030 0 0 {name=X_50439_ }
C {devices/lab_pin.sym} 81650 -24910 0 0 {name=p81094 lab=_81259_/CLK }
C {devices/lab_pin.sym} 81650 -24890 0 0 {name=p81095 lab=_81259_/D }
C {devices/lab_pin.sym} 81830 -24910 0 1 {name=p81096 lab=_81259_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -24900 0 0 {name=X_81259_ }
C {devices/lab_pin.sym} 81700 -24770 0 0 {name=p81097 lab=clkbuf_9_509_0_CLK/X }
C {devices/lab_pin.sym} 81780 -24770 0 1 {name=p81098 lab=_86506_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 81740 -24770 0 0 {name=Xclkbuf_10_1018_0_CLK }
C {devices/lab_pin.sym} 81680 -24660 0 0 {name=p81099 lab=_71012_/A }
C {devices/lab_pin.sym} 81680 -24620 0 0 {name=p81100 lab=_71012_/B }
C {devices/lab_pin.sym} 81800 -24640 0 1 {name=p81101 lab=_71013_/A }
C {sky130_stdcells/nor2_4.sym} 81740 -24640 0 0 {name=X_71012_ }
C {devices/lab_pin.sym} 81680 -24520 0 0 {name=p81102 lab=_41002_/B }
C {devices/lab_pin.sym} 81680 -24480 0 0 {name=p81103 lab=_41223_/B }
C {devices/lab_pin.sym} 81800 -24500 0 1 {name=p81104 lab=_41172_/X }
C {sky130_stdcells/or2_4.sym} 81740 -24500 0 0 {name=X_41172_ }
C {devices/lab_pin.sym} 81660 -24390 0 0 {name=p81105 lab=_85686_/Q }
C {devices/lab_pin.sym} 81660 -24350 0 0 {name=p81106 lab=_53146_/X }
C {devices/lab_pin.sym} 81660 -24310 0 0 {name=p81107 lab=_53157_/Y }
C {devices/lab_pin.sym} 81820 -24350 0 1 {name=p81108 lab=_53158_/Y }
C {sky130_stdcells/o21ai_4.sym} 81740 -24350 0 0 {name=X_53158_ }
C {devices/lab_pin.sym} 81680 -24230 0 0 {name=p81109 lab=_48388_/A }
C {devices/lab_pin.sym} 81680 -24190 0 0 {name=p81110 lab=_52135_/B }
C {devices/lab_pin.sym} 81680 -24150 0 0 {name=p81111 lab=_52097_/X }
C {devices/lab_pin.sym} 81800 -24190 0 1 {name=p81112 lab=_52109_/X }
C {sky130_stdcells/and3_4.sym} 81740 -24190 0 0 {name=X_52109_ }
C {devices/lab_pin.sym} 81700 -24050 0 0 {name=p81113 lab=_75820_/A }
C {devices/lab_pin.sym} 81780 -24050 0 1 {name=p81114 lab=_75821_/B }
C {sky130_stdcells/inv_2.sym} 81740 -24050 0 0 {name=X_75820_ }
C {devices/lab_pin.sym} 81650 -23930 0 0 {name=p81115 lab=_87820_/CLK }
C {devices/lab_pin.sym} 81650 -23910 0 0 {name=p81116 lab=_42601_/Y }
C {devices/lab_pin.sym} 81830 -23930 0 1 {name=p81117 lab=_42600_/A }
C {sky130_stdcells/dfxtp_4.sym} 81740 -23920 0 0 {name=X_87806_ }
C {devices/lab_pin.sym} 81700 -23790 0 0 {name=p81118 lab=_58813_/A }
C {devices/lab_pin.sym} 81780 -23790 0 1 {name=p81119 lab=_57966_/X }
C {sky130_stdcells/buf_2.sym} 81740 -23790 0 0 {name=X_57966_ }
C {devices/lab_pin.sym} 81700 -23670 0 0 {name=p81120 lab=_45980_/A }
C {devices/lab_pin.sym} 81780 -23670 0 1 {name=p81121 lab=_45980_/X }
C {sky130_stdcells/buf_2.sym} 81740 -23670 0 0 {name=X_45980_ }
C {devices/lab_pin.sym} 81700 -23550 0 0 {name=p81122 lab=_53195_/A }
C {devices/lab_pin.sym} 81780 -23550 0 1 {name=p81123 lab=_53107_/C }
C {sky130_stdcells/buf_2.sym} 81740 -23550 0 0 {name=X_53089_ }
C {devices/lab_pin.sym} 81650 -23430 0 0 {name=p81124 lab=_85709_/CLK }
C {devices/lab_pin.sym} 81650 -23410 0 0 {name=p81125 lab=_85998_/D }
C {devices/lab_pin.sym} 81830 -23430 0 1 {name=p81126 lab=_85998_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -23420 0 0 {name=X_85998_ }
C {devices/lab_pin.sym} 81700 -23290 0 0 {name=p81127 lab=_59564_/B }
C {devices/lab_pin.sym} 81780 -23290 0 1 {name=p81128 lab=_59705_/X }
C {sky130_stdcells/buf_2.sym} 81740 -23290 0 0 {name=X_59705_ }
C {devices/lab_pin.sym} 81660 -23190 0 0 {name=p81129 lab=_44928_/Y }
C {devices/lab_pin.sym} 81660 -23150 0 0 {name=p81130 lab=_44930_/Y }
C {devices/lab_pin.sym} 81660 -23110 0 0 {name=p81131 lab=_44889_/X }
C {devices/lab_pin.sym} 81820 -23150 0 1 {name=p81132 lab=_44931_/X }
C {sky130_stdcells/a21o_4.sym} 81740 -23150 0 0 {name=X_44931_ }
C {devices/lab_pin.sym} 81680 -23020 0 0 {name=p81133 lab=_56917_/A }
C {devices/lab_pin.sym} 81680 -22980 0 0 {name=p81134 lab=_56798_/B }
C {devices/lab_pin.sym} 81800 -23000 0 1 {name=p81135 lab=_56917_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -23000 0 0 {name=X_56917_ }
C {devices/lab_pin.sym} 81680 -22880 0 0 {name=p81136 lab=_75751_/A }
C {devices/lab_pin.sym} 81680 -22840 0 0 {name=p81137 lab=_75750_/Y }
C {devices/lab_pin.sym} 81800 -22860 0 1 {name=p81138 lab=_75759_/A }
C {sky130_stdcells/xor2_4.sym} 81740 -22860 0 0 {name=X_75751_ }
C {devices/lab_pin.sym} 81650 -22730 0 0 {name=p81139 lab=_87993_/CLK }
C {devices/lab_pin.sym} 81650 -22710 0 0 {name=p81140 lab=_42754_/X }
C {devices/lab_pin.sym} 81830 -22730 0 1 {name=p81141 lab=_69008_/B }
C {sky130_stdcells/dfxtp_4.sym} 81740 -22720 0 0 {name=X_87737_ }
C {devices/lab_pin.sym} 81700 -22590 0 0 {name=p81142 lab=_73359_/A }
C {devices/lab_pin.sym} 81780 -22590 0 1 {name=p81143 lab=_72963_/X }
C {sky130_stdcells/buf_2.sym} 81740 -22590 0 0 {name=X_72963_ }
C {devices/lab_pin.sym} 81650 -22470 0 0 {name=p81144 lab=_85485_/CLK }
C {devices/lab_pin.sym} 81650 -22450 0 0 {name=p81145 lab=_84949_/D }
C {devices/lab_pin.sym} 81830 -22470 0 1 {name=p81146 lab=_84949_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -22460 0 0 {name=X_84949_ }
C {devices/lab_pin.sym} 81680 -22340 0 0 {name=p81147 lab=_57971_/A }
C {devices/lab_pin.sym} 81680 -22300 0 0 {name=p81148 lab=_57897_/B }
C {devices/lab_pin.sym} 81800 -22320 0 1 {name=p81149 lab=_57897_/Y }
C {sky130_stdcells/nor2_4.sym} 81740 -22320 0 0 {name=X_57897_ }
C {devices/lab_pin.sym} 81680 -22200 0 0 {name=p81150 lab=_74691_/A }
C {devices/lab_pin.sym} 81680 -22160 0 0 {name=p81151 lab=_74702_/B }
C {devices/lab_pin.sym} 81800 -22180 0 1 {name=p81152 lab=_74702_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -22180 0 0 {name=X_74702_ }
C {devices/lab_pin.sym} 81660 -22070 0 0 {name=p81153 lab=_86612_/Q }
C {devices/lab_pin.sym} 81660 -22030 0 0 {name=p81154 lab=_47619_/X }
C {devices/lab_pin.sym} 81660 -21990 0 0 {name=p81155 lab=_47649_/Y }
C {devices/lab_pin.sym} 81820 -22030 0 1 {name=p81156 lab=_47650_/Y }
C {sky130_stdcells/o21ai_4.sym} 81740 -22030 0 0 {name=X_47650_ }
C {devices/lab_pin.sym} 81680 -21910 0 0 {name=p81157 lab=_71576_/X }
C {devices/lab_pin.sym} 81680 -21870 0 0 {name=p81158 lab=_71930_/B }
C {devices/lab_pin.sym} 81680 -21830 0 0 {name=p81159 lab=_71536_/A }
C {devices/lab_pin.sym} 81800 -21870 0 1 {name=p81160 lab=_71914_/Y }
C {sky130_stdcells/nor3_4.sym} 81740 -21870 0 0 {name=X_71914_ }
C {devices/lab_pin.sym} 81700 -21730 0 0 {name=p81161 lab=_59635_/Y }
C {devices/lab_pin.sym} 81780 -21730 0 1 {name=p81162 lab=_59806_/A }
C {sky130_stdcells/buf_2.sym} 81740 -21730 0 0 {name=X_59636_ }
C {devices/lab_pin.sym} 81660 -21630 0 0 {name=p81163 lab=_78461_/A }
C {devices/lab_pin.sym} 81660 -21590 0 0 {name=p81164 lab=_78458_/Y }
C {devices/lab_pin.sym} 81660 -21550 0 0 {name=p81165 lab=_78460_/A }
C {devices/lab_pin.sym} 81820 -21590 0 1 {name=p81166 lab=_78474_/A }
C {sky130_stdcells/o21a_4.sym} 81740 -21590 0 0 {name=X_78470_ }
C {devices/lab_pin.sym} 81660 -21480 0 0 {name=p81167 lab=_41781_/Y }
C {devices/lab_pin.sym} 81660 -21440 0 0 {name=p81168 lab=_44848_/X }
C {devices/lab_pin.sym} 81660 -21400 0 0 {name=p81169 lab=_68020_/B }
C {devices/lab_pin.sym} 81660 -21360 0 0 {name=p81170 lab=_44849_/X }
C {devices/lab_pin.sym} 81820 -21420 0 1 {name=p81171 lab=_44862_/X }
C {sky130_stdcells/a2bb2o_4.sym} 81740 -21420 0 0 {name=X_44862_ }
C {devices/lab_pin.sym} 81700 -21270 0 0 {name=p81172 lab=_56700_/C }
C {devices/lab_pin.sym} 81780 -21270 0 1 {name=p81173 lab=_56848_/X }
C {sky130_stdcells/buf_2.sym} 81740 -21270 0 0 {name=X_56848_ }
C {devices/lab_pin.sym} 81660 -21180 0 0 {name=p81174 lab=_75670_/A }
C {devices/lab_pin.sym} 81660 -21140 0 0 {name=p81175 lab=_75669_/Y }
C {devices/lab_pin.sym} 81660 -21100 0 0 {name=p81176 lab=_75656_/A }
C {devices/lab_pin.sym} 81660 -21060 0 0 {name=p81177 lab=_80780_/D }
C {devices/lab_pin.sym} 81820 -21120 0 1 {name=p81178 lab=_75682_/X }
C {sky130_stdcells/a2bb2o_4.sym} 81740 -21120 0 0 {name=X_75682_ }
C {devices/lab_pin.sym} 81650 -20970 0 0 {name=p81179 lab=_88180_/CLK }
C {devices/lab_pin.sym} 81650 -20950 0 0 {name=p81180 lab=_87668_/D }
C {devices/lab_pin.sym} 81830 -20970 0 1 {name=p81181 lab=_87668_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -20960 0 0 {name=X_87668_ }
C {devices/lab_pin.sym} 81700 -20830 0 0 {name=p81182 lab=_72806_/A }
C {devices/lab_pin.sym} 81780 -20830 0 1 {name=p81183 lab=_72894_/X }
C {sky130_stdcells/buf_2.sym} 81740 -20830 0 0 {name=X_72894_ }
C {devices/lab_pin.sym} 81660 -20730 0 0 {name=p81184 lab=_46493_/X }
C {devices/lab_pin.sym} 81660 -20690 0 0 {name=p81185 lab=_48157_/B }
C {devices/lab_pin.sym} 81660 -20650 0 0 {name=p81186 lab=_46600_/Y }
C {devices/lab_pin.sym} 81820 -20690 0 1 {name=p81187 lab=_54091_/A }
C {sky130_stdcells/o21ai_4.sym} 81740 -20690 0 0 {name=X_46601_ }
C {devices/lab_pin.sym} 81680 -20560 0 0 {name=p81188 lab=_77421_/A }
C {devices/lab_pin.sym} 81680 -20520 0 0 {name=p81189 lab=_82191_/D }
C {devices/lab_pin.sym} 81800 -20540 0 1 {name=p81190 lab=_81903_/D }
C {sky130_stdcells/xor2_4.sym} 81740 -20540 0 0 {name=X_77421_ }
C {devices/lab_pin.sym} 81700 -20410 0 0 {name=p81191 lab=_43813_/A }
C {devices/lab_pin.sym} 81780 -20410 0 1 {name=p81192 lab=_43813_/Y }
C {sky130_stdcells/inv_2.sym} 81740 -20410 0 0 {name=X_43813_ }
C {devices/lab_pin.sym} 81700 -20290 0 0 {name=p81193 lab=_74691_/A }
C {devices/lab_pin.sym} 81780 -20290 0 1 {name=p81194 lab=_74633_/X }
C {sky130_stdcells/buf_2.sym} 81740 -20290 0 0 {name=X_74633_ }
C {devices/lab_pin.sym} 81650 -20170 0 0 {name=p81195 lab=_85981_/CLK }
C {devices/lab_pin.sym} 81650 -20150 0 0 {name=p81196 lab=_86619_/D }
C {devices/lab_pin.sym} 81830 -20170 0 1 {name=p81197 lab=_72193_/A }
C {sky130_stdcells/dfxtp_4.sym} 81740 -20160 0 0 {name=X_86619_ }
C {devices/lab_pin.sym} 81700 -20030 0 0 {name=p81198 lab=_83707_/Q }
C {devices/lab_pin.sym} 81780 -20030 0 1 {name=p81199 lab=_47582_/A }
C {sky130_stdcells/inv_2.sym} 81740 -20030 0 0 {name=X_47581_ }
C {devices/lab_pin.sym} 81700 -19910 0 0 {name=p81200 lab=_70886_/A }
C {devices/lab_pin.sym} 81780 -19910 0 1 {name=p81201 lab=_71846_/A }
C {sky130_stdcells/buf_2.sym} 81740 -19910 0 0 {name=X_71845_ }
C {devices/lab_pin.sym} 81680 -19810 0 0 {name=p81202 lab=_59661_/D }
C {devices/lab_pin.sym} 81680 -19770 0 0 {name=p81203 lab=_60599_/A }
C {devices/lab_pin.sym} 81680 -19730 0 0 {name=p81204 lab=_60380_/B }
C {devices/lab_pin.sym} 81800 -19770 0 1 {name=p81205 lab=_59633_/A }
C {sky130_stdcells/and3_4.sym} 81740 -19770 0 0 {name=X_59567_ }
C {devices/lab_pin.sym} 81660 -19670 0 0 {name=p81206 lab=_44512_/A }
C {devices/lab_pin.sym} 81660 -19630 0 0 {name=p81207 lab=_41887_/A }
C {devices/lab_pin.sym} 81660 -19590 0 0 {name=p81208 lab=_41407_/X }
C {devices/lab_pin.sym} 81660 -19550 0 0 {name=p81209 lab=_86952_/Q }
C {devices/lab_pin.sym} 81660 -19510 0 0 {name=p81210 lab=_44516_/A }
C {devices/lab_pin.sym} 81820 -19590 0 1 {name=p81211 lab=_44794_/A }
C {sky130_stdcells/o32ai_4.sym} 81740 -19590 0 0 {name=X_44793_ }
C {devices/lab_pin.sym} 81680 -19440 0 0 {name=p81212 lab=_56567_/Y }
C {devices/lab_pin.sym} 81680 -19400 0 0 {name=p81213 lab=_56778_/Y }
C {devices/lab_pin.sym} 81800 -19420 0 1 {name=p81214 lab=_56779_/Y }
C {sky130_stdcells/nor2_4.sym} 81740 -19420 0 0 {name=X_56779_ }
C {devices/lab_pin.sym} 81650 -19290 0 0 {name=p81215 lab=_88111_/CLK }
C {devices/lab_pin.sym} 81650 -19270 0 0 {name=p81216 lab=_87599_/D }
C {devices/lab_pin.sym} 81830 -19290 0 1 {name=p81217 lab=_73653_/A }
C {sky130_stdcells/dfxtp_4.sym} 81740 -19280 0 0 {name=X_87599_ }
C {devices/lab_pin.sym} 81680 -19160 0 0 {name=p81218 lab=_49287_/A }
C {devices/lab_pin.sym} 81680 -19120 0 0 {name=p81219 lab=_49320_/B }
C {devices/lab_pin.sym} 81800 -19140 0 1 {name=p81220 lab=_49320_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -19140 0 0 {name=X_49320_ }
C {devices/lab_pin.sym} 81660 -19030 0 0 {name=p81221 lab=_46522_/Y }
C {devices/lab_pin.sym} 81660 -18990 0 0 {name=p81222 lab=_46523_/X }
C {devices/lab_pin.sym} 81660 -18950 0 0 {name=p81223 lab=_46531_/Y }
C {devices/lab_pin.sym} 81820 -18990 0 1 {name=p81224 lab=_46532_/Y }
C {sky130_stdcells/a21boi_4.sym} 81740 -18990 0 0 {name=X_46532_ }
C {devices/lab_pin.sym} 81700 -18850 0 0 {name=p81225 lab=_83421_/Q }
C {devices/lab_pin.sym} 81780 -18850 0 1 {name=p81226 lab=_58518_/Y }
C {sky130_stdcells/inv_2.sym} 81740 -18850 0 0 {name=X_58518_ }
C {devices/lab_pin.sym} 81680 -18740 0 0 {name=p81227 lab=_81930_/Q }
C {devices/lab_pin.sym} 81680 -18700 0 0 {name=p81228 lab=_82186_/D }
C {devices/lab_pin.sym} 81800 -18720 0 1 {name=p81229 lab=_81898_/D }
C {sky130_stdcells/xor2_4.sym} 81740 -18720 0 0 {name=X_77352_ }
C {devices/lab_pin.sym} 81700 -18590 0 0 {name=p81230 lab=_43744_/A }
C {devices/lab_pin.sym} 81780 -18590 0 1 {name=p81231 lab=_69932_/B }
C {sky130_stdcells/inv_2.sym} 81740 -18590 0 0 {name=X_43744_ }
C {devices/lab_pin.sym} 81680 -18490 0 0 {name=p81232 lab=_74541_/A }
C {devices/lab_pin.sym} 81680 -18450 0 0 {name=p81233 lab=_46228_/A }
C {devices/lab_pin.sym} 81680 -18410 0 0 {name=p81234 lab=_74564_/C }
C {devices/lab_pin.sym} 81800 -18450 0 1 {name=p81235 lab=_74564_/Y }
C {sky130_stdcells/nand3_4.sym} 81740 -18450 0 0 {name=X_74564_ }
C {devices/lab_pin.sym} 81660 -18340 0 0 {name=p81236 lab=_40955_/X }
C {devices/lab_pin.sym} 81660 -18300 0 0 {name=p81237 lab=_40941_/X }
C {devices/lab_pin.sym} 81660 -18260 0 0 {name=p81238 lab=_88304_/Q }
C {devices/lab_pin.sym} 81660 -18220 0 0 {name=p81239 lab=_40942_/X }
C {devices/lab_pin.sym} 81820 -18280 0 1 {name=p81240 lab=_88304_/D }
C {sky130_stdcells/a2bb2o_4.sym} 81740 -18280 0 0 {name=X_40956_ }
C {devices/lab_pin.sym} 81660 -18150 0 0 {name=p81241 lab=_71761_/Y }
C {devices/lab_pin.sym} 81660 -18110 0 0 {name=p81242 lab=_83380_/Q }
C {devices/lab_pin.sym} 81660 -18070 0 0 {name=p81243 lab=_71775_/X }
C {devices/lab_pin.sym} 81820 -18110 0 1 {name=p81244 lab=_71776_/X }
C {sky130_stdcells/a21o_4.sym} 81740 -18110 0 0 {name=X_71776_ }
C {devices/lab_pin.sym} 81680 -17980 0 0 {name=p81245 lab=_59498_/A }
C {devices/lab_pin.sym} 81680 -17940 0 0 {name=p81246 lab=_59497_/Y }
C {devices/lab_pin.sym} 81800 -17960 0 1 {name=p81247 lab=_59498_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -17960 0 0 {name=X_59498_ }
C {devices/lab_pin.sym} 81700 -17830 0 0 {name=p81248 lab=clkbuf_9_335_0_CLK/X }
C {devices/lab_pin.sym} 81780 -17830 0 1 {name=p81249 lab=_88133_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 81740 -17830 0 0 {name=Xclkbuf_10_670_0_CLK }
C {devices/lab_pin.sym} 81700 -17710 0 0 {name=p81250 lab=_76302_/Y }
C {devices/lab_pin.sym} 81780 -17710 0 1 {name=p81251 lab=_76303_/Y }
C {sky130_stdcells/inv_2.sym} 81740 -17710 0 0 {name=X_76303_ }
C {devices/lab_pin.sym} 81680 -17600 0 0 {name=p81252 lab=_49241_/A }
C {devices/lab_pin.sym} 81680 -17560 0 0 {name=p81253 lab=_46356_/X }
C {devices/lab_pin.sym} 81800 -17580 0 1 {name=p81254 lab=_49251_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -17580 0 0 {name=X_49251_ }
C {devices/lab_pin.sym} 81660 -17480 0 0 {name=p81255 lab=_72721_/X }
C {devices/lab_pin.sym} 81660 -17440 0 0 {name=p81256 lab=_86179_/Q }
C {devices/lab_pin.sym} 81660 -17400 0 0 {name=p81257 lab=_73351_/X }
C {devices/lab_pin.sym} 81660 -17360 0 0 {name=p81258 lab=_73514_/X }
C {devices/lab_pin.sym} 81820 -17420 0 1 {name=p81259 lab=_73515_/X }
C {sky130_stdcells/a211o_4.sym} 81740 -17420 0 0 {name=X_73515_ }
C {devices/lab_pin.sym} 81660 -17290 0 0 {name=p81260 lab=_46458_/Y }
C {devices/lab_pin.sym} 81660 -17250 0 0 {name=p81261 lab=_46399_/X }
C {devices/lab_pin.sym} 81660 -17210 0 0 {name=p81262 lab=_46462_/Y }
C {devices/lab_pin.sym} 81820 -17250 0 1 {name=p81263 lab=_86735_/D }
C {sky130_stdcells/a21boi_4.sym} 81740 -17250 0 0 {name=X_46463_ }
C {devices/lab_pin.sym} 81680 -17140 0 0 {name=p81264 lab=_70727_/A }
C {devices/lab_pin.sym} 81680 -17100 0 0 {name=p81265 lab=_70779_/B }
C {devices/lab_pin.sym} 81680 -17060 0 0 {name=p81266 lab=_70727_/C }
C {devices/lab_pin.sym} 81680 -17020 0 0 {name=p81267 lab=_70769_/D }
C {devices/lab_pin.sym} 81800 -17080 0 1 {name=p81268 lab=_70727_/Y }
C {sky130_stdcells/nand4_4.sym} 81740 -17080 0 0 {name=X_70727_ }
C {devices/lab_pin.sym} 81700 -16930 0 0 {name=p81269 lab=_84845_/Q }
C {devices/lab_pin.sym} 81780 -16930 0 1 {name=p81270 lab=_63244_/A }
C {sky130_stdcells/inv_2.sym} 81740 -16930 0 0 {name=X_58449_ }
C {devices/lab_pin.sym} 81700 -16810 0 0 {name=p81271 lab=_77282_/Y }
C {devices/lab_pin.sym} 81780 -16810 0 1 {name=p81272 lab=_77285_/A }
C {sky130_stdcells/inv_2.sym} 81740 -16810 0 0 {name=X_77283_ }
C {devices/lab_pin.sym} 81700 -16690 0 0 {name=p81273 lab=_87316_/Q }
C {devices/lab_pin.sym} 81780 -16690 0 1 {name=p81274 lab=_69114_/B }
C {sky130_stdcells/inv_2.sym} 81740 -16690 0 0 {name=X_43675_ }
C {devices/lab_pin.sym} 81680 -16580 0 0 {name=p81275 lab=_74490_/A }
C {devices/lab_pin.sym} 81680 -16540 0 0 {name=p81276 lab=_48660_/A }
C {devices/lab_pin.sym} 81800 -16560 0 1 {name=p81277 lab=_74495_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -16560 0 0 {name=X_74495_ }
C {devices/lab_pin.sym} 81700 -16430 0 0 {name=p81278 lab=_40887_/A }
C {devices/lab_pin.sym} 81780 -16430 0 1 {name=p81279 lab=_40887_/Y }
C {sky130_stdcells/inv_2.sym} 81740 -16430 0 0 {name=X_40887_ }
C {devices/lab_pin.sym} 81660 -16330 0 0 {name=p81280 lab=_48199_/Y }
C {devices/lab_pin.sym} 81660 -16290 0 0 {name=p81281 lab=_48194_/X }
C {devices/lab_pin.sym} 81660 -16250 0 0 {name=p81282 lab=_48201_/X }
C {devices/lab_pin.sym} 81820 -16290 0 1 {name=p81283 lab=_48202_/Y }
C {sky130_stdcells/a21oi_4.sym} 81740 -16290 0 0 {name=X_48202_ }
C {devices/lab_pin.sym} 81700 -16150 0 0 {name=p81284 lab=clkbuf_8_80_0_CLK/X }
C {devices/lab_pin.sym} 81780 -16150 0 1 {name=p81285 lab=clkbuf_9_161_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 81740 -16150 0 0 {name=Xclkbuf_9_161_0_CLK }
C {devices/lab_pin.sym} 81680 -16040 0 0 {name=p81286 lab=_79022_/A }
C {devices/lab_pin.sym} 81680 -16000 0 0 {name=p81287 lab=_79018_/A }
C {devices/lab_pin.sym} 81800 -16020 0 1 {name=p81288 lab=_79022_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -16020 0 0 {name=X_79022_ }
C {devices/lab_pin.sym} 81660 -15920 0 0 {name=p81289 lab=_55628_/B }
C {devices/lab_pin.sym} 81660 -15880 0 0 {name=p81290 lab=_45412_/X }
C {devices/lab_pin.sym} 81660 -15840 0 0 {name=p81291 lab=_45396_/X }
C {devices/lab_pin.sym} 81660 -15800 0 0 {name=p81292 lab=_45413_/Y }
C {devices/lab_pin.sym} 81820 -15860 0 1 {name=p81293 lab=_45414_/X }
C {sky130_stdcells/a211o_4.sym} 81740 -15860 0 0 {name=X_45414_ }
C {devices/lab_pin.sym} 81700 -15710 0 0 {name=p81294 lab=_76234_/A }
C {devices/lab_pin.sym} 81780 -15710 0 1 {name=p81295 lab=_76234_/Y }
C {sky130_stdcells/inv_2.sym} 81740 -15710 0 0 {name=X_76234_ }
C {devices/lab_pin.sym} 81680 -15610 0 0 {name=p81296 lab=_42626_/A }
C {devices/lab_pin.sym} 81680 -15570 0 0 {name=p81297 lab=_40591_/B }
C {devices/lab_pin.sym} 81680 -15530 0 0 {name=p81298 lab=_40591_/C }
C {devices/lab_pin.sym} 81800 -15570 0 1 {name=p81299 lab=_42626_/X }
C {sky130_stdcells/and3_4.sym} 81740 -15570 0 0 {name=X_42626_ }
C {devices/lab_pin.sym} 81680 -15440 0 0 {name=p81300 lab=_49173_/A }
C {devices/lab_pin.sym} 81680 -15400 0 0 {name=p81301 lab=_50714_/B }
C {devices/lab_pin.sym} 81800 -15420 0 1 {name=p81302 lab=_49182_/X }
C {sky130_stdcells/and2_4.sym} 81740 -15420 0 0 {name=X_49182_ }
C {devices/lab_pin.sym} 81700 -15290 0 0 {name=p81303 lab=_72905_/A }
C {devices/lab_pin.sym} 81780 -15290 0 1 {name=p81304 lab=_73446_/X }
C {sky130_stdcells/buf_2.sym} 81740 -15290 0 0 {name=X_73446_ }
C {devices/lab_pin.sym} 81680 -15190 0 0 {name=p81305 lab=_61437_/A }
C {devices/lab_pin.sym} 81680 -15150 0 0 {name=p81306 lab=_61460_/B }
C {devices/lab_pin.sym} 81680 -15110 0 0 {name=p81307 lab=_61459_/X }
C {devices/lab_pin.sym} 81800 -15150 0 1 {name=p81308 lab=_61460_/Y }
C {sky130_stdcells/nand3_4.sym} 81740 -15150 0 0 {name=X_61460_ }
C {devices/lab_pin.sym} 81700 -15010 0 0 {name=p81309 lab=_83644_/Q }
C {devices/lab_pin.sym} 81780 -15010 0 1 {name=p81310 lab=_52484_/B }
C {sky130_stdcells/inv_2.sym} 81740 -15010 0 0 {name=X_46394_ }
C {devices/lab_pin.sym} 81680 -14920 0 0 {name=p81311 lab=_70727_/A }
C {devices/lab_pin.sym} 81680 -14880 0 0 {name=p81312 lab=_70656_/B }
C {devices/lab_pin.sym} 81680 -14840 0 0 {name=p81313 lab=_70890_/C }
C {devices/lab_pin.sym} 81680 -14800 0 0 {name=p81314 lab=_70656_/D }
C {devices/lab_pin.sym} 81800 -14860 0 1 {name=p81315 lab=_70658_/Y }
C {sky130_stdcells/nand4_4.sym} 81740 -14860 0 0 {name=X_70658_ }
C {devices/lab_pin.sym} 81660 -14730 0 0 {name=p81316 lab=_74234_/B }
C {devices/lab_pin.sym} 81660 -14690 0 0 {name=p81317 lab=_48103_/X }
C {devices/lab_pin.sym} 81660 -14650 0 0 {name=p81318 lab=_48132_/Y }
C {devices/lab_pin.sym} 81820 -14690 0 1 {name=p81319 lab=_48133_/Y }
C {sky130_stdcells/o21ai_4.sym} 81740 -14690 0 0 {name=X_48133_ }
C {sky130_stdcells/decap_3.sym} 81740 -14520 0 0 {name=XPHY_90 }
C {devices/lab_pin.sym} 81700 -14370 0 0 {name=p81320 lab=_63118_/A }
C {devices/lab_pin.sym} 81780 -14370 0 1 {name=p81321 lab=_63060_/A }
C {sky130_stdcells/buf_2.sym} 81740 -14370 0 0 {name=X_60411_ }
C {devices/lab_pin.sym} 81700 -14250 0 0 {name=p81322 lab=_45345_/A }
C {devices/lab_pin.sym} 81780 -14250 0 1 {name=p81323 lab=_45347_/A }
C {sky130_stdcells/inv_2.sym} 81740 -14250 0 0 {name=X_45345_ }
C {devices/lab_pin.sym} 81660 -14150 0 0 {name=p81324 lab=_76163_/Y }
C {devices/lab_pin.sym} 81660 -14110 0 0 {name=p81325 lab=_81634_/Q }
C {devices/lab_pin.sym} 81660 -14070 0 0 {name=p81326 lab=_76164_/Y }
C {devices/lab_pin.sym} 81820 -14110 0 1 {name=p81327 lab=_76165_/X }
C {sky130_stdcells/a21bo_4.sym} 81740 -14110 0 0 {name=X_76165_ }
C {devices/lab_pin.sym} 81660 -14010 0 0 {name=p81328 lab=_42554_/X }
C {devices/lab_pin.sym} 81660 -13970 0 0 {name=p81329 lab=_40792_/A }
C {devices/lab_pin.sym} 81660 -13930 0 0 {name=p81330 lab=_42477_/X }
C {devices/lab_pin.sym} 81660 -13890 0 0 {name=p81331 lab=_42555_/Y }
C {devices/lab_pin.sym} 81660 -13850 0 0 {name=p81332 lab=_42556_/X }
C {devices/lab_pin.sym} 81820 -13930 0 1 {name=p81333 lab=_87822_/D }
C {sky130_stdcells/o32ai_4.sym} 81740 -13930 0 0 {name=X_42557_ }
C {devices/lab_pin.sym} 81680 -13800 0 0 {name=p81334 lab=_64272_/A }
C {devices/lab_pin.sym} 81680 -13760 0 0 {name=p81335 lab=_61368_/B }
C {devices/lab_pin.sym} 81680 -13720 0 0 {name=p81336 lab=_61368_/C }
C {devices/lab_pin.sym} 81680 -13680 0 0 {name=p81337 lab=_61391_/D }
C {devices/lab_pin.sym} 81800 -13740 0 1 {name=p81338 lab=_61392_/A }
C {sky130_stdcells/nand4_4.sym} 81740 -13740 0 0 {name=X_61391_ }
C {devices/lab_pin.sym} 81660 -13610 0 0 {name=p81339 lab=_73370_/Y }
C {devices/lab_pin.sym} 81660 -13570 0 0 {name=p81340 lab=_73371_/Y }
C {devices/lab_pin.sym} 81660 -13530 0 0 {name=p81341 lab=_73376_/X }
C {devices/lab_pin.sym} 81820 -13570 0 1 {name=p81342 lab=_73377_/Y }
C {sky130_stdcells/o21ai_4.sym} 81740 -13570 0 0 {name=X_73377_ }
C {devices/lab_pin.sym} 81700 -13430 0 0 {name=p81343 lab=_70578_/A }
C {devices/lab_pin.sym} 81780 -13430 0 1 {name=p81344 lab=_70959_/C }
C {sky130_stdcells/buf_2.sym} 81740 -13430 0 0 {name=X_70589_ }
C {devices/lab_pin.sym} 81700 -13310 0 0 {name=p81345 lab=_83248_/CLK }
C {devices/lab_pin.sym} 81780 -13310 0 1 {name=p81346 lab=_84895_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 81740 -13310 0 0 {name=Xclkbuf_opt_4_CLK }
C {devices/lab_pin.sym} 81700 -13190 0 0 {name=p81347 lab=clkbuf_9_342_0_CLK/X }
C {devices/lab_pin.sym} 81780 -13190 0 1 {name=p81348 lab=_87195_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 81740 -13190 0 0 {name=Xclkbuf_10_685_0_CLK }
C {devices/lab_pin.sym} 81700 -13070 0 0 {name=p81349 lab=_63130_/A }
C {devices/lab_pin.sym} 81780 -13070 0 1 {name=p81350 lab=_63130_/X }
C {sky130_stdcells/buf_2.sym} 81740 -13070 0 0 {name=X_63130_ }
C {devices/lab_pin.sym} 81660 -12970 0 0 {name=p81351 lab=_75117_/B }
C {devices/lab_pin.sym} 81660 -12930 0 0 {name=p81352 lab=_75117_/C }
C {devices/lab_pin.sym} 81660 -12890 0 0 {name=p81353 lab=_75117_/A }
C {devices/lab_pin.sym} 81820 -12930 0 1 {name=p81354 lab=_75116_/X }
C {sky130_stdcells/a21o_4.sym} 81740 -12930 0 0 {name=X_75116_ }
C {devices/lab_pin.sym} 81660 -12820 0 0 {name=p81355 lab=_41507_/X }
C {devices/lab_pin.sym} 81660 -12780 0 0 {name=p81356 lab=_41486_/X }
C {devices/lab_pin.sym} 81660 -12740 0 0 {name=p81357 lab=_88202_/Q }
C {devices/lab_pin.sym} 81660 -12700 0 0 {name=p81358 lab=_41487_/X }
C {devices/lab_pin.sym} 81820 -12760 0 1 {name=p81359 lab=_41508_/X }
C {sky130_stdcells/a2bb2o_4.sym} 81740 -12760 0 0 {name=X_41508_ }
C {devices/lab_pin.sym} 81700 -12610 0 0 {name=p81360 lab=_48064_/A }
C {devices/lab_pin.sym} 81780 -12610 0 1 {name=p81361 lab=_48065_/A }
C {sky130_stdcells/inv_2.sym} 81740 -12610 0 0 {name=X_48064_ }
C {devices/lab_pin.sym} 81660 -12530 0 0 {name=p81362 lab=_60275_/X }
C {devices/lab_pin.sym} 81660 -12490 0 0 {name=p81363 lab=_60285_/Y }
C {devices/lab_pin.sym} 81660 -12450 0 0 {name=p81364 lab=_60306_/Y }
C {devices/lab_pin.sym} 81660 -12410 0 0 {name=p81365 lab=_79649_/A }
C {devices/lab_pin.sym} 81660 -12370 0 0 {name=p81366 lab=_60341_/X }
C {devices/lab_pin.sym} 81820 -12450 0 1 {name=p81367 lab=_60342_/X }
C {sky130_stdcells/o32a_4.sym} 81740 -12450 0 0 {name=X_60342_ }
C {devices/lab_pin.sym} 81660 -12310 0 0 {name=p81368 lab=_72240_/X }
C {devices/lab_pin.sym} 81660 -12270 0 0 {name=p81369 lab=_85680_/Q }
C {devices/lab_pin.sym} 81660 -12230 0 0 {name=p81370 lab=_72241_/X }
C {devices/lab_pin.sym} 81820 -12270 0 1 {name=p81371 lab=_72328_/X }
C {sky130_stdcells/o21a_4.sym} 81740 -12270 0 0 {name=X_72328_ }
C {devices/lab_pin.sym} 81660 -12150 0 0 {name=p81372 lab=_45270_/X }
C {devices/lab_pin.sym} 81660 -12110 0 0 {name=p81373 lab=_45273_/Y }
C {devices/lab_pin.sym} 81660 -12070 0 0 {name=p81374 lab=_45275_/X }
C {devices/lab_pin.sym} 81820 -12110 0 1 {name=p81375 lab=_45276_/Y }
C {sky130_stdcells/a21oi_4.sym} 81740 -12110 0 0 {name=X_45276_ }
C {devices/lab_pin.sym} 81680 -11990 0 0 {name=p81376 lab=_76096_/A }
C {devices/lab_pin.sym} 81680 -11950 0 0 {name=p81377 lab=_81720_/D }
C {devices/lab_pin.sym} 81680 -11910 0 0 {name=p81378 lab=_76075_/B }
C {devices/lab_pin.sym} 81800 -11950 0 1 {name=p81379 lab=_76096_/Y }
C {sky130_stdcells/nand3_4.sym} 81740 -11950 0 0 {name=X_76096_ }
C {devices/lab_pin.sym} 81700 -11810 0 0 {name=p81380 lab=_42488_/A }
C {devices/lab_pin.sym} 81780 -11810 0 1 {name=p81381 lab=_42556_/A }
C {sky130_stdcells/buf_2.sym} 81740 -11810 0 0 {name=X_42488_ }
C {devices/lab_pin.sym} 81700 -11690 0 0 {name=p81382 lab=clkbuf_8_88_0_CLK/X }
C {devices/lab_pin.sym} 81780 -11690 0 1 {name=p81383 lab=clkbuf_9_176_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 81740 -11690 0 0 {name=Xclkbuf_9_176_0_CLK }
C {devices/lab_pin.sym} 81700 -11570 0 0 {name=p81384 lab=_83047_/Q }
C {devices/lab_pin.sym} 81780 -11570 0 1 {name=p81385 lab=_47016_/A }
C {sky130_stdcells/inv_2.sym} 81740 -11570 0 0 {name=X_47015_ }
C {devices/lab_pin.sym} 81700 -11450 0 0 {name=p81386 lab=_44225_/Y }
C {devices/lab_pin.sym} 81780 -11450 0 1 {name=p81387 lab=_44227_/Y }
C {sky130_stdcells/inv_2.sym} 81740 -11450 0 0 {name=X_44227_ }
C {devices/lab_pin.sym} 81660 -11370 0 0 {name=p81388 lab=_58421_/A }
C {devices/lab_pin.sym} 81660 -11330 0 0 {name=p81389 lab=_63010_/X }
C {devices/lab_pin.sym} 81660 -11290 0 0 {name=p81390 lab=_63059_/X }
C {devices/lab_pin.sym} 81660 -11250 0 0 {name=p81391 lab=_59467_/Y }
C {devices/lab_pin.sym} 81660 -11210 0 0 {name=p81392 lab=_63060_/X }
C {devices/lab_pin.sym} 81820 -11290 0 1 {name=p81393 lab=_63061_/Y }
C {sky130_stdcells/o32ai_4.sym} 81740 -11290 0 0 {name=X_63061_ }
C {devices/lab_pin.sym} 81680 -11160 0 0 {name=p81394 lab=_75047_/A }
C {devices/lab_pin.sym} 81680 -11120 0 0 {name=p81395 lab=_75047_/B }
C {devices/lab_pin.sym} 81680 -11080 0 0 {name=p81396 lab=_75039_/X }
C {devices/lab_pin.sym} 81680 -11040 0 0 {name=p81397 lab=_75051_/B }
C {devices/lab_pin.sym} 81800 -11100 0 1 {name=p81398 lab=_75047_/Y }
C {sky130_stdcells/nand4_4.sym} 81740 -11100 0 0 {name=X_75047_ }
C {devices/lab_pin.sym} 81680 -10970 0 0 {name=p81399 lab=_79920_/Y }
C {devices/lab_pin.sym} 81680 -10930 0 0 {name=p81400 lab=_79924_/B }
C {devices/lab_pin.sym} 81680 -10890 0 0 {name=p81401 lab=_79924_/C }
C {devices/lab_pin.sym} 81800 -10930 0 1 {name=p81402 lab=_79927_/A }
C {sky130_stdcells/nand3_4.sym} 81740 -10930 0 0 {name=X_79924_ }
C {devices/lab_pin.sym} 81700 -10790 0 0 {name=p81403 lab=_40586_/A }
C {devices/lab_pin.sym} 81780 -10790 0 1 {name=p81404 lab=_41471_/B }
C {sky130_stdcells/buf_2.sym} 81740 -10790 0 0 {name=X_41439_ }
C {devices/lab_pin.sym} 81700 -10670 0 0 {name=p81405 lab=_60273_/A }
C {devices/lab_pin.sym} 81780 -10670 0 1 {name=p81406 lab=_60273_/X }
C {sky130_stdcells/buf_2.sym} 81740 -10670 0 0 {name=X_60273_ }
C {devices/lab_pin.sym} 81660 -10570 0 0 {name=p81407 lab=_72258_/X }
C {devices/lab_pin.sym} 81660 -10530 0 0 {name=p81408 lab=_85686_/Q }
C {devices/lab_pin.sym} 81660 -10490 0 0 {name=p81409 lab=_72146_/X }
C {devices/lab_pin.sym} 81820 -10530 0 1 {name=p81410 lab=_72259_/X }
C {sky130_stdcells/o21a_4.sym} 81740 -10530 0 0 {name=X_72259_ }
C {devices/lab_pin.sym} 81680 -10420 0 0 {name=p81411 lab=_61548_/B }
C {devices/lab_pin.sym} 81680 -10380 0 0 {name=p81412 lab=_61995_/X }
C {devices/lab_pin.sym} 81680 -10340 0 0 {name=p81413 lab=_62010_/X }
C {devices/lab_pin.sym} 81680 -10300 0 0 {name=p81414 lab=_62011_/X }
C {devices/lab_pin.sym} 81800 -10360 0 1 {name=p81415 lab=_62012_/Y }
C {sky130_stdcells/nand4_4.sym} 81740 -10360 0 0 {name=X_62012_ }
C {devices/lab_pin.sym} 81680 -10220 0 0 {name=p81416 lab=_60665_/C }
C {devices/lab_pin.sym} 81680 -10180 0 0 {name=p81417 lab=_44003_/X }
C {devices/lab_pin.sym} 81800 -10200 0 1 {name=p81418 lab=_44158_/Y }
C {sky130_stdcells/xnor2_4.sym} 81740 -10200 0 0 {name=X_44158_ }
C {devices/lab_pin.sym} 81660 -10100 0 0 {name=p81419 lab=_79854_/B }
C {devices/lab_pin.sym} 81660 -10060 0 0 {name=p81420 lab=_79835_/X }
C {devices/lab_pin.sym} 81660 -10020 0 0 {name=p81421 lab=_79840_/A }
C {devices/lab_pin.sym} 81660 -9980 0 0 {name=p81422 lab=_79827_/Y }
C {devices/lab_pin.sym} 81820 -10040 0 1 {name=p81423 lab=_79855_/X }
C {sky130_stdcells/a211o_4.sym} 81740 -10040 0 0 {name=X_79855_ }
C {devices/lab_pin.sym} 81660 -9930 0 0 {name=p81424 lab=_43105_/X }
C {devices/lab_pin.sym} 81660 -9890 0 0 {name=p81425 lab=_43106_/X }
C {devices/lab_pin.sym} 81660 -9850 0 0 {name=p81426 lab=_40753_/X }
C {devices/lab_pin.sym} 81660 -9810 0 0 {name=p81427 lab=_43107_/Y }
C {devices/lab_pin.sym} 81660 -9770 0 0 {name=p81428 lab=_43108_/X }
C {devices/lab_pin.sym} 81820 -9850 0 1 {name=p81429 lab=_43109_/Y }
C {sky130_stdcells/o32ai_4.sym} 81740 -9850 0 0 {name=X_43109_ }
C {devices/lab_pin.sym} 81660 -9720 0 0 {name=p81430 lab=_87433_/Q }
C {devices/lab_pin.sym} 81660 -9680 0 0 {name=p81431 lab=_66797_/X }
C {devices/lab_pin.sym} 81660 -9640 0 0 {name=p81432 lab=_66747_/X }
C {devices/lab_pin.sym} 81660 -9600 0 0 {name=p81433 lab=_66819_/X }
C {devices/lab_pin.sym} 81820 -9660 0 1 {name=p81434 lab=_66820_/X }
C {sky130_stdcells/a211o_4.sym} 81740 -9660 0 0 {name=X_66820_ }
C {devices/lab_pin.sym} 81700 -9510 0 0 {name=p81435 lab=_82546_/Q }
C {devices/lab_pin.sym} 81780 -9510 0 1 {name=p81436 lab=_78807_/A }
C {sky130_stdcells/inv_2.sym} 81740 -9510 0 0 {name=X_78806_ }
C {devices/lab_pin.sym} 81700 -9390 0 0 {name=p81437 lab=_48904_/A }
C {devices/lab_pin.sym} 81780 -9390 0 1 {name=p81438 lab=_49009_/B }
C {sky130_stdcells/buf_2.sym} 81740 -9390 0 0 {name=X_48966_ }
C {devices/lab_pin.sym} 81700 -9270 0 0 {name=p81439 lab=_44052_/A }
C {devices/lab_pin.sym} 81780 -9270 0 1 {name=p81440 lab=_44090_/B }
C {sky130_stdcells/buf_2.sym} 81740 -9270 0 0 {name=X_44089_ }
C {devices/lab_pin.sym} 81680 -9160 0 0 {name=p81441 lab=_79782_/X }
C {devices/lab_pin.sym} 81680 -9120 0 0 {name=p81442 lab=_79785_/Y }
C {devices/lab_pin.sym} 81800 -9140 0 1 {name=p81443 lab=_79786_/X }
C {sky130_stdcells/xor2_4.sym} 81740 -9140 0 0 {name=X_79786_ }
C {devices/lab_pin.sym} 81680 -9020 0 0 {name=p81444 lab=_60931_/C }
C {devices/lab_pin.sym} 81680 -8980 0 0 {name=p81445 lab=_76998_/B }
C {devices/lab_pin.sym} 81800 -9000 0 1 {name=p81446 lab=_76998_/X }
C {sky130_stdcells/xor2_4.sym} 81740 -9000 0 0 {name=X_76998_ }
C {devices/lab_pin.sym} 81700 -8870 0 0 {name=p81447 lab=_47917_/A }
C {devices/lab_pin.sym} 81780 -8870 0 1 {name=p81448 lab=_50270_/A }
C {sky130_stdcells/buf_2.sym} 81740 -8870 0 0 {name=X_47917_ }
C {devices/lab_pin.sym} 81700 -8750 0 0 {name=p81449 lab=_66608_/A }
C {devices/lab_pin.sym} 81780 -8750 0 1 {name=p81450 lab=_66751_/X }
C {sky130_stdcells/buf_2.sym} 81740 -8750 0 0 {name=X_66751_ }
C {devices/lab_pin.sym} 81680 -8650 0 0 {name=p81451 lab=_78732_/X }
C {devices/lab_pin.sym} 81680 -8610 0 0 {name=p81452 lab=_78735_/Y }
C {devices/lab_pin.sym} 81680 -8570 0 0 {name=p81453 lab=_78733_/Y }
C {devices/lab_pin.sym} 81800 -8610 0 1 {name=p81454 lab=_78737_/Y }
C {sky130_stdcells/nand3_4.sym} 81740 -8610 0 0 {name=X_78737_ }
C {devices/lab_pin.sym} 81700 -8470 0 0 {name=p81455 lab=_60871_/Y }
C {devices/lab_pin.sym} 81780 -8470 0 1 {name=p81456 lab=_64179_/B }
C {sky130_stdcells/buf_2.sym} 81740 -8470 0 0 {name=X_63963_ }
C {devices/lab_pin.sym} 81680 -8360 0 0 {name=p81457 lab=_75949_/A }
C {devices/lab_pin.sym} 81680 -8320 0 0 {name=p81458 lab=_75948_/Y }
C {devices/lab_pin.sym} 81800 -8340 0 1 {name=p81459 lab=_81734_/D }
C {sky130_stdcells/xor2_4.sym} 81740 -8340 0 0 {name=X_75949_ }
C {devices/lab_pin.sym} 81700 -8210 0 0 {name=p81460 lab=_48897_/A }
C {devices/lab_pin.sym} 81780 -8210 0 1 {name=p81461 lab=_48898_/A }
C {sky130_stdcells/buf_2.sym} 81740 -8210 0 0 {name=X_48897_ }
C {devices/lab_pin.sym} 81700 -8090 0 0 {name=p81462 lab=clkbuf_9_311_0_CLK/X }
C {devices/lab_pin.sym} 81780 -8090 0 1 {name=p81463 lab=_86758_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 81740 -8090 0 0 {name=Xclkbuf_10_623_0_CLK }
C {devices/lab_pin.sym} 81680 -7980 0 0 {name=p81464 lab=_65702_/A }
C {devices/lab_pin.sym} 81680 -7940 0 0 {name=p81465 lab=_85871_/Q }
C {devices/lab_pin.sym} 81800 -7960 0 1 {name=p81466 lab=_65702_/X }
C {sky130_stdcells/and2_4.sym} 81740 -7960 0 0 {name=X_65702_ }
C {devices/lab_pin.sym} 81660 -7850 0 0 {name=p81467 lab=_62912_/X }
C {devices/lab_pin.sym} 81660 -7810 0 0 {name=p81468 lab=_62893_/X }
C {devices/lab_pin.sym} 81660 -7770 0 0 {name=p81469 lab=_62913_/Y }
C {devices/lab_pin.sym} 81820 -7810 0 1 {name=p81470 lab=_84371_/D }
C {sky130_stdcells/a21oi_4.sym} 81740 -7810 0 0 {name=X_62914_ }
C {devices/lab_pin.sym} 81660 -7700 0 0 {name=p81471 lab=_87515_/Q }
C {devices/lab_pin.sym} 81660 -7660 0 0 {name=p81472 lab=_69468_/X }
C {devices/lab_pin.sym} 81660 -7620 0 0 {name=p81473 lab=_69343_/X }
C {devices/lab_pin.sym} 81660 -7580 0 0 {name=p81474 lab=_69469_/X }
C {devices/lab_pin.sym} 81820 -7640 0 1 {name=p81475 lab=_69470_/X }
C {sky130_stdcells/a211o_4.sym} 81740 -7640 0 0 {name=X_69470_ }
C {devices/lab_pin.sym} 81700 -7490 0 0 {name=p81476 lab=_51282_/A }
C {devices/lab_pin.sym} 81780 -7490 0 1 {name=p81477 lab=_47848_/X }
C {sky130_stdcells/buf_2.sym} 81740 -7490 0 0 {name=X_47848_ }
C {devices/lab_pin.sym} 81700 -7370 0 0 {name=p81478 lab=_57866_/A }
C {devices/lab_pin.sym} 81780 -7370 0 1 {name=p81479 lab=_66682_/X }
C {sky130_stdcells/buf_2.sym} 81740 -7370 0 0 {name=X_66682_ }
C {devices/lab_pin.sym} 81680 -7270 0 0 {name=p81480 lab=_78663_/X }
C {devices/lab_pin.sym} 81680 -7230 0 0 {name=p81481 lab=_78666_/Y }
C {devices/lab_pin.sym} 81680 -7190 0 0 {name=p81482 lab=_78664_/Y }
C {devices/lab_pin.sym} 81800 -7230 0 1 {name=p81483 lab=_78669_/B }
C {sky130_stdcells/nand3_4.sym} 81740 -7230 0 0 {name=X_78668_ }
C {devices/lab_pin.sym} 81680 -7120 0 0 {name=p81484 lab=_61438_/X }
C {devices/lab_pin.sym} 81680 -7080 0 0 {name=p81485 lab=_63877_/B }
C {devices/lab_pin.sym} 81680 -7040 0 0 {name=p81486 lab=_63894_/C }
C {devices/lab_pin.sym} 81680 -7000 0 0 {name=p81487 lab=_63877_/D }
C {devices/lab_pin.sym} 81800 -7060 0 1 {name=p81488 lab=_63894_/Y }
C {sky130_stdcells/nand4_4.sym} 81740 -7060 0 0 {name=X_63894_ }
C {devices/lab_pin.sym} 81700 -6910 0 0 {name=p81489 lab=clkbuf_8_57_0_CLK/X }
C {devices/lab_pin.sym} 81780 -6910 0 1 {name=p81490 lab=clkbuf_9_114_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 81740 -6910 0 0 {name=Xclkbuf_9_114_0_CLK }
C {devices/lab_pin.sym} 81700 -6790 0 0 {name=p81491 lab=_44245_/A }
C {devices/lab_pin.sym} 81780 -6790 0 1 {name=p81492 lab=_68421_/X }
C {sky130_stdcells/buf_2.sym} 81740 -6790 0 0 {name=X_68421_ }
C {devices/lab_pin.sym} 81700 -6670 0 0 {name=p81493 lab=_84188_/Q }
C {devices/lab_pin.sym} 81780 -6670 0 1 {name=p81494 lab=_65634_/C }
C {sky130_stdcells/inv_2.sym} 81740 -6670 0 0 {name=X_65633_ }
C {devices/lab_pin.sym} 81680 -6570 0 0 {name=p81495 lab=_77614_/X }
C {devices/lab_pin.sym} 81680 -6530 0 0 {name=p81496 lab=_77619_/B }
C {devices/lab_pin.sym} 81680 -6490 0 0 {name=p81497 lab=_77619_/C }
C {devices/lab_pin.sym} 81800 -6530 0 1 {name=p81498 lab=_77666_/A }
C {sky130_stdcells/nand3_4.sym} 81740 -6530 0 0 {name=X_77619_ }
C {devices/lab_pin.sym} 81700 -6390 0 0 {name=p81499 lab=clkbuf_8_20_0_CLK/X }
C {devices/lab_pin.sym} 81780 -6390 0 1 {name=p81500 lab=clkbuf_9_41_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 81740 -6390 0 0 {name=Xclkbuf_9_41_0_CLK }
C {devices/lab_pin.sym} 81700 -6270 0 0 {name=p81501 lab=_60274_/X }
C {devices/lab_pin.sym} 81780 -6270 0 1 {name=p81502 lab=_62889_/D }
C {sky130_stdcells/buf_2.sym} 81740 -6270 0 0 {name=X_62845_ }
C {devices/lab_pin.sym} 81700 -6150 0 0 {name=p81503 lab=_47779_/A }
C {devices/lab_pin.sym} 81780 -6150 0 1 {name=p81504 lab=_47780_/A }
C {sky130_stdcells/inv_2.sym} 81740 -6150 0 0 {name=X_47779_ }
C {devices/lab_pin.sym} 81680 -6040 0 0 {name=p81505 lab=_78623_/B }
C {devices/lab_pin.sym} 81680 -6000 0 0 {name=p81506 lab=_78623_/A }
C {devices/lab_pin.sym} 81800 -6020 0 1 {name=p81507 lab=_78599_/X }
C {sky130_stdcells/xor2_4.sym} 81740 -6020 0 0 {name=X_78599_ }
C {devices/lab_pin.sym} 81680 -5900 0 0 {name=p81508 lab=_49502_/A }
C {devices/lab_pin.sym} 81680 -5860 0 0 {name=p81509 lab=_51043_/B }
C {devices/lab_pin.sym} 81800 -5880 0 1 {name=p81510 lab=_49518_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -5880 0 0 {name=X_49518_ }
C {devices/lab_pin.sym} 81680 -5760 0 0 {name=p81511 lab=_80625_/X }
C {devices/lab_pin.sym} 81680 -5720 0 0 {name=p81512 lab=_80630_/B }
C {devices/lab_pin.sym} 81800 -5740 0 1 {name=p81513 lab=_80633_/C }
C {sky130_stdcells/xnor2_4.sym} 81740 -5740 0 0 {name=X_80630_ }
C {devices/lab_pin.sym} 81660 -5630 0 0 {name=p81514 lab=_68344_/X }
C {devices/lab_pin.sym} 81660 -5590 0 0 {name=p81515 lab=_68351_/X }
C {devices/lab_pin.sym} 81660 -5550 0 0 {name=p81516 lab=_58002_/A }
C {devices/lab_pin.sym} 81820 -5590 0 1 {name=p81517 lab=_68352_/X }
C {sky130_stdcells/a21o_4.sym} 81740 -5590 0 0 {name=X_68352_ }
C {devices/lab_pin.sym} 81680 -5460 0 0 {name=p81518 lab=_65779_/A }
C {devices/lab_pin.sym} 81680 -5420 0 0 {name=p81519 lab=_73012_/B }
C {devices/lab_pin.sym} 81800 -5440 0 1 {name=p81520 lab=_65564_/X }
C {sky130_stdcells/and2_4.sym} 81740 -5440 0 0 {name=X_65564_ }
C {devices/lab_pin.sym} 81680 -5320 0 0 {name=p81521 lab=_50777_/A }
C {devices/lab_pin.sym} 81680 -5280 0 0 {name=p81522 lab=_46396_/B }
C {devices/lab_pin.sym} 81800 -5300 0 1 {name=p81523 lab=_50790_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -5300 0 0 {name=X_50790_ }
C {devices/lab_pin.sym} 81700 -5170 0 0 {name=p81524 lab=_62717_/A }
C {devices/lab_pin.sym} 81780 -5170 0 1 {name=p81525 lab=_62789_/D }
C {sky130_stdcells/buf_2.sym} 81740 -5170 0 0 {name=X_62776_ }
C {devices/lab_pin.sym} 81700 -5050 0 0 {name=p81526 lab=clkbuf_9_319_0_CLK/X }
C {devices/lab_pin.sym} 81780 -5050 0 1 {name=p81527 lab=_82288_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 81740 -5050 0 0 {name=Xclkbuf_10_638_0_CLK }
C {devices/lab_pin.sym} 81660 -4960 0 0 {name=p81528 lab=_67141_/X }
C {devices/lab_pin.sym} 81660 -4920 0 0 {name=p81529 lab=_67292_/Y }
C {devices/lab_pin.sym} 81660 -4880 0 0 {name=p81530 lab=_67269_/X }
C {devices/lab_pin.sym} 81660 -4840 0 0 {name=p81531 lab=_67302_/Y }
C {devices/lab_pin.sym} 81820 -4900 0 1 {name=p81532 lab=_67303_/X }
C {sky130_stdcells/a211o_4.sym} 81740 -4900 0 0 {name=X_67303_ }
C {devices/lab_pin.sym} 81680 -4770 0 0 {name=p81533 lab=_64515_/A }
C {devices/lab_pin.sym} 81680 -4730 0 0 {name=p81534 lab=_59433_/A }
C {devices/lab_pin.sym} 81680 -4690 0 0 {name=p81535 lab=_64515_/C }
C {devices/lab_pin.sym} 81800 -4730 0 1 {name=p81536 lab=_64515_/Y }
C {sky130_stdcells/nand3_4.sym} 81740 -4730 0 0 {name=X_64515_ }
C {devices/lab_pin.sym} 81680 -4600 0 0 {name=p81537 lab=_49454_/A }
C {devices/lab_pin.sym} 81680 -4560 0 0 {name=p81538 lab=_50971_/B }
C {devices/lab_pin.sym} 81800 -4580 0 1 {name=p81539 lab=_49449_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -4580 0 0 {name=X_49449_ }
C {devices/lab_pin.sym} 81700 -4450 0 0 {name=p81540 lab=_59824_/B }
C {devices/lab_pin.sym} 81780 -4450 0 1 {name=p81541 lab=_61728_/A }
C {sky130_stdcells/buf_2.sym} 81740 -4450 0 0 {name=X_61727_ }
C {devices/lab_pin.sym} 81680 -4340 0 0 {name=p81542 lab=_80557_/X }
C {devices/lab_pin.sym} 81680 -4300 0 0 {name=p81543 lab=_80561_/B }
C {devices/lab_pin.sym} 81800 -4320 0 1 {name=p81544 lab=_80561_/X }
C {sky130_stdcells/xor2_4.sym} 81740 -4320 0 0 {name=X_80561_ }
C {devices/lab_pin.sym} 81700 -4190 0 0 {name=p81545 lab=_68208_/X }
C {devices/lab_pin.sym} 81780 -4190 0 1 {name=p81546 lab=_68283_/X }
C {sky130_stdcells/buf_2.sym} 81740 -4190 0 0 {name=X_68283_ }
C {devices/lab_pin.sym} 81680 -4090 0 0 {name=p81547 lab=_64730_/X }
C {devices/lab_pin.sym} 81680 -4050 0 0 {name=p81548 lab=_65647_/B }
C {devices/lab_pin.sym} 81680 -4010 0 0 {name=p81549 lab=_64735_/X }
C {devices/lab_pin.sym} 81800 -4050 0 1 {name=p81550 lab=_65495_/Y }
C {sky130_stdcells/nand3_4.sym} 81740 -4050 0 0 {name=X_65495_ }
C {devices/lab_pin.sym} 81700 -3910 0 0 {name=p81551 lab=clkbuf_8_64_0_CLK/X }
C {devices/lab_pin.sym} 81780 -3910 0 1 {name=p81552 lab=clkbuf_9_129_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 81740 -3910 0 0 {name=Xclkbuf_9_129_0_CLK }
C {devices/lab_pin.sym} 81650 -3790 0 0 {name=p81553 lab=_82299_/CLK }
C {devices/lab_pin.sym} 81650 -3770 0 0 {name=p81554 lab=_82300_/D }
C {devices/lab_pin.sym} 81830 -3790 0 1 {name=p81555 lab=_40790_/B }
C {sky130_stdcells/dfxtp_4.sym} 81740 -3780 0 0 {name=X_82300_ }
C {devices/lab_pin.sym} 81700 -3650 0 0 {name=p81556 lab=clkbuf_9_57_0_CLK/A }
C {devices/lab_pin.sym} 81780 -3650 0 1 {name=p81557 lab=clkbuf_9_56_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 81740 -3650 0 0 {name=Xclkbuf_9_56_0_CLK }
C {devices/lab_pin.sym} 81660 -3560 0 0 {name=p81558 lab=_67141_/X }
C {devices/lab_pin.sym} 81660 -3520 0 0 {name=p81559 lab=_67220_/Y }
C {devices/lab_pin.sym} 81660 -3480 0 0 {name=p81560 lab=_67152_/X }
C {devices/lab_pin.sym} 81660 -3440 0 0 {name=p81561 lab=_67233_/Y }
C {devices/lab_pin.sym} 81820 -3500 0 1 {name=p81562 lab=_67234_/X }
C {sky130_stdcells/a211o_4.sym} 81740 -3500 0 0 {name=X_67234_ }
C {devices/lab_pin.sym} 81680 -3360 0 0 {name=p81563 lab=_52466_/A }
C {devices/lab_pin.sym} 81680 -3320 0 0 {name=p81564 lab=_53980_/B }
C {devices/lab_pin.sym} 81800 -3340 0 1 {name=p81565 lab=_52460_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -3340 0 0 {name=X_52460_ }
C {devices/lab_pin.sym} 81680 -3220 0 0 {name=p81566 lab=_63611_/A }
C {devices/lab_pin.sym} 81680 -3180 0 0 {name=p81567 lab=_64419_/B }
C {devices/lab_pin.sym} 81800 -3200 0 1 {name=p81568 lab=_64446_/Y }
C {sky130_stdcells/nor2_4.sym} 81740 -3200 0 0 {name=X_64446_ }
C {devices/lab_pin.sym} 81650 -3070 0 0 {name=p81569 lab=_83711_/CLK }
C {devices/lab_pin.sym} 81650 -3050 0 0 {name=p81570 lab=_83280_/D }
C {devices/lab_pin.sym} 81830 -3070 0 1 {name=p81571 lab=_83280_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -3060 0 0 {name=X_83280_ }
C {devices/lab_pin.sym} 81660 -2970 0 0 {name=p81572 lab=_61649_/Y }
C {devices/lab_pin.sym} 81660 -2930 0 0 {name=p81573 lab=_61652_/Y }
C {devices/lab_pin.sym} 81660 -2890 0 0 {name=p81574 lab=_61594_/X }
C {devices/lab_pin.sym} 81660 -2850 0 0 {name=p81575 lab=_61655_/Y }
C {devices/lab_pin.sym} 81660 -2820 0 0 {name=p81576 lab=_61657_/Y }
C {devices/lab_pin.sym} 81820 -2890 0 1 {name=p81577 lab=_61658_/X }
C {sky130_stdcells/a41o_4.sym} 81740 -2890 0 0 {name=X_61658_ }
C {devices/lab_pin.sym} 81660 -2750 0 0 {name=p81578 lab=_80471_/B }
C {devices/lab_pin.sym} 81660 -2710 0 0 {name=p81579 lab=_80488_/X }
C {devices/lab_pin.sym} 81660 -2670 0 0 {name=p81580 lab=_80491_/Y }
C {devices/lab_pin.sym} 81820 -2710 0 1 {name=p81581 lab=_80492_/Y }
C {sky130_stdcells/a21oi_4.sym} 81740 -2710 0 0 {name=X_80492_ }
C {devices/lab_pin.sym} 81680 -2600 0 0 {name=p81582 lab=_51410_/X }
C {devices/lab_pin.sym} 81680 -2560 0 0 {name=p81583 lab=_51230_/X }
C {devices/lab_pin.sym} 81680 -2520 0 0 {name=p81584 lab=_51225_/C }
C {devices/lab_pin.sym} 81680 -2480 0 0 {name=p81585 lab=_52938_/D }
C {devices/lab_pin.sym} 81800 -2540 0 1 {name=p81586 lab=_51411_/X }
C {sky130_stdcells/and4_4.sym} 81740 -2540 0 0 {name=X_51411_ }
C {devices/lab_pin.sym} 81650 -2390 0 0 {name=p81587 lab=_82515_/CLK }
C {devices/lab_pin.sym} 81650 -2370 0 0 {name=p81588 lab=_82263_/Q }
C {devices/lab_pin.sym} 81830 -2390 0 1 {name=p81589 lab=_77538_/B }
C {sky130_stdcells/dfxtp_4.sym} 81740 -2380 0 0 {name=X_82231_ }
C {devices/lab_pin.sym} 81660 -2280 0 0 {name=p81590 lab=_60399_/Y }
C {devices/lab_pin.sym} 81660 -2240 0 0 {name=p81591 lab=_60488_/C }
C {devices/lab_pin.sym} 81660 -2200 0 0 {name=p81592 lab=_60583_/Y }
C {devices/lab_pin.sym} 81660 -2160 0 0 {name=p81593 lab=_60608_/X }
C {devices/lab_pin.sym} 81820 -2220 0 1 {name=p81594 lab=_60609_/X }
C {sky130_stdcells/a211o_4.sym} 81740 -2220 0 0 {name=X_60609_ }
C {devices/lab_pin.sym} 81660 -2090 0 0 {name=p81595 lab=_84081_/Q }
C {devices/lab_pin.sym} 81660 -2050 0 0 {name=p81596 lab=_67092_/X }
C {devices/lab_pin.sym} 81660 -2010 0 0 {name=p81597 lab=_67164_/X }
C {devices/lab_pin.sym} 81820 -2050 0 1 {name=p81598 lab=_67165_/X }
C {sky130_stdcells/a21bo_4.sym} 81740 -2050 0 0 {name=X_67165_ }
C {devices/lab_pin.sym} 81660 -1930 0 0 {name=p81599 lab=_50693_/A }
C {devices/lab_pin.sym} 81660 -1890 0 0 {name=p81600 lab=_50693_/B }
C {devices/lab_pin.sym} 81660 -1850 0 0 {name=p81601 lab=_52295_/A }
C {devices/lab_pin.sym} 81820 -1890 0 1 {name=p81602 lab=_52391_/X }
C {sky130_stdcells/o21a_4.sym} 81740 -1890 0 0 {name=X_52391_ }
C {devices/lab_pin.sym} 81700 -1750 0 0 {name=p81603 lab=_64377_/A }
C {devices/lab_pin.sym} 81780 -1750 0 1 {name=p81604 lab=_64377_/X }
C {sky130_stdcells/buf_2.sym} 81740 -1750 0 0 {name=X_64377_ }
C {devices/lab_pin.sym} 81700 -1630 0 0 {name=p81605 lab=_72561_/C }
C {devices/lab_pin.sym} 81780 -1630 0 1 {name=p81606 lab=_61590_/C }
C {sky130_stdcells/buf_2.sym} 81740 -1630 0 0 {name=X_61589_ }
C {devices/lab_pin.sym} 81680 -1520 0 0 {name=p81607 lab=_54134_/A }
C {devices/lab_pin.sym} 81680 -1480 0 0 {name=p81608 lab=_54130_/B }
C {devices/lab_pin.sym} 81800 -1500 0 1 {name=p81609 lab=_54130_/Y }
C {sky130_stdcells/nand2_4.sym} 81740 -1500 0 0 {name=X_54130_ }
C {devices/lab_pin.sym} 81660 -1390 0 0 {name=p81610 lab=_66113_/X }
C {devices/lab_pin.sym} 81660 -1350 0 0 {name=p81611 lab=_66115_/X }
C {devices/lab_pin.sym} 81660 -1310 0 0 {name=p81612 lab=_65961_/X }
C {devices/lab_pin.sym} 81820 -1350 0 1 {name=p81613 lab=_66116_/X }
C {sky130_stdcells/a21o_4.sym} 81740 -1350 0 0 {name=X_66116_ }
C {devices/lab_pin.sym} 81700 -1210 0 0 {name=p81614 lab=_53671_/A }
C {devices/lab_pin.sym} 81780 -1210 0 1 {name=p81615 lab=_51352_/C }
C {sky130_stdcells/buf_2.sym} 81740 -1210 0 0 {name=X_51342_ }
C {devices/lab_pin.sym} 81660 -1110 0 0 {name=p81616 lab=_79198_/A }
C {devices/lab_pin.sym} 81660 -1070 0 0 {name=p81617 lab=_63310_/X }
C {devices/lab_pin.sym} 81660 -1030 0 0 {name=p81618 lab=_63327_/X }
C {devices/lab_pin.sym} 81820 -1070 0 1 {name=p81619 lab=_63328_/Y }
C {sky130_stdcells/o21ai_4.sym} 81740 -1070 0 0 {name=X_63328_ }
C {devices/lab_pin.sym} 81650 -930 0 0 {name=p81620 lab=_82746_/CLK }
C {devices/lab_pin.sym} 81650 -910 0 0 {name=p81621 lab=_66138_/A }
C {devices/lab_pin.sym} 81830 -930 0 1 {name=p81622 lab=_82162_/Q }
C {sky130_stdcells/dfxtp_4.sym} 81740 -920 0 0 {name=X_82162_ }
C {devices/lab_pin.sym} 81660 -820 0 0 {name=p81623 lab=_87933_/Q }
C {devices/lab_pin.sym} 81660 -780 0 0 {name=p81624 lab=_66994_/X }
C {devices/lab_pin.sym} 81660 -740 0 0 {name=p81625 lab=_67046_/X }
C {devices/lab_pin.sym} 81660 -700 0 0 {name=p81626 lab=_67095_/X }
C {devices/lab_pin.sym} 81820 -760 0 1 {name=p81627 lab=_67096_/X }
C {sky130_stdcells/a211o_4.sym} 81740 -760 0 0 {name=X_67096_ }
C {devices/lab_pin.sym} 82570 -42150 0 0 {name=p81628 lab=_80728_/CLK }
C {devices/lab_pin.sym} 82570 -42130 0 0 {name=p81629 lab=_79802_/X }
C {devices/lab_pin.sym} 82750 -42150 0 1 {name=p81630 lab=_81113_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -42140 0 0 {name=X_81113_ }
C {devices/lab_pin.sym} 82600 -42020 0 0 {name=p81631 lab=_54031_/A }
C {devices/lab_pin.sym} 82600 -41980 0 0 {name=p81632 lab=_50850_/B }
C {devices/lab_pin.sym} 82720 -42000 0 1 {name=p81633 lab=_54061_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -42000 0 0 {name=X_54061_ }
C {devices/lab_pin.sym} 82620 -41870 0 0 {name=p81634 lab=_84160_/Q }
C {devices/lab_pin.sym} 82700 -41870 0 1 {name=p81635 lab=_66048_/C }
C {sky130_stdcells/inv_2.sym} 82660 -41870 0 0 {name=X_66047_ }
C {devices/lab_pin.sym} 82580 -41770 0 0 {name=p81636 lab=_64794_/B }
C {devices/lab_pin.sym} 82580 -41730 0 0 {name=p81637 lab=_51259_/X }
C {devices/lab_pin.sym} 82580 -41690 0 0 {name=p81638 lab=_51272_/Y }
C {devices/lab_pin.sym} 82740 -41730 0 1 {name=p81639 lab=_51273_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -41730 0 0 {name=X_51273_ }
C {devices/lab_pin.sym} 82620 -41590 0 0 {name=p81640 lab=_63010_/A }
C {devices/lab_pin.sym} 82700 -41590 0 1 {name=p81641 lab=_63259_/X }
C {sky130_stdcells/buf_2.sym} 82660 -41590 0 0 {name=X_63259_ }
C {devices/lab_pin.sym} 82570 -41470 0 0 {name=p81642 lab=_87472_/CLK }
C {devices/lab_pin.sym} 82570 -41450 0 0 {name=p81643 lab=_86970_/D }
C {devices/lab_pin.sym} 82750 -41470 0 1 {name=p81644 lab=_86970_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -41460 0 0 {name=X_86970_ }
C {devices/lab_pin.sym} 82570 -41330 0 0 {name=p81645 lab=_82139_/CLK }
C {devices/lab_pin.sym} 82570 -41310 0 0 {name=p81646 lab=_82093_/D }
C {devices/lab_pin.sym} 82750 -41330 0 1 {name=p81647 lab=_82093_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -41320 0 0 {name=X_82093_ }
C {devices/lab_pin.sym} 82600 -41200 0 0 {name=p81648 lab=_53025_/A }
C {devices/lab_pin.sym} 82600 -41160 0 0 {name=p81649 lab=_53012_/B }
C {devices/lab_pin.sym} 82720 -41180 0 1 {name=p81650 lab=_53012_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -41180 0 0 {name=X_53012_ }
C {devices/lab_pin.sym} 82600 -41060 0 0 {name=p81651 lab=_51737_/A }
C {devices/lab_pin.sym} 82600 -41020 0 0 {name=p81652 lab=_50224_/B }
C {devices/lab_pin.sym} 82720 -41040 0 1 {name=p81653 lab=_50224_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -41040 0 0 {name=X_50224_ }
C {devices/lab_pin.sym} 82570 -40910 0 0 {name=p81654 lab=_83161_/CLK }
C {devices/lab_pin.sym} 82570 -40890 0 0 {name=p81655 lab=_85921_/D }
C {devices/lab_pin.sym} 82750 -40910 0 1 {name=p81656 lab=_73561_/B }
C {sky130_stdcells/dfxtp_4.sym} 82660 -40900 0 0 {name=X_85921_ }
C {devices/lab_pin.sym} 82570 -40770 0 0 {name=p81657 lab=_81117_/CLK }
C {devices/lab_pin.sym} 82570 -40750 0 0 {name=p81658 lab=_75345_/X }
C {devices/lab_pin.sym} 82750 -40770 0 1 {name=p81659 lab=_81044_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -40760 0 0 {name=X_81044_ }
C {devices/lab_pin.sym} 82600 -40640 0 0 {name=p81660 lab=_57806_/X }
C {devices/lab_pin.sym} 82600 -40600 0 0 {name=p81661 lab=_57820_/B }
C {devices/lab_pin.sym} 82720 -40620 0 1 {name=p81662 lab=_57820_/Y }
C {sky130_stdcells/nor2_4.sym} 82660 -40620 0 0 {name=X_57820_ }
C {devices/lab_pin.sym} 82580 -40520 0 0 {name=p81663 lab=_73225_/A }
C {devices/lab_pin.sym} 82580 -40480 0 0 {name=p81664 lab=_69747_/X }
C {devices/lab_pin.sym} 82580 -40440 0 0 {name=p81665 lab=_69617_/X }
C {devices/lab_pin.sym} 82580 -40400 0 0 {name=p81666 lab=_69805_/Y }
C {devices/lab_pin.sym} 82740 -40460 0 1 {name=p81667 lab=_69806_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -40460 0 0 {name=X_69806_ }
C {devices/lab_pin.sym} 82620 -40310 0 0 {name=p81668 lab=_48833_/A }
C {devices/lab_pin.sym} 82700 -40310 0 1 {name=p81669 lab=_51256_/B }
C {sky130_stdcells/buf_2.sym} 82660 -40310 0 0 {name=X_50155_ }
C {devices/lab_pin.sym} 82570 -40190 0 0 {name=p81670 lab=_85566_/CLK }
C {devices/lab_pin.sym} 82570 -40170 0 0 {name=p81671 lab=_52292_/Y }
C {devices/lab_pin.sym} 82750 -40190 0 1 {name=p81672 lab=_64753_/B }
C {sky130_stdcells/dfxtp_4.sym} 82660 -40180 0 0 {name=X_85852_ }
C {devices/lab_pin.sym} 82600 -40060 0 0 {name=p81673 lab=_67972_/A }
C {devices/lab_pin.sym} 82600 -40020 0 0 {name=p81674 lab=_87703_/Q }
C {devices/lab_pin.sym} 82720 -40040 0 1 {name=p81675 lab=_67998_/X }
C {sky130_stdcells/and2_4.sym} 82660 -40040 0 0 {name=X_67998_ }
C {devices/lab_pin.sym} 82570 -39910 0 0 {name=p81676 lab=_86713_/CLK }
C {devices/lab_pin.sym} 82570 -39890 0 0 {name=p81677 lab=_84803_/D }
C {devices/lab_pin.sym} 82750 -39910 0 1 {name=p81678 lab=_84803_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -39900 0 0 {name=X_84803_ }
C {devices/lab_pin.sym} 82580 -39790 0 0 {name=p81679 lab=_57748_/Y }
C {devices/lab_pin.sym} 82580 -39750 0 0 {name=p81680 lab=_57750_/Y }
C {devices/lab_pin.sym} 82580 -39710 0 0 {name=p81681 lab=_57718_/X }
C {devices/lab_pin.sym} 82740 -39750 0 1 {name=p81682 lab=_57751_/X }
C {sky130_stdcells/a21o_4.sym} 82660 -39750 0 0 {name=X_57751_ }
C {devices/lab_pin.sym} 82600 -39620 0 0 {name=p81683 lab=_69687_/A }
C {devices/lab_pin.sym} 82600 -39580 0 0 {name=p81684 lab=_69737_/B }
C {devices/lab_pin.sym} 82720 -39600 0 1 {name=p81685 lab=_69737_/Y }
C {sky130_stdcells/nor2_4.sym} 82660 -39600 0 0 {name=X_69737_ }
C {devices/lab_pin.sym} 82600 -39480 0 0 {name=p81686 lab=_50069_/A }
C {devices/lab_pin.sym} 82600 -39440 0 0 {name=p81687 lab=_71989_/B }
C {devices/lab_pin.sym} 82720 -39460 0 1 {name=p81688 lab=_50086_/X }
C {sky130_stdcells/and2_4.sym} 82660 -39460 0 0 {name=X_50086_ }
C {devices/lab_pin.sym} 82620 -39330 0 0 {name=p81689 lab=_54888_/A }
C {devices/lab_pin.sym} 82700 -39330 0 1 {name=p81690 lab=_54964_/A }
C {sky130_stdcells/buf_2.sym} 82660 -39330 0 0 {name=X_54963_ }
C {devices/lab_pin.sym} 82580 -39240 0 0 {name=p81691 lab=_87875_/Q }
C {devices/lab_pin.sym} 82580 -39200 0 0 {name=p81692 lab=_66875_/X }
C {devices/lab_pin.sym} 82580 -39160 0 0 {name=p81693 lab=_66926_/X }
C {devices/lab_pin.sym} 82580 -39120 0 0 {name=p81694 lab=_66948_/X }
C {devices/lab_pin.sym} 82740 -39180 0 1 {name=p81695 lab=_66949_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -39180 0 0 {name=X_66949_ }
C {devices/lab_pin.sym} 82570 -39030 0 0 {name=p81696 lab=_82956_/CLK }
C {devices/lab_pin.sym} 82570 -39010 0 0 {name=p81697 lab=_85783_/D }
C {devices/lab_pin.sym} 82750 -39030 0 1 {name=p81698 lab=_85783_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -39020 0 0 {name=X_85783_ }
C {devices/lab_pin.sym} 82570 -38890 0 0 {name=p81699 lab=_85075_/CLK }
C {devices/lab_pin.sym} 82570 -38870 0 0 {name=p81700 lab=_82995_/D }
C {devices/lab_pin.sym} 82750 -38890 0 1 {name=p81701 lab=_82995_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -38880 0 0 {name=X_82995_ }
C {devices/lab_pin.sym} 82600 -38760 0 0 {name=p81702 lab=_56702_/A }
C {devices/lab_pin.sym} 82600 -38720 0 0 {name=p81703 lab=_56685_/B }
C {devices/lab_pin.sym} 82720 -38740 0 1 {name=p81704 lab=_56702_/X }
C {sky130_stdcells/and2_4.sym} 82660 -38740 0 0 {name=X_56702_ }
C {devices/lab_pin.sym} 82570 -38610 0 0 {name=p81705 lab=_88034_/CLK }
C {devices/lab_pin.sym} 82570 -38590 0 0 {name=p81706 lab=_87522_/D }
C {devices/lab_pin.sym} 82750 -38610 0 1 {name=p81707 lab=_87522_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -38600 0 0 {name=X_87522_ }
C {devices/lab_pin.sym} 82620 -38470 0 0 {name=p81708 lab=_53838_/A }
C {devices/lab_pin.sym} 82700 -38470 0 1 {name=p81709 lab=_53914_/X }
C {sky130_stdcells/buf_2.sym} 82660 -38470 0 0 {name=X_53914_ }
C {devices/lab_pin.sym} 82570 -38350 0 0 {name=p81710 lab=_83438_/CLK }
C {devices/lab_pin.sym} 82570 -38330 0 0 {name=p81711 lab=_84734_/D }
C {devices/lab_pin.sym} 82750 -38350 0 1 {name=p81712 lab=_59433_/A }
C {sky130_stdcells/dfxtp_4.sym} 82660 -38340 0 0 {name=X_84734_ }
C {devices/lab_pin.sym} 82620 -38210 0 0 {name=p81713 lab=_57682_/A }
C {devices/lab_pin.sym} 82700 -38210 0 1 {name=p81714 lab=_57682_/Y }
C {sky130_stdcells/inv_2.sym} 82660 -38210 0 0 {name=X_57682_ }
C {devices/lab_pin.sym} 82570 -38090 0 0 {name=p81715 lab=_81970_/CLK }
C {devices/lab_pin.sym} 82570 -38070 0 0 {name=p81716 lab=_77944_/B }
C {devices/lab_pin.sym} 82750 -38090 0 1 {name=p81717 lab=_81946_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -38080 0 0 {name=X_81946_ }
C {devices/lab_pin.sym} 82600 -37960 0 0 {name=p81718 lab=_69663_/X }
C {devices/lab_pin.sym} 82600 -37920 0 0 {name=p81719 lab=_69668_/B }
C {devices/lab_pin.sym} 82720 -37940 0 1 {name=p81720 lab=_69668_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -37940 0 0 {name=X_69668_ }
C {devices/lab_pin.sym} 82600 -37820 0 0 {name=p81721 lab=_54893_/X }
C {devices/lab_pin.sym} 82600 -37780 0 0 {name=p81722 lab=_54894_/B }
C {devices/lab_pin.sym} 82720 -37800 0 1 {name=p81723 lab=_54894_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -37800 0 0 {name=X_54894_ }
C {devices/lab_pin.sym} 82600 -37680 0 0 {name=p81724 lab=_59421_/A }
C {devices/lab_pin.sym} 82600 -37640 0 0 {name=p81725 lab=_59424_/B }
C {devices/lab_pin.sym} 82720 -37660 0 1 {name=p81726 lab=_59421_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -37660 0 0 {name=X_59421_ }
C {devices/lab_pin.sym} 82600 -37540 0 0 {name=p81727 lab=_55503_/D }
C {devices/lab_pin.sym} 82600 -37500 0 0 {name=p81728 lab=_56632_/Y }
C {devices/lab_pin.sym} 82720 -37520 0 1 {name=p81729 lab=_56633_/X }
C {sky130_stdcells/xor2_4.sym} 82660 -37520 0 0 {name=X_56633_ }
C {devices/lab_pin.sym} 82580 -37420 0 0 {name=p81730 lab=_88105_/Q }
C {devices/lab_pin.sym} 82580 -37380 0 0 {name=p81731 lab=_68467_/X }
C {devices/lab_pin.sym} 82580 -37340 0 0 {name=p81732 lab=_68617_/X }
C {devices/lab_pin.sym} 82580 -37300 0 0 {name=p81733 lab=_68618_/Y }
C {devices/lab_pin.sym} 82740 -37360 0 1 {name=p81734 lab=_68619_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -37360 0 0 {name=X_68619_ }
C {devices/lab_pin.sym} 82570 -37210 0 0 {name=p81735 lab=_87446_/CLK }
C {devices/lab_pin.sym} 82570 -37190 0 0 {name=p81736 lab=_43377_/Y }
C {devices/lab_pin.sym} 82750 -37210 0 1 {name=p81737 lab=_87453_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -37200 0 0 {name=X_87453_ }
C {devices/lab_pin.sym} 82580 -37090 0 0 {name=p81738 lab=_53842_/Y }
C {devices/lab_pin.sym} 82580 -37050 0 0 {name=p81739 lab=_53838_/X }
C {devices/lab_pin.sym} 82580 -37010 0 0 {name=p81740 lab=_53844_/Y }
C {devices/lab_pin.sym} 82740 -37050 0 1 {name=p81741 lab=_53845_/Y }
C {sky130_stdcells/a21boi_4.sym} 82660 -37050 0 0 {name=X_53845_ }
C {devices/lab_pin.sym} 82570 -36910 0 0 {name=p81742 lab=_84508_/CLK }
C {devices/lab_pin.sym} 82570 -36890 0 0 {name=p81743 lab=_60082_/Y }
C {devices/lab_pin.sym} 82750 -36910 0 1 {name=p81744 lab=_80082_/A }
C {sky130_stdcells/dfxtp_4.sym} 82660 -36900 0 0 {name=X_84665_ }
C {devices/lab_pin.sym} 82570 -36770 0 0 {name=p81745 lab=_81872_/CLK }
C {devices/lab_pin.sym} 82570 -36750 0 0 {name=p81746 lab=_78068_/X }
C {devices/lab_pin.sym} 82750 -36770 0 1 {name=p81747 lab=_81877_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -36760 0 0 {name=X_81877_ }
C {devices/lab_pin.sym} 82600 -36640 0 0 {name=p81748 lab=_69596_/X }
C {devices/lab_pin.sym} 82600 -36600 0 0 {name=p81749 lab=_69598_/X }
C {devices/lab_pin.sym} 82720 -36620 0 1 {name=p81750 lab=_69599_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -36620 0 0 {name=X_69599_ }
C {devices/lab_pin.sym} 82570 -36490 0 0 {name=p81751 lab=_86404_/CLK }
C {devices/lab_pin.sym} 82570 -36470 0 0 {name=p81752 lab=_86404_/D }
C {devices/lab_pin.sym} 82750 -36490 0 1 {name=p81753 lab=_65367_/B }
C {sky130_stdcells/dfxtp_4.sym} 82660 -36480 0 0 {name=X_86404_ }
C {devices/lab_pin.sym} 82620 -36350 0 0 {name=p81754 lab=_40810_/A }
C {devices/lab_pin.sym} 82700 -36350 0 1 {name=p81755 lab=_40810_/X }
C {sky130_stdcells/buf_2.sym} 82660 -36350 0 0 {name=X_40810_ }
C {devices/lab_pin.sym} 82580 -36250 0 0 {name=p81756 lab=_59348_/Y }
C {devices/lab_pin.sym} 82580 -36210 0 0 {name=p81757 lab=_59350_/Y }
C {devices/lab_pin.sym} 82580 -36170 0 0 {name=p81758 lab=_59351_/X }
C {devices/lab_pin.sym} 82740 -36210 0 1 {name=p81759 lab=_59352_/X }
C {sky130_stdcells/a21o_4.sym} 82660 -36210 0 0 {name=X_59352_ }
C {devices/lab_pin.sym} 82620 -36070 0 0 {name=p81760 lab=_71655_/A }
C {devices/lab_pin.sym} 82700 -36070 0 1 {name=p81761 lab=_71641_/A }
C {sky130_stdcells/buf_2.sym} 82660 -36070 0 0 {name=X_71630_ }
C {devices/lab_pin.sym} 82570 -35950 0 0 {name=p81762 lab=_85558_/CLK }
C {devices/lab_pin.sym} 82570 -35930 0 0 {name=p81763 lab=_83616_/D }
C {devices/lab_pin.sym} 82750 -35950 0 1 {name=p81764 lab=_48972_/A }
C {sky130_stdcells/dfxtp_4.sym} 82660 -35940 0 0 {name=X_83616_ }
C {devices/lab_pin.sym} 82600 -35840 0 0 {name=p81765 lab=_56564_/A }
C {devices/lab_pin.sym} 82600 -35800 0 0 {name=p81766 lab=_56564_/B }
C {devices/lab_pin.sym} 82600 -35760 0 0 {name=p81767 lab=_56564_/C }
C {devices/lab_pin.sym} 82600 -35720 0 0 {name=p81768 lab=_56564_/D }
C {devices/lab_pin.sym} 82720 -35780 0 1 {name=p81769 lab=_56931_/A }
C {sky130_stdcells/nand4_4.sym} 82660 -35780 0 0 {name=X_56564_ }
C {devices/lab_pin.sym} 82570 -35630 0 0 {name=p81770 lab=_83944_/CLK }
C {devices/lab_pin.sym} 82570 -35610 0 0 {name=p81771 lab=_83972_/Q }
C {devices/lab_pin.sym} 82750 -35630 0 1 {name=p81772 lab=_75657_/B }
C {sky130_stdcells/dfxtp_4.sym} 82660 -35620 0 0 {name=X_80828_ }
C {devices/lab_pin.sym} 82570 -35490 0 0 {name=p81773 lab=_88215_/CLK }
C {devices/lab_pin.sym} 82570 -35470 0 0 {name=p81774 lab=_43511_/Y }
C {devices/lab_pin.sym} 82750 -35490 0 1 {name=p81775 lab=_87384_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -35480 0 0 {name=X_87384_ }
C {devices/lab_pin.sym} 82580 -35370 0 0 {name=p81776 lab=_40402_/A }
C {devices/lab_pin.sym} 82580 -35330 0 0 {name=p81777 lab=_41452_/A }
C {devices/lab_pin.sym} 82580 -35290 0 0 {name=p81778 lab=_41789_/X }
C {devices/lab_pin.sym} 82740 -35330 0 1 {name=p81779 lab=_41790_/X }
C {sky130_stdcells/o21a_4.sym} 82660 -35330 0 0 {name=X_41790_ }
C {devices/lab_pin.sym} 82600 -35200 0 0 {name=p81780 lab=_53791_/A }
C {devices/lab_pin.sym} 82600 -35160 0 0 {name=p81781 lab=_48704_/Y }
C {devices/lab_pin.sym} 82720 -35180 0 1 {name=p81782 lab=_53776_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -35180 0 0 {name=X_53776_ }
C {devices/lab_pin.sym} 82570 -35050 0 0 {name=p81783 lab=_82452_/CLK }
C {devices/lab_pin.sym} 82570 -35030 0 0 {name=p81784 lab=_84596_/D }
C {devices/lab_pin.sym} 82750 -35050 0 1 {name=p81785 lab=_79136_/A }
C {sky130_stdcells/dfxtp_4.sym} 82660 -35040 0 0 {name=X_84596_ }
C {devices/lab_pin.sym} 82580 -34930 0 0 {name=p81786 lab=_86094_/Q }
C {devices/lab_pin.sym} 82580 -34890 0 0 {name=p81787 lab=_50965_/X }
C {devices/lab_pin.sym} 82580 -34850 0 0 {name=p81788 lab=_50987_/Y }
C {devices/lab_pin.sym} 82740 -34890 0 1 {name=p81789 lab=_50988_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -34890 0 0 {name=X_50988_ }
C {devices/lab_pin.sym} 82620 -34750 0 0 {name=p81790 lab=_58303_/A }
C {devices/lab_pin.sym} 82700 -34750 0 1 {name=p81791 lab=_58303_/Y }
C {sky130_stdcells/inv_2.sym} 82660 -34750 0 0 {name=X_58303_ }
C {devices/lab_pin.sym} 82580 -34660 0 0 {name=p81792 lab=_45567_/A }
C {devices/lab_pin.sym} 82580 -34620 0 0 {name=p81793 lab=_55511_/X }
C {devices/lab_pin.sym} 82580 -34580 0 0 {name=p81794 lab=_55513_/X }
C {devices/lab_pin.sym} 82580 -34540 0 0 {name=p81795 lab=_55514_/Y }
C {devices/lab_pin.sym} 82740 -34600 0 1 {name=p81796 lab=_55515_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -34600 0 0 {name=X_55515_ }
C {devices/lab_pin.sym} 82570 -34450 0 0 {name=p81797 lab=_86655_/CLK }
C {devices/lab_pin.sym} 82570 -34430 0 0 {name=p81798 lab=_86335_/D }
C {devices/lab_pin.sym} 82750 -34450 0 1 {name=p81799 lab=_57731_/B }
C {sky130_stdcells/dfxtp_4.sym} 82660 -34440 0 0 {name=X_86335_ }
C {devices/lab_pin.sym} 82580 -34330 0 0 {name=p81800 lab=_85765_/Q }
C {devices/lab_pin.sym} 82580 -34290 0 0 {name=p81801 lab=_52711_/X }
C {devices/lab_pin.sym} 82580 -34250 0 0 {name=p81802 lab=_52726_/Y }
C {devices/lab_pin.sym} 82740 -34290 0 1 {name=p81803 lab=_52727_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -34290 0 0 {name=X_52727_ }
C {devices/lab_pin.sym} 82600 -34160 0 0 {name=p81804 lab=_40741_/A }
C {devices/lab_pin.sym} 82600 -34120 0 0 {name=p81805 lab=_40760_/B }
C {devices/lab_pin.sym} 82720 -34140 0 1 {name=p81806 lab=_40741_/X }
C {sky130_stdcells/or2_4.sym} 82660 -34140 0 0 {name=X_40741_ }
C {devices/lab_pin.sym} 82600 -34030 0 0 {name=p81807 lab=_71586_/A }
C {devices/lab_pin.sym} 82600 -33990 0 0 {name=p81808 lab=_71553_/B }
C {devices/lab_pin.sym} 82600 -33950 0 0 {name=p81809 lab=_71558_/X }
C {devices/lab_pin.sym} 82720 -33990 0 1 {name=p81810 lab=_71561_/Y }
C {sky130_stdcells/nor3_4.sym} 82660 -33990 0 0 {name=X_71561_ }
C {devices/lab_pin.sym} 82580 -33890 0 0 {name=p81811 lab=_59253_/X }
C {devices/lab_pin.sym} 82580 -33850 0 0 {name=p81812 lab=_59281_/Y }
C {devices/lab_pin.sym} 82580 -33810 0 0 {name=p81813 lab=_59282_/Y }
C {devices/lab_pin.sym} 82580 -33770 0 0 {name=p81814 lab=_59271_/X }
C {devices/lab_pin.sym} 82580 -33730 0 0 {name=p81815 lab=_59258_/X }
C {devices/lab_pin.sym} 82740 -33810 0 1 {name=p81816 lab=_59283_/X }
C {sky130_stdcells/o32a_4.sym} 82660 -33810 0 0 {name=X_59283_ }
C {devices/lab_pin.sym} 82570 -33650 0 0 {name=p81817 lab=_85354_/CLK }
C {devices/lab_pin.sym} 82570 -33630 0 0 {name=p81818 lab=_83547_/D }
C {devices/lab_pin.sym} 82750 -33650 0 1 {name=p81819 lab=_83547_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -33640 0 0 {name=X_83547_ }
C {devices/lab_pin.sym} 82580 -33530 0 0 {name=p81820 lab=_56064_/X }
C {devices/lab_pin.sym} 82580 -33490 0 0 {name=p81821 lab=_56483_/X }
C {devices/lab_pin.sym} 82580 -33450 0 0 {name=p81822 lab=_56494_/Y }
C {devices/lab_pin.sym} 82740 -33490 0 1 {name=p81823 lab=_56495_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -33490 0 0 {name=X_56495_ }
C {devices/lab_pin.sym} 82570 -33350 0 0 {name=p81824 lab=_81134_/CLK }
C {devices/lab_pin.sym} 82570 -33330 0 0 {name=p81825 lab=_80759_/D }
C {devices/lab_pin.sym} 82750 -33350 0 1 {name=p81826 lab=_81135_/D }
C {sky130_stdcells/dfxtp_4.sym} 82660 -33340 0 0 {name=X_80759_ }
C {devices/lab_pin.sym} 82580 -33240 0 0 {name=p81827 lab=_43170_/Y }
C {devices/lab_pin.sym} 82580 -33200 0 0 {name=p81828 lab=_73298_/X }
C {devices/lab_pin.sym} 82580 -33160 0 0 {name=p81829 lab=_73251_/X }
C {devices/lab_pin.sym} 82580 -33120 0 0 {name=p81830 lab=_73299_/Y }
C {devices/lab_pin.sym} 82740 -33180 0 1 {name=p81831 lab=_73300_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -33180 0 0 {name=X_73300_ }
C {devices/lab_pin.sym} 82580 -33050 0 0 {name=p81832 lab=_57655_/Y }
C {devices/lab_pin.sym} 82580 -33010 0 0 {name=p81833 lab=_70501_/X }
C {devices/lab_pin.sym} 82580 -32970 0 0 {name=p81834 lab=_70511_/Y }
C {devices/lab_pin.sym} 82740 -33010 0 1 {name=p81835 lab=_83760_/D }
C {sky130_stdcells/o21ai_4.sym} 82660 -33010 0 0 {name=X_70512_ }
C {sky130_stdcells/decap_3.sym} 82660 -32840 0 0 {name=XPHY_600 }
C {devices/lab_pin.sym} 82600 -32700 0 0 {name=p81836 lab=_58230_/A }
C {devices/lab_pin.sym} 82600 -32660 0 0 {name=p81837 lab=_58233_/Y }
C {devices/lab_pin.sym} 82720 -32680 0 1 {name=p81838 lab=_58234_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -32680 0 0 {name=X_58234_ }
C {devices/lab_pin.sym} 82580 -32590 0 0 {name=p81839 lab=_43449_/X }
C {devices/lab_pin.sym} 82580 -32550 0 0 {name=p81840 lab=_43452_/X }
C {devices/lab_pin.sym} 82580 -32510 0 0 {name=p81841 lab=_41631_/X }
C {devices/lab_pin.sym} 82580 -32470 0 0 {name=p81842 lab=_87411_/Q }
C {devices/lab_pin.sym} 82580 -32430 0 0 {name=p81843 lab=_43456_/X }
C {devices/lab_pin.sym} 82740 -32510 0 1 {name=p81844 lab=_43461_/A }
C {sky130_stdcells/o32ai_4.sym} 82660 -32510 0 0 {name=X_43460_ }
C {devices/lab_pin.sym} 82600 -32360 0 0 {name=p81845 lab=_55446_/A }
C {devices/lab_pin.sym} 82600 -32320 0 0 {name=p81846 lab=_55328_/X }
C {devices/lab_pin.sym} 82720 -32340 0 1 {name=p81847 lab=_55446_/X }
C {sky130_stdcells/and2_4.sym} 82660 -32340 0 0 {name=X_55446_ }
C {devices/lab_pin.sym} 82580 -32230 0 0 {name=p81848 lab=_74268_/X }
C {devices/lab_pin.sym} 82580 -32190 0 0 {name=p81849 lab=_74281_/C }
C {devices/lab_pin.sym} 82580 -32150 0 0 {name=p81850 lab=_74279_/X }
C {devices/lab_pin.sym} 82740 -32190 0 1 {name=p81851 lab=_74280_/X }
C {sky130_stdcells/a21o_4.sym} 82660 -32190 0 0 {name=X_74280_ }
C {devices/lab_pin.sym} 82570 -32050 0 0 {name=p81852 lab=_85562_/CLK }
C {devices/lab_pin.sym} 82570 -32030 0 0 {name=p81853 lab=_50094_/Y }
C {devices/lab_pin.sym} 82750 -32050 0 1 {name=p81854 lab=_64804_/B }
C {sky130_stdcells/dfxtp_4.sym} 82660 -32040 0 0 {name=X_86266_ }
C {sky130_stdcells/decap_3.sym} 82660 -31880 0 0 {name=XPHY_611 }
C {devices/lab_pin.sym} 82580 -31750 0 0 {name=p81855 lab=_40670_/X }
C {devices/lab_pin.sym} 82580 -31710 0 0 {name=p81856 lab=_82866_/Q }
C {devices/lab_pin.sym} 82580 -31670 0 0 {name=p81857 lab=_40671_/X }
C {devices/lab_pin.sym} 82740 -31710 0 1 {name=p81858 lab=_40672_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -31710 0 0 {name=X_40672_ }
C {devices/lab_pin.sym} 82600 -31580 0 0 {name=p81859 lab=_52657_/X }
C {devices/lab_pin.sym} 82600 -31540 0 0 {name=p81860 lab=_52658_/B }
C {devices/lab_pin.sym} 82720 -31560 0 1 {name=p81861 lab=_52658_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -31560 0 0 {name=X_52658_ }
C {devices/lab_pin.sym} 82600 -31450 0 0 {name=p81862 lab=_71488_/X }
C {devices/lab_pin.sym} 82600 -31410 0 0 {name=p81863 lab=_71297_/X }
C {devices/lab_pin.sym} 82600 -31370 0 0 {name=p81864 lab=_71496_/C }
C {devices/lab_pin.sym} 82720 -31410 0 1 {name=p81865 lab=_71492_/X }
C {sky130_stdcells/and3_4.sym} 82660 -31410 0 0 {name=X_71492_ }
C {devices/lab_pin.sym} 82570 -31270 0 0 {name=p81866 lab=_83415_/CLK }
C {devices/lab_pin.sym} 82570 -31250 0 0 {name=p81867 lab=_71497_/X }
C {devices/lab_pin.sym} 82750 -31270 0 1 {name=p81868 lab=_83478_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -31260 0 0 {name=X_83478_ }
C {sky130_stdcells/decap_3.sym} 82660 -31100 0 0 {name=XPHY_622 }
C {sky130_stdcells/decap_3.sym} 82660 -30920 0 0 {name=XPHY_633 }
C {devices/lab_pin.sym} 82620 -30770 0 0 {name=p81869 lab=_41872_/A }
C {devices/lab_pin.sym} 82700 -30770 0 1 {name=p81870 lab=_42411_/X }
C {sky130_stdcells/buf_2.sym} 82660 -30770 0 0 {name=X_42411_ }
C {devices/lab_pin.sym} 82570 -30650 0 0 {name=p81871 lab=_88006_/CLK }
C {devices/lab_pin.sym} 82570 -30630 0 0 {name=p81872 lab=_88005_/D }
C {devices/lab_pin.sym} 82750 -30650 0 1 {name=p81873 lab=_88005_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -30640 0 0 {name=X_88005_ }
C {sky130_stdcells/decap_3.sym} 82660 -30480 0 0 {name=XPHY_644 }
C {devices/lab_pin.sym} 82580 -30350 0 0 {name=p81874 lab=_88321_/Q }
C {devices/lab_pin.sym} 82580 -30310 0 0 {name=p81875 lab=_73086_/X }
C {devices/lab_pin.sym} 82580 -30270 0 0 {name=p81876 lab=_73202_/X }
C {devices/lab_pin.sym} 82740 -30310 0 1 {name=p81877 lab=_73231_/X }
C {sky130_stdcells/o21a_4.sym} 82660 -30310 0 0 {name=X_73231_ }
C {devices/lab_pin.sym} 82570 -30170 0 0 {name=p81878 lab=_85249_/CLK }
C {devices/lab_pin.sym} 82570 -30150 0 0 {name=p81879 lab=_85217_/D }
C {devices/lab_pin.sym} 82750 -30170 0 1 {name=p81880 lab=_85217_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -30160 0 0 {name=X_85217_ }
C {devices/lab_pin.sym} 82600 -30060 0 0 {name=p81881 lab=_51619_/A }
C {devices/lab_pin.sym} 82600 -30020 0 0 {name=p81882 lab=_51603_/B }
C {devices/lab_pin.sym} 82600 -29980 0 0 {name=p81883 lab=_51608_/X }
C {devices/lab_pin.sym} 82600 -29940 0 0 {name=p81884 lab=_53133_/D }
C {devices/lab_pin.sym} 82720 -30000 0 1 {name=p81885 lab=_51609_/X }
C {sky130_stdcells/and4_4.sym} 82660 -30000 0 0 {name=X_51609_ }
C {devices/lab_pin.sym} 82580 -29870 0 0 {name=p81886 lab=_50293_/B }
C {devices/lab_pin.sym} 82580 -29830 0 0 {name=p81887 lab=_70422_/X }
C {devices/lab_pin.sym} 82580 -29790 0 0 {name=p81888 lab=_70442_/Y }
C {devices/lab_pin.sym} 82740 -29830 0 1 {name=p81889 lab=_70443_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -29830 0 0 {name=X_70443_ }
C {devices/lab_pin.sym} 82580 -29710 0 0 {name=p81890 lab=_58153_/X }
C {devices/lab_pin.sym} 82580 -29670 0 0 {name=p81891 lab=_83493_/Q }
C {devices/lab_pin.sym} 82580 -29630 0 0 {name=p81892 lab=_58164_/Y }
C {devices/lab_pin.sym} 82740 -29670 0 1 {name=p81893 lab=_58165_/X }
C {sky130_stdcells/o21a_4.sym} 82660 -29670 0 0 {name=X_58165_ }
C {sky130_stdcells/decap_3.sym} 82660 -29500 0 0 {name=XPHY_655 }
C {devices/lab_pin.sym} 82570 -29350 0 0 {name=p81894 lab=_84197_/CLK }
C {devices/lab_pin.sym} 82570 -29330 0 0 {name=p81895 lab=_82429_/D }
C {devices/lab_pin.sym} 82750 -29350 0 1 {name=p81896 lab=_78710_/A }
C {sky130_stdcells/dfxtp_4.sym} 82660 -29340 0 0 {name=X_82429_ }
C {devices/lab_pin.sym} 82600 -29220 0 0 {name=p81897 lab=_55374_/Y }
C {devices/lab_pin.sym} 82600 -29180 0 0 {name=p81898 lab=_55375_/A }
C {devices/lab_pin.sym} 82720 -29200 0 1 {name=p81899 lab=_55377_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -29200 0 0 {name=X_55377_ }
C {devices/lab_pin.sym} 82620 -29070 0 0 {name=p81900 lab=_43390_/Y }
C {devices/lab_pin.sym} 82700 -29070 0 1 {name=p81901 lab=_87446_/D }
C {sky130_stdcells/inv_2.sym} 82660 -29070 0 0 {name=X_43391_ }
C {devices/lab_pin.sym} 82570 -28950 0 0 {name=p81902 lab=_86191_/CLK }
C {devices/lab_pin.sym} 82570 -28930 0 0 {name=p81903 lab=_50457_/Y }
C {devices/lab_pin.sym} 82750 -28950 0 1 {name=p81904 lab=_86197_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -28940 0 0 {name=X_86197_ }
C {sky130_stdcells/decap_3.sym} 82660 -28780 0 0 {name=XPHY_666 }
C {devices/lab_pin.sym} 82580 -28650 0 0 {name=p81905 lab=_52587_/Y }
C {devices/lab_pin.sym} 82580 -28610 0 0 {name=p81906 lab=_52532_/X }
C {devices/lab_pin.sym} 82580 -28570 0 0 {name=p81907 lab=_52588_/X }
C {devices/lab_pin.sym} 82740 -28610 0 1 {name=p81908 lab=_52589_/Y }
C {sky130_stdcells/a21oi_4.sym} 82660 -28610 0 0 {name=X_52589_ }
C {sky130_stdcells/decap_3.sym} 82660 -28440 0 0 {name=XPHY_677 }
C {sky130_stdcells/decap_3.sym} 82660 -28260 0 0 {name=XPHY_688 }
C {devices/lab_pin.sym} 82580 -28130 0 0 {name=p81909 lab=_45119_/X }
C {devices/lab_pin.sym} 82580 -28090 0 0 {name=p81910 lab=_45126_/Y }
C {devices/lab_pin.sym} 82580 -28050 0 0 {name=p81911 lab=_45129_/Y }
C {devices/lab_pin.sym} 82740 -28090 0 1 {name=p81912 lab=_45130_/Y }
C {sky130_stdcells/a21oi_4.sym} 82660 -28090 0 0 {name=X_45130_ }
C {devices/lab_pin.sym} 82600 -27970 0 0 {name=p81913 lab=_56960_/X }
C {devices/lab_pin.sym} 82600 -27930 0 0 {name=p81914 lab=_85079_/Q }
C {devices/lab_pin.sym} 82600 -27890 0 0 {name=p81915 lab=_57112_/X }
C {devices/lab_pin.sym} 82720 -27930 0 1 {name=p81916 lab=_57116_/Y }
C {sky130_stdcells/nor3_4.sym} 82660 -27930 0 0 {name=X_57116_ }
C {devices/lab_pin.sym} 82580 -27810 0 0 {name=p81917 lab=_85462_/Q }
C {devices/lab_pin.sym} 82580 -27770 0 0 {name=p81918 lab=_54320_/X }
C {devices/lab_pin.sym} 82580 -27730 0 0 {name=p81919 lab=_54327_/Y }
C {devices/lab_pin.sym} 82740 -27770 0 1 {name=p81920 lab=_54328_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -27770 0 0 {name=X_54328_ }
C {devices/lab_pin.sym} 82620 -27630 0 0 {name=p81921 lab=_42290_/A }
C {devices/lab_pin.sym} 82700 -27630 0 1 {name=p81922 lab=_42342_/X }
C {sky130_stdcells/buf_2.sym} 82660 -27630 0 0 {name=X_42342_ }
C {devices/lab_pin.sym} 82580 -27530 0 0 {name=p81923 lab=_73159_/X }
C {devices/lab_pin.sym} 82580 -27490 0 0 {name=p81924 lab=_73161_/X }
C {devices/lab_pin.sym} 82580 -27450 0 0 {name=p81925 lab=_72877_/X }
C {devices/lab_pin.sym} 82740 -27490 0 1 {name=p81926 lab=_73168_/A }
C {sky130_stdcells/a21o_4.sym} 82660 -27490 0 0 {name=X_73162_ }
C {sky130_stdcells/decap_3.sym} 82660 -27320 0 0 {name=XPHY_699 }
C {devices/lab_pin.sym} 82570 -27170 0 0 {name=p81927 lab=_85114_/CLK }
C {devices/lab_pin.sym} 82570 -27150 0 0 {name=p81928 lab=_85148_/D }
C {devices/lab_pin.sym} 82750 -27170 0 1 {name=p81929 lab=_85148_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -27160 0 0 {name=X_85148_ }
C {devices/lab_pin.sym} 82620 -27030 0 0 {name=p81930 lab=_70809_/A }
C {devices/lab_pin.sym} 82700 -27030 0 1 {name=p81931 lab=_70374_/X }
C {sky130_stdcells/buf_2.sym} 82660 -27030 0 0 {name=X_70374_ }
C {devices/lab_pin.sym} 82600 -26920 0 0 {name=p81932 lab=_58576_/A }
C {devices/lab_pin.sym} 82600 -26880 0 0 {name=p81933 lab=_58096_/B }
C {devices/lab_pin.sym} 82720 -26900 0 1 {name=p81934 lab=_58096_/Y }
C {sky130_stdcells/nor2_4.sym} 82660 -26900 0 0 {name=X_58096_ }
C {devices/lab_pin.sym} 82600 -26790 0 0 {name=p81935 lab=_72113_/A }
C {devices/lab_pin.sym} 82600 -26750 0 0 {name=p81936 lab=_72113_/B }
C {devices/lab_pin.sym} 82600 -26710 0 0 {name=p81937 lab=_72048_/X }
C {devices/lab_pin.sym} 82720 -26750 0 1 {name=p81938 lab=_72113_/X }
C {sky130_stdcells/and3_4.sym} 82660 -26750 0 0 {name=X_72113_ }
C {devices/lab_pin.sym} 82580 -26630 0 0 {name=p81939 lab=_55896_/B }
C {devices/lab_pin.sym} 82580 -26590 0 0 {name=p81940 lab=_45060_/X }
C {devices/lab_pin.sym} 82580 -26550 0 0 {name=p81941 lab=_45040_/X }
C {devices/lab_pin.sym} 82740 -26590 0 1 {name=p81942 lab=_45061_/X }
C {sky130_stdcells/o21a_4.sym} 82660 -26590 0 0 {name=X_45061_ }
C {devices/lab_pin.sym} 82580 -26470 0 0 {name=p81943 lab=_56761_/X }
C {devices/lab_pin.sym} 82580 -26430 0 0 {name=p81944 lab=_57046_/Y }
C {devices/lab_pin.sym} 82580 -26390 0 0 {name=p81945 lab=_57038_/B }
C {devices/lab_pin.sym} 82740 -26430 0 1 {name=p81946 lab=_57047_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -26430 0 0 {name=X_57047_ }
C {devices/lab_pin.sym} 82580 -26320 0 0 {name=p81947 lab=_41507_/X }
C {devices/lab_pin.sym} 82580 -26280 0 0 {name=p81948 lab=_42271_/X }
C {devices/lab_pin.sym} 82580 -26240 0 0 {name=p81949 lab=_87946_/Q }
C {devices/lab_pin.sym} 82580 -26200 0 0 {name=p81950 lab=_42272_/X }
C {devices/lab_pin.sym} 82740 -26260 0 1 {name=p81951 lab=_87946_/D }
C {sky130_stdcells/a2bb2o_4.sym} 82660 -26260 0 0 {name=X_42273_ }
C {devices/lab_pin.sym} 82600 -26140 0 0 {name=p81952 lab=_54255_/A }
C {devices/lab_pin.sym} 82600 -26100 0 0 {name=p81953 lab=_54246_/X }
C {devices/lab_pin.sym} 82600 -26060 0 0 {name=p81954 lab=_54255_/C }
C {devices/lab_pin.sym} 82600 -26020 0 0 {name=p81955 lab=_53090_/D }
C {devices/lab_pin.sym} 82720 -26080 0 1 {name=p81956 lab=_54259_/X }
C {sky130_stdcells/and4_4.sym} 82660 -26080 0 0 {name=X_54259_ }
C {devices/lab_pin.sym} 82600 -25940 0 0 {name=p81957 lab=_73093_/A }
C {devices/lab_pin.sym} 82600 -25900 0 0 {name=p81958 lab=_65612_/B }
C {devices/lab_pin.sym} 82720 -25920 0 1 {name=p81959 lab=_73093_/X }
C {sky130_stdcells/and2_4.sym} 82660 -25920 0 0 {name=X_73093_ }
C {devices/lab_pin.sym} 82600 -25800 0 0 {name=p81960 lab=_82172_/Q }
C {devices/lab_pin.sym} 82600 -25760 0 0 {name=p81961 lab=_77970_/B }
C {devices/lab_pin.sym} 82720 -25780 0 1 {name=p81962 lab=_77970_/X }
C {sky130_stdcells/xor2_4.sym} 82660 -25780 0 0 {name=X_77970_ }
C {devices/lab_pin.sym} 82570 -25650 0 0 {name=p81963 lab=_85013_/CLK }
C {devices/lab_pin.sym} 82570 -25630 0 0 {name=p81964 lab=_85079_/D }
C {devices/lab_pin.sym} 82750 -25650 0 1 {name=p81965 lab=_85079_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -25640 0 0 {name=X_85079_ }
C {devices/lab_pin.sym} 82620 -25510 0 0 {name=p81966 lab=_44012_/A }
C {devices/lab_pin.sym} 82700 -25510 0 1 {name=p81967 lab=_64806_/A }
C {sky130_stdcells/buf_2.sym} 82660 -25510 0 0 {name=X_44012_ }
C {devices/lab_pin.sym} 82580 -25410 0 0 {name=p81968 lab=_41136_/X }
C {devices/lab_pin.sym} 82580 -25370 0 0 {name=p81969 lab=_40705_/A }
C {devices/lab_pin.sym} 82580 -25330 0 0 {name=p81970 lab=_41223_/X }
C {devices/lab_pin.sym} 82740 -25370 0 1 {name=p81971 lab=_41224_/X }
C {sky130_stdcells/o21a_4.sym} 82660 -25370 0 0 {name=X_41224_ }
C {devices/lab_pin.sym} 82600 -25250 0 0 {name=p81972 lab=_49060_/A }
C {devices/lab_pin.sym} 82600 -25210 0 0 {name=p81973 lab=_72043_/X }
C {devices/lab_pin.sym} 82600 -25170 0 0 {name=p81974 lab=_71964_/X }
C {devices/lab_pin.sym} 82720 -25210 0 1 {name=p81975 lab=_72044_/X }
C {sky130_stdcells/and3_4.sym} 82660 -25210 0 0 {name=X_72044_ }
C {devices/lab_pin.sym} 82620 -25070 0 0 {name=p81976 lab=_76920_/Y }
C {devices/lab_pin.sym} 82700 -25070 0 1 {name=p81977 lab=_76921_/Y }
C {sky130_stdcells/inv_2.sym} 82660 -25070 0 0 {name=X_76921_ }
C {devices/lab_pin.sym} 82600 -24960 0 0 {name=p81978 lab=_48831_/A }
C {devices/lab_pin.sym} 82600 -24920 0 0 {name=p81979 lab=_48820_/B }
C {devices/lab_pin.sym} 82720 -24940 0 1 {name=p81980 lab=_48820_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -24940 0 0 {name=X_48820_ }
C {devices/lab_pin.sym} 82600 -24820 0 0 {name=p81981 lab=_79627_/Y }
C {devices/lab_pin.sym} 82600 -24780 0 0 {name=p81982 lab=_79630_/X }
C {devices/lab_pin.sym} 82720 -24800 0 1 {name=p81983 lab=_79642_/B }
C {sky130_stdcells/or2_4.sym} 82660 -24800 0 0 {name=X_79640_ }
C {devices/lab_pin.sym} 82600 -24680 0 0 {name=p81984 lab=_41159_/A }
C {devices/lab_pin.sym} 82600 -24640 0 0 {name=p81985 lab=_81145_/Q }
C {devices/lab_pin.sym} 82720 -24660 0 1 {name=p81986 lab=_41155_/X }
C {sky130_stdcells/or2_4.sym} 82660 -24660 0 0 {name=X_41155_ }
C {devices/lab_pin.sym} 82580 -24550 0 0 {name=p81987 lab=_76841_/A }
C {devices/lab_pin.sym} 82580 -24510 0 0 {name=p81988 lab=_76840_/Y }
C {devices/lab_pin.sym} 82580 -24470 0 0 {name=p81989 lab=_76851_/X }
C {devices/lab_pin.sym} 82740 -24510 0 1 {name=p81990 lab=_76852_/Y }
C {sky130_stdcells/a21oi_4.sym} 82660 -24510 0 0 {name=X_76852_ }
C {devices/lab_pin.sym} 82580 -24410 0 0 {name=p81991 lab=_58918_/X }
C {devices/lab_pin.sym} 82580 -24370 0 0 {name=p81992 lab=_58996_/Y }
C {devices/lab_pin.sym} 82580 -24330 0 0 {name=p81993 lab=_58997_/Y }
C {devices/lab_pin.sym} 82580 -24290 0 0 {name=p81994 lab=_58959_/X }
C {devices/lab_pin.sym} 82580 -24250 0 0 {name=p81995 lab=_58923_/X }
C {devices/lab_pin.sym} 82740 -24330 0 1 {name=p81996 lab=_58998_/X }
C {sky130_stdcells/o32a_4.sym} 82660 -24330 0 0 {name=X_58998_ }
C {devices/lab_pin.sym} 82600 -24190 0 0 {name=p81997 lab=_75793_/B }
C {devices/lab_pin.sym} 82600 -24150 0 0 {name=p81998 lab=_75793_/A }
C {devices/lab_pin.sym} 82600 -24110 0 0 {name=p81999 lab=_75803_/C }
C {devices/lab_pin.sym} 82720 -24150 0 1 {name=p82000 lab=_75810_/A }
C {sky130_stdcells/nand3_4.sym} 82660 -24150 0 0 {name=X_75803_ }
C {devices/lab_pin.sym} 82580 -24030 0 0 {name=p82001 lab=_65551_/B }
C {devices/lab_pin.sym} 82580 -23990 0 0 {name=p82002 lab=_48730_/X }
C {devices/lab_pin.sym} 82580 -23950 0 0 {name=p82003 lab=_48750_/Y }
C {devices/lab_pin.sym} 82740 -23990 0 1 {name=p82004 lab=_48751_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -23990 0 0 {name=X_48751_ }
C {devices/lab_pin.sym} 82620 -23850 0 0 {name=p82005 lab=_79571_/A }
C {devices/lab_pin.sym} 82700 -23850 0 1 {name=p82006 lab=_79573_/B }
C {sky130_stdcells/inv_2.sym} 82660 -23850 0 0 {name=X_79571_ }
C {devices/lab_pin.sym} 82620 -23730 0 0 {name=p82007 lab=_45962_/X }
C {devices/lab_pin.sym} 82700 -23730 0 1 {name=p82008 lab=_45963_/X }
C {sky130_stdcells/buf_2.sym} 82660 -23730 0 0 {name=X_45963_ }
C {devices/lab_pin.sym} 82580 -23630 0 0 {name=p82009 lab=_41073_/X }
C {devices/lab_pin.sym} 82580 -23590 0 0 {name=p82010 lab=_81702_/Q }
C {devices/lab_pin.sym} 82580 -23550 0 0 {name=p82011 lab=_41085_/X }
C {devices/lab_pin.sym} 82740 -23590 0 1 {name=p82012 lab=_41086_/X }
C {sky130_stdcells/o21a_4.sym} 82660 -23590 0 0 {name=X_41086_ }
C {devices/lab_pin.sym} 82580 -23470 0 0 {name=p82013 lab=_57947_/X }
C {devices/lab_pin.sym} 82580 -23430 0 0 {name=p82014 lab=_85713_/Q }
C {devices/lab_pin.sym} 82580 -23390 0 0 {name=p82015 lab=_57948_/X }
C {devices/lab_pin.sym} 82740 -23430 0 1 {name=p82016 lab=_57949_/X }
C {sky130_stdcells/o21a_4.sym} 82660 -23430 0 0 {name=X_57949_ }
C {devices/lab_pin.sym} 82600 -23300 0 0 {name=p82017 lab=_81584_/Q }
C {devices/lab_pin.sym} 82600 -23260 0 0 {name=p82018 lab=_76783_/B }
C {devices/lab_pin.sym} 82720 -23280 0 1 {name=p82019 lab=_81552_/D }
C {sky130_stdcells/xor2_4.sym} 82660 -23280 0 0 {name=X_76783_ }
C {devices/lab_pin.sym} 82600 -23160 0 0 {name=p82020 lab=_44126_/X }
C {devices/lab_pin.sym} 82600 -23120 0 0 {name=p82021 lab=_66168_/B }
C {devices/lab_pin.sym} 82720 -23140 0 1 {name=p82022 lab=_73995_/X }
C {sky130_stdcells/and2_4.sym} 82660 -23140 0 0 {name=X_73995_ }
C {devices/lab_pin.sym} 82600 -23040 0 0 {name=p82023 lab=_47692_/A }
C {devices/lab_pin.sym} 82600 -23000 0 0 {name=p82024 lab=_47739_/B }
C {devices/lab_pin.sym} 82600 -22960 0 0 {name=p82025 lab=_47692_/C }
C {devices/lab_pin.sym} 82600 -22920 0 0 {name=p82026 lab=_53196_/D }
C {devices/lab_pin.sym} 82720 -22980 0 1 {name=p82027 lab=_47702_/X }
C {sky130_stdcells/and4_4.sym} 82660 -22980 0 0 {name=X_47702_ }
C {devices/lab_pin.sym} 82620 -22830 0 0 {name=p82028 lab=_82801_/Q }
C {devices/lab_pin.sym} 82700 -22830 0 1 {name=p82029 lab=_78522_/Y }
C {sky130_stdcells/inv_2.sym} 82660 -22830 0 0 {name=X_78522_ }
C {devices/lab_pin.sym} 82580 -22730 0 0 {name=p82030 lab=_56469_/C }
C {devices/lab_pin.sym} 82580 -22690 0 0 {name=p82031 lab=_44882_/X }
C {devices/lab_pin.sym} 82580 -22650 0 0 {name=p82032 lab=_44884_/X }
C {devices/lab_pin.sym} 82740 -22690 0 1 {name=p82033 lab=_44914_/X }
C {sky130_stdcells/o21a_4.sym} 82660 -22690 0 0 {name=X_44914_ }
C {devices/lab_pin.sym} 82600 -22560 0 0 {name=p82034 lab=_75734_/A }
C {devices/lab_pin.sym} 82600 -22520 0 0 {name=p82035 lab=_75733_/Y }
C {devices/lab_pin.sym} 82720 -22540 0 1 {name=p82036 lab=_75735_/A }
C {sky130_stdcells/xor2_4.sym} 82660 -22540 0 0 {name=X_75734_ }
C {devices/lab_pin.sym} 82620 -22410 0 0 {name=p82037 lab=_48682_/A }
C {devices/lab_pin.sym} 82700 -22410 0 1 {name=p82038 lab=_48683_/A }
C {sky130_stdcells/inv_2.sym} 82660 -22410 0 0 {name=X_48682_ }
C {devices/lab_pin.sym} 82580 -22330 0 0 {name=p82039 lab=_60950_/Y }
C {devices/lab_pin.sym} 82580 -22290 0 0 {name=p82040 lab=_60881_/Y }
C {devices/lab_pin.sym} 82580 -22250 0 0 {name=p82041 lab=_60952_/X }
C {devices/lab_pin.sym} 82580 -22210 0 0 {name=p82042 lab=_60958_/X }
C {devices/lab_pin.sym} 82580 -22170 0 0 {name=p82043 lab=_60959_/X }
C {devices/lab_pin.sym} 82740 -22250 0 1 {name=p82044 lab=_84548_/D }
C {sky130_stdcells/o41a_4.sym} 82660 -22250 0 0 {name=X_60960_ }
C {devices/lab_pin.sym} 82580 -22120 0 0 {name=p82045 lab=_41999_/Y }
C {devices/lab_pin.sym} 82580 -22080 0 0 {name=p82046 lab=_72921_/X }
C {devices/lab_pin.sym} 82580 -22040 0 0 {name=p82047 lab=_72944_/X }
C {devices/lab_pin.sym} 82580 -22000 0 0 {name=p82048 lab=_72945_/Y }
C {devices/lab_pin.sym} 82740 -22060 0 1 {name=p82049 lab=_72946_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -22060 0 0 {name=X_72946_ }
C {devices/lab_pin.sym} 82580 -21940 0 0 {name=p82050 lab=_45884_/Y }
C {devices/lab_pin.sym} 82580 -21900 0 0 {name=p82051 lab=_45886_/X }
C {devices/lab_pin.sym} 82580 -21860 0 0 {name=p82052 lab=_58517_/A }
C {devices/lab_pin.sym} 82580 -21820 0 0 {name=p82053 lab=_45893_/Y }
C {devices/lab_pin.sym} 82740 -21880 0 1 {name=p82054 lab=_45894_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -21880 0 0 {name=X_45894_ }
C {devices/lab_pin.sym} 82600 -21740 0 0 {name=p82055 lab=_47649_/A }
C {devices/lab_pin.sym} 82600 -21700 0 0 {name=p82056 lab=_53157_/B }
C {devices/lab_pin.sym} 82720 -21720 0 1 {name=p82057 lab=_47633_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -21720 0 0 {name=X_47633_ }
C {devices/lab_pin.sym} 82600 -21620 0 0 {name=p82058 lab=_60162_/A }
C {devices/lab_pin.sym} 82600 -21580 0 0 {name=p82059 lab=_60403_/C }
C {devices/lab_pin.sym} 82600 -21540 0 0 {name=p82060 lab=_59775_/A }
C {devices/lab_pin.sym} 82600 -21500 0 0 {name=p82061 lab=_61294_/D }
C {devices/lab_pin.sym} 82720 -21560 0 1 {name=p82062 lab=_59619_/X }
C {sky130_stdcells/and4_4.sym} 82660 -21560 0 0 {name=X_59619_ }
C {devices/lab_pin.sym} 82600 -21420 0 0 {name=p82063 lab=_78475_/B }
C {devices/lab_pin.sym} 82600 -21380 0 0 {name=p82064 lab=_78453_/B }
C {devices/lab_pin.sym} 82720 -21400 0 1 {name=p82065 lab=_82764_/D }
C {sky130_stdcells/xor2_4.sym} 82660 -21400 0 0 {name=X_78453_ }
C {devices/lab_pin.sym} 82580 -21310 0 0 {name=p82066 lab=_44832_/X }
C {devices/lab_pin.sym} 82580 -21270 0 0 {name=p82067 lab=_44844_/X }
C {devices/lab_pin.sym} 82580 -21230 0 0 {name=p82068 lab=_41734_/X }
C {devices/lab_pin.sym} 82580 -21190 0 0 {name=p82069 lab=_86923_/Q }
C {devices/lab_pin.sym} 82580 -21150 0 0 {name=p82070 lab=_44833_/X }
C {devices/lab_pin.sym} 82740 -21230 0 1 {name=p82071 lab=_44846_/A }
C {sky130_stdcells/o32ai_4.sym} 82660 -21230 0 0 {name=X_44845_ }
C {devices/lab_pin.sym} 82600 -21080 0 0 {name=p82072 lab=_75665_/A }
C {devices/lab_pin.sym} 82600 -21040 0 0 {name=p82073 lab=_75665_/B }
C {devices/lab_pin.sym} 82720 -21060 0 1 {name=p82074 lab=_75680_/A }
C {sky130_stdcells/nand2_4.sym} 82660 -21060 0 0 {name=X_75665_ }
C {devices/lab_pin.sym} 82620 -20930 0 0 {name=p82075 lab=_60890_/X }
C {devices/lab_pin.sym} 82700 -20930 0 1 {name=p82076 lab=_60891_/Y }
C {sky130_stdcells/inv_2.sym} 82660 -20930 0 0 {name=X_60891_ }
C {devices/lab_pin.sym} 82620 -20810 0 0 {name=p82077 lab=_72877_/A }
C {devices/lab_pin.sym} 82700 -20810 0 1 {name=p82078 lab=_72877_/X }
C {sky130_stdcells/buf_2.sym} 82660 -20810 0 0 {name=X_72877_ }
C {devices/lab_pin.sym} 82600 -20700 0 0 {name=p82079 lab=_77404_/A }
C {devices/lab_pin.sym} 82600 -20660 0 0 {name=p82080 lab=_82190_/D }
C {devices/lab_pin.sym} 82720 -20680 0 1 {name=p82081 lab=_81902_/D }
C {sky130_stdcells/xor2_4.sym} 82660 -20680 0 0 {name=X_77404_ }
C {devices/lab_pin.sym} 82580 -20580 0 0 {name=p82082 lab=_62629_/Y }
C {devices/lab_pin.sym} 82580 -20540 0 0 {name=p82083 lab=_59945_/Y }
C {devices/lab_pin.sym} 82580 -20500 0 0 {name=p82084 lab=_62186_/X }
C {devices/lab_pin.sym} 82580 -20460 0 0 {name=p82085 lab=_59931_/A }
C {devices/lab_pin.sym} 82740 -20520 0 1 {name=p82086 lab=_62630_/X }
C {sky130_stdcells/a2bb2o_4.sym} 82660 -20520 0 0 {name=X_62630_ }
C {devices/lab_pin.sym} 82580 -20390 0 0 {name=p82087 lab=_45305_/Y }
C {devices/lab_pin.sym} 82580 -20350 0 0 {name=p82088 lab=_74612_/X }
C {devices/lab_pin.sym} 82580 -20310 0 0 {name=p82089 lab=_74615_/X }
C {devices/lab_pin.sym} 82740 -20350 0 1 {name=p82090 lab=_83015_/D }
C {sky130_stdcells/o21ai_4.sym} 82660 -20350 0 0 {name=X_74616_ }
C {devices/lab_pin.sym} 82580 -20230 0 0 {name=p82091 lab=_86621_/Q }
C {devices/lab_pin.sym} 82580 -20190 0 0 {name=p82092 lab=_47524_/X }
C {devices/lab_pin.sym} 82580 -20150 0 0 {name=p82093 lab=_47563_/Y }
C {devices/lab_pin.sym} 82740 -20190 0 1 {name=p82094 lab=_47564_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -20190 0 0 {name=X_47564_ }
C {devices/lab_pin.sym} 82580 -20070 0 0 {name=p82095 lab=_71825_/X }
C {devices/lab_pin.sym} 82580 -20030 0 0 {name=p82096 lab=_83361_/Q }
C {devices/lab_pin.sym} 82580 -19990 0 0 {name=p82097 lab=_71827_/X }
C {devices/lab_pin.sym} 82740 -20030 0 1 {name=p82098 lab=_83361_/D }
C {sky130_stdcells/a21o_4.sym} 82660 -20030 0 0 {name=X_71828_ }
C {devices/lab_pin.sym} 82600 -19900 0 0 {name=p82099 lab=_78385_/A }
C {devices/lab_pin.sym} 82600 -19860 0 0 {name=p82100 lab=_82664_/D }
C {devices/lab_pin.sym} 82720 -19880 0 1 {name=p82101 lab=_78384_/Y }
C {sky130_stdcells/nor2_4.sym} 82660 -19880 0 0 {name=X_78384_ }
C {devices/lab_pin.sym} 82580 -19780 0 0 {name=p82102 lab=_41355_/Y }
C {devices/lab_pin.sym} 82580 -19740 0 0 {name=p82103 lab=_44774_/X }
C {devices/lab_pin.sym} 82580 -19700 0 0 {name=p82104 lab=_86962_/Q }
C {devices/lab_pin.sym} 82580 -19660 0 0 {name=p82105 lab=_44775_/X }
C {devices/lab_pin.sym} 82740 -19720 0 1 {name=p82106 lab=_86962_/D }
C {sky130_stdcells/a2bb2o_4.sym} 82660 -19720 0 0 {name=X_44776_ }
C {devices/lab_pin.sym} 82600 -19580 0 0 {name=p82107 lab=_75588_/Y }
C {devices/lab_pin.sym} 82600 -19540 0 0 {name=p82108 lab=_75596_/B }
C {devices/lab_pin.sym} 82720 -19560 0 1 {name=p82109 lab=_75597_/B }
C {sky130_stdcells/xor2_4.sym} 82660 -19560 0 0 {name=X_75596_ }
C {devices/lab_pin.sym} 82620 -19430 0 0 {name=p82110 lab=_88080_/Q }
C {devices/lab_pin.sym} 82700 -19430 0 1 {name=p82111 lab=_41988_/Y }
C {sky130_stdcells/inv_2.sym} 82660 -19430 0 0 {name=X_41988_ }
C {devices/lab_pin.sym} 82580 -19330 0 0 {name=p82112 lab=_65109_/B }
C {devices/lab_pin.sym} 82580 -19290 0 0 {name=p82113 lab=_49300_/X }
C {devices/lab_pin.sym} 82580 -19250 0 0 {name=p82114 lab=_49302_/Y }
C {devices/lab_pin.sym} 82740 -19290 0 1 {name=p82115 lab=_49303_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -19290 0 0 {name=X_49303_ }
C {devices/lab_pin.sym} 82580 -19170 0 0 {name=p82116 lab=_46403_/X }
C {devices/lab_pin.sym} 82580 -19130 0 0 {name=p82117 lab=_49119_/A }
C {devices/lab_pin.sym} 82580 -19090 0 0 {name=p82118 lab=_46514_/X }
C {devices/lab_pin.sym} 82740 -19130 0 1 {name=p82119 lab=_51356_/B }
C {sky130_stdcells/o21ai_4.sym} 82660 -19130 0 0 {name=X_46515_ }
C {devices/lab_pin.sym} 82580 -19010 0 0 {name=p82120 lab=_77320_/Y }
C {devices/lab_pin.sym} 82580 -18970 0 0 {name=p82121 lab=_77316_/A }
C {devices/lab_pin.sym} 82580 -18930 0 0 {name=p82122 lab=_77316_/B }
C {devices/lab_pin.sym} 82740 -18970 0 1 {name=p82123 lab=_77335_/Y }
C {sky130_stdcells/a21boi_4.sym} 82660 -18970 0 0 {name=X_77335_ }
C {devices/lab_pin.sym} 82580 -18860 0 0 {name=p82124 lab=_40881_/X }
C {devices/lab_pin.sym} 82580 -18820 0 0 {name=p82125 lab=_43695_/X }
C {devices/lab_pin.sym} 82580 -18780 0 0 {name=p82126 lab=_73299_/A }
C {devices/lab_pin.sym} 82580 -18740 0 0 {name=p82127 lab=_43696_/X }
C {devices/lab_pin.sym} 82740 -18800 0 1 {name=p82128 lab=_87294_/D }
C {sky130_stdcells/a2bb2o_4.sym} 82660 -18800 0 0 {name=X_43727_ }
C {devices/lab_pin.sym} 82600 -18670 0 0 {name=p82129 lab=_74541_/A }
C {devices/lab_pin.sym} 82600 -18630 0 0 {name=p82130 lab=_46215_/B }
C {devices/lab_pin.sym} 82600 -18590 0 0 {name=p82131 lab=_74547_/C }
C {devices/lab_pin.sym} 82720 -18630 0 1 {name=p82132 lab=_74547_/Y }
C {sky130_stdcells/nand3_4.sym} 82660 -18630 0 0 {name=X_74547_ }
C {devices/lab_pin.sym} 82600 -18510 0 0 {name=p82133 lab=_62559_/Y }
C {devices/lab_pin.sym} 82600 -18470 0 0 {name=p82134 lab=_62561_/B }
C {devices/lab_pin.sym} 82600 -18430 0 0 {name=p82135 lab=_62560_/Y }
C {devices/lab_pin.sym} 82720 -18470 0 1 {name=p82136 lab=_62561_/Y }
C {sky130_stdcells/nand3_4.sym} 82660 -18470 0 0 {name=X_62561_ }
C {devices/lab_pin.sym} 82620 -18330 0 0 {name=p82137 lab=_40938_/Y }
C {devices/lab_pin.sym} 82700 -18330 0 1 {name=p82138 lab=_40939_/X }
C {sky130_stdcells/buf_2.sym} 82660 -18330 0 0 {name=X_40939_ }
C {devices/lab_pin.sym} 82600 -18240 0 0 {name=p82139 lab=_47513_/A }
C {devices/lab_pin.sym} 82600 -18200 0 0 {name=p82140 lab=_47463_/X }
C {devices/lab_pin.sym} 82600 -18160 0 0 {name=p82141 lab=_47513_/C }
C {devices/lab_pin.sym} 82600 -18120 0 0 {name=p82142 lab=_53078_/D }
C {devices/lab_pin.sym} 82720 -18180 0 1 {name=p82143 lab=_47495_/X }
C {sky130_stdcells/and4_4.sym} 82660 -18180 0 0 {name=X_47495_ }
C {devices/lab_pin.sym} 82580 -18050 0 0 {name=p82144 lab=_52965_/B }
C {devices/lab_pin.sym} 82580 -18010 0 0 {name=p82145 lab=_71736_/X }
C {devices/lab_pin.sym} 82580 -17970 0 0 {name=p82146 lab=_71758_/Y }
C {devices/lab_pin.sym} 82740 -18010 0 1 {name=p82147 lab=_83386_/D }
C {sky130_stdcells/o21ai_4.sym} 82660 -18010 0 0 {name=X_71759_ }
C {devices/lab_pin.sym} 82580 -17890 0 0 {name=p82148 lab=_79806_/B }
C {devices/lab_pin.sym} 82580 -17850 0 0 {name=p82149 lab=_64255_/X }
C {devices/lab_pin.sym} 82580 -17810 0 0 {name=p82150 lab=_64299_/X }
C {devices/lab_pin.sym} 82740 -17850 0 1 {name=p82151 lab=_84258_/D }
C {sky130_stdcells/a21o_4.sym} 82660 -17850 0 0 {name=X_64300_ }
C {devices/lab_pin.sym} 82620 -17710 0 0 {name=p82152 lab=_48623_/A }
C {devices/lab_pin.sym} 82700 -17710 0 1 {name=p82153 lab=_49234_/X }
C {sky130_stdcells/buf_2.sym} 82660 -17710 0 0 {name=X_49234_ }
C {devices/lab_pin.sym} 82620 -17590 0 0 {name=p82154 lab=_61342_/X }
C {devices/lab_pin.sym} 82700 -17590 0 1 {name=p82155 lab=_61512_/X }
C {sky130_stdcells/buf_2.sym} 82660 -17590 0 0 {name=X_61512_ }
C {devices/lab_pin.sym} 82620 -17470 0 0 {name=p82156 lab=_46446_/A }
C {devices/lab_pin.sym} 82700 -17470 0 1 {name=p82157 lab=_46447_/B }
C {sky130_stdcells/inv_2.sym} 82660 -17470 0 0 {name=X_46446_ }
C {devices/lab_pin.sym} 82580 -17380 0 0 {name=p82158 lab=_65252_/X }
C {devices/lab_pin.sym} 82580 -17340 0 0 {name=p82159 lab=_86727_/Q }
C {devices/lab_pin.sym} 82580 -17300 0 0 {name=p82160 lab=_65230_/X }
C {devices/lab_pin.sym} 82580 -17260 0 0 {name=p82161 lab=_65279_/X }
C {devices/lab_pin.sym} 82740 -17320 0 1 {name=p82162 lab=_65280_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -17320 0 0 {name=X_65280_ }
C {devices/lab_pin.sym} 82580 -17190 0 0 {name=p82163 lab=_77264_/Y }
C {devices/lab_pin.sym} 82580 -17150 0 0 {name=p82164 lab=_77265_/Y }
C {devices/lab_pin.sym} 82580 -17110 0 0 {name=p82165 lab=_82213_/Q }
C {devices/lab_pin.sym} 82740 -17150 0 1 {name=p82166 lab=_77266_/X }
C {sky130_stdcells/a21o_4.sym} 82660 -17150 0 0 {name=X_77266_ }
C {devices/lab_pin.sym} 82580 -17040 0 0 {name=p82167 lab=_40716_/X }
C {devices/lab_pin.sym} 82580 -17000 0 0 {name=p82168 lab=_43656_/X }
C {devices/lab_pin.sym} 82580 -16960 0 0 {name=p82169 lab=_74097_/A }
C {devices/lab_pin.sym} 82580 -16920 0 0 {name=p82170 lab=_43657_/X }
C {devices/lab_pin.sym} 82740 -16980 0 1 {name=p82171 lab=_87324_/D }
C {sky130_stdcells/a2bb2o_4.sym} 82660 -16980 0 0 {name=X_43658_ }
C {devices/lab_pin.sym} 82600 -16860 0 0 {name=p82172 lab=_61560_/B }
C {devices/lab_pin.sym} 82600 -16820 0 0 {name=p82173 lab=_62492_/B }
C {devices/lab_pin.sym} 82600 -16780 0 0 {name=p82174 lab=_62449_/X }
C {devices/lab_pin.sym} 82600 -16740 0 0 {name=p82175 lab=_62475_/X }
C {devices/lab_pin.sym} 82720 -16800 0 1 {name=p82176 lab=_62492_/Y }
C {sky130_stdcells/nand4_4.sym} 82660 -16800 0 0 {name=X_62492_ }
C {devices/lab_pin.sym} 82600 -16670 0 0 {name=p82177 lab=_48621_/A }
C {devices/lab_pin.sym} 82600 -16630 0 0 {name=p82178 lab=_74478_/B }
C {devices/lab_pin.sym} 82600 -16590 0 0 {name=p82179 lab=_74478_/C }
C {devices/lab_pin.sym} 82720 -16630 0 1 {name=p82180 lab=_74478_/X }
C {sky130_stdcells/and3_4.sym} 82660 -16630 0 0 {name=X_74478_ }
C {devices/lab_pin.sym} 82620 -16490 0 0 {name=p82181 lab=_79022_/A }
C {devices/lab_pin.sym} 82700 -16490 0 1 {name=p82182 lab=_79010_/A }
C {sky130_stdcells/inv_2.sym} 82660 -16490 0 0 {name=X_79005_ }
C {devices/lab_pin.sym} 82580 -16390 0 0 {name=p82183 lab=_64219_/Y }
C {devices/lab_pin.sym} 82580 -16350 0 0 {name=p82184 lab=_64230_/X }
C {devices/lab_pin.sym} 82580 -16310 0 0 {name=p82185 lab=_72577_/B }
C {devices/lab_pin.sym} 82740 -16350 0 1 {name=p82186 lab=_64231_/X }
C {sky130_stdcells/o21a_4.sym} 82660 -16350 0 0 {name=X_64231_ }
C {devices/lab_pin.sym} 82580 -16230 0 0 {name=p82187 lab=_76215_/Y }
C {devices/lab_pin.sym} 82580 -16190 0 0 {name=p82188 lab=_76216_/Y }
C {devices/lab_pin.sym} 82580 -16150 0 0 {name=p82189 lab=_76234_/A }
C {devices/lab_pin.sym} 82740 -16190 0 1 {name=p82190 lab=_76217_/X }
C {sky130_stdcells/a21o_4.sym} 82660 -16190 0 0 {name=X_76217_ }
C {devices/lab_pin.sym} 82580 -16090 0 0 {name=p82191 lab=_42568_/X }
C {devices/lab_pin.sym} 82580 -16050 0 0 {name=p82192 lab=_42569_/X }
C {devices/lab_pin.sym} 82580 -16010 0 0 {name=p82193 lab=_40899_/X }
C {devices/lab_pin.sym} 82580 -15970 0 0 {name=p82194 lab=_69897_/B }
C {devices/lab_pin.sym} 82580 -15930 0 0 {name=p82195 lab=_42571_/X }
C {devices/lab_pin.sym} 82740 -16010 0 1 {name=p82196 lab=_87802_/D }
C {sky130_stdcells/o32ai_4.sym} 82660 -16010 0 0 {name=X_42609_ }
C {devices/lab_pin.sym} 82580 -15870 0 0 {name=p82197 lab=_49160_/Y }
C {devices/lab_pin.sym} 82580 -15830 0 0 {name=p82198 lab=_49138_/X }
C {devices/lab_pin.sym} 82580 -15790 0 0 {name=p82199 lab=_49164_/X }
C {devices/lab_pin.sym} 82740 -15830 0 1 {name=p82200 lab=_86438_/D }
C {sky130_stdcells/a21oi_4.sym} 82660 -15830 0 0 {name=X_49165_ }
C {devices/lab_pin.sym} 82620 -15690 0 0 {name=p82201 lab=_61442_/Y }
C {devices/lab_pin.sym} 82700 -15690 0 1 {name=p82202 lab=_61443_/Y }
C {sky130_stdcells/inv_2.sym} 82660 -15690 0 0 {name=X_61443_ }
C {devices/lab_pin.sym} 82600 -15580 0 0 {name=p82203 lab=_73476_/A }
C {devices/lab_pin.sym} 82600 -15540 0 0 {name=p82204 lab=_86503_/Q }
C {devices/lab_pin.sym} 82720 -15560 0 1 {name=p82205 lab=_73429_/X }
C {sky130_stdcells/and2_4.sym} 82660 -15560 0 0 {name=X_73429_ }
C {devices/lab_pin.sym} 82620 -15430 0 0 {name=p82206 lab=_46376_/Y }
C {devices/lab_pin.sym} 82700 -15430 0 1 {name=p82207 lab=_50781_/B }
C {sky130_stdcells/buf_2.sym} 82660 -15430 0 0 {name=X_46377_ }
C {devices/lab_pin.sym} 82580 -15330 0 0 {name=p82208 lab=_77189_/Y }
C {devices/lab_pin.sym} 82580 -15290 0 0 {name=p82209 lab=_77202_/A }
C {devices/lab_pin.sym} 82580 -15250 0 0 {name=p82210 lab=_77196_/Y }
C {devices/lab_pin.sym} 82740 -15290 0 1 {name=p82211 lab=_77198_/B }
C {sky130_stdcells/a21boi_4.sym} 82660 -15290 0 0 {name=X_77197_ }
C {devices/lab_pin.sym} 82620 -15150 0 0 {name=p82212 lab=_43588_/X }
C {devices/lab_pin.sym} 82700 -15150 0 1 {name=p82213 lab=_47832_/A }
C {sky130_stdcells/buf_2.sym} 82660 -15150 0 0 {name=X_43589_ }
C {devices/lab_pin.sym} 82600 -15040 0 0 {name=p82214 lab=_48142_/A }
C {devices/lab_pin.sym} 82600 -15000 0 0 {name=p82215 lab=_50370_/B }
C {devices/lab_pin.sym} 82720 -15020 0 1 {name=p82216 lab=_48116_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -15020 0 0 {name=X_48116_ }
C {devices/lab_pin.sym} 82580 -14910 0 0 {name=p82217 lab=_56450_/C }
C {devices/lab_pin.sym} 82580 -14870 0 0 {name=p82218 lab=_45326_/X }
C {devices/lab_pin.sym} 82580 -14830 0 0 {name=p82219 lab=_45327_/X }
C {devices/lab_pin.sym} 82740 -14870 0 1 {name=p82220 lab=_45328_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -14870 0 0 {name=X_45328_ }
C {devices/lab_pin.sym} 82600 -14740 0 0 {name=p82221 lab=_76145_/Y }
C {devices/lab_pin.sym} 82600 -14700 0 0 {name=p82222 lab=_76147_/Y }
C {devices/lab_pin.sym} 82720 -14720 0 1 {name=p82223 lab=_76150_/A }
C {sky130_stdcells/nand2_4.sym} 82660 -14720 0 0 {name=X_76148_ }
C {devices/lab_pin.sym} 82600 -14610 0 0 {name=p82224 lab=_64162_/A }
C {devices/lab_pin.sym} 82600 -14570 0 0 {name=p82225 lab=_58360_/A }
C {devices/lab_pin.sym} 82600 -14530 0 0 {name=p82226 lab=_64173_/C }
C {devices/lab_pin.sym} 82720 -14570 0 1 {name=p82227 lab=_64162_/X }
C {sky130_stdcells/and3_4.sym} 82660 -14570 0 0 {name=X_64162_ }
C {devices/lab_pin.sym} 82580 -14450 0 0 {name=p82228 lab=_65164_/B }
C {devices/lab_pin.sym} 82580 -14410 0 0 {name=p82229 lab=_49052_/X }
C {devices/lab_pin.sym} 82580 -14370 0 0 {name=p82230 lab=_49095_/Y }
C {devices/lab_pin.sym} 82740 -14410 0 1 {name=p82231 lab=_49096_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -14410 0 0 {name=X_49096_ }
C {devices/lab_pin.sym} 82620 -14270 0 0 {name=p82232 lab=_61374_/A }
C {devices/lab_pin.sym} 82700 -14270 0 1 {name=p82233 lab=_61375_/A }
C {sky130_stdcells/buf_2.sym} 82660 -14270 0 0 {name=X_61374_ }
C {devices/lab_pin.sym} 82600 -14180 0 0 {name=p82234 lab=_59390_/Y }
C {devices/lab_pin.sym} 82600 -14140 0 0 {name=p82235 lab=_63113_/B }
C {devices/lab_pin.sym} 82600 -14100 0 0 {name=p82236 lab=_63103_/C }
C {devices/lab_pin.sym} 82600 -14060 0 0 {name=p82237 lab=_63092_/D }
C {devices/lab_pin.sym} 82720 -14120 0 1 {name=p82238 lab=_63113_/X }
C {sky130_stdcells/or4_4.sym} 82660 -14120 0 0 {name=X_63113_ }
C {devices/lab_pin.sym} 82600 -13990 0 0 {name=p82239 lab=_52039_/A }
C {devices/lab_pin.sym} 82600 -13950 0 0 {name=p82240 lab=_48069_/B }
C {devices/lab_pin.sym} 82600 -13910 0 0 {name=p82241 lab=_47919_/X }
C {devices/lab_pin.sym} 82720 -13950 0 1 {name=p82242 lab=_48047_/X }
C {sky130_stdcells/and3_4.sym} 82660 -13950 0 0 {name=X_48047_ }
C {devices/lab_pin.sym} 82600 -13840 0 0 {name=p82243 lab=_60267_/X }
C {devices/lab_pin.sym} 82600 -13800 0 0 {name=p82244 lab=_60325_/B }
C {devices/lab_pin.sym} 82600 -13760 0 0 {name=p82245 lab=_60325_/C }
C {devices/lab_pin.sym} 82600 -13720 0 0 {name=p82246 lab=_60367_/D }
C {devices/lab_pin.sym} 82720 -13780 0 1 {name=p82247 lab=_60325_/Y }
C {sky130_stdcells/nand4_4.sym} 82660 -13780 0 0 {name=X_60325_ }
C {devices/lab_pin.sym} 82580 -13650 0 0 {name=p82248 lab=_45256_/X }
C {devices/lab_pin.sym} 82580 -13610 0 0 {name=p82249 lab=_45258_/Y }
C {devices/lab_pin.sym} 82580 -13570 0 0 {name=p82250 lab=_45200_/X }
C {devices/lab_pin.sym} 82740 -13610 0 1 {name=p82251 lab=_45259_/Y }
C {sky130_stdcells/a21oi_4.sym} 82660 -13610 0 0 {name=X_45259_ }
C {devices/lab_pin.sym} 82600 -13480 0 0 {name=p82252 lab=_68994_/A }
C {devices/lab_pin.sym} 82600 -13440 0 0 {name=p82253 lab=_68970_/B }
C {devices/lab_pin.sym} 82720 -13460 0 1 {name=p82254 lab=_68970_/X }
C {sky130_stdcells/and2_4.sym} 82660 -13460 0 0 {name=X_68970_ }
C {devices/lab_pin.sym} 82600 -13360 0 0 {name=p82255 lab=_83243_/Q }
C {devices/lab_pin.sym} 82600 -13320 0 0 {name=p82256 lab=_64158_/B }
C {devices/lab_pin.sym} 82600 -13280 0 0 {name=p82257 lab=_64158_/C }
C {devices/lab_pin.sym} 82600 -13240 0 0 {name=p82258 lab=_64045_/X }
C {devices/lab_pin.sym} 82720 -13300 0 1 {name=p82259 lab=_64094_/D }
C {sky130_stdcells/nand4_4.sym} 82660 -13300 0 0 {name=X_64093_ }
C {devices/lab_pin.sym} 82600 -13160 0 0 {name=p82260 lab=_81719_/D }
C {devices/lab_pin.sym} 82600 -13120 0 0 {name=p82261 lab=_76070_/B }
C {devices/lab_pin.sym} 82720 -13140 0 1 {name=p82262 lab=_76079_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -13140 0 0 {name=X_76079_ }
C {devices/lab_pin.sym} 82580 -13030 0 0 {name=p82263 lab=_67918_/X }
C {devices/lab_pin.sym} 82580 -12990 0 0 {name=p82264 lab=_67920_/X }
C {devices/lab_pin.sym} 82580 -12950 0 0 {name=p82265 lab=_67875_/X }
C {devices/lab_pin.sym} 82740 -12990 0 1 {name=p82266 lab=_67921_/Y }
C {sky130_stdcells/a21oi_4.sym} 82660 -12990 0 0 {name=X_67921_ }
C {devices/lab_pin.sym} 82600 -12880 0 0 {name=p82267 lab=_63044_/A }
C {devices/lab_pin.sym} 82600 -12840 0 0 {name=p82268 lab=_63004_/B }
C {devices/lab_pin.sym} 82600 -12800 0 0 {name=p82269 lab=_63081_/C }
C {devices/lab_pin.sym} 82600 -12760 0 0 {name=p82270 lab=_63033_/D }
C {devices/lab_pin.sym} 82720 -12820 0 1 {name=p82271 lab=_63044_/X }
C {sky130_stdcells/or4_4.sym} 82660 -12820 0 0 {name=X_63044_ }
C {devices/lab_pin.sym} 82600 -12680 0 0 {name=p82272 lab=_79906_/Y }
C {devices/lab_pin.sym} 82600 -12640 0 0 {name=p82273 lab=_79907_/B }
C {devices/lab_pin.sym} 82720 -12660 0 1 {name=p82274 lab=_79913_/A }
C {sky130_stdcells/nand2_4.sym} 82660 -12660 0 0 {name=X_79907_ }
C {devices/lab_pin.sym} 82580 -12550 0 0 {name=p82275 lab=_60268_/C }
C {devices/lab_pin.sym} 82580 -12510 0 0 {name=p82276 lab=_60300_/B }
C {devices/lab_pin.sym} 82580 -12470 0 0 {name=p82277 lab=_60325_/C }
C {devices/lab_pin.sym} 82740 -12510 0 1 {name=p82278 lab=_60256_/X }
C {sky130_stdcells/o21a_4.sym} 82660 -12510 0 0 {name=X_60256_ }
C {devices/lab_pin.sym} 82580 -12390 0 0 {name=p82279 lab=_84052_/Q }
C {devices/lab_pin.sym} 82580 -12350 0 0 {name=p82280 lab=_67806_/X }
C {devices/lab_pin.sym} 82580 -12310 0 0 {name=p82281 lab=_67851_/X }
C {devices/lab_pin.sym} 82740 -12350 0 1 {name=p82282 lab=_84052_/D }
C {sky130_stdcells/a21bo_4.sym} 82660 -12350 0 0 {name=X_67852_ }
C {devices/lab_pin.sym} 82600 -12220 0 0 {name=p82283 lab=_79836_/X }
C {devices/lab_pin.sym} 82600 -12180 0 0 {name=p82284 lab=_79838_/B }
C {devices/lab_pin.sym} 82720 -12200 0 1 {name=p82285 lab=_79854_/B }
C {sky130_stdcells/xnor2_4.sym} 82660 -12200 0 0 {name=X_79838_ }
C {devices/lab_pin.sym} 82620 -12070 0 0 {name=p82286 lab=_60187_/A }
C {devices/lab_pin.sym} 82700 -12070 0 1 {name=p82287 lab=_60204_/A }
C {sky130_stdcells/buf_2.sym} 82660 -12070 0 0 {name=X_60187_ }
C {devices/lab_pin.sym} 82580 -11970 0 0 {name=p82288 lab=_72377_/B }
C {devices/lab_pin.sym} 82580 -11930 0 0 {name=p82289 lab=_49986_/X }
C {devices/lab_pin.sym} 82580 -11890 0 0 {name=p82290 lab=_49997_/Y }
C {devices/lab_pin.sym} 82740 -11930 0 1 {name=p82291 lab=_49998_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -11930 0 0 {name=X_49998_ }
C {devices/lab_pin.sym} 82620 -11790 0 0 {name=p82292 lab=clkbuf_9_281_0_CLK/X }
C {devices/lab_pin.sym} 82700 -11790 0 1 {name=p82293 lab=_88116_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 82660 -11790 0 0 {name=Xclkbuf_10_562_0_CLK }
C {devices/lab_pin.sym} 82620 -11670 0 0 {name=p82294 lab=clkbuf_6_53_0_CLK/A }
C {devices/lab_pin.sym} 82700 -11670 0 1 {name=p82295 lab=clkbuf_6_53_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 82660 -11670 0 0 {name=Xclkbuf_6_53_0_CLK }
C {devices/lab_pin.sym} 82580 -11580 0 0 {name=p82296 lab=_88394_/Q }
C {devices/lab_pin.sym} 82580 -11540 0 0 {name=p82297 lab=_66751_/X }
C {devices/lab_pin.sym} 82580 -11500 0 0 {name=p82298 lab=_66801_/X }
C {devices/lab_pin.sym} 82580 -11460 0 0 {name=p82299 lab=_66802_/X }
C {devices/lab_pin.sym} 82740 -11520 0 1 {name=p82300 lab=_66803_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -11520 0 0 {name=X_66803_ }
C {devices/lab_pin.sym} 82620 -11370 0 0 {name=p82301 lab=_52295_/B }
C {devices/lab_pin.sym} 82700 -11370 0 1 {name=p82302 lab=_71989_/B }
C {sky130_stdcells/buf_2.sym} 82660 -11370 0 0 {name=X_48949_ }
C {devices/lab_pin.sym} 82600 -11260 0 0 {name=p82303 lab=_67690_/X }
C {devices/lab_pin.sym} 82600 -11220 0 0 {name=p82304 lab=_87648_/Q }
C {devices/lab_pin.sym} 82720 -11240 0 1 {name=p82305 lab=_67783_/X }
C {sky130_stdcells/and2_4.sym} 82660 -11240 0 0 {name=X_67783_ }
C {devices/lab_pin.sym} 82580 -11130 0 0 {name=p82306 lab=_79757_/A }
C {devices/lab_pin.sym} 82580 -11090 0 0 {name=p82307 lab=_79756_/Y }
C {devices/lab_pin.sym} 82580 -11050 0 0 {name=p82308 lab=_79768_/X }
C {devices/lab_pin.sym} 82740 -11090 0 1 {name=p82309 lab=_79769_/X }
C {sky130_stdcells/a21o_4.sym} 82660 -11090 0 0 {name=X_79769_ }
C {devices/lab_pin.sym} 82600 -10960 0 0 {name=p82310 lab=_64995_/A }
C {devices/lab_pin.sym} 82600 -10920 0 0 {name=p82311 lab=_64994_/Y }
C {devices/lab_pin.sym} 82720 -10940 0 1 {name=p82312 lab=_64995_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -10940 0 0 {name=X_64995_ }
C {devices/lab_pin.sym} 82570 -10810 0 0 {name=p82313 lab=_81684_/CLK }
C {devices/lab_pin.sym} 82570 -10790 0 0 {name=p82314 lab=_81800_/D }
C {devices/lab_pin.sym} 82750 -10810 0 1 {name=p82315 lab=_47464_/A }
C {sky130_stdcells/dfxtp_4.sym} 82660 -10800 0 0 {name=X_81800_ }
C {devices/lab_pin.sym} 82580 -10700 0 0 {name=p82316 lab=_88023_/Q }
C {devices/lab_pin.sym} 82580 -10660 0 0 {name=p82317 lab=_69368_/X }
C {devices/lab_pin.sym} 82580 -10620 0 0 {name=p82318 lab=_69478_/X }
C {devices/lab_pin.sym} 82580 -10580 0 0 {name=p82319 lab=_69521_/X }
C {devices/lab_pin.sym} 82740 -10640 0 1 {name=p82320 lab=_69522_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -10640 0 0 {name=X_69522_ }
C {devices/lab_pin.sym} 82620 -10490 0 0 {name=p82321 lab=_66971_/A }
C {devices/lab_pin.sym} 82700 -10490 0 1 {name=p82322 lab=_66734_/X }
C {sky130_stdcells/buf_2.sym} 82660 -10490 0 0 {name=X_66734_ }
C {devices/lab_pin.sym} 82620 -10370 0 0 {name=p82323 lab=_51928_/X }
C {devices/lab_pin.sym} 82700 -10370 0 1 {name=p82324 lab=_51960_/X }
C {sky130_stdcells/buf_2.sym} 82660 -10370 0 0 {name=X_51960_ }
C {devices/lab_pin.sym} 82620 -10250 0 0 {name=p82325 lab=_63751_/X }
C {devices/lab_pin.sym} 82700 -10250 0 1 {name=p82326 lab=_64025_/D }
C {sky130_stdcells/buf_2.sym} 82660 -10250 0 0 {name=X_63946_ }
C {devices/lab_pin.sym} 82570 -10130 0 0 {name=p82327 lab=_83783_/CLK }
C {devices/lab_pin.sym} 82570 -10110 0 0 {name=p82328 lab=_82780_/D }
C {devices/lab_pin.sym} 82750 -10130 0 1 {name=p82329 lab=_82780_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -10120 0 0 {name=X_82780_ }
C {devices/lab_pin.sym} 82620 -9990 0 0 {name=p82330 lab=_50728_/A }
C {devices/lab_pin.sym} 82700 -9990 0 1 {name=p82331 lab=_50932_/A }
C {sky130_stdcells/buf_2.sym} 82660 -9990 0 0 {name=X_50911_ }
C {devices/lab_pin.sym} 82570 -9870 0 0 {name=p82332 lab=_84020_/CLK }
C {devices/lab_pin.sym} 82570 -9850 0 0 {name=p82333 lab=_75929_/B }
C {devices/lab_pin.sym} 82750 -9870 0 1 {name=p82334 lab=_41784_/B }
C {sky130_stdcells/dfxtp_4.sym} 82660 -9860 0 0 {name=X_81731_ }
C {devices/lab_pin.sym} 82580 -9760 0 0 {name=p82335 lab=_88028_/Q }
C {devices/lab_pin.sym} 82580 -9720 0 0 {name=p82336 lab=_69315_/X }
C {devices/lab_pin.sym} 82580 -9680 0 0 {name=p82337 lab=_69393_/X }
C {devices/lab_pin.sym} 82580 -9640 0 0 {name=p82338 lab=_69452_/X }
C {devices/lab_pin.sym} 82740 -9700 0 1 {name=p82339 lab=_69453_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -9700 0 0 {name=X_69453_ }
C {devices/lab_pin.sym} 82600 -9560 0 0 {name=p82340 lab=_66664_/X }
C {devices/lab_pin.sym} 82600 -9520 0 0 {name=p82341 lab=_86802_/Q }
C {devices/lab_pin.sym} 82720 -9540 0 1 {name=p82342 lab=_66665_/X }
C {sky130_stdcells/and2_4.sym} 82660 -9540 0 0 {name=X_66665_ }
C {devices/lab_pin.sym} 82620 -9410 0 0 {name=p82343 lab=_52679_/A }
C {devices/lab_pin.sym} 82700 -9410 0 1 {name=p82344 lab=_52626_/A }
C {sky130_stdcells/buf_2.sym} 82660 -9410 0 0 {name=X_51891_ }
C {devices/lab_pin.sym} 82600 -9320 0 0 {name=p82345 lab=_61428_/X }
C {devices/lab_pin.sym} 82600 -9280 0 0 {name=p82346 lab=_63877_/B }
C {devices/lab_pin.sym} 82600 -9240 0 0 {name=p82347 lab=_63814_/C }
C {devices/lab_pin.sym} 82600 -9200 0 0 {name=p82348 lab=_63877_/D }
C {devices/lab_pin.sym} 82720 -9260 0 1 {name=p82349 lab=_63877_/Y }
C {sky130_stdcells/nand4_4.sym} 82660 -9260 0 0 {name=X_63877_ }
C {devices/lab_pin.sym} 82620 -9110 0 0 {name=p82350 lab=clkbuf_9_288_0_CLK/X }
C {devices/lab_pin.sym} 82700 -9110 0 1 {name=p82351 lab=_80813_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 82660 -9110 0 0 {name=Xclkbuf_10_577_0_CLK }
C {devices/lab_pin.sym} 82580 -9020 0 0 {name=p82352 lab=_88018_/Q }
C {devices/lab_pin.sym} 82580 -8980 0 0 {name=p82353 lab=_68402_/X }
C {devices/lab_pin.sym} 82580 -8940 0 0 {name=p82354 lab=_68359_/X }
C {devices/lab_pin.sym} 82580 -8900 0 0 {name=p82355 lab=_68403_/X }
C {devices/lab_pin.sym} 82740 -8960 0 1 {name=p82356 lab=_68404_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -8960 0 0 {name=X_68404_ }
C {devices/lab_pin.sym} 82620 -8810 0 0 {name=p82357 lab=_50724_/A }
C {devices/lab_pin.sym} 82700 -8810 0 1 {name=p82358 lab=_53658_/B }
C {sky130_stdcells/buf_2.sym} 82660 -8810 0 0 {name=X_53630_ }
C {devices/lab_pin.sym} 82600 -8700 0 0 {name=p82359 lab=_65753_/A }
C {devices/lab_pin.sym} 82600 -8660 0 0 {name=p82360 lab=_73096_/B }
C {devices/lab_pin.sym} 82720 -8680 0 1 {name=p82361 lab=_65616_/X }
C {sky130_stdcells/and2_4.sym} 82660 -8680 0 0 {name=X_65616_ }
C {devices/lab_pin.sym} 82570 -8550 0 0 {name=p82362 lab=_84449_/CLK }
C {devices/lab_pin.sym} 82570 -8530 0 0 {name=p82363 lab=_61850_/Y }
C {devices/lab_pin.sym} 82750 -8550 0 1 {name=p82364 lab=_78073_/B }
C {sky130_stdcells/dfxtp_4.sym} 82660 -8540 0 0 {name=X_84450_ }
C {devices/lab_pin.sym} 82600 -8420 0 0 {name=p82365 lab=_50806_/A }
C {devices/lab_pin.sym} 82600 -8380 0 0 {name=p82366 lab=_49320_/B }
C {devices/lab_pin.sym} 82720 -8400 0 1 {name=p82367 lab=_50842_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -8400 0 0 {name=X_50842_ }
C {devices/lab_pin.sym} 82620 -8270 0 0 {name=p82368 lab=_62979_/A }
C {devices/lab_pin.sym} 82700 -8270 0 1 {name=p82369 lab=_62971_/A }
C {sky130_stdcells/buf_2.sym} 82660 -8270 0 0 {name=X_62828_ }
C {devices/lab_pin.sym} 82570 -8150 0 0 {name=p82370 lab=_81680_/CLK }
C {devices/lab_pin.sym} 82570 -8130 0 0 {name=p82371 lab=_76755_/A }
C {devices/lab_pin.sym} 82750 -8150 0 1 {name=p82372 lab=_76572_/A }
C {sky130_stdcells/dfxtp_4.sym} 82660 -8140 0 0 {name=X_81662_ }
C {devices/lab_pin.sym} 82580 -8040 0 0 {name=p82373 lab=_87521_/Q }
C {devices/lab_pin.sym} 82580 -8000 0 0 {name=p82374 lab=_69356_/X }
C {devices/lab_pin.sym} 82580 -7960 0 0 {name=p82375 lab=_69371_/X }
C {devices/lab_pin.sym} 82580 -7920 0 0 {name=p82376 lab=_69383_/X }
C {devices/lab_pin.sym} 82740 -7980 0 1 {name=p82377 lab=_69384_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -7980 0 0 {name=X_69384_ }
C {devices/lab_pin.sym} 82580 -7860 0 0 {name=p82378 lab=_87134_/Q }
C {devices/lab_pin.sym} 82580 -7820 0 0 {name=p82379 lab=_66593_/X }
C {devices/lab_pin.sym} 82580 -7780 0 0 {name=p82380 lab=_66594_/X }
C {devices/lab_pin.sym} 82580 -7740 0 0 {name=p82381 lab=_66595_/X }
C {devices/lab_pin.sym} 82740 -7800 0 1 {name=p82382 lab=_66596_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -7800 0 0 {name=X_66596_ }
C {devices/lab_pin.sym} 82570 -7650 0 0 {name=p82383 lab=_84939_/CLK }
C {devices/lab_pin.sym} 82570 -7630 0 0 {name=p82384 lab=_83401_/D }
C {devices/lab_pin.sym} 82750 -7650 0 1 {name=p82385 lab=_83401_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -7640 0 0 {name=X_83401_ }
C {devices/lab_pin.sym} 82600 -7520 0 0 {name=p82386 lab=_84776_/Q }
C {devices/lab_pin.sym} 82600 -7480 0 0 {name=p82387 lab=_84168_/Q }
C {devices/lab_pin.sym} 82720 -7500 0 1 {name=p82388 lab=_80613_/X }
C {sky130_stdcells/xor2_4.sym} 82660 -7500 0 0 {name=X_80613_ }
C {devices/lab_pin.sym} 82580 -7390 0 0 {name=p82389 lab=_68056_/X }
C {devices/lab_pin.sym} 82580 -7350 0 0 {name=p82390 lab=_68061_/X }
C {devices/lab_pin.sym} 82580 -7310 0 0 {name=p82391 lab=_68327_/X }
C {devices/lab_pin.sym} 82740 -7350 0 1 {name=p82392 lab=_68335_/Y }
C {sky130_stdcells/a21oi_4.sym} 82660 -7350 0 0 {name=X_68335_ }
C {devices/lab_pin.sym} 82600 -7230 0 0 {name=p82393 lab=_52039_/A }
C {devices/lab_pin.sym} 82600 -7190 0 0 {name=p82394 lab=_53620_/B }
C {devices/lab_pin.sym} 82600 -7150 0 0 {name=p82395 lab=_53492_/X }
C {devices/lab_pin.sym} 82720 -7190 0 1 {name=p82396 lab=_53561_/X }
C {sky130_stdcells/and3_4.sym} 82660 -7190 0 0 {name=X_53561_ }
C {devices/lab_pin.sym} 82580 -7070 0 0 {name=p82397 lab=_65545_/Y }
C {devices/lab_pin.sym} 82580 -7030 0 0 {name=p82398 lab=_65529_/X }
C {devices/lab_pin.sym} 82580 -6990 0 0 {name=p82399 lab=_65546_/X }
C {devices/lab_pin.sym} 82740 -7030 0 1 {name=p82400 lab=_65547_/X }
C {sky130_stdcells/a21o_4.sym} 82660 -7030 0 0 {name=X_65547_ }
C {devices/lab_pin.sym} 82570 -6890 0 0 {name=p82401 lab=_84520_/CLK }
C {devices/lab_pin.sym} 82570 -6870 0 0 {name=p82402 lab=_84381_/D }
C {devices/lab_pin.sym} 82750 -6890 0 1 {name=p82403 lab=_62806_/C }
C {sky130_stdcells/dfxtp_4.sym} 82660 -6880 0 0 {name=X_84381_ }
C {devices/lab_pin.sym} 82600 -6760 0 0 {name=p82404 lab=_50764_/A }
C {devices/lab_pin.sym} 82600 -6720 0 0 {name=p82405 lab=_52468_/B }
C {devices/lab_pin.sym} 82720 -6740 0 1 {name=p82406 lab=_50773_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -6740 0 0 {name=X_50773_ }
C {devices/lab_pin.sym} 82620 -6610 0 0 {name=p82407 lab=_60211_/A }
C {devices/lab_pin.sym} 82700 -6610 0 1 {name=p82408 lab=_62759_/X }
C {sky130_stdcells/buf_2.sym} 82660 -6610 0 0 {name=X_62759_ }
C {devices/lab_pin.sym} 82570 -6490 0 0 {name=p82409 lab=_81428_/CLK }
C {devices/lab_pin.sym} 82570 -6470 0 0 {name=p82410 lab=_65559_/C }
C {devices/lab_pin.sym} 82750 -6490 0 1 {name=p82411 lab=_81593_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -6480 0 0 {name=X_81593_ }
C {devices/lab_pin.sym} 82620 -6350 0 0 {name=p82412 lab=_55168_/X }
C {devices/lab_pin.sym} 82700 -6350 0 1 {name=p82413 lab=_55300_/X }
C {sky130_stdcells/buf_2.sym} 82660 -6350 0 0 {name=X_55300_ }
C {devices/lab_pin.sym} 82620 -6230 0 0 {name=p82414 lab=clkbuf_9_250_0_CLK/X }
C {devices/lab_pin.sym} 82700 -6230 0 1 {name=p82415 lab=_86096_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 82660 -6230 0 0 {name=Xclkbuf_10_500_0_CLK }
C {devices/lab_pin.sym} 82570 -6110 0 0 {name=p82416 lab=_86121_/CLK }
C {devices/lab_pin.sym} 82570 -6090 0 0 {name=p82417 lab=_86120_/D }
C {devices/lab_pin.sym} 82750 -6110 0 1 {name=p82418 lab=_86120_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -6100 0 0 {name=X_86120_ }
C {devices/lab_pin.sym} 82580 -5990 0 0 {name=p82419 lab=_65074_/B }
C {devices/lab_pin.sym} 82580 -5950 0 0 {name=p82420 lab=_52500_/X }
C {devices/lab_pin.sym} 82580 -5910 0 0 {name=p82421 lab=_52511_/Y }
C {devices/lab_pin.sym} 82740 -5950 0 1 {name=p82422 lab=_52512_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -5950 0 0 {name=X_52512_ }
C {devices/lab_pin.sym} 82570 -5810 0 0 {name=p82423 lab=_83753_/CLK }
C {devices/lab_pin.sym} 82570 -5790 0 0 {name=p82424 lab=_71909_/Y }
C {devices/lab_pin.sym} 82750 -5810 0 1 {name=p82425 lab=_83332_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -5800 0 0 {name=X_83332_ }
C {devices/lab_pin.sym} 82600 -5690 0 0 {name=p82426 lab=_56280_/A }
C {devices/lab_pin.sym} 82600 -5650 0 0 {name=p82427 lab=_56177_/B }
C {devices/lab_pin.sym} 82600 -5610 0 0 {name=p82428 lab=_56280_/C }
C {devices/lab_pin.sym} 82720 -5650 0 1 {name=p82429 lab=_56280_/Y }
C {sky130_stdcells/nand3_4.sym} 82660 -5650 0 0 {name=X_56280_ }
C {devices/lab_pin.sym} 82600 -5520 0 0 {name=p82430 lab=_80551_/B }
C {devices/lab_pin.sym} 82600 -5480 0 0 {name=p82431 lab=_80544_/B }
C {devices/lab_pin.sym} 82720 -5500 0 1 {name=p82432 lab=_80544_/X }
C {sky130_stdcells/xor2_4.sym} 82660 -5500 0 0 {name=X_80544_ }
C {devices/lab_pin.sym} 82580 -5390 0 0 {name=p82433 lab=_83997_/Q }
C {devices/lab_pin.sym} 82580 -5350 0 0 {name=p82434 lab=_68259_/X }
C {devices/lab_pin.sym} 82580 -5310 0 0 {name=p82435 lab=_68265_/X }
C {devices/lab_pin.sym} 82740 -5350 0 1 {name=p82436 lab=_68266_/X }
C {sky130_stdcells/a21bo_4.sym} 82660 -5350 0 0 {name=X_68266_ }
C {devices/lab_pin.sym} 82620 -5210 0 0 {name=p82437 lab=_53671_/A }
C {devices/lab_pin.sym} 82700 -5210 0 1 {name=p82438 lab=_53492_/X }
C {sky130_stdcells/buf_2.sym} 82660 -5210 0 0 {name=X_53492_ }
C {devices/lab_pin.sym} 82620 -5090 0 0 {name=p82439 lab=_65984_/A }
C {devices/lab_pin.sym} 82700 -5090 0 1 {name=p82440 lab=_65647_/B }
C {sky130_stdcells/buf_2.sym} 82660 -5090 0 0 {name=X_65478_ }
C {devices/lab_pin.sym} 82600 -4980 0 0 {name=p82441 lab=_55125_/A }
C {devices/lab_pin.sym} 82600 -4940 0 0 {name=p82442 lab=_55231_/B }
C {devices/lab_pin.sym} 82720 -4960 0 1 {name=p82443 lab=_55231_/Y }
C {sky130_stdcells/nor2_4.sym} 82660 -4960 0 0 {name=X_55231_ }
C {devices/lab_pin.sym} 82580 -4850 0 0 {name=p82444 lab=_67214_/X }
C {devices/lab_pin.sym} 82580 -4810 0 0 {name=p82445 lab=_67216_/X }
C {devices/lab_pin.sym} 82580 -4770 0 0 {name=p82446 lab=_67147_/X }
C {devices/lab_pin.sym} 82740 -4810 0 1 {name=p82447 lab=_67220_/A }
C {sky130_stdcells/a21o_4.sym} 82660 -4810 0 0 {name=X_67217_ }
C {devices/lab_pin.sym} 82570 -4670 0 0 {name=p82448 lab=_85635_/CLK }
C {devices/lab_pin.sym} 82570 -4650 0 0 {name=p82449 lab=_86051_/D }
C {devices/lab_pin.sym} 82750 -4670 0 1 {name=p82450 lab=_86051_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -4660 0 0 {name=X_86051_ }
C {devices/lab_pin.sym} 82580 -4550 0 0 {name=p82451 lab=_52441_/Y }
C {devices/lab_pin.sym} 82580 -4510 0 0 {name=p82452 lab=_52430_/X }
C {devices/lab_pin.sym} 82580 -4470 0 0 {name=p82453 lab=_52442_/Y }
C {devices/lab_pin.sym} 82740 -4510 0 1 {name=p82454 lab=_52443_/Y }
C {sky130_stdcells/a21boi_4.sym} 82660 -4510 0 0 {name=X_52443_ }
C {devices/lab_pin.sym} 82620 -4370 0 0 {name=p82455 lab=_65296_/A }
C {devices/lab_pin.sym} 82700 -4370 0 1 {name=p82456 lab=_64429_/X }
C {sky130_stdcells/buf_2.sym} 82660 -4370 0 0 {name=X_64429_ }
C {devices/lab_pin.sym} 82570 -4250 0 0 {name=p82457 lab=_86289_/CLK }
C {devices/lab_pin.sym} 82570 -4230 0 0 {name=p82458 lab=_83263_/D }
C {devices/lab_pin.sym} 82750 -4250 0 1 {name=p82459 lab=_83263_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -4240 0 0 {name=X_83263_ }
C {devices/lab_pin.sym} 82600 -4120 0 0 {name=p82460 lab=_80475_/A }
C {devices/lab_pin.sym} 82600 -4080 0 0 {name=p82461 lab=_80475_/B }
C {devices/lab_pin.sym} 82720 -4100 0 1 {name=p82462 lab=_80476_/B }
C {sky130_stdcells/xor2_4.sym} 82660 -4100 0 0 {name=X_80475_ }
C {devices/lab_pin.sym} 82580 -3990 0 0 {name=p82463 lab=_67229_/X }
C {devices/lab_pin.sym} 82580 -3950 0 0 {name=p82464 lab=_67232_/X }
C {devices/lab_pin.sym} 82580 -3910 0 0 {name=p82465 lab=_68173_/X }
C {devices/lab_pin.sym} 82740 -3950 0 1 {name=p82466 lab=_68197_/Y }
C {sky130_stdcells/a21oi_4.sym} 82660 -3950 0 0 {name=X_68197_ }
C {devices/lab_pin.sym} 82570 -3810 0 0 {name=p82467 lab=_83335_/CLK }
C {devices/lab_pin.sym} 82570 -3790 0 0 {name=p82468 lab=_57452_/Y }
C {devices/lab_pin.sym} 82750 -3810 0 1 {name=p82469 lab=_57448_/A }
C {sky130_stdcells/dfxtp_4.sym} 82660 -3800 0 0 {name=X_85002_ }
C {devices/lab_pin.sym} 82570 -3670 0 0 {name=p82470 lab=_82220_/CLK }
C {devices/lab_pin.sym} 82570 -3650 0 0 {name=p82471 lab=_82246_/Q }
C {devices/lab_pin.sym} 82750 -3670 0 1 {name=p82472 lab=_82214_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -3660 0 0 {name=X_82214_ }
C {devices/lab_pin.sym} 82600 -3550 0 0 {name=p82473 lab=_55139_/X }
C {devices/lab_pin.sym} 82600 -3510 0 0 {name=p82474 lab=_83747_/Q }
C {devices/lab_pin.sym} 82600 -3470 0 0 {name=p82475 lab=_55146_/X }
C {devices/lab_pin.sym} 82720 -3510 0 1 {name=p82476 lab=_55162_/Y }
C {sky130_stdcells/nand3_4.sym} 82660 -3510 0 0 {name=X_55162_ }
C {devices/lab_pin.sym} 82580 -3390 0 0 {name=p82477 lab=_67143_/X }
C {devices/lab_pin.sym} 82580 -3350 0 0 {name=p82478 lab=_67146_/X }
C {devices/lab_pin.sym} 82580 -3310 0 0 {name=p82479 lab=_67147_/X }
C {devices/lab_pin.sym} 82740 -3350 0 1 {name=p82480 lab=_67148_/X }
C {sky130_stdcells/a21o_4.sym} 82660 -3350 0 0 {name=X_67148_ }
C {devices/lab_pin.sym} 82600 -3220 0 0 {name=p82481 lab=_52373_/X }
C {devices/lab_pin.sym} 82600 -3180 0 0 {name=p82482 lab=_50674_/B }
C {devices/lab_pin.sym} 82720 -3200 0 1 {name=p82483 lab=_52374_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -3200 0 0 {name=X_52374_ }
C {devices/lab_pin.sym} 82570 -3070 0 0 {name=p82484 lab=_83191_/CLK }
C {devices/lab_pin.sym} 82570 -3050 0 0 {name=p82485 lab=_72676_/X }
C {devices/lab_pin.sym} 82750 -3070 0 1 {name=p82486 lab=_83194_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -3060 0 0 {name=X_83194_ }
C {devices/lab_pin.sym} 82620 -2930 0 0 {name=p82487 lab=clkbuf_9_257_0_CLK/X }
C {devices/lab_pin.sym} 82700 -2930 0 1 {name=p82488 lab=_81428_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 82660 -2930 0 0 {name=Xclkbuf_10_515_0_CLK }
C {devices/lab_pin.sym} 82620 -2810 0 0 {name=p82489 lab=_53351_/A }
C {devices/lab_pin.sym} 82700 -2810 0 1 {name=p82490 lab=_54113_/X }
C {sky130_stdcells/buf_2.sym} 82660 -2810 0 0 {name=X_54113_ }
C {devices/lab_pin.sym} 82580 -2710 0 0 {name=p82491 lab=_86031_/Q }
C {devices/lab_pin.sym} 82580 -2670 0 0 {name=p82492 lab=_51309_/X }
C {devices/lab_pin.sym} 82580 -2630 0 0 {name=p82493 lab=_51324_/Y }
C {devices/lab_pin.sym} 82740 -2670 0 1 {name=p82494 lab=_51325_/Y }
C {sky130_stdcells/o21ai_4.sym} 82660 -2670 0 0 {name=X_51325_ }
C {devices/lab_pin.sym} 82570 -2530 0 0 {name=p82495 lab=_82145_/CLK }
C {devices/lab_pin.sym} 82570 -2510 0 0 {name=p82496 lab=_82145_/D }
C {devices/lab_pin.sym} 82750 -2530 0 1 {name=p82497 lab=_82101_/D }
C {sky130_stdcells/dfxtp_4.sym} 82660 -2520 0 0 {name=X_82145_ }
C {devices/lab_pin.sym} 82600 -2400 0 0 {name=p82498 lab=_55093_/A }
C {devices/lab_pin.sym} 82600 -2360 0 0 {name=p82499 lab=_47771_/Y }
C {devices/lab_pin.sym} 82720 -2380 0 1 {name=p82500 lab=_55093_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -2380 0 0 {name=X_55093_ }
C {devices/lab_pin.sym} 82620 -2250 0 0 {name=p82501 lab=_59969_/X }
C {devices/lab_pin.sym} 82700 -2250 0 1 {name=p82502 lab=_60042_/A }
C {sky130_stdcells/inv_2.sym} 82660 -2250 0 0 {name=X_59970_ }
C {devices/lab_pin.sym} 82600 -2140 0 0 {name=p82503 lab=_67057_/A }
C {devices/lab_pin.sym} 82600 -2100 0 0 {name=p82504 lab=_67079_/B }
C {devices/lab_pin.sym} 82720 -2120 0 1 {name=p82505 lab=_67079_/X }
C {sky130_stdcells/and2_4.sym} 82660 -2120 0 0 {name=X_67079_ }
C {devices/lab_pin.sym} 82600 -2000 0 0 {name=p82506 lab=_58921_/A }
C {devices/lab_pin.sym} 82600 -1960 0 0 {name=p82507 lab=_58898_/B }
C {devices/lab_pin.sym} 82720 -1980 0 1 {name=p82508 lab=_58921_/Y }
C {sky130_stdcells/nor2_4.sym} 82660 -1980 0 0 {name=X_58921_ }
C {devices/lab_pin.sym} 82580 -1870 0 0 {name=p82509 lab=_54042_/Y }
C {devices/lab_pin.sym} 82580 -1830 0 0 {name=p82510 lab=_54015_/X }
C {devices/lab_pin.sym} 82580 -1790 0 0 {name=p82511 lab=_54043_/X }
C {devices/lab_pin.sym} 82740 -1830 0 1 {name=p82512 lab=_54044_/Y }
C {sky130_stdcells/a21oi_4.sym} 82660 -1830 0 0 {name=X_54044_ }
C {devices/lab_pin.sym} 82600 -1710 0 0 {name=p82513 lab=_51256_/A }
C {devices/lab_pin.sym} 82600 -1670 0 0 {name=p82514 lab=_51256_/B }
C {devices/lab_pin.sym} 82600 -1630 0 0 {name=p82515 lab=_51330_/C }
C {devices/lab_pin.sym} 82720 -1670 0 1 {name=p82516 lab=_51256_/X }
C {sky130_stdcells/and3_4.sym} 82660 -1670 0 0 {name=X_51256_ }
C {devices/lab_pin.sym} 82570 -1530 0 0 {name=p82517 lab=_88220_/CLK }
C {devices/lab_pin.sym} 82570 -1510 0 0 {name=p82518 lab=_86953_/D }
C {devices/lab_pin.sym} 82750 -1530 0 1 {name=p82519 lab=_86953_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -1520 0 0 {name=X_86953_ }
C {devices/lab_pin.sym} 82570 -1390 0 0 {name=p82520 lab=_81160_/CLK }
C {devices/lab_pin.sym} 82570 -1370 0 0 {name=p82521 lab=_82076_/D }
C {devices/lab_pin.sym} 82750 -1390 0 1 {name=p82522 lab=_77964_/A }
C {sky130_stdcells/dfxtp_4.sym} 82660 -1380 0 0 {name=X_82076_ }
C {devices/lab_pin.sym} 82580 -1280 0 0 {name=p82523 lab=_69603_/X }
C {devices/lab_pin.sym} 82580 -1240 0 0 {name=p82524 lab=_69951_/Y }
C {devices/lab_pin.sym} 82580 -1200 0 0 {name=p82525 lab=_70081_/X }
C {devices/lab_pin.sym} 82580 -1160 0 0 {name=p82526 lab=_70089_/Y }
C {devices/lab_pin.sym} 82740 -1220 0 1 {name=p82527 lab=_70090_/X }
C {sky130_stdcells/a211o_4.sym} 82660 -1220 0 0 {name=X_70090_ }
C {devices/lab_pin.sym} 82600 -1080 0 0 {name=p82528 lab=_50187_/X }
C {devices/lab_pin.sym} 82600 -1040 0 0 {name=p82529 lab=_50721_/B }
C {devices/lab_pin.sym} 82720 -1060 0 1 {name=p82530 lab=_50207_/Y }
C {sky130_stdcells/nand2_4.sym} 82660 -1060 0 0 {name=X_50207_ }
C {devices/lab_pin.sym} 82570 -930 0 0 {name=p82531 lab=_86576_/CLK }
C {devices/lab_pin.sym} 82570 -910 0 0 {name=p82532 lab=_85904_/D }
C {devices/lab_pin.sym} 82750 -930 0 1 {name=p82533 lab=_66153_/B }
C {sky130_stdcells/dfxtp_4.sym} 82660 -920 0 0 {name=X_85904_ }
C {devices/lab_pin.sym} 82570 -790 0 0 {name=p82534 lab=_82786_/CLK }
C {devices/lab_pin.sym} 82570 -770 0 0 {name=p82535 lab=_81027_/D }
C {devices/lab_pin.sym} 82750 -790 0 1 {name=p82536 lab=_81027_/Q }
C {sky130_stdcells/dfxtp_4.sym} 82660 -780 0 0 {name=X_81027_ }
C {devices/lab_pin.sym} 83540 -42150 0 0 {name=p82537 lab=_58721_/A }
C {devices/lab_pin.sym} 83620 -42150 0 1 {name=p82538 lab=_59090_/B }
C {sky130_stdcells/buf_2.sym} 83580 -42150 0 0 {name=X_58852_ }
C {devices/lab_pin.sym} 83520 -42060 0 0 {name=p82539 lab=_51177_/A }
C {devices/lab_pin.sym} 83520 -42020 0 0 {name=p82540 lab=_51192_/B }
C {devices/lab_pin.sym} 83520 -41980 0 0 {name=p82541 lab=_51192_/C }
C {devices/lab_pin.sym} 83520 -41940 0 0 {name=p82542 lab=_52879_/D }
C {devices/lab_pin.sym} 83640 -42000 0 1 {name=p82543 lab=_51187_/X }
C {sky130_stdcells/and4_4.sym} 83580 -42000 0 0 {name=X_51187_ }
C {devices/lab_pin.sym} 83490 -41850 0 0 {name=p82544 lab=_86869_/CLK }
C {devices/lab_pin.sym} 83490 -41830 0 0 {name=p82545 lab=_45323_/Y }
C {devices/lab_pin.sym} 83670 -41850 0 1 {name=p82546 lab=_63312_/B }
C {sky130_stdcells/dfxtp_4.sym} 83580 -41840 0 0 {name=X_86884_ }
C {devices/lab_pin.sym} 83540 -41710 0 0 {name=p82547 lab=_57803_/A }
C {devices/lab_pin.sym} 83620 -41710 0 1 {name=p82548 lab=_57804_/A }
C {sky130_stdcells/buf_2.sym} 83580 -41710 0 0 {name=X_57803_ }
C {devices/lab_pin.sym} 83540 -41590 0 0 {name=p82549 lab=_50064_/A }
C {devices/lab_pin.sym} 83620 -41590 0 1 {name=p82550 lab=_50153_/A }
C {sky130_stdcells/buf_2.sym} 83580 -41590 0 0 {name=X_50138_ }
C {devices/lab_pin.sym} 83490 -41470 0 0 {name=p82551 lab=_86155_/CLK }
C {devices/lab_pin.sym} 83490 -41450 0 0 {name=p82552 lab=_52378_/Y }
C {devices/lab_pin.sym} 83670 -41470 0 1 {name=p82553 lab=_85835_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -41460 0 0 {name=X_85835_ }
C {devices/lab_pin.sym} 83500 -41350 0 0 {name=p82554 lab=_58703_/X }
C {devices/lab_pin.sym} 83500 -41310 0 0 {name=p82555 lab=_85456_/Q }
C {devices/lab_pin.sym} 83500 -41270 0 0 {name=p82556 lab=_58782_/X }
C {devices/lab_pin.sym} 83660 -41310 0 1 {name=p82557 lab=_58783_/Y }
C {sky130_stdcells/o21ai_4.sym} 83580 -41310 0 0 {name=X_58783_ }
C {devices/lab_pin.sym} 83520 -41200 0 0 {name=p82558 lab=_55993_/Y }
C {devices/lab_pin.sym} 83520 -41160 0 0 {name=p82559 lab=_55994_/X }
C {devices/lab_pin.sym} 83520 -41120 0 0 {name=p82560 lab=_56083_/C }
C {devices/lab_pin.sym} 83520 -41080 0 0 {name=p82561 lab=_55854_/X }
C {devices/lab_pin.sym} 83640 -41140 0 1 {name=p82562 lab=_55995_/X }
C {sky130_stdcells/and4_4.sym} 83580 -41140 0 0 {name=X_55995_ }
C {devices/lab_pin.sym} 83520 -41000 0 0 {name=p82563 lab=_72800_/A }
C {devices/lab_pin.sym} 83520 -40960 0 0 {name=p82564 lab=_72924_/B }
C {devices/lab_pin.sym} 83640 -40980 0 1 {name=p82565 lab=_72800_/Y }
C {sky130_stdcells/nor2_4.sym} 83580 -40980 0 0 {name=X_72800_ }
C {devices/lab_pin.sym} 83520 -40860 0 0 {name=p82566 lab=_57734_/A }
C {devices/lab_pin.sym} 83520 -40820 0 0 {name=p82567 lab=_57833_/B }
C {devices/lab_pin.sym} 83640 -40840 0 1 {name=p82568 lab=_57734_/Y }
C {sky130_stdcells/nor2_4.sym} 83580 -40840 0 0 {name=X_57734_ }
C {devices/lab_pin.sym} 83540 -40710 0 0 {name=p82569 lab=_42960_/A }
C {devices/lab_pin.sym} 83620 -40710 0 1 {name=p82570 lab=_87630_/D }
C {sky130_stdcells/inv_2.sym} 83580 -40710 0 0 {name=X_42960_ }
C {devices/lab_pin.sym} 83520 -40600 0 0 {name=p82571 lab=_50069_/A }
C {devices/lab_pin.sym} 83520 -40560 0 0 {name=p82572 lab=_71970_/B }
C {devices/lab_pin.sym} 83640 -40580 0 1 {name=p82573 lab=_50069_/X }
C {sky130_stdcells/and2_4.sym} 83580 -40580 0 0 {name=X_50069_ }
C {devices/lab_pin.sym} 83520 -40480 0 0 {name=p82574 lab=_54955_/A }
C {devices/lab_pin.sym} 83520 -40440 0 0 {name=p82575 lab=_54942_/B }
C {devices/lab_pin.sym} 83520 -40400 0 0 {name=p82576 lab=_46617_/A }
C {devices/lab_pin.sym} 83520 -40360 0 0 {name=p82577 lab=_53253_/D }
C {devices/lab_pin.sym} 83640 -40420 0 1 {name=p82578 lab=_54946_/X }
C {sky130_stdcells/and4_4.sym} 83580 -40420 0 0 {name=X_54946_ }
C {devices/lab_pin.sym} 83520 -40280 0 0 {name=p82579 lab=_73733_/A }
C {devices/lab_pin.sym} 83520 -40240 0 0 {name=p82580 lab=_73780_/B }
C {devices/lab_pin.sym} 83640 -40260 0 1 {name=p82581 lab=_73780_/X }
C {sky130_stdcells/and2_4.sym} 83580 -40260 0 0 {name=X_73780_ }
C {devices/lab_pin.sym} 83490 -40130 0 0 {name=p82582 lab=_85767_/CLK }
C {devices/lab_pin.sym} 83490 -40110 0 0 {name=p82583 lab=_52725_/Y }
C {devices/lab_pin.sym} 83670 -40130 0 1 {name=p82584 lab=_85766_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -40120 0 0 {name=X_85766_ }
C {devices/lab_pin.sym} 83520 -40010 0 0 {name=p82585 lab=_70990_/A }
C {devices/lab_pin.sym} 83520 -39970 0 0 {name=p82586 lab=_70945_/B }
C {devices/lab_pin.sym} 83520 -39930 0 0 {name=p82587 lab=_70990_/C }
C {devices/lab_pin.sym} 83640 -39970 0 1 {name=p82588 lab=_70992_/Y }
C {sky130_stdcells/nand3_4.sym} 83580 -39970 0 0 {name=X_70992_ }
C {devices/lab_pin.sym} 83490 -39830 0 0 {name=p82589 lab=_82980_/CLK }
C {devices/lab_pin.sym} 83490 -39810 0 0 {name=p82590 lab=_74706_/X }
C {devices/lab_pin.sym} 83670 -39830 0 1 {name=p82591 lab=_45875_/A }
C {sky130_stdcells/dfxtp_4.sym} 83580 -39820 0 0 {name=X_82978_ }
C {devices/lab_pin.sym} 83540 -39690 0 0 {name=p82592 lab=_41911_/A }
C {devices/lab_pin.sym} 83620 -39690 0 1 {name=p82593 lab=_41912_/A }
C {sky130_stdcells/buf_2.sym} 83580 -39690 0 0 {name=X_41911_ }
C {devices/lab_pin.sym} 83490 -39570 0 0 {name=p82594 lab=_87520_/CLK }
C {devices/lab_pin.sym} 83490 -39550 0 0 {name=p82595 lab=_43275_/Y }
C {devices/lab_pin.sym} 83670 -39570 0 1 {name=p82596 lab=_87505_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -39560 0 0 {name=X_87505_ }
C {devices/lab_pin.sym} 83540 -39430 0 0 {name=p82597 lab=_72730_/X }
C {devices/lab_pin.sym} 83620 -39430 0 1 {name=p82598 lab=_72731_/X }
C {sky130_stdcells/buf_2.sym} 83580 -39430 0 0 {name=X_72731_ }
C {devices/lab_pin.sym} 83490 -39310 0 0 {name=p82599 lab=_84903_/CLK }
C {devices/lab_pin.sym} 83490 -39290 0 0 {name=p82600 lab=_84717_/D }
C {devices/lab_pin.sym} 83670 -39310 0 1 {name=p82601 lab=_84717_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -39300 0 0 {name=X_84717_ }
C {devices/lab_pin.sym} 83540 -39170 0 0 {name=p82602 lab=_57665_/A }
C {devices/lab_pin.sym} 83620 -39170 0 1 {name=p82603 lab=_57666_/B }
C {sky130_stdcells/buf_2.sym} 83580 -39170 0 0 {name=X_57665_ }
C {devices/lab_pin.sym} 83490 -39050 0 0 {name=p82604 lab=_82234_/CLK }
C {devices/lab_pin.sym} 83490 -39030 0 0 {name=p82605 lab=_77786_/X }
C {devices/lab_pin.sym} 83670 -39050 0 1 {name=p82606 lab=_81929_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -39040 0 0 {name=X_81929_ }
C {devices/lab_pin.sym} 83500 -38930 0 0 {name=p82607 lab=_85361_/Q }
C {devices/lab_pin.sym} 83500 -38890 0 0 {name=p82608 lab=_54865_/X }
C {devices/lab_pin.sym} 83500 -38850 0 0 {name=p82609 lab=_54876_/Y }
C {devices/lab_pin.sym} 83660 -38890 0 1 {name=p82610 lab=_54877_/Y }
C {sky130_stdcells/o21ai_4.sym} 83580 -38890 0 0 {name=X_54877_ }
C {devices/lab_pin.sym} 83500 -38780 0 0 {name=p82611 lab=_41636_/X }
C {devices/lab_pin.sym} 83500 -38740 0 0 {name=p82612 lab=_42886_/X }
C {devices/lab_pin.sym} 83500 -38700 0 0 {name=p82613 lab=_67356_/B }
C {devices/lab_pin.sym} 83500 -38660 0 0 {name=p82614 lab=_42887_/X }
C {devices/lab_pin.sym} 83660 -38720 0 1 {name=p82615 lab=_87666_/D }
C {sky130_stdcells/a2bb2o_4.sym} 83580 -38720 0 0 {name=X_42891_ }
C {devices/lab_pin.sym} 83490 -38570 0 0 {name=p82616 lab=_85697_/CLK }
C {devices/lab_pin.sym} 83490 -38550 0 0 {name=p82617 lab=_53104_/Y }
C {devices/lab_pin.sym} 83670 -38570 0 1 {name=p82618 lab=_85697_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -38560 0 0 {name=X_85697_ }
C {devices/lab_pin.sym} 83500 -38450 0 0 {name=p82619 lab=_59394_/X }
C {devices/lab_pin.sym} 83500 -38410 0 0 {name=p82620 lab=_83486_/Q }
C {devices/lab_pin.sym} 83500 -38370 0 0 {name=p82621 lab=_59403_/Y }
C {devices/lab_pin.sym} 83660 -38410 0 1 {name=p82622 lab=_84742_/D }
C {sky130_stdcells/o21a_4.sym} 83580 -38410 0 0 {name=X_59404_ }
C {devices/lab_pin.sym} 83520 -38280 0 0 {name=p82623 lab=_56616_/A }
C {devices/lab_pin.sym} 83520 -38240 0 0 {name=p82624 lab=_56616_/B }
C {devices/lab_pin.sym} 83640 -38260 0 1 {name=p82625 lab=_56617_/A }
C {sky130_stdcells/and2_4.sym} 83580 -38260 0 0 {name=X_56616_ }
C {devices/lab_pin.sym} 83500 -38170 0 0 {name=p82626 lab=_44622_/X }
C {devices/lab_pin.sym} 83500 -38130 0 0 {name=p82627 lab=_44623_/X }
C {devices/lab_pin.sym} 83500 -38090 0 0 {name=p82628 lab=_41009_/A }
C {devices/lab_pin.sym} 83500 -38050 0 0 {name=p82629 lab=_87026_/Q }
C {devices/lab_pin.sym} 83500 -38010 0 0 {name=p82630 lab=_44625_/X }
C {devices/lab_pin.sym} 83660 -38090 0 1 {name=p82631 lab=_44631_/A }
C {sky130_stdcells/o32ai_4.sym} 83580 -38090 0 0 {name=X_44630_ }
C {devices/lab_pin.sym} 83500 -37950 0 0 {name=p82632 lab=_75438_/Y }
C {devices/lab_pin.sym} 83500 -37910 0 0 {name=p82633 lab=_75431_/X }
C {devices/lab_pin.sym} 83500 -37870 0 0 {name=p82634 lab=_75432_/Y }
C {devices/lab_pin.sym} 83660 -37910 0 1 {name=p82635 lab=_75450_/Y }
C {sky130_stdcells/a21boi_4.sym} 83580 -37910 0 0 {name=X_75450_ }
C {devices/lab_pin.sym} 83490 -37770 0 0 {name=p82636 lab=_87436_/CLK }
C {devices/lab_pin.sym} 83490 -37750 0 0 {name=p82637 lab=_43409_/Y }
C {devices/lab_pin.sym} 83670 -37770 0 1 {name=p82638 lab=_87436_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -37760 0 0 {name=X_87436_ }
C {devices/lab_pin.sym} 83500 -37650 0 0 {name=p82639 lab=_85560_/Q }
C {devices/lab_pin.sym} 83500 -37610 0 0 {name=p82640 lab=_53784_/X }
C {devices/lab_pin.sym} 83500 -37570 0 0 {name=p82641 lab=_53827_/Y }
C {devices/lab_pin.sym} 83660 -37610 0 1 {name=p82642 lab=_53828_/Y }
C {sky130_stdcells/o21ai_4.sym} 83580 -37610 0 0 {name=X_53828_ }
C {devices/lab_pin.sym} 83500 -37510 0 0 {name=p82643 lab=_41839_/X }
C {devices/lab_pin.sym} 83500 -37470 0 0 {name=p82644 lab=_41841_/X }
C {devices/lab_pin.sym} 83500 -37430 0 0 {name=p82645 lab=_40491_/X }
C {devices/lab_pin.sym} 83500 -37390 0 0 {name=p82646 lab=_88127_/Q }
C {devices/lab_pin.sym} 83500 -37350 0 0 {name=p82647 lab=_41835_/X }
C {devices/lab_pin.sym} 83660 -37430 0 1 {name=p82648 lab=_41843_/A }
C {sky130_stdcells/o32ai_4.sym} 83580 -37430 0 0 {name=X_41842_ }
C {devices/lab_pin.sym} 83520 -37290 0 0 {name=p82649 lab=_72668_/A }
C {devices/lab_pin.sym} 83520 -37250 0 0 {name=p82650 lab=_72668_/B }
C {devices/lab_pin.sym} 83520 -37210 0 0 {name=p82651 lab=_72662_/C }
C {devices/lab_pin.sym} 83640 -37250 0 1 {name=p82652 lab=_72662_/Y }
C {sky130_stdcells/nand3_4.sym} 83580 -37250 0 0 {name=X_72662_ }
C {devices/lab_pin.sym} 83490 -37110 0 0 {name=p82653 lab=_84645_/CLK }
C {devices/lab_pin.sym} 83490 -37090 0 0 {name=p82654 lab=_60231_/Y }
C {devices/lab_pin.sym} 83670 -37110 0 1 {name=p82655 lab=_79872_/A }
C {sky130_stdcells/dfxtp_4.sym} 83580 -37100 0 0 {name=X_84648_ }
C {devices/lab_pin.sym} 83500 -36990 0 0 {name=p82656 lab=_84972_/Q }
C {devices/lab_pin.sym} 83500 -36950 0 0 {name=p82657 lab=_57550_/X }
C {devices/lab_pin.sym} 83500 -36910 0 0 {name=p82658 lab=_57595_/Y }
C {devices/lab_pin.sym} 83660 -36950 0 1 {name=p82659 lab=_57596_/Y }
C {sky130_stdcells/o21ai_4.sym} 83580 -36950 0 0 {name=X_57596_ }
C {devices/lab_pin.sym} 83520 -36830 0 0 {name=p82660 lab=_48440_/A }
C {devices/lab_pin.sym} 83520 -36790 0 0 {name=p82661 lab=_74395_/X }
C {devices/lab_pin.sym} 83520 -36750 0 0 {name=p82662 lab=_74421_/C }
C {devices/lab_pin.sym} 83640 -36790 0 1 {name=p82663 lab=_74401_/X }
C {sky130_stdcells/and3_4.sym} 83580 -36790 0 0 {name=X_74401_ }
C {devices/lab_pin.sym} 83500 -36670 0 0 {name=p82664 lab=_59311_/X }
C {devices/lab_pin.sym} 83500 -36630 0 0 {name=p82665 lab=_85734_/Q }
C {devices/lab_pin.sym} 83500 -36590 0 0 {name=p82666 lab=_59334_/X }
C {devices/lab_pin.sym} 83660 -36630 0 1 {name=p82667 lab=_59335_/X }
C {sky130_stdcells/o21a_4.sym} 83580 -36630 0 0 {name=X_59335_ }
C {devices/lab_pin.sym} 83500 -36510 0 0 {name=p82668 lab=_71604_/X }
C {devices/lab_pin.sym} 83500 -36470 0 0 {name=p82669 lab=_83439_/Q }
C {devices/lab_pin.sym} 83500 -36430 0 0 {name=p82670 lab=_71612_/Y }
C {devices/lab_pin.sym} 83660 -36470 0 1 {name=p82671 lab=_71613_/X }
C {sky130_stdcells/a21o_4.sym} 83580 -36470 0 0 {name=X_71613_ }
C {devices/lab_pin.sym} 83500 -36370 0 0 {name=p82672 lab=_44547_/X }
C {devices/lab_pin.sym} 83500 -36330 0 0 {name=p82673 lab=_44548_/X }
C {devices/lab_pin.sym} 83500 -36290 0 0 {name=p82674 lab=_40854_/X }
C {devices/lab_pin.sym} 83500 -36250 0 0 {name=p82675 lab=_87054_/Q }
C {devices/lab_pin.sym} 83500 -36210 0 0 {name=p82676 lab=_44549_/X }
C {devices/lab_pin.sym} 83660 -36290 0 1 {name=p82677 lab=_44562_/A }
C {sky130_stdcells/o32ai_4.sym} 83580 -36290 0 0 {name=X_44561_ }
C {devices/lab_pin.sym} 83540 -36130 0 0 {name=p82678 lab=_72739_/A }
C {devices/lab_pin.sym} 83620 -36130 0 1 {name=p82679 lab=_56547_/X }
C {sky130_stdcells/buf_2.sym} 83580 -36130 0 0 {name=X_56547_ }
C {devices/lab_pin.sym} 83520 -36020 0 0 {name=p82680 lab=_75380_/Y }
C {devices/lab_pin.sym} 83520 -35980 0 0 {name=p82681 lab=_75381_/B }
C {devices/lab_pin.sym} 83640 -36000 0 1 {name=p82682 lab=_75382_/A }
C {sky130_stdcells/nand2_4.sym} 83580 -36000 0 0 {name=X_75381_ }
C {devices/lab_pin.sym} 83540 -35870 0 0 {name=p82683 lab=_41772_/X }
C {devices/lab_pin.sym} 83620 -35870 0 1 {name=p82684 lab=_41773_/X }
C {sky130_stdcells/buf_2.sym} 83580 -35870 0 0 {name=X_41773_ }
C {devices/lab_pin.sym} 83490 -35750 0 0 {name=p82685 lab=_86824_/CLK }
C {devices/lab_pin.sym} 83490 -35730 0 0 {name=p82686 lab=_43544_/Y }
C {devices/lab_pin.sym} 83670 -35750 0 1 {name=p82687 lab=_87367_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -35740 0 0 {name=X_87367_ }
C {devices/lab_pin.sym} 83520 -35630 0 0 {name=p82688 lab=_48667_/A }
C {devices/lab_pin.sym} 83520 -35590 0 0 {name=p82689 lab=_53774_/B }
C {devices/lab_pin.sym} 83520 -35550 0 0 {name=p82690 lab=_53748_/C }
C {devices/lab_pin.sym} 83640 -35590 0 1 {name=p82691 lab=_53759_/X }
C {sky130_stdcells/and3_4.sym} 83580 -35590 0 0 {name=X_53759_ }
C {devices/lab_pin.sym} 83500 -35490 0 0 {name=p82692 lab=_72546_/Y }
C {devices/lab_pin.sym} 83500 -35450 0 0 {name=p82693 lab=_59621_/X }
C {devices/lab_pin.sym} 83500 -35410 0 0 {name=p82694 lab=_72539_/Y }
C {devices/lab_pin.sym} 83500 -35370 0 0 {name=p82695 lab=_72510_/Y }
C {devices/lab_pin.sym} 83500 -35340 0 0 {name=p82696 lab=_72592_/Y }
C {devices/lab_pin.sym} 83660 -35410 0 1 {name=p82697 lab=_72593_/X }
C {sky130_stdcells/a41o_4.sym} 83580 -35410 0 0 {name=X_72593_ }
C {devices/lab_pin.sym} 83490 -35250 0 0 {name=p82698 lab=_84454_/CLK }
C {devices/lab_pin.sym} 83490 -35230 0 0 {name=p82699 lab=_84579_/D }
C {devices/lab_pin.sym} 83670 -35250 0 1 {name=p82700 lab=_78074_/A }
C {sky130_stdcells/dfxtp_4.sym} 83580 -35240 0 0 {name=X_84579_ }
C {devices/lab_pin.sym} 83540 -35110 0 0 {name=p82701 lab=_72083_/A }
C {devices/lab_pin.sym} 83620 -35110 0 1 {name=p82702 lab=_46300_/X }
C {sky130_stdcells/buf_2.sym} 83580 -35110 0 0 {name=X_46300_ }
C {devices/lab_pin.sym} 83520 -35000 0 0 {name=p82703 lab=_77111_/A }
C {devices/lab_pin.sym} 83520 -34960 0 0 {name=p82704 lab=_82290_/D }
C {devices/lab_pin.sym} 83640 -34980 0 1 {name=p82705 lab=_77120_/Y }
C {sky130_stdcells/nand2_4.sym} 83580 -34980 0 0 {name=X_77120_ }
C {devices/lab_pin.sym} 83500 -34880 0 0 {name=p82706 lab=_41778_/X }
C {devices/lab_pin.sym} 83500 -34840 0 0 {name=p82707 lab=_43498_/X }
C {devices/lab_pin.sym} 83500 -34800 0 0 {name=p82708 lab=_87383_/Q }
C {devices/lab_pin.sym} 83500 -34760 0 0 {name=p82709 lab=_43499_/X }
C {devices/lab_pin.sym} 83660 -34820 0 1 {name=p82710 lab=_43512_/X }
C {sky130_stdcells/a2bb2o_4.sym} 83580 -34820 0 0 {name=X_43512_ }
C {devices/lab_pin.sym} 83520 -34690 0 0 {name=p82711 lab=_74338_/A }
C {devices/lab_pin.sym} 83520 -34650 0 0 {name=p82712 lab=_74338_/B }
C {devices/lab_pin.sym} 83520 -34610 0 0 {name=p82713 lab=_55994_/X }
C {devices/lab_pin.sym} 83640 -34650 0 1 {name=p82714 lab=_74332_/Y }
C {sky130_stdcells/nand3_4.sym} 83580 -34650 0 0 {name=X_74332_ }
C {devices/lab_pin.sym} 83490 -34510 0 0 {name=p82715 lab=_86637_/CLK }
C {devices/lab_pin.sym} 83490 -34490 0 0 {name=p82716 lab=_86318_/D }
C {devices/lab_pin.sym} 83670 -34510 0 1 {name=p82717 lab=_57991_/B }
C {sky130_stdcells/dfxtp_4.sym} 83580 -34500 0 0 {name=X_86318_ }
C {devices/lab_pin.sym} 83540 -34370 0 0 {name=p82718 lab=_40723_/X }
C {devices/lab_pin.sym} 83620 -34370 0 1 {name=p82719 lab=_40724_/X }
C {sky130_stdcells/buf_2.sym} 83580 -34370 0 0 {name=X_40724_ }
C {devices/lab_pin.sym} 83500 -34270 0 0 {name=p82720 lab=_86651_/Q }
C {devices/lab_pin.sym} 83500 -34230 0 0 {name=p82721 lab=_47240_/X }
C {devices/lab_pin.sym} 83500 -34190 0 0 {name=p82722 lab=_47279_/Y }
C {devices/lab_pin.sym} 83660 -34230 0 1 {name=p82723 lab=_47280_/Y }
C {sky130_stdcells/o21ai_4.sym} 83580 -34230 0 0 {name=X_47280_ }
C {devices/lab_pin.sym} 83500 -34110 0 0 {name=p82724 lab=_59262_/Y }
C {devices/lab_pin.sym} 83500 -34070 0 0 {name=p82725 lab=_59265_/Y }
C {devices/lab_pin.sym} 83500 -34030 0 0 {name=p82726 lab=_59140_/X }
C {devices/lab_pin.sym} 83660 -34070 0 1 {name=p82727 lab=_59266_/X }
C {sky130_stdcells/a21o_4.sym} 83580 -34070 0 0 {name=X_59266_ }
C {devices/lab_pin.sym} 83520 -33950 0 0 {name=p82728 lab=_70679_/A }
C {devices/lab_pin.sym} 83520 -33910 0 0 {name=p82729 lab=_71546_/B }
C {devices/lab_pin.sym} 83520 -33870 0 0 {name=p82730 lab=_71546_/C }
C {devices/lab_pin.sym} 83640 -33910 0 1 {name=p82731 lab=_71544_/Y }
C {sky130_stdcells/nor3_4.sym} 83580 -33910 0 0 {name=X_71544_ }
C {devices/lab_pin.sym} 83500 -33790 0 0 {name=p82732 lab=_56026_/X }
C {devices/lab_pin.sym} 83500 -33750 0 0 {name=p82733 lab=_56468_/X }
C {devices/lab_pin.sym} 83500 -33710 0 0 {name=p82734 lab=_56477_/Y }
C {devices/lab_pin.sym} 83660 -33750 0 1 {name=p82735 lab=_85181_/D }
C {sky130_stdcells/o21ai_4.sym} 83580 -33750 0 0 {name=X_56478_ }
C {devices/lab_pin.sym} 83540 -33610 0 0 {name=p82736 lab=_44491_/Y }
C {devices/lab_pin.sym} 83620 -33610 0 1 {name=p82737 lab=_87082_/D }
C {sky130_stdcells/inv_2.sym} 83580 -33610 0 0 {name=X_44492_ }
C {devices/lab_pin.sym} 83490 -33490 0 0 {name=p82738 lab=_87814_/CLK }
C {devices/lab_pin.sym} 83490 -33470 0 0 {name=p82739 lab=_43715_/Y }
C {devices/lab_pin.sym} 83670 -33490 0 1 {name=p82740 lab=_43713_/A }
C {sky130_stdcells/dfxtp_4.sym} 83580 -33480 0 0 {name=X_87298_ }
C {devices/lab_pin.sym} 83500 -33370 0 0 {name=p82741 lab=_46230_/X }
C {devices/lab_pin.sym} 83500 -33330 0 0 {name=p82742 lab=_86770_/Q }
C {devices/lab_pin.sym} 83500 -33290 0 0 {name=p82743 lab=_45909_/X }
C {devices/lab_pin.sym} 83660 -33330 0 1 {name=p82744 lab=_86756_/D }
C {sky130_stdcells/a21o_4.sym} 83580 -33330 0 0 {name=X_46231_ }
C {devices/lab_pin.sym} 83520 -33200 0 0 {name=p82745 lab=_63355_/A }
C {devices/lab_pin.sym} 83520 -33160 0 0 {name=p82746 lab=_58217_/B }
C {devices/lab_pin.sym} 83640 -33180 0 1 {name=p82747 lab=_58217_/Y }
C {sky130_stdcells/nand2_4.sym} 83580 -33180 0 0 {name=X_58217_ }
C {devices/lab_pin.sym} 83520 -33080 0 0 {name=p82748 lab=_77034_/B }
C {devices/lab_pin.sym} 83520 -33040 0 0 {name=p82749 lab=_77034_/C }
C {devices/lab_pin.sym} 83520 -33000 0 0 {name=p82750 lab=_77038_/X }
C {devices/lab_pin.sym} 83520 -32960 0 0 {name=p82751 lab=_77045_/X }
C {devices/lab_pin.sym} 83640 -33020 0 1 {name=p82752 lab=_77051_/X }
C {sky130_stdcells/and4_4.sym} 83580 -33020 0 0 {name=X_77051_ }
C {sky130_stdcells/decap_3.sym} 83580 -32840 0 0 {name=XPHY_430 }
C {devices/lab_pin.sym} 83500 -32730 0 0 {name=p82753 lab=_43422_/X }
C {devices/lab_pin.sym} 83500 -32690 0 0 {name=p82754 lab=_43426_/X }
C {devices/lab_pin.sym} 83500 -32650 0 0 {name=p82755 lab=_41596_/X }
C {devices/lab_pin.sym} 83500 -32610 0 0 {name=p82756 lab=_87417_/Q }
C {devices/lab_pin.sym} 83500 -32570 0 0 {name=p82757 lab=_43434_/X }
C {devices/lab_pin.sym} 83660 -32650 0 1 {name=p82758 lab=_43443_/Y }
C {sky130_stdcells/o32ai_4.sym} 83580 -32650 0 0 {name=X_43443_ }
C {devices/lab_pin.sym} 83500 -32510 0 0 {name=p82759 lab=_70134_/B }
C {devices/lab_pin.sym} 83500 -32470 0 0 {name=p82760 lab=_74003_/B }
C {devices/lab_pin.sym} 83500 -32430 0 0 {name=p82761 lab=_74262_/X }
C {devices/lab_pin.sym} 83660 -32470 0 1 {name=p82762 lab=_83115_/D }
C {sky130_stdcells/o21ai_4.sym} 83580 -32470 0 0 {name=X_74263_ }
C {devices/lab_pin.sym} 83540 -32330 0 0 {name=p82763 lab=_55429_/A }
C {devices/lab_pin.sym} 83620 -32330 0 1 {name=p82764 lab=_55429_/Y }
C {sky130_stdcells/inv_2.sym} 83580 -32330 0 0 {name=X_55429_ }
C {devices/lab_pin.sym} 83490 -32210 0 0 {name=p82765 lab=_83613_/CLK }
C {devices/lab_pin.sym} 83490 -32190 0 0 {name=p82766 lab=_50176_/Y }
C {devices/lab_pin.sym} 83670 -32210 0 1 {name=p82767 lab=_86249_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -32200 0 0 {name=X_86249_ }
C {sky130_stdcells/decap_3.sym} 83580 -32040 0 0 {name=XPHY_441 }
C {devices/lab_pin.sym} 83500 -31910 0 0 {name=p82768 lab=_40577_/X }
C {devices/lab_pin.sym} 83500 -31870 0 0 {name=p82769 lab=_82869_/Q }
C {devices/lab_pin.sym} 83500 -31830 0 0 {name=p82770 lab=_40654_/X }
C {devices/lab_pin.sym} 83660 -31870 0 1 {name=p82771 lab=_40656_/A }
C {sky130_stdcells/o21a_4.sym} 83580 -31870 0 0 {name=X_40655_ }
C {devices/lab_pin.sym} 83500 -31750 0 0 {name=p82772 lab=_59135_/X }
C {devices/lab_pin.sym} 83500 -31710 0 0 {name=p82773 lab=_85649_/Q }
C {devices/lab_pin.sym} 83500 -31670 0 0 {name=p82774 lab=_59196_/X }
C {devices/lab_pin.sym} 83660 -31710 0 1 {name=p82775 lab=_59197_/X }
C {sky130_stdcells/o21a_4.sym} 83580 -31710 0 0 {name=X_59197_ }
C {devices/lab_pin.sym} 83540 -31570 0 0 {name=p82776 lab=_71068_/B }
C {devices/lab_pin.sym} 83620 -31570 0 1 {name=p82777 lab=_71827_/A }
C {sky130_stdcells/buf_2.sym} 83580 -31570 0 0 {name=X_71475_ }
C {sky130_stdcells/decap_3.sym} 83580 -31420 0 0 {name=XPHY_452 }
C {sky130_stdcells/decap_3.sym} 83580 -31240 0 0 {name=XPHY_463 }
C {devices/lab_pin.sym} 83520 -31100 0 0 {name=p82778 lab=_75999_/Y }
C {devices/lab_pin.sym} 83520 -31060 0 0 {name=p82779 lab=_76001_/Y }
C {devices/lab_pin.sym} 83640 -31080 0 1 {name=p82780 lab=_81741_/D }
C {sky130_stdcells/xor2_4.sym} 83580 -31080 0 0 {name=X_76002_ }
C {sky130_stdcells/decap_3.sym} 83580 -30920 0 0 {name=XPHY_474 }
C {devices/lab_pin.sym} 83540 -30770 0 0 {name=p82781 lab=_73359_/A }
C {devices/lab_pin.sym} 83620 -30770 0 1 {name=p82782 lab=_73214_/X }
C {sky130_stdcells/buf_2.sym} 83580 -30770 0 0 {name=X_73214_ }
C {devices/lab_pin.sym} 83520 -30680 0 0 {name=p82783 lab=_46162_/A }
C {devices/lab_pin.sym} 83520 -30640 0 0 {name=p82784 lab=_46162_/B }
C {devices/lab_pin.sym} 83520 -30600 0 0 {name=p82785 lab=_46162_/C }
C {devices/lab_pin.sym} 83520 -30560 0 0 {name=p82786 lab=_46162_/D }
C {devices/lab_pin.sym} 83640 -30620 0 1 {name=p82787 lab=_46162_/X }
C {sky130_stdcells/and4_4.sym} 83580 -30620 0 0 {name=X_46162_ }
C {devices/lab_pin.sym} 83540 -30470 0 0 {name=p82788 lab=_70426_/A }
C {devices/lab_pin.sym} 83620 -30470 0 1 {name=p82789 lab=_70442_/A }
C {sky130_stdcells/buf_2.sym} 83580 -30470 0 0 {name=X_70426_ }
C {devices/lab_pin.sym} 83500 -30370 0 0 {name=p82790 lab=_57677_/X }
C {devices/lab_pin.sym} 83500 -30330 0 0 {name=p82791 lab=_58145_/Y }
C {devices/lab_pin.sym} 83500 -30290 0 0 {name=p82792 lab=_58147_/Y }
C {devices/lab_pin.sym} 83660 -30330 0 1 {name=p82793 lab=_58148_/Y }
C {sky130_stdcells/a21oi_4.sym} 83580 -30330 0 0 {name=X_58148_ }
C {sky130_stdcells/decap_3.sym} 83580 -30160 0 0 {name=XPHY_485 }
C {devices/lab_pin.sym} 83500 -30040 0 0 {name=p82794 lab=_41397_/X }
C {devices/lab_pin.sym} 83500 -30000 0 0 {name=p82795 lab=_43371_/X }
C {devices/lab_pin.sym} 83500 -29960 0 0 {name=p82796 lab=_87454_/Q }
C {devices/lab_pin.sym} 83500 -29920 0 0 {name=p82797 lab=_43372_/X }
C {devices/lab_pin.sym} 83660 -29980 0 1 {name=p82798 lab=_43374_/X }
C {sky130_stdcells/a2bb2o_4.sym} 83580 -29980 0 0 {name=X_43374_ }
C {devices/lab_pin.sym} 83520 -29840 0 0 {name=p82799 lab=_74152_/A }
C {devices/lab_pin.sym} 83520 -29800 0 0 {name=p82800 lab=_66298_/B }
C {devices/lab_pin.sym} 83640 -29820 0 1 {name=p82801 lab=_74194_/X }
C {sky130_stdcells/and2_4.sym} 83580 -29820 0 0 {name=X_74194_ }
C {devices/lab_pin.sym} 83540 -29690 0 0 {name=p82802 lab=_40586_/A }
C {devices/lab_pin.sym} 83620 -29690 0 1 {name=p82803 lab=_40736_/A }
C {sky130_stdcells/buf_2.sym} 83580 -29690 0 0 {name=X_40586_ }
C {sky130_stdcells/decap_3.sym} 83580 -29540 0 0 {name=XPHY_496 }
C {devices/lab_pin.sym} 83500 -29410 0 0 {name=p82804 lab=_55855_/B }
C {devices/lab_pin.sym} 83500 -29370 0 0 {name=p82805 lab=_45056_/X }
C {devices/lab_pin.sym} 83500 -29330 0 0 {name=p82806 lab=_45087_/X }
C {devices/lab_pin.sym} 83660 -29370 0 1 {name=p82807 lab=_45113_/X }
C {sky130_stdcells/o21a_4.sym} 83580 -29370 0 0 {name=X_45113_ }
C {devices/lab_pin.sym} 83540 -29230 0 0 {name=p82808 lab=_42290_/A }
C {devices/lab_pin.sym} 83620 -29230 0 1 {name=p82809 lab=_42325_/X }
C {sky130_stdcells/buf_2.sym} 83580 -29230 0 0 {name=X_42325_ }
C {devices/lab_pin.sym} 83500 -29130 0 0 {name=p82810 lab=_83163_/Q }
C {devices/lab_pin.sym} 83500 -29090 0 0 {name=p82811 lab=_73079_/X }
C {devices/lab_pin.sym} 83500 -29050 0 0 {name=p82812 lab=_73144_/Y }
C {devices/lab_pin.sym} 83660 -29090 0 1 {name=p82813 lab=_73145_/X }
C {sky130_stdcells/a21o_4.sym} 83580 -29090 0 0 {name=X_73145_ }
C {devices/lab_pin.sym} 83540 -28950 0 0 {name=p82814 lab=_58696_/A }
C {devices/lab_pin.sym} 83620 -28950 0 1 {name=p82815 lab=_58079_/X }
C {sky130_stdcells/buf_2.sym} 83580 -28950 0 0 {name=X_58079_ }
C {devices/lab_pin.sym} 83540 -28830 0 0 {name=p82816 lab=_70356_/Y }
C {devices/lab_pin.sym} 83620 -28830 0 1 {name=p82817 lab=_70827_/C }
C {sky130_stdcells/buf_2.sym} 83580 -28830 0 0 {name=X_70357_ }
C {devices/lab_pin.sym} 83540 -28710 0 0 {name=p82818 lab=_80655_/Q }
C {devices/lab_pin.sym} 83620 -28710 0 1 {name=p82819 lab=_46121_/A }
C {sky130_stdcells/buf_2.sym} 83580 -28710 0 0 {name=X_46093_ }
C {devices/lab_pin.sym} 83540 -28590 0 0 {name=p82820 lab=_65607_/A }
C {devices/lab_pin.sym} 83620 -28590 0 1 {name=p82821 lab=_60110_/X }
C {sky130_stdcells/buf_2.sym} 83580 -28590 0 0 {name=X_60110_ }
C {devices/lab_pin.sym} 83500 -28490 0 0 {name=p82822 lab=_49919_/Y }
C {devices/lab_pin.sym} 83500 -28450 0 0 {name=p82823 lab=_49897_/X }
C {devices/lab_pin.sym} 83500 -28410 0 0 {name=p82824 lab=_49920_/X }
C {devices/lab_pin.sym} 83660 -28450 0 1 {name=p82825 lab=_49921_/Y }
C {sky130_stdcells/a21oi_4.sym} 83580 -28450 0 0 {name=X_49921_ }
C {devices/lab_pin.sym} 83540 -28310 0 0 {name=p82826 lab=_44895_/X }
C {devices/lab_pin.sym} 83620 -28310 0 1 {name=p82827 lab=_45044_/X }
C {sky130_stdcells/buf_2.sym} 83580 -28310 0 0 {name=X_45044_ }
C {devices/lab_pin.sym} 83500 -28220 0 0 {name=p82828 lab=_41454_/X }
C {devices/lab_pin.sym} 83500 -28180 0 0 {name=p82829 lab=_42248_/X }
C {devices/lab_pin.sym} 83500 -28140 0 0 {name=p82830 lab=_87956_/Q }
C {devices/lab_pin.sym} 83500 -28100 0 0 {name=p82831 lab=_42249_/X }
C {devices/lab_pin.sym} 83660 -28160 0 1 {name=p82832 lab=_87956_/D }
C {sky130_stdcells/a2bb2o_4.sym} 83580 -28160 0 0 {name=X_42256_ }
C {devices/lab_pin.sym} 83500 -28050 0 0 {name=p82833 lab=_61086_/X }
C {devices/lab_pin.sym} 83500 -28010 0 0 {name=p82834 lab=_72584_/C }
C {devices/lab_pin.sym} 83500 -27970 0 0 {name=p82835 lab=_60622_/D }
C {devices/lab_pin.sym} 83500 -27930 0 0 {name=p82836 lab=_61122_/B }
C {devices/lab_pin.sym} 83500 -27900 0 0 {name=p82837 lab=_61089_/Y }
C {devices/lab_pin.sym} 83660 -27970 0 1 {name=p82838 lab=_61091_/A }
C {sky130_stdcells/a41o_4.sym} 83580 -27970 0 0 {name=X_61090_ }
C {devices/lab_pin.sym} 83500 -27830 0 0 {name=p82839 lab=_73074_/X }
C {devices/lab_pin.sym} 83500 -27790 0 0 {name=p82840 lab=_73075_/Y }
C {devices/lab_pin.sym} 83500 -27750 0 0 {name=p82841 lab=_72970_/X }
C {devices/lab_pin.sym} 83660 -27790 0 1 {name=p82842 lab=_73076_/Y }
C {sky130_stdcells/a21oi_4.sym} 83580 -27790 0 0 {name=X_73076_ }
C {devices/lab_pin.sym} 83520 -27660 0 0 {name=p82843 lab=_82251_/Q }
C {devices/lab_pin.sym} 83520 -27620 0 0 {name=p82844 lab=_81963_/Q }
C {devices/lab_pin.sym} 83640 -27640 0 1 {name=p82845 lab=_77954_/B }
C {sky130_stdcells/xnor2_4.sym} 83580 -27640 0 0 {name=X_77953_ }
C {devices/lab_pin.sym} 83500 -27530 0 0 {name=p82846 lab=_70269_/X }
C {devices/lab_pin.sym} 83500 -27490 0 0 {name=p82847 lab=_74722_/A }
C {devices/lab_pin.sym} 83500 -27450 0 0 {name=p82848 lab=_70287_/X }
C {devices/lab_pin.sym} 83660 -27490 0 1 {name=p82849 lab=_83810_/D }
C {sky130_stdcells/a21o_4.sym} 83580 -27490 0 0 {name=X_70288_ }
C {devices/lab_pin.sym} 83520 -27360 0 0 {name=p82850 lab=_41207_/A }
C {devices/lab_pin.sym} 83520 -27320 0 0 {name=p82851 lab=_41223_/B }
C {devices/lab_pin.sym} 83640 -27340 0 1 {name=p82852 lab=_41207_/X }
C {sky130_stdcells/or2_4.sym} 83580 -27340 0 0 {name=X_41207_ }
C {devices/lab_pin.sym} 83540 -27210 0 0 {name=p82853 lab=_60041_/A }
C {devices/lab_pin.sym} 83620 -27210 0 1 {name=p82854 lab=_60041_/Y }
C {sky130_stdcells/inv_2.sym} 83580 -27210 0 0 {name=X_60041_ }
C {devices/lab_pin.sym} 83520 -27100 0 0 {name=p82855 lab=_72017_/X }
C {devices/lab_pin.sym} 83520 -27060 0 0 {name=p82856 lab=_53852_/B }
C {devices/lab_pin.sym} 83640 -27080 0 1 {name=p82857 lab=_72027_/Y }
C {sky130_stdcells/nand2_4.sym} 83580 -27080 0 0 {name=X_72027_ }
C {devices/lab_pin.sym} 83520 -26970 0 0 {name=p82858 lab=_76904_/A }
C {devices/lab_pin.sym} 83520 -26930 0 0 {name=p82859 lab=_81597_/Q }
C {devices/lab_pin.sym} 83520 -26890 0 0 {name=p82860 lab=_76902_/B }
C {devices/lab_pin.sym} 83640 -26930 0 1 {name=p82861 lab=_76904_/Y }
C {sky130_stdcells/nand3_4.sym} 83580 -26930 0 0 {name=X_76904_ }
C {devices/lab_pin.sym} 83500 -26810 0 0 {name=p82862 lab=_49849_/Y }
C {devices/lab_pin.sym} 83500 -26770 0 0 {name=p82863 lab=_49844_/X }
C {devices/lab_pin.sym} 83500 -26730 0 0 {name=p82864 lab=_49851_/X }
C {devices/lab_pin.sym} 83660 -26770 0 1 {name=p82865 lab=_86312_/D }
C {sky130_stdcells/a21oi_4.sym} 83580 -26770 0 0 {name=X_49852_ }
C {devices/lab_pin.sym} 83500 -26660 0 0 {name=p82866 lab=_41272_/X }
C {devices/lab_pin.sym} 83500 -26620 0 0 {name=p82867 lab=_42183_/X }
C {devices/lab_pin.sym} 83500 -26580 0 0 {name=p82868 lab=_87990_/Q }
C {devices/lab_pin.sym} 83500 -26540 0 0 {name=p82869 lab=_42184_/X }
C {devices/lab_pin.sym} 83660 -26600 0 1 {name=p82870 lab=_42187_/X }
C {sky130_stdcells/a2bb2o_4.sym} 83580 -26600 0 0 {name=X_42187_ }
C {devices/lab_pin.sym} 83520 -26460 0 0 {name=p82871 lab=_77884_/A }
C {devices/lab_pin.sym} 83520 -26420 0 0 {name=p82872 lab=_77883_/Y }
C {devices/lab_pin.sym} 83640 -26440 0 1 {name=p82873 lab=_77887_/A }
C {sky130_stdcells/xor2_4.sym} 83580 -26440 0 0 {name=X_77884_ }
C {devices/lab_pin.sym} 83520 -26320 0 0 {name=p82874 lab=_48793_/A }
C {devices/lab_pin.sym} 83520 -26280 0 0 {name=p82875 lab=_48561_/B }
C {devices/lab_pin.sym} 83640 -26300 0 1 {name=p82876 lab=_48803_/Y }
C {sky130_stdcells/nand2_4.sym} 83580 -26300 0 0 {name=X_48803_ }
C {devices/lab_pin.sym} 83500 -26190 0 0 {name=p82877 lab=_79596_/Y }
C {devices/lab_pin.sym} 83500 -26150 0 0 {name=p82878 lab=_79621_/Y }
C {devices/lab_pin.sym} 83500 -26110 0 0 {name=p82879 lab=_79622_/Y }
C {devices/lab_pin.sym} 83660 -26150 0 1 {name=p82880 lab=_79624_/B }
C {sky130_stdcells/a21oi_4.sym} 83580 -26150 0 0 {name=X_79623_ }
C {devices/lab_pin.sym} 83500 -26030 0 0 {name=p82881 lab=_41136_/X }
C {devices/lab_pin.sym} 83500 -25990 0 0 {name=p82882 lab=_81148_/Q }
C {devices/lab_pin.sym} 83500 -25950 0 0 {name=p82883 lab=_41137_/X }
C {devices/lab_pin.sym} 83660 -25990 0 1 {name=p82884 lab=_41138_/X }
C {sky130_stdcells/o21a_4.sym} 83580 -25990 0 0 {name=X_41138_ }
C {devices/lab_pin.sym} 83500 -25870 0 0 {name=p82885 lab=_81493_/Q }
C {devices/lab_pin.sym} 83500 -25830 0 0 {name=p82886 lab=_76832_/Y }
C {devices/lab_pin.sym} 83500 -25790 0 0 {name=p82887 lab=_76834_/X }
C {devices/lab_pin.sym} 83660 -25830 0 1 {name=p82888 lab=_76835_/Y }
C {sky130_stdcells/o21ai_4.sym} 83580 -25830 0 0 {name=X_76835_ }
C {devices/lab_pin.sym} 83520 -25720 0 0 {name=p82889 lab=_49779_/A }
C {devices/lab_pin.sym} 83520 -25680 0 0 {name=p82890 lab=_49802_/B }
C {devices/lab_pin.sym} 83520 -25640 0 0 {name=p82891 lab=_49789_/C }
C {devices/lab_pin.sym} 83520 -25600 0 0 {name=p82892 lab=_52997_/D }
C {devices/lab_pin.sym} 83640 -25660 0 1 {name=p82893 lab=_49783_/X }
C {sky130_stdcells/and4_4.sym} 83580 -25660 0 0 {name=X_49783_ }
C {devices/lab_pin.sym} 83520 -25520 0 0 {name=p82894 lab=_46959_/A }
C {devices/lab_pin.sym} 83520 -25480 0 0 {name=p82895 lab=_52794_/B }
C {devices/lab_pin.sym} 83640 -25500 0 1 {name=p82896 lab=_46995_/Y }
C {sky130_stdcells/nand2_4.sym} 83580 -25500 0 0 {name=X_46995_ }
C {devices/lab_pin.sym} 83520 -25390 0 0 {name=p82897 lab=_63800_/A }
C {devices/lab_pin.sym} 83520 -25350 0 0 {name=p82898 lab=_63800_/B }
C {devices/lab_pin.sym} 83520 -25310 0 0 {name=p82899 lab=_63800_/C }
C {devices/lab_pin.sym} 83640 -25350 0 1 {name=p82900 lab=_63800_/Y }
C {sky130_stdcells/nor3_4.sym} 83580 -25350 0 0 {name=X_63800_ }
C {devices/lab_pin.sym} 83540 -25210 0 0 {name=p82901 lab=_48734_/A }
C {devices/lab_pin.sym} 83620 -25210 0 1 {name=p82902 lab=_48734_/X }
C {sky130_stdcells/buf_2.sym} 83580 -25210 0 0 {name=X_48734_ }
C {devices/lab_pin.sym} 83520 -25100 0 0 {name=p82903 lab=_79554_/A }
C {devices/lab_pin.sym} 83520 -25060 0 0 {name=p82904 lab=_79554_/B }
C {devices/lab_pin.sym} 83640 -25080 0 1 {name=p82905 lab=_79555_/C }
C {sky130_stdcells/nand2_4.sym} 83580 -25080 0 0 {name=X_79554_ }
C {devices/lab_pin.sym} 83540 -24950 0 0 {name=p82906 lab=_44207_/A }
C {devices/lab_pin.sym} 83620 -24950 0 1 {name=p82907 lab=_45947_/B }
C {sky130_stdcells/buf_2.sym} 83580 -24950 0 0 {name=X_45946_ }
C {devices/lab_pin.sym} 83500 -24850 0 0 {name=p82908 lab=_41061_/X }
C {devices/lab_pin.sym} 83500 -24810 0 0 {name=p82909 lab=_82281_/Q }
C {devices/lab_pin.sym} 83500 -24770 0 0 {name=p82910 lab=_41068_/X }
C {devices/lab_pin.sym} 83660 -24810 0 1 {name=p82911 lab=_41069_/Y }
C {sky130_stdcells/o21ai_4.sym} 83580 -24810 0 0 {name=X_41069_ }
C {devices/lab_pin.sym} 83520 -24680 0 0 {name=p82912 lab=_64680_/A }
C {devices/lab_pin.sym} 83520 -24640 0 0 {name=p82913 lab=_64780_/B }
C {devices/lab_pin.sym} 83640 -24660 0 1 {name=p82914 lab=_64780_/X }
C {sky130_stdcells/and2_4.sym} 83580 -24660 0 0 {name=X_64780_ }
C {devices/lab_pin.sym} 83520 -24540 0 0 {name=p82915 lab=_81695_/Q }
C {devices/lab_pin.sym} 83520 -24500 0 0 {name=p82916 lab=_76766_/B }
C {devices/lab_pin.sym} 83640 -24520 0 1 {name=p82917 lab=_76766_/Y }
C {sky130_stdcells/xnor2_4.sym} 83580 -24520 0 0 {name=X_76766_ }
C {devices/lab_pin.sym} 83540 -24390 0 0 {name=p82918 lab=_83248_/Q }
C {devices/lab_pin.sym} 83620 -24390 0 1 {name=p82919 lab=_63573_/A }
C {sky130_stdcells/inv_2.sym} 83580 -24390 0 0 {name=X_61992_ }
C {devices/lab_pin.sym} 83520 -24280 0 0 {name=p82920 lab=_73978_/A }
C {devices/lab_pin.sym} 83520 -24240 0 0 {name=p82921 lab=_73977_/X }
C {devices/lab_pin.sym} 83640 -24260 0 1 {name=p82922 lab=_73979_/B }
C {sky130_stdcells/nand2_4.sym} 83580 -24260 0 0 {name=X_73978_ }
C {devices/lab_pin.sym} 83520 -24150 0 0 {name=p82923 lab=_78501_/Y }
C {devices/lab_pin.sym} 83520 -24110 0 0 {name=p82924 lab=_78505_/B }
C {devices/lab_pin.sym} 83520 -24070 0 0 {name=p82925 lab=_78505_/C }
C {devices/lab_pin.sym} 83640 -24110 0 1 {name=p82926 lab=_78505_/X }
C {sky130_stdcells/or3_4.sym} 83580 -24110 0 0 {name=X_78505_ }
C {devices/lab_pin.sym} 83520 -24000 0 0 {name=p82927 lab=_62195_/A }
C {devices/lab_pin.sym} 83520 -23960 0 0 {name=p82928 lab=_64192_/B }
C {devices/lab_pin.sym} 83520 -23920 0 0 {name=p82929 lab=_64192_/C }
C {devices/lab_pin.sym} 83520 -23880 0 0 {name=p82930 lab=_63731_/D }
C {devices/lab_pin.sym} 83640 -23940 0 1 {name=p82931 lab=_63731_/Y }
C {sky130_stdcells/nand4_4.sym} 83580 -23940 0 0 {name=X_63731_ }
C {devices/lab_pin.sym} 83520 -23800 0 0 {name=p82932 lab=_75704_/B }
C {devices/lab_pin.sym} 83520 -23760 0 0 {name=p82933 lab=_75716_/X }
C {devices/lab_pin.sym} 83640 -23780 0 1 {name=p82934 lab=_75722_/A }
C {sky130_stdcells/nand2_4.sym} 83580 -23780 0 0 {name=X_75717_ }
C {devices/lab_pin.sym} 83500 -23670 0 0 {name=p82935 lab=_48652_/X }
C {devices/lab_pin.sym} 83500 -23630 0 0 {name=p82936 lab=_82342_/Q }
C {devices/lab_pin.sym} 83500 -23590 0 0 {name=p82937 lab=_48664_/Y }
C {devices/lab_pin.sym} 83660 -23630 0 1 {name=p82938 lab=_48666_/A }
C {sky130_stdcells/o21ai_4.sym} 83580 -23630 0 0 {name=X_48665_ }
C {devices/lab_pin.sym} 83540 -23490 0 0 {name=p82939 lab=_64067_/A }
C {devices/lab_pin.sym} 83620 -23490 0 1 {name=p82940 lab=_63781_/B }
C {sky130_stdcells/buf_2.sym} 83580 -23490 0 0 {name=X_60943_ }
C {devices/lab_pin.sym} 83520 -23380 0 0 {name=p82941 lab=_72929_/A }
C {devices/lab_pin.sym} 83520 -23340 0 0 {name=p82942 lab=_65519_/B }
C {devices/lab_pin.sym} 83640 -23360 0 1 {name=p82943 lab=_72929_/X }
C {sky130_stdcells/and2_4.sym} 83580 -23360 0 0 {name=X_72929_ }
C {devices/lab_pin.sym} 83500 -23260 0 0 {name=p82944 lab=_79484_/B }
C {devices/lab_pin.sym} 83500 -23220 0 0 {name=p82945 lab=_79484_/A }
C {devices/lab_pin.sym} 83500 -23180 0 0 {name=p82946 lab=_79470_/A }
C {devices/lab_pin.sym} 83500 -23140 0 0 {name=p82947 lab=_79470_/B }
C {devices/lab_pin.sym} 83660 -23200 0 1 {name=p82948 lab=_79486_/C }
C {sky130_stdcells/a211o_4.sym} 83580 -23200 0 0 {name=X_79485_ }
C {devices/lab_pin.sym} 83500 -23070 0 0 {name=p82949 lab=_45874_/X }
C {devices/lab_pin.sym} 83500 -23030 0 0 {name=p82950 lab=_45876_/Y }
C {devices/lab_pin.sym} 83500 -22990 0 0 {name=p82951 lab=_44972_/X }
C {devices/lab_pin.sym} 83660 -23030 0 1 {name=p82952 lab=_45877_/Y }
C {sky130_stdcells/a21oi_4.sym} 83580 -23030 0 0 {name=X_45877_ }
C {devices/lab_pin.sym} 83520 -22900 0 0 {name=p82953 lab=_76709_/B }
C {devices/lab_pin.sym} 83520 -22860 0 0 {name=p82954 lab=_76696_/X }
C {devices/lab_pin.sym} 83640 -22880 0 1 {name=p82955 lab=_76697_/Y }
C {sky130_stdcells/xnor2_4.sym} 83580 -22880 0 0 {name=X_76697_ }
C {devices/lab_pin.sym} 83540 -22750 0 0 {name=p82956 lab=_47616_/A }
C {devices/lab_pin.sym} 83620 -22750 0 1 {name=p82957 lab=_53151_/D }
C {sky130_stdcells/buf_2.sym} 83580 -22750 0 0 {name=X_47616_ }
C {devices/lab_pin.sym} 83540 -22630 0 0 {name=p82958 lab=_84121_/Q }
C {devices/lab_pin.sym} 83620 -22630 0 1 {name=p82959 lab=_66450_/Y }
C {sky130_stdcells/inv_2.sym} 83580 -22630 0 0 {name=X_66450_ }
C {devices/lab_pin.sym} 83500 -22530 0 0 {name=p82960 lab=_78418_/B }
C {devices/lab_pin.sym} 83500 -22490 0 0 {name=p82961 lab=_78418_/A }
C {devices/lab_pin.sym} 83500 -22450 0 0 {name=p82962 lab=_78435_/Y }
C {devices/lab_pin.sym} 83660 -22490 0 1 {name=p82963 lab=_78436_/Y }
C {sky130_stdcells/a21boi_4.sym} 83580 -22490 0 0 {name=X_78436_ }
C {devices/lab_pin.sym} 83540 -22350 0 0 {name=p82964 lab=_44827_/Y }
C {devices/lab_pin.sym} 83620 -22350 0 1 {name=p82965 lab=_86933_/D }
C {sky130_stdcells/inv_2.sym} 83580 -22350 0 0 {name=X_44828_ }
C {devices/lab_pin.sym} 83520 -22240 0 0 {name=p82966 lab=_81002_/Q }
C {devices/lab_pin.sym} 83520 -22200 0 0 {name=p82967 lab=_75648_/B }
C {devices/lab_pin.sym} 83640 -22220 0 1 {name=p82968 lab=_75648_/X }
C {sky130_stdcells/xor2_4.sym} 83580 -22220 0 0 {name=X_75648_ }
C {devices/lab_pin.sym} 83500 -22130 0 0 {name=p82969 lab=_63624_/X }
C {devices/lab_pin.sym} 83500 -22090 0 0 {name=p82970 lab=_63655_/X }
C {devices/lab_pin.sym} 83500 -22050 0 0 {name=p82971 lab=_63656_/X }
C {devices/lab_pin.sym} 83500 -22010 0 0 {name=p82972 lab=_63660_/X }
C {devices/lab_pin.sym} 83500 -21970 0 0 {name=p82973 lab=_63661_/Y }
C {devices/lab_pin.sym} 83660 -22050 0 1 {name=p82974 lab=_63662_/Y }
C {sky130_stdcells/o41ai_4.sym} 83580 -22050 0 0 {name=X_63662_ }
C {devices/lab_pin.sym} 83540 -21890 0 0 {name=p82975 lab=_48904_/A }
C {devices/lab_pin.sym} 83620 -21890 0 1 {name=p82976 lab=_48959_/B }
C {sky130_stdcells/buf_2.sym} 83580 -21890 0 0 {name=X_48596_ }
C {devices/lab_pin.sym} 83540 -21770 0 0 {name=p82977 lab=_60865_/B }
C {devices/lab_pin.sym} 83620 -21770 0 1 {name=p82978 lab=_64172_/D }
C {sky130_stdcells/buf_2.sym} 83580 -21770 0 0 {name=X_60874_ }
C {devices/lab_pin.sym} 83520 -21660 0 0 {name=p82979 lab=_65401_/A }
C {devices/lab_pin.sym} 83520 -21620 0 0 {name=p82980 lab=_85826_/Q }
C {devices/lab_pin.sym} 83640 -21640 0 1 {name=p82981 lab=_65401_/X }
C {sky130_stdcells/and2_4.sym} 83580 -21640 0 0 {name=X_65401_ }
C {devices/lab_pin.sym} 83520 -21540 0 0 {name=p82982 lab=_61675_/B }
C {devices/lab_pin.sym} 83520 -21500 0 0 {name=p82983 lab=_62309_/B }
C {devices/lab_pin.sym} 83520 -21460 0 0 {name=p82984 lab=_62309_/C }
C {devices/lab_pin.sym} 83520 -21420 0 0 {name=p82985 lab=_62225_/X }
C {devices/lab_pin.sym} 83640 -21480 0 1 {name=p82986 lab=_62613_/Y }
C {sky130_stdcells/nand4_4.sym} 83580 -21480 0 0 {name=X_62613_ }
C {devices/lab_pin.sym} 83540 -21330 0 0 {name=p82987 lab=_47547_/A }
C {devices/lab_pin.sym} 83620 -21330 0 1 {name=p82988 lab=_47548_/A }
C {sky130_stdcells/inv_2.sym} 83580 -21330 0 0 {name=X_47547_ }
C {devices/lab_pin.sym} 83520 -21230 0 0 {name=p82989 lab=_65962_/X }
C {devices/lab_pin.sym} 83520 -21190 0 0 {name=p82990 lab=_65833_/B }
C {devices/lab_pin.sym} 83520 -21150 0 0 {name=p82991 lab=_65966_/X }
C {devices/lab_pin.sym} 83640 -21190 0 1 {name=p82992 lab=_66381_/Y }
C {sky130_stdcells/nand3_4.sym} 83580 -21190 0 0 {name=X_66381_ }
C {devices/lab_pin.sym} 83540 -21050 0 0 {name=p82993 lab=_78353_/B }
C {devices/lab_pin.sym} 83620 -21050 0 1 {name=p82994 lab=_78367_/Y }
C {sky130_stdcells/inv_2.sym} 83580 -21050 0 0 {name=X_78367_ }
C {devices/lab_pin.sym} 83500 -20970 0 0 {name=p82995 lab=_44740_/X }
C {devices/lab_pin.sym} 83500 -20930 0 0 {name=p82996 lab=_44741_/X }
C {devices/lab_pin.sym} 83500 -20890 0 0 {name=p82997 lab=_41316_/A }
C {devices/lab_pin.sym} 83500 -20850 0 0 {name=p82998 lab=_86969_/Q }
C {devices/lab_pin.sym} 83500 -20810 0 0 {name=p82999 lab=_44742_/X }
C {devices/lab_pin.sym} 83660 -20890 0 1 {name=p83000 lab=_44760_/A }
C {sky130_stdcells/o32ai_4.sym} 83580 -20890 0 0 {name=X_44759_ }
C {devices/lab_pin.sym} 83500 -20750 0 0 {name=p83001 lab=_63589_/Y }
C {devices/lab_pin.sym} 83500 -20710 0 0 {name=p83002 lab=_63578_/X }
C {devices/lab_pin.sym} 83500 -20670 0 0 {name=p83003 lab=_63592_/Y }
C {devices/lab_pin.sym} 83660 -20710 0 1 {name=p83004 lab=_63593_/Y }
C {sky130_stdcells/a21oi_4.sym} 83580 -20710 0 0 {name=X_63593_ }
C {devices/lab_pin.sym} 83540 -20570 0 0 {name=p83005 lab=_81107_/Q }
C {devices/lab_pin.sym} 83620 -20570 0 1 {name=p83006 lab=_75579_/Y }
C {sky130_stdcells/inv_2.sym} 83580 -20570 0 0 {name=X_75579_ }
C {devices/lab_pin.sym} 83540 -20450 0 0 {name=p83007 lab=_68120_/A }
C {devices/lab_pin.sym} 83620 -20450 0 1 {name=p83008 lab=_68120_/X }
C {sky130_stdcells/buf_2.sym} 83580 -20450 0 0 {name=X_68120_ }
C {devices/lab_pin.sym} 83500 -20360 0 0 {name=p83009 lab=_65252_/X }
C {devices/lab_pin.sym} 83500 -20320 0 0 {name=p83010 lab=_83285_/Q }
C {devices/lab_pin.sym} 83500 -20280 0 0 {name=p83011 lab=_65230_/X }
C {devices/lab_pin.sym} 83500 -20240 0 0 {name=p83012 lab=_65331_/X }
C {devices/lab_pin.sym} 83660 -20300 0 1 {name=p83013 lab=_65332_/X }
C {sky130_stdcells/a211o_4.sym} 83580 -20300 0 0 {name=X_65332_ }
C {devices/lab_pin.sym} 83520 -20160 0 0 {name=p83014 lab=_77318_/A }
C {devices/lab_pin.sym} 83520 -20120 0 0 {name=p83015 lab=_77318_/B }
C {devices/lab_pin.sym} 83640 -20140 0 1 {name=p83016 lab=_77318_/Y }
C {sky130_stdcells/nand2_4.sym} 83580 -20140 0 0 {name=X_77318_ }
C {devices/lab_pin.sym} 83540 -20010 0 0 {name=p83017 lab=_62544_/A }
C {devices/lab_pin.sym} 83620 -20010 0 1 {name=p83018 lab=_62544_/Y }
C {sky130_stdcells/inv_2.sym} 83580 -20010 0 0 {name=X_62544_ }
C {devices/lab_pin.sym} 83540 -19890 0 0 {name=p83019 lab=_47619_/A }
C {devices/lab_pin.sym} 83620 -19890 0 1 {name=p83020 lab=_47478_/X }
C {sky130_stdcells/buf_2.sym} 83580 -19890 0 0 {name=X_47478_ }
C {devices/lab_pin.sym} 83520 -19780 0 0 {name=p83021 lab=_78298_/A }
C {devices/lab_pin.sym} 83520 -19740 0 0 {name=p83022 lab=_78298_/B }
C {devices/lab_pin.sym} 83640 -19760 0 1 {name=p83023 lab=_78299_/B }
C {sky130_stdcells/xor2_4.sym} 83580 -19760 0 0 {name=X_78298_ }
C {devices/lab_pin.sym} 83500 -19650 0 0 {name=p83024 lab=_49213_/Y }
C {devices/lab_pin.sym} 83500 -19610 0 0 {name=p83025 lab=_49214_/X }
C {devices/lab_pin.sym} 83500 -19570 0 0 {name=p83026 lab=_49216_/Y }
C {devices/lab_pin.sym} 83660 -19610 0 1 {name=p83027 lab=_49217_/Y }
C {sky130_stdcells/a21boi_4.sym} 83580 -19610 0 0 {name=X_49217_ }
C {devices/lab_pin.sym} 83520 -19480 0 0 {name=p83028 lab=_68403_/A }
C {devices/lab_pin.sym} 83520 -19440 0 0 {name=p83029 lab=_68051_/B }
C {devices/lab_pin.sym} 83640 -19460 0 1 {name=p83030 lab=_68051_/X }
C {sky130_stdcells/and2_4.sym} 83580 -19460 0 0 {name=X_68051_ }
C {devices/lab_pin.sym} 83500 -19350 0 0 {name=p83031 lab=_46422_/Y }
C {devices/lab_pin.sym} 83500 -19310 0 0 {name=p83032 lab=_46300_/X }
C {devices/lab_pin.sym} 83500 -19270 0 0 {name=p83033 lab=_46428_/X }
C {devices/lab_pin.sym} 83660 -19310 0 1 {name=p83034 lab=_46429_/Y }
C {sky130_stdcells/a21oi_4.sym} 83580 -19310 0 0 {name=X_46429_ }
C {devices/lab_pin.sym} 83540 -19170 0 0 {name=p83035 lab=_65782_/A }
C {devices/lab_pin.sym} 83620 -19170 0 1 {name=p83036 lab=_65289_/A }
C {sky130_stdcells/buf_2.sym} 83580 -19170 0 0 {name=X_65263_ }
C {devices/lab_pin.sym} 83520 -19060 0 0 {name=p83037 lab=_77249_/A }
C {devices/lab_pin.sym} 83520 -19020 0 0 {name=p83038 lab=_82084_/D }
C {devices/lab_pin.sym} 83640 -19040 0 1 {name=p83039 lab=_77250_/A }
C {sky130_stdcells/nor2_4.sym} 83580 -19040 0 0 {name=X_77249_ }
C {devices/lab_pin.sym} 83540 -18910 0 0 {name=p83040 lab=_62475_/A }
C {devices/lab_pin.sym} 83620 -18910 0 1 {name=p83041 lab=_62475_/X }
C {sky130_stdcells/buf_2.sym} 83580 -18910 0 0 {name=X_62475_ }
C {devices/lab_pin.sym} 83540 -18790 0 0 {name=p83042 lab=_66647_/A }
C {devices/lab_pin.sym} 83620 -18790 0 1 {name=p83043 lab=_67028_/A }
C {sky130_stdcells/buf_2.sym} 83580 -18790 0 0 {name=X_67002_ }
C {devices/lab_pin.sym} 83500 -18710 0 0 {name=p83044 lab=_64202_/Y }
C {devices/lab_pin.sym} 83500 -18670 0 0 {name=p83045 lab=_64210_/Y }
C {devices/lab_pin.sym} 83500 -18630 0 0 {name=p83046 lab=_64212_/Y }
C {devices/lab_pin.sym} 83500 -18590 0 0 {name=p83047 lab=_61323_/A }
C {devices/lab_pin.sym} 83500 -18550 0 0 {name=p83048 lab=_64213_/X }
C {devices/lab_pin.sym} 83660 -18630 0 1 {name=p83049 lab=_64214_/Y }
C {sky130_stdcells/o32ai_4.sym} 83580 -18630 0 0 {name=X_64214_ }
C {devices/lab_pin.sym} 83520 -18480 0 0 {name=p83050 lab=_49148_/A }
C {devices/lab_pin.sym} 83520 -18440 0 0 {name=p83051 lab=_49161_/B }
C {devices/lab_pin.sym} 83640 -18460 0 1 {name=p83052 lab=_49148_/Y }
C {sky130_stdcells/nor2_4.sym} 83580 -18460 0 0 {name=X_49148_ }
C {devices/lab_pin.sym} 83500 -18350 0 0 {name=p83053 lab=_61424_/X }
C {devices/lab_pin.sym} 83500 -18310 0 0 {name=p83054 lab=_61394_/X }
C {devices/lab_pin.sym} 83500 -18270 0 0 {name=p83055 lab=_61425_/Y }
C {devices/lab_pin.sym} 83660 -18310 0 1 {name=p83056 lab=_61426_/Y }
C {sky130_stdcells/a21oi_4.sym} 83580 -18310 0 0 {name=X_61426_ }
C {devices/lab_pin.sym} 83520 -18190 0 0 {name=p83057 lab=_80251_/A }
C {devices/lab_pin.sym} 83520 -18150 0 0 {name=p83058 lab=_80250_/X }
C {devices/lab_pin.sym} 83520 -18110 0 0 {name=p83059 lab=_80257_/Y }
C {devices/lab_pin.sym} 83640 -18150 0 1 {name=p83060 lab=_80261_/B }
C {sky130_stdcells/nand3_4.sym} 83580 -18150 0 0 {name=X_80260_ }
C {devices/lab_pin.sym} 83540 -18010 0 0 {name=p83061 lab=_65680_/A }
C {devices/lab_pin.sym} 83620 -18010 0 1 {name=p83062 lab=_65529_/A }
C {sky130_stdcells/buf_2.sym} 83580 -18010 0 0 {name=X_65194_ }
C {devices/lab_pin.sym} 83520 -17920 0 0 {name=p83063 lab=_63312_/B }
C {devices/lab_pin.sym} 83520 -17880 0 0 {name=p83064 lab=_64145_/B }
C {devices/lab_pin.sym} 83520 -17840 0 0 {name=p83065 lab=_64179_/C }
C {devices/lab_pin.sym} 83520 -17800 0 0 {name=p83066 lab=_64179_/D }
C {devices/lab_pin.sym} 83640 -17860 0 1 {name=p83067 lab=_64145_/Y }
C {sky130_stdcells/nand4_4.sym} 83580 -17860 0 0 {name=X_64145_ }
C {devices/lab_pin.sym} 83520 -17730 0 0 {name=p83068 lab=_61377_/A }
C {devices/lab_pin.sym} 83520 -17690 0 0 {name=p83069 lab=_61356_/X }
C {devices/lab_pin.sym} 83520 -17650 0 0 {name=p83070 lab=_61377_/C }
C {devices/lab_pin.sym} 83640 -17690 0 1 {name=p83071 lab=_61357_/Y }
C {sky130_stdcells/nand3_4.sym} 83580 -17690 0 0 {name=X_61357_ }
C {devices/lab_pin.sym} 83540 -17550 0 0 {name=p83072 lab=_49079_/A }
C {devices/lab_pin.sym} 83620 -17550 0 1 {name=p83073 lab=_53879_/B }
C {sky130_stdcells/buf_2.sym} 83580 -17550 0 0 {name=X_49079_ }
C {devices/lab_pin.sym} 83520 -17440 0 0 {name=p83074 lab=_80198_/B }
C {devices/lab_pin.sym} 83520 -17400 0 0 {name=p83075 lab=_80190_/X }
C {devices/lab_pin.sym} 83640 -17420 0 1 {name=p83076 lab=_80191_/Y }
C {sky130_stdcells/xnor2_4.sym} 83580 -17420 0 0 {name=X_80191_ }
C {devices/lab_pin.sym} 83520 -17320 0 0 {name=p83077 lab=_51115_/A }
C {devices/lab_pin.sym} 83520 -17280 0 0 {name=p83078 lab=_51115_/B }
C {devices/lab_pin.sym} 83520 -17240 0 0 {name=p83079 lab=_51110_/C }
C {devices/lab_pin.sym} 83520 -17200 0 0 {name=p83080 lab=_52801_/D }
C {devices/lab_pin.sym} 83640 -17260 0 1 {name=p83081 lab=_51110_/X }
C {sky130_stdcells/and4_4.sym} 83580 -17260 0 0 {name=X_51110_ }
C {devices/lab_pin.sym} 83540 -17110 0 0 {name=p83082 lab=_62737_/A }
C {devices/lab_pin.sym} 83620 -17110 0 1 {name=p83083 lab=_60309_/C }
C {sky130_stdcells/buf_2.sym} 83580 -17110 0 0 {name=X_60308_ }
C {devices/lab_pin.sym} 83540 -16990 0 0 {name=p83084 lab=_51922_/X }
C {devices/lab_pin.sym} 83620 -16990 0 1 {name=p83085 lab=_52100_/A }
C {sky130_stdcells/buf_2.sym} 83580 -16990 0 0 {name=X_52090_ }
C {devices/lab_pin.sym} 83500 -16890 0 0 {name=p83086 lab=_83954_/Q }
C {devices/lab_pin.sym} 83500 -16850 0 0 {name=p83087 lab=_68838_/X }
C {devices/lab_pin.sym} 83500 -16810 0 0 {name=p83088 lab=_68952_/X }
C {devices/lab_pin.sym} 83660 -16850 0 1 {name=p83089 lab=_83954_/D }
C {sky130_stdcells/a21bo_4.sym} 83580 -16850 0 0 {name=X_68953_ }
C {devices/lab_pin.sym} 83500 -16740 0 0 {name=p83090 lab=_60996_/Y }
C {devices/lab_pin.sym} 83500 -16700 0 0 {name=p83091 lab=_60934_/X }
C {devices/lab_pin.sym} 83500 -16660 0 0 {name=p83092 lab=_64184_/A }
C {devices/lab_pin.sym} 83500 -16620 0 0 {name=p83093 lab=_64184_/C }
C {devices/lab_pin.sym} 83660 -16680 0 1 {name=p83094 lab=_64076_/Y }
C {sky130_stdcells/a22oi_4.sym} 83580 -16680 0 0 {name=X_64076_ }
C {devices/lab_pin.sym} 83540 -16530 0 0 {name=p83095 lab=_61306_/A }
C {devices/lab_pin.sym} 83620 -16530 0 1 {name=p83096 lab=_72514_/A }
C {sky130_stdcells/inv_2.sym} 83580 -16530 0 0 {name=X_61288_ }
C {devices/lab_pin.sym} 83520 -16440 0 0 {name=p83097 lab=_51029_/A }
C {devices/lab_pin.sym} 83520 -16400 0 0 {name=p83098 lab=_51045_/B }
C {devices/lab_pin.sym} 83520 -16360 0 0 {name=p83099 lab=_51045_/C }
C {devices/lab_pin.sym} 83520 -16320 0 0 {name=p83100 lab=_52730_/D }
C {devices/lab_pin.sym} 83640 -16380 0 1 {name=p83101 lab=_51041_/X }
C {sky130_stdcells/and4_4.sym} 83580 -16380 0 0 {name=X_51041_ }
C {devices/lab_pin.sym} 83500 -16260 0 0 {name=p83102 lab=_87451_/Q }
C {devices/lab_pin.sym} 83500 -16220 0 0 {name=p83103 lab=_67834_/X }
C {devices/lab_pin.sym} 83500 -16180 0 0 {name=p83104 lab=_67835_/X }
C {devices/lab_pin.sym} 83500 -16140 0 0 {name=p83105 lab=_67903_/X }
C {devices/lab_pin.sym} 83660 -16200 0 1 {name=p83106 lab=_67904_/X }
C {sky130_stdcells/a211o_4.sym} 83580 -16200 0 0 {name=X_67904_ }
C {devices/lab_pin.sym} 83540 -16050 0 0 {name=p83107 lab=_60503_/X }
C {devices/lab_pin.sym} 83620 -16050 0 1 {name=p83108 lab=_63039_/A }
C {sky130_stdcells/buf_2.sym} 83580 -16050 0 0 {name=X_63027_ }
C {devices/lab_pin.sym} 83520 -15950 0 0 {name=p83109 lab=_60239_/A }
C {devices/lab_pin.sym} 83520 -15910 0 0 {name=p83110 lab=_60239_/B }
C {devices/lab_pin.sym} 83520 -15870 0 0 {name=p83111 lab=_60189_/A }
C {devices/lab_pin.sym} 83640 -15910 0 1 {name=p83112 lab=_60239_/X }
C {sky130_stdcells/and3_4.sym} 83580 -15910 0 0 {name=X_60239_ }
C {devices/lab_pin.sym} 83490 -15770 0 0 {name=p83113 lab=_81134_/CLK }
C {devices/lab_pin.sym} 83490 -15750 0 0 {name=p83114 lab=_83950_/D }
C {devices/lab_pin.sym} 83670 -15770 0 1 {name=p83115 lab=_80806_/D }
C {sky130_stdcells/dfxtp_4.sym} 83580 -15760 0 0 {name=X_83950_ }
C {devices/lab_pin.sym} 83540 -15630 0 0 {name=p83116 lab=_69088_/A }
C {devices/lab_pin.sym} 83620 -15630 0 1 {name=p83117 lab=_68884_/X }
C {sky130_stdcells/buf_2.sym} 83580 -15630 0 0 {name=X_68884_ }
C {devices/lab_pin.sym} 83490 -15510 0 0 {name=p83118 lab=_82896_/CLK }
C {devices/lab_pin.sym} 83490 -15490 0 0 {name=p83119 lab=_78218_/B }
C {devices/lab_pin.sym} 83670 -15510 0 1 {name=p83120 lab=_82901_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -15500 0 0 {name=X_82901_ }
C {devices/lab_pin.sym} 83540 -15370 0 0 {name=p83121 lab=_67359_/X }
C {devices/lab_pin.sym} 83620 -15370 0 1 {name=p83122 lab=_67835_/X }
C {sky130_stdcells/buf_2.sym} 83580 -15370 0 0 {name=X_67835_ }
C {devices/lab_pin.sym} 83490 -15250 0 0 {name=p83123 lab=_82558_/CLK }
C {devices/lab_pin.sym} 83490 -15230 0 0 {name=p83124 lab=_69980_/X }
C {devices/lab_pin.sym} 83670 -15250 0 1 {name=p83125 lab=_83881_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -15240 0 0 {name=X_83881_ }
C {devices/lab_pin.sym} 83520 -15120 0 0 {name=p83126 lab=_54790_/A }
C {devices/lab_pin.sym} 83520 -15080 0 0 {name=p83127 lab=_47543_/Y }
C {devices/lab_pin.sym} 83640 -15100 0 1 {name=p83128 lab=_54800_/Y }
C {sky130_stdcells/nand2_4.sym} 83580 -15100 0 0 {name=X_54800_ }
C {devices/lab_pin.sym} 83490 -14970 0 0 {name=p83129 lab=_86549_/CLK }
C {devices/lab_pin.sym} 83490 -14950 0 0 {name=p83130 lab=_53526_/Y }
C {devices/lab_pin.sym} 83670 -14970 0 1 {name=p83131 lab=_85620_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -14960 0 0 {name=X_85620_ }
C {devices/lab_pin.sym} 83490 -14830 0 0 {name=p83132 lab=_82833_/CLK }
C {devices/lab_pin.sym} 83490 -14810 0 0 {name=p83133 lab=_82832_/D }
C {devices/lab_pin.sym} 83670 -14830 0 1 {name=p83134 lab=_82800_/D }
C {sky130_stdcells/dfxtp_4.sym} 83580 -14820 0 0 {name=X_82832_ }
C {devices/lab_pin.sym} 83500 -14720 0 0 {name=p83135 lab=_45257_/A }
C {devices/lab_pin.sym} 83500 -14680 0 0 {name=p83136 lab=_55306_/X }
C {devices/lab_pin.sym} 83500 -14640 0 0 {name=p83137 lab=_55172_/X }
C {devices/lab_pin.sym} 83500 -14600 0 0 {name=p83138 lab=_55779_/X }
C {devices/lab_pin.sym} 83660 -14660 0 1 {name=p83139 lab=_55780_/X }
C {sky130_stdcells/a211o_4.sym} 83580 -14660 0 0 {name=X_55780_ }
C {devices/lab_pin.sym} 83500 -14530 0 0 {name=p83140 lab=_67763_/X }
C {devices/lab_pin.sym} 83500 -14490 0 0 {name=p83141 lab=_67765_/X }
C {devices/lab_pin.sym} 83500 -14450 0 0 {name=p83142 lab=_67742_/X }
C {devices/lab_pin.sym} 83660 -14490 0 1 {name=p83143 lab=_67766_/X }
C {sky130_stdcells/a21o_4.sym} 83580 -14490 0 0 {name=X_67766_ }
C {devices/lab_pin.sym} 83500 -14370 0 0 {name=p83144 lab=_85717_/Q }
C {devices/lab_pin.sym} 83500 -14330 0 0 {name=p83145 lab=_52984_/X }
C {devices/lab_pin.sym} 83500 -14290 0 0 {name=p83146 lab=_52991_/Y }
C {devices/lab_pin.sym} 83660 -14330 0 1 {name=p83147 lab=_52992_/Y }
C {sky130_stdcells/o21ai_4.sym} 83580 -14330 0 0 {name=X_52992_ }
C {devices/lab_pin.sym} 83500 -14210 0 0 {name=p83148 lab=_64975_/X }
C {devices/lab_pin.sym} 83500 -14170 0 0 {name=p83149 lab=_64977_/X }
C {devices/lab_pin.sym} 83500 -14130 0 0 {name=p83150 lab=_64574_/X }
C {devices/lab_pin.sym} 83660 -14170 0 1 {name=p83151 lab=_64978_/X }
C {sky130_stdcells/a21o_4.sym} 83580 -14170 0 0 {name=X_64978_ }
C {devices/lab_pin.sym} 83540 -14030 0 0 {name=p83152 lab=_69746_/A }
C {devices/lab_pin.sym} 83620 -14030 0 1 {name=p83153 lab=_69505_/X }
C {sky130_stdcells/buf_2.sym} 83580 -14030 0 0 {name=X_69505_ }
C {devices/lab_pin.sym} 83540 -13910 0 0 {name=p83154 lab=_54758_/A }
C {devices/lab_pin.sym} 83620 -13910 0 1 {name=p83155 lab=_54731_/X }
C {sky130_stdcells/buf_2.sym} 83580 -13910 0 0 {name=X_54731_ }
C {devices/lab_pin.sym} 83540 -13790 0 0 {name=p83156 lab=_66717_/A }
C {devices/lab_pin.sym} 83620 -13790 0 1 {name=p83157 lab=_66717_/X }
C {sky130_stdcells/buf_2.sym} 83580 -13790 0 0 {name=X_66717_ }
C {devices/lab_pin.sym} 83490 -13670 0 0 {name=p83158 lab=_86256_/CLK }
C {devices/lab_pin.sym} 83490 -13650 0 0 {name=p83159 lab=_53876_/Y }
C {devices/lab_pin.sym} 83670 -13670 0 1 {name=p83160 lab=_85551_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -13660 0 0 {name=X_85551_ }
C {devices/lab_pin.sym} 83540 -13530 0 0 {name=p83161 lab=_52322_/A }
C {devices/lab_pin.sym} 83620 -13530 0 1 {name=p83162 lab=_52177_/A }
C {sky130_stdcells/buf_2.sym} 83580 -13530 0 0 {name=X_51943_ }
C {devices/lab_pin.sym} 83540 -13410 0 0 {name=p83163 lab=_63849_/A }
C {devices/lab_pin.sym} 83620 -13410 0 1 {name=p83164 lab=_63960_/B }
C {sky130_stdcells/buf_2.sym} 83580 -13410 0 0 {name=X_63929_ }
C {devices/lab_pin.sym} 83490 -13290 0 0 {name=p83165 lab=_82769_/CLK }
C {devices/lab_pin.sym} 83490 -13270 0 0 {name=p83166 lab=_82763_/D }
C {devices/lab_pin.sym} 83670 -13290 0 1 {name=p83167 lab=_82955_/D }
C {sky130_stdcells/dfxtp_4.sym} 83580 -13280 0 0 {name=X_82763_ }
C {devices/lab_pin.sym} 83500 -13180 0 0 {name=p83168 lab=_87152_/Q }
C {devices/lab_pin.sym} 83500 -13140 0 0 {name=p83169 lab=_67670_/X }
C {devices/lab_pin.sym} 83500 -13100 0 0 {name=p83170 lab=_67671_/X }
C {devices/lab_pin.sym} 83500 -13060 0 0 {name=p83171 lab=_67696_/X }
C {devices/lab_pin.sym} 83660 -13120 0 1 {name=p83172 lab=_67698_/B }
C {sky130_stdcells/a211o_4.sym} 83580 -13120 0 0 {name=X_67697_ }
C {devices/lab_pin.sym} 83490 -12970 0 0 {name=p83173 lab=_84493_/CLK }
C {devices/lab_pin.sym} 83490 -12950 0 0 {name=p83174 lab=_61235_/Y }
C {devices/lab_pin.sym} 83670 -12970 0 1 {name=p83175 lab=_84502_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -12960 0 0 {name=X_84502_ }
C {devices/lab_pin.sym} 83490 -12830 0 0 {name=p83176 lab=_82053_/CLK }
C {devices/lab_pin.sym} 83490 -12810 0 0 {name=p83177 lab=_81714_/D }
C {devices/lab_pin.sym} 83670 -12830 0 1 {name=p83178 lab=_81714_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -12820 0 0 {name=X_81714_ }
C {devices/lab_pin.sym} 83520 -12710 0 0 {name=p83179 lab=_57188_/A }
C {devices/lab_pin.sym} 83520 -12670 0 0 {name=p83180 lab=_57445_/B }
C {devices/lab_pin.sym} 83520 -12630 0 0 {name=p83181 lab=_56818_/X }
C {devices/lab_pin.sym} 83640 -12670 0 1 {name=p83182 lab=_57450_/Y }
C {sky130_stdcells/nand3_4.sym} 83580 -12670 0 0 {name=X_57450_ }
C {devices/lab_pin.sym} 83500 -12560 0 0 {name=p83183 lab=_69423_/X }
C {devices/lab_pin.sym} 83500 -12520 0 0 {name=p83184 lab=_69340_/X }
C {devices/lab_pin.sym} 83500 -12480 0 0 {name=p83185 lab=_69434_/Y }
C {devices/lab_pin.sym} 83500 -12440 0 0 {name=p83186 lab=_69435_/Y }
C {devices/lab_pin.sym} 83660 -12500 0 1 {name=p83187 lab=_69436_/X }
C {sky130_stdcells/a211o_4.sym} 83580 -12500 0 0 {name=X_69436_ }
C {devices/lab_pin.sym} 83490 -12350 0 0 {name=p83188 lab=_88288_/CLK }
C {devices/lab_pin.sym} 83490 -12330 0 0 {name=p83189 lab=_41141_/Y }
C {devices/lab_pin.sym} 83670 -12350 0 1 {name=p83190 lab=_88270_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -12340 0 0 {name=X_88270_ }
C {devices/lab_pin.sym} 83520 -12240 0 0 {name=p83191 lab=_54667_/A }
C {devices/lab_pin.sym} 83520 -12200 0 0 {name=p83192 lab=_54674_/B }
C {devices/lab_pin.sym} 83520 -12160 0 0 {name=p83193 lab=_54644_/X }
C {devices/lab_pin.sym} 83520 -12120 0 0 {name=p83194 lab=_47302_/A }
C {devices/lab_pin.sym} 83640 -12180 0 1 {name=p83195 lab=_54662_/X }
C {sky130_stdcells/and4_4.sym} 83580 -12180 0 0 {name=X_54662_ }
C {devices/lab_pin.sym} 83520 -12040 0 0 {name=p83196 lab=_66669_/A }
C {devices/lab_pin.sym} 83520 -12000 0 0 {name=p83197 lab=_88144_/Q }
C {devices/lab_pin.sym} 83640 -12020 0 1 {name=p83198 lab=_66648_/X }
C {sky130_stdcells/and2_4.sym} 83580 -12020 0 0 {name=X_66648_ }
C {devices/lab_pin.sym} 83490 -11890 0 0 {name=p83199 lab=_84930_/CLK }
C {devices/lab_pin.sym} 83490 -11870 0 0 {name=p83200 lab=_54219_/Y }
C {devices/lab_pin.sym} 83670 -11890 0 1 {name=p83201 lab=_85482_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -11880 0 0 {name=X_85482_ }
C {devices/lab_pin.sym} 83540 -11750 0 0 {name=p83202 lab=_53269_/A }
C {devices/lab_pin.sym} 83620 -11750 0 1 {name=p83203 lab=_51875_/A }
C {sky130_stdcells/buf_2.sym} 83580 -11750 0 0 {name=X_51874_ }
C {devices/lab_pin.sym} 83490 -11630 0 0 {name=p83204 lab=_81190_/CLK }
C {devices/lab_pin.sym} 83490 -11610 0 0 {name=p83205 lab=_78845_/X }
C {devices/lab_pin.sym} 83670 -11630 0 1 {name=p83206 lab=_82694_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -11620 0 0 {name=X_82694_ }
C {devices/lab_pin.sym} 83520 -11510 0 0 {name=p83207 lab=_56397_/X }
C {devices/lab_pin.sym} 83520 -11470 0 0 {name=p83208 lab=_56399_/B }
C {devices/lab_pin.sym} 83520 -11430 0 0 {name=p83209 lab=_85208_/Q }
C {devices/lab_pin.sym} 83640 -11470 0 1 {name=p83210 lab=_56401_/Y }
C {sky130_stdcells/nand3_4.sym} 83580 -11470 0 0 {name=X_56401_ }
C {devices/lab_pin.sym} 83490 -11330 0 0 {name=p83211 lab=_87221_/CLK }
C {devices/lab_pin.sym} 83490 -11310 0 0 {name=p83212 lab=_87221_/D }
C {devices/lab_pin.sym} 83670 -11330 0 1 {name=p83213 lab=_69100_/B }
C {sky130_stdcells/dfxtp_4.sym} 83580 -11320 0 0 {name=X_87221_ }
C {devices/lab_pin.sym} 83500 -11210 0 0 {name=p83214 lab=_85602_/Q }
C {devices/lab_pin.sym} 83500 -11170 0 0 {name=p83215 lab=_53610_/X }
C {devices/lab_pin.sym} 83500 -11130 0 0 {name=p83216 lab=_53612_/Y }
C {devices/lab_pin.sym} 83660 -11170 0 1 {name=p83217 lab=_53613_/Y }
C {sky130_stdcells/o21ai_4.sym} 83580 -11170 0 0 {name=X_53613_ }
C {devices/lab_pin.sym} 83490 -11030 0 0 {name=p83218 lab=_81859_/CLK }
C {devices/lab_pin.sym} 83490 -11010 0 0 {name=p83219 lab=_62103_/Y }
C {devices/lab_pin.sym} 83670 -11030 0 1 {name=p83220 lab=_78056_/B }
C {sky130_stdcells/dfxtp_4.sym} 83580 -11020 0 0 {name=X_84433_ }
C {devices/lab_pin.sym} 83520 -10910 0 0 {name=p83221 lab=_51330_/A }
C {devices/lab_pin.sym} 83520 -10870 0 0 {name=p83222 lab=_50825_/B }
C {devices/lab_pin.sym} 83520 -10830 0 0 {name=p83223 lab=_50751_/C }
C {devices/lab_pin.sym} 83640 -10870 0 1 {name=p83224 lab=_50825_/X }
C {sky130_stdcells/and3_4.sym} 83580 -10870 0 0 {name=X_50825_ }
C {devices/lab_pin.sym} 83500 -10770 0 0 {name=p83225 lab=_56561_/X }
C {devices/lab_pin.sym} 83500 -10730 0 0 {name=p83226 lab=_57372_/X }
C {devices/lab_pin.sym} 83500 -10690 0 0 {name=p83227 lab=_56931_/X }
C {devices/lab_pin.sym} 83500 -10650 0 0 {name=p83228 lab=_45393_/A }
C {devices/lab_pin.sym} 83500 -10610 0 0 {name=p83229 lab=_57380_/X }
C {devices/lab_pin.sym} 83660 -10690 0 1 {name=p83230 lab=_85025_/D }
C {sky130_stdcells/a32o_4.sym} 83580 -10690 0 0 {name=X_57381_ }
C {devices/lab_pin.sym} 83540 -10530 0 0 {name=p83231 lab=_69065_/X }
C {devices/lab_pin.sym} 83620 -10530 0 1 {name=p83232 lab=_69367_/X }
C {sky130_stdcells/buf_2.sym} 83580 -10530 0 0 {name=X_69367_ }
C {devices/lab_pin.sym} 83490 -10410 0 0 {name=p83233 lab=_81260_/CLK }
C {devices/lab_pin.sym} 83490 -10390 0 0 {name=p83234 lab=_81677_/Q }
C {devices/lab_pin.sym} 83670 -10410 0 1 {name=p83235 lab=_76300_/A }
C {sky130_stdcells/dfxtp_4.sym} 83580 -10400 0 0 {name=X_81645_ }
C {devices/lab_pin.sym} 83540 -10270 0 0 {name=p83236 lab=_54540_/A }
C {devices/lab_pin.sym} 83620 -10270 0 1 {name=p83237 lab=_54593_/X }
C {sky130_stdcells/buf_2.sym} 83580 -10270 0 0 {name=X_54593_ }
C {devices/lab_pin.sym} 83540 -10150 0 0 {name=p83238 lab=_69768_/A }
C {devices/lab_pin.sym} 83620 -10150 0 1 {name=p83239 lab=_66579_/X }
C {sky130_stdcells/buf_2.sym} 83580 -10150 0 0 {name=X_66579_ }
C {devices/lab_pin.sym} 83500 -10070 0 0 {name=p83240 lab=_59115_/X }
C {devices/lab_pin.sym} 83500 -10030 0 0 {name=p83241 lab=_59117_/Y }
C {devices/lab_pin.sym} 83500 -9990 0 0 {name=p83242 lab=_59118_/Y }
C {devices/lab_pin.sym} 83500 -9950 0 0 {name=p83243 lab=_59046_/X }
C {devices/lab_pin.sym} 83500 -9910 0 0 {name=p83244 lab=_59119_/X }
C {devices/lab_pin.sym} 83660 -9990 0 1 {name=p83245 lab=_59120_/X }
C {sky130_stdcells/o32a_4.sym} 83580 -9990 0 0 {name=X_59120_ }
C {devices/lab_pin.sym} 83520 -9850 0 0 {name=p83246 lab=_56332_/A }
C {devices/lab_pin.sym} 83520 -9810 0 0 {name=p83247 lab=_56335_/B }
C {devices/lab_pin.sym} 83520 -9770 0 0 {name=p83248 lab=_55836_/B }
C {devices/lab_pin.sym} 83640 -9810 0 1 {name=p83249 lab=_56332_/Y }
C {sky130_stdcells/nand3_4.sym} 83580 -9810 0 0 {name=X_56332_ }
C {devices/lab_pin.sym} 83540 -9670 0 0 {name=p83250 lab=_68338_/A }
C {devices/lab_pin.sym} 83620 -9670 0 1 {name=p83251 lab=_68318_/X }
C {sky130_stdcells/buf_2.sym} 83580 -9670 0 0 {name=X_68318_ }
C {devices/lab_pin.sym} 83490 -9550 0 0 {name=p83252 lab=_88164_/CLK }
C {devices/lab_pin.sym} 83490 -9530 0 0 {name=p83253 lab=_87152_/D }
C {devices/lab_pin.sym} 83670 -9550 0 1 {name=p83254 lab=_87152_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -9540 0 0 {name=X_87152_ }
C {devices/lab_pin.sym} 83540 -9410 0 0 {name=p83255 lab=_53900_/A }
C {devices/lab_pin.sym} 83620 -9410 0 1 {name=p83256 lab=_53793_/A }
C {sky130_stdcells/buf_2.sym} 83580 -9410 0 0 {name=X_53544_ }
C {devices/lab_pin.sym} 83490 -9290 0 0 {name=p83257 lab=_84559_/CLK }
C {devices/lab_pin.sym} 83490 -9270 0 0 {name=p83258 lab=_62978_/Y }
C {devices/lab_pin.sym} 83670 -9290 0 1 {name=p83259 lab=_84364_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -9280 0 0 {name=X_84364_ }
C {devices/lab_pin.sym} 83500 -9170 0 0 {name=p83260 lab=_50754_/Y }
C {devices/lab_pin.sym} 83500 -9130 0 0 {name=p83261 lab=_50676_/X }
C {devices/lab_pin.sym} 83500 -9090 0 0 {name=p83262 lab=_50755_/X }
C {devices/lab_pin.sym} 83660 -9130 0 1 {name=p83263 lab=_50756_/Y }
C {sky130_stdcells/a21oi_4.sym} 83580 -9130 0 0 {name=X_50756_ }
C {devices/lab_pin.sym} 83490 -8990 0 0 {name=p83264 lab=_81575_/CLK }
C {devices/lab_pin.sym} 83490 -8970 0 0 {name=p83265 lab=_65817_/C }
C {devices/lab_pin.sym} 83670 -8990 0 1 {name=p83266 lab=_76706_/A }
C {sky130_stdcells/dfxtp_4.sym} 83580 -8980 0 0 {name=X_81576_ }
C {devices/lab_pin.sym} 83500 -8870 0 0 {name=p83267 lab=_81398_/D }
C {devices/lab_pin.sym} 83500 -8830 0 0 {name=p83268 lab=_69230_/X }
C {devices/lab_pin.sym} 83500 -8790 0 0 {name=p83269 lab=_69297_/X }
C {devices/lab_pin.sym} 83660 -8830 0 1 {name=p83270 lab=_83934_/D }
C {sky130_stdcells/a21bo_4.sym} 83580 -8830 0 0 {name=X_69298_ }
C {devices/lab_pin.sym} 83490 -8690 0 0 {name=p83271 lab=_82956_/CLK }
C {devices/lab_pin.sym} 83490 -8670 0 0 {name=p83272 lab=_50942_/Y }
C {devices/lab_pin.sym} 83670 -8690 0 1 {name=p83273 lab=_86103_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -8680 0 0 {name=X_86103_ }
C {devices/lab_pin.sym} 83500 -8570 0 0 {name=p83274 lab=_59013_/X }
C {devices/lab_pin.sym} 83500 -8530 0 0 {name=p83275 lab=_85757_/Q }
C {devices/lab_pin.sym} 83500 -8490 0 0 {name=p83276 lab=_59037_/X }
C {devices/lab_pin.sym} 83660 -8530 0 1 {name=p83277 lab=_59051_/X }
C {sky130_stdcells/o21a_4.sym} 83580 -8530 0 0 {name=X_59051_ }
C {devices/lab_pin.sym} 83490 -8390 0 0 {name=p83278 lab=_85003_/CLK }
C {devices/lab_pin.sym} 83490 -8370 0 0 {name=p83279 lab=_83315_/D }
C {devices/lab_pin.sym} 83670 -8390 0 1 {name=p83280 lab=_83315_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -8380 0 0 {name=X_83315_ }
C {devices/lab_pin.sym} 83520 -8270 0 0 {name=p83281 lab=_56263_/A }
C {devices/lab_pin.sym} 83520 -8230 0 0 {name=p83282 lab=_56263_/B }
C {devices/lab_pin.sym} 83520 -8190 0 0 {name=p83283 lab=_85254_/Q }
C {devices/lab_pin.sym} 83640 -8230 0 1 {name=p83284 lab=_56263_/Y }
C {sky130_stdcells/nand3_4.sym} 83580 -8230 0 0 {name=X_56263_ }
C {devices/lab_pin.sym} 83520 -8100 0 0 {name=p83285 lab=_80525_/X }
C {devices/lab_pin.sym} 83520 -8060 0 0 {name=p83286 lab=_80536_/B }
C {devices/lab_pin.sym} 83640 -8080 0 1 {name=p83287 lab=_80527_/Y }
C {sky130_stdcells/xnor2_4.sym} 83580 -8080 0 0 {name=X_80527_ }
C {devices/lab_pin.sym} 83500 -7980 0 0 {name=p83288 lab=_68246_/X }
C {devices/lab_pin.sym} 83500 -7940 0 0 {name=p83289 lab=_67532_/Y }
C {devices/lab_pin.sym} 83500 -7900 0 0 {name=p83290 lab=_68247_/X }
C {devices/lab_pin.sym} 83500 -7860 0 0 {name=p83291 lab=_68248_/Y }
C {devices/lab_pin.sym} 83660 -7920 0 1 {name=p83292 lab=_68249_/X }
C {sky130_stdcells/a211o_4.sym} 83580 -7920 0 0 {name=X_68249_ }
C {devices/lab_pin.sym} 83490 -7770 0 0 {name=p83293 lab=_87083_/CLK }
C {devices/lab_pin.sym} 83490 -7750 0 0 {name=p83294 lab=_44490_/Y }
C {devices/lab_pin.sym} 83670 -7770 0 1 {name=p83295 lab=_87083_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -7760 0 0 {name=X_87083_ }
C {devices/lab_pin.sym} 83500 -7650 0 0 {name=p83296 lab=_53469_/Y }
C {devices/lab_pin.sym} 83500 -7610 0 0 {name=p83297 lab=_53472_/X }
C {devices/lab_pin.sym} 83500 -7570 0 0 {name=p83298 lab=_53474_/X }
C {devices/lab_pin.sym} 83660 -7610 0 1 {name=p83299 lab=_85630_/D }
C {sky130_stdcells/a21oi_4.sym} 83580 -7610 0 0 {name=X_53475_ }
C {devices/lab_pin.sym} 83490 -7470 0 0 {name=p83300 lab=_84293_/CLK }
C {devices/lab_pin.sym} 83490 -7450 0 0 {name=p83301 lab=_84295_/D }
C {devices/lab_pin.sym} 83670 -7470 0 1 {name=p83302 lab=_63784_/C }
C {sky130_stdcells/dfxtp_4.sym} 83580 -7460 0 0 {name=X_84295_ }
C {devices/lab_pin.sym} 83500 -7350 0 0 {name=p83303 lab=_86153_/Q }
C {devices/lab_pin.sym} 83500 -7310 0 0 {name=p83304 lab=_50680_/X }
C {devices/lab_pin.sym} 83500 -7270 0 0 {name=p83305 lab=_50686_/Y }
C {devices/lab_pin.sym} 83660 -7310 0 1 {name=p83306 lab=_50687_/Y }
C {sky130_stdcells/o21ai_4.sym} 83580 -7310 0 0 {name=X_50687_ }
C {devices/lab_pin.sym} 83540 -7170 0 0 {name=p83307 lab=_58002_/A }
C {devices/lab_pin.sym} 83620 -7170 0 1 {name=p83308 lab=_58939_/A }
C {sky130_stdcells/buf_2.sym} 83580 -7170 0 0 {name=X_58002_ }
C {devices/lab_pin.sym} 83540 -7050 0 0 {name=p83309 lab=clkbuf_9_227_0_CLK/X }
C {devices/lab_pin.sym} 83620 -7050 0 1 {name=p83310 lab=_85981_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 83580 -7050 0 0 {name=Xclkbuf_10_454_0_CLK }
C {devices/lab_pin.sym} 83500 -6960 0 0 {name=p83311 lab=_85026_/Q }
C {devices/lab_pin.sym} 83500 -6920 0 0 {name=p83312 lab=_55142_/A }
C {devices/lab_pin.sym} 83500 -6880 0 0 {name=p83313 lab=_80665_/Q }
C {devices/lab_pin.sym} 83500 -6840 0 0 {name=p83314 lab=_55213_/X }
C {devices/lab_pin.sym} 83660 -6900 0 1 {name=p83315 lab=_55214_/X }
C {sky130_stdcells/a211o_4.sym} 83580 -6900 0 0 {name=X_55214_ }
C {devices/lab_pin.sym} 83490 -6750 0 0 {name=p83316 lab=_85818_/CLK }
C {devices/lab_pin.sym} 83490 -6730 0 0 {name=p83317 lab=_51315_/Y }
C {devices/lab_pin.sym} 83670 -6750 0 1 {name=p83318 lab=_65002_/B }
C {sky130_stdcells/dfxtp_4.sym} 83580 -6740 0 0 {name=X_86034_ }
C {devices/lab_pin.sym} 83540 -6610 0 0 {name=p83319 lab=_40439_/X }
C {devices/lab_pin.sym} 83620 -6610 0 1 {name=p83320 lab=_40440_/X }
C {sky130_stdcells/buf_2.sym} 83580 -6610 0 0 {name=X_40440_ }
C {devices/lab_pin.sym} 83520 -6510 0 0 {name=p83321 lab=_50731_/A }
C {devices/lab_pin.sym} 83520 -6470 0 0 {name=p83322 lab=_51238_/B }
C {devices/lab_pin.sym} 83520 -6430 0 0 {name=p83323 lab=_53944_/C }
C {devices/lab_pin.sym} 83640 -6470 0 1 {name=p83324 lab=_52426_/Y }
C {sky130_stdcells/nor3_4.sym} 83580 -6470 0 0 {name=X_52426_ }
C {devices/lab_pin.sym} 83540 -6330 0 0 {name=p83325 lab=_71090_/A }
C {devices/lab_pin.sym} 83620 -6330 0 1 {name=p83326 lab=_71261_/B }
C {sky130_stdcells/buf_2.sym} 83580 -6330 0 0 {name=X_71260_ }
C {devices/lab_pin.sym} 83490 -6210 0 0 {name=p83327 lab=_83246_/CLK }
C {devices/lab_pin.sym} 83490 -6190 0 0 {name=p83328 lab=_83246_/D }
C {devices/lab_pin.sym} 83670 -6210 0 1 {name=p83329 lab=_62022_/A }
C {sky130_stdcells/dfxtp_4.sym} 83580 -6200 0 0 {name=X_83246_ }
C {devices/lab_pin.sym} 83540 -6070 0 0 {name=p83330 lab=_56186_/Y }
C {devices/lab_pin.sym} 83620 -6070 0 1 {name=p83331 lab=_56194_/X }
C {sky130_stdcells/buf_2.sym} 83580 -6070 0 0 {name=X_56194_ }
C {devices/lab_pin.sym} 83520 -5960 0 0 {name=p83332 lab=_80458_/A }
C {devices/lab_pin.sym} 83520 -5920 0 0 {name=p83333 lab=_80458_/B }
C {devices/lab_pin.sym} 83640 -5940 0 1 {name=p83334 lab=_80458_/X }
C {sky130_stdcells/or2_4.sym} 83580 -5940 0 0 {name=X_80458_ }
C {devices/lab_pin.sym} 83540 -5810 0 0 {name=p83335 lab=_86500_/CLK }
C {devices/lab_pin.sym} 83620 -5810 0 1 {name=p83336 lab=_85866_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 83580 -5810 0 0 {name=Xclkbuf_opt_27_CLK }
C {devices/lab_pin.sym} 83500 -5710 0 0 {name=p83337 lab=_70209_/X }
C {devices/lab_pin.sym} 83500 -5670 0 0 {name=p83338 lab=_74763_/C }
C {devices/lab_pin.sym} 83500 -5630 0 0 {name=p83339 lab=_70210_/X }
C {devices/lab_pin.sym} 83660 -5670 0 1 {name=p83340 lab=_83836_/D }
C {sky130_stdcells/a21o_4.sym} 83580 -5670 0 0 {name=X_70211_ }
C {devices/lab_pin.sym} 83520 -5540 0 0 {name=p83341 lab=_55145_/A }
C {devices/lab_pin.sym} 83520 -5500 0 0 {name=p83342 lab=_55145_/B }
C {devices/lab_pin.sym} 83640 -5520 0 1 {name=p83343 lab=_55145_/Y }
C {sky130_stdcells/nor2_4.sym} 83580 -5520 0 0 {name=X_55145_ }
C {devices/lab_pin.sym} 83540 -5390 0 0 {name=p83344 lab=_40370_/X }
C {devices/lab_pin.sym} 83620 -5390 0 1 {name=p83345 lab=_40371_/X }
C {sky130_stdcells/buf_2.sym} 83580 -5390 0 0 {name=X_40371_ }
C {devices/lab_pin.sym} 83520 -5280 0 0 {name=p83346 lab=_52349_/A }
C {devices/lab_pin.sym} 83520 -5240 0 0 {name=p83347 lab=_49073_/X }
C {devices/lab_pin.sym} 83640 -5260 0 1 {name=p83348 lab=_52357_/Y }
C {sky130_stdcells/nand2_4.sym} 83580 -5260 0 0 {name=X_52357_ }
C {devices/lab_pin.sym} 83540 -5130 0 0 {name=p83349 lab=_71191_/A }
C {devices/lab_pin.sym} 83620 -5130 0 1 {name=p83350 lab=_71211_/A }
C {sky130_stdcells/inv_2.sym} 83580 -5130 0 0 {name=X_71191_ }
C {devices/lab_pin.sym} 83490 -5010 0 0 {name=p83351 lab=_83507_/CLK }
C {devices/lab_pin.sym} 83490 -4990 0 0 {name=p83352 lab=_83177_/D }
C {devices/lab_pin.sym} 83670 -5010 0 1 {name=p83353 lab=_83177_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -5000 0 0 {name=X_83177_ }
C {devices/lab_pin.sym} 83500 -4890 0 0 {name=p83354 lab=_80378_/X }
C {devices/lab_pin.sym} 83500 -4850 0 0 {name=p83355 lab=_80380_/B }
C {devices/lab_pin.sym} 83500 -4810 0 0 {name=p83356 lab=_80388_/Y }
C {devices/lab_pin.sym} 83660 -4850 0 1 {name=p83357 lab=_80406_/B }
C {sky130_stdcells/a21boi_4.sym} 83580 -4850 0 0 {name=X_80389_ }
C {devices/lab_pin.sym} 83500 -4740 0 0 {name=p83358 lab=_41050_/X }
C {devices/lab_pin.sym} 83500 -4700 0 0 {name=p83359 lab=_42103_/X }
C {devices/lab_pin.sym} 83500 -4660 0 0 {name=p83360 lab=_88031_/Q }
C {devices/lab_pin.sym} 83500 -4620 0 0 {name=p83361 lab=_42104_/X }
C {devices/lab_pin.sym} 83660 -4680 0 1 {name=p83362 lab=_88031_/D }
C {sky130_stdcells/a2bb2o_4.sym} 83580 -4680 0 0 {name=X_42110_ }
C {devices/lab_pin.sym} 83500 -4550 0 0 {name=p83363 lab=_51305_/Y }
C {devices/lab_pin.sym} 83500 -4510 0 0 {name=p83364 lab=_51289_/X }
C {devices/lab_pin.sym} 83500 -4470 0 0 {name=p83365 lab=_51307_/X }
C {devices/lab_pin.sym} 83660 -4510 0 1 {name=p83366 lab=_86035_/D }
C {sky130_stdcells/a21oi_4.sym} 83580 -4510 0 0 {name=X_51308_ }
C {devices/lab_pin.sym} 83500 -4400 0 0 {name=p83367 lab=_83528_/Q }
C {devices/lab_pin.sym} 83500 -4360 0 0 {name=p83368 lab=_83176_/Q }
C {devices/lab_pin.sym} 83500 -4320 0 0 {name=p83369 lab=_83510_/Q }
C {devices/lab_pin.sym} 83500 -4280 0 0 {name=p83370 lab=_83158_/Q }
C {devices/lab_pin.sym} 83660 -4340 0 1 {name=p83371 lab=_70144_/C }
C {sky130_stdcells/a22oi_4.sym} 83580 -4340 0 0 {name=X_70142_ }
C {devices/lab_pin.sym} 83490 -4190 0 0 {name=p83372 lab=_82084_/CLK }
C {devices/lab_pin.sym} 83490 -4170 0 0 {name=p83373 lab=_82128_/D }
C {devices/lab_pin.sym} 83670 -4190 0 1 {name=p83374 lab=_82084_/D }
C {sky130_stdcells/dfxtp_4.sym} 83580 -4180 0 0 {name=X_82128_ }
C {devices/lab_pin.sym} 83540 -4050 0 0 {name=p83375 lab=_43127_/A }
C {devices/lab_pin.sym} 83620 -4050 0 1 {name=p83376 lab=_43090_/X }
C {sky130_stdcells/buf_2.sym} 83580 -4050 0 0 {name=X_43090_ }
C {devices/lab_pin.sym} 83540 -3930 0 0 {name=p83377 lab=_55102_/A }
C {devices/lab_pin.sym} 83620 -3930 0 1 {name=p83378 lab=_55076_/X }
C {sky130_stdcells/buf_2.sym} 83580 -3930 0 0 {name=X_55076_ }
C {devices/lab_pin.sym} 83540 -3810 0 0 {name=p83379 lab=_59770_/A }
C {devices/lab_pin.sym} 83620 -3810 0 1 {name=p83380 lab=_60422_/A }
C {sky130_stdcells/buf_2.sym} 83580 -3810 0 0 {name=X_59953_ }
C {devices/lab_pin.sym} 83500 -3710 0 0 {name=p83381 lab=_64753_/B }
C {devices/lab_pin.sym} 83500 -3670 0 0 {name=p83382 lab=_52269_/X }
C {devices/lab_pin.sym} 83500 -3630 0 0 {name=p83383 lab=_52287_/Y }
C {devices/lab_pin.sym} 83660 -3670 0 1 {name=p83384 lab=_52288_/Y }
C {sky130_stdcells/o21ai_4.sym} 83580 -3670 0 0 {name=X_52288_ }
C {devices/lab_pin.sym} 83490 -3530 0 0 {name=p83385 lab=_87408_/CLK }
C {devices/lab_pin.sym} 83490 -3510 0 0 {name=p83386 lab=_87985_/D }
C {devices/lab_pin.sym} 83670 -3530 0 1 {name=p83387 lab=_87985_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -3520 0 0 {name=X_87985_ }
C {devices/lab_pin.sym} 83540 -3390 0 0 {name=p83388 lab=clkbuf_9_234_0_CLK/X }
C {devices/lab_pin.sym} 83620 -3390 0 1 {name=p83389 lab=_85764_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 83580 -3390 0 0 {name=Xclkbuf_10_469_0_CLK }
C {devices/lab_pin.sym} 83540 -3270 0 0 {name=p83390 lab=_42041_/A }
C {devices/lab_pin.sym} 83620 -3270 0 1 {name=p83391 lab=_42041_/Y }
C {sky130_stdcells/inv_2.sym} 83580 -3270 0 0 {name=X_42041_ }
C {devices/lab_pin.sym} 83540 -3150 0 0 {name=p83392 lab=_58904_/A }
C {devices/lab_pin.sym} 83620 -3150 0 1 {name=p83393 lab=_58904_/X }
C {sky130_stdcells/buf_2.sym} 83580 -3150 0 0 {name=X_58904_ }
C {devices/lab_pin.sym} 83500 -3050 0 0 {name=p83394 lab=_54025_/Y }
C {devices/lab_pin.sym} 83500 -3010 0 0 {name=p83395 lab=_54015_/X }
C {devices/lab_pin.sym} 83500 -2970 0 0 {name=p83396 lab=_54026_/X }
C {devices/lab_pin.sym} 83660 -3010 0 1 {name=p83397 lab=_54027_/Y }
C {sky130_stdcells/a21oi_4.sym} 83580 -3010 0 0 {name=X_54027_ }
C {devices/lab_pin.sym} 83500 -2890 0 0 {name=p83398 lab=_51236_/Y }
C {devices/lab_pin.sym} 83500 -2850 0 0 {name=p83399 lab=_51237_/X }
C {devices/lab_pin.sym} 83500 -2810 0 0 {name=p83400 lab=_51238_/Y }
C {devices/lab_pin.sym} 83660 -2850 0 1 {name=p83401 lab=_51239_/Y }
C {sky130_stdcells/a21oi_4.sym} 83580 -2850 0 0 {name=X_51239_ }
C {devices/lab_pin.sym} 83520 -2720 0 0 {name=p83402 lab=_81137_/D }
C {devices/lab_pin.sym} 83520 -2680 0 0 {name=p83403 lab=_80849_/Q }
C {devices/lab_pin.sym} 83640 -2700 0 1 {name=p83404 lab=_74958_/B }
C {sky130_stdcells/or2_4.sym} 83580 -2700 0 0 {name=X_74950_ }
C {devices/lab_pin.sym} 83500 -2590 0 0 {name=p83405 lab=_82537_/D }
C {devices/lab_pin.sym} 83500 -2550 0 0 {name=p83406 lab=_70067_/X }
C {devices/lab_pin.sym} 83500 -2510 0 0 {name=p83407 lab=_70072_/X }
C {devices/lab_pin.sym} 83660 -2550 0 1 {name=p83408 lab=_83857_/D }
C {sky130_stdcells/a21bo_4.sym} 83580 -2550 0 0 {name=X_70073_ }
C {devices/lab_pin.sym} 83490 -2410 0 0 {name=p83409 lab=_86935_/CLK }
C {devices/lab_pin.sym} 83490 -2390 0 0 {name=p83410 lab=_86936_/D }
C {devices/lab_pin.sym} 83670 -2410 0 1 {name=p83411 lab=_86936_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -2400 0 0 {name=X_86936_ }
C {devices/lab_pin.sym} 83490 -2270 0 0 {name=p83412 lab=_84105_/CLK }
C {devices/lab_pin.sym} 83490 -2250 0 0 {name=p83413 lab=_82059_/D }
C {devices/lab_pin.sym} 83670 -2270 0 1 {name=p83414 lab=_82059_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -2260 0 0 {name=X_82059_ }
C {devices/lab_pin.sym} 83540 -2130 0 0 {name=p83415 lab=_59883_/Y }
C {devices/lab_pin.sym} 83620 -2130 0 1 {name=p83416 lab=_59884_/X }
C {sky130_stdcells/buf_2.sym} 83580 -2130 0 0 {name=X_59884_ }
C {devices/lab_pin.sym} 83520 -2020 0 0 {name=p83417 lab=_73949_/A }
C {devices/lab_pin.sym} 83520 -1980 0 0 {name=p83418 lab=_73901_/B }
C {devices/lab_pin.sym} 83640 -2000 0 1 {name=p83419 lab=_73901_/X }
C {sky130_stdcells/and2_4.sym} 83580 -2000 0 0 {name=X_73901_ }
C {devices/lab_pin.sym} 83540 -1870 0 0 {name=p83420 lab=_59033_/A }
C {devices/lab_pin.sym} 83620 -1870 0 1 {name=p83421 lab=_58835_/X }
C {sky130_stdcells/buf_2.sym} 83580 -1870 0 0 {name=X_58835_ }
C {devices/lab_pin.sym} 83520 -1760 0 0 {name=p83422 lab=_81127_/D }
C {devices/lab_pin.sym} 83520 -1720 0 0 {name=p83423 lab=_74875_/B }
C {devices/lab_pin.sym} 83640 -1740 0 1 {name=p83424 lab=_74881_/Y }
C {sky130_stdcells/nand2_4.sym} 83580 -1740 0 0 {name=X_74881_ }
C {devices/lab_pin.sym} 83490 -1610 0 0 {name=p83425 lab=_84409_/CLK }
C {devices/lab_pin.sym} 83490 -1590 0 0 {name=p83426 lab=_45594_/Y }
C {devices/lab_pin.sym} 83670 -1610 0 1 {name=p83427 lab=_63147_/B }
C {sky130_stdcells/dfxtp_4.sym} 83580 -1600 0 0 {name=X_86867_ }
C {devices/lab_pin.sym} 83540 -1470 0 0 {name=p83428 lab=_82983_/Q }
C {devices/lab_pin.sym} 83620 -1470 0 1 {name=p83429 lab=_74691_/B }
C {sky130_stdcells/inv_2.sym} 83580 -1470 0 0 {name=X_45800_ }
C {devices/lab_pin.sym} 83520 -1360 0 0 {name=p83430 lab=_76620_/A }
C {devices/lab_pin.sym} 83520 -1320 0 0 {name=p83431 lab=_81548_/Q }
C {devices/lab_pin.sym} 83640 -1340 0 1 {name=p83432 lab=_76620_/X }
C {sky130_stdcells/xor2_4.sym} 83580 -1340 0 0 {name=X_76620_ }
C {devices/lab_pin.sym} 83500 -1230 0 0 {name=p83433 lab=_73828_/X }
C {devices/lab_pin.sym} 83500 -1190 0 0 {name=p83434 lab=_73831_/X }
C {devices/lab_pin.sym} 83500 -1150 0 0 {name=p83435 lab=_73738_/X }
C {devices/lab_pin.sym} 83660 -1190 0 1 {name=p83436 lab=_73835_/A }
C {sky130_stdcells/a21o_4.sym} 83580 -1190 0 0 {name=X_73832_ }
C {devices/lab_pin.sym} 83490 -1050 0 0 {name=p83437 lab=_85818_/CLK }
C {devices/lab_pin.sym} 83490 -1030 0 0 {name=p83438 lab=_85818_/D }
C {devices/lab_pin.sym} 83670 -1050 0 1 {name=p83439 lab=_85818_/Q }
C {sky130_stdcells/dfxtp_4.sym} 83580 -1040 0 0 {name=X_85818_ }
C {devices/lab_pin.sym} 83520 -920 0 0 {name=p83440 lab=_46806_/A }
C {devices/lab_pin.sym} 83520 -880 0 0 {name=p83441 lab=_50976_/B }
C {devices/lab_pin.sym} 83640 -900 0 1 {name=p83442 lab=_46780_/Y }
C {sky130_stdcells/nand2_4.sym} 83580 -900 0 0 {name=X_46780_ }
C {devices/lab_pin.sym} 83540 -770 0 0 {name=p83443 lab=_58766_/A }
C {devices/lab_pin.sym} 83620 -770 0 1 {name=p83444 lab=_58766_/X }
C {sky130_stdcells/buf_2.sym} 83580 -770 0 0 {name=X_58766_ }
C {devices/lab_pin.sym} 84440 -42160 0 0 {name=p83445 lab=_55695_/A }
C {devices/lab_pin.sym} 84440 -42120 0 0 {name=p83446 lab=_56469_/C }
C {devices/lab_pin.sym} 84560 -42140 0 1 {name=p83447 lab=_55978_/X }
C {sky130_stdcells/and2_4.sym} 84500 -42140 0 0 {name=X_55978_ }
C {devices/lab_pin.sym} 84420 -42030 0 0 {name=p83448 lab=_43990_/Y }
C {devices/lab_pin.sym} 84420 -41990 0 0 {name=p83449 lab=_43954_/X }
C {devices/lab_pin.sym} 84420 -41950 0 0 {name=p83450 lab=_43991_/Y }
C {devices/lab_pin.sym} 84580 -41990 0 1 {name=p83451 lab=_43992_/Y }
C {sky130_stdcells/a21oi_4.sym} 84500 -41990 0 0 {name=X_43992_ }
C {devices/lab_pin.sym} 84410 -41850 0 0 {name=p83452 lab=_87484_/CLK }
C {devices/lab_pin.sym} 84410 -41830 0 0 {name=p83453 lab=_86798_/D }
C {devices/lab_pin.sym} 84590 -41850 0 1 {name=p83454 lab=_66765_/B }
C {sky130_stdcells/dfxtp_4.sym} 84500 -41840 0 0 {name=X_86798_ }
C {devices/lab_pin.sym} 84460 -41710 0 0 {name=p83455 lab=_58882_/A }
C {devices/lab_pin.sym} 84540 -41710 0 1 {name=p83456 lab=_57718_/A }
C {sky130_stdcells/buf_2.sym} 84500 -41710 0 0 {name=X_57717_ }
C {devices/lab_pin.sym} 84420 -41610 0 0 {name=p83457 lab=_45668_/X }
C {devices/lab_pin.sym} 84420 -41570 0 0 {name=p83458 lab=_61582_/A }
C {devices/lab_pin.sym} 84420 -41530 0 0 {name=p83459 lab=_45685_/X }
C {devices/lab_pin.sym} 84580 -41570 0 1 {name=p83460 lab=_45731_/Y }
C {sky130_stdcells/o21ai_4.sym} 84500 -41570 0 0 {name=X_45731_ }
C {devices/lab_pin.sym} 84440 -41440 0 0 {name=p83461 lab=_76552_/A }
C {devices/lab_pin.sym} 84440 -41400 0 0 {name=p83462 lab=_81545_/Q }
C {devices/lab_pin.sym} 84560 -41420 0 1 {name=p83463 lab=_76554_/B }
C {sky130_stdcells/nor2_4.sym} 84500 -41420 0 0 {name=X_76551_ }
C {devices/lab_pin.sym} 84420 -41320 0 0 {name=p83464 lab=_41782_/X }
C {devices/lab_pin.sym} 84420 -41280 0 0 {name=p83465 lab=_42930_/X }
C {devices/lab_pin.sym} 84420 -41240 0 0 {name=p83466 lab=_68018_/B }
C {devices/lab_pin.sym} 84420 -41200 0 0 {name=p83467 lab=_42931_/X }
C {devices/lab_pin.sym} 84580 -41260 0 1 {name=p83468 lab=_87638_/D }
C {sky130_stdcells/a2bb2o_4.sym} 84500 -41260 0 0 {name=X_42943_ }
C {devices/lab_pin.sym} 84420 -41130 0 0 {name=p83469 lab=_54925_/Y }
C {devices/lab_pin.sym} 84420 -41090 0 0 {name=p83470 lab=_54909_/X }
C {devices/lab_pin.sym} 84420 -41050 0 0 {name=p83471 lab=_54928_/X }
C {devices/lab_pin.sym} 84580 -41090 0 1 {name=p83472 lab=_85352_/D }
C {sky130_stdcells/a21oi_4.sym} 84500 -41090 0 0 {name=X_54929_ }
C {devices/lab_pin.sym} 84420 -40980 0 0 {name=p83473 lab=_73665_/X }
C {devices/lab_pin.sym} 84420 -40940 0 0 {name=p83474 lab=_84985_/Q }
C {devices/lab_pin.sym} 84420 -40900 0 0 {name=p83475 lab=_73740_/X }
C {devices/lab_pin.sym} 84420 -40860 0 0 {name=p83476 lab=_73762_/X }
C {devices/lab_pin.sym} 84580 -40920 0 1 {name=p83477 lab=_73764_/B }
C {sky130_stdcells/a211o_4.sym} 84500 -40920 0 0 {name=X_73763_ }
C {devices/lab_pin.sym} 84410 -40770 0 0 {name=p83478 lab=_85751_/CLK }
C {devices/lab_pin.sym} 84410 -40750 0 0 {name=p83479 lab=_52819_/Y }
C {devices/lab_pin.sym} 84590 -40770 0 1 {name=p83480 lab=_85749_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -40760 0 0 {name=X_85749_ }
C {devices/lab_pin.sym} 84420 -40650 0 0 {name=p83481 lab=_46396_/B }
C {devices/lab_pin.sym} 84420 -40610 0 0 {name=p83482 lab=_70961_/A }
C {devices/lab_pin.sym} 84420 -40570 0 0 {name=p83483 lab=_70974_/Y }
C {devices/lab_pin.sym} 84580 -40610 0 1 {name=p83484 lab=_83644_/D }
C {sky130_stdcells/o21ai_4.sym} 84500 -40610 0 0 {name=X_70975_ }
C {devices/lab_pin.sym} 84460 -40470 0 0 {name=p83485 lab=_58697_/A }
C {devices/lab_pin.sym} 84540 -40470 0 1 {name=p83486 lab=_58698_/A }
C {sky130_stdcells/buf_2.sym} 84500 -40470 0 0 {name=X_58697_ }
C {devices/lab_pin.sym} 84420 -40370 0 0 {name=p83487 lab=_75503_/A }
C {devices/lab_pin.sym} 84420 -40330 0 0 {name=p83488 lab=_75503_/C }
C {devices/lab_pin.sym} 84420 -40290 0 0 {name=p83489 lab=_75503_/B }
C {devices/lab_pin.sym} 84580 -40330 0 1 {name=p83490 lab=_75536_/A }
C {sky130_stdcells/a21o_4.sym} 84500 -40330 0 0 {name=X_75502_ }
C {devices/lab_pin.sym} 84420 -40210 0 0 {name=p83491 lab=_48372_/X }
C {devices/lab_pin.sym} 84420 -40170 0 0 {name=p83492 lab=_47926_/A }
C {devices/lab_pin.sym} 84420 -40130 0 0 {name=p83493 lab=_48449_/Y }
C {devices/lab_pin.sym} 84580 -40170 0 1 {name=p83494 lab=_74406_/A }
C {sky130_stdcells/o21ai_4.sym} 84500 -40170 0 0 {name=X_48450_ }
C {devices/lab_pin.sym} 84440 -40050 0 0 {name=p83495 lab=_72714_/A }
C {devices/lab_pin.sym} 84440 -40010 0 0 {name=p83496 lab=_72714_/B }
C {devices/lab_pin.sym} 84440 -39970 0 0 {name=p83497 lab=_55656_/X }
C {devices/lab_pin.sym} 84560 -40010 0 1 {name=p83498 lab=_72714_/Y }
C {sky130_stdcells/nand3_4.sym} 84500 -40010 0 0 {name=X_72714_ }
C {devices/lab_pin.sym} 84440 -39880 0 0 {name=p83499 lab=_79257_/Y }
C {devices/lab_pin.sym} 84440 -39840 0 0 {name=p83500 lab=_79270_/B }
C {devices/lab_pin.sym} 84560 -39860 0 1 {name=p83501 lab=_79270_/X }
C {sky130_stdcells/or2_4.sym} 84500 -39860 0 0 {name=X_79270_ }
C {devices/lab_pin.sym} 84420 -39750 0 0 {name=p83502 lab=_57414_/A }
C {devices/lab_pin.sym} 84420 -39710 0 0 {name=p83503 lab=_45357_/X }
C {devices/lab_pin.sym} 84420 -39670 0 0 {name=p83504 lab=_45339_/X }
C {devices/lab_pin.sym} 84580 -39710 0 1 {name=p83505 lab=_45662_/X }
C {sky130_stdcells/o21a_4.sym} 84500 -39710 0 0 {name=X_45662_ }
C {devices/lab_pin.sym} 84440 -39590 0 0 {name=p83506 lab=_50391_/A }
C {devices/lab_pin.sym} 84440 -39550 0 0 {name=p83507 lab=_46620_/A }
C {devices/lab_pin.sym} 84440 -39510 0 0 {name=p83508 lab=_46428_/C }
C {devices/lab_pin.sym} 84560 -39550 0 1 {name=p83509 lab=_57648_/Y }
C {sky130_stdcells/nand3_4.sym} 84500 -39550 0 0 {name=X_57648_ }
C {devices/lab_pin.sym} 84440 -39440 0 0 {name=p83510 lab=_76482_/A }
C {devices/lab_pin.sym} 84440 -39400 0 0 {name=p83511 lab=_76482_/B }
C {devices/lab_pin.sym} 84440 -39360 0 0 {name=p83512 lab=_76482_/C }
C {devices/lab_pin.sym} 84440 -39320 0 0 {name=p83513 lab=_76463_/X }
C {devices/lab_pin.sym} 84560 -39380 0 1 {name=p83514 lab=_76482_/X }
C {sky130_stdcells/and4_4.sym} 84500 -39380 0 0 {name=X_76482_ }
C {devices/lab_pin.sym} 84460 -39230 0 0 {name=p83515 lab=_42846_/X }
C {devices/lab_pin.sym} 84540 -39230 0 1 {name=p83516 lab=_42874_/X }
C {sky130_stdcells/buf_2.sym} 84500 -39230 0 0 {name=X_42874_ }
C {devices/lab_pin.sym} 84440 -39130 0 0 {name=p83517 lab=_73692_/X }
C {devices/lab_pin.sym} 84440 -39090 0 0 {name=p83518 lab=_73694_/B }
C {devices/lab_pin.sym} 84440 -39050 0 0 {name=p83519 lab=_73694_/C }
C {devices/lab_pin.sym} 84560 -39090 0 1 {name=p83520 lab=_73694_/Y }
C {sky130_stdcells/nand3_4.sym} 84500 -39090 0 0 {name=X_73694_ }
C {devices/lab_pin.sym} 84460 -38950 0 0 {name=p83521 lab=clkbuf_9_203_0_CLK/X }
C {devices/lab_pin.sym} 84540 -38950 0 1 {name=p83522 lab=_85338_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 84500 -38950 0 0 {name=Xclkbuf_10_407_0_CLK }
C {devices/lab_pin.sym} 84420 -38850 0 0 {name=p83523 lab=_47397_/Y }
C {devices/lab_pin.sym} 84420 -38810 0 0 {name=p83524 lab=_47364_/X }
C {devices/lab_pin.sym} 84420 -38770 0 0 {name=p83525 lab=_47400_/X }
C {devices/lab_pin.sym} 84580 -38810 0 1 {name=p83526 lab=_86639_/D }
C {sky130_stdcells/a21oi_4.sym} 84500 -38810 0 0 {name=X_47401_ }
C {devices/lab_pin.sym} 84440 -38680 0 0 {name=p83527 lab=_78210_/B }
C {devices/lab_pin.sym} 84440 -38640 0 0 {name=p83528 lab=_78221_/B }
C {devices/lab_pin.sym} 84560 -38660 0 1 {name=p83529 lab=_78221_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -38660 0 0 {name=X_78221_ }
C {devices/lab_pin.sym} 84420 -38570 0 0 {name=p83530 lab=_44588_/X }
C {devices/lab_pin.sym} 84420 -38530 0 0 {name=p83531 lab=_44589_/X }
C {devices/lab_pin.sym} 84420 -38490 0 0 {name=p83532 lab=_40972_/A }
C {devices/lab_pin.sym} 84420 -38450 0 0 {name=p83533 lab=_87032_/Q }
C {devices/lab_pin.sym} 84420 -38410 0 0 {name=p83534 lab=_44590_/X }
C {devices/lab_pin.sym} 84580 -38490 0 1 {name=p83535 lab=_44613_/Y }
C {sky130_stdcells/o32ai_4.sym} 84500 -38490 0 0 {name=X_44613_ }
C {devices/lab_pin.sym} 84440 -38340 0 0 {name=p83536 lab=_75431_/X }
C {devices/lab_pin.sym} 84440 -38300 0 0 {name=p83537 lab=_75432_/Y }
C {devices/lab_pin.sym} 84560 -38320 0 1 {name=p83538 lab=_75433_/X }
C {sky130_stdcells/and2_4.sym} 84500 -38320 0 0 {name=X_75433_ }
C {devices/lab_pin.sym} 84460 -38190 0 0 {name=p83539 lab=_41825_/A }
C {devices/lab_pin.sym} 84540 -38190 0 1 {name=p83540 lab=_41825_/X }
C {sky130_stdcells/buf_2.sym} 84500 -38190 0 0 {name=X_41825_ }
C {devices/lab_pin.sym} 84410 -38070 0 0 {name=p83541 lab=_81182_/CLK }
C {devices/lab_pin.sym} 84410 -38050 0 0 {name=p83542 lab=_87419_/D }
C {devices/lab_pin.sym} 84590 -38070 0 1 {name=p83543 lab=_87419_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -38060 0 0 {name=X_87419_ }
C {devices/lab_pin.sym} 84440 -37940 0 0 {name=p83544 lab=_48392_/A }
C {devices/lab_pin.sym} 84440 -37900 0 0 {name=p83545 lab=_48380_/X }
C {devices/lab_pin.sym} 84560 -37920 0 1 {name=p83546 lab=_48381_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -37920 0 0 {name=X_48381_ }
C {devices/lab_pin.sym} 84460 -37790 0 0 {name=p83547 lab=_72630_/X }
C {devices/lab_pin.sym} 84540 -37790 0 1 {name=p83548 lab=_72645_/X }
C {sky130_stdcells/buf_2.sym} 84500 -37790 0 0 {name=X_72645_ }
C {devices/lab_pin.sym} 84420 -37690 0 0 {name=p83549 lab=_84975_/Q }
C {devices/lab_pin.sym} 84420 -37650 0 0 {name=p83550 lab=_57550_/X }
C {devices/lab_pin.sym} 84420 -37610 0 0 {name=p83551 lab=_57578_/Y }
C {devices/lab_pin.sym} 84580 -37650 0 1 {name=p83552 lab=_57579_/Y }
C {sky130_stdcells/o21ai_4.sym} 84500 -37650 0 0 {name=X_57579_ }
C {devices/lab_pin.sym} 84420 -37530 0 0 {name=p83553 lab=_45591_/X }
C {devices/lab_pin.sym} 84420 -37490 0 0 {name=p83554 lab=_61483_/A }
C {devices/lab_pin.sym} 84420 -37450 0 0 {name=p83555 lab=_45530_/X }
C {devices/lab_pin.sym} 84580 -37490 0 1 {name=p83556 lab=_45593_/Y }
C {sky130_stdcells/o21ai_4.sym} 84500 -37490 0 0 {name=X_45593_ }
C {devices/lab_pin.sym} 84410 -37350 0 0 {name=p83557 lab=_86834_/CLK }
C {devices/lab_pin.sym} 84410 -37330 0 0 {name=p83558 lab=_40392_/X }
C {devices/lab_pin.sym} 84590 -37350 0 1 {name=p83559 lab=_88399_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -37340 0 0 {name=X_88399_ }
C {devices/lab_pin.sym} 84420 -37250 0 0 {name=p83560 lab=_59253_/X }
C {devices/lab_pin.sym} 84420 -37210 0 0 {name=p83561 lab=_59316_/Y }
C {devices/lab_pin.sym} 84420 -37170 0 0 {name=p83562 lab=_59317_/Y }
C {devices/lab_pin.sym} 84420 -37130 0 0 {name=p83563 lab=_59271_/X }
C {devices/lab_pin.sym} 84420 -37090 0 0 {name=p83564 lab=_59258_/X }
C {devices/lab_pin.sym} 84580 -37170 0 1 {name=p83565 lab=_59318_/X }
C {sky130_stdcells/o32a_4.sym} 84500 -37170 0 0 {name=X_59318_ }
C {devices/lab_pin.sym} 84460 -37010 0 0 {name=p83566 lab=_47382_/A }
C {devices/lab_pin.sym} 84540 -37010 0 1 {name=p83567 lab=_47332_/X }
C {sky130_stdcells/buf_2.sym} 84500 -37010 0 0 {name=X_47332_ }
C {devices/lab_pin.sym} 84440 -36900 0 0 {name=p83568 lab=_78152_/A }
C {devices/lab_pin.sym} 84440 -36860 0 0 {name=p83569 lab=_78151_/Y }
C {devices/lab_pin.sym} 84560 -36880 0 1 {name=p83570 lab=_78153_/B }
C {sky130_stdcells/xor2_4.sym} 84500 -36880 0 0 {name=X_78152_ }
C {devices/lab_pin.sym} 84420 -36790 0 0 {name=p83571 lab=_44529_/X }
C {devices/lab_pin.sym} 84420 -36750 0 0 {name=p83572 lab=_44530_/X }
C {devices/lab_pin.sym} 84420 -36710 0 0 {name=p83573 lab=_40820_/A }
C {devices/lab_pin.sym} 84420 -36670 0 0 {name=p83574 lab=_44543_/Y }
C {devices/lab_pin.sym} 84420 -36630 0 0 {name=p83575 lab=_44533_/X }
C {devices/lab_pin.sym} 84580 -36710 0 1 {name=p83576 lab=_87060_/D }
C {sky130_stdcells/o32ai_4.sym} 84500 -36710 0 0 {name=X_44544_ }
C {devices/lab_pin.sym} 84440 -36560 0 0 {name=p83577 lab=_75364_/A }
C {devices/lab_pin.sym} 84440 -36520 0 0 {name=p83578 lab=_75355_/X }
C {devices/lab_pin.sym} 84560 -36540 0 1 {name=p83579 lab=_75364_/Y }
C {sky130_stdcells/nor2_4.sym} 84500 -36540 0 0 {name=X_75364_ }
C {devices/lab_pin.sym} 84420 -36430 0 0 {name=p83580 lab=_41603_/X }
C {devices/lab_pin.sym} 84420 -36390 0 0 {name=p83581 lab=_82889_/Q }
C {devices/lab_pin.sym} 84420 -36350 0 0 {name=p83582 lab=_41755_/X }
C {devices/lab_pin.sym} 84580 -36390 0 1 {name=p83583 lab=_41756_/X }
C {sky130_stdcells/o21a_4.sym} 84500 -36390 0 0 {name=X_41756_ }
C {devices/lab_pin.sym} 84420 -36270 0 0 {name=p83584 lab=_63252_/B }
C {devices/lab_pin.sym} 84420 -36230 0 0 {name=p83585 lab=_60570_/C }
C {devices/lab_pin.sym} 84420 -36190 0 0 {name=p83586 lab=_63272_/A }
C {devices/lab_pin.sym} 84580 -36230 0 1 {name=p83587 lab=_60590_/Y }
C {sky130_stdcells/a21oi_4.sym} 84500 -36230 0 0 {name=X_60590_ }
C {devices/lab_pin.sym} 84460 -36090 0 0 {name=p83588 lab=_72576_/A }
C {devices/lab_pin.sym} 84540 -36090 0 1 {name=p83589 lab=_72576_/Y }
C {sky130_stdcells/inv_2.sym} 84500 -36090 0 0 {name=X_72576_ }
C {devices/lab_pin.sym} 84440 -35980 0 0 {name=p83590 lab=_82096_/Q }
C {devices/lab_pin.sym} 84440 -35940 0 0 {name=p83591 lab=_77103_/B }
C {devices/lab_pin.sym} 84560 -35960 0 1 {name=p83592 lab=_77103_/X }
C {sky130_stdcells/xor2_4.sym} 84500 -35960 0 0 {name=X_77103_ }
C {devices/lab_pin.sym} 84460 -35830 0 0 {name=p83593 lab=_72704_/A }
C {devices/lab_pin.sym} 84540 -35830 0 1 {name=p83594 lab=_74325_/A }
C {sky130_stdcells/buf_2.sym} 84500 -35830 0 0 {name=X_74315_ }
C {devices/lab_pin.sym} 84460 -35710 0 0 {name=p83595 lab=_40707_/A }
C {devices/lab_pin.sym} 84540 -35710 0 1 {name=p83596 lab=_40707_/X }
C {sky130_stdcells/buf_2.sym} 84500 -35710 0 0 {name=X_40707_ }
C {devices/lab_pin.sym} 84460 -35590 0 0 {name=p83597 lab=_81821_/Q }
C {devices/lab_pin.sym} 84540 -35590 0 1 {name=p83598 lab=_47264_/A }
C {sky130_stdcells/inv_2.sym} 84500 -35590 0 0 {name=X_47263_ }
C {devices/lab_pin.sym} 84420 -35490 0 0 {name=p83599 lab=_59199_/X }
C {devices/lab_pin.sym} 84420 -35450 0 0 {name=p83600 lab=_85741_/Q }
C {devices/lab_pin.sym} 84420 -35410 0 0 {name=p83601 lab=_59124_/X }
C {devices/lab_pin.sym} 84580 -35450 0 1 {name=p83602 lab=_59249_/X }
C {sky130_stdcells/o21a_4.sym} 84500 -35450 0 0 {name=X_59249_ }
C {devices/lab_pin.sym} 84440 -35330 0 0 {name=p83603 lab=_70933_/B }
C {devices/lab_pin.sym} 84440 -35290 0 0 {name=p83604 lab=_70694_/A }
C {devices/lab_pin.sym} 84440 -35250 0 0 {name=p83605 lab=_70700_/A }
C {devices/lab_pin.sym} 84560 -35290 0 1 {name=p83606 lab=_71527_/Y }
C {sky130_stdcells/nand3_4.sym} 84500 -35290 0 0 {name=X_71527_ }
C {devices/lab_pin.sym} 84440 -35160 0 0 {name=p83607 lab=_78083_/A }
C {devices/lab_pin.sym} 84440 -35120 0 0 {name=p83608 lab=_78083_/B }
C {devices/lab_pin.sym} 84560 -35140 0 1 {name=p83609 lab=_78085_/A }
C {sky130_stdcells/nand2_4.sym} 84500 -35140 0 0 {name=X_78083_ }
C {devices/lab_pin.sym} 84460 -35010 0 0 {name=p83610 lab=_44603_/A }
C {devices/lab_pin.sym} 84540 -35010 0 1 {name=p83611 lab=_44475_/X }
C {sky130_stdcells/buf_2.sym} 84500 -35010 0 0 {name=X_44475_ }
C {devices/lab_pin.sym} 84420 -34910 0 0 {name=p83612 lab=_75284_/A }
C {devices/lab_pin.sym} 84420 -34870 0 0 {name=p83613 lab=_75283_/Y }
C {devices/lab_pin.sym} 84420 -34830 0 0 {name=p83614 lab=_75276_/Y }
C {devices/lab_pin.sym} 84580 -34870 0 1 {name=p83615 lab=_75295_/X }
C {sky130_stdcells/o21a_4.sym} 84500 -34870 0 0 {name=X_75295_ }
C {devices/lab_pin.sym} 84420 -34750 0 0 {name=p83616 lab=_41603_/X }
C {devices/lab_pin.sym} 84420 -34710 0 0 {name=p83617 lab=_82903_/Q }
C {devices/lab_pin.sym} 84420 -34670 0 0 {name=p83618 lab=_41686_/X }
C {devices/lab_pin.sym} 84580 -34710 0 1 {name=p83619 lab=_41687_/X }
C {sky130_stdcells/o21a_4.sym} 84500 -34710 0 0 {name=X_41687_ }
C {devices/lab_pin.sym} 84460 -34570 0 0 {name=p83620 lab=_49002_/A }
C {devices/lab_pin.sym} 84540 -34570 0 1 {name=p83621 lab=_49052_/A }
C {sky130_stdcells/buf_2.sym} 84500 -34570 0 0 {name=X_49002_ }
C {devices/lab_pin.sym} 84440 -34480 0 0 {name=p83622 lab=_46213_/X }
C {devices/lab_pin.sym} 84440 -34440 0 0 {name=p83623 lab=_46098_/A }
C {devices/lab_pin.sym} 84440 -34400 0 0 {name=p83624 lab=_46214_/C }
C {devices/lab_pin.sym} 84440 -34360 0 0 {name=p83625 lab=_46214_/D }
C {devices/lab_pin.sym} 84560 -34420 0 1 {name=p83626 lab=_46215_/C }
C {sky130_stdcells/nand4_4.sym} 84500 -34420 0 0 {name=X_46214_ }
C {devices/lab_pin.sym} 84460 -34270 0 0 {name=p83627 lab=clkbuf_8_81_0_CLK/A }
C {devices/lab_pin.sym} 84540 -34270 0 1 {name=p83628 lab=clkbuf_8_81_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 84500 -34270 0 0 {name=Xclkbuf_8_81_0_CLK }
C {sky130_stdcells/decap_3.sym} 84500 -34120 0 0 {name=XPHY_260 }
C {devices/lab_pin.sym} 84440 -33990 0 0 {name=p83629 lab=_77026_/Y }
C {devices/lab_pin.sym} 84440 -33950 0 0 {name=p83630 lab=_77034_/B }
C {devices/lab_pin.sym} 84440 -33910 0 0 {name=p83631 lab=_77034_/C }
C {devices/lab_pin.sym} 84560 -33950 0 1 {name=p83632 lab=_77041_/A }
C {sky130_stdcells/nand3_4.sym} 84500 -33950 0 0 {name=X_77034_ }
C {devices/lab_pin.sym} 84460 -33810 0 0 {name=p83633 lab=_43425_/X }
C {devices/lab_pin.sym} 84540 -33810 0 1 {name=p83634 lab=_43426_/X }
C {sky130_stdcells/buf_2.sym} 84500 -33810 0 0 {name=X_43426_ }
C {devices/lab_pin.sym} 84440 -33720 0 0 {name=p83635 lab=_61367_/A }
C {devices/lab_pin.sym} 84440 -33680 0 0 {name=p83636 lab=_62247_/X }
C {devices/lab_pin.sym} 84440 -33640 0 0 {name=p83637 lab=_62259_/X }
C {devices/lab_pin.sym} 84440 -33600 0 0 {name=p83638 lab=_62560_/D }
C {devices/lab_pin.sym} 84560 -33660 0 1 {name=p83639 lab=_62260_/Y }
C {sky130_stdcells/nand4_4.sym} 84500 -33660 0 0 {name=X_62260_ }
C {devices/lab_pin.sym} 84440 -33520 0 0 {name=p83640 lab=_87317_/Q }
C {devices/lab_pin.sym} 84440 -33480 0 0 {name=p83641 lab=_74246_/B }
C {devices/lab_pin.sym} 84560 -33500 0 1 {name=p83642 lab=_74246_/Y }
C {sky130_stdcells/nor2_4.sym} 84500 -33500 0 0 {name=X_74246_ }
C {sky130_stdcells/decap_3.sym} 84500 -33340 0 0 {name=XPHY_271 }
C {devices/lab_pin.sym} 84460 -33190 0 0 {name=p83643 lab=_40836_/A }
C {devices/lab_pin.sym} 84540 -33190 0 1 {name=p83644 lab=_40638_/X }
C {sky130_stdcells/buf_2.sym} 84500 -33190 0 0 {name=X_40638_ }
C {devices/lab_pin.sym} 84460 -33070 0 0 {name=p83645 lab=_47194_/A }
C {devices/lab_pin.sym} 84540 -33070 0 1 {name=p83646 lab=_47195_/A }
C {sky130_stdcells/inv_2.sym} 84500 -33070 0 0 {name=X_47194_ }
C {devices/lab_pin.sym} 84440 -32970 0 0 {name=p83647 lab=_70689_/A }
C {devices/lab_pin.sym} 84440 -32930 0 0 {name=p83648 lab=_71446_/X }
C {devices/lab_pin.sym} 84440 -32890 0 0 {name=p83649 lab=_71458_/C }
C {devices/lab_pin.sym} 84560 -32930 0 1 {name=p83650 lab=_71458_/Y }
C {sky130_stdcells/nor3_4.sym} 84500 -32930 0 0 {name=X_71458_ }
C {sky130_stdcells/decap_3.sym} 84500 -32760 0 0 {name=XPHY_282 }
C {sky130_stdcells/decap_3.sym} 84500 -32580 0 0 {name=XPHY_293 }
C {devices/lab_pin.sym} 84460 -32430 0 0 {name=p83651 lab=_83613_/CLK }
C {devices/lab_pin.sym} 84540 -32430 0 1 {name=p83652 lab=_86453_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 84500 -32430 0 0 {name=Xclkbuf_opt_18_CLK }
C {devices/lab_pin.sym} 84460 -32310 0 0 {name=p83653 lab=_64457_/B }
C {devices/lab_pin.sym} 84540 -32310 0 1 {name=p83654 lab=_61238_/C }
C {sky130_stdcells/buf_2.sym} 84500 -32310 0 0 {name=X_61211_ }
C {devices/lab_pin.sym} 84460 -32190 0 0 {name=p83655 lab=MACRO_WR_SELECT }
C {devices/lab_pin.sym} 84540 -32190 0 1 {name=p83656 lab=_70609_/A }
C {sky130_stdcells/buf_2.sym} 84500 -32190 0 0 {name=X_70409_ }
C {devices/lab_pin.sym} 84460 -32070 0 0 {name=p83657 lab=_58547_/A }
C {devices/lab_pin.sym} 84540 -32070 0 1 {name=p83658 lab=_46150_/B }
C {sky130_stdcells/buf_2.sym} 84500 -32070 0 0 {name=X_46145_ }
C {devices/lab_pin.sym} 84460 -31950 0 0 {name=p83659 lab=_43302_/A }
C {devices/lab_pin.sym} 84540 -31950 0 1 {name=p83660 lab=_43357_/X }
C {sky130_stdcells/buf_2.sym} 84500 -31950 0 0 {name=X_43357_ }
C {devices/lab_pin.sym} 84440 -31850 0 0 {name=p83661 lab=_62181_/A }
C {devices/lab_pin.sym} 84440 -31810 0 0 {name=p83662 lab=_62181_/B }
C {devices/lab_pin.sym} 84440 -31770 0 0 {name=p83663 lab=_78049_/B }
C {devices/lab_pin.sym} 84560 -31810 0 1 {name=p83664 lab=_62191_/Y }
C {sky130_stdcells/nor3_4.sym} 84500 -31810 0 0 {name=X_62191_ }
C {devices/lab_pin.sym} 84440 -31680 0 0 {name=p83665 lab=_74237_/A }
C {devices/lab_pin.sym} 84440 -31640 0 0 {name=p83666 lab=_74177_/B }
C {devices/lab_pin.sym} 84560 -31660 0 1 {name=p83667 lab=_74177_/X }
C {sky130_stdcells/and2_4.sym} 84500 -31660 0 0 {name=X_74177_ }
C {devices/lab_pin.sym} 84420 -31570 0 0 {name=p83668 lab=_40550_/X }
C {devices/lab_pin.sym} 84420 -31530 0 0 {name=p83669 lab=_40556_/X }
C {devices/lab_pin.sym} 84420 -31490 0 0 {name=p83670 lab=_40560_/X }
C {devices/lab_pin.sym} 84420 -31450 0 0 {name=p83671 lab=_88371_/Q }
C {devices/lab_pin.sym} 84420 -31410 0 0 {name=p83672 lab=_40568_/X }
C {devices/lab_pin.sym} 84580 -31490 0 1 {name=p83673 lab=_40569_/Y }
C {sky130_stdcells/o32ai_4.sym} 84500 -31490 0 0 {name=X_40569_ }
C {devices/lab_pin.sym} 84440 -31350 0 0 {name=p83674 lab=_71411_/A }
C {devices/lab_pin.sym} 84440 -31310 0 0 {name=p83675 lab=_71386_/B }
C {devices/lab_pin.sym} 84440 -31270 0 0 {name=p83676 lab=_71399_/C }
C {devices/lab_pin.sym} 84560 -31310 0 1 {name=p83677 lab=_71389_/Y }
C {sky130_stdcells/nor3_4.sym} 84500 -31310 0 0 {name=X_71389_ }
C {devices/lab_pin.sym} 84420 -31210 0 0 {name=p83678 lab=_42307_/X }
C {devices/lab_pin.sym} 84420 -31170 0 0 {name=p83679 lab=_42297_/X }
C {devices/lab_pin.sym} 84420 -31130 0 0 {name=p83680 lab=_41596_/X }
C {devices/lab_pin.sym} 84420 -31090 0 0 {name=p83681 lab=_87929_/Q }
C {devices/lab_pin.sym} 84420 -31050 0 0 {name=p83682 lab=_42298_/X }
C {devices/lab_pin.sym} 84580 -31130 0 1 {name=p83683 lab=_42308_/Y }
C {sky130_stdcells/o32ai_4.sym} 84500 -31130 0 0 {name=X_42308_ }
C {devices/lab_pin.sym} 84460 -30970 0 0 {name=p83684 lab=_64323_/A }
C {devices/lab_pin.sym} 84540 -30970 0 1 {name=p83685 lab=_64250_/C }
C {sky130_stdcells/buf_2.sym} 84500 -30970 0 0 {name=X_61142_ }
C {devices/lab_pin.sym} 84420 -30870 0 0 {name=p83686 lab=_73125_/X }
C {devices/lab_pin.sym} 84420 -30830 0 0 {name=p83687 lab=_73127_/X }
C {devices/lab_pin.sym} 84420 -30790 0 0 {name=p83688 lab=_72951_/X }
C {devices/lab_pin.sym} 84580 -30830 0 1 {name=p83689 lab=_73128_/X }
C {sky130_stdcells/a21o_4.sym} 84500 -30830 0 0 {name=X_73128_ }
C {devices/lab_pin.sym} 84420 -30720 0 0 {name=p83690 lab=_41600_/Y }
C {devices/lab_pin.sym} 84420 -30680 0 0 {name=p83691 lab=_43586_/X }
C {devices/lab_pin.sym} 84420 -30640 0 0 {name=p83692 lab=_67227_/B }
C {devices/lab_pin.sym} 84420 -30600 0 0 {name=p83693 lab=_43593_/X }
C {devices/lab_pin.sym} 84580 -30660 0 1 {name=p83694 lab=_86779_/D }
C {sky130_stdcells/a2bb2o_4.sym} 84500 -30660 0 0 {name=X_46076_ }
C {devices/lab_pin.sym} 84460 -30510 0 0 {name=p83695 lab=_43218_/A }
C {devices/lab_pin.sym} 84540 -30510 0 1 {name=p83696 lab=_43288_/X }
C {sky130_stdcells/buf_2.sym} 84500 -30510 0 0 {name=X_43288_ }
C {devices/lab_pin.sym} 84440 -30400 0 0 {name=p83697 lab=_78998_/A }
C {devices/lab_pin.sym} 84440 -30360 0 0 {name=p83698 lab=_78998_/B }
C {devices/lab_pin.sym} 84560 -30380 0 1 {name=p83699 lab=_78993_/A }
C {sky130_stdcells/xor2_4.sym} 84500 -30380 0 0 {name=X_78985_ }
C {devices/lab_pin.sym} 84460 -30250 0 0 {name=p83700 lab=clkbuf_8_97_0_CLK/A }
C {devices/lab_pin.sym} 84540 -30250 0 1 {name=p83701 lab=clkbuf_8_96_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 84500 -30250 0 0 {name=Xclkbuf_8_96_0_CLK }
C {devices/lab_pin.sym} 84440 -30160 0 0 {name=p83702 lab=_49904_/A }
C {devices/lab_pin.sym} 84440 -30120 0 0 {name=p83703 lab=_49893_/B }
C {devices/lab_pin.sym} 84440 -30080 0 0 {name=p83704 lab=_49904_/C }
C {devices/lab_pin.sym} 84440 -30040 0 0 {name=p83705 lab=_53118_/D }
C {devices/lab_pin.sym} 84560 -30100 0 1 {name=p83706 lab=_49904_/X }
C {sky130_stdcells/and4_4.sym} 84500 -30100 0 0 {name=X_49904_ }
C {devices/lab_pin.sym} 84460 -29950 0 0 {name=p83707 lab=_45827_/B }
C {devices/lab_pin.sym} 84540 -29950 0 1 {name=p83708 lab=_45027_/X }
C {sky130_stdcells/buf_2.sym} 84500 -29950 0 0 {name=X_45027_ }
C {devices/lab_pin.sym} 84460 -29830 0 0 {name=p83709 lab=_65768_/A }
C {devices/lab_pin.sym} 84540 -29830 0 1 {name=p83710 lab=_65950_/X }
C {sky130_stdcells/buf_2.sym} 84500 -29830 0 0 {name=X_65950_ }
C {devices/lab_pin.sym} 84460 -29710 0 0 {name=p83711 lab=_42239_/A }
C {devices/lab_pin.sym} 84540 -29710 0 1 {name=p83712 lab=_87965_/D }
C {sky130_stdcells/inv_2.sym} 84500 -29710 0 0 {name=X_42239_ }
C {devices/lab_pin.sym} 84440 -29600 0 0 {name=p83713 lab=_82249_/Q }
C {devices/lab_pin.sym} 84440 -29560 0 0 {name=p83714 lab=_81961_/Q }
C {devices/lab_pin.sym} 84560 -29580 0 1 {name=p83715 lab=_77946_/A }
C {sky130_stdcells/xnor2_4.sym} 84500 -29580 0 0 {name=X_77936_ }
C {devices/lab_pin.sym} 84440 -29460 0 0 {name=p83716 lab=_61070_/X }
C {devices/lab_pin.sym} 84440 -29420 0 0 {name=p83717 lab=_61122_/C }
C {devices/lab_pin.sym} 84560 -29440 0 1 {name=p83718 lab=_61074_/A }
C {sky130_stdcells/and2_4.sym} 84500 -29440 0 0 {name=X_61073_ }
C {devices/lab_pin.sym} 84460 -29310 0 0 {name=p83719 lab=_72732_/B }
C {devices/lab_pin.sym} 84540 -29310 0 1 {name=p83720 lab=_73059_/X }
C {sky130_stdcells/buf_2.sym} 84500 -29310 0 0 {name=X_73059_ }
C {devices/lab_pin.sym} 84440 -29210 0 0 {name=p83721 lab=_64897_/X }
C {devices/lab_pin.sym} 84440 -29170 0 0 {name=p83722 lab=_64712_/B }
C {devices/lab_pin.sym} 84440 -29130 0 0 {name=p83723 lab=_64900_/X }
C {devices/lab_pin.sym} 84560 -29170 0 1 {name=p83724 lab=_64901_/Y }
C {sky130_stdcells/nand3_4.sym} 84500 -29170 0 0 {name=X_64901_ }
C {devices/lab_pin.sym} 84460 -29030 0 0 {name=p83725 lab=_62218_/A }
C {devices/lab_pin.sym} 84540 -29030 0 1 {name=p83726 lab=_62194_/D }
C {sky130_stdcells/buf_2.sym} 84500 -29030 0 0 {name=X_60024_ }
C {devices/lab_pin.sym} 84440 -28940 0 0 {name=p83727 lab=_49830_/A }
C {devices/lab_pin.sym} 84440 -28900 0 0 {name=p83728 lab=_49851_/B }
C {devices/lab_pin.sym} 84440 -28860 0 0 {name=p83729 lab=_49830_/C }
C {devices/lab_pin.sym} 84440 -28820 0 0 {name=p83730 lab=_53048_/D }
C {devices/lab_pin.sym} 84560 -28880 0 1 {name=p83731 lab=_49835_/X }
C {sky130_stdcells/and4_4.sym} 84500 -28880 0 0 {name=X_49835_ }
C {devices/lab_pin.sym} 84420 -28750 0 0 {name=p83732 lab=_65875_/X }
C {devices/lab_pin.sym} 84420 -28710 0 0 {name=p83733 lab=_65879_/X }
C {devices/lab_pin.sym} 84420 -28670 0 0 {name=p83734 lab=_65880_/X }
C {devices/lab_pin.sym} 84580 -28710 0 1 {name=p83735 lab=_65884_/A }
C {sky130_stdcells/a21o_4.sym} 84500 -28710 0 0 {name=X_65881_ }
C {devices/lab_pin.sym} 84420 -28590 0 0 {name=p83736 lab=_77855_/Y }
C {devices/lab_pin.sym} 84420 -28550 0 0 {name=p83737 lab=_77860_/B }
C {devices/lab_pin.sym} 84420 -28510 0 0 {name=p83738 lab=_77861_/A }
C {devices/lab_pin.sym} 84580 -28550 0 1 {name=p83739 lab=_77867_/Y }
C {sky130_stdcells/a21boi_4.sym} 84500 -28550 0 0 {name=X_77867_ }
C {devices/lab_pin.sym} 84420 -28430 0 0 {name=p83740 lab=_67614_/X }
C {devices/lab_pin.sym} 84420 -28390 0 0 {name=p83741 lab=_67617_/X }
C {devices/lab_pin.sym} 84420 -28350 0 0 {name=p83742 lab=_67619_/X }
C {devices/lab_pin.sym} 84580 -28390 0 1 {name=p83743 lab=_67623_/A }
C {sky130_stdcells/a21o_4.sym} 84500 -28390 0 0 {name=X_67620_ }
C {devices/lab_pin.sym} 84440 -28260 0 0 {name=p83744 lab=_79602_/X }
C {devices/lab_pin.sym} 84440 -28220 0 0 {name=p83745 lab=_79603_/Y }
C {devices/lab_pin.sym} 84560 -28240 0 1 {name=p83746 lab=_79607_/B }
C {sky130_stdcells/nand2_4.sym} 84500 -28240 0 0 {name=X_79606_ }
C {devices/lab_pin.sym} 84420 -28130 0 0 {name=p83747 lab=_64827_/X }
C {devices/lab_pin.sym} 84420 -28090 0 0 {name=p83748 lab=_64831_/X }
C {devices/lab_pin.sym} 84420 -28050 0 0 {name=p83749 lab=_64729_/X }
C {devices/lab_pin.sym} 84580 -28090 0 1 {name=p83750 lab=_64832_/X }
C {sky130_stdcells/a21o_4.sym} 84500 -28090 0 0 {name=X_64832_ }
C {devices/lab_pin.sym} 84440 -27960 0 0 {name=p83751 lab=_76818_/A }
C {devices/lab_pin.sym} 84440 -27920 0 0 {name=p83752 lab=_76818_/B }
C {devices/lab_pin.sym} 84560 -27940 0 1 {name=p83753 lab=_76819_/B }
C {sky130_stdcells/xor2_4.sym} 84500 -27940 0 0 {name=X_76818_ }
C {devices/lab_pin.sym} 84440 -27840 0 0 {name=p83754 lab=_49779_/A }
C {devices/lab_pin.sym} 84440 -27800 0 0 {name=p83755 lab=_49750_/X }
C {devices/lab_pin.sym} 84440 -27760 0 0 {name=p83756 lab=_49789_/C }
C {devices/lab_pin.sym} 84440 -27720 0 0 {name=p83757 lab=_52982_/D }
C {devices/lab_pin.sym} 84560 -27780 0 1 {name=p83758 lab=_49766_/X }
C {sky130_stdcells/and4_4.sym} 84500 -27780 0 0 {name=X_49766_ }
C {devices/lab_pin.sym} 84420 -27650 0 0 {name=p83759 lab=_59068_/A }
C {devices/lab_pin.sym} 84420 -27610 0 0 {name=p83760 lab=_46955_/X }
C {devices/lab_pin.sym} 84420 -27570 0 0 {name=p83761 lab=_46977_/Y }
C {devices/lab_pin.sym} 84580 -27610 0 1 {name=p83762 lab=_46978_/Y }
C {sky130_stdcells/o21ai_4.sym} 84500 -27610 0 0 {name=X_46978_ }
C {devices/lab_pin.sym} 84440 -27480 0 0 {name=p83763 lab=_77796_/Y }
C {devices/lab_pin.sym} 84440 -27440 0 0 {name=p83764 lab=_77798_/B }
C {devices/lab_pin.sym} 84560 -27460 0 1 {name=p83765 lab=_77798_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -27460 0 0 {name=X_77798_ }
C {devices/lab_pin.sym} 84440 -27340 0 0 {name=p83766 lab=_48725_/A }
C {devices/lab_pin.sym} 84440 -27300 0 0 {name=p83767 lab=_48368_/X }
C {devices/lab_pin.sym} 84560 -27320 0 1 {name=p83768 lab=_48717_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -27320 0 0 {name=X_48717_ }
C {devices/lab_pin.sym} 84460 -27190 0 0 {name=p83769 lab=_67550_/X }
C {devices/lab_pin.sym} 84540 -27190 0 1 {name=p83770 lab=_67551_/X }
C {sky130_stdcells/buf_2.sym} 84500 -27190 0 0 {name=X_67551_ }
C {devices/lab_pin.sym} 84440 -27080 0 0 {name=p83771 lab=_64542_/Y }
C {devices/lab_pin.sym} 84440 -27040 0 0 {name=p83772 lab=_79538_/A }
C {devices/lab_pin.sym} 84560 -27060 0 1 {name=p83773 lab=_79544_/A }
C {sky130_stdcells/nand2_4.sym} 84500 -27060 0 0 {name=X_79537_ }
C {devices/lab_pin.sym} 84460 -26930 0 0 {name=p83774 lab=_72745_/A }
C {devices/lab_pin.sym} 84540 -26930 0 1 {name=p83775 lab=_72905_/A }
C {sky130_stdcells/buf_2.sym} 84500 -26930 0 0 {name=X_45929_ }
C {devices/lab_pin.sym} 84460 -26810 0 0 {name=p83776 lab=_84228_/Q }
C {devices/lab_pin.sym} 84540 -26810 0 1 {name=p83777 lab=_64764_/C }
C {sky130_stdcells/inv_2.sym} 84500 -26810 0 0 {name=X_64763_ }
C {devices/lab_pin.sym} 84460 -26690 0 0 {name=p83778 lab=_76735_/Y }
C {devices/lab_pin.sym} 84540 -26690 0 1 {name=p83779 lab=_76749_/Y }
C {sky130_stdcells/inv_2.sym} 84500 -26690 0 0 {name=X_76749_ }
C {devices/lab_pin.sym} 84440 -26600 0 0 {name=p83780 lab=_49685_/A }
C {devices/lab_pin.sym} 84440 -26560 0 0 {name=p83781 lab=_49697_/B }
C {devices/lab_pin.sym} 84440 -26520 0 0 {name=p83782 lab=_49685_/C }
C {devices/lab_pin.sym} 84440 -26480 0 0 {name=p83783 lab=_51220_/D }
C {devices/lab_pin.sym} 84560 -26540 0 1 {name=p83784 lab=_49697_/X }
C {sky130_stdcells/and4_4.sym} 84500 -26540 0 0 {name=X_49697_ }
C {devices/lab_pin.sym} 84460 -26390 0 0 {name=p83785 lab=_61722_/A }
C {devices/lab_pin.sym} 84540 -26390 0 1 {name=p83786 lab=_62002_/A }
C {sky130_stdcells/buf_2.sym} 84500 -26390 0 0 {name=X_61975_ }
C {devices/lab_pin.sym} 84420 -26290 0 0 {name=p83787 lab=_66500_/Y }
C {devices/lab_pin.sym} 84420 -26250 0 0 {name=p83788 lab=_66483_/X }
C {devices/lab_pin.sym} 84420 -26210 0 0 {name=p83789 lab=_66501_/X }
C {devices/lab_pin.sym} 84580 -26250 0 1 {name=p83790 lab=_66502_/X }
C {sky130_stdcells/a21o_4.sym} 84500 -26250 0 0 {name=X_66502_ }
C {devices/lab_pin.sym} 84440 -26120 0 0 {name=p83791 lab=_59448_/A }
C {devices/lab_pin.sym} 84440 -26080 0 0 {name=p83792 lab=_63370_/A }
C {devices/lab_pin.sym} 84560 -26100 0 1 {name=p83793 lab=_63714_/Y }
C {sky130_stdcells/nor2_4.sym} 84500 -26100 0 0 {name=X_63714_ }
C {devices/lab_pin.sym} 84460 -25970 0 0 {name=p83794 lab=_48647_/Y }
C {devices/lab_pin.sym} 84540 -25970 0 1 {name=p83795 lab=_48847_/B }
C {sky130_stdcells/buf_2.sym} 84500 -25970 0 0 {name=X_48648_ }
C {devices/lab_pin.sym} 84460 -25850 0 0 {name=p83796 lab=_60853_/X }
C {devices/lab_pin.sym} 84540 -25850 0 1 {name=p83797 lab=_60926_/X }
C {sky130_stdcells/buf_2.sym} 84500 -25850 0 0 {name=X_60926_ }
C {devices/lab_pin.sym} 84440 -25740 0 0 {name=p83798 lab=_67575_/A }
C {devices/lab_pin.sym} 84440 -25700 0 0 {name=p83799 lab=_67482_/B }
C {devices/lab_pin.sym} 84560 -25720 0 1 {name=p83800 lab=_67482_/X }
C {sky130_stdcells/and2_4.sym} 84500 -25720 0 0 {name=X_67482_ }
C {devices/lab_pin.sym} 84440 -25600 0 0 {name=p83801 lab=_79466_/X }
C {devices/lab_pin.sym} 84440 -25560 0 0 {name=p83802 lab=_79468_/B }
C {devices/lab_pin.sym} 84560 -25580 0 1 {name=p83803 lab=_79484_/B }
C {sky130_stdcells/xnor2_4.sym} 84500 -25580 0 0 {name=X_79468_ }
C {devices/lab_pin.sym} 84440 -25460 0 0 {name=p83804 lab=_64694_/A }
C {devices/lab_pin.sym} 84440 -25420 0 0 {name=p83805 lab=_64694_/B }
C {devices/lab_pin.sym} 84560 -25440 0 1 {name=p83806 lab=_64694_/X }
C {sky130_stdcells/and2_4.sym} 84500 -25440 0 0 {name=X_64694_ }
C {devices/lab_pin.sym} 84460 -25310 0 0 {name=p83807 lab=clkbuf_8_35_0_CLK/A }
C {devices/lab_pin.sym} 84540 -25310 0 1 {name=p83808 lab=clkbuf_9_69_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 84500 -25310 0 0 {name=Xclkbuf_8_34_0_CLK }
C {devices/lab_pin.sym} 84420 -25220 0 0 {name=p83809 lab=_87533_/Q }
C {devices/lab_pin.sym} 84420 -25180 0 0 {name=p83810 lab=_69044_/X }
C {devices/lab_pin.sym} 84420 -25140 0 0 {name=p83811 lab=_68979_/X }
C {devices/lab_pin.sym} 84420 -25100 0 0 {name=p83812 lab=_69220_/X }
C {devices/lab_pin.sym} 84580 -25160 0 1 {name=p83813 lab=_69221_/X }
C {sky130_stdcells/a211o_4.sym} 84500 -25160 0 0 {name=X_69221_ }
C {devices/lab_pin.sym} 84440 -25030 0 0 {name=p83814 lab=_66433_/A }
C {devices/lab_pin.sym} 84440 -24990 0 0 {name=p83815 lab=_66419_/X }
C {devices/lab_pin.sym} 84440 -24950 0 0 {name=p83816 lab=_66433_/C }
C {devices/lab_pin.sym} 84560 -24990 0 1 {name=p83817 lab=_66433_/X }
C {sky130_stdcells/and3_4.sym} 84500 -24990 0 0 {name=X_66433_ }
C {devices/lab_pin.sym} 84440 -24860 0 0 {name=p83818 lab=_78418_/B }
C {devices/lab_pin.sym} 84440 -24820 0 0 {name=p83819 lab=_78418_/A }
C {devices/lab_pin.sym} 84560 -24840 0 1 {name=p83820 lab=_78423_/C }
C {sky130_stdcells/nand2_4.sym} 84500 -24840 0 0 {name=X_78419_ }
C {devices/lab_pin.sym} 84460 -24710 0 0 {name=p83821 lab=_63468_/A }
C {devices/lab_pin.sym} 84540 -24710 0 1 {name=p83822 lab=_63670_/B }
C {sky130_stdcells/buf_2.sym} 84500 -24710 0 0 {name=X_63645_ }
C {devices/lab_pin.sym} 84440 -24620 0 0 {name=p83823 lab=_60851_/X }
C {devices/lab_pin.sym} 84440 -24580 0 0 {name=p83824 lab=_60408_/A }
C {devices/lab_pin.sym} 84440 -24540 0 0 {name=p83825 lab=_59753_/B }
C {devices/lab_pin.sym} 84440 -24500 0 0 {name=p83826 lab=_60857_/D }
C {devices/lab_pin.sym} 84560 -24560 0 1 {name=p83827 lab=_60857_/X }
C {sky130_stdcells/and4_4.sym} 84500 -24560 0 0 {name=X_60857_ }
C {devices/lab_pin.sym} 84440 -24430 0 0 {name=p83828 lab=_52199_/A }
C {devices/lab_pin.sym} 84440 -24390 0 0 {name=p83829 lab=_48624_/B }
C {devices/lab_pin.sym} 84440 -24350 0 0 {name=p83830 lab=_48610_/C }
C {devices/lab_pin.sym} 84560 -24390 0 1 {name=p83831 lab=_48579_/X }
C {sky130_stdcells/and3_4.sym} 84500 -24390 0 0 {name=X_48579_ }
C {devices/lab_pin.sym} 84420 -24270 0 0 {name=p83832 lab=_79387_/A }
C {devices/lab_pin.sym} 84420 -24230 0 0 {name=p83833 lab=_79386_/Y }
C {devices/lab_pin.sym} 84420 -24190 0 0 {name=p83834 lab=_79398_/X }
C {devices/lab_pin.sym} 84580 -24230 0 1 {name=p83835 lab=_79399_/X }
C {sky130_stdcells/a21o_4.sym} 84500 -24230 0 0 {name=X_79399_ }
C {devices/lab_pin.sym} 84440 -24110 0 0 {name=p83836 lab=_48979_/A }
C {devices/lab_pin.sym} 84440 -24070 0 0 {name=p83837 lab=_50560_/X }
C {devices/lab_pin.sym} 84440 -24030 0 0 {name=p83838 lab=_50568_/C }
C {devices/lab_pin.sym} 84560 -24070 0 1 {name=p83839 lab=_50610_/X }
C {sky130_stdcells/and3_4.sym} 84500 -24070 0 0 {name=X_50610_ }
C {devices/lab_pin.sym} 84410 -23930 0 0 {name=p83840 lab=_84049_/CLK }
C {devices/lab_pin.sym} 84410 -23910 0 0 {name=p83841 lab=_81462_/Q }
C {devices/lab_pin.sym} 84590 -23930 0 1 {name=p83842 lab=_76062_/B }
C {sky130_stdcells/dfxtp_4.sym} 84500 -23920 0 0 {name=X_81430_ }
C {devices/lab_pin.sym} 84420 -23810 0 0 {name=p83843 lab=_69148_/X }
C {devices/lab_pin.sym} 84420 -23770 0 0 {name=p83844 lab=_69151_/X }
C {devices/lab_pin.sym} 84420 -23730 0 0 {name=p83845 lab=_69116_/X }
C {devices/lab_pin.sym} 84580 -23770 0 1 {name=p83846 lab=_69152_/X }
C {sky130_stdcells/a21o_4.sym} 84500 -23770 0 0 {name=X_69152_ }
C {devices/lab_pin.sym} 84440 -23650 0 0 {name=p83847 lab=_66318_/X }
C {devices/lab_pin.sym} 84440 -23610 0 0 {name=p83848 lab=_66415_/B }
C {devices/lab_pin.sym} 84440 -23570 0 0 {name=p83849 lab=_66364_/C }
C {devices/lab_pin.sym} 84560 -23610 0 1 {name=p83850 lab=_66364_/X }
C {sky130_stdcells/and3_4.sym} 84500 -23610 0 0 {name=X_66364_ }
C {devices/lab_pin.sym} 84440 -23480 0 0 {name=p83851 lab=_51590_/A }
C {devices/lab_pin.sym} 84440 -23440 0 0 {name=p83852 lab=_53115_/B }
C {devices/lab_pin.sym} 84560 -23460 0 1 {name=p83853 lab=_51590_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -23460 0 0 {name=X_51590_ }
C {devices/lab_pin.sym} 84420 -23370 0 0 {name=p83854 lab=_63556_/X }
C {devices/lab_pin.sym} 84420 -23330 0 0 {name=p83855 lab=_63569_/X }
C {devices/lab_pin.sym} 84420 -23290 0 0 {name=p83856 lab=_63570_/X }
C {devices/lab_pin.sym} 84420 -23250 0 0 {name=p83857 lab=_63574_/X }
C {devices/lab_pin.sym} 84420 -23210 0 0 {name=p83858 lab=_63575_/Y }
C {devices/lab_pin.sym} 84580 -23290 0 1 {name=p83859 lab=_63576_/Y }
C {sky130_stdcells/o41ai_4.sym} 84500 -23290 0 0 {name=X_63576_ }
C {devices/lab_pin.sym} 84460 -23130 0 0 {name=p83860 lab=_60558_/X }
C {devices/lab_pin.sym} 84540 -23130 0 1 {name=p83861 lab=_60792_/A }
C {sky130_stdcells/buf_2.sym} 84500 -23130 0 0 {name=X_60788_ }
C {devices/lab_pin.sym} 84420 -23040 0 0 {name=p83862 lab=_68097_/X }
C {devices/lab_pin.sym} 84420 -23000 0 0 {name=p83863 lab=_66650_/Y }
C {devices/lab_pin.sym} 84420 -22960 0 0 {name=p83864 lab=_68089_/X }
C {devices/lab_pin.sym} 84420 -22920 0 0 {name=p83865 lab=_68102_/Y }
C {devices/lab_pin.sym} 84580 -22980 0 1 {name=p83866 lab=_68103_/X }
C {sky130_stdcells/a211o_4.sym} 84500 -22980 0 0 {name=X_68103_ }
C {devices/lab_pin.sym} 84440 -22840 0 0 {name=p83867 lab=_65836_/A }
C {devices/lab_pin.sym} 84440 -22800 0 0 {name=p83868 lab=_65315_/B }
C {devices/lab_pin.sym} 84560 -22820 0 1 {name=p83869 lab=_65315_/X }
C {sky130_stdcells/and2_4.sym} 84500 -22820 0 0 {name=X_65315_ }
C {devices/lab_pin.sym} 84440 -22700 0 0 {name=p83870 lab=_50541_/A }
C {devices/lab_pin.sym} 84440 -22660 0 0 {name=p83871 lab=_48673_/B }
C {devices/lab_pin.sym} 84560 -22680 0 1 {name=p83872 lab=_50541_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -22680 0 0 {name=X_50541_ }
C {devices/lab_pin.sym} 84440 -22570 0 0 {name=p83873 lab=_62483_/X }
C {devices/lab_pin.sym} 84440 -22530 0 0 {name=p83874 lab=_62541_/B }
C {devices/lab_pin.sym} 84440 -22490 0 0 {name=p83875 lab=_62527_/C }
C {devices/lab_pin.sym} 84560 -22530 0 1 {name=p83876 lab=_62527_/Y }
C {sky130_stdcells/nor3_4.sym} 84500 -22530 0 0 {name=X_62527_ }
C {devices/lab_pin.sym} 84410 -22390 0 0 {name=p83877 lab=_81361_/CLK }
C {devices/lab_pin.sym} 84410 -22370 0 0 {name=p83878 lab=_81361_/D }
C {devices/lab_pin.sym} 84590 -22390 0 1 {name=p83879 lab=_81361_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -22380 0 0 {name=X_81361_ }
C {devices/lab_pin.sym} 84420 -22270 0 0 {name=p83880 lab=_69080_/X }
C {devices/lab_pin.sym} 84420 -22230 0 0 {name=p83881 lab=_69082_/X }
C {devices/lab_pin.sym} 84420 -22190 0 0 {name=p83882 lab=_69017_/X }
C {devices/lab_pin.sym} 84580 -22230 0 1 {name=p83883 lab=_69083_/Y }
C {sky130_stdcells/a21oi_4.sym} 84500 -22230 0 0 {name=X_69083_ }
C {devices/lab_pin.sym} 84460 -22090 0 0 {name=p83884 lab=_66180_/A }
C {devices/lab_pin.sym} 84540 -22090 0 1 {name=p83885 lab=_66295_/X }
C {sky130_stdcells/buf_2.sym} 84500 -22090 0 0 {name=X_66295_ }
C {devices/lab_pin.sym} 84460 -21970 0 0 {name=p83886 lab=clkbuf_8_49_0_CLK/A }
C {devices/lab_pin.sym} 84540 -21970 0 1 {name=p83887 lab=clkbuf_9_99_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 84500 -21970 0 0 {name=Xclkbuf_8_49_0_CLK }
C {devices/lab_pin.sym} 84410 -21850 0 0 {name=p83888 lab=_83846_/CLK }
C {devices/lab_pin.sym} 84410 -21830 0 0 {name=p83889 lab=_83100_/D }
C {devices/lab_pin.sym} 84590 -21850 0 1 {name=p83890 lab=_70304_/C }
C {sky130_stdcells/dfxtp_4.sym} 84500 -21840 0 0 {name=X_83100_ }
C {devices/lab_pin.sym} 84440 -21720 0 0 {name=p83891 lab=_84749_/Q }
C {devices/lab_pin.sym} 84440 -21680 0 0 {name=p83892 lab=_66319_/C }
C {devices/lab_pin.sym} 84560 -21700 0 1 {name=p83893 lab=_80313_/A }
C {sky130_stdcells/nor2_4.sym} 84500 -21700 0 0 {name=X_80312_ }
C {devices/lab_pin.sym} 84420 -21590 0 0 {name=p83894 lab=_68029_/X }
C {devices/lab_pin.sym} 84420 -21550 0 0 {name=p83895 lab=_68032_/X }
C {devices/lab_pin.sym} 84420 -21510 0 0 {name=p83896 lab=_68033_/X }
C {devices/lab_pin.sym} 84580 -21550 0 1 {name=p83897 lab=_68034_/X }
C {sky130_stdcells/a21o_4.sym} 84500 -21550 0 0 {name=X_68034_ }
C {devices/lab_pin.sym} 84420 -21430 0 0 {name=p83898 lab=_85666_/Q }
C {devices/lab_pin.sym} 84420 -21390 0 0 {name=p83899 lab=_51929_/X }
C {devices/lab_pin.sym} 84420 -21350 0 0 {name=p83900 lab=_53259_/Y }
C {devices/lab_pin.sym} 84580 -21390 0 1 {name=p83901 lab=_53260_/Y }
C {sky130_stdcells/o21ai_4.sym} 84500 -21390 0 0 {name=X_53260_ }
C {devices/lab_pin.sym} 84420 -21270 0 0 {name=p83902 lab=_65243_/Y }
C {devices/lab_pin.sym} 84420 -21230 0 0 {name=p83903 lab=_65195_/X }
C {devices/lab_pin.sym} 84420 -21190 0 0 {name=p83904 lab=_65245_/X }
C {devices/lab_pin.sym} 84580 -21230 0 1 {name=p83905 lab=_65246_/X }
C {sky130_stdcells/a21o_4.sym} 84500 -21230 0 0 {name=X_65246_ }
C {devices/lab_pin.sym} 84410 -21090 0 0 {name=p83906 lab=_84079_/CLK }
C {devices/lab_pin.sym} 84410 -21070 0 0 {name=p83907 lab=_84080_/D }
C {devices/lab_pin.sym} 84590 -21090 0 1 {name=p83908 lab=_84080_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -21080 0 0 {name=X_84080_ }
C {devices/lab_pin.sym} 84420 -20970 0 0 {name=p83909 lab=_86194_/Q }
C {devices/lab_pin.sym} 84420 -20930 0 0 {name=p83910 lab=_50387_/X }
C {devices/lab_pin.sym} 84420 -20890 0 0 {name=p83911 lab=_50471_/Y }
C {devices/lab_pin.sym} 84580 -20930 0 1 {name=p83912 lab=_50472_/Y }
C {sky130_stdcells/o21ai_4.sym} 84500 -20930 0 0 {name=X_50472_ }
C {devices/lab_pin.sym} 84410 -20790 0 0 {name=p83913 lab=_81620_/CLK }
C {devices/lab_pin.sym} 84410 -20770 0 0 {name=p83914 lab=_76980_/X }
C {devices/lab_pin.sym} 84590 -20790 0 1 {name=p83915 lab=_81260_/D }
C {sky130_stdcells/dfxtp_4.sym} 84500 -20780 0 0 {name=X_81292_ }
C {devices/lab_pin.sym} 84440 -20680 0 0 {name=p83916 lab=_61542_/A }
C {devices/lab_pin.sym} 84440 -20640 0 0 {name=p83917 lab=_62472_/B }
C {devices/lab_pin.sym} 84440 -20600 0 0 {name=p83918 lab=_62490_/C }
C {devices/lab_pin.sym} 84440 -20560 0 0 {name=p83919 lab=_62431_/D }
C {devices/lab_pin.sym} 84560 -20620 0 1 {name=p83920 lab=_62458_/Y }
C {sky130_stdcells/nand4_4.sym} 84500 -20620 0 0 {name=X_62458_ }
C {devices/lab_pin.sym} 84420 -20490 0 0 {name=p83921 lab=_85867_/Q }
C {devices/lab_pin.sym} 84420 -20450 0 0 {name=p83922 lab=_52178_/X }
C {devices/lab_pin.sym} 84420 -20410 0 0 {name=p83923 lab=_52210_/Y }
C {devices/lab_pin.sym} 84580 -20450 0 1 {name=p83924 lab=_52211_/Y }
C {sky130_stdcells/o21ai_4.sym} 84500 -20450 0 0 {name=X_52211_ }
C {devices/lab_pin.sym} 84410 -20310 0 0 {name=p83925 lab=_85269_/CLK }
C {devices/lab_pin.sym} 84410 -20290 0 0 {name=p83926 lab=_83031_/D }
C {devices/lab_pin.sym} 84590 -20310 0 1 {name=p83927 lab=_83031_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -20300 0 0 {name=X_83031_ }
C {devices/lab_pin.sym} 84440 -20200 0 0 {name=p83928 lab=_64282_/A }
C {devices/lab_pin.sym} 84440 -20160 0 0 {name=p83929 lab=_61452_/B }
C {devices/lab_pin.sym} 84440 -20120 0 0 {name=p83930 lab=_61452_/C }
C {devices/lab_pin.sym} 84440 -20080 0 0 {name=p83931 lab=_61391_/D }
C {devices/lab_pin.sym} 84560 -20140 0 1 {name=p83932 lab=_61409_/Y }
C {sky130_stdcells/nand4_4.sym} 84500 -20140 0 0 {name=X_61409_ }
C {devices/lab_pin.sym} 84440 -20000 0 0 {name=p83933 lab=_80239_/Y }
C {devices/lab_pin.sym} 84440 -19960 0 0 {name=p83934 lab=_80242_/Y }
C {devices/lab_pin.sym} 84560 -19980 0 1 {name=p83935 lab=_80243_/X }
C {sky130_stdcells/xor2_4.sym} 84500 -19980 0 0 {name=X_80243_ }
C {devices/lab_pin.sym} 84440 -19880 0 0 {name=p83936 lab=_53211_/A }
C {devices/lab_pin.sym} 84440 -19840 0 0 {name=p83937 lab=_53181_/B }
C {devices/lab_pin.sym} 84440 -19800 0 0 {name=p83938 lab=_53169_/X }
C {devices/lab_pin.sym} 84440 -19760 0 0 {name=p83939 lab=_53191_/D }
C {devices/lab_pin.sym} 84560 -19820 0 1 {name=p83940 lab=_53191_/X }
C {sky130_stdcells/and4_4.sym} 84500 -19820 0 0 {name=X_53191_ }
C {devices/lab_pin.sym} 84420 -19690 0 0 {name=p83941 lab=_65174_/X }
C {devices/lab_pin.sym} 84420 -19650 0 0 {name=p83942 lab=_65176_/X }
C {devices/lab_pin.sym} 84420 -19610 0 0 {name=p83943 lab=_65161_/X }
C {devices/lab_pin.sym} 84580 -19650 0 1 {name=p83944 lab=_65177_/X }
C {sky130_stdcells/a21o_4.sym} 84500 -19650 0 0 {name=X_65177_ }
C {devices/lab_pin.sym} 84440 -19540 0 0 {name=p83945 lab=_62406_/A }
C {devices/lab_pin.sym} 84440 -19500 0 0 {name=p83946 lab=_62389_/B }
C {devices/lab_pin.sym} 84440 -19460 0 0 {name=p83947 lab=_62387_/Y }
C {devices/lab_pin.sym} 84440 -19420 0 0 {name=p83948 lab=_62389_/D }
C {devices/lab_pin.sym} 84560 -19480 0 1 {name=p83949 lab=_62389_/Y }
C {sky130_stdcells/nand4_4.sym} 84500 -19480 0 0 {name=X_62389_ }
C {devices/lab_pin.sym} 84420 -19350 0 0 {name=p83950 lab=_52138_/Y }
C {devices/lab_pin.sym} 84420 -19310 0 0 {name=p83951 lab=_52108_/X }
C {devices/lab_pin.sym} 84420 -19270 0 0 {name=p83952 lab=_52141_/X }
C {devices/lab_pin.sym} 84580 -19310 0 1 {name=p83953 lab=_85881_/D }
C {sky130_stdcells/a21oi_4.sym} 84500 -19310 0 0 {name=X_52142_ }
C {devices/lab_pin.sym} 84420 -19210 0 0 {name=p83954 lab=_64124_/X }
C {devices/lab_pin.sym} 84420 -19170 0 0 {name=p83955 lab=_64048_/X }
C {devices/lab_pin.sym} 84420 -19130 0 0 {name=p83956 lab=_64125_/Y }
C {devices/lab_pin.sym} 84420 -19090 0 0 {name=p83957 lab=_64126_/Y }
C {devices/lab_pin.sym} 84420 -19060 0 0 {name=p83958 lab=_64127_/X }
C {devices/lab_pin.sym} 84580 -19130 0 1 {name=p83959 lab=_64128_/X }
C {sky130_stdcells/a41o_4.sym} 84500 -19130 0 0 {name=X_64128_ }
C {devices/lab_pin.sym} 84440 -18980 0 0 {name=p83960 lab=_84946_/Q }
C {devices/lab_pin.sym} 84440 -18940 0 0 {name=p83961 lab=_65546_/C }
C {devices/lab_pin.sym} 84560 -18960 0 1 {name=p83962 lab=_80176_/A }
C {sky130_stdcells/xor2_4.sym} 84500 -18960 0 0 {name=X_80174_ }
C {devices/lab_pin.sym} 84420 -18850 0 0 {name=p83963 lab=_68420_/X }
C {devices/lab_pin.sym} 84420 -18810 0 0 {name=p83964 lab=_68423_/X }
C {devices/lab_pin.sym} 84420 -18770 0 0 {name=p83965 lab=_69925_/X }
C {devices/lab_pin.sym} 84580 -18810 0 1 {name=p83966 lab=_69985_/Y }
C {sky130_stdcells/a21oi_4.sym} 84500 -18810 0 0 {name=X_69985_ }
C {devices/lab_pin.sym} 84420 -18690 0 0 {name=p83967 lab=_52071_/Y }
C {devices/lab_pin.sym} 84420 -18650 0 0 {name=p83968 lab=_52066_/X }
C {devices/lab_pin.sym} 84420 -18610 0 0 {name=p83969 lab=_52072_/Y }
C {devices/lab_pin.sym} 84580 -18650 0 1 {name=p83970 lab=_85894_/D }
C {sky130_stdcells/a21boi_4.sym} 84500 -18650 0 0 {name=X_52073_ }
C {devices/lab_pin.sym} 84420 -18540 0 0 {name=p83971 lab=_56949_/X }
C {devices/lab_pin.sym} 84420 -18500 0 0 {name=p83972 lab=_56589_/X }
C {devices/lab_pin.sym} 84420 -18460 0 0 {name=p83973 lab=_85116_/Q }
C {devices/lab_pin.sym} 84420 -18420 0 0 {name=p83974 lab=_56947_/X }
C {devices/lab_pin.sym} 84580 -18480 0 1 {name=p83975 lab=_85116_/D }
C {sky130_stdcells/a2bb2o_4.sym} 84500 -18480 0 0 {name=X_56950_ }
C {devices/lab_pin.sym} 84440 -18360 0 0 {name=p83976 lab=_84837_/Q }
C {devices/lab_pin.sym} 84440 -18320 0 0 {name=p83977 lab=_64091_/B }
C {devices/lab_pin.sym} 84440 -18280 0 0 {name=p83978 lab=_64091_/C }
C {devices/lab_pin.sym} 84440 -18240 0 0 {name=p83979 lab=_64091_/D }
C {devices/lab_pin.sym} 84560 -18300 0 1 {name=p83980 lab=_64059_/Y }
C {sky130_stdcells/nand4_4.sym} 84500 -18300 0 0 {name=X_64059_ }
C {devices/lab_pin.sym} 84410 -18150 0 0 {name=p83981 lab=_87525_/CLK }
C {devices/lab_pin.sym} 84410 -18130 0 0 {name=p83982 lab=_87770_/D }
C {devices/lab_pin.sym} 84590 -18150 0 1 {name=p83983 lab=_69480_/B }
C {sky130_stdcells/dfxtp_4.sym} 84500 -18140 0 0 {name=X_87770_ }
C {devices/lab_pin.sym} 84420 -18040 0 0 {name=p83984 lab=_74095_/A }
C {devices/lab_pin.sym} 84420 -18000 0 0 {name=p83985 lab=_68792_/X }
C {devices/lab_pin.sym} 84420 -17960 0 0 {name=p83986 lab=_68933_/X }
C {devices/lab_pin.sym} 84420 -17920 0 0 {name=p83987 lab=_68935_/Y }
C {devices/lab_pin.sym} 84580 -17980 0 1 {name=p83988 lab=_68936_/X }
C {sky130_stdcells/a211o_4.sym} 84500 -17980 0 0 {name=X_68936_ }
C {devices/lab_pin.sym} 84410 -17830 0 0 {name=p83989 lab=_86587_/CLK }
C {devices/lab_pin.sym} 84410 -17810 0 0 {name=p83990 lab=_57545_/Y }
C {devices/lab_pin.sym} 84590 -17830 0 1 {name=p83991 lab=_84982_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -17820 0 0 {name=X_84982_ }
C {devices/lab_pin.sym} 84440 -17720 0 0 {name=p83992 lab=_51018_/A }
C {devices/lab_pin.sym} 84440 -17680 0 0 {name=p83993 lab=_51029_/B }
C {devices/lab_pin.sym} 84440 -17640 0 0 {name=p83994 lab=_51029_/C }
C {devices/lab_pin.sym} 84440 -17600 0 0 {name=p83995 lab=_52716_/D }
C {devices/lab_pin.sym} 84560 -17660 0 1 {name=p83996 lab=_51024_/X }
C {sky130_stdcells/and4_4.sym} 84500 -17660 0 0 {name=X_51024_ }
C {devices/lab_pin.sym} 84420 -17540 0 0 {name=p83997 lab=_83031_/Q }
C {devices/lab_pin.sym} 84420 -17500 0 0 {name=p83998 lab=_55607_/A }
C {devices/lab_pin.sym} 84420 -17460 0 0 {name=p83999 lab=_44101_/A }
C {devices/lab_pin.sym} 84420 -17420 0 0 {name=p84000 lab=_55900_/X }
C {devices/lab_pin.sym} 84580 -17480 0 1 {name=p84001 lab=_55901_/X }
C {sky130_stdcells/a211o_4.sym} 84500 -17480 0 0 {name=X_55901_ }
C {devices/lab_pin.sym} 84410 -17330 0 0 {name=p84002 lab=_85471_/CLK }
C {devices/lab_pin.sym} 84410 -17310 0 0 {name=p84003 lab=_46621_/Y }
C {devices/lab_pin.sym} 84590 -17330 0 1 {name=p84004 lab=_86721_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -17320 0 0 {name=X_86721_ }
C {devices/lab_pin.sym} 84410 -17190 0 0 {name=p84005 lab=_83933_/CLK }
C {devices/lab_pin.sym} 84410 -17170 0 0 {name=p84006 lab=_69314_/X }
C {devices/lab_pin.sym} 84590 -17190 0 1 {name=p84007 lab=_83933_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -17180 0 0 {name=X_83933_ }
C {devices/lab_pin.sym} 84440 -17060 0 0 {name=p84008 lab=_55674_/A }
C {devices/lab_pin.sym} 84440 -17020 0 0 {name=p84009 lab=_46234_/Y }
C {devices/lab_pin.sym} 84560 -17040 0 1 {name=p84010 lab=_56881_/X }
C {sky130_stdcells/and2_4.sym} 84500 -17040 0 0 {name=X_56881_ }
C {devices/lab_pin.sym} 84420 -16930 0 0 {name=p84011 lab=_68863_/X }
C {devices/lab_pin.sym} 84420 -16890 0 0 {name=p84012 lab=_68866_/X }
C {devices/lab_pin.sym} 84420 -16850 0 0 {name=p84013 lab=_68846_/X }
C {devices/lab_pin.sym} 84580 -16890 0 1 {name=p84014 lab=_68867_/Y }
C {sky130_stdcells/a21oi_4.sym} 84500 -16890 0 0 {name=X_68867_ }
C {devices/lab_pin.sym} 84420 -16770 0 0 {name=p84015 lab=_58618_/X }
C {devices/lab_pin.sym} 84420 -16730 0 0 {name=p84016 lab=_86109_/Q }
C {devices/lab_pin.sym} 84420 -16690 0 0 {name=p84017 lab=_58619_/X }
C {devices/lab_pin.sym} 84580 -16730 0 1 {name=p84018 lab=_58620_/Y }
C {sky130_stdcells/o21ai_4.sym} 84500 -16730 0 0 {name=X_58620_ }
C {devices/lab_pin.sym} 84420 -16620 0 0 {name=p84019 lab=_85265_/Q }
C {devices/lab_pin.sym} 84420 -16580 0 0 {name=p84020 lab=_55475_/X }
C {devices/lab_pin.sym} 84420 -16540 0 0 {name=p84021 lab=_44048_/X }
C {devices/lab_pin.sym} 84420 -16500 0 0 {name=p84022 lab=_55831_/X }
C {devices/lab_pin.sym} 84580 -16560 0 1 {name=p84023 lab=_55832_/X }
C {sky130_stdcells/a211o_4.sym} 84500 -16560 0 0 {name=X_55832_ }
C {devices/lab_pin.sym} 84440 -16420 0 0 {name=p84024 lab=_67817_/X }
C {devices/lab_pin.sym} 84440 -16380 0 0 {name=p84025 lab=_87647_/Q }
C {devices/lab_pin.sym} 84560 -16400 0 1 {name=p84026 lab=_67818_/X }
C {sky130_stdcells/and2_4.sym} 84500 -16400 0 0 {name=X_67818_ }
C {devices/lab_pin.sym} 84410 -16270 0 0 {name=p84027 lab=_86651_/CLK }
C {devices/lab_pin.sym} 84410 -16250 0 0 {name=p84028 lab=_47276_/Y }
C {devices/lab_pin.sym} 84590 -16270 0 1 {name=p84029 lab=_86652_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -16260 0 0 {name=X_86652_ }
C {devices/lab_pin.sym} 84410 -16130 0 0 {name=p84030 lab=_82541_/CLK }
C {devices/lab_pin.sym} 84410 -16110 0 0 {name=p84031 lab=_70047_/X }
C {devices/lab_pin.sym} 84590 -16130 0 1 {name=p84032 lab=_82544_/D }
C {sky130_stdcells/dfxtp_4.sym} 84500 -16120 0 0 {name=X_83864_ }
C {devices/lab_pin.sym} 84440 -16000 0 0 {name=p84033 lab=_68795_/X }
C {devices/lab_pin.sym} 84440 -15960 0 0 {name=p84034 lab=_68798_/B }
C {devices/lab_pin.sym} 84560 -15980 0 1 {name=p84035 lab=_68798_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -15980 0 0 {name=X_68798_ }
C {devices/lab_pin.sym} 84410 -15850 0 0 {name=p84036 lab=_85599_/CLK }
C {devices/lab_pin.sym} 84410 -15830 0 0 {name=p84037 lab=_85603_/D }
C {devices/lab_pin.sym} 84590 -15850 0 1 {name=p84038 lab=_85603_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -15840 0 0 {name=X_85603_ }
C {devices/lab_pin.sym} 84410 -15710 0 0 {name=p84039 lab=_82152_/CLK }
C {devices/lab_pin.sym} 84410 -15690 0 0 {name=p84040 lab=_82847_/Q }
C {devices/lab_pin.sym} 84590 -15710 0 1 {name=p84041 lab=_78749_/A }
C {sky130_stdcells/dfxtp_4.sym} 84500 -15700 0 0 {name=X_82815_ }
C {devices/lab_pin.sym} 84440 -15580 0 0 {name=p84042 lab=_58551_/A }
C {devices/lab_pin.sym} 84440 -15540 0 0 {name=p84043 lab=_58557_/B }
C {devices/lab_pin.sym} 84560 -15560 0 1 {name=p84044 lab=_58551_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -15560 0 0 {name=X_58551_ }
C {devices/lab_pin.sym} 84420 -15450 0 0 {name=p84045 lab=_55760_/Y }
C {devices/lab_pin.sym} 84420 -15410 0 0 {name=p84046 lab=_44095_/X }
C {devices/lab_pin.sym} 84420 -15370 0 0 {name=p84047 lab=_55762_/X }
C {devices/lab_pin.sym} 84580 -15410 0 1 {name=p84048 lab=_56117_/C }
C {sky130_stdcells/a21boi_4.sym} 84500 -15410 0 0 {name=X_55763_ }
C {devices/lab_pin.sym} 84440 -15280 0 0 {name=p84049 lab=_67793_/A }
C {devices/lab_pin.sym} 84440 -15240 0 0 {name=p84050 lab=_87714_/Q }
C {devices/lab_pin.sym} 84560 -15260 0 1 {name=p84051 lab=_67749_/X }
C {sky130_stdcells/and2_4.sym} 84500 -15260 0 0 {name=X_67749_ }
C {devices/lab_pin.sym} 84410 -15130 0 0 {name=p84052 lab=_86554_/CLK }
C {devices/lab_pin.sym} 84410 -15110 0 0 {name=p84053 lab=_47947_/Y }
C {devices/lab_pin.sym} 84590 -15130 0 1 {name=p84054 lab=_66055_/B }
C {sky130_stdcells/dfxtp_4.sym} 84500 -15120 0 0 {name=X_86583_ }
C {devices/lab_pin.sym} 84460 -14990 0 0 {name=p84055 lab=_52892_/A }
C {devices/lab_pin.sym} 84540 -14990 0 1 {name=p84056 lab=_52975_/X }
C {sky130_stdcells/buf_2.sym} 84500 -14990 0 0 {name=X_52975_ }
C {devices/lab_pin.sym} 84410 -14870 0 0 {name=p84057 lab=_83819_/CLK }
C {devices/lab_pin.sym} 84410 -14850 0 0 {name=p84058 lab=_70329_/X }
C {devices/lab_pin.sym} 84590 -14870 0 1 {name=p84059 lab=_74742_/B }
C {sky130_stdcells/dfxtp_4.sym} 84500 -14860 0 0 {name=X_83795_ }
C {devices/lab_pin.sym} 84420 -14750 0 0 {name=p84060 lab=_57500_/Y }
C {devices/lab_pin.sym} 84420 -14710 0 0 {name=p84061 lab=_46576_/X }
C {devices/lab_pin.sym} 84420 -14670 0 0 {name=p84062 lab=_57501_/Y }
C {devices/lab_pin.sym} 84580 -14710 0 1 {name=p84063 lab=_84991_/D }
C {sky130_stdcells/a21boi_4.sym} 84500 -14710 0 0 {name=X_57502_ }
C {devices/lab_pin.sym} 84410 -14570 0 0 {name=p84064 lab=_88060_/CLK }
C {devices/lab_pin.sym} 84410 -14550 0 0 {name=p84065 lab=_88322_/D }
C {devices/lab_pin.sym} 84590 -14570 0 1 {name=p84066 lab=_88322_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -14560 0 0 {name=X_88322_ }
C {devices/lab_pin.sym} 84440 -14440 0 0 {name=p84067 lab=_54718_/A }
C {devices/lab_pin.sym} 84440 -14400 0 0 {name=p84068 lab=_47394_/Y }
C {devices/lab_pin.sym} 84560 -14420 0 1 {name=p84069 lab=_54714_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -14420 0 0 {name=X_54714_ }
C {devices/lab_pin.sym} 84410 -14290 0 0 {name=p84070 lab=_85535_/CLK }
C {devices/lab_pin.sym} 84410 -14270 0 0 {name=p84071 lab=_85534_/D }
C {devices/lab_pin.sym} 84590 -14290 0 1 {name=p84072 lab=_85534_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -14280 0 0 {name=X_85534_ }
C {devices/lab_pin.sym} 84460 -14150 0 0 {name=p84073 lab=_51926_/A }
C {devices/lab_pin.sym} 84540 -14150 0 1 {name=p84074 lab=_85921_/D }
C {sky130_stdcells/inv_2.sym} 84500 -14150 0 0 {name=X_51926_ }
C {devices/lab_pin.sym} 84440 -14040 0 0 {name=p84075 lab=_70698_/A }
C {devices/lab_pin.sym} 84440 -14000 0 0 {name=p84076 lab=_70760_/B }
C {devices/lab_pin.sym} 84560 -14020 0 1 {name=p84077 lab=_70761_/A }
C {sky130_stdcells/nor2_4.sym} 84500 -14020 0 0 {name=X_70760_ }
C {devices/lab_pin.sym} 84460 -13890 0 0 {name=p84078 lab=_58510_/A }
C {devices/lab_pin.sym} 84540 -13890 0 1 {name=p84079 lab=_58502_/B }
C {sky130_stdcells/buf_2.sym} 84500 -13890 0 0 {name=X_58482_ }
C {devices/lab_pin.sym} 84410 -13770 0 0 {name=p84080 lab=_82746_/CLK }
C {devices/lab_pin.sym} 84410 -13750 0 0 {name=p84081 lab=_79435_/B }
C {devices/lab_pin.sym} 84590 -13770 0 1 {name=p84082 lab=_82746_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -13760 0 0 {name=X_82746_ }
C {devices/lab_pin.sym} 84460 -13630 0 0 {name=p84083 lab=_55691_/A }
C {devices/lab_pin.sym} 84540 -13630 0 1 {name=p84084 lab=_55695_/A }
C {sky130_stdcells/buf_2.sym} 84500 -13630 0 0 {name=X_55694_ }
C {devices/lab_pin.sym} 84420 -13530 0 0 {name=p84085 lab=_57484_/A }
C {devices/lab_pin.sym} 84420 -13490 0 0 {name=p84086 lab=_57431_/Y }
C {devices/lab_pin.sym} 84420 -13450 0 0 {name=p84087 lab=_57432_/Y }
C {devices/lab_pin.sym} 84580 -13490 0 1 {name=p84088 lab=_57434_/A }
C {sky130_stdcells/a21o_4.sym} 84500 -13490 0 0 {name=X_57433_ }
C {devices/lab_pin.sym} 84420 -13370 0 0 {name=p84089 lab=_68874_/X }
C {devices/lab_pin.sym} 84420 -13330 0 0 {name=p84090 lab=_68877_/X }
C {devices/lab_pin.sym} 84420 -13290 0 0 {name=p84091 lab=_69418_/X }
C {devices/lab_pin.sym} 84580 -13330 0 1 {name=p84092 lab=_69419_/Y }
C {sky130_stdcells/a21oi_4.sym} 84500 -13330 0 0 {name=X_69419_ }
C {devices/lab_pin.sym} 84410 -13190 0 0 {name=p84093 lab=_87103_/CLK }
C {devices/lab_pin.sym} 84410 -13170 0 0 {name=p84094 lab=_88253_/D }
C {devices/lab_pin.sym} 84590 -13190 0 1 {name=p84095 lab=_68924_/B }
C {sky130_stdcells/dfxtp_4.sym} 84500 -13180 0 0 {name=X_88253_ }
C {devices/lab_pin.sym} 84440 -13080 0 0 {name=p84096 lab=_54667_/A }
C {devices/lab_pin.sym} 84440 -13040 0 0 {name=p84097 lab=_54645_/B }
C {devices/lab_pin.sym} 84440 -13000 0 0 {name=p84098 lab=_54644_/X }
C {devices/lab_pin.sym} 84440 -12960 0 0 {name=p84099 lab=_54645_/D }
C {devices/lab_pin.sym} 84560 -13020 0 1 {name=p84100 lab=_54645_/X }
C {sky130_stdcells/and4_4.sym} 84500 -13020 0 0 {name=X_54645_ }
C {devices/lab_pin.sym} 84410 -12870 0 0 {name=p84101 lab=_82768_/CLK }
C {devices/lab_pin.sym} 84410 -12850 0 0 {name=p84102 lab=_85465_/D }
C {devices/lab_pin.sym} 84590 -12870 0 1 {name=p84103 lab=_85465_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -12860 0 0 {name=X_85465_ }
C {devices/lab_pin.sym} 84440 -12740 0 0 {name=p84104 lab=_51853_/A }
C {devices/lab_pin.sym} 84440 -12700 0 0 {name=p84105 lab=_46805_/X }
C {devices/lab_pin.sym} 84560 -12720 0 1 {name=p84106 lab=_51857_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -12720 0 0 {name=X_51857_ }
C {devices/lab_pin.sym} 84460 -12590 0 0 {name=p84107 lab=_70570_/Y }
C {devices/lab_pin.sym} 84540 -12590 0 1 {name=p84108 lab=_70692_/A }
C {sky130_stdcells/buf_2.sym} 84500 -12590 0 0 {name=X_70691_ }
C {devices/lab_pin.sym} 84410 -12470 0 0 {name=p84109 lab=_82671_/CLK }
C {devices/lab_pin.sym} 84410 -12450 0 0 {name=p84110 lab=_82677_/D }
C {devices/lab_pin.sym} 84590 -12470 0 1 {name=p84111 lab=_82677_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -12460 0 0 {name=X_82677_ }
C {devices/lab_pin.sym} 84410 -12330 0 0 {name=p84112 lab=_87150_/CLK }
C {devices/lab_pin.sym} 84410 -12310 0 0 {name=p84113 lab=_43910_/X }
C {devices/lab_pin.sym} 84590 -12330 0 1 {name=p84114 lab=_87204_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -12320 0 0 {name=X_87204_ }
C {devices/lab_pin.sym} 84460 -12190 0 0 {name=p84115 lab=_41610_/A }
C {devices/lab_pin.sym} 84540 -12190 0 1 {name=p84116 lab=_41610_/Y }
C {sky130_stdcells/inv_2.sym} 84500 -12190 0 0 {name=X_41610_ }
C {devices/lab_pin.sym} 84420 -12090 0 0 {name=p84117 lab=_64758_/X }
C {devices/lab_pin.sym} 84420 -12050 0 0 {name=p84118 lab=_85319_/Q }
C {devices/lab_pin.sym} 84420 -12010 0 0 {name=p84119 lab=_72386_/X }
C {devices/lab_pin.sym} 84580 -12050 0 1 {name=p84120 lab=_72430_/X }
C {sky130_stdcells/o21a_4.sym} 84500 -12050 0 0 {name=X_72430_ }
C {devices/lab_pin.sym} 84410 -11910 0 0 {name=p84121 lab=_84403_/CLK }
C {devices/lab_pin.sym} 84410 -11890 0 0 {name=p84122 lab=_84416_/D }
C {devices/lab_pin.sym} 84590 -11910 0 1 {name=p84123 lab=_84416_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -11900 0 0 {name=X_84416_ }
C {devices/lab_pin.sym} 84440 -11780 0 0 {name=p84124 lab=_50787_/X }
C {devices/lab_pin.sym} 84440 -11740 0 0 {name=p84125 lab=_50808_/B }
C {devices/lab_pin.sym} 84560 -11760 0 1 {name=p84126 lab=_50808_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -11760 0 0 {name=X_50808_ }
C {devices/lab_pin.sym} 84440 -11660 0 0 {name=p84127 lab=_57222_/Y }
C {devices/lab_pin.sym} 84440 -11620 0 0 {name=p84128 lab=_56275_/X }
C {devices/lab_pin.sym} 84440 -11580 0 0 {name=p84129 lab=_73191_/B }
C {devices/lab_pin.sym} 84440 -11540 0 0 {name=p84130 lab=_57364_/D }
C {devices/lab_pin.sym} 84560 -11600 0 1 {name=p84131 lab=_57364_/X }
C {sky130_stdcells/and4_4.sym} 84500 -11600 0 0 {name=X_57364_ }
C {devices/lab_pin.sym} 84410 -11450 0 0 {name=p84132 lab=_81275_/CLK }
C {devices/lab_pin.sym} 84410 -11430 0 0 {name=p84133 lab=_76548_/X }
C {devices/lab_pin.sym} 84590 -11450 0 1 {name=p84134 lab=_81628_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -11440 0 0 {name=X_81628_ }
C {devices/lab_pin.sym} 84410 -11310 0 0 {name=p84135 lab=_87110_/CLK }
C {devices/lab_pin.sym} 84410 -11290 0 0 {name=p84136 lab=_88184_/D }
C {devices/lab_pin.sym} 84590 -11310 0 1 {name=p84137 lab=_67231_/B }
C {sky130_stdcells/dfxtp_4.sym} 84500 -11300 0 0 {name=X_88184_ }
C {devices/lab_pin.sym} 84460 -11170 0 0 {name=p84138 lab=_42590_/A }
C {devices/lab_pin.sym} 84540 -11170 0 1 {name=p84139 lab=_42590_/X }
C {sky130_stdcells/buf_2.sym} 84500 -11170 0 0 {name=X_42590_ }
C {devices/lab_pin.sym} 84440 -11080 0 0 {name=p84140 lab=_54565_/A }
C {devices/lab_pin.sym} 84440 -11040 0 0 {name=p84141 lab=_54585_/B }
C {devices/lab_pin.sym} 84440 -11000 0 0 {name=p84142 lab=_54565_/C }
C {devices/lab_pin.sym} 84440 -10960 0 0 {name=p84143 lab=_54576_/D }
C {devices/lab_pin.sym} 84560 -11020 0 1 {name=p84144 lab=_54576_/X }
C {sky130_stdcells/and4_4.sym} 84500 -11020 0 0 {name=X_54576_ }
C {devices/lab_pin.sym} 84410 -10870 0 0 {name=p84145 lab=_85492_/CLK }
C {devices/lab_pin.sym} 84410 -10850 0 0 {name=p84146 lab=_54690_/Y }
C {devices/lab_pin.sym} 84590 -10870 0 1 {name=p84147 lab=_85396_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -10860 0 0 {name=X_85396_ }
C {devices/lab_pin.sym} 84420 -10750 0 0 {name=p84148 lab=_51785_/Y }
C {devices/lab_pin.sym} 84420 -10710 0 0 {name=p84149 lab=_51767_/X }
C {devices/lab_pin.sym} 84420 -10670 0 0 {name=p84150 lab=_51787_/X }
C {devices/lab_pin.sym} 84580 -10710 0 1 {name=p84151 lab=_85946_/D }
C {sky130_stdcells/a21oi_4.sym} 84500 -10710 0 0 {name=X_51788_ }
C {devices/lab_pin.sym} 84420 -10590 0 0 {name=p84152 lab=_58934_/X }
C {devices/lab_pin.sym} 84420 -10550 0 0 {name=p84153 lab=_85656_/Q }
C {devices/lab_pin.sym} 84420 -10510 0 0 {name=p84154 lab=_59081_/X }
C {devices/lab_pin.sym} 84580 -10550 0 1 {name=p84155 lab=_59103_/X }
C {sky130_stdcells/o21a_4.sym} 84500 -10550 0 0 {name=X_59103_ }
C {devices/lab_pin.sym} 84440 -10430 0 0 {name=p84156 lab=_56309_/A }
C {devices/lab_pin.sym} 84440 -10390 0 0 {name=p84157 lab=_56312_/X }
C {devices/lab_pin.sym} 84440 -10350 0 0 {name=p84158 lab=_85239_/Q }
C {devices/lab_pin.sym} 84560 -10390 0 1 {name=p84159 lab=_56315_/Y }
C {sky130_stdcells/nand3_4.sym} 84500 -10390 0 0 {name=X_56315_ }
C {devices/lab_pin.sym} 84460 -10250 0 0 {name=p84160 lab=clkbuf_9_196_0_CLK/X }
C {devices/lab_pin.sym} 84540 -10250 0 1 {name=p84161 lab=_84477_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 84500 -10250 0 0 {name=Xclkbuf_10_393_0_CLK }
C {devices/lab_pin.sym} 84460 -10130 0 0 {name=p84162 lab=_41490_/A }
C {devices/lab_pin.sym} 84540 -10130 0 1 {name=p84163 lab=_41541_/X }
C {sky130_stdcells/buf_2.sym} 84500 -10130 0 0 {name=X_41541_ }
C {devices/lab_pin.sym} 84410 -10010 0 0 {name=p84164 lab=_87484_/CLK }
C {devices/lab_pin.sym} 84410 -9990 0 0 {name=p84165 lab=_44388_/X }
C {devices/lab_pin.sym} 84590 -10010 0 1 {name=p84166 lab=_87135_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -10000 0 0 {name=X_87135_ }
C {devices/lab_pin.sym} 84440 -9880 0 0 {name=p84167 lab=_53509_/A }
C {devices/lab_pin.sym} 84440 -9840 0 0 {name=p84168 lab=_47978_/A }
C {devices/lab_pin.sym} 84560 -9860 0 1 {name=p84169 lab=_53527_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -9860 0 0 {name=X_53527_ }
C {devices/lab_pin.sym} 84460 -9730 0 0 {name=p84170 lab=_72155_/A }
C {devices/lab_pin.sym} 84540 -9730 0 1 {name=p84171 lab=_72361_/X }
C {sky130_stdcells/buf_2.sym} 84500 -9730 0 0 {name=X_72361_ }
C {devices/lab_pin.sym} 84410 -9610 0 0 {name=p84172 lab=_82263_/CLK }
C {devices/lab_pin.sym} 84410 -9590 0 0 {name=p84173 lab=_84347_/D }
C {devices/lab_pin.sym} 84590 -9610 0 1 {name=p84174 lab=_79363_/A }
C {sky130_stdcells/dfxtp_4.sym} 84500 -9600 0 0 {name=X_84347_ }
C {devices/lab_pin.sym} 84420 -9490 0 0 {name=p84175 lab=_86143_/Q }
C {devices/lab_pin.sym} 84420 -9450 0 0 {name=p84176 lab=_50706_/X }
C {devices/lab_pin.sym} 84420 -9410 0 0 {name=p84177 lab=_50738_/Y }
C {devices/lab_pin.sym} 84580 -9450 0 1 {name=p84178 lab=_50739_/Y }
C {sky130_stdcells/o21ai_4.sym} 84500 -9450 0 0 {name=X_50739_ }
C {devices/lab_pin.sym} 84440 -9320 0 0 {name=p84179 lab=_57295_/A }
C {devices/lab_pin.sym} 84440 -9280 0 0 {name=p84180 lab=_57295_/B }
C {devices/lab_pin.sym} 84560 -9300 0 1 {name=p84181 lab=_57295_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -9300 0 0 {name=X_57295_ }
C {devices/lab_pin.sym} 84410 -9170 0 0 {name=p84182 lab=_84049_/CLK }
C {devices/lab_pin.sym} 84410 -9150 0 0 {name=p84183 lab=_76845_/X }
C {devices/lab_pin.sym} 84590 -9170 0 1 {name=p84184 lab=_81515_/D }
C {sky130_stdcells/dfxtp_4.sym} 84500 -9160 0 0 {name=X_81559_ }
C {devices/lab_pin.sym} 84420 -9050 0 0 {name=p84185 lab=_88348_/Q }
C {devices/lab_pin.sym} 84420 -9010 0 0 {name=p84186 lab=_73153_/X }
C {devices/lab_pin.sym} 84420 -8970 0 0 {name=p84187 lab=_72901_/X }
C {devices/lab_pin.sym} 84580 -9010 0 1 {name=p84188 lab=_74100_/Y }
C {sky130_stdcells/o21ai_4.sym} 84500 -9010 0 0 {name=X_74100_ }
C {devices/lab_pin.sym} 84420 -8890 0 0 {name=p84189 lab=_50341_/B }
C {devices/lab_pin.sym} 84420 -8850 0 0 {name=p84190 lab=_71289_/Y }
C {devices/lab_pin.sym} 84420 -8810 0 0 {name=p84191 lab=_71311_/Y }
C {devices/lab_pin.sym} 84580 -8850 0 1 {name=p84192 lab=_83540_/D }
C {sky130_stdcells/o21ai_4.sym} 84500 -8850 0 0 {name=X_71312_ }
C {devices/lab_pin.sym} 84420 -8730 0 0 {name=p84193 lab=_58961_/X }
C {devices/lab_pin.sym} 84420 -8690 0 0 {name=p84194 lab=_85662_/Q }
C {devices/lab_pin.sym} 84420 -8650 0 0 {name=p84195 lab=_59010_/X }
C {devices/lab_pin.sym} 84580 -8690 0 1 {name=p84196 lab=_59034_/X }
C {sky130_stdcells/o21a_4.sym} 84500 -8690 0 0 {name=X_59034_ }
C {devices/lab_pin.sym} 84460 -8550 0 0 {name=p84197 lab=_44175_/A }
C {devices/lab_pin.sym} 84540 -8550 0 1 {name=p84198 lab=_64642_/A }
C {sky130_stdcells/buf_2.sym} 84500 -8550 0 0 {name=X_44260_ }
C {devices/lab_pin.sym} 84440 -8450 0 0 {name=p84199 lab=_56250_/A }
C {devices/lab_pin.sym} 84440 -8410 0 0 {name=p84200 lab=_56253_/B }
C {devices/lab_pin.sym} 84440 -8370 0 0 {name=p84201 lab=_56246_/C }
C {devices/lab_pin.sym} 84560 -8410 0 1 {name=p84202 lab=_56246_/Y }
C {sky130_stdcells/nand3_4.sym} 84500 -8410 0 0 {name=X_56246_ }
C {devices/lab_pin.sym} 84440 -8280 0 0 {name=p84203 lab=_81058_/Q }
C {devices/lab_pin.sym} 84440 -8240 0 0 {name=p84204 lab=_75080_/B }
C {devices/lab_pin.sym} 84560 -8260 0 1 {name=p84205 lab=_81026_/D }
C {sky130_stdcells/xor2_4.sym} 84500 -8260 0 0 {name=X_75080_ }
C {devices/lab_pin.sym} 84410 -8130 0 0 {name=p84206 lab=_87070_/CLK }
C {devices/lab_pin.sym} 84410 -8110 0 0 {name=p84207 lab=_87066_/D }
C {devices/lab_pin.sym} 84590 -8130 0 1 {name=p84208 lab=_87066_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -8120 0 0 {name=X_87066_ }
C {devices/lab_pin.sym} 84420 -8010 0 0 {name=p84209 lab=_41421_/X }
C {devices/lab_pin.sym} 84420 -7970 0 0 {name=p84210 lab=_82334_/Q }
C {devices/lab_pin.sym} 84420 -7930 0 0 {name=p84211 lab=_41471_/X }
C {devices/lab_pin.sym} 84580 -7970 0 1 {name=p84212 lab=_41472_/X }
C {sky130_stdcells/o21a_4.sym} 84500 -7970 0 0 {name=X_41472_ }
C {devices/lab_pin.sym} 84440 -7840 0 0 {name=p84213 lab=_53458_/A }
C {devices/lab_pin.sym} 84440 -7800 0 0 {name=p84214 lab=_48178_/X }
C {devices/lab_pin.sym} 84560 -7820 0 1 {name=p84215 lab=_53458_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -7820 0 0 {name=X_53458_ }
C {devices/lab_pin.sym} 84460 -7690 0 0 {name=p84216 lab=_59297_/A }
C {devices/lab_pin.sym} 84540 -7690 0 1 {name=p84217 lab=_72292_/X }
C {sky130_stdcells/buf_2.sym} 84500 -7690 0 0 {name=X_72292_ }
C {devices/lab_pin.sym} 84410 -7570 0 0 {name=p84218 lab=_84273_/CLK }
C {devices/lab_pin.sym} 84410 -7550 0 0 {name=p84219 lab=_64056_/Y }
C {devices/lab_pin.sym} 84590 -7570 0 1 {name=p84220 lab=_80049_/B }
C {sky130_stdcells/dfxtp_4.sym} 84500 -7560 0 0 {name=X_84278_ }
C {devices/lab_pin.sym} 84460 -7430 0 0 {name=p84221 lab=_43024_/A }
C {devices/lab_pin.sym} 84540 -7430 0 1 {name=p84222 lab=_43212_/A }
C {sky130_stdcells/buf_2.sym} 84500 -7430 0 0 {name=X_43211_ }
C {devices/lab_pin.sym} 84440 -7320 0 0 {name=p84223 lab=_74031_/A }
C {devices/lab_pin.sym} 84440 -7280 0 0 {name=p84224 lab=_73869_/X }
C {devices/lab_pin.sym} 84560 -7300 0 1 {name=p84225 lab=_74031_/Y }
C {sky130_stdcells/nor2_4.sym} 84500 -7300 0 0 {name=X_74031_ }
C {devices/lab_pin.sym} 84410 -7170 0 0 {name=p84226 lab=_83690_/CLK }
C {devices/lab_pin.sym} 84410 -7150 0 0 {name=p84227 lab=_51401_/Y }
C {devices/lab_pin.sym} 84590 -7170 0 1 {name=p84228 lab=_86017_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -7160 0 0 {name=X_86017_ }
C {devices/lab_pin.sym} 84460 -7030 0 0 {name=p84229 lab=_40947_/A }
C {devices/lab_pin.sym} 84540 -7030 0 1 {name=p84230 lab=_40907_/B }
C {sky130_stdcells/buf_2.sym} 84500 -7030 0 0 {name=X_40423_ }
C {devices/lab_pin.sym} 84440 -6920 0 0 {name=p84231 lab=_52400_/X }
C {devices/lab_pin.sym} 84440 -6880 0 0 {name=p84232 lab=_50712_/B }
C {devices/lab_pin.sym} 84560 -6900 0 1 {name=p84233 lab=_52409_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -6900 0 0 {name=X_52409_ }
C {devices/lab_pin.sym} 84440 -6790 0 0 {name=p84234 lab=_71252_/A }
C {devices/lab_pin.sym} 84440 -6750 0 0 {name=p84235 lab=_71217_/B }
C {devices/lab_pin.sym} 84440 -6710 0 0 {name=p84236 lab=_71248_/C }
C {devices/lab_pin.sym} 84560 -6750 0 1 {name=p84237 lab=_71243_/Y }
C {sky130_stdcells/nand3_4.sym} 84500 -6750 0 0 {name=X_71243_ }
C {devices/lab_pin.sym} 84410 -6610 0 0 {name=p84238 lab=_83229_/CLK }
C {devices/lab_pin.sym} 84410 -6590 0 0 {name=p84239 lab=_72578_/X }
C {devices/lab_pin.sym} 84590 -6610 0 1 {name=p84240 lab=_79385_/B }
C {sky130_stdcells/dfxtp_4.sym} 84500 -6600 0 0 {name=X_83229_ }
C {devices/lab_pin.sym} 84460 -6470 0 0 {name=p84241 lab=_44131_/A }
C {devices/lab_pin.sym} 84540 -6470 0 1 {name=p84242 lab=_72739_/A }
C {sky130_stdcells/buf_2.sym} 84500 -6470 0 0 {name=X_44191_ }
C {devices/lab_pin.sym} 84440 -6370 0 0 {name=p84243 lab=_56177_/A }
C {devices/lab_pin.sym} 84440 -6330 0 0 {name=p84244 lab=_56177_/B }
C {devices/lab_pin.sym} 84440 -6290 0 0 {name=p84245 lab=_55741_/B }
C {devices/lab_pin.sym} 84560 -6330 0 1 {name=p84246 lab=_56178_/B }
C {sky130_stdcells/nand3_4.sym} 84500 -6330 0 0 {name=X_56177_ }
C {devices/lab_pin.sym} 84420 -6210 0 0 {name=p84247 lab=_53387_/Y }
C {devices/lab_pin.sym} 84420 -6170 0 0 {name=p84248 lab=_53382_/X }
C {devices/lab_pin.sym} 84420 -6130 0 0 {name=p84249 lab=_53388_/X }
C {devices/lab_pin.sym} 84580 -6170 0 1 {name=p84250 lab=_85643_/D }
C {sky130_stdcells/a21oi_4.sym} 84500 -6170 0 0 {name=X_53389_ }
C {devices/lab_pin.sym} 84460 -6030 0 0 {name=p84251 lab=_55128_/A }
C {devices/lab_pin.sym} 84540 -6030 0 1 {name=p84252 lab=_55128_/X }
C {sky130_stdcells/buf_2.sym} 84500 -6030 0 0 {name=X_55128_ }
C {devices/lab_pin.sym} 84460 -5910 0 0 {name=p84253 lab=_43127_/A }
C {devices/lab_pin.sym} 84540 -5910 0 1 {name=p84254 lab=_43142_/X }
C {sky130_stdcells/buf_2.sym} 84500 -5910 0 0 {name=X_43142_ }
C {devices/lab_pin.sym} 84460 -5790 0 0 {name=p84255 lab=_40353_/Y }
C {devices/lab_pin.sym} 84540 -5790 0 1 {name=p84256 lab=_40354_/X }
C {sky130_stdcells/buf_2.sym} 84500 -5790 0 0 {name=X_40354_ }
C {devices/lab_pin.sym} 84420 -5690 0 0 {name=p84257 lab=_48763_/B }
C {devices/lab_pin.sym} 84420 -5650 0 0 {name=p84258 lab=_71165_/X }
C {devices/lab_pin.sym} 84420 -5610 0 0 {name=p84259 lab=_71173_/Y }
C {devices/lab_pin.sym} 84580 -5650 0 1 {name=p84260 lab=_71174_/Y }
