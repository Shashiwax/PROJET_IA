C {devices/lab_pin.sym} 62380 -9310 0 0 {name=p62150 lab=_59657_/A }
C {devices/lab_pin.sym} 62460 -9310 0 1 {name=p62151 lab=_60353_/B }
C {sky130_stdcells/buf_2.sym} 62420 -9310 0 0 {name=X_59657_ }
C {devices/lab_pin.sym} 62360 -9210 0 0 {name=p62152 lab=_78487_/Y }
C {devices/lab_pin.sym} 62360 -9170 0 0 {name=p62153 lab=_78488_/Y }
C {devices/lab_pin.sym} 62360 -9130 0 0 {name=p62154 lab=_78490_/Y }
C {devices/lab_pin.sym} 62480 -9170 0 1 {name=p62155 lab=_78491_/X }
C {sky130_stdcells/or3_4.sym} 62420 -9170 0 0 {name=X_78491_ }
C {devices/lab_pin.sym} 62380 -9030 0 0 {name=p62156 lab=_80671_/Q }
C {devices/lab_pin.sym} 62460 -9030 0 1 {name=p62157 lab=_45389_/A }
C {sky130_stdcells/inv_2.sym} 62420 -9030 0 0 {name=X_44883_ }
C {devices/lab_pin.sym} 62380 -8910 0 0 {name=p62158 lab=_56868_/X }
C {devices/lab_pin.sym} 62460 -8910 0 1 {name=p62159 lab=_56869_/Y }
C {sky130_stdcells/inv_2.sym} 62420 -8910 0 0 {name=X_56869_ }
C {devices/lab_pin.sym} 62330 -8790 0 0 {name=p62160 lab=_87888_/CLK }
C {devices/lab_pin.sym} 62330 -8770 0 0 {name=p62161 lab=_87689_/D }
C {devices/lab_pin.sym} 62510 -8790 0 1 {name=p62162 lab=_66817_/B }
C {sky130_stdcells/dfxtp_4.sym} 62420 -8780 0 0 {name=X_87689_ }
C {devices/lab_pin.sym} 62360 -8660 0 0 {name=p62163 lab=_49410_/A }
C {devices/lab_pin.sym} 62360 -8620 0 0 {name=p62164 lab=_46701_/X }
C {devices/lab_pin.sym} 62480 -8640 0 1 {name=p62165 lab=_49410_/Y }
C {sky130_stdcells/nand2_4.sym} 62420 -8640 0 0 {name=X_49410_ }
C {devices/lab_pin.sym} 62380 -8510 0 0 {name=p62166 lab=_46719_/A }
C {devices/lab_pin.sym} 62460 -8510 0 1 {name=p62167 lab=_46622_/X }
C {sky130_stdcells/buf_2.sym} 62420 -8510 0 0 {name=X_46622_ }
C {devices/lab_pin.sym} 62340 -8410 0 0 {name=p62168 lab=_58571_/X }
C {devices/lab_pin.sym} 62340 -8370 0 0 {name=p62169 lab=_85790_/Q }
C {devices/lab_pin.sym} 62340 -8330 0 0 {name=p62170 lab=_58594_/X }
C {devices/lab_pin.sym} 62500 -8370 0 1 {name=p62171 lab=_58608_/X }
C {sky130_stdcells/o21a_4.sym} 62420 -8370 0 0 {name=X_58608_ }
C {devices/lab_pin.sym} 62340 -8250 0 0 {name=p62172 lab=_77422_/Y }
C {devices/lab_pin.sym} 62340 -8210 0 0 {name=p62173 lab=_77423_/Y }
C {devices/lab_pin.sym} 62340 -8170 0 0 {name=p62174 lab=_77424_/Y }
C {devices/lab_pin.sym} 62500 -8210 0 1 {name=p62175 lab=_77442_/X }
C {sky130_stdcells/o21a_4.sym} 62420 -8210 0 0 {name=X_77442_ }
C {devices/lab_pin.sym} 62340 -8100 0 0 {name=p62176 lab=_41151_/X }
C {devices/lab_pin.sym} 62340 -8060 0 0 {name=p62177 lab=_43832_/X }
C {devices/lab_pin.sym} 62340 -8020 0 0 {name=p62178 lab=_68546_/B }
C {devices/lab_pin.sym} 62340 -7980 0 0 {name=p62179 lab=_43833_/X }
C {devices/lab_pin.sym} 62500 -8040 0 1 {name=p62180 lab=_43834_/X }
C {sky130_stdcells/a2bb2o_4.sym} 62420 -8040 0 0 {name=X_43834_ }
C {devices/lab_pin.sym} 62340 -7920 0 0 {name=p62181 lab=_45951_/Y }
C {devices/lab_pin.sym} 62340 -7880 0 0 {name=p62182 lab=_56638_/X }
C {devices/lab_pin.sym} 62340 -7840 0 0 {name=p62183 lab=_45604_/A }
C {devices/lab_pin.sym} 62340 -7800 0 0 {name=p62184 lab=_74645_/X }
C {devices/lab_pin.sym} 62500 -7860 0 1 {name=p62185 lab=_74654_/X }
C {sky130_stdcells/a2bb2o_4.sym} 62420 -7860 0 0 {name=X_74654_ }
C {devices/lab_pin.sym} 62340 -7730 0 0 {name=p62186 lab=_71847_/Y }
C {devices/lab_pin.sym} 62340 -7690 0 0 {name=p62187 lab=_83347_/Q }
C {devices/lab_pin.sym} 62340 -7650 0 0 {name=p62188 lab=_71865_/Y }
C {devices/lab_pin.sym} 62500 -7690 0 1 {name=p62189 lab=_83347_/D }
C {sky130_stdcells/a21o_4.sym} 62420 -7690 0 0 {name=X_71866_ }
C {devices/lab_pin.sym} 62340 -7570 0 0 {name=p62190 lab=_59662_/B }
C {devices/lab_pin.sym} 62340 -7530 0 0 {name=p62191 lab=_59633_/A }
C {devices/lab_pin.sym} 62340 -7490 0 0 {name=p62192 lab=_59634_/B }
C {devices/lab_pin.sym} 62500 -7530 0 1 {name=p62193 lab=_59588_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -7530 0 0 {name=X_59588_ }
C {devices/lab_pin.sym} 62340 -7410 0 0 {name=p62194 lab=_65310_/B }
C {devices/lab_pin.sym} 62340 -7370 0 0 {name=p62195 lab=_49334_/X }
C {devices/lab_pin.sym} 62340 -7330 0 0 {name=p62196 lab=_49340_/Y }
C {devices/lab_pin.sym} 62500 -7370 0 1 {name=p62197 lab=_49341_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -7370 0 0 {name=X_49341_ }
C {devices/lab_pin.sym} 62380 -7230 0 0 {name=p62198 lab=_73355_/A }
C {devices/lab_pin.sym} 62460 -7230 0 1 {name=p62199 lab=_73605_/X }
C {sky130_stdcells/buf_2.sym} 62420 -7230 0 0 {name=X_73605_ }
C {devices/lab_pin.sym} 62340 -7130 0 0 {name=p62200 lab=_47184_/X }
C {devices/lab_pin.sym} 62340 -7090 0 0 {name=p62201 lab=_70802_/X }
C {devices/lab_pin.sym} 62340 -7050 0 0 {name=p62202 lab=_70816_/Y }
C {devices/lab_pin.sym} 62500 -7090 0 1 {name=p62203 lab=_83693_/D }
C {sky130_stdcells/o21ai_4.sym} 62420 -7090 0 0 {name=X_70817_ }
C {devices/lab_pin.sym} 62340 -6970 0 0 {name=p62204 lab=_46548_/Y }
C {devices/lab_pin.sym} 62340 -6930 0 0 {name=p62205 lab=_46523_/X }
C {devices/lab_pin.sym} 62340 -6890 0 0 {name=p62206 lab=_46552_/Y }
C {devices/lab_pin.sym} 62500 -6930 0 1 {name=p62207 lab=_86727_/D }
C {sky130_stdcells/a21boi_4.sym} 62420 -6930 0 0 {name=X_46553_ }
C {devices/lab_pin.sym} 62380 -6790 0 0 {name=p62208 lab=_84824_/Q }
C {devices/lab_pin.sym} 62460 -6790 0 1 {name=p62209 lab=_58541_/A }
C {sky130_stdcells/inv_2.sym} 62420 -6790 0 0 {name=X_58539_ }
C {devices/lab_pin.sym} 62340 -6690 0 0 {name=p62210 lab=_77351_/B }
C {devices/lab_pin.sym} 62340 -6650 0 0 {name=p62211 lab=_77371_/Y }
C {devices/lab_pin.sym} 62340 -6610 0 0 {name=p62212 lab=_77372_/Y }
C {devices/lab_pin.sym} 62500 -6650 0 1 {name=p62213 lab=_77374_/B }
C {sky130_stdcells/a21oi_4.sym} 62420 -6650 0 0 {name=X_77373_ }
C {devices/lab_pin.sym} 62340 -6550 0 0 {name=p62214 lab=_43005_/X }
C {devices/lab_pin.sym} 62340 -6510 0 0 {name=p62215 lab=_43760_/X }
C {devices/lab_pin.sym} 62340 -6470 0 0 {name=p62216 lab=_40972_/X }
C {devices/lab_pin.sym} 62340 -6430 0 0 {name=p62217 lab=_69236_/B }
C {devices/lab_pin.sym} 62340 -6390 0 0 {name=p62218 lab=_43756_/X }
C {devices/lab_pin.sym} 62500 -6470 0 1 {name=p62219 lab=_43766_/A }
C {sky130_stdcells/o32ai_4.sym} 62420 -6470 0 0 {name=X_43765_ }
C {devices/lab_pin.sym} 62340 -6340 0 0 {name=p62220 lab=_74575_/X }
C {devices/lab_pin.sym} 62340 -6300 0 0 {name=p62221 lab=_74583_/X }
C {devices/lab_pin.sym} 62340 -6260 0 0 {name=p62222 lab=_56084_/Y }
C {devices/lab_pin.sym} 62340 -6220 0 0 {name=p62223 lab=_74584_/X }
C {devices/lab_pin.sym} 62500 -6280 0 1 {name=p62224 lab=_74585_/X }
C {sky130_stdcells/a211o_4.sym} 62420 -6280 0 0 {name=X_74585_ }
C {devices/lab_pin.sym} 62380 -6130 0 0 {name=p62225 lab=_40976_/X }
C {devices/lab_pin.sym} 62460 -6130 0 1 {name=p62226 lab=_40977_/X }
C {sky130_stdcells/buf_2.sym} 62420 -6130 0 0 {name=X_40977_ }
C {devices/lab_pin.sym} 62340 -6030 0 0 {name=p62227 lab=_58204_/Y }
C {devices/lab_pin.sym} 62340 -5990 0 0 {name=p62228 lab=_71783_/Y }
C {devices/lab_pin.sym} 62340 -5950 0 0 {name=p62229 lab=_71796_/Y }
C {devices/lab_pin.sym} 62500 -5990 0 1 {name=p62230 lab=_71797_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -5990 0 0 {name=X_71797_ }
C {devices/lab_pin.sym} 62360 -5860 0 0 {name=p62231 lab=_82625_/D }
C {devices/lab_pin.sym} 62360 -5820 0 0 {name=p62232 lab=_79112_/B }
C {devices/lab_pin.sym} 62480 -5840 0 1 {name=p62233 lab=_79114_/A }
C {sky130_stdcells/nand2_4.sym} 62420 -5840 0 0 {name=X_79112_ }
C {devices/lab_pin.sym} 62360 -5720 0 0 {name=p62234 lab=_45504_/A }
C {devices/lab_pin.sym} 62360 -5680 0 0 {name=p62235 lab=_45490_/B }
C {devices/lab_pin.sym} 62480 -5700 0 1 {name=p62236 lab=_45504_/Y }
C {sky130_stdcells/nor2_4.sym} 62420 -5700 0 0 {name=X_45504_ }
C {devices/lab_pin.sym} 62340 -5590 0 0 {name=p62237 lab=_76319_/Y }
C {devices/lab_pin.sym} 62340 -5550 0 0 {name=p62238 lab=_76295_/Y }
C {devices/lab_pin.sym} 62340 -5510 0 0 {name=p62239 lab=_76323_/X }
C {devices/lab_pin.sym} 62500 -5550 0 1 {name=p62240 lab=_76324_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -5550 0 0 {name=X_76324_ }
C {devices/lab_pin.sym} 62340 -5440 0 0 {name=p62241 lab=_41165_/X }
C {devices/lab_pin.sym} 62340 -5400 0 0 {name=p62242 lab=_42710_/X }
C {devices/lab_pin.sym} 62340 -5360 0 0 {name=p62243 lab=_68624_/B }
C {devices/lab_pin.sym} 62340 -5320 0 0 {name=p62244 lab=_42711_/X }
C {devices/lab_pin.sym} 62500 -5380 0 1 {name=p62245 lab=_87753_/D }
C {sky130_stdcells/a2bb2o_4.sym} 62420 -5380 0 0 {name=X_42716_ }
C {devices/lab_pin.sym} 62380 -5230 0 0 {name=p62246 lab=_48995_/A }
C {devices/lab_pin.sym} 62460 -5230 0 1 {name=p62247 lab=_49273_/A }
C {sky130_stdcells/buf_2.sym} 62420 -5230 0 0 {name=X_49272_ }
C {devices/lab_pin.sym} 62360 -5130 0 0 {name=p62248 lab=_61541_/A }
C {devices/lab_pin.sym} 62360 -5090 0 0 {name=p62249 lab=_61549_/X }
C {devices/lab_pin.sym} 62360 -5050 0 0 {name=p62250 lab=_61541_/C }
C {devices/lab_pin.sym} 62480 -5090 0 1 {name=p62251 lab=_61550_/Y }
C {sky130_stdcells/nand3_4.sym} 62420 -5090 0 0 {name=X_61550_ }
C {devices/lab_pin.sym} 62340 -4980 0 0 {name=p62252 lab=_72721_/X }
C {devices/lab_pin.sym} 62340 -4940 0 0 {name=p62253 lab=_86178_/Q }
C {devices/lab_pin.sym} 62340 -4900 0 0 {name=p62254 lab=_44194_/X }
C {devices/lab_pin.sym} 62340 -4860 0 0 {name=p62255 lab=_73535_/X }
C {devices/lab_pin.sym} 62500 -4920 0 1 {name=p62256 lab=_73536_/X }
C {sky130_stdcells/a211o_4.sym} 62420 -4920 0 0 {name=X_73536_ }
C {devices/lab_pin.sym} 62380 -4770 0 0 {name=p62257 lab=_54043_/A }
C {devices/lab_pin.sym} 62460 -4770 0 1 {name=p62258 lab=_52524_/A }
C {sky130_stdcells/buf_2.sym} 62420 -4770 0 0 {name=X_46484_ }
C {devices/lab_pin.sym} 62340 -4670 0 0 {name=p62259 lab=_53115_/B }
C {devices/lab_pin.sym} 62340 -4630 0 0 {name=p62260 lab=_70738_/X }
C {devices/lab_pin.sym} 62340 -4590 0 0 {name=p62261 lab=_70747_/Y }
C {devices/lab_pin.sym} 62500 -4630 0 1 {name=p62262 lab=_70748_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -4630 0 0 {name=X_70748_ }
C {devices/lab_pin.sym} 62380 -4490 0 0 {name=p62263 lab=_43673_/A }
C {devices/lab_pin.sym} 62460 -4490 0 1 {name=p62264 lab=_43696_/X }
C {sky130_stdcells/buf_2.sym} 62420 -4490 0 0 {name=X_43696_ }
C {devices/lab_pin.sym} 62340 -4390 0 0 {name=p62265 lab=_48220_/Y }
C {devices/lab_pin.sym} 62340 -4350 0 0 {name=p62266 lab=_48175_/X }
C {devices/lab_pin.sym} 62340 -4310 0 0 {name=p62267 lab=_48222_/Y }
C {devices/lab_pin.sym} 62500 -4350 0 1 {name=p62268 lab=_86553_/D }
C {sky130_stdcells/a21boi_4.sym} 62420 -4350 0 0 {name=X_48223_ }
C {devices/lab_pin.sym} 62380 -4210 0 0 {name=p62269 lab=_60501_/A }
C {devices/lab_pin.sym} 62460 -4210 0 1 {name=p62270 lab=_60501_/Y }
C {sky130_stdcells/inv_2.sym} 62420 -4210 0 0 {name=X_60501_ }
C {devices/lab_pin.sym} 62340 -4110 0 0 {name=p62271 lab=_79044_/A }
C {devices/lab_pin.sym} 62340 -4070 0 0 {name=p62272 lab=_79044_/C }
C {devices/lab_pin.sym} 62340 -4030 0 0 {name=p62273 lab=_79044_/B }
C {devices/lab_pin.sym} 62500 -4070 0 1 {name=p62274 lab=_79057_/A }
C {sky130_stdcells/a21o_4.sym} 62420 -4070 0 0 {name=X_79043_ }
C {devices/lab_pin.sym} 62380 -3930 0 0 {name=p62275 lab=_63030_/B }
C {devices/lab_pin.sym} 62460 -3930 0 1 {name=p62276 lab=_61358_/A }
C {sky130_stdcells/buf_2.sym} 62420 -3930 0 0 {name=X_45435_ }
C {devices/lab_pin.sym} 62380 -3810 0 0 {name=p62277 lab=_76255_/A }
C {devices/lab_pin.sym} 62460 -3810 0 1 {name=p62278 lab=_76255_/Y }
C {sky130_stdcells/inv_2.sym} 62420 -3810 0 0 {name=X_76255_ }
C {devices/lab_pin.sym} 62380 -3690 0 0 {name=p62279 lab=_42590_/A }
C {devices/lab_pin.sym} 62460 -3690 0 1 {name=p62280 lab=_42647_/X }
C {sky130_stdcells/buf_2.sym} 62420 -3690 0 0 {name=X_42647_ }
C {devices/lab_pin.sym} 62380 -3570 0 0 {name=p62281 lab=_84821_/Q }
C {devices/lab_pin.sym} 62460 -3570 0 1 {name=p62282 lab=_61481_/X }
C {sky130_stdcells/buf_2.sym} 62420 -3570 0 0 {name=X_61481_ }
C {devices/lab_pin.sym} 62340 -3470 0 0 {name=p62283 lab=_73463_/X }
C {devices/lab_pin.sym} 62340 -3430 0 0 {name=p62284 lab=_73466_/X }
C {devices/lab_pin.sym} 62340 -3390 0 0 {name=p62285 lab=_73347_/X }
C {devices/lab_pin.sym} 62500 -3430 0 1 {name=p62286 lab=_73481_/B }
C {sky130_stdcells/a21o_4.sym} 62420 -3430 0 0 {name=X_73467_ }
C {devices/lab_pin.sym} 62360 -3310 0 0 {name=p62287 lab=_70679_/A }
C {devices/lab_pin.sym} 62360 -3270 0 0 {name=p62288 lab=_70676_/B }
C {devices/lab_pin.sym} 62360 -3230 0 0 {name=p62289 lab=_70676_/C }
C {devices/lab_pin.sym} 62480 -3270 0 1 {name=p62290 lab=_70679_/Y }
C {sky130_stdcells/nor3_4.sym} 62420 -3270 0 0 {name=X_70679_ }
C {devices/lab_pin.sym} 62360 -3160 0 0 {name=p62291 lab=_58440_/Y }
C {devices/lab_pin.sym} 62360 -3120 0 0 {name=p62292 lab=_63170_/X }
C {devices/lab_pin.sym} 62360 -3080 0 0 {name=p62293 lab=_63295_/C }
C {devices/lab_pin.sym} 62360 -3040 0 0 {name=p62294 lab=_63267_/D }
C {devices/lab_pin.sym} 62480 -3100 0 1 {name=p62295 lab=_63220_/X }
C {sky130_stdcells/or4_4.sym} 62420 -3100 0 0 {name=X_63220_ }
C {devices/lab_pin.sym} 62380 -2950 0 0 {name=p62296 lab=_75203_/Y }
C {devices/lab_pin.sym} 62460 -2950 0 1 {name=p62297 lab=_75207_/A }
C {sky130_stdcells/inv_2.sym} 62420 -2950 0 0 {name=X_75206_ }
C {devices/lab_pin.sym} 62340 -2870 0 0 {name=p62298 lab=_72413_/X }
C {devices/lab_pin.sym} 62340 -2830 0 0 {name=p62299 lab=_72415_/Y }
C {devices/lab_pin.sym} 62340 -2790 0 0 {name=p62300 lab=_72416_/Y }
C {devices/lab_pin.sym} 62340 -2750 0 0 {name=p62301 lab=_72337_/X }
C {devices/lab_pin.sym} 62340 -2710 0 0 {name=p62302 lab=_72417_/X }
C {devices/lab_pin.sym} 62500 -2790 0 1 {name=p62303 lab=_72418_/X }
C {sky130_stdcells/o32a_4.sym} 62420 -2790 0 0 {name=X_72418_ }
C {devices/lab_pin.sym} 62360 -2640 0 0 {name=p62304 lab=_48725_/A }
C {devices/lab_pin.sym} 62360 -2600 0 0 {name=p62305 lab=_50389_/B }
C {devices/lab_pin.sym} 62480 -2620 0 1 {name=p62306 lab=_48154_/Y }
C {sky130_stdcells/nand2_4.sym} 62420 -2620 0 0 {name=X_48154_ }
C {devices/lab_pin.sym} 62380 -2490 0 0 {name=p62307 lab=_60482_/A }
C {devices/lab_pin.sym} 62460 -2490 0 1 {name=p62308 lab=_60443_/A }
C {sky130_stdcells/buf_2.sym} 62420 -2490 0 0 {name=X_60432_ }
C {devices/lab_pin.sym} 62340 -2390 0 0 {name=p62309 lab=_45363_/X }
C {devices/lab_pin.sym} 62340 -2350 0 0 {name=p62310 lab=_45365_/Y }
C {devices/lab_pin.sym} 62340 -2310 0 0 {name=p62311 lab=_45348_/X }
C {devices/lab_pin.sym} 62500 -2350 0 1 {name=p62312 lab=_45366_/Y }
C {sky130_stdcells/a21oi_4.sym} 62420 -2350 0 0 {name=X_45366_ }
C {devices/lab_pin.sym} 62380 -2210 0 0 {name=p62313 lab=_76186_/A }
C {devices/lab_pin.sym} 62460 -2210 0 1 {name=p62314 lab=_76189_/A }
C {sky130_stdcells/inv_2.sym} 62420 -2210 0 0 {name=X_76186_ }
C {devices/lab_pin.sym} 62380 -2090 0 0 {name=p62315 lab=_42578_/A }
C {devices/lab_pin.sym} 62460 -2090 0 1 {name=p62316 lab=_87814_/D }
C {sky130_stdcells/inv_2.sym} 62420 -2090 0 0 {name=X_42578_ }
C {devices/lab_pin.sym} 62340 -1990 0 0 {name=p62317 lab=_73395_/X }
C {devices/lab_pin.sym} 62340 -1950 0 0 {name=p62318 lab=_73397_/X }
C {devices/lab_pin.sym} 62340 -1910 0 0 {name=p62319 lab=_73347_/X }
C {devices/lab_pin.sym} 62500 -1950 0 1 {name=p62320 lab=_73412_/B }
C {sky130_stdcells/a21o_4.sym} 62420 -1950 0 0 {name=X_73398_ }
C {devices/lab_pin.sym} 62360 -1840 0 0 {name=p62321 lab=_47113_/A }
C {devices/lab_pin.sym} 62360 -1800 0 0 {name=p62322 lab=_47082_/X }
C {devices/lab_pin.sym} 62360 -1760 0 0 {name=p62323 lab=_47091_/X }
C {devices/lab_pin.sym} 62360 -1720 0 0 {name=p62324 lab=_52857_/D }
C {devices/lab_pin.sym} 62480 -1780 0 1 {name=p62325 lab=_47105_/X }
C {sky130_stdcells/and4_4.sym} 62420 -1780 0 0 {name=X_47105_ }
C {devices/lab_pin.sym} 62340 -1670 0 0 {name=p62326 lab=_44153_/X }
C {devices/lab_pin.sym} 62340 -1630 0 0 {name=p62327 lab=_44313_/A }
C {devices/lab_pin.sym} 62340 -1590 0 0 {name=p62328 lab=_44210_/X }
C {devices/lab_pin.sym} 62340 -1550 0 0 {name=p62329 lab=_43975_/B }
C {devices/lab_pin.sym} 62340 -1510 0 0 {name=p62330 lab=_44316_/X }
C {devices/lab_pin.sym} 62500 -1590 0 1 {name=p62331 lab=_44317_/X }
C {sky130_stdcells/o32a_4.sym} 62420 -1590 0 0 {name=X_44317_ }
C {devices/lab_pin.sym} 62340 -1450 0 0 {name=p62332 lab=_63148_/Y }
C {devices/lab_pin.sym} 62340 -1410 0 0 {name=p62333 lab=_63150_/X }
C {devices/lab_pin.sym} 62340 -1370 0 0 {name=p62334 lab=_63114_/X }
C {devices/lab_pin.sym} 62500 -1410 0 1 {name=p62335 lab=_63151_/Y }
C {sky130_stdcells/a21oi_4.sym} 62420 -1410 0 0 {name=X_63151_ }
C {devices/lab_pin.sym} 62360 -1280 0 0 {name=p62336 lab=_80774_/Q }
C {devices/lab_pin.sym} 62360 -1240 0 0 {name=p62337 lab=_81030_/D }
C {devices/lab_pin.sym} 62480 -1260 0 1 {name=p62338 lab=_80742_/D }
C {sky130_stdcells/xor2_4.sym} 62420 -1260 0 0 {name=X_75137_ }
C {devices/lab_pin.sym} 62380 -1130 0 0 {name=p62339 lab=_41529_/A }
C {devices/lab_pin.sym} 62460 -1130 0 1 {name=p62340 lab=_41529_/X }
C {sky130_stdcells/buf_2.sym} 62420 -1130 0 0 {name=X_41529_ }
C {devices/lab_pin.sym} 62380 -1010 0 0 {name=p62341 lab=_47857_/X }
C {devices/lab_pin.sym} 62460 -1010 0 1 {name=p62342 lab=_48138_/A }
C {sky130_stdcells/buf_2.sym} 62420 -1010 0 0 {name=X_48085_ }
C {devices/lab_pin.sym} 62340 -910 0 0 {name=p62343 lab=_62678_/A }
C {devices/lab_pin.sym} 62340 -870 0 0 {name=p62344 lab=_60273_/X }
C {devices/lab_pin.sym} 62340 -830 0 0 {name=p62345 lab=_60263_/C }
C {devices/lab_pin.sym} 62500 -870 0 1 {name=p62346 lab=_60363_/Y }
C {sky130_stdcells/a21oi_4.sym} 62420 -870 0 0 {name=X_60363_ }
C {devices/lab_pin.sym} 62340 -770 0 0 {name=p62347 lab=_72299_/X }
C {devices/lab_pin.sym} 62340 -730 0 0 {name=p62348 lab=_72347_/Y }
C {devices/lab_pin.sym} 62340 -690 0 0 {name=p62349 lab=_72348_/Y }
C {devices/lab_pin.sym} 62340 -650 0 0 {name=p62350 lab=_72337_/X }
C {devices/lab_pin.sym} 62340 -610 0 0 {name=p62351 lab=_72303_/X }
C {devices/lab_pin.sym} 62500 -690 0 1 {name=p62352 lab=_72349_/X }
C {sky130_stdcells/o32a_4.sym} 62420 -690 0 0 {name=X_72349_ }
C {devices/lab_pin.sym} 63300 -42150 0 0 {name=p62353 lab=_45297_/A }
C {devices/lab_pin.sym} 63380 -42150 0 1 {name=p62354 lab=_45297_/X }
C {sky130_stdcells/buf_2.sym} 63340 -42150 0 0 {name=X_45297_ }
C {devices/lab_pin.sym} 63280 -42050 0 0 {name=p62355 lab=_62050_/X }
C {devices/lab_pin.sym} 63280 -42010 0 0 {name=p62356 lab=_62090_/B }
C {devices/lab_pin.sym} 63280 -41970 0 0 {name=p62357 lab=_78056_/B }
C {devices/lab_pin.sym} 63400 -42010 0 1 {name=p62358 lab=_62102_/Y }
C {sky130_stdcells/nor3_4.sym} 63340 -42010 0 0 {name=X_62102_ }
C {devices/lab_pin.sym} 63300 -41870 0 0 {name=p62359 lab=_46941_/A }
C {devices/lab_pin.sym} 63380 -41870 0 1 {name=p62360 lab=_47039_/B }
C {sky130_stdcells/buf_2.sym} 63340 -41870 0 0 {name=X_47036_ }
C {devices/lab_pin.sym} 63300 -41750 0 0 {name=p62361 lab=_58602_/A }
C {devices/lab_pin.sym} 63380 -41750 0 1 {name=p62362 lab=_72296_/A }
C {sky130_stdcells/buf_2.sym} 63340 -41750 0 0 {name=X_44248_ }
C {devices/lab_pin.sym} 63280 -41640 0 0 {name=p62363 lab=_80744_/Q }
C {devices/lab_pin.sym} 63280 -41600 0 0 {name=p62364 lab=_75061_/B }
C {devices/lab_pin.sym} 63400 -41620 0 1 {name=p62365 lab=_75069_/B }
C {sky130_stdcells/nand2_4.sym} 63340 -41620 0 0 {name=X_75068_ }
C {devices/lab_pin.sym} 63280 -41500 0 0 {name=p62366 lab=_79945_/A }
C {devices/lab_pin.sym} 63280 -41460 0 0 {name=p62367 lab=_79945_/B }
C {devices/lab_pin.sym} 63400 -41480 0 1 {name=p62368 lab=_79946_/A }
C {sky130_stdcells/nand2_4.sym} 63340 -41480 0 0 {name=X_79945_ }
C {devices/lab_pin.sym} 63260 -41370 0 0 {name=p62369 lab=_63080_/Y }
C {devices/lab_pin.sym} 63260 -41330 0 0 {name=p62370 lab=_63081_/X }
C {devices/lab_pin.sym} 63260 -41290 0 0 {name=p62371 lab=_63056_/X }
C {devices/lab_pin.sym} 63420 -41330 0 1 {name=p62372 lab=_63082_/Y }
C {sky130_stdcells/a21oi_4.sym} 63340 -41330 0 0 {name=X_63082_ }
C {devices/lab_pin.sym} 63280 -41210 0 0 {name=p62373 lab=_60317_/A }
C {devices/lab_pin.sym} 63280 -41170 0 0 {name=p62374 lab=_60244_/B }
C {devices/lab_pin.sym} 63280 -41130 0 0 {name=p62375 lab=_79784_/A }
C {devices/lab_pin.sym} 63400 -41170 0 1 {name=p62376 lab=_60294_/Y }
C {sky130_stdcells/nor3_4.sym} 63340 -41170 0 0 {name=X_60294_ }
C {devices/lab_pin.sym} 63300 -41030 0 0 {name=p62377 lab=_72877_/A }
C {devices/lab_pin.sym} 63380 -41030 0 1 {name=p62378 lab=_74019_/X }
C {sky130_stdcells/buf_2.sym} 63340 -41030 0 0 {name=X_74019_ }
C {devices/lab_pin.sym} 63300 -40910 0 0 {name=p62379 lab=_66910_/A }
C {devices/lab_pin.sym} 63380 -40910 0 1 {name=p62380 lab=_66910_/X }
C {sky130_stdcells/buf_2.sym} 63340 -40910 0 0 {name=X_66910_ }
C {devices/lab_pin.sym} 63300 -40790 0 0 {name=p62381 lab=_62033_/A }
C {devices/lab_pin.sym} 63380 -40790 0 1 {name=p62382 lab=_62033_/X }
C {sky130_stdcells/buf_2.sym} 63340 -40790 0 0 {name=X_62033_ }
C {devices/lab_pin.sym} 63300 -40670 0 0 {name=p62383 lab=_45924_/A }
C {devices/lab_pin.sym} 63380 -40670 0 1 {name=p62384 lab=_64713_/A }
C {sky130_stdcells/buf_2.sym} 63340 -40670 0 0 {name=X_44179_ }
C {devices/lab_pin.sym} 63260 -40580 0 0 {name=p62385 lab=_87964_/Q }
C {devices/lab_pin.sym} 63260 -40540 0 0 {name=p62386 lab=_67888_/X }
C {devices/lab_pin.sym} 63260 -40500 0 0 {name=p62387 lab=_67865_/X }
C {devices/lab_pin.sym} 63260 -40460 0 0 {name=p62388 lab=_67889_/X }
C {devices/lab_pin.sym} 63420 -40520 0 1 {name=p62389 lab=_67890_/X }
C {sky130_stdcells/a211o_4.sym} 63340 -40520 0 0 {name=X_67890_ }
C {devices/lab_pin.sym} 63260 -40400 0 0 {name=p62390 lab=_79844_/X }
C {devices/lab_pin.sym} 63260 -40360 0 0 {name=p62391 lab=_79866_/B }
C {devices/lab_pin.sym} 63260 -40320 0 0 {name=p62392 lab=_79861_/X }
C {devices/lab_pin.sym} 63260 -40280 0 0 {name=p62393 lab=_79865_/B }
C {devices/lab_pin.sym} 63420 -40340 0 1 {name=p62394 lab=_79876_/X }
C {sky130_stdcells/o22a_4.sym} 63340 -40340 0 0 {name=X_79876_ }
C {devices/lab_pin.sym} 63280 -40200 0 0 {name=p62395 lab=_66840_/X }
C {devices/lab_pin.sym} 63280 -40160 0 0 {name=p62396 lab=_86827_/Q }
C {devices/lab_pin.sym} 63400 -40180 0 1 {name=p62397 lab=_66841_/X }
C {sky130_stdcells/and2_4.sym} 63340 -40180 0 0 {name=X_66841_ }
C {devices/lab_pin.sym} 63260 -40070 0 0 {name=p62398 lab=_78828_/A }
C {devices/lab_pin.sym} 63260 -40030 0 0 {name=p62399 lab=_78828_/C }
C {devices/lab_pin.sym} 63260 -39990 0 0 {name=p62400 lab=_78828_/B }
C {devices/lab_pin.sym} 63420 -40030 0 1 {name=p62401 lab=_78829_/A }
C {sky130_stdcells/a21o_4.sym} 63340 -40030 0 0 {name=X_78827_ }
C {devices/lab_pin.sym} 63260 -39910 0 0 {name=p62402 lab=_48946_/X }
C {devices/lab_pin.sym} 63260 -39870 0 0 {name=p62403 lab=_48473_/A }
C {devices/lab_pin.sym} 63260 -39830 0 0 {name=p62404 lab=_48986_/Y }
C {devices/lab_pin.sym} 63420 -39870 0 1 {name=p62405 lab=_48988_/A }
C {sky130_stdcells/a21o_4.sym} 63340 -39870 0 0 {name=X_48987_ }
C {devices/lab_pin.sym} 63260 -39750 0 0 {name=p62406 lab=_69557_/X }
C {devices/lab_pin.sym} 63260 -39710 0 0 {name=p62407 lab=_69559_/X }
C {devices/lab_pin.sym} 63260 -39670 0 0 {name=p62408 lab=_69433_/X }
C {devices/lab_pin.sym} 63420 -39710 0 1 {name=p62409 lab=_69560_/Y }
C {sky130_stdcells/a21oi_4.sym} 63340 -39710 0 0 {name=X_69560_ }
C {devices/lab_pin.sym} 63260 -39590 0 0 {name=p62410 lab=_47933_/Y }
C {devices/lab_pin.sym} 63260 -39550 0 0 {name=p62411 lab=_47903_/X }
C {devices/lab_pin.sym} 63260 -39510 0 0 {name=p62412 lab=_47937_/X }
C {devices/lab_pin.sym} 63420 -39550 0 1 {name=p62413 lab=_86584_/D }
C {sky130_stdcells/a21oi_4.sym} 63340 -39550 0 0 {name=X_47938_ }
C {devices/lab_pin.sym} 63280 -39430 0 0 {name=p62414 lab=_78758_/A }
C {devices/lab_pin.sym} 63280 -39390 0 0 {name=p62415 lab=_78756_/Y }
C {devices/lab_pin.sym} 63280 -39350 0 0 {name=p62416 lab=_78758_/C }
C {devices/lab_pin.sym} 63400 -39390 0 1 {name=p62417 lab=_78770_/D }
C {sky130_stdcells/nand3_4.sym} 63340 -39390 0 0 {name=X_78758_ }
C {devices/lab_pin.sym} 63280 -39260 0 0 {name=p62418 lab=_66795_/A }
C {devices/lab_pin.sym} 63280 -39220 0 0 {name=p62419 lab=_87627_/Q }
C {devices/lab_pin.sym} 63400 -39240 0 1 {name=p62420 lab=_66772_/X }
C {sky130_stdcells/and2_4.sym} 63340 -39240 0 0 {name=X_66772_ }
C {devices/lab_pin.sym} 63280 -39140 0 0 {name=p62421 lab=_57683_/X }
C {devices/lab_pin.sym} 63280 -39100 0 0 {name=p62422 lab=_64046_/B }
C {devices/lab_pin.sym} 63280 -39060 0 0 {name=p62423 lab=_64046_/C }
C {devices/lab_pin.sym} 63280 -39020 0 0 {name=p62424 lab=_64016_/D }
C {devices/lab_pin.sym} 63400 -39080 0 1 {name=p62425 lab=_63985_/D }
C {sky130_stdcells/nand4_4.sym} 63340 -39080 0 0 {name=X_63984_ }
C {devices/lab_pin.sym} 63260 -38960 0 0 {name=p62426 lab=_87098_/Q }
C {devices/lab_pin.sym} 63260 -38920 0 0 {name=p62427 lab=_68455_/X }
C {devices/lab_pin.sym} 63260 -38880 0 0 {name=p62428 lab=_68509_/X }
C {devices/lab_pin.sym} 63260 -38840 0 0 {name=p62429 lab=_68510_/X }
C {devices/lab_pin.sym} 63420 -38900 0 1 {name=p62430 lab=_68511_/X }
C {sky130_stdcells/a211o_4.sym} 63340 -38900 0 0 {name=X_68511_ }
C {devices/lab_pin.sym} 63280 -38760 0 0 {name=p62431 lab=_65769_/A }
C {devices/lab_pin.sym} 63280 -38720 0 0 {name=p62432 lab=_86510_/Q }
C {devices/lab_pin.sym} 63400 -38740 0 1 {name=p62433 lab=_65723_/X }
C {sky130_stdcells/and2_4.sym} 63340 -38740 0 0 {name=X_65723_ }
C {devices/lab_pin.sym} 63260 -38630 0 0 {name=p62434 lab=_77675_/A }
C {devices/lab_pin.sym} 63260 -38590 0 0 {name=p62435 lab=_77676_/X }
C {devices/lab_pin.sym} 63260 -38550 0 0 {name=p62436 lab=_77700_/X }
C {devices/lab_pin.sym} 63420 -38590 0 1 {name=p62437 lab=_77709_/X }
C {sky130_stdcells/a21o_4.sym} 63340 -38590 0 0 {name=X_77709_ }
C {devices/lab_pin.sym} 63280 -38470 0 0 {name=p62438 lab=_62965_/A }
C {devices/lab_pin.sym} 63280 -38430 0 0 {name=p62439 lab=_62935_/B }
C {devices/lab_pin.sym} 63280 -38390 0 0 {name=p62440 lab=_62113_/X }
C {devices/lab_pin.sym} 63400 -38430 0 1 {name=p62441 lab=_62935_/Y }
C {sky130_stdcells/nand3_4.sym} 63340 -38430 0 0 {name=X_62935_ }
C {devices/lab_pin.sym} 63300 -38290 0 0 {name=p62442 lab=_69190_/A }
C {devices/lab_pin.sym} 63380 -38290 0 1 {name=p62443 lab=_69580_/A }
C {sky130_stdcells/buf_2.sym} 63340 -38290 0 0 {name=X_69491_ }
C {devices/lab_pin.sym} 63280 -38180 0 0 {name=p62444 lab=_47869_/A }
C {devices/lab_pin.sym} 63280 -38140 0 0 {name=p62445 lab=_47915_/B }
C {devices/lab_pin.sym} 63400 -38160 0 1 {name=p62446 lab=_47869_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -38160 0 0 {name=X_47869_ }
C {devices/lab_pin.sym} 63300 -38030 0 0 {name=p62447 lab=_78689_/A }
C {devices/lab_pin.sym} 63380 -38030 0 1 {name=p62448 lab=_78689_/Y }
C {sky130_stdcells/inv_2.sym} 63340 -38030 0 0 {name=X_78689_ }
C {devices/lab_pin.sym} 63280 -37920 0 0 {name=p62449 lab=_49607_/X }
C {devices/lab_pin.sym} 63280 -37880 0 0 {name=p62450 lab=_51130_/B }
C {devices/lab_pin.sym} 63400 -37900 0 1 {name=p62451 lab=_49608_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -37900 0 0 {name=X_49608_ }
C {devices/lab_pin.sym} 63250 -37770 0 0 {name=p62452 lab=_80720_/CLK }
C {devices/lab_pin.sym} 63250 -37750 0 0 {name=p62453 lab=_75906_/X }
C {devices/lab_pin.sym} 63430 -37770 0 1 {name=p62454 lab=_80688_/D }
C {sky130_stdcells/dfxtp_4.sym} 63340 -37760 0 0 {name=X_80720_ }
C {devices/lab_pin.sym} 63300 -37630 0 0 {name=p62455 lab=_68442_/A }
C {devices/lab_pin.sym} 63380 -37630 0 1 {name=p62456 lab=_68442_/X }
C {sky130_stdcells/buf_2.sym} 63340 -37630 0 0 {name=X_68442_ }
C {devices/lab_pin.sym} 63300 -37510 0 0 {name=p62457 lab=_58876_/A }
C {devices/lab_pin.sym} 63380 -37510 0 1 {name=p62458 lab=_65654_/X }
C {sky130_stdcells/buf_2.sym} 63340 -37510 0 0 {name=X_65654_ }
C {devices/lab_pin.sym} 63280 -37410 0 0 {name=p62459 lab=_51396_/A }
C {devices/lab_pin.sym} 63280 -37370 0 0 {name=p62460 lab=_50825_/B }
C {devices/lab_pin.sym} 63280 -37330 0 0 {name=p62461 lab=_50830_/C }
C {devices/lab_pin.sym} 63400 -37370 0 1 {name=p62462 lab=_50880_/X }
C {sky130_stdcells/and3_4.sym} 63340 -37370 0 0 {name=X_50880_ }
C {devices/lab_pin.sym} 63280 -37260 0 0 {name=p62463 lab=_58478_/A }
C {devices/lab_pin.sym} 63280 -37220 0 0 {name=p62464 lab=_62841_/X }
C {devices/lab_pin.sym} 63280 -37180 0 0 {name=p62465 lab=_60309_/C }
C {devices/lab_pin.sym} 63280 -37140 0 0 {name=p62466 lab=_60254_/B }
C {devices/lab_pin.sym} 63400 -37200 0 1 {name=p62467 lab=_62866_/Y }
C {sky130_stdcells/nand4_4.sym} 63340 -37200 0 0 {name=X_62866_ }
C {devices/lab_pin.sym} 63300 -37050 0 0 {name=p62468 lab=clkbuf_7_63_0_CLK/A }
C {devices/lab_pin.sym} 63380 -37050 0 1 {name=p62469 lab=clkbuf_7_63_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 63340 -37050 0 0 {name=Xclkbuf_7_63_0_CLK }
C {devices/lab_pin.sym} 63280 -36950 0 0 {name=p62470 lab=_64595_/X }
C {devices/lab_pin.sym} 63280 -36910 0 0 {name=p62471 lab=_64633_/B }
C {devices/lab_pin.sym} 63280 -36870 0 0 {name=p62472 lab=_64604_/X }
C {devices/lab_pin.sym} 63400 -36910 0 1 {name=p62473 lab=_64605_/Y }
C {sky130_stdcells/nand3_4.sym} 63340 -36910 0 0 {name=X_64605_ }
C {devices/lab_pin.sym} 63280 -36780 0 0 {name=p62474 lab=_49546_/A }
C {devices/lab_pin.sym} 63280 -36740 0 0 {name=p62475 lab=_52752_/B }
C {devices/lab_pin.sym} 63400 -36760 0 1 {name=p62476 lab=_49539_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -36760 0 0 {name=X_49539_ }
C {devices/lab_pin.sym} 63250 -36630 0 0 {name=p62477 lab=_86757_/CLK }
C {devices/lab_pin.sym} 63250 -36610 0 0 {name=p62478 lab=_80651_/D }
C {devices/lab_pin.sym} 63430 -36630 0 1 {name=p62479 lab=_46111_/A }
C {sky130_stdcells/dfxtp_4.sym} 63340 -36620 0 0 {name=X_80651_ }
C {devices/lab_pin.sym} 63300 -36490 0 0 {name=p62480 lab=_61722_/A }
C {devices/lab_pin.sym} 63380 -36490 0 1 {name=p62481 lab=_61865_/A }
C {sky130_stdcells/buf_2.sym} 63340 -36490 0 0 {name=X_61817_ }
C {devices/lab_pin.sym} 63260 -36390 0 0 {name=p62482 lab=_68369_/X }
C {devices/lab_pin.sym} 63260 -36350 0 0 {name=p62483 lab=_68372_/X }
C {devices/lab_pin.sym} 63260 -36310 0 0 {name=p62484 lab=_68327_/X }
C {devices/lab_pin.sym} 63420 -36350 0 1 {name=p62485 lab=_68373_/Y }
C {sky130_stdcells/a21oi_4.sym} 63340 -36350 0 0 {name=X_68373_ }
C {devices/lab_pin.sym} 63260 -36240 0 0 {name=p62486 lab=_65524_/X }
C {devices/lab_pin.sym} 63260 -36200 0 0 {name=p62487 lab=_83071_/Q }
C {devices/lab_pin.sym} 63260 -36160 0 0 {name=p62488 lab=_65568_/X }
C {devices/lab_pin.sym} 63260 -36120 0 0 {name=p62489 lab=_65584_/X }
C {devices/lab_pin.sym} 63420 -36180 0 1 {name=p62490 lab=_65585_/X }
C {sky130_stdcells/a211o_4.sym} 63340 -36180 0 0 {name=X_65585_ }
C {devices/lab_pin.sym} 63280 -36060 0 0 {name=p62491 lab=_62819_/A }
C {devices/lab_pin.sym} 63280 -36020 0 0 {name=p62492 lab=_84829_/Q }
C {devices/lab_pin.sym} 63280 -35980 0 0 {name=p62493 lab=_62819_/C }
C {devices/lab_pin.sym} 63280 -35940 0 0 {name=p62494 lab=_62782_/X }
C {devices/lab_pin.sym} 63400 -36000 0 1 {name=p62495 lab=_62797_/X }
C {sky130_stdcells/and4_4.sym} 63340 -36000 0 0 {name=X_62797_ }
C {devices/lab_pin.sym} 63280 -35860 0 0 {name=p62496 lab=_67324_/A }
C {devices/lab_pin.sym} 63280 -35820 0 0 {name=p62497 lab=_67324_/B }
C {devices/lab_pin.sym} 63400 -35840 0 1 {name=p62498 lab=_67324_/X }
C {sky130_stdcells/and2_4.sym} 63340 -35840 0 0 {name=X_67324_ }
C {devices/lab_pin.sym} 63300 -35710 0 0 {name=p62499 lab=_52177_/A }
C {devices/lab_pin.sym} 63380 -35710 0 1 {name=p62500 lab=_52567_/A }
C {sky130_stdcells/buf_2.sym} 63340 -35710 0 0 {name=X_52550_ }
C {devices/lab_pin.sym} 63280 -35610 0 0 {name=p62501 lab=_64546_/A }
C {devices/lab_pin.sym} 63280 -35570 0 0 {name=p62502 lab=_64525_/B }
C {devices/lab_pin.sym} 63280 -35530 0 0 {name=p62503 lab=_64536_/C }
C {devices/lab_pin.sym} 63400 -35570 0 1 {name=p62504 lab=_64536_/X }
C {sky130_stdcells/and3_4.sym} 63340 -35570 0 0 {name=X_64536_ }
C {devices/lab_pin.sym} 63250 -35430 0 0 {name=p62505 lab=_83367_/CLK }
C {devices/lab_pin.sym} 63250 -35410 0 0 {name=p62506 lab=_83370_/D }
C {devices/lab_pin.sym} 63430 -35430 0 1 {name=p62507 lab=_83370_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -35420 0 0 {name=X_83370_ }
C {devices/lab_pin.sym} 63300 -35290 0 0 {name=p62508 lab=_61747_/X }
C {devices/lab_pin.sym} 63380 -35290 0 1 {name=p62509 lab=_61748_/X }
C {sky130_stdcells/buf_2.sym} 63340 -35290 0 0 {name=X_61748_ }
C {devices/lab_pin.sym} 63280 -35180 0 0 {name=p62510 lab=_80566_/Y }
C {devices/lab_pin.sym} 63280 -35140 0 0 {name=p62511 lab=_80570_/B }
C {devices/lab_pin.sym} 63400 -35160 0 1 {name=p62512 lab=_80582_/X }
C {sky130_stdcells/or2_4.sym} 63340 -35160 0 0 {name=X_80582_ }
C {sky130_stdcells/decap_3.sym} 63340 -35000 0 0 {name=XPHY_309 }
C {devices/lab_pin.sym} 63280 -34860 0 0 {name=p62513 lab=_51491_/A }
C {devices/lab_pin.sym} 63280 -34820 0 0 {name=p62514 lab=_53025_/B }
C {devices/lab_pin.sym} 63400 -34840 0 1 {name=p62515 lab=_51501_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -34840 0 0 {name=X_51501_ }
C {devices/lab_pin.sym} 63250 -34710 0 0 {name=p62516 lab=_82327_/CLK }
C {devices/lab_pin.sym} 63250 -34690 0 0 {name=p62517 lab=_77110_/B }
C {devices/lab_pin.sym} 63430 -34710 0 1 {name=p62518 lab=_82321_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -34700 0 0 {name=X_82321_ }
C {devices/lab_pin.sym} 63300 -34570 0 0 {name=p62519 lab=_67014_/X }
C {devices/lab_pin.sym} 63380 -34570 0 1 {name=p62520 lab=_67255_/X }
C {sky130_stdcells/buf_2.sym} 63340 -34570 0 0 {name=X_67255_ }
C {devices/lab_pin.sym} 63260 -34470 0 0 {name=p62521 lab=_85813_/Q }
C {devices/lab_pin.sym} 63260 -34430 0 0 {name=p62522 lab=_52470_/X }
C {devices/lab_pin.sym} 63260 -34390 0 0 {name=p62523 lab=_52480_/Y }
C {devices/lab_pin.sym} 63420 -34430 0 1 {name=p62524 lab=_52481_/Y }
C {sky130_stdcells/o21ai_4.sym} 63340 -34430 0 0 {name=X_52481_ }
C {devices/lab_pin.sym} 63280 -34310 0 0 {name=p62525 lab=_64474_/A }
C {devices/lab_pin.sym} 63280 -34270 0 0 {name=p62526 lab=_64421_/X }
C {devices/lab_pin.sym} 63280 -34230 0 0 {name=p62527 lab=_64467_/C }
C {devices/lab_pin.sym} 63400 -34270 0 1 {name=p62528 lab=_64467_/X }
C {sky130_stdcells/and3_4.sym} 63340 -34270 0 0 {name=X_64467_ }
C {devices/lab_pin.sym} 63260 -34170 0 0 {name=p62529 lab=_61673_/Y }
C {devices/lab_pin.sym} 63260 -34130 0 0 {name=p62530 lab=_61675_/Y }
C {devices/lab_pin.sym} 63260 -34090 0 0 {name=p62531 lab=_61594_/X }
C {devices/lab_pin.sym} 63260 -34050 0 0 {name=p62532 lab=_61676_/Y }
C {devices/lab_pin.sym} 63260 -34020 0 0 {name=p62533 lab=_61678_/Y }
C {devices/lab_pin.sym} 63420 -34090 0 1 {name=p62534 lab=_61679_/X }
C {sky130_stdcells/a41o_4.sym} 63340 -34090 0 0 {name=X_61679_ }
C {devices/lab_pin.sym} 63300 -33930 0 0 {name=p62535 lab=clkbuf_7_78_0_CLK/A }
C {devices/lab_pin.sym} 63380 -33930 0 1 {name=p62536 lab=clkbuf_7_78_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 63340 -33930 0 0 {name=Xclkbuf_7_78_0_CLK }
C {devices/lab_pin.sym} 63300 -33810 0 0 {name=p62537 lab=_54249_/A }
C {devices/lab_pin.sym} 63380 -33810 0 1 {name=p62538 lab=_54220_/X }
C {sky130_stdcells/buf_2.sym} 63340 -33810 0 0 {name=X_54220_ }
C {devices/lab_pin.sym} 63280 -33710 0 0 {name=p62539 lab=_66123_/A }
C {devices/lab_pin.sym} 63280 -33670 0 0 {name=p62540 lab=_66151_/B }
C {devices/lab_pin.sym} 63280 -33630 0 0 {name=p62541 lab=_80419_/B }
C {devices/lab_pin.sym} 63400 -33670 0 1 {name=p62542 lab=_66206_/X }
C {sky130_stdcells/and3_4.sym} 63340 -33670 0 0 {name=X_66206_ }
C {devices/lab_pin.sym} 63250 -33530 0 0 {name=p62543 lab=_85040_/CLK }
C {devices/lab_pin.sym} 63250 -33510 0 0 {name=p62544 lab=_85040_/D }
C {devices/lab_pin.sym} 63430 -33530 0 1 {name=p62545 lab=_57283_/B }
C {sky130_stdcells/dfxtp_4.sym} 63340 -33520 0 0 {name=X_85040_ }
C {devices/lab_pin.sym} 63260 -33410 0 0 {name=p62546 lab=_86011_/Q }
C {devices/lab_pin.sym} 63260 -33370 0 0 {name=p62547 lab=_51429_/X }
C {devices/lab_pin.sym} 63260 -33330 0 0 {name=p62548 lab=_51431_/Y }
C {devices/lab_pin.sym} 63420 -33370 0 1 {name=p62549 lab=_51432_/Y }
C {sky130_stdcells/o21ai_4.sym} 63340 -33370 0 0 {name=X_51432_ }
C {devices/lab_pin.sym} 63280 -33260 0 0 {name=p62550 lab=_64257_/A }
C {devices/lab_pin.sym} 63280 -33220 0 0 {name=p62551 lab=_63465_/B }
C {devices/lab_pin.sym} 63280 -33180 0 0 {name=p62552 lab=_63418_/C }
C {devices/lab_pin.sym} 63280 -33140 0 0 {name=p62553 lab=_63465_/D }
C {devices/lab_pin.sym} 63400 -33200 0 1 {name=p62554 lab=_63418_/Y }
C {sky130_stdcells/nand4_4.sym} 63340 -33200 0 0 {name=X_63418_ }
C {devices/lab_pin.sym} 63250 -33050 0 0 {name=p62555 lab=_83278_/CLK }
C {devices/lab_pin.sym} 63250 -33030 0 0 {name=p62556 lab=_80409_/X }
C {devices/lab_pin.sym} 63430 -33050 0 1 {name=p62557 lab=_82252_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -33040 0 0 {name=X_82252_ }
C {devices/lab_pin.sym} 63260 -32940 0 0 {name=p62558 lab=_67166_/X }
C {devices/lab_pin.sym} 63260 -32900 0 0 {name=p62559 lab=_67175_/Y }
C {devices/lab_pin.sym} 63260 -32860 0 0 {name=p62560 lab=_67152_/X }
C {devices/lab_pin.sym} 63260 -32820 0 0 {name=p62561 lab=_67185_/Y }
C {devices/lab_pin.sym} 63420 -32880 0 1 {name=p62562 lab=_67186_/X }
C {sky130_stdcells/a211o_4.sym} 63340 -32880 0 0 {name=X_67186_ }
C {devices/lab_pin.sym} 63260 -32750 0 0 {name=p62563 lab=_79722_/B }
C {devices/lab_pin.sym} 63260 -32710 0 0 {name=p62564 lab=_64373_/X }
C {devices/lab_pin.sym} 63260 -32670 0 0 {name=p62565 lab=_64397_/X }
C {devices/lab_pin.sym} 63420 -32710 0 1 {name=p62566 lab=_64398_/X }
C {sky130_stdcells/a21o_4.sym} 63340 -32710 0 0 {name=X_64398_ }
C {devices/lab_pin.sym} 63250 -32570 0 0 {name=p62567 lab=_81197_/CLK }
C {devices/lab_pin.sym} 63250 -32550 0 0 {name=p62568 lab=_75024_/X }
C {devices/lab_pin.sym} 63430 -32570 0 1 {name=p62569 lab=_49029_/A }
C {sky130_stdcells/dfxtp_4.sym} 63340 -32560 0 0 {name=X_81203_ }
C {devices/lab_pin.sym} 63280 -32460 0 0 {name=p62570 lab=_54127_/X }
C {devices/lab_pin.sym} 63280 -32420 0 0 {name=p62571 lab=_54160_/B }
C {devices/lab_pin.sym} 63280 -32380 0 0 {name=p62572 lab=_54146_/X }
C {devices/lab_pin.sym} 63280 -32340 0 0 {name=p62573 lab=_52982_/D }
C {devices/lab_pin.sym} 63400 -32400 0 1 {name=p62574 lab=_54151_/X }
C {sky130_stdcells/and4_4.sym} 63340 -32400 0 0 {name=X_54151_ }
C {devices/lab_pin.sym} 63300 -32250 0 0 {name=p62575 lab=_66065_/A }
C {devices/lab_pin.sym} 63380 -32250 0 1 {name=p62576 lab=_66137_/X }
C {sky130_stdcells/buf_2.sym} 63340 -32250 0 0 {name=X_66137_ }
C {devices/lab_pin.sym} 63300 -32130 0 0 {name=p62577 lab=_51790_/A }
C {devices/lab_pin.sym} 63380 -32130 0 1 {name=p62578 lab=_51364_/A }
C {sky130_stdcells/buf_2.sym} 63340 -32130 0 0 {name=X_51363_ }
C {devices/lab_pin.sym} 63260 -32040 0 0 {name=p62579 lab=_59448_/A }
C {devices/lab_pin.sym} 63260 -32000 0 0 {name=p62580 lab=_60493_/A }
C {devices/lab_pin.sym} 63260 -31960 0 0 {name=p62581 lab=_64190_/A }
C {devices/lab_pin.sym} 63260 -31920 0 0 {name=p62582 lab=_60555_/A }
C {devices/lab_pin.sym} 63420 -31980 0 1 {name=p62583 lab=_63349_/X }
C {sky130_stdcells/a2bb2o_4.sym} 63340 -31980 0 0 {name=X_63349_ }
C {devices/lab_pin.sym} 63250 -31830 0 0 {name=p62584 lab=_84951_/CLK }
C {devices/lab_pin.sym} 63250 -31810 0 0 {name=p62585 lab=_82183_/D }
C {devices/lab_pin.sym} 63430 -31830 0 1 {name=p62586 lab=_82183_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -31820 0 0 {name=X_82183_ }
C {devices/lab_pin.sym} 63260 -31710 0 0 {name=p62587 lab=_85697_/Q }
C {devices/lab_pin.sym} 63260 -31670 0 0 {name=p62588 lab=_53093_/X }
C {devices/lab_pin.sym} 63260 -31630 0 0 {name=p62589 lab=_53101_/Y }
C {devices/lab_pin.sym} 63420 -31670 0 1 {name=p62590 lab=_53102_/Y }
C {sky130_stdcells/o21ai_4.sym} 63340 -31670 0 0 {name=X_53102_ }
C {devices/lab_pin.sym} 63280 -31550 0 0 {name=p62591 lab=_50314_/A }
C {devices/lab_pin.sym} 63280 -31510 0 0 {name=p62592 lab=_74509_/C }
C {devices/lab_pin.sym} 63280 -31470 0 0 {name=p62593 lab=_50247_/X }
C {devices/lab_pin.sym} 63400 -31510 0 1 {name=p62594 lab=_50314_/X }
C {sky130_stdcells/and3_4.sym} 63340 -31510 0 0 {name=X_50314_ }
C {devices/lab_pin.sym} 63250 -31370 0 0 {name=p62595 lab=_81134_/CLK }
C {devices/lab_pin.sym} 63250 -31350 0 0 {name=p62596 lab=_81134_/D }
C {devices/lab_pin.sym} 63430 -31370 0 1 {name=p62597 lab=_40694_/A }
C {sky130_stdcells/dfxtp_4.sym} 63340 -31360 0 0 {name=X_81134_ }
C {devices/lab_pin.sym} 63260 -31250 0 0 {name=p62598 lab=_85508_/Q }
C {devices/lab_pin.sym} 63260 -31210 0 0 {name=p62599 lab=_54067_/X }
C {devices/lab_pin.sym} 63260 -31170 0 0 {name=p62600 lab=_54081_/Y }
C {devices/lab_pin.sym} 63420 -31210 0 1 {name=p62601 lab=_54082_/Y }
C {sky130_stdcells/o21ai_4.sym} 63340 -31210 0 0 {name=X_54082_ }
C {devices/lab_pin.sym} 63300 -31070 0 0 {name=p62602 lab=_65516_/A }
C {devices/lab_pin.sym} 63380 -31070 0 1 {name=p62603 lab=_66068_/X }
C {sky130_stdcells/buf_2.sym} 63340 -31070 0 0 {name=X_66068_ }
C {devices/lab_pin.sym} 63280 -30960 0 0 {name=p62604 lab=_51298_/A }
C {devices/lab_pin.sym} 63280 -30920 0 0 {name=p62605 lab=_51294_/B }
C {devices/lab_pin.sym} 63400 -30940 0 1 {name=p62606 lab=_51294_/X }
C {sky130_stdcells/and2_4.sym} 63340 -30940 0 0 {name=X_51294_ }
C {devices/lab_pin.sym} 63250 -30810 0 0 {name=p62607 lab=_86982_/CLK }
C {devices/lab_pin.sym} 63250 -30790 0 0 {name=p62608 lab=_86991_/D }
C {devices/lab_pin.sym} 63430 -30810 0 1 {name=p62609 lab=_44709_/A }
C {sky130_stdcells/dfxtp_4.sym} 63340 -30800 0 0 {name=X_86991_ }
C {devices/lab_pin.sym} 63300 -30670 0 0 {name=p62610 lab=clkbuf_7_70_0_CLK/X }
C {devices/lab_pin.sym} 63380 -30670 0 1 {name=p62611 lab=clkbuf_9_283_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 63340 -30670 0 0 {name=Xclkbuf_8_141_0_CLK }
C {devices/lab_pin.sym} 63280 -30560 0 0 {name=p62612 lab=_53025_/A }
C {devices/lab_pin.sym} 63280 -30520 0 0 {name=p62613 lab=_53033_/B }
C {devices/lab_pin.sym} 63400 -30540 0 1 {name=p62614 lab=_53033_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -30540 0 0 {name=X_53033_ }
C {devices/lab_pin.sym} 63260 -30430 0 0 {name=p62615 lab=_57905_/Y }
C {devices/lab_pin.sym} 63260 -30390 0 0 {name=p62616 lab=_57907_/Y }
C {devices/lab_pin.sym} 63260 -30350 0 0 {name=p62617 lab=_57909_/X }
C {devices/lab_pin.sym} 63420 -30390 0 1 {name=p62618 lab=_57910_/X }
C {sky130_stdcells/a21o_4.sym} 63340 -30390 0 0 {name=X_57910_ }
C {devices/lab_pin.sym} 63280 -30260 0 0 {name=p62619 lab=_65019_/A }
C {devices/lab_pin.sym} 63280 -30220 0 0 {name=p62620 lab=_65018_/Y }
C {devices/lab_pin.sym} 63400 -30240 0 1 {name=p62621 lab=_65019_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -30240 0 0 {name=X_65019_ }
C {devices/lab_pin.sym} 63300 -30110 0 0 {name=p62622 lab=_50256_/A }
C {devices/lab_pin.sym} 63380 -30110 0 1 {name=p62623 lab=_50537_/A }
C {sky130_stdcells/buf_2.sym} 63340 -30110 0 0 {name=X_50245_ }
C {devices/lab_pin.sym} 63250 -29990 0 0 {name=p62624 lab=_82768_/CLK }
C {devices/lab_pin.sym} 63250 -29970 0 0 {name=p62625 lab=_51811_/Y }
C {devices/lab_pin.sym} 63430 -29990 0 1 {name=p62626 lab=_85942_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -29980 0 0 {name=X_85942_ }
C {devices/lab_pin.sym} 63250 -29850 0 0 {name=p62627 lab=_81065_/CLK }
C {devices/lab_pin.sym} 63250 -29830 0 0 {name=p62628 lab=_81097_/Q }
C {devices/lab_pin.sym} 63430 -29850 0 1 {name=p62629 lab=_75175_/B }
C {sky130_stdcells/dfxtp_4.sym} 63340 -29840 0 0 {name=X_81065_ }
C {devices/lab_pin.sym} 63260 -29730 0 0 {name=p62630 lab=_58835_/X }
C {devices/lab_pin.sym} 63260 -29690 0 0 {name=p62631 lab=_85448_/Q }
C {devices/lab_pin.sym} 63260 -29650 0 0 {name=p62632 lab=_58889_/X }
C {devices/lab_pin.sym} 63420 -29690 0 1 {name=p62633 lab=_58890_/Y }
C {sky130_stdcells/o21ai_4.sym} 63340 -29690 0 0 {name=X_58890_ }
C {devices/lab_pin.sym} 63260 -29570 0 0 {name=p62634 lab=_80005_/X }
C {devices/lab_pin.sym} 63260 -29530 0 0 {name=p62635 lab=_80006_/X }
C {devices/lab_pin.sym} 63260 -29490 0 0 {name=p62636 lab=_80015_/Y }
C {devices/lab_pin.sym} 63420 -29530 0 1 {name=p62637 lab=_80016_/Y }
C {sky130_stdcells/a21boi_4.sym} 63340 -29530 0 0 {name=X_80016_ }
C {devices/lab_pin.sym} 63260 -29410 0 0 {name=p62638 lab=_57836_/Y }
C {devices/lab_pin.sym} 63260 -29370 0 0 {name=p62639 lab=_57840_/Y }
C {devices/lab_pin.sym} 63260 -29330 0 0 {name=p62640 lab=_57829_/X }
C {devices/lab_pin.sym} 63420 -29370 0 1 {name=p62641 lab=_57841_/X }
C {sky130_stdcells/a21o_4.sym} 63340 -29370 0 0 {name=X_57841_ }
C {devices/lab_pin.sym} 63260 -29260 0 0 {name=p62642 lab=_87052_/Q }
C {devices/lab_pin.sym} 63260 -29220 0 0 {name=p62643 lab=_66608_/X }
C {devices/lab_pin.sym} 63260 -29180 0 0 {name=p62644 lab=_58827_/A }
C {devices/lab_pin.sym} 63260 -29140 0 0 {name=p62645 lab=_69826_/X }
C {devices/lab_pin.sym} 63420 -29200 0 1 {name=p62646 lab=_69827_/X }
C {sky130_stdcells/a211o_4.sym} 63340 -29200 0 0 {name=X_69827_ }
C {devices/lab_pin.sym} 63260 -29070 0 0 {name=p62647 lab=_50174_/Y }
C {devices/lab_pin.sym} 63260 -29030 0 0 {name=p62648 lab=_50166_/X }
C {devices/lab_pin.sym} 63260 -28990 0 0 {name=p62649 lab=_50175_/X }
C {devices/lab_pin.sym} 63420 -29030 0 1 {name=p62650 lab=_50176_/Y }
C {sky130_stdcells/a21oi_4.sym} 63340 -29030 0 0 {name=X_50176_ }
C {devices/lab_pin.sym} 63250 -28890 0 0 {name=p62651 lab=_85859_/CLK }
C {devices/lab_pin.sym} 63250 -28870 0 0 {name=p62652 lab=_85873_/D }
C {devices/lab_pin.sym} 63430 -28890 0 1 {name=p62653 lab=_85873_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -28880 0 0 {name=X_85873_ }
C {devices/lab_pin.sym} 63300 -28750 0 0 {name=p62654 lab=clkbuf_6_8_0_CLK/X }
C {devices/lab_pin.sym} 63380 -28750 0 1 {name=p62655 lab=clkbuf_7_16_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 63340 -28750 0 0 {name=Xclkbuf_7_16_0_CLK }
C {devices/lab_pin.sym} 63250 -28630 0 0 {name=p62656 lab=_82899_/CLK }
C {devices/lab_pin.sym} 63250 -28610 0 0 {name=p62657 lab=_87612_/D }
C {devices/lab_pin.sym} 63430 -28630 0 1 {name=p62658 lab=_87612_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -28620 0 0 {name=X_87612_ }
C {devices/lab_pin.sym} 63250 -28490 0 0 {name=p62659 lab=_83438_/CLK }
C {devices/lab_pin.sym} 63250 -28470 0 0 {name=p62660 lab=_84824_/D }
C {devices/lab_pin.sym} 63430 -28490 0 1 {name=p62661 lab=_84824_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -28480 0 0 {name=X_84824_ }
C {devices/lab_pin.sym} 63300 -28350 0 0 {name=p62662 lab=_57965_/A }
C {devices/lab_pin.sym} 63380 -28350 0 1 {name=p62663 lab=_57947_/A }
C {sky130_stdcells/buf_2.sym} 63340 -28350 0 0 {name=X_57772_ }
C {devices/lab_pin.sym} 63280 -28240 0 0 {name=p62664 lab=_69758_/A }
C {devices/lab_pin.sym} 63280 -28200 0 0 {name=p62665 lab=_69758_/B }
C {devices/lab_pin.sym} 63400 -28220 0 1 {name=p62666 lab=_69758_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -28220 0 0 {name=X_69758_ }
C {devices/lab_pin.sym} 63300 -28090 0 0 {name=p62667 lab=clkbuf_7_78_0_CLK/X }
C {devices/lab_pin.sym} 63380 -28090 0 1 {name=p62668 lab=clkbuf_9_313_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 63340 -28090 0 0 {name=Xclkbuf_8_156_0_CLK }
C {devices/lab_pin.sym} 63260 -27990 0 0 {name=p62669 lab=_54982_/Y }
C {devices/lab_pin.sym} 63260 -27950 0 0 {name=p62670 lab=_54971_/X }
C {devices/lab_pin.sym} 63260 -27910 0 0 {name=p62671 lab=_54983_/X }
C {devices/lab_pin.sym} 63420 -27950 0 1 {name=p62672 lab=_54984_/Y }
C {sky130_stdcells/a21oi_4.sym} 63340 -27950 0 0 {name=X_54984_ }
C {devices/lab_pin.sym} 63300 -27810 0 0 {name=p62673 lab=clkbuf_9_75_0_CLK/X }
C {devices/lab_pin.sym} 63380 -27810 0 1 {name=p62674 lab=_81689_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 63340 -27810 0 0 {name=Xclkbuf_10_151_0_CLK }
C {devices/lab_pin.sym} 63300 -27690 0 0 {name=p62675 lab=_69814_/A }
C {devices/lab_pin.sym} 63380 -27690 0 1 {name=p62676 lab=_59512_/A }
C {sky130_stdcells/buf_2.sym} 63340 -27690 0 0 {name=X_59511_ }
C {devices/lab_pin.sym} 63280 -27580 0 0 {name=p62677 lab=_56609_/X }
C {devices/lab_pin.sym} 63280 -27540 0 0 {name=p62678 lab=_56723_/B }
C {devices/lab_pin.sym} 63400 -27560 0 1 {name=p62679 lab=_56723_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -27560 0 0 {name=X_56723_ }
C {devices/lab_pin.sym} 63260 -27460 0 0 {name=p62680 lab=_87090_/Q }
C {devices/lab_pin.sym} 63260 -27420 0 0 {name=p62681 lab=_68707_/X }
C {devices/lab_pin.sym} 63260 -27380 0 0 {name=p62682 lab=_68630_/X }
C {devices/lab_pin.sym} 63260 -27340 0 0 {name=p62683 lab=_68708_/X }
C {devices/lab_pin.sym} 63420 -27400 0 1 {name=p62684 lab=_68709_/X }
C {sky130_stdcells/a211o_4.sym} 63340 -27400 0 0 {name=X_68709_ }
C {devices/lab_pin.sym} 63250 -27250 0 0 {name=p62685 lab=_87544_/CLK }
C {devices/lab_pin.sym} 63250 -27230 0 0 {name=p62686 lab=_43198_/Y }
C {devices/lab_pin.sym} 63430 -27250 0 1 {name=p62687 lab=_73465_/A }
C {sky130_stdcells/dfxtp_4.sym} 63340 -27240 0 0 {name=X_87543_ }
C {devices/lab_pin.sym} 63260 -27130 0 0 {name=p62688 lab=_53933_/Y }
C {devices/lab_pin.sym} 63260 -27090 0 0 {name=p62689 lab=_53914_/X }
C {devices/lab_pin.sym} 63260 -27050 0 0 {name=p62690 lab=_53934_/Y }
C {devices/lab_pin.sym} 63420 -27090 0 1 {name=p62691 lab=_85539_/D }
C {sky130_stdcells/a21boi_4.sym} 63340 -27090 0 0 {name=X_53935_ }
C {devices/lab_pin.sym} 63250 -26950 0 0 {name=p62692 lab=_84757_/CLK }
C {devices/lab_pin.sym} 63250 -26930 0 0 {name=p62693 lab=_84755_/D }
C {devices/lab_pin.sym} 63430 -26950 0 1 {name=p62694 lab=_84755_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -26940 0 0 {name=X_84755_ }
C {devices/lab_pin.sym} 63300 -26810 0 0 {name=p62695 lab=clkbuf_9_390_0_CLK/X }
C {devices/lab_pin.sym} 63380 -26810 0 1 {name=p62696 lab=_82711_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 63340 -26810 0 0 {name=Xclkbuf_10_781_0_CLK }
C {devices/lab_pin.sym} 63250 -26690 0 0 {name=p62697 lab=_82558_/CLK }
C {devices/lab_pin.sym} 63250 -26670 0 0 {name=p62698 lab=_81967_/D }
C {devices/lab_pin.sym} 63430 -26690 0 1 {name=p62699 lab=_81967_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -26680 0 0 {name=X_81967_ }
C {devices/lab_pin.sym} 63260 -26570 0 0 {name=p62700 lab=_69686_/X }
C {devices/lab_pin.sym} 63260 -26530 0 0 {name=p62701 lab=_69688_/X }
C {devices/lab_pin.sym} 63260 -26490 0 0 {name=p62702 lab=_69678_/X }
C {devices/lab_pin.sym} 63420 -26530 0 1 {name=p62703 lab=_69689_/X }
C {sky130_stdcells/a21o_4.sym} 63340 -26530 0 0 {name=X_69689_ }
C {devices/lab_pin.sym} 63260 -26420 0 0 {name=p62704 lab=_40899_/X }
C {devices/lab_pin.sym} 63260 -26380 0 0 {name=p62705 lab=_40821_/X }
C {devices/lab_pin.sym} 63260 -26340 0 0 {name=p62706 lab=_88314_/Q }
C {devices/lab_pin.sym} 63260 -26300 0 0 {name=p62707 lab=_40822_/X }
C {devices/lab_pin.sym} 63420 -26360 0 1 {name=p62708 lab=_40900_/X }
C {sky130_stdcells/a2bb2o_4.sym} 63340 -26360 0 0 {name=X_40900_ }
C {devices/lab_pin.sym} 63260 -26230 0 0 {name=p62709 lab=_58220_/Y }
C {devices/lab_pin.sym} 63260 -26190 0 0 {name=p62710 lab=_71718_/X }
C {devices/lab_pin.sym} 63260 -26150 0 0 {name=p62711 lab=_71719_/Y }
C {devices/lab_pin.sym} 63420 -26190 0 1 {name=p62712 lab=_83400_/D }
C {sky130_stdcells/o21ai_4.sym} 63340 -26190 0 0 {name=X_71720_ }
C {devices/lab_pin.sym} 63300 -26050 0 0 {name=p62713 lab=_58982_/A }
C {devices/lab_pin.sym} 63380 -26050 0 1 {name=p62714 lab=_59442_/X }
C {sky130_stdcells/buf_2.sym} 63340 -26050 0 0 {name=X_59442_ }
C {devices/lab_pin.sym} 63250 -25930 0 0 {name=p62715 lab=_83707_/CLK }
C {devices/lab_pin.sym} 63250 -25910 0 0 {name=p62716 lab=_83706_/D }
C {devices/lab_pin.sym} 63430 -25930 0 1 {name=p62717 lab=_83706_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -25920 0 0 {name=X_83706_ }
C {devices/lab_pin.sym} 63250 -25790 0 0 {name=p62718 lab=_81507_/CLK }
C {devices/lab_pin.sym} 63250 -25770 0 0 {name=p62719 lab=_80918_/D }
C {devices/lab_pin.sym} 63430 -25790 0 1 {name=p62720 lab=_80918_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -25780 0 0 {name=X_80918_ }
C {devices/lab_pin.sym} 63280 -25660 0 0 {name=p62721 lab=_57131_/A }
C {devices/lab_pin.sym} 63280 -25620 0 0 {name=p62722 lab=_56653_/Y }
C {devices/lab_pin.sym} 63400 -25640 0 1 {name=p62723 lab=_56655_/A }
C {sky130_stdcells/nor2_4.sym} 63340 -25640 0 0 {name=X_56654_ }
C {devices/lab_pin.sym} 63250 -25510 0 0 {name=p62724 lab=_88180_/CLK }
C {devices/lab_pin.sym} 63250 -25490 0 0 {name=p62725 lab=_87474_/D }
C {devices/lab_pin.sym} 63430 -25510 0 1 {name=p62726 lab=_87474_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -25500 0 0 {name=X_87474_ }
C {devices/lab_pin.sym} 63300 -25370 0 0 {name=p62727 lab=_41880_/A }
C {devices/lab_pin.sym} 63380 -25370 0 1 {name=p62728 lab=_41881_/A }
C {sky130_stdcells/buf_2.sym} 63340 -25370 0 0 {name=X_41880_ }
C {devices/lab_pin.sym} 63260 -25270 0 0 {name=p62729 lab=_85552_/Q }
C {devices/lab_pin.sym} 63260 -25230 0 0 {name=p62730 lab=_53784_/X }
C {devices/lab_pin.sym} 63260 -25190 0 0 {name=p62731 lab=_53865_/Y }
C {devices/lab_pin.sym} 63420 -25230 0 1 {name=p62732 lab=_53866_/Y }
C {sky130_stdcells/o21ai_4.sym} 63340 -25230 0 0 {name=X_53866_ }
C {devices/lab_pin.sym} 63250 -25090 0 0 {name=p62733 lab=_84713_/CLK }
C {devices/lab_pin.sym} 63250 -25070 0 0 {name=p62734 lab=_59861_/Y }
C {devices/lab_pin.sym} 63430 -25090 0 1 {name=p62735 lab=_80323_/A }
C {sky130_stdcells/dfxtp_4.sym} 63340 -25080 0 0 {name=X_84686_ }
C {devices/lab_pin.sym} 63300 -24950 0 0 {name=p62736 lab=clkbuf_8_136_0_CLK/X }
C {devices/lab_pin.sym} 63380 -24950 0 1 {name=p62737 lab=clkbuf_9_272_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 63340 -24950 0 0 {name=Xclkbuf_9_272_0_CLK }
C {devices/lab_pin.sym} 63250 -24830 0 0 {name=p62738 lab=_82116_/CLK }
C {devices/lab_pin.sym} 63250 -24810 0 0 {name=p62739 lab=_81898_/D }
C {devices/lab_pin.sym} 63430 -24830 0 1 {name=p62740 lab=_82274_/D }
C {sky130_stdcells/dfxtp_4.sym} 63340 -24820 0 0 {name=X_81898_ }
C {devices/lab_pin.sym} 63300 -24690 0 0 {name=p62741 lab=_44116_/B }
C {devices/lab_pin.sym} 63380 -24690 0 1 {name=p62742 lab=_55605_/X }
C {sky130_stdcells/buf_2.sym} 63340 -24690 0 0 {name=X_55605_ }
C {devices/lab_pin.sym} 63250 -24570 0 0 {name=p62743 lab=_86424_/CLK }
C {devices/lab_pin.sym} 63250 -24550 0 0 {name=p62744 lab=_86425_/D }
C {devices/lab_pin.sym} 63430 -24570 0 1 {name=p62745 lab=_86425_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -24560 0 0 {name=X_86425_ }
C {devices/lab_pin.sym} 63300 -24430 0 0 {name=p62746 lab=_40831_/A }
C {devices/lab_pin.sym} 63380 -24430 0 1 {name=p62747 lab=_40831_/X }
C {sky130_stdcells/buf_2.sym} 63340 -24430 0 0 {name=X_40831_ }
C {devices/lab_pin.sym} 63300 -24310 0 0 {name=p62748 lab=_52845_/A }
C {devices/lab_pin.sym} 63380 -24310 0 1 {name=p62749 lab=_52818_/C }
C {sky130_stdcells/buf_2.sym} 63340 -24310 0 0 {name=X_52817_ }
C {devices/lab_pin.sym} 63280 -24200 0 0 {name=p62750 lab=_59373_/A }
C {devices/lab_pin.sym} 63280 -24160 0 0 {name=p62751 lab=_59226_/B }
C {devices/lab_pin.sym} 63400 -24180 0 1 {name=p62752 lab=_59373_/Y }
C {sky130_stdcells/nor2_4.sym} 63340 -24180 0 0 {name=X_59373_ }
C {devices/lab_pin.sym} 63260 -24070 0 0 {name=p62753 lab=_58500_/Y }
C {devices/lab_pin.sym} 63260 -24030 0 0 {name=p62754 lab=_71649_/X }
C {devices/lab_pin.sym} 63260 -23990 0 0 {name=p62755 lab=_71650_/Y }
C {devices/lab_pin.sym} 63420 -24030 0 1 {name=p62756 lab=_83425_/D }
C {sky130_stdcells/o21ai_4.sym} 63340 -24030 0 0 {name=X_71651_ }
C {devices/lab_pin.sym} 63250 -23890 0 0 {name=p62757 lab=_86424_/CLK }
C {devices/lab_pin.sym} 63250 -23870 0 0 {name=p62758 lab=_70999_/Y }
C {devices/lab_pin.sym} 63430 -23890 0 1 {name=p62759 lab=_46476_/A }
C {sky130_stdcells/dfxtp_4.sym} 63340 -23880 0 0 {name=X_83637_ }
C {devices/lab_pin.sym} 63260 -23780 0 0 {name=p62760 lab=_56568_/X }
C {devices/lab_pin.sym} 63260 -23740 0 0 {name=p62761 lab=_56584_/X }
C {devices/lab_pin.sym} 63260 -23700 0 0 {name=p62762 lab=_55590_/B }
C {devices/lab_pin.sym} 63260 -23660 0 0 {name=p62763 lab=_56572_/X }
C {devices/lab_pin.sym} 63420 -23720 0 1 {name=p62764 lab=_56585_/X }
C {sky130_stdcells/a2bb2o_4.sym} 63340 -23720 0 0 {name=X_56585_ }
C {devices/lab_pin.sym} 63300 -23570 0 0 {name=p62765 lab=clkbuf_9_83_0_CLK/X }
C {devices/lab_pin.sym} 63380 -23570 0 1 {name=p62766 lab=_81250_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 63340 -23570 0 0 {name=Xclkbuf_10_166_0_CLK }
C {devices/lab_pin.sym} 63250 -23450 0 0 {name=p62767 lab=_80849_/CLK }
C {devices/lab_pin.sym} 63250 -23430 0 0 {name=p62768 lab=_80881_/Q }
C {devices/lab_pin.sym} 63430 -23450 0 1 {name=p62769 lab=_80849_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -23440 0 0 {name=X_80849_ }
C {devices/lab_pin.sym} 63260 -23330 0 0 {name=p62770 lab=_85566_/Q }
C {devices/lab_pin.sym} 63260 -23290 0 0 {name=p62771 lab=_53722_/X }
C {devices/lab_pin.sym} 63260 -23250 0 0 {name=p62772 lab=_53796_/Y }
C {devices/lab_pin.sym} 63420 -23290 0 1 {name=p62773 lab=_53797_/Y }
C {sky130_stdcells/o21ai_4.sym} 63340 -23290 0 0 {name=X_53797_ }
C {devices/lab_pin.sym} 63300 -23150 0 0 {name=p62774 lab=_70771_/A }
C {devices/lab_pin.sym} 63380 -23150 0 1 {name=p62775 lab=_70714_/A }
C {sky130_stdcells/buf_2.sym} 63340 -23150 0 0 {name=X_70602_ }
C {devices/lab_pin.sym} 63260 -23050 0 0 {name=p62776 lab=_58310_/X }
C {devices/lab_pin.sym} 63260 -23010 0 0 {name=p62777 lab=_83454_/Q }
C {devices/lab_pin.sym} 63260 -22970 0 0 {name=p62778 lab=_58323_/Y }
C {devices/lab_pin.sym} 63420 -23010 0 1 {name=p62779 lab=_84878_/D }
C {sky130_stdcells/o21a_4.sym} 63340 -23010 0 0 {name=X_58324_ }
C {devices/lab_pin.sym} 63260 -22910 0 0 {name=p62780 lab=_43542_/X }
C {devices/lab_pin.sym} 63260 -22870 0 0 {name=p62781 lab=_43546_/X }
C {devices/lab_pin.sym} 63260 -22830 0 0 {name=p62782 lab=_40452_/X }
C {devices/lab_pin.sym} 63260 -22790 0 0 {name=p62783 lab=_87365_/Q }
C {devices/lab_pin.sym} 63260 -22750 0 0 {name=p62784 lab=_43549_/X }
C {devices/lab_pin.sym} 63420 -22830 0 1 {name=p62785 lab=_43550_/Y }
C {sky130_stdcells/o32ai_4.sym} 63340 -22830 0 0 {name=X_43550_ }
C {devices/lab_pin.sym} 63300 -22670 0 0 {name=p62786 lab=clkbuf_9_398_0_CLK/X }
C {devices/lab_pin.sym} 63380 -22670 0 1 {name=p62787 lab=_82692_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 63340 -22670 0 0 {name=Xclkbuf_10_796_0_CLK }
C {devices/lab_pin.sym} 63280 -22580 0 0 {name=p62788 lab=_55536_/A }
C {devices/lab_pin.sym} 63280 -22540 0 0 {name=p62789 lab=_55526_/X }
C {devices/lab_pin.sym} 63280 -22500 0 0 {name=p62790 lab=_55536_/C }
C {devices/lab_pin.sym} 63280 -22460 0 0 {name=p62791 lab=_55536_/D }
C {devices/lab_pin.sym} 63400 -22520 0 1 {name=p62792 lab=_55536_/X }
C {sky130_stdcells/and4_4.sym} 63340 -22520 0 0 {name=X_55536_ }
C {devices/lab_pin.sym} 63300 -22370 0 0 {name=p62793 lab=_71978_/A }
C {devices/lab_pin.sym} 63380 -22370 0 1 {name=p62794 lab=_74370_/X }
C {sky130_stdcells/buf_2.sym} 63340 -22370 0 0 {name=X_74370_ }
C {devices/lab_pin.sym} 63250 -22250 0 0 {name=p62795 lab=_86359_/CLK }
C {devices/lab_pin.sym} 63250 -22230 0 0 {name=p62796 lab=_49611_/Y }
C {devices/lab_pin.sym} 63430 -22250 0 1 {name=p62797 lab=_59167_/B }
C {sky130_stdcells/dfxtp_4.sym} 63340 -22240 0 0 {name=X_86356_ }
C {devices/lab_pin.sym} 63300 -22110 0 0 {name=p62798 lab=_40762_/A }
C {devices/lab_pin.sym} 63380 -22110 0 1 {name=p62799 lab=_40762_/X }
C {sky130_stdcells/buf_2.sym} 63340 -22110 0 0 {name=X_40762_ }
C {devices/lab_pin.sym} 63280 -22000 0 0 {name=p62800 lab=_52744_/A }
C {devices/lab_pin.sym} 63280 -21960 0 0 {name=p62801 lab=_52748_/B }
C {devices/lab_pin.sym} 63400 -21980 0 1 {name=p62802 lab=_52748_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -21980 0 0 {name=X_52748_ }
C {devices/lab_pin.sym} 63300 -21850 0 0 {name=p62803 lab=_71189_/B }
C {devices/lab_pin.sym} 63380 -21850 0 1 {name=p62804 lab=_71582_/X }
C {sky130_stdcells/buf_2.sym} 63340 -21850 0 0 {name=X_71582_ }
C {devices/lab_pin.sym} 63250 -21730 0 0 {name=p62805 lab=_86500_/CLK }
C {devices/lab_pin.sym} 63250 -21710 0 0 {name=p62806 lab=_71220_/Y }
C {devices/lab_pin.sym} 63430 -21730 0 1 {name=p62807 lab=_48638_/A }
C {sky130_stdcells/dfxtp_4.sym} 63340 -21720 0 0 {name=X_83568_ }
C {devices/lab_pin.sym} 63300 -21590 0 0 {name=p62808 lab=_41993_/A }
C {devices/lab_pin.sym} 63380 -21590 0 1 {name=p62809 lab=_42501_/X }
C {sky130_stdcells/buf_2.sym} 63340 -21590 0 0 {name=X_42501_ }
C {devices/lab_pin.sym} 63260 -21500 0 0 {name=p62810 lab=_69860_/B }
C {devices/lab_pin.sym} 63260 -21460 0 0 {name=p62811 lab=_73319_/X }
C {devices/lab_pin.sym} 63260 -21420 0 0 {name=p62812 lab=_72890_/X }
C {devices/lab_pin.sym} 63260 -21380 0 0 {name=p62813 lab=_73320_/Y }
C {devices/lab_pin.sym} 63420 -21440 0 1 {name=p62814 lab=_73321_/X }
C {sky130_stdcells/a211o_4.sym} 63340 -21440 0 0 {name=X_73321_ }
C {devices/lab_pin.sym} 63250 -21290 0 0 {name=p62815 lab=_85213_/CLK }
C {devices/lab_pin.sym} 63250 -21270 0 0 {name=p62816 lab=_85307_/D }
C {devices/lab_pin.sym} 63430 -21290 0 1 {name=p62817 lab=_55934_/B }
C {sky130_stdcells/dfxtp_4.sym} 63340 -21280 0 0 {name=X_85307_ }
C {devices/lab_pin.sym} 63300 -21150 0 0 {name=p62818 lab=_70532_/Y }
C {devices/lab_pin.sym} 63380 -21150 0 1 {name=p62819 lab=_70533_/X }
C {sky130_stdcells/buf_2.sym} 63340 -21150 0 0 {name=X_70533_ }
C {devices/lab_pin.sym} 63300 -21030 0 0 {name=p62820 lab=_58273_/A }
C {devices/lab_pin.sym} 63380 -21030 0 1 {name=p62821 lab=_58268_/B }
C {sky130_stdcells/buf_2.sym} 63340 -21030 0 0 {name=X_58255_ }
C {devices/lab_pin.sym} 63250 -20910 0 0 {name=p62822 lab=_82518_/CLK }
C {devices/lab_pin.sym} 63250 -20890 0 0 {name=p62823 lab=_82519_/D }
C {devices/lab_pin.sym} 63430 -20910 0 1 {name=p62824 lab=_82519_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -20900 0 0 {name=X_82519_ }
C {devices/lab_pin.sym} 63300 -20770 0 0 {name=p62825 lab=_43480_/Y }
C {devices/lab_pin.sym} 63380 -20770 0 1 {name=p62826 lab=_87401_/D }
C {sky130_stdcells/inv_2.sym} 63340 -20770 0 0 {name=X_43481_ }
C {devices/lab_pin.sym} 63300 -20650 0 0 {name=p62827 lab=clkbuf_9_286_0_CLK/A }
C {devices/lab_pin.sym} 63380 -20650 0 1 {name=p62828 lab=clkbuf_9_287_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 63340 -20650 0 0 {name=Xclkbuf_9_287_0_CLK }
C {devices/lab_pin.sym} 63300 -20530 0 0 {name=p62829 lab=_55466_/X }
C {devices/lab_pin.sym} 63380 -20530 0 1 {name=p62830 lab=_55467_/X }
C {sky130_stdcells/buf_2.sym} 63340 -20530 0 0 {name=X_55467_ }
C {devices/lab_pin.sym} 63250 -20410 0 0 {name=p62831 lab=_86610_/CLK }
C {devices/lab_pin.sym} 63250 -20390 0 0 {name=p62832 lab=_49985_/Y }
C {devices/lab_pin.sym} 63430 -20410 0 1 {name=p62833 lab=_86287_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -20400 0 0 {name=X_86287_ }
C {devices/lab_pin.sym} 63300 -20270 0 0 {name=p62834 lab=_40692_/Y }
C {devices/lab_pin.sym} 63380 -20270 0 1 {name=p62835 lab=_88353_/D }
C {sky130_stdcells/inv_2.sym} 63340 -20270 0 0 {name=X_40693_ }
C {devices/lab_pin.sym} 63300 -20150 0 0 {name=p62836 lab=_52679_/A }
C {devices/lab_pin.sym} 63380 -20150 0 1 {name=p62837 lab=_52708_/A }
C {sky130_stdcells/buf_2.sym} 63340 -20150 0 0 {name=X_52679_ }
C {devices/lab_pin.sym} 63250 -20030 0 0 {name=p62838 lab=_81233_/CLK }
C {devices/lab_pin.sym} 63250 -20010 0 0 {name=p62839 lab=_71438_/X }
C {devices/lab_pin.sym} 63430 -20030 0 1 {name=p62840 lab=_83499_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -20020 0 0 {name=X_83499_ }
C {devices/lab_pin.sym} 63260 -19910 0 0 {name=p62841 lab=_45202_/X }
C {devices/lab_pin.sym} 63260 -19870 0 0 {name=p62842 lab=_61568_/B }
C {devices/lab_pin.sym} 63260 -19830 0 0 {name=p62843 lab=_45219_/X }
C {devices/lab_pin.sym} 63420 -19870 0 1 {name=p62844 lab=_45220_/Y }
C {sky130_stdcells/o21ai_4.sym} 63340 -19870 0 0 {name=X_45220_ }
C {devices/lab_pin.sym} 63260 -19750 0 0 {name=p62845 lab=_57204_/X }
C {devices/lab_pin.sym} 63260 -19710 0 0 {name=p62846 lab=_57205_/Y }
C {devices/lab_pin.sym} 63260 -19670 0 0 {name=p62847 lab=_57112_/X }
C {devices/lab_pin.sym} 63420 -19710 0 1 {name=p62848 lab=_57206_/Y }
C {sky130_stdcells/a21oi_4.sym} 63340 -19710 0 0 {name=X_57206_ }
C {devices/lab_pin.sym} 63280 -19580 0 0 {name=p62849 lab=_81522_/Q }
C {devices/lab_pin.sym} 63280 -19540 0 0 {name=p62850 lab=_76040_/B }
C {devices/lab_pin.sym} 63400 -19560 0 1 {name=p62851 lab=_81771_/D }
C {sky130_stdcells/xor2_4.sym} 63340 -19560 0 0 {name=X_76040_ }
C {devices/lab_pin.sym} 63250 -19430 0 0 {name=p62852 lab=_87776_/CLK }
C {devices/lab_pin.sym} 63250 -19410 0 0 {name=p62853 lab=_42119_/Y }
C {devices/lab_pin.sym} 63430 -19430 0 1 {name=p62854 lab=_88026_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -19420 0 0 {name=X_88026_ }
C {devices/lab_pin.sym} 63300 -19290 0 0 {name=p62855 lab=_42432_/A }
C {devices/lab_pin.sym} 63380 -19290 0 1 {name=p62856 lab=_42432_/Y }
C {sky130_stdcells/inv_2.sym} 63340 -19290 0 0 {name=X_42432_ }
C {devices/lab_pin.sym} 63260 -19190 0 0 {name=p62857 lab=_54416_/Y }
C {devices/lab_pin.sym} 63260 -19150 0 0 {name=p62858 lab=_54394_/X }
C {devices/lab_pin.sym} 63260 -19110 0 0 {name=p62859 lab=_54417_/X }
C {devices/lab_pin.sym} 63420 -19150 0 1 {name=p62860 lab=_85446_/D }
C {sky130_stdcells/a21oi_4.sym} 63340 -19150 0 0 {name=X_54418_ }
C {devices/lab_pin.sym} 63280 -19020 0 0 {name=p62861 lab=_73252_/A }
C {devices/lab_pin.sym} 63280 -18980 0 0 {name=p62862 lab=_73228_/B }
C {devices/lab_pin.sym} 63400 -19000 0 1 {name=p62863 lab=_73252_/Y }
C {sky130_stdcells/nor2_4.sym} 63340 -19000 0 0 {name=X_73252_ }
C {devices/lab_pin.sym} 63250 -18870 0 0 {name=p62864 lab=_85269_/CLK }
C {devices/lab_pin.sym} 63250 -18850 0 0 {name=p62865 lab=_85238_/D }
C {devices/lab_pin.sym} 63430 -18870 0 1 {name=p62866 lab=_56317_/C }
C {sky130_stdcells/dfxtp_4.sym} 63340 -18860 0 0 {name=X_85238_ }
C {devices/lab_pin.sym} 63280 -18750 0 0 {name=p62867 lab=_71323_/A }
C {devices/lab_pin.sym} 63280 -18710 0 0 {name=p62868 lab=_71500_/C }
C {devices/lab_pin.sym} 63280 -18670 0 0 {name=p62869 lab=_71672_/C }
C {devices/lab_pin.sym} 63400 -18710 0 1 {name=p62870 lab=_70464_/Y }
C {sky130_stdcells/nand3_4.sym} 63340 -18710 0 0 {name=X_70464_ }
C {devices/lab_pin.sym} 63300 -18570 0 0 {name=p62871 lab=_83376_/Q }
C {devices/lab_pin.sym} 63380 -18570 0 1 {name=p62872 lab=_58186_/Y }
C {sky130_stdcells/inv_2.sym} 63340 -18570 0 0 {name=X_58186_ }
C {devices/lab_pin.sym} 63300 -18450 0 0 {name=p62873 lab=_55298_/A }
C {devices/lab_pin.sym} 63380 -18450 0 1 {name=p62874 lab=_55398_/Y }
C {sky130_stdcells/inv_2.sym} 63340 -18450 0 0 {name=X_55398_ }
C {devices/lab_pin.sym} 63260 -18360 0 0 {name=p62875 lab=_83275_/Q }
C {devices/lab_pin.sym} 63260 -18320 0 0 {name=p62876 lab=_72115_/X }
C {devices/lab_pin.sym} 63260 -18280 0 0 {name=p62877 lab=_72195_/X }
C {devices/lab_pin.sym} 63260 -18240 0 0 {name=p62878 lab=_72202_/X }
C {devices/lab_pin.sym} 63420 -18300 0 1 {name=p62879 lab=_83275_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 63340 -18300 0 0 {name=X_72203_ }
C {devices/lab_pin.sym} 63260 -18170 0 0 {name=p62880 lab=_85201_/Q }
C {devices/lab_pin.sym} 63260 -18130 0 0 {name=p62881 lab=_45102_/X }
C {devices/lab_pin.sym} 63260 -18090 0 0 {name=p62882 lab=_45150_/X }
C {devices/lab_pin.sym} 63420 -18130 0 1 {name=p62883 lab=_45151_/Y }
C {sky130_stdcells/o21ai_4.sym} 63340 -18130 0 0 {name=X_45151_ }
C {devices/lab_pin.sym} 63280 -18000 0 0 {name=p62884 lab=_57137_/A }
C {devices/lab_pin.sym} 63280 -17960 0 0 {name=p62885 lab=_45888_/A }
C {devices/lab_pin.sym} 63400 -17980 0 1 {name=p62886 lab=_57137_/X }
C {sky130_stdcells/or2_4.sym} 63340 -17980 0 0 {name=X_57137_ }
C {devices/lab_pin.sym} 63300 -17850 0 0 {name=p62887 lab=_54320_/A }
C {devices/lab_pin.sym} 63380 -17850 0 1 {name=p62888 lab=_54349_/X }
C {sky130_stdcells/buf_2.sym} 63340 -17850 0 0 {name=X_54349_ }
C {devices/lab_pin.sym} 63260 -17760 0 0 {name=p62889 lab=_41749_/X }
C {devices/lab_pin.sym} 63260 -17720 0 0 {name=p62890 lab=_42356_/X }
C {devices/lab_pin.sym} 63260 -17680 0 0 {name=p62891 lab=_87900_/Q }
C {devices/lab_pin.sym} 63260 -17640 0 0 {name=p62892 lab=_42357_/X }
C {devices/lab_pin.sym} 63420 -17700 0 1 {name=p62893 lab=_87900_/D }
C {sky130_stdcells/a2bb2o_4.sym} 63340 -17700 0 0 {name=X_42363_ }
C {devices/lab_pin.sym} 63280 -17560 0 0 {name=p62894 lab=_73183_/A }
C {devices/lab_pin.sym} 63280 -17520 0 0 {name=p62895 lab=_86481_/Q }
C {devices/lab_pin.sym} 63400 -17540 0 1 {name=p62896 lab=_73183_/X }
C {sky130_stdcells/and2_4.sym} 63340 -17540 0 0 {name=X_73183_ }
C {devices/lab_pin.sym} 63250 -17410 0 0 {name=p62897 lab=_85168_/CLK }
C {devices/lab_pin.sym} 63250 -17390 0 0 {name=p62898 lab=_85169_/D }
C {devices/lab_pin.sym} 63430 -17410 0 1 {name=p62899 lab=_55833_/B }
C {sky130_stdcells/dfxtp_4.sym} 63340 -17400 0 0 {name=X_85169_ }
C {devices/lab_pin.sym} 63300 -17270 0 0 {name=p62900 lab=_70786_/A }
C {devices/lab_pin.sym} 63380 -17270 0 1 {name=p62901 lab=_74529_/A }
C {sky130_stdcells/buf_2.sym} 63340 -17270 0 0 {name=X_70395_ }
C {devices/lab_pin.sym} 63300 -17150 0 0 {name=p62902 lab=clkbuf_9_210_0_CLK/A }
C {devices/lab_pin.sym} 63380 -17150 0 1 {name=p62903 lab=clkbuf_9_210_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 63340 -17150 0 0 {name=Xclkbuf_9_210_0_CLK }
C {devices/lab_pin.sym} 63300 -17030 0 0 {name=p62904 lab=_44102_/A }
C {devices/lab_pin.sym} 63380 -17030 0 1 {name=p62905 lab=_44102_/X }
C {sky130_stdcells/buf_2.sym} 63340 -17030 0 0 {name=X_44102_ }
C {devices/lab_pin.sym} 63280 -16920 0 0 {name=p62906 lab=_41314_/A }
C {devices/lab_pin.sym} 63280 -16880 0 0 {name=p62907 lab=_41275_/B }
C {devices/lab_pin.sym} 63400 -16900 0 1 {name=p62908 lab=_41314_/X }
C {sky130_stdcells/or2_4.sym} 63340 -16900 0 0 {name=X_41314_ }
C {devices/lab_pin.sym} 63260 -16790 0 0 {name=p62909 lab=_59381_/X }
C {devices/lab_pin.sym} 63260 -16750 0 0 {name=p62910 lab=_85984_/Q }
C {devices/lab_pin.sym} 63260 -16710 0 0 {name=p62911 lab=_72133_/X }
C {devices/lab_pin.sym} 63420 -16750 0 1 {name=p62912 lab=_72134_/Y }
C {sky130_stdcells/o21ai_4.sym} 63340 -16750 0 0 {name=X_72134_ }
C {devices/lab_pin.sym} 63280 -16620 0 0 {name=p62913 lab=_45082_/A }
C {devices/lab_pin.sym} 63280 -16580 0 0 {name=p62914 lab=_45067_/B }
C {devices/lab_pin.sym} 63400 -16600 0 1 {name=p62915 lab=_45082_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -16600 0 0 {name=X_45082_ }
C {devices/lab_pin.sym} 63260 -16490 0 0 {name=p62916 lab=_56649_/X }
C {devices/lab_pin.sym} 63260 -16450 0 0 {name=p62917 lab=_57067_/Y }
C {devices/lab_pin.sym} 63260 -16410 0 0 {name=p62918 lab=_56892_/B }
C {devices/lab_pin.sym} 63420 -16450 0 1 {name=p62919 lab=_57068_/X }
C {sky130_stdcells/a21o_4.sym} 63340 -16450 0 0 {name=X_57068_ }
C {devices/lab_pin.sym} 63300 -16310 0 0 {name=p62920 lab=clkbuf_7_54_0_CLK/X }
C {devices/lab_pin.sym} 63380 -16310 0 1 {name=p62921 lab=clkbuf_9_219_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 63340 -16310 0 0 {name=Xclkbuf_8_109_0_CLK }
C {devices/lab_pin.sym} 63260 -16230 0 0 {name=p62922 lab=_42279_/X }
C {devices/lab_pin.sym} 63260 -16190 0 0 {name=p62923 lab=_42275_/X }
C {devices/lab_pin.sym} 63260 -16150 0 0 {name=p62924 lab=_41565_/X }
C {devices/lab_pin.sym} 63260 -16110 0 0 {name=p62925 lab=_87935_/Q }
C {devices/lab_pin.sym} 63260 -16070 0 0 {name=p62926 lab=_42276_/X }
C {devices/lab_pin.sym} 63420 -16150 0 1 {name=p62927 lab=_42294_/Y }
C {sky130_stdcells/o32ai_4.sym} 63340 -16150 0 0 {name=X_42294_ }
C {devices/lab_pin.sym} 63260 -16030 0 0 {name=p62928 lab=_77977_/Y }
C {devices/lab_pin.sym} 63260 -15990 0 0 {name=p62929 lab=_77975_/Y }
C {devices/lab_pin.sym} 63260 -15950 0 0 {name=p62930 lab=_77967_/C }
C {devices/lab_pin.sym} 63260 -15910 0 0 {name=p62931 lab=_77967_/B }
C {devices/lab_pin.sym} 63260 -15870 0 0 {name=p62932 lab=_77990_/Y }
C {devices/lab_pin.sym} 63420 -15950 0 1 {name=p62933 lab=_77991_/X }
C {sky130_stdcells/o41a_4.sym} 63340 -15950 0 0 {name=X_77991_ }
C {devices/lab_pin.sym} 63300 -15790 0 0 {name=p62934 lab=clkbuf_9_52_0_CLK/X }
C {devices/lab_pin.sym} 63380 -15790 0 1 {name=p62935 lab=_85071_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 63340 -15790 0 0 {name=Xclkbuf_10_104_0_CLK }
C {devices/lab_pin.sym} 63300 -15670 0 0 {name=p62936 lab=_83622_/Q }
C {devices/lab_pin.sym} 63380 -15670 0 1 {name=p62937 lab=_71972_/B }
C {sky130_stdcells/inv_2.sym} 63340 -15670 0 0 {name=X_48910_ }
C {devices/lab_pin.sym} 63300 -15550 0 0 {name=p62938 lab=_44012_/A }
C {devices/lab_pin.sym} 63380 -15550 0 1 {name=p62939 lab=_64850_/A }
C {sky130_stdcells/buf_2.sym} 63340 -15550 0 0 {name=X_44033_ }
C {devices/lab_pin.sym} 63280 -15440 0 0 {name=p62940 lab=_55966_/X }
C {devices/lab_pin.sym} 63280 -15400 0 0 {name=p62941 lab=_56019_/B }
C {devices/lab_pin.sym} 63400 -15420 0 1 {name=p62942 lab=_56019_/Y }
C {sky130_stdcells/xnor2_4.sym} 63340 -15420 0 0 {name=X_56019_ }
C {devices/lab_pin.sym} 63280 -15300 0 0 {name=p62943 lab=_84218_/Q }
C {devices/lab_pin.sym} 63280 -15260 0 0 {name=p62944 lab=_83266_/Q }
C {devices/lab_pin.sym} 63400 -15280 0 1 {name=p62945 lab=_79730_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -15280 0 0 {name=X_79730_ }
C {devices/lab_pin.sym} 63300 -15150 0 0 {name=p62946 lab=_41244_/X }
C {devices/lab_pin.sym} 63380 -15150 0 1 {name=p62947 lab=_41245_/X }
C {sky130_stdcells/buf_2.sym} 63340 -15150 0 0 {name=X_41245_ }
C {devices/lab_pin.sym} 63260 -15050 0 0 {name=p62948 lab=_72063_/Y }
C {devices/lab_pin.sym} 63260 -15010 0 0 {name=p62949 lab=_72059_/X }
C {devices/lab_pin.sym} 63260 -14970 0 0 {name=p62950 lab=_72064_/X }
C {devices/lab_pin.sym} 63420 -15010 0 1 {name=p62951 lab=_72065_/Y }
C {sky130_stdcells/a21oi_4.sym} 63340 -15010 0 0 {name=X_72065_ }
C {devices/lab_pin.sym} 63280 -14890 0 0 {name=p62952 lab=_76939_/X }
C {devices/lab_pin.sym} 63280 -14850 0 0 {name=p62953 lab=_76942_/B }
C {devices/lab_pin.sym} 63280 -14810 0 0 {name=p62954 lab=_76953_/A }
C {devices/lab_pin.sym} 63400 -14850 0 1 {name=p62955 lab=_76942_/Y }
C {sky130_stdcells/nand3_4.sym} 63340 -14850 0 0 {name=X_76942_ }
C {devices/lab_pin.sym} 63300 -14710 0 0 {name=p62956 lab=clkbuf_9_367_0_CLK/X }
C {devices/lab_pin.sym} 63380 -14710 0 1 {name=p62957 lab=_87790_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 63340 -14710 0 0 {name=Xclkbuf_10_734_0_CLK }
C {devices/lab_pin.sym} 63260 -14610 0 0 {name=p62958 lab=_49887_/Y }
C {devices/lab_pin.sym} 63260 -14570 0 0 {name=p62959 lab=_49870_/X }
C {devices/lab_pin.sym} 63260 -14530 0 0 {name=p62960 lab=_49889_/X }
C {devices/lab_pin.sym} 63420 -14570 0 1 {name=p62961 lab=_49890_/Y }
C {sky130_stdcells/a21oi_4.sym} 63340 -14570 0 0 {name=X_49890_ }
C {devices/lab_pin.sym} 63300 -14430 0 0 {name=p62962 lab=_71016_/A }
C {devices/lab_pin.sym} 63380 -14430 0 1 {name=p62963 lab=_71039_/D }
C {sky130_stdcells/buf_2.sym} 63340 -14430 0 0 {name=X_71016_ }
C {devices/lab_pin.sym} 63280 -14330 0 0 {name=p62964 lab=_48841_/A }
C {devices/lab_pin.sym} 63280 -14290 0 0 {name=p62965 lab=_48849_/B }
C {devices/lab_pin.sym} 63280 -14250 0 0 {name=p62966 lab=_48849_/C }
C {devices/lab_pin.sym} 63400 -14290 0 1 {name=p62967 lab=_48841_/X }
C {sky130_stdcells/and3_4.sym} 63340 -14290 0 0 {name=X_48841_ }
C {devices/lab_pin.sym} 63300 -14150 0 0 {name=p62968 lab=_79660_/X }
C {devices/lab_pin.sym} 63380 -14150 0 1 {name=p62969 lab=_79667_/A }
C {sky130_stdcells/inv_2.sym} 63340 -14150 0 0 {name=X_79661_ }
C {devices/lab_pin.sym} 63300 -14030 0 0 {name=p62970 lab=_41176_/A }
C {devices/lab_pin.sym} 63380 -14030 0 1 {name=p62971 lab=_41176_/Y }
C {sky130_stdcells/inv_2.sym} 63340 -14030 0 0 {name=X_41176_ }
C {devices/lab_pin.sym} 63300 -13910 0 0 {name=p62972 lab=clkbuf_8_112_0_CLK/X }
C {devices/lab_pin.sym} 63380 -13910 0 1 {name=p62973 lab=clkbuf_9_225_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 63340 -13910 0 0 {name=Xclkbuf_9_225_0_CLK }
C {devices/lab_pin.sym} 63300 -13790 0 0 {name=p62974 lab=_76873_/A }
C {devices/lab_pin.sym} 63380 -13790 0 1 {name=p62975 lab=_76873_/Y }
C {sky130_stdcells/inv_2.sym} 63340 -13790 0 0 {name=X_76873_ }
C {devices/lab_pin.sym} 63280 -13680 0 0 {name=p62976 lab=_78611_/A }
C {devices/lab_pin.sym} 63280 -13640 0 0 {name=p62977 lab=_82679_/D }
C {devices/lab_pin.sym} 63400 -13660 0 1 {name=p62978 lab=_78613_/A }
C {sky130_stdcells/nand2_4.sym} 63340 -13660 0 0 {name=X_78612_ }
C {devices/lab_pin.sym} 63280 -13540 0 0 {name=p62979 lab=_75824_/A }
C {devices/lab_pin.sym} 63280 -13500 0 0 {name=p62980 lab=_75824_/B }
C {devices/lab_pin.sym} 63400 -13520 0 1 {name=p62981 lab=_75824_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -13520 0 0 {name=X_75824_ }
C {devices/lab_pin.sym} 63260 -13410 0 0 {name=p62982 lab=_48769_/Y }
C {devices/lab_pin.sym} 63260 -13370 0 0 {name=p62983 lab=_48760_/X }
C {devices/lab_pin.sym} 63260 -13330 0 0 {name=p62984 lab=_48771_/X }
C {devices/lab_pin.sym} 63420 -13370 0 1 {name=p62985 lab=_86486_/D }
C {sky130_stdcells/a21oi_4.sym} 63340 -13370 0 0 {name=X_48772_ }
C {devices/lab_pin.sym} 63300 -13230 0 0 {name=p62986 lab=clkbuf_9_59_0_CLK/X }
C {devices/lab_pin.sym} 63380 -13230 0 1 {name=p62987 lab=_84555_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 63340 -13230 0 0 {name=Xclkbuf_10_119_0_CLK }
C {devices/lab_pin.sym} 63280 -13120 0 0 {name=p62988 lab=_79592_/A }
C {devices/lab_pin.sym} 63280 -13080 0 0 {name=p62989 lab=_79591_/Y }
C {devices/lab_pin.sym} 63400 -13100 0 1 {name=p62990 lab=_79592_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -13100 0 0 {name=X_79592_ }
C {devices/lab_pin.sym} 63300 -12970 0 0 {name=p62991 lab=_45984_/A }
C {devices/lab_pin.sym} 63380 -12970 0 1 {name=p62992 lab=_45984_/Y }
C {sky130_stdcells/inv_2.sym} 63340 -12970 0 0 {name=X_45984_ }
C {devices/lab_pin.sym} 63300 -12850 0 0 {name=p62993 lab=clkbuf_9_374_0_CLK/X }
C {devices/lab_pin.sym} 63380 -12850 0 1 {name=p62994 lab=_87249_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 63340 -12850 0 0 {name=Xclkbuf_10_749_0_CLK }
C {devices/lab_pin.sym} 63280 -12760 0 0 {name=p62995 lab=_47758_/A }
C {devices/lab_pin.sym} 63280 -12720 0 0 {name=p62996 lab=_47739_/B }
C {devices/lab_pin.sym} 63280 -12680 0 0 {name=p62997 lab=_47749_/C }
C {devices/lab_pin.sym} 63280 -12640 0 0 {name=p62998 lab=_53207_/D }
C {devices/lab_pin.sym} 63400 -12700 0 1 {name=p62999 lab=_47723_/X }
C {sky130_stdcells/and4_4.sym} 63340 -12700 0 0 {name=X_47723_ }
C {devices/lab_pin.sym} 63300 -12550 0 0 {name=p63000 lab=_57754_/X }
C {devices/lab_pin.sym} 63380 -12550 0 1 {name=p63001 lab=_63055_/A }
C {sky130_stdcells/buf_2.sym} 63340 -12550 0 0 {name=X_59709_ }
C {devices/lab_pin.sym} 63260 -12450 0 0 {name=p63002 lab=_78539_/Y }
C {devices/lab_pin.sym} 63260 -12410 0 0 {name=p63003 lab=_78519_/B }
C {devices/lab_pin.sym} 63260 -12370 0 0 {name=p63004 lab=_78542_/X }
C {devices/lab_pin.sym} 63420 -12410 0 1 {name=p63005 lab=_78561_/A }
C {sky130_stdcells/o21ai_4.sym} 63340 -12410 0 0 {name=X_78543_ }
C {devices/lab_pin.sym} 63300 -12270 0 0 {name=p63006 lab=_45705_/A }
C {devices/lab_pin.sym} 63380 -12270 0 1 {name=p63007 lab=_44935_/X }
C {sky130_stdcells/buf_2.sym} 63340 -12270 0 0 {name=X_44935_ }
C {devices/lab_pin.sym} 63300 -12150 0 0 {name=p63008 lab=_75733_/Y }
C {devices/lab_pin.sym} 63380 -12150 0 1 {name=p63009 lab=_80788_/D }
C {sky130_stdcells/inv_2.sym} 63340 -12150 0 0 {name=X_75755_ }
C {devices/lab_pin.sym} 63280 -12040 0 0 {name=p63010 lab=_60926_/X }
C {devices/lab_pin.sym} 63280 -12000 0 0 {name=p63011 lab=_60930_/A }
C {devices/lab_pin.sym} 63400 -12020 0 1 {name=p63012 lab=_60982_/A }
C {sky130_stdcells/nor2_4.sym} 63340 -12020 0 0 {name=X_60981_ }
C {devices/lab_pin.sym} 63280 -11900 0 0 {name=p63013 lab=_53651_/B }
C {devices/lab_pin.sym} 63280 -11860 0 0 {name=p63014 lab=_72967_/B }
C {devices/lab_pin.sym} 63400 -11880 0 1 {name=p63015 lab=_72967_/X }
C {sky130_stdcells/xor2_4.sym} 63340 -11880 0 0 {name=X_72967_ }
C {devices/lab_pin.sym} 63300 -11750 0 0 {name=p63016 lab=_61348_/A }
C {devices/lab_pin.sym} 63380 -11750 0 1 {name=p63017 lab=_62893_/A }
C {sky130_stdcells/buf_2.sym} 63340 -11750 0 0 {name=X_62720_ }
C {devices/lab_pin.sym} 63260 -11650 0 0 {name=p63018 lab=_74630_/X }
C {devices/lab_pin.sym} 63260 -11610 0 0 {name=p63019 lab=_57083_/X }
C {devices/lab_pin.sym} 63260 -11570 0 0 {name=p63020 lab=_74705_/Y }
C {devices/lab_pin.sym} 63420 -11610 0 1 {name=p63021 lab=_74706_/X }
C {sky130_stdcells/o21a_4.sym} 63340 -11610 0 0 {name=X_74706_ }
C {devices/lab_pin.sym} 63300 -11470 0 0 {name=p63022 lab=_55031_/D }
C {devices/lab_pin.sym} 63380 -11470 0 1 {name=p63023 lab=_53170_/D }
C {sky130_stdcells/buf_2.sym} 63340 -11470 0 0 {name=X_47654_ }
C {devices/lab_pin.sym} 63280 -11380 0 0 {name=p63024 lab=_70368_/X }
C {devices/lab_pin.sym} 63280 -11340 0 0 {name=p63025 lab=_70979_/C }
C {devices/lab_pin.sym} 63280 -11300 0 0 {name=p63026 lab=_71902_/X }
C {devices/lab_pin.sym} 63280 -11260 0 0 {name=p63027 lab=_71928_/D }
C {devices/lab_pin.sym} 63400 -11320 0 1 {name=p63028 lab=_71918_/Y }
C {sky130_stdcells/nand4_4.sym} 63340 -11320 0 0 {name=X_71918_ }
C {devices/lab_pin.sym} 63280 -11180 0 0 {name=p63029 lab=_78474_/A }
C {devices/lab_pin.sym} 63280 -11140 0 0 {name=p63030 lab=_78473_/X }
C {devices/lab_pin.sym} 63400 -11160 0 1 {name=p63031 lab=_78482_/A }
C {sky130_stdcells/xnor2_4.sym} 63340 -11160 0 0 {name=X_78474_ }
C {devices/lab_pin.sym} 63260 -11070 0 0 {name=p63032 lab=_44857_/X }
C {devices/lab_pin.sym} 63260 -11030 0 0 {name=p63033 lab=_44865_/X }
C {devices/lab_pin.sym} 63260 -10990 0 0 {name=p63034 lab=_41790_/X }
C {devices/lab_pin.sym} 63260 -10950 0 0 {name=p63035 lab=_86912_/Q }
C {devices/lab_pin.sym} 63260 -10910 0 0 {name=p63036 lab=_44858_/X }
C {devices/lab_pin.sym} 63420 -10990 0 1 {name=p63037 lab=_44867_/A }
C {sky130_stdcells/o32ai_4.sym} 63340 -10990 0 0 {name=X_44866_ }
C {devices/lab_pin.sym} 63280 -10840 0 0 {name=p63038 lab=_81006_/Q }
C {devices/lab_pin.sym} 63280 -10800 0 0 {name=p63039 lab=_75686_/B }
C {devices/lab_pin.sym} 63400 -10820 0 1 {name=p63040 lab=_75686_/X }
C {sky130_stdcells/xor2_4.sym} 63340 -10820 0 0 {name=X_75686_ }
C {devices/lab_pin.sym} 63260 -10710 0 0 {name=p63041 lab=_72893_/X }
C {devices/lab_pin.sym} 63260 -10670 0 0 {name=p63042 lab=_72897_/X }
C {devices/lab_pin.sym} 63260 -10630 0 0 {name=p63043 lab=_72862_/X }
C {devices/lab_pin.sym} 63420 -10670 0 1 {name=p63044 lab=_72898_/X }
C {sky130_stdcells/a21o_4.sym} 63340 -10670 0 0 {name=X_72898_ }
C {devices/lab_pin.sym} 63260 -10550 0 0 {name=p63045 lab=_46597_/Y }
C {devices/lab_pin.sym} 63260 -10510 0 0 {name=p63046 lab=_46598_/X }
C {devices/lab_pin.sym} 63260 -10470 0 0 {name=p63047 lab=_46604_/X }
C {devices/lab_pin.sym} 63420 -10510 0 1 {name=p63048 lab=_86722_/D }
C {sky130_stdcells/a21oi_4.sym} 63340 -10510 0 0 {name=X_46605_ }
C {devices/lab_pin.sym} 63300 -10370 0 0 {name=p63049 lab=_77424_/Y }
C {devices/lab_pin.sym} 63380 -10370 0 1 {name=p63050 lab=_77426_/C }
C {sky130_stdcells/inv_2.sym} 63340 -10370 0 0 {name=X_77425_ }
C {devices/lab_pin.sym} 63300 -10250 0 0 {name=p63051 lab=_43752_/A }
C {devices/lab_pin.sym} 63380 -10250 0 1 {name=p63052 lab=_43817_/X }
C {sky130_stdcells/buf_2.sym} 63340 -10250 0 0 {name=X_43817_ }
C {devices/lab_pin.sym} 63260 -10170 0 0 {name=p63053 lab=_62638_/Y }
C {devices/lab_pin.sym} 63260 -10130 0 0 {name=p63054 lab=_62642_/Y }
C {devices/lab_pin.sym} 63260 -10090 0 0 {name=p63055 lab=_62648_/X }
C {devices/lab_pin.sym} 63260 -10050 0 0 {name=p63056 lab=_58147_/A }
C {devices/lab_pin.sym} 63260 -10010 0 0 {name=p63057 lab=_62650_/X }
C {devices/lab_pin.sym} 63420 -10090 0 1 {name=p63058 lab=_62651_/Y }
C {sky130_stdcells/o32ai_4.sym} 63340 -10090 0 0 {name=X_62651_ }
C {devices/lab_pin.sym} 63260 -9960 0 0 {name=p63059 lab=_45952_/X }
C {devices/lab_pin.sym} 63260 -9920 0 0 {name=p63060 lab=_56583_/X }
C {devices/lab_pin.sym} 63260 -9880 0 0 {name=p63061 lab=_83005_/Q }
C {devices/lab_pin.sym} 63260 -9840 0 0 {name=p63062 lab=_74633_/X }
C {devices/lab_pin.sym} 63420 -9900 0 1 {name=p63063 lab=_83005_/D }
C {sky130_stdcells/a2bb2o_4.sym} 63340 -9900 0 0 {name=X_74637_ }
C {devices/lab_pin.sym} 63300 -9750 0 0 {name=p63064 lab=_47585_/A }
C {devices/lab_pin.sym} 63380 -9750 0 1 {name=p63065 lab=_47586_/A }
C {sky130_stdcells/inv_2.sym} 63340 -9750 0 0 {name=X_47585_ }
C {devices/lab_pin.sym} 63300 -9630 0 0 {name=p63066 lab=_71846_/A }
C {devices/lab_pin.sym} 63380 -9630 0 1 {name=p63067 lab=_71867_/B }
C {sky130_stdcells/buf_2.sym} 63340 -9630 0 0 {name=X_71849_ }
C {devices/lab_pin.sym} 63300 -9510 0 0 {name=p63068 lab=_44797_/A }
C {devices/lab_pin.sym} 63380 -9510 0 1 {name=p63069 lab=_44797_/Y }
C {sky130_stdcells/inv_2.sym} 63340 -9510 0 0 {name=X_44797_ }
C {devices/lab_pin.sym} 63280 -9400 0 0 {name=p63070 lab=_49287_/A }
C {devices/lab_pin.sym} 63280 -9360 0 0 {name=p63071 lab=_51358_/B }
C {devices/lab_pin.sym} 63400 -9380 0 1 {name=p63072 lab=_49324_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -9380 0 0 {name=X_49324_ }
C {devices/lab_pin.sym} 63260 -9290 0 0 {name=p63073 lab=_61590_/Y }
C {devices/lab_pin.sym} 63260 -9250 0 0 {name=p63074 lab=_61593_/Y }
C {devices/lab_pin.sym} 63260 -9210 0 0 {name=p63075 lab=_61594_/X }
C {devices/lab_pin.sym} 63260 -9170 0 0 {name=p63076 lab=_61597_/Y }
C {devices/lab_pin.sym} 63260 -9140 0 0 {name=p63077 lab=_61601_/Y }
C {devices/lab_pin.sym} 63420 -9210 0 1 {name=p63078 lab=_61602_/X }
C {sky130_stdcells/a41o_4.sym} 63340 -9210 0 0 {name=X_61602_ }
C {devices/lab_pin.sym} 63260 -9070 0 0 {name=p63079 lab=_86728_/Q }
C {devices/lab_pin.sym} 63260 -9030 0 0 {name=p63080 lab=_46430_/X }
C {devices/lab_pin.sym} 63260 -8990 0 0 {name=p63081 lab=_46535_/Y }
C {devices/lab_pin.sym} 63420 -9030 0 1 {name=p63082 lab=_46536_/Y }
C {sky130_stdcells/o21ai_4.sym} 63340 -9030 0 0 {name=X_46536_ }
C {devices/lab_pin.sym} 63260 -8910 0 0 {name=p63083 lab=_65198_/X }
C {devices/lab_pin.sym} 63260 -8870 0 0 {name=p63084 lab=_65359_/Y }
C {devices/lab_pin.sym} 63260 -8830 0 0 {name=p63085 lab=_65369_/Y }
C {devices/lab_pin.sym} 63420 -8870 0 1 {name=p63086 lab=_65370_/Y }
C {sky130_stdcells/o21ai_4.sym} 63340 -8870 0 0 {name=X_65370_ }
C {devices/lab_pin.sym} 63280 -8740 0 0 {name=p63087 lab=_77338_/A }
C {devices/lab_pin.sym} 63280 -8700 0 0 {name=p63088 lab=_77338_/B }
C {devices/lab_pin.sym} 63400 -8720 0 1 {name=p63089 lab=_77356_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -8720 0 0 {name=X_77356_ }
C {devices/lab_pin.sym} 63260 -8630 0 0 {name=p63090 lab=_62576_/X }
C {devices/lab_pin.sym} 63260 -8590 0 0 {name=p63091 lab=_62578_/X }
C {devices/lab_pin.sym} 63260 -8550 0 0 {name=p63092 lab=_62581_/Y }
C {devices/lab_pin.sym} 63260 -8510 0 0 {name=p63093 lab=_58352_/A }
C {devices/lab_pin.sym} 63260 -8470 0 0 {name=p63094 lab=_62572_/X }
C {devices/lab_pin.sym} 63420 -8550 0 1 {name=p63095 lab=_62582_/Y }
C {sky130_stdcells/o32ai_4.sym} 63340 -8550 0 0 {name=X_62582_ }
C {devices/lab_pin.sym} 63260 -8420 0 0 {name=p63096 lab=_40925_/X }
C {devices/lab_pin.sym} 63260 -8380 0 0 {name=p63097 lab=_43736_/X }
C {devices/lab_pin.sym} 63260 -8340 0 0 {name=p63098 lab=_73509_/A }
C {devices/lab_pin.sym} 63260 -8300 0 0 {name=p63099 lab=_43737_/X }
C {devices/lab_pin.sym} 63420 -8360 0 1 {name=p63100 lab=_43748_/X }
C {sky130_stdcells/a2bb2o_4.sym} 63340 -8360 0 0 {name=X_43748_ }
C {devices/lab_pin.sym} 63300 -8210 0 0 {name=p63101 lab=_74549_/Y }
C {devices/lab_pin.sym} 63380 -8210 0 1 {name=p63102 lab=_74568_/X }
C {sky130_stdcells/buf_2.sym} 63340 -8210 0 0 {name=X_74568_ }
C {devices/lab_pin.sym} 63280 -8110 0 0 {name=p63103 lab=_64295_/A }
C {devices/lab_pin.sym} 63280 -8070 0 0 {name=p63104 lab=_64307_/B }
C {devices/lab_pin.sym} 63280 -8030 0 0 {name=p63105 lab=_84832_/Q }
C {devices/lab_pin.sym} 63400 -8070 0 1 {name=p63106 lab=_64321_/X }
C {sky130_stdcells/and3_4.sym} 63340 -8070 0 0 {name=X_64321_ }
C {devices/lab_pin.sym} 63300 -7930 0 0 {name=p63107 lab=_76306_/X }
C {devices/lab_pin.sym} 63380 -7930 0 1 {name=p63108 lab=_76321_/A }
C {sky130_stdcells/buf_2.sym} 63340 -7930 0 0 {name=X_76307_ }
C {devices/lab_pin.sym} 63300 -7810 0 0 {name=p63109 lab=_48548_/A }
C {devices/lab_pin.sym} 63380 -7810 0 1 {name=p63110 lab=_49255_/X }
C {sky130_stdcells/buf_2.sym} 63340 -7810 0 0 {name=X_49255_ }
C {devices/lab_pin.sym} 63280 -7700 0 0 {name=p63111 lab=_73476_/A }
C {devices/lab_pin.sym} 63280 -7660 0 0 {name=p63112 lab=_86499_/Q }
C {devices/lab_pin.sym} 63400 -7680 0 1 {name=p63113 lab=_73519_/X }
C {sky130_stdcells/and2_4.sym} 63340 -7680 0 0 {name=X_73519_ }
C {devices/lab_pin.sym} 63260 -7590 0 0 {name=p63114 lab=_61521_/Y }
C {devices/lab_pin.sym} 63260 -7550 0 0 {name=p63115 lab=_61524_/Y }
C {devices/lab_pin.sym} 63260 -7510 0 0 {name=p63116 lab=_61525_/X }
C {devices/lab_pin.sym} 63260 -7470 0 0 {name=p63117 lab=_61528_/Y }
C {devices/lab_pin.sym} 63260 -7440 0 0 {name=p63118 lab=_61532_/Y }
C {devices/lab_pin.sym} 63420 -7510 0 1 {name=p63119 lab=_61533_/X }
C {sky130_stdcells/a41o_4.sym} 63340 -7510 0 0 {name=X_61533_ }
C {devices/lab_pin.sym} 63260 -7370 0 0 {name=p63120 lab=_86734_/Q }
C {devices/lab_pin.sym} 63260 -7330 0 0 {name=p63121 lab=_46292_/X }
C {devices/lab_pin.sym} 63260 -7290 0 0 {name=p63122 lab=_46466_/Y }
C {devices/lab_pin.sym} 63420 -7330 0 1 {name=p63123 lab=_46467_/Y }
C {sky130_stdcells/o21ai_4.sym} 63340 -7330 0 0 {name=X_46467_ }
C {devices/lab_pin.sym} 63280 -7200 0 0 {name=p63124 lab=_77287_/A }
C {devices/lab_pin.sym} 63280 -7160 0 0 {name=p63125 lab=_77286_/Y }
C {devices/lab_pin.sym} 63400 -7180 0 1 {name=p63126 lab=_77318_/A }
C {sky130_stdcells/nor2_4.sym} 63340 -7180 0 0 {name=X_77287_ }
C {devices/lab_pin.sym} 63260 -7080 0 0 {name=p63127 lab=_40771_/X }
C {devices/lab_pin.sym} 63260 -7040 0 0 {name=p63128 lab=_43671_/X }
C {devices/lab_pin.sym} 63260 -7000 0 0 {name=p63129 lab=_87314_/Q }
C {devices/lab_pin.sym} 63260 -6960 0 0 {name=p63130 lab=_43673_/X }
C {devices/lab_pin.sym} 63420 -7020 0 1 {name=p63131 lab=_43679_/X }
C {sky130_stdcells/a2bb2o_4.sym} 63340 -7020 0 0 {name=X_43679_ }
C {devices/lab_pin.sym} 63280 -6880 0 0 {name=p63132 lab=_46272_/A }
C {devices/lab_pin.sym} 63280 -6840 0 0 {name=p63133 lab=_48672_/A }
C {devices/lab_pin.sym} 63400 -6860 0 1 {name=p63134 lab=_74499_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -6860 0 0 {name=X_74499_ }
C {devices/lab_pin.sym} 63260 -6750 0 0 {name=p63135 lab=_73689_/B }
C {devices/lab_pin.sym} 63260 -6710 0 0 {name=p63136 lab=_48203_/X }
C {devices/lab_pin.sym} 63260 -6670 0 0 {name=p63137 lab=_48205_/Y }
C {devices/lab_pin.sym} 63420 -6710 0 1 {name=p63138 lab=_48206_/Y }
C {sky130_stdcells/o21ai_4.sym} 63340 -6710 0 0 {name=X_48206_ }
C {devices/lab_pin.sym} 63300 -6570 0 0 {name=p63139 lab=_67039_/X }
C {devices/lab_pin.sym} 63380 -6570 0 1 {name=p63140 lab=_67040_/X }
C {sky130_stdcells/buf_2.sym} 63340 -6570 0 0 {name=X_67040_ }
C {devices/lab_pin.sym} 63260 -6470 0 0 {name=p63141 lab=_79022_/Y }
C {devices/lab_pin.sym} 63260 -6430 0 0 {name=p63142 lab=_79010_/B }
C {devices/lab_pin.sym} 63260 -6390 0 0 {name=p63143 lab=_79025_/Y }
C {devices/lab_pin.sym} 63420 -6430 0 1 {name=p63144 lab=_79027_/B }
C {sky130_stdcells/o21ai_4.sym} 63340 -6430 0 0 {name=X_79026_ }
C {devices/lab_pin.sym} 63260 -6310 0 0 {name=p63145 lab=_45416_/Y }
C {devices/lab_pin.sym} 63260 -6270 0 0 {name=p63146 lab=_45417_/Y }
C {devices/lab_pin.sym} 63260 -6230 0 0 {name=p63147 lab=_44901_/X }
C {devices/lab_pin.sym} 63420 -6270 0 1 {name=p63148 lab=_45418_/X }
C {sky130_stdcells/o21a_4.sym} 63340 -6270 0 0 {name=X_45418_ }
C {devices/lab_pin.sym} 63260 -6170 0 0 {name=p63149 lab=_64245_/X }
C {devices/lab_pin.sym} 63260 -6130 0 0 {name=p63150 lab=_64246_/X }
C {devices/lab_pin.sym} 63260 -6090 0 0 {name=p63151 lab=_64248_/X }
C {devices/lab_pin.sym} 63260 -6050 0 0 {name=p63152 lab=_64251_/Y }
C {devices/lab_pin.sym} 63260 -6010 0 0 {name=p63153 lab=_64229_/X }
C {devices/lab_pin.sym} 63420 -6090 0 1 {name=p63154 lab=_64252_/X }
C {sky130_stdcells/o41a_4.sym} 63340 -6090 0 0 {name=X_64252_ }
C {devices/lab_pin.sym} 63280 -5940 0 0 {name=p63155 lab=_76236_/X }
C {devices/lab_pin.sym} 63280 -5900 0 0 {name=p63156 lab=_76237_/Y }
C {devices/lab_pin.sym} 63400 -5920 0 1 {name=p63157 lab=_76238_/X }
C {sky130_stdcells/and2_4.sym} 63340 -5920 0 0 {name=X_76238_ }
C {devices/lab_pin.sym} 63280 -5800 0 0 {name=p63158 lab=_49156_/X }
C {devices/lab_pin.sym} 63280 -5760 0 0 {name=p63159 lab=_50716_/B }
C {devices/lab_pin.sym} 63400 -5780 0 1 {name=p63160 lab=_49186_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -5780 0 0 {name=X_49186_ }
C {devices/lab_pin.sym} 63300 -5650 0 0 {name=p63161 lab=_61334_/A }
C {devices/lab_pin.sym} 63380 -5650 0 1 {name=p63162 lab=_61464_/X }
C {sky130_stdcells/buf_2.sym} 63340 -5650 0 0 {name=X_61464_ }
C {devices/lab_pin.sym} 63300 -5530 0 0 {name=p63163 lab=_44803_/A }
C {devices/lab_pin.sym} 63380 -5530 0 1 {name=p63164 lab=_46399_/A }
C {sky130_stdcells/buf_2.sym} 63340 -5530 0 0 {name=X_46398_ }
C {devices/lab_pin.sym} 63300 -5410 0 0 {name=p63165 lab=_60503_/X }
C {devices/lab_pin.sym} 63380 -5410 0 1 {name=p63166 lab=_63203_/X }
C {sky130_stdcells/buf_2.sym} 63340 -5410 0 0 {name=X_63203_ }
C {devices/lab_pin.sym} 63260 -5310 0 0 {name=p63167 lab=_48134_/X }
C {devices/lab_pin.sym} 63260 -5270 0 0 {name=p63168 lab=_82916_/Q }
C {devices/lab_pin.sym} 63260 -5230 0 0 {name=p63169 lab=_48136_/X }
C {devices/lab_pin.sym} 63420 -5270 0 1 {name=p63170 lab=_48342_/A }
C {sky130_stdcells/o21ai_4.sym} 63340 -5270 0 0 {name=X_48137_ }
C {devices/lab_pin.sym} 63300 -5130 0 0 {name=p63171 lab=_60606_/A }
C {devices/lab_pin.sym} 63380 -5130 0 1 {name=p63172 lab=_60447_/B }
C {sky130_stdcells/inv_2.sym} 63340 -5130 0 0 {name=X_60415_ }
C {devices/lab_pin.sym} 63260 -5030 0 0 {name=p63173 lab=_45344_/X }
C {devices/lab_pin.sym} 63260 -4990 0 0 {name=p63174 lab=_45347_/Y }
C {devices/lab_pin.sym} 63260 -4950 0 0 {name=p63175 lab=_45348_/X }
C {devices/lab_pin.sym} 63420 -4990 0 1 {name=p63176 lab=_45349_/Y }
C {sky130_stdcells/a21oi_4.sym} 63340 -4990 0 0 {name=X_45349_ }
C {devices/lab_pin.sym} 63300 -4850 0 0 {name=p63177 lab=_76169_/A }
C {devices/lab_pin.sym} 63380 -4850 0 1 {name=p63178 lab=_81603_/D }
C {sky130_stdcells/buf_2.sym} 63340 -4850 0 0 {name=X_76169_ }
C {devices/lab_pin.sym} 63280 -4760 0 0 {name=p63179 lab=_61683_/X }
C {devices/lab_pin.sym} 63280 -4720 0 0 {name=p63180 lab=_64172_/B }
C {devices/lab_pin.sym} 63280 -4680 0 0 {name=p63181 lab=_64172_/C }
C {devices/lab_pin.sym} 63280 -4640 0 0 {name=p63182 lab=_64172_/D }
C {devices/lab_pin.sym} 63400 -4700 0 1 {name=p63183 lab=_64183_/Y }
C {sky130_stdcells/nand4_4.sym} 63340 -4700 0 0 {name=X_64183_ }
C {devices/lab_pin.sym} 63280 -4570 0 0 {name=p63184 lab=_61384_/A }
C {devices/lab_pin.sym} 63280 -4530 0 0 {name=p63185 lab=_61384_/B }
C {devices/lab_pin.sym} 63280 -4490 0 0 {name=p63186 lab=_79152_/B }
C {devices/lab_pin.sym} 63400 -4530 0 1 {name=p63187 lab=_61395_/Y }
C {sky130_stdcells/nor3_4.sym} 63340 -4530 0 0 {name=X_61395_ }
C {devices/lab_pin.sym} 63300 -4390 0 0 {name=p63188 lab=_60458_/X }
C {devices/lab_pin.sym} 63380 -4390 0 1 {name=p63189 lab=_63135_/D }
C {sky130_stdcells/buf_2.sym} 63340 -4390 0 0 {name=X_63134_ }
C {devices/lab_pin.sym} 63300 -4270 0 0 {name=p63190 lab=_48790_/A }
C {devices/lab_pin.sym} 63380 -4270 0 1 {name=p63191 lab=_48723_/C }
C {sky130_stdcells/buf_2.sym} 63340 -4270 0 0 {name=X_48068_ }
C {devices/lab_pin.sym} 63280 -4170 0 0 {name=p63192 lab=_60477_/A }
C {devices/lab_pin.sym} 63280 -4130 0 0 {name=p63193 lab=_60319_/X }
C {devices/lab_pin.sym} 63280 -4090 0 0 {name=p63194 lab=_60346_/C }
C {devices/lab_pin.sym} 63400 -4130 0 1 {name=p63195 lab=_60346_/Y }
C {sky130_stdcells/nor3_4.sym} 63340 -4130 0 0 {name=X_60346_ }
C {devices/lab_pin.sym} 63260 -4020 0 0 {name=p63196 lab=_41963_/A }
C {devices/lab_pin.sym} 63260 -3980 0 0 {name=p63197 lab=_68989_/X }
C {devices/lab_pin.sym} 63260 -3940 0 0 {name=p63198 lab=_68555_/X }
C {devices/lab_pin.sym} 63260 -3900 0 0 {name=p63199 lab=_68990_/Y }
C {devices/lab_pin.sym} 63420 -3960 0 1 {name=p63200 lab=_68991_/X }
C {sky130_stdcells/a211o_4.sym} 63340 -3960 0 0 {name=X_68991_ }
C {devices/lab_pin.sym} 63300 -3810 0 0 {name=p63201 lab=_82391_/Q }
C {devices/lab_pin.sym} 63380 -3810 0 1 {name=p63202 lab=_54498_/D }
C {sky130_stdcells/inv_2.sym} 63340 -3810 0 0 {name=X_47019_ }
C {devices/lab_pin.sym} 63300 -3690 0 0 {name=p63203 lab=_67466_/X }
C {devices/lab_pin.sym} 63380 -3690 0 1 {name=p63204 lab=_67942_/X }
C {sky130_stdcells/buf_2.sym} 63340 -3690 0 0 {name=X_67942_ }
C {devices/lab_pin.sym} 63300 -3570 0 0 {name=p63205 lab=_60484_/A }
C {devices/lab_pin.sym} 63380 -3570 0 1 {name=p63206 lab=_63066_/D }
C {sky130_stdcells/buf_2.sym} 63340 -3570 0 0 {name=X_63065_ }
C {devices/lab_pin.sym} 63280 -3460 0 0 {name=p63207 lab=_79928_/A }
C {devices/lab_pin.sym} 63280 -3420 0 0 {name=p63208 lab=_79928_/B }
C {devices/lab_pin.sym} 63400 -3440 0 1 {name=p63209 lab=_79928_/Y }
C {sky130_stdcells/nor2_4.sym} 63340 -3440 0 0 {name=X_79928_ }
C {devices/lab_pin.sym} 63260 -3340 0 0 {name=p63210 lab=_60344_/C }
C {devices/lab_pin.sym} 63260 -3300 0 0 {name=p63211 lab=_60268_/C }
C {devices/lab_pin.sym} 63260 -3260 0 0 {name=p63212 lab=_60344_/B }
C {devices/lab_pin.sym} 63260 -3220 0 0 {name=p63213 lab=_60324_/C }
C {devices/lab_pin.sym} 63420 -3280 0 1 {name=p63214 lab=_60277_/X }
C {sky130_stdcells/a211o_4.sym} 63340 -3280 0 0 {name=X_60277_ }
C {devices/lab_pin.sym} 63300 -3130 0 0 {name=p63215 lab=_46308_/A }
C {devices/lab_pin.sym} 63380 -3130 0 1 {name=p63216 lab=_50050_/A }
C {sky130_stdcells/buf_2.sym} 63340 -3130 0 0 {name=X_50030_ }
C {devices/lab_pin.sym} 63260 -3050 0 0 {name=p63217 lab=_62004_/X }
C {devices/lab_pin.sym} 63260 -3010 0 0 {name=p63218 lab=_62006_/X }
C {devices/lab_pin.sym} 63260 -2970 0 0 {name=p63219 lab=_62015_/Y }
C {devices/lab_pin.sym} 63260 -2930 0 0 {name=p63220 lab=_84847_/Q }
C {devices/lab_pin.sym} 63260 -2890 0 0 {name=p63221 lab=_61973_/X }
C {devices/lab_pin.sym} 63420 -2970 0 1 {name=p63222 lab=_62016_/Y }
C {sky130_stdcells/o32ai_4.sym} 63340 -2970 0 0 {name=X_62016_ }
C {devices/lab_pin.sym} 63280 -2820 0 0 {name=p63223 lab=_79859_/A }
C {devices/lab_pin.sym} 63280 -2780 0 0 {name=p63224 lab=_79858_/Y }
C {devices/lab_pin.sym} 63400 -2800 0 1 {name=p63225 lab=_79859_/X }
C {sky130_stdcells/xor2_4.sym} 63340 -2800 0 0 {name=X_79859_ }
C {devices/lab_pin.sym} 63280 -2680 0 0 {name=p63226 lab=_67873_/A }
C {devices/lab_pin.sym} 63280 -2640 0 0 {name=p63227 lab=_67873_/B }
C {devices/lab_pin.sym} 63400 -2660 0 1 {name=p63228 lab=_67873_/X }
C {sky130_stdcells/and2_4.sym} 63340 -2660 0 0 {name=X_67873_ }
C {devices/lab_pin.sym} 63280 -2540 0 0 {name=p63229 lab=_69612_/A }
C {devices/lab_pin.sym} 63280 -2500 0 0 {name=p63230 lab=_69612_/B }
C {devices/lab_pin.sym} 63400 -2520 0 1 {name=p63231 lab=_69612_/X }
C {sky130_stdcells/and2_4.sym} 63340 -2520 0 0 {name=X_69612_ }
C {devices/lab_pin.sym} 63260 -2420 0 0 {name=p63232 lab=_87125_/Q }
C {devices/lab_pin.sym} 63260 -2380 0 0 {name=p63233 lab=_66751_/X }
C {devices/lab_pin.sym} 63260 -2340 0 0 {name=p63234 lab=_66801_/X }
C {devices/lab_pin.sym} 63260 -2300 0 0 {name=p63235 lab=_66823_/X }
C {devices/lab_pin.sym} 63420 -2360 0 1 {name=p63236 lab=_66824_/X }
C {sky130_stdcells/a211o_4.sym} 63340 -2360 0 0 {name=X_66824_ }
C {devices/lab_pin.sym} 63250 -2210 0 0 {name=p63237 lab=_82498_/CLK }
C {devices/lab_pin.sym} 63250 -2190 0 0 {name=p63238 lab=_78228_/B }
C {devices/lab_pin.sym} 63430 -2210 0 1 {name=p63239 lab=_82870_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -2200 0 0 {name=X_82870_ }
C {devices/lab_pin.sym} 63250 -2070 0 0 {name=p63240 lab=_81275_/CLK }
C {devices/lab_pin.sym} 63250 -2050 0 0 {name=p63241 lab=_81821_/D }
C {devices/lab_pin.sym} 63430 -2070 0 1 {name=p63242 lab=_81821_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -2060 0 0 {name=X_81821_ }
C {devices/lab_pin.sym} 63260 -1960 0 0 {name=p63243 lab=_88021_/Q }
C {devices/lab_pin.sym} 63260 -1920 0 0 {name=p63244 lab=_69424_/X }
C {devices/lab_pin.sym} 63260 -1880 0 0 {name=p63245 lab=_69465_/X }
C {devices/lab_pin.sym} 63260 -1840 0 0 {name=p63246 lab=_69542_/X }
C {devices/lab_pin.sym} 63420 -1900 0 1 {name=p63247 lab=_69543_/X }
C {sky130_stdcells/a211o_4.sym} 63340 -1900 0 0 {name=X_69543_ }
C {devices/lab_pin.sym} 63260 -1780 0 0 {name=p63248 lab=_66499_/B }
C {devices/lab_pin.sym} 63260 -1740 0 0 {name=p63249 lab=_66743_/Y }
C {devices/lab_pin.sym} 63260 -1700 0 0 {name=p63250 lab=_66672_/X }
C {devices/lab_pin.sym} 63260 -1660 0 0 {name=p63251 lab=_66754_/Y }
C {devices/lab_pin.sym} 63420 -1720 0 1 {name=p63252 lab=_66755_/X }
C {sky130_stdcells/a211o_4.sym} 63340 -1720 0 0 {name=X_66755_ }
C {devices/lab_pin.sym} 63300 -1570 0 0 {name=p63253 lab=_51934_/A }
C {devices/lab_pin.sym} 63380 -1570 0 1 {name=p63254 lab=_51981_/X }
C {sky130_stdcells/buf_2.sym} 63340 -1570 0 0 {name=X_51981_ }
C {devices/lab_pin.sym} 63300 -1450 0 0 {name=p63255 lab=_63966_/Y }
C {devices/lab_pin.sym} 63380 -1450 0 1 {name=p63256 lab=_63967_/Y }
C {sky130_stdcells/inv_2.sym} 63340 -1450 0 0 {name=X_63967_ }
C {devices/lab_pin.sym} 63280 -1350 0 0 {name=p63257 lab=_52204_/A }
C {devices/lab_pin.sym} 63280 -1310 0 0 {name=p63258 lab=_53720_/B }
C {devices/lab_pin.sym} 63280 -1270 0 0 {name=p63259 lab=_53734_/C }
C {devices/lab_pin.sym} 63400 -1310 0 1 {name=p63260 lab=_53720_/X }
C {sky130_stdcells/and3_4.sym} 63340 -1310 0 0 {name=X_53720_ }
C {devices/lab_pin.sym} 63260 -1190 0 0 {name=p63261 lab=_65703_/X }
C {devices/lab_pin.sym} 63260 -1150 0 0 {name=p63262 lab=_65705_/X }
C {devices/lab_pin.sym} 63260 -1110 0 0 {name=p63263 lab=_65642_/X }
C {devices/lab_pin.sym} 63420 -1150 0 1 {name=p63264 lab=_65710_/A }
C {sky130_stdcells/a21o_4.sym} 63340 -1150 0 0 {name=X_65706_ }
C {devices/lab_pin.sym} 63250 -1010 0 0 {name=p63265 lab=_84292_/CLK }
C {devices/lab_pin.sym} 63250 -990 0 0 {name=p63266 lab=_61015_/Y }
C {devices/lab_pin.sym} 63430 -1010 0 1 {name=p63267 lab=_84540_/Q }
C {sky130_stdcells/dfxtp_4.sym} 63340 -1000 0 0 {name=X_84540_ }
C {devices/lab_pin.sym} 63280 -880 0 0 {name=p63268 lab=_50932_/A }
C {devices/lab_pin.sym} 63280 -840 0 0 {name=p63269 lab=_46701_/X }
C {devices/lab_pin.sym} 63400 -860 0 1 {name=p63270 lab=_50932_/Y }
C {sky130_stdcells/nand2_4.sym} 63340 -860 0 0 {name=X_50932_ }
C {devices/lab_pin.sym} 63260 -760 0 0 {name=p63271 lab=_58498_/A }
C {devices/lab_pin.sym} 63260 -720 0 0 {name=p63272 lab=_60304_/A }
C {devices/lab_pin.sym} 63260 -680 0 0 {name=p63273 lab=_64473_/A }
C {devices/lab_pin.sym} 63260 -640 0 0 {name=p63274 lab=_62875_/X }
C {devices/lab_pin.sym} 63420 -700 0 1 {name=p63275 lab=_62918_/X }
C {sky130_stdcells/o22a_4.sym} 63340 -700 0 0 {name=X_62918_ }
C {devices/lab_pin.sym} 64170 -42150 0 0 {name=p63276 lab=_81756_/CLK }
C {devices/lab_pin.sym} 64170 -42130 0 0 {name=p63277 lab=_76083_/B }
C {devices/lab_pin.sym} 64350 -42150 0 1 {name=p63278 lab=_41330_/A }
C {sky130_stdcells/dfxtp_4.sym} 64260 -42140 0 0 {name=X_81752_ }
C {devices/lab_pin.sym} 64180 -42030 0 0 {name=p63279 lab=_69471_/X }
C {devices/lab_pin.sym} 64180 -41990 0 0 {name=p63280 lab=_69473_/X }
C {devices/lab_pin.sym} 64180 -41950 0 0 {name=p63281 lab=_69433_/X }
C {devices/lab_pin.sym} 64340 -41990 0 1 {name=p63282 lab=_69474_/Y }
C {sky130_stdcells/a21oi_4.sym} 64260 -41990 0 0 {name=X_69474_ }
C {devices/lab_pin.sym} 64180 -41880 0 0 {name=p63283 lab=_66526_/X }
C {devices/lab_pin.sym} 64180 -41840 0 0 {name=p63284 lab=_66671_/Y }
C {devices/lab_pin.sym} 64180 -41800 0 0 {name=p63285 lab=_66672_/X }
C {devices/lab_pin.sym} 64180 -41760 0 0 {name=p63286 lab=_66685_/Y }
C {devices/lab_pin.sym} 64340 -41820 0 1 {name=p63287 lab=_66686_/X }
C {sky130_stdcells/a211o_4.sym} 64260 -41820 0 0 {name=X_66686_ }
C {devices/lab_pin.sym} 64180 -41690 0 0 {name=p63288 lab=_63896_/X }
C {devices/lab_pin.sym} 64180 -41650 0 0 {name=p63289 lab=_63833_/X }
C {devices/lab_pin.sym} 64180 -41610 0 0 {name=p63290 lab=_63897_/Y }
C {devices/lab_pin.sym} 64340 -41650 0 1 {name=p63291 lab=_63898_/Y }
C {sky130_stdcells/a21oi_4.sym} 64260 -41650 0 0 {name=X_63898_ }
C {devices/lab_pin.sym} 64200 -41520 0 0 {name=p63292 lab=_68403_/A }
C {devices/lab_pin.sym} 64200 -41480 0 0 {name=p63293 lab=_68425_/B }
C {devices/lab_pin.sym} 64320 -41500 0 1 {name=p63294 lab=_68425_/X }
C {sky130_stdcells/and2_4.sym} 64260 -41500 0 0 {name=X_68425_ }
C {devices/lab_pin.sym} 64170 -41370 0 0 {name=p63295 lab=_81121_/CLK }
C {devices/lab_pin.sym} 64170 -41350 0 0 {name=p63296 lab=_80703_/D }
C {devices/lab_pin.sym} 64350 -41370 0 1 {name=p63297 lab=_80703_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -41360 0 0 {name=X_80703_ }
C {devices/lab_pin.sym} 64200 -41240 0 0 {name=p63298 lab=_53656_/A }
C {devices/lab_pin.sym} 64200 -41200 0 0 {name=p63299 lab=_53651_/B }
C {devices/lab_pin.sym} 64320 -41220 0 1 {name=p63300 lab=_53651_/Y }
C {sky130_stdcells/nand2_4.sym} 64260 -41220 0 0 {name=X_53651_ }
C {devices/lab_pin.sym} 64180 -41120 0 0 {name=p63301 lab=_65484_/X }
C {devices/lab_pin.sym} 64180 -41080 0 0 {name=p63302 lab=_86195_/Q }
C {devices/lab_pin.sym} 64180 -41040 0 0 {name=p63303 lab=_65534_/X }
C {devices/lab_pin.sym} 64180 -41000 0 0 {name=p63304 lab=_65636_/X }
C {devices/lab_pin.sym} 64340 -41060 0 1 {name=p63305 lab=_65637_/X }
C {sky130_stdcells/a211o_4.sym} 64260 -41060 0 0 {name=X_65637_ }
C {devices/lab_pin.sym} 64170 -40910 0 0 {name=p63306 lab=_82822_/CLK }
C {devices/lab_pin.sym} 64170 -40890 0 0 {name=p63307 lab=_61556_/Y }
C {devices/lab_pin.sym} 64350 -40910 0 1 {name=p63308 lab=_84471_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -40900 0 0 {name=X_84471_ }
C {devices/lab_pin.sym} 64180 -40790 0 0 {name=p63309 lab=_86118_/Q }
C {devices/lab_pin.sym} 64180 -40750 0 0 {name=p63310 lab=_50856_/X }
C {devices/lab_pin.sym} 64180 -40710 0 0 {name=p63311 lab=_50862_/Y }
C {devices/lab_pin.sym} 64340 -40750 0 1 {name=p63312 lab=_50863_/Y }
C {sky130_stdcells/o21ai_4.sym} 64260 -40750 0 0 {name=X_50863_ }
C {devices/lab_pin.sym} 64180 -40650 0 0 {name=p63313 lab=_62843_/X }
C {devices/lab_pin.sym} 64180 -40610 0 0 {name=p63314 lab=_62831_/X }
C {devices/lab_pin.sym} 64180 -40570 0 0 {name=p63315 lab=_62844_/Y }
C {devices/lab_pin.sym} 64180 -40530 0 0 {name=p63316 lab=_62846_/Y }
C {devices/lab_pin.sym} 64180 -40500 0 0 {name=p63317 lab=_62848_/X }
C {devices/lab_pin.sym} 64340 -40570 0 1 {name=p63318 lab=_62849_/X }
C {sky130_stdcells/a41o_4.sym} 64260 -40570 0 0 {name=X_62849_ }
C {devices/lab_pin.sym} 64170 -40410 0 0 {name=p63319 lab=_81697_/CLK }
C {devices/lab_pin.sym} 64170 -40390 0 0 {name=p63320 lab=_81683_/D }
C {devices/lab_pin.sym} 64350 -40410 0 1 {name=p63321 lab=_76656_/B }
C {sky130_stdcells/dfxtp_4.sym} 64260 -40400 0 0 {name=X_81683_ }
C {devices/lab_pin.sym} 64170 -40270 0 0 {name=p63322 lab=_86210_/CLK }
C {devices/lab_pin.sym} 64170 -40250 0 0 {name=p63323 lab=_50392_/Y }
C {devices/lab_pin.sym} 64350 -40270 0 1 {name=p63324 lab=_86210_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -40260 0 0 {name=X_86210_ }
C {devices/lab_pin.sym} 64220 -40130 0 0 {name=p63325 lab=_52602_/A }
C {devices/lab_pin.sym} 64300 -40130 0 1 {name=p63326 lab=_52624_/A }
C {sky130_stdcells/buf_2.sym} 64260 -40130 0 0 {name=X_52602_ }
C {devices/lab_pin.sym} 64170 -40010 0 0 {name=p63327 lab=_84945_/CLK }
C {devices/lab_pin.sym} 64170 -39990 0 0 {name=p63328 lab=_71659_/Y }
C {devices/lab_pin.sym} 64350 -40010 0 1 {name=p63329 lab=_58513_/A }
C {sky130_stdcells/dfxtp_4.sym} 64260 -40000 0 0 {name=X_83422_ }
C {devices/lab_pin.sym} 64200 -39880 0 0 {name=p63330 lab=_80632_/Y }
C {devices/lab_pin.sym} 64200 -39840 0 0 {name=p63331 lab=_80633_/Y }
C {devices/lab_pin.sym} 64320 -39860 0 1 {name=p63332 lab=_80634_/Y }
C {sky130_stdcells/nand2_4.sym} 64260 -39860 0 0 {name=X_80634_ }
C {devices/lab_pin.sym} 64200 -39760 0 0 {name=p63333 lab=_56183_/X }
C {devices/lab_pin.sym} 64200 -39720 0 0 {name=p63334 lab=_56460_/B }
C {devices/lab_pin.sym} 64200 -39680 0 0 {name=p63335 lab=_56370_/C }
C {devices/lab_pin.sym} 64200 -39640 0 0 {name=p63336 lab=_56460_/D }
C {devices/lab_pin.sym} 64320 -39700 0 1 {name=p63337 lab=_56370_/Y }
C {sky130_stdcells/nand4_4.sym} 64260 -39700 0 0 {name=X_56370_ }
C {devices/lab_pin.sym} 64180 -39580 0 0 {name=p63338 lab=_87103_/Q }
C {devices/lab_pin.sym} 64180 -39540 0 0 {name=p63339 lab=_68353_/X }
C {devices/lab_pin.sym} 64180 -39500 0 0 {name=p63340 lab=_68354_/X }
C {devices/lab_pin.sym} 64180 -39460 0 0 {name=p63341 lab=_68355_/X }
C {devices/lab_pin.sym} 64340 -39520 0 1 {name=p63342 lab=_68356_/X }
C {sky130_stdcells/a211o_4.sym} 64260 -39520 0 0 {name=X_68356_ }
C {devices/lab_pin.sym} 64170 -39370 0 0 {name=p63343 lab=_87221_/CLK }
C {devices/lab_pin.sym} 64170 -39350 0 0 {name=p63344 lab=_43937_/Y }
C {devices/lab_pin.sym} 64350 -39370 0 1 {name=p63345 lab=_87190_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -39360 0 0 {name=X_87190_ }
C {devices/lab_pin.sym} 64180 -39250 0 0 {name=p63346 lab=_85608_/Q }
C {devices/lab_pin.sym} 64180 -39210 0 0 {name=p63347 lab=_53556_/X }
C {devices/lab_pin.sym} 64180 -39170 0 0 {name=p63348 lab=_53581_/Y }
C {devices/lab_pin.sym} 64340 -39210 0 1 {name=p63349 lab=_53582_/Y }
C {sky130_stdcells/o21ai_4.sym} 64260 -39210 0 0 {name=X_53582_ }
C {devices/lab_pin.sym} 64220 -39070 0 0 {name=p63350 lab=_65768_/A }
C {devices/lab_pin.sym} 64300 -39070 0 1 {name=p63351 lab=_65568_/X }
C {sky130_stdcells/buf_2.sym} 64260 -39070 0 0 {name=X_65568_ }
C {devices/lab_pin.sym} 64180 -38970 0 0 {name=p63352 lab=_50791_/Y }
C {devices/lab_pin.sym} 64180 -38930 0 0 {name=p63353 lab=_50792_/X }
C {devices/lab_pin.sym} 64180 -38890 0 0 {name=p63354 lab=_50793_/Y }
C {devices/lab_pin.sym} 64340 -38930 0 1 {name=p63355 lab=_86132_/D }
C {sky130_stdcells/a21boi_4.sym} 64260 -38930 0 0 {name=X_50794_ }
C {devices/lab_pin.sym} 64180 -38820 0 0 {name=p63356 lab=_85102_/Q }
C {devices/lab_pin.sym} 64180 -38780 0 0 {name=p63357 lab=_55305_/X }
C {devices/lab_pin.sym} 64180 -38740 0 0 {name=p63358 lab=_44045_/X }
C {devices/lab_pin.sym} 64180 -38700 0 0 {name=p63359 lab=_55320_/Y }
C {devices/lab_pin.sym} 64340 -38760 0 1 {name=p63360 lab=_55321_/X }
C {sky130_stdcells/a211o_4.sym} 64260 -38760 0 0 {name=X_55321_ }
C {devices/lab_pin.sym} 64170 -38610 0 0 {name=p63361 lab=_86045_/CLK }
C {devices/lab_pin.sym} 64170 -38590 0 0 {name=p63362 lab=_50752_/Y }
C {devices/lab_pin.sym} 64350 -38610 0 1 {name=p63363 lab=_86141_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -38600 0 0 {name=X_86141_ }
C {devices/lab_pin.sym} 64180 -38500 0 0 {name=p63364 lab=_87860_/Q }
C {devices/lab_pin.sym} 64180 -38460 0 0 {name=p63365 lab=_67236_/X }
C {devices/lab_pin.sym} 64180 -38420 0 0 {name=p63366 lab=_67284_/X }
C {devices/lab_pin.sym} 64180 -38380 0 0 {name=p63367 lab=_67306_/X }
C {devices/lab_pin.sym} 64340 -38440 0 1 {name=p63368 lab=_67307_/X }
C {sky130_stdcells/a211o_4.sym} 64260 -38440 0 0 {name=X_67307_ }
C {sky130_stdcells/decap_3.sym} 64260 -38260 0 0 {name=XPHY_106 }
C {devices/lab_pin.sym} 64200 -38130 0 0 {name=p63369 lab=_52533_/A }
C {devices/lab_pin.sym} 64200 -38090 0 0 {name=p63370 lab=_52509_/B }
C {devices/lab_pin.sym} 64200 -38050 0 0 {name=p63371 lab=_50918_/A }
C {devices/lab_pin.sym} 64320 -38090 0 1 {name=p63372 lab=_52533_/X }
C {sky130_stdcells/and3_4.sym} 64260 -38090 0 0 {name=X_52533_ }
C {devices/lab_pin.sym} 64180 -37970 0 0 {name=p63373 lab=_79581_/B }
C {devices/lab_pin.sym} 64180 -37930 0 0 {name=p63374 lab=_64429_/X }
C {devices/lab_pin.sym} 64180 -37890 0 0 {name=p63375 lab=_64518_/X }
C {devices/lab_pin.sym} 64340 -37930 0 1 {name=p63376 lab=_64519_/X }
C {sky130_stdcells/a21o_4.sym} 64260 -37930 0 0 {name=X_64519_ }
C {devices/lab_pin.sym} 64170 -37790 0 0 {name=p63377 lab=_83480_/CLK }
C {devices/lab_pin.sym} 64170 -37770 0 0 {name=p63378 lab=_83353_/D }
C {devices/lab_pin.sym} 64350 -37790 0 1 {name=p63379 lab=_83353_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -37780 0 0 {name=X_83353_ }
C {sky130_stdcells/decap_3.sym} 64260 -37620 0 0 {name=XPHY_117 }
C {devices/lab_pin.sym} 64200 -37480 0 0 {name=p63380 lab=_84771_/Q }
C {devices/lab_pin.sym} 64200 -37440 0 0 {name=p63381 lab=_84163_/Q }
C {devices/lab_pin.sym} 64320 -37460 0 1 {name=p63382 lab=_80565_/Y }
C {sky130_stdcells/nand2_4.sym} 64260 -37460 0 0 {name=X_80565_ }
C {devices/lab_pin.sym} 64220 -37330 0 0 {name=p63383 lab=_68447_/A }
C {devices/lab_pin.sym} 64300 -37330 0 1 {name=p63384 lab=_68287_/X }
C {sky130_stdcells/buf_2.sym} 64260 -37330 0 0 {name=X_68287_ }
C {devices/lab_pin.sym} 64180 -37230 0 0 {name=p63385 lab=_65496_/Y }
C {devices/lab_pin.sym} 64180 -37190 0 0 {name=p63386 lab=_65448_/X }
C {devices/lab_pin.sym} 64180 -37150 0 0 {name=p63387 lab=_65498_/Y }
C {devices/lab_pin.sym} 64340 -37190 0 1 {name=p63388 lab=_84197_/D }
C {sky130_stdcells/a21o_4.sym} 64260 -37190 0 0 {name=X_65499_ }
C {sky130_stdcells/decap_3.sym} 64260 -37020 0 0 {name=XPHY_128 }
C {devices/lab_pin.sym} 64220 -36870 0 0 {name=p63389 lab=clkbuf_3_6_1_CLK/X }
C {devices/lab_pin.sym} 64300 -36870 0 1 {name=p63390 lab=clkbuf_4_13_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 64260 -36870 0 0 {name=Xclkbuf_4_13_0_CLK }
C {sky130_stdcells/decap_3.sym} 64260 -36720 0 0 {name=XPHY_139 }
C {devices/lab_pin.sym} 64180 -36610 0 0 {name=p63391 lab=_58010_/X }
C {devices/lab_pin.sym} 64180 -36570 0 0 {name=p63392 lab=_58038_/Y }
C {devices/lab_pin.sym} 64180 -36530 0 0 {name=p63393 lab=_58039_/Y }
C {devices/lab_pin.sym} 64180 -36490 0 0 {name=p63394 lab=_58028_/X }
C {devices/lab_pin.sym} 64180 -36450 0 0 {name=p63395 lab=_58015_/X }
C {devices/lab_pin.sym} 64340 -36530 0 1 {name=p63396 lab=_58040_/X }
C {sky130_stdcells/o32a_4.sym} 64260 -36530 0 0 {name=X_58040_ }
C {devices/lab_pin.sym} 64170 -36370 0 0 {name=p63397 lab=_82349_/CLK }
C {devices/lab_pin.sym} 64170 -36350 0 0 {name=p63398 lab=_77222_/B }
C {devices/lab_pin.sym} 64350 -36370 0 1 {name=p63399 lab=_82304_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -36360 0 0 {name=X_82304_ }
C {devices/lab_pin.sym} 64200 -36240 0 0 {name=p63400 lab=_55252_/A }
C {devices/lab_pin.sym} 64200 -36200 0 0 {name=p63401 lab=_85128_/Q }
C {devices/lab_pin.sym} 64320 -36220 0 1 {name=p63402 lab=_55252_/X }
C {sky130_stdcells/and2_4.sym} 64260 -36220 0 0 {name=X_55252_ }
C {devices/lab_pin.sym} 64180 -36120 0 0 {name=p63403 lab=_87863_/Q }
C {devices/lab_pin.sym} 64180 -36080 0 0 {name=p63404 lab=_67236_/X }
C {devices/lab_pin.sym} 64180 -36040 0 0 {name=p63405 lab=_67167_/X }
C {devices/lab_pin.sym} 64180 -36000 0 0 {name=p63406 lab=_67237_/X }
C {devices/lab_pin.sym} 64340 -36060 0 1 {name=p63407 lab=_67238_/X }
C {sky130_stdcells/a211o_4.sym} 64260 -36060 0 0 {name=X_67238_ }
C {devices/lab_pin.sym} 64170 -35910 0 0 {name=p63408 lab=_85751_/CLK }
C {devices/lab_pin.sym} 64170 -35890 0 0 {name=p63409 lab=_86072_/D }
C {devices/lab_pin.sym} 64350 -35910 0 1 {name=p63410 lab=_86072_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -35900 0 0 {name=X_86072_ }
C {devices/lab_pin.sym} 64200 -35780 0 0 {name=p63411 lab=_52468_/A }
C {devices/lab_pin.sym} 64200 -35740 0 0 {name=p63412 lab=_53983_/B }
C {devices/lab_pin.sym} 64320 -35760 0 1 {name=p63413 lab=_52464_/Y }
C {sky130_stdcells/nand2_4.sym} 64260 -35760 0 0 {name=X_52464_ }
C {devices/lab_pin.sym} 64170 -35630 0 0 {name=p63414 lab=_86149_/CLK }
C {devices/lab_pin.sym} 64170 -35610 0 0 {name=p63415 lab=_72104_/Y }
C {devices/lab_pin.sym} 64350 -35630 0 1 {name=p63416 lab=_83284_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -35620 0 0 {name=X_83284_ }
C {devices/lab_pin.sym} 64200 -35500 0 0 {name=p63417 lab=_59143_/A }
C {devices/lab_pin.sym} 64200 -35460 0 0 {name=p63418 lab=_84157_/Q }
C {devices/lab_pin.sym} 64320 -35480 0 1 {name=p63419 lab=_80496_/X }
C {sky130_stdcells/xor2_4.sym} 64260 -35480 0 0 {name=X_80496_ }
C {devices/lab_pin.sym} 64200 -35380 0 0 {name=p63420 lab=_54191_/A }
C {devices/lab_pin.sym} 64200 -35340 0 0 {name=p63421 lab=_54191_/B }
C {devices/lab_pin.sym} 64200 -35300 0 0 {name=p63422 lab=_54209_/C }
C {devices/lab_pin.sym} 64200 -35260 0 0 {name=p63423 lab=_53036_/D }
C {devices/lab_pin.sym} 64320 -35320 0 1 {name=p63424 lab=_54203_/X }
C {sky130_stdcells/and4_4.sym} 64260 -35320 0 0 {name=X_54203_ }
C {devices/lab_pin.sym} 64170 -35170 0 0 {name=p63425 lab=_83008_/CLK }
C {devices/lab_pin.sym} 64170 -35150 0 0 {name=p63426 lab=_57387_/X }
C {devices/lab_pin.sym} 64350 -35170 0 1 {name=p63427 lab=_85023_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -35160 0 0 {name=X_85023_ }
C {devices/lab_pin.sym} 64220 -35030 0 0 {name=p63428 lab=_51170_/A }
C {devices/lab_pin.sym} 64300 -35030 0 1 {name=p63429 lab=_51438_/C }
C {sky130_stdcells/buf_2.sym} 64260 -35030 0 0 {name=X_51415_ }
C {devices/lab_pin.sym} 64170 -34910 0 0 {name=p63430 lab=_82515_/CLK }
C {devices/lab_pin.sym} 64170 -34890 0 0 {name=p63431 lab=_82267_/Q }
C {devices/lab_pin.sym} 64350 -34910 0 1 {name=p63432 lab=_77599_/A }
C {sky130_stdcells/dfxtp_4.sym} 64260 -34900 0 0 {name=X_82235_ }
C {devices/lab_pin.sym} 64220 -34770 0 0 {name=p63433 lab=_55245_/A }
C {devices/lab_pin.sym} 64300 -34770 0 1 {name=p63434 lab=_55711_/A }
C {sky130_stdcells/buf_2.sym} 64260 -34770 0 0 {name=X_55183_ }
C {devices/lab_pin.sym} 64180 -34680 0 0 {name=p63435 lab=_87930_/Q }
C {devices/lab_pin.sym} 64180 -34640 0 0 {name=p63436 lab=_67117_/X }
C {devices/lab_pin.sym} 64180 -34600 0 0 {name=p63437 lab=_67167_/X }
C {devices/lab_pin.sym} 64180 -34560 0 0 {name=p63438 lab=_67168_/X }
C {devices/lab_pin.sym} 64340 -34620 0 1 {name=p63439 lab=_67169_/X }
C {sky130_stdcells/a211o_4.sym} 64260 -34620 0 0 {name=X_67169_ }
C {devices/lab_pin.sym} 64200 -34480 0 0 {name=p63440 lab=_52385_/A }
C {devices/lab_pin.sym} 64200 -34440 0 0 {name=p63441 lab=_52395_/B }
C {devices/lab_pin.sym} 64320 -34460 0 1 {name=p63442 lab=_52395_/X }
C {sky130_stdcells/and2_4.sym} 64260 -34460 0 0 {name=X_52395_ }
C {devices/lab_pin.sym} 64200 -34340 0 0 {name=p63443 lab=_54134_/A }
C {devices/lab_pin.sym} 64200 -34300 0 0 {name=p63444 lab=_47297_/Y }
C {devices/lab_pin.sym} 64320 -34320 0 1 {name=p63445 lab=_54134_/Y }
C {sky130_stdcells/nand2_4.sym} 64260 -34320 0 0 {name=X_54134_ }
C {devices/lab_pin.sym} 64180 -34210 0 0 {name=p63446 lab=_65147_/B }
C {devices/lab_pin.sym} 64180 -34170 0 0 {name=p63447 lab=_51332_/X }
C {devices/lab_pin.sym} 64180 -34130 0 0 {name=p63448 lab=_51345_/Y }
C {devices/lab_pin.sym} 64340 -34170 0 1 {name=p63449 lab=_51346_/Y }
C {sky130_stdcells/o21ai_4.sym} 64260 -34170 0 0 {name=X_51346_ }
C {devices/lab_pin.sym} 64220 -34030 0 0 {name=p63450 lab=_83846_/Q }
C {devices/lab_pin.sym} 64300 -34030 0 1 {name=p63451 lab=_70180_/Y }
C {sky130_stdcells/inv_2.sym} 64260 -34030 0 0 {name=X_70180_ }
C {devices/lab_pin.sym} 64170 -33910 0 0 {name=p63452 lab=_86553_/CLK }
C {devices/lab_pin.sym} 64170 -33890 0 0 {name=p63453 lab=_84158_/Q }
C {devices/lab_pin.sym} 64350 -33910 0 1 {name=p63454 lab=_82166_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -33900 0 0 {name=X_82166_ }
C {devices/lab_pin.sym} 64220 -33770 0 0 {name=p63455 lab=_59990_/X }
C {devices/lab_pin.sym} 64300 -33770 0 1 {name=p63456 lab=_60129_/B }
C {sky130_stdcells/inv_2.sym} 64260 -33770 0 0 {name=X_59991_ }
C {devices/lab_pin.sym} 64170 -33650 0 0 {name=p63457 lab=_81117_/CLK }
C {devices/lab_pin.sym} 64170 -33630 0 0 {name=p63458 lab=_79842_/X }
C {devices/lab_pin.sym} 64350 -33650 0 1 {name=p63459 lab=_75669_/A }
C {sky130_stdcells/dfxtp_4.sym} 64260 -33640 0 0 {name=X_81117_ }
C {devices/lab_pin.sym} 64200 -33520 0 0 {name=p63460 lab=_58942_/A }
C {devices/lab_pin.sym} 64200 -33480 0 0 {name=p63461 lab=_59090_/B }
C {devices/lab_pin.sym} 64320 -33500 0 1 {name=p63462 lab=_58942_/Y }
C {sky130_stdcells/nor2_4.sym} 64260 -33500 0 0 {name=X_58942_ }
C {devices/lab_pin.sym} 64200 -33380 0 0 {name=p63463 lab=_54031_/A }
C {devices/lab_pin.sym} 64200 -33340 0 0 {name=p63464 lab=_50854_/B }
C {devices/lab_pin.sym} 64320 -33360 0 1 {name=p63465 lab=_54065_/Y }
C {sky130_stdcells/nand2_4.sym} 64260 -33360 0 0 {name=X_54065_ }
C {devices/lab_pin.sym} 64180 -33250 0 0 {name=p63466 lab=_64820_/B }
C {devices/lab_pin.sym} 64180 -33210 0 0 {name=p63467 lab=_51259_/X }
C {devices/lab_pin.sym} 64180 -33170 0 0 {name=p63468 lab=_51276_/Y }
C {devices/lab_pin.sym} 64340 -33210 0 1 {name=p63469 lab=_51277_/Y }
C {sky130_stdcells/o21ai_4.sym} 64260 -33210 0 0 {name=X_51277_ }
C {devices/lab_pin.sym} 64170 -33070 0 0 {name=p63470 lab=_88180_/CLK }
C {devices/lab_pin.sym} 64170 -33050 0 0 {name=p63471 lab=_44752_/X }
C {devices/lab_pin.sym} 64350 -33070 0 1 {name=p63472 lab=_86974_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -33060 0 0 {name=X_86974_ }
C {devices/lab_pin.sym} 64170 -32930 0 0 {name=p63473 lab=_82604_/CLK }
C {devices/lab_pin.sym} 64170 -32910 0 0 {name=p63474 lab=_77444_/B }
C {devices/lab_pin.sym} 64350 -32930 0 1 {name=p63475 lab=_77110_/A }
C {sky130_stdcells/dfxtp_4.sym} 64260 -32920 0 0 {name=X_82097_ }
C {devices/lab_pin.sym} 64200 -32800 0 0 {name=p63476 lab=_40852_/B }
C {devices/lab_pin.sym} 64200 -32760 0 0 {name=p63477 lab=_41091_/B }
C {devices/lab_pin.sym} 64320 -32780 0 1 {name=p63478 lab=_41030_/X }
C {sky130_stdcells/or2_4.sym} 64260 -32780 0 0 {name=X_41030_ }
C {devices/lab_pin.sym} 64180 -32670 0 0 {name=p63479 lab=_53013_/Y }
C {devices/lab_pin.sym} 64180 -32630 0 0 {name=p63480 lab=_53001_/X }
C {devices/lab_pin.sym} 64180 -32590 0 0 {name=p63481 lab=_53015_/X }
C {devices/lab_pin.sym} 64340 -32630 0 1 {name=p63482 lab=_53016_/Y }
C {sky130_stdcells/a21oi_4.sym} 64260 -32630 0 0 {name=X_53016_ }
C {devices/lab_pin.sym} 64220 -32490 0 0 {name=p63483 lab=_50638_/A }
C {devices/lab_pin.sym} 64300 -32490 0 1 {name=p63484 lab=_50228_/X }
C {sky130_stdcells/buf_2.sym} 64260 -32490 0 0 {name=X_50228_ }
C {devices/lab_pin.sym} 64170 -32370 0 0 {name=p63485 lab=_85444_/CLK }
C {devices/lab_pin.sym} 64170 -32350 0 0 {name=p63486 lab=_51906_/Y }
C {devices/lab_pin.sym} 64350 -32370 0 1 {name=p63487 lab=_85925_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -32360 0 0 {name=X_85925_ }
C {devices/lab_pin.sym} 64170 -32230 0 0 {name=p63488 lab=_81048_/CLK }
C {devices/lab_pin.sym} 64170 -32210 0 0 {name=p63489 lab=_75407_/X }
C {devices/lab_pin.sym} 64350 -32230 0 1 {name=p63490 lab=_81048_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -32220 0 0 {name=X_81048_ }
C {devices/lab_pin.sym} 64220 -32090 0 0 {name=p63491 lab=clkbuf_9_503_0_CLK/X }
C {devices/lab_pin.sym} 64300 -32090 0 1 {name=p63492 lab=_85879_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 64260 -32090 0 0 {name=Xclkbuf_10_1006_0_CLK }
C {devices/lab_pin.sym} 64200 -31980 0 0 {name=p63493 lab=_86697_/Q }
C {devices/lab_pin.sym} 64200 -31940 0 0 {name=p63494 lab=_58873_/B }
C {devices/lab_pin.sym} 64320 -31960 0 1 {name=p63495 lab=_58873_/Y }
C {sky130_stdcells/nor2_4.sym} 64260 -31960 0 0 {name=X_58873_ }
C {devices/lab_pin.sym} 64220 -31830 0 0 {name=p63496 lab=_44181_/X }
C {devices/lab_pin.sym} 64300 -31830 0 1 {name=p63497 lab=_57824_/X }
C {sky130_stdcells/buf_2.sym} 64260 -31830 0 0 {name=X_57824_ }
C {devices/lab_pin.sym} 64180 -31730 0 0 {name=p63498 lab=_86252_/Q }
C {devices/lab_pin.sym} 64180 -31690 0 0 {name=p63499 lab=_50137_/X }
C {devices/lab_pin.sym} 64180 -31650 0 0 {name=p63500 lab=_50158_/Y }
C {devices/lab_pin.sym} 64340 -31690 0 1 {name=p63501 lab=_50159_/Y }
C {sky130_stdcells/o21ai_4.sym} 64260 -31690 0 0 {name=X_50159_ }
C {devices/lab_pin.sym} 64200 -31560 0 0 {name=p63502 lab=_88102_/Q }
C {devices/lab_pin.sym} 64200 -31520 0 0 {name=p63503 lab=_73869_/X }
C {devices/lab_pin.sym} 64320 -31540 0 1 {name=p63504 lab=_73870_/Y }
C {sky130_stdcells/nor2_4.sym} 64260 -31540 0 0 {name=X_73870_ }
C {devices/lab_pin.sym} 64170 -31410 0 0 {name=p63505 lab=_83311_/CLK }
C {devices/lab_pin.sym} 64170 -31390 0 0 {name=p63506 lab=_52268_/Y }
C {devices/lab_pin.sym} 64350 -31410 0 1 {name=p63507 lab=_85856_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -31400 0 0 {name=X_85856_ }
C {devices/lab_pin.sym} 64180 -31290 0 0 {name=p63508 lab=_72802_/X }
C {devices/lab_pin.sym} 64180 -31250 0 0 {name=p63509 lab=_72822_/C }
C {devices/lab_pin.sym} 64180 -31210 0 0 {name=p63510 lab=_72820_/X }
C {devices/lab_pin.sym} 64340 -31250 0 1 {name=p63511 lab=_72821_/X }
C {sky130_stdcells/a21o_4.sym} 64260 -31250 0 0 {name=X_72821_ }
C {devices/lab_pin.sym} 64170 -31110 0 0 {name=p63512 lab=_84807_/CLK }
C {devices/lab_pin.sym} 64170 -31090 0 0 {name=p63513 lab=_58695_/Y }
C {devices/lab_pin.sym} 64350 -31110 0 1 {name=p63514 lab=_84807_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -31100 0 0 {name=X_84807_ }
C {devices/lab_pin.sym} 64220 -30970 0 0 {name=p63515 lab=_57754_/X }
C {devices/lab_pin.sym} 64300 -30970 0 1 {name=p63516 lab=_59801_/A }
C {sky130_stdcells/buf_2.sym} 64260 -30970 0 0 {name=X_57755_ }
C {devices/lab_pin.sym} 64180 -30890 0 0 {name=p63517 lab=_42970_/X }
C {devices/lab_pin.sym} 64180 -30850 0 0 {name=p63518 lab=_42971_/X }
C {devices/lab_pin.sym} 64180 -30810 0 0 {name=p63519 lab=_40459_/X }
C {devices/lab_pin.sym} 64180 -30770 0 0 {name=p63520 lab=_87620_/Q }
C {devices/lab_pin.sym} 64180 -30730 0 0 {name=p63521 lab=_42976_/X }
C {devices/lab_pin.sym} 64340 -30810 0 1 {name=p63522 lab=_42981_/Y }
C {sky130_stdcells/o32ai_4.sym} 64260 -30810 0 0 {name=X_42981_ }
C {devices/lab_pin.sym} 64220 -30650 0 0 {name=p63523 lab=_55072_/A }
C {devices/lab_pin.sym} 64300 -30650 0 1 {name=p63524 lab=_54967_/X }
C {sky130_stdcells/buf_2.sym} 64260 -30650 0 0 {name=X_54967_ }
C {devices/lab_pin.sym} 64170 -30530 0 0 {name=p63525 lab=_85786_/CLK }
C {devices/lab_pin.sym} 64170 -30510 0 0 {name=p63526 lab=_52611_/Y }
C {devices/lab_pin.sym} 64350 -30530 0 1 {name=p63527 lab=_85787_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -30520 0 0 {name=X_85787_ }
C {devices/lab_pin.sym} 64170 -30390 0 0 {name=p63528 lab=_83001_/CLK }
C {devices/lab_pin.sym} 64170 -30370 0 0 {name=p63529 lab=_82999_/D }
C {devices/lab_pin.sym} 64350 -30390 0 1 {name=p63530 lab=_45558_/A }
C {sky130_stdcells/dfxtp_4.sym} 64260 -30380 0 0 {name=X_82999_ }
C {devices/lab_pin.sym} 64180 -30290 0 0 {name=p63531 lab=_44707_/X }
C {devices/lab_pin.sym} 64180 -30250 0 0 {name=p63532 lab=_44708_/X }
C {devices/lab_pin.sym} 64180 -30210 0 0 {name=p63533 lab=_40695_/Y }
C {devices/lab_pin.sym} 64180 -30170 0 0 {name=p63534 lab=_44719_/Y }
C {devices/lab_pin.sym} 64180 -30130 0 0 {name=p63535 lab=_44710_/X }
C {devices/lab_pin.sym} 64340 -30210 0 1 {name=p63536 lab=_86988_/D }
C {sky130_stdcells/o32ai_4.sym} 64260 -30210 0 0 {name=X_44720_ }
C {devices/lab_pin.sym} 64180 -30070 0 0 {name=p63537 lab=_56702_/X }
C {devices/lab_pin.sym} 64180 -30030 0 0 {name=p63538 lab=_56703_/X }
C {devices/lab_pin.sym} 64180 -29990 0 0 {name=p63539 lab=_56705_/Y }
C {devices/lab_pin.sym} 64340 -30030 0 1 {name=p63540 lab=_56706_/X }
C {sky130_stdcells/a21bo_4.sym} 64260 -30030 0 0 {name=X_56706_ }
C {devices/lab_pin.sym} 64180 -29910 0 0 {name=p63541 lab=_75519_/A }
C {devices/lab_pin.sym} 64180 -29870 0 0 {name=p63542 lab=_75516_/Y }
C {devices/lab_pin.sym} 64180 -29830 0 0 {name=p63543 lab=_75517_/Y }
C {devices/lab_pin.sym} 64340 -29870 0 1 {name=p63544 lab=_75540_/X }
C {sky130_stdcells/o21a_4.sym} 64260 -29870 0 0 {name=X_75540_ }
C {devices/lab_pin.sym} 64170 -29730 0 0 {name=p63545 lab=_87782_/CLK }
C {devices/lab_pin.sym} 64170 -29710 0 0 {name=p63546 lab=_43234_/Y }
C {devices/lab_pin.sym} 64350 -29730 0 1 {name=p63547 lab=_87526_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -29720 0 0 {name=X_87526_ }
C {devices/lab_pin.sym} 64220 -29590 0 0 {name=p63548 lab=_42013_/A }
C {devices/lab_pin.sym} 64300 -29590 0 1 {name=p63549 lab=_41932_/X }
C {sky130_stdcells/buf_2.sym} 64260 -29590 0 0 {name=X_41932_ }
C {devices/lab_pin.sym} 64180 -29490 0 0 {name=p63550 lab=_85542_/Q }
C {devices/lab_pin.sym} 64180 -29450 0 0 {name=p63551 lab=_53896_/X }
C {devices/lab_pin.sym} 64180 -29410 0 0 {name=p63552 lab=_53917_/Y }
C {devices/lab_pin.sym} 64340 -29450 0 1 {name=p63553 lab=_53918_/Y }
C {sky130_stdcells/o21ai_4.sym} 64260 -29450 0 0 {name=X_53918_ }
C {devices/lab_pin.sym} 64200 -29320 0 0 {name=p63554 lab=_73535_/A }
C {devices/lab_pin.sym} 64200 -29280 0 0 {name=p63555 lab=_65425_/B }
C {devices/lab_pin.sym} 64320 -29300 0 1 {name=p63556 lab=_72752_/X }
C {sky130_stdcells/and2_4.sym} 64260 -29300 0 0 {name=X_72752_ }
C {devices/lab_pin.sym} 64170 -29170 0 0 {name=p63557 lab=_83457_/CLK }
C {devices/lab_pin.sym} 64170 -29150 0 0 {name=p63558 lab=_84738_/D }
C {devices/lab_pin.sym} 64350 -29170 0 1 {name=p63559 lab=_84738_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -29160 0 0 {name=X_84738_ }
C {devices/lab_pin.sym} 64200 -29040 0 0 {name=p63560 lab=_57686_/A }
C {devices/lab_pin.sym} 64200 -29000 0 0 {name=p63561 lab=_57701_/A }
C {devices/lab_pin.sym} 64320 -29020 0 1 {name=p63562 lab=_57687_/A }
C {sky130_stdcells/nor2_4.sym} 64260 -29020 0 0 {name=X_57686_ }
C {devices/lab_pin.sym} 64200 -28900 0 0 {name=p63563 lab=_54893_/X }
C {devices/lab_pin.sym} 64200 -28860 0 0 {name=p63564 lab=_54898_/B }
C {devices/lab_pin.sym} 64320 -28880 0 1 {name=p63565 lab=_54898_/Y }
C {sky130_stdcells/nand2_4.sym} 64260 -28880 0 0 {name=X_54898_ }
C {devices/lab_pin.sym} 64180 -28770 0 0 {name=p63566 lab=_58294_/Y }
C {devices/lab_pin.sym} 64180 -28730 0 0 {name=p63567 lab=_71695_/X }
C {devices/lab_pin.sym} 64180 -28690 0 0 {name=p63568 lab=_71702_/Y }
C {devices/lab_pin.sym} 64340 -28730 0 1 {name=p63569 lab=_83405_/D }
C {sky130_stdcells/o21ai_4.sym} 64260 -28730 0 0 {name=X_71703_ }
C {devices/lab_pin.sym} 64180 -28610 0 0 {name=p63570 lab=_59417_/X }
C {devices/lab_pin.sym} 64180 -28570 0 0 {name=p63571 lab=_83345_/Q }
C {devices/lab_pin.sym} 64180 -28530 0 0 {name=p63572 lab=_59424_/Y }
C {devices/lab_pin.sym} 64340 -28570 0 1 {name=p63573 lab=_84737_/D }
C {sky130_stdcells/o21a_4.sym} 64260 -28570 0 0 {name=X_59425_ }
C {devices/lab_pin.sym} 64180 -28460 0 0 {name=p63574 lab=_41058_/Y }
C {devices/lab_pin.sym} 64180 -28420 0 0 {name=p63575 lab=_44648_/X }
C {devices/lab_pin.sym} 64180 -28380 0 0 {name=p63576 lab=_87017_/Q }
C {devices/lab_pin.sym} 64180 -28340 0 0 {name=p63577 lab=_44650_/X }
C {devices/lab_pin.sym} 64340 -28400 0 1 {name=p63578 lab=_87017_/D }
C {sky130_stdcells/a2bb2o_4.sym} 64260 -28400 0 0 {name=X_44651_ }
C {devices/lab_pin.sym} 64200 -28260 0 0 {name=p63579 lab=_56650_/B }
C {devices/lab_pin.sym} 64200 -28220 0 0 {name=p63580 lab=_55646_/X }
C {devices/lab_pin.sym} 64320 -28240 0 1 {name=p63581 lab=_56638_/B }
C {sky130_stdcells/nand2_4.sym} 64260 -28240 0 0 {name=X_56637_ }
C {devices/lab_pin.sym} 64200 -28120 0 0 {name=p63582 lab=_75465_/Y }
C {devices/lab_pin.sym} 64200 -28080 0 0 {name=p63583 lab=_75470_/Y }
C {devices/lab_pin.sym} 64320 -28100 0 1 {name=p63584 lab=_81052_/D }
C {sky130_stdcells/xor2_4.sym} 64260 -28100 0 0 {name=X_75471_ }
C {devices/lab_pin.sym} 64170 -27970 0 0 {name=p63585 lab=_87720_/CLK }
C {devices/lab_pin.sym} 64170 -27950 0 0 {name=p63586 lab=_43366_/Y }
C {devices/lab_pin.sym} 64350 -27970 0 1 {name=p63587 lab=_87457_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -27960 0 0 {name=X_87457_ }
C {devices/lab_pin.sym} 64180 -27850 0 0 {name=p63588 lab=_85556_/Q }
C {devices/lab_pin.sym} 64180 -27810 0 0 {name=p63589 lab=_53846_/X }
C {devices/lab_pin.sym} 64180 -27770 0 0 {name=p63590 lab=_53848_/Y }
C {devices/lab_pin.sym} 64340 -27810 0 1 {name=p63591 lab=_53849_/Y }
C {sky130_stdcells/o21ai_4.sym} 64260 -27810 0 0 {name=X_53849_ }
C {devices/lab_pin.sym} 64200 -27680 0 0 {name=p63592 lab=_41863_/A }
C {devices/lab_pin.sym} 64200 -27640 0 0 {name=p63593 lab=_41862_/Y }
C {devices/lab_pin.sym} 64320 -27660 0 1 {name=p63594 lab=_42626_/A }
C {sky130_stdcells/nor2_4.sym} 64260 -27660 0 0 {name=X_41863_ }
C {devices/lab_pin.sym} 64200 -27550 0 0 {name=p63595 lab=_72683_/A }
C {devices/lab_pin.sym} 64200 -27510 0 0 {name=p63596 lab=_72683_/B }
C {devices/lab_pin.sym} 64200 -27470 0 0 {name=p63597 lab=_55378_/X }
C {devices/lab_pin.sym} 64320 -27510 0 1 {name=p63598 lab=_72683_/Y }
C {sky130_stdcells/nand3_4.sym} 64260 -27510 0 0 {name=X_72683_ }
C {devices/lab_pin.sym} 64170 -27370 0 0 {name=p63599 lab=_84498_/CLK }
C {devices/lab_pin.sym} 64170 -27350 0 0 {name=p63600 lab=_60060_/X }
C {devices/lab_pin.sym} 64350 -27370 0 1 {name=p63601 lab=_84669_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -27360 0 0 {name=X_84669_ }
C {devices/lab_pin.sym} 64200 -27240 0 0 {name=p63602 lab=_77200_/A }
C {devices/lab_pin.sym} 64200 -27200 0 0 {name=p63603 lab=_82302_/D }
C {devices/lab_pin.sym} 64320 -27220 0 1 {name=p63604 lab=_77210_/X }
C {sky130_stdcells/or2_4.sym} 64260 -27220 0 0 {name=X_77210_ }
C {devices/lab_pin.sym} 64220 -27090 0 0 {name=p63605 lab=_43583_/Y }
C {devices/lab_pin.sym} 64300 -27090 0 1 {name=p63606 lab=_43602_/X }
C {sky130_stdcells/buf_2.sym} 64260 -27090 0 0 {name=X_43602_ }
C {devices/lab_pin.sym} 64180 -26990 0 0 {name=p63607 lab=_74419_/Y }
C {devices/lab_pin.sym} 64180 -26950 0 0 {name=p63608 lab=_74405_/X }
C {devices/lab_pin.sym} 64180 -26910 0 0 {name=p63609 lab=_74421_/X }
C {devices/lab_pin.sym} 64340 -26950 0 1 {name=p63610 lab=_74422_/Y }
C {sky130_stdcells/a21oi_4.sym} 64260 -26950 0 0 {name=X_74422_ }
C {devices/lab_pin.sym} 64170 -26810 0 0 {name=p63611 lab=_85800_/CLK }
C {devices/lab_pin.sym} 64170 -26790 0 0 {name=p63612 lab=_49333_/Y }
C {devices/lab_pin.sym} 64350 -26810 0 1 {name=p63613 lab=_86408_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -26800 0 0 {name=X_86408_ }
C {devices/lab_pin.sym} 64220 -26670 0 0 {name=p63614 lab=_40814_/A }
C {devices/lab_pin.sym} 64300 -26670 0 1 {name=p63615 lab=_40814_/X }
C {sky130_stdcells/buf_2.sym} 64260 -26670 0 0 {name=X_40814_ }
C {devices/lab_pin.sym} 64200 -26580 0 0 {name=p63616 lab=_47380_/A }
C {devices/lab_pin.sym} 64200 -26540 0 0 {name=p63617 lab=_47408_/B }
C {devices/lab_pin.sym} 64200 -26500 0 0 {name=p63618 lab=_47370_/C }
C {devices/lab_pin.sym} 64200 -26460 0 0 {name=p63619 lab=_53008_/D }
C {devices/lab_pin.sym} 64320 -26520 0 1 {name=p63620 lab=_47370_/X }
C {sky130_stdcells/and4_4.sym} 64260 -26520 0 0 {name=X_47370_ }
C {devices/lab_pin.sym} 64220 -26370 0 0 {name=p63621 lab=_71241_/A }
C {devices/lab_pin.sym} 64300 -26370 0 1 {name=p63622 lab=_71637_/A }
C {sky130_stdcells/buf_2.sym} 64260 -26370 0 0 {name=X_71634_ }
C {devices/lab_pin.sym} 64180 -26270 0 0 {name=p63623 lab=_59231_/X }
C {devices/lab_pin.sym} 64180 -26230 0 0 {name=p63624 lab=_85412_/Q }
C {devices/lab_pin.sym} 64180 -26190 0 0 {name=p63625 lab=_59355_/X }
C {devices/lab_pin.sym} 64340 -26230 0 1 {name=p63626 lab=_59356_/Y }
C {sky130_stdcells/o21ai_4.sym} 64260 -26230 0 0 {name=X_59356_ }
C {devices/lab_pin.sym} 64200 -26100 0 0 {name=p63627 lab=_78199_/A }
C {devices/lab_pin.sym} 64200 -26060 0 0 {name=p63628 lab=_78199_/B }
C {devices/lab_pin.sym} 64320 -26080 0 1 {name=p63629 lab=_78204_/A }
C {sky130_stdcells/xor2_4.sym} 64260 -26080 0 0 {name=X_78190_ }
C {devices/lab_pin.sym} 64180 -25990 0 0 {name=p63630 lab=_44554_/X }
C {devices/lab_pin.sym} 64180 -25950 0 0 {name=p63631 lab=_44555_/X }
C {devices/lab_pin.sym} 64180 -25910 0 0 {name=p63632 lab=_40898_/Y }
C {devices/lab_pin.sym} 64180 -25870 0 0 {name=p63633 lab=_44581_/Y }
C {devices/lab_pin.sym} 64180 -25830 0 0 {name=p63634 lab=_44557_/X }
C {devices/lab_pin.sym} 64340 -25910 0 1 {name=p63635 lab=_87046_/D }
C {sky130_stdcells/o32ai_4.sym} 64260 -25910 0 0 {name=X_44582_ }
C {devices/lab_pin.sym} 64220 -25750 0 0 {name=p63636 lab=_56567_/Y }
C {devices/lab_pin.sym} 64300 -25750 0 1 {name=p63637 lab=_56568_/X }
C {sky130_stdcells/buf_2.sym} 64260 -25750 0 0 {name=X_56568_ }
C {devices/lab_pin.sym} 64220 -25630 0 0 {name=p63638 lab=_41793_/Y }
C {devices/lab_pin.sym} 64300 -25630 0 1 {name=p63639 lab=_41794_/Y }
C {sky130_stdcells/inv_2.sym} 64260 -25630 0 0 {name=X_41794_ }
C {devices/lab_pin.sym} 64170 -25510 0 0 {name=p63640 lab=_87195_/CLK }
C {devices/lab_pin.sym} 64170 -25490 0 0 {name=p63641 lab=_43502_/X }
C {devices/lab_pin.sym} 64350 -25510 0 1 {name=p63642 lab=_87388_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -25500 0 0 {name=X_87388_ }
C {sky130_stdcells/decap_3.sym} 64260 -25340 0 0 {name=XPHY_8 }
C {devices/lab_pin.sym} 64220 -25190 0 0 {name=p63643 lab=_53969_/A }
C {devices/lab_pin.sym} 64300 -25190 0 1 {name=p63644 lab=_50755_/A }
C {sky130_stdcells/buf_2.sym} 64260 -25190 0 0 {name=X_46321_ }
C {devices/lab_pin.sym} 64220 -25070 0 0 {name=p63645 lab=_84882_/Q }
C {devices/lab_pin.sym} 64300 -25070 0 1 {name=p63646 lab=_63348_/A }
C {sky130_stdcells/inv_2.sym} 64260 -25070 0 0 {name=X_58307_ }
C {devices/lab_pin.sym} 64200 -24970 0 0 {name=p63647 lab=_77141_/A }
C {devices/lab_pin.sym} 64200 -24930 0 0 {name=p63648 lab=_77141_/B }
C {devices/lab_pin.sym} 64200 -24890 0 0 {name=p63649 lab=_77141_/C }
C {devices/lab_pin.sym} 64320 -24930 0 1 {name=p63650 lab=_77142_/B }
C {sky130_stdcells/and3_4.sym} 64260 -24930 0 0 {name=X_77141_ }
C {devices/lab_pin.sym} 64220 -24790 0 0 {name=p63651 lab=_43466_/X }
C {devices/lab_pin.sym} 64300 -24790 0 1 {name=p63652 lab=_43533_/X }
C {sky130_stdcells/buf_2.sym} 64260 -24790 0 0 {name=X_43533_ }
C {devices/lab_pin.sym} 64220 -24670 0 0 {name=p63653 lab=_55498_/X }
C {devices/lab_pin.sym} 64300 -24670 0 1 {name=p63654 lab=_55524_/A }
C {sky130_stdcells/buf_2.sym} 64260 -24670 0 0 {name=X_55519_ }
C {devices/lab_pin.sym} 64200 -24560 0 0 {name=p63655 lab=_56127_/B }
C {devices/lab_pin.sym} 64200 -24520 0 0 {name=p63656 lab=_73050_/A }
C {devices/lab_pin.sym} 64320 -24540 0 1 {name=p63657 lab=_74353_/Y }
C {sky130_stdcells/nor2_4.sym} 64260 -24540 0 0 {name=X_74353_ }
C {devices/lab_pin.sym} 64170 -24410 0 0 {name=p63658 lab=_86340_/CLK }
C {devices/lab_pin.sym} 64170 -24390 0 0 {name=p63659 lab=_49702_/Y }
C {devices/lab_pin.sym} 64350 -24410 0 1 {name=p63660 lab=_59372_/B }
C {sky130_stdcells/dfxtp_4.sym} 64260 -24400 0 0 {name=X_86339_ }
C {devices/lab_pin.sym} 64180 -24310 0 0 {name=p63661 lab=_40687_/X }
C {devices/lab_pin.sym} 64180 -24270 0 0 {name=p63662 lab=_40688_/X }
C {devices/lab_pin.sym} 64180 -24230 0 0 {name=p63663 lab=_40743_/X }
C {devices/lab_pin.sym} 64180 -24190 0 0 {name=p63664 lab=_88343_/Q }
C {devices/lab_pin.sym} 64180 -24150 0 0 {name=p63665 lab=_40744_/X }
C {devices/lab_pin.sym} 64340 -24230 0 1 {name=p63666 lab=_40746_/A }
C {sky130_stdcells/o32ai_4.sym} 64260 -24230 0 0 {name=X_40745_ }
C {devices/lab_pin.sym} 64180 -24090 0 0 {name=p63667 lab=_59199_/X }
C {devices/lab_pin.sym} 64180 -24050 0 0 {name=p63668 lab=_85738_/Q }
C {devices/lab_pin.sym} 64180 -24010 0 0 {name=p63669 lab=_59263_/X }
C {devices/lab_pin.sym} 64340 -24050 0 1 {name=p63670 lab=_59287_/X }
C {sky130_stdcells/o21a_4.sym} 64260 -24050 0 0 {name=X_59287_ }
C {devices/lab_pin.sym} 64200 -23930 0 0 {name=p63671 lab=_71859_/A }
C {devices/lab_pin.sym} 64200 -23890 0 0 {name=p63672 lab=_71553_/B }
C {devices/lab_pin.sym} 64200 -23850 0 0 {name=p63673 lab=_71558_/X }
C {devices/lab_pin.sym} 64320 -23890 0 1 {name=p63674 lab=_71565_/Y }
C {sky130_stdcells/nor3_4.sym} 64260 -23890 0 0 {name=X_71565_ }
C {devices/lab_pin.sym} 64220 -23750 0 0 {name=p63675 lab=_56528_/A }
C {devices/lab_pin.sym} 64300 -23750 0 1 {name=p63676 lab=_56499_/X }
C {sky130_stdcells/buf_2.sym} 64260 -23750 0 0 {name=X_56499_ }
C {devices/lab_pin.sym} 64180 -23650 0 0 {name=p63677 lab=_49018_/X }
C {devices/lab_pin.sym} 64180 -23610 0 0 {name=p63678 lab=_48529_/Y }
C {devices/lab_pin.sym} 64180 -23570 0 0 {name=p63679 lab=_49039_/Y }
C {devices/lab_pin.sym} 64340 -23610 0 1 {name=p63680 lab=_49041_/A }
C {sky130_stdcells/a21o_4.sym} 64260 -23610 0 0 {name=X_49040_ }
C {devices/lab_pin.sym} 64200 -23480 0 0 {name=p63681 lab=_73206_/X }
C {devices/lab_pin.sym} 64200 -23440 0 0 {name=p63682 lab=_85868_/Q }
C {devices/lab_pin.sym} 64320 -23460 0 1 {name=p63683 lab=_73304_/X }
C {sky130_stdcells/and2_4.sym} 64260 -23460 0 0 {name=X_73304_ }
C {devices/lab_pin.sym} 64220 -23330 0 0 {name=p63684 lab=_57563_/A }
C {devices/lab_pin.sym} 64300 -23330 0 1 {name=p63685 lab=_46280_/A }
C {sky130_stdcells/buf_2.sym} 64260 -23330 0 0 {name=X_46252_ }
C {devices/lab_pin.sym} 64200 -23230 0 0 {name=p63686 lab=_70511_/A }
C {devices/lab_pin.sym} 64200 -23190 0 0 {name=p63687 lab=_70947_/B }
C {devices/lab_pin.sym} 64200 -23150 0 0 {name=p63688 lab=_70508_/X }
C {devices/lab_pin.sym} 64320 -23190 0 1 {name=p63689 lab=_70516_/Y }
C {sky130_stdcells/nand3_4.sym} 64260 -23190 0 0 {name=X_70516_ }
C {devices/lab_pin.sym} 64200 -23060 0 0 {name=p63690 lab=_58237_/X }
C {devices/lab_pin.sym} 64200 -23020 0 0 {name=p63691 lab=_58238_/B }
C {devices/lab_pin.sym} 64320 -23040 0 1 {name=p63692 lab=_58238_/Y }
C {sky130_stdcells/nor2_4.sym} 64260 -23040 0 0 {name=X_58238_ }
C {sky130_stdcells/decap_3.sym} 64260 -22880 0 0 {name=XPHY_640 }
C {devices/lab_pin.sym} 64200 -22740 0 0 {name=p63693 lab=_77068_/Y }
C {devices/lab_pin.sym} 64200 -22700 0 0 {name=p63694 lab=_77072_/B }
C {devices/lab_pin.sym} 64320 -22720 0 1 {name=p63695 lab=_77084_/A }
C {sky130_stdcells/nand2_4.sym} 64260 -22720 0 0 {name=X_77072_ }
C {devices/lab_pin.sym} 64180 -22620 0 0 {name=p63696 lab=_41647_/X }
C {devices/lab_pin.sym} 64180 -22580 0 0 {name=p63697 lab=_43446_/X }
C {devices/lab_pin.sym} 64180 -22540 0 0 {name=p63698 lab=_87408_/Q }
C {devices/lab_pin.sym} 64180 -22500 0 0 {name=p63699 lab=_43447_/X }
C {devices/lab_pin.sym} 64340 -22560 0 1 {name=p63700 lab=_87408_/D }
C {sky130_stdcells/a2bb2o_4.sym} 64260 -22560 0 0 {name=X_43464_ }
C {devices/lab_pin.sym} 64200 -22430 0 0 {name=p63701 lab=_72714_/A }
C {devices/lab_pin.sym} 64200 -22390 0 0 {name=p63702 lab=_72714_/B }
C {devices/lab_pin.sym} 64200 -22350 0 0 {name=p63703 lab=_74284_/C }
C {devices/lab_pin.sym} 64320 -22390 0 1 {name=p63704 lab=_74284_/Y }
C {sky130_stdcells/nand3_4.sym} 64260 -22390 0 0 {name=X_74284_ }
C {sky130_stdcells/decap_3.sym} 64260 -22220 0 0 {name=XPHY_651 }
C {devices/lab_pin.sym} 64200 -22080 0 0 {name=p63705 lab=_40676_/A }
C {devices/lab_pin.sym} 64200 -22040 0 0 {name=p63706 lab=_40710_/B }
C {devices/lab_pin.sym} 64320 -22060 0 1 {name=p63707 lab=_40676_/X }
C {sky130_stdcells/or2_4.sym} 64260 -22060 0 0 {name=X_40676_ }
C {devices/lab_pin.sym} 64200 -21950 0 0 {name=p63708 lab=_71488_/X }
C {devices/lab_pin.sym} 64200 -21910 0 0 {name=p63709 lab=_70476_/X }
C {devices/lab_pin.sym} 64200 -21870 0 0 {name=p63710 lab=_71496_/C }
C {devices/lab_pin.sym} 64320 -21910 0 1 {name=p63711 lab=_71496_/X }
C {sky130_stdcells/and3_4.sym} 64260 -21910 0 0 {name=X_71496_ }
C {sky130_stdcells/decap_3.sym} 64260 -21740 0 0 {name=XPHY_662 }
C {sky130_stdcells/decap_3.sym} 64260 -21560 0 0 {name=XPHY_673 }
C {devices/lab_pin.sym} 64220 -21410 0 0 {name=p63712 lab=_64434_/B }
C {devices/lab_pin.sym} 64300 -21410 0 1 {name=p63713 lab=_61558_/B }
C {sky130_stdcells/buf_2.sym} 64260 -21410 0 0 {name=X_45203_ }
C {devices/lab_pin.sym} 64200 -21300 0 0 {name=p63714 lab=_76023_/A }
C {devices/lab_pin.sym} 64200 -21260 0 0 {name=p63715 lab=_76023_/B }
C {devices/lab_pin.sym} 64320 -21280 0 1 {name=p63716 lab=_76023_/Y }
C {sky130_stdcells/nand2_4.sym} 64260 -21280 0 0 {name=X_76023_ }
C {devices/lab_pin.sym} 64170 -21150 0 0 {name=p63717 lab=_88006_/CLK }
C {devices/lab_pin.sym} 64170 -21130 0 0 {name=p63718 lab=_88009_/D }
C {devices/lab_pin.sym} 64350 -21150 0 1 {name=p63719 lab=_88009_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -21140 0 0 {name=X_88009_ }
C {devices/lab_pin.sym} 64220 -21010 0 0 {name=p63720 lab=_41911_/A }
C {devices/lab_pin.sym} 64300 -21010 0 1 {name=p63721 lab=_42415_/X }
C {sky130_stdcells/buf_2.sym} 64260 -21010 0 0 {name=X_42415_ }
C {sky130_stdcells/decap_3.sym} 64260 -20860 0 0 {name=XPHY_684 }
C {devices/lab_pin.sym} 64200 -20720 0 0 {name=p63722 lab=_73260_/A }
C {devices/lab_pin.sym} 64200 -20680 0 0 {name=p63723 lab=_86479_/Q }
C {devices/lab_pin.sym} 64320 -20700 0 1 {name=p63724 lab=_73235_/X }
C {sky130_stdcells/and2_4.sym} 64260 -20700 0 0 {name=X_73235_ }
C {devices/lab_pin.sym} 64200 -20580 0 0 {name=p63725 lab=_86764_/Q }
C {devices/lab_pin.sym} 64200 -20540 0 0 {name=p63726 lab=_46195_/A }
C {devices/lab_pin.sym} 64320 -20560 0 1 {name=p63727 lab=_46183_/X }
C {sky130_stdcells/or2_4.sym} 64260 -20560 0 0 {name=X_46183_ }
C {devices/lab_pin.sym} 64220 -20430 0 0 {name=p63728 lab=_71005_/A }
C {devices/lab_pin.sym} 64300 -20430 0 1 {name=p63729 lab=_70954_/B }
C {sky130_stdcells/buf_2.sym} 64260 -20430 0 0 {name=X_70447_ }
C {devices/lab_pin.sym} 64180 -20330 0 0 {name=p63730 lab=_58153_/X }
C {devices/lab_pin.sym} 64180 -20290 0 0 {name=p63731 lab=_83492_/Q }
C {devices/lab_pin.sym} 64180 -20250 0 0 {name=p63732 lab=_58168_/Y }
C {devices/lab_pin.sym} 64340 -20290 0 1 {name=p63733 lab=_58169_/X }
C {sky130_stdcells/o21a_4.sym} 64260 -20290 0 0 {name=X_58169_ }
C {sky130_stdcells/decap_3.sym} 64260 -20120 0 0 {name=XPHY_695 }
C {devices/lab_pin.sym} 64180 -20000 0 0 {name=p63734 lab=_41465_/X }
C {devices/lab_pin.sym} 64180 -19960 0 0 {name=p63735 lab=_43386_/X }
C {devices/lab_pin.sym} 64180 -19920 0 0 {name=p63736 lab=_87442_/Q }
C {devices/lab_pin.sym} 64180 -19880 0 0 {name=p63737 lab=_43388_/X }
C {devices/lab_pin.sym} 64340 -19940 0 1 {name=p63738 lab=_87442_/D }
C {sky130_stdcells/a2bb2o_4.sym} 64260 -19940 0 0 {name=X_43395_ }
C {devices/lab_pin.sym} 64220 -19790 0 0 {name=p63739 lab=_60199_/X }
C {devices/lab_pin.sym} 64300 -19790 0 1 {name=p63740 lab=_60227_/A }
C {sky130_stdcells/buf_2.sym} 64260 -19790 0 0 {name=X_60200_ }
C {devices/lab_pin.sym} 64220 -19670 0 0 {name=p63741 lab=_45284_/A }
C {devices/lab_pin.sym} 64300 -19670 0 1 {name=p63742 lab=_45134_/X }
C {sky130_stdcells/buf_2.sym} 64260 -19670 0 0 {name=X_45134_ }
C {devices/lab_pin.sym} 64220 -19550 0 0 {name=p63743 lab=_42397_/A }
C {devices/lab_pin.sym} 64300 -19550 0 1 {name=p63744 lab=_42346_/X }
C {sky130_stdcells/buf_2.sym} 64260 -19550 0 0 {name=X_42346_ }
C {devices/lab_pin.sym} 64220 -19430 0 0 {name=p63745 lab=_61180_/A }
C {devices/lab_pin.sym} 64300 -19430 0 1 {name=p63746 lab=_64263_/A }
C {sky130_stdcells/buf_2.sym} 64260 -19430 0 0 {name=X_61180_ }
C {devices/lab_pin.sym} 64200 -19320 0 0 {name=p63747 lab=_73386_/A }
C {devices/lab_pin.sym} 64200 -19280 0 0 {name=p63748 lab=_86514_/Q }
C {devices/lab_pin.sym} 64320 -19300 0 1 {name=p63749 lab=_73166_/X }
C {sky130_stdcells/and2_4.sym} 64260 -19300 0 0 {name=X_73166_ }
C {devices/lab_pin.sym} 64220 -19170 0 0 {name=p63750 lab=_71054_/A }
C {devices/lab_pin.sym} 64300 -19170 0 1 {name=p63751 lab=_74523_/A }
C {sky130_stdcells/buf_2.sym} 64260 -19170 0 0 {name=X_70378_ }
C {devices/lab_pin.sym} 64220 -19050 0 0 {name=p63752 lab=clkbuf_9_336_0_CLK/X }
C {devices/lab_pin.sym} 64300 -19050 0 1 {name=p63753 lab=_88158_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 64260 -19050 0 0 {name=Xclkbuf_10_673_0_CLK }
C {devices/lab_pin.sym} 64180 -18970 0 0 {name=p63754 lab=_59875_/X }
C {devices/lab_pin.sym} 64180 -18930 0 0 {name=p63755 lab=_62194_/A }
C {devices/lab_pin.sym} 64180 -18890 0 0 {name=p63756 lab=_60129_/Y }
C {devices/lab_pin.sym} 64180 -18850 0 0 {name=p63757 lab=_59969_/X }
C {devices/lab_pin.sym} 64180 -18810 0 0 {name=p63758 lab=_60130_/X }
C {devices/lab_pin.sym} 64340 -18890 0 1 {name=p63759 lab=_84657_/D }
C {sky130_stdcells/o41a_4.sym} 64260 -18890 0 0 {name=X_60131_ }
C {devices/lab_pin.sym} 64220 -18730 0 0 {name=p63760 lab=_57696_/X }
C {devices/lab_pin.sym} 64300 -18730 0 1 {name=p63761 lab=_72193_/B }
C {sky130_stdcells/buf_2.sym} 64260 -18730 0 0 {name=X_72117_ }
C {devices/lab_pin.sym} 64220 -18610 0 0 {name=p63762 lab=_49915_/A }
C {devices/lab_pin.sym} 64300 -18610 0 1 {name=p63763 lab=_49943_/B }
C {sky130_stdcells/buf_2.sym} 64260 -18610 0 0 {name=X_49942_ }
C {devices/lab_pin.sym} 64180 -18510 0 0 {name=p63764 lab=_55900_/B }
C {devices/lab_pin.sym} 64180 -18470 0 0 {name=p63765 lab=_45044_/X }
C {devices/lab_pin.sym} 64180 -18430 0 0 {name=p63766 lab=_45004_/X }
C {devices/lab_pin.sym} 64340 -18470 0 1 {name=p63767 lab=_45065_/X }
C {sky130_stdcells/o21a_4.sym} 64260 -18470 0 0 {name=X_45065_ }
C {devices/lab_pin.sym} 64180 -18370 0 0 {name=p63768 lab=_42252_/X }
C {devices/lab_pin.sym} 64180 -18330 0 0 {name=p63769 lab=_42275_/X }
C {devices/lab_pin.sym} 64180 -18290 0 0 {name=p63770 lab=_41515_/X }
C {devices/lab_pin.sym} 64180 -18250 0 0 {name=p63771 lab=_87944_/Q }
C {devices/lab_pin.sym} 64180 -18210 0 0 {name=p63772 lab=_42276_/X }
C {devices/lab_pin.sym} 64340 -18290 0 1 {name=p63773 lab=_42277_/Y }
C {sky130_stdcells/o32ai_4.sym} 64260 -18290 0 0 {name=X_42277_ }
C {devices/lab_pin.sym} 64200 -18140 0 0 {name=p63774 lab=_82253_/Q }
C {devices/lab_pin.sym} 64200 -18100 0 0 {name=p63775 lab=_81965_/Q }
C {devices/lab_pin.sym} 64320 -18120 0 1 {name=p63776 lab=_78043_/A }
C {sky130_stdcells/xnor2_4.sym} 64260 -18120 0 0 {name=X_77974_ }
C {devices/lab_pin.sym} 64180 -18020 0 0 {name=p63777 lab=_72963_/X }
C {devices/lab_pin.sym} 64180 -17980 0 0 {name=p63778 lab=_83069_/Q }
C {devices/lab_pin.sym} 64180 -17940 0 0 {name=p63779 lab=_73015_/X }
C {devices/lab_pin.sym} 64180 -17900 0 0 {name=p63780 lab=_73096_/X }
C {devices/lab_pin.sym} 64340 -17960 0 1 {name=p63781 lab=_73097_/X }
C {sky130_stdcells/a211o_4.sym} 64260 -17960 0 0 {name=X_73097_ }
C {devices/lab_pin.sym} 64220 -17810 0 0 {name=p63782 lab=clkbuf_8_82_0_CLK/X }
C {devices/lab_pin.sym} 64300 -17810 0 1 {name=p63783 lab=clkbuf_9_164_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 64260 -17810 0 0 {name=Xclkbuf_9_164_0_CLK }
C {devices/lab_pin.sym} 64220 -17690 0 0 {name=p63784 lab=clkbuf_8_45_0_CLK/X }
C {devices/lab_pin.sym} 64300 -17690 0 1 {name=p63785 lab=clkbuf_9_91_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 64260 -17690 0 0 {name=Xclkbuf_9_91_0_CLK }
C {devices/lab_pin.sym} 64220 -17570 0 0 {name=p63786 lab=_68617_/A }
C {devices/lab_pin.sym} 64300 -17570 0 1 {name=p63787 lab=_57848_/A }
C {sky130_stdcells/buf_2.sym} 64260 -17570 0 0 {name=X_44016_ }
C {devices/lab_pin.sym} 64200 -17460 0 0 {name=p63788 lab=_79713_/A }
C {devices/lab_pin.sym} 64200 -17420 0 0 {name=p63789 lab=_79713_/B }
C {devices/lab_pin.sym} 64320 -17440 0 1 {name=p63790 lab=_79719_/B }
C {sky130_stdcells/xor2_4.sym} 64260 -17440 0 0 {name=X_79713_ }
C {devices/lab_pin.sym} 64200 -17320 0 0 {name=p63791 lab=_41228_/A }
C {devices/lab_pin.sym} 64200 -17280 0 0 {name=p63792 lab=_41197_/B }
C {devices/lab_pin.sym} 64320 -17300 0 1 {name=p63793 lab=_41228_/X }
C {sky130_stdcells/or2_4.sym} 64260 -17300 0 0 {name=X_41228_ }
C {devices/lab_pin.sym} 64180 -17190 0 0 {name=p63794 lab=_59977_/A }
C {devices/lab_pin.sym} 64180 -17150 0 0 {name=p63795 lab=_60091_/B }
C {devices/lab_pin.sym} 64180 -17110 0 0 {name=p63796 lab=_59938_/Y }
C {devices/lab_pin.sym} 64340 -17150 0 1 {name=p63797 lab=_60062_/X }
C {sky130_stdcells/o21a_4.sym} 64260 -17150 0 0 {name=X_60062_ }
C {devices/lab_pin.sym} 64220 -17010 0 0 {name=p63798 lab=_71964_/A }
C {devices/lab_pin.sym} 64300 -17010 0 1 {name=p63799 lab=_72048_/X }
C {sky130_stdcells/buf_2.sym} 64260 -17010 0 0 {name=X_72048_ }
C {devices/lab_pin.sym} 64220 -16890 0 0 {name=p63800 lab=_81599_/Q }
C {devices/lab_pin.sym} 64300 -16890 0 1 {name=p63801 lab=_76926_/B }
C {sky130_stdcells/inv_2.sym} 64260 -16890 0 0 {name=X_76925_ }
C {devices/lab_pin.sym} 64180 -16790 0 0 {name=p63802 lab=_49869_/Y }
C {devices/lab_pin.sym} 64180 -16750 0 0 {name=p63803 lab=_49870_/X }
C {devices/lab_pin.sym} 64180 -16710 0 0 {name=p63804 lab=_49872_/X }
C {devices/lab_pin.sym} 64340 -16750 0 1 {name=p63805 lab=_86308_/D }
C {sky130_stdcells/a21oi_4.sym} 64260 -16750 0 0 {name=X_49873_ }
C {devices/lab_pin.sym} 64180 -16630 0 0 {name=p63806 lab=_48821_/Y }
C {devices/lab_pin.sym} 64180 -16590 0 0 {name=p63807 lab=_48813_/X }
C {devices/lab_pin.sym} 64180 -16550 0 0 {name=p63808 lab=_48823_/X }
C {devices/lab_pin.sym} 64340 -16590 0 1 {name=p63809 lab=_48824_/Y }
C {sky130_stdcells/a21oi_4.sym} 64260 -16590 0 0 {name=X_48824_ }
C {devices/lab_pin.sym} 64220 -16450 0 0 {name=p63810 lab=clkbuf_9_344_0_CLK/X }
C {devices/lab_pin.sym} 64300 -16450 0 1 {name=p63811 lab=_88215_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 64260 -16450 0 0 {name=Xclkbuf_10_688_0_CLK }
C {devices/lab_pin.sym} 64180 -16350 0 0 {name=p63812 lab=_79642_/Y }
C {devices/lab_pin.sym} 64180 -16310 0 0 {name=p63813 lab=_79624_/B }
C {devices/lab_pin.sym} 64180 -16270 0 0 {name=p63814 lab=_79643_/X }
C {devices/lab_pin.sym} 64340 -16310 0 1 {name=p63815 lab=_79645_/B }
C {sky130_stdcells/o21ai_4.sym} 64260 -16310 0 0 {name=X_79644_ }
C {devices/lab_pin.sym} 64200 -16180 0 0 {name=p63816 lab=_41159_/A }
C {devices/lab_pin.sym} 64200 -16140 0 0 {name=p63817 lab=_40639_/A }
C {devices/lab_pin.sym} 64320 -16160 0 1 {name=p63818 lab=_41159_/X }
C {sky130_stdcells/or2_4.sym} 64260 -16160 0 0 {name=X_41159_ }
C {devices/lab_pin.sym} 64200 -16050 0 0 {name=p63819 lab=_64870_/A }
C {devices/lab_pin.sym} 64200 -16010 0 0 {name=p63820 lab=_64870_/B }
C {devices/lab_pin.sym} 64200 -15970 0 0 {name=p63821 lab=_64870_/C }
C {devices/lab_pin.sym} 64320 -16010 0 1 {name=p63822 lab=_64870_/Y }
C {sky130_stdcells/nor3_4.sym} 64260 -16010 0 0 {name=X_64870_ }
C {devices/lab_pin.sym} 64220 -15870 0 0 {name=p63823 lab=_81497_/Q }
C {devices/lab_pin.sym} 64300 -15870 0 1 {name=p63824 lab=_76858_/A }
C {sky130_stdcells/inv_2.sym} 64260 -15870 0 0 {name=X_76856_ }
C {devices/lab_pin.sym} 64200 -15780 0 0 {name=p63825 lab=_61386_/B }
C {devices/lab_pin.sym} 64200 -15740 0 0 {name=p63826 lab=_63790_/X }
C {devices/lab_pin.sym} 64200 -15700 0 0 {name=p63827 lab=_63757_/C }
C {devices/lab_pin.sym} 64200 -15660 0 0 {name=p63828 lab=_63776_/X }
C {devices/lab_pin.sym} 64320 -15720 0 1 {name=p63829 lab=_63821_/Y }
C {sky130_stdcells/nand4_4.sym} 64260 -15720 0 0 {name=X_63821_ }
C {devices/lab_pin.sym} 64200 -15580 0 0 {name=p63830 lab=_75807_/A }
C {devices/lab_pin.sym} 64200 -15540 0 0 {name=p63831 lab=_80796_/D }
C {devices/lab_pin.sym} 64320 -15560 0 1 {name=p63832 lab=_75832_/B }
C {sky130_stdcells/xor2_4.sym} 64260 -15560 0 0 {name=X_75807_ }
C {devices/lab_pin.sym} 64220 -15430 0 0 {name=p63833 lab=_48755_/A }
C {devices/lab_pin.sym} 64300 -15430 0 1 {name=p63834 lab=_48837_/A }
C {sky130_stdcells/buf_2.sym} 64260 -15430 0 0 {name=X_48755_ }
C {devices/lab_pin.sym} 64220 -15310 0 0 {name=p63835 lab=clkbuf_8_89_0_CLK/X }
C {devices/lab_pin.sym} 64300 -15310 0 1 {name=p63836 lab=clkbuf_9_179_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 64260 -15310 0 0 {name=Xclkbuf_9_179_0_CLK }
C {devices/lab_pin.sym} 64200 -15210 0 0 {name=p63837 lab=_79565_/Y }
C {devices/lab_pin.sym} 64200 -15170 0 0 {name=p63838 lab=_79576_/B }
C {devices/lab_pin.sym} 64200 -15130 0 0 {name=p63839 lab=_79576_/A }
C {devices/lab_pin.sym} 64320 -15170 0 1 {name=p63840 lab=_79575_/Y }
C {sky130_stdcells/nand3_4.sym} 64260 -15170 0 0 {name=X_79575_ }
C {devices/lab_pin.sym} 64180 -15070 0 0 {name=p63841 lab=_44857_/X }
C {devices/lab_pin.sym} 64180 -15030 0 0 {name=p63842 lab=_44865_/X }
C {devices/lab_pin.sym} 64180 -14990 0 0 {name=p63843 lab=_40370_/X }
C {devices/lab_pin.sym} 64180 -14950 0 0 {name=p63844 lab=_66618_/B }
C {devices/lab_pin.sym} 64180 -14910 0 0 {name=p63845 lab=_44858_/X }
C {devices/lab_pin.sym} 64340 -14990 0 1 {name=p63846 lab=_45967_/Y }
C {sky130_stdcells/o32ai_4.sym} 64260 -14990 0 0 {name=X_45967_ }
C {devices/lab_pin.sym} 64200 -14840 0 0 {name=p63847 lab=_76772_/Y }
C {devices/lab_pin.sym} 64200 -14800 0 0 {name=p63848 lab=_76773_/Y }
C {devices/lab_pin.sym} 64320 -14820 0 1 {name=p63849 lab=_76787_/Y }
C {sky130_stdcells/nor2_4.sym} 64260 -14820 0 0 {name=X_76787_ }
C {devices/lab_pin.sym} 64180 -14720 0 0 {name=p63850 lab=_73930_/X }
C {devices/lab_pin.sym} 64180 -14680 0 0 {name=p63851 lab=_84975_/Q }
C {devices/lab_pin.sym} 64180 -14640 0 0 {name=p63852 lab=_45885_/X }
C {devices/lab_pin.sym} 64180 -14600 0 0 {name=p63853 lab=_73998_/X }
C {devices/lab_pin.sym} 64340 -14660 0 1 {name=p63854 lab=_73999_/X }
C {sky130_stdcells/a211o_4.sym} 64260 -14660 0 0 {name=X_73999_ }
C {devices/lab_pin.sym} 64200 -14520 0 0 {name=p63855 lab=_47696_/A }
C {devices/lab_pin.sym} 64200 -14480 0 0 {name=p63856 lab=_53200_/B }
C {devices/lab_pin.sym} 64320 -14500 0 1 {name=p63857 lab=_47706_/Y }
C {sky130_stdcells/nand2_4.sym} 64260 -14500 0 0 {name=X_47706_ }
C {devices/lab_pin.sym} 64220 -14370 0 0 {name=p63858 lab=_66540_/A }
C {devices/lab_pin.sym} 64300 -14370 0 1 {name=p63859 lab=_66540_/X }
C {sky130_stdcells/buf_2.sym} 64260 -14370 0 0 {name=X_66540_ }
C {devices/lab_pin.sym} 64200 -14270 0 0 {name=p63860 lab=_78522_/Y }
C {devices/lab_pin.sym} 64200 -14230 0 0 {name=p63861 lab=_78526_/B }
C {devices/lab_pin.sym} 64200 -14190 0 0 {name=p63862 lab=_78526_/C }
C {devices/lab_pin.sym} 64320 -14230 0 1 {name=p63863 lab=_78528_/A }
C {sky130_stdcells/or3_4.sym} 64260 -14230 0 0 {name=X_78526_ }
C {devices/lab_pin.sym} 64220 -14090 0 0 {name=p63864 lab=_80672_/Q }
C {devices/lab_pin.sym} 64300 -14090 0 1 {name=p63865 lab=_45153_/A }
C {sky130_stdcells/buf_2.sym} 64260 -14090 0 0 {name=X_44918_ }
C {devices/lab_pin.sym} 64220 -13970 0 0 {name=p63866 lab=_63751_/X }
C {devices/lab_pin.sym} 64300 -13970 0 1 {name=p63867 lab=_64177_/D }
C {sky130_stdcells/buf_2.sym} 64260 -13970 0 0 {name=X_63752_ }
C {devices/lab_pin.sym} 64180 -13870 0 0 {name=p63868 lab=_75727_/A }
C {devices/lab_pin.sym} 64180 -13830 0 0 {name=p63869 lab=_75726_/Y }
C {devices/lab_pin.sym} 64180 -13790 0 0 {name=p63870 lab=_75737_/X }
C {devices/lab_pin.sym} 64340 -13830 0 1 {name=p63871 lab=_75738_/Y }
C {sky130_stdcells/a21oi_4.sym} 64260 -13830 0 0 {name=X_75738_ }
C {devices/lab_pin.sym} 64220 -13690 0 0 {name=p63872 lab=_81764_/Q }
C {devices/lab_pin.sym} 64300 -13690 0 1 {name=p63873 lab=_48687_/A }
C {sky130_stdcells/inv_2.sym} 64260 -13690 0 0 {name=X_48686_ }
C {devices/lab_pin.sym} 64220 -13570 0 0 {name=p63874 lab=_60901_/B }
C {devices/lab_pin.sym} 64300 -13570 0 1 {name=p63875 lab=_60993_/B }
C {sky130_stdcells/buf_2.sym} 64260 -13570 0 0 {name=X_60964_ }
C {devices/lab_pin.sym} 64220 -13450 0 0 {name=p63876 lab=clkbuf_9_305_0_CLK/X }
C {devices/lab_pin.sym} 64300 -13450 0 1 {name=p63877 lab=_80835_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 64260 -13450 0 0 {name=Xclkbuf_10_611_0_CLK }
C {devices/lab_pin.sym} 64220 -13330 0 0 {name=p63878 lab=_45897_/X }
C {devices/lab_pin.sym} 64300 -13330 0 1 {name=p63879 lab=_45898_/X }
C {sky130_stdcells/buf_2.sym} 64260 -13330 0 0 {name=X_45898_ }
C {devices/lab_pin.sym} 64200 -13240 0 0 {name=p63880 lab=_61376_/X }
C {devices/lab_pin.sym} 64200 -13200 0 0 {name=p63881 lab=_62694_/B }
C {devices/lab_pin.sym} 64200 -13160 0 0 {name=p63882 lab=_62694_/C }
C {devices/lab_pin.sym} 64200 -13120 0 0 {name=p63883 lab=_62664_/D }
C {devices/lab_pin.sym} 64320 -13180 0 1 {name=p63884 lab=_62703_/Y }
C {sky130_stdcells/nand4_4.sym} 64260 -13180 0 0 {name=X_62703_ }
C {devices/lab_pin.sym} 64200 -13060 0 0 {name=p63885 lab=_47655_/A }
C {devices/lab_pin.sym} 64200 -13020 0 0 {name=p63886 lab=_47645_/B }
C {devices/lab_pin.sym} 64200 -12980 0 0 {name=p63887 lab=_47614_/X }
C {devices/lab_pin.sym} 64200 -12940 0 0 {name=p63888 lab=_53159_/D }
C {devices/lab_pin.sym} 64320 -13000 0 1 {name=p63889 lab=_47637_/X }
C {sky130_stdcells/and4_4.sym} 64260 -13000 0 0 {name=X_47637_ }
C {devices/lab_pin.sym} 64200 -12870 0 0 {name=p63890 lab=_66216_/A }
C {devices/lab_pin.sym} 64200 -12830 0 0 {name=p63891 lab=_66397_/X }
C {devices/lab_pin.sym} 64200 -12790 0 0 {name=p63892 lab=_66216_/C }
C {devices/lab_pin.sym} 64320 -12830 0 1 {name=p63893 lab=_66471_/Y }
C {sky130_stdcells/nand3_4.sym} 64260 -12830 0 0 {name=X_66471_ }
C {devices/lab_pin.sym} 64220 -12690 0 0 {name=p63894 lab=_82797_/Q }
C {devices/lab_pin.sym} 64300 -12690 0 1 {name=p63895 lab=_78461_/A }
C {sky130_stdcells/inv_2.sym} 64260 -12690 0 0 {name=X_78457_ }
C {devices/lab_pin.sym} 64220 -12570 0 0 {name=p63896 lab=_45964_/A }
C {devices/lab_pin.sym} 64300 -12570 0 1 {name=p63897 lab=_44849_/X }
C {sky130_stdcells/buf_2.sym} 64260 -12570 0 0 {name=X_44849_ }
C {devices/lab_pin.sym} 64200 -12460 0 0 {name=p63898 lab=_75669_/A }
C {devices/lab_pin.sym} 64200 -12420 0 0 {name=p63899 lab=_75669_/B }
C {devices/lab_pin.sym} 64320 -12440 0 1 {name=p63900 lab=_75669_/Y }
C {sky130_stdcells/xnor2_4.sym} 64260 -12440 0 0 {name=X_75669_ }
C {devices/lab_pin.sym} 64180 -12340 0 0 {name=p63901 lab=_59436_/Y }
C {devices/lab_pin.sym} 64180 -12300 0 0 {name=p63902 lab=_63626_/X }
C {devices/lab_pin.sym} 64180 -12260 0 0 {name=p63903 lab=_61666_/A }
C {devices/lab_pin.sym} 64180 -12220 0 0 {name=p63904 lab=_63627_/X }
C {devices/lab_pin.sym} 64340 -12280 0 1 {name=p63905 lab=_63683_/X }
C {sky130_stdcells/a2bb2o_4.sym} 64260 -12280 0 0 {name=X_63683_ }
C {devices/lab_pin.sym} 64220 -12130 0 0 {name=p63906 lab=_60894_/X }
C {devices/lab_pin.sym} 64300 -12130 0 1 {name=p63907 lab=_60895_/X }
C {sky130_stdcells/buf_2.sym} 64260 -12130 0 0 {name=X_60895_ }
C {devices/lab_pin.sym} 64220 -12010 0 0 {name=p63908 lab=clkbuf_8_51_0_CLK/X }
C {devices/lab_pin.sym} 64300 -12010 0 1 {name=p63909 lab=clkbuf_9_102_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 64260 -12010 0 0 {name=Xclkbuf_9_102_0_CLK }
C {devices/lab_pin.sym} 64180 -11910 0 0 {name=p63910 lab=_67298_/X }
C {devices/lab_pin.sym} 64180 -11870 0 0 {name=p63911 lab=_67301_/X }
C {devices/lab_pin.sym} 64180 -11830 0 0 {name=p63912 lab=_68209_/X }
C {devices/lab_pin.sym} 64340 -11870 0 1 {name=p63913 lab=_68210_/Y }
C {sky130_stdcells/a21oi_4.sym} 64260 -11870 0 0 {name=X_68210_ }
C {devices/lab_pin.sym} 64180 -11750 0 0 {name=p63914 lab=_65420_/Y }
C {devices/lab_pin.sym} 64180 -11710 0 0 {name=p63915 lab=_65347_/X }
C {devices/lab_pin.sym} 64180 -11670 0 0 {name=p63916 lab=_65421_/X }
C {devices/lab_pin.sym} 64340 -11710 0 1 {name=p63917 lab=_84202_/D }
C {sky130_stdcells/a21o_4.sym} 64260 -11710 0 0 {name=X_65422_ }
C {devices/lab_pin.sym} 64220 -11570 0 0 {name=p63918 lab=_82223_/Q }
C {devices/lab_pin.sym} 64300 -11570 0 1 {name=p63919 lab=_77412_/A }
C {sky130_stdcells/inv_2.sym} 64260 -11570 0 0 {name=X_77408_ }
C {devices/lab_pin.sym} 64200 -11480 0 0 {name=p63920 lab=_62634_/A }
C {devices/lab_pin.sym} 64200 -11440 0 0 {name=p63921 lab=_62634_/B }
C {devices/lab_pin.sym} 64200 -11400 0 0 {name=p63922 lab=_62634_/C }
C {devices/lab_pin.sym} 64200 -11360 0 0 {name=p63923 lab=_62633_/Y }
C {devices/lab_pin.sym} 64320 -11420 0 1 {name=p63924 lab=_62634_/Y }
C {sky130_stdcells/nand4_4.sym} 64260 -11420 0 0 {name=X_62634_ }
C {devices/lab_pin.sym} 64220 -11270 0 0 {name=p63925 lab=_69190_/A }
C {devices/lab_pin.sym} 64300 -11270 0 1 {name=p63926 lab=_69191_/A }
C {sky130_stdcells/buf_2.sym} 64260 -11270 0 0 {name=X_69190_ }
C {devices/lab_pin.sym} 64200 -11180 0 0 {name=p63927 lab=_47530_/X }
C {devices/lab_pin.sym} 64200 -11140 0 0 {name=p63928 lab=_47595_/B }
C {devices/lab_pin.sym} 64200 -11100 0 0 {name=p63929 lab=_47595_/C }
C {devices/lab_pin.sym} 64200 -11060 0 0 {name=p63930 lab=_53125_/D }
C {devices/lab_pin.sym} 64320 -11120 0 1 {name=p63931 lab=_47568_/X }
C {sky130_stdcells/and4_4.sym} 64260 -11120 0 0 {name=X_47568_ }
C {devices/lab_pin.sym} 64180 -10990 0 0 {name=p63932 lab=_78384_/Y }
C {devices/lab_pin.sym} 64180 -10950 0 0 {name=p63933 lab=_78386_/Y }
C {devices/lab_pin.sym} 64180 -10910 0 0 {name=p63934 lab=_78387_/Y }
C {devices/lab_pin.sym} 64340 -10950 0 1 {name=p63935 lab=_78394_/A }
C {sky130_stdcells/o21ai_4.sym} 64260 -10950 0 0 {name=X_78388_ }
C {devices/lab_pin.sym} 64180 -10830 0 0 {name=p63936 lab=_65124_/B }
C {devices/lab_pin.sym} 64180 -10790 0 0 {name=p63937 lab=_49300_/X }
C {devices/lab_pin.sym} 64180 -10750 0 0 {name=p63938 lab=_49306_/Y }
C {devices/lab_pin.sym} 64340 -10790 0 1 {name=p63939 lab=_49307_/Y }
C {sky130_stdcells/o21ai_4.sym} 64260 -10790 0 0 {name=X_49307_ }
C {devices/lab_pin.sym} 64180 -10670 0 0 {name=p63940 lab=_66891_/X }
C {devices/lab_pin.sym} 64180 -10630 0 0 {name=p63941 lab=_66893_/X }
C {devices/lab_pin.sym} 64180 -10590 0 0 {name=p63942 lab=_68133_/X }
C {devices/lab_pin.sym} 64340 -10630 0 1 {name=p63943 lab=_68141_/Y }
C {sky130_stdcells/a21oi_4.sym} 64260 -10630 0 0 {name=X_68141_ }
C {devices/lab_pin.sym} 64220 -10490 0 0 {name=p63944 lab=_83785_/Q }
C {devices/lab_pin.sym} 64300 -10490 0 1 {name=p63945 lab=_54058_/B }
C {sky130_stdcells/inv_2.sym} 64260 -10490 0 0 {name=X_46519_ }
C {devices/lab_pin.sym} 64180 -10400 0 0 {name=p63946 lab=_65350_/X }
C {devices/lab_pin.sym} 64180 -10360 0 0 {name=p63947 lab=_86148_/Q }
C {devices/lab_pin.sym} 64180 -10320 0 0 {name=p63948 lab=_65224_/X }
C {devices/lab_pin.sym} 64180 -10280 0 0 {name=p63949 lab=_65352_/X }
C {devices/lab_pin.sym} 64340 -10340 0 1 {name=p63950 lab=_65353_/X }
C {sky130_stdcells/a211o_4.sym} 64260 -10340 0 0 {name=X_65353_ }
C {devices/lab_pin.sym} 64200 -10200 0 0 {name=p63951 lab=_77339_/A }
C {devices/lab_pin.sym} 64200 -10160 0 0 {name=p63952 lab=_77339_/B }
C {devices/lab_pin.sym} 64320 -10180 0 1 {name=p63953 lab=_77339_/X }
C {sky130_stdcells/or2_4.sym} 64260 -10180 0 0 {name=X_77339_ }
C {devices/lab_pin.sym} 64220 -10050 0 0 {name=p63954 lab=clkbuf_9_313_0_CLK/X }
C {devices/lab_pin.sym} 64300 -10050 0 1 {name=p63955 lab=_80961_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 64260 -10050 0 0 {name=Xclkbuf_10_626_0_CLK }
C {devices/lab_pin.sym} 64200 -9960 0 0 {name=p63956 lab=_62487_/X }
C {devices/lab_pin.sym} 64200 -9920 0 0 {name=p63957 lab=_58187_/X }
C {devices/lab_pin.sym} 64200 -9880 0 0 {name=p63958 lab=_62565_/C }
C {devices/lab_pin.sym} 64200 -9840 0 0 {name=p63959 lab=_62608_/D }
C {devices/lab_pin.sym} 64320 -9900 0 1 {name=p63960 lab=_62565_/X }
C {sky130_stdcells/and4_4.sym} 64260 -9900 0 0 {name=X_62565_ }
C {devices/lab_pin.sym} 64200 -9760 0 0 {name=p63961 lab=_47517_/A }
C {devices/lab_pin.sym} 64200 -9720 0 0 {name=p63962 lab=_53080_/B }
C {devices/lab_pin.sym} 64320 -9740 0 1 {name=p63963 lab=_47499_/Y }
C {sky130_stdcells/nand2_4.sym} 64260 -9740 0 0 {name=X_47499_ }
C {devices/lab_pin.sym} 64200 -9640 0 0 {name=p63964 lab=_64304_/A }
C {devices/lab_pin.sym} 64200 -9600 0 0 {name=p63965 lab=_64303_/X }
C {devices/lab_pin.sym} 64200 -9560 0 0 {name=p63966 lab=_84961_/Q }
C {devices/lab_pin.sym} 64200 -9520 0 0 {name=p63967 lab=_64304_/D }
C {devices/lab_pin.sym} 64320 -9580 0 1 {name=p63968 lab=_64304_/X }
C {sky130_stdcells/and4_4.sym} 64260 -9580 0 0 {name=X_64304_ }
C {devices/lab_pin.sym} 64180 -9470 0 0 {name=p63969 lab=_61509_/Y }
C {devices/lab_pin.sym} 64180 -9430 0 0 {name=p63970 lab=_61511_/Y }
C {devices/lab_pin.sym} 64180 -9390 0 0 {name=p63971 lab=_61464_/X }
C {devices/lab_pin.sym} 64180 -9350 0 0 {name=p63972 lab=_61513_/Y }
C {devices/lab_pin.sym} 64180 -9320 0 0 {name=p63973 lab=_61515_/Y }
C {devices/lab_pin.sym} 64340 -9390 0 1 {name=p63974 lab=_61516_/X }
C {sky130_stdcells/a41o_4.sym} 64260 -9390 0 0 {name=X_61516_ }
C {devices/lab_pin.sym} 64180 -9250 0 0 {name=p63975 lab=_64784_/B }
C {devices/lab_pin.sym} 64180 -9210 0 0 {name=p63976 lab=_49222_/X }
C {devices/lab_pin.sym} 64180 -9170 0 0 {name=p63977 lab=_49237_/Y }
C {devices/lab_pin.sym} 64340 -9210 0 1 {name=p63978 lab=_49238_/Y }
C {sky130_stdcells/o21ai_4.sym} 64260 -9210 0 0 {name=X_49238_ }
C {devices/lab_pin.sym} 64200 -9090 0 0 {name=p63979 lab=_80350_/A }
C {devices/lab_pin.sym} 64200 -9050 0 0 {name=p63980 lab=_80350_/B }
C {devices/lab_pin.sym} 64200 -9010 0 0 {name=p63981 lab=_80350_/C }
C {devices/lab_pin.sym} 64320 -9050 0 1 {name=p63982 lab=_80353_/A }
C {sky130_stdcells/nand3_4.sym} 64260 -9050 0 0 {name=X_80350_ }
C {devices/lab_pin.sym} 64180 -8940 0 0 {name=p63983 lab=_87444_/Q }
C {devices/lab_pin.sym} 64180 -8900 0 0 {name=p63984 lab=_68069_/X }
C {devices/lab_pin.sym} 64180 -8860 0 0 {name=p63985 lab=_68070_/X }
C {devices/lab_pin.sym} 64180 -8820 0 0 {name=p63986 lab=_68071_/X }
C {devices/lab_pin.sym} 64340 -8880 0 1 {name=p63987 lab=_68072_/X }
C {sky130_stdcells/a211o_4.sym} 64260 -8880 0 0 {name=X_68072_ }
C {devices/lab_pin.sym} 64220 -8730 0 0 {name=p63988 lab=_65158_/A }
C {devices/lab_pin.sym} 64300 -8730 0 1 {name=p63989 lab=_65285_/A }
C {sky130_stdcells/buf_2.sym} 64260 -8730 0 0 {name=X_65284_ }
C {devices/lab_pin.sym} 64220 -8610 0 0 {name=p63990 lab=clkbuf_8_58_0_CLK/X }
C {devices/lab_pin.sym} 64300 -8610 0 1 {name=p63991 lab=clkbuf_9_117_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 64260 -8610 0 0 {name=Xclkbuf_9_117_0_CLK }
C {devices/lab_pin.sym} 64180 -8530 0 0 {name=p63992 lab=_61558_/B }
C {devices/lab_pin.sym} 64180 -8490 0 0 {name=p63993 lab=_62462_/X }
C {devices/lab_pin.sym} 64180 -8450 0 0 {name=p63994 lab=_62436_/X }
C {devices/lab_pin.sym} 64180 -8410 0 0 {name=p63995 lab=_62478_/X }
C {devices/lab_pin.sym} 64180 -8380 0 0 {name=p63996 lab=_62495_/X }
C {devices/lab_pin.sym} 64340 -8450 0 1 {name=p63997 lab=_62496_/X }
C {sky130_stdcells/a41o_4.sym} 64260 -8450 0 0 {name=X_62496_ }
C {devices/lab_pin.sym} 64220 -8290 0 0 {name=p63998 lab=clkbuf_8_22_0_CLK/X }
C {devices/lab_pin.sym} 64300 -8290 0 1 {name=p63999 lab=clkbuf_9_44_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 64260 -8290 0 0 {name=Xclkbuf_9_44_0_CLK }
C {devices/lab_pin.sym} 64200 -8180 0 0 {name=p64000 lab=_67023_/A }
C {devices/lab_pin.sym} 64200 -8140 0 0 {name=p64001 lab=_67023_/B }
C {devices/lab_pin.sym} 64320 -8160 0 1 {name=p64002 lab=_67023_/X }
C {sky130_stdcells/and2_4.sym} 64260 -8160 0 0 {name=X_67023_ }
C {devices/lab_pin.sym} 64180 -8050 0 0 {name=p64003 lab=_78993_/B }
C {devices/lab_pin.sym} 64180 -8010 0 0 {name=p64004 lab=_79006_/X }
C {devices/lab_pin.sym} 64180 -7970 0 0 {name=p64005 lab=_79008_/Y }
C {devices/lab_pin.sym} 64340 -8010 0 1 {name=p64006 lab=_79010_/B }
C {sky130_stdcells/a21oi_4.sym} 64260 -8010 0 0 {name=X_79009_ }
C {devices/lab_pin.sym} 64200 -7890 0 0 {name=p64007 lab=_64223_/A }
C {devices/lab_pin.sym} 64200 -7850 0 0 {name=p64008 lab=_64235_/B }
C {devices/lab_pin.sym} 64200 -7810 0 0 {name=p64009 lab=_64223_/C }
C {devices/lab_pin.sym} 64320 -7850 0 1 {name=p64010 lab=_64235_/X }
C {sky130_stdcells/and3_4.sym} 64260 -7850 0 0 {name=X_64235_ }
C {devices/lab_pin.sym} 64180 -7730 0 0 {name=p64011 lab=_86437_/Q }
C {devices/lab_pin.sym} 64180 -7690 0 0 {name=p64012 lab=_49153_/X }
C {devices/lab_pin.sym} 64180 -7650 0 0 {name=p64013 lab=_49168_/Y }
C {devices/lab_pin.sym} 64340 -7690 0 1 {name=p64014 lab=_49169_/Y }
C {sky130_stdcells/o21ai_4.sym} 64260 -7690 0 0 {name=X_49169_ }
C {devices/lab_pin.sym} 64200 -7570 0 0 {name=p64015 lab=_61437_/A }
C {devices/lab_pin.sym} 64200 -7530 0 0 {name=p64016 lab=_61447_/B }
C {devices/lab_pin.sym} 64200 -7490 0 0 {name=p64017 lab=_61398_/C }
C {devices/lab_pin.sym} 64320 -7530 0 1 {name=p64018 lab=_61447_/Y }
C {sky130_stdcells/nand3_4.sym} 64260 -7530 0 0 {name=X_61447_ }
C {devices/lab_pin.sym} 64200 -7400 0 0 {name=p64019 lab=_84747_/Q }
C {devices/lab_pin.sym} 64200 -7360 0 0 {name=p64020 lab=_84139_/Q }
C {devices/lab_pin.sym} 64320 -7380 0 1 {name=p64021 lab=_80281_/Y }
C {sky130_stdcells/nor2_4.sym} 64260 -7380 0 0 {name=X_80281_ }
C {devices/lab_pin.sym} 64180 -7270 0 0 {name=p64022 lab=_86055_/Q }
C {devices/lab_pin.sym} 64180 -7230 0 0 {name=p64023 lab=_51183_/X }
C {devices/lab_pin.sym} 64180 -7190 0 0 {name=p64024 lab=_51199_/Y }
C {devices/lab_pin.sym} 64340 -7230 0 1 {name=p64025 lab=_51200_/Y }
C {sky130_stdcells/o21ai_4.sym} 64260 -7230 0 0 {name=X_51200_ }
C {devices/lab_pin.sym} 64170 -7090 0 0 {name=p64026 lab=_82104_/CLK }
C {devices/lab_pin.sym} 64170 -7070 0 0 {name=p64027 lab=_77754_/B }
C {devices/lab_pin.sym} 64350 -7090 0 1 {name=p64028 lab=_81988_/D }
C {sky130_stdcells/dfxtp_4.sym} 64260 -7080 0 0 {name=X_82020_ }
C {devices/lab_pin.sym} 64200 -6960 0 0 {name=p64029 lab=_52210_/A }
C {devices/lab_pin.sym} 64200 -6920 0 0 {name=p64030 lab=_48540_/B }
C {devices/lab_pin.sym} 64320 -6940 0 1 {name=p64031 lab=_52180_/Y }
C {sky130_stdcells/nand2_4.sym} 64260 -6940 0 0 {name=X_52180_ }
C {devices/lab_pin.sym} 64220 -6810 0 0 {name=p64032 lab=clkbuf_3_3_0_CLK/A }
C {devices/lab_pin.sym} 64300 -6810 0 1 {name=p64033 lab=clkbuf_3_2_1_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 64260 -6810 0 0 {name=Xclkbuf_3_2_0_CLK }
C {devices/lab_pin.sym} 64200 -6720 0 0 {name=p64034 lab=_61676_/A }
C {devices/lab_pin.sym} 64200 -6680 0 0 {name=p64035 lab=_64177_/B }
C {devices/lab_pin.sym} 64200 -6640 0 0 {name=p64036 lab=_64189_/D }
C {devices/lab_pin.sym} 64200 -6600 0 0 {name=p64037 lab=_64177_/D }
C {devices/lab_pin.sym} 64320 -6660 0 1 {name=p64038 lab=_64166_/Y }
C {sky130_stdcells/nand4_4.sym} 64260 -6660 0 0 {name=X_64166_ }
C {devices/lab_pin.sym} 64200 -6540 0 0 {name=p64039 lab=_61378_/A }
C {devices/lab_pin.sym} 64200 -6500 0 0 {name=p64040 lab=_61367_/B }
C {devices/lab_pin.sym} 64200 -6460 0 0 {name=p64041 lab=_61367_/C }
C {devices/lab_pin.sym} 64200 -6420 0 0 {name=p64042 lab=_61367_/D }
C {devices/lab_pin.sym} 64320 -6480 0 1 {name=p64043 lab=_61378_/Y }
C {sky130_stdcells/nand4_4.sym} 64260 -6480 0 0 {name=X_61378_ }
C {devices/lab_pin.sym} 64180 -6350 0 0 {name=p64044 lab=_86068_/Q }
C {devices/lab_pin.sym} 64180 -6310 0 0 {name=p64045 lab=_51128_/X }
C {devices/lab_pin.sym} 64180 -6270 0 0 {name=p64046 lab=_51130_/Y }
C {devices/lab_pin.sym} 64340 -6310 0 1 {name=p64047 lab=_51131_/Y }
C {sky130_stdcells/o21ai_4.sym} 64260 -6310 0 0 {name=X_51131_ }
C {devices/lab_pin.sym} 64220 -6170 0 0 {name=p64048 lab=_60523_/A }
C {devices/lab_pin.sym} 64300 -6170 0 1 {name=p64049 lab=_63117_/X }
C {sky130_stdcells/buf_2.sym} 64260 -6170 0 0 {name=X_63117_ }
C {devices/lab_pin.sym} 64220 -6050 0 0 {name=p64050 lab=_57757_/A }
C {devices/lab_pin.sym} 64300 -6050 0 1 {name=p64051 lab=_65296_/A }
C {sky130_stdcells/buf_2.sym} 64260 -6050 0 0 {name=X_60329_ }
C {devices/lab_pin.sym} 64180 -5950 0 0 {name=p64052 lab=_80809_/D }
C {devices/lab_pin.sym} 64180 -5910 0 0 {name=p64053 lab=_68954_/X }
C {devices/lab_pin.sym} 64180 -5870 0 0 {name=p64054 lab=_68973_/X }
C {devices/lab_pin.sym} 64340 -5910 0 1 {name=p64055 lab=_83953_/D }
C {sky130_stdcells/a21bo_4.sym} 64260 -5910 0 0 {name=X_68974_ }
C {devices/lab_pin.sym} 64220 -5770 0 0 {name=p64056 lab=_63733_/X }
C {devices/lab_pin.sym} 64300 -5770 0 1 {name=p64057 lab=_64173_/C }
C {sky130_stdcells/buf_2.sym} 64260 -5770 0 0 {name=X_64097_ }
C {devices/lab_pin.sym} 64220 -5650 0 0 {name=p64058 lab=clkbuf_9_59_0_CLK/A }
C {devices/lab_pin.sym} 64300 -5650 0 1 {name=p64059 lab=clkbuf_9_59_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 64260 -5650 0 0 {name=Xclkbuf_9_59_0_CLK }
C {devices/lab_pin.sym} 64180 -5550 0 0 {name=p64060 lab=_51059_/Y }
C {devices/lab_pin.sym} 64180 -5510 0 0 {name=p64061 lab=_51039_/X }
C {devices/lab_pin.sym} 64180 -5470 0 0 {name=p64062 lab=_51061_/X }
C {devices/lab_pin.sym} 64340 -5510 0 1 {name=p64063 lab=_51062_/Y }
C {sky130_stdcells/a21oi_4.sym} 64260 -5510 0 0 {name=X_51062_ }
C {devices/lab_pin.sym} 64220 -5370 0 0 {name=p64064 lab=_68120_/A }
C {devices/lab_pin.sym} 64300 -5370 0 1 {name=p64065 lab=_67925_/X }
C {sky130_stdcells/buf_2.sym} 64260 -5370 0 0 {name=X_67925_ }
C {devices/lab_pin.sym} 64220 -5250 0 0 {name=p64066 lab=_60466_/X }
C {devices/lab_pin.sym} 64300 -5250 0 1 {name=p64067 lab=_63085_/C }
C {sky130_stdcells/buf_2.sym} 64260 -5250 0 0 {name=X_63048_ }
C {devices/lab_pin.sym} 64170 -5130 0 0 {name=p64068 lab=_80931_/CLK }
C {devices/lab_pin.sym} 64170 -5110 0 0 {name=p64069 lab=_83971_/D }
C {devices/lab_pin.sym} 64350 -5130 0 1 {name=p64070 lab=_80827_/D }
C {sky130_stdcells/dfxtp_4.sym} 64260 -5120 0 0 {name=X_83971_ }
C {devices/lab_pin.sym} 64220 -4990 0 0 {name=p64071 lab=_48171_/X }
C {devices/lab_pin.sym} 64300 -4990 0 1 {name=p64072 lab=_50027_/A }
C {sky130_stdcells/buf_2.sym} 64260 -4990 0 0 {name=X_50013_ }
C {devices/lab_pin.sym} 64170 -4870 0 0 {name=p64073 lab=_82390_/CLK }
C {devices/lab_pin.sym} 64170 -4850 0 0 {name=p64074 lab=_53032_/Y }
C {devices/lab_pin.sym} 64350 -4870 0 1 {name=p64075 lab=_85710_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -4860 0 0 {name=X_85710_ }
C {devices/lab_pin.sym} 64170 -4730 0 0 {name=p64076 lab=_82931_/CLK }
C {devices/lab_pin.sym} 64170 -4710 0 0 {name=p64077 lab=_78189_/X }
C {devices/lab_pin.sym} 64350 -4730 0 1 {name=p64078 lab=_82922_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -4720 0 0 {name=X_82922_ }
C {devices/lab_pin.sym} 64200 -4600 0 0 {name=p64079 lab=_67955_/A }
C {devices/lab_pin.sym} 64200 -4560 0 0 {name=p64080 lab=_67856_/B }
C {devices/lab_pin.sym} 64320 -4580 0 1 {name=p64081 lab=_67856_/X }
C {sky130_stdcells/and2_4.sym} 64260 -4580 0 0 {name=X_67856_ }
C {devices/lab_pin.sym} 64200 -4460 0 0 {name=p64082 lab=_44081_/X }
C {devices/lab_pin.sym} 64200 -4420 0 0 {name=p64083 lab=_55870_/B }
C {devices/lab_pin.sym} 64320 -4440 0 1 {name=p64084 lab=_55870_/X }
C {sky130_stdcells/and2_4.sym} 64260 -4440 0 0 {name=X_55870_ }
C {devices/lab_pin.sym} 64170 -4310 0 0 {name=p64085 lab=_86372_/CLK }
C {devices/lab_pin.sym} 64170 -4290 0 0 {name=p64086 lab=_86690_/D }
C {devices/lab_pin.sym} 64350 -4310 0 1 {name=p64087 lab=_86690_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -4300 0 0 {name=X_86690_ }
C {devices/lab_pin.sym} 64200 -4200 0 0 {name=p64088 lab=_54825_/A }
C {devices/lab_pin.sym} 64200 -4160 0 0 {name=p64089 lab=_54843_/B }
C {devices/lab_pin.sym} 64200 -4120 0 0 {name=p64090 lab=_54831_/C }
C {devices/lab_pin.sym} 64200 -4080 0 0 {name=p64091 lab=_53129_/D }
C {devices/lab_pin.sym} 64320 -4140 0 1 {name=p64092 lab=_54821_/X }
C {sky130_stdcells/and4_4.sym} 64260 -4140 0 0 {name=X_54821_ }
C {devices/lab_pin.sym} 64170 -3990 0 0 {name=p64093 lab=_85738_/CLK }
C {devices/lab_pin.sym} 64170 -3970 0 0 {name=p64094 lab=_85641_/D }
C {devices/lab_pin.sym} 64350 -3990 0 1 {name=p64095 lab=_85641_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -3980 0 0 {name=X_85641_ }
C {devices/lab_pin.sym} 64220 -3850 0 0 {name=p64096 lab=_69245_/A }
C {devices/lab_pin.sym} 64300 -3850 0 1 {name=p64097 lab=_66807_/X }
C {sky130_stdcells/buf_2.sym} 64260 -3850 0 0 {name=X_66807_ }
C {devices/lab_pin.sym} 64170 -3730 0 0 {name=p64098 lab=_82299_/CLK }
C {devices/lab_pin.sym} 64170 -3710 0 0 {name=p64099 lab=_78103_/B }
C {devices/lab_pin.sym} 64350 -3730 0 1 {name=p64100 lab=_82853_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -3720 0 0 {name=X_82853_ }
C {devices/lab_pin.sym} 64180 -3610 0 0 {name=p64101 lab=_67784_/X }
C {devices/lab_pin.sym} 64180 -3570 0 0 {name=p64102 lab=_67786_/X }
C {devices/lab_pin.sym} 64180 -3530 0 0 {name=p64103 lab=_67742_/X }
C {devices/lab_pin.sym} 64340 -3570 0 1 {name=p64104 lab=_67792_/A }
C {sky130_stdcells/a21o_4.sym} 64260 -3570 0 0 {name=X_67787_ }
C {devices/lab_pin.sym} 64220 -3430 0 0 {name=p64105 lab=_64817_/A }
C {devices/lab_pin.sym} 64300 -3430 0 1 {name=p64106 lab=_64999_/X }
C {sky130_stdcells/buf_2.sym} 64260 -3430 0 0 {name=X_64999_ }
C {devices/lab_pin.sym} 64180 -3330 0 0 {name=p64107 lab=_57538_/Y }
C {devices/lab_pin.sym} 64180 -3290 0 0 {name=p64108 lab=_57515_/X }
C {devices/lab_pin.sym} 64180 -3250 0 0 {name=p64109 lab=_57539_/Y }
C {devices/lab_pin.sym} 64340 -3290 0 1 {name=p64110 lab=_84983_/D }
C {sky130_stdcells/a21boi_4.sym} 64260 -3290 0 0 {name=X_57540_ }
C {devices/lab_pin.sym} 64170 -3150 0 0 {name=p64111 lab=_81362_/CLK }
C {devices/lab_pin.sym} 64170 -3130 0 0 {name=p64112 lab=_81612_/Q }
C {devices/lab_pin.sym} 64350 -3150 0 1 {name=p64113 lab=_81804_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -3140 0 0 {name=X_81804_ }
C {devices/lab_pin.sym} 64200 -3020 0 0 {name=p64114 lab=_69612_/A }
C {devices/lab_pin.sym} 64200 -2980 0 0 {name=p64115 lab=_69526_/B }
C {devices/lab_pin.sym} 64320 -3000 0 1 {name=p64116 lab=_69526_/X }
C {sky130_stdcells/and2_4.sym} 64260 -3000 0 0 {name=X_69526_ }
C {devices/lab_pin.sym} 64170 -2870 0 0 {name=p64117 lab=_88363_/CLK }
C {devices/lab_pin.sym} 64170 -2850 0 0 {name=p64118 lab=_40653_/X }
C {devices/lab_pin.sym} 64350 -2870 0 1 {name=p64119 lab=_68645_/B }
C {sky130_stdcells/dfxtp_4.sym} 64260 -2860 0 0 {name=X_88360_ }
C {devices/lab_pin.sym} 64220 -2730 0 0 {name=p64120 lab=_54344_/A }
C {devices/lab_pin.sym} 64300 -2730 0 1 {name=p64121 lab=_54807_/A }
C {sky130_stdcells/buf_2.sym} 64260 -2730 0 0 {name=X_54752_ }
C {devices/lab_pin.sym} 64200 -2620 0 0 {name=p64122 lab=_66664_/X }
C {devices/lab_pin.sym} 64200 -2580 0 0 {name=p64123 lab=_86831_/Q }
C {devices/lab_pin.sym} 64320 -2600 0 1 {name=p64124 lab=_66738_/X }
C {sky130_stdcells/and2_4.sym} 64260 -2600 0 0 {name=X_66738_ }
C {devices/lab_pin.sym} 64170 -2470 0 0 {name=p64125 lab=_83564_/CLK }
C {devices/lab_pin.sym} 64170 -2450 0 0 {name=p64126 lab=_85572_/D }
C {devices/lab_pin.sym} 64350 -2470 0 1 {name=p64127 lab=_85572_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -2460 0 0 {name=X_85572_ }
C {devices/lab_pin.sym} 64200 -2340 0 0 {name=p64128 lab=_51941_/A }
C {devices/lab_pin.sym} 64200 -2300 0 0 {name=p64129 lab=_48207_/X }
C {devices/lab_pin.sym} 64320 -2320 0 1 {name=p64130 lab=_51964_/Y }
C {sky130_stdcells/nand2_4.sym} 64260 -2320 0 0 {name=X_51964_ }
C {devices/lab_pin.sym} 64170 -2190 0 0 {name=p64131 lab=_82973_/CLK }
C {devices/lab_pin.sym} 64170 -2170 0 0 {name=p64132 lab=_78784_/Y }
C {devices/lab_pin.sym} 64350 -2190 0 1 {name=p64133 lab=_82784_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -2180 0 0 {name=X_82784_ }
C {devices/lab_pin.sym} 64170 -2050 0 0 {name=p64134 lab=_88327_/CLK }
C {devices/lab_pin.sym} 64170 -2030 0 0 {name=p64135 lab=_87311_/D }
C {devices/lab_pin.sym} 64350 -2050 0 1 {name=p64136 lab=_87311_/Q }
C {sky130_stdcells/dfxtp_4.sym} 64260 -2040 0 0 {name=X_87311_ }
C {devices/lab_pin.sym} 64200 -1930 0 0 {name=p64137 lab=_52182_/A }
C {devices/lab_pin.sym} 64200 -1890 0 0 {name=p64138 lab=_53720_/B }
C {devices/lab_pin.sym} 64200 -1850 0 0 {name=p64139 lab=_53734_/C }
C {devices/lab_pin.sym} 64320 -1890 0 1 {name=p64140 lab=_53703_/X }
C {sky130_stdcells/and3_4.sym} 64260 -1890 0 0 {name=X_53703_ }
C {devices/lab_pin.sym} 64170 -1750 0 0 {name=p64141 lab=_84287_/CLK }
C {devices/lab_pin.sym} 64170 -1730 0 0 {name=p64142 lab=_61062_/Y }
C {devices/lab_pin.sym} 64350 -1750 0 1 {name=p64143 lab=_76971_/A }
C {sky130_stdcells/dfxtp_4.sym} 64260 -1740 0 0 {name=X_84523_ }
C {devices/lab_pin.sym} 64180 -1630 0 0 {name=p64144 lab=_50913_/Y }
C {devices/lab_pin.sym} 64180 -1590 0 0 {name=p64145 lab=_50902_/X }
C {devices/lab_pin.sym} 64180 -1550 0 0 {name=p64146 lab=_50914_/X }
C {devices/lab_pin.sym} 64340 -1590 0 1 {name=p64147 lab=_50915_/Y }
C {sky130_stdcells/a21oi_4.sym} 64260 -1590 0 0 {name=X_50915_ }
C {devices/lab_pin.sym} 64170 -1450 0 0 {name=p64148 lab=_86807_/CLK }
C {devices/lab_pin.sym} 64170 -1430 0 0 {name=p64149 lab=_75955_/B }
C {devices/lab_pin.sym} 64350 -1450 0 1 {name=p64150 lab=_41427_/A }
C {sky130_stdcells/dfxtp_4.sym} 64260 -1440 0 0 {name=X_81735_ }
C {devices/lab_pin.sym} 64180 -1330 0 0 {name=p64151 lab=_57372_/X }
C {devices/lab_pin.sym} 64180 -1290 0 0 {name=p64152 lab=_57469_/X }
C {devices/lab_pin.sym} 64180 -1250 0 0 {name=p64153 lab=_57470_/Y }
C {devices/lab_pin.sym} 64340 -1290 0 1 {name=p64154 lab=_57472_/A }
C {sky130_stdcells/o21ai_4.sym} 64260 -1290 0 0 {name=X_57471_ }
C {devices/lab_pin.sym} 64220 -1150 0 0 {name=p64155 lab=_69457_/A }
C {devices/lab_pin.sym} 64300 -1150 0 1 {name=p64156 lab=_69457_/X }
C {sky130_stdcells/buf_2.sym} 64260 -1150 0 0 {name=X_69457_ }
C {devices/lab_pin.sym} 64170 -1030 0 0 {name=p64157 lab=_87022_/CLK }
C {devices/lab_pin.sym} 64170 -1010 0 0 {name=p64158 lab=_41029_/X }
C {devices/lab_pin.sym} 64350 -1030 0 1 {name=p64159 lab=_69362_/B }
C {sky130_stdcells/dfxtp_4.sym} 64260 -1020 0 0 {name=X_88291_ }
C {devices/lab_pin.sym} 64180 -910 0 0 {name=p64160 lab=_85397_/Q }
C {devices/lab_pin.sym} 64180 -870 0 0 {name=p64161 lab=_54676_/X }
C {devices/lab_pin.sym} 64180 -830 0 0 {name=p64162 lab=_54682_/Y }
C {devices/lab_pin.sym} 64340 -870 0 1 {name=p64163 lab=_54683_/Y }
C {sky130_stdcells/o21ai_4.sym} 64260 -870 0 0 {name=X_54683_ }
C {devices/lab_pin.sym} 64200 -740 0 0 {name=p64164 lab=_66669_/A }
C {devices/lab_pin.sym} 64200 -700 0 0 {name=p64165 lab=_88207_/Q }
C {devices/lab_pin.sym} 64320 -720 0 1 {name=p64166 lab=_66669_/X }
C {sky130_stdcells/and2_4.sym} 64260 -720 0 0 {name=X_66669_ }
C {devices/lab_pin.sym} 65120 -42160 0 0 {name=p64167 lab=_51875_/A }
C {devices/lab_pin.sym} 65120 -42120 0 0 {name=p64168 lab=_51031_/B }
C {devices/lab_pin.sym} 65240 -42140 0 1 {name=p64169 lab=_51895_/Y }
C {sky130_stdcells/nand2_4.sym} 65180 -42140 0 0 {name=X_51895_ }
C {devices/lab_pin.sym} 65100 -42030 0 0 {name=p64170 lab=_59208_/X }
C {devices/lab_pin.sym} 65100 -41990 0 0 {name=p64171 lab=_86064_/Q }
C {devices/lab_pin.sym} 65100 -41950 0 0 {name=p64172 lab=_59209_/X }
C {devices/lab_pin.sym} 65260 -41990 0 1 {name=p64173 lab=_59210_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -41990 0 0 {name=X_59210_ }
C {devices/lab_pin.sym} 65140 -41850 0 0 {name=p64174 lab=_56435_/A }
C {devices/lab_pin.sym} 65220 -41850 0 1 {name=p64175 lab=_56431_/A }
C {sky130_stdcells/buf_2.sym} 65180 -41850 0 0 {name=X_56422_ }
C {devices/lab_pin.sym} 65140 -41730 0 0 {name=p64176 lab=_67657_/X }
C {devices/lab_pin.sym} 65220 -41730 0 1 {name=p64177 lab=_68409_/A }
C {sky130_stdcells/buf_2.sym} 65180 -41730 0 0 {name=X_68408_ }
C {devices/lab_pin.sym} 65090 -41610 0 0 {name=p64178 lab=_88012_/CLK }
C {devices/lab_pin.sym} 65090 -41590 0 0 {name=p64179 lab=_43836_/X }
C {devices/lab_pin.sym} 65270 -41610 0 1 {name=p64180 lab=_68604_/B }
C {sky130_stdcells/dfxtp_4.sym} 65180 -41600 0 0 {name=X_87242_ }
C {devices/lab_pin.sym} 65100 -41490 0 0 {name=p64181 lab=_85598_/Q }
C {devices/lab_pin.sym} 65100 -41450 0 0 {name=p64182 lab=_53626_/X }
C {devices/lab_pin.sym} 65100 -41410 0 0 {name=p64183 lab=_53633_/Y }
C {devices/lab_pin.sym} 65260 -41450 0 1 {name=p64184 lab=_53634_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -41450 0 0 {name=X_53634_ }
C {devices/lab_pin.sym} 65090 -41310 0 0 {name=p64185 lab=_84454_/CLK }
C {devices/lab_pin.sym} 65090 -41290 0 0 {name=p64186 lab=_61785_/Y }
C {devices/lab_pin.sym} 65270 -41310 0 1 {name=p64187 lab=_78077_/B }
C {sky130_stdcells/dfxtp_4.sym} 65180 -41300 0 0 {name=X_84454_ }
C {devices/lab_pin.sym} 65100 -41190 0 0 {name=p64188 lab=_50843_/Y }
C {devices/lab_pin.sym} 65100 -41150 0 0 {name=p64189 lab=_50792_/X }
C {devices/lab_pin.sym} 65100 -41110 0 0 {name=p64190 lab=_50845_/Y }
C {devices/lab_pin.sym} 65260 -41150 0 1 {name=p64191 lab=_86122_/D }
C {sky130_stdcells/a21boi_4.sym} 65180 -41150 0 0 {name=X_50846_ }
C {devices/lab_pin.sym} 65090 -41010 0 0 {name=p64192 lab=_81040_/CLK }
C {devices/lab_pin.sym} 65090 -40990 0 0 {name=p64193 lab=_80264_/Y }
C {devices/lab_pin.sym} 65270 -41010 0 1 {name=p64194 lab=_81666_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -41000 0 0 {name=X_81666_ }
C {devices/lab_pin.sym} 65100 -40900 0 0 {name=p64195 lab=_87021_/Q }
C {devices/lab_pin.sym} 65100 -40860 0 0 {name=p64196 lab=_69239_/X }
C {devices/lab_pin.sym} 65100 -40820 0 0 {name=p64197 lab=_69361_/X }
C {devices/lab_pin.sym} 65100 -40780 0 0 {name=p64198 lab=_69387_/X }
C {devices/lab_pin.sym} 65260 -40840 0 1 {name=p64199 lab=_69388_/X }
C {sky130_stdcells/a211o_4.sym} 65180 -40840 0 0 {name=X_69388_ }
C {devices/lab_pin.sym} 65100 -40710 0 0 {name=p64200 lab=_59137_/Y }
C {devices/lab_pin.sym} 65100 -40670 0 0 {name=p64201 lab=_59139_/Y }
C {devices/lab_pin.sym} 65100 -40630 0 0 {name=p64202 lab=_59140_/X }
C {devices/lab_pin.sym} 65260 -40670 0 1 {name=p64203 lab=_59141_/X }
C {sky130_stdcells/a21o_4.sym} 65180 -40670 0 0 {name=X_59141_ }
C {devices/lab_pin.sym} 65090 -40530 0 0 {name=p64204 lab=_83491_/CLK }
C {devices/lab_pin.sym} 65090 -40510 0 0 {name=p64205 lab=_83405_/D }
C {devices/lab_pin.sym} 65270 -40530 0 1 {name=p64206 lab=_83405_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -40520 0 0 {name=X_83405_ }
C {devices/lab_pin.sym} 65100 -40410 0 0 {name=p64207 lab=_56139_/X }
C {devices/lab_pin.sym} 65100 -40370 0 0 {name=p64208 lab=_56350_/X }
C {devices/lab_pin.sym} 65100 -40330 0 0 {name=p64209 lab=_56352_/Y }
C {devices/lab_pin.sym} 65260 -40370 0 1 {name=p64210 lab=_56353_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -40370 0 0 {name=X_56353_ }
C {devices/lab_pin.sym} 65120 -40240 0 0 {name=p64211 lab=_80617_/A }
C {devices/lab_pin.sym} 65120 -40200 0 0 {name=p64212 lab=_80607_/X }
C {devices/lab_pin.sym} 65240 -40220 0 1 {name=p64213 lab=_80617_/Y }
C {sky130_stdcells/nand2_4.sym} 65180 -40220 0 0 {name=X_80617_ }
C {devices/lab_pin.sym} 65100 -40110 0 0 {name=p64214 lab=_68082_/X }
C {devices/lab_pin.sym} 65100 -40070 0 0 {name=p64215 lab=_68084_/X }
C {devices/lab_pin.sym} 65100 -40030 0 0 {name=p64216 lab=_68327_/X }
C {devices/lab_pin.sym} 65260 -40070 0 1 {name=p64217 lab=_68339_/Y }
C {sky130_stdcells/a21oi_4.sym} 65180 -40070 0 0 {name=X_68339_ }
C {devices/lab_pin.sym} 65090 -39930 0 0 {name=p64218 lab=_87169_/CLK }
C {devices/lab_pin.sym} 65090 -39910 0 0 {name=p64219 lab=_44289_/X }
C {devices/lab_pin.sym} 65270 -39930 0 1 {name=p64220 lab=_44072_/A }
C {sky130_stdcells/dfxtp_4.sym} 65180 -39920 0 0 {name=X_87173_ }
C {devices/lab_pin.sym} 65120 -39800 0 0 {name=p64221 lab=_53565_/A }
C {devices/lab_pin.sym} 65120 -39760 0 0 {name=p64222 lab=_48297_/X }
C {devices/lab_pin.sym} 65240 -39780 0 1 {name=p64223 lab=_53565_/Y }
C {sky130_stdcells/nand2_4.sym} 65180 -39780 0 0 {name=X_53565_ }
C {devices/lab_pin.sym} 65090 -39650 0 0 {name=p64224 lab=_84518_/CLK }
C {devices/lab_pin.sym} 65090 -39630 0 0 {name=p64225 lab=_62758_/Y }
C {devices/lab_pin.sym} 65270 -39650 0 1 {name=p64226 lab=_75915_/B }
C {sky130_stdcells/dfxtp_4.sym} 65180 -39640 0 0 {name=X_84385_ }
C {devices/lab_pin.sym} 65120 -39520 0 0 {name=p64227 lab=_50777_/A }
C {devices/lab_pin.sym} 65120 -39480 0 0 {name=p64228 lab=_50777_/B }
C {devices/lab_pin.sym} 65240 -39500 0 1 {name=p64229 lab=_50777_/Y }
C {sky130_stdcells/nand2_4.sym} 65180 -39500 0 0 {name=X_50777_ }
C {devices/lab_pin.sym} 65090 -39370 0 0 {name=p64230 lab=_81433_/CLK }
C {devices/lab_pin.sym} 65090 -39350 0 0 {name=p64231 lab=_84197_/Q }
C {devices/lab_pin.sym} 65270 -39370 0 1 {name=p64232 lab=_81597_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -39360 0 0 {name=X_81597_ }
C {devices/lab_pin.sym} 65100 -39260 0 0 {name=p64233 lab=_85039_/Q }
C {devices/lab_pin.sym} 65100 -39220 0 0 {name=p64234 lab=_44060_/X }
C {devices/lab_pin.sym} 65100 -39180 0 0 {name=p64235 lab=_55301_/X }
C {devices/lab_pin.sym} 65100 -39140 0 0 {name=p64236 lab=_55303_/X }
C {devices/lab_pin.sym} 65260 -39200 0 1 {name=p64237 lab=_55304_/X }
C {sky130_stdcells/a211o_4.sym} 65180 -39200 0 0 {name=X_55304_ }
C {devices/lab_pin.sym} 65090 -39050 0 0 {name=p64238 lab=_86040_/CLK }
C {devices/lab_pin.sym} 65090 -39030 0 0 {name=p64239 lab=_86124_/D }
C {devices/lab_pin.sym} 65270 -39050 0 1 {name=p64240 lab=_86124_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -39040 0 0 {name=X_86124_ }
C {devices/lab_pin.sym} 65120 -38920 0 0 {name=p64241 lab=_40368_/X }
C {devices/lab_pin.sym} 65120 -38880 0 0 {name=p64242 lab=_40530_/B }
C {devices/lab_pin.sym} 65240 -38900 0 1 {name=p64243 lab=_40530_/X }
C {sky130_stdcells/or2_4.sym} 65180 -38900 0 0 {name=X_40530_ }
C {devices/lab_pin.sym} 65140 -38770 0 0 {name=p64244 lab=_52515_/X }
C {devices/lab_pin.sym} 65220 -38770 0 1 {name=p64245 lab=_52516_/X }
C {sky130_stdcells/buf_2.sym} 65180 -38770 0 0 {name=X_52516_ }
C {devices/lab_pin.sym} 65100 -38670 0 0 {name=p64246 lab=_71344_/X }
C {devices/lab_pin.sym} 65100 -38630 0 0 {name=p64247 lab=_83529_/Q }
C {devices/lab_pin.sym} 65100 -38590 0 0 {name=p64248 lab=_71349_/X }
C {devices/lab_pin.sym} 65260 -38630 0 1 {name=p64249 lab=_83529_/D }
C {sky130_stdcells/a21o_4.sym} 65180 -38630 0 0 {name=X_71350_ }
C {devices/lab_pin.sym} 65100 -38510 0 0 {name=p64250 lab=_59033_/X }
C {devices/lab_pin.sym} 65100 -38470 0 0 {name=p64251 lab=_85435_/Q }
C {devices/lab_pin.sym} 65100 -38430 0 0 {name=p64252 lab=_59071_/X }
C {devices/lab_pin.sym} 65260 -38470 0 1 {name=p64253 lab=_59072_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -38470 0 0 {name=X_59072_ }
C {devices/lab_pin.sym} 65090 -38330 0 0 {name=p64254 lab=_83333_/CLK }
C {devices/lab_pin.sym} 65090 -38310 0 0 {name=p64255 lab=_83336_/D }
C {devices/lab_pin.sym} 65270 -38330 0 1 {name=p64256 lab=_83336_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -38320 0 0 {name=X_83336_ }
C {devices/lab_pin.sym} 65120 -38200 0 0 {name=p64257 lab=_80548_/A }
C {devices/lab_pin.sym} 65120 -38160 0 0 {name=p64258 lab=_84322_/Q }
C {devices/lab_pin.sym} 65240 -38180 0 1 {name=p64259 lab=_80549_/B }
C {sky130_stdcells/xor2_4.sym} 65180 -38180 0 0 {name=X_80548_ }
C {devices/lab_pin.sym} 65140 -38050 0 0 {name=p64260 lab=_56350_/A }
C {devices/lab_pin.sym} 65220 -38050 0 1 {name=p64261 lab=_56284_/X }
C {sky130_stdcells/buf_2.sym} 65180 -38050 0 0 {name=X_56284_ }
C {devices/lab_pin.sym} 65100 -37950 0 0 {name=p64262 lab=_85625_/Q }
C {devices/lab_pin.sym} 65100 -37910 0 0 {name=p64263 lab=_53476_/X }
C {devices/lab_pin.sym} 65100 -37870 0 0 {name=p64264 lab=_53495_/Y }
C {devices/lab_pin.sym} 65260 -37910 0 1 {name=p64265 lab=_53496_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -37910 0 0 {name=X_53496_ }
C {devices/lab_pin.sym} 65100 -37790 0 0 {name=p64266 lab=_58019_/Y }
C {devices/lab_pin.sym} 65100 -37750 0 0 {name=p64267 lab=_58022_/Y }
C {devices/lab_pin.sym} 65100 -37710 0 0 {name=p64268 lab=_57909_/X }
C {devices/lab_pin.sym} 65260 -37750 0 1 {name=p64269 lab=_58023_/X }
C {sky130_stdcells/a21o_4.sym} 65180 -37750 0 0 {name=X_58023_ }
C {devices/lab_pin.sym} 65120 -37640 0 0 {name=p64270 lab=_70296_/X }
C {devices/lab_pin.sym} 65120 -37600 0 0 {name=p64271 lab=_70297_/X }
C {devices/lab_pin.sym} 65120 -37560 0 0 {name=p64272 lab=_70301_/C }
C {devices/lab_pin.sym} 65120 -37520 0 0 {name=p64273 lab=_70301_/D }
C {devices/lab_pin.sym} 65240 -37580 0 1 {name=p64274 lab=_70301_/X }
C {sky130_stdcells/and4_4.sym} 65180 -37580 0 0 {name=X_70301_ }
C {devices/lab_pin.sym} 65120 -37440 0 0 {name=p64275 lab=_55235_/A }
C {devices/lab_pin.sym} 65120 -37400 0 0 {name=p64276 lab=_56898_/A }
C {devices/lab_pin.sym} 65240 -37420 0 1 {name=p64277 lab=_55235_/X }
C {sky130_stdcells/and2_4.sym} 65180 -37420 0 0 {name=X_55235_ }
C {devices/lab_pin.sym} 65090 -37290 0 0 {name=p64278 lab=_85735_/CLK }
C {devices/lab_pin.sym} 65090 -37270 0 0 {name=p64279 lab=_51204_/Y }
C {devices/lab_pin.sym} 65270 -37290 0 1 {name=p64280 lab=_86055_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -37280 0 0 {name=X_86055_ }
C {devices/lab_pin.sym} 65140 -37150 0 0 {name=p64281 lab=_40461_/A }
C {devices/lab_pin.sym} 65220 -37150 0 1 {name=p64282 lab=_40461_/Y }
C {sky130_stdcells/inv_2.sym} 65180 -37150 0 0 {name=X_40461_ }
C {devices/lab_pin.sym} 65100 -37050 0 0 {name=p64283 lab=_52445_/Y }
C {devices/lab_pin.sym} 65100 -37010 0 0 {name=p64284 lab=_52415_/X }
C {devices/lab_pin.sym} 65100 -36970 0 0 {name=p64285 lab=_52446_/X }
C {devices/lab_pin.sym} 65260 -37010 0 1 {name=p64286 lab=_85821_/D }
C {sky130_stdcells/a21oi_4.sym} 65180 -37010 0 0 {name=X_52447_ }
C {devices/lab_pin.sym} 65120 -36900 0 0 {name=p64287 lab=_71181_/A }
C {devices/lab_pin.sym} 65120 -36860 0 0 {name=p64288 lab=_71268_/A }
C {devices/lab_pin.sym} 65120 -36820 0 0 {name=p64289 lab=_71279_/C }
C {devices/lab_pin.sym} 65120 -36780 0 0 {name=p64290 lab=_71276_/D }
C {devices/lab_pin.sym} 65240 -36840 0 1 {name=p64291 lab=_71281_/Y }
C {sky130_stdcells/nand4_4.sym} 65180 -36840 0 0 {name=X_71281_ }
C {devices/lab_pin.sym} 65090 -36690 0 0 {name=p64292 lab=_85332_/CLK }
C {devices/lab_pin.sym} 65090 -36670 0 0 {name=p64293 lab=_83267_/D }
C {devices/lab_pin.sym} 65270 -36690 0 1 {name=p64294 lab=_83267_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -36680 0 0 {name=X_83267_ }
C {devices/lab_pin.sym} 65100 -36570 0 0 {name=p64295 lab=_80471_/B }
C {devices/lab_pin.sym} 65100 -36530 0 0 {name=p64296 lab=_80471_/A }
C {devices/lab_pin.sym} 65100 -36490 0 0 {name=p64297 lab=_80478_/X }
C {devices/lab_pin.sym} 65260 -36530 0 1 {name=p64298 lab=_80480_/B }
C {sky130_stdcells/a21boi_4.sym} 65180 -36530 0 0 {name=X_80479_ }
C {devices/lab_pin.sym} 65140 -36390 0 0 {name=p64299 lab=_42199_/X }
C {devices/lab_pin.sym} 65220 -36390 0 1 {name=p64300 lab=_42200_/X }
C {sky130_stdcells/buf_2.sym} 65180 -36390 0 0 {name=X_42200_ }
C {devices/lab_pin.sym} 65100 -36290 0 0 {name=p64301 lab=_73021_/B }
C {devices/lab_pin.sym} 65100 -36250 0 0 {name=p64302 lab=_73021_/C }
C {devices/lab_pin.sym} 65100 -36210 0 0 {name=p64303 lab=_73019_/X }
C {devices/lab_pin.sym} 65260 -36250 0 1 {name=p64304 lab=_73020_/X }
C {sky130_stdcells/a21o_4.sym} 65180 -36250 0 0 {name=X_73020_ }
C {devices/lab_pin.sym} 65090 -36110 0 0 {name=p64305 lab=_85034_/CLK }
C {devices/lab_pin.sym} 65090 -36090 0 0 {name=p64306 lab=_85006_/D }
C {devices/lab_pin.sym} 65270 -36110 0 1 {name=p64307 lab=_55317_/B }
C {sky130_stdcells/dfxtp_4.sym} 65180 -36100 0 0 {name=X_85006_ }
C {devices/lab_pin.sym} 65140 -35970 0 0 {name=p64308 lab=_70232_/A }
C {devices/lab_pin.sym} 65220 -35970 0 1 {name=p64309 lab=_70239_/B }
C {sky130_stdcells/buf_2.sym} 65180 -35970 0 0 {name=X_70232_ }
C {devices/lab_pin.sym} 65090 -35850 0 0 {name=p64310 lab=_81928_/CLK }
C {devices/lab_pin.sym} 65090 -35830 0 0 {name=p64311 lab=_82250_/Q }
C {devices/lab_pin.sym} 65270 -35850 0 1 {name=p64312 lab=_77339_/A }
C {sky130_stdcells/dfxtp_4.sym} 65180 -35840 0 0 {name=X_82218_ }
C {devices/lab_pin.sym} 65140 -35710 0 0 {name=p64313 lab=_43180_/A }
C {devices/lab_pin.sym} 65220 -35710 0 1 {name=p64314 lab=_43180_/X }
C {sky130_stdcells/buf_2.sym} 65180 -35710 0 0 {name=X_43180_ }
C {devices/lab_pin.sym} 65120 -35600 0 0 {name=p64315 lab=_55159_/A }
C {devices/lab_pin.sym} 65120 -35560 0 0 {name=p64316 lab=_85068_/Q }
C {devices/lab_pin.sym} 65240 -35580 0 1 {name=p64317 lab=_55166_/X }
C {sky130_stdcells/and2_4.sym} 65180 -35580 0 0 {name=X_55166_ }
C {devices/lab_pin.sym} 65100 -35480 0 0 {name=p64318 lab=_40391_/X }
C {devices/lab_pin.sym} 65100 -35440 0 0 {name=p64319 lab=_40342_/X }
C {devices/lab_pin.sym} 65100 -35400 0 0 {name=p64320 lab=_88399_/Q }
C {devices/lab_pin.sym} 65100 -35360 0 0 {name=p64321 lab=_40355_/X }
C {devices/lab_pin.sym} 65260 -35420 0 1 {name=p64322 lab=_40392_/X }
C {sky130_stdcells/a2bb2o_4.sym} 65180 -35420 0 0 {name=X_40392_ }
C {devices/lab_pin.sym} 65100 -35290 0 0 {name=p64323 lab=_52375_/Y }
C {devices/lab_pin.sym} 65100 -35250 0 0 {name=p64324 lab=_52364_/X }
C {devices/lab_pin.sym} 65100 -35210 0 0 {name=p64325 lab=_52377_/X }
C {devices/lab_pin.sym} 65260 -35250 0 1 {name=p64326 lab=_52378_/Y }
C {sky130_stdcells/a21oi_4.sym} 65180 -35250 0 0 {name=X_52378_ }
C {devices/lab_pin.sym} 65090 -35110 0 0 {name=p64327 lab=_85049_/CLK }
C {devices/lab_pin.sym} 65090 -35090 0 0 {name=p64328 lab=_83198_/D }
C {devices/lab_pin.sym} 65270 -35110 0 1 {name=p64329 lab=_70205_/C }
C {sky130_stdcells/dfxtp_4.sym} 65180 -35100 0 0 {name=X_83198_ }
C {devices/lab_pin.sym} 65100 -35010 0 0 {name=p64330 lab=_42120_/X }
C {devices/lab_pin.sym} 65100 -34970 0 0 {name=p64331 lab=_42116_/X }
C {devices/lab_pin.sym} 65100 -34930 0 0 {name=p64332 lab=_41116_/X }
C {devices/lab_pin.sym} 65100 -34890 0 0 {name=p64333 lab=_88019_/Q }
C {devices/lab_pin.sym} 65100 -34850 0 0 {name=p64334 lab=_42117_/X }
C {devices/lab_pin.sym} 65260 -34930 0 1 {name=p64335 lab=_42132_/A }
C {sky130_stdcells/o32ai_4.sym} 65180 -34930 0 0 {name=X_42131_ }
C {devices/lab_pin.sym} 65140 -34770 0 0 {name=p64336 lab=_53436_/X }
C {devices/lab_pin.sym} 65220 -34770 0 1 {name=p64337 lab=_54117_/X }
C {sky130_stdcells/buf_2.sym} 65180 -34770 0 0 {name=X_54117_ }
C {devices/lab_pin.sym} 65100 -34670 0 0 {name=p64338 lab=_65105_/B }
C {devices/lab_pin.sym} 65100 -34630 0 0 {name=p64339 lab=_51309_/X }
C {devices/lab_pin.sym} 65100 -34590 0 0 {name=p64340 lab=_51328_/Y }
C {devices/lab_pin.sym} 65260 -34630 0 1 {name=p64341 lab=_51329_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -34630 0 0 {name=X_51329_ }
C {devices/lab_pin.sym} 65140 -34490 0 0 {name=p64342 lab=_70134_/X }
C {devices/lab_pin.sym} 65220 -34490 0 1 {name=p64343 lab=_70348_/D }
C {sky130_stdcells/buf_2.sym} 65180 -34490 0 0 {name=X_70163_ }
C {devices/lab_pin.sym} 65090 -34370 0 0 {name=p64344 lab=_82746_/CLK }
C {devices/lab_pin.sym} 65090 -34350 0 0 {name=p64345 lab=_66319_/C }
C {devices/lab_pin.sym} 65270 -34370 0 1 {name=p64346 lab=_82149_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -34360 0 0 {name=X_82149_ }
C {devices/lab_pin.sym} 65100 -34250 0 0 {name=p64347 lab=_55094_/Y }
C {devices/lab_pin.sym} 65100 -34210 0 0 {name=p64348 lab=_55076_/X }
C {devices/lab_pin.sym} 65100 -34170 0 0 {name=p64349 lab=_55096_/X }
C {devices/lab_pin.sym} 65260 -34210 0 1 {name=p64350 lab=_55097_/Y }
C {sky130_stdcells/a21oi_4.sym} 65180 -34210 0 0 {name=X_55097_ }
C {devices/lab_pin.sym} 65120 -34100 0 0 {name=p64351 lab=_59995_/A }
C {devices/lab_pin.sym} 65120 -34060 0 0 {name=p64352 lab=_62621_/D }
C {devices/lab_pin.sym} 65120 -34020 0 0 {name=p64353 lab=_59950_/B }
C {devices/lab_pin.sym} 65120 -33980 0 0 {name=p64354 lab=_59977_/B }
C {devices/lab_pin.sym} 65240 -34040 0 1 {name=p64355 lab=_59974_/Y }
C {sky130_stdcells/nand4_4.sym} 65180 -34040 0 0 {name=X_59974_ }
C {devices/lab_pin.sym} 65100 -33930 0 0 {name=p64356 lab=_42060_/X }
C {devices/lab_pin.sym} 65100 -33890 0 0 {name=p64357 lab=_42049_/X }
C {devices/lab_pin.sym} 65100 -33850 0 0 {name=p64358 lab=_40925_/X }
C {devices/lab_pin.sym} 65100 -33810 0 0 {name=p64359 lab=_42061_/Y }
C {devices/lab_pin.sym} 65100 -33770 0 0 {name=p64360 lab=_41872_/X }
C {devices/lab_pin.sym} 65260 -33850 0 1 {name=p64361 lab=_42062_/Y }
C {sky130_stdcells/o32ai_4.sym} 65180 -33850 0 0 {name=X_42062_ }
C {devices/lab_pin.sym} 65140 -33690 0 0 {name=p64362 lab=_59033_/A }
C {devices/lab_pin.sym} 65220 -33690 0 1 {name=p64363 lab=_58925_/X }
C {sky130_stdcells/buf_2.sym} 65180 -33690 0 0 {name=X_58925_ }
C {devices/lab_pin.sym} 65100 -33590 0 0 {name=p64364 lab=_54046_/Y }
C {devices/lab_pin.sym} 65100 -33550 0 0 {name=p64365 lab=_54015_/X }
C {devices/lab_pin.sym} 65100 -33510 0 0 {name=p64366 lab=_54047_/X }
C {devices/lab_pin.sym} 65260 -33550 0 1 {name=p64367 lab=_85516_/D }
C {sky130_stdcells/a21oi_4.sym} 65180 -33550 0 0 {name=X_54048_ }
C {devices/lab_pin.sym} 65120 -33420 0 0 {name=p64368 lab=_74971_/A }
C {devices/lab_pin.sym} 65120 -33380 0 0 {name=p64369 lab=_74971_/B }
C {devices/lab_pin.sym} 65240 -33400 0 1 {name=p64370 lab=_74972_/B }
C {sky130_stdcells/and2_4.sym} 65180 -33400 0 0 {name=X_74971_ }
C {devices/lab_pin.sym} 65100 -33290 0 0 {name=p64371 lab=_82531_/D }
C {devices/lab_pin.sym} 65100 -33250 0 0 {name=p64372 lab=_70085_/X }
C {devices/lab_pin.sym} 65100 -33210 0 0 {name=p64373 lab=_70093_/X }
C {devices/lab_pin.sym} 65260 -33250 0 1 {name=p64374 lab=_70094_/X }
C {sky130_stdcells/a21bo_4.sym} 65180 -33250 0 0 {name=X_70094_ }
C {devices/lab_pin.sym} 65090 -33110 0 0 {name=p64375 lab=_88224_/CLK }
C {devices/lab_pin.sym} 65090 -33090 0 0 {name=p64376 lab=_44783_/Y }
C {devices/lab_pin.sym} 65270 -33110 0 1 {name=p64377 lab=_86957_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -33100 0 0 {name=X_86957_ }
C {devices/lab_pin.sym} 65140 -32970 0 0 {name=p64378 lab=_41013_/A }
C {devices/lab_pin.sym} 65220 -32970 0 1 {name=p64379 lab=_41019_/B }
C {sky130_stdcells/buf_2.sym} 65180 -32970 0 0 {name=X_41013_ }
C {devices/lab_pin.sym} 65120 -32860 0 0 {name=p64380 lab=_76697_/Y }
C {devices/lab_pin.sym} 65120 -32820 0 0 {name=p64381 lab=_76704_/Y }
C {devices/lab_pin.sym} 65240 -32840 0 1 {name=p64382 lab=_76710_/Y }
C {sky130_stdcells/nor2_4.sym} 65180 -32840 0 0 {name=X_76710_ }
C {devices/lab_pin.sym} 65100 -32740 0 0 {name=p64383 lab=_43068_/Y }
C {devices/lab_pin.sym} 65100 -32700 0 0 {name=p64384 lab=_72888_/X }
C {devices/lab_pin.sym} 65100 -32660 0 0 {name=p64385 lab=_73920_/X }
C {devices/lab_pin.sym} 65100 -32620 0 0 {name=p64386 lab=_73921_/Y }
C {devices/lab_pin.sym} 65260 -32680 0 1 {name=p64387 lab=_73922_/X }
C {sky130_stdcells/a211o_4.sym} 65180 -32680 0 0 {name=X_73922_ }
C {devices/lab_pin.sym} 65090 -32530 0 0 {name=p64388 lab=_86549_/CLK }
C {devices/lab_pin.sym} 65090 -32510 0 0 {name=p64389 lab=_85908_/D }
C {devices/lab_pin.sym} 65270 -32530 0 1 {name=p64390 lab=_66094_/B }
C {sky130_stdcells/dfxtp_4.sym} 65180 -32520 0 0 {name=X_85908_ }
C {devices/lab_pin.sym} 65140 -32390 0 0 {name=p64391 lab=_83662_/Q }
C {devices/lab_pin.sym} 65220 -32390 0 1 {name=p64392 lab=_52722_/B }
C {sky130_stdcells/inv_2.sym} 65180 -32390 0 0 {name=X_46870_ }
C {devices/lab_pin.sym} 65140 -32270 0 0 {name=p64393 lab=_84794_/Q }
C {devices/lab_pin.sym} 65220 -32270 0 1 {name=p64394 lab=_58856_/Y }
C {sky130_stdcells/inv_2.sym} 65180 -32270 0 0 {name=X_58856_ }
C {devices/lab_pin.sym} 65120 -32170 0 0 {name=p64395 lab=_77687_/Y }
C {devices/lab_pin.sym} 65120 -32130 0 0 {name=p64396 lab=_77690_/B }
C {devices/lab_pin.sym} 65120 -32090 0 0 {name=p64397 lab=_77688_/Y }
C {devices/lab_pin.sym} 65240 -32130 0 1 {name=p64398 lab=_77690_/Y }
C {sky130_stdcells/nand3_4.sym} 65180 -32130 0 0 {name=X_77690_ }
C {devices/lab_pin.sym} 65090 -31990 0 0 {name=p64399 lab=_86861_/CLK }
C {devices/lab_pin.sym} 65090 -31970 0 0 {name=p64400 lab=_45262_/Y }
C {devices/lab_pin.sym} 65270 -31990 0 1 {name=p64401 lab=_62544_/A }
C {sky130_stdcells/dfxtp_4.sym} 65180 -31980 0 0 {name=X_86888_ }
C {devices/lab_pin.sym} 65100 -31870 0 0 {name=p64402 lab=_45819_/X }
C {devices/lab_pin.sym} 65100 -31830 0 0 {name=p64403 lab=_61655_/A }
C {devices/lab_pin.sym} 65100 -31790 0 0 {name=p64404 lab=_45765_/X }
C {devices/lab_pin.sym} 65260 -31830 0 1 {name=p64405 lab=_45821_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -31830 0 0 {name=X_45821_ }
C {devices/lab_pin.sym} 65120 -31700 0 0 {name=p64406 lab=_57806_/X }
C {devices/lab_pin.sym} 65120 -31660 0 0 {name=p64407 lab=_86332_/Q }
C {devices/lab_pin.sym} 65240 -31680 0 1 {name=p64408 lab=_57807_/Y }
C {sky130_stdcells/nor2_4.sym} 65180 -31680 0 0 {name=X_57807_ }
C {devices/lab_pin.sym} 65120 -31560 0 0 {name=p64409 lab=_76639_/Y }
C {devices/lab_pin.sym} 65120 -31520 0 0 {name=p64410 lab=_76640_/Y }
C {devices/lab_pin.sym} 65240 -31540 0 1 {name=p64411 lab=_76643_/A }
C {sky130_stdcells/nand2_4.sym} 65180 -31540 0 0 {name=X_76641_ }
C {devices/lab_pin.sym} 65100 -31440 0 0 {name=p64412 lab=_73850_/X }
C {devices/lab_pin.sym} 65100 -31400 0 0 {name=p64413 lab=_86229_/Q }
C {devices/lab_pin.sym} 65100 -31360 0 0 {name=p64414 lab=_73804_/X }
C {devices/lab_pin.sym} 65100 -31320 0 0 {name=p64415 lab=_73852_/X }
C {devices/lab_pin.sym} 65260 -31380 0 1 {name=p64416 lab=_73853_/X }
C {sky130_stdcells/a211o_4.sym} 65180 -31380 0 0 {name=X_73853_ }
C {devices/lab_pin.sym} 65090 -31230 0 0 {name=p64417 lab=_86256_/CLK }
C {devices/lab_pin.sym} 65090 -31210 0 0 {name=p64418 lab=_85839_/D }
C {devices/lab_pin.sym} 65270 -31230 0 1 {name=p64419 lab=_85839_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -31220 0 0 {name=X_85839_ }
C {devices/lab_pin.sym} 65140 -31090 0 0 {name=p64420 lab=_59061_/A }
C {devices/lab_pin.sym} 65220 -31090 0 1 {name=p64421 lab=_58787_/X }
C {sky130_stdcells/buf_2.sym} 65180 -31090 0 0 {name=X_58787_ }
C {devices/lab_pin.sym} 65120 -31000 0 0 {name=p64422 lab=_55997_/X }
C {devices/lab_pin.sym} 65120 -30960 0 0 {name=p64423 lab=_74312_/C }
C {devices/lab_pin.sym} 65120 -30920 0 0 {name=p64424 lab=_55928_/B }
C {devices/lab_pin.sym} 65120 -30880 0 0 {name=p64425 lab=_55928_/C }
C {devices/lab_pin.sym} 65240 -30940 0 1 {name=p64426 lab=_55999_/X }
C {sky130_stdcells/and4_4.sym} 65180 -30940 0 0 {name=X_55999_ }
C {devices/lab_pin.sym} 65120 -30800 0 0 {name=p64427 lab=_48604_/A }
C {devices/lab_pin.sym} 65120 -30760 0 0 {name=p64428 lab=_48540_/B }
C {devices/lab_pin.sym} 65240 -30780 0 1 {name=p64429 lab=_48540_/Y }
C {sky130_stdcells/nand2_4.sym} 65180 -30780 0 0 {name=X_48540_ }
C {devices/lab_pin.sym} 65100 -30670 0 0 {name=p64430 lab=_69597_/B }
C {devices/lab_pin.sym} 65100 -30630 0 0 {name=p64431 lab=_72803_/X }
C {devices/lab_pin.sym} 65100 -30590 0 0 {name=p64432 lab=_72776_/X }
C {devices/lab_pin.sym} 65260 -30630 0 1 {name=p64433 lab=_72804_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -30630 0 0 {name=X_72804_ }
C {devices/lab_pin.sym} 65120 -30500 0 0 {name=p64434 lab=_79351_/X }
C {devices/lab_pin.sym} 65120 -30460 0 0 {name=p64435 lab=_79360_/B }
C {devices/lab_pin.sym} 65240 -30480 0 1 {name=p64436 lab=_79360_/Y }
C {sky130_stdcells/nand2_4.sym} 65180 -30480 0 0 {name=X_79360_ }
C {devices/lab_pin.sym} 65140 -30350 0 0 {name=p64437 lab=_85098_/Q }
C {devices/lab_pin.sym} 65220 -30350 0 1 {name=p64438 lab=_45752_/Y }
C {sky130_stdcells/inv_2.sym} 65180 -30350 0 0 {name=X_45752_ }
C {devices/lab_pin.sym} 65100 -30250 0 0 {name=p64439 lab=_46224_/X }
C {devices/lab_pin.sym} 65100 -30210 0 0 {name=p64440 lab=_85407_/Q }
C {devices/lab_pin.sym} 65100 -30170 0 0 {name=p64441 lab=_57737_/X }
C {devices/lab_pin.sym} 65260 -30210 0 1 {name=p64442 lab=_57738_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -30210 0 0 {name=X_57738_ }
C {devices/lab_pin.sym} 65140 -30070 0 0 {name=p64443 lab=_76572_/A }
C {devices/lab_pin.sym} 65220 -30070 0 1 {name=p64444 lab=_76572_/Y }
C {sky130_stdcells/inv_2.sym} 65180 -30070 0 0 {name=X_76572_ }
C {devices/lab_pin.sym} 65100 -29980 0 0 {name=p64445 lab=_40404_/X }
C {devices/lab_pin.sym} 65100 -29940 0 0 {name=p64446 lab=_42962_/X }
C {devices/lab_pin.sym} 65100 -29900 0 0 {name=p64447 lab=_87628_/Q }
C {devices/lab_pin.sym} 65100 -29860 0 0 {name=p64448 lab=_42963_/X }
C {devices/lab_pin.sym} 65260 -29920 0 1 {name=p64449 lab=_42964_/X }
C {sky130_stdcells/a2bb2o_4.sym} 65180 -29920 0 0 {name=X_42964_ }
C {devices/lab_pin.sym} 65100 -29800 0 0 {name=p64450 lab=_73735_/X }
C {devices/lab_pin.sym} 65100 -29760 0 0 {name=p64451 lab=_85624_/Q }
C {devices/lab_pin.sym} 65100 -29720 0 0 {name=p64452 lab=_73782_/X }
C {devices/lab_pin.sym} 65100 -29680 0 0 {name=p64453 lab=_73783_/X }
C {devices/lab_pin.sym} 65260 -29740 0 1 {name=p64454 lab=_73784_/X }
C {sky130_stdcells/a211o_4.sym} 65180 -29740 0 0 {name=X_73784_ }
C {devices/lab_pin.sym} 65100 -29610 0 0 {name=p64455 lab=_51328_/B }
C {devices/lab_pin.sym} 65100 -29570 0 0 {name=p64456 lab=_70983_/X }
C {devices/lab_pin.sym} 65100 -29530 0 0 {name=p64457 lab=_70995_/Y }
C {devices/lab_pin.sym} 65260 -29570 0 1 {name=p64458 lab=_70996_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -29570 0 0 {name=X_70996_ }
C {devices/lab_pin.sym} 65120 -29440 0 0 {name=p64459 lab=_78308_/Y }
C {devices/lab_pin.sym} 65120 -29400 0 0 {name=p64460 lab=_78310_/Y }
C {devices/lab_pin.sym} 65240 -29420 0 1 {name=p64461 lab=_78311_/Y }
C {sky130_stdcells/nor2_4.sym} 65180 -29420 0 0 {name=X_78311_ }
C {devices/lab_pin.sym} 65100 -29330 0 0 {name=p64462 lab=_44679_/X }
C {devices/lab_pin.sym} 65100 -29290 0 0 {name=p64463 lab=_44680_/X }
C {devices/lab_pin.sym} 65100 -29250 0 0 {name=p64464 lab=_40667_/X }
C {devices/lab_pin.sym} 65100 -29210 0 0 {name=p64465 lab=_86993_/Q }
C {devices/lab_pin.sym} 65100 -29170 0 0 {name=p64466 lab=_44681_/X }
C {devices/lab_pin.sym} 65260 -29250 0 1 {name=p64467 lab=_44704_/A }
C {sky130_stdcells/o32ai_4.sym} 65180 -29250 0 0 {name=X_44703_ }
C {devices/lab_pin.sym} 65100 -29110 0 0 {name=p64468 lab=_75519_/X }
C {devices/lab_pin.sym} 65100 -29070 0 0 {name=p64469 lab=_75520_/Y }
C {devices/lab_pin.sym} 65100 -29030 0 0 {name=p64470 lab=_75524_/B }
C {devices/lab_pin.sym} 65260 -29070 0 1 {name=p64471 lab=_75523_/X }
C {sky130_stdcells/a21o_4.sym} 65180 -29070 0 0 {name=X_75523_ }
C {devices/lab_pin.sym} 65090 -28930 0 0 {name=p64472 lab=_87790_/CLK }
C {devices/lab_pin.sym} 65090 -28910 0 0 {name=p64473 lab=_87509_/D }
C {devices/lab_pin.sym} 65270 -28930 0 1 {name=p64474 lab=_87509_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -28920 0 0 {name=X_87509_ }
C {devices/lab_pin.sym} 65100 -28830 0 0 {name=p64475 lab=_41887_/X }
C {devices/lab_pin.sym} 65100 -28790 0 0 {name=p64476 lab=_41888_/X }
C {devices/lab_pin.sym} 65100 -28750 0 0 {name=p64477 lab=_40633_/X }
C {devices/lab_pin.sym} 65100 -28710 0 0 {name=p64478 lab=_41914_/Y }
C {devices/lab_pin.sym} 65100 -28670 0 0 {name=p64479 lab=_41891_/X }
C {devices/lab_pin.sym} 65260 -28750 0 1 {name=p64480 lab=_88107_/D }
C {sky130_stdcells/o32ai_4.sym} 65180 -28750 0 0 {name=X_41915_ }
C {devices/lab_pin.sym} 65140 -28590 0 0 {name=p64481 lab=_73262_/A }
C {devices/lab_pin.sym} 65220 -28590 0 1 {name=p64482 lab=_72735_/X }
C {sky130_stdcells/buf_2.sym} 65180 -28590 0 0 {name=X_72735_ }
C {devices/lab_pin.sym} 65140 -28470 0 0 {name=p64483 lab=_48471_/A }
C {devices/lab_pin.sym} 65220 -28470 0 1 {name=p64484 lab=_48471_/X }
C {sky130_stdcells/buf_2.sym} 65180 -28470 0 0 {name=X_48471_ }
C {devices/lab_pin.sym} 65140 -28350 0 0 {name=p64485 lab=_79291_/A }
C {devices/lab_pin.sym} 65220 -28350 0 1 {name=p64486 lab=_79297_/A }
C {sky130_stdcells/inv_2.sym} 65180 -28350 0 0 {name=X_79291_ }
C {devices/lab_pin.sym} 65100 -28250 0 0 {name=p64487 lab=_45680_/X }
C {devices/lab_pin.sym} 65100 -28210 0 0 {name=p64488 lab=_45682_/Y }
C {devices/lab_pin.sym} 65100 -28170 0 0 {name=p64489 lab=_45561_/X }
C {devices/lab_pin.sym} 65260 -28210 0 1 {name=p64490 lab=_45683_/Y }
C {sky130_stdcells/a21oi_4.sym} 65180 -28210 0 0 {name=X_45683_ }
C {devices/lab_pin.sym} 65140 -28070 0 0 {name=p64491 lab=_84957_/Q }
C {devices/lab_pin.sym} 65220 -28070 0 1 {name=p64492 lab=_57670_/A }
C {sky130_stdcells/buf_2.sym} 65180 -28070 0 0 {name=X_57669_ }
C {devices/lab_pin.sym} 65140 -27950 0 0 {name=p64493 lab=_42846_/X }
C {devices/lab_pin.sym} 65220 -27950 0 1 {name=p64494 lab=_42895_/X }
C {sky130_stdcells/buf_2.sym} 65180 -27950 0 0 {name=X_42895_ }
C {devices/lab_pin.sym} 65120 -27840 0 0 {name=p64495 lab=_47404_/A }
C {devices/lab_pin.sym} 65120 -27800 0 0 {name=p64496 lab=_53041_/B }
C {devices/lab_pin.sym} 65240 -27820 0 1 {name=p64497 lab=_47422_/Y }
C {sky130_stdcells/nand2_4.sym} 65180 -27820 0 0 {name=X_47422_ }
C {devices/lab_pin.sym} 65100 -27710 0 0 {name=p64498 lab=_59394_/X }
C {devices/lab_pin.sym} 65100 -27670 0 0 {name=p64499 lab=_83485_/Q }
C {devices/lab_pin.sym} 65100 -27630 0 0 {name=p64500 lab=_59407_/Y }
C {devices/lab_pin.sym} 65260 -27670 0 1 {name=p64501 lab=_84741_/D }
C {sky130_stdcells/o21a_4.sym} 65180 -27670 0 0 {name=X_59408_ }
C {devices/lab_pin.sym} 65120 -27540 0 0 {name=p64502 lab=_78241_/A }
C {devices/lab_pin.sym} 65120 -27500 0 0 {name=p64503 lab=_78241_/B }
C {devices/lab_pin.sym} 65240 -27520 0 1 {name=p64504 lab=_78252_/C }
C {sky130_stdcells/nand2_4.sym} 65180 -27520 0 0 {name=X_78242_ }
C {devices/lab_pin.sym} 65100 -27430 0 0 {name=p64505 lab=_44622_/X }
C {devices/lab_pin.sym} 65100 -27390 0 0 {name=p64506 lab=_44623_/X }
C {devices/lab_pin.sym} 65100 -27350 0 0 {name=p64507 lab=_41021_/A }
C {devices/lab_pin.sym} 65100 -27310 0 0 {name=p64508 lab=_87024_/Q }
C {devices/lab_pin.sym} 65100 -27270 0 0 {name=p64509 lab=_44625_/X }
C {devices/lab_pin.sym} 65260 -27350 0 1 {name=p64510 lab=_44634_/Y }
C {sky130_stdcells/o32ai_4.sym} 65180 -27350 0 0 {name=X_44634_ }
C {devices/lab_pin.sym} 65120 -27200 0 0 {name=p64511 lab=_80700_/Q }
C {devices/lab_pin.sym} 65120 -27160 0 0 {name=p64512 lab=_80956_/D }
C {devices/lab_pin.sym} 65240 -27180 0 1 {name=p64513 lab=_75457_/B }
C {sky130_stdcells/nor2_4.sym} 65180 -27180 0 0 {name=X_75454_ }
C {devices/lab_pin.sym} 65140 -27050 0 0 {name=p64514 lab=_41846_/A }
C {devices/lab_pin.sym} 65220 -27050 0 1 {name=p64515 lab=_88125_/D }
C {sky130_stdcells/inv_2.sym} 65180 -27050 0 0 {name=X_41846_ }
C {devices/lab_pin.sym} 65140 -26930 0 0 {name=p64516 lab=_63630_/B }
C {devices/lab_pin.sym} 65220 -26930 0 1 {name=p64517 lab=_60732_/C }
C {sky130_stdcells/buf_2.sym} 65180 -26930 0 0 {name=X_60680_ }
C {devices/lab_pin.sym} 65120 -26830 0 0 {name=p64518 lab=_72668_/A }
C {devices/lab_pin.sym} 65120 -26790 0 0 {name=p64519 lab=_72668_/B }
C {devices/lab_pin.sym} 65120 -26750 0 0 {name=p64520 lab=_55503_/D }
C {devices/lab_pin.sym} 65240 -26790 0 1 {name=p64521 lab=_72666_/Y }
C {sky130_stdcells/nand3_4.sym} 65180 -26790 0 0 {name=X_72666_ }
C {devices/lab_pin.sym} 65140 -26650 0 0 {name=p64522 lab=_74492_/A }
C {devices/lab_pin.sym} 65220 -26650 0 1 {name=p64523 lab=_74405_/X }
C {sky130_stdcells/buf_2.sym} 65180 -26650 0 0 {name=X_74405_ }
C {devices/lab_pin.sym} 65120 -26540 0 0 {name=p64524 lab=_47333_/X }
C {devices/lab_pin.sym} 65120 -26500 0 0 {name=p64525 lab=_52999_/B }
C {devices/lab_pin.sym} 65240 -26520 0 1 {name=p64526 lab=_47353_/Y }
C {sky130_stdcells/nand2_4.sym} 65180 -26520 0 0 {name=X_47353_ }
C {devices/lab_pin.sym} 65140 -26390 0 0 {name=p64527 lab=_59043_/A }
C {devices/lab_pin.sym} 65220 -26390 0 1 {name=p64528 lab=_59339_/X }
C {sky130_stdcells/buf_2.sym} 65180 -26390 0 0 {name=X_59339_ }
C {devices/lab_pin.sym} 65100 -26290 0 0 {name=p64529 lab=_71604_/X }
C {devices/lab_pin.sym} 65100 -26250 0 0 {name=p64530 lab=_83437_/Q }
C {devices/lab_pin.sym} 65100 -26210 0 0 {name=p64531 lab=_71616_/Y }
C {devices/lab_pin.sym} 65260 -26250 0 1 {name=p64532 lab=_83437_/D }
C {sky130_stdcells/a21o_4.sym} 65180 -26250 0 0 {name=X_71617_ }
C {devices/lab_pin.sym} 65120 -26120 0 0 {name=p64533 lab=_78173_/A }
C {devices/lab_pin.sym} 65120 -26080 0 0 {name=p64534 lab=_78173_/B }
C {devices/lab_pin.sym} 65240 -26100 0 1 {name=p64535 lab=_78173_/X }
C {sky130_stdcells/xor2_4.sym} 65180 -26100 0 0 {name=X_78173_ }
C {devices/lab_pin.sym} 65140 -25970 0 0 {name=p64536 lab=_44547_/A }
C {devices/lab_pin.sym} 65220 -25970 0 1 {name=p64537 lab=_44565_/X }
C {sky130_stdcells/buf_2.sym} 65180 -25970 0 0 {name=X_44565_ }
C {devices/lab_pin.sym} 65140 -25850 0 0 {name=p64538 lab=_75384_/X }
C {devices/lab_pin.sym} 65220 -25850 0 1 {name=p64539 lab=_75386_/B }
C {sky130_stdcells/inv_2.sym} 65180 -25850 0 0 {name=X_75385_ }
C {devices/lab_pin.sym} 65100 -25750 0 0 {name=p64540 lab=_40621_/X }
C {devices/lab_pin.sym} 65100 -25710 0 0 {name=p64541 lab=_41435_/A }
C {devices/lab_pin.sym} 65100 -25670 0 0 {name=p64542 lab=_41776_/X }
C {devices/lab_pin.sym} 65260 -25710 0 1 {name=p64543 lab=_41777_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -25710 0 0 {name=X_41777_ }
C {devices/lab_pin.sym} 65120 -25590 0 0 {name=p64544 lab=_72528_/Y }
C {devices/lab_pin.sym} 65120 -25550 0 0 {name=p64545 lab=_72597_/B }
C {devices/lab_pin.sym} 65120 -25510 0 0 {name=p64546 lab=_72597_/C }
C {devices/lab_pin.sym} 65240 -25550 0 1 {name=p64547 lab=_72597_/Y }
C {sky130_stdcells/nand3_4.sym} 65180 -25550 0 0 {name=X_72597_ }
C {devices/lab_pin.sym} 65100 -25430 0 0 {name=p64548 lab=_46301_/X }
C {devices/lab_pin.sym} 65100 -25390 0 0 {name=p64549 lab=_82941_/Q }
C {devices/lab_pin.sym} 65100 -25350 0 0 {name=p64550 lab=_46303_/Y }
C {devices/lab_pin.sym} 65260 -25390 0 1 {name=p64551 lab=_53964_/A }
C {sky130_stdcells/o21ai_4.sym} 65180 -25390 0 0 {name=X_46304_ }
C {devices/lab_pin.sym} 65120 -25260 0 0 {name=p64552 lab=_77143_/B }
C {devices/lab_pin.sym} 65120 -25220 0 0 {name=p64553 lab=_81916_/Q }
C {devices/lab_pin.sym} 65240 -25240 0 1 {name=p64554 lab=_77141_/A }
C {sky130_stdcells/xor2_4.sym} 65180 -25240 0 0 {name=X_77124_ }
C {devices/lab_pin.sym} 65100 -25150 0 0 {name=p64555 lab=_43495_/X }
C {devices/lab_pin.sym} 65100 -25110 0 0 {name=p64556 lab=_43503_/X }
C {devices/lab_pin.sym} 65100 -25070 0 0 {name=p64557 lab=_41786_/X }
C {devices/lab_pin.sym} 65100 -25030 0 0 {name=p64558 lab=_87381_/Q }
C {devices/lab_pin.sym} 65100 -24990 0 0 {name=p64559 lab=_43506_/X }
C {devices/lab_pin.sym} 65260 -25070 0 1 {name=p64560 lab=_43516_/Y }
C {sky130_stdcells/o32ai_4.sym} 65180 -25070 0 0 {name=X_43516_ }
C {devices/lab_pin.sym} 65120 -24940 0 0 {name=p64561 lab=_61438_/X }
C {devices/lab_pin.sym} 65120 -24900 0 0 {name=p64562 lab=_62309_/B }
C {devices/lab_pin.sym} 65120 -24860 0 0 {name=p64563 lab=_62309_/C }
C {devices/lab_pin.sym} 65120 -24820 0 0 {name=p64564 lab=_62225_/X }
C {devices/lab_pin.sym} 65240 -24880 0 1 {name=p64565 lab=_62351_/D }
C {sky130_stdcells/nand4_4.sym} 65180 -24880 0 0 {name=X_62350_ }
C {devices/lab_pin.sym} 65120 -24750 0 0 {name=p64566 lab=_74338_/A }
C {devices/lab_pin.sym} 65120 -24710 0 0 {name=p64567 lab=_74338_/B }
C {devices/lab_pin.sym} 65120 -24670 0 0 {name=p64568 lab=_55811_/X }
C {devices/lab_pin.sym} 65240 -24710 0 1 {name=p64569 lab=_74336_/Y }
C {sky130_stdcells/nand3_4.sym} 65180 -24710 0 0 {name=X_74336_ }
C {devices/lab_pin.sym} 65100 -24590 0 0 {name=p64570 lab=_40670_/X }
C {devices/lab_pin.sym} 65100 -24550 0 0 {name=p64571 lab=_40897_/A }
C {devices/lab_pin.sym} 65100 -24510 0 0 {name=p64572 lab=_40727_/X }
C {devices/lab_pin.sym} 65260 -24550 0 1 {name=p64573 lab=_40729_/A }
C {sky130_stdcells/o21ai_4.sym} 65180 -24550 0 0 {name=X_40728_ }
C {devices/lab_pin.sym} 65120 -24440 0 0 {name=p64574 lab=_47246_/X }
C {devices/lab_pin.sym} 65120 -24400 0 0 {name=p64575 lab=_47311_/B }
C {devices/lab_pin.sym} 65120 -24360 0 0 {name=p64576 lab=_47321_/C }
C {devices/lab_pin.sym} 65120 -24320 0 0 {name=p64577 lab=_52963_/D }
C {devices/lab_pin.sym} 65240 -24380 0 1 {name=p64578 lab=_47284_/X }
C {sky130_stdcells/and4_4.sym} 65180 -24380 0 0 {name=X_47284_ }
C {devices/lab_pin.sym} 65120 -24250 0 0 {name=p64579 lab=_71411_/A }
C {devices/lab_pin.sym} 65120 -24210 0 0 {name=p64580 lab=_71546_/B }
C {devices/lab_pin.sym} 65120 -24170 0 0 {name=p64581 lab=_71536_/A }
C {devices/lab_pin.sym} 65240 -24210 0 1 {name=p64582 lab=_71548_/Y }
C {sky130_stdcells/nor3_4.sym} 65180 -24210 0 0 {name=X_71548_ }
C {devices/lab_pin.sym} 65140 -24070 0 0 {name=p64583 lab=_44547_/A }
C {devices/lab_pin.sym} 65220 -24070 0 1 {name=p64584 lab=_44496_/X }
C {sky130_stdcells/buf_2.sym} 65180 -24070 0 0 {name=X_44496_ }
C {devices/lab_pin.sym} 65100 -23970 0 0 {name=p64585 lab=_49017_/Y }
C {devices/lab_pin.sym} 65100 -23930 0 0 {name=p64586 lab=_48985_/X }
C {devices/lab_pin.sym} 65100 -23890 0 0 {name=p64587 lab=_49022_/X }
C {devices/lab_pin.sym} 65260 -23930 0 1 {name=p64588 lab=_49023_/Y }
C {sky130_stdcells/a21oi_4.sym} 65180 -23930 0 0 {name=X_49023_ }
C {devices/lab_pin.sym} 65140 -23790 0 0 {name=p64589 lab=_84857_/Q }
C {devices/lab_pin.sym} 65220 -23790 0 1 {name=p64590 lab=_61301_/X }
C {sky130_stdcells/buf_2.sym} 65180 -23790 0 0 {name=X_61301_ }
C {devices/lab_pin.sym} 65140 -23670 0 0 {name=p64591 lab=_46234_/Y }
C {devices/lab_pin.sym} 65220 -23670 0 1 {name=p64592 lab=_56777_/B }
C {sky130_stdcells/buf_2.sym} 65180 -23670 0 0 {name=X_46235_ }
C {sky130_stdcells/decap_3.sym} 65180 -23520 0 0 {name=XPHY_470 }
C {devices/lab_pin.sym} 65120 -23380 0 0 {name=p64593 lab=_77047_/B }
C {devices/lab_pin.sym} 65120 -23340 0 0 {name=p64594 lab=_77055_/B }
C {devices/lab_pin.sym} 65240 -23360 0 1 {name=p64595 lab=_77055_/Y }
C {sky130_stdcells/nor2_4.sym} 65180 -23360 0 0 {name=X_77055_ }
C {devices/lab_pin.sym} 65140 -23230 0 0 {name=p64596 lab=_43397_/A }
C {devices/lab_pin.sym} 65220 -23230 0 1 {name=p64597 lab=_43447_/X }
C {sky130_stdcells/buf_2.sym} 65180 -23230 0 0 {name=X_43447_ }
C {devices/lab_pin.sym} 65100 -23150 0 0 {name=p64598 lab=_61375_/B }
C {devices/lab_pin.sym} 65100 -23110 0 0 {name=p64599 lab=_62278_/X }
C {devices/lab_pin.sym} 65100 -23070 0 0 {name=p64600 lab=_60027_/A }
C {devices/lab_pin.sym} 65100 -23030 0 0 {name=p64601 lab=_60011_/X }
C {devices/lab_pin.sym} 65100 -23000 0 0 {name=p64602 lab=_62280_/X }
C {devices/lab_pin.sym} 65260 -23070 0 1 {name=p64603 lab=_62281_/X }
C {sky130_stdcells/a41o_4.sym} 65180 -23070 0 0 {name=X_62281_ }
C {devices/lab_pin.sym} 65100 -22940 0 0 {name=p64604 lab=_69114_/B }
C {devices/lab_pin.sym} 65100 -22900 0 0 {name=p64605 lab=_73124_/B }
C {devices/lab_pin.sym} 65100 -22860 0 0 {name=p64606 lab=_73920_/X }
C {devices/lab_pin.sym} 65100 -22820 0 0 {name=p64607 lab=_74266_/Y }
C {devices/lab_pin.sym} 65260 -22880 0 1 {name=p64608 lab=_74267_/X }
C {sky130_stdcells/a211o_4.sym} 65180 -22880 0 0 {name=X_74267_ }
C {sky130_stdcells/decap_3.sym} 65180 -22700 0 0 {name=XPHY_481 }
C {devices/lab_pin.sym} 65120 -22560 0 0 {name=p64609 lab=_40659_/A }
C {devices/lab_pin.sym} 65120 -22520 0 0 {name=p64610 lab=_40654_/B }
C {devices/lab_pin.sym} 65240 -22540 0 1 {name=p64611 lab=_40659_/X }
C {sky130_stdcells/or2_4.sym} 65180 -22540 0 0 {name=X_40659_ }
C {devices/lab_pin.sym} 65120 -22440 0 0 {name=p64612 lab=_71827_/A }
C {devices/lab_pin.sym} 65120 -22400 0 0 {name=p64613 lab=_71479_/B }
C {devices/lab_pin.sym} 65120 -22360 0 0 {name=p64614 lab=_71435_/C }
C {devices/lab_pin.sym} 65120 -22320 0 0 {name=p64615 lab=_71716_/D }
C {devices/lab_pin.sym} 65240 -22380 0 1 {name=p64616 lab=_71479_/X }
C {sky130_stdcells/and4_4.sym} 65180 -22380 0 0 {name=X_71479_ }
C {sky130_stdcells/decap_3.sym} 65180 -22200 0 0 {name=XPHY_492 }
C {devices/lab_pin.sym} 65120 -22070 0 0 {name=p64617 lab=_64053_/A }
C {devices/lab_pin.sym} 65120 -22030 0 0 {name=p64618 lab=_58438_/A }
C {devices/lab_pin.sym} 65120 -21990 0 0 {name=p64619 lab=_64071_/C }
C {devices/lab_pin.sym} 65240 -22030 0 1 {name=p64620 lab=_64020_/X }
C {sky130_stdcells/and3_4.sym} 65180 -22030 0 0 {name=X_64020_ }
C {devices/lab_pin.sym} 65120 -21900 0 0 {name=p64621 lab=_75994_/Y }
C {devices/lab_pin.sym} 65120 -21860 0 0 {name=p64622 lab=_76006_/B }
C {devices/lab_pin.sym} 65240 -21880 0 1 {name=p64623 lab=_76009_/A }
C {sky130_stdcells/nand2_4.sym} 65180 -21880 0 0 {name=X_76006_ }
C {devices/lab_pin.sym} 65140 -21750 0 0 {name=p64624 lab=_64223_/A }
C {devices/lab_pin.sym} 65220 -21750 0 1 {name=p64625 lab=_61232_/X }
C {sky130_stdcells/buf_2.sym} 65180 -21750 0 0 {name=X_61232_ }
C {devices/lab_pin.sym} 65120 -21640 0 0 {name=p64626 lab=_48550_/Y }
C {devices/lab_pin.sym} 65120 -21600 0 0 {name=p64627 lab=_73217_/Y }
C {devices/lab_pin.sym} 65240 -21620 0 1 {name=p64628 lab=_73218_/X }
C {sky130_stdcells/xor2_4.sym} 65180 -21620 0 0 {name=X_73218_ }
C {devices/lab_pin.sym} 65120 -21510 0 0 {name=p64629 lab=_46166_/A }
C {devices/lab_pin.sym} 65120 -21470 0 0 {name=p64630 lab=_45886_/X }
C {devices/lab_pin.sym} 65120 -21430 0 0 {name=p64631 lab=_46166_/C }
C {devices/lab_pin.sym} 65240 -21470 0 1 {name=p64632 lab=_46167_/A }
C {sky130_stdcells/and3_4.sym} 65180 -21470 0 0 {name=X_46166_ }
C {devices/lab_pin.sym} 65140 -21330 0 0 {name=p64633 lab=_43329_/X }
C {devices/lab_pin.sym} 65220 -21330 0 1 {name=p64634 lab=_43378_/X }
C {sky130_stdcells/buf_2.sym} 65180 -21330 0 0 {name=X_43378_ }
C {devices/lab_pin.sym} 65100 -21240 0 0 {name=p64635 lab=_74155_/X }
C {devices/lab_pin.sym} 65100 -21200 0 0 {name=p64636 lab=_84966_/Q }
C {devices/lab_pin.sym} 65100 -21160 0 0 {name=p64637 lab=_72992_/X }
C {devices/lab_pin.sym} 65100 -21120 0 0 {name=p64638 lab=_74197_/X }
C {devices/lab_pin.sym} 65260 -21180 0 1 {name=p64639 lab=_74198_/X }
C {sky130_stdcells/a211o_4.sym} 65180 -21180 0 0 {name=X_74198_ }
C {devices/lab_pin.sym} 65100 -21050 0 0 {name=p64640 lab=_55857_/B }
C {devices/lab_pin.sym} 65100 -21010 0 0 {name=p64641 lab=_45060_/X }
C {devices/lab_pin.sym} 65100 -20970 0 0 {name=p64642 lab=_45116_/X }
C {devices/lab_pin.sym} 65260 -21010 0 1 {name=p64643 lab=_45117_/X }
C {sky130_stdcells/o21a_4.sym} 65180 -21010 0 0 {name=X_45117_ }
C {devices/lab_pin.sym} 65140 -20870 0 0 {name=p64644 lab=_43161_/A }
C {devices/lab_pin.sym} 65220 -20870 0 1 {name=p64645 lab=_42417_/A }
C {sky130_stdcells/buf_2.sym} 65180 -20870 0 0 {name=X_42329_ }
C {devices/lab_pin.sym} 65100 -20770 0 0 {name=p64646 lab=_61095_/X }
C {devices/lab_pin.sym} 65100 -20730 0 0 {name=p64647 lab=_61109_/X }
C {devices/lab_pin.sym} 65100 -20690 0 0 {name=p64648 lab=_59691_/X }
C {devices/lab_pin.sym} 65260 -20730 0 1 {name=p64649 lab=_61163_/Y }
C {sky130_stdcells/a21oi_4.sym} 65180 -20730 0 0 {name=X_61163_ }
C {devices/lab_pin.sym} 65120 -20600 0 0 {name=p64650 lab=_73149_/A }
C {devices/lab_pin.sym} 65120 -20560 0 0 {name=p64651 lab=_72896_/B }
C {devices/lab_pin.sym} 65240 -20580 0 1 {name=p64652 lab=_73149_/Y }
C {sky130_stdcells/nor2_4.sym} 65180 -20580 0 0 {name=X_73149_ }
C {devices/lab_pin.sym} 65140 -20450 0 0 {name=p64653 lab=_46097_/A }
C {devices/lab_pin.sym} 65220 -20450 0 1 {name=p64654 lab=_46098_/A }
C {sky130_stdcells/buf_2.sym} 65180 -20450 0 0 {name=X_46097_ }
C {devices/lab_pin.sym} 65120 -20350 0 0 {name=p64655 lab=_60125_/A }
C {devices/lab_pin.sym} 65120 -20310 0 0 {name=p64656 lab=_60103_/B }
C {devices/lab_pin.sym} 65120 -20270 0 0 {name=p64657 lab=_84659_/Q }
C {devices/lab_pin.sym} 65240 -20310 0 1 {name=p64658 lab=_60114_/Y }
C {sky130_stdcells/nor3_4.sym} 65180 -20310 0 0 {name=X_60114_ }
C {devices/lab_pin.sym} 65140 -20170 0 0 {name=p64659 lab=_49925_/A }
C {devices/lab_pin.sym} 65220 -20170 0 1 {name=p64660 lab=_49925_/X }
C {sky130_stdcells/buf_2.sym} 65180 -20170 0 0 {name=X_49925_ }
C {devices/lab_pin.sym} 65120 -20060 0 0 {name=p64661 lab=_45046_/Y }
C {devices/lab_pin.sym} 65120 -20020 0 0 {name=p64662 lab=_45067_/B }
C {devices/lab_pin.sym} 65240 -20040 0 1 {name=p64663 lab=_45048_/Y }
C {sky130_stdcells/nand2_4.sym} 65180 -20040 0 0 {name=X_45048_ }
C {devices/lab_pin.sym} 65100 -19930 0 0 {name=p64664 lab=_65968_/Y }
C {devices/lab_pin.sym} 65100 -19890 0 0 {name=p64665 lab=_65915_/X }
C {devices/lab_pin.sym} 65100 -19850 0 0 {name=p64666 lab=_65970_/X }
C {devices/lab_pin.sym} 65260 -19890 0 1 {name=p64667 lab=_84165_/D }
C {sky130_stdcells/a21o_4.sym} 65180 -19890 0 0 {name=X_65971_ }
C {devices/lab_pin.sym} 65140 -19750 0 0 {name=p64668 lab=_61107_/A }
C {devices/lab_pin.sym} 65220 -19750 0 1 {name=p64669 lab=_61153_/A }
C {sky130_stdcells/buf_2.sym} 65180 -19750 0 0 {name=X_61094_ }
C {devices/lab_pin.sym} 65120 -19640 0 0 {name=p64670 lab=_77957_/A }
C {devices/lab_pin.sym} 65120 -19600 0 0 {name=p64671 lab=_77956_/Y }
C {devices/lab_pin.sym} 65240 -19620 0 1 {name=p64672 lab=_77958_/B }
C {sky130_stdcells/xnor2_4.sym} 65180 -19620 0 0 {name=X_77957_ }
C {devices/lab_pin.sym} 65100 -19510 0 0 {name=p64673 lab=_67705_/X }
C {devices/lab_pin.sym} 65100 -19470 0 0 {name=p64674 lab=_67708_/X }
C {devices/lab_pin.sym} 65100 -19430 0 0 {name=p64675 lab=_67709_/X }
C {devices/lab_pin.sym} 65260 -19470 0 1 {name=p64676 lab=_67710_/Y }
C {sky130_stdcells/a21oi_4.sym} 65180 -19470 0 0 {name=X_67710_ }
C {devices/lab_pin.sym} 65100 -19350 0 0 {name=p64677 lab=_64917_/X }
C {devices/lab_pin.sym} 65100 -19310 0 0 {name=p64678 lab=_64921_/X }
C {devices/lab_pin.sym} 65100 -19270 0 0 {name=p64679 lab=_64851_/X }
C {devices/lab_pin.sym} 65260 -19310 0 1 {name=p64680 lab=_64926_/A }
C {sky130_stdcells/a21o_4.sym} 65180 -19310 0 0 {name=X_64922_ }
C {devices/lab_pin.sym} 65120 -19180 0 0 {name=p64681 lab=_76906_/Y }
C {devices/lab_pin.sym} 65120 -19140 0 0 {name=p64682 lab=_76934_/A }
C {devices/lab_pin.sym} 65240 -19160 0 1 {name=p64683 lab=_76931_/A }
C {sky130_stdcells/xor2_4.sym} 65180 -19160 0 0 {name=X_76908_ }
C {devices/lab_pin.sym} 65120 -19050 0 0 {name=p64684 lab=_60058_/B }
C {devices/lab_pin.sym} 65120 -19010 0 0 {name=p64685 lab=_60079_/B }
C {devices/lab_pin.sym} 65120 -18970 0 0 {name=p64686 lab=_60027_/X }
C {devices/lab_pin.sym} 65240 -19010 0 1 {name=p64687 lab=_60045_/Y }
C {sky130_stdcells/nand3_4.sym} 65180 -19010 0 0 {name=X_60045_ }
C {devices/lab_pin.sym} 65100 -18890 0 0 {name=p64688 lab=_58070_/B }
C {devices/lab_pin.sym} 65100 -18850 0 0 {name=p64689 lab=_49853_/X }
C {devices/lab_pin.sym} 65100 -18810 0 0 {name=p64690 lab=_49855_/Y }
C {devices/lab_pin.sym} 65260 -18850 0 1 {name=p64691 lab=_49856_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -18850 0 0 {name=X_49856_ }
C {devices/lab_pin.sym} 65100 -18730 0 0 {name=p64692 lab=_80821_/D }
C {devices/lab_pin.sym} 65100 -18690 0 0 {name=p64693 lab=_68586_/X }
C {devices/lab_pin.sym} 65100 -18650 0 0 {name=p64694 lab=_68689_/X }
C {devices/lab_pin.sym} 65260 -18690 0 1 {name=p64695 lab=_68690_/X }
C {sky130_stdcells/a21bo_4.sym} 65180 -18690 0 0 {name=X_68690_ }
C {devices/lab_pin.sym} 65120 -18560 0 0 {name=p64696 lab=_82163_/Q }
C {devices/lab_pin.sym} 65120 -18520 0 0 {name=p64697 lab=_77888_/B }
C {devices/lab_pin.sym} 65240 -18540 0 1 {name=p64698 lab=_82131_/D }
C {sky130_stdcells/xor2_4.sym} 65180 -18540 0 0 {name=X_77888_ }
C {devices/lab_pin.sym} 65140 -18410 0 0 {name=p64699 lab=_47832_/X }
C {devices/lab_pin.sym} 65220 -18410 0 1 {name=p64700 lab=_48808_/A }
C {sky130_stdcells/buf_2.sym} 65180 -18410 0 0 {name=X_48807_ }
C {devices/lab_pin.sym} 65140 -18290 0 0 {name=p64701 lab=_67997_/A }
C {devices/lab_pin.sym} 65220 -18290 0 1 {name=p64702 lab=_67641_/X }
C {sky130_stdcells/buf_2.sym} 65180 -18290 0 0 {name=X_67641_ }
C {devices/lab_pin.sym} 65140 -18170 0 0 {name=p64703 lab=_79626_/Y }
C {devices/lab_pin.sym} 65220 -18170 0 1 {name=p64704 lab=_79627_/Y }
C {sky130_stdcells/inv_2.sym} 65180 -18170 0 0 {name=X_79627_ }
C {devices/lab_pin.sym} 65120 -18060 0 0 {name=p64705 lab=_64773_/A }
C {devices/lab_pin.sym} 65120 -18020 0 0 {name=p64706 lab=_86456_/Q }
C {devices/lab_pin.sym} 65240 -18040 0 1 {name=p64707 lab=_64853_/X }
C {sky130_stdcells/and2_4.sym} 65180 -18040 0 0 {name=X_64853_ }
C {devices/lab_pin.sym} 65140 -17910 0 0 {name=p64708 lab=_76839_/A }
C {devices/lab_pin.sym} 65220 -17910 0 1 {name=p64709 lab=_76841_/A }
C {sky130_stdcells/inv_2.sym} 65180 -17910 0 0 {name=X_76839_ }
C {devices/lab_pin.sym} 65140 -17790 0 0 {name=p64710 lab=_49787_/A }
C {devices/lab_pin.sym} 65220 -17790 0 1 {name=p64711 lab=_49787_/X }
C {sky130_stdcells/buf_2.sym} 65180 -17790 0 0 {name=X_49787_ }
C {devices/lab_pin.sym} 65140 -17670 0 0 {name=p64712 lab=_46999_/A }
C {devices/lab_pin.sym} 65220 -17670 0 1 {name=p64713 lab=_52797_/D }
C {sky130_stdcells/buf_2.sym} 65180 -17670 0 0 {name=X_46999_ }
C {devices/lab_pin.sym} 65140 -17550 0 0 {name=p64714 lab=clkbuf_9_275_0_CLK/X }
C {devices/lab_pin.sym} 65220 -17550 0 1 {name=p64715 lab=_81746_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 65180 -17550 0 0 {name=Xclkbuf_10_550_0_CLK }
C {devices/lab_pin.sym} 65140 -17430 0 0 {name=p64716 lab=clkbuf_6_41_0_CLK/A }
C {devices/lab_pin.sym} 65220 -17430 0 1 {name=p64717 lab=clkbuf_7_83_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 65180 -17430 0 0 {name=Xclkbuf_6_41_0_CLK }
C {devices/lab_pin.sym} 65120 -17340 0 0 {name=p64718 lab=_63410_/B }
C {devices/lab_pin.sym} 65120 -17300 0 0 {name=p64719 lab=_63820_/B }
C {devices/lab_pin.sym} 65120 -17260 0 0 {name=p64720 lab=_63753_/C }
C {devices/lab_pin.sym} 65120 -17220 0 0 {name=p64721 lab=_63820_/D }
C {devices/lab_pin.sym} 65240 -17280 0 1 {name=p64722 lab=_63804_/Y }
C {sky130_stdcells/nand4_4.sym} 65180 -17280 0 0 {name=X_63804_ }
C {devices/lab_pin.sym} 65100 -17150 0 0 {name=p64723 lab=_72911_/B }
C {devices/lab_pin.sym} 65100 -17110 0 0 {name=p64724 lab=_48730_/X }
C {devices/lab_pin.sym} 65100 -17070 0 0 {name=p64725 lab=_48737_/Y }
C {devices/lab_pin.sym} 65260 -17110 0 1 {name=p64726 lab=_48738_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -17110 0 0 {name=X_48738_ }
C {devices/lab_pin.sym} 65120 -16980 0 0 {name=p64727 lab=_67572_/A }
C {devices/lab_pin.sym} 65120 -16940 0 0 {name=p64728 lab=_86933_/Q }
C {devices/lab_pin.sym} 65240 -16960 0 1 {name=p64729 lab=_67572_/X }
C {sky130_stdcells/and2_4.sym} 65180 -16960 0 0 {name=X_67572_ }
C {devices/lab_pin.sym} 65120 -16840 0 0 {name=p64730 lab=_79558_/A }
C {devices/lab_pin.sym} 65120 -16800 0 0 {name=p64731 lab=_79558_/B }
C {devices/lab_pin.sym} 65240 -16820 0 1 {name=p64732 lab=_79558_/Y }
C {sky130_stdcells/nand2_4.sym} 65180 -16820 0 0 {name=X_79558_ }
C {devices/lab_pin.sym} 65120 -16700 0 0 {name=p64733 lab=_64810_/A }
C {devices/lab_pin.sym} 65120 -16660 0 0 {name=p64734 lab=_64784_/B }
C {devices/lab_pin.sym} 65240 -16680 0 1 {name=p64735 lab=_64784_/X }
C {sky130_stdcells/and2_4.sym} 65180 -16680 0 0 {name=X_64784_ }
C {devices/lab_pin.sym} 65120 -16580 0 0 {name=p64736 lab=_61538_/B }
C {devices/lab_pin.sym} 65120 -16540 0 0 {name=p64737 lab=_61995_/X }
C {devices/lab_pin.sym} 65120 -16500 0 0 {name=p64738 lab=_61953_/C }
C {devices/lab_pin.sym} 65120 -16460 0 0 {name=p64739 lab=_61937_/X }
C {devices/lab_pin.sym} 65240 -16520 0 1 {name=p64740 lab=_62000_/C }
C {sky130_stdcells/nand4_4.sym} 65180 -16520 0 0 {name=X_61996_ }
C {devices/lab_pin.sym} 65100 -16390 0 0 {name=p64741 lab=_69307_/X }
C {devices/lab_pin.sym} 65100 -16350 0 0 {name=p64742 lab=_69310_/X }
C {devices/lab_pin.sym} 65100 -16310 0 0 {name=p64743 lab=_69171_/X }
C {devices/lab_pin.sym} 65260 -16350 0 1 {name=p64744 lab=_69311_/Y }
C {sky130_stdcells/a21oi_4.sym} 65180 -16350 0 0 {name=X_69311_ }
C {devices/lab_pin.sym} 65140 -16210 0 0 {name=p64745 lab=_65464_/A }
C {devices/lab_pin.sym} 65220 -16210 0 1 {name=p64746 lab=_66524_/B }
C {sky130_stdcells/buf_2.sym} 65180 -16210 0 0 {name=X_66523_ }
C {devices/lab_pin.sym} 65100 -16110 0 0 {name=p64747 lab=_78505_/X }
C {devices/lab_pin.sym} 65100 -16070 0 0 {name=p64748 lab=_78510_/C }
C {devices/lab_pin.sym} 65100 -16030 0 0 {name=p64749 lab=_78508_/Y }
C {devices/lab_pin.sym} 65260 -16070 0 1 {name=p64750 lab=_78511_/A }
C {sky130_stdcells/a21o_4.sym} 65180 -16070 0 0 {name=X_78509_ }
C {devices/lab_pin.sym} 65140 -15930 0 0 {name=p64751 lab=_63735_/A }
C {devices/lab_pin.sym} 65220 -15930 0 1 {name=p64752 lab=_64136_/B }
C {sky130_stdcells/buf_2.sym} 65180 -15930 0 0 {name=X_63735_ }
C {devices/lab_pin.sym} 65140 -15810 0 0 {name=p64753 lab=_48612_/A }
C {devices/lab_pin.sym} 65220 -15810 0 1 {name=p64754 lab=_48669_/X }
C {sky130_stdcells/buf_2.sym} 65180 -15810 0 0 {name=X_48669_ }
C {devices/lab_pin.sym} 65120 -15710 0 0 {name=p64755 lab=_60946_/X }
C {devices/lab_pin.sym} 65120 -15670 0 0 {name=p64756 lab=_60838_/X }
C {devices/lab_pin.sym} 65120 -15630 0 0 {name=p64757 lab=_60947_/C }
C {devices/lab_pin.sym} 65240 -15670 0 1 {name=p64758 lab=_60947_/Y }
C {sky130_stdcells/nor3_4.sym} 65180 -15670 0 0 {name=X_60947_ }
C {devices/lab_pin.sym} 65120 -15540 0 0 {name=p64759 lab=_79489_/A }
C {devices/lab_pin.sym} 65120 -15500 0 0 {name=p64760 lab=_79488_/Y }
C {devices/lab_pin.sym} 65240 -15520 0 1 {name=p64761 lab=_82846_/D }
C {sky130_stdcells/xor2_4.sym} 65180 -15520 0 0 {name=X_79489_ }
C {devices/lab_pin.sym} 65120 -15400 0 0 {name=p64762 lab=_50695_/A }
C {devices/lab_pin.sym} 65120 -15360 0 0 {name=p64763 lab=_50183_/B }
C {devices/lab_pin.sym} 65240 -15380 0 1 {name=p64764 lab=_50700_/Y }
C {sky130_stdcells/nand2_4.sym} 65180 -15380 0 0 {name=X_50700_ }
C {devices/lab_pin.sym} 65090 -15250 0 0 {name=p64765 lab=_88175_/CLK }
C {devices/lab_pin.sym} 65090 -15230 0 0 {name=p64766 lab=_81564_/Q }
C {devices/lab_pin.sym} 65270 -15250 0 1 {name=p64767 lab=_76025_/A }
C {sky130_stdcells/dfxtp_4.sym} 65180 -15240 0 0 {name=X_81520_ }
C {devices/lab_pin.sym} 65100 -15130 0 0 {name=p64768 lab=_69238_/X }
C {devices/lab_pin.sym} 65100 -15090 0 0 {name=p64769 lab=_69241_/X }
C {devices/lab_pin.sym} 65100 -15050 0 0 {name=p64770 lab=_69142_/X }
C {devices/lab_pin.sym} 65260 -15090 0 1 {name=p64771 lab=_69242_/Y }
C {sky130_stdcells/a21oi_4.sym} 65180 -15090 0 0 {name=X_69242_ }
C {devices/lab_pin.sym} 65120 -14970 0 0 {name=p64772 lab=_65053_/X }
C {devices/lab_pin.sym} 65120 -14930 0 0 {name=p64773 lab=_66423_/B }
C {devices/lab_pin.sym} 65120 -14890 0 0 {name=p64774 lab=_65055_/X }
C {devices/lab_pin.sym} 65240 -14930 0 1 {name=p64775 lab=_66454_/Y }
C {sky130_stdcells/nand3_4.sym} 65180 -14930 0 0 {name=X_66454_ }
C {devices/lab_pin.sym} 65100 -14810 0 0 {name=p64776 lab=_51678_/Y }
C {devices/lab_pin.sym} 65100 -14770 0 0 {name=p64777 lab=_51667_/X }
C {devices/lab_pin.sym} 65100 -14730 0 0 {name=p64778 lab=_51679_/X }
C {devices/lab_pin.sym} 65260 -14770 0 1 {name=p64779 lab=_85966_/D }
C {sky130_stdcells/a21oi_4.sym} 65180 -14770 0 0 {name=X_51680_ }
C {devices/lab_pin.sym} 65100 -14670 0 0 {name=p64780 lab=_58194_/A }
C {devices/lab_pin.sym} 65100 -14630 0 0 {name=p64781 lab=_60798_/X }
C {devices/lab_pin.sym} 65100 -14590 0 0 {name=p64782 lab=_63384_/C }
C {devices/lab_pin.sym} 65100 -14550 0 0 {name=p64783 lab=_60703_/Y }
C {devices/lab_pin.sym} 65100 -14510 0 0 {name=p64784 lab=_62129_/X }
C {devices/lab_pin.sym} 65260 -14590 0 1 {name=p64785 lab=_63666_/X }
C {sky130_stdcells/a32o_4.sym} 65180 -14590 0 0 {name=X_63666_ }
C {devices/lab_pin.sym} 65140 -14430 0 0 {name=p64786 lab=clkbuf_9_282_0_CLK/X }
C {devices/lab_pin.sym} 65220 -14430 0 1 {name=p64787 lab=_82067_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 65180 -14430 0 0 {name=Xclkbuf_10_565_0_CLK }
C {devices/lab_pin.sym} 65140 -14310 0 0 {name=p64788 lab=_60853_/X }
C {devices/lab_pin.sym} 65220 -14310 0 1 {name=p64789 lab=_60879_/D }
C {sky130_stdcells/buf_2.sym} 65180 -14310 0 0 {name=X_60878_ }
C {devices/lab_pin.sym} 65140 -14190 0 0 {name=p64790 lab=clkbuf_6_57_0_CLK/A }
C {devices/lab_pin.sym} 65220 -14190 0 1 {name=p64791 lab=clkbuf_6_56_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 65180 -14190 0 0 {name=Xclkbuf_6_56_0_CLK }
C {devices/lab_pin.sym} 65100 -14090 0 0 {name=p64792 lab=_65402_/X }
C {devices/lab_pin.sym} 65100 -14050 0 0 {name=p64793 lab=_65404_/X }
C {devices/lab_pin.sym} 65100 -14010 0 0 {name=p64794 lab=_65277_/X }
C {devices/lab_pin.sym} 65260 -14050 0 1 {name=p64795 lab=_65410_/A }
C {sky130_stdcells/a21o_4.sym} 65180 -14050 0 0 {name=X_65405_ }
C {devices/lab_pin.sym} 65100 -13930 0 0 {name=p64796 lab=_50629_/Y }
C {devices/lab_pin.sym} 65100 -13890 0 0 {name=p64797 lab=_50619_/X }
C {devices/lab_pin.sym} 65100 -13850 0 0 {name=p64798 lab=_50630_/Y }
C {devices/lab_pin.sym} 65260 -13890 0 1 {name=p64799 lab=_50631_/Y }
C {sky130_stdcells/a21boi_4.sym} 65180 -13890 0 0 {name=X_50631_ }
C {devices/lab_pin.sym} 65100 -13770 0 0 {name=p64800 lab=_62615_/Y }
C {devices/lab_pin.sym} 65100 -13730 0 0 {name=p64801 lab=_62593_/X }
C {devices/lab_pin.sym} 65100 -13690 0 0 {name=p64802 lab=_62616_/Y }
C {devices/lab_pin.sym} 65260 -13730 0 1 {name=p64803 lab=_62617_/Y }
C {sky130_stdcells/a21oi_4.sym} 65180 -13730 0 0 {name=X_62617_ }
C {devices/lab_pin.sym} 65090 -13590 0 0 {name=p64804 lab=_84049_/CLK }
C {devices/lab_pin.sym} 65090 -13570 0 0 {name=p64805 lab=_76733_/B }
C {devices/lab_pin.sym} 65270 -13590 0 1 {name=p64806 lab=_81451_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -13580 0 0 {name=X_81451_ }
C {devices/lab_pin.sym} 65100 -13470 0 0 {name=p64807 lab=_68430_/X }
C {devices/lab_pin.sym} 65100 -13430 0 0 {name=p64808 lab=_68432_/X }
C {devices/lab_pin.sym} 65100 -13390 0 0 {name=p64809 lab=_69061_/X }
C {devices/lab_pin.sym} 65260 -13430 0 1 {name=p64810 lab=_69173_/Y }
C {sky130_stdcells/a21oi_4.sym} 65180 -13430 0 0 {name=X_69173_ }
C {devices/lab_pin.sym} 65120 -13310 0 0 {name=p64811 lab=_64747_/X }
C {devices/lab_pin.sym} 65120 -13270 0 0 {name=p64812 lab=_66385_/B }
C {devices/lab_pin.sym} 65120 -13230 0 0 {name=p64813 lab=_64750_/X }
C {devices/lab_pin.sym} 65240 -13270 0 1 {name=p64814 lab=_66385_/Y }
C {sky130_stdcells/nand3_4.sym} 65180 -13270 0 0 {name=X_66385_ }
C {devices/lab_pin.sym} 65120 -13140 0 0 {name=p64815 lab=_63657_/A }
C {devices/lab_pin.sym} 65120 -13100 0 0 {name=p64816 lab=_62027_/X }
C {devices/lab_pin.sym} 65240 -13120 0 1 {name=p64817 lab=_63597_/X }
C {sky130_stdcells/and2_4.sym} 65180 -13120 0 0 {name=X_63597_ }
C {devices/lab_pin.sym} 65120 -13000 0 0 {name=p64818 lab=_80416_/A }
C {devices/lab_pin.sym} 65120 -12960 0 0 {name=p64819 lab=_80416_/B }
C {devices/lab_pin.sym} 65240 -12980 0 1 {name=p64820 lab=_80425_/A }
C {sky130_stdcells/xor2_4.sym} 65180 -12980 0 0 {name=X_80402_ }
C {devices/lab_pin.sym} 65100 -12870 0 0 {name=p64821 lab=_82073_/D }
C {devices/lab_pin.sym} 65100 -12830 0 0 {name=p64822 lab=_68120_/X }
C {devices/lab_pin.sym} 65100 -12790 0 0 {name=p64823 lab=_68123_/X }
C {devices/lab_pin.sym} 65260 -12830 0 1 {name=p64824 lab=_84033_/D }
C {sky130_stdcells/a21bo_4.sym} 65180 -12830 0 0 {name=X_68124_ }
C {devices/lab_pin.sym} 65140 -12690 0 0 {name=p64825 lab=_48755_/A }
C {devices/lab_pin.sym} 65220 -12690 0 1 {name=p64826 lab=_53351_/A }
C {sky130_stdcells/buf_2.sym} 65180 -12690 0 0 {name=X_53350_ }
C {devices/lab_pin.sym} 65100 -12600 0 0 {name=p64827 lab=_65334_/X }
C {devices/lab_pin.sym} 65100 -12560 0 0 {name=p64828 lab=_86117_/Q }
C {devices/lab_pin.sym} 65100 -12520 0 0 {name=p64829 lab=_65256_/X }
C {devices/lab_pin.sym} 65100 -12480 0 0 {name=p64830 lab=_65335_/X }
C {devices/lab_pin.sym} 65260 -12540 0 1 {name=p64831 lab=_65336_/X }
C {sky130_stdcells/a211o_4.sym} 65180 -12540 0 0 {name=X_65336_ }
C {devices/lab_pin.sym} 65090 -12390 0 0 {name=p64832 lab=_82748_/CLK }
C {devices/lab_pin.sym} 65090 -12370 0 0 {name=p64833 lab=_84170_/D }
C {devices/lab_pin.sym} 65270 -12390 0 1 {name=p64834 lab=_65901_/C }
C {sky130_stdcells/dfxtp_4.sym} 65180 -12380 0 0 {name=X_84170_ }
C {devices/lab_pin.sym} 65100 -12270 0 0 {name=p64835 lab=_50559_/Y }
C {devices/lab_pin.sym} 65100 -12230 0 0 {name=p64836 lab=_50551_/X }
C {devices/lab_pin.sym} 65100 -12190 0 0 {name=p64837 lab=_50561_/X }
C {devices/lab_pin.sym} 65260 -12230 0 1 {name=p64838 lab=_86177_/D }
C {sky130_stdcells/a21oi_4.sym} 65180 -12230 0 0 {name=X_50562_ }
C {devices/lab_pin.sym} 65120 -12120 0 0 {name=p64839 lab=_61609_/X }
C {devices/lab_pin.sym} 65120 -12080 0 0 {name=p64840 lab=_62548_/B }
C {devices/lab_pin.sym} 65120 -12040 0 0 {name=p64841 lab=_62548_/C }
C {devices/lab_pin.sym} 65120 -12000 0 0 {name=p64842 lab=_62548_/D }
C {devices/lab_pin.sym} 65240 -12060 0 1 {name=p64843 lab=_62548_/Y }
C {sky130_stdcells/nand4_4.sym} 65180 -12060 0 0 {name=X_62548_ }
C {devices/lab_pin.sym} 65090 -11910 0 0 {name=p64844 lab=_84087_/CLK }
C {devices/lab_pin.sym} 65090 -11890 0 0 {name=p64845 lab=_81382_/D }
C {devices/lab_pin.sym} 65270 -11910 0 1 {name=p64846 lab=_76828_/B }
C {sky130_stdcells/dfxtp_4.sym} 65180 -11900 0 0 {name=X_81382_ }
C {devices/lab_pin.sym} 65100 -11790 0 0 {name=p64847 lab=_50599_/A }
C {devices/lab_pin.sym} 65100 -11750 0 0 {name=p64848 lab=_50599_/B }
C {devices/lab_pin.sym} 65100 -11710 0 0 {name=p64849 lab=_52280_/X }
C {devices/lab_pin.sym} 65260 -11750 0 1 {name=p64850 lab=_52301_/X }
C {sky130_stdcells/o21a_4.sym} 65180 -11750 0 0 {name=X_52301_ }
C {devices/lab_pin.sym} 65090 -11610 0 0 {name=p64851 lab=_86213_/CLK }
C {devices/lab_pin.sym} 65090 -11590 0 0 {name=p64852 lab=_83121_/D }
C {devices/lab_pin.sym} 65270 -11610 0 1 {name=p64853 lab=_70128_/C }
C {sky130_stdcells/dfxtp_4.sym} 65180 -11600 0 0 {name=X_83121_ }
C {devices/lab_pin.sym} 65140 -11470 0 0 {name=p64854 lab=_44195_/Y }
C {devices/lab_pin.sym} 65220 -11470 0 1 {name=p64855 lab=_44196_/D }
C {sky130_stdcells/buf_8.sym} 65180 -11470 0 0 {name=Xpsn_inst_psn_buff_9 }
C {devices/lab_pin.sym} 65100 -11370 0 0 {name=p64856 lab=_80315_/A }
C {devices/lab_pin.sym} 65100 -11330 0 0 {name=p64857 lab=_80313_/Y }
C {devices/lab_pin.sym} 65100 -11290 0 0 {name=p64858 lab=_80332_/Y }
C {devices/lab_pin.sym} 65260 -11330 0 1 {name=p64859 lab=_80333_/Y }
C {sky130_stdcells/a21oi_4.sym} 65180 -11330 0 0 {name=X_80333_ }
C {devices/lab_pin.sym} 65100 -11220 0 0 {name=p64860 lab=_87381_/Q }
C {devices/lab_pin.sym} 65100 -11180 0 0 {name=p64861 lab=_67987_/X }
C {devices/lab_pin.sym} 65100 -11140 0 0 {name=p64862 lab=_68053_/X }
C {devices/lab_pin.sym} 65100 -11100 0 0 {name=p64863 lab=_68054_/X }
C {devices/lab_pin.sym} 65260 -11160 0 1 {name=p64864 lab=_68055_/X }
C {sky130_stdcells/a211o_4.sym} 65180 -11160 0 0 {name=X_68055_ }
C {devices/lab_pin.sym} 65100 -11030 0 0 {name=p64865 lab=_85662_/Q }
C {devices/lab_pin.sym} 65100 -10990 0 0 {name=p64866 lab=_53268_/X }
C {devices/lab_pin.sym} 65100 -10950 0 0 {name=p64867 lab=_53280_/Y }
C {devices/lab_pin.sym} 65260 -10990 0 1 {name=p64868 lab=_53281_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -10990 0 0 {name=X_53281_ }
C {devices/lab_pin.sym} 65100 -10870 0 0 {name=p64869 lab=_65198_/X }
C {devices/lab_pin.sym} 65100 -10830 0 0 {name=p64870 lab=_65255_/Y }
C {devices/lab_pin.sym} 65100 -10790 0 0 {name=p64871 lab=_65266_/Y }
C {devices/lab_pin.sym} 65260 -10830 0 1 {name=p64872 lab=_65267_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -10830 0 0 {name=X_65267_ }
C {devices/lab_pin.sym} 65100 -10710 0 0 {name=p64873 lab=_50490_/Y }
C {devices/lab_pin.sym} 65100 -10670 0 0 {name=p64874 lab=_50491_/X }
C {devices/lab_pin.sym} 65100 -10630 0 0 {name=p64875 lab=_50492_/X }
C {devices/lab_pin.sym} 65260 -10670 0 1 {name=p64876 lab=_86190_/D }
C {sky130_stdcells/a21oi_4.sym} 65180 -10670 0 0 {name=X_50493_ }
C {devices/lab_pin.sym} 65120 -10560 0 0 {name=p64877 lab=_62479_/A }
C {devices/lab_pin.sym} 65120 -10520 0 0 {name=p64878 lab=_63585_/B }
C {devices/lab_pin.sym} 65120 -10480 0 0 {name=p64879 lab=_62479_/C }
C {devices/lab_pin.sym} 65120 -10440 0 0 {name=p64880 lab=_62463_/X }
C {devices/lab_pin.sym} 65240 -10500 0 1 {name=p64881 lab=_62479_/X }
C {sky130_stdcells/and4_4.sym} 65180 -10500 0 0 {name=X_62479_ }
C {devices/lab_pin.sym} 65140 -10350 0 0 {name=p64882 lab=_55072_/A }
C {devices/lab_pin.sym} 65220 -10350 0 1 {name=p64883 lab=_55020_/X }
C {sky130_stdcells/buf_2.sym} 65180 -10350 0 0 {name=X_55020_ }
C {devices/lab_pin.sym} 65120 -10240 0 0 {name=p64884 lab=_67057_/A }
C {devices/lab_pin.sym} 65120 -10200 0 0 {name=p64885 lab=_87681_/Q }
C {devices/lab_pin.sym} 65240 -10220 0 1 {name=p64886 lab=_67006_/X }
C {sky130_stdcells/and2_4.sym} 65180 -10220 0 0 {name=X_67006_ }
C {devices/lab_pin.sym} 65140 -10090 0 0 {name=p64887 lab=_52203_/A }
C {devices/lab_pin.sym} 65220 -10090 0 1 {name=p64888 lab=_52232_/X }
C {sky130_stdcells/buf_2.sym} 65180 -10090 0 0 {name=X_52232_ }
C {devices/lab_pin.sym} 65140 -9970 0 0 {name=p64889 lab=_64315_/A }
C {devices/lab_pin.sym} 65220 -9970 0 1 {name=p64890 lab=_64219_/B }
C {sky130_stdcells/buf_2.sym} 65180 -9970 0 0 {name=X_64218_ }
C {devices/lab_pin.sym} 65090 -9850 0 0 {name=p64891 lab=_85566_/CLK }
C {devices/lab_pin.sym} 65090 -9830 0 0 {name=p64892 lab=_74506_/Y }
C {devices/lab_pin.sym} 65270 -9850 0 1 {name=p64893 lab=_83052_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -9840 0 0 {name=X_83052_ }
C {devices/lab_pin.sym} 65120 -9720 0 0 {name=p64894 lab=_80264_/A }
C {devices/lab_pin.sym} 65120 -9680 0 0 {name=p64895 lab=_80264_/B }
C {devices/lab_pin.sym} 65240 -9700 0 1 {name=p64896 lab=_80264_/Y }
C {sky130_stdcells/xnor2_4.sym} 65180 -9700 0 0 {name=X_80264_ }
C {devices/lab_pin.sym} 65140 -9570 0 0 {name=p64897 lab=_65198_/A }
C {devices/lab_pin.sym} 65220 -9570 0 1 {name=p64898 lab=_65198_/X }
C {sky130_stdcells/buf_2.sym} 65180 -9570 0 0 {name=X_65198_ }
C {devices/lab_pin.sym} 65090 -9450 0 0 {name=p64899 lab=_82008_/CLK }
C {devices/lab_pin.sym} 65090 -9430 0 0 {name=p64900 lab=_82035_/Q }
C {devices/lab_pin.sym} 65270 -9450 0 1 {name=p64901 lab=_77127_/A }
C {sky130_stdcells/dfxtp_4.sym} 65180 -9440 0 0 {name=X_82003_ }
C {devices/lab_pin.sym} 65120 -9320 0 0 {name=p64902 lab=_52168_/A }
C {devices/lab_pin.sym} 65120 -9280 0 0 {name=p64903 lab=_52163_/B }
C {devices/lab_pin.sym} 65240 -9300 0 1 {name=p64904 lab=_52163_/Y }
C {sky130_stdcells/nand2_4.sym} 65180 -9300 0 0 {name=X_52163_ }
C {devices/lab_pin.sym} 65120 -9200 0 0 {name=p64905 lab=_62140_/X }
C {devices/lab_pin.sym} 65120 -9160 0 0 {name=p64906 lab=_64182_/B }
C {devices/lab_pin.sym} 65120 -9120 0 0 {name=p64907 lab=_64095_/C }
C {devices/lab_pin.sym} 65120 -9080 0 0 {name=p64908 lab=_64095_/D }
C {devices/lab_pin.sym} 65240 -9140 0 1 {name=p64909 lab=_64149_/Y }
C {sky130_stdcells/nand4_4.sym} 65180 -9140 0 0 {name=X_64149_ }
C {devices/lab_pin.sym} 65090 -8990 0 0 {name=p64910 lab=_87348_/CLK }
C {devices/lab_pin.sym} 65090 -8970 0 0 {name=p64911 lab=_42444_/X }
C {devices/lab_pin.sym} 65270 -8990 0 1 {name=p64912 lab=_87860_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -8980 0 0 {name=X_87860_ }
C {devices/lab_pin.sym} 65120 -8860 0 0 {name=p64913 lab=_80195_/A }
C {devices/lab_pin.sym} 65120 -8820 0 0 {name=p64914 lab=_84292_/Q }
C {devices/lab_pin.sym} 65240 -8840 0 1 {name=p64915 lab=_80195_/X }
C {sky130_stdcells/xor2_4.sym} 65180 -8840 0 0 {name=X_80195_ }
C {devices/lab_pin.sym} 65140 -8710 0 0 {name=p64916 lab=clkbuf_9_251_0_CLK/X }
C {devices/lab_pin.sym} 65220 -8710 0 1 {name=p64917 lab=_85459_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 65180 -8710 0 0 {name=Xclkbuf_10_503_0_CLK }
C {devices/lab_pin.sym} 65140 -8590 0 0 {name=p64918 lab=_51141_/A }
C {devices/lab_pin.sym} 65220 -8590 0 1 {name=p64919 lab=_51115_/C }
C {sky130_stdcells/buf_2.sym} 65180 -8590 0 0 {name=X_51114_ }
C {devices/lab_pin.sym} 65090 -8470 0 0 {name=p64920 lab=_81154_/CLK }
C {devices/lab_pin.sym} 65090 -8450 0 0 {name=p64921 lab=_46019_/X }
C {devices/lab_pin.sym} 65270 -8470 0 1 {name=p64922 lab=_67215_/B }
C {sky130_stdcells/dfxtp_4.sym} 65180 -8460 0 0 {name=X_86811_ }
C {devices/lab_pin.sym} 65100 -8350 0 0 {name=p64923 lab=_52092_/Y }
C {devices/lab_pin.sym} 65100 -8310 0 0 {name=p64924 lab=_52049_/X }
C {devices/lab_pin.sym} 65100 -8270 0 0 {name=p64925 lab=_52093_/X }
C {devices/lab_pin.sym} 65260 -8310 0 1 {name=p64926 lab=_85890_/D }
C {sky130_stdcells/a21oi_4.sym} 65180 -8310 0 0 {name=X_52094_ }
C {devices/lab_pin.sym} 65120 -8190 0 0 {name=p64927 lab=_58547_/A }
C {devices/lab_pin.sym} 65120 -8150 0 0 {name=p64928 lab=_56971_/B }
C {devices/lab_pin.sym} 65120 -8110 0 0 {name=p64929 lab=_56971_/C }
C {devices/lab_pin.sym} 65240 -8150 0 1 {name=p64930 lab=_56971_/Y }
C {sky130_stdcells/nor3_4.sym} 65180 -8150 0 0 {name=X_56971_ }
C {devices/lab_pin.sym} 65100 -8040 0 0 {name=p64931 lab=_74121_/A }
C {devices/lab_pin.sym} 65100 -8000 0 0 {name=p64932 lab=_68883_/X }
C {devices/lab_pin.sym} 65100 -7960 0 0 {name=p64933 lab=_68884_/X }
C {devices/lab_pin.sym} 65100 -7920 0 0 {name=p64934 lab=_68956_/Y }
C {devices/lab_pin.sym} 65260 -7980 0 1 {name=p64935 lab=_68957_/X }
C {sky130_stdcells/a211o_4.sym} 65180 -7980 0 0 {name=X_68957_ }
C {devices/lab_pin.sym} 65090 -7830 0 0 {name=p64936 lab=_87544_/CLK }
C {devices/lab_pin.sym} 65090 -7810 0 0 {name=p64937 lab=_87791_/D }
C {devices/lab_pin.sym} 65270 -7830 0 1 {name=p64938 lab=_87791_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -7820 0 0 {name=X_87791_ }
C {devices/lab_pin.sym} 65100 -7720 0 0 {name=p64939 lab=_84806_/Q }
C {devices/lab_pin.sym} 65100 -7680 0 0 {name=p64940 lab=_58599_/X }
C {devices/lab_pin.sym} 65100 -7640 0 0 {name=p64941 lab=_58702_/X }
C {devices/lab_pin.sym} 65100 -7600 0 0 {name=p64942 lab=_58709_/X }
C {devices/lab_pin.sym} 65260 -7660 0 1 {name=p64943 lab=_58710_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 65180 -7660 0 0 {name=X_58710_ }
C {devices/lab_pin.sym} 65120 -7540 0 0 {name=p64944 lab=_51029_/A }
C {devices/lab_pin.sym} 65120 -7500 0 0 {name=p64945 lab=_51045_/B }
C {devices/lab_pin.sym} 65120 -7460 0 0 {name=p64946 lab=_51045_/C }
C {devices/lab_pin.sym} 65120 -7420 0 0 {name=p64947 lab=_52735_/D }
C {devices/lab_pin.sym} 65240 -7480 0 1 {name=p64948 lab=_51045_/X }
C {sky130_stdcells/and4_4.sym} 65180 -7480 0 0 {name=X_51045_ }
C {devices/lab_pin.sym} 65100 -7360 0 0 {name=p64949 lab=_56395_/C }
C {devices/lab_pin.sym} 65100 -7320 0 0 {name=p64950 lab=_44070_/B }
C {devices/lab_pin.sym} 65100 -7280 0 0 {name=p64951 lab=_55627_/X }
C {devices/lab_pin.sym} 65100 -7240 0 0 {name=p64952 lab=_55921_/X }
C {devices/lab_pin.sym} 65260 -7300 0 1 {name=p64953 lab=_55922_/X }
C {sky130_stdcells/a211o_4.sym} 65180 -7300 0 0 {name=X_55922_ }
C {devices/lab_pin.sym} 65090 -7150 0 0 {name=p64954 lab=_85527_/CLK }
C {devices/lab_pin.sym} 65090 -7130 0 0 {name=p64955 lab=_46384_/Y }
C {devices/lab_pin.sym} 65270 -7150 0 1 {name=p64956 lab=_86742_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -7140 0 0 {name=X_86742_ }
C {devices/lab_pin.sym} 65140 -7010 0 0 {name=p64957 lab=_69797_/A }
C {devices/lab_pin.sym} 65220 -7010 0 1 {name=p64958 lab=_67908_/X }
C {sky130_stdcells/buf_2.sym} 65180 -7010 0 0 {name=X_67908_ }
C {devices/lab_pin.sym} 65140 -6890 0 0 {name=p64959 lab=_59801_/A }
C {devices/lab_pin.sym} 65220 -6890 0 1 {name=p64960 lab=_59816_/A }
C {sky130_stdcells/buf_2.sym} 65180 -6890 0 0 {name=X_59690_ }
C {devices/lab_pin.sym} 65090 -6770 0 0 {name=p64961 lab=_80821_/CLK }
C {devices/lab_pin.sym} 65090 -6750 0 0 {name=p64962 lab=_83954_/D }
C {devices/lab_pin.sym} 65270 -6770 0 1 {name=p64963 lab=_83954_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -6760 0 0 {name=X_83954_ }
C {devices/lab_pin.sym} 65120 -6640 0 0 {name=p64964 lab=_68746_/A }
C {devices/lab_pin.sym} 65120 -6600 0 0 {name=p64965 lab=_68888_/B }
C {devices/lab_pin.sym} 65240 -6620 0 1 {name=p64966 lab=_68888_/Y }
C {sky130_stdcells/nor2_4.sym} 65180 -6620 0 0 {name=X_68888_ }
C {devices/lab_pin.sym} 65140 -6490 0 0 {name=p64967 lab=_58641_/A }
C {devices/lab_pin.sym} 65220 -6490 0 1 {name=p64968 lab=_58641_/X }
C {sky130_stdcells/buf_2.sym} 65180 -6490 0 0 {name=X_58641_ }
C {devices/lab_pin.sym} 65090 -6370 0 0 {name=p64969 lab=_82906_/CLK }
C {devices/lab_pin.sym} 65090 -6350 0 0 {name=p64970 lab=_78247_/B }
C {devices/lab_pin.sym} 65270 -6370 0 1 {name=p64971 lab=_41674_/A }
C {sky130_stdcells/dfxtp_4.sym} 65180 -6360 0 0 {name=X_82905_ }
C {devices/lab_pin.sym} 65120 -6240 0 0 {name=p64972 lab=_55850_/X }
C {devices/lab_pin.sym} 65120 -6200 0 0 {name=p64973 lab=_55853_/B }
C {devices/lab_pin.sym} 65240 -6220 0 1 {name=p64974 lab=_55853_/X }
C {sky130_stdcells/and2_4.sym} 65180 -6220 0 0 {name=X_55853_ }
C {devices/lab_pin.sym} 65140 -6090 0 0 {name=p64975 lab=clkbuf_9_259_0_CLK/X }
C {devices/lab_pin.sym} 65220 -6090 0 1 {name=p64976 lab=_81482_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 65180 -6090 0 0 {name=Xclkbuf_10_518_0_CLK }
C {devices/lab_pin.sym} 65140 -5970 0 0 {name=p64977 lab=_68644_/A }
C {devices/lab_pin.sym} 65220 -5970 0 1 {name=p64978 lab=_67909_/A }
C {sky130_stdcells/buf_2.sym} 65180 -5970 0 0 {name=X_67839_ }
C {devices/lab_pin.sym} 65090 -5850 0 0 {name=p64979 lab=_86353_/CLK }
C {devices/lab_pin.sym} 65090 -5830 0 0 {name=p64980 lab=_86673_/D }
C {devices/lab_pin.sym} 65270 -5850 0 1 {name=p64981 lab=_86673_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -5840 0 0 {name=X_86673_ }
C {devices/lab_pin.sym} 65090 -5710 0 0 {name=p64982 lab=_82301_/CLK }
C {devices/lab_pin.sym} 65090 -5690 0 0 {name=p64983 lab=_83885_/D }
C {devices/lab_pin.sym} 65270 -5710 0 1 {name=p64984 lab=_81957_/D }
C {sky130_stdcells/dfxtp_4.sym} 65180 -5700 0 0 {name=X_83885_ }
C {devices/lab_pin.sym} 65100 -5590 0 0 {name=p64985 lab=_54801_/Y }
C {devices/lab_pin.sym} 65100 -5550 0 0 {name=p64986 lab=_54802_/X }
C {devices/lab_pin.sym} 65100 -5510 0 0 {name=p64987 lab=_54803_/X }
C {devices/lab_pin.sym} 65260 -5550 0 1 {name=p64988 lab=_85375_/D }
C {sky130_stdcells/a21oi_4.sym} 65180 -5550 0 0 {name=X_54804_ }
C {devices/lab_pin.sym} 65090 -5410 0 0 {name=p64989 lab=_86235_/CLK }
C {devices/lab_pin.sym} 65090 -5390 0 0 {name=p64990 lab=_85624_/D }
C {devices/lab_pin.sym} 65270 -5410 0 1 {name=p64991 lab=_85624_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -5400 0 0 {name=X_85624_ }
C {devices/lab_pin.sym} 65100 -5290 0 0 {name=p64992 lab=_51779_/B }
C {devices/lab_pin.sym} 65100 -5250 0 0 {name=p64993 lab=_70830_/Y }
C {devices/lab_pin.sym} 65100 -5210 0 0 {name=p64994 lab=_70849_/Y }
C {devices/lab_pin.sym} 65260 -5250 0 1 {name=p64995 lab=_70850_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -5250 0 0 {name=X_70850_ }
C {devices/lab_pin.sym} 65100 -5130 0 0 {name=p64996 lab=_58571_/X }
C {devices/lab_pin.sym} 65100 -5090 0 0 {name=p64997 lab=_85793_/Q }
C {devices/lab_pin.sym} 65100 -5050 0 0 {name=p64998 lab=_58089_/X }
C {devices/lab_pin.sym} 65260 -5090 0 1 {name=p64999 lab=_58572_/X }
C {sky130_stdcells/o21a_4.sym} 65180 -5090 0 0 {name=X_58572_ }
C {devices/lab_pin.sym} 65090 -4950 0 0 {name=p65000 lab=_84177_/CLK }
C {devices/lab_pin.sym} 65090 -4930 0 0 {name=p65001 lab=_82836_/D }
C {devices/lab_pin.sym} 65270 -4950 0 1 {name=p65002 lab=_82836_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -4940 0 0 {name=X_82836_ }
C {devices/lab_pin.sym} 65100 -4840 0 0 {name=p65003 lab=_56250_/C }
C {devices/lab_pin.sym} 65100 -4800 0 0 {name=p65004 lab=_55747_/X }
C {devices/lab_pin.sym} 65100 -4760 0 0 {name=p65005 lab=_55165_/X }
C {devices/lab_pin.sym} 65100 -4720 0 0 {name=p65006 lab=_55783_/X }
C {devices/lab_pin.sym} 65260 -4780 0 1 {name=p65007 lab=_55784_/X }
C {sky130_stdcells/a211o_4.sym} 65180 -4780 0 0 {name=X_55784_ }
C {devices/lab_pin.sym} 65100 -4650 0 0 {name=p65008 lab=_85716_/Q }
C {devices/lab_pin.sym} 65100 -4610 0 0 {name=p65009 lab=_52984_/X }
C {devices/lab_pin.sym} 65100 -4570 0 0 {name=p65010 lab=_52995_/Y }
C {devices/lab_pin.sym} 65260 -4610 0 1 {name=p65011 lab=_52996_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -4610 0 0 {name=X_52996_ }
C {devices/lab_pin.sym} 65120 -4480 0 0 {name=p65012 lab=_47819_/A }
C {devices/lab_pin.sym} 65120 -4440 0 0 {name=p65013 lab=_57523_/B }
C {devices/lab_pin.sym} 65240 -4460 0 1 {name=p65014 lab=_57523_/Y }
C {sky130_stdcells/nand2_4.sym} 65180 -4460 0 0 {name=X_57523_ }
C {devices/lab_pin.sym} 65120 -4340 0 0 {name=p65015 lab=_69454_/A }
C {devices/lab_pin.sym} 65120 -4300 0 0 {name=p65016 lab=_69509_/B }
C {devices/lab_pin.sym} 65240 -4320 0 1 {name=p65017 lab=_69509_/X }
C {sky130_stdcells/and2_4.sym} 65180 -4320 0 0 {name=X_69509_ }
C {devices/lab_pin.sym} 65090 -4190 0 0 {name=p65018 lab=_87850_/CLK }
C {devices/lab_pin.sym} 65090 -4170 0 0 {name=p65019 lab=_88343_/D }
C {devices/lab_pin.sym} 65270 -4190 0 1 {name=p65020 lab=_88343_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -4180 0 0 {name=X_88343_ }
C {devices/lab_pin.sym} 65100 -4070 0 0 {name=p65021 lab=_54733_/Y }
C {devices/lab_pin.sym} 65100 -4030 0 0 {name=p65022 lab=_54720_/X }
C {devices/lab_pin.sym} 65100 -3990 0 0 {name=p65023 lab=_54734_/X }
C {devices/lab_pin.sym} 65260 -4030 0 1 {name=p65024 lab=_54735_/Y }
C {sky130_stdcells/a21oi_4.sym} 65180 -4030 0 0 {name=X_54735_ }
C {devices/lab_pin.sym} 65090 -3890 0 0 {name=p65025 lab=_85555_/CLK }
C {devices/lab_pin.sym} 65090 -3870 0 0 {name=p65026 lab=_53855_/Y }
C {devices/lab_pin.sym} 65270 -3890 0 1 {name=p65027 lab=_85555_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -3880 0 0 {name=X_85555_ }
C {devices/lab_pin.sym} 65120 -3760 0 0 {name=p65028 lab=_51947_/A }
C {devices/lab_pin.sym} 65120 -3720 0 0 {name=p65029 lab=_51947_/B }
C {devices/lab_pin.sym} 65240 -3740 0 1 {name=p65030 lab=_51947_/Y }
C {sky130_stdcells/nand2_4.sym} 65180 -3740 0 0 {name=X_51947_ }
C {devices/lab_pin.sym} 65140 -3610 0 0 {name=p65031 lab=_70387_/A }
C {devices/lab_pin.sym} 65220 -3610 0 1 {name=p65032 lab=_70782_/A }
C {sky130_stdcells/buf_2.sym} 65180 -3610 0 0 {name=X_70781_ }
C {devices/lab_pin.sym} 65090 -3490 0 0 {name=p65033 lab=_82769_/CLK }
C {devices/lab_pin.sym} 65090 -3470 0 0 {name=p65034 lab=_82767_/D }
C {devices/lab_pin.sym} 65270 -3490 0 1 {name=p65035 lab=_82767_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -3480 0 0 {name=X_82767_ }
C {devices/lab_pin.sym} 65100 -3370 0 0 {name=p65036 lab=_41577_/X }
C {devices/lab_pin.sym} 65100 -3330 0 0 {name=p65037 lab=_82900_/Q }
C {devices/lab_pin.sym} 65100 -3290 0 0 {name=p65038 lab=_41699_/X }
C {devices/lab_pin.sym} 65260 -3330 0 1 {name=p65039 lab=_41700_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -3330 0 0 {name=X_41700_ }
C {devices/lab_pin.sym} 65100 -3230 0 0 {name=p65040 lab=_72597_/B }
C {devices/lab_pin.sym} 65100 -3190 0 0 {name=p65041 lab=_72597_/C }
C {devices/lab_pin.sym} 65100 -3150 0 0 {name=p65042 lab=_72583_/C }
C {devices/lab_pin.sym} 65100 -3110 0 0 {name=p65043 lab=_72510_/C }
C {devices/lab_pin.sym} 65100 -3080 0 0 {name=p65044 lab=_59789_/A }
C {devices/lab_pin.sym} 65260 -3150 0 1 {name=p65045 lab=_72520_/X }
C {sky130_stdcells/a41o_4.sym} 65180 -3150 0 0 {name=X_72520_ }
C {devices/lab_pin.sym} 65090 -2990 0 0 {name=p65046 lab=_84501_/CLK }
C {devices/lab_pin.sym} 65090 -2970 0 0 {name=p65047 lab=_61217_/X }
C {devices/lab_pin.sym} 65270 -2990 0 1 {name=p65048 lab=_84506_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -2980 0 0 {name=X_84506_ }
C {devices/lab_pin.sym} 65100 -2870 0 0 {name=p65049 lab=_57441_/X }
C {devices/lab_pin.sym} 65100 -2830 0 0 {name=p65050 lab=_56758_/X }
C {devices/lab_pin.sym} 65100 -2790 0 0 {name=p65051 lab=_57453_/X }
C {devices/lab_pin.sym} 65260 -2830 0 1 {name=p65052 lab=_57454_/X }
C {sky130_stdcells/o21a_4.sym} 65180 -2830 0 0 {name=X_57454_ }
C {devices/lab_pin.sym} 65090 -2690 0 0 {name=p65053 lab=_81532_/CLK }
C {devices/lab_pin.sym} 65090 -2670 0 0 {name=p65054 lab=_81718_/D }
C {devices/lab_pin.sym} 65270 -2690 0 1 {name=p65055 lab=_81718_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -2680 0 0 {name=X_81718_ }
C {devices/lab_pin.sym} 65090 -2550 0 0 {name=p65056 lab=_88272_/CLK }
C {devices/lab_pin.sym} 65090 -2530 0 0 {name=p65057 lab=_41122_/X }
C {devices/lab_pin.sym} 65270 -2550 0 1 {name=p65058 lab=_88274_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -2540 0 0 {name=X_88274_ }
C {devices/lab_pin.sym} 65140 -2410 0 0 {name=p65059 lab=_54558_/A }
C {devices/lab_pin.sym} 65220 -2410 0 1 {name=p65060 lab=_54666_/X }
C {sky130_stdcells/buf_2.sym} 65180 -2410 0 0 {name=X_54666_ }
C {devices/lab_pin.sym} 65140 -2290 0 0 {name=p65061 lab=_42680_/A }
C {devices/lab_pin.sym} 65220 -2290 0 1 {name=p65062 lab=_42681_/A }
C {sky130_stdcells/buf_2.sym} 65180 -2290 0 0 {name=X_42680_ }
C {devices/lab_pin.sym} 65090 -2170 0 0 {name=p65063 lab=_86317_/CLK }
C {devices/lab_pin.sym} 65090 -2150 0 0 {name=p65064 lab=_54200_/Y }
C {devices/lab_pin.sym} 65270 -2170 0 1 {name=p65065 lab=_85486_/Q }
C {sky130_stdcells/dfxtp_4.sym} 65180 -2160 0 0 {name=X_85486_ }
C {devices/lab_pin.sym} 65120 -2060 0 0 {name=p65066 lab=_51870_/A }
C {devices/lab_pin.sym} 65120 -2020 0 0 {name=p65067 lab=_51870_/B }
C {devices/lab_pin.sym} 65120 -1980 0 0 {name=p65068 lab=_51870_/C }
C {devices/lab_pin.sym} 65120 -1940 0 0 {name=p65069 lab=_52704_/D }
C {devices/lab_pin.sym} 65240 -2000 0 1 {name=p65070 lab=_51878_/X }
C {sky130_stdcells/and4_4.sym} 65180 -2000 0 0 {name=X_51878_ }
C {devices/lab_pin.sym} 65090 -1850 0 0 {name=p65071 lab=_84111_/CLK }
C {devices/lab_pin.sym} 65090 -1830 0 0 {name=p65072 lab=_82698_/D }
C {devices/lab_pin.sym} 65270 -1850 0 1 {name=p65073 lab=_82686_/D }
C {sky130_stdcells/dfxtp_4.sym} 65180 -1840 0 0 {name=X_82698_ }
C {devices/lab_pin.sym} 65120 -1730 0 0 {name=p65074 lab=_56397_/X }
C {devices/lab_pin.sym} 65120 -1690 0 0 {name=p65075 lab=_56399_/B }
C {devices/lab_pin.sym} 65120 -1650 0 0 {name=p65076 lab=_85206_/Q }
C {devices/lab_pin.sym} 65240 -1690 0 1 {name=p65077 lab=_56405_/Y }
C {sky130_stdcells/nand3_4.sym} 65180 -1690 0 0 {name=X_56405_ }
C {devices/lab_pin.sym} 65090 -1550 0 0 {name=p65078 lab=_87225_/CLK }
C {devices/lab_pin.sym} 65090 -1530 0 0 {name=p65079 lab=_87225_/D }
C {devices/lab_pin.sym} 65270 -1550 0 1 {name=p65080 lab=_69011_/B }
C {sky130_stdcells/dfxtp_4.sym} 65180 -1540 0 0 {name=X_87225_ }
C {devices/lab_pin.sym} 65140 -1410 0 0 {name=p65081 lab=_41630_/X }
C {devices/lab_pin.sym} 65220 -1410 0 1 {name=p65082 lab=_41631_/X }
C {sky130_stdcells/buf_2.sym} 65180 -1410 0 0 {name=X_41631_ }
C {devices/lab_pin.sym} 65100 -1310 0 0 {name=p65083 lab=_85601_/Q }
C {devices/lab_pin.sym} 65100 -1270 0 0 {name=p65084 lab=_53556_/X }
C {devices/lab_pin.sym} 65100 -1230 0 0 {name=p65085 lab=_53616_/Y }
C {devices/lab_pin.sym} 65260 -1270 0 1 {name=p65086 lab=_53617_/Y }
C {sky130_stdcells/o21ai_4.sym} 65180 -1270 0 0 {name=X_53617_ }
C {devices/lab_pin.sym} 65100 -1150 0 0 {name=p65087 lab=_65308_/X }
C {devices/lab_pin.sym} 65100 -1110 0 0 {name=p65088 lab=_85669_/Q }
C {devices/lab_pin.sym} 65100 -1070 0 0 {name=p65089 lab=_72422_/X }
C {devices/lab_pin.sym} 65260 -1110 0 1 {name=p65090 lab=_72451_/X }
C {sky130_stdcells/o21a_4.sym} 65180 -1110 0 0 {name=X_72451_ }
C {devices/lab_pin.sym} 65090 -970 0 0 {name=p65091 lab=_84438_/CLK }
C {devices/lab_pin.sym} 65090 -950 0 0 {name=p65092 lab=_62053_/Y }
C {devices/lab_pin.sym} 65270 -970 0 1 {name=p65093 lab=_78060_/B }
C {sky130_stdcells/dfxtp_4.sym} 65180 -960 0 0 {name=X_84437_ }
C {devices/lab_pin.sym} 65140 -830 0 0 {name=p65094 lab=_50538_/A }
C {devices/lab_pin.sym} 65220 -830 0 1 {name=p65095 lab=_50830_/C }
C {sky130_stdcells/buf_2.sym} 65180 -830 0 0 {name=X_50829_ }
C {devices/lab_pin.sym} 65090 -710 0 0 {name=p65096 lab=_81811_/CLK }
C {devices/lab_pin.sym} 65090 -690 0 0 {name=p65097 lab=_81681_/Q }
C {devices/lab_pin.sym} 65270 -710 0 1 {name=p65098 lab=_76365_/A }
C {sky130_stdcells/dfxtp_4.sym} 65180 -700 0 0 {name=X_81649_ }
C {devices/lab_pin.sym} 66060 -42150 0 0 {name=p65099 lab=_57380_/X }
C {devices/lab_pin.sym} 66140 -42150 0 1 {name=p65100 lab=_57385_/X }
C {sky130_stdcells/buf_2.sym} 66100 -42150 0 0 {name=X_57385_ }
C {devices/lab_pin.sym} 66020 -42050 0 0 {name=p65101 lab=_85413_/Q }
C {devices/lab_pin.sym} 66020 -42010 0 0 {name=p65102 lab=_54593_/X }
C {devices/lab_pin.sym} 66020 -41970 0 0 {name=p65103 lab=_54596_/Y }
C {devices/lab_pin.sym} 66180 -42010 0 1 {name=p65104 lab=_54597_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -42010 0 0 {name=X_54597_ }
C {devices/lab_pin.sym} 66060 -41870 0 0 {name=p65105 lab=_59037_/A }
C {devices/lab_pin.sym} 66140 -41870 0 1 {name=p65106 lab=_59124_/X }
C {sky130_stdcells/buf_2.sym} 66100 -41870 0 0 {name=X_59124_ }
C {devices/lab_pin.sym} 66020 -41770 0 0 {name=p65107 lab=_71397_/X }
C {devices/lab_pin.sym} 66020 -41730 0 0 {name=p65108 lab=_83512_/Q }
C {devices/lab_pin.sym} 66020 -41690 0 0 {name=p65109 lab=_71401_/Y }
C {devices/lab_pin.sym} 66180 -41730 0 1 {name=p65110 lab=_83512_/D }
C {sky130_stdcells/a21o_4.sym} 66100 -41730 0 0 {name=X_71402_ }
C {devices/lab_pin.sym} 66060 -41590 0 0 {name=p65111 lab=_44381_/A }
C {devices/lab_pin.sym} 66140 -41590 0 1 {name=p65112 lab=_44350_/X }
C {sky130_stdcells/buf_2.sym} 66100 -41590 0 0 {name=X_44350_ }
C {devices/lab_pin.sym} 66020 -41490 0 0 {name=p65113 lab=_56103_/X }
C {devices/lab_pin.sym} 66020 -41450 0 0 {name=p65114 lab=_56321_/X }
C {devices/lab_pin.sym} 66020 -41410 0 0 {name=p65115 lab=_56335_/Y }
C {devices/lab_pin.sym} 66180 -41450 0 1 {name=p65116 lab=_56336_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -41450 0 0 {name=X_56336_ }
C {devices/lab_pin.sym} 66040 -41320 0 0 {name=p65117 lab=_80681_/Q }
C {devices/lab_pin.sym} 66040 -41280 0 0 {name=p65118 lab=_80937_/D }
C {devices/lab_pin.sym} 66160 -41300 0 1 {name=p65119 lab=_75175_/C }
C {sky130_stdcells/nand2_4.sym} 66100 -41300 0 0 {name=X_75170_ }
C {devices/lab_pin.sym} 66010 -41170 0 0 {name=p65120 lab=_86934_/CLK }
C {devices/lab_pin.sym} 66010 -41150 0 0 {name=p65121 lab=_87156_/D }
C {devices/lab_pin.sym} 66190 -41170 0 1 {name=p65122 lab=_87156_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -41160 0 0 {name=X_87156_ }
C {devices/lab_pin.sym} 66060 -41030 0 0 {name=p65123 lab=_40586_/A }
C {devices/lab_pin.sym} 66140 -41030 0 1 {name=p65124 lab=_41563_/B }
C {sky130_stdcells/buf_2.sym} 66100 -41030 0 0 {name=X_41562_ }
C {devices/lab_pin.sym} 66040 -40920 0 0 {name=p65125 lab=_53548_/A }
C {devices/lab_pin.sym} 66040 -40880 0 0 {name=p65126 lab=_48022_/Y }
C {devices/lab_pin.sym} 66160 -40900 0 1 {name=p65127 lab=_53548_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -40900 0 0 {name=X_53548_ }
C {devices/lab_pin.sym} 66040 -40780 0 0 {name=p65128 lab=_72347_/A }
C {devices/lab_pin.sym} 66040 -40740 0 0 {name=p65129 lab=_86283_/Q }
C {devices/lab_pin.sym} 66160 -40760 0 1 {name=p65130 lab=_72382_/Y }
C {sky130_stdcells/nor2_4.sym} 66100 -40760 0 0 {name=X_72382_ }
C {devices/lab_pin.sym} 66010 -40630 0 0 {name=p65131 lab=_84449_/CLK }
C {devices/lab_pin.sym} 66010 -40610 0 0 {name=p65132 lab=_84368_/D }
C {devices/lab_pin.sym} 66190 -40630 0 1 {name=p65133 lab=_62943_/C }
C {sky130_stdcells/dfxtp_4.sym} 66100 -40620 0 0 {name=X_84368_ }
C {devices/lab_pin.sym} 66060 -40490 0 0 {name=p65134 lab=_43217_/A }
C {devices/lab_pin.sym} 66140 -40490 0 1 {name=p65135 lab=_43302_/A }
C {sky130_stdcells/buf_2.sym} 66100 -40490 0 0 {name=X_43301_ }
C {devices/lab_pin.sym} 66040 -40380 0 0 {name=p65136 lab=_74121_/A }
C {devices/lab_pin.sym} 66040 -40340 0 0 {name=p65137 lab=_73372_/B }
C {devices/lab_pin.sym} 66160 -40360 0 1 {name=p65138 lab=_74121_/Y }
C {sky130_stdcells/nor2_4.sym} 66100 -40360 0 0 {name=X_74121_ }
C {devices/lab_pin.sym} 66010 -40230 0 0 {name=p65139 lab=_85786_/CLK }
C {devices/lab_pin.sym} 66010 -40210 0 0 {name=p65140 lab=_50920_/Y }
C {devices/lab_pin.sym} 66190 -40230 0 1 {name=p65141 lab=_86107_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -40220 0 0 {name=X_86107_ }
C {devices/lab_pin.sym} 66040 -40100 0 0 {name=p65142 lab=_82313_/Q }
C {devices/lab_pin.sym} 66040 -40060 0 0 {name=p65143 lab=_40471_/X }
C {devices/lab_pin.sym} 66160 -40080 0 1 {name=p65144 lab=_40513_/X }
C {sky130_stdcells/or2_4.sym} 66100 -40080 0 0 {name=X_40513_ }
C {devices/lab_pin.sym} 66020 -39980 0 0 {name=p65145 lab=_84773_/Q }
C {devices/lab_pin.sym} 66020 -39940 0 0 {name=p65146 lab=_59043_/X }
C {devices/lab_pin.sym} 66020 -39900 0 0 {name=p65147 lab=_59047_/X }
C {devices/lab_pin.sym} 66020 -39860 0 0 {name=p65148 lab=_59054_/X }
C {devices/lab_pin.sym} 66180 -39920 0 1 {name=p65149 lab=_84773_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 66100 -39920 0 0 {name=X_59055_ }
C {devices/lab_pin.sym} 66040 -39790 0 0 {name=p65150 lab=_71335_/A }
C {devices/lab_pin.sym} 66040 -39750 0 0 {name=p65151 lab=_71335_/B }
C {devices/lab_pin.sym} 66040 -39710 0 0 {name=p65152 lab=_71333_/C }
C {devices/lab_pin.sym} 66160 -39750 0 1 {name=p65153 lab=_71333_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -39750 0 0 {name=X_71333_ }
C {devices/lab_pin.sym} 66010 -39610 0 0 {name=p65154 lab=_83316_/CLK }
C {devices/lab_pin.sym} 66010 -39590 0 0 {name=p65155 lab=_83319_/D }
C {devices/lab_pin.sym} 66190 -39610 0 1 {name=p65156 lab=_55671_/A }
C {sky130_stdcells/dfxtp_4.sym} 66100 -39600 0 0 {name=X_83319_ }
C {devices/lab_pin.sym} 66020 -39490 0 0 {name=p65157 lab=_44279_/Y }
C {devices/lab_pin.sym} 66020 -39450 0 0 {name=p65158 lab=_44280_/Y }
C {devices/lab_pin.sym} 66020 -39410 0 0 {name=p65159 lab=_44277_/X }
C {devices/lab_pin.sym} 66180 -39450 0 1 {name=p65160 lab=_44281_/Y }
C {sky130_stdcells/a21oi_4.sym} 66100 -39450 0 0 {name=X_44281_ }
C {devices/lab_pin.sym} 66040 -39330 0 0 {name=p65161 lab=_56194_/X }
C {devices/lab_pin.sym} 66040 -39290 0 0 {name=p65162 lab=_56263_/B }
C {devices/lab_pin.sym} 66040 -39250 0 0 {name=p65163 lab=_56267_/C }
C {devices/lab_pin.sym} 66160 -39290 0 1 {name=p65164 lab=_56267_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -39290 0 0 {name=X_56267_ }
C {devices/lab_pin.sym} 66010 -39150 0 0 {name=p65165 lab=_87103_/CLK }
C {devices/lab_pin.sym} 66010 -39130 0 0 {name=p65166 lab=_44479_/X }
C {devices/lab_pin.sym} 66190 -39150 0 1 {name=p65167 lab=_87087_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -39140 0 0 {name=X_87087_ }
C {devices/lab_pin.sym} 66060 -39010 0 0 {name=p65168 lab=_41492_/X }
C {devices/lab_pin.sym} 66140 -39010 0 1 {name=p65169 lab=_41493_/X }
C {sky130_stdcells/buf_2.sym} 66100 -39010 0 0 {name=X_41493_ }
C {devices/lab_pin.sym} 66020 -38910 0 0 {name=p65170 lab=_85629_/Q }
C {devices/lab_pin.sym} 66020 -38870 0 0 {name=p65171 lab=_53476_/X }
C {devices/lab_pin.sym} 66020 -38830 0 0 {name=p65172 lab=_53478_/Y }
C {devices/lab_pin.sym} 66180 -38870 0 1 {name=p65173 lab=_53479_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -38870 0 0 {name=X_53479_ }
C {devices/lab_pin.sym} 66010 -38730 0 0 {name=p65174 lab=_84299_/CLK }
C {devices/lab_pin.sym} 66010 -38710 0 0 {name=p65175 lab=_63711_/Y }
C {devices/lab_pin.sym} 66190 -38730 0 1 {name=p65176 lab=_80279_/B }
C {sky130_stdcells/dfxtp_4.sym} 66100 -38720 0 0 {name=X_84299_ }
C {devices/lab_pin.sym} 66020 -38630 0 0 {name=p65177 lab=_46013_/X }
C {devices/lab_pin.sym} 66020 -38590 0 0 {name=p65178 lab=_46001_/X }
C {devices/lab_pin.sym} 66020 -38550 0 0 {name=p65179 lab=_40531_/X }
C {devices/lab_pin.sym} 66020 -38510 0 0 {name=p65180 lab=_86810_/Q }
C {devices/lab_pin.sym} 66020 -38470 0 0 {name=p65181 lab=_46014_/X }
C {devices/lab_pin.sym} 66180 -38550 0 1 {name=p65182 lab=_46021_/A }
C {sky130_stdcells/o32ai_4.sym} 66100 -38550 0 0 {name=X_46020_ }
C {devices/lab_pin.sym} 66040 -38400 0 0 {name=p65183 lab=_86637_/Q }
C {devices/lab_pin.sym} 66040 -38360 0 0 {name=p65184 lab=_57954_/X }
C {devices/lab_pin.sym} 66160 -38380 0 1 {name=p65185 lab=_58006_/Y }
C {sky130_stdcells/nor2_4.sym} 66100 -38380 0 0 {name=X_58006_ }
C {devices/lab_pin.sym} 66060 -38250 0 0 {name=p65186 lab=_43212_/A }
C {devices/lab_pin.sym} 66140 -38250 0 1 {name=p65187 lab=_43232_/X }
C {sky130_stdcells/buf_2.sym} 66100 -38250 0 0 {name=X_43232_ }
C {devices/lab_pin.sym} 66040 -38150 0 0 {name=p65188 lab=_72718_/C }
C {devices/lab_pin.sym} 66040 -38110 0 0 {name=p65189 lab=_83314_/Q }
C {devices/lab_pin.sym} 66040 -38070 0 0 {name=p65190 lab=_72718_/D }
C {devices/lab_pin.sym} 66160 -38110 0 1 {name=p65191 lab=_55218_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -38110 0 0 {name=X_55218_ }
C {devices/lab_pin.sym} 66010 -37970 0 0 {name=p65192 lab=_85527_/CLK }
C {devices/lab_pin.sym} 66010 -37950 0 0 {name=p65193 lab=_51295_/Y }
C {devices/lab_pin.sym} 66190 -37970 0 1 {name=p65194 lab=_86038_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -37960 0 0 {name=X_86038_ }
C {devices/lab_pin.sym} 66020 -37860 0 0 {name=p65195 lab=_68886_/B }
C {devices/lab_pin.sym} 66020 -37820 0 0 {name=p65196 lab=_73891_/X }
C {devices/lab_pin.sym} 66020 -37780 0 0 {name=p65197 lab=_73962_/X }
C {devices/lab_pin.sym} 66020 -37740 0 0 {name=p65198 lab=_74051_/Y }
C {devices/lab_pin.sym} 66180 -37800 0 1 {name=p65199 lab=_74052_/X }
C {sky130_stdcells/a211o_4.sym} 66100 -37800 0 0 {name=X_74052_ }
C {devices/lab_pin.sym} 66040 -37660 0 0 {name=p65200 lab=_40368_/X }
C {devices/lab_pin.sym} 66040 -37620 0 0 {name=p65201 lab=_41523_/A }
C {devices/lab_pin.sym} 66160 -37640 0 1 {name=p65202 lab=_40444_/X }
C {sky130_stdcells/or2_4.sym} 66100 -37640 0 0 {name=X_40444_ }
C {devices/lab_pin.sym} 66060 -37510 0 0 {name=p65203 lab=_71264_/A }
C {devices/lab_pin.sym} 66140 -37510 0 1 {name=p65204 lab=_71264_/X }
C {sky130_stdcells/buf_2.sym} 66100 -37510 0 0 {name=X_71264_ }
C {devices/lab_pin.sym} 66040 -37410 0 0 {name=p65205 lab=_56280_/A }
C {devices/lab_pin.sym} 66040 -37370 0 0 {name=p65206 lab=_56192_/B }
C {devices/lab_pin.sym} 66040 -37330 0 0 {name=p65207 lab=_56198_/C }
C {devices/lab_pin.sym} 66160 -37370 0 1 {name=p65208 lab=_56198_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -37370 0 0 {name=X_56198_ }
C {devices/lab_pin.sym} 66040 -37240 0 0 {name=p65209 lab=_87306_/Q }
C {devices/lab_pin.sym} 66040 -37200 0 0 {name=p65210 lab=_73003_/B }
C {devices/lab_pin.sym} 66160 -37220 0 1 {name=p65211 lab=_73003_/Y }
C {sky130_stdcells/nor2_4.sym} 66100 -37220 0 0 {name=X_73003_ }
C {devices/lab_pin.sym} 66020 -37110 0 0 {name=p65212 lab=_70209_/X }
C {devices/lab_pin.sym} 66020 -37070 0 0 {name=p65213 lab=_83834_/Q }
C {devices/lab_pin.sym} 66020 -37030 0 0 {name=p65214 lab=_70214_/X }
C {devices/lab_pin.sym} 66180 -37070 0 1 {name=p65215 lab=_83834_/D }
C {sky130_stdcells/a21o_4.sym} 66100 -37070 0 0 {name=X_70215_ }
C {devices/lab_pin.sym} 66020 -36970 0 0 {name=p65216 lab=_43162_/X }
C {devices/lab_pin.sym} 66020 -36930 0 0 {name=p65217 lab=_43149_/X }
C {devices/lab_pin.sym} 66020 -36890 0 0 {name=p65218 lab=_40866_/X }
C {devices/lab_pin.sym} 66020 -36850 0 0 {name=p65219 lab=_73252_/A }
C {devices/lab_pin.sym} 66020 -36810 0 0 {name=p65220 lab=_43154_/X }
C {devices/lab_pin.sym} 66180 -36890 0 1 {name=p65221 lab=_43164_/A }
C {sky130_stdcells/o32ai_4.sym} 66100 -36890 0 0 {name=X_43163_ }
C {devices/lab_pin.sym} 66060 -36730 0 0 {name=p65222 lab=_55149_/A }
C {devices/lab_pin.sym} 66140 -36730 0 1 {name=p65223 lab=_55224_/A }
C {sky130_stdcells/buf_2.sym} 66100 -36730 0 0 {name=X_55149_ }
C {devices/lab_pin.sym} 66020 -36630 0 0 {name=p65224 lab=_78854_/Y }
C {devices/lab_pin.sym} 66020 -36590 0 0 {name=p65225 lab=_78855_/X }
C {devices/lab_pin.sym} 66020 -36550 0 0 {name=p65226 lab=_78859_/Y }
C {devices/lab_pin.sym} 66180 -36590 0 1 {name=p65227 lab=_78860_/Y }
C {sky130_stdcells/a21oi_4.sym} 66100 -36590 0 0 {name=X_78860_ }
C {devices/lab_pin.sym} 66060 -36450 0 0 {name=p65228 lab=_44736_/A }
C {devices/lab_pin.sym} 66140 -36450 0 1 {name=p65229 lab=_40375_/X }
C {sky130_stdcells/buf_2.sym} 66100 -36450 0 0 {name=X_40375_ }
C {devices/lab_pin.sym} 66020 -36350 0 0 {name=p65230 lab=_48540_/B }
C {devices/lab_pin.sym} 66020 -36310 0 0 {name=p65231 lab=_71190_/X }
C {devices/lab_pin.sym} 66020 -36270 0 0 {name=p65232 lab=_71194_/Y }
C {devices/lab_pin.sym} 66180 -36310 0 1 {name=p65233 lab=_83577_/D }
C {sky130_stdcells/o21ai_4.sym} 66100 -36310 0 0 {name=X_71195_ }
C {devices/lab_pin.sym} 66020 -36200 0 0 {name=p65234 lab=_41064_/X }
C {devices/lab_pin.sym} 66020 -36160 0 0 {name=p65235 lab=_42103_/X }
C {devices/lab_pin.sym} 66020 -36120 0 0 {name=p65236 lab=_88028_/Q }
C {devices/lab_pin.sym} 66020 -36080 0 0 {name=p65237 lab=_42104_/X }
C {devices/lab_pin.sym} 66180 -36140 0 1 {name=p65238 lab=_88028_/D }
C {sky130_stdcells/a2bb2o_4.sym} 66100 -36140 0 0 {name=X_42114_ }
C {devices/lab_pin.sym} 66040 -36000 0 0 {name=p65239 lab=_77808_/X }
C {devices/lab_pin.sym} 66040 -35960 0 0 {name=p65240 lab=_77811_/B }
C {devices/lab_pin.sym} 66160 -35980 0 1 {name=p65241 lab=_77812_/B }
C {sky130_stdcells/xnor2_4.sym} 66100 -35980 0 0 {name=X_77811_ }
C {devices/lab_pin.sym} 66020 -35880 0 0 {name=p65242 lab=_83522_/Q }
C {devices/lab_pin.sym} 66020 -35840 0 0 {name=p65243 lab=_83170_/Q }
C {devices/lab_pin.sym} 66020 -35800 0 0 {name=p65244 lab=_83503_/Q }
C {devices/lab_pin.sym} 66020 -35760 0 0 {name=p65245 lab=_83151_/Q }
C {devices/lab_pin.sym} 66180 -35820 0 1 {name=p65246 lab=_70146_/Y }
C {sky130_stdcells/a22oi_4.sym} 66100 -35820 0 0 {name=X_70146_ }
C {devices/lab_pin.sym} 66060 -35670 0 0 {name=p65247 lab=_47904_/A }
C {devices/lab_pin.sym} 66140 -35670 0 1 {name=p65248 lab=_47971_/X }
C {sky130_stdcells/buf_2.sym} 66100 -35670 0 0 {name=X_47971_ }
C {devices/lab_pin.sym} 66060 -35550 0 0 {name=p65249 lab=_87578_/Q }
C {devices/lab_pin.sym} 66140 -35550 0 1 {name=p65250 lab=_43094_/Y }
C {sky130_stdcells/inv_2.sym} 66100 -35550 0 0 {name=X_43094_ }
C {devices/lab_pin.sym} 66060 -35430 0 0 {name=p65251 lab=_59885_/Y }
C {devices/lab_pin.sym} 66140 -35430 0 1 {name=p65252 lab=_61205_/B }
C {sky130_stdcells/inv_2.sym} 66100 -35430 0 0 {name=X_59957_ }
C {devices/lab_pin.sym} 66040 -35320 0 0 {name=p65253 lab=_82817_/Q }
C {devices/lab_pin.sym} 66040 -35280 0 0 {name=p65254 lab=_78791_/B }
C {devices/lab_pin.sym} 66160 -35300 0 1 {name=p65255 lab=_78792_/B }
C {sky130_stdcells/xor2_4.sym} 66100 -35300 0 0 {name=X_78791_ }
C {devices/lab_pin.sym} 66010 -35170 0 0 {name=p65256 lab=_87993_/CLK }
C {devices/lab_pin.sym} 66010 -35150 0 0 {name=p65257 lab=_87989_/D }
C {devices/lab_pin.sym} 66190 -35170 0 1 {name=p65258 lab=_87989_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -35160 0 0 {name=X_87989_ }
C {devices/lab_pin.sym} 66040 -35040 0 0 {name=p65259 lab=_49699_/A }
C {devices/lab_pin.sym} 66040 -35000 0 0 {name=p65260 lab=_52924_/B }
C {devices/lab_pin.sym} 66160 -35020 0 1 {name=p65261 lab=_49710_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -35020 0 0 {name=X_49710_ }
C {devices/lab_pin.sym} 66040 -34900 0 0 {name=p65262 lab=_46948_/A }
C {devices/lab_pin.sym} 66040 -34860 0 0 {name=p65263 lab=_52748_/B }
C {devices/lab_pin.sym} 66160 -34880 0 1 {name=p65264 lab=_46922_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -34880 0 0 {name=X_46922_ }
C {devices/lab_pin.sym} 66020 -34790 0 0 {name=p65265 lab=_42028_/X }
C {devices/lab_pin.sym} 66020 -34750 0 0 {name=p65266 lab=_42043_/X }
C {devices/lab_pin.sym} 66020 -34710 0 0 {name=p65267 lab=_40894_/X }
C {devices/lab_pin.sym} 66020 -34670 0 0 {name=p65268 lab=_73372_/A }
C {devices/lab_pin.sym} 66020 -34630 0 0 {name=p65269 lab=_42044_/X }
C {devices/lab_pin.sym} 66180 -34710 0 1 {name=p65270 lab=_42046_/A }
C {sky130_stdcells/o32ai_4.sym} 66100 -34710 0 0 {name=X_42045_ }
C {devices/lab_pin.sym} 66020 -34580 0 0 {name=p65271 lab=_84791_/Q }
C {devices/lab_pin.sym} 66020 -34540 0 0 {name=p65272 lab=_58871_/X }
C {devices/lab_pin.sym} 66020 -34500 0 0 {name=p65273 lab=_58899_/X }
C {devices/lab_pin.sym} 66020 -34460 0 0 {name=p65274 lab=_58907_/X }
C {devices/lab_pin.sym} 66180 -34520 0 1 {name=p65275 lab=_58908_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 66100 -34520 0 0 {name=X_58908_ }
C {devices/lab_pin.sym} 66040 -34380 0 0 {name=p65276 lab=_77742_/A }
C {devices/lab_pin.sym} 66040 -34340 0 0 {name=p65277 lab=_77741_/Y }
C {devices/lab_pin.sym} 66160 -34360 0 1 {name=p65278 lab=_77742_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -34360 0 0 {name=X_77742_ }
C {devices/lab_pin.sym} 66020 -34250 0 0 {name=p65279 lab=_81136_/D }
C {devices/lab_pin.sym} 66020 -34210 0 0 {name=p65280 lab=_74960_/C }
C {devices/lab_pin.sym} 66020 -34170 0 0 {name=p65281 lab=_74953_/Y }
C {devices/lab_pin.sym} 66180 -34210 0 1 {name=p65282 lab=_74954_/Y }
C {sky130_stdcells/a21oi_4.sym} 66100 -34210 0 0 {name=X_74954_ }
C {devices/lab_pin.sym} 66020 -34090 0 0 {name=p65283 lab=_69003_/X }
C {devices/lab_pin.sym} 66020 -34050 0 0 {name=p65284 lab=_69005_/X }
C {devices/lab_pin.sym} 66020 -34010 0 0 {name=p65285 lab=_69992_/X }
C {devices/lab_pin.sym} 66180 -34050 0 1 {name=p65286 lab=_70079_/A }
C {sky130_stdcells/a21o_4.sym} 66100 -34050 0 0 {name=X_70077_ }
C {devices/lab_pin.sym} 66060 -33910 0 0 {name=p65287 lab=_59585_/A }
C {devices/lab_pin.sym} 66140 -33910 0 1 {name=p65288 lab=_60593_/B }
C {sky130_stdcells/buf_2.sym} 66100 -33910 0 0 {name=X_59888_ }
C {devices/lab_pin.sym} 66060 -33790 0 0 {name=p65289 lab=_49641_/A }
C {devices/lab_pin.sym} 66140 -33790 0 1 {name=p65290 lab=_49642_/B }
C {sky130_stdcells/buf_2.sym} 66100 -33790 0 0 {name=X_49641_ }
C {devices/lab_pin.sym} 66020 -33700 0 0 {name=p65291 lab=_73854_/X }
C {devices/lab_pin.sym} 66020 -33660 0 0 {name=p65292 lab=_85619_/Q }
C {devices/lab_pin.sym} 66020 -33620 0 0 {name=p65293 lab=_73903_/X }
C {devices/lab_pin.sym} 66020 -33580 0 0 {name=p65294 lab=_73904_/X }
C {devices/lab_pin.sym} 66180 -33640 0 1 {name=p65295 lab=_73905_/X }
C {sky130_stdcells/a211o_4.sym} 66100 -33640 0 0 {name=X_73905_ }
C {devices/lab_pin.sym} 66020 -33510 0 0 {name=p65296 lab=_58813_/X }
C {devices/lab_pin.sym} 66020 -33470 0 0 {name=p65297 lab=_85772_/Q }
C {devices/lab_pin.sym} 66020 -33430 0 0 {name=p65298 lab=_58838_/X }
C {devices/lab_pin.sym} 66180 -33470 0 1 {name=p65299 lab=_58839_/X }
C {sky130_stdcells/o21a_4.sym} 66100 -33470 0 0 {name=X_58839_ }
C {devices/lab_pin.sym} 66020 -33350 0 0 {name=p65300 lab=_58887_/A }
C {devices/lab_pin.sym} 66020 -33310 0 0 {name=p65301 lab=_46813_/X }
C {devices/lab_pin.sym} 66020 -33270 0 0 {name=p65302 lab=_46852_/Y }
C {devices/lab_pin.sym} 66180 -33310 0 1 {name=p65303 lab=_46853_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -33310 0 0 {name=X_46853_ }
C {devices/lab_pin.sym} 66040 -33180 0 0 {name=p65304 lab=_77674_/A }
C {devices/lab_pin.sym} 66040 -33140 0 0 {name=p65305 lab=_82123_/Q }
C {devices/lab_pin.sym} 66160 -33160 0 1 {name=p65306 lab=_77673_/Y }
C {sky130_stdcells/nor2_4.sym} 66100 -33160 0 0 {name=X_77673_ }
C {devices/lab_pin.sym} 66060 -33030 0 0 {name=p65307 lab=_74899_/A }
C {devices/lab_pin.sym} 66140 -33030 0 1 {name=p65308 lab=_74887_/B }
C {sky130_stdcells/inv_2.sym} 66100 -33030 0 0 {name=X_74885_ }
C {devices/lab_pin.sym} 66020 -32930 0 0 {name=p65309 lab=_79404_/X }
C {devices/lab_pin.sym} 66020 -32890 0 0 {name=p65310 lab=_79405_/X }
C {devices/lab_pin.sym} 66020 -32850 0 0 {name=p65311 lab=_79411_/Y }
C {devices/lab_pin.sym} 66180 -32890 0 1 {name=p65312 lab=_79416_/A }
C {sky130_stdcells/a21boi_4.sym} 66100 -32890 0 0 {name=X_79412_ }
C {devices/lab_pin.sym} 66020 -32770 0 0 {name=p65313 lab=_45799_/X }
C {devices/lab_pin.sym} 66020 -32730 0 0 {name=p65314 lab=_45802_/Y }
C {devices/lab_pin.sym} 66020 -32690 0 0 {name=p65315 lab=_45803_/X }
C {devices/lab_pin.sym} 66180 -32730 0 1 {name=p65316 lab=_45804_/Y }
C {sky130_stdcells/a21oi_4.sym} 66100 -32730 0 0 {name=X_45804_ }
C {devices/lab_pin.sym} 66040 -32610 0 0 {name=p65317 lab=_76616_/X }
C {devices/lab_pin.sym} 66040 -32570 0 0 {name=p65318 lab=_76624_/B }
C {devices/lab_pin.sym} 66040 -32530 0 0 {name=p65319 lab=_76624_/C }
C {devices/lab_pin.sym} 66160 -32570 0 1 {name=p65320 lab=_76624_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -32570 0 0 {name=X_76624_ }
C {devices/lab_pin.sym} 66040 -32460 0 0 {name=p65321 lab=_49571_/X }
C {devices/lab_pin.sym} 66040 -32420 0 0 {name=p65322 lab=_49561_/B }
C {devices/lab_pin.sym} 66040 -32380 0 0 {name=p65323 lab=_49548_/X }
C {devices/lab_pin.sym} 66040 -32340 0 0 {name=p65324 lab=_52785_/D }
C {devices/lab_pin.sym} 66160 -32400 0 1 {name=p65325 lab=_49572_/X }
C {sky130_stdcells/and4_4.sym} 66100 -32400 0 0 {name=X_49572_ }
C {devices/lab_pin.sym} 66020 -32270 0 0 {name=p65326 lab=_61848_/Y }
C {devices/lab_pin.sym} 66020 -32230 0 0 {name=p65327 lab=_61801_/X }
C {devices/lab_pin.sym} 66020 -32190 0 0 {name=p65328 lab=_61849_/Y }
C {devices/lab_pin.sym} 66180 -32230 0 1 {name=p65329 lab=_61850_/Y }
C {sky130_stdcells/a21oi_4.sym} 66100 -32230 0 0 {name=X_61850_ }
C {devices/lab_pin.sym} 66040 -32100 0 0 {name=p65330 lab=_53514_/B }
C {devices/lab_pin.sym} 66040 -32060 0 0 {name=p65331 lab=_73836_/B }
C {devices/lab_pin.sym} 66160 -32080 0 1 {name=p65332 lab=_73836_/X }
C {sky130_stdcells/xor2_4.sym} 66100 -32080 0 0 {name=X_73836_ }
C {devices/lab_pin.sym} 66040 -31980 0 0 {name=p65333 lab=_46784_/A }
C {devices/lab_pin.sym} 66040 -31940 0 0 {name=p65334 lab=_46784_/B }
C {devices/lab_pin.sym} 66040 -31900 0 0 {name=p65335 lab=_46784_/C }
C {devices/lab_pin.sym} 66040 -31860 0 0 {name=p65336 lab=_46783_/X }
C {devices/lab_pin.sym} 66160 -31920 0 1 {name=p65337 lab=_46784_/X }
C {sky130_stdcells/and4_4.sym} 66100 -31920 0 0 {name=X_46784_ }
C {devices/lab_pin.sym} 66040 -31790 0 0 {name=p65338 lab=_59571_/C }
C {devices/lab_pin.sym} 66040 -31750 0 0 {name=p65339 lab=_60665_/C }
C {devices/lab_pin.sym} 66040 -31710 0 0 {name=p65340 lab=_59563_/A }
C {devices/lab_pin.sym} 66160 -31750 0 1 {name=p65341 lab=_59584_/C }
C {sky130_stdcells/nand3_4.sym} 66100 -31750 0 0 {name=X_43996_ }
C {devices/lab_pin.sym} 66040 -31630 0 0 {name=p65342 lab=_50469_/A }
C {devices/lab_pin.sym} 66040 -31590 0 0 {name=p65343 lab=_48500_/X }
C {devices/lab_pin.sym} 66040 -31550 0 0 {name=p65344 lab=_48533_/C }
C {devices/lab_pin.sym} 66160 -31590 0 1 {name=p65345 lab=_48523_/X }
C {sky130_stdcells/and3_4.sym} 66100 -31590 0 0 {name=X_48523_ }
C {devices/lab_pin.sym} 66020 -31470 0 0 {name=p65346 lab=_60804_/B }
C {devices/lab_pin.sym} 66020 -31430 0 0 {name=p65347 lab=_60725_/B }
C {devices/lab_pin.sym} 66020 -31390 0 0 {name=p65348 lab=_60785_/Y }
C {devices/lab_pin.sym} 66180 -31430 0 1 {name=p65349 lab=_60801_/X }
C {sky130_stdcells/o21a_4.sym} 66100 -31430 0 0 {name=X_60801_ }
C {devices/lab_pin.sym} 66040 -31300 0 0 {name=p65350 lab=_79343_/A }
C {devices/lab_pin.sym} 66040 -31260 0 0 {name=p65351 lab=_79343_/B }
C {devices/lab_pin.sym} 66160 -31280 0 1 {name=p65352 lab=_79344_/B }
C {sky130_stdcells/xor2_4.sym} 66100 -31280 0 0 {name=X_79343_ }
C {devices/lab_pin.sym} 66060 -31150 0 0 {name=p65353 lab=_45705_/A }
C {devices/lab_pin.sym} 66140 -31150 0 1 {name=p65354 lab=_45736_/B }
C {sky130_stdcells/buf_2.sym} 66100 -31150 0 0 {name=X_45735_ }
C {devices/lab_pin.sym} 66020 -31050 0 0 {name=p65355 lab=_76554_/B }
C {devices/lab_pin.sym} 66020 -31010 0 0 {name=p65356 lab=_76554_/C }
C {devices/lab_pin.sym} 66020 -30970 0 0 {name=p65357 lab=_76550_/Y }
C {devices/lab_pin.sym} 66180 -31010 0 1 {name=p65358 lab=_76555_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -31010 0 0 {name=X_76555_ }
C {devices/lab_pin.sym} 66060 -30870 0 0 {name=p65359 lab=_42946_/Y }
C {devices/lab_pin.sym} 66140 -30870 0 1 {name=p65360 lab=_87637_/D }
C {sky130_stdcells/inv_2.sym} 66100 -30870 0 0 {name=X_42947_ }
C {devices/lab_pin.sym} 66040 -30780 0 0 {name=p65361 lab=_61780_/X }
C {devices/lab_pin.sym} 66040 -30740 0 0 {name=p65362 lab=_61765_/B }
C {devices/lab_pin.sym} 66040 -30700 0 0 {name=p65363 lab=_61765_/C }
C {devices/lab_pin.sym} 66040 -30660 0 0 {name=p65364 lab=_61748_/X }
C {devices/lab_pin.sym} 66160 -30720 0 1 {name=p65365 lab=_61781_/Y }
C {sky130_stdcells/nand4_4.sym} 66100 -30720 0 0 {name=X_61781_ }
C {devices/lab_pin.sym} 66040 -30590 0 0 {name=p65366 lab=_73765_/X }
C {devices/lab_pin.sym} 66040 -30550 0 0 {name=p65367 lab=_73767_/B }
C {devices/lab_pin.sym} 66040 -30510 0 0 {name=p65368 lab=_73767_/C }
C {devices/lab_pin.sym} 66160 -30550 0 1 {name=p65369 lab=_73767_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -30550 0 0 {name=X_73767_ }
C {devices/lab_pin.sym} 66040 -30430 0 0 {name=p65370 lab=_70976_/A }
C {devices/lab_pin.sym} 66040 -30390 0 0 {name=p65371 lab=_71066_/B }
C {devices/lab_pin.sym} 66040 -30350 0 0 {name=p65372 lab=_70979_/C }
C {devices/lab_pin.sym} 66160 -30390 0 1 {name=p65373 lab=_70979_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -30390 0 0 {name=X_70979_ }
C {devices/lab_pin.sym} 66040 -30280 0 0 {name=p65374 lab=_63496_/A }
C {devices/lab_pin.sym} 66040 -30240 0 0 {name=p65375 lab=_63520_/B }
C {devices/lab_pin.sym} 66040 -30200 0 0 {name=p65376 lab=_63520_/C }
C {devices/lab_pin.sym} 66040 -30160 0 0 {name=p65377 lab=_63496_/D }
C {devices/lab_pin.sym} 66160 -30220 0 1 {name=p65378 lab=_63520_/X }
C {sky130_stdcells/and4_4.sym} 66100 -30220 0 0 {name=X_63520_ }
C {devices/lab_pin.sym} 66040 -30100 0 0 {name=p65379 lab=_75466_/A }
C {devices/lab_pin.sym} 66040 -30060 0 0 {name=p65380 lab=_75466_/B }
C {devices/lab_pin.sym} 66040 -30020 0 0 {name=p65381 lab=_75506_/C }
C {devices/lab_pin.sym} 66040 -29980 0 0 {name=p65382 lab=_75506_/D }
C {devices/lab_pin.sym} 66160 -30040 0 1 {name=p65383 lab=_75506_/X }
C {sky130_stdcells/and4_4.sym} 66100 -30040 0 0 {name=X_75506_ }
C {devices/lab_pin.sym} 66040 -29910 0 0 {name=p65384 lab=_60711_/X }
C {devices/lab_pin.sym} 66040 -29870 0 0 {name=p65385 lab=_60660_/X }
C {devices/lab_pin.sym} 66040 -29830 0 0 {name=p65386 lab=_60732_/C }
C {devices/lab_pin.sym} 66160 -29870 0 1 {name=p65387 lab=_60732_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -29870 0 0 {name=X_60732_ }
C {devices/lab_pin.sym} 66060 -29730 0 0 {name=p65388 lab=_83584_/Q }
C {devices/lab_pin.sym} 66140 -29730 0 1 {name=p65389 lab=_53663_/B }
C {sky130_stdcells/inv_2.sym} 66100 -29730 0 0 {name=X_48454_ }
C {devices/lab_pin.sym} 66040 -29640 0 0 {name=p65390 lab=_45893_/C }
C {devices/lab_pin.sym} 66040 -29600 0 0 {name=p65391 lab=_44907_/A }
C {devices/lab_pin.sym} 66040 -29560 0 0 {name=p65392 lab=_72718_/C }
C {devices/lab_pin.sym} 66040 -29520 0 0 {name=p65393 lab=_72718_/D }
C {devices/lab_pin.sym} 66160 -29580 0 1 {name=p65394 lab=_72718_/X }
C {sky130_stdcells/and4_4.sym} 66100 -29580 0 0 {name=X_72718_ }
C {devices/lab_pin.sym} 66020 -29450 0 0 {name=p65395 lab=_79272_/Y }
C {devices/lab_pin.sym} 66020 -29410 0 0 {name=p65396 lab=_79253_/Y }
C {devices/lab_pin.sym} 66020 -29370 0 0 {name=p65397 lab=_79273_/X }
C {devices/lab_pin.sym} 66180 -29410 0 1 {name=p65398 lab=_79275_/B }
C {sky130_stdcells/o21ai_4.sym} 66100 -29410 0 0 {name=X_79274_ }
C {devices/lab_pin.sym} 66020 -29290 0 0 {name=p65399 lab=_82992_/Q }
C {devices/lab_pin.sym} 66020 -29250 0 0 {name=p65400 lab=_45388_/X }
C {devices/lab_pin.sym} 66020 -29210 0 0 {name=p65401 lab=_45665_/X }
C {devices/lab_pin.sym} 66180 -29250 0 1 {name=p65402 lab=_45666_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -29250 0 0 {name=X_45666_ }
C {devices/lab_pin.sym} 66040 -29120 0 0 {name=p65403 lab=_76486_/A }
C {devices/lab_pin.sym} 66040 -29080 0 0 {name=p65404 lab=_76485_/X }
C {devices/lab_pin.sym} 66160 -29100 0 1 {name=p65405 lab=_81336_/D }
C {sky130_stdcells/xor2_4.sym} 66100 -29100 0 0 {name=X_76486_ }
C {devices/lab_pin.sym} 66020 -29000 0 0 {name=p65406 lab=_41601_/X }
C {devices/lab_pin.sym} 66020 -28960 0 0 {name=p65407 lab=_42866_/X }
C {devices/lab_pin.sym} 66020 -28920 0 0 {name=p65408 lab=_67223_/B }
C {devices/lab_pin.sym} 66020 -28880 0 0 {name=p65409 lab=_42867_/X }
C {devices/lab_pin.sym} 66180 -28940 0 1 {name=p65410 lab=_87672_/D }
C {sky130_stdcells/a2bb2o_4.sym} 66100 -28940 0 0 {name=X_42878_ }
C {devices/lab_pin.sym} 66060 -28790 0 0 {name=p65411 lab=_73343_/X }
C {devices/lab_pin.sym} 66140 -28790 0 1 {name=p65412 lab=_73698_/X }
C {sky130_stdcells/buf_2.sym} 66100 -28790 0 0 {name=X_73698_ }
C {devices/lab_pin.sym} 66020 -28690 0 0 {name=p65413 lab=_86638_/Q }
C {devices/lab_pin.sym} 66020 -28650 0 0 {name=p65414 lab=_47382_/X }
C {devices/lab_pin.sym} 66020 -28610 0 0 {name=p65415 lab=_47404_/Y }
C {devices/lab_pin.sym} 66180 -28650 0 1 {name=p65416 lab=_47405_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -28650 0 0 {name=X_47405_ }
C {devices/lab_pin.sym} 66040 -28520 0 0 {name=p65417 lab=_78225_/A }
C {devices/lab_pin.sym} 66040 -28480 0 0 {name=p65418 lab=_78234_/A }
C {devices/lab_pin.sym} 66160 -28500 0 1 {name=p65419 lab=_78226_/B }
C {sky130_stdcells/xor2_4.sym} 66100 -28500 0 0 {name=X_78225_ }
C {devices/lab_pin.sym} 66060 -28370 0 0 {name=p65420 lab=_46298_/A }
C {devices/lab_pin.sym} 66140 -28370 0 1 {name=p65421 lab=_44618_/A }
C {sky130_stdcells/buf_2.sym} 66100 -28370 0 0 {name=X_44617_ }
C {devices/lab_pin.sym} 66040 -28270 0 0 {name=p65422 lab=_63463_/A }
C {devices/lab_pin.sym} 66040 -28230 0 0 {name=p65423 lab=_84898_/Q }
C {devices/lab_pin.sym} 66040 -28190 0 0 {name=p65424 lab=_63463_/C }
C {devices/lab_pin.sym} 66160 -28230 0 1 {name=p65425 lab=_63451_/X }
C {sky130_stdcells/and3_4.sym} 66100 -28230 0 0 {name=X_63451_ }
C {devices/lab_pin.sym} 66020 -28110 0 0 {name=p65426 lab=_75401_/Y }
C {devices/lab_pin.sym} 66020 -28070 0 0 {name=p65427 lab=_75435_/D }
C {devices/lab_pin.sym} 66020 -28030 0 0 {name=p65428 lab=_75435_/B }
C {devices/lab_pin.sym} 66180 -28070 0 1 {name=p65429 lab=_75437_/X }
C {sky130_stdcells/a21bo_4.sym} 66100 -28070 0 0 {name=X_75437_ }
C {devices/lab_pin.sym} 66060 -27930 0 0 {name=p65430 lab=_41829_/A }
C {devices/lab_pin.sym} 66140 -27930 0 1 {name=p65431 lab=_41829_/Y }
C {sky130_stdcells/inv_2.sym} 66100 -27930 0 0 {name=X_41829_ }
C {devices/lab_pin.sym} 66040 -27820 0 0 {name=p65432 lab=_48384_/Y }
C {devices/lab_pin.sym} 66040 -27780 0 0 {name=p65433 lab=_48449_/B }
C {devices/lab_pin.sym} 66160 -27800 0 1 {name=p65434 lab=_48385_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -27800 0 0 {name=X_48385_ }
C {devices/lab_pin.sym} 66040 -27700 0 0 {name=p65435 lab=_60720_/A }
C {devices/lab_pin.sym} 66040 -27660 0 0 {name=p65436 lab=_60687_/A }
C {devices/lab_pin.sym} 66040 -27620 0 0 {name=p65437 lab=_60632_/A }
C {devices/lab_pin.sym} 66040 -27580 0 0 {name=p65438 lab=_60702_/C }
C {devices/lab_pin.sym} 66160 -27640 0 1 {name=p65439 lab=_60663_/Y }
C {sky130_stdcells/nand4_4.sym} 66100 -27640 0 0 {name=X_60663_ }
C {devices/lab_pin.sym} 66020 -27510 0 0 {name=p65440 lab=_70188_/C }
C {devices/lab_pin.sym} 66020 -27470 0 0 {name=p65441 lab=_72645_/X }
C {devices/lab_pin.sym} 66020 -27430 0 0 {name=p65442 lab=_72648_/Y }
C {devices/lab_pin.sym} 66180 -27470 0 1 {name=p65443 lab=_72649_/X }
C {sky130_stdcells/a21bo_4.sym} 66100 -27470 0 0 {name=X_72649_ }
C {devices/lab_pin.sym} 66040 -27340 0 0 {name=p65444 lab=_45597_/A }
C {devices/lab_pin.sym} 66040 -27300 0 0 {name=p65445 lab=_45597_/B }
C {devices/lab_pin.sym} 66160 -27320 0 1 {name=p65446 lab=_45597_/Y }
C {sky130_stdcells/nor2_4.sym} 66100 -27320 0 0 {name=X_45597_ }
C {devices/lab_pin.sym} 66060 -27190 0 0 {name=p65447 lab=_62203_/Y }
C {devices/lab_pin.sym} 66140 -27190 0 1 {name=p65448 lab=_62448_/A }
C {sky130_stdcells/buf_2.sym} 66100 -27190 0 0 {name=X_62402_ }
C {devices/lab_pin.sym} 66040 -27080 0 0 {name=p65449 lab=_47333_/X }
C {devices/lab_pin.sym} 66040 -27040 0 0 {name=p65450 lab=_52991_/B }
C {devices/lab_pin.sym} 66160 -27060 0 1 {name=p65451 lab=_47336_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -27060 0 0 {name=X_47336_ }
C {devices/lab_pin.sym} 66020 -26950 0 0 {name=p65452 lab=_66167_/X }
C {devices/lab_pin.sym} 66020 -26910 0 0 {name=p65453 lab=_66169_/X }
C {devices/lab_pin.sym} 66020 -26870 0 0 {name=p65454 lab=_65961_/X }
C {devices/lab_pin.sym} 66180 -26910 0 1 {name=p65455 lab=_66173_/A }
C {sky130_stdcells/a21o_4.sym} 66100 -26910 0 0 {name=X_66170_ }
C {devices/lab_pin.sym} 66040 -26780 0 0 {name=p65456 lab=_78154_/X }
C {devices/lab_pin.sym} 66040 -26740 0 0 {name=p65457 lab=_78162_/C }
C {devices/lab_pin.sym} 66160 -26760 0 1 {name=p65458 lab=_78156_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -26760 0 0 {name=X_78156_ }
C {devices/lab_pin.sym} 66060 -26630 0 0 {name=p65459 lab=_44548_/A }
C {devices/lab_pin.sym} 66140 -26630 0 1 {name=p65460 lab=_44548_/X }
C {sky130_stdcells/buf_2.sym} 66100 -26630 0 0 {name=X_44548_ }
C {devices/lab_pin.sym} 66040 -26530 0 0 {name=p65461 lab=_63305_/X }
C {devices/lab_pin.sym} 66040 -26490 0 0 {name=p65462 lab=_63392_/B }
C {devices/lab_pin.sym} 66040 -26450 0 0 {name=p65463 lab=_80614_/B }
C {devices/lab_pin.sym} 66160 -26490 0 1 {name=p65464 lab=_63382_/Y }
C {sky130_stdcells/nor3_4.sym} 66100 -26490 0 0 {name=X_63382_ }
C {devices/lab_pin.sym} 66020 -26370 0 0 {name=p65465 lab=_75347_/X }
C {devices/lab_pin.sym} 66020 -26330 0 0 {name=p65466 lab=_75366_/Y }
C {devices/lab_pin.sym} 66020 -26290 0 0 {name=p65467 lab=_75367_/Y }
C {devices/lab_pin.sym} 66180 -26330 0 1 {name=p65468 lab=_75368_/X }
C {sky130_stdcells/a21bo_4.sym} 66100 -26330 0 0 {name=X_75368_ }
C {devices/lab_pin.sym} 66060 -26190 0 0 {name=p65469 lab=_60594_/A }
C {devices/lab_pin.sym} 66140 -26190 0 1 {name=p65470 lab=_60596_/A }
C {sky130_stdcells/inv_2.sym} 66100 -26190 0 0 {name=X_60594_ }
C {devices/lab_pin.sym} 66020 -26100 0 0 {name=p65471 lab=_65118_/X }
C {devices/lab_pin.sym} 66020 -26060 0 0 {name=p65472 lab=_85517_/Q }
C {devices/lab_pin.sym} 66020 -26020 0 0 {name=p65473 lab=_64919_/X }
C {devices/lab_pin.sym} 66020 -25980 0 0 {name=p65474 lab=_65120_/X }
C {devices/lab_pin.sym} 66180 -26040 0 1 {name=p65475 lab=_65121_/X }
C {sky130_stdcells/a211o_4.sym} 66100 -26040 0 0 {name=X_65121_ }
C {devices/lab_pin.sym} 66040 -25900 0 0 {name=p65476 lab=_77114_/B }
C {devices/lab_pin.sym} 66040 -25860 0 0 {name=p65477 lab=_82288_/D }
C {devices/lab_pin.sym} 66160 -25880 0 1 {name=p65478 lab=_77107_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -25880 0 0 {name=X_77107_ }
C {devices/lab_pin.sym} 66040 -25770 0 0 {name=p65479 lab=_62319_/A }
C {devices/lab_pin.sym} 66040 -25730 0 0 {name=p65480 lab=_63459_/B }
C {devices/lab_pin.sym} 66040 -25690 0 0 {name=p65481 lab=_62319_/C }
C {devices/lab_pin.sym} 66160 -25730 0 1 {name=p65482 lab=_62335_/C }
C {sky130_stdcells/nand3_4.sym} 66100 -25730 0 0 {name=X_62333_ }
C {devices/lab_pin.sym} 66040 -25610 0 0 {name=p65483 lab=_74325_/A }
C {devices/lab_pin.sym} 66040 -25570 0 0 {name=p65484 lab=_74325_/B }
C {devices/lab_pin.sym} 66040 -25530 0 0 {name=p65485 lab=_56073_/A }
C {devices/lab_pin.sym} 66160 -25570 0 1 {name=p65486 lab=_74319_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -25570 0 0 {name=X_74319_ }
C {devices/lab_pin.sym} 66060 -25430 0 0 {name=p65487 lab=_83388_/Q }
C {devices/lab_pin.sym} 66140 -25430 0 1 {name=p65488 lab=_54121_/B }
C {sky130_stdcells/inv_2.sym} 66100 -25430 0 0 {name=X_47267_ }
C {devices/lab_pin.sym} 66040 -25320 0 0 {name=p65489 lab=_78088_/A }
C {devices/lab_pin.sym} 66040 -25280 0 0 {name=p65490 lab=_78088_/B }
C {devices/lab_pin.sym} 66160 -25300 0 1 {name=p65491 lab=_78087_/Y }
C {sky130_stdcells/nor2_4.sym} 66100 -25300 0 0 {name=X_78087_ }
C {devices/lab_pin.sym} 66020 -25200 0 0 {name=p65492 lab=_41198_/Y }
C {devices/lab_pin.sym} 66020 -25160 0 0 {name=p65493 lab=_44474_/X }
C {devices/lab_pin.sym} 66020 -25120 0 0 {name=p65494 lab=_87087_/Q }
C {devices/lab_pin.sym} 66020 -25080 0 0 {name=p65495 lab=_44475_/X }
C {devices/lab_pin.sym} 66180 -25140 0 1 {name=p65496 lab=_44479_/X }
C {sky130_stdcells/a2bb2o_4.sym} 66100 -25140 0 0 {name=X_44479_ }
C {devices/lab_pin.sym} 66060 -24990 0 0 {name=p65497 lab=_75299_/A }
C {devices/lab_pin.sym} 66140 -24990 0 1 {name=p65498 lab=_75299_/Y }
C {sky130_stdcells/inv_2.sym} 66100 -24990 0 0 {name=X_75299_ }
C {devices/lab_pin.sym} 66060 -24870 0 0 {name=p65499 lab=_53841_/B }
C {devices/lab_pin.sym} 66140 -24870 0 1 {name=p65500 lab=_49006_/X }
C {sky130_stdcells/buf_2.sym} 66100 -24870 0 0 {name=X_49006_ }
C {devices/lab_pin.sym} 66040 -24780 0 0 {name=p65501 lab=_44031_/X }
C {devices/lab_pin.sym} 66040 -24740 0 0 {name=p65502 lab=_46098_/A }
C {devices/lab_pin.sym} 66040 -24700 0 0 {name=p65503 lab=_46214_/C }
C {devices/lab_pin.sym} 66040 -24660 0 0 {name=p65504 lab=_46214_/D }
C {devices/lab_pin.sym} 66160 -24720 0 1 {name=p65505 lab=_46218_/Y }
C {sky130_stdcells/nand4_4.sym} 66100 -24720 0 0 {name=X_46218_ }
C {devices/lab_pin.sym} 66020 -24600 0 0 {name=p65506 lab=_64696_/X }
C {devices/lab_pin.sym} 66020 -24560 0 0 {name=p65507 lab=_85520_/Q }
C {devices/lab_pin.sym} 66020 -24520 0 0 {name=p65508 lab=_64697_/X }
C {devices/lab_pin.sym} 66020 -24480 0 0 {name=p65509 lab=_65051_/X }
C {devices/lab_pin.sym} 66180 -24540 0 1 {name=p65510 lab=_65052_/X }
C {sky130_stdcells/a211o_4.sym} 66100 -24540 0 0 {name=X_65052_ }
C {devices/lab_pin.sym} 66040 -24400 0 0 {name=p65511 lab=_81992_/Q }
C {devices/lab_pin.sym} 66040 -24360 0 0 {name=p65512 lab=_82280_/D }
C {devices/lab_pin.sym} 66160 -24380 0 1 {name=p65513 lab=_77038_/X }
C {sky130_stdcells/xor2_4.sym} 66100 -24380 0 0 {name=X_77038_ }
C {devices/lab_pin.sym} 66020 -24290 0 0 {name=p65514 lab=_62256_/X }
C {devices/lab_pin.sym} 66020 -24250 0 0 {name=p65515 lab=_62258_/X }
C {devices/lab_pin.sym} 66020 -24210 0 0 {name=p65516 lab=_62263_/Y }
C {devices/lab_pin.sym} 66020 -24170 0 0 {name=p65517 lab=_84918_/Q }
C {devices/lab_pin.sym} 66020 -24130 0 0 {name=p65518 lab=_62214_/X }
C {devices/lab_pin.sym} 66180 -24210 0 1 {name=p65519 lab=_62264_/Y }
C {sky130_stdcells/o32ai_4.sym} 66100 -24210 0 0 {name=X_62264_ }
C {devices/lab_pin.sym} 66060 -24050 0 0 {name=p65520 lab=_46725_/A }
C {devices/lab_pin.sym} 66140 -24050 0 1 {name=p65521 lab=_47198_/X }
C {sky130_stdcells/buf_2.sym} 66100 -24050 0 0 {name=X_47198_ }
C {devices/lab_pin.sym} 66060 -23930 0 0 {name=p65522 lab=_44273_/Y }
C {devices/lab_pin.sym} 66140 -23930 0 1 {name=p65523 lab=_44274_/D }
C {sky130_stdcells/buf_8.sym} 66100 -23930 0 0 {name=Xpsn_inst_psn_buff_16 }
C {devices/lab_pin.sym} 66040 -23840 0 0 {name=p65524 lab=_61522_/X }
C {devices/lab_pin.sym} 66040 -23800 0 0 {name=p65525 lab=_64052_/B }
C {devices/lab_pin.sym} 66040 -23760 0 0 {name=p65526 lab=_64003_/C }
C {devices/lab_pin.sym} 66040 -23720 0 0 {name=p65527 lab=_64052_/D }
C {devices/lab_pin.sym} 66160 -23780 0 1 {name=p65528 lab=_64003_/Y }
C {sky130_stdcells/nand4_4.sym} 66100 -23780 0 0 {name=X_64003_ }
C {devices/lab_pin.sym} 66020 -23670 0 0 {name=p65529 lab=_61112_/X }
C {devices/lab_pin.sym} 66020 -23630 0 0 {name=p65530 lab=_61096_/X }
C {devices/lab_pin.sym} 66020 -23590 0 0 {name=p65531 lab=_61103_/X }
C {devices/lab_pin.sym} 66020 -23550 0 0 {name=p65532 lab=_61205_/A }
C {devices/lab_pin.sym} 66020 -23520 0 0 {name=p65533 lab=_60528_/A }
C {devices/lab_pin.sym} 66180 -23590 0 1 {name=p65534 lab=_61215_/Y }
C {sky130_stdcells/a41oi_4.sym} 66100 -23590 0 0 {name=X_61215_ }
C {devices/lab_pin.sym} 66060 -23430 0 0 {name=p65535 lab=_50212_/A }
C {devices/lab_pin.sym} 66140 -23430 0 1 {name=p65536 lab=_41909_/B1 }
C {sky130_stdcells/buf_2.sym} 66100 -23430 0 0 {name=Xpsn_inst_psn_buff_27 }
C {devices/lab_pin.sym} 66040 -23330 0 0 {name=p65537 lab=_46120_/A }
C {devices/lab_pin.sym} 66040 -23290 0 0 {name=p65538 lab=_46120_/B }
C {devices/lab_pin.sym} 66040 -23250 0 0 {name=p65539 lab=_49380_/C }
C {devices/lab_pin.sym} 66160 -23290 0 1 {name=p65540 lab=_46149_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -23290 0 0 {name=X_46149_ }
C {devices/lab_pin.sym} 66040 -23160 0 0 {name=p65541 lab=_68934_/X }
C {devices/lab_pin.sym} 66040 -23120 0 0 {name=p65542 lab=_69860_/B }
C {devices/lab_pin.sym} 66160 -23140 0 1 {name=p65543 lab=_69860_/Y }
C {sky130_stdcells/nor2_4.sym} 66100 -23140 0 0 {name=X_69860_ }
C {devices/lab_pin.sym} 66060 -23010 0 0 {name=p65544 lab=_62195_/A }
C {devices/lab_pin.sym} 66140 -23010 0 1 {name=p65545 lab=_62195_/Y }
C {sky130_stdcells/inv_2.sym} 66100 -23010 0 0 {name=X_62195_ }
C {devices/lab_pin.sym} 66020 -22920 0 0 {name=p65546 lab=_68798_/Y }
C {devices/lab_pin.sym} 66020 -22880 0 0 {name=p65547 lab=_68358_/X }
C {devices/lab_pin.sym} 66020 -22840 0 0 {name=p65548 lab=_68649_/X }
C {devices/lab_pin.sym} 66020 -22800 0 0 {name=p65549 lab=_68810_/Y }
C {devices/lab_pin.sym} 66180 -22860 0 1 {name=p65550 lab=_68811_/X }
C {sky130_stdcells/a211o_4.sym} 66100 -22860 0 0 {name=X_68811_ }
C {devices/lab_pin.sym} 66060 -22710 0 0 {name=p65551 lab=_61145_/X }
C {devices/lab_pin.sym} 66140 -22710 0 1 {name=p65552 lab=_64523_/D }
C {sky130_stdcells/buf_2.sym} 66100 -22710 0 0 {name=X_61146_ }
C {devices/lab_pin.sym} 66040 -22600 0 0 {name=p65553 lab=_69791_/A }
C {devices/lab_pin.sym} 66040 -22560 0 0 {name=p65554 lab=_69790_/Y }
C {devices/lab_pin.sym} 66160 -22580 0 1 {name=p65555 lab=_69791_/Y }
C {sky130_stdcells/nor2_4.sym} 66100 -22580 0 0 {name=X_69791_ }
C {devices/lab_pin.sym} 66060 -22450 0 0 {name=p65556 lab=_78967_/Y }
C {devices/lab_pin.sym} 66140 -22450 0 1 {name=p65557 lab=_82516_/D }
C {sky130_stdcells/inv_2.sym} 66100 -22450 0 0 {name=X_78989_ }
C {devices/lab_pin.sym} 66040 -22340 0 0 {name=p65558 lab=_49928_/A }
C {devices/lab_pin.sym} 66040 -22300 0 0 {name=p65559 lab=_53122_/B }
C {devices/lab_pin.sym} 66160 -22320 0 1 {name=p65560 lab=_49908_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -22320 0 0 {name=X_49908_ }
C {devices/lab_pin.sym} 66060 -22190 0 0 {name=p65561 lab=_68742_/A }
C {devices/lab_pin.sym} 66140 -22190 0 1 {name=p65562 lab=_69067_/A }
C {sky130_stdcells/buf_2.sym} 66100 -22190 0 0 {name=X_68742_ }
C {devices/lab_pin.sym} 66020 -22090 0 0 {name=p65563 lab=_65903_/X }
C {devices/lab_pin.sym} 66020 -22050 0 0 {name=p65564 lab=_65477_/Y }
C {devices/lab_pin.sym} 66020 -22010 0 0 {name=p65565 lab=_65953_/Y }
C {devices/lab_pin.sym} 66180 -22050 0 1 {name=p65566 lab=_65954_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -22050 0 0 {name=X_65954_ }
C {devices/lab_pin.sym} 66060 -21910 0 0 {name=p65567 lab=_61144_/A }
C {devices/lab_pin.sym} 66140 -21910 0 1 {name=p65568 lab=_61083_/C }
C {sky130_stdcells/inv_2.sym} 66100 -21910 0 0 {name=X_61077_ }
C {devices/lab_pin.sym} 66020 -21820 0 0 {name=p65569 lab=_64752_/X }
C {devices/lab_pin.sym} 66020 -21780 0 0 {name=p65570 lab=_86166_/Q }
C {devices/lab_pin.sym} 66020 -21740 0 0 {name=p65571 lab=_64902_/X }
C {devices/lab_pin.sym} 66020 -21700 0 0 {name=p65572 lab=_64904_/X }
C {devices/lab_pin.sym} 66180 -21760 0 1 {name=p65573 lab=_64905_/X }
C {sky130_stdcells/a211o_4.sym} 66100 -21760 0 0 {name=X_64905_ }
C {devices/lab_pin.sym} 66040 -21630 0 0 {name=p65574 lab=_62194_/D }
C {devices/lab_pin.sym} 66040 -21590 0 0 {name=p65575 lab=_60091_/C }
C {devices/lab_pin.sym} 66040 -21550 0 0 {name=p65576 lab=_60027_/X }
C {devices/lab_pin.sym} 66160 -21590 0 1 {name=p65577 lab=_60028_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -21590 0 0 {name=X_60028_ }
C {devices/lab_pin.sym} 66040 -21480 0 0 {name=p65578 lab=_49830_/A }
C {devices/lab_pin.sym} 66040 -21440 0 0 {name=p65579 lab=_49851_/B }
C {devices/lab_pin.sym} 66040 -21400 0 0 {name=p65580 lab=_49830_/C }
C {devices/lab_pin.sym} 66040 -21360 0 0 {name=p65581 lab=_53052_/D }
C {devices/lab_pin.sym} 66160 -21420 0 1 {name=p65582 lab=_49839_/X }
C {sky130_stdcells/and4_4.sym} 66100 -21420 0 0 {name=X_49839_ }
C {devices/lab_pin.sym} 66010 -21270 0 0 {name=p65583 lab=_81996_/CLK }
C {devices/lab_pin.sym} 66010 -21250 0 0 {name=p65584 lab=_75376_/B }
C {devices/lab_pin.sym} 66190 -21270 0 1 {name=p65585 lab=_80951_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -21260 0 0 {name=X_80951_ }
C {devices/lab_pin.sym} 66020 -21160 0 0 {name=p65586 lab=_73845_/A }
C {devices/lab_pin.sym} 66020 -21120 0 0 {name=p65587 lab=_68493_/X }
C {devices/lab_pin.sym} 66020 -21080 0 0 {name=p65588 lab=_68494_/X }
C {devices/lab_pin.sym} 66020 -21040 0 0 {name=p65589 lab=_68672_/Y }
C {devices/lab_pin.sym} 66180 -21100 0 1 {name=p65590 lab=_68673_/X }
C {sky130_stdcells/a211o_4.sym} 66100 -21100 0 0 {name=X_68673_ }
C {devices/lab_pin.sym} 66040 -20970 0 0 {name=p65591 lab=_65390_/X }
C {devices/lab_pin.sym} 66040 -20930 0 0 {name=p65592 lab=_65828_/B }
C {devices/lab_pin.sym} 66040 -20890 0 0 {name=p65593 lab=_65393_/X }
C {devices/lab_pin.sym} 66160 -20930 0 1 {name=p65594 lab=_65885_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -20930 0 0 {name=X_65885_ }
C {devices/lab_pin.sym} 66060 -20790 0 0 {name=p65595 lab=_67863_/A }
C {devices/lab_pin.sym} 66140 -20790 0 1 {name=p65596 lab=_67624_/X }
C {sky130_stdcells/buf_2.sym} 66100 -20790 0 0 {name=X_67624_ }
C {devices/lab_pin.sym} 66040 -20680 0 0 {name=p65597 lab=_52850_/A }
C {devices/lab_pin.sym} 66040 -20640 0 0 {name=p65598 lab=_52850_/B }
C {devices/lab_pin.sym} 66160 -20660 0 1 {name=p65599 lab=_52850_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -20660 0 0 {name=X_52850_ }
C {devices/lab_pin.sym} 66040 -20540 0 0 {name=p65600 lab=_64836_/A }
C {devices/lab_pin.sym} 66040 -20500 0 0 {name=p65601 lab=_86457_/Q }
C {devices/lab_pin.sym} 66160 -20520 0 1 {name=p65602 lab=_64836_/X }
C {sky130_stdcells/and2_4.sym} 66100 -20520 0 0 {name=X_64836_ }
C {devices/lab_pin.sym} 66010 -20390 0 0 {name=p65603 lab=_83673_/CLK }
C {devices/lab_pin.sym} 66010 -20370 0 0 {name=p65604 lab=_70898_/Y }
C {devices/lab_pin.sym} 66190 -20390 0 1 {name=p65605 lab=_46794_/A }
C {sky130_stdcells/dfxtp_4.sym} 66100 -20380 0 0 {name=X_83670_ }
C {devices/lab_pin.sym} 66010 -20250 0 0 {name=p65606 lab=_81130_/CLK }
C {devices/lab_pin.sym} 66010 -20230 0 0 {name=p65607 lab=_75724_/B }
C {devices/lab_pin.sym} 66190 -20250 0 1 {name=p65608 lab=_80882_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -20240 0 0 {name=X_80882_ }
C {devices/lab_pin.sym} 66020 -20130 0 0 {name=p65609 lab=_85943_/Q }
C {devices/lab_pin.sym} 66020 -20090 0 0 {name=p65610 lab=_51789_/X }
C {devices/lab_pin.sym} 66020 -20050 0 0 {name=p65611 lab=_51800_/Y }
C {devices/lab_pin.sym} 66180 -20090 0 1 {name=p65612 lab=_51801_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -20090 0 0 {name=X_51801_ }
C {devices/lab_pin.sym} 66010 -19950 0 0 {name=p65613 lab=_82589_/CLK }
C {devices/lab_pin.sym} 66010 -19930 0 0 {name=p65614 lab=_82621_/D }
C {devices/lab_pin.sym} 66190 -19950 0 1 {name=p65615 lab=_82621_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -19940 0 0 {name=X_82621_ }
C {devices/lab_pin.sym} 66040 -19820 0 0 {name=p65616 lab=_67555_/A }
C {devices/lab_pin.sym} 66040 -19780 0 0 {name=p65617 lab=_67555_/B }
C {devices/lab_pin.sym} 66160 -19800 0 1 {name=p65618 lab=_67555_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -19800 0 0 {name=X_67555_ }
C {devices/lab_pin.sym} 66040 -19680 0 0 {name=p65619 lab=_52773_/A }
C {devices/lab_pin.sym} 66040 -19640 0 0 {name=p65620 lab=_52781_/B }
C {devices/lab_pin.sym} 66160 -19660 0 1 {name=p65621 lab=_52781_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -19660 0 0 {name=X_52781_ }
C {devices/lab_pin.sym} 66040 -19540 0 0 {name=p65622 lab=_64767_/A }
C {devices/lab_pin.sym} 66040 -19500 0 0 {name=p65623 lab=_85851_/Q }
C {devices/lab_pin.sym} 66160 -19520 0 1 {name=p65624 lab=_64767_/X }
C {sky130_stdcells/and2_4.sym} 66100 -19520 0 0 {name=X_64767_ }
C {devices/lab_pin.sym} 66040 -19420 0 0 {name=p65625 lab=_61962_/X }
C {devices/lab_pin.sym} 66040 -19380 0 0 {name=p65626 lab=_61945_/X }
C {devices/lab_pin.sym} 66040 -19340 0 0 {name=p65627 lab=_63557_/B }
C {devices/lab_pin.sym} 66040 -19300 0 0 {name=p65628 lab=_61947_/D }
C {devices/lab_pin.sym} 66160 -19360 0 1 {name=p65629 lab=_61979_/X }
C {sky130_stdcells/and4_4.sym} 66100 -19360 0 0 {name=X_61979_ }
C {devices/lab_pin.sym} 66060 -19210 0 0 {name=p65630 lab=_54245_/A }
C {devices/lab_pin.sym} 66140 -19210 0 1 {name=p65631 lab=_54521_/A }
C {sky130_stdcells/buf_2.sym} 66100 -19210 0 0 {name=X_54520_ }
C {devices/lab_pin.sym} 66020 -19110 0 0 {name=p65632 lab=_66504_/Y }
C {devices/lab_pin.sym} 66020 -19070 0 0 {name=p65633 lab=_66483_/X }
C {devices/lab_pin.sym} 66020 -19030 0 0 {name=p65634 lab=_66505_/X }
C {devices/lab_pin.sym} 66180 -19070 0 1 {name=p65635 lab=_84110_/D }
C {sky130_stdcells/a21o_4.sym} 66100 -19070 0 0 {name=X_66506_ }
C {devices/lab_pin.sym} 66010 -18930 0 0 {name=p65636 lab=_85372_/CLK }
C {devices/lab_pin.sym} 66010 -18910 0 0 {name=p65637 lab=_54988_/Y }
C {devices/lab_pin.sym} 66190 -18930 0 1 {name=p65638 lab=_85340_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -18920 0 0 {name=X_85340_ }
C {devices/lab_pin.sym} 66040 -18800 0 0 {name=p65639 lab=_51737_/A }
C {devices/lab_pin.sym} 66040 -18760 0 0 {name=p65640 lab=_53255_/B }
C {devices/lab_pin.sym} 66160 -18780 0 1 {name=p65641 lab=_51732_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -18780 0 0 {name=X_51732_ }
C {devices/lab_pin.sym} 66040 -18670 0 0 {name=p65642 lab=_63701_/A }
C {devices/lab_pin.sym} 66040 -18630 0 0 {name=p65643 lab=_63701_/B }
C {devices/lab_pin.sym} 66040 -18590 0 0 {name=p65644 lab=_80268_/B }
C {devices/lab_pin.sym} 66160 -18630 0 1 {name=p65645 lab=_63718_/Y }
C {sky130_stdcells/nor3_4.sym} 66100 -18630 0 0 {name=X_63718_ }
C {devices/lab_pin.sym} 66010 -18490 0 0 {name=p65646 lab=_83133_/CLK }
C {devices/lab_pin.sym} 66010 -18470 0 0 {name=p65647 lab=_82552_/D }
C {devices/lab_pin.sym} 66190 -18490 0 1 {name=p65648 lab=_82552_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -18480 0 0 {name=X_82552_ }
C {devices/lab_pin.sym} 66020 -18380 0 0 {name=p65649 lab=_87981_/Q }
C {devices/lab_pin.sym} 66020 -18340 0 0 {name=p65650 lab=_67414_/X }
C {devices/lab_pin.sym} 66020 -18300 0 0 {name=p65651 lab=_67391_/X }
C {devices/lab_pin.sym} 66020 -18260 0 0 {name=p65652 lab=_67485_/X }
C {devices/lab_pin.sym} 66180 -18320 0 1 {name=p65653 lab=_67486_/X }
C {sky130_stdcells/a211o_4.sym} 66100 -18320 0 0 {name=X_67486_ }
C {devices/lab_pin.sym} 66060 -18170 0 0 {name=p65654 lab=_64616_/A }
C {devices/lab_pin.sym} 66140 -18170 0 1 {name=p65655 lab=_65836_/A }
C {sky130_stdcells/buf_2.sym} 66100 -18170 0 0 {name=X_64698_ }
C {devices/lab_pin.sym} 66010 -18050 0 0 {name=p65656 lab=_81461_/CLK }
C {devices/lab_pin.sym} 66010 -18030 0 0 {name=p65657 lab=_84071_/Q }
C {devices/lab_pin.sym} 66190 -18050 0 1 {name=p65658 lab=_81503_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -18040 0 0 {name=X_81503_ }
C {devices/lab_pin.sym} 66020 -17940 0 0 {name=p65659 lab=_87033_/Q }
C {devices/lab_pin.sym} 66020 -17900 0 0 {name=p65660 lab=_69182_/X }
C {devices/lab_pin.sym} 66020 -17860 0 0 {name=p65661 lab=_69183_/X }
C {devices/lab_pin.sym} 66020 -17820 0 0 {name=p65662 lab=_69224_/X }
C {devices/lab_pin.sym} 66180 -17880 0 1 {name=p65663 lab=_69226_/B }
C {sky130_stdcells/a211o_4.sym} 66100 -17880 0 0 {name=X_69225_ }
C {devices/lab_pin.sym} 66040 -17740 0 0 {name=p65664 lab=_54446_/A }
C {devices/lab_pin.sym} 66040 -17700 0 0 {name=p65665 lab=_54451_/B }
C {devices/lab_pin.sym} 66160 -17720 0 1 {name=p65666 lab=_54451_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -17720 0 0 {name=X_54451_ }
C {devices/lab_pin.sym} 66040 -17610 0 0 {name=p65667 lab=_64978_/X }
C {devices/lab_pin.sym} 66040 -17570 0 0 {name=p65668 lab=_66518_/B }
C {devices/lab_pin.sym} 66040 -17530 0 0 {name=p65669 lab=_64982_/X }
C {devices/lab_pin.sym} 66160 -17570 0 1 {name=p65670 lab=_66437_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -17570 0 0 {name=X_66437_ }
C {devices/lab_pin.sym} 66010 -17430 0 0 {name=p65671 lab=_85270_/CLK }
C {devices/lab_pin.sym} 66010 -17410 0 0 {name=p65672 lab=_85271_/D }
C {devices/lab_pin.sym} 66190 -17430 0 1 {name=p65673 lab=_56219_/C }
C {sky130_stdcells/dfxtp_4.sym} 66100 -17420 0 0 {name=X_85271_ }
C {devices/lab_pin.sym} 66040 -17320 0 0 {name=p65674 lab=_51657_/X }
C {devices/lab_pin.sym} 66040 -17280 0 0 {name=p65675 lab=_51651_/B }
C {devices/lab_pin.sym} 66040 -17240 0 0 {name=p65676 lab=_51684_/C }
C {devices/lab_pin.sym} 66040 -17200 0 0 {name=p65677 lab=_53185_/D }
C {devices/lab_pin.sym} 66160 -17260 0 1 {name=p65678 lab=_51663_/X }
C {sky130_stdcells/and4_4.sym} 66100 -17260 0 0 {name=X_51663_ }
C {devices/lab_pin.sym} 66020 -17150 0 0 {name=p65679 lab=_58184_/A }
C {devices/lab_pin.sym} 66020 -17110 0 0 {name=p65680 lab=_60798_/X }
C {devices/lab_pin.sym} 66020 -17070 0 0 {name=p65681 lab=_63384_/C }
C {devices/lab_pin.sym} 66020 -17030 0 0 {name=p65682 lab=_60703_/Y }
C {devices/lab_pin.sym} 66020 -16990 0 0 {name=p65683 lab=_62097_/X }
C {devices/lab_pin.sym} 66180 -17070 0 1 {name=p65684 lab=_63649_/X }
C {sky130_stdcells/a32o_4.sym} 66100 -17070 0 0 {name=X_63649_ }
C {devices/lab_pin.sym} 66010 -16910 0 0 {name=p65685 lab=_82532_/CLK }
C {devices/lab_pin.sym} 66010 -16890 0 0 {name=p65686 lab=_78564_/X }
C {devices/lab_pin.sym} 66190 -16910 0 1 {name=p65687 lab=_82483_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -16900 0 0 {name=X_82483_ }
C {devices/lab_pin.sym} 66010 -16770 0 0 {name=p65688 lab=_88283_/CLK }
C {devices/lab_pin.sym} 66010 -16750 0 0 {name=p65689 lab=_44664_/X }
C {devices/lab_pin.sym} 66190 -16770 0 1 {name=p65690 lab=_87010_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -16760 0 0 {name=X_87010_ }
C {devices/lab_pin.sym} 66040 -16660 0 0 {name=p65691 lab=_53397_/A }
C {devices/lab_pin.sym} 66040 -16620 0 0 {name=p65692 lab=_53402_/B }
C {devices/lab_pin.sym} 66040 -16580 0 0 {name=p65693 lab=_53388_/C }
C {devices/lab_pin.sym} 66040 -16540 0 0 {name=p65694 lab=_52887_/D }
C {devices/lab_pin.sym} 66160 -16600 0 1 {name=p65695 lab=_53402_/X }
C {sky130_stdcells/and4_4.sym} 66100 -16600 0 0 {name=X_53402_ }
C {devices/lab_pin.sym} 66010 -16450 0 0 {name=p65696 lab=_85315_/CLK }
C {devices/lab_pin.sym} 66010 -16430 0 0 {name=p65697 lab=_84222_/D }
C {devices/lab_pin.sym} 66190 -16450 0 1 {name=p65698 lab=_84222_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -16440 0 0 {name=X_84222_ }
C {devices/lab_pin.sym} 66060 -16310 0 0 {name=p65699 lab=_50572_/A }
C {devices/lab_pin.sym} 66140 -16310 0 1 {name=p65700 lab=_50624_/A }
C {sky130_stdcells/buf_2.sym} 66100 -16310 0 0 {name=X_50614_ }
C {devices/lab_pin.sym} 66040 -16220 0 0 {name=p65701 lab=_57170_/A }
C {devices/lab_pin.sym} 66040 -16180 0 0 {name=p65702 lab=_57170_/B }
C {devices/lab_pin.sym} 66040 -16140 0 0 {name=p65703 lab=_56800_/X }
C {devices/lab_pin.sym} 66040 -16100 0 0 {name=p65704 lab=_57156_/X }
C {devices/lab_pin.sym} 66160 -16160 0 1 {name=p65705 lab=_57170_/Y }
C {sky130_stdcells/nand4_4.sym} 66100 -16160 0 0 {name=X_57170_ }
C {devices/lab_pin.sym} 66010 -16010 0 0 {name=p65706 lab=_82648_/CLK }
C {devices/lab_pin.sym} 66010 -15990 0 0 {name=p65707 lab=_81466_/Q }
C {devices/lab_pin.sym} 66190 -16010 0 1 {name=p65708 lab=_76092_/B }
C {sky130_stdcells/dfxtp_4.sym} 66100 -16000 0 0 {name=X_81434_ }
C {devices/lab_pin.sym} 66060 -15870 0 0 {name=p65709 lab=_69156_/A }
C {devices/lab_pin.sym} 66140 -15870 0 1 {name=p65710 lab=_69156_/X }
C {sky130_stdcells/buf_2.sym} 66100 -15870 0 0 {name=X_69156_ }
C {devices/lab_pin.sym} 66040 -15760 0 0 {name=p65711 lab=_54378_/A }
C {devices/lab_pin.sym} 66040 -15720 0 0 {name=p65712 lab=_52692_/B }
C {devices/lab_pin.sym} 66160 -15740 0 1 {name=p65713 lab=_54382_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -15740 0 0 {name=X_54382_ }
C {devices/lab_pin.sym} 66020 -15630 0 0 {name=p65714 lab=_66366_/X }
C {devices/lab_pin.sym} 66020 -15590 0 0 {name=p65715 lab=_64623_/Y }
C {devices/lab_pin.sym} 66020 -15550 0 0 {name=p65716 lab=_66367_/Y }
C {devices/lab_pin.sym} 66180 -15590 0 1 {name=p65717 lab=_66368_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -15590 0 0 {name=X_66368_ }
C {devices/lab_pin.sym} 66060 -15450 0 0 {name=p65718 lab=_51621_/A }
C {devices/lab_pin.sym} 66140 -15450 0 1 {name=p65719 lab=_51594_/X }
C {sky130_stdcells/buf_2.sym} 66100 -15450 0 0 {name=X_51594_ }
C {devices/lab_pin.sym} 66020 -15350 0 0 {name=p65720 lab=_66681_/X }
C {devices/lab_pin.sym} 66020 -15310 0 0 {name=p65721 lab=_66684_/X }
C {devices/lab_pin.sym} 66020 -15270 0 0 {name=p65722 lab=_68106_/X }
C {devices/lab_pin.sym} 66180 -15310 0 1 {name=p65723 lab=_68107_/Y }
C {sky130_stdcells/a21oi_4.sym} 66100 -15310 0 0 {name=X_68107_ }
C {devices/lab_pin.sym} 66060 -15170 0 0 {name=p65724 lab=_56121_/A }
C {devices/lab_pin.sym} 66140 -15170 0 1 {name=p65725 lab=_56121_/X }
C {sky130_stdcells/buf_2.sym} 66100 -15170 0 0 {name=X_56121_ }
C {devices/lab_pin.sym} 66020 -15070 0 0 {name=p65726 lab=_85653_/Q }
C {devices/lab_pin.sym} 66020 -15030 0 0 {name=p65727 lab=_53324_/X }
C {devices/lab_pin.sym} 66020 -14990 0 0 {name=p65728 lab=_53332_/Y }
C {devices/lab_pin.sym} 66180 -15030 0 1 {name=p65729 lab=_53333_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -15030 0 0 {name=X_53333_ }
C {devices/lab_pin.sym} 66040 -14900 0 0 {name=p65730 lab=_65319_/A }
C {devices/lab_pin.sym} 66040 -14860 0 0 {name=p65731 lab=_65319_/B }
C {devices/lab_pin.sym} 66160 -14880 0 1 {name=p65732 lab=_65319_/X }
C {sky130_stdcells/and2_4.sym} 66100 -14880 0 0 {name=X_65319_ }
C {devices/lab_pin.sym} 66010 -14750 0 0 {name=p65733 lab=_82746_/CLK }
C {devices/lab_pin.sym} 66010 -14730 0 0 {name=p65734 lab=_66152_/X }
C {devices/lab_pin.sym} 66190 -14750 0 1 {name=p65735 lab=_84153_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -14740 0 0 {name=X_84153_ }
C {devices/lab_pin.sym} 66040 -14620 0 0 {name=p65736 lab=_50541_/A }
C {devices/lab_pin.sym} 66040 -14580 0 0 {name=p65737 lab=_48684_/B }
C {devices/lab_pin.sym} 66160 -14600 0 1 {name=p65738 lab=_50545_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -14600 0 0 {name=X_50545_ }
C {devices/lab_pin.sym} 66010 -14470 0 0 {name=p65739 lab=_81461_/CLK }
C {devices/lab_pin.sym} 66010 -14450 0 0 {name=p65740 lab=_76832_/Y }
C {devices/lab_pin.sym} 66190 -14470 0 1 {name=p65741 lab=_81365_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -14460 0 0 {name=X_81365_ }
C {devices/lab_pin.sym} 66020 -14360 0 0 {name=p65742 lab=_87573_/Q }
C {devices/lab_pin.sym} 66020 -14320 0 0 {name=p65743 lab=_68636_/X }
C {devices/lab_pin.sym} 66020 -14280 0 0 {name=p65744 lab=_68517_/X }
C {devices/lab_pin.sym} 66020 -14240 0 0 {name=p65745 lab=_69086_/X }
C {devices/lab_pin.sym} 66180 -14300 0 1 {name=p65746 lab=_69087_/X }
C {sky130_stdcells/a211o_4.sym} 66100 -14300 0 0 {name=X_69087_ }
C {devices/lab_pin.sym} 66020 -14180 0 0 {name=p65747 lab=_66236_/X }
C {devices/lab_pin.sym} 66020 -14140 0 0 {name=p65748 lab=_85606_/Q }
C {devices/lab_pin.sym} 66020 -14100 0 0 {name=p65749 lab=_66251_/X }
C {devices/lab_pin.sym} 66020 -14060 0 0 {name=p65750 lab=_66298_/X }
C {devices/lab_pin.sym} 66180 -14120 0 1 {name=p65751 lab=_66299_/X }
C {sky130_stdcells/a211o_4.sym} 66100 -14120 0 0 {name=X_66299_ }
C {devices/lab_pin.sym} 66010 -13970 0 0 {name=p65752 lab=_83846_/CLK }
C {devices/lab_pin.sym} 66010 -13950 0 0 {name=p65753 lab=_74309_/X }
C {devices/lab_pin.sym} 66190 -13970 0 1 {name=p65754 lab=_70292_/C }
C {sky130_stdcells/dfxtp_4.sym} 66100 -13960 0 0 {name=X_83104_ }
C {devices/lab_pin.sym} 66040 -13850 0 0 {name=p65755 lab=_56052_/A }
C {devices/lab_pin.sym} 66040 -13810 0 0 {name=p65756 lab=_56052_/B }
C {devices/lab_pin.sym} 66040 -13770 0 0 {name=p65757 lab=_55913_/B }
C {devices/lab_pin.sym} 66160 -13810 0 1 {name=p65758 lab=_56052_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -13810 0 0 {name=X_56052_ }
C {devices/lab_pin.sym} 66020 -13690 0 0 {name=p65759 lab=_80313_/Y }
C {devices/lab_pin.sym} 66020 -13650 0 0 {name=p65760 lab=_80314_/Y }
C {devices/lab_pin.sym} 66020 -13610 0 0 {name=p65761 lab=_80315_/A }
C {devices/lab_pin.sym} 66180 -13650 0 1 {name=p65762 lab=_80318_/A }
C {sky130_stdcells/a21o_4.sym} 66100 -13650 0 0 {name=X_80316_ }
C {devices/lab_pin.sym} 66020 -13540 0 0 {name=p65763 lab=_67782_/X }
C {devices/lab_pin.sym} 66020 -13500 0 0 {name=p65764 lab=_68027_/Y }
C {devices/lab_pin.sym} 66020 -13460 0 0 {name=p65765 lab=_67983_/X }
C {devices/lab_pin.sym} 66020 -13420 0 0 {name=p65766 lab=_68037_/Y }
C {devices/lab_pin.sym} 66180 -13480 0 1 {name=p65767 lab=_68038_/X }
C {sky130_stdcells/a211o_4.sym} 66100 -13480 0 0 {name=X_68038_ }
C {devices/lab_pin.sym} 66020 -13350 0 0 {name=p65768 lab=_85665_/Q }
C {devices/lab_pin.sym} 66020 -13310 0 0 {name=p65769 lab=_51900_/X }
C {devices/lab_pin.sym} 66020 -13270 0 0 {name=p65770 lab=_53263_/Y }
C {devices/lab_pin.sym} 66180 -13310 0 1 {name=p65771 lab=_53264_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -13310 0 0 {name=X_53264_ }
C {devices/lab_pin.sym} 66010 -13170 0 0 {name=p65772 lab=_83918_/CLK }
C {devices/lab_pin.sym} 66010 -13150 0 0 {name=p65773 lab=_84084_/D }
C {devices/lab_pin.sym} 66190 -13170 0 1 {name=p65774 lab=_84084_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -13160 0 0 {name=X_84084_ }
C {devices/lab_pin.sym} 66020 -13050 0 0 {name=p65775 lab=_50472_/Y }
C {devices/lab_pin.sym} 66020 -13010 0 0 {name=p65776 lab=_50474_/X }
C {devices/lab_pin.sym} 66020 -12970 0 0 {name=p65777 lab=_50475_/Y }
C {devices/lab_pin.sym} 66180 -13010 0 1 {name=p65778 lab=_50476_/Y }
C {sky130_stdcells/a21boi_4.sym} 66100 -13010 0 0 {name=X_50476_ }
C {devices/lab_pin.sym} 66010 -12870 0 0 {name=p65779 lab=_81296_/CLK }
C {devices/lab_pin.sym} 66010 -12850 0 0 {name=p65780 lab=_76984_/X }
C {devices/lab_pin.sym} 66190 -12870 0 1 {name=p65781 lab=_81264_/D }
C {sky130_stdcells/dfxtp_4.sym} 66100 -12860 0 0 {name=X_81296_ }
C {devices/lab_pin.sym} 66060 -12730 0 0 {name=p65782 lab=clkbuf_9_221_0_CLK/X }
C {devices/lab_pin.sym} 66140 -12730 0 1 {name=p65783 lab=_84197_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 66100 -12730 0 0 {name=Xclkbuf_10_442_0_CLK }
C {devices/lab_pin.sym} 66020 -12630 0 0 {name=p65784 lab=_85337_/Q }
C {devices/lab_pin.sym} 66020 -12590 0 0 {name=p65785 lab=_54994_/X }
C {devices/lab_pin.sym} 66020 -12550 0 0 {name=p65786 lab=_55002_/Y }
C {devices/lab_pin.sym} 66180 -12590 0 1 {name=p65787 lab=_55003_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -12590 0 0 {name=X_55003_ }
C {devices/lab_pin.sym} 66060 -12450 0 0 {name=p65788 lab=_52215_/A }
C {devices/lab_pin.sym} 66140 -12450 0 1 {name=p65789 lab=_52220_/A }
C {sky130_stdcells/buf_2.sym} 66100 -12450 0 0 {name=X_52215_ }
C {devices/lab_pin.sym} 66010 -12330 0 0 {name=p65790 lab=_85213_/CLK }
C {devices/lab_pin.sym} 66010 -12310 0 0 {name=p65791 lab=_83035_/D }
C {devices/lab_pin.sym} 66190 -12330 0 1 {name=p65792 lab=_83035_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -12320 0 0 {name=X_83035_ }
C {devices/lab_pin.sym} 66010 -12190 0 0 {name=p65793 lab=_86932_/CLK }
C {devices/lab_pin.sym} 66010 -12170 0 0 {name=p65794 lab=_42341_/X }
C {devices/lab_pin.sym} 66190 -12190 0 1 {name=p65795 lab=_87912_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -12180 0 0 {name=X_87912_ }
C {devices/lab_pin.sym} 66020 -12070 0 0 {name=p65796 lab=_80244_/Y }
C {devices/lab_pin.sym} 66020 -12030 0 0 {name=p65797 lab=_80227_/Y }
C {devices/lab_pin.sym} 66020 -11990 0 0 {name=p65798 lab=_80246_/X }
C {devices/lab_pin.sym} 66180 -12030 0 1 {name=p65799 lab=_80247_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -12030 0 0 {name=X_80247_ }
C {devices/lab_pin.sym} 66060 -11890 0 0 {name=p65800 lab=_53195_/A }
C {devices/lab_pin.sym} 66140 -11890 0 1 {name=p65801 lab=_53195_/X }
C {sky130_stdcells/buf_2.sym} 66100 -11890 0 0 {name=X_53195_ }
C {devices/lab_pin.sym} 66020 -11790 0 0 {name=p65802 lab=_82556_/D }
C {devices/lab_pin.sym} 66020 -11750 0 0 {name=p65803 lab=_69988_/X }
C {devices/lab_pin.sym} 66020 -11710 0 0 {name=p65804 lab=_69999_/X }
C {devices/lab_pin.sym} 66180 -11750 0 1 {name=p65805 lab=_83876_/D }
C {sky130_stdcells/a21bo_4.sym} 66100 -11750 0 0 {name=X_70000_ }
C {devices/lab_pin.sym} 66060 -11610 0 0 {name=p65806 lab=_59810_/Y }
C {devices/lab_pin.sym} 66140 -11610 0 1 {name=p65807 lab=_59811_/Y }
C {sky130_stdcells/inv_2.sym} 66100 -11610 0 0 {name=X_59811_ }
C {devices/lab_pin.sym} 66040 -11510 0 0 {name=p65808 lab=_50443_/A }
C {devices/lab_pin.sym} 66040 -11470 0 0 {name=p65809 lab=_52140_/X }
C {devices/lab_pin.sym} 66040 -11430 0 0 {name=p65810 lab=_52156_/C }
C {devices/lab_pin.sym} 66160 -11470 0 1 {name=p65811 lab=_52146_/X }
C {sky130_stdcells/and3_4.sym} 66100 -11470 0 0 {name=X_52146_ }
C {devices/lab_pin.sym} 66010 -11330 0 0 {name=p65812 lab=_88104_/CLK }
C {devices/lab_pin.sym} 66010 -11310 0 0 {name=p65813 lab=_87843_/D }
C {devices/lab_pin.sym} 66190 -11330 0 1 {name=p65814 lab=_73940_/A }
C {sky130_stdcells/dfxtp_4.sym} 66100 -11320 0 0 {name=X_87843_ }
C {devices/lab_pin.sym} 66040 -11200 0 0 {name=p65815 lab=_80178_/A }
C {devices/lab_pin.sym} 66040 -11160 0 0 {name=p65816 lab=_80178_/B }
C {devices/lab_pin.sym} 66160 -11180 0 1 {name=p65817 lab=_80178_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -11180 0 0 {name=X_80178_ }
C {devices/lab_pin.sym} 66020 -11070 0 0 {name=p65818 lab=_69610_/X }
C {devices/lab_pin.sym} 66020 -11030 0 0 {name=p65819 lab=_69613_/X }
C {devices/lab_pin.sym} 66020 -10990 0 0 {name=p65820 lab=_69939_/X }
C {devices/lab_pin.sym} 66180 -11030 0 1 {name=p65821 lab=_69989_/Y }
C {sky130_stdcells/a21oi_4.sym} 66100 -11030 0 0 {name=X_69989_ }
C {devices/lab_pin.sym} 66060 -10890 0 0 {name=p65822 lab=_59742_/A }
C {devices/lab_pin.sym} 66140 -10890 0 1 {name=p65823 lab=_59742_/Y }
C {sky130_stdcells/inv_2.sym} 66100 -10890 0 0 {name=X_59742_ }
C {devices/lab_pin.sym} 66040 -10780 0 0 {name=p65824 lab=_52121_/A }
C {devices/lab_pin.sym} 66040 -10740 0 0 {name=p65825 lab=_48335_/B }
C {devices/lab_pin.sym} 66160 -10760 0 1 {name=p65826 lab=_52077_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -10760 0 0 {name=X_52077_ }
C {devices/lab_pin.sym} 66040 -10650 0 0 {name=p65827 lab=_56602_/X }
C {devices/lab_pin.sym} 66040 -10610 0 0 {name=p65828 lab=_85115_/Q }
C {devices/lab_pin.sym} 66040 -10570 0 0 {name=p65829 lab=_56953_/X }
C {devices/lab_pin.sym} 66160 -10610 0 1 {name=p65830 lab=_56954_/Y }
C {sky130_stdcells/nor3_4.sym} 66100 -10610 0 0 {name=X_56954_ }
C {devices/lab_pin.sym} 66010 -10470 0 0 {name=p65831 lab=_87525_/CLK }
C {devices/lab_pin.sym} 66010 -10450 0 0 {name=p65832 lab=_42678_/Y }
C {devices/lab_pin.sym} 66190 -10470 0 1 {name=p65833 lab=_87774_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -10460 0 0 {name=X_87774_ }
C {devices/lab_pin.sym} 66060 -10330 0 0 {name=p65834 lab=clkbuf_9_228_0_CLK/X }
C {devices/lab_pin.sym} 66140 -10330 0 1 {name=p65835 lab=_86297_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 66100 -10330 0 0 {name=Xclkbuf_10_457_0_CLK }
C {devices/lab_pin.sym} 66010 -10210 0 0 {name=p65836 lab=_86558_/CLK }
C {devices/lab_pin.sym} 66010 -10190 0 0 {name=p65837 lab=_84986_/D }
C {devices/lab_pin.sym} 66190 -10210 0 1 {name=p65838 lab=_84986_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -10200 0 0 {name=X_84986_ }
C {devices/lab_pin.sym} 66040 -10080 0 0 {name=p65839 lab=_55903_/A }
C {devices/lab_pin.sym} 66040 -10040 0 0 {name=p65840 lab=_56488_/C }
C {devices/lab_pin.sym} 66160 -10060 0 1 {name=p65841 lab=_55905_/X }
C {sky130_stdcells/and2_4.sym} 66100 -10060 0 0 {name=X_55905_ }
C {devices/lab_pin.sym} 66060 -9930 0 0 {name=p65842 lab=_50973_/A }
C {devices/lab_pin.sym} 66140 -9930 0 1 {name=p65843 lab=_51029_/A }
C {sky130_stdcells/buf_2.sym} 66100 -9930 0 0 {name=X_51028_ }
C {devices/lab_pin.sym} 66010 -9810 0 0 {name=p65844 lab=_86119_/CLK }
C {devices/lab_pin.sym} 66010 -9790 0 0 {name=p65845 lab=_86725_/D }
C {devices/lab_pin.sym} 66190 -9810 0 1 {name=p65846 lab=_86725_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -9800 0 0 {name=X_86725_ }
C {devices/lab_pin.sym} 66040 -9690 0 0 {name=p65847 lab=_71570_/X }
C {devices/lab_pin.sym} 66040 -9650 0 0 {name=p65848 lab=_70538_/X }
C {devices/lab_pin.sym} 66040 -9610 0 0 {name=p65849 lab=_71598_/C }
C {devices/lab_pin.sym} 66160 -9650 0 1 {name=p65850 lab=_71951_/Y }
C {sky130_stdcells/nor3_4.sym} 66100 -9650 0 0 {name=X_71951_ }
C {devices/lab_pin.sym} 66010 -9510 0 0 {name=p65851 lab=_84087_/CLK }
C {devices/lab_pin.sym} 66010 -9490 0 0 {name=p65852 lab=_69258_/X }
C {devices/lab_pin.sym} 66190 -9510 0 1 {name=p65853 lab=_83937_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -9500 0 0 {name=X_83937_ }
C {devices/lab_pin.sym} 66060 -9370 0 0 {name=p65854 lab=_59770_/A }
C {devices/lab_pin.sym} 66140 -9370 0 1 {name=p65855 lab=_60036_/A }
C {sky130_stdcells/buf_2.sym} 66100 -9370 0 0 {name=X_59673_ }
C {devices/lab_pin.sym} 66040 -9260 0 0 {name=p65856 lab=_56885_/A }
C {devices/lab_pin.sym} 66040 -9220 0 0 {name=p65857 lab=_56884_/Y }
C {devices/lab_pin.sym} 66160 -9240 0 1 {name=p65858 lab=_56886_/B }
C {sky130_stdcells/and2_4.sym} 66100 -9240 0 0 {name=X_56885_ }
C {devices/lab_pin.sym} 66020 -9130 0 0 {name=p65859 lab=_50998_/B }
C {devices/lab_pin.sym} 66020 -9090 0 0 {name=p65860 lab=_70885_/A }
C {devices/lab_pin.sym} 66020 -9050 0 0 {name=p65861 lab=_70901_/Y }
C {devices/lab_pin.sym} 66180 -9090 0 1 {name=p65862 lab=_70902_/Y }
C {sky130_stdcells/o21ai_4.sym} 66100 -9090 0 0 {name=X_70902_ }
C {devices/lab_pin.sym} 66060 -8950 0 0 {name=p65863 lab=_58857_/A }
C {devices/lab_pin.sym} 66140 -8950 0 1 {name=p65864 lab=_58624_/X }
C {sky130_stdcells/buf_2.sym} 66100 -8950 0 0 {name=X_58624_ }
C {devices/lab_pin.sym} 66020 -8860 0 0 {name=p65865 lab=_41199_/X }
C {devices/lab_pin.sym} 66020 -8820 0 0 {name=p65866 lab=_43842_/X }
C {devices/lab_pin.sym} 66020 -8780 0 0 {name=p65867 lab=_87235_/Q }
C {devices/lab_pin.sym} 66020 -8740 0 0 {name=p65868 lab=_43843_/X }
C {devices/lab_pin.sym} 66180 -8800 0 1 {name=p65869 lab=_43850_/X }
C {sky130_stdcells/a2bb2o_4.sym} 66100 -8800 0 0 {name=X_43850_ }
C {devices/lab_pin.sym} 66040 -8660 0 0 {name=p65870 lab=_55836_/A }
C {devices/lab_pin.sym} 66040 -8620 0 0 {name=p65871 lab=_55836_/B }
C {devices/lab_pin.sym} 66160 -8640 0 1 {name=p65872 lab=_55836_/X }
C {sky130_stdcells/and2_4.sym} 66100 -8640 0 0 {name=X_55836_ }
C {devices/lab_pin.sym} 66040 -8520 0 0 {name=p65873 lab=_74679_/A }
C {devices/lab_pin.sym} 66040 -8480 0 0 {name=p65874 lab=_45697_/A }
C {devices/lab_pin.sym} 66160 -8500 0 1 {name=p65875 lab=_74670_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -8500 0 0 {name=X_74670_ }
C {devices/lab_pin.sym} 66010 -8370 0 0 {name=p65876 lab=_85727_/CLK }
C {devices/lab_pin.sym} 66010 -8350 0 0 {name=p65877 lab=_47238_/Y }
C {devices/lab_pin.sym} 66190 -8370 0 1 {name=p65878 lab=_57722_/A }
C {sky130_stdcells/dfxtp_4.sym} 66100 -8360 0 0 {name=X_86656_ }
C {devices/lab_pin.sym} 66020 -8250 0 0 {name=p65879 lab=_71871_/X }
C {devices/lab_pin.sym} 66020 -8210 0 0 {name=p65880 lab=_83342_/Q }
C {devices/lab_pin.sym} 66020 -8170 0 0 {name=p65881 lab=_71881_/Y }
C {devices/lab_pin.sym} 66180 -8210 0 1 {name=p65882 lab=_71882_/X }
C {sky130_stdcells/a21o_4.sym} 66100 -8210 0 0 {name=X_71882_ }
C {devices/lab_pin.sym} 66010 -8070 0 0 {name=p65883 lab=_82541_/CLK }
C {devices/lab_pin.sym} 66010 -8050 0 0 {name=p65884 lab=_70032_/X }
C {devices/lab_pin.sym} 66190 -8070 0 1 {name=p65885 lab=_83868_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -8060 0 0 {name=X_83868_ }
C {devices/lab_pin.sym} 66020 -7960 0 0 {name=p65886 lab=_41393_/X }
C {devices/lab_pin.sym} 66020 -7920 0 0 {name=p65887 lab=_42787_/X }
C {devices/lab_pin.sym} 66020 -7880 0 0 {name=p65888 lab=_67808_/B }
C {devices/lab_pin.sym} 66020 -7840 0 0 {name=p65889 lab=_42788_/X }
C {devices/lab_pin.sym} 66180 -7900 0 1 {name=p65890 lab=_42801_/X }
C {sky130_stdcells/a2bb2o_4.sym} 66100 -7900 0 0 {name=X_42801_ }
C {devices/lab_pin.sym} 66040 -7770 0 0 {name=p65891 lab=_73619_/X }
C {devices/lab_pin.sym} 66040 -7730 0 0 {name=p65892 lab=_73601_/X }
C {devices/lab_pin.sym} 66040 -7690 0 0 {name=p65893 lab=_73604_/Y }
C {devices/lab_pin.sym} 66160 -7730 0 1 {name=p65894 lab=_73621_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -7730 0 0 {name=X_73621_ }
C {devices/lab_pin.sym} 66010 -7590 0 0 {name=p65895 lab=_86535_/CLK }
C {devices/lab_pin.sym} 66010 -7570 0 0 {name=p65896 lab=_85607_/D }
C {devices/lab_pin.sym} 66190 -7590 0 1 {name=p65897 lab=_85607_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -7580 0 0 {name=X_85607_ }
C {devices/lab_pin.sym} 66040 -7480 0 0 {name=p65898 lab=_70860_/A }
C {devices/lab_pin.sym} 66040 -7440 0 0 {name=p65899 lab=_70791_/B }
C {devices/lab_pin.sym} 66040 -7400 0 0 {name=p65900 lab=_71066_/C }
C {devices/lab_pin.sym} 66040 -7360 0 0 {name=p65901 lab=_70841_/D }
C {devices/lab_pin.sym} 66160 -7420 0 1 {name=p65902 lab=_70833_/Y }
C {sky130_stdcells/nand4_4.sym} 66100 -7420 0 0 {name=X_70833_ }
C {devices/lab_pin.sym} 66020 -7290 0 0 {name=p65903 lab=_58538_/X }
C {devices/lab_pin.sym} 66020 -7250 0 0 {name=p65904 lab=_83356_/Q }
C {devices/lab_pin.sym} 66020 -7210 0 0 {name=p65905 lab=_58554_/Y }
C {devices/lab_pin.sym} 66180 -7250 0 1 {name=p65906 lab=_58555_/X }
C {sky130_stdcells/o21a_4.sym} 66100 -7250 0 0 {name=X_58555_ }
C {devices/lab_pin.sym} 66010 -7110 0 0 {name=p65907 lab=_82786_/CLK }
C {devices/lab_pin.sym} 66010 -7090 0 0 {name=p65908 lab=_79523_/X }
C {devices/lab_pin.sym} 66190 -7110 0 1 {name=p65909 lab=_82787_/D }
C {sky130_stdcells/dfxtp_4.sym} 66100 -7100 0 0 {name=X_82819_ }
C {devices/lab_pin.sym} 66060 -6970 0 0 {name=p65910 lab=_43760_/A }
C {devices/lab_pin.sym} 66140 -6970 0 1 {name=p65911 lab=_43781_/X }
C {sky130_stdcells/buf_2.sym} 66100 -6970 0 0 {name=X_43781_ }
C {devices/lab_pin.sym} 66020 -6880 0 0 {name=p65912 lab=_85193_/Q }
C {devices/lab_pin.sym} 66020 -6840 0 0 {name=p65913 lab=_55152_/X }
C {devices/lab_pin.sym} 66020 -6800 0 0 {name=p65914 lab=_55168_/A }
C {devices/lab_pin.sym} 66020 -6760 0 0 {name=p65915 lab=_55766_/X }
C {devices/lab_pin.sym} 66180 -6820 0 1 {name=p65916 lab=_55767_/X }
C {sky130_stdcells/a211o_4.sym} 66100 -6820 0 0 {name=X_55767_ }
C {devices/lab_pin.sym} 66010 -6670 0 0 {name=p65917 lab=_86587_/CLK }
C {devices/lab_pin.sym} 66010 -6650 0 0 {name=p65918 lab=_86587_/D }
C {devices/lab_pin.sym} 66190 -6670 0 1 {name=p65919 lab=_73711_/B }
C {sky130_stdcells/dfxtp_4.sym} 66100 -6660 0 0 {name=X_86587_ }
C {devices/lab_pin.sym} 66020 -6550 0 0 {name=p65920 lab=_40991_/X }
C {devices/lab_pin.sym} 66020 -6510 0 0 {name=p65921 lab=_81718_/Q }
C {devices/lab_pin.sym} 66020 -6470 0 0 {name=p65922 lab=_40992_/X }
C {devices/lab_pin.sym} 66180 -6510 0 1 {name=p65923 lab=_40994_/A }
C {sky130_stdcells/o21a_4.sym} 66100 -6510 0 0 {name=X_40993_ }
C {devices/lab_pin.sym} 66040 -6380 0 0 {name=p65924 lab=_52979_/A }
C {devices/lab_pin.sym} 66040 -6340 0 0 {name=p65925 lab=_52979_/B }
C {devices/lab_pin.sym} 66160 -6360 0 1 {name=p65926 lab=_52979_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -6360 0 0 {name=X_52979_ }
C {devices/lab_pin.sym} 66010 -6230 0 0 {name=p65927 lab=_83842_/CLK }
C {devices/lab_pin.sym} 66010 -6210 0 0 {name=p65928 lab=_70319_/Y }
C {devices/lab_pin.sym} 66190 -6230 0 1 {name=p65929 lab=_70317_/A }
C {sky130_stdcells/dfxtp_4.sym} 66100 -6220 0 0 {name=X_83799_ }
C {devices/lab_pin.sym} 66060 -6090 0 0 {name=p65930 lab=_45395_/X }
C {devices/lab_pin.sym} 66140 -6090 0 1 {name=p65931 lab=_45520_/X }
C {sky130_stdcells/buf_2.sym} 66100 -6090 0 0 {name=X_45520_ }
C {devices/lab_pin.sym} 66060 -5970 0 0 {name=p65932 lab=_71978_/A }
C {devices/lab_pin.sym} 66140 -5970 0 1 {name=p65933 lab=_57506_/X }
C {sky130_stdcells/buf_2.sym} 66100 -5970 0 0 {name=X_57506_ }
C {devices/lab_pin.sym} 66020 -5870 0 0 {name=p65934 lab=_76302_/Y }
C {devices/lab_pin.sym} 66020 -5830 0 0 {name=p65935 lab=_76306_/A }
C {devices/lab_pin.sym} 66020 -5790 0 0 {name=p65936 lab=_76317_/B }
C {devices/lab_pin.sym} 66180 -5830 0 1 {name=p65937 lab=_76340_/X }
C {sky130_stdcells/a21o_4.sym} 66100 -5830 0 0 {name=X_76340_ }
C {devices/lab_pin.sym} 66010 -5690 0 0 {name=p65938 lab=_88326_/CLK }
C {devices/lab_pin.sym} 66010 -5670 0 0 {name=p65939 lab=_88326_/D }
C {devices/lab_pin.sym} 66190 -5690 0 1 {name=p65940 lab=_69740_/B }
C {sky130_stdcells/dfxtp_4.sym} 66100 -5680 0 0 {name=X_88326_ }
C {devices/lab_pin.sym} 66060 -5550 0 0 {name=p65941 lab=_42700_/A }
C {devices/lab_pin.sym} 66140 -5550 0 1 {name=p65942 lab=_42732_/X }
C {sky130_stdcells/buf_2.sym} 66100 -5550 0 0 {name=X_42732_ }
C {devices/lab_pin.sym} 66040 -5440 0 0 {name=p65943 lab=_54718_/A }
C {devices/lab_pin.sym} 66040 -5400 0 0 {name=p65944 lab=_47403_/A }
C {devices/lab_pin.sym} 66160 -5420 0 1 {name=p65945 lab=_54718_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -5420 0 0 {name=X_54718_ }
C {devices/lab_pin.sym} 66010 -5290 0 0 {name=p65946 lab=_85538_/CLK }
C {devices/lab_pin.sym} 66010 -5270 0 0 {name=p65947 lab=_85538_/D }
C {devices/lab_pin.sym} 66190 -5290 0 1 {name=p65948 lab=_85538_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -5280 0 0 {name=X_85538_ }
C {devices/lab_pin.sym} 66040 -5160 0 0 {name=p65949 lab=_73552_/A }
C {devices/lab_pin.sym} 66040 -5120 0 0 {name=p65950 lab=_73438_/B }
C {devices/lab_pin.sym} 66160 -5140 0 1 {name=p65951 lab=_73552_/Y }
C {sky130_stdcells/nor2_4.sym} 66100 -5140 0 0 {name=X_73552_ }
C {devices/lab_pin.sym} 66060 -5010 0 0 {name=p65952 lab=_70764_/A }
C {devices/lab_pin.sym} 66140 -5010 0 1 {name=p65953 lab=_70772_/A }
C {sky130_stdcells/buf_2.sym} 66100 -5010 0 0 {name=X_70764_ }
C {devices/lab_pin.sym} 66060 -4890 0 0 {name=p65954 lab=_84837_/Q }
C {devices/lab_pin.sym} 66140 -4890 0 1 {name=p65955 lab=_58487_/A }
C {sky130_stdcells/buf_2.sym} 66100 -4890 0 0 {name=X_58486_ }
C {devices/lab_pin.sym} 66040 -4780 0 0 {name=p65956 lab=_55698_/A }
C {devices/lab_pin.sym} 66040 -4740 0 0 {name=p65957 lab=_55990_/C }
C {devices/lab_pin.sym} 66160 -4760 0 1 {name=p65958 lab=_55698_/X }
C {sky130_stdcells/and2_4.sym} 66100 -4760 0 0 {name=X_55698_ }
C {devices/lab_pin.sym} 66060 -4630 0 0 {name=p65959 lab=clkbuf_9_501_0_CLK/A }
C {devices/lab_pin.sym} 66140 -4630 0 1 {name=p65960 lab=clkbuf_9_501_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 66100 -4630 0 0 {name=Xclkbuf_9_501_0_CLK }
C {devices/lab_pin.sym} 66040 -4520 0 0 {name=p65961 lab=_72503_/A }
C {devices/lab_pin.sym} 66040 -4480 0 0 {name=p65962 lab=_61302_/A }
C {devices/lab_pin.sym} 66160 -4500 0 1 {name=p65963 lab=_72516_/B }
C {sky130_stdcells/nor2_4.sym} 66100 -4500 0 0 {name=X_72503_ }
C {devices/lab_pin.sym} 66060 -4370 0 0 {name=p65964 lab=_63041_/B }
C {devices/lab_pin.sym} 66140 -4370 0 1 {name=p65965 lab=_61367_/A }
C {sky130_stdcells/buf_2.sym} 66100 -4370 0 0 {name=X_45451_ }
C {devices/lab_pin.sym} 66040 -4270 0 0 {name=p65966 lab=_56797_/A }
C {devices/lab_pin.sym} 66040 -4230 0 0 {name=p65967 lab=_57445_/B }
C {devices/lab_pin.sym} 66040 -4190 0 0 {name=p65968 lab=_56796_/Y }
C {devices/lab_pin.sym} 66160 -4230 0 1 {name=p65969 lab=_57437_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -4230 0 0 {name=X_57437_ }
C {devices/lab_pin.sym} 66020 -4110 0 0 {name=p65970 lab=_76241_/X }
C {devices/lab_pin.sym} 66020 -4070 0 0 {name=p65971 lab=_76269_/Y }
C {devices/lab_pin.sym} 66020 -4030 0 0 {name=p65972 lab=_76270_/X }
C {devices/lab_pin.sym} 66180 -4070 0 1 {name=p65973 lab=_76271_/X }
C {sky130_stdcells/o21a_4.sym} 66100 -4070 0 0 {name=X_76271_ }
C {devices/lab_pin.sym} 66010 -3930 0 0 {name=p65974 lab=_87083_/CLK }
C {devices/lab_pin.sym} 66010 -3910 0 0 {name=p65975 lab=_88257_/D }
C {devices/lab_pin.sym} 66190 -3930 0 1 {name=p65976 lab=_68820_/B }
C {sky130_stdcells/dfxtp_4.sym} 66100 -3920 0 0 {name=X_88257_ }
C {devices/lab_pin.sym} 66020 -3830 0 0 {name=p65977 lab=_42647_/X }
C {devices/lab_pin.sym} 66020 -3790 0 0 {name=p65978 lab=_42648_/X }
C {devices/lab_pin.sym} 66020 -3750 0 0 {name=p65979 lab=_41016_/X }
C {devices/lab_pin.sym} 66020 -3710 0 0 {name=p65980 lab=_87781_/Q }
C {devices/lab_pin.sym} 66020 -3670 0 0 {name=p65981 lab=_42658_/X }
C {devices/lab_pin.sym} 66180 -3750 0 1 {name=p65982 lab=_42663_/Y }
C {sky130_stdcells/o32ai_4.sym} 66100 -3750 0 0 {name=X_42663_ }
C {devices/lab_pin.sym} 66060 -3590 0 0 {name=p65983 lab=_54594_/X }
C {devices/lab_pin.sym} 66140 -3590 0 1 {name=p65984 lab=_54649_/X }
C {sky130_stdcells/buf_2.sym} 66100 -3590 0 0 {name=X_54649_ }
C {devices/lab_pin.sym} 66020 -3490 0 0 {name=p65985 lab=_83149_/Q }
C {devices/lab_pin.sym} 66020 -3450 0 0 {name=p65986 lab=_73437_/X }
C {devices/lab_pin.sym} 66020 -3410 0 0 {name=p65987 lab=_73482_/Y }
C {devices/lab_pin.sym} 66180 -3450 0 1 {name=p65988 lab=_73483_/X }
C {sky130_stdcells/a21o_4.sym} 66100 -3450 0 0 {name=X_73483_ }
C {devices/lab_pin.sym} 66010 -3310 0 0 {name=p65989 lab=_82206_/CLK }
C {devices/lab_pin.sym} 66010 -3290 0 0 {name=p65990 lab=_54293_/Y }
C {devices/lab_pin.sym} 66190 -3310 0 1 {name=p65991 lab=_85469_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -3300 0 0 {name=X_85469_ }
C {devices/lab_pin.sym} 66060 -3170 0 0 {name=p65992 lab=_70695_/A }
C {devices/lab_pin.sym} 66140 -3170 0 1 {name=p65993 lab=_70698_/A }
C {sky130_stdcells/buf_2.sym} 66100 -3170 0 0 {name=X_70695_ }
C {devices/lab_pin.sym} 66040 -3060 0 0 {name=p65994 lab=_78010_/A }
C {devices/lab_pin.sym} 66040 -3020 0 0 {name=p65995 lab=_77998_/A }
C {devices/lab_pin.sym} 66160 -3040 0 1 {name=p65996 lab=_78011_/A }
C {sky130_stdcells/and2_4.sym} 66100 -3040 0 0 {name=X_78010_ }
C {devices/lab_pin.sym} 66020 -2940 0 0 {name=p65997 lab=_41507_/X }
C {devices/lab_pin.sym} 66020 -2900 0 0 {name=p65998 lab=_44394_/X }
C {devices/lab_pin.sym} 66020 -2860 0 0 {name=p65999 lab=_87126_/Q }
C {devices/lab_pin.sym} 66020 -2820 0 0 {name=p66000 lab=_44395_/X }
C {devices/lab_pin.sym} 66180 -2880 0 1 {name=p66001 lab=_44402_/X }
C {sky130_stdcells/a2bb2o_4.sym} 66100 -2880 0 0 {name=X_44402_ }
C {devices/lab_pin.sym} 66040 -2740 0 0 {name=p66002 lab=_80684_/Q }
C {devices/lab_pin.sym} 66040 -2700 0 0 {name=p66003 lab=_80984_/Q }
C {devices/lab_pin.sym} 66160 -2720 0 1 {name=p66004 lab=_75222_/Y }
C {sky130_stdcells/nand2_4.sym} 66100 -2720 0 0 {name=X_75222_ }
C {devices/lab_pin.sym} 66010 -2590 0 0 {name=p66005 lab=_87720_/CLK }
C {devices/lab_pin.sym} 66010 -2570 0 0 {name=p66006 lab=_87208_/D }
C {devices/lab_pin.sym} 66190 -2590 0 1 {name=p66007 lab=_67596_/B }
C {sky130_stdcells/dfxtp_4.sym} 66100 -2580 0 0 {name=X_87208_ }
C {devices/lab_pin.sym} 66040 -2460 0 0 {name=p66008 lab=_40536_/B }
C {devices/lab_pin.sym} 66040 -2420 0 0 {name=p66009 lab=_41563_/B }
C {devices/lab_pin.sym} 66160 -2440 0 1 {name=p66010 lab=_41614_/X }
C {sky130_stdcells/or2_4.sym} 66100 -2440 0 0 {name=X_41614_ }
C {devices/lab_pin.sym} 66060 -2310 0 0 {name=p66011 lab=_48169_/X }
C {devices/lab_pin.sym} 66140 -2310 0 1 {name=p66012 lab=_48170_/X }
C {sky130_stdcells/buf_2.sym} 66100 -2310 0 0 {name=X_48170_ }
C {devices/lab_pin.sym} 66020 -2210 0 0 {name=p66013 lab=_72431_/Y }
C {devices/lab_pin.sym} 66020 -2170 0 0 {name=p66014 lab=_72433_/Y }
C {devices/lab_pin.sym} 66020 -2130 0 0 {name=p66015 lab=_57779_/X }
C {devices/lab_pin.sym} 66180 -2170 0 1 {name=p66016 lab=_72434_/X }
C {sky130_stdcells/a21o_4.sym} 66100 -2170 0 0 {name=X_72434_ }
C {devices/lab_pin.sym} 66020 -2050 0 0 {name=p66017 lab=_45379_/X }
C {devices/lab_pin.sym} 66020 -2010 0 0 {name=p66018 lab=_45381_/Y }
C {devices/lab_pin.sym} 66020 -1970 0 0 {name=p66019 lab=_45348_/X }
C {devices/lab_pin.sym} 66180 -2010 0 1 {name=p66020 lab=_45382_/Y }
C {sky130_stdcells/a21oi_4.sym} 66100 -2010 0 0 {name=X_45382_ }
C {devices/lab_pin.sym} 66060 -1870 0 0 {name=p66021 lab=_57368_/A }
C {devices/lab_pin.sym} 66140 -1870 0 1 {name=p66022 lab=_85027_/D }
C {sky130_stdcells/inv_2.sym} 66100 -1870 0 0 {name=X_57368_ }
C {devices/lab_pin.sym} 66010 -1750 0 0 {name=p66023 lab=_87110_/CLK }
C {devices/lab_pin.sym} 66010 -1730 0 0 {name=p66024 lab=_88188_/D }
C {devices/lab_pin.sym} 66190 -1750 0 1 {name=p66025 lab=_67128_/B }
C {sky130_stdcells/dfxtp_4.sym} 66100 -1740 0 0 {name=X_88188_ }
C {devices/lab_pin.sym} 66060 -1610 0 0 {name=p66026 lab=_42593_/Y }
C {devices/lab_pin.sym} 66140 -1610 0 1 {name=p66027 lab=_87809_/D }
C {sky130_stdcells/inv_2.sym} 66100 -1610 0 0 {name=X_42594_ }
C {devices/lab_pin.sym} 66040 -1520 0 0 {name=p66028 lab=_47113_/A }
C {devices/lab_pin.sym} 66040 -1480 0 0 {name=p66029 lab=_47082_/X }
C {devices/lab_pin.sym} 66040 -1440 0 0 {name=p66030 lab=_47091_/X }
C {devices/lab_pin.sym} 66040 -1400 0 0 {name=p66031 lab=_52867_/D }
C {devices/lab_pin.sym} 66160 -1460 0 1 {name=p66032 lab=_47121_/X }
C {sky130_stdcells/and4_4.sym} 66100 -1460 0 0 {name=X_47121_ }
C {devices/lab_pin.sym} 66020 -1330 0 0 {name=p66033 lab=_59105_/X }
C {devices/lab_pin.sym} 66020 -1290 0 0 {name=p66034 lab=_85752_/Q }
C {devices/lab_pin.sym} 66020 -1250 0 0 {name=p66035 lab=_59106_/X }
C {devices/lab_pin.sym} 66180 -1290 0 1 {name=p66036 lab=_59107_/X }
C {sky130_stdcells/o21a_4.sym} 66100 -1290 0 0 {name=X_59107_ }
C {devices/lab_pin.sym} 66020 -1190 0 0 {name=p66037 lab=_44330_/X }
C {devices/lab_pin.sym} 66020 -1150 0 0 {name=p66038 lab=_44331_/X }
C {devices/lab_pin.sym} 66020 -1110 0 0 {name=p66039 lab=_41656_/X }
C {devices/lab_pin.sym} 66020 -1070 0 0 {name=p66040 lab=_87162_/Q }
C {devices/lab_pin.sym} 66020 -1030 0 0 {name=p66041 lab=_44332_/X }
C {devices/lab_pin.sym} 66180 -1110 0 1 {name=p66042 lab=_44333_/Y }
C {sky130_stdcells/o32ai_4.sym} 66100 -1110 0 0 {name=X_44333_ }
C {devices/lab_pin.sym} 66040 -970 0 0 {name=p66043 lab=_56309_/A }
C {devices/lab_pin.sym} 66040 -930 0 0 {name=p66044 lab=_56312_/X }
C {devices/lab_pin.sym} 66040 -890 0 0 {name=p66045 lab=_55874_/B }
C {devices/lab_pin.sym} 66160 -930 0 1 {name=p66046 lab=_56319_/Y }
C {sky130_stdcells/nand3_4.sym} 66100 -930 0 0 {name=X_56319_ }
C {devices/lab_pin.sym} 66010 -790 0 0 {name=p66047 lab=_88215_/CLK }
C {devices/lab_pin.sym} 66010 -770 0 0 {name=p66048 lab=_87139_/D }
C {devices/lab_pin.sym} 66190 -790 0 1 {name=p66049 lab=_87139_/Q }
C {sky130_stdcells/dfxtp_4.sym} 66100 -780 0 0 {name=X_87139_ }
C {devices/lab_pin.sym} 66980 -42150 0 0 {name=p66050 lab=_75153_/A }
C {devices/lab_pin.sym} 67060 -42150 0 1 {name=p66051 lab=_75153_/Y }
C {sky130_stdcells/inv_2.sym} 67020 -42150 0 0 {name=X_75153_ }
C {devices/lab_pin.sym} 66980 -42030 0 0 {name=p66052 lab=_41544_/X }
C {devices/lab_pin.sym} 67060 -42030 0 1 {name=p66053 lab=_41545_/X }
C {sky130_stdcells/buf_2.sym} 67020 -42030 0 0 {name=X_41545_ }
C {devices/lab_pin.sym} 66940 -41930 0 0 {name=p66054 lab=_72360_/Y }
C {devices/lab_pin.sym} 66940 -41890 0 0 {name=p66055 lab=_72364_/Y }
C {devices/lab_pin.sym} 66940 -41850 0 0 {name=p66056 lab=_72292_/X }
C {devices/lab_pin.sym} 67100 -41890 0 1 {name=p66057 lab=_72365_/X }
C {sky130_stdcells/a21o_4.sym} 67020 -41890 0 0 {name=X_72365_ }
C {devices/lab_pin.sym} 66960 -41770 0 0 {name=p66058 lab=_57427_/A }
C {devices/lab_pin.sym} 66960 -41730 0 0 {name=p66059 lab=_57340_/C }
C {devices/lab_pin.sym} 66960 -41690 0 0 {name=p66060 lab=_56750_/Y }
C {devices/lab_pin.sym} 67080 -41730 0 1 {name=p66061 lab=_57299_/Y }
C {sky130_stdcells/nand3_4.sym} 67020 -41730 0 0 {name=X_57299_ }
C {devices/lab_pin.sym} 66960 -41600 0 0 {name=p66062 lab=_73583_/A }
C {devices/lab_pin.sym} 66960 -41560 0 0 {name=p66063 lab=_74104_/B }
C {devices/lab_pin.sym} 67080 -41580 0 1 {name=p66064 lab=_74104_/X }
C {sky130_stdcells/and2_4.sym} 67020 -41580 0 0 {name=X_74104_ }
C {devices/lab_pin.sym} 66980 -41450 0 0 {name=p66065 lab=_47052_/A }
C {devices/lab_pin.sym} 67060 -41450 0 1 {name=p66066 lab=_47053_/A }
C {sky130_stdcells/inv_2.sym} 67020 -41450 0 0 {name=X_47052_ }
C {devices/lab_pin.sym} 66940 -41350 0 0 {name=p66067 lab=_59013_/X }
C {devices/lab_pin.sym} 66940 -41310 0 0 {name=p66068 lab=_85758_/Q }
C {devices/lab_pin.sym} 66940 -41270 0 0 {name=p66069 lab=_59037_/X }
C {devices/lab_pin.sym} 67100 -41310 0 1 {name=p66070 lab=_59038_/X }
C {sky130_stdcells/o21a_4.sym} 67020 -41310 0 0 {name=X_59038_ }
C {devices/lab_pin.sym} 66960 -41190 0 0 {name=p66071 lab=_71500_/A }
C {devices/lab_pin.sym} 66960 -41150 0 0 {name=p66072 lab=_71314_/B }
C {devices/lab_pin.sym} 66960 -41110 0 0 {name=p66073 lab=_71779_/B }
C {devices/lab_pin.sym} 67080 -41150 0 1 {name=p66074 lab=_71316_/Y }
C {sky130_stdcells/nand3_4.sym} 67020 -41150 0 0 {name=X_71316_ }
C {devices/lab_pin.sym} 66980 -41010 0 0 {name=p66075 lab=_44263_/X }
C {devices/lab_pin.sym} 67060 -41010 0 1 {name=p66076 lab=_57837_/A }
C {sky130_stdcells/buf_2.sym} 67020 -41010 0 0 {name=X_44264_ }
C {devices/lab_pin.sym} 66960 -40900 0 0 {name=p66077 lab=_79961_/A }
C {devices/lab_pin.sym} 66960 -40860 0 0 {name=p66078 lab=_79960_/Y }
C {devices/lab_pin.sym} 67080 -40880 0 1 {name=p66079 lab=_79964_/A }
C {sky130_stdcells/nand2_4.sym} 67020 -40880 0 0 {name=X_79961_ }
C {devices/lab_pin.sym} 66940 -40770 0 0 {name=p66080 lab=_75082_/X }
C {devices/lab_pin.sym} 66940 -40730 0 0 {name=p66081 lab=_75102_/B }
C {devices/lab_pin.sym} 66940 -40690 0 0 {name=p66082 lab=_75085_/B }
C {devices/lab_pin.sym} 67100 -40730 0 1 {name=p66083 lab=_75091_/A }
C {sky130_stdcells/a21o_4.sym} 67020 -40730 0 0 {name=X_75084_ }
C {devices/lab_pin.sym} 66980 -40590 0 0 {name=p66084 lab=_41476_/A }
C {devices/lab_pin.sym} 67060 -40590 0 1 {name=p66085 lab=_88208_/D }
C {sky130_stdcells/inv_2.sym} 67020 -40590 0 0 {name=X_41476_ }
C {devices/lab_pin.sym} 66980 -40470 0 0 {name=p66086 lab=_72296_/A }
C {devices/lab_pin.sym} 67060 -40470 0 1 {name=p66087 lab=_72296_/X }
C {sky130_stdcells/buf_2.sym} 67020 -40470 0 0 {name=X_72296_ }
C {devices/lab_pin.sym} 66980 -40350 0 0 {name=p66088 lab=_46002_/Y }
C {devices/lab_pin.sym} 67060 -40350 0 1 {name=p66089 lab=_86820_/D }
C {sky130_stdcells/inv_2.sym} 67020 -40350 0 0 {name=X_46003_ }
C {devices/lab_pin.sym} 66940 -40260 0 0 {name=p66090 lab=_40964_/X }
C {devices/lab_pin.sym} 66940 -40220 0 0 {name=p66091 lab=_43180_/X }
C {devices/lab_pin.sym} 66940 -40180 0 0 {name=p66092 lab=_87534_/Q }
C {devices/lab_pin.sym} 66940 -40140 0 0 {name=p66093 lab=_43185_/X }
C {devices/lab_pin.sym} 67100 -40200 0 1 {name=p66094 lab=_87534_/D }
C {sky130_stdcells/a2bb2o_4.sym} 67020 -40200 0 0 {name=X_43215_ }
C {devices/lab_pin.sym} 66940 -40070 0 0 {name=p66095 lab=_74032_/X }
C {devices/lab_pin.sym} 66940 -40030 0 0 {name=p66096 lab=_74034_/X }
C {devices/lab_pin.sym} 66940 -39990 0 0 {name=p66097 lab=_73944_/X }
C {devices/lab_pin.sym} 67100 -40030 0 1 {name=p66098 lab=_74048_/B }
C {sky130_stdcells/a21o_4.sym} 67020 -40030 0 0 {name=X_74035_ }
C {devices/lab_pin.sym} 66960 -39900 0 0 {name=p66099 lab=_78912_/A }
C {devices/lab_pin.sym} 66960 -39860 0 0 {name=p66100 lab=_78912_/B }
C {devices/lab_pin.sym} 67080 -39880 0 1 {name=p66101 lab=_78919_/A }
C {sky130_stdcells/xor2_4.sym} 67020 -39880 0 0 {name=X_78912_ }
C {devices/lab_pin.sym} 66940 -39790 0 0 {name=p66102 lab=_57491_/A }
C {devices/lab_pin.sym} 66940 -39750 0 0 {name=p66103 lab=_40364_/X }
C {devices/lab_pin.sym} 66940 -39710 0 0 {name=p66104 lab=_40426_/X }
C {devices/lab_pin.sym} 66940 -39670 0 0 {name=p66105 lab=_88393_/Q }
C {devices/lab_pin.sym} 66940 -39630 0 0 {name=p66106 lab=_40375_/X }
C {devices/lab_pin.sym} 67100 -39710 0 1 {name=p66107 lab=_40428_/A }
C {sky130_stdcells/o32ai_4.sym} 67020 -39710 0 0 {name=X_40427_ }
C {devices/lab_pin.sym} 66940 -39570 0 0 {name=p66108 lab=_50224_/B }
C {devices/lab_pin.sym} 66940 -39530 0 0 {name=p66109 lab=_71239_/X }
C {devices/lab_pin.sym} 66940 -39490 0 0 {name=p66110 lab=_71246_/Y }
C {devices/lab_pin.sym} 67100 -39530 0 1 {name=p66111 lab=_71247_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -39530 0 0 {name=X_71247_ }
C {devices/lab_pin.sym} 66980 -39390 0 0 {name=p66112 lab=clkbuf_6_0_0_CLK/X }
C {devices/lab_pin.sym} 67060 -39390 0 1 {name=p66113 lab=clkbuf_8_3_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 67020 -39390 0 0 {name=Xclkbuf_7_1_0_CLK }
C {devices/lab_pin.sym} 66960 -39280 0 0 {name=p66114 lab=_72739_/A }
C {devices/lab_pin.sym} 66960 -39240 0 0 {name=p66115 lab=_44194_/X }
C {devices/lab_pin.sym} 67080 -39260 0 1 {name=p66116 lab=_44195_/Y }
C {sky130_stdcells/nor2_4.sym} 67020 -39260 0 0 {name=X_44195_ }
C {devices/lab_pin.sym} 66960 -39140 0 0 {name=p66117 lab=_79890_/Y }
C {devices/lab_pin.sym} 66960 -39100 0 0 {name=p66118 lab=_79891_/Y }
C {devices/lab_pin.sym} 67080 -39120 0 1 {name=p66119 lab=_79892_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -39120 0 0 {name=X_79892_ }
C {devices/lab_pin.sym} 66980 -38990 0 0 {name=p66120 lab=_60422_/A }
C {devices/lab_pin.sym} 67060 -38990 0 1 {name=p66121 lab=_61000_/X }
C {sky130_stdcells/buf_2.sym} 67020 -38990 0 0 {name=X_61000_ }
C {devices/lab_pin.sym} 66980 -38870 0 0 {name=p66122 lab=_43146_/A }
C {devices/lab_pin.sym} 67060 -38870 0 1 {name=p66123 lab=_43146_/X }
C {sky130_stdcells/buf_2.sym} 67020 -38870 0 0 {name=X_43146_ }
C {devices/lab_pin.sym} 66940 -38770 0 0 {name=p66124 lab=_78837_/B }
C {devices/lab_pin.sym} 66940 -38730 0 0 {name=p66125 lab=_78841_/Y }
C {devices/lab_pin.sym} 66940 -38690 0 0 {name=p66126 lab=_78842_/Y }
C {devices/lab_pin.sym} 67100 -38730 0 1 {name=p66127 lab=_78854_/B }
C {sky130_stdcells/a21oi_4.sym} 67020 -38730 0 0 {name=X_78843_ }
C {devices/lab_pin.sym} 66980 -38590 0 0 {name=p66128 lab=_40435_/A }
C {devices/lab_pin.sym} 67060 -38590 0 1 {name=p66129 lab=_44587_/A }
C {sky130_stdcells/buf_2.sym} 67020 -38590 0 0 {name=X_40358_ }
C {devices/lab_pin.sym} 66960 -38500 0 0 {name=p66130 lab=_71178_/A }
C {devices/lab_pin.sym} 66960 -38460 0 0 {name=p66131 lab=_71185_/B }
C {devices/lab_pin.sym} 66960 -38420 0 0 {name=p66132 lab=_71181_/C }
C {devices/lab_pin.sym} 66960 -38380 0 0 {name=p66133 lab=_71178_/D }
C {devices/lab_pin.sym} 67080 -38440 0 1 {name=p66134 lab=_71178_/Y }
C {sky130_stdcells/nand4_4.sym} 67020 -38440 0 0 {name=X_71178_ }
C {devices/lab_pin.sym} 66960 -38300 0 0 {name=p66135 lab=_70129_/A }
C {devices/lab_pin.sym} 66960 -38260 0 0 {name=p66136 lab=_70129_/B }
C {devices/lab_pin.sym} 67080 -38280 0 1 {name=p66137 lab=_70131_/B }
C {sky130_stdcells/nor2_4.sym} 67020 -38280 0 0 {name=X_70129_ }
C {devices/lab_pin.sym} 66980 -38150 0 0 {name=p66138 lab=_47846_/A }
C {devices/lab_pin.sym} 67060 -38150 0 1 {name=p66139 lab=_47954_/X }
C {sky130_stdcells/buf_2.sym} 67020 -38150 0 0 {name=X_47954_ }
C {devices/lab_pin.sym} 66980 -38030 0 0 {name=p66140 lab=_43076_/Y }
C {devices/lab_pin.sym} 67060 -38030 0 1 {name=p66141 lab=_87585_/D }
C {sky130_stdcells/inv_2.sym} 67020 -38030 0 0 {name=X_43077_ }
C {devices/lab_pin.sym} 66940 -37930 0 0 {name=p66142 lab=_78749_/Y }
C {devices/lab_pin.sym} 66940 -37890 0 0 {name=p66143 lab=_78753_/B }
C {devices/lab_pin.sym} 66940 -37850 0 0 {name=p66144 lab=_78752_/A }
C {devices/lab_pin.sym} 67100 -37890 0 1 {name=p66145 lab=_78778_/A }
C {sky130_stdcells/o21a_4.sym} 67020 -37890 0 0 {name=X_78774_ }
C {devices/lab_pin.sym} 66960 -37760 0 0 {name=p66146 lab=_75986_/A }
C {devices/lab_pin.sym} 66960 -37720 0 0 {name=p66147 lab=_75986_/B }
C {devices/lab_pin.sym} 67080 -37740 0 1 {name=p66148 lab=_81739_/D }
C {sky130_stdcells/xnor2_4.sym} 67020 -37740 0 0 {name=X_75986_ }
C {devices/lab_pin.sym} 66980 -37610 0 0 {name=p66149 lab=clkbuf_8_85_0_CLK/A }
C {devices/lab_pin.sym} 67060 -37610 0 1 {name=p66150 lab=clkbuf_8_84_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 67020 -37610 0 0 {name=Xclkbuf_8_84_0_CLK }
C {devices/lab_pin.sym} 66980 -37490 0 0 {name=p66151 lab=_54435_/D }
C {devices/lab_pin.sym} 67060 -37490 0 1 {name=p66152 lab=_52742_/D }
C {sky130_stdcells/buf_2.sym} 67020 -37490 0 0 {name=X_46905_ }
C {devices/lab_pin.sym} 66980 -37370 0 0 {name=p66153 lab=_42013_/A }
C {devices/lab_pin.sym} 67060 -37370 0 1 {name=p66154 lab=_42028_/X }
C {sky130_stdcells/buf_2.sym} 67020 -37370 0 0 {name=X_42028_ }
C {devices/lab_pin.sym} 66980 -37250 0 0 {name=p66155 lab=_82050_/Q }
C {devices/lab_pin.sym} 67060 -37250 0 1 {name=p66156 lab=_77725_/Y }
C {sky130_stdcells/inv_2.sym} 67020 -37250 0 0 {name=X_77725_ }
C {devices/lab_pin.sym} 66980 -37130 0 0 {name=p66157 lab=_62791_/X }
C {devices/lab_pin.sym} 67060 -37130 0 1 {name=p66158 lab=_62988_/A }
C {sky130_stdcells/buf_2.sym} 67020 -37130 0 0 {name=X_62951_ }
C {devices/lab_pin.sym} 66960 -37020 0 0 {name=p66159 lab=_81134_/D }
C {devices/lab_pin.sym} 66960 -36980 0 0 {name=p66160 lab=_74928_/B }
C {devices/lab_pin.sym} 67080 -37000 0 1 {name=p66161 lab=_74937_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -37000 0 0 {name=X_74937_ }
C {devices/lab_pin.sym} 66940 -36890 0 0 {name=p66162 lab=_40877_/X }
C {devices/lab_pin.sym} 66940 -36850 0 0 {name=p66163 lab=_82365_/Q }
C {devices/lab_pin.sym} 66940 -36810 0 0 {name=p66164 lab=_47884_/X }
C {devices/lab_pin.sym} 67100 -36850 0 1 {name=p66165 lab=_47886_/A }
C {sky130_stdcells/o21ai_4.sym} 67020 -36850 0 0 {name=X_47885_ }
C {devices/lab_pin.sym} 66980 -36710 0 0 {name=p66166 lab=_49571_/A }
C {devices/lab_pin.sym} 67060 -36710 0 1 {name=p66167 lab=_49625_/A }
C {sky130_stdcells/buf_2.sym} 67020 -36710 0 0 {name=X_49624_ }
C {devices/lab_pin.sym} 66980 -36590 0 0 {name=p66168 lab=_59668_/B }
C {devices/lab_pin.sym} 67060 -36590 0 1 {name=p66169 lab=_61902_/X }
C {sky130_stdcells/buf_2.sym} 67020 -36590 0 0 {name=X_61902_ }
C {devices/lab_pin.sym} 66980 -36470 0 0 {name=p66170 lab=_82954_/Q }
C {devices/lab_pin.sym} 67060 -36470 0 1 {name=p66171 lab=_54395_/D }
C {sky130_stdcells/inv_2.sym} 67020 -36470 0 0 {name=X_46836_ }
C {devices/lab_pin.sym} 66960 -36360 0 0 {name=p66172 lab=_65704_/A }
C {devices/lab_pin.sym} 66960 -36320 0 0 {name=p66173 lab=_86481_/Q }
C {devices/lab_pin.sym} 67080 -36340 0 1 {name=p66174 lab=_65670_/X }
C {sky130_stdcells/and2_4.sym} 67020 -36340 0 0 {name=X_65670_ }
C {devices/lab_pin.sym} 66940 -36230 0 0 {name=p66175 lab=_77652_/Y }
C {devices/lab_pin.sym} 66940 -36190 0 0 {name=p66176 lab=_77654_/Y }
C {devices/lab_pin.sym} 66940 -36150 0 0 {name=p66177 lab=_77655_/A }
C {devices/lab_pin.sym} 67100 -36190 0 1 {name=p66178 lab=_77656_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -36190 0 0 {name=X_77656_ }
C {devices/lab_pin.sym} 66960 -36070 0 0 {name=p66179 lab=_62894_/A }
C {devices/lab_pin.sym} 66960 -36030 0 0 {name=p66180 lab=_62852_/X }
C {devices/lab_pin.sym} 66960 -35990 0 0 {name=p66181 lab=_84374_/Q }
C {devices/lab_pin.sym} 67080 -36030 0 1 {name=p66182 lab=_62882_/Y }
C {sky130_stdcells/nor3_4.sym} 67020 -36030 0 0 {name=X_62882_ }
C {devices/lab_pin.sym} 66960 -35900 0 0 {name=p66183 lab=_80933_/Q }
C {devices/lab_pin.sym} 66960 -35860 0 0 {name=p66184 lab=_74868_/B }
C {devices/lab_pin.sym} 67080 -35880 0 1 {name=p66185 lab=_74868_/X }
C {sky130_stdcells/xor2_4.sym} 67020 -35880 0 0 {name=X_74868_ }
C {devices/lab_pin.sym} 66960 -35760 0 0 {name=p66186 lab=_64621_/A }
C {devices/lab_pin.sym} 66960 -35720 0 0 {name=p66187 lab=_86432_/Q }
C {devices/lab_pin.sym} 67080 -35740 0 1 {name=p66188 lab=_64621_/X }
C {sky130_stdcells/and2_4.sym} 67020 -35740 0 0 {name=X_64621_ }
C {devices/lab_pin.sym} 66980 -35610 0 0 {name=p66189 lab=_76605_/X }
C {devices/lab_pin.sym} 67060 -35610 0 1 {name=p66190 lab=_76608_/A }
C {sky130_stdcells/inv_2.sym} 67020 -35610 0 0 {name=X_76607_ }
C {devices/lab_pin.sym} 66960 -35520 0 0 {name=p66191 lab=_61863_/A }
C {devices/lab_pin.sym} 66960 -35480 0 0 {name=p66192 lab=_61829_/Y }
C {devices/lab_pin.sym} 66960 -35440 0 0 {name=p66193 lab=_61830_/Y }
C {devices/lab_pin.sym} 66960 -35400 0 0 {name=p66194 lab=_61832_/Y }
C {devices/lab_pin.sym} 67080 -35460 0 1 {name=p66195 lab=_61833_/Y }
C {sky130_stdcells/nand4_4.sym} 67020 -35460 0 0 {name=X_61833_ }
C {devices/lab_pin.sym} 66940 -35330 0 0 {name=p66196 lab=_86366_/Q }
C {devices/lab_pin.sym} 66940 -35290 0 0 {name=p66197 lab=_49551_/X }
C {devices/lab_pin.sym} 66940 -35250 0 0 {name=p66198 lab=_49554_/Y }
C {devices/lab_pin.sym} 67100 -35290 0 1 {name=p66199 lab=_49555_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -35290 0 0 {name=X_49555_ }
C {devices/lab_pin.sym} 66980 -35150 0 0 {name=p66200 lab=_73343_/X }
C {devices/lab_pin.sym} 67060 -35150 0 1 {name=p66201 lab=_73819_/X }
C {sky130_stdcells/buf_2.sym} 67020 -35150 0 0 {name=X_73819_ }
C {devices/lab_pin.sym} 66980 -35030 0 0 {name=p66202 lab=_46767_/A }
C {devices/lab_pin.sym} 67060 -35030 0 1 {name=p66203 lab=_46767_/X }
C {sky130_stdcells/buf_2.sym} 67020 -35030 0 0 {name=X_46767_ }
C {devices/lab_pin.sym} 66980 -34910 0 0 {name=p66204 lab=clkbuf_8_99_0_CLK/A }
C {devices/lab_pin.sym} 67060 -34910 0 1 {name=p66205 lab=clkbuf_8_99_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 67020 -34910 0 0 {name=Xclkbuf_8_99_0_CLK }
C {devices/lab_pin.sym} 66980 -34790 0 0 {name=p66206 lab=_77586_/X }
C {devices/lab_pin.sym} 67060 -34790 0 1 {name=p66207 lab=_77587_/Y }
C {sky130_stdcells/inv_2.sym} 67020 -34790 0 0 {name=X_77587_ }
C {devices/lab_pin.sym} 66960 -34680 0 0 {name=p66208 lab=_43979_/A }
C {devices/lab_pin.sym} 66960 -34640 0 0 {name=p66209 lab=_43978_/Y }
C {devices/lab_pin.sym} 67080 -34660 0 1 {name=p66210 lab=_43979_/Y }
C {sky130_stdcells/nor2_4.sym} 67020 -34660 0 0 {name=X_43979_ }
C {devices/lab_pin.sym} 66960 -34560 0 0 {name=p66211 lab=_74716_/A }
C {devices/lab_pin.sym} 66960 -34520 0 0 {name=p66212 lab=_70637_/A }
C {devices/lab_pin.sym} 66960 -34480 0 0 {name=p66213 lab=_74799_/C }
C {devices/lab_pin.sym} 66960 -34440 0 0 {name=p66214 lab=_74739_/B }
C {devices/lab_pin.sym} 67080 -34500 0 1 {name=p66215 lab=_74799_/X }
C {sky130_stdcells/and4_4.sym} 67020 -34500 0 0 {name=X_74799_ }
C {devices/lab_pin.sym} 66940 -34370 0 0 {name=p66216 lab=_86516_/Q }
C {devices/lab_pin.sym} 66940 -34330 0 0 {name=p66217 lab=_48478_/X }
C {devices/lab_pin.sym} 66940 -34290 0 0 {name=p66218 lab=_48505_/Y }
C {devices/lab_pin.sym} 67100 -34330 0 1 {name=p66219 lab=_48506_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -34330 0 0 {name=X_48506_ }
C {devices/lab_pin.sym} 66960 -34200 0 0 {name=p66220 lab=_67340_/A }
C {devices/lab_pin.sym} 66960 -34160 0 0 {name=p66221 lab=_67339_/X }
C {devices/lab_pin.sym} 67080 -34180 0 1 {name=p66222 lab=_67340_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -34180 0 0 {name=X_67340_ }
C {devices/lab_pin.sym} 66960 -34060 0 0 {name=p66223 lab=_79334_/A }
C {devices/lab_pin.sym} 66960 -34020 0 0 {name=p66224 lab=_79325_/Y }
C {devices/lab_pin.sym} 67080 -34040 0 1 {name=p66225 lab=_82831_/D }
C {sky130_stdcells/xnor2_4.sym} 67020 -34040 0 0 {name=X_79326_ }
C {devices/lab_pin.sym} 66940 -33930 0 0 {name=p66226 lab=_45708_/X }
C {devices/lab_pin.sym} 66940 -33890 0 0 {name=p66227 lab=_45715_/Y }
C {devices/lab_pin.sym} 66940 -33850 0 0 {name=p66228 lab=_45717_/Y }
C {devices/lab_pin.sym} 67100 -33890 0 1 {name=p66229 lab=_45718_/Y }
C {sky130_stdcells/a21oi_4.sym} 67020 -33890 0 0 {name=X_45718_ }
C {devices/lab_pin.sym} 66960 -33760 0 0 {name=p66230 lab=_63713_/A }
C {devices/lab_pin.sym} 66960 -33720 0 0 {name=p66231 lab=_61226_/X }
C {devices/lab_pin.sym} 67080 -33740 0 1 {name=p66232 lab=_64552_/Y }
C {sky130_stdcells/nor2_4.sym} 67020 -33740 0 0 {name=X_64552_ }
C {devices/lab_pin.sym} 66980 -33610 0 0 {name=p66233 lab=_76537_/X }
C {devices/lab_pin.sym} 67060 -33610 0 1 {name=p66234 lab=_76540_/B }
C {sky130_stdcells/inv_2.sym} 67020 -33610 0 0 {name=X_76538_ }
C {devices/lab_pin.sym} 66940 -33510 0 0 {name=p66235 lab=_86378_/Q }
C {devices/lab_pin.sym} 66940 -33470 0 0 {name=p66236 lab=_49470_/X }
C {devices/lab_pin.sym} 66940 -33430 0 0 {name=p66237 lab=_49485_/Y }
C {devices/lab_pin.sym} 67100 -33470 0 1 {name=p66238 lab=_49486_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -33470 0 0 {name=X_49486_ }
C {devices/lab_pin.sym} 66980 -33330 0 0 {name=p66239 lab=_61856_/A }
C {devices/lab_pin.sym} 67060 -33330 0 1 {name=p66240 lab=_61765_/B }
C {sky130_stdcells/buf_2.sym} 67020 -33330 0 0 {name=X_61764_ }
C {devices/lab_pin.sym} 66960 -33240 0 0 {name=p66241 lab=_46717_/A }
C {devices/lab_pin.sym} 66960 -33200 0 0 {name=p66242 lab=_46682_/B }
C {devices/lab_pin.sym} 66960 -33160 0 0 {name=p66243 lab=_46682_/C }
C {devices/lab_pin.sym} 66960 -33120 0 0 {name=p66244 lab=_52622_/D }
C {devices/lab_pin.sym} 67080 -33180 0 1 {name=p66245 lab=_46698_/X }
C {sky130_stdcells/and4_4.sym} 67020 -33180 0 0 {name=X_46698_ }
C {devices/lab_pin.sym} 66940 -33060 0 0 {name=p66246 lab=_61460_/B }
C {devices/lab_pin.sym} 66940 -33020 0 0 {name=p66247 lab=_63487_/X }
C {devices/lab_pin.sym} 66940 -32980 0 0 {name=p66248 lab=_63500_/X }
C {devices/lab_pin.sym} 66940 -32940 0 0 {name=p66249 lab=_63502_/X }
C {devices/lab_pin.sym} 67100 -33000 0 1 {name=p66250 lab=_63503_/X }
C {sky130_stdcells/a211o_4.sym} 67020 -33000 0 0 {name=X_63503_ }
C {devices/lab_pin.sym} 66980 -32850 0 0 {name=p66251 lab=_46317_/A }
C {devices/lab_pin.sym} 67060 -32850 0 1 {name=p66252 lab=_48642_/A }
C {sky130_stdcells/buf_2.sym} 67020 -32850 0 0 {name=X_48437_ }
C {devices/lab_pin.sym} 66980 -32730 0 0 {name=p66253 lab=_60036_/A }
C {devices/lab_pin.sym} 67060 -32730 0 1 {name=p66254 lab=_60715_/X }
C {sky130_stdcells/buf_2.sym} 67020 -32730 0 0 {name=X_60715_ }
C {devices/lab_pin.sym} 66980 -32610 0 0 {name=p66255 lab=_67270_/X }
C {devices/lab_pin.sym} 67060 -32610 0 1 {name=p66256 lab=_67271_/X }
C {sky130_stdcells/buf_2.sym} 67020 -32610 0 0 {name=X_67271_ }
C {devices/lab_pin.sym} 66980 -32490 0 0 {name=p66257 lab=_79256_/Y }
C {devices/lab_pin.sym} 67060 -32490 0 1 {name=p66258 lab=_79257_/Y }
C {sky130_stdcells/inv_2.sym} 67020 -32490 0 0 {name=X_79257_ }
C {devices/lab_pin.sym} 66940 -32400 0 0 {name=p66259 lab=_45647_/Y }
C {devices/lab_pin.sym} 66940 -32360 0 0 {name=p66260 lab=_45632_/X }
C {devices/lab_pin.sym} 66940 -32320 0 0 {name=p66261 lab=_45616_/X }
C {devices/lab_pin.sym} 66940 -32280 0 0 {name=p66262 lab=_45648_/Y }
C {devices/lab_pin.sym} 67100 -32340 0 1 {name=p66263 lab=_45649_/X }
C {sky130_stdcells/a211o_4.sym} 67020 -32340 0 0 {name=X_45649_ }
C {devices/lab_pin.sym} 66960 -32220 0 0 {name=p66264 lab=_61140_/X }
C {devices/lab_pin.sym} 66960 -32180 0 0 {name=p66265 lab=_64523_/B }
C {devices/lab_pin.sym} 66960 -32140 0 0 {name=p66266 lab=_58184_/A }
C {devices/lab_pin.sym} 66960 -32100 0 0 {name=p66267 lab=_61153_/C }
C {devices/lab_pin.sym} 67080 -32160 0 1 {name=p66268 lab=_64483_/X }
C {sky130_stdcells/and4_4.sym} 67020 -32160 0 0 {name=X_64483_ }
C {devices/lab_pin.sym} 66960 -32020 0 0 {name=p66269 lab=_81367_/Q }
C {devices/lab_pin.sym} 66960 -31980 0 0 {name=p66270 lab=_76469_/B }
C {devices/lab_pin.sym} 67080 -32000 0 1 {name=p66271 lab=_76469_/X }
C {sky130_stdcells/xor2_4.sym} 67020 -32000 0 0 {name=X_76469_ }
C {devices/lab_pin.sym} 66960 -31900 0 0 {name=p66272 lab=_61695_/A }
C {devices/lab_pin.sym} 66960 -31860 0 0 {name=p66273 lab=_61653_/X }
C {devices/lab_pin.sym} 66960 -31820 0 0 {name=p66274 lab=_61654_/X }
C {devices/lab_pin.sym} 66960 -31780 0 0 {name=p66275 lab=_61368_/D }
C {devices/lab_pin.sym} 67080 -31840 0 1 {name=p66276 lab=_61695_/Y }
C {sky130_stdcells/nand4_4.sym} 67020 -31840 0 0 {name=X_61695_ }
C {devices/lab_pin.sym} 66980 -31690 0 0 {name=p66277 lab=clkbuf_8_23_0_CLK/A }
C {devices/lab_pin.sym} 67060 -31690 0 1 {name=p66278 lab=clkbuf_8_22_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 67020 -31690 0 0 {name=Xclkbuf_8_22_0_CLK }
C {devices/lab_pin.sym} 66980 -31570 0 0 {name=p66279 lab=_69371_/A }
C {devices/lab_pin.sym} 67060 -31570 0 1 {name=p66280 lab=_69010_/X }
C {sky130_stdcells/buf_2.sym} 67020 -31570 0 0 {name=X_69010_ }
C {devices/lab_pin.sym} 66960 -31460 0 0 {name=p66281 lab=_66054_/X }
C {devices/lab_pin.sym} 66960 -31420 0 0 {name=p66282 lab=_74083_/B }
C {devices/lab_pin.sym} 67080 -31440 0 1 {name=p66283 lab=_66222_/X }
C {sky130_stdcells/and2_4.sym} 67020 -31440 0 0 {name=X_66222_ }
C {devices/lab_pin.sym} 66940 -31330 0 0 {name=p66284 lab=_78199_/Y }
C {devices/lab_pin.sym} 66940 -31290 0 0 {name=p66285 lab=_78206_/Y }
C {devices/lab_pin.sym} 66940 -31250 0 0 {name=p66286 lab=_78207_/Y }
C {devices/lab_pin.sym} 67100 -31290 0 1 {name=p66287 lab=_78208_/X }
C {sky130_stdcells/o21a_4.sym} 67020 -31290 0 0 {name=X_78208_ }
C {devices/lab_pin.sym} 66980 -31150 0 0 {name=p66288 lab=_63368_/A }
C {devices/lab_pin.sym} 67060 -31150 0 1 {name=p66289 lab=_63434_/X }
C {sky130_stdcells/buf_2.sym} 67020 -31150 0 0 {name=X_63434_ }
C {devices/lab_pin.sym} 66980 -31030 0 0 {name=p66290 lab=_48367_/Y }
C {devices/lab_pin.sym} 67060 -31030 0 1 {name=p66291 lab=_48368_/X }
C {sky130_stdcells/buf_2.sym} 67020 -31030 0 0 {name=X_48368_ }
C {devices/lab_pin.sym} 66960 -30920 0 0 {name=p66292 lab=_60662_/A }
C {devices/lab_pin.sym} 66960 -30880 0 0 {name=p66293 lab=_60687_/A }
C {devices/lab_pin.sym} 67080 -30900 0 1 {name=p66294 lab=_60646_/Y }
C {sky130_stdcells/nor2_4.sym} 67020 -30900 0 0 {name=X_60646_ }
C {devices/lab_pin.sym} 66960 -30780 0 0 {name=p66295 lab=_79188_/A }
C {devices/lab_pin.sym} 66960 -30740 0 0 {name=p66296 lab=_79188_/B }
C {devices/lab_pin.sym} 67080 -30760 0 1 {name=p66297 lab=_79189_/B }
C {sky130_stdcells/nand2_4.sym} 67020 -30760 0 0 {name=X_79188_ }
C {devices/lab_pin.sym} 66980 -30630 0 0 {name=p66298 lab=_81815_/Q }
C {devices/lab_pin.sym} 67060 -30630 0 1 {name=p66299 lab=_47320_/A }
C {sky130_stdcells/inv_2.sym} 67020 -30630 0 0 {name=X_47319_ }
C {devices/lab_pin.sym} 66960 -30520 0 0 {name=p66300 lab=_64593_/A }
C {devices/lab_pin.sym} 66960 -30480 0 0 {name=p66301 lab=_66153_/B }
C {devices/lab_pin.sym} 67080 -30500 0 1 {name=p66302 lab=_66153_/X }
C {sky130_stdcells/and2_4.sym} 67020 -30500 0 0 {name=X_66153_ }
C {devices/lab_pin.sym} 66960 -30380 0 0 {name=p66303 lab=_82666_/Q }
C {devices/lab_pin.sym} 66960 -30340 0 0 {name=p66304 lab=_78139_/B }
C {devices/lab_pin.sym} 67080 -30360 0 1 {name=p66305 lab=_78139_/X }
C {sky130_stdcells/xor2_4.sym} 67020 -30360 0 0 {name=X_78139_ }
C {devices/lab_pin.sym} 66960 -30250 0 0 {name=p66306 lab=_63305_/X }
C {devices/lab_pin.sym} 66960 -30210 0 0 {name=p66307 lab=_63392_/B }
C {devices/lab_pin.sym} 66960 -30170 0 0 {name=p66308 lab=_63365_/C }
C {devices/lab_pin.sym} 67080 -30210 0 1 {name=p66309 lab=_63365_/Y }
C {sky130_stdcells/nor3_4.sym} 67020 -30210 0 0 {name=X_63365_ }
C {devices/lab_pin.sym} 66940 -30090 0 0 {name=p66310 lab=_48296_/Y }
C {devices/lab_pin.sym} 66940 -30050 0 0 {name=p66311 lab=_48273_/X }
C {devices/lab_pin.sym} 66940 -30010 0 0 {name=p66312 lab=_48298_/Y }
C {devices/lab_pin.sym} 67100 -30050 0 1 {name=p66313 lab=_86540_/D }
C {sky130_stdcells/a21boi_4.sym} 67020 -30050 0 0 {name=X_48299_ }
C {devices/lab_pin.sym} 66980 -29910 0 0 {name=p66314 lab=_72250_/A }
C {devices/lab_pin.sym} 67060 -29910 0 1 {name=p66315 lab=_60577_/X }
C {sky130_stdcells/buf_2.sym} 67020 -29910 0 0 {name=X_60577_ }
C {devices/lab_pin.sym} 66940 -29820 0 0 {name=p66316 lab=_64999_/X }
C {devices/lab_pin.sym} 66940 -29780 0 0 {name=p66317 lab=_86126_/Q }
C {devices/lab_pin.sym} 66940 -29740 0 0 {name=p66318 lab=_64927_/X }
C {devices/lab_pin.sym} 66940 -29700 0 0 {name=p66319 lab=_65103_/X }
C {devices/lab_pin.sym} 67100 -29760 0 1 {name=p66320 lab=_65104_/X }
C {sky130_stdcells/a211o_4.sym} 67020 -29760 0 0 {name=X_65104_ }
C {devices/lab_pin.sym} 66980 -29610 0 0 {name=p66321 lab=_53511_/A }
C {devices/lab_pin.sym} 67060 -29610 0 1 {name=p66322 lab=_50331_/B }
C {sky130_stdcells/buf_2.sym} 67020 -29610 0 0 {name=X_50330_ }
C {devices/lab_pin.sym} 66980 -29490 0 0 {name=p66323 lab=_62471_/A }
C {devices/lab_pin.sym} 67060 -29490 0 1 {name=p66324 lab=_62332_/D }
C {sky130_stdcells/buf_2.sym} 67020 -29490 0 0 {name=X_62316_ }
C {devices/lab_pin.sym} 66930 -29370 0 0 {name=p66325 lab=_82284_/CLK }
C {devices/lab_pin.sym} 66930 -29350 0 0 {name=p66326 lab=_81150_/D }
C {devices/lab_pin.sym} 67110 -29370 0 1 {name=p66327 lab=_40588_/A }
C {sky130_stdcells/dfxtp_4.sym} 67020 -29360 0 0 {name=X_81150_ }
C {devices/lab_pin.sym} 66960 -29240 0 0 {name=p66328 lab=_44263_/X }
C {devices/lab_pin.sym} 66960 -29200 0 0 {name=p66329 lab=_66084_/B }
C {devices/lab_pin.sym} 67080 -29220 0 1 {name=p66330 lab=_66084_/X }
C {sky130_stdcells/and2_4.sym} 67020 -29220 0 0 {name=X_66084_ }
C {devices/lab_pin.sym} 66980 -29090 0 0 {name=p66331 lab=clkbuf_8_37_0_CLK/A }
C {devices/lab_pin.sym} 67060 -29090 0 1 {name=p66332 lab=clkbuf_8_37_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 67020 -29090 0 0 {name=Xclkbuf_8_37_0_CLK }
C {devices/lab_pin.sym} 66940 -28990 0 0 {name=p66333 lab=_63293_/Y }
C {devices/lab_pin.sym} 66940 -28950 0 0 {name=p66334 lab=_63295_/X }
C {devices/lab_pin.sym} 66940 -28910 0 0 {name=p66335 lab=_63231_/X }
C {devices/lab_pin.sym} 67100 -28950 0 1 {name=p66336 lab=_63296_/Y }
C {sky130_stdcells/a21oi_4.sym} 67020 -28950 0 0 {name=X_63296_ }
C {devices/lab_pin.sym} 66960 -28820 0 0 {name=p66337 lab=_84939_/Q }
C {devices/lab_pin.sym} 66960 -28780 0 0 {name=p66338 lab=_84187_/Q }
C {devices/lab_pin.sym} 67080 -28800 0 1 {name=p66339 lab=_80101_/X }
C {sky130_stdcells/xor2_4.sym} 67020 -28800 0 0 {name=X_80101_ }
C {devices/lab_pin.sym} 66940 -28700 0 0 {name=p66340 lab=_44583_/A }
C {devices/lab_pin.sym} 66940 -28660 0 0 {name=p66341 lab=_66608_/X }
C {devices/lab_pin.sym} 66940 -28620 0 0 {name=p66342 lab=_58827_/A }
C {devices/lab_pin.sym} 66940 -28580 0 0 {name=p66343 lab=_69911_/X }
C {devices/lab_pin.sym} 67100 -28640 0 1 {name=p66344 lab=_69912_/X }
C {sky130_stdcells/a211o_4.sym} 67020 -28640 0 0 {name=X_69912_ }
C {devices/lab_pin.sym} 66980 -28490 0 0 {name=p66345 lab=_65859_/A }
C {devices/lab_pin.sym} 67060 -28490 0 1 {name=p66346 lab=_65035_/X }
C {sky130_stdcells/buf_2.sym} 67020 -28490 0 0 {name=X_65035_ }
C {devices/lab_pin.sym} 66940 -28390 0 0 {name=p66347 lab=_86236_/Q }
C {devices/lab_pin.sym} 66940 -28350 0 0 {name=p66348 lab=_50250_/X }
C {devices/lab_pin.sym} 66940 -28310 0 0 {name=p66349 lab=_50260_/Y }
C {devices/lab_pin.sym} 67100 -28350 0 1 {name=p66350 lab=_50261_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -28350 0 0 {name=X_50261_ }
C {devices/lab_pin.sym} 66980 -28210 0 0 {name=p66351 lab=_62623_/A }
C {devices/lab_pin.sym} 67060 -28210 0 1 {name=p66352 lab=_62247_/X }
C {sky130_stdcells/buf_2.sym} 67020 -28210 0 0 {name=X_62247_ }
C {devices/lab_pin.sym} 66930 -28090 0 0 {name=p66353 lab=_80696_/CLK }
C {devices/lab_pin.sym} 66930 -28070 0 0 {name=p66354 lab=_81113_/Q }
C {devices/lab_pin.sym} 67110 -28090 0 1 {name=p66355 lab=_75409_/A }
C {sky130_stdcells/dfxtp_4.sym} 67020 -28080 0 0 {name=X_81081_ }
C {devices/lab_pin.sym} 66940 -27970 0 0 {name=p66356 lab=_51998_/Y }
C {devices/lab_pin.sym} 66940 -27930 0 0 {name=p66357 lab=_51981_/X }
C {devices/lab_pin.sym} 66940 -27890 0 0 {name=p66358 lab=_51999_/Y }
C {devices/lab_pin.sym} 67100 -27930 0 1 {name=p66359 lab=_85909_/D }
C {sky130_stdcells/a21boi_4.sym} 67020 -27930 0 0 {name=X_52000_ }
C {devices/lab_pin.sym} 66960 -27800 0 0 {name=p66360 lab=_80016_/Y }
C {devices/lab_pin.sym} 66960 -27760 0 0 {name=p66361 lab=_80019_/Y }
C {devices/lab_pin.sym} 67080 -27780 0 1 {name=p66362 lab=_80032_/X }
C {sky130_stdcells/or2_4.sym} 67020 -27780 0 0 {name=X_80032_ }
C {devices/lab_pin.sym} 66940 -27680 0 0 {name=p66363 lab=_87051_/Q }
C {devices/lab_pin.sym} 66940 -27640 0 0 {name=p66364 lab=_69796_/X }
C {devices/lab_pin.sym} 66940 -27600 0 0 {name=p66365 lab=_69797_/X }
C {devices/lab_pin.sym} 66940 -27560 0 0 {name=p66366 lab=_69842_/X }
C {devices/lab_pin.sym} 67100 -27620 0 1 {name=p66367 lab=_69843_/X }
C {sky130_stdcells/a211o_4.sym} 67020 -27620 0 0 {name=X_69843_ }
C {devices/lab_pin.sym} 66980 -27470 0 0 {name=p66368 lab=_50105_/A }
C {devices/lab_pin.sym} 67060 -27470 0 1 {name=p66369 lab=_51242_/A }
C {sky130_stdcells/buf_2.sym} 67020 -27470 0 0 {name=X_50192_ }
C {devices/lab_pin.sym} 66980 -27350 0 0 {name=p66370 lab=_62120_/A }
C {devices/lab_pin.sym} 67060 -27350 0 1 {name=p66371 lab=_62181_/A }
C {sky130_stdcells/buf_2.sym} 67020 -27350 0 0 {name=X_62178_ }
C {devices/lab_pin.sym} 66980 -27230 0 0 {name=p66372 lab=_64303_/A }
C {devices/lab_pin.sym} 67060 -27230 0 1 {name=p66373 lab=_64523_/B }
C {sky130_stdcells/buf_2.sym} 67020 -27230 0 0 {name=X_61129_ }
C {devices/lab_pin.sym} 66930 -27110 0 0 {name=p66374 lab=_84840_/CLK }
C {devices/lab_pin.sym} 66930 -27090 0 0 {name=p66375 lab=_84840_/D }
C {devices/lab_pin.sym} 67110 -27110 0 1 {name=p66376 lab=_64412_/C }
C {sky130_stdcells/dfxtp_4.sym} 67020 -27100 0 0 {name=X_84840_ }
C {devices/lab_pin.sym} 66940 -27000 0 0 {name=p66377 lab=_69746_/X }
C {devices/lab_pin.sym} 66940 -26960 0 0 {name=p66378 lab=_69772_/Y }
C {devices/lab_pin.sym} 66940 -26920 0 0 {name=p66379 lab=_69733_/X }
C {devices/lab_pin.sym} 66940 -26880 0 0 {name=p66380 lab=_69773_/Y }
C {devices/lab_pin.sym} 67100 -26940 0 1 {name=p66381 lab=_69774_/X }
C {sky130_stdcells/a211o_4.sym} 67020 -26940 0 0 {name=X_69774_ }
C {devices/lab_pin.sym} 66940 -26820 0 0 {name=p66382 lab=_87426_/Q }
C {devices/lab_pin.sym} 66940 -26780 0 0 {name=p66383 lab=_66915_/X }
C {devices/lab_pin.sym} 66940 -26740 0 0 {name=p66384 lab=_66984_/X }
C {devices/lab_pin.sym} 66940 -26700 0 0 {name=p66385 lab=_66985_/X }
C {devices/lab_pin.sym} 67100 -26760 0 1 {name=p66386 lab=_66986_/X }
C {sky130_stdcells/a211o_4.sym} 67020 -26760 0 0 {name=X_66986_ }
C {devices/lab_pin.sym} 66960 -26620 0 0 {name=p66387 lab=_68720_/X }
C {devices/lab_pin.sym} 66960 -26580 0 0 {name=p66388 lab=_68724_/X }
C {devices/lab_pin.sym} 67080 -26600 0 1 {name=p66389 lab=_68725_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -26600 0 0 {name=X_68725_ }
C {devices/lab_pin.sym} 66960 -26480 0 0 {name=p66390 lab=_53951_/A }
C {devices/lab_pin.sym} 66960 -26440 0 0 {name=p66391 lab=_53951_/B }
C {devices/lab_pin.sym} 67080 -26460 0 1 {name=p66392 lab=_53951_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -26460 0 0 {name=X_53951_ }
C {devices/lab_pin.sym} 66980 -26330 0 0 {name=p66393 lab=_64729_/A }
C {devices/lab_pin.sym} 67060 -26330 0 1 {name=p66394 lab=_65937_/X }
C {sky130_stdcells/buf_2.sym} 67020 -26330 0 0 {name=X_65937_ }
C {devices/lab_pin.sym} 66930 -26210 0 0 {name=p66395 lab=_86686_/CLK }
C {devices/lab_pin.sym} 66930 -26190 0 0 {name=p66396 lab=_84771_/D }
C {devices/lab_pin.sym} 67110 -26210 0 1 {name=p66397 lab=_84771_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -26200 0 0 {name=X_84771_ }
C {devices/lab_pin.sym} 66930 -26070 0 0 {name=p66398 lab=_81933_/CLK }
C {devices/lab_pin.sym} 66930 -26050 0 0 {name=p66399 lab=_81983_/D }
C {devices/lab_pin.sym} 67110 -26070 0 1 {name=p66400 lab=_81983_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -26060 0 0 {name=X_81983_ }
C {devices/lab_pin.sym} 66930 -25930 0 0 {name=p66401 lab=_86499_/CLK }
C {devices/lab_pin.sym} 66930 -25910 0 0 {name=p66402 lab=_48580_/Y }
C {devices/lab_pin.sym} 67110 -25930 0 1 {name=p66403 lab=_86510_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -25920 0 0 {name=X_86510_ }
C {devices/lab_pin.sym} 66980 -25790 0 0 {name=p66404 lab=_52821_/A }
C {devices/lab_pin.sym} 67060 -25790 0 1 {name=p66405 lab=_52902_/X }
C {sky130_stdcells/buf_2.sym} 67020 -25790 0 0 {name=X_52902_ }
C {devices/lab_pin.sym} 66930 -25670 0 0 {name=p66406 lab=_85378_/CLK }
C {devices/lab_pin.sym} 66930 -25650 0 0 {name=p66407 lab=_70693_/X }
C {devices/lab_pin.sym} 67110 -25670 0 1 {name=p66408 lab=_47515_/A }
C {sky130_stdcells/dfxtp_4.sym} 67020 -25660 0 0 {name=X_83722_ }
C {devices/lab_pin.sym} 66980 -25530 0 0 {name=p66409 lab=_56670_/A }
C {devices/lab_pin.sym} 67060 -25530 0 1 {name=p66410 lab=_56852_/A }
C {sky130_stdcells/buf_2.sym} 67020 -25530 0 0 {name=X_56670_ }
C {devices/lab_pin.sym} 66940 -25430 0 0 {name=p66411 lab=_68653_/X }
C {devices/lab_pin.sym} 66940 -25390 0 0 {name=p66412 lab=_68655_/X }
C {devices/lab_pin.sym} 66940 -25350 0 0 {name=p66413 lab=_68558_/X }
C {devices/lab_pin.sym} 67100 -25390 0 1 {name=p66414 lab=_68656_/X }
C {sky130_stdcells/a21o_4.sym} 67020 -25390 0 0 {name=X_68656_ }
C {devices/lab_pin.sym} 66930 -25250 0 0 {name=p66415 lab=_81059_/CLK }
C {devices/lab_pin.sym} 66930 -25230 0 0 {name=p66416 lab=_75124_/B }
C {devices/lab_pin.sym} 67110 -25250 0 1 {name=p66417 lab=_74874_/A }
C {sky130_stdcells/dfxtp_4.sym} 67020 -25240 0 0 {name=X_80934_ }
C {devices/lab_pin.sym} 66930 -25110 0 0 {name=p66418 lab=_87235_/CLK }
C {devices/lab_pin.sym} 66930 -25090 0 0 {name=p66419 lab=_87490_/D }
C {devices/lab_pin.sym} 67110 -25110 0 1 {name=p66420 lab=_87490_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -25100 0 0 {name=X_87490_ }
C {devices/lab_pin.sym} 66940 -24990 0 0 {name=p66421 lab=_85549_/Q }
C {devices/lab_pin.sym} 66940 -24950 0 0 {name=p66422 lab=_53869_/X }
C {devices/lab_pin.sym} 66940 -24910 0 0 {name=p66423 lab=_53881_/Y }
C {devices/lab_pin.sym} 67100 -24950 0 1 {name=p66424 lab=_53882_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -24950 0 0 {name=X_53882_ }
C {devices/lab_pin.sym} 66960 -24830 0 0 {name=p66425 lab=_65863_/X }
C {devices/lab_pin.sym} 66960 -24790 0 0 {name=p66426 lab=_65868_/B }
C {devices/lab_pin.sym} 66960 -24750 0 0 {name=p66427 lab=_65867_/X }
C {devices/lab_pin.sym} 67080 -24790 0 1 {name=p66428 lab=_65868_/Y }
C {sky130_stdcells/nand3_4.sym} 67020 -24790 0 0 {name=X_65868_ }
C {devices/lab_pin.sym} 66980 -24650 0 0 {name=p66429 lab=_55947_/A }
C {devices/lab_pin.sym} 67060 -24650 0 1 {name=p66430 lab=_55691_/A }
C {sky130_stdcells/buf_2.sym} 67020 -24650 0 0 {name=X_55621_ }
C {devices/lab_pin.sym} 66940 -24550 0 0 {name=p66431 lab=_67604_/X }
C {devices/lab_pin.sym} 66940 -24510 0 0 {name=p66432 lab=_67606_/X }
C {devices/lab_pin.sym} 66940 -24470 0 0 {name=p66433 lab=_67561_/X }
C {devices/lab_pin.sym} 67100 -24510 0 1 {name=p66434 lab=_67607_/X }
C {sky130_stdcells/a21o_4.sym} 67020 -24510 0 0 {name=X_67607_ }
C {devices/lab_pin.sym} 66930 -24370 0 0 {name=p66435 lab=_86154_/CLK }
C {devices/lab_pin.sym} 66930 -24350 0 0 {name=p66436 lab=_49133_/Y }
C {devices/lab_pin.sym} 67110 -24370 0 1 {name=p66437 lab=_86441_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -24360 0 0 {name=X_86441_ }
C {devices/lab_pin.sym} 66960 -24240 0 0 {name=p66438 lab=_52843_/A }
C {devices/lab_pin.sym} 66960 -24200 0 0 {name=p66439 lab=_52833_/B }
C {devices/lab_pin.sym} 67080 -24220 0 1 {name=p66440 lab=_52833_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -24220 0 0 {name=X_52833_ }
C {devices/lab_pin.sym} 66940 -24120 0 0 {name=p66441 lab=_64817_/X }
C {devices/lab_pin.sym} 66940 -24080 0 0 {name=p66442 lab=_86137_/Q }
C {devices/lab_pin.sym} 66940 -24040 0 0 {name=p66443 lab=_64776_/X }
C {devices/lab_pin.sym} 66940 -24000 0 0 {name=p66444 lab=_64818_/X }
C {devices/lab_pin.sym} 67100 -24060 0 1 {name=p66445 lab=_64819_/X }
C {sky130_stdcells/a211o_4.sym} 67020 -24060 0 0 {name=X_64819_ }
C {devices/lab_pin.sym} 66930 -23910 0 0 {name=p66446 lab=_85822_/CLK }
C {devices/lab_pin.sym} 66930 -23890 0 0 {name=p66447 lab=_83653_/D }
C {devices/lab_pin.sym} 67110 -23910 0 1 {name=p66448 lab=_46294_/A }
C {sky130_stdcells/dfxtp_4.sym} 67020 -23900 0 0 {name=X_83653_ }
C {devices/lab_pin.sym} 66930 -23770 0 0 {name=p66449 lab=_81990_/CLK }
C {devices/lab_pin.sym} 66930 -23750 0 0 {name=p66450 lab=_80897_/Q }
C {devices/lab_pin.sym} 67110 -23770 0 1 {name=p66451 lab=_80865_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -23760 0 0 {name=X_80865_ }
C {devices/lab_pin.sym} 66980 -23630 0 0 {name=p66452 lab=_64665_/A }
C {devices/lab_pin.sym} 67060 -23630 0 1 {name=p66453 lab=_68587_/X }
C {sky130_stdcells/buf_2.sym} 67020 -23630 0 0 {name=X_68587_ }
C {devices/lab_pin.sym} 66960 -23530 0 0 {name=p66454 lab=_65796_/X }
C {devices/lab_pin.sym} 66960 -23490 0 0 {name=p66455 lab=_65725_/B }
C {devices/lab_pin.sym} 66960 -23450 0 0 {name=p66456 lab=_65798_/X }
C {devices/lab_pin.sym} 67080 -23490 0 1 {name=p66457 lab=_65799_/Y }
C {sky130_stdcells/nand3_4.sym} 67020 -23490 0 0 {name=X_65799_ }
C {devices/lab_pin.sym} 66940 -23370 0 0 {name=p66458 lab=_58328_/X }
C {devices/lab_pin.sym} 66940 -23330 0 0 {name=p66459 lab=_83450_/Q }
C {devices/lab_pin.sym} 66940 -23290 0 0 {name=p66460 lab=_58339_/Y }
C {devices/lab_pin.sym} 67100 -23330 0 1 {name=p66461 lab=_84874_/D }
C {sky130_stdcells/o21a_4.sym} 67020 -23330 0 0 {name=X_58340_ }
C {devices/lab_pin.sym} 66930 -23190 0 0 {name=p66462 lab=_82604_/CLK }
C {devices/lab_pin.sym} 66930 -23170 0 0 {name=p66463 lab=_78901_/B }
C {devices/lab_pin.sym} 67110 -23190 0 1 {name=p66464 lab=_82572_/D }
C {sky130_stdcells/dfxtp_4.sym} 67020 -23180 0 0 {name=X_82604_ }
C {devices/lab_pin.sym} 66980 -23050 0 0 {name=p66465 lab=_55552_/A }
C {devices/lab_pin.sym} 67060 -23050 0 1 {name=p66466 lab=_55552_/X }
C {sky130_stdcells/buf_2.sym} 67020 -23050 0 0 {name=X_55552_ }
C {devices/lab_pin.sym} 66940 -22950 0 0 {name=p66467 lab=_67535_/X }
C {devices/lab_pin.sym} 66940 -22910 0 0 {name=p66468 lab=_67537_/X }
C {devices/lab_pin.sym} 66940 -22870 0 0 {name=p66469 lab=_67442_/X }
C {devices/lab_pin.sym} 67100 -22910 0 1 {name=p66470 lab=_67538_/X }
C {sky130_stdcells/a21o_4.sym} 67020 -22910 0 0 {name=X_67538_ }
C {devices/lab_pin.sym} 66930 -22770 0 0 {name=p66471 lab=_86372_/CLK }
C {devices/lab_pin.sym} 66930 -22750 0 0 {name=p66472 lab=_86372_/D }
C {devices/lab_pin.sym} 67110 -22770 0 1 {name=p66473 lab=_86372_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -22760 0 0 {name=X_86372_ }
C {devices/lab_pin.sym} 66940 -22650 0 0 {name=p66474 lab=_52761_/Y }
C {devices/lab_pin.sym} 66940 -22610 0 0 {name=p66475 lab=_52755_/X }
C {devices/lab_pin.sym} 66940 -22570 0 0 {name=p66476 lab=_52763_/X }
C {devices/lab_pin.sym} 67100 -22610 0 1 {name=p66477 lab=_52764_/Y }
C {sky130_stdcells/a21oi_4.sym} 67020 -22610 0 0 {name=X_52764_ }
C {devices/lab_pin.sym} 66930 -22470 0 0 {name=p66478 lab=_83584_/CLK }
C {devices/lab_pin.sym} 66930 -22450 0 0 {name=p66479 lab=_83584_/D }
C {devices/lab_pin.sym} 67110 -22470 0 1 {name=p66480 lab=_83584_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -22460 0 0 {name=X_83584_ }
C {devices/lab_pin.sym} 66930 -22330 0 0 {name=p66481 lab=_83957_/CLK }
C {devices/lab_pin.sym} 66930 -22310 0 0 {name=p66482 lab=_80796_/D }
C {devices/lab_pin.sym} 67110 -22330 0 1 {name=p66483 lab=_75472_/A }
C {sky130_stdcells/dfxtp_4.sym} 67020 -22320 0 0 {name=X_80796_ }
C {devices/lab_pin.sym} 66930 -22190 0 0 {name=p66484 lab=_88111_/CLK }
C {devices/lab_pin.sym} 66930 -22170 0 0 {name=p66485 lab=_41896_/Y }
C {devices/lab_pin.sym} 67110 -22190 0 1 {name=p66486 lab=_73650_/A }
C {sky130_stdcells/dfxtp_4.sym} 67020 -22180 0 0 {name=X_88111_ }
C {devices/lab_pin.sym} 66960 -22080 0 0 {name=p66487 lab=_54483_/A }
C {devices/lab_pin.sym} 66960 -22040 0 0 {name=p66488 lab=_54503_/B }
C {devices/lab_pin.sym} 66960 -22000 0 0 {name=p66489 lab=_54483_/C }
C {devices/lab_pin.sym} 66960 -21960 0 0 {name=p66490 lab=_54503_/D }
C {devices/lab_pin.sym} 67080 -22020 0 1 {name=p66491 lab=_54503_/X }
C {sky130_stdcells/and4_4.sym} 67020 -22020 0 0 {name=X_54503_ }
C {devices/lab_pin.sym} 66930 -21870 0 0 {name=p66492 lab=_85354_/CLK }
C {devices/lab_pin.sym} 66930 -21850 0 0 {name=p66493 lab=_85323_/D }
C {devices/lab_pin.sym} 67110 -21870 0 1 {name=p66494 lab=_85323_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -21860 0 0 {name=X_85323_ }
C {devices/lab_pin.sym} 66960 -21760 0 0 {name=p66495 lab=_51709_/X }
C {devices/lab_pin.sym} 66960 -21720 0 0 {name=p66496 lab=_51715_/B }
C {devices/lab_pin.sym} 66960 -21680 0 0 {name=p66497 lab=_51715_/C }
C {devices/lab_pin.sym} 66960 -21640 0 0 {name=p66498 lab=_53238_/D }
C {devices/lab_pin.sym} 67080 -21700 0 1 {name=p66499 lab=_51715_/X }
C {sky130_stdcells/and4_4.sym} 67020 -21700 0 0 {name=X_51715_ }
C {devices/lab_pin.sym} 66980 -21550 0 0 {name=p66500 lab=_58328_/A }
C {devices/lab_pin.sym} 67060 -21550 0 1 {name=p66501 lab=_58271_/X }
C {sky130_stdcells/buf_2.sym} 67020 -21550 0 0 {name=X_58271_ }
C {devices/lab_pin.sym} 66930 -21430 0 0 {name=p66502 lab=_82541_/CLK }
C {devices/lab_pin.sym} 66930 -21410 0 0 {name=p66503 lab=_82535_/D }
C {devices/lab_pin.sym} 67110 -21430 0 1 {name=p66504 lab=_82535_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -21420 0 0 {name=X_82535_ }
C {devices/lab_pin.sym} 66980 -21290 0 0 {name=p66505 lab=_55483_/A }
C {devices/lab_pin.sym} 67060 -21290 0 1 {name=p66506 lab=_55483_/Y }
C {sky130_stdcells/inv_2.sym} 67020 -21290 0 0 {name=X_55483_ }
C {devices/lab_pin.sym} 66940 -21200 0 0 {name=p66507 lab=_87162_/Q }
C {devices/lab_pin.sym} 66940 -21160 0 0 {name=p66508 lab=_67467_/X }
C {devices/lab_pin.sym} 66940 -21120 0 0 {name=p66509 lab=_67398_/X }
C {devices/lab_pin.sym} 66940 -21080 0 0 {name=p66510 lab=_67468_/X }
C {devices/lab_pin.sym} 67100 -21140 0 1 {name=p66511 lab=_67469_/X }
C {sky130_stdcells/a211o_4.sym} 67020 -21140 0 0 {name=X_67469_ }
C {devices/lab_pin.sym} 66940 -21010 0 0 {name=p66512 lab=_52693_/Y }
C {devices/lab_pin.sym} 66940 -20970 0 0 {name=p66513 lab=_52673_/X }
C {devices/lab_pin.sym} 66940 -20930 0 0 {name=p66514 lab=_52694_/X }
C {devices/lab_pin.sym} 67100 -20970 0 1 {name=p66515 lab=_52695_/Y }
C {sky130_stdcells/a21oi_4.sym} 67020 -20970 0 0 {name=X_52695_ }
C {devices/lab_pin.sym} 66980 -20830 0 0 {name=p66516 lab=_55657_/Y }
C {devices/lab_pin.sym} 67060 -20830 0 1 {name=p66517 lab=_57222_/Y }
C {sky130_stdcells/inv_2.sym} 67020 -20830 0 0 {name=X_57222_ }
C {devices/lab_pin.sym} 66940 -20730 0 0 {name=p66518 lab=_69204_/X }
C {devices/lab_pin.sym} 66940 -20690 0 0 {name=p66519 lab=_69207_/X }
C {devices/lab_pin.sym} 66940 -20650 0 0 {name=p66520 lab=_69116_/X }
C {devices/lab_pin.sym} 67100 -20690 0 1 {name=p66521 lab=_69208_/X }
C {sky130_stdcells/a21o_4.sym} 67020 -20690 0 0 {name=X_69208_ }
C {devices/lab_pin.sym} 66930 -20550 0 0 {name=p66522 lab=_87789_/CLK }
C {devices/lab_pin.sym} 66930 -20530 0 0 {name=p66523 lab=_42086_/X }
C {devices/lab_pin.sym} 67110 -20550 0 1 {name=p66524 lab=_88042_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -20540 0 0 {name=X_88042_ }
C {devices/lab_pin.sym} 66940 -20430 0 0 {name=p66525 lab=_85443_/Q }
C {devices/lab_pin.sym} 66940 -20390 0 0 {name=p66526 lab=_54431_/X }
C {devices/lab_pin.sym} 66940 -20350 0 0 {name=p66527 lab=_54433_/Y }
C {devices/lab_pin.sym} 67100 -20390 0 1 {name=p66528 lab=_54434_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -20390 0 0 {name=X_54434_ }
C {devices/lab_pin.sym} 66930 -20250 0 0 {name=p66529 lab=_85190_/CLK }
C {devices/lab_pin.sym} 66930 -20230 0 0 {name=p66530 lab=_85254_/D }
C {devices/lab_pin.sym} 67110 -20250 0 1 {name=p66531 lab=_85254_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -20240 0 0 {name=X_85254_ }
C {devices/lab_pin.sym} 66940 -20130 0 0 {name=p66532 lab=_51644_/Y }
C {devices/lab_pin.sym} 66940 -20090 0 0 {name=p66533 lab=_51639_/X }
C {devices/lab_pin.sym} 66940 -20050 0 0 {name=p66534 lab=_51645_/X }
C {devices/lab_pin.sym} 67100 -20090 0 1 {name=p66535 lab=_85972_/D }
C {sky130_stdcells/a21oi_4.sym} 67020 -20090 0 0 {name=X_51646_ }
C {devices/lab_pin.sym} 66960 -19970 0 0 {name=p66536 lab=_71706_/A }
C {devices/lab_pin.sym} 66960 -19930 0 0 {name=p66537 lab=_70483_/B }
C {devices/lab_pin.sym} 66960 -19890 0 0 {name=p66538 lab=_71815_/B }
C {devices/lab_pin.sym} 67080 -19930 0 1 {name=p66539 lab=_70480_/X }
C {sky130_stdcells/and3_4.sym} 67020 -19930 0 0 {name=X_70480_ }
C {devices/lab_pin.sym} 66930 -19790 0 0 {name=p66540 lab=_82595_/CLK }
C {devices/lab_pin.sym} 66930 -19770 0 0 {name=p66541 lab=_82466_/D }
C {devices/lab_pin.sym} 67110 -19790 0 1 {name=p66542 lab=_78248_/B }
C {sky130_stdcells/dfxtp_4.sym} 67020 -19780 0 0 {name=X_82466_ }
C {devices/lab_pin.sym} 66930 -19650 0 0 {name=p66543 lab=_85315_/CLK }
C {devices/lab_pin.sym} 66930 -19630 0 0 {name=p66544 lab=_84205_/D }
C {devices/lab_pin.sym} 67110 -19650 0 1 {name=p66545 lab=_65348_/C }
C {sky130_stdcells/dfxtp_4.sym} 67020 -19640 0 0 {name=X_84205_ }
C {devices/lab_pin.sym} 66960 -19520 0 0 {name=p66546 lab=_57153_/A }
C {devices/lab_pin.sym} 66960 -19480 0 0 {name=p66547 lab=_57153_/B }
C {devices/lab_pin.sym} 67080 -19500 0 1 {name=p66548 lab=_57153_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -19500 0 0 {name=X_57153_ }
C {devices/lab_pin.sym} 66930 -19370 0 0 {name=p66549 lab=_81575_/CLK }
C {devices/lab_pin.sym} 66930 -19350 0 0 {name=p66550 lab=_81449_/Q }
C {devices/lab_pin.sym} 67110 -19370 0 1 {name=p66551 lab=_75976_/B }
C {sky130_stdcells/dfxtp_4.sym} 67020 -19360 0 0 {name=X_81417_ }
C {devices/lab_pin.sym} 66940 -19250 0 0 {name=p66552 lab=_69135_/X }
C {devices/lab_pin.sym} 66940 -19210 0 0 {name=p66553 lab=_69137_/X }
C {devices/lab_pin.sym} 66940 -19170 0 0 {name=p66554 lab=_69138_/X }
C {devices/lab_pin.sym} 67100 -19210 0 1 {name=p66555 lab=_69139_/X }
C {sky130_stdcells/a21o_4.sym} 67020 -19210 0 0 {name=X_69139_ }
C {devices/lab_pin.sym} 66940 -19090 0 0 {name=p66556 lab=_85455_/Q }
C {devices/lab_pin.sym} 66940 -19050 0 0 {name=p66557 lab=_54349_/X }
C {devices/lab_pin.sym} 66940 -19010 0 0 {name=p66558 lab=_54364_/Y }
C {devices/lab_pin.sym} 67100 -19050 0 1 {name=p66559 lab=_54365_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -19050 0 0 {name=X_54365_ }
C {devices/lab_pin.sym} 66930 -18910 0 0 {name=p66560 lab=_85249_/CLK }
C {devices/lab_pin.sym} 66930 -18890 0 0 {name=p66561 lab=_85185_/D }
C {devices/lab_pin.sym} 67110 -18910 0 1 {name=p66562 lab=_85185_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -18900 0 0 {name=X_85185_ }
C {devices/lab_pin.sym} 66960 -18780 0 0 {name=p66563 lab=_51590_/A }
C {devices/lab_pin.sym} 66960 -18740 0 0 {name=p66564 lab=_53105_/B }
C {devices/lab_pin.sym} 67080 -18760 0 1 {name=p66565 lab=_51577_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -18760 0 0 {name=X_51577_ }
C {devices/lab_pin.sym} 66930 -18630 0 0 {name=p66566 lab=_82965_/CLK }
C {devices/lab_pin.sym} 66930 -18610 0 0 {name=p66567 lab=_82205_/Q }
C {devices/lab_pin.sym} 67110 -18630 0 1 {name=p66568 lab=_82397_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -18620 0 0 {name=X_82397_ }
C {devices/lab_pin.sym} 66980 -18490 0 0 {name=p66569 lab=clkbuf_9_190_0_CLK/X }
C {devices/lab_pin.sym} 67060 -18490 0 1 {name=p66570 lab=_85757_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67020 -18490 0 0 {name=Xclkbuf_10_381_0_CLK }
C {devices/lab_pin.sym} 66980 -18370 0 0 {name=p66571 lab=_56104_/A }
C {devices/lab_pin.sym} 67060 -18370 0 1 {name=p66572 lab=_56131_/A }
C {sky130_stdcells/buf_2.sym} 67020 -18370 0 0 {name=X_56104_ }
C {devices/lab_pin.sym} 66960 -18280 0 0 {name=p66573 lab=_53330_/A }
C {devices/lab_pin.sym} 66960 -18240 0 0 {name=p66574 lab=_53293_/B }
C {devices/lab_pin.sym} 66960 -18200 0 0 {name=p66575 lab=_53302_/X }
C {devices/lab_pin.sym} 66960 -18160 0 0 {name=p66576 lab=_52801_/D }
C {devices/lab_pin.sym} 67080 -18220 0 1 {name=p66577 lab=_53316_/X }
C {sky130_stdcells/and4_4.sym} 67020 -18220 0 0 {name=X_53316_ }
C {devices/lab_pin.sym} 66960 -18080 0 0 {name=p66578 lab=_41330_/A }
C {devices/lab_pin.sym} 66960 -18040 0 0 {name=p66579 lab=_41275_/B }
C {devices/lab_pin.sym} 67080 -18060 0 1 {name=p66580 lab=_41330_/X }
C {sky130_stdcells/or2_4.sym} 67020 -18060 0 0 {name=X_41330_ }
C {devices/lab_pin.sym} 66940 -17960 0 0 {name=p66581 lab=_83279_/Q }
C {devices/lab_pin.sym} 66940 -17920 0 0 {name=p66582 lab=_72115_/X }
C {devices/lab_pin.sym} 66940 -17880 0 0 {name=p66583 lab=_72142_/X }
C {devices/lab_pin.sym} 66940 -17840 0 0 {name=p66584 lab=_72149_/X }
C {devices/lab_pin.sym} 67100 -17900 0 1 {name=p66585 lab=_83279_/D }
