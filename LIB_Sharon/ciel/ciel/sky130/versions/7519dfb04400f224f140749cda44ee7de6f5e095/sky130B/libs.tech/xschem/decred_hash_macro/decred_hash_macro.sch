C {sky130_stdcells/o21a_4.sym} 159020 -32110 0 0 {name=X_58914_ }
C {devices/lab_pin.sym} 158940 -32010 0 0 {name=p157882 lab=_42035_/X }
C {devices/lab_pin.sym} 158940 -31970 0 0 {name=p157883 lab=_42049_/X }
C {devices/lab_pin.sym} 158940 -31930 0 0 {name=p157884 lab=_40903_/X }
C {devices/lab_pin.sym} 158940 -31890 0 0 {name=p157885 lab=_42050_/Y }
C {devices/lab_pin.sym} 158940 -31850 0 0 {name=p157886 lab=_42037_/X }
C {devices/lab_pin.sym} 159100 -31930 0 1 {name=p157887 lab=_42051_/Y }
C {sky130_stdcells/o32ai_4.sym} 159020 -31930 0 0 {name=X_42051_ }
C {devices/lab_pin.sym} 158960 -31780 0 0 {name=p157888 lab=_54037_/A }
C {devices/lab_pin.sym} 158960 -31740 0 0 {name=p157889 lab=_46464_/Y }
C {devices/lab_pin.sym} 159080 -31760 0 1 {name=p157890 lab=_54037_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -31760 0 0 {name=X_54037_ }
C {devices/lab_pin.sym} 158960 -31640 0 0 {name=p157891 lab=_51240_/A }
C {devices/lab_pin.sym} 158960 -31600 0 0 {name=p157892 lab=_50744_/B }
C {devices/lab_pin.sym} 159080 -31620 0 1 {name=p157893 lab=_51249_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -31620 0 0 {name=X_51249_ }
C {devices/lab_pin.sym} 158930 -31490 0 0 {name=p157894 lab=_87137_/CLK }
C {devices/lab_pin.sym} 158930 -31470 0 0 {name=p157895 lab=_44802_/Y }
C {devices/lab_pin.sym} 159110 -31490 0 1 {name=p157896 lab=_86946_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -31480 0 0 {name=X_86946_ }
C {devices/lab_pin.sym} 158930 -31350 0 0 {name=p157897 lab=_81160_/CLK }
C {devices/lab_pin.sym} 158930 -31330 0 0 {name=p157898 lab=_82069_/D }
C {devices/lab_pin.sym} 159110 -31350 0 1 {name=p157899 lab=_82069_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -31340 0 0 {name=X_82069_ }
C {devices/lab_pin.sym} 158960 -31230 0 0 {name=p157900 lab=_74958_/B }
C {devices/lab_pin.sym} 158960 -31190 0 0 {name=p157901 lab=_81136_/D }
C {devices/lab_pin.sym} 158960 -31150 0 0 {name=p157902 lab=_74960_/C }
C {devices/lab_pin.sym} 159080 -31190 0 1 {name=p157903 lab=_74960_/Y }
C {sky130_stdcells/nand3_4.sym} 159020 -31190 0 0 {name=X_74960_ }
C {devices/lab_pin.sym} 158940 -31080 0 0 {name=p157904 lab=_69029_/Y }
C {devices/lab_pin.sym} 158940 -31040 0 0 {name=p157905 lab=_68823_/X }
C {devices/lab_pin.sym} 158940 -31000 0 0 {name=p157906 lab=_70081_/X }
C {devices/lab_pin.sym} 158940 -30960 0 0 {name=p157907 lab=_70082_/Y }
C {devices/lab_pin.sym} 159100 -31020 0 1 {name=p157908 lab=_70083_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -31020 0 0 {name=X_70083_ }
C {devices/lab_pin.sym} 158960 -30890 0 0 {name=p157909 lab=_59887_/Y }
C {devices/lab_pin.sym} 158960 -30850 0 0 {name=p157910 lab=_59892_/Y }
C {devices/lab_pin.sym} 158960 -30810 0 0 {name=p157911 lab=_60165_/A }
C {devices/lab_pin.sym} 159080 -30850 0 1 {name=p157912 lab=_59927_/A }
C {sky130_stdcells/nand3_4.sym} 159020 -30850 0 0 {name=X_59894_ }
C {devices/lab_pin.sym} 158960 -30720 0 0 {name=p157913 lab=_41007_/A }
C {devices/lab_pin.sym} 158960 -30680 0 0 {name=p157914 lab=_41002_/B }
C {devices/lab_pin.sym} 159080 -30700 0 1 {name=p157915 lab=_41002_/X }
C {sky130_stdcells/or2_4.sym} 159020 -30700 0 0 {name=X_41002_ }
C {devices/lab_pin.sym} 158960 -30580 0 0 {name=p157916 lab=_47978_/A }
C {devices/lab_pin.sym} 158960 -30540 0 0 {name=p157917 lab=_73911_/B }
C {devices/lab_pin.sym} 159080 -30560 0 1 {name=p157918 lab=_73911_/X }
C {sky130_stdcells/xor2_4.sym} 159020 -30560 0 0 {name=X_73911_ }
C {devices/lab_pin.sym} 158940 -30450 0 0 {name=p157919 lab=_58740_/X }
C {devices/lab_pin.sym} 158940 -30410 0 0 {name=p157920 lab=_85451_/Q }
C {devices/lab_pin.sym} 158940 -30370 0 0 {name=p157921 lab=_58844_/X }
C {devices/lab_pin.sym} 159100 -30410 0 1 {name=p157922 lab=_58845_/Y }
C {sky130_stdcells/o21ai_4.sym} 159020 -30410 0 0 {name=X_58845_ }
C {devices/lab_pin.sym} 158960 -30280 0 0 {name=p157923 lab=_81129_/D }
C {devices/lab_pin.sym} 158960 -30240 0 0 {name=p157924 lab=_74891_/B }
C {devices/lab_pin.sym} 159080 -30260 0 1 {name=p157925 lab=_74894_/A }
C {sky130_stdcells/xor2_4.sym} 159020 -30260 0 0 {name=X_74891_ }
C {devices/lab_pin.sym} 158930 -30130 0 0 {name=p157926 lab=_86878_/CLK }
C {devices/lab_pin.sym} 158930 -30110 0 0 {name=p157927 lab=_45437_/Y }
C {devices/lab_pin.sym} 159110 -30130 0 1 {name=p157928 lab=_63030_/B }
C {sky130_stdcells/dfxtp_4.sym} 159020 -30120 0 0 {name=X_86877_ }
C {devices/lab_pin.sym} 158940 -30020 0 0 {name=p157929 lab=_45808_/Y }
C {devices/lab_pin.sym} 158940 -29980 0 0 {name=p157930 lab=_45734_/X }
C {devices/lab_pin.sym} 158940 -29940 0 0 {name=p157931 lab=_45571_/X }
C {devices/lab_pin.sym} 158940 -29900 0 0 {name=p157932 lab=_45809_/Y }
C {devices/lab_pin.sym} 159100 -29960 0 1 {name=p157933 lab=_45810_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -29960 0 0 {name=X_45810_ }
C {devices/lab_pin.sym} 158980 -29810 0 0 {name=p157934 lab=_84915_/CLK }
C {devices/lab_pin.sym} 159060 -29810 0 1 {name=p157935 lab=_84883_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 159020 -29810 0 0 {name=Xclkbuf_opt_10_CLK }
C {devices/lab_pin.sym} 158940 -29710 0 0 {name=p157936 lab=_76595_/Y }
C {devices/lab_pin.sym} 158940 -29670 0 0 {name=p157937 lab=_76597_/X }
C {devices/lab_pin.sym} 158940 -29630 0 0 {name=p157938 lab=_76621_/X }
C {devices/lab_pin.sym} 159100 -29670 0 1 {name=p157939 lab=_76640_/B }
C {sky130_stdcells/a21o_4.sym} 159020 -29670 0 0 {name=X_76630_ }
C {devices/lab_pin.sym} 158960 -29540 0 0 {name=p157940 lab=_73842_/A }
C {devices/lab_pin.sym} 158960 -29500 0 0 {name=p157941 lab=_73649_/X }
C {devices/lab_pin.sym} 159080 -29520 0 1 {name=p157942 lab=_73842_/Y }
C {sky130_stdcells/nor2_4.sym} 159020 -29520 0 0 {name=X_73842_ }
C {devices/lab_pin.sym} 158930 -29390 0 0 {name=p157943 lab=_86749_/CLK }
C {devices/lab_pin.sym} 158930 -29370 0 0 {name=p157944 lab=_52412_/Y }
C {devices/lab_pin.sym} 159110 -29390 0 1 {name=p157945 lab=_85828_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -29380 0 0 {name=X_85828_ }
C {devices/lab_pin.sym} 158980 -29250 0 0 {name=p157946 lab=_46790_/A }
C {devices/lab_pin.sym} 159060 -29250 0 1 {name=p157947 lab=_46790_/Y }
C {sky130_stdcells/inv_2.sym} 159020 -29250 0 0 {name=X_46790_ }
C {devices/lab_pin.sym} 158960 -29140 0 0 {name=p157948 lab=_58776_/A }
C {devices/lab_pin.sym} 158960 -29100 0 0 {name=p157949 lab=_58764_/B }
C {devices/lab_pin.sym} 159080 -29120 0 1 {name=p157950 lab=_58776_/Y }
C {sky130_stdcells/nor2_4.sym} 159020 -29120 0 0 {name=X_58776_ }
C {devices/lab_pin.sym} 158980 -28990 0 0 {name=p157951 lab=_55686_/Y }
C {devices/lab_pin.sym} 159060 -28990 0 1 {name=p157952 lab=_56104_/A }
C {sky130_stdcells/buf_2.sym} 159020 -28990 0 0 {name=X_55988_ }
C {devices/lab_pin.sym} 158940 -28900 0 0 {name=p157953 lab=_45738_/Y }
C {devices/lab_pin.sym} 158940 -28860 0 0 {name=p157954 lab=_45632_/X }
C {devices/lab_pin.sym} 158940 -28820 0 0 {name=p157955 lab=_45616_/X }
C {devices/lab_pin.sym} 158940 -28780 0 0 {name=p157956 lab=_45740_/Y }
C {devices/lab_pin.sym} 159100 -28840 0 1 {name=p157957 lab=_45741_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -28840 0 0 {name=X_45741_ }
C {devices/lab_pin.sym} 158940 -28710 0 0 {name=p157958 lab=_57712_/X }
C {devices/lab_pin.sym} 158940 -28670 0 0 {name=p157959 lab=_85728_/Q }
C {devices/lab_pin.sym} 158940 -28630 0 0 {name=p157960 lab=_44252_/X }
C {devices/lab_pin.sym} 159100 -28670 0 1 {name=p157961 lab=_57727_/X }
C {sky130_stdcells/o21a_4.sym} 159020 -28670 0 0 {name=X_57727_ }
C {devices/lab_pin.sym} 158960 -28540 0 0 {name=p157962 lab=_76559_/Y }
C {devices/lab_pin.sym} 158960 -28500 0 0 {name=p157963 lab=_76560_/Y }
C {devices/lab_pin.sym} 159080 -28520 0 1 {name=p157964 lab=_76584_/D }
C {sky130_stdcells/and2_4.sym} 159020 -28520 0 0 {name=X_76561_ }
C {devices/lab_pin.sym} 158940 -28420 0 0 {name=p157965 lab=_40331_/X }
C {devices/lab_pin.sym} 158940 -28380 0 0 {name=p157966 lab=_42950_/X }
C {devices/lab_pin.sym} 158940 -28340 0 0 {name=p157967 lab=_66598_/B }
C {devices/lab_pin.sym} 158940 -28300 0 0 {name=p157968 lab=_42951_/X }
C {devices/lab_pin.sym} 159100 -28360 0 1 {name=p157969 lab=_42953_/X }
C {sky130_stdcells/a2bb2o_4.sym} 159020 -28360 0 0 {name=X_42953_ }
C {devices/lab_pin.sym} 158960 -28220 0 0 {name=p157970 lab=_54919_/X }
C {devices/lab_pin.sym} 158960 -28180 0 0 {name=p157971 lab=_47788_/A }
C {devices/lab_pin.sym} 159080 -28200 0 1 {name=p157972 lab=_54939_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -28200 0 0 {name=X_54939_ }
C {devices/lab_pin.sym} 158960 -28080 0 0 {name=p157973 lab=_73773_/A }
C {devices/lab_pin.sym} 158960 -28040 0 0 {name=p157974 lab=_73599_/B }
C {devices/lab_pin.sym} 159080 -28060 0 1 {name=p157975 lab=_73773_/Y }
C {sky130_stdcells/nor2_4.sym} 159020 -28060 0 0 {name=X_73773_ }
C {devices/lab_pin.sym} 158930 -27930 0 0 {name=p157976 lab=_85761_/CLK }
C {devices/lab_pin.sym} 158930 -27910 0 0 {name=p157977 lab=_52764_/Y }
C {devices/lab_pin.sym} 159110 -27930 0 1 {name=p157978 lab=_85759_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -27920 0 0 {name=X_85759_ }
C {devices/lab_pin.sym} 158980 -27790 0 0 {name=p157979 lab=_70772_/A }
C {devices/lab_pin.sym} 159060 -27790 0 1 {name=p157980 lab=_70986_/A }
C {sky130_stdcells/buf_2.sym} 159020 -27790 0 0 {name=X_70985_ }
C {devices/lab_pin.sym} 158960 -27680 0 0 {name=p157981 lab=_78298_/B }
C {devices/lab_pin.sym} 158960 -27640 0 0 {name=p157982 lab=_78298_/A }
C {devices/lab_pin.sym} 159080 -27660 0 1 {name=p157983 lab=_78302_/A }
C {sky130_stdcells/nand2_4.sym} 159020 -27660 0 0 {name=X_78300_ }
C {devices/lab_pin.sym} 158940 -27550 0 0 {name=p157984 lab=_75438_/Y }
C {devices/lab_pin.sym} 158940 -27510 0 0 {name=p157985 lab=_75506_/X }
C {devices/lab_pin.sym} 158940 -27470 0 0 {name=p157986 lab=_75511_/Y }
C {devices/lab_pin.sym} 159100 -27510 0 1 {name=p157987 lab=_75538_/B }
C {sky130_stdcells/a21oi_4.sym} 159020 -27510 0 0 {name=X_75512_ }
C {devices/lab_pin.sym} 158980 -27370 0 0 {name=p157988 lab=_50638_/A }
C {devices/lab_pin.sym} 159060 -27370 0 1 {name=p157989 lab=_50523_/A }
C {sky130_stdcells/inv_2.sym} 159020 -27370 0 0 {name=X_41904_ }
C {devices/lab_pin.sym} 158980 -27250 0 0 {name=p157990 lab=_81784_/Q }
C {devices/lab_pin.sym} 159060 -27250 0 1 {name=p157991 lab=_48976_/B }
C {sky130_stdcells/inv_2.sym} 159020 -27250 0 0 {name=X_48460_ }
C {devices/lab_pin.sym} 158980 -27130 0 0 {name=p157992 lab=_45896_/X }
C {devices/lab_pin.sym} 159060 -27130 0 1 {name=p157993 lab=_72725_/A }
C {sky130_stdcells/buf_2.sym} 159020 -27130 0 0 {name=X_72724_ }
C {devices/lab_pin.sym} 158960 -27020 0 0 {name=p157994 lab=_79278_/X }
C {devices/lab_pin.sym} 158960 -26980 0 0 {name=p157995 lab=_79285_/B }
C {devices/lab_pin.sym} 159080 -27000 0 1 {name=p157996 lab=_79280_/Y }
C {sky130_stdcells/xnor2_4.sym} 159020 -27000 0 0 {name=X_79280_ }
C {devices/lab_pin.sym} 158980 -26870 0 0 {name=p157997 lab=_85071_/Q }
C {devices/lab_pin.sym} 159060 -26870 0 1 {name=p157998 lab=_45672_/Y }
C {sky130_stdcells/inv_2.sym} 159020 -26870 0 0 {name=X_45672_ }
C {devices/lab_pin.sym} 158940 -26770 0 0 {name=p157999 lab=_57650_/X }
C {devices/lab_pin.sym} 158940 -26730 0 0 {name=p158000 lab=_57655_/Y }
C {devices/lab_pin.sym} 158940 -26690 0 0 {name=p158001 lab=_57657_/Y }
C {devices/lab_pin.sym} 159100 -26730 0 1 {name=p158002 lab=_84960_/D }
C {sky130_stdcells/a21oi_4.sym} 159020 -26730 0 0 {name=X_57658_ }
C {devices/lab_pin.sym} 158940 -26610 0 0 {name=p158003 lab=_76491_/B }
C {devices/lab_pin.sym} 158940 -26570 0 0 {name=p158004 lab=_76491_/C }
C {devices/lab_pin.sym} 158940 -26530 0 0 {name=p158005 lab=_76487_/Y }
C {devices/lab_pin.sym} 159100 -26570 0 1 {name=p158006 lab=_76492_/Y }
C {sky130_stdcells/o21ai_4.sym} 159020 -26570 0 0 {name=X_76492_ }
C {devices/lab_pin.sym} 158940 -26470 0 0 {name=p158007 lab=_42874_/X }
C {devices/lab_pin.sym} 158940 -26430 0 0 {name=p158008 lab=_42875_/X }
C {devices/lab_pin.sym} 158940 -26390 0 0 {name=p158009 lab=_41621_/X }
C {devices/lab_pin.sym} 158940 -26350 0 0 {name=p158010 lab=_67294_/B }
C {devices/lab_pin.sym} 158940 -26310 0 0 {name=p158011 lab=_42881_/X }
C {devices/lab_pin.sym} 159100 -26390 0 1 {name=p158012 lab=_42885_/A }
C {sky130_stdcells/o32ai_4.sym} 159020 -26390 0 0 {name=X_42884_ }
C {devices/lab_pin.sym} 158980 -26230 0 0 {name=p158013 lab=_47411_/A }
C {devices/lab_pin.sym} 159060 -26230 0 1 {name=p158014 lab=_53033_/B }
C {sky130_stdcells/buf_2.sym} 159020 -26230 0 0 {name=X_47411_ }
C {devices/lab_pin.sym} 158960 -26120 0 0 {name=p158015 lab=_78231_/A }
C {devices/lab_pin.sym} 158960 -26080 0 0 {name=p158016 lab=_78231_/B }
C {devices/lab_pin.sym} 159080 -26100 0 1 {name=p158017 lab=_78231_/X }
C {sky130_stdcells/xor2_4.sym} 159020 -26100 0 0 {name=X_78231_ }
C {devices/lab_pin.sym} 158980 -25970 0 0 {name=p158018 lab=_44567_/A }
C {devices/lab_pin.sym} 159060 -25970 0 1 {name=p158019 lab=_44623_/X }
C {sky130_stdcells/buf_2.sym} 159020 -25970 0 0 {name=X_44623_ }
C {devices/lab_pin.sym} 158980 -25850 0 0 {name=p158020 lab=_56593_/A }
C {devices/lab_pin.sym} 159060 -25850 0 1 {name=p158021 lab=_56609_/X }
C {sky130_stdcells/buf_2.sym} 159020 -25850 0 0 {name=X_56609_ }
C {devices/lab_pin.sym} 158960 -25740 0 0 {name=p158022 lab=_75443_/A }
C {devices/lab_pin.sym} 158960 -25700 0 0 {name=p158023 lab=_80955_/D }
C {devices/lab_pin.sym} 159080 -25720 0 1 {name=p158024 lab=_75443_/Y }
C {sky130_stdcells/nor2_4.sym} 159020 -25720 0 0 {name=X_75443_ }
C {devices/lab_pin.sym} 158930 -25590 0 0 {name=p158025 lab=_86796_/CLK }
C {devices/lab_pin.sym} 158930 -25570 0 0 {name=p158026 lab=_43420_/X }
C {devices/lab_pin.sym} 159110 -25590 0 1 {name=p158027 lab=_87429_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -25580 0 0 {name=X_87429_ }
C {devices/lab_pin.sym} 158980 -25450 0 0 {name=p158028 lab=_40568_/A }
C {devices/lab_pin.sym} 159060 -25450 0 1 {name=p158029 lab=_41835_/X }
C {sky130_stdcells/buf_2.sym} 159020 -25450 0 0 {name=X_41835_ }
C {devices/lab_pin.sym} 158980 -25330 0 0 {name=p158030 lab=_48391_/A }
C {devices/lab_pin.sym} 159060 -25330 0 1 {name=p158031 lab=_48391_/X }
C {sky130_stdcells/buf_2.sym} 159020 -25330 0 0 {name=X_48391_ }
C {devices/lab_pin.sym} 158940 -25230 0 0 {name=p158032 lab=_83201_/Q }
C {devices/lab_pin.sym} 158940 -25190 0 0 {name=p158033 lab=_72645_/X }
C {devices/lab_pin.sym} 158940 -25150 0 0 {name=p158034 lab=_72654_/Y }
C {devices/lab_pin.sym} 159100 -25190 0 1 {name=p158035 lab=_83201_/D }
C {sky130_stdcells/a21bo_4.sym} 159020 -25190 0 0 {name=X_72655_ }
C {devices/lab_pin.sym} 158940 -25070 0 0 {name=p158036 lab=_57585_/Y }
C {devices/lab_pin.sym} 158940 -25030 0 0 {name=p158037 lab=_57506_/X }
C {devices/lab_pin.sym} 158940 -24990 0 0 {name=p158038 lab=_57588_/X }
C {devices/lab_pin.sym} 159100 -25030 0 1 {name=p158039 lab=_84974_/D }
C {sky130_stdcells/a21oi_4.sym} 159020 -25030 0 0 {name=X_57589_ }
C {devices/lab_pin.sym} 158940 -24910 0 0 {name=p158040 lab=_47337_/Y }
C {devices/lab_pin.sym} 158940 -24870 0 0 {name=p158041 lab=_47317_/X }
C {devices/lab_pin.sym} 158940 -24830 0 0 {name=p158042 lab=_47341_/X }
C {devices/lab_pin.sym} 159100 -24870 0 1 {name=p158043 lab=_86645_/D }
C {sky130_stdcells/a21oi_4.sym} 159020 -24870 0 0 {name=X_47342_ }
C {devices/lab_pin.sym} 158980 -24730 0 0 {name=p158044 lab=_71690_/A }
C {devices/lab_pin.sym} 159060 -24730 0 1 {name=p158045 lab=_71606_/X }
C {sky130_stdcells/buf_2.sym} 159020 -24730 0 0 {name=X_71606_ }
C {devices/lab_pin.sym} 158960 -24620 0 0 {name=p158046 lab=_86662_/Q }
C {devices/lab_pin.sym} 158960 -24580 0 0 {name=p158047 lab=_59306_/B }
C {devices/lab_pin.sym} 159080 -24600 0 1 {name=p158048 lab=_59328_/Y }
C {sky130_stdcells/nor2_4.sym} 159020 -24600 0 0 {name=X_59328_ }
C {devices/lab_pin.sym} 158960 -24490 0 0 {name=p158049 lab=_78152_/A }
C {devices/lab_pin.sym} 158960 -24450 0 0 {name=p158050 lab=_78154_/X }
C {devices/lab_pin.sym} 158960 -24410 0 0 {name=p158051 lab=_78162_/C }
C {devices/lab_pin.sym} 159080 -24450 0 1 {name=p158052 lab=_78162_/X }
C {sky130_stdcells/and3_4.sym} 159020 -24450 0 0 {name=X_78162_ }
C {devices/lab_pin.sym} 158980 -24310 0 0 {name=p158053 lab=_44529_/A }
C {devices/lab_pin.sym} 159060 -24310 0 1 {name=p158054 lab=_44554_/X }
C {sky130_stdcells/buf_2.sym} 159020 -24310 0 0 {name=X_44554_ }
C {devices/lab_pin.sym} 158940 -24210 0 0 {name=p158055 lab=_75362_/A }
C {devices/lab_pin.sym} 158940 -24170 0 0 {name=p158056 lab=_75372_/Y }
C {devices/lab_pin.sym} 158940 -24130 0 0 {name=p158057 lab=_75373_/Y }
C {devices/lab_pin.sym} 159100 -24170 0 1 {name=p158058 lab=_75383_/A }
C {sky130_stdcells/o21a_4.sym} 159020 -24170 0 0 {name=X_75374_ }
C {devices/lab_pin.sym} 158960 -24040 0 0 {name=p158059 lab=_82887_/Q }
C {devices/lab_pin.sym} 158960 -24000 0 0 {name=p158060 lab=_46240_/A }
C {devices/lab_pin.sym} 159080 -24020 0 1 {name=p158061 lab=_41766_/X }
C {sky130_stdcells/or2_4.sym} 159020 -24020 0 0 {name=X_41766_ }
C {devices/lab_pin.sym} 158940 -23920 0 0 {name=p158062 lab=_79363_/B }
C {devices/lab_pin.sym} 158940 -23880 0 0 {name=p158063 lab=_72445_/X }
C {devices/lab_pin.sym} 158940 -23840 0 0 {name=p158064 lab=_72583_/Y }
C {devices/lab_pin.sym} 158940 -23800 0 0 {name=p158065 lab=_72585_/Y }
C {devices/lab_pin.sym} 159100 -23860 0 1 {name=p158066 lab=_72586_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 159020 -23860 0 0 {name=X_72586_ }
C {devices/lab_pin.sym} 158960 -23720 0 0 {name=p158067 lab=_77113_/A }
C {devices/lab_pin.sym} 158960 -23680 0 0 {name=p158068 lab=_77113_/B }
C {devices/lab_pin.sym} 159080 -23700 0 1 {name=p158069 lab=_77113_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -23700 0 0 {name=X_77113_ }
C {devices/lab_pin.sym} 158980 -23570 0 0 {name=p158070 lab=_43505_/A }
C {devices/lab_pin.sym} 159060 -23570 0 1 {name=p158071 lab=_43505_/Y }
C {sky130_stdcells/inv_2.sym} 159020 -23570 0 0 {name=X_43505_ }
C {devices/lab_pin.sym} 158960 -23470 0 0 {name=p158072 lab=_74325_/A }
C {devices/lab_pin.sym} 158960 -23430 0 0 {name=p158073 lab=_74325_/B }
C {devices/lab_pin.sym} 158960 -23390 0 0 {name=p158074 lab=_56088_/X }
C {devices/lab_pin.sym} 159080 -23430 0 1 {name=p158075 lab=_74325_/Y }
C {sky130_stdcells/nand3_4.sym} 159020 -23430 0 0 {name=X_74325_ }
C {devices/lab_pin.sym} 158980 -23290 0 0 {name=p158076 lab=_48192_/A }
C {devices/lab_pin.sym} 159060 -23290 0 1 {name=p158077 lab=_40717_/X }
C {sky130_stdcells/buf_2.sym} 159020 -23290 0 0 {name=X_40717_ }
C {devices/lab_pin.sym} 158980 -23170 0 0 {name=p158078 lab=_81820_/Q }
C {devices/lab_pin.sym} 159060 -23170 0 1 {name=p158079 lab=_54645_/D }
C {sky130_stdcells/inv_2.sym} 159020 -23170 0 0 {name=X_47273_ }
C {devices/lab_pin.sym} 158940 -23090 0 0 {name=p158080 lab=_59253_/X }
C {devices/lab_pin.sym} 158940 -23050 0 0 {name=p158081 lab=_59256_/Y }
C {devices/lab_pin.sym} 158940 -23010 0 0 {name=p158082 lab=_59257_/Y }
C {devices/lab_pin.sym} 158940 -22970 0 0 {name=p158083 lab=_59133_/X }
C {devices/lab_pin.sym} 158940 -22930 0 0 {name=p158084 lab=_59258_/X }
C {devices/lab_pin.sym} 159100 -23010 0 1 {name=p158085 lab=_59259_/X }
C {sky130_stdcells/o32a_4.sym} 159020 -23010 0 0 {name=X_59259_ }
C {devices/lab_pin.sym} 158960 -22870 0 0 {name=p158086 lab=_70670_/A }
C {devices/lab_pin.sym} 158960 -22830 0 0 {name=p158087 lab=_71622_/D }
C {devices/lab_pin.sym} 158960 -22790 0 0 {name=p158088 lab=_71546_/C }
C {devices/lab_pin.sym} 159080 -22830 0 1 {name=p158089 lab=_71537_/Y }
C {sky130_stdcells/nor3_4.sym} 159020 -22830 0 0 {name=X_71537_ }
C {devices/lab_pin.sym} 158940 -22710 0 0 {name=p158090 lab=_78085_/A }
C {devices/lab_pin.sym} 158940 -22670 0 0 {name=p158091 lab=_78091_/Y }
C {devices/lab_pin.sym} 158940 -22630 0 0 {name=p158092 lab=_78092_/Y }
C {devices/lab_pin.sym} 159100 -22670 0 1 {name=p158093 lab=_78093_/Y }
C {sky130_stdcells/o21ai_4.sym} 159020 -22670 0 0 {name=X_78093_ }
C {devices/lab_pin.sym} 158940 -22570 0 0 {name=p158094 lab=_44481_/X }
C {devices/lab_pin.sym} 158940 -22530 0 0 {name=p158095 lab=_44482_/X }
C {devices/lab_pin.sym} 158940 -22490 0 0 {name=p158096 lab=_41209_/A }
C {devices/lab_pin.sym} 158940 -22450 0 0 {name=p158097 lab=_87085_/Q }
C {devices/lab_pin.sym} 158940 -22410 0 0 {name=p158098 lab=_44484_/X }
C {devices/lab_pin.sym} 159100 -22490 0 1 {name=p158099 lab=_44486_/A }
C {sky130_stdcells/o32ai_4.sym} 159020 -22490 0 0 {name=X_44485_ }
C {devices/lab_pin.sym} 158980 -22330 0 0 {name=p158100 lab=_41697_/A }
C {devices/lab_pin.sym} 159060 -22330 0 1 {name=p158101 lab=_41697_/X }
C {sky130_stdcells/buf_2.sym} 159020 -22330 0 0 {name=X_41697_ }
C {devices/lab_pin.sym} 158960 -22220 0 0 {name=p158102 lab=_49022_/A }
C {devices/lab_pin.sym} 158960 -22180 0 0 {name=p158103 lab=_53844_/B }
C {devices/lab_pin.sym} 159080 -22200 0 1 {name=p158104 lab=_49012_/X }
C {sky130_stdcells/and2_4.sym} 159020 -22200 0 0 {name=X_49012_ }
C {devices/lab_pin.sym} 158980 -22070 0 0 {name=p158105 lab=_57811_/A }
C {devices/lab_pin.sym} 159060 -22070 0 1 {name=p158106 lab=_46224_/X }
C {sky130_stdcells/buf_2.sym} 159020 -22070 0 0 {name=X_46224_ }
C {devices/lab_pin.sym} 158960 -21960 0 0 {name=p158107 lab=_82088_/Q }
C {devices/lab_pin.sym} 158960 -21920 0 0 {name=p158108 lab=_77044_/B }
C {devices/lab_pin.sym} 159080 -21940 0 1 {name=p158109 lab=_77044_/X }
C {sky130_stdcells/xor2_4.sym} 159020 -21940 0 0 {name=X_77044_ }
C {sky130_stdcells/decap_3.sym} 159020 -21780 0 0 {name=XPHY_360 }
C {devices/lab_pin.sym} 158980 -21630 0 0 {name=p158110 lab=_43435_/Y }
C {devices/lab_pin.sym} 159060 -21630 0 1 {name=p158111 lab=_87423_/D }
C {sky130_stdcells/inv_2.sym} 159020 -21630 0 0 {name=X_43436_ }
C {devices/lab_pin.sym} 158960 -21520 0 0 {name=p158112 lab=_74022_/X }
C {devices/lab_pin.sym} 158960 -21480 0 0 {name=p158113 lab=_86531_/Q }
C {devices/lab_pin.sym} 159080 -21500 0 1 {name=p158114 lab=_74256_/X }
C {sky130_stdcells/and2_4.sym} 159020 -21500 0 0 {name=X_74256_ }
C {devices/lab_pin.sym} 158980 -21370 0 0 {name=p158115 lab=_62269_/X }
C {devices/lab_pin.sym} 159060 -21370 0 1 {name=p158116 lab=_62304_/A }
C {sky130_stdcells/buf_2.sym} 159020 -21370 0 0 {name=X_62270_ }
C {devices/lab_pin.sym} 158960 -21260 0 0 {name=p158117 lab=_40648_/A }
C {devices/lab_pin.sym} 158960 -21220 0 0 {name=p158118 lab=_40588_/B }
C {devices/lab_pin.sym} 159080 -21240 0 1 {name=p158119 lab=_40648_/X }
C {sky130_stdcells/or2_4.sym} 159020 -21240 0 0 {name=X_40648_ }
C {sky130_stdcells/decap_3.sym} 159020 -21080 0 0 {name=XPHY_371 }
C {devices/lab_pin.sym} 158960 -20960 0 0 {name=p158120 lab=_70880_/B }
C {devices/lab_pin.sym} 158960 -20920 0 0 {name=p158121 lab=_71435_/B }
C {devices/lab_pin.sym} 158960 -20880 0 0 {name=p158122 lab=_70768_/A }
C {devices/lab_pin.sym} 158960 -20840 0 0 {name=p158123 lab=_71476_/D }
C {devices/lab_pin.sym} 159080 -20900 0 1 {name=p158124 lab=_71468_/X }
C {sky130_stdcells/and4_4.sym} 159020 -20900 0 0 {name=X_71468_ }
C {sky130_stdcells/decap_3.sym} 159020 -20720 0 0 {name=XPHY_382 }
C {sky130_stdcells/decap_3.sym} 159020 -20540 0 0 {name=XPHY_393 }
C {devices/lab_pin.sym} 158940 -20430 0 0 {name=p158125 lab=_61095_/X }
C {devices/lab_pin.sym} 158940 -20390 0 0 {name=p158126 lab=_61179_/A }
C {devices/lab_pin.sym} 158940 -20350 0 0 {name=p158127 lab=_61176_/B }
C {devices/lab_pin.sym} 158940 -20310 0 0 {name=p158128 lab=_64456_/C }
C {devices/lab_pin.sym} 158940 -20280 0 0 {name=p158129 lab=_65296_/A }
C {devices/lab_pin.sym} 159100 -20350 0 1 {name=p158130 lab=_61221_/Y }
C {sky130_stdcells/a41oi_4.sym} 159020 -20350 0 0 {name=X_61221_ }
C {devices/lab_pin.sym} 158960 -20200 0 0 {name=p158131 lab=_73206_/X }
C {devices/lab_pin.sym} 158960 -20160 0 0 {name=p158132 lab=_85872_/Q }
C {devices/lab_pin.sym} 159080 -20180 0 1 {name=p158133 lab=_73207_/X }
C {sky130_stdcells/and2_4.sym} 159020 -20180 0 0 {name=X_73207_ }
C {devices/lab_pin.sym} 158980 -20050 0 0 {name=p158134 lab=_46155_/A }
C {devices/lab_pin.sym} 159060 -20050 0 1 {name=p158135 lab=_46155_/X }
C {sky130_stdcells/buf_2.sym} 159020 -20050 0 0 {name=X_46155_ }
C {devices/lab_pin.sym} 158980 -19930 0 0 {name=p158136 lab=_70495_/A }
C {devices/lab_pin.sym} 159060 -19930 0 1 {name=p158137 lab=_71287_/C }
C {sky130_stdcells/buf_2.sym} 159020 -19930 0 0 {name=X_70419_ }
C {devices/lab_pin.sym} 158980 -19810 0 0 {name=p158138 lab=_43296_/A }
C {devices/lab_pin.sym} 159060 -19810 0 1 {name=p158139 lab=_43367_/X }
C {sky130_stdcells/buf_2.sym} 159020 -19810 0 0 {name=X_43367_ }
C {devices/lab_pin.sym} 158980 -19690 0 0 {name=p158140 lab=clkbuf_9_297_0_CLK/X }
C {devices/lab_pin.sym} 159060 -19690 0 1 {name=p158141 lab=_81059_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 159020 -19690 0 0 {name=Xclkbuf_10_594_0_CLK }
C {devices/lab_pin.sym} 158940 -19600 0 0 {name=p158142 lab=_43098_/Y }
C {devices/lab_pin.sym} 158940 -19560 0 0 {name=p158143 lab=_56273_/X }
C {devices/lab_pin.sym} 158940 -19520 0 0 {name=p158144 lab=_73035_/X }
C {devices/lab_pin.sym} 158940 -19480 0 0 {name=p158145 lab=_74186_/Y }
C {devices/lab_pin.sym} 159100 -19540 0 1 {name=p158146 lab=_74187_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -19540 0 0 {name=X_74187_ }
C {devices/lab_pin.sym} 158960 -19400 0 0 {name=p158147 lab=_40579_/A }
C {devices/lab_pin.sym} 158960 -19360 0 0 {name=p158148 lab=_40654_/B }
C {devices/lab_pin.sym} 159080 -19380 0 1 {name=p158149 lab=_40579_/X }
C {sky130_stdcells/or2_4.sym} 159020 -19380 0 0 {name=X_40579_ }
C {devices/lab_pin.sym} 158960 -19270 0 0 {name=p158150 lab=_70670_/A }
C {devices/lab_pin.sym} 158960 -19230 0 0 {name=p158151 lab=_71404_/B }
C {devices/lab_pin.sym} 158960 -19190 0 0 {name=p158152 lab=_71399_/C }
C {devices/lab_pin.sym} 159080 -19230 0 1 {name=p158153 lab=_71399_/Y }
C {sky130_stdcells/nor3_4.sym} 159020 -19230 0 0 {name=X_71399_ }
C {devices/lab_pin.sym} 158940 -19110 0 0 {name=p158154 lab=_55870_/B }
C {devices/lab_pin.sym} 158940 -19070 0 0 {name=p158155 lab=_45044_/X }
C {devices/lab_pin.sym} 158940 -19030 0 0 {name=p158156 lab=_45079_/X }
C {devices/lab_pin.sym} 159100 -19070 0 1 {name=p158157 lab=_45106_/X }
C {sky130_stdcells/o21a_4.sym} 159020 -19070 0 0 {name=X_45106_ }
C {devices/lab_pin.sym} 158980 -18930 0 0 {name=p158158 lab=_41878_/A }
C {devices/lab_pin.sym} 159060 -18930 0 1 {name=p158159 lab=_42397_/A }
C {sky130_stdcells/buf_2.sym} 159020 -18930 0 0 {name=X_42318_ }
C {devices/lab_pin.sym} 158980 -18810 0 0 {name=p158160 lab=_64523_/D }
C {devices/lab_pin.sym} 159060 -18810 0 1 {name=p158161 lab=_61153_/C }
C {sky130_stdcells/buf_2.sym} 159020 -18810 0 0 {name=X_61152_ }
C {devices/lab_pin.sym} 158960 -18700 0 0 {name=p158162 lab=_73239_/A }
C {devices/lab_pin.sym} 158960 -18660 0 0 {name=p158163 lab=_86515_/Q }
C {devices/lab_pin.sym} 159080 -18680 0 1 {name=p158164 lab=_73138_/X }
C {sky130_stdcells/and2_4.sym} 159020 -18680 0 0 {name=X_73138_ }
C {devices/lab_pin.sym} 158980 -18550 0 0 {name=p158165 lab=_46129_/A }
C {devices/lab_pin.sym} 159060 -18550 0 1 {name=p158166 lab=_46151_/B }
C {sky130_stdcells/inv_2.sym} 159020 -18550 0 0 {name=X_46086_ }
C {devices/lab_pin.sym} 158980 -18430 0 0 {name=p158167 lab=_43298_/A }
C {devices/lab_pin.sym} 159060 -18430 0 1 {name=p158168 lab=_43298_/Y }
C {sky130_stdcells/inv_2.sym} 159020 -18430 0 0 {name=X_43298_ }
C {devices/lab_pin.sym} 158980 -18310 0 0 {name=p158169 lab=_82647_/Q }
C {devices/lab_pin.sym} 159060 -18310 0 1 {name=p158170 lab=_78997_/A }
C {sky130_stdcells/inv_2.sym} 159020 -18310 0 0 {name=X_78995_ }
C {devices/lab_pin.sym} 158960 -18210 0 0 {name=p158171 lab=_60081_/A }
C {devices/lab_pin.sym} 158960 -18170 0 0 {name=p158172 lab=_60103_/B }
C {devices/lab_pin.sym} 158960 -18130 0 0 {name=p158173 lab=_60103_/C }
C {devices/lab_pin.sym} 159080 -18170 0 1 {name=p158174 lab=_60103_/Y }
C {sky130_stdcells/nor3_4.sym} 159020 -18170 0 0 {name=X_60103_ }
C {devices/lab_pin.sym} 158980 -18030 0 0 {name=p158175 lab=_51012_/A }
C {devices/lab_pin.sym} 159060 -18030 0 1 {name=p158176 lab=_49915_/A }
C {sky130_stdcells/buf_2.sym} 159020 -18030 0 0 {name=X_49914_ }
C {devices/lab_pin.sym} 158940 -17930 0 0 {name=p158177 lab=_45030_/X }
C {devices/lab_pin.sym} 158940 -17890 0 0 {name=p158178 lab=_45034_/Y }
C {devices/lab_pin.sym} 158940 -17850 0 0 {name=p158179 lab=_45036_/Y }
C {devices/lab_pin.sym} 159100 -17890 0 1 {name=p158180 lab=_45037_/Y }
C {sky130_stdcells/a21oi_4.sym} 159020 -17890 0 0 {name=X_45037_ }
C {devices/lab_pin.sym} 158980 -17750 0 0 {name=p158181 lab=_42259_/A }
C {devices/lab_pin.sym} 159060 -17750 0 1 {name=p158182 lab=_42249_/X }
C {sky130_stdcells/buf_2.sym} 159020 -17750 0 0 {name=X_42249_ }
C {devices/lab_pin.sym} 158940 -17660 0 0 {name=p158183 lab=_65300_/X }
C {devices/lab_pin.sym} 158940 -17620 0 0 {name=p158184 lab=_85629_/Q }
C {devices/lab_pin.sym} 158940 -17580 0 0 {name=p158185 lab=_65301_/X }
C {devices/lab_pin.sym} 158940 -17540 0 0 {name=p158186 lab=_65959_/X }
C {devices/lab_pin.sym} 159100 -17600 0 1 {name=p158187 lab=_65960_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -17600 0 0 {name=X_65960_ }
C {devices/lab_pin.sym} 158960 -17480 0 0 {name=p158188 lab=_64361_/A }
C {devices/lab_pin.sym} 158960 -17440 0 0 {name=p158189 lab=_61083_/B }
C {devices/lab_pin.sym} 158960 -17400 0 0 {name=p158190 lab=_61083_/C }
C {devices/lab_pin.sym} 158960 -17360 0 0 {name=p158191 lab=_61082_/X }
C {devices/lab_pin.sym} 159080 -17420 0 1 {name=p158192 lab=_64367_/A }
C {sky130_stdcells/nand4_4.sym} 159020 -17420 0 0 {name=X_61083_ }
C {devices/lab_pin.sym} 158980 -17270 0 0 {name=p158193 lab=_73516_/A }
C {devices/lab_pin.sym} 159060 -17270 0 1 {name=p158194 lab=_73239_/A }
C {sky130_stdcells/buf_2.sym} 159020 -17270 0 0 {name=X_73069_ }
C {devices/lab_pin.sym} 158980 -17150 0 0 {name=p158195 lab=_77946_/A }
C {devices/lab_pin.sym} 159060 -17150 0 1 {name=p158196 lab=_77946_/Y }
C {sky130_stdcells/inv_2.sym} 159020 -17150 0 0 {name=X_77946_ }
C {devices/lab_pin.sym} 158960 -17050 0 0 {name=p158197 lab=_64908_/X }
C {devices/lab_pin.sym} 158960 -17010 0 0 {name=p158198 lab=_64888_/B }
C {devices/lab_pin.sym} 158960 -16970 0 0 {name=p158199 lab=_64910_/X }
C {devices/lab_pin.sym} 159080 -17010 0 1 {name=p158200 lab=_64911_/Y }
C {sky130_stdcells/nand3_4.sym} 159020 -17010 0 0 {name=X_64911_ }
C {devices/lab_pin.sym} 158980 -16870 0 0 {name=p158201 lab=_64738_/A }
C {devices/lab_pin.sym} 159060 -16870 0 1 {name=p158202 lab=_60034_/X }
C {sky130_stdcells/buf_2.sym} 159020 -16870 0 0 {name=X_60034_ }
C {devices/lab_pin.sym} 158980 -16750 0 0 {name=p158203 lab=_49925_/A }
C {devices/lab_pin.sym} 159060 -16750 0 1 {name=p158204 lab=_49851_/A }
C {sky130_stdcells/buf_2.sym} 159020 -16750 0 0 {name=X_49845_ }
C {devices/lab_pin.sym} 158940 -16660 0 0 {name=p158205 lab=_65845_/X }
C {devices/lab_pin.sym} 158940 -16620 0 0 {name=p158206 lab=_86178_/Q }
C {devices/lab_pin.sym} 158940 -16580 0 0 {name=p158207 lab=_65790_/X }
C {devices/lab_pin.sym} 158940 -16540 0 0 {name=p158208 lab=_65890_/X }
C {devices/lab_pin.sym} 159100 -16600 0 1 {name=p158209 lab=_65891_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -16600 0 0 {name=X_65891_ }
C {devices/lab_pin.sym} 158940 -16480 0 0 {name=p158210 lab=_77863_/Y }
C {devices/lab_pin.sym} 158940 -16440 0 0 {name=p158211 lab=_77864_/Y }
C {devices/lab_pin.sym} 158940 -16400 0 0 {name=p158212 lab=_77851_/A }
C {devices/lab_pin.sym} 158940 -16360 0 0 {name=p158213 lab=_77866_/Y }
C {devices/lab_pin.sym} 159100 -16420 0 1 {name=p158214 lab=_77877_/X }
C {sky130_stdcells/a2bb2o_4.sym} 159020 -16420 0 0 {name=X_77877_ }
C {devices/lab_pin.sym} 158940 -16300 0 0 {name=p158215 lab=_87399_/Q }
C {devices/lab_pin.sym} 158940 -16260 0 0 {name=p158216 lab=_67628_/X }
C {devices/lab_pin.sym} 158940 -16220 0 0 {name=p158217 lab=_67581_/X }
C {devices/lab_pin.sym} 158940 -16180 0 0 {name=p158218 lab=_67629_/X }
C {devices/lab_pin.sym} 159100 -16240 0 1 {name=p158219 lab=_67630_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -16240 0 0 {name=X_67630_ }
C {devices/lab_pin.sym} 158960 -16100 0 0 {name=p158220 lab=_79614_/X }
C {devices/lab_pin.sym} 158960 -16060 0 0 {name=p158221 lab=_79615_/X }
C {devices/lab_pin.sym} 159080 -16080 0 1 {name=p158222 lab=_79616_/Y }
C {sky130_stdcells/xnor2_4.sym} 159020 -16080 0 0 {name=X_79616_ }
C {devices/lab_pin.sym} 158960 -15970 0 0 {name=p158223 lab=_64870_/A }
C {devices/lab_pin.sym} 158960 -15930 0 0 {name=p158224 lab=_64870_/B }
C {devices/lab_pin.sym} 158960 -15890 0 0 {name=p158225 lab=_64841_/Y }
C {devices/lab_pin.sym} 159080 -15930 0 1 {name=p158226 lab=_64842_/Y }
C {sky130_stdcells/nor3_4.sym} 159020 -15930 0 0 {name=X_64842_ }
C {devices/lab_pin.sym} 158960 -15800 0 0 {name=p158227 lab=_81670_/Q }
C {devices/lab_pin.sym} 158960 -15760 0 0 {name=p158228 lab=_76828_/B }
C {devices/lab_pin.sym} 159080 -15780 0 1 {name=p158229 lab=_76828_/Y }
C {sky130_stdcells/xnor2_4.sym} 159020 -15780 0 0 {name=X_76828_ }
C {devices/lab_pin.sym} 158980 -15650 0 0 {name=p158230 lab=_46612_/A }
C {devices/lab_pin.sym} 159060 -15650 0 1 {name=p158231 lab=_51012_/A }
C {sky130_stdcells/buf_2.sym} 159020 -15650 0 0 {name=X_49776_ }
C {devices/lab_pin.sym} 158980 -15530 0 0 {name=p158232 lab=_46941_/A }
C {devices/lab_pin.sym} 159060 -15530 0 1 {name=p158233 lab=_47029_/B }
C {sky130_stdcells/buf_2.sym} 159020 -15530 0 0 {name=X_46988_ }
C {devices/lab_pin.sym} 158980 -15410 0 0 {name=p158234 lab=_48790_/A }
C {devices/lab_pin.sym} 159060 -15410 0 1 {name=p158235 lab=_48761_/C }
C {sky130_stdcells/buf_2.sym} 159020 -15410 0 0 {name=X_48727_ }
C {devices/lab_pin.sym} 158980 -15290 0 0 {name=p158236 lab=_67203_/X }
C {devices/lab_pin.sym} 159060 -15290 0 1 {name=p158237 lab=_67561_/X }
C {sky130_stdcells/buf_2.sym} 159020 -15290 0 0 {name=X_67561_ }
C {devices/lab_pin.sym} 158960 -15180 0 0 {name=p158238 lab=_79547_/A }
C {devices/lab_pin.sym} 158960 -15140 0 0 {name=p158239 lab=_79546_/Y }
C {devices/lab_pin.sym} 159080 -15160 0 1 {name=p158240 lab=_79547_/Y }
C {sky130_stdcells/nor2_4.sym} 159020 -15160 0 0 {name=X_79547_ }
C {devices/lab_pin.sym} 158940 -15050 0 0 {name=p158241 lab=_45937_/Y }
C {devices/lab_pin.sym} 158940 -15010 0 0 {name=p158242 lab=_45938_/X }
C {devices/lab_pin.sym} 158940 -14970 0 0 {name=p158243 lab=_45935_/X }
C {devices/lab_pin.sym} 159100 -15010 0 1 {name=p158244 lab=_45939_/Y }
C {sky130_stdcells/a21oi_4.sym} 159020 -15010 0 0 {name=X_45939_ }
C {devices/lab_pin.sym} 158960 -14880 0 0 {name=p158245 lab=_64773_/A }
C {devices/lab_pin.sym} 158960 -14840 0 0 {name=p158246 lab=_86459_/Q }
C {devices/lab_pin.sym} 159080 -14860 0 1 {name=p158247 lab=_64773_/X }
C {sky130_stdcells/and2_4.sym} 159020 -14860 0 0 {name=X_64773_ }
C {devices/lab_pin.sym} 158980 -14730 0 0 {name=p158248 lab=_76747_/Y }
C {devices/lab_pin.sym} 159060 -14730 0 1 {name=p158249 lab=_81357_/D }
C {sky130_stdcells/inv_2.sym} 159020 -14730 0 0 {name=X_76759_ }
C {devices/lab_pin.sym} 158980 -14610 0 0 {name=p158250 lab=clkbuf_9_266_0_CLK/X }
C {devices/lab_pin.sym} 159060 -14610 0 1 {name=p158251 lab=_84087_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 159020 -14610 0 0 {name=Xclkbuf_10_532_0_CLK }
C {devices/lab_pin.sym} 158980 -14490 0 0 {name=p158252 lab=_61985_/A }
C {devices/lab_pin.sym} 159060 -14490 0 1 {name=p158253 lab=_63561_/B }
C {sky130_stdcells/buf_2.sym} 159020 -14490 0 0 {name=X_61985_ }
C {devices/lab_pin.sym} 158980 -14370 0 0 {name=p158254 lab=clkbuf_6_23_0_CLK/A }
C {devices/lab_pin.sym} 159060 -14370 0 1 {name=p158255 lab=clkbuf_7_47_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 159020 -14370 0 0 {name=Xclkbuf_6_23_0_CLK }
C {devices/lab_pin.sym} 158980 -14250 0 0 {name=p158256 lab=_69146_/A }
C {devices/lab_pin.sym} 159060 -14250 0 1 {name=p158257 lab=_69300_/X }
C {sky130_stdcells/buf_2.sym} 159020 -14250 0 0 {name=X_69300_ }
C {devices/lab_pin.sym} 158940 -14150 0 0 {name=p158258 lab=_60371_/X }
C {devices/lab_pin.sym} 158940 -14110 0 0 {name=p158259 lab=_66328_/Y }
C {devices/lab_pin.sym} 158940 -14070 0 0 {name=p158260 lab=_66511_/Y }
C {devices/lab_pin.sym} 159100 -14110 0 1 {name=p158261 lab=_66512_/Y }
C {sky130_stdcells/o21ai_4.sym} 159020 -14110 0 0 {name=X_66512_ }
C {devices/lab_pin.sym} 158980 -13970 0 0 {name=p158262 lab=_63724_/A }
C {devices/lab_pin.sym} 159060 -13970 0 1 {name=p158263 lab=_64192_/C }
C {sky130_stdcells/buf_2.sym} 159020 -13970 0 0 {name=X_63724_ }
C {devices/lab_pin.sym} 158940 -13870 0 0 {name=p158264 lab=_48650_/Y }
C {devices/lab_pin.sym} 158940 -13830 0 0 {name=p158265 lab=_48651_/X }
C {devices/lab_pin.sym} 158940 -13790 0 0 {name=p158266 lab=_48657_/X }
C {devices/lab_pin.sym} 159100 -13830 0 1 {name=p158267 lab=_48658_/Y }
C {sky130_stdcells/a21oi_4.sym} 159020 -13830 0 0 {name=X_48658_ }
C {devices/lab_pin.sym} 158980 -13690 0 0 {name=p158268 lab=_60935_/X }
C {devices/lab_pin.sym} 159060 -13690 0 1 {name=p158269 lab=_60937_/B }
C {sky130_stdcells/inv_2.sym} 159020 -13690 0 0 {name=X_60936_ }
C {devices/lab_pin.sym} 158940 -13590 0 0 {name=p158270 lab=_67489_/X }
C {devices/lab_pin.sym} 158940 -13550 0 0 {name=p158271 lab=_67491_/X }
C {devices/lab_pin.sym} 158940 -13510 0 0 {name=p158272 lab=_67401_/X }
C {devices/lab_pin.sym} 159100 -13550 0 1 {name=p158273 lab=_67492_/Y }
C {sky130_stdcells/a21oi_4.sym} 159020 -13550 0 0 {name=X_67492_ }
C {devices/lab_pin.sym} 158960 -13420 0 0 {name=p158274 lab=_79474_/Y }
C {devices/lab_pin.sym} 158960 -13380 0 0 {name=p158275 lab=_79496_/B }
C {devices/lab_pin.sym} 159080 -13400 0 1 {name=p158276 lab=_79505_/A }
C {sky130_stdcells/xor2_4.sym} 159020 -13400 0 0 {name=X_79478_ }
C {devices/lab_pin.sym} 158980 -13270 0 0 {name=p158277 lab=_68649_/A }
C {devices/lab_pin.sym} 159060 -13270 0 1 {name=p158278 lab=_69231_/X }
C {sky130_stdcells/buf_2.sym} 159020 -13270 0 0 {name=X_69231_ }
C {devices/lab_pin.sym} 158980 -13150 0 0 {name=p158279 lab=_47609_/A }
C {devices/lab_pin.sym} 159060 -13150 0 1 {name=p158280 lab=_47610_/A }
C {sky130_stdcells/inv_2.sym} 159020 -13150 0 0 {name=X_47609_ }
C {devices/lab_pin.sym} 158980 -13030 0 0 {name=p158281 lab=_66046_/A }
C {devices/lab_pin.sym} 159060 -13030 0 1 {name=p158282 lab=_66445_/A }
C {sky130_stdcells/buf_2.sym} 159020 -13030 0 0 {name=X_66443_ }
C {devices/lab_pin.sym} 158940 -12930 0 0 {name=p158283 lab=_78425_/Y }
C {devices/lab_pin.sym} 158940 -12890 0 0 {name=p158284 lab=_78369_/B }
C {devices/lab_pin.sym} 158940 -12850 0 0 {name=p158285 lab=_78428_/X }
C {devices/lab_pin.sym} 159100 -12890 0 1 {name=p158286 lab=_78429_/Y }
C {sky130_stdcells/o21ai_4.sym} 159020 -12890 0 0 {name=X_78429_ }
C {devices/lab_pin.sym} 158960 -12780 0 0 {name=p158287 lab=_63655_/A }
C {devices/lab_pin.sym} 158960 -12740 0 0 {name=p158288 lab=_63655_/B }
C {devices/lab_pin.sym} 158960 -12700 0 0 {name=p158289 lab=_63581_/X }
C {devices/lab_pin.sym} 158960 -12660 0 0 {name=p158290 lab=_63595_/D }
C {devices/lab_pin.sym} 159080 -12720 0 1 {name=p158291 lab=_63655_/X }
C {sky130_stdcells/and4_4.sym} 159020 -12720 0 0 {name=X_63655_ }
C {devices/lab_pin.sym} 158980 -12570 0 0 {name=p158292 lab=_48589_/A }
C {devices/lab_pin.sym} 159060 -12570 0 1 {name=p158293 lab=_52204_/A }
C {sky130_stdcells/buf_2.sym} 159020 -12570 0 0 {name=X_48589_ }
C {devices/lab_pin.sym} 158980 -12450 0 0 {name=p158294 lab=_60857_/X }
C {devices/lab_pin.sym} 159060 -12450 0 1 {name=p158295 lab=_60867_/Y }
C {sky130_stdcells/inv_2.sym} 159020 -12450 0 0 {name=X_60867_ }
C {sky130_stdcells/decap_3.sym} 159020 -12300 0 0 {name=XPHY_19 }
C {devices/lab_pin.sym} 158960 -12160 0 0 {name=p158296 lab=_50624_/A }
C {devices/lab_pin.sym} 158960 -12120 0 0 {name=p158297 lab=_72014_/B }
C {devices/lab_pin.sym} 159080 -12140 0 1 {name=p158298 lab=_50620_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -12140 0 0 {name=X_50620_ }
C {devices/lab_pin.sym} 158960 -12030 0 0 {name=p158299 lab=_62653_/A }
C {devices/lab_pin.sym} 158960 -11990 0 0 {name=p158300 lab=_62653_/B }
C {devices/lab_pin.sym} 158960 -11950 0 0 {name=p158301 lab=_62606_/C }
C {devices/lab_pin.sym} 159080 -11990 0 1 {name=p158302 lab=_62606_/Y }
C {sky130_stdcells/nor3_4.sym} 159020 -11990 0 0 {name=X_62606_ }
C {devices/lab_pin.sym} 158930 -11850 0 0 {name=p158303 lab=_81322_/CLK }
C {devices/lab_pin.sym} 158930 -11830 0 0 {name=p158304 lab=_81440_/D }
C {devices/lab_pin.sym} 159110 -11850 0 1 {name=p158305 lab=_76144_/B }
C {sky130_stdcells/dfxtp_4.sym} 159020 -11840 0 0 {name=X_81440_ }
C {devices/lab_pin.sym} 158980 -11710 0 0 {name=p158306 lab=_69162_/A }
C {devices/lab_pin.sym} 159060 -11710 0 1 {name=p158307 lab=_69162_/X }
C {sky130_stdcells/buf_2.sym} 159020 -11710 0 0 {name=X_69162_ }
C {devices/lab_pin.sym} 158980 -11590 0 0 {name=p158308 lab=clkbuf_9_273_0_CLK/X }
C {devices/lab_pin.sym} 159060 -11590 0 1 {name=p158309 lab=_84003_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 159020 -11590 0 0 {name=Xclkbuf_10_547_0_CLK }
C {devices/lab_pin.sym} 158940 -11490 0 0 {name=p158310 lab=_66372_/Y }
C {devices/lab_pin.sym} 158940 -11450 0 0 {name=p158311 lab=_66343_/X }
C {devices/lab_pin.sym} 158940 -11410 0 0 {name=p158312 lab=_66373_/X }
C {devices/lab_pin.sym} 159100 -11450 0 1 {name=p158313 lab=_84135_/D }
C {sky130_stdcells/a21o_4.sym} 159020 -11450 0 0 {name=X_66374_ }
C {devices/lab_pin.sym} 158980 -11310 0 0 {name=p158314 lab=clkbuf_6_39_0_CLK/A }
C {devices/lab_pin.sym} 159060 -11310 0 1 {name=p158315 lab=clkbuf_7_77_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 159020 -11310 0 0 {name=Xclkbuf_6_38_0_CLK }
C {devices/lab_pin.sym} 158960 -11210 0 0 {name=p158316 lab=_63586_/A }
C {devices/lab_pin.sym} 158960 -11170 0 0 {name=p158317 lab=_63630_/B }
C {devices/lab_pin.sym} 158960 -11130 0 0 {name=p158318 lab=_63630_/C }
C {devices/lab_pin.sym} 159080 -11170 0 1 {name=p158319 lab=_63586_/Y }
C {sky130_stdcells/nor3_4.sym} 159020 -11170 0 0 {name=X_63586_ }
C {devices/lab_pin.sym} 158980 -11030 0 0 {name=p158320 lab=_63375_/A }
C {devices/lab_pin.sym} 159060 -11030 0 1 {name=p158321 lab=_60798_/X }
C {sky130_stdcells/buf_2.sym} 159020 -11030 0 0 {name=X_60798_ }
C {devices/lab_pin.sym} 158940 -10930 0 0 {name=p158322 lab=_82076_/D }
C {devices/lab_pin.sym} 158940 -10890 0 0 {name=p158323 lab=_68101_/X }
C {devices/lab_pin.sym} 158940 -10850 0 0 {name=p158324 lab=_68112_/X }
C {devices/lab_pin.sym} 159100 -10890 0 1 {name=p158325 lab=_68113_/X }
C {sky130_stdcells/a21bo_4.sym} 159020 -10890 0 0 {name=X_68113_ }
C {devices/lab_pin.sym} 158940 -10780 0 0 {name=p158326 lab=_65199_/X }
C {devices/lab_pin.sym} 158940 -10740 0 0 {name=p158327 lab=_86149_/Q }
C {devices/lab_pin.sym} 158940 -10700 0 0 {name=p158328 lab=_65224_/X }
C {devices/lab_pin.sym} 158940 -10660 0 0 {name=p158329 lab=_65324_/X }
C {devices/lab_pin.sym} 159100 -10720 0 1 {name=p158330 lab=_65325_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -10720 0 0 {name=X_65325_ }
C {devices/lab_pin.sym} 158980 -10570 0 0 {name=p158331 lab=_50551_/A }
C {devices/lab_pin.sym} 159060 -10570 0 1 {name=p158332 lab=_50551_/X }
C {sky130_stdcells/buf_2.sym} 159020 -10570 0 0 {name=X_50551_ }
C {devices/lab_pin.sym} 158960 -10480 0 0 {name=p158333 lab=_62570_/A }
C {devices/lab_pin.sym} 158960 -10440 0 0 {name=p158334 lab=_63629_/B }
C {devices/lab_pin.sym} 158960 -10400 0 0 {name=p158335 lab=_62601_/C }
C {devices/lab_pin.sym} 158960 -10360 0 0 {name=p158336 lab=_62463_/X }
C {devices/lab_pin.sym} 159080 -10420 0 1 {name=p158337 lab=_62537_/X }
C {sky130_stdcells/and4_4.sym} 159020 -10420 0 0 {name=X_62537_ }
C {devices/lab_pin.sym} 158930 -10270 0 0 {name=p158338 lab=_81344_/CLK }
C {devices/lab_pin.sym} 158930 -10250 0 0 {name=p158339 lab=_76963_/Y }
C {devices/lab_pin.sym} 159110 -10270 0 1 {name=p158340 lab=_81371_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -10260 0 0 {name=X_81371_ }
C {devices/lab_pin.sym} 158940 -10160 0 0 {name=p158341 lab=_44747_/A }
C {devices/lab_pin.sym} 158940 -10120 0 0 {name=p158342 lab=_68570_/X }
C {devices/lab_pin.sym} 158940 -10080 0 0 {name=p158343 lab=_68571_/X }
C {devices/lab_pin.sym} 158940 -10040 0 0 {name=p158344 lab=_69092_/X }
C {devices/lab_pin.sym} 159100 -10100 0 1 {name=p158345 lab=_69093_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -10100 0 0 {name=X_69093_ }
C {devices/lab_pin.sym} 158930 -9950 0 0 {name=p158346 lab=_82998_/CLK }
C {devices/lab_pin.sym} 158930 -9930 0 0 {name=p158347 lab=_74294_/X }
C {devices/lab_pin.sym} 159110 -9950 0 1 {name=p158348 lab=_70275_/C }
C {sky130_stdcells/dfxtp_4.sym} 159020 -9940 0 0 {name=X_83110_ }
C {devices/lab_pin.sym} 158960 -9820 0 0 {name=p158349 lab=_80320_/Y }
C {devices/lab_pin.sym} 158960 -9780 0 0 {name=p158350 lab=_80322_/B }
C {devices/lab_pin.sym} 159080 -9800 0 1 {name=p158351 lab=_80322_/X }
C {sky130_stdcells/xor2_4.sym} 159020 -9800 0 0 {name=X_80322_ }
C {devices/lab_pin.sym} 158960 -9680 0 0 {name=p158352 lab=_68044_/A }
C {devices/lab_pin.sym} 158960 -9640 0 0 {name=p158353 lab=_68044_/B }
C {devices/lab_pin.sym} 159080 -9660 0 1 {name=p158354 lab=_68044_/X }
C {sky130_stdcells/and2_4.sym} 159020 -9660 0 0 {name=X_68044_ }
C {devices/lab_pin.sym} 158960 -9540 0 0 {name=p158355 lab=_53276_/A }
C {devices/lab_pin.sym} 158960 -9500 0 0 {name=p158356 lab=_54446_/B }
C {devices/lab_pin.sym} 159080 -9520 0 1 {name=p158357 lab=_53270_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -9520 0 0 {name=X_53270_ }
C {devices/lab_pin.sym} 158980 -9390 0 0 {name=p158358 lab=_65790_/A }
C {devices/lab_pin.sym} 159060 -9390 0 1 {name=p158359 lab=_65256_/X }
C {sky130_stdcells/buf_2.sym} 159020 -9390 0 0 {name=X_65256_ }
C {devices/lab_pin.sym} 158930 -9270 0 0 {name=p158360 lab=_83932_/CLK }
C {devices/lab_pin.sym} 158930 -9250 0 0 {name=p158361 lab=_66946_/X }
C {devices/lab_pin.sym} 159110 -9270 0 1 {name=p158362 lab=_80914_/D }
C {sky130_stdcells/dfxtp_4.sym} 159020 -9260 0 0 {name=X_84090_ }
C {devices/lab_pin.sym} 158940 -9150 0 0 {name=p158363 lab=_86192_/Q }
C {devices/lab_pin.sym} 158940 -9110 0 0 {name=p158364 lab=_50387_/X }
C {devices/lab_pin.sym} 158940 -9070 0 0 {name=p158365 lab=_50481_/Y }
C {devices/lab_pin.sym} 159100 -9110 0 1 {name=p158366 lab=_50482_/Y }
C {sky130_stdcells/o21ai_4.sym} 159020 -9110 0 0 {name=X_50482_ }
C {devices/lab_pin.sym} 158960 -8990 0 0 {name=p158367 lab=_62411_/X }
C {devices/lab_pin.sym} 158960 -8950 0 0 {name=p158368 lab=_62412_/X }
C {devices/lab_pin.sym} 158960 -8910 0 0 {name=p158369 lab=_76984_/B }
C {devices/lab_pin.sym} 159080 -8950 0 1 {name=p158370 lab=_62468_/Y }
C {sky130_stdcells/nor3_4.sym} 159020 -8950 0 0 {name=X_62468_ }
C {devices/lab_pin.sym} 158940 -8830 0 0 {name=p158371 lab=_85865_/Q }
C {devices/lab_pin.sym} 158940 -8790 0 0 {name=p158372 lab=_52214_/X }
C {devices/lab_pin.sym} 158940 -8750 0 0 {name=p158373 lab=_52220_/Y }
C {devices/lab_pin.sym} 159100 -8790 0 1 {name=p158374 lab=_52221_/Y }
C {sky130_stdcells/o21ai_4.sym} 159020 -8790 0 0 {name=X_52221_ }
C {devices/lab_pin.sym} 158980 -8650 0 0 {name=p158375 lab=_64207_/A }
C {devices/lab_pin.sym} 159060 -8650 0 1 {name=p158376 lab=_64545_/C }
C {sky130_stdcells/buf_2.sym} 159020 -8650 0 0 {name=X_64207_ }
C {devices/lab_pin.sym} 158930 -8530 0 0 {name=p158377 lab=_82993_/CLK }
C {devices/lab_pin.sym} 158930 -8510 0 0 {name=p158378 lab=_83041_/D }
C {devices/lab_pin.sym} 159110 -8530 0 1 {name=p158379 lab=_74541_/C }
C {sky130_stdcells/dfxtp_4.sym} 159020 -8520 0 0 {name=X_83041_ }
C {devices/lab_pin.sym} 158980 -8390 0 0 {name=p158380 lab=_84850_/Q }
C {devices/lab_pin.sym} 159060 -8390 0 1 {name=p158381 lab=_61419_/X }
C {sky130_stdcells/buf_2.sym} 159020 -8390 0 0 {name=X_61419_ }
C {devices/lab_pin.sym} 158960 -8280 0 0 {name=p158382 lab=_84953_/Q }
C {devices/lab_pin.sym} 158960 -8240 0 0 {name=p158383 lab=_84201_/Q }
C {devices/lab_pin.sym} 159080 -8260 0 1 {name=p158384 lab=_80253_/X }
C {sky130_stdcells/xor2_4.sym} 159020 -8260 0 0 {name=X_80253_ }
C {devices/lab_pin.sym} 158940 -8160 0 0 {name=p158385 lab=_65059_/X }
C {devices/lab_pin.sym} 158940 -8120 0 0 {name=p158386 lab=_85547_/Q }
C {devices/lab_pin.sym} 158940 -8080 0 0 {name=p158387 lab=_65060_/X }
C {devices/lab_pin.sym} 158940 -8040 0 0 {name=p158388 lab=_65186_/X }
C {devices/lab_pin.sym} 159100 -8100 0 1 {name=p158389 lab=_65187_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -8100 0 0 {name=X_65187_ }
C {devices/lab_pin.sym} 158960 -7980 0 0 {name=p158390 lab=_62344_/X }
C {devices/lab_pin.sym} 158960 -7940 0 0 {name=p158391 lab=_57672_/X }
C {devices/lab_pin.sym} 158960 -7900 0 0 {name=p158392 lab=_62565_/C }
C {devices/lab_pin.sym} 158960 -7860 0 0 {name=p158393 lab=_62355_/X }
C {devices/lab_pin.sym} 159080 -7920 0 1 {name=p158394 lab=_62399_/X }
C {sky130_stdcells/and4_4.sym} 159020 -7920 0 0 {name=X_62399_ }
C {devices/lab_pin.sym} 158980 -7770 0 0 {name=p158395 lab=_52152_/A }
C {devices/lab_pin.sym} 159060 -7770 0 1 {name=p158396 lab=_52152_/X }
C {sky130_stdcells/buf_2.sym} 159020 -7770 0 0 {name=X_52152_ }
C {devices/lab_pin.sym} 158980 -7650 0 0 {name=p158397 lab=_60034_/X }
C {devices/lab_pin.sym} 159060 -7650 0 1 {name=p158398 lab=_64187_/A }
C {sky130_stdcells/buf_2.sym} 159020 -7650 0 0 {name=X_64138_ }
C {devices/lab_pin.sym} 158940 -7550 0 0 {name=p158399 lab=_80176_/A }
C {devices/lab_pin.sym} 158940 -7510 0 0 {name=p158400 lab=_80175_/X }
C {devices/lab_pin.sym} 158940 -7470 0 0 {name=p158401 lab=_80183_/Y }
C {devices/lab_pin.sym} 159100 -7510 0 1 {name=p158402 lab=_80184_/Y }
C {sky130_stdcells/a21boi_4.sym} 159020 -7510 0 0 {name=X_80184_ }
C {devices/lab_pin.sym} 158940 -7390 0 0 {name=p158403 lab=_69625_/X }
C {devices/lab_pin.sym} 158940 -7350 0 0 {name=p158404 lab=_69628_/X }
C {devices/lab_pin.sym} 158940 -7310 0 0 {name=p158405 lab=_69994_/X }
C {devices/lab_pin.sym} 159100 -7350 0 1 {name=p158406 lab=_69995_/X }
C {sky130_stdcells/a21o_4.sym} 159020 -7350 0 0 {name=X_69995_ }
C {devices/lab_pin.sym} 158960 -7220 0 0 {name=p158407 lab=_51112_/A }
C {devices/lab_pin.sym} 158960 -7180 0 0 {name=p158408 lab=_52794_/B }
C {devices/lab_pin.sym} 159080 -7200 0 1 {name=p158409 lab=_51103_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -7200 0 0 {name=X_51103_ }
C {devices/lab_pin.sym} 158930 -7070 0 0 {name=p158410 lab=_87073_/CLK }
C {devices/lab_pin.sym} 158930 -7050 0 0 {name=p158411 lab=_46038_/Y }
C {devices/lab_pin.sym} 159110 -7070 0 1 {name=p158412 lab=_86800_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -7060 0 0 {name=X_86800_ }
C {devices/lab_pin.sym} 158960 -6940 0 0 {name=p158413 lab=_52083_/A }
C {devices/lab_pin.sym} 158960 -6900 0 0 {name=p158414 lab=_50381_/B }
C {devices/lab_pin.sym} 159080 -6920 0 1 {name=p158415 lab=_52083_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -6920 0 0 {name=X_52083_ }
C {devices/lab_pin.sym} 158980 -6790 0 0 {name=p158416 lab=_56774_/A }
C {devices/lab_pin.sym} 159060 -6790 0 1 {name=p158417 lab=_56960_/X }
C {sky130_stdcells/buf_2.sym} 159020 -6790 0 0 {name=X_56960_ }
C {devices/lab_pin.sym} 158940 -6690 0 0 {name=p158418 lab=_68942_/X }
C {devices/lab_pin.sym} 158940 -6650 0 0 {name=p158419 lab=_68945_/X }
C {devices/lab_pin.sym} 158940 -6610 0 0 {name=p158420 lab=_68922_/X }
C {devices/lab_pin.sym} 159100 -6650 0 1 {name=p158421 lab=_68946_/X }
C {sky130_stdcells/a21o_4.sym} 159020 -6650 0 0 {name=X_68946_ }
C {devices/lab_pin.sym} 158960 -6540 0 0 {name=p158422 lab=_61570_/B }
C {devices/lab_pin.sym} 158960 -6500 0 0 {name=p158423 lab=_64161_/B }
C {devices/lab_pin.sym} 158960 -6460 0 0 {name=p158424 lab=_64150_/C }
C {devices/lab_pin.sym} 158960 -6420 0 0 {name=p158425 lab=_64161_/D }
C {devices/lab_pin.sym} 159080 -6480 0 1 {name=p158426 lab=_64069_/Y }
C {sky130_stdcells/nand4_4.sym} 159020 -6480 0 0 {name=X_64069_ }
C {devices/lab_pin.sym} 158930 -6330 0 0 {name=p158427 lab=_87782_/CLK }
C {devices/lab_pin.sym} 158930 -6310 0 0 {name=p158428 lab=_42668_/Y }
C {devices/lab_pin.sym} 159110 -6330 0 1 {name=p158429 lab=_87780_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -6320 0 0 {name=X_87780_ }
C {devices/lab_pin.sym} 158930 -6190 0 0 {name=p158430 lab=_85920_/CLK }
C {devices/lab_pin.sym} 158930 -6170 0 0 {name=p158431 lab=_84992_/D }
C {devices/lab_pin.sym} 159110 -6190 0 1 {name=p158432 lab=_84992_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -6180 0 0 {name=X_84992_ }
C {devices/lab_pin.sym} 158980 -6050 0 0 {name=p158433 lab=_51141_/A }
C {devices/lab_pin.sym} 159060 -6050 0 1 {name=p158434 lab=_51045_/C }
C {sky130_stdcells/buf_2.sym} 159020 -6050 0 0 {name=X_51034_ }
C {devices/lab_pin.sym} 158940 -5960 0 0 {name=p158435 lab=_85208_/Q }
C {devices/lab_pin.sym} 158940 -5920 0 0 {name=p158436 lab=_55617_/A }
C {devices/lab_pin.sym} 158940 -5880 0 0 {name=p158437 lab=_55627_/X }
C {devices/lab_pin.sym} 158940 -5840 0 0 {name=p158438 lab=_55910_/X }
C {devices/lab_pin.sym} 159100 -5900 0 1 {name=p158439 lab=_55911_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -5900 0 0 {name=X_55911_ }
C {devices/lab_pin.sym} 158930 -5750 0 0 {name=p158440 lab=_86733_/CLK }
C {devices/lab_pin.sym} 158930 -5730 0 0 {name=p158441 lab=_86731_/D }
C {devices/lab_pin.sym} 159110 -5750 0 1 {name=p158442 lab=_86731_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -5740 0 0 {name=X_86731_ }
C {devices/lab_pin.sym} 158930 -5610 0 0 {name=p158443 lab=_81351_/CLK }
C {devices/lab_pin.sym} 158930 -5590 0 0 {name=p158444 lab=_69175_/X }
C {devices/lab_pin.sym} 159110 -5610 0 1 {name=p158445 lab=_83943_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -5600 0 0 {name=X_83943_ }
C {devices/lab_pin.sym} 158940 -5490 0 0 {name=p158446 lab=_55662_/Y }
C {devices/lab_pin.sym} 158940 -5450 0 0 {name=p158447 lab=_56889_/X }
C {devices/lab_pin.sym} 158940 -5410 0 0 {name=p158448 lab=_56890_/Y }
C {devices/lab_pin.sym} 159100 -5450 0 1 {name=p158449 lab=_56892_/B }
C {sky130_stdcells/a21oi_4.sym} 159020 -5450 0 0 {name=X_56891_ }
C {devices/lab_pin.sym} 158940 -5340 0 0 {name=p158450 lab=_87083_/Q }
C {devices/lab_pin.sym} 158940 -5300 0 0 {name=p158451 lab=_68832_/X }
C {devices/lab_pin.sym} 158940 -5260 0 0 {name=p158452 lab=_68875_/X }
C {devices/lab_pin.sym} 158940 -5220 0 0 {name=p158453 lab=_68876_/X }
C {devices/lab_pin.sym} 159100 -5280 0 1 {name=p158454 lab=_68877_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -5280 0 0 {name=X_68877_ }
C {devices/lab_pin.sym} 158940 -5150 0 0 {name=p158455 lab=_58627_/Y }
C {devices/lab_pin.sym} 158940 -5110 0 0 {name=p158456 lab=_58629_/Y }
C {devices/lab_pin.sym} 158940 -5070 0 0 {name=p158457 lab=_58003_/X }
C {devices/lab_pin.sym} 159100 -5110 0 1 {name=p158458 lab=_58630_/X }
C {sky130_stdcells/a21o_4.sym} 159020 -5110 0 0 {name=X_58630_ }
C {devices/lab_pin.sym} 158940 -5000 0 0 {name=p158459 lab=_83025_/Q }
C {devices/lab_pin.sym} 158940 -4960 0 0 {name=p158460 lab=_55572_/X }
C {devices/lab_pin.sym} 158940 -4920 0 0 {name=p158461 lab=_55532_/X }
C {devices/lab_pin.sym} 158940 -4880 0 0 {name=p158462 lab=_55841_/X }
C {devices/lab_pin.sym} 159100 -4940 0 1 {name=p158463 lab=_55842_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -4940 0 0 {name=X_55842_ }
C {devices/lab_pin.sym} 158940 -4810 0 0 {name=p158464 lab=_67824_/X }
C {devices/lab_pin.sym} 158940 -4770 0 0 {name=p158465 lab=_67827_/X }
C {devices/lab_pin.sym} 158940 -4730 0 0 {name=p158466 lab=_67637_/X }
C {devices/lab_pin.sym} 159100 -4770 0 1 {name=p158467 lab=_67828_/Y }
C {sky130_stdcells/a21oi_4.sym} 159020 -4770 0 0 {name=X_67828_ }
C {devices/lab_pin.sym} 158930 -4630 0 0 {name=p158468 lab=_86665_/CLK }
C {devices/lab_pin.sym} 158930 -4610 0 0 {name=p158469 lab=_47182_/Y }
C {devices/lab_pin.sym} 159110 -4630 0 1 {name=p158470 lab=_86662_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -4620 0 0 {name=X_86662_ }
C {devices/lab_pin.sym} 158930 -4490 0 0 {name=p158471 lab=_82558_/CLK }
C {devices/lab_pin.sym} 158930 -4470 0 0 {name=p158472 lab=_70008_/X }
C {devices/lab_pin.sym} 159110 -4490 0 1 {name=p158473 lab=_83874_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -4480 0 0 {name=X_83874_ }
C {devices/lab_pin.sym} 158930 -4350 0 0 {name=p158474 lab=_87883_/CLK }
C {devices/lab_pin.sym} 158930 -4330 0 0 {name=p158475 lab=_40377_/Y }
C {devices/lab_pin.sym} 159110 -4350 0 1 {name=p158476 lab=_88401_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -4340 0 0 {name=X_88401_ }
C {devices/lab_pin.sym} 158930 -4210 0 0 {name=p158477 lab=_85601_/CLK }
C {devices/lab_pin.sym} 158930 -4190 0 0 {name=p158478 lab=_85613_/D }
C {devices/lab_pin.sym} 159110 -4210 0 1 {name=p158479 lab=_85613_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -4200 0 0 {name=X_85613_ }
C {devices/lab_pin.sym} 158980 -4070 0 0 {name=p158480 lab=_58984_/A }
C {devices/lab_pin.sym} 159060 -4070 0 1 {name=p158481 lab=_58973_/B }
C {sky130_stdcells/buf_2.sym} 159020 -4070 0 0 {name=X_58561_ }
C {devices/lab_pin.sym} 158930 -3950 0 0 {name=p158482 lab=_83238_/CLK }
C {devices/lab_pin.sym} 158930 -3930 0 0 {name=p158483 lab=_79263_/X }
C {devices/lab_pin.sym} 159110 -3950 0 1 {name=p158484 lab=_82825_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -3940 0 0 {name=X_82825_ }
C {devices/lab_pin.sym} 158960 -3840 0 0 {name=p158485 lab=_56117_/A }
C {devices/lab_pin.sym} 158960 -3800 0 0 {name=p158486 lab=_56117_/B }
C {devices/lab_pin.sym} 158960 -3760 0 0 {name=p158487 lab=_56117_/C }
C {devices/lab_pin.sym} 158960 -3720 0 0 {name=p158488 lab=_55773_/D }
C {devices/lab_pin.sym} 159080 -3780 0 1 {name=p158489 lab=_55801_/A }
C {sky130_stdcells/and4_4.sym} 159020 -3780 0 0 {name=X_55773_ }
C {devices/lab_pin.sym} 158940 -3660 0 0 {name=p158490 lab=_67496_/X }
C {devices/lab_pin.sym} 158940 -3620 0 0 {name=p158491 lab=_67746_/Y }
C {devices/lab_pin.sym} 158940 -3580 0 0 {name=p158492 lab=_67747_/X }
C {devices/lab_pin.sym} 158940 -3540 0 0 {name=p158493 lab=_67758_/Y }
C {devices/lab_pin.sym} 159100 -3600 0 1 {name=p158494 lab=_67759_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -3600 0 0 {name=X_67759_ }
C {devices/lab_pin.sym} 158930 -3450 0 0 {name=p158495 lab=_83161_/CLK }
C {devices/lab_pin.sym} 158930 -3430 0 0 {name=p158496 lab=_86593_/D }
C {devices/lab_pin.sym} 159110 -3450 0 1 {name=p158497 lab=_65908_/B }
C {sky130_stdcells/dfxtp_4.sym} 159020 -3440 0 0 {name=X_86593_ }
C {devices/lab_pin.sym} 158980 -3310 0 0 {name=p158498 lab=_52903_/X }
C {devices/lab_pin.sym} 159060 -3310 0 1 {name=p158499 lab=_52999_/A }
C {sky130_stdcells/buf_2.sym} 159020 -3310 0 0 {name=X_52985_ }
C {devices/lab_pin.sym} 158940 -3210 0 0 {name=p158500 lab=_57510_/Y }
C {devices/lab_pin.sym} 158940 -3170 0 0 {name=p158501 lab=_46576_/X }
C {devices/lab_pin.sym} 158940 -3130 0 0 {name=p158502 lab=_57511_/Y }
C {devices/lab_pin.sym} 159100 -3170 0 1 {name=p158503 lab=_84989_/D }
C {sky130_stdcells/a21boi_4.sym} 159020 -3170 0 0 {name=X_57512_ }
C {devices/lab_pin.sym} 158930 -3030 0 0 {name=p158504 lab=_84970_/CLK }
C {devices/lab_pin.sym} 158930 -3010 0 0 {name=p158505 lab=_88332_/D }
C {devices/lab_pin.sym} 159110 -3030 0 1 {name=p158506 lab=_88332_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -3020 0 0 {name=X_88332_ }
C {devices/lab_pin.sym} 158940 -2910 0 0 {name=p158507 lab=_85389_/Q }
C {devices/lab_pin.sym} 158940 -2870 0 0 {name=p158508 lab=_54703_/X }
C {devices/lab_pin.sym} 158940 -2830 0 0 {name=p158509 lab=_54723_/Y }
C {devices/lab_pin.sym} 159100 -2870 0 1 {name=p158510 lab=_54724_/Y }
C {sky130_stdcells/o21ai_4.sym} 159020 -2870 0 0 {name=X_54724_ }
C {devices/lab_pin.sym} 158930 -2730 0 0 {name=p158511 lab=_86145_/CLK }
C {devices/lab_pin.sym} 158930 -2710 0 0 {name=p158512 lab=_85544_/D }
C {devices/lab_pin.sym} 159110 -2730 0 1 {name=p158513 lab=_85544_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -2720 0 0 {name=X_85544_ }
C {devices/lab_pin.sym} 158980 -2590 0 0 {name=p158514 lab=_52407_/A }
C {devices/lab_pin.sym} 159060 -2590 0 1 {name=p158515 lab=_51941_/A }
C {sky130_stdcells/buf_2.sym} 159020 -2590 0 0 {name=X_51936_ }
C {devices/lab_pin.sym} 158940 -2490 0 0 {name=p158516 lab=_52843_/B }
C {devices/lab_pin.sym} 158940 -2450 0 0 {name=p158517 lab=_70761_/X }
C {devices/lab_pin.sym} 158940 -2410 0 0 {name=p158518 lab=_70769_/Y }
C {devices/lab_pin.sym} 159100 -2450 0 1 {name=p158519 lab=_70770_/Y }
C {sky130_stdcells/o21ai_4.sym} 159020 -2450 0 0 {name=X_70770_ }
C {devices/lab_pin.sym} 158930 -2310 0 0 {name=p158520 lab=_82768_/CLK }
C {devices/lab_pin.sym} 158930 -2290 0 0 {name=p158521 lab=_82756_/D }
C {devices/lab_pin.sym} 159110 -2310 0 1 {name=p158522 lab=_82948_/D }
C {sky130_stdcells/dfxtp_4.sym} 159020 -2300 0 0 {name=X_82756_ }
C {devices/lab_pin.sym} 158980 -2170 0 0 {name=p158523 lab=_58517_/A }
C {devices/lab_pin.sym} 159060 -2170 0 1 {name=p158524 lab=_58492_/X }
C {sky130_stdcells/buf_2.sym} 159020 -2170 0 0 {name=X_58492_ }
C {devices/lab_pin.sym} 158930 -2050 0 0 {name=p158525 lab=_81514_/CLK }
C {devices/lab_pin.sym} 158930 -2030 0 0 {name=p158526 lab=_81707_/D }
C {devices/lab_pin.sym} 159110 -2050 0 1 {name=p158527 lab=_41228_/A }
C {sky130_stdcells/dfxtp_4.sym} 159020 -2040 0 0 {name=X_81707_ }
C {devices/lab_pin.sym} 158960 -1920 0 0 {name=p158528 lab=_85003_/Q }
C {devices/lab_pin.sym} 158960 -1880 0 0 {name=p158529 lab=_57463_/B }
C {devices/lab_pin.sym} 159080 -1900 0 1 {name=p158530 lab=_57443_/X }
C {sky130_stdcells/or2_4.sym} 159020 -1900 0 0 {name=X_57443_ }
C {devices/lab_pin.sym} 158930 -1770 0 0 {name=p158531 lab=_88263_/CLK }
C {devices/lab_pin.sym} 158930 -1750 0 0 {name=p158532 lab=_41176_/Y }
C {devices/lab_pin.sym} 159110 -1770 0 1 {name=p158533 lab=_68686_/B }
C {sky130_stdcells/dfxtp_4.sym} 159020 -1760 0 0 {name=X_88263_ }
C {devices/lab_pin.sym} 158940 -1650 0 0 {name=p158534 lab=_69426_/X }
C {devices/lab_pin.sym} 158940 -1610 0 0 {name=p158535 lab=_69428_/X }
C {devices/lab_pin.sym} 158940 -1570 0 0 {name=p158536 lab=_69346_/X }
C {devices/lab_pin.sym} 159100 -1610 0 1 {name=p158537 lab=_69429_/X }
C {sky130_stdcells/a21o_4.sym} 159020 -1610 0 0 {name=X_69429_ }
C {devices/lab_pin.sym} 158940 -1490 0 0 {name=p158538 lab=_85402_/Q }
C {devices/lab_pin.sym} 158940 -1450 0 0 {name=p158539 lab=_54648_/X }
C {devices/lab_pin.sym} 158940 -1410 0 0 {name=p158540 lab=_54654_/Y }
C {devices/lab_pin.sym} 159100 -1450 0 1 {name=p158541 lab=_54655_/Y }
C {sky130_stdcells/o21ai_4.sym} 159020 -1450 0 0 {name=X_54655_ }
C {devices/lab_pin.sym} 158930 -1310 0 0 {name=p158542 lab=_84926_/CLK }
C {devices/lab_pin.sym} 158930 -1290 0 0 {name=p158543 lab=_85475_/D }
C {devices/lab_pin.sym} 159110 -1310 0 1 {name=p158544 lab=_85475_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -1300 0 0 {name=X_85475_ }
C {devices/lab_pin.sym} 158960 -1180 0 0 {name=p158545 lab=_51853_/A }
C {devices/lab_pin.sym} 158960 -1140 0 0 {name=p158546 lab=_51003_/B }
C {devices/lab_pin.sym} 159080 -1160 0 1 {name=p158547 lab=_51867_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -1160 0 0 {name=X_51867_ }
C {devices/lab_pin.sym} 158930 -1030 0 0 {name=p158548 lab=_84111_/CLK }
C {devices/lab_pin.sym} 158930 -1010 0 0 {name=p158549 lab=_82687_/D }
C {devices/lab_pin.sym} 159110 -1030 0 1 {name=p158550 lab=_82687_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -1020 0 0 {name=X_82687_ }
C {devices/lab_pin.sym} 158930 -890 0 0 {name=p158551 lab=_86934_/CLK }
C {devices/lab_pin.sym} 158930 -870 0 0 {name=p158552 lab=_87214_/D }
C {devices/lab_pin.sym} 159110 -890 0 1 {name=p158553 lab=_67453_/B }
C {sky130_stdcells/dfxtp_4.sym} 159020 -880 0 0 {name=X_87214_ }
C {devices/lab_pin.sym} 158940 -770 0 0 {name=p158554 lab=_41533_/X }
C {devices/lab_pin.sym} 158940 -730 0 0 {name=p158555 lab=_82307_/Q }
C {devices/lab_pin.sym} 158940 -690 0 0 {name=p158556 lab=_41619_/X }
C {devices/lab_pin.sym} 159100 -730 0 1 {name=p158557 lab=_41620_/X }
C {sky130_stdcells/o21a_4.sym} 159020 -730 0 0 {name=X_41620_ }
C {devices/lab_pin.sym} 159880 -42160 0 0 {name=p158558 lab=_53601_/A }
C {devices/lab_pin.sym} 159880 -42120 0 0 {name=p158559 lab=_48141_/A }
C {devices/lab_pin.sym} 160000 -42140 0 1 {name=p158560 lab=_53606_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -42140 0 0 {name=X_53606_ }
C {devices/lab_pin.sym} 159860 -42030 0 0 {name=p158561 lab=_72419_/X }
C {devices/lab_pin.sym} 159860 -41990 0 0 {name=p158562 lab=_85350_/Q }
C {devices/lab_pin.sym} 159860 -41950 0 0 {name=p158563 lab=_72439_/X }
C {devices/lab_pin.sym} 160020 -41990 0 1 {name=p158564 lab=_72440_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -41990 0 0 {name=X_72440_ }
C {devices/lab_pin.sym} 159850 -41850 0 0 {name=p158565 lab=_84426_/CLK }
C {devices/lab_pin.sym} 159850 -41830 0 0 {name=p158566 lab=_62192_/Y }
C {devices/lab_pin.sym} 160030 -41850 0 1 {name=p158567 lab=_78049_/B }
C {sky130_stdcells/dfxtp_4.sym} 159940 -41840 0 0 {name=X_84426_ }
C {devices/lab_pin.sym} 159900 -41710 0 0 {name=p158568 lab=_50595_/A }
C {devices/lab_pin.sym} 159980 -41710 0 1 {name=p158569 lab=_50991_/A }
C {sky130_stdcells/buf_2.sym} 159940 -41710 0 0 {name=X_50818_ }
C {devices/lab_pin.sym} 159900 -41590 0 0 {name=p158570 lab=_72910_/A }
C {devices/lab_pin.sym} 159980 -41590 0 1 {name=p158571 lab=_73040_/A }
C {sky130_stdcells/buf_2.sym} 159940 -41590 0 0 {name=X_57374_ }
C {devices/lab_pin.sym} 159850 -41470 0 0 {name=p158572 lab=_80912_/CLK }
C {devices/lab_pin.sym} 159850 -41450 0 0 {name=p158573 lab=_81670_/Q }
C {devices/lab_pin.sym} 160030 -41470 0 1 {name=p158574 lab=_81638_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -41460 0 0 {name=X_81638_ }
C {devices/lab_pin.sym} 159850 -41330 0 0 {name=p158575 lab=_87116_/CLK }
C {devices/lab_pin.sym} 159850 -41310 0 0 {name=p158576 lab=_88194_/D }
C {devices/lab_pin.sym} 160030 -41330 0 1 {name=p158577 lab=_88194_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -41320 0 0 {name=X_88194_ }
C {devices/lab_pin.sym} 159860 -41210 0 0 {name=p158578 lab=_54583_/Y }
C {devices/lab_pin.sym} 159860 -41170 0 0 {name=p158579 lab=_54584_/X }
C {devices/lab_pin.sym} 159860 -41130 0 0 {name=p158580 lab=_54585_/X }
C {devices/lab_pin.sym} 160020 -41170 0 1 {name=p158581 lab=_54586_/Y }
C {sky130_stdcells/a21oi_4.sym} 159940 -41170 0 0 {name=X_54586_ }
C {devices/lab_pin.sym} 159880 -41060 0 0 {name=p158582 lab=_51794_/A }
C {devices/lab_pin.sym} 159880 -41020 0 0 {name=p158583 lab=_51794_/B }
C {devices/lab_pin.sym} 159880 -40980 0 0 {name=p158584 lab=_51794_/C }
C {devices/lab_pin.sym} 159880 -40940 0 0 {name=p158585 lab=_46707_/X }
C {devices/lab_pin.sym} 160000 -41000 0 1 {name=p158586 lab=_51798_/X }
C {sky130_stdcells/and4_4.sym} 159940 -41000 0 0 {name=X_51798_ }
C {devices/lab_pin.sym} 159900 -40850 0 0 {name=p158587 lab=clkbuf_8_7_0_CLK/A }
C {devices/lab_pin.sym} 159980 -40850 0 1 {name=p158588 lab=clkbuf_8_6_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 159940 -40850 0 0 {name=Xclkbuf_8_6_0_CLK }
C {devices/lab_pin.sym} 159860 -40770 0 0 {name=p158589 lab=_58864_/X }
C {devices/lab_pin.sym} 159860 -40730 0 0 {name=p158590 lab=_59110_/Y }
C {devices/lab_pin.sym} 159860 -40690 0 0 {name=p158591 lab=_59112_/Y }
C {devices/lab_pin.sym} 159860 -40650 0 0 {name=p158592 lab=_58943_/X }
C {devices/lab_pin.sym} 159860 -40610 0 0 {name=p158593 lab=_58868_/X }
C {devices/lab_pin.sym} 160020 -40690 0 1 {name=p158594 lab=_59113_/X }
C {sky130_stdcells/o32a_4.sym} 159940 -40690 0 0 {name=X_59113_ }
C {devices/lab_pin.sym} 159900 -40530 0 0 {name=p158595 lab=_56351_/A }
C {devices/lab_pin.sym} 159980 -40530 0 1 {name=p158596 lab=_56335_/B }
C {sky130_stdcells/buf_2.sym} 159940 -40530 0 0 {name=X_56325_ }
C {devices/lab_pin.sym} 159850 -40410 0 0 {name=p158597 lab=_86920_/CLK }
C {devices/lab_pin.sym} 159850 -40390 0 0 {name=p158598 lab=_44367_/X }
C {devices/lab_pin.sym} 160030 -40410 0 1 {name=p158599 lab=_87145_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -40400 0 0 {name=X_87145_ }
C {devices/lab_pin.sym} 159900 -40270 0 0 {name=p158600 lab=_53982_/A }
C {devices/lab_pin.sym} 159980 -40270 0 1 {name=p158601 lab=_53537_/X }
C {sky130_stdcells/buf_2.sym} 159940 -40270 0 0 {name=X_53537_ }
C {devices/lab_pin.sym} 159860 -40170 0 0 {name=p158602 lab=_41548_/X }
C {devices/lab_pin.sym} 159860 -40130 0 0 {name=p158603 lab=_82320_/Q }
C {devices/lab_pin.sym} 159860 -40090 0 0 {name=p158604 lab=_41550_/X }
C {devices/lab_pin.sym} 160020 -40130 0 1 {name=p158605 lab=_41552_/A }
C {sky130_stdcells/o21ai_4.sym} 159940 -40130 0 0 {name=X_41551_ }
C {devices/lab_pin.sym} 159900 -39990 0 0 {name=p158606 lab=_83260_/Q }
C {devices/lab_pin.sym} 159980 -39990 0 1 {name=p158607 lab=_72371_/Y }
C {sky130_stdcells/inv_2.sym} 159940 -39990 0 0 {name=X_72371_ }
C {devices/lab_pin.sym} 159850 -39870 0 0 {name=p158608 lab=_84360_/CLK }
C {devices/lab_pin.sym} 159850 -39850 0 0 {name=p158609 lab=_63058_/X }
C {devices/lab_pin.sym} 160030 -39870 0 1 {name=p158610 lab=_79467_/A }
C {sky130_stdcells/dfxtp_4.sym} 159940 -39860 0 0 {name=X_84357_ }
C {devices/lab_pin.sym} 159860 -39750 0 0 {name=p158611 lab=_86141_/Q }
C {devices/lab_pin.sym} 159860 -39710 0 0 {name=p158612 lab=_50727_/X }
C {devices/lab_pin.sym} 159860 -39670 0 0 {name=p158613 lab=_50748_/Y }
C {devices/lab_pin.sym} 160020 -39710 0 1 {name=p158614 lab=_50749_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -39710 0 0 {name=X_50749_ }
C {devices/lab_pin.sym} 159850 -39570 0 0 {name=p158615 lab=_83940_/CLK }
C {devices/lab_pin.sym} 159850 -39550 0 0 {name=p158616 lab=_76958_/Y }
C {devices/lab_pin.sym} 160030 -39570 0 1 {name=p158617 lab=_81525_/D }
C {sky130_stdcells/dfxtp_4.sym} 159940 -39560 0 0 {name=X_81569_ }
C {devices/lab_pin.sym} 159860 -39460 0 0 {name=p158618 lab=_74106_/X }
C {devices/lab_pin.sym} 159860 -39420 0 0 {name=p158619 lab=_85610_/Q }
C {devices/lab_pin.sym} 159860 -39380 0 0 {name=p158620 lab=_74107_/X }
C {devices/lab_pin.sym} 159860 -39340 0 0 {name=p158621 lab=_74109_/X }
C {devices/lab_pin.sym} 160020 -39400 0 1 {name=p158622 lab=_74110_/X }
C {sky130_stdcells/a211o_4.sym} 159940 -39400 0 0 {name=X_74110_ }
C {devices/lab_pin.sym} 159860 -39290 0 0 {name=p158623 lab=_40477_/X }
C {devices/lab_pin.sym} 159860 -39250 0 0 {name=p158624 lab=_40488_/X }
C {devices/lab_pin.sym} 159860 -39210 0 0 {name=p158625 lab=_40501_/X }
C {devices/lab_pin.sym} 159860 -39170 0 0 {name=p158626 lab=_88381_/Q }
C {devices/lab_pin.sym} 159860 -39130 0 0 {name=p158627 lab=_40492_/X }
C {devices/lab_pin.sym} 160020 -39210 0 1 {name=p158628 lab=_40502_/Y }
C {sky130_stdcells/o32ai_4.sym} 159940 -39210 0 0 {name=X_40502_ }
C {devices/lab_pin.sym} 159880 -39060 0 0 {name=p158629 lab=_59029_/A }
C {devices/lab_pin.sym} 159880 -39020 0 0 {name=p158630 lab=_59044_/B }
C {devices/lab_pin.sym} 160000 -39040 0 1 {name=p158631 lab=_59044_/Y }
C {sky130_stdcells/nor2_4.sym} 159940 -39040 0 0 {name=X_59044_ }
C {devices/lab_pin.sym} 159850 -38910 0 0 {name=p158632 lab=_85547_/CLK }
C {devices/lab_pin.sym} 159850 -38890 0 0 {name=p158633 lab=_83308_/D }
C {devices/lab_pin.sym} 160030 -38910 0 1 {name=p158634 lab=_83308_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -38900 0 0 {name=X_83308_ }
C {devices/lab_pin.sym} 159860 -38790 0 0 {name=p158635 lab=_48310_/B }
C {devices/lab_pin.sym} 159860 -38750 0 0 {name=p158636 lab=_71320_/X }
C {devices/lab_pin.sym} 159860 -38710 0 0 {name=p158637 lab=_71321_/Y }
C {devices/lab_pin.sym} 160020 -38750 0 1 {name=p158638 lab=_83537_/D }
C {sky130_stdcells/o21ai_4.sym} 159940 -38750 0 0 {name=X_71322_ }
C {devices/lab_pin.sym} 159900 -38610 0 0 {name=p158639 lab=_72908_/A }
C {devices/lab_pin.sym} 159980 -38610 0 1 {name=p158640 lab=_44270_/X }
C {sky130_stdcells/buf_2.sym} 159940 -38610 0 0 {name=X_44270_ }
C {devices/lab_pin.sym} 159880 -38510 0 0 {name=p158641 lab=_56263_/A }
C {devices/lab_pin.sym} 159880 -38470 0 0 {name=p158642 lab=_56253_/B }
C {devices/lab_pin.sym} 159880 -38430 0 0 {name=p158643 lab=_85257_/Q }
C {devices/lab_pin.sym} 160000 -38470 0 1 {name=p158644 lab=_56256_/Y }
C {sky130_stdcells/nand3_4.sym} 159940 -38470 0 0 {name=X_56256_ }
C {devices/lab_pin.sym} 159860 -38350 0 0 {name=p158645 lab=_75091_/A }
C {devices/lab_pin.sym} 159860 -38310 0 0 {name=p158646 lab=_75102_/A }
C {devices/lab_pin.sym} 159860 -38270 0 0 {name=p158647 lab=_75091_/B }
C {devices/lab_pin.sym} 160020 -38310 0 1 {name=p158648 lab=_75090_/X }
C {sky130_stdcells/a21o_4.sym} 159940 -38310 0 0 {name=X_75090_ }
C {devices/lab_pin.sym} 159850 -38170 0 0 {name=p158649 lab=_88245_/CLK }
C {devices/lab_pin.sym} 159850 -38150 0 0 {name=p158650 lab=_44505_/X }
C {devices/lab_pin.sym} 160030 -38170 0 1 {name=p158651 lab=_87076_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -38160 0 0 {name=X_87076_ }
C {devices/lab_pin.sym} 159900 -38030 0 0 {name=p158652 lab=_41482_/A }
C {devices/lab_pin.sym} 159980 -38030 0 1 {name=p158653 lab=_41523_/B }
C {sky130_stdcells/buf_2.sym} 159940 -38030 0 0 {name=X_41482_ }
C {devices/lab_pin.sym} 159880 -37920 0 0 {name=p158654 lab=_53468_/A }
C {devices/lab_pin.sym} 159880 -37880 0 0 {name=p158655 lab=_47863_/Y }
C {devices/lab_pin.sym} 160000 -37900 0 1 {name=p158656 lab=_53468_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -37900 0 0 {name=X_53468_ }
C {devices/lab_pin.sym} 159850 -37770 0 0 {name=p158657 lab=_84671_/CLK }
C {devices/lab_pin.sym} 159850 -37750 0 0 {name=p158658 lab=_63898_/Y }
C {devices/lab_pin.sym} 160030 -37770 0 1 {name=p158659 lab=_63897_/C }
C {sky130_stdcells/dfxtp_4.sym} 159940 -37760 0 0 {name=X_84288_ }
C {devices/lab_pin.sym} 159900 -37630 0 0 {name=p158660 lab=_43221_/A }
C {devices/lab_pin.sym} 159980 -37630 0 1 {name=p158661 lab=_43221_/Y }
C {sky130_stdcells/inv_2.sym} 159940 -37630 0 0 {name=X_43221_ }
C {devices/lab_pin.sym} 159900 -37510 0 0 {name=p158662 lab=_55207_/A }
C {devices/lab_pin.sym} 159980 -37510 0 1 {name=p158663 lab=_55208_/B }
C {sky130_stdcells/inv_2.sym} 159940 -37510 0 0 {name=X_55207_ }
C {devices/lab_pin.sym} 159860 -37420 0 0 {name=p158664 lab=_74016_/X }
C {devices/lab_pin.sym} 159860 -37380 0 0 {name=p158665 lab=_85613_/Q }
C {devices/lab_pin.sym} 159860 -37340 0 0 {name=p158666 lab=_73903_/X }
C {devices/lab_pin.sym} 159860 -37300 0 0 {name=p158667 lab=_74040_/X }
C {devices/lab_pin.sym} 160020 -37360 0 1 {name=p158668 lab=_74041_/X }
C {sky130_stdcells/a211o_4.sym} 159940 -37360 0 0 {name=X_74041_ }
C {devices/lab_pin.sym} 159850 -37210 0 0 {name=p158669 lab=_86029_/CLK }
C {devices/lab_pin.sym} 159850 -37190 0 0 {name=p158670 lab=_86027_/D }
C {devices/lab_pin.sym} 160030 -37210 0 1 {name=p158671 lab=_86027_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -37200 0 0 {name=X_86027_ }
C {devices/lab_pin.sym} 159860 -37110 0 0 {name=p158672 lab=_57491_/A }
C {devices/lab_pin.sym} 159860 -37070 0 0 {name=p158673 lab=_40364_/X }
C {devices/lab_pin.sym} 159860 -37030 0 0 {name=p158674 lab=_40432_/X }
C {devices/lab_pin.sym} 159860 -36990 0 0 {name=p158675 lab=_88392_/Q }
C {devices/lab_pin.sym} 159860 -36950 0 0 {name=p158676 lab=_40375_/X }
C {devices/lab_pin.sym} 160020 -37030 0 1 {name=p158677 lab=_40434_/A }
C {sky130_stdcells/o32ai_4.sym} 159940 -37030 0 0 {name=X_40433_ }
C {devices/lab_pin.sym} 159860 -36890 0 0 {name=p158678 lab=_85826_/Q }
C {devices/lab_pin.sym} 159860 -36850 0 0 {name=p158679 lab=_52397_/X }
C {devices/lab_pin.sym} 159860 -36810 0 0 {name=p158680 lab=_52418_/Y }
C {devices/lab_pin.sym} 160020 -36850 0 1 {name=p158681 lab=_52419_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -36850 0 0 {name=X_52419_ }
C {devices/lab_pin.sym} 159860 -36730 0 0 {name=p158682 lab=_51954_/B }
C {devices/lab_pin.sym} 159860 -36690 0 0 {name=p158683 lab=_71239_/X }
C {devices/lab_pin.sym} 159860 -36650 0 0 {name=p158684 lab=_71252_/Y }
C {devices/lab_pin.sym} 160020 -36690 0 1 {name=p158685 lab=_71253_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -36690 0 0 {name=X_71253_ }
C {devices/lab_pin.sym} 159850 -36550 0 0 {name=p158686 lab=_84487_/CLK }
C {devices/lab_pin.sym} 159850 -36530 0 0 {name=p158687 lab=_83239_/D }
C {devices/lab_pin.sym} 160030 -36550 0 1 {name=p158688 lab=_79493_/B }
C {sky130_stdcells/dfxtp_4.sym} 159940 -36540 0 0 {name=X_83239_ }
C {devices/lab_pin.sym} 159900 -36410 0 0 {name=p158689 lab=_56186_/Y }
C {devices/lab_pin.sym} 159980 -36410 0 1 {name=p158690 lab=_56255_/A }
C {sky130_stdcells/buf_2.sym} 159940 -36410 0 0 {name=X_56187_ }
C {devices/lab_pin.sym} 159880 -36300 0 0 {name=p158691 lab=_53386_/A }
C {devices/lab_pin.sym} 159880 -36260 0 0 {name=p158692 lab=_54578_/B }
C {devices/lab_pin.sym} 160000 -36280 0 1 {name=p158693 lab=_53399_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -36280 0 0 {name=X_53399_ }
C {devices/lab_pin.sym} 159900 -36150 0 0 {name=p158694 lab=_70233_/A }
C {devices/lab_pin.sym} 159980 -36150 0 1 {name=p158695 lab=_70204_/X }
C {sky130_stdcells/buf_2.sym} 159940 -36150 0 0 {name=X_70204_ }
C {devices/lab_pin.sym} 159900 -36030 0 0 {name=p158696 lab=_87556_/Q }
C {devices/lab_pin.sym} 159980 -36030 0 1 {name=p158697 lab=_43152_/Y }
C {sky130_stdcells/inv_2.sym} 159940 -36030 0 0 {name=X_43152_ }
C {devices/lab_pin.sym} 159900 -35910 0 0 {name=p158698 lab=_55138_/A }
C {devices/lab_pin.sym} 159980 -35910 0 1 {name=p158699 lab=_55138_/X }
C {sky130_stdcells/buf_2.sym} 159940 -35910 0 0 {name=X_55138_ }
C {devices/lab_pin.sym} 159900 -35790 0 0 {name=p158700 lab=_40363_/X }
C {devices/lab_pin.sym} 159980 -35790 0 1 {name=p158701 lab=_40364_/X }
C {sky130_stdcells/buf_2.sym} 159940 -35790 0 0 {name=X_40364_ }
C {devices/lab_pin.sym} 159860 -35690 0 0 {name=p158702 lab=_50466_/B }
C {devices/lab_pin.sym} 159860 -35650 0 0 {name=p158703 lab=_71164_/Y }
C {devices/lab_pin.sym} 159860 -35610 0 0 {name=p158704 lab=_71183_/Y }
C {devices/lab_pin.sym} 160020 -35650 0 1 {name=p158705 lab=_71184_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -35650 0 0 {name=X_71184_ }
C {devices/lab_pin.sym} 159900 -35510 0 0 {name=p158706 lab=_51719_/A }
C {devices/lab_pin.sym} 159980 -35510 0 1 {name=p158707 lab=_42103_/X }
C {sky130_stdcells/buf_2.sym} 159940 -35510 0 0 {name=X_42103_ }
C {devices/lab_pin.sym} 159880 -35400 0 0 {name=p158708 lab=_77786_/X }
C {devices/lab_pin.sym} 159880 -35360 0 0 {name=p158709 lab=_77787_/A }
C {devices/lab_pin.sym} 160000 -35380 0 1 {name=p158710 lab=_77800_/X }
C {sky130_stdcells/and2_4.sym} 159940 -35380 0 0 {name=X_77800_ }
C {devices/lab_pin.sym} 159860 -35280 0 0 {name=p158711 lab=_83512_/Q }
C {devices/lab_pin.sym} 159860 -35240 0 0 {name=p158712 lab=_83160_/Q }
C {devices/lab_pin.sym} 159860 -35200 0 0 {name=p158713 lab=_83509_/Q }
C {devices/lab_pin.sym} 159860 -35160 0 0 {name=p158714 lab=_83157_/Q }
C {devices/lab_pin.sym} 160020 -35220 0 1 {name=p158715 lab=_70139_/A }
C {sky130_stdcells/a22oi_4.sym} 159940 -35220 0 0 {name=X_70135_ }
C {devices/lab_pin.sym} 159900 -35070 0 0 {name=p158716 lab=_73864_/A }
C {devices/lab_pin.sym} 159980 -35070 0 1 {name=p158717 lab=_50293_/B }
C {sky130_stdcells/buf_2.sym} 159940 -35070 0 0 {name=X_47960_ }
C {devices/lab_pin.sym} 159860 -34990 0 0 {name=p158718 lab=_43072_/X }
C {devices/lab_pin.sym} 159860 -34950 0 0 {name=p158719 lab=_43075_/X }
C {devices/lab_pin.sym} 159860 -34910 0 0 {name=p158720 lab=_40707_/X }
C {devices/lab_pin.sym} 159860 -34870 0 0 {name=p158721 lab=_74053_/A }
C {devices/lab_pin.sym} 159860 -34830 0 0 {name=p158722 lab=_43080_/X }
C {devices/lab_pin.sym} 160020 -34910 0 1 {name=p158723 lab=_43083_/Y }
C {sky130_stdcells/o32ai_4.sym} 159940 -34910 0 0 {name=X_43083_ }
C {devices/lab_pin.sym} 159900 -34750 0 0 {name=p158724 lab=_46614_/X }
C {devices/lab_pin.sym} 159980 -34750 0 1 {name=p158725 lab=_55083_/A }
C {sky130_stdcells/buf_2.sym} 159940 -34750 0 0 {name=X_55069_ }
C {devices/lab_pin.sym} 159900 -34630 0 0 {name=p158726 lab=_59945_/Y }
C {devices/lab_pin.sym} 159980 -34630 0 1 {name=p158727 lab=_59951_/C }
C {sky130_stdcells/buf_2.sym} 159940 -34630 0 0 {name=X_59946_ }
C {devices/lab_pin.sym} 159880 -34530 0 0 {name=p158728 lab=_78780_/A }
C {devices/lab_pin.sym} 159880 -34490 0 0 {name=p158729 lab=_78773_/X }
C {devices/lab_pin.sym} 159880 -34450 0 0 {name=p158730 lab=_78779_/Y }
C {devices/lab_pin.sym} 160000 -34490 0 1 {name=p158731 lab=_78783_/A }
C {sky130_stdcells/nand3_4.sym} 159940 -34490 0 0 {name=X_78780_ }
C {devices/lab_pin.sym} 159880 -34360 0 0 {name=p158732 lab=_81707_/D }
C {devices/lab_pin.sym} 159880 -34320 0 0 {name=p158733 lab=_75991_/B }
C {devices/lab_pin.sym} 160000 -34340 0 1 {name=p158734 lab=_75992_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -34340 0 0 {name=X_75992_ }
C {devices/lab_pin.sym} 159850 -34210 0 0 {name=p158735 lab=_88158_/CLK }
C {devices/lab_pin.sym} 159850 -34190 0 0 {name=p158736 lab=_87978_/D }
C {devices/lab_pin.sym} 160030 -34210 0 1 {name=p158737 lab=_87978_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -34200 0 0 {name=X_87978_ }
C {devices/lab_pin.sym} 159900 -34070 0 0 {name=p158738 lab=_46911_/A }
C {devices/lab_pin.sym} 159980 -34070 0 1 {name=p158739 lab=_52744_/B }
C {sky130_stdcells/inv_2.sym} 159940 -34070 0 0 {name=X_46911_ }
C {devices/lab_pin.sym} 159900 -33950 0 0 {name=p158740 lab=_42034_/A }
C {devices/lab_pin.sym} 159980 -33950 0 1 {name=p158741 lab=_42034_/Y }
C {sky130_stdcells/inv_2.sym} 159940 -33950 0 0 {name=X_42034_ }
C {devices/lab_pin.sym} 159900 -33830 0 0 {name=p158742 lab=_82258_/Q }
C {devices/lab_pin.sym} 159980 -33830 0 1 {name=p158743 lab=_77731_/Y }
C {sky130_stdcells/inv_2.sym} 159940 -33830 0 0 {name=X_77731_ }
C {devices/lab_pin.sym} 159880 -33720 0 0 {name=p158744 lab=_74933_/Y }
C {devices/lab_pin.sym} 159880 -33680 0 0 {name=p158745 lab=_74943_/B }
C {devices/lab_pin.sym} 160000 -33700 0 1 {name=p158746 lab=_74947_/A }
C {sky130_stdcells/nand2_4.sym} 159940 -33700 0 0 {name=X_74943_ }
C {devices/lab_pin.sym} 159860 -33590 0 0 {name=p158747 lab=_83859_/Q }
C {devices/lab_pin.sym} 159860 -33550 0 0 {name=p158748 lab=_70048_/X }
C {devices/lab_pin.sym} 159860 -33510 0 0 {name=p158749 lab=_70065_/Y }
C {devices/lab_pin.sym} 160020 -33550 0 1 {name=p158750 lab=_70066_/X }
C {sky130_stdcells/a21bo_4.sym} 159940 -33550 0 0 {name=X_70066_ }
C {devices/lab_pin.sym} 159850 -33410 0 0 {name=p158751 lab=_87144_/CLK }
C {devices/lab_pin.sym} 159850 -33390 0 0 {name=p158752 lab=_86929_/D }
C {devices/lab_pin.sym} 160030 -33410 0 1 {name=p158753 lab=_67679_/B }
C {sky130_stdcells/dfxtp_4.sym} 159940 -33400 0 0 {name=X_86929_ }
C {devices/lab_pin.sym} 159880 -33280 0 0 {name=p158754 lab=_47855_/A }
C {devices/lab_pin.sym} 159880 -33240 0 0 {name=p158755 lab=_50260_/B }
C {devices/lab_pin.sym} 160000 -33260 0 1 {name=p158756 lab=_47891_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -33260 0 0 {name=X_47891_ }
C {devices/lab_pin.sym} 159900 -33130 0 0 {name=p158757 lab=_59876_/X }
C {devices/lab_pin.sym} 159980 -33130 0 1 {name=p158758 lab=_59877_/X }
C {sky130_stdcells/buf_2.sym} 159940 -33130 0 0 {name=X_59877_ }
C {devices/lab_pin.sym} 159880 -33040 0 0 {name=p158759 lab=_49625_/A }
C {devices/lab_pin.sym} 159880 -33000 0 0 {name=p158760 lab=_49614_/X }
C {devices/lab_pin.sym} 159880 -32960 0 0 {name=p158761 lab=_49629_/X }
C {devices/lab_pin.sym} 159880 -32920 0 0 {name=p158762 lab=_52846_/D }
C {devices/lab_pin.sym} 160000 -32980 0 1 {name=p158763 lab=_49630_/X }
C {sky130_stdcells/and4_4.sym} 159940 -32980 0 0 {name=X_49630_ }
C {devices/lab_pin.sym} 159880 -32840 0 0 {name=p158764 lab=_46817_/A }
C {devices/lab_pin.sym} 159880 -32800 0 0 {name=p158765 lab=_51016_/B }
C {devices/lab_pin.sym} 160000 -32820 0 1 {name=p158766 lab=_46842_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -32820 0 0 {name=X_46842_ }
C {devices/lab_pin.sym} 159900 -32690 0 0 {name=p158767 lab=_58918_/A }
C {devices/lab_pin.sym} 159980 -32690 0 1 {name=p158768 lab=_58828_/X }
C {sky130_stdcells/buf_2.sym} 159940 -32690 0 0 {name=X_58828_ }
C {devices/lab_pin.sym} 159900 -32570 0 0 {name=p158769 lab=_77661_/X }
C {devices/lab_pin.sym} 159980 -32570 0 1 {name=p158770 lab=_77662_/Y }
C {sky130_stdcells/inv_2.sym} 159940 -32570 0 0 {name=X_77662_ }
C {devices/lab_pin.sym} 159880 -32460 0 0 {name=p158771 lab=_74874_/A }
C {devices/lab_pin.sym} 159880 -32420 0 0 {name=p158772 lab=_74874_/B }
C {devices/lab_pin.sym} 160000 -32440 0 1 {name=p158773 lab=_74874_/X }
C {sky130_stdcells/xor2_4.sym} 159940 -32440 0 0 {name=X_74874_ }
C {devices/lab_pin.sym} 159880 -32320 0 0 {name=p158774 lab=_79418_/B }
C {devices/lab_pin.sym} 159880 -32280 0 0 {name=p158775 lab=_79401_/B }
C {devices/lab_pin.sym} 160000 -32300 0 1 {name=p158776 lab=_82838_/D }
C {sky130_stdcells/xor2_4.sym} 159940 -32300 0 0 {name=X_79401_ }
C {devices/lab_pin.sym} 159880 -32180 0 0 {name=p158777 lab=_76613_/A }
C {devices/lab_pin.sym} 159880 -32140 0 0 {name=p158778 lab=_76613_/B }
C {devices/lab_pin.sym} 160000 -32160 0 1 {name=p158779 lab=_81343_/D }
C {sky130_stdcells/nor2_4.sym} 159940 -32160 0 0 {name=X_76613_ }
C {devices/lab_pin.sym} 159880 -32060 0 0 {name=p158780 lab=_49561_/A }
C {devices/lab_pin.sym} 159880 -32020 0 0 {name=p158781 lab=_49561_/B }
C {devices/lab_pin.sym} 159880 -31980 0 0 {name=p158782 lab=_49548_/X }
C {devices/lab_pin.sym} 159880 -31940 0 0 {name=p158783 lab=_52775_/D }
C {devices/lab_pin.sym} 160000 -32000 0 1 {name=p158784 lab=_49561_/X }
C {sky130_stdcells/and4_4.sym} 159940 -32000 0 0 {name=X_49561_ }
C {devices/lab_pin.sym} 159860 -31870 0 0 {name=p158785 lab=_68645_/B }
C {devices/lab_pin.sym} 159860 -31830 0 0 {name=p158786 lab=_73801_/X }
C {devices/lab_pin.sym} 159860 -31790 0 0 {name=p158787 lab=_73704_/X }
C {devices/lab_pin.sym} 160020 -31830 0 1 {name=p158788 lab=_73825_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -31830 0 0 {name=X_73825_ }
C {devices/lab_pin.sym} 159900 -31690 0 0 {name=p158789 lab=_46915_/A }
C {devices/lab_pin.sym} 159980 -31690 0 1 {name=p158790 lab=_46784_/A }
C {sky130_stdcells/buf_2.sym} 159940 -31690 0 0 {name=X_46773_ }
C {devices/lab_pin.sym} 159860 -31590 0 0 {name=p158791 lab=_58714_/X }
C {devices/lab_pin.sym} 159860 -31550 0 0 {name=p158792 lab=_85778_/Q }
C {devices/lab_pin.sym} 159860 -31510 0 0 {name=p158793 lab=_58716_/X }
C {devices/lab_pin.sym} 160020 -31550 0 1 {name=p158794 lab=_58759_/X }
C {sky130_stdcells/o21a_4.sym} 159940 -31550 0 0 {name=X_58759_ }
C {devices/lab_pin.sym} 159900 -31410 0 0 {name=p158795 lab=_77592_/X }
C {devices/lab_pin.sym} 159980 -31410 0 1 {name=p158796 lab=_77593_/Y }
C {sky130_stdcells/inv_2.sym} 159940 -31410 0 0 {name=X_77593_ }
C {devices/lab_pin.sym} 159860 -31320 0 0 {name=p158797 lab=_44186_/A }
C {devices/lab_pin.sym} 159860 -31280 0 0 {name=p158798 lab=_43954_/X }
C {devices/lab_pin.sym} 159860 -31240 0 0 {name=p158799 lab=_43945_/Y }
C {devices/lab_pin.sym} 159860 -31200 0 0 {name=p158800 lab=_43984_/Y }
C {devices/lab_pin.sym} 160020 -31260 0 1 {name=p158801 lab=_43985_/X }
C {sky130_stdcells/a211o_4.sym} 159940 -31260 0 0 {name=X_43985_ }
C {devices/lab_pin.sym} 159860 -31130 0 0 {name=p158802 lab=_48506_/Y }
C {devices/lab_pin.sym} 159860 -31090 0 0 {name=p158803 lab=_48459_/X }
C {devices/lab_pin.sym} 159860 -31050 0 0 {name=p158804 lab=_48511_/X }
C {devices/lab_pin.sym} 160020 -31090 0 1 {name=p158805 lab=_86516_/D }
C {sky130_stdcells/a21oi_4.sym} 159940 -31090 0 0 {name=X_48512_ }
C {devices/lab_pin.sym} 159880 -30960 0 0 {name=p158806 lab=_79346_/A }
C {devices/lab_pin.sym} 159880 -30920 0 0 {name=p158807 lab=_79346_/B }
C {devices/lab_pin.sym} 160000 -30940 0 1 {name=p158808 lab=_79332_/X }
C {sky130_stdcells/xor2_4.sym} 159940 -30940 0 0 {name=X_79332_ }
C {devices/lab_pin.sym} 159860 -30830 0 0 {name=p158809 lab=_85036_/Q }
C {devices/lab_pin.sym} 159860 -30790 0 0 {name=p158810 lab=_45675_/X }
C {devices/lab_pin.sym} 159860 -30750 0 0 {name=p158811 lab=_45723_/X }
C {devices/lab_pin.sym} 160020 -30790 0 1 {name=p158812 lab=_45724_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -30790 0 0 {name=X_45724_ }
C {devices/lab_pin.sym} 159900 -30650 0 0 {name=p158813 lab=_76526_/X }
C {devices/lab_pin.sym} 159980 -30650 0 1 {name=p158814 lab=_76544_/Y }
C {sky130_stdcells/inv_2.sym} 159940 -30650 0 0 {name=X_76544_ }
C {devices/lab_pin.sym} 159900 -30530 0 0 {name=p158815 lab=_42936_/A }
C {devices/lab_pin.sym} 159980 -30530 0 1 {name=p158816 lab=_42936_/Y }
C {sky130_stdcells/inv_2.sym} 159940 -30530 0 0 {name=X_42936_ }
C {devices/lab_pin.sym} 159860 -30430 0 0 {name=p158817 lab=_86377_/Q }
C {devices/lab_pin.sym} 159860 -30390 0 0 {name=p158818 lab=_49470_/X }
C {devices/lab_pin.sym} 159860 -30350 0 0 {name=p158819 lab=_49491_/Y }
C {devices/lab_pin.sym} 160020 -30390 0 1 {name=p158820 lab=_49492_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -30390 0 0 {name=X_49492_ }
C {devices/lab_pin.sym} 159880 -30280 0 0 {name=p158821 lab=_61770_/A }
C {devices/lab_pin.sym} 159880 -30240 0 0 {name=p158822 lab=_61770_/B }
C {devices/lab_pin.sym} 159880 -30200 0 0 {name=p158823 lab=_63396_/B }
C {devices/lab_pin.sym} 159880 -30160 0 0 {name=p158824 lab=_61770_/D }
C {devices/lab_pin.sym} 160000 -30220 0 1 {name=p158825 lab=_61770_/X }
C {sky130_stdcells/and4_4.sym} 159940 -30220 0 0 {name=X_61770_ }
C {devices/lab_pin.sym} 159860 -30090 0 0 {name=p158826 lab=_44691_/Y }
C {devices/lab_pin.sym} 159860 -30050 0 0 {name=p158827 lab=_73728_/X }
C {devices/lab_pin.sym} 159860 -30010 0 0 {name=p158828 lab=_73755_/Y }
C {devices/lab_pin.sym} 160020 -30050 0 1 {name=p158829 lab=_73767_/C }
C {sky130_stdcells/a21o_4.sym} 159940 -30050 0 0 {name=X_73756_ }
C {devices/lab_pin.sym} 159860 -29930 0 0 {name=p158830 lab=_50777_/B }
C {devices/lab_pin.sym} 159860 -29890 0 0 {name=p158831 lab=_70961_/X }
C {devices/lab_pin.sym} 159860 -29850 0 0 {name=p158832 lab=_70967_/Y }
C {devices/lab_pin.sym} 160020 -29890 0 1 {name=p158833 lab=_70968_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -29890 0 0 {name=X_70968_ }
C {devices/lab_pin.sym} 159860 -29770 0 0 {name=p158834 lab=_48436_/Y }
C {devices/lab_pin.sym} 159860 -29730 0 0 {name=p158835 lab=_48383_/X }
C {devices/lab_pin.sym} 159860 -29690 0 0 {name=p158836 lab=_48442_/X }
C {devices/lab_pin.sym} 160020 -29730 0 1 {name=p158837 lab=_48443_/Y }
C {sky130_stdcells/a21oi_4.sym} 159940 -29730 0 0 {name=X_48443_ }
C {devices/lab_pin.sym} 159900 -29590 0 0 {name=p158838 lab=_63413_/A }
C {devices/lab_pin.sym} 159980 -29590 0 1 {name=p158839 lab=_63672_/C }
C {sky130_stdcells/buf_2.sym} 159940 -29590 0 0 {name=X_60721_ }
C {devices/lab_pin.sym} 159860 -29490 0 0 {name=p158840 lab=_70251_/C }
C {devices/lab_pin.sym} 159860 -29450 0 0 {name=p158841 lab=_72702_/X }
C {devices/lab_pin.sym} 159860 -29410 0 0 {name=p158842 lab=_72706_/Y }
C {devices/lab_pin.sym} 160020 -29450 0 1 {name=p158843 lab=_72707_/X }
C {sky130_stdcells/a21bo_4.sym} 159940 -29450 0 0 {name=X_72707_ }
C {devices/lab_pin.sym} 159880 -29320 0 0 {name=p158844 lab=_79263_/A }
C {devices/lab_pin.sym} 159880 -29280 0 0 {name=p158845 lab=_79263_/B }
C {devices/lab_pin.sym} 160000 -29300 0 1 {name=p158846 lab=_79263_/X }
C {sky130_stdcells/xor2_4.sym} 159940 -29300 0 0 {name=X_79263_ }
C {devices/lab_pin.sym} 159860 -29190 0 0 {name=p158847 lab=_45652_/X }
C {devices/lab_pin.sym} 159860 -29150 0 0 {name=p158848 lab=_45654_/Y }
C {devices/lab_pin.sym} 159860 -29110 0 0 {name=p158849 lab=_45561_/X }
C {devices/lab_pin.sym} 160020 -29150 0 1 {name=p158850 lab=_45655_/Y }
C {sky130_stdcells/a21oi_4.sym} 159940 -29150 0 0 {name=X_45655_ }
C {devices/lab_pin.sym} 159860 -29030 0 0 {name=p158851 lab=_76471_/Y }
C {devices/lab_pin.sym} 159860 -28990 0 0 {name=p158852 lab=_76473_/Y }
C {devices/lab_pin.sym} 159860 -28950 0 0 {name=p158853 lab=_76474_/A }
C {devices/lab_pin.sym} 160020 -28990 0 1 {name=p158854 lab=_76479_/C }
C {sky130_stdcells/o21ai_4.sym} 159940 -28990 0 0 {name=X_76475_ }
C {devices/lab_pin.sym} 159900 -28850 0 0 {name=p158855 lab=_42832_/A }
C {devices/lab_pin.sym} 159980 -28850 0 1 {name=p158856 lab=_42867_/X }
C {sky130_stdcells/buf_2.sym} 159940 -28850 0 0 {name=X_42867_ }
C {devices/lab_pin.sym} 159860 -28760 0 0 {name=p158857 lab=_73609_/X }
C {devices/lab_pin.sym} 159860 -28720 0 0 {name=p158858 lab=_85628_/Q }
C {devices/lab_pin.sym} 159860 -28680 0 0 {name=p158859 lab=_73661_/X }
C {devices/lab_pin.sym} 159860 -28640 0 0 {name=p158860 lab=_73686_/X }
C {devices/lab_pin.sym} 160020 -28700 0 1 {name=p158861 lab=_73687_/X }
C {sky130_stdcells/a211o_4.sym} 159940 -28700 0 0 {name=X_73687_ }
C {devices/lab_pin.sym} 159880 -28580 0 0 {name=p158862 lab=_70871_/A }
C {devices/lab_pin.sym} 159880 -28540 0 0 {name=p158863 lab=_70903_/B }
C {devices/lab_pin.sym} 159880 -28500 0 0 {name=p158864 lab=_70899_/C }
C {devices/lab_pin.sym} 159880 -28460 0 0 {name=p158865 lab=_70899_/D }
C {devices/lab_pin.sym} 160000 -28520 0 1 {name=p158866 lab=_70899_/Y }
C {sky130_stdcells/nand4_4.sym} 159940 -28520 0 0 {name=X_70899_ }
C {devices/lab_pin.sym} 159880 -28380 0 0 {name=p158867 lab=_78220_/B }
C {devices/lab_pin.sym} 159880 -28340 0 0 {name=p158868 lab=_78220_/C }
C {devices/lab_pin.sym} 160000 -28360 0 1 {name=p158869 lab=_78214_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -28360 0 0 {name=X_78214_ }
C {devices/lab_pin.sym} 159860 -28270 0 0 {name=p158870 lab=_44588_/X }
C {devices/lab_pin.sym} 159860 -28230 0 0 {name=p158871 lab=_44589_/X }
C {devices/lab_pin.sym} 159860 -28190 0 0 {name=p158872 lab=_40950_/A }
C {devices/lab_pin.sym} 159860 -28150 0 0 {name=p158873 lab=_87037_/Q }
C {devices/lab_pin.sym} 159860 -28110 0 0 {name=p158874 lab=_44590_/X }
C {devices/lab_pin.sym} 160020 -28190 0 1 {name=p158875 lab=_44606_/Y }
C {sky130_stdcells/o32ai_4.sym} 159940 -28190 0 0 {name=X_44606_ }
C {devices/lab_pin.sym} 159900 -28030 0 0 {name=p158876 lab=_63375_/A }
C {devices/lab_pin.sym} 159980 -28030 0 1 {name=p158877 lab=_63463_/A }
C {sky130_stdcells/buf_2.sym} 159940 -28030 0 0 {name=X_63440_ }
C {devices/lab_pin.sym} 159900 -27910 0 0 {name=p158878 lab=_75426_/A }
C {devices/lab_pin.sym} 159980 -27910 0 1 {name=p158879 lab=_75427_/C }
C {sky130_stdcells/inv_2.sym} 159940 -27910 0 0 {name=X_75426_ }
C {devices/lab_pin.sym} 159900 -27790 0 0 {name=p158880 lab=_41818_/A }
C {devices/lab_pin.sym} 159980 -27790 0 1 {name=p158881 lab=_41818_/Y }
C {sky130_stdcells/inv_2.sym} 159940 -27790 0 0 {name=X_41818_ }
C {devices/lab_pin.sym} 159880 -27680 0 0 {name=p158882 lab=_48891_/B }
C {devices/lab_pin.sym} 159880 -27640 0 0 {name=p158883 lab=_48449_/B }
C {devices/lab_pin.sym} 160000 -27660 0 1 {name=p158884 lab=_48374_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -27660 0 0 {name=X_48374_ }
C {devices/lab_pin.sym} 159900 -27530 0 0 {name=p158885 lab=_60652_/A }
C {devices/lab_pin.sym} 159980 -27530 0 1 {name=p158886 lab=_60652_/X }
C {sky130_stdcells/buf_2.sym} 159940 -27530 0 0 {name=X_60652_ }
C {devices/lab_pin.sym} 159860 -27430 0 0 {name=p158887 lab=_70176_/C }
C {devices/lab_pin.sym} 159860 -27390 0 0 {name=p158888 lab=_72631_/X }
C {devices/lab_pin.sym} 159860 -27350 0 0 {name=p158889 lab=_72637_/Y }
C {devices/lab_pin.sym} 160020 -27390 0 1 {name=p158890 lab=_83208_/D }
C {sky130_stdcells/a21bo_4.sym} 159940 -27390 0 0 {name=X_72638_ }
C {devices/lab_pin.sym} 159860 -27270 0 0 {name=p158891 lab=_79186_/Y }
C {devices/lab_pin.sym} 159860 -27230 0 0 {name=p158892 lab=_79180_/Y }
C {devices/lab_pin.sym} 159860 -27190 0 0 {name=p158893 lab=_79181_/Y }
C {devices/lab_pin.sym} 160020 -27230 0 1 {name=p158894 lab=_79207_/B }
C {sky130_stdcells/a21boi_4.sym} 159940 -27230 0 0 {name=X_79194_ }
C {devices/lab_pin.sym} 159860 -27120 0 0 {name=p158895 lab=_45584_/Y }
C {devices/lab_pin.sym} 159860 -27080 0 0 {name=p158896 lab=_45570_/X }
C {devices/lab_pin.sym} 159860 -27040 0 0 {name=p158897 lab=_45520_/X }
C {devices/lab_pin.sym} 159860 -27000 0 0 {name=p158898 lab=_45585_/Y }
C {devices/lab_pin.sym} 160020 -27060 0 1 {name=p158899 lab=_45586_/X }
C {sky130_stdcells/a211o_4.sym} 159940 -27060 0 0 {name=X_45586_ }
C {devices/lab_pin.sym} 159900 -26910 0 0 {name=p158900 lab=_42797_/Y }
C {devices/lab_pin.sym} 159980 -26910 0 1 {name=p158901 lab=_42798_/Y }
C {sky130_stdcells/inv_2.sym} 159940 -26910 0 0 {name=X_42798_ }
C {devices/lab_pin.sym} 159880 -26800 0 0 {name=p158902 lab=_47287_/X }
C {devices/lab_pin.sym} 159880 -26760 0 0 {name=p158903 lab=_52986_/B }
C {devices/lab_pin.sym} 160000 -26780 0 1 {name=p158904 lab=_47325_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -26780 0 0 {name=X_47325_ }
C {devices/lab_pin.sym} 159880 -26660 0 0 {name=p158905 lab=_78145_/A }
C {devices/lab_pin.sym} 159880 -26620 0 0 {name=p158906 lab=_82860_/D }
C {devices/lab_pin.sym} 160000 -26640 0 1 {name=p158907 lab=_78152_/A }
C {sky130_stdcells/xor2_4.sym} 159940 -26640 0 0 {name=X_78145_ }
C {devices/lab_pin.sym} 159900 -26510 0 0 {name=p158908 lab=_72973_/A }
C {devices/lab_pin.sym} 159980 -26510 0 1 {name=p158909 lab=_44537_/Y }
C {sky130_stdcells/inv_2.sym} 159940 -26510 0 0 {name=X_44537_ }
C {devices/lab_pin.sym} 159880 -26400 0 0 {name=p158910 lab=_75355_/X }
C {devices/lab_pin.sym} 159880 -26360 0 0 {name=p158911 lab=_75357_/B }
C {devices/lab_pin.sym} 160000 -26380 0 1 {name=p158912 lab=_75357_/Y }
C {sky130_stdcells/xnor2_4.sym} 159940 -26380 0 0 {name=X_75357_ }
C {devices/lab_pin.sym} 159900 -26250 0 0 {name=p158913 lab=_63371_/A }
C {devices/lab_pin.sym} 159980 -26250 0 1 {name=p158914 lab=_63372_/A }
C {sky130_stdcells/buf_2.sym} 159940 -26250 0 0 {name=X_63371_ }
C {devices/lab_pin.sym} 159900 -26130 0 0 {name=p158915 lab=_41748_/Y }
C {devices/lab_pin.sym} 159980 -26130 0 1 {name=p158916 lab=_41749_/X }
C {sky130_stdcells/buf_2.sym} 159940 -26130 0 0 {name=X_41749_ }
C {devices/lab_pin.sym} 159880 -26030 0 0 {name=p158917 lab=_60583_/A }
C {devices/lab_pin.sym} 159880 -25990 0 0 {name=p158918 lab=_60602_/B }
C {devices/lab_pin.sym} 159880 -25950 0 0 {name=p158919 lab=_63280_/C }
C {devices/lab_pin.sym} 160000 -25990 0 1 {name=p158920 lab=_60583_/Y }
C {sky130_stdcells/nor3_4.sym} 159940 -25990 0 0 {name=X_60583_ }
C {devices/lab_pin.sym} 159880 -25870 0 0 {name=p158921 lab=_72569_/A }
C {devices/lab_pin.sym} 159880 -25830 0 0 {name=p158922 lab=_57896_/A }
C {devices/lab_pin.sym} 159880 -25790 0 0 {name=p158923 lab=_72569_/C }
C {devices/lab_pin.sym} 160000 -25830 0 1 {name=p158924 lab=_72569_/Y }
C {sky130_stdcells/nand3_4.sym} 159940 -25830 0 0 {name=X_72569_ }
C {devices/lab_pin.sym} 159860 -25720 0 0 {name=p158925 lab=_65065_/X }
C {devices/lab_pin.sym} 159860 -25680 0 0 {name=p158926 lab=_86734_/Q }
C {devices/lab_pin.sym} 159860 -25640 0 0 {name=p158927 lab=_65108_/X }
C {devices/lab_pin.sym} 159860 -25600 0 0 {name=p158928 lab=_65109_/X }
C {devices/lab_pin.sym} 160020 -25660 0 1 {name=p158929 lab=_65110_/X }
C {sky130_stdcells/a211o_4.sym} 159940 -25660 0 0 {name=X_65110_ }
C {devices/lab_pin.sym} 159880 -25540 0 0 {name=p158930 lab=_62362_/A }
C {devices/lab_pin.sym} 159880 -25500 0 0 {name=p158931 lab=_62317_/Y }
C {devices/lab_pin.sym} 159880 -25460 0 0 {name=p158932 lab=_62322_/C }
C {devices/lab_pin.sym} 159880 -25420 0 0 {name=p158933 lab=_62321_/Y }
C {devices/lab_pin.sym} 160000 -25480 0 1 {name=p158934 lab=_62322_/Y }
C {sky130_stdcells/nand4_4.sym} 159940 -25480 0 0 {name=X_62322_ }
C {devices/lab_pin.sym} 159880 -25350 0 0 {name=p158935 lab=_74302_/X }
C {devices/lab_pin.sym} 159880 -25310 0 0 {name=p158936 lab=_74310_/B }
C {devices/lab_pin.sym} 159880 -25270 0 0 {name=p158937 lab=_56044_/X }
C {devices/lab_pin.sym} 160000 -25310 0 1 {name=p158938 lab=_74308_/Y }
C {sky130_stdcells/nand3_4.sym} 159940 -25310 0 0 {name=X_74308_ }
C {devices/lab_pin.sym} 159900 -25170 0 0 {name=p158939 lab=_54634_/D }
C {devices/lab_pin.sym} 159980 -25170 0 1 {name=p158940 lab=_52942_/D }
C {sky130_stdcells/buf_2.sym} 159940 -25170 0 0 {name=X_47256_ }
C {devices/lab_pin.sym} 159880 -25060 0 0 {name=p158941 lab=_66081_/Y }
C {devices/lab_pin.sym} 159880 -25020 0 0 {name=p158942 lab=_66089_/Y }
C {devices/lab_pin.sym} 160000 -25040 0 1 {name=p158943 lab=_66090_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -25040 0 0 {name=X_66090_ }
C {devices/lab_pin.sym} 159880 -24920 0 0 {name=p158944 lab=_60717_/C }
C {devices/lab_pin.sym} 159880 -24880 0 0 {name=p158945 lab=_78076_/B }
C {devices/lab_pin.sym} 160000 -24900 0 1 {name=p158946 lab=_78076_/X }
C {sky130_stdcells/xor2_4.sym} 159940 -24900 0 0 {name=X_78076_ }
C {devices/lab_pin.sym} 159860 -24800 0 0 {name=p158947 lab=_41161_/A }
C {devices/lab_pin.sym} 159860 -24760 0 0 {name=p158948 lab=_44464_/X }
C {devices/lab_pin.sym} 159860 -24720 0 0 {name=p158949 lab=_87094_/Q }
C {devices/lab_pin.sym} 159860 -24680 0 0 {name=p158950 lab=_44466_/X }
C {devices/lab_pin.sym} 160020 -24740 0 1 {name=p158951 lab=_44468_/X }
C {sky130_stdcells/a2bb2o_4.sym} 159940 -24740 0 0 {name=X_44468_ }
C {devices/lab_pin.sym} 159880 -24600 0 0 {name=p158952 lab=_75288_/A }
C {devices/lab_pin.sym} 159880 -24560 0 0 {name=p158953 lab=_80945_/D }
C {devices/lab_pin.sym} 160000 -24580 0 1 {name=p158954 lab=_75288_/Y }
C {sky130_stdcells/nor2_4.sym} 159940 -24580 0 0 {name=X_75288_ }
C {devices/lab_pin.sym} 159880 -24470 0 0 {name=p158955 lab=_46222_/A }
C {devices/lab_pin.sym} 159880 -24430 0 0 {name=p158956 lab=_46207_/B }
C {devices/lab_pin.sym} 159880 -24390 0 0 {name=p158957 lab=_46162_/C }
C {devices/lab_pin.sym} 160000 -24430 0 1 {name=p158958 lab=_46207_/Y }
C {sky130_stdcells/nand3_4.sym} 159940 -24430 0 0 {name=X_46207_ }
C {devices/lab_pin.sym} 159860 -24320 0 0 {name=p158959 lab=_64934_/X }
C {devices/lab_pin.sym} 159860 -24280 0 0 {name=p158960 lab=_83297_/Q }
C {devices/lab_pin.sym} 159860 -24240 0 0 {name=p158961 lab=_64991_/X }
C {devices/lab_pin.sym} 159860 -24200 0 0 {name=p158962 lab=_65040_/X }
C {devices/lab_pin.sym} 160020 -24260 0 1 {name=p158963 lab=_65041_/X }
C {sky130_stdcells/a211o_4.sym} 159940 -24260 0 0 {name=X_65041_ }
C {sky130_stdcells/decap_3.sym} 159940 -24080 0 0 {name=XPHY_190 }
C {devices/lab_pin.sym} 159880 -23940 0 0 {name=p158964 lab=_77034_/B }
C {devices/lab_pin.sym} 159880 -23900 0 0 {name=p158965 lab=_77026_/Y }
C {devices/lab_pin.sym} 160000 -23920 0 1 {name=p158966 lab=_77028_/B }
C {sky130_stdcells/xor2_4.sym} 159940 -23920 0 0 {name=X_77027_ }
C {devices/lab_pin.sym} 159860 -23820 0 0 {name=p158967 lab=_41525_/X }
C {devices/lab_pin.sym} 159860 -23780 0 0 {name=p158968 lab=_43412_/X }
C {devices/lab_pin.sym} 159860 -23740 0 0 {name=p158969 lab=_87430_/Q }
C {devices/lab_pin.sym} 159860 -23700 0 0 {name=p158970 lab=_43413_/X }
C {devices/lab_pin.sym} 160020 -23760 0 1 {name=p158971 lab=_43419_/X }
C {sky130_stdcells/a2bb2o_4.sym} 159940 -23760 0 0 {name=X_43419_ }
C {devices/lab_pin.sym} 159900 -23610 0 0 {name=p158972 lab=_62033_/A }
C {devices/lab_pin.sym} 159980 -23610 0 1 {name=p158973 lab=_62253_/X }
C {sky130_stdcells/buf_2.sym} 159940 -23610 0 0 {name=X_62253_ }
C {devices/lab_pin.sym} 159880 -23500 0 0 {name=p158974 lab=_74239_/A }
C {devices/lab_pin.sym} 159880 -23460 0 0 {name=p158975 lab=_74239_/B }
C {devices/lab_pin.sym} 160000 -23480 0 1 {name=p158976 lab=_74239_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -23480 0 0 {name=X_74239_ }
C {devices/lab_pin.sym} 159900 -23350 0 0 {name=p158977 lab=_47140_/A }
C {devices/lab_pin.sym} 159980 -23350 0 1 {name=p158978 lab=_47210_/C }
C {sky130_stdcells/buf_2.sym} 159940 -23350 0 0 {name=X_47187_ }
C {devices/lab_pin.sym} 159860 -23270 0 0 {name=p158979 lab=_44381_/X }
C {devices/lab_pin.sym} 159860 -23230 0 0 {name=p158980 lab=_44382_/X }
C {devices/lab_pin.sym} 159860 -23190 0 0 {name=p158981 lab=_41498_/X }
C {devices/lab_pin.sym} 159860 -23150 0 0 {name=p158982 lab=_87128_/Q }
C {devices/lab_pin.sym} 159860 -23110 0 0 {name=p158983 lab=_44383_/X }
C {devices/lab_pin.sym} 160020 -23190 0 1 {name=p158984 lab=_44400_/A }
C {sky130_stdcells/o32ai_4.sym} 159940 -23190 0 0 {name=X_44399_ }
C {devices/lab_pin.sym} 159860 -23070 0 0 {name=p158985 lab=_61190_/X }
C {devices/lab_pin.sym} 159860 -23030 0 0 {name=p158986 lab=_61156_/X }
C {devices/lab_pin.sym} 159860 -22990 0 0 {name=p158987 lab=_61272_/B }
C {devices/lab_pin.sym} 159860 -22950 0 0 {name=p158988 lab=_61202_/Y }
C {devices/lab_pin.sym} 159860 -22920 0 0 {name=p158989 lab=_61203_/Y }
C {devices/lab_pin.sym} 160020 -22990 0 1 {name=p158990 lab=_84508_/D }
C {sky130_stdcells/a41oi_4.sym} 159940 -22990 0 0 {name=X_61204_ }
C {devices/lab_pin.sym} 159880 -22850 0 0 {name=p158991 lab=_46138_/A }
C {devices/lab_pin.sym} 159880 -22810 0 0 {name=p158992 lab=_46119_/A }
C {devices/lab_pin.sym} 159880 -22770 0 0 {name=p158993 lab=_43012_/B }
C {devices/lab_pin.sym} 160000 -22810 0 1 {name=p158994 lab=_46138_/Y }
C {sky130_stdcells/nand3_4.sym} 159940 -22810 0 0 {name=X_46138_ }
C {devices/lab_pin.sym} 159860 -22690 0 0 {name=p158995 lab=_63713_/A }
C {devices/lab_pin.sym} 159860 -22650 0 0 {name=p158996 lab=_59628_/A }
C {devices/lab_pin.sym} 159860 -22610 0 0 {name=p158997 lab=_59763_/A }
C {devices/lab_pin.sym} 160020 -22650 0 1 {name=p158998 lab=_62188_/B }
C {sky130_stdcells/a21o_4.sym} 159940 -22650 0 0 {name=X_62184_ }
C {devices/lab_pin.sym} 159900 -22510 0 0 {name=p158999 lab=_69478_/A }
C {devices/lab_pin.sym} 159980 -22510 0 1 {name=p159000 lab=_68800_/X }
C {sky130_stdcells/buf_2.sym} 159940 -22510 0 0 {name=X_68800_ }
C {devices/lab_pin.sym} 159880 -22400 0 0 {name=p159001 lab=_64546_/A }
C {devices/lab_pin.sym} 159880 -22360 0 0 {name=p159002 lab=_64225_/B }
C {devices/lab_pin.sym} 160000 -22380 0 1 {name=p159003 lab=_61135_/X }
C {sky130_stdcells/and2_4.sym} 159940 -22380 0 0 {name=X_61135_ }
C {devices/lab_pin.sym} 159860 -22290 0 0 {name=p159004 lab=_46067_/X }
C {devices/lab_pin.sym} 159860 -22250 0 0 {name=p159005 lab=_46054_/X }
C {devices/lab_pin.sym} 159860 -22210 0 0 {name=p159006 lab=_41573_/X }
C {devices/lab_pin.sym} 159860 -22170 0 0 {name=p159007 lab=_86784_/Q }
C {devices/lab_pin.sym} 159860 -22130 0 0 {name=p159008 lab=_46068_/X }
C {devices/lab_pin.sym} 160020 -22210 0 1 {name=p159009 lab=_46070_/A }
C {sky130_stdcells/o32ai_4.sym} 159940 -22210 0 0 {name=X_46069_ }
C {devices/lab_pin.sym} 159880 -22060 0 0 {name=p159010 lab=_69766_/A }
C {devices/lab_pin.sym} 159880 -22020 0 0 {name=p159011 lab=_69780_/B }
C {devices/lab_pin.sym} 160000 -22040 0 1 {name=p159012 lab=_69780_/Y }
C {sky130_stdcells/nor2_4.sym} 159940 -22040 0 0 {name=X_69780_ }
C {devices/lab_pin.sym} 159860 -21940 0 0 {name=p159013 lab=_66947_/X }
C {devices/lab_pin.sym} 159860 -21900 0 0 {name=p159014 lab=_66980_/Y }
C {devices/lab_pin.sym} 159860 -21860 0 0 {name=p159015 lab=_66910_/X }
C {devices/lab_pin.sym} 159860 -21820 0 0 {name=p159016 lab=_66991_/Y }
C {devices/lab_pin.sym} 160020 -21880 0 1 {name=p159017 lab=_66992_/X }
C {sky130_stdcells/a211o_4.sym} 159940 -21880 0 0 {name=X_66992_ }
C {devices/lab_pin.sym} 159880 -21740 0 0 {name=p159018 lab=_78976_/Y }
C {devices/lab_pin.sym} 159880 -21700 0 0 {name=p159019 lab=_78978_/B }
C {devices/lab_pin.sym} 160000 -21720 0 1 {name=p159020 lab=_78986_/B }
C {sky130_stdcells/xor2_4.sym} 159940 -21720 0 0 {name=X_78978_ }
C {devices/lab_pin.sym} 159900 -21590 0 0 {name=p159021 lab=_69371_/A }
C {devices/lab_pin.sym} 159980 -21590 0 1 {name=p159022 lab=_68731_/X }
C {sky130_stdcells/buf_2.sym} 159940 -21590 0 0 {name=X_68731_ }
C {devices/lab_pin.sym} 159880 -21490 0 0 {name=p159023 lab=_65916_/A }
C {devices/lab_pin.sym} 159880 -21450 0 0 {name=p159024 lab=_65970_/B }
C {devices/lab_pin.sym} 159880 -21410 0 0 {name=p159025 lab=_84167_/Q }
C {devices/lab_pin.sym} 160000 -21450 0 1 {name=p159026 lab=_65943_/X }
C {sky130_stdcells/and3_4.sym} 159940 -21450 0 0 {name=X_65943_ }
C {devices/lab_pin.sym} 159880 -21320 0 0 {name=p159027 lab=_77916_/A }
C {devices/lab_pin.sym} 159880 -21280 0 0 {name=p159028 lab=_77923_/A }
C {devices/lab_pin.sym} 160000 -21300 0 1 {name=p159029 lab=_77929_/X }
C {sky130_stdcells/and2_4.sym} 159940 -21300 0 0 {name=X_77929_ }
C {devices/lab_pin.sym} 159880 -21190 0 0 {name=p159030 lab=_59622_/A }
C {devices/lab_pin.sym} 159880 -21150 0 0 {name=p159031 lab=_61066_/B }
C {devices/lab_pin.sym} 159880 -21110 0 0 {name=p159032 lab=_60641_/A }
C {devices/lab_pin.sym} 160000 -21150 0 1 {name=p159033 lab=_61066_/Y }
C {sky130_stdcells/nor3_4.sym} 159940 -21150 0 0 {name=X_61066_ }
C {devices/lab_pin.sym} 159900 -21010 0 0 {name=p159034 lab=_62336_/A }
C {devices/lab_pin.sym} 159980 -21010 0 1 {name=p159035 lab=_62623_/A }
C {sky130_stdcells/buf_2.sym} 159940 -21010 0 0 {name=X_60017_ }
C {devices/lab_pin.sym} 159880 -20900 0 0 {name=p159036 lab=_49827_/X }
C {devices/lab_pin.sym} 159880 -20860 0 0 {name=p159037 lab=_53041_/B }
C {devices/lab_pin.sym} 160000 -20880 0 1 {name=p159038 lab=_49828_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -20880 0 0 {name=X_49828_ }
C {devices/lab_pin.sym} 159850 -20750 0 0 {name=p159039 lab=_80804_/CLK }
C {devices/lab_pin.sym} 159850 -20730 0 0 {name=p159040 lab=_80984_/Q }
C {devices/lab_pin.sym} 160030 -20750 0 1 {name=p159041 lab=_74920_/A }
C {sky130_stdcells/dfxtp_4.sym} 159940 -20740 0 0 {name=X_80940_ }
C {devices/lab_pin.sym} 159860 -20630 0 0 {name=p159042 lab=_68656_/X }
C {devices/lab_pin.sym} 159860 -20590 0 0 {name=p159043 lab=_68659_/X }
C {devices/lab_pin.sym} 159860 -20550 0 0 {name=p159044 lab=_68661_/X }
C {devices/lab_pin.sym} 160020 -20590 0 1 {name=p159045 lab=_68662_/Y }
C {sky130_stdcells/a21oi_4.sym} 159940 -20590 0 0 {name=X_68662_ }
C {devices/lab_pin.sym} 159880 -20460 0 0 {name=p159046 lab=_65702_/A }
C {devices/lab_pin.sym} 159880 -20420 0 0 {name=p159047 lab=_85859_/Q }
C {devices/lab_pin.sym} 160000 -20440 0 1 {name=p159048 lab=_65874_/X }
C {sky130_stdcells/and2_4.sym} 159940 -20440 0 0 {name=X_65874_ }
C {devices/lab_pin.sym} 159900 -20310 0 0 {name=p159049 lab=clkbuf_9_235_0_CLK/X }
C {devices/lab_pin.sym} 159980 -20310 0 1 {name=p159050 lab=_85767_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 159940 -20310 0 0 {name=Xclkbuf_10_471_0_CLK }
C {devices/lab_pin.sym} 159880 -20200 0 0 {name=p159051 lab=_67569_/X }
C {devices/lab_pin.sym} 159880 -20160 0 0 {name=p159052 lab=_67613_/B }
C {devices/lab_pin.sym} 160000 -20180 0 1 {name=p159053 lab=_67613_/X }
C {sky130_stdcells/and2_4.sym} 159940 -20180 0 0 {name=X_67613_ }
C {devices/lab_pin.sym} 159880 -20070 0 0 {name=p159054 lab=_64822_/X }
C {devices/lab_pin.sym} 159880 -20030 0 0 {name=p159055 lab=_64712_/B }
C {devices/lab_pin.sym} 159880 -19990 0 0 {name=p159056 lab=_64824_/X }
C {devices/lab_pin.sym} 160000 -20030 0 1 {name=p159057 lab=_64825_/Y }
C {sky130_stdcells/nand3_4.sym} 159940 -20030 0 0 {name=X_64825_ }
C {devices/lab_pin.sym} 159900 -19890 0 0 {name=p159058 lab=_49787_/A }
C {devices/lab_pin.sym} 159980 -19890 0 1 {name=p159059 lab=_49759_/X }
C {sky130_stdcells/buf_2.sym} 159940 -19890 0 0 {name=X_49759_ }
C {devices/lab_pin.sym} 159850 -19770 0 0 {name=p159060 lab=_80746_/CLK }
C {devices/lab_pin.sym} 159850 -19750 0 0 {name=p159061 lab=_75617_/B }
C {devices/lab_pin.sym} 160030 -19770 0 1 {name=p159062 lab=_80871_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -19760 0 0 {name=X_80871_ }
C {devices/lab_pin.sym} 159860 -19660 0 0 {name=p159063 lab=_73773_/A }
C {devices/lab_pin.sym} 159860 -19620 0 0 {name=p159064 lab=_68069_/X }
C {devices/lab_pin.sym} 159860 -19580 0 0 {name=p159065 lab=_68070_/X }
C {devices/lab_pin.sym} 159860 -19540 0 0 {name=p159066 lab=_68592_/Y }
C {devices/lab_pin.sym} 160020 -19600 0 1 {name=p159067 lab=_68593_/X }
C {sky130_stdcells/a211o_4.sym} 159940 -19600 0 0 {name=X_68593_ }
C {devices/lab_pin.sym} 159850 -19450 0 0 {name=p159068 lab=_82610_/CLK }
C {devices/lab_pin.sym} 159850 -19430 0 0 {name=p159069 lab=_78958_/B }
C {devices/lab_pin.sym} 160030 -19450 0 1 {name=p159070 lab=_82578_/D }
C {sky130_stdcells/dfxtp_4.sym} 159940 -19440 0 0 {name=X_82610_ }
C {devices/lab_pin.sym} 159860 -19330 0 0 {name=p159071 lab=_84065_/Q }
C {devices/lab_pin.sym} 159860 -19290 0 0 {name=p159072 lab=_67449_/X }
C {devices/lab_pin.sym} 159860 -19250 0 0 {name=p159073 lab=_67543_/X }
C {devices/lab_pin.sym} 160020 -19290 0 1 {name=p159074 lab=_84065_/D }
C {sky130_stdcells/a21bo_4.sym} 159940 -19290 0 0 {name=X_67544_ }
C {devices/lab_pin.sym} 159900 -19150 0 0 {name=p159075 lab=_52770_/A }
C {devices/lab_pin.sym} 159980 -19150 0 1 {name=p159076 lab=_52775_/B }
C {sky130_stdcells/buf_2.sym} 159940 -19150 0 0 {name=X_52770_ }
C {devices/lab_pin.sym} 159860 -19060 0 0 {name=p159077 lab=_64722_/X }
C {devices/lab_pin.sym} 159860 -19020 0 0 {name=p159078 lab=_85564_/Q }
C {devices/lab_pin.sym} 159860 -18980 0 0 {name=p159079 lab=_64724_/X }
C {devices/lab_pin.sym} 159860 -18940 0 0 {name=p159080 lab=_64755_/X }
C {devices/lab_pin.sym} 160020 -19000 0 1 {name=p159081 lab=_64756_/X }
C {sky130_stdcells/a211o_4.sym} 159940 -19000 0 0 {name=X_64756_ }
C {devices/lab_pin.sym} 159850 -18850 0 0 {name=p159082 lab=_86523_/CLK }
C {devices/lab_pin.sym} 159850 -18830 0 0 {name=p159083 lab=_83590_/D }
C {devices/lab_pin.sym} 160030 -18850 0 1 {name=p159084 lab=_83590_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -18840 0 0 {name=X_83590_ }
C {devices/lab_pin.sym} 159880 -18740 0 0 {name=p159085 lab=_61509_/B }
C {devices/lab_pin.sym} 159880 -18700 0 0 {name=p159086 lab=_61953_/B }
C {devices/lab_pin.sym} 159880 -18660 0 0 {name=p159087 lab=_61953_/C }
C {devices/lab_pin.sym} 159880 -18620 0 0 {name=p159088 lab=_61937_/X }
C {devices/lab_pin.sym} 160000 -18680 0 1 {name=p159089 lab=_61968_/Y }
C {sky130_stdcells/nand4_4.sym} 159940 -18680 0 0 {name=X_61968_ }
C {devices/lab_pin.sym} 159900 -18530 0 0 {name=p159090 lab=_52605_/A }
C {devices/lab_pin.sym} 159980 -18530 0 1 {name=p159091 lab=_51721_/X }
C {sky130_stdcells/buf_2.sym} 159940 -18530 0 0 {name=X_51721_ }
C {devices/lab_pin.sym} 159860 -18440 0 0 {name=p159092 lab=_61682_/B }
C {devices/lab_pin.sym} 159860 -18400 0 0 {name=p159093 lab=_63426_/A }
C {devices/lab_pin.sym} 159860 -18360 0 0 {name=p159094 lab=_63705_/X }
C {devices/lab_pin.sym} 159860 -18320 0 0 {name=p159095 lab=_63706_/X }
C {devices/lab_pin.sym} 160020 -18380 0 1 {name=p159096 lab=_63707_/X }
C {sky130_stdcells/a211o_4.sym} 159940 -18380 0 0 {name=X_63707_ }
C {devices/lab_pin.sym} 159850 -18230 0 0 {name=p159097 lab=_82541_/CLK }
C {devices/lab_pin.sym} 159850 -18210 0 0 {name=p159098 lab=_82541_/D }
C {devices/lab_pin.sym} 160030 -18230 0 1 {name=p159099 lab=_79051_/B }
C {sky130_stdcells/dfxtp_4.sym} 159940 -18220 0 0 {name=X_82541_ }
C {devices/lab_pin.sym} 159900 -18090 0 0 {name=p159100 lab=_60855_/X }
C {devices/lab_pin.sym} 159980 -18090 0 1 {name=p159101 lab=_60920_/A }
C {sky130_stdcells/buf_2.sym} 159940 -18090 0 0 {name=X_60919_ }
C {devices/lab_pin.sym} 159860 -18000 0 0 {name=p159102 lab=_87917_/Q }
C {devices/lab_pin.sym} 159860 -17960 0 0 {name=p159103 lab=_67473_/X }
C {devices/lab_pin.sym} 159860 -17920 0 0 {name=p159104 lab=_67405_/X }
C {devices/lab_pin.sym} 159860 -17880 0 0 {name=p159105 lab=_67474_/X }
C {devices/lab_pin.sym} 160020 -17940 0 1 {name=p159106 lab=_67475_/X }
C {sky130_stdcells/a211o_4.sym} 159940 -17940 0 0 {name=X_67475_ }
C {devices/lab_pin.sym} 159900 -17790 0 0 {name=p159107 lab=clkbuf_9_243_0_CLK/X }
C {devices/lab_pin.sym} 159980 -17790 0 1 {name=p159108 lab=_84802_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 159940 -17790 0 0 {name=Xclkbuf_10_486_0_CLK }
C {devices/lab_pin.sym} 159860 -17690 0 0 {name=p159109 lab=_64561_/X }
C {devices/lab_pin.sym} 159860 -17650 0 0 {name=p159110 lab=_64675_/Y }
C {devices/lab_pin.sym} 159860 -17610 0 0 {name=p159111 lab=_64686_/Y }
C {devices/lab_pin.sym} 160020 -17650 0 1 {name=p159112 lab=_64687_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -17650 0 0 {name=X_64687_ }
C {devices/lab_pin.sym} 159880 -17530 0 0 {name=p159113 lab=_61960_/A }
C {devices/lab_pin.sym} 159880 -17490 0 0 {name=p159114 lab=_61960_/B }
C {devices/lab_pin.sym} 159880 -17450 0 0 {name=p159115 lab=_78070_/B }
C {devices/lab_pin.sym} 160000 -17490 0 1 {name=p159116 lab=_61899_/Y }
C {sky130_stdcells/nor3_4.sym} 159940 -17490 0 0 {name=X_61899_ }
C {devices/lab_pin.sym} 159860 -17380 0 0 {name=p159117 lab=_69146_/X }
C {devices/lab_pin.sym} 159860 -17340 0 0 {name=p159118 lab=_69109_/X }
C {devices/lab_pin.sym} 159860 -17300 0 0 {name=p159119 lab=_69211_/Y }
C {devices/lab_pin.sym} 159860 -17260 0 0 {name=p159120 lab=_69213_/Y }
C {devices/lab_pin.sym} 160020 -17320 0 1 {name=p159121 lab=_69214_/X }
C {sky130_stdcells/a211o_4.sym} 159940 -17320 0 0 {name=X_69214_ }
C {devices/lab_pin.sym} 159880 -17200 0 0 {name=p159122 lab=_54435_/A }
C {devices/lab_pin.sym} 159880 -17160 0 0 {name=p159123 lab=_54440_/B }
C {devices/lab_pin.sym} 159880 -17120 0 0 {name=p159124 lab=_54429_/C }
C {devices/lab_pin.sym} 159880 -17080 0 0 {name=p159125 lab=_46916_/Y }
C {devices/lab_pin.sym} 160000 -17140 0 1 {name=p159126 lab=_54440_/X }
C {sky130_stdcells/and4_4.sym} 159940 -17140 0 0 {name=X_54440_ }
C {devices/lab_pin.sym} 159880 -17010 0 0 {name=p159127 lab=_66426_/A }
C {devices/lab_pin.sym} 159880 -16970 0 0 {name=p159128 lab=_66397_/X }
C {devices/lab_pin.sym} 159880 -16930 0 0 {name=p159129 lab=_66426_/C }
C {devices/lab_pin.sym} 160000 -16970 0 1 {name=p159130 lab=_66426_/Y }
C {sky130_stdcells/nand3_4.sym} 159940 -16970 0 0 {name=X_66426_ }
C {devices/lab_pin.sym} 159850 -16830 0 0 {name=p159131 lab=_85192_/CLK }
C {devices/lab_pin.sym} 159850 -16810 0 0 {name=p159132 lab=_56249_/Y }
C {devices/lab_pin.sym} 160030 -16830 0 1 {name=p159133 lab=_85260_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -16820 0 0 {name=X_85260_ }
C {devices/lab_pin.sym} 159860 -16710 0 0 {name=p159134 lab=_51650_/Y }
C {devices/lab_pin.sym} 159860 -16670 0 0 {name=p159135 lab=_51639_/X }
C {devices/lab_pin.sym} 159860 -16630 0 0 {name=p159136 lab=_51651_/X }
C {devices/lab_pin.sym} 160020 -16670 0 1 {name=p159137 lab=_51652_/Y }
C {sky130_stdcells/a21oi_4.sym} 159940 -16670 0 0 {name=X_51652_ }
C {devices/lab_pin.sym} 159880 -16540 0 0 {name=p159138 lab=_58400_/A }
C {devices/lab_pin.sym} 159880 -16500 0 0 {name=p159139 lab=_63648_/B }
C {devices/lab_pin.sym} 160000 -16520 0 1 {name=p159140 lab=_63638_/Y }
C {sky130_stdcells/nor2_4.sym} 159940 -16520 0 0 {name=X_63638_ }
C {devices/lab_pin.sym} 159850 -16390 0 0 {name=p159141 lab=_81198_/CLK }
C {devices/lab_pin.sym} 159850 -16370 0 0 {name=p159142 lab=_78401_/X }
C {devices/lab_pin.sym} 160030 -16390 0 1 {name=p159143 lab=_82472_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -16380 0 0 {name=X_82472_ }
C {devices/lab_pin.sym} 159850 -16250 0 0 {name=p159144 lab=_85315_/CLK }
C {devices/lab_pin.sym} 159850 -16230 0 0 {name=p159145 lab=_84211_/D }
C {devices/lab_pin.sym} 160030 -16250 0 1 {name=p159146 lab=_84211_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -16240 0 0 {name=X_84211_ }
C {devices/lab_pin.sym} 159880 -16120 0 0 {name=p159147 lab=_50597_/A }
C {devices/lab_pin.sym} 159880 -16080 0 0 {name=p159148 lab=_48963_/X }
C {devices/lab_pin.sym} 160000 -16100 0 1 {name=p159149 lab=_50603_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -16100 0 0 {name=X_50603_ }
C {devices/lab_pin.sym} 159850 -15970 0 0 {name=p159150 lab=_81749_/CLK }
C {devices/lab_pin.sym} 159850 -15950 0 0 {name=p159151 lab=_81423_/D }
C {devices/lab_pin.sym} 160030 -15970 0 1 {name=p159152 lab=_76021_/B }
C {sky130_stdcells/dfxtp_4.sym} 159940 -15960 0 0 {name=X_81423_ }
C {devices/lab_pin.sym} 159860 -15850 0 0 {name=p159153 lab=_83945_/Q }
C {devices/lab_pin.sym} 159860 -15810 0 0 {name=p159154 lab=_69066_/X }
C {devices/lab_pin.sym} 159860 -15770 0 0 {name=p159155 lab=_69144_/X }
C {devices/lab_pin.sym} 160020 -15810 0 1 {name=p159156 lab=_83945_/D }
C {sky130_stdcells/a21bo_4.sym} 159940 -15810 0 0 {name=X_69145_ }
C {devices/lab_pin.sym} 159900 -15670 0 0 {name=p159157 lab=_54399_/A }
C {devices/lab_pin.sym} 159980 -15670 0 1 {name=p159158 lab=_54395_/A }
C {sky130_stdcells/buf_2.sym} 159940 -15670 0 0 {name=X_54371_ }
C {devices/lab_pin.sym} 159880 -15570 0 0 {name=p159159 lab=_65894_/X }
C {devices/lab_pin.sym} 159880 -15530 0 0 {name=p159160 lab=_66367_/B }
C {devices/lab_pin.sym} 159880 -15490 0 0 {name=p159161 lab=_65897_/X }
C {devices/lab_pin.sym} 160000 -15530 0 1 {name=p159162 lab=_66357_/Y }
C {sky130_stdcells/nand3_4.sym} 159940 -15530 0 0 {name=X_66357_ }
C {devices/lab_pin.sym} 159850 -15390 0 0 {name=p159163 lab=_85190_/CLK }
C {devices/lab_pin.sym} 159850 -15370 0 0 {name=p159164 lab=_85191_/D }
C {devices/lab_pin.sym} 160030 -15390 0 1 {name=p159165 lab=_56444_/C }
C {sky130_stdcells/dfxtp_4.sym} 159940 -15380 0 0 {name=X_85191_ }
C {devices/lab_pin.sym} 159860 -15270 0 0 {name=p159166 lab=_85983_/Q }
C {devices/lab_pin.sym} 159860 -15230 0 0 {name=p159167 lab=_51566_/X }
C {devices/lab_pin.sym} 159860 -15190 0 0 {name=p159168 lab=_51582_/Y }
C {devices/lab_pin.sym} 160020 -15230 0 1 {name=p159169 lab=_51583_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -15230 0 0 {name=X_51583_ }
C {devices/lab_pin.sym} 159880 -15120 0 0 {name=p159170 lab=_63546_/A }
C {devices/lab_pin.sym} 159880 -15080 0 0 {name=p159171 lab=_58474_/A }
C {devices/lab_pin.sym} 159880 -15040 0 0 {name=p159172 lab=_63520_/C }
C {devices/lab_pin.sym} 159880 -15000 0 0 {name=p159173 lab=_63546_/D }
C {devices/lab_pin.sym} 160000 -15060 0 1 {name=p159174 lab=_63569_/X }
C {sky130_stdcells/and4_4.sym} 159940 -15060 0 0 {name=X_63569_ }
C {devices/lab_pin.sym} 159880 -14930 0 0 {name=p159175 lab=_56131_/A }
C {devices/lab_pin.sym} 159880 -14890 0 0 {name=p159176 lab=_56115_/B }
C {devices/lab_pin.sym} 159880 -14850 0 0 {name=p159177 lab=_55817_/B }
C {devices/lab_pin.sym} 160000 -14890 0 1 {name=p159178 lab=_56110_/Y }
C {sky130_stdcells/nand3_4.sym} 159940 -14890 0 0 {name=X_56110_ }
C {devices/lab_pin.sym} 159880 -14780 0 0 {name=p159179 lab=_53330_/A }
C {devices/lab_pin.sym} 159880 -14740 0 0 {name=p159180 lab=_53330_/B }
C {devices/lab_pin.sym} 159880 -14700 0 0 {name=p159181 lab=_53302_/X }
C {devices/lab_pin.sym} 159880 -14660 0 0 {name=p159182 lab=_52805_/D }
C {devices/lab_pin.sym} 160000 -14720 0 1 {name=p159183 lab=_53322_/X }
C {sky130_stdcells/and4_4.sym} 159940 -14720 0 0 {name=X_53322_ }
C {devices/lab_pin.sym} 159900 -14570 0 0 {name=p159184 lab=_57947_/A }
C {devices/lab_pin.sym} 159980 -14570 0 1 {name=p159185 lab=_65308_/X }
C {sky130_stdcells/buf_2.sym} 159940 -14570 0 0 {name=X_65308_ }
C {devices/lab_pin.sym} 159850 -14450 0 0 {name=p159186 lab=_84231_/CLK }
C {devices/lab_pin.sym} 159850 -14430 0 0 {name=p159187 lab=_84142_/D }
C {devices/lab_pin.sym} 160030 -14450 0 1 {name=p159188 lab=_84142_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -14440 0 0 {name=X_84142_ }
C {devices/lab_pin.sym} 159900 -14310 0 0 {name=p159189 lab=_50534_/A }
C {devices/lab_pin.sym} 159980 -14310 0 1 {name=p159190 lab=_50541_/A }
C {sky130_stdcells/buf_2.sym} 159940 -14310 0 0 {name=X_50534_ }
C {devices/lab_pin.sym} 159900 -14190 0 0 {name=p159191 lab=_73186_/A }
C {devices/lab_pin.sym} 159980 -14190 0 1 {name=p159192 lab=_73227_/A }
C {sky130_stdcells/buf_2.sym} 159940 -14190 0 0 {name=X_57090_ }
C {devices/lab_pin.sym} 159850 -14070 0 0 {name=p159193 lab=_81322_/CLK }
C {devices/lab_pin.sym} 159850 -14050 0 0 {name=p159194 lab=_81354_/D }
C {devices/lab_pin.sym} 160030 -14070 0 1 {name=p159195 lab=_76274_/A }
C {sky130_stdcells/dfxtp_4.sym} 159940 -14060 0 0 {name=X_81354_ }
C {devices/lab_pin.sym} 159880 -13940 0 0 {name=p159196 lab=_69134_/A }
C {devices/lab_pin.sym} 159880 -13900 0 0 {name=p159197 lab=_69076_/B }
C {devices/lab_pin.sym} 160000 -13920 0 1 {name=p159198 lab=_69076_/X }
C {sky130_stdcells/and2_4.sym} 159940 -13920 0 0 {name=X_69076_ }
C {devices/lab_pin.sym} 159880 -13800 0 0 {name=p159199 lab=_58805_/A }
C {devices/lab_pin.sym} 159880 -13760 0 0 {name=p159200 lab=_74177_/B }
C {devices/lab_pin.sym} 160000 -13780 0 1 {name=p159201 lab=_66288_/X }
C {sky130_stdcells/and2_4.sym} 159940 -13780 0 0 {name=X_66288_ }
C {devices/lab_pin.sym} 159880 -13670 0 0 {name=p159202 lab=_56023_/A }
C {devices/lab_pin.sym} 159880 -13630 0 0 {name=p159203 lab=_56052_/B }
C {devices/lab_pin.sym} 159880 -13590 0 0 {name=p159204 lab=_56041_/C }
C {devices/lab_pin.sym} 160000 -13630 0 1 {name=p159205 lab=_56041_/Y }
C {sky130_stdcells/nand3_4.sym} 159940 -13630 0 0 {name=X_56041_ }
C {devices/lab_pin.sym} 159860 -13510 0 0 {name=p159206 lab=_80298_/A }
C {devices/lab_pin.sym} 159860 -13470 0 0 {name=p159207 lab=_80292_/A }
C {devices/lab_pin.sym} 159860 -13430 0 0 {name=p159208 lab=_80292_/B }
C {devices/lab_pin.sym} 160020 -13470 0 1 {name=p159209 lab=_80319_/B }
C {sky130_stdcells/a21boi_4.sym} 159940 -13470 0 0 {name=X_80305_ }
C {devices/lab_pin.sym} 159880 -13340 0 0 {name=p159210 lab=_68027_/A }
C {devices/lab_pin.sym} 159880 -13300 0 0 {name=p159211 lab=_68027_/B }
C {devices/lab_pin.sym} 160000 -13320 0 1 {name=p159212 lab=_68027_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -13320 0 0 {name=X_68027_ }
C {devices/lab_pin.sym} 159880 -13220 0 0 {name=p159213 lab=_53243_/X }
C {devices/lab_pin.sym} 159880 -13180 0 0 {name=p159214 lab=_51747_/A }
C {devices/lab_pin.sym} 159880 -13140 0 0 {name=p159215 lab=_53266_/C }
C {devices/lab_pin.sym} 159880 -13100 0 0 {name=p159216 lab=_53253_/D }
C {devices/lab_pin.sym} 160000 -13160 0 1 {name=p159217 lab=_53253_/X }
C {sky130_stdcells/and4_4.sym} 159940 -13160 0 0 {name=X_53253_ }
C {devices/lab_pin.sym} 159900 -13010 0 0 {name=p159218 lab=_64991_/A }
C {devices/lab_pin.sym} 159980 -13010 0 1 {name=p159219 lab=_65239_/X }
C {sky130_stdcells/buf_2.sym} 159940 -13010 0 0 {name=X_65239_ }
C {devices/lab_pin.sym} 159850 -12890 0 0 {name=p159220 lab=_81473_/CLK }
C {devices/lab_pin.sym} 159850 -12870 0 0 {name=p159221 lab=_67353_/X }
C {devices/lab_pin.sym} 160030 -12890 0 1 {name=p159222 lab=_81505_/D }
C {sky130_stdcells/dfxtp_4.sym} 159940 -12880 0 0 {name=X_84073_ }
C {devices/lab_pin.sym} 159900 -12750 0 0 {name=p159223 lab=_50534_/A }
C {devices/lab_pin.sym} 159980 -12750 0 1 {name=p159224 lab=_50465_/X }
C {sky130_stdcells/buf_2.sym} 159940 -12750 0 0 {name=X_50465_ }
C {devices/lab_pin.sym} 159850 -12630 0 0 {name=p159225 lab=_81282_/CLK }
C {devices/lab_pin.sym} 159850 -12610 0 0 {name=p159226 lab=_76973_/X }
C {devices/lab_pin.sym} 160030 -12630 0 1 {name=p159227 lab=_81285_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -12620 0 0 {name=X_81285_ }
C {devices/lab_pin.sym} 159880 -12510 0 0 {name=p159228 lab=_52204_/A }
C {devices/lab_pin.sym} 159880 -12470 0 0 {name=p159229 lab=_52198_/X }
C {devices/lab_pin.sym} 159880 -12430 0 0 {name=p159230 lab=_52218_/C }
C {devices/lab_pin.sym} 160000 -12470 0 1 {name=p159231 lab=_52204_/X }
C {sky130_stdcells/and3_4.sym} 159940 -12470 0 0 {name=X_52204_ }
C {devices/lab_pin.sym} 159850 -12330 0 0 {name=p159232 lab=_83025_/CLK }
C {devices/lab_pin.sym} 159850 -12310 0 0 {name=p159233 lab=_74590_/Y }
C {devices/lab_pin.sym} 160030 -12330 0 1 {name=p159234 lab=_45168_/A }
C {sky130_stdcells/dfxtp_4.sym} 159940 -12320 0 0 {name=X_83024_ }
C {devices/lab_pin.sym} 159850 -12190 0 0 {name=p159235 lab=_87644_/CLK }
C {devices/lab_pin.sym} 159850 -12170 0 0 {name=p159236 lab=_87901_/D }
C {devices/lab_pin.sym} 160030 -12190 0 1 {name=p159237 lab=_87901_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -12180 0 0 {name=X_87901_ }
C {devices/lab_pin.sym} 159860 -12070 0 0 {name=p159238 lab=_80228_/A }
C {devices/lab_pin.sym} 159860 -12030 0 0 {name=p159239 lab=_80227_/Y }
C {devices/lab_pin.sym} 159860 -11990 0 0 {name=p159240 lab=_80235_/X }
C {devices/lab_pin.sym} 160020 -12030 0 1 {name=p159241 lab=_80236_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -12030 0 0 {name=X_80236_ }
C {devices/lab_pin.sym} 159860 -11910 0 0 {name=p159242 lab=_85681_/Q }
C {devices/lab_pin.sym} 159860 -11870 0 0 {name=p159243 lab=_53172_/X }
C {devices/lab_pin.sym} 159860 -11830 0 0 {name=p159244 lab=_53183_/Y }
C {devices/lab_pin.sym} 160020 -11870 0 1 {name=p159245 lab=_53184_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -11870 0 0 {name=X_53184_ }
C {devices/lab_pin.sym} 159880 -11750 0 0 {name=p159246 lab=_53620_/A }
C {devices/lab_pin.sym} 159880 -11710 0 0 {name=p159247 lab=_50331_/B }
C {devices/lab_pin.sym} 159880 -11670 0 0 {name=p159248 lab=_50338_/X }
C {devices/lab_pin.sym} 160000 -11710 0 1 {name=p159249 lab=_50396_/X }
C {sky130_stdcells/and3_4.sym} 159940 -11710 0 0 {name=X_50396_ }
C {devices/lab_pin.sym} 159900 -11570 0 0 {name=p159250 lab=clkbuf_9_212_0_CLK/X }
C {devices/lab_pin.sym} 159980 -11570 0 1 {name=p159251 lab=_82797_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 159940 -11570 0 0 {name=Xclkbuf_10_424_0_CLK }
C {devices/lab_pin.sym} 159860 -11490 0 0 {name=p159252 lab=_59687_/C }
C {devices/lab_pin.sym} 159860 -11450 0 0 {name=p159253 lab=_59688_/X }
C {devices/lab_pin.sym} 159860 -11410 0 0 {name=p159254 lab=_59797_/Y }
C {devices/lab_pin.sym} 159860 -11370 0 0 {name=p159255 lab=_59798_/Y }
C {devices/lab_pin.sym} 159860 -11340 0 0 {name=p159256 lab=_59799_/Y }
C {devices/lab_pin.sym} 160020 -11410 0 1 {name=p159257 lab=_59800_/Y }
C {sky130_stdcells/a41oi_4.sym} 159940 -11410 0 0 {name=X_59800_ }
C {devices/lab_pin.sym} 159880 -11270 0 0 {name=p159258 lab=_52135_/A }
C {devices/lab_pin.sym} 159880 -11230 0 0 {name=p159259 lab=_52135_/B }
C {devices/lab_pin.sym} 159880 -11190 0 0 {name=p159260 lab=_52156_/C }
C {devices/lab_pin.sym} 160000 -11230 0 1 {name=p159261 lab=_52135_/X }
C {sky130_stdcells/and3_4.sym} 159940 -11230 0 0 {name=X_52135_ }
C {devices/lab_pin.sym} 159850 -11090 0 0 {name=p159262 lab=_88086_/CLK }
C {devices/lab_pin.sym} 159850 -11070 0 0 {name=p159263 lab=_42531_/Y }
C {devices/lab_pin.sym} 160030 -11090 0 1 {name=p159264 lab=_74184_/A }
C {sky130_stdcells/dfxtp_4.sym} 159940 -11080 0 0 {name=X_87832_ }
C {devices/lab_pin.sym} 159880 -10960 0 0 {name=p159265 lab=_80167_/A }
C {devices/lab_pin.sym} 159880 -10920 0 0 {name=p159266 lab=_80166_/X }
C {devices/lab_pin.sym} 160000 -10940 0 1 {name=p159267 lab=_80167_/Y }
C {sky130_stdcells/xnor2_4.sym} 159940 -10940 0 0 {name=X_80167_ }
C {devices/lab_pin.sym} 159880 -10820 0 0 {name=p159268 lab=_86638_/Q }
C {devices/lab_pin.sym} 159880 -10780 0 0 {name=p159269 lab=_57954_/X }
C {devices/lab_pin.sym} 160000 -10800 0 1 {name=p159270 lab=_57992_/Y }
C {sky130_stdcells/nor2_4.sym} 159940 -10800 0 0 {name=X_57992_ }
C {devices/lab_pin.sym} 159860 -10690 0 0 {name=p159271 lab=_68369_/X }
C {devices/lab_pin.sym} 159860 -10650 0 0 {name=p159272 lab=_68372_/X }
C {devices/lab_pin.sym} 159860 -10610 0 0 {name=p159273 lab=_69925_/X }
C {devices/lab_pin.sym} 160020 -10650 0 1 {name=p159274 lab=_69978_/Y }
C {sky130_stdcells/a21oi_4.sym} 159940 -10650 0 0 {name=X_69978_ }
C {devices/lab_pin.sym} 159900 -10510 0 0 {name=p159275 lab=_59687_/A }
C {devices/lab_pin.sym} 159980 -10510 0 1 {name=p159276 lab=_59731_/Y }
C {sky130_stdcells/inv_2.sym} 159940 -10510 0 0 {name=X_59731_ }
C {devices/lab_pin.sym} 159900 -10390 0 0 {name=p159277 lab=_52462_/A }
C {devices/lab_pin.sym} 159980 -10390 0 1 {name=p159278 lab=_52066_/X }
C {sky130_stdcells/buf_2.sym} 159940 -10390 0 0 {name=X_52066_ }
C {devices/lab_pin.sym} 159900 -10270 0 0 {name=p159279 lab=_56940_/Y }
C {devices/lab_pin.sym} 159980 -10270 0 1 {name=p159280 lab=_56943_/X }
C {sky130_stdcells/buf_2.sym} 159940 -10270 0 0 {name=X_56943_ }
C {devices/lab_pin.sym} 159900 -10150 0 0 {name=p159281 lab=_68300_/X }
C {devices/lab_pin.sym} 159980 -10150 0 1 {name=p159282 lab=_68929_/X }
C {sky130_stdcells/buf_2.sym} 159940 -10150 0 0 {name=X_68929_ }
C {devices/lab_pin.sym} 159850 -10030 0 0 {name=p159283 lab=_87520_/CLK }
C {devices/lab_pin.sym} 159850 -10010 0 0 {name=p159284 lab=_42702_/Y }
C {devices/lab_pin.sym} 160030 -10030 0 1 {name=p159285 lab=_68343_/B }
C {sky130_stdcells/dfxtp_4.sym} 159940 -10020 0 0 {name=X_87763_ }
C {devices/lab_pin.sym} 159850 -9890 0 0 {name=p159286 lab=_83544_/CLK }
C {devices/lab_pin.sym} 159850 -9870 0 0 {name=p159287 lab=_57583_/Y }
C {devices/lab_pin.sym} 160030 -9890 0 1 {name=p159288 lab=_84975_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -9880 0 0 {name=X_84975_ }
C {devices/lab_pin.sym} 159880 -9760 0 0 {name=p159289 lab=_80098_/A }
C {devices/lab_pin.sym} 159880 -9720 0 0 {name=p159290 lab=_80098_/B }
C {devices/lab_pin.sym} 160000 -9740 0 1 {name=p159291 lab=_80098_/X }
C {sky130_stdcells/xor2_4.sym} 159940 -9740 0 0 {name=X_80098_ }
C {devices/lab_pin.sym} 159860 -9630 0 0 {name=p159292 lab=_86089_/Q }
C {devices/lab_pin.sym} 159860 -9590 0 0 {name=p159293 lab=_50992_/X }
C {devices/lab_pin.sym} 159860 -9550 0 0 {name=p159294 lab=_51016_/Y }
C {devices/lab_pin.sym} 160020 -9590 0 1 {name=p159295 lab=_51017_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -9590 0 0 {name=X_51017_ }
C {devices/lab_pin.sym} 159850 -9450 0 0 {name=p159296 lab=_86711_/CLK }
C {devices/lab_pin.sym} 159850 -9430 0 0 {name=p159297 lab=_86714_/D }
C {devices/lab_pin.sym} 160030 -9450 0 1 {name=p159298 lab=_58660_/A }
C {sky130_stdcells/dfxtp_4.sym} 159940 -9440 0 0 {name=X_86714_ }
C {devices/lab_pin.sym} 159900 -9310 0 0 {name=p159299 lab=clkbuf_9_219_0_CLK/X }
C {devices/lab_pin.sym} 159980 -9310 0 1 {name=p159300 lab=_85354_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 159940 -9310 0 0 {name=Xclkbuf_10_439_0_CLK }
C {devices/lab_pin.sym} 159880 -9220 0 0 {name=p159301 lab=_70368_/X }
C {devices/lab_pin.sym} 159880 -9180 0 0 {name=p159302 lab=_71001_/C }
C {devices/lab_pin.sym} 159880 -9140 0 0 {name=p159303 lab=_71940_/C }
C {devices/lab_pin.sym} 159880 -9100 0 0 {name=p159304 lab=_71945_/D }
C {devices/lab_pin.sym} 160000 -9160 0 1 {name=p159305 lab=_71940_/Y }
C {sky130_stdcells/nand4_4.sym} 159940 -9160 0 0 {name=X_71940_ }
C {devices/lab_pin.sym} 159880 -9030 0 0 {name=p159306 lab=_59805_/A }
C {devices/lab_pin.sym} 159880 -8990 0 0 {name=p159307 lab=_59662_/B }
C {devices/lab_pin.sym} 159880 -8950 0 0 {name=p159308 lab=_59662_/C }
C {devices/lab_pin.sym} 160000 -8990 0 1 {name=p159309 lab=_59681_/A }
C {sky130_stdcells/and3_4.sym} 159940 -8990 0 0 {name=X_59662_ }
C {devices/lab_pin.sym} 159850 -8850 0 0 {name=p159310 lab=_83926_/CLK }
C {devices/lab_pin.sym} 159850 -8830 0 0 {name=p159311 lab=_83926_/D }
C {devices/lab_pin.sym} 160030 -8850 0 1 {name=p159312 lab=_81390_/D }
C {sky130_stdcells/dfxtp_4.sym} 159940 -8840 0 0 {name=X_83926_ }
C {devices/lab_pin.sym} 159880 -8720 0 0 {name=p159313 lab=_56873_/X }
C {devices/lab_pin.sym} 159880 -8680 0 0 {name=p159314 lab=_56774_/C }
C {devices/lab_pin.sym} 160000 -8700 0 1 {name=p159315 lab=_56874_/X }
C {sky130_stdcells/and2_4.sym} 159940 -8700 0 0 {name=X_56874_ }
C {devices/lab_pin.sym} 159900 -8570 0 0 {name=p159316 lab=clkbuf_0_CLK/X }
C {devices/lab_pin.sym} 159980 -8570 0 1 {name=p159317 lab=clkbuf_1_0_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 159940 -8570 0 0 {name=Xclkbuf_1_0_0_CLK }
C {devices/lab_pin.sym} 159850 -8450 0 0 {name=p159318 lab=_87950_/CLK }
C {devices/lab_pin.sym} 159850 -8430 0 0 {name=p159319 lab=_42834_/X }
C {devices/lab_pin.sym} 160030 -8450 0 1 {name=p159320 lab=_66689_/B }
C {sky130_stdcells/dfxtp_4.sym} 159940 -8440 0 0 {name=X_87694_ }
C {devices/lab_pin.sym} 159880 -8320 0 0 {name=p159321 lab=_58687_/A }
C {devices/lab_pin.sym} 159880 -8280 0 0 {name=p159322 lab=_58613_/B }
C {devices/lab_pin.sym} 160000 -8300 0 1 {name=p159323 lab=_58613_/Y }
C {sky130_stdcells/nor2_4.sym} 159940 -8300 0 0 {name=X_58613_ }
C {devices/lab_pin.sym} 159860 -8190 0 0 {name=p159324 lab=_55822_/X }
C {devices/lab_pin.sym} 159860 -8150 0 0 {name=p159325 lab=_55824_/X }
C {devices/lab_pin.sym} 159860 -8110 0 0 {name=p159326 lab=_44111_/X }
C {devices/lab_pin.sym} 160020 -8150 0 1 {name=p159327 lab=_55825_/X }
C {sky130_stdcells/a21o_4.sym} 159940 -8150 0 0 {name=X_55825_ }
C {devices/lab_pin.sym} 159850 -8010 0 0 {name=p159328 lab=_86005_/CLK }
C {devices/lab_pin.sym} 159850 -7990 0 0 {name=p159329 lab=_86645_/D }
C {devices/lab_pin.sym} 160030 -8010 0 1 {name=p159330 lab=_86645_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -8000 0 0 {name=X_86645_ }
C {devices/lab_pin.sym} 159900 -7870 0 0 {name=p159331 lab=_71870_/Y }
C {devices/lab_pin.sym} 159980 -7870 0 1 {name=p159332 lab=_71871_/X }
C {sky130_stdcells/buf_2.sym} 159940 -7870 0 0 {name=X_71871_ }
C {devices/lab_pin.sym} 159880 -7770 0 0 {name=p159333 lab=_59546_/A }
C {devices/lab_pin.sym} 159880 -7730 0 0 {name=p159334 lab=_43998_/A }
C {devices/lab_pin.sym} 159880 -7690 0 0 {name=p159335 lab=_59543_/A }
C {devices/lab_pin.sym} 160000 -7730 0 1 {name=p159336 lab=_59593_/X }
C {sky130_stdcells/and3_4.sym} 159940 -7730 0 0 {name=X_59593_ }
C {devices/lab_pin.sym} 159850 -7590 0 0 {name=p159337 lab=_82536_/CLK }
C {devices/lab_pin.sym} 159850 -7570 0 0 {name=p159338 lab=_83857_/D }
C {devices/lab_pin.sym} 160030 -7590 0 1 {name=p159339 lab=_82537_/D }
C {sky130_stdcells/dfxtp_4.sym} 159940 -7580 0 0 {name=X_83857_ }
C {devices/lab_pin.sym} 159880 -7460 0 0 {name=p159340 lab=_73638_/A }
C {devices/lab_pin.sym} 159880 -7420 0 0 {name=p159341 lab=_65935_/B }
C {devices/lab_pin.sym} 160000 -7440 0 1 {name=p159342 lab=_73610_/X }
C {sky130_stdcells/and2_4.sym} 159940 -7440 0 0 {name=X_73610_ }
C {devices/lab_pin.sym} 159880 -7330 0 0 {name=p159343 lab=_71219_/A }
C {devices/lab_pin.sym} 159880 -7290 0 0 {name=p159344 lab=_70954_/B }
C {devices/lab_pin.sym} 159880 -7250 0 0 {name=p159345 lab=_70703_/X }
C {devices/lab_pin.sym} 160000 -7290 0 1 {name=p159346 lab=_70822_/Y }
C {sky130_stdcells/nand3_4.sym} 159940 -7290 0 0 {name=X_70822_ }
C {devices/lab_pin.sym} 159880 -7160 0 0 {name=p159347 lab=_58543_/Y }
C {devices/lab_pin.sym} 159880 -7120 0 0 {name=p159348 lab=_58557_/B }
C {devices/lab_pin.sym} 160000 -7140 0 1 {name=p159349 lab=_58544_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -7140 0 0 {name=X_58544_ }
C {devices/lab_pin.sym} 159850 -7010 0 0 {name=p159350 lab=_82740_/CLK }
C {devices/lab_pin.sym} 159850 -6990 0 0 {name=p159351 lab=_82840_/Q }
C {devices/lab_pin.sym} 160030 -7010 0 1 {name=p159352 lab=_82808_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -7000 0 0 {name=X_82808_ }
C {devices/lab_pin.sym} 159900 -6870 0 0 {name=p159353 lab=_43752_/A }
C {devices/lab_pin.sym} 159980 -6870 0 1 {name=p159354 lab=_43770_/X }
C {sky130_stdcells/buf_2.sym} 159940 -6870 0 0 {name=X_43770_ }
C {devices/lab_pin.sym} 159880 -6760 0 0 {name=p159355 lab=_55192_/A }
C {devices/lab_pin.sym} 159880 -6720 0 0 {name=p159356 lab=_55756_/B }
C {devices/lab_pin.sym} 160000 -6740 0 1 {name=p159357 lab=_55756_/X }
C {sky130_stdcells/and2_4.sym} 159940 -6740 0 0 {name=X_55756_ }
C {devices/lab_pin.sym} 159860 -6630 0 0 {name=p159358 lab=_45169_/A }
C {devices/lab_pin.sym} 159860 -6590 0 0 {name=p159359 lab=_74582_/X }
C {devices/lab_pin.sym} 159860 -6550 0 0 {name=p159360 lab=_74589_/X }
C {devices/lab_pin.sym} 160020 -6590 0 1 {name=p159361 lab=_74590_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -6590 0 0 {name=X_74590_ }
C {devices/lab_pin.sym} 159850 -6450 0 0 {name=p159362 lab=_86576_/CLK }
C {devices/lab_pin.sym} 159850 -6430 0 0 {name=p159363 lab=_86576_/D }
C {devices/lab_pin.sym} 160030 -6450 0 1 {name=p159364 lab=_66155_/B }
C {sky130_stdcells/dfxtp_4.sym} 159940 -6440 0 0 {name=X_86576_ }
C {devices/lab_pin.sym} 159900 -6310 0 0 {name=p159365 lab=_40982_/A }
C {devices/lab_pin.sym} 159980 -6310 0 1 {name=p159366 lab=_40982_/X }
C {sky130_stdcells/buf_2.sym} 159940 -6310 0 0 {name=X_40982_ }
C {devices/lab_pin.sym} 159860 -6210 0 0 {name=p159367 lab=_52966_/Y }
C {devices/lab_pin.sym} 159860 -6170 0 0 {name=p159368 lab=_52946_/X }
C {devices/lab_pin.sym} 159860 -6130 0 0 {name=p159369 lab=_52967_/X }
C {devices/lab_pin.sym} 160020 -6170 0 1 {name=p159370 lab=_85722_/D }
C {sky130_stdcells/a21oi_4.sym} 159940 -6170 0 0 {name=X_52968_ }
C {devices/lab_pin.sym} 159850 -6030 0 0 {name=p159371 lab=_81620_/CLK }
C {devices/lab_pin.sym} 159850 -6010 0 0 {name=p159372 lab=_83788_/D }
C {devices/lab_pin.sym} 160030 -6030 0 1 {name=p159373 lab=_74760_/A }
C {sky130_stdcells/dfxtp_4.sym} 159940 -6020 0 0 {name=X_83788_ }
C {devices/lab_pin.sym} 159900 -5890 0 0 {name=p159374 lab=_42720_/X }
C {devices/lab_pin.sym} 159980 -5890 0 1 {name=p159375 lab=_42721_/X }
C {sky130_stdcells/buf_2.sym} 159940 -5890 0 0 {name=X_42721_ }
C {devices/lab_pin.sym} 159850 -5770 0 0 {name=p159376 lab=_88056_/CLK }
C {devices/lab_pin.sym} 159850 -5750 0 0 {name=p159377 lab=_88315_/D }
C {devices/lab_pin.sym} 160030 -5770 0 1 {name=p159378 lab=_69888_/B }
C {sky130_stdcells/dfxtp_4.sym} 159940 -5760 0 0 {name=X_88315_ }
C {devices/lab_pin.sym} 159880 -5660 0 0 {name=p159379 lab=_54699_/X }
C {devices/lab_pin.sym} 159880 -5620 0 0 {name=p159380 lab=_54707_/B }
C {devices/lab_pin.sym} 159880 -5580 0 0 {name=p159381 lab=_54721_/C }
C {devices/lab_pin.sym} 159880 -5540 0 0 {name=p159382 lab=_47379_/A }
C {devices/lab_pin.sym} 160000 -5600 0 1 {name=p159383 lab=_54707_/X }
C {sky130_stdcells/and4_4.sym} 159940 -5600 0 0 {name=X_54707_ }
C {devices/lab_pin.sym} 159860 -5480 0 0 {name=p159384 lab=_72722_/X }
C {devices/lab_pin.sym} 159860 -5440 0 0 {name=p159385 lab=_83050_/Q }
C {devices/lab_pin.sym} 159860 -5400 0 0 {name=p159386 lab=_73406_/X }
C {devices/lab_pin.sym} 159860 -5360 0 0 {name=p159387 lab=_73540_/X }
C {devices/lab_pin.sym} 160020 -5420 0 1 {name=p159388 lab=_73542_/B }
C {sky130_stdcells/a211o_4.sym} 159940 -5420 0 0 {name=X_73541_ }
C {devices/lab_pin.sym} 159850 -5270 0 0 {name=p159389 lab=_85527_/CLK }
C {devices/lab_pin.sym} 159850 -5250 0 0 {name=p159390 lab=_53994_/Y }
C {devices/lab_pin.sym} 160030 -5270 0 1 {name=p159391 lab=_85527_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -5260 0 0 {name=X_85527_ }
C {devices/lab_pin.sym} 159880 -5160 0 0 {name=p159392 lab=_51914_/A }
C {devices/lab_pin.sym} 159880 -5120 0 0 {name=p159393 lab=_51898_/B }
C {devices/lab_pin.sym} 159880 -5080 0 0 {name=p159394 lab=_51919_/C }
C {devices/lab_pin.sym} 159880 -5040 0 0 {name=p159395 lab=_52746_/D }
C {devices/lab_pin.sym} 160000 -5100 0 1 {name=p159396 lab=_51919_/X }
C {sky130_stdcells/and4_4.sym} 159940 -5100 0 0 {name=X_51919_ }
C {devices/lab_pin.sym} 159880 -4960 0 0 {name=p159397 lab=_70753_/A }
C {devices/lab_pin.sym} 159880 -4920 0 0 {name=p159398 lab=_70724_/A }
C {devices/lab_pin.sym} 160000 -4940 0 1 {name=p159399 lab=_70753_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -4940 0 0 {name=X_70753_ }
C {devices/lab_pin.sym} 159860 -4830 0 0 {name=p159400 lab=_58467_/X }
C {devices/lab_pin.sym} 159860 -4790 0 0 {name=p159401 lab=_58472_/Y }
C {devices/lab_pin.sym} 159860 -4750 0 0 {name=p159402 lab=_58474_/Y }
C {devices/lab_pin.sym} 160020 -4790 0 1 {name=p159403 lab=_84840_/D }
C {sky130_stdcells/a21oi_4.sym} 159940 -4790 0 0 {name=X_58475_ }
C {devices/lab_pin.sym} 159850 -4650 0 0 {name=p159404 lab=_84177_/CLK }
C {devices/lab_pin.sym} 159850 -4630 0 0 {name=p159405 lab=_66435_/A }
C {devices/lab_pin.sym} 160030 -4650 0 1 {name=p159406 lab=_78965_/A }
C {sky130_stdcells/dfxtp_4.sym} 159940 -4640 0 0 {name=X_82739_ }
C {devices/lab_pin.sym} 159900 -4510 0 0 {name=p159407 lab=_55686_/Y }
C {devices/lab_pin.sym} 159980 -4510 0 1 {name=p159408 lab=_56169_/A }
C {sky130_stdcells/buf_2.sym} 159940 -4510 0 0 {name=X_55687_ }
C {devices/lab_pin.sym} 159900 -4390 0 0 {name=p159409 lab=_52845_/A }
C {devices/lab_pin.sym} 159980 -4390 0 1 {name=p159410 lab=_52900_/C }
C {sky130_stdcells/buf_2.sym} 159940 -4390 0 0 {name=X_52899_ }
C {devices/lab_pin.sym} 159860 -4290 0 0 {name=p159411 lab=_57275_/X }
C {devices/lab_pin.sym} 159860 -4250 0 0 {name=p159412 lab=_57003_/B }
C {devices/lab_pin.sym} 159860 -4210 0 0 {name=p159413 lab=_57425_/X }
C {devices/lab_pin.sym} 160020 -4250 0 1 {name=p159414 lab=_57426_/X }
C {sky130_stdcells/o21a_4.sym} 159940 -4250 0 0 {name=X_57426_ }
C {devices/lab_pin.sym} 159880 -4120 0 0 {name=p159415 lab=_45440_/A }
C {devices/lab_pin.sym} 159880 -4080 0 0 {name=p159416 lab=_44892_/X }
C {devices/lab_pin.sym} 160000 -4100 0 1 {name=p159417 lab=_45440_/Y }
C {sky130_stdcells/nor2_4.sym} 159940 -4100 0 0 {name=X_45440_ }
C {devices/lab_pin.sym} 159880 -3980 0 0 {name=p159418 lab=_81258_/Q }
C {devices/lab_pin.sym} 159880 -3940 0 0 {name=p159419 lab=_81514_/D }
C {devices/lab_pin.sym} 160000 -3960 0 1 {name=p159420 lab=_76260_/X }
C {sky130_stdcells/xor2_4.sym} 159940 -3960 0 0 {name=X_76260_ }
C {devices/lab_pin.sym} 159850 -3830 0 0 {name=p159421 lab=_88247_/CLK }
C {devices/lab_pin.sym} 159850 -3810 0 0 {name=p159422 lab=_41273_/X }
C {devices/lab_pin.sym} 160030 -3830 0 1 {name=p159423 lab=_88246_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -3820 0 0 {name=X_88246_ }
C {devices/lab_pin.sym} 159900 -3690 0 0 {name=p159424 lab=_42651_/X }
C {devices/lab_pin.sym} 159980 -3690 0 1 {name=p159425 lab=_42652_/X }
C {sky130_stdcells/buf_2.sym} 159940 -3690 0 0 {name=X_42652_ }
C {devices/lab_pin.sym} 159900 -3570 0 0 {name=p159426 lab=_73284_/A }
C {devices/lab_pin.sym} 159980 -3570 0 1 {name=p159427 lab=_73472_/X }
C {sky130_stdcells/buf_2.sym} 159940 -3570 0 0 {name=X_73472_ }
C {devices/lab_pin.sym} 159900 -3450 0 0 {name=p159428 lab=_54558_/A }
C {devices/lab_pin.sym} 159980 -3450 0 1 {name=p159429 lab=_54638_/X }
C {sky130_stdcells/buf_2.sym} 159940 -3450 0 0 {name=X_54638_ }
C {devices/lab_pin.sym} 159850 -3330 0 0 {name=p159430 lab=_85459_/CLK }
C {devices/lab_pin.sym} 159850 -3310 0 0 {name=p159431 lab=_85458_/D }
C {devices/lab_pin.sym} 160030 -3330 0 1 {name=p159432 lab=_85458_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -3320 0 0 {name=X_85458_ }
C {devices/lab_pin.sym} 159900 -3190 0 0 {name=p159433 lab=_71863_/A }
C {devices/lab_pin.sym} 159980 -3190 0 1 {name=p159434 lab=_71411_/A }
C {sky130_stdcells/buf_2.sym} 159940 -3190 0 0 {name=X_70684_ }
C {devices/lab_pin.sym} 159880 -3080 0 0 {name=p159435 lab=_80779_/Q }
C {devices/lab_pin.sym} 159880 -3040 0 0 {name=p159436 lab=_81035_/D }
C {devices/lab_pin.sym} 160000 -3060 0 1 {name=p159437 lab=_80747_/D }
C {sky130_stdcells/xor2_4.sym} 159940 -3060 0 0 {name=X_75211_ }
C {devices/lab_pin.sym} 159900 -2930 0 0 {name=p159438 lab=_40365_/X }
C {devices/lab_pin.sym} 159980 -2930 0 1 {name=p159439 lab=_41603_/X }
C {sky130_stdcells/buf_2.sym} 159940 -2930 0 0 {name=X_41603_ }
C {devices/lab_pin.sym} 159860 -2830 0 0 {name=p159440 lab=_72389_/X }
C {devices/lab_pin.sym} 159860 -2790 0 0 {name=p159441 lab=_85672_/Q }
C {devices/lab_pin.sym} 159860 -2750 0 0 {name=p159442 lab=_72422_/X }
C {devices/lab_pin.sym} 160020 -2790 0 1 {name=p159443 lab=_72423_/X }
C {sky130_stdcells/o21a_4.sym} 159940 -2790 0 0 {name=X_72423_ }
C {devices/lab_pin.sym} 159850 -2650 0 0 {name=p159444 lab=_84409_/CLK }
C {devices/lab_pin.sym} 159850 -2630 0 0 {name=p159445 lab=_84409_/D }
C {devices/lab_pin.sym} 160030 -2650 0 1 {name=p159446 lab=_76985_/B }
C {sky130_stdcells/dfxtp_4.sym} 159940 -2640 0 0 {name=X_84409_ }
C {devices/lab_pin.sym} 159860 -2530 0 0 {name=p159447 lab=_45350_/X }
C {devices/lab_pin.sym} 159860 -2490 0 0 {name=p159448 lab=_61682_/B }
C {devices/lab_pin.sym} 159860 -2450 0 0 {name=p159449 lab=_45370_/X }
C {devices/lab_pin.sym} 160020 -2490 0 1 {name=p159450 lab=_45371_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -2490 0 0 {name=X_45371_ }
C {devices/lab_pin.sym} 159860 -2390 0 0 {name=p159451 lab=_45891_/X }
C {devices/lab_pin.sym} 159860 -2350 0 0 {name=p159452 lab=_56995_/A }
C {devices/lab_pin.sym} 159860 -2310 0 0 {name=p159453 lab=_56275_/X }
C {devices/lab_pin.sym} 159860 -2270 0 0 {name=p159454 lab=_57364_/D }
C {devices/lab_pin.sym} 159860 -2240 0 0 {name=p159455 lab=_56901_/Y }
C {devices/lab_pin.sym} 160020 -2310 0 1 {name=p159456 lab=_57358_/A }
C {sky130_stdcells/a41o_4.sym} 159940 -2310 0 0 {name=X_57357_ }
C {devices/lab_pin.sym} 159900 -2150 0 0 {name=p159457 lab=_76190_/X }
C {devices/lab_pin.sym} 159980 -2150 0 1 {name=p159458 lab=_76193_/A }
C {sky130_stdcells/inv_2.sym} 159940 -2150 0 0 {name=X_76191_ }
C {devices/lab_pin.sym} 159850 -2030 0 0 {name=p159459 lab=_82896_/CLK }
C {devices/lab_pin.sym} 159850 -2010 0 0 {name=p159460 lab=_41644_/X }
C {devices/lab_pin.sym} 160030 -2030 0 1 {name=p159461 lab=_67385_/B }
C {sky130_stdcells/dfxtp_4.sym} 159940 -2020 0 0 {name=X_88177_ }
C {devices/lab_pin.sym} 159900 -1890 0 0 {name=p159462 lab=_42583_/A }
C {devices/lab_pin.sym} 159980 -1890 0 1 {name=p159463 lab=_42583_/Y }
C {sky130_stdcells/inv_2.sym} 159940 -1890 0 0 {name=X_42583_ }
C {devices/lab_pin.sym} 159880 -1780 0 0 {name=p159464 lab=_54578_/A }
C {devices/lab_pin.sym} 159880 -1740 0 0 {name=p159465 lab=_53390_/B }
C {devices/lab_pin.sym} 160000 -1760 0 1 {name=p159466 lab=_54569_/Y }
C {sky130_stdcells/nand2_4.sym} 159940 -1760 0 0 {name=X_54569_ }
C {devices/lab_pin.sym} 159850 -1630 0 0 {name=p159467 lab=_85485_/CLK }
C {devices/lab_pin.sym} 159850 -1610 0 0 {name=p159468 lab=_54728_/Y }
C {devices/lab_pin.sym} 160030 -1630 0 1 {name=p159469 lab=_85389_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -1620 0 0 {name=X_85389_ }
C {devices/lab_pin.sym} 159860 -1510 0 0 {name=p159470 lab=_59245_/A }
C {devices/lab_pin.sym} 159860 -1470 0 0 {name=p159471 lab=_47096_/X }
C {devices/lab_pin.sym} 159860 -1430 0 0 {name=p159472 lab=_47109_/Y }
C {devices/lab_pin.sym} 160020 -1470 0 1 {name=p159473 lab=_47110_/Y }
C {sky130_stdcells/o21ai_4.sym} 159940 -1470 0 0 {name=X_47110_ }
C {devices/lab_pin.sym} 159900 -1330 0 0 {name=p159474 lab=_44321_/Y }
C {devices/lab_pin.sym} 159980 -1330 0 1 {name=p159475 lab=_87167_/D }
C {sky130_stdcells/inv_2.sym} 159940 -1330 0 0 {name=X_44322_ }
C {devices/lab_pin.sym} 159900 -1210 0 0 {name=p159476 lab=_56347_/A }
C {devices/lab_pin.sym} 159980 -1210 0 1 {name=p159477 lab=_56309_/A }
C {sky130_stdcells/buf_2.sym} 159940 -1210 0 0 {name=X_56308_ }
C {devices/lab_pin.sym} 159880 -1110 0 0 {name=p159478 lab=_75142_/A }
C {devices/lab_pin.sym} 159880 -1070 0 0 {name=p159479 lab=_81063_/Q }
C {devices/lab_pin.sym} 159880 -1030 0 0 {name=p159480 lab=_75140_/Y }
C {devices/lab_pin.sym} 160000 -1070 0 1 {name=p159481 lab=_75145_/C }
C {sky130_stdcells/nand3_4.sym} 159940 -1070 0 0 {name=X_75142_ }
C {devices/lab_pin.sym} 159850 -930 0 0 {name=p159482 lab=_87436_/CLK }
C {devices/lab_pin.sym} 159850 -910 0 0 {name=p159483 lab=_44400_/Y }
C {devices/lab_pin.sym} 160030 -930 0 1 {name=p159484 lab=_87128_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159940 -920 0 0 {name=X_87128_ }
C {devices/lab_pin.sym} 159880 -800 0 0 {name=p159485 lab=_81170_/Q }
C {devices/lab_pin.sym} 159880 -760 0 0 {name=p159486 lab=_41471_/B }
C {devices/lab_pin.sym} 160000 -780 0 1 {name=p159487 lab=_41534_/X }
C {sky130_stdcells/or2_4.sym} 159940 -780 0 0 {name=X_41534_ }
C {devices/lab_pin.sym} 160780 -42170 0 0 {name=p159488 lab=_72352_/X }
C {devices/lab_pin.sym} 160780 -42130 0 0 {name=p159489 lab=_85966_/Q }
C {devices/lab_pin.sym} 160780 -42090 0 0 {name=p159490 lab=_72353_/X }
C {devices/lab_pin.sym} 160940 -42130 0 1 {name=p159491 lab=_72354_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -42130 0 0 {name=X_72354_ }
C {devices/lab_pin.sym} 160820 -41990 0 0 {name=p159492 lab=_83536_/Q }
C {devices/lab_pin.sym} 160900 -41990 0 1 {name=p159493 lab=_57617_/B }
C {sky130_stdcells/inv_2.sym} 160860 -41990 0 0 {name=X_48090_ }
C {devices/lab_pin.sym} 160800 -41880 0 0 {name=p159494 lab=_57153_/A }
C {devices/lab_pin.sym} 160800 -41840 0 0 {name=p159495 lab=_57322_/B }
C {devices/lab_pin.sym} 160920 -41860 0 1 {name=p159496 lab=_57295_/A }
C {sky130_stdcells/nand2_4.sym} 160860 -41860 0 0 {name=X_57288_ }
C {devices/lab_pin.sym} 160820 -41730 0 0 {name=p159497 lab=_83044_/Q }
C {devices/lab_pin.sym} 160900 -41730 0 1 {name=p159498 lab=_53336_/B }
C {sky130_stdcells/inv_2.sym} 160860 -41730 0 0 {name=X_47041_ }
C {devices/lab_pin.sym} 160820 -41610 0 0 {name=p159499 lab=_58918_/A }
C {devices/lab_pin.sym} 160900 -41610 0 1 {name=p159500 lab=_59027_/X }
C {sky130_stdcells/buf_2.sym} 160860 -41610 0 0 {name=X_59027_ }
C {devices/lab_pin.sym} 160820 -41490 0 0 {name=p159501 lab=_70387_/A }
C {devices/lab_pin.sym} 160900 -41490 0 1 {name=p159502 lab=_71680_/C }
C {sky130_stdcells/buf_2.sym} 160860 -41490 0 0 {name=X_71305_ }
C {devices/lab_pin.sym} 160820 -41370 0 0 {name=p159503 lab=_44184_/A }
C {devices/lab_pin.sym} 160900 -41370 0 1 {name=p159504 lab=_44253_/X }
C {sky130_stdcells/buf_2.sym} 160860 -41370 0 0 {name=X_44253_ }
C {devices/lab_pin.sym} 160820 -41250 0 0 {name=p159505 lab=_56252_/A }
C {devices/lab_pin.sym} 160900 -41250 0 1 {name=p159506 lab=_56250_/A }
C {sky130_stdcells/buf_2.sym} 160860 -41250 0 0 {name=X_56239_ }
C {devices/lab_pin.sym} 160800 -41140 0 0 {name=p159507 lab=_60139_/C }
C {devices/lab_pin.sym} 160800 -41100 0 0 {name=p159508 lab=_79950_/B }
C {devices/lab_pin.sym} 160920 -41120 0 1 {name=p159509 lab=_79957_/A }
C {sky130_stdcells/xor2_4.sym} 160860 -41120 0 0 {name=X_79950_ }
C {devices/lab_pin.sym} 160800 -41010 0 0 {name=p159510 lab=_75067_/Y }
C {devices/lab_pin.sym} 160800 -40970 0 0 {name=p159511 lab=_75069_/B }
C {devices/lab_pin.sym} 160800 -40930 0 0 {name=p159512 lab=_75070_/Y }
C {devices/lab_pin.sym} 160920 -40970 0 1 {name=p159513 lab=_75074_/B }
C {sky130_stdcells/nand3_4.sym} 160860 -40970 0 0 {name=X_75073_ }
C {devices/lab_pin.sym} 160770 -40830 0 0 {name=p159514 lab=_88108_/CLK }
C {devices/lab_pin.sym} 160770 -40810 0 0 {name=p159515 lab=_44546_/Y }
C {devices/lab_pin.sym} 160950 -40830 0 1 {name=p159516 lab=_87059_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -40820 0 0 {name=X_87059_ }
C {devices/lab_pin.sym} 160820 -40690 0 0 {name=p159517 lab=_41464_/Y }
C {devices/lab_pin.sym} 160900 -40690 0 1 {name=p159518 lab=_41465_/X }
C {sky130_stdcells/buf_2.sym} 160860 -40690 0 0 {name=X_41465_ }
C {devices/lab_pin.sym} 160780 -40600 0 0 {name=p159519 lab=_83268_/Q }
C {devices/lab_pin.sym} 160780 -40560 0 0 {name=p159520 lab=_72250_/X }
C {devices/lab_pin.sym} 160780 -40520 0 0 {name=p159521 lab=_72279_/X }
C {devices/lab_pin.sym} 160780 -40480 0 0 {name=p159522 lab=_72284_/X }
C {devices/lab_pin.sym} 160940 -40540 0 1 {name=p159523 lab=_83268_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 160860 -40540 0 0 {name=X_72285_ }
C {devices/lab_pin.sym} 160780 -40430 0 0 {name=p159524 lab=_43047_/X }
C {devices/lab_pin.sym} 160780 -40390 0 0 {name=p159525 lab=_53944_/A }
C {devices/lab_pin.sym} 160780 -40350 0 0 {name=p159526 lab=_40929_/X }
C {devices/lab_pin.sym} 160780 -40310 0 0 {name=p159527 lab=_43203_/Y }
C {devices/lab_pin.sym} 160780 -40270 0 0 {name=p159528 lab=_43021_/X }
C {devices/lab_pin.sym} 160940 -40350 0 1 {name=p159529 lab=_43204_/Y }
C {sky130_stdcells/o32ai_4.sym} 160860 -40350 0 0 {name=X_43204_ }
C {devices/lab_pin.sym} 160780 -40220 0 0 {name=p159530 lab=_73907_/X }
C {devices/lab_pin.sym} 160780 -40180 0 0 {name=p159531 lab=_84974_/Q }
C {devices/lab_pin.sym} 160780 -40140 0 0 {name=p159532 lab=_74021_/X }
C {devices/lab_pin.sym} 160780 -40100 0 0 {name=p159533 lab=_74023_/X }
C {devices/lab_pin.sym} 160940 -40160 0 1 {name=p159534 lab=_74025_/B }
C {sky130_stdcells/a211o_4.sym} 160860 -40160 0 0 {name=X_74024_ }
C {devices/lab_pin.sym} 160800 -40020 0 0 {name=p159535 lab=_82732_/Q }
C {devices/lab_pin.sym} 160800 -39980 0 0 {name=p159536 lab=_78901_/B }
C {devices/lab_pin.sym} 160920 -40000 0 1 {name=p159537 lab=_82700_/D }
C {sky130_stdcells/xor2_4.sym} 160860 -40000 0 0 {name=X_78901_ }
C {devices/lab_pin.sym} 160800 -39880 0 0 {name=p159538 lab=_40416_/A }
C {devices/lab_pin.sym} 160800 -39840 0 0 {name=p159539 lab=_81176_/Q }
C {devices/lab_pin.sym} 160920 -39860 0 1 {name=p159540 lab=_40416_/X }
C {sky130_stdcells/or2_4.sym} 160860 -39860 0 0 {name=X_40416_ }
C {devices/lab_pin.sym} 160780 -39750 0 0 {name=p159541 lab=_48872_/B }
C {devices/lab_pin.sym} 160780 -39710 0 0 {name=p159542 lab=_71236_/A2 }
C {devices/lab_pin.sym} 160780 -39670 0 0 {name=p159543 lab=_71235_/Y }
C {devices/lab_pin.sym} 160940 -39710 0 1 {name=p159544 lab=_71236_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -39710 0 0 {name=X_71236_ }
C {devices/lab_pin.sym} 160820 -39570 0 0 {name=p159545 lab=_44184_/A }
C {devices/lab_pin.sym} 160900 -39570 0 1 {name=p159546 lab=_44184_/X }
C {sky130_stdcells/buf_2.sym} 160860 -39570 0 0 {name=X_44184_ }
C {devices/lab_pin.sym} 160800 -39460 0 0 {name=p159547 lab=_79870_/Y }
C {devices/lab_pin.sym} 160800 -39420 0 0 {name=p159548 lab=_79873_/Y }
C {devices/lab_pin.sym} 160920 -39440 0 1 {name=p159549 lab=_79881_/X }
C {sky130_stdcells/or2_4.sym} 160860 -39440 0 0 {name=X_79881_ }
C {devices/lab_pin.sym} 160780 -39330 0 0 {name=p159550 lab=_41324_/X }
C {devices/lab_pin.sym} 160780 -39290 0 0 {name=p159551 lab=_82892_/Q }
C {devices/lab_pin.sym} 160780 -39250 0 0 {name=p159552 lab=_41395_/X }
C {devices/lab_pin.sym} 160940 -39290 0 1 {name=p159553 lab=_41397_/A }
C {sky130_stdcells/o21ai_4.sym} 160860 -39290 0 0 {name=X_41396_ }
C {devices/lab_pin.sym} 160820 -39150 0 0 {name=p159554 lab=clkbuf_8_51_0_CLK/A }
C {devices/lab_pin.sym} 160900 -39150 0 1 {name=p159555 lab=clkbuf_8_51_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 160860 -39150 0 0 {name=Xclkbuf_8_51_0_CLK }
C {devices/lab_pin.sym} 160820 -39030 0 0 {name=p159556 lab=_87563_/Q }
C {devices/lab_pin.sym} 160900 -39030 0 1 {name=p159557 lab=_43135_/Y }
C {sky130_stdcells/inv_2.sym} 160860 -39030 0 0 {name=X_43135_ }
C {devices/lab_pin.sym} 160820 -38910 0 0 {name=p159558 lab=_82629_/Q }
C {devices/lab_pin.sym} 160900 -38910 0 1 {name=p159559 lab=_78841_/B }
C {sky130_stdcells/inv_2.sym} 160860 -38910 0 0 {name=X_78832_ }
C {devices/lab_pin.sym} 160820 -38790 0 0 {name=p159560 lab=_40361_/A }
C {devices/lab_pin.sym} 160900 -38790 0 1 {name=p159561 lab=_46450_/A }
C {sky130_stdcells/buf_2.sym} 160860 -38790 0 0 {name=X_40347_ }
C {devices/lab_pin.sym} 160820 -38670 0 0 {name=p159562 lab=_70611_/X }
C {devices/lab_pin.sym} 160900 -38670 0 1 {name=p159563 lab=_71178_/D }
C {sky130_stdcells/buf_2.sym} 160860 -38670 0 0 {name=X_71167_ }
C {devices/lab_pin.sym} 160820 -38550 0 0 {name=p159564 lab=_72012_/B }
C {devices/lab_pin.sym} 160900 -38550 0 1 {name=p159565 lab=_48992_/X }
C {sky130_stdcells/buf_2.sym} 160860 -38550 0 0 {name=X_48992_ }
C {devices/lab_pin.sym} 160800 -38460 0 0 {name=p159566 lab=_70102_/Y }
C {devices/lab_pin.sym} 160800 -38420 0 0 {name=p159567 lab=_70107_/Y }
C {devices/lab_pin.sym} 160800 -38380 0 0 {name=p159568 lab=_70118_/C }
C {devices/lab_pin.sym} 160800 -38340 0 0 {name=p159569 lab=_70118_/D }
C {devices/lab_pin.sym} 160920 -38400 0 1 {name=p159570 lab=_70118_/Y }
C {sky130_stdcells/nor4_4.sym} 160860 -38400 0 0 {name=X_70118_ }
C {devices/lab_pin.sym} 160800 -38260 0 0 {name=p159571 lab=_47943_/A }
C {devices/lab_pin.sym} 160800 -38220 0 0 {name=p159572 lab=_46371_/A }
C {devices/lab_pin.sym} 160920 -38240 0 1 {name=p159573 lab=_47943_/X }
C {sky130_stdcells/or2_4.sym} 160860 -38240 0 0 {name=X_47943_ }
C {devices/lab_pin.sym} 160780 -38150 0 0 {name=p159574 lab=_43038_/X }
C {devices/lab_pin.sym} 160780 -38110 0 0 {name=p159575 lab=_43050_/X }
C {devices/lab_pin.sym} 160780 -38070 0 0 {name=p159576 lab=_40667_/X }
C {devices/lab_pin.sym} 160780 -38030 0 0 {name=p159577 lab=_73895_/A }
C {devices/lab_pin.sym} 160780 -37990 0 0 {name=p159578 lab=_43061_/X }
C {devices/lab_pin.sym} 160940 -38070 0 1 {name=p159579 lab=_43066_/Y }
C {sky130_stdcells/o32ai_4.sym} 160860 -38070 0 0 {name=X_43066_ }
C {devices/lab_pin.sym} 160800 -37940 0 0 {name=p159580 lab=_62237_/A }
C {devices/lab_pin.sym} 160800 -37900 0 0 {name=p159581 lab=_59918_/Y }
C {devices/lab_pin.sym} 160800 -37860 0 0 {name=p159582 lab=_59929_/C }
C {devices/lab_pin.sym} 160800 -37820 0 0 {name=p159583 lab=_59985_/A }
C {devices/lab_pin.sym} 160920 -37880 0 1 {name=p159584 lab=_62196_/A }
C {sky130_stdcells/and4_4.sym} 160860 -37880 0 0 {name=X_59929_ }
C {devices/lab_pin.sym} 160820 -37730 0 0 {name=p159585 lab=_78761_/X }
C {devices/lab_pin.sym} 160900 -37730 0 1 {name=p159586 lab=_78764_/A }
C {sky130_stdcells/inv_2.sym} 160860 -37730 0 0 {name=X_78763_ }
C {devices/lab_pin.sym} 160780 -37630 0 0 {name=p159587 lab=_50133_/B }
C {devices/lab_pin.sym} 160780 -37590 0 0 {name=p159588 lab=_71095_/X }
C {devices/lab_pin.sym} 160780 -37550 0 0 {name=p159589 lab=_71097_/Y }
C {devices/lab_pin.sym} 160940 -37590 0 1 {name=p159590 lab=_83609_/D }
C {sky130_stdcells/o21ai_4.sym} 160860 -37590 0 0 {name=X_71098_ }
C {devices/lab_pin.sym} 160800 -37460 0 0 {name=p159591 lab=_75961_/A }
C {devices/lab_pin.sym} 160800 -37420 0 0 {name=p159592 lab=_75970_/A }
C {devices/lab_pin.sym} 160920 -37440 0 1 {name=p159593 lab=_75975_/Y }
C {sky130_stdcells/nand2_4.sym} 160860 -37440 0 0 {name=X_75975_ }
C {devices/lab_pin.sym} 160820 -37310 0 0 {name=p159594 lab=_42017_/A }
C {devices/lab_pin.sym} 160900 -37310 0 1 {name=p159595 lab=_42017_/Y }
C {sky130_stdcells/inv_2.sym} 160860 -37310 0 0 {name=X_42017_ }
C {devices/lab_pin.sym} 160800 -37200 0 0 {name=p159596 lab=_82241_/Q }
C {devices/lab_pin.sym} 160800 -37160 0 0 {name=p159597 lab=_77713_/Y }
C {devices/lab_pin.sym} 160920 -37180 0 1 {name=p159598 lab=_77715_/B }
C {sky130_stdcells/xnor2_4.sym} 160860 -37180 0 0 {name=X_77714_ }
C {devices/lab_pin.sym} 160800 -37080 0 0 {name=p159599 lab=_62967_/A }
C {devices/lab_pin.sym} 160800 -37040 0 0 {name=p159600 lab=_63295_/A }
C {devices/lab_pin.sym} 160800 -37000 0 0 {name=p159601 lab=_62939_/X }
C {devices/lab_pin.sym} 160800 -36960 0 0 {name=p159602 lab=_62967_/D }
C {devices/lab_pin.sym} 160920 -37020 0 1 {name=p159603 lab=_62940_/X }
C {sky130_stdcells/and4_4.sym} 160860 -37020 0 0 {name=X_62940_ }
C {devices/lab_pin.sym} 160800 -36880 0 0 {name=p159604 lab=_74926_/A }
C {devices/lab_pin.sym} 160800 -36840 0 0 {name=p159605 lab=_74925_/Y }
C {devices/lab_pin.sym} 160920 -36860 0 1 {name=p159606 lab=_74927_/B }
C {sky130_stdcells/xor2_4.sym} 160860 -36860 0 0 {name=X_74926_ }
C {devices/lab_pin.sym} 160780 -36750 0 0 {name=p159607 lab=_68831_/X }
C {devices/lab_pin.sym} 160780 -36710 0 0 {name=p159608 lab=_68834_/X }
C {devices/lab_pin.sym} 160780 -36670 0 0 {name=p159609 lab=_70044_/X }
C {devices/lab_pin.sym} 160940 -36710 0 1 {name=p159610 lab=_70049_/Y }
C {sky130_stdcells/a21oi_4.sym} 160860 -36710 0 0 {name=X_70049_ }
C {devices/lab_pin.sym} 160820 -36570 0 0 {name=p159611 lab=_52309_/A }
C {devices/lab_pin.sym} 160900 -36570 0 1 {name=p159612 lab=_49312_/C }
C {sky130_stdcells/buf_2.sym} 160860 -36570 0 0 {name=X_47874_ }
C {devices/lab_pin.sym} 160820 -36450 0 0 {name=p159613 lab=clkbuf_8_67_0_CLK/A }
C {devices/lab_pin.sym} 160900 -36450 0 1 {name=p159614 lab=clkbuf_8_66_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 160860 -36450 0 0 {name=Xclkbuf_8_66_0_CLK }
C {devices/lab_pin.sym} 160780 -36350 0 0 {name=p159615 lab=_78690_/Y }
C {devices/lab_pin.sym} 160780 -36310 0 0 {name=p159616 lab=_78693_/C }
C {devices/lab_pin.sym} 160780 -36270 0 0 {name=p159617 lab=_78689_/Y }
C {devices/lab_pin.sym} 160940 -36310 0 1 {name=p159618 lab=_78694_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -36310 0 0 {name=X_78694_ }
C {devices/lab_pin.sym} 160780 -36190 0 0 {name=p159619 lab=_86355_/Q }
C {devices/lab_pin.sym} 160780 -36150 0 0 {name=p159620 lab=_49606_/X }
C {devices/lab_pin.sym} 160780 -36110 0 0 {name=p159621 lab=_49612_/Y }
C {devices/lab_pin.sym} 160940 -36150 0 1 {name=p159622 lab=_49613_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -36150 0 0 {name=X_49613_ }
C {devices/lab_pin.sym} 160820 -36010 0 0 {name=p159623 lab=_52696_/B }
C {devices/lab_pin.sym} 160900 -36010 0 1 {name=p159624 lab=_51003_/B }
C {sky130_stdcells/buf_2.sym} 160860 -36010 0 0 {name=X_46825_ }
C {devices/lab_pin.sym} 160800 -35900 0 0 {name=p159625 lab=_77644_/Y }
C {devices/lab_pin.sym} 160800 -35860 0 0 {name=p159626 lab=_77645_/B }
C {devices/lab_pin.sym} 160920 -35880 0 1 {name=p159627 lab=_77648_/A }
C {sky130_stdcells/nand2_4.sym} 160860 -35880 0 0 {name=X_77645_ }
C {devices/lab_pin.sym} 160800 -35760 0 0 {name=p159628 lab=_74865_/A }
C {devices/lab_pin.sym} 160800 -35720 0 0 {name=p159629 lab=_74856_/Y }
C {devices/lab_pin.sym} 160920 -35740 0 1 {name=p159630 lab=_74857_/Y }
C {sky130_stdcells/nor2_4.sym} 160860 -35740 0 0 {name=X_74857_ }
C {devices/lab_pin.sym} 160800 -35640 0 0 {name=p159631 lab=_62847_/X }
C {devices/lab_pin.sym} 160800 -35600 0 0 {name=p159632 lab=_58440_/Y }
C {devices/lab_pin.sym} 160800 -35560 0 0 {name=p159633 lab=_62911_/C }
C {devices/lab_pin.sym} 160800 -35520 0 0 {name=p159634 lab=_62880_/D }
C {devices/lab_pin.sym} 160920 -35580 0 1 {name=p159635 lab=_62871_/X }
C {sky130_stdcells/and4_4.sym} 160860 -35580 0 0 {name=X_62871_ }
C {devices/lab_pin.sym} 160780 -35450 0 0 {name=p159636 lab=_64606_/Y }
C {devices/lab_pin.sym} 160780 -35410 0 0 {name=p159637 lab=_60349_/X }
C {devices/lab_pin.sym} 160780 -35370 0 0 {name=p159638 lab=_64609_/X }
C {devices/lab_pin.sym} 160940 -35410 0 1 {name=p159639 lab=_64610_/X }
C {sky130_stdcells/a21o_4.sym} 160860 -35410 0 0 {name=X_64610_ }
C {devices/lab_pin.sym} 160800 -35300 0 0 {name=p159640 lab=_49561_/A }
C {devices/lab_pin.sym} 160800 -35260 0 0 {name=p159641 lab=_49537_/B }
C {devices/lab_pin.sym} 160800 -35220 0 0 {name=p159642 lab=_49522_/C }
C {devices/lab_pin.sym} 160800 -35180 0 0 {name=p159643 lab=_52758_/D }
C {devices/lab_pin.sym} 160920 -35240 0 1 {name=p159644 lab=_49544_/X }
C {sky130_stdcells/and4_4.sym} 160860 -35240 0 0 {name=X_49544_ }
C {devices/lab_pin.sym} 160780 -35110 0 0 {name=p159645 lab=_61816_/Y }
C {devices/lab_pin.sym} 160780 -35070 0 0 {name=p159646 lab=_61801_/X }
C {devices/lab_pin.sym} 160780 -35030 0 0 {name=p159647 lab=_61821_/Y }
C {devices/lab_pin.sym} 160940 -35070 0 1 {name=p159648 lab=_61822_/Y }
C {sky130_stdcells/a21oi_4.sym} 160860 -35070 0 0 {name=X_61822_ }
C {devices/lab_pin.sym} 160780 -34960 0 0 {name=p159649 lab=_73735_/X }
C {devices/lab_pin.sym} 160780 -34920 0 0 {name=p159650 lab=_85623_/Q }
C {devices/lab_pin.sym} 160780 -34880 0 0 {name=p159651 lab=_73782_/X }
C {devices/lab_pin.sym} 160780 -34840 0 0 {name=p159652 lab=_73807_/X }
C {devices/lab_pin.sym} 160940 -34900 0 1 {name=p159653 lab=_73808_/X }
C {sky130_stdcells/a211o_4.sym} 160860 -34900 0 0 {name=X_73808_ }
C {devices/lab_pin.sym} 160780 -34770 0 0 {name=p159654 lab=_46750_/Y }
C {devices/lab_pin.sym} 160780 -34730 0 0 {name=p159655 lab=_46751_/X }
C {devices/lab_pin.sym} 160780 -34690 0 0 {name=p159656 lab=_46755_/X }
C {devices/lab_pin.sym} 160940 -34730 0 1 {name=p159657 lab=_86707_/D }
C {sky130_stdcells/a21oi_4.sym} 160860 -34730 0 0 {name=X_46756_ }
C {devices/lab_pin.sym} 160800 -34600 0 0 {name=p159658 lab=_65667_/A }
C {devices/lab_pin.sym} 160800 -34560 0 0 {name=p159659 lab=_85878_/Q }
C {devices/lab_pin.sym} 160920 -34580 0 1 {name=p159660 lab=_65590_/X }
C {sky130_stdcells/and2_4.sym} 160860 -34580 0 0 {name=X_65590_ }
C {devices/lab_pin.sym} 160800 -34460 0 0 {name=p159661 lab=_77576_/A }
C {devices/lab_pin.sym} 160800 -34420 0 0 {name=p159662 lab=_77576_/B }
C {devices/lab_pin.sym} 160920 -34440 0 1 {name=p159663 lab=_77578_/A }
C {sky130_stdcells/and2_4.sym} 160860 -34440 0 0 {name=X_77576_ }
C {devices/lab_pin.sym} 160780 -34340 0 0 {name=p159664 lab=_86841_/Q }
C {devices/lab_pin.sym} 160780 -34300 0 0 {name=p159665 lab=_43987_/B }
C {devices/lab_pin.sym} 160780 -34260 0 0 {name=p159666 lab=_43955_/Y }
C {devices/lab_pin.sym} 160780 -34220 0 0 {name=p159667 lab=_43967_/X }
C {devices/lab_pin.sym} 160940 -34280 0 1 {name=p159668 lab=_43969_/B }
C {sky130_stdcells/a211o_4.sym} 160860 -34280 0 0 {name=X_43968_ }
C {devices/lab_pin.sym} 160800 -34140 0 0 {name=p159669 lab=_74788_/A }
C {devices/lab_pin.sym} 160800 -34100 0 0 {name=p159670 lab=_71507_/B }
C {devices/lab_pin.sym} 160920 -34120 0 1 {name=p159671 lab=_74788_/Y }
C {sky130_stdcells/nor2_4.sym} 160860 -34120 0 0 {name=X_74788_ }
C {devices/lab_pin.sym} 160780 -34010 0 0 {name=p159672 lab=_79303_/A }
C {devices/lab_pin.sym} 160780 -33970 0 0 {name=p159673 lab=_79302_/Y }
C {devices/lab_pin.sym} 160780 -33930 0 0 {name=p159674 lab=_79314_/X }
C {devices/lab_pin.sym} 160940 -33970 0 1 {name=p159675 lab=_79315_/X }
C {sky130_stdcells/a21o_4.sym} 160860 -33970 0 0 {name=X_79315_ }
C {devices/lab_pin.sym} 160780 -33850 0 0 {name=p159676 lab=_85037_/Q }
C {devices/lab_pin.sym} 160780 -33810 0 0 {name=p159677 lab=_45675_/X }
C {devices/lab_pin.sym} 160780 -33770 0 0 {name=p159678 lab=_45706_/X }
C {devices/lab_pin.sym} 160940 -33810 0 1 {name=p159679 lab=_45707_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -33810 0 0 {name=X_45707_ }
C {devices/lab_pin.sym} 160780 -33690 0 0 {name=p159680 lab=_79552_/A }
C {devices/lab_pin.sym} 160780 -33650 0 0 {name=p159681 lab=_64532_/X }
C {devices/lab_pin.sym} 160780 -33610 0 0 {name=p159682 lab=_64540_/Y }
C {devices/lab_pin.sym} 160940 -33650 0 1 {name=p159683 lab=_84236_/D }
C {sky130_stdcells/o21ai_4.sym} 160860 -33650 0 0 {name=X_64541_ }
C {devices/lab_pin.sym} 160800 -33520 0 0 {name=p159684 lab=_76519_/X }
C {devices/lab_pin.sym} 160800 -33480 0 0 {name=p159685 lab=_76526_/X }
C {devices/lab_pin.sym} 160920 -33500 0 1 {name=p159686 lab=_76584_/A }
C {sky130_stdcells/xnor2_4.sym} 160860 -33500 0 0 {name=X_76527_ }
C {devices/lab_pin.sym} 160820 -33370 0 0 {name=p159687 lab=_42919_/A }
C {devices/lab_pin.sym} 160900 -33370 0 1 {name=p159688 lab=_87652_/D }
C {sky130_stdcells/inv_2.sym} 160860 -33370 0 0 {name=X_42919_ }
C {devices/lab_pin.sym} 160780 -33270 0 0 {name=p159689 lab=_61751_/Y }
C {devices/lab_pin.sym} 160780 -33230 0 0 {name=p159690 lab=_61699_/X }
C {devices/lab_pin.sym} 160780 -33190 0 0 {name=p159691 lab=_61752_/Y }
C {devices/lab_pin.sym} 160940 -33230 0 1 {name=p159692 lab=_61753_/Y }
C {sky130_stdcells/a21oi_4.sym} 160860 -33230 0 0 {name=X_61753_ }
C {devices/lab_pin.sym} 160780 -33110 0 0 {name=p159693 lab=_49473_/Y }
C {devices/lab_pin.sym} 160780 -33070 0 0 {name=p159694 lab=_49460_/X }
C {devices/lab_pin.sym} 160780 -33030 0 0 {name=p159695 lab=_49474_/X }
C {devices/lab_pin.sym} 160940 -33070 0 1 {name=p159696 lab=_86381_/D }
C {sky130_stdcells/a21oi_4.sym} 160860 -33070 0 0 {name=X_49475_ }
C {devices/lab_pin.sym} 160780 -32950 0 0 {name=p159697 lab=_73734_/X }
C {devices/lab_pin.sym} 160780 -32910 0 0 {name=p159698 lab=_73737_/X }
C {devices/lab_pin.sym} 160780 -32870 0 0 {name=p159699 lab=_73738_/X }
C {devices/lab_pin.sym} 160940 -32910 0 1 {name=p159700 lab=_73739_/X }
C {sky130_stdcells/a21o_4.sym} 160860 -32910 0 0 {name=X_73739_ }
C {devices/lab_pin.sym} 160780 -32790 0 0 {name=p159701 lab=_58660_/A }
C {devices/lab_pin.sym} 160780 -32750 0 0 {name=p159702 lab=_46672_/X }
C {devices/lab_pin.sym} 160780 -32710 0 0 {name=p159703 lab=_46686_/Y }
C {devices/lab_pin.sym} 160940 -32750 0 1 {name=p159704 lab=_46687_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -32750 0 0 {name=X_46687_ }
C {devices/lab_pin.sym} 160820 -32610 0 0 {name=p159705 lab=_43898_/Y }
C {devices/lab_pin.sym} 160900 -32610 0 1 {name=p159706 lab=_87210_/D }
C {sky130_stdcells/inv_2.sym} 160860 -32610 0 0 {name=X_43899_ }
C {devices/lab_pin.sym} 160820 -32490 0 0 {name=p159707 lab=_60703_/Y }
C {devices/lab_pin.sym} 160900 -32490 0 1 {name=p159708 lab=_60704_/Y }
C {sky130_stdcells/inv_2.sym} 160860 -32490 0 0 {name=X_60704_ }
C {devices/lab_pin.sym} 160820 -32370 0 0 {name=p159709 lab=_48426_/A }
C {devices/lab_pin.sym} 160900 -32370 0 1 {name=p159710 lab=_48426_/Y }
C {sky130_stdcells/inv_2.sym} 160860 -32370 0 0 {name=X_48426_ }
C {devices/lab_pin.sym} 160800 -32260 0 0 {name=p159711 lab=_79244_/X }
C {devices/lab_pin.sym} 160800 -32220 0 0 {name=p159712 lab=_79246_/B }
C {devices/lab_pin.sym} 160920 -32240 0 1 {name=p159713 lab=_79246_/Y }
C {sky130_stdcells/xnor2_4.sym} 160860 -32240 0 0 {name=X_79246_ }
C {devices/lab_pin.sym} 160780 -32140 0 0 {name=p159714 lab=_87862_/Q }
C {devices/lab_pin.sym} 160780 -32100 0 0 {name=p159715 lab=_67236_/X }
C {devices/lab_pin.sym} 160780 -32060 0 0 {name=p159716 lab=_67167_/X }
C {devices/lab_pin.sym} 160780 -32020 0 0 {name=p159717 lab=_67259_/X }
C {devices/lab_pin.sym} 160940 -32080 0 1 {name=p159718 lab=_67260_/X }
C {sky130_stdcells/a211o_4.sym} 160860 -32080 0 0 {name=X_67260_ }
C {devices/lab_pin.sym} 160800 -31940 0 0 {name=p159719 lab=_45638_/A }
C {devices/lab_pin.sym} 160800 -31900 0 0 {name=p159720 lab=_45654_/B }
C {devices/lab_pin.sym} 160920 -31920 0 1 {name=p159721 lab=_45638_/Y }
C {sky130_stdcells/nand2_4.sym} 160860 -31920 0 0 {name=X_45638_ }
C {devices/lab_pin.sym} 160780 -31810 0 0 {name=p159722 lab=_79649_/B }
C {devices/lab_pin.sym} 160780 -31770 0 0 {name=p159723 lab=_64429_/X }
C {devices/lab_pin.sym} 160780 -31730 0 0 {name=p159724 lab=_64471_/X }
C {devices/lab_pin.sym} 160940 -31770 0 1 {name=p159725 lab=_64472_/X }
C {sky130_stdcells/a21o_4.sym} 160860 -31770 0 0 {name=X_64472_ }
C {devices/lab_pin.sym} 160800 -31640 0 0 {name=p159726 lab=_76439_/X }
C {devices/lab_pin.sym} 160800 -31600 0 0 {name=p159727 lab=_76438_/A }
C {devices/lab_pin.sym} 160920 -31620 0 1 {name=p159728 lab=_76458_/Y }
C {sky130_stdcells/nand2_4.sym} 160860 -31620 0 0 {name=X_76458_ }
C {devices/lab_pin.sym} 160800 -31510 0 0 {name=p159729 lab=_61292_/A }
C {devices/lab_pin.sym} 160800 -31470 0 0 {name=p159730 lab=_61683_/X }
C {devices/lab_pin.sym} 160800 -31430 0 0 {name=p159731 lab=_61675_/C }
C {devices/lab_pin.sym} 160920 -31470 0 1 {name=p159732 lab=_61684_/Y }
C {sky130_stdcells/nand3_4.sym} 160860 -31470 0 0 {name=X_61684_ }
C {devices/lab_pin.sym} 160800 -31340 0 0 {name=p159733 lab=_44263_/X }
C {devices/lab_pin.sym} 160800 -31300 0 0 {name=p159734 lab=_66211_/B }
C {devices/lab_pin.sym} 160920 -31320 0 1 {name=p159735 lab=_66211_/X }
C {sky130_stdcells/and2_4.sym} 160860 -31320 0 0 {name=X_66211_ }
C {devices/lab_pin.sym} 160820 -31190 0 0 {name=p159736 lab=_63484_/A }
C {devices/lab_pin.sym} 160900 -31190 0 1 {name=p159737 lab=_63448_/A }
C {sky130_stdcells/buf_2.sym} 160860 -31190 0 0 {name=X_63423_ }
C {devices/lab_pin.sym} 160820 -31070 0 0 {name=p159738 lab=_75409_/A }
C {devices/lab_pin.sym} 160900 -31070 0 1 {name=p159739 lab=_75413_/A }
C {sky130_stdcells/inv_2.sym} 160860 -31070 0 0 {name=X_75409_ }
C {devices/lab_pin.sym} 160820 -30950 0 0 {name=p159740 lab=_83593_/Q }
C {devices/lab_pin.sym} 160900 -30950 0 1 {name=p159741 lab=_48357_/Y }
C {sky130_stdcells/inv_2.sym} 160860 -30950 0 0 {name=X_48357_ }
C {devices/lab_pin.sym} 160800 -30840 0 0 {name=p159742 lab=_60694_/C }
C {devices/lab_pin.sym} 160800 -30800 0 0 {name=p159743 lab=_60725_/A }
C {devices/lab_pin.sym} 160920 -30820 0 1 {name=p159744 lab=_60820_/B }
C {sky130_stdcells/nand2_4.sym} 160860 -30820 0 0 {name=X_60635_ }
C {devices/lab_pin.sym} 160780 -30720 0 0 {name=p159745 lab=_87417_/Q }
C {devices/lab_pin.sym} 160780 -30680 0 0 {name=p159746 lab=_67121_/X }
C {devices/lab_pin.sym} 160780 -30640 0 0 {name=p159747 lab=_67122_/X }
C {devices/lab_pin.sym} 160780 -30600 0 0 {name=p159748 lab=_67190_/X }
C {devices/lab_pin.sym} 160940 -30660 0 1 {name=p159749 lab=_67191_/X }
C {sky130_stdcells/a211o_4.sym} 160860 -30660 0 0 {name=X_67191_ }
C {devices/lab_pin.sym} 160800 -30520 0 0 {name=p159750 lab=_79171_/Y }
C {devices/lab_pin.sym} 160800 -30480 0 0 {name=p159751 lab=_79176_/Y }
C {devices/lab_pin.sym} 160920 -30500 0 1 {name=p159752 lab=_79523_/B }
C {sky130_stdcells/nand2_4.sym} 160860 -30500 0 0 {name=X_79177_ }
C {devices/lab_pin.sym} 160820 -30370 0 0 {name=p159753 lab=_85078_/Q }
C {devices/lab_pin.sym} 160900 -30370 0 1 {name=p159754 lab=_55508_/B }
C {sky130_stdcells/inv_2.sym} 160860 -30370 0 0 {name=X_45569_ }
C {devices/lab_pin.sym} 160800 -30260 0 0 {name=p159755 lab=_81266_/Q }
C {devices/lab_pin.sym} 160800 -30220 0 0 {name=p159756 lab=_81522_/D }
C {devices/lab_pin.sym} 160920 -30240 0 1 {name=p159757 lab=_76389_/Y }
C {sky130_stdcells/nor2_4.sym} 160860 -30240 0 0 {name=X_76389_ }
C {devices/lab_pin.sym} 160780 -30130 0 0 {name=p159758 lab=_86648_/Q }
C {devices/lab_pin.sym} 160780 -30090 0 0 {name=p159759 lab=_47286_/X }
C {devices/lab_pin.sym} 160780 -30050 0 0 {name=p159760 lab=_47307_/Y }
C {devices/lab_pin.sym} 160940 -30090 0 1 {name=p159761 lab=_47308_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -30090 0 0 {name=X_47308_ }
C {devices/lab_pin.sym} 160780 -29980 0 0 {name=p159762 lab=_64714_/X }
C {devices/lab_pin.sym} 160780 -29940 0 0 {name=p159763 lab=_86225_/Q }
C {devices/lab_pin.sym} 160780 -29900 0 0 {name=p159764 lab=_65904_/X }
C {devices/lab_pin.sym} 160780 -29860 0 0 {name=p159765 lab=_66141_/X }
C {devices/lab_pin.sym} 160940 -29920 0 1 {name=p159766 lab=_66142_/X }
C {sky130_stdcells/a211o_4.sym} 160860 -29920 0 0 {name=X_66142_ }
C {devices/lab_pin.sym} 160800 -29780 0 0 {name=p159767 lab=_78128_/A }
C {devices/lab_pin.sym} 160800 -29740 0 0 {name=p159768 lab=_78128_/B }
C {devices/lab_pin.sym} 160920 -29760 0 1 {name=p159769 lab=_78128_/X }
C {sky130_stdcells/xor2_4.sym} 160860 -29760 0 0 {name=X_78128_ }
C {devices/lab_pin.sym} 160780 -29670 0 0 {name=p159770 lab=_59450_/Y }
C {devices/lab_pin.sym} 160780 -29630 0 0 {name=p159771 lab=_60748_/X }
C {devices/lab_pin.sym} 160780 -29590 0 0 {name=p159772 lab=_60654_/X }
C {devices/lab_pin.sym} 160780 -29550 0 0 {name=p159773 lab=_62195_/Y }
C {devices/lab_pin.sym} 160780 -29510 0 0 {name=p159774 lab=_60671_/B }
C {devices/lab_pin.sym} 160940 -29590 0 1 {name=p159775 lab=_63354_/Y }
C {sky130_stdcells/o32ai_4.sym} 160860 -29590 0 0 {name=X_63354_ }
C {devices/lab_pin.sym} 160780 -29450 0 0 {name=p159776 lab=_48285_/Y }
C {devices/lab_pin.sym} 160780 -29410 0 0 {name=p159777 lab=_48233_/X }
C {devices/lab_pin.sym} 160780 -29370 0 0 {name=p159778 lab=_48287_/X }
C {devices/lab_pin.sym} 160940 -29410 0 1 {name=p159779 lab=_86542_/D }
C {sky130_stdcells/a21oi_4.sym} 160860 -29410 0 0 {name=X_48288_ }
C {devices/lab_pin.sym} 160800 -29280 0 0 {name=p159780 lab=_60566_/A }
C {devices/lab_pin.sym} 160800 -29240 0 0 {name=p159781 lab=_60595_/C }
C {devices/lab_pin.sym} 160920 -29260 0 1 {name=p159782 lab=_60566_/X }
C {sky130_stdcells/and2_4.sym} 160860 -29260 0 0 {name=X_60566_ }
C {devices/lab_pin.sym} 160800 -29160 0 0 {name=p159783 lab=_62288_/X }
C {devices/lab_pin.sym} 160800 -29120 0 0 {name=p159784 lab=_62285_/X }
C {devices/lab_pin.sym} 160800 -29080 0 0 {name=p159785 lab=_64284_/B }
C {devices/lab_pin.sym} 160800 -29040 0 0 {name=p159786 lab=_60025_/X }
C {devices/lab_pin.sym} 160920 -29100 0 1 {name=p159787 lab=_62305_/X }
C {sky130_stdcells/and4_4.sym} 160860 -29100 0 0 {name=X_62305_ }
C {devices/lab_pin.sym} 160820 -28950 0 0 {name=p159788 lab=_47003_/A }
C {devices/lab_pin.sym} 160900 -28950 0 1 {name=p159789 lab=_47382_/A }
C {sky130_stdcells/buf_2.sym} 160860 -28950 0 0 {name=X_47239_ }
C {devices/lab_pin.sym} 160780 -28850 0 0 {name=p159790 lab=_66070_/X }
C {devices/lab_pin.sym} 160780 -28810 0 0 {name=p159791 lab=_66072_/X }
C {devices/lab_pin.sym} 160780 -28770 0 0 {name=p159792 lab=_65961_/X }
C {devices/lab_pin.sym} 160940 -28810 0 1 {name=p159793 lab=_66073_/X }
C {sky130_stdcells/a21o_4.sym} 160860 -28810 0 0 {name=X_66073_ }
C {devices/lab_pin.sym} 160800 -28680 0 0 {name=p159794 lab=_78059_/A }
C {devices/lab_pin.sym} 160800 -28640 0 0 {name=p159795 lab=_78059_/B }
C {devices/lab_pin.sym} 160920 -28660 0 1 {name=p159796 lab=_78059_/X }
C {sky130_stdcells/xor2_4.sym} 160860 -28660 0 0 {name=X_78059_ }
C {devices/lab_pin.sym} 160800 -28550 0 0 {name=p159797 lab=_63285_/A }
C {devices/lab_pin.sym} 160800 -28510 0 0 {name=p159798 lab=_63285_/B }
C {devices/lab_pin.sym} 160800 -28470 0 0 {name=p159799 lab=_79259_/A }
C {devices/lab_pin.sym} 160920 -28510 0 1 {name=p159800 lab=_63285_/Y }
C {sky130_stdcells/nor3_4.sym} 160860 -28510 0 0 {name=X_63285_ }
C {devices/lab_pin.sym} 160800 -28390 0 0 {name=p159801 lab=_60526_/A }
C {devices/lab_pin.sym} 160800 -28350 0 0 {name=p159802 lab=_60519_/B }
C {devices/lab_pin.sym} 160800 -28310 0 0 {name=p159803 lab=_79150_/A }
C {devices/lab_pin.sym} 160920 -28350 0 1 {name=p159804 lab=_60497_/Y }
C {sky130_stdcells/nor3_4.sym} 160860 -28350 0 0 {name=X_60497_ }
C {devices/lab_pin.sym} 160780 -28240 0 0 {name=p159805 lab=_64944_/X }
C {devices/lab_pin.sym} 160780 -28200 0 0 {name=p159806 lab=_86129_/Q }
C {devices/lab_pin.sym} 160780 -28160 0 0 {name=p159807 lab=_65022_/X }
C {devices/lab_pin.sym} 160780 -28120 0 0 {name=p159808 lab=_65023_/X }
C {devices/lab_pin.sym} 160940 -28180 0 1 {name=p159809 lab=_65024_/X }
C {sky130_stdcells/a211o_4.sym} 160860 -28180 0 0 {name=X_65024_ }
C {devices/lab_pin.sym} 160780 -28060 0 0 {name=p159810 lab=_87046_/Q }
C {devices/lab_pin.sym} 160780 -28020 0 0 {name=p159811 lab=_69796_/X }
C {devices/lab_pin.sym} 160780 -27980 0 0 {name=p159812 lab=_69797_/X }
C {devices/lab_pin.sym} 160780 -27940 0 0 {name=p159813 lab=_69900_/X }
C {devices/lab_pin.sym} 160940 -28000 0 1 {name=p159814 lab=_69902_/B }
C {sky130_stdcells/a211o_4.sym} 160860 -28000 0 0 {name=X_69901_ }
C {devices/lab_pin.sym} 160820 -27850 0 0 {name=p159815 lab=_50219_/X }
C {devices/lab_pin.sym} 160900 -27850 0 1 {name=p159816 lab=_50250_/X }
C {sky130_stdcells/buf_2.sym} 160860 -27850 0 0 {name=X_50250_ }
C {devices/lab_pin.sym} 160820 -27730 0 0 {name=p159817 lab=_62236_/A }
C {devices/lab_pin.sym} 160900 -27730 0 1 {name=p159818 lab=_62597_/B }
C {sky130_stdcells/buf_2.sym} 160860 -27730 0 0 {name=X_62236_ }
C {devices/lab_pin.sym} 160820 -27610 0 0 {name=p159819 lab=clkbuf_7_9_0_CLK/X }
C {devices/lab_pin.sym} 160900 -27610 0 1 {name=p159820 lab=clkbuf_9_39_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 160860 -27610 0 0 {name=Xclkbuf_8_19_0_CLK }
C {devices/lab_pin.sym} 160770 -27490 0 0 {name=p159821 lab=_81070_/CLK }
C {devices/lab_pin.sym} 160770 -27470 0 0 {name=p159822 lab=_81102_/Q }
C {devices/lab_pin.sym} 160950 -27490 0 1 {name=p159823 lab=_81070_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -27480 0 0 {name=X_81070_ }
C {devices/lab_pin.sym} 160800 -27360 0 0 {name=p159824 lab=_80004_/X }
C {devices/lab_pin.sym} 160800 -27320 0 0 {name=p159825 lab=_80007_/Y }
C {devices/lab_pin.sym} 160920 -27340 0 1 {name=p159826 lab=_80021_/X }
C {sky130_stdcells/or2_4.sym} 160860 -27340 0 0 {name=X_80021_ }
C {devices/lab_pin.sym} 160820 -27210 0 0 {name=p159827 lab=_69746_/A }
C {devices/lab_pin.sym} 160900 -27210 0 1 {name=p159828 lab=_69832_/X }
C {sky130_stdcells/buf_2.sym} 160860 -27210 0 0 {name=X_69832_ }
C {devices/lab_pin.sym} 160800 -27100 0 0 {name=p159829 lab=_50169_/A }
C {devices/lab_pin.sym} 160800 -27060 0 0 {name=p159830 lab=_49144_/X }
C {devices/lab_pin.sym} 160920 -27080 0 1 {name=p159831 lab=_50181_/Y }
C {sky130_stdcells/nand2_4.sym} 160860 -27080 0 0 {name=X_50181_ }
C {devices/lab_pin.sym} 160800 -26970 0 0 {name=p159832 lab=_62144_/A }
C {devices/lab_pin.sym} 160800 -26930 0 0 {name=p159833 lab=_62121_/X }
C {devices/lab_pin.sym} 160800 -26890 0 0 {name=p159834 lab=_78051_/B }
C {devices/lab_pin.sym} 160920 -26930 0 1 {name=p159835 lab=_62167_/Y }
C {sky130_stdcells/nor3_4.sym} 160860 -26930 0 0 {name=X_62167_ }
C {devices/lab_pin.sym} 160780 -26810 0 0 {name=p159836 lab=_61195_/A }
C {devices/lab_pin.sym} 160780 -26770 0 0 {name=p159837 lab=_61117_/X }
C {devices/lab_pin.sym} 160780 -26730 0 0 {name=p159838 lab=_72590_/A }
C {devices/lab_pin.sym} 160940 -26770 0 1 {name=p159839 lab=_61118_/X }
C {sky130_stdcells/o21a_4.sym} 160860 -26770 0 0 {name=X_61118_ }
C {devices/lab_pin.sym} 160820 -26630 0 0 {name=p159840 lab=_69988_/A }
C {devices/lab_pin.sym} 160900 -26630 0 1 {name=p159841 lab=_69763_/X }
C {sky130_stdcells/buf_2.sym} 160860 -26630 0 0 {name=X_69763_ }
C {devices/lab_pin.sym} 160800 -26520 0 0 {name=p159842 lab=_66902_/X }
C {devices/lab_pin.sym} 160800 -26480 0 0 {name=p159843 lab=_66975_/B }
C {devices/lab_pin.sym} 160920 -26500 0 1 {name=p159844 lab=_66975_/X }
C {sky130_stdcells/and2_4.sym} 160860 -26500 0 0 {name=X_66975_ }
C {devices/lab_pin.sym} 160800 -26400 0 0 {name=p159845 lab=_62097_/X }
C {devices/lab_pin.sym} 160800 -26360 0 0 {name=p159846 lab=_62065_/B }
C {devices/lab_pin.sym} 160800 -26320 0 0 {name=p159847 lab=_59608_/A }
C {devices/lab_pin.sym} 160800 -26280 0 0 {name=p159848 lab=_62130_/D }
C {devices/lab_pin.sym} 160920 -26340 0 1 {name=p159849 lab=_62099_/D }
C {sky130_stdcells/nand4_4.sym} 160860 -26340 0 0 {name=X_62098_ }
C {devices/lab_pin.sym} 160820 -26190 0 0 {name=p159850 lab=_68714_/A }
C {devices/lab_pin.sym} 160900 -26190 0 1 {name=p159851 lab=_69958_/A }
C {sky130_stdcells/buf_2.sym} 160860 -26190 0 0 {name=X_68714_ }
C {devices/lab_pin.sym} 160820 -26070 0 0 {name=p159852 lab=_53729_/A }
C {devices/lab_pin.sym} 160900 -26070 0 1 {name=p159853 lab=_53940_/X }
C {sky130_stdcells/buf_2.sym} 160860 -26070 0 0 {name=X_53940_ }
C {devices/lab_pin.sym} 160780 -25980 0 0 {name=p159854 lab=_65924_/X }
C {devices/lab_pin.sym} 160780 -25940 0 0 {name=p159855 lab=_84992_/Q }
C {devices/lab_pin.sym} 160780 -25900 0 0 {name=p159856 lab=_65865_/X }
C {devices/lab_pin.sym} 160780 -25860 0 0 {name=p159857 lab=_65925_/X }
C {devices/lab_pin.sym} 160940 -25920 0 1 {name=p159858 lab=_65927_/C }
C {sky130_stdcells/a211o_4.sym} 160860 -25920 0 0 {name=X_65926_ }
C {devices/lab_pin.sym} 160800 -25790 0 0 {name=p159859 lab=_61055_/A }
C {devices/lab_pin.sym} 160800 -25750 0 0 {name=p159860 lab=_61000_/X }
C {devices/lab_pin.sym} 160800 -25710 0 0 {name=p159861 lab=_76976_/A }
C {devices/lab_pin.sym} 160920 -25750 0 1 {name=p159862 lab=_61049_/X }
C {sky130_stdcells/or3_4.sym} 160860 -25750 0 0 {name=X_61049_ }
C {devices/lab_pin.sym} 160770 -25610 0 0 {name=p159863 lab=_84760_/CLK }
C {devices/lab_pin.sym} 160770 -25590 0 0 {name=p159864 lab=_84760_/D }
C {devices/lab_pin.sym} 160950 -25610 0 1 {name=p159865 lab=_80441_/A }
C {sky130_stdcells/dfxtp_4.sym} 160860 -25600 0 0 {name=X_84760_ }
C {devices/lab_pin.sym} 160770 -25470 0 0 {name=p159866 lab=_82116_/CLK }
C {devices/lab_pin.sym} 160770 -25450 0 0 {name=p159867 lab=_83900_/Q }
C {devices/lab_pin.sym} 160950 -25470 0 1 {name=p159868 lab=_81972_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -25460 0 0 {name=X_81972_ }
C {devices/lab_pin.sym} 160780 -25360 0 0 {name=p159869 lab=_69267_/Y }
C {devices/lab_pin.sym} 160780 -25320 0 0 {name=p159870 lab=_69644_/X }
C {devices/lab_pin.sym} 160780 -25280 0 0 {name=p159871 lab=_69672_/X }
C {devices/lab_pin.sym} 160780 -25240 0 0 {name=p159872 lab=_69693_/Y }
C {devices/lab_pin.sym} 160940 -25300 0 1 {name=p159873 lab=_69694_/X }
C {sky130_stdcells/a211o_4.sym} 160860 -25300 0 0 {name=X_69694_ }
C {devices/lab_pin.sym} 160820 -25150 0 0 {name=p159874 lab=clkbuf_3_5_0_CLK/X }
C {devices/lab_pin.sym} 160900 -25150 0 1 {name=p159875 lab=clkbuf_3_5_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 160860 -25150 0 0 {name=Xclkbuf_3_5_1_CLK }
C {devices/lab_pin.sym} 160770 -25030 0 0 {name=p159876 lab=_83711_/CLK }
C {devices/lab_pin.sym} 160770 -25010 0 0 {name=p159877 lab=_83711_/D }
C {devices/lab_pin.sym} 160950 -25030 0 1 {name=p159878 lab=_83711_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -25020 0 0 {name=X_83711_ }
C {devices/lab_pin.sym} 160770 -24890 0 0 {name=p159879 lab=_81169_/CLK }
C {devices/lab_pin.sym} 160770 -24870 0 0 {name=p159880 lab=_80923_/D }
C {devices/lab_pin.sym} 160950 -24890 0 1 {name=p159881 lab=_80923_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -24880 0 0 {name=X_80923_ }
C {devices/lab_pin.sym} 160800 -24760 0 0 {name=p159882 lab=_69092_/A }
C {devices/lab_pin.sym} 160800 -24720 0 0 {name=p159883 lab=_68645_/B }
C {devices/lab_pin.sym} 160920 -24740 0 1 {name=p159884 lab=_68645_/X }
C {sky130_stdcells/and2_4.sym} 160860 -24740 0 0 {name=X_68645_ }
C {devices/lab_pin.sym} 160820 -24610 0 0 {name=p159885 lab=_54295_/A }
C {devices/lab_pin.sym} 160900 -24610 0 1 {name=p159886 lab=_53871_/X }
C {sky130_stdcells/buf_2.sym} 160860 -24610 0 0 {name=X_53871_ }
C {devices/lab_pin.sym} 160800 -24500 0 0 {name=p159887 lab=_65804_/A }
C {devices/lab_pin.sym} 160800 -24460 0 0 {name=p159888 lab=_85860_/Q }
C {devices/lab_pin.sym} 160920 -24480 0 1 {name=p159889 lab=_65857_/X }
C {sky130_stdcells/and2_4.sym} 160860 -24480 0 0 {name=X_65857_ }
C {devices/lab_pin.sym} 160770 -24350 0 0 {name=p159890 lab=_84713_/CLK }
C {devices/lab_pin.sym} 160770 -24330 0 0 {name=p159891 lab=_59839_/Y }
C {devices/lab_pin.sym} 160950 -24350 0 1 {name=p159892 lab=_80391_/A }
C {sky130_stdcells/dfxtp_4.sym} 160860 -24340 0 0 {name=X_84691_ }
C {devices/lab_pin.sym} 160820 -24210 0 0 {name=p159893 lab=_55610_/A }
C {devices/lab_pin.sym} 160900 -24210 0 1 {name=p159894 lab=_55610_/X }
C {sky130_stdcells/buf_2.sym} 160860 -24210 0 0 {name=X_55610_ }
C {devices/lab_pin.sym} 160770 -24090 0 0 {name=p159895 lab=_85822_/CLK }
C {devices/lab_pin.sym} 160770 -24070 0 0 {name=p159896 lab=_86430_/D }
C {devices/lab_pin.sym} 160950 -24090 0 1 {name=p159897 lab=_86430_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -24080 0 0 {name=X_86430_ }
C {devices/lab_pin.sym} 160820 -23950 0 0 {name=p159898 lab=_52767_/A }
C {devices/lab_pin.sym} 160900 -23950 0 1 {name=p159899 lab=_52843_/A }
C {sky130_stdcells/buf_2.sym} 160860 -23950 0 0 {name=X_52822_ }
C {devices/lab_pin.sym} 160780 -23850 0 0 {name=p159900 lab=_64802_/X }
C {devices/lab_pin.sym} 160780 -23810 0 0 {name=p159901 lab=_64805_/X }
C {devices/lab_pin.sym} 160780 -23770 0 0 {name=p159902 lab=_64807_/X }
C {devices/lab_pin.sym} 160940 -23810 0 1 {name=p159903 lab=_64808_/X }
C {sky130_stdcells/a21o_4.sym} 160860 -23810 0 0 {name=X_64808_ }
C {devices/lab_pin.sym} 160770 -23670 0 0 {name=p159904 lab=_82394_/CLK }
C {devices/lab_pin.sym} 160770 -23650 0 0 {name=p159905 lab=_83642_/D }
C {devices/lab_pin.sym} 160950 -23670 0 1 {name=p159906 lab=_46419_/A }
C {sky130_stdcells/dfxtp_4.sym} 160860 -23660 0 0 {name=X_83642_ }
C {devices/lab_pin.sym} 160820 -23530 0 0 {name=p159907 lab=_56552_/Y }
C {devices/lab_pin.sym} 160900 -23530 0 1 {name=p159908 lab=_56590_/X }
C {sky130_stdcells/buf_2.sym} 160860 -23530 0 0 {name=X_56590_ }
C {devices/lab_pin.sym} 160770 -23410 0 0 {name=p159909 lab=_80854_/CLK }
C {devices/lab_pin.sym} 160770 -23390 0 0 {name=p159910 lab=_80854_/D }
C {devices/lab_pin.sym} 160950 -23410 0 1 {name=p159911 lab=_74995_/B }
C {sky130_stdcells/dfxtp_4.sym} 160860 -23400 0 0 {name=X_80854_ }
C {devices/lab_pin.sym} 160780 -23300 0 0 {name=p159912 lab=_88011_/Q }
C {devices/lab_pin.sym} 160780 -23260 0 0 {name=p159913 lab=_68527_/X }
C {devices/lab_pin.sym} 160780 -23220 0 0 {name=p159914 lab=_68501_/X }
C {devices/lab_pin.sym} 160780 -23180 0 0 {name=p159915 lab=_68575_/X }
C {devices/lab_pin.sym} 160940 -23240 0 1 {name=p159916 lab=_68576_/X }
C {sky130_stdcells/a211o_4.sym} 160860 -23240 0 0 {name=X_68576_ }
C {devices/lab_pin.sym} 160780 -23110 0 0 {name=p159917 lab=_65786_/Y }
C {devices/lab_pin.sym} 160780 -23070 0 0 {name=p159918 lab=_65757_/X }
C {devices/lab_pin.sym} 160780 -23030 0 0 {name=p159919 lab=_65787_/X }
C {devices/lab_pin.sym} 160940 -23070 0 1 {name=p159920 lab=_84178_/D }
C {sky130_stdcells/a21o_4.sym} 160860 -23070 0 0 {name=X_65788_ }
C {devices/lab_pin.sym} 160780 -22950 0 0 {name=p159921 lab=_55538_/X }
C {devices/lab_pin.sym} 160780 -22910 0 0 {name=p159922 lab=_55540_/X }
C {devices/lab_pin.sym} 160780 -22870 0 0 {name=p159923 lab=_55516_/X }
C {devices/lab_pin.sym} 160940 -22910 0 1 {name=p159924 lab=_56616_/A }
C {sky130_stdcells/a21o_4.sym} 160860 -22910 0 0 {name=X_55541_ }
C {devices/lab_pin.sym} 160800 -22780 0 0 {name=p159925 lab=_67572_/A }
C {devices/lab_pin.sym} 160800 -22740 0 0 {name=p159926 lab=_67527_/B }
C {devices/lab_pin.sym} 160920 -22760 0 1 {name=p159927 lab=_67527_/X }
C {sky130_stdcells/and2_4.sym} 160860 -22760 0 0 {name=X_67527_ }
C {devices/lab_pin.sym} 160770 -22630 0 0 {name=p159928 lab=_86361_/CLK }
C {devices/lab_pin.sym} 160770 -22610 0 0 {name=p159929 lab=_86361_/D }
C {devices/lab_pin.sym} 160950 -22630 0 1 {name=p159930 lab=_86361_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -22620 0 0 {name=X_86361_ }
C {devices/lab_pin.sym} 160780 -22510 0 0 {name=p159931 lab=_85760_/Q }
C {devices/lab_pin.sym} 160780 -22470 0 0 {name=p159932 lab=_52737_/X }
C {devices/lab_pin.sym} 160780 -22430 0 0 {name=p159933 lab=_52752_/Y }
C {devices/lab_pin.sym} 160940 -22470 0 1 {name=p159934 lab=_52753_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -22470 0 0 {name=X_52753_ }
C {devices/lab_pin.sym} 160820 -22330 0 0 {name=p159935 lab=_64739_/A }
C {devices/lab_pin.sym} 160900 -22330 0 1 {name=p159936 lab=_64870_/A }
C {sky130_stdcells/buf_2.sym} 160860 -22330 0 0 {name=X_64739_ }
C {devices/lab_pin.sym} 160770 -22210 0 0 {name=p159937 lab=_86505_/CLK }
C {devices/lab_pin.sym} 160770 -22190 0 0 {name=p159938 lab=_83573_/D }
C {devices/lab_pin.sym} 160950 -22210 0 1 {name=p159939 lab=_48581_/A }
C {sky130_stdcells/dfxtp_4.sym} 160860 -22200 0 0 {name=X_83573_ }
C {devices/lab_pin.sym} 160770 -22070 0 0 {name=p159940 lab=_81041_/CLK }
C {devices/lab_pin.sym} 160770 -22050 0 0 {name=p159941 lab=_80785_/D }
C {devices/lab_pin.sym} 160950 -22070 0 1 {name=p159942 lab=_75297_/A }
C {sky130_stdcells/dfxtp_4.sym} 160860 -22060 0 0 {name=X_80785_ }
C {devices/lab_pin.sym} 160770 -21930 0 0 {name=p159943 lab=_87588_/CLK }
C {devices/lab_pin.sym} 160770 -21910 0 0 {name=p159944 lab=_88100_/D }
C {devices/lab_pin.sym} 160950 -21930 0 1 {name=p159945 lab=_41938_/A }
C {sky130_stdcells/dfxtp_4.sym} 160860 -21920 0 0 {name=X_88100_ }
C {devices/lab_pin.sym} 160770 -21790 0 0 {name=p159946 lab=_85311_/CLK }
C {devices/lab_pin.sym} 160770 -21770 0 0 {name=p159947 lab=_56008_/Y }
C {devices/lab_pin.sym} 160950 -21790 0 1 {name=p159948 lab=_85312_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -21780 0 0 {name=X_85312_ }
C {devices/lab_pin.sym} 160780 -21670 0 0 {name=p159949 lab=_85961_/Q }
C {devices/lab_pin.sym} 160780 -21630 0 0 {name=p159950 lab=_51701_/X }
C {devices/lab_pin.sym} 160780 -21590 0 0 {name=p159951 lab=_51703_/Y }
C {devices/lab_pin.sym} 160940 -21630 0 1 {name=p159952 lab=_51704_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -21630 0 0 {name=X_51704_ }
C {devices/lab_pin.sym} 160780 -21510 0 0 {name=p159953 lab=_58253_/X }
C {devices/lab_pin.sym} 160780 -21470 0 0 {name=p159954 lab=_83447_/Q }
C {devices/lab_pin.sym} 160780 -21430 0 0 {name=p159955 lab=_58259_/Y }
C {devices/lab_pin.sym} 160940 -21470 0 1 {name=p159956 lab=_84895_/D }
C {sky130_stdcells/o21a_4.sym} 160860 -21470 0 0 {name=X_58260_ }
C {devices/lab_pin.sym} 160770 -21330 0 0 {name=p159957 lab=_82589_/CLK }
C {devices/lab_pin.sym} 160770 -21310 0 0 {name=p159958 lab=_82524_/D }
C {devices/lab_pin.sym} 160950 -21330 0 1 {name=p159959 lab=_78707_/A }
C {sky130_stdcells/dfxtp_4.sym} 160860 -21320 0 0 {name=X_82524_ }
C {devices/lab_pin.sym} 160800 -21200 0 0 {name=p159960 lab=_55470_/A }
C {devices/lab_pin.sym} 160800 -21160 0 0 {name=p159961 lab=_45615_/Y }
C {devices/lab_pin.sym} 160920 -21180 0 1 {name=p159962 lab=_55472_/Y }
C {sky130_stdcells/nor2_4.sym} 160860 -21180 0 0 {name=X_55472_ }
C {devices/lab_pin.sym} 160800 -21060 0 0 {name=p159963 lab=_67455_/X }
C {devices/lab_pin.sym} 160800 -21020 0 0 {name=p159964 lab=_67457_/X }
C {devices/lab_pin.sym} 160920 -21040 0 1 {name=p159965 lab=_67458_/Y }
C {sky130_stdcells/nand2_4.sym} 160860 -21040 0 0 {name=X_67458_ }
C {devices/lab_pin.sym} 160770 -20910 0 0 {name=p159966 lab=_86611_/CLK }
C {devices/lab_pin.sym} 160770 -20890 0 0 {name=p159967 lab=_49959_/Y }
C {devices/lab_pin.sym} 160950 -20910 0 1 {name=p159968 lab=_72277_/B }
C {sky130_stdcells/dfxtp_4.sym} 160860 -20900 0 0 {name=X_86292_ }
C {devices/lab_pin.sym} 160820 -20770 0 0 {name=p159969 lab=_52684_/A }
C {devices/lab_pin.sym} 160900 -20770 0 1 {name=p159970 lab=_52684_/X }
C {sky130_stdcells/buf_2.sym} 160860 -20770 0 0 {name=X_52684_ }
C {devices/lab_pin.sym} 160800 -20670 0 0 {name=p159971 lab=_56885_/A }
C {devices/lab_pin.sym} 160800 -20630 0 0 {name=p159972 lab=_57126_/A }
C {devices/lab_pin.sym} 160800 -20590 0 0 {name=p159973 lab=_56884_/Y }
C {devices/lab_pin.sym} 160920 -20630 0 1 {name=p159974 lab=_57212_/A }
C {sky130_stdcells/nand3_4.sym} 160860 -20630 0 0 {name=X_57211_ }
C {devices/lab_pin.sym} 160770 -20490 0 0 {name=p159975 lab=_87273_/CLK }
C {devices/lab_pin.sym} 160770 -20470 0 0 {name=p159976 lab=_88031_/D }
C {devices/lab_pin.sym} 160950 -20490 0 1 {name=p159977 lab=_88031_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -20480 0 0 {name=X_88031_ }
C {devices/lab_pin.sym} 160800 -20380 0 0 {name=p159978 lab=_54399_/X }
C {devices/lab_pin.sym} 160800 -20340 0 0 {name=p159979 lab=_54417_/B }
C {devices/lab_pin.sym} 160800 -20300 0 0 {name=p159980 lab=_54402_/C }
C {devices/lab_pin.sym} 160800 -20260 0 0 {name=p159981 lab=_54423_/D }
C {devices/lab_pin.sym} 160920 -20320 0 1 {name=p159982 lab=_54423_/X }
C {sky130_stdcells/and4_4.sym} 160860 -20320 0 0 {name=X_54423_ }
C {devices/lab_pin.sym} 160820 -20170 0 0 {name=p159983 lab=_45923_/X }
C {devices/lab_pin.sym} 160900 -20170 0 1 {name=p159984 lab=_66410_/A }
C {sky130_stdcells/buf_2.sym} 160860 -20170 0 0 {name=X_66409_ }
C {devices/lab_pin.sym} 160770 -20050 0 0 {name=p159985 lab=_85244_/CLK }
C {devices/lab_pin.sym} 160770 -20030 0 0 {name=p159986 lab=_85243_/D }
C {devices/lab_pin.sym} 160950 -20050 0 1 {name=p159987 lab=_56303_/C }
C {sky130_stdcells/dfxtp_4.sym} 160860 -20040 0 0 {name=X_85243_ }
C {devices/lab_pin.sym} 160800 -19940 0 0 {name=p159988 lab=_51629_/X }
C {devices/lab_pin.sym} 160800 -19900 0 0 {name=p159989 lab=_51619_/B }
C {devices/lab_pin.sym} 160800 -19860 0 0 {name=p159990 lab=_51651_/C }
C {devices/lab_pin.sym} 160800 -19820 0 0 {name=p159991 lab=_53159_/D }
C {devices/lab_pin.sym} 160920 -19880 0 1 {name=p159992 lab=_51635_/X }
C {sky130_stdcells/and4_4.sym} 160860 -19880 0 0 {name=X_51635_ }
C {devices/lab_pin.sym} 160820 -19730 0 0 {name=p159993 lab=_58341_/A }
C {devices/lab_pin.sym} 160900 -19730 0 1 {name=p159994 lab=_58191_/X }
C {sky130_stdcells/buf_2.sym} 160860 -19730 0 0 {name=X_58191_ }
C {devices/lab_pin.sym} 160770 -19610 0 0 {name=p159995 lab=_82463_/CLK }
C {devices/lab_pin.sym} 160770 -19590 0 0 {name=p159996 lab=_79147_/X }
C {devices/lab_pin.sym} 160950 -19610 0 1 {name=p159997 lab=_82455_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -19600 0 0 {name=X_82455_ }
C {devices/lab_pin.sym} 160820 -19470 0 0 {name=p159998 lab=_67388_/X }
C {devices/lab_pin.sym} 160900 -19470 0 1 {name=p159999 lab=_67863_/A }
C {sky130_stdcells/buf_2.sym} 160860 -19470 0 0 {name=X_67389_ }
C {devices/lab_pin.sym} 160780 -19370 0 0 {name=p160000 lab=_56702_/A }
C {devices/lab_pin.sym} 160780 -19330 0 0 {name=p160001 lab=_56685_/B }
C {devices/lab_pin.sym} 160780 -19290 0 0 {name=p160002 lab=_57141_/X }
C {devices/lab_pin.sym} 160940 -19330 0 1 {name=p160003 lab=_57142_/X }
C {sky130_stdcells/a21bo_4.sym} 160860 -19330 0 0 {name=X_57142_ }
C {devices/lab_pin.sym} 160770 -19190 0 0 {name=p160004 lab=_83940_/CLK }
C {devices/lab_pin.sym} 160770 -19170 0 0 {name=p160005 lab=_83942_/Q }
C {devices/lab_pin.sym} 160950 -19190 0 1 {name=p160006 lab=_76755_/B }
C {sky130_stdcells/dfxtp_4.sym} 160860 -19180 0 0 {name=X_81406_ }
C {devices/lab_pin.sym} 160820 -19050 0 0 {name=p160007 lab=_69651_/A }
C {devices/lab_pin.sym} 160900 -19050 0 1 {name=p160008 lab=_69128_/X }
C {sky130_stdcells/buf_2.sym} 160860 -19050 0 0 {name=X_69128_ }
C {devices/lab_pin.sym} 160780 -18950 0 0 {name=p160009 lab=_54352_/Y }
C {devices/lab_pin.sym} 160780 -18910 0 0 {name=p160010 lab=_54338_/X }
C {devices/lab_pin.sym} 160780 -18870 0 0 {name=p160011 lab=_54353_/X }
C {devices/lab_pin.sym} 160940 -18910 0 1 {name=p160012 lab=_85458_/D }
C {sky130_stdcells/a21oi_4.sym} 160860 -18910 0 0 {name=X_54354_ }
C {devices/lab_pin.sym} 160770 -18770 0 0 {name=p160013 lab=_85270_/CLK }
C {devices/lab_pin.sym} 160770 -18750 0 0 {name=p160014 lab=_56495_/Y }
C {devices/lab_pin.sym} 160950 -18770 0 1 {name=p160015 lab=_56494_/C }
C {sky130_stdcells/dfxtp_4.sym} 160860 -18760 0 0 {name=X_85174_ }
C {devices/lab_pin.sym} 160820 -18630 0 0 {name=p160016 lab=_51621_/A }
C {devices/lab_pin.sym} 160900 -18630 0 1 {name=p160017 lab=_51566_/X }
C {sky130_stdcells/buf_2.sym} 160860 -18630 0 0 {name=X_51566_ }
C {devices/lab_pin.sym} 160770 -18510 0 0 {name=p160018 lab=_82386_/CLK }
C {devices/lab_pin.sym} 160770 -18490 0 0 {name=p160019 lab=_82194_/Q }
C {devices/lab_pin.sym} 160950 -18510 0 1 {name=p160020 lab=_82386_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -18500 0 0 {name=X_82386_ }
C {devices/lab_pin.sym} 160800 -18380 0 0 {name=p160021 lab=_53298_/A }
C {devices/lab_pin.sym} 160800 -18340 0 0 {name=p160022 lab=_54478_/B }
C {devices/lab_pin.sym} 160920 -18360 0 1 {name=p160023 lab=_53305_/Y }
C {sky130_stdcells/nand2_4.sym} 160860 -18360 0 0 {name=X_53305_ }
C {devices/lab_pin.sym} 160770 -18230 0 0 {name=p160024 lab=_84220_/CLK }
C {devices/lab_pin.sym} 160770 -18210 0 0 {name=p160025 lab=_84125_/D }
C {devices/lab_pin.sym} 160950 -18230 0 1 {name=p160026 lab=_84125_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -18220 0 0 {name=X_84125_ }
C {devices/lab_pin.sym} 160800 -18100 0 0 {name=p160027 lab=_50513_/A }
C {devices/lab_pin.sym} 160800 -18060 0 0 {name=p160028 lab=_48628_/B }
C {devices/lab_pin.sym} 160920 -18080 0 1 {name=p160029 lab=_50517_/Y }
C {sky130_stdcells/nand2_4.sym} 160860 -18080 0 0 {name=X_50517_ }
C {devices/lab_pin.sym} 160780 -17970 0 0 {name=p160030 lab=_57068_/X }
C {devices/lab_pin.sym} 160780 -17930 0 0 {name=p160031 lab=_56930_/X }
C {devices/lab_pin.sym} 160780 -17890 0 0 {name=p160032 lab=_57072_/Y }
C {devices/lab_pin.sym} 160940 -17930 0 1 {name=p160033 lab=_85093_/D }
C {sky130_stdcells/a21o_4.sym} 160860 -17930 0 0 {name=X_57073_ }
C {devices/lab_pin.sym} 160770 -17790 0 0 {name=p160034 lab=_81749_/CLK }
C {devices/lab_pin.sym} 160770 -17770 0 0 {name=p160035 lab=_76500_/X }
C {devices/lab_pin.sym} 160950 -17790 0 1 {name=p160036 lab=_81713_/D }
C {sky130_stdcells/dfxtp_4.sym} 160860 -17780 0 0 {name=X_81337_ }
C {devices/lab_pin.sym} 160800 -17660 0 0 {name=p160037 lab=_69059_/A }
C {devices/lab_pin.sym} 160800 -17620 0 0 {name=p160038 lab=_88343_/Q }
C {devices/lab_pin.sym} 160920 -17640 0 1 {name=p160039 lab=_69059_/X }
C {sky130_stdcells/and2_4.sym} 160860 -17640 0 0 {name=X_69059_ }
C {devices/lab_pin.sym} 160820 -17510 0 0 {name=p160040 lab=_54366_/A }
C {devices/lab_pin.sym} 160900 -17510 0 1 {name=p160041 lab=_54285_/X }
C {sky130_stdcells/buf_2.sym} 160860 -17510 0 0 {name=X_54285_ }
C {devices/lab_pin.sym} 160780 -17410 0 0 {name=p160042 lab=_85999_/Q }
C {devices/lab_pin.sym} 160780 -17370 0 0 {name=p160043 lab=_51485_/X }
C {devices/lab_pin.sym} 160780 -17330 0 0 {name=p160044 lab=_51496_/Y }
C {devices/lab_pin.sym} 160940 -17370 0 1 {name=p160045 lab=_51497_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -17370 0 0 {name=X_51497_ }
C {devices/lab_pin.sym} 160820 -17230 0 0 {name=p160046 lab=clkbuf_9_181_0_CLK/X }
C {devices/lab_pin.sym} 160900 -17230 0 1 {name=p160047 lab=_86627_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 160860 -17230 0 0 {name=Xclkbuf_10_363_0_CLK }
C {devices/lab_pin.sym} 160780 -17130 0 0 {name=p160048 lab=_55688_/X }
C {devices/lab_pin.sym} 160780 -17090 0 0 {name=p160049 lab=_56020_/X }
C {devices/lab_pin.sym} 160780 -17050 0 0 {name=p160050 lab=_56023_/Y }
C {devices/lab_pin.sym} 160940 -17090 0 1 {name=p160051 lab=_56024_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -17090 0 0 {name=X_56024_ }
C {devices/lab_pin.sym} 160820 -16950 0 0 {name=p160052 lab=_41249_/Y }
C {devices/lab_pin.sym} 160900 -16950 0 1 {name=p160053 lab=_41250_/X }
C {sky130_stdcells/buf_2.sym} 160860 -16950 0 0 {name=X_41250_ }
C {devices/lab_pin.sym} 160800 -16840 0 0 {name=p160054 lab=_53246_/A }
C {devices/lab_pin.sym} 160800 -16800 0 0 {name=p160055 lab=_53236_/B }
C {devices/lab_pin.sym} 160920 -16820 0 1 {name=p160056 lab=_53236_/Y }
C {sky130_stdcells/nand2_4.sym} 160860 -16820 0 0 {name=X_53236_ }
C {devices/lab_pin.sym} 160800 -16710 0 0 {name=p160057 lab=_49112_/A }
C {devices/lab_pin.sym} 160800 -16670 0 0 {name=p160058 lab=_72043_/X }
C {devices/lab_pin.sym} 160800 -16630 0 0 {name=p160059 lab=_72048_/X }
C {devices/lab_pin.sym} 160920 -16670 0 1 {name=p160060 lab=_72070_/X }
C {sky130_stdcells/and3_4.sym} 160860 -16670 0 0 {name=X_72070_ }
C {devices/lab_pin.sym} 160770 -16530 0 0 {name=p160061 lab=_81492_/CLK }
C {devices/lab_pin.sym} 160770 -16510 0 0 {name=p160062 lab=_84056_/D }
C {devices/lab_pin.sym} 160950 -16530 0 1 {name=p160063 lab=_84056_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -16520 0 0 {name=X_84056_ }
C {devices/lab_pin.sym} 160780 -16410 0 0 {name=p160064 lab=_50446_/Y }
C {devices/lab_pin.sym} 160780 -16370 0 0 {name=p160065 lab=_50429_/X }
C {devices/lab_pin.sym} 160780 -16330 0 0 {name=p160066 lab=_50447_/X }
C {devices/lab_pin.sym} 160940 -16370 0 1 {name=p160067 lab=_86199_/D }
C {sky130_stdcells/a21oi_4.sym} 160860 -16370 0 0 {name=X_50448_ }
C {devices/lab_pin.sym} 160820 -16230 0 0 {name=p160068 lab=clkbuf_9_496_0_CLK/X }
C {devices/lab_pin.sym} 160900 -16230 0 1 {name=p160069 lab=_86523_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 160860 -16230 0 0 {name=Xclkbuf_10_993_0_CLK }
C {devices/lab_pin.sym} 160770 -16110 0 0 {name=p160070 lab=_81362_/CLK }
C {devices/lab_pin.sym} 160770 -16090 0 0 {name=p160071 lab=_81300_/Q }
C {devices/lab_pin.sym} 160950 -16110 0 1 {name=p160072 lab=_76410_/A }
C {sky130_stdcells/dfxtp_4.sym} 160860 -16100 0 0 {name=X_81268_ }
C {devices/lab_pin.sym} 160800 -16000 0 0 {name=p160073 lab=_71171_/A }
C {devices/lab_pin.sym} 160800 -15960 0 0 {name=p160074 lab=_70620_/B }
C {devices/lab_pin.sym} 160800 -15920 0 0 {name=p160075 lab=_70925_/X }
C {devices/lab_pin.sym} 160800 -15880 0 0 {name=p160076 lab=_71018_/D }
C {devices/lab_pin.sym} 160920 -15940 0 1 {name=p160077 lab=_71021_/Y }
C {sky130_stdcells/nand4_4.sym} 160860 -15940 0 0 {name=X_71021_ }
C {devices/lab_pin.sym} 160770 -15790 0 0 {name=p160078 lab=_85050_/CLK }
C {devices/lab_pin.sym} 160770 -15770 0 0 {name=p160079 lab=_83007_/D }
C {devices/lab_pin.sym} 160950 -15790 0 1 {name=p160080 lab=_83007_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -15780 0 0 {name=X_83007_ }
C {devices/lab_pin.sym} 160820 -15650 0 0 {name=p160081 lab=_80208_/X }
C {devices/lab_pin.sym} 160900 -15650 0 1 {name=p160082 lab=_80220_/B }
C {sky130_stdcells/inv_2.sym} 160860 -15650 0 0 {name=X_80219_ }
C {devices/lab_pin.sym} 160820 -15530 0 0 {name=p160083 lab=_41181_/A }
C {devices/lab_pin.sym} 160900 -15530 0 1 {name=p160084 lab=_41181_/X }
C {sky130_stdcells/buf_2.sym} 160860 -15530 0 0 {name=X_41181_ }
C {devices/lab_pin.sym} 160800 -15420 0 0 {name=p160085 lab=_53147_/X }
C {devices/lab_pin.sym} 160800 -15380 0 0 {name=p160086 lab=_53167_/B }
C {devices/lab_pin.sym} 160920 -15400 0 1 {name=p160087 lab=_53167_/Y }
C {sky130_stdcells/nand2_4.sym} 160860 -15400 0 0 {name=X_53167_ }
C {devices/lab_pin.sym} 160780 -15290 0 0 {name=p160088 lab=_86212_/Q }
C {devices/lab_pin.sym} 160780 -15250 0 0 {name=p160089 lab=_50363_/X }
C {devices/lab_pin.sym} 160780 -15210 0 0 {name=p160090 lab=_50378_/Y }
C {devices/lab_pin.sym} 160940 -15250 0 1 {name=p160091 lab=_50379_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -15250 0 0 {name=X_50379_ }
C {devices/lab_pin.sym} 160820 -15110 0 0 {name=p160092 lab=clkbuf_8_242_0_CLK/X }
C {devices/lab_pin.sym} 160900 -15110 0 1 {name=p160093 lab=clkbuf_9_484_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 160860 -15110 0 0 {name=Xclkbuf_9_484_0_CLK }
C {devices/lab_pin.sym} 160770 -14990 0 0 {name=p160094 lab=_82931_/CLK }
C {devices/lab_pin.sym} 160770 -14970 0 0 {name=p160095 lab=_81199_/D }
C {devices/lab_pin.sym} 160950 -14990 0 1 {name=p160096 lab=_81199_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -14980 0 0 {name=X_81199_ }
C {devices/lab_pin.sym} 160820 -14850 0 0 {name=p160097 lab=_52431_/A }
C {devices/lab_pin.sym} 160900 -14850 0 1 {name=p160098 lab=_52188_/A }
C {sky130_stdcells/buf_2.sym} 160860 -14850 0 0 {name=X_52118_ }
C {devices/lab_pin.sym} 160770 -14730 0 0 {name=p160099 lab=_87813_/CLK }
C {devices/lab_pin.sym} 160770 -14710 0 0 {name=p160100 lab=_42576_/Y }
C {devices/lab_pin.sym} 160950 -14730 0 1 {name=p160101 lab=_87815_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -14720 0 0 {name=X_87815_ }
C {devices/lab_pin.sym} 160820 -14590 0 0 {name=p160102 lab=clkbuf_9_189_0_CLK/X }
C {devices/lab_pin.sym} 160900 -14590 0 1 {name=p160103 lab=_86688_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 160860 -14590 0 0 {name=Xclkbuf_10_378_0_CLK }
C {devices/lab_pin.sym} 160820 -14470 0 0 {name=p160104 lab=_53097_/X }
C {devices/lab_pin.sym} 160900 -14470 0 1 {name=p160105 lab=_53113_/B }
C {sky130_stdcells/buf_2.sym} 160860 -14470 0 0 {name=X_53098_ }
C {devices/lab_pin.sym} 160780 -14370 0 0 {name=p160106 lab=_57875_/X }
C {devices/lab_pin.sym} 160780 -14330 0 0 {name=p160107 lab=_85391_/Q }
C {devices/lab_pin.sym} 160780 -14290 0 0 {name=p160108 lab=_57974_/X }
C {devices/lab_pin.sym} 160940 -14330 0 1 {name=p160109 lab=_57975_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -14330 0 0 {name=X_57975_ }
C {devices/lab_pin.sym} 160820 -14190 0 0 {name=p160110 lab=_60175_/A }
C {devices/lab_pin.sym} 160900 -14190 0 1 {name=p160111 lab=_59716_/A }
C {sky130_stdcells/buf_2.sym} 160860 -14190 0 0 {name=X_59714_ }
C {devices/lab_pin.sym} 160820 -14070 0 0 {name=p160112 lab=_52486_/A }
C {devices/lab_pin.sym} 160900 -14070 0 1 {name=p160113 lab=_52049_/X }
C {sky130_stdcells/buf_2.sym} 160860 -14070 0 0 {name=X_52049_ }
C {devices/lab_pin.sym} 160800 -13960 0 0 {name=p160114 lab=_56609_/X }
C {devices/lab_pin.sym} 160800 -13920 0 0 {name=p160115 lab=_56922_/X }
C {devices/lab_pin.sym} 160920 -13940 0 1 {name=p160116 lab=_56927_/C }
C {sky130_stdcells/nand2_4.sym} 160860 -13940 0 0 {name=X_56926_ }
C {devices/lab_pin.sym} 160820 -13810 0 0 {name=p160117 lab=_64235_/B }
C {devices/lab_pin.sym} 160900 -13810 0 1 {name=p160118 lab=_61354_/B }
C {sky130_stdcells/buf_2.sym} 160860 -13810 0 0 {name=X_44940_ }
C {devices/lab_pin.sym} 160800 -13700 0 0 {name=p160119 lab=_81014_/Q }
C {devices/lab_pin.sym} 160800 -13660 0 0 {name=p160120 lab=_75760_/B }
C {devices/lab_pin.sym} 160920 -13680 0 1 {name=p160121 lab=_80982_/D }
C {sky130_stdcells/xor2_4.sym} 160860 -13680 0 0 {name=X_75760_ }
C {devices/lab_pin.sym} 160770 -13550 0 0 {name=p160122 lab=_88012_/CLK }
C {devices/lab_pin.sym} 160770 -13530 0 0 {name=p160123 lab=_87746_/D }
C {devices/lab_pin.sym} 160950 -13550 0 1 {name=p160124 lab=_68790_/B }
C {sky130_stdcells/dfxtp_4.sym} 160860 -13540 0 0 {name=X_87746_ }
C {devices/lab_pin.sym} 160780 -13430 0 0 {name=p160125 lab=_83170_/Q }
C {devices/lab_pin.sym} 160780 -13390 0 0 {name=p160126 lab=_72943_/X }
C {devices/lab_pin.sym} 160780 -13350 0 0 {name=p160127 lab=_72971_/Y }
C {devices/lab_pin.sym} 160940 -13390 0 1 {name=p160128 lab=_72972_/X }
C {sky130_stdcells/a21o_4.sym} 160860 -13390 0 0 {name=X_72972_ }
C {devices/lab_pin.sym} 160770 -13250 0 0 {name=p160129 lab=_84960_/CLK }
C {devices/lab_pin.sym} 160770 -13230 0 0 {name=p160130 lab=_57667_/Y }
C {devices/lab_pin.sym} 160950 -13250 0 1 {name=p160131 lab=_57664_/A }
C {sky130_stdcells/dfxtp_4.sym} 160860 -13240 0 0 {name=X_84958_ }
C {devices/lab_pin.sym} 160820 -13110 0 0 {name=p160132 lab=_74711_/A }
C {devices/lab_pin.sym} 160900 -13110 0 1 {name=p160133 lab=_74711_/Y }
C {sky130_stdcells/inv_2.sym} 160860 -13110 0 0 {name=X_74711_ }
C {devices/lab_pin.sym} 160800 -13010 0 0 {name=p160134 lab=_71698_/A }
C {devices/lab_pin.sym} 160800 -12970 0 0 {name=p160135 lab=_71930_/B }
C {devices/lab_pin.sym} 160800 -12930 0 0 {name=p160136 lab=_71574_/C }
C {devices/lab_pin.sym} 160920 -12970 0 1 {name=p160137 lab=_71923_/Y }
C {sky130_stdcells/nor3_4.sym} 160860 -12970 0 0 {name=X_71923_ }
C {devices/lab_pin.sym} 160770 -12830 0 0 {name=p160138 lab=_83905_/CLK }
C {devices/lab_pin.sym} 160770 -12810 0 0 {name=p160139 lab=_83909_/D }
C {devices/lab_pin.sym} 160950 -12830 0 1 {name=p160140 lab=_81981_/D }
C {sky130_stdcells/dfxtp_4.sym} 160860 -12820 0 0 {name=X_83909_ }
C {devices/lab_pin.sym} 160820 -12690 0 0 {name=p160141 lab=_59604_/X }
C {devices/lab_pin.sym} 160900 -12690 0 1 {name=p160142 lab=_59664_/C }
C {sky130_stdcells/buf_2.sym} 160860 -12690 0 0 {name=X_59645_ }
C {devices/lab_pin.sym} 160820 -12570 0 0 {name=p160143 lab=clkbuf_9_499_0_CLK/A }
C {devices/lab_pin.sym} 160900 -12570 0 1 {name=p160144 lab=clkbuf_9_499_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 160860 -12570 0 0 {name=Xclkbuf_9_499_0_CLK }
C {devices/lab_pin.sym} 160820 -12450 0 0 {name=p160145 lab=_45297_/A }
C {devices/lab_pin.sym} 160900 -12450 0 1 {name=p160146 lab=_45604_/B }
C {sky130_stdcells/buf_2.sym} 160860 -12450 0 0 {name=X_44871_ }
C {devices/lab_pin.sym} 160820 -12330 0 0 {name=p160147 lab=_56856_/Y }
C {devices/lab_pin.sym} 160900 -12330 0 1 {name=p160148 lab=_56857_/X }
C {sky130_stdcells/buf_2.sym} 160860 -12330 0 0 {name=X_56857_ }
C {devices/lab_pin.sym} 160780 -12230 0 0 {name=p160149 lab=_75684_/Y }
C {devices/lab_pin.sym} 160780 -12190 0 0 {name=p160150 lab=_75685_/A }
C {devices/lab_pin.sym} 160780 -12150 0 0 {name=p160151 lab=_75690_/Y }
C {devices/lab_pin.sym} 160940 -12190 0 1 {name=p160152 lab=_75692_/B }
C {sky130_stdcells/a21oi_4.sym} 160860 -12190 0 0 {name=X_75691_ }
C {devices/lab_pin.sym} 160770 -12050 0 0 {name=p160153 lab=_87686_/CLK }
C {devices/lab_pin.sym} 160770 -12030 0 0 {name=p160154 lab=_42870_/Y }
C {devices/lab_pin.sym} 160950 -12050 0 1 {name=p160155 lab=_67095_/B }
C {sky130_stdcells/dfxtp_4.sym} 160860 -12040 0 0 {name=X_87677_ }
C {devices/lab_pin.sym} 160770 -11910 0 0 {name=p160156 lab=_84921_/CLK }
C {devices/lab_pin.sym} 160770 -11890 0 0 {name=p160157 lab=_58281_/X }
C {devices/lab_pin.sym} 160950 -11910 0 1 {name=p160158 lab=_58279_/A }
C {sky130_stdcells/dfxtp_4.sym} 160860 -11900 0 0 {name=X_84889_ }
C {devices/lab_pin.sym} 160820 -11770 0 0 {name=p160159 lab=clkbuf_9_150_0_CLK/X }
C {devices/lab_pin.sym} 160900 -11770 0 1 {name=p160160 lab=_84314_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 160860 -11770 0 0 {name=Xclkbuf_10_301_0_CLK }
C {devices/lab_pin.sym} 160820 -11650 0 0 {name=p160161 lab=_46610_/A }
C {devices/lab_pin.sym} 160900 -11650 0 1 {name=p160162 lab=_74509_/B }
C {sky130_stdcells/buf_2.sym} 160860 -11650 0 0 {name=X_46610_ }
C {devices/lab_pin.sym} 160780 -11550 0 0 {name=p160163 lab=_77426_/X }
C {devices/lab_pin.sym} 160780 -11510 0 0 {name=p160164 lab=_77427_/Y }
C {devices/lab_pin.sym} 160780 -11470 0 0 {name=p160165 lab=_77431_/B }
C {devices/lab_pin.sym} 160940 -11510 0 1 {name=p160166 lab=_77430_/X }
C {sky130_stdcells/a21o_4.sym} 160860 -11510 0 0 {name=X_77430_ }
C {devices/lab_pin.sym} 160780 -11400 0 0 {name=p160167 lab=_41121_/X }
C {devices/lab_pin.sym} 160780 -11360 0 0 {name=p160168 lab=_43817_/X }
C {devices/lab_pin.sym} 160780 -11320 0 0 {name=p160169 lab=_87250_/Q }
C {devices/lab_pin.sym} 160780 -11280 0 0 {name=p160170 lab=_43818_/X }
C {devices/lab_pin.sym} 160940 -11340 0 1 {name=p160171 lab=_43822_/X }
C {sky130_stdcells/a2bb2o_4.sym} 160860 -11340 0 0 {name=X_43822_ }
C {devices/lab_pin.sym} 160800 -11200 0 0 {name=p160172 lab=_55817_/A }
C {devices/lab_pin.sym} 160800 -11160 0 0 {name=p160173 lab=_85293_/Q }
C {devices/lab_pin.sym} 160920 -11180 0 1 {name=p160174 lab=_55808_/X }
C {sky130_stdcells/and2_4.sym} 160860 -11180 0 0 {name=X_55808_ }
C {devices/lab_pin.sym} 160820 -11050 0 0 {name=p160175 lab=_74675_/A }
C {devices/lab_pin.sym} 160900 -11050 0 1 {name=p160176 lab=_74642_/X }
C {sky130_stdcells/buf_2.sym} 160860 -11050 0 0 {name=X_74642_ }
C {devices/lab_pin.sym} 160770 -10930 0 0 {name=p160177 lab=_85990_/CLK }
C {devices/lab_pin.sym} 160770 -10910 0 0 {name=p160178 lab=_47504_/Y }
C {devices/lab_pin.sym} 160950 -10930 0 1 {name=p160179 lab=_86628_/Q }
C {sky130_stdcells/dfxtp_4.sym} 160860 -10920 0 0 {name=X_86628_ }
C {devices/lab_pin.sym} 160820 -10790 0 0 {name=p160180 lab=_47589_/Y }
C {devices/lab_pin.sym} 160900 -10790 0 1 {name=p160181 lab=_53135_/B }
C {sky130_stdcells/buf_2.sym} 160860 -10790 0 0 {name=X_47590_ }
C {devices/lab_pin.sym} 160780 -10690 0 0 {name=p160182 lab=_71848_/X }
C {devices/lab_pin.sym} 160780 -10650 0 0 {name=p160183 lab=_83353_/Q }
C {devices/lab_pin.sym} 160780 -10610 0 0 {name=p160184 lab=_71853_/Y }
C {devices/lab_pin.sym} 160940 -10650 0 1 {name=p160185 lab=_83353_/D }
C {sky130_stdcells/a21o_4.sym} 160860 -10650 0 0 {name=X_71854_ }
C {devices/lab_pin.sym} 160820 -10510 0 0 {name=p160186 lab=_59575_/Y }
C {devices/lab_pin.sym} 160900 -10510 0 1 {name=p160187 lab=_59662_/C }
C {sky130_stdcells/inv_2.sym} 160860 -10510 0 0 {name=X_59576_ }
C {devices/lab_pin.sym} 160820 -10390 0 0 {name=p160188 lab=clkbuf_9_465_0_CLK/X }
C {devices/lab_pin.sym} 160900 -10390 0 1 {name=p160189 lab=_87834_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 160860 -10390 0 0 {name=Xclkbuf_10_931_0_CLK }
C {devices/lab_pin.sym} 160820 -10270 0 0 {name=p160190 lab=_56788_/A }
C {devices/lab_pin.sym} 160900 -10270 0 1 {name=p160191 lab=_56788_/X }
C {sky130_stdcells/buf_2.sym} 160860 -10270 0 0 {name=X_56788_ }
C {devices/lab_pin.sym} 160820 -10150 0 0 {name=p160192 lab=_70712_/A }
C {devices/lab_pin.sym} 160900 -10150 0 1 {name=p160193 lab=_74531_/C }
C {sky130_stdcells/buf_2.sym} 160860 -10150 0 0 {name=X_70805_ }
C {devices/lab_pin.sym} 160780 -10050 0 0 {name=p160194 lab=_46536_/Y }
C {devices/lab_pin.sym} 160780 -10010 0 0 {name=p160195 lab=_46523_/X }
C {devices/lab_pin.sym} 160780 -9970 0 0 {name=p160196 lab=_46540_/Y }
C {devices/lab_pin.sym} 160940 -10010 0 1 {name=p160197 lab=_46541_/Y }
C {sky130_stdcells/a21boi_4.sym} 160860 -10010 0 0 {name=X_46541_ }
C {devices/lab_pin.sym} 160820 -9870 0 0 {name=p160198 lab=_64379_/C }
C {devices/lab_pin.sym} 160900 -9870 0 1 {name=p160199 lab=_58528_/A }
C {sky130_stdcells/buf_2.sym} 160860 -9870 0 0 {name=X_58527_ }
C {devices/lab_pin.sym} 160820 -9750 0 0 {name=p160200 lab=_77361_/A }
C {devices/lab_pin.sym} 160900 -9750 0 1 {name=p160201 lab=_77361_/Y }
C {sky130_stdcells/inv_2.sym} 160860 -9750 0 0 {name=X_77361_ }
C {devices/lab_pin.sym} 160820 -9630 0 0 {name=p160202 lab=_43673_/A }
C {devices/lab_pin.sym} 160900 -9630 0 1 {name=p160203 lab=_43753_/X }
C {sky130_stdcells/buf_2.sym} 160860 -9630 0 0 {name=X_43753_ }
C {devices/lab_pin.sym} 160780 -9540 0 0 {name=p160204 lab=_56458_/C }
C {devices/lab_pin.sym} 160780 -9500 0 0 {name=p160205 lab=_55278_/A }
C {devices/lab_pin.sym} 160780 -9460 0 0 {name=p160206 lab=_55168_/A }
C {devices/lab_pin.sym} 160780 -9420 0 0 {name=p160207 lab=_55738_/X }
C {devices/lab_pin.sym} 160940 -9480 0 1 {name=p160208 lab=_55739_/X }
C {sky130_stdcells/a211o_4.sym} 160860 -9480 0 0 {name=X_55739_ }
C {devices/lab_pin.sym} 160770 -9330 0 0 {name=p160209 lab=_86560_/CLK }
C {devices/lab_pin.sym} 160770 -9310 0 0 {name=p160210 lab=_48185_/Y }
C {devices/lab_pin.sym} 160950 -9330 0 1 {name=p160211 lab=_65939_/B }
C {sky130_stdcells/dfxtp_4.sym} 160860 -9320 0 0 {name=X_86559_ }
C {devices/lab_pin.sym} 160780 -9220 0 0 {name=p160212 lab=_74559_/X }
C {devices/lab_pin.sym} 160780 -9180 0 0 {name=p160213 lab=_74569_/X }
C {devices/lab_pin.sym} 160780 -9140 0 0 {name=p160214 lab=_56063_/Y }
C {devices/lab_pin.sym} 160780 -9100 0 0 {name=p160215 lab=_74570_/X }
C {devices/lab_pin.sym} 160940 -9160 0 1 {name=p160216 lab=_74573_/X }
C {sky130_stdcells/a211o_4.sym} 160860 -9160 0 0 {name=X_74573_ }
C {devices/lab_pin.sym} 160780 -9040 0 0 {name=p160217 lab=_40964_/X }
C {devices/lab_pin.sym} 160780 -9000 0 0 {name=p160218 lab=_40941_/X }
C {devices/lab_pin.sym} 160780 -8960 0 0 {name=p160219 lab=_69209_/B }
C {devices/lab_pin.sym} 160780 -8920 0 0 {name=p160220 lab=_40942_/X }
C {devices/lab_pin.sym} 160940 -8980 0 1 {name=p160221 lab=_88302_/D }
C {sky130_stdcells/a2bb2o_4.sym} 160860 -8980 0 0 {name=X_40965_ }
C {devices/lab_pin.sym} 160820 -8830 0 0 {name=p160222 lab=_71714_/Y }
C {devices/lab_pin.sym} 160900 -8830 0 1 {name=p160223 lab=_71785_/X }
C {sky130_stdcells/buf_2.sym} 160860 -8830 0 0 {name=X_71785_ }
C {devices/lab_pin.sym} 160820 -8710 0 0 {name=p160224 lab=clkbuf_9_423_0_CLK/A }
C {devices/lab_pin.sym} 160900 -8710 0 1 {name=p160225 lab=clkbuf_9_422_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 160860 -8710 0 0 {name=Xclkbuf_9_422_0_CLK }
C {devices/lab_pin.sym} 160800 -8600 0 0 {name=p160226 lab=_79097_/Y }
C {devices/lab_pin.sym} 160800 -8560 0 0 {name=p160227 lab=_79099_/Y }
C {devices/lab_pin.sym} 160920 -8580 0 1 {name=p160228 lab=_82720_/D }
C {sky130_stdcells/nor2_4.sym} 160860 -8580 0 0 {name=X_79100_ }
C {devices/lab_pin.sym} 160800 -8460 0 0 {name=p160229 lab=_76312_/A }
C {devices/lab_pin.sym} 160800 -8420 0 0 {name=p160230 lab=_76312_/B }
C {devices/lab_pin.sym} 160920 -8440 0 1 {name=p160231 lab=_76312_/X }
C {sky130_stdcells/xor2_4.sym} 160860 -8440 0 0 {name=X_76312_ }
C {devices/lab_pin.sym} 160780 -8350 0 0 {name=p160232 lab=_42687_/X }
C {devices/lab_pin.sym} 160780 -8310 0 0 {name=p160233 lab=_42688_/X }
C {devices/lab_pin.sym} 160780 -8270 0 0 {name=p160234 lab=_41125_/X }
C {devices/lab_pin.sym} 160780 -8230 0 0 {name=p160235 lab=_68425_/B }
C {devices/lab_pin.sym} 160780 -8190 0 0 {name=p160236 lab=_42700_/X }
C {devices/lab_pin.sym} 160940 -8270 0 1 {name=p160237 lab=_42704_/Y }
C {sky130_stdcells/o32ai_4.sym} 160860 -8270 0 0 {name=X_42704_ }
C {devices/lab_pin.sym} 160780 -8130 0 0 {name=p160238 lab=_49258_/Y }
C {devices/lab_pin.sym} 160780 -8090 0 0 {name=p160239 lab=_49247_/X }
C {devices/lab_pin.sym} 160780 -8050 0 0 {name=p160240 lab=_49259_/Y }
C {devices/lab_pin.sym} 160940 -8090 0 1 {name=p160241 lab=_49260_/Y }
C {sky130_stdcells/a21boi_4.sym} 160860 -8090 0 0 {name=X_49260_ }
C {devices/lab_pin.sym} 160800 -7970 0 0 {name=p160242 lab=_73522_/X }
C {devices/lab_pin.sym} 160800 -7930 0 0 {name=p160243 lab=_73524_/B }
C {devices/lab_pin.sym} 160800 -7890 0 0 {name=p160244 lab=_73524_/C }
C {devices/lab_pin.sym} 160920 -7930 0 1 {name=p160245 lab=_73524_/Y }
C {sky130_stdcells/nand3_4.sym} 160860 -7930 0 0 {name=X_73524_ }
C {devices/lab_pin.sym} 160800 -7810 0 0 {name=p160246 lab=_51330_/A }
C {devices/lab_pin.sym} 160800 -7770 0 0 {name=p160247 lab=_46428_/B }
C {devices/lab_pin.sym} 160800 -7730 0 0 {name=p160248 lab=_46472_/C }
C {devices/lab_pin.sym} 160920 -7770 0 1 {name=p160249 lab=_46472_/X }
C {sky130_stdcells/and3_4.sym} 160860 -7770 0 0 {name=X_46472_ }
C {devices/lab_pin.sym} 160800 -7660 0 0 {name=p160250 lab=_74515_/C }
C {devices/lab_pin.sym} 160800 -7620 0 0 {name=p160251 lab=_70730_/X }
C {devices/lab_pin.sym} 160800 -7580 0 0 {name=p160252 lab=_70732_/X }
C {devices/lab_pin.sym} 160800 -7540 0 0 {name=p160253 lab=_70735_/X }
C {devices/lab_pin.sym} 160920 -7600 0 1 {name=p160254 lab=_70736_/Y }
C {sky130_stdcells/nand4_4.sym} 160860 -7600 0 0 {name=X_70736_ }
C {devices/lab_pin.sym} 160780 -7470 0 0 {name=p160255 lab=_58341_/X }
C {devices/lab_pin.sym} 160780 -7430 0 0 {name=p160256 lab=_58454_/Y }
C {devices/lab_pin.sym} 160780 -7390 0 0 {name=p160257 lab=_58457_/Y }
C {devices/lab_pin.sym} 160940 -7430 0 1 {name=p160258 lab=_84844_/D }
C {sky130_stdcells/a21oi_4.sym} 160860 -7430 0 0 {name=X_58458_ }
C {devices/lab_pin.sym} 160800 -7300 0 0 {name=p160259 lab=_77294_/A }
C {devices/lab_pin.sym} 160800 -7260 0 0 {name=p160260 lab=_77294_/B }
C {devices/lab_pin.sym} 160920 -7280 0 1 {name=p160261 lab=_77292_/Y }
C {sky130_stdcells/nor2_4.sym} 160860 -7280 0 0 {name=X_77292_ }
C {devices/lab_pin.sym} 160820 -7150 0 0 {name=p160262 lab=_43683_/X }
C {devices/lab_pin.sym} 160900 -7150 0 1 {name=p160263 lab=_87311_/D }
C {sky130_stdcells/inv_2.sym} 160860 -7150 0 0 {name=X_43684_ }
C {devices/lab_pin.sym} 160820 -7030 0 0 {name=p160264 lab=clkbuf_9_158_0_CLK/X }
C {devices/lab_pin.sym} 160900 -7030 0 1 {name=p160265 lab=_85485_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 160860 -7030 0 0 {name=Xclkbuf_10_316_0_CLK }
C {devices/lab_pin.sym} 160820 -6910 0 0 {name=p160266 lab=_40895_/Y }
C {devices/lab_pin.sym} 160900 -6910 0 1 {name=p160267 lab=_88315_/D }
C {sky130_stdcells/inv_2.sym} 160860 -6910 0 0 {name=X_40896_ }
C {devices/lab_pin.sym} 160780 -6810 0 0 {name=p160268 lab=_65997_/B }
C {devices/lab_pin.sym} 160780 -6770 0 0 {name=p160269 lab=_48203_/X }
C {devices/lab_pin.sym} 160780 -6730 0 0 {name=p160270 lab=_48210_/Y }
C {devices/lab_pin.sym} 160940 -6770 0 1 {name=p160271 lab=_48211_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -6770 0 0 {name=X_48211_ }
C {devices/lab_pin.sym} 160800 -6640 0 0 {name=p160272 lab=_79029_/Y }
C {devices/lab_pin.sym} 160800 -6600 0 0 {name=p160273 lab=_79031_/B }
C {devices/lab_pin.sym} 160920 -6620 0 1 {name=p160274 lab=_79034_/A }
C {sky130_stdcells/xor2_4.sym} 160860 -6620 0 0 {name=X_79031_ }
C {devices/lab_pin.sym} 160800 -6500 0 0 {name=p160275 lab=_85119_/Q }
C {devices/lab_pin.sym} 160800 -6460 0 0 {name=p160276 lab=_44892_/X }
C {devices/lab_pin.sym} 160920 -6480 0 1 {name=p160277 lab=_45423_/Y }
C {sky130_stdcells/nor2_4.sym} 160860 -6480 0 0 {name=X_45423_ }
C {devices/lab_pin.sym} 160800 -6360 0 0 {name=p160278 lab=_57409_/A }
C {devices/lab_pin.sym} 160800 -6320 0 0 {name=p160279 lab=_56703_/X }
C {devices/lab_pin.sym} 160920 -6340 0 1 {name=p160280 lab=_57409_/Y }
C {sky130_stdcells/nor2_4.sym} 160860 -6340 0 0 {name=X_57409_ }
C {devices/lab_pin.sym} 160800 -6220 0 0 {name=p160281 lab=_76239_/X }
C {devices/lab_pin.sym} 160800 -6180 0 0 {name=p160282 lab=_76242_/Y }
C {devices/lab_pin.sym} 160920 -6200 0 1 {name=p160283 lab=_81608_/D }
C {sky130_stdcells/xor2_4.sym} 160860 -6200 0 0 {name=X_76243_ }
C {devices/lab_pin.sym} 160770 -6070 0 0 {name=p160284 lab=_88232_/CLK }
C {devices/lab_pin.sym} 160770 -6050 0 0 {name=p160285 lab=_88229_/D }
C {devices/lab_pin.sym} 160950 -6070 0 1 {name=p160286 lab=_67672_/B }
C {sky130_stdcells/dfxtp_4.sym} 160860 -6060 0 0 {name=X_88229_ }
C {devices/lab_pin.sym} 160780 -5960 0 0 {name=p160287 lab=_40935_/X }
C {devices/lab_pin.sym} 160780 -5920 0 0 {name=p160288 lab=_42631_/X }
C {devices/lab_pin.sym} 160780 -5880 0 0 {name=p160289 lab=_87795_/Q }
C {devices/lab_pin.sym} 160780 -5840 0 0 {name=p160290 lab=_42634_/X }
C {devices/lab_pin.sym} 160940 -5900 0 1 {name=p160291 lab=_42635_/X }
C {sky130_stdcells/a2bb2o_4.sym} 160860 -5900 0 0 {name=X_42635_ }
C {devices/lab_pin.sym} 160820 -5750 0 0 {name=p160292 lab=clkbuf_9_473_0_CLK/X }
C {devices/lab_pin.sym} 160900 -5750 0 1 {name=p160293 lab=_88085_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 160860 -5750 0 0 {name=Xclkbuf_10_946_0_CLK }
C {devices/lab_pin.sym} 160800 -5640 0 0 {name=p160294 lab=_73386_/A }
C {devices/lab_pin.sym} 160800 -5600 0 0 {name=p160295 lab=_86502_/Q }
C {devices/lab_pin.sym} 160920 -5620 0 1 {name=p160296 lab=_73455_/X }
C {sky130_stdcells/and2_4.sym} 160860 -5620 0 0 {name=X_73455_ }
C {devices/lab_pin.sym} 160780 -5510 0 0 {name=p160297 lab=_40623_/X }
C {devices/lab_pin.sym} 160780 -5470 0 0 {name=p160298 lab=_48697_/Y }
C {devices/lab_pin.sym} 160780 -5430 0 0 {name=p160299 lab=_49190_/Y }
C {devices/lab_pin.sym} 160940 -5470 0 1 {name=p160300 lab=_49192_/A }
C {sky130_stdcells/a21o_4.sym} 160860 -5470 0 0 {name=X_49191_ }
C {devices/lab_pin.sym} 160820 -5330 0 0 {name=p160301 lab=_70667_/A }
C {devices/lab_pin.sym} 160900 -5330 0 1 {name=p160302 lab=_70676_/B }
C {sky130_stdcells/buf_2.sym} 160860 -5330 0 0 {name=X_70667_ }
C {devices/lab_pin.sym} 160820 -5210 0 0 {name=p160303 lab=_84861_/Q }
C {devices/lab_pin.sym} 160900 -5210 0 1 {name=p160304 lab=_58391_/A }
C {sky130_stdcells/inv_2.sym} 160860 -5210 0 0 {name=X_58389_ }
C {devices/lab_pin.sym} 160780 -5130 0 0 {name=p160305 lab=_72299_/X }
C {devices/lab_pin.sym} 160780 -5090 0 0 {name=p160306 lab=_72404_/Y }
C {devices/lab_pin.sym} 160780 -5050 0 0 {name=p160307 lab=_72405_/Y }
C {devices/lab_pin.sym} 160780 -5010 0 0 {name=p160308 lab=_72337_/X }
C {devices/lab_pin.sym} 160780 -4970 0 0 {name=p160309 lab=_72303_/X }
C {devices/lab_pin.sym} 160940 -5050 0 1 {name=p160310 lab=_72406_/X }
C {sky130_stdcells/o32a_4.sym} 160860 -5050 0 0 {name=X_72406_ }
C {devices/lab_pin.sym} 160800 -4900 0 0 {name=p160311 lab=_48142_/A }
C {devices/lab_pin.sym} 160800 -4860 0 0 {name=p160312 lab=_50383_/B }
C {devices/lab_pin.sym} 160920 -4880 0 1 {name=p160313 lab=_48142_/Y }
C {sky130_stdcells/nand2_4.sym} 160860 -4880 0 0 {name=X_48142_ }
C {devices/lab_pin.sym} 160820 -4750 0 0 {name=p160314 lab=_60420_/A }
C {devices/lab_pin.sym} 160900 -4750 0 1 {name=p160315 lab=_60421_/B }
C {sky130_stdcells/inv_2.sym} 160860 -4750 0 0 {name=X_60420_ }
C {devices/lab_pin.sym} 160820 -4630 0 0 {name=p160316 lab=_45705_/A }
C {devices/lab_pin.sym} 160900 -4630 0 1 {name=p160317 lab=_45354_/X }
C {sky130_stdcells/buf_2.sym} 160860 -4630 0 0 {name=X_45354_ }
C {devices/lab_pin.sym} 160800 -4530 0 0 {name=p160318 lab=_76174_/A }
C {devices/lab_pin.sym} 160800 -4490 0 0 {name=p160319 lab=_76176_/A }
C {devices/lab_pin.sym} 160800 -4450 0 0 {name=p160320 lab=_76175_/A }
C {devices/lab_pin.sym} 160920 -4490 0 1 {name=p160321 lab=_76174_/Y }
C {sky130_stdcells/nand3_4.sym} 160860 -4490 0 0 {name=X_76174_ }
C {devices/lab_pin.sym} 160820 -4350 0 0 {name=p160322 lab=clkbuf_8_218_0_CLK/X }
C {devices/lab_pin.sym} 160900 -4350 0 1 {name=p160323 lab=clkbuf_9_437_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 160860 -4350 0 0 {name=Xclkbuf_9_437_0_CLK }
C {devices/lab_pin.sym} 160780 -4270 0 0 {name=p160324 lab=_42521_/X }
C {devices/lab_pin.sym} 160780 -4230 0 0 {name=p160325 lab=_42522_/X }
C {devices/lab_pin.sym} 160780 -4190 0 0 {name=p160326 lab=_40814_/X }
C {devices/lab_pin.sym} 160780 -4150 0 0 {name=p160327 lab=_87817_/Q }
C {devices/lab_pin.sym} 160780 -4110 0 0 {name=p160328 lab=_42540_/X }
C {devices/lab_pin.sym} 160940 -4190 0 1 {name=p160329 lab=_42566_/Y }
C {sky130_stdcells/o32ai_4.sym} 160860 -4190 0 0 {name=X_42566_ }
C {devices/lab_pin.sym} 160800 -4040 0 0 {name=p160330 lab=_73386_/A }
C {devices/lab_pin.sym} 160800 -4000 0 0 {name=p160331 lab=_86505_/Q }
C {devices/lab_pin.sym} 160920 -4020 0 1 {name=p160332 lab=_73386_/X }
C {sky130_stdcells/and2_4.sym} 160860 -4020 0 0 {name=X_73386_ }
C {devices/lab_pin.sym} 160820 -3890 0 0 {name=p160333 lab=_70768_/A }
C {devices/lab_pin.sym} 160900 -3890 0 1 {name=p160334 lab=_70710_/A }
C {sky130_stdcells/buf_2.sym} 160860 -3890 0 0 {name=X_70598_ }
C {devices/lab_pin.sym} 160820 -3770 0 0 {name=p160335 lab=_73181_/A }
C {devices/lab_pin.sym} 160900 -3770 0 1 {name=p160336 lab=_44305_/X }
C {sky130_stdcells/buf_2.sym} 160860 -3770 0 0 {name=X_44305_ }
C {devices/lab_pin.sym} 160800 -3660 0 0 {name=p160337 lab=_80678_/Q }
C {devices/lab_pin.sym} 160800 -3620 0 0 {name=p160338 lab=_75124_/B }
C {devices/lab_pin.sym} 160920 -3640 0 1 {name=p160339 lab=_75127_/C }
C {sky130_stdcells/nand2_4.sym} 160860 -3640 0 0 {name=X_75125_ }
C {devices/lab_pin.sym} 160820 -3510 0 0 {name=p160340 lab=_41517_/A }
C {devices/lab_pin.sym} 160900 -3510 0 1 {name=p160341 lab=_41517_/Y }
C {sky130_stdcells/inv_2.sym} 160860 -3510 0 0 {name=X_41517_ }
C {devices/lab_pin.sym} 160800 -3400 0 0 {name=p160342 lab=_48092_/A }
C {devices/lab_pin.sym} 160800 -3360 0 0 {name=p160343 lab=_48073_/B }
C {devices/lab_pin.sym} 160920 -3380 0 1 {name=p160344 lab=_48073_/Y }
C {sky130_stdcells/nand2_4.sym} 160860 -3380 0 0 {name=X_48073_ }
C {devices/lab_pin.sym} 160780 -3280 0 0 {name=p160345 lab=_60350_/Y }
C {devices/lab_pin.sym} 160780 -3240 0 0 {name=p160346 lab=_60344_/C }
C {devices/lab_pin.sym} 160780 -3200 0 0 {name=p160347 lab=_60255_/A }
C {devices/lab_pin.sym} 160780 -3160 0 0 {name=p160348 lab=_60327_/X }
C {devices/lab_pin.sym} 160940 -3220 0 1 {name=p160349 lab=_60351_/X }
C {sky130_stdcells/a211o_4.sym} 160860 -3220 0 0 {name=X_60351_ }
C {devices/lab_pin.sym} 160820 -3070 0 0 {name=p160350 lab=_59133_/A }
C {devices/lab_pin.sym} 160900 -3070 0 1 {name=p160351 lab=_72337_/X }
C {sky130_stdcells/buf_2.sym} 160860 -3070 0 0 {name=X_72337_ }
C {devices/lab_pin.sym} 160780 -2970 0 0 {name=p160352 lab=_85160_/Q }
C {devices/lab_pin.sym} 160780 -2930 0 0 {name=p160353 lab=_45284_/X }
C {devices/lab_pin.sym} 160780 -2890 0 0 {name=p160354 lab=_45265_/X }
C {devices/lab_pin.sym} 160940 -2930 0 1 {name=p160355 lab=_45285_/X }
C {sky130_stdcells/o21a_4.sym} 160860 -2930 0 0 {name=X_45285_ }
C {devices/lab_pin.sym} 160780 -2830 0 0 {name=p160356 lab=_42495_/X }
C {devices/lab_pin.sym} 160780 -2790 0 0 {name=p160357 lab=_42496_/X }
C {devices/lab_pin.sym} 160780 -2750 0 0 {name=p160358 lab=_40667_/X }
C {devices/lab_pin.sym} 160780 -2710 0 0 {name=p160359 lab=_68727_/A }
C {devices/lab_pin.sym} 160780 -2670 0 0 {name=p160360 lab=_42480_/X }
C {devices/lab_pin.sym} 160940 -2750 0 1 {name=p160361 lab=_42498_/A }
C {sky130_stdcells/o32ai_4.sym} 160860 -2750 0 0 {name=X_42497_ }
C {devices/lab_pin.sym} 160820 -2590 0 0 {name=p160362 lab=_47023_/Y }
C {devices/lab_pin.sym} 160900 -2590 0 1 {name=p160363 lab=_52807_/B }
C {sky130_stdcells/buf_2.sym} 160860 -2590 0 0 {name=X_47024_ }
C {devices/lab_pin.sym} 160800 -2500 0 0 {name=p160364 lab=_44196_/A }
C {devices/lab_pin.sym} 160800 -2460 0 0 {name=p160365 lab=_44196_/B }
C {devices/lab_pin.sym} 160800 -2420 0 0 {name=p160366 lab=_44235_/X }
C {devices/lab_pin.sym} 160800 -2380 0 0 {name=p160367 lab=_44196_/D }
C {devices/lab_pin.sym} 160920 -2440 0 1 {name=p160368 lab=_44236_/X }
C {sky130_stdcells/and4_4.sym} 160860 -2440 0 0 {name=X_44236_ }
C {devices/lab_pin.sym} 160780 -2310 0 0 {name=p160369 lab=_63068_/Y }
C {devices/lab_pin.sym} 160780 -2270 0 0 {name=p160370 lab=_63069_/X }
C {devices/lab_pin.sym} 160780 -2230 0 0 {name=p160371 lab=_63056_/X }
C {devices/lab_pin.sym} 160940 -2270 0 1 {name=p160372 lab=_63070_/Y }
C {sky130_stdcells/a21oi_4.sym} 160860 -2270 0 0 {name=X_63070_ }
C {devices/lab_pin.sym} 160800 -2140 0 0 {name=p160373 lab=_81150_/D }
C {devices/lab_pin.sym} 160800 -2100 0 0 {name=p160374 lab=_75046_/B }
C {devices/lab_pin.sym} 160920 -2120 0 1 {name=p160375 lab=_75056_/X }
C {sky130_stdcells/or2_4.sym} 160860 -2120 0 0 {name=X_75056_ }
C {devices/lab_pin.sym} 160780 -2010 0 0 {name=p160376 lab=_79926_/A }
C {devices/lab_pin.sym} 160780 -1970 0 0 {name=p160377 lab=_79918_/Y }
C {devices/lab_pin.sym} 160780 -1930 0 0 {name=p160378 lab=_79919_/Y }
C {devices/lab_pin.sym} 160940 -1970 0 1 {name=p160379 lab=_79934_/A }
C {sky130_stdcells/a21boi_4.sym} 160860 -1970 0 0 {name=X_79933_ }
C {devices/lab_pin.sym} 160780 -1860 0 0 {name=p160380 lab=_41447_/X }
C {devices/lab_pin.sym} 160780 -1820 0 0 {name=p160381 lab=_41418_/X }
C {devices/lab_pin.sym} 160780 -1780 0 0 {name=p160382 lab=_68047_/B }
C {devices/lab_pin.sym} 160780 -1740 0 0 {name=p160383 lab=_41419_/X }
C {devices/lab_pin.sym} 160940 -1800 0 1 {name=p160384 lab=_88213_/D }
C {sky130_stdcells/a2bb2o_4.sym} 160860 -1800 0 0 {name=X_41448_ }
C {devices/lab_pin.sym} 160780 -1670 0 0 {name=p160385 lab=_72228_/X }
C {devices/lab_pin.sym} 160780 -1630 0 0 {name=p160386 lab=_85973_/Q }
C {devices/lab_pin.sym} 160780 -1590 0 0 {name=p160387 lab=_72267_/X }
C {devices/lab_pin.sym} 160940 -1630 0 1 {name=p160388 lab=_72268_/Y }
C {sky130_stdcells/o21ai_4.sym} 160860 -1630 0 0 {name=X_72268_ }
C {devices/lab_pin.sym} 160800 -1510 0 0 {name=p160389 lab=_60344_/A }
C {devices/lab_pin.sym} 160800 -1470 0 0 {name=p160390 lab=_60221_/A }
C {devices/lab_pin.sym} 160800 -1430 0 0 {name=p160391 lab=_60324_/A }
C {devices/lab_pin.sym} 160920 -1470 0 1 {name=p160392 lab=_60284_/B }
C {sky130_stdcells/nand3_4.sym} 160860 -1470 0 0 {name=X_60282_ }
C {devices/lab_pin.sym} 160800 -1360 0 0 {name=p160393 lab=_61962_/X }
C {devices/lab_pin.sym} 160800 -1320 0 0 {name=p160394 lab=_62021_/B }
C {devices/lab_pin.sym} 160800 -1280 0 0 {name=p160395 lab=_58483_/A }
C {devices/lab_pin.sym} 160800 -1240 0 0 {name=p160396 lab=_62020_/X }
C {devices/lab_pin.sym} 160920 -1300 0 1 {name=p160397 lab=_62021_/X }
C {sky130_stdcells/and4_4.sym} 160860 -1300 0 0 {name=X_62021_ }
C {devices/lab_pin.sym} 160800 -1160 0 0 {name=p160398 lab=_87328_/Q }
C {devices/lab_pin.sym} 160800 -1120 0 0 {name=p160399 lab=_74246_/B }
C {devices/lab_pin.sym} 160920 -1140 0 1 {name=p160400 lab=_74007_/Y }
C {sky130_stdcells/nor2_4.sym} 160860 -1140 0 0 {name=X_74007_ }
C {devices/lab_pin.sym} 160800 -1030 0 0 {name=p160401 lab=_71219_/A }
C {devices/lab_pin.sym} 160800 -990 0 0 {name=p160402 lab=_71076_/B }
C {devices/lab_pin.sym} 160800 -950 0 0 {name=p160403 lab=_71219_/C }
C {devices/lab_pin.sym} 160920 -990 0 1 {name=p160404 lab=_71219_/Y }
C {sky130_stdcells/nand3_4.sym} 160860 -990 0 0 {name=X_71219_ }
C {devices/lab_pin.sym} 160800 -870 0 0 {name=p160405 lab=_44006_/X }
C {devices/lab_pin.sym} 160800 -830 0 0 {name=p160406 lab=_44164_/X }
C {devices/lab_pin.sym} 160800 -790 0 0 {name=p160407 lab=_44166_/Y }
C {devices/lab_pin.sym} 160920 -830 0 1 {name=p160408 lab=_44167_/Y }
C {sky130_stdcells/nand3_4.sym} 160860 -830 0 0 {name=X_44167_ }
C {devices/lab_pin.sym} 160800 -700 0 0 {name=p160409 lab=_79862_/X }
C {devices/lab_pin.sym} 160800 -660 0 0 {name=p160410 lab=_79864_/B }
C {devices/lab_pin.sym} 160920 -680 0 1 {name=p160411 lab=_79865_/B }
C {sky130_stdcells/xnor2_4.sym} 160860 -680 0 0 {name=X_79864_ }
C {devices/lab_pin.sym} 161740 -42150 0 0 {name=p160412 lab=_41013_/A }
C {devices/lab_pin.sym} 161820 -42150 0 1 {name=p160413 lab=_41379_/X }
C {sky130_stdcells/buf_2.sym} 161780 -42150 0 0 {name=X_41379_ }
C {devices/lab_pin.sym} 161700 -42050 0 0 {name=p160414 lab=_72123_/X }
C {devices/lab_pin.sym} 161700 -42010 0 0 {name=p160415 lab=_85691_/Q }
C {devices/lab_pin.sym} 161700 -41970 0 0 {name=p160416 lab=_72146_/X }
C {devices/lab_pin.sym} 161860 -42010 0 1 {name=p160417 lab=_72199_/X }
C {sky130_stdcells/o21a_4.sym} 161780 -42010 0 0 {name=X_72199_ }
C {devices/lab_pin.sym} 161700 -41910 0 0 {name=p160418 lab=_43105_/X }
C {devices/lab_pin.sym} 161700 -41870 0 0 {name=p160419 lab=_43106_/X }
C {devices/lab_pin.sym} 161700 -41830 0 0 {name=p160420 lab=_40776_/X }
C {devices/lab_pin.sym} 161700 -41790 0 0 {name=p160421 lab=_43117_/Y }
C {devices/lab_pin.sym} 161700 -41750 0 0 {name=p160422 lab=_43108_/X }
C {devices/lab_pin.sym} 161860 -41830 0 1 {name=p160423 lab=_43118_/Y }
C {sky130_stdcells/o32ai_4.sym} 161780 -41830 0 0 {name=X_43118_ }
C {devices/lab_pin.sym} 161740 -41670 0 0 {name=p160424 lab=_82627_/Q }
C {devices/lab_pin.sym} 161820 -41670 0 1 {name=p160425 lab=_78818_/C }
C {sky130_stdcells/inv_2.sym} 161780 -41670 0 0 {name=X_78815_ }
C {devices/lab_pin.sym} 161700 -41570 0 0 {name=p160426 lab=_86456_/Q }
C {devices/lab_pin.sym} 161700 -41530 0 0 {name=p160427 lab=_48952_/X }
C {devices/lab_pin.sym} 161700 -41490 0 0 {name=p160428 lab=_48974_/Y }
C {devices/lab_pin.sym} 161860 -41530 0 1 {name=p160429 lab=_48975_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -41530 0 0 {name=X_48975_ }
C {devices/lab_pin.sym} 161740 -41390 0 0 {name=p160430 lab=_44097_/X }
C {devices/lab_pin.sym} 161820 -41390 0 1 {name=p160431 lab=_44098_/X }
C {sky130_stdcells/buf_2.sym} 161780 -41390 0 0 {name=X_44098_ }
C {devices/lab_pin.sym} 161700 -41290 0 0 {name=p160432 lab=_64870_/C }
C {devices/lab_pin.sym} 161700 -41250 0 0 {name=p160433 lab=_72224_/Y }
C {devices/lab_pin.sym} 161700 -41210 0 0 {name=p160434 lab=_79794_/Y }
C {devices/lab_pin.sym} 161860 -41250 0 1 {name=p160435 lab=_79795_/X }
C {sky130_stdcells/o21a_4.sym} 161780 -41250 0 0 {name=X_79795_ }
C {devices/lab_pin.sym} 161720 -41120 0 0 {name=p160436 lab=_47926_/A }
C {devices/lab_pin.sym} 161720 -41080 0 0 {name=p160437 lab=_47963_/B }
C {devices/lab_pin.sym} 161840 -41100 0 1 {name=p160438 lab=_47926_/X }
C {sky130_stdcells/or2_4.sym} 161780 -41100 0 0 {name=X_47926_ }
C {devices/lab_pin.sym} 161700 -41010 0 0 {name=p160439 lab=_43046_/X }
C {devices/lab_pin.sym} 161700 -40970 0 0 {name=p160440 lab=_43047_/X }
C {devices/lab_pin.sym} 161700 -40930 0 0 {name=p160441 lab=_40633_/X }
C {devices/lab_pin.sym} 161700 -40890 0 0 {name=p160442 lab=_43048_/Y }
C {devices/lab_pin.sym} 161700 -40850 0 0 {name=p160443 lab=_43034_/X }
C {devices/lab_pin.sym} 161860 -40930 0 1 {name=p160444 lab=_43049_/Y }
C {sky130_stdcells/o32ai_4.sym} 161780 -40930 0 0 {name=X_43049_ }
C {devices/lab_pin.sym} 161700 -40790 0 0 {name=p160445 lab=_78675_/B }
C {devices/lab_pin.sym} 161700 -40750 0 0 {name=p160446 lab=_78740_/X }
C {devices/lab_pin.sym} 161700 -40710 0 0 {name=p160447 lab=_78745_/Y }
C {devices/lab_pin.sym} 161860 -40750 0 1 {name=p160448 lab=_78746_/Y }
C {sky130_stdcells/a21oi_4.sym} 161780 -40750 0 0 {name=X_78746_ }
C {devices/lab_pin.sym} 161720 -40620 0 0 {name=p160449 lab=_66760_/A }
C {devices/lab_pin.sym} 161720 -40580 0 0 {name=p160450 lab=_87691_/Q }
C {devices/lab_pin.sym} 161840 -40600 0 1 {name=p160451 lab=_66760_/X }
C {sky130_stdcells/and2_4.sym} 161780 -40600 0 0 {name=X_66760_ }
C {devices/lab_pin.sym} 161740 -40470 0 0 {name=p160452 lab=_63972_/A }
C {devices/lab_pin.sym} 161820 -40470 0 1 {name=p160453 lab=_64003_/C }
C {sky130_stdcells/buf_2.sym} 161780 -40470 0 0 {name=X_63972_ }
C {devices/lab_pin.sym} 161720 -40360 0 0 {name=p160454 lab=_75957_/A }
C {devices/lab_pin.sym} 161720 -40320 0 0 {name=p160455 lab=_75957_/B }
C {devices/lab_pin.sym} 161840 -40340 0 1 {name=p160456 lab=_75958_/Y }
C {sky130_stdcells/nor2_4.sym} 161780 -40340 0 0 {name=X_75958_ }
C {devices/lab_pin.sym} 161720 -40230 0 0 {name=p160457 lab=_65086_/X }
C {devices/lab_pin.sym} 161720 -40190 0 0 {name=p160458 lab=_65828_/B }
C {devices/lab_pin.sym} 161720 -40150 0 0 {name=p160459 lab=_65088_/X }
C {devices/lab_pin.sym} 161840 -40190 0 1 {name=p160460 lab=_65711_/Y }
C {sky130_stdcells/nand3_4.sym} 161780 -40190 0 0 {name=X_65711_ }
C {devices/lab_pin.sym} 161720 -40060 0 0 {name=p160461 lab=_58279_/Y }
C {devices/lab_pin.sym} 161720 -40020 0 0 {name=p160462 lab=_60337_/C }
C {devices/lab_pin.sym} 161840 -40040 0 1 {name=p160463 lab=_62923_/Y }
C {sky130_stdcells/nor2_4.sym} 161780 -40040 0 0 {name=X_62923_ }
C {devices/lab_pin.sym} 161700 -39930 0 0 {name=p160464 lab=_74904_/Y }
C {devices/lab_pin.sym} 161700 -39890 0 0 {name=p160465 lab=_74905_/A }
C {devices/lab_pin.sym} 161700 -39850 0 0 {name=p160466 lab=_74908_/Y }
C {devices/lab_pin.sym} 161860 -39890 0 1 {name=p160467 lab=_74909_/Y }
C {sky130_stdcells/a21boi_4.sym} 161780 -39890 0 0 {name=X_74909_ }
C {devices/lab_pin.sym} 161740 -39750 0 0 {name=p160468 lab=_48144_/A }
C {devices/lab_pin.sym} 161820 -39750 0 1 {name=p160469 lab=_47857_/X }
C {sky130_stdcells/buf_2.sym} 161780 -39750 0 0 {name=X_47857_ }
C {devices/lab_pin.sym} 161720 -39640 0 0 {name=p160470 lab=_66664_/X }
C {devices/lab_pin.sym} 161720 -39600 0 0 {name=p160471 lab=_66691_/B }
C {devices/lab_pin.sym} 161840 -39620 0 1 {name=p160472 lab=_66691_/X }
C {sky130_stdcells/and2_4.sym} 161780 -39620 0 0 {name=X_66691_ }
C {devices/lab_pin.sym} 161700 -39510 0 0 {name=p160473 lab=_78663_/A }
C {devices/lab_pin.sym} 161700 -39470 0 0 {name=p160474 lab=_78663_/B }
C {devices/lab_pin.sym} 161700 -39430 0 0 {name=p160475 lab=_78661_/Y }
C {devices/lab_pin.sym} 161860 -39470 0 1 {name=p160476 lab=_78685_/A }
C {sky130_stdcells/o21a_4.sym} 161780 -39470 0 0 {name=X_78677_ }
C {devices/lab_pin.sym} 161720 -39340 0 0 {name=p160477 lab=_75889_/A }
C {devices/lab_pin.sym} 161720 -39300 0 0 {name=p160478 lab=_80820_/Q }
C {devices/lab_pin.sym} 161840 -39320 0 1 {name=p160479 lab=_75889_/Y }
C {sky130_stdcells/xnor2_4.sym} 161780 -39320 0 0 {name=X_75889_ }
C {devices/lab_pin.sym} 161700 -39210 0 0 {name=p160480 lab=_68426_/X }
C {devices/lab_pin.sym} 161700 -39170 0 0 {name=p160481 lab=_68428_/X }
C {devices/lab_pin.sym} 161700 -39130 0 0 {name=p160482 lab=_68429_/X }
C {devices/lab_pin.sym} 161860 -39170 0 1 {name=p160483 lab=_68430_/X }
C {sky130_stdcells/a21o_4.sym} 161780 -39170 0 0 {name=X_68430_ }
C {devices/lab_pin.sym} 161740 -39030 0 0 {name=p160484 lab=_46667_/A }
C {devices/lab_pin.sym} 161820 -39030 0 1 {name=p160485 lab=_46830_/C }
C {sky130_stdcells/buf_2.sym} 161780 -39030 0 0 {name=X_46808_ }
C {devices/lab_pin.sym} 161740 -38910 0 0 {name=p160486 lab=_64851_/A }
C {devices/lab_pin.sym} 161820 -38910 0 1 {name=p160487 lab=_65642_/X }
C {sky130_stdcells/buf_2.sym} 161780 -38910 0 0 {name=X_65642_ }
C {devices/lab_pin.sym} 161720 -38800 0 0 {name=p160488 lab=_77628_/A }
C {devices/lab_pin.sym} 161720 -38760 0 0 {name=p160489 lab=_82204_/D }
C {devices/lab_pin.sym} 161840 -38780 0 1 {name=p160490 lab=_81916_/D }
C {sky130_stdcells/xor2_4.sym} 161780 -38780 0 0 {name=X_77628_ }
C {devices/lab_pin.sym} 161700 -38670 0 0 {name=p160491 lab=_62849_/X }
C {devices/lab_pin.sym} 161700 -38630 0 0 {name=p160492 lab=_62838_/X }
C {devices/lab_pin.sym} 161700 -38590 0 0 {name=p160493 lab=_62853_/Y }
C {devices/lab_pin.sym} 161860 -38630 0 1 {name=p160494 lab=_62854_/Y }
C {sky130_stdcells/a21oi_4.sym} 161780 -38630 0 0 {name=X_62854_ }
C {devices/lab_pin.sym} 161740 -38490 0 0 {name=p160495 lab=_47788_/A }
C {devices/lab_pin.sym} 161820 -38490 0 1 {name=p160496 lab=_53246_/B }
C {sky130_stdcells/buf_2.sym} 161780 -38490 0 0 {name=X_47788_ }
C {devices/lab_pin.sym} 161720 -38400 0 0 {name=p160497 lab=_61823_/A }
C {devices/lab_pin.sym} 161720 -38360 0 0 {name=p160498 lab=_61823_/B }
C {devices/lab_pin.sym} 161720 -38320 0 0 {name=p160499 lab=_63424_/B }
C {devices/lab_pin.sym} 161720 -38280 0 0 {name=p160500 lab=_61788_/X }
C {devices/lab_pin.sym} 161840 -38340 0 1 {name=p160501 lab=_61805_/X }
C {sky130_stdcells/and4_4.sym} 161780 -38340 0 0 {name=X_61805_ }
C {devices/lab_pin.sym} 161700 -38210 0 0 {name=p160502 lab=_86371_/Q }
C {devices/lab_pin.sym} 161700 -38170 0 0 {name=p160503 lab=_49524_/X }
C {devices/lab_pin.sym} 161700 -38130 0 0 {name=p160504 lab=_49526_/Y }
C {devices/lab_pin.sym} 161860 -38170 0 1 {name=p160505 lab=_49527_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -38170 0 0 {name=X_49527_ }
C {devices/lab_pin.sym} 161740 -38030 0 0 {name=p160506 lab=clkbuf_4_8_1_CLK/X }
C {devices/lab_pin.sym} 161820 -38030 0 1 {name=p160507 lab=clkbuf_6_33_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 161780 -38030 0 0 {name=Xclkbuf_5_16_0_CLK }
C {devices/lab_pin.sym} 161740 -37910 0 0 {name=p160508 lab=_68361_/A }
C {devices/lab_pin.sym} 161820 -37910 0 1 {name=p160509 lab=_68361_/Y }
C {sky130_stdcells/inv_2.sym} 161780 -37910 0 0 {name=X_68361_ }
C {devices/lab_pin.sym} 161740 -37790 0 0 {name=p160510 lab=_83676_/Q }
C {devices/lab_pin.sym} 161820 -37790 0 1 {name=p160511 lab=_52645_/B }
C {sky130_stdcells/inv_2.sym} 161780 -37790 0 0 {name=X_46739_ }
C {devices/lab_pin.sym} 161720 -37690 0 0 {name=p160512 lab=_65559_/A }
C {devices/lab_pin.sym} 161720 -37650 0 0 {name=p160513 lab=_65559_/B }
C {devices/lab_pin.sym} 161720 -37610 0 0 {name=p160514 lab=_84192_/Q }
C {devices/lab_pin.sym} 161840 -37650 0 1 {name=p160515 lab=_65573_/X }
C {sky130_stdcells/and3_4.sym} 161780 -37650 0 0 {name=X_65573_ }
C {devices/lab_pin.sym} 161720 -37520 0 0 {name=p160516 lab=_77559_/A }
C {devices/lab_pin.sym} 161720 -37480 0 0 {name=p160517 lab=_77559_/B }
C {devices/lab_pin.sym} 161840 -37500 0 1 {name=p160518 lab=_77559_/X }
C {sky130_stdcells/and2_4.sym} 161780 -37500 0 0 {name=X_77559_ }
C {devices/lab_pin.sym} 161720 -37390 0 0 {name=p160519 lab=_62773_/X }
C {devices/lab_pin.sym} 161720 -37350 0 0 {name=p160520 lab=_62762_/B }
C {devices/lab_pin.sym} 161720 -37310 0 0 {name=p160521 lab=_61909_/X }
C {devices/lab_pin.sym} 161840 -37350 0 1 {name=p160522 lab=_62785_/Y }
C {sky130_stdcells/nand3_4.sym} 161780 -37350 0 0 {name=X_62785_ }
C {devices/lab_pin.sym} 161740 -37210 0 0 {name=p160523 lab=_64706_/A }
C {devices/lab_pin.sym} 161820 -37210 0 1 {name=p160524 lab=_67312_/X }
C {sky130_stdcells/buf_2.sym} 161780 -37210 0 0 {name=X_67312_ }
C {devices/lab_pin.sym} 161720 -37110 0 0 {name=p160525 lab=_64545_/A }
C {devices/lab_pin.sym} 161720 -37070 0 0 {name=p160526 lab=_64524_/B }
C {devices/lab_pin.sym} 161720 -37030 0 0 {name=p160527 lab=_64545_/C }
C {devices/lab_pin.sym} 161840 -37070 0 1 {name=p160528 lab=_64524_/X }
C {sky130_stdcells/and3_4.sym} 161780 -37070 0 0 {name=X_64524_ }
C {devices/lab_pin.sym} 161720 -36940 0 0 {name=p160529 lab=_49454_/A }
C {devices/lab_pin.sym} 161720 -36900 0 0 {name=p160530 lab=_50981_/B }
C {devices/lab_pin.sym} 161840 -36920 0 1 {name=p160531 lab=_49458_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -36920 0 0 {name=X_49458_ }
C {devices/lab_pin.sym} 161740 -36790 0 0 {name=p160532 lab=_61736_/A }
C {devices/lab_pin.sym} 161820 -36790 0 1 {name=p160533 lab=_61782_/A }
C {sky130_stdcells/buf_2.sym} 161780 -36790 0 0 {name=X_61736_ }
C {devices/lab_pin.sym} 161720 -36680 0 0 {name=p160534 lab=_80566_/Y }
C {devices/lab_pin.sym} 161720 -36640 0 0 {name=p160535 lab=_80570_/B }
C {devices/lab_pin.sym} 161840 -36660 0 1 {name=p160536 lab=_80570_/Y }
C {sky130_stdcells/xnor2_4.sym} 161780 -36660 0 0 {name=X_80570_ }
C {devices/lab_pin.sym} 161700 -36560 0 0 {name=p160537 lab=_68254_/X }
C {devices/lab_pin.sym} 161700 -36520 0 0 {name=p160538 lab=_67792_/Y }
C {devices/lab_pin.sym} 161700 -36480 0 0 {name=p160539 lab=_68287_/X }
C {devices/lab_pin.sym} 161700 -36440 0 0 {name=p160540 lab=_68291_/Y }
C {devices/lab_pin.sym} 161860 -36500 0 1 {name=p160541 lab=_68292_/X }
C {sky130_stdcells/a211o_4.sym} 161780 -36500 0 0 {name=X_68292_ }
C {devices/lab_pin.sym} 161700 -36370 0 0 {name=p160542 lab=_48402_/Y }
C {devices/lab_pin.sym} 161700 -36330 0 0 {name=p160543 lab=_48403_/X }
C {devices/lab_pin.sym} 161700 -36290 0 0 {name=p160544 lab=_48408_/Y }
C {devices/lab_pin.sym} 161860 -36330 0 1 {name=p160545 lab=_86525_/D }
C {sky130_stdcells/a21boi_4.sym} 161780 -36330 0 0 {name=X_48409_ }
C {devices/lab_pin.sym} 161700 -36210 0 0 {name=p160546 lab=_67238_/X }
C {devices/lab_pin.sym} 161700 -36170 0 0 {name=p160547 lab=_67242_/X }
C {devices/lab_pin.sym} 161700 -36130 0 0 {name=p160548 lab=_67147_/X }
C {devices/lab_pin.sym} 161860 -36170 0 1 {name=p160549 lab=_67247_/A }
C {sky130_stdcells/a21o_4.sym} 161780 -36170 0 0 {name=X_67243_ }
C {devices/lab_pin.sym} 161720 -36040 0 0 {name=p160550 lab=_84791_/Q }
C {devices/lab_pin.sym} 161720 -36000 0 0 {name=p160551 lab=_84111_/Q }
C {devices/lab_pin.sym} 161840 -36020 0 1 {name=p160552 lab=_79229_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -36020 0 0 {name=X_79229_ }
C {devices/lab_pin.sym} 161740 -35890 0 0 {name=p160553 lab=_64263_/A }
C {devices/lab_pin.sym} 161820 -35890 0 1 {name=p160554 lab=_64455_/X }
C {sky130_stdcells/buf_2.sym} 161780 -35890 0 0 {name=X_64455_ }
C {devices/lab_pin.sym} 161740 -35770 0 0 {name=p160555 lab=_49205_/A }
C {devices/lab_pin.sym} 161820 -35770 0 1 {name=p160556 lab=_49410_/A }
C {sky130_stdcells/buf_2.sym} 161780 -35770 0 0 {name=X_49389_ }
C {devices/lab_pin.sym} 161740 -35650 0 0 {name=p160557 lab=_61380_/A }
C {devices/lab_pin.sym} 161820 -35650 0 1 {name=p160558 lab=_72563_/B }
C {sky130_stdcells/buf_2.sym} 161780 -35650 0 0 {name=X_61667_ }
C {devices/lab_pin.sym} 161740 -35530 0 0 {name=p160559 lab=_51147_/A }
C {devices/lab_pin.sym} 161820 -35530 0 1 {name=p160560 lab=_51420_/X }
C {sky130_stdcells/buf_2.sym} 161780 -35530 0 0 {name=X_51420_ }
C {devices/lab_pin.sym} 161740 -35410 0 0 {name=p160561 lab=_63468_/A }
C {devices/lab_pin.sym} 161820 -35410 0 1 {name=p160562 lab=_63456_/B }
C {sky130_stdcells/buf_2.sym} 161780 -35410 0 0 {name=X_63406_ }
C {devices/lab_pin.sym} 161690 -35290 0 0 {name=p160563 lab=_82531_/CLK }
C {devices/lab_pin.sym} 161690 -35270 0 0 {name=p160564 lab=_82272_/Q }
C {devices/lab_pin.sym} 161870 -35290 0 1 {name=p160565 lab=_82240_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -35280 0 0 {name=X_82240_ }
C {devices/lab_pin.sym} 161720 -35170 0 0 {name=p160566 lab=_59660_/C }
C {devices/lab_pin.sym} 161720 -35130 0 0 {name=p160567 lab=_61075_/B }
C {devices/lab_pin.sym} 161720 -35090 0 0 {name=p160568 lab=_59660_/D }
C {devices/lab_pin.sym} 161840 -35130 0 1 {name=p160569 lab=_60619_/A }
C {sky130_stdcells/nand3_4.sym} 161780 -35130 0 0 {name=X_60618_ }
C {devices/lab_pin.sym} 161700 -35020 0 0 {name=p160570 lab=_87110_/Q }
C {devices/lab_pin.sym} 161700 -34980 0 0 {name=p160571 lab=_67074_/X }
C {devices/lab_pin.sym} 161700 -34940 0 0 {name=p160572 lab=_67075_/X }
C {devices/lab_pin.sym} 161700 -34900 0 0 {name=p160573 lab=_67173_/X }
C {devices/lab_pin.sym} 161860 -34960 0 1 {name=p160574 lab=_67174_/X }
C {sky130_stdcells/a211o_4.sym} 161780 -34960 0 0 {name=X_67174_ }
C {devices/lab_pin.sym} 161740 -34810 0 0 {name=p160575 lab=_64386_/A }
C {devices/lab_pin.sym} 161820 -34810 0 1 {name=p160576 lab=_64386_/X }
C {sky130_stdcells/buf_2.sym} 161780 -34810 0 0 {name=X_64386_ }
C {devices/lab_pin.sym} 161740 -34690 0 0 {name=p160577 lab=_61686_/A }
C {devices/lab_pin.sym} 161820 -34690 0 1 {name=p160578 lab=_61598_/X }
C {sky130_stdcells/buf_2.sym} 161780 -34690 0 0 {name=X_61598_ }
C {devices/lab_pin.sym} 161740 -34570 0 0 {name=p160579 lab=_65484_/A }
C {devices/lab_pin.sym} 161820 -34570 0 1 {name=p160580 lab=_66125_/X }
C {sky130_stdcells/buf_2.sym} 161780 -34570 0 0 {name=X_66125_ }
C {devices/lab_pin.sym} 161700 -34470 0 0 {name=p160581 lab=_86027_/Q }
C {devices/lab_pin.sym} 161700 -34430 0 0 {name=p160582 lab=_51332_/X }
C {devices/lab_pin.sym} 161700 -34390 0 0 {name=p160583 lab=_51350_/Y }
C {devices/lab_pin.sym} 161860 -34430 0 1 {name=p160584 lab=_51351_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -34430 0 0 {name=X_51351_ }
C {devices/lab_pin.sym} 161700 -34310 0 0 {name=p160585 lab=_79184_/A }
C {devices/lab_pin.sym} 161700 -34270 0 0 {name=p160586 lab=_63310_/X }
C {devices/lab_pin.sym} 161700 -34230 0 0 {name=p160587 lab=_63336_/X }
C {devices/lab_pin.sym} 161860 -34270 0 1 {name=p160588 lab=_63337_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -34270 0 0 {name=X_63337_ }
C {devices/lab_pin.sym} 161690 -34130 0 0 {name=p160589 lab=_84111_/CLK }
C {devices/lab_pin.sym} 161690 -34110 0 0 {name=p160590 lab=_84163_/Q }
C {devices/lab_pin.sym} 161870 -34130 0 1 {name=p160591 lab=_82171_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -34120 0 0 {name=X_82171_ }
C {devices/lab_pin.sym} 161740 -33990 0 0 {name=p160592 lab=_60583_/A }
C {devices/lab_pin.sym} 161820 -33990 0 1 {name=p160593 lab=_60570_/C }
C {sky130_stdcells/buf_2.sym} 161780 -33990 0 0 {name=X_60549_ }
C {devices/lab_pin.sym} 161720 -33880 0 0 {name=p160594 lab=_50285_/A }
C {devices/lab_pin.sym} 161720 -33840 0 0 {name=p160595 lab=_50302_/B }
C {devices/lab_pin.sym} 161840 -33860 0 1 {name=p160596 lab=_50302_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -33860 0 0 {name=X_50302_ }
C {devices/lab_pin.sym} 161690 -33730 0 0 {name=p160597 lab=_81195_/CLK }
C {devices/lab_pin.sym} 161690 -33710 0 0 {name=p160598 lab=_81122_/D }
C {devices/lab_pin.sym} 161870 -33730 0 1 {name=p160599 lab=_40760_/A }
C {sky130_stdcells/dfxtp_4.sym} 161780 -33720 0 0 {name=X_81122_ }
C {devices/lab_pin.sym} 161700 -33610 0 0 {name=p160600 lab=_85511_/Q }
C {devices/lab_pin.sym} 161700 -33570 0 0 {name=p160601 lab=_54067_/X }
C {devices/lab_pin.sym} 161700 -33530 0 0 {name=p160602 lab=_54069_/Y }
C {devices/lab_pin.sym} 161860 -33570 0 1 {name=p160603 lab=_54070_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -33570 0 0 {name=X_54070_ }
C {devices/lab_pin.sym} 161700 -33460 0 0 {name=p160604 lab=_66053_/X }
C {devices/lab_pin.sym} 161700 -33420 0 0 {name=p160605 lab=_85623_/Q }
C {devices/lab_pin.sym} 161700 -33380 0 0 {name=p160606 lab=_65976_/X }
C {devices/lab_pin.sym} 161700 -33340 0 0 {name=p160607 lab=_66055_/X }
C {devices/lab_pin.sym} 161860 -33400 0 1 {name=p160608 lab=_66056_/X }
C {sky130_stdcells/a211o_4.sym} 161780 -33400 0 0 {name=X_66056_ }
C {devices/lab_pin.sym} 161740 -33250 0 0 {name=p160609 lab=_51282_/A }
C {devices/lab_pin.sym} 161820 -33250 0 1 {name=p160610 lab=_51298_/A }
C {sky130_stdcells/buf_2.sym} 161780 -33250 0 0 {name=X_51282_ }
C {devices/lab_pin.sym} 161700 -33150 0 0 {name=p160611 lab=_63266_/Y }
C {devices/lab_pin.sym} 161700 -33110 0 0 {name=p160612 lab=_63267_/X }
C {devices/lab_pin.sym} 161700 -33070 0 0 {name=p160613 lab=_63231_/X }
C {devices/lab_pin.sym} 161860 -33110 0 1 {name=p160614 lab=_63268_/Y }
C {sky130_stdcells/a21oi_4.sym} 161780 -33110 0 0 {name=X_63268_ }
C {devices/lab_pin.sym} 161720 -32980 0 0 {name=p160615 lab=_53025_/A }
C {devices/lab_pin.sym} 161720 -32940 0 0 {name=p160616 lab=_53021_/B }
C {devices/lab_pin.sym} 161840 -32960 0 1 {name=p160617 lab=_53021_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -32960 0 0 {name=X_53021_ }
C {devices/lab_pin.sym} 161700 -32860 0 0 {name=p160618 lab=_64934_/X }
C {devices/lab_pin.sym} 161700 -32820 0 0 {name=p160619 lab=_86738_/Q }
C {devices/lab_pin.sym} 161700 -32780 0 0 {name=p160620 lab=_64991_/X }
C {devices/lab_pin.sym} 161700 -32740 0 0 {name=p160621 lab=_65006_/X }
C {devices/lab_pin.sym} 161860 -32800 0 1 {name=p160622 lab=_65007_/X }
C {sky130_stdcells/a211o_4.sym} 161780 -32800 0 0 {name=X_65007_ }
C {devices/lab_pin.sym} 161700 -32670 0 0 {name=p160623 lab=_86239_/Q }
C {devices/lab_pin.sym} 161700 -32630 0 0 {name=p160624 lab=_50220_/X }
C {devices/lab_pin.sym} 161700 -32590 0 0 {name=p160625 lab=_50232_/Y }
C {devices/lab_pin.sym} 161860 -32630 0 1 {name=p160626 lab=_50233_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -32630 0 0 {name=X_50233_ }
C {devices/lab_pin.sym} 161740 -32490 0 0 {name=p160627 lab=_62618_/C }
C {devices/lab_pin.sym} 161820 -32490 0 1 {name=p160628 lab=_62219_/X }
C {sky130_stdcells/buf_2.sym} 161780 -32490 0 0 {name=X_62219_ }
C {devices/lab_pin.sym} 161690 -32370 0 0 {name=p160629 lab=_86089_/CLK }
C {devices/lab_pin.sym} 161690 -32350 0 0 {name=p160630 lab=_85930_/D }
C {devices/lab_pin.sym} 161870 -32370 0 1 {name=p160631 lab=_85930_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -32360 0 0 {name=X_85930_ }
C {devices/lab_pin.sym} 161690 -32230 0 0 {name=p160632 lab=_83749_/CLK }
C {devices/lab_pin.sym} 161690 -32210 0 0 {name=p160633 lab=_75486_/X }
C {devices/lab_pin.sym} 161870 -32230 0 1 {name=p160634 lab=_81053_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -32220 0 0 {name=X_81053_ }
C {devices/lab_pin.sym} 161700 -32110 0 0 {name=p160635 lab=_63197_/Y }
C {devices/lab_pin.sym} 161700 -32070 0 0 {name=p160636 lab=_63198_/X }
C {devices/lab_pin.sym} 161700 -32030 0 0 {name=p160637 lab=_63172_/X }
C {devices/lab_pin.sym} 161860 -32070 0 1 {name=p160638 lab=_63199_/Y }
C {sky130_stdcells/a21oi_4.sym} 161780 -32070 0 0 {name=X_63199_ }
C {devices/lab_pin.sym} 161700 -31950 0 0 {name=p160639 lab=_58048_/Y }
C {devices/lab_pin.sym} 161700 -31910 0 0 {name=p160640 lab=_65802_/C }
C {devices/lab_pin.sym} 161700 -31870 0 0 {name=p160641 lab=_80003_/Y }
C {devices/lab_pin.sym} 161860 -31910 0 1 {name=p160642 lab=_80004_/X }
C {sky130_stdcells/o21a_4.sym} 161780 -31910 0 0 {name=X_80004_ }
C {devices/lab_pin.sym} 161740 -31770 0 0 {name=p160643 lab=_70012_/A }
C {devices/lab_pin.sym} 161820 -31770 0 1 {name=p160644 lab=_69815_/X }
C {sky130_stdcells/buf_2.sym} 161780 -31770 0 0 {name=X_69815_ }
C {devices/lab_pin.sym} 161720 -31660 0 0 {name=p160645 lab=_50169_/A }
C {devices/lab_pin.sym} 161720 -31620 0 0 {name=p160646 lab=_50674_/B }
C {devices/lab_pin.sym} 161840 -31640 0 1 {name=p160647 lab=_50164_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -31640 0 0 {name=X_50164_ }
C {devices/lab_pin.sym} 161690 -31510 0 0 {name=p160648 lab=_86506_/CLK }
C {devices/lab_pin.sym} 161690 -31490 0 0 {name=p160649 lab=_85861_/D }
C {devices/lab_pin.sym} 161870 -31510 0 1 {name=p160650 lab=_85861_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -31500 0 0 {name=X_85861_ }
C {devices/lab_pin.sym} 161690 -31370 0 0 {name=p160651 lab=_87070_/CLK }
C {devices/lab_pin.sym} 161690 -31350 0 0 {name=p160652 lab=_43035_/Y }
C {devices/lab_pin.sym} 161870 -31370 0 1 {name=p160653 lab=_43032_/A }
C {sky130_stdcells/dfxtp_4.sym} 161780 -31360 0 0 {name=X_87600_ }
C {devices/lab_pin.sym} 161690 -31230 0 0 {name=p160654 lab=_85955_/CLK }
C {devices/lab_pin.sym} 161690 -31210 0 0 {name=p160655 lab=_84812_/D }
C {devices/lab_pin.sym} 161870 -31230 0 1 {name=p160656 lab=_58623_/A }
C {sky130_stdcells/dfxtp_4.sym} 161780 -31220 0 0 {name=X_84812_ }
C {devices/lab_pin.sym} 161740 -31090 0 0 {name=p160657 lab=_57759_/X }
C {devices/lab_pin.sym} 161820 -31090 0 1 {name=p160658 lab=_57760_/X }
C {sky130_stdcells/buf_2.sym} 161780 -31090 0 0 {name=X_57760_ }
C {devices/lab_pin.sym} 161740 -30970 0 0 {name=p160659 lab=_69746_/A }
C {devices/lab_pin.sym} 161820 -30970 0 1 {name=p160660 lab=_69746_/X }
C {sky130_stdcells/buf_2.sym} 161780 -30970 0 0 {name=X_69746_ }
C {devices/lab_pin.sym} 161720 -30860 0 0 {name=p160661 lab=_50103_/A }
C {devices/lab_pin.sym} 161720 -30820 0 0 {name=p160662 lab=_48963_/X }
C {devices/lab_pin.sym} 161840 -30840 0 1 {name=p160663 lab=_50095_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -30840 0 0 {name=X_50095_ }
C {devices/lab_pin.sym} 161740 -30710 0 0 {name=p160664 lab=_49793_/A }
C {devices/lab_pin.sym} 161820 -30710 0 1 {name=p160665 lab=_54973_/A }
C {sky130_stdcells/buf_2.sym} 161780 -30710 0 0 {name=X_54972_ }
C {devices/lab_pin.sym} 161720 -30600 0 0 {name=p160666 lab=_66952_/X }
C {devices/lab_pin.sym} 161720 -30560 0 0 {name=p160667 lab=_66957_/X }
C {devices/lab_pin.sym} 161840 -30580 0 1 {name=p160668 lab=_66958_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -30580 0 0 {name=X_66958_ }
C {devices/lab_pin.sym} 161690 -30450 0 0 {name=p160669 lab=_83685_/CLK }
C {devices/lab_pin.sym} 161690 -30430 0 0 {name=p160670 lab=_85792_/D }
C {devices/lab_pin.sym} 161870 -30450 0 1 {name=p160671 lab=_85792_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -30440 0 0 {name=X_85792_ }
C {devices/lab_pin.sym} 161720 -30320 0 0 {name=p160672 lab=_56651_/Y }
C {devices/lab_pin.sym} 161720 -30280 0 0 {name=p160673 lab=_56721_/D }
C {devices/lab_pin.sym} 161840 -30300 0 1 {name=p160674 lab=_56775_/A }
C {sky130_stdcells/nor2_4.sym} 161780 -30300 0 0 {name=X_56711_ }
C {devices/lab_pin.sym} 161690 -30170 0 0 {name=p160675 lab=_87782_/CLK }
C {devices/lab_pin.sym} 161690 -30150 0 0 {name=p160676 lab=_87531_/D }
C {devices/lab_pin.sym} 161870 -30170 0 1 {name=p160677 lab=_87531_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -30160 0 0 {name=X_87531_ }
C {devices/lab_pin.sym} 161720 -30040 0 0 {name=p160678 lab=_53951_/A }
C {devices/lab_pin.sym} 161720 -30000 0 0 {name=p160679 lab=_49166_/Y }
C {devices/lab_pin.sym} 161840 -30020 0 1 {name=p160680 lab=_53923_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -30020 0 0 {name=X_53923_ }
C {devices/lab_pin.sym} 161700 -29920 0 0 {name=p160681 lab=_65859_/X }
C {devices/lab_pin.sym} 161700 -29880 0 0 {name=p160682 lab=_85633_/Q }
C {devices/lab_pin.sym} 161700 -29840 0 0 {name=p160683 lab=_65860_/X }
C {devices/lab_pin.sym} 161700 -29800 0 0 {name=p160684 lab=_65908_/X }
C {devices/lab_pin.sym} 161860 -29860 0 1 {name=p160685 lab=_65909_/X }
C {sky130_stdcells/a211o_4.sym} 161780 -29860 0 0 {name=X_65909_ }
C {devices/lab_pin.sym} 161690 -29710 0 0 {name=p160686 lab=_83491_/CLK }
C {devices/lab_pin.sym} 161690 -29690 0 0 {name=p160687 lab=_59400_/X }
C {devices/lab_pin.sym} 161870 -29710 0 1 {name=p160688 lab=_84743_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -29700 0 0 {name=X_84743_ }
C {devices/lab_pin.sym} 161740 -29570 0 0 {name=p160689 lab=_57896_/A }
C {devices/lab_pin.sym} 161820 -29570 0 1 {name=p160690 lab=_57691_/X }
C {sky130_stdcells/buf_2.sym} 161780 -29570 0 0 {name=X_57691_ }
C {devices/lab_pin.sym} 161690 -29450 0 0 {name=p160691 lab=_81954_/CLK }
C {devices/lab_pin.sym} 161690 -29430 0 0 {name=p160692 lab=_83883_/Q }
C {devices/lab_pin.sym} 161870 -29450 0 1 {name=p160693 lab=_77883_/B }
C {sky130_stdcells/dfxtp_4.sym} 161780 -29440 0 0 {name=X_81955_ }
C {devices/lab_pin.sym} 161700 -29340 0 0 {name=p160694 lab=_42002_/A }
C {devices/lab_pin.sym} 161700 -29300 0 0 {name=p160695 lab=_69607_/X }
C {devices/lab_pin.sym} 161700 -29260 0 0 {name=p160696 lab=_68617_/X }
C {devices/lab_pin.sym} 161700 -29220 0 0 {name=p160697 lab=_69676_/Y }
C {devices/lab_pin.sym} 161860 -29280 0 1 {name=p160698 lab=_69677_/X }
C {sky130_stdcells/a211o_4.sym} 161780 -29280 0 0 {name=X_69677_ }
C {devices/lab_pin.sym} 161720 -29140 0 0 {name=p160699 lab=_66840_/X }
C {devices/lab_pin.sym} 161720 -29100 0 0 {name=p160700 lab=_86825_/Q }
C {devices/lab_pin.sym} 161840 -29120 0 1 {name=p160701 lab=_66889_/X }
C {sky130_stdcells/and2_4.sym} 161780 -29120 0 0 {name=X_66889_ }
C {devices/lab_pin.sym} 161740 -28990 0 0 {name=p160702 lab=_59430_/A }
C {devices/lab_pin.sym} 161820 -28990 0 1 {name=p160703 lab=_59430_/Y }
C {sky130_stdcells/inv_2.sym} 161780 -28990 0 0 {name=X_59430_ }
C {devices/lab_pin.sym} 161720 -28880 0 0 {name=p160704 lab=_55646_/X }
C {devices/lab_pin.sym} 161720 -28840 0 0 {name=p160705 lab=_56650_/B }
C {devices/lab_pin.sym} 161840 -28860 0 1 {name=p160706 lab=_56642_/Y }
C {sky130_stdcells/xnor2_4.sym} 161780 -28860 0 0 {name=X_56642_ }
C {devices/lab_pin.sym} 161690 -28730 0 0 {name=p160707 lab=_84087_/CLK }
C {devices/lab_pin.sym} 161690 -28710 0 0 {name=p160708 lab=_80906_/D }
C {devices/lab_pin.sym} 161870 -28730 0 1 {name=p160709 lab=_80906_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -28720 0 0 {name=X_80906_ }
C {devices/lab_pin.sym} 161700 -28620 0 0 {name=p160710 lab=_87497_/Q }
C {devices/lab_pin.sym} 161700 -28580 0 0 {name=p160711 lab=_68626_/X }
C {devices/lab_pin.sym} 161700 -28540 0 0 {name=p160712 lab=_68601_/X }
C {devices/lab_pin.sym} 161700 -28500 0 0 {name=p160713 lab=_68627_/X }
C {devices/lab_pin.sym} 161860 -28560 0 1 {name=p160714 lab=_68628_/X }
C {sky130_stdcells/a211o_4.sym} 161780 -28560 0 0 {name=X_68628_ }
C {devices/lab_pin.sym} 161690 -28410 0 0 {name=p160715 lab=_87149_/CLK }
C {devices/lab_pin.sym} 161690 -28390 0 0 {name=p160716 lab=_87462_/D }
C {devices/lab_pin.sym} 161870 -28410 0 1 {name=p160717 lab=_87462_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -28400 0 0 {name=X_87462_ }
C {devices/lab_pin.sym} 161720 -28280 0 0 {name=p160718 lab=_53844_/A }
C {devices/lab_pin.sym} 161720 -28240 0 0 {name=p160719 lab=_53854_/B }
C {devices/lab_pin.sym} 161840 -28260 0 1 {name=p160720 lab=_53854_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -28260 0 0 {name=X_53854_ }
C {devices/lab_pin.sym} 161690 -28130 0 0 {name=p160721 lab=_84671_/CLK }
C {devices/lab_pin.sym} 161690 -28110 0 0 {name=p160722 lab=_84674_/D }
C {devices/lab_pin.sym} 161870 -28130 0 1 {name=p160723 lab=_60021_/C }
C {sky130_stdcells/dfxtp_4.sym} 161780 -28120 0 0 {name=X_84674_ }
C {devices/lab_pin.sym} 161690 -27990 0 0 {name=p160724 lab=_82531_/CLK }
C {devices/lab_pin.sym} 161690 -27970 0 0 {name=p160725 lab=_81886_/D }
C {devices/lab_pin.sym} 161870 -27990 0 1 {name=p160726 lab=_81886_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -27980 0 0 {name=X_81886_ }
C {devices/lab_pin.sym} 161690 -27850 0 0 {name=p160727 lab=_85516_/CLK }
C {devices/lab_pin.sym} 161690 -27830 0 0 {name=p160728 lab=_86413_/D }
C {devices/lab_pin.sym} 161870 -27850 0 1 {name=p160729 lab=_65124_/B }
C {sky130_stdcells/dfxtp_4.sym} 161780 -27840 0 0 {name=X_86413_ }
C {devices/lab_pin.sym} 161720 -27740 0 0 {name=p160730 lab=_52784_/X }
C {devices/lab_pin.sym} 161720 -27700 0 0 {name=p160731 lab=_52818_/B }
C {devices/lab_pin.sym} 161720 -27660 0 0 {name=p160732 lab=_52789_/X }
C {devices/lab_pin.sym} 161720 -27620 0 0 {name=p160733 lab=_52805_/D }
C {devices/lab_pin.sym} 161840 -27680 0 1 {name=p160734 lab=_52805_/X }
C {sky130_stdcells/and4_4.sym} 161780 -27680 0 0 {name=X_52805_ }
C {devices/lab_pin.sym} 161690 -27530 0 0 {name=p160735 lab=_83623_/CLK }
C {devices/lab_pin.sym} 161690 -27510 0 0 {name=p160736 lab=_71051_/Y }
C {devices/lab_pin.sym} 161870 -27530 0 1 {name=p160737 lab=_83625_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -27520 0 0 {name=X_83625_ }
C {devices/lab_pin.sym} 161720 -27400 0 0 {name=p160738 lab=_59361_/A }
C {devices/lab_pin.sym} 161720 -27360 0 0 {name=p160739 lab=_59226_/B }
C {devices/lab_pin.sym} 161840 -27380 0 1 {name=p160740 lab=_59361_/Y }
C {sky130_stdcells/nor2_4.sym} 161780 -27380 0 0 {name=X_59361_ }
C {devices/lab_pin.sym} 161700 -27280 0 0 {name=p160741 lab=_56568_/X }
C {devices/lab_pin.sym} 161700 -27240 0 0 {name=p160742 lab=_56571_/X }
C {devices/lab_pin.sym} 161700 -27200 0 0 {name=p160743 lab=_85152_/Q }
C {devices/lab_pin.sym} 161700 -27160 0 0 {name=p160744 lab=_56572_/X }
C {devices/lab_pin.sym} 161860 -27220 0 1 {name=p160745 lab=_56573_/X }
C {sky130_stdcells/a2bb2o_4.sym} 161780 -27220 0 0 {name=X_56573_ }
C {devices/lab_pin.sym} 161690 -27070 0 0 {name=p160746 lab=_81125_/CLK }
C {devices/lab_pin.sym} 161690 -27050 0 0 {name=p160747 lab=_80837_/D }
C {devices/lab_pin.sym} 161870 -27070 0 1 {name=p160748 lab=_74870_/B }
C {sky130_stdcells/dfxtp_4.sym} 161780 -27060 0 0 {name=X_80837_ }
C {devices/lab_pin.sym} 161700 -26950 0 0 {name=p160749 lab=_68554_/X }
C {devices/lab_pin.sym} 161700 -26910 0 0 {name=p160750 lab=_68557_/X }
C {devices/lab_pin.sym} 161700 -26870 0 0 {name=p160751 lab=_68558_/X }
C {devices/lab_pin.sym} 161860 -26910 0 1 {name=p160752 lab=_68559_/X }
C {sky130_stdcells/a21o_4.sym} 161780 -26910 0 0 {name=X_68559_ }
C {devices/lab_pin.sym} 161690 -26770 0 0 {name=p160753 lab=_87646_/CLK }
C {devices/lab_pin.sym} 161690 -26750 0 0 {name=p160754 lab=_43493_/X }
C {devices/lab_pin.sym} 161870 -26770 0 1 {name=p160755 lab=_87393_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -26760 0 0 {name=X_87393_ }
C {devices/lab_pin.sym} 161740 -26630 0 0 {name=p160756 lab=_53755_/A }
C {devices/lab_pin.sym} 161820 -26630 0 1 {name=p160757 lab=_53786_/A }
C {sky130_stdcells/buf_2.sym} 161780 -26630 0 0 {name=X_53785_ }
C {devices/lab_pin.sym} 161700 -26530 0 0 {name=p160758 lab=_50995_/Y }
C {devices/lab_pin.sym} 161700 -26490 0 0 {name=p160759 lab=_50983_/X }
C {devices/lab_pin.sym} 161700 -26450 0 0 {name=p160760 lab=_50996_/X }
C {devices/lab_pin.sym} 161860 -26490 0 1 {name=p160761 lab=_86093_/D }
C {sky130_stdcells/a21oi_4.sym} 161780 -26490 0 0 {name=X_50997_ }
C {devices/lab_pin.sym} 161740 -26350 0 0 {name=p160762 lab=_58425_/A }
C {devices/lab_pin.sym} 161820 -26350 0 1 {name=p160763 lab=_58408_/A }
C {sky130_stdcells/buf_2.sym} 161780 -26350 0 0 {name=X_58312_ }
C {devices/lab_pin.sym} 161720 -26240 0 0 {name=p160764 lab=_55524_/A }
C {devices/lab_pin.sym} 161720 -26200 0 0 {name=p160765 lab=_45551_/Y }
C {devices/lab_pin.sym} 161840 -26220 0 1 {name=p160766 lab=_55524_/Y }
C {sky130_stdcells/nor2_4.sym} 161780 -26220 0 0 {name=X_55524_ }
C {devices/lab_pin.sym} 161690 -26090 0 0 {name=p160767 lab=_82381_/CLK }
C {devices/lab_pin.sym} 161690 -26070 0 0 {name=p160768 lab=_49674_/Y }
C {devices/lab_pin.sym} 161870 -26090 0 1 {name=p160769 lab=_86344_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -26080 0 0 {name=X_86344_ }
C {devices/lab_pin.sym} 161700 -25980 0 0 {name=p160770 lab=_40749_/X }
C {devices/lab_pin.sym} 161700 -25940 0 0 {name=p160771 lab=_40719_/X }
C {devices/lab_pin.sym} 161700 -25900 0 0 {name=p160772 lab=_88342_/Q }
C {devices/lab_pin.sym} 161700 -25860 0 0 {name=p160773 lab=_40720_/X }
C {devices/lab_pin.sym} 161860 -25920 0 1 {name=p160774 lab=_40750_/X }
C {sky130_stdcells/a2bb2o_4.sym} 161780 -25920 0 0 {name=X_40750_ }
C {devices/lab_pin.sym} 161700 -25790 0 0 {name=p160775 lab=_52733_/Y }
C {devices/lab_pin.sym} 161700 -25750 0 0 {name=p160776 lab=_52728_/X }
C {devices/lab_pin.sym} 161700 -25710 0 0 {name=p160777 lab=_52735_/X }
C {devices/lab_pin.sym} 161860 -25750 0 1 {name=p160778 lab=_52736_/Y }
C {sky130_stdcells/a21oi_4.sym} 161780 -25750 0 0 {name=X_52736_ }
C {devices/lab_pin.sym} 161740 -25610 0 0 {name=p160779 lab=_58641_/A }
C {devices/lab_pin.sym} 161820 -25610 0 1 {name=p160780 lab=_59292_/X }
C {sky130_stdcells/buf_2.sym} 161780 -25610 0 0 {name=X_59292_ }
C {devices/lab_pin.sym} 161740 -25490 0 0 {name=p160781 lab=_71570_/A }
C {devices/lab_pin.sym} 161820 -25490 0 1 {name=p160782 lab=_71570_/X }
C {sky130_stdcells/buf_2.sym} 161780 -25490 0 0 {name=X_71570_ }
C {devices/lab_pin.sym} 161690 -25370 0 0 {name=p160783 lab=_83556_/CLK }
C {devices/lab_pin.sym} 161690 -25350 0 0 {name=p160784 lab=_71257_/Y }
C {devices/lab_pin.sym} 161870 -25370 0 1 {name=p160785 lab=_83556_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -25360 0 0 {name=X_83556_ }
C {devices/lab_pin.sym} 161690 -25230 0 0 {name=p160786 lab=_80740_/CLK }
C {devices/lab_pin.sym} 161690 -25210 0 0 {name=p160787 lab=_80768_/D }
C {devices/lab_pin.sym} 161870 -25230 0 1 {name=p160788 lab=_80768_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -25220 0 0 {name=X_80768_ }
C {devices/lab_pin.sym} 161740 -25090 0 0 {name=p160789 lab=_70966_/A }
C {devices/lab_pin.sym} 161820 -25090 0 1 {name=p160790 lab=_70962_/C }
C {sky130_stdcells/buf_2.sym} 161780 -25090 0 0 {name=X_70521_ }
C {devices/lab_pin.sym} 161690 -24970 0 0 {name=p160791 lab=_82498_/CLK }
C {devices/lab_pin.sym} 161690 -24950 0 0 {name=p160792 lab=_82507_/D }
C {devices/lab_pin.sym} 161870 -24970 0 1 {name=p160793 lab=_82507_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -24960 0 0 {name=X_82507_ }
C {devices/lab_pin.sym} 161740 -24830 0 0 {name=p160794 lab=_58510_/A }
C {devices/lab_pin.sym} 161820 -24830 0 1 {name=p160795 lab=_58248_/B }
C {sky130_stdcells/buf_2.sym} 161780 -24830 0 0 {name=X_58243_ }
C {devices/lab_pin.sym} 161720 -24720 0 0 {name=p160796 lab=_55454_/X }
C {devices/lab_pin.sym} 161720 -24680 0 0 {name=p160797 lab=_45595_/Y }
C {devices/lab_pin.sym} 161840 -24700 0 1 {name=p160798 lab=_55455_/Y }
C {sky130_stdcells/nor2_4.sym} 161780 -24700 0 0 {name=X_55455_ }
C {devices/lab_pin.sym} 161690 -24570 0 0 {name=p160799 lab=_85955_/CLK }
C {devices/lab_pin.sym} 161690 -24550 0 0 {name=p160800 lab=_50047_/Y }
C {devices/lab_pin.sym} 161870 -24570 0 1 {name=p160801 lab=_72471_/B }
C {sky130_stdcells/dfxtp_4.sym} 161780 -24560 0 0 {name=X_86275_ }
C {sky130_stdcells/decap_3.sym} 161780 -24400 0 0 {name=XPHY_701 }
C {devices/lab_pin.sym} 161700 -24270 0 0 {name=p160802 lab=_40601_/X }
C {devices/lab_pin.sym} 161700 -24230 0 0 {name=p160803 lab=_81136_/Q }
C {devices/lab_pin.sym} 161700 -24190 0 0 {name=p160804 lab=_40680_/X }
C {devices/lab_pin.sym} 161860 -24230 0 1 {name=p160805 lab=_40682_/A }
C {sky130_stdcells/o21a_4.sym} 161780 -24230 0 0 {name=X_40681_ }
C {devices/lab_pin.sym} 161720 -24100 0 0 {name=p160806 lab=_52657_/X }
C {devices/lab_pin.sym} 161720 -24060 0 0 {name=p160807 lab=_52667_/B }
C {devices/lab_pin.sym} 161840 -24080 0 1 {name=p160808 lab=_52667_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -24080 0 0 {name=X_52667_ }
C {devices/lab_pin.sym} 161690 -23950 0 0 {name=p160809 lab=_83482_/CLK }
C {devices/lab_pin.sym} 161690 -23930 0 0 {name=p160810 lab=_71472_/X }
C {devices/lab_pin.sym} 161870 -23950 0 1 {name=p160811 lab=_83487_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -23940 0 0 {name=X_83487_ }
C {sky130_stdcells/decap_3.sym} 161780 -23780 0 0 {name=XPHY_712 }
C {devices/lab_pin.sym} 161690 -23630 0 0 {name=p160812 lab=_81082_/CLK }
C {devices/lab_pin.sym} 161690 -23610 0 0 {name=p160813 lab=_80699_/D }
C {devices/lab_pin.sym} 161870 -23630 0 1 {name=p160814 lab=_75443_/A }
C {sky130_stdcells/dfxtp_4.sym} 161780 -23620 0 0 {name=X_80699_ }
C {devices/lab_pin.sym} 161690 -23490 0 0 {name=p160815 lab=_87249_/CLK }
C {devices/lab_pin.sym} 161690 -23470 0 0 {name=p160816 lab=_88014_/D }
C {devices/lab_pin.sym} 161870 -23490 0 1 {name=p160817 lab=_88014_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -23480 0 0 {name=X_88014_ }
C {devices/lab_pin.sym} 161700 -23390 0 0 {name=p160818 lab=_42417_/X }
C {devices/lab_pin.sym} 161700 -23350 0 0 {name=p160819 lab=_42410_/X }
C {devices/lab_pin.sym} 161700 -23310 0 0 {name=p160820 lab=_40480_/X }
C {devices/lab_pin.sym} 161700 -23270 0 0 {name=p160821 lab=_87873_/Q }
C {devices/lab_pin.sym} 161700 -23230 0 0 {name=p160822 lab=_42411_/X }
C {devices/lab_pin.sym} 161860 -23310 0 1 {name=p160823 lab=_42421_/A }
C {sky130_stdcells/o32ai_4.sym} 161780 -23310 0 0 {name=X_42420_ }
C {devices/lab_pin.sym} 161720 -23160 0 0 {name=p160824 lab=_54425_/A }
C {devices/lab_pin.sym} 161720 -23120 0 0 {name=p160825 lab=_52713_/B }
C {devices/lab_pin.sym} 161840 -23140 0 1 {name=p160826 lab=_54406_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -23140 0 0 {name=X_54406_ }
C {devices/lab_pin.sym} 161700 -23040 0 0 {name=p160827 lab=_73214_/X }
C {devices/lab_pin.sym} 161700 -23000 0 0 {name=p160828 lab=_83063_/Q }
C {devices/lab_pin.sym} 161700 -22960 0 0 {name=p160829 lab=_73238_/X }
C {devices/lab_pin.sym} 161700 -22920 0 0 {name=p160830 lab=_73239_/X }
C {devices/lab_pin.sym} 161860 -22980 0 1 {name=p160831 lab=_73240_/X }
C {sky130_stdcells/a211o_4.sym} 161780 -22980 0 0 {name=X_73240_ }
C {devices/lab_pin.sym} 161690 -22830 0 0 {name=p160832 lab=_85257_/CLK }
C {devices/lab_pin.sym} 161690 -22810 0 0 {name=p160833 lab=_85226_/D }
C {devices/lab_pin.sym} 161870 -22830 0 1 {name=p160834 lab=_55774_/B }
C {sky130_stdcells/dfxtp_4.sym} 161780 -22820 0 0 {name=X_85226_ }
C {devices/lab_pin.sym} 161700 -22710 0 0 {name=p160835 lab=_85977_/Q }
C {devices/lab_pin.sym} 161700 -22670 0 0 {name=p160836 lab=_51594_/X }
C {devices/lab_pin.sym} 161700 -22630 0 0 {name=p160837 lab=_51617_/Y }
C {devices/lab_pin.sym} 161860 -22670 0 1 {name=p160838 lab=_51618_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -22670 0 0 {name=X_51618_ }
C {devices/lab_pin.sym} 161740 -22530 0 0 {name=p160839 lab=HASH_ADDR[0] }
C {devices/lab_pin.sym} 161820 -22530 0 1 {name=p160840 lab=_70758_/A }
C {sky130_stdcells/buf_2.sym} 161780 -22530 0 0 {name=X_70452_ }
C {devices/lab_pin.sym} 161740 -22410 0 0 {name=p160841 lab=_58273_/A }
C {devices/lab_pin.sym} 161820 -22410 0 1 {name=p160842 lab=_58217_/B }
C {sky130_stdcells/buf_2.sym} 161780 -22410 0 0 {name=X_58174_ }
C {devices/lab_pin.sym} 161690 -22290 0 0 {name=p160843 lab=_82436_/CLK }
C {devices/lab_pin.sym} 161690 -22270 0 0 {name=p160844 lab=_82438_/D }
C {devices/lab_pin.sym} 161870 -22290 0 1 {name=p160845 lab=_82438_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -22280 0 0 {name=X_82438_ }
C {devices/lab_pin.sym} 161720 -22160 0 0 {name=p160846 lab=_55310_/X }
C {devices/lab_pin.sym} 161720 -22120 0 0 {name=p160847 lab=_55315_/X }
C {devices/lab_pin.sym} 161840 -22140 0 1 {name=p160848 lab=_55387_/A }
C {sky130_stdcells/and2_4.sym} 161780 -22140 0 0 {name=X_55386_ }
C {devices/lab_pin.sym} 161740 -22010 0 0 {name=p160849 lab=_52626_/A }
C {devices/lab_pin.sym} 161820 -22010 0 1 {name=p160850 lab=_52622_/C }
C {sky130_stdcells/buf_2.sym} 161780 -22010 0 0 {name=X_52598_ }
C {devices/lab_pin.sym} 161740 -21890 0 0 {name=p160851 lab=clkbuf_6_57_0_CLK/X }
C {devices/lab_pin.sym} 161820 -21890 0 1 {name=p160852 lab=clkbuf_8_229_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 161780 -21890 0 0 {name=Xclkbuf_7_114_0_CLK }
C {devices/lab_pin.sym} 161700 -21790 0 0 {name=p160853 lab=_55481_/B }
C {devices/lab_pin.sym} 161700 -21750 0 0 {name=p160854 lab=_57106_/X }
C {devices/lab_pin.sym} 161700 -21710 0 0 {name=p160855 lab=_57124_/X }
C {devices/lab_pin.sym} 161860 -21750 0 1 {name=p160856 lab=_85074_/D }
C {sky130_stdcells/o21ai_4.sym} 161780 -21750 0 0 {name=X_57125_ }
C {devices/lab_pin.sym} 161700 -21630 0 0 {name=p160857 lab=_85460_/Q }
C {devices/lab_pin.sym} 161700 -21590 0 0 {name=p160858 lab=_54320_/X }
C {devices/lab_pin.sym} 161700 -21550 0 0 {name=p160859 lab=_54336_/Y }
C {devices/lab_pin.sym} 161860 -21590 0 1 {name=p160860 lab=_54337_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -21590 0 0 {name=X_54337_ }
C {devices/lab_pin.sym} 161700 -21490 0 0 {name=p160861 lab=_42350_/X }
C {devices/lab_pin.sym} 161700 -21450 0 0 {name=p160862 lab=_42346_/X }
C {devices/lab_pin.sym} 161700 -21410 0 0 {name=p160863 lab=_41710_/X }
C {devices/lab_pin.sym} 161700 -21370 0 0 {name=p160864 lab=_87908_/Q }
C {devices/lab_pin.sym} 161700 -21330 0 0 {name=p160865 lab=_42347_/X }
C {devices/lab_pin.sym} 161860 -21410 0 1 {name=p160866 lab=_42352_/A }
C {sky130_stdcells/o32ai_4.sym} 161780 -21410 0 0 {name=X_42351_ }
C {devices/lab_pin.sym} 161720 -21260 0 0 {name=p160867 lab=_73339_/A }
C {devices/lab_pin.sym} 161720 -21220 0 0 {name=p160868 lab=_73170_/Y }
C {devices/lab_pin.sym} 161840 -21240 0 1 {name=p160869 lab=_73171_/Y }
C {sky130_stdcells/nor2_4.sym} 161780 -21240 0 0 {name=X_73171_ }
C {devices/lab_pin.sym} 161690 -21110 0 0 {name=p160870 lab=_85221_/CLK }
C {devices/lab_pin.sym} 161690 -21090 0 0 {name=p160871 lab=_85157_/D }
C {devices/lab_pin.sym} 161870 -21110 0 1 {name=p160872 lab=_55732_/B }
C {sky130_stdcells/dfxtp_4.sym} 161780 -21100 0 0 {name=X_85157_ }
C {devices/lab_pin.sym} 161700 -20990 0 0 {name=p160873 lab=_51546_/Y }
C {devices/lab_pin.sym} 161700 -20950 0 0 {name=p160874 lab=_51531_/X }
C {devices/lab_pin.sym} 161700 -20910 0 0 {name=p160875 lab=_51548_/X }
C {devices/lab_pin.sym} 161860 -20950 0 1 {name=p160876 lab=_85990_/D }
C {sky130_stdcells/a21oi_4.sym} 161780 -20950 0 0 {name=X_51549_ }
C {devices/lab_pin.sym} 161740 -20810 0 0 {name=p160877 lab=_70994_/A }
C {devices/lab_pin.sym} 161820 -20810 0 1 {name=p160878 lab=_70383_/X }
C {sky130_stdcells/buf_2.sym} 161780 -20810 0 0 {name=X_70383_ }
C {devices/lab_pin.sym} 161690 -20690 0 0 {name=p160879 lab=_82369_/CLK }
C {devices/lab_pin.sym} 161690 -20670 0 0 {name=p160880 lab=_77044_/X }
C {devices/lab_pin.sym} 161870 -20690 0 1 {name=p160881 lab=_82369_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -20680 0 0 {name=X_82369_ }
C {devices/lab_pin.sym} 161740 -20550 0 0 {name=p160882 lab=_41301_/Y }
C {devices/lab_pin.sym} 161820 -20550 0 1 {name=p160883 lab=_41302_/X }
C {sky130_stdcells/buf_2.sym} 161780 -20550 0 0 {name=X_41302_ }
C {devices/lab_pin.sym} 161700 -20450 0 0 {name=p160884 lab=_59331_/X }
C {devices/lab_pin.sym} 161700 -20410 0 0 {name=p160885 lab=_85377_/Q }
C {devices/lab_pin.sym} 161700 -20370 0 0 {name=p160886 lab=_72121_/X }
C {devices/lab_pin.sym} 161860 -20410 0 1 {name=p160887 lab=_72122_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -20410 0 0 {name=X_72122_ }
C {devices/lab_pin.sym} 161690 -20270 0 0 {name=p160888 lab=_84228_/CLK }
C {devices/lab_pin.sym} 161690 -20250 0 0 {name=p160889 lab=_84108_/D }
C {devices/lab_pin.sym} 161870 -20270 0 1 {name=p160890 lab=_84108_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -20260 0 0 {name=X_84108_ }
C {devices/lab_pin.sym} 161740 -20130 0 0 {name=p160891 lab=clkbuf_9_42_0_CLK/X }
C {devices/lab_pin.sym} 161820 -20130 0 1 {name=p160892 lab=_84835_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 161780 -20130 0 0 {name=Xclkbuf_10_84_0_CLK }
C {devices/lab_pin.sym} 161740 -20010 0 0 {name=p160893 lab=_45219_/A }
C {devices/lab_pin.sym} 161820 -20010 0 1 {name=p160894 lab=_45070_/X }
C {sky130_stdcells/buf_2.sym} 161780 -20010 0 0 {name=X_45070_ }
C {devices/lab_pin.sym} 161740 -19890 0 0 {name=p160895 lab=_57055_/Y }
C {devices/lab_pin.sym} 161820 -19890 0 1 {name=p160896 lab=_57056_/Y }
C {sky130_stdcells/inv_2.sym} 161780 -19890 0 0 {name=X_57056_ }
C {devices/lab_pin.sym} 161700 -19800 0 0 {name=p160897 lab=_41525_/X }
C {devices/lab_pin.sym} 161700 -19760 0 0 {name=p160898 lab=_42271_/X }
C {devices/lab_pin.sym} 161700 -19720 0 0 {name=p160899 lab=_87942_/Q }
C {devices/lab_pin.sym} 161700 -19680 0 0 {name=p160900 lab=_42272_/X }
C {devices/lab_pin.sym} 161860 -19740 0 1 {name=p160901 lab=_87942_/D }
C {sky130_stdcells/a2bb2o_4.sym} 161780 -19740 0 0 {name=X_42282_ }
C {devices/lab_pin.sym} 161720 -19600 0 0 {name=p160902 lab=_54288_/A }
C {devices/lab_pin.sym} 161720 -19560 0 0 {name=p160903 lab=_52577_/B }
C {devices/lab_pin.sym} 161840 -19580 0 1 {name=p160904 lab=_54268_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -19580 0 0 {name=X_54268_ }
C {devices/lab_pin.sym} 161690 -19450 0 0 {name=p160905 lab=_83008_/CLK }
C {devices/lab_pin.sym} 161690 -19430 0 0 {name=p160906 lab=_57100_/X }
C {devices/lab_pin.sym} 161870 -19450 0 1 {name=p160907 lab=_45408_/A }
C {sky130_stdcells/dfxtp_4.sym} 161780 -19440 0 0 {name=X_85088_ }
C {devices/lab_pin.sym} 161740 -19310 0 0 {name=p160908 lab=clkbuf_8_231_0_CLK/A }
C {devices/lab_pin.sym} 161820 -19310 0 1 {name=p160909 lab=clkbuf_9_461_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 161780 -19310 0 0 {name=Xclkbuf_8_230_0_CLK }
C {devices/lab_pin.sym} 161740 -19190 0 0 {name=p160910 lab=_64717_/A }
C {devices/lab_pin.sym} 161820 -19190 0 1 {name=p160911 lab=_64803_/A }
C {sky130_stdcells/buf_2.sym} 161780 -19190 0 0 {name=X_44021_ }
C {devices/lab_pin.sym} 161720 -19090 0 0 {name=p160912 lab=_56177_/A }
C {devices/lab_pin.sym} 161720 -19050 0 0 {name=p160913 lab=_56017_/B }
C {devices/lab_pin.sym} 161720 -19010 0 0 {name=p160914 lab=_85312_/Q }
C {devices/lab_pin.sym} 161840 -19050 0 1 {name=p160915 lab=_56007_/Y }
C {sky130_stdcells/nand3_4.sym} 161780 -19050 0 0 {name=X_56007_ }
C {devices/lab_pin.sym} 161700 -18930 0 0 {name=p160916 lab=_41136_/X }
C {devices/lab_pin.sym} 161700 -18890 0 0 {name=p160917 lab=_40714_/A }
C {devices/lab_pin.sym} 161700 -18850 0 0 {name=p160918 lab=_41232_/X }
C {devices/lab_pin.sym} 161860 -18890 0 1 {name=p160919 lab=_41233_/X }
C {sky130_stdcells/o21a_4.sym} 161780 -18890 0 0 {name=X_41233_ }
C {devices/lab_pin.sym} 161720 -18760 0 0 {name=p160920 lab=_53219_/A }
C {devices/lab_pin.sym} 161720 -18720 0 0 {name=p160921 lab=_53219_/B }
C {devices/lab_pin.sym} 161840 -18740 0 1 {name=p160922 lab=_53219_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -18740 0 0 {name=X_53219_ }
C {devices/lab_pin.sym} 161720 -18620 0 0 {name=p160923 lab=_72053_/A }
C {devices/lab_pin.sym} 161720 -18580 0 0 {name=p160924 lab=_53877_/B }
C {devices/lab_pin.sym} 161840 -18600 0 1 {name=p160925 lab=_72053_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -18600 0 0 {name=X_72053_ }
C {devices/lab_pin.sym} 161720 -18480 0 0 {name=p160926 lab=_76946_/B }
C {devices/lab_pin.sym} 161720 -18440 0 0 {name=p160927 lab=_76945_/A }
C {devices/lab_pin.sym} 161840 -18460 0 1 {name=p160928 lab=_76939_/A }
C {sky130_stdcells/xnor2_4.sym} 161780 -18460 0 0 {name=X_76930_ }
C {devices/lab_pin.sym} 161690 -18330 0 0 {name=p160929 lab=_81169_/CLK }
C {devices/lab_pin.sym} 161690 -18310 0 0 {name=p160930 lab=_84039_/D }
C {devices/lab_pin.sym} 161870 -18330 0 1 {name=p160931 lab=_82079_/D }
C {sky130_stdcells/dfxtp_4.sym} 161780 -18320 0 0 {name=X_84039_ }
C {devices/lab_pin.sym} 161720 -18220 0 0 {name=p160932 lab=_54191_/A }
C {devices/lab_pin.sym} 161720 -18180 0 0 {name=p160933 lab=_54191_/B }
C {devices/lab_pin.sym} 161720 -18140 0 0 {name=p160934 lab=_54209_/C }
C {devices/lab_pin.sym} 161720 -18100 0 0 {name=p160935 lab=_53031_/D }
C {devices/lab_pin.sym} 161840 -18160 0 1 {name=p160936 lab=_54199_/X }
C {sky130_stdcells/and4_4.sym} 161780 -18160 0 0 {name=X_54199_ }
C {devices/lab_pin.sym} 161740 -18010 0 0 {name=p160937 lab=_71071_/A }
C {devices/lab_pin.sym} 161820 -18010 0 1 {name=p160938 lab=_71055_/A }
C {sky130_stdcells/buf_2.sym} 161780 -18010 0 0 {name=X_71004_ }
C {devices/lab_pin.sym} 161700 -17910 0 0 {name=p160939 lab=_41143_/X }
C {devices/lab_pin.sym} 161700 -17870 0 0 {name=p160940 lab=_40644_/A }
C {devices/lab_pin.sym} 161700 -17830 0 0 {name=p160941 lab=_41163_/X }
C {devices/lab_pin.sym} 161860 -17870 0 1 {name=p160942 lab=_41165_/A }
C {sky130_stdcells/o21ai_4.sym} 161780 -17870 0 0 {name=X_41164_ }
C {devices/lab_pin.sym} 161700 -17750 0 0 {name=p160943 lab=_81496_/Q }
C {devices/lab_pin.sym} 161700 -17710 0 0 {name=p160944 lab=_81368_/D }
C {devices/lab_pin.sym} 161700 -17670 0 0 {name=p160945 lab=_76860_/Y }
C {devices/lab_pin.sym} 161860 -17710 0 1 {name=p160946 lab=_76862_/B }
C {sky130_stdcells/a21oi_4.sym} 161780 -17710 0 0 {name=X_76861_ }
C {devices/lab_pin.sym} 161740 -17570 0 0 {name=p160947 lab=clkbuf_9_49_0_CLK/X }
C {devices/lab_pin.sym} 161820 -17570 0 1 {name=p160948 lab=_86855_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 161780 -17570 0 0 {name=Xclkbuf_10_99_0_CLK }
C {devices/lab_pin.sym} 161720 -17460 0 0 {name=p160949 lab=_78600_/A }
C {devices/lab_pin.sym} 161720 -17420 0 0 {name=p160950 lab=_78600_/B }
C {devices/lab_pin.sym} 161840 -17440 0 1 {name=p160951 lab=_78601_/A }
C {sky130_stdcells/nor2_4.sym} 161780 -17440 0 0 {name=X_78600_ }
C {devices/lab_pin.sym} 161740 -17310 0 0 {name=p160952 lab=_75811_/X }
C {devices/lab_pin.sym} 161820 -17310 0 1 {name=p160953 lab=_80892_/D }
C {sky130_stdcells/buf_2.sym} 161780 -17310 0 0 {name=X_75812_ }
C {devices/lab_pin.sym} 161740 -17190 0 0 {name=p160954 lab=_48840_/A }
C {devices/lab_pin.sym} 161820 -17190 0 1 {name=p160955 lab=_48760_/X }
C {sky130_stdcells/buf_2.sym} 161780 -17190 0 0 {name=X_48760_ }
C {devices/lab_pin.sym} 161720 -17080 0 0 {name=p160956 lab=_79580_/A }
C {devices/lab_pin.sym} 161720 -17040 0 0 {name=p160957 lab=_79580_/B }
C {devices/lab_pin.sym} 161840 -17060 0 1 {name=p160958 lab=_81093_/D }
C {sky130_stdcells/xor2_4.sym} 161780 -17060 0 0 {name=X_79580_ }
C {devices/lab_pin.sym} 161740 -16930 0 0 {name=p160959 lab=_45971_/Y }
C {devices/lab_pin.sym} 161820 -16930 0 1 {name=p160960 lab=_86833_/D }
C {sky130_stdcells/inv_2.sym} 161780 -16930 0 0 {name=X_45972_ }
C {devices/lab_pin.sym} 161740 -16810 0 0 {name=p160961 lab=_40878_/A }
C {devices/lab_pin.sym} 161820 -16810 0 1 {name=p160962 lab=_41159_/A }
C {sky130_stdcells/buf_2.sym} 161780 -16810 0 0 {name=X_41095_ }
C {devices/lab_pin.sym} 161720 -16700 0 0 {name=p160963 lab=_57971_/A }
C {devices/lab_pin.sym} 161720 -16660 0 0 {name=p160964 lab=_57958_/B }
C {devices/lab_pin.sym} 161840 -16680 0 1 {name=p160965 lab=_57958_/Y }
C {sky130_stdcells/nor2_4.sym} 161780 -16680 0 0 {name=X_57958_ }
C {devices/lab_pin.sym} 161720 -16560 0 0 {name=p160966 lab=_81666_/Q }
C {devices/lab_pin.sym} 161720 -16520 0 0 {name=p160967 lab=_76792_/B }
C {devices/lab_pin.sym} 161840 -16540 0 1 {name=p160968 lab=_76792_/Y }
C {sky130_stdcells/xnor2_4.sym} 161780 -16540 0 0 {name=X_76792_ }
C {devices/lab_pin.sym} 161740 -16410 0 0 {name=p160969 lab=clkbuf_8_245_0_CLK/A }
C {devices/lab_pin.sym} 161820 -16410 0 1 {name=p160970 lab=clkbuf_9_491_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 161780 -16410 0 0 {name=Xclkbuf_8_245_0_CLK }
C {devices/lab_pin.sym} 161740 -16290 0 0 {name=p160971 lab=clkbuf_9_120_0_CLK/X }
C {devices/lab_pin.sym} 161820 -16290 0 1 {name=p160972 lab=_84449_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 161780 -16290 0 0 {name=Xclkbuf_10_240_0_CLK }
C {devices/lab_pin.sym} 161720 -16200 0 0 {name=p160973 lab=_47692_/A }
C {devices/lab_pin.sym} 161720 -16160 0 0 {name=p160974 lab=_47739_/B }
C {devices/lab_pin.sym} 161720 -16120 0 0 {name=p160975 lab=_47749_/C }
C {devices/lab_pin.sym} 161720 -16080 0 0 {name=p160976 lab=_53203_/D }
C {devices/lab_pin.sym} 161840 -16140 0 1 {name=p160977 lab=_47711_/X }
C {sky130_stdcells/and4_4.sym} 161780 -16140 0 0 {name=X_47711_ }
C {devices/lab_pin.sym} 161720 -16000 0 0 {name=p160978 lab=_78529_/Y }
C {devices/lab_pin.sym} 161720 -15960 0 0 {name=p160979 lab=_78530_/X }
C {devices/lab_pin.sym} 161840 -15980 0 1 {name=p160980 lab=_82769_/D }
C {sky130_stdcells/xnor2_4.sym} 161780 -15980 0 0 {name=X_78531_ }
C {devices/lab_pin.sym} 161700 -15870 0 0 {name=p160981 lab=_44905_/X }
C {devices/lab_pin.sym} 161700 -15830 0 0 {name=p160982 lab=_61329_/B }
C {devices/lab_pin.sym} 161700 -15790 0 0 {name=p160983 lab=_44907_/X }
C {devices/lab_pin.sym} 161860 -15830 0 1 {name=p160984 lab=_44923_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -15830 0 0 {name=X_44923_ }
C {devices/lab_pin.sym} 161700 -15710 0 0 {name=p160985 lab=_55218_/Y }
C {devices/lab_pin.sym} 161700 -15670 0 0 {name=p160986 lab=_56908_/X }
C {devices/lab_pin.sym} 161700 -15630 0 0 {name=p160987 lab=_56707_/X }
C {devices/lab_pin.sym} 161860 -15670 0 1 {name=p160988 lab=_56909_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -15670 0 0 {name=X_56909_ }
C {devices/lab_pin.sym} 161720 -15540 0 0 {name=p160989 lab=_81093_/Q }
C {devices/lab_pin.sym} 161720 -15500 0 0 {name=p160990 lab=_75743_/B }
C {devices/lab_pin.sym} 161840 -15520 0 1 {name=p160991 lab=_75743_/Y }
C {sky130_stdcells/xnor2_4.sym} 161780 -15520 0 0 {name=X_75743_ }
C {devices/lab_pin.sym} 161690 -15390 0 0 {name=p160992 lab=_82906_/CLK }
C {devices/lab_pin.sym} 161690 -15370 0 0 {name=p160993 lab=_87729_/D }
C {devices/lab_pin.sym} 161870 -15390 0 1 {name=p160994 lab=_67392_/B }
C {sky130_stdcells/dfxtp_4.sym} 161780 -15380 0 0 {name=X_87729_ }
C {devices/lab_pin.sym} 161720 -15270 0 0 {name=p160995 lab=_48691_/A }
C {devices/lab_pin.sym} 161720 -15230 0 0 {name=p160996 lab=_48894_/B }
C {devices/lab_pin.sym} 161720 -15190 0 0 {name=p160997 lab=_48894_/C }
C {devices/lab_pin.sym} 161840 -15230 0 1 {name=p160998 lab=_48691_/X }
C {sky130_stdcells/and3_4.sym} 161780 -15230 0 0 {name=X_48691_ }
C {devices/lab_pin.sym} 161740 -15090 0 0 {name=p160999 lab=_73351_/A }
C {devices/lab_pin.sym} 161820 -15090 0 1 {name=p161000 lab=_72955_/X }
C {sky130_stdcells/buf_2.sym} 161780 -15090 0 0 {name=X_72955_ }
C {devices/lab_pin.sym} 161740 -14970 0 0 {name=p161001 lab=clkbuf_9_435_0_CLK/X }
C {devices/lab_pin.sym} 161820 -14970 0 1 {name=p161002 lab=_85920_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 161780 -14970 0 0 {name=Xclkbuf_10_870_0_CLK }
C {devices/lab_pin.sym} 161740 -14850 0 0 {name=p161003 lab=_72201_/A }
C {devices/lab_pin.sym} 161820 -14850 0 1 {name=p161004 lab=_57889_/X }
C {sky130_stdcells/buf_2.sym} 161780 -14850 0 0 {name=X_57889_ }
C {devices/lab_pin.sym} 161700 -14750 0 0 {name=p161005 lab=_86613_/Q }
C {devices/lab_pin.sym} 161700 -14710 0 0 {name=p161006 lab=_47619_/X }
C {devices/lab_pin.sym} 161700 -14670 0 0 {name=p161007 lab=_47641_/Y }
C {devices/lab_pin.sym} 161860 -14710 0 1 {name=p161008 lab=_47642_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -14710 0 0 {name=X_47642_ }
C {devices/lab_pin.sym} 161740 -14570 0 0 {name=p161009 lab=clkbuf_9_11_0_CLK/X }
C {devices/lab_pin.sym} 161820 -14570 0 1 {name=p161010 lab=_85221_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 161780 -14570 0 0 {name=Xclkbuf_10_22_0_CLK }
C {devices/lab_pin.sym} 161700 -14470 0 0 {name=p161011 lab=_56971_/B }
C {devices/lab_pin.sym} 161700 -14430 0 0 {name=p161012 lab=_71892_/X }
C {devices/lab_pin.sym} 161700 -14390 0 0 {name=p161013 lab=_71905_/Y }
C {devices/lab_pin.sym} 161860 -14430 0 1 {name=p161014 lab=_83333_/D }
C {sky130_stdcells/o21ai_4.sym} 161780 -14430 0 0 {name=X_71906_ }
C {devices/lab_pin.sym} 161740 -14290 0 0 {name=p161015 lab=_59628_/A }
C {devices/lab_pin.sym} 161820 -14290 0 1 {name=p161016 lab=_59631_/B }
C {sky130_stdcells/buf_2.sym} 161780 -14290 0 0 {name=X_59628_ }
C {devices/lab_pin.sym} 161700 -14190 0 0 {name=p161017 lab=_78458_/Y }
C {devices/lab_pin.sym} 161700 -14150 0 0 {name=p161018 lab=_78460_/Y }
C {devices/lab_pin.sym} 161700 -14110 0 0 {name=p161019 lab=_78461_/A }
C {devices/lab_pin.sym} 161860 -14150 0 1 {name=p161020 lab=_78463_/B }
C {sky130_stdcells/o21ai_4.sym} 161780 -14150 0 0 {name=X_78462_ }
C {devices/lab_pin.sym} 161700 -14050 0 0 {name=p161021 lab=_44832_/X }
C {devices/lab_pin.sym} 161700 -14010 0 0 {name=p161022 lab=_44844_/X }
C {devices/lab_pin.sym} 161700 -13970 0 0 {name=p161023 lab=_41761_/X }
C {devices/lab_pin.sym} 161700 -13930 0 0 {name=p161024 lab=_67929_/B }
C {devices/lab_pin.sym} 161700 -13890 0 0 {name=p161025 lab=_44833_/X }
C {devices/lab_pin.sym} 161860 -13970 0 1 {name=p161026 lab=_44855_/A }
C {sky130_stdcells/o32ai_4.sym} 161780 -13970 0 0 {name=X_44854_ }
C {devices/lab_pin.sym} 161720 -13820 0 0 {name=p161027 lab=_75674_/A }
C {devices/lab_pin.sym} 161720 -13780 0 0 {name=p161028 lab=_75673_/Y }
C {devices/lab_pin.sym} 161840 -13800 0 1 {name=p161029 lab=_75675_/B }
C {sky130_stdcells/xnor2_4.sym} 161780 -13800 0 0 {name=X_75674_ }
C {devices/lab_pin.sym} 161720 -13680 0 0 {name=p161030 lab=_73050_/A }
C {devices/lab_pin.sym} 161720 -13640 0 0 {name=p161031 lab=_72885_/Y }
C {devices/lab_pin.sym} 161840 -13660 0 1 {name=p161032 lab=_72886_/Y }
C {sky130_stdcells/nor2_4.sym} 161780 -13660 0 0 {name=X_72886_ }
C {devices/lab_pin.sym} 161740 -13530 0 0 {name=p161033 lab=clkbuf_8_180_0_CLK/X }
C {devices/lab_pin.sym} 161820 -13530 0 1 {name=p161034 lab=clkbuf_9_361_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 161780 -13530 0 0 {name=Xclkbuf_9_361_0_CLK }
C {devices/lab_pin.sym} 161700 -13430 0 0 {name=p161035 lab=_77412_/B }
C {devices/lab_pin.sym} 161700 -13390 0 0 {name=p161036 lab=_77412_/C }
C {devices/lab_pin.sym} 161700 -13350 0 0 {name=p161037 lab=_77412_/A }
C {devices/lab_pin.sym} 161860 -13390 0 1 {name=p161038 lab=_77413_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -13390 0 0 {name=X_77413_ }
C {devices/lab_pin.sym} 161700 -13290 0 0 {name=p161039 lab=_43790_/X }
C {devices/lab_pin.sym} 161700 -13250 0 0 {name=p161040 lab=_43797_/X }
C {devices/lab_pin.sym} 161700 -13210 0 0 {name=p161041 lab=_41076_/X }
C {devices/lab_pin.sym} 161700 -13170 0 0 {name=p161042 lab=_87258_/Q }
C {devices/lab_pin.sym} 161700 -13130 0 0 {name=p161043 lab=_43791_/X }
C {devices/lab_pin.sym} 161860 -13210 0 1 {name=p161044 lab=_43806_/A }
C {sky130_stdcells/o32ai_4.sym} 161780 -13210 0 0 {name=X_43805_ }
C {devices/lab_pin.sym} 161720 -13070 0 0 {name=p161045 lab=_74625_/A }
C {devices/lab_pin.sym} 161720 -13030 0 0 {name=p161046 lab=_74537_/Y }
C {devices/lab_pin.sym} 161720 -12990 0 0 {name=p161047 lab=_56173_/Y }
C {devices/lab_pin.sym} 161840 -13030 0 1 {name=p161048 lab=_74625_/Y }
C {sky130_stdcells/nand3_4.sym} 161780 -13030 0 0 {name=X_74625_ }
C {devices/lab_pin.sym} 161740 -12890 0 0 {name=p161049 lab=_47572_/Y }
C {devices/lab_pin.sym} 161820 -12890 0 1 {name=p161050 lab=_53127_/B }
C {sky130_stdcells/buf_2.sym} 161780 -12890 0 0 {name=X_47573_ }
C {devices/lab_pin.sym} 161720 -12800 0 0 {name=p161051 lab=_71829_/X }
C {devices/lab_pin.sym} 161720 -12760 0 0 {name=p161052 lab=_71839_/B }
C {devices/lab_pin.sym} 161720 -12720 0 0 {name=p161053 lab=_70782_/A }
C {devices/lab_pin.sym} 161720 -12680 0 0 {name=p161054 lab=_71826_/X }
C {devices/lab_pin.sym} 161840 -12740 0 1 {name=p161055 lab=_71837_/X }
C {sky130_stdcells/and4_4.sym} 161780 -12740 0 0 {name=X_71837_ }
C {devices/lab_pin.sym} 161740 -12590 0 0 {name=p161056 lab=_59558_/Y }
C {devices/lab_pin.sym} 161820 -12590 0 1 {name=p161057 lab=_59560_/A }
C {sky130_stdcells/inv_2.sym} 161780 -12590 0 0 {name=X_59559_ }
C {devices/lab_pin.sym} 161700 -12490 0 0 {name=p161058 lab=_78394_/A }
C {devices/lab_pin.sym} 161700 -12450 0 0 {name=p161059 lab=_78394_/B }
C {devices/lab_pin.sym} 161700 -12410 0 0 {name=p161060 lab=_78394_/C }
C {devices/lab_pin.sym} 161860 -12450 0 1 {name=p161061 lab=_78426_/C }
C {sky130_stdcells/a21o_4.sym} 161780 -12450 0 0 {name=X_78393_ }
C {devices/lab_pin.sym} 161740 -12310 0 0 {name=p161062 lab=_44784_/Y }
C {devices/lab_pin.sym} 161820 -12310 0 1 {name=p161063 lab=_86956_/D }
C {sky130_stdcells/inv_2.sym} 161780 -12310 0 0 {name=X_44785_ }
C {devices/lab_pin.sym} 161700 -12230 0 0 {name=p161064 lab=_41982_/X }
C {devices/lab_pin.sym} 161700 -12190 0 0 {name=p161065 lab=_41993_/X }
C {devices/lab_pin.sym} 161700 -12150 0 0 {name=p161066 lab=_40798_/X }
C {devices/lab_pin.sym} 161700 -12110 0 0 {name=p161067 lab=_41996_/Y }
C {devices/lab_pin.sym} 161700 -12070 0 0 {name=p161068 lab=_41984_/X }
C {devices/lab_pin.sym} 161860 -12150 0 1 {name=p161069 lab=_88077_/D }
C {sky130_stdcells/o32ai_4.sym} 161780 -12150 0 0 {name=X_41997_ }
C {devices/lab_pin.sym} 161740 -11990 0 0 {name=p161070 lab=clkbuf_9_127_0_CLK/X }
C {devices/lab_pin.sym} 161820 -11990 0 1 {name=p161071 lab=_82786_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 161780 -11990 0 0 {name=Xclkbuf_10_255_0_CLK }
C {devices/lab_pin.sym} 161720 -11890 0 0 {name=p161072 lab=_52528_/A }
C {devices/lab_pin.sym} 161720 -11850 0 0 {name=p161073 lab=_49283_/B }
C {devices/lab_pin.sym} 161720 -11810 0 0 {name=p161074 lab=_49312_/C }
C {devices/lab_pin.sym} 161840 -11850 0 1 {name=p161075 lab=_49312_/X }
C {sky130_stdcells/and3_4.sym} 161780 -11850 0 0 {name=X_49312_ }
C {devices/lab_pin.sym} 161740 -11710 0 0 {name=p161076 lab=_46401_/A }
C {devices/lab_pin.sym} 161820 -11710 0 1 {name=p161077 lab=_46531_/A }
C {sky130_stdcells/buf_2.sym} 161780 -11710 0 0 {name=X_46524_ }
C {devices/lab_pin.sym} 161720 -11610 0 0 {name=p161078 lab=_77339_/X }
C {devices/lab_pin.sym} 161720 -11570 0 0 {name=p161079 lab=_77342_/Y }
C {devices/lab_pin.sym} 161720 -11530 0 0 {name=p161080 lab=_77340_/Y }
C {devices/lab_pin.sym} 161840 -11570 0 1 {name=p161081 lab=_77345_/B }
C {sky130_stdcells/nand3_4.sym} 161780 -11570 0 0 {name=X_77344_ }
C {devices/lab_pin.sym} 161740 -11430 0 0 {name=p161082 lab=_43685_/A }
C {devices/lab_pin.sym} 161820 -11430 0 1 {name=p161083 lab=_43736_/X }
C {sky130_stdcells/buf_2.sym} 161780 -11430 0 0 {name=X_43736_ }
C {devices/lab_pin.sym} 161720 -11340 0 0 {name=p161084 lab=_62570_/A }
C {devices/lab_pin.sym} 161720 -11300 0 0 {name=p161085 lab=_62113_/X }
C {devices/lab_pin.sym} 161720 -11260 0 0 {name=p161086 lab=_62601_/C }
C {devices/lab_pin.sym} 161720 -11220 0 0 {name=p161087 lab=_62623_/D }
C {devices/lab_pin.sym} 161840 -11280 0 1 {name=p161088 lab=_62570_/X }
C {sky130_stdcells/and4_4.sym} 161780 -11280 0 0 {name=X_62570_ }
C {devices/lab_pin.sym} 161700 -11150 0 0 {name=p161089 lab=_44966_/Y }
C {devices/lab_pin.sym} 161700 -11110 0 0 {name=p161090 lab=_74551_/X }
C {devices/lab_pin.sym} 161700 -11070 0 0 {name=p161091 lab=_74555_/X }
C {devices/lab_pin.sym} 161860 -11110 0 1 {name=p161092 lab=_74556_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -11110 0 0 {name=X_74556_ }
C {devices/lab_pin.sym} 161740 -10970 0 0 {name=p161093 lab=clkbuf_9_442_0_CLK/X }
C {devices/lab_pin.sym} 161820 -10970 0 1 {name=p161094 lab=_85529_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 161780 -10970 0 0 {name=Xclkbuf_10_885_0_CLK }
C {devices/lab_pin.sym} 161720 -10860 0 0 {name=p161095 lab=_82303_/Q }
C {devices/lab_pin.sym} 161720 -10820 0 0 {name=p161096 lab=_40970_/B }
C {devices/lab_pin.sym} 161840 -10840 0 1 {name=p161097 lab=_40948_/X }
C {sky130_stdcells/or2_4.sym} 161780 -10840 0 0 {name=X_40948_ }
C {devices/lab_pin.sym} 161720 -10730 0 0 {name=p161098 lab=_71763_/X }
C {devices/lab_pin.sym} 161720 -10690 0 0 {name=p161099 lab=_71427_/C }
C {devices/lab_pin.sym} 161720 -10650 0 0 {name=p161100 lab=_70794_/X }
C {devices/lab_pin.sym} 161840 -10690 0 1 {name=p161101 lab=_71768_/X }
C {sky130_stdcells/and3_4.sym} 161780 -10690 0 0 {name=X_71768_ }
C {devices/lab_pin.sym} 161740 -10550 0 0 {name=p161102 lab=clkbuf_9_18_0_CLK/X }
C {devices/lab_pin.sym} 161820 -10550 0 1 {name=p161103 lab=_85057_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 161780 -10550 0 0 {name=Xclkbuf_10_37_0_CLK }
C {devices/lab_pin.sym} 161720 -10440 0 0 {name=p161104 lab=_49220_/A }
C {devices/lab_pin.sym} 161720 -10400 0 0 {name=p161105 lab=_53978_/B }
C {devices/lab_pin.sym} 161840 -10420 0 1 {name=p161106 lab=_49243_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -10420 0 0 {name=X_49243_ }
C {devices/lab_pin.sym} 161720 -10310 0 0 {name=p161107 lab=_61499_/A }
C {devices/lab_pin.sym} 161720 -10270 0 0 {name=p161108 lab=_61521_/B }
C {devices/lab_pin.sym} 161720 -10230 0 0 {name=p161109 lab=_61538_/C }
C {devices/lab_pin.sym} 161840 -10270 0 1 {name=p161110 lab=_61521_/Y }
C {sky130_stdcells/nand3_4.sym} 161780 -10270 0 0 {name=X_61521_ }
C {devices/lab_pin.sym} 161720 -10140 0 0 {name=p161111 lab=_73507_/A }
C {devices/lab_pin.sym} 161720 -10100 0 0 {name=p161112 lab=_73053_/B }
C {devices/lab_pin.sym} 161840 -10120 0 1 {name=p161113 lab=_73507_/Y }
C {sky130_stdcells/nor2_4.sym} 161780 -10120 0 0 {name=X_73507_ }
C {devices/lab_pin.sym} 161740 -9990 0 0 {name=p161114 lab=_83639_/Q }
C {devices/lab_pin.sym} 161820 -9990 0 1 {name=p161115 lab=_46455_/Y }
C {sky130_stdcells/inv_2.sym} 161780 -9990 0 0 {name=X_46455_ }
C {devices/lab_pin.sym} 161720 -9900 0 0 {name=p161116 lab=_70719_/A }
C {devices/lab_pin.sym} 161720 -9860 0 0 {name=p161117 lab=_70713_/X }
C {devices/lab_pin.sym} 161720 -9820 0 0 {name=p161118 lab=_70727_/C }
C {devices/lab_pin.sym} 161720 -9780 0 0 {name=p161119 lab=_70710_/D }
C {devices/lab_pin.sym} 161840 -9840 0 1 {name=p161120 lab=_70719_/Y }
C {sky130_stdcells/nand4_4.sym} 161780 -9840 0 0 {name=X_70719_ }
C {devices/lab_pin.sym} 161720 -9700 0 0 {name=p161121 lab=_77273_/X }
C {devices/lab_pin.sym} 161720 -9660 0 0 {name=p161122 lab=_77274_/Y }
C {devices/lab_pin.sym} 161840 -9680 0 1 {name=p161123 lab=_77277_/B }
C {sky130_stdcells/nand2_4.sym} 161780 -9680 0 0 {name=X_77275_ }
C {devices/lab_pin.sym} 161740 -9550 0 0 {name=p161124 lab=_43667_/A }
C {devices/lab_pin.sym} 161820 -9550 0 1 {name=p161125 lab=_69055_/B }
C {sky130_stdcells/inv_2.sym} 161780 -9550 0 0 {name=X_43667_ }
C {devices/lab_pin.sym} 161740 -9430 0 0 {name=p161126 lab=_74458_/A }
C {devices/lab_pin.sym} 161820 -9430 0 1 {name=p161127 lab=_74501_/C }
C {sky130_stdcells/buf_2.sym} 161780 -9430 0 0 {name=X_74487_ }
C {devices/lab_pin.sym} 161740 -9310 0 0 {name=p161128 lab=clkbuf_8_188_0_CLK/X }
C {devices/lab_pin.sym} 161820 -9310 0 1 {name=p161129 lab=clkbuf_9_376_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 161780 -9310 0 0 {name=Xclkbuf_9_376_0_CLK }
C {devices/lab_pin.sym} 161720 -9200 0 0 {name=p161130 lab=_46469_/B }
C {devices/lab_pin.sym} 161720 -9160 0 0 {name=p161131 lab=_40879_/B }
C {devices/lab_pin.sym} 161840 -9180 0 1 {name=p161132 lab=_40879_/X }
C {sky130_stdcells/or2_4.sym} 161780 -9180 0 0 {name=X_40879_ }
C {devices/lab_pin.sym} 161700 -9070 0 0 {name=p161133 lab=_71691_/Y }
C {devices/lab_pin.sym} 161700 -9030 0 0 {name=p161134 lab=_83407_/Q }
C {devices/lab_pin.sym} 161700 -8990 0 0 {name=p161135 lab=_71698_/Y }
C {devices/lab_pin.sym} 161860 -9030 0 1 {name=p161136 lab=_83407_/D }
C {sky130_stdcells/a21o_4.sym} 161780 -9030 0 0 {name=X_71699_ }
C {devices/lab_pin.sym} 161720 -8900 0 0 {name=p161137 lab=_79012_/Y }
C {devices/lab_pin.sym} 161720 -8860 0 0 {name=p161138 lab=_79014_/B }
C {devices/lab_pin.sym} 161840 -8880 0 1 {name=p161139 lab=_79018_/A }
C {sky130_stdcells/xor2_4.sym} 161780 -8880 0 0 {name=X_79014_ }
C {devices/lab_pin.sym} 161700 -8770 0 0 {name=p161140 lab=_45350_/X }
C {devices/lab_pin.sym} 161700 -8730 0 0 {name=p161141 lab=_61315_/A }
C {devices/lab_pin.sym} 161700 -8690 0 0 {name=p161142 lab=_45370_/X }
C {devices/lab_pin.sym} 161860 -8730 0 1 {name=p161143 lab=_45406_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -8730 0 0 {name=X_45406_ }
C {devices/lab_pin.sym} 161700 -8610 0 0 {name=p161144 lab=_64233_/Y }
C {devices/lab_pin.sym} 161700 -8570 0 0 {name=p161145 lab=_64239_/X }
C {devices/lab_pin.sym} 161700 -8530 0 0 {name=p161146 lab=_72577_/B }
C {devices/lab_pin.sym} 161860 -8570 0 1 {name=p161147 lab=_64240_/X }
C {sky130_stdcells/o21a_4.sym} 161780 -8570 0 0 {name=X_64240_ }
C {devices/lab_pin.sym} 161720 -8440 0 0 {name=p161148 lab=_76226_/A }
C {devices/lab_pin.sym} 161720 -8400 0 0 {name=p161149 lab=_81607_/D }
C {devices/lab_pin.sym} 161840 -8420 0 1 {name=p161150 lab=_76226_/X }
C {sky130_stdcells/xor2_4.sym} 161780 -8420 0 0 {name=X_76226_ }
C {devices/lab_pin.sym} 161700 -8330 0 0 {name=p161151 lab=_42614_/X }
C {devices/lab_pin.sym} 161700 -8290 0 0 {name=p161152 lab=_42615_/X }
C {devices/lab_pin.sym} 161700 -8250 0 0 {name=p161153 lab=_40914_/X }
C {devices/lab_pin.sym} 161700 -8210 0 0 {name=p161154 lab=_69929_/A }
C {devices/lab_pin.sym} 161700 -8170 0 0 {name=p161155 lab=_42597_/X }
C {devices/lab_pin.sym} 161860 -8250 0 1 {name=p161156 lab=_42619_/A }
C {sky130_stdcells/o32ai_4.sym} 161780 -8250 0 0 {name=X_42618_ }
C {devices/lab_pin.sym} 161700 -8110 0 0 {name=p161157 lab=_49169_/Y }
C {devices/lab_pin.sym} 161700 -8070 0 0 {name=p161158 lab=_49138_/X }
C {devices/lab_pin.sym} 161700 -8030 0 0 {name=p161159 lab=_49173_/X }
C {devices/lab_pin.sym} 161860 -8070 0 1 {name=p161160 lab=_86437_/D }
C {sky130_stdcells/a21oi_4.sym} 161780 -8070 0 0 {name=X_49174_ }
C {devices/lab_pin.sym} 161720 -7960 0 0 {name=p161161 lab=_59399_/A }
C {devices/lab_pin.sym} 161720 -7920 0 0 {name=p161162 lab=_61452_/B }
C {devices/lab_pin.sym} 161720 -7880 0 0 {name=p161163 lab=_61452_/C }
C {devices/lab_pin.sym} 161720 -7840 0 0 {name=p161164 lab=_61452_/D }
C {devices/lab_pin.sym} 161840 -7900 0 1 {name=p161165 lab=_61453_/A }
C {sky130_stdcells/nand4_4.sym} 161780 -7900 0 0 {name=X_61452_ }
C {devices/lab_pin.sym} 161720 -7760 0 0 {name=p161166 lab=_73438_/A }
C {devices/lab_pin.sym} 161720 -7720 0 0 {name=p161167 lab=_73438_/B }
C {devices/lab_pin.sym} 161840 -7740 0 1 {name=p161168 lab=_73438_/Y }
C {sky130_stdcells/nor2_4.sym} 161780 -7740 0 0 {name=X_73438_ }
C {devices/lab_pin.sym} 161740 -7610 0 0 {name=p161169 lab=_52480_/B }
C {devices/lab_pin.sym} 161820 -7610 0 1 {name=p161170 lab=_49265_/B }
C {sky130_stdcells/buf_2.sym} 161780 -7610 0 0 {name=X_46386_ }
C {devices/lab_pin.sym} 161740 -7490 0 0 {name=p161171 lab=_43598_/A }
C {devices/lab_pin.sym} 161820 -7490 0 1 {name=p161172 lab=_43598_/Y }
C {sky130_stdcells/inv_2.sym} 161780 -7490 0 0 {name=X_43598_ }
C {devices/lab_pin.sym} 161700 -7390 0 0 {name=p161173 lab=_66310_/B }
C {devices/lab_pin.sym} 161700 -7350 0 0 {name=p161174 lab=_48103_/X }
C {devices/lab_pin.sym} 161700 -7310 0 0 {name=p161175 lab=_48124_/Y }
C {devices/lab_pin.sym} 161860 -7350 0 1 {name=p161176 lab=_48125_/Y }
C {sky130_stdcells/o21ai_4.sym} 161780 -7350 0 0 {name=X_48125_ }
C {devices/lab_pin.sym} 161720 -7240 0 0 {name=p161177 lab=_60403_/A }
C {devices/lab_pin.sym} 161720 -7200 0 0 {name=p161178 lab=_60403_/B }
C {devices/lab_pin.sym} 161720 -7160 0 0 {name=p161179 lab=_60403_/C }
C {devices/lab_pin.sym} 161720 -7120 0 0 {name=p161180 lab=_60414_/B }
C {devices/lab_pin.sym} 161840 -7180 0 1 {name=p161181 lab=_60404_/B }
C {sky130_stdcells/and4_4.sym} 161780 -7180 0 0 {name=X_60403_ }
C {devices/lab_pin.sym} 161700 -7050 0 0 {name=p161182 lab=_55722_/B }
C {devices/lab_pin.sym} 161700 -7010 0 0 {name=p161183 lab=_45281_/X }
C {devices/lab_pin.sym} 161700 -6970 0 0 {name=p161184 lab=_45311_/X }
C {devices/lab_pin.sym} 161860 -7010 0 1 {name=p161185 lab=_45337_/X }
C {sky130_stdcells/o21a_4.sym} 161780 -7010 0 0 {name=X_45337_ }
C {devices/lab_pin.sym} 161720 -6880 0 0 {name=p161186 lab=_81346_/Q }
C {devices/lab_pin.sym} 161720 -6840 0 0 {name=p161187 lab=_81602_/D }
C {devices/lab_pin.sym} 161840 -6860 0 1 {name=p161188 lab=_76157_/X }
C {sky130_stdcells/xor2_4.sym} 161780 -6860 0 0 {name=X_76157_ }
C {devices/lab_pin.sym} 161720 -6760 0 0 {name=p161189 lab=_62162_/X }
C {devices/lab_pin.sym} 161720 -6720 0 0 {name=p161190 lab=_64182_/B }
C {devices/lab_pin.sym} 161720 -6680 0 0 {name=p161191 lab=_64182_/C }
C {devices/lab_pin.sym} 161720 -6640 0 0 {name=p161192 lab=_64182_/D }
C {devices/lab_pin.sym} 161840 -6700 0 1 {name=p161193 lab=_64171_/Y }
C {sky130_stdcells/nand4_4.sym} 161780 -6700 0 0 {name=X_64171_ }
C {devices/lab_pin.sym} 161700 -6590 0 0 {name=p161194 lab=_42536_/X }
C {devices/lab_pin.sym} 161700 -6550 0 0 {name=p161195 lab=_42547_/X }
C {devices/lab_pin.sym} 161700 -6510 0 0 {name=p161196 lab=_40776_/X }
C {devices/lab_pin.sym} 161700 -6470 0 0 {name=p161197 lab=_42548_/Y }
C {devices/lab_pin.sym} 161700 -6430 0 0 {name=p161198 lab=_42538_/X }
C {devices/lab_pin.sym} 161860 -6510 0 1 {name=p161199 lab=_42549_/Y }
C {sky130_stdcells/o32ai_4.sym} 161780 -6510 0 0 {name=X_42549_ }
C {devices/lab_pin.sym} 161700 -6370 0 0 {name=p161200 lab=_83154_/Q }
C {devices/lab_pin.sym} 161700 -6330 0 0 {name=p161201 lab=_73318_/X }
C {devices/lab_pin.sym} 161700 -6290 0 0 {name=p161202 lab=_73368_/Y }
C {devices/lab_pin.sym} 161860 -6330 0 1 {name=p161203 lab=_83154_/D }
C {sky130_stdcells/a21o_4.sym} 161780 -6330 0 0 {name=X_73369_ }
C {devices/lab_pin.sym} 161700 -6230 0 0 {name=p161204 lab=_61375_/Y }
C {devices/lab_pin.sym} 161700 -6190 0 0 {name=p161205 lab=_61377_/Y }
C {devices/lab_pin.sym} 161700 -6150 0 0 {name=p161206 lab=_61334_/X }
C {devices/lab_pin.sym} 161700 -6110 0 0 {name=p161207 lab=_61378_/Y }
C {devices/lab_pin.sym} 161700 -6080 0 0 {name=p161208 lab=_61382_/Y }
C {devices/lab_pin.sym} 161860 -6150 0 1 {name=p161209 lab=_61383_/X }
C {sky130_stdcells/a41o_4.sym} 161780 -6150 0 0 {name=X_61383_ }
C {devices/lab_pin.sym} 161720 -6000 0 0 {name=p161210 lab=_75108_/A }
C {devices/lab_pin.sym} 161720 -5960 0 0 {name=p161211 lab=_75107_/Y }
C {devices/lab_pin.sym} 161840 -5980 0 1 {name=p161212 lab=_75108_/X }
C {sky130_stdcells/xor2_4.sym} 161780 -5980 0 0 {name=X_75108_ }
C {devices/lab_pin.sym} 161720 -5880 0 0 {name=p161213 lab=_63088_/A }
C {devices/lab_pin.sym} 161720 -5840 0 0 {name=p161214 lab=_64335_/C }
C {devices/lab_pin.sym} 161720 -5800 0 0 {name=p161215 lab=_63087_/X }
C {devices/lab_pin.sym} 161720 -5760 0 0 {name=p161216 lab=_63077_/D }
C {devices/lab_pin.sym} 161840 -5820 0 1 {name=p161217 lab=_63122_/X }
C {sky130_stdcells/and4_4.sym} 161780 -5820 0 0 {name=X_63122_ }
C {devices/lab_pin.sym} 161720 -5680 0 0 {name=p161218 lab=_48056_/A }
C {devices/lab_pin.sym} 161720 -5640 0 0 {name=p161219 lab=_47973_/B }
C {devices/lab_pin.sym} 161840 -5660 0 1 {name=p161220 lab=_48056_/X }
C {sky130_stdcells/or2_4.sym} 161780 -5660 0 0 {name=X_48056_ }
C {devices/lab_pin.sym} 161720 -5560 0 0 {name=p161221 lab=_60296_/X }
C {devices/lab_pin.sym} 161720 -5520 0 0 {name=p161222 lab=_60241_/A }
C {devices/lab_pin.sym} 161720 -5480 0 0 {name=p161223 lab=_60300_/C }
C {devices/lab_pin.sym} 161720 -5440 0 0 {name=p161224 lab=_60367_/D }
C {devices/lab_pin.sym} 161840 -5500 0 1 {name=p161225 lab=_60334_/Y }
C {sky130_stdcells/nand4_4.sym} 161780 -5500 0 0 {name=X_60334_ }
C {devices/lab_pin.sym} 161700 -5370 0 0 {name=p161226 lab=_45264_/Y }
C {devices/lab_pin.sym} 161700 -5330 0 0 {name=p161227 lab=_45267_/Y }
C {devices/lab_pin.sym} 161700 -5290 0 0 {name=p161228 lab=_45212_/X }
C {devices/lab_pin.sym} 161860 -5330 0 1 {name=p161229 lab=_45268_/X }
C {sky130_stdcells/a21o_4.sym} 161780 -5330 0 0 {name=X_45268_ }
C {devices/lab_pin.sym} 161700 -5210 0 0 {name=p161230 lab=_81720_/D }
C {devices/lab_pin.sym} 161700 -5170 0 0 {name=p161231 lab=_76075_/B }
C {devices/lab_pin.sym} 161700 -5130 0 0 {name=p161232 lab=_76087_/Y }
C {devices/lab_pin.sym} 161860 -5170 0 1 {name=p161233 lab=_76089_/B }
C {sky130_stdcells/a21oi_4.sym} 161780 -5170 0 0 {name=X_76088_ }
C {devices/lab_pin.sym} 161740 -5030 0 0 {name=p161234 lab=_47006_/Y }
C {devices/lab_pin.sym} 161820 -5030 0 1 {name=p161235 lab=_52799_/B }
C {sky130_stdcells/buf_2.sym} 161780 -5030 0 0 {name=X_47007_ }
C {devices/lab_pin.sym} 161700 -4940 0 0 {name=p161236 lab=_44054_/Y }
C {devices/lab_pin.sym} 161700 -4900 0 0 {name=p161237 lab=_44185_/X }
C {devices/lab_pin.sym} 161700 -4860 0 0 {name=p161238 lab=_44204_/Y }
C {devices/lab_pin.sym} 161700 -4820 0 0 {name=p161239 lab=_44218_/X }
C {devices/lab_pin.sym} 161860 -4880 0 1 {name=p161240 lab=_44220_/A }
C {sky130_stdcells/o22a_4.sym} 161780 -4880 0 0 {name=X_44219_ }
C {devices/lab_pin.sym} 161700 -4760 0 0 {name=p161241 lab=_87386_/Q }
C {devices/lab_pin.sym} 161700 -4720 0 0 {name=p161242 lab=_67834_/X }
C {devices/lab_pin.sym} 161700 -4680 0 0 {name=p161243 lab=_67835_/X }
C {devices/lab_pin.sym} 161700 -4640 0 0 {name=p161244 lab=_67929_/X }
C {devices/lab_pin.sym} 161860 -4700 0 1 {name=p161245 lab=_67930_/X }
C {sky130_stdcells/a211o_4.sym} 161780 -4700 0 0 {name=X_67930_ }
C {devices/lab_pin.sym} 161740 -4550 0 0 {name=p161246 lab=_63053_/A }
C {devices/lab_pin.sym} 161820 -4550 0 1 {name=p161247 lab=_63081_/B }
C {sky130_stdcells/buf_2.sym} 161780 -4550 0 0 {name=X_63053_ }
C {devices/lab_pin.sym} 161740 -4430 0 0 {name=p161248 lab=_75038_/X }
C {devices/lab_pin.sym} 161820 -4430 0 1 {name=p161249 lab=_75039_/X }
C {sky130_stdcells/buf_2.sym} 161780 -4430 0 0 {name=X_75039_ }
C {devices/lab_pin.sym} 161720 -4320 0 0 {name=p161250 lab=_79902_/Y }
C {devices/lab_pin.sym} 161720 -4280 0 0 {name=p161251 lab=_80262_/B }
C {devices/lab_pin.sym} 161840 -4300 0 1 {name=p161252 lab=_79932_/A }
C {sky130_stdcells/nor2_4.sym} 161780 -4300 0 0 {name=X_79916_ }
C {devices/lab_pin.sym} 161720 -4190 0 0 {name=p161253 lab=_60513_/A }
C {devices/lab_pin.sym} 161720 -4150 0 0 {name=p161254 lab=_61587_/B }
C {devices/lab_pin.sym} 161720 -4110 0 0 {name=p161255 lab=_79826_/A }
C {devices/lab_pin.sym} 161840 -4150 0 1 {name=p161256 lab=_60265_/X }
C {sky130_stdcells/or3_4.sym} 161780 -4150 0 0 {name=X_60265_ }
C {devices/lab_pin.sym} 161740 -4010 0 0 {name=p161257 lab=clkbuf_9_411_0_CLK/X }
C {devices/lab_pin.sym} 161820 -4010 0 1 {name=p161258 lab=_84981_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 161780 -4010 0 0 {name=Xclkbuf_10_823_0_CLK }
C {devices/lab_pin.sym} 161720 -3900 0 0 {name=p161259 lab=_45199_/A }
C {devices/lab_pin.sym} 161720 -3860 0 0 {name=p161260 lab=_45199_/B }
C {devices/lab_pin.sym} 161840 -3880 0 1 {name=p161261 lab=_45199_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -3880 0 0 {name=X_45199_ }
C {devices/lab_pin.sym} 161720 -3780 0 0 {name=p161262 lab=_61962_/X }
C {devices/lab_pin.sym} 161720 -3740 0 0 {name=p161263 lab=_61945_/X }
C {devices/lab_pin.sym} 161720 -3700 0 0 {name=p161264 lab=_58478_/A }
C {devices/lab_pin.sym} 161720 -3660 0 0 {name=p161265 lab=_61947_/D }
C {devices/lab_pin.sym} 161840 -3720 0 1 {name=p161266 lab=_62004_/X }
C {sky130_stdcells/and4_4.sym} 161780 -3720 0 0 {name=X_62004_ }
C {devices/lab_pin.sym} 161720 -3580 0 0 {name=p161267 lab=_79845_/X }
C {devices/lab_pin.sym} 161720 -3540 0 0 {name=p161268 lab=_79860_/B }
C {devices/lab_pin.sym} 161840 -3560 0 1 {name=p161269 lab=_79866_/B }
C {sky130_stdcells/xnor2_4.sym} 161780 -3560 0 0 {name=X_79847_ }
C {devices/lab_pin.sym} 161700 -3460 0 0 {name=p161270 lab=_86953_/Q }
C {devices/lab_pin.sym} 161700 -3420 0 0 {name=p161271 lab=_67788_/X }
C {devices/lab_pin.sym} 161700 -3380 0 0 {name=p161272 lab=_67789_/X }
C {devices/lab_pin.sym} 161700 -3340 0 0 {name=p161273 lab=_67860_/X }
C {devices/lab_pin.sym} 161860 -3400 0 1 {name=p161274 lab=_67861_/X }
C {sky130_stdcells/a211o_4.sym} 161780 -3400 0 0 {name=X_67861_ }
C {devices/lab_pin.sym} 161740 -3250 0 0 {name=p161275 lab=_62737_/A }
C {devices/lab_pin.sym} 161820 -3250 0 1 {name=p161276 lab=_60197_/C }
C {sky130_stdcells/buf_2.sym} 161780 -3250 0 0 {name=X_60196_ }
C {devices/lab_pin.sym} 161740 -3130 0 0 {name=p161277 lab=clkbuf_9_315_0_CLK/A }
C {devices/lab_pin.sym} 161820 -3130 0 1 {name=p161278 lab=clkbuf_9_314_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 161780 -3130 0 0 {name=Xclkbuf_9_314_0_CLK }
C {devices/lab_pin.sym} 161700 -3030 0 0 {name=p161279 lab=_69167_/X }
C {devices/lab_pin.sym} 161700 -2990 0 0 {name=p161280 lab=_69170_/X }
C {devices/lab_pin.sym} 161700 -2950 0 0 {name=p161281 lab=_69575_/X }
C {devices/lab_pin.sym} 161860 -2990 0 1 {name=p161282 lab=_69600_/Y }
C {sky130_stdcells/a21oi_4.sym} 161780 -2990 0 0 {name=X_69600_ }
C {devices/lab_pin.sym} 161700 -2870 0 0 {name=p161283 lab=_66809_/X }
C {devices/lab_pin.sym} 161700 -2830 0 0 {name=p161284 lab=_66811_/X }
C {devices/lab_pin.sym} 161700 -2790 0 0 {name=p161285 lab=_66787_/X }
C {devices/lab_pin.sym} 161860 -2830 0 1 {name=p161286 lab=_66815_/A }
C {sky130_stdcells/a21o_4.sym} 161780 -2830 0 0 {name=X_66812_ }
C {devices/lab_pin.sym} 161720 -2700 0 0 {name=p161287 lab=_49048_/A }
C {devices/lab_pin.sym} 161720 -2660 0 0 {name=p161288 lab=_48958_/B }
C {devices/lab_pin.sym} 161840 -2680 0 1 {name=p161289 lab=_50599_/A }
C {sky130_stdcells/nor2_4.sym} 161780 -2680 0 0 {name=X_48958_ }
C {devices/lab_pin.sym} 161720 -2560 0 0 {name=p161290 lab=_67792_/A }
C {devices/lab_pin.sym} 161720 -2520 0 0 {name=p161291 lab=_67791_/X }
C {devices/lab_pin.sym} 161840 -2540 0 1 {name=p161292 lab=_67792_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -2540 0 0 {name=X_67792_ }
C {devices/lab_pin.sym} 161720 -2420 0 0 {name=p161293 lab=_79762_/X }
C {devices/lab_pin.sym} 161720 -2380 0 0 {name=p161294 lab=_79766_/B }
C {devices/lab_pin.sym} 161840 -2400 0 1 {name=p161295 lab=_79778_/X }
C {sky130_stdcells/or2_4.sym} 161780 -2400 0 0 {name=X_79778_ }
C {devices/lab_pin.sym} 161740 -2270 0 0 {name=p161296 lab=clkbuf_9_104_0_CLK/X }
C {devices/lab_pin.sym} 161820 -2270 0 1 {name=p161297 lab=_84508_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 161780 -2270 0 0 {name=Xclkbuf_10_208_0_CLK }
C {devices/lab_pin.sym} 161720 -2160 0 0 {name=p161298 lab=_69956_/A }
C {devices/lab_pin.sym} 161720 -2120 0 0 {name=p161299 lab=_69531_/B }
C {devices/lab_pin.sym} 161840 -2140 0 1 {name=p161300 lab=_69531_/X }
C {sky130_stdcells/and2_4.sym} 161780 -2140 0 0 {name=X_69531_ }
C {devices/lab_pin.sym} 161700 -2030 0 0 {name=p161301 lab=_47902_/Y }
C {devices/lab_pin.sym} 161700 -1990 0 0 {name=p161302 lab=_47903_/X }
C {devices/lab_pin.sym} 161700 -1950 0 0 {name=p161303 lab=_47908_/X }
C {devices/lab_pin.sym} 161860 -1990 0 1 {name=p161304 lab=_86587_/D }
C {sky130_stdcells/a21oi_4.sym} 161780 -1990 0 0 {name=X_47909_ }
C {devices/lab_pin.sym} 161720 -1860 0 0 {name=p161305 lab=_66743_/A }
C {devices/lab_pin.sym} 161720 -1820 0 0 {name=p161306 lab=_66742_/X }
C {devices/lab_pin.sym} 161840 -1840 0 1 {name=p161307 lab=_66743_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -1840 0 0 {name=X_66743_ }
C {devices/lab_pin.sym} 161740 -1710 0 0 {name=p161308 lab=clkbuf_9_419_0_CLK/X }
C {devices/lab_pin.sym} 161820 -1710 0 1 {name=p161309 lab=_82973_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 161780 -1710 0 0 {name=Xclkbuf_10_838_0_CLK }
C {devices/lab_pin.sym} 161720 -1600 0 0 {name=p161310 lab=_78729_/A }
C {devices/lab_pin.sym} 161720 -1560 0 0 {name=p161311 lab=_82686_/D }
C {devices/lab_pin.sym} 161840 -1580 0 1 {name=p161312 lab=_78732_/B }
C {sky130_stdcells/nor2_4.sym} 161780 -1580 0 0 {name=X_78729_ }
C {devices/lab_pin.sym} 161740 -1450 0 0 {name=p161313 lab=_64032_/A }
C {devices/lab_pin.sym} 161820 -1450 0 1 {name=p161314 lab=_63955_/X }
C {sky130_stdcells/buf_2.sym} 161780 -1450 0 0 {name=X_63955_ }
C {devices/lab_pin.sym} 161720 -1340 0 0 {name=p161315 lab=_48695_/A }
C {devices/lab_pin.sym} 161720 -1300 0 0 {name=p161316 lab=_48889_/B }
C {devices/lab_pin.sym} 161840 -1320 0 1 {name=p161317 lab=_48889_/Y }
C {sky130_stdcells/nand2_4.sym} 161780 -1320 0 0 {name=X_48889_ }
C {devices/lab_pin.sym} 161700 -1210 0 0 {name=p161318 lab=_50917_/Y }
C {devices/lab_pin.sym} 161700 -1170 0 0 {name=p161319 lab=_50902_/X }
C {devices/lab_pin.sym} 161700 -1130 0 0 {name=p161320 lab=_50919_/X }
C {devices/lab_pin.sym} 161860 -1170 0 1 {name=p161321 lab=_50920_/Y }
C {sky130_stdcells/a21oi_4.sym} 161780 -1170 0 0 {name=X_50920_ }
C {devices/lab_pin.sym} 161690 -1030 0 0 {name=p161322 lab=_84003_/CLK }
C {devices/lab_pin.sym} 161690 -1010 0 0 {name=p161323 lab=_81740_/D }
C {devices/lab_pin.sym} 161870 -1030 0 1 {name=p161324 lab=_81740_/Q }
C {sky130_stdcells/dfxtp_4.sym} 161780 -1020 0 0 {name=X_81740_ }
C {devices/lab_pin.sym} 161700 -910 0 0 {name=p161325 lab=_63630_/A }
C {devices/lab_pin.sym} 161700 -870 0 0 {name=p161326 lab=_62875_/X }
C {devices/lab_pin.sym} 161700 -830 0 0 {name=p161327 lab=_62905_/Y }
C {devices/lab_pin.sym} 161860 -870 0 1 {name=p161328 lab=_62906_/X }
C {sky130_stdcells/o21a_4.sym} 161780 -870 0 0 {name=X_62906_ }
C {devices/lab_pin.sym} 161700 -750 0 0 {name=p161329 lab=_68946_/X }
C {devices/lab_pin.sym} 161700 -710 0 0 {name=p161330 lab=_68950_/X }
C {devices/lab_pin.sym} 161700 -670 0 0 {name=p161331 lab=_69418_/X }
C {devices/lab_pin.sym} 161860 -710 0 1 {name=p161332 lab=_69462_/Y }
C {sky130_stdcells/a21oi_4.sym} 161780 -710 0 0 {name=X_69462_ }
C {devices/lab_pin.sym} 162660 -42150 0 0 {name=p161333 lab=clkbuf_9_329_0_CLK/A }
C {devices/lab_pin.sym} 162740 -42150 0 1 {name=p161334 lab=clkbuf_9_329_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 162700 -42150 0 0 {name=Xclkbuf_9_329_0_CLK }
C {devices/lab_pin.sym} 162660 -42030 0 0 {name=p161335 lab=_66673_/X }
C {devices/lab_pin.sym} 162740 -42030 0 1 {name=p161336 lab=_66794_/A }
C {sky130_stdcells/buf_2.sym} 162700 -42030 0 0 {name=X_66674_ }
C {devices/lab_pin.sym} 162660 -41910 0 0 {name=p161337 lab=_60915_/X }
C {devices/lab_pin.sym} 162740 -41910 0 1 {name=p161338 lab=_63902_/B }
C {sky130_stdcells/buf_2.sym} 162700 -41910 0 0 {name=X_63886_ }
C {devices/lab_pin.sym} 162620 -41810 0 0 {name=p161339 lab=_83976_/Q }
C {devices/lab_pin.sym} 162620 -41770 0 0 {name=p161340 lab=_68338_/X }
C {devices/lab_pin.sym} 162620 -41730 0 0 {name=p161341 lab=_68412_/X }
C {devices/lab_pin.sym} 162780 -41770 0 1 {name=p161342 lab=_68413_/X }
C {sky130_stdcells/a21bo_4.sym} 162700 -41770 0 0 {name=X_68413_ }
C {devices/lab_pin.sym} 162620 -41660 0 0 {name=p161343 lab=_65623_/X }
C {devices/lab_pin.sym} 162620 -41620 0 0 {name=p161344 lab=_86196_/Q }
C {devices/lab_pin.sym} 162620 -41580 0 0 {name=p161345 lab=_65517_/X }
C {devices/lab_pin.sym} 162620 -41540 0 0 {name=p161346 lab=_65624_/X }
C {devices/lab_pin.sym} 162780 -41600 0 1 {name=p161347 lab=_65625_/X }
C {sky130_stdcells/a211o_4.sym} 162700 -41600 0 0 {name=X_65625_ }
C {devices/lab_pin.sym} 162620 -41470 0 0 {name=p161348 lab=_50848_/Y }
C {devices/lab_pin.sym} 162620 -41430 0 0 {name=p161349 lab=_50849_/X }
C {devices/lab_pin.sym} 162620 -41390 0 0 {name=p161350 lab=_50850_/Y }
C {devices/lab_pin.sym} 162780 -41430 0 1 {name=p161351 lab=_50851_/Y }
C {sky130_stdcells/a21boi_4.sym} 162700 -41430 0 0 {name=X_50851_ }
C {devices/lab_pin.sym} 162620 -41330 0 0 {name=p161352 lab=_62830_/Y }
C {devices/lab_pin.sym} 162620 -41290 0 0 {name=p161353 lab=_62831_/X }
C {devices/lab_pin.sym} 162620 -41250 0 0 {name=p161354 lab=_62833_/Y }
C {devices/lab_pin.sym} 162620 -41210 0 0 {name=p161355 lab=_62834_/Y }
C {devices/lab_pin.sym} 162620 -41180 0 0 {name=p161356 lab=_62836_/X }
C {devices/lab_pin.sym} 162780 -41250 0 1 {name=p161357 lab=_62837_/X }
C {sky130_stdcells/a41o_4.sym} 162700 -41250 0 0 {name=X_62837_ }
C {devices/lab_pin.sym} 162610 -41090 0 0 {name=p161358 lab=_81671_/CLK }
C {devices/lab_pin.sym} 162610 -41070 0 0 {name=p161359 lab=_79982_/X }
C {devices/lab_pin.sym} 162790 -41090 0 1 {name=p161360 lab=_81671_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -41080 0 0 {name=X_81671_ }
C {devices/lab_pin.sym} 162660 -40950 0 0 {name=p161361 lab=_69245_/A }
C {devices/lab_pin.sym} 162740 -40950 0 1 {name=p161362 lab=_69393_/X }
C {sky130_stdcells/buf_2.sym} 162700 -40950 0 0 {name=X_69393_ }
C {devices/lab_pin.sym} 162610 -40830 0 0 {name=p161363 lab=_83380_/CLK }
C {devices/lab_pin.sym} 162610 -40810 0 0 {name=p161364 lab=_83410_/D }
C {devices/lab_pin.sym} 162790 -40830 0 1 {name=p161365 lab=_83410_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -40820 0 0 {name=X_83410_ }
C {devices/lab_pin.sym} 162640 -40700 0 0 {name=p161366 lab=_80622_/A }
C {devices/lab_pin.sym} 162640 -40660 0 0 {name=p161367 lab=_80622_/B }
C {devices/lab_pin.sym} 162760 -40680 0 1 {name=p161368 lab=_80624_/A }
C {sky130_stdcells/nand2_4.sym} 162700 -40680 0 0 {name=X_80622_ }
C {devices/lab_pin.sym} 162620 -40580 0 0 {name=p161369 lab=_88019_/Q }
C {devices/lab_pin.sym} 162620 -40540 0 0 {name=p161370 lab=_69796_/A }
C {devices/lab_pin.sym} 162620 -40500 0 0 {name=p161371 lab=_66295_/X }
C {devices/lab_pin.sym} 162620 -40460 0 0 {name=p161372 lab=_68343_/X }
C {devices/lab_pin.sym} 162780 -40520 0 1 {name=p161373 lab=_68344_/X }
C {sky130_stdcells/a211o_4.sym} 162700 -40520 0 0 {name=X_68344_ }
C {devices/lab_pin.sym} 162640 -40390 0 0 {name=p161374 lab=_65553_/X }
C {devices/lab_pin.sym} 162640 -40350 0 0 {name=p161375 lab=_65663_/B }
C {devices/lab_pin.sym} 162640 -40310 0 0 {name=p161376 lab=_65556_/C }
C {devices/lab_pin.sym} 162760 -40350 0 1 {name=p161377 lab=_65556_/Y }
C {sky130_stdcells/nand3_4.sym} 162700 -40350 0 0 {name=X_65556_ }
C {devices/lab_pin.sym} 162640 -40230 0 0 {name=p161378 lab=_52050_/A }
C {devices/lab_pin.sym} 162640 -40190 0 0 {name=p161379 lab=_53620_/B }
C {devices/lab_pin.sym} 162640 -40150 0 0 {name=p161380 lab=_53620_/C }
C {devices/lab_pin.sym} 162760 -40190 0 1 {name=p161381 lab=_53570_/X }
C {sky130_stdcells/and3_4.sym} 162700 -40190 0 0 {name=X_53570_ }
C {devices/lab_pin.sym} 162610 -40050 0 0 {name=p161382 lab=_84392_/CLK }
C {devices/lab_pin.sym} 162610 -40030 0 0 {name=p161383 lab=_62698_/Y }
C {devices/lab_pin.sym} 162790 -40050 0 1 {name=p161384 lab=_84390_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -40040 0 0 {name=X_84390_ }
C {devices/lab_pin.sym} 162620 -39930 0 0 {name=p161385 lab=_86134_/Q }
C {devices/lab_pin.sym} 162620 -39890 0 0 {name=p161386 lab=_50775_/X }
C {devices/lab_pin.sym} 162620 -39850 0 0 {name=p161387 lab=_50781_/Y }
C {devices/lab_pin.sym} 162780 -39890 0 1 {name=p161388 lab=_50782_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -39890 0 0 {name=X_50782_ }
C {devices/lab_pin.sym} 162660 -39750 0 0 {name=p161389 lab=_60309_/D }
C {devices/lab_pin.sym} 162740 -39750 0 1 {name=p161390 lab=_62768_/X }
C {sky130_stdcells/buf_2.sym} 162700 -39750 0 0 {name=X_62768_ }
C {devices/lab_pin.sym} 162620 -39650 0 0 {name=p161391 lab=_52519_/Y }
C {devices/lab_pin.sym} 162620 -39610 0 0 {name=p161392 lab=_52496_/X }
C {devices/lab_pin.sym} 162620 -39570 0 0 {name=p161393 lab=_52520_/X }
C {devices/lab_pin.sym} 162780 -39610 0 1 {name=p161394 lab=_52521_/Y }
C {sky130_stdcells/a21oi_4.sym} 162700 -39610 0 0 {name=X_52521_ }
C {devices/lab_pin.sym} 162620 -39510 0 0 {name=p161395 lab=_64501_/X }
C {devices/lab_pin.sym} 162620 -39470 0 0 {name=p161396 lab=_64504_/Y }
C {devices/lab_pin.sym} 162620 -39430 0 0 {name=p161397 lab=_64506_/Y }
C {devices/lab_pin.sym} 162620 -39390 0 0 {name=p161398 lab=_84871_/Q }
C {devices/lab_pin.sym} 162620 -39350 0 0 {name=p161399 lab=_64213_/X }
C {devices/lab_pin.sym} 162780 -39430 0 1 {name=p161400 lab=_64507_/Y }
C {sky130_stdcells/o32ai_4.sym} 162700 -39430 0 0 {name=X_64507_ }
C {devices/lab_pin.sym} 162610 -39270 0 0 {name=p161401 lab=_83491_/CLK }
C {devices/lab_pin.sym} 162610 -39250 0 0 {name=p161402 lab=_83341_/D }
C {devices/lab_pin.sym} 162790 -39270 0 1 {name=p161403 lab=_59437_/B }
C {sky130_stdcells/dfxtp_4.sym} 162700 -39260 0 0 {name=X_83341_ }
C {devices/lab_pin.sym} 162660 -39130 0 0 {name=p161404 lab=_61719_/A }
C {devices/lab_pin.sym} 162740 -39130 0 1 {name=p161405 lab=_61719_/X }
C {sky130_stdcells/buf_2.sym} 162700 -39130 0 0 {name=X_61719_ }
C {devices/lab_pin.sym} 162620 -39030 0 0 {name=p161406 lab=_80537_/X }
C {devices/lab_pin.sym} 162620 -38990 0 0 {name=p161407 lab=_80541_/B }
C {devices/lab_pin.sym} 162620 -38950 0 0 {name=p161408 lab=_80552_/X }
C {devices/lab_pin.sym} 162780 -38990 0 1 {name=p161409 lab=_80553_/X }
C {sky130_stdcells/a21o_4.sym} 162700 -38990 0 0 {name=X_80553_ }
C {devices/lab_pin.sym} 162620 -38870 0 0 {name=p161410 lab=_82643_/D }
C {devices/lab_pin.sym} 162620 -38830 0 0 {name=p161411 lab=_68259_/X }
C {devices/lab_pin.sym} 162620 -38790 0 0 {name=p161412 lab=_68274_/X }
C {devices/lab_pin.sym} 162780 -38830 0 1 {name=p161413 lab=_83995_/D }
C {sky130_stdcells/a21bo_4.sym} 162700 -38830 0 0 {name=X_68275_ }
C {devices/lab_pin.sym} 162640 -38700 0 0 {name=p161414 lab=_65667_/A }
C {devices/lab_pin.sym} 162640 -38660 0 0 {name=p161415 lab=_85885_/Q }
C {devices/lab_pin.sym} 162760 -38680 0 1 {name=p161416 lab=_65487_/X }
C {sky130_stdcells/and2_4.sym} 162700 -38680 0 0 {name=X_65487_ }
C {devices/lab_pin.sym} 162660 -38550 0 0 {name=p161417 lab=_60211_/A }
C {devices/lab_pin.sym} 162740 -38550 0 1 {name=p161418 lab=_62699_/X }
C {sky130_stdcells/buf_2.sym} 162700 -38550 0 0 {name=X_62699_ }
C {devices/lab_pin.sym} 162640 -38440 0 0 {name=p161419 lab=_55237_/Y }
C {devices/lab_pin.sym} 162640 -38400 0 0 {name=p161420 lab=_55240_/B }
C {devices/lab_pin.sym} 162760 -38420 0 1 {name=p161421 lab=_55241_/B }
C {sky130_stdcells/nor2_4.sym} 162700 -38420 0 0 {name=X_55240_ }
C {devices/lab_pin.sym} 162660 -38290 0 0 {name=p161422 lab=_67226_/A }
C {devices/lab_pin.sym} 162740 -38290 0 1 {name=p161423 lab=_67226_/X }
C {sky130_stdcells/buf_2.sym} 162700 -38290 0 0 {name=X_67226_ }
C {devices/lab_pin.sym} 162610 -38170 0 0 {name=p161424 lab=_85741_/CLK }
C {devices/lab_pin.sym} 162610 -38150 0 0 {name=p161425 lab=_86060_/D }
C {devices/lab_pin.sym} 162790 -38170 0 1 {name=p161426 lab=_86060_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -38160 0 0 {name=X_86060_ }
C {devices/lab_pin.sym} 162640 -38040 0 0 {name=p161427 lab=_52466_/A }
C {devices/lab_pin.sym} 162640 -38000 0 0 {name=p161428 lab=_53971_/B }
C {devices/lab_pin.sym} 162760 -38020 0 1 {name=p161429 lab=_52452_/Y }
C {sky130_stdcells/nand2_4.sym} 162700 -38020 0 0 {name=X_52452_ }
C {devices/lab_pin.sym} 162640 -37910 0 0 {name=p161430 lab=_64515_/A }
C {devices/lab_pin.sym} 162640 -37870 0 0 {name=p161431 lab=_84862_/Q }
C {devices/lab_pin.sym} 162640 -37830 0 0 {name=p161432 lab=_64515_/C }
C {devices/lab_pin.sym} 162760 -37870 0 1 {name=p161433 lab=_64438_/Y }
C {sky130_stdcells/nand3_4.sym} 162700 -37870 0 0 {name=X_64438_ }
C {devices/lab_pin.sym} 162610 -37730 0 0 {name=p161434 lab=_83627_/CLK }
C {devices/lab_pin.sym} 162610 -37710 0 0 {name=p161435 lab=_83272_/D }
C {devices/lab_pin.sym} 162790 -37730 0 1 {name=p161436 lab=_72224_/A }
C {sky130_stdcells/dfxtp_4.sym} 162700 -37720 0 0 {name=X_83272_ }
C {devices/lab_pin.sym} 162640 -37600 0 0 {name=p161437 lab=_80484_/A }
C {devices/lab_pin.sym} 162640 -37560 0 0 {name=p161438 lab=_84316_/Q }
C {devices/lab_pin.sym} 162760 -37580 0 1 {name=p161439 lab=_80494_/B }
C {sky130_stdcells/xor2_4.sym} 162700 -37580 0 0 {name=X_80484_ }
C {devices/lab_pin.sym} 162610 -37450 0 0 {name=p161440 lab=_85075_/CLK }
C {devices/lab_pin.sym} 162610 -37430 0 0 {name=p161441 lab=_85011_/D }
C {devices/lab_pin.sym} 162790 -37450 0 1 {name=p161442 lab=_85011_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -37440 0 0 {name=X_85011_ }
C {devices/lab_pin.sym} 162660 -37310 0 0 {name=p161443 lab=_51211_/A }
C {devices/lab_pin.sym} 162740 -37310 0 1 {name=p161444 lab=_51403_/X }
C {sky130_stdcells/buf_2.sym} 162700 -37310 0 0 {name=X_51403_ }
C {devices/lab_pin.sym} 162610 -37190 0 0 {name=p161445 lab=_81839_/CLK }
C {devices/lab_pin.sym} 162610 -37170 0 0 {name=p161446 lab=_82255_/Q }
C {devices/lab_pin.sym} 162790 -37190 0 1 {name=p161447 lab=_82223_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -37180 0 0 {name=X_82223_ }
C {devices/lab_pin.sym} 162620 -37070 0 0 {name=p161448 lab=_55167_/X }
C {devices/lab_pin.sym} 162620 -37030 0 0 {name=p161449 lab=_55170_/X }
C {devices/lab_pin.sym} 162620 -36990 0 0 {name=p161450 lab=_44109_/X }
C {devices/lab_pin.sym} 162780 -37030 0 1 {name=p161451 lab=_55171_/X }
C {sky130_stdcells/a21o_4.sym} 162700 -37030 0 0 {name=X_55171_ }
C {devices/lab_pin.sym} 162640 -36900 0 0 {name=p161452 lab=_67133_/A }
C {devices/lab_pin.sym} 162640 -36860 0 0 {name=p161453 lab=_86782_/Q }
C {devices/lab_pin.sym} 162760 -36880 0 1 {name=p161454 lab=_67157_/X }
C {sky130_stdcells/and2_4.sym} 162700 -36880 0 0 {name=X_67157_ }
C {devices/lab_pin.sym} 162640 -36760 0 0 {name=p161455 lab=_52373_/X }
C {devices/lab_pin.sym} 162640 -36720 0 0 {name=p161456 lab=_49125_/X }
C {devices/lab_pin.sym} 162760 -36740 0 1 {name=p161457 lab=_52383_/Y }
C {sky130_stdcells/nand2_4.sym} 162700 -36740 0 0 {name=X_52383_ }
C {devices/lab_pin.sym} 162620 -36630 0 0 {name=p161458 lab=_58331_/A }
C {devices/lab_pin.sym} 162620 -36590 0 0 {name=p161459 lab=_64367_/X }
C {devices/lab_pin.sym} 162620 -36550 0 0 {name=p161460 lab=_64368_/Y }
C {devices/lab_pin.sym} 162780 -36590 0 1 {name=p161461 lab=_64369_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -36590 0 0 {name=X_64369_ }
C {devices/lab_pin.sym} 162620 -36470 0 0 {name=p161462 lab=_85500_/Q }
C {devices/lab_pin.sym} 162620 -36430 0 0 {name=p161463 lab=_54113_/X }
C {devices/lab_pin.sym} 162620 -36390 0 0 {name=p161464 lab=_54121_/Y }
C {devices/lab_pin.sym} 162780 -36430 0 1 {name=p161465 lab=_54122_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -36430 0 0 {name=X_54122_ }
C {devices/lab_pin.sym} 162660 -36290 0 0 {name=p161466 lab=_84156_/Q }
C {devices/lab_pin.sym} 162740 -36290 0 1 {name=p161467 lab=_66109_/C }
C {sky130_stdcells/inv_2.sym} 162700 -36290 0 0 {name=X_66108_ }
C {devices/lab_pin.sym} 162660 -36170 0 0 {name=p161468 lab=_51790_/A }
C {devices/lab_pin.sym} 162740 -36170 0 1 {name=p161469 lab=_51350_/A }
C {sky130_stdcells/buf_2.sym} 162700 -36170 0 0 {name=X_51334_ }
C {devices/lab_pin.sym} 162610 -36050 0 0 {name=p161470 lab=_84220_/CLK }
C {devices/lab_pin.sym} 162610 -36030 0 0 {name=p161471 lab=_66247_/C }
C {devices/lab_pin.sym} 162790 -36050 0 1 {name=p161472 lab=_82154_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -36040 0 0 {name=X_82154_ }
C {devices/lab_pin.sym} 162620 -35940 0 0 {name=p161473 lab=_87114_/Q }
C {devices/lab_pin.sym} 162620 -35900 0 0 {name=p161474 lab=_66988_/X }
C {devices/lab_pin.sym} 162620 -35860 0 0 {name=p161475 lab=_67040_/X }
C {devices/lab_pin.sym} 162620 -35820 0 0 {name=p161476 lab=_67087_/X }
C {devices/lab_pin.sym} 162780 -35880 0 1 {name=p161477 lab=_67088_/X }
C {sky130_stdcells/a211o_4.sym} 162700 -35880 0 0 {name=X_67088_ }
C {devices/lab_pin.sym} 162610 -35730 0 0 {name=p161478 lab=_81104_/CLK }
C {devices/lab_pin.sym} 162610 -35710 0 0 {name=p161479 lab=_79718_/X }
C {devices/lab_pin.sym} 162790 -35730 0 1 {name=p161480 lab=_81105_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -35720 0 0 {name=X_81105_ }
C {devices/lab_pin.sym} 162620 -35610 0 0 {name=p161481 lab=_58891_/X }
C {devices/lab_pin.sym} 162620 -35570 0 0 {name=p161482 lab=_86085_/Q }
C {devices/lab_pin.sym} 162620 -35530 0 0 {name=p161483 lab=_58929_/X }
C {devices/lab_pin.sym} 162780 -35570 0 1 {name=p161484 lab=_58930_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -35570 0 0 {name=X_58930_ }
C {devices/lab_pin.sym} 162620 -35450 0 0 {name=p161485 lab=_54050_/Y }
C {devices/lab_pin.sym} 162620 -35410 0 0 {name=p161486 lab=_54051_/X }
C {devices/lab_pin.sym} 162620 -35370 0 0 {name=p161487 lab=_54052_/X }
C {devices/lab_pin.sym} 162780 -35410 0 1 {name=p161488 lab=_54053_/Y }
C {sky130_stdcells/a21oi_4.sym} 162700 -35410 0 0 {name=X_54053_ }
C {devices/lab_pin.sym} 162620 -35290 0 0 {name=p161489 lab=_66036_/X }
C {devices/lab_pin.sym} 162620 -35250 0 0 {name=p161490 lab=_66038_/X }
C {devices/lab_pin.sym} 162620 -35210 0 0 {name=p161491 lab=_65880_/X }
C {devices/lab_pin.sym} 162780 -35250 0 1 {name=p161492 lab=_66043_/A }
C {sky130_stdcells/a21o_4.sym} 162700 -35250 0 0 {name=X_66039_ }
C {devices/lab_pin.sym} 162660 -35110 0 0 {name=p161493 lab=_51265_/A }
C {devices/lab_pin.sym} 162740 -35110 0 1 {name=p161494 lab=_51266_/B }
C {sky130_stdcells/buf_2.sym} 162700 -35110 0 0 {name=X_51265_ }
C {devices/lab_pin.sym} 162610 -34990 0 0 {name=p161495 lab=_86965_/CLK }
C {devices/lab_pin.sym} 162610 -34970 0 0 {name=p161496 lab=_86962_/D }
C {devices/lab_pin.sym} 162790 -34990 0 1 {name=p161497 lab=_86962_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -34980 0 0 {name=X_86962_ }
C {devices/lab_pin.sym} 162610 -34850 0 0 {name=p161498 lab=_81989_/CLK }
C {devices/lab_pin.sym} 162610 -34830 0 0 {name=p161499 lab=_77265_/B }
C {devices/lab_pin.sym} 162790 -34850 0 1 {name=p161500 lab=_82085_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -34840 0 0 {name=X_82085_ }
C {devices/lab_pin.sym} 162620 -34730 0 0 {name=p161501 lab=_53000_/Y }
C {devices/lab_pin.sym} 162620 -34690 0 0 {name=p161502 lab=_53001_/X }
C {devices/lab_pin.sym} 162620 -34650 0 0 {name=p161503 lab=_53003_/X }
C {devices/lab_pin.sym} 162780 -34690 0 1 {name=p161504 lab=_53004_/Y }
C {sky130_stdcells/a21oi_4.sym} 162700 -34690 0 0 {name=X_53004_ }
C {devices/lab_pin.sym} 162620 -34570 0 0 {name=p161505 lab=_86241_/Q }
C {devices/lab_pin.sym} 162620 -34530 0 0 {name=p161506 lab=_41872_/X }
C {devices/lab_pin.sym} 162620 -34490 0 0 {name=p161507 lab=_50215_/X }
C {devices/lab_pin.sym} 162780 -34530 0 1 {name=p161508 lab=_50217_/A }
C {sky130_stdcells/o21ai_4.sym} 162700 -34530 0 0 {name=X_50216_ }
C {devices/lab_pin.sym} 162610 -34390 0 0 {name=p161509 lab=_85915_/CLK }
C {devices/lab_pin.sym} 162610 -34370 0 0 {name=p161510 lab=_51978_/Y }
C {devices/lab_pin.sym} 162790 -34390 0 1 {name=p161511 lab=_66022_/B }
C {sky130_stdcells/dfxtp_4.sym} 162700 -34380 0 0 {name=X_85913_ }
C {devices/lab_pin.sym} 162610 -34250 0 0 {name=p161512 lab=_82084_/CLK }
C {devices/lab_pin.sym} 162610 -34230 0 0 {name=p161513 lab=_81036_/D }
C {devices/lab_pin.sym} 162790 -34250 0 1 {name=p161514 lab=_81036_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -34240 0 0 {name=X_81036_ }
C {devices/lab_pin.sym} 162620 -34130 0 0 {name=p161515 lab=_58846_/X }
C {devices/lab_pin.sym} 162620 -34090 0 0 {name=p161516 lab=_85770_/Q }
C {devices/lab_pin.sym} 162620 -34050 0 0 {name=p161517 lab=_58847_/X }
C {devices/lab_pin.sym} 162780 -34090 0 1 {name=p161518 lab=_58861_/X }
C {sky130_stdcells/o21a_4.sym} 162700 -34090 0 0 {name=X_58861_ }
C {devices/lab_pin.sym} 162660 -33950 0 0 {name=p161519 lab=_51170_/A }
C {devices/lab_pin.sym} 162740 -33950 0 1 {name=p161520 lab=_51197_/C }
C {sky130_stdcells/buf_2.sym} 162700 -33950 0 0 {name=X_51196_ }
C {devices/lab_pin.sym} 162610 -33830 0 0 {name=p161521 lab=_86896_/CLK }
C {devices/lab_pin.sym} 162610 -33810 0 0 {name=p161522 lab=_45186_/Y }
C {devices/lab_pin.sym} 162790 -33830 0 1 {name=p161523 lab=_64420_/B }
C {sky130_stdcells/dfxtp_4.sym} 162700 -33820 0 0 {name=X_86893_ }
C {devices/lab_pin.sym} 162620 -33710 0 0 {name=p161524 lab=_57705_/X }
C {devices/lab_pin.sym} 162620 -33670 0 0 {name=p161525 lab=_85500_/Q }
C {devices/lab_pin.sym} 162620 -33630 0 0 {name=p161526 lab=_57736_/X }
C {devices/lab_pin.sym} 162780 -33670 0 1 {name=p161527 lab=_57812_/X }
C {sky130_stdcells/o21a_4.sym} 162700 -33670 0 0 {name=X_57812_ }
C {devices/lab_pin.sym} 162640 -33550 0 0 {name=p161528 lab=_52355_/A }
C {devices/lab_pin.sym} 162640 -33510 0 0 {name=p161529 lab=_50082_/B }
C {devices/lab_pin.sym} 162640 -33470 0 0 {name=p161530 lab=_50147_/C }
C {devices/lab_pin.sym} 162760 -33510 0 1 {name=p161531 lab=_50147_/X }
C {sky130_stdcells/and3_4.sym} 162700 -33510 0 0 {name=X_50147_ }
C {devices/lab_pin.sym} 162610 -33370 0 0 {name=p161532 lab=_85535_/CLK }
C {devices/lab_pin.sym} 162610 -33350 0 0 {name=p161533 lab=_52333_/Y }
C {devices/lab_pin.sym} 162790 -33370 0 1 {name=p161534 lab=_85844_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -33360 0 0 {name=X_85844_ }
C {devices/lab_pin.sym} 162660 -33230 0 0 {name=p161535 lab=_84799_/Q }
C {devices/lab_pin.sym} 162740 -33230 0 1 {name=p161536 lab=_58792_/Y }
C {sky130_stdcells/inv_2.sym} 162700 -33230 0 0 {name=X_58792_ }
C {devices/lab_pin.sym} 162620 -33140 0 0 {name=p161537 lab=_84951_/Q }
C {devices/lab_pin.sym} 162620 -33100 0 0 {name=p161538 lab=_57691_/X }
C {devices/lab_pin.sym} 162620 -33060 0 0 {name=p161539 lab=_57735_/X }
C {devices/lab_pin.sym} 162620 -33020 0 0 {name=p161540 lab=_57742_/X }
C {devices/lab_pin.sym} 162780 -33080 0 1 {name=p161541 lab=_84951_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 162700 -33080 0 0 {name=X_57743_ }
C {devices/lab_pin.sym} 162620 -32950 0 0 {name=p161542 lab=_69307_/X }
C {devices/lab_pin.sym} 162620 -32910 0 0 {name=p161543 lab=_69310_/X }
C {devices/lab_pin.sym} 162620 -32870 0 0 {name=p161544 lab=_69728_/X }
C {devices/lab_pin.sym} 162780 -32910 0 1 {name=p161545 lab=_69729_/Y }
C {sky130_stdcells/a21oi_4.sym} 162700 -32910 0 0 {name=X_69729_ }
C {devices/lab_pin.sym} 162640 -32790 0 0 {name=p161546 lab=_48928_/A }
C {devices/lab_pin.sym} 162640 -32750 0 0 {name=p161547 lab=_50082_/B }
C {devices/lab_pin.sym} 162640 -32710 0 0 {name=p161548 lab=_50059_/C }
C {devices/lab_pin.sym} 162760 -32750 0 1 {name=p161549 lab=_50078_/X }
C {sky130_stdcells/and3_4.sym} 162700 -32750 0 0 {name=X_50078_ }
C {devices/lab_pin.sym} 162640 -32640 0 0 {name=p161550 lab=_54955_/A }
C {devices/lab_pin.sym} 162640 -32600 0 0 {name=p161551 lab=_54955_/B }
C {devices/lab_pin.sym} 162640 -32560 0 0 {name=p161552 lab=_46617_/A }
C {devices/lab_pin.sym} 162640 -32520 0 0 {name=p161553 lab=_53261_/D }
C {devices/lab_pin.sym} 162760 -32580 0 1 {name=p161554 lab=_54955_/X }
C {sky130_stdcells/and4_4.sym} 162700 -32580 0 0 {name=X_54955_ }
C {devices/lab_pin.sym} 162610 -32430 0 0 {name=p161555 lab=_85778_/CLK }
C {devices/lab_pin.sym} 162610 -32410 0 0 {name=p161556 lab=_52676_/Y }
C {devices/lab_pin.sym} 162790 -32430 0 1 {name=p161557 lab=_85775_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -32420 0 0 {name=X_85775_ }
C {devices/lab_pin.sym} 162610 -32290 0 0 {name=p161558 lab=_82987_/CLK }
C {devices/lab_pin.sym} 162610 -32270 0 0 {name=p161559 lab=_82987_/D }
C {devices/lab_pin.sym} 162790 -32290 0 1 {name=p161560 lab=_45745_/A }
C {sky130_stdcells/dfxtp_4.sym} 162700 -32280 0 0 {name=X_82987_ }
C {devices/lab_pin.sym} 162610 -32150 0 0 {name=p161561 lab=_87520_/CLK }
C {devices/lab_pin.sym} 162610 -32130 0 0 {name=p161562 lab=_87514_/D }
C {devices/lab_pin.sym} 162790 -32150 0 1 {name=p161563 lab=_87514_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -32140 0 0 {name=X_87514_ }
C {devices/lab_pin.sym} 162660 -32010 0 0 {name=p161564 lab=_88105_/Q }
C {devices/lab_pin.sym} 162740 -32010 0 1 {name=p161565 lab=_41920_/Y }
C {sky130_stdcells/inv_2.sym} 162700 -32010 0 0 {name=X_41920_ }
C {devices/lab_pin.sym} 162640 -31900 0 0 {name=p161566 lab=_53902_/A }
C {devices/lab_pin.sym} 162640 -31860 0 0 {name=p161567 lab=_72079_/B }
C {devices/lab_pin.sym} 162760 -31880 0 1 {name=p161568 lab=_53906_/Y }
C {sky130_stdcells/nand2_4.sym} 162700 -31880 0 0 {name=X_53906_ }
C {devices/lab_pin.sym} 162660 -31750 0 0 {name=p161569 lab=_72739_/X }
C {devices/lab_pin.sym} 162740 -31750 0 1 {name=p161570 lab=_73007_/A }
C {sky130_stdcells/buf_2.sym} 162700 -31750 0 0 {name=X_72740_ }
C {devices/lab_pin.sym} 162610 -31630 0 0 {name=p161571 lab=_84732_/CLK }
C {devices/lab_pin.sym} 162610 -31610 0 0 {name=p161572 lab=_84726_/D }
C {devices/lab_pin.sym} 162790 -31630 0 1 {name=p161573 lab=_84726_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -31620 0 0 {name=X_84726_ }
C {devices/lab_pin.sym} 162660 -31490 0 0 {name=p161574 lab=_57674_/A }
C {devices/lab_pin.sym} 162740 -31490 0 1 {name=p161575 lab=_57674_/Y }
C {sky130_stdcells/inv_2.sym} 162700 -31490 0 0 {name=X_57674_ }
C {devices/lab_pin.sym} 162660 -31370 0 0 {name=p161576 lab=clkbuf_7_91_0_CLK/A }
C {devices/lab_pin.sym} 162740 -31370 0 1 {name=p161577 lab=clkbuf_7_91_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 162700 -31370 0 0 {name=Xclkbuf_7_91_0_CLK }
C {devices/lab_pin.sym} 162610 -31250 0 0 {name=p161578 lab=_81954_/CLK }
C {devices/lab_pin.sym} 162610 -31230 0 0 {name=p161579 lab=_81938_/D }
C {devices/lab_pin.sym} 162790 -31250 0 1 {name=p161580 lab=_81938_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -31240 0 0 {name=X_81938_ }
C {devices/lab_pin.sym} 162620 -31130 0 0 {name=p161581 lab=_85359_/Q }
C {devices/lab_pin.sym} 162620 -31090 0 0 {name=p161582 lab=_54865_/X }
C {devices/lab_pin.sym} 162620 -31050 0 0 {name=p161583 lab=_54885_/Y }
C {devices/lab_pin.sym} 162780 -31090 0 1 {name=p161584 lab=_54886_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -31090 0 0 {name=X_54886_ }
C {devices/lab_pin.sym} 162660 -30950 0 0 {name=p161585 lab=_84739_/Q }
C {devices/lab_pin.sym} 162740 -30950 0 1 {name=p161586 lab=_59413_/Y }
C {sky130_stdcells/inv_2.sym} 162700 -30950 0 0 {name=X_59413_ }
C {devices/lab_pin.sym} 162620 -30860 0 0 {name=p161587 lab=_56629_/B }
C {devices/lab_pin.sym} 162620 -30820 0 0 {name=p161588 lab=_56580_/B }
C {devices/lab_pin.sym} 162620 -30780 0 0 {name=p161589 lab=_56609_/X }
C {devices/lab_pin.sym} 162620 -30740 0 0 {name=p161590 lab=_56624_/Y }
C {devices/lab_pin.sym} 162780 -30800 0 1 {name=p161591 lab=_56626_/A }
C {sky130_stdcells/a211o_4.sym} 162700 -30800 0 0 {name=X_56625_ }
C {devices/lab_pin.sym} 162610 -30650 0 0 {name=p161592 lab=_87382_/CLK }
C {devices/lab_pin.sym} 162610 -30630 0 0 {name=p161593 lab=_87445_/D }
C {devices/lab_pin.sym} 162790 -30650 0 1 {name=p161594 lab=_87445_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -30640 0 0 {name=X_87445_ }
C {devices/lab_pin.sym} 162660 -30510 0 0 {name=p161595 lab=_41851_/A }
C {devices/lab_pin.sym} 162740 -30510 0 1 {name=p161596 lab=_41851_/Y }
C {sky130_stdcells/inv_2.sym} 162700 -30510 0 0 {name=X_41851_ }
C {devices/lab_pin.sym} 162620 -30410 0 0 {name=p161597 lab=_85558_/Q }
C {devices/lab_pin.sym} 162620 -30370 0 0 {name=p161598 lab=_53816_/X }
C {devices/lab_pin.sym} 162620 -30330 0 0 {name=p161599 lab=_53836_/Y }
C {devices/lab_pin.sym} 162780 -30370 0 1 {name=p161600 lab=_53837_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -30370 0 0 {name=X_53837_ }
C {devices/lab_pin.sym} 162620 -30250 0 0 {name=p161601 lab=_83195_/Q }
C {devices/lab_pin.sym} 162620 -30210 0 0 {name=p161602 lab=_72658_/X }
C {devices/lab_pin.sym} 162620 -30170 0 0 {name=p161603 lab=_72670_/Y }
C {devices/lab_pin.sym} 162780 -30210 0 1 {name=p161604 lab=_72671_/X }
C {sky130_stdcells/a21bo_4.sym} 162700 -30210 0 0 {name=X_72671_ }
C {devices/lab_pin.sym} 162610 -30070 0 0 {name=p161605 lab=_84508_/CLK }
C {devices/lab_pin.sym} 162610 -30050 0 0 {name=p161606 lab=_84657_/D }
C {devices/lab_pin.sym} 162790 -30070 0 1 {name=p161607 lab=_79998_/A }
C {sky130_stdcells/dfxtp_4.sym} 162700 -30060 0 0 {name=X_84657_ }
C {devices/lab_pin.sym} 162610 -29930 0 0 {name=p161608 lab=_81834_/CLK }
C {devices/lab_pin.sym} 162610 -29910 0 0 {name=p161609 lab=_78060_/X }
C {devices/lab_pin.sym} 162790 -29930 0 1 {name=p161610 lab=_81869_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -29920 0 0 {name=X_81869_ }
C {devices/lab_pin.sym} 162640 -29810 0 0 {name=p161611 lab=_48464_/A }
C {devices/lab_pin.sym} 162640 -29770 0 0 {name=p161612 lab=_74395_/X }
C {devices/lab_pin.sym} 162640 -29730 0 0 {name=p161613 lab=_74421_/C }
C {devices/lab_pin.sym} 162760 -29770 0 1 {name=p161614 lab=_74410_/X }
C {sky130_stdcells/and3_4.sym} 162700 -29770 0 0 {name=X_74410_ }
C {devices/lab_pin.sym} 162660 -29630 0 0 {name=p161615 lab=_40802_/A }
C {devices/lab_pin.sym} 162740 -29630 0 1 {name=p161616 lab=_40802_/X }
C {sky130_stdcells/buf_2.sym} 162700 -29630 0 0 {name=X_40802_ }
C {devices/lab_pin.sym} 162640 -29540 0 0 {name=p161617 lab=_71867_/A }
C {devices/lab_pin.sym} 162640 -29500 0 0 {name=p161618 lab=_70667_/A }
C {devices/lab_pin.sym} 162640 -29460 0 0 {name=p161619 lab=_71215_/C }
C {devices/lab_pin.sym} 162640 -29420 0 0 {name=p161620 lab=_71622_/D }
C {devices/lab_pin.sym} 162760 -29480 0 1 {name=p161621 lab=_71622_/Y }
C {sky130_stdcells/nor4_4.sym} 162700 -29480 0 0 {name=X_71622_ }
C {devices/lab_pin.sym} 162610 -29330 0 0 {name=p161622 lab=_85837_/CLK }
C {devices/lab_pin.sym} 162610 -29310 0 0 {name=p161623 lab=_83608_/D }
C {devices/lab_pin.sym} 162790 -29330 0 1 {name=p161624 lab=_49054_/A }
C {sky130_stdcells/dfxtp_4.sym} 162700 -29320 0 0 {name=X_83608_ }
C {devices/lab_pin.sym} 162660 -29190 0 0 {name=p161625 lab=_64713_/A }
C {devices/lab_pin.sym} 162740 -29190 0 1 {name=p161626 lab=_64678_/A }
C {sky130_stdcells/buf_2.sym} 162700 -29190 0 0 {name=X_59344_ }
C {devices/lab_pin.sym} 162660 -29070 0 0 {name=p161627 lab=_44570_/A }
C {devices/lab_pin.sym} 162740 -29070 0 1 {name=p161628 lab=_44570_/Y }
C {sky130_stdcells/inv_2.sym} 162700 -29070 0 0 {name=X_44570_ }
C {devices/lab_pin.sym} 162660 -28950 0 0 {name=p161629 lab=_56556_/A }
C {devices/lab_pin.sym} 162740 -28950 0 1 {name=p161630 lab=_56556_/Y }
C {sky130_stdcells/inv_2.sym} 162700 -28950 0 0 {name=X_56556_ }
C {devices/lab_pin.sym} 162610 -28830 0 0 {name=p161631 lab=_87995_/CLK }
C {devices/lab_pin.sym} 162610 -28810 0 0 {name=p161632 lab=_43526_/X }
C {devices/lab_pin.sym} 162790 -28830 0 1 {name=p161633 lab=_87376_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -28820 0 0 {name=X_87376_ }
C {devices/lab_pin.sym} 162640 -28700 0 0 {name=p161634 lab=_75390_/A }
C {devices/lab_pin.sym} 162640 -28660 0 0 {name=p161635 lab=_75390_/B }
C {devices/lab_pin.sym} 162760 -28680 0 1 {name=p161636 lab=_75390_/X }
C {sky130_stdcells/xor2_4.sym} 162700 -28680 0 0 {name=X_75390_ }
C {devices/lab_pin.sym} 162660 -28550 0 0 {name=p161637 lab=_41781_/Y }
C {devices/lab_pin.sym} 162740 -28550 0 1 {name=p161638 lab=_41782_/X }
C {sky130_stdcells/buf_2.sym} 162700 -28550 0 0 {name=X_41782_ }
C {devices/lab_pin.sym} 162640 -28450 0 0 {name=p161639 lab=_48691_/A }
C {devices/lab_pin.sym} 162640 -28410 0 0 {name=p161640 lab=_53774_/B }
C {devices/lab_pin.sym} 162640 -28370 0 0 {name=p161641 lab=_53774_/C }
C {devices/lab_pin.sym} 162760 -28410 0 1 {name=p161642 lab=_53768_/X }
C {sky130_stdcells/and3_4.sym} 162700 -28410 0 0 {name=X_53768_ }
C {devices/lab_pin.sym} 162610 -28270 0 0 {name=p161643 lab=_84590_/CLK }
C {devices/lab_pin.sym} 162610 -28250 0 0 {name=p161644 lab=_84588_/D }
C {devices/lab_pin.sym} 162790 -28270 0 1 {name=p161645 lab=_79128_/A }
C {sky130_stdcells/dfxtp_4.sym} 162700 -28260 0 0 {name=X_84588_ }
C {devices/lab_pin.sym} 162620 -28160 0 0 {name=p161646 lab=_41797_/X }
C {devices/lab_pin.sym} 162620 -28120 0 0 {name=p161647 lab=_43513_/X }
C {devices/lab_pin.sym} 162620 -28080 0 0 {name=p161648 lab=_87379_/Q }
C {devices/lab_pin.sym} 162620 -28040 0 0 {name=p161649 lab=_43514_/X }
C {devices/lab_pin.sym} 162780 -28100 0 1 {name=p161650 lab=_43521_/X }
C {sky130_stdcells/a2bb2o_4.sym} 162700 -28100 0 0 {name=X_43521_ }
C {devices/lab_pin.sym} 162660 -27950 0 0 {name=p161651 lab=_55462_/X }
C {devices/lab_pin.sym} 162740 -27950 0 1 {name=p161652 lab=_55507_/X }
C {sky130_stdcells/buf_2.sym} 162700 -27950 0 0 {name=X_55507_ }
C {devices/lab_pin.sym} 162660 -27830 0 0 {name=p161653 lab=_45883_/B }
C {devices/lab_pin.sym} 162740 -27830 0 1 {name=p161654 lab=_74351_/A }
C {sky130_stdcells/buf_2.sym} 162700 -27830 0 0 {name=X_74341_ }
C {devices/lab_pin.sym} 162610 -27710 0 0 {name=p161655 lab=_86322_/CLK }
C {devices/lab_pin.sym} 162610 -27690 0 0 {name=p161656 lab=_49767_/Y }
C {devices/lab_pin.sym} 162790 -27710 0 1 {name=p161657 lab=_57870_/B }
C {sky130_stdcells/dfxtp_4.sym} 162700 -27700 0 0 {name=X_86327_ }
C {devices/lab_pin.sym} 162620 -27590 0 0 {name=p161658 lab=_40731_/X }
C {devices/lab_pin.sym} 162620 -27550 0 0 {name=p161659 lab=_82855_/Q }
C {devices/lab_pin.sym} 162620 -27510 0 0 {name=p161660 lab=_40732_/X }
C {devices/lab_pin.sym} 162780 -27550 0 1 {name=p161661 lab=_40733_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -27550 0 0 {name=X_40733_ }
C {devices/lab_pin.sym} 162620 -27430 0 0 {name=p161662 lab=_85767_/Q }
C {devices/lab_pin.sym} 162620 -27390 0 0 {name=p161663 lab=_52711_/X }
C {devices/lab_pin.sym} 162620 -27350 0 0 {name=p161664 lab=_52718_/Y }
C {devices/lab_pin.sym} 162780 -27390 0 1 {name=p161665 lab=_52719_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -27390 0 0 {name=X_52719_ }
C {devices/lab_pin.sym} 162620 -27270 0 0 {name=p161666 lab=_59260_/X }
C {devices/lab_pin.sym} 162620 -27230 0 0 {name=p161667 lab=_85419_/Q }
C {devices/lab_pin.sym} 162620 -27190 0 0 {name=p161668 lab=_59274_/X }
C {devices/lab_pin.sym} 162780 -27230 0 1 {name=p161669 lab=_59275_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -27230 0 0 {name=X_59275_ }
C {devices/lab_pin.sym} 162640 -27110 0 0 {name=p161670 lab=_70692_/A }
C {devices/lab_pin.sym} 162640 -27070 0 0 {name=p161671 lab=_71553_/B }
C {devices/lab_pin.sym} 162640 -27030 0 0 {name=p161672 lab=_71536_/A }
C {devices/lab_pin.sym} 162760 -27070 0 1 {name=p161673 lab=_71553_/Y }
C {sky130_stdcells/nor3_4.sym} 162700 -27070 0 0 {name=X_71553_ }
C {devices/lab_pin.sym} 162610 -26930 0 0 {name=p161674 lab=_86530_/CLK }
C {devices/lab_pin.sym} 162610 -26910 0 0 {name=p161675 lab=_71315_/Y }
C {devices/lab_pin.sym} 162790 -26930 0 1 {name=p161676 lab=_48060_/A }
C {sky130_stdcells/dfxtp_4.sym} 162700 -26920 0 0 {name=X_83539_ }
C {devices/lab_pin.sym} 162660 -26790 0 0 {name=p161677 lab=_56525_/A }
C {devices/lab_pin.sym} 162740 -26790 0 1 {name=p161678 lab=_56487_/X }
C {sky130_stdcells/buf_2.sym} 162700 -26790 0 0 {name=X_56487_ }
C {devices/lab_pin.sym} 162640 -26680 0 0 {name=p161679 lab=_53713_/A }
C {devices/lab_pin.sym} 162640 -26640 0 0 {name=p161680 lab=_48538_/Y }
C {devices/lab_pin.sym} 162760 -26660 0 1 {name=p161681 lab=_53699_/Y }
C {sky130_stdcells/nand2_4.sym} 162700 -26660 0 0 {name=X_53699_ }
C {devices/lab_pin.sym} 162640 -26540 0 0 {name=p161682 lab=_46240_/A }
C {devices/lab_pin.sym} 162640 -26500 0 0 {name=p161683 lab=_48882_/A }
C {devices/lab_pin.sym} 162760 -26520 0 1 {name=p161684 lab=_46240_/Y }
C {sky130_stdcells/nand2_4.sym} 162700 -26520 0 0 {name=X_46240_ }
C {devices/lab_pin.sym} 162660 -26390 0 0 {name=p161685 lab=_70504_/A }
C {devices/lab_pin.sym} 162740 -26390 0 1 {name=p161686 lab=_70511_/A }
C {sky130_stdcells/buf_2.sym} 162700 -26390 0 0 {name=X_70504_ }
C {devices/lab_pin.sym} 162640 -26280 0 0 {name=p161687 lab=_58225_/X }
C {devices/lab_pin.sym} 162640 -26240 0 0 {name=p161688 lab=_58238_/B }
C {devices/lab_pin.sym} 162760 -26260 0 1 {name=p161689 lab=_58226_/Y }
C {sky130_stdcells/nor2_4.sym} 162700 -26260 0 0 {name=X_58226_ }
C {sky130_stdcells/decap_3.sym} 162700 -26100 0 0 {name=XPHY_520 }
C {devices/lab_pin.sym} 162640 -25960 0 0 {name=p161690 lab=_77060_/A }
C {devices/lab_pin.sym} 162640 -25920 0 0 {name=p161691 lab=_77060_/B }
C {devices/lab_pin.sym} 162760 -25940 0 1 {name=p161692 lab=_77060_/X }
C {sky130_stdcells/xor2_4.sym} 162700 -25940 0 0 {name=X_77060_ }
C {devices/lab_pin.sym} 162640 -25820 0 0 {name=p161693 lab=_55380_/Y }
C {devices/lab_pin.sym} 162640 -25780 0 0 {name=p161694 lab=_55438_/B }
C {devices/lab_pin.sym} 162760 -25800 0 1 {name=p161695 lab=_55441_/A }
C {sky130_stdcells/nor2_4.sym} 162700 -25800 0 0 {name=X_55438_ }
C {devices/lab_pin.sym} 162660 -25670 0 0 {name=p161696 lab=_43425_/X }
C {devices/lab_pin.sym} 162740 -25670 0 1 {name=p161697 lab=_43452_/X }
C {sky130_stdcells/buf_2.sym} 162700 -25670 0 0 {name=X_43452_ }
C {devices/lab_pin.sym} 162620 -25580 0 0 {name=p161698 lab=_74012_/X }
C {devices/lab_pin.sym} 162620 -25540 0 0 {name=p161699 lab=_86210_/Q }
C {devices/lab_pin.sym} 162620 -25500 0 0 {name=p161700 lab=_45930_/X }
C {devices/lab_pin.sym} 162620 -25460 0 0 {name=p161701 lab=_74271_/X }
C {devices/lab_pin.sym} 162780 -25520 0 1 {name=p161702 lab=_74272_/X }
C {sky130_stdcells/a211o_4.sym} 162700 -25520 0 0 {name=X_74272_ }
C {devices/lab_pin.sym} 162610 -25370 0 0 {name=p161703 lab=_85555_/CLK }
C {devices/lab_pin.sym} 162610 -25350 0 0 {name=p161704 lab=_86258_/D }
C {devices/lab_pin.sym} 162790 -25370 0 1 {name=p161705 lab=_65012_/B }
C {sky130_stdcells/dfxtp_4.sym} 162700 -25360 0 0 {name=X_86258_ }
C {sky130_stdcells/decap_3.sym} 162700 -25200 0 0 {name=XPHY_531 }
C {devices/lab_pin.sym} 162660 -25050 0 0 {name=p161706 lab=_40420_/A }
C {devices/lab_pin.sym} 162740 -25050 0 1 {name=p161707 lab=_40829_/A }
C {sky130_stdcells/buf_2.sym} 162700 -25050 0 0 {name=X_40664_ }
C {devices/lab_pin.sym} 162620 -24950 0 0 {name=p161708 lab=_71463_/Y }
C {devices/lab_pin.sym} 162620 -24910 0 0 {name=p161709 lab=_83482_/Q }
C {devices/lab_pin.sym} 162620 -24870 0 0 {name=p161710 lab=_71483_/X }
C {devices/lab_pin.sym} 162780 -24910 0 1 {name=p161711 lab=_83482_/D }
C {sky130_stdcells/a21o_4.sym} 162700 -24910 0 0 {name=X_71484_ }
C {sky130_stdcells/decap_3.sym} 162700 -24740 0 0 {name=XPHY_542 }
C {sky130_stdcells/decap_3.sym} 162700 -24560 0 0 {name=XPHY_553 }
C {devices/lab_pin.sym} 162640 -24420 0 0 {name=p161712 lab=_81518_/Q }
C {devices/lab_pin.sym} 162640 -24380 0 0 {name=p161713 lab=_81742_/D }
C {devices/lab_pin.sym} 162760 -24400 0 1 {name=p161714 lab=_76011_/X }
C {sky130_stdcells/xor2_4.sym} 162700 -24400 0 0 {name=X_76011_ }
C {devices/lab_pin.sym} 162660 -24270 0 0 {name=p161715 lab=_42403_/A }
C {devices/lab_pin.sym} 162740 -24270 0 1 {name=p161716 lab=_42403_/Y }
C {sky130_stdcells/inv_2.sym} 162700 -24270 0 0 {name=X_42403_ }
C {sky130_stdcells/decap_3.sym} 162700 -24120 0 0 {name=XPHY_564 }
C {devices/lab_pin.sym} 162620 -23990 0 0 {name=p161717 lab=_83160_/Q }
C {devices/lab_pin.sym} 162620 -23950 0 0 {name=p161718 lab=_73193_/X }
C {devices/lab_pin.sym} 162620 -23910 0 0 {name=p161719 lab=_73222_/Y }
C {devices/lab_pin.sym} 162780 -23950 0 1 {name=p161720 lab=_73223_/X }
C {sky130_stdcells/a21o_4.sym} 162700 -23950 0 0 {name=X_73223_ }
C {devices/lab_pin.sym} 162610 -23810 0 0 {name=p161721 lab=_85241_/CLK }
C {devices/lab_pin.sym} 162610 -23790 0 0 {name=p161722 lab=_85209_/D }
C {devices/lab_pin.sym} 162790 -23810 0 1 {name=p161723 lab=_85209_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -23800 0 0 {name=X_85209_ }
C {devices/lab_pin.sym} 162640 -23680 0 0 {name=p161724 lab=_46170_/Y }
C {devices/lab_pin.sym} 162640 -23640 0 0 {name=p161725 lab=_72498_/B }
C {devices/lab_pin.sym} 162760 -23660 0 1 {name=p161726 lab=_46171_/Y }
C {sky130_stdcells/nand2_4.sym} 162700 -23660 0 0 {name=X_46171_ }
C {devices/lab_pin.sym} 162640 -23550 0 0 {name=p161727 lab=_70442_/A }
C {devices/lab_pin.sym} 162640 -23510 0 0 {name=p161728 lab=_74523_/A }
C {devices/lab_pin.sym} 162640 -23470 0 0 {name=p161729 lab=_70431_/C }
C {devices/lab_pin.sym} 162760 -23510 0 1 {name=p161730 lab=_70435_/Y }
C {sky130_stdcells/nand3_4.sym} 162700 -23510 0 0 {name=X_70435_ }
C {devices/lab_pin.sym} 162620 -23390 0 0 {name=p161731 lab=_58153_/X }
C {devices/lab_pin.sym} 162620 -23350 0 0 {name=p161732 lab=_83495_/Q }
C {devices/lab_pin.sym} 162620 -23310 0 0 {name=p161733 lab=_58156_/Y }
C {devices/lab_pin.sym} 162780 -23350 0 1 {name=p161734 lab=_84919_/D }
C {sky130_stdcells/o21a_4.sym} 162700 -23350 0 0 {name=X_58157_ }
C {sky130_stdcells/decap_3.sym} 162700 -23180 0 0 {name=XPHY_575 }
C {devices/lab_pin.sym} 162660 -23030 0 0 {name=p161735 lab=_43382_/Y }
C {devices/lab_pin.sym} 162740 -23030 0 1 {name=p161736 lab=_87450_/D }
C {sky130_stdcells/inv_2.sym} 162700 -23030 0 0 {name=X_43383_ }
C {devices/lab_pin.sym} 162640 -22930 0 0 {name=p161737 lab=_55369_/A }
C {devices/lab_pin.sym} 162640 -22890 0 0 {name=p161738 lab=_55369_/B }
C {devices/lab_pin.sym} 162640 -22850 0 0 {name=p161739 lab=_55368_/Y }
C {devices/lab_pin.sym} 162760 -22890 0 1 {name=p161740 lab=_55443_/C }
C {sky130_stdcells/nand3_4.sym} 162700 -22890 0 0 {name=X_55369_ }
C {devices/lab_pin.sym} 162610 -22750 0 0 {name=p161741 lab=_86505_/CLK }
C {devices/lab_pin.sym} 162610 -22730 0 0 {name=p161742 lab=_86189_/D }
C {devices/lab_pin.sym} 162790 -22750 0 1 {name=p161743 lab=_86189_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -22740 0 0 {name=X_86189_ }
C {devices/lab_pin.sym} 162660 -22610 0 0 {name=p161744 lab=_49569_/A }
C {devices/lab_pin.sym} 162740 -22610 0 1 {name=p161745 lab=_40595_/X }
C {sky130_stdcells/buf_2.sym} 162700 -22610 0 0 {name=X_40595_ }
C {sky130_stdcells/decap_3.sym} 162700 -22460 0 0 {name=XPHY_586 }
C {sky130_stdcells/decap_3.sym} 162700 -22280 0 0 {name=XPHY_597 }
C {devices/lab_pin.sym} 162660 -22130 0 0 {name=p161746 lab=_45122_/A }
C {devices/lab_pin.sym} 162740 -22130 0 1 {name=p161747 lab=_45124_/A }
C {sky130_stdcells/inv_2.sym} 162700 -22130 0 0 {name=X_45122_ }
C {devices/lab_pin.sym} 162620 -22030 0 0 {name=p161748 lab=_56600_/X }
C {devices/lab_pin.sym} 162620 -21990 0 0 {name=p161749 lab=_57106_/X }
C {devices/lab_pin.sym} 162620 -21950 0 0 {name=p161750 lab=_57107_/Y }
C {devices/lab_pin.sym} 162780 -21990 0 1 {name=p161751 lab=_85083_/D }
C {sky130_stdcells/a21oi_4.sym} 162700 -21990 0 0 {name=X_57108_ }
C {devices/lab_pin.sym} 162620 -21890 0 0 {name=p161752 lab=_42330_/X }
C {devices/lab_pin.sym} 162620 -21850 0 0 {name=p161753 lab=_42319_/X }
C {devices/lab_pin.sym} 162620 -21810 0 0 {name=p161754 lab=_41667_/X }
C {devices/lab_pin.sym} 162620 -21770 0 0 {name=p161755 lab=_87916_/Q }
C {devices/lab_pin.sym} 162620 -21730 0 0 {name=p161756 lab=_42320_/X }
C {devices/lab_pin.sym} 162780 -21810 0 1 {name=p161757 lab=_42335_/A }
C {sky130_stdcells/o32ai_4.sym} 162700 -21810 0 0 {name=X_42334_ }
C {devices/lab_pin.sym} 162620 -21670 0 0 {name=p161758 lab=_88324_/Q }
C {devices/lab_pin.sym} 162620 -21630 0 0 {name=p161759 lab=_73153_/X }
C {devices/lab_pin.sym} 162620 -21590 0 0 {name=p161760 lab=_72901_/X }
C {devices/lab_pin.sym} 162780 -21630 0 1 {name=p161761 lab=_73154_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -21630 0 0 {name=X_73154_ }
C {devices/lab_pin.sym} 162660 -21490 0 0 {name=p161762 lab=_59036_/A }
C {devices/lab_pin.sym} 162740 -21490 0 1 {name=p161763 lab=_58928_/A }
C {sky130_stdcells/buf_2.sym} 162700 -21490 0 0 {name=X_58088_ }
C {devices/lab_pin.sym} 162660 -21370 0 0 {name=p161764 lab=_71129_/A }
C {devices/lab_pin.sym} 162740 -21370 0 1 {name=p161765 lab=_70366_/X }
C {sky130_stdcells/buf_2.sym} 162700 -21370 0 0 {name=X_70366_ }
C {devices/lab_pin.sym} 162640 -21260 0 0 {name=p161766 lab=_72091_/X }
C {devices/lab_pin.sym} 162640 -21220 0 0 {name=p161767 lab=_53932_/B }
C {devices/lab_pin.sym} 162760 -21240 0 1 {name=p161768 lab=_72105_/Y }
C {sky130_stdcells/nand2_4.sym} 162700 -21240 0 0 {name=X_72105_ }
C {devices/lab_pin.sym} 162660 -21110 0 0 {name=p161769 lab=_52679_/A }
C {devices/lab_pin.sym} 162740 -21110 0 1 {name=p161770 lab=_49930_/X }
C {sky130_stdcells/buf_2.sym} 162700 -21110 0 0 {name=X_49930_ }
C {devices/lab_pin.sym} 162640 -21000 0 0 {name=p161771 lab=_57039_/A }
C {devices/lab_pin.sym} 162640 -20960 0 0 {name=p161772 lab=_57026_/X }
C {devices/lab_pin.sym} 162760 -20980 0 1 {name=p161773 lab=_57039_/Y }
C {sky130_stdcells/nor2_4.sym} 162700 -20980 0 0 {name=X_57039_ }
C {devices/lab_pin.sym} 162660 -20850 0 0 {name=p161774 lab=_64320_/B }
C {devices/lab_pin.sym} 162740 -20850 0 1 {name=p161775 lab=_61437_/B }
C {sky130_stdcells/buf_2.sym} 162700 -20850 0 0 {name=X_45053_ }
C {devices/lab_pin.sym} 162620 -20760 0 0 {name=p161776 lab=_41485_/X }
C {devices/lab_pin.sym} 162620 -20720 0 0 {name=p161777 lab=_42258_/X }
C {devices/lab_pin.sym} 162620 -20680 0 0 {name=p161778 lab=_87950_/Q }
C {devices/lab_pin.sym} 162620 -20640 0 0 {name=p161779 lab=_42259_/X }
C {devices/lab_pin.sym} 162780 -20700 0 1 {name=p161780 lab=_42265_/X }
C {sky130_stdcells/a2bb2o_4.sym} 162700 -20700 0 0 {name=X_42265_ }
C {devices/lab_pin.sym} 162620 -20570 0 0 {name=p161781 lab=_77954_/A }
C {devices/lab_pin.sym} 162620 -20530 0 0 {name=p161782 lab=_77954_/B }
C {devices/lab_pin.sym} 162620 -20490 0 0 {name=p161783 lab=_77961_/Y }
C {devices/lab_pin.sym} 162780 -20530 0 1 {name=p161784 lab=_77967_/C }
C {sky130_stdcells/o21a_4.sym} 162700 -20530 0 0 {name=X_77962_ }
C {devices/lab_pin.sym} 162620 -20410 0 0 {name=p161785 lab=_73082_/X }
C {devices/lab_pin.sym} 162620 -20370 0 0 {name=p161786 lab=_73084_/X }
C {devices/lab_pin.sym} 162620 -20330 0 0 {name=p161787 lab=_72951_/X }
C {devices/lab_pin.sym} 162780 -20370 0 1 {name=p161788 lab=_73101_/B }
C {sky130_stdcells/a21o_4.sym} 162700 -20370 0 0 {name=X_73085_ }
C {devices/lab_pin.sym} 162660 -20230 0 0 {name=p161789 lab=_70247_/X }
C {devices/lab_pin.sym} 162740 -20230 0 1 {name=p161790 lab=_70297_/X }
C {sky130_stdcells/buf_2.sym} 162700 -20230 0 0 {name=X_70297_ }
C {devices/lab_pin.sym} 162640 -20130 0 0 {name=p161791 lab=_62975_/D }
C {devices/lab_pin.sym} 162640 -20090 0 0 {name=p161792 lab=_60665_/C }
C {devices/lab_pin.sym} 162640 -20050 0 0 {name=p161793 lab=_44003_/X }
C {devices/lab_pin.sym} 162760 -20090 0 1 {name=p161794 lab=_44004_/Y }
C {sky130_stdcells/nand3_4.sym} 162700 -20090 0 0 {name=X_44004_ }
C {devices/lab_pin.sym} 162640 -19960 0 0 {name=p161795 lab=_79699_/X }
C {devices/lab_pin.sym} 162640 -19920 0 0 {name=p161796 lab=_79710_/B }
C {devices/lab_pin.sym} 162760 -19940 0 1 {name=p161797 lab=_79701_/Y }
C {sky130_stdcells/xnor2_4.sym} 162700 -19940 0 0 {name=X_79701_ }
C {devices/lab_pin.sym} 162660 -19810 0 0 {name=p161798 lab=_41216_/A }
C {devices/lab_pin.sym} 162740 -19810 0 1 {name=p161799 lab=_41216_/Y }
C {sky130_stdcells/inv_2.sym} 162700 -19810 0 0 {name=X_41216_ }
C {devices/lab_pin.sym} 162640 -19710 0 0 {name=p161800 lab=_59929_/C }
C {devices/lab_pin.sym} 162640 -19670 0 0 {name=p161801 lab=_59910_/X }
C {devices/lab_pin.sym} 162640 -19630 0 0 {name=p161802 lab=_59927_/Y }
C {devices/lab_pin.sym} 162760 -19670 0 1 {name=p161803 lab=_62203_/A }
C {sky130_stdcells/nand3_4.sym} 162700 -19670 0 0 {name=X_60050_ }
C {devices/lab_pin.sym} 162640 -19540 0 0 {name=p161804 lab=_72017_/X }
C {devices/lab_pin.sym} 162640 -19500 0 0 {name=p161805 lab=_53860_/B }
C {devices/lab_pin.sym} 162760 -19520 0 1 {name=p161806 lab=_72036_/Y }
C {sky130_stdcells/nand2_4.sym} 162700 -19520 0 0 {name=X_72036_ }
C {devices/lab_pin.sym} 162620 -19410 0 0 {name=p161807 lab=_76870_/Y }
C {devices/lab_pin.sym} 162620 -19370 0 0 {name=p161808 lab=_76910_/X }
C {devices/lab_pin.sym} 162620 -19330 0 0 {name=p161809 lab=_76912_/X }
C {devices/lab_pin.sym} 162780 -19370 0 1 {name=p161810 lab=_76914_/B }
C {sky130_stdcells/a21boi_4.sym} 162700 -19370 0 0 {name=X_76913_ }
C {devices/lab_pin.sym} 162660 -19230 0 0 {name=p161811 lab=clkbuf_6_22_0_CLK/X }
C {devices/lab_pin.sym} 162740 -19230 0 1 {name=p161812 lab=clkbuf_8_89_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 162700 -19230 0 0 {name=Xclkbuf_7_44_0_CLK }
C {devices/lab_pin.sym} 162660 -19110 0 0 {name=p161813 lab=_49861_/A }
C {devices/lab_pin.sym} 162740 -19110 0 1 {name=p161814 lab=_49884_/B }
C {sky130_stdcells/buf_2.sym} 162700 -19110 0 0 {name=X_49861_ }
C {devices/lab_pin.sym} 162620 -19020 0 0 {name=p161815 lab=_41302_/X }
C {devices/lab_pin.sym} 162620 -18980 0 0 {name=p161816 lab=_42192_/X }
C {devices/lab_pin.sym} 162620 -18940 0 0 {name=p161817 lab=_87984_/Q }
C {devices/lab_pin.sym} 162620 -18900 0 0 {name=p161818 lab=_42193_/X }
C {devices/lab_pin.sym} 162780 -18960 0 1 {name=p161819 lab=_87984_/D }
C {sky130_stdcells/a2bb2o_4.sym} 162700 -18960 0 0 {name=X_42196_ }
C {devices/lab_pin.sym} 162640 -18820 0 0 {name=p161820 lab=_77880_/A }
C {devices/lab_pin.sym} 162640 -18780 0 0 {name=p161821 lab=_77887_/A }
C {devices/lab_pin.sym} 162760 -18800 0 1 {name=p161822 lab=_77893_/X }
C {sky130_stdcells/and2_4.sym} 162700 -18800 0 0 {name=X_77893_ }
C {devices/lab_pin.sym} 162660 -18670 0 0 {name=p161823 lab=clkbuf_7_92_0_CLK/X }
C {devices/lab_pin.sym} 162740 -18670 0 1 {name=p161824 lab=clkbuf_8_184_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 162700 -18670 0 0 {name=Xclkbuf_8_184_0_CLK }
C {devices/lab_pin.sym} 162620 -18570 0 0 {name=p161825 lab=_86478_/Q }
C {devices/lab_pin.sym} 162620 -18530 0 0 {name=p161826 lab=_48809_/X }
C {devices/lab_pin.sym} 162620 -18490 0 0 {name=p161827 lab=_48811_/Y }
C {devices/lab_pin.sym} 162780 -18530 0 1 {name=p161828 lab=_48812_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -18530 0 0 {name=X_48812_ }
C {devices/lab_pin.sym} 162620 -18410 0 0 {name=p161829 lab=_79624_/A }
C {devices/lab_pin.sym} 162620 -18370 0 0 {name=p161830 lab=_79624_/B }
C {devices/lab_pin.sym} 162620 -18330 0 0 {name=p161831 lab=_79619_/A }
C {devices/lab_pin.sym} 162780 -18370 0 1 {name=p161832 lab=_79632_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -18370 0 0 {name=X_79632_ }
C {devices/lab_pin.sym} 162660 -18230 0 0 {name=p161833 lab=_41147_/A }
C {devices/lab_pin.sym} 162740 -18230 0 1 {name=p161834 lab=_41147_/X }
C {sky130_stdcells/buf_2.sym} 162700 -18230 0 0 {name=X_41147_ }
C {devices/lab_pin.sym} 162640 -18120 0 0 {name=p161835 lab=_76844_/A }
C {devices/lab_pin.sym} 162640 -18080 0 0 {name=p161836 lab=_76843_/Y }
C {devices/lab_pin.sym} 162760 -18100 0 1 {name=p161837 lab=_76845_/B }
C {sky130_stdcells/xnor2_4.sym} 162700 -18100 0 0 {name=X_76844_ }
C {devices/lab_pin.sym} 162620 -17990 0 0 {name=p161838 lab=_57934_/B }
C {devices/lab_pin.sym} 162620 -17950 0 0 {name=p161839 lab=_49768_/X }
C {devices/lab_pin.sym} 162620 -17910 0 0 {name=p161840 lab=_49791_/Y }
C {devices/lab_pin.sym} 162780 -17950 0 1 {name=p161841 lab=_49792_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -17950 0 0 {name=X_49792_ }
C {devices/lab_pin.sym} 162660 -17810 0 0 {name=p161842 lab=_52573_/B }
C {devices/lab_pin.sym} 162740 -17810 0 1 {name=p161843 lab=_48766_/B }
C {sky130_stdcells/buf_2.sym} 162700 -17810 0 0 {name=X_48743_ }
C {devices/lab_pin.sym} 162640 -17700 0 0 {name=p161844 lab=_79547_/Y }
C {devices/lab_pin.sym} 162640 -17660 0 0 {name=p161845 lab=_79563_/B }
C {devices/lab_pin.sym} 162760 -17680 0 1 {name=p161846 lab=_79563_/Y }
C {sky130_stdcells/xnor2_4.sym} 162700 -17680 0 0 {name=X_79563_ }
C {devices/lab_pin.sym} 162660 -17550 0 0 {name=p161847 lab=_44196_/B }
C {devices/lab_pin.sym} 162740 -17550 0 1 {name=p161848 lab=_45955_/X }
C {sky130_stdcells/buf_2.sym} 162700 -17550 0 0 {name=X_45955_ }
C {devices/lab_pin.sym} 162660 -17430 0 0 {name=p161849 lab=_41078_/A }
C {devices/lab_pin.sym} 162740 -17430 0 1 {name=p161850 lab=_41078_/Y }
C {sky130_stdcells/inv_2.sym} 162700 -17430 0 0 {name=X_41078_ }
C {devices/lab_pin.sym} 162640 -17320 0 0 {name=p161851 lab=_76763_/A }
C {devices/lab_pin.sym} 162640 -17280 0 0 {name=p161852 lab=_76770_/A }
C {devices/lab_pin.sym} 162760 -17300 0 1 {name=p161853 lab=_76776_/B }
C {sky130_stdcells/and2_4.sym} 162700 -17300 0 0 {name=X_76775_ }
C {devices/lab_pin.sym} 162640 -17180 0 0 {name=p161854 lab=_73987_/A }
C {devices/lab_pin.sym} 162640 -17140 0 0 {name=p161855 lab=_57376_/X }
C {devices/lab_pin.sym} 162760 -17160 0 1 {name=p161856 lab=_73987_/Y }
C {sky130_stdcells/nor2_4.sym} 162700 -17160 0 0 {name=X_73987_ }
C {devices/lab_pin.sym} 162660 -17030 0 0 {name=p161857 lab=clkbuf_7_58_0_CLK/A }
C {devices/lab_pin.sym} 162740 -17030 0 1 {name=p161858 lab=clkbuf_7_59_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 162700 -17030 0 0 {name=Xclkbuf_7_59_0_CLK }
C {devices/lab_pin.sym} 162660 -16910 0 0 {name=p161859 lab=_78486_/Y }
C {devices/lab_pin.sym} 162740 -16910 0 1 {name=p161860 lab=_78514_/Y }
C {sky130_stdcells/inv_2.sym} 162700 -16910 0 0 {name=X_78514_ }
C {devices/lab_pin.sym} 162660 -16790 0 0 {name=p161861 lab=_44290_/X }
C {devices/lab_pin.sym} 162740 -16790 0 1 {name=p161862 lab=_44907_/A }
C {sky130_stdcells/buf_2.sym} 162700 -16790 0 0 {name=X_44906_ }
C {devices/lab_pin.sym} 162660 -16670 0 0 {name=p161863 lab=_63735_/A }
C {devices/lab_pin.sym} 162740 -16670 0 1 {name=p161864 lab=_63741_/A }
C {sky130_stdcells/buf_2.sym} 162700 -16670 0 0 {name=X_63740_ }
C {devices/lab_pin.sym} 162640 -16560 0 0 {name=p161865 lab=_81091_/Q }
C {devices/lab_pin.sym} 162640 -16520 0 0 {name=p161866 lab=_75726_/B }
C {devices/lab_pin.sym} 162760 -16540 0 1 {name=p161867 lab=_75726_/Y }
C {sky130_stdcells/xnor2_4.sym} 162700 -16540 0 0 {name=X_75726_ }
C {devices/lab_pin.sym} 162620 -16430 0 0 {name=p161868 lab=_86501_/Q }
C {devices/lab_pin.sym} 162620 -16390 0 0 {name=p161869 lab=_48669_/X }
C {devices/lab_pin.sym} 162620 -16350 0 0 {name=p161870 lab=_48673_/Y }
C {devices/lab_pin.sym} 162780 -16390 0 1 {name=p161871 lab=_48674_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -16390 0 0 {name=X_48674_ }
C {devices/lab_pin.sym} 162660 -16250 0 0 {name=p161872 lab=_60951_/Y }
C {devices/lab_pin.sym} 162740 -16250 0 1 {name=p161873 lab=_60952_/X }
C {sky130_stdcells/buf_2.sym} 162700 -16250 0 0 {name=X_60952_ }
C {devices/lab_pin.sym} 162640 -16140 0 0 {name=p161874 lab=_53647_/B }
C {devices/lab_pin.sym} 162640 -16100 0 0 {name=p161875 lab=_72938_/B }
C {devices/lab_pin.sym} 162760 -16120 0 1 {name=p161876 lab=_72938_/X }
C {sky130_stdcells/xor2_4.sym} 162700 -16120 0 0 {name=X_72938_ }
C {devices/lab_pin.sym} 162640 -16000 0 0 {name=p161877 lab=_79494_/A }
C {devices/lab_pin.sym} 162640 -15960 0 0 {name=p161878 lab=_79494_/B }
C {devices/lab_pin.sym} 162760 -15980 0 1 {name=p161879 lab=_79494_/Y }
C {sky130_stdcells/xnor2_4.sym} 162700 -15980 0 0 {name=X_79494_ }
C {devices/lab_pin.sym} 162660 -15850 0 0 {name=p161880 lab=_45885_/X }
C {devices/lab_pin.sym} 162740 -15850 0 1 {name=p161881 lab=_45886_/X }
C {sky130_stdcells/buf_2.sym} 162700 -15850 0 0 {name=X_45886_ }
C {devices/lab_pin.sym} 162660 -15730 0 0 {name=p161882 lab=clkbuf_7_99_0_CLK/X }
C {devices/lab_pin.sym} 162740 -15730 0 1 {name=p161883 lab=clkbuf_9_398_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 162700 -15730 0 0 {name=Xclkbuf_8_199_0_CLK }
C {devices/lab_pin.sym} 162660 -15610 0 0 {name=p161884 lab=clkbuf_9_97_0_CLK/X }
C {devices/lab_pin.sym} 162740 -15610 0 1 {name=p161885 lab=_83749_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 162700 -15610 0 0 {name=Xclkbuf_10_194_0_CLK }
C {devices/lab_pin.sym} 162620 -15510 0 0 {name=p161886 lab=_72247_/A }
C {devices/lab_pin.sym} 162620 -15470 0 0 {name=p161887 lab=_47619_/X }
C {devices/lab_pin.sym} 162620 -15430 0 0 {name=p161888 lab=_47624_/Y }
C {devices/lab_pin.sym} 162780 -15470 0 1 {name=p161889 lab=_47625_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -15470 0 0 {name=X_47625_ }
C {devices/lab_pin.sym} 162620 -15350 0 0 {name=p161890 lab=_78432_/A }
C {devices/lab_pin.sym} 162620 -15310 0 0 {name=p161891 lab=_82667_/D }
C {devices/lab_pin.sym} 162620 -15270 0 0 {name=p161892 lab=_78439_/C }
C {devices/lab_pin.sym} 162780 -15310 0 1 {name=p161893 lab=_78466_/A }
C {sky130_stdcells/a21boi_4.sym} 162700 -15310 0 0 {name=X_78445_ }
C {devices/lab_pin.sym} 162620 -15190 0 0 {name=p161894 lab=_63669_/Y }
C {devices/lab_pin.sym} 162620 -15150 0 0 {name=p161895 lab=_63635_/X }
C {devices/lab_pin.sym} 162620 -15110 0 0 {name=p161896 lab=_63670_/Y }
C {devices/lab_pin.sym} 162780 -15150 0 1 {name=p161897 lab=_84303_/D }
C {sky130_stdcells/a21oi_4.sym} 162700 -15150 0 0 {name=X_63671_ }
C {devices/lab_pin.sym} 162660 -15010 0 0 {name=p161898 lab=_44837_/A }
C {devices/lab_pin.sym} 162740 -15010 0 1 {name=p161899 lab=_86928_/D }
C {sky130_stdcells/inv_2.sym} 162700 -15010 0 0 {name=X_44837_ }
C {devices/lab_pin.sym} 162640 -14900 0 0 {name=p161900 lab=_75657_/A }
C {devices/lab_pin.sym} 162640 -14860 0 0 {name=p161901 lab=_75657_/B }
C {devices/lab_pin.sym} 162760 -14880 0 1 {name=p161902 lab=_75657_/Y }
C {sky130_stdcells/xnor2_4.sym} 162700 -14880 0 0 {name=X_75657_ }
C {devices/lab_pin.sym} 162660 -14750 0 0 {name=p161903 lab=_60864_/X }
C {devices/lab_pin.sym} 162740 -14750 0 1 {name=p161904 lab=_60984_/A }
C {sky130_stdcells/buf_2.sym} 162700 -14750 0 0 {name=X_60883_ }
C {devices/lab_pin.sym} 162640 -14640 0 0 {name=p161905 lab=_72869_/A }
C {devices/lab_pin.sym} 162640 -14600 0 0 {name=p161906 lab=_72868_/Y }
C {devices/lab_pin.sym} 162760 -14620 0 1 {name=p161907 lab=_72869_/Y }
C {sky130_stdcells/nand2_4.sym} 162700 -14620 0 0 {name=X_72869_ }
C {devices/lab_pin.sym} 162640 -14500 0 0 {name=p161908 lab=_65410_/A }
C {devices/lab_pin.sym} 162640 -14460 0 0 {name=p161909 lab=_65409_/X }
C {devices/lab_pin.sym} 162760 -14480 0 1 {name=p161910 lab=_65410_/Y }
C {sky130_stdcells/nand2_4.sym} 162700 -14480 0 0 {name=X_65410_ }
C {devices/lab_pin.sym} 162620 -14380 0 0 {name=p161911 lab=_74605_/X }
C {devices/lab_pin.sym} 162620 -14340 0 0 {name=p161912 lab=_74599_/X }
C {devices/lab_pin.sym} 162620 -14300 0 0 {name=p161913 lab=_56138_/Y }
C {devices/lab_pin.sym} 162620 -14260 0 0 {name=p161914 lab=_74600_/X }
C {devices/lab_pin.sym} 162780 -14320 0 1 {name=p161915 lab=_74608_/X }
C {sky130_stdcells/a211o_4.sym} 162700 -14320 0 0 {name=X_74608_ }
C {devices/lab_pin.sym} 162640 -14200 0 0 {name=p161916 lab=_62622_/A }
C {devices/lab_pin.sym} 162640 -14160 0 0 {name=p161917 lab=_62619_/Y }
C {devices/lab_pin.sym} 162640 -14120 0 0 {name=p161918 lab=_62622_/C }
C {devices/lab_pin.sym} 162640 -14080 0 0 {name=p161919 lab=_62621_/Y }
C {devices/lab_pin.sym} 162760 -14140 0 1 {name=p161920 lab=_62622_/Y }
C {sky130_stdcells/nand4_4.sym} 162700 -14140 0 0 {name=X_62622_ }
C {devices/lab_pin.sym} 162660 -13990 0 0 {name=p161921 lab=_47556_/A }
C {devices/lab_pin.sym} 162740 -13990 0 1 {name=p161922 lab=_47595_/B }
C {sky130_stdcells/buf_2.sym} 162700 -13990 0 0 {name=X_47556_ }
C {devices/lab_pin.sym} 162620 -13890 0 0 {name=p161923 lab=_66386_/Y }
C {devices/lab_pin.sym} 162620 -13850 0 0 {name=p161924 lab=_66377_/X }
C {devices/lab_pin.sym} 162620 -13810 0 0 {name=p161925 lab=_66389_/Y }
C {devices/lab_pin.sym} 162780 -13850 0 1 {name=p161926 lab=_84132_/D }
C {sky130_stdcells/a21o_4.sym} 162700 -13850 0 0 {name=X_66390_ }
C {devices/lab_pin.sym} 162640 -13720 0 0 {name=p161927 lab=_78364_/C }
C {devices/lab_pin.sym} 162640 -13680 0 0 {name=p161928 lab=_78376_/B }
C {devices/lab_pin.sym} 162760 -13700 0 1 {name=p161929 lab=_78378_/A }
C {sky130_stdcells/nand2_4.sym} 162700 -13700 0 0 {name=X_78376_ }
C {devices/lab_pin.sym} 162660 -13570 0 0 {name=p161930 lab=_44532_/A }
C {devices/lab_pin.sym} 162740 -13570 0 1 {name=p161931 lab=_44768_/X }
C {sky130_stdcells/buf_2.sym} 162700 -13570 0 0 {name=X_44768_ }
C {devices/lab_pin.sym} 162620 -13470 0 0 {name=p161932 lab=_75586_/A }
C {devices/lab_pin.sym} 162620 -13430 0 0 {name=p161933 lab=_75584_/Y }
C {devices/lab_pin.sym} 162620 -13390 0 0 {name=p161934 lab=_75583_/A }
C {devices/lab_pin.sym} 162780 -13430 0 1 {name=p161935 lab=_75588_/Y }
C {sky130_stdcells/a21oi_4.sym} 162700 -13430 0 0 {name=X_75588_ }
C {devices/lab_pin.sym} 162660 -13290 0 0 {name=p161936 lab=clkbuf_7_61_0_CLK/X }
C {devices/lab_pin.sym} 162740 -13290 0 1 {name=p161937 lab=clkbuf_9_245_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 162700 -13290 0 0 {name=Xclkbuf_8_122_0_CLK }
C {devices/lab_pin.sym} 162660 -13170 0 0 {name=p161938 lab=_46507_/A }
C {devices/lab_pin.sym} 162740 -13170 0 1 {name=p161939 lab=_52533_/A }
C {sky130_stdcells/buf_2.sym} 162700 -13170 0 0 {name=X_46507_ }
C {devices/lab_pin.sym} 162660 -13050 0 0 {name=p161940 lab=_64656_/A }
C {devices/lab_pin.sym} 162740 -13050 0 1 {name=p161941 lab=_65660_/A }
C {sky130_stdcells/buf_2.sym} 162700 -13050 0 0 {name=X_65341_ }
C {devices/lab_pin.sym} 162620 -12950 0 0 {name=p161942 lab=_77323_/Y }
C {devices/lab_pin.sym} 162620 -12910 0 0 {name=p161943 lab=_77325_/Y }
C {devices/lab_pin.sym} 162620 -12870 0 0 {name=p161944 lab=_77326_/Y }
C {devices/lab_pin.sym} 162780 -12910 0 1 {name=p161945 lab=_77327_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -12910 0 0 {name=X_77327_ }
C {devices/lab_pin.sym} 162620 -12800 0 0 {name=p161946 lab=_40861_/A }
C {devices/lab_pin.sym} 162620 -12760 0 0 {name=p161947 lab=_43716_/X }
C {devices/lab_pin.sym} 162620 -12720 0 0 {name=p161948 lab=_69808_/B }
C {devices/lab_pin.sym} 162620 -12680 0 0 {name=p161949 lab=_43718_/X }
C {devices/lab_pin.sym} 162780 -12740 0 1 {name=p161950 lab=_43719_/X }
C {sky130_stdcells/a2bb2o_4.sym} 162700 -12740 0 0 {name=X_43719_ }
C {devices/lab_pin.sym} 162660 -12590 0 0 {name=p161951 lab=_62672_/A }
C {devices/lab_pin.sym} 162740 -12590 0 1 {name=p161952 lab=_62553_/X }
C {sky130_stdcells/buf_2.sym} 162700 -12590 0 0 {name=X_62553_ }
C {devices/lab_pin.sym} 162640 -12490 0 0 {name=p161953 lab=_74539_/A }
C {devices/lab_pin.sym} 162640 -12450 0 0 {name=p161954 lab=_45933_/Y }
C {devices/lab_pin.sym} 162640 -12410 0 0 {name=p161955 lab=_55684_/X }
C {devices/lab_pin.sym} 162760 -12450 0 1 {name=p161956 lab=_74549_/A }
C {sky130_stdcells/nand3_4.sym} 162700 -12450 0 0 {name=X_74539_ }
C {devices/lab_pin.sym} 162640 -12340 0 0 {name=p161957 lab=_47513_/A }
C {devices/lab_pin.sym} 162640 -12300 0 0 {name=p161958 lab=_47463_/X }
C {devices/lab_pin.sym} 162640 -12260 0 0 {name=p161959 lab=_47513_/C }
C {devices/lab_pin.sym} 162640 -12220 0 0 {name=p161960 lab=_53074_/D }
C {devices/lab_pin.sym} 162760 -12280 0 1 {name=p161961 lab=_47487_/X }
C {sky130_stdcells/and4_4.sym} 162700 -12280 0 0 {name=X_47487_ }
C {devices/lab_pin.sym} 162620 -12170 0 0 {name=p161962 lab=_44679_/X }
C {devices/lab_pin.sym} 162620 -12130 0 0 {name=p161963 lab=_44680_/X }
C {devices/lab_pin.sym} 162620 -12090 0 0 {name=p161964 lab=_40656_/X }
C {devices/lab_pin.sym} 162620 -12050 0 0 {name=p161965 lab=_86995_/Q }
C {devices/lab_pin.sym} 162620 -12010 0 0 {name=p161966 lab=_44681_/X }
C {devices/lab_pin.sym} 162780 -12090 0 1 {name=p161967 lab=_44700_/A }
C {sky130_stdcells/o32ai_4.sym} 162700 -12090 0 0 {name=X_44699_ }
C {devices/lab_pin.sym} 162640 -11940 0 0 {name=p161968 lab=_49220_/A }
C {devices/lab_pin.sym} 162640 -11900 0 0 {name=p161969 lab=_53959_/B }
C {devices/lab_pin.sym} 162760 -11920 0 1 {name=p161970 lab=_49226_/Y }
C {sky130_stdcells/nand2_4.sym} 162700 -11920 0 0 {name=X_49226_ }
C {devices/lab_pin.sym} 162640 -11820 0 0 {name=p161971 lab=_59415_/A }
C {devices/lab_pin.sym} 162640 -11780 0 0 {name=p161972 lab=_61484_/B }
C {devices/lab_pin.sym} 162640 -11740 0 0 {name=p161973 lab=_61484_/C }
C {devices/lab_pin.sym} 162640 -11700 0 0 {name=p161974 lab=_61514_/D }
C {devices/lab_pin.sym} 162760 -11760 0 1 {name=p161975 lab=_61504_/Y }
C {sky130_stdcells/nand4_4.sym} 162700 -11760 0 0 {name=X_61504_ }
C {devices/lab_pin.sym} 162640 -11620 0 0 {name=p161976 lab=_68371_/A }
C {devices/lab_pin.sym} 162640 -11580 0 0 {name=p161977 lab=_88149_/Q }
C {devices/lab_pin.sym} 162760 -11600 0 1 {name=p161978 lab=_68060_/X }
C {sky130_stdcells/and2_4.sym} 162700 -11600 0 0 {name=X_68060_ }
C {devices/lab_pin.sym} 162660 -11470 0 0 {name=p161979 lab=_46438_/A }
C {devices/lab_pin.sym} 162740 -11470 0 1 {name=p161980 lab=_50808_/B }
C {sky130_stdcells/buf_2.sym} 162700 -11470 0 0 {name=X_46438_ }
C {devices/lab_pin.sym} 162660 -11350 0 0 {name=p161981 lab=_65118_/A }
C {devices/lab_pin.sym} 162740 -11350 0 1 {name=p161982 lab=_65272_/X }
C {sky130_stdcells/buf_2.sym} 162700 -11350 0 0 {name=X_65272_ }
C {devices/lab_pin.sym} 162640 -11250 0 0 {name=p161983 lab=_77258_/A }
C {devices/lab_pin.sym} 162640 -11210 0 0 {name=p161984 lab=_77255_/Y }
C {devices/lab_pin.sym} 162640 -11170 0 0 {name=p161985 lab=_77252_/Y }
C {devices/lab_pin.sym} 162760 -11210 0 1 {name=p161986 lab=_77258_/Y }
C {sky130_stdcells/nand3_4.sym} 162700 -11210 0 0 {name=X_77258_ }
C {devices/lab_pin.sym} 162660 -11070 0 0 {name=p161987 lab=_62179_/X }
C {devices/lab_pin.sym} 162740 -11070 0 1 {name=p161988 lab=_62541_/B }
C {sky130_stdcells/buf_2.sym} 162700 -11070 0 0 {name=X_62484_ }
C {devices/lab_pin.sym} 162640 -10960 0 0 {name=p161989 lab=_66942_/A }
C {devices/lab_pin.sym} 162640 -10920 0 0 {name=p161990 lab=_67011_/B }
C {devices/lab_pin.sym} 162760 -10940 0 1 {name=p161991 lab=_67011_/X }
C {sky130_stdcells/and2_4.sym} 162700 -10940 0 0 {name=X_67011_ }
C {devices/lab_pin.sym} 162640 -10820 0 0 {name=p161992 lab=_76206_/Y }
C {devices/lab_pin.sym} 162640 -10780 0 0 {name=p161993 lab=_76208_/Y }
C {devices/lab_pin.sym} 162760 -10800 0 1 {name=p161994 lab=_76209_/Y }
C {sky130_stdcells/nor2_4.sym} 162700 -10800 0 0 {name=X_76209_ }
C {devices/lab_pin.sym} 162640 -10690 0 0 {name=p161995 lab=_64223_/A }
C {devices/lab_pin.sym} 162640 -10650 0 0 {name=p161996 lab=_64223_/B }
C {devices/lab_pin.sym} 162640 -10610 0 0 {name=p161997 lab=_64223_/C }
C {devices/lab_pin.sym} 162760 -10650 0 1 {name=p161998 lab=_64223_/X }
C {sky130_stdcells/and3_4.sym} 162700 -10650 0 0 {name=X_64223_ }
C {devices/lab_pin.sym} 162660 -10510 0 0 {name=p161999 lab=_49157_/A }
C {devices/lab_pin.sym} 162740 -10510 0 1 {name=p162000 lab=_53917_/B }
C {sky130_stdcells/inv_2.sym} 162700 -10510 0 0 {name=X_49157_ }
C {devices/lab_pin.sym} 162620 -10410 0 0 {name=p162001 lab=_61433_/X }
C {devices/lab_pin.sym} 162620 -10370 0 0 {name=p162002 lab=_61394_/X }
C {devices/lab_pin.sym} 162620 -10330 0 0 {name=p162003 lab=_61434_/Y }
C {devices/lab_pin.sym} 162780 -10370 0 1 {name=p162004 lab=_61435_/Y }
C {sky130_stdcells/a21oi_4.sym} 162700 -10370 0 0 {name=X_61435_ }
C {devices/lab_pin.sym} 162640 -10240 0 0 {name=p162005 lab=_46387_/A }
C {devices/lab_pin.sym} 162640 -10200 0 0 {name=p162006 lab=_50777_/B }
C {devices/lab_pin.sym} 162760 -10220 0 1 {name=p162007 lab=_46369_/Y }
C {sky130_stdcells/nand2_4.sym} 162700 -10220 0 0 {name=X_46369_ }
C {devices/lab_pin.sym} 162620 -10110 0 0 {name=p162008 lab=_77185_/Y }
C {devices/lab_pin.sym} 162620 -10070 0 0 {name=p162009 lab=_77177_/B }
C {devices/lab_pin.sym} 162620 -10030 0 0 {name=p162010 lab=_77188_/X }
C {devices/lab_pin.sym} 162780 -10070 0 1 {name=p162011 lab=_77189_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -10070 0 0 {name=X_77189_ }
C {devices/lab_pin.sym} 162660 -9930 0 0 {name=p162012 lab=clkbuf_7_68_0_CLK/X }
C {devices/lab_pin.sym} 162740 -9930 0 1 {name=p162013 lab=clkbuf_9_274_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 162700 -9930 0 0 {name=Xclkbuf_8_137_0_CLK }
C {devices/lab_pin.sym} 162660 -9810 0 0 {name=p162014 lab=clkbuf_9_66_0_CLK/X }
C {devices/lab_pin.sym} 162740 -9810 0 1 {name=p162015 lab=_83813_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 162700 -9810 0 0 {name=Xclkbuf_10_132_0_CLK }
C {devices/lab_pin.sym} 162620 -9710 0 0 {name=p162016 lab=_66285_/B }
C {devices/lab_pin.sym} 162620 -9670 0 0 {name=p162017 lab=_48103_/X }
C {devices/lab_pin.sym} 162620 -9630 0 0 {name=p162018 lab=_48107_/Y }
C {devices/lab_pin.sym} 162780 -9670 0 1 {name=p162019 lab=_48108_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -9670 0 0 {name=X_48108_ }
C {devices/lab_pin.sym} 162620 -9550 0 0 {name=p162020 lab=_64152_/X }
C {devices/lab_pin.sym} 162620 -9510 0 0 {name=p162021 lab=_64129_/X }
C {devices/lab_pin.sym} 162620 -9470 0 0 {name=p162022 lab=_64153_/Y }
C {devices/lab_pin.sym} 162780 -9510 0 1 {name=p162023 lab=_84270_/D }
C {sky130_stdcells/a21oi_4.sym} 162700 -9510 0 0 {name=X_64154_ }
C {devices/lab_pin.sym} 162640 -9390 0 0 {name=p162024 lab=_61377_/A }
C {devices/lab_pin.sym} 162640 -9350 0 0 {name=p162025 lab=_61365_/X }
C {devices/lab_pin.sym} 162640 -9310 0 0 {name=p162026 lab=_61377_/C }
C {devices/lab_pin.sym} 162760 -9350 0 1 {name=p162027 lab=_61366_/Y }
C {sky130_stdcells/nand3_4.sym} 162700 -9350 0 0 {name=X_61366_ }
C {devices/lab_pin.sym} 162620 -9230 0 0 {name=p162028 lab=_40601_/X }
C {devices/lab_pin.sym} 162620 -9190 0 0 {name=p162029 lab=_81197_/Q }
C {devices/lab_pin.sym} 162620 -9150 0 0 {name=p162030 lab=_49087_/Y }
C {devices/lab_pin.sym} 162780 -9190 0 1 {name=p162031 lab=_49089_/A }
C {sky130_stdcells/o21ai_4.sym} 162700 -9190 0 0 {name=X_49088_ }
C {devices/lab_pin.sym} 162660 -9050 0 0 {name=p162032 lab=clkbuf_9_381_0_CLK/X }
C {devices/lab_pin.sym} 162740 -9050 0 1 {name=p162033 lab=_87520_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 162700 -9050 0 0 {name=Xclkbuf_10_762_0_CLK }
C {devices/lab_pin.sym} 162620 -8950 0 0 {name=p162034 lab=_79427_/A }
C {devices/lab_pin.sym} 162620 -8910 0 0 {name=p162035 lab=_63072_/X }
C {devices/lab_pin.sym} 162620 -8870 0 0 {name=p162036 lab=_63104_/Y }
C {devices/lab_pin.sym} 162780 -8910 0 1 {name=p162037 lab=_63105_/X }
C {sky130_stdcells/a21o_4.sym} 162700 -8910 0 0 {name=X_63105_ }
C {devices/lab_pin.sym} 162640 -8790 0 0 {name=p162038 lab=_60317_/A }
C {devices/lab_pin.sym} 162640 -8750 0 0 {name=p162039 lab=_60244_/B }
C {devices/lab_pin.sym} 162640 -8710 0 0 {name=p162040 lab=_79733_/A }
C {devices/lab_pin.sym} 162760 -8750 0 1 {name=p162041 lab=_60317_/Y }
C {sky130_stdcells/nor3_4.sym} 162700 -8750 0 0 {name=X_60317_ }
C {devices/lab_pin.sym} 162660 -8610 0 0 {name=p162042 lab=_48039_/A }
C {devices/lab_pin.sym} 162740 -8610 0 1 {name=p162043 lab=_57590_/B }
C {sky130_stdcells/inv_2.sym} 162700 -8610 0 0 {name=X_48039_ }
C {devices/lab_pin.sym} 162660 -8490 0 0 {name=p162044 lab=_60034_/X }
C {devices/lab_pin.sym} 162740 -8490 0 1 {name=p162045 lab=_64116_/A }
C {sky130_stdcells/buf_2.sym} 162700 -8490 0 0 {name=X_64085_ }
C {devices/lab_pin.sym} 162640 -8380 0 0 {name=p162046 lab=_68750_/A }
C {devices/lab_pin.sym} 162640 -8340 0 0 {name=p162047 lab=_88347_/Q }
C {devices/lab_pin.sym} 162760 -8360 0 1 {name=p162048 lab=_68962_/X }
C {sky130_stdcells/and2_4.sym} 162700 -8360 0 0 {name=X_68962_ }
C {devices/lab_pin.sym} 162660 -8230 0 0 {name=p162049 lab=_72515_/D }
C {devices/lab_pin.sym} 162740 -8230 0 1 {name=p162050 lab=_72549_/B }
C {sky130_stdcells/buf_2.sym} 162700 -8230 0 0 {name=X_61297_ }
C {devices/lab_pin.sym} 162660 -8110 0 0 {name=p162051 lab=clkbuf_9_253_0_CLK/A }
C {devices/lab_pin.sym} 162740 -8110 0 1 {name=p162052 lab=clkbuf_9_253_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 162700 -8110 0 0 {name=Xclkbuf_9_253_0_CLK }
C {devices/lab_pin.sym} 162620 -8010 0 0 {name=p162053 lab=_86083_/Q }
C {devices/lab_pin.sym} 162620 -7970 0 0 {name=p162054 lab=_51047_/X }
C {devices/lab_pin.sym} 162620 -7930 0 0 {name=p162055 lab=_51049_/Y }
C {devices/lab_pin.sym} 162780 -7970 0 1 {name=p162056 lab=_51050_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -7970 0 0 {name=X_51050_ }
C {devices/lab_pin.sym} 162620 -7870 0 0 {name=p162057 lab=_58415_/A }
C {devices/lab_pin.sym} 162620 -7830 0 0 {name=p162058 lab=_63010_/X }
C {devices/lab_pin.sym} 162620 -7790 0 0 {name=p162059 lab=_60523_/X }
C {devices/lab_pin.sym} 162620 -7750 0 0 {name=p162060 lab=_59460_/A }
C {devices/lab_pin.sym} 162620 -7710 0 0 {name=p162061 lab=_60412_/X }
C {devices/lab_pin.sym} 162780 -7790 0 1 {name=p162062 lab=_63036_/Y }
C {sky130_stdcells/o32ai_4.sym} 162700 -7790 0 0 {name=X_63036_ }
C {devices/lab_pin.sym} 162620 -7660 0 0 {name=p162063 lab=_87899_/Q }
C {devices/lab_pin.sym} 162620 -7620 0 0 {name=p162064 lab=_67888_/X }
C {devices/lab_pin.sym} 162620 -7580 0 0 {name=p162065 lab=_67865_/X }
C {devices/lab_pin.sym} 162620 -7540 0 0 {name=p162066 lab=_67912_/X }
C {devices/lab_pin.sym} 162780 -7600 0 1 {name=p162067 lab=_67913_/X }
C {sky130_stdcells/a211o_4.sym} 162700 -7600 0 0 {name=X_67913_ }
C {devices/lab_pin.sym} 162620 -7480 0 0 {name=p162068 lab=_79846_/A }
C {devices/lab_pin.sym} 162620 -7440 0 0 {name=p162069 lab=_60246_/X }
C {devices/lab_pin.sym} 162620 -7400 0 0 {name=p162070 lab=_60247_/Y }
C {devices/lab_pin.sym} 162620 -7360 0 0 {name=p162071 lab=_60238_/Y }
C {devices/lab_pin.sym} 162780 -7420 0 1 {name=p162072 lab=_60248_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 162700 -7420 0 0 {name=X_60248_ }
C {devices/lab_pin.sym} 162620 -7300 0 0 {name=p162073 lab=_86986_/Q }
C {devices/lab_pin.sym} 162620 -7260 0 0 {name=p162074 lab=_68864_/X }
C {devices/lab_pin.sym} 162620 -7220 0 0 {name=p162075 lab=_68891_/X }
C {devices/lab_pin.sym} 162620 -7180 0 0 {name=p162076 lab=_68892_/X }
C {devices/lab_pin.sym} 162780 -7240 0 1 {name=p162077 lab=_68893_/X }
C {sky130_stdcells/a211o_4.sym} 162700 -7240 0 0 {name=X_68893_ }
C {devices/lab_pin.sym} 162660 -7090 0 0 {name=p162078 lab=clkbuf_9_73_0_CLK/X }
C {devices/lab_pin.sym} 162740 -7090 0 1 {name=p162079 lab=_81627_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 162700 -7090 0 0 {name=Xclkbuf_10_147_0_CLK }
C {devices/lab_pin.sym} 162640 -6980 0 0 {name=p162080 lab=_50001_/A }
C {devices/lab_pin.sym} 162640 -6940 0 0 {name=p162081 lab=_53213_/B }
C {devices/lab_pin.sym} 162760 -6960 0 1 {name=p162082 lab=_50001_/Y }
C {sky130_stdcells/nand2_4.sym} 162700 -6960 0 0 {name=X_50001_ }
C {devices/lab_pin.sym} 162610 -6830 0 0 {name=p162083 lab=_87416_/CLK }
C {devices/lab_pin.sym} 162610 -6810 0 0 {name=p162084 lab=_78287_/B }
C {devices/lab_pin.sym} 162790 -6830 0 1 {name=p162085 lab=_82910_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -6820 0 0 {name=X_82910_ }
C {devices/lab_pin.sym} 162620 -6720 0 0 {name=p162086 lab=_87966_/Q }
C {devices/lab_pin.sym} 162620 -6680 0 0 {name=p162087 lab=_67770_/X }
C {devices/lab_pin.sym} 162620 -6640 0 0 {name=p162088 lab=_67748_/X }
C {devices/lab_pin.sym} 162620 -6600 0 0 {name=p162089 lab=_67843_/X }
C {devices/lab_pin.sym} 162780 -6660 0 1 {name=p162090 lab=_67844_/X }
C {sky130_stdcells/a211o_4.sym} 162700 -6660 0 0 {name=X_67844_ }
C {devices/lab_pin.sym} 162610 -6510 0 0 {name=p162091 lab=_82339_/CLK }
C {devices/lab_pin.sym} 162610 -6490 0 0 {name=p162092 lab=_83890_/D }
C {devices/lab_pin.sym} 162790 -6510 0 1 {name=p162093 lab=_81962_/D }
C {sky130_stdcells/dfxtp_4.sym} 162700 -6500 0 0 {name=X_83890_ }
C {devices/lab_pin.sym} 162660 -6370 0 0 {name=p162094 lab=_60179_/A }
C {devices/lab_pin.sym} 162740 -6370 0 1 {name=p162095 lab=_60179_/Y }
C {sky130_stdcells/inv_2.sym} 162700 -6370 0 0 {name=X_60179_ }
C {devices/lab_pin.sym} 162660 -6250 0 0 {name=p162096 lab=clkbuf_9_388_0_CLK/X }
C {devices/lab_pin.sym} 162740 -6250 0 1 {name=p162097 lab=_82485_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 162700 -6250 0 0 {name=Xclkbuf_10_777_0_CLK }
C {devices/lab_pin.sym} 162610 -6130 0 0 {name=p162098 lab=_82152_/CLK }
C {devices/lab_pin.sym} 162610 -6110 0 0 {name=p162099 lab=_79432_/X }
C {devices/lab_pin.sym} 162790 -6130 0 1 {name=p162100 lab=_82841_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -6120 0 0 {name=X_82841_ }
C {devices/lab_pin.sym} 162620 -6010 0 0 {name=p162101 lab=_67772_/X }
C {devices/lab_pin.sym} 162620 -5970 0 0 {name=p162102 lab=_67774_/X }
C {devices/lab_pin.sym} 162620 -5930 0 0 {name=p162103 lab=_67681_/X }
C {devices/lab_pin.sym} 162780 -5970 0 1 {name=p162104 lab=_67775_/X }
C {sky130_stdcells/a21o_4.sym} 162700 -5970 0 0 {name=X_67775_ }
C {devices/lab_pin.sym} 162640 -5840 0 0 {name=p162105 lab=_65012_/A }
C {devices/lab_pin.sym} 162640 -5800 0 0 {name=p162106 lab=_86259_/Q }
C {devices/lab_pin.sym} 162760 -5820 0 1 {name=p162107 lab=_64987_/X }
C {sky130_stdcells/and2_4.sym} 162700 -5820 0 0 {name=X_64987_ }
C {devices/lab_pin.sym} 162660 -5690 0 0 {name=p162108 lab=clkbuf_9_269_0_CLK/A }
C {devices/lab_pin.sym} 162740 -5690 0 1 {name=p162109 lab=clkbuf_9_268_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 162700 -5690 0 0 {name=Xclkbuf_9_268_0_CLK }
C {devices/lab_pin.sym} 162620 -5600 0 0 {name=p162110 lab=_87012_/Q }
C {devices/lab_pin.sym} 162620 -5560 0 0 {name=p162111 lab=_69457_/X }
C {devices/lab_pin.sym} 162620 -5520 0 0 {name=p162112 lab=_69458_/X }
C {devices/lab_pin.sym} 162620 -5480 0 0 {name=p162113 lab=_69513_/X }
C {devices/lab_pin.sym} 162780 -5540 0 1 {name=p162114 lab=_69515_/B }
C {sky130_stdcells/a211o_4.sym} 162700 -5540 0 0 {name=X_69514_ }
C {devices/lab_pin.sym} 162620 -5410 0 0 {name=p162115 lab=_54737_/Y }
C {devices/lab_pin.sym} 162620 -5370 0 0 {name=p162116 lab=_54720_/X }
C {devices/lab_pin.sym} 162620 -5330 0 0 {name=p162117 lab=_54739_/X }
C {devices/lab_pin.sym} 162780 -5370 0 1 {name=p162118 lab=_85387_/D }
C {sky130_stdcells/a21oi_4.sym} 162700 -5370 0 0 {name=X_54740_ }
C {devices/lab_pin.sym} 162660 -5230 0 0 {name=p162119 lab=_66606_/A }
C {devices/lab_pin.sym} 162740 -5230 0 1 {name=p162120 lab=_66726_/X }
C {sky130_stdcells/buf_2.sym} 162700 -5230 0 0 {name=X_66726_ }
C {devices/lab_pin.sym} 162610 -5110 0 0 {name=p162121 lab=_83305_/CLK }
C {devices/lab_pin.sym} 162610 -5090 0 0 {name=p162122 lab=_53831_/Y }
C {devices/lab_pin.sym} 162790 -5110 0 1 {name=p162123 lab=_85560_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -5100 0 0 {name=X_85560_ }
C {devices/lab_pin.sym} 162640 -4990 0 0 {name=p162124 lab=_48196_/A }
C {devices/lab_pin.sym} 162640 -4950 0 0 {name=p162125 lab=_51352_/B }
C {devices/lab_pin.sym} 162640 -4910 0 0 {name=p162126 lab=_50830_/C }
C {devices/lab_pin.sym} 162760 -4950 0 1 {name=p162127 lab=_51952_/X }
C {sky130_stdcells/and3_4.sym} 162700 -4950 0 0 {name=X_51952_ }
C {devices/lab_pin.sym} 162640 -4840 0 0 {name=p162128 lab=_57670_/A }
C {devices/lab_pin.sym} 162640 -4800 0 0 {name=p162129 lab=_63902_/B }
C {devices/lab_pin.sym} 162640 -4760 0 0 {name=p162130 lab=_63902_/C }
C {devices/lab_pin.sym} 162640 -4720 0 0 {name=p162131 lab=_63902_/D }
C {devices/lab_pin.sym} 162760 -4780 0 1 {name=p162132 lab=_63939_/D }
C {sky130_stdcells/nand4_4.sym} 162700 -4780 0 0 {name=X_63938_ }
C {devices/lab_pin.sym} 162610 -4630 0 0 {name=p162133 lab=_82965_/CLK }
C {devices/lab_pin.sym} 162610 -4610 0 0 {name=p162134 lab=_82772_/D }
C {devices/lab_pin.sym} 162790 -4630 0 1 {name=p162135 lab=_82964_/D }
C {sky130_stdcells/dfxtp_4.sym} 162700 -4620 0 0 {name=X_82772_ }
C {devices/lab_pin.sym} 162660 -4490 0 0 {name=p162136 lab=clkbuf_9_350_0_CLK/X }
C {devices/lab_pin.sym} 162740 -4490 0 1 {name=p162137 lab=_88201_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 162700 -4490 0 0 {name=Xclkbuf_10_700_0_CLK }
C {devices/lab_pin.sym} 162610 -4370 0 0 {name=p162138 lab=_84241_/CLK }
C {devices/lab_pin.sym} 162610 -4350 0 0 {name=p162139 lab=_61189_/X }
C {devices/lab_pin.sym} 162790 -4370 0 1 {name=p162140 lab=_84511_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -4360 0 0 {name=X_84511_ }
C {devices/lab_pin.sym} 162660 -4230 0 0 {name=p162141 lab=_50929_/A }
C {devices/lab_pin.sym} 162740 -4230 0 1 {name=p162142 lab=_50919_/B }
C {sky130_stdcells/buf_2.sym} 162700 -4230 0 0 {name=X_50903_ }
C {devices/lab_pin.sym} 162610 -4110 0 0 {name=p162143 lab=_84020_/CLK }
C {devices/lab_pin.sym} 162610 -4090 0 0 {name=p162144 lab=_81723_/D }
C {devices/lab_pin.sym} 162790 -4110 0 1 {name=p162145 lab=_81723_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -4100 0 0 {name=X_81723_ }
C {devices/lab_pin.sym} 162620 -3990 0 0 {name=p162146 lab=_69441_/X }
C {devices/lab_pin.sym} 162620 -3950 0 0 {name=p162147 lab=_69444_/X }
C {devices/lab_pin.sym} 162620 -3910 0 0 {name=p162148 lab=_69399_/X }
C {devices/lab_pin.sym} 162780 -3950 0 1 {name=p162149 lab=_69445_/X }
C {sky130_stdcells/a21o_4.sym} 162700 -3950 0 0 {name=X_69445_ }
C {devices/lab_pin.sym} 162660 -3810 0 0 {name=p162150 lab=_54616_/X }
C {devices/lab_pin.sym} 162740 -3810 0 1 {name=p162151 lab=_54674_/A }
C {sky130_stdcells/buf_2.sym} 162700 -3810 0 0 {name=X_54671_ }
C {devices/lab_pin.sym} 162610 -3690 0 0 {name=p162152 lab=_85491_/CLK }
C {devices/lab_pin.sym} 162610 -3670 0 0 {name=p162153 lab=_85491_/D }
C {devices/lab_pin.sym} 162790 -3690 0 1 {name=p162154 lab=_85491_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -3680 0 0 {name=X_85491_ }
C {devices/lab_pin.sym} 162620 -3580 0 0 {name=p162155 lab=_87132_/Q }
C {devices/lab_pin.sym} 162620 -3540 0 0 {name=p162156 lab=_66633_/X }
C {devices/lab_pin.sym} 162620 -3500 0 0 {name=p162157 lab=_46212_/A }
C {devices/lab_pin.sym} 162620 -3460 0 0 {name=p162158 lab=_66656_/X }
C {devices/lab_pin.sym} 162780 -3520 0 1 {name=p162159 lab=_66657_/X }
C {sky130_stdcells/a211o_4.sym} 162700 -3520 0 0 {name=X_66657_ }
C {devices/lab_pin.sym} 162620 -3390 0 0 {name=p162160 lab=_51881_/Y }
C {devices/lab_pin.sym} 162620 -3350 0 0 {name=p162161 lab=_51877_/X }
C {devices/lab_pin.sym} 162620 -3310 0 0 {name=p162162 lab=_51882_/X }
C {devices/lab_pin.sym} 162780 -3350 0 1 {name=p162163 lab=_51883_/Y }
C {sky130_stdcells/a21oi_4.sym} 162700 -3350 0 0 {name=X_51883_ }
C {devices/lab_pin.sym} 162640 -3240 0 0 {name=p162164 lab=_63459_/B }
C {devices/lab_pin.sym} 162640 -3200 0 0 {name=p162165 lab=_63900_/B }
C {devices/lab_pin.sym} 162640 -3160 0 0 {name=p162166 lab=_63900_/C }
C {devices/lab_pin.sym} 162640 -3120 0 0 {name=p162167 lab=_63900_/D }
C {devices/lab_pin.sym} 162760 -3180 0 1 {name=p162168 lab=_63869_/Y }
C {sky130_stdcells/nand4_4.sym} 162700 -3180 0 0 {name=X_63869_ }
C {devices/lab_pin.sym} 162660 -3030 0 0 {name=p162169 lab=_56435_/A }
C {devices/lab_pin.sym} 162740 -3030 0 1 {name=p162170 lab=_56418_/A }
C {sky130_stdcells/buf_2.sym} 162700 -3030 0 0 {name=X_56410_ }
C {devices/lab_pin.sym} 162610 -2910 0 0 {name=p162171 lab=_87748_/CLK }
C {devices/lab_pin.sym} 162610 -2890 0 0 {name=p162172 lab=_87230_/D }
C {devices/lab_pin.sym} 162790 -2910 0 1 {name=p162173 lab=_68898_/B }
C {sky130_stdcells/dfxtp_4.sym} 162700 -2900 0 0 {name=X_87230_ }
C {devices/lab_pin.sym} 162640 -2780 0 0 {name=p162174 lab=_53622_/A }
C {devices/lab_pin.sym} 162640 -2740 0 0 {name=p162175 lab=_48367_/Y }
C {devices/lab_pin.sym} 162760 -2760 0 1 {name=p162176 lab=_53622_/Y }
C {sky130_stdcells/nand2_4.sym} 162700 -2760 0 0 {name=X_53622_ }
C {devices/lab_pin.sym} 162640 -2650 0 0 {name=p162177 lab=_64933_/X }
C {devices/lab_pin.sym} 162640 -2610 0 0 {name=p162178 lab=_65653_/B }
C {devices/lab_pin.sym} 162640 -2570 0 0 {name=p162179 lab=_64936_/X }
C {devices/lab_pin.sym} 162760 -2610 0 1 {name=p162180 lab=_65608_/Y }
C {sky130_stdcells/nand3_4.sym} 162700 -2610 0 0 {name=X_65608_ }
