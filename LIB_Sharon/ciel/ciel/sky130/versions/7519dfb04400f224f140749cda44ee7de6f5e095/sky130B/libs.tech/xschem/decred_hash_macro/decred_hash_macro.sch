C {devices/lab_pin.sym} 35660 -3480 0 0 {name=p35626 lab=_83078_/Q }
C {devices/lab_pin.sym} 35660 -3440 0 0 {name=p35627 lab=_72785_/X }
C {devices/lab_pin.sym} 35660 -3400 0 0 {name=p35628 lab=_72843_/X }
C {devices/lab_pin.sym} 35820 -3460 0 1 {name=p35629 lab=_72844_/X }
C {sky130_stdcells/a211o_4.sym} 35740 -3460 0 0 {name=X_72844_ }
C {devices/lab_pin.sym} 35700 -3310 0 0 {name=p35630 lab=_85063_/Q }
C {devices/lab_pin.sym} 35780 -3310 0 1 {name=p35631 lab=_45792_/Y }
C {sky130_stdcells/inv_2.sym} 35740 -3310 0 0 {name=X_45792_ }
C {devices/lab_pin.sym} 35700 -3190 0 0 {name=p35632 lab=_58002_/A }
C {devices/lab_pin.sym} 35780 -3190 0 1 {name=p35633 lab=_72201_/A }
C {sky130_stdcells/buf_2.sym} 35740 -3190 0 0 {name=X_57778_ }
C {devices/lab_pin.sym} 35700 -3070 0 0 {name=p35634 lab=clkbuf_9_270_0_CLK/X }
C {devices/lab_pin.sym} 35780 -3070 0 1 {name=p35635 lab=_83933_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 35740 -3070 0 0 {name=Xclkbuf_10_540_0_CLK }
C {devices/lab_pin.sym} 35700 -2950 0 0 {name=p35636 lab=clkbuf_6_31_0_CLK/A }
C {devices/lab_pin.sym} 35780 -2950 0 1 {name=p35637 lab=clkbuf_7_63_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 35740 -2950 0 0 {name=Xclkbuf_6_31_0_CLK }
C {devices/lab_pin.sym} 35700 -2830 0 0 {name=p35638 lab=_81249_/Q }
C {devices/lab_pin.sym} 35780 -2830 0 1 {name=p35639 lab=_47532_/A }
C {sky130_stdcells/inv_2.sym} 35740 -2830 0 0 {name=X_47531_ }
C {devices/lab_pin.sym} 35680 -2730 0 0 {name=p35640 lab=_43959_/A }
C {devices/lab_pin.sym} 35680 -2690 0 0 {name=p35641 lab=_45941_/A }
C {devices/lab_pin.sym} 35680 -2650 0 0 {name=p35642 lab=_43959_/B }
C {devices/lab_pin.sym} 35800 -2690 0 1 {name=p35643 lab=_59517_/Y }
C {sky130_stdcells/nand3_4.sym} 35740 -2690 0 0 {name=X_59517_ }
C {devices/lab_pin.sym} 35660 -2570 0 0 {name=p35644 lab=_78325_/B }
C {devices/lab_pin.sym} 35660 -2530 0 0 {name=p35645 lab=_78339_/A }
C {devices/lab_pin.sym} 35660 -2490 0 0 {name=p35646 lab=_78338_/A }
C {devices/lab_pin.sym} 35820 -2530 0 1 {name=p35647 lab=_78353_/A }
C {sky130_stdcells/o21ai_4.sym} 35740 -2530 0 0 {name=X_78351_ }
C {devices/lab_pin.sym} 35700 -2390 0 0 {name=p35648 lab=_57140_/A }
C {devices/lab_pin.sym} 35780 -2390 0 1 {name=p35649 lab=_56729_/X }
C {sky130_stdcells/buf_2.sym} 35740 -2390 0 0 {name=X_56729_ }
C {devices/lab_pin.sym} 35660 -2310 0 0 {name=p35650 lab=_44740_/X }
C {devices/lab_pin.sym} 35660 -2270 0 0 {name=p35651 lab=_44741_/X }
C {devices/lab_pin.sym} 35660 -2230 0 0 {name=p35652 lab=_40743_/X }
C {devices/lab_pin.sym} 35660 -2190 0 0 {name=p35653 lab=_86979_/Q }
C {devices/lab_pin.sym} 35660 -2150 0 0 {name=p35654 lab=_44742_/X }
C {devices/lab_pin.sym} 35820 -2230 0 1 {name=p35655 lab=_44744_/A }
C {sky130_stdcells/o32ai_4.sym} 35740 -2230 0 0 {name=X_44743_ }
C {devices/lab_pin.sym} 35680 -2080 0 0 {name=p35656 lab=_75561_/Y }
C {devices/lab_pin.sym} 35680 -2040 0 0 {name=p35657 lab=_75563_/B }
C {devices/lab_pin.sym} 35800 -2060 0 1 {name=p35658 lab=_81057_/D }
C {sky130_stdcells/nand2_4.sym} 35740 -2060 0 0 {name=X_75563_ }
C {devices/lab_pin.sym} 35650 -1930 0 0 {name=p35659 lab=_87813_/CLK }
C {devices/lab_pin.sym} 35650 -1910 0 0 {name=p35660 lab=_43174_/Y }
C {devices/lab_pin.sym} 35830 -1930 0 1 {name=p35661 lab=_73323_/A }
C {sky130_stdcells/dfxtp_4.sym} 35740 -1920 0 0 {name=X_87549_ }
C {devices/lab_pin.sym} 35700 -1790 0 0 {name=p35662 lab=_41955_/A }
C {devices/lab_pin.sym} 35780 -1790 0 1 {name=p35663 lab=_41955_/Y }
C {sky130_stdcells/inv_2.sym} 35740 -1790 0 0 {name=X_41955_ }
C {devices/lab_pin.sym} 35700 -1670 0 0 {name=p35664 lab=_56274_/X }
C {devices/lab_pin.sym} 35780 -1670 0 1 {name=p35665 lab=_72775_/X }
C {sky130_stdcells/buf_2.sym} 35740 -1670 0 0 {name=X_72775_ }
C {devices/lab_pin.sym} 35660 -1570 0 0 {name=p35666 lab=_77287_/A }
C {devices/lab_pin.sym} 35660 -1530 0 0 {name=p35667 lab=_77290_/B }
C {devices/lab_pin.sym} 35660 -1490 0 0 {name=p35668 lab=_77286_/A }
C {devices/lab_pin.sym} 35820 -1530 0 1 {name=p35669 lab=_77302_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -1530 0 0 {name=X_77302_ }
C {devices/lab_pin.sym} 35660 -1410 0 0 {name=p35670 lab=_74512_/Y }
C {devices/lab_pin.sym} 35660 -1370 0 0 {name=p35671 lab=_46300_/X }
C {devices/lab_pin.sym} 35660 -1330 0 0 {name=p35672 lab=_74513_/Y }
C {devices/lab_pin.sym} 35820 -1370 0 1 {name=p35673 lab=_83050_/D }
C {sky130_stdcells/a21boi_4.sym} 35740 -1370 0 0 {name=X_74514_ }
C {devices/lab_pin.sym} 35660 -1260 0 0 {name=p35674 lab=_40903_/X }
C {devices/lab_pin.sym} 35660 -1220 0 0 {name=p35675 lab=_40904_/X }
C {devices/lab_pin.sym} 35660 -1180 0 0 {name=p35676 lab=_88313_/Q }
C {devices/lab_pin.sym} 35660 -1140 0 0 {name=p35677 lab=_40905_/X }
C {devices/lab_pin.sym} 35820 -1200 0 1 {name=p35678 lab=_88313_/D }
C {sky130_stdcells/a2bb2o_4.sym} 35740 -1200 0 0 {name=X_40906_ }
C {devices/lab_pin.sym} 35700 -1050 0 0 {name=p35679 lab=_47414_/A }
C {devices/lab_pin.sym} 35780 -1050 0 1 {name=p35680 lab=_47462_/X }
C {sky130_stdcells/buf_2.sym} 35740 -1050 0 0 {name=X_47462_ }
C {devices/lab_pin.sym} 35660 -950 0 0 {name=p35681 lab=_58229_/Y }
C {devices/lab_pin.sym} 35660 -910 0 0 {name=p35682 lab=_71718_/X }
C {devices/lab_pin.sym} 35660 -870 0 0 {name=p35683 lab=_71725_/Y }
C {devices/lab_pin.sym} 35820 -910 0 1 {name=p35684 lab=_71726_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -910 0 0 {name=X_71726_ }
C {devices/lab_pin.sym} 35680 -780 0 0 {name=p35685 lab=_59448_/A }
C {devices/lab_pin.sym} 35680 -740 0 0 {name=p35686 lab=_59444_/X }
C {devices/lab_pin.sym} 35800 -760 0 1 {name=p35687 lab=_59448_/Y }
C {sky130_stdcells/nand2_4.sym} 35740 -760 0 0 {name=X_59448_ }
C {devices/lab_pin.sym} 36600 -42160 0 0 {name=p35688 lab=_78282_/A }
C {devices/lab_pin.sym} 36600 -42120 0 0 {name=p35689 lab=_78281_/Y }
C {devices/lab_pin.sym} 36720 -42140 0 1 {name=p35690 lab=_78282_/X }
C {sky130_stdcells/or2_4.sym} 36660 -42140 0 0 {name=X_78282_ }
C {devices/lab_pin.sym} 36620 -42010 0 0 {name=p35691 lab=_44674_/A }
C {devices/lab_pin.sym} 36700 -42010 0 1 {name=p35692 lab=_44674_/Y }
C {sky130_stdcells/inv_2.sym} 36660 -42010 0 0 {name=X_44674_ }
C {devices/lab_pin.sym} 36620 -41890 0 0 {name=p35693 lab=_81086_/Q }
C {devices/lab_pin.sym} 36700 -41890 0 1 {name=p35694 lab=_75498_/A }
C {sky130_stdcells/inv_2.sym} 36660 -41890 0 0 {name=X_75494_ }
C {devices/lab_pin.sym} 36620 -41770 0 0 {name=p35695 lab=_42059_/A }
C {devices/lab_pin.sym} 36700 -41770 0 1 {name=p35696 lab=_41887_/A }
C {sky130_stdcells/buf_2.sym} 36660 -41770 0 0 {name=X_41886_ }
C {devices/lab_pin.sym} 36620 -41650 0 0 {name=p35697 lab=_72113_/A }
C {devices/lab_pin.sym} 36700 -41650 0 1 {name=p35698 lab=_50209_/A }
C {sky130_stdcells/buf_2.sym} 36660 -41650 0 0 {name=X_49201_ }
C {devices/lab_pin.sym} 36580 -41550 0 0 {name=p35699 lab=_86739_/Q }
C {devices/lab_pin.sym} 36580 -41510 0 0 {name=p35700 lab=_46364_/X }
C {devices/lab_pin.sym} 36580 -41470 0 0 {name=p35701 lab=_46412_/Y }
C {devices/lab_pin.sym} 36740 -41510 0 1 {name=p35702 lab=_46413_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -41510 0 0 {name=X_46413_ }
C {devices/lab_pin.sym} 36600 -41380 0 0 {name=p35703 lab=_77233_/A }
C {devices/lab_pin.sym} 36600 -41340 0 0 {name=p35704 lab=_82082_/D }
C {devices/lab_pin.sym} 36720 -41360 0 1 {name=p35705 lab=_77233_/X }
C {sky130_stdcells/xor2_4.sym} 36660 -41360 0 0 {name=X_77233_ }
C {devices/lab_pin.sym} 36620 -41230 0 0 {name=p35706 lab=_43607_/A }
C {devices/lab_pin.sym} 36700 -41230 0 1 {name=p35707 lab=_43625_/X }
C {sky130_stdcells/buf_2.sym} 36660 -41230 0 0 {name=X_43625_ }
C {devices/lab_pin.sym} 36600 -41130 0 0 {name=p35708 lab=_48544_/A }
C {devices/lab_pin.sym} 36600 -41090 0 0 {name=p35709 lab=_74420_/X }
C {devices/lab_pin.sym} 36600 -41050 0 0 {name=p35710 lab=_74425_/X }
C {devices/lab_pin.sym} 36720 -41090 0 1 {name=p35711 lab=_74445_/X }
C {sky130_stdcells/and3_4.sym} 36660 -41090 0 0 {name=X_74445_ }
C {devices/lab_pin.sym} 36600 -40960 0 0 {name=p35712 lab=_82867_/Q }
C {devices/lab_pin.sym} 36600 -40920 0 0 {name=p35713 lab=_40847_/B }
C {devices/lab_pin.sym} 36720 -40940 0 1 {name=p35714 lab=_40837_/X }
C {sky130_stdcells/or2_4.sym} 36660 -40940 0 0 {name=X_40837_ }
C {devices/lab_pin.sym} 36620 -40810 0 0 {name=p35715 lab=clkbuf_9_277_0_CLK/X }
C {devices/lab_pin.sym} 36700 -40810 0 1 {name=p35716 lab=_87473_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 36660 -40810 0 0 {name=Xclkbuf_10_555_0_CLK }
C {devices/lab_pin.sym} 36580 -40710 0 0 {name=p35717 lab=_47388_/Y }
C {devices/lab_pin.sym} 36580 -40670 0 0 {name=p35718 lab=_47364_/X }
C {devices/lab_pin.sym} 36580 -40630 0 0 {name=p35719 lab=_47392_/X }
C {devices/lab_pin.sym} 36740 -40670 0 1 {name=p35720 lab=_86640_/D }
C {sky130_stdcells/a21oi_4.sym} 36660 -40670 0 0 {name=X_47393_ }
C {devices/lab_pin.sym} 36580 -40550 0 0 {name=p35721 lab=_59346_/X }
C {devices/lab_pin.sym} 36580 -40510 0 0 {name=p35722 lab=_85634_/Q }
C {devices/lab_pin.sym} 36580 -40470 0 0 {name=p35723 lab=_59308_/X }
C {devices/lab_pin.sym} 36740 -40510 0 1 {name=p35724 lab=_59379_/X }
C {sky130_stdcells/o21a_4.sym} 36660 -40510 0 0 {name=X_59379_ }
C {devices/lab_pin.sym} 36580 -40390 0 0 {name=p35725 lab=_58508_/Y }
C {devices/lab_pin.sym} 36580 -40350 0 0 {name=p35726 lab=_71649_/X }
C {devices/lab_pin.sym} 36580 -40310 0 0 {name=p35727 lab=_71656_/Y }
C {devices/lab_pin.sym} 36740 -40350 0 1 {name=p35728 lab=_71657_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -40350 0 0 {name=X_71657_ }
C {devices/lab_pin.sym} 36620 -40210 0 0 {name=p35729 lab=clkbuf_6_47_0_CLK/A }
C {devices/lab_pin.sym} 36700 -40210 0 1 {name=p35730 lab=clkbuf_7_93_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 36660 -40210 0 0 {name=Xclkbuf_6_46_0_CLK }
C {devices/lab_pin.sym} 36620 -40090 0 0 {name=p35731 lab=_61409_/Y }
C {devices/lab_pin.sym} 36700 -40090 0 1 {name=p35732 lab=_61410_/Y }
C {sky130_stdcells/inv_2.sym} 36660 -40090 0 0 {name=X_61410_ }
C {devices/lab_pin.sym} 36600 -39980 0 0 {name=p35733 lab=_49080_/A }
C {devices/lab_pin.sym} 36600 -39940 0 0 {name=p35734 lab=_72079_/B }
C {devices/lab_pin.sym} 36720 -39960 0 1 {name=p35735 lab=_49132_/X }
C {sky130_stdcells/and2_4.sym} 36660 -39960 0 0 {name=X_49132_ }
C {devices/lab_pin.sym} 36600 -39840 0 0 {name=p35736 lab=_46326_/A }
C {devices/lab_pin.sym} 36600 -39800 0 0 {name=p35737 lab=_49245_/B }
C {devices/lab_pin.sym} 36720 -39820 0 1 {name=p35738 lab=_46344_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -39820 0 0 {name=X_46344_ }
C {devices/lab_pin.sym} 36620 -39690 0 0 {name=p35739 lab=_70997_/A }
C {devices/lab_pin.sym} 36700 -39690 0 1 {name=p35740 lab=_70719_/A }
C {sky130_stdcells/buf_2.sym} 36660 -39690 0 0 {name=X_70608_ }
C {devices/lab_pin.sym} 36600 -39580 0 0 {name=p35741 lab=_77173_/B }
C {devices/lab_pin.sym} 36600 -39540 0 0 {name=p35742 lab=_77173_/C }
C {devices/lab_pin.sym} 36720 -39560 0 1 {name=p35743 lab=_77167_/A }
C {sky130_stdcells/nand2_4.sym} 36660 -39560 0 0 {name=X_77164_ }
C {devices/lab_pin.sym} 36620 -39430 0 0 {name=p35744 lab=_43555_/Y }
C {devices/lab_pin.sym} 36700 -39430 0 1 {name=p35745 lab=_87362_/D }
C {sky130_stdcells/inv_2.sym} 36660 -39430 0 0 {name=X_43556_ }
C {devices/lab_pin.sym} 36620 -39310 0 0 {name=p35746 lab=_62623_/C }
C {devices/lab_pin.sym} 36700 -39310 0 1 {name=p35747 lab=_62390_/X }
C {sky130_stdcells/buf_2.sym} 36660 -39310 0 0 {name=X_62390_ }
C {devices/lab_pin.sym} 36580 -39210 0 0 {name=p35748 lab=_74374_/Y }
C {devices/lab_pin.sym} 36580 -39170 0 0 {name=p35749 lab=_74370_/X }
C {devices/lab_pin.sym} 36580 -39130 0 0 {name=p35750 lab=_74375_/X }
C {devices/lab_pin.sym} 36740 -39170 0 1 {name=p35751 lab=_74376_/Y }
C {sky130_stdcells/a21oi_4.sym} 36660 -39170 0 0 {name=X_74376_ }
C {devices/lab_pin.sym} 36580 -39060 0 0 {name=p35752 lab=_40767_/X }
C {devices/lab_pin.sym} 36580 -39020 0 0 {name=p35753 lab=_40754_/X }
C {devices/lab_pin.sym} 36580 -38980 0 0 {name=p35754 lab=_88339_/Q }
C {devices/lab_pin.sym} 36580 -38940 0 0 {name=p35755 lab=_40756_/X }
C {devices/lab_pin.sym} 36740 -39000 0 1 {name=p35756 lab=_88339_/D }
C {sky130_stdcells/a2bb2o_4.sym} 36660 -39000 0 0 {name=X_40768_ }
C {devices/lab_pin.sym} 36600 -38870 0 0 {name=p35757 lab=_71698_/A }
C {devices/lab_pin.sym} 36600 -38830 0 0 {name=p35758 lab=_71590_/B }
C {devices/lab_pin.sym} 36600 -38790 0 0 {name=p35759 lab=_71582_/X }
C {devices/lab_pin.sym} 36720 -38830 0 1 {name=p35760 lab=_71588_/Y }
C {sky130_stdcells/nor3_4.sym} 36660 -38830 0 0 {name=X_71588_ }
C {devices/lab_pin.sym} 36620 -38690 0 0 {name=p35761 lab=_76114_/X }
C {devices/lab_pin.sym} 36700 -38690 0 1 {name=p35762 lab=_76126_/A }
C {sky130_stdcells/buf_2.sym} 36660 -38690 0 0 {name=X_76115_ }
C {devices/lab_pin.sym} 36580 -38610 0 0 {name=p35763 lab=_42495_/X }
C {devices/lab_pin.sym} 36580 -38570 0 0 {name=p35764 lab=_42496_/X }
C {devices/lab_pin.sym} 36580 -38530 0 0 {name=p35765 lab=_40691_/X }
C {devices/lab_pin.sym} 36580 -38490 0 0 {name=p35766 lab=_87841_/Q }
C {devices/lab_pin.sym} 36580 -38450 0 0 {name=p35767 lab=_42506_/X }
C {devices/lab_pin.sym} 36740 -38530 0 1 {name=p35768 lab=_42508_/A }
C {sky130_stdcells/o32ai_4.sym} 36660 -38530 0 0 {name=X_42507_ }
C {devices/lab_pin.sym} 36620 -38370 0 0 {name=p35769 lab=_83607_/Q }
C {devices/lab_pin.sym} 36700 -38370 0 1 {name=p35770 lab=_49064_/A }
C {sky130_stdcells/inv_2.sym} 36660 -38370 0 0 {name=X_49063_ }
C {devices/lab_pin.sym} 36620 -38250 0 0 {name=p35771 lab=_61317_/X }
C {devices/lab_pin.sym} 36700 -38250 0 1 {name=p35772 lab=_61368_/C }
C {sky130_stdcells/buf_2.sym} 36660 -38250 0 0 {name=X_61341_ }
C {devices/lab_pin.sym} 36580 -38150 0 0 {name=p35773 lab=_87049_/Q }
C {devices/lab_pin.sym} 36580 -38110 0 0 {name=p35774 lab=_73370_/B }
C {devices/lab_pin.sym} 36580 -38070 0 0 {name=p35775 lab=_73326_/X }
C {devices/lab_pin.sym} 36740 -38110 0 1 {name=p35776 lab=_73327_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -38110 0 0 {name=X_73327_ }
C {devices/lab_pin.sym} 36580 -37990 0 0 {name=p35777 lab=_46262_/X }
C {devices/lab_pin.sym} 36580 -37950 0 0 {name=p35778 lab=_81215_/Q }
C {devices/lab_pin.sym} 36580 -37910 0 0 {name=p35779 lab=_46274_/X }
C {devices/lab_pin.sym} 36740 -37950 0 1 {name=p35780 lab=_46276_/A }
C {sky130_stdcells/o21ai_4.sym} 36660 -37950 0 0 {name=X_46275_ }
C {devices/lab_pin.sym} 36620 -37810 0 0 {name=p35781 lab=_70361_/A }
C {devices/lab_pin.sym} 36700 -37810 0 1 {name=p35782 lab=_71215_/C }
C {sky130_stdcells/buf_2.sym} 36660 -37810 0 0 {name=X_70539_ }
C {devices/lab_pin.sym} 36600 -37700 0 0 {name=p35783 lab=_77114_/B }
C {devices/lab_pin.sym} 36600 -37660 0 0 {name=p35784 lab=_82288_/D }
C {devices/lab_pin.sym} 36720 -37680 0 1 {name=p35785 lab=_77112_/A }
C {sky130_stdcells/xor2_4.sym} 36660 -37680 0 0 {name=X_77095_ }
C {devices/lab_pin.sym} 36580 -37590 0 0 {name=p35786 lab=_43472_/X }
C {devices/lab_pin.sym} 36580 -37550 0 0 {name=p35787 lab=_43475_/X }
C {devices/lab_pin.sym} 36580 -37510 0 0 {name=p35788 lab=_41705_/X }
C {devices/lab_pin.sym} 36580 -37470 0 0 {name=p35789 lab=_87397_/Q }
C {devices/lab_pin.sym} 36580 -37430 0 0 {name=p35790 lab=_43479_/X }
C {devices/lab_pin.sym} 36740 -37510 0 1 {name=p35791 lab=_43488_/A }
C {sky130_stdcells/o32ai_4.sym} 36660 -37510 0 0 {name=X_43487_ }
C {devices/lab_pin.sym} 36620 -37350 0 0 {name=p35792 lab=_40784_/A }
C {devices/lab_pin.sym} 36700 -37350 0 1 {name=p35793 lab=_40760_/B }
C {sky130_stdcells/buf_2.sym} 36660 -37350 0 0 {name=X_40699_ }
C {devices/lab_pin.sym} 36620 -37230 0 0 {name=p35794 lab=_83544_/Q }
C {devices/lab_pin.sym} 36700 -37230 0 1 {name=p35795 lab=_48014_/Y }
C {sky130_stdcells/inv_2.sym} 36660 -37230 0 0 {name=X_48014_ }
C {devices/lab_pin.sym} 36580 -37130 0 0 {name=p35796 lab=_85196_/Q }
C {devices/lab_pin.sym} 36580 -37090 0 0 {name=p35797 lab=_45176_/X }
C {devices/lab_pin.sym} 36580 -37050 0 0 {name=p35798 lab=_45225_/X }
C {devices/lab_pin.sym} 36740 -37090 0 1 {name=p35799 lab=_45226_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -37090 0 0 {name=X_45226_ }
C {devices/lab_pin.sym} 36600 -36980 0 0 {name=p35800 lab=_63238_/B }
C {devices/lab_pin.sym} 36600 -36940 0 0 {name=p35801 lab=_64145_/B }
C {devices/lab_pin.sym} 36600 -36900 0 0 {name=p35802 lab=_64029_/C }
C {devices/lab_pin.sym} 36600 -36860 0 0 {name=p35803 lab=_64029_/D }
C {devices/lab_pin.sym} 36720 -36920 0 1 {name=p35804 lab=_64064_/C }
C {sky130_stdcells/nand4_4.sym} 36660 -36920 0 0 {name=X_64060_ }
C {devices/lab_pin.sym} 36600 -36780 0 0 {name=p35805 lab=_81716_/D }
C {devices/lab_pin.sym} 36600 -36740 0 0 {name=p35806 lab=_76058_/B }
C {devices/lab_pin.sym} 36720 -36760 0 1 {name=p35807 lab=_76063_/A }
C {sky130_stdcells/xor2_4.sym} 36660 -36760 0 0 {name=X_76046_ }
C {devices/lab_pin.sym} 36620 -36630 0 0 {name=p35808 lab=_43161_/A }
C {devices/lab_pin.sym} 36700 -36630 0 1 {name=p35809 lab=_43146_/A }
C {sky130_stdcells/buf_2.sym} 36660 -36630 0 0 {name=X_42438_ }
C {devices/lab_pin.sym} 36600 -36540 0 0 {name=p35810 lab=_60296_/X }
C {devices/lab_pin.sym} 36600 -36500 0 0 {name=p35811 lab=_61272_/B }
C {devices/lab_pin.sym} 36600 -36460 0 0 {name=p35812 lab=_61151_/Y }
C {devices/lab_pin.sym} 36600 -36420 0 0 {name=p35813 lab=_61271_/Y }
C {devices/lab_pin.sym} 36720 -36480 0 1 {name=p35814 lab=_61272_/Y }
C {sky130_stdcells/nand4_4.sym} 36660 -36480 0 0 {name=X_61272_ }
C {devices/lab_pin.sym} 36600 -36340 0 0 {name=p35815 lab=_73206_/X }
C {devices/lab_pin.sym} 36600 -36300 0 0 {name=p35816 lab=_85870_/Q }
C {devices/lab_pin.sym} 36720 -36320 0 1 {name=p35817 lab=_73258_/X }
C {sky130_stdcells/and2_4.sym} 36660 -36320 0 0 {name=X_73258_ }
C {devices/lab_pin.sym} 36580 -36230 0 0 {name=p35818 lab=_58409_/A }
C {devices/lab_pin.sym} 36580 -36190 0 0 {name=p35819 lab=_63010_/X }
C {devices/lab_pin.sym} 36580 -36150 0 0 {name=p35820 lab=_60523_/X }
C {devices/lab_pin.sym} 36580 -36110 0 0 {name=p35821 lab=_59454_/A }
C {devices/lab_pin.sym} 36580 -36070 0 0 {name=p35822 lab=_60412_/X }
C {devices/lab_pin.sym} 36740 -36150 0 1 {name=p35823 lab=_63011_/Y }
C {sky130_stdcells/o32ai_4.sym} 36660 -36150 0 0 {name=X_63011_ }
C {devices/lab_pin.sym} 36620 -35990 0 0 {name=p35824 lab=_59286_/A }
C {devices/lab_pin.sym} 36700 -35990 0 1 {name=p35825 lab=_72209_/X }
C {sky130_stdcells/buf_2.sym} 36660 -35990 0 0 {name=X_72209_ }
C {devices/lab_pin.sym} 36620 -35870 0 0 {name=p35826 lab=_60222_/X }
C {devices/lab_pin.sym} 36700 -35870 0 1 {name=p35827 lab=_60408_/A }
C {sky130_stdcells/buf_2.sym} 36660 -35870 0 0 {name=X_60223_ }
C {devices/lab_pin.sym} 36580 -35770 0 0 {name=p35828 lab=_45154_/X }
C {devices/lab_pin.sym} 36580 -35730 0 0 {name=p35829 lab=_45156_/Y }
C {devices/lab_pin.sym} 36580 -35690 0 0 {name=p35830 lab=_45125_/X }
C {devices/lab_pin.sym} 36740 -35730 0 1 {name=p35831 lab=_45157_/Y }
C {sky130_stdcells/a21oi_4.sym} 36660 -35730 0 0 {name=X_45157_ }
C {devices/lab_pin.sym} 36620 -35590 0 0 {name=p35832 lab=_42397_/A }
C {devices/lab_pin.sym} 36700 -35590 0 1 {name=p35833 lab=_42369_/X }
C {sky130_stdcells/buf_2.sym} 36660 -35590 0 0 {name=X_42369_ }
C {devices/lab_pin.sym} 36600 -35480 0 0 {name=p35834 lab=_48538_/Y }
C {devices/lab_pin.sym} 36600 -35440 0 0 {name=p35835 lab=_73188_/Y }
C {devices/lab_pin.sym} 36720 -35460 0 1 {name=p35836 lab=_73189_/X }
C {sky130_stdcells/xor2_4.sym} 36660 -35460 0 0 {name=X_73189_ }
C {devices/lab_pin.sym} 36620 -35330 0 0 {name=p35837 lab=_80666_/Q }
C {devices/lab_pin.sym} 36700 -35330 0 1 {name=p35838 lab=_44108_/X }
C {sky130_stdcells/buf_2.sym} 36660 -35330 0 0 {name=X_44108_ }
C {devices/lab_pin.sym} 36600 -35220 0 0 {name=p35839 lab=_84226_/Q }
C {devices/lab_pin.sym} 36600 -35180 0 0 {name=p35840 lab=_83274_/Q }
C {devices/lab_pin.sym} 36720 -35200 0 1 {name=p35841 lab=_79807_/A }
C {sky130_stdcells/xor2_4.sym} 36660 -35200 0 0 {name=X_79805_ }
C {devices/lab_pin.sym} 36580 -35110 0 0 {name=p35842 lab=_59875_/X }
C {devices/lab_pin.sym} 36580 -35070 0 0 {name=p35843 lab=_60062_/X }
C {devices/lab_pin.sym} 36580 -35030 0 0 {name=p35844 lab=_60049_/A }
C {devices/lab_pin.sym} 36580 -34990 0 0 {name=p35845 lab=_60000_/Y }
C {devices/lab_pin.sym} 36580 -34950 0 0 {name=p35846 lab=_60153_/Y }
C {devices/lab_pin.sym} 36740 -35030 0 1 {name=p35847 lab=_84650_/D }
C {sky130_stdcells/o41a_4.sym} 36660 -35030 0 0 {name=X_60154_ }
C {devices/lab_pin.sym} 36580 -34890 0 0 {name=p35848 lab=_49963_/Y }
C {devices/lab_pin.sym} 36580 -34850 0 0 {name=p35849 lab=_49951_/X }
C {devices/lab_pin.sym} 36580 -34810 0 0 {name=p35850 lab=_49964_/X }
C {devices/lab_pin.sym} 36740 -34850 0 1 {name=p35851 lab=_86291_/D }
C {sky130_stdcells/a21oi_4.sym} 36660 -34850 0 0 {name=X_49965_ }
C {devices/lab_pin.sym} 36580 -34730 0 0 {name=p35852 lab=_55874_/B }
C {devices/lab_pin.sym} 36580 -34690 0 0 {name=p35853 lab=_45056_/X }
C {devices/lab_pin.sym} 36580 -34650 0 0 {name=p35854 lab=_45087_/X }
C {devices/lab_pin.sym} 36740 -34690 0 1 {name=p35855 lab=_45088_/X }
C {sky130_stdcells/o21a_4.sym} 36660 -34690 0 0 {name=X_45088_ }
C {devices/lab_pin.sym} 36600 -34560 0 0 {name=p35856 lab=_77997_/A }
C {devices/lab_pin.sym} 36600 -34520 0 0 {name=p35857 lab=_78012_/A }
C {devices/lab_pin.sym} 36720 -34540 0 1 {name=p35858 lab=_77998_/A }
C {sky130_stdcells/xor2_4.sym} 36660 -34540 0 0 {name=X_77997_ }
C {devices/lab_pin.sym} 36620 -34410 0 0 {name=p35859 lab=_48903_/A }
C {devices/lab_pin.sym} 36700 -34410 0 1 {name=p35860 lab=_48995_/A }
C {sky130_stdcells/buf_2.sym} 36660 -34410 0 0 {name=X_48916_ }
C {devices/lab_pin.sym} 36580 -34320 0 0 {name=p35861 lab=_87970_/Q }
C {devices/lab_pin.sym} 36580 -34280 0 0 {name=p35862 lab=_67651_/X }
C {devices/lab_pin.sym} 36580 -34240 0 0 {name=p35863 lab=_67748_/X }
C {devices/lab_pin.sym} 36580 -34200 0 0 {name=p35864 lab=_67749_/X }
C {devices/lab_pin.sym} 36740 -34260 0 1 {name=p35865 lab=_67750_/X }
C {sky130_stdcells/a211o_4.sym} 36660 -34260 0 0 {name=X_67750_ }
C {devices/lab_pin.sym} 36620 -34110 0 0 {name=p35866 lab=_44038_/X }
C {devices/lab_pin.sym} 36700 -34110 0 1 {name=p35867 lab=_44039_/X }
C {sky130_stdcells/buf_2.sym} 36660 -34110 0 0 {name=X_44039_ }
C {devices/lab_pin.sym} 36600 -34000 0 0 {name=p35868 lab=_79720_/X }
C {devices/lab_pin.sym} 36600 -33960 0 0 {name=p35869 lab=_79724_/B }
C {devices/lab_pin.sym} 36720 -33980 0 1 {name=p35870 lab=_79736_/X }
C {sky130_stdcells/or2_4.sym} 36660 -33980 0 0 {name=X_79736_ }
C {devices/lab_pin.sym} 36620 -33850 0 0 {name=p35871 lab=_65984_/A }
C {devices/lab_pin.sym} 36700 -33850 0 1 {name=p35872 lab=_65111_/B }
C {sky130_stdcells/buf_2.sym} 36660 -33850 0 0 {name=X_64962_ }
C {devices/lab_pin.sym} 36600 -33740 0 0 {name=p35873 lab=_76953_/A }
C {devices/lab_pin.sym} 36600 -33700 0 0 {name=p35874 lab=_76953_/B }
C {devices/lab_pin.sym} 36720 -33720 0 1 {name=p35875 lab=_76948_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -33720 0 0 {name=X_76948_ }
C {devices/lab_pin.sym} 36620 -33590 0 0 {name=p35876 lab=_60085_/A }
C {devices/lab_pin.sym} 36700 -33590 0 1 {name=p35877 lab=_60092_/B }
C {sky130_stdcells/inv_2.sym} 36660 -33590 0 0 {name=X_60085_ }
C {devices/lab_pin.sym} 36580 -33490 0 0 {name=p35878 lab=_72139_/B }
C {devices/lab_pin.sym} 36580 -33450 0 0 {name=p35879 lab=_49880_/X }
C {devices/lab_pin.sym} 36580 -33410 0 0 {name=p35880 lab=_49895_/Y }
C {devices/lab_pin.sym} 36740 -33450 0 1 {name=p35881 lab=_49896_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -33450 0 0 {name=X_49896_ }
C {devices/lab_pin.sym} 36580 -33340 0 0 {name=p35882 lab=_87374_/Q }
C {devices/lab_pin.sym} 36580 -33300 0 0 {name=p35883 lab=_66678_/X }
C {devices/lab_pin.sym} 36580 -33260 0 0 {name=p35884 lab=_66629_/X }
C {devices/lab_pin.sym} 36580 -33220 0 0 {name=p35885 lab=_66700_/X }
C {devices/lab_pin.sym} 36740 -33280 0 1 {name=p35886 lab=_66701_/X }
C {sky130_stdcells/a211o_4.sym} 36660 -33280 0 0 {name=X_66701_ }
C {devices/lab_pin.sym} 36620 -33130 0 0 {name=p35887 lab=_63912_/X }
C {devices/lab_pin.sym} 36700 -33130 0 1 {name=p35888 lab=_63913_/X }
C {sky130_stdcells/buf_2.sym} 36660 -33130 0 0 {name=X_63913_ }
C {devices/lab_pin.sym} 36600 -33020 0 0 {name=p35889 lab=_48851_/A }
C {devices/lab_pin.sym} 36600 -32980 0 0 {name=p35890 lab=_48847_/B }
C {devices/lab_pin.sym} 36720 -33000 0 1 {name=p35891 lab=_48847_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -33000 0 0 {name=X_48847_ }
C {devices/lab_pin.sym} 36620 -32870 0 0 {name=p35892 lab=_67203_/X }
C {devices/lab_pin.sym} 36700 -32870 0 1 {name=p35893 lab=_67681_/X }
C {sky130_stdcells/buf_2.sym} 36660 -32870 0 0 {name=X_67681_ }
C {devices/lab_pin.sym} 36600 -32760 0 0 {name=p35894 lab=_79667_/A }
C {devices/lab_pin.sym} 36600 -32720 0 0 {name=p35895 lab=_79666_/Y }
C {devices/lab_pin.sym} 36720 -32740 0 1 {name=p35896 lab=_79667_/X }
C {sky130_stdcells/xor2_4.sym} 36660 -32740 0 0 {name=X_79667_ }
C {devices/lab_pin.sym} 36600 -32620 0 0 {name=p35897 lab=_64694_/A }
C {devices/lab_pin.sym} 36600 -32580 0 0 {name=p35898 lab=_85814_/Q }
C {devices/lab_pin.sym} 36720 -32600 0 1 {name=p35899 lab=_64893_/X }
C {sky130_stdcells/and2_4.sym} 36660 -32600 0 0 {name=X_64893_ }
C {devices/lab_pin.sym} 36600 -32480 0 0 {name=p35900 lab=_81595_/Q }
C {devices/lab_pin.sym} 36600 -32440 0 0 {name=p35901 lab=_76879_/B }
C {devices/lab_pin.sym} 36720 -32460 0 1 {name=p35902 lab=_76879_/X }
C {sky130_stdcells/xor2_4.sym} 36660 -32460 0 0 {name=X_76879_ }
C {devices/lab_pin.sym} 36580 -32360 0 0 {name=p35903 lab=_69300_/X }
C {devices/lab_pin.sym} 36580 -32320 0 0 {name=p35904 lab=_69340_/X }
C {devices/lab_pin.sym} 36580 -32280 0 0 {name=p35905 lab=_69417_/Y }
C {devices/lab_pin.sym} 36580 -32240 0 0 {name=p35906 lab=_69419_/Y }
C {devices/lab_pin.sym} 36740 -32300 0 1 {name=p35907 lab=_69420_/X }
C {sky130_stdcells/a211o_4.sym} 36660 -32300 0 0 {name=X_69420_ }
C {devices/lab_pin.sym} 36580 -32170 0 0 {name=p35908 lab=_66627_/X }
C {devices/lab_pin.sym} 36580 -32130 0 0 {name=p35909 lab=_66631_/X }
C {devices/lab_pin.sym} 36580 -32090 0 0 {name=p35910 lab=_66606_/X }
C {devices/lab_pin.sym} 36740 -32130 0 1 {name=p35911 lab=_66632_/X }
C {sky130_stdcells/a21o_4.sym} 36660 -32130 0 0 {name=X_66632_ }
C {devices/lab_pin.sym} 36620 -31990 0 0 {name=p35912 lab=clkbuf_9_254_0_CLK/X }
C {devices/lab_pin.sym} 36700 -31990 0 1 {name=p35913 lab=_86104_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 36660 -31990 0 0 {name=Xclkbuf_10_508_0_CLK }
C {devices/lab_pin.sym} 36620 -31870 0 0 {name=p35914 lab=_78617_/Y }
C {devices/lab_pin.sym} 36700 -31870 0 1 {name=p35915 lab=_78618_/Y }
C {sky130_stdcells/inv_2.sym} 36660 -31870 0 0 {name=X_78618_ }
C {devices/lab_pin.sym} 36600 -31780 0 0 {name=p35916 lab=_61399_/X }
C {devices/lab_pin.sym} 36600 -31740 0 0 {name=p35917 lab=_63877_/B }
C {devices/lab_pin.sym} 36600 -31700 0 0 {name=p35918 lab=_63814_/C }
C {devices/lab_pin.sym} 36600 -31660 0 0 {name=p35919 lab=_63877_/D }
C {devices/lab_pin.sym} 36720 -31720 0 1 {name=p35920 lab=_63844_/Y }
C {sky130_stdcells/nand4_4.sym} 36660 -31720 0 0 {name=X_63844_ }
C {devices/lab_pin.sym} 36580 -31590 0 0 {name=p35921 lab=_86484_/Q }
C {devices/lab_pin.sym} 36580 -31550 0 0 {name=p35922 lab=_48754_/X }
C {devices/lab_pin.sym} 36580 -31510 0 0 {name=p35923 lab=_48777_/Y }
C {devices/lab_pin.sym} 36740 -31550 0 1 {name=p35924 lab=_48778_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -31550 0 0 {name=X_48778_ }
C {devices/lab_pin.sym} 36620 -31410 0 0 {name=p35925 lab=_79598_/A }
C {devices/lab_pin.sym} 36700 -31410 0 1 {name=p35926 lab=_81094_/D }
C {sky130_stdcells/inv_2.sym} 36660 -31410 0 0 {name=X_79598_ }
C {devices/lab_pin.sym} 36580 -31310 0 0 {name=p35927 lab=_68761_/X }
C {devices/lab_pin.sym} 36580 -31270 0 0 {name=p35928 lab=_68764_/X }
C {devices/lab_pin.sym} 36580 -31230 0 0 {name=p35929 lab=_69295_/X }
C {devices/lab_pin.sym} 36740 -31270 0 1 {name=p35930 lab=_69351_/Y }
C {sky130_stdcells/a21oi_4.sym} 36660 -31270 0 0 {name=X_69351_ }
C {devices/lab_pin.sym} 36620 -31130 0 0 {name=p35931 lab=_81228_/Q }
C {devices/lab_pin.sym} 36700 -31130 0 1 {name=p35932 lab=_47729_/Y }
C {sky130_stdcells/inv_2.sym} 36660 -31130 0 0 {name=X_47729_ }
C {devices/lab_pin.sym} 36620 -31010 0 0 {name=p35933 lab=_66563_/A }
C {devices/lab_pin.sym} 36700 -31010 0 1 {name=p35934 lab=_69567_/A }
C {sky130_stdcells/buf_2.sym} 36660 -31010 0 0 {name=X_66563_ }
C {devices/lab_pin.sym} 36600 -30900 0 0 {name=p35935 lab=_78549_/A }
C {devices/lab_pin.sym} 36600 -30860 0 0 {name=p35936 lab=_82675_/D }
C {devices/lab_pin.sym} 36720 -30880 0 1 {name=p35937 lab=_78554_/A }
C {sky130_stdcells/nor2_4.sym} 36660 -30880 0 0 {name=X_78549_ }
C {devices/lab_pin.sym} 36600 -30780 0 0 {name=p35938 lab=_63384_/B }
C {devices/lab_pin.sym} 36600 -30740 0 0 {name=p35939 lab=_63820_/B }
C {devices/lab_pin.sym} 36600 -30700 0 0 {name=p35940 lab=_63753_/C }
C {devices/lab_pin.sym} 36600 -30660 0 0 {name=p35941 lab=_64177_/D }
C {devices/lab_pin.sym} 36720 -30720 0 1 {name=p35942 lab=_63775_/Y }
C {sky130_stdcells/nand4_4.sym} 36660 -30720 0 0 {name=X_63775_ }
C {devices/lab_pin.sym} 36600 -30580 0 0 {name=p35943 lab=_61012_/C }
C {devices/lab_pin.sym} 36600 -30540 0 0 {name=p35944 lab=_60918_/X }
C {devices/lab_pin.sym} 36720 -30560 0 1 {name=p35945 lab=_60987_/Y }
C {sky130_stdcells/nor2_4.sym} 36660 -30560 0 0 {name=X_60987_ }
C {devices/lab_pin.sym} 36580 -30450 0 0 {name=p35946 lab=_67847_/X }
C {devices/lab_pin.sym} 36580 -30410 0 0 {name=p35947 lab=_67849_/X }
C {devices/lab_pin.sym} 36580 -30370 0 0 {name=p35948 lab=_68283_/X }
C {devices/lab_pin.sym} 36740 -30410 0 1 {name=p35949 lab=_68302_/Y }
C {sky130_stdcells/a21oi_4.sym} 36660 -30410 0 0 {name=X_68302_ }
C {devices/lab_pin.sym} 36580 -30290 0 0 {name=p35950 lab=_65512_/Y }
C {devices/lab_pin.sym} 36580 -30250 0 0 {name=p35951 lab=_65448_/X }
C {devices/lab_pin.sym} 36580 -30210 0 0 {name=p35952 lab=_65513_/X }
C {devices/lab_pin.sym} 36740 -30250 0 1 {name=p35953 lab=_84196_/D }
C {sky130_stdcells/a21o_4.sym} 36660 -30250 0 0 {name=X_65514_ }
C {devices/lab_pin.sym} 36600 -30120 0 0 {name=p35954 lab=_50740_/A }
C {devices/lab_pin.sym} 36600 -30080 0 0 {name=p35955 lab=_53953_/B }
C {devices/lab_pin.sym} 36720 -30100 0 1 {name=p35956 lab=_50740_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -30100 0 0 {name=X_50740_ }
C {devices/lab_pin.sym} 36580 -30010 0 0 {name=p35957 lab=_58241_/X }
C {devices/lab_pin.sym} 36580 -29970 0 0 {name=p35958 lab=_62689_/X }
C {devices/lab_pin.sym} 36580 -29930 0 0 {name=p35959 lab=_62708_/X }
C {devices/lab_pin.sym} 36580 -29890 0 0 {name=p35960 lab=_62699_/X }
C {devices/lab_pin.sym} 36580 -29860 0 0 {name=p35961 lab=_62725_/X }
C {devices/lab_pin.sym} 36740 -29930 0 1 {name=p35962 lab=_62726_/Y }
C {sky130_stdcells/a41oi_4.sym} 36660 -29930 0 0 {name=X_62726_ }
C {devices/lab_pin.sym} 36570 -29770 0 0 {name=p35963 lab=_81433_/CLK }
C {devices/lab_pin.sym} 36570 -29750 0 0 {name=p35964 lab=_81560_/D }
C {devices/lab_pin.sym} 36750 -29770 0 1 {name=p35965 lab=_81560_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -29760 0 0 {name=X_81560_ }
C {devices/lab_pin.sym} 36580 -29650 0 0 {name=p35966 lab=_68629_/X }
C {devices/lab_pin.sym} 36580 -29610 0 0 {name=p35967 lab=_68632_/X }
C {devices/lab_pin.sym} 36580 -29570 0 0 {name=p35968 lab=_69212_/X }
C {devices/lab_pin.sym} 36740 -29610 0 1 {name=p35969 lab=_69282_/Y }
C {sky130_stdcells/a21oi_4.sym} 36660 -29610 0 0 {name=X_69282_ }
C {devices/lab_pin.sym} 36580 -29490 0 0 {name=p35970 lab=_66475_/X }
C {devices/lab_pin.sym} 36580 -29450 0 0 {name=p35971 lab=_66275_/Y }
C {devices/lab_pin.sym} 36580 -29410 0 0 {name=p35972 lab=_66493_/Y }
C {devices/lab_pin.sym} 36740 -29450 0 1 {name=p35973 lab=_66494_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -29450 0 0 {name=X_66494_ }
C {devices/lab_pin.sym} 36580 -29330 0 0 {name=p35974 lab=_80495_/X }
C {devices/lab_pin.sym} 36580 -29290 0 0 {name=p35975 lab=_80498_/Y }
C {devices/lab_pin.sym} 36580 -29250 0 0 {name=p35976 lab=_80510_/X }
C {devices/lab_pin.sym} 36740 -29290 0 1 {name=p35977 lab=_80511_/X }
C {sky130_stdcells/a21o_4.sym} 36660 -29290 0 0 {name=X_80511_ }
C {devices/lab_pin.sym} 36580 -29180 0 0 {name=p35978 lab=_68221_/X }
C {devices/lab_pin.sym} 36580 -29140 0 0 {name=p35979 lab=_67436_/Y }
C {devices/lab_pin.sym} 36580 -29100 0 0 {name=p35980 lab=_68228_/X }
C {devices/lab_pin.sym} 36580 -29060 0 0 {name=p35981 lab=_68232_/Y }
C {devices/lab_pin.sym} 36740 -29120 0 1 {name=p35982 lab=_68233_/X }
C {sky130_stdcells/a211o_4.sym} 36660 -29120 0 0 {name=X_68233_ }
C {devices/lab_pin.sym} 36580 -29000 0 0 {name=p35983 lab=_64835_/X }
C {devices/lab_pin.sym} 36580 -28960 0 0 {name=p35984 lab=_83080_/Q }
C {devices/lab_pin.sym} 36580 -28920 0 0 {name=p35985 lab=_65015_/X }
C {devices/lab_pin.sym} 36580 -28880 0 0 {name=p35986 lab=_65444_/X }
C {devices/lab_pin.sym} 36740 -28940 0 1 {name=p35987 lab=_65445_/X }
C {sky130_stdcells/a211o_4.sym} 36660 -28940 0 0 {name=X_65445_ }
C {devices/lab_pin.sym} 36580 -28810 0 0 {name=p35988 lab=_86156_/Q }
C {devices/lab_pin.sym} 36580 -28770 0 0 {name=p35989 lab=_50654_/X }
C {devices/lab_pin.sym} 36580 -28730 0 0 {name=p35990 lab=_50670_/Y }
C {devices/lab_pin.sym} 36740 -28770 0 1 {name=p35991 lab=_50671_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -28770 0 0 {name=X_50671_ }
C {devices/lab_pin.sym} 36620 -28630 0 0 {name=p35992 lab=_60239_/A }
C {devices/lab_pin.sym} 36700 -28630 0 1 {name=p35993 lab=_62657_/X }
C {sky130_stdcells/buf_2.sym} 36660 -28630 0 0 {name=X_62657_ }
C {devices/lab_pin.sym} 36570 -28510 0 0 {name=p35994 lab=_81265_/CLK }
C {devices/lab_pin.sym} 36570 -28490 0 0 {name=p35995 lab=_84059_/Q }
C {devices/lab_pin.sym} 36750 -28510 0 1 {name=p35996 lab=_81491_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -28500 0 0 {name=X_81491_ }
C {devices/lab_pin.sym} 36580 -28390 0 0 {name=p35997 lab=_85828_/Q }
C {devices/lab_pin.sym} 36580 -28350 0 0 {name=p35998 lab=_52397_/X }
C {devices/lab_pin.sym} 36580 -28310 0 0 {name=p35999 lab=_52409_/Y }
C {devices/lab_pin.sym} 36740 -28350 0 1 {name=p36000 lab=_52410_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -28350 0 0 {name=X_52410_ }
C {devices/lab_pin.sym} 36570 -28210 0 0 {name=p36001 lab=_83229_/CLK }
C {devices/lab_pin.sym} 36570 -28190 0 0 {name=p36002 lab=_72574_/Y }
C {devices/lab_pin.sym} 36750 -28210 0 1 {name=p36003 lab=_79394_/B }
C {sky130_stdcells/dfxtp_4.sym} 36660 -28200 0 0 {name=X_83230_ }
C {devices/lab_pin.sym} 36620 -28070 0 0 {name=p36004 lab=_61290_/X }
C {devices/lab_pin.sym} 36700 -28070 0 1 {name=p36005 lab=_61608_/X }
C {sky130_stdcells/buf_2.sym} 36660 -28070 0 0 {name=X_61608_ }
C {devices/lab_pin.sym} 36600 -27960 0 0 {name=p36006 lab=_80442_/A }
C {devices/lab_pin.sym} 36600 -27920 0 0 {name=p36007 lab=_80442_/B }
C {devices/lab_pin.sym} 36720 -27940 0 1 {name=p36008 lab=_80452_/B }
C {sky130_stdcells/xor2_4.sym} 36660 -27940 0 0 {name=X_80442_ }
C {devices/lab_pin.sym} 36580 -27830 0 0 {name=p36009 lab=_67038_/X }
C {devices/lab_pin.sym} 36580 -27790 0 0 {name=p36010 lab=_67042_/X }
C {devices/lab_pin.sym} 36580 -27750 0 0 {name=p36011 lab=_68129_/X }
C {devices/lab_pin.sym} 36740 -27790 0 1 {name=p36012 lab=_68164_/Y }
C {sky130_stdcells/a21oi_4.sym} 36660 -27790 0 0 {name=X_68164_ }
C {devices/lab_pin.sym} 36600 -27660 0 0 {name=p36013 lab=_53386_/A }
C {devices/lab_pin.sym} 36600 -27620 0 0 {name=p36014 lab=_53390_/B }
C {devices/lab_pin.sym} 36720 -27640 0 1 {name=p36015 lab=_53390_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -27640 0 0 {name=X_53390_ }
C {devices/lab_pin.sym} 36580 -27540 0 0 {name=p36016 lab=_64564_/X }
C {devices/lab_pin.sym} 36580 -27500 0 0 {name=p36017 lab=_86115_/Q }
C {devices/lab_pin.sym} 36580 -27460 0 0 {name=p36018 lab=_64566_/X }
C {devices/lab_pin.sym} 36580 -27420 0 0 {name=p36019 lab=_65375_/X }
C {devices/lab_pin.sym} 36740 -27480 0 1 {name=p36020 lab=_65376_/X }
C {sky130_stdcells/a211o_4.sym} 36660 -27480 0 0 {name=X_65376_ }
C {devices/lab_pin.sym} 36600 -27360 0 0 {name=p36021 lab=_61652_/B }
C {devices/lab_pin.sym} 36600 -27320 0 0 {name=p36022 lab=_62504_/X }
C {devices/lab_pin.sym} 36600 -27280 0 0 {name=p36023 lab=_62534_/X }
C {devices/lab_pin.sym} 36600 -27240 0 0 {name=p36024 lab=_62621_/D }
C {devices/lab_pin.sym} 36720 -27300 0 1 {name=p36025 lab=_62589_/D }
C {sky130_stdcells/nand4_4.sym} 36660 -27300 0 0 {name=X_62588_ }
C {devices/lab_pin.sym} 36580 -27180 0 0 {name=p36026 lab=_66899_/X }
C {devices/lab_pin.sym} 36580 -27140 0 0 {name=p36027 lab=_67102_/Y }
C {devices/lab_pin.sym} 36580 -27100 0 0 {name=p36028 lab=_67031_/X }
C {devices/lab_pin.sym} 36580 -27060 0 0 {name=p36029 lab=_67114_/Y }
C {devices/lab_pin.sym} 36740 -27120 0 1 {name=p36030 lab=_67115_/X }
C {sky130_stdcells/a211o_4.sym} 36660 -27120 0 0 {name=X_67115_ }
C {devices/lab_pin.sym} 36600 -26980 0 0 {name=p36031 lab=_52320_/A }
C {devices/lab_pin.sym} 36600 -26940 0 0 {name=p36032 lab=_49041_/A }
C {devices/lab_pin.sym} 36720 -26960 0 1 {name=p36033 lab=_52341_/X }
C {sky130_stdcells/and2_4.sym} 36660 -26960 0 0 {name=X_52341_ }
C {devices/lab_pin.sym} 36580 -26870 0 0 {name=p36034 lab=_64318_/X }
C {devices/lab_pin.sym} 36580 -26830 0 0 {name=p36035 lab=_64320_/X }
C {devices/lab_pin.sym} 36580 -26790 0 0 {name=p36036 lab=_64321_/X }
C {devices/lab_pin.sym} 36580 -26750 0 0 {name=p36037 lab=_64325_/Y }
C {devices/lab_pin.sym} 36580 -26710 0 0 {name=p36038 lab=_64326_/X }
C {devices/lab_pin.sym} 36740 -26790 0 1 {name=p36039 lab=_64327_/X }
C {sky130_stdcells/o41a_4.sym} 36660 -26790 0 0 {name=X_64327_ }
C {devices/lab_pin.sym} 36570 -26630 0 0 {name=p36040 lab=_83161_/CLK }
C {devices/lab_pin.sym} 36570 -26610 0 0 {name=p36041 lab=_73192_/X }
C {devices/lab_pin.sym} 36750 -26630 0 1 {name=p36042 lab=_83161_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -26620 0 0 {name=X_83161_ }
C {devices/lab_pin.sym} 36620 -26490 0 0 {name=p36043 lab=_61355_/A }
C {devices/lab_pin.sym} 36700 -26490 0 1 {name=p36044 lab=_61541_/A }
C {sky130_stdcells/buf_2.sym} 36660 -26490 0 0 {name=X_61539_ }
C {devices/lab_pin.sym} 36600 -26380 0 0 {name=p36045 lab=_80383_/B }
C {devices/lab_pin.sym} 36600 -26340 0 0 {name=p36046 lab=_80372_/X }
C {devices/lab_pin.sym} 36720 -26360 0 1 {name=p36047 lab=_80375_/A }
C {sky130_stdcells/xor2_4.sym} 36660 -26360 0 0 {name=X_80373_ }
C {devices/lab_pin.sym} 36580 -26250 0 0 {name=p36048 lab=_84040_/Q }
C {devices/lab_pin.sym} 36580 -26210 0 0 {name=p36049 lab=_68040_/X }
C {devices/lab_pin.sym} 36580 -26170 0 0 {name=p36050 lab=_68094_/X }
C {devices/lab_pin.sym} 36740 -26210 0 1 {name=p36051 lab=_68095_/X }
C {sky130_stdcells/a21bo_4.sym} 36660 -26210 0 0 {name=X_68095_ }
C {devices/lab_pin.sym} 36570 -26070 0 0 {name=p36052 lab=_82580_/CLK }
C {devices/lab_pin.sym} 36570 -26050 0 0 {name=p36053 lab=_82124_/Q }
C {devices/lab_pin.sym} 36750 -26070 0 1 {name=p36054 lab=_82112_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -26060 0 0 {name=X_82112_ }
C {devices/lab_pin.sym} 36580 -25950 0 0 {name=p36055 lab=_85326_/Q }
C {devices/lab_pin.sym} 36580 -25910 0 0 {name=p36056 lab=_55046_/X }
C {devices/lab_pin.sym} 36580 -25870 0 0 {name=p36057 lab=_55059_/Y }
C {devices/lab_pin.sym} 36740 -25910 0 1 {name=p36058 lab=_55060_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -25910 0 0 {name=X_55060_ }
C {devices/lab_pin.sym} 36620 -25770 0 0 {name=p36059 lab=_67046_/A }
C {devices/lab_pin.sym} 36700 -25770 0 1 {name=p36060 lab=_67046_/X }
C {sky130_stdcells/buf_2.sym} 36660 -25770 0 0 {name=X_67046_ }
C {devices/lab_pin.sym} 36600 -25660 0 0 {name=p36061 lab=_52293_/A }
C {devices/lab_pin.sym} 36600 -25620 0 0 {name=p36062 lab=_48901_/B }
C {devices/lab_pin.sym} 36720 -25640 0 1 {name=p36063 lab=_52272_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -25640 0 0 {name=X_52272_ }
C {devices/lab_pin.sym} 36620 -25510 0 0 {name=p36064 lab=_64221_/A }
C {devices/lab_pin.sym} 36700 -25510 0 1 {name=p36065 lab=_64304_/D }
C {sky130_stdcells/buf_2.sym} 36660 -25510 0 0 {name=X_64258_ }
C {devices/lab_pin.sym} 36570 -25390 0 0 {name=p36066 lab=_83095_/CLK }
C {devices/lab_pin.sym} 36570 -25370 0 0 {name=p36067 lab=_74339_/X }
C {devices/lab_pin.sym} 36750 -25390 0 1 {name=p36068 lab=_70326_/A }
C {sky130_stdcells/dfxtp_4.sym} 36660 -25380 0 0 {name=X_83092_ }
C {devices/lab_pin.sym} 36600 -25260 0 0 {name=p36069 lab=_53998_/A }
C {devices/lab_pin.sym} 36600 -25220 0 0 {name=p36070 lab=_46417_/B }
C {devices/lab_pin.sym} 36720 -25240 0 1 {name=p36071 lab=_54011_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -25240 0 0 {name=X_54011_ }
C {devices/lab_pin.sym} 36580 -25130 0 0 {name=p36072 lab=_86051_/Q }
C {devices/lab_pin.sym} 36580 -25090 0 0 {name=p36073 lab=_51209_/X }
C {devices/lab_pin.sym} 36580 -25050 0 0 {name=p36074 lab=_51222_/Y }
C {devices/lab_pin.sym} 36740 -25090 0 1 {name=p36075 lab=_51223_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -25090 0 0 {name=X_51223_ }
C {devices/lab_pin.sym} 36570 -24950 0 0 {name=p36076 lab=_86920_/CLK }
C {devices/lab_pin.sym} 36570 -24930 0 0 {name=p36077 lab=_86920_/D }
C {devices/lab_pin.sym} 36750 -24950 0 1 {name=p36078 lab=_86920_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -24940 0 0 {name=X_86920_ }
C {devices/lab_pin.sym} 36570 -24810 0 0 {name=p36079 lab=_82139_/CLK }
C {devices/lab_pin.sym} 36570 -24790 0 0 {name=p36080 lab=_77958_/B }
C {devices/lab_pin.sym} 36750 -24810 0 1 {name=p36081 lab=_82043_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -24800 0 0 {name=X_82043_ }
C {devices/lab_pin.sym} 36600 -24700 0 0 {name=p36082 lab=_63209_/A }
C {devices/lab_pin.sym} 36600 -24660 0 0 {name=p36083 lab=_63170_/X }
C {devices/lab_pin.sym} 36600 -24620 0 0 {name=p36084 lab=_63161_/C }
C {devices/lab_pin.sym} 36600 -24580 0 0 {name=p36085 lab=_63267_/D }
C {devices/lab_pin.sym} 36720 -24640 0 1 {name=p36086 lab=_63209_/X }
C {sky130_stdcells/or4_4.sym} 36660 -24640 0 0 {name=X_63209_ }
C {devices/lab_pin.sym} 36600 -24520 0 0 {name=p36087 lab=_84730_/Q }
C {devices/lab_pin.sym} 36600 -24480 0 0 {name=p36088 lab=_64067_/A }
C {devices/lab_pin.sym} 36600 -24440 0 0 {name=p36089 lab=_64189_/C }
C {devices/lab_pin.sym} 36600 -24400 0 0 {name=p36090 lab=_64189_/D }
C {devices/lab_pin.sym} 36720 -24460 0 1 {name=p36091 lab=_64189_/Y }
C {sky130_stdcells/nand4_4.sym} 36660 -24460 0 0 {name=X_64189_ }
C {devices/lab_pin.sym} 36600 -24340 0 0 {name=p36092 lab=_51160_/A }
C {devices/lab_pin.sym} 36600 -24300 0 0 {name=p36093 lab=_51160_/B }
C {devices/lab_pin.sym} 36600 -24260 0 0 {name=p36094 lab=_51141_/X }
C {devices/lab_pin.sym} 36600 -24220 0 0 {name=p36095 lab=_52846_/D }
C {devices/lab_pin.sym} 36720 -24280 0 1 {name=p36096 lab=_51154_/X }
C {sky130_stdcells/and4_4.sym} 36660 -24280 0 0 {name=X_51154_ }
C {devices/lab_pin.sym} 36570 -24130 0 0 {name=p36097 lab=_86882_/CLK }
C {devices/lab_pin.sym} 36570 -24110 0 0 {name=p36098 lab=_45838_/Y }
C {devices/lab_pin.sym} 36750 -24130 0 1 {name=p36099 lab=_63324_/B }
C {sky130_stdcells/dfxtp_4.sym} 36660 -24120 0 0 {name=X_86851_ }
C {devices/lab_pin.sym} 36580 -24020 0 0 {name=p36100 lab=_68986_/Y }
C {devices/lab_pin.sym} 36580 -23980 0 0 {name=p36101 lab=_68823_/X }
C {devices/lab_pin.sym} 36580 -23940 0 0 {name=p36102 lab=_68824_/X }
C {devices/lab_pin.sym} 36580 -23900 0 0 {name=p36103 lab=_68996_/Y }
C {devices/lab_pin.sym} 36740 -23960 0 1 {name=p36104 lab=_68997_/X }
C {sky130_stdcells/a211o_4.sym} 36660 -23960 0 0 {name=X_68997_ }
C {devices/lab_pin.sym} 36620 -23810 0 0 {name=p36105 lab=_50105_/A }
C {devices/lab_pin.sym} 36700 -23810 0 1 {name=p36106 lab=_50106_/A }
C {sky130_stdcells/buf_2.sym} 36660 -23810 0 0 {name=X_50105_ }
C {devices/lab_pin.sym} 36570 -23690 0 0 {name=p36107 lab=_85514_/CLK }
C {devices/lab_pin.sym} 36570 -23670 0 0 {name=p36108 lab=_85802_/D }
C {devices/lab_pin.sym} 36750 -23690 0 1 {name=p36109 lab=_65209_/B }
C {sky130_stdcells/dfxtp_4.sym} 36660 -23680 0 0 {name=X_85802_ }
C {devices/lab_pin.sym} 36600 -23560 0 0 {name=p36110 lab=_58763_/A }
C {devices/lab_pin.sym} 36600 -23520 0 0 {name=p36111 lab=_58750_/B }
C {devices/lab_pin.sym} 36720 -23540 0 1 {name=p36112 lab=_58750_/Y }
C {sky130_stdcells/nor2_4.sym} 36660 -23540 0 0 {name=X_58750_ }
C {devices/lab_pin.sym} 36580 -23430 0 0 {name=p36113 lab=_51081_/Y }
C {devices/lab_pin.sym} 36580 -23390 0 0 {name=p36114 lab=_51065_/X }
C {devices/lab_pin.sym} 36580 -23350 0 0 {name=p36115 lab=_51084_/X }
C {devices/lab_pin.sym} 36740 -23390 0 1 {name=p36116 lab=_86077_/D }
C {sky130_stdcells/a21oi_4.sym} 36660 -23390 0 0 {name=X_51085_ }
C {devices/lab_pin.sym} 36580 -23270 0 0 {name=p36117 lab=_55959_/X }
C {devices/lab_pin.sym} 36580 -23230 0 0 {name=p36118 lab=_55961_/X }
C {devices/lab_pin.sym} 36580 -23190 0 0 {name=p36119 lab=_55615_/X }
C {devices/lab_pin.sym} 36740 -23230 0 1 {name=p36120 lab=_55965_/A }
C {sky130_stdcells/a21o_4.sym} 36660 -23230 0 0 {name=X_55962_ }
C {devices/lab_pin.sym} 36620 -23090 0 0 {name=p36121 lab=_66898_/X }
C {devices/lab_pin.sym} 36700 -23090 0 1 {name=p36122 lab=_67948_/X }
C {sky130_stdcells/buf_2.sym} 36660 -23090 0 0 {name=X_67948_ }
C {devices/lab_pin.sym} 36570 -22970 0 0 {name=p36123 lab=_82317_/CLK }
C {devices/lab_pin.sym} 36570 -22950 0 0 {name=p36124 lab=_86782_/D }
C {devices/lab_pin.sym} 36750 -22970 0 1 {name=p36125 lab=_86782_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -22960 0 0 {name=X_86782_ }
C {devices/lab_pin.sym} 36570 -22830 0 0 {name=p36126 lab=_82642_/CLK }
C {devices/lab_pin.sym} 36570 -22810 0 0 {name=p36127 lab=_68278_/X }
C {devices/lab_pin.sym} 36750 -22830 0 1 {name=p36128 lab=_83994_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -22820 0 0 {name=X_83994_ }
C {devices/lab_pin.sym} 36620 -22690 0 0 {name=p36129 lab=_57701_/A }
C {devices/lab_pin.sym} 36700 -22690 0 1 {name=p36130 lab=_58635_/A }
C {sky130_stdcells/buf_2.sym} 36660 -22690 0 0 {name=X_57701_ }
C {devices/lab_pin.sym} 36600 -22600 0 0 {name=p36131 lab=_50050_/A }
C {devices/lab_pin.sym} 36600 -22560 0 0 {name=p36132 lab=_50040_/B }
C {devices/lab_pin.sym} 36600 -22520 0 0 {name=p36133 lab=_51750_/C }
C {devices/lab_pin.sym} 36600 -22480 0 0 {name=p36134 lab=_53249_/D }
C {devices/lab_pin.sym} 36720 -22540 0 1 {name=p36135 lab=_50036_/X }
C {sky130_stdcells/and4_4.sym} 36660 -22540 0 0 {name=X_50036_ }
C {devices/lab_pin.sym} 36580 -22410 0 0 {name=p36136 lab=_85354_/Q }
C {devices/lab_pin.sym} 36580 -22370 0 0 {name=p36137 lab=_54892_/X }
C {devices/lab_pin.sym} 36580 -22330 0 0 {name=p36138 lab=_54912_/Y }
C {devices/lab_pin.sym} 36740 -22370 0 1 {name=p36139 lab=_54913_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -22370 0 0 {name=X_54913_ }
C {devices/lab_pin.sym} 36570 -22230 0 0 {name=p36140 lab=_86342_/CLK }
C {devices/lab_pin.sym} 36570 -22210 0 0 {name=p36141 lab=_85733_/D }
C {devices/lab_pin.sym} 36750 -22230 0 1 {name=p36142 lab=_85733_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -22220 0 0 {name=X_85733_ }
C {devices/lab_pin.sym} 36580 -22110 0 0 {name=p36143 lab=_58591_/X }
C {devices/lab_pin.sym} 36580 -22070 0 0 {name=p36144 lab=_85464_/Q }
C {devices/lab_pin.sym} 36580 -22030 0 0 {name=p36145 lab=_58680_/X }
C {devices/lab_pin.sym} 36740 -22070 0 1 {name=p36146 lab=_58681_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -22070 0 0 {name=X_58681_ }
C {devices/lab_pin.sym} 36570 -21930 0 0 {name=p36147 lab=_82369_/CLK }
C {devices/lab_pin.sym} 36570 -21910 0 0 {name=p36148 lab=_78123_/X }
C {devices/lab_pin.sym} 36750 -21930 0 1 {name=p36149 lab=_82945_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -21920 0 0 {name=X_82945_ }
C {devices/lab_pin.sym} 36620 -21790 0 0 {name=p36150 lab=_55892_/X }
C {devices/lab_pin.sym} 36700 -21790 0 1 {name=p36151 lab=_55928_/A }
C {sky130_stdcells/buf_2.sym} 36660 -21790 0 0 {name=X_55893_ }
C {devices/lab_pin.sym} 36620 -21670 0 0 {name=p36152 lab=_67997_/A }
C {devices/lab_pin.sym} 36700 -21670 0 1 {name=p36153 lab=_67879_/X }
C {sky130_stdcells/buf_2.sym} 36660 -21670 0 0 {name=X_67879_ }
C {devices/lab_pin.sym} 36600 -21560 0 0 {name=p36154 lab=_57608_/X }
C {devices/lab_pin.sym} 36600 -21520 0 0 {name=p36155 lab=_52079_/B }
C {devices/lab_pin.sym} 36720 -21540 0 1 {name=p36156 lab=_57632_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -21540 0 0 {name=X_57632_ }
C {devices/lab_pin.sym} 36620 -21410 0 0 {name=p36157 lab=_87823_/Q }
C {devices/lab_pin.sym} 36700 -21410 0 1 {name=p36158 lab=_69619_/B }
C {sky130_stdcells/inv_2.sym} 36660 -21410 0 0 {name=X_69618_ }
C {devices/lab_pin.sym} 36580 -21310 0 0 {name=p36159 lab=_54842_/Y }
C {devices/lab_pin.sym} 36580 -21270 0 0 {name=p36160 lab=_54830_/X }
C {devices/lab_pin.sym} 36580 -21230 0 0 {name=p36161 lab=_54843_/X }
C {devices/lab_pin.sym} 36740 -21270 0 1 {name=p36162 lab=_85368_/D }
C {sky130_stdcells/a21oi_4.sym} 36660 -21270 0 0 {name=X_54844_ }
C {devices/lab_pin.sym} 36570 -21130 0 0 {name=p36163 lab=_85439_/CLK }
C {devices/lab_pin.sym} 36570 -21110 0 0 {name=p36164 lab=_85664_/D }
C {devices/lab_pin.sym} 36750 -21130 0 1 {name=p36165 lab=_85664_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -21120 0 0 {name=X_85664_ }
C {devices/lab_pin.sym} 36600 -21020 0 0 {name=p36166 lab=_70863_/A }
C {devices/lab_pin.sym} 36600 -20980 0 0 {name=p36167 lab=_70890_/B }
C {devices/lab_pin.sym} 36600 -20940 0 0 {name=p36168 lab=_70890_/C }
C {devices/lab_pin.sym} 36600 -20900 0 0 {name=p36169 lab=_70890_/D }
C {devices/lab_pin.sym} 36720 -20960 0 1 {name=p36170 lab=_70890_/Y }
C {sky130_stdcells/nand4_4.sym} 36660 -20960 0 0 {name=X_70890_ }
C {devices/lab_pin.sym} 36570 -20810 0 0 {name=p36171 lab=_82942_/CLK }
C {devices/lab_pin.sym} 36570 -20790 0 0 {name=p36172 lab=_78262_/B }
C {devices/lab_pin.sym} 36750 -20810 0 1 {name=p36173 lab=_82876_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -20800 0 0 {name=X_82876_ }
C {devices/lab_pin.sym} 36570 -20670 0 0 {name=p36174 lab=_88171_/CLK }
C {devices/lab_pin.sym} 36570 -20650 0 0 {name=p36175 lab=_43477_/Y }
C {devices/lab_pin.sym} 36750 -20670 0 1 {name=p36176 lab=_87403_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -20660 0 0 {name=X_87403_ }
C {devices/lab_pin.sym} 36570 -20530 0 0 {name=p36177 lab=_84477_/CLK }
C {devices/lab_pin.sym} 36570 -20510 0 0 {name=p36178 lab=_60457_/Y }
C {devices/lab_pin.sym} 36750 -20530 0 1 {name=p36179 lab=_79155_/A }
C {sky130_stdcells/dfxtp_4.sym} 36660 -20520 0 0 {name=X_84615_ }
C {devices/lab_pin.sym} 36620 -20390 0 0 {name=p36180 lab=_57563_/A }
C {devices/lab_pin.sym} 36700 -20390 0 1 {name=p36181 lab=_57563_/X }
C {sky130_stdcells/buf_2.sym} 36660 -20390 0 0 {name=X_57563_ }
C {devices/lab_pin.sym} 36570 -20270 0 0 {name=p36182 lab=_82211_/CLK }
C {devices/lab_pin.sym} 36570 -20250 0 0 {name=p36183 lab=_81827_/D }
C {devices/lab_pin.sym} 36750 -20270 0 1 {name=p36184 lab=_77236_/A }
C {sky130_stdcells/dfxtp_4.sym} 36660 -20260 0 0 {name=X_81827_ }
C {devices/lab_pin.sym} 36580 -20150 0 0 {name=p36185 lab=_69546_/X }
C {devices/lab_pin.sym} 36580 -20110 0 0 {name=p36186 lab=_69548_/X }
C {devices/lab_pin.sym} 36580 -20070 0 0 {name=p36187 lab=_69433_/X }
C {devices/lab_pin.sym} 36740 -20110 0 1 {name=p36188 lab=_69549_/Y }
C {sky130_stdcells/a21oi_4.sym} 36660 -20110 0 0 {name=X_69549_ }
C {devices/lab_pin.sym} 36570 -19970 0 0 {name=p36189 lab=_87417_/CLK }
C {devices/lab_pin.sym} 36570 -19950 0 0 {name=p36190 lab=_40494_/Y }
C {devices/lab_pin.sym} 36750 -19970 0 1 {name=p36191 lab=_88383_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -19960 0 0 {name=X_88383_ }
C {devices/lab_pin.sym} 36600 -19860 0 0 {name=p36192 lab=_54775_/A }
C {devices/lab_pin.sym} 36600 -19820 0 0 {name=p36193 lab=_54788_/B }
C {devices/lab_pin.sym} 36600 -19780 0 0 {name=p36194 lab=_54775_/C }
C {devices/lab_pin.sym} 36600 -19740 0 0 {name=p36195 lab=_47502_/A }
C {devices/lab_pin.sym} 36720 -19800 0 1 {name=p36196 lab=_54775_/X }
C {sky130_stdcells/and4_4.sym} 36660 -19800 0 0 {name=X_54775_ }
C {devices/lab_pin.sym} 36570 -19650 0 0 {name=p36197 lab=_85590_/CLK }
C {devices/lab_pin.sym} 36570 -19630 0 0 {name=p36198 lab=_85595_/D }
C {devices/lab_pin.sym} 36750 -19650 0 1 {name=p36199 lab=_85595_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -19640 0 0 {name=X_85595_ }
C {devices/lab_pin.sym} 36620 -19510 0 0 {name=p36200 lab=_52486_/A }
C {devices/lab_pin.sym} 36700 -19510 0 1 {name=p36201 lab=_51987_/X }
C {sky130_stdcells/buf_2.sym} 36660 -19510 0 0 {name=X_51987_ }
C {devices/lab_pin.sym} 36580 -19430 0 0 {name=p36202 lab=_59237_/X }
C {devices/lab_pin.sym} 36580 -19390 0 0 {name=p36203 lab=_59299_/Y }
C {devices/lab_pin.sym} 36580 -19350 0 0 {name=p36204 lab=_59300_/Y }
C {devices/lab_pin.sym} 36580 -19310 0 0 {name=p36205 lab=_59301_/X }
C {devices/lab_pin.sym} 36580 -19270 0 0 {name=p36206 lab=_59241_/X }
C {devices/lab_pin.sym} 36740 -19350 0 1 {name=p36207 lab=_59302_/X }
C {sky130_stdcells/o32a_4.sym} 36660 -19350 0 0 {name=X_59302_ }
C {devices/lab_pin.sym} 36580 -19210 0 0 {name=p36208 lab=_56103_/X }
C {devices/lab_pin.sym} 36580 -19170 0 0 {name=p36209 lab=_56499_/X }
C {devices/lab_pin.sym} 36580 -19130 0 0 {name=p36210 lab=_56513_/Y }
C {devices/lab_pin.sym} 36740 -19170 0 1 {name=p36211 lab=_56514_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -19170 0 0 {name=X_56514_ }
C {devices/lab_pin.sym} 36580 -19050 0 0 {name=p36212 lab=_41717_/X }
C {devices/lab_pin.sym} 36580 -19010 0 0 {name=p36213 lab=_81740_/Q }
C {devices/lab_pin.sym} 36580 -18970 0 0 {name=p36214 lab=_41739_/X }
C {devices/lab_pin.sym} 36740 -19010 0 1 {name=p36215 lab=_41741_/A }
C {sky130_stdcells/o21ai_4.sym} 36660 -19010 0 0 {name=X_41740_ }
C {devices/lab_pin.sym} 36570 -18870 0 0 {name=p36216 lab=_87345_/CLK }
C {devices/lab_pin.sym} 36570 -18850 0 0 {name=p36217 lab=_43632_/Y }
C {devices/lab_pin.sym} 36750 -18870 0 1 {name=p36218 lab=_87334_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -18860 0 0 {name=X_87334_ }
C {devices/lab_pin.sym} 36600 -18740 0 0 {name=p36219 lab=_53778_/A }
C {devices/lab_pin.sym} 36600 -18700 0 0 {name=p36220 lab=_50503_/B }
C {devices/lab_pin.sym} 36720 -18720 0 1 {name=p36221 lab=_53726_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -18720 0 0 {name=X_53726_ }
C {devices/lab_pin.sym} 36620 -18590 0 0 {name=p36222 lab=_72559_/Y }
C {devices/lab_pin.sym} 36700 -18590 0 1 {name=p36223 lab=_72560_/Y }
C {sky130_stdcells/inv_2.sym} 36660 -18590 0 0 {name=X_72560_ }
C {devices/lab_pin.sym} 36570 -18470 0 0 {name=p36224 lab=_84529_/CLK }
C {devices/lab_pin.sym} 36570 -18450 0 0 {name=p36225 lab=_84546_/D }
C {devices/lab_pin.sym} 36750 -18470 0 1 {name=p36226 lab=_84546_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -18460 0 0 {name=X_84546_ }
C {devices/lab_pin.sym} 36620 -18330 0 0 {name=p36227 lab=_51021_/A }
C {devices/lab_pin.sym} 36700 -18330 0 1 {name=p36228 lab=_50938_/X }
C {sky130_stdcells/buf_2.sym} 36660 -18330 0 0 {name=X_50938_ }
C {devices/lab_pin.sym} 36620 -18210 0 0 {name=p36229 lab=_46366_/A }
C {devices/lab_pin.sym} 36700 -18210 0 1 {name=p36230 lab=_57499_/A }
C {sky130_stdcells/buf_2.sym} 36660 -18210 0 0 {name=X_57494_ }
C {devices/lab_pin.sym} 36570 -18090 0 0 {name=p36231 lab=_81783_/CLK }
C {devices/lab_pin.sym} 36570 -18070 0 0 {name=p36232 lab=_76130_/B }
C {devices/lab_pin.sym} 36750 -18090 0 1 {name=p36233 lab=_81758_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -18080 0 0 {name=X_81758_ }
C {devices/lab_pin.sym} 36580 -17970 0 0 {name=p36234 lab=_59231_/X }
C {devices/lab_pin.sym} 36580 -17930 0 0 {name=p36235 lab=_85422_/Q }
C {devices/lab_pin.sym} 36580 -17890 0 0 {name=p36236 lab=_59232_/X }
C {devices/lab_pin.sym} 36740 -17930 0 1 {name=p36237 lab=_59233_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -17930 0 0 {name=X_59233_ }
C {devices/lab_pin.sym} 36580 -17810 0 0 {name=p36238 lab=_53227_/B }
C {devices/lab_pin.sym} 36580 -17770 0 0 {name=p36239 lab=_71508_/X }
C {devices/lab_pin.sym} 36580 -17730 0 0 {name=p36240 lab=_71510_/Y }
C {devices/lab_pin.sym} 36740 -17770 0 1 {name=p36241 lab=_83473_/D }
C {sky130_stdcells/o21ai_4.sym} 36660 -17770 0 0 {name=X_71511_ }
C {devices/lab_pin.sym} 36580 -17650 0 0 {name=p36242 lab=_56148_/X }
C {devices/lab_pin.sym} 36580 -17610 0 0 {name=p36243 lab=_56439_/X }
C {devices/lab_pin.sym} 36580 -17570 0 0 {name=p36244 lab=_56444_/Y }
C {devices/lab_pin.sym} 36740 -17610 0 1 {name=p36245 lab=_85191_/D }
C {sky130_stdcells/o21ai_4.sym} 36660 -17610 0 0 {name=X_56445_ }
C {devices/lab_pin.sym} 36570 -17470 0 0 {name=p36246 lab=_80676_/CLK }
C {devices/lab_pin.sym} 36570 -17450 0 0 {name=p36247 lab=_75895_/X }
C {devices/lab_pin.sym} 36750 -17470 0 1 {name=p36248 lab=_80709_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -17460 0 0 {name=X_80709_ }
C {devices/lab_pin.sym} 36570 -17330 0 0 {name=p36249 lab=_88036_/CLK }
C {devices/lab_pin.sym} 36570 -17310 0 0 {name=p36250 lab=_87265_/D }
C {devices/lab_pin.sym} 36750 -17330 0 1 {name=p36251 lab=_87265_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -17320 0 0 {name=X_87265_ }
C {devices/lab_pin.sym} 36620 -17190 0 0 {name=p36252 lab=_44587_/A }
C {devices/lab_pin.sym} 36700 -17190 0 1 {name=p36253 lab=_41802_/A }
C {sky130_stdcells/buf_2.sym} 36660 -17190 0 0 {name=X_41671_ }
C {devices/lab_pin.sym} 36580 -17090 0 0 {name=p36254 lab=_85593_/Q }
C {devices/lab_pin.sym} 36580 -17050 0 0 {name=p36255 lab=_53626_/X }
C {devices/lab_pin.sym} 36580 -17010 0 0 {name=p36256 lab=_53656_/Y }
C {devices/lab_pin.sym} 36740 -17050 0 1 {name=p36257 lab=_53657_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -17050 0 0 {name=X_53657_ }
C {devices/lab_pin.sym} 36580 -16930 0 0 {name=p36258 lab=_72484_/X }
C {devices/lab_pin.sym} 36580 -16890 0 0 {name=p36259 lab=_83383_/Q }
C {devices/lab_pin.sym} 36580 -16850 0 0 {name=p36260 lab=_72490_/Y }
C {devices/lab_pin.sym} 36740 -16890 0 1 {name=p36261 lab=_83247_/D }
C {sky130_stdcells/o21a_4.sym} 36660 -16890 0 0 {name=X_72491_ }
C {devices/lab_pin.sym} 36570 -16750 0 0 {name=p36262 lab=_84477_/CLK }
C {devices/lab_pin.sym} 36570 -16730 0 0 {name=p36263 lab=_84477_/D }
C {devices/lab_pin.sym} 36750 -16750 0 1 {name=p36264 lab=_84477_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -16740 0 0 {name=X_84477_ }
C {devices/lab_pin.sym} 36580 -16630 0 0 {name=p36265 lab=_50867_/Y }
C {devices/lab_pin.sym} 36580 -16590 0 0 {name=p36266 lab=_50849_/X }
C {devices/lab_pin.sym} 36580 -16550 0 0 {name=p36267 lab=_50868_/Y }
C {devices/lab_pin.sym} 36740 -16590 0 1 {name=p36268 lab=_50869_/Y }
C {sky130_stdcells/a21boi_4.sym} 36660 -16590 0 0 {name=X_50869_ }
C {devices/lab_pin.sym} 36570 -16450 0 0 {name=p36269 lab=_81689_/CLK }
C {devices/lab_pin.sym} 36570 -16430 0 0 {name=p36270 lab=_80171_/X }
C {devices/lab_pin.sym} 36750 -16450 0 1 {name=p36271 lab=_76707_/A }
C {sky130_stdcells/dfxtp_4.sym} 36660 -16440 0 0 {name=X_81689_ }
C {sky130_stdcells/decap_3.sym} 36660 -16280 0 0 {name=XPHY_100 }
C {devices/lab_pin.sym} 36580 -16160 0 0 {name=p36272 lab=_41503_/X }
C {devices/lab_pin.sym} 36580 -16120 0 0 {name=p36273 lab=_43396_/X }
C {devices/lab_pin.sym} 36580 -16080 0 0 {name=p36274 lab=_87435_/Q }
C {devices/lab_pin.sym} 36580 -16040 0 0 {name=p36275 lab=_43397_/X }
C {devices/lab_pin.sym} 36740 -16100 0 1 {name=p36276 lab=_87435_/D }
C {sky130_stdcells/a2bb2o_4.sym} 36660 -16100 0 0 {name=X_43410_ }
C {devices/lab_pin.sym} 36570 -15950 0 0 {name=p36277 lab=_85599_/CLK }
C {devices/lab_pin.sym} 36570 -15930 0 0 {name=p36278 lab=_50361_/Y }
C {devices/lab_pin.sym} 36750 -15950 0 1 {name=p36279 lab=_86216_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -15940 0 0 {name=X_86216_ }
C {devices/lab_pin.sym} 36580 -15830 0 0 {name=p36280 lab=_44745_/Y }
C {devices/lab_pin.sym} 36580 -15790 0 0 {name=p36281 lab=_56274_/X }
C {devices/lab_pin.sym} 36580 -15750 0 0 {name=p36282 lab=_74229_/Y }
C {devices/lab_pin.sym} 36740 -15790 0 1 {name=p36283 lab=_74230_/X }
C {sky130_stdcells/a21o_4.sym} 36660 -15790 0 0 {name=X_74230_ }
C {devices/lab_pin.sym} 36620 -15650 0 0 {name=p36284 lab=_46526_/A }
C {devices/lab_pin.sym} 36700 -15650 0 1 {name=p36285 lab=_48904_/A }
C {sky130_stdcells/buf_2.sym} 36660 -15650 0 0 {name=X_40622_ }
C {sky130_stdcells/decap_3.sym} 36660 -15500 0 0 {name=XPHY_111 }
C {devices/lab_pin.sym} 36600 -15360 0 0 {name=p36286 lab=_52624_/A }
C {devices/lab_pin.sym} 36600 -15320 0 0 {name=p36287 lab=_46676_/A }
C {devices/lab_pin.sym} 36720 -15340 0 1 {name=p36288 lab=_52608_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -15340 0 0 {name=X_52608_ }
C {devices/lab_pin.sym} 36580 -15230 0 0 {name=p36289 lab=_59085_/X }
C {devices/lab_pin.sym} 36580 -15190 0 0 {name=p36290 lab=_86068_/Q }
C {devices/lab_pin.sym} 36580 -15150 0 0 {name=p36291 lab=_59163_/X }
C {devices/lab_pin.sym} 36740 -15190 0 1 {name=p36292 lab=_59164_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -15190 0 0 {name=X_59164_ }
C {devices/lab_pin.sym} 36570 -15050 0 0 {name=p36293 lab=_82386_/CLK }
C {devices/lab_pin.sym} 36570 -15030 0 0 {name=p36294 lab=_71643_/Y }
C {devices/lab_pin.sym} 36750 -15050 0 1 {name=p36295 lab=_83428_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -15040 0 0 {name=X_83428_ }
C {devices/lab_pin.sym} 36600 -14930 0 0 {name=p36296 lab=_71258_/A }
C {devices/lab_pin.sym} 36600 -14890 0 0 {name=p36297 lab=_71217_/B }
C {devices/lab_pin.sym} 36600 -14850 0 0 {name=p36298 lab=_71500_/C }
C {devices/lab_pin.sym} 36720 -14890 0 1 {name=p36299 lab=_71442_/Y }
C {sky130_stdcells/nand3_4.sym} 36660 -14890 0 0 {name=X_71442_ }
C {sky130_stdcells/decap_3.sym} 36660 -14720 0 0 {name=XPHY_122 }
C {devices/lab_pin.sym} 36580 -14600 0 0 {name=p36300 lab=_41469_/X }
C {devices/lab_pin.sym} 36580 -14560 0 0 {name=p36301 lab=_44377_/X }
C {devices/lab_pin.sym} 36580 -14520 0 0 {name=p36302 lab=_87133_/Q }
C {devices/lab_pin.sym} 36580 -14480 0 0 {name=p36303 lab=_44379_/X }
C {devices/lab_pin.sym} 36740 -14540 0 1 {name=p36304 lab=_44390_/X }
C {sky130_stdcells/a2bb2o_4.sym} 36660 -14540 0 0 {name=X_44390_ }
C {devices/lab_pin.sym} 36580 -14410 0 0 {name=p36305 lab=_56372_/X }
C {devices/lab_pin.sym} 36580 -14370 0 0 {name=p36306 lab=_55987_/X }
C {devices/lab_pin.sym} 36580 -14330 0 0 {name=p36307 lab=_56375_/Y }
C {devices/lab_pin.sym} 36740 -14370 0 1 {name=p36308 lab=_85217_/D }
C {sky130_stdcells/o21ai_4.sym} 36660 -14370 0 0 {name=X_56376_ }
C {devices/lab_pin.sym} 36570 -14230 0 0 {name=p36309 lab=_87446_/CLK }
C {devices/lab_pin.sym} 36570 -14210 0 0 {name=p36310 lab=_87196_/D }
C {devices/lab_pin.sym} 36750 -14230 0 1 {name=p36311 lab=_67891_/B }
C {sky130_stdcells/dfxtp_4.sym} 36660 -14220 0 0 {name=X_87196_ }
C {devices/lab_pin.sym} 36600 -14100 0 0 {name=p36312 lab=_53601_/A }
C {devices/lab_pin.sym} 36600 -14060 0 0 {name=p36313 lab=_53588_/B }
C {devices/lab_pin.sym} 36720 -14080 0 1 {name=p36314 lab=_53588_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -14080 0 0 {name=X_53588_ }
C {sky130_stdcells/decap_3.sym} 36660 -13920 0 0 {name=XPHY_133 }
C {sky130_stdcells/decap_3.sym} 36660 -13740 0 0 {name=XPHY_144 }
C {devices/lab_pin.sym} 36580 -13610 0 0 {name=p36315 lab=_58111_/Y }
C {devices/lab_pin.sym} 36580 -13570 0 0 {name=p36316 lab=_58114_/Y }
C {devices/lab_pin.sym} 36580 -13530 0 0 {name=p36317 lab=_58003_/X }
C {devices/lab_pin.sym} 36740 -13570 0 1 {name=p36318 lab=_58115_/X }
C {sky130_stdcells/a21o_4.sym} 36660 -13570 0 0 {name=X_58115_ }
C {sky130_stdcells/decap_3.sym} 36660 -13400 0 0 {name=XPHY_155 }
C {devices/lab_pin.sym} 36580 -13280 0 0 {name=p36319 lab=_41312_/X }
C {devices/lab_pin.sym} 36580 -13240 0 0 {name=p36320 lab=_43336_/X }
C {devices/lab_pin.sym} 36580 -13200 0 0 {name=p36321 lab=_87470_/Q }
C {devices/lab_pin.sym} 36580 -13160 0 0 {name=p36322 lab=_43337_/X }
C {devices/lab_pin.sym} 36740 -13220 0 1 {name=p36323 lab=_87470_/D }
C {sky130_stdcells/a2bb2o_4.sym} 36660 -13220 0 0 {name=X_43341_ }
C {devices/lab_pin.sym} 36600 -13090 0 0 {name=p36324 lab=_55322_/X }
C {devices/lab_pin.sym} 36600 -13050 0 0 {name=p36325 lab=_83750_/Q }
C {devices/lab_pin.sym} 36600 -13010 0 0 {name=p36326 lab=_55324_/X }
C {devices/lab_pin.sym} 36720 -13050 0 1 {name=p36327 lab=_55384_/A }
C {sky130_stdcells/nand3_4.sym} 36660 -13050 0 0 {name=X_55327_ }
C {devices/lab_pin.sym} 36600 -12920 0 0 {name=p36328 lab=_74148_/Y }
C {devices/lab_pin.sym} 36600 -12880 0 0 {name=p36329 lab=_74161_/B }
C {devices/lab_pin.sym} 36720 -12900 0 1 {name=p36330 lab=_74161_/Y }
C {sky130_stdcells/xnor2_4.sym} 36660 -12900 0 0 {name=X_74161_ }
C {devices/lab_pin.sym} 36570 -12770 0 0 {name=p36331 lab=_83594_/CLK }
C {devices/lab_pin.sym} 36570 -12750 0 0 {name=p36332 lab=_86147_/D }
C {devices/lab_pin.sym} 36750 -12770 0 1 {name=p36333 lab=_86147_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -12760 0 0 {name=X_86147_ }
C {devices/lab_pin.sym} 36620 -12630 0 0 {name=p36334 lab=_42446_/A }
C {devices/lab_pin.sym} 36700 -12630 0 1 {name=p36335 lab=_40636_/A }
C {sky130_stdcells/inv_2.sym} 36660 -12630 0 0 {name=X_40553_ }
C {devices/lab_pin.sym} 36600 -12520 0 0 {name=p36336 lab=_52501_/X }
C {devices/lab_pin.sym} 36600 -12480 0 0 {name=p36337 lab=_54058_/B }
C {devices/lab_pin.sym} 36720 -12500 0 1 {name=p36338 lab=_52539_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -12500 0 0 {name=X_52539_ }
C {sky130_stdcells/decap_3.sym} 36660 -12340 0 0 {name=XPHY_166 }
C {devices/lab_pin.sym} 36580 -12230 0 0 {name=p36339 lab=_59027_/X }
C {devices/lab_pin.sym} 36580 -12190 0 0 {name=p36340 lab=_59093_/Y }
C {devices/lab_pin.sym} 36580 -12150 0 0 {name=p36341 lab=_59094_/Y }
C {devices/lab_pin.sym} 36580 -12110 0 0 {name=p36342 lab=_59046_/X }
C {devices/lab_pin.sym} 36580 -12070 0 0 {name=p36343 lab=_59031_/X }
C {devices/lab_pin.sym} 36740 -12150 0 1 {name=p36344 lab=_59095_/X }
C {sky130_stdcells/o32a_4.sym} 36660 -12150 0 0 {name=X_59095_ }
C {devices/lab_pin.sym} 36620 -11990 0 0 {name=p36345 lab=_71372_/Y }
C {devices/lab_pin.sym} 36700 -11990 0 1 {name=p36346 lab=_71373_/X }
C {sky130_stdcells/buf_2.sym} 36660 -11990 0 0 {name=X_71373_ }
C {devices/lab_pin.sym} 36570 -11870 0 0 {name=p36347 lab=_83421_/CLK }
C {devices/lab_pin.sym} 36570 -11850 0 0 {name=p36348 lab=_83359_/D }
C {devices/lab_pin.sym} 36750 -11870 0 1 {name=p36349 lab=_83359_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -11860 0 0 {name=X_83359_ }
C {sky130_stdcells/decap_3.sym} 36660 -11700 0 0 {name=XPHY_177 }
C {sky130_stdcells/decap_3.sym} 36660 -11520 0 0 {name=XPHY_188 }
C {devices/lab_pin.sym} 36600 -11380 0 0 {name=p36350 lab=_73181_/A }
C {devices/lab_pin.sym} 36600 -11340 0 0 {name=p36351 lab=_85876_/Q }
C {devices/lab_pin.sym} 36720 -11360 0 1 {name=p36352 lab=_73112_/X }
C {sky130_stdcells/and2_4.sym} 36660 -11360 0 0 {name=X_73112_ }
C {sky130_stdcells/decap_3.sym} 36660 -11200 0 0 {name=XPHY_199 }
C {devices/lab_pin.sym} 36580 -11070 0 0 {name=p36353 lab=_70320_/X }
C {devices/lab_pin.sym} 36580 -11030 0 0 {name=p36354 lab=_74768_/B }
C {devices/lab_pin.sym} 36580 -10990 0 0 {name=p36355 lab=_70323_/X }
C {devices/lab_pin.sym} 36740 -11030 0 1 {name=p36356 lab=_83797_/D }
C {sky130_stdcells/a21o_4.sym} 36660 -11030 0 0 {name=X_70324_ }
C {devices/lab_pin.sym} 36580 -10920 0 0 {name=p36357 lab=_41555_/Y }
C {devices/lab_pin.sym} 36580 -10880 0 0 {name=p36358 lab=_46043_/X }
C {devices/lab_pin.sym} 36580 -10840 0 0 {name=p36359 lab=_86788_/Q }
C {devices/lab_pin.sym} 36580 -10800 0 0 {name=p36360 lab=_46044_/X }
C {devices/lab_pin.sym} 36740 -10860 0 1 {name=p36361 lab=_46060_/X }
C {sky130_stdcells/a2bb2o_4.sym} 36660 -10860 0 0 {name=X_46060_ }
C {devices/lab_pin.sym} 36580 -10730 0 0 {name=p36362 lab=_58042_/Y }
C {devices/lab_pin.sym} 36580 -10690 0 0 {name=p36363 lab=_58045_/Y }
C {devices/lab_pin.sym} 36580 -10650 0 0 {name=p36364 lab=_58035_/X }
C {devices/lab_pin.sym} 36740 -10690 0 1 {name=p36365 lab=_58046_/X }
C {sky130_stdcells/a21o_4.sym} 36660 -10690 0 0 {name=X_58046_ }
C {devices/lab_pin.sym} 36580 -10580 0 0 {name=p36366 lab=_41121_/X }
C {devices/lab_pin.sym} 36580 -10540 0 0 {name=p36367 lab=_43264_/X }
C {devices/lab_pin.sym} 36580 -10500 0 0 {name=p36368 lab=_87506_/Q }
C {devices/lab_pin.sym} 36580 -10460 0 0 {name=p36369 lab=_43265_/X }
C {devices/lab_pin.sym} 36740 -10520 0 1 {name=p36370 lab=_87506_/D }
C {sky130_stdcells/a2bb2o_4.sym} 36660 -10520 0 0 {name=X_43272_ }
C {devices/lab_pin.sym} 36600 -10380 0 0 {name=p36371 lab=_55135_/A }
C {devices/lab_pin.sym} 36600 -10340 0 0 {name=p36372 lab=_85065_/Q }
C {devices/lab_pin.sym} 36720 -10360 0 1 {name=p36373 lab=_55258_/X }
C {sky130_stdcells/and2_4.sym} 36660 -10360 0 0 {name=X_55258_ }
C {devices/lab_pin.sym} 36570 -10230 0 0 {name=p36374 lab=_85757_/CLK }
C {devices/lab_pin.sym} 36570 -10210 0 0 {name=p36375 lab=_86078_/D }
C {devices/lab_pin.sym} 36750 -10230 0 1 {name=p36376 lab=_86078_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -10220 0 0 {name=X_86078_ }
C {devices/lab_pin.sym} 36600 -10100 0 0 {name=p36377 lab=_74079_/Y }
C {devices/lab_pin.sym} 36600 -10060 0 0 {name=p36378 lab=_74092_/B }
C {devices/lab_pin.sym} 36720 -10080 0 1 {name=p36379 lab=_74093_/B }
C {sky130_stdcells/xnor2_4.sym} 36660 -10080 0 0 {name=X_74092_ }
C {devices/lab_pin.sym} 36580 -9970 0 0 {name=p36380 lab=_40325_/X }
C {devices/lab_pin.sym} 36580 -9930 0 0 {name=p36381 lab=_82318_/Q }
C {devices/lab_pin.sym} 36580 -9890 0 0 {name=p36382 lab=_40483_/X }
C {devices/lab_pin.sym} 36740 -9930 0 1 {name=p36383 lab=_40484_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -9930 0 0 {name=X_40484_ }
C {devices/lab_pin.sym} 36580 -9810 0 0 {name=p36384 lab=_45003_/X }
C {devices/lab_pin.sym} 36580 -9770 0 0 {name=p36385 lab=_45008_/Y }
C {devices/lab_pin.sym} 36580 -9730 0 0 {name=p36386 lab=_45010_/Y }
C {devices/lab_pin.sym} 36740 -9770 0 1 {name=p36387 lab=_45011_/Y }
C {sky130_stdcells/a21oi_4.sym} 36660 -9770 0 0 {name=X_45011_ }
C {devices/lab_pin.sym} 36620 -9630 0 0 {name=p36388 lab=_41909_/Y }
C {devices/lab_pin.sym} 36700 -9630 0 1 {name=p36389 lab=_42259_/A }
C {sky130_stdcells/buf_2.sym} 36660 -9630 0 0 {name=X_42223_ }
C {devices/lab_pin.sym} 36600 -9540 0 0 {name=p36390 lab=_54208_/X }
C {devices/lab_pin.sym} 36600 -9500 0 0 {name=p36391 lab=_54191_/B }
C {devices/lab_pin.sym} 36600 -9460 0 0 {name=p36392 lab=_54209_/C }
C {devices/lab_pin.sym} 36600 -9420 0 0 {name=p36393 lab=_53044_/D }
C {devices/lab_pin.sym} 36720 -9480 0 1 {name=p36394 lab=_54209_/X }
C {sky130_stdcells/and4_4.sym} 36660 -9480 0 0 {name=X_54209_ }
C {devices/lab_pin.sym} 36580 -9360 0 0 {name=p36395 lab=_72908_/X }
C {devices/lab_pin.sym} 36580 -9320 0 0 {name=p36396 lab=_85591_/Q }
C {devices/lab_pin.sym} 36580 -9280 0 0 {name=p36397 lab=_72909_/X }
C {devices/lab_pin.sym} 36580 -9240 0 0 {name=p36398 lab=_73042_/X }
C {devices/lab_pin.sym} 36740 -9300 0 1 {name=p36399 lab=_73043_/X }
C {sky130_stdcells/a211o_4.sym} 36660 -9300 0 0 {name=X_73043_ }
C {devices/lab_pin.sym} 36600 -9160 0 0 {name=p36400 lab=_77920_/A }
C {devices/lab_pin.sym} 36600 -9120 0 0 {name=p36401 lab=_77919_/Y }
C {devices/lab_pin.sym} 36720 -9140 0 1 {name=p36402 lab=_77923_/A }
C {sky130_stdcells/xor2_4.sym} 36660 -9140 0 0 {name=X_77920_ }
C {devices/lab_pin.sym} 36570 -9010 0 0 {name=p36403 lab=_85040_/CLK }
C {devices/lab_pin.sym} 36570 -8990 0 0 {name=p36404 lab=_85029_/D }
C {devices/lab_pin.sym} 36750 -9010 0 1 {name=p36405 lab=_85029_/Q }
C {sky130_stdcells/dfxtp_4.sym} 36660 -9000 0 0 {name=X_85029_ }
C {devices/lab_pin.sym} 36620 -8870 0 0 {name=p36406 lab=_70238_/A }
C {devices/lab_pin.sym} 36700 -8870 0 1 {name=p36407 lab=_70255_/X }
C {sky130_stdcells/buf_2.sym} 36660 -8870 0 0 {name=X_70255_ }
C {devices/lab_pin.sym} 36620 -8750 0 0 {name=p36408 lab=_55278_/A }
C {devices/lab_pin.sym} 36700 -8750 0 1 {name=p36409 lab=_55710_/B }
C {sky130_stdcells/buf_2.sym} 36660 -8750 0 0 {name=X_55189_ }
C {devices/lab_pin.sym} 36620 -8630 0 0 {name=p36410 lab=_42083_/A }
C {devices/lab_pin.sym} 36700 -8630 0 1 {name=p36411 lab=_42154_/X }
C {sky130_stdcells/buf_2.sym} 36660 -8630 0 0 {name=X_42154_ }
C {devices/lab_pin.sym} 36620 -8510 0 0 {name=p36412 lab=_77851_/A }
C {devices/lab_pin.sym} 36700 -8510 0 1 {name=p36413 lab=_77851_/Y }
C {sky130_stdcells/inv_2.sym} 36660 -8510 0 0 {name=X_77851_ }
C {devices/lab_pin.sym} 36620 -8390 0 0 {name=p36414 lab=_70232_/A }
C {devices/lab_pin.sym} 36700 -8390 0 1 {name=p36415 lab=_70200_/B }
C {sky130_stdcells/buf_2.sym} 36660 -8390 0 0 {name=X_70186_ }
C {devices/lab_pin.sym} 36600 -8300 0 0 {name=p36416 lab=_59995_/X }
C {devices/lab_pin.sym} 36600 -8260 0 0 {name=p36417 lab=_59950_/B }
C {devices/lab_pin.sym} 36600 -8220 0 0 {name=p36418 lab=_59977_/B }
C {devices/lab_pin.sym} 36600 -8180 0 0 {name=p36419 lab=_60091_/B }
C {devices/lab_pin.sym} 36720 -8240 0 1 {name=p36420 lab=_59998_/B }
C {sky130_stdcells/nand4_4.sym} 36660 -8240 0 0 {name=X_59997_ }
C {devices/lab_pin.sym} 36580 -8120 0 0 {name=p36421 lab=_41104_/X }
C {devices/lab_pin.sym} 36580 -8080 0 0 {name=p36422 lab=_41065_/X }
C {devices/lab_pin.sym} 36580 -8040 0 0 {name=p36423 lab=_69547_/B }
C {devices/lab_pin.sym} 36580 -8000 0 0 {name=p36424 lab=_41066_/X }
C {devices/lab_pin.sym} 36740 -8060 0 1 {name=p36425 lab=_88277_/D }
C {sky130_stdcells/a2bb2o_4.sym} 36660 -8060 0 0 {name=X_41105_ }
C {devices/lab_pin.sym} 36600 -7920 0 0 {name=p36426 lab=_76802_/A }
C {devices/lab_pin.sym} 36600 -7880 0 0 {name=p36427 lab=_76802_/B }
C {devices/lab_pin.sym} 36720 -7900 0 1 {name=p36428 lab=_76802_/X }
C {sky130_stdcells/xor2_4.sym} 36660 -7900 0 0 {name=X_76802_ }
C {devices/lab_pin.sym} 36620 -7770 0 0 {name=p36429 lab=_49641_/A }
C {devices/lab_pin.sym} 36700 -7770 0 1 {name=p36430 lab=_49750_/X }
C {sky130_stdcells/buf_2.sym} 36660 -7770 0 0 {name=X_49750_ }
C {devices/lab_pin.sym} 36620 -7650 0 0 {name=p36431 lab=_46961_/X }
C {devices/lab_pin.sym} 36700 -7650 0 1 {name=p36432 lab=_46981_/A }
C {sky130_stdcells/buf_2.sym} 36660 -7650 0 0 {name=X_46962_ }
C {devices/lab_pin.sym} 36620 -7530 0 0 {name=p36433 lab=_42084_/Y }
C {devices/lab_pin.sym} 36700 -7530 0 1 {name=p36434 lab=_42085_/Y }
C {sky130_stdcells/inv_2.sym} 36660 -7530 0 0 {name=X_42085_ }
C {devices/lab_pin.sym} 36580 -7430 0 0 {name=p36435 lab=_58858_/X }
C {devices/lab_pin.sym} 36580 -7390 0 0 {name=p36436 lab=_85443_/Q }
C {devices/lab_pin.sym} 36580 -7350 0 0 {name=p36437 lab=_58947_/X }
C {devices/lab_pin.sym} 36740 -7390 0 1 {name=p36438 lab=_58948_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -7390 0 0 {name=X_58948_ }
C {devices/lab_pin.sym} 36620 -7250 0 0 {name=p36439 lab=_77782_/A }
C {devices/lab_pin.sym} 36700 -7250 0 1 {name=p36440 lab=_77782_/Y }
C {sky130_stdcells/inv_2.sym} 36660 -7250 0 0 {name=X_77782_ }
C {devices/lab_pin.sym} 36600 -7140 0 0 {name=p36441 lab=_81143_/D }
C {devices/lab_pin.sym} 36600 -7100 0 0 {name=p36442 lab=_75003_/B }
C {devices/lab_pin.sym} 36720 -7120 0 1 {name=p36443 lab=_74994_/X }
C {sky130_stdcells/xor2_4.sym} 36660 -7120 0 0 {name=X_74994_ }
C {devices/lab_pin.sym} 36620 -6990 0 0 {name=p36444 lab=_74509_/A }
C {devices/lab_pin.sym} 36700 -6990 0 1 {name=p36445 lab=_48702_/A }
C {sky130_stdcells/buf_2.sym} 36660 -6990 0 0 {name=X_48701_ }
C {devices/lab_pin.sym} 36600 -6890 0 0 {name=p36446 lab=_79510_/Y }
C {devices/lab_pin.sym} 36600 -6850 0 0 {name=p36447 lab=_79512_/B }
C {devices/lab_pin.sym} 36600 -6810 0 0 {name=p36448 lab=_79519_/A }
C {devices/lab_pin.sym} 36720 -6850 0 1 {name=p36449 lab=_79522_/B }
C {sky130_stdcells/nand3_4.sym} 36660 -6850 0 0 {name=X_79521_ }
C {devices/lab_pin.sym} 36600 -6720 0 0 {name=p36450 lab=MACRO_RD_SELECT }
C {devices/lab_pin.sym} 36600 -6680 0 0 {name=p36451 lab=_59498_/A }
C {devices/lab_pin.sym} 36720 -6700 0 1 {name=p36452 lab=_45913_/Y }
C {sky130_stdcells/nor2_4.sym} 36660 -6700 0 0 {name=X_45913_ }
C {devices/lab_pin.sym} 36620 -6570 0 0 {name=p36453 lab=_41035_/X }
C {devices/lab_pin.sym} 36700 -6570 0 1 {name=p36454 lab=_41036_/X }
C {sky130_stdcells/buf_2.sym} 36660 -6570 0 0 {name=X_41036_ }
C {devices/lab_pin.sym} 36600 -6460 0 0 {name=p36455 lab=_76733_/A }
C {devices/lab_pin.sym} 36600 -6420 0 0 {name=p36456 lab=_76733_/B }
C {devices/lab_pin.sym} 36720 -6440 0 1 {name=p36457 lab=_81547_/D }
C {sky130_stdcells/xor2_4.sym} 36660 -6440 0 0 {name=X_76733_ }
C {devices/lab_pin.sym} 36580 -6330 0 0 {name=p36458 lab=_49676_/Y }
C {devices/lab_pin.sym} 36580 -6290 0 0 {name=p36459 lab=_49677_/X }
C {devices/lab_pin.sym} 36580 -6250 0 0 {name=p36460 lab=_49680_/X }
C {devices/lab_pin.sym} 36740 -6290 0 1 {name=p36461 lab=_86343_/D }
C {sky130_stdcells/a21oi_4.sym} 36660 -6290 0 0 {name=X_49681_ }
C {devices/lab_pin.sym} 36580 -6170 0 0 {name=p36462 lab=_73941_/X }
C {devices/lab_pin.sym} 36580 -6130 0 0 {name=p36463 lab=_73943_/X }
C {devices/lab_pin.sym} 36580 -6090 0 0 {name=p36464 lab=_73944_/X }
C {devices/lab_pin.sym} 36740 -6130 0 1 {name=p36465 lab=_73945_/X }
C {sky130_stdcells/a21o_4.sym} 36660 -6130 0 0 {name=X_73945_ }
C {devices/lab_pin.sym} 36580 -6010 0 0 {name=p36466 lab=_58835_/X }
C {devices/lab_pin.sym} 36580 -5970 0 0 {name=p36467 lab=_85449_/Q }
C {devices/lab_pin.sym} 36580 -5930 0 0 {name=p36468 lab=_58878_/X }
C {devices/lab_pin.sym} 36740 -5970 0 1 {name=p36469 lab=_58879_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -5970 0 0 {name=X_58879_ }
C {devices/lab_pin.sym} 36620 -5830 0 0 {name=p36470 lab=_46941_/A }
C {devices/lab_pin.sym} 36700 -5830 0 1 {name=p36471 lab=_46896_/B }
C {sky130_stdcells/buf_2.sym} 36660 -5830 0 0 {name=X_46893_ }
C {devices/lab_pin.sym} 36600 -5720 0 0 {name=p36472 lab=_60909_/X }
C {devices/lab_pin.sym} 36600 -5680 0 0 {name=p36473 lab=_60910_/B }
C {devices/lab_pin.sym} 36720 -5700 0 1 {name=p36474 lab=_60910_/X }
C {sky130_stdcells/and2_4.sym} 36660 -5700 0 0 {name=X_60910_ }
C {devices/lab_pin.sym} 36600 -5580 0 0 {name=p36475 lab=_48632_/A }
C {devices/lab_pin.sym} 36600 -5540 0 0 {name=p36476 lab=_48632_/B }
C {devices/lab_pin.sym} 36720 -5560 0 1 {name=p36477 lab=_48632_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -5560 0 0 {name=X_48632_ }
C {devices/lab_pin.sym} 36600 -5440 0 0 {name=p36478 lab=_79459_/B }
C {devices/lab_pin.sym} 36600 -5400 0 0 {name=p36479 lab=_79451_/Y }
C {devices/lab_pin.sym} 36720 -5420 0 1 {name=p36480 lab=_82843_/D }
C {sky130_stdcells/xnor2_4.sym} 36660 -5420 0 0 {name=X_79452_ }
C {devices/lab_pin.sym} 36580 -5320 0 0 {name=p36481 lab=_45842_/Y }
C {devices/lab_pin.sym} 36580 -5280 0 0 {name=p36482 lab=_45632_/X }
C {devices/lab_pin.sym} 36580 -5240 0 0 {name=p36483 lab=_44884_/X }
C {devices/lab_pin.sym} 36580 -5200 0 0 {name=p36484 lab=_45843_/Y }
C {devices/lab_pin.sym} 36740 -5260 0 1 {name=p36485 lab=_45844_/X }
C {sky130_stdcells/a211o_4.sym} 36660 -5260 0 0 {name=X_45844_ }
C {devices/lab_pin.sym} 36600 -5120 0 0 {name=p36486 lab=_76664_/A }
C {devices/lab_pin.sym} 36600 -5080 0 0 {name=p36487 lab=_76663_/Y }
C {devices/lab_pin.sym} 36720 -5100 0 1 {name=p36488 lab=_81443_/D }
C {sky130_stdcells/xnor2_4.sym} 36660 -5100 0 0 {name=X_76664_ }
C {devices/lab_pin.sym} 36600 -5000 0 0 {name=p36489 lab=_61447_/B }
C {devices/lab_pin.sym} 36600 -4960 0 0 {name=p36490 lab=_61843_/B }
C {devices/lab_pin.sym} 36600 -4920 0 0 {name=p36491 lab=_61860_/C }
C {devices/lab_pin.sym} 36600 -4880 0 0 {name=p36492 lab=_61860_/D }
C {devices/lab_pin.sym} 36720 -4940 0 1 {name=p36493 lab=_61890_/Y }
C {sky130_stdcells/nand4_4.sym} 36660 -4940 0 0 {name=X_61890_ }
C {devices/lab_pin.sym} 36580 -4810 0 0 {name=p36494 lab=_68699_/B }
C {devices/lab_pin.sym} 36580 -4770 0 0 {name=p36495 lab=_73777_/X }
C {devices/lab_pin.sym} 36580 -4730 0 0 {name=p36496 lab=_73656_/X }
C {devices/lab_pin.sym} 36740 -4770 0 1 {name=p36497 lab=_73876_/X }
C {sky130_stdcells/o21a_4.sym} 36660 -4770 0 0 {name=X_73876_ }
C {devices/lab_pin.sym} 36600 -4640 0 0 {name=p36498 lab=_78403_/A }
C {devices/lab_pin.sym} 36600 -4600 0 0 {name=p36499 lab=_82709_/Q }
C {devices/lab_pin.sym} 36720 -4620 0 1 {name=p36500 lab=_78408_/C }
C {sky130_stdcells/nand2_4.sym} 36660 -4620 0 0 {name=X_78403_ }
C {devices/lab_pin.sym} 36580 -4510 0 0 {name=p36501 lab=_75640_/A }
C {devices/lab_pin.sym} 36580 -4470 0 0 {name=p36502 lab=_75609_/Y }
C {devices/lab_pin.sym} 36580 -4430 0 0 {name=p36503 lab=_75622_/A }
C {devices/lab_pin.sym} 36740 -4470 0 1 {name=p36504 lab=_75615_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -4470 0 0 {name=X_75615_ }
C {devices/lab_pin.sym} 36620 -4330 0 0 {name=p36505 lab=_48471_/A }
C {devices/lab_pin.sym} 36700 -4330 0 1 {name=p36506 lab=_48563_/X }
C {sky130_stdcells/buf_2.sym} 36660 -4330 0 0 {name=X_48563_ }
C {devices/lab_pin.sym} 36600 -4220 0 0 {name=p36507 lab=_60615_/A }
C {devices/lab_pin.sym} 36600 -4180 0 0 {name=p36508 lab=_59551_/A }
C {devices/lab_pin.sym} 36720 -4200 0 1 {name=p36509 lab=_60843_/A }
C {sky130_stdcells/and2_4.sym} 36660 -4200 0 0 {name=X_60841_ }
C {devices/lab_pin.sym} 36620 -4070 0 0 {name=p36510 lab=_44187_/A }
C {devices/lab_pin.sym} 36700 -4070 0 1 {name=p36511 lab=_74012_/A }
C {sky130_stdcells/buf_2.sym} 36660 -4070 0 0 {name=X_72827_ }
C {devices/lab_pin.sym} 36580 -3970 0 0 {name=p36512 lab=_79373_/A }
C {devices/lab_pin.sym} 36580 -3930 0 0 {name=p36513 lab=_79373_/B }
C {devices/lab_pin.sym} 36580 -3890 0 0 {name=p36514 lab=_79382_/Y }
C {devices/lab_pin.sym} 36740 -3930 0 1 {name=p36515 lab=_79387_/A }
C {sky130_stdcells/a21boi_4.sym} 36660 -3930 0 0 {name=X_79383_ }
C {devices/lab_pin.sym} 36580 -3810 0 0 {name=p36516 lab=_82985_/Q }
C {devices/lab_pin.sym} 36580 -3770 0 0 {name=p36517 lab=_45388_/X }
C {devices/lab_pin.sym} 36580 -3730 0 0 {name=p36518 lab=_45774_/X }
C {devices/lab_pin.sym} 36740 -3770 0 1 {name=p36519 lab=_45775_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -3770 0 0 {name=X_45775_ }
C {devices/lab_pin.sym} 36600 -3640 0 0 {name=p36520 lab=_76595_/A }
C {devices/lab_pin.sym} 36600 -3600 0 0 {name=p36521 lab=_76595_/B }
C {devices/lab_pin.sym} 36720 -3620 0 1 {name=p36522 lab=_76595_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -3620 0 0 {name=X_76595_ }
C {devices/lab_pin.sym} 36620 -3490 0 0 {name=p36523 lab=_42986_/Y }
C {devices/lab_pin.sym} 36700 -3490 0 1 {name=p36524 lab=_42987_/Y }
C {sky130_stdcells/inv_2.sym} 36660 -3490 0 0 {name=X_42987_ }
C {devices/lab_pin.sym} 36580 -3390 0 0 {name=p36525 lab=_47508_/Y }
C {devices/lab_pin.sym} 36580 -3350 0 0 {name=p36526 lab=_47509_/X }
C {devices/lab_pin.sym} 36580 -3310 0 0 {name=p36527 lab=_47513_/X }
C {devices/lab_pin.sym} 36740 -3350 0 1 {name=p36528 lab=_86627_/D }
C {sky130_stdcells/a21oi_4.sym} 36660 -3350 0 0 {name=X_47514_ }
C {devices/lab_pin.sym} 36580 -3230 0 0 {name=p36529 lab=_78329_/A }
C {devices/lab_pin.sym} 36580 -3190 0 0 {name=p36530 lab=_78332_/Y }
C {devices/lab_pin.sym} 36580 -3150 0 0 {name=p36531 lab=_78333_/Y }
C {devices/lab_pin.sym} 36740 -3190 0 1 {name=p36532 lab=_78334_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -3190 0 0 {name=X_78334_ }
C {devices/lab_pin.sym} 36580 -3090 0 0 {name=p36533 lab=_44707_/X }
C {devices/lab_pin.sym} 36580 -3050 0 0 {name=p36534 lab=_44708_/X }
C {devices/lab_pin.sym} 36580 -3010 0 0 {name=p36535 lab=_40712_/A }
C {devices/lab_pin.sym} 36580 -2970 0 0 {name=p36536 lab=_44725_/Y }
C {devices/lab_pin.sym} 36580 -2930 0 0 {name=p36537 lab=_44710_/X }
C {devices/lab_pin.sym} 36740 -3010 0 1 {name=p36538 lab=_44726_/Y }
C {sky130_stdcells/o32ai_4.sym} 36660 -3010 0 0 {name=X_44726_ }
C {devices/lab_pin.sym} 36580 -2880 0 0 {name=p36539 lab=_58377_/A }
C {devices/lab_pin.sym} 36580 -2840 0 0 {name=p36540 lab=_63558_/X }
C {devices/lab_pin.sym} 36580 -2800 0 0 {name=p36541 lab=_61528_/A }
C {devices/lab_pin.sym} 36580 -2760 0 0 {name=p36542 lab=_63559_/X }
C {devices/lab_pin.sym} 36740 -2820 0 1 {name=p36543 lab=_63560_/X }
C {sky130_stdcells/a2bb2o_4.sym} 36660 -2820 0 0 {name=X_63560_ }
C {devices/lab_pin.sym} 36600 -2690 0 0 {name=p36544 lab=_75546_/A }
C {devices/lab_pin.sym} 36600 -2650 0 0 {name=p36545 lab=_75539_/X }
C {devices/lab_pin.sym} 36600 -2610 0 0 {name=p36546 lab=_75546_/C }
C {devices/lab_pin.sym} 36720 -2650 0 1 {name=p36547 lab=_75546_/Y }
C {sky130_stdcells/nand3_4.sym} 36660 -2650 0 0 {name=X_75546_ }
C {devices/lab_pin.sym} 36620 -2510 0 0 {name=p36548 lab=_41938_/A }
C {devices/lab_pin.sym} 36700 -2510 0 1 {name=p36549 lab=_41938_/Y }
C {sky130_stdcells/inv_2.sym} 36660 -2510 0 0 {name=X_41938_ }
C {devices/lab_pin.sym} 36600 -2410 0 0 {name=p36550 lab=_60711_/X }
C {devices/lab_pin.sym} 36600 -2370 0 0 {name=p36551 lab=_60660_/X }
C {devices/lab_pin.sym} 36600 -2330 0 0 {name=p36552 lab=_60697_/B }
C {devices/lab_pin.sym} 36720 -2370 0 1 {name=p36553 lab=_60772_/Y }
C {sky130_stdcells/nand3_4.sym} 36660 -2370 0 0 {name=X_60772_ }
C {devices/lab_pin.sym} 36580 -2250 0 0 {name=p36554 lab=_73096_/B }
C {devices/lab_pin.sym} 36580 -2210 0 0 {name=p36555 lab=_48478_/X }
C {devices/lab_pin.sym} 36580 -2170 0 0 {name=p36556 lab=_48493_/Y }
C {devices/lab_pin.sym} 36740 -2210 0 1 {name=p36557 lab=_48494_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -2210 0 0 {name=X_48494_ }
C {devices/lab_pin.sym} 36620 -2070 0 0 {name=p36558 lab=_73638_/A }
C {devices/lab_pin.sym} 36700 -2070 0 1 {name=p36559 lab=_72758_/X }
C {sky130_stdcells/buf_2.sym} 36660 -2070 0 0 {name=X_72758_ }
C {devices/lab_pin.sym} 36620 -1950 0 0 {name=p36560 lab=clkbuf_9_247_0_CLK/X }
C {devices/lab_pin.sym} 36700 -1950 0 1 {name=p36561 lab=_84815_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 36660 -1950 0 0 {name=Xclkbuf_10_494_0_CLK }
C {devices/lab_pin.sym} 36620 -1830 0 0 {name=p36562 lab=_62214_/A }
C {devices/lab_pin.sym} 36700 -1830 0 1 {name=p36563 lab=_62511_/X }
C {sky130_stdcells/buf_2.sym} 36660 -1830 0 0 {name=X_62511_ }
C {devices/lab_pin.sym} 36580 -1730 0 0 {name=p36564 lab=_86634_/Q }
C {devices/lab_pin.sym} 36580 -1690 0 0 {name=p36565 lab=_47429_/X }
C {devices/lab_pin.sym} 36580 -1650 0 0 {name=p36566 lab=_47444_/Y }
C {devices/lab_pin.sym} 36740 -1690 0 1 {name=p36567 lab=_47445_/Y }
C {sky130_stdcells/o21ai_4.sym} 36660 -1690 0 0 {name=X_47445_ }
C {devices/lab_pin.sym} 36580 -1570 0 0 {name=p36568 lab=_71691_/Y }
C {devices/lab_pin.sym} 36580 -1530 0 0 {name=p36569 lab=_83402_/Q }
C {devices/lab_pin.sym} 36580 -1490 0 0 {name=p36570 lab=_71708_/Y }
C {devices/lab_pin.sym} 36740 -1530 0 1 {name=p36571 lab=_83402_/D }
C {sky130_stdcells/a21o_4.sym} 36660 -1530 0 0 {name=X_71709_ }
C {devices/lab_pin.sym} 36600 -1400 0 0 {name=p36572 lab=_78265_/A }
C {devices/lab_pin.sym} 36600 -1360 0 0 {name=p36573 lab=_82467_/Q }
C {devices/lab_pin.sym} 36720 -1380 0 1 {name=p36574 lab=_78265_/Y }
C {sky130_stdcells/nand2_4.sym} 36660 -1380 0 0 {name=X_78265_ }
C {devices/lab_pin.sym} 36620 -1250 0 0 {name=p36575 lab=_44657_/A }
C {devices/lab_pin.sym} 36700 -1250 0 1 {name=p36576 lab=_44657_/Y }
C {sky130_stdcells/inv_2.sym} 36660 -1250 0 0 {name=X_44657_ }
C {devices/lab_pin.sym} 36600 -1160 0 0 {name=p36577 lab=_59399_/A }
C {devices/lab_pin.sym} 36600 -1120 0 0 {name=p36578 lab=_63491_/B }
C {devices/lab_pin.sym} 36600 -1080 0 0 {name=p36579 lab=_63465_/C }
C {devices/lab_pin.sym} 36600 -1040 0 0 {name=p36580 lab=_63491_/D }
C {devices/lab_pin.sym} 36720 -1100 0 1 {name=p36581 lab=_63491_/Y }
C {sky130_stdcells/nand4_4.sym} 36660 -1100 0 0 {name=X_63491_ }
C {devices/lab_pin.sym} 36600 -970 0 0 {name=p36582 lab=_75477_/A }
C {devices/lab_pin.sym} 36600 -930 0 0 {name=p36583 lab=_75477_/B }
C {devices/lab_pin.sym} 36600 -890 0 0 {name=p36584 lab=_75477_/C }
C {devices/lab_pin.sym} 36720 -930 0 1 {name=p36585 lab=_75477_/X }
C {sky130_stdcells/or3_4.sym} 36660 -930 0 0 {name=X_75477_ }
C {devices/lab_pin.sym} 36600 -810 0 0 {name=p36586 lab=_41869_/A }
C {devices/lab_pin.sym} 36600 -770 0 0 {name=p36587 lab=_41869_/B }
C {devices/lab_pin.sym} 36600 -730 0 0 {name=p36588 lab=_41869_/C }
C {devices/lab_pin.sym} 36720 -770 0 1 {name=p36589 lab=_41869_/Y }
C {sky130_stdcells/nor3_4.sym} 36660 -770 0 0 {name=X_41869_ }
C {devices/lab_pin.sym} 37520 -42170 0 0 {name=p36590 lab=_72697_/A }
C {devices/lab_pin.sym} 37520 -42130 0 0 {name=p36591 lab=_72697_/B }
C {devices/lab_pin.sym} 37520 -42090 0 0 {name=p36592 lab=_55405_/X }
C {devices/lab_pin.sym} 37640 -42130 0 1 {name=p36593 lab=_72689_/Y }
C {sky130_stdcells/nand3_4.sym} 37580 -42130 0 0 {name=X_72689_ }
C {sky130_stdcells/decap_3.sym} 37580 -41960 0 0 {name=XPHY_2 }
C {devices/lab_pin.sym} 37540 -41810 0 0 {name=p36594 lab=_64772_/A }
C {devices/lab_pin.sym} 37620 -41810 0 1 {name=p36595 lab=_65230_/X }
C {sky130_stdcells/buf_2.sym} 37580 -41810 0 0 {name=X_65230_ }
C {devices/lab_pin.sym} 37520 -41700 0 0 {name=p36596 lab=_77217_/A }
C {devices/lab_pin.sym} 37520 -41660 0 0 {name=p36597 lab=_77217_/B }
C {devices/lab_pin.sym} 37640 -41680 0 1 {name=p36598 lab=_77216_/Y }
C {sky130_stdcells/nor2_4.sym} 37580 -41680 0 0 {name=X_77216_ }
C {devices/lab_pin.sym} 37500 -41580 0 0 {name=p36599 lab=_40590_/X }
C {devices/lab_pin.sym} 37500 -41540 0 0 {name=p36600 lab=_43604_/X }
C {devices/lab_pin.sym} 37500 -41500 0 0 {name=p36601 lab=_87344_/Q }
C {devices/lab_pin.sym} 37500 -41460 0 0 {name=p36602 lab=_43607_/X }
C {devices/lab_pin.sym} 37660 -41520 0 1 {name=p36603 lab=_87344_/D }
C {sky130_stdcells/a2bb2o_4.sym} 37580 -41520 0 0 {name=X_43608_ }
C {devices/lab_pin.sym} 37520 -41390 0 0 {name=p36604 lab=_62411_/X }
C {devices/lab_pin.sym} 37520 -41350 0 0 {name=p36605 lab=_62412_/X }
C {devices/lab_pin.sym} 37520 -41310 0 0 {name=p36606 lab=_62442_/C }
C {devices/lab_pin.sym} 37640 -41350 0 1 {name=p36607 lab=_62442_/Y }
C {sky130_stdcells/nor3_4.sym} 37580 -41350 0 0 {name=X_62442_ }
C {devices/lab_pin.sym} 37520 -41220 0 0 {name=p36608 lab=_74413_/X }
C {devices/lab_pin.sym} 37520 -41180 0 0 {name=p36609 lab=_74428_/B }
C {devices/lab_pin.sym} 37640 -41200 0 1 {name=p36610 lab=_74428_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -41200 0 0 {name=X_74428_ }
C {devices/lab_pin.sym} 37540 -41070 0 0 {name=p36611 lab=_46902_/A }
C {devices/lab_pin.sym} 37620 -41070 0 1 {name=p36612 lab=_47565_/A }
C {sky130_stdcells/buf_2.sym} 37580 -41070 0 0 {name=X_47376_ }
C {devices/lab_pin.sym} 37520 -40960 0 0 {name=p36613 lab=_78204_/A }
C {devices/lab_pin.sym} 37520 -40920 0 0 {name=p36614 lab=_78205_/A }
C {devices/lab_pin.sym} 37640 -40940 0 1 {name=p36615 lab=_78197_/B }
C {sky130_stdcells/xor2_4.sym} 37580 -40940 0 0 {name=X_78196_ }
C {devices/lab_pin.sym} 37540 -40810 0 0 {name=p36616 lab=_44679_/A }
C {devices/lab_pin.sym} 37620 -40810 0 1 {name=p36617 lab=_44588_/X }
C {sky130_stdcells/buf_2.sym} 37580 -40810 0 0 {name=X_44588_ }
C {devices/lab_pin.sym} 37540 -40690 0 0 {name=p36618 lab=_49115_/A }
C {devices/lab_pin.sym} 37620 -40690 0 1 {name=p36619 lab=_72072_/B }
C {sky130_stdcells/inv_2.sym} 37580 -40690 0 0 {name=X_49115_ }
C {devices/lab_pin.sym} 37500 -40590 0 0 {name=p36620 lab=_86747_/Q }
C {devices/lab_pin.sym} 37500 -40550 0 0 {name=p36621 lab=_46279_/X }
C {devices/lab_pin.sym} 37500 -40510 0 0 {name=p36622 lab=_46326_/Y }
C {devices/lab_pin.sym} 37660 -40550 0 1 {name=p36623 lab=_46327_/Y }
C {sky130_stdcells/o21ai_4.sym} 37580 -40550 0 0 {name=X_46327_ }
C {devices/lab_pin.sym} 37540 -40410 0 0 {name=p36624 lab=_64807_/A }
C {devices/lab_pin.sym} 37620 -40410 0 1 {name=p36625 lab=_65161_/X }
C {sky130_stdcells/buf_2.sym} 37580 -40410 0 0 {name=X_65161_ }
C {devices/lab_pin.sym} 37520 -40300 0 0 {name=p36626 lab=_82102_/Q }
C {devices/lab_pin.sym} 37520 -40260 0 0 {name=p36627 lab=_77147_/B }
C {devices/lab_pin.sym} 37640 -40280 0 1 {name=p36628 lab=_77147_/X }
C {sky130_stdcells/xor2_4.sym} 37580 -40280 0 0 {name=X_77147_ }
C {devices/lab_pin.sym} 37540 -40150 0 0 {name=p36629 lab=_43538_/Y }
C {devices/lab_pin.sym} 37620 -40150 0 1 {name=p36630 lab=_87369_/D }
C {sky130_stdcells/inv_2.sym} 37580 -40150 0 0 {name=X_43539_ }
C {devices/lab_pin.sym} 37520 -40060 0 0 {name=p36631 lab=_61468_/A }
C {devices/lab_pin.sym} 37520 -40020 0 0 {name=p36632 lab=_62332_/B }
C {devices/lab_pin.sym} 37520 -39980 0 0 {name=p36633 lab=_62386_/C }
C {devices/lab_pin.sym} 37520 -39940 0 0 {name=p36634 lab=_62332_/D }
C {devices/lab_pin.sym} 37640 -40000 0 1 {name=p36635 lab=_62378_/B }
C {sky130_stdcells/nand4_4.sym} 37580 -40000 0 0 {name=X_62373_ }
C {devices/lab_pin.sym} 37520 -39870 0 0 {name=p36636 lab=_45954_/X }
C {devices/lab_pin.sym} 37520 -39830 0 0 {name=p36637 lab=_58334_/A }
C {devices/lab_pin.sym} 37520 -39790 0 0 {name=p36638 lab=_56167_/B }
C {devices/lab_pin.sym} 37640 -39830 0 1 {name=p36639 lab=_74359_/Y }
C {sky130_stdcells/nand3_4.sym} 37580 -39830 0 0 {name=X_74359_ }
C {devices/lab_pin.sym} 37500 -39720 0 0 {name=p36640 lab=_62557_/Y }
C {devices/lab_pin.sym} 37500 -39680 0 0 {name=p36641 lab=_60880_/X }
C {devices/lab_pin.sym} 37500 -39640 0 0 {name=p36642 lab=_84913_/Q }
C {devices/lab_pin.sym} 37500 -39600 0 0 {name=p36643 lab=_61028_/X }
C {devices/lab_pin.sym} 37660 -39660 0 1 {name=p36644 lab=_64112_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 37580 -39660 0 0 {name=X_64112_ }
C {devices/lab_pin.sym} 37520 -39520 0 0 {name=p36645 lab=_49007_/A }
C {devices/lab_pin.sym} 37520 -39480 0 0 {name=p36646 lab=_50133_/B }
C {devices/lab_pin.sym} 37640 -39500 0 1 {name=p36647 lab=_49046_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -39500 0 0 {name=X_49046_ }
C {devices/lab_pin.sym} 37540 -39370 0 0 {name=p36648 lab=_61323_/X }
C {devices/lab_pin.sym} 37620 -39370 0 1 {name=p36649 lab=_61324_/Y }
C {sky130_stdcells/inv_2.sym} 37580 -39370 0 0 {name=X_61324_ }
C {devices/lab_pin.sym} 37540 -39250 0 0 {name=p36650 lab=_46258_/A }
C {devices/lab_pin.sym} 37620 -39250 0 1 {name=p36651 lab=_46258_/X }
C {sky130_stdcells/buf_2.sym} 37580 -39250 0 0 {name=X_46258_ }
C {devices/lab_pin.sym} 37520 -39150 0 0 {name=p36652 lab=_65196_/A }
C {devices/lab_pin.sym} 37520 -39110 0 0 {name=p36653 lab=_65268_/B }
C {devices/lab_pin.sym} 37520 -39070 0 0 {name=p36654 lab=_84215_/Q }
C {devices/lab_pin.sym} 37640 -39110 0 1 {name=p36655 lab=_65092_/X }
C {sky130_stdcells/and3_4.sym} 37580 -39110 0 0 {name=X_65092_ }
C {devices/lab_pin.sym} 37520 -38980 0 0 {name=p36656 lab=_77066_/A }
C {devices/lab_pin.sym} 37520 -38940 0 0 {name=p36657 lab=_82284_/D }
C {devices/lab_pin.sym} 37640 -38960 0 1 {name=p36658 lab=_77078_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -38960 0 0 {name=X_77078_ }
C {devices/lab_pin.sym} 37540 -38830 0 0 {name=p36659 lab=_45284_/A }
C {devices/lab_pin.sym} 37620 -38830 0 1 {name=p36660 lab=_45209_/X }
C {sky130_stdcells/buf_2.sym} 37580 -38830 0 0 {name=X_45209_ }
C {devices/lab_pin.sym} 37520 -38720 0 0 {name=p36661 lab=_68759_/A }
C {devices/lab_pin.sym} 37520 -38680 0 0 {name=p36662 lab=_68920_/B }
C {devices/lab_pin.sym} 37640 -38700 0 1 {name=p36663 lab=_68920_/X }
C {sky130_stdcells/and2_4.sym} 37580 -38700 0 0 {name=X_68920_ }
C {devices/lab_pin.sym} 37540 -38570 0 0 {name=p36664 lab=_60871_/Y }
C {devices/lab_pin.sym} 37620 -38570 0 1 {name=p36665 lab=_64145_/B }
C {sky130_stdcells/buf_2.sym} 37580 -38570 0 0 {name=X_64043_ }
C {devices/lab_pin.sym} 37500 -38470 0 0 {name=p36666 lab=_76023_/A }
C {devices/lab_pin.sym} 37500 -38430 0 0 {name=p36667 lab=_76023_/B }
C {devices/lab_pin.sym} 37500 -38390 0 0 {name=p36668 lab=_76024_/A }
C {devices/lab_pin.sym} 37660 -38430 0 1 {name=p36669 lab=_76029_/Y }
C {sky130_stdcells/a21boi_4.sym} 37580 -38430 0 0 {name=X_76029_ }
C {devices/lab_pin.sym} 37500 -38320 0 0 {name=p36670 lab=_75899_/A }
C {devices/lab_pin.sym} 37500 -38280 0 0 {name=p36671 lab=_61252_/X }
C {devices/lab_pin.sym} 37500 -38240 0 0 {name=p36672 lab=_61208_/Y }
C {devices/lab_pin.sym} 37500 -38200 0 0 {name=p36673 lab=_61254_/Y }
C {devices/lab_pin.sym} 37660 -38260 0 1 {name=p36674 lab=_61255_/X }
C {sky130_stdcells/o22a_4.sym} 37580 -38260 0 0 {name=X_61255_ }
C {devices/lab_pin.sym} 37520 -38130 0 0 {name=p36675 lab=_46195_/A }
C {devices/lab_pin.sym} 37520 -38090 0 0 {name=p36676 lab=_46133_/C }
C {devices/lab_pin.sym} 37520 -38050 0 0 {name=p36677 lab=_46217_/B }
C {devices/lab_pin.sym} 37640 -38090 0 1 {name=p36678 lab=_46189_/Y }
C {sky130_stdcells/nand3_4.sym} 37580 -38090 0 0 {name=X_46189_ }
C {devices/lab_pin.sym} 37540 -37950 0 0 {name=p36679 lab=clkbuf_9_216_0_CLK/X }
C {devices/lab_pin.sym} 37620 -37950 0 1 {name=p36680 lab=_83526_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 37580 -37950 0 0 {name=Xclkbuf_10_432_0_CLK }
C {devices/lab_pin.sym} 37540 -37830 0 0 {name=p36681 lab=_60182_/A }
C {devices/lab_pin.sym} 37620 -37830 0 1 {name=p36682 lab=_61286_/A }
C {sky130_stdcells/buf_2.sym} 37580 -37830 0 0 {name=X_60206_ }
C {devices/lab_pin.sym} 37500 -37740 0 0 {name=p36683 lab=_87488_/Q }
C {devices/lab_pin.sym} 37500 -37700 0 0 {name=p36684 lab=_68757_/X }
C {devices/lab_pin.sym} 37500 -37660 0 0 {name=p36685 lab=_68731_/X }
C {devices/lab_pin.sym} 37500 -37620 0 0 {name=p36686 lab=_68850_/X }
C {devices/lab_pin.sym} 37660 -37680 0 1 {name=p36687 lab=_68851_/X }
C {sky130_stdcells/a211o_4.sym} 37580 -37680 0 0 {name=X_68851_ }
C {devices/lab_pin.sym} 37500 -37570 0 0 {name=p36688 lab=_60933_/X }
C {devices/lab_pin.sym} 37500 -37530 0 0 {name=p36689 lab=_61110_/Y }
C {devices/lab_pin.sym} 37500 -37490 0 0 {name=p36690 lab=_61294_/D }
C {devices/lab_pin.sym} 37500 -37450 0 0 {name=p36691 lab=_59662_/C }
C {devices/lab_pin.sym} 37500 -37420 0 0 {name=p36692 lab=_61185_/Y }
C {devices/lab_pin.sym} 37660 -37490 0 1 {name=p36693 lab=_84512_/D }
C {sky130_stdcells/a41oi_4.sym} 37580 -37490 0 0 {name=X_61186_ }
C {devices/lab_pin.sym} 37500 -37360 0 0 {name=p36694 lab=_86956_/Q }
C {devices/lab_pin.sym} 37500 -37320 0 0 {name=p36695 lab=_67706_/X }
C {devices/lab_pin.sym} 37500 -37280 0 0 {name=p36696 lab=_67755_/X }
C {devices/lab_pin.sym} 37500 -37240 0 0 {name=p36697 lab=_67801_/X }
C {devices/lab_pin.sym} 37660 -37300 0 1 {name=p36698 lab=_67802_/X }
C {sky130_stdcells/a211o_4.sym} 37580 -37300 0 0 {name=X_67802_ }
C {devices/lab_pin.sym} 37500 -37190 0 0 {name=p36699 lab=_60028_/Y }
C {devices/lab_pin.sym} 37500 -37150 0 0 {name=p36700 lab=_60102_/Y }
C {devices/lab_pin.sym} 37500 -37110 0 0 {name=p36701 lab=_60119_/Y }
C {devices/lab_pin.sym} 37500 -37070 0 0 {name=p36702 lab=_59988_/Y }
C {devices/lab_pin.sym} 37500 -37040 0 0 {name=p36703 lab=_60136_/Y }
C {devices/lab_pin.sym} 37660 -37110 0 1 {name=p36704 lab=_84655_/D }
C {sky130_stdcells/a41oi_4.sym} 37580 -37110 0 0 {name=X_60137_ }
C {devices/lab_pin.sym} 37500 -36970 0 0 {name=p36705 lab=_49946_/Y }
C {devices/lab_pin.sym} 37500 -36930 0 0 {name=p36706 lab=_49924_/X }
C {devices/lab_pin.sym} 37500 -36890 0 0 {name=p36707 lab=_49947_/X }
C {devices/lab_pin.sym} 37660 -36930 0 1 {name=p36708 lab=_49948_/Y }
C {sky130_stdcells/a21oi_4.sym} 37580 -36930 0 0 {name=X_49948_ }
C {devices/lab_pin.sym} 37500 -36820 0 0 {name=p36709 lab=_41941_/A }
C {devices/lab_pin.sym} 37500 -36780 0 0 {name=p36710 lab=_68757_/X }
C {devices/lab_pin.sym} 37500 -36740 0 0 {name=p36711 lab=_68555_/X }
C {devices/lab_pin.sym} 37500 -36700 0 0 {name=p36712 lab=_68781_/Y }
C {devices/lab_pin.sym} 37660 -36760 0 1 {name=p36713 lab=_68782_/X }
C {sky130_stdcells/a211o_4.sym} 37580 -36760 0 0 {name=X_68782_ }
C {devices/lab_pin.sym} 37520 -36620 0 0 {name=p36714 lab=_65878_/A }
C {devices/lab_pin.sym} 37520 -36580 0 0 {name=p36715 lab=_73711_/B }
C {devices/lab_pin.sym} 37640 -36600 0 1 {name=p36716 lab=_65994_/X }
C {sky130_stdcells/and2_4.sym} 37580 -36600 0 0 {name=X_65994_ }
C {devices/lab_pin.sym} 37500 -36500 0 0 {name=p36717 lab=_86959_/Q }
C {devices/lab_pin.sym} 37500 -36460 0 0 {name=p36718 lab=_67706_/X }
C {devices/lab_pin.sym} 37500 -36420 0 0 {name=p36719 lab=_67633_/X }
C {devices/lab_pin.sym} 37500 -36380 0 0 {name=p36720 lab=_67732_/X }
C {devices/lab_pin.sym} 37660 -36440 0 1 {name=p36721 lab=_67733_/X }
C {sky130_stdcells/a211o_4.sym} 37580 -36440 0 0 {name=X_67733_ }
C {devices/lab_pin.sym} 37520 -36300 0 0 {name=p36722 lab=_79712_/X }
C {devices/lab_pin.sym} 37520 -36260 0 0 {name=p36723 lab=_79719_/B }
C {devices/lab_pin.sym} 37640 -36280 0 1 {name=p36724 lab=_79719_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -36280 0 0 {name=X_79719_ }
C {devices/lab_pin.sym} 37540 -36150 0 0 {name=p36725 lab=_64667_/A }
C {devices/lab_pin.sym} 37620 -36150 0 1 {name=p36726 lab=_64946_/A }
C {sky130_stdcells/buf_2.sym} 37580 -36150 0 0 {name=X_64945_ }
C {devices/lab_pin.sym} 37500 -36070 0 0 {name=p36727 lab=_59951_/B }
C {devices/lab_pin.sym} 37500 -36030 0 0 {name=p36728 lab=_60061_/Y }
C {devices/lab_pin.sym} 37500 -35990 0 0 {name=p36729 lab=_60000_/A }
C {devices/lab_pin.sym} 37500 -35950 0 0 {name=p36730 lab=_60129_/B }
C {devices/lab_pin.sym} 37500 -35920 0 0 {name=p36731 lab=_60067_/Y }
C {devices/lab_pin.sym} 37660 -35990 0 1 {name=p36732 lab=_84667_/D }
C {sky130_stdcells/a41oi_4.sym} 37580 -35990 0 0 {name=X_60068_ }
C {devices/lab_pin.sym} 37540 -35830 0 0 {name=p36733 lab=clkbuf_9_223_0_CLK/X }
C {devices/lab_pin.sym} 37620 -35830 0 1 {name=p36734 lab=_85317_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 37580 -35830 0 0 {name=Xclkbuf_10_447_0_CLK }
C {devices/lab_pin.sym} 37540 -35710 0 0 {name=p36735 lab=_48897_/A }
C {devices/lab_pin.sym} 37620 -35710 0 1 {name=p36736 lab=_49906_/A }
C {sky130_stdcells/buf_2.sym} 37580 -35710 0 0 {name=X_49879_ }
C {devices/lab_pin.sym} 37490 -35590 0 0 {name=p36737 lab=_80991_/CLK }
C {devices/lab_pin.sym} 37490 -35570 0 0 {name=p36738 lab=_75850_/Y }
C {devices/lab_pin.sym} 37670 -35590 0 1 {name=p36739 lab=_80991_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -35580 0 0 {name=X_80991_ }
C {devices/lab_pin.sym} 37500 -35470 0 0 {name=p36740 lab=_51908_/Y }
C {devices/lab_pin.sym} 37500 -35430 0 0 {name=p36741 lab=_51904_/X }
C {devices/lab_pin.sym} 37500 -35390 0 0 {name=p36742 lab=_51909_/X }
C {devices/lab_pin.sym} 37660 -35430 0 1 {name=p36743 lab=_51910_/Y }
C {sky130_stdcells/a21oi_4.sym} 37580 -35430 0 0 {name=X_51910_ }
C {devices/lab_pin.sym} 37490 -35290 0 0 {name=p36744 lab=_84111_/CLK }
C {devices/lab_pin.sym} 37490 -35270 0 0 {name=p36745 lab=_84114_/Q }
C {devices/lab_pin.sym} 37670 -35290 0 1 {name=p36746 lab=_82730_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -35280 0 0 {name=X_82730_ }
C {devices/lab_pin.sym} 37540 -35150 0 0 {name=p36747 lab=_66898_/X }
C {devices/lab_pin.sym} 37620 -35150 0 1 {name=p36748 lab=_67664_/X }
C {sky130_stdcells/buf_2.sym} 37580 -35150 0 0 {name=X_67664_ }
C {devices/lab_pin.sym} 37500 -35050 0 0 {name=p36749 lab=_85735_/Q }
C {devices/lab_pin.sym} 37500 -35010 0 0 {name=p36750 lab=_52874_/X }
C {devices/lab_pin.sym} 37500 -34970 0 0 {name=p36751 lab=_52889_/Y }
C {devices/lab_pin.sym} 37660 -35010 0 1 {name=p36752 lab=_52890_/Y }
C {sky130_stdcells/o21ai_4.sym} 37580 -35010 0 0 {name=X_52890_ }
C {devices/lab_pin.sym} 37500 -34890 0 0 {name=p36753 lab=_64873_/X }
C {devices/lab_pin.sym} 37500 -34850 0 0 {name=p36754 lab=_64875_/X }
C {devices/lab_pin.sym} 37500 -34810 0 0 {name=p36755 lab=_64807_/X }
C {devices/lab_pin.sym} 37660 -34850 0 1 {name=p36756 lab=_64876_/X }
C {sky130_stdcells/a21o_4.sym} 37580 -34850 0 0 {name=X_64876_ }
C {devices/lab_pin.sym} 37520 -34720 0 0 {name=p36757 lab=_69400_/X }
C {devices/lab_pin.sym} 37520 -34680 0 0 {name=p36758 lab=_69402_/X }
C {devices/lab_pin.sym} 37640 -34700 0 1 {name=p36759 lab=_69403_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -34700 0 0 {name=X_69403_ }
C {devices/lab_pin.sym} 37540 -34570 0 0 {name=p36760 lab=_66534_/A }
C {devices/lab_pin.sym} 37620 -34570 0 1 {name=p36761 lab=_66689_/A }
C {sky130_stdcells/buf_2.sym} 37580 -34570 0 0 {name=X_66615_ }
C {devices/lab_pin.sym} 37500 -34470 0 0 {name=p36762 lab=_85936_/Q }
C {devices/lab_pin.sym} 37500 -34430 0 0 {name=p36763 lab=_51817_/X }
C {devices/lab_pin.sym} 37500 -34390 0 0 {name=p36764 lab=_51840_/Y }
C {devices/lab_pin.sym} 37660 -34430 0 1 {name=p36765 lab=_51841_/Y }
C {sky130_stdcells/o21ai_4.sym} 37580 -34430 0 0 {name=X_51841_ }
C {devices/lab_pin.sym} 37540 -34290 0 0 {name=p36766 lab=_63761_/A }
C {devices/lab_pin.sym} 37620 -34290 0 1 {name=p36767 lab=_63877_/D }
C {sky130_stdcells/buf_2.sym} 37580 -34290 0 0 {name=X_63827_ }
C {devices/lab_pin.sym} 37490 -34170 0 0 {name=p36768 lab=_82879_/CLK }
C {devices/lab_pin.sym} 37490 -34150 0 0 {name=p36769 lab=_82661_/D }
C {devices/lab_pin.sym} 37670 -34170 0 1 {name=p36770 lab=_82661_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -34160 0 0 {name=X_82661_ }
C {devices/lab_pin.sym} 37540 -34030 0 0 {name=p36771 lab=_67359_/X }
C {devices/lab_pin.sym} 37620 -34030 0 1 {name=p36772 lab=_67595_/X }
C {sky130_stdcells/buf_2.sym} 37580 -34030 0 0 {name=X_67595_ }
C {devices/lab_pin.sym} 37490 -33910 0 0 {name=p36773 lab=_84400_/CLK }
C {devices/lab_pin.sym} 37490 -33890 0 0 {name=p36774 lab=_84400_/D }
C {devices/lab_pin.sym} 37670 -33910 0 1 {name=p36775 lab=_84400_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -33900 0 0 {name=X_84400_ }
C {devices/lab_pin.sym} 37490 -33770 0 0 {name=p36776 lab=_81259_/CLK }
C {devices/lab_pin.sym} 37490 -33750 0 0 {name=p36777 lab=_76297_/B }
C {devices/lab_pin.sym} 37670 -33770 0 1 {name=p36778 lab=_81612_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -33760 0 0 {name=X_81612_ }
C {devices/lab_pin.sym} 37500 -33650 0 0 {name=p36779 lab=_69331_/X }
C {devices/lab_pin.sym} 37500 -33610 0 0 {name=p36780 lab=_69333_/X }
C {devices/lab_pin.sym} 37500 -33570 0 0 {name=p36781 lab=_69138_/X }
C {devices/lab_pin.sym} 37660 -33610 0 1 {name=p36782 lab=_69334_/X }
C {sky130_stdcells/a21o_4.sym} 37580 -33610 0 0 {name=X_69334_ }
C {devices/lab_pin.sym} 37500 -33490 0 0 {name=p36783 lab=_54556_/Y }
C {devices/lab_pin.sym} 37500 -33450 0 0 {name=p36784 lab=_54558_/X }
C {devices/lab_pin.sym} 37500 -33410 0 0 {name=p36785 lab=_54559_/X }
C {devices/lab_pin.sym} 37660 -33450 0 1 {name=p36786 lab=_54560_/Y }
C {sky130_stdcells/a21oi_4.sym} 37580 -33450 0 0 {name=X_54560_ }
C {devices/lab_pin.sym} 37540 -33310 0 0 {name=p36787 lab=_57776_/A }
C {devices/lab_pin.sym} 37620 -33310 0 1 {name=p36788 lab=_66547_/A }
C {sky130_stdcells/buf_2.sym} 37580 -33310 0 0 {name=X_66546_ }
C {devices/lab_pin.sym} 37490 -33190 0 0 {name=p36789 lab=_85379_/CLK }
C {devices/lab_pin.sym} 37490 -33170 0 0 {name=p36790 lab=_85380_/D }
C {devices/lab_pin.sym} 37670 -33190 0 1 {name=p36791 lab=_85380_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -33180 0 0 {name=X_85380_ }
C {devices/lab_pin.sym} 37520 -33080 0 0 {name=p36792 lab=_51768_/A }
C {devices/lab_pin.sym} 37520 -33040 0 0 {name=p36793 lab=_51782_/B }
C {devices/lab_pin.sym} 37520 -33000 0 0 {name=p36794 lab=_51755_/X }
C {devices/lab_pin.sym} 37520 -32960 0 0 {name=p36795 lab=_51772_/D }
C {devices/lab_pin.sym} 37640 -33020 0 1 {name=p36796 lab=_51772_/X }
C {sky130_stdcells/and4_4.sym} 37580 -33020 0 0 {name=X_51772_ }
C {devices/lab_pin.sym} 37520 -32900 0 0 {name=p36797 lab=_58221_/X }
C {devices/lab_pin.sym} 37520 -32860 0 0 {name=p36798 lab=_64189_/C }
C {devices/lab_pin.sym} 37520 -32820 0 0 {name=p36799 lab=_60908_/A }
C {devices/lab_pin.sym} 37520 -32780 0 0 {name=p36800 lab=_63731_/D }
C {devices/lab_pin.sym} 37640 -32840 0 1 {name=p36801 lab=_63758_/Y }
C {sky130_stdcells/nand4_4.sym} 37580 -32840 0 0 {name=X_63758_ }
C {devices/lab_pin.sym} 37490 -32690 0 0 {name=p36802 lab=_82671_/CLK }
C {devices/lab_pin.sym} 37490 -32670 0 0 {name=p36803 lab=_82624_/Q }
C {devices/lab_pin.sym} 37670 -32690 0 1 {name=p36804 lab=_78301_/A }
C {sky130_stdcells/dfxtp_4.sym} 37580 -32680 0 0 {name=X_82592_ }
C {devices/lab_pin.sym} 37540 -32550 0 0 {name=p36805 lab=_53511_/A }
C {devices/lab_pin.sym} 37620 -32550 0 1 {name=p36806 lab=_53697_/B }
C {sky130_stdcells/buf_2.sym} 37580 -32550 0 0 {name=X_53511_ }
C {devices/lab_pin.sym} 37490 -32430 0 0 {name=p36807 lab=_84187_/CLK }
C {devices/lab_pin.sym} 37490 -32410 0 0 {name=p36808 lab=_63346_/Y }
C {devices/lab_pin.sym} 37670 -32430 0 1 {name=p36809 lab=_79169_/B }
C {sky130_stdcells/dfxtp_4.sym} 37580 -32420 0 0 {name=X_84331_ }
C {devices/lab_pin.sym} 37540 -32290 0 0 {name=p36810 lab=_50460_/A }
C {devices/lab_pin.sym} 37620 -32290 0 1 {name=p36811 lab=_50724_/A }
C {sky130_stdcells/buf_2.sym} 37580 -32290 0 0 {name=X_50723_ }
C {devices/lab_pin.sym} 37490 -32170 0 0 {name=p36812 lab=_81575_/CLK }
C {devices/lab_pin.sym} 37490 -32150 0 0 {name=p36813 lab=_81543_/D }
C {devices/lab_pin.sym} 37670 -32170 0 1 {name=p36814 lab=_76522_/B }
C {sky130_stdcells/dfxtp_4.sym} 37580 -32160 0 0 {name=X_81543_ }
C {devices/lab_pin.sym} 37540 -32030 0 0 {name=p36815 lab=_62655_/Y }
C {devices/lab_pin.sym} 37620 -32030 0 1 {name=p36816 lab=_62979_/A }
C {sky130_stdcells/buf_2.sym} 37580 -32030 0 0 {name=X_62709_ }
C {devices/lab_pin.sym} 37520 -31920 0 0 {name=p36817 lab=_69253_/A }
C {devices/lab_pin.sym} 37520 -31880 0 0 {name=p36818 lab=_69265_/B }
C {devices/lab_pin.sym} 37640 -31900 0 1 {name=p36819 lab=_69265_/X }
C {sky130_stdcells/and2_4.sym} 37580 -31900 0 0 {name=X_69265_ }
C {devices/lab_pin.sym} 37520 -31780 0 0 {name=p36820 lab=_54486_/X }
C {devices/lab_pin.sym} 37520 -31740 0 0 {name=p36821 lab=_47006_/Y }
C {devices/lab_pin.sym} 37640 -31760 0 1 {name=p36822 lab=_54491_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -31760 0 0 {name=X_54491_ }
C {devices/lab_pin.sym} 37500 -31650 0 0 {name=p36823 lab=_66475_/X }
C {devices/lab_pin.sym} 37500 -31610 0 0 {name=p36824 lab=_66228_/Y }
C {devices/lab_pin.sym} 37500 -31570 0 0 {name=p36825 lab=_66476_/Y }
C {devices/lab_pin.sym} 37660 -31610 0 1 {name=p36826 lab=_66477_/Y }
C {sky130_stdcells/o21ai_4.sym} 37580 -31610 0 0 {name=X_66477_ }
C {devices/lab_pin.sym} 37540 -31470 0 0 {name=p36827 lab=_63644_/A }
C {devices/lab_pin.sym} 37620 -31470 0 1 {name=p36828 lab=_63701_/A }
C {sky130_stdcells/buf_2.sym} 37580 -31470 0 0 {name=X_63689_ }
C {devices/lab_pin.sym} 37500 -31370 0 0 {name=p36829 lab=_56079_/X }
C {devices/lab_pin.sym} 37500 -31330 0 0 {name=p36830 lab=_56225_/X }
C {devices/lab_pin.sym} 37500 -31290 0 0 {name=p36831 lab=_56229_/Y }
C {devices/lab_pin.sym} 37660 -31330 0 1 {name=p36832 lab=_56230_/Y }
C {sky130_stdcells/o21ai_4.sym} 37580 -31330 0 0 {name=X_56230_ }
C {devices/lab_pin.sym} 37540 -31190 0 0 {name=p36833 lab=_68106_/A }
C {devices/lab_pin.sym} 37620 -31190 0 1 {name=p36834 lab=_68216_/X }
C {sky130_stdcells/buf_2.sym} 37580 -31190 0 0 {name=X_68216_ }
C {devices/lab_pin.sym} 37490 -31070 0 0 {name=p36835 lab=_88324_/CLK }
C {devices/lab_pin.sym} 37490 -31050 0 0 {name=p36836 lab=_44574_/Y }
C {devices/lab_pin.sym} 37670 -31070 0 1 {name=p36837 lab=_44573_/A }
C {sky130_stdcells/dfxtp_4.sym} 37580 -31060 0 0 {name=X_87050_ }
C {devices/lab_pin.sym} 37540 -30930 0 0 {name=p36838 lab=_53817_/A }
C {devices/lab_pin.sym} 37620 -30930 0 1 {name=p36839 lab=_54067_/A }
C {sky130_stdcells/buf_2.sym} 37580 -30930 0 0 {name=X_53442_ }
C {devices/lab_pin.sym} 37540 -30810 0 0 {name=p36840 lab=_64797_/A }
C {devices/lab_pin.sym} 37620 -30810 0 1 {name=p36841 lab=_65428_/X }
C {sky130_stdcells/buf_2.sym} 37580 -30810 0 0 {name=X_65428_ }
C {devices/lab_pin.sym} 37490 -30690 0 0 {name=p36842 lab=_83402_/CLK }
C {devices/lab_pin.sym} 37490 -30670 0 0 {name=p36843 lab=_64254_/X }
C {devices/lab_pin.sym} 37670 -30690 0 1 {name=p36844 lab=_79846_/B }
C {sky130_stdcells/dfxtp_4.sym} 37580 -30680 0 0 {name=X_84262_ }
C {devices/lab_pin.sym} 37540 -30550 0 0 {name=p36845 lab=_50506_/A }
C {devices/lab_pin.sym} 37620 -30550 0 1 {name=p36846 lab=_50654_/X }
C {sky130_stdcells/buf_2.sym} 37580 -30550 0 0 {name=X_50654_ }
C {devices/lab_pin.sym} 37490 -30430 0 0 {name=p36847 lab=_81352_/CLK }
C {devices/lab_pin.sym} 37490 -30410 0 0 {name=p36848 lab=_81474_/D }
C {devices/lab_pin.sym} 37670 -30430 0 1 {name=p36849 lab=_81474_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -30420 0 0 {name=X_81474_ }
C {devices/lab_pin.sym} 37520 -30300 0 0 {name=p36850 lab=_69027_/A }
C {devices/lab_pin.sym} 37520 -30260 0 0 {name=p36851 lab=_88303_/Q }
C {devices/lab_pin.sym} 37640 -30280 0 1 {name=p36852 lab=_69196_/X }
C {sky130_stdcells/and2_4.sym} 37580 -30280 0 0 {name=X_69196_ }
C {devices/lab_pin.sym} 37490 -30150 0 0 {name=p36853 lab=_85712_/CLK }
C {devices/lab_pin.sym} 37490 -30130 0 0 {name=p36854 lab=_86001_/D }
C {devices/lab_pin.sym} 37670 -30150 0 1 {name=p36855 lab=_86001_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -30140 0 0 {name=X_86001_ }
C {devices/lab_pin.sym} 37490 -30010 0 0 {name=p36856 lab=_83216_/CLK }
C {devices/lab_pin.sym} 37490 -29990 0 0 {name=p36857 lab=_72622_/X }
C {devices/lab_pin.sym} 37670 -30010 0 1 {name=p36858 lab=_79198_/B }
C {sky130_stdcells/dfxtp_4.sym} 37580 -30000 0 0 {name=X_83213_ }
C {devices/lab_pin.sym} 37520 -29880 0 0 {name=p36859 lab=_80425_/A }
C {devices/lab_pin.sym} 37520 -29840 0 0 {name=p36860 lab=_80425_/B }
C {devices/lab_pin.sym} 37640 -29860 0 1 {name=p36861 lab=_80425_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -29860 0 0 {name=X_80425_ }
C {devices/lab_pin.sym} 37500 -29750 0 0 {name=p36862 lab=_82067_/D }
C {devices/lab_pin.sym} 37500 -29710 0 0 {name=p36863 lab=_68140_/X }
C {devices/lab_pin.sym} 37500 -29670 0 0 {name=p36864 lab=_68146_/X }
C {devices/lab_pin.sym} 37660 -29710 0 1 {name=p36865 lab=_68147_/X }
C {sky130_stdcells/a21bo_4.sym} 37580 -29710 0 0 {name=X_68147_ }
C {devices/lab_pin.sym} 37500 -29590 0 0 {name=p36866 lab=_56142_/X }
C {devices/lab_pin.sym} 37500 -29550 0 0 {name=p36867 lab=_56159_/X }
C {devices/lab_pin.sym} 37500 -29510 0 0 {name=p36868 lab=_56160_/Y }
C {devices/lab_pin.sym} 37660 -29550 0 1 {name=p36869 lab=_56161_/Y }
C {sky130_stdcells/o21ai_4.sym} 37580 -29550 0 0 {name=X_56161_ }
C {devices/lab_pin.sym} 37520 -29420 0 0 {name=p36870 lab=_53353_/A }
C {devices/lab_pin.sym} 37520 -29380 0 0 {name=p36871 lab=_53373_/B }
C {devices/lab_pin.sym} 37640 -29400 0 1 {name=p36872 lab=_53373_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -29400 0 0 {name=X_53373_ }
C {devices/lab_pin.sym} 37520 -29280 0 0 {name=p36873 lab=_65359_/A }
C {devices/lab_pin.sym} 37520 -29240 0 0 {name=p36874 lab=_65358_/X }
C {devices/lab_pin.sym} 37640 -29260 0 1 {name=p36875 lab=_65359_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -29260 0 0 {name=X_65359_ }
C {devices/lab_pin.sym} 37490 -29130 0 0 {name=p36876 lab=_84192_/CLK }
C {devices/lab_pin.sym} 37490 -29110 0 0 {name=p36877 lab=_84193_/D }
C {devices/lab_pin.sym} 37670 -29130 0 1 {name=p36878 lab=_65559_/C }
C {sky130_stdcells/dfxtp_4.sym} 37580 -29120 0 0 {name=X_84193_ }
C {devices/lab_pin.sym} 37500 -29010 0 0 {name=p36879 lab=_50583_/Y }
C {devices/lab_pin.sym} 37500 -28970 0 0 {name=p36880 lab=_50551_/X }
C {devices/lab_pin.sym} 37500 -28930 0 0 {name=p36881 lab=_50584_/X }
C {devices/lab_pin.sym} 37660 -28970 0 1 {name=p36882 lab=_50585_/Y }
C {sky130_stdcells/a21oi_4.sym} 37580 -28970 0 0 {name=X_50585_ }
C {devices/lab_pin.sym} 37520 -28860 0 0 {name=p36883 lab=_55112_/A }
C {devices/lab_pin.sym} 37520 -28820 0 0 {name=p36884 lab=_47877_/A }
C {devices/lab_pin.sym} 37520 -28780 0 0 {name=p36885 lab=_55120_/C }
C {devices/lab_pin.sym} 37520 -28740 0 0 {name=p36886 lab=_47803_/A }
C {devices/lab_pin.sym} 37640 -28800 0 1 {name=p36887 lab=_55112_/X }
C {sky130_stdcells/and4_4.sym} 37580 -28800 0 0 {name=X_55112_ }
C {devices/lab_pin.sym} 37540 -28650 0 0 {name=p36888 lab=_52324_/A }
C {devices/lab_pin.sym} 37620 -28650 0 1 {name=p36889 lab=_52324_/X }
C {sky130_stdcells/buf_2.sym} 37580 -28650 0 0 {name=X_52324_ }
C {devices/lab_pin.sym} 37490 -28530 0 0 {name=p36890 lab=_83544_/CLK }
C {devices/lab_pin.sym} 37490 -28510 0 0 {name=p36891 lab=_73594_/X }
C {devices/lab_pin.sym} 37670 -28530 0 1 {name=p36892 lab=_83144_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -28520 0 0 {name=X_83144_ }
C {devices/lab_pin.sym} 37540 -28390 0 0 {name=p36893 lab=clkbuf_9_506_0_CLK/A }
C {devices/lab_pin.sym} 37620 -28390 0 1 {name=p36894 lab=clkbuf_9_506_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 37580 -28390 0 0 {name=Xclkbuf_9_506_0_CLK }
C {devices/lab_pin.sym} 37500 -28300 0 0 {name=p36895 lab=_56088_/X }
C {devices/lab_pin.sym} 37500 -28260 0 0 {name=p36896 lab=_56091_/X }
C {devices/lab_pin.sym} 37500 -28220 0 0 {name=p36897 lab=_55830_/X }
C {devices/lab_pin.sym} 37500 -28180 0 0 {name=p36898 lab=_56083_/C }
C {devices/lab_pin.sym} 37660 -28240 0 1 {name=p36899 lab=_56093_/C }
C {sky130_stdcells/a2bb2oi_4.sym} 37580 -28240 0 0 {name=X_56092_ }
C {devices/lab_pin.sym} 37520 -28100 0 0 {name=p36900 lab=_84752_/Q }
C {devices/lab_pin.sym} 37520 -28060 0 0 {name=p36901 lab=_84144_/Q }
C {devices/lab_pin.sym} 37640 -28080 0 1 {name=p36902 lab=_80358_/A }
C {sky130_stdcells/xor2_4.sym} 37580 -28080 0 0 {name=X_80356_ }
C {devices/lab_pin.sym} 37520 -27960 0 0 {name=p36903 lab=_68403_/A }
C {devices/lab_pin.sym} 37520 -27920 0 0 {name=p36904 lab=_68078_/B }
C {devices/lab_pin.sym} 37640 -27940 0 1 {name=p36905 lab=_68078_/X }
C {sky130_stdcells/and2_4.sym} 37580 -27940 0 0 {name=X_68078_ }
C {devices/lab_pin.sym} 37540 -27810 0 0 {name=p36906 lab=_46614_/X }
C {devices/lab_pin.sym} 37620 -27810 0 1 {name=p36907 lab=_55043_/X }
C {sky130_stdcells/buf_2.sym} 37580 -27810 0 0 {name=X_55043_ }
C {devices/lab_pin.sym} 37540 -27690 0 0 {name=p36908 lab=_62475_/A }
C {devices/lab_pin.sym} 37620 -27690 0 1 {name=p36909 lab=_62515_/C }
C {sky130_stdcells/buf_2.sym} 37580 -27690 0 0 {name=X_59920_ }
C {devices/lab_pin.sym} 37500 -27600 0 0 {name=p36910 lab=_88384_/Q }
C {devices/lab_pin.sym} 37500 -27560 0 0 {name=p36911 lab=_66954_/X }
C {devices/lab_pin.sym} 37500 -27520 0 0 {name=p36912 lab=_66955_/X }
C {devices/lab_pin.sym} 37500 -27480 0 0 {name=p36913 lab=_67028_/X }
C {devices/lab_pin.sym} 37660 -27540 0 1 {name=p36914 lab=_67030_/B }
C {sky130_stdcells/a211o_4.sym} 37580 -27540 0 0 {name=X_67029_ }
C {devices/lab_pin.sym} 37520 -27400 0 0 {name=p36915 lab=_52185_/X }
C {devices/lab_pin.sym} 37520 -27360 0 0 {name=p36916 lab=_48872_/B }
C {devices/lab_pin.sym} 37640 -27380 0 1 {name=p36917 lab=_52255_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -27380 0 0 {name=X_52255_ }
C {devices/lab_pin.sym} 37490 -27250 0 0 {name=p36918 lab=_86523_/CLK }
C {devices/lab_pin.sym} 37490 -27230 0 0 {name=p36919 lab=_83075_/D }
C {devices/lab_pin.sym} 37670 -27250 0 1 {name=p36920 lab=_83075_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -27240 0 0 {name=X_83075_ }
C {devices/lab_pin.sym} 37490 -27110 0 0 {name=p36921 lab=_87952_/CLK }
C {devices/lab_pin.sym} 37490 -27090 0 0 {name=p36922 lab=_42263_/Y }
C {devices/lab_pin.sym} 37670 -27110 0 1 {name=p36923 lab=_87952_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -27100 0 0 {name=X_87952_ }
C {devices/lab_pin.sym} 37520 -26980 0 0 {name=p36924 lab=_80288_/A }
C {devices/lab_pin.sym} 37520 -26940 0 0 {name=p36925 lab=_80288_/B }
C {devices/lab_pin.sym} 37640 -26960 0 1 {name=p36926 lab=_80287_/X }
C {sky130_stdcells/xor2_4.sym} 37580 -26960 0 0 {name=X_80287_ }
C {devices/lab_pin.sym} 37500 -26850 0 0 {name=p36927 lab=_86054_/Q }
C {devices/lab_pin.sym} 37500 -26810 0 0 {name=p36928 lab=_51183_/X }
C {devices/lab_pin.sym} 37500 -26770 0 0 {name=p36929 lab=_51205_/Y }
C {devices/lab_pin.sym} 37660 -26810 0 1 {name=p36930 lab=_51206_/Y }
C {sky130_stdcells/o21ai_4.sym} 37580 -26810 0 0 {name=X_51206_ }
C {devices/lab_pin.sym} 37540 -26670 0 0 {name=p36931 lab=_64732_/A }
C {devices/lab_pin.sym} 37620 -26670 0 1 {name=p36932 lab=_70040_/X }
C {sky130_stdcells/buf_2.sym} 37580 -26670 0 0 {name=X_70040_ }
C {devices/lab_pin.sym} 37490 -26550 0 0 {name=p36933 lab=_84421_/CLK }
C {devices/lab_pin.sym} 37490 -26530 0 0 {name=p36934 lab=_45037_/Y }
C {devices/lab_pin.sym} 37670 -26550 0 1 {name=p36935 lab=_64305_/B }
C {sky130_stdcells/dfxtp_4.sym} 37580 -26540 0 0 {name=X_86903_ }
C {devices/lab_pin.sym} 37490 -26410 0 0 {name=p36936 lab=_81954_/CLK }
C {devices/lab_pin.sym} 37490 -26390 0 0 {name=p36937 lab=_77805_/B }
C {devices/lab_pin.sym} 37670 -26410 0 1 {name=p36938 lab=_81994_/D }
C {sky130_stdcells/dfxtp_4.sym} 37580 -26400 0 0 {name=X_82026_ }
C {devices/lab_pin.sym} 37540 -26270 0 0 {name=p36939 lab=_60036_/A }
C {devices/lab_pin.sym} 37620 -26270 0 1 {name=p36940 lab=_59852_/A }
C {sky130_stdcells/buf_2.sym} 37580 -26270 0 0 {name=X_59851_ }
C {devices/lab_pin.sym} 37520 -26160 0 0 {name=p36941 lab=_52185_/X }
C {devices/lab_pin.sym} 37520 -26120 0 0 {name=p36942 lab=_48551_/X }
C {devices/lab_pin.sym} 37640 -26140 0 1 {name=p36943 lab=_52186_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -26140 0 0 {name=X_52186_ }
C {devices/lab_pin.sym} 37490 -26010 0 0 {name=p36944 lab=_87883_/CLK }
C {devices/lab_pin.sym} 37490 -25990 0 0 {name=p36945 lab=_87883_/D }
C {devices/lab_pin.sym} 37670 -26010 0 1 {name=p36946 lab=_87883_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -26000 0 0 {name=X_87883_ }
C {devices/lab_pin.sym} 37500 -25910 0 0 {name=p36947 lab=_58748_/X }
C {devices/lab_pin.sym} 37500 -25870 0 0 {name=p36948 lab=_58800_/Y }
C {devices/lab_pin.sym} 37500 -25830 0 0 {name=p36949 lab=_58801_/Y }
C {devices/lab_pin.sym} 37500 -25790 0 0 {name=p36950 lab=_58766_/X }
C {devices/lab_pin.sym} 37500 -25750 0 0 {name=p36951 lab=_58752_/X }
C {devices/lab_pin.sym} 37660 -25830 0 1 {name=p36952 lab=_58802_/X }
C {sky130_stdcells/o32a_4.sym} 37580 -25830 0 0 {name=X_58802_ }
C {devices/lab_pin.sym} 37520 -25700 0 0 {name=p36953 lab=_51160_/A }
C {devices/lab_pin.sym} 37520 -25660 0 0 {name=p36954 lab=_51121_/B }
C {devices/lab_pin.sym} 37520 -25620 0 0 {name=p36955 lab=_51115_/C }
C {devices/lab_pin.sym} 37520 -25580 0 0 {name=p36956 lab=_52831_/D }
C {devices/lab_pin.sym} 37640 -25640 0 1 {name=p36957 lab=_51137_/X }
C {sky130_stdcells/and4_4.sym} 37580 -25640 0 0 {name=X_51137_ }
C {devices/lab_pin.sym} 37490 -25490 0 0 {name=p36958 lab=_86834_/CLK }
C {devices/lab_pin.sym} 37490 -25470 0 0 {name=p36959 lab=_86834_/D }
C {devices/lab_pin.sym} 37670 -25490 0 1 {name=p36960 lab=_86834_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -25480 0 0 {name=X_86834_ }
C {devices/lab_pin.sym} 37540 -25350 0 0 {name=p36961 lab=_70056_/A }
C {devices/lab_pin.sym} 37620 -25350 0 1 {name=p36962 lab=_59782_/X }
C {sky130_stdcells/buf_2.sym} 37580 -25350 0 0 {name=X_59782_ }
C {devices/lab_pin.sym} 37520 -25260 0 0 {name=p36963 lab=_56726_/X }
C {devices/lab_pin.sym} 37520 -25220 0 0 {name=p36964 lab=_56684_/B }
C {devices/lab_pin.sym} 37520 -25180 0 0 {name=p36965 lab=_56739_/X }
C {devices/lab_pin.sym} 37520 -25140 0 0 {name=p36966 lab=_56994_/D }
C {devices/lab_pin.sym} 37640 -25200 0 1 {name=p36967 lab=_56994_/Y }
C {sky130_stdcells/nand4_4.sym} 37580 -25200 0 0 {name=X_56994_ }
C {devices/lab_pin.sym} 37500 -25070 0 0 {name=p36968 lab=_58682_/X }
C {devices/lab_pin.sym} 37500 -25030 0 0 {name=p36969 lab=_85780_/Q }
C {devices/lab_pin.sym} 37500 -24990 0 0 {name=p36970 lab=_58706_/X }
C {devices/lab_pin.sym} 37660 -25030 0 1 {name=p36971 lab=_58733_/X }
C {sky130_stdcells/o21a_4.sym} 37580 -25030 0 0 {name=X_58733_ }
C {devices/lab_pin.sym} 37520 -24900 0 0 {name=p36972 lab=_55945_/A }
C {devices/lab_pin.sym} 37520 -24860 0 0 {name=p36973 lab=_55945_/B }
C {devices/lab_pin.sym} 37640 -24880 0 1 {name=p36974 lab=_55946_/A }
C {sky130_stdcells/and2_4.sym} 37580 -24880 0 0 {name=X_55945_ }
C {devices/lab_pin.sym} 37500 -24770 0 0 {name=p36975 lab=_51064_/Y }
C {devices/lab_pin.sym} 37500 -24730 0 0 {name=p36976 lab=_51065_/X }
C {devices/lab_pin.sym} 37500 -24690 0 0 {name=p36977 lab=_51067_/X }
C {devices/lab_pin.sym} 37660 -24730 0 1 {name=p36978 lab=_86080_/D }
C {sky130_stdcells/a21oi_4.sym} 37580 -24730 0 0 {name=X_51068_ }
C {devices/lab_pin.sym} 37490 -24590 0 0 {name=p36979 lab=_84409_/CLK }
C {devices/lab_pin.sym} 37490 -24570 0 0 {name=p36980 lab=_86765_/D }
C {devices/lab_pin.sym} 37670 -24590 0 1 {name=p36981 lab=_44904_/A }
C {sky130_stdcells/dfxtp_4.sym} 37580 -24580 0 0 {name=X_86765_ }
C {devices/lab_pin.sym} 37540 -24450 0 0 {name=p36982 lab=clkbuf_8_75_0_CLK/A }
C {devices/lab_pin.sym} 37620 -24450 0 1 {name=p36983 lab=clkbuf_8_74_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 37580 -24450 0 0 {name=Xclkbuf_8_74_0_CLK }
C {devices/lab_pin.sym} 37520 -24340 0 0 {name=p36984 lab=_72007_/A }
C {devices/lab_pin.sym} 37520 -24300 0 0 {name=p36985 lab=_53819_/B }
C {devices/lab_pin.sym} 37640 -24320 0 1 {name=p36986 lab=_71991_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -24320 0 0 {name=X_71991_ }
C {devices/lab_pin.sym} 37490 -24190 0 0 {name=p36987 lab=_80740_/CLK }
C {devices/lab_pin.sym} 37490 -24170 0 0 {name=p36988 lab=_83977_/D }
C {devices/lab_pin.sym} 37670 -24190 0 1 {name=p36989 lab=_83977_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -24180 0 0 {name=X_83977_ }
C {devices/lab_pin.sym} 37540 -24050 0 0 {name=p36990 lab=clkbuf_7_6_0_CLK/A }
C {devices/lab_pin.sym} 37620 -24050 0 1 {name=p36991 lab=clkbuf_7_6_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 37580 -24050 0 0 {name=Xclkbuf_7_6_0_CLK }
C {devices/lab_pin.sym} 37540 -23930 0 0 {name=p36992 lab=_42909_/Y }
C {devices/lab_pin.sym} 37620 -23930 0 1 {name=p36993 lab=_42910_/Y }
C {sky130_stdcells/inv_2.sym} 37580 -23930 0 0 {name=X_42910_ }
C {devices/lab_pin.sym} 37500 -23830 0 0 {name=p36994 lab=_72415_/B }
C {devices/lab_pin.sym} 37500 -23790 0 0 {name=p36995 lab=_50012_/X }
C {devices/lab_pin.sym} 37500 -23750 0 0 {name=p36996 lab=_50018_/Y }
C {devices/lab_pin.sym} 37660 -23790 0 1 {name=p36997 lab=_50019_/Y }
C {sky130_stdcells/o21ai_4.sym} 37580 -23790 0 0 {name=X_50019_ }
C {devices/lab_pin.sym} 37490 -23650 0 0 {name=p36998 lab=_84757_/CLK }
C {devices/lab_pin.sym} 37490 -23630 0 0 {name=p36999 lab=_52998_/Y }
C {devices/lab_pin.sym} 37670 -23650 0 1 {name=p37000 lab=_85716_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -23640 0 0 {name=X_85716_ }
C {devices/lab_pin.sym} 37500 -23530 0 0 {name=p37001 lab=_44688_/Y }
C {devices/lab_pin.sym} 37500 -23490 0 0 {name=p37002 lab=_73728_/X }
C {devices/lab_pin.sym} 37500 -23450 0 0 {name=p37003 lab=_73729_/Y }
C {devices/lab_pin.sym} 37660 -23490 0 1 {name=p37004 lab=_73730_/X }
C {sky130_stdcells/a21o_4.sym} 37580 -23490 0 0 {name=X_73730_ }
C {devices/lab_pin.sym} 37540 -23350 0 0 {name=p37005 lab=_58793_/A }
C {devices/lab_pin.sym} 37620 -23350 0 1 {name=p37006 lab=_58664_/X }
C {sky130_stdcells/buf_2.sym} 37580 -23350 0 0 {name=X_58664_ }
C {devices/lab_pin.sym} 37520 -23250 0 0 {name=p37007 lab=_70942_/A }
C {devices/lab_pin.sym} 37520 -23210 0 0 {name=p37008 lab=_70942_/B }
C {devices/lab_pin.sym} 37520 -23170 0 0 {name=p37009 lab=_70947_/C }
C {devices/lab_pin.sym} 37640 -23210 0 1 {name=p37010 lab=_70942_/Y }
C {sky130_stdcells/nand3_4.sym} 37580 -23210 0 0 {name=X_70942_ }
C {devices/lab_pin.sym} 37490 -23070 0 0 {name=p37011 lab=_81190_/CLK }
C {devices/lab_pin.sym} 37490 -23050 0 0 {name=p37012 lab=_78231_/X }
C {devices/lab_pin.sym} 37670 -23070 0 1 {name=p37013 lab=_82928_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -23060 0 0 {name=X_82928_ }
C {devices/lab_pin.sym} 37500 -22970 0 0 {name=p37014 lab=_43862_/X }
C {devices/lab_pin.sym} 37500 -22930 0 0 {name=p37015 lab=_43876_/X }
C {devices/lab_pin.sym} 37500 -22890 0 0 {name=p37016 lab=_41316_/X }
C {devices/lab_pin.sym} 37500 -22850 0 0 {name=p37017 lab=_87213_/Q }
C {devices/lab_pin.sym} 37500 -22810 0 0 {name=p37018 lab=_43863_/X }
C {devices/lab_pin.sym} 37660 -22890 0 1 {name=p37019 lab=_43890_/Y }
C {sky130_stdcells/o32ai_4.sym} 37580 -22890 0 0 {name=X_43890_ }
C {devices/lab_pin.sym} 37520 -22740 0 0 {name=p37020 lab=_55549_/A }
C {devices/lab_pin.sym} 37520 -22700 0 0 {name=p37021 lab=_55876_/B }
C {devices/lab_pin.sym} 37640 -22720 0 1 {name=p37022 lab=_55876_/X }
C {sky130_stdcells/and2_4.sym} 37580 -22720 0 0 {name=X_55876_ }
C {devices/lab_pin.sym} 37490 -22590 0 0 {name=p37023 lab=_86697_/CLK }
C {devices/lab_pin.sym} 37490 -22570 0 0 {name=p37024 lab=_86696_/D }
C {devices/lab_pin.sym} 37670 -22590 0 1 {name=p37025 lab=_58887_/A }
C {sky130_stdcells/dfxtp_4.sym} 37580 -22580 0 0 {name=X_86696_ }
C {devices/lab_pin.sym} 37540 -22450 0 0 {name=p37026 lab=_47714_/A }
C {devices/lab_pin.sym} 37620 -22450 0 1 {name=p37027 lab=_57615_/X }
C {sky130_stdcells/buf_2.sym} 37580 -22450 0 0 {name=X_57615_ }
C {devices/lab_pin.sym} 37500 -22360 0 0 {name=p37028 lab=_41503_/X }
C {devices/lab_pin.sym} 37500 -22320 0 0 {name=p37029 lab=_42830_/X }
C {devices/lab_pin.sym} 37500 -22280 0 0 {name=p37030 lab=_87691_/Q }
C {devices/lab_pin.sym} 37500 -22240 0 0 {name=p37031 lab=_42832_/X }
C {devices/lab_pin.sym} 37660 -22300 0 1 {name=p37032 lab=_42841_/X }
C {sky130_stdcells/a2bb2o_4.sym} 37580 -22300 0 0 {name=X_42841_ }
C {devices/lab_pin.sym} 37520 -22160 0 0 {name=p37033 lab=_54823_/A }
C {devices/lab_pin.sym} 37520 -22120 0 0 {name=p37034 lab=_47589_/Y }
C {devices/lab_pin.sym} 37640 -22140 0 1 {name=p37035 lab=_54827_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -22140 0 0 {name=X_54827_ }
C {devices/lab_pin.sym} 37540 -22010 0 0 {name=p37036 lab=_73284_/A }
C {devices/lab_pin.sym} 37620 -22010 0 1 {name=p37037 lab=_73661_/X }
C {sky130_stdcells/buf_2.sym} 37580 -22010 0 0 {name=X_73661_ }
C {devices/lab_pin.sym} 37490 -21890 0 0 {name=p37038 lab=_85648_/CLK }
C {devices/lab_pin.sym} 37490 -21870 0 0 {name=p37039 lab=_53368_/Y }
C {devices/lab_pin.sym} 37670 -21890 0 1 {name=p37040 lab=_85647_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -21880 0 0 {name=X_85647_ }
C {devices/lab_pin.sym} 37520 -21780 0 0 {name=p37041 lab=_70873_/A }
C {devices/lab_pin.sym} 37520 -21740 0 0 {name=p37042 lab=_70869_/B }
C {devices/lab_pin.sym} 37520 -21700 0 0 {name=p37043 lab=_70869_/C }
C {devices/lab_pin.sym} 37520 -21660 0 0 {name=p37044 lab=_70869_/D }
C {devices/lab_pin.sym} 37640 -21720 0 1 {name=p37045 lab=_70873_/Y }
C {sky130_stdcells/nand4_4.sym} 37580 -21720 0 0 {name=X_70873_ }
C {devices/lab_pin.sym} 37500 -21590 0 0 {name=p37046 lab=_58571_/X }
C {devices/lab_pin.sym} 37500 -21550 0 0 {name=p37047 lab=_85791_/Q }
C {devices/lab_pin.sym} 37500 -21510 0 0 {name=p37048 lab=_58594_/X }
C {devices/lab_pin.sym} 37660 -21550 0 1 {name=p37049 lab=_58595_/X }
C {sky130_stdcells/o21a_4.sym} 37580 -21550 0 0 {name=X_58595_ }
C {devices/lab_pin.sym} 37490 -21410 0 0 {name=p37050 lab=_82859_/CLK }
C {devices/lab_pin.sym} 37490 -21390 0 0 {name=p37051 lab=_82483_/Q }
C {devices/lab_pin.sym} 37670 -21410 0 1 {name=p37052 lab=_40883_/A }
C {sky130_stdcells/dfxtp_4.sym} 37580 -21400 0 0 {name=X_82859_ }
C {devices/lab_pin.sym} 37500 -21290 0 0 {name=p37053 lab=_75401_/A }
C {devices/lab_pin.sym} 37500 -21250 0 0 {name=p37054 lab=_75397_/Y }
C {devices/lab_pin.sym} 37500 -21210 0 0 {name=p37055 lab=_75399_/Y }
C {devices/lab_pin.sym} 37660 -21250 0 1 {name=p37056 lab=_75400_/X }
C {sky130_stdcells/a21o_4.sym} 37580 -21250 0 0 {name=X_75400_ }
C {devices/lab_pin.sym} 37500 -21140 0 0 {name=p37057 lab=_72516_/B }
C {devices/lab_pin.sym} 37500 -21100 0 0 {name=p37058 lab=_72579_/A }
C {devices/lab_pin.sym} 37500 -21060 0 0 {name=p37059 lab=_59512_/X }
C {devices/lab_pin.sym} 37500 -21020 0 0 {name=p37060 lab=_72602_/X }
C {devices/lab_pin.sym} 37660 -21080 0 1 {name=p37061 lab=_72612_/X }
C {sky130_stdcells/a211o_4.sym} 37580 -21080 0 0 {name=X_72612_ }
C {devices/lab_pin.sym} 37520 -20940 0 0 {name=p37062 lab=_45560_/A }
C {devices/lab_pin.sym} 37520 -20900 0 0 {name=p37063 lab=_45654_/B }
C {devices/lab_pin.sym} 37640 -20920 0 1 {name=p37064 lab=_45560_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -20920 0 0 {name=X_45560_ }
C {devices/lab_pin.sym} 37540 -20790 0 0 {name=p37065 lab=clkbuf_8_89_0_CLK/A }
C {devices/lab_pin.sym} 37620 -20790 0 1 {name=p37066 lab=clkbuf_8_89_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 37580 -20790 0 0 {name=Xclkbuf_8_89_0_CLK }
C {devices/lab_pin.sym} 37520 -20680 0 0 {name=p37067 lab=_57528_/X }
C {devices/lab_pin.sym} 37520 -20640 0 0 {name=p37068 lab=_73864_/A }
C {devices/lab_pin.sym} 37640 -20660 0 1 {name=p37069 lab=_57546_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -20660 0 0 {name=X_57546_ }
C {devices/lab_pin.sym} 37520 -20540 0 0 {name=p37070 lab=_76376_/X }
C {devices/lab_pin.sym} 37520 -20500 0 0 {name=p37071 lab=_76379_/X }
C {devices/lab_pin.sym} 37640 -20520 0 1 {name=p37072 lab=_76387_/A }
C {sky130_stdcells/xor2_4.sym} 37580 -20520 0 0 {name=X_76380_ }
C {devices/lab_pin.sym} 37490 -20390 0 0 {name=p37073 lab=_86982_/CLK }
C {devices/lab_pin.sym} 37490 -20370 0 0 {name=p37074 lab=_40614_/Y }
C {devices/lab_pin.sym} 37670 -20390 0 1 {name=p37075 lab=_68498_/B }
C {sky130_stdcells/dfxtp_4.sym} 37580 -20380 0 0 {name=X_88366_ }
C {devices/lab_pin.sym} 37500 -20290 0 0 {name=p37076 lab=_42739_/X }
C {devices/lab_pin.sym} 37500 -20250 0 0 {name=p37077 lab=_42740_/X }
C {devices/lab_pin.sym} 37500 -20210 0 0 {name=p37078 lab=_41316_/X }
C {devices/lab_pin.sym} 37500 -20170 0 0 {name=p37079 lab=_87725_/Q }
C {devices/lab_pin.sym} 37500 -20130 0 0 {name=p37080 lab=_42750_/X }
C {devices/lab_pin.sym} 37660 -20210 0 1 {name=p37081 lab=_42773_/A }
C {sky130_stdcells/o32ai_4.sym} 37580 -20210 0 0 {name=X_42772_ }
C {devices/lab_pin.sym} 37540 -20050 0 0 {name=p37082 lab=_54758_/A }
C {devices/lab_pin.sym} 37620 -20050 0 1 {name=p37083 lab=_54758_/X }
C {sky130_stdcells/buf_2.sym} 37580 -20050 0 0 {name=X_54758_ }
C {devices/lab_pin.sym} 37490 -19930 0 0 {name=p37084 lab=_85859_/CLK }
C {devices/lab_pin.sym} 37490 -19910 0 0 {name=p37085 lab=_85578_/D }
C {devices/lab_pin.sym} 37670 -19930 0 1 {name=p37086 lab=_85578_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -19920 0 0 {name=X_85578_ }
C {devices/lab_pin.sym} 37520 -19800 0 0 {name=p37087 lab=_73582_/Y }
C {devices/lab_pin.sym} 37520 -19760 0 0 {name=p37088 lab=_73591_/X }
C {devices/lab_pin.sym} 37640 -19780 0 1 {name=p37089 lab=_73592_/Y }
C {sky130_stdcells/xnor2_4.sym} 37580 -19780 0 0 {name=X_73592_ }
C {devices/lab_pin.sym} 37540 -19650 0 0 {name=p37090 lab=_40686_/A }
C {devices/lab_pin.sym} 37620 -19650 0 1 {name=p37091 lab=_44512_/A }
C {sky130_stdcells/buf_2.sym} 37580 -19650 0 0 {name=X_44511_ }
C {devices/lab_pin.sym} 37490 -19530 0 0 {name=p37092 lab=_83153_/CLK }
C {devices/lab_pin.sym} 37490 -19510 0 0 {name=p37093 lab=_87317_/D }
C {devices/lab_pin.sym} 37670 -19530 0 1 {name=p37094 lab=_87317_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -19520 0 0 {name=X_87317_ }
C {devices/lab_pin.sym} 37520 -19400 0 0 {name=p37095 lab=_80692_/Q }
C {devices/lab_pin.sym} 37520 -19360 0 0 {name=p37096 lab=_80948_/D }
C {devices/lab_pin.sym} 37640 -19380 0 1 {name=p37097 lab=_75331_/Y }
C {sky130_stdcells/nor2_4.sym} 37580 -19380 0 0 {name=X_75331_ }
C {devices/lab_pin.sym} 37540 -19250 0 0 {name=p37098 lab=_41814_/A }
C {devices/lab_pin.sym} 37620 -19250 0 1 {name=p37099 lab=_41723_/X }
C {sky130_stdcells/buf_2.sym} 37580 -19250 0 0 {name=X_41723_ }
C {devices/lab_pin.sym} 37520 -19140 0 0 {name=p37100 lab=_53713_/A }
C {devices/lab_pin.sym} 37520 -19100 0 0 {name=p37101 lab=_48559_/Y }
C {devices/lab_pin.sym} 37640 -19120 0 1 {name=p37102 lab=_53709_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -19120 0 0 {name=X_53709_ }
C {devices/lab_pin.sym} 37540 -18990 0 0 {name=p37103 lab=_72543_/A }
C {devices/lab_pin.sym} 37620 -18990 0 1 {name=p37104 lab=_72573_/A }
C {sky130_stdcells/buf_2.sym} 37580 -18990 0 0 {name=X_72543_ }
C {devices/lab_pin.sym} 37490 -18870 0 0 {name=p37105 lab=_84529_/CLK }
C {devices/lab_pin.sym} 37490 -18850 0 0 {name=p37106 lab=_84529_/D }
C {devices/lab_pin.sym} 37670 -18870 0 1 {name=p37107 lab=_76977_/A }
C {sky130_stdcells/dfxtp_4.sym} 37580 -18860 0 0 {name=X_84529_ }
C {devices/lab_pin.sym} 37500 -18760 0 0 {name=p37108 lab=_45488_/Y }
C {devices/lab_pin.sym} 37500 -18720 0 0 {name=p37109 lab=_45489_/X }
C {devices/lab_pin.sym} 37500 -18680 0 0 {name=p37110 lab=_45443_/X }
C {devices/lab_pin.sym} 37500 -18640 0 0 {name=p37111 lab=_45490_/Y }
C {devices/lab_pin.sym} 37660 -18700 0 1 {name=p37112 lab=_45491_/X }
C {sky130_stdcells/a211o_4.sym} 37580 -18700 0 0 {name=X_45491_ }
C {devices/lab_pin.sym} 37500 -18570 0 0 {name=p37113 lab=_57372_/X }
C {devices/lab_pin.sym} 37500 -18530 0 0 {name=p37114 lab=_57474_/Y }
C {devices/lab_pin.sym} 37500 -18490 0 0 {name=p37115 lab=_57476_/X }
C {devices/lab_pin.sym} 37660 -18530 0 1 {name=p37116 lab=_57478_/A }
C {sky130_stdcells/o21ai_4.sym} 37580 -18530 0 0 {name=X_57477_ }
C {devices/lab_pin.sym} 37490 -18390 0 0 {name=p37117 lab=_87022_/CLK }
C {devices/lab_pin.sym} 37490 -18370 0 0 {name=p37118 lab=_88297_/D }
C {devices/lab_pin.sym} 37670 -18390 0 1 {name=p37119 lab=_69279_/B }
C {sky130_stdcells/dfxtp_4.sym} 37580 -18380 0 0 {name=X_88297_ }
C {devices/lab_pin.sym} 37520 -18280 0 0 {name=p37120 lab=_54674_/A }
C {devices/lab_pin.sym} 37520 -18240 0 0 {name=p37121 lab=_54707_/B }
C {devices/lab_pin.sym} 37520 -18200 0 0 {name=p37122 lab=_54674_/C }
C {devices/lab_pin.sym} 37520 -18160 0 0 {name=p37123 lab=_47348_/A }
C {devices/lab_pin.sym} 37640 -18220 0 1 {name=p37124 lab=_54689_/X }
C {sky130_stdcells/and4_4.sym} 37580 -18220 0 0 {name=X_54689_ }
C {devices/lab_pin.sym} 37540 -18070 0 0 {name=p37125 lab=_47230_/A }
C {devices/lab_pin.sym} 37620 -18070 0 1 {name=p37126 lab=_54097_/B }
C {sky130_stdcells/inv_2.sym} 37580 -18070 0 0 {name=X_47230_ }
C {devices/lab_pin.sym} 37540 -17950 0 0 {name=p37127 lab=_84759_/Q }
C {devices/lab_pin.sym} 37620 -17950 0 1 {name=p37128 lab=_59216_/Y }
C {sky130_stdcells/inv_2.sym} 37580 -17950 0 0 {name=X_59216_ }
C {devices/lab_pin.sym} 37520 -17840 0 0 {name=p37129 lab=_84555_/Q }
C {devices/lab_pin.sym} 37520 -17800 0 0 {name=p37130 lab=_78050_/B }
C {devices/lab_pin.sym} 37640 -17820 0 1 {name=p37131 lab=_81859_/D }
C {sky130_stdcells/xor2_4.sym} 37580 -17820 0 0 {name=X_78050_ }
C {devices/lab_pin.sym} 37540 -17690 0 0 {name=p37132 lab=_44441_/Y }
C {devices/lab_pin.sym} 37620 -17690 0 1 {name=p37133 lab=_87106_/D }
C {sky130_stdcells/inv_2.sym} 37580 -17690 0 0 {name=X_44442_ }
C {devices/lab_pin.sym} 37500 -17590 0 0 {name=p37134 lab=_56109_/X }
C {devices/lab_pin.sym} 37500 -17550 0 0 {name=p37135 lab=_56426_/X }
C {devices/lab_pin.sym} 37500 -17510 0 0 {name=p37136 lab=_56427_/Y }
C {devices/lab_pin.sym} 37660 -17550 0 1 {name=p37137 lab=_85198_/D }
C {sky130_stdcells/o21ai_4.sym} 37580 -17550 0 0 {name=X_56428_ }
C {devices/lab_pin.sym} 37520 -17420 0 0 {name=p37138 lab=_75237_/X }
C {devices/lab_pin.sym} 37520 -17380 0 0 {name=p37139 lab=_75240_/X }
C {devices/lab_pin.sym} 37640 -17400 0 1 {name=p37140 lab=_75262_/X }
C {sky130_stdcells/xor2_4.sym} 37580 -17400 0 0 {name=X_75262_ }
C {devices/lab_pin.sym} 37520 -17280 0 0 {name=p37141 lab=_82908_/Q }
C {devices/lab_pin.sym} 37520 -17240 0 0 {name=p37142 lab=_41653_/X }
C {devices/lab_pin.sym} 37640 -17260 0 1 {name=p37143 lab=_41654_/X }
C {sky130_stdcells/or2_4.sym} 37580 -17260 0 0 {name=X_41654_ }
C {devices/lab_pin.sym} 37490 -17130 0 0 {name=p37144 lab=_87766_/CLK }
C {devices/lab_pin.sym} 37490 -17110 0 0 {name=p37145 lab=_43827_/X }
C {devices/lab_pin.sym} 37670 -17130 0 1 {name=p37146 lab=_87248_/Q }
C {sky130_stdcells/dfxtp_4.sym} 37580 -17120 0 0 {name=X_87248_ }
C {devices/lab_pin.sym} 37500 -17020 0 0 {name=p37147 lab=_72465_/Y }
C {devices/lab_pin.sym} 37500 -16980 0 0 {name=p37148 lab=_72358_/X }
C {devices/lab_pin.sym} 37500 -16940 0 0 {name=p37149 lab=_72470_/X }
C {devices/lab_pin.sym} 37500 -16900 0 0 {name=p37150 lab=_72473_/X }
C {devices/lab_pin.sym} 37660 -16960 0 1 {name=p37151 lab=_72474_/Y }
C {sky130_stdcells/a22oi_4.sym} 37580 -16960 0 0 {name=X_72474_ }
C {devices/lab_pin.sym} 37540 -16810 0 0 {name=p37152 lab=clkbuf_7_6_0_CLK/X }
C {devices/lab_pin.sym} 37620 -16810 0 1 {name=p37153 lab=clkbuf_9_25_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 37580 -16810 0 0 {name=Xclkbuf_8_12_0_CLK }
C {devices/lab_pin.sym} 37520 -16700 0 0 {name=p37154 lab=_84553_/Q }
C {devices/lab_pin.sym} 37520 -16660 0 0 {name=p37155 lab=_84425_/Q }
C {devices/lab_pin.sym} 37640 -16680 0 1 {name=p37156 lab=_77001_/X }
C {sky130_stdcells/xor2_4.sym} 37580 -16680 0 0 {name=X_77001_ }
C {devices/lab_pin.sym} 37500 -16580 0 0 {name=p37157 lab=_45931_/X }
C {devices/lab_pin.sym} 37500 -16540 0 0 {name=p37158 lab=_86213_/Q }
C {devices/lab_pin.sym} 37500 -16500 0 0 {name=p37159 lab=_72985_/X }
C {devices/lab_pin.sym} 37500 -16460 0 0 {name=p37160 lab=_74212_/X }
C {devices/lab_pin.sym} 37660 -16520 0 1 {name=p37161 lab=_74213_/X }
C {sky130_stdcells/a211o_4.sym} 37580 -16520 0 0 {name=X_74213_ }
C {devices/lab_pin.sym} 37540 -16370 0 0 {name=p37162 lab=_40604_/X }
C {devices/lab_pin.sym} 37620 -16370 0 1 {name=p37163 lab=_40605_/X }
C {sky130_stdcells/buf_2.sym} 37580 -16370 0 0 {name=X_40605_ }
C {devices/lab_pin.sym} 37540 -16250 0 0 {name=p37164 lab=_82376_/Q }
C {devices/lab_pin.sym} 37620 -16250 0 1 {name=p37165 lab=_54580_/D }
C {sky130_stdcells/inv_2.sym} 37580 -16250 0 0 {name=X_47161_ }
C {devices/lab_pin.sym} 37500 -16150 0 0 {name=p37166 lab=_71420_/X }
C {devices/lab_pin.sym} 37500 -16110 0 0 {name=p37167 lab=_83504_/Q }
C {devices/lab_pin.sym} 37500 -16070 0 0 {name=p37168 lab=_71424_/X }
C {devices/lab_pin.sym} 37660 -16110 0 1 {name=p37169 lab=_71425_/X }
C {sky130_stdcells/a21o_4.sym} 37580 -16110 0 0 {name=X_71425_ }
C {devices/lab_pin.sym} 37500 -15990 0 0 {name=p37170 lab=_58934_/X }
C {devices/lab_pin.sym} 37500 -15950 0 0 {name=p37171 lab=_85653_/Q }
C {devices/lab_pin.sym} 37500 -15910 0 0 {name=p37172 lab=_59081_/X }
C {devices/lab_pin.sym} 37660 -15950 0 1 {name=p37173 lab=_59147_/X }
C {sky130_stdcells/o21a_4.sym} 37580 -15950 0 0 {name=X_59147_ }
C {devices/lab_pin.sym} 37500 -15840 0 0 {name=p37174 lab=_41768_/X }
C {devices/lab_pin.sym} 37500 -15800 0 0 {name=p37175 lab=_44364_/X }
C {devices/lab_pin.sym} 37500 -15760 0 0 {name=p37176 lab=_87141_/Q }
C {devices/lab_pin.sym} 37500 -15720 0 0 {name=p37177 lab=_44365_/X }
C {devices/lab_pin.sym} 37660 -15780 0 1 {name=p37178 lab=_87141_/D }
C {sky130_stdcells/a2bb2o_4.sym} 37580 -15780 0 0 {name=X_44373_ }
C {devices/lab_pin.sym} 37500 -15650 0 0 {name=p37179 lab=_56153_/X }
C {devices/lab_pin.sym} 37500 -15610 0 0 {name=p37180 lab=_56350_/X }
C {devices/lab_pin.sym} 37500 -15570 0 0 {name=p37181 lab=_56358_/Y }
C {devices/lab_pin.sym} 37660 -15610 0 1 {name=p37182 lab=_85222_/D }
C {sky130_stdcells/o21ai_4.sym} 37580 -15610 0 0 {name=X_56359_ }
C {devices/lab_pin.sym} 37490 -15470 0 0 {name=p37183 lab=_87178_/CLK }
C {devices/lab_pin.sym} 37490 -15450 0 0 {name=p37184 lab=_87179_/D }
C {devices/lab_pin.sym} 37670 -15470 0 1 {name=p37185 lab=_44232_/B }
C {sky130_stdcells/dfxtp_4.sym} 37580 -15460 0 0 {name=X_87179_ }
C {devices/lab_pin.sym} 37520 -15350 0 0 {name=p37186 lab=_75182_/A }
C {devices/lab_pin.sym} 37520 -15310 0 0 {name=p37187 lab=_75162_/B }
C {devices/lab_pin.sym} 37520 -15270 0 0 {name=p37188 lab=_75162_/A }
C {devices/lab_pin.sym} 37640 -15310 0 1 {name=p37189 lab=_75193_/Y }
C {sky130_stdcells/nand3_4.sym} 37580 -15310 0 0 {name=X_75193_ }
C {devices/lab_pin.sym} 37500 -15190 0 0 {name=p37190 lab=_41548_/X }
C {devices/lab_pin.sym} 37500 -15150 0 0 {name=p37191 lab=_82313_/Q }
C {devices/lab_pin.sym} 37500 -15110 0 0 {name=p37192 lab=_41584_/X }
C {devices/lab_pin.sym} 37660 -15150 0 1 {name=p37193 lab=_41585_/Y }
C {sky130_stdcells/o21ai_4.sym} 37580 -15150 0 0 {name=X_41585_ }
C {devices/lab_pin.sym} 37520 -15020 0 0 {name=p37194 lab=_46112_/A }
C {devices/lab_pin.sym} 37520 -14980 0 0 {name=p37195 lab=_46111_/X }
C {devices/lab_pin.sym} 37640 -15000 0 1 {name=p37196 lab=_46138_/A }
C {sky130_stdcells/nor2_4.sym} 37580 -15000 0 0 {name=X_46112_ }
C {devices/lab_pin.sym} 37500 -14900 0 0 {name=p37197 lab=_41264_/X }
C {devices/lab_pin.sym} 37500 -14860 0 0 {name=p37198 lab=_43300_/X }
C {devices/lab_pin.sym} 37500 -14820 0 0 {name=p37199 lab=_87480_/Q }
C {devices/lab_pin.sym} 37500 -14780 0 0 {name=p37200 lab=_43302_/X }
C {devices/lab_pin.sym} 37660 -14840 0 1 {name=p37201 lab=_87480_/D }
C {sky130_stdcells/a2bb2o_4.sym} 37580 -14840 0 0 {name=X_43324_ }
C {devices/lab_pin.sym} 37500 -14720 0 0 {name=p37202 lab=_41963_/Y }
C {devices/lab_pin.sym} 37500 -14680 0 0 {name=p37203 lab=_56273_/X }
C {devices/lab_pin.sym} 37500 -14640 0 0 {name=p37204 lab=_72725_/A }
C {devices/lab_pin.sym} 37500 -14600 0 0 {name=p37205 lab=_74143_/Y }
C {devices/lab_pin.sym} 37660 -14660 0 1 {name=p37206 lab=_74144_/X }
C {sky130_stdcells/a211o_4.sym} 37580 -14660 0 0 {name=X_74144_ }
C {devices/lab_pin.sym} 37520 -14520 0 0 {name=p37207 lab=_40937_/A }
C {devices/lab_pin.sym} 37520 -14480 0 0 {name=p37208 lab=_40536_/B }
C {devices/lab_pin.sym} 37640 -14500 0 1 {name=p37209 lab=_40536_/X }
C {sky130_stdcells/or2_4.sym} 37580 -14500 0 0 {name=X_40536_ }
C {devices/lab_pin.sym} 37540 -14370 0 0 {name=p37210 lab=_47092_/A }
C {devices/lab_pin.sym} 37620 -14370 0 1 {name=p37211 lab=_47093_/A }
C {sky130_stdcells/inv_2.sym} 37580 -14370 0 0 {name=X_47092_ }
C {devices/lab_pin.sym} 37540 -14250 0 0 {name=p37212 lab=_84770_/Q }
C {devices/lab_pin.sym} 37620 -14250 0 1 {name=p37213 lab=_59078_/Y }
C {sky130_stdcells/inv_2.sym} 37580 -14250 0 0 {name=X_59078_ }
C {devices/lab_pin.sym} 37540 -14130 0 0 {name=p37214 lab=DATA_TO_HASH[5] }
C {devices/lab_pin.sym} 37620 -14130 0 1 {name=p37215 lab=_71427_/C }
C {sky130_stdcells/buf_2.sym} 37580 -14130 0 0 {name=X_71356_ }
C {devices/lab_pin.sym} 37540 -14010 0 0 {name=p37216 lab=_43585_/X }
C {devices/lab_pin.sym} 37620 -14010 0 1 {name=p37217 lab=_46043_/X }
C {sky130_stdcells/buf_2.sym} 37580 -14010 0 0 {name=X_46043_ }
C {devices/lab_pin.sym} 37500 -13930 0 0 {name=p37218 lab=_58010_/X }
C {devices/lab_pin.sym} 37500 -13890 0 0 {name=p37219 lab=_58026_/Y }
C {devices/lab_pin.sym} 37500 -13850 0 0 {name=p37220 lab=_58027_/Y }
C {devices/lab_pin.sym} 37500 -13810 0 0 {name=p37221 lab=_58028_/X }
C {devices/lab_pin.sym} 37500 -13770 0 0 {name=p37222 lab=_58015_/X }
C {devices/lab_pin.sym} 37660 -13850 0 1 {name=p37223 lab=_58029_/X }
C {sky130_stdcells/o32a_4.sym} 37580 -13850 0 0 {name=X_58029_ }
C {devices/lab_pin.sym} 37500 -13710 0 0 {name=p37224 lab=_70303_/X }
C {devices/lab_pin.sym} 37500 -13670 0 0 {name=p37225 lab=_74748_/A }
C {devices/lab_pin.sym} 37500 -13630 0 0 {name=p37226 lab=_70306_/X }
C {devices/lab_pin.sym} 37660 -13670 0 1 {name=p37227 lab=_70307_/X }
C {sky130_stdcells/a21o_4.sym} 37580 -13670 0 0 {name=X_70307_ }
C {devices/lab_pin.sym} 37500 -13560 0 0 {name=p37228 lab=_41070_/X }
C {devices/lab_pin.sym} 37500 -13520 0 0 {name=p37229 lab=_43247_/X }
C {devices/lab_pin.sym} 37500 -13480 0 0 {name=p37230 lab=_87515_/Q }
C {devices/lab_pin.sym} 37500 -13440 0 0 {name=p37231 lab=_43248_/X }
C {devices/lab_pin.sym} 37660 -13500 0 1 {name=p37232 lab=_87515_/D }
C {sky130_stdcells/a2bb2o_4.sym} 37580 -13500 0 0 {name=X_43255_ }
C {devices/lab_pin.sym} 37520 -13360 0 0 {name=p37233 lab=_78952_/A }
C {devices/lab_pin.sym} 37520 -13320 0 0 {name=p37234 lab=_78951_/X }
C {devices/lab_pin.sym} 37640 -13340 0 1 {name=p37235 lab=_78956_/A }
C {sky130_stdcells/nand2_4.sym} 37580 -13340 0 0 {name=X_78952_ }
C {devices/lab_pin.sym} 37500 -13240 0 0 {name=p37236 lab=_43087_/Y }
C {devices/lab_pin.sym} 37500 -13200 0 0 {name=p37237 lab=_72895_/X }
C {devices/lab_pin.sym} 37500 -13160 0 0 {name=p37238 lab=_73486_/X }
C {devices/lab_pin.sym} 37500 -13120 0 0 {name=p37239 lab=_74074_/Y }
C {devices/lab_pin.sym} 37660 -13180 0 1 {name=p37240 lab=_74075_/X }
C {sky130_stdcells/a211o_4.sym} 37580 -13180 0 0 {name=X_74075_ }
C {devices/lab_pin.sym} 37540 -13030 0 0 {name=p37241 lab=clkbuf_8_27_0_CLK/A }
C {devices/lab_pin.sym} 37620 -13030 0 1 {name=p37242 lab=clkbuf_9_55_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 37580 -13030 0 0 {name=Xclkbuf_8_27_0_CLK }
C {devices/lab_pin.sym} 37520 -12920 0 0 {name=p37243 lab=_82321_/Q }
C {devices/lab_pin.sym} 37520 -12880 0 0 {name=p37244 lab=_40467_/B }
C {devices/lab_pin.sym} 37640 -12900 0 1 {name=p37245 lab=_40467_/X }
C {sky130_stdcells/or2_4.sym} 37580 -12900 0 0 {name=X_40467_ }
C {devices/lab_pin.sym} 37520 -12800 0 0 {name=p37246 lab=_71136_/A }
C {devices/lab_pin.sym} 37520 -12760 0 0 {name=p37247 lab=_70696_/B }
C {devices/lab_pin.sym} 37520 -12720 0 0 {name=p37248 lab=_71287_/C }
C {devices/lab_pin.sym} 37520 -12680 0 0 {name=p37249 lab=_70578_/A }
C {devices/lab_pin.sym} 37640 -12740 0 1 {name=p37250 lab=_71287_/Y }
C {sky130_stdcells/nand4_4.sym} 37580 -12740 0 0 {name=X_71287_ }
C {devices/lab_pin.sym} 37500 -12630 0 0 {name=p37251 lab=_42205_/X }
C {devices/lab_pin.sym} 37500 -12590 0 0 {name=p37252 lab=_42200_/X }
C {devices/lab_pin.sym} 37500 -12550 0 0 {name=p37253 lab=_41321_/X }
C {devices/lab_pin.sym} 37500 -12510 0 0 {name=p37254 lab=_87980_/Q }
C {devices/lab_pin.sym} 37500 -12470 0 0 {name=p37255 lab=_42201_/X }
C {devices/lab_pin.sym} 37660 -12550 0 1 {name=p37256 lab=_42206_/Y }
C {sky130_stdcells/o32ai_4.sym} 37580 -12550 0 0 {name=X_42206_ }
C {devices/lab_pin.sym} 37500 -12430 0 0 {name=p37257 lab=_60995_/Y }
C {devices/lab_pin.sym} 37500 -12390 0 0 {name=p37258 lab=_61008_/Y }
C {devices/lab_pin.sym} 37500 -12350 0 0 {name=p37259 lab=_60989_/X }
C {devices/lab_pin.sym} 37500 -12310 0 0 {name=p37260 lab=_84531_/Q }
C {devices/lab_pin.sym} 37500 -12270 0 0 {name=p37261 lab=_59509_/X }
C {devices/lab_pin.sym} 37660 -12350 0 1 {name=p37262 lab=_84531_/D }
C {sky130_stdcells/o32a_4.sym} 37580 -12350 0 0 {name=X_61040_ }
C {devices/lab_pin.sym} 37500 -12210 0 0 {name=p37263 lab=_77891_/A }
C {devices/lab_pin.sym} 37500 -12170 0 0 {name=p37264 lab=_77890_/Y }
C {devices/lab_pin.sym} 37500 -12130 0 0 {name=p37265 lab=_77902_/X }
C {devices/lab_pin.sym} 37660 -12170 0 1 {name=p37266 lab=_77903_/Y }
C {sky130_stdcells/o21ai_4.sym} 37580 -12170 0 0 {name=X_77903_ }
C {devices/lab_pin.sym} 37540 -12030 0 0 {name=p37267 lab=_73530_/B }
C {devices/lab_pin.sym} 37620 -12030 0 1 {name=p37268 lab=_73026_/X }
C {sky130_stdcells/buf_2.sym} 37580 -12030 0 0 {name=X_73026_ }
C {devices/lab_pin.sym} 37540 -11910 0 0 {name=p37269 lab=_70238_/A }
C {devices/lab_pin.sym} 37620 -11910 0 1 {name=p37270 lab=_70238_/X }
C {sky130_stdcells/buf_2.sym} 37580 -11910 0 0 {name=X_70238_ }
C {devices/lab_pin.sym} 37500 -11820 0 0 {name=p37271 lab=_40890_/X }
C {devices/lab_pin.sym} 37500 -11780 0 0 {name=p37272 lab=_43180_/X }
C {devices/lab_pin.sym} 37500 -11740 0 0 {name=p37273 lab=_73341_/A }
C {devices/lab_pin.sym} 37500 -11700 0 0 {name=p37274 lab=_43185_/X }
C {devices/lab_pin.sym} 37660 -11760 0 1 {name=p37275 lab=_43186_/X }
C {sky130_stdcells/a2bb2o_4.sym} 37580 -11760 0 0 {name=X_43186_ }
C {devices/lab_pin.sym} 37540 -11610 0 0 {name=p37276 lab=_82635_/Q }
C {devices/lab_pin.sym} 37620 -11610 0 1 {name=p37277 lab=_78885_/A }
C {sky130_stdcells/inv_2.sym} 37580 -11610 0 0 {name=X_78883_ }
C {devices/lab_pin.sym} 37520 -11500 0 0 {name=p37278 lab=_82331_/Q }
C {devices/lab_pin.sym} 37520 -11460 0 0 {name=p37279 lab=_40385_/B }
C {devices/lab_pin.sym} 37640 -11480 0 1 {name=p37280 lab=_40398_/X }
C {sky130_stdcells/or2_4.sym} 37580 -11480 0 0 {name=X_40398_ }
C {devices/lab_pin.sym} 37520 -11380 0 0 {name=p37281 lab=_49807_/A }
C {devices/lab_pin.sym} 37520 -11340 0 0 {name=p37282 lab=_49802_/B }
C {devices/lab_pin.sym} 37520 -11300 0 0 {name=p37283 lab=_49795_/X }
C {devices/lab_pin.sym} 37520 -11260 0 0 {name=p37284 lab=_53015_/D }
C {devices/lab_pin.sym} 37640 -11320 0 1 {name=p37285 lab=_49802_/X }
C {sky130_stdcells/and4_4.sym} 37580 -11320 0 0 {name=X_49802_ }
C {devices/lab_pin.sym} 37540 -11170 0 0 {name=p37286 lab=_42137_/A }
C {devices/lab_pin.sym} 37620 -11170 0 1 {name=p37287 lab=_42137_/X }
C {sky130_stdcells/buf_2.sym} 37580 -11170 0 0 {name=X_42137_ }
C {devices/lab_pin.sym} 37520 -11060 0 0 {name=p37288 lab=_77847_/A }
C {devices/lab_pin.sym} 37520 -11020 0 0 {name=p37289 lab=_77833_/Y }
C {devices/lab_pin.sym} 37640 -11040 0 1 {name=p37290 lab=_77842_/A }
C {sky130_stdcells/xor2_4.sym} 37580 -11040 0 0 {name=X_77834_ }
C {devices/lab_pin.sym} 37540 -10910 0 0 {name=p37291 lab=_70209_/A }
C {devices/lab_pin.sym} 37620 -10910 0 1 {name=p37292 lab=_70169_/X }
C {sky130_stdcells/buf_2.sym} 37580 -10910 0 0 {name=X_70169_ }
C {devices/lab_pin.sym} 37540 -10790 0 0 {name=p37293 lab=_47872_/A }
C {devices/lab_pin.sym} 37620 -10790 0 1 {name=p37294 lab=_52573_/B }
C {sky130_stdcells/buf_2.sym} 37580 -10790 0 0 {name=X_47994_ }
C {devices/lab_pin.sym} 37540 -10670 0 0 {name=p37295 lab=_49678_/X }
C {devices/lab_pin.sym} 37620 -10670 0 1 {name=p37296 lab=_49751_/A }
C {sky130_stdcells/buf_2.sym} 37580 -10670 0 0 {name=X_49733_ }
C {devices/lab_pin.sym} 37500 -10570 0 0 {name=p37297 lab=_46939_/Y }
C {devices/lab_pin.sym} 37500 -10530 0 0 {name=p37298 lab=_46940_/X }
C {devices/lab_pin.sym} 37500 -10490 0 0 {name=p37299 lab=_46944_/X }
C {devices/lab_pin.sym} 37660 -10530 0 1 {name=p37300 lab=_46945_/Y }
C {sky130_stdcells/a21oi_4.sym} 37580 -10530 0 0 {name=X_46945_ }
C {devices/lab_pin.sym} 37540 -10390 0 0 {name=p37301 lab=_42067_/Y }
C {devices/lab_pin.sym} 37620 -10390 0 1 {name=p37302 lab=_88049_/D }
C {sky130_stdcells/inv_2.sym} 37580 -10390 0 0 {name=X_42068_ }
C {devices/lab_pin.sym} 37520 -10280 0 0 {name=p37303 lab=_77764_/B }
C {devices/lab_pin.sym} 37520 -10240 0 0 {name=p37304 lab=_77756_/Y }
C {devices/lab_pin.sym} 37640 -10260 0 1 {name=p37305 lab=_77765_/Y }
C {sky130_stdcells/nor2_4.sym} 37580 -10260 0 0 {name=X_77765_ }
C {devices/lab_pin.sym} 37500 -10170 0 0 {name=p37306 lab=_60259_/A }
C {devices/lab_pin.sym} 37500 -10130 0 0 {name=p37307 lab=_61694_/B }
C {devices/lab_pin.sym} 37500 -10090 0 0 {name=p37308 lab=_62926_/B }
C {devices/lab_pin.sym} 37500 -10050 0 0 {name=p37309 lab=_60281_/A }
C {devices/lab_pin.sym} 37500 -10010 0 0 {name=p37310 lab=_62186_/X }
C {devices/lab_pin.sym} 37660 -10090 0 1 {name=p37311 lab=_62991_/X }
C {sky130_stdcells/a32o_4.sym} 37580 -10090 0 0 {name=X_62991_ }
C {devices/lab_pin.sym} 37520 -9940 0 0 {name=p37312 lab=_74987_/A }
C {devices/lab_pin.sym} 37520 -9900 0 0 {name=p37313 lab=_74988_/A }
C {devices/lab_pin.sym} 37640 -9920 0 1 {name=p37314 lab=_74978_/B }
C {sky130_stdcells/xor2_4.sym} 37580 -9920 0 0 {name=X_74977_ }
C {devices/lab_pin.sym} 37520 -9800 0 0 {name=p37315 lab=_79500_/Y }
C {devices/lab_pin.sym} 37520 -9760 0 0 {name=p37316 lab=_79504_/B }
C {devices/lab_pin.sym} 37640 -9780 0 1 {name=p37317 lab=_79510_/B }
C {sky130_stdcells/xor2_4.sym} 37580 -9780 0 0 {name=X_79504_ }
C {devices/lab_pin.sym} 37520 -9660 0 0 {name=p37318 lab=_82290_/Q }
C {devices/lab_pin.sym} 37520 -9620 0 0 {name=p37319 lab=_41019_/B }
C {devices/lab_pin.sym} 37640 -9640 0 1 {name=p37320 lab=_41019_/X }
C {sky130_stdcells/or2_4.sym} 37580 -9640 0 0 {name=X_41019_ }
C {devices/lab_pin.sym} 37500 -9530 0 0 {name=p37321 lab=_64720_/X }
C {devices/lab_pin.sym} 37500 -9490 0 0 {name=p37322 lab=_64727_/X }
C {devices/lab_pin.sym} 37500 -9450 0 0 {name=p37323 lab=_64729_/X }
C {devices/lab_pin.sym} 37660 -9490 0 1 {name=p37324 lab=_64730_/X }
C {sky130_stdcells/a21o_4.sym} 37580 -9490 0 0 {name=X_64730_ }
C {devices/lab_pin.sym} 37520 -9360 0 0 {name=p37325 lab=_76714_/Y }
C {devices/lab_pin.sym} 37520 -9320 0 0 {name=p37326 lab=_76715_/Y }
C {devices/lab_pin.sym} 37640 -9340 0 1 {name=p37327 lab=_76725_/A }
C {sky130_stdcells/xor2_4.sym} 37580 -9340 0 0 {name=X_76716_ }
C {devices/lab_pin.sym} 37520 -9240 0 0 {name=p37328 lab=_49651_/X }
C {devices/lab_pin.sym} 37520 -9200 0 0 {name=p37329 lab=_49642_/B }
C {devices/lab_pin.sym} 37520 -9160 0 0 {name=p37330 lab=_49669_/C }
C {devices/lab_pin.sym} 37520 -9120 0 0 {name=p37331 lab=_52879_/D }
C {devices/lab_pin.sym} 37640 -9180 0 1 {name=p37332 lab=_49664_/X }
C {sky130_stdcells/and4_4.sym} 37580 -9180 0 0 {name=X_49664_ }
C {devices/lab_pin.sym} 37500 -9070 0 0 {name=p37333 lab=_61929_/X }
C {devices/lab_pin.sym} 37500 -9030 0 0 {name=p37334 lab=_61932_/X }
C {devices/lab_pin.sym} 37500 -8990 0 0 {name=p37335 lab=_61941_/Y }
C {devices/lab_pin.sym} 37500 -8950 0 0 {name=p37336 lab=_84740_/Q }
C {devices/lab_pin.sym} 37500 -8910 0 0 {name=p37337 lab=_61895_/X }
C {devices/lab_pin.sym} 37660 -8990 0 1 {name=p37338 lab=_61942_/Y }
C {sky130_stdcells/o32ai_4.sym} 37580 -8990 0 0 {name=X_61942_ }
C {devices/lab_pin.sym} 37500 -8860 0 0 {name=p37339 lab=_72744_/X }
C {devices/lab_pin.sym} 37500 -8820 0 0 {name=p37340 lab=_85618_/Q }
C {devices/lab_pin.sym} 37500 -8780 0 0 {name=p37341 lab=_72857_/X }
C {devices/lab_pin.sym} 37500 -8740 0 0 {name=p37342 lab=_73927_/X }
C {devices/lab_pin.sym} 37660 -8800 0 1 {name=p37343 lab=_73928_/X }
C {sky130_stdcells/a211o_4.sym} 37580 -8800 0 0 {name=X_73928_ }
C {devices/lab_pin.sym} 37520 -8680 0 0 {name=p37344 lab=_46868_/A }
C {devices/lab_pin.sym} 37520 -8640 0 0 {name=p37345 lab=_46845_/X }
C {devices/lab_pin.sym} 37520 -8600 0 0 {name=p37346 lab=_46868_/C }
C {devices/lab_pin.sym} 37520 -8560 0 0 {name=p37347 lab=_52724_/D }
C {devices/lab_pin.sym} 37640 -8620 0 1 {name=p37348 lab=_46876_/X }
C {sky130_stdcells/and4_4.sym} 37580 -8620 0 0 {name=X_46876_ }
C {devices/lab_pin.sym} 37500 -8490 0 0 {name=p37349 lab=_77693_/C }
C {devices/lab_pin.sym} 37500 -8450 0 0 {name=p37350 lab=_77693_/D }
C {devices/lab_pin.sym} 37500 -8410 0 0 {name=p37351 lab=_77680_/X }
C {devices/lab_pin.sym} 37660 -8450 0 1 {name=p37352 lab=_77703_/B }
C {sky130_stdcells/a21bo_4.sym} 37580 -8450 0 0 {name=X_77696_ }
C {devices/lab_pin.sym} 37540 -8310 0 0 {name=p37353 lab=_48615_/A }
C {devices/lab_pin.sym} 37620 -8310 0 1 {name=p37354 lab=_52216_/B }
C {sky130_stdcells/buf_2.sym} 37580 -8310 0 0 {name=X_48615_ }
C {devices/lab_pin.sym} 37520 -8200 0 0 {name=p37355 lab=_58653_/A }
C {devices/lab_pin.sym} 37520 -8160 0 0 {name=p37356 lab=_79435_/B }
C {devices/lab_pin.sym} 37640 -8180 0 1 {name=p37357 lab=_79444_/A }
C {sky130_stdcells/xor2_4.sym} 37580 -8180 0 0 {name=X_79435_ }
C {devices/lab_pin.sym} 37520 -8060 0 0 {name=p37358 lab=_85029_/Q }
C {devices/lab_pin.sym} 37520 -8020 0 0 {name=p37359 lab=_45827_/B }
C {devices/lab_pin.sym} 37640 -8040 0 1 {name=p37360 lab=_45827_/Y }
C {sky130_stdcells/nor2_4.sym} 37580 -8040 0 0 {name=X_45827_ }
C {devices/lab_pin.sym} 37500 -7930 0 0 {name=p37361 lab=_64561_/X }
C {devices/lab_pin.sym} 37500 -7890 0 0 {name=p37362 lab=_64649_/Y }
C {devices/lab_pin.sym} 37500 -7850 0 0 {name=p37363 lab=_64660_/Y }
C {devices/lab_pin.sym} 37660 -7890 0 1 {name=p37364 lab=_64661_/Y }
C {sky130_stdcells/o21ai_4.sym} 37580 -7890 0 0 {name=X_64661_ }
C {devices/lab_pin.sym} 37520 -7760 0 0 {name=p37365 lab=_81682_/Q }
C {devices/lab_pin.sym} 37520 -7720 0 0 {name=p37366 lab=_81394_/Q }
C {devices/lab_pin.sym} 37640 -7740 0 1 {name=p37367 lab=_76965_/A }
C {sky130_stdcells/xnor2_4.sym} 37580 -7740 0 0 {name=X_76647_ }
C {devices/lab_pin.sym} 37540 -7610 0 0 {name=p37368 lab=_61736_/A }
C {devices/lab_pin.sym} 37620 -7610 0 1 {name=p37369 lab=_61879_/A }
C {sky130_stdcells/buf_2.sym} 37580 -7610 0 0 {name=X_61873_ }
C {devices/lab_pin.sym} 37500 -7510 0 0 {name=p37370 lab=_86358_/Q }
C {devices/lab_pin.sym} 37500 -7470 0 0 {name=p37371 lab=_49579_/X }
C {devices/lab_pin.sym} 37500 -7430 0 0 {name=p37372 lab=_49594_/Y }
C {devices/lab_pin.sym} 37660 -7470 0 1 {name=p37373 lab=_49595_/Y }
C {sky130_stdcells/o21ai_4.sym} 37580 -7470 0 0 {name=X_49595_ }
C {devices/lab_pin.sym} 37540 -7330 0 0 {name=p37374 lab=_73614_/A }
C {devices/lab_pin.sym} 37620 -7330 0 1 {name=p37375 lab=_73859_/X }
C {sky130_stdcells/buf_2.sym} 37580 -7330 0 0 {name=X_73859_ }
C {devices/lab_pin.sym} 37540 -7210 0 0 {name=p37376 lab=_66262_/A }
C {devices/lab_pin.sym} 37620 -7210 0 1 {name=p37377 lab=_66402_/B }
C {sky130_stdcells/buf_2.sym} 37580 -7210 0 0 {name=X_66400_ }
C {devices/lab_pin.sym} 37500 -7120 0 0 {name=p37378 lab=_61568_/B }
C {devices/lab_pin.sym} 37500 -7080 0 0 {name=p37379 lab=_63609_/X }
C {devices/lab_pin.sym} 37500 -7040 0 0 {name=p37380 lab=_63610_/X }
C {devices/lab_pin.sym} 37500 -7000 0 0 {name=p37381 lab=_63611_/Y }
C {devices/lab_pin.sym} 37660 -7060 0 1 {name=p37382 lab=_63612_/X }
C {sky130_stdcells/a211o_4.sym} 37580 -7060 0 0 {name=X_63612_ }
C {devices/lab_pin.sym} 37520 -6930 0 0 {name=p37383 lab=_52182_/A }
C {devices/lab_pin.sym} 37520 -6890 0 0 {name=p37384 lab=_48500_/X }
C {devices/lab_pin.sym} 37520 -6850 0 0 {name=p37385 lab=_48610_/C }
C {devices/lab_pin.sym} 37640 -6890 0 1 {name=p37386 lab=_48546_/X }
C {sky130_stdcells/and3_4.sym} 37580 -6890 0 0 {name=X_48546_ }
C {devices/lab_pin.sym} 37540 -6750 0 0 {name=p37387 lab=_60823_/Y }
C {devices/lab_pin.sym} 37620 -6750 0 1 {name=p37388 lab=_60824_/Y }
C {sky130_stdcells/inv_2.sym} 37580 -6750 0 0 {name=X_60824_ }
C {devices/lab_pin.sym} 37540 -6630 0 0 {name=p37389 lab=_67144_/A }
C {devices/lab_pin.sym} 37620 -6630 0 1 {name=p37390 lab=_67381_/A }
C {sky130_stdcells/buf_2.sym} 37580 -6630 0 0 {name=X_67380_ }
C {devices/lab_pin.sym} 37520 -6520 0 0 {name=p37391 lab=_79350_/X }
C {devices/lab_pin.sym} 37520 -6480 0 0 {name=p37392 lab=_79353_/Y }
C {devices/lab_pin.sym} 37640 -6500 0 1 {name=p37393 lab=_79366_/X }
C {sky130_stdcells/or2_4.sym} 37580 -6500 0 0 {name=X_79366_ }
C {devices/lab_pin.sym} 37500 -6390 0 0 {name=p37394 lab=_45754_/X }
C {devices/lab_pin.sym} 37500 -6350 0 0 {name=p37395 lab=_45756_/Y }
C {devices/lab_pin.sym} 37500 -6310 0 0 {name=p37396 lab=_45757_/X }
C {devices/lab_pin.sym} 37660 -6350 0 1 {name=p37397 lab=_45758_/X }
C {sky130_stdcells/a21o_4.sym} 37580 -6350 0 0 {name=X_45758_ }
C {devices/lab_pin.sym} 37540 -6210 0 0 {name=p37398 lab=_64803_/A }
C {devices/lab_pin.sym} 37620 -6210 0 1 {name=p37399 lab=_64593_/A }
C {sky130_stdcells/buf_2.sym} 37580 -6210 0 0 {name=X_64592_ }
C {devices/lab_pin.sym} 37500 -6110 0 0 {name=p37400 lab=_76550_/Y }
C {devices/lab_pin.sym} 37500 -6070 0 0 {name=p37401 lab=_76554_/B }
C {devices/lab_pin.sym} 37500 -6030 0 0 {name=p37402 lab=_76552_/Y }
C {devices/lab_pin.sym} 37660 -6070 0 1 {name=p37403 lab=_76578_/X }
C {sky130_stdcells/o21a_4.sym} 37580 -6070 0 0 {name=X_76578_ }
C {devices/lab_pin.sym} 37540 -5930 0 0 {name=p37404 lab=_84140_/Q }
C {devices/lab_pin.sym} 37620 -5930 0 1 {name=p37405 lab=_66332_/C }
C {sky130_stdcells/inv_2.sym} 37580 -5930 0 0 {name=X_66331_ }
C {devices/lab_pin.sym} 37500 -5830 0 0 {name=p37406 lab=_78318_/A }
C {devices/lab_pin.sym} 37500 -5790 0 0 {name=p37407 lab=_78335_/B }
C {devices/lab_pin.sym} 37500 -5750 0 0 {name=p37408 lab=_78318_/B }
C {devices/lab_pin.sym} 37660 -5790 0 1 {name=p37409 lab=_78317_/X }
C {sky130_stdcells/a21o_4.sym} 37580 -5790 0 0 {name=X_78317_ }
C {devices/lab_pin.sym} 37540 -5650 0 0 {name=p37410 lab=_44709_/A }
C {devices/lab_pin.sym} 37620 -5650 0 1 {name=p37411 lab=_44709_/Y }
C {sky130_stdcells/inv_2.sym} 37580 -5650 0 0 {name=X_44709_ }
C {devices/lab_pin.sym} 37520 -5550 0 0 {name=p37412 lab=_63554_/A }
C {devices/lab_pin.sym} 37520 -5510 0 0 {name=p37413 lab=_63554_/B }
C {devices/lab_pin.sym} 37520 -5470 0 0 {name=p37414 lab=_80475_/B }
C {devices/lab_pin.sym} 37640 -5510 0 1 {name=p37415 lab=_63543_/Y }
C {sky130_stdcells/nor3_4.sym} 37580 -5510 0 0 {name=X_63543_ }
C {devices/lab_pin.sym} 37540 -5370 0 0 {name=p37416 lab=_75528_/B }
C {devices/lab_pin.sym} 37620 -5370 0 1 {name=p37417 lab=_75530_/A }
C {sky130_stdcells/inv_2.sym} 37580 -5370 0 0 {name=X_75529_ }
C {devices/lab_pin.sym} 37500 -5270 0 0 {name=p37418 lab=_48470_/Y }
C {devices/lab_pin.sym} 37500 -5230 0 0 {name=p37419 lab=_48459_/X }
C {devices/lab_pin.sym} 37500 -5190 0 0 {name=p37420 lab=_48476_/X }
C {devices/lab_pin.sym} 37660 -5230 0 1 {name=p37421 lab=_48477_/Y }
C {sky130_stdcells/a21oi_4.sym} 37580 -5230 0 0 {name=X_48477_ }
C {devices/lab_pin.sym} 37520 -5110 0 0 {name=p37422 lab=_60761_/A }
C {devices/lab_pin.sym} 37520 -5070 0 0 {name=p37423 lab=_60752_/B }
C {devices/lab_pin.sym} 37520 -5030 0 0 {name=p37424 lab=_60755_/C }
C {devices/lab_pin.sym} 37640 -5070 0 1 {name=p37425 lab=_60755_/Y }
C {sky130_stdcells/nor3_4.sym} 37580 -5070 0 0 {name=X_60755_ }
C {devices/lab_pin.sym} 37520 -4940 0 0 {name=p37426 lab=_79297_/A }
C {devices/lab_pin.sym} 37520 -4900 0 0 {name=p37427 lab=_79296_/Y }
C {devices/lab_pin.sym} 37640 -4920 0 1 {name=p37428 lab=_82828_/D }
C {sky130_stdcells/xor2_4.sym} 37580 -4920 0 0 {name=X_79297_ }
C {devices/lab_pin.sym} 37520 -4800 0 0 {name=p37429 lab=_85070_/Q }
C {devices/lab_pin.sym} 37520 -4760 0 0 {name=p37430 lab=_45801_/A }
C {devices/lab_pin.sym} 37640 -4780 0 1 {name=p37431 lab=_45689_/Y }
C {sky130_stdcells/nor2_4.sym} 37580 -4780 0 0 {name=X_45689_ }
C {devices/lab_pin.sym} 37520 -4660 0 0 {name=p37432 lab=_69047_/X }
C {devices/lab_pin.sym} 37520 -4620 0 0 {name=p37433 lab=_69049_/X }
C {devices/lab_pin.sym} 37640 -4640 0 1 {name=p37434 lab=_69050_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -4640 0 0 {name=X_69050_ }
C {devices/lab_pin.sym} 37500 -4530 0 0 {name=p37435 lab=_47423_/Y }
C {devices/lab_pin.sym} 37500 -4490 0 0 {name=p37436 lab=_47414_/X }
C {devices/lab_pin.sym} 37500 -4450 0 0 {name=p37437 lab=_47427_/X }
C {devices/lab_pin.sym} 37660 -4490 0 1 {name=p37438 lab=_86636_/D }
C {sky130_stdcells/a21oi_4.sym} 37580 -4490 0 0 {name=X_47428_ }
C {devices/lab_pin.sym} 37540 -4350 0 0 {name=p37439 lab=_66262_/A }
C {devices/lab_pin.sym} 37620 -4350 0 1 {name=p37440 lab=_66389_/B }
C {sky130_stdcells/buf_2.sym} 37580 -4350 0 0 {name=X_66262_ }
C {devices/lab_pin.sym} 37520 -4240 0 0 {name=p37441 lab=_78248_/A }
C {devices/lab_pin.sym} 37520 -4200 0 0 {name=p37442 lab=_78248_/B }
C {devices/lab_pin.sym} 37640 -4220 0 1 {name=p37443 lab=_78251_/A }
C {sky130_stdcells/nor2_4.sym} 37580 -4220 0 0 {name=X_78248_ }
C {devices/lab_pin.sym} 37520 -4100 0 0 {name=p37444 lab=_63488_/A }
C {devices/lab_pin.sym} 37520 -4060 0 0 {name=p37445 lab=_61876_/X }
C {devices/lab_pin.sym} 37640 -4080 0 1 {name=p37446 lab=_63474_/X }
C {sky130_stdcells/and2_4.sym} 37580 -4080 0 0 {name=X_63474_ }
C {devices/lab_pin.sym} 37500 -3970 0 0 {name=p37447 lab=_60646_/Y }
C {devices/lab_pin.sym} 37500 -3930 0 0 {name=p37448 lab=_60677_/A }
C {devices/lab_pin.sym} 37500 -3890 0 0 {name=p37449 lab=_60713_/A }
C {devices/lab_pin.sym} 37660 -3930 0 1 {name=p37450 lab=_60686_/X }
C {sky130_stdcells/a21o_4.sym} 37580 -3930 0 0 {name=X_60686_ }
C {devices/lab_pin.sym} 37500 -3820 0 0 {name=p37451 lab=_87447_/Q }
C {devices/lab_pin.sym} 37500 -3780 0 0 {name=p37452 lab=_67953_/X }
C {devices/lab_pin.sym} 37500 -3740 0 0 {name=p37453 lab=_67954_/X }
C {devices/lab_pin.sym} 37500 -3700 0 0 {name=p37454 lab=_68000_/X }
C {devices/lab_pin.sym} 37660 -3760 0 1 {name=p37455 lab=_68001_/X }
C {sky130_stdcells/a211o_4.sym} 37580 -3760 0 0 {name=X_68001_ }
C {devices/lab_pin.sym} 37520 -3620 0 0 {name=p37456 lab=_65159_/A }
C {devices/lab_pin.sym} 37520 -3580 0 0 {name=p37457 lab=_86026_/Q }
C {devices/lab_pin.sym} 37640 -3600 0 1 {name=p37458 lab=_65213_/X }
C {sky130_stdcells/and2_4.sym} 37580 -3600 0 0 {name=X_65213_ }
C {devices/lab_pin.sym} 37500 -3510 0 0 {name=p37459 lab=_62416_/X }
C {devices/lab_pin.sym} 37500 -3470 0 0 {name=p37460 lab=_62421_/Y }
C {devices/lab_pin.sym} 37500 -3430 0 0 {name=p37461 lab=_62424_/X }
C {devices/lab_pin.sym} 37500 -3390 0 0 {name=p37462 lab=_84739_/Q }
C {devices/lab_pin.sym} 37500 -3350 0 0 {name=p37463 lab=_62367_/X }
C {devices/lab_pin.sym} 37660 -3430 0 1 {name=p37464 lab=_62425_/Y }
C {sky130_stdcells/o32ai_4.sym} 37580 -3430 0 0 {name=X_62425_ }
C {devices/lab_pin.sym} 37540 -3270 0 0 {name=p37465 lab=_47359_/A }
C {devices/lab_pin.sym} 37620 -3270 0 1 {name=p37466 lab=_47360_/A }
C {sky130_stdcells/inv_2.sym} 37580 -3270 0 0 {name=X_47359_ }
C {devices/lab_pin.sym} 37520 -3170 0 0 {name=p37467 lab=_66177_/A }
C {devices/lab_pin.sym} 37520 -3130 0 0 {name=p37468 lab=_66164_/B }
C {devices/lab_pin.sym} 37520 -3090 0 0 {name=p37469 lab=_66193_/C }
C {devices/lab_pin.sym} 37640 -3130 0 1 {name=p37470 lab=_66193_/Y }
C {sky130_stdcells/nor3_4.sym} 37580 -3130 0 0 {name=X_66193_ }
C {devices/lab_pin.sym} 37500 -3010 0 0 {name=p37471 lab=_78170_/Y }
C {devices/lab_pin.sym} 37500 -2970 0 0 {name=p37472 lab=_78177_/Y }
C {devices/lab_pin.sym} 37500 -2930 0 0 {name=p37473 lab=_78178_/Y }
C {devices/lab_pin.sym} 37660 -2970 0 1 {name=p37474 lab=_78179_/X }
C {sky130_stdcells/o21a_4.sym} 37580 -2970 0 0 {name=X_78179_ }
C {devices/lab_pin.sym} 37500 -2850 0 0 {name=p37475 lab=_80197_/Y }
C {devices/lab_pin.sym} 37500 -2810 0 0 {name=p37476 lab=_80201_/Y }
C {devices/lab_pin.sym} 37500 -2770 0 0 {name=p37477 lab=_80209_/X }
C {devices/lab_pin.sym} 37660 -2810 0 1 {name=p37478 lab=_80210_/Y }
C {sky130_stdcells/o21ai_4.sym} 37580 -2810 0 0 {name=X_80210_ }
C {devices/lab_pin.sym} 37520 -2680 0 0 {name=p37479 lab=_64946_/A }
C {devices/lab_pin.sym} 37520 -2640 0 0 {name=p37480 lab=_65144_/B }
C {devices/lab_pin.sym} 37640 -2660 0 1 {name=p37481 lab=_65144_/X }
C {sky130_stdcells/and2_4.sym} 37580 -2660 0 0 {name=X_65144_ }
C {devices/lab_pin.sym} 37520 -2540 0 0 {name=p37482 lab=_50383_/A }
C {devices/lab_pin.sym} 37520 -2500 0 0 {name=p37483 lab=_50370_/B }
C {devices/lab_pin.sym} 37640 -2520 0 1 {name=p37484 lab=_50370_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -2520 0 0 {name=X_50370_ }
C {devices/lab_pin.sym} 37520 -2420 0 0 {name=p37485 lab=_62344_/X }
C {devices/lab_pin.sym} 37520 -2380 0 0 {name=p37486 lab=_57660_/X }
C {devices/lab_pin.sym} 37520 -2340 0 0 {name=p37487 lab=_62315_/C }
C {devices/lab_pin.sym} 37520 -2300 0 0 {name=p37488 lab=_62355_/X }
C {devices/lab_pin.sym} 37640 -2360 0 1 {name=p37489 lab=_62356_/X }
C {sky130_stdcells/and4_4.sym} 37580 -2360 0 0 {name=X_62356_ }
C {devices/lab_pin.sym} 37490 -2210 0 0 {name=p37490 lab=_81190_/CLK }
C {devices/lab_pin.sym} 37490 -2190 0 0 {name=p37491 lab=_74927_/X }
C {devices/lab_pin.sym} 37670 -2210 0 1 {name=p37492 lab=_49161_/A }
C {sky130_stdcells/dfxtp_4.sym} 37580 -2200 0 0 {name=X_81190_ }
C {devices/lab_pin.sym} 37540 -2070 0 0 {name=p37493 lab=clkbuf_9_185_0_CLK/X }
C {devices/lab_pin.sym} 37620 -2070 0 1 {name=p37494 lab=_83049_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 37580 -2070 0 0 {name=Xclkbuf_10_371_0_CLK }
C {devices/lab_pin.sym} 37520 -1960 0 0 {name=p37495 lab=_49029_/A }
C {devices/lab_pin.sym} 37520 -1920 0 0 {name=p37496 lab=_49029_/B }
C {devices/lab_pin.sym} 37640 -1940 0 1 {name=p37497 lab=_49029_/Y }
C {sky130_stdcells/nor2_4.sym} 37580 -1940 0 0 {name=X_49029_ }
C {devices/lab_pin.sym} 37500 -1830 0 0 {name=p37498 lab=_61295_/A }
C {devices/lab_pin.sym} 37500 -1790 0 0 {name=p37499 lab=_72540_/B }
C {devices/lab_pin.sym} 37500 -1750 0 0 {name=p37500 lab=_72503_/A }
C {devices/lab_pin.sym} 37660 -1790 0 1 {name=p37501 lab=_61308_/A }
C {sky130_stdcells/o21a_4.sym} 37580 -1790 0 0 {name=X_61307_ }
C {devices/lab_pin.sym} 37520 -1660 0 0 {name=p37502 lab=_80132_/X }
C {devices/lab_pin.sym} 37520 -1620 0 0 {name=p37503 lab=_80141_/B }
C {devices/lab_pin.sym} 37640 -1640 0 1 {name=p37504 lab=_80141_/Y }
C {sky130_stdcells/nand2_4.sym} 37580 -1640 0 0 {name=X_80141_ }
C {devices/lab_pin.sym} 37500 -1530 0 0 {name=p37505 lab=_69535_/X }
C {devices/lab_pin.sym} 37500 -1490 0 0 {name=p37506 lab=_69537_/X }
C {devices/lab_pin.sym} 37500 -1450 0 0 {name=p37507 lab=_69939_/X }
C {devices/lab_pin.sym} 37660 -1490 0 1 {name=p37508 lab=_69952_/Y }
C {sky130_stdcells/a21oi_4.sym} 37580 -1490 0 0 {name=X_69952_ }
C {devices/lab_pin.sym} 37500 -1380 0 0 {name=p37509 lab=_64971_/X }
C {devices/lab_pin.sym} 37500 -1340 0 0 {name=p37510 lab=_86127_/Q }
C {devices/lab_pin.sym} 37500 -1300 0 0 {name=p37511 lab=_64972_/X }
C {devices/lab_pin.sym} 37500 -1260 0 0 {name=p37512 lab=_65074_/X }
C {devices/lab_pin.sym} 37660 -1320 0 1 {name=p37513 lab=_65075_/X }
C {sky130_stdcells/a211o_4.sym} 37580 -1320 0 0 {name=X_65075_ }
C {devices/lab_pin.sym} 37520 -1200 0 0 {name=p37514 lab=_62304_/A }
C {devices/lab_pin.sym} 37520 -1160 0 0 {name=p37515 lab=_58237_/X }
C {devices/lab_pin.sym} 37520 -1120 0 0 {name=p37516 lab=_62244_/C }
C {devices/lab_pin.sym} 37520 -1080 0 0 {name=p37517 lab=_62286_/X }
C {devices/lab_pin.sym} 37640 -1140 0 1 {name=p37518 lab=_62287_/X }
C {sky130_stdcells/and4_4.sym} 37580 -1140 0 0 {name=X_62287_ }
C {devices/lab_pin.sym} 37500 -1010 0 0 {name=p37519 lab=_52037_/Y }
C {devices/lab_pin.sym} 37500 -970 0 0 {name=p37520 lab=_51987_/X }
C {devices/lab_pin.sym} 37500 -930 0 0 {name=p37521 lab=_52039_/X }
C {devices/lab_pin.sym} 37660 -970 0 1 {name=p37522 lab=_85901_/D }
C {sky130_stdcells/a21oi_4.sym} 37580 -970 0 0 {name=X_52040_ }
C {devices/lab_pin.sym} 37500 -860 0 0 {name=p37523 lab=_87082_/Q }
C {devices/lab_pin.sym} 37500 -820 0 0 {name=p37524 lab=_68832_/X }
C {devices/lab_pin.sym} 37500 -780 0 0 {name=p37525 lab=_68875_/X }
C {devices/lab_pin.sym} 37500 -740 0 0 {name=p37526 lab=_68902_/X }
C {devices/lab_pin.sym} 37660 -800 0 1 {name=p37527 lab=_68903_/X }
C {sky130_stdcells/a211o_4.sym} 37580 -800 0 0 {name=X_68903_ }
C {devices/lab_pin.sym} 37540 -650 0 0 {name=p37528 lab=_64026_/A }
C {devices/lab_pin.sym} 37620 -650 0 1 {name=p37529 lab=_64091_/B }
C {sky130_stdcells/buf_2.sym} 37580 -650 0 0 {name=X_64026_ }
C {devices/lab_pin.sym} 38440 -42180 0 0 {name=p37530 lab=_61086_/X }
C {devices/lab_pin.sym} 38440 -42140 0 0 {name=p37531 lab=_61238_/B }
C {devices/lab_pin.sym} 38440 -42100 0 0 {name=p37532 lab=_61238_/C }
C {devices/lab_pin.sym} 38440 -42060 0 0 {name=p37533 lab=_64454_/B }
C {devices/lab_pin.sym} 38560 -42120 0 1 {name=p37534 lab=_61238_/Y }
C {sky130_stdcells/nand4_4.sym} 38500 -42120 0 0 {name=X_61238_ }
C {devices/lab_pin.sym} 38460 -41970 0 0 {name=p37535 lab=_80071_/X }
C {devices/lab_pin.sym} 38540 -41970 0 1 {name=p37536 lab=_80072_/Y }
C {sky130_stdcells/inv_2.sym} 38500 -41970 0 0 {name=X_80072_ }
C {devices/lab_pin.sym} 38440 -41860 0 0 {name=p37537 lab=_69791_/A }
C {devices/lab_pin.sym} 38440 -41820 0 0 {name=p37538 lab=_69883_/B }
C {devices/lab_pin.sym} 38560 -41840 0 1 {name=p37539 lab=_69883_/Y }
C {sky130_stdcells/nor2_4.sym} 38500 -41840 0 0 {name=X_69883_ }
C {devices/lab_pin.sym} 38460 -41710 0 0 {name=p37540 lab=clkbuf_9_493_0_CLK/A }
C {devices/lab_pin.sym} 38540 -41710 0 1 {name=p37541 lab=clkbuf_9_492_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 38500 -41710 0 0 {name=Xclkbuf_9_492_0_CLK }
C {devices/lab_pin.sym} 38410 -41590 0 0 {name=p37542 lab=_82116_/CLK }
C {devices/lab_pin.sym} 38410 -41570 0 0 {name=p37543 lab=_83900_/D }
C {devices/lab_pin.sym} 38590 -41590 0 1 {name=p37544 lab=_83900_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -41580 0 0 {name=X_83900_ }
C {devices/lab_pin.sym} 38420 -41480 0 0 {name=p37545 lab=_73985_/A }
C {devices/lab_pin.sym} 38420 -41440 0 0 {name=p37546 lab=_68832_/X }
C {devices/lab_pin.sym} 38420 -41400 0 0 {name=p37547 lab=_68762_/X }
C {devices/lab_pin.sym} 38420 -41360 0 0 {name=p37548 lab=_68833_/X }
C {devices/lab_pin.sym} 38580 -41420 0 1 {name=p37549 lab=_68834_/X }
C {sky130_stdcells/a211o_4.sym} 38500 -41420 0 0 {name=X_68834_ }
C {devices/lab_pin.sym} 38460 -41270 0 0 {name=p37550 lab=_64225_/B }
C {devices/lab_pin.sym} 38540 -41270 0 1 {name=p37551 lab=_61169_/X }
C {sky130_stdcells/buf_2.sym} 38500 -41270 0 0 {name=X_61169_ }
C {devices/lab_pin.sym} 38410 -41150 0 0 {name=p37552 lab=_84849_/CLK }
C {devices/lab_pin.sym} 38410 -41130 0 0 {name=p37553 lab=_84880_/D }
C {devices/lab_pin.sym} 38590 -41150 0 1 {name=p37554 lab=_84880_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -41140 0 0 {name=X_84880_ }
C {devices/lab_pin.sym} 38460 -41010 0 0 {name=p37555 lab=clkbuf_9_193_0_CLK/X }
C {devices/lab_pin.sym} 38540 -41010 0 1 {name=p37556 lab=_84333_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 38500 -41010 0 0 {name=Xclkbuf_10_386_0_CLK }
C {devices/lab_pin.sym} 38410 -40890 0 0 {name=p37557 lab=_83188_/CLK }
C {devices/lab_pin.sym} 38410 -40870 0 0 {name=p37558 lab=_83831_/D }
C {devices/lab_pin.sym} 38590 -40890 0 1 {name=p37559 lab=_83831_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -40880 0 0 {name=X_83831_ }
C {devices/lab_pin.sym} 38420 -40770 0 0 {name=p37560 lab=_68761_/X }
C {devices/lab_pin.sym} 38420 -40730 0 0 {name=p37561 lab=_68764_/X }
C {devices/lab_pin.sym} 38420 -40690 0 0 {name=p37562 lab=_68661_/X }
C {devices/lab_pin.sym} 38580 -40730 0 1 {name=p37563 lab=_68765_/Y }
C {sky130_stdcells/a21oi_4.sym} 38500 -40730 0 0 {name=X_68765_ }
C {devices/lab_pin.sym} 38440 -40600 0 0 {name=p37564 lab=_53991_/A }
C {devices/lab_pin.sym} 38440 -40560 0 0 {name=p37565 lab=_46367_/Y }
C {devices/lab_pin.sym} 38560 -40580 0 1 {name=p37566 lab=_53991_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -40580 0 0 {name=X_53991_ }
C {devices/lab_pin.sym} 38440 -40460 0 0 {name=p37567 lab=_65878_/A }
C {devices/lab_pin.sym} 38440 -40420 0 0 {name=p37568 lab=_65977_/B }
C {devices/lab_pin.sym} 38560 -40440 0 1 {name=p37569 lab=_65977_/X }
C {sky130_stdcells/and2_4.sym} 38500 -40440 0 0 {name=X_65977_ }
C {devices/lab_pin.sym} 38440 -40320 0 0 {name=p37570 lab=_55235_/A }
C {devices/lab_pin.sym} 38440 -40280 0 0 {name=p37571 lab=_55730_/B }
C {devices/lab_pin.sym} 38560 -40300 0 1 {name=p37572 lab=_55730_/X }
C {sky130_stdcells/and2_4.sym} 38500 -40300 0 0 {name=X_55730_ }
C {devices/lab_pin.sym} 38460 -40170 0 0 {name=p37573 lab=_68057_/A }
C {devices/lab_pin.sym} 38540 -40170 0 1 {name=p37574 lab=_68640_/A }
C {sky130_stdcells/buf_2.sym} 38500 -40170 0 0 {name=X_67716_ }
C {devices/lab_pin.sym} 38410 -40050 0 0 {name=p37575 lab=_85915_/CLK }
C {devices/lab_pin.sym} 38410 -40030 0 0 {name=p37576 lab=_86550_/D }
C {devices/lab_pin.sym} 38590 -40050 0 1 {name=p37577 lab=_73833_/B }
C {sky130_stdcells/dfxtp_4.sym} 38500 -40040 0 0 {name=X_86550_ }
C {devices/lab_pin.sym} 38440 -39940 0 0 {name=p37578 lab=_52922_/A }
C {devices/lab_pin.sym} 38440 -39900 0 0 {name=p37579 lab=_52954_/B }
C {devices/lab_pin.sym} 38440 -39860 0 0 {name=p37580 lab=_52926_/X }
C {devices/lab_pin.sym} 38440 -39820 0 0 {name=p37581 lab=_52942_/D }
C {devices/lab_pin.sym} 38560 -39880 0 1 {name=p37582 lab=_52942_/X }
C {sky130_stdcells/and4_4.sym} 38500 -39880 0 0 {name=X_52942_ }
C {devices/lab_pin.sym} 38460 -39730 0 0 {name=p37583 lab=_64777_/A }
C {devices/lab_pin.sym} 38540 -39730 0 1 {name=p37584 lab=_64929_/A }
C {sky130_stdcells/buf_2.sym} 38500 -39730 0 0 {name=X_64928_ }
C {devices/lab_pin.sym} 38410 -39610 0 0 {name=p37585 lab=_83476_/CLK }
C {devices/lab_pin.sym} 38410 -39590 0 0 {name=p37586 lab=_83762_/D }
C {devices/lab_pin.sym} 38590 -39610 0 1 {name=p37587 lab=_58372_/A }
C {sky130_stdcells/dfxtp_4.sym} 38500 -39600 0 0 {name=X_83762_ }
C {devices/lab_pin.sym} 38410 -39470 0 0 {name=p37588 lab=_81059_/CLK }
C {devices/lab_pin.sym} 38410 -39450 0 0 {name=p37589 lab=_75686_/X }
C {devices/lab_pin.sym} 38590 -39470 0 1 {name=p37590 lab=_75079_/B }
C {sky130_stdcells/dfxtp_4.sym} 38500 -39460 0 0 {name=X_80974_ }
C {devices/lab_pin.sym} 38420 -39360 0 0 {name=p37591 lab=_73873_/A }
C {devices/lab_pin.sym} 38420 -39320 0 0 {name=p37592 lab=_68640_/X }
C {devices/lab_pin.sym} 38420 -39280 0 0 {name=p37593 lab=_68070_/X }
C {devices/lab_pin.sym} 38420 -39240 0 0 {name=p37594 lab=_68695_/Y }
C {devices/lab_pin.sym} 38580 -39300 0 1 {name=p37595 lab=_68696_/X }
C {sky130_stdcells/a211o_4.sym} 38500 -39300 0 0 {name=X_68696_ }
C {devices/lab_pin.sym} 38410 -39150 0 0 {name=p37596 lab=_85499_/CLK }
C {devices/lab_pin.sym} 38410 -39130 0 0 {name=p37597 lab=_85501_/D }
C {devices/lab_pin.sym} 38590 -39150 0 1 {name=p37598 lab=_85501_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -39140 0 0 {name=X_85501_ }
C {devices/lab_pin.sym} 38410 -39010 0 0 {name=p37599 lab=_82803_/CLK }
C {devices/lab_pin.sym} 38410 -38990 0 0 {name=p37600 lab=_82713_/D }
C {devices/lab_pin.sym} 38590 -39010 0 1 {name=p37601 lab=_82669_/D }
C {sky130_stdcells/dfxtp_4.sym} 38500 -39000 0 0 {name=X_82713_ }
C {devices/lab_pin.sym} 38440 -38880 0 0 {name=p37602 lab=_67696_/A }
C {devices/lab_pin.sym} 38440 -38840 0 0 {name=p37603 lab=_67647_/B }
C {devices/lab_pin.sym} 38560 -38860 0 1 {name=p37604 lab=_67647_/X }
C {sky130_stdcells/and2_4.sym} 38500 -38860 0 0 {name=X_67647_ }
C {devices/lab_pin.sym} 38420 -38750 0 0 {name=p37605 lab=_55652_/Y }
C {devices/lab_pin.sym} 38420 -38710 0 0 {name=p37606 lab=_55654_/X }
C {devices/lab_pin.sym} 38420 -38670 0 0 {name=p37607 lab=_55660_/Y }
C {devices/lab_pin.sym} 38580 -38710 0 1 {name=p37608 lab=_55661_/X }
C {sky130_stdcells/o21a_4.sym} 38500 -38710 0 0 {name=X_55661_ }
C {devices/lab_pin.sym} 38410 -38570 0 0 {name=p37609 lab=_86191_/CLK }
C {devices/lab_pin.sym} 38410 -38550 0 0 {name=p37610 lab=_86481_/D }
C {devices/lab_pin.sym} 38590 -38570 0 1 {name=p37611 lab=_86481_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -38560 0 0 {name=X_86481_ }
C {devices/lab_pin.sym} 38420 -38450 0 0 {name=p37612 lab=_52870_/Y }
C {devices/lab_pin.sym} 38420 -38410 0 0 {name=p37613 lab=_52865_/X }
C {devices/lab_pin.sym} 38420 -38370 0 0 {name=p37614 lab=_52872_/X }
C {devices/lab_pin.sym} 38580 -38410 0 1 {name=p37615 lab=_52873_/Y }
C {sky130_stdcells/a21oi_4.sym} 38500 -38410 0 0 {name=X_52873_ }
C {devices/lab_pin.sym} 38460 -38270 0 0 {name=p37616 lab=_64679_/A }
C {devices/lab_pin.sym} 38540 -38270 0 1 {name=p37617 lab=_64859_/X }
C {sky130_stdcells/buf_2.sym} 38500 -38270 0 0 {name=X_64859_ }
C {devices/lab_pin.sym} 38410 -38150 0 0 {name=p37618 lab=_82381_/CLK }
C {devices/lab_pin.sym} 38410 -38130 0 0 {name=p37619 lab=_83693_/D }
C {devices/lab_pin.sym} 38590 -38150 0 1 {name=p37620 lab=_47183_/A }
C {sky130_stdcells/dfxtp_4.sym} 38500 -38140 0 0 {name=X_83693_ }
C {devices/lab_pin.sym} 38460 -38010 0 0 {name=p37621 lab=_44308_/X }
C {devices/lab_pin.sym} 38540 -38010 0 1 {name=p37622 lab=_57400_/X }
C {sky130_stdcells/buf_2.sym} 38500 -38010 0 0 {name=X_57400_ }
C {devices/lab_pin.sym} 38410 -37890 0 0 {name=p37623 lab=_88220_/CLK }
C {devices/lab_pin.sym} 38410 -37870 0 0 {name=p37624 lab=_41410_/Y }
C {devices/lab_pin.sym} 38590 -37890 0 1 {name=p37625 lab=_88220_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -37880 0 0 {name=X_88220_ }
C {devices/lab_pin.sym} 38440 -37780 0 0 {name=p37626 lab=_54589_/X }
C {devices/lab_pin.sym} 38440 -37740 0 0 {name=p37627 lab=_54607_/B }
C {devices/lab_pin.sym} 38440 -37700 0 0 {name=p37628 lab=_54591_/C }
C {devices/lab_pin.sym} 38440 -37660 0 0 {name=p37629 lab=_54612_/D }
C {devices/lab_pin.sym} 38560 -37720 0 1 {name=p37630 lab=_54612_/X }
C {sky130_stdcells/and4_4.sym} 38500 -37720 0 0 {name=X_54612_ }
C {devices/lab_pin.sym} 38410 -37570 0 0 {name=p37631 lab=_85431_/CLK }
C {devices/lab_pin.sym} 38410 -37550 0 0 {name=p37632 lab=_85432_/D }
C {devices/lab_pin.sym} 38590 -37570 0 1 {name=p37633 lab=_85432_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -37560 0 0 {name=X_85432_ }
C {devices/lab_pin.sym} 38440 -37460 0 0 {name=p37634 lab=_51805_/A }
C {devices/lab_pin.sym} 38440 -37420 0 0 {name=p37635 lab=_51815_/B }
C {devices/lab_pin.sym} 38440 -37380 0 0 {name=p37636 lab=_51810_/C }
C {devices/lab_pin.sym} 38440 -37340 0 0 {name=p37637 lab=_46744_/X }
C {devices/lab_pin.sym} 38560 -37400 0 1 {name=p37638 lab=_51824_/X }
C {sky130_stdcells/and4_4.sym} 38500 -37400 0 0 {name=X_51824_ }
C {devices/lab_pin.sym} 38440 -37260 0 0 {name=p37639 lab=_58380_/A }
C {devices/lab_pin.sym} 38440 -37220 0 0 {name=p37640 lab=_58369_/X }
C {devices/lab_pin.sym} 38560 -37240 0 1 {name=p37641 lab=_58380_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -37240 0 0 {name=X_58380_ }
C {devices/lab_pin.sym} 38410 -37110 0 0 {name=p37642 lab=_82642_/CLK }
C {devices/lab_pin.sym} 38410 -37090 0 0 {name=p37643 lab=_82644_/D }
C {devices/lab_pin.sym} 38590 -37110 0 1 {name=p37644 lab=_78966_/A }
C {sky130_stdcells/dfxtp_4.sym} 38500 -37100 0 0 {name=X_82644_ }
C {devices/lab_pin.sym} 38440 -36980 0 0 {name=p37645 lab=_55592_/A }
C {devices/lab_pin.sym} 38440 -36940 0 0 {name=p37646 lab=_55592_/B }
C {devices/lab_pin.sym} 38560 -36960 0 1 {name=p37647 lab=_55592_/X }
C {sky130_stdcells/and2_4.sym} 38500 -36960 0 0 {name=X_55592_ }
C {devices/lab_pin.sym} 38460 -36830 0 0 {name=p37648 lab=_67222_/A }
C {devices/lab_pin.sym} 38540 -36830 0 1 {name=p37649 lab=_67675_/A }
C {sky130_stdcells/buf_2.sym} 38500 -36830 0 0 {name=X_67578_ }
C {devices/lab_pin.sym} 38460 -36710 0 0 {name=p37650 lab=clkbuf_9_430_0_CLK/A }
C {devices/lab_pin.sym} 38540 -36710 0 1 {name=p37651 lab=clkbuf_9_430_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 38500 -36710 0 0 {name=Xclkbuf_9_430_0_CLK }
C {devices/lab_pin.sym} 38440 -36610 0 0 {name=p37652 lab=_57331_/A }
C {devices/lab_pin.sym} 38440 -36570 0 0 {name=p37653 lab=_57331_/B }
C {devices/lab_pin.sym} 38440 -36530 0 0 {name=p37654 lab=_57331_/C }
C {devices/lab_pin.sym} 38560 -36570 0 1 {name=p37655 lab=_57331_/Y }
C {sky130_stdcells/nand3_4.sym} 38500 -36570 0 0 {name=X_57331_ }
C {devices/lab_pin.sym} 38420 -36460 0 0 {name=p37656 lab=_88038_/Q }
C {devices/lab_pin.sym} 38420 -36420 0 0 {name=p37657 lab=_69315_/X }
C {devices/lab_pin.sym} 38420 -36380 0 0 {name=p37658 lab=_69245_/X }
C {devices/lab_pin.sym} 38420 -36340 0 0 {name=p37659 lab=_69316_/X }
C {devices/lab_pin.sym} 38580 -36400 0 1 {name=p37660 lab=_69317_/X }
C {sky130_stdcells/a211o_4.sym} 38500 -36400 0 0 {name=X_69317_ }
C {devices/lab_pin.sym} 38410 -36250 0 0 {name=p37661 lab=_88215_/CLK }
C {devices/lab_pin.sym} 38410 -36230 0 0 {name=p37662 lab=_88151_/D }
C {devices/lab_pin.sym} 38590 -36250 0 1 {name=p37663 lab=_88151_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -36240 0 0 {name=X_88151_ }
C {devices/lab_pin.sym} 38420 -36130 0 0 {name=p37664 lab=_85423_/Q }
C {devices/lab_pin.sym} 38420 -36090 0 0 {name=p37665 lab=_54540_/X }
C {devices/lab_pin.sym} 38420 -36050 0 0 {name=p37666 lab=_54542_/Y }
C {devices/lab_pin.sym} 38580 -36090 0 1 {name=p37667 lab=_54543_/Y }
C {sky130_stdcells/o21ai_4.sym} 38500 -36090 0 0 {name=X_54543_ }
C {devices/lab_pin.sym} 38460 -35950 0 0 {name=p37668 lab=_69315_/A }
C {devices/lab_pin.sym} 38540 -35950 0 1 {name=p37669 lab=_66529_/X }
C {sky130_stdcells/buf_2.sym} 38500 -35950 0 0 {name=X_66529_ }
C {devices/lab_pin.sym} 38410 -35830 0 0 {name=p37670 lab=_83630_/CLK }
C {devices/lab_pin.sym} 38410 -35810 0 0 {name=p37671 lab=_54870_/Y }
C {devices/lab_pin.sym} 38590 -35830 0 1 {name=p37672 lab=_85363_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -35820 0 0 {name=X_85363_ }
C {devices/lab_pin.sym} 38460 -35690 0 0 {name=p37673 lab=_51781_/A }
C {devices/lab_pin.sym} 38540 -35690 0 1 {name=p37674 lab=_51755_/X }
C {sky130_stdcells/buf_2.sym} 38500 -35690 0 0 {name=X_51755_ }
C {devices/lab_pin.sym} 38410 -35570 0 0 {name=p37675 lab=_82575_/CLK }
C {devices/lab_pin.sym} 38410 -35550 0 0 {name=p37676 lab=_82607_/Q }
C {devices/lab_pin.sym} 38590 -35570 0 1 {name=p37677 lab=_78177_/A }
C {sky130_stdcells/dfxtp_4.sym} 38500 -35560 0 0 {name=X_82575_ }
C {devices/lab_pin.sym} 38460 -35430 0 0 {name=p37678 lab=clkbuf_9_162_0_CLK/X }
C {devices/lab_pin.sym} 38540 -35430 0 1 {name=p37679 lab=_83690_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 38500 -35430 0 0 {name=Xclkbuf_10_324_0_CLK }
C {devices/lab_pin.sym} 38410 -35310 0 0 {name=p37680 lab=_88272_/CLK }
C {devices/lab_pin.sym} 38410 -35290 0 0 {name=p37681 lab=_44455_/X }
C {devices/lab_pin.sym} 38590 -35310 0 1 {name=p37682 lab=_87102_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -35300 0 0 {name=X_87102_ }
C {devices/lab_pin.sym} 38410 -35170 0 0 {name=p37683 lab=_84314_/CLK }
C {devices/lab_pin.sym} 38410 -35150 0 0 {name=p37684 lab=_63555_/Y }
C {devices/lab_pin.sym} 38590 -35170 0 1 {name=p37685 lab=_63554_/C }
C {sky130_stdcells/dfxtp_4.sym} 38500 -35160 0 0 {name=X_84314_ }
C {devices/lab_pin.sym} 38460 -35030 0 0 {name=p37686 lab=_50742_/A }
C {devices/lab_pin.sym} 38540 -35030 0 1 {name=p37687 lab=_50706_/X }
C {sky130_stdcells/buf_2.sym} 38500 -35030 0 0 {name=X_50706_ }
C {devices/lab_pin.sym} 38420 -34940 0 0 {name=p37688 lab=_57261_/X }
C {devices/lab_pin.sym} 38420 -34900 0 0 {name=p37689 lab=_56639_/X }
C {devices/lab_pin.sym} 38420 -34860 0 0 {name=p37690 lab=_45600_/A }
C {devices/lab_pin.sym} 38420 -34820 0 0 {name=p37691 lab=_57236_/X }
C {devices/lab_pin.sym} 38580 -34880 0 1 {name=p37692 lab=_57262_/X }
C {sky130_stdcells/a2bb2o_4.sym} 38500 -34880 0 0 {name=X_57262_ }
C {devices/lab_pin.sym} 38410 -34730 0 0 {name=p37693 lab=_84079_/CLK }
C {devices/lab_pin.sym} 38410 -34710 0 0 {name=p37694 lab=_81526_/D }
C {devices/lab_pin.sym} 38590 -34730 0 1 {name=p37695 lab=_81526_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -34720 0 0 {name=X_81526_ }
C {devices/lab_pin.sym} 38460 -34590 0 0 {name=p37696 lab=_68517_/A }
C {devices/lab_pin.sym} 38540 -34590 0 1 {name=p37697 lab=_69248_/X }
C {sky130_stdcells/buf_2.sym} 38500 -34590 0 0 {name=X_69248_ }
C {devices/lab_pin.sym} 38410 -34470 0 0 {name=p37698 lab=_88081_/CLK }
C {devices/lab_pin.sym} 38410 -34450 0 0 {name=p37699 lab=_41985_/Y }
C {devices/lab_pin.sym} 38590 -34470 0 1 {name=p37700 lab=_88082_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -34460 0 0 {name=X_88082_ }
C {devices/lab_pin.sym} 38460 -34330 0 0 {name=p37701 lab=clkbuf_9_477_0_CLK/X }
C {devices/lab_pin.sym} 38540 -34330 0 1 {name=p37702 lab=_87820_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 38500 -34330 0 0 {name=Xclkbuf_10_954_0_CLK }
C {devices/lab_pin.sym} 38420 -34230 0 0 {name=p37703 lab=_85435_/Q }
C {devices/lab_pin.sym} 38420 -34190 0 0 {name=p37704 lab=_54457_/X }
C {devices/lab_pin.sym} 38420 -34150 0 0 {name=p37705 lab=_54473_/Y }
C {devices/lab_pin.sym} 38580 -34190 0 1 {name=p37706 lab=_54474_/Y }
C {sky130_stdcells/o21ai_4.sym} 38500 -34190 0 0 {name=X_54474_ }
C {devices/lab_pin.sym} 38410 -34050 0 0 {name=p37707 lab=_85192_/CLK }
C {devices/lab_pin.sym} 38410 -34030 0 0 {name=p37708 lab=_56111_/Y }
C {devices/lab_pin.sym} 38590 -34050 0 1 {name=p37709 lab=_55817_/B }
C {sky130_stdcells/dfxtp_4.sym} 38500 -34040 0 0 {name=X_85294_ }
C {devices/lab_pin.sym} 38440 -33920 0 0 {name=p37710 lab=_51697_/A }
C {devices/lab_pin.sym} 38440 -33880 0 0 {name=p37711 lab=_53209_/B }
C {devices/lab_pin.sym} 38560 -33900 0 1 {name=p37712 lab=_51686_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -33900 0 0 {name=X_51686_ }
C {devices/lab_pin.sym} 38460 -33770 0 0 {name=p37713 lab=_59061_/A }
C {devices/lab_pin.sym} 38540 -33770 0 1 {name=p37714 lab=_59001_/X }
C {sky130_stdcells/buf_2.sym} 38500 -33770 0 0 {name=X_59001_ }
C {devices/lab_pin.sym} 38460 -33650 0 0 {name=p37715 lab=_56252_/A }
C {devices/lab_pin.sym} 38540 -33650 0 1 {name=p37716 lab=_56214_/A }
C {sky130_stdcells/buf_2.sym} 38500 -33650 0 0 {name=X_56213_ }
C {devices/lab_pin.sym} 38410 -33530 0 0 {name=p37717 lab=_88301_/CLK }
C {devices/lab_pin.sym} 38410 -33510 0 0 {name=p37718 lab=_44612_/X }
C {devices/lab_pin.sym} 38590 -33530 0 1 {name=p37719 lab=_87033_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -33520 0 0 {name=X_87033_ }
C {devices/lab_pin.sym} 38420 -33410 0 0 {name=p37720 lab=_53423_/Y }
C {devices/lab_pin.sym} 38420 -33370 0 0 {name=p37721 lab=_53408_/X }
C {devices/lab_pin.sym} 38420 -33330 0 0 {name=p37722 lab=_53424_/X }
C {devices/lab_pin.sym} 38580 -33370 0 1 {name=p37723 lab=_53425_/Y }
C {sky130_stdcells/a21oi_4.sym} 38500 -33370 0 0 {name=X_53425_ }
C {devices/lab_pin.sym} 38410 -33230 0 0 {name=p37724 lab=_82436_/CLK }
C {devices/lab_pin.sym} 38410 -33210 0 0 {name=p37725 lab=_64453_/X }
C {devices/lab_pin.sym} 38590 -33230 0 1 {name=p37726 lab=_84245_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -33220 0 0 {name=X_84245_ }
C {devices/lab_pin.sym} 38420 -33110 0 0 {name=p37727 lab=_86162_/Q }
C {devices/lab_pin.sym} 38420 -33070 0 0 {name=p37728 lab=_50626_/X }
C {devices/lab_pin.sym} 38420 -33030 0 0 {name=p37729 lab=_50636_/Y }
C {devices/lab_pin.sym} 38580 -33070 0 1 {name=p37730 lab=_50637_/Y }
C {sky130_stdcells/o21ai_4.sym} 38500 -33070 0 0 {name=X_50637_ }
C {devices/lab_pin.sym} 38440 -32960 0 0 {name=p37731 lab=_56761_/X }
C {devices/lab_pin.sym} 38440 -32920 0 0 {name=p37732 lab=_56659_/Y }
C {devices/lab_pin.sym} 38440 -32880 0 0 {name=p37733 lab=_56894_/Y }
C {devices/lab_pin.sym} 38440 -32840 0 0 {name=p37734 lab=_57193_/D }
C {devices/lab_pin.sym} 38560 -32900 0 1 {name=p37735 lab=_57193_/Y }
C {sky130_stdcells/nand4_4.sym} 38500 -32900 0 0 {name=X_57193_ }
C {devices/lab_pin.sym} 38410 -32750 0 0 {name=p37736 lab=_81333_/CLK }
C {devices/lab_pin.sym} 38410 -32730 0 0 {name=p37737 lab=_76790_/B }
C {devices/lab_pin.sym} 38590 -32750 0 1 {name=p37738 lab=_81425_/D }
C {sky130_stdcells/dfxtp_4.sym} 38500 -32740 0 0 {name=X_81457_ }
C {devices/lab_pin.sym} 38440 -32620 0 0 {name=p37739 lab=_69179_/A }
C {devices/lab_pin.sym} 38440 -32580 0 0 {name=p37740 lab=_69179_/B }
C {devices/lab_pin.sym} 38560 -32600 0 1 {name=p37741 lab=_69179_/X }
C {sky130_stdcells/and2_4.sym} 38500 -32600 0 0 {name=X_69179_ }
C {devices/lab_pin.sym} 38460 -32470 0 0 {name=p37742 lab=clkbuf_9_444_0_CLK/A }
C {devices/lab_pin.sym} 38540 -32470 0 1 {name=p37743 lab=clkbuf_9_445_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 38500 -32470 0 0 {name=Xclkbuf_9_445_0_CLK }
C {devices/lab_pin.sym} 38460 -32350 0 0 {name=p37744 lab=_44267_/A }
C {devices/lab_pin.sym} 38540 -32350 0 1 {name=p37745 lab=_44266_/C }
C {sky130_stdcells/buf_2.sym} 38500 -32350 0 0 {name=Xpsn_inst_psn_buff_3 }
C {devices/lab_pin.sym} 38460 -32230 0 0 {name=p37746 lab=_71225_/A }
C {devices/lab_pin.sym} 38540 -32230 0 1 {name=p37747 lab=_71219_/C }
C {sky130_stdcells/buf_2.sym} 38500 -32230 0 0 {name=X_71210_ }
C {devices/lab_pin.sym} 38460 -32110 0 0 {name=p37748 lab=_56144_/A }
C {devices/lab_pin.sym} 38540 -32110 0 1 {name=p37749 lab=_56144_/X }
C {sky130_stdcells/buf_2.sym} 38500 -32110 0 0 {name=X_56144_ }
C {devices/lab_pin.sym} 38420 -32010 0 0 {name=p37750 lab=_80386_/Y }
C {devices/lab_pin.sym} 38420 -31970 0 0 {name=p37751 lab=_80404_/X }
C {devices/lab_pin.sym} 38420 -31930 0 0 {name=p37752 lab=_80407_/Y }
C {devices/lab_pin.sym} 38580 -31970 0 1 {name=p37753 lab=_80408_/Y }
C {sky130_stdcells/a21oi_4.sym} 38500 -31970 0 0 {name=X_80408_ }
C {devices/lab_pin.sym} 38460 -31830 0 0 {name=p37754 lab=_53221_/A }
C {devices/lab_pin.sym} 38540 -31830 0 1 {name=p37755 lab=_53357_/A }
C {sky130_stdcells/buf_2.sym} 38500 -31830 0 0 {name=X_53356_ }
C {devices/lab_pin.sym} 38420 -31730 0 0 {name=p37756 lab=_41324_/X }
C {devices/lab_pin.sym} 38420 -31690 0 0 {name=p37757 lab=_82897_/Q }
C {devices/lab_pin.sym} 38420 -31650 0 0 {name=p37758 lab=_41369_/X }
C {devices/lab_pin.sym} 38580 -31690 0 1 {name=p37759 lab=_41370_/Y }
C {sky130_stdcells/o21ai_4.sym} 38500 -31690 0 0 {name=X_41370_ }
C {devices/lab_pin.sym} 38420 -31590 0 0 {name=p37760 lab=_72172_/X }
C {devices/lab_pin.sym} 38420 -31550 0 0 {name=p37761 lab=_72187_/Y }
C {devices/lab_pin.sym} 38420 -31510 0 0 {name=p37762 lab=_72188_/Y }
C {devices/lab_pin.sym} 38420 -31470 0 0 {name=p37763 lab=_72189_/X }
C {devices/lab_pin.sym} 38420 -31430 0 0 {name=p37764 lab=_72176_/X }
C {devices/lab_pin.sym} 38580 -31510 0 1 {name=p37765 lab=_72190_/X }
C {sky130_stdcells/o32a_4.sym} 38500 -31510 0 0 {name=X_72190_ }
C {devices/lab_pin.sym} 38410 -31350 0 0 {name=p37766 lab=_84175_/CLK }
C {devices/lab_pin.sym} 38410 -31330 0 0 {name=p37767 lab=_84176_/D }
C {devices/lab_pin.sym} 38590 -31350 0 1 {name=p37768 lab=_65817_/C }
C {sky130_stdcells/dfxtp_4.sym} 38500 -31340 0 0 {name=X_84176_ }
C {devices/lab_pin.sym} 38460 -31210 0 0 {name=p37769 lab=clkbuf_9_169_0_CLK/X }
C {devices/lab_pin.sym} 38540 -31210 0 1 {name=p37770 lab=_83699_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 38500 -31210 0 0 {name=Xclkbuf_10_339_0_CLK }
C {devices/lab_pin.sym} 38440 -31110 0 0 {name=p37771 lab=_48894_/A }
C {devices/lab_pin.sym} 38440 -31070 0 0 {name=p37772 lab=_50560_/X }
C {devices/lab_pin.sym} 38440 -31030 0 0 {name=p37773 lab=_50568_/C }
C {devices/lab_pin.sym} 38560 -31070 0 1 {name=p37774 lab=_50568_/X }
C {sky130_stdcells/and3_4.sym} 38500 -31070 0 0 {name=X_50568_ }
C {devices/lab_pin.sym} 38410 -30930 0 0 {name=p37775 lab=_81482_/CLK }
C {devices/lab_pin.sym} 38410 -30910 0 0 {name=p37776 lab=_81388_/D }
C {devices/lab_pin.sym} 38590 -30930 0 1 {name=p37777 lab=_76884_/B }
C {sky130_stdcells/dfxtp_4.sym} 38500 -30920 0 0 {name=X_81388_ }
C {devices/lab_pin.sym} 38440 -30800 0 0 {name=p37778 lab=_52299_/A }
C {devices/lab_pin.sym} 38440 -30760 0 0 {name=p37779 lab=_52307_/B }
C {devices/lab_pin.sym} 38560 -30780 0 1 {name=p37780 lab=_52307_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -30780 0 0 {name=X_52307_ }
C {devices/lab_pin.sym} 38460 -30650 0 0 {name=p37781 lab=_40321_/A }
C {devices/lab_pin.sym} 38540 -30650 0 1 {name=p37782 lab=_46526_/A }
C {sky130_stdcells/buf_2.sym} 38500 -30650 0 0 {name=X_40321_ }
C {devices/lab_pin.sym} 38440 -30560 0 0 {name=p37783 lab=_71168_/A }
C {devices/lab_pin.sym} 38440 -30520 0 0 {name=p37784 lab=_71141_/B }
C {devices/lab_pin.sym} 38440 -30480 0 0 {name=p37785 lab=_71152_/C }
C {devices/lab_pin.sym} 38440 -30440 0 0 {name=p37786 lab=_70875_/X }
C {devices/lab_pin.sym} 38560 -30500 0 1 {name=p37787 lab=_71141_/Y }
C {sky130_stdcells/nand4_4.sym} 38500 -30500 0 0 {name=X_71141_ }
C {devices/lab_pin.sym} 38460 -30350 0 0 {name=p37788 lab=clkbuf_9_484_0_CLK/X }
C {devices/lab_pin.sym} 38540 -30350 0 1 {name=p37789 lab=_86222_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 38500 -30350 0 0 {name=Xclkbuf_10_969_0_CLK }
C {devices/lab_pin.sym} 38410 -30230 0 0 {name=p37790 lab=_83145_/CLK }
C {devices/lab_pin.sym} 38410 -30210 0 0 {name=p37791 lab=_74004_/Y }
C {devices/lab_pin.sym} 38590 -30230 0 1 {name=p37792 lab=_83127_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -30220 0 0 {name=X_83127_ }
C {devices/lab_pin.sym} 38440 -30100 0 0 {name=p37793 lab=_80337_/Y }
C {devices/lab_pin.sym} 38440 -30060 0 0 {name=p37794 lab=_80338_/Y }
C {devices/lab_pin.sym} 38560 -30080 0 1 {name=p37795 lab=_80339_/X }
C {sky130_stdcells/xor2_4.sym} 38500 -30080 0 0 {name=X_80339_ }
C {devices/lab_pin.sym} 38460 -29950 0 0 {name=p37796 lab=_56104_/A }
C {devices/lab_pin.sym} 38540 -29950 0 1 {name=p37797 lab=_56100_/A }
C {sky130_stdcells/buf_2.sym} 38500 -29950 0 0 {name=X_56075_ }
C {devices/lab_pin.sym} 38420 -29850 0 0 {name=p37798 lab=_85661_/Q }
C {devices/lab_pin.sym} 38420 -29810 0 0 {name=p37799 lab=_53268_/X }
C {devices/lab_pin.sym} 38420 -29770 0 0 {name=p37800 lab=_53286_/Y }
C {devices/lab_pin.sym} 38580 -29810 0 1 {name=p37801 lab=_53287_/Y }
C {sky130_stdcells/o21ai_4.sym} 38500 -29810 0 0 {name=X_53287_ }
C {devices/lab_pin.sym} 38460 -29670 0 0 {name=p37802 lab=_50594_/A }
C {devices/lab_pin.sym} 38540 -29670 0 1 {name=p37803 lab=_50499_/X }
C {sky130_stdcells/buf_2.sym} 38500 -29670 0 0 {name=X_50499_ }
C {devices/lab_pin.sym} 38460 -29550 0 0 {name=p37804 lab=_43040_/A }
C {devices/lab_pin.sym} 38540 -29550 0 1 {name=p37805 lab=_87598_/D }
C {sky130_stdcells/inv_2.sym} 38500 -29550 0 0 {name=X_43040_ }
C {devices/lab_pin.sym} 38440 -29460 0 0 {name=p37806 lab=_55017_/X }
C {devices/lab_pin.sym} 38440 -29420 0 0 {name=p37807 lab=_55026_/B }
C {devices/lab_pin.sym} 38440 -29380 0 0 {name=p37808 lab=_55026_/C }
C {devices/lab_pin.sym} 38440 -29340 0 0 {name=p37809 lab=_55026_/D }
C {devices/lab_pin.sym} 38560 -29400 0 1 {name=p37810 lab=_55026_/X }
C {sky130_stdcells/and4_4.sym} 38500 -29400 0 0 {name=X_55026_ }
C {devices/lab_pin.sym} 38460 -29250 0 0 {name=p37811 lab=_59903_/A }
C {devices/lab_pin.sym} 38540 -29250 0 1 {name=p37812 lab=_59904_/B }
C {sky130_stdcells/inv_2.sym} 38500 -29250 0 0 {name=X_59903_ }
C {devices/lab_pin.sym} 38420 -29150 0 0 {name=p37813 lab=_52236_/Y }
C {devices/lab_pin.sym} 38420 -29110 0 0 {name=p37814 lab=_52232_/X }
C {devices/lab_pin.sym} 38420 -29070 0 0 {name=p37815 lab=_52237_/X }
C {devices/lab_pin.sym} 38580 -29110 0 1 {name=p37816 lab=_85862_/D }
C {sky130_stdcells/a21oi_4.sym} 38500 -29110 0 0 {name=X_52238_ }
C {devices/lab_pin.sym} 38460 -28970 0 0 {name=p37817 lab=_71072_/A }
C {devices/lab_pin.sym} 38540 -28970 0 1 {name=p37818 lab=_71078_/C }
C {sky130_stdcells/buf_2.sym} 38500 -28970 0 0 {name=X_71072_ }
C {devices/lab_pin.sym} 38410 -28850 0 0 {name=p37819 lab=_85571_/CLK }
C {devices/lab_pin.sym} 38410 -28830 0 0 {name=p37820 lab=_74479_/Y }
C {devices/lab_pin.sym} 38590 -28850 0 1 {name=p37821 lab=_83058_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -28840 0 0 {name=X_83058_ }
C {devices/lab_pin.sym} 38410 -28710 0 0 {name=p37822 lab=_88386_/CLK }
C {devices/lab_pin.sym} 38410 -28690 0 0 {name=p37823 lab=_42295_/Y }
C {devices/lab_pin.sym} 38590 -28710 0 1 {name=p37824 lab=_87935_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -28700 0 0 {name=X_87935_ }
C {devices/lab_pin.sym} 38460 -28570 0 0 {name=p37825 lab=_74900_/A }
C {devices/lab_pin.sym} 38540 -28570 0 1 {name=p37826 lab=_74900_/Y }
C {sky130_stdcells/inv_2.sym} 38500 -28570 0 0 {name=X_74900_ }
C {devices/lab_pin.sym} 38420 -28470 0 0 {name=p37827 lab=_69712_/X }
C {devices/lab_pin.sym} 38420 -28430 0 0 {name=p37828 lab=_69714_/X }
C {devices/lab_pin.sym} 38420 -28390 0 0 {name=p37829 lab=_70001_/X }
C {devices/lab_pin.sym} 38580 -28430 0 1 {name=p37830 lab=_70023_/Y }
C {sky130_stdcells/a21oi_4.sym} 38500 -28430 0 0 {name=X_70023_ }
C {devices/lab_pin.sym} 38410 -28290 0 0 {name=p37831 lab=_82009_/CLK }
C {devices/lab_pin.sym} 38410 -28270 0 0 {name=p37832 lab=_82041_/Q }
C {devices/lab_pin.sym} 38590 -28290 0 1 {name=p37833 lab=_77163_/A }
C {sky130_stdcells/dfxtp_4.sym} 38500 -28280 0 0 {name=X_82009_ }
C {devices/lab_pin.sym} 38440 -28170 0 0 {name=p37834 lab=_59834_/A }
C {devices/lab_pin.sym} 38440 -28130 0 0 {name=p37835 lab=_59833_/X }
C {devices/lab_pin.sym} 38440 -28090 0 0 {name=p37836 lab=_80400_/A }
C {devices/lab_pin.sym} 38560 -28130 0 1 {name=p37837 lab=_59834_/X }
C {sky130_stdcells/or3_4.sym} 38500 -28130 0 0 {name=X_59834_ }
C {devices/lab_pin.sym} 38420 -28010 0 0 {name=p37838 lab=_85875_/Q }
C {devices/lab_pin.sym} 38420 -27970 0 0 {name=p37839 lab=_52152_/X }
C {devices/lab_pin.sym} 38420 -27930 0 0 {name=p37840 lab=_52168_/Y }
C {devices/lab_pin.sym} 38580 -27970 0 1 {name=p37841 lab=_52169_/Y }
C {sky130_stdcells/o21ai_4.sym} 38500 -27970 0 0 {name=X_52169_ }
C {devices/lab_pin.sym} 38440 -27840 0 0 {name=p37842 lab=_75880_/A }
C {devices/lab_pin.sym} 38440 -27800 0 0 {name=p37843 lab=_75880_/B }
C {devices/lab_pin.sym} 38560 -27820 0 1 {name=p37844 lab=_75880_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -27820 0 0 {name=X_75880_ }
C {devices/lab_pin.sym} 38410 -27690 0 0 {name=p37845 lab=_82899_/CLK }
C {devices/lab_pin.sym} 38410 -27670 0 0 {name=p37846 lab=_87866_/D }
C {devices/lab_pin.sym} 38590 -27690 0 1 {name=p37847 lab=_87866_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -27680 0 0 {name=X_87866_ }
C {devices/lab_pin.sym} 38410 -27550 0 0 {name=p37848 lab=_86784_/CLK }
C {devices/lab_pin.sym} 38410 -27530 0 0 {name=p37849 lab=_86817_/D }
C {devices/lab_pin.sym} 38590 -27550 0 1 {name=p37850 lab=_67071_/B }
C {sky130_stdcells/dfxtp_4.sym} 38500 -27540 0 0 {name=X_86817_ }
C {devices/lab_pin.sym} 38460 -27410 0 0 {name=p37851 lab=_74831_/A }
C {devices/lab_pin.sym} 38540 -27410 0 1 {name=p37852 lab=_74844_/A }
C {sky130_stdcells/buf_2.sym} 38500 -27410 0 0 {name=X_74831_ }
C {devices/lab_pin.sym} 38460 -27290 0 0 {name=p37853 lab=_59765_/A }
C {devices/lab_pin.sym} 38540 -27290 0 1 {name=p37854 lab=_61770_/B }
C {sky130_stdcells/buf_2.sym} 38500 -27290 0 0 {name=X_59765_ }
C {devices/lab_pin.sym} 38420 -27190 0 0 {name=p37855 lab=_44988_/X }
C {devices/lab_pin.sym} 38420 -27150 0 0 {name=p37856 lab=_44990_/Y }
C {devices/lab_pin.sym} 38420 -27110 0 0 {name=p37857 lab=_44973_/X }
C {devices/lab_pin.sym} 38580 -27150 0 1 {name=p37858 lab=_44991_/Y }
C {sky130_stdcells/a21oi_4.sym} 38500 -27150 0 0 {name=X_44991_ }
C {devices/lab_pin.sym} 38440 -27020 0 0 {name=p37859 lab=_56976_/X }
C {devices/lab_pin.sym} 38440 -26980 0 0 {name=p37860 lab=_56685_/X }
C {devices/lab_pin.sym} 38560 -27000 0 1 {name=p37861 lab=_56977_/Y }
C {sky130_stdcells/nor2_4.sym} 38500 -27000 0 0 {name=X_56977_ }
C {devices/lab_pin.sym} 38410 -26870 0 0 {name=p37862 lab=_87285_/CLK }
C {devices/lab_pin.sym} 38410 -26850 0 0 {name=p37863 lab=_87797_/D }
C {devices/lab_pin.sym} 38590 -26870 0 1 {name=p37864 lab=_73507_/A }
C {sky130_stdcells/dfxtp_4.sym} 38500 -26860 0 0 {name=X_87797_ }
C {devices/lab_pin.sym} 38420 -26750 0 0 {name=p37865 lab=_46724_/Y }
C {devices/lab_pin.sym} 38420 -26710 0 0 {name=p37866 lab=_46704_/X }
C {devices/lab_pin.sym} 38420 -26670 0 0 {name=p37867 lab=_46729_/X }
C {devices/lab_pin.sym} 38580 -26710 0 1 {name=p37868 lab=_86710_/D }
C {sky130_stdcells/a21oi_4.sym} 38500 -26710 0 0 {name=X_46730_ }
C {devices/lab_pin.sym} 38460 -26570 0 0 {name=p37869 lab=_58847_/A }
C {devices/lab_pin.sym} 38540 -26570 0 1 {name=p37870 lab=_58716_/X }
C {sky130_stdcells/buf_2.sym} 38500 -26570 0 0 {name=X_58716_ }
C {devices/lab_pin.sym} 38440 -26460 0 0 {name=p37871 lab=_77551_/A }
C {devices/lab_pin.sym} 38440 -26420 0 0 {name=p37872 lab=_82116_/Q }
C {devices/lab_pin.sym} 38560 -26440 0 1 {name=p37873 lab=_77553_/B }
C {sky130_stdcells/nor2_4.sym} 38500 -26440 0 0 {name=X_77550_ }
C {devices/lab_pin.sym} 38420 -26340 0 0 {name=p37874 lab=_41454_/X }
C {devices/lab_pin.sym} 38420 -26300 0 0 {name=p37875 lab=_43939_/X }
C {devices/lab_pin.sym} 38420 -26260 0 0 {name=p37876 lab=_68071_/B }
C {devices/lab_pin.sym} 38420 -26220 0 0 {name=p37877 lab=_43941_/X }
C {devices/lab_pin.sym} 38580 -26280 0 1 {name=p37878 lab=_43942_/X }
C {sky130_stdcells/a2bb2o_4.sym} 38500 -26280 0 0 {name=X_43942_ }
C {devices/lab_pin.sym} 38440 -26160 0 0 {name=p37879 lab=_55928_/A }
C {devices/lab_pin.sym} 38440 -26120 0 0 {name=p37880 lab=_55928_/B }
C {devices/lab_pin.sym} 38440 -26080 0 0 {name=p37881 lab=_55928_/C }
C {devices/lab_pin.sym} 38440 -26040 0 0 {name=p37882 lab=_55927_/X }
C {devices/lab_pin.sym} 38560 -26100 0 1 {name=p37883 lab=_55956_/A }
C {sky130_stdcells/and4_4.sym} 38500 -26100 0 0 {name=X_55928_ }
C {devices/lab_pin.sym} 38440 -25960 0 0 {name=p37884 lab=_74762_/A }
C {devices/lab_pin.sym} 38440 -25920 0 0 {name=p37885 lab=_71507_/B }
C {devices/lab_pin.sym} 38560 -25940 0 1 {name=p37886 lab=_74762_/Y }
C {sky130_stdcells/nor2_4.sym} 38500 -25940 0 0 {name=X_74762_ }
C {devices/lab_pin.sym} 38410 -25810 0 0 {name=p37887 lab=_86246_/CLK }
C {devices/lab_pin.sym} 38410 -25790 0 0 {name=p37888 lab=_46323_/Y }
C {devices/lab_pin.sym} 38590 -25810 0 1 {name=p37889 lab=_86748_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -25800 0 0 {name=X_86748_ }
C {devices/lab_pin.sym} 38440 -25680 0 0 {name=p37890 lab=_71970_/A }
C {devices/lab_pin.sym} 38440 -25640 0 0 {name=p37891 lab=_71974_/B }
C {devices/lab_pin.sym} 38560 -25660 0 1 {name=p37892 lab=_71974_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -25660 0 0 {name=X_71974_ }
C {devices/lab_pin.sym} 38440 -25550 0 0 {name=p37893 lab=_59696_/A }
C {devices/lab_pin.sym} 38440 -25510 0 0 {name=p37894 lab=_66514_/B }
C {devices/lab_pin.sym} 38440 -25470 0 0 {name=p37895 lab=_80605_/A }
C {devices/lab_pin.sym} 38560 -25510 0 1 {name=p37896 lab=_59696_/Y }
C {sky130_stdcells/nor3_4.sym} 38500 -25510 0 0 {name=X_59696_ }
C {devices/lab_pin.sym} 38460 -25370 0 0 {name=p37897 lab=_81658_/Q }
C {devices/lab_pin.sym} 38540 -25370 0 1 {name=p37898 lab=_76501_/Y }
C {sky130_stdcells/inv_2.sym} 38500 -25370 0 0 {name=X_76501_ }
C {devices/lab_pin.sym} 38420 -25270 0 0 {name=p37899 lab=_73708_/X }
C {devices/lab_pin.sym} 38420 -25230 0 0 {name=p37900 lab=_73712_/X }
C {devices/lab_pin.sym} 38420 -25190 0 0 {name=p37901 lab=_73612_/X }
C {devices/lab_pin.sym} 38580 -25230 0 1 {name=p37902 lab=_73716_/A }
C {sky130_stdcells/a21o_4.sym} 38500 -25230 0 0 {name=X_73713_ }
C {devices/lab_pin.sym} 38460 -25090 0 0 {name=p37903 lab=clkbuf_9_453_0_CLK/X }
C {devices/lab_pin.sym} 38540 -25090 0 1 {name=p37904 lab=_88111_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 38500 -25090 0 0 {name=Xclkbuf_10_907_0_CLK }
C {devices/lab_pin.sym} 38460 -24970 0 0 {name=p37905 lab=_70925_/A }
C {devices/lab_pin.sym} 38540 -24970 0 1 {name=p37906 lab=_70925_/X }
C {sky130_stdcells/buf_2.sym} 38500 -24970 0 0 {name=X_70925_ }
C {devices/lab_pin.sym} 38460 -24850 0 0 {name=p37907 lab=_83684_/Q }
C {devices/lab_pin.sym} 38540 -24850 0 1 {name=p37908 lab=_46662_/A }
C {sky130_stdcells/inv_2.sym} 38500 -24850 0 0 {name=X_46661_ }
C {devices/lab_pin.sym} 38420 -24750 0 0 {name=p37909 lab=_58643_/Y }
C {devices/lab_pin.sym} 38420 -24710 0 0 {name=p37910 lab=_58645_/Y }
C {devices/lab_pin.sym} 38420 -24670 0 0 {name=p37911 lab=_58646_/X }
C {devices/lab_pin.sym} 38580 -24710 0 1 {name=p37912 lab=_58647_/X }
C {sky130_stdcells/a21o_4.sym} 38500 -24710 0 0 {name=X_58647_ }
C {devices/lab_pin.sym} 38440 -24580 0 0 {name=p37913 lab=_77478_/X }
C {devices/lab_pin.sym} 38440 -24540 0 0 {name=p37914 lab=_77480_/Y }
C {devices/lab_pin.sym} 38560 -24560 0 1 {name=p37915 lab=_77481_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -24560 0 0 {name=X_77481_ }
C {devices/lab_pin.sym} 38420 -24460 0 0 {name=p37916 lab=_41264_/X }
C {devices/lab_pin.sym} 38420 -24420 0 0 {name=p37917 lab=_43868_/X }
C {devices/lab_pin.sym} 38420 -24380 0 0 {name=p37918 lab=_69033_/B }
C {devices/lab_pin.sym} 38420 -24340 0 0 {name=p37919 lab=_43870_/X }
C {devices/lab_pin.sym} 38580 -24400 0 1 {name=p37920 lab=_43873_/X }
C {sky130_stdcells/a2bb2o_4.sym} 38500 -24400 0 0 {name=X_43873_ }
C {devices/lab_pin.sym} 38420 -24270 0 0 {name=p37921 lab=_55856_/X }
C {devices/lab_pin.sym} 38420 -24230 0 0 {name=p37922 lab=_55858_/X }
C {devices/lab_pin.sym} 38420 -24190 0 0 {name=p37923 lab=_55516_/X }
C {devices/lab_pin.sym} 38580 -24230 0 1 {name=p37924 lab=_55859_/X }
C {sky130_stdcells/a21o_4.sym} 38500 -24230 0 0 {name=X_55859_ }
C {devices/lab_pin.sym} 38410 -24090 0 0 {name=p37925 lab=_86359_/CLK }
C {devices/lab_pin.sym} 38410 -24070 0 0 {name=p37926 lab=_47022_/Y }
C {devices/lab_pin.sym} 38590 -24090 0 1 {name=p37927 lab=_59118_/A }
C {sky130_stdcells/dfxtp_4.sym} 38500 -24080 0 0 {name=X_86679_ }
C {devices/lab_pin.sym} 38460 -23950 0 0 {name=p37928 lab=_74693_/A }
C {devices/lab_pin.sym} 38540 -23950 0 1 {name=p37929 lab=_74693_/Y }
C {sky130_stdcells/inv_2.sym} 38500 -23950 0 0 {name=X_74693_ }
C {devices/lab_pin.sym} 38460 -23830 0 0 {name=p37930 lab=_74383_/B }
C {devices/lab_pin.sym} 38540 -23830 0 1 {name=p37931 lab=_48401_/B }
C {sky130_stdcells/buf_2.sym} 38500 -23830 0 0 {name=X_48400_ }
C {devices/lab_pin.sym} 38420 -23730 0 0 {name=p37932 lab=_79203_/A }
C {devices/lab_pin.sym} 38420 -23690 0 0 {name=p37933 lab=_79201_/Y }
C {devices/lab_pin.sym} 38420 -23650 0 0 {name=p37934 lab=_79219_/Y }
C {devices/lab_pin.sym} 38580 -23690 0 1 {name=p37935 lab=_79220_/Y }
C {sky130_stdcells/a21oi_4.sym} 38500 -23690 0 0 {name=X_79220_ }
C {devices/lab_pin.sym} 38460 -23550 0 0 {name=p37936 lab=_45612_/A }
C {devices/lab_pin.sym} 38540 -23550 0 1 {name=p37937 lab=_45793_/B }
C {sky130_stdcells/buf_2.sym} 38500 -23550 0 0 {name=X_45612_ }
C {devices/lab_pin.sym} 38440 -23440 0 0 {name=p37938 lab=_76430_/X }
C {devices/lab_pin.sym} 38440 -23400 0 0 {name=p37939 lab=_76431_/Y }
C {devices/lab_pin.sym} 38560 -23420 0 1 {name=p37940 lab=_76432_/X }
C {sky130_stdcells/and2_4.sym} 38500 -23420 0 0 {name=X_76432_ }
C {devices/lab_pin.sym} 38420 -23320 0 0 {name=p37941 lab=_41454_/X }
C {devices/lab_pin.sym} 38420 -23280 0 0 {name=p37942 lab=_42821_/X }
C {devices/lab_pin.sym} 38420 -23240 0 0 {name=p37943 lab=_68067_/B }
C {devices/lab_pin.sym} 38420 -23200 0 0 {name=p37944 lab=_42822_/X }
C {devices/lab_pin.sym} 38580 -23260 0 1 {name=p37945 lab=_42824_/X }
C {sky130_stdcells/a2bb2o_4.sym} 38500 -23260 0 0 {name=X_42824_ }
C {devices/lab_pin.sym} 38440 -23140 0 0 {name=p37946 lab=_49397_/A }
C {devices/lab_pin.sym} 38440 -23100 0 0 {name=p37947 lab=_49369_/X }
C {devices/lab_pin.sym} 38440 -23060 0 0 {name=p37948 lab=_49380_/C }
C {devices/lab_pin.sym} 38440 -23020 0 0 {name=p37949 lab=_51768_/D }
C {devices/lab_pin.sym} 38560 -23080 0 1 {name=p37950 lab=_49380_/X }
C {sky130_stdcells/and4_4.sym} 38500 -23080 0 0 {name=X_49380_ }
C {devices/lab_pin.sym} 38440 -22940 0 0 {name=p37951 lab=_47863_/Y }
C {devices/lab_pin.sym} 38440 -22900 0 0 {name=p37952 lab=_73644_/B }
C {devices/lab_pin.sym} 38560 -22920 0 1 {name=p37953 lab=_73644_/X }
C {sky130_stdcells/xor2_4.sym} 38500 -22920 0 0 {name=X_73644_ }
C {devices/lab_pin.sym} 38460 -22790 0 0 {name=p37954 lab=clkbuf_4_12_1_CLK/X }
C {devices/lab_pin.sym} 38540 -22790 0 1 {name=p37955 lab=clkbuf_6_49_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 38500 -22790 0 0 {name=Xclkbuf_5_24_0_CLK }
C {devices/lab_pin.sym} 38440 -22680 0 0 {name=p37956 lab=_57497_/A }
C {devices/lab_pin.sym} 38440 -22640 0 0 {name=p37957 lab=_54087_/B }
C {devices/lab_pin.sym} 38560 -22660 0 1 {name=p37958 lab=_46592_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -22660 0 0 {name=X_46592_ }
C {devices/lab_pin.sym} 38420 -22570 0 0 {name=p37959 lab=_58079_/X }
C {devices/lab_pin.sym} 38420 -22530 0 0 {name=p37960 lab=_58576_/Y }
C {devices/lab_pin.sym} 38420 -22490 0 0 {name=p37961 lab=_58577_/Y }
C {devices/lab_pin.sym} 38420 -22450 0 0 {name=p37962 lab=_58098_/X }
C {devices/lab_pin.sym} 38420 -22410 0 0 {name=p37963 lab=_58083_/X }
C {devices/lab_pin.sym} 38580 -22490 0 1 {name=p37964 lab=_58578_/X }
C {sky130_stdcells/o32a_4.sym} 38500 -22490 0 0 {name=X_58578_ }
C {devices/lab_pin.sym} 38460 -22330 0 0 {name=p37965 lab=_70854_/A }
C {devices/lab_pin.sym} 38540 -22330 0 1 {name=p37966 lab=_71068_/B }
C {sky130_stdcells/inv_2.sym} 38500 -22330 0 0 {name=X_70856_ }
C {devices/lab_pin.sym} 38420 -22230 0 0 {name=p37967 lab=_48328_/Y }
C {devices/lab_pin.sym} 38420 -22190 0 0 {name=p37968 lab=_48322_/X }
C {devices/lab_pin.sym} 38420 -22150 0 0 {name=p37969 lab=_48330_/Y }
C {devices/lab_pin.sym} 38580 -22190 0 1 {name=p37970 lab=_86534_/D }
C {sky130_stdcells/a21boi_4.sym} 38500 -22190 0 0 {name=X_48331_ }
C {devices/lab_pin.sym} 38440 -22060 0 0 {name=p37971 lab=_79151_/A }
C {devices/lab_pin.sym} 38440 -22020 0 0 {name=p37972 lab=_79151_/B }
C {devices/lab_pin.sym} 38560 -22040 0 1 {name=p37973 lab=_79151_/X }
C {sky130_stdcells/xor2_4.sym} 38500 -22040 0 0 {name=X_79151_ }
C {devices/lab_pin.sym} 38420 -21930 0 0 {name=p37974 lab=_45541_/Y }
C {devices/lab_pin.sym} 38420 -21890 0 0 {name=p37975 lab=_45542_/Y }
C {devices/lab_pin.sym} 38420 -21850 0 0 {name=p37976 lab=_44939_/B }
C {devices/lab_pin.sym} 38580 -21890 0 1 {name=p37977 lab=_45543_/X }
C {sky130_stdcells/o21a_4.sym} 38500 -21890 0 0 {name=X_45543_ }
C {devices/lab_pin.sym} 38440 -21760 0 0 {name=p37978 lab=_57528_/X }
C {devices/lab_pin.sym} 38440 -21720 0 0 {name=p37979 lab=_73765_/A }
C {devices/lab_pin.sym} 38560 -21740 0 1 {name=p37980 lab=_57529_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -21740 0 0 {name=X_57529_ }
C {devices/lab_pin.sym} 38440 -21620 0 0 {name=p37981 lab=_81360_/Q }
C {devices/lab_pin.sym} 38440 -21580 0 0 {name=p37982 lab=_76363_/B }
C {devices/lab_pin.sym} 38560 -21600 0 1 {name=p37983 lab=_76363_/X }
C {sky130_stdcells/xor2_4.sym} 38500 -21600 0 0 {name=X_76363_ }
C {devices/lab_pin.sym} 38410 -21470 0 0 {name=p37984 lab=_82538_/CLK }
C {devices/lab_pin.sym} 38410 -21450 0 0 {name=p37985 lab=_40713_/X }
C {devices/lab_pin.sym} 38590 -21470 0 1 {name=p37986 lab=_88349_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -21460 0 0 {name=X_88349_ }
C {devices/lab_pin.sym} 38420 -21360 0 0 {name=p37987 lab=_41264_/X }
C {devices/lab_pin.sym} 38420 -21320 0 0 {name=p37988 lab=_42745_/X }
C {devices/lab_pin.sym} 38420 -21280 0 0 {name=p37989 lab=_69031_/B }
C {devices/lab_pin.sym} 38420 -21240 0 0 {name=p37990 lab=_42746_/X }
C {devices/lab_pin.sym} 38580 -21300 0 1 {name=p37991 lab=_87736_/D }
C {sky130_stdcells/a2bb2o_4.sym} 38500 -21300 0 0 {name=X_42755_ }
C {devices/lab_pin.sym} 38440 -21160 0 0 {name=p37992 lab=_88114_/Q }
C {devices/lab_pin.sym} 38440 -21120 0 0 {name=p37993 lab=_74095_/B }
C {devices/lab_pin.sym} 38560 -21140 0 1 {name=p37994 lab=_73575_/Y }
C {sky130_stdcells/nor2_4.sym} 38500 -21140 0 0 {name=X_73575_ }
C {devices/lab_pin.sym} 38440 -21040 0 0 {name=p37995 lab=_70873_/A }
C {devices/lab_pin.sym} 38440 -21000 0 0 {name=p37996 lab=_70791_/B }
C {devices/lab_pin.sym} 38440 -20960 0 0 {name=p37997 lab=_70791_/C }
C {devices/lab_pin.sym} 38440 -20920 0 0 {name=p37998 lab=_70791_/D }
C {devices/lab_pin.sym} 38560 -20980 0 1 {name=p37999 lab=_70787_/Y }
C {sky130_stdcells/nand4_4.sym} 38500 -20980 0 0 {name=X_70787_ }
C {devices/lab_pin.sym} 38440 -20840 0 0 {name=p38000 lab=_82566_/Q }
C {devices/lab_pin.sym} 38440 -20800 0 0 {name=p38001 lab=_78102_/B }
C {devices/lab_pin.sym} 38560 -20820 0 1 {name=p38002 lab=_78130_/A }
C {sky130_stdcells/xor2_4.sym} 38500 -20820 0 0 {name=X_78102_ }
C {devices/lab_pin.sym} 38440 -20700 0 0 {name=p38003 lab=_80691_/Q }
C {devices/lab_pin.sym} 38440 -20660 0 0 {name=p38004 lab=_80991_/Q }
C {devices/lab_pin.sym} 38560 -20680 0 1 {name=p38005 lab=_75314_/Y }
C {sky130_stdcells/nor2_4.sym} 38500 -20680 0 0 {name=X_75314_ }
C {devices/lab_pin.sym} 38420 -20590 0 0 {name=p38006 lab=_41672_/X }
C {devices/lab_pin.sym} 38420 -20550 0 0 {name=p38007 lab=_41673_/X }
C {devices/lab_pin.sym} 38420 -20510 0 0 {name=p38008 lab=_41705_/X }
C {devices/lab_pin.sym} 38420 -20470 0 0 {name=p38009 lab=_67683_/B }
C {devices/lab_pin.sym} 38420 -20430 0 0 {name=p38010 lab=_41668_/X }
C {devices/lab_pin.sym} 38580 -20510 0 1 {name=p38011 lab=_41707_/A }
C {sky130_stdcells/o32ai_4.sym} 38500 -20510 0 0 {name=X_41706_ }
C {devices/lab_pin.sym} 38420 -20370 0 0 {name=p38012 lab=_48260_/Y }
C {devices/lab_pin.sym} 38420 -20330 0 0 {name=p38013 lab=_48233_/X }
C {devices/lab_pin.sym} 38420 -20290 0 0 {name=p38014 lab=_48261_/X }
C {devices/lab_pin.sym} 38580 -20330 0 1 {name=p38015 lab=_86546_/D }
C {sky130_stdcells/a21oi_4.sym} 38500 -20330 0 0 {name=X_48262_ }
C {devices/lab_pin.sym} 38460 -20190 0 0 {name=p38016 lab=_60482_/Y }
C {devices/lab_pin.sym} 38540 -20190 0 1 {name=p38017 lab=_60541_/C }
C {sky130_stdcells/buf_2.sym} 38500 -20190 0 0 {name=X_60540_ }
C {devices/lab_pin.sym} 38420 -20090 0 0 {name=p38018 lab=_72522_/Y }
C {devices/lab_pin.sym} 38420 -20050 0 0 {name=p38019 lab=_72525_/Y }
C {devices/lab_pin.sym} 38420 -20010 0 0 {name=p38020 lab=_59980_/X }
C {devices/lab_pin.sym} 38580 -20050 0 1 {name=p38021 lab=_72533_/A }
C {sky130_stdcells/a21o_4.sym} 38500 -20050 0 0 {name=X_72526_ }
C {devices/lab_pin.sym} 38440 -19920 0 0 {name=p38022 lab=_82623_/D }
C {devices/lab_pin.sym} 38440 -19880 0 0 {name=p38023 lab=_79082_/B }
C {devices/lab_pin.sym} 38560 -19900 0 1 {name=p38024 lab=_79084_/A }
C {sky130_stdcells/nand2_4.sym} 38500 -19900 0 0 {name=X_79082_ }
C {devices/lab_pin.sym} 38460 -19770 0 0 {name=p38025 lab=_85020_/Q }
C {devices/lab_pin.sym} 38540 -19770 0 1 {name=p38026 lab=_45474_/Y }
C {sky130_stdcells/inv_2.sym} 38500 -19770 0 0 {name=X_45474_ }
C {devices/lab_pin.sym} 38420 -19670 0 0 {name=p38027 lab=_76283_/A }
C {devices/lab_pin.sym} 38420 -19630 0 0 {name=p38028 lab=_76267_/B }
C {devices/lab_pin.sym} 38420 -19590 0 0 {name=p38029 lab=_76293_/A }
C {devices/lab_pin.sym} 38580 -19630 0 1 {name=p38030 lab=_76294_/Y }
C {sky130_stdcells/a21oi_4.sym} 38500 -19630 0 0 {name=X_76294_ }
C {devices/lab_pin.sym} 38460 -19490 0 0 {name=p38031 lab=_42685_/Y }
C {devices/lab_pin.sym} 38540 -19490 0 1 {name=p38032 lab=_87770_/D }
C {sky130_stdcells/inv_2.sym} 38500 -19490 0 0 {name=X_42686_ }
C {devices/lab_pin.sym} 38460 -19370 0 0 {name=p38033 lab=_47212_/Y }
C {devices/lab_pin.sym} 38540 -19370 0 1 {name=p38034 lab=_52918_/B }
C {sky130_stdcells/buf_2.sym} 38500 -19370 0 0 {name=X_47213_ }
C {devices/lab_pin.sym} 38440 -19260 0 0 {name=p38035 lab=_78033_/A }
C {devices/lab_pin.sym} 38440 -19220 0 0 {name=p38036 lab=_78033_/B }
C {devices/lab_pin.sym} 38560 -19240 0 1 {name=p38037 lab=_78033_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -19240 0 0 {name=X_78033_ }
C {devices/lab_pin.sym} 38460 -19110 0 0 {name=p38038 lab=_44381_/A }
C {devices/lab_pin.sym} 38540 -19110 0 1 {name=p38039 lab=_44425_/X }
C {sky130_stdcells/buf_2.sym} 38500 -19110 0 0 {name=X_44425_ }
C {devices/lab_pin.sym} 38440 -19000 0 0 {name=p38040 lab=_75245_/A }
C {devices/lab_pin.sym} 38440 -18960 0 0 {name=p38041 lab=_75244_/Y }
C {devices/lab_pin.sym} 38560 -18980 0 1 {name=p38042 lab=_75245_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -18980 0 0 {name=X_75245_ }
C {devices/lab_pin.sym} 38460 -18850 0 0 {name=p38043 lab=_40717_/X }
C {devices/lab_pin.sym} 38540 -18850 0 1 {name=p38044 lab=_41799_/A }
C {sky130_stdcells/buf_2.sym} 38500 -18850 0 0 {name=X_41637_ }
C {devices/lab_pin.sym} 38460 -18730 0 0 {name=p38045 lab=_48934_/A }
C {devices/lab_pin.sym} 38540 -18730 0 1 {name=p38046 lab=_48193_/X }
C {sky130_stdcells/buf_2.sym} 38500 -18730 0 0 {name=X_48193_ }
C {devices/lab_pin.sym} 38420 -18650 0 0 {name=p38047 lab=_63347_/C }
C {devices/lab_pin.sym} 38420 -18610 0 0 {name=p38048 lab=_60476_/C }
C {devices/lab_pin.sym} 38420 -18570 0 0 {name=p38049 lab=_60570_/B }
C {devices/lab_pin.sym} 38420 -18530 0 0 {name=p38050 lab=_60476_/A }
C {devices/lab_pin.sym} 38420 -18490 0 0 {name=p38051 lab=_60435_/C }
C {devices/lab_pin.sym} 38580 -18570 0 1 {name=p38052 lab=_60471_/X }
C {sky130_stdcells/o41a_4.sym} 38500 -18570 0 0 {name=X_60471_ }
C {devices/lab_pin.sym} 38420 -18430 0 0 {name=p38053 lab=_57709_/X }
C {devices/lab_pin.sym} 38420 -18390 0 0 {name=p38054 lab=_85348_/Q }
C {devices/lab_pin.sym} 38420 -18350 0 0 {name=p38055 lab=_72456_/X }
C {devices/lab_pin.sym} 38580 -18390 0 1 {name=p38056 lab=_72457_/Y }
C {sky130_stdcells/o21ai_4.sym} 38500 -18390 0 0 {name=X_72457_ }
C {devices/lab_pin.sym} 38460 -18250 0 0 {name=p38057 lab=_60084_/A }
C {devices/lab_pin.sym} 38540 -18250 0 1 {name=p38058 lab=_62211_/D }
C {sky130_stdcells/buf_2.sym} 38500 -18250 0 0 {name=X_62210_ }
C {devices/lab_pin.sym} 38420 -18150 0 0 {name=p38059 lab=_47138_/Y }
C {devices/lab_pin.sym} 38420 -18110 0 0 {name=p38060 lab=_47128_/X }
C {devices/lab_pin.sym} 38420 -18070 0 0 {name=p38061 lab=_47143_/X }
C {devices/lab_pin.sym} 38580 -18110 0 1 {name=p38062 lab=_86666_/D }
C {sky130_stdcells/a21oi_4.sym} 38500 -18110 0 0 {name=X_47144_ }
C {devices/lab_pin.sym} 38460 -17970 0 0 {name=p38063 lab=_71191_/A }
C {devices/lab_pin.sym} 38540 -17970 0 1 {name=p38064 lab=_71411_/B }
C {sky130_stdcells/buf_2.sym} 38500 -17970 0 0 {name=X_71408_ }
C {devices/lab_pin.sym} 38420 -17880 0 0 {name=p38065 lab=_41715_/X }
C {devices/lab_pin.sym} 38420 -17840 0 0 {name=p38066 lab=_44345_/X }
C {devices/lab_pin.sym} 38420 -17800 0 0 {name=p38067 lab=_87151_/Q }
C {devices/lab_pin.sym} 38420 -17760 0 0 {name=p38068 lab=_44346_/X }
C {devices/lab_pin.sym} 38580 -17820 0 1 {name=p38069 lab=_87151_/D }
C {sky130_stdcells/a2bb2o_4.sym} 38500 -17820 0 0 {name=X_44356_ }
C {devices/lab_pin.sym} 38420 -17690 0 0 {name=p38070 lab=_75154_/Y }
C {devices/lab_pin.sym} 38420 -17650 0 0 {name=p38071 lab=_75151_/Y }
C {devices/lab_pin.sym} 38420 -17610 0 0 {name=p38072 lab=_75153_/A }
C {devices/lab_pin.sym} 38580 -17650 0 1 {name=p38073 lab=_75178_/C }
C {sky130_stdcells/o21ai_4.sym} 38500 -17650 0 0 {name=X_75176_ }
C {devices/lab_pin.sym} 38460 -17510 0 0 {name=p38074 lab=_63010_/A }
C {devices/lab_pin.sym} 38540 -17510 0 1 {name=p38075 lab=_63190_/X }
C {sky130_stdcells/buf_2.sym} 38500 -17510 0 0 {name=X_63190_ }
C {devices/lab_pin.sym} 38440 -17400 0 0 {name=p38076 lab=_81164_/Q }
C {devices/lab_pin.sym} 38440 -17360 0 0 {name=p38077 lab=_41584_/B }
C {devices/lab_pin.sym} 38560 -17380 0 1 {name=p38078 lab=_41568_/X }
C {sky130_stdcells/or2_4.sym} 38500 -17380 0 0 {name=X_41568_ }
C {devices/lab_pin.sym} 38420 -17270 0 0 {name=p38079 lab=_72305_/X }
C {devices/lab_pin.sym} 38420 -17230 0 0 {name=p38080 lab=_85355_/Q }
C {devices/lab_pin.sym} 38420 -17190 0 0 {name=p38081 lab=_72387_/X }
C {devices/lab_pin.sym} 38580 -17230 0 1 {name=p38082 lab=_72388_/Y }
C {sky130_stdcells/o21ai_4.sym} 38500 -17230 0 0 {name=X_72388_ }
C {devices/lab_pin.sym} 38460 -17090 0 0 {name=p38083 lab=_43306_/Y }
C {devices/lab_pin.sym} 38540 -17090 0 1 {name=p38084 lab=_87489_/D }
C {sky130_stdcells/inv_2.sym} 38500 -17090 0 0 {name=X_43307_ }
C {devices/lab_pin.sym} 38440 -16980 0 0 {name=p38085 lab=_73583_/A }
C {devices/lab_pin.sym} 38440 -16940 0 0 {name=p38086 lab=_74127_/B }
C {devices/lab_pin.sym} 38560 -16960 0 1 {name=p38087 lab=_74127_/X }
C {sky130_stdcells/and2_4.sym} 38500 -16960 0 0 {name=X_74127_ }
C {devices/lab_pin.sym} 38440 -16860 0 0 {name=p38088 lab=_62140_/X }
C {devices/lab_pin.sym} 38440 -16820 0 0 {name=p38089 lab=_62175_/B }
C {devices/lab_pin.sym} 38440 -16780 0 0 {name=p38090 lab=_62046_/C }
C {devices/lab_pin.sym} 38440 -16740 0 0 {name=p38091 lab=_62046_/D }
C {devices/lab_pin.sym} 38560 -16800 0 1 {name=p38092 lab=_62141_/Y }
C {sky130_stdcells/nand4_4.sym} 38500 -16800 0 0 {name=X_62141_ }
C {devices/lab_pin.sym} 38420 -16670 0 0 {name=p38093 lab=_40504_/X }
C {devices/lab_pin.sym} 38420 -16630 0 0 {name=p38094 lab=_82312_/Q }
C {devices/lab_pin.sym} 38420 -16590 0 0 {name=p38095 lab=_40518_/X }
C {devices/lab_pin.sym} 38580 -16630 0 1 {name=p38096 lab=_40519_/Y }
C {sky130_stdcells/o21ai_4.sym} 38500 -16630 0 0 {name=X_40519_ }
C {devices/lab_pin.sym} 38440 -16520 0 0 {name=p38097 lab=_47067_/A }
C {devices/lab_pin.sym} 38440 -16480 0 0 {name=p38098 lab=_47039_/B }
C {devices/lab_pin.sym} 38440 -16440 0 0 {name=p38099 lab=_47048_/C }
C {devices/lab_pin.sym} 38440 -16400 0 0 {name=p38100 lab=_52841_/D }
C {devices/lab_pin.sym} 38560 -16460 0 1 {name=p38101 lab=_47075_/X }
C {sky130_stdcells/and4_4.sym} 38500 -16460 0 0 {name=X_47075_ }
C {devices/lab_pin.sym} 38420 -16330 0 0 {name=p38102 lab=_50389_/B }
C {devices/lab_pin.sym} 38420 -16290 0 0 {name=p38103 lab=_71320_/A }
C {devices/lab_pin.sym} 38420 -16250 0 0 {name=p38104 lab=_71338_/Y }
C {devices/lab_pin.sym} 38580 -16290 0 1 {name=p38105 lab=_71339_/Y }
C {sky130_stdcells/o21ai_4.sym} 38500 -16290 0 0 {name=X_71339_ }
C {devices/lab_pin.sym} 38460 -16150 0 0 {name=p38106 lab=_44286_/Y }
C {devices/lab_pin.sym} 38540 -16150 0 1 {name=p38107 lab=_44287_/X }
C {sky130_stdcells/buf_2.sym} 38500 -16150 0 0 {name=X_44287_ }
C {devices/lab_pin.sym} 38440 -16040 0 0 {name=p38108 lab=_84656_/Q }
C {devices/lab_pin.sym} 38440 -16000 0 0 {name=p38109 lab=_64130_/C }
C {devices/lab_pin.sym} 38560 -16020 0 1 {name=p38110 lab=_79985_/B }
C {sky130_stdcells/xor2_4.sym} 38500 -16020 0 0 {name=X_79984_ }
C {devices/lab_pin.sym} 38420 -15930 0 0 {name=p38111 lab=_41489_/X }
C {devices/lab_pin.sym} 38420 -15890 0 0 {name=p38112 lab=_41490_/X }
C {devices/lab_pin.sym} 38420 -15850 0 0 {name=p38113 lab=_41498_/X }
C {devices/lab_pin.sym} 38420 -15810 0 0 {name=p38114 lab=_66752_/B }
C {devices/lab_pin.sym} 38420 -15770 0 0 {name=p38115 lab=_41474_/X }
C {devices/lab_pin.sym} 38580 -15850 0 1 {name=p38116 lab=_41500_/A }
C {sky130_stdcells/o32ai_4.sym} 38500 -15850 0 0 {name=X_41499_ }
C {devices/lab_pin.sym} 38420 -15720 0 0 {name=p38117 lab=_40547_/Y }
C {devices/lab_pin.sym} 38420 -15680 0 0 {name=p38118 lab=_46022_/X }
C {devices/lab_pin.sym} 38420 -15640 0 0 {name=p38119 lab=_86807_/Q }
C {devices/lab_pin.sym} 38420 -15600 0 0 {name=p38120 lab=_46023_/X }
C {devices/lab_pin.sym} 38580 -15660 0 1 {name=p38121 lab=_46026_/X }
C {sky130_stdcells/a2bb2o_4.sym} 38500 -15660 0 0 {name=X_46026_ }
C {devices/lab_pin.sym} 38460 -15510 0 0 {name=p38122 lab=_43237_/Y }
C {devices/lab_pin.sym} 38540 -15510 0 1 {name=p38123 lab=_43238_/Y }
C {sky130_stdcells/inv_2.sym} 38500 -15510 0 0 {name=X_43238_ }
C {devices/lab_pin.sym} 38420 -15420 0 0 {name=p38124 lab=_63630_/A }
C {devices/lab_pin.sym} 38420 -15380 0 0 {name=p38125 lab=_59825_/B }
C {devices/lab_pin.sym} 38420 -15340 0 0 {name=p38126 lab=_61597_/A }
C {devices/lab_pin.sym} 38420 -15300 0 0 {name=p38127 lab=_59807_/A }
C {devices/lab_pin.sym} 38580 -15360 0 1 {name=p38128 lab=_62072_/X }
C {sky130_stdcells/a2bb2o_4.sym} 38500 -15360 0 0 {name=X_62072_ }
C {devices/lab_pin.sym} 38440 -15220 0 0 {name=p38129 lab=_74038_/A }
C {devices/lab_pin.sym} 38440 -15180 0 0 {name=p38130 lab=_66209_/B }
C {devices/lab_pin.sym} 38560 -15200 0 1 {name=p38131 lab=_74058_/X }
C {sky130_stdcells/and2_4.sym} 38500 -15200 0 0 {name=X_74058_ }
C {devices/lab_pin.sym} 38420 -15100 0 0 {name=p38132 lab=_78921_/Y }
C {devices/lab_pin.sym} 38420 -15060 0 0 {name=p38133 lab=_78923_/B }
C {devices/lab_pin.sym} 38420 -15020 0 0 {name=p38134 lab=_82638_/Q }
C {devices/lab_pin.sym} 38420 -14980 0 0 {name=p38135 lab=_82510_/D }
C {devices/lab_pin.sym} 38580 -15040 0 1 {name=p38136 lab=_78935_/X }
C {sky130_stdcells/a2bb2o_4.sym} 38500 -15040 0 0 {name=X_78935_ }
C {devices/lab_pin.sym} 38460 -14890 0 0 {name=p38137 lab=_65969_/A }
C {devices/lab_pin.sym} 38540 -14890 0 1 {name=p38138 lab=_65916_/A }
C {sky130_stdcells/buf_2.sym} 38500 -14890 0 0 {name=X_65900_ }
C {devices/lab_pin.sym} 38420 -14810 0 0 {name=p38139 lab=_61022_/Y }
C {devices/lab_pin.sym} 38420 -14770 0 0 {name=p38140 lab=_60994_/A }
C {devices/lab_pin.sym} 38420 -14730 0 0 {name=p38141 lab=_61012_/C }
C {devices/lab_pin.sym} 38420 -14690 0 0 {name=p38142 lab=_76985_/A }
C {devices/lab_pin.sym} 38420 -14650 0 0 {name=p38143 lab=_59829_/X }
C {devices/lab_pin.sym} 38580 -14730 0 1 {name=p38144 lab=_84537_/D }
C {sky130_stdcells/a32o_4.sym} 38500 -14730 0 0 {name=X_61023_ }
C {devices/lab_pin.sym} 38420 -14590 0 0 {name=p38145 lab=_44539_/Y }
C {devices/lab_pin.sym} 38420 -14550 0 0 {name=p38146 lab=_73006_/X }
C {devices/lab_pin.sym} 38420 -14510 0 0 {name=p38147 lab=_73008_/Y }
C {devices/lab_pin.sym} 38580 -14550 0 1 {name=p38148 lab=_73021_/C }
C {sky130_stdcells/a21o_4.sym} 38500 -14550 0 0 {name=X_73009_ }
C {devices/lab_pin.sym} 38460 -14410 0 0 {name=p38149 lab=_43169_/A }
C {devices/lab_pin.sym} 38540 -14410 0 1 {name=p38150 lab=_87551_/D }
C {sky130_stdcells/inv_2.sym} 38500 -14410 0 0 {name=X_43169_ }
C {devices/lab_pin.sym} 38440 -14300 0 0 {name=p38151 lab=_66785_/A }
C {devices/lab_pin.sym} 38440 -14260 0 0 {name=p38152 lab=_86793_/Q }
C {devices/lab_pin.sym} 38560 -14280 0 1 {name=p38153 lab=_66880_/X }
C {sky130_stdcells/and2_4.sym} 38500 -14280 0 0 {name=X_66880_ }
C {devices/lab_pin.sym} 38440 -14160 0 0 {name=p38154 lab=_78866_/A }
C {devices/lab_pin.sym} 38440 -14120 0 0 {name=p38155 lab=_78860_/Y }
C {devices/lab_pin.sym} 38560 -14140 0 1 {name=p38156 lab=_78867_/B }
C {sky130_stdcells/nor2_4.sym} 38500 -14140 0 0 {name=X_78866_ }
C {devices/lab_pin.sym} 38440 -14030 0 0 {name=p38157 lab=_65855_/A }
C {devices/lab_pin.sym} 38440 -13990 0 0 {name=p38158 lab=_65916_/B }
C {devices/lab_pin.sym} 38440 -13950 0 0 {name=p38159 lab=_84175_/Q }
C {devices/lab_pin.sym} 38560 -13990 0 1 {name=p38160 lab=_65831_/X }
C {sky130_stdcells/and3_4.sym} 38500 -13990 0 0 {name=X_65831_ }
C {devices/lab_pin.sym} 38440 -13860 0 0 {name=p38161 lab=_77817_/A }
C {devices/lab_pin.sym} 38440 -13820 0 0 {name=p38162 lab=_77816_/X }
C {devices/lab_pin.sym} 38560 -13840 0 1 {name=p38163 lab=_77822_/A }
C {sky130_stdcells/nand2_4.sym} 38500 -13840 0 0 {name=X_77817_ }
C {devices/lab_pin.sym} 38460 -13710 0 0 {name=p38164 lab=_83771_/Q }
C {devices/lab_pin.sym} 38540 -13710 0 1 {name=p38165 lab=_47978_/A }
C {sky130_stdcells/inv_2.sym} 38500 -13710 0 0 {name=X_47977_ }
C {devices/lab_pin.sym} 38440 -13600 0 0 {name=p38166 lab=_78797_/A }
C {devices/lab_pin.sym} 38440 -13560 0 0 {name=p38167 lab=_78797_/B }
C {devices/lab_pin.sym} 38560 -13580 0 1 {name=p38168 lab=_82785_/D }
C {sky130_stdcells/nand2_4.sym} 38500 -13580 0 0 {name=X_78797_ }
C {devices/lab_pin.sym} 38460 -13450 0 0 {name=p38169 lab=_49688_/X }
C {devices/lab_pin.sym} 38540 -13450 0 1 {name=p38170 lab=_49716_/X }
C {sky130_stdcells/buf_2.sym} 38500 -13450 0 0 {name=X_49716_ }
C {devices/lab_pin.sym} 38420 -13360 0 0 {name=p38171 lab=_87096_/Q }
C {devices/lab_pin.sym} 38420 -13320 0 0 {name=p38172 lab=_68353_/X }
C {devices/lab_pin.sym} 38420 -13280 0 0 {name=p38173 lab=_68354_/X }
C {devices/lab_pin.sym} 38420 -13240 0 0 {name=p38174 lab=_68549_/X }
C {devices/lab_pin.sym} 38580 -13300 0 1 {name=p38175 lab=_68551_/B }
C {sky130_stdcells/a211o_4.sym} 38500 -13300 0 0 {name=X_68550_ }
C {devices/lab_pin.sym} 38460 -13150 0 0 {name=p38176 lab=_46928_/A }
C {devices/lab_pin.sym} 38540 -13150 0 1 {name=p38177 lab=_54446_/B }
C {sky130_stdcells/inv_2.sym} 38500 -13150 0 0 {name=X_46928_ }
C {devices/lab_pin.sym} 38460 -13030 0 0 {name=p38178 lab=_64903_/A }
C {devices/lab_pin.sym} 38540 -13030 0 1 {name=p38179 lab=_65763_/A }
C {sky130_stdcells/buf_2.sym} 38500 -13030 0 0 {name=X_65762_ }
C {devices/lab_pin.sym} 38440 -12920 0 0 {name=p38180 lab=_77747_/B }
C {devices/lab_pin.sym} 38440 -12880 0 0 {name=p38181 lab=_82260_/Q }
C {devices/lab_pin.sym} 38560 -12900 0 1 {name=p38182 lab=_77751_/C }
C {sky130_stdcells/nand2_4.sym} 38500 -12900 0 0 {name=X_77748_ }
C {devices/lab_pin.sym} 38440 -12800 0 0 {name=p38183 lab=_61675_/B }
C {devices/lab_pin.sym} 38440 -12760 0 0 {name=p38184 lab=_62936_/X }
C {devices/lab_pin.sym} 38440 -12720 0 0 {name=p38185 lab=_62982_/C }
C {devices/lab_pin.sym} 38440 -12680 0 0 {name=p38186 lab=_62908_/X }
C {devices/lab_pin.sym} 38560 -12740 0 1 {name=p38187 lab=_62974_/Y }
C {sky130_stdcells/nand4_4.sym} 38500 -12740 0 0 {name=X_62974_ }
C {devices/lab_pin.sym} 38420 -12620 0 0 {name=p38188 lab=_87404_/Q }
C {devices/lab_pin.sym} 38420 -12580 0 0 {name=p38189 lab=_67476_/X }
C {devices/lab_pin.sym} 38420 -12540 0 0 {name=p38190 lab=_67477_/X }
C {devices/lab_pin.sym} 38420 -12500 0 0 {name=p38191 lab=_67500_/X }
C {devices/lab_pin.sym} 38580 -12560 0 1 {name=p38192 lab=_67501_/X }
C {sky130_stdcells/a211o_4.sym} 38500 -12560 0 0 {name=X_67501_ }
C {devices/lab_pin.sym} 38460 -12410 0 0 {name=p38193 lab=_64713_/A }
C {devices/lab_pin.sym} 38540 -12410 0 1 {name=p38194 lab=_64752_/A }
C {sky130_stdcells/buf_2.sym} 38500 -12410 0 0 {name=X_64713_ }
C {devices/lab_pin.sym} 38420 -12310 0 0 {name=p38195 lab=_49645_/Y }
C {devices/lab_pin.sym} 38420 -12270 0 0 {name=p38196 lab=_49623_/X }
C {devices/lab_pin.sym} 38420 -12230 0 0 {name=p38197 lab=_49646_/X }
C {devices/lab_pin.sym} 38580 -12270 0 1 {name=p38198 lab=_49647_/Y }
C {sky130_stdcells/a21oi_4.sym} 38500 -12270 0 0 {name=X_49647_ }
C {devices/lab_pin.sym} 38440 -12160 0 0 {name=p38199 lab=_61879_/A }
C {devices/lab_pin.sym} 38440 -12120 0 0 {name=p38200 lab=_61919_/Y }
C {devices/lab_pin.sym} 38440 -12080 0 0 {name=p38201 lab=_61921_/Y }
C {devices/lab_pin.sym} 38440 -12040 0 0 {name=p38202 lab=_61924_/Y }
C {devices/lab_pin.sym} 38560 -12100 0 1 {name=p38203 lab=_61925_/Y }
C {sky130_stdcells/nand4_4.sym} 38500 -12100 0 0 {name=X_61925_ }
C {devices/lab_pin.sym} 38420 -11980 0 0 {name=p38204 lab=_88015_/Q }
C {devices/lab_pin.sym} 38420 -11940 0 0 {name=p38205 lab=_68402_/X }
C {devices/lab_pin.sym} 38420 -11900 0 0 {name=p38206 lab=_68359_/X }
C {devices/lab_pin.sym} 38420 -11860 0 0 {name=p38207 lab=_68480_/X }
C {devices/lab_pin.sym} 38580 -11920 0 1 {name=p38208 lab=_68481_/X }
C {sky130_stdcells/a211o_4.sym} 38500 -11920 0 0 {name=X_68481_ }
C {devices/lab_pin.sym} 38460 -11770 0 0 {name=p38209 lab=_46767_/A }
C {devices/lab_pin.sym} 38540 -11770 0 1 {name=p38210 lab=_46859_/X }
C {sky130_stdcells/buf_2.sym} 38500 -11770 0 0 {name=X_46859_ }
C {devices/lab_pin.sym} 38420 -11680 0 0 {name=p38211 lab=_65596_/X }
C {devices/lab_pin.sym} 38420 -11640 0 0 {name=p38212 lab=_83064_/Q }
C {devices/lab_pin.sym} 38420 -11600 0 0 {name=p38213 lab=_65540_/X }
C {devices/lab_pin.sym} 38420 -11560 0 0 {name=p38214 lab=_65692_/X }
C {devices/lab_pin.sym} 38580 -11620 0 1 {name=p38215 lab=_65694_/B }
C {sky130_stdcells/a211o_4.sym} 38500 -11620 0 0 {name=X_65693_ }
C {devices/lab_pin.sym} 38460 -11470 0 0 {name=p38216 lab=_77678_/X }
C {devices/lab_pin.sym} 38540 -11470 0 1 {name=p38217 lab=_77679_/Y }
C {sky130_stdcells/inv_2.sym} 38500 -11470 0 0 {name=X_77679_ }
C {devices/lab_pin.sym} 38460 -11350 0 0 {name=p38218 lab=_66953_/X }
C {devices/lab_pin.sym} 38540 -11350 0 1 {name=p38219 lab=_67432_/X }
C {sky130_stdcells/buf_2.sym} 38500 -11350 0 0 {name=X_67432_ }
C {devices/lab_pin.sym} 38440 -11240 0 0 {name=p38220 lab=_79418_/A }
C {devices/lab_pin.sym} 38440 -11200 0 0 {name=p38221 lab=_79418_/B }
C {devices/lab_pin.sym} 38560 -11220 0 1 {name=p38222 lab=_79418_/X }
C {sky130_stdcells/and2_4.sym} 38500 -11220 0 0 {name=X_79418_ }
C {devices/lab_pin.sym} 38420 -11120 0 0 {name=p38223 lab=_64615_/X }
C {devices/lab_pin.sym} 38420 -11080 0 0 {name=p38224 lab=_85535_/Q }
C {devices/lab_pin.sym} 38420 -11040 0 0 {name=p38225 lab=_64642_/X }
C {devices/lab_pin.sym} 38420 -11000 0 0 {name=p38226 lab=_64643_/X }
C {devices/lab_pin.sym} 38580 -11060 0 1 {name=p38227 lab=_64644_/X }
C {sky130_stdcells/a211o_4.sym} 38500 -11060 0 0 {name=X_64644_ }
C {devices/lab_pin.sym} 38420 -10930 0 0 {name=p38228 lab=_49575_/Y }
C {devices/lab_pin.sym} 38420 -10890 0 0 {name=p38229 lab=_49570_/X }
C {devices/lab_pin.sym} 38420 -10850 0 0 {name=p38230 lab=_49577_/X }
C {devices/lab_pin.sym} 38580 -10890 0 1 {name=p38231 lab=_49578_/Y }
C {sky130_stdcells/a21oi_4.sym} 38500 -10890 0 0 {name=X_49578_ }
C {devices/lab_pin.sym} 38460 -10750 0 0 {name=p38232 lab=_61856_/A }
C {devices/lab_pin.sym} 38540 -10750 0 1 {name=p38233 lab=_61874_/D }
C {sky130_stdcells/buf_2.sym} 38500 -10750 0 0 {name=X_61856_ }
C {devices/lab_pin.sym} 38410 -10630 0 0 {name=p38234 lab=_80696_/CLK }
C {devices/lab_pin.sym} 38410 -10610 0 0 {name=p38235 lab=_80690_/D }
C {devices/lab_pin.sym} 38590 -10630 0 1 {name=p38236 lab=_80690_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -10620 0 0 {name=X_80690_ }
C {devices/lab_pin.sym} 38440 -10510 0 0 {name=p38237 lab=_60792_/A }
C {devices/lab_pin.sym} 38440 -10470 0 0 {name=p38238 lab=_60810_/B }
C {devices/lab_pin.sym} 38440 -10430 0 0 {name=p38239 lab=_84562_/Q }
C {devices/lab_pin.sym} 38560 -10470 0 1 {name=p38240 lab=_60807_/Y }
C {sky130_stdcells/nor3_4.sym} 38500 -10470 0 0 {name=X_60807_ }
C {devices/lab_pin.sym} 38460 -10330 0 0 {name=p38241 lab=_81778_/Q }
C {devices/lab_pin.sym} 38540 -10330 0 1 {name=p38242 lab=_48529_/Y }
C {sky130_stdcells/inv_2.sym} 38500 -10330 0 0 {name=X_48529_ }
C {devices/lab_pin.sym} 38420 -10230 0 0 {name=p38243 lab=_67357_/X }
C {devices/lab_pin.sym} 38420 -10190 0 0 {name=p38244 lab=_67362_/X }
C {devices/lab_pin.sym} 38420 -10150 0 0 {name=p38245 lab=_67264_/X }
C {devices/lab_pin.sym} 38580 -10190 0 1 {name=p38246 lab=_67367_/A }
C {sky130_stdcells/a21o_4.sym} 38500 -10190 0 0 {name=X_67363_ }
C {devices/lab_pin.sym} 38440 -10060 0 0 {name=p38247 lab=_79342_/X }
C {devices/lab_pin.sym} 38440 -10020 0 0 {name=p38248 lab=_79344_/B }
C {devices/lab_pin.sym} 38560 -10040 0 1 {name=p38249 lab=_79349_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -10040 0 0 {name=X_79349_ }
C {devices/lab_pin.sym} 38420 -9930 0 0 {name=p38250 lab=_64570_/X }
C {devices/lab_pin.sym} 38420 -9890 0 0 {name=p38251 lab=_64573_/X }
C {devices/lab_pin.sym} 38420 -9850 0 0 {name=p38252 lab=_64574_/X }
C {devices/lab_pin.sym} 38580 -9890 0 1 {name=p38253 lab=_64582_/A }
C {sky130_stdcells/a21o_4.sym} 38500 -9890 0 0 {name=X_64575_ }
C {devices/lab_pin.sym} 38460 -9750 0 0 {name=p38254 lab=_61755_/A }
C {devices/lab_pin.sym} 38540 -9750 0 1 {name=p38255 lab=_61787_/X }
C {sky130_stdcells/buf_2.sym} 38500 -9750 0 0 {name=X_61787_ }
C {devices/lab_pin.sym} 38420 -9650 0 0 {name=p38256 lab=_69097_/X }
C {devices/lab_pin.sym} 38420 -9610 0 0 {name=p38257 lab=_69101_/X }
C {devices/lab_pin.sym} 38420 -9570 0 0 {name=p38258 lab=_69035_/X }
C {devices/lab_pin.sym} 38580 -9610 0 1 {name=p38259 lab=_69102_/X }
C {sky130_stdcells/a21o_4.sym} 38500 -9610 0 0 {name=X_69102_ }
C {devices/lab_pin.sym} 38420 -9500 0 0 {name=p38260 lab=_66117_/X }
C {devices/lab_pin.sym} 38420 -9460 0 0 {name=p38261 lab=_84965_/Q }
C {devices/lab_pin.sym} 38420 -9420 0 0 {name=p38262 lab=_66118_/X }
C {devices/lab_pin.sym} 38420 -9380 0 0 {name=p38263 lab=_66313_/X }
C {devices/lab_pin.sym} 38580 -9440 0 1 {name=p38264 lab=_66314_/X }
C {sky130_stdcells/a211o_4.sym} 38500 -9440 0 0 {name=X_66314_ }
C {devices/lab_pin.sym} 38460 -9290 0 0 {name=p38265 lab=_51622_/A }
C {devices/lab_pin.sym} 38540 -9290 0 1 {name=p38266 lab=_51545_/A }
C {sky130_stdcells/buf_2.sym} 38500 -9290 0 0 {name=X_51540_ }
C {devices/lab_pin.sym} 38440 -9200 0 0 {name=p38267 lab=_59411_/A }
C {devices/lab_pin.sym} 38440 -9160 0 0 {name=p38268 lab=_63491_/B }
C {devices/lab_pin.sym} 38440 -9120 0 0 {name=p38269 lab=_63514_/C }
C {devices/lab_pin.sym} 38440 -9080 0 0 {name=p38270 lab=_63491_/D }
C {devices/lab_pin.sym} 38560 -9140 0 1 {name=p38271 lab=_63526_/Y }
C {sky130_stdcells/nand4_4.sym} 38500 -9140 0 0 {name=X_63526_ }
C {devices/lab_pin.sym} 38410 -8990 0 0 {name=p38272 lab=_82570_/CLK }
C {devices/lab_pin.sym} 38410 -8970 0 0 {name=p38273 lab=_77214_/X }
C {devices/lab_pin.sym} 38590 -8990 0 1 {name=p38274 lab=_82360_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -8980 0 0 {name=X_82360_ }
C {devices/lab_pin.sym} 38440 -8870 0 0 {name=p38275 lab=_60624_/A }
C {devices/lab_pin.sym} 38440 -8830 0 0 {name=p38276 lab=_60687_/A }
C {devices/lab_pin.sym} 38440 -8790 0 0 {name=p38277 lab=_60632_/X }
C {devices/lab_pin.sym} 38560 -8830 0 1 {name=p38278 lab=_60738_/Y }
C {sky130_stdcells/nand3_4.sym} 38500 -8830 0 0 {name=X_60738_ }
C {devices/lab_pin.sym} 38440 -8700 0 0 {name=p38279 lab=_67248_/A }
C {devices/lab_pin.sym} 38440 -8660 0 0 {name=p38280 lab=_67294_/B }
C {devices/lab_pin.sym} 38560 -8680 0 1 {name=p38281 lab=_67294_/X }
C {sky130_stdcells/and2_4.sym} 38500 -8680 0 0 {name=X_67294_ }
C {devices/lab_pin.sym} 38410 -8550 0 0 {name=p38282 lab=_81279_/CLK }
C {devices/lab_pin.sym} 38410 -8530 0 0 {name=p38283 lab=_76999_/X }
C {devices/lab_pin.sym} 38590 -8550 0 1 {name=p38284 lab=_81311_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -8540 0 0 {name=X_81311_ }
C {devices/lab_pin.sym} 38440 -8420 0 0 {name=p38285 lab=_69011_/A }
C {devices/lab_pin.sym} 38440 -8380 0 0 {name=p38286 lab=_69033_/B }
C {devices/lab_pin.sym} 38560 -8400 0 1 {name=p38287 lab=_69033_/X }
C {sky130_stdcells/and2_4.sym} 38500 -8400 0 0 {name=X_69033_ }
C {devices/lab_pin.sym} 38440 -8290 0 0 {name=p38288 lab=_65781_/X }
C {devices/lab_pin.sym} 38440 -8250 0 0 {name=p38289 lab=_66135_/B }
C {devices/lab_pin.sym} 38440 -8210 0 0 {name=p38290 lab=_65784_/X }
C {devices/lab_pin.sym} 38560 -8250 0 1 {name=p38291 lab=_66245_/Y }
C {sky130_stdcells/nand3_4.sym} 38500 -8250 0 0 {name=X_66245_ }
C {devices/lab_pin.sym} 38460 -8110 0 0 {name=p38292 lab=_51033_/A }
C {devices/lab_pin.sym} 38540 -8110 0 1 {name=p38293 lab=_51552_/A }
C {sky130_stdcells/buf_2.sym} 38500 -8110 0 0 {name=X_51471_ }
C {devices/lab_pin.sym} 38420 -8010 0 0 {name=p38294 lab=_63454_/Y }
C {devices/lab_pin.sym} 38420 -7970 0 0 {name=p38295 lab=_63455_/X }
C {devices/lab_pin.sym} 38420 -7930 0 0 {name=p38296 lab=_63456_/Y }
C {devices/lab_pin.sym} 38580 -7970 0 1 {name=p38297 lab=_84322_/D }
C {sky130_stdcells/a21oi_4.sym} 38500 -7970 0 0 {name=X_63457_ }
C {devices/lab_pin.sym} 38410 -7830 0 0 {name=p38298 lab=_82103_/CLK }
C {devices/lab_pin.sym} 38410 -7810 0 0 {name=p38299 lab=_77127_/B }
C {devices/lab_pin.sym} 38590 -7830 0 1 {name=p38300 lab=_41014_/A }
C {sky130_stdcells/dfxtp_4.sym} 38500 -7820 0 0 {name=X_82291_ }
C {devices/lab_pin.sym} 38460 -7690 0 0 {name=p38301 lab=_60770_/A }
C {devices/lab_pin.sym} 38540 -7690 0 1 {name=p38302 lab=_63398_/A }
C {sky130_stdcells/buf_2.sym} 38500 -7690 0 0 {name=X_60669_ }
C {devices/lab_pin.sym} 38460 -7570 0 0 {name=p38303 lab=clkbuf_6_61_0_CLK/X }
C {devices/lab_pin.sym} 38540 -7570 0 1 {name=p38304 lab=clkbuf_8_245_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 38500 -7570 0 0 {name=Xclkbuf_7_122_0_CLK }
C {devices/lab_pin.sym} 38420 -7470 0 0 {name=p38305 lab=_85676_/Q }
C {devices/lab_pin.sym} 38420 -7430 0 0 {name=p38306 lab=_53198_/X }
C {devices/lab_pin.sym} 38420 -7390 0 0 {name=p38307 lab=_53209_/Y }
C {devices/lab_pin.sym} 38580 -7430 0 1 {name=p38308 lab=_53210_/Y }
C {sky130_stdcells/o21ai_4.sym} 38500 -7430 0 0 {name=X_53210_ }
C {devices/lab_pin.sym} 38410 -7290 0 0 {name=p38309 lab=_81154_/CLK }
C {devices/lab_pin.sym} 38410 -7270 0 0 {name=p38310 lab=_68136_/X }
C {devices/lab_pin.sym} 38590 -7290 0 1 {name=p38311 lab=_82070_/D }
C {sky130_stdcells/dfxtp_4.sym} 38500 -7280 0 0 {name=X_84030_ }
C {devices/lab_pin.sym} 38420 -7170 0 0 {name=p38312 lab=_50420_/Y }
C {devices/lab_pin.sym} 38420 -7130 0 0 {name=p38313 lab=_50380_/X }
C {devices/lab_pin.sym} 38420 -7090 0 0 {name=p38314 lab=_50421_/Y }
C {devices/lab_pin.sym} 38580 -7130 0 1 {name=p38315 lab=_50422_/Y }
C {sky130_stdcells/a21boi_4.sym} 38500 -7130 0 0 {name=X_50422_ }
C {devices/lab_pin.sym} 38440 -7020 0 0 {name=p38316 lab=_62337_/A }
C {devices/lab_pin.sym} 38440 -6980 0 0 {name=p38317 lab=_61939_/X }
C {devices/lab_pin.sym} 38440 -6940 0 0 {name=p38318 lab=_62364_/X }
C {devices/lab_pin.sym} 38440 -6900 0 0 {name=p38319 lab=_62392_/D }
C {devices/lab_pin.sym} 38560 -6960 0 1 {name=p38320 lab=_62408_/X }
C {sky130_stdcells/and4_4.sym} 38500 -6960 0 0 {name=X_62408_ }
C {devices/lab_pin.sym} 38410 -6810 0 0 {name=p38321 lab=_85338_/CLK }
C {devices/lab_pin.sym} 38410 -6790 0 0 {name=p38322 lab=_81050_/Q }
C {devices/lab_pin.sym} 38590 -6810 0 1 {name=p38323 lab=_81242_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -6800 0 0 {name=X_81242_ }
C {devices/lab_pin.sym} 38460 -6670 0 0 {name=p38324 lab=_54217_/A }
C {devices/lab_pin.sym} 38540 -6670 0 1 {name=p38325 lab=_54191_/B }
C {sky130_stdcells/buf_2.sym} 38500 -6670 0 0 {name=X_54190_ }
C {devices/lab_pin.sym} 38460 -6550 0 0 {name=p38326 lab=_84151_/Q }
C {devices/lab_pin.sym} 38540 -6550 0 1 {name=p38327 lab=_66177_/C }
C {sky130_stdcells/inv_2.sym} 38500 -6550 0 0 {name=X_66176_ }
C {devices/lab_pin.sym} 38420 -6460 0 0 {name=p38328 lab=_61354_/B }
C {devices/lab_pin.sym} 38420 -6420 0 0 {name=p38329 lab=_60834_/X }
C {devices/lab_pin.sym} 38420 -6380 0 0 {name=p38330 lab=_63386_/X }
C {devices/lab_pin.sym} 38420 -6340 0 0 {name=p38331 lab=_63387_/X }
C {devices/lab_pin.sym} 38580 -6400 0 1 {name=p38332 lab=_63388_/X }
C {sky130_stdcells/a211o_4.sym} 38500 -6400 0 0 {name=X_63388_ }
C {devices/lab_pin.sym} 38440 -6260 0 0 {name=p38333 lab=_53121_/X }
C {devices/lab_pin.sym} 38440 -6220 0 0 {name=p38334 lab=_53141_/B }
C {devices/lab_pin.sym} 38560 -6240 0 1 {name=p38335 lab=_53141_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -6240 0 0 {name=X_53141_ }
C {devices/lab_pin.sym} 38460 -6110 0 0 {name=p38336 lab=_64776_/A }
C {devices/lab_pin.sym} 38540 -6110 0 1 {name=p38337 lab=_65127_/X }
C {sky130_stdcells/buf_2.sym} 38500 -6110 0 0 {name=X_65127_ }
C {devices/lab_pin.sym} 38460 -5990 0 0 {name=p38338 lab=clkbuf_9_46_0_CLK/X }
C {devices/lab_pin.sym} 38540 -5990 0 1 {name=p38339 lab=_84414_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 38500 -5990 0 0 {name=Xclkbuf_10_92_0_CLK }
C {devices/lab_pin.sym} 38420 -5890 0 0 {name=p38340 lab=_50350_/Y }
C {devices/lab_pin.sym} 38420 -5850 0 0 {name=p38341 lab=_50351_/X }
C {devices/lab_pin.sym} 38420 -5810 0 0 {name=p38342 lab=_50352_/Y }
C {devices/lab_pin.sym} 38580 -5850 0 1 {name=p38343 lab=_50353_/Y }
C {sky130_stdcells/a21boi_4.sym} 38500 -5850 0 0 {name=X_50353_ }
C {devices/lab_pin.sym} 38420 -5750 0 0 {name=p38344 lab=_62330_/X }
C {devices/lab_pin.sym} 38420 -5710 0 0 {name=p38345 lab=_62335_/Y }
C {devices/lab_pin.sym} 38420 -5670 0 0 {name=p38346 lab=_62338_/X }
C {devices/lab_pin.sym} 38420 -5630 0 0 {name=p38347 lab=_84745_/Q }
C {devices/lab_pin.sym} 38420 -5590 0 0 {name=p38348 lab=_62300_/X }
C {devices/lab_pin.sym} 38580 -5670 0 1 {name=p38349 lab=_62339_/Y }
C {sky130_stdcells/o32ai_4.sym} 38500 -5670 0 0 {name=X_62339_ }
C {devices/lab_pin.sym} 38410 -5510 0 0 {name=p38350 lab=_82335_/CLK }
C {devices/lab_pin.sym} 38410 -5490 0 0 {name=p38351 lab=_74985_/B }
C {devices/lab_pin.sym} 38590 -5510 0 1 {name=p38352 lab=_81173_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -5500 0 0 {name=X_81173_ }
C {devices/lab_pin.sym} 38460 -5370 0 0 {name=p38353 lab=_44196_/D }
C {devices/lab_pin.sym} 38540 -5370 0 1 {name=p38354 lab=_56278_/A }
C {sky130_stdcells/buf_2.sym} 38500 -5370 0 0 {name=Xpsn_inst_psn_buff_10 }
C {devices/lab_pin.sym} 38460 -5250 0 0 {name=p38355 lab=_53441_/A }
C {devices/lab_pin.sym} 38540 -5250 0 1 {name=p38356 lab=_43019_/B1 }
C {sky130_stdcells/buf_2.sym} 38500 -5250 0 0 {name=Xpsn_inst_psn_buff_21 }
C {devices/lab_pin.sym} 38460 -5130 0 0 {name=p38357 lab=_47002_/A }
C {devices/lab_pin.sym} 38540 -5130 0 1 {name=p38358 lab=_40352_/A }
C {sky130_stdcells/buf_2.sym} 38500 -5130 0 0 {name=Xpsn_inst_psn_buff_32 }
C {devices/lab_pin.sym} 38440 -5020 0 0 {name=p38359 lab=_84669_/Q }
C {devices/lab_pin.sym} 38440 -4980 0 0 {name=p38360 lab=_63944_/C }
C {devices/lab_pin.sym} 38560 -5000 0 1 {name=p38361 lab=_80124_/X }
C {sky130_stdcells/xor2_4.sym} 38500 -5000 0 0 {name=X_80124_ }
C {devices/lab_pin.sym} 38440 -4880 0 0 {name=p38362 lab=_53080_/A }
C {devices/lab_pin.sym} 38440 -4840 0 0 {name=p38363 lab=_53072_/B }
C {devices/lab_pin.sym} 38560 -4860 0 1 {name=p38364 lab=_53072_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -4860 0 0 {name=X_53072_ }
C {devices/lab_pin.sym} 38420 -4760 0 0 {name=p38365 lab=_65009_/X }
C {devices/lab_pin.sym} 38420 -4720 0 0 {name=p38366 lab=_86160_/Q }
C {devices/lab_pin.sym} 38420 -4680 0 0 {name=p38367 lab=_64902_/X }
C {devices/lab_pin.sym} 38420 -4640 0 0 {name=p38368 lab=_65057_/X }
C {devices/lab_pin.sym} 38580 -4700 0 1 {name=p38369 lab=_65058_/X }
C {sky130_stdcells/a211o_4.sym} 38500 -4700 0 0 {name=X_65058_ }
C {devices/lab_pin.sym} 38440 -4560 0 0 {name=p38370 lab=_69900_/A }
C {devices/lab_pin.sym} 38440 -4520 0 0 {name=p38371 lab=_69935_/B }
C {devices/lab_pin.sym} 38560 -4540 0 1 {name=p38372 lab=_69935_/X }
C {sky130_stdcells/and2_4.sym} 38500 -4540 0 0 {name=X_69935_ }
C {devices/lab_pin.sym} 38460 -4410 0 0 {name=p38373 lab=_50500_/A }
C {devices/lab_pin.sym} 38540 -4410 0 1 {name=p38374 lab=_50285_/A }
C {sky130_stdcells/buf_2.sym} 38500 -4410 0 0 {name=X_50284_ }
C {devices/lab_pin.sym} 38410 -4290 0 0 {name=p38375 lab=_85981_/CLK }
C {devices/lab_pin.sym} 38410 -4270 0 0 {name=p38376 lab=_85981_/D }
C {devices/lab_pin.sym} 38590 -4290 0 1 {name=p38377 lab=_85981_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -4280 0 0 {name=X_85981_ }
C {devices/lab_pin.sym} 38440 -4160 0 0 {name=p38378 lab=_56866_/A }
C {devices/lab_pin.sym} 38440 -4120 0 0 {name=p38379 lab=_56899_/Y }
C {devices/lab_pin.sym} 38560 -4140 0 1 {name=p38380 lab=_56900_/X }
C {sky130_stdcells/and2_4.sym} 38500 -4140 0 0 {name=X_56900_ }
C {devices/lab_pin.sym} 38460 -4010 0 0 {name=p38381 lab=_52274_/A }
C {devices/lab_pin.sym} 38540 -4010 0 1 {name=p38382 lab=_52431_/A }
C {sky130_stdcells/buf_2.sym} 38500 -4010 0 0 {name=X_52023_ }
C {devices/lab_pin.sym} 38440 -3910 0 0 {name=p38383 lab=_64074_/A }
C {devices/lab_pin.sym} 38440 -3870 0 0 {name=p38384 lab=_64074_/B }
C {devices/lab_pin.sym} 38440 -3830 0 0 {name=p38385 lab=_80082_/B }
C {devices/lab_pin.sym} 38560 -3870 0 1 {name=p38386 lab=_64009_/Y }
C {sky130_stdcells/nor3_4.sym} 38500 -3870 0 0 {name=X_64009_ }
C {devices/lab_pin.sym} 38410 -3730 0 0 {name=p38387 lab=_87720_/CLK }
C {devices/lab_pin.sym} 38410 -3710 0 0 {name=p38388 lab=_87720_/D }
C {devices/lab_pin.sym} 38590 -3730 0 1 {name=p38389 lab=_87720_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -3720 0 0 {name=X_87720_ }
C {devices/lab_pin.sym} 38410 -3590 0 0 {name=p38390 lab=_84930_/CLK }
C {devices/lab_pin.sym} 38410 -3570 0 0 {name=p38391 lab=_84932_/D }
C {devices/lab_pin.sym} 38590 -3590 0 1 {name=p38392 lab=_84932_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -3580 0 0 {name=X_84932_ }
C {devices/lab_pin.sym} 38420 -3470 0 0 {name=p38393 lab=_80052_/Y }
C {devices/lab_pin.sym} 38420 -3430 0 0 {name=p38394 lab=_80035_/Y }
C {devices/lab_pin.sym} 38420 -3390 0 0 {name=p38395 lab=_80054_/X }
C {devices/lab_pin.sym} 38580 -3430 0 1 {name=p38396 lab=_80056_/B }
C {sky130_stdcells/o21ai_4.sym} 38500 -3430 0 0 {name=X_80055_ }
C {devices/lab_pin.sym} 38420 -3310 0 0 {name=p38397 lab=_57838_/X }
C {devices/lab_pin.sym} 38420 -3270 0 0 {name=p38398 lab=_86007_/Q }
C {devices/lab_pin.sym} 38420 -3230 0 0 {name=p38399 lab=_57879_/X }
C {devices/lab_pin.sym} 38580 -3270 0 1 {name=p38400 lab=_57880_/Y }
C {sky130_stdcells/o21ai_4.sym} 38500 -3270 0 0 {name=X_57880_ }
C {devices/lab_pin.sym} 38420 -3160 0 0 {name=p38401 lab=_87049_/Q }
C {devices/lab_pin.sym} 38420 -3120 0 0 {name=p38402 lab=_66608_/X }
C {devices/lab_pin.sym} 38420 -3080 0 0 {name=p38403 lab=_58827_/A }
C {devices/lab_pin.sym} 38420 -3040 0 0 {name=p38404 lab=_69865_/X }
C {devices/lab_pin.sym} 38580 -3100 0 1 {name=p38405 lab=_69866_/X }
C {sky130_stdcells/a211o_4.sym} 38500 -3100 0 0 {name=X_69866_ }
C {devices/lab_pin.sym} 38440 -2960 0 0 {name=p38406 lab=_55264_/A }
C {devices/lab_pin.sym} 38440 -2920 0 0 {name=p38407 lab=_55264_/C }
C {devices/lab_pin.sym} 38560 -2940 0 1 {name=p38408 lab=_56831_/X }
C {sky130_stdcells/and2_4.sym} 38500 -2940 0 0 {name=X_56831_ }
C {devices/lab_pin.sym} 38420 -2830 0 0 {name=p38409 lab=_68814_/X }
C {devices/lab_pin.sym} 38420 -2790 0 0 {name=p38410 lab=_68816_/X }
C {devices/lab_pin.sym} 38420 -2750 0 0 {name=p38411 lab=_68773_/X }
C {devices/lab_pin.sym} 38580 -2790 0 1 {name=p38412 lab=_68817_/X }
C {sky130_stdcells/a21o_4.sym} 38500 -2790 0 0 {name=X_68817_ }
C {devices/lab_pin.sym} 38410 -2650 0 0 {name=p38413 lab=_87394_/CLK }
C {devices/lab_pin.sym} 38410 -2630 0 0 {name=p38414 lab=_87651_/D }
C {devices/lab_pin.sym} 38590 -2650 0 1 {name=p38415 lab=_67714_/B }
C {sky130_stdcells/dfxtp_4.sym} 38500 -2640 0 0 {name=X_87651_ }
C {devices/lab_pin.sym} 38410 -2510 0 0 {name=p38416 lab=_84344_/CLK }
C {devices/lab_pin.sym} 38410 -2490 0 0 {name=p38417 lab=_84863_/D }
C {devices/lab_pin.sym} 38590 -2510 0 1 {name=p38418 lab=_58382_/A }
C {sky130_stdcells/dfxtp_4.sym} 38500 -2500 0 0 {name=X_84863_ }
C {devices/lab_pin.sym} 38460 -2370 0 0 {name=p38419 lab=_69797_/A }
C {devices/lab_pin.sym} 38540 -2370 0 1 {name=p38420 lab=_69797_/X }
C {sky130_stdcells/buf_2.sym} 38500 -2370 0 0 {name=X_69797_ }
C {devices/lab_pin.sym} 38460 -2250 0 0 {name=p38421 lab=clkbuf_8_253_0_CLK/A }
C {devices/lab_pin.sym} 38540 -2250 0 1 {name=p38422 lab=clkbuf_9_506_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 38500 -2250 0 0 {name=Xclkbuf_8_253_0_CLK }
C {devices/lab_pin.sym} 38410 -2130 0 0 {name=p38423 lab=_85961_/CLK }
C {devices/lab_pin.sym} 38410 -2110 0 0 {name=p38424 lab=_86602_/D }
C {devices/lab_pin.sym} 38590 -2130 0 1 {name=p38425 lab=_86602_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -2120 0 0 {name=X_86602_ }
C {devices/lab_pin.sym} 38440 -2010 0 0 {name=p38426 lab=_59564_/A }
C {devices/lab_pin.sym} 38440 -1970 0 0 {name=p38427 lab=_59516_/A }
C {devices/lab_pin.sym} 38440 -1930 0 0 {name=p38428 lab=_59581_/C }
C {devices/lab_pin.sym} 38560 -1970 0 1 {name=p38429 lab=_59551_/A }
C {sky130_stdcells/nand3_4.sym} 38500 -1970 0 0 {name=X_59550_ }
C {devices/lab_pin.sym} 38410 -1830 0 0 {name=p38430 lab=_83842_/CLK }
C {devices/lab_pin.sym} 38410 -1810 0 0 {name=p38431 lab=_70276_/X }
C {devices/lab_pin.sym} 38590 -1830 0 1 {name=p38432 lab=_74781_/A }
C {sky130_stdcells/dfxtp_4.sym} 38500 -1820 0 0 {name=X_83814_ }
C {devices/lab_pin.sym} 38460 -1690 0 0 {name=p38433 lab=_56733_/X }
C {devices/lab_pin.sym} 38540 -1690 0 1 {name=p38434 lab=_57003_/B }
C {sky130_stdcells/buf_2.sym} 38500 -1690 0 0 {name=X_56762_ }
C {devices/lab_pin.sym} 38460 -1570 0 0 {name=p38435 lab=_69678_/A }
C {devices/lab_pin.sym} 38540 -1570 0 1 {name=p38436 lab=_68748_/X }
C {sky130_stdcells/buf_2.sym} 38500 -1570 0 0 {name=X_68748_ }
C {devices/lab_pin.sym} 38410 -1450 0 0 {name=p38437 lab=_88327_/CLK }
C {devices/lab_pin.sym} 38410 -1430 0 0 {name=p38438 lab=_87582_/D }
C {devices/lab_pin.sym} 38590 -1450 0 1 {name=p38439 lab=_74053_/A }
C {sky130_stdcells/dfxtp_4.sym} 38500 -1440 0 0 {name=X_87582_ }
C {devices/lab_pin.sym} 38440 -1320 0 0 {name=p38440 lab=_53978_/A }
C {devices/lab_pin.sym} 38440 -1280 0 0 {name=p38441 lab=_52454_/B }
C {devices/lab_pin.sym} 38560 -1300 0 1 {name=p38442 lab=_53974_/Y }
C {sky130_stdcells/nand2_4.sym} 38500 -1300 0 0 {name=X_53974_ }
C {devices/lab_pin.sym} 38410 -1170 0 0 {name=p38443 lab=_86701_/CLK }
C {devices/lab_pin.sym} 38410 -1150 0 0 {name=p38444 lab=_84794_/D }
C {devices/lab_pin.sym} 38590 -1170 0 1 {name=p38445 lab=_84794_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -1160 0 0 {name=X_84794_ }
C {devices/lab_pin.sym} 38460 -1030 0 0 {name=p38446 lab=_64307_/C }
C {devices/lab_pin.sym} 38540 -1030 0 1 {name=p38447 lab=_63459_/B }
C {sky130_stdcells/buf_2.sym} 38500 -1030 0 0 {name=X_58501_ }
C {devices/lab_pin.sym} 38440 -920 0 0 {name=p38448 lab=_55235_/A }
C {devices/lab_pin.sym} 38440 -880 0 0 {name=p38449 lab=_55713_/B }
C {devices/lab_pin.sym} 38560 -900 0 1 {name=p38450 lab=_55713_/X }
C {sky130_stdcells/and2_4.sym} 38500 -900 0 0 {name=X_55713_ }
C {devices/lab_pin.sym} 38410 -770 0 0 {name=p38451 lab=_86203_/CLK }
C {devices/lab_pin.sym} 38410 -750 0 0 {name=p38452 lab=_48339_/Y }
C {devices/lab_pin.sym} 38590 -770 0 1 {name=p38453 lab=_86533_/Q }
C {sky130_stdcells/dfxtp_4.sym} 38500 -760 0 0 {name=X_86533_ }
C {devices/lab_pin.sym} 39340 -42170 0 0 {name=p38454 lab=_85729_/Q }
C {devices/lab_pin.sym} 39340 -42130 0 0 {name=p38455 lab=_52902_/X }
C {devices/lab_pin.sym} 39340 -42090 0 0 {name=p38456 lab=_52924_/Y }
C {devices/lab_pin.sym} 39500 -42130 0 1 {name=p38457 lab=_52925_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -42130 0 0 {name=X_52925_ }
C {devices/lab_pin.sym} 39380 -41990 0 0 {name=p38458 lab=clkbuf_9_15_0_CLK/X }
C {devices/lab_pin.sym} 39460 -41990 0 1 {name=p38459 lab=_82979_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 39420 -41990 0 0 {name=Xclkbuf_10_30_0_CLK }
C {devices/lab_pin.sym} 39380 -41870 0 0 {name=p38460 lab=_64225_/C }
C {devices/lab_pin.sym} 39460 -41870 0 1 {name=p38461 lab=_63369_/B }
C {sky130_stdcells/buf_2.sym} 39420 -41870 0 0 {name=X_59481_ }
C {devices/lab_pin.sym} 39330 -41750 0 0 {name=p38462 lab=_83745_/CLK }
C {devices/lab_pin.sym} 39330 -41730 0 0 {name=p38463 lab=_83745_/D }
C {devices/lab_pin.sym} 39510 -41750 0 1 {name=p38464 lab=_47297_/A }
C {sky130_stdcells/dfxtp_4.sym} 39420 -41740 0 0 {name=X_83745_ }
C {devices/lab_pin.sym} 39360 -41630 0 0 {name=p38465 lab=_72765_/A }
C {devices/lab_pin.sym} 39360 -41590 0 0 {name=p38466 lab=_56672_/Y }
C {devices/lab_pin.sym} 39360 -41550 0 0 {name=p38467 lab=_56693_/C }
C {devices/lab_pin.sym} 39480 -41590 0 1 {name=p38468 lab=_56694_/C }
C {sky130_stdcells/nand3_4.sym} 39420 -41590 0 0 {name=X_56693_ }
C {devices/lab_pin.sym} 39360 -41460 0 0 {name=p38469 lab=_68599_/A }
C {devices/lab_pin.sym} 39360 -41420 0 0 {name=p38470 lab=_87751_/Q }
C {devices/lab_pin.sym} 39480 -41440 0 1 {name=p38471 lab=_68679_/X }
C {sky130_stdcells/and2_4.sym} 39420 -41440 0 0 {name=X_68679_ }
C {devices/lab_pin.sym} 39330 -41310 0 0 {name=p38472 lab=_81197_/CLK }
C {devices/lab_pin.sym} 39330 -41290 0 0 {name=p38473 lab=_75475_/B }
C {devices/lab_pin.sym} 39510 -41310 0 1 {name=p38474 lab=_75045_/A }
C {sky130_stdcells/dfxtp_4.sym} 39420 -41300 0 0 {name=X_80957_ }
C {devices/lab_pin.sym} 39360 -41200 0 0 {name=p38475 lab=_70710_/A }
C {devices/lab_pin.sym} 39360 -41160 0 0 {name=p38476 lab=_70703_/X }
C {devices/lab_pin.sym} 39360 -41120 0 0 {name=p38477 lab=_70710_/C }
C {devices/lab_pin.sym} 39360 -41080 0 0 {name=p38478 lab=_70710_/D }
C {devices/lab_pin.sym} 39480 -41140 0 1 {name=p38479 lab=_70710_/Y }
C {sky130_stdcells/nand4_4.sym} 39420 -41140 0 0 {name=X_70710_ }
C {devices/lab_pin.sym} 39380 -40990 0 0 {name=p38480 lab=_84849_/Q }
C {devices/lab_pin.sym} 39460 -40990 0 1 {name=p38481 lab=_63198_/A }
C {sky130_stdcells/inv_2.sym} 39420 -40990 0 0 {name=X_58432_ }
C {devices/lab_pin.sym} 39380 -40870 0 0 {name=p38482 lab=_55644_/A }
C {devices/lab_pin.sym} 39460 -40870 0 1 {name=p38483 lab=_56564_/D }
C {sky130_stdcells/buf_2.sym} 39420 -40870 0 0 {name=X_55644_ }
C {devices/lab_pin.sym} 39330 -40750 0 0 {name=p38484 lab=_83311_/CLK }
C {devices/lab_pin.sym} 39330 -40730 0 0 {name=p38485 lab=_48895_/Y }
C {devices/lab_pin.sym} 39510 -40750 0 1 {name=p38486 lab=_86464_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -40740 0 0 {name=X_86464_ }
C {devices/lab_pin.sym} 39340 -40630 0 0 {name=p38487 lab=_85742_/Q }
C {devices/lab_pin.sym} 39340 -40590 0 0 {name=p38488 lab=_52848_/X }
C {devices/lab_pin.sym} 39340 -40550 0 0 {name=p38489 lab=_52855_/Y }
C {devices/lab_pin.sym} 39500 -40590 0 1 {name=p38490 lab=_52856_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -40590 0 0 {name=X_52856_ }
C {devices/lab_pin.sym} 39380 -40450 0 0 {name=p38491 lab=_40835_/A }
C {devices/lab_pin.sym} 39460 -40450 0 1 {name=p38492 lab=_40870_/X }
C {sky130_stdcells/buf_2.sym} 39420 -40450 0 0 {name=X_40870_ }
C {devices/lab_pin.sym} 39360 -40340 0 0 {name=p38493 lab=_71690_/A }
C {devices/lab_pin.sym} 39360 -40300 0 0 {name=p38494 lab=_71319_/B }
C {devices/lab_pin.sym} 39480 -40320 0 1 {name=p38495 lab=_71690_/Y }
C {sky130_stdcells/nor2_4.sym} 39420 -40320 0 0 {name=X_71690_ }
C {devices/lab_pin.sym} 39330 -40190 0 0 {name=p38496 lab=_83676_/CLK }
C {devices/lab_pin.sym} 39330 -40170 0 0 {name=p38497 lab=_70874_/Y }
C {devices/lab_pin.sym} 39510 -40190 0 1 {name=p38498 lab=_83676_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -40180 0 0 {name=X_83676_ }
C {devices/lab_pin.sym} 39330 -40050 0 0 {name=p38499 lab=_80991_/CLK }
C {devices/lab_pin.sym} 39330 -40030 0 0 {name=p38500 lab=_80888_/D }
C {devices/lab_pin.sym} 39510 -40050 0 1 {name=p38501 lab=_80888_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -40040 0 0 {name=X_80888_ }
C {devices/lab_pin.sym} 39380 -39910 0 0 {name=p38502 lab=clkbuf_9_131_0_CLK/X }
C {devices/lab_pin.sym} 39460 -39910 0 1 {name=p38503 lab=_83763_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 39420 -39910 0 0 {name=Xclkbuf_10_263_0_CLK }
C {devices/lab_pin.sym} 39330 -39790 0 0 {name=p38504 lab=_87126_/CLK }
C {devices/lab_pin.sym} 39330 -39770 0 0 {name=p38505 lab=_88203_/D }
C {devices/lab_pin.sym} 39510 -39790 0 1 {name=p38506 lab=_88203_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -39780 0 0 {name=X_88203_ }
C {devices/lab_pin.sym} 39330 -39650 0 0 {name=p38507 lab=_85735_/CLK }
C {devices/lab_pin.sym} 39330 -39630 0 0 {name=p38508 lab=_54586_/Y }
C {devices/lab_pin.sym} 39510 -39650 0 1 {name=p38509 lab=_85415_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -39640 0 0 {name=X_85415_ }
C {devices/lab_pin.sym} 39360 -39520 0 0 {name=p38510 lab=_51796_/A }
C {devices/lab_pin.sym} 39360 -39480 0 0 {name=p38511 lab=_51807_/B }
C {devices/lab_pin.sym} 39480 -39500 0 1 {name=p38512 lab=_51807_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -39500 0 0 {name=X_51807_ }
C {devices/lab_pin.sym} 39380 -39370 0 0 {name=p38513 lab=_70773_/A }
C {devices/lab_pin.sym} 39460 -39370 0 1 {name=p38514 lab=_70925_/A }
C {sky130_stdcells/buf_2.sym} 39420 -39370 0 0 {name=X_70641_ }
C {devices/lab_pin.sym} 39330 -39250 0 0 {name=p38515 lab=_87421_/CLK }
C {devices/lab_pin.sym} 39330 -39230 0 0 {name=p38516 lab=_83979_/Q }
C {devices/lab_pin.sym} 39510 -39250 0 1 {name=p38517 lab=_82627_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -39240 0 0 {name=X_82627_ }
C {devices/lab_pin.sym} 39380 -39110 0 0 {name=p38518 lab=_63335_/A }
C {devices/lab_pin.sym} 39460 -39110 0 1 {name=p38519 lab=_58364_/A }
C {sky130_stdcells/buf_2.sym} 39420 -39110 0 0 {name=X_58363_ }
C {devices/lab_pin.sym} 39360 -39000 0 0 {name=p38520 lab=_44064_/X }
C {devices/lab_pin.sym} 39360 -38960 0 0 {name=p38521 lab=_45474_/Y }
C {devices/lab_pin.sym} 39480 -38980 0 1 {name=p38522 lab=_55575_/Y }
C {sky130_stdcells/nor2_4.sym} 39420 -38980 0 0 {name=X_55575_ }
C {devices/lab_pin.sym} 39380 -38850 0 0 {name=p38523 lab=clkbuf_9_446_0_CLK/X }
C {devices/lab_pin.sym} 39460 -38850 0 1 {name=p38524 lab=_85822_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 39420 -38850 0 0 {name=Xclkbuf_10_893_0_CLK }
C {devices/lab_pin.sym} 39330 -38730 0 0 {name=p38525 lab=_86393_/CLK }
C {devices/lab_pin.sym} 39330 -38710 0 0 {name=p38526 lab=_86395_/D }
C {devices/lab_pin.sym} 39510 -38730 0 1 {name=p38527 lab=_86395_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -38720 0 0 {name=X_86395_ }
C {devices/lab_pin.sym} 39360 -38600 0 0 {name=p38528 lab=_52773_/A }
C {devices/lab_pin.sym} 39360 -38560 0 0 {name=p38529 lab=_52787_/B }
C {devices/lab_pin.sym} 39480 -38580 0 1 {name=p38530 lab=_52787_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -38580 0 0 {name=X_52787_ }
C {devices/lab_pin.sym} 39360 -38470 0 0 {name=p38531 lab=_56797_/A }
C {devices/lab_pin.sym} 39360 -38430 0 0 {name=p38532 lab=_57327_/B }
C {devices/lab_pin.sym} 39360 -38390 0 0 {name=p38533 lab=_56796_/Y }
C {devices/lab_pin.sym} 39480 -38430 0 1 {name=p38534 lab=_57315_/A }
C {sky130_stdcells/nand3_4.sym} 39420 -38430 0 0 {name=X_57314_ }
C {devices/lab_pin.sym} 39380 -38290 0 0 {name=p38535 lab=clkbuf_9_22_0_CLK/X }
C {devices/lab_pin.sym} 39460 -38290 0 1 {name=p38536 lab=_85013_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 39420 -38290 0 0 {name=Xclkbuf_10_45_0_CLK }
C {devices/lab_pin.sym} 39330 -38170 0 0 {name=p38537 lab=_88133_/CLK }
C {devices/lab_pin.sym} 39330 -38150 0 0 {name=p38538 lab=_88134_/D }
C {devices/lab_pin.sym} 39510 -38170 0 1 {name=p38539 lab=_66892_/B }
C {sky130_stdcells/dfxtp_4.sym} 39420 -38160 0 0 {name=X_88134_ }
C {devices/lab_pin.sym} 39380 -38030 0 0 {name=p38540 lab=_42612_/A }
C {devices/lab_pin.sym} 39460 -38030 0 1 {name=p38541 lab=_42540_/X }
C {sky130_stdcells/buf_2.sym} 39420 -38030 0 0 {name=X_42540_ }
C {devices/lab_pin.sym} 39360 -37940 0 0 {name=p38542 lab=_54509_/A }
C {devices/lab_pin.sym} 39360 -37900 0 0 {name=p38543 lab=_54526_/B }
C {devices/lab_pin.sym} 39360 -37860 0 0 {name=p38544 lab=_54509_/C }
C {devices/lab_pin.sym} 39360 -37820 0 0 {name=p38545 lab=_54526_/D }
C {devices/lab_pin.sym} 39480 -37880 0 1 {name=p38546 lab=_54526_/X }
C {sky130_stdcells/and4_4.sym} 39420 -37880 0 0 {name=X_54526_ }
C {devices/lab_pin.sym} 39360 -37740 0 0 {name=p38547 lab=_73407_/A }
C {devices/lab_pin.sym} 39360 -37700 0 0 {name=p38548 lab=_86506_/Q }
C {devices/lab_pin.sym} 39480 -37720 0 1 {name=p38549 lab=_73360_/X }
C {sky130_stdcells/and2_4.sym} 39420 -37720 0 0 {name=X_73360_ }
C {devices/lab_pin.sym} 39330 -37590 0 0 {name=p38550 lab=_85346_/CLK }
C {devices/lab_pin.sym} 39330 -37570 0 0 {name=p38551 lab=_85346_/D }
C {devices/lab_pin.sym} 39510 -37590 0 1 {name=p38552 lab=_85346_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -37580 0 0 {name=X_85346_ }
C {devices/lab_pin.sym} 39340 -37470 0 0 {name=p38553 lab=_85954_/Q }
C {devices/lab_pin.sym} 39340 -37430 0 0 {name=p38554 lab=_50220_/X }
C {devices/lab_pin.sym} 39340 -37390 0 0 {name=p38555 lab=_51737_/Y }
C {devices/lab_pin.sym} 39500 -37430 0 1 {name=p38556 lab=_51738_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -37430 0 0 {name=X_51738_ }
C {devices/lab_pin.sym} 39380 -37290 0 0 {name=p38557 lab=_83405_/Q }
C {devices/lab_pin.sym} 39460 -37290 0 1 {name=p38558 lab=_58294_/Y }
C {sky130_stdcells/inv_2.sym} 39420 -37290 0 0 {name=X_58294_ }
C {devices/lab_pin.sym} 39380 -37170 0 0 {name=p38559 lab=_71012_/A }
C {devices/lab_pin.sym} 39460 -37170 0 1 {name=p38560 lab=_70573_/B }
C {sky130_stdcells/buf_2.sym} 39420 -37170 0 0 {name=X_70572_ }
C {devices/lab_pin.sym} 39330 -37050 0 0 {name=p38561 lab=_82558_/CLK }
C {devices/lab_pin.sym} 39330 -37030 0 0 {name=p38562 lab=_82558_/D }
C {devices/lab_pin.sym} 39510 -37050 0 1 {name=p38563 lab=_82558_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -37040 0 0 {name=X_82558_ }
C {devices/lab_pin.sym} 39380 -36910 0 0 {name=p38564 lab=clkbuf_8_192_0_CLK/X }
C {devices/lab_pin.sym} 39460 -36910 0 1 {name=p38565 lab=clkbuf_9_384_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 39420 -36910 0 0 {name=Xclkbuf_9_384_0_CLK }
C {devices/lab_pin.sym} 39340 -36810 0 0 {name=p38566 lab=_72307_/Y }
C {devices/lab_pin.sym} 39340 -36770 0 0 {name=p38567 lab=_72310_/Y }
C {devices/lab_pin.sym} 39340 -36730 0 0 {name=p38568 lab=_72201_/X }
C {devices/lab_pin.sym} 39500 -36770 0 1 {name=p38569 lab=_72311_/X }
C {sky130_stdcells/a21o_4.sym} 39420 -36770 0 0 {name=X_72311_ }
C {devices/lab_pin.sym} 39380 -36630 0 0 {name=p38570 lab=_57244_/X }
C {devices/lab_pin.sym} 39460 -36630 0 1 {name=p38571 lab=_57245_/X }
C {sky130_stdcells/buf_2.sym} 39420 -36630 0 0 {name=X_57245_ }
C {devices/lab_pin.sym} 39330 -36510 0 0 {name=p38572 lab=_84087_/CLK }
C {devices/lab_pin.sym} 39330 -36490 0 0 {name=p38573 lab=_81553_/Q }
C {devices/lab_pin.sym} 39510 -36510 0 1 {name=p38574 lab=_81509_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -36500 0 0 {name=X_81509_ }
C {devices/lab_pin.sym} 39330 -36370 0 0 {name=p38575 lab=_87553_/CLK }
C {devices/lab_pin.sym} 39330 -36350 0 0 {name=p38576 lab=_88065_/D }
C {devices/lab_pin.sym} 39510 -36370 0 1 {name=p38577 lab=_73225_/A }
C {sky130_stdcells/dfxtp_4.sym} 39420 -36360 0 0 {name=X_88065_ }
C {devices/lab_pin.sym} 39380 -36230 0 0 {name=p38578 lab=_54376_/A }
C {devices/lab_pin.sym} 39460 -36230 0 1 {name=p38579 lab=_54457_/X }
C {sky130_stdcells/buf_2.sym} 39420 -36230 0 0 {name=X_54457_ }
C {devices/lab_pin.sym} 39380 -36110 0 0 {name=p38580 lab=_42470_/Y }
C {devices/lab_pin.sym} 39460 -36110 0 1 {name=p38581 lab=_87854_/D }
C {sky130_stdcells/inv_2.sym} 39420 -36110 0 0 {name=X_42471_ }
C {devices/lab_pin.sym} 39360 -36000 0 0 {name=p38582 lab=_48582_/A }
C {devices/lab_pin.sym} 39360 -35960 0 0 {name=p38583 lab=_73290_/Y }
C {devices/lab_pin.sym} 39480 -35980 0 1 {name=p38584 lab=_73291_/X }
C {sky130_stdcells/xor2_4.sym} 39420 -35980 0 0 {name=X_73291_ }
C {devices/lab_pin.sym} 39330 -35850 0 0 {name=p38585 lab=_85277_/CLK }
C {devices/lab_pin.sym} 39330 -35830 0 0 {name=p38586 lab=_85277_/D }
C {devices/lab_pin.sym} 39510 -35850 0 1 {name=p38587 lab=_56203_/C }
C {sky130_stdcells/dfxtp_4.sym} 39420 -35840 0 0 {name=X_85277_ }
C {devices/lab_pin.sym} 39360 -35740 0 0 {name=p38588 lab=_51657_/X }
C {devices/lab_pin.sym} 39360 -35700 0 0 {name=p38589 lab=_51684_/B }
C {devices/lab_pin.sym} 39360 -35660 0 0 {name=p38590 lab=_51684_/C }
C {devices/lab_pin.sym} 39360 -35620 0 0 {name=p38591 lab=_53191_/D }
C {devices/lab_pin.sym} 39480 -35680 0 1 {name=p38592 lab=_51669_/X }
C {sky130_stdcells/and4_4.sym} 39420 -35680 0 0 {name=X_51669_ }
C {devices/lab_pin.sym} 39380 -35530 0 0 {name=p38593 lab=clkbuf_9_139_0_CLK/X }
C {devices/lab_pin.sym} 39460 -35530 0 1 {name=p38594 lab=_85404_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 39420 -35530 0 0 {name=Xclkbuf_10_278_0_CLK }
C {devices/lab_pin.sym} 39330 -35410 0 0 {name=p38595 lab=_82711_/CLK }
C {devices/lab_pin.sym} 39330 -35390 0 0 {name=p38596 lab=_82489_/D }
C {devices/lab_pin.sym} 39510 -35410 0 1 {name=p38597 lab=_82489_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -35400 0 0 {name=X_82489_ }
C {devices/lab_pin.sym} 39380 -35270 0 0 {name=p38598 lab=_44158_/Y }
C {devices/lab_pin.sym} 39460 -35270 0 1 {name=p38599 lab=_44210_/X }
C {sky130_stdcells/buf_2.sym} 39420 -35270 0 0 {name=X_44210_ }
C {devices/lab_pin.sym} 39360 -35160 0 0 {name=p38600 lab=_75030_/A }
C {devices/lab_pin.sym} 39360 -35120 0 0 {name=p38601 lab=_75023_/A }
C {devices/lab_pin.sym} 39480 -35140 0 1 {name=p38602 lab=_75047_/B }
C {sky130_stdcells/and2_4.sym} 39420 -35140 0 0 {name=X_75030_ }
C {devices/lab_pin.sym} 39330 -35010 0 0 {name=p38603 lab=_87011_/CLK }
C {devices/lab_pin.sym} 39330 -34990 0 0 {name=p38604 lab=_44652_/X }
C {devices/lab_pin.sym} 39510 -35010 0 1 {name=p38605 lab=_87016_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -35000 0 0 {name=X_87016_ }
C {devices/lab_pin.sym} 39360 -34880 0 0 {name=p38606 lab=_41422_/A }
C {devices/lab_pin.sym} 39360 -34840 0 0 {name=p38607 lab=_41379_/X }
C {devices/lab_pin.sym} 39480 -34860 0 1 {name=p38608 lab=_41422_/X }
C {sky130_stdcells/or2_4.sym} 39420 -34860 0 0 {name=X_41422_ }
C {devices/lab_pin.sym} 39380 -34730 0 0 {name=p38609 lab=_53355_/A }
C {devices/lab_pin.sym} 39460 -34730 0 1 {name=p38610 lab=_53408_/X }
C {sky130_stdcells/buf_2.sym} 39420 -34730 0 0 {name=X_53408_ }
C {devices/lab_pin.sym} 39340 -34630 0 0 {name=p38611 lab=_72240_/X }
C {devices/lab_pin.sym} 39340 -34590 0 0 {name=p38612 lab=_85687_/Q }
C {devices/lab_pin.sym} 39340 -34550 0 0 {name=p38613 lab=_72241_/X }
C {devices/lab_pin.sym} 39500 -34590 0 1 {name=p38614 lab=_72242_/X }
C {sky130_stdcells/o21a_4.sym} 39420 -34590 0 0 {name=X_72242_ }
C {devices/lab_pin.sym} 39330 -34450 0 0 {name=p38615 lab=_84228_/CLK }
C {devices/lab_pin.sym} 39330 -34430 0 0 {name=p38616 lab=_84228_/D }
C {devices/lab_pin.sym} 39510 -34450 0 1 {name=p38617 lab=_84228_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -34440 0 0 {name=X_84228_ }
C {devices/lab_pin.sym} 39340 -34330 0 0 {name=p38618 lab=_55814_/B }
C {devices/lab_pin.sym} 39340 -34290 0 0 {name=p38619 lab=_45134_/X }
C {devices/lab_pin.sym} 39340 -34250 0 0 {name=p38620 lab=_45189_/X }
C {devices/lab_pin.sym} 39500 -34290 0 1 {name=p38621 lab=_45190_/X }
C {sky130_stdcells/o21a_4.sym} 39420 -34290 0 0 {name=X_45190_ }
C {devices/lab_pin.sym} 39380 -34150 0 0 {name=p38622 lab=_57175_/Y }
C {devices/lab_pin.sym} 39460 -34150 0 1 {name=p38623 lab=_85068_/D }
C {sky130_stdcells/inv_2.sym} 39420 -34150 0 0 {name=X_57176_ }
C {devices/lab_pin.sym} 39360 -34040 0 0 {name=p38624 lab=_54378_/A }
C {devices/lab_pin.sym} 39360 -34000 0 0 {name=p38625 lab=_52696_/B }
C {devices/lab_pin.sym} 39480 -34020 0 1 {name=p38626 lab=_54388_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -34020 0 0 {name=X_54388_ }
C {devices/lab_pin.sym} 39380 -33890 0 0 {name=p38627 lab=_44140_/X }
C {devices/lab_pin.sym} 39460 -33890 0 1 {name=p38628 lab=_44141_/X }
C {sky130_stdcells/buf_2.sym} 39420 -33890 0 0 {name=X_44141_ }
C {devices/lab_pin.sym} 39360 -33790 0 0 {name=p38629 lab=_56147_/A }
C {devices/lab_pin.sym} 39360 -33750 0 0 {name=p38630 lab=_56127_/B }
C {devices/lab_pin.sym} 39360 -33710 0 0 {name=p38631 lab=_56127_/C }
C {devices/lab_pin.sym} 39480 -33750 0 1 {name=p38632 lab=_56143_/B }
C {sky130_stdcells/nor3_4.sym} 39420 -33750 0 0 {name=X_56127_ }
C {devices/lab_pin.sym} 39340 -33640 0 0 {name=p38633 lab=_41352_/X }
C {devices/lab_pin.sym} 39340 -33600 0 0 {name=p38634 lab=_41307_/X }
C {devices/lab_pin.sym} 39340 -33560 0 0 {name=p38635 lab=_88231_/Q }
C {devices/lab_pin.sym} 39340 -33520 0 0 {name=p38636 lab=_41308_/X }
C {devices/lab_pin.sym} 39500 -33580 0 1 {name=p38637 lab=_41353_/X }
C {sky130_stdcells/a2bb2o_4.sym} 39420 -33580 0 0 {name=X_41353_ }
C {devices/lab_pin.sym} 39360 -33460 0 0 {name=p38638 lab=_53339_/A }
C {devices/lab_pin.sym} 39360 -33420 0 0 {name=p38639 lab=_53330_/B }
C {devices/lab_pin.sym} 39360 -33380 0 0 {name=p38640 lab=_53330_/C }
C {devices/lab_pin.sym} 39360 -33340 0 0 {name=p38641 lab=_52827_/D }
C {devices/lab_pin.sym} 39480 -33400 0 1 {name=p38642 lab=_53339_/X }
C {sky130_stdcells/and4_4.sym} 39420 -33400 0 0 {name=X_53339_ }
C {devices/lab_pin.sym} 39380 -33250 0 0 {name=p38643 lab=_59238_/A }
C {devices/lab_pin.sym} 39460 -33250 0 1 {name=p38644 lab=_72220_/A }
C {sky130_stdcells/buf_2.sym} 39420 -33250 0 0 {name=X_72173_ }
C {devices/lab_pin.sym} 39330 -33130 0 0 {name=p38645 lab=_84166_/CLK }
C {devices/lab_pin.sym} 39330 -33110 0 0 {name=p38646 lab=_66067_/X }
C {devices/lab_pin.sym} 39510 -33130 0 1 {name=p38647 lab=_84159_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -33120 0 0 {name=X_84159_ }
C {devices/lab_pin.sym} 39380 -32990 0 0 {name=p38648 lab=clkbuf_9_398_0_CLK/A }
C {devices/lab_pin.sym} 39460 -32990 0 1 {name=p38649 lab=clkbuf_9_399_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 39420 -32990 0 0 {name=Xclkbuf_9_399_0_CLK }
C {devices/lab_pin.sym} 39380 -32870 0 0 {name=p38650 lab=clkbuf_8_207_0_CLK/A }
C {devices/lab_pin.sym} 39460 -32870 0 1 {name=p38651 lab=clkbuf_9_413_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 39420 -32870 0 0 {name=Xclkbuf_8_206_0_CLK }
C {devices/lab_pin.sym} 39380 -32750 0 0 {name=p38652 lab=clkbuf_9_100_0_CLK/X }
C {devices/lab_pin.sym} 39460 -32750 0 1 {name=p38653 lab=_81048_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 39420 -32750 0 0 {name=Xclkbuf_10_201_0_CLK }
C {devices/lab_pin.sym} 39340 -32650 0 0 {name=p38654 lab=_49144_/X }
C {devices/lab_pin.sym} 39340 -32610 0 0 {name=p38655 lab=_71117_/X }
C {devices/lab_pin.sym} 39340 -32570 0 0 {name=p38656 lab=_71123_/Y }
C {devices/lab_pin.sym} 39500 -32610 0 1 {name=p38657 lab=_83599_/D }
C {sky130_stdcells/o21ai_4.sym} 39420 -32610 0 0 {name=X_71124_ }
C {devices/lab_pin.sym} 39380 -32470 0 0 {name=p38658 lab=_44072_/A }
C {devices/lab_pin.sym} 39460 -32470 0 1 {name=p38659 lab=_44072_/Y }
C {sky130_stdcells/inv_2.sym} 39420 -32470 0 0 {name=X_44072_ }
C {devices/lab_pin.sym} 39380 -32350 0 0 {name=p38660 lab=_56142_/A }
C {devices/lab_pin.sym} 39460 -32350 0 1 {name=p38661 lab=_56058_/X }
C {sky130_stdcells/buf_2.sym} 39420 -32350 0 0 {name=X_56058_ }
C {devices/lab_pin.sym} 39380 -32230 0 0 {name=p38662 lab=_41253_/A }
C {devices/lab_pin.sym} 39460 -32230 0 1 {name=p38663 lab=_41284_/X }
C {sky130_stdcells/buf_2.sym} 39420 -32230 0 0 {name=X_41284_ }
C {devices/lab_pin.sym} 39360 -32120 0 0 {name=p38664 lab=_76981_/A }
C {devices/lab_pin.sym} 39360 -32080 0 0 {name=p38665 lab=_76981_/B }
C {devices/lab_pin.sym} 39480 -32100 0 1 {name=p38666 lab=_76981_/X }
C {sky130_stdcells/xor2_4.sym} 39420 -32100 0 0 {name=X_76981_ }
C {devices/lab_pin.sym} 39380 -31970 0 0 {name=p38667 lab=clkbuf_9_415_0_CLK/X }
C {devices/lab_pin.sym} 39460 -31970 0 1 {name=p38668 lab=_86578_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 39420 -31970 0 0 {name=Xclkbuf_10_831_0_CLK }
C {devices/lab_pin.sym} 39380 -31850 0 0 {name=p38669 lab=_73717_/A }
C {devices/lab_pin.sym} 39460 -31850 0 1 {name=p38670 lab=_50264_/B }
C {sky130_stdcells/buf_2.sym} 39420 -31850 0 0 {name=X_47900_ }
C {devices/lab_pin.sym} 39380 -31730 0 0 {name=p38671 lab=_43023_/A }
C {devices/lab_pin.sym} 39460 -31730 0 1 {name=p38672 lab=_87603_/D }
C {sky130_stdcells/inv_2.sym} 39420 -31730 0 0 {name=X_43023_ }
C {devices/lab_pin.sym} 39360 -31640 0 0 {name=p38673 lab=_55013_/A }
C {devices/lab_pin.sym} 39360 -31600 0 0 {name=p38674 lab=_55026_/B }
C {devices/lab_pin.sym} 39360 -31560 0 0 {name=p38675 lab=_55013_/C }
C {devices/lab_pin.sym} 39360 -31520 0 0 {name=p38676 lab=_47616_/A }
C {devices/lab_pin.sym} 39480 -31580 0 1 {name=p38677 lab=_55009_/X }
C {sky130_stdcells/and4_4.sym} 39420 -31580 0 0 {name=X_55009_ }
C {devices/lab_pin.sym} 39380 -31430 0 0 {name=p38678 lab=_78720_/A }
C {devices/lab_pin.sym} 39460 -31430 0 1 {name=p38679 lab=_78721_/B }
C {sky130_stdcells/inv_2.sym} 39420 -31430 0 0 {name=X_78720_ }
C {devices/lab_pin.sym} 39360 -31330 0 0 {name=p38680 lab=_71055_/A }
C {devices/lab_pin.sym} 39360 -31290 0 0 {name=p38681 lab=_71055_/B }
C {devices/lab_pin.sym} 39360 -31250 0 0 {name=p38682 lab=_71055_/C }
C {devices/lab_pin.sym} 39480 -31290 0 1 {name=p38683 lab=_71055_/Y }
C {sky130_stdcells/nand3_4.sym} 39420 -31290 0 0 {name=X_71055_ }
C {devices/lab_pin.sym} 39380 -31150 0 0 {name=p38684 lab=_75932_/A }
C {devices/lab_pin.sym} 39460 -31150 0 1 {name=p38685 lab=_75933_/B }
C {sky130_stdcells/inv_2.sym} 39420 -31150 0 0 {name=X_75932_ }
C {devices/lab_pin.sym} 39330 -31030 0 0 {name=p38686 lab=_88171_/CLK }
C {devices/lab_pin.sym} 39330 -31010 0 0 {name=p38687 lab=_87918_/D }
C {devices/lab_pin.sym} 39510 -31030 0 1 {name=p38688 lab=_87918_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -31020 0 0 {name=X_87918_ }
C {devices/lab_pin.sym} 39380 -30890 0 0 {name=p38689 lab=_48651_/A }
C {devices/lab_pin.sym} 39460 -30890 0 1 {name=p38690 lab=_48880_/X }
C {sky130_stdcells/buf_2.sym} 39420 -30890 0 0 {name=X_48880_ }
C {devices/lab_pin.sym} 39380 -30770 0 0 {name=p38691 lab=clkbuf_9_323_0_CLK/A }
C {devices/lab_pin.sym} 39460 -30770 0 1 {name=p38692 lab=clkbuf_9_322_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 39420 -30770 0 0 {name=Xclkbuf_9_322_0_CLK }
C {devices/lab_pin.sym} 39340 -30670 0 0 {name=p38693 lab=_68559_/X }
C {devices/lab_pin.sym} 39340 -30630 0 0 {name=p38694 lab=_68561_/X }
C {devices/lab_pin.sym} 39340 -30590 0 0 {name=p38695 lab=_70005_/X }
C {devices/lab_pin.sym} 39500 -30630 0 1 {name=p38696 lab=_70006_/Y }
C {sky130_stdcells/a21oi_4.sym} 39420 -30630 0 0 {name=X_70006_ }
C {devices/lab_pin.sym} 39380 -30490 0 0 {name=p38697 lab=_47830_/Y }
C {devices/lab_pin.sym} 39460 -30490 0 1 {name=p38698 lab=_57489_/B }
C {sky130_stdcells/buf_2.sym} 39420 -30490 0 0 {name=X_47831_ }
C {devices/lab_pin.sym} 39340 -30410 0 0 {name=p38699 lab=_59754_/C }
C {devices/lab_pin.sym} 39340 -30370 0 0 {name=p38700 lab=_59631_/B }
C {devices/lab_pin.sym} 39340 -30330 0 0 {name=p38701 lab=_61202_/A }
C {devices/lab_pin.sym} 39340 -30290 0 0 {name=p38702 lab=_62183_/A }
C {devices/lab_pin.sym} 39340 -30250 0 0 {name=p38703 lab=_59840_/A }
C {devices/lab_pin.sym} 39500 -30330 0 1 {name=p38704 lab=_59817_/Y }
C {sky130_stdcells/a2111oi_4.sym} 39420 -30330 0 0 {name=X_59817_ }
C {devices/lab_pin.sym} 39340 -30190 0 0 {name=p38705 lab=_78628_/Y }
C {devices/lab_pin.sym} 39340 -30150 0 0 {name=p38706 lab=_78632_/B }
C {devices/lab_pin.sym} 39340 -30110 0 0 {name=p38707 lab=_78630_/Y }
C {devices/lab_pin.sym} 39500 -30150 0 1 {name=p38708 lab=_78651_/X }
C {sky130_stdcells/o21a_4.sym} 39420 -30150 0 0 {name=X_78651_ }
C {devices/lab_pin.sym} 39340 -30030 0 0 {name=p38709 lab=_75864_/A }
C {devices/lab_pin.sym} 39340 -29990 0 0 {name=p38710 lab=_75862_/Y }
C {devices/lab_pin.sym} 39340 -29950 0 0 {name=p38711 lab=_81024_/Q }
C {devices/lab_pin.sym} 39500 -29990 0 1 {name=p38712 lab=_75863_/Y }
C {sky130_stdcells/a21oi_4.sym} 39420 -29990 0 0 {name=X_75863_ }
C {devices/lab_pin.sym} 39330 -29850 0 0 {name=p38713 lab=_87851_/CLK }
C {devices/lab_pin.sym} 39330 -29830 0 0 {name=p38714 lab=_87849_/D }
C {devices/lab_pin.sym} 39510 -29850 0 1 {name=p38715 lab=_73795_/A }
C {sky130_stdcells/dfxtp_4.sym} 39420 -29840 0 0 {name=X_87849_ }
C {devices/lab_pin.sym} 39380 -29710 0 0 {name=p38716 lab=clkbuf_9_108_0_CLK/X }
C {devices/lab_pin.sym} 39460 -29710 0 1 {name=p38717 lab=_84520_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 39420 -29710 0 0 {name=Xclkbuf_10_216_0_CLK }
C {devices/lab_pin.sym} 39380 -29590 0 0 {name=p38718 lab=_77601_/Y }
C {devices/lab_pin.sym} 39460 -29590 0 1 {name=p38719 lab=_77603_/C }
C {sky130_stdcells/inv_2.sym} 39420 -29590 0 0 {name=X_77602_ }
C {devices/lab_pin.sym} 39380 -29470 0 0 {name=p38720 lab=_46220_/A }
C {devices/lab_pin.sym} 39460 -29470 0 1 {name=p38721 lab=_80668_/D }
C {sky130_stdcells/inv_2.sym} 39420 -29470 0 0 {name=X_74814_ }
C {devices/lab_pin.sym} 39380 -29350 0 0 {name=p38722 lab=_83472_/Q }
C {devices/lab_pin.sym} 39460 -29350 0 1 {name=p38723 lab=_47762_/Y }
C {sky130_stdcells/inv_2.sym} 39420 -29350 0 0 {name=X_47762_ }
C {devices/lab_pin.sym} 39380 -29230 0 0 {name=p38724 lab=clkbuf_9_423_0_CLK/X }
C {devices/lab_pin.sym} 39460 -29230 0 1 {name=p38725 lab=_86118_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 39420 -29230 0 0 {name=Xclkbuf_10_846_0_CLK }
C {devices/lab_pin.sym} 39340 -29150 0 0 {name=p38726 lab=_59742_/Y }
C {devices/lab_pin.sym} 39340 -29110 0 0 {name=p38727 lab=_59744_/Y }
C {devices/lab_pin.sym} 39340 -29070 0 0 {name=p38728 lab=_59745_/X }
C {devices/lab_pin.sym} 39340 -29030 0 0 {name=p38729 lab=_59746_/Y }
C {devices/lab_pin.sym} 39340 -29000 0 0 {name=p38730 lab=_59747_/Y }
C {devices/lab_pin.sym} 39500 -29070 0 1 {name=p38731 lab=_59748_/Y }
C {sky130_stdcells/a41oi_4.sym} 39420 -29070 0 0 {name=X_59748_ }
C {devices/lab_pin.sym} 39360 -28920 0 0 {name=p38732 lab=_78582_/A }
C {devices/lab_pin.sym} 39360 -28880 0 0 {name=p38733 lab=_82772_/D }
C {devices/lab_pin.sym} 39480 -28900 0 1 {name=p38734 lab=_82484_/D }
C {sky130_stdcells/xor2_4.sym} 39420 -28900 0 0 {name=X_78582_ }
C {devices/lab_pin.sym} 39340 -28790 0 0 {name=p38735 lab=_44965_/X }
C {devices/lab_pin.sym} 39340 -28750 0 0 {name=p38736 lab=_44970_/Y }
C {devices/lab_pin.sym} 39340 -28710 0 0 {name=p38737 lab=_44973_/X }
C {devices/lab_pin.sym} 39500 -28750 0 1 {name=p38738 lab=_44974_/Y }
C {sky130_stdcells/a21oi_4.sym} 39420 -28750 0 0 {name=X_44974_ }
C {devices/lab_pin.sym} 39360 -28620 0 0 {name=p38739 lab=_81018_/Q }
C {devices/lab_pin.sym} 39360 -28580 0 0 {name=p38740 lab=_80890_/D }
C {devices/lab_pin.sym} 39480 -28600 0 1 {name=p38741 lab=_80986_/D }
C {sky130_stdcells/xor2_4.sym} 39420 -28600 0 0 {name=X_75794_ }
C {devices/lab_pin.sym} 39340 -28490 0 0 {name=p38742 lab=_49499_/Y }
C {devices/lab_pin.sym} 39340 -28450 0 0 {name=p38743 lab=_49487_/X }
C {devices/lab_pin.sym} 39340 -28410 0 0 {name=p38744 lab=_49500_/X }
C {devices/lab_pin.sym} 39500 -28450 0 1 {name=p38745 lab=_86376_/D }
C {sky130_stdcells/a21oi_4.sym} 39420 -28450 0 0 {name=X_49501_ }
C {devices/lab_pin.sym} 39340 -28330 0 0 {name=p38746 lab=_58688_/A }
C {devices/lab_pin.sym} 39340 -28290 0 0 {name=p38747 lab=_46672_/X }
C {devices/lab_pin.sym} 39340 -28250 0 0 {name=p38748 lab=_46712_/Y }
C {devices/lab_pin.sym} 39500 -28290 0 1 {name=p38749 lab=_46713_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -28290 0 0 {name=X_46713_ }
C {devices/lab_pin.sym} 39360 -28160 0 0 {name=p38750 lab=_77532_/A }
C {devices/lab_pin.sym} 39360 -28120 0 0 {name=p38751 lab=_82103_/D }
C {devices/lab_pin.sym} 39480 -28140 0 1 {name=p38752 lab=_77533_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -28140 0 0 {name=X_77533_ }
C {devices/lab_pin.sym} 39340 -28050 0 0 {name=p38753 lab=_43916_/X }
C {devices/lab_pin.sym} 39340 -28010 0 0 {name=p38754 lab=_43924_/X }
C {devices/lab_pin.sym} 39340 -27970 0 0 {name=p38755 lab=_41408_/X }
C {devices/lab_pin.sym} 39340 -27930 0 0 {name=p38756 lab=_67891_/B }
C {devices/lab_pin.sym} 39340 -27890 0 0 {name=p38757 lab=_43917_/X }
C {devices/lab_pin.sym} 39500 -27970 0 1 {name=p38758 lab=_43926_/A }
C {sky130_stdcells/o32ai_4.sym} 39420 -27970 0 0 {name=X_43925_ }
C {devices/lab_pin.sym} 39360 -27840 0 0 {name=p38759 lab=_74745_/A }
C {devices/lab_pin.sym} 39360 -27800 0 0 {name=p38760 lab=_74804_/C }
C {devices/lab_pin.sym} 39360 -27760 0 0 {name=p38761 lab=_74744_/X }
C {devices/lab_pin.sym} 39360 -27720 0 0 {name=p38762 lab=_74745_/D }
C {devices/lab_pin.sym} 39480 -27780 0 1 {name=p38763 lab=_74745_/Y }
C {sky130_stdcells/nand4_4.sym} 39420 -27780 0 0 {name=X_74745_ }
C {devices/lab_pin.sym} 39340 -27650 0 0 {name=p38764 lab=_47689_/Y }
C {devices/lab_pin.sym} 39340 -27610 0 0 {name=p38765 lab=_47651_/X }
C {devices/lab_pin.sym} 39340 -27570 0 0 {name=p38766 lab=_47692_/X }
C {devices/lab_pin.sym} 39500 -27610 0 1 {name=p38767 lab=_86608_/D }
C {sky130_stdcells/a21oi_4.sym} 39420 -27610 0 0 {name=X_47693_ }
C {devices/lab_pin.sym} 39360 -27480 0 0 {name=p38768 lab=_71957_/A }
C {devices/lab_pin.sym} 39360 -27440 0 0 {name=p38769 lab=_48876_/Y }
C {devices/lab_pin.sym} 39480 -27460 0 1 {name=p38770 lab=_71957_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -27460 0 0 {name=X_71957_ }
C {devices/lab_pin.sym} 39380 -27330 0 0 {name=p38771 lab=_59679_/A }
C {devices/lab_pin.sym} 39460 -27330 0 1 {name=p38772 lab=_59687_/A }
C {sky130_stdcells/buf_2.sym} 39420 -27330 0 0 {name=X_59679_ }
C {devices/lab_pin.sym} 39380 -27210 0 0 {name=p38773 lab=clkbuf_8_168_0_CLK/X }
C {devices/lab_pin.sym} 39460 -27210 0 1 {name=p38774 lab=clkbuf_9_337_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 39420 -27210 0 0 {name=Xclkbuf_9_337_0_CLK }
C {devices/lab_pin.sym} 39340 -27110 0 0 {name=p38775 lab=_86388_/Q }
C {devices/lab_pin.sym} 39340 -27070 0 0 {name=p38776 lab=_49415_/X }
C {devices/lab_pin.sym} 39340 -27030 0 0 {name=p38777 lab=_49431_/Y }
C {devices/lab_pin.sym} 39500 -27070 0 1 {name=p38778 lab=_49432_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -27070 0 0 {name=X_49432_ }
C {devices/lab_pin.sym} 39360 -26960 0 0 {name=p38779 lab=_84729_/Q }
C {devices/lab_pin.sym} 39360 -26920 0 0 {name=p38780 lab=_59761_/A }
C {devices/lab_pin.sym} 39360 -26880 0 0 {name=p38781 lab=_62187_/C }
C {devices/lab_pin.sym} 39360 -26840 0 0 {name=p38782 lab=_59761_/B }
C {devices/lab_pin.sym} 39480 -26900 0 1 {name=p38783 lab=_61710_/Y }
C {sky130_stdcells/nand4_4.sym} 39420 -26900 0 0 {name=X_61710_ }
C {devices/lab_pin.sym} 39340 -26770 0 0 {name=p38784 lab=_58601_/A }
C {devices/lab_pin.sym} 39340 -26730 0 0 {name=p38785 lab=_46622_/X }
C {devices/lab_pin.sym} 39340 -26690 0 0 {name=p38786 lab=_46643_/Y }
C {devices/lab_pin.sym} 39500 -26730 0 1 {name=p38787 lab=_46644_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -26730 0 0 {name=X_46644_ }
C {devices/lab_pin.sym} 39360 -26600 0 0 {name=p38788 lab=_70908_/A }
C {devices/lab_pin.sym} 39360 -26560 0 0 {name=p38789 lab=_70698_/A }
C {devices/lab_pin.sym} 39480 -26580 0 1 {name=p38790 lab=_70909_/A }
C {sky130_stdcells/nor2_4.sym} 39420 -26580 0 0 {name=X_70908_ }
C {devices/lab_pin.sym} 39340 -26470 0 0 {name=p38791 lab=_77460_/Y }
C {devices/lab_pin.sym} 39340 -26430 0 0 {name=p38792 lab=_77439_/Y }
C {devices/lab_pin.sym} 39340 -26390 0 0 {name=p38793 lab=_77463_/X }
C {devices/lab_pin.sym} 39500 -26430 0 1 {name=p38794 lab=_77465_/B }
C {sky130_stdcells/o21ai_4.sym} 39420 -26430 0 0 {name=X_77464_ }
C {devices/lab_pin.sym} 39380 -26290 0 0 {name=p38795 lab=_43855_/Y }
C {devices/lab_pin.sym} 39460 -26290 0 1 {name=p38796 lab=_43856_/Y }
C {sky130_stdcells/inv_2.sym} 39420 -26290 0 0 {name=X_43856_ }
C {devices/lab_pin.sym} 39360 -26180 0 0 {name=p38797 lab=_74679_/A }
C {devices/lab_pin.sym} 39360 -26140 0 0 {name=p38798 lab=_45728_/A }
C {devices/lab_pin.sym} 39480 -26160 0 1 {name=p38799 lab=_74676_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -26160 0 0 {name=X_74676_ }
C {devices/lab_pin.sym} 39360 -26060 0 0 {name=p38800 lab=_62658_/A }
C {devices/lab_pin.sym} 39360 -26020 0 0 {name=p38801 lab=_64248_/C }
C {devices/lab_pin.sym} 39360 -25980 0 0 {name=p38802 lab=_62676_/C }
C {devices/lab_pin.sym} 39360 -25940 0 0 {name=p38803 lab=_62657_/X }
C {devices/lab_pin.sym} 39480 -26000 0 1 {name=p38804 lab=_62690_/X }
C {sky130_stdcells/and4_4.sym} 39420 -26000 0 0 {name=X_62690_ }
C {devices/lab_pin.sym} 39340 -25870 0 0 {name=p38805 lab=_71870_/Y }
C {devices/lab_pin.sym} 39340 -25830 0 0 {name=p38806 lab=_83339_/Q }
C {devices/lab_pin.sym} 39340 -25790 0 0 {name=p38807 lab=_71887_/Y }
C {devices/lab_pin.sym} 39500 -25830 0 1 {name=p38808 lab=_83339_/D }
C {sky130_stdcells/a21o_4.sym} 39420 -25830 0 0 {name=X_71888_ }
C {devices/lab_pin.sym} 39360 -25710 0 0 {name=p38809 lab=_79203_/A }
C {devices/lab_pin.sym} 39360 -25670 0 0 {name=p38810 lab=_79201_/Y }
C {devices/lab_pin.sym} 39360 -25630 0 0 {name=p38811 lab=_79202_/Y }
C {devices/lab_pin.sym} 39480 -25670 0 1 {name=p38812 lab=_79205_/B }
C {sky130_stdcells/nand3_4.sym} 39420 -25670 0 0 {name=X_79203_ }
C {devices/lab_pin.sym} 39380 -25530 0 0 {name=p38813 lab=_76415_/A }
C {devices/lab_pin.sym} 39460 -25530 0 1 {name=p38814 lab=_76415_/Y }
C {sky130_stdcells/inv_2.sym} 39420 -25530 0 0 {name=X_76415_ }
C {devices/lab_pin.sym} 39380 -25410 0 0 {name=p38815 lab=_42806_/Y }
C {devices/lab_pin.sym} 39460 -25410 0 1 {name=p38816 lab=_87709_/D }
C {sky130_stdcells/inv_2.sym} 39420 -25410 0 0 {name=X_42807_ }
C {devices/lab_pin.sym} 39340 -25310 0 0 {name=p38817 lab=_86401_/Q }
C {devices/lab_pin.sym} 39340 -25270 0 0 {name=p38818 lab=_49360_/X }
C {devices/lab_pin.sym} 39340 -25230 0 0 {name=p38819 lab=_49362_/Y }
C {devices/lab_pin.sym} 39500 -25270 0 1 {name=p38820 lab=_49363_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -25270 0 0 {name=X_49363_ }
C {devices/lab_pin.sym} 39360 -25140 0 0 {name=p38821 lab=_84871_/Q }
C {devices/lab_pin.sym} 39360 -25100 0 0 {name=p38822 lab=_61321_/Y }
C {devices/lab_pin.sym} 39480 -25120 0 1 {name=p38823 lab=_61642_/A }
C {sky130_stdcells/or2_4.sym} 39420 -25120 0 0 {name=X_61641_ }
C {devices/lab_pin.sym} 39380 -24990 0 0 {name=p38824 lab=_72892_/B }
C {devices/lab_pin.sym} 39460 -24990 0 1 {name=p38825 lab=_73627_/X }
C {sky130_stdcells/buf_2.sym} 39420 -24990 0 0 {name=X_73627_ }
C {devices/lab_pin.sym} 39340 -24890 0 0 {name=p38826 lab=_86724_/Q }
C {devices/lab_pin.sym} 39340 -24850 0 0 {name=p38827 lab=_46543_/X }
C {devices/lab_pin.sym} 39340 -24810 0 0 {name=p38828 lab=_46574_/Y }
C {devices/lab_pin.sym} 39500 -24850 0 1 {name=p38829 lab=_46575_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -24850 0 0 {name=X_46575_ }
C {devices/lab_pin.sym} 39360 -24740 0 0 {name=p38830 lab=_70867_/A }
C {devices/lab_pin.sym} 39360 -24700 0 0 {name=p38831 lab=_70846_/B }
C {devices/lab_pin.sym} 39360 -24660 0 0 {name=p38832 lab=_70849_/C }
C {devices/lab_pin.sym} 39360 -24620 0 0 {name=p38833 lab=_70841_/D }
C {devices/lab_pin.sym} 39480 -24680 0 1 {name=p38834 lab=_70839_/Y }
C {sky130_stdcells/nand4_4.sym} 39420 -24680 0 0 {name=X_70839_ }
C {devices/lab_pin.sym} 39360 -24540 0 0 {name=p38835 lab=_77417_/A }
C {devices/lab_pin.sym} 39360 -24500 0 0 {name=p38836 lab=_77417_/B }
C {devices/lab_pin.sym} 39480 -24520 0 1 {name=p38837 lab=_77434_/B }
C {sky130_stdcells/xnor2_4.sym} 39420 -24520 0 0 {name=X_77395_ }
C {devices/lab_pin.sym} 39380 -24390 0 0 {name=p38838 lab=_43787_/A }
C {devices/lab_pin.sym} 39460 -24390 0 1 {name=p38839 lab=_87268_/D }
C {sky130_stdcells/inv_2.sym} 39420 -24390 0 0 {name=X_43787_ }
C {devices/lab_pin.sym} 39380 -24270 0 0 {name=p38840 lab=_40999_/A }
C {devices/lab_pin.sym} 39460 -24270 0 1 {name=p38841 lab=_40999_/X }
C {sky130_stdcells/buf_2.sym} 39420 -24270 0 0 {name=X_40999_ }
C {devices/lab_pin.sym} 39340 -24170 0 0 {name=p38842 lab=_48311_/Y }
C {devices/lab_pin.sym} 39340 -24130 0 0 {name=p38843 lab=_48273_/X }
C {devices/lab_pin.sym} 39340 -24090 0 0 {name=p38844 lab=_48313_/Y }
C {devices/lab_pin.sym} 39500 -24130 0 1 {name=p38845 lab=_48314_/Y }
C {sky130_stdcells/a21boi_4.sym} 39420 -24130 0 0 {name=X_48314_ }
C {devices/lab_pin.sym} 39360 -24000 0 0 {name=p38846 lab=_79134_/A }
C {devices/lab_pin.sym} 39360 -23960 0 0 {name=p38847 lab=_79134_/B }
C {devices/lab_pin.sym} 39480 -23980 0 1 {name=p38848 lab=_79134_/X }
C {sky130_stdcells/xor2_4.sym} 39420 -23980 0 0 {name=X_79134_ }
C {devices/lab_pin.sym} 39380 -23850 0 0 {name=p38849 lab=_45526_/A }
C {devices/lab_pin.sym} 39460 -23850 0 1 {name=p38850 lab=_45527_/A }
C {sky130_stdcells/inv_2.sym} 39420 -23850 0 0 {name=X_45526_ }
C {devices/lab_pin.sym} 39360 -23740 0 0 {name=p38851 lab=_59411_/A }
C {devices/lab_pin.sym} 39360 -23700 0 0 {name=p38852 lab=_64316_/B }
C {devices/lab_pin.sym} 39480 -23720 0 1 {name=p38853 lab=_64360_/Y }
C {sky130_stdcells/nor2_4.sym} 39420 -23720 0 0 {name=X_64360_ }
C {devices/lab_pin.sym} 39360 -23600 0 0 {name=p38854 lab=_76345_/A }
C {devices/lab_pin.sym} 39360 -23560 0 0 {name=p38855 lab=_81564_/Q }
C {devices/lab_pin.sym} 39480 -23580 0 1 {name=p38856 lab=_76347_/A }
C {sky130_stdcells/nand2_4.sym} 39420 -23580 0 0 {name=X_76346_ }
C {devices/lab_pin.sym} 39380 -23450 0 0 {name=p38857 lab=_42737_/Y }
C {devices/lab_pin.sym} 39460 -23450 0 1 {name=p38858 lab=_87743_/D }
C {sky130_stdcells/inv_2.sym} 39420 -23450 0 0 {name=X_42738_ }
C {devices/lab_pin.sym} 39340 -23350 0 0 {name=p38859 lab=_49292_/Y }
C {devices/lab_pin.sym} 39340 -23310 0 0 {name=p38860 lab=_49281_/X }
C {devices/lab_pin.sym} 39340 -23270 0 0 {name=p38861 lab=_49293_/X }
C {devices/lab_pin.sym} 39500 -23310 0 1 {name=p38862 lab=_86416_/D }
C {sky130_stdcells/a21oi_4.sym} 39420 -23310 0 0 {name=X_49294_ }
C {devices/lab_pin.sym} 39360 -23200 0 0 {name=p38863 lab=_61572_/A }
C {devices/lab_pin.sym} 39360 -23160 0 0 {name=p38864 lab=_61542_/B }
C {devices/lab_pin.sym} 39360 -23120 0 0 {name=p38865 lab=_61542_/C }
C {devices/lab_pin.sym} 39360 -23080 0 0 {name=p38866 lab=_61572_/D }
C {devices/lab_pin.sym} 39480 -23140 0 1 {name=p38867 lab=_61572_/Y }
C {sky130_stdcells/nand4_4.sym} 39420 -23140 0 0 {name=X_61572_ }
C {devices/lab_pin.sym} 39340 -23010 0 0 {name=p38868 lab=_87007_/Q }
C {devices/lab_pin.sym} 39340 -22970 0 0 {name=p38869 lab=_57092_/X }
C {devices/lab_pin.sym} 39340 -22930 0 0 {name=p38870 lab=_73557_/X }
C {devices/lab_pin.sym} 39500 -22970 0 1 {name=p38871 lab=_73558_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -22970 0 0 {name=X_73558_ }
C {devices/lab_pin.sym} 39340 -22870 0 0 {name=p38872 lab=_59433_/Y }
C {devices/lab_pin.sym} 39340 -22830 0 0 {name=p38873 lab=_63259_/X }
C {devices/lab_pin.sym} 39340 -22790 0 0 {name=p38874 lab=_63234_/X }
C {devices/lab_pin.sym} 39340 -22750 0 0 {name=p38875 lab=_58978_/Y }
C {devices/lab_pin.sym} 39340 -22710 0 0 {name=p38876 lab=_63235_/X }
C {devices/lab_pin.sym} 39500 -22790 0 1 {name=p38877 lab=_63311_/Y }
C {sky130_stdcells/o32ai_4.sym} 39420 -22790 0 0 {name=X_63311_ }
C {devices/lab_pin.sym} 39380 -22630 0 0 {name=p38878 lab=_60523_/A }
C {devices/lab_pin.sym} 39460 -22630 0 1 {name=p38879 lab=_60523_/X }
C {sky130_stdcells/buf_2.sym} 39420 -22630 0 0 {name=X_60523_ }
C {devices/lab_pin.sym} 39340 -22530 0 0 {name=p38880 lab=_66087_/B }
C {devices/lab_pin.sym} 39340 -22490 0 0 {name=p38881 lab=_48241_/X }
C {devices/lab_pin.sym} 39340 -22450 0 0 {name=p38882 lab=_48244_/Y }
C {devices/lab_pin.sym} 39500 -22490 0 1 {name=p38883 lab=_48245_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -22490 0 0 {name=X_48245_ }
C {devices/lab_pin.sym} 39380 -22350 0 0 {name=p38884 lab=_72503_/A }
C {devices/lab_pin.sym} 39460 -22350 0 1 {name=p38885 lab=_72510_/C }
C {sky130_stdcells/buf_2.sym} 39420 -22350 0 0 {name=X_72509_ }
C {devices/lab_pin.sym} 39380 -22230 0 0 {name=p38886 lab=_79065_/A }
C {devices/lab_pin.sym} 39460 -22230 0 1 {name=p38887 lab=_79065_/Y }
C {sky130_stdcells/inv_2.sym} 39420 -22230 0 0 {name=X_79065_ }
C {devices/lab_pin.sym} 39360 -22120 0 0 {name=p38888 lab=_85117_/Q }
C {devices/lab_pin.sym} 39360 -22080 0 0 {name=p38889 lab=_45456_/X }
C {devices/lab_pin.sym} 39480 -22100 0 1 {name=p38890 lab=_45457_/Y }
C {sky130_stdcells/nor2_4.sym} 39420 -22100 0 0 {name=X_45457_ }
C {devices/lab_pin.sym} 39340 -21990 0 0 {name=p38891 lab=_79817_/B }
C {devices/lab_pin.sym} 39340 -21950 0 0 {name=p38892 lab=_64255_/X }
C {devices/lab_pin.sym} 39340 -21910 0 0 {name=p38893 lab=_64290_/X }
C {devices/lab_pin.sym} 39500 -21950 0 1 {name=p38894 lab=_64291_/X }
C {sky130_stdcells/a21o_4.sym} 39420 -21950 0 0 {name=X_64291_ }
C {devices/lab_pin.sym} 39360 -21820 0 0 {name=p38895 lab=_76276_/B }
C {devices/lab_pin.sym} 39360 -21780 0 0 {name=p38896 lab=_81643_/Q }
C {devices/lab_pin.sym} 39480 -21800 0 1 {name=p38897 lab=_76282_/C }
C {sky130_stdcells/nand2_4.sym} 39420 -21800 0 0 {name=X_76277_ }
C {devices/lab_pin.sym} 39340 -21700 0 0 {name=p38898 lab=_41028_/X }
C {devices/lab_pin.sym} 39340 -21660 0 0 {name=p38899 lab=_42652_/X }
C {devices/lab_pin.sym} 39340 -21620 0 0 {name=p38900 lab=_69354_/B }
C {devices/lab_pin.sym} 39340 -21580 0 0 {name=p38901 lab=_42653_/X }
C {devices/lab_pin.sym} 39500 -21640 0 1 {name=p38902 lab=_87779_/D }
C {sky130_stdcells/a2bb2o_4.sym} 39420 -21640 0 0 {name=X_42669_ }
C {devices/lab_pin.sym} 39380 -21490 0 0 {name=p38903 lab=_72861_/X }
C {devices/lab_pin.sym} 39460 -21490 0 1 {name=p38904 lab=_73489_/X }
C {sky130_stdcells/buf_2.sym} 39420 -21490 0 0 {name=X_73489_ }
C {devices/lab_pin.sym} 39360 -21380 0 0 {name=p38905 lab=_66030_/A }
C {devices/lab_pin.sym} 39360 -21340 0 0 {name=p38906 lab=_66029_/X }
C {devices/lab_pin.sym} 39480 -21360 0 1 {name=p38907 lab=_66030_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -21360 0 0 {name=X_66030_ }
C {devices/lab_pin.sym} 39340 -21250 0 0 {name=p38908 lab=_78011_/Y }
C {devices/lab_pin.sym} 39340 -21210 0 0 {name=p38909 lab=_77993_/B }
C {devices/lab_pin.sym} 39340 -21170 0 0 {name=p38910 lab=_78015_/Y }
C {devices/lab_pin.sym} 39500 -21210 0 1 {name=p38911 lab=_78018_/B }
C {sky130_stdcells/o21ai_4.sym} 39420 -21210 0 0 {name=X_78016_ }
C {devices/lab_pin.sym} 39380 -21070 0 0 {name=p38912 lab=_44407_/Y }
C {devices/lab_pin.sym} 39460 -21070 0 1 {name=p38913 lab=_87124_/D }
C {sky130_stdcells/inv_2.sym} 39420 -21070 0 0 {name=X_44408_ }
C {devices/lab_pin.sym} 39380 -20950 0 0 {name=p38914 lab=_63018_/X }
C {devices/lab_pin.sym} 39460 -20950 0 1 {name=p38915 lab=_63242_/X }
C {sky130_stdcells/buf_2.sym} 39420 -20950 0 0 {name=X_63242_ }
C {devices/lab_pin.sym} 39360 -20850 0 0 {name=p38916 lab=_75224_/Y }
C {devices/lab_pin.sym} 39360 -20810 0 0 {name=p38917 lab=_75225_/Y }
C {devices/lab_pin.sym} 39360 -20770 0 0 {name=p38918 lab=_75227_/Y }
C {devices/lab_pin.sym} 39480 -20810 0 1 {name=p38919 lab=_75228_/X }
C {sky130_stdcells/or3_4.sym} 39420 -20810 0 0 {name=X_75228_ }
C {devices/lab_pin.sym} 39380 -20670 0 0 {name=p38920 lab=_48903_/A }
C {devices/lab_pin.sym} 39460 -20670 0 1 {name=p38921 lab=_49173_/A }
C {sky130_stdcells/buf_2.sym} 39420 -20670 0 0 {name=X_48176_ }
C {devices/lab_pin.sym} 39380 -20550 0 0 {name=p38922 lab=_60454_/A }
C {devices/lab_pin.sym} 39460 -20550 0 1 {name=p38923 lab=_60562_/B }
C {sky130_stdcells/buf_2.sym} 39420 -20550 0 0 {name=X_60454_ }
C {devices/lab_pin.sym} 39380 -20430 0 0 {name=p38924 lab=_45596_/A }
C {devices/lab_pin.sym} 39460 -20430 0 1 {name=p38925 lab=_45388_/X }
C {sky130_stdcells/buf_2.sym} 39420 -20430 0 0 {name=X_45388_ }
C {devices/lab_pin.sym} 39380 -20310 0 0 {name=p38926 lab=_46653_/A }
C {devices/lab_pin.sym} 39460 -20310 0 1 {name=p38927 lab=_47128_/A }
C {sky130_stdcells/buf_2.sym} 39420 -20310 0 0 {name=X_47127_ }
C {devices/lab_pin.sym} 39380 -20190 0 0 {name=p38928 lab=_44339_/A }
C {devices/lab_pin.sym} 39460 -20190 0 1 {name=p38929 lab=_87159_/D }
C {sky130_stdcells/inv_2.sym} 39420 -20190 0 0 {name=X_44339_ }
C {devices/lab_pin.sym} 39340 -20090 0 0 {name=p38930 lab=_63169_/Y }
C {devices/lab_pin.sym} 39340 -20050 0 0 {name=p38931 lab=_63171_/X }
C {devices/lab_pin.sym} 39340 -20010 0 0 {name=p38932 lab=_63172_/X }
C {devices/lab_pin.sym} 39500 -20050 0 1 {name=p38933 lab=_63173_/Y }
C {sky130_stdcells/a21oi_4.sym} 39420 -20050 0 0 {name=X_63173_ }
C {devices/lab_pin.sym} 39340 -19930 0 0 {name=p38934 lab=_75158_/Y }
C {devices/lab_pin.sym} 39340 -19890 0 0 {name=p38935 lab=_75138_/Y }
C {devices/lab_pin.sym} 39340 -19850 0 0 {name=p38936 lab=_75140_/Y }
C {devices/lab_pin.sym} 39500 -19890 0 1 {name=p38937 lab=_75159_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -19890 0 0 {name=X_75159_ }
C {devices/lab_pin.sym} 39360 -19760 0 0 {name=p38938 lab=_60385_/A }
C {devices/lab_pin.sym} 39360 -19720 0 0 {name=p38939 lab=_60182_/A }
C {devices/lab_pin.sym} 39480 -19740 0 1 {name=p38940 lab=_60386_/A }
C {sky130_stdcells/nor2_4.sym} 39420 -19740 0 0 {name=X_60385_ }
C {devices/lab_pin.sym} 39360 -19640 0 0 {name=p38941 lab=_61948_/A }
C {devices/lab_pin.sym} 39360 -19600 0 0 {name=p38942 lab=_62124_/B }
C {devices/lab_pin.sym} 39360 -19560 0 0 {name=p38943 lab=_61755_/X }
C {devices/lab_pin.sym} 39360 -19520 0 0 {name=p38944 lab=_61728_/A }
C {devices/lab_pin.sym} 39480 -19580 0 1 {name=p38945 lab=_62124_/X }
C {sky130_stdcells/and4_4.sym} 39420 -19580 0 0 {name=X_62124_ }
C {devices/lab_pin.sym} 39380 -19430 0 0 {name=p38946 lab=_54522_/D }
C {devices/lab_pin.sym} 39460 -19430 0 1 {name=p38947 lab=_52831_/D }
C {sky130_stdcells/buf_2.sym} 39420 -19430 0 0 {name=X_47058_ }
C {devices/lab_pin.sym} 39360 -19320 0 0 {name=p38948 lab=_67978_/X }
C {devices/lab_pin.sym} 39360 -19280 0 0 {name=p38949 lab=_67981_/B }
C {devices/lab_pin.sym} 39480 -19300 0 1 {name=p38950 lab=_67981_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -19300 0 0 {name=X_67981_ }
C {devices/lab_pin.sym} 39380 -19170 0 0 {name=p38951 lab=_79966_/X }
C {devices/lab_pin.sym} 39460 -19170 0 1 {name=p38952 lab=_79967_/Y }
C {sky130_stdcells/inv_2.sym} 39420 -19170 0 0 {name=X_79967_ }
C {devices/lab_pin.sym} 39340 -19080 0 0 {name=p38953 lab=_40496_/Y }
C {devices/lab_pin.sym} 39340 -19040 0 0 {name=p38954 lab=_46007_/X }
C {devices/lab_pin.sym} 39340 -19000 0 0 {name=p38955 lab=_67071_/B }
C {devices/lab_pin.sym} 39340 -18960 0 0 {name=p38956 lab=_46008_/X }
C {devices/lab_pin.sym} 39500 -19020 0 1 {name=p38957 lab=_86817_/D }
C {sky130_stdcells/a2bb2o_4.sym} 39420 -19020 0 0 {name=X_46009_ }
C {devices/lab_pin.sym} 39340 -18900 0 0 {name=p38958 lab=_73081_/A }
C {devices/lab_pin.sym} 39340 -18860 0 0 {name=p38959 lab=_68636_/X }
C {devices/lab_pin.sym} 39340 -18820 0 0 {name=p38960 lab=_68691_/X }
C {devices/lab_pin.sym} 39340 -18780 0 0 {name=p38961 lab=_69719_/Y }
C {devices/lab_pin.sym} 39500 -18840 0 1 {name=p38962 lab=_69720_/X }
C {sky130_stdcells/a211o_4.sym} 39420 -18840 0 0 {name=X_69720_ }
C {devices/lab_pin.sym} 39360 -18700 0 0 {name=p38963 lab=_66956_/A }
C {devices/lab_pin.sym} 39360 -18660 0 0 {name=p38964 lab=_66932_/B }
C {devices/lab_pin.sym} 39480 -18680 0 1 {name=p38965 lab=_66932_/X }
C {sky130_stdcells/and2_4.sym} 39420 -18680 0 0 {name=X_66932_ }
C {devices/lab_pin.sym} 39360 -18580 0 0 {name=p38966 lab=_62055_/A }
C {devices/lab_pin.sym} 39360 -18540 0 0 {name=p38967 lab=_62055_/B }
C {devices/lab_pin.sym} 39360 -18500 0 0 {name=p38968 lab=_59628_/A }
C {devices/lab_pin.sym} 39360 -18460 0 0 {name=p38969 lab=_59649_/A }
C {devices/lab_pin.sym} 39480 -18520 0 1 {name=p38970 lab=_62055_/X }
C {sky130_stdcells/and4_4.sym} 39420 -18520 0 0 {name=X_62055_ }
C {devices/lab_pin.sym} 39360 -18380 0 0 {name=p38971 lab=_78914_/Y }
C {devices/lab_pin.sym} 39360 -18340 0 0 {name=p38972 lab=_78918_/B }
C {devices/lab_pin.sym} 39480 -18360 0 1 {name=p38973 lab=_78918_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -18360 0 0 {name=X_78918_ }
C {devices/lab_pin.sym} 39360 -18240 0 0 {name=p38974 lab=_60153_/C }
C {devices/lab_pin.sym} 39360 -18200 0 0 {name=p38975 lab=_64200_/C }
C {devices/lab_pin.sym} 39480 -18220 0 1 {name=p38976 lab=_79898_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -18220 0 0 {name=X_79898_ }
C {devices/lab_pin.sym} 39380 -18090 0 0 {name=p38977 lab=_63734_/A }
C {devices/lab_pin.sym} 39460 -18090 0 1 {name=p38978 lab=_63765_/A }
C {sky130_stdcells/buf_2.sym} 39420 -18090 0 0 {name=X_61006_ }
C {devices/lab_pin.sym} 39380 -17970 0 0 {name=p38979 lab=_69651_/A }
C {devices/lab_pin.sym} 39460 -17970 0 1 {name=p38980 lab=_69680_/A }
C {sky130_stdcells/buf_2.sym} 39420 -17970 0 0 {name=X_69651_ }
C {devices/lab_pin.sym} 39380 -17850 0 0 {name=p38981 lab=_66628_/X }
C {devices/lab_pin.sym} 39460 -17850 0 1 {name=p38982 lab=_66863_/X }
C {sky130_stdcells/buf_2.sym} 39420 -17850 0 0 {name=X_66863_ }
C {devices/lab_pin.sym} 39340 -17750 0 0 {name=p38983 lab=_78874_/A }
C {devices/lab_pin.sym} 39340 -17710 0 0 {name=p38984 lab=_78854_/B }
C {devices/lab_pin.sym} 39340 -17670 0 0 {name=p38985 lab=_78856_/A }
C {devices/lab_pin.sym} 39500 -17710 0 1 {name=p38986 lab=_78849_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -17710 0 0 {name=X_78849_ }
C {devices/lab_pin.sym} 39380 -17570 0 0 {name=p38987 lab=_44020_/A }
C {devices/lab_pin.sym} 39460 -17570 0 1 {name=p38988 lab=_69357_/A }
C {sky130_stdcells/buf_2.sym} 39420 -17570 0 0 {name=X_68602_ }
C {devices/lab_pin.sym} 39360 -17470 0 0 {name=p38989 lab=_65810_/X }
C {devices/lab_pin.sym} 39360 -17430 0 0 {name=p38990 lab=_65725_/B }
C {devices/lab_pin.sym} 39360 -17390 0 0 {name=p38991 lab=_65813_/X }
C {devices/lab_pin.sym} 39480 -17430 0 1 {name=p38992 lab=_65814_/Y }
C {sky130_stdcells/nand3_4.sym} 39420 -17430 0 0 {name=X_65814_ }
C {devices/lab_pin.sym} 39330 -17290 0 0 {name=p38993 lab=_81859_/CLK }
C {devices/lab_pin.sym} 39330 -17270 0 0 {name=p38994 lab=_78051_/X }
C {devices/lab_pin.sym} 39510 -17290 0 1 {name=p38995 lab=_81828_/D }
C {sky130_stdcells/dfxtp_4.sym} 39420 -17280 0 0 {name=X_81860_ }
C {devices/lab_pin.sym} 39380 -17150 0 0 {name=p38996 lab=_69582_/A }
C {devices/lab_pin.sym} 39460 -17150 0 1 {name=p38997 lab=_69582_/X }
C {sky130_stdcells/buf_2.sym} 39420 -17150 0 0 {name=X_69582_ }
C {devices/lab_pin.sym} 39380 -17030 0 0 {name=p38998 lab=_66794_/A }
C {devices/lab_pin.sym} 39460 -17030 0 1 {name=p38999 lab=_66794_/X }
C {sky130_stdcells/buf_2.sym} 39420 -17030 0 0 {name=X_66794_ }
C {devices/lab_pin.sym} 39330 -16910 0 0 {name=p39000 lab=_83957_/CLK }
C {devices/lab_pin.sym} 39330 -16890 0 0 {name=p39001 lab=_83955_/Q }
C {devices/lab_pin.sym} 39510 -16910 0 1 {name=p39002 lab=_75796_/B }
C {sky130_stdcells/dfxtp_4.sym} 39420 -16900 0 0 {name=X_80811_ }
C {devices/lab_pin.sym} 39380 -16770 0 0 {name=p39003 lab=_64584_/X }
C {devices/lab_pin.sym} 39460 -16770 0 1 {name=p39004 lab=_69014_/A }
C {sky130_stdcells/buf_2.sym} 39420 -16770 0 0 {name=X_68533_ }
C {devices/lab_pin.sym} 39360 -16670 0 0 {name=p39005 lab=_65888_/A }
C {devices/lab_pin.sym} 39360 -16630 0 0 {name=p39006 lab=_65802_/B }
C {devices/lab_pin.sym} 39360 -16590 0 0 {name=p39007 lab=_65745_/C }
C {devices/lab_pin.sym} 39480 -16630 0 1 {name=p39008 lab=_65745_/Y }
C {sky130_stdcells/nor3_4.sym} 39420 -16630 0 0 {name=X_65745_ }
C {devices/lab_pin.sym} 39360 -16500 0 0 {name=p39009 lab=_50971_/A }
C {devices/lab_pin.sym} 39360 -16460 0 0 {name=p39010 lab=_50971_/B }
C {devices/lab_pin.sym} 39480 -16480 0 1 {name=p39011 lab=_50971_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -16480 0 0 {name=X_50971_ }
C {devices/lab_pin.sym} 39360 -16370 0 0 {name=p39012 lab=_62965_/A }
C {devices/lab_pin.sym} 39360 -16330 0 0 {name=p39013 lab=_62664_/B }
C {devices/lab_pin.sym} 39360 -16290 0 0 {name=p39014 lab=_62140_/X }
C {devices/lab_pin.sym} 39480 -16330 0 1 {name=p39015 lab=_62957_/Y }
C {sky130_stdcells/nand3_4.sym} 39420 -16330 0 0 {name=X_62957_ }
C {devices/lab_pin.sym} 39330 -16190 0 0 {name=p39016 lab=_86807_/CLK }
C {devices/lab_pin.sym} 39330 -16170 0 0 {name=p39017 lab=_75950_/X }
C {devices/lab_pin.sym} 39510 -16190 0 1 {name=p39018 lab=_48384_/A }
C {sky130_stdcells/dfxtp_4.sym} 39420 -16180 0 0 {name=X_81791_ }
C {devices/lab_pin.sym} 39340 -16070 0 0 {name=p39019 lab=_52707_/Y }
C {devices/lab_pin.sym} 39340 -16030 0 0 {name=p39020 lab=_52702_/X }
C {devices/lab_pin.sym} 39340 -15990 0 0 {name=p39021 lab=_52709_/X }
C {devices/lab_pin.sym} 39500 -16030 0 1 {name=p39022 lab=_52710_/Y }
C {sky130_stdcells/a21oi_4.sym} 39420 -16030 0 0 {name=X_52710_ }
C {devices/lab_pin.sym} 39330 -15890 0 0 {name=p39023 lab=_86210_/CLK }
C {devices/lab_pin.sym} 39330 -15870 0 0 {name=p39024 lab=_71339_/Y }
C {devices/lab_pin.sym} 39510 -15890 0 1 {name=p39025 lab=_48152_/A }
C {sky130_stdcells/dfxtp_4.sym} 39420 -15880 0 0 {name=X_83530_ }
C {devices/lab_pin.sym} 39360 -15780 0 0 {name=p39026 lab=_61460_/B }
C {devices/lab_pin.sym} 39360 -15740 0 0 {name=p39027 lab=_61843_/B }
C {devices/lab_pin.sym} 39360 -15700 0 0 {name=p39028 lab=_61860_/C }
C {devices/lab_pin.sym} 39360 -15660 0 0 {name=p39029 lab=_61860_/D }
C {devices/lab_pin.sym} 39480 -15720 0 1 {name=p39030 lab=_61908_/Y }
C {sky130_stdcells/nand4_4.sym} 39420 -15720 0 0 {name=X_61908_ }
C {devices/lab_pin.sym} 39330 -15570 0 0 {name=p39031 lab=_81996_/CLK }
C {devices/lab_pin.sym} 39330 -15550 0 0 {name=p39032 lab=_80742_/D }
C {devices/lab_pin.sym} 39510 -15570 0 1 {name=p39033 lab=_81150_/D }
C {sky130_stdcells/dfxtp_4.sym} 39420 -15560 0 0 {name=X_80742_ }
C {devices/lab_pin.sym} 39380 -15430 0 0 {name=p39034 lab=_87855_/Q }
C {devices/lab_pin.sym} 39460 -15430 0 1 {name=p39035 lab=_68465_/B }
C {sky130_stdcells/inv_2.sym} 39420 -15430 0 0 {name=X_68464_ }
C {devices/lab_pin.sym} 39340 -15330 0 0 {name=p39036 lab=_85587_/Q }
C {devices/lab_pin.sym} 39340 -15290 0 0 {name=p39037 lab=_53687_/X }
C {devices/lab_pin.sym} 39340 -15250 0 0 {name=p39038 lab=_53689_/Y }
C {devices/lab_pin.sym} 39500 -15290 0 1 {name=p39039 lab=_53690_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -15290 0 0 {name=X_53690_ }
C {devices/lab_pin.sym} 39360 -15160 0 0 {name=p39040 lab=_65676_/A }
C {devices/lab_pin.sym} 39360 -15120 0 0 {name=p39041 lab=_65675_/X }
C {devices/lab_pin.sym} 39480 -15140 0 1 {name=p39042 lab=_65676_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -15140 0 0 {name=X_65676_ }
C {devices/lab_pin.sym} 39360 -15030 0 0 {name=p39043 lab=_62965_/A }
C {devices/lab_pin.sym} 39360 -14990 0 0 {name=p39044 lab=_62935_/B }
C {devices/lab_pin.sym} 39360 -14950 0 0 {name=p39045 lab=_63610_/B }
C {devices/lab_pin.sym} 39480 -14990 0 1 {name=p39046 lab=_62888_/Y }
C {sky130_stdcells/nand3_4.sym} 39420 -14990 0 0 {name=X_62888_ }
C {devices/lab_pin.sym} 39360 -14860 0 0 {name=p39047 lab=_67342_/A }
C {devices/lab_pin.sym} 39360 -14820 0 0 {name=p39048 lab=_67415_/B }
C {devices/lab_pin.sym} 39480 -14840 0 1 {name=p39049 lab=_67415_/X }
C {sky130_stdcells/and2_4.sym} 39420 -14840 0 0 {name=X_67415_ }
C {devices/lab_pin.sym} 39360 -14720 0 0 {name=p39050 lab=_52637_/A }
C {devices/lab_pin.sym} 39360 -14680 0 0 {name=p39051 lab=_54332_/B }
C {devices/lab_pin.sym} 39480 -14700 0 1 {name=p39052 lab=_52641_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -14700 0 0 {name=X_52641_ }
C {devices/lab_pin.sym} 39360 -14580 0 0 {name=p39053 lab=_64680_/A }
C {devices/lab_pin.sym} 39360 -14540 0 0 {name=p39054 lab=_64627_/B }
C {devices/lab_pin.sym} 39480 -14560 0 1 {name=p39055 lab=_64627_/X }
C {sky130_stdcells/and2_4.sym} 39420 -14560 0 0 {name=X_64627_ }
C {devices/lab_pin.sym} 39330 -14430 0 0 {name=p39056 lab=_83464_/CLK }
C {devices/lab_pin.sym} 39330 -14410 0 0 {name=p39057 lab=_83461_/D }
C {devices/lab_pin.sym} 39510 -14430 0 1 {name=p39058 lab=_83461_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -14420 0 0 {name=X_83461_ }
C {devices/lab_pin.sym} 39360 -14320 0 0 {name=p39059 lab=_61839_/A }
C {devices/lab_pin.sym} 39360 -14280 0 0 {name=p39060 lab=_61839_/B }
C {devices/lab_pin.sym} 39360 -14240 0 0 {name=p39061 lab=_61839_/C }
C {devices/lab_pin.sym} 39360 -14200 0 0 {name=p39062 lab=_63089_/B }
C {devices/lab_pin.sym} 39480 -14260 0 1 {name=p39063 lab=_61839_/X }
C {sky130_stdcells/and4_4.sym} 39420 -14260 0 0 {name=X_61839_ }
C {devices/lab_pin.sym} 39330 -14110 0 0 {name=p39064 lab=_81807_/CLK }
C {devices/lab_pin.sym} 39330 -14090 0 0 {name=p39065 lab=_70157_/X }
C {devices/lab_pin.sym} 39510 -14110 0 1 {name=p39066 lab=_80673_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -14100 0 0 {name=X_80673_ }
C {devices/lab_pin.sym} 39380 -13970 0 0 {name=p39067 lab=_64584_/X }
C {devices/lab_pin.sym} 39460 -13970 0 1 {name=p39068 lab=_69651_/A }
C {sky130_stdcells/buf_2.sym} 39420 -13970 0 0 {name=X_68395_ }
C {devices/lab_pin.sym} 39330 -13850 0 0 {name=p39069 lab=_85297_/CLK }
C {devices/lab_pin.sym} 39330 -13830 0 0 {name=p39070 lab=_85200_/D }
C {devices/lab_pin.sym} 39510 -13850 0 1 {name=p39071 lab=_56420_/C }
C {sky130_stdcells/dfxtp_4.sym} 39420 -13840 0 0 {name=X_85200_ }
C {devices/lab_pin.sym} 39330 -13710 0 0 {name=p39072 lab=_82248_/CLK }
C {devices/lab_pin.sym} 39330 -13690 0 0 {name=p39073 lab=_82444_/Q }
C {devices/lab_pin.sym} 39510 -13710 0 1 {name=p39074 lab=_78455_/A }
C {sky130_stdcells/dfxtp_4.sym} 39420 -13700 0 0 {name=X_82412_ }
C {devices/lab_pin.sym} 39380 -13570 0 0 {name=p39075 lab=_55360_/A }
C {devices/lab_pin.sym} 39460 -13570 0 1 {name=p39076 lab=_55360_/X }
C {sky130_stdcells/buf_2.sym} 39420 -13570 0 0 {name=X_55360_ }
C {devices/lab_pin.sym} 39340 -13480 0 0 {name=p39077 lab=_87411_/Q }
C {devices/lab_pin.sym} 39340 -13440 0 0 {name=p39078 lab=_67274_/X }
C {devices/lab_pin.sym} 39340 -13400 0 0 {name=p39079 lab=_67344_/X }
C {devices/lab_pin.sym} 39340 -13360 0 0 {name=p39080 lab=_67345_/X }
C {devices/lab_pin.sym} 39500 -13420 0 1 {name=p39081 lab=_67346_/X }
C {sky130_stdcells/a211o_4.sym} 39420 -13420 0 0 {name=X_67346_ }
C {devices/lab_pin.sym} 39330 -13270 0 0 {name=p39082 lab=_85859_/CLK }
C {devices/lab_pin.sym} 39330 -13250 0 0 {name=p39083 lab=_86180_/D }
C {devices/lab_pin.sym} 39510 -13270 0 1 {name=p39084 lab=_86180_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -13260 0 0 {name=X_86180_ }
C {devices/lab_pin.sym} 39340 -13150 0 0 {name=p39085 lab=_65411_/B }
C {devices/lab_pin.sym} 39340 -13110 0 0 {name=p39086 lab=_52516_/X }
C {devices/lab_pin.sym} 39340 -13070 0 0 {name=p39087 lab=_52571_/Y }
C {devices/lab_pin.sym} 39500 -13110 0 1 {name=p39088 lab=_52572_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -13110 0 0 {name=X_52572_ }
C {devices/lab_pin.sym} 39340 -13010 0 0 {name=p39089 lab=_64552_/Y }
C {devices/lab_pin.sym} 39340 -12970 0 0 {name=p39090 lab=_64555_/Y }
C {devices/lab_pin.sym} 39340 -12930 0 0 {name=p39091 lab=_64557_/Y }
C {devices/lab_pin.sym} 39340 -12890 0 0 {name=p39092 lab=_84866_/Q }
C {devices/lab_pin.sym} 39340 -12850 0 0 {name=p39093 lab=_64521_/X }
C {devices/lab_pin.sym} 39500 -12930 0 1 {name=p39094 lab=_64558_/Y }
C {sky130_stdcells/o32ai_4.sym} 39420 -12930 0 0 {name=X_64558_ }
C {devices/lab_pin.sym} 39330 -12770 0 0 {name=p39095 lab=_85505_/CLK }
C {devices/lab_pin.sym} 39330 -12750 0 0 {name=p39096 lab=_83392_/D }
C {devices/lab_pin.sym} 39510 -12770 0 1 {name=p39097 lab=_47230_/A }
C {sky130_stdcells/dfxtp_4.sym} 39420 -12760 0 0 {name=X_83392_ }
C {sky130_stdcells/decap_3.sym} 39420 -12600 0 0 {name=XPHY_507 }
C {sky130_stdcells/decap_3.sym} 39420 -12420 0 0 {name=XPHY_518 }
C {devices/lab_pin.sym} 39380 -12270 0 0 {name=p39098 lab=_54366_/A }
C {devices/lab_pin.sym} 39460 -12270 0 1 {name=p39099 lab=_54311_/X }
C {sky130_stdcells/buf_2.sym} 39420 -12270 0 0 {name=X_54311_ }
C {sky130_stdcells/decap_3.sym} 39420 -12120 0 0 {name=XPHY_529 }
C {devices/lab_pin.sym} 39330 -11970 0 0 {name=p39100 lab=_85071_/CLK }
C {devices/lab_pin.sym} 39330 -11950 0 0 {name=p39101 lab=_85131_/D }
C {devices/lab_pin.sym} 39510 -11970 0 1 {name=p39102 lab=_85131_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -11960 0 0 {name=X_85131_ }
C {devices/lab_pin.sym} 39340 -11850 0 0 {name=p39103 lab=_51519_/Y }
C {devices/lab_pin.sym} 39340 -11810 0 0 {name=p39104 lab=_51503_/X }
C {devices/lab_pin.sym} 39340 -11770 0 0 {name=p39105 lab=_51522_/X }
C {devices/lab_pin.sym} 39500 -11810 0 1 {name=p39106 lab=_51523_/Y }
C {sky130_stdcells/a21oi_4.sym} 39420 -11810 0 0 {name=X_51523_ }
C {devices/lab_pin.sym} 39360 -11700 0 0 {name=p39107 lab=_63496_/A }
C {devices/lab_pin.sym} 39360 -11660 0 0 {name=p39108 lab=_58520_/A }
C {devices/lab_pin.sym} 39360 -11620 0 0 {name=p39109 lab=_63458_/X }
C {devices/lab_pin.sym} 39360 -11580 0 0 {name=p39110 lab=_63496_/D }
C {devices/lab_pin.sym} 39480 -11640 0 1 {name=p39111 lab=_63509_/X }
C {sky130_stdcells/and4_4.sym} 39420 -11640 0 0 {name=X_63509_ }
C {devices/lab_pin.sym} 39330 -11490 0 0 {name=p39112 lab=_82343_/CLK }
C {devices/lab_pin.sym} 39330 -11470 0 0 {name=p39113 lab=_77089_/X }
C {devices/lab_pin.sym} 39510 -11490 0 1 {name=p39114 lab=_48110_/A }
C {sky130_stdcells/dfxtp_4.sym} 39420 -11480 0 0 {name=X_82343_ }
C {devices/lab_pin.sym} 39340 -11370 0 0 {name=p39115 lab=_55263_/X }
C {devices/lab_pin.sym} 39340 -11330 0 0 {name=p39116 lab=_55290_/Y }
C {devices/lab_pin.sym} 39340 -11290 0 0 {name=p39117 lab=_55264_/Y }
C {devices/lab_pin.sym} 39500 -11330 0 1 {name=p39118 lab=_55291_/Y }
C {sky130_stdcells/a21boi_4.sym} 39420 -11330 0 0 {name=X_55291_ }
C {devices/lab_pin.sym} 39340 -11210 0 0 {name=p39119 lab=_67273_/X }
C {devices/lab_pin.sym} 39340 -11170 0 0 {name=p39120 lab=_67276_/X }
C {devices/lab_pin.sym} 39340 -11130 0 0 {name=p39121 lab=_67204_/X }
C {devices/lab_pin.sym} 39500 -11170 0 1 {name=p39122 lab=_67277_/X }
C {sky130_stdcells/a21o_4.sym} 39420 -11170 0 0 {name=X_67277_ }
C {devices/lab_pin.sym} 39340 -11070 0 0 {name=p39123 lab=_64483_/X }
C {devices/lab_pin.sym} 39340 -11030 0 0 {name=p39124 lab=_64486_/Y }
C {devices/lab_pin.sym} 39340 -10990 0 0 {name=p39125 lab=_64488_/Y }
C {devices/lab_pin.sym} 39340 -10950 0 0 {name=p39126 lab=_84873_/Q }
C {devices/lab_pin.sym} 39340 -10910 0 0 {name=p39127 lab=_64213_/X }
C {devices/lab_pin.sym} 39500 -10990 0 1 {name=p39128 lab=_64489_/Y }
C {sky130_stdcells/o32ai_4.sym} 39420 -10990 0 0 {name=X_64489_ }
C {devices/lab_pin.sym} 39340 -10850 0 0 {name=p39129 lab=_56930_/X }
C {devices/lab_pin.sym} 39340 -10810 0 0 {name=p39130 lab=_57028_/Y }
C {devices/lab_pin.sym} 39340 -10770 0 0 {name=p39131 lab=_57029_/Y }
C {devices/lab_pin.sym} 39500 -10810 0 1 {name=p39132 lab=_57031_/A }
C {sky130_stdcells/o21ai_4.sym} 39420 -10810 0 0 {name=X_57030_ }
C {devices/lab_pin.sym} 39340 -10700 0 0 {name=p39133 lab=_87077_/Q }
C {devices/lab_pin.sym} 39340 -10660 0 0 {name=p39134 lab=_68948_/X }
C {devices/lab_pin.sym} 39340 -10620 0 0 {name=p39135 lab=_68993_/X }
C {devices/lab_pin.sym} 39340 -10580 0 0 {name=p39136 lab=_69015_/X }
C {devices/lab_pin.sym} 39500 -10640 0 1 {name=p39137 lab=_69016_/X }
C {sky130_stdcells/a211o_4.sym} 39420 -10640 0 0 {name=X_69016_ }
C {devices/lab_pin.sym} 39340 -10510 0 0 {name=p39138 lab=_54240_/Y }
C {devices/lab_pin.sym} 39340 -10470 0 0 {name=p39139 lab=_54226_/X }
C {devices/lab_pin.sym} 39340 -10430 0 0 {name=p39140 lab=_54241_/X }
C {devices/lab_pin.sym} 39500 -10470 0 1 {name=p39141 lab=_85478_/D }
C {sky130_stdcells/a21oi_4.sym} 39420 -10470 0 0 {name=X_54242_ }
C {devices/lab_pin.sym} 39360 -10340 0 0 {name=p39142 lab=_66224_/X }
C {devices/lab_pin.sym} 39360 -10300 0 0 {name=p39143 lab=_66227_/X }
C {devices/lab_pin.sym} 39480 -10320 0 1 {name=p39144 lab=_66228_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -10320 0 0 {name=X_66228_ }
C {devices/lab_pin.sym} 39330 -10190 0 0 {name=p39145 lab=_84998_/CLK }
C {devices/lab_pin.sym} 39330 -10170 0 0 {name=p39146 lab=_85062_/D }
C {devices/lab_pin.sym} 39510 -10190 0 1 {name=p39147 lab=_57210_/B }
C {sky130_stdcells/dfxtp_4.sym} 39420 -10180 0 0 {name=X_85062_ }
C {devices/lab_pin.sym} 39360 -10060 0 0 {name=p39148 lab=_51430_/X }
C {devices/lab_pin.sym} 39360 -10020 0 0 {name=p39149 lab=_52979_/B }
C {devices/lab_pin.sym} 39480 -10040 0 1 {name=p39150 lab=_51454_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -10040 0 0 {name=X_51454_ }
C {devices/lab_pin.sym} 39330 -9910 0 0 {name=p39151 lab=_82103_/CLK }
C {devices/lab_pin.sym} 39330 -9890 0 0 {name=p39152 lab=_82274_/D }
C {devices/lab_pin.sym} 39510 -9910 0 1 {name=p39153 lab=_82274_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -9900 0 0 {name=X_82274_ }
C {devices/lab_pin.sym} 39330 -9770 0 0 {name=p39154 lab=_84074_/CLK }
C {devices/lab_pin.sym} 39330 -9750 0 0 {name=p39155 lab=_68203_/X }
C {devices/lab_pin.sym} 39510 -9770 0 1 {name=p39156 lab=_82053_/D }
C {sky130_stdcells/dfxtp_4.sym} 39420 -9760 0 0 {name=X_84013_ }
C {devices/lab_pin.sym} 39360 -9640 0 0 {name=p39157 lab=_50432_/A }
C {devices/lab_pin.sym} 39360 -9600 0 0 {name=p39158 lab=_48380_/X }
C {devices/lab_pin.sym} 39480 -9620 0 1 {name=p39159 lab=_50405_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -9620 0 0 {name=X_50405_ }
C {devices/lab_pin.sym} 39330 -9490 0 0 {name=p39160 lab=_81224_/CLK }
C {devices/lab_pin.sym} 39330 -9470 0 0 {name=p39161 lab=_81033_/Q }
C {devices/lab_pin.sym} 39510 -9490 0 1 {name=p39162 lab=_81225_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -9480 0 0 {name=X_81225_ }
C {devices/lab_pin.sym} 39360 -9380 0 0 {name=p39163 lab=_54160_/A }
C {devices/lab_pin.sym} 39360 -9340 0 0 {name=p39164 lab=_54186_/B }
C {devices/lab_pin.sym} 39360 -9300 0 0 {name=p39165 lab=_54191_/C }
C {devices/lab_pin.sym} 39360 -9260 0 0 {name=p39166 lab=_53003_/D }
C {devices/lab_pin.sym} 39480 -9320 0 1 {name=p39167 lab=_54173_/X }
C {sky130_stdcells/and4_4.sym} 39420 -9320 0 0 {name=X_54173_ }
C {devices/lab_pin.sym} 39360 -9180 0 0 {name=p39168 lab=_57770_/A }
C {devices/lab_pin.sym} 39360 -9140 0 0 {name=p39169 lab=_66159_/B }
C {devices/lab_pin.sym} 39480 -9160 0 1 {name=p39170 lab=_66159_/X }
C {sky130_stdcells/and2_4.sym} 39420 -9160 0 0 {name=X_66159_ }
C {devices/lab_pin.sym} 39340 -9050 0 0 {name=p39171 lab=_51383_/Y }
C {devices/lab_pin.sym} 39340 -9010 0 0 {name=p39172 lab=_51366_/X }
C {devices/lab_pin.sym} 39340 -8970 0 0 {name=p39173 lab=_51384_/X }
C {devices/lab_pin.sym} 39500 -9010 0 1 {name=p39174 lab=_86020_/D }
C {sky130_stdcells/a21oi_4.sym} 39420 -9010 0 0 {name=X_51385_ }
C {devices/lab_pin.sym} 39380 -8870 0 0 {name=p39175 lab=_53097_/X }
C {devices/lab_pin.sym} 39460 -8870 0 1 {name=p39176 lab=_53133_/B }
C {sky130_stdcells/buf_2.sym} 39420 -8870 0 0 {name=X_53124_ }
C {devices/lab_pin.sym} 39340 -8770 0 0 {name=p39177 lab=_86221_/Q }
C {devices/lab_pin.sym} 39340 -8730 0 0 {name=p39178 lab=_50333_/X }
C {devices/lab_pin.sym} 39340 -8690 0 0 {name=p39179 lab=_50335_/Y }
C {devices/lab_pin.sym} 39500 -8730 0 1 {name=p39180 lab=_50336_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -8730 0 0 {name=X_50336_ }
C {devices/lab_pin.sym} 39330 -8590 0 0 {name=p39181 lab=_81179_/CLK }
C {devices/lab_pin.sym} 39330 -8570 0 0 {name=p39182 lab=_81156_/D }
C {devices/lab_pin.sym} 39510 -8590 0 1 {name=p39183 lab=_40536_/B }
C {sky130_stdcells/dfxtp_4.sym} 39420 -8580 0 0 {name=X_81156_ }
C {devices/lab_pin.sym} 39380 -8450 0 0 {name=p39184 lab=_58981_/A }
C {devices/lab_pin.sym} 39460 -8450 0 1 {name=p39185 lab=_58982_/A }
C {sky130_stdcells/buf_2.sym} 39420 -8450 0 0 {name=X_58981_ }
C {devices/lab_pin.sym} 39360 -8340 0 0 {name=p39186 lab=_80107_/A }
C {devices/lab_pin.sym} 39360 -8300 0 0 {name=p39187 lab=_80106_/Y }
C {devices/lab_pin.sym} 39480 -8320 0 1 {name=p39188 lab=_81683_/D }
C {sky130_stdcells/xnor2_4.sym} 39420 -8320 0 0 {name=X_80107_ }
C {devices/lab_pin.sym} 39340 -8210 0 0 {name=p39189 lab=_85705_/Q }
C {devices/lab_pin.sym} 39340 -8170 0 0 {name=p39190 lab=_53038_/X }
C {devices/lab_pin.sym} 39340 -8130 0 0 {name=p39191 lab=_53054_/Y }
C {devices/lab_pin.sym} 39500 -8170 0 1 {name=p39192 lab=_53055_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -8170 0 0 {name=X_53055_ }
C {devices/lab_pin.sym} 39340 -8070 0 0 {name=p39193 lab=_57781_/X }
C {devices/lab_pin.sym} 39340 -8030 0 0 {name=p39194 lab=_57930_/Y }
C {devices/lab_pin.sym} 39340 -7990 0 0 {name=p39195 lab=_57931_/Y }
C {devices/lab_pin.sym} 39340 -7950 0 0 {name=p39196 lab=_57893_/X }
C {devices/lab_pin.sym} 39340 -7910 0 0 {name=p39197 lab=_57795_/X }
C {devices/lab_pin.sym} 39500 -7990 0 1 {name=p39198 lab=_57932_/X }
C {sky130_stdcells/o32a_4.sym} 39420 -7990 0 0 {name=X_57932_ }
C {devices/lab_pin.sym} 39360 -7840 0 0 {name=p39199 lab=_64615_/A }
C {devices/lab_pin.sym} 39360 -7800 0 0 {name=p39200 lab=_69918_/B }
C {devices/lab_pin.sym} 39480 -7820 0 1 {name=p39201 lab=_69918_/Y }
C {sky130_stdcells/nor2_4.sym} 39420 -7820 0 0 {name=X_69918_ }
C {devices/lab_pin.sym} 39380 -7690 0 0 {name=p39202 lab=clkbuf_6_26_0_CLK/X }
C {devices/lab_pin.sym} 39460 -7690 0 1 {name=p39203 lab=clkbuf_7_52_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 39420 -7690 0 0 {name=Xclkbuf_7_52_0_CLK }
C {devices/lab_pin.sym} 39340 -7590 0 0 {name=p39204 lab=_50265_/Y }
C {devices/lab_pin.sym} 39340 -7550 0 0 {name=p39205 lab=_50227_/X }
C {devices/lab_pin.sym} 39340 -7510 0 0 {name=p39206 lab=_50266_/Y }
C {devices/lab_pin.sym} 39500 -7550 0 1 {name=p39207 lab=_86235_/D }
C {sky130_stdcells/a21boi_4.sym} 39420 -7550 0 0 {name=X_50267_ }
C {devices/lab_pin.sym} 39330 -7410 0 0 {name=p39208 lab=_85962_/CLK }
C {devices/lab_pin.sym} 39330 -7390 0 0 {name=p39209 lab=_85964_/D }
C {devices/lab_pin.sym} 39510 -7410 0 1 {name=p39210 lab=_85964_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -7400 0 0 {name=X_85964_ }
C {devices/lab_pin.sym} 39330 -7270 0 0 {name=p39211 lab=_81087_/CLK }
C {devices/lab_pin.sym} 39330 -7250 0 0 {name=p39212 lab=_75688_/A }
C {devices/lab_pin.sym} 39510 -7270 0 1 {name=p39213 lab=_81087_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -7260 0 0 {name=X_81087_ }
C {devices/lab_pin.sym} 39380 -7130 0 0 {name=p39214 lab=clkbuf_7_96_0_CLK/X }
C {devices/lab_pin.sym} 39460 -7130 0 1 {name=p39215 lab=clkbuf_8_192_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 39420 -7130 0 0 {name=Xclkbuf_8_192_0_CLK }
C {devices/lab_pin.sym} 39340 -7030 0 0 {name=p39216 lab=_73901_/B }
C {devices/lab_pin.sym} 39340 -6990 0 0 {name=p39217 lab=_51994_/X }
C {devices/lab_pin.sym} 39340 -6950 0 0 {name=p39218 lab=_52005_/Y }
C {devices/lab_pin.sym} 39500 -6990 0 1 {name=p39219 lab=_52006_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -6990 0 0 {name=X_52006_ }
C {devices/lab_pin.sym} 39330 -6850 0 0 {name=p39220 lab=_87221_/CLK }
C {devices/lab_pin.sym} 39330 -6830 0 0 {name=p39221 lab=_87703_/D }
C {devices/lab_pin.sym} 39510 -6850 0 1 {name=p39222 lab=_87703_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -6840 0 0 {name=X_87703_ }
C {devices/lab_pin.sym} 39340 -6730 0 0 {name=p39223 lab=_80026_/X }
C {devices/lab_pin.sym} 39340 -6690 0 0 {name=p39224 lab=_80027_/X }
C {devices/lab_pin.sym} 39340 -6650 0 0 {name=p39225 lab=_80037_/Y }
C {devices/lab_pin.sym} 39500 -6690 0 1 {name=p39226 lab=_80042_/A }
C {sky130_stdcells/a21boi_4.sym} 39420 -6690 0 0 {name=X_80038_ }
C {devices/lab_pin.sym} 39330 -6550 0 0 {name=p39227 lab=_84915_/CLK }
C {devices/lab_pin.sym} 39330 -6530 0 0 {name=p39228 lab=_84915_/D }
C {devices/lab_pin.sym} 39510 -6550 0 1 {name=p39229 lab=_84915_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -6540 0 0 {name=X_84915_ }
C {devices/lab_pin.sym} 39340 -6430 0 0 {name=p39230 lab=_57838_/X }
C {devices/lab_pin.sym} 39340 -6390 0 0 {name=p39231 lab=_86008_/Q }
C {devices/lab_pin.sym} 39340 -6350 0 0 {name=p39232 lab=_57862_/X }
C {devices/lab_pin.sym} 39500 -6390 0 1 {name=p39233 lab=_57863_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -6390 0 0 {name=X_57863_ }
C {devices/lab_pin.sym} 39340 -6280 0 0 {name=p39234 lab=_43170_/A }
C {devices/lab_pin.sym} 39340 -6240 0 0 {name=p39235 lab=_66529_/X }
C {devices/lab_pin.sym} 39340 -6200 0 0 {name=p39236 lab=_68436_/X }
C {devices/lab_pin.sym} 39340 -6160 0 0 {name=p39237 lab=_69848_/X }
C {devices/lab_pin.sym} 39500 -6220 0 1 {name=p39238 lab=_69849_/X }
C {sky130_stdcells/a211o_4.sym} 39420 -6220 0 0 {name=X_69849_ }
C {devices/lab_pin.sym} 39340 -6090 0 0 {name=p39239 lab=_50196_/Y }
C {devices/lab_pin.sym} 39340 -6050 0 0 {name=p39240 lab=_50191_/X }
C {devices/lab_pin.sym} 39340 -6010 0 0 {name=p39241 lab=_50197_/X }
C {devices/lab_pin.sym} 39500 -6050 0 1 {name=p39242 lab=_50198_/Y }
C {sky130_stdcells/a21oi_4.sym} 39420 -6050 0 0 {name=X_50198_ }
C {devices/lab_pin.sym} 39330 -5910 0 0 {name=p39243 lab=_85895_/CLK }
C {devices/lab_pin.sym} 39330 -5890 0 0 {name=p39244 lab=_85895_/D }
C {devices/lab_pin.sym} 39510 -5910 0 1 {name=p39245 lab=_66283_/B }
C {sky130_stdcells/dfxtp_4.sym} 39420 -5900 0 0 {name=X_85895_ }
C {devices/lab_pin.sym} 39360 -5790 0 0 {name=p39246 lab=_59602_/A }
C {devices/lab_pin.sym} 39360 -5750 0 0 {name=p39247 lab=_59639_/A }
C {devices/lab_pin.sym} 39360 -5710 0 0 {name=p39248 lab=_59602_/C }
C {devices/lab_pin.sym} 39480 -5750 0 1 {name=p39249 lab=_59603_/A }
C {sky130_stdcells/and3_4.sym} 39420 -5750 0 0 {name=X_59602_ }
C {devices/lab_pin.sym} 39360 -5620 0 0 {name=p39250 lab=_56814_/A }
C {devices/lab_pin.sym} 39360 -5580 0 0 {name=p39251 lab=_56798_/B }
C {devices/lab_pin.sym} 39480 -5600 0 1 {name=p39252 lab=_56814_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -5600 0 0 {name=X_56814_ }
C {devices/lab_pin.sym} 39330 -5470 0 0 {name=p39253 lab=_87995_/CLK }
C {devices/lab_pin.sym} 39330 -5450 0 0 {name=p39254 lab=_42953_/X }
C {devices/lab_pin.sym} 39510 -5470 0 1 {name=p39255 lab=_66598_/B }
C {sky130_stdcells/dfxtp_4.sym} 39420 -5460 0 0 {name=X_87634_ }
C {devices/lab_pin.sym} 39340 -5360 0 0 {name=p39256 lab=_69622_/B }
C {devices/lab_pin.sym} 39340 -5320 0 0 {name=p39257 lab=_44128_/X }
C {devices/lab_pin.sym} 39340 -5280 0 0 {name=p39258 lab=_72858_/X }
C {devices/lab_pin.sym} 39340 -5240 0 0 {name=p39259 lab=_72859_/Y }
C {devices/lab_pin.sym} 39500 -5300 0 1 {name=p39260 lab=_72860_/X }
C {sky130_stdcells/a211o_4.sym} 39420 -5300 0 0 {name=X_72860_ }
C {devices/lab_pin.sym} 39330 -5150 0 0 {name=p39261 lab=_83457_/CLK }
C {devices/lab_pin.sym} 39330 -5130 0 0 {name=p39262 lab=_58447_/X }
C {devices/lab_pin.sym} 39510 -5150 0 1 {name=p39263 lab=_84846_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -5140 0 0 {name=X_84846_ }
C {devices/lab_pin.sym} 39380 -5010 0 0 {name=p39264 lab=_58635_/A }
C {devices/lab_pin.sym} 39460 -5010 0 1 {name=p39265 lab=_72417_/A }
C {sky130_stdcells/buf_2.sym} 39420 -5010 0 0 {name=X_57794_ }
C {devices/lab_pin.sym} 39360 -4910 0 0 {name=p39266 lab=_71813_/A }
C {devices/lab_pin.sym} 39360 -4870 0 0 {name=p39267 lab=_71427_/C }
C {devices/lab_pin.sym} 39360 -4830 0 0 {name=p39268 lab=_70852_/C }
C {devices/lab_pin.sym} 39480 -4870 0 1 {name=p39269 lab=_71811_/X }
C {sky130_stdcells/and3_4.sym} 39420 -4870 0 0 {name=X_71811_ }
C {devices/lab_pin.sym} 39380 -4730 0 0 {name=p39270 lab=clkbuf_7_67_0_CLK/A }
C {devices/lab_pin.sym} 39460 -4730 0 1 {name=p39271 lab=clkbuf_7_67_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 39420 -4730 0 0 {name=Xclkbuf_7_67_0_CLK }
C {devices/lab_pin.sym} 39340 -4640 0 0 {name=p39272 lab=_59899_/B }
C {devices/lab_pin.sym} 39340 -4600 0 0 {name=p39273 lab=_59899_/D }
C {devices/lab_pin.sym} 39340 -4560 0 0 {name=p39274 lab=_43969_/A }
C {devices/lab_pin.sym} 39340 -4520 0 0 {name=p39275 lab=_43969_/B }
C {devices/lab_pin.sym} 39500 -4580 0 1 {name=p39276 lab=_59546_/A }
C {sky130_stdcells/a22oi_4.sym} 39420 -4580 0 0 {name=X_59533_ }
C {devices/lab_pin.sym} 39340 -4450 0 0 {name=p39277 lab=_56742_/Y }
C {devices/lab_pin.sym} 39340 -4410 0 0 {name=p39278 lab=_56744_/Y }
C {devices/lab_pin.sym} 39340 -4370 0 0 {name=p39279 lab=_56696_/B }
C {devices/lab_pin.sym} 39500 -4410 0 1 {name=p39280 lab=_56745_/X }
C {sky130_stdcells/a21o_4.sym} 39420 -4410 0 0 {name=X_56745_ }
C {devices/lab_pin.sym} 39330 -4270 0 0 {name=p39281 lab=_83158_/CLK }
C {devices/lab_pin.sym} 39330 -4250 0 0 {name=p39282 lab=_43132_/Y }
C {devices/lab_pin.sym} 39510 -4270 0 1 {name=p39283 lab=_87565_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -4260 0 0 {name=X_87565_ }
C {devices/lab_pin.sym} 39360 -4140 0 0 {name=p39284 lab=_53956_/X }
C {devices/lab_pin.sym} 39360 -4100 0 0 {name=p39285 lab=_52440_/B }
C {devices/lab_pin.sym} 39480 -4120 0 1 {name=p39286 lab=_53957_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -4120 0 0 {name=X_53957_ }
C {devices/lab_pin.sym} 39340 -4030 0 0 {name=p39287 lab=_41960_/X }
C {devices/lab_pin.sym} 39340 -3990 0 0 {name=p39288 lab=_41951_/X }
C {devices/lab_pin.sym} 39340 -3950 0 0 {name=p39289 lab=_40743_/X }
C {devices/lab_pin.sym} 39340 -3910 0 0 {name=p39290 lab=_74204_/A }
C {devices/lab_pin.sym} 39340 -3870 0 0 {name=p39291 lab=_41953_/X }
C {devices/lab_pin.sym} 39500 -3950 0 1 {name=p39292 lab=_41972_/A }
C {sky130_stdcells/o32ai_4.sym} 39420 -3950 0 0 {name=X_41971_ }
C {devices/lab_pin.sym} 39360 -3810 0 0 {name=p39293 lab=_72789_/X }
C {devices/lab_pin.sym} 39360 -3770 0 0 {name=p39294 lab=_72774_/X }
C {devices/lab_pin.sym} 39360 -3730 0 0 {name=p39295 lab=_72791_/C }
C {devices/lab_pin.sym} 39480 -3770 0 1 {name=p39296 lab=_72791_/Y }
C {sky130_stdcells/nand3_4.sym} 39420 -3770 0 0 {name=X_72791_ }
C {devices/lab_pin.sym} 39330 -3630 0 0 {name=p39297 lab=_86372_/CLK }
C {devices/lab_pin.sym} 39330 -3610 0 0 {name=p39298 lab=_84777_/D }
C {devices/lab_pin.sym} 39510 -3630 0 1 {name=p39299 lab=_84777_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -3620 0 0 {name=X_84777_ }
C {devices/lab_pin.sym} 39330 -3490 0 0 {name=p39300 lab=_81989_/CLK }
C {devices/lab_pin.sym} 39330 -3470 0 0 {name=p39301 lab=_81989_/D }
C {devices/lab_pin.sym} 39510 -3490 0 1 {name=p39302 lab=_77018_/A }
C {sky130_stdcells/dfxtp_4.sym} 39420 -3480 0 0 {name=X_81989_ }
C {devices/lab_pin.sym} 39380 -3350 0 0 {name=p39303 lab=_87299_/Q }
C {devices/lab_pin.sym} 39460 -3350 0 1 {name=p39304 lab=_69780_/B }
C {sky130_stdcells/inv_2.sym} 39420 -3350 0 0 {name=X_43710_ }
C {devices/lab_pin.sym} 39340 -3250 0 0 {name=p39305 lab=_51130_/B }
C {devices/lab_pin.sym} 39340 -3210 0 0 {name=p39306 lab=_74516_/X }
C {devices/lab_pin.sym} 39340 -3170 0 0 {name=p39307 lab=_74529_/Y }
C {devices/lab_pin.sym} 39500 -3210 0 1 {name=p39308 lab=_74530_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -3210 0 0 {name=X_74530_ }
C {devices/lab_pin.sym} 39330 -3070 0 0 {name=p39309 lab=_86516_/CLK }
C {devices/lab_pin.sym} 39330 -3050 0 0 {name=p39310 lab=_86516_/D }
C {devices/lab_pin.sym} 39510 -3070 0 1 {name=p39311 lab=_86516_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -3060 0 0 {name=X_86516_ }
C {devices/lab_pin.sym} 39340 -2960 0 0 {name=p39312 lab=_40921_/X }
C {devices/lab_pin.sym} 39340 -2920 0 0 {name=p39313 lab=_40904_/X }
C {devices/lab_pin.sym} 39340 -2880 0 0 {name=p39314 lab=_88310_/Q }
C {devices/lab_pin.sym} 39340 -2840 0 0 {name=p39315 lab=_40905_/X }
C {devices/lab_pin.sym} 39500 -2900 0 1 {name=p39316 lab=_88310_/D }
C {sky130_stdcells/a2bb2o_4.sym} 39420 -2900 0 0 {name=X_40922_ }
C {devices/lab_pin.sym} 39360 -2780 0 0 {name=p39317 lab=_52895_/A }
C {devices/lab_pin.sym} 39360 -2740 0 0 {name=p39318 lab=_52916_/B }
C {devices/lab_pin.sym} 39360 -2700 0 0 {name=p39319 lab=_52900_/C }
C {devices/lab_pin.sym} 39360 -2660 0 0 {name=p39320 lab=_51214_/D }
C {devices/lab_pin.sym} 39480 -2720 0 1 {name=p39321 lab=_52908_/X }
C {sky130_stdcells/and4_4.sym} 39420 -2720 0 0 {name=X_52908_ }
C {devices/lab_pin.sym} 39340 -2590 0 0 {name=p39322 lab=_52924_/B }
C {devices/lab_pin.sym} 39340 -2550 0 0 {name=p39323 lab=_71737_/X }
C {devices/lab_pin.sym} 39340 -2510 0 0 {name=p39324 lab=_71741_/Y }
C {devices/lab_pin.sym} 39500 -2550 0 1 {name=p39325 lab=_71742_/Y }
C {sky130_stdcells/o21ai_4.sym} 39420 -2550 0 0 {name=X_71742_ }
C {devices/lab_pin.sym} 39330 -2410 0 0 {name=p39326 lab=_85484_/CLK }
C {devices/lab_pin.sym} 39330 -2390 0 0 {name=p39327 lab=_70674_/X }
C {devices/lab_pin.sym} 39510 -2410 0 1 {name=p39328 lab=_47458_/A }
C {sky130_stdcells/dfxtp_4.sym} 39420 -2400 0 0 {name=X_83728_ }
C {devices/lab_pin.sym} 39380 -2270 0 0 {name=p39329 lab=_59398_/A }
C {devices/lab_pin.sym} 39460 -2270 0 1 {name=p39330 lab=_59478_/B }
C {sky130_stdcells/buf_2.sym} 39420 -2270 0 0 {name=X_59464_ }
C {devices/lab_pin.sym} 39340 -2190 0 0 {name=p39331 lab=_44686_/X }
C {devices/lab_pin.sym} 39340 -2150 0 0 {name=p39332 lab=_44687_/X }
C {devices/lab_pin.sym} 39340 -2110 0 0 {name=p39333 lab=_40625_/Y }
C {devices/lab_pin.sym} 39340 -2070 0 0 {name=p39334 lab=_44688_/Y }
C {devices/lab_pin.sym} 39340 -2030 0 0 {name=p39335 lab=_44689_/X }
C {devices/lab_pin.sym} 39500 -2110 0 1 {name=p39336 lab=_87000_/D }
C {sky130_stdcells/o32ai_4.sym} 39420 -2110 0 0 {name=X_44690_ }
C {devices/lab_pin.sym} 39360 -1960 0 0 {name=p39337 lab=_83333_/Q }
C {devices/lab_pin.sym} 39360 -1920 0 0 {name=p39338 lab=_56675_/X }
C {devices/lab_pin.sym} 39480 -1940 0 1 {name=p39339 lab=_56676_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -1940 0 0 {name=X_56676_ }
C {devices/lab_pin.sym} 39330 -1810 0 0 {name=p39340 lab=_87749_/CLK }
C {devices/lab_pin.sym} 39330 -1790 0 0 {name=p39341 lab=_87496_/D }
C {devices/lab_pin.sym} 39510 -1810 0 1 {name=p39342 lab=_87496_/Q }
C {sky130_stdcells/dfxtp_4.sym} 39420 -1800 0 0 {name=X_87496_ }
C {devices/lab_pin.sym} 39360 -1690 0 0 {name=p39343 lab=_52370_/A }
C {devices/lab_pin.sym} 39360 -1650 0 0 {name=p39344 lab=_53875_/B }
C {devices/lab_pin.sym} 39360 -1610 0 0 {name=p39345 lab=_53888_/C }
C {devices/lab_pin.sym} 39480 -1650 0 1 {name=p39346 lab=_53888_/X }
C {sky130_stdcells/and3_4.sym} 39420 -1650 0 0 {name=X_53888_ }
C {devices/lab_pin.sym} 39360 -1520 0 0 {name=p39347 lab=_58415_/A }
C {devices/lab_pin.sym} 39360 -1480 0 0 {name=p39348 lab=_58415_/B }
C {devices/lab_pin.sym} 39480 -1500 0 1 {name=p39349 lab=_58415_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -1500 0 0 {name=X_58415_ }
C {devices/lab_pin.sym} 39380 -1370 0 0 {name=p39350 lab=_87330_/Q }
C {devices/lab_pin.sym} 39460 -1370 0 1 {name=p39351 lab=_43641_/Y }
C {sky130_stdcells/inv_2.sym} 39420 -1370 0 0 {name=X_43641_ }
C {devices/lab_pin.sym} 39380 -1250 0 0 {name=p39352 lab=_55610_/A }
C {devices/lab_pin.sym} 39460 -1250 0 1 {name=p39353 lab=_55627_/X }
C {sky130_stdcells/buf_2.sym} 39420 -1250 0 0 {name=X_55627_ }
C {devices/lab_pin.sym} 39360 -1140 0 0 {name=p39354 lab=_74442_/X }
C {devices/lab_pin.sym} 39360 -1100 0 0 {name=p39355 lab=_48582_/A }
C {devices/lab_pin.sym} 39480 -1120 0 1 {name=p39356 lab=_74461_/Y }
C {sky130_stdcells/nand2_4.sym} 39420 -1120 0 0 {name=X_74461_ }
C {devices/lab_pin.sym} 39330 -990 0 0 {name=p39357 lab=_85557_/CLK }
C {devices/lab_pin.sym} 39330 -970 0 0 {name=p39358 lab=_86447_/D }
C {devices/lab_pin.sym} 39510 -990 0 1 {name=p39359 lab=_65087_/B }
C {sky130_stdcells/dfxtp_4.sym} 39420 -980 0 0 {name=X_86447_ }
C {devices/lab_pin.sym} 39340 -870 0 0 {name=p39360 lab=_40324_/X }
C {devices/lab_pin.sym} 39340 -830 0 0 {name=p39361 lab=_82864_/Q }
C {devices/lab_pin.sym} 39340 -790 0 0 {name=p39362 lab=_40852_/X }
C {devices/lab_pin.sym} 39500 -830 0 1 {name=p39363 lab=_40853_/X }
C {sky130_stdcells/o21a_4.sym} 39420 -830 0 0 {name=X_40853_ }
C {devices/lab_pin.sym} 39380 -690 0 0 {name=p39364 lab=_52783_/A }
C {devices/lab_pin.sym} 39460 -690 0 1 {name=p39365 lab=_52839_/X }
C {sky130_stdcells/buf_2.sym} 39420 -690 0 0 {name=X_52839_ }
C {devices/lab_pin.sym} 40260 -42170 0 0 {name=p39366 lab=_58468_/Y }
C {devices/lab_pin.sym} 40260 -42130 0 0 {name=p39367 lab=_71669_/X }
C {devices/lab_pin.sym} 40260 -42090 0 0 {name=p39368 lab=_71672_/Y }
C {devices/lab_pin.sym} 40420 -42130 0 1 {name=p39369 lab=_71673_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -42130 0 0 {name=X_71673_ }
C {devices/lab_pin.sym} 40300 -41990 0 0 {name=p39370 lab=_84743_/Q }
C {devices/lab_pin.sym} 40380 -41990 0 1 {name=p39371 lab=_63127_/A }
C {sky130_stdcells/inv_2.sym} 40340 -41990 0 0 {name=X_59395_ }
C {devices/lab_pin.sym} 40250 -41870 0 0 {name=p39372 lab=_85444_/CLK }
C {devices/lab_pin.sym} 40250 -41850 0 0 {name=p39373 lab=_70929_/Y }
C {devices/lab_pin.sym} 40430 -41870 0 1 {name=p39374 lab=_46898_/A }
C {sky130_stdcells/dfxtp_4.sym} 40340 -41860 0 0 {name=X_83659_ }
C {devices/lab_pin.sym} 40280 -41740 0 0 {name=p39375 lab=_76200_/A }
C {devices/lab_pin.sym} 40280 -41700 0 0 {name=p39376 lab=_76200_/B }
C {devices/lab_pin.sym} 40400 -41720 0 1 {name=p39377 lab=_76200_/X }
C {sky130_stdcells/or2_4.sym} 40340 -41720 0 0 {name=X_76200_ }
C {devices/lab_pin.sym} 40300 -41590 0 0 {name=p39378 lab=clkbuf_7_65_0_CLK/X }
C {devices/lab_pin.sym} 40380 -41590 0 1 {name=p39379 lab=clkbuf_8_130_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 40340 -41590 0 0 {name=Xclkbuf_8_130_0_CLK }
C {devices/lab_pin.sym} 40280 -41490 0 0 {name=p39380 lab=_73410_/X }
C {devices/lab_pin.sym} 40280 -41450 0 0 {name=p39381 lab=_73412_/B }
C {devices/lab_pin.sym} 40280 -41410 0 0 {name=p39382 lab=_73412_/C }
C {devices/lab_pin.sym} 40400 -41450 0 1 {name=p39383 lab=_73412_/Y }
C {sky130_stdcells/nand3_4.sym} 40340 -41450 0 0 {name=X_73412_ }
C {devices/lab_pin.sym} 40260 -41330 0 0 {name=p39384 lab=_53005_/B }
C {devices/lab_pin.sym} 40260 -41290 0 0 {name=p39385 lab=_70583_/X }
C {devices/lab_pin.sym} 40260 -41250 0 0 {name=p39386 lab=_70623_/Y }
C {devices/lab_pin.sym} 40420 -41290 0 1 {name=p39387 lab=_83738_/D }
C {sky130_stdcells/o21ai_4.sym} 40340 -41290 0 0 {name=X_70624_ }
C {devices/lab_pin.sym} 40260 -41170 0 0 {name=p39388 lab=_46348_/X }
C {devices/lab_pin.sym} 40260 -41130 0 0 {name=p39389 lab=_81208_/Q }
C {devices/lab_pin.sym} 40260 -41090 0 0 {name=p39390 lab=_46359_/X }
C {devices/lab_pin.sym} 40420 -41130 0 1 {name=p39391 lab=_46361_/A }
C {sky130_stdcells/o21ai_4.sym} 40340 -41130 0 0 {name=X_46360_ }
C {devices/lab_pin.sym} 40300 -40990 0 0 {name=p39392 lab=_84872_/Q }
C {devices/lab_pin.sym} 40380 -40990 0 1 {name=p39393 lab=_63295_/A }
C {sky130_stdcells/inv_2.sym} 40340 -40990 0 0 {name=X_58346_ }
C {devices/lab_pin.sym} 40260 -40890 0 0 {name=p39394 lab=_77172_/A }
C {devices/lab_pin.sym} 40260 -40850 0 0 {name=p39395 lab=_77177_/B }
C {devices/lab_pin.sym} 40260 -40810 0 0 {name=p39396 lab=_77171_/A }
C {devices/lab_pin.sym} 40420 -40850 0 1 {name=p39397 lab=_77181_/B }
C {sky130_stdcells/o21ai_4.sym} 40340 -40850 0 0 {name=X_77180_ }
C {devices/lab_pin.sym} 40280 -40720 0 0 {name=p39398 lab=_55524_/A }
C {devices/lab_pin.sym} 40280 -40680 0 0 {name=p39399 lab=_45485_/Y }
C {devices/lab_pin.sym} 40400 -40700 0 1 {name=p39400 lab=_55558_/Y }
C {sky130_stdcells/nor2_4.sym} 40340 -40700 0 0 {name=X_55558_ }
C {devices/lab_pin.sym} 40260 -40600 0 0 {name=p39401 lab=_40520_/X }
C {devices/lab_pin.sym} 40260 -40560 0 0 {name=p39402 lab=_43560_/X }
C {devices/lab_pin.sym} 40260 -40520 0 0 {name=p39403 lab=_87354_/Q }
C {devices/lab_pin.sym} 40260 -40480 0 0 {name=p39404 lab=_43561_/X }
C {devices/lab_pin.sym} 40420 -40540 0 1 {name=p39405 lab=_87354_/D }
C {sky130_stdcells/a2bb2o_4.sym} 40340 -40540 0 0 {name=X_43572_ }
C {devices/lab_pin.sym} 40260 -40410 0 0 {name=p39406 lab=_74390_/Y }
C {devices/lab_pin.sym} 40260 -40370 0 0 {name=p39407 lab=_72107_/X }
C {devices/lab_pin.sym} 40260 -40330 0 0 {name=p39408 lab=_74391_/Y }
C {devices/lab_pin.sym} 40420 -40370 0 1 {name=p39409 lab=_74392_/Y }
C {sky130_stdcells/a21boi_4.sym} 40340 -40370 0 0 {name=X_74392_ }
C {devices/lab_pin.sym} 40250 -40230 0 0 {name=p39410 lab=_83666_/CLK }
C {devices/lab_pin.sym} 40250 -40210 0 0 {name=p39411 lab=_49490_/Y }
C {devices/lab_pin.sym} 40430 -40230 0 1 {name=p39412 lab=_86378_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -40220 0 0 {name=X_86378_ }
C {devices/lab_pin.sym} 40300 -40090 0 0 {name=p39413 lab=_40784_/A }
C {devices/lab_pin.sym} 40380 -40090 0 1 {name=p39414 lab=_40847_/B }
C {sky130_stdcells/buf_2.sym} 40340 -40090 0 0 {name=X_40784_ }
C {devices/lab_pin.sym} 40300 -39970 0 0 {name=p39415 lab=_80671_/Q }
C {devices/lab_pin.sym} 40380 -39970 0 1 {name=p39416 lab=_45311_/X }
C {sky130_stdcells/buf_2.sym} 40340 -39970 0 0 {name=X_45311_ }
C {devices/lab_pin.sym} 40280 -39860 0 0 {name=p39417 lab=_81727_/D }
C {devices/lab_pin.sym} 40280 -39820 0 0 {name=p39418 lab=_76139_/B }
C {devices/lab_pin.sym} 40400 -39840 0 1 {name=p39419 lab=_76135_/A }
C {sky130_stdcells/xnor2_4.sym} 40340 -39840 0 0 {name=X_76131_ }
C {devices/lab_pin.sym} 40250 -39710 0 0 {name=p39420 lab=_88121_/CLK }
C {devices/lab_pin.sym} 40250 -39690 0 0 {name=p39421 lab=_88117_/D }
C {devices/lab_pin.sym} 40430 -39710 0 1 {name=p39422 lab=_67290_/B }
C {sky130_stdcells/dfxtp_4.sym} 40340 -39700 0 0 {name=X_88117_ }
C {devices/lab_pin.sym} 40260 -39610 0 0 {name=p39423 lab=_42521_/X }
C {devices/lab_pin.sym} 40260 -39570 0 0 {name=p39424 lab=_42522_/X }
C {devices/lab_pin.sym} 40260 -39530 0 0 {name=p39425 lab=_40724_/X }
C {devices/lab_pin.sym} 40260 -39490 0 0 {name=p39426 lab=_68955_/A }
C {devices/lab_pin.sym} 40260 -39450 0 0 {name=p39427 lab=_42506_/X }
C {devices/lab_pin.sym} 40420 -39530 0 1 {name=p39428 lab=_42524_/A }
C {sky130_stdcells/o32ai_4.sym} 40340 -39530 0 0 {name=X_42523_ }
C {devices/lab_pin.sym} 40280 -39400 0 0 {name=p39429 lab=_54509_/A }
C {devices/lab_pin.sym} 40280 -39360 0 0 {name=p39430 lab=_54503_/B }
C {devices/lab_pin.sym} 40280 -39320 0 0 {name=p39431 lab=_54509_/C }
C {devices/lab_pin.sym} 40280 -39280 0 0 {name=p39432 lab=_54509_/D }
C {devices/lab_pin.sym} 40400 -39340 0 1 {name=p39433 lab=_54509_/X }
C {sky130_stdcells/and4_4.sym} 40340 -39340 0 0 {name=X_54509_ }
C {devices/lab_pin.sym} 40250 -39190 0 0 {name=p39434 lab=_83550_/CLK }
C {devices/lab_pin.sym} 40250 -39170 0 0 {name=p39435 lab=_55045_/Y }
C {devices/lab_pin.sym} 40430 -39190 0 1 {name=p39436 lab=_85329_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -39180 0 0 {name=X_85329_ }
C {devices/lab_pin.sym} 40300 -39050 0 0 {name=p39437 lab=_45930_/X }
C {devices/lab_pin.sym} 40380 -39050 0 1 {name=p39438 lab=_73343_/X }
C {sky130_stdcells/buf_2.sym} 40340 -39050 0 0 {name=X_73343_ }
C {devices/lab_pin.sym} 40300 -38930 0 0 {name=p39439 lab=_72052_/A }
C {devices/lab_pin.sym} 40380 -38930 0 1 {name=p39440 lab=_46719_/A }
C {sky130_stdcells/buf_2.sym} 40340 -38930 0 0 {name=X_46291_ }
C {devices/lab_pin.sym} 40280 -38840 0 0 {name=p39441 lab=_71859_/A }
C {devices/lab_pin.sym} 40280 -38800 0 0 {name=p39442 lab=_70549_/X }
C {devices/lab_pin.sym} 40280 -38760 0 0 {name=p39443 lab=_70568_/C }
C {devices/lab_pin.sym} 40280 -38720 0 0 {name=p39444 lab=_70550_/D }
C {devices/lab_pin.sym} 40400 -38780 0 1 {name=p39445 lab=_70555_/Y }
C {sky130_stdcells/nor4_4.sym} 40340 -38780 0 0 {name=X_70555_ }
C {devices/lab_pin.sym} 40280 -38640 0 0 {name=p39446 lab=_58277_/A }
C {devices/lab_pin.sym} 40280 -38600 0 0 {name=p39447 lab=_58280_/B }
C {devices/lab_pin.sym} 40400 -38620 0 1 {name=p39448 lab=_58277_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -38620 0 0 {name=X_58277_ }
C {devices/lab_pin.sym} 40280 -38500 0 0 {name=p39449 lab=_55489_/A }
C {devices/lab_pin.sym} 40280 -38460 0 0 {name=p39450 lab=_55489_/B }
C {devices/lab_pin.sym} 40400 -38480 0 1 {name=p39451 lab=_55489_/Y }
C {sky130_stdcells/nor2_4.sym} 40340 -38480 0 0 {name=X_55489_ }
C {devices/lab_pin.sym} 40300 -38350 0 0 {name=p39452 lab=_83542_/Q }
C {devices/lab_pin.sym} 40380 -38350 0 1 {name=p39453 lab=_53552_/B }
C {sky130_stdcells/inv_2.sym} 40340 -38350 0 0 {name=X_48030_ }
C {devices/lab_pin.sym} 40260 -38250 0 0 {name=p39454 lab=_45239_/Y }
C {devices/lab_pin.sym} 40260 -38210 0 0 {name=p39455 lab=_45241_/Y }
C {devices/lab_pin.sym} 40260 -38170 0 0 {name=p39456 lab=_45212_/X }
C {devices/lab_pin.sym} 40420 -38210 0 1 {name=p39457 lab=_45242_/X }
C {sky130_stdcells/a21o_4.sym} 40340 -38210 0 0 {name=X_45242_ }
C {devices/lab_pin.sym} 40300 -38070 0 0 {name=p39458 lab=_57227_/Y }
C {devices/lab_pin.sym} 40380 -38070 0 1 {name=p39459 lab=_85059_/D }
C {sky130_stdcells/inv_2.sym} 40340 -38070 0 0 {name=X_57228_ }
C {devices/lab_pin.sym} 40280 -37960 0 0 {name=p39460 lab=_81718_/D }
C {devices/lab_pin.sym} 40280 -37920 0 0 {name=p39461 lab=_76062_/B }
C {devices/lab_pin.sym} 40400 -37940 0 1 {name=p39462 lab=_76068_/A }
C {sky130_stdcells/xor2_4.sym} 40340 -37940 0 0 {name=X_76062_ }
C {devices/lab_pin.sym} 40250 -37810 0 0 {name=p39463 lab=_88087_/CLK }
C {devices/lab_pin.sym} 40250 -37790 0 0 {name=p39464 lab=_88048_/D }
C {devices/lab_pin.sym} 40430 -37810 0 1 {name=p39465 lab=_88048_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -37800 0 0 {name=X_88048_ }
C {devices/lab_pin.sym} 40260 -37710 0 0 {name=p39466 lab=_51238_/B }
C {devices/lab_pin.sym} 40260 -37670 0 0 {name=p39467 lab=_42430_/X }
C {devices/lab_pin.sym} 40260 -37630 0 0 {name=p39468 lab=_40560_/X }
C {devices/lab_pin.sym} 40260 -37590 0 0 {name=p39469 lab=_68361_/A }
C {devices/lab_pin.sym} 40260 -37550 0 0 {name=p39470 lab=_42453_/X }
C {devices/lab_pin.sym} 40420 -37630 0 1 {name=p39471 lab=_42454_/Y }
C {sky130_stdcells/o32ai_4.sym} 40340 -37630 0 0 {name=X_42454_ }
C {devices/lab_pin.sym} 40260 -37500 0 0 {name=p39472 lab=_69835_/B }
C {devices/lab_pin.sym} 40260 -37460 0 0 {name=p39473 lab=_73224_/X }
C {devices/lab_pin.sym} 40260 -37420 0 0 {name=p39474 lab=_73194_/X }
C {devices/lab_pin.sym} 40260 -37380 0 0 {name=p39475 lab=_73273_/Y }
C {devices/lab_pin.sym} 40420 -37440 0 1 {name=p39476 lab=_73274_/X }
C {sky130_stdcells/a211o_4.sym} 40340 -37440 0 0 {name=X_73274_ }
C {devices/lab_pin.sym} 40280 -37310 0 0 {name=p39477 lab=_71337_/A }
C {devices/lab_pin.sym} 40280 -37270 0 0 {name=p39478 lab=_70483_/B }
C {devices/lab_pin.sym} 40280 -37230 0 0 {name=p39479 lab=_71777_/B }
C {devices/lab_pin.sym} 40400 -37270 0 1 {name=p39480 lab=_70486_/X }
C {sky130_stdcells/and3_4.sym} 40340 -37270 0 0 {name=X_70486_ }
C {devices/lab_pin.sym} 40300 -37130 0 0 {name=p39481 lab=clkbuf_7_72_0_CLK/X }
C {devices/lab_pin.sym} 40380 -37130 0 1 {name=p39482 lab=clkbuf_9_291_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 40340 -37130 0 0 {name=Xclkbuf_8_145_0_CLK }
C {devices/lab_pin.sym} 40280 -37020 0 0 {name=p39483 lab=_75010_/Y }
C {devices/lab_pin.sym} 40280 -36980 0 0 {name=p39484 lab=_75013_/B }
C {devices/lab_pin.sym} 40400 -37000 0 1 {name=p39485 lab=_75014_/B }
C {sky130_stdcells/xor2_4.sym} 40340 -37000 0 0 {name=X_75013_ }
C {devices/lab_pin.sym} 40300 -36870 0 0 {name=p39486 lab=_41405_/A }
C {devices/lab_pin.sym} 40380 -36870 0 1 {name=p39487 lab=_41405_/Y }
C {sky130_stdcells/inv_2.sym} 40340 -36870 0 0 {name=X_41405_ }
C {devices/lab_pin.sym} 40300 -36750 0 0 {name=p39488 lab=clkbuf_9_70_0_CLK/X }
C {devices/lab_pin.sym} 40380 -36750 0 1 {name=p39489 lab=_81620_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 40340 -36750 0 0 {name=Xclkbuf_10_140_0_CLK }
C {devices/lab_pin.sym} 40300 -36630 0 0 {name=p39490 lab=_59081_/A }
C {devices/lab_pin.sym} 40380 -36630 0 1 {name=p39491 lab=_72225_/X }
C {sky130_stdcells/buf_2.sym} 40340 -36630 0 0 {name=X_72225_ }
C {devices/lab_pin.sym} 40260 -36530 0 0 {name=p39492 lab=_45166_/X }
C {devices/lab_pin.sym} 40260 -36490 0 0 {name=p39493 lab=_45170_/Y }
C {devices/lab_pin.sym} 40260 -36450 0 0 {name=p39494 lab=_45172_/Y }
C {devices/lab_pin.sym} 40420 -36490 0 1 {name=p39495 lab=_45173_/Y }
C {sky130_stdcells/a21oi_4.sym} 40340 -36490 0 0 {name=X_45173_ }
C {devices/lab_pin.sym} 40260 -36370 0 0 {name=p39496 lab=_57427_/A }
C {devices/lab_pin.sym} 40260 -36330 0 0 {name=p39497 lab=_56750_/Y }
C {devices/lab_pin.sym} 40260 -36290 0 0 {name=p39498 lab=_57096_/Y }
C {devices/lab_pin.sym} 40420 -36330 0 1 {name=p39499 lab=_57159_/Y }
C {sky130_stdcells/a21oi_4.sym} 40340 -36330 0 0 {name=X_57159_ }
C {devices/lab_pin.sym} 40260 -36230 0 0 {name=p39500 lab=_42378_/X }
C {devices/lab_pin.sym} 40260 -36190 0 0 {name=p39501 lab=_42369_/X }
C {devices/lab_pin.sym} 40260 -36150 0 0 {name=p39502 lab=_40371_/X }
C {devices/lab_pin.sym} 40260 -36110 0 0 {name=p39503 lab=_87889_/Q }
C {devices/lab_pin.sym} 40260 -36070 0 0 {name=p39504 lab=_42370_/X }
C {devices/lab_pin.sym} 40420 -36150 0 1 {name=p39505 lab=_42386_/A }
C {sky130_stdcells/o32ai_4.sym} 40340 -36150 0 0 {name=X_42385_ }
C {devices/lab_pin.sym} 40300 -35990 0 0 {name=p39506 lab=clkbuf_9_385_0_CLK/X }
C {devices/lab_pin.sym} 40380 -35990 0 1 {name=p39507 lab=_82124_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 40340 -35990 0 0 {name=Xclkbuf_10_770_0_CLK }
C {devices/lab_pin.sym} 40300 -35870 0 0 {name=p39508 lab=_44124_/A }
C {devices/lab_pin.sym} 40380 -35870 0 1 {name=p39509 lab=_72814_/A }
C {sky130_stdcells/buf_2.sym} 40340 -35870 0 0 {name=X_44124_ }
C {devices/lab_pin.sym} 40260 -35770 0 0 {name=p39510 lab=_79812_/Y }
C {devices/lab_pin.sym} 40260 -35730 0 0 {name=p39511 lab=_79829_/A }
C {devices/lab_pin.sym} 40260 -35690 0 0 {name=p39512 lab=_79820_/Y }
C {devices/lab_pin.sym} 40420 -35730 0 1 {name=p39513 lab=_79822_/B }
C {sky130_stdcells/a21oi_4.sym} 40340 -35730 0 0 {name=X_79821_ }
C {devices/lab_pin.sym} 40300 -35590 0 0 {name=p39514 lab=_40686_/A }
C {devices/lab_pin.sym} 40380 -35590 0 1 {name=p39515 lab=_41336_/X }
C {sky130_stdcells/buf_2.sym} 40340 -35590 0 0 {name=X_41336_ }
C {devices/lab_pin.sym} 40300 -35470 0 0 {name=p39516 lab=_60170_/A }
C {devices/lab_pin.sym} 40380 -35470 0 1 {name=p39517 lab=_60344_/A }
C {sky130_stdcells/buf_2.sym} 40340 -35470 0 0 {name=X_60170_ }
C {devices/lab_pin.sym} 40300 -35350 0 0 {name=p39518 lab=_58847_/A }
C {devices/lab_pin.sym} 40380 -35350 0 1 {name=p39519 lab=_72156_/X }
C {sky130_stdcells/buf_2.sym} 40340 -35350 0 0 {name=X_72156_ }
C {devices/lab_pin.sym} 40280 -35240 0 0 {name=p39520 lab=_49981_/A }
C {devices/lab_pin.sym} 40280 -35200 0 0 {name=p39521 lab=_53193_/B }
C {devices/lab_pin.sym} 40400 -35220 0 1 {name=p39522 lab=_49981_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -35220 0 0 {name=X_49981_ }
C {devices/lab_pin.sym} 40300 -35090 0 0 {name=p39523 lab=clkbuf_8_130_0_CLK/X }
C {devices/lab_pin.sym} 40380 -35090 0 1 {name=p39524 lab=clkbuf_9_261_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 40340 -35090 0 0 {name=Xclkbuf_9_261_0_CLK }
C {devices/lab_pin.sym} 40260 -34990 0 0 {name=p39525 lab=_50153_/B }
C {devices/lab_pin.sym} 40260 -34950 0 0 {name=p39526 lab=_71095_/X }
C {devices/lab_pin.sym} 40260 -34910 0 0 {name=p39527 lab=_71106_/Y }
C {devices/lab_pin.sym} 40420 -34950 0 1 {name=p39528 lab=_71107_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -34950 0 0 {name=X_71107_ }
C {devices/lab_pin.sym} 40280 -34820 0 0 {name=p39529 lab=_48901_/A }
C {devices/lab_pin.sym} 40280 -34780 0 0 {name=p39530 lab=_52287_/B }
C {devices/lab_pin.sym} 40400 -34800 0 1 {name=p39531 lab=_48932_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -34800 0 0 {name=X_48932_ }
C {devices/lab_pin.sym} 40300 -34670 0 0 {name=p39532 lab=_86755_/Q }
C {devices/lab_pin.sym} 40380 -34670 0 1 {name=p39533 lab=_55125_/A }
C {sky130_stdcells/buf_2.sym} 40340 -34670 0 0 {name=X_44055_ }
C {devices/lab_pin.sym} 40280 -34560 0 0 {name=p39534 lab=_84220_/Q }
C {devices/lab_pin.sym} 40280 -34520 0 0 {name=p39535 lab=_83268_/Q }
C {devices/lab_pin.sym} 40400 -34540 0 1 {name=p39536 lab=_79752_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -34540 0 0 {name=X_79752_ }
C {devices/lab_pin.sym} 40260 -34430 0 0 {name=p39537 lab=_41255_/X }
C {devices/lab_pin.sym} 40260 -34390 0 0 {name=p39538 lab=_40741_/A }
C {devices/lab_pin.sym} 40260 -34350 0 0 {name=p39539 lab=_41266_/X }
C {devices/lab_pin.sym} 40420 -34390 0 1 {name=p39540 lab=_41267_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -34390 0 0 {name=X_41267_ }
C {devices/lab_pin.sym} 40260 -34270 0 0 {name=p39541 lab=_83287_/Q }
C {devices/lab_pin.sym} 40260 -34230 0 0 {name=p39542 lab=_72051_/X }
C {devices/lab_pin.sym} 40260 -34190 0 0 {name=p39543 lab=_72086_/Y }
C {devices/lab_pin.sym} 40420 -34230 0 1 {name=p39544 lab=_72087_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -34230 0 0 {name=X_72087_ }
C {devices/lab_pin.sym} 40300 -34090 0 0 {name=p39545 lab=_76895_/Y }
C {devices/lab_pin.sym} 40380 -34090 0 1 {name=p39546 lab=_81373_/D }
C {sky130_stdcells/inv_2.sym} 40340 -34090 0 0 {name=X_76964_ }
C {devices/lab_pin.sym} 40300 -33970 0 0 {name=p39547 lab=clkbuf_9_77_0_CLK/X }
C {devices/lab_pin.sym} 40380 -33970 0 1 {name=p39548 lab=_81660_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 40340 -33970 0 0 {name=Xclkbuf_10_155_0_CLK }
C {devices/lab_pin.sym} 40260 -33890 0 0 {name=p39549 lab=_43005_/X }
C {devices/lab_pin.sym} 40260 -33850 0 0 {name=p39550 lab=_42477_/A }
C {devices/lab_pin.sym} 40260 -33810 0 0 {name=p39551 lab=_40532_/X }
C {devices/lab_pin.sym} 40260 -33770 0 0 {name=p39552 lab=_87607_/Q }
C {devices/lab_pin.sym} 40260 -33730 0 0 {name=p39553 lab=_42463_/A }
C {devices/lab_pin.sym} 40420 -33810 0 1 {name=p39554 lab=_43006_/Y }
C {sky130_stdcells/o32ai_4.sym} 40340 -33810 0 0 {name=X_43006_ }
C {devices/lab_pin.sym} 40260 -33670 0 0 {name=p39555 lab=_78685_/A }
C {devices/lab_pin.sym} 40260 -33630 0 0 {name=p39556 lab=_78702_/Y }
C {devices/lab_pin.sym} 40260 -33590 0 0 {name=p39557 lab=_78669_/B }
C {devices/lab_pin.sym} 40420 -33630 0 1 {name=p39558 lab=_78703_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -33630 0 0 {name=X_78703_ }
C {devices/lab_pin.sym} 40300 -33490 0 0 {name=p39559 lab=_71005_/A }
C {devices/lab_pin.sym} 40380 -33490 0 1 {name=p39560 lab=_71183_/A }
C {sky130_stdcells/buf_2.sym} 40340 -33490 0 0 {name=X_71038_ }
C {devices/lab_pin.sym} 40280 -33380 0 0 {name=p39561 lab=_84513_/Q }
C {devices/lab_pin.sym} 40280 -33340 0 0 {name=p39562 lab=_75915_/B }
C {devices/lab_pin.sym} 40400 -33360 0 1 {name=p39563 lab=_75915_/X }
C {sky130_stdcells/xor2_4.sym} 40340 -33360 0 0 {name=X_75915_ }
C {devices/lab_pin.sym} 40280 -33240 0 0 {name=p39564 lab=_50056_/A }
C {devices/lab_pin.sym} 40280 -33200 0 0 {name=p39565 lab=_48684_/B }
C {devices/lab_pin.sym} 40400 -33220 0 1 {name=p39566 lab=_48863_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -33220 0 0 {name=X_48863_ }
C {devices/lab_pin.sym} 40280 -33100 0 0 {name=p39567 lab=_79660_/X }
C {devices/lab_pin.sym} 40280 -33060 0 0 {name=p39568 lab=_79673_/X }
C {devices/lab_pin.sym} 40400 -33080 0 1 {name=p39569 lab=_79683_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -33080 0 0 {name=X_79683_ }
C {devices/lab_pin.sym} 40260 -32970 0 0 {name=p39570 lab=_41184_/X }
C {devices/lab_pin.sym} 40260 -32930 0 0 {name=p39571 lab=_40676_/A }
C {devices/lab_pin.sym} 40260 -32890 0 0 {name=p39572 lab=_41197_/X }
C {devices/lab_pin.sym} 40420 -32930 0 1 {name=p39573 lab=_41198_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -32930 0 0 {name=X_41198_ }
C {devices/lab_pin.sym} 40300 -32790 0 0 {name=p39574 lab=clkbuf_9_392_0_CLK/X }
C {devices/lab_pin.sym} 40380 -32790 0 1 {name=p39575 lab=_82529_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 40340 -32790 0 0 {name=Xclkbuf_10_785_0_CLK }
C {devices/lab_pin.sym} 40280 -32680 0 0 {name=p39576 lab=_81677_/Q }
C {devices/lab_pin.sym} 40280 -32640 0 0 {name=p39577 lab=_76895_/B }
C {devices/lab_pin.sym} 40400 -32660 0 1 {name=p39578 lab=_76895_/Y }
C {sky130_stdcells/xnor2_4.sym} 40340 -32660 0 0 {name=X_76895_ }
C {devices/lab_pin.sym} 40300 -32530 0 0 {name=p39579 lab=_47814_/A }
C {devices/lab_pin.sym} 40380 -32530 0 1 {name=p39580 lab=_53257_/D }
C {sky130_stdcells/buf_2.sym} 40340 -32530 0 0 {name=X_47814_ }
C {devices/lab_pin.sym} 40260 -32430 0 0 {name=p39581 lab=_78614_/Y }
C {devices/lab_pin.sym} 40260 -32390 0 0 {name=p39582 lab=_78616_/A }
C {devices/lab_pin.sym} 40260 -32350 0 0 {name=p39583 lab=_78613_/A }
C {devices/lab_pin.sym} 40420 -32390 0 1 {name=p39584 lab=_78634_/X }
C {sky130_stdcells/o21a_4.sym} 40340 -32390 0 0 {name=X_78634_ }
C {devices/lab_pin.sym} 40280 -32280 0 0 {name=p39585 lab=_61844_/X }
C {devices/lab_pin.sym} 40280 -32240 0 0 {name=p39586 lab=_63860_/B }
C {devices/lab_pin.sym} 40280 -32200 0 0 {name=p39587 lab=_63860_/C }
C {devices/lab_pin.sym} 40280 -32160 0 0 {name=p39588 lab=_63860_/D }
C {devices/lab_pin.sym} 40400 -32220 0 1 {name=p39589 lab=_63860_/Y }
C {sky130_stdcells/nand4_4.sym} 40340 -32220 0 0 {name=X_63860_ }
C {devices/lab_pin.sym} 40300 -32070 0 0 {name=p39590 lab=_75846_/A }
C {devices/lab_pin.sym} 40380 -32070 0 1 {name=p39591 lab=_80895_/D }
C {sky130_stdcells/inv_2.sym} 40340 -32070 0 0 {name=X_75846_ }
C {devices/lab_pin.sym} 40260 -31970 0 0 {name=p39592 lab=_86481_/Q }
C {devices/lab_pin.sym} 40260 -31930 0 0 {name=p39593 lab=_48781_/X }
C {devices/lab_pin.sym} 40260 -31890 0 0 {name=p39594 lab=_48793_/Y }
C {devices/lab_pin.sym} 40420 -31930 0 1 {name=p39595 lab=_48794_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -31930 0 0 {name=X_48794_ }
C {devices/lab_pin.sym} 40300 -31790 0 0 {name=p39596 lab=clkbuf_9_277_0_CLK/A }
C {devices/lab_pin.sym} 40380 -31790 0 1 {name=p39597 lab=clkbuf_9_276_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 40340 -31790 0 0 {name=Xclkbuf_9_276_0_CLK }
C {devices/lab_pin.sym} 40300 -31670 0 0 {name=p39598 lab=_60273_/A }
C {devices/lab_pin.sym} 40380 -31670 0 1 {name=p39599 lab=_62812_/B }
C {sky130_stdcells/buf_2.sym} 40340 -31670 0 0 {name=X_62811_ }
C {devices/lab_pin.sym} 40300 -31550 0 0 {name=p39600 lab=_47745_/A }
C {devices/lab_pin.sym} 40380 -31550 0 1 {name=p39601 lab=_47745_/X }
C {sky130_stdcells/buf_2.sym} 40340 -31550 0 0 {name=X_47745_ }
C {devices/lab_pin.sym} 40300 -31430 0 0 {name=p39602 lab=_82804_/Q }
C {devices/lab_pin.sym} 40380 -31430 0 1 {name=p39603 lab=_78569_/A }
C {sky130_stdcells/inv_2.sym} 40340 -31430 0 0 {name=X_78565_ }
C {devices/lab_pin.sym} 40260 -31330 0 0 {name=p39604 lab=_56203_/C }
C {devices/lab_pin.sym} 40260 -31290 0 0 {name=p39605 lab=_44911_/X }
C {devices/lab_pin.sym} 40260 -31250 0 0 {name=p39606 lab=_44956_/X }
C {devices/lab_pin.sym} 40420 -31290 0 1 {name=p39607 lab=_44957_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -31290 0 0 {name=X_44957_ }
C {devices/lab_pin.sym} 40280 -31160 0 0 {name=p39608 lab=_81016_/Q }
C {devices/lab_pin.sym} 40280 -31120 0 0 {name=p39609 lab=_80888_/D }
C {devices/lab_pin.sym} 40400 -31140 0 1 {name=p39610 lab=_80984_/D }
C {sky130_stdcells/xor2_4.sym} 40340 -31140 0 0 {name=X_75777_ }
C {devices/lab_pin.sym} 40280 -31040 0 0 {name=p39611 lab=_61364_/B }
C {devices/lab_pin.sym} 40280 -31000 0 0 {name=p39612 lab=_63790_/X }
C {devices/lab_pin.sym} 40280 -30960 0 0 {name=p39613 lab=_63757_/C }
C {devices/lab_pin.sym} 40280 -30920 0 0 {name=p39614 lab=_63776_/X }
C {devices/lab_pin.sym} 40400 -30980 0 1 {name=p39615 lab=_63791_/Y }
C {sky130_stdcells/nand4_4.sym} 40340 -30980 0 0 {name=X_63791_ }
C {devices/lab_pin.sym} 40280 -30840 0 0 {name=p39616 lab=_73183_/A }
C {devices/lab_pin.sym} 40280 -30800 0 0 {name=p39617 lab=_65551_/B }
C {devices/lab_pin.sym} 40400 -30820 0 1 {name=p39618 lab=_72989_/X }
C {sky130_stdcells/and2_4.sym} 40340 -30820 0 0 {name=X_72989_ }
C {devices/lab_pin.sym} 40300 -30690 0 0 {name=p39619 lab=_64967_/X }
C {devices/lab_pin.sym} 40380 -30690 0 1 {name=p39620 lab=_65559_/A }
C {sky130_stdcells/buf_2.sym} 40340 -30690 0 0 {name=X_65530_ }
C {devices/lab_pin.sym} 40260 -30590 0 0 {name=p39621 lab=_77505_/Y }
C {devices/lab_pin.sym} 40260 -30550 0 0 {name=p39622 lab=_77509_/B }
C {devices/lab_pin.sym} 40260 -30510 0 0 {name=p39623 lab=_77508_/A }
C {devices/lab_pin.sym} 40420 -30550 0 1 {name=p39624 lab=_77516_/X }
C {sky130_stdcells/o21a_4.sym} 40340 -30550 0 0 {name=X_77516_ }
C {devices/lab_pin.sym} 40300 -30410 0 0 {name=p39625 lab=_43869_/X }
C {devices/lab_pin.sym} 40380 -30410 0 1 {name=p39626 lab=_43908_/X }
C {sky130_stdcells/buf_2.sym} 40340 -30410 0 0 {name=X_43908_ }
C {devices/lab_pin.sym} 40300 -30290 0 0 {name=p39627 lab=_62681_/X }
C {devices/lab_pin.sym} 40380 -30290 0 1 {name=p39628 lab=_62742_/X }
C {sky130_stdcells/buf_2.sym} 40340 -30290 0 0 {name=X_62742_ }
C {devices/lab_pin.sym} 40300 -30170 0 0 {name=p39629 lab=_70637_/A }
C {devices/lab_pin.sym} 40380 -30170 0 1 {name=p39630 lab=_74796_/B }
C {sky130_stdcells/buf_2.sym} 40340 -30170 0 0 {name=X_74728_ }
C {devices/lab_pin.sym} 40280 -30080 0 0 {name=p39631 lab=_47692_/A }
C {devices/lab_pin.sym} 40280 -30040 0 0 {name=p39632 lab=_47692_/B }
C {devices/lab_pin.sym} 40280 -30000 0 0 {name=p39633 lab=_47692_/C }
C {devices/lab_pin.sym} 40280 -29960 0 0 {name=p39634 lab=_53181_/D }
C {devices/lab_pin.sym} 40400 -30020 0 1 {name=p39635 lab=_47676_/X }
C {sky130_stdcells/and4_4.sym} 40340 -30020 0 0 {name=X_47676_ }
C {devices/lab_pin.sym} 40280 -29880 0 0 {name=p39636 lab=_78474_/A }
C {devices/lab_pin.sym} 40280 -29840 0 0 {name=p39637 lab=_78473_/X }
C {devices/lab_pin.sym} 40400 -29860 0 1 {name=p39638 lab=_78496_/X }
C {sky130_stdcells/xor2_4.sym} 40340 -29860 0 0 {name=X_78496_ }
C {devices/lab_pin.sym} 40300 -29730 0 0 {name=p39639 lab=_44887_/X }
C {devices/lab_pin.sym} 40380 -29730 0 1 {name=p39640 lab=_44889_/A }
C {sky130_stdcells/buf_2.sym} 40340 -29730 0 0 {name=X_44888_ }
C {devices/lab_pin.sym} 40300 -29610 0 0 {name=p39641 lab=_49415_/A }
C {devices/lab_pin.sym} 40380 -29610 0 1 {name=p39642 lab=_49415_/X }
C {sky130_stdcells/buf_2.sym} 40340 -29610 0 0 {name=X_49415_ }
C {devices/lab_pin.sym} 40260 -29510 0 0 {name=p39643 lab=_58577_/A }
C {devices/lab_pin.sym} 40260 -29470 0 0 {name=p39644 lab=_46622_/X }
C {devices/lab_pin.sym} 40260 -29430 0 0 {name=p39645 lab=_46626_/Y }
C {devices/lab_pin.sym} 40420 -29470 0 1 {name=p39646 lab=_46627_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -29470 0 0 {name=X_46627_ }
C {devices/lab_pin.sym} 40280 -29340 0 0 {name=p39647 lab=_65458_/X }
C {devices/lab_pin.sym} 40280 -29300 0 0 {name=p39648 lab=_65461_/B }
C {devices/lab_pin.sym} 40400 -29320 0 1 {name=p39649 lab=_65461_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -29320 0 0 {name=X_65461_ }
C {devices/lab_pin.sym} 40280 -29210 0 0 {name=p39650 lab=_77447_/A }
C {devices/lab_pin.sym} 40280 -29170 0 0 {name=p39651 lab=_77444_/Y }
C {devices/lab_pin.sym} 40280 -29130 0 0 {name=p39652 lab=_77446_/Y }
C {devices/lab_pin.sym} 40400 -29170 0 1 {name=p39653 lab=_77447_/X }
C {sky130_stdcells/or3_4.sym} 40340 -29170 0 0 {name=X_77447_ }
C {devices/lab_pin.sym} 40260 -29070 0 0 {name=p39654 lab=_43810_/X }
C {devices/lab_pin.sym} 40260 -29030 0 0 {name=p39655 lab=_43824_/X }
C {devices/lab_pin.sym} 40260 -28990 0 0 {name=p39656 lab=_41174_/X }
C {devices/lab_pin.sym} 40260 -28950 0 0 {name=p39657 lab=_68681_/B }
C {devices/lab_pin.sym} 40260 -28910 0 0 {name=p39658 lab=_43811_/X }
C {devices/lab_pin.sym} 40420 -28990 0 1 {name=p39659 lab=_43840_/A }
C {sky130_stdcells/o32ai_4.sym} 40340 -28990 0 0 {name=X_43839_ }
C {devices/lab_pin.sym} 40280 -28850 0 0 {name=p39660 lab=_62673_/A }
C {devices/lab_pin.sym} 40280 -28810 0 0 {name=p39661 lab=_62673_/B }
C {devices/lab_pin.sym} 40280 -28770 0 0 {name=p39662 lab=_84392_/Q }
C {devices/lab_pin.sym} 40400 -28810 0 1 {name=p39663 lab=_62673_/Y }
C {sky130_stdcells/nor3_4.sym} 40340 -28810 0 0 {name=X_62673_ }
C {devices/lab_pin.sym} 40300 -28670 0 0 {name=p39664 lab=_74659_/A }
C {devices/lab_pin.sym} 40380 -28670 0 1 {name=p39665 lab=_74659_/Y }
C {sky130_stdcells/inv_2.sym} 40340 -28670 0 0 {name=X_74659_ }
C {devices/lab_pin.sym} 40300 -28550 0 0 {name=p39666 lab=_67082_/A }
C {devices/lab_pin.sym} 40380 -28550 0 1 {name=p39667 lab=_67250_/A }
C {sky130_stdcells/buf_2.sym} 40340 -28550 0 0 {name=X_67200_ }
C {devices/lab_pin.sym} 40280 -28450 0 0 {name=p39668 lab=_64402_/X }
C {devices/lab_pin.sym} 40280 -28410 0 0 {name=p39669 lab=_64379_/B }
C {devices/lab_pin.sym} 40280 -28370 0 0 {name=p39670 lab=_64412_/C }
C {devices/lab_pin.sym} 40400 -28410 0 1 {name=p39671 lab=_64412_/X }
C {sky130_stdcells/and3_4.sym} 40340 -28410 0 0 {name=X_64412_ }
C {devices/lab_pin.sym} 40280 -28290 0 0 {name=p39672 lab=_61634_/A }
C {devices/lab_pin.sym} 40280 -28250 0 0 {name=p39673 lab=_61634_/B }
C {devices/lab_pin.sym} 40280 -28210 0 0 {name=p39674 lab=_79133_/B }
C {devices/lab_pin.sym} 40400 -28250 0 1 {name=p39675 lab=_61624_/Y }
C {sky130_stdcells/nor3_4.sym} 40340 -28250 0 0 {name=X_61624_ }
C {devices/lab_pin.sym} 40280 -28120 0 0 {name=p39676 lab=_49327_/X }
C {devices/lab_pin.sym} 40280 -28080 0 0 {name=p39677 lab=_54079_/B }
C {devices/lab_pin.sym} 40400 -28100 0 1 {name=p39678 lab=_49346_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -28100 0 0 {name=X_49346_ }
C {devices/lab_pin.sym} 40300 -27970 0 0 {name=p39679 lab=_68160_/A }
C {devices/lab_pin.sym} 40380 -27970 0 1 {name=p39680 lab=_68180_/X }
C {sky130_stdcells/buf_2.sym} 40340 -27970 0 0 {name=X_68180_ }
C {devices/lab_pin.sym} 40280 -27860 0 0 {name=p39681 lab=_82918_/Q }
C {devices/lab_pin.sym} 40280 -27820 0 0 {name=p39682 lab=_46527_/X }
C {devices/lab_pin.sym} 40400 -27840 0 1 {name=p39683 lab=_46558_/X }
C {sky130_stdcells/or2_4.sym} 40340 -27840 0 0 {name=X_46558_ }
C {devices/lab_pin.sym} 40280 -27720 0 0 {name=p39684 lab=_65289_/A }
C {devices/lab_pin.sym} 40280 -27680 0 0 {name=p39685 lab=_65392_/B }
C {devices/lab_pin.sym} 40400 -27700 0 1 {name=p39686 lab=_65392_/X }
C {sky130_stdcells/and2_4.sym} 40340 -27700 0 0 {name=X_65392_ }
C {devices/lab_pin.sym} 40300 -27570 0 0 {name=p39687 lab=_82221_/Q }
C {devices/lab_pin.sym} 40380 -27570 0 1 {name=p39688 lab=_77382_/A }
C {sky130_stdcells/inv_2.sym} 40340 -27570 0 0 {name=X_77378_ }
C {devices/lab_pin.sym} 40300 -27450 0 0 {name=p39689 lab=clkbuf_9_361_0_CLK/X }
C {devices/lab_pin.sym} 40380 -27450 0 1 {name=p39690 lab=_87022_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 40340 -27450 0 0 {name=Xclkbuf_10_723_0_CLK }
C {devices/lab_pin.sym} 40280 -27340 0 0 {name=p39691 lab=_67131_/A }
C {devices/lab_pin.sym} 40280 -27300 0 0 {name=p39692 lab=_87612_/Q }
C {devices/lab_pin.sym} 40400 -27320 0 1 {name=p39693 lab=_67131_/X }
C {sky130_stdcells/and2_4.sym} 40340 -27320 0 0 {name=X_67131_ }
C {devices/lab_pin.sym} 40300 -27190 0 0 {name=p39694 lab=_78998_/B }
C {devices/lab_pin.sym} 40380 -27190 0 1 {name=p39695 lab=_79117_/Y }
C {sky130_stdcells/inv_2.sym} 40340 -27190 0 0 {name=X_79117_ }
C {devices/lab_pin.sym} 40260 -27090 0 0 {name=p39696 lab=_83002_/Q }
C {devices/lab_pin.sym} 40260 -27050 0 0 {name=p39697 lab=_45401_/X }
C {devices/lab_pin.sym} 40260 -27010 0 0 {name=p39698 lab=_45508_/X }
C {devices/lab_pin.sym} 40420 -27050 0 1 {name=p39699 lab=_45510_/A }
C {sky130_stdcells/o21ai_4.sym} 40340 -27050 0 0 {name=X_45509_ }
C {devices/lab_pin.sym} 40280 -26930 0 0 {name=p39700 lab=_64319_/X }
C {devices/lab_pin.sym} 40280 -26890 0 0 {name=p39701 lab=_64343_/B }
C {devices/lab_pin.sym} 40280 -26850 0 0 {name=p39702 lab=_64333_/X }
C {devices/lab_pin.sym} 40400 -26890 0 1 {name=p39703 lab=_64343_/X }
C {sky130_stdcells/and3_4.sym} 40340 -26890 0 0 {name=X_64343_ }
C {devices/lab_pin.sym} 40260 -26770 0 0 {name=p39704 lab=_76316_/A }
C {devices/lab_pin.sym} 40260 -26730 0 0 {name=p39705 lab=_76327_/Y }
C {devices/lab_pin.sym} 40260 -26690 0 0 {name=p39706 lab=_76328_/Y }
C {devices/lab_pin.sym} 40420 -26730 0 1 {name=p39707 lab=_76338_/A }
C {sky130_stdcells/o21a_4.sym} 40340 -26730 0 0 {name=X_76329_ }
C {devices/lab_pin.sym} 40280 -26600 0 0 {name=p39708 lab=_49273_/A }
C {devices/lab_pin.sym} 40280 -26560 0 0 {name=p39709 lab=_46417_/B }
C {devices/lab_pin.sym} 40400 -26580 0 1 {name=p39710 lab=_49277_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -26580 0 0 {name=X_49277_ }
C {devices/lab_pin.sym} 40280 -26470 0 0 {name=p39711 lab=_61546_/A }
C {devices/lab_pin.sym} 40280 -26430 0 0 {name=p39712 lab=_61546_/B }
C {devices/lab_pin.sym} 40280 -26390 0 0 {name=p39713 lab=_84471_/Q }
C {devices/lab_pin.sym} 40400 -26430 0 1 {name=p39714 lab=_61555_/Y }
C {sky130_stdcells/nor3_4.sym} 40340 -26430 0 0 {name=X_61555_ }
C {devices/lab_pin.sym} 40300 -26290 0 0 {name=p39715 lab=_83636_/Q }
C {devices/lab_pin.sym} 40380 -26290 0 1 {name=p39716 lab=_52526_/B }
C {sky130_stdcells/inv_2.sym} 40340 -26290 0 0 {name=X_46489_ }
C {devices/lab_pin.sym} 40300 -26170 0 0 {name=p39717 lab=clkbuf_9_214_0_CLK/A }
C {devices/lab_pin.sym} 40380 -26170 0 1 {name=p39718 lab=clkbuf_9_214_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 40340 -26170 0 0 {name=Xclkbuf_9_214_0_CLK }
C {devices/lab_pin.sym} 40300 -26050 0 0 {name=p39719 lab=_47937_/B }
C {devices/lab_pin.sym} 40380 -26050 0 1 {name=p39720 lab=_53504_/B }
C {sky130_stdcells/buf_2.sym} 40340 -26050 0 0 {name=X_48228_ }
C {devices/lab_pin.sym} 40260 -25950 0 0 {name=p39721 lab=_60500_/Y }
C {devices/lab_pin.sym} 40260 -25910 0 0 {name=p39722 lab=_60501_/Y }
C {devices/lab_pin.sym} 40260 -25870 0 0 {name=p39723 lab=_60482_/A }
C {devices/lab_pin.sym} 40420 -25910 0 1 {name=p39724 lab=_63247_/A }
C {sky130_stdcells/o21a_4.sym} 40340 -25910 0 0 {name=X_60506_ }
C {devices/lab_pin.sym} 40300 -25770 0 0 {name=p39725 lab=_45915_/X }
C {devices/lab_pin.sym} 40380 -25770 0 1 {name=p39726 lab=_67062_/X }
C {sky130_stdcells/buf_2.sym} 40340 -25770 0 0 {name=X_67062_ }
C {devices/lab_pin.sym} 40280 -25660 0 0 {name=p39727 lab=_82524_/D }
C {devices/lab_pin.sym} 40280 -25620 0 0 {name=p39728 lab=_79048_/B }
C {devices/lab_pin.sym} 40400 -25640 0 1 {name=p39729 lab=_79049_/A }
C {sky130_stdcells/and2_4.sym} 40340 -25640 0 0 {name=X_79048_ }
C {devices/lab_pin.sym} 40300 -25510 0 0 {name=p39730 lab=_64274_/A }
C {devices/lab_pin.sym} 40380 -25510 0 1 {name=p39731 lab=_64274_/X }
C {sky130_stdcells/buf_2.sym} 40340 -25510 0 0 {name=X_64274_ }
C {devices/lab_pin.sym} 40260 -25430 0 0 {name=p39732 lab=_61479_/Y }
C {devices/lab_pin.sym} 40260 -25390 0 0 {name=p39733 lab=_61482_/Y }
C {devices/lab_pin.sym} 40260 -25350 0 0 {name=p39734 lab=_61464_/X }
C {devices/lab_pin.sym} 40260 -25310 0 0 {name=p39735 lab=_61483_/Y }
C {devices/lab_pin.sym} 40260 -25280 0 0 {name=p39736 lab=_61485_/Y }
C {devices/lab_pin.sym} 40420 -25350 0 1 {name=p39737 lab=_61486_/X }
C {sky130_stdcells/a41o_4.sym} 40340 -25350 0 0 {name=X_61486_ }
C {devices/lab_pin.sym} 40300 -25190 0 0 {name=p39738 lab=clkbuf_9_54_0_CLK/X }
C {devices/lab_pin.sym} 40380 -25190 0 1 {name=p39739 lab=_84531_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 40340 -25190 0 0 {name=Xclkbuf_10_108_0_CLK }
C {devices/lab_pin.sym} 40260 -25100 0 0 {name=p39740 lab=_65924_/X }
C {devices/lab_pin.sym} 40260 -25060 0 0 {name=p39741 lab=_84986_/Q }
C {devices/lab_pin.sym} 40260 -25020 0 0 {name=p39742 lab=_65950_/X }
C {devices/lab_pin.sym} 40260 -24980 0 0 {name=p39743 lab=_66012_/X }
C {devices/lab_pin.sym} 40420 -25040 0 1 {name=p39744 lab=_66013_/X }
C {sky130_stdcells/a211o_4.sym} 40340 -25040 0 0 {name=X_66013_ }
C {devices/lab_pin.sym} 40280 -24920 0 0 {name=p39745 lab=_63288_/A }
C {devices/lab_pin.sym} 40280 -24880 0 0 {name=p39746 lab=_64434_/B }
C {devices/lab_pin.sym} 40280 -24840 0 0 {name=p39747 lab=_63312_/C }
C {devices/lab_pin.sym} 40280 -24800 0 0 {name=p39748 lab=_63192_/D }
C {devices/lab_pin.sym} 40400 -24860 0 1 {name=p39749 lab=_63225_/X }
C {sky130_stdcells/and4_4.sym} 40340 -24860 0 0 {name=X_63225_ }
C {devices/lab_pin.sym} 40300 -24710 0 0 {name=p39750 lab=_52093_/A }
C {devices/lab_pin.sym} 40380 -24710 0 1 {name=p39751 lab=_50391_/A }
C {sky130_stdcells/buf_2.sym} 40340 -24710 0 0 {name=X_48159_ }
C {devices/lab_pin.sym} 40300 -24590 0 0 {name=p39752 lab=_60436_/Y }
C {devices/lab_pin.sym} 40380 -24590 0 1 {name=p39753 lab=_84616_/D }
C {sky130_stdcells/inv_2.sym} 40340 -24590 0 0 {name=X_60437_ }
C {devices/lab_pin.sym} 40300 -24470 0 0 {name=p39754 lab=clkbuf_9_369_0_CLK/X }
C {devices/lab_pin.sym} 40380 -24470 0 1 {name=p39755 lab=_86834_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 40340 -24470 0 0 {name=Xclkbuf_10_738_0_CLK }
C {devices/lab_pin.sym} 40250 -24350 0 0 {name=p39756 lab=_84197_/CLK }
C {devices/lab_pin.sym} 40250 -24330 0 0 {name=p39757 lab=_84218_/Q }
C {devices/lab_pin.sym} 40430 -24350 0 1 {name=p39758 lab=_81010_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -24340 0 0 {name=X_81010_ }
C {devices/lab_pin.sym} 40300 -24210 0 0 {name=p39759 lab=_51170_/A }
C {devices/lab_pin.sym} 40380 -24210 0 1 {name=p39760 lab=_51192_/C }
C {sky130_stdcells/buf_2.sym} 40340 -24210 0 0 {name=X_51170_ }
C {devices/lab_pin.sym} 40280 -24120 0 0 {name=p39761 lab=_63144_/X }
C {devices/lab_pin.sym} 40280 -24080 0 0 {name=p39762 lab=_84828_/Q }
C {devices/lab_pin.sym} 40280 -24040 0 0 {name=p39763 lab=_63146_/C }
C {devices/lab_pin.sym} 40280 -24000 0 0 {name=p39764 lab=_63135_/D }
C {devices/lab_pin.sym} 40400 -24060 0 1 {name=p39765 lab=_63156_/X }
C {sky130_stdcells/and4_4.sym} 40340 -24060 0 0 {name=X_63156_ }
C {devices/lab_pin.sym} 40260 -23940 0 0 {name=p39766 lab=_79566_/B }
C {devices/lab_pin.sym} 40260 -23900 0 0 {name=p39767 lab=_60323_/X }
C {devices/lab_pin.sym} 40260 -23860 0 0 {name=p39768 lab=_60305_/Y }
C {devices/lab_pin.sym} 40260 -23820 0 0 {name=p39769 lab=_60367_/Y }
C {devices/lab_pin.sym} 40420 -23880 0 1 {name=p39770 lab=_60368_/X }
C {sky130_stdcells/o22a_4.sym} 40340 -23880 0 0 {name=X_60368_ }
C {devices/lab_pin.sym} 40300 -23730 0 0 {name=p39771 lab=clkbuf_8_114_0_CLK/X }
C {devices/lab_pin.sym} 40380 -23730 0 1 {name=p39772 lab=clkbuf_9_229_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 40340 -23730 0 0 {name=Xclkbuf_9_229_0_CLK }
C {devices/lab_pin.sym} 40260 -23630 0 0 {name=p39773 lab=_64948_/B }
C {devices/lab_pin.sym} 40260 -23590 0 0 {name=p39774 lab=_50113_/X }
C {devices/lab_pin.sym} 40260 -23550 0 0 {name=p39775 lab=_50120_/Y }
C {devices/lab_pin.sym} 40420 -23590 0 1 {name=p39776 lab=_50121_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -23590 0 0 {name=X_50121_ }
C {devices/lab_pin.sym} 40300 -23450 0 0 {name=p39777 lab=_59605_/Y }
C {devices/lab_pin.sym} 40380 -23450 0 1 {name=p39778 lab=_62158_/C }
C {sky130_stdcells/buf_2.sym} 40340 -23450 0 0 {name=X_62107_ }
C {devices/lab_pin.sym} 40280 -23340 0 0 {name=p39779 lab=_67914_/X }
C {devices/lab_pin.sym} 40280 -23300 0 0 {name=p39780 lab=_67964_/B }
C {devices/lab_pin.sym} 40400 -23320 0 1 {name=p39781 lab=_67964_/X }
C {sky130_stdcells/and2_4.sym} 40340 -23320 0 0 {name=X_67964_ }
C {devices/lab_pin.sym} 40300 -23190 0 0 {name=p39782 lab=_60606_/X }
C {devices/lab_pin.sym} 40380 -23190 0 1 {name=p39783 lab=_63087_/X }
C {sky130_stdcells/buf_2.sym} 40340 -23190 0 0 {name=X_63087_ }
C {devices/lab_pin.sym} 40280 -23090 0 0 {name=p39784 lab=_60299_/A }
C {devices/lab_pin.sym} 40280 -23050 0 0 {name=p39785 lab=_60296_/X }
C {devices/lab_pin.sym} 40280 -23010 0 0 {name=p39786 lab=_60299_/C }
C {devices/lab_pin.sym} 40400 -23050 0 1 {name=p39787 lab=_60299_/Y }
C {sky130_stdcells/nand3_4.sym} 40340 -23050 0 0 {name=X_60299_ }
C {devices/lab_pin.sym} 40280 -22920 0 0 {name=p39788 lab=_69865_/A }
C {devices/lab_pin.sym} 40280 -22880 0 0 {name=p39789 lab=_88329_/Q }
C {devices/lab_pin.sym} 40400 -22900 0 1 {name=p39790 lab=_69703_/X }
C {sky130_stdcells/and2_4.sym} 40340 -22900 0 0 {name=X_69703_ }
C {devices/lab_pin.sym} 40280 -22780 0 0 {name=p39791 lab=_50056_/A }
C {devices/lab_pin.sym} 40280 -22740 0 0 {name=p39792 lab=_48878_/B }
C {devices/lab_pin.sym} 40400 -22760 0 1 {name=p39793 lab=_50052_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -22760 0 0 {name=X_50052_ }
C {devices/lab_pin.sym} 40300 -22630 0 0 {name=p39794 lab=_66915_/A }
C {devices/lab_pin.sym} 40380 -22630 0 1 {name=p39795 lab=_66915_/X }
C {sky130_stdcells/buf_2.sym} 40340 -22630 0 0 {name=X_66915_ }
C {devices/lab_pin.sym} 40280 -22540 0 0 {name=p39796 lab=_62037_/X }
C {devices/lab_pin.sym} 40280 -22500 0 0 {name=p39797 lab=_62021_/B }
C {devices/lab_pin.sym} 40280 -22460 0 0 {name=p39798 lab=_58487_/A }
C {devices/lab_pin.sym} 40280 -22420 0 0 {name=p39799 lab=_62020_/X }
C {devices/lab_pin.sym} 40400 -22480 0 1 {name=p39800 lab=_62038_/X }
C {sky130_stdcells/and4_4.sym} 40340 -22480 0 0 {name=X_62038_ }
C {devices/lab_pin.sym} 40250 -22330 0 0 {name=p39801 lab=_82961_/CLK }
C {devices/lab_pin.sym} 40250 -22310 0 0 {name=p39802 lab=_82769_/Q }
C {devices/lab_pin.sym} 40430 -22330 0 1 {name=p39803 lab=_82961_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -22320 0 0 {name=X_82961_ }
C {devices/lab_pin.sym} 40280 -22200 0 0 {name=p39804 lab=_67992_/A }
C {devices/lab_pin.sym} 40280 -22160 0 0 {name=p39805 lab=_88220_/Q }
C {devices/lab_pin.sym} 40400 -22180 0 1 {name=p39806 lab=_67895_/X }
C {sky130_stdcells/and2_4.sym} 40340 -22180 0 0 {name=X_67895_ }
C {devices/lab_pin.sym} 40250 -22050 0 0 {name=p39807 lab=_84329_/CLK }
C {devices/lab_pin.sym} 40250 -22030 0 0 {name=p39808 lab=_84700_/D }
C {devices/lab_pin.sym} 40430 -22050 0 1 {name=p39809 lab=_80484_/A }
C {sky130_stdcells/dfxtp_4.sym} 40340 -22040 0 0 {name=X_84700_ }
C {devices/lab_pin.sym} 40250 -21910 0 0 {name=p39810 lab=_82103_/CLK }
C {devices/lab_pin.sym} 40250 -21890 0 0 {name=p39811 lab=_81912_/D }
C {devices/lab_pin.sym} 40430 -21910 0 1 {name=p39812 lab=_82288_/D }
C {sky130_stdcells/dfxtp_4.sym} 40340 -21900 0 0 {name=X_81912_ }
C {devices/lab_pin.sym} 40260 -21800 0 0 {name=p39813 lab=_43126_/A }
C {devices/lab_pin.sym} 40260 -21760 0 0 {name=p39814 lab=_69506_/X }
C {devices/lab_pin.sym} 40260 -21720 0 0 {name=p39815 lab=_68436_/X }
C {devices/lab_pin.sym} 40260 -21680 0 0 {name=p39816 lab=_69633_/X }
C {devices/lab_pin.sym} 40420 -21740 0 1 {name=p39817 lab=_69634_/X }
C {sky130_stdcells/a211o_4.sym} 40340 -21740 0 0 {name=X_69634_ }
C {devices/lab_pin.sym} 40260 -21610 0 0 {name=p39818 lab=_85364_/Q }
C {devices/lab_pin.sym} 40260 -21570 0 0 {name=p39819 lab=_54839_/X }
C {devices/lab_pin.sym} 40260 -21530 0 0 {name=p39820 lab=_54859_/Y }
C {devices/lab_pin.sym} 40420 -21570 0 1 {name=p39821 lab=_54860_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -21570 0 0 {name=X_54860_ }
C {devices/lab_pin.sym} 40260 -21460 0 0 {name=p39822 lab=_88392_/Q }
C {devices/lab_pin.sym} 40260 -21420 0 0 {name=p39823 lab=_66751_/X }
C {devices/lab_pin.sym} 40260 -21380 0 0 {name=p39824 lab=_66801_/X }
C {devices/lab_pin.sym} 40260 -21340 0 0 {name=p39825 lab=_66845_/X }
C {devices/lab_pin.sym} 40420 -21400 0 1 {name=p39826 lab=_66846_/X }
C {sky130_stdcells/a211o_4.sym} 40340 -21400 0 0 {name=X_66846_ }
C {devices/lab_pin.sym} 40250 -21250 0 0 {name=p39827 lab=_84797_/CLK }
C {devices/lab_pin.sym} 40250 -21230 0 0 {name=p39828 lab=_53192_/Y }
C {devices/lab_pin.sym} 40430 -21250 0 1 {name=p39829 lab=_85680_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -21240 0 0 {name=X_85680_ }
C {devices/lab_pin.sym} 40250 -21110 0 0 {name=p39830 lab=_86935_/CLK }
C {devices/lab_pin.sym} 40250 -21090 0 0 {name=p39831 lab=_78153_/B }
C {devices/lab_pin.sym} 40430 -21110 0 1 {name=p39832 lab=_82892_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -21100 0 0 {name=X_82892_ }
C {devices/lab_pin.sym} 40260 -20990 0 0 {name=p39833 lab=_53809_/Y }
C {devices/lab_pin.sym} 40260 -20950 0 0 {name=p39834 lab=_53773_/X }
C {devices/lab_pin.sym} 40260 -20910 0 0 {name=p39835 lab=_53810_/X }
C {devices/lab_pin.sym} 40420 -20950 0 1 {name=p39836 lab=_53811_/Y }
C {sky130_stdcells/a21oi_4.sym} 40340 -20950 0 0 {name=X_53811_ }
C {devices/lab_pin.sym} 40250 -20810 0 0 {name=p39837 lab=_84649_/CLK }
C {devices/lab_pin.sym} 40250 -20790 0 0 {name=p39838 lab=_60328_/X }
C {devices/lab_pin.sym} 40430 -20810 0 1 {name=p39839 lab=_79691_/A }
C {sky130_stdcells/dfxtp_4.sym} 40340 -20800 0 0 {name=X_84631_ }
C {devices/lab_pin.sym} 40250 -20670 0 0 {name=p39840 lab=_81857_/CLK }
C {devices/lab_pin.sym} 40250 -20650 0 0 {name=p39841 lab=_81875_/Q }
C {devices/lab_pin.sym} 40430 -20670 0 1 {name=p39842 lab=_77471_/A }
C {sky130_stdcells/dfxtp_4.sym} 40340 -20660 0 0 {name=X_81843_ }
C {devices/lab_pin.sym} 40280 -20540 0 0 {name=p39843 lab=_69580_/A }
C {devices/lab_pin.sym} 40280 -20500 0 0 {name=p39844 lab=_87315_/Q }
C {devices/lab_pin.sym} 40400 -20520 0 1 {name=p39845 lab=_69565_/X }
C {sky130_stdcells/and2_4.sym} 40340 -20520 0 0 {name=X_69565_ }
C {devices/lab_pin.sym} 40260 -20410 0 0 {name=p39846 lab=_85377_/Q }
C {devices/lab_pin.sym} 40260 -20370 0 0 {name=p39847 lab=_54784_/X }
C {devices/lab_pin.sym} 40260 -20330 0 0 {name=p39848 lab=_54790_/Y }
C {devices/lab_pin.sym} 40420 -20370 0 1 {name=p39849 lab=_54791_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -20370 0 0 {name=X_54791_ }
C {devices/lab_pin.sym} 40280 -20240 0 0 {name=p39850 lab=_66728_/A }
C {devices/lab_pin.sym} 40280 -20200 0 0 {name=p39851 lab=_88139_/Q }
C {devices/lab_pin.sym} 40400 -20220 0 1 {name=p39852 lab=_66777_/X }
C {sky130_stdcells/and2_4.sym} 40340 -20220 0 0 {name=X_66777_ }
C {devices/lab_pin.sym} 40300 -20090 0 0 {name=p39853 lab=_63761_/A }
C {devices/lab_pin.sym} 40380 -20090 0 1 {name=p39854 lab=_64052_/D }
C {sky130_stdcells/buf_2.sym} 40340 -20090 0 0 {name=X_63989_ }
C {devices/lab_pin.sym} 40260 -19990 0 0 {name=p39855 lab=_56139_/X }
C {devices/lab_pin.sym} 40260 -19950 0 0 {name=p39856 lab=_56528_/X }
C {devices/lab_pin.sym} 40260 -19910 0 0 {name=p39857 lab=_56529_/Y }
C {devices/lab_pin.sym} 40420 -19950 0 1 {name=p39858 lab=_85161_/D }
C {sky130_stdcells/o21ai_4.sym} 40340 -19950 0 0 {name=X_56530_ }
C {devices/lab_pin.sym} 40300 -19810 0 0 {name=p39859 lab=_68300_/X }
C {devices/lab_pin.sym} 40380 -19810 0 1 {name=p39860 lab=_68516_/X }
C {sky130_stdcells/buf_2.sym} 40340 -19810 0 0 {name=X_68516_ }
C {devices/lab_pin.sym} 40250 -19690 0 0 {name=p39861 lab=_82899_/CLK }
C {devices/lab_pin.sym} 40250 -19670 0 0 {name=p39862 lab=_43578_/X }
C {devices/lab_pin.sym} 40430 -19690 0 1 {name=p39863 lab=_87350_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -19680 0 0 {name=X_87350_ }
C {devices/lab_pin.sym} 40260 -19570 0 0 {name=p39864 lab=_85577_/Q }
C {devices/lab_pin.sym} 40260 -19530 0 0 {name=p39865 lab=_53729_/X }
C {devices/lab_pin.sym} 40260 -19490 0 0 {name=p39866 lab=_53741_/Y }
C {devices/lab_pin.sym} 40420 -19530 0 1 {name=p39867 lab=_53742_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -19530 0 0 {name=X_53742_ }
C {devices/lab_pin.sym} 40280 -19410 0 0 {name=p39868 lab=_65634_/A }
C {devices/lab_pin.sym} 40280 -19370 0 0 {name=p39869 lab=_65802_/B }
C {devices/lab_pin.sym} 40280 -19330 0 0 {name=p39870 lab=_65728_/C }
C {devices/lab_pin.sym} 40400 -19370 0 1 {name=p39871 lab=_65728_/Y }
C {sky130_stdcells/nor3_4.sym} 40340 -19370 0 0 {name=X_65728_ }
C {devices/lab_pin.sym} 40250 -19230 0 0 {name=p39872 lab=_84562_/CLK }
C {devices/lab_pin.sym} 40250 -19210 0 0 {name=p39873 lab=_84562_/D }
C {devices/lab_pin.sym} 40430 -19230 0 1 {name=p39874 lab=_84562_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -19220 0 0 {name=X_84562_ }
C {devices/lab_pin.sym} 40260 -19110 0 0 {name=p39875 lab=_50951_/Y }
C {devices/lab_pin.sym} 40260 -19070 0 0 {name=p39876 lab=_50928_/X }
C {devices/lab_pin.sym} 40260 -19030 0 0 {name=p39877 lab=_50953_/X }
C {devices/lab_pin.sym} 40420 -19070 0 1 {name=p39878 lab=_86101_/D }
C {sky130_stdcells/a21oi_4.sym} 40340 -19070 0 0 {name=X_50954_ }
C {devices/lab_pin.sym} 40250 -18930 0 0 {name=p39879 lab=_82053_/CLK }
C {devices/lab_pin.sym} 40250 -18910 0 0 {name=p39880 lab=_76061_/X }
C {devices/lab_pin.sym} 40430 -18930 0 1 {name=p39881 lab=_81774_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -18920 0 0 {name=X_81774_ }
C {devices/lab_pin.sym} 40260 -18810 0 0 {name=p39882 lab=_69493_/X }
C {devices/lab_pin.sym} 40260 -18770 0 0 {name=p39883 lab=_69495_/X }
C {devices/lab_pin.sym} 40260 -18730 0 0 {name=p39884 lab=_69399_/X }
C {devices/lab_pin.sym} 40420 -18770 0 1 {name=p39885 lab=_69496_/X }
C {sky130_stdcells/a21o_4.sym} 40340 -18770 0 0 {name=X_69496_ }
C {devices/lab_pin.sym} 40250 -18630 0 0 {name=p39886 lab=_86301_/CLK }
C {devices/lab_pin.sym} 40250 -18610 0 0 {name=p39887 lab=_49911_/Y }
C {devices/lab_pin.sym} 40430 -18630 0 1 {name=p39888 lab=_72174_/B }
C {sky130_stdcells/dfxtp_4.sym} 40340 -18620 0 0 {name=X_86301_ }
C {devices/lab_pin.sym} 40250 -18490 0 0 {name=p39889 lab=_83507_/CLK }
C {devices/lab_pin.sym} 40250 -18470 0 0 {name=p39890 lab=_71400_/X }
C {devices/lab_pin.sym} 40430 -18490 0 1 {name=p39891 lab=_83513_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -18480 0 0 {name=X_83513_ }
C {devices/lab_pin.sym} 40300 -18350 0 0 {name=p39892 lab=_56463_/A }
C {devices/lab_pin.sym} 40380 -18350 0 1 {name=p39893 lab=_56528_/A }
C {sky130_stdcells/buf_2.sym} 40340 -18350 0 0 {name=X_56461_ }
C {devices/lab_pin.sym} 40300 -18230 0 0 {name=p39894 lab=_68447_/A }
C {devices/lab_pin.sym} 40380 -18230 0 1 {name=p39895 lab=_68447_/X }
C {sky130_stdcells/buf_2.sym} 40340 -18230 0 0 {name=X_68447_ }
C {devices/lab_pin.sym} 40250 -18110 0 0 {name=p39896 lab=_84269_/CLK }
C {devices/lab_pin.sym} 40250 -18090 0 0 {name=p39897 lab=_80725_/D }
C {devices/lab_pin.sym} 40430 -18110 0 1 {name=p39898 lab=_80725_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -18100 0 0 {name=X_80725_ }
C {devices/lab_pin.sym} 40250 -17970 0 0 {name=p39899 lab=_88097_/CLK }
C {devices/lab_pin.sym} 40250 -17950 0 0 {name=p39900 lab=_87281_/D }
C {devices/lab_pin.sym} 40430 -17970 0 1 {name=p39901 lab=_69165_/B }
C {sky130_stdcells/dfxtp_4.sym} 40340 -17960 0 0 {name=X_87281_ }
C {devices/lab_pin.sym} 40260 -17850 0 0 {name=p39902 lab=_53670_/Y }
C {devices/lab_pin.sym} 40260 -17810 0 0 {name=p39903 lab=_53653_/X }
C {devices/lab_pin.sym} 40260 -17770 0 0 {name=p39904 lab=_53672_/X }
C {devices/lab_pin.sym} 40420 -17810 0 1 {name=p39905 lab=_85591_/D }
C {sky130_stdcells/a21oi_4.sym} 40340 -17810 0 0 {name=X_53673_ }
C {devices/lab_pin.sym} 40260 -17690 0 0 {name=p39906 lab=_65656_/X }
C {devices/lab_pin.sym} 40260 -17650 0 0 {name=p39907 lab=_65658_/X }
C {devices/lab_pin.sym} 40260 -17610 0 0 {name=p39908 lab=_65614_/X }
C {devices/lab_pin.sym} 40420 -17650 0 1 {name=p39909 lab=_65659_/X }
C {sky130_stdcells/a21o_4.sym} 40340 -17650 0 0 {name=X_65659_ }
C {devices/lab_pin.sym} 40250 -17510 0 0 {name=p39910 lab=_84493_/CLK }
C {devices/lab_pin.sym} 40250 -17490 0 0 {name=p39911 lab=_61269_/Y }
C {devices/lab_pin.sym} 40430 -17510 0 1 {name=p39912 lab=_84493_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -17500 0 0 {name=X_84493_ }
C {devices/lab_pin.sym} 40260 -17390 0 0 {name=p39913 lab=_86113_/Q }
C {devices/lab_pin.sym} 40260 -17350 0 0 {name=p39914 lab=_50882_/X }
C {devices/lab_pin.sym} 40260 -17310 0 0 {name=p39915 lab=_50884_/Y }
C {devices/lab_pin.sym} 40420 -17350 0 1 {name=p39916 lab=_50885_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -17350 0 0 {name=X_50885_ }
C {devices/lab_pin.sym} 40300 -17210 0 0 {name=p39917 lab=_83373_/Q }
C {devices/lab_pin.sym} 40380 -17210 0 1 {name=p39918 lab=_58200_/Y }
C {sky130_stdcells/inv_2.sym} 40340 -17210 0 0 {name=X_58200_ }
C {devices/lab_pin.sym} 40300 -17090 0 0 {name=p39919 lab=_55200_/C }
C {devices/lab_pin.sym} 40380 -17090 0 1 {name=p39920 lab=_55412_/Y }
C {sky130_stdcells/inv_2.sym} 40340 -17090 0 0 {name=X_55412_ }
C {devices/lab_pin.sym} 40250 -16970 0 0 {name=p39921 lab=_86235_/CLK }
C {devices/lab_pin.sym} 40250 -16950 0 0 {name=p39922 lab=_86232_/D }
C {devices/lab_pin.sym} 40430 -16970 0 1 {name=p39923 lab=_86232_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -16960 0 0 {name=X_86232_ }
C {devices/lab_pin.sym} 40280 -16840 0 0 {name=p39924 lab=_52624_/A }
C {devices/lab_pin.sym} 40280 -16800 0 0 {name=p39925 lab=_54314_/B }
C {devices/lab_pin.sym} 40400 -16820 0 1 {name=p39926 lab=_52624_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -16820 0 0 {name=X_52624_ }
C {devices/lab_pin.sym} 40260 -16710 0 0 {name=p39927 lab=_59176_/Y }
C {devices/lab_pin.sym} 40260 -16670 0 0 {name=p39928 lab=_59179_/Y }
C {devices/lab_pin.sym} 40260 -16630 0 0 {name=p39929 lab=_59140_/X }
C {devices/lab_pin.sym} 40420 -16670 0 1 {name=p39930 lab=_59180_/X }
C {sky130_stdcells/a21o_4.sym} 40340 -16670 0 0 {name=X_59180_ }
C {devices/lab_pin.sym} 40250 -16530 0 0 {name=p39931 lab=_83763_/CLK }
C {devices/lab_pin.sym} 40250 -16510 0 0 {name=p39932 lab=_83444_/D }
C {devices/lab_pin.sym} 40430 -16530 0 1 {name=p39933 lab=_83444_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -16520 0 0 {name=X_83444_ }
C {devices/lab_pin.sym} 40280 -16410 0 0 {name=p39934 lab=_56383_/X }
C {devices/lab_pin.sym} 40280 -16370 0 0 {name=p39935 lab=_56386_/B }
C {devices/lab_pin.sym} 40280 -16330 0 0 {name=p39936 lab=_56392_/C }
C {devices/lab_pin.sym} 40400 -16370 0 1 {name=p39937 lab=_56392_/Y }
C {sky130_stdcells/nand3_4.sym} 40340 -16370 0 0 {name=X_56392_ }
C {devices/lab_pin.sym} 40250 -16230 0 0 {name=p39938 lab=_86772_/CLK }
C {devices/lab_pin.sym} 40250 -16210 0 0 {name=p39939 lab=_74835_/Y }
C {devices/lab_pin.sym} 40430 -16230 0 1 {name=p39940 lab=_80656_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -16220 0 0 {name=X_80656_ }
C {devices/lab_pin.sym} 40300 -16090 0 0 {name=p39941 lab=_66673_/X }
C {devices/lab_pin.sym} 40380 -16090 0 1 {name=p39942 lab=_69088_/A }
C {sky130_stdcells/buf_2.sym} 40340 -16090 0 0 {name=X_68378_ }
C {sky130_stdcells/decap_3.sym} 40340 -15940 0 0 {name=XPHY_304 }
C {devices/lab_pin.sym} 40300 -15790 0 0 {name=p39943 lab=_58721_/A }
C {devices/lab_pin.sym} 40380 -15790 0 1 {name=p39944 lab=_58649_/B }
C {sky130_stdcells/buf_2.sym} 40340 -15790 0 0 {name=X_58131_ }
C {sky130_stdcells/decap_3.sym} 40340 -15640 0 0 {name=XPHY_315 }
C {devices/lab_pin.sym} 40280 -15500 0 0 {name=p39945 lab=_55317_/A }
C {devices/lab_pin.sym} 40280 -15460 0 0 {name=p39946 lab=_57137_/A }
C {devices/lab_pin.sym} 40400 -15480 0 1 {name=p39947 lab=_55343_/X }
C {sky130_stdcells/and2_4.sym} 40340 -15480 0 0 {name=X_55343_ }
C {devices/lab_pin.sym} 40300 -15350 0 0 {name=p39948 lab=_63055_/A }
C {devices/lab_pin.sym} 40380 -15350 0 1 {name=p39949 lab=_68461_/A }
C {sky130_stdcells/buf_2.sym} 40340 -15350 0 0 {name=X_67329_ }
C {devices/lab_pin.sym} 40250 -15230 0 0 {name=p39950 lab=_85557_/CLK }
C {devices/lab_pin.sym} 40250 -15210 0 0 {name=p39951 lab=_86163_/D }
C {devices/lab_pin.sym} 40430 -15230 0 1 {name=p39952 lab=_86163_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -15220 0 0 {name=X_86163_ }
C {devices/lab_pin.sym} 40280 -15100 0 0 {name=p39953 lab=_52567_/A }
C {devices/lab_pin.sym} 40280 -15060 0 0 {name=p39954 lab=_54073_/B }
C {devices/lab_pin.sym} 40400 -15080 0 1 {name=p39955 lab=_52555_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -15080 0 0 {name=X_52555_ }
C {sky130_stdcells/decap_3.sym} 40340 -14920 0 0 {name=XPHY_326 }
C {devices/lab_pin.sym} 40250 -14770 0 0 {name=p39956 lab=_83372_/CLK }
C {devices/lab_pin.sym} 40250 -14750 0 0 {name=p39957 lab=_71791_/Y }
C {devices/lab_pin.sym} 40430 -14770 0 1 {name=p39958 lab=_83375_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -14760 0 0 {name=X_83375_ }
C {devices/lab_pin.sym} 40280 -14640 0 0 {name=p39959 lab=_84774_/Q }
C {devices/lab_pin.sym} 40280 -14600 0 0 {name=p39960 lab=_84166_/Q }
C {devices/lab_pin.sym} 40400 -14620 0 1 {name=p39961 lab=_80587_/X }
C {sky130_stdcells/xor2_4.sym} 40340 -14620 0 0 {name=X_80587_ }
C {sky130_stdcells/decap_3.sym} 40340 -14460 0 0 {name=XPHY_337 }
C {sky130_stdcells/decap_3.sym} 40340 -14280 0 0 {name=XPHY_348 }
C {sky130_stdcells/decap_3.sym} 40340 -14100 0 0 {name=XPHY_359 }
C {devices/lab_pin.sym} 40250 -13950 0 0 {name=p39962 lab=_85114_/CLK }
C {devices/lab_pin.sym} 40250 -13930 0 0 {name=p39963 lab=_85114_/D }
C {devices/lab_pin.sym} 40430 -13950 0 1 {name=p39964 lab=_45501_/A }
C {sky130_stdcells/dfxtp_4.sym} 40340 -13940 0 0 {name=X_85114_ }
C {devices/lab_pin.sym} 40260 -13830 0 0 {name=p39965 lab=_51502_/Y }
C {devices/lab_pin.sym} 40260 -13790 0 0 {name=p39966 lab=_51503_/X }
C {devices/lab_pin.sym} 40260 -13750 0 0 {name=p39967 lab=_51505_/X }
C {devices/lab_pin.sym} 40420 -13790 0 1 {name=p39968 lab=_85998_/D }
C {sky130_stdcells/a21oi_4.sym} 40340 -13790 0 0 {name=X_51506_ }
C {devices/lab_pin.sym} 40300 -13650 0 0 {name=p39969 lab=_58679_/A }
C {devices/lab_pin.sym} 40380 -13650 0 1 {name=p39970 lab=_58062_/X }
C {sky130_stdcells/buf_2.sym} 40340 -13650 0 0 {name=X_58062_ }
C {devices/lab_pin.sym} 40280 -13560 0 0 {name=p39971 lab=_70338_/A }
C {devices/lab_pin.sym} 40280 -13520 0 0 {name=p39972 lab=_70333_/B }
C {devices/lab_pin.sym} 40280 -13480 0 0 {name=p39973 lab=_83087_/Q }
C {devices/lab_pin.sym} 40280 -13440 0 0 {name=p39974 lab=_70332_/X }
C {devices/lab_pin.sym} 40400 -13500 0 1 {name=p39975 lab=_70340_/X }
C {sky130_stdcells/and4_4.sym} 40340 -13500 0 0 {name=X_70340_ }
C {devices/lab_pin.sym} 40250 -13350 0 0 {name=p39976 lab=_86758_/CLK }
C {devices/lab_pin.sym} 40250 -13330 0 0 {name=p39977 lab=_77147_/B }
C {devices/lab_pin.sym} 40430 -13350 0 1 {name=p39978 lab=_82326_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -13340 0 0 {name=X_82326_ }
C {devices/lab_pin.sym} 40260 -13240 0 0 {name=p39979 lab=_82982_/Q }
C {devices/lab_pin.sym} 40260 -13200 0 0 {name=p39980 lab=_55272_/X }
C {devices/lab_pin.sym} 40260 -13160 0 0 {name=p39981 lab=_55140_/X }
C {devices/lab_pin.sym} 40260 -13120 0 0 {name=p39982 lab=_55273_/X }
C {devices/lab_pin.sym} 40420 -13180 0 1 {name=p39983 lab=_55274_/X }
C {sky130_stdcells/a211o_4.sym} 40340 -13180 0 0 {name=X_55274_ }
C {devices/lab_pin.sym} 40250 -13030 0 0 {name=p39984 lab=_85778_/CLK }
C {devices/lab_pin.sym} 40250 -13010 0 0 {name=p39985 lab=_50990_/Y }
C {devices/lab_pin.sym} 40430 -13030 0 1 {name=p39986 lab=_86094_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -13020 0 0 {name=X_86094_ }
C {devices/lab_pin.sym} 40300 -12890 0 0 {name=p39987 lab=_52486_/A }
C {devices/lab_pin.sym} 40380 -12890 0 1 {name=p39988 lab=_52486_/X }
C {sky130_stdcells/buf_2.sym} 40340 -12890 0 0 {name=X_52486_ }
C {devices/lab_pin.sym} 40260 -12790 0 0 {name=p39989 lab=_57009_/Y }
C {devices/lab_pin.sym} 40260 -12750 0 0 {name=p39990 lab=_57012_/Y }
C {devices/lab_pin.sym} 40260 -12710 0 0 {name=p39991 lab=_44039_/X }
C {devices/lab_pin.sym} 40420 -12750 0 1 {name=p39992 lab=_57013_/X }
C {sky130_stdcells/o21a_4.sym} 40340 -12750 0 0 {name=X_57013_ }
C {devices/lab_pin.sym} 40300 -12610 0 0 {name=p39993 lab=_51822_/A }
C {devices/lab_pin.sym} 40380 -12610 0 1 {name=p39994 lab=_54253_/A }
C {sky130_stdcells/buf_2.sym} 40340 -12610 0 0 {name=X_54225_ }
C {devices/lab_pin.sym} 40250 -12490 0 0 {name=p39995 lab=_85042_/CLK }
C {devices/lab_pin.sym} 40250 -12470 0 0 {name=p39996 lab=_57260_/X }
C {devices/lab_pin.sym} 40430 -12490 0 1 {name=p39997 lab=_45585_/A }
C {sky130_stdcells/dfxtp_4.sym} 40340 -12480 0 0 {name=X_85045_ }
C {devices/lab_pin.sym} 40300 -12350 0 0 {name=p39998 lab=_51218_/X }
C {devices/lab_pin.sym} 40380 -12350 0 1 {name=p39999 lab=_51456_/A }
C {sky130_stdcells/buf_2.sym} 40340 -12350 0 0 {name=X_51437_ }
C {devices/lab_pin.sym} 40260 -12250 0 0 {name=p40000 lab=_70269_/X }
C {devices/lab_pin.sym} 40260 -12210 0 0 {name=p40001 lab=_74801_/B }
C {devices/lab_pin.sym} 40260 -12170 0 0 {name=p40002 lab=_70270_/X }
C {devices/lab_pin.sym} 40420 -12210 0 1 {name=p40003 lab=_83816_/D }
C {sky130_stdcells/a21o_4.sym} 40340 -12210 0 0 {name=X_70271_ }
C {devices/lab_pin.sym} 40250 -12070 0 0 {name=p40004 lab=_85381_/CLK }
C {devices/lab_pin.sym} 40250 -12050 0 0 {name=p40005 lab=_82257_/D }
C {devices/lab_pin.sym} 40430 -12070 0 1 {name=p40006 lab=_82257_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -12060 0 0 {name=X_82257_ }
C {devices/lab_pin.sym} 40280 -11940 0 0 {name=p40007 lab=_71993_/X }
C {devices/lab_pin.sym} 40280 -11900 0 0 {name=p40008 lab=_53834_/B }
C {devices/lab_pin.sym} 40400 -11920 0 1 {name=p40009 lab=_72010_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -11920 0 0 {name=X_72010_ }
C {devices/lab_pin.sym} 40250 -11790 0 0 {name=p40010 lab=_82933_/CLK }
C {devices/lab_pin.sym} 40250 -11770 0 0 {name=p40011 lab=_75060_/X }
C {devices/lab_pin.sym} 40430 -11790 0 1 {name=p40012 lab=_81208_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -11780 0 0 {name=X_81208_ }
C {devices/lab_pin.sym} 40300 -11650 0 0 {name=p40013 lab=_42096_/A }
C {devices/lab_pin.sym} 40380 -11650 0 1 {name=p40014 lab=_42170_/X }
C {sky130_stdcells/buf_2.sym} 40340 -11650 0 0 {name=X_42170_ }
C {devices/lab_pin.sym} 40280 -11560 0 0 {name=p40015 lab=_54160_/A }
C {devices/lab_pin.sym} 40280 -11520 0 0 {name=p40016 lab=_54160_/B }
C {devices/lab_pin.sym} 40280 -11480 0 0 {name=p40017 lab=_54146_/X }
C {devices/lab_pin.sym} 40280 -11440 0 0 {name=p40018 lab=_52989_/D }
C {devices/lab_pin.sym} 40400 -11500 0 1 {name=p40019 lab=_54156_/X }
C {sky130_stdcells/and4_4.sym} 40340 -11500 0 0 {name=X_54156_ }
C {devices/lab_pin.sym} 40280 -11360 0 0 {name=p40020 lab=_51367_/X }
C {devices/lab_pin.sym} 40280 -11320 0 0 {name=p40021 lab=_46539_/A }
C {devices/lab_pin.sym} 40400 -11340 0 1 {name=p40022 lab=_51368_/X }
C {sky130_stdcells/and2_4.sym} 40340 -11340 0 0 {name=X_51368_ }
C {devices/lab_pin.sym} 40250 -11210 0 0 {name=p40023 lab=_85404_/CLK }
C {devices/lab_pin.sym} 40250 -11190 0 0 {name=p40024 lab=_82188_/D }
C {devices/lab_pin.sym} 40430 -11210 0 1 {name=p40025 lab=_82188_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -11200 0 0 {name=X_82188_ }
C {devices/lab_pin.sym} 40280 -11100 0 0 {name=p40026 lab=_53107_/A }
C {devices/lab_pin.sym} 40280 -11060 0 0 {name=p40027 lab=_53113_/B }
C {devices/lab_pin.sym} 40280 -11020 0 0 {name=p40028 lab=_53107_/C }
C {devices/lab_pin.sym} 40280 -10980 0 0 {name=p40029 lab=_53107_/D }
C {devices/lab_pin.sym} 40400 -11040 0 1 {name=p40030 lab=_53107_/X }
C {sky130_stdcells/and4_4.sym} 40340 -11040 0 0 {name=X_53107_ }
C {devices/lab_pin.sym} 40300 -10890 0 0 {name=p40031 lab=_41121_/A }
C {devices/lab_pin.sym} 40380 -10890 0 1 {name=p40032 lab=_41121_/X }
C {sky130_stdcells/buf_2.sym} 40340 -10890 0 0 {name=X_41121_ }
C {devices/lab_pin.sym} 40260 -10790 0 0 {name=p40033 lab=_86224_/Q }
C {devices/lab_pin.sym} 40260 -10750 0 0 {name=p40034 lab=_50316_/X }
C {devices/lab_pin.sym} 40260 -10710 0 0 {name=p40035 lab=_50318_/Y }
C {devices/lab_pin.sym} 40420 -10750 0 1 {name=p40036 lab=_50319_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -10750 0 0 {name=X_50319_ }
C {devices/lab_pin.sym} 40250 -10610 0 0 {name=p40037 lab=_80854_/CLK }
C {devices/lab_pin.sym} 40250 -10590 0 0 {name=p40038 lab=_80763_/Q }
