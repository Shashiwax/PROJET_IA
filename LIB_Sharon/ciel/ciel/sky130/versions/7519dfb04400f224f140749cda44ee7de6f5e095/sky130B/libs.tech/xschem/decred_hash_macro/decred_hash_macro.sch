C {sky130_stdcells/buf_2.sym} 13660 -8690 0 0 {name=X_60013_ }
C {devices/lab_pin.sym} 13580 -8590 0 0 {name=p13528 lab=_49821_/Y }
C {devices/lab_pin.sym} 13580 -8550 0 0 {name=p13529 lab=_49815_/X }
C {devices/lab_pin.sym} 13580 -8510 0 0 {name=p13530 lab=_49823_/X }
C {devices/lab_pin.sym} 13740 -8550 0 1 {name=p13531 lab=_86317_/D }
C {sky130_stdcells/a21oi_4.sym} 13660 -8550 0 0 {name=X_49824_ }
C {devices/lab_pin.sym} 13620 -8410 0 0 {name=p13532 lab=_65045_/A }
C {devices/lab_pin.sym} 13700 -8410 0 1 {name=p13533 lab=_65888_/B }
C {sky130_stdcells/buf_2.sym} 13660 -8410 0 0 {name=X_65870_ }
C {devices/lab_pin.sym} 13580 -8330 0 0 {name=p13534 lab=_42154_/X }
C {devices/lab_pin.sym} 13580 -8290 0 0 {name=p13535 lab=_42141_/X }
C {devices/lab_pin.sym} 13580 -8250 0 0 {name=p13536 lab=_41193_/X }
C {devices/lab_pin.sym} 13580 -8210 0 0 {name=p13537 lab=_88004_/Q }
C {devices/lab_pin.sym} 13580 -8170 0 0 {name=p13538 lab=_42142_/X }
C {devices/lab_pin.sym} 13740 -8250 0 1 {name=p13539 lab=_42159_/Y }
C {sky130_stdcells/o32ai_4.sym} 13660 -8250 0 0 {name=X_42159_ }
C {devices/lab_pin.sym} 13620 -8090 0 0 {name=p13540 lab=_77845_/Y }
C {devices/lab_pin.sym} 13700 -8090 0 1 {name=p13541 lab=_77856_/Y }
C {sky130_stdcells/inv_2.sym} 13660 -8090 0 0 {name=X_77856_ }
C {devices/lab_pin.sym} 13580 -8000 0 0 {name=p13542 lab=_64678_/X }
C {devices/lab_pin.sym} 13580 -7960 0 0 {name=p13543 lab=_85529_/Q }
C {devices/lab_pin.sym} 13580 -7920 0 0 {name=p13544 lab=_64679_/X }
C {devices/lab_pin.sym} 13580 -7880 0 0 {name=p13545 lab=_64820_/X }
C {devices/lab_pin.sym} 13740 -7940 0 1 {name=p13546 lab=_64821_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -7940 0 0 {name=X_64821_ }
C {devices/lab_pin.sym} 13580 -7810 0 0 {name=p13547 lab=_76801_/B }
C {devices/lab_pin.sym} 13580 -7770 0 0 {name=p13548 lab=_76801_/A }
C {devices/lab_pin.sym} 13580 -7730 0 0 {name=p13549 lab=_76806_/Y }
C {devices/lab_pin.sym} 13740 -7770 0 1 {name=p13550 lab=_76807_/Y }
C {sky130_stdcells/a21oi_4.sym} 13660 -7770 0 0 {name=X_76807_ }
C {devices/lab_pin.sym} 13600 -7660 0 0 {name=p13551 lab=_49751_/A }
C {devices/lab_pin.sym} 13600 -7620 0 0 {name=p13552 lab=_49750_/X }
C {devices/lab_pin.sym} 13600 -7580 0 0 {name=p13553 lab=_49761_/C }
C {devices/lab_pin.sym} 13600 -7540 0 0 {name=p13554 lab=_52971_/D }
C {devices/lab_pin.sym} 13720 -7600 0 1 {name=p13555 lab=_49755_/X }
C {sky130_stdcells/and4_4.sym} 13660 -7600 0 0 {name=X_49755_ }
C {devices/lab_pin.sym} 13620 -7450 0 0 {name=p13556 lab=_83716_/Q }
C {devices/lab_pin.sym} 13700 -7450 0 1 {name=p13557 lab=_54469_/B }
C {sky130_stdcells/inv_2.sym} 13660 -7450 0 0 {name=X_46967_ }
C {devices/lab_pin.sym} 13600 -7340 0 0 {name=p13558 lab=_77787_/A }
C {devices/lab_pin.sym} 13600 -7300 0 0 {name=p13559 lab=_77786_/X }
C {devices/lab_pin.sym} 13720 -7320 0 1 {name=p13560 lab=_77796_/B }
C {sky130_stdcells/xnor2_4.sym} 13660 -7320 0 0 {name=X_77787_ }
C {devices/lab_pin.sym} 13600 -7200 0 0 {name=p13561 lab=_80768_/Q }
C {devices/lab_pin.sym} 13600 -7160 0 0 {name=p13562 lab=_75020_/C }
C {devices/lab_pin.sym} 13720 -7180 0 1 {name=p13563 lab=_74999_/X }
C {sky130_stdcells/xor2_4.sym} 13660 -7180 0 0 {name=X_74999_ }
C {devices/lab_pin.sym} 13600 -7060 0 0 {name=p13564 lab=_49212_/A }
C {devices/lab_pin.sym} 13600 -7020 0 0 {name=p13565 lab=_48872_/B }
C {devices/lab_pin.sym} 13720 -7040 0 1 {name=p13566 lab=_48706_/Y }
C {sky130_stdcells/nand2_4.sym} 13660 -7040 0 0 {name=X_48706_ }
C {devices/lab_pin.sym} 13600 -6920 0 0 {name=p13567 lab=_67539_/X }
C {devices/lab_pin.sym} 13600 -6880 0 0 {name=p13568 lab=_88171_/Q }
C {devices/lab_pin.sym} 13720 -6900 0 1 {name=p13569 lab=_67540_/X }
C {sky130_stdcells/and2_4.sym} 13660 -6900 0 0 {name=X_67540_ }
C {devices/lab_pin.sym} 13620 -6770 0 0 {name=p13570 lab=_79529_/B }
C {devices/lab_pin.sym} 13700 -6770 0 1 {name=p13571 lab=_79526_/Y }
C {sky130_stdcells/inv_2.sym} 13660 -6770 0 0 {name=X_79526_ }
C {devices/lab_pin.sym} 13580 -6670 0 0 {name=p13572 lab=_65381_/A }
C {devices/lab_pin.sym} 13580 -6630 0 0 {name=p13573 lab=_44024_/A }
C {devices/lab_pin.sym} 13580 -6590 0 0 {name=p13574 lab=_44157_/Y }
C {devices/lab_pin.sym} 13740 -6630 0 1 {name=p13575 lab=_45918_/Y }
C {sky130_stdcells/a21oi_4.sym} 13660 -6630 0 0 {name=X_45918_ }
C {devices/lab_pin.sym} 13620 -6490 0 0 {name=p13576 lab=_64752_/A }
C {devices/lab_pin.sym} 13700 -6490 0 1 {name=p13577 lab=_64752_/X }
C {sky130_stdcells/buf_2.sym} 13660 -6490 0 0 {name=X_64752_ }
C {devices/lab_pin.sym} 13600 -6380 0 0 {name=p13578 lab=_76724_/Y }
C {devices/lab_pin.sym} 13600 -6340 0 0 {name=p13579 lab=_76737_/X }
C {devices/lab_pin.sym} 13720 -6360 0 1 {name=p13580 lab=_76738_/Y }
C {sky130_stdcells/nand2_4.sym} 13660 -6360 0 0 {name=X_76738_ }
C {devices/lab_pin.sym} 13580 -6250 0 0 {name=p13581 lab=_49683_/Y }
C {devices/lab_pin.sym} 13580 -6210 0 0 {name=p13582 lab=_49677_/X }
C {devices/lab_pin.sym} 13580 -6170 0 0 {name=p13583 lab=_49685_/X }
C {devices/lab_pin.sym} 13740 -6210 0 1 {name=p13584 lab=_49686_/Y }
C {sky130_stdcells/a21oi_4.sym} 13660 -6210 0 0 {name=X_49686_ }
C {devices/lab_pin.sym} 13600 -6100 0 0 {name=p13585 lab=_61949_/A }
C {devices/lab_pin.sym} 13600 -6060 0 0 {name=p13586 lab=_61949_/B }
C {devices/lab_pin.sym} 13600 -6020 0 0 {name=p13587 lab=_61949_/C }
C {devices/lab_pin.sym} 13600 -5980 0 0 {name=p13588 lab=_63182_/B }
C {devices/lab_pin.sym} 13720 -6040 0 1 {name=p13589 lab=_61964_/X }
C {sky130_stdcells/and4_4.sym} 13660 -6040 0 0 {name=X_61964_ }
C {devices/lab_pin.sym} 13620 -5890 0 0 {name=p13590 lab=_46898_/A }
C {devices/lab_pin.sym} 13700 -5890 0 1 {name=p13591 lab=_52739_/B }
C {sky130_stdcells/inv_2.sym} 13660 -5890 0 0 {name=X_46898_ }
C {devices/lab_pin.sym} 13600 -5800 0 0 {name=p13592 lab=_63484_/A }
C {devices/lab_pin.sym} 13600 -5760 0 0 {name=p13593 lab=_63703_/B }
C {devices/lab_pin.sym} 13600 -5720 0 0 {name=p13594 lab=_63672_/C }
C {devices/lab_pin.sym} 13600 -5680 0 0 {name=p13595 lab=_60682_/A }
C {devices/lab_pin.sym} 13720 -5740 0 1 {name=p13596 lab=_63703_/X }
C {sky130_stdcells/and4_4.sym} 13660 -5740 0 0 {name=X_63703_ }
C {devices/lab_pin.sym} 13620 -5590 0 0 {name=p13597 lab=_60915_/A }
C {devices/lab_pin.sym} 13700 -5590 0 1 {name=p13598 lab=_60915_/X }
C {sky130_stdcells/buf_2.sym} 13660 -5590 0 0 {name=X_60915_ }
C {devices/lab_pin.sym} 13580 -5490 0 0 {name=p13599 lab=_48629_/Y }
C {devices/lab_pin.sym} 13580 -5450 0 0 {name=p13600 lab=_48585_/X }
C {devices/lab_pin.sym} 13580 -5410 0 0 {name=p13601 lab=_48636_/X }
C {devices/lab_pin.sym} 13740 -5450 0 1 {name=p13602 lab=_86505_/D }
C {sky130_stdcells/a21oi_4.sym} 13660 -5450 0 0 {name=X_48637_ }
C {devices/lab_pin.sym} 13580 -5340 0 0 {name=p13603 lab=_67166_/X }
C {devices/lab_pin.sym} 13580 -5300 0 0 {name=p13604 lab=_67458_/Y }
C {devices/lab_pin.sym} 13580 -5260 0 0 {name=p13605 lab=_67390_/X }
C {devices/lab_pin.sym} 13580 -5220 0 0 {name=p13606 lab=_67470_/Y }
C {devices/lab_pin.sym} 13740 -5280 0 1 {name=p13607 lab=_67471_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -5280 0 0 {name=X_67471_ }
C {devices/lab_pin.sym} 13600 -5140 0 0 {name=p13608 lab=_79455_/X }
C {devices/lab_pin.sym} 13600 -5100 0 0 {name=p13609 lab=_79457_/B }
C {devices/lab_pin.sym} 13720 -5120 0 1 {name=p13610 lab=_79470_/B }
C {sky130_stdcells/xnor2_4.sym} 13660 -5120 0 0 {name=X_79457_ }
C {devices/lab_pin.sym} 13580 -5010 0 0 {name=p13611 lab=_45846_/X }
C {devices/lab_pin.sym} 13580 -4970 0 0 {name=p13612 lab=_45848_/Y }
C {devices/lab_pin.sym} 13580 -4930 0 0 {name=p13613 lab=_45803_/X }
C {devices/lab_pin.sym} 13740 -4970 0 1 {name=p13614 lab=_45849_/Y }
C {sky130_stdcells/a21oi_4.sym} 13660 -4970 0 0 {name=X_45849_ }
C {devices/lab_pin.sym} 13620 -4830 0 0 {name=p13615 lab=_64683_/A }
C {devices/lab_pin.sym} 13700 -4830 0 1 {name=p13616 lab=_64937_/B }
C {sky130_stdcells/buf_2.sym} 13660 -4830 0 0 {name=X_64683_ }
C {devices/lab_pin.sym} 13600 -4720 0 0 {name=p13617 lab=_76667_/Y }
C {devices/lab_pin.sym} 13600 -4680 0 0 {name=p13618 lab=_81684_/Q }
C {devices/lab_pin.sym} 13720 -4700 0 1 {name=p13619 lab=_76669_/Y }
C {sky130_stdcells/nand2_4.sym} 13660 -4700 0 0 {name=X_76669_ }
C {devices/lab_pin.sym} 13620 -4570 0 0 {name=p13620 lab=_61719_/A }
C {devices/lab_pin.sym} 13700 -4570 0 1 {name=p13621 lab=_61895_/X }
C {sky130_stdcells/buf_2.sym} 13660 -4570 0 0 {name=X_61895_ }
C {devices/lab_pin.sym} 13580 -4480 0 0 {name=p13622 lab=_87034_/Q }
C {devices/lab_pin.sym} 13580 -4440 0 0 {name=p13623 lab=_69153_/X }
C {devices/lab_pin.sym} 13580 -4400 0 0 {name=p13624 lab=_69168_/X }
C {devices/lab_pin.sym} 13580 -4360 0 0 {name=p13625 lab=_69209_/X }
C {devices/lab_pin.sym} 13740 -4420 0 1 {name=p13626 lab=_69210_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -4420 0 0 {name=X_69210_ }
C {devices/lab_pin.sym} 13600 -4290 0 0 {name=p13627 lab=_66073_/X }
C {devices/lab_pin.sym} 13600 -4250 0 0 {name=p13628 lab=_65833_/B }
C {devices/lab_pin.sym} 13600 -4210 0 0 {name=p13629 lab=_66075_/X }
C {devices/lab_pin.sym} 13720 -4250 0 1 {name=p13630 lab=_66422_/Y }
C {sky130_stdcells/nand3_4.sym} 13660 -4250 0 0 {name=X_66422_ }
C {devices/lab_pin.sym} 13600 -4130 0 0 {name=p13631 lab=_78407_/Y }
C {devices/lab_pin.sym} 13600 -4090 0 0 {name=p13632 lab=_78405_/A }
C {devices/lab_pin.sym} 13600 -4050 0 0 {name=p13633 lab=_78408_/C }
C {devices/lab_pin.sym} 13720 -4090 0 1 {name=p13634 lab=_78411_/B }
C {sky130_stdcells/nand3_4.sym} 13660 -4090 0 0 {name=X_78408_ }
C {devices/lab_pin.sym} 13580 -3990 0 0 {name=p13635 lab=_63624_/X }
C {devices/lab_pin.sym} 13580 -3950 0 0 {name=p13636 lab=_63625_/X }
C {devices/lab_pin.sym} 13580 -3910 0 0 {name=p13637 lab=_63628_/X }
C {devices/lab_pin.sym} 13580 -3870 0 0 {name=p13638 lab=_63631_/X }
C {devices/lab_pin.sym} 13580 -3830 0 0 {name=p13639 lab=_63633_/Y }
C {devices/lab_pin.sym} 13740 -3910 0 1 {name=p13640 lab=_63634_/Y }
C {sky130_stdcells/o41ai_4.sym} 13660 -3910 0 0 {name=X_63634_ }
C {devices/lab_pin.sym} 13620 -3750 0 0 {name=p13641 lab=_48635_/A }
C {devices/lab_pin.sym} 13700 -3750 0 1 {name=p13642 lab=_48624_/B }
C {sky130_stdcells/buf_2.sym} 13660 -3750 0 0 {name=X_48568_ }
C {devices/lab_pin.sym} 13600 -3640 0 0 {name=p13643 lab=_60845_/Y }
C {devices/lab_pin.sym} 13600 -3600 0 0 {name=p13644 lab=_59579_/A }
C {devices/lab_pin.sym} 13720 -3620 0 1 {name=p13645 lab=_60846_/Y }
C {sky130_stdcells/nor2_4.sym} 13660 -3620 0 0 {name=X_60846_ }
C {devices/lab_pin.sym} 13600 -3500 0 0 {name=p13646 lab=_79374_/A }
C {devices/lab_pin.sym} 13600 -3460 0 0 {name=p13647 lab=_79373_/Y }
C {devices/lab_pin.sym} 13720 -3480 0 1 {name=p13648 lab=_79388_/X }
C {sky130_stdcells/or2_4.sym} 13660 -3480 0 0 {name=X_79388_ }
C {devices/lab_pin.sym} 13620 -3350 0 0 {name=p13649 lab=clkbuf_7_8_0_CLK/X }
C {devices/lab_pin.sym} 13700 -3350 0 1 {name=p13650 lab=clkbuf_9_33_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 13660 -3350 0 0 {name=Xclkbuf_8_16_0_CLK }
C {devices/lab_pin.sym} 13580 -3260 0 0 {name=p13651 lab=_87039_/Q }
C {devices/lab_pin.sym} 13580 -3220 0 0 {name=p13652 lab=_69058_/X }
C {devices/lab_pin.sym} 13580 -3180 0 0 {name=p13653 lab=_69103_/X }
C {devices/lab_pin.sym} 13580 -3140 0 0 {name=p13654 lab=_69140_/X }
C {devices/lab_pin.sym} 13740 -3200 0 1 {name=p13655 lab=_69141_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -3200 0 0 {name=X_69141_ }
C {devices/lab_pin.sym} 13620 -3050 0 0 {name=p13656 lab=_47565_/A }
C {devices/lab_pin.sym} 13700 -3050 0 1 {name=p13657 lab=_47519_/X }
C {sky130_stdcells/buf_2.sym} 13660 -3050 0 0 {name=X_47519_ }
C {devices/lab_pin.sym} 13600 -2940 0 0 {name=p13658 lab=_64710_/A }
C {devices/lab_pin.sym} 13600 -2900 0 0 {name=p13659 lab=_86530_/Q }
C {devices/lab_pin.sym} 13720 -2920 0 1 {name=p13660 lab=_66353_/X }
C {sky130_stdcells/and2_4.sym} 13660 -2920 0 0 {name=X_66353_ }
C {devices/lab_pin.sym} 13600 -2800 0 0 {name=p13661 lab=_78339_/A }
C {devices/lab_pin.sym} 13600 -2760 0 0 {name=p13662 lab=_78339_/B }
C {devices/lab_pin.sym} 13720 -2780 0 1 {name=p13663 lab=_78340_/B }
C {sky130_stdcells/nor2_4.sym} 13660 -2780 0 0 {name=X_78339_ }
C {devices/lab_pin.sym} 13600 -2680 0 0 {name=p13664 lab=_58434_/A }
C {devices/lab_pin.sym} 13600 -2640 0 0 {name=p13665 lab=_63541_/B }
C {devices/lab_pin.sym} 13600 -2600 0 0 {name=p13666 lab=_63575_/C }
C {devices/lab_pin.sym} 13600 -2560 0 0 {name=p13667 lab=_63541_/D }
C {devices/lab_pin.sym} 13720 -2620 0 1 {name=p13668 lab=_63565_/Y }
C {sky130_stdcells/nand4_4.sym} 13660 -2620 0 0 {name=X_63565_ }
C {devices/lab_pin.sym} 13580 -2490 0 0 {name=p13669 lab=_78064_/A }
C {devices/lab_pin.sym} 13580 -2450 0 0 {name=p13670 lab=_59803_/X }
C {devices/lab_pin.sym} 13580 -2410 0 0 {name=p13671 lab=_60776_/Y }
C {devices/lab_pin.sym} 13740 -2450 0 1 {name=p13672 lab=_84569_/D }
C {sky130_stdcells/a21bo_4.sym} 13660 -2450 0 0 {name=X_60777_ }
C {devices/lab_pin.sym} 13620 -2310 0 0 {name=p13673 lab=_48499_/A }
C {devices/lab_pin.sym} 13700 -2310 0 1 {name=p13674 lab=_48635_/A }
C {sky130_stdcells/buf_2.sym} 13660 -2310 0 0 {name=X_48499_ }
C {devices/lab_pin.sym} 13620 -2190 0 0 {name=p13675 lab=_65614_/A }
C {devices/lab_pin.sym} 13700 -2190 0 1 {name=p13676 lab=_65304_/X }
C {sky130_stdcells/buf_2.sym} 13660 -2190 0 0 {name=X_65304_ }
C {devices/lab_pin.sym} 13620 -2070 0 0 {name=p13677 lab=_50496_/A }
C {devices/lab_pin.sym} 13700 -2070 0 1 {name=p13678 lab=_50552_/B }
C {sky130_stdcells/buf_2.sym} 13660 -2070 0 0 {name=X_50530_ }
C {devices/lab_pin.sym} 13580 -1970 0 0 {name=p13679 lab=_84836_/Q }
C {devices/lab_pin.sym} 13580 -1930 0 0 {name=p13680 lab=_60056_/A }
C {devices/lab_pin.sym} 13580 -1890 0 0 {name=p13681 lab=_62515_/X }
C {devices/lab_pin.sym} 13740 -1930 0 1 {name=p13682 lab=_62516_/X }
C {sky130_stdcells/a21o_4.sym} 13660 -1930 0 0 {name=X_62516_ }
C {devices/lab_pin.sym} 13570 -1790 0 0 {name=p13683 lab=_81346_/CLK }
C {devices/lab_pin.sym} 13570 -1770 0 0 {name=p13684 lab=_81350_/D }
C {devices/lab_pin.sym} 13750 -1790 0 1 {name=p13685 lab=_81350_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -1780 0 0 {name=X_81350_ }
C {devices/lab_pin.sym} 13620 -1650 0 0 {name=p13686 lab=_64777_/A }
C {devices/lab_pin.sym} 13700 -1650 0 1 {name=p13687 lab=_69073_/A }
C {sky130_stdcells/buf_2.sym} 13660 -1650 0 0 {name=X_69072_ }
C {devices/lab_pin.sym} 13580 -1560 0 0 {name=p13688 lab=_64714_/X }
C {devices/lab_pin.sym} 13580 -1520 0 0 {name=p13689 lab=_86215_/Q }
C {devices/lab_pin.sym} 13580 -1480 0 0 {name=p13690 lab=_64716_/X }
C {devices/lab_pin.sym} 13580 -1440 0 0 {name=p13691 lab=_66283_/X }
C {devices/lab_pin.sym} 13740 -1500 0 1 {name=p13692 lab=_66284_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -1500 0 0 {name=X_66284_ }
C {devices/lab_pin.sym} 13600 -1380 0 0 {name=p13693 lab=_63496_/A }
C {devices/lab_pin.sym} 13600 -1340 0 0 {name=p13694 lab=_63496_/B }
C {devices/lab_pin.sym} 13600 -1300 0 0 {name=p13695 lab=_63458_/X }
C {devices/lab_pin.sym} 13600 -1260 0 0 {name=p13696 lab=_63496_/D }
C {devices/lab_pin.sym} 13720 -1320 0 1 {name=p13697 lab=_63496_/X }
C {sky130_stdcells/and4_4.sym} 13660 -1320 0 0 {name=X_63496_ }
C {devices/lab_pin.sym} 13620 -1170 0 0 {name=p13698 lab=_80300_/Y }
C {devices/lab_pin.sym} 13700 -1170 0 1 {name=p13699 lab=_80301_/Y }
C {sky130_stdcells/inv_2.sym} 13660 -1170 0 0 {name=X_80301_ }
C {devices/lab_pin.sym} 13620 -1050 0 0 {name=p13700 lab=_67550_/X }
C {devices/lab_pin.sym} 13700 -1050 0 1 {name=p13701 lab=_68023_/X }
C {sky130_stdcells/buf_2.sym} 13660 -1050 0 0 {name=X_68023_ }
C {devices/lab_pin.sym} 13580 -960 0 0 {name=p13702 lab=_65172_/X }
C {devices/lab_pin.sym} 13580 -920 0 0 {name=p13703 lab=_86121_/Q }
C {devices/lab_pin.sym} 13580 -880 0 0 {name=p13704 lab=_65127_/X }
C {devices/lab_pin.sym} 13580 -840 0 0 {name=p13705 lab=_65234_/X }
C {devices/lab_pin.sym} 13740 -900 0 1 {name=p13706 lab=_65235_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -900 0 0 {name=X_65235_ }
C {devices/lab_pin.sym} 13620 -750 0 0 {name=p13707 lab=_50496_/A }
C {devices/lab_pin.sym} 13700 -750 0 1 {name=p13708 lab=_50492_/B }
C {sky130_stdcells/buf_2.sym} 13660 -750 0 0 {name=X_50461_ }
C {devices/lab_pin.sym} 14540 -42150 0 0 {name=p13709 lab=_62532_/A }
C {devices/lab_pin.sym} 14620 -42150 0 1 {name=p13710 lab=_62491_/C }
C {sky130_stdcells/buf_2.sym} 14580 -42150 0 0 {name=X_62447_ }
C {devices/lab_pin.sym} 14490 -42030 0 0 {name=p13711 lab=_81697_/CLK }
C {devices/lab_pin.sym} 14490 -42010 0 0 {name=p13712 lab=_81313_/Q }
C {devices/lab_pin.sym} 14670 -42030 0 1 {name=p13713 lab=_76636_/A }
C {sky130_stdcells/dfxtp_4.sym} 14580 -42020 0 0 {name=X_81281_ }
C {devices/lab_pin.sym} 14500 -41910 0 0 {name=p13714 lab=_52197_/Y }
C {devices/lab_pin.sym} 14500 -41870 0 0 {name=p13715 lab=_52170_/X }
C {devices/lab_pin.sym} 14500 -41830 0 0 {name=p13716 lab=_52199_/X }
C {devices/lab_pin.sym} 14660 -41870 0 1 {name=p13717 lab=_85870_/D }
C {sky130_stdcells/a21oi_4.sym} 14580 -41870 0 0 {name=X_52200_ }
C {devices/lab_pin.sym} 14490 -41730 0 0 {name=p13718 lab=_80670_/CLK }
C {devices/lab_pin.sym} 14490 -41710 0 0 {name=p13719 lab=_74602_/Y }
C {devices/lab_pin.sym} 14670 -41730 0 1 {name=p13720 lab=_83020_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -41720 0 0 {name=X_83020_ }
C {devices/lab_pin.sym} 14520 -41600 0 0 {name=p13721 lab=_59982_/C }
C {devices/lab_pin.sym} 14520 -41560 0 0 {name=p13722 lab=_63784_/C }
C {devices/lab_pin.sym} 14640 -41580 0 1 {name=p13723 lab=_80232_/X }
C {sky130_stdcells/xor2_4.sym} 14580 -41580 0 0 {name=X_80232_ }
C {devices/lab_pin.sym} 14500 -41470 0 0 {name=p13724 lab=_85682_/Q }
C {devices/lab_pin.sym} 14500 -41430 0 0 {name=p13725 lab=_53172_/X }
C {devices/lab_pin.sym} 14500 -41390 0 0 {name=p13726 lab=_53179_/Y }
C {devices/lab_pin.sym} 14660 -41430 0 1 {name=p13727 lab=_53180_/Y }
C {sky130_stdcells/o21ai_4.sym} 14580 -41430 0 0 {name=X_53180_ }
C {devices/lab_pin.sym} 14520 -41310 0 0 {name=p13728 lab=_65162_/X }
C {devices/lab_pin.sym} 14520 -41270 0 0 {name=p13729 lab=_65631_/B }
C {devices/lab_pin.sym} 14520 -41230 0 0 {name=p13730 lab=_65165_/X }
C {devices/lab_pin.sym} 14640 -41270 0 1 {name=p13731 lab=_65166_/Y }
C {sky130_stdcells/nand3_4.sym} 14580 -41270 0 0 {name=X_65166_ }
C {devices/lab_pin.sym} 14540 -41130 0 0 {name=p13732 lab=clkbuf_3_2_1_CLK/A }
C {devices/lab_pin.sym} 14620 -41130 0 1 {name=p13733 lab=clkbuf_4_5_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 14580 -41130 0 0 {name=Xclkbuf_3_2_1_CLK }
C {devices/lab_pin.sym} 14500 -41030 0 0 {name=p13734 lab=_50390_/Y }
C {devices/lab_pin.sym} 14500 -40990 0 0 {name=p13735 lab=_50380_/X }
C {devices/lab_pin.sym} 14500 -40950 0 0 {name=p13736 lab=_50391_/Y }
C {devices/lab_pin.sym} 14660 -40990 0 1 {name=p13737 lab=_50392_/Y }
C {sky130_stdcells/a21boi_4.sym} 14580 -40990 0 0 {name=X_50392_ }
C {devices/lab_pin.sym} 14520 -40880 0 0 {name=p13738 lab=_62406_/A }
C {devices/lab_pin.sym} 14520 -40840 0 0 {name=p13739 lab=_62378_/B }
C {devices/lab_pin.sym} 14520 -40800 0 0 {name=p13740 lab=_62378_/C }
C {devices/lab_pin.sym} 14520 -40760 0 0 {name=p13741 lab=_62378_/D }
C {devices/lab_pin.sym} 14640 -40820 0 1 {name=p13742 lab=_62378_/Y }
C {sky130_stdcells/nand4_4.sym} 14580 -40820 0 0 {name=X_62378_ }
C {devices/lab_pin.sym} 14500 -40690 0 0 {name=p13743 lab=_52129_/Y }
C {devices/lab_pin.sym} 14500 -40650 0 0 {name=p13744 lab=_52108_/X }
C {devices/lab_pin.sym} 14500 -40610 0 0 {name=p13745 lab=_52130_/X }
C {devices/lab_pin.sym} 14660 -40650 0 1 {name=p13746 lab=_52131_/Y }
C {sky130_stdcells/a21oi_4.sym} 14580 -40650 0 0 {name=X_52131_ }
C {devices/lab_pin.sym} 14500 -40530 0 0 {name=p13747 lab=_64115_/Y }
C {devices/lab_pin.sym} 14500 -40490 0 0 {name=p13748 lab=_64073_/X }
C {devices/lab_pin.sym} 14500 -40450 0 0 {name=p13749 lab=_64116_/Y }
C {devices/lab_pin.sym} 14660 -40490 0 1 {name=p13750 lab=_84273_/D }
C {sky130_stdcells/a21oi_4.sym} 14580 -40490 0 0 {name=X_64117_ }
C {devices/lab_pin.sym} 14520 -40370 0 0 {name=p13751 lab=_61329_/A }
C {devices/lab_pin.sym} 14520 -40330 0 0 {name=p13752 lab=_61329_/B }
C {devices/lab_pin.sym} 14520 -40290 0 0 {name=p13753 lab=_61375_/C }
C {devices/lab_pin.sym} 14640 -40330 0 1 {name=p13754 lab=_61329_/Y }
C {sky130_stdcells/nand3_4.sym} 14580 -40330 0 0 {name=X_61329_ }
C {devices/lab_pin.sym} 14520 -40200 0 0 {name=p13755 lab=_84944_/Q }
C {devices/lab_pin.sym} 14520 -40160 0 0 {name=p13756 lab=_84192_/Q }
C {devices/lab_pin.sym} 14640 -40180 0 1 {name=p13757 lab=_80163_/Y }
C {sky130_stdcells/nand2_4.sym} 14580 -40180 0 0 {name=X_80163_ }
C {devices/lab_pin.sym} 14500 -40080 0 0 {name=p13758 lab=_64846_/X }
C {devices/lab_pin.sym} 14500 -40040 0 0 {name=p13759 lab=_85550_/Q }
C {devices/lab_pin.sym} 14500 -40000 0 0 {name=p13760 lab=_64919_/X }
C {devices/lab_pin.sym} 14500 -39960 0 0 {name=p13761 lab=_65096_/X }
C {devices/lab_pin.sym} 14660 -40020 0 1 {name=p13762 lab=_65097_/X }
C {sky130_stdcells/a211o_4.sym} 14580 -40020 0 0 {name=X_65097_ }
C {devices/lab_pin.sym} 14520 -39880 0 0 {name=p13763 lab=_69971_/X }
C {devices/lab_pin.sym} 14520 -39840 0 0 {name=p13764 lab=_69973_/X }
C {devices/lab_pin.sym} 14640 -39860 0 1 {name=p13765 lab=_69974_/Y }
C {sky130_stdcells/nand2_4.sym} 14580 -39860 0 0 {name=X_69974_ }
C {devices/lab_pin.sym} 14520 -39750 0 0 {name=p13766 lab=_50360_/A }
C {devices/lab_pin.sym} 14520 -39710 0 0 {name=p13767 lab=_52098_/B }
C {devices/lab_pin.sym} 14520 -39670 0 0 {name=p13768 lab=_52033_/X }
C {devices/lab_pin.sym} 14640 -39710 0 1 {name=p13769 lab=_52062_/X }
C {sky130_stdcells/and3_4.sym} 14580 -39710 0 0 {name=X_52062_ }
C {devices/lab_pin.sym} 14500 -39600 0 0 {name=p13770 lab=_87081_/Q }
C {devices/lab_pin.sym} 14500 -39560 0 0 {name=p13771 lab=_68832_/X }
C {devices/lab_pin.sym} 14500 -39520 0 0 {name=p13772 lab=_68875_/X }
C {devices/lab_pin.sym} 14500 -39480 0 0 {name=p13773 lab=_68924_/X }
C {devices/lab_pin.sym} 14660 -39540 0 1 {name=p13774 lab=_68925_/X }
C {sky130_stdcells/a211o_4.sym} 14580 -39540 0 0 {name=X_68925_ }
C {devices/lab_pin.sym} 14540 -39390 0 0 {name=p13775 lab=_63741_/A }
C {devices/lab_pin.sym} 14620 -39390 0 1 {name=p13776 lab=_64048_/X }
C {sky130_stdcells/buf_2.sym} 14580 -39390 0 0 {name=X_64048_ }
C {devices/lab_pin.sym} 14490 -39270 0 0 {name=p13777 lab=_86530_/CLK }
C {devices/lab_pin.sym} 14490 -39250 0 0 {name=p13778 lab=_84971_/D }
C {devices/lab_pin.sym} 14670 -39270 0 1 {name=p13779 lab=_84971_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -39260 0 0 {name=X_84971_ }
C {devices/lab_pin.sym} 14520 -39140 0 0 {name=p13780 lab=_80071_/X }
C {devices/lab_pin.sym} 14520 -39100 0 0 {name=p13781 lab=_80084_/X }
C {devices/lab_pin.sym} 14640 -39120 0 1 {name=p13782 lab=_80094_/Y }
C {sky130_stdcells/nand2_4.sym} 14580 -39120 0 0 {name=X_80094_ }
C {devices/lab_pin.sym} 14540 -38990 0 0 {name=p13783 lab=_51013_/A }
C {devices/lab_pin.sym} 14620 -38990 0 1 {name=p13784 lab=_51029_/B }
C {sky130_stdcells/buf_2.sym} 14580 -38990 0 0 {name=X_51013_ }
C {devices/lab_pin.sym} 14490 -38870 0 0 {name=p13785 lab=_86711_/CLK }
C {devices/lab_pin.sym} 14490 -38850 0 0 {name=p13786 lab=_86710_/D }
C {devices/lab_pin.sym} 14670 -38870 0 1 {name=p13787 lab=_58700_/A }
C {sky130_stdcells/dfxtp_4.sym} 14580 -38860 0 0 {name=X_86710_ }
C {devices/lab_pin.sym} 14490 -38730 0 0 {name=p13788 lab=_83932_/CLK }
C {devices/lab_pin.sym} 14490 -38710 0 0 {name=p13789 lab=_69464_/X }
C {devices/lab_pin.sym} 14670 -38730 0 1 {name=p13790 lab=_83922_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -38720 0 0 {name=X_83922_ }
C {devices/lab_pin.sym} 14500 -38610 0 0 {name=p13791 lab=_55675_/X }
C {devices/lab_pin.sym} 14500 -38570 0 0 {name=p13792 lab=_56869_/Y }
C {devices/lab_pin.sym} 14500 -38530 0 0 {name=p13793 lab=_56691_/A }
C {devices/lab_pin.sym} 14660 -38570 0 1 {name=p13794 lab=_56870_/Y }
C {sky130_stdcells/a21oi_4.sym} 14580 -38570 0 0 {name=X_56870_ }
C {devices/lab_pin.sym} 14500 -38460 0 0 {name=p13795 lab=_68666_/X }
C {devices/lab_pin.sym} 14500 -38420 0 0 {name=p13796 lab=_68612_/X }
C {devices/lab_pin.sym} 14500 -38380 0 0 {name=p13797 lab=_68847_/Y }
C {devices/lab_pin.sym} 14500 -38340 0 0 {name=p13798 lab=_68855_/Y }
C {devices/lab_pin.sym} 14660 -38400 0 1 {name=p13799 lab=_68856_/X }
C {sky130_stdcells/a211o_4.sym} 14580 -38400 0 0 {name=X_68856_ }
C {devices/lab_pin.sym} 14490 -38250 0 0 {name=p13800 lab=_87950_/CLK }
C {devices/lab_pin.sym} 14490 -38230 0 0 {name=p13801 lab=_42842_/X }
C {devices/lab_pin.sym} 14670 -38250 0 1 {name=p13802 lab=_87690_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -38240 0 0 {name=X_87690_ }
C {devices/lab_pin.sym} 14520 -38120 0 0 {name=p13803 lab=_55817_/A }
C {devices/lab_pin.sym} 14520 -38080 0 0 {name=p13804 lab=_55821_/B }
C {devices/lab_pin.sym} 14640 -38100 0 1 {name=p13805 lab=_55821_/X }
C {sky130_stdcells/and2_4.sym} 14580 -38100 0 0 {name=X_55821_ }
C {devices/lab_pin.sym} 14490 -37970 0 0 {name=p13806 lab=_86640_/CLK }
C {devices/lab_pin.sym} 14490 -37950 0 0 {name=p13807 lab=_47381_/Y }
C {devices/lab_pin.sym} 14670 -37970 0 1 {name=p13808 lab=_86641_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -37960 0 0 {name=X_86641_ }
C {devices/lab_pin.sym} 14540 -37830 0 0 {name=p13809 lab=_68637_/A }
C {devices/lab_pin.sym} 14620 -37830 0 1 {name=p13810 lab=_67901_/A }
C {sky130_stdcells/buf_2.sym} 14580 -37830 0 0 {name=X_67807_ }
C {devices/lab_pin.sym} 14490 -37710 0 0 {name=p13811 lab=_86988_/CLK }
C {devices/lab_pin.sym} 14490 -37690 0 0 {name=p13812 lab=_70088_/X }
C {devices/lab_pin.sym} 14670 -37710 0 1 {name=p13813 lab=_83853_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -37700 0 0 {name=X_83853_ }
C {devices/lab_pin.sym} 14500 -37590 0 0 {name=p13814 lab=_68783_/X }
C {devices/lab_pin.sym} 14500 -37550 0 0 {name=p13815 lab=_68786_/X }
C {devices/lab_pin.sym} 14500 -37510 0 0 {name=p13816 lab=_68737_/X }
C {devices/lab_pin.sym} 14660 -37550 0 1 {name=p13817 lab=_68787_/Y }
C {sky130_stdcells/a21oi_4.sym} 14580 -37550 0 0 {name=X_68787_ }
C {devices/lab_pin.sym} 14520 -37420 0 0 {name=p13818 lab=_65999_/A }
C {devices/lab_pin.sym} 14520 -37380 0 0 {name=p13819 lab=_65999_/B }
C {devices/lab_pin.sym} 14640 -37400 0 1 {name=p13820 lab=_65999_/Y }
C {sky130_stdcells/nand2_4.sym} 14580 -37400 0 0 {name=X_65999_ }
C {devices/lab_pin.sym} 14540 -37270 0 0 {name=p13821 lab=_58984_/A }
C {devices/lab_pin.sym} 14620 -37270 0 1 {name=p13822 lab=_58557_/B }
C {sky130_stdcells/buf_2.sym} 14580 -37270 0 0 {name=X_58540_ }
C {devices/lab_pin.sym} 14490 -37150 0 0 {name=p13823 lab=_82803_/CLK }
C {devices/lab_pin.sym} 14490 -37130 0 0 {name=p13824 lab=_82836_/Q }
C {devices/lab_pin.sym} 14670 -37150 0 1 {name=p13825 lab=_82804_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -37140 0 0 {name=X_82804_ }
C {devices/lab_pin.sym} 14520 -37020 0 0 {name=p13826 lab=_55749_/X }
C {devices/lab_pin.sym} 14520 -36980 0 0 {name=p13827 lab=_55752_/B }
C {devices/lab_pin.sym} 14640 -37000 0 1 {name=p13828 lab=_55752_/Y }
C {sky130_stdcells/nand2_4.sym} 14580 -37000 0 0 {name=X_55752_ }
C {devices/lab_pin.sym} 14500 -36900 0 0 {name=p13829 lab=_87906_/Q }
C {devices/lab_pin.sym} 14500 -36860 0 0 {name=p13830 lab=_67713_/X }
C {devices/lab_pin.sym} 14500 -36820 0 0 {name=p13831 lab=_67641_/X }
C {devices/lab_pin.sym} 14500 -36780 0 0 {name=p13832 lab=_67737_/X }
C {devices/lab_pin.sym} 14660 -36840 0 1 {name=p13833 lab=_67738_/X }
C {sky130_stdcells/a211o_4.sym} 14580 -36840 0 0 {name=X_67738_ }
C {devices/lab_pin.sym} 14490 -36690 0 0 {name=p13834 lab=_86570_/CLK }
C {devices/lab_pin.sym} 14490 -36670 0 0 {name=p13835 lab=_86572_/D }
C {devices/lab_pin.sym} 14670 -36690 0 1 {name=p13836 lab=_66211_/B }
C {sky130_stdcells/dfxtp_4.sym} 14580 -36680 0 0 {name=X_86572_ }
C {devices/lab_pin.sym} 14500 -36570 0 0 {name=p13837 lab=_52960_/Y }
C {devices/lab_pin.sym} 14500 -36530 0 0 {name=p13838 lab=_52946_/X }
C {devices/lab_pin.sym} 14500 -36490 0 0 {name=p13839 lab=_52963_/X }
C {devices/lab_pin.sym} 14660 -36530 0 1 {name=p13840 lab=_85723_/D }
C {sky130_stdcells/a21oi_4.sym} 14580 -36530 0 0 {name=X_52964_ }
C {devices/lab_pin.sym} 14490 -36390 0 0 {name=p13841 lab=_85953_/CLK }
C {devices/lab_pin.sym} 14490 -36370 0 0 {name=p13842 lab=_70376_/Y }
C {devices/lab_pin.sym} 14670 -36390 0 1 {name=p13843 lab=_83784_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -36380 0 0 {name=X_83784_ }
C {devices/lab_pin.sym} 14490 -36250 0 0 {name=p13844 lab=_85315_/CLK }
C {devices/lab_pin.sym} 14490 -36230 0 0 {name=p13845 lab=_84204_/Q }
C {devices/lab_pin.sym} 14670 -36250 0 1 {name=p13846 lab=_80996_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -36240 0 0 {name=X_80996_ }
C {devices/lab_pin.sym} 14490 -36110 0 0 {name=p13847 lab=_88056_/CLK }
C {devices/lab_pin.sym} 14490 -36090 0 0 {name=p13848 lab=_88311_/D }
C {devices/lab_pin.sym} 14670 -36110 0 1 {name=p13849 lab=_69935_/B }
C {sky130_stdcells/dfxtp_4.sym} 14580 -36100 0 0 {name=X_88311_ }
C {devices/lab_pin.sym} 14540 -35970 0 0 {name=p13850 lab=_54729_/A }
C {devices/lab_pin.sym} 14620 -35970 0 1 {name=p13851 lab=_54703_/X }
C {sky130_stdcells/buf_2.sym} 14580 -35970 0 0 {name=X_54703_ }
C {devices/lab_pin.sym} 14490 -35850 0 0 {name=p13852 lab=_85815_/CLK }
C {devices/lab_pin.sym} 14490 -35830 0 0 {name=p13853 lab=_54012_/Y }
C {devices/lab_pin.sym} 14670 -35850 0 1 {name=p13854 lab=_85523_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -35840 0 0 {name=X_85523_ }
C {devices/lab_pin.sym} 14500 -35730 0 0 {name=p13855 lab=_51912_/Y }
C {devices/lab_pin.sym} 14500 -35690 0 0 {name=p13856 lab=_51904_/X }
C {devices/lab_pin.sym} 14500 -35650 0 0 {name=p13857 lab=_51914_/X }
C {devices/lab_pin.sym} 14660 -35690 0 1 {name=p13858 lab=_51915_/Y }
C {sky130_stdcells/a21oi_4.sym} 14580 -35690 0 0 {name=X_51915_ }
C {devices/lab_pin.sym} 14490 -35550 0 0 {name=p13859 lab=_84177_/CLK }
C {devices/lab_pin.sym} 14490 -35530 0 0 {name=p13860 lab=_82735_/D }
C {devices/lab_pin.sym} 14670 -35550 0 1 {name=p13861 lab=_82735_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -35540 0 0 {name=X_82735_ }
C {devices/lab_pin.sym} 14500 -35430 0 0 {name=p13862 lab=_58467_/X }
C {devices/lab_pin.sym} 14500 -35390 0 0 {name=p13863 lab=_58468_/Y }
C {devices/lab_pin.sym} 14500 -35350 0 0 {name=p13864 lab=_58470_/Y }
C {devices/lab_pin.sym} 14660 -35390 0 1 {name=p13865 lab=_84841_/D }
C {sky130_stdcells/a21oi_4.sym} 14580 -35390 0 0 {name=X_58471_ }
C {devices/lab_pin.sym} 14520 -35280 0 0 {name=p13866 lab=_55683_/A }
C {devices/lab_pin.sym} 14520 -35240 0 0 {name=p13867 lab=_55683_/B }
C {devices/lab_pin.sym} 14520 -35200 0 0 {name=p13868 lab=_55429_/Y }
C {devices/lab_pin.sym} 14520 -35160 0 0 {name=p13869 lab=_55683_/D }
C {devices/lab_pin.sym} 14640 -35220 0 1 {name=p13870 lab=_55683_/Y }
C {sky130_stdcells/nand4_4.sym} 14580 -35220 0 0 {name=X_55683_ }
C {devices/lab_pin.sym} 14500 -35090 0 0 {name=p13871 lab=_67666_/X }
C {devices/lab_pin.sym} 14500 -35050 0 0 {name=p13872 lab=_67668_/X }
C {devices/lab_pin.sym} 14500 -35010 0 0 {name=p13873 lab=_67619_/X }
C {devices/lab_pin.sym} 14660 -35050 0 1 {name=p13874 lab=_67674_/A }
C {sky130_stdcells/a21o_4.sym} 14580 -35050 0 0 {name=X_67669_ }
C {devices/lab_pin.sym} 14520 -34940 0 0 {name=p13875 lab=_52895_/A }
C {devices/lab_pin.sym} 14520 -34900 0 0 {name=p13876 lab=_52879_/B }
C {devices/lab_pin.sym} 14520 -34860 0 0 {name=p13877 lab=_52872_/C }
C {devices/lab_pin.sym} 14520 -34820 0 0 {name=p13878 lab=_52895_/D }
C {devices/lab_pin.sym} 14640 -34880 0 1 {name=p13879 lab=_52895_/X }
C {sky130_stdcells/and4_4.sym} 14580 -34880 0 0 {name=X_52895_ }
C {devices/lab_pin.sym} 14540 -34730 0 0 {name=p13880 lab=clkbuf_9_180_0_CLK/X }
C {devices/lab_pin.sym} 14620 -34730 0 1 {name=p13881 lab=_84930_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 14580 -34730 0 0 {name=Xclkbuf_10_360_0_CLK }
C {devices/lab_pin.sym} 14520 -34630 0 0 {name=p13882 lab=_56724_/A }
C {devices/lab_pin.sym} 14520 -34590 0 0 {name=p13883 lab=_57445_/B }
C {devices/lab_pin.sym} 14520 -34550 0 0 {name=p13884 lab=_56723_/Y }
C {devices/lab_pin.sym} 14640 -34590 0 1 {name=p13885 lab=_57422_/Y }
C {sky130_stdcells/nand3_4.sym} 14580 -34590 0 0 {name=X_57422_ }
C {devices/lab_pin.sym} 14500 -34470 0 0 {name=p13886 lab=_81390_/D }
C {devices/lab_pin.sym} 14500 -34430 0 0 {name=p13887 lab=_69367_/X }
C {devices/lab_pin.sym} 14500 -34390 0 0 {name=p13888 lab=_69407_/X }
C {devices/lab_pin.sym} 14660 -34430 0 1 {name=p13889 lab=_83926_/D }
C {sky130_stdcells/a21bo_4.sym} 14580 -34430 0 0 {name=X_69408_ }
C {devices/lab_pin.sym} 14490 -34290 0 0 {name=p13890 lab=_82906_/CLK }
C {devices/lab_pin.sym} 14490 -34270 0 0 {name=p13891 lab=_88242_/D }
C {devices/lab_pin.sym} 14670 -34290 0 1 {name=p13892 lab=_67373_/B }
C {sky130_stdcells/dfxtp_4.sym} 14580 -34280 0 0 {name=X_88242_ }
C {devices/lab_pin.sym} 14520 -34180 0 0 {name=p13893 lab=_54625_/A }
C {devices/lab_pin.sym} 14520 -34140 0 0 {name=p13894 lab=_54645_/B }
C {devices/lab_pin.sym} 14520 -34100 0 0 {name=p13895 lab=_54618_/X }
C {devices/lab_pin.sym} 14520 -34060 0 0 {name=p13896 lab=_54634_/D }
C {devices/lab_pin.sym} 14640 -34120 0 1 {name=p13897 lab=_54634_/X }
C {sky130_stdcells/and4_4.sym} 14580 -34120 0 0 {name=X_54634_ }
C {devices/lab_pin.sym} 14490 -33970 0 0 {name=p13898 lab=_85778_/CLK }
C {devices/lab_pin.sym} 14490 -33950 0 0 {name=p13899 lab=_85454_/D }
C {devices/lab_pin.sym} 14670 -33970 0 1 {name=p13900 lab=_85454_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -33960 0 0 {name=X_85454_ }
C {devices/lab_pin.sym} 14540 -33830 0 0 {name=p13901 lab=_51789_/A }
C {devices/lab_pin.sym} 14620 -33830 0 1 {name=p13902 lab=_51846_/X }
C {sky130_stdcells/buf_2.sym} 14580 -33830 0 0 {name=X_51846_ }
C {devices/lab_pin.sym} 14500 -33730 0 0 {name=p13903 lab=_70664_/X }
C {devices/lab_pin.sym} 14500 -33690 0 0 {name=p13904 lab=_47480_/A }
C {devices/lab_pin.sym} 14500 -33650 0 0 {name=p13905 lab=_70679_/Y }
C {devices/lab_pin.sym} 14660 -33690 0 1 {name=p13906 lab=_83726_/D }
C {sky130_stdcells/a21o_4.sym} 14580 -33690 0 0 {name=X_70680_ }
C {devices/lab_pin.sym} 14490 -33550 0 0 {name=p13907 lab=_82879_/CLK }
C {devices/lab_pin.sym} 14490 -33530 0 0 {name=p13908 lab=_82710_/Q }
C {devices/lab_pin.sym} 14670 -33550 0 1 {name=p13909 lab=_82666_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -33540 0 0 {name=X_82666_ }
C {devices/lab_pin.sym} 14540 -33410 0 0 {name=p13910 lab=clkbuf_9_495_0_CLK/X }
C {devices/lab_pin.sym} 14620 -33410 0 1 {name=p13911 lab=_85561_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 14580 -33410 0 0 {name=Xclkbuf_10_990_0_CLK }
C {devices/lab_pin.sym} 14490 -33290 0 0 {name=p13912 lab=_84403_/CLK }
C {devices/lab_pin.sym} 14490 -33270 0 0 {name=p13913 lab=_84405_/D }
C {devices/lab_pin.sym} 14670 -33290 0 1 {name=p13914 lab=_76981_/B }
C {sky130_stdcells/dfxtp_4.sym} 14580 -33280 0 0 {name=X_84405_ }
C {devices/lab_pin.sym} 14500 -33170 0 0 {name=p13915 lab=_56885_/A }
C {devices/lab_pin.sym} 14500 -33130 0 0 {name=p13916 lab=_56884_/Y }
C {devices/lab_pin.sym} 14500 -33090 0 0 {name=p13917 lab=_44287_/X }
C {devices/lab_pin.sym} 14660 -33130 0 1 {name=p13918 lab=_57353_/Y }
C {sky130_stdcells/a21oi_4.sym} 14580 -33130 0 0 {name=X_57353_ }
C {devices/lab_pin.sym} 14490 -32990 0 0 {name=p13919 lab=_81260_/CLK }
C {devices/lab_pin.sym} 14490 -32970 0 0 {name=p13920 lab=_81617_/D }
C {devices/lab_pin.sym} 14670 -32990 0 1 {name=p13921 lab=_81809_/D }
C {sky130_stdcells/dfxtp_4.sym} 14580 -32980 0 0 {name=X_81617_ }
C {devices/lab_pin.sym} 14500 -32870 0 0 {name=p13922 lab=_83931_/Q }
C {devices/lab_pin.sym} 14500 -32830 0 0 {name=p13923 lab=_69299_/X }
C {devices/lab_pin.sym} 14500 -32790 0 0 {name=p13924 lab=_69338_/X }
C {devices/lab_pin.sym} 14660 -32830 0 1 {name=p13925 lab=_69339_/X }
C {sky130_stdcells/a21bo_4.sym} 14580 -32830 0 0 {name=X_69339_ }
C {devices/lab_pin.sym} 14490 -32690 0 0 {name=p13926 lab=_87472_/CLK }
C {devices/lab_pin.sym} 14490 -32670 0 0 {name=p13927 lab=_88173_/D }
C {devices/lab_pin.sym} 14670 -32690 0 1 {name=p13928 lab=_67482_/B }
C {sky130_stdcells/dfxtp_4.sym} 14580 -32680 0 0 {name=X_88173_ }
C {devices/lab_pin.sym} 14520 -32580 0 0 {name=p13929 lab=_54565_/A }
C {devices/lab_pin.sym} 14520 -32540 0 0 {name=p13930 lab=_54559_/B }
C {devices/lab_pin.sym} 14520 -32500 0 0 {name=p13931 lab=_54565_/C }
C {devices/lab_pin.sym} 14520 -32460 0 0 {name=p13932 lab=_54565_/D }
C {devices/lab_pin.sym} 14640 -32520 0 1 {name=p13933 lab=_54565_/X }
C {sky130_stdcells/and4_4.sym} 14580 -32520 0 0 {name=X_54565_ }
C {devices/lab_pin.sym} 14490 -32370 0 0 {name=p13934 lab=_85379_/CLK }
C {devices/lab_pin.sym} 14490 -32350 0 0 {name=p13935 lab=_54749_/Y }
C {devices/lab_pin.sym} 14670 -32370 0 1 {name=p13936 lab=_85385_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -32360 0 0 {name=X_85385_ }
C {devices/lab_pin.sym} 14520 -32260 0 0 {name=p13937 lab=_51794_/A }
C {devices/lab_pin.sym} 14520 -32220 0 0 {name=p13938 lab=_51782_/B }
C {devices/lab_pin.sym} 14520 -32180 0 0 {name=p13939 lab=_51755_/X }
C {devices/lab_pin.sym} 14520 -32140 0 0 {name=p13940 lab=_51777_/D }
C {devices/lab_pin.sym} 14640 -32200 0 1 {name=p13941 lab=_51777_/X }
C {sky130_stdcells/and4_4.sym} 14580 -32200 0 0 {name=X_51777_ }
C {devices/lab_pin.sym} 14490 -32050 0 0 {name=p13942 lab=_82879_/CLK }
C {devices/lab_pin.sym} 14490 -32030 0 0 {name=p13943 lab=_78838_/B }
C {devices/lab_pin.sym} 14670 -32050 0 1 {name=p13944 lab=_82565_/D }
C {sky130_stdcells/dfxtp_4.sym} 14580 -32040 0 0 {name=X_82597_ }
C {devices/lab_pin.sym} 14540 -31910 0 0 {name=p13945 lab=clkbuf_8_240_0_CLK/X }
C {devices/lab_pin.sym} 14620 -31910 0 1 {name=p13946 lab=clkbuf_9_481_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 14580 -31910 0 0 {name=Xclkbuf_9_481_0_CLK }
C {devices/lab_pin.sym} 14500 -31810 0 0 {name=p13947 lab=_56035_/X }
C {devices/lab_pin.sym} 14500 -31770 0 0 {name=p13948 lab=_56290_/X }
C {devices/lab_pin.sym} 14500 -31730 0 0 {name=p13949 lab=_56303_/Y }
C {devices/lab_pin.sym} 14660 -31770 0 1 {name=p13950 lab=_85243_/D }
C {sky130_stdcells/o21ai_4.sym} 14580 -31770 0 0 {name=X_56304_ }
C {devices/lab_pin.sym} 14490 -31630 0 0 {name=p13951 lab=_87137_/CLK }
C {devices/lab_pin.sym} 14490 -31610 0 0 {name=p13952 lab=_87124_/D }
C {devices/lab_pin.sym} 14670 -31630 0 1 {name=p13953 lab=_87124_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -31620 0 0 {name=X_87124_ }
C {devices/lab_pin.sym} 14540 -31490 0 0 {name=p13954 lab=_41486_/A }
C {devices/lab_pin.sym} 14620 -31490 0 1 {name=p13955 lab=_41530_/X }
C {sky130_stdcells/buf_2.sym} 14580 -31490 0 0 {name=X_41530_ }
C {devices/lab_pin.sym} 14520 -31380 0 0 {name=p13956 lab=_53503_/X }
C {devices/lab_pin.sym} 14520 -31340 0 0 {name=p13957 lab=_53516_/B }
C {devices/lab_pin.sym} 14640 -31360 0 1 {name=p13958 lab=_53516_/Y }
C {sky130_stdcells/nand2_4.sym} 14580 -31360 0 0 {name=X_53516_ }
C {devices/lab_pin.sym} 14500 -31250 0 0 {name=p13959 lab=_72339_/X }
C {devices/lab_pin.sym} 14500 -31210 0 0 {name=p13960 lab=_85326_/Q }
C {devices/lab_pin.sym} 14500 -31170 0 0 {name=p13961 lab=_72255_/X }
C {devices/lab_pin.sym} 14660 -31210 0 1 {name=p13962 lab=_72350_/X }
C {sky130_stdcells/o21a_4.sym} 14580 -31210 0 0 {name=X_72350_ }
C {devices/lab_pin.sym} 14490 -31070 0 0 {name=p13963 lab=_84263_/CLK }
C {devices/lab_pin.sym} 14490 -31050 0 0 {name=p13964 lab=_84336_/D }
C {devices/lab_pin.sym} 14670 -31070 0 1 {name=p13965 lab=_79245_/A }
C {sky130_stdcells/dfxtp_4.sym} 14580 -31060 0 0 {name=X_84336_ }
C {devices/lab_pin.sym} 14540 -30930 0 0 {name=p13966 lab=_50728_/A }
C {devices/lab_pin.sym} 14620 -30930 0 1 {name=p13967 lab=_50799_/A }
C {sky130_stdcells/buf_2.sym} 14580 -30930 0 0 {name=X_50728_ }
C {devices/lab_pin.sym} 14490 -30810 0 0 {name=p13968 lab=_81352_/CLK }
C {devices/lab_pin.sym} 14490 -30790 0 0 {name=p13969 lab=_76745_/X }
C {devices/lab_pin.sym} 14670 -30810 0 1 {name=p13970 lab=_81548_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -30800 0 0 {name=X_81548_ }
C {devices/lab_pin.sym} 14520 -30690 0 0 {name=p13971 lab=_57284_/A }
C {devices/lab_pin.sym} 14520 -30650 0 0 {name=p13972 lab=_57340_/C }
C {devices/lab_pin.sym} 14520 -30610 0 0 {name=p13973 lab=_56715_/Y }
C {devices/lab_pin.sym} 14640 -30650 0 1 {name=p13974 lab=_57284_/Y }
C {sky130_stdcells/nand3_4.sym} 14580 -30650 0 0 {name=X_57284_ }
C {devices/lab_pin.sym} 14520 -30520 0 0 {name=p13975 lab=_54486_/X }
C {devices/lab_pin.sym} 14520 -30480 0 0 {name=p13976 lab=_47016_/A }
C {devices/lab_pin.sym} 14640 -30500 0 1 {name=p13977 lab=_54496_/Y }
C {sky130_stdcells/nand2_4.sym} 14580 -30500 0 0 {name=X_54496_ }
C {devices/lab_pin.sym} 14540 -30370 0 0 {name=p13978 lab=clkbuf_9_187_0_CLK/X }
C {devices/lab_pin.sym} 14620 -30370 0 1 {name=p13979 lab=_85754_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 14580 -30370 0 0 {name=Xclkbuf_10_375_0_CLK }
C {devices/lab_pin.sym} 14500 -30270 0 0 {name=p13980 lab=_59013_/X }
C {devices/lab_pin.sym} 14500 -30230 0 0 {name=p13981 lab=_85759_/Q }
C {devices/lab_pin.sym} 14500 -30190 0 0 {name=p13982 lab=_58928_/X }
C {devices/lab_pin.sym} 14660 -30230 0 1 {name=p13983 lab=_59023_/X }
C {sky130_stdcells/o21a_4.sym} 14580 -30230 0 0 {name=X_59023_ }
C {devices/lab_pin.sym} 14500 -30110 0 0 {name=p13984 lab=_48024_/B }
C {devices/lab_pin.sym} 14500 -30070 0 0 {name=p13985 lab=_71290_/X }
C {devices/lab_pin.sym} 14500 -30030 0 0 {name=p13986 lab=_71300_/Y }
C {devices/lab_pin.sym} 14660 -30070 0 1 {name=p13987 lab=_83543_/D }
C {sky130_stdcells/o21ai_4.sym} 14580 -30070 0 0 {name=X_71301_ }
C {devices/lab_pin.sym} 14520 -29950 0 0 {name=p13988 lab=_56233_/A }
C {devices/lab_pin.sym} 14520 -29910 0 0 {name=p13989 lab=_56243_/B }
C {devices/lab_pin.sym} 14520 -29870 0 0 {name=p13990 lab=_85265_/Q }
C {devices/lab_pin.sym} 14640 -29910 0 1 {name=p13991 lab=_56235_/Y }
C {sky130_stdcells/nand3_4.sym} 14580 -29910 0 0 {name=X_56235_ }
C {devices/lab_pin.sym} 14540 -29770 0 0 {name=p13992 lab=_41460_/Y }
C {devices/lab_pin.sym} 14620 -29770 0 1 {name=p13993 lab=_41461_/X }
C {sky130_stdcells/buf_2.sym} 14580 -29770 0 0 {name=X_41461_ }
C {devices/lab_pin.sym} 14490 -29650 0 0 {name=p13994 lab=_88060_/CLK }
C {devices/lab_pin.sym} 14490 -29630 0 0 {name=p13995 lab=_87055_/D }
C {devices/lab_pin.sym} 14670 -29650 0 1 {name=p13996 lab=_87055_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -29640 0 0 {name=X_87055_ }
C {devices/lab_pin.sym} 14540 -29510 0 0 {name=p13997 lab=_53447_/A }
C {devices/lab_pin.sym} 14620 -29510 0 1 {name=p13998 lab=_53661_/A }
C {sky130_stdcells/buf_2.sym} 14580 -29510 0 0 {name=X_53447_ }
C {devices/lab_pin.sym} 14500 -29410 0 0 {name=p13999 lab=_72143_/X }
C {devices/lab_pin.sym} 14500 -29370 0 0 {name=p14000 lab=_85364_/Q }
C {devices/lab_pin.sym} 14500 -29330 0 0 {name=p14001 lab=_72280_/X }
C {devices/lab_pin.sym} 14660 -29370 0 1 {name=p14002 lab=_72281_/Y }
C {sky130_stdcells/o21ai_4.sym} 14580 -29370 0 0 {name=X_72281_ }
C {devices/lab_pin.sym} 14490 -29230 0 0 {name=p14003 lab=_84652_/CLK }
C {devices/lab_pin.sym} 14490 -29210 0 0 {name=p14004 lab=_64188_/Y }
C {devices/lab_pin.sym} 14670 -29230 0 1 {name=p14005 lab=_79908_/B }
C {sky130_stdcells/dfxtp_4.sym} 14580 -29220 0 0 {name=X_84267_ }
C {devices/lab_pin.sym} 14540 -29090 0 0 {name=p14006 lab=_50538_/A }
C {devices/lab_pin.sym} 14620 -29090 0 1 {name=p14007 lab=_50668_/C }
C {sky130_stdcells/buf_2.sym} 14580 -29090 0 0 {name=X_50659_ }
C {devices/lab_pin.sym} 14490 -28970 0 0 {name=p14008 lab=_81575_/CLK }
C {devices/lab_pin.sym} 14490 -28950 0 0 {name=p14009 lab=_81479_/D }
C {devices/lab_pin.sym} 14670 -28970 0 1 {name=p14010 lab=_76691_/A }
C {sky130_stdcells/dfxtp_4.sym} 14580 -28960 0 0 {name=X_81479_ }
C {devices/lab_pin.sym} 14500 -28870 0 0 {name=p14011 lab=_43031_/X }
C {devices/lab_pin.sym} 14500 -28830 0 0 {name=p14012 lab=_43125_/X }
C {devices/lab_pin.sym} 14500 -28790 0 0 {name=p14013 lab=_40921_/X }
C {devices/lab_pin.sym} 14500 -28750 0 0 {name=p14014 lab=_43199_/Y }
C {devices/lab_pin.sym} 14500 -28710 0 0 {name=p14015 lab=_43021_/X }
C {devices/lab_pin.sym} 14660 -28790 0 1 {name=p14016 lab=_87542_/D }
C {sky130_stdcells/o32ai_4.sym} 14580 -28790 0 0 {name=X_43200_ }
C {devices/lab_pin.sym} 14500 -28650 0 0 {name=p14017 lab=_74015_/X }
C {devices/lab_pin.sym} 14500 -28610 0 0 {name=p14018 lab=_74018_/X }
C {devices/lab_pin.sym} 14500 -28570 0 0 {name=p14019 lab=_74019_/X }
C {devices/lab_pin.sym} 14660 -28610 0 1 {name=p14020 lab=_74025_/A }
C {sky130_stdcells/a21o_4.sym} 14580 -28610 0 0 {name=X_74020_ }
C {devices/lab_pin.sym} 14490 -28470 0 0 {name=p14021 lab=_86005_/CLK }
C {devices/lab_pin.sym} 14490 -28450 0 0 {name=p14022 lab=_86006_/D }
C {devices/lab_pin.sym} 14670 -28470 0 1 {name=p14023 lab=_86006_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -28460 0 0 {name=X_86006_ }
C {devices/lab_pin.sym} 14500 -28360 0 0 {name=p14024 lab=_40408_/X }
C {devices/lab_pin.sym} 14500 -28320 0 0 {name=p14025 lab=_40410_/X }
C {devices/lab_pin.sym} 14500 -28280 0 0 {name=p14026 lab=_88395_/Q }
C {devices/lab_pin.sym} 14500 -28240 0 0 {name=p14027 lab=_40411_/X }
C {devices/lab_pin.sym} 14660 -28300 0 1 {name=p14028 lab=_88395_/D }
C {sky130_stdcells/a2bb2o_4.sym} 14580 -28300 0 0 {name=X_40412_ }
C {devices/lab_pin.sym} 14520 -28170 0 0 {name=p14029 lab=_71232_/A }
C {devices/lab_pin.sym} 14520 -28130 0 0 {name=p14030 lab=_71232_/B }
C {devices/lab_pin.sym} 14520 -28090 0 0 {name=p14031 lab=_71232_/C }
C {devices/lab_pin.sym} 14640 -28130 0 1 {name=p14032 lab=_71232_/Y }
C {sky130_stdcells/nand3_4.sym} 14580 -28130 0 0 {name=X_71232_ }
C {devices/lab_pin.sym} 14490 -27990 0 0 {name=p14033 lab=_83218_/CLK }
C {devices/lab_pin.sym} 14490 -27970 0 0 {name=p14034 lab=_83218_/D }
C {devices/lab_pin.sym} 14670 -27990 0 1 {name=p14035 lab=_79267_/B }
C {sky130_stdcells/dfxtp_4.sym} 14580 -27980 0 0 {name=X_83218_ }
C {devices/lab_pin.sym} 14540 -27850 0 0 {name=p14036 lab=_64713_/A }
C {devices/lab_pin.sym} 14620 -27850 0 1 {name=p14037 lab=_64817_/A }
C {sky130_stdcells/buf_2.sym} 14580 -27850 0 0 {name=X_44180_ }
C {devices/lab_pin.sym} 14500 -27750 0 0 {name=p14038 lab=_56142_/X }
C {devices/lab_pin.sym} 14500 -27710 0 0 {name=p14039 lab=_56164_/X }
C {devices/lab_pin.sym} 14500 -27670 0 0 {name=p14040 lab=_56165_/Y }
C {devices/lab_pin.sym} 14660 -27710 0 1 {name=p14041 lab=_85284_/D }
C {sky130_stdcells/o21ai_4.sym} 14580 -27710 0 0 {name=X_56166_ }
C {devices/lab_pin.sym} 14500 -27590 0 0 {name=p14042 lab=_41324_/X }
C {devices/lab_pin.sym} 14500 -27550 0 0 {name=p14043 lab=_82893_/Q }
C {devices/lab_pin.sym} 14500 -27510 0 0 {name=p14044 lab=_41391_/X }
C {devices/lab_pin.sym} 14660 -27550 0 1 {name=p14045 lab=_41392_/Y }
C {sky130_stdcells/o21ai_4.sym} 14580 -27550 0 0 {name=X_41392_ }
C {devices/lab_pin.sym} 14540 -27410 0 0 {name=p14046 lab=_53351_/A }
C {devices/lab_pin.sym} 14620 -27410 0 1 {name=p14047 lab=_53378_/X }
C {sky130_stdcells/buf_2.sym} 14580 -27410 0 0 {name=X_53378_ }
C {devices/lab_pin.sym} 14490 -27290 0 0 {name=p14048 lab=_84194_/CLK }
C {devices/lab_pin.sym} 14490 -27270 0 0 {name=p14049 lab=_84198_/D }
C {devices/lab_pin.sym} 14670 -27290 0 1 {name=p14050 lab=_65481_/C }
C {sky130_stdcells/dfxtp_4.sym} 14580 -27280 0 0 {name=X_84198_ }
C {devices/lab_pin.sym} 14540 -27150 0 0 {name=p14051 lab=clkbuf_9_497_0_CLK/A }
C {devices/lab_pin.sym} 14620 -27150 0 1 {name=p14052 lab=clkbuf_9_496_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 14580 -27150 0 0 {name=Xclkbuf_9_496_0_CLK }
C {devices/lab_pin.sym} 14540 -27030 0 0 {name=p14053 lab=_87565_/Q }
C {devices/lab_pin.sym} 14620 -27030 0 1 {name=p14054 lab=_43131_/Y }
C {sky130_stdcells/inv_2.sym} 14580 -27030 0 0 {name=X_43131_ }
C {devices/lab_pin.sym} 14500 -26930 0 0 {name=p14055 lab=_55115_/Y }
C {devices/lab_pin.sym} 14500 -26890 0 0 {name=p14056 lab=_55102_/X }
C {devices/lab_pin.sym} 14500 -26850 0 0 {name=p14057 lab=_55116_/X }
C {devices/lab_pin.sym} 14660 -26890 0 1 {name=p14058 lab=_55117_/Y }
C {sky130_stdcells/a21oi_4.sym} 14580 -26890 0 0 {name=X_55117_ }
C {devices/lab_pin.sym} 14540 -26750 0 0 {name=p14059 lab=_40343_/A }
C {devices/lab_pin.sym} 14620 -26750 0 1 {name=p14060 lab=_40344_/A }
C {sky130_stdcells/buf_2.sym} 14580 -26750 0 0 {name=X_40343_ }
C {devices/lab_pin.sym} 14500 -26650 0 0 {name=p14061 lab=_52327_/Y }
C {devices/lab_pin.sym} 14500 -26610 0 0 {name=p14062 lab=_52314_/X }
C {devices/lab_pin.sym} 14500 -26570 0 0 {name=p14063 lab=_52328_/X }
C {devices/lab_pin.sym} 14660 -26610 0 1 {name=p14064 lab=_52329_/Y }
C {sky130_stdcells/a21oi_4.sym} 14580 -26610 0 0 {name=X_52329_ }
C {devices/lab_pin.sym} 14540 -26470 0 0 {name=p14065 lab=_71163_/A }
C {devices/lab_pin.sym} 14620 -26470 0 1 {name=p14066 lab=_71164_/B }
C {sky130_stdcells/buf_2.sym} 14580 -26470 0 0 {name=X_71163_ }
C {devices/lab_pin.sym} 14490 -26350 0 0 {name=p14067 lab=_86218_/CLK }
C {devices/lab_pin.sym} 14490 -26330 0 0 {name=p14068 lab=_73483_/X }
C {devices/lab_pin.sym} 14670 -26350 0 1 {name=p14069 lab=_83149_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -26340 0 0 {name=X_83149_ }
C {devices/lab_pin.sym} 14500 -26230 0 0 {name=p14070 lab=_56082_/X }
C {devices/lab_pin.sym} 14500 -26190 0 0 {name=p14071 lab=_56094_/X }
C {devices/lab_pin.sym} 14500 -26150 0 0 {name=p14072 lab=_56096_/Y }
C {devices/lab_pin.sym} 14660 -26190 0 1 {name=p14073 lab=_56097_/Y }
C {sky130_stdcells/o21ai_4.sym} 14580 -26190 0 0 {name=X_56097_ }
C {devices/lab_pin.sym} 14540 -26050 0 0 {name=p14074 lab=_83130_/Q }
C {devices/lab_pin.sym} 14620 -26050 0 1 {name=p14075 lab=_70114_/Y }
C {sky130_stdcells/inv_2.sym} 14580 -26050 0 0 {name=X_70114_ }
C {devices/lab_pin.sym} 14500 -25970 0 0 {name=p14076 lab=_43038_/X }
C {devices/lab_pin.sym} 14500 -25930 0 0 {name=p14077 lab=_43050_/X }
C {devices/lab_pin.sym} 14500 -25890 0 0 {name=p14078 lab=_40656_/X }
C {devices/lab_pin.sym} 14500 -25850 0 0 {name=p14079 lab=_73845_/A }
C {devices/lab_pin.sym} 14500 -25810 0 0 {name=p14080 lab=_43061_/X }
C {devices/lab_pin.sym} 14660 -25890 0 1 {name=p14081 lab=_43062_/Y }
C {sky130_stdcells/o32ai_4.sym} 14580 -25890 0 0 {name=X_43062_ }
C {devices/lab_pin.sym} 14520 -25740 0 0 {name=p14082 lab=_55054_/A }
C {devices/lab_pin.sym} 14520 -25700 0 0 {name=p14083 lab=_54880_/B }
C {devices/lab_pin.sym} 14640 -25720 0 1 {name=p14084 lab=_55048_/Y }
C {sky130_stdcells/nand2_4.sym} 14580 -25720 0 0 {name=X_55048_ }
C {devices/lab_pin.sym} 14520 -25600 0 0 {name=p14085 lab=_59880_/X }
C {devices/lab_pin.sym} 14520 -25560 0 0 {name=p14086 lab=_59883_/Y }
C {devices/lab_pin.sym} 14640 -25580 0 1 {name=p14087 lab=_59926_/A }
C {sky130_stdcells/and2_4.sym} 14580 -25580 0 0 {name=X_59925_ }
C {devices/lab_pin.sym} 14540 -25450 0 0 {name=p14088 lab=_71093_/X }
C {devices/lab_pin.sym} 14620 -25450 0 1 {name=p14089 lab=_71095_/A }
C {sky130_stdcells/buf_2.sym} 14580 -25450 0 0 {name=X_71094_ }
C {devices/lab_pin.sym} 14520 -25340 0 0 {name=p14090 lab=_75971_/A }
C {devices/lab_pin.sym} 14520 -25300 0 0 {name=p14091 lab=_81737_/D }
C {devices/lab_pin.sym} 14640 -25320 0 1 {name=p14092 lab=_81762_/D }
C {sky130_stdcells/xor2_4.sym} 14580 -25320 0 0 {name=X_75971_ }
C {devices/lab_pin.sym} 14490 -25190 0 0 {name=p14093 lab=_87952_/CLK }
C {devices/lab_pin.sym} 14490 -25170 0 0 {name=p14094 lab=_87957_/D }
C {devices/lab_pin.sym} 14670 -25190 0 1 {name=p14095 lab=_87957_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -25180 0 0 {name=X_87957_ }
C {devices/lab_pin.sym} 14540 -25050 0 0 {name=p14096 lab=_42013_/A }
C {devices/lab_pin.sym} 14620 -25050 0 1 {name=p14097 lab=_42013_/X }
C {sky130_stdcells/buf_2.sym} 14580 -25050 0 0 {name=X_42013_ }
C {devices/lab_pin.sym} 14520 -24940 0 0 {name=p14098 lab=_77710_/A }
C {devices/lab_pin.sym} 14520 -24900 0 0 {name=p14099 lab=_77709_/X }
C {devices/lab_pin.sym} 14640 -24920 0 1 {name=p14100 lab=_77718_/A }
C {sky130_stdcells/nand2_4.sym} 14580 -24920 0 0 {name=X_77710_ }
C {devices/lab_pin.sym} 14520 -24800 0 0 {name=p14101 lab=_80757_/Q }
C {devices/lab_pin.sym} 14520 -24760 0 0 {name=p14102 lab=_74921_/B }
C {devices/lab_pin.sym} 14640 -24780 0 1 {name=p14103 lab=_74923_/B }
C {sky130_stdcells/nand2_4.sym} 14580 -24780 0 0 {name=X_74922_ }
C {devices/lab_pin.sym} 14500 -24670 0 0 {name=p14104 lab=_68807_/X }
C {devices/lab_pin.sym} 14500 -24630 0 0 {name=p14105 lab=_68809_/X }
C {devices/lab_pin.sym} 14500 -24590 0 0 {name=p14106 lab=_70044_/X }
C {devices/lab_pin.sym} 14660 -24630 0 1 {name=p14107 lab=_70045_/Y }
C {sky130_stdcells/a21oi_4.sym} 14580 -24630 0 0 {name=X_70045_ }
C {devices/lab_pin.sym} 14490 -24490 0 0 {name=p14108 lab=_84538_/CLK }
C {devices/lab_pin.sym} 14490 -24470 0 0 {name=p14109 lab=_44955_/Y }
C {devices/lab_pin.sym} 14670 -24490 0 1 {name=p14110 lab=_64246_/B }
C {sky130_stdcells/dfxtp_4.sym} 14580 -24480 0 0 {name=X_86908_ }
C {devices/lab_pin.sym} 14500 -24370 0 0 {name=p14111 lab=_47867_/X }
C {devices/lab_pin.sym} 14500 -24330 0 0 {name=p14112 lab=_46285_/A }
C {devices/lab_pin.sym} 14500 -24290 0 0 {name=p14113 lab=_47869_/Y }
C {devices/lab_pin.sym} 14660 -24330 0 1 {name=p14114 lab=_47871_/A }
C {sky130_stdcells/o21ai_4.sym} 14580 -24330 0 0 {name=X_47870_ }
C {devices/lab_pin.sym} 14500 -24230 0 0 {name=p14115 lab=_59651_/A }
C {devices/lab_pin.sym} 14500 -24190 0 0 {name=p14116 lab=_59700_/Y }
C {devices/lab_pin.sym} 14500 -24150 0 0 {name=p14117 lab=_59717_/Y }
C {devices/lab_pin.sym} 14500 -24110 0 0 {name=p14118 lab=_59746_/Y }
C {devices/lab_pin.sym} 14500 -24080 0 0 {name=p14119 lab=_59855_/Y }
C {devices/lab_pin.sym} 14660 -24150 0 1 {name=p14120 lab=_84687_/D }
C {sky130_stdcells/a41oi_4.sym} 14580 -24150 0 0 {name=X_59856_ }
C {devices/lab_pin.sym} 14520 -24000 0 0 {name=p14121 lab=_78691_/A }
C {devices/lab_pin.sym} 14520 -23960 0 0 {name=p14122 lab=_82684_/D }
C {devices/lab_pin.sym} 14640 -23980 0 1 {name=p14123 lab=_78690_/Y }
C {sky130_stdcells/nor2_4.sym} 14580 -23980 0 0 {name=X_78690_ }
C {devices/lab_pin.sym} 14490 -23850 0 0 {name=p14124 lab=_87888_/CLK }
C {devices/lab_pin.sym} 14490 -23830 0 0 {name=p14125 lab=_42387_/X }
C {devices/lab_pin.sym} 14670 -23850 0 1 {name=p14126 lab=_87888_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -23840 0 0 {name=X_87888_ }
C {devices/lab_pin.sym} 14540 -23710 0 0 {name=p14127 lab=clkbuf_9_156_0_CLK/X }
C {devices/lab_pin.sym} 14620 -23710 0 1 {name=p14128 lab=_84760_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 14580 -23710 0 0 {name=Xclkbuf_10_313_0_CLK }
C {devices/lab_pin.sym} 14540 -23590 0 0 {name=p14129 lab=_46820_/Y }
C {devices/lab_pin.sym} 14620 -23590 0 1 {name=p14130 lab=_52694_/D }
C {sky130_stdcells/buf_2.sym} 14580 -23590 0 0 {name=X_46821_ }
C {devices/lab_pin.sym} 14520 -23480 0 0 {name=p14131 lab=_58807_/A }
C {devices/lab_pin.sym} 14520 -23440 0 0 {name=p14132 lab=_58873_/B }
C {devices/lab_pin.sym} 14640 -23460 0 1 {name=p14133 lab=_58807_/Y }
C {sky130_stdcells/nor2_4.sym} 14580 -23460 0 0 {name=X_58807_ }
C {devices/lab_pin.sym} 14540 -23330 0 0 {name=p14134 lab=_77645_/B }
C {devices/lab_pin.sym} 14620 -23330 0 1 {name=p14135 lab=_77643_/A }
C {sky130_stdcells/inv_2.sym} 14580 -23330 0 0 {name=X_77641_ }
C {devices/lab_pin.sym} 14520 -23220 0 0 {name=p14136 lab=_80931_/Q }
C {devices/lab_pin.sym} 14520 -23180 0 0 {name=p14137 lab=_74853_/B }
C {devices/lab_pin.sym} 14640 -23200 0 1 {name=p14138 lab=_74853_/X }
C {sky130_stdcells/xor2_4.sym} 14580 -23200 0 0 {name=X_74853_ }
C {devices/lab_pin.sym} 14490 -23070 0 0 {name=p14139 lab=_86841_/CLK }
C {devices/lab_pin.sym} 14490 -23050 0 0 {name=p14140 lab=_45961_/Y }
C {devices/lab_pin.sym} 14670 -23070 0 1 {name=p14141 lab=_44104_/A }
C {sky130_stdcells/dfxtp_4.sym} 14580 -23060 0 0 {name=X_86839_ }
C {devices/lab_pin.sym} 14540 -22930 0 0 {name=p14142 lab=_60132_/A }
C {devices/lab_pin.sym} 14620 -22930 0 1 {name=p14143 lab=_59787_/X }
C {sky130_stdcells/buf_2.sym} 14580 -22930 0 0 {name=X_59787_ }
C {devices/lab_pin.sym} 14500 -22830 0 0 {name=p14144 lab=_56996_/Y }
C {devices/lab_pin.sym} 14500 -22790 0 0 {name=p14145 lab=_56998_/Y }
C {devices/lab_pin.sym} 14500 -22750 0 0 {name=p14146 lab=_56982_/X }
C {devices/lab_pin.sym} 14660 -22790 0 1 {name=p14147 lab=_56999_/Y }
C {sky130_stdcells/o21ai_4.sym} 14580 -22790 0 0 {name=X_56999_ }
C {devices/lab_pin.sym} 14540 -22650 0 0 {name=p14148 lab=clkbuf_9_471_0_CLK/X }
C {devices/lab_pin.sym} 14620 -22650 0 1 {name=p14149 lab=_88062_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 14580 -22650 0 0 {name=Xclkbuf_10_943_0_CLK }
C {devices/lab_pin.sym} 14500 -22550 0 0 {name=p14150 lab=_86368_/Q }
C {devices/lab_pin.sym} 14500 -22510 0 0 {name=p14151 lab=_49524_/X }
C {devices/lab_pin.sym} 14500 -22470 0 0 {name=p14152 lab=_49539_/Y }
C {devices/lab_pin.sym} 14660 -22510 0 1 {name=p14153 lab=_49540_/Y }
C {sky130_stdcells/o21ai_4.sym} 14580 -22510 0 0 {name=X_49540_ }
C {devices/lab_pin.sym} 14540 -22370 0 0 {name=p14154 lab=_73948_/A }
C {devices/lab_pin.sym} 14620 -22370 0 1 {name=p14155 lab=_73804_/X }
C {sky130_stdcells/buf_2.sym} 14580 -22370 0 0 {name=X_73804_ }
C {devices/lab_pin.sym} 14540 -22250 0 0 {name=p14156 lab=_46845_/A }
C {devices/lab_pin.sym} 14620 -22250 0 1 {name=p14157 lab=_46784_/B }
C {sky130_stdcells/buf_2.sym} 14580 -22250 0 0 {name=X_46752_ }
C {devices/lab_pin.sym} 14540 -22130 0 0 {name=p14158 lab=_84803_/Q }
C {devices/lab_pin.sym} 14620 -22130 0 1 {name=p14159 lab=_58738_/Y }
C {sky130_stdcells/inv_2.sym} 14580 -22130 0 0 {name=X_58738_ }
C {devices/lab_pin.sym} 14500 -22030 0 0 {name=p14160 lab=_77553_/A }
C {devices/lab_pin.sym} 14500 -21990 0 0 {name=p14161 lab=_77553_/B }
C {devices/lab_pin.sym} 14500 -21950 0 0 {name=p14162 lab=_77552_/A }
C {devices/lab_pin.sym} 14660 -21990 0 1 {name=p14163 lab=_77572_/X }
C {sky130_stdcells/o21a_4.sym} 14580 -21990 0 0 {name=X_77572_ }
C {devices/lab_pin.sym} 14520 -21860 0 0 {name=p14164 lab=_43957_/A }
C {devices/lab_pin.sym} 14520 -21820 0 0 {name=p14165 lab=_44313_/B }
C {devices/lab_pin.sym} 14640 -21840 0 1 {name=p14166 lab=_43964_/X }
C {sky130_stdcells/and2_4.sym} 14580 -21840 0 0 {name=X_43964_ }
C {devices/lab_pin.sym} 14520 -21740 0 0 {name=p14167 lab=_74784_/A }
C {devices/lab_pin.sym} 14520 -21700 0 0 {name=p14168 lab=_74781_/Y }
C {devices/lab_pin.sym} 14520 -21660 0 0 {name=p14169 lab=_74782_/Y }
C {devices/lab_pin.sym} 14520 -21620 0 0 {name=p14170 lab=_74783_/Y }
C {devices/lab_pin.sym} 14640 -21680 0 1 {name=p14171 lab=_74784_/Y }
C {sky130_stdcells/nand4_4.sym} 14580 -21680 0 0 {name=X_74784_ }
C {devices/lab_pin.sym} 14520 -21540 0 0 {name=p14172 lab=_72007_/A }
C {devices/lab_pin.sym} 14520 -21500 0 0 {name=p14173 lab=_71996_/B }
C {devices/lab_pin.sym} 14640 -21520 0 1 {name=p14174 lab=_71996_/Y }
C {sky130_stdcells/nand2_4.sym} 14580 -21520 0 0 {name=X_71996_ }
C {devices/lab_pin.sym} 14540 -21390 0 0 {name=p14175 lab=clkbuf_9_435_0_CLK/A }
C {devices/lab_pin.sym} 14620 -21390 0 1 {name=p14176 lab=clkbuf_9_434_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 14580 -21390 0 0 {name=Xclkbuf_9_434_0_CLK }
C {devices/lab_pin.sym} 14520 -21280 0 0 {name=p14177 lab=_79309_/X }
C {devices/lab_pin.sym} 14520 -21240 0 0 {name=p14178 lab=_79311_/B }
C {devices/lab_pin.sym} 14640 -21260 0 1 {name=p14179 lab=_79324_/B }
C {sky130_stdcells/xnor2_4.sym} 14580 -21260 0 0 {name=X_79311_ }
C {devices/lab_pin.sym} 14520 -21140 0 0 {name=p14180 lab=_85101_/Q }
C {devices/lab_pin.sym} 14520 -21100 0 0 {name=p14181 lab=_45793_/B }
C {devices/lab_pin.sym} 14640 -21120 0 1 {name=p14182 lab=_45703_/Y }
C {sky130_stdcells/nor2_4.sym} 14580 -21120 0 0 {name=X_45703_ }
C {devices/lab_pin.sym} 14540 -20990 0 0 {name=p14183 lab=_76522_/Y }
C {devices/lab_pin.sym} 14620 -20990 0 1 {name=p14184 lab=_76524_/C }
C {sky130_stdcells/inv_2.sym} 14580 -20990 0 0 {name=X_76523_ }
C {devices/lab_pin.sym} 14540 -20870 0 0 {name=p14185 lab=_42914_/Y }
C {devices/lab_pin.sym} 14620 -20870 0 1 {name=p14186 lab=_87653_/D }
C {sky130_stdcells/inv_2.sym} 14580 -20870 0 0 {name=X_42915_ }
C {devices/lab_pin.sym} 14540 -20750 0 0 {name=p14187 lab=_49444_/A }
C {devices/lab_pin.sym} 14620 -20750 0 1 {name=p14188 lab=_49481_/A }
C {sky130_stdcells/buf_2.sym} 14580 -20750 0 0 {name=X_49471_ }
C {devices/lab_pin.sym} 14540 -20630 0 0 {name=p14189 lab=_74012_/A }
C {devices/lab_pin.sym} 14620 -20630 0 1 {name=p14190 lab=_73735_/X }
C {sky130_stdcells/buf_2.sym} 14580 -20630 0 0 {name=X_73735_ }
C {devices/lab_pin.sym} 14500 -20530 0 0 {name=p14191 lab=_46678_/Y }
C {devices/lab_pin.sym} 14500 -20490 0 0 {name=p14192 lab=_46654_/X }
C {devices/lab_pin.sym} 14500 -20450 0 0 {name=p14193 lab=_46682_/X }
C {devices/lab_pin.sym} 14660 -20490 0 1 {name=p14194 lab=_86715_/D }
C {sky130_stdcells/a21oi_4.sym} 14580 -20490 0 0 {name=X_46683_ }
C {devices/lab_pin.sym} 14500 -20370 0 0 {name=p14195 lab=_58667_/X }
C {devices/lab_pin.sym} 14500 -20330 0 0 {name=p14196 lab=_86105_/Q }
C {devices/lab_pin.sym} 14500 -20290 0 0 {name=p14197 lab=_58668_/X }
C {devices/lab_pin.sym} 14660 -20330 0 1 {name=p14198 lab=_58669_/Y }
C {sky130_stdcells/o21ai_4.sym} 14580 -20330 0 0 {name=X_58669_ }
C {devices/lab_pin.sym} 14520 -20210 0 0 {name=p14199 lab=_70947_/A }
C {devices/lab_pin.sym} 14520 -20170 0 0 {name=p14200 lab=_70947_/B }
C {devices/lab_pin.sym} 14520 -20130 0 0 {name=p14201 lab=_70947_/C }
C {devices/lab_pin.sym} 14640 -20170 0 1 {name=p14202 lab=_70947_/Y }
C {sky130_stdcells/nand3_4.sym} 14580 -20170 0 0 {name=X_70947_ }
C {devices/lab_pin.sym} 14540 -20030 0 0 {name=p14203 lab=_43810_/A }
C {devices/lab_pin.sym} 14620 -20030 0 1 {name=p14204 lab=_43895_/X }
C {sky130_stdcells/buf_2.sym} 14580 -20030 0 0 {name=X_43895_ }
C {devices/lab_pin.sym} 14540 -19910 0 0 {name=p14205 lab=clkbuf_9_164_0_CLK/X }
C {devices/lab_pin.sym} 14620 -19910 0 1 {name=p14206 lab=_86647_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 14580 -19910 0 0 {name=Xclkbuf_10_328_0_CLK }
C {devices/lab_pin.sym} 14540 -19790 0 0 {name=p14207 lab=_83587_/Q }
C {devices/lab_pin.sym} 14620 -19790 0 1 {name=p14208 lab=_53647_/B }
C {sky130_stdcells/inv_2.sym} 14580 -19790 0 0 {name=X_48422_ }
C {devices/lab_pin.sym} 14520 -19690 0 0 {name=p14209 lab=_60700_/A }
C {devices/lab_pin.sym} 14520 -19650 0 0 {name=p14210 lab=_60612_/B }
C {devices/lab_pin.sym} 14520 -19610 0 0 {name=p14211 lab=_60700_/C }
C {devices/lab_pin.sym} 14640 -19650 0 1 {name=p14212 lab=_60700_/Y }
C {sky130_stdcells/nor3_4.sym} 14580 -19650 0 0 {name=X_60700_ }
C {devices/lab_pin.sym} 14500 -19530 0 0 {name=p14213 lab=_79225_/Y }
C {devices/lab_pin.sym} 14500 -19490 0 0 {name=p14214 lab=_79224_/A }
C {devices/lab_pin.sym} 14500 -19450 0 0 {name=p14215 lab=_79224_/B }
C {devices/lab_pin.sym} 14660 -19490 0 1 {name=p14216 lab=_79242_/Y }
C {sky130_stdcells/a21boi_4.sym} 14580 -19490 0 0 {name=X_79242_ }
C {devices/lab_pin.sym} 14500 -19380 0 0 {name=p14217 lab=_45631_/Y }
C {devices/lab_pin.sym} 14500 -19340 0 0 {name=p14218 lab=_45632_/X }
C {devices/lab_pin.sym} 14500 -19300 0 0 {name=p14219 lab=_45616_/X }
C {devices/lab_pin.sym} 14500 -19260 0 0 {name=p14220 lab=_45633_/Y }
C {devices/lab_pin.sym} 14660 -19320 0 1 {name=p14221 lab=_45634_/X }
C {sky130_stdcells/a211o_4.sym} 14580 -19320 0 0 {name=X_45634_ }
C {devices/lab_pin.sym} 14500 -19190 0 0 {name=p14222 lab=_76455_/A }
C {devices/lab_pin.sym} 14500 -19150 0 0 {name=p14223 lab=_76455_/B }
C {devices/lab_pin.sym} 14500 -19110 0 0 {name=p14224 lab=_76453_/Y }
C {devices/lab_pin.sym} 14660 -19150 0 1 {name=p14225 lab=_76454_/X }
C {sky130_stdcells/o21a_4.sym} 14580 -19150 0 0 {name=X_76454_ }
C {devices/lab_pin.sym} 14540 -19010 0 0 {name=p14226 lab=_40554_/X }
C {devices/lab_pin.sym} 14620 -19010 0 1 {name=p14227 lab=_42846_/X }
C {sky130_stdcells/buf_2.sym} 14580 -19010 0 0 {name=X_42846_ }
C {devices/lab_pin.sym} 14520 -18910 0 0 {name=p14228 lab=_61690_/A }
C {devices/lab_pin.sym} 14520 -18870 0 0 {name=p14229 lab=_61690_/B }
C {devices/lab_pin.sym} 14520 -18830 0 0 {name=p14230 lab=_79128_/B }
C {devices/lab_pin.sym} 14640 -18870 0 1 {name=p14231 lab=_61680_/Y }
C {sky130_stdcells/nor3_4.sym} 14580 -18870 0 0 {name=X_61680_ }
C {devices/lab_pin.sym} 14520 -18740 0 0 {name=p14232 lab=_73641_/A }
C {devices/lab_pin.sym} 14520 -18700 0 0 {name=p14233 lab=_86557_/Q }
C {devices/lab_pin.sym} 14640 -18720 0 1 {name=p14234 lab=_73666_/X }
C {sky130_stdcells/and2_4.sym} 14580 -18720 0 0 {name=X_73666_ }
C {devices/lab_pin.sym} 14540 -18590 0 0 {name=p14235 lab=clkbuf_9_479_0_CLK/X }
C {devices/lab_pin.sym} 14620 -18590 0 1 {name=p14236 lab=_83158_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 14580 -18590 0 0 {name=Xclkbuf_10_958_0_CLK }
C {devices/lab_pin.sym} 14540 -18470 0 0 {name=p14237 lab=_71068_/B }
C {devices/lab_pin.sym} 14620 -18470 0 1 {name=p14238 lab=_70880_/B }
C {sky130_stdcells/buf_2.sym} 14580 -18470 0 0 {name=X_70878_ }
C {devices/lab_pin.sym} 14500 -18370 0 0 {name=p14239 lab=_75404_/A }
C {devices/lab_pin.sym} 14500 -18330 0 0 {name=p14240 lab=_75383_/X }
C {devices/lab_pin.sym} 14500 -18290 0 0 {name=p14241 lab=_75384_/X }
C {devices/lab_pin.sym} 14660 -18330 0 1 {name=p14242 lab=_75405_/Y }
C {sky130_stdcells/a21oi_4.sym} 14580 -18330 0 0 {name=X_75405_ }
C {devices/lab_pin.sym} 14520 -18220 0 0 {name=p14243 lab=_59619_/X }
C {devices/lab_pin.sym} 14520 -18180 0 0 {name=p14244 lab=_60299_/C }
C {devices/lab_pin.sym} 14520 -18140 0 0 {name=p14245 lab=_60629_/Y }
C {devices/lab_pin.sym} 14520 -18100 0 0 {name=p14246 lab=_60631_/D }
C {devices/lab_pin.sym} 14640 -18160 0 1 {name=p14247 lab=_60632_/A }
C {sky130_stdcells/nand4_4.sym} 14580 -18160 0 0 {name=X_60631_ }
C {devices/lab_pin.sym} 14500 -18030 0 0 {name=p14248 lab=_86530_/Q }
C {devices/lab_pin.sym} 14500 -17990 0 0 {name=p14249 lab=_48350_/X }
C {devices/lab_pin.sym} 14500 -17950 0 0 {name=p14250 lab=_48352_/Y }
C {devices/lab_pin.sym} 14660 -17990 0 1 {name=p14251 lab=_48353_/Y }
C {sky130_stdcells/o21ai_4.sym} 14580 -17990 0 0 {name=X_48353_ }
C {devices/lab_pin.sym} 14540 -17850 0 0 {name=p14252 lab=_72617_/A }
C {devices/lab_pin.sym} 14620 -17850 0 1 {name=p14253 lab=_79211_/A }
C {sky130_stdcells/inv_2.sym} 14580 -17850 0 0 {name=X_72617_ }
C {devices/lab_pin.sym} 14540 -17730 0 0 {name=p14254 lab=_79173_/A }
C {devices/lab_pin.sym} 14620 -17730 0 1 {name=p14255 lab=_79173_/Y }
C {sky130_stdcells/inv_2.sym} 14580 -17730 0 0 {name=X_79173_ }
C {devices/lab_pin.sym} 14500 -17630 0 0 {name=p14256 lab=_45555_/X }
C {devices/lab_pin.sym} 14500 -17590 0 0 {name=p14257 lab=_45562_/Y }
C {devices/lab_pin.sym} 14500 -17550 0 0 {name=p14258 lab=_45564_/Y }
C {devices/lab_pin.sym} 14660 -17590 0 1 {name=p14259 lab=_86869_/D }
C {sky130_stdcells/a21oi_4.sym} 14580 -17590 0 0 {name=X_45565_ }
C {devices/lab_pin.sym} 14500 -17470 0 0 {name=p14260 lab=_76383_/X }
C {devices/lab_pin.sym} 14500 -17430 0 0 {name=p14261 lab=_76353_/Y }
C {devices/lab_pin.sym} 14500 -17390 0 0 {name=p14262 lab=_76384_/Y }
C {devices/lab_pin.sym} 14660 -17430 0 1 {name=p14263 lab=_76385_/X }
C {sky130_stdcells/a21o_4.sym} 14580 -17430 0 0 {name=X_76385_ }
C {devices/lab_pin.sym} 14540 -17290 0 0 {name=p14264 lab=_42776_/Y }
C {devices/lab_pin.sym} 14620 -17290 0 1 {name=p14265 lab=_87724_/D }
C {sky130_stdcells/inv_2.sym} 14580 -17290 0 0 {name=X_42777_ }
C {devices/lab_pin.sym} 14540 -17170 0 0 {name=p14266 lab=_73250_/A }
C {devices/lab_pin.sym} 14620 -17170 0 1 {name=p14267 lab=_73597_/X }
C {sky130_stdcells/buf_2.sym} 14580 -17170 0 0 {name=X_73597_ }
C {devices/lab_pin.sym} 14540 -17050 0 0 {name=p14268 lab=clkbuf_8_224_0_CLK/X }
C {devices/lab_pin.sym} 14620 -17050 0 1 {name=p14269 lab=clkbuf_9_449_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 14580 -17050 0 0 {name=Xclkbuf_9_449_0_CLK }
C {devices/lab_pin.sym} 14500 -16950 0 0 {name=p14270 lab=_47300_/Y }
C {devices/lab_pin.sym} 14500 -16910 0 0 {name=p14271 lab=_47271_/X }
C {devices/lab_pin.sym} 14500 -16870 0 0 {name=p14272 lab=_47303_/X }
C {devices/lab_pin.sym} 14660 -16910 0 1 {name=p14273 lab=_86649_/D }
C {sky130_stdcells/a21oi_4.sym} 14580 -16910 0 0 {name=X_47304_ }
C {devices/lab_pin.sym} 14520 -16780 0 0 {name=p14274 lab=_82569_/Q }
C {devices/lab_pin.sym} 14520 -16740 0 0 {name=p14275 lab=_78124_/B }
C {devices/lab_pin.sym} 14640 -16760 0 1 {name=p14276 lab=_78130_/D }
C {sky130_stdcells/xor2_4.sym} 14580 -16760 0 0 {name=X_78124_ }
C {devices/lab_pin.sym} 14540 -16630 0 0 {name=p14277 lab=_44516_/A }
C {devices/lab_pin.sym} 14620 -16630 0 1 {name=p14278 lab=_44516_/X }
C {sky130_stdcells/buf_2.sym} 14580 -16630 0 0 {name=X_44516_ }
C {devices/lab_pin.sym} 14500 -16540 0 0 {name=p14279 lab=_62186_/X }
C {devices/lab_pin.sym} 14500 -16500 0 0 {name=p14280 lab=_60541_/Y }
C {devices/lab_pin.sym} 14500 -16460 0 0 {name=p14281 lab=_63348_/Y }
C {devices/lab_pin.sym} 14500 -16420 0 0 {name=p14282 lab=_63349_/X }
C {devices/lab_pin.sym} 14660 -16480 0 1 {name=p14283 lab=_63350_/X }
C {sky130_stdcells/a211o_4.sym} 14580 -16480 0 0 {name=X_63350_ }
C {devices/lab_pin.sym} 14500 -16350 0 0 {name=p14284 lab=_75317_/Y }
C {devices/lab_pin.sym} 14500 -16310 0 0 {name=p14285 lab=_75314_/Y }
C {devices/lab_pin.sym} 14500 -16270 0 0 {name=p14286 lab=_75315_/Y }
C {devices/lab_pin.sym} 14660 -16310 0 1 {name=p14287 lab=_75336_/X }
C {sky130_stdcells/o21a_4.sym} 14580 -16310 0 0 {name=X_75336_ }
C {devices/lab_pin.sym} 14500 -16200 0 0 {name=p14288 lab=_41727_/X }
C {devices/lab_pin.sym} 14500 -16160 0 0 {name=p14289 lab=_41722_/X }
C {devices/lab_pin.sym} 14500 -16120 0 0 {name=p14290 lab=_88161_/Q }
C {devices/lab_pin.sym} 14500 -16080 0 0 {name=p14291 lab=_41723_/X }
C {devices/lab_pin.sym} 14660 -16140 0 1 {name=p14292 lab=_88161_/D }
C {sky130_stdcells/a2bb2o_4.sym} 14580 -16140 0 0 {name=X_41728_ }
C {devices/lab_pin.sym} 14520 -16000 0 0 {name=p14293 lab=_48264_/X }
C {devices/lab_pin.sym} 14520 -15960 0 0 {name=p14294 lab=_50328_/B }
C {devices/lab_pin.sym} 14640 -15980 0 1 {name=p14295 lab=_48284_/Y }
C {sky130_stdcells/nand2_4.sym} 14580 -15980 0 0 {name=X_48284_ }
C {devices/lab_pin.sym} 14520 -15870 0 0 {name=p14296 lab=_65842_/A }
C {devices/lab_pin.sym} 14520 -15830 0 0 {name=p14297 lab=_60562_/B }
C {devices/lab_pin.sym} 14520 -15790 0 0 {name=p14298 lab=_60555_/A }
C {devices/lab_pin.sym} 14640 -15830 0 1 {name=p14299 lab=_60562_/Y }
C {sky130_stdcells/nor3_4.sym} 14580 -15830 0 0 {name=X_60562_ }
C {devices/lab_pin.sym} 14500 -15730 0 0 {name=p14300 lab=_72506_/Y }
C {devices/lab_pin.sym} 14500 -15690 0 0 {name=p14301 lab=_72546_/Y }
C {devices/lab_pin.sym} 14500 -15650 0 0 {name=p14302 lab=_72517_/A }
C {devices/lab_pin.sym} 14500 -15610 0 0 {name=p14303 lab=_72525_/Y }
C {devices/lab_pin.sym} 14500 -15580 0 0 {name=p14304 lab=_72547_/Y }
C {devices/lab_pin.sym} 14660 -15650 0 1 {name=p14305 lab=_72548_/Y }
C {sky130_stdcells/a41oi_4.sym} 14580 -15650 0 0 {name=X_72548_ }
C {devices/lab_pin.sym} 14500 -15510 0 0 {name=p14306 lab=_45493_/X }
C {devices/lab_pin.sym} 14500 -15470 0 0 {name=p14307 lab=_45495_/Y }
C {devices/lab_pin.sym} 14500 -15430 0 0 {name=p14308 lab=_45348_/X }
C {devices/lab_pin.sym} 14660 -15470 0 1 {name=p14309 lab=_45496_/Y }
C {sky130_stdcells/a21oi_4.sym} 14580 -15470 0 0 {name=X_45496_ }
C {devices/lab_pin.sym} 14500 -15370 0 0 {name=p14310 lab=_62287_/X }
C {devices/lab_pin.sym} 14500 -15330 0 0 {name=p14311 lab=_62290_/X }
C {devices/lab_pin.sym} 14500 -15290 0 0 {name=p14312 lab=_62299_/Y }
C {devices/lab_pin.sym} 14500 -15250 0 0 {name=p14313 lab=_58166_/A }
C {devices/lab_pin.sym} 14500 -15210 0 0 {name=p14314 lab=_62300_/X }
C {devices/lab_pin.sym} 14660 -15290 0 1 {name=p14315 lab=_62301_/Y }
C {sky130_stdcells/o32ai_4.sym} 14580 -15290 0 0 {name=X_62301_ }
C {devices/lab_pin.sym} 14540 -15130 0 0 {name=p14316 lab=_81824_/Q }
C {devices/lab_pin.sym} 14620 -15130 0 1 {name=p14317 lab=_47236_/A }
C {sky130_stdcells/inv_2.sym} 14580 -15130 0 0 {name=X_47235_ }
C {devices/lab_pin.sym} 14520 -15020 0 0 {name=p14318 lab=_84560_/Q }
C {devices/lab_pin.sym} 14520 -14980 0 0 {name=p14319 lab=_62122_/C }
C {devices/lab_pin.sym} 14640 -15000 0 1 {name=p14320 lab=_78055_/X }
C {sky130_stdcells/xor2_4.sym} 14580 -15000 0 0 {name=X_78055_ }
C {devices/lab_pin.sym} 14540 -14870 0 0 {name=p14321 lab=_44547_/A }
C {devices/lab_pin.sym} 14620 -14870 0 1 {name=p14322 lab=_44447_/X }
C {sky130_stdcells/buf_2.sym} 14580 -14870 0 0 {name=X_44447_ }
C {devices/lab_pin.sym} 14520 -14780 0 0 {name=p14323 lab=_84873_/Q }
C {devices/lab_pin.sym} 14520 -14740 0 0 {name=p14324 lab=_63281_/B }
C {devices/lab_pin.sym} 14520 -14700 0 0 {name=p14325 lab=_63301_/C }
C {devices/lab_pin.sym} 14520 -14660 0 0 {name=p14326 lab=_63281_/D }
C {devices/lab_pin.sym} 14640 -14720 0 1 {name=p14327 lab=_63281_/X }
C {sky130_stdcells/or4_4.sym} 14580 -14720 0 0 {name=X_63281_ }
C {devices/lab_pin.sym} 14540 -14570 0 0 {name=p14328 lab=_75267_/A }
C {devices/lab_pin.sym} 14620 -14570 0 1 {name=p14329 lab=_75267_/Y }
C {sky130_stdcells/inv_2.sym} 14580 -14570 0 0 {name=X_75267_ }
C {devices/lab_pin.sym} 14540 -14450 0 0 {name=p14330 lab=_40421_/X }
C {devices/lab_pin.sym} 14620 -14450 0 1 {name=p14331 lab=_41659_/X }
C {sky130_stdcells/buf_2.sym} 14580 -14450 0 0 {name=X_41659_ }
C {devices/lab_pin.sym} 14540 -14330 0 0 {name=p14332 lab=_60493_/A }
C {devices/lab_pin.sym} 14620 -14330 0 1 {name=p14333 lab=_60493_/X }
C {sky130_stdcells/buf_2.sym} 14580 -14330 0 0 {name=X_60493_ }
C {devices/lab_pin.sym} 14500 -14230 0 0 {name=p14334 lab=_72419_/X }
C {devices/lab_pin.sym} 14500 -14190 0 0 {name=p14335 lab=_85346_/Q }
C {devices/lab_pin.sym} 14500 -14150 0 0 {name=p14336 lab=_72478_/X }
C {devices/lab_pin.sym} 14660 -14190 0 1 {name=p14337 lab=_72479_/Y }
C {sky130_stdcells/o21ai_4.sym} 14580 -14190 0 0 {name=X_72479_ }
C {devices/lab_pin.sym} 14520 -14070 0 0 {name=p14338 lab=_65196_/A }
C {devices/lab_pin.sym} 14520 -14030 0 0 {name=p14339 lab=_64913_/B }
C {devices/lab_pin.sym} 14520 -13990 0 0 {name=p14340 lab=_84218_/Q }
C {devices/lab_pin.sym} 14640 -14030 0 1 {name=p14341 lab=_65020_/X }
C {sky130_stdcells/and3_4.sym} 14580 -14030 0 0 {name=X_65020_ }
C {devices/lab_pin.sym} 14520 -13900 0 0 {name=p14342 lab=_77004_/Y }
C {devices/lab_pin.sym} 14520 -13860 0 0 {name=p14343 lab=_77006_/B }
C {devices/lab_pin.sym} 14640 -13880 0 1 {name=p14344 lab=_77006_/Y }
C {sky130_stdcells/xnor2_4.sym} 14580 -13880 0 0 {name=X_77006_ }
C {devices/lab_pin.sym} 14540 -13750 0 0 {name=p14345 lab=_62471_/A }
C {devices/lab_pin.sym} 14620 -13750 0 1 {name=p14346 lab=_62597_/D }
C {sky130_stdcells/buf_2.sym} 14580 -13750 0 0 {name=X_62232_ }
C {devices/lab_pin.sym} 14500 -13660 0 0 {name=p14347 lab=_74155_/X }
C {devices/lab_pin.sym} 14500 -13620 0 0 {name=p14348 lab=_84965_/Q }
C {devices/lab_pin.sym} 14500 -13580 0 0 {name=p14349 lab=_72992_/X }
C {devices/lab_pin.sym} 14500 -13540 0 0 {name=p14350 lab=_74217_/X }
C {devices/lab_pin.sym} 14660 -13600 0 1 {name=p14351 lab=_74218_/X }
C {sky130_stdcells/a211o_4.sym} 14580 -13600 0 0 {name=X_74218_ }
C {devices/lab_pin.sym} 14540 -13450 0 0 {name=p14352 lab=_47165_/Y }
C {devices/lab_pin.sym} 14620 -13450 0 1 {name=p14353 lab=_52889_/B }
C {sky130_stdcells/buf_2.sym} 14580 -13450 0 0 {name=X_47166_ }
C {devices/lab_pin.sym} 14540 -13330 0 0 {name=p14354 lab=_40353_/Y }
C {devices/lab_pin.sym} 14620 -13330 0 1 {name=p14355 lab=_44454_/A }
C {sky130_stdcells/buf_2.sym} 14580 -13330 0 0 {name=X_44378_ }
C {devices/lab_pin.sym} 14520 -13220 0 0 {name=p14356 lab=_80778_/Q }
C {devices/lab_pin.sym} 14520 -13180 0 0 {name=p14357 lab=_81034_/D }
C {devices/lab_pin.sym} 14640 -13200 0 1 {name=p14358 lab=_75198_/X }
C {sky130_stdcells/xor2_4.sym} 14580 -13200 0 0 {name=X_75198_ }
C {devices/lab_pin.sym} 14520 -13090 0 0 {name=p14359 lab=_46204_/B }
C {devices/lab_pin.sym} 14520 -13050 0 0 {name=p14360 lab=_46204_/C }
C {devices/lab_pin.sym} 14520 -13010 0 0 {name=p14361 lab=_46204_/D }
C {devices/lab_pin.sym} 14640 -13050 0 1 {name=p14362 lab=_46117_/X }
C {sky130_stdcells/and3_4.sym} 14580 -13050 0 0 {name=X_46117_ }
C {devices/lab_pin.sym} 14540 -12910 0 0 {name=p14363 lab=_43020_/A }
C {devices/lab_pin.sym} 14620 -12910 0 1 {name=p14364 lab=_43329_/X }
C {sky130_stdcells/buf_2.sym} 14580 -12910 0 0 {name=X_43329_ }
C {devices/lab_pin.sym} 14520 -12820 0 0 {name=p14365 lab=_62162_/X }
C {devices/lab_pin.sym} 14520 -12780 0 0 {name=p14366 lab=_62175_/B }
C {devices/lab_pin.sym} 14520 -12740 0 0 {name=p14367 lab=_61761_/C }
C {devices/lab_pin.sym} 14520 -12700 0 0 {name=p14368 lab=_62060_/X }
C {devices/lab_pin.sym} 14640 -12760 0 1 {name=p14369 lab=_62163_/Y }
C {sky130_stdcells/nand4_4.sym} 14580 -12760 0 0 {name=X_62163_ }
C {devices/lab_pin.sym} 14540 -12610 0 0 {name=p14370 lab=_72757_/A }
C {devices/lab_pin.sym} 14620 -12610 0 1 {name=p14371 lab=_74232_/A }
C {sky130_stdcells/buf_2.sym} 14580 -12610 0 0 {name=X_74149_ }
C {devices/lab_pin.sym} 14540 -12490 0 0 {name=p14372 lab=_46909_/X }
C {devices/lab_pin.sym} 14620 -12490 0 1 {name=p14373 lab=_47109_/A }
C {sky130_stdcells/buf_2.sym} 14580 -12490 0 0 {name=X_47097_ }
C {devices/lab_pin.sym} 14500 -12390 0 0 {name=p14374 lab=_61112_/X }
C {devices/lab_pin.sym} 14500 -12350 0 0 {name=p14375 lab=_61205_/A }
C {devices/lab_pin.sym} 14500 -12310 0 0 {name=p14376 lab=_61144_/A }
C {devices/lab_pin.sym} 14660 -12350 0 1 {name=p14377 lab=_64285_/A }
C {sky130_stdcells/a21boi_4.sym} 14580 -12350 0 0 {name=X_61114_ }
C {devices/lab_pin.sym} 14500 -12250 0 0 {name=p14378 lab=_46046_/X }
C {devices/lab_pin.sym} 14500 -12210 0 0 {name=p14379 lab=_46032_/X }
C {devices/lab_pin.sym} 14500 -12170 0 0 {name=p14380 lab=_41514_/X }
C {devices/lab_pin.sym} 14500 -12130 0 0 {name=p14381 lab=_66830_/B }
C {devices/lab_pin.sym} 14500 -12090 0 0 {name=p14382 lab=_46047_/X }
C {devices/lab_pin.sym} 14660 -12170 0 1 {name=p14383 lab=_46049_/A }
C {sky130_stdcells/o32ai_4.sym} 14580 -12170 0 0 {name=X_46048_ }
C {devices/lab_pin.sym} 14540 -12010 0 0 {name=p14384 lab=_66971_/A }
C {devices/lab_pin.sym} 14620 -12010 0 1 {name=p14385 lab=_66971_/X }
C {sky130_stdcells/buf_2.sym} 14580 -12010 0 0 {name=X_66971_ }
C {devices/lab_pin.sym} 14520 -11920 0 0 {name=p14386 lab=_61730_/X }
C {devices/lab_pin.sym} 14520 -11880 0 0 {name=p14387 lab=_62094_/B }
C {devices/lab_pin.sym} 14520 -11840 0 0 {name=p14388 lab=_59722_/X }
C {devices/lab_pin.sym} 14520 -11800 0 0 {name=p14389 lab=_62094_/D }
C {devices/lab_pin.sym} 14640 -11860 0 1 {name=p14390 lab=_62094_/X }
C {sky130_stdcells/and4_4.sym} 14580 -11860 0 0 {name=X_62094_ }
C {devices/lab_pin.sym} 14520 -11720 0 0 {name=p14391 lab=_78957_/A }
C {devices/lab_pin.sym} 14520 -11680 0 0 {name=p14392 lab=_78957_/B }
C {devices/lab_pin.sym} 14640 -11700 0 1 {name=p14393 lab=_78958_/B }
C {sky130_stdcells/xor2_4.sym} 14580 -11700 0 0 {name=X_78957_ }
C {devices/lab_pin.sym} 14540 -11570 0 0 {name=p14394 lab=clkbuf_4_6_1_CLK/X }
C {devices/lab_pin.sym} 14620 -11570 0 1 {name=p14395 lab=clkbuf_6_27_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 14580 -11570 0 0 {name=Xclkbuf_5_13_0_CLK }
C {devices/lab_pin.sym} 14500 -11470 0 0 {name=p14396 lab=_68706_/X }
C {devices/lab_pin.sym} 14500 -11430 0 0 {name=p14397 lab=_68709_/X }
C {devices/lab_pin.sym} 14500 -11390 0 0 {name=p14398 lab=_68661_/X }
C {devices/lab_pin.sym} 14660 -11430 0 1 {name=p14399 lab=_68710_/Y }
C {sky130_stdcells/a21oi_4.sym} 14580 -11430 0 0 {name=X_68710_ }
C {devices/lab_pin.sym} 14500 -11320 0 0 {name=p14400 lab=_65733_/X }
C {devices/lab_pin.sym} 14500 -11280 0 0 {name=p14401 lab=_85632_/Q }
C {devices/lab_pin.sym} 14500 -11240 0 0 {name=p14402 lab=_65734_/X }
C {devices/lab_pin.sym} 14500 -11200 0 0 {name=p14403 lab=_65921_/X }
C {devices/lab_pin.sym} 14660 -11260 0 1 {name=p14404 lab=_65922_/X }
C {sky130_stdcells/a211o_4.sym} 14580 -11260 0 0 {name=X_65922_ }
C {devices/lab_pin.sym} 14520 -11120 0 0 {name=p14405 lab=_77908_/A }
C {devices/lab_pin.sym} 14520 -11080 0 0 {name=p14406 lab=_77907_/Y }
C {devices/lab_pin.sym} 14640 -11100 0 1 {name=p14407 lab=_77916_/A }
C {sky130_stdcells/xor2_4.sym} 14580 -11100 0 0 {name=X_77908_ }
C {devices/lab_pin.sym} 14540 -10970 0 0 {name=p14408 lab=_44315_/A }
C {devices/lab_pin.sym} 14620 -10970 0 1 {name=p14409 lab=_61412_/A }
C {sky130_stdcells/buf_2.sym} 14580 -10970 0 0 {name=X_61045_ }
C {devices/lab_pin.sym} 14540 -10850 0 0 {name=p14410 lab=_69485_/A }
C {devices/lab_pin.sym} 14620 -10850 0 1 {name=p14411 lab=_69690_/X }
C {sky130_stdcells/buf_2.sym} 14580 -10850 0 0 {name=X_69690_ }
C {devices/lab_pin.sym} 14520 -10740 0 0 {name=p14412 lab=_78888_/A }
C {devices/lab_pin.sym} 14520 -10700 0 0 {name=p14413 lab=_78888_/B }
C {devices/lab_pin.sym} 14640 -10720 0 1 {name=p14414 lab=_78889_/B }
C {sky130_stdcells/xnor2_4.sym} 14580 -10720 0 0 {name=X_78888_ }
C {devices/lab_pin.sym} 14520 -10620 0 0 {name=p14415 lab=_49807_/A }
C {devices/lab_pin.sym} 14520 -10580 0 0 {name=p14416 lab=_49830_/B }
C {devices/lab_pin.sym} 14520 -10540 0 0 {name=p14417 lab=_49795_/X }
C {devices/lab_pin.sym} 14520 -10500 0 0 {name=p14418 lab=_53019_/D }
C {devices/lab_pin.sym} 14640 -10560 0 1 {name=p14419 lab=_49807_/X }
C {sky130_stdcells/and4_4.sym} 14580 -10560 0 0 {name=X_49807_ }
C {devices/lab_pin.sym} 14520 -10420 0 0 {name=p14420 lab=_69661_/A }
C {devices/lab_pin.sym} 14520 -10380 0 0 {name=p14421 lab=_68641_/B }
C {devices/lab_pin.sym} 14640 -10400 0 1 {name=p14422 lab=_68641_/Y }
C {sky130_stdcells/nor2_4.sym} 14580 -10400 0 0 {name=X_68641_ }
C {devices/lab_pin.sym} 14520 -10290 0 0 {name=p14423 lab=_65850_/X }
C {devices/lab_pin.sym} 14520 -10250 0 0 {name=p14424 lab=_65725_/B }
C {devices/lab_pin.sym} 14520 -10210 0 0 {name=p14425 lab=_65852_/X }
C {devices/lab_pin.sym} 14640 -10250 0 1 {name=p14426 lab=_65853_/Y }
C {sky130_stdcells/nand3_4.sym} 14580 -10250 0 0 {name=X_65853_ }
C {devices/lab_pin.sym} 14500 -10140 0 0 {name=p14427 lab=_77827_/A }
C {devices/lab_pin.sym} 14500 -10100 0 0 {name=p14428 lab=_77826_/Y }
C {devices/lab_pin.sym} 14500 -10060 0 0 {name=p14429 lab=_77813_/A }
C {devices/lab_pin.sym} 14500 -10020 0 0 {name=p14430 lab=_77838_/Y }
C {devices/lab_pin.sym} 14660 -10080 0 1 {name=p14431 lab=_77839_/X }
C {sky130_stdcells/a2bb2o_4.sym} 14580 -10080 0 0 {name=X_77839_ }
C {devices/lab_pin.sym} 14540 -9930 0 0 {name=p14432 lab=_47832_/A }
C {devices/lab_pin.sym} 14620 -9930 0 1 {name=p14433 lab=_48755_/A }
C {sky130_stdcells/buf_2.sym} 14580 -9930 0 0 {name=X_47999_ }
C {devices/lab_pin.sym} 14520 -9820 0 0 {name=p14434 lab=_64804_/A }
C {devices/lab_pin.sym} 14520 -9780 0 0 {name=p14435 lab=_64804_/B }
C {devices/lab_pin.sym} 14640 -9800 0 1 {name=p14436 lab=_64804_/X }
C {sky130_stdcells/and2_4.sym} 14580 -9800 0 0 {name=X_64804_ }
C {devices/lab_pin.sym} 14540 -9670 0 0 {name=p14437 lab=_49657_/A }
C {devices/lab_pin.sym} 14620 -9670 0 1 {name=p14438 lab=_49761_/C }
C {sky130_stdcells/buf_2.sym} 14580 -9670 0 0 {name=X_49738_ }
C {devices/lab_pin.sym} 14490 -9550 0 0 {name=p14439 lab=_81130_/CLK }
C {devices/lab_pin.sym} 14490 -9530 0 0 {name=p14440 lab=_80882_/Q }
C {devices/lab_pin.sym} 14670 -9550 0 1 {name=p14441 lab=_74957_/B }
C {sky130_stdcells/dfxtp_4.sym} 14580 -9540 0 0 {name=X_80850_ }
C {devices/lab_pin.sym} 14520 -9420 0 0 {name=p14442 lab=_68444_/A }
C {devices/lab_pin.sym} 14520 -9380 0 0 {name=p14443 lab=_88363_/Q }
C {devices/lab_pin.sym} 14640 -9400 0 1 {name=p14444 lab=_68572_/X }
C {sky130_stdcells/and2_4.sym} 14580 -9400 0 0 {name=X_68572_ }
C {devices/lab_pin.sym} 14540 -9270 0 0 {name=p14445 lab=clkbuf_4_14_1_CLK/X }
C {devices/lab_pin.sym} 14620 -9270 0 1 {name=p14446 lab=clkbuf_6_57_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 14580 -9270 0 0 {name=Xclkbuf_5_28_0_CLK }
C {devices/lab_pin.sym} 14500 -9180 0 0 {name=p14447 lab=_65660_/X }
C {devices/lab_pin.sym} 14500 -9140 0 0 {name=p14448 lab=_83058_/Q }
C {devices/lab_pin.sym} 14500 -9100 0 0 {name=p14449 lab=_65768_/X }
C {devices/lab_pin.sym} 14500 -9060 0 0 {name=p14450 lab=_65783_/X }
C {devices/lab_pin.sym} 14660 -9120 0 1 {name=p14451 lab=_65784_/X }
C {sky130_stdcells/a211o_4.sym} 14580 -9120 0 0 {name=X_65784_ }
C {devices/lab_pin.sym} 14500 -8990 0 0 {name=p14452 lab=_62992_/Y }
C {devices/lab_pin.sym} 14500 -8950 0 0 {name=p14453 lab=_62987_/X }
C {devices/lab_pin.sym} 14500 -8910 0 0 {name=p14454 lab=_62995_/Y }
C {devices/lab_pin.sym} 14660 -8950 0 1 {name=p14455 lab=_84362_/D }
C {sky130_stdcells/a21oi_4.sym} 14580 -8950 0 0 {name=X_62996_ }
C {devices/lab_pin.sym} 14520 -8820 0 0 {name=p14456 lab=_79510_/B }
C {devices/lab_pin.sym} 14520 -8780 0 0 {name=p14457 lab=_79510_/A }
C {devices/lab_pin.sym} 14640 -8800 0 1 {name=p14458 lab=_82848_/D }
C {sky130_stdcells/xor2_4.sym} 14580 -8800 0 0 {name=X_79509_ }
C {devices/lab_pin.sym} 14540 -8670 0 0 {name=p14459 lab=_66563_/A }
C {devices/lab_pin.sym} 14620 -8670 0 1 {name=p14460 lab=_67997_/A }
C {sky130_stdcells/buf_2.sym} 14580 -8670 0 0 {name=X_67523_ }
C {devices/lab_pin.sym} 14500 -8580 0 0 {name=p14461 lab=_64657_/X }
C {devices/lab_pin.sym} 14500 -8540 0 0 {name=p14462 lab=_83309_/Q }
C {devices/lab_pin.sym} 14500 -8500 0 0 {name=p14463 lab=_64733_/X }
C {devices/lab_pin.sym} 14500 -8460 0 0 {name=p14464 lab=_64734_/X }
C {devices/lab_pin.sym} 14660 -8520 0 1 {name=p14465 lab=_64735_/X }
C {sky130_stdcells/a211o_4.sym} 14580 -8520 0 0 {name=X_64735_ }
C {devices/lab_pin.sym} 14520 -8400 0 0 {name=p14466 lab=_49651_/X }
C {devices/lab_pin.sym} 14520 -8360 0 0 {name=p14467 lab=_49669_/B }
C {devices/lab_pin.sym} 14520 -8320 0 0 {name=p14468 lab=_49669_/C }
C {devices/lab_pin.sym} 14520 -8280 0 0 {name=p14469 lab=_51192_/D }
C {devices/lab_pin.sym} 14640 -8340 0 1 {name=p14470 lab=_49669_/X }
C {sky130_stdcells/and4_4.sym} 14580 -8340 0 0 {name=X_49669_ }
C {devices/lab_pin.sym} 14520 -8220 0 0 {name=p14471 lab=_61915_/A }
C {devices/lab_pin.sym} 14520 -8180 0 0 {name=p14472 lab=_61945_/X }
C {devices/lab_pin.sym} 14520 -8140 0 0 {name=p14473 lab=_58528_/A }
C {devices/lab_pin.sym} 14520 -8100 0 0 {name=p14474 lab=_61947_/D }
C {devices/lab_pin.sym} 14640 -8160 0 1 {name=p14475 lab=_61947_/X }
C {sky130_stdcells/and4_4.sym} 14580 -8160 0 0 {name=X_61947_ }
C {devices/lab_pin.sym} 14490 -8010 0 0 {name=p14476 lab=_80849_/CLK }
C {devices/lab_pin.sym} 14490 -7990 0 0 {name=p14477 lab=_80781_/D }
C {devices/lab_pin.sym} 14670 -8010 0 1 {name=p14478 lab=_80781_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -8000 0 0 {name=X_80781_ }
C {devices/lab_pin.sym} 14500 -7890 0 0 {name=p14479 lab=_51698_/Y }
C {devices/lab_pin.sym} 14500 -7850 0 0 {name=p14480 lab=_51693_/X }
C {devices/lab_pin.sym} 14500 -7810 0 0 {name=p14481 lab=_51699_/X }
C {devices/lab_pin.sym} 14660 -7850 0 1 {name=p14482 lab=_85962_/D }
C {sky130_stdcells/a21oi_4.sym} 14580 -7850 0 0 {name=X_51700_ }
C {devices/lab_pin.sym} 14490 -7710 0 0 {name=p14483 lab=_82617_/CLK }
C {devices/lab_pin.sym} 14490 -7690 0 0 {name=p14484 lab=_82520_/D }
C {devices/lab_pin.sym} 14670 -7710 0 1 {name=p14485 lab=_78644_/A }
C {sky130_stdcells/dfxtp_4.sym} 14580 -7700 0 0 {name=X_82520_ }
C {devices/lab_pin.sym} 14500 -7600 0 0 {name=p14486 lab=_87470_/Q }
C {devices/lab_pin.sym} 14500 -7560 0 0 {name=p14487 lab=_67358_/X }
C {devices/lab_pin.sym} 14500 -7520 0 0 {name=p14488 lab=_67360_/X }
C {devices/lab_pin.sym} 14500 -7480 0 0 {name=p14489 lab=_67453_/X }
C {devices/lab_pin.sym} 14660 -7540 0 1 {name=p14490 lab=_67454_/X }
C {sky130_stdcells/a211o_4.sym} 14580 -7540 0 0 {name=X_67454_ }
C {devices/lab_pin.sym} 14540 -7390 0 0 {name=p14491 lab=_52708_/A }
C {devices/lab_pin.sym} 14620 -7390 0 1 {name=p14492 lab=_52694_/C }
C {sky130_stdcells/buf_2.sym} 14580 -7390 0 0 {name=X_52680_ }
C {devices/lab_pin.sym} 14540 -7270 0 0 {name=p14493 lab=_64666_/A }
C {devices/lab_pin.sym} 14620 -7270 0 1 {name=p14494 lab=_64666_/X }
C {sky130_stdcells/buf_2.sym} 14580 -7270 0 0 {name=X_64666_ }
C {devices/lab_pin.sym} 14520 -7180 0 0 {name=p14495 lab=_61876_/X }
C {devices/lab_pin.sym} 14520 -7140 0 0 {name=p14496 lab=_61846_/B }
C {devices/lab_pin.sym} 14520 -7100 0 0 {name=p14497 lab=_61878_/C }
C {devices/lab_pin.sym} 14520 -7060 0 0 {name=p14498 lab=_61846_/D }
C {devices/lab_pin.sym} 14640 -7120 0 1 {name=p14499 lab=_61879_/D }
C {sky130_stdcells/nand4_4.sym} 14580 -7120 0 0 {name=X_61878_ }
C {devices/lab_pin.sym} 14500 -6990 0 0 {name=p14500 lab=_66282_/X }
C {devices/lab_pin.sym} 14500 -6950 0 0 {name=p14501 lab=_66030_/Y }
C {devices/lab_pin.sym} 14500 -6910 0 0 {name=p14502 lab=_66404_/Y }
C {devices/lab_pin.sym} 14660 -6950 0 1 {name=p14503 lab=_66405_/Y }
C {sky130_stdcells/o21ai_4.sym} 14580 -6950 0 0 {name=X_66405_ }
C {devices/lab_pin.sym} 14500 -6830 0 0 {name=p14504 lab=_51628_/Y }
C {devices/lab_pin.sym} 14500 -6790 0 0 {name=p14505 lab=_51613_/X }
C {devices/lab_pin.sym} 14500 -6750 0 0 {name=p14506 lab=_51630_/X }
C {devices/lab_pin.sym} 14660 -6790 0 1 {name=p14507 lab=_51631_/Y }
C {sky130_stdcells/a21oi_4.sym} 14580 -6790 0 0 {name=X_51631_ }
C {devices/lab_pin.sym} 14520 -6660 0 0 {name=p14508 lab=_58393_/Y }
C {devices/lab_pin.sym} 14520 -6620 0 0 {name=p14509 lab=_63648_/B }
C {devices/lab_pin.sym} 14640 -6640 0 1 {name=p14510 lab=_63617_/Y }
C {sky130_stdcells/nor2_4.sym} 14580 -6640 0 0 {name=X_63617_ }
C {devices/lab_pin.sym} 14490 -6510 0 0 {name=p14511 lab=_82820_/CLK }
C {devices/lab_pin.sym} 14490 -6490 0 0 {name=p14512 lab=_79143_/X }
C {devices/lab_pin.sym} 14670 -6510 0 1 {name=p14513 lab=_82419_/D }
C {sky130_stdcells/dfxtp_4.sym} 14580 -6500 0 0 {name=X_82451_ }
C {devices/lab_pin.sym} 14520 -6390 0 0 {name=p14514 lab=_72592_/A }
C {devices/lab_pin.sym} 14520 -6350 0 0 {name=p14515 lab=_59837_/B }
C {devices/lab_pin.sym} 14520 -6310 0 0 {name=p14516 lab=_84556_/Q }
C {devices/lab_pin.sym} 14640 -6350 0 1 {name=p14517 lab=_60829_/Y }
C {sky130_stdcells/nor3_4.sym} 14580 -6350 0 0 {name=X_60829_ }
C {devices/lab_pin.sym} 14520 -6220 0 0 {name=p14518 lab=_67364_/X }
C {devices/lab_pin.sym} 14520 -6180 0 0 {name=p14519 lab=_67385_/B }
C {devices/lab_pin.sym} 14640 -6200 0 1 {name=p14520 lab=_67385_/X }
C {sky130_stdcells/and2_4.sym} 14580 -6200 0 0 {name=X_67385_ }
C {devices/lab_pin.sym} 14540 -6070 0 0 {name=p14521 lab=_64683_/A }
C {devices/lab_pin.sym} 14620 -6070 0 1 {name=p14522 lab=_64633_/B }
C {sky130_stdcells/buf_2.sym} 14580 -6070 0 0 {name=X_64597_ }
C {devices/lab_pin.sym} 14490 -5950 0 0 {name=p14523 lab=_81352_/CLK }
C {devices/lab_pin.sym} 14490 -5930 0 0 {name=p14524 lab=_83938_/Q }
C {devices/lab_pin.sym} 14670 -5950 0 1 {name=p14525 lab=_76715_/B }
C {sky130_stdcells/dfxtp_4.sym} 14580 -5940 0 0 {name=X_81402_ }
C {devices/lab_pin.sym} 14540 -5810 0 0 {name=p14526 lab=_69371_/A }
C {devices/lab_pin.sym} 14620 -5810 0 1 {name=p14527 lab=_69124_/X }
C {sky130_stdcells/buf_2.sym} 14580 -5810 0 0 {name=X_69124_ }
C {devices/lab_pin.sym} 14540 -5690 0 0 {name=p14528 lab=_54322_/A }
C {devices/lab_pin.sym} 14620 -5690 0 1 {name=p14529 lab=_54355_/A }
C {sky130_stdcells/buf_2.sym} 14580 -5690 0 0 {name=X_54350_ }
C {devices/lab_pin.sym} 14520 -5580 0 0 {name=p14530 lab=_65074_/A }
C {devices/lab_pin.sym} 14520 -5540 0 0 {name=p14531 lab=_86563_/Q }
C {devices/lab_pin.sym} 14640 -5560 0 1 {name=p14532 lab=_66336_/X }
C {sky130_stdcells/and2_4.sym} 14580 -5560 0 0 {name=X_66336_ }
C {devices/lab_pin.sym} 14490 -5430 0 0 {name=p14533 lab=_85297_/CLK }
C {devices/lab_pin.sym} 14490 -5410 0 0 {name=p14534 lab=_85170_/D }
C {devices/lab_pin.sym} 14670 -5430 0 1 {name=p14535 lab=_55848_/B }
C {sky130_stdcells/dfxtp_4.sym} 14580 -5420 0 0 {name=X_85170_ }
C {devices/lab_pin.sym} 14500 -5310 0 0 {name=p14536 lab=_85987_/Q }
C {devices/lab_pin.sym} 14500 -5270 0 0 {name=p14537 lab=_51539_/X }
C {devices/lab_pin.sym} 14500 -5230 0 0 {name=p14538 lab=_51561_/Y }
C {devices/lab_pin.sym} 14660 -5270 0 1 {name=p14539 lab=_51562_/Y }
C {sky130_stdcells/o21ai_4.sym} 14580 -5270 0 0 {name=X_51562_ }
C {devices/lab_pin.sym} 14540 -5130 0 0 {name=p14540 lab=_63487_/A }
C {devices/lab_pin.sym} 14620 -5130 0 1 {name=p14541 lab=_63548_/X }
C {sky130_stdcells/buf_2.sym} 14580 -5130 0 0 {name=X_63548_ }
C {devices/lab_pin.sym} 14490 -5010 0 0 {name=p14542 lab=_83703_/CLK }
C {devices/lab_pin.sym} 14490 -4990 0 0 {name=p14543 lab=_82190_/Q }
C {devices/lab_pin.sym} 14670 -5010 0 1 {name=p14544 lab=_82382_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -5000 0 0 {name=X_82382_ }
C {devices/lab_pin.sym} 14540 -4870 0 0 {name=p14545 lab=_53355_/A }
C {devices/lab_pin.sym} 14620 -4870 0 1 {name=p14546 lab=_53301_/X }
C {sky130_stdcells/buf_2.sym} 14580 -4870 0 0 {name=X_53301_ }
C {devices/lab_pin.sym} 14490 -4750 0 0 {name=p14547 lab=_82177_/CLK }
C {devices/lab_pin.sym} 14490 -4730 0 0 {name=p14548 lab=_84121_/D }
C {devices/lab_pin.sym} 14670 -4750 0 1 {name=p14549 lab=_84121_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -4740 0 0 {name=X_84121_ }
C {devices/lab_pin.sym} 14520 -4620 0 0 {name=p14550 lab=_50513_/A }
C {devices/lab_pin.sym} 14520 -4580 0 0 {name=p14551 lab=_52216_/B }
C {devices/lab_pin.sym} 14640 -4600 0 1 {name=p14552 lab=_50513_/Y }
C {sky130_stdcells/nand2_4.sym} 14580 -4600 0 0 {name=X_50513_ }
C {devices/lab_pin.sym} 14490 -4470 0 0 {name=p14553 lab=_81333_/CLK }
C {devices/lab_pin.sym} 14490 -4450 0 0 {name=p14554 lab=_81333_/D }
C {devices/lab_pin.sym} 14670 -4470 0 1 {name=p14555 lab=_81333_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -4460 0 0 {name=X_81333_ }
C {devices/lab_pin.sym} 14520 -4340 0 0 {name=p14556 lab=_69648_/A }
C {devices/lab_pin.sym} 14520 -4300 0 0 {name=p14557 lab=_69055_/B }
C {devices/lab_pin.sym} 14640 -4320 0 1 {name=p14558 lab=_69055_/Y }
C {sky130_stdcells/nor2_4.sym} 14580 -4320 0 0 {name=X_69055_ }
C {devices/lab_pin.sym} 14520 -4200 0 0 {name=p14559 lab=_54288_/A }
C {devices/lab_pin.sym} 14520 -4160 0 0 {name=p14560 lab=_52590_/B }
C {devices/lab_pin.sym} 14640 -4180 0 1 {name=p14561 lab=_54281_/Y }
C {sky130_stdcells/nand2_4.sym} 14580 -4180 0 0 {name=X_54281_ }
C {devices/lab_pin.sym} 14540 -4050 0 0 {name=p14562 lab=_65486_/A }
C {devices/lab_pin.sym} 14620 -4050 0 1 {name=p14563 lab=_66267_/X }
C {sky130_stdcells/buf_2.sym} 14580 -4050 0 0 {name=X_66267_ }
C {devices/lab_pin.sym} 14540 -3930 0 0 {name=p14564 lab=_51218_/X }
C {devices/lab_pin.sym} 14620 -3930 0 1 {name=p14565 lab=_51509_/A }
C {sky130_stdcells/buf_2.sym} 14580 -3930 0 0 {name=X_51493_ }
C {devices/lab_pin.sym} 14540 -3810 0 0 {name=p14566 lab=_63417_/A }
C {devices/lab_pin.sym} 14620 -3810 0 1 {name=p14567 lab=_63491_/D }
C {sky130_stdcells/buf_2.sym} 14580 -3810 0 0 {name=X_63479_ }
C {devices/lab_pin.sym} 14540 -3690 0 0 {name=p14568 lab=_68402_/A }
C {devices/lab_pin.sym} 14620 -3690 0 1 {name=p14569 lab=_68006_/X }
C {sky130_stdcells/buf_2.sym} 14580 -3690 0 0 {name=X_68006_ }
C {devices/lab_pin.sym} 14540 -3570 0 0 {name=p14570 lab=_56019_/Y }
C {devices/lab_pin.sym} 14620 -3570 0 1 {name=p14571 lab=_56020_/X }
C {sky130_stdcells/buf_2.sym} 14580 -3570 0 0 {name=X_56020_ }
C {devices/lab_pin.sym} 14520 -3460 0 0 {name=p14572 lab=_53246_/A }
C {devices/lab_pin.sym} 14520 -3420 0 0 {name=p14573 lab=_53232_/B }
C {devices/lab_pin.sym} 14640 -3440 0 1 {name=p14574 lab=_53232_/Y }
C {sky130_stdcells/nand2_4.sym} 14580 -3440 0 0 {name=X_53232_ }
C {devices/lab_pin.sym} 14520 -3330 0 0 {name=p14575 lab=_65215_/X }
C {devices/lab_pin.sym} 14520 -3290 0 0 {name=p14576 lab=_65111_/B }
C {devices/lab_pin.sym} 14520 -3250 0 0 {name=p14577 lab=_65217_/X }
C {devices/lab_pin.sym} 14640 -3290 0 1 {name=p14578 lab=_65218_/Y }
C {sky130_stdcells/nand3_4.sym} 14580 -3290 0 0 {name=X_65218_ }
C {devices/lab_pin.sym} 14490 -3150 0 0 {name=p14579 lab=_81431_/CLK }
C {devices/lab_pin.sym} 14490 -3130 0 0 {name=p14580 lab=_84052_/D }
C {devices/lab_pin.sym} 14670 -3150 0 1 {name=p14581 lab=_84052_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -3140 0 0 {name=X_84052_ }
C {devices/lab_pin.sym} 14500 -3030 0 0 {name=p14582 lab=_50441_/Y }
C {devices/lab_pin.sym} 14500 -2990 0 0 {name=p14583 lab=_50429_/X }
C {devices/lab_pin.sym} 14500 -2950 0 0 {name=p14584 lab=_50443_/X }
C {devices/lab_pin.sym} 14660 -2990 0 1 {name=p14585 lab=_86200_/D }
C {sky130_stdcells/a21oi_4.sym} 14580 -2990 0 0 {name=X_50444_ }
C {devices/lab_pin.sym} 14490 -2850 0 0 {name=p14586 lab=_81361_/CLK }
C {devices/lab_pin.sym} 14490 -2830 0 0 {name=p14587 lab=_81264_/D }
C {devices/lab_pin.sym} 14670 -2850 0 1 {name=p14588 lab=_76345_/A }
C {sky130_stdcells/dfxtp_4.sym} 14580 -2840 0 0 {name=X_81264_ }
C {devices/lab_pin.sym} 14520 -2720 0 0 {name=p14589 lab=_44263_/X }
C {devices/lab_pin.sym} 14520 -2680 0 0 {name=p14590 lab=_66198_/B }
C {devices/lab_pin.sym} 14640 -2700 0 1 {name=p14591 lab=_66198_/X }
C {sky130_stdcells/and2_4.sym} 14580 -2700 0 0 {name=X_66198_ }
C {devices/lab_pin.sym} 14490 -2570 0 0 {name=p14592 lab=_85144_/CLK }
C {devices/lab_pin.sym} 14490 -2550 0 0 {name=p14593 lab=_83003_/D }
C {devices/lab_pin.sym} 14670 -2570 0 1 {name=p14594 lab=_45494_/A }
C {sky130_stdcells/dfxtp_4.sym} 14580 -2560 0 0 {name=X_83003_ }
C {devices/lab_pin.sym} 14520 -2440 0 0 {name=p14595 lab=_80215_/A }
C {devices/lab_pin.sym} 14520 -2400 0 0 {name=p14596 lab=_63800_/C }
C {devices/lab_pin.sym} 14640 -2420 0 1 {name=p14597 lab=_80215_/X }
C {sky130_stdcells/xor2_4.sym} 14580 -2420 0 0 {name=X_80215_ }
C {devices/lab_pin.sym} 14540 -2290 0 0 {name=p14598 lab=_53189_/A }
C {devices/lab_pin.sym} 14620 -2290 0 1 {name=p14599 lab=_53163_/X }
C {sky130_stdcells/buf_2.sym} 14580 -2290 0 0 {name=X_53163_ }
C {devices/lab_pin.sym} 14500 -2190 0 0 {name=p14600 lab=_65145_/X }
C {devices/lab_pin.sym} 14500 -2150 0 0 {name=p14601 lab=_65148_/X }
C {devices/lab_pin.sym} 14500 -2110 0 0 {name=p14602 lab=_65122_/X }
C {devices/lab_pin.sym} 14660 -2150 0 1 {name=p14603 lab=_65154_/A }
C {sky130_stdcells/a21o_4.sym} 14580 -2150 0 0 {name=X_65149_ }
C {devices/lab_pin.sym} 14500 -2030 0 0 {name=p14604 lab=_86213_/Q }
C {devices/lab_pin.sym} 14500 -1990 0 0 {name=p14605 lab=_50363_/X }
C {devices/lab_pin.sym} 14500 -1950 0 0 {name=p14606 lab=_50374_/Y }
C {devices/lab_pin.sym} 14660 -1990 0 1 {name=p14607 lab=_50375_/Y }
C {sky130_stdcells/o21ai_4.sym} 14580 -1990 0 0 {name=X_50375_ }
C {devices/lab_pin.sym} 14490 -1850 0 0 {name=p14608 lab=_81195_/CLK }
C {devices/lab_pin.sym} 14490 -1830 0 0 {name=p14609 lab=_74964_/X }
C {devices/lab_pin.sym} 14670 -1850 0 1 {name=p14610 lab=_46504_/A }
C {sky130_stdcells/dfxtp_4.sym} 14580 -1840 0 0 {name=X_81195_ }
C {devices/lab_pin.sym} 14500 -1730 0 0 {name=p14611 lab=_52112_/Y }
C {devices/lab_pin.sym} 14500 -1690 0 0 {name=p14612 lab=_52108_/X }
C {devices/lab_pin.sym} 14500 -1650 0 0 {name=p14613 lab=_52113_/X }
C {devices/lab_pin.sym} 14660 -1690 0 1 {name=p14614 lab=_85886_/D }
C {sky130_stdcells/a21oi_4.sym} 14580 -1690 0 0 {name=X_52114_ }
C {devices/lab_pin.sym} 14490 -1550 0 0 {name=p14615 lab=_87553_/CLK }
C {devices/lab_pin.sym} 14490 -1530 0 0 {name=p14616 lab=_42586_/Y }
C {devices/lab_pin.sym} 14670 -1550 0 1 {name=p14617 lab=_87811_/Q }
C {sky130_stdcells/dfxtp_4.sym} 14580 -1540 0 0 {name=X_87811_ }
C {devices/lab_pin.sym} 14520 -1420 0 0 {name=p14618 lab=_80142_/X }
C {devices/lab_pin.sym} 14520 -1380 0 0 {name=p14619 lab=_80145_/Y }
C {devices/lab_pin.sym} 14640 -1400 0 1 {name=p14620 lab=_80157_/A }
C {sky130_stdcells/xor2_4.sym} 14580 -1400 0 0 {name=X_80146_ }
C {devices/lab_pin.sym} 14540 -1270 0 0 {name=p14621 lab=_53147_/A }
C {devices/lab_pin.sym} 14620 -1270 0 1 {name=p14622 lab=_53115_/A }
C {sky130_stdcells/buf_2.sym} 14580 -1270 0 0 {name=X_53094_ }
C {devices/lab_pin.sym} 14520 -1160 0 0 {name=p14623 lab=_57971_/A }
C {devices/lab_pin.sym} 14520 -1120 0 0 {name=p14624 lab=_57971_/B }
C {devices/lab_pin.sym} 14640 -1140 0 1 {name=p14625 lab=_57971_/Y }
C {sky130_stdcells/nor2_4.sym} 14580 -1140 0 0 {name=X_57971_ }
C {devices/lab_pin.sym} 14500 -1040 0 0 {name=p14626 lab=_43201_/A }
C {devices/lab_pin.sym} 14500 -1000 0 0 {name=p14627 lab=_66571_/X }
C {devices/lab_pin.sym} 14500 -960 0 0 {name=p14628 lab=_68741_/X }
C {devices/lab_pin.sym} 14500 -920 0 0 {name=p14629 lab=_69956_/X }
C {devices/lab_pin.sym} 14660 -980 0 1 {name=p14630 lab=_69957_/X }
C {sky130_stdcells/a211o_4.sym} 14580 -980 0 0 {name=X_69957_ }
C {devices/lab_pin.sym} 14500 -870 0 0 {name=p14631 lab=_63344_/B }
C {devices/lab_pin.sym} 14500 -830 0 0 {name=p14632 lab=_59741_/A }
C {devices/lab_pin.sym} 14500 -790 0 0 {name=p14633 lab=_62975_/D }
C {devices/lab_pin.sym} 14500 -750 0 0 {name=p14634 lab=_59890_/C }
C {devices/lab_pin.sym} 14500 -720 0 0 {name=p14635 lab=_63055_/A }
C {devices/lab_pin.sym} 14660 -790 0 1 {name=p14636 lab=_59710_/Y }
C {sky130_stdcells/a41oi_4.sym} 14580 -790 0 0 {name=X_59710_ }
C {devices/lab_pin.sym} 14520 -640 0 0 {name=p14637 lab=_52058_/A }
C {devices/lab_pin.sym} 14520 -600 0 0 {name=p14638 lab=_48297_/X }
C {devices/lab_pin.sym} 14640 -620 0 1 {name=p14639 lab=_52045_/Y }
C {sky130_stdcells/nand2_4.sym} 14580 -620 0 0 {name=X_52045_ }
C {devices/lab_pin.sym} 15460 -42150 0 0 {name=p14640 lab=_83330_/Q }
C {devices/lab_pin.sym} 15540 -42150 0 1 {name=p14641 lab=_56922_/X }
C {sky130_stdcells/buf_2.sym} 15500 -42150 0 0 {name=X_56922_ }
C {devices/lab_pin.sym} 15440 -42040 0 0 {name=p14642 lab=_69685_/A }
C {devices/lab_pin.sym} 15440 -42000 0 0 {name=p14643 lab=_87325_/Q }
C {devices/lab_pin.sym} 15560 -42020 0 1 {name=p14644 lab=_68908_/X }
C {sky130_stdcells/and2_4.sym} 15500 -42020 0 0 {name=X_68908_ }
C {devices/lab_pin.sym} 15410 -41890 0 0 {name=p14645 lab=_87487_/CLK }
C {devices/lab_pin.sym} 15410 -41870 0 0 {name=p14646 lab=_87742_/D }
C {devices/lab_pin.sym} 15590 -41890 0 1 {name=p14647 lab=_68896_/B }
C {sky130_stdcells/dfxtp_4.sym} 15500 -41880 0 0 {name=X_87742_ }
C {devices/lab_pin.sym} 15420 -41770 0 0 {name=p14648 lab=_80056_/B }
C {devices/lab_pin.sym} 15420 -41730 0 0 {name=p14649 lab=_80073_/X }
C {devices/lab_pin.sym} 15420 -41690 0 0 {name=p14650 lab=_80076_/Y }
C {devices/lab_pin.sym} 15580 -41730 0 1 {name=p14651 lab=_80077_/Y }
C {sky130_stdcells/a21oi_4.sym} 15500 -41730 0 0 {name=X_80077_ }
C {devices/lab_pin.sym} 15410 -41590 0 0 {name=p14652 lab=_84829_/CLK }
C {devices/lab_pin.sym} 15410 -41570 0 0 {name=p14653 lab=_84954_/D }
C {devices/lab_pin.sym} 15590 -41590 0 1 {name=p14654 lab=_84954_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -41580 0 0 {name=X_84954_ }
C {devices/lab_pin.sym} 15440 -41460 0 0 {name=p14655 lab=_69900_/A }
C {devices/lab_pin.sym} 15440 -41420 0 0 {name=p14656 lab=_69888_/B }
C {devices/lab_pin.sym} 15560 -41440 0 1 {name=p14657 lab=_69888_/X }
C {sky130_stdcells/and2_4.sym} 15500 -41440 0 0 {name=X_69888_ }
C {devices/lab_pin.sym} 15440 -41330 0 0 {name=p14658 lab=_61276_/B }
C {devices/lab_pin.sym} 15440 -41290 0 0 {name=p14659 lab=_60403_/A }
C {devices/lab_pin.sym} 15440 -41250 0 0 {name=p14660 lab=_60402_/A }
C {devices/lab_pin.sym} 15560 -41290 0 1 {name=p14661 lab=_59661_/A }
C {sky130_stdcells/and3_4.sym} 15500 -41290 0 0 {name=X_59641_ }
C {devices/lab_pin.sym} 15410 -41150 0 0 {name=p14662 lab=_83905_/CLK }
C {devices/lab_pin.sym} 15410 -41130 0 0 {name=p14663 lab=_83905_/D }
C {devices/lab_pin.sym} 15590 -41150 0 1 {name=p14664 lab=_83905_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -41140 0 0 {name=X_83905_ }
C {devices/lab_pin.sym} 15440 -41020 0 0 {name=p14665 lab=_56824_/X }
C {devices/lab_pin.sym} 15440 -40980 0 0 {name=p14666 lab=_85128_/Q }
C {devices/lab_pin.sym} 15560 -41000 0 1 {name=p14667 lab=_56853_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -41000 0 0 {name=X_56853_ }
C {devices/lab_pin.sym} 15440 -40880 0 0 {name=p14668 lab=_69685_/A }
C {devices/lab_pin.sym} 15440 -40840 0 0 {name=p14669 lab=_87328_/Q }
C {devices/lab_pin.sym} 15560 -40860 0 1 {name=p14670 lab=_68839_/X }
C {sky130_stdcells/and2_4.sym} 15500 -40860 0 0 {name=X_68839_ }
C {devices/lab_pin.sym} 15410 -40730 0 0 {name=p14671 lab=_87671_/CLK }
C {devices/lab_pin.sym} 15410 -40710 0 0 {name=p14672 lab=_87673_/D }
C {devices/lab_pin.sym} 15590 -40730 0 1 {name=p14673 lab=_67188_/B }
C {sky130_stdcells/dfxtp_4.sym} 15500 -40720 0 0 {name=X_87673_ }
C {devices/lab_pin.sym} 15410 -40590 0 0 {name=p14674 lab=_84885_/CLK }
C {devices/lab_pin.sym} 15410 -40570 0 0 {name=p14675 lab=_84885_/D }
C {devices/lab_pin.sym} 15590 -40590 0 1 {name=p14676 lab=_64525_/C }
C {sky130_stdcells/dfxtp_4.sym} 15500 -40580 0 0 {name=X_84885_ }
C {devices/lab_pin.sym} 15420 -40480 0 0 {name=p14677 lab=_56246_/C }
C {devices/lab_pin.sym} 15420 -40440 0 0 {name=p14678 lab=_55311_/X }
C {devices/lab_pin.sym} 15420 -40400 0 0 {name=p14679 lab=_44046_/X }
C {devices/lab_pin.sym} 15420 -40360 0 0 {name=p14680 lab=_55803_/X }
C {devices/lab_pin.sym} 15580 -40420 0 1 {name=p14681 lab=_55804_/X }
C {sky130_stdcells/a211o_4.sym} 15500 -40420 0 0 {name=X_55804_ }
C {devices/lab_pin.sym} 15410 -40270 0 0 {name=p14682 lab=_84922_/CLK }
C {devices/lab_pin.sym} 15410 -40250 0 0 {name=p14683 lab=_86624_/D }
C {devices/lab_pin.sym} 15590 -40270 0 1 {name=p14684 lab=_72129_/A }
C {sky130_stdcells/dfxtp_4.sym} 15500 -40260 0 0 {name=X_86624_ }
C {devices/lab_pin.sym} 15460 -40130 0 0 {name=p14685 lab=_71867_/B }
C {devices/lab_pin.sym} 15540 -40130 0 1 {name=p14686 lab=_71857_/B }
C {sky130_stdcells/buf_2.sym} 15500 -40130 0 0 {name=X_71850_ }
C {devices/lab_pin.sym} 15410 -40010 0 0 {name=p14687 lab=_83191_/CLK }
C {devices/lab_pin.sym} 15410 -39990 0 0 {name=p14688 lab=_83836_/D }
C {devices/lab_pin.sym} 15590 -40010 0 1 {name=p14689 lab=_74763_/C }
C {sky130_stdcells/dfxtp_4.sym} 15500 -40000 0 0 {name=X_83836_ }
C {devices/lab_pin.sym} 15460 -39870 0 0 {name=p14690 lab=_60160_/B }
C {devices/lab_pin.sym} 15540 -39870 0 1 {name=p14691 lab=_60620_/B }
C {sky130_stdcells/buf_2.sym} 15500 -39870 0 0 {name=X_59572_ }
C {devices/lab_pin.sym} 15460 -39750 0 0 {name=p14692 lab=_56768_/Y }
C {devices/lab_pin.sym} 15540 -39750 0 1 {name=p14693 lab=_56785_/D }
C {sky130_stdcells/buf_2.sym} 15500 -39750 0 0 {name=X_56784_ }
C {devices/lab_pin.sym} 15420 -39650 0 0 {name=p14694 lab=_85526_/Q }
C {devices/lab_pin.sym} 15420 -39610 0 0 {name=p14695 lab=_53989_/X }
C {devices/lab_pin.sym} 15420 -39570 0 0 {name=p14696 lab=_53995_/Y }
C {devices/lab_pin.sym} 15580 -39610 0 1 {name=p14697 lab=_53996_/Y }
C {sky130_stdcells/o21ai_4.sym} 15500 -39610 0 0 {name=X_53996_ }
C {devices/lab_pin.sym} 15460 -39470 0 0 {name=p14698 lab=_70800_/X }
C {devices/lab_pin.sym} 15540 -39470 0 1 {name=p14699 lab=_70802_/A }
C {sky130_stdcells/buf_2.sym} 15500 -39470 0 0 {name=X_70801_ }
C {devices/lab_pin.sym} 15460 -39350 0 0 {name=p14700 lab=_84828_/Q }
C {devices/lab_pin.sym} 15540 -39350 0 1 {name=p14701 lab=_63520_/B }
C {sky130_stdcells/buf_2.sym} 15500 -39350 0 0 {name=X_58523_ }
C {devices/lab_pin.sym} 15460 -39230 0 0 {name=p14702 lab=clkbuf_6_55_0_CLK/X }
C {devices/lab_pin.sym} 15540 -39230 0 1 {name=p14703 lab=clkbuf_8_223_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 15500 -39230 0 0 {name=Xclkbuf_7_111_0_CLK }
C {devices/lab_pin.sym} 15420 -39130 0 0 {name=p14704 lab=_55728_/Y }
C {devices/lab_pin.sym} 15420 -39090 0 0 {name=p14705 lab=_55729_/Y }
C {devices/lab_pin.sym} 15420 -39050 0 0 {name=p14706 lab=_55734_/Y }
C {devices/lab_pin.sym} 15580 -39090 0 1 {name=p14707 lab=_56158_/A }
C {sky130_stdcells/a21oi_4.sym} 15500 -39090 0 0 {name=X_55735_ }
C {devices/lab_pin.sym} 15410 -38950 0 0 {name=p14708 lab=_85915_/CLK }
C {devices/lab_pin.sym} 15410 -38930 0 0 {name=p14709 lab=_48214_/Y }
C {devices/lab_pin.sym} 15590 -38950 0 1 {name=p14710 lab=_65997_/B }
C {sky130_stdcells/dfxtp_4.sym} 15500 -38940 0 0 {name=X_86555_ }
C {devices/lab_pin.sym} 15460 -38810 0 0 {name=p14711 lab=_40960_/Y }
C {devices/lab_pin.sym} 15540 -38810 0 1 {name=p14712 lab=_88303_/D }
C {sky130_stdcells/inv_2.sym} 15500 -38810 0 0 {name=X_40961_ }
C {devices/lab_pin.sym} 15460 -38690 0 0 {name=p14713 lab=_52893_/X }
C {devices/lab_pin.sym} 15540 -38690 0 1 {name=p14714 lab=_52947_/X }
C {sky130_stdcells/buf_2.sym} 15500 -38690 0 0 {name=X_52947_ }
C {devices/lab_pin.sym} 15460 -38570 0 0 {name=p14715 lab=_71823_/A }
C {devices/lab_pin.sym} 15540 -38570 0 1 {name=p14716 lab=_71783_/A }
C {sky130_stdcells/buf_2.sym} 15500 -38570 0 0 {name=X_71781_ }
C {devices/lab_pin.sym} 15410 -38450 0 0 {name=p14717 lab=_82251_/CLK }
C {devices/lab_pin.sym} 15410 -38430 0 0 {name=p14718 lab=_70474_/Y }
C {devices/lab_pin.sym} 15590 -38450 0 1 {name=p14719 lab=_58350_/A }
C {sky130_stdcells/dfxtp_4.sym} 15500 -38440 0 0 {name=X_83767_ }
C {devices/lab_pin.sym} 15410 -38310 0 0 {name=p14720 lab=_81061_/CLK }
C {devices/lab_pin.sym} 15410 -38290 0 0 {name=p14721 lab=_75731_/X }
C {devices/lab_pin.sym} 15590 -38310 0 1 {name=p14722 lab=_75138_/B }
C {sky130_stdcells/dfxtp_4.sym} 15500 -38300 0 0 {name=X_80979_ }
C {devices/lab_pin.sym} 15460 -38170 0 0 {name=p14723 lab=_42700_/A }
C {devices/lab_pin.sym} 15540 -38170 0 1 {name=p14724 lab=_42700_/X }
C {sky130_stdcells/buf_2.sym} 15500 -38170 0 0 {name=X_42700_ }
C {devices/lab_pin.sym} 15420 -38080 0 0 {name=p14725 lab=_73359_/X }
C {devices/lab_pin.sym} 15420 -38040 0 0 {name=p14726 lab=_83051_/Q }
C {devices/lab_pin.sym} 15420 -38000 0 0 {name=p14727 lab=_73406_/X }
C {devices/lab_pin.sym} 15420 -37960 0 0 {name=p14728 lab=_73519_/X }
C {devices/lab_pin.sym} 15580 -38020 0 1 {name=p14729 lab=_73521_/B }
C {sky130_stdcells/a211o_4.sym} 15500 -38020 0 0 {name=X_73520_ }
C {devices/lab_pin.sym} 15410 -37870 0 0 {name=p14730 lab=_86733_/CLK }
C {devices/lab_pin.sym} 15410 -37850 0 0 {name=p14731 lab=_54092_/Y }
C {devices/lab_pin.sym} 15590 -37870 0 1 {name=p14732 lab=_85506_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -37860 0 0 {name=X_85506_ }
C {devices/lab_pin.sym} 15460 -37730 0 0 {name=p14733 lab=_83476_/Q }
C {devices/lab_pin.sym} 15540 -37730 0 1 {name=p14734 lab=_58454_/Y }
C {sky130_stdcells/inv_2.sym} 15500 -37730 0 0 {name=X_58454_ }
C {devices/lab_pin.sym} 15460 -37610 0 0 {name=p14735 lab=_71735_/D }
C {devices/lab_pin.sym} 15540 -37610 0 1 {name=p14736 lab=_70732_/X }
C {sky130_stdcells/buf_2.sym} 15500 -37610 0 0 {name=X_70732_ }
C {devices/lab_pin.sym} 15410 -37490 0 0 {name=p14737 lab=_81216_/CLK }
C {devices/lab_pin.sym} 15410 -37470 0 0 {name=p14738 lab=_79071_/X }
C {devices/lab_pin.sym} 15590 -37490 0 1 {name=p14739 lab=_82674_/D }
C {sky130_stdcells/dfxtp_4.sym} 15500 -37480 0 0 {name=X_82718_ }
C {devices/lab_pin.sym} 15420 -37380 0 0 {name=p14740 lab=_40776_/X }
C {devices/lab_pin.sym} 15420 -37340 0 0 {name=p14741 lab=_43671_/X }
C {devices/lab_pin.sym} 15420 -37300 0 0 {name=p14742 lab=_72800_/A }
C {devices/lab_pin.sym} 15420 -37260 0 0 {name=p14743 lab=_43673_/X }
C {devices/lab_pin.sym} 15580 -37320 0 1 {name=p14744 lab=_43680_/X }
C {sky130_stdcells/a2bb2o_4.sym} 15500 -37320 0 0 {name=X_43680_ }
C {devices/lab_pin.sym} 15440 -37180 0 0 {name=p14745 lab=_55657_/Y }
C {devices/lab_pin.sym} 15440 -37140 0 0 {name=p14746 lab=_55656_/X }
C {devices/lab_pin.sym} 15560 -37160 0 1 {name=p14747 lab=_55666_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -37160 0 0 {name=X_55666_ }
C {devices/lab_pin.sym} 15410 -37030 0 0 {name=p14748 lab=_85879_/CLK }
C {devices/lab_pin.sym} 15410 -37010 0 0 {name=p14749 lab=_86486_/D }
C {devices/lab_pin.sym} 15590 -37030 0 1 {name=p14750 lab=_86486_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -37020 0 0 {name=X_86486_ }
C {devices/lab_pin.sym} 15460 -36890 0 0 {name=p14751 lab=clkbuf_9_40_0_CLK/X }
C {devices/lab_pin.sym} 15540 -36890 0 1 {name=p14752 lab=_86896_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 15500 -36890 0 0 {name=Xclkbuf_10_81_0_CLK }
C {devices/lab_pin.sym} 15440 -36780 0 0 {name=p14753 lab=_82857_/Q }
C {devices/lab_pin.sym} 15440 -36740 0 0 {name=p14754 lab=_40883_/B }
C {devices/lab_pin.sym} 15560 -36760 0 1 {name=p14755 lab=_40892_/X }
C {sky130_stdcells/or2_4.sym} 15500 -36760 0 0 {name=X_40892_ }
C {devices/lab_pin.sym} 15460 -36630 0 0 {name=p14756 lab=_52852_/A }
C {devices/lab_pin.sym} 15540 -36630 0 1 {name=p14757 lab=_52879_/B }
C {sky130_stdcells/buf_2.sym} 15500 -36630 0 0 {name=X_52878_ }
C {devices/lab_pin.sym} 15410 -36510 0 0 {name=p14758 lab=_83699_/CLK }
C {devices/lab_pin.sym} 15410 -36490 0 0 {name=p14759 lab=_70797_/Y }
C {devices/lab_pin.sym} 15590 -36510 0 1 {name=p14760 lab=_47135_/A }
C {sky130_stdcells/dfxtp_4.sym} 15500 -36500 0 0 {name=X_83698_ }
C {devices/lab_pin.sym} 15420 -36400 0 0 {name=p14761 lab=_57394_/X }
C {devices/lab_pin.sym} 15420 -36360 0 0 {name=p14762 lab=_56639_/X }
C {devices/lab_pin.sym} 15420 -36320 0 0 {name=p14763 lab=_45599_/A }
C {devices/lab_pin.sym} 15420 -36280 0 0 {name=p14764 lab=_57395_/X }
C {devices/lab_pin.sym} 15580 -36340 0 1 {name=p14765 lab=_85012_/D }
C {sky130_stdcells/a2bb2o_4.sym} 15500 -36340 0 0 {name=X_57405_ }
C {devices/lab_pin.sym} 15410 -36190 0 0 {name=p14766 lab=_88158_/CLK }
C {devices/lab_pin.sym} 15410 -36170 0 0 {name=p14767 lab=_88225_/D }
C {devices/lab_pin.sym} 15590 -36190 0 1 {name=p14768 lab=_67767_/B }
C {sky130_stdcells/dfxtp_4.sym} 15500 -36180 0 0 {name=X_88225_ }
C {devices/lab_pin.sym} 15460 -36050 0 0 {name=p14769 lab=_53189_/A }
C {devices/lab_pin.sym} 15540 -36050 0 1 {name=p14770 lab=_42631_/X }
C {sky130_stdcells/buf_2.sym} 15500 -36050 0 0 {name=X_42631_ }
C {devices/lab_pin.sym} 15460 -35930 0 0 {name=p14771 lab=_54616_/X }
C {devices/lab_pin.sym} 15540 -35930 0 1 {name=p14772 lab=_54625_/A }
C {sky130_stdcells/buf_2.sym} 15500 -35930 0 0 {name=X_54617_ }
C {devices/lab_pin.sym} 15410 -35810 0 0 {name=p14773 lab=_85757_/CLK }
C {devices/lab_pin.sym} 15410 -35790 0 0 {name=p14774 lab=_85437_/D }
C {devices/lab_pin.sym} 15590 -35810 0 1 {name=p14775 lab=_85437_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -35800 0 0 {name=X_85437_ }
C {devices/lab_pin.sym} 15460 -35670 0 0 {name=p14776 lab=_72910_/A }
C {devices/lab_pin.sym} 15540 -35670 0 1 {name=p14777 lab=_73497_/A }
C {sky130_stdcells/buf_2.sym} 15500 -35670 0 0 {name=X_73451_ }
C {devices/lab_pin.sym} 15420 -35570 0 0 {name=p14778 lab=_51827_/Y }
C {devices/lab_pin.sym} 15420 -35530 0 0 {name=p14779 lab=_51823_/X }
C {devices/lab_pin.sym} 15420 -35490 0 0 {name=p14780 lab=_51828_/X }
C {devices/lab_pin.sym} 15580 -35530 0 1 {name=p14781 lab=_85939_/D }
C {sky130_stdcells/a21oi_4.sym} 15500 -35530 0 0 {name=X_51829_ }
C {devices/lab_pin.sym} 15440 -35420 0 0 {name=p14782 lab=_70884_/A }
C {devices/lab_pin.sym} 15440 -35380 0 0 {name=p14783 lab=_70635_/A }
C {devices/lab_pin.sym} 15440 -35340 0 0 {name=p14784 lab=_70662_/X }
C {devices/lab_pin.sym} 15440 -35300 0 0 {name=p14785 lab=_70591_/A }
C {devices/lab_pin.sym} 15560 -35360 0 1 {name=p14786 lab=_70664_/A }
C {sky130_stdcells/nand4_4.sym} 15500 -35360 0 0 {name=X_70663_ }
C {devices/lab_pin.sym} 15460 -35210 0 0 {name=p14787 lab=_84862_/Q }
C {devices/lab_pin.sym} 15540 -35210 0 1 {name=p14788 lab=_58385_/Y }
C {sky130_stdcells/inv_2.sym} 15500 -35210 0 0 {name=X_58385_ }
C {devices/lab_pin.sym} 15410 -35090 0 0 {name=p14789 lab=_81755_/CLK }
C {devices/lab_pin.sym} 15410 -35070 0 0 {name=p14790 lab=_84001_/Q }
C {devices/lab_pin.sym} 15590 -35090 0 1 {name=p14791 lab=_79012_/A }
C {sky130_stdcells/dfxtp_4.sym} 15500 -35080 0 0 {name=X_82649_ }
C {devices/lab_pin.sym} 15420 -34980 0 0 {name=p14792 lab=_45444_/A }
C {devices/lab_pin.sym} 15420 -34940 0 0 {name=p14793 lab=_55571_/X }
C {devices/lab_pin.sym} 15420 -34900 0 0 {name=p14794 lab=_55610_/A }
C {devices/lab_pin.sym} 15420 -34860 0 0 {name=p14795 lab=_55596_/Y }
C {devices/lab_pin.sym} 15580 -34920 0 1 {name=p14796 lab=_55597_/X }
C {sky130_stdcells/a211o_4.sym} 15500 -34920 0 0 {name=X_55597_ }
C {devices/lab_pin.sym} 15460 -34770 0 0 {name=p14797 lab=clkbuf_6_63_0_CLK/X }
C {devices/lab_pin.sym} 15540 -34770 0 1 {name=p14798 lab=clkbuf_8_253_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 15500 -34770 0 0 {name=Xclkbuf_7_126_0_CLK }
C {devices/lab_pin.sym} 15420 -34690 0 0 {name=p14799 lab=_57800_/X }
C {devices/lab_pin.sym} 15420 -34650 0 0 {name=p14800 lab=_72400_/Y }
C {devices/lab_pin.sym} 15420 -34610 0 0 {name=p14801 lab=_72401_/Y }
C {devices/lab_pin.sym} 15420 -34570 0 0 {name=p14802 lab=_64761_/B }
C {devices/lab_pin.sym} 15420 -34530 0 0 {name=p14803 lab=_59833_/X }
C {devices/lab_pin.sym} 15580 -34610 0 1 {name=p14804 lab=_72402_/X }
C {sky130_stdcells/o32a_4.sym} 15500 -34610 0 0 {name=X_72402_ }
C {devices/lab_pin.sym} 15460 -34450 0 0 {name=p14805 lab=_45350_/A }
C {devices/lab_pin.sym} 15540 -34450 0 1 {name=p14806 lab=_45350_/X }
C {sky130_stdcells/buf_2.sym} 15500 -34450 0 0 {name=X_45350_ }
C {devices/lab_pin.sym} 15460 -34330 0 0 {name=p14807 lab=_57335_/Y }
C {devices/lab_pin.sym} 15540 -34330 0 1 {name=p14808 lab=_85033_/D }
C {sky130_stdcells/inv_2.sym} 15500 -34330 0 0 {name=X_57336_ }
C {devices/lab_pin.sym} 15440 -34220 0 0 {name=p14809 lab=_81347_/Q }
C {devices/lab_pin.sym} 15440 -34180 0 0 {name=p14810 lab=_81603_/D }
C {devices/lab_pin.sym} 15560 -34200 0 1 {name=p14811 lab=_76170_/X }
C {sky130_stdcells/xor2_4.sym} 15500 -34200 0 0 {name=X_76170_ }
C {devices/lab_pin.sym} 15410 -34070 0 0 {name=p14812 lab=_87141_/CLK }
C {devices/lab_pin.sym} 15410 -34050 0 0 {name=p14813 lab=_88156_/D }
C {devices/lab_pin.sym} 15590 -34070 0 1 {name=p14814 lab=_67885_/B }
C {sky130_stdcells/dfxtp_4.sym} 15500 -34060 0 0 {name=X_88156_ }
C {devices/lab_pin.sym} 15460 -33930 0 0 {name=p14815 lab=_87819_/Q }
C {devices/lab_pin.sym} 15540 -33930 0 1 {name=p14816 lab=_69676_/B }
C {sky130_stdcells/inv_2.sym} 15500 -33930 0 0 {name=X_42562_ }
C {devices/lab_pin.sym} 15460 -33810 0 0 {name=p14817 lab=_54521_/A }
C {devices/lab_pin.sym} 15540 -33810 0 1 {name=p14818 lab=_54559_/B }
C {sky130_stdcells/buf_2.sym} 15500 -33810 0 0 {name=X_54548_ }
C {devices/lab_pin.sym} 15420 -33720 0 0 {name=p14819 lab=_72908_/X }
C {devices/lab_pin.sym} 15420 -33680 0 0 {name=p14820 lab=_85577_/Q }
C {devices/lab_pin.sym} 15420 -33640 0 0 {name=p14821 lab=_72909_/X }
C {devices/lab_pin.sym} 15420 -33600 0 0 {name=p14822 lab=_73381_/X }
C {devices/lab_pin.sym} 15580 -33660 0 1 {name=p14823 lab=_73382_/X }
C {sky130_stdcells/a211o_4.sym} 15500 -33660 0 0 {name=X_73382_ }
C {devices/lab_pin.sym} 15410 -33510 0 0 {name=p14824 lab=_83275_/CLK }
C {devices/lab_pin.sym} 15410 -33490 0 0 {name=p14825 lab=_85368_/D }
C {devices/lab_pin.sym} 15590 -33510 0 1 {name=p14826 lab=_85368_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -33500 0 0 {name=X_85368_ }
C {devices/lab_pin.sym} 15460 -33370 0 0 {name=p14827 lab=_70620_/D }
C {devices/lab_pin.sym} 15540 -33370 0 1 {name=p14828 lab=_70594_/X }
C {sky130_stdcells/buf_2.sym} 15500 -33370 0 0 {name=X_70594_ }
C {devices/lab_pin.sym} 15440 -33270 0 0 {name=p14829 lab=_44006_/X }
C {devices/lab_pin.sym} 15440 -33230 0 0 {name=p14830 lab=_44164_/X }
C {devices/lab_pin.sym} 15440 -33190 0 0 {name=p14831 lab=_44300_/Y }
C {devices/lab_pin.sym} 15560 -33230 0 1 {name=p14832 lab=_44301_/Y }
C {sky130_stdcells/nand3_4.sym} 15500 -33230 0 0 {name=X_44301_ }
C {devices/lab_pin.sym} 15440 -33100 0 0 {name=p14833 lab=_75119_/X }
C {devices/lab_pin.sym} 15440 -33060 0 0 {name=p14834 lab=_75121_/B }
C {devices/lab_pin.sym} 15560 -33080 0 1 {name=p14835 lab=_75122_/A }
C {sky130_stdcells/nand2_4.sym} 15500 -33080 0 0 {name=X_75121_ }
C {devices/lab_pin.sym} 15410 -32950 0 0 {name=p14836 lab=_87417_/CLK }
C {devices/lab_pin.sym} 15410 -32930 0 0 {name=p14837 lab=_87107_/D }
C {devices/lab_pin.sym} 15590 -32950 0 1 {name=p14838 lab=_87107_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -32940 0 0 {name=X_87107_ }
C {devices/lab_pin.sym} 15440 -32820 0 0 {name=p14839 lab=_41513_/A }
C {devices/lab_pin.sym} 15440 -32780 0 0 {name=p14840 lab=_82326_/Q }
C {devices/lab_pin.sym} 15560 -32800 0 1 {name=p14841 lab=_41513_/X }
C {sky130_stdcells/or2_4.sym} 15500 -32800 0 0 {name=X_41513_ }
C {devices/lab_pin.sym} 15420 -32710 0 0 {name=p14842 lab=_72270_/X }
C {devices/lab_pin.sym} 15420 -32670 0 0 {name=p14843 lab=_72331_/Y }
C {devices/lab_pin.sym} 15420 -32630 0 0 {name=p14844 lab=_72332_/Y }
C {devices/lab_pin.sym} 15420 -32590 0 0 {name=p14845 lab=_72296_/X }
C {devices/lab_pin.sym} 15420 -32550 0 0 {name=p14846 lab=_72274_/X }
C {devices/lab_pin.sym} 15580 -32630 0 1 {name=p14847 lab=_72333_/X }
C {sky130_stdcells/o32a_4.sym} 15500 -32630 0 0 {name=X_72333_ }
C {devices/lab_pin.sym} 15410 -32470 0 0 {name=p14848 lab=_84321_/CLK }
C {devices/lab_pin.sym} 15410 -32450 0 0 {name=p14849 lab=_84319_/D }
C {devices/lab_pin.sym} 15590 -32470 0 1 {name=p14850 lab=_63493_/C }
C {sky130_stdcells/dfxtp_4.sym} 15500 -32460 0 0 {name=X_84319_ }
C {devices/lab_pin.sym} 15460 -32330 0 0 {name=p14851 lab=_45281_/A }
C {devices/lab_pin.sym} 15540 -32330 0 1 {name=p14852 lab=_45281_/X }
C {sky130_stdcells/buf_2.sym} 15500 -32330 0 0 {name=X_45281_ }
C {devices/lab_pin.sym} 15460 -32210 0 0 {name=p14853 lab=clkbuf_9_48_0_CLK/X }
C {devices/lab_pin.sym} 15540 -32210 0 1 {name=p14854 lab=_85134_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 15500 -32210 0 0 {name=Xclkbuf_10_96_0_CLK }
C {devices/lab_pin.sym} 15440 -32120 0 0 {name=p14855 lab=_56755_/X }
C {devices/lab_pin.sym} 15440 -32080 0 0 {name=p14856 lab=_57140_/B }
C {devices/lab_pin.sym} 15440 -32040 0 0 {name=p14857 lab=_56759_/X }
C {devices/lab_pin.sym} 15440 -32000 0 0 {name=p14858 lab=_57272_/D }
C {devices/lab_pin.sym} 15560 -32060 0 1 {name=p14859 lab=_57267_/X }
C {sky130_stdcells/and4_4.sym} 15500 -32060 0 0 {name=X_57267_ }
C {devices/lab_pin.sym} 15410 -31910 0 0 {name=p14860 lab=_88087_/CLK }
C {devices/lab_pin.sym} 15410 -31890 0 0 {name=p14861 lab=_41972_/Y }
C {devices/lab_pin.sym} 15590 -31910 0 1 {name=p14862 lab=_74204_/A }
C {sky130_stdcells/dfxtp_4.sym} 15500 -31900 0 0 {name=X_88087_ }
C {devices/lab_pin.sym} 15420 -31810 0 0 {name=p14863 lab=_42466_/X }
C {devices/lab_pin.sym} 15420 -31770 0 0 {name=p14864 lab=_42467_/X }
C {devices/lab_pin.sym} 15420 -31730 0 0 {name=p14865 lab=_40661_/X }
C {devices/lab_pin.sym} 15420 -31690 0 0 {name=p14866 lab=_68692_/A }
C {devices/lab_pin.sym} 15420 -31650 0 0 {name=p14867 lab=_42480_/X }
C {devices/lab_pin.sym} 15580 -31730 0 1 {name=p14868 lab=_42494_/A }
C {sky130_stdcells/o32ai_4.sym} 15500 -31730 0 0 {name=X_42493_ }
C {devices/lab_pin.sym} 15420 -31590 0 0 {name=p14869 lab=_85434_/Q }
C {devices/lab_pin.sym} 15420 -31550 0 0 {name=p14870 lab=_54457_/X }
C {devices/lab_pin.sym} 15420 -31510 0 0 {name=p14871 lab=_54478_/Y }
C {devices/lab_pin.sym} 15580 -31550 0 1 {name=p14872 lab=_54479_/Y }
C {sky130_stdcells/o21ai_4.sym} 15500 -31550 0 0 {name=X_54479_ }
C {devices/lab_pin.sym} 15410 -31410 0 0 {name=p14873 lab=_85279_/CLK }
C {devices/lab_pin.sym} 15410 -31390 0 0 {name=p14874 lab=_85299_/D }
C {devices/lab_pin.sym} 15590 -31410 0 1 {name=p14875 lab=_56080_/C }
C {sky130_stdcells/dfxtp_4.sym} 15500 -31400 0 0 {name=X_85299_ }
C {devices/lab_pin.sym} 15460 -31270 0 0 {name=p14876 lab=_54498_/D }
C {devices/lab_pin.sym} 15540 -31270 0 1 {name=p14877 lab=_52805_/D }
C {sky130_stdcells/buf_2.sym} 15500 -31270 0 0 {name=X_47020_ }
C {devices/lab_pin.sym} 15440 -31160 0 0 {name=p14878 lab=_58920_/A }
C {devices/lab_pin.sym} 15440 -31120 0 0 {name=p14879 lab=_86368_/Q }
C {devices/lab_pin.sym} 15560 -31140 0 1 {name=p14880 lab=_59006_/Y }
C {sky130_stdcells/nor2_4.sym} 15500 -31140 0 0 {name=X_59006_ }
C {devices/lab_pin.sym} 15460 -31010 0 0 {name=p14881 lab=clkbuf_8_243_0_CLK/A }
C {devices/lab_pin.sym} 15540 -31010 0 1 {name=p14882 lab=clkbuf_8_242_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 15500 -31010 0 0 {name=Xclkbuf_8_242_0_CLK }
C {devices/lab_pin.sym} 15440 -30910 0 0 {name=p14883 lab=_44227_/Y }
C {devices/lab_pin.sym} 15440 -30870 0 0 {name=p14884 lab=_44232_/B }
C {devices/lab_pin.sym} 15440 -30830 0 0 {name=p14885 lab=_44242_/C }
C {devices/lab_pin.sym} 15560 -30870 0 1 {name=p14886 lab=_44232_/Y }
C {sky130_stdcells/nand3_4.sym} 15500 -30870 0 0 {name=X_44232_ }
C {devices/lab_pin.sym} 15460 -30730 0 0 {name=p14887 lab=_56123_/A }
C {devices/lab_pin.sym} 15540 -30730 0 1 {name=p14888 lab=_56229_/B }
C {sky130_stdcells/buf_2.sym} 15500 -30730 0 0 {name=X_56218_ }
C {devices/lab_pin.sym} 15420 -30630 0 0 {name=p14889 lab=_75047_/Y }
C {devices/lab_pin.sym} 15420 -30590 0 0 {name=p14890 lab=_75023_/B }
C {devices/lab_pin.sym} 15420 -30550 0 0 {name=p14891 lab=_75051_/X }
C {devices/lab_pin.sym} 15580 -30590 0 1 {name=p14892 lab=_75053_/B }
C {sky130_stdcells/o21ai_4.sym} 15500 -30590 0 0 {name=X_75052_ }
C {devices/lab_pin.sym} 15410 -30450 0 0 {name=p14893 lab=_86989_/CLK }
C {devices/lab_pin.sym} 15410 -30430 0 0 {name=p14894 lab=_44605_/X }
C {devices/lab_pin.sym} 15590 -30450 0 1 {name=p14895 lab=_87038_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -30440 0 0 {name=X_87038_ }
C {devices/lab_pin.sym} 15460 -30310 0 0 {name=p14896 lab=_41444_/A }
C {devices/lab_pin.sym} 15540 -30310 0 1 {name=p14897 lab=_41444_/Y }
C {sky130_stdcells/inv_2.sym} 15500 -30310 0 0 {name=X_41444_ }
C {devices/lab_pin.sym} 15460 -30190 0 0 {name=p14898 lab=_57708_/X }
C {devices/lab_pin.sym} 15540 -30190 0 1 {name=p14899 lab=_72264_/X }
C {sky130_stdcells/buf_2.sym} 15500 -30190 0 0 {name=X_72264_ }
C {devices/lab_pin.sym} 15440 -30080 0 0 {name=p14900 lab=_56842_/X }
C {devices/lab_pin.sym} 15440 -30040 0 0 {name=p14901 lab=_57198_/B }
C {devices/lab_pin.sym} 15560 -30060 0 1 {name=p14902 lab=_57198_/X }
C {sky130_stdcells/xor2_4.sym} 15500 -30060 0 0 {name=X_57198_ }
C {devices/lab_pin.sym} 15440 -29940 0 0 {name=p14903 lab=_74002_/X }
C {devices/lab_pin.sym} 15440 -29900 0 0 {name=p14904 lab=_74003_/B }
C {devices/lab_pin.sym} 15560 -29920 0 1 {name=p14905 lab=_74003_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -29920 0 0 {name=X_74003_ }
C {devices/lab_pin.sym} 15440 -29810 0 0 {name=p14906 lab=_71507_/A }
C {devices/lab_pin.sym} 15440 -29770 0 0 {name=p14907 lab=_70428_/A }
C {devices/lab_pin.sym} 15440 -29730 0 0 {name=p14908 lab=_71215_/C }
C {devices/lab_pin.sym} 15560 -29770 0 1 {name=p14909 lab=_71215_/Y }
C {sky130_stdcells/nor3_4.sym} 15500 -29770 0 0 {name=X_71215_ }
C {devices/lab_pin.sym} 15440 -29640 0 0 {name=p14910 lab=_44162_/Y }
C {devices/lab_pin.sym} 15440 -29600 0 0 {name=p14911 lab=_44163_/B }
C {devices/lab_pin.sym} 15560 -29620 0 1 {name=p14912 lab=_87184_/D }
C {sky130_stdcells/nor2_4.sym} 15500 -29620 0 0 {name=X_44163_ }
C {devices/lab_pin.sym} 15460 -29490 0 0 {name=p14913 lab=_56123_/A }
C {devices/lab_pin.sym} 15540 -29490 0 1 {name=p14914 lab=_56150_/B }
C {sky130_stdcells/buf_2.sym} 15500 -29490 0 0 {name=X_56149_ }
C {devices/lab_pin.sym} 15440 -29380 0 0 {name=p14915 lab=_79845_/X }
C {devices/lab_pin.sym} 15440 -29340 0 0 {name=p14916 lab=_79860_/B }
C {devices/lab_pin.sym} 15560 -29360 0 1 {name=p14917 lab=_79860_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -29360 0 0 {name=X_79860_ }
C {devices/lab_pin.sym} 15420 -29250 0 0 {name=p14918 lab=_41373_/X }
C {devices/lab_pin.sym} 15420 -29210 0 0 {name=p14919 lab=_41719_/A }
C {devices/lab_pin.sym} 15420 -29170 0 0 {name=p14920 lab=_41374_/X }
C {devices/lab_pin.sym} 15580 -29210 0 1 {name=p14921 lab=_41376_/A }
C {sky130_stdcells/o21a_4.sym} 15500 -29210 0 0 {name=X_41375_ }
C {devices/lab_pin.sym} 15420 -29110 0 0 {name=p14922 lab=_72137_/X }
C {devices/lab_pin.sym} 15420 -29070 0 0 {name=p14923 lab=_72192_/Y }
C {devices/lab_pin.sym} 15420 -29030 0 0 {name=p14924 lab=_72193_/Y }
C {devices/lab_pin.sym} 15420 -28990 0 0 {name=p14925 lab=_72194_/X }
C {devices/lab_pin.sym} 15420 -28950 0 0 {name=p14926 lab=_72141_/X }
C {devices/lab_pin.sym} 15580 -29030 0 1 {name=p14927 lab=_72195_/X }
C {sky130_stdcells/o32a_4.sym} 15500 -29030 0 0 {name=X_72195_ }
C {devices/lab_pin.sym} 15420 -28910 0 0 {name=p14928 lab=_43105_/X }
C {devices/lab_pin.sym} 15420 -28870 0 0 {name=p14929 lab=_43106_/X }
C {devices/lab_pin.sym} 15420 -28830 0 0 {name=p14930 lab=_40767_/X }
C {devices/lab_pin.sym} 15420 -28790 0 0 {name=p14931 lab=_43113_/Y }
C {devices/lab_pin.sym} 15420 -28750 0 0 {name=p14932 lab=_43108_/X }
C {devices/lab_pin.sym} 15580 -28830 0 1 {name=p14933 lab=_43114_/Y }
C {sky130_stdcells/o32ai_4.sym} 15500 -28830 0 0 {name=X_43114_ }
C {devices/lab_pin.sym} 15460 -28670 0 0 {name=p14934 lab=_82547_/Q }
C {devices/lab_pin.sym} 15540 -28670 0 1 {name=p14935 lab=_78812_/A }
C {sky130_stdcells/inv_2.sym} 15500 -28670 0 0 {name=X_78811_ }
C {devices/lab_pin.sym} 15460 -28550 0 0 {name=p14936 lab=_40326_/A }
C {devices/lab_pin.sym} 15540 -28550 0 1 {name=p14937 lab=_40629_/A }
C {sky130_stdcells/buf_2.sym} 15500 -28550 0 0 {name=X_40326_ }
C {devices/lab_pin.sym} 15460 -28430 0 0 {name=p14938 lab=_71225_/A }
C {devices/lab_pin.sym} 15540 -28430 0 1 {name=p14939 lab=_71155_/B }
C {sky130_stdcells/buf_2.sym} 15500 -28430 0 0 {name=X_71146_ }
C {devices/lab_pin.sym} 15420 -28330 0 0 {name=p14940 lab=_48965_/Y }
C {devices/lab_pin.sym} 15420 -28290 0 0 {name=p14941 lab=_48935_/X }
C {devices/lab_pin.sym} 15420 -28250 0 0 {name=p14942 lab=_48970_/X }
C {devices/lab_pin.sym} 15580 -28290 0 1 {name=p14943 lab=_86457_/D }
C {sky130_stdcells/a21oi_4.sym} 15500 -28290 0 0 {name=X_48971_ }
C {devices/lab_pin.sym} 15460 -28150 0 0 {name=p14944 lab=_55140_/A }
C {devices/lab_pin.sym} 15540 -28150 0 1 {name=p14945 lab=_44095_/A }
C {sky130_stdcells/buf_2.sym} 15500 -28150 0 0 {name=X_44094_ }
C {devices/lab_pin.sym} 15420 -28050 0 0 {name=p14946 lab=_79778_/X }
C {devices/lab_pin.sym} 15420 -28010 0 0 {name=p14947 lab=_79789_/X }
C {devices/lab_pin.sym} 15420 -27970 0 0 {name=p14948 lab=_79790_/X }
C {devices/lab_pin.sym} 15580 -28010 0 1 {name=p14949 lab=_79791_/Y }
C {sky130_stdcells/a21oi_4.sym} 15500 -28010 0 0 {name=X_79791_ }
C {devices/lab_pin.sym} 15460 -27870 0 0 {name=p14950 lab=clkbuf_9_126_0_CLK/X }
C {devices/lab_pin.sym} 15540 -27870 0 1 {name=p14951 lab=_81857_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 15500 -27870 0 0 {name=Xclkbuf_10_252_0_CLK }
C {devices/lab_pin.sym} 15460 -27750 0 0 {name=p14952 lab=_83777_/Q }
C {devices/lab_pin.sym} 15540 -27750 0 1 {name=p14953 lab=_73765_/A }
C {sky130_stdcells/inv_2.sym} 15500 -27750 0 0 {name=X_47922_ }
C {devices/lab_pin.sym} 15460 -27630 0 0 {name=p14954 lab=_43030_/A }
C {devices/lab_pin.sym} 15540 -27630 0 1 {name=p14955 lab=_43046_/A }
C {sky130_stdcells/buf_2.sym} 15500 -27630 0 0 {name=X_43045_ }
C {devices/lab_pin.sym} 15440 -27520 0 0 {name=p14956 lab=_61066_/B }
C {devices/lab_pin.sym} 15440 -27480 0 0 {name=p14957 lab=_61277_/C }
C {devices/lab_pin.sym} 15560 -27500 0 1 {name=p14958 lab=_59909_/C }
C {sky130_stdcells/nor2_4.sym} 15500 -27500 0 0 {name=X_59908_ }
C {devices/lab_pin.sym} 15440 -27380 0 0 {name=p14959 lab=_78742_/A }
C {devices/lab_pin.sym} 15440 -27340 0 0 {name=p14960 lab=_78742_/B }
C {devices/lab_pin.sym} 15560 -27360 0 1 {name=p14961 lab=_78742_/X }
C {sky130_stdcells/or2_4.sym} 15500 -27360 0 0 {name=X_78742_ }
C {devices/lab_pin.sym} 15420 -27250 0 0 {name=p14962 lab=_52307_/B }
C {devices/lab_pin.sym} 15420 -27210 0 0 {name=p14963 lab=_71070_/X }
C {devices/lab_pin.sym} 15420 -27170 0 0 {name=p14964 lab=_71076_/Y }
C {devices/lab_pin.sym} 15580 -27210 0 1 {name=p14965 lab=_83616_/D }
C {sky130_stdcells/o21ai_4.sym} 15500 -27210 0 0 {name=X_71077_ }
C {devices/lab_pin.sym} 15440 -27080 0 0 {name=p14966 lab=_75954_/A }
C {devices/lab_pin.sym} 15440 -27040 0 0 {name=p14967 lab=_75953_/Y }
C {devices/lab_pin.sym} 15560 -27060 0 1 {name=p14968 lab=_75955_/B }
C {sky130_stdcells/xnor2_4.sym} 15500 -27060 0 0 {name=X_75954_ }
C {devices/lab_pin.sym} 15460 -26930 0 0 {name=p14969 lab=clkbuf_9_441_0_CLK/X }
C {devices/lab_pin.sym} 15540 -26930 0 1 {name=p14970 lab=_86414_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 15500 -26930 0 0 {name=Xclkbuf_10_882_0_CLK }
C {devices/lab_pin.sym} 15440 -26820 0 0 {name=p14971 lab=_74905_/A }
C {devices/lab_pin.sym} 15440 -26780 0 0 {name=p14972 lab=_74904_/Y }
C {devices/lab_pin.sym} 15560 -26800 0 1 {name=p14973 lab=_74906_/B }
C {sky130_stdcells/xor2_4.sym} 15500 -26800 0 0 {name=X_74905_ }
C {devices/lab_pin.sym} 15420 -26690 0 0 {name=p14974 lab=_82549_/D }
C {devices/lab_pin.sym} 15420 -26650 0 0 {name=p14975 lab=_70010_/X }
C {devices/lab_pin.sym} 15420 -26610 0 0 {name=p14976 lab=_70027_/X }
C {devices/lab_pin.sym} 15580 -26650 0 1 {name=p14977 lab=_70028_/X }
C {sky130_stdcells/a21bo_4.sym} 15500 -26650 0 0 {name=X_70028_ }
C {devices/lab_pin.sym} 15460 -26510 0 0 {name=p14978 lab=_83559_/Q }
C {devices/lab_pin.sym} 15540 -26510 0 1 {name=p14979 lab=_47853_/Y }
C {sky130_stdcells/inv_2.sym} 15500 -26510 0 0 {name=X_47853_ }
C {devices/lab_pin.sym} 15460 -26390 0 0 {name=p14980 lab=_59839_/A }
C {devices/lab_pin.sym} 15540 -26390 0 1 {name=p14981 lab=_59839_/Y }
C {sky130_stdcells/inv_2.sym} 15500 -26390 0 0 {name=X_59839_ }
C {devices/lab_pin.sym} 15420 -26290 0 0 {name=p14982 lab=_78638_/B }
C {devices/lab_pin.sym} 15420 -26250 0 0 {name=p14983 lab=_78655_/B }
C {devices/lab_pin.sym} 15420 -26210 0 0 {name=p14984 lab=_78653_/X }
C {devices/lab_pin.sym} 15580 -26250 0 1 {name=p14985 lab=_78673_/X }
C {sky130_stdcells/a21bo_4.sym} 15500 -26250 0 0 {name=X_78673_ }
C {devices/lab_pin.sym} 15460 -26110 0 0 {name=p14986 lab=clkbuf_9_17_0_CLK/X }
C {devices/lab_pin.sym} 15540 -26110 0 1 {name=p14987 lab=_83008_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 15500 -26110 0 0 {name=Xclkbuf_10_34_0_CLK }
C {devices/lab_pin.sym} 15460 -25990 0 0 {name=p14988 lab=_75796_/Y }
C {devices/lab_pin.sym} 15540 -25990 0 1 {name=p14989 lab=_80795_/D }
C {sky130_stdcells/inv_2.sym} 15500 -25990 0 0 {name=X_75885_ }
C {devices/lab_pin.sym} 15460 -25870 0 0 {name=p14990 lab=clkbuf_9_373_0_CLK/A }
C {devices/lab_pin.sym} 15540 -25870 0 1 {name=p14991 lab=clkbuf_9_373_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 15500 -25870 0 0 {name=Xclkbuf_9_373_0_CLK }
C {devices/lab_pin.sym} 15460 -25750 0 0 {name=p14992 lab=_83669_/Q }
C {devices/lab_pin.sym} 15540 -25750 0 1 {name=p14993 lab=_52686_/B }
C {sky130_stdcells/inv_2.sym} 15500 -25750 0 0 {name=X_46804_ }
C {devices/lab_pin.sym} 15420 -25650 0 0 {name=p14994 lab=_77606_/A }
C {devices/lab_pin.sym} 15420 -25610 0 0 {name=p14995 lab=_77623_/Y }
C {devices/lab_pin.sym} 15420 -25570 0 0 {name=p14996 lab=_77590_/B }
C {devices/lab_pin.sym} 15580 -25610 0 1 {name=p14997 lab=_77624_/Y }
C {sky130_stdcells/o21ai_4.sym} 15500 -25610 0 0 {name=X_77624_ }
C {devices/lab_pin.sym} 15460 -25470 0 0 {name=p14998 lab=_62791_/X }
C {devices/lab_pin.sym} 15540 -25470 0 1 {name=p14999 lab=_62894_/A }
C {sky130_stdcells/buf_2.sym} 15500 -25470 0 0 {name=X_62850_ }
C {devices/lab_pin.sym} 15440 -25360 0 0 {name=p15000 lab=_74844_/A }
C {devices/lab_pin.sym} 15440 -25320 0 0 {name=p15001 lab=_46092_/X }
C {devices/lab_pin.sym} 15560 -25340 0 1 {name=p15002 lab=_74836_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -25340 0 0 {name=X_74836_ }
C {devices/lab_pin.sym} 15460 -25210 0 0 {name=p15003 lab=_47784_/A }
C {devices/lab_pin.sym} 15540 -25210 0 1 {name=p15004 lab=_53244_/D }
C {sky130_stdcells/buf_2.sym} 15500 -25210 0 0 {name=X_47784_ }
C {devices/lab_pin.sym} 15420 -25110 0 0 {name=p15005 lab=_44975_/X }
C {devices/lab_pin.sym} 15420 -25070 0 0 {name=p15006 lab=_61386_/B }
C {devices/lab_pin.sym} 15420 -25030 0 0 {name=p15007 lab=_44995_/X }
C {devices/lab_pin.sym} 15580 -25070 0 1 {name=p15008 lab=_44996_/Y }
C {sky130_stdcells/o21ai_4.sym} 15500 -25070 0 0 {name=X_44996_ }
C {devices/lab_pin.sym} 15460 -24930 0 0 {name=p15009 lab=clkbuf_9_133_0_CLK/X }
C {devices/lab_pin.sym} 15540 -24930 0 1 {name=p15010 lab=_84960_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 15500 -24930 0 0 {name=Xclkbuf_10_267_0_CLK }
C {devices/lab_pin.sym} 15420 -24830 0 0 {name=p15011 lab=_49519_/Y }
C {devices/lab_pin.sym} 15420 -24790 0 0 {name=p15012 lab=_49514_/X }
C {devices/lab_pin.sym} 15420 -24750 0 0 {name=p15013 lab=_49522_/X }
C {devices/lab_pin.sym} 15580 -24790 0 1 {name=p15014 lab=_86372_/D }
C {sky130_stdcells/a21oi_4.sym} 15500 -24790 0 0 {name=X_49523_ }
C {devices/lab_pin.sym} 15460 -24650 0 0 {name=p15015 lab=_61645_/A }
C {devices/lab_pin.sym} 15540 -24650 0 1 {name=p15016 lab=_61801_/X }
C {sky130_stdcells/buf_2.sym} 15500 -24650 0 0 {name=X_61801_ }
C {devices/lab_pin.sym} 15460 -24530 0 0 {name=p15017 lab=_46735_/A }
C {devices/lab_pin.sym} 15540 -24530 0 1 {name=p15018 lab=_46735_/Y }
C {sky130_stdcells/inv_2.sym} 15500 -24530 0 0 {name=X_46735_ }
C {devices/lab_pin.sym} 15420 -24430 0 0 {name=p15019 lab=_77535_/Y }
C {devices/lab_pin.sym} 15420 -24390 0 0 {name=p15020 lab=_77537_/A }
C {devices/lab_pin.sym} 15420 -24350 0 0 {name=p15021 lab=_77533_/Y }
C {devices/lab_pin.sym} 15580 -24390 0 1 {name=p15022 lab=_77555_/X }
C {sky130_stdcells/o21a_4.sym} 15500 -24390 0 0 {name=X_77555_ }
C {devices/lab_pin.sym} 15460 -24250 0 0 {name=p15023 lab=_87176_/Q }
C {devices/lab_pin.sym} 15540 -24250 0 1 {name=p15024 lab=_43948_/B }
C {sky130_stdcells/inv_2.sym} 15500 -24250 0 0 {name=X_43947_ }
C {devices/lab_pin.sym} 15420 -24150 0 0 {name=p15025 lab=_62778_/X }
C {devices/lab_pin.sym} 15420 -24110 0 0 {name=p15026 lab=_62779_/X }
C {devices/lab_pin.sym} 15420 -24070 0 0 {name=p15027 lab=_62780_/Y }
C {devices/lab_pin.sym} 15580 -24110 0 1 {name=p15028 lab=_84383_/D }
C {sky130_stdcells/a21oi_4.sym} 15500 -24110 0 0 {name=X_62781_ }
C {devices/lab_pin.sym} 15420 -24010 0 0 {name=p15029 lab=_83804_/Q }
C {devices/lab_pin.sym} 15420 -23970 0 0 {name=p15030 lab=_74738_/A }
C {devices/lab_pin.sym} 15420 -23930 0 0 {name=p15031 lab=_74761_/Y }
C {devices/lab_pin.sym} 15420 -23890 0 0 {name=p15032 lab=_74762_/Y }
C {devices/lab_pin.sym} 15420 -23850 0 0 {name=p15033 lab=_74766_/X }
C {devices/lab_pin.sym} 15580 -23930 0 1 {name=p15034 lab=_74767_/X }
C {sky130_stdcells/a2111o_4.sym} 15500 -23930 0 0 {name=X_74767_ }
C {devices/lab_pin.sym} 15440 -23790 0 0 {name=p15035 lab=_48926_/A }
C {devices/lab_pin.sym} 15440 -23750 0 0 {name=p15036 lab=_71959_/X }
C {devices/lab_pin.sym} 15440 -23710 0 0 {name=p15037 lab=_71964_/X }
C {devices/lab_pin.sym} 15560 -23750 0 1 {name=p15038 lab=_71979_/X }
C {sky130_stdcells/and3_4.sym} 15500 -23750 0 0 {name=X_71979_ }
C {devices/lab_pin.sym} 15460 -23610 0 0 {name=p15039 lab=clkbuf_9_448_0_CLK/X }
C {devices/lab_pin.sym} 15540 -23610 0 1 {name=p15040 lab=_86988_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 15500 -23610 0 0 {name=Xclkbuf_10_897_0_CLK }
C {devices/lab_pin.sym} 15460 -23490 0 0 {name=p15041 lab=_79568_/B }
C {devices/lab_pin.sym} 15540 -23490 0 1 {name=p15042 lab=_79566_/A }
C {sky130_stdcells/inv_2.sym} 15500 -23490 0 0 {name=X_64520_ }
C {devices/lab_pin.sym} 15420 -23390 0 0 {name=p15043 lab=_76502_/Y }
C {devices/lab_pin.sym} 15420 -23350 0 0 {name=p15044 lab=_76504_/Y }
C {devices/lab_pin.sym} 15420 -23310 0 0 {name=p15045 lab=_76501_/Y }
C {devices/lab_pin.sym} 15580 -23350 0 1 {name=p15046 lab=_76510_/C }
C {sky130_stdcells/o21ai_4.sym} 15500 -23350 0 0 {name=X_76506_ }
C {devices/lab_pin.sym} 15460 -23210 0 0 {name=p15047 lab=clkbuf_9_24_0_CLK/X }
C {devices/lab_pin.sym} 15540 -23210 0 1 {name=p15048 lab=_85041_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 15500 -23210 0 0 {name=Xclkbuf_10_49_0_CLK }
C {devices/lab_pin.sym} 15460 -23090 0 0 {name=p15049 lab=_59722_/A }
C {devices/lab_pin.sym} 15540 -23090 0 1 {name=p15050 lab=_61732_/X }
C {sky130_stdcells/buf_2.sym} 15500 -23090 0 0 {name=X_61732_ }
C {devices/lab_pin.sym} 15440 -22980 0 0 {name=p15051 lab=_49454_/A }
C {devices/lab_pin.sym} 15440 -22940 0 0 {name=p15052 lab=_50976_/B }
C {devices/lab_pin.sym} 15560 -22960 0 1 {name=p15053 lab=_49454_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -22960 0 0 {name=X_49454_ }
C {devices/lab_pin.sym} 15420 -22850 0 0 {name=p15054 lab=_73719_/B }
C {devices/lab_pin.sym} 15420 -22810 0 0 {name=p15055 lab=_73719_/C }
C {devices/lab_pin.sym} 15420 -22770 0 0 {name=p15056 lab=_73717_/X }
C {devices/lab_pin.sym} 15580 -22810 0 1 {name=p15057 lab=_73718_/X }
C {sky130_stdcells/a21o_4.sym} 15500 -22810 0 0 {name=X_73718_ }
C {devices/lab_pin.sym} 15460 -22670 0 0 {name=p15058 lab=_46902_/A }
C {devices/lab_pin.sym} 15540 -22670 0 1 {name=p15059 lab=_46667_/A }
C {sky130_stdcells/buf_2.sym} 15500 -22670 0 0 {name=X_46666_ }
C {devices/lab_pin.sym} 15460 -22550 0 0 {name=p15060 lab=_82228_/Q }
C {devices/lab_pin.sym} 15540 -22550 0 1 {name=p15061 lab=_77486_/Y }
C {sky130_stdcells/inv_2.sym} 15500 -22550 0 0 {name=X_77486_ }
C {devices/lab_pin.sym} 15460 -22430 0 0 {name=p15062 lab=_43877_/Y }
C {devices/lab_pin.sym} 15540 -22430 0 1 {name=p15063 lab=_87221_/D }
C {sky130_stdcells/inv_2.sym} 15500 -22430 0 0 {name=X_43878_ }
C {devices/lab_pin.sym} 15420 -22330 0 0 {name=p15064 lab=_74675_/X }
C {devices/lab_pin.sym} 15420 -22290 0 0 {name=p15065 lab=_57068_/X }
C {devices/lab_pin.sym} 15420 -22250 0 0 {name=p15066 lab=_74697_/Y }
C {devices/lab_pin.sym} 15580 -22290 0 1 {name=p15067 lab=_74698_/Y }
C {sky130_stdcells/o21ai_4.sym} 15500 -22290 0 0 {name=X_74698_ }
C {devices/lab_pin.sym} 15460 -22150 0 0 {name=p15068 lab=clkbuf_9_389_0_CLK/A }
C {devices/lab_pin.sym} 15540 -22150 0 1 {name=p15069 lab=clkbuf_9_388_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 15500 -22150 0 0 {name=Xclkbuf_9_388_0_CLK }
C {devices/lab_pin.sym} 15440 -22040 0 0 {name=p15070 lab=_48405_/A }
C {devices/lab_pin.sym} 15440 -22000 0 0 {name=p15071 lab=_48136_/B }
C {devices/lab_pin.sym} 15560 -22020 0 1 {name=p15072 lab=_48405_/X }
C {sky130_stdcells/or2_4.sym} 15500 -22020 0 0 {name=X_48405_ }
C {devices/lab_pin.sym} 15420 -21910 0 0 {name=p15073 lab=_79208_/Y }
C {devices/lab_pin.sym} 15420 -21870 0 0 {name=p15074 lab=_79209_/Y }
C {devices/lab_pin.sym} 15420 -21830 0 0 {name=p15075 lab=_79205_/Y }
C {devices/lab_pin.sym} 15580 -21870 0 1 {name=p15076 lab=_79225_/Y }
C {sky130_stdcells/o21ai_4.sym} 15500 -21870 0 0 {name=X_79225_ }
C {devices/lab_pin.sym} 15440 -21740 0 0 {name=p15077 lab=_45617_/A }
C {devices/lab_pin.sym} 15440 -21700 0 0 {name=p15078 lab=_45617_/B }
C {devices/lab_pin.sym} 15560 -21720 0 1 {name=p15079 lab=_45617_/Y }
C {sky130_stdcells/nor2_4.sym} 15500 -21720 0 0 {name=X_45617_ }
C {devices/lab_pin.sym} 15420 -21630 0 0 {name=p15080 lab=_64446_/Y }
C {devices/lab_pin.sym} 15420 -21590 0 0 {name=p15081 lab=_64447_/X }
C {devices/lab_pin.sym} 15420 -21550 0 0 {name=p15082 lab=_64448_/X }
C {devices/lab_pin.sym} 15420 -21510 0 0 {name=p15083 lab=_64450_/Y }
C {devices/lab_pin.sym} 15420 -21470 0 0 {name=p15084 lab=_64440_/X }
C {devices/lab_pin.sym} 15580 -21550 0 1 {name=p15085 lab=_64451_/X }
C {sky130_stdcells/o41a_4.sym} 15500 -21550 0 0 {name=X_64451_ }
C {devices/lab_pin.sym} 15420 -21410 0 0 {name=p15086 lab=_76430_/A }
C {devices/lab_pin.sym} 15420 -21370 0 0 {name=p15087 lab=_76430_/B }
C {devices/lab_pin.sym} 15420 -21330 0 0 {name=p15088 lab=_76429_/A }
C {devices/lab_pin.sym} 15580 -21370 0 1 {name=p15089 lab=_76437_/X }
C {sky130_stdcells/o21a_4.sym} 15500 -21370 0 0 {name=X_76437_ }
C {devices/lab_pin.sym} 15460 -21230 0 0 {name=p15090 lab=_42828_/Y }
C {devices/lab_pin.sym} 15540 -21230 0 1 {name=p15091 lab=_87696_/D }
C {sky130_stdcells/inv_2.sym} 15500 -21230 0 0 {name=X_42829_ }
C {devices/lab_pin.sym} 15460 -21110 0 0 {name=p15092 lab=_49493_/A }
C {devices/lab_pin.sym} 15540 -21110 0 1 {name=p15093 lab=_49408_/C }
C {sky130_stdcells/buf_2.sym} 15500 -21110 0 0 {name=X_49385_ }
C {devices/lab_pin.sym} 15440 -21010 0 0 {name=p15094 lab=_61636_/A }
C {devices/lab_pin.sym} 15440 -20970 0 0 {name=p15095 lab=_61663_/B }
C {devices/lab_pin.sym} 15440 -20930 0 0 {name=p15096 lab=_61682_/C }
C {devices/lab_pin.sym} 15560 -20970 0 1 {name=p15097 lab=_61663_/Y }
C {sky130_stdcells/nand3_4.sym} 15500 -20970 0 0 {name=X_61663_ }
C {devices/lab_pin.sym} 15460 -20830 0 0 {name=p15098 lab=_73227_/A }
C {devices/lab_pin.sym} 15540 -20830 0 1 {name=p15099 lab=_73649_/X }
C {sky130_stdcells/buf_2.sym} 15500 -20830 0 0 {name=X_73649_ }
C {devices/lab_pin.sym} 15420 -20730 0 0 {name=p15100 lab=_86722_/Q }
C {devices/lab_pin.sym} 15420 -20690 0 0 {name=p15101 lab=_46474_/X }
C {devices/lab_pin.sym} 15420 -20650 0 0 {name=p15102 lab=_46596_/Y }
C {devices/lab_pin.sym} 15580 -20690 0 1 {name=p15103 lab=_46597_/Y }
C {sky130_stdcells/o21ai_4.sym} 15500 -20690 0 0 {name=X_46597_ }
C {devices/lab_pin.sym} 15460 -20550 0 0 {name=p15104 lab=clkbuf_9_410_0_CLK/X }
C {devices/lab_pin.sym} 15540 -20550 0 1 {name=p15105 lab=_81190_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 15500 -20550 0 0 {name=Xclkbuf_10_820_0_CLK }
C {devices/lab_pin.sym} 15440 -20460 0 0 {name=p15106 lab=_61368_/A }
C {devices/lab_pin.sym} 15440 -20420 0 0 {name=p15107 lab=_63389_/B }
C {devices/lab_pin.sym} 15440 -20380 0 0 {name=p15108 lab=_63418_/C }
C {devices/lab_pin.sym} 15440 -20340 0 0 {name=p15109 lab=_63389_/D }
C {devices/lab_pin.sym} 15560 -20400 0 1 {name=p15110 lab=_63402_/Y }
C {sky130_stdcells/nand4_4.sym} 15500 -20400 0 0 {name=X_63402_ }
C {devices/lab_pin.sym} 15420 -20270 0 0 {name=p15111 lab=_86533_/Q }
C {devices/lab_pin.sym} 15420 -20230 0 0 {name=p15112 lab=_48333_/X }
C {devices/lab_pin.sym} 15420 -20190 0 0 {name=p15113 lab=_48335_/Y }
C {devices/lab_pin.sym} 15580 -20230 0 1 {name=p15114 lab=_48336_/Y }
C {sky130_stdcells/o21ai_4.sym} 15500 -20230 0 0 {name=X_48336_ }
C {devices/lab_pin.sym} 15440 -20110 0 0 {name=p15115 lab=_60182_/Y }
C {devices/lab_pin.sym} 15440 -20070 0 0 {name=p15116 lab=_59536_/A }
C {devices/lab_pin.sym} 15440 -20030 0 0 {name=p15117 lab=_61285_/C }
C {devices/lab_pin.sym} 15560 -20070 0 1 {name=p15118 lab=_60622_/A }
C {sky130_stdcells/and3_4.sym} 15500 -20070 0 0 {name=X_60614_ }
C {devices/lab_pin.sym} 15440 -19940 0 0 {name=p15119 lab=_67241_/A }
C {devices/lab_pin.sym} 15440 -19900 0 0 {name=p15120 lab=_86781_/Q }
C {devices/lab_pin.sym} 15560 -19920 0 1 {name=p15121 lab=_67170_/X }
C {sky130_stdcells/and2_4.sym} 15500 -19920 0 0 {name=X_67170_ }
C {devices/lab_pin.sym} 15440 -19800 0 0 {name=p15122 lab=_79156_/A }
C {devices/lab_pin.sym} 15440 -19760 0 0 {name=p15123 lab=_84488_/Q }
C {devices/lab_pin.sym} 15560 -19780 0 1 {name=p15124 lab=_79156_/X }
C {sky130_stdcells/xor2_4.sym} 15500 -19780 0 0 {name=X_79156_ }
C {devices/lab_pin.sym} 15460 -19650 0 0 {name=p15125 lab=_45389_/X }
C {devices/lab_pin.sym} 15540 -19650 0 1 {name=p15126 lab=_45548_/X }
C {sky130_stdcells/buf_2.sym} 15500 -19650 0 0 {name=X_45548_ }
C {devices/lab_pin.sym} 15440 -19550 0 0 {name=p15127 lab=_64380_/X }
C {devices/lab_pin.sym} 15440 -19510 0 0 {name=p15128 lab=_84819_/Q }
C {devices/lab_pin.sym} 15440 -19470 0 0 {name=p15129 lab=_64381_/X }
C {devices/lab_pin.sym} 15560 -19510 0 1 {name=p15130 lab=_64382_/Y }
C {sky130_stdcells/nand3_4.sym} 15500 -19510 0 0 {name=X_64382_ }
C {devices/lab_pin.sym} 15460 -19370 0 0 {name=p15131 lab=_76368_/A }
C {devices/lab_pin.sym} 15540 -19370 0 1 {name=p15132 lab=_76368_/Y }
C {sky130_stdcells/inv_2.sym} 15500 -19370 0 0 {name=X_76368_ }
C {devices/lab_pin.sym} 15460 -19250 0 0 {name=p15133 lab=_61323_/B }
C {devices/lab_pin.sym} 15540 -19250 0 1 {name=p15134 lab=_61594_/X }
C {sky130_stdcells/buf_2.sym} 15500 -19250 0 0 {name=X_61594_ }
C {devices/lab_pin.sym} 15440 -19150 0 0 {name=p15135 lab=_66116_/X }
C {devices/lab_pin.sym} 15440 -19110 0 0 {name=p15136 lab=_65967_/B }
C {devices/lab_pin.sym} 15440 -19070 0 0 {name=p15137 lab=_66120_/X }
C {devices/lab_pin.sym} 15560 -19110 0 1 {name=p15138 lab=_66121_/Y }
C {sky130_stdcells/nand3_4.sym} 15500 -19110 0 0 {name=X_66121_ }
C {devices/lab_pin.sym} 15440 -18980 0 0 {name=p15139 lab=_78107_/A }
C {devices/lab_pin.sym} 15440 -18940 0 0 {name=p15140 lab=_78107_/B }
C {devices/lab_pin.sym} 15560 -18960 0 1 {name=p15141 lab=_78107_/X }
C {sky130_stdcells/xor2_4.sym} 15500 -18960 0 0 {name=X_78107_ }
C {devices/lab_pin.sym} 15460 -18830 0 0 {name=p15142 lab=clkbuf_9_311_0_CLK/A }
C {devices/lab_pin.sym} 15540 -18830 0 1 {name=p15143 lab=clkbuf_9_311_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 15500 -18830 0 0 {name=Xclkbuf_9_311_0_CLK }
C {devices/lab_pin.sym} 15440 -18740 0 0 {name=p15144 lab=_60433_/A }
C {devices/lab_pin.sym} 15440 -18700 0 0 {name=p15145 lab=_63333_/B }
C {devices/lab_pin.sym} 15440 -18660 0 0 {name=p15146 lab=_63333_/C }
C {devices/lab_pin.sym} 15440 -18620 0 0 {name=p15147 lab=_60484_/A }
C {devices/lab_pin.sym} 15560 -18680 0 1 {name=p15148 lab=_63333_/X }
C {sky130_stdcells/and4_4.sym} 15500 -18680 0 0 {name=X_63333_ }
C {devices/lab_pin.sym} 15440 -18540 0 0 {name=p15149 lab=_75314_/Y }
C {devices/lab_pin.sym} 15440 -18500 0 0 {name=p15150 lab=_75319_/B }
C {devices/lab_pin.sym} 15560 -18520 0 1 {name=p15151 lab=_75320_/A }
C {sky130_stdcells/nor2_4.sym} 15500 -18520 0 0 {name=X_75319_ }
C {devices/lab_pin.sym} 15460 -18390 0 0 {name=p15152 lab=_52139_/A }
C {devices/lab_pin.sym} 15540 -18390 0 1 {name=p15153 lab=_48545_/A }
C {sky130_stdcells/buf_2.sym} 15500 -18390 0 0 {name=X_48267_ }
C {devices/lab_pin.sym} 15420 -18290 0 0 {name=p15154 lab=_60515_/A }
C {devices/lab_pin.sym} 15420 -18250 0 0 {name=p15155 lab=_60488_/A }
C {devices/lab_pin.sym} 15420 -18210 0 0 {name=p15156 lab=_65842_/A }
C {devices/lab_pin.sym} 15580 -18250 0 1 {name=p15157 lab=_60546_/A }
C {sky130_stdcells/a21o_4.sym} 15500 -18250 0 0 {name=X_60545_ }
C {devices/lab_pin.sym} 15440 -18120 0 0 {name=p15158 lab=_79065_/A }
C {devices/lab_pin.sym} 15440 -18080 0 0 {name=p15159 lab=_79087_/B }
C {devices/lab_pin.sym} 15560 -18100 0 1 {name=p15160 lab=_79088_/A }
C {sky130_stdcells/and2_4.sym} 15500 -18100 0 0 {name=X_79087_ }
C {devices/lab_pin.sym} 15440 -17980 0 0 {name=p15161 lab=_45479_/A }
C {devices/lab_pin.sym} 15440 -17940 0 0 {name=p15162 lab=_45604_/B }
C {devices/lab_pin.sym} 15560 -17960 0 1 {name=p15163 lab=_45479_/Y }
C {sky130_stdcells/nor2_4.sym} 15500 -17960 0 0 {name=X_45479_ }
C {devices/lab_pin.sym} 15420 -17850 0 0 {name=p15164 lab=_76290_/B }
C {devices/lab_pin.sym} 15420 -17810 0 0 {name=p15165 lab=_81644_/Q }
C {devices/lab_pin.sym} 15420 -17770 0 0 {name=p15166 lab=_76298_/Y }
C {devices/lab_pin.sym} 15580 -17810 0 1 {name=p15167 lab=_76299_/Y }
C {sky130_stdcells/a21boi_4.sym} 15500 -17810 0 0 {name=X_76299_ }
C {devices/lab_pin.sym} 15460 -17670 0 0 {name=p15168 lab=clkbuf_9_102_0_CLK/X }
C {devices/lab_pin.sym} 15540 -17670 0 1 {name=p15169 lab=_84652_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 15500 -17670 0 0 {name=Xclkbuf_10_205_0_CLK }
C {devices/lab_pin.sym} 15440 -17580 0 0 {name=p15170 lab=_47210_/A }
C {devices/lab_pin.sym} 15440 -17540 0 0 {name=p15171 lab=_47181_/B }
C {devices/lab_pin.sym} 15440 -17500 0 0 {name=p15172 lab=_47210_/C }
C {devices/lab_pin.sym} 15440 -17460 0 0 {name=p15173 lab=_47218_/D }
C {devices/lab_pin.sym} 15560 -17520 0 1 {name=p15174 lab=_47218_/X }
C {sky130_stdcells/and4_4.sym} 15500 -17520 0 0 {name=X_47218_ }
C {devices/lab_pin.sym} 15460 -17370 0 0 {name=p15175 lab=_65117_/A }
C {devices/lab_pin.sym} 15540 -17370 0 1 {name=p15176 lab=_66053_/A }
C {sky130_stdcells/buf_2.sym} 15500 -17370 0 0 {name=X_66052_ }
C {devices/lab_pin.sym} 15460 -17250 0 0 {name=p15177 lab=_77872_/Y }
C {devices/lab_pin.sym} 15540 -17250 0 1 {name=p15178 lab=_81938_/D }
C {sky130_stdcells/inv_2.sym} 15500 -17250 0 0 {name=X_78038_ }
C {devices/lab_pin.sym} 15460 -17130 0 0 {name=p15179 lab=_60410_/B }
C {devices/lab_pin.sym} 15540 -17130 0 1 {name=p15180 lab=_63333_/C }
C {sky130_stdcells/buf_2.sym} 15500 -17130 0 0 {name=X_63264_ }
C {devices/lab_pin.sym} 15440 -17020 0 0 {name=p15181 lab=_48190_/A }
C {devices/lab_pin.sym} 15440 -16980 0 0 {name=p15182 lab=_51954_/B }
C {devices/lab_pin.sym} 15560 -17000 0 1 {name=p15183 lab=_48198_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -17000 0 0 {name=X_48198_ }
C {devices/lab_pin.sym} 15440 -16900 0 0 {name=p15184 lab=_60476_/A }
C {devices/lab_pin.sym} 15440 -16860 0 0 {name=p15185 lab=_60488_/A }
C {devices/lab_pin.sym} 15440 -16820 0 0 {name=p15186 lab=_60476_/C }
C {devices/lab_pin.sym} 15440 -16780 0 0 {name=p15187 lab=_60476_/D }
C {devices/lab_pin.sym} 15560 -16840 0 1 {name=p15188 lab=_60476_/Y }
C {sky130_stdcells/nand4_4.sym} 15500 -16840 0 0 {name=X_60476_ }
C {devices/lab_pin.sym} 15460 -16690 0 0 {name=p15189 lab=clkbuf_9_417_0_CLK/X }
C {devices/lab_pin.sym} 15540 -16690 0 1 {name=p15190 lab=_84175_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 15500 -16690 0 0 {name=Xclkbuf_10_835_0_CLK }
C {devices/lab_pin.sym} 15420 -16600 0 0 {name=p15191 lab=_64858_/X }
C {devices/lab_pin.sym} 15420 -16560 0 0 {name=p15192 lab=_85522_/Q }
C {devices/lab_pin.sym} 15420 -16520 0 0 {name=p15193 lab=_64859_/X }
C {devices/lab_pin.sym} 15420 -16480 0 0 {name=p15194 lab=_65002_/X }
C {devices/lab_pin.sym} 15580 -16540 0 1 {name=p15195 lab=_65003_/X }
C {sky130_stdcells/a211o_4.sym} 15500 -16540 0 0 {name=X_65003_ }
C {devices/lab_pin.sym} 15420 -16430 0 0 {name=p15196 lab=_62194_/X }
C {devices/lab_pin.sym} 15420 -16390 0 0 {name=p15197 lab=_62197_/X }
C {devices/lab_pin.sym} 15420 -16350 0 0 {name=p15198 lab=_62212_/Y }
C {devices/lab_pin.sym} 15420 -16310 0 0 {name=p15199 lab=_58147_/A }
C {devices/lab_pin.sym} 15420 -16270 0 0 {name=p15200 lab=_62214_/X }
C {devices/lab_pin.sym} 15580 -16350 0 1 {name=p15201 lab=_62215_/Y }
C {sky130_stdcells/o32ai_4.sym} 15500 -16350 0 0 {name=X_62215_ }
C {devices/lab_pin.sym} 15460 -16190 0 0 {name=p15202 lab=_53395_/B }
C {devices/lab_pin.sym} 15540 -16190 0 1 {name=p15203 lab=_52881_/B }
C {sky130_stdcells/buf_2.sym} 15500 -16190 0 0 {name=X_47149_ }
C {devices/lab_pin.sym} 15460 -16070 0 0 {name=p15204 lab=_63342_/C }
C {devices/lab_pin.sym} 15540 -16070 0 1 {name=p15205 lab=_63241_/C }
C {sky130_stdcells/buf_2.sym} 15500 -16070 0 0 {name=X_63195_ }
C {devices/lab_pin.sym} 15460 -15950 0 0 {name=p15206 lab=clkbuf_9_326_0_CLK/A }
C {devices/lab_pin.sym} 15540 -15950 0 1 {name=p15207 lab=clkbuf_9_326_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 15500 -15950 0 0 {name=Xclkbuf_9_326_0_CLK }
C {devices/lab_pin.sym} 15440 -15840 0 0 {name=p15208 lab=_80000_/A }
C {devices/lab_pin.sym} 15440 -15800 0 0 {name=p15209 lab=_79999_/X }
C {devices/lab_pin.sym} 15560 -15820 0 1 {name=p15210 lab=_80000_/X }
C {sky130_stdcells/xor2_4.sym} 15500 -15820 0 0 {name=X_80000_ }
C {devices/lab_pin.sym} 15440 -15700 0 0 {name=p15211 lab=_69770_/A }
C {devices/lab_pin.sym} 15440 -15660 0 0 {name=p15212 lab=_88321_/Q }
C {devices/lab_pin.sym} 15560 -15680 0 1 {name=p15213 lab=_69811_/X }
C {sky130_stdcells/and2_4.sym} 15500 -15680 0 0 {name=X_69811_ }
C {devices/lab_pin.sym} 15440 -15570 0 0 {name=p15214 lab=_52370_/A }
C {devices/lab_pin.sym} 15440 -15530 0 0 {name=p15215 lab=_51256_/B }
C {devices/lab_pin.sym} 15440 -15490 0 0 {name=p15216 lab=_50147_/C }
C {devices/lab_pin.sym} 15560 -15530 0 1 {name=p15217 lab=_50160_/X }
C {sky130_stdcells/and3_4.sym} 15500 -15530 0 0 {name=X_50160_ }
C {devices/lab_pin.sym} 15440 -15420 0 0 {name=p15218 lab=_62037_/X }
C {devices/lab_pin.sym} 15440 -15380 0 0 {name=p15219 lab=_62063_/X }
C {devices/lab_pin.sym} 15440 -15340 0 0 {name=p15220 lab=_58296_/A }
C {devices/lab_pin.sym} 15440 -15300 0 0 {name=p15221 lab=_62183_/D }
C {devices/lab_pin.sym} 15560 -15360 0 1 {name=p15222 lab=_62146_/X }
C {sky130_stdcells/and4_4.sym} 15500 -15360 0 0 {name=X_62146_ }
C {devices/lab_pin.sym} 15460 -15210 0 0 {name=p15223 lab=_79989_/A }
C {devices/lab_pin.sym} 15540 -15210 0 1 {name=p15224 lab=_79989_/Y }
C {sky130_stdcells/inv_2.sym} 15500 -15210 0 0 {name=X_79989_ }
C {devices/lab_pin.sym} 15460 -15090 0 0 {name=p15225 lab=_69655_/A }
C {devices/lab_pin.sym} 15540 -15090 0 1 {name=p15226 lab=_69742_/X }
C {sky130_stdcells/buf_2.sym} 15500 -15090 0 0 {name=X_69742_ }
C {devices/lab_pin.sym} 15420 -14990 0 0 {name=p15227 lab=_64804_/B }
C {devices/lab_pin.sym} 15420 -14950 0 0 {name=p15228 lab=_50088_/X }
C {devices/lab_pin.sym} 15420 -14910 0 0 {name=p15229 lab=_50090_/Y }
C {devices/lab_pin.sym} 15580 -14950 0 1 {name=p15230 lab=_50091_/Y }
C {sky130_stdcells/o21ai_4.sym} 15500 -14950 0 0 {name=X_50091_ }
C {devices/lab_pin.sym} 15460 -14810 0 0 {name=p15231 lab=_66953_/X }
C {devices/lab_pin.sym} 15540 -14810 0 1 {name=p15232 lab=_66954_/X }
C {sky130_stdcells/buf_2.sym} 15500 -14810 0 0 {name=X_66954_ }
C {devices/lab_pin.sym} 15440 -14720 0 0 {name=p15233 lab=_62142_/A }
C {devices/lab_pin.sym} 15440 -14680 0 0 {name=p15234 lab=_62077_/B }
C {devices/lab_pin.sym} 15440 -14640 0 0 {name=p15235 lab=_62077_/C }
C {devices/lab_pin.sym} 15440 -14600 0 0 {name=p15236 lab=_62077_/D }
C {devices/lab_pin.sym} 15560 -14660 0 1 {name=p15237 lab=_62077_/Y }
C {sky130_stdcells/nand4_4.sym} 15500 -14660 0 0 {name=X_62077_ }
C {devices/lab_pin.sym} 15460 -14510 0 0 {name=p15238 lab=_65791_/A }
C {devices/lab_pin.sym} 15540 -14510 0 1 {name=p15239 lab=_65932_/A }
C {sky130_stdcells/buf_2.sym} 15500 -14510 0 0 {name=X_65905_ }
C {devices/lab_pin.sym} 15460 -14390 0 0 {name=p15240 lab=_61027_/X }
C {devices/lab_pin.sym} 15540 -14390 0 1 {name=p15241 lab=_61028_/X }
C {sky130_stdcells/buf_2.sym} 15500 -14390 0 0 {name=X_61028_ }
C {devices/lab_pin.sym} 15410 -14270 0 0 {name=p15242 lab=_82124_/CLK }
C {devices/lab_pin.sym} 15410 -14250 0 0 {name=p15243 lab=_78012_/Y }
C {devices/lab_pin.sym} 15590 -14270 0 1 {name=p15244 lab=_77690_/B }
C {sky130_stdcells/dfxtp_4.sym} 15500 -14260 0 0 {name=X_81951_ }
C {devices/lab_pin.sym} 15440 -14140 0 0 {name=p15245 lab=_69605_/A }
C {devices/lab_pin.sym} 15440 -14100 0 0 {name=p15246 lab=_87307_/Q }
C {devices/lab_pin.sym} 15560 -14120 0 1 {name=p15247 lab=_69673_/X }
C {sky130_stdcells/and2_4.sym} 15500 -14120 0 0 {name=X_69673_ }
C {devices/lab_pin.sym} 15420 -14020 0 0 {name=p15248 lab=_87122_/Q }
C {devices/lab_pin.sym} 15420 -13980 0 0 {name=p15249 lab=_66833_/X }
C {devices/lab_pin.sym} 15420 -13940 0 0 {name=p15250 lab=_66834_/X }
C {devices/lab_pin.sym} 15420 -13900 0 0 {name=p15251 lab=_66884_/X }
C {devices/lab_pin.sym} 15580 -13960 0 1 {name=p15252 lab=_66885_/X }
C {sky130_stdcells/a211o_4.sym} 15500 -13960 0 0 {name=X_66885_ }
C {devices/lab_pin.sym} 15410 -13810 0 0 {name=p15253 lab=_84014_/CLK }
C {devices/lab_pin.sym} 15410 -13790 0 0 {name=p15254 lab=_84078_/Q }
C {devices/lab_pin.sym} 15590 -13810 0 1 {name=p15255 lab=_75606_/A }
C {sky130_stdcells/dfxtp_4.sym} 15500 -13800 0 0 {name=X_80902_ }
C {devices/lab_pin.sym} 15440 -13680 0 0 {name=p15256 lab=_68599_/A }
C {devices/lab_pin.sym} 15440 -13640 0 0 {name=p15257 lab=_68624_/B }
C {devices/lab_pin.sym} 15560 -13660 0 1 {name=p15258 lab=_68624_/X }
C {sky130_stdcells/and2_4.sym} 15500 -13660 0 0 {name=X_68624_ }
C {devices/lab_pin.sym} 15440 -13540 0 0 {name=p15259 lab=_53844_/A }
C {devices/lab_pin.sym} 15440 -13500 0 0 {name=p15260 lab=_72025_/B }
C {devices/lab_pin.sym} 15560 -13520 0 1 {name=p15261 lab=_53850_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -13520 0 0 {name=X_53850_ }
C {devices/lab_pin.sym} 15440 -13400 0 0 {name=p15262 lab=_65836_/A }
C {devices/lab_pin.sym} 15440 -13360 0 0 {name=p15263 lab=_86470_/Q }
C {devices/lab_pin.sym} 15560 -13380 0 1 {name=p15264 lab=_65836_/X }
C {sky130_stdcells/and2_4.sym} 15500 -13380 0 0 {name=X_65836_ }
C {devices/lab_pin.sym} 15410 -13250 0 0 {name=p15265 lab=_84668_/CLK }
C {devices/lab_pin.sym} 15410 -13230 0 0 {name=p15266 lab=_84670_/D }
C {devices/lab_pin.sym} 15590 -13250 0 1 {name=p15267 lab=_60051_/C }
C {sky130_stdcells/dfxtp_4.sym} 15500 -13240 0 0 {name=X_84670_ }
C {devices/lab_pin.sym} 15410 -13110 0 0 {name=p15268 lab=_81883_/CLK }
C {devices/lab_pin.sym} 15410 -13090 0 0 {name=p15269 lab=_81882_/D }
C {devices/lab_pin.sym} 15590 -13110 0 1 {name=p15270 lab=_81882_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -13100 0 0 {name=X_81882_ }
C {devices/lab_pin.sym} 15440 -13000 0 0 {name=p15271 lab=_52784_/X }
C {devices/lab_pin.sym} 15440 -12960 0 0 {name=p15272 lab=_52818_/B }
C {devices/lab_pin.sym} 15440 -12920 0 0 {name=p15273 lab=_52789_/X }
C {devices/lab_pin.sym} 15440 -12880 0 0 {name=p15274 lab=_52801_/D }
C {devices/lab_pin.sym} 15560 -12940 0 1 {name=p15275 lab=_52801_/X }
C {sky130_stdcells/and4_4.sym} 15500 -12940 0 0 {name=X_52801_ }
C {devices/lab_pin.sym} 15410 -12790 0 0 {name=p15276 lab=_85561_/CLK }
C {devices/lab_pin.sym} 15410 -12770 0 0 {name=p15277 lab=_83621_/D }
C {devices/lab_pin.sym} 15590 -12790 0 1 {name=p15278 lab=_48920_/A }
C {sky130_stdcells/dfxtp_4.sym} 15500 -12780 0 0 {name=X_83621_ }
C {devices/lab_pin.sym} 15410 -12650 0 0 {name=p15279 lab=_83944_/CLK }
C {devices/lab_pin.sym} 15410 -12630 0 0 {name=p15280 lab=_83977_/Q }
C {devices/lab_pin.sym} 15590 -12650 0 1 {name=p15281 lab=_75707_/B }
C {sky130_stdcells/dfxtp_4.sym} 15500 -12640 0 0 {name=X_80833_ }
C {devices/lab_pin.sym} 15460 -12510 0 0 {name=p15282 lab=_68617_/A }
C {devices/lab_pin.sym} 15540 -12510 0 1 {name=p15283 lab=_68555_/X }
C {sky130_stdcells/buf_2.sym} 15500 -12510 0 0 {name=X_68555_ }
C {devices/lab_pin.sym} 15420 -12410 0 0 {name=p15284 lab=_85569_/Q }
C {devices/lab_pin.sym} 15420 -12370 0 0 {name=p15285 lab=_53754_/X }
C {devices/lab_pin.sym} 15420 -12330 0 0 {name=p15286 lab=_53780_/Y }
C {devices/lab_pin.sym} 15580 -12370 0 1 {name=p15287 lab=_53781_/Y }
C {sky130_stdcells/o21ai_4.sym} 15500 -12370 0 0 {name=X_53781_ }
C {devices/lab_pin.sym} 15420 -12250 0 0 {name=p15288 lab=_65764_/X }
C {devices/lab_pin.sym} 15420 -12210 0 0 {name=p15289 lab=_65766_/X }
C {devices/lab_pin.sym} 15420 -12170 0 0 {name=p15290 lab=_65614_/X }
C {devices/lab_pin.sym} 15580 -12210 0 1 {name=p15291 lab=_65767_/X }
C {sky130_stdcells/a21o_4.sym} 15500 -12210 0 0 {name=X_65767_ }
C {devices/lab_pin.sym} 15460 -12070 0 0 {name=p15292 lab=_51021_/A }
C {devices/lab_pin.sym} 15540 -12070 0 1 {name=p15293 lab=_51003_/A }
C {sky130_stdcells/buf_2.sym} 15500 -12070 0 0 {name=X_50993_ }
C {devices/lab_pin.sym} 15440 -11980 0 0 {name=p15294 lab=_62979_/A }
C {devices/lab_pin.sym} 15440 -11940 0 0 {name=p15295 lab=_64546_/C }
C {devices/lab_pin.sym} 15440 -11900 0 0 {name=p15296 lab=_60302_/X }
C {devices/lab_pin.sym} 15440 -11860 0 0 {name=p15297 lab=_62979_/D }
C {devices/lab_pin.sym} 15560 -11920 0 1 {name=p15298 lab=_62979_/X }
C {sky130_stdcells/and4_4.sym} 15500 -11920 0 0 {name=X_62979_ }
C {devices/lab_pin.sym} 15440 -11780 0 0 {name=p15299 lab=_55524_/A }
C {devices/lab_pin.sym} 15440 -11740 0 0 {name=p15300 lab=_55520_/B }
C {devices/lab_pin.sym} 15560 -11760 0 1 {name=p15301 lab=_55520_/Y }
C {sky130_stdcells/nor2_4.sym} 15500 -11760 0 0 {name=X_55520_ }
C {devices/lab_pin.sym} 15440 -11640 0 0 {name=p15302 lab=_67506_/A }
C {devices/lab_pin.sym} 15440 -11600 0 0 {name=p15303 lab=_67506_/B }
C {devices/lab_pin.sym} 15560 -11620 0 1 {name=p15304 lab=_67506_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -11620 0 0 {name=X_67506_ }
C {devices/lab_pin.sym} 15410 -11490 0 0 {name=p15305 lab=_86340_/CLK }
C {devices/lab_pin.sym} 15410 -11470 0 0 {name=p15306 lab=_49698_/Y }
C {devices/lab_pin.sym} 15590 -11490 0 1 {name=p15307 lab=_59360_/B }
C {sky130_stdcells/dfxtp_4.sym} 15500 -11480 0 0 {name=X_86340_ }
C {devices/lab_pin.sym} 15440 -11360 0 0 {name=p15308 lab=_52718_/A }
C {devices/lab_pin.sym} 15440 -11320 0 0 {name=p15309 lab=_52732_/B }
C {devices/lab_pin.sym} 15560 -11340 0 1 {name=p15310 lab=_52732_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -11340 0 0 {name=X_52732_ }
C {devices/lab_pin.sym} 15460 -11210 0 0 {name=p15311 lab=_64903_/A }
C {devices/lab_pin.sym} 15540 -11210 0 1 {name=p15312 lab=_64826_/A }
C {sky130_stdcells/buf_2.sym} 15500 -11210 0 0 {name=X_64718_ }
C {devices/lab_pin.sym} 15410 -11090 0 0 {name=p15313 lab=_83550_/CLK }
C {devices/lab_pin.sym} 15410 -11070 0 0 {name=p15314 lab=_83552_/D }
C {devices/lab_pin.sym} 15590 -11090 0 1 {name=p15315 lab=_83552_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -11080 0 0 {name=X_83552_ }
C {devices/lab_pin.sym} 15410 -10950 0 0 {name=p15316 lab=_80740_/CLK }
C {devices/lab_pin.sym} 15410 -10930 0 0 {name=p15317 lab=_75472_/X }
C {devices/lab_pin.sym} 15590 -10950 0 1 {name=p15318 lab=_81140_/D }
C {sky130_stdcells/dfxtp_4.sym} 15500 -10940 0 0 {name=X_80764_ }
C {devices/lab_pin.sym} 15420 -10840 0 0 {name=p15319 lab=_87099_/Q }
C {devices/lab_pin.sym} 15420 -10800 0 0 {name=p15320 lab=_68455_/X }
C {devices/lab_pin.sym} 15420 -10760 0 0 {name=p15321 lab=_68370_/X }
C {devices/lab_pin.sym} 15420 -10720 0 0 {name=p15322 lab=_68485_/X }
C {devices/lab_pin.sym} 15580 -10780 0 1 {name=p15323 lab=_68486_/X }
C {sky130_stdcells/a211o_4.sym} 15500 -10780 0 0 {name=X_68486_ }
C {devices/lab_pin.sym} 15440 -10650 0 0 {name=p15324 lab=_65621_/A }
C {devices/lab_pin.sym} 15440 -10610 0 0 {name=p15325 lab=_65775_/B }
C {devices/lab_pin.sym} 15440 -10570 0 0 {name=p15326 lab=_65698_/C }
C {devices/lab_pin.sym} 15560 -10610 0 1 {name=p15327 lab=_65698_/X }
C {sky130_stdcells/and3_4.sym} 15500 -10610 0 0 {name=X_65698_ }
C {devices/lab_pin.sym} 15410 -10470 0 0 {name=p15328 lab=_82503_/CLK }
C {devices/lab_pin.sym} 15410 -10450 0 0 {name=p15329 lab=_78857_/A }
C {devices/lab_pin.sym} 15590 -10470 0 1 {name=p15330 lab=_78383_/A }
C {sky130_stdcells/dfxtp_4.sym} 15500 -10460 0 0 {name=X_82503_ }
C {devices/lab_pin.sym} 15440 -10340 0 0 {name=p15331 lab=_55447_/Y }
C {devices/lab_pin.sym} 15440 -10300 0 0 {name=p15332 lab=_55451_/B }
C {devices/lab_pin.sym} 15560 -10320 0 1 {name=p15333 lab=_55676_/B }
C {sky130_stdcells/and2_4.sym} 15500 -10320 0 0 {name=X_55451_ }
C {devices/lab_pin.sym} 15440 -10200 0 0 {name=p15334 lab=_67342_/A }
C {devices/lab_pin.sym} 15440 -10160 0 0 {name=p15335 lab=_67437_/B }
C {devices/lab_pin.sym} 15560 -10180 0 1 {name=p15336 lab=_67437_/X }
C {sky130_stdcells/and2_4.sym} 15500 -10180 0 0 {name=X_67437_ }
C {devices/lab_pin.sym} 15410 -10050 0 0 {name=p15337 lab=_83307_/CLK }
C {devices/lab_pin.sym} 15410 -10030 0 0 {name=p15338 lab=_50070_/Y }
C {devices/lab_pin.sym} 15590 -10050 0 1 {name=p15339 lab=_86271_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -10040 0 0 {name=X_86271_ }
C {devices/lab_pin.sym} 15440 -9920 0 0 {name=p15340 lab=_52657_/X }
C {devices/lab_pin.sym} 15440 -9880 0 0 {name=p15341 lab=_52663_/B }
C {devices/lab_pin.sym} 15560 -9900 0 1 {name=p15342 lab=_52663_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -9900 0 0 {name=X_52663_ }
C {devices/lab_pin.sym} 15440 -9780 0 0 {name=p15343 lab=_64649_/A }
C {devices/lab_pin.sym} 15440 -9740 0 0 {name=p15344 lab=_64648_/X }
C {devices/lab_pin.sym} 15560 -9760 0 1 {name=p15345 lab=_64649_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -9760 0 0 {name=X_64649_ }
C {devices/lab_pin.sym} 15410 -9630 0 0 {name=p15346 lab=_83414_/CLK }
C {devices/lab_pin.sym} 15410 -9610 0 0 {name=p15347 lab=_83483_/D }
C {devices/lab_pin.sym} 15590 -9630 0 1 {name=p15348 lab=_83483_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -9620 0 0 {name=X_83483_ }
C {devices/lab_pin.sym} 15410 -9490 0 0 {name=p15349 lab=_81111_/CLK }
C {devices/lab_pin.sym} 15410 -9470 0 0 {name=p15350 lab=_80695_/D }
C {devices/lab_pin.sym} 15590 -9490 0 1 {name=p15351 lab=_75376_/A }
C {sky130_stdcells/dfxtp_4.sym} 15500 -9480 0 0 {name=X_80695_ }
C {devices/lab_pin.sym} 15410 -9350 0 0 {name=p15352 lab=_87757_/CLK }
C {devices/lab_pin.sym} 15410 -9330 0 0 {name=p15353 lab=_42151_/X }
C {devices/lab_pin.sym} 15590 -9350 0 1 {name=p15354 lab=_88010_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -9340 0 0 {name=X_88010_ }
C {devices/lab_pin.sym} 15440 -9240 0 0 {name=p15355 lab=_54399_/X }
C {devices/lab_pin.sym} 15440 -9200 0 0 {name=p15356 lab=_54395_/B }
C {devices/lab_pin.sym} 15440 -9160 0 0 {name=p15357 lab=_54402_/C }
C {devices/lab_pin.sym} 15440 -9120 0 0 {name=p15358 lab=_46846_/Y }
C {devices/lab_pin.sym} 15560 -9180 0 1 {name=p15359 lab=_54402_/X }
C {sky130_stdcells/and4_4.sym} 15500 -9180 0 0 {name=X_54402_ }
C {devices/lab_pin.sym} 15410 -9030 0 0 {name=p15360 lab=_85190_/CLK }
C {devices/lab_pin.sym} 15410 -9010 0 0 {name=p15361 lab=_85222_/D }
C {devices/lab_pin.sym} 15590 -9030 0 1 {name=p15362 lab=_55702_/B }
C {sky130_stdcells/dfxtp_4.sym} 15500 -9020 0 0 {name=X_85222_ }
C {devices/lab_pin.sym} 15460 -8890 0 0 {name=p15363 lab=_51694_/A }
C {devices/lab_pin.sym} 15540 -8890 0 1 {name=p15364 lab=_51619_/B }
C {sky130_stdcells/buf_2.sym} 15500 -8890 0 0 {name=X_51614_ }
C {devices/lab_pin.sym} 15460 -8770 0 0 {name=p15365 lab=_46155_/A }
C {devices/lab_pin.sym} 15540 -8770 0 1 {name=p15366 lab=_58253_/A }
C {sky130_stdcells/buf_2.sym} 15500 -8770 0 0 {name=X_58170_ }
C {devices/lab_pin.sym} 15410 -8650 0 0 {name=p15367 lab=_82436_/CLK }
C {devices/lab_pin.sym} 15410 -8630 0 0 {name=p15368 lab=_79126_/X }
C {devices/lab_pin.sym} 15590 -8650 0 1 {name=p15369 lab=_82434_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -8640 0 0 {name=X_82434_ }
C {sky130_stdcells/decap_3.sym} 15500 -8480 0 0 {name=XPHY_705 }
C {devices/lab_pin.sym} 15460 -8330 0 0 {name=p15370 lab=_55382_/A }
C {devices/lab_pin.sym} 15540 -8330 0 1 {name=p15371 lab=_55383_/C }
C {sky130_stdcells/inv_2.sym} 15500 -8330 0 0 {name=X_55382_ }
C {devices/lab_pin.sym} 15440 -8220 0 0 {name=p15372 lab=_67342_/A }
C {devices/lab_pin.sym} 15440 -8180 0 0 {name=p15373 lab=_67368_/B }
C {devices/lab_pin.sym} 15560 -8200 0 1 {name=p15374 lab=_67368_/X }
C {sky130_stdcells/and2_4.sym} 15500 -8200 0 0 {name=X_67368_ }
C {sky130_stdcells/decap_3.sym} 15500 -8040 0 0 {name=XPHY_716 }
C {devices/lab_pin.sym} 15440 -7920 0 0 {name=p15375 lab=_52614_/A }
C {devices/lab_pin.sym} 15440 -7880 0 0 {name=p15376 lab=_52594_/B }
C {devices/lab_pin.sym} 15440 -7840 0 0 {name=p15377 lab=_51919_/C }
C {devices/lab_pin.sym} 15440 -7800 0 0 {name=p15378 lab=_51768_/D }
C {devices/lab_pin.sym} 15560 -7860 0 1 {name=p15379 lab=_52594_/X }
C {sky130_stdcells/and4_4.sym} 15500 -7860 0 0 {name=X_52594_ }
C {devices/lab_pin.sym} 15460 -7710 0 0 {name=p15380 lab=_57096_/Y }
C {devices/lab_pin.sym} 15540 -7710 0 1 {name=p15381 lab=_57121_/X }
C {sky130_stdcells/buf_2.sym} 15500 -7710 0 0 {name=X_57121_ }
C {devices/lab_pin.sym} 15420 -7620 0 0 {name=p15382 lab=_68929_/X }
C {devices/lab_pin.sym} 15420 -7580 0 0 {name=p15383 lab=_69094_/Y }
C {devices/lab_pin.sym} 15420 -7540 0 0 {name=p15384 lab=_69095_/X }
C {devices/lab_pin.sym} 15420 -7500 0 0 {name=p15385 lab=_69106_/Y }
C {devices/lab_pin.sym} 15580 -7560 0 1 {name=p15386 lab=_69107_/X }
C {sky130_stdcells/a211o_4.sym} 15500 -7560 0 0 {name=X_69107_ }
C {devices/lab_pin.sym} 15420 -7430 0 0 {name=p15387 lab=_85461_/Q }
C {devices/lab_pin.sym} 15420 -7390 0 0 {name=p15388 lab=_54320_/X }
C {devices/lab_pin.sym} 15420 -7350 0 0 {name=p15389 lab=_54332_/Y }
C {devices/lab_pin.sym} 15580 -7390 0 1 {name=p15390 lab=_54333_/Y }
C {sky130_stdcells/o21ai_4.sym} 15500 -7390 0 0 {name=X_54333_ }
C {devices/lab_pin.sym} 15440 -7270 0 0 {name=p15391 lab=_66318_/X }
C {devices/lab_pin.sym} 15440 -7230 0 0 {name=p15392 lab=_66319_/B }
C {devices/lab_pin.sym} 15440 -7190 0 0 {name=p15393 lab=_66319_/C }
C {devices/lab_pin.sym} 15560 -7230 0 1 {name=p15394 lab=_66319_/X }
C {sky130_stdcells/and3_4.sym} 15500 -7230 0 0 {name=X_66319_ }
C {devices/lab_pin.sym} 15410 -7090 0 0 {name=p15395 lab=_85311_/CLK }
C {devices/lab_pin.sym} 15410 -7070 0 0 {name=p15396 lab=_85153_/D }
C {devices/lab_pin.sym} 15590 -7090 0 1 {name=p15397 lab=_55640_/A }
C {sky130_stdcells/dfxtp_4.sym} 15500 -7080 0 0 {name=X_85153_ }
C {devices/lab_pin.sym} 15440 -6960 0 0 {name=p15398 lab=_51545_/A }
C {devices/lab_pin.sym} 15440 -6920 0 0 {name=p15399 lab=_53072_/B }
C {devices/lab_pin.sym} 15560 -6940 0 1 {name=p15400 lab=_51545_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -6940 0 0 {name=X_51545_ }
C {devices/lab_pin.sym} 15410 -6810 0 0 {name=p15401 lab=_82369_/CLK }
C {devices/lab_pin.sym} 15410 -6790 0 0 {name=p15402 lab=_82365_/D }
C {devices/lab_pin.sym} 15590 -6810 0 1 {name=p15403 lab=_82365_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -6800 0 0 {name=X_82365_ }
C {devices/lab_pin.sym} 15460 -6670 0 0 {name=p15404 lab=_67062_/X }
C {devices/lab_pin.sym} 15540 -6670 0 1 {name=p15405 lab=_67324_/A }
C {sky130_stdcells/buf_2.sym} 15500 -6670 0 0 {name=X_67299_ }
C {devices/lab_pin.sym} 15410 -6550 0 0 {name=p15406 lab=_80928_/CLK }
C {devices/lab_pin.sym} 15410 -6530 0 0 {name=p15407 lab=_84104_/D }
C {devices/lab_pin.sym} 15590 -6550 0 1 {name=p15408 lab=_84104_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -6540 0 0 {name=X_84104_ }
C {devices/lab_pin.sym} 15420 -6440 0 0 {name=p15409 lab=_46159_/A }
C {devices/lab_pin.sym} 15420 -6400 0 0 {name=p15410 lab=_57047_/Y }
C {devices/lab_pin.sym} 15420 -6360 0 0 {name=p15411 lab=_57049_/Y }
C {devices/lab_pin.sym} 15420 -6320 0 0 {name=p15412 lab=_57051_/Y }
C {devices/lab_pin.sym} 15580 -6380 0 1 {name=p15413 lab=_57052_/X }
C {sky130_stdcells/a211o_4.sym} 15500 -6380 0 0 {name=X_57052_ }
C {devices/lab_pin.sym} 15410 -6230 0 0 {name=p15414 lab=_84105_/CLK }
C {devices/lab_pin.sym} 15410 -6210 0 0 {name=p15415 lab=_76184_/X }
C {devices/lab_pin.sym} 15590 -6230 0 1 {name=p15416 lab=_81724_/D }
C {sky130_stdcells/dfxtp_4.sym} 15500 -6220 0 0 {name=X_81316_ }
C {devices/lab_pin.sym} 15420 -6120 0 0 {name=p15417 lab=_87076_/Q }
C {devices/lab_pin.sym} 15420 -6080 0 0 {name=p15418 lab=_68948_/X }
C {devices/lab_pin.sym} 15420 -6040 0 0 {name=p15419 lab=_68993_/X }
C {devices/lab_pin.sym} 15420 -6000 0 0 {name=p15420 lab=_69037_/X }
C {devices/lab_pin.sym} 15580 -6060 0 1 {name=p15421 lab=_69038_/X }
C {sky130_stdcells/a211o_4.sym} 15500 -6060 0 0 {name=X_69038_ }
C {devices/lab_pin.sym} 15440 -5940 0 0 {name=p15422 lab=_54286_/A }
C {devices/lab_pin.sym} 15440 -5900 0 0 {name=p15423 lab=_54246_/X }
C {devices/lab_pin.sym} 15440 -5860 0 0 {name=p15424 lab=_54255_/C }
C {devices/lab_pin.sym} 15440 -5820 0 0 {name=p15425 lab=_53099_/D }
C {devices/lab_pin.sym} 15560 -5880 0 1 {name=p15426 lab=_54264_/X }
C {sky130_stdcells/and4_4.sym} 15500 -5880 0 0 {name=X_54264_ }
C {devices/lab_pin.sym} 15410 -5730 0 0 {name=p15427 lab=_83008_/CLK }
C {devices/lab_pin.sym} 15410 -5710 0 0 {name=p15428 lab=_57104_/X }
C {devices/lab_pin.sym} 15590 -5730 0 1 {name=p15429 lab=_45470_/A }
C {sky130_stdcells/dfxtp_4.sym} 15500 -5720 0 0 {name=X_85084_ }
C {devices/lab_pin.sym} 15420 -5610 0 0 {name=p15430 lab=_86003_/Q }
C {devices/lab_pin.sym} 15420 -5570 0 0 {name=p15431 lab=_51458_/X }
C {devices/lab_pin.sym} 15420 -5530 0 0 {name=p15432 lab=_51475_/Y }
C {devices/lab_pin.sym} 15580 -5570 0 1 {name=p15433 lab=_51476_/Y }
C {sky130_stdcells/o21ai_4.sym} 15500 -5570 0 0 {name=X_51476_ }
C {devices/lab_pin.sym} 15410 -5430 0 0 {name=p15434 lab=_82299_/CLK }
C {devices/lab_pin.sym} 15410 -5410 0 0 {name=p15435 lab=_81920_/Q }
C {devices/lab_pin.sym} 15590 -5430 0 1 {name=p15436 lab=_82296_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -5420 0 0 {name=X_82296_ }
C {devices/lab_pin.sym} 15440 -5320 0 0 {name=p15437 lab=_56002_/Y }
C {devices/lab_pin.sym} 15440 -5280 0 0 {name=p15438 lab=_56003_/B }
C {devices/lab_pin.sym} 15440 -5240 0 0 {name=p15439 lab=_55966_/X }
C {devices/lab_pin.sym} 15440 -5200 0 0 {name=p15440 lab=_55975_/X }
C {devices/lab_pin.sym} 15560 -5260 0 1 {name=p15441 lab=_56003_/Y }
C {sky130_stdcells/nand4_4.sym} 15500 -5260 0 0 {name=X_56003_ }
C {devices/lab_pin.sym} 15460 -5110 0 0 {name=p15442 lab=_53189_/A }
C {devices/lab_pin.sym} 15540 -5110 0 1 {name=p15443 lab=_53215_/X }
C {sky130_stdcells/buf_2.sym} 15500 -5110 0 0 {name=X_53215_ }
C {devices/lab_pin.sym} 15410 -4990 0 0 {name=p15444 lab=_81160_/CLK }
C {devices/lab_pin.sym} 15410 -4970 0 0 {name=p15445 lab=_68116_/X }
C {devices/lab_pin.sym} 15590 -4990 0 1 {name=p15446 lab=_84035_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -4980 0 0 {name=X_84035_ }
C {devices/lab_pin.sym} 15440 -4860 0 0 {name=p15447 lab=_50432_/A }
C {devices/lab_pin.sym} 15440 -4820 0 0 {name=p15448 lab=_48435_/B }
C {devices/lab_pin.sym} 15560 -4840 0 1 {name=p15449 lab=_50427_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -4840 0 0 {name=X_50427_ }
C {devices/lab_pin.sym} 15410 -4710 0 0 {name=p15450 lab=_85335_/CLK }
C {devices/lab_pin.sym} 15410 -4690 0 0 {name=p15451 lab=_81055_/Q }
C {devices/lab_pin.sym} 15590 -4710 0 1 {name=p15452 lab=_47547_/A }
C {sky130_stdcells/dfxtp_4.sym} 15500 -4700 0 0 {name=X_81247_ }
C {devices/lab_pin.sym} 15440 -4580 0 0 {name=p15453 lab=_54215_/A }
C {devices/lab_pin.sym} 15440 -4540 0 0 {name=p15454 lab=_47403_/A }
C {devices/lab_pin.sym} 15560 -4560 0 1 {name=p15455 lab=_54195_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -4560 0 0 {name=X_54195_ }
C {devices/lab_pin.sym} 15460 -4430 0 0 {name=p15456 lab=_70772_/A }
C {devices/lab_pin.sym} 15540 -4430 0 1 {name=p15457 lab=_71001_/C }
C {sky130_stdcells/buf_2.sym} 15500 -4430 0 0 {name=X_71000_ }
C {devices/lab_pin.sym} 15420 -4330 0 0 {name=p15458 lab=_41061_/X }
C {devices/lab_pin.sym} 15420 -4290 0 0 {name=p15459 lab=_81720_/Q }
C {devices/lab_pin.sym} 15420 -4250 0 0 {name=p15460 lab=_41159_/X }
C {devices/lab_pin.sym} 15580 -4290 0 1 {name=p15461 lab=_41161_/A }
C {sky130_stdcells/o21ai_4.sym} 15500 -4290 0 0 {name=X_41160_ }
C {devices/lab_pin.sym} 15460 -4150 0 0 {name=p15462 lab=_53172_/A }
C {devices/lab_pin.sym} 15540 -4150 0 1 {name=p15463 lab=_53146_/X }
C {sky130_stdcells/buf_2.sym} 15500 -4150 0 0 {name=X_53146_ }
C {devices/lab_pin.sym} 15440 -4040 0 0 {name=p15464 lab=_50398_/A }
C {devices/lab_pin.sym} 15440 -4000 0 0 {name=p15465 lab=_50358_/B }
C {devices/lab_pin.sym} 15560 -4020 0 1 {name=p15466 lab=_50358_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -4020 0 0 {name=X_50358_ }
C {devices/lab_pin.sym} 15410 -3890 0 0 {name=p15467 lab=_82335_/CLK }
C {devices/lab_pin.sym} 15410 -3870 0 0 {name=p15468 lab=_75024_/B }
C {devices/lab_pin.sym} 15590 -3890 0 1 {name=p15469 lab=_40402_/B }
C {sky130_stdcells/dfxtp_4.sym} 15500 -3880 0 0 {name=X_81178_ }
C {devices/lab_pin.sym} 15440 -3760 0 0 {name=p15470 lab=_80126_/X }
C {devices/lab_pin.sym} 15440 -3720 0 0 {name=p15471 lab=_80129_/B }
C {devices/lab_pin.sym} 15560 -3740 0 1 {name=p15472 lab=_81685_/D }
C {sky130_stdcells/xor2_4.sym} 15500 -3740 0 0 {name=X_80129_ }
C {devices/lab_pin.sym} 15420 -3630 0 0 {name=p15473 lab=_85701_/Q }
C {devices/lab_pin.sym} 15420 -3590 0 0 {name=p15474 lab=_53065_/X }
C {devices/lab_pin.sym} 15420 -3550 0 0 {name=p15475 lab=_53076_/Y }
C {devices/lab_pin.sym} 15580 -3590 0 1 {name=p15476 lab=_53077_/Y }
C {sky130_stdcells/o21ai_4.sym} 15500 -3590 0 0 {name=X_53077_ }
C {devices/lab_pin.sym} 15460 -3450 0 0 {name=p15477 lab=_58721_/A }
C {devices/lab_pin.sym} 15540 -3450 0 1 {name=p15478 lab=_57954_/X }
C {sky130_stdcells/buf_2.sym} 15500 -3450 0 0 {name=X_57954_ }
C {devices/lab_pin.sym} 15440 -3340 0 0 {name=p15479 lab=_40912_/B }
C {devices/lab_pin.sym} 15440 -3300 0 0 {name=p15480 lab=_41091_/B }
C {devices/lab_pin.sym} 15560 -3320 0 1 {name=p15481 lab=_41091_/X }
C {sky130_stdcells/or2_4.sym} 15500 -3320 0 0 {name=X_41091_ }
C {devices/lab_pin.sym} 15440 -3200 0 0 {name=p15482 lab=_50285_/A }
C {devices/lab_pin.sym} 15440 -3160 0 0 {name=p15483 lab=_48236_/B }
C {devices/lab_pin.sym} 15560 -3180 0 1 {name=p15484 lab=_50289_/Y }
C {sky130_stdcells/nand2_4.sym} 15500 -3180 0 0 {name=X_50289_ }
C {devices/lab_pin.sym} 15410 -3050 0 0 {name=p15485 lab=_85697_/CLK }
C {devices/lab_pin.sym} 15410 -3030 0 0 {name=p15486 lab=_51571_/Y }
C {devices/lab_pin.sym} 15590 -3050 0 1 {name=p15487 lab=_85986_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -3040 0 0 {name=X_85986_ }
C {devices/lab_pin.sym} 15460 -2910 0 0 {name=p15488 lab=_83315_/Q }
C {devices/lab_pin.sym} 15540 -2910 0 1 {name=p15489 lab=_56908_/A }
C {sky130_stdcells/inv_2.sym} 15500 -2910 0 0 {name=X_56905_ }
C {devices/lab_pin.sym} 15420 -2810 0 0 {name=p15490 lab=_66166_/B }
C {devices/lab_pin.sym} 15420 -2770 0 0 {name=p15491 lab=_51994_/X }
C {devices/lab_pin.sym} 15420 -2730 0 0 {name=p15492 lab=_52027_/Y }
C {devices/lab_pin.sym} 15580 -2770 0 1 {name=p15493 lab=_52028_/Y }
C {sky130_stdcells/o21ai_4.sym} 15500 -2770 0 0 {name=X_52028_ }
C {devices/lab_pin.sym} 15410 -2630 0 0 {name=p15494 lab=_87221_/CLK }
C {devices/lab_pin.sym} 15410 -2610 0 0 {name=p15495 lab=_42773_/Y }
C {devices/lab_pin.sym} 15590 -2630 0 1 {name=p15496 lab=_87725_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -2620 0 0 {name=X_87725_ }
C {devices/lab_pin.sym} 15410 -2490 0 0 {name=p15497 lab=_85485_/CLK }
C {devices/lab_pin.sym} 15410 -2470 0 0 {name=p15498 lab=_84937_/D }
C {devices/lab_pin.sym} 15590 -2490 0 1 {name=p15499 lab=_84937_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -2480 0 0 {name=X_84937_ }
C {devices/lab_pin.sym} 15460 -2350 0 0 {name=p15500 lab=_72951_/A }
C {devices/lab_pin.sym} 15540 -2350 0 1 {name=p15501 lab=_72951_/X }
C {sky130_stdcells/buf_2.sym} 15500 -2350 0 0 {name=X_72951_ }
C {devices/lab_pin.sym} 15420 -2250 0 0 {name=p15502 lab=_57884_/X }
C {devices/lab_pin.sym} 15420 -2210 0 0 {name=p15503 lab=_85494_/Q }
C {devices/lab_pin.sym} 15420 -2170 0 0 {name=p15504 lab=_57763_/X }
C {devices/lab_pin.sym} 15580 -2210 0 1 {name=p15505 lab=_57885_/X }
C {sky130_stdcells/o21a_4.sym} 15500 -2210 0 0 {name=X_57885_ }
C {devices/lab_pin.sym} 15460 -2070 0 0 {name=p15506 lab=_70591_/A }
C {devices/lab_pin.sym} 15540 -2070 0 1 {name=p15507 lab=_71902_/X }
C {sky130_stdcells/buf_2.sym} 15500 -2070 0 0 {name=X_71902_ }
C {devices/lab_pin.sym} 15440 -1970 0 0 {name=p15508 lab=_59619_/X }
C {devices/lab_pin.sym} 15440 -1930 0 0 {name=p15509 lab=_59621_/X }
C {devices/lab_pin.sym} 15440 -1890 0 0 {name=p15510 lab=_59753_/B }
C {devices/lab_pin.sym} 15560 -1930 0 1 {name=p15511 lab=_59624_/X }
C {sky130_stdcells/and3_4.sym} 15500 -1930 0 0 {name=X_59624_ }
C {devices/lab_pin.sym} 15420 -1820 0 0 {name=p15512 lab=_41744_/Y }
C {devices/lab_pin.sym} 15420 -1780 0 0 {name=p15513 lab=_44848_/X }
C {devices/lab_pin.sym} 15420 -1740 0 0 {name=p15514 lab=_86921_/Q }
C {devices/lab_pin.sym} 15420 -1700 0 0 {name=p15515 lab=_44849_/X }
C {devices/lab_pin.sym} 15580 -1760 0 1 {name=p15516 lab=_86921_/D }
C {sky130_stdcells/a2bb2o_4.sym} 15500 -1760 0 0 {name=X_44850_ }
C {devices/lab_pin.sym} 15440 -1640 0 0 {name=p15517 lab=_56759_/X }
C {devices/lab_pin.sym} 15440 -1600 0 0 {name=p15518 lab=_56866_/A }
C {devices/lab_pin.sym} 15440 -1560 0 0 {name=p15519 lab=_83333_/Q }
C {devices/lab_pin.sym} 15440 -1520 0 0 {name=p15520 lab=_56659_/Y }
C {devices/lab_pin.sym} 15560 -1580 0 1 {name=p15521 lab=_56836_/Y }
C {sky130_stdcells/nand4_4.sym} 15500 -1580 0 0 {name=X_56836_ }
C {devices/lab_pin.sym} 15440 -1440 0 0 {name=p15522 lab=_75670_/A }
C {devices/lab_pin.sym} 15440 -1400 0 0 {name=p15523 lab=_75669_/Y }
C {devices/lab_pin.sym} 15560 -1420 0 1 {name=p15524 lab=_75674_/A }
C {sky130_stdcells/xor2_4.sym} 15500 -1420 0 0 {name=X_75670_ }
C {devices/lab_pin.sym} 15410 -1290 0 0 {name=p15525 lab=_86932_/CLK }
C {devices/lab_pin.sym} 15410 -1270 0 0 {name=p15526 lab=_42911_/X }
C {devices/lab_pin.sym} 15590 -1290 0 1 {name=p15527 lab=_87656_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -1280 0 0 {name=X_87656_ }
C {devices/lab_pin.sym} 15420 -1180 0 0 {name=p15528 lab=_56181_/X }
C {devices/lab_pin.sym} 15420 -1140 0 0 {name=p15529 lab=_83077_/Q }
C {devices/lab_pin.sym} 15420 -1100 0 0 {name=p15530 lab=_72880_/X }
C {devices/lab_pin.sym} 15420 -1060 0 0 {name=p15531 lab=_72881_/X }
C {devices/lab_pin.sym} 15580 -1120 0 1 {name=p15532 lab=_72883_/B }
C {sky130_stdcells/a211o_4.sym} 15500 -1120 0 0 {name=X_72882_ }
C {devices/lab_pin.sym} 15410 -970 0 0 {name=p15533 lab=_84823_/CLK }
C {devices/lab_pin.sym} 15410 -950 0 0 {name=p15534 lab=_58365_/X }
C {devices/lab_pin.sym} 15590 -970 0 1 {name=p15535 lab=_84868_/Q }
C {sky130_stdcells/dfxtp_4.sym} 15500 -960 0 0 {name=X_84868_ }
C {devices/lab_pin.sym} 15460 -830 0 0 {name=p15536 lab=_43752_/A }
C {devices/lab_pin.sym} 15540 -830 0 1 {name=p15537 lab=_43801_/X }
C {sky130_stdcells/buf_2.sym} 15500 -830 0 0 {name=X_43801_ }
C {devices/lab_pin.sym} 15420 -740 0 0 {name=p15538 lab=_58253_/A }
C {devices/lab_pin.sym} 15420 -700 0 0 {name=p15539 lab=_74613_/X }
C {devices/lab_pin.sym} 15420 -660 0 0 {name=p15540 lab=_56164_/A }
C {devices/lab_pin.sym} 15420 -620 0 0 {name=p15541 lab=_74614_/X }
C {devices/lab_pin.sym} 15580 -680 0 1 {name=p15542 lab=_74621_/X }
C {sky130_stdcells/a211o_4.sym} 15500 -680 0 0 {name=X_74621_ }
C {devices/lab_pin.sym} 16330 -42150 0 0 {name=p15543 lab=_86610_/CLK }
C {devices/lab_pin.sym} 16330 -42130 0 0 {name=p15544 lab=_86607_/D }
C {devices/lab_pin.sym} 16510 -42150 0 1 {name=p15545 lab=_72336_/A }
C {sky130_stdcells/dfxtp_4.sym} 16420 -42140 0 0 {name=X_86607_ }
C {devices/lab_pin.sym} 16360 -42040 0 0 {name=p15546 lab=_71829_/X }
C {devices/lab_pin.sym} 16360 -42000 0 0 {name=p15547 lab=_71839_/B }
C {devices/lab_pin.sym} 16360 -41960 0 0 {name=p15548 lab=_70771_/A }
C {devices/lab_pin.sym} 16360 -41920 0 0 {name=p15549 lab=_71826_/X }
C {devices/lab_pin.sym} 16480 -41980 0 1 {name=p15550 lab=_71833_/X }
C {sky130_stdcells/and4_4.sym} 16420 -41980 0 0 {name=X_71833_ }
C {devices/lab_pin.sym} 16380 -41830 0 0 {name=p15551 lab=_59602_/A }
C {devices/lab_pin.sym} 16460 -41830 0 1 {name=p15552 lab=_61276_/B }
C {sky130_stdcells/buf_2.sym} 16420 -41830 0 0 {name=X_59555_ }
C {devices/lab_pin.sym} 16330 -41710 0 0 {name=p15553 lab=_83819_/CLK }
C {devices/lab_pin.sym} 16330 -41690 0 0 {name=p15554 lab=_70261_/X }
C {devices/lab_pin.sym} 16510 -41710 0 1 {name=p15555 lab=_74751_/A }
C {sky130_stdcells/dfxtp_4.sym} 16420 -41700 0 0 {name=X_83819_ }
C {devices/lab_pin.sym} 16380 -41570 0 0 {name=p15556 lab=_44780_/Y }
C {devices/lab_pin.sym} 16460 -41570 0 1 {name=p15557 lab=_86958_/D }
C {sky130_stdcells/inv_2.sym} 16420 -41570 0 0 {name=X_44781_ }
C {devices/lab_pin.sym} 16380 -41450 0 0 {name=p15558 lab=_83324_/Q }
C {devices/lab_pin.sym} 16460 -41450 0 1 {name=p15559 lab=_56767_/X }
C {sky130_stdcells/buf_2.sym} 16420 -41450 0 0 {name=X_56767_ }
C {devices/lab_pin.sym} 16330 -41330 0 0 {name=p15560 lab=_87588_/CLK }
C {devices/lab_pin.sym} 16330 -41310 0 0 {name=p15561 lab=_87587_/D }
C {devices/lab_pin.sym} 16510 -41330 0 1 {name=p15562 lab=_43070_/A }
C {sky130_stdcells/dfxtp_4.sym} 16420 -41320 0 0 {name=X_87587_ }
C {devices/lab_pin.sym} 16380 -41190 0 0 {name=p15563 lab=_41993_/A }
C {devices/lab_pin.sym} 16460 -41190 0 1 {name=p15564 lab=_41993_/X }
C {sky130_stdcells/buf_2.sym} 16420 -41190 0 0 {name=X_41993_ }
C {devices/lab_pin.sym} 16340 -41090 0 0 {name=p15565 lab=_53977_/Y }
C {devices/lab_pin.sym} 16340 -41050 0 0 {name=p15566 lab=_53948_/X }
C {devices/lab_pin.sym} 16340 -41010 0 0 {name=p15567 lab=_53978_/Y }
C {devices/lab_pin.sym} 16500 -41050 0 1 {name=p15568 lab=_85530_/D }
C {sky130_stdcells/a21boi_4.sym} 16420 -41050 0 0 {name=X_53979_ }
C {devices/lab_pin.sym} 16330 -40910 0 0 {name=p15569 lab=_84797_/CLK }
C {devices/lab_pin.sym} 16330 -40890 0 0 {name=p15570 lab=_58803_/Y }
C {devices/lab_pin.sym} 16510 -40910 0 1 {name=p15571 lab=_84799_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -40900 0 0 {name=X_84799_ }
C {devices/lab_pin.sym} 16380 -40770 0 0 {name=p15572 lab=_54058_/B }
C {devices/lab_pin.sym} 16460 -40770 0 1 {name=p15573 lab=_51358_/B }
C {sky130_stdcells/buf_2.sym} 16420 -40770 0 0 {name=X_46520_ }
C {devices/lab_pin.sym} 16360 -40660 0 0 {name=p15574 lab=_58506_/A }
C {devices/lab_pin.sym} 16360 -40620 0 0 {name=p15575 lab=_58502_/B }
C {devices/lab_pin.sym} 16480 -40640 0 1 {name=p15576 lab=_58506_/Y }
C {sky130_stdcells/nor2_4.sym} 16420 -40640 0 0 {name=X_58506_ }
C {devices/lab_pin.sym} 16360 -40520 0 0 {name=p15577 lab=_77339_/B }
C {devices/lab_pin.sym} 16360 -40480 0 0 {name=p15578 lab=_77339_/A }
C {devices/lab_pin.sym} 16480 -40500 0 1 {name=p15579 lab=_77340_/Y }
C {sky130_stdcells/nand2_4.sym} 16420 -40500 0 0 {name=X_77340_ }
C {devices/lab_pin.sym} 16380 -40370 0 0 {name=p15580 lab=_43732_/A }
C {devices/lab_pin.sym} 16460 -40370 0 1 {name=p15581 lab=_69885_/B }
C {sky130_stdcells/inv_2.sym} 16420 -40370 0 0 {name=X_43732_ }
C {devices/lab_pin.sym} 16340 -40270 0 0 {name=p15582 lab=_55710_/Y }
C {devices/lab_pin.sym} 16340 -40230 0 0 {name=p15583 lab=_55712_/Y }
C {devices/lab_pin.sym} 16340 -40190 0 0 {name=p15584 lab=_55717_/Y }
C {devices/lab_pin.sym} 16500 -40230 0 1 {name=p15585 lab=_56167_/B }
C {sky130_stdcells/a21oi_4.sym} 16420 -40230 0 0 {name=X_55718_ }
C {devices/lab_pin.sym} 16330 -40090 0 0 {name=p15586 lab=_86218_/CLK }
C {devices/lab_pin.sym} 16330 -40070 0 0 {name=p15587 lab=_86538_/D }
C {devices/lab_pin.sym} 16510 -40090 0 1 {name=p15588 lab=_66242_/B }
C {sky130_stdcells/dfxtp_4.sym} 16420 -40080 0 0 {name=X_86538_ }
C {devices/lab_pin.sym} 16380 -39950 0 0 {name=p15589 lab=_45932_/Y }
C {devices/lab_pin.sym} 16460 -39950 0 1 {name=p15590 lab=_74552_/X }
C {sky130_stdcells/buf_2.sym} 16420 -39950 0 0 {name=X_74552_ }
C {devices/lab_pin.sym} 16380 -39830 0 0 {name=p15591 lab=_40835_/A }
C {devices/lab_pin.sym} 16460 -39830 0 1 {name=p15592 lab=_40944_/X }
C {sky130_stdcells/buf_2.sym} 16420 -39830 0 0 {name=X_40944_ }
C {devices/lab_pin.sym} 16360 -39730 0 0 {name=p15593 lab=_71763_/X }
C {devices/lab_pin.sym} 16360 -39690 0 0 {name=p15594 lab=_71422_/C }
C {devices/lab_pin.sym} 16360 -39650 0 0 {name=p15595 lab=_70794_/X }
C {devices/lab_pin.sym} 16480 -39690 0 1 {name=p15596 lab=_71764_/X }
C {sky130_stdcells/and3_4.sym} 16420 -39690 0 0 {name=X_71764_ }
C {devices/lab_pin.sym} 16360 -39560 0 0 {name=p15597 lab=_63384_/B }
C {devices/lab_pin.sym} 16360 -39520 0 0 {name=p15598 lab=_58532_/X }
C {devices/lab_pin.sym} 16480 -39540 0 1 {name=p15599 lab=_59486_/Y }
C {sky130_stdcells/nor2_4.sym} 16420 -39540 0 0 {name=X_59486_ }
C {devices/lab_pin.sym} 16380 -39410 0 0 {name=p15600 lab=_83337_/Q }
C {devices/lab_pin.sym} 16460 -39410 0 1 {name=p15601 lab=_56698_/Y }
C {sky130_stdcells/inv_2.sym} 16420 -39410 0 0 {name=X_56698_ }
C {devices/lab_pin.sym} 16360 -39300 0 0 {name=p15602 lab=_48683_/A }
C {devices/lab_pin.sym} 16360 -39260 0 0 {name=p15603 lab=_73502_/Y }
C {devices/lab_pin.sym} 16480 -39280 0 1 {name=p15604 lab=_73503_/X }
C {sky130_stdcells/xor2_4.sym} 16420 -39280 0 0 {name=X_73503_ }
C {devices/lab_pin.sym} 16380 -39150 0 0 {name=p15605 lab=_50460_/A }
C {devices/lab_pin.sym} 16460 -39150 0 1 {name=p15606 lab=_53874_/A }
C {sky130_stdcells/buf_2.sym} 16420 -39150 0 0 {name=X_46451_ }
C {devices/lab_pin.sym} 16340 -39050 0 0 {name=p15607 lab=_52760_/B }
C {devices/lab_pin.sym} 16340 -39010 0 0 {name=p15608 lab=_70699_/X }
C {devices/lab_pin.sym} 16340 -38970 0 0 {name=p15609 lab=_70714_/Y }
C {devices/lab_pin.sym} 16500 -39010 0 1 {name=p15610 lab=_83719_/D }
C {sky130_stdcells/o21ai_4.sym} 16420 -39010 0 0 {name=X_70715_ }
C {devices/lab_pin.sym} 16380 -38870 0 0 {name=p15611 lab=_63209_/A }
C {devices/lab_pin.sym} 16460 -38870 0 1 {name=p15612 lab=_58438_/A }
C {sky130_stdcells/buf_2.sym} 16420 -38870 0 0 {name=X_58437_ }
C {devices/lab_pin.sym} 16360 -38770 0 0 {name=p15613 lab=_77269_/Y }
C {devices/lab_pin.sym} 16360 -38730 0 0 {name=p15614 lab=_77266_/X }
C {devices/lab_pin.sym} 16360 -38690 0 0 {name=p15615 lab=_77267_/Y }
C {devices/lab_pin.sym} 16480 -38730 0 1 {name=p15616 lab=_77274_/B }
C {sky130_stdcells/nand3_4.sym} 16420 -38730 0 0 {name=X_77271_ }
C {devices/lab_pin.sym} 16380 -38590 0 0 {name=p15617 lab=_43663_/A }
C {devices/lab_pin.sym} 16460 -38590 0 1 {name=p15618 lab=_43663_/Y }
C {sky130_stdcells/inv_2.sym} 16420 -38590 0 0 {name=X_43663_ }
C {devices/lab_pin.sym} 16340 -38510 0 0 {name=p15619 lab=_56564_/A }
C {devices/lab_pin.sym} 16340 -38470 0 0 {name=p15620 lab=_55624_/X }
C {devices/lab_pin.sym} 16340 -38430 0 0 {name=p15621 lab=_56564_/C }
C {devices/lab_pin.sym} 16340 -38390 0 0 {name=p15622 lab=_56564_/D }
C {devices/lab_pin.sym} 16340 -38360 0 0 {name=p15623 lab=_55648_/X }
C {devices/lab_pin.sym} 16500 -38430 0 1 {name=p15624 lab=_55649_/Y }
C {sky130_stdcells/a41oi_4.sym} 16420 -38430 0 0 {name=X_55649_ }
C {devices/lab_pin.sym} 16360 -38290 0 0 {name=p15625 lab=_48634_/A }
C {devices/lab_pin.sym} 16360 -38250 0 0 {name=p15626 lab=_74501_/B }
C {devices/lab_pin.sym} 16360 -38210 0 0 {name=p15627 lab=_74478_/C }
C {devices/lab_pin.sym} 16480 -38250 0 1 {name=p15628 lab=_74483_/X }
C {sky130_stdcells/and3_4.sym} 16420 -38250 0 0 {name=X_74483_ }
C {devices/lab_pin.sym} 16330 -38110 0 0 {name=p15629 lab=_86499_/CLK }
C {devices/lab_pin.sym} 16330 -38090 0 0 {name=p15630 lab=_48860_/Y }
C {devices/lab_pin.sym} 16510 -38110 0 1 {name=p15631 lab=_86469_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -38100 0 0 {name=X_86469_ }
C {devices/lab_pin.sym} 16340 -38010 0 0 {name=p15632 lab=_40870_/X }
C {devices/lab_pin.sym} 16340 -37970 0 0 {name=p15633 lab=_40871_/X }
C {devices/lab_pin.sym} 16340 -37930 0 0 {name=p15634 lab=_40874_/X }
C {devices/lab_pin.sym} 16340 -37890 0 0 {name=p15635 lab=_69842_/B }
C {devices/lab_pin.sym} 16340 -37850 0 0 {name=p15636 lab=_40867_/X }
C {devices/lab_pin.sym} 16500 -37930 0 1 {name=p15637 lab=_40875_/Y }
C {sky130_stdcells/o32ai_4.sym} 16420 -37930 0 0 {name=X_40875_ }
C {devices/lab_pin.sym} 16380 -37770 0 0 {name=p15638 lab=_71690_/Y }
C {devices/lab_pin.sym} 16460 -37770 0 1 {name=p15639 lab=_71695_/X }
C {sky130_stdcells/buf_2.sym} 16420 -37770 0 0 {name=X_71695_ }
C {devices/lab_pin.sym} 16360 -37660 0 0 {name=p15640 lab=_79010_/A }
C {devices/lab_pin.sym} 16360 -37620 0 0 {name=p15641 lab=_79010_/B }
C {devices/lab_pin.sym} 16480 -37640 0 1 {name=p15642 lab=_79011_/B }
C {sky130_stdcells/xor2_4.sym} 16420 -37640 0 0 {name=X_79010_ }
C {devices/lab_pin.sym} 16340 -37530 0 0 {name=p15643 lab=_55640_/A }
C {devices/lab_pin.sym} 16340 -37490 0 0 {name=p15644 lab=_44935_/X }
C {devices/lab_pin.sym} 16340 -37450 0 0 {name=p15645 lab=_45757_/A }
C {devices/lab_pin.sym} 16500 -37490 0 1 {name=p15646 lab=_45402_/X }
C {sky130_stdcells/o21a_4.sym} 16420 -37490 0 0 {name=X_45402_ }
C {devices/lab_pin.sym} 16380 -37350 0 0 {name=p15647 lab=_76221_/Y }
C {devices/lab_pin.sym} 16460 -37350 0 1 {name=p15648 lab=_76222_/Y }
C {sky130_stdcells/inv_2.sym} 16420 -37350 0 0 {name=X_76222_ }
C {devices/lab_pin.sym} 16330 -37230 0 0 {name=p15649 lab=_88208_/CLK }
C {devices/lab_pin.sym} 16330 -37210 0 0 {name=p15650 lab=_88208_/D }
C {devices/lab_pin.sym} 16510 -37230 0 1 {name=p15651 lab=_66656_/B }
C {sky130_stdcells/dfxtp_4.sym} 16420 -37220 0 0 {name=X_88208_ }
C {devices/lab_pin.sym} 16380 -37090 0 0 {name=p15652 lab=_42590_/A }
C {devices/lab_pin.sym} 16460 -37090 0 1 {name=p15653 lab=_42614_/X }
C {sky130_stdcells/buf_2.sym} 16420 -37090 0 0 {name=X_42614_ }
C {devices/lab_pin.sym} 16360 -36980 0 0 {name=p15654 lab=_81189_/Q }
C {devices/lab_pin.sym} 16360 -36940 0 0 {name=p15655 lab=_49161_/B }
C {devices/lab_pin.sym} 16480 -36960 0 1 {name=p15656 lab=_49170_/Y }
C {sky130_stdcells/nor2_4.sym} 16420 -36960 0 0 {name=X_49170_ }
C {devices/lab_pin.sym} 16360 -36850 0 0 {name=p15657 lab=_73432_/X }
C {devices/lab_pin.sym} 16360 -36810 0 0 {name=p15658 lab=_73434_/B }
C {devices/lab_pin.sym} 16360 -36770 0 0 {name=p15659 lab=_73434_/C }
C {devices/lab_pin.sym} 16480 -36810 0 1 {name=p15660 lab=_73434_/Y }
C {sky130_stdcells/nand3_4.sym} 16420 -36810 0 0 {name=X_73434_ }
C {devices/lab_pin.sym} 16380 -36670 0 0 {name=p15661 lab=_51294_/B }
C {devices/lab_pin.sym} 16460 -36670 0 1 {name=p15662 lab=_52478_/B }
C {sky130_stdcells/buf_2.sym} 16420 -36670 0 0 {name=X_46382_ }
C {devices/lab_pin.sym} 16340 -36570 0 0 {name=p15663 lab=_53021_/B }
C {devices/lab_pin.sym} 16340 -36530 0 0 {name=p15664 lab=_70632_/X }
C {devices/lab_pin.sym} 16340 -36490 0 0 {name=p15665 lab=_70645_/Y }
C {devices/lab_pin.sym} 16500 -36530 0 1 {name=p15666 lab=_83735_/D }
C {sky130_stdcells/o21ai_4.sym} 16420 -36530 0 0 {name=X_70646_ }
C {devices/lab_pin.sym} 16380 -36390 0 0 {name=p15667 lab=_63344_/A }
C {devices/lab_pin.sym} 16460 -36390 0 1 {name=p15668 lab=_58370_/A }
C {sky130_stdcells/buf_2.sym} 16420 -36390 0 0 {name=X_58368_ }
C {devices/lab_pin.sym} 16340 -36300 0 0 {name=p15669 lab=_40559_/X }
C {devices/lab_pin.sym} 16340 -36260 0 0 {name=p15670 lab=_43586_/X }
C {devices/lab_pin.sym} 16340 -36220 0 0 {name=p15671 lab=_43587_/Y }
C {devices/lab_pin.sym} 16340 -36180 0 0 {name=p15672 lab=_43593_/X }
C {devices/lab_pin.sym} 16500 -36240 0 1 {name=p15673 lab=_43595_/A }
C {sky130_stdcells/a2bb2o_4.sym} 16420 -36240 0 0 {name=X_43594_ }
C {devices/lab_pin.sym} 16380 -36090 0 0 {name=p15674 lab=clkbuf_7_41_0_CLK/A }
C {devices/lab_pin.sym} 16460 -36090 0 1 {name=p15675 lab=clkbuf_8_83_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 16420 -36090 0 0 {name=Xclkbuf_7_41_0_CLK }
C {devices/lab_pin.sym} 16340 -35990 0 0 {name=p15676 lab=_48117_/Y }
C {devices/lab_pin.sym} 16340 -35950 0 0 {name=p15677 lab=_48109_/X }
C {devices/lab_pin.sym} 16340 -35910 0 0 {name=p15678 lab=_48120_/X }
C {devices/lab_pin.sym} 16500 -35950 0 1 {name=p15679 lab=_48121_/Y }
C {sky130_stdcells/a21oi_4.sym} 16420 -35950 0 0 {name=X_48121_ }
C {devices/lab_pin.sym} 16340 -35830 0 0 {name=p15680 lab=_45330_/X }
C {devices/lab_pin.sym} 16340 -35790 0 0 {name=p15681 lab=_45332_/Y }
C {devices/lab_pin.sym} 16340 -35750 0 0 {name=p15682 lab=_45275_/X }
C {devices/lab_pin.sym} 16500 -35790 0 1 {name=p15683 lab=_45333_/Y }
C {sky130_stdcells/a21oi_4.sym} 16420 -35790 0 0 {name=X_45333_ }
C {devices/lab_pin.sym} 16360 -35680 0 0 {name=p15684 lab=_56782_/X }
C {devices/lab_pin.sym} 16360 -35640 0 0 {name=p15685 lab=_57023_/X }
C {devices/lab_pin.sym} 16360 -35600 0 0 {name=p15686 lab=_56768_/Y }
C {devices/lab_pin.sym} 16360 -35560 0 0 {name=p15687 lab=_57319_/D }
C {devices/lab_pin.sym} 16480 -35620 0 1 {name=p15688 lab=_57319_/X }
C {sky130_stdcells/and4_4.sym} 16420 -35620 0 0 {name=X_57319_ }
C {devices/lab_pin.sym} 16380 -35470 0 0 {name=p15689 lab=_76152_/Y }
C {devices/lab_pin.sym} 16460 -35470 0 1 {name=p15690 lab=_76153_/Y }
C {sky130_stdcells/inv_2.sym} 16420 -35470 0 0 {name=X_76153_ }
C {devices/lab_pin.sym} 16330 -35350 0 0 {name=p15691 lab=_86824_/CLK }
C {devices/lab_pin.sym} 16330 -35330 0 0 {name=p15692 lab=_88139_/D }
C {devices/lab_pin.sym} 16510 -35350 0 1 {name=p15693 lab=_88139_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -35340 0 0 {name=X_88139_ }
C {devices/lab_pin.sym} 16380 -35210 0 0 {name=p15694 lab=clkbuf_7_90_0_CLK/X }
C {devices/lab_pin.sym} 16460 -35210 0 1 {name=p15695 lab=clkbuf_9_363_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 16420 -35210 0 0 {name=Xclkbuf_8_181_0_CLK }
C {devices/lab_pin.sym} 16380 -35090 0 0 {name=p15696 lab=_72769_/A }
C {devices/lab_pin.sym} 16460 -35090 0 1 {name=p15697 lab=_69583_/B }
C {sky130_stdcells/inv_2.sym} 16420 -35090 0 0 {name=X_42545_ }
C {devices/lab_pin.sym} 16360 -34990 0 0 {name=p15698 lab=_73363_/X }
C {devices/lab_pin.sym} 16360 -34950 0 0 {name=p15699 lab=_73365_/B }
C {devices/lab_pin.sym} 16360 -34910 0 0 {name=p15700 lab=_73365_/C }
C {devices/lab_pin.sym} 16480 -34950 0 1 {name=p15701 lab=_73365_/Y }
C {sky130_stdcells/nand3_4.sym} 16420 -34950 0 0 {name=X_73365_ }
C {devices/lab_pin.sym} 16380 -34810 0 0 {name=p15702 lab=MACRO_WR_SELECT }
C {devices/lab_pin.sym} 16460 -34810 0 1 {name=p15703 lab=_70578_/A }
C {sky130_stdcells/buf_2.sym} 16420 -34810 0 0 {name=X_70577_ }
C {devices/lab_pin.sym} 16380 -34690 0 0 {name=p15704 lab=_64536_/C }
C {devices/lab_pin.sym} 16460 -34690 0 1 {name=p15705 lab=_63694_/B }
C {sky130_stdcells/buf_2.sym} 16420 -34690 0 0 {name=X_58299_ }
C {devices/lab_pin.sym} 16360 -34590 0 0 {name=p15706 lab=_75104_/A }
C {devices/lab_pin.sym} 16360 -34550 0 0 {name=p15707 lab=_75104_/B }
C {devices/lab_pin.sym} 16360 -34510 0 0 {name=p15708 lab=_75104_/C }
C {devices/lab_pin.sym} 16480 -34550 0 1 {name=p15709 lab=_75105_/A }
C {sky130_stdcells/nand3_4.sym} 16420 -34550 0 0 {name=X_75104_ }
C {devices/lab_pin.sym} 16380 -34410 0 0 {name=p15710 lab=_48051_/Y }
C {devices/lab_pin.sym} 16460 -34410 0 1 {name=p15711 lab=_50341_/B }
C {sky130_stdcells/buf_2.sym} 16420 -34410 0 0 {name=X_48052_ }
C {devices/lab_pin.sym} 16340 -34330 0 0 {name=p15712 lab=_60263_/A }
C {devices/lab_pin.sym} 16340 -34290 0 0 {name=p15713 lab=_60331_/B }
C {devices/lab_pin.sym} 16340 -34250 0 0 {name=p15714 lab=_60324_/C }
C {devices/lab_pin.sym} 16340 -34210 0 0 {name=p15715 lab=_60344_/C }
C {devices/lab_pin.sym} 16340 -34180 0 0 {name=p15716 lab=_65296_/A }
C {devices/lab_pin.sym} 16500 -34250 0 1 {name=p15717 lab=_60330_/Y }
C {sky130_stdcells/a41oi_4.sym} 16420 -34250 0 0 {name=X_60330_ }
C {devices/lab_pin.sym} 16340 -34110 0 0 {name=p15718 lab=_72240_/X }
C {devices/lab_pin.sym} 16340 -34070 0 0 {name=p15719 lab=_85681_/Q }
C {devices/lab_pin.sym} 16340 -34030 0 0 {name=p15720 lab=_72241_/X }
C {devices/lab_pin.sym} 16500 -34070 0 1 {name=p15721 lab=_72316_/X }
C {sky130_stdcells/o21a_4.sym} 16420 -34070 0 0 {name=X_72316_ }
C {devices/lab_pin.sym} 16340 -33950 0 0 {name=p15722 lab=_85257_/Q }
C {devices/lab_pin.sym} 16340 -33910 0 0 {name=p15723 lab=_45222_/X }
C {devices/lab_pin.sym} 16340 -33870 0 0 {name=p15724 lab=_45263_/X }
C {devices/lab_pin.sym} 16500 -33910 0 1 {name=p15725 lab=_45264_/Y }
C {sky130_stdcells/o21ai_4.sym} 16420 -33910 0 0 {name=X_45264_ }
C {devices/lab_pin.sym} 16360 -33780 0 0 {name=p15726 lab=_81721_/D }
C {devices/lab_pin.sym} 16360 -33740 0 0 {name=p15727 lab=_76085_/B }
C {devices/lab_pin.sym} 16480 -33760 0 1 {name=p15728 lab=_76096_/A }
C {sky130_stdcells/or2_4.sym} 16420 -33760 0 0 {name=X_76084_ }
C {devices/lab_pin.sym} 16340 -33670 0 0 {name=p15729 lab=_42460_/X }
C {devices/lab_pin.sym} 16340 -33630 0 0 {name=p15730 lab=_42472_/X }
C {devices/lab_pin.sym} 16340 -33590 0 0 {name=p15731 lab=_40626_/X }
C {devices/lab_pin.sym} 16340 -33550 0 0 {name=p15732 lab=_42475_/Y }
C {devices/lab_pin.sym} 16340 -33510 0 0 {name=p15733 lab=_42463_/X }
C {devices/lab_pin.sym} 16500 -33590 0 1 {name=p15734 lab=_42476_/Y }
C {sky130_stdcells/o32ai_4.sym} 16420 -33590 0 0 {name=X_42476_ }
C {devices/lab_pin.sym} 16360 -33440 0 0 {name=p15735 lab=_42600_/A }
C {devices/lab_pin.sym} 16360 -33400 0 0 {name=p15736 lab=_73053_/B }
C {devices/lab_pin.sym} 16480 -33420 0 1 {name=p15737 lab=_73296_/Y }
C {sky130_stdcells/nor2_4.sym} 16420 -33420 0 0 {name=X_73296_ }
C {devices/lab_pin.sym} 16380 -33290 0 0 {name=p15738 lab=_47003_/A }
C {devices/lab_pin.sym} 16460 -33290 0 1 {name=p15739 lab=_47004_/A }
C {sky130_stdcells/buf_2.sym} 16420 -33290 0 0 {name=X_47003_ }
C {devices/lab_pin.sym} 16340 -33190 0 0 {name=p15740 lab=_44208_/X }
C {devices/lab_pin.sym} 16340 -33150 0 0 {name=p15741 lab=_44211_/Y }
C {devices/lab_pin.sym} 16340 -33110 0 0 {name=p15742 lab=_44214_/X }
C {devices/lab_pin.sym} 16500 -33150 0 1 {name=p15743 lab=_44215_/X }
C {sky130_stdcells/o21a_4.sym} 16420 -33150 0 0 {name=X_44215_ }
C {devices/lab_pin.sym} 16340 -33030 0 0 {name=p15744 lab=_75031_/Y }
C {devices/lab_pin.sym} 16340 -32990 0 0 {name=p15745 lab=_75023_/B }
C {devices/lab_pin.sym} 16340 -32950 0 0 {name=p15746 lab=_75049_/A }
C {devices/lab_pin.sym} 16500 -32990 0 1 {name=p15747 lab=_75035_/Y }
C {sky130_stdcells/o21ai_4.sym} 16420 -32990 0 0 {name=X_75035_ }
C {devices/lab_pin.sym} 16360 -32860 0 0 {name=p15748 lab=_79912_/A }
C {devices/lab_pin.sym} 16360 -32820 0 0 {name=p15749 lab=_79911_/Y }
C {devices/lab_pin.sym} 16480 -32840 0 1 {name=p15750 lab=_79912_/Y }
C {sky130_stdcells/nor2_4.sym} 16420 -32840 0 0 {name=X_79912_ }
C {devices/lab_pin.sym} 16360 -32720 0 0 {name=p15751 lab=_41427_/A }
C {devices/lab_pin.sym} 16360 -32680 0 0 {name=p15752 lab=_41435_/B }
C {devices/lab_pin.sym} 16480 -32700 0 1 {name=p15753 lab=_41427_/X }
C {sky130_stdcells/or2_4.sym} 16420 -32700 0 0 {name=X_41427_ }
C {devices/lab_pin.sym} 16360 -32580 0 0 {name=p15754 lab=_72247_/A }
C {devices/lab_pin.sym} 16360 -32540 0 0 {name=p15755 lab=_72332_/B }
C {devices/lab_pin.sym} 16480 -32560 0 1 {name=p15756 lab=_72247_/Y }
C {sky130_stdcells/nor2_4.sym} 16420 -32560 0 0 {name=X_72247_ }
C {devices/lab_pin.sym} 16340 -32470 0 0 {name=p15757 lab=_60249_/X }
C {devices/lab_pin.sym} 16340 -32430 0 0 {name=p15758 lab=_60252_/X }
C {devices/lab_pin.sym} 16340 -32390 0 0 {name=p15759 lab=_60256_/X }
C {devices/lab_pin.sym} 16340 -32350 0 0 {name=p15760 lab=_60259_/Y }
C {devices/lab_pin.sym} 16340 -32320 0 0 {name=p15761 lab=_60260_/Y }
C {devices/lab_pin.sym} 16500 -32390 0 1 {name=p15762 lab=_60261_/Y }
C {sky130_stdcells/a41oi_4.sym} 16420 -32390 0 0 {name=X_60261_ }
C {devices/lab_pin.sym} 16340 -32250 0 0 {name=p15763 lab=_55817_/B }
C {devices/lab_pin.sym} 16340 -32210 0 0 {name=p15764 lab=_45194_/X }
C {devices/lab_pin.sym} 16340 -32170 0 0 {name=p15765 lab=_45153_/X }
C {devices/lab_pin.sym} 16500 -32210 0 1 {name=p15766 lab=_45195_/X }
C {sky130_stdcells/o21a_4.sym} 16420 -32210 0 0 {name=X_45195_ }
C {devices/lab_pin.sym} 16380 -32070 0 0 {name=p15767 lab=clkbuf_7_57_0_CLK/A }
C {devices/lab_pin.sym} 16460 -32070 0 1 {name=p15768 lab=clkbuf_7_56_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 16420 -32070 0 0 {name=Xclkbuf_7_56_0_CLK }
C {devices/lab_pin.sym} 16360 -31980 0 0 {name=p15769 lab=_61957_/A }
C {devices/lab_pin.sym} 16360 -31940 0 0 {name=p15770 lab=_62000_/B }
C {devices/lab_pin.sym} 16360 -31900 0 0 {name=p15771 lab=_62000_/C }
C {devices/lab_pin.sym} 16360 -31860 0 0 {name=p15772 lab=_62000_/D }
C {devices/lab_pin.sym} 16480 -31920 0 1 {name=p15773 lab=_62000_/Y }
C {sky130_stdcells/nand4_4.sym} 16420 -31920 0 0 {name=X_62000_ }
C {devices/lab_pin.sym} 16380 -31770 0 0 {name=p15774 lab=clkbuf_7_98_0_CLK/X }
C {devices/lab_pin.sym} 16460 -31770 0 1 {name=p15775 lab=clkbuf_9_393_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 16420 -31770 0 0 {name=Xclkbuf_8_196_0_CLK }
C {devices/lab_pin.sym} 16380 -31650 0 0 {name=p15776 lab=_44146_/A }
C {devices/lab_pin.sym} 16460 -31650 0 1 {name=p15777 lab=_44147_/A }
C {sky130_stdcells/buf_2.sym} 16420 -31650 0 0 {name=X_44146_ }
C {devices/lab_pin.sym} 16360 -31540 0 0 {name=p15778 lab=_79836_/X }
C {devices/lab_pin.sym} 16360 -31500 0 0 {name=p15779 lab=_79838_/B }
C {devices/lab_pin.sym} 16480 -31520 0 1 {name=p15780 lab=_79843_/Y }
C {sky130_stdcells/nand2_4.sym} 16420 -31520 0 0 {name=X_79843_ }
C {devices/lab_pin.sym} 16380 -31390 0 0 {name=p15781 lab=clkbuf_9_95_0_CLK/X }
C {devices/lab_pin.sym} 16460 -31390 0 1 {name=p15782 lab=_81070_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 16420 -31390 0 0 {name=Xclkbuf_10_191_0_CLK }
C {devices/lab_pin.sym} 16380 -31270 0 0 {name=p15783 lab=_40878_/A }
C {devices/lab_pin.sym} 16460 -31270 0 1 {name=p15784 lab=_41358_/X }
C {sky130_stdcells/buf_2.sym} 16420 -31270 0 0 {name=X_41358_ }
C {devices/lab_pin.sym} 16340 -31190 0 0 {name=p15785 lab=_60263_/A }
C {devices/lab_pin.sym} 16340 -31150 0 0 {name=p15786 lab=_60344_/A }
C {devices/lab_pin.sym} 16340 -31110 0 0 {name=p15787 lab=_60324_/A }
C {devices/lab_pin.sym} 16340 -31070 0 0 {name=p15788 lab=_60268_/A }
C {devices/lab_pin.sym} 16340 -31040 0 0 {name=p15789 lab=_59980_/X }
C {devices/lab_pin.sym} 16500 -31110 0 1 {name=p15790 lab=_60192_/Y }
C {sky130_stdcells/a41oi_4.sym} 16420 -31110 0 0 {name=X_60192_ }
C {devices/lab_pin.sym} 16340 -30980 0 0 {name=p15791 lab=_72165_/Y }
C {devices/lab_pin.sym} 16340 -30940 0 0 {name=p15792 lab=_72152_/X }
C {devices/lab_pin.sym} 16340 -30900 0 0 {name=p15793 lab=_72171_/X }
C {devices/lab_pin.sym} 16340 -30860 0 0 {name=p15794 lab=_72177_/X }
C {devices/lab_pin.sym} 16500 -30920 0 1 {name=p15795 lab=_83277_/D }
C {sky130_stdcells/a22oi_4.sym} 16420 -30920 0 0 {name=X_72178_ }
C {devices/lab_pin.sym} 16360 -30790 0 0 {name=p15796 lab=_71129_/A }
C {devices/lab_pin.sym} 16360 -30750 0 0 {name=p15797 lab=_71230_/B }
C {devices/lab_pin.sym} 16360 -30710 0 0 {name=p15798 lab=_70914_/D }
C {devices/lab_pin.sym} 16480 -30750 0 1 {name=p15799 lab=_71129_/Y }
C {sky130_stdcells/nand3_4.sym} 16420 -30750 0 0 {name=X_71129_ }
C {devices/lab_pin.sym} 16380 -30610 0 0 {name=p15800 lab=_83618_/Q }
C {devices/lab_pin.sym} 16460 -30610 0 1 {name=p15801 lab=_53819_/B }
C {sky130_stdcells/inv_2.sym} 16420 -30610 0 0 {name=X_48954_ }
C {devices/lab_pin.sym} 16380 -30490 0 0 {name=p15802 lab=_55761_/A }
C {devices/lab_pin.sym} 16460 -30490 0 1 {name=p15803 lab=_44077_/X }
C {sky130_stdcells/buf_2.sym} 16420 -30490 0 0 {name=X_44077_ }
C {devices/lab_pin.sym} 16360 -30380 0 0 {name=p15804 lab=_84223_/Q }
C {devices/lab_pin.sym} 16360 -30340 0 0 {name=p15805 lab=_72236_/A }
C {devices/lab_pin.sym} 16480 -30360 0 1 {name=p15806 lab=_79774_/X }
C {sky130_stdcells/xor2_4.sym} 16420 -30360 0 0 {name=X_79774_ }
C {devices/lab_pin.sym} 16340 -30260 0 0 {name=p15807 lab=_41288_/X }
C {devices/lab_pin.sym} 16340 -30220 0 0 {name=p15808 lab=_41283_/X }
C {devices/lab_pin.sym} 16340 -30180 0 0 {name=p15809 lab=_67338_/B }
C {devices/lab_pin.sym} 16340 -30140 0 0 {name=p15810 lab=_41284_/X }
C {devices/lab_pin.sym} 16500 -30200 0 1 {name=p15811 lab=_88243_/D }
C {sky130_stdcells/a2bb2o_4.sym} 16420 -30200 0 0 {name=X_41289_ }
C {devices/lab_pin.sym} 16360 -30060 0 0 {name=p15812 lab=_76986_/A }
C {devices/lab_pin.sym} 16360 -30020 0 0 {name=p15813 lab=_62442_/C }
C {devices/lab_pin.sym} 16480 -30040 0 1 {name=p15814 lab=_76986_/X }
C {sky130_stdcells/xor2_4.sym} 16420 -30040 0 0 {name=X_76986_ }
C {devices/lab_pin.sym} 16380 -29910 0 0 {name=p15815 lab=_47972_/A }
C {devices/lab_pin.sym} 16460 -29910 0 1 {name=p15816 lab=_47963_/B }
C {sky130_stdcells/buf_2.sym} 16420 -29910 0 0 {name=X_47905_ }
C {devices/lab_pin.sym} 16340 -29830 0 0 {name=p15817 lab=_42439_/X }
C {devices/lab_pin.sym} 16340 -29790 0 0 {name=p15818 lab=_43017_/X }
C {devices/lab_pin.sym} 16340 -29750 0 0 {name=p15819 lab=_40581_/X }
C {devices/lab_pin.sym} 16340 -29710 0 0 {name=p15820 lab=_73599_/A }
C {devices/lab_pin.sym} 16340 -29670 0 0 {name=p15821 lab=_43025_/X }
C {devices/lab_pin.sym} 16500 -29750 0 1 {name=p15822 lab=_43029_/A }
C {sky130_stdcells/o32ai_4.sym} 16420 -29750 0 0 {name=X_43028_ }
C {devices/lab_pin.sym} 16360 -29600 0 0 {name=p15823 lab=_78725_/A }
C {devices/lab_pin.sym} 16360 -29560 0 0 {name=p15824 lab=_78725_/B }
C {devices/lab_pin.sym} 16480 -29580 0 1 {name=p15825 lab=_78725_/X }
C {sky130_stdcells/and2_4.sym} 16420 -29580 0 0 {name=X_78725_ }
C {devices/lab_pin.sym} 16360 -29480 0 0 {name=p15826 lab=_64364_/B }
C {devices/lab_pin.sym} 16360 -29440 0 0 {name=p15827 lab=_64029_/B }
C {devices/lab_pin.sym} 16360 -29400 0 0 {name=p15828 lab=_63951_/C }
C {devices/lab_pin.sym} 16360 -29360 0 0 {name=p15829 lab=_64015_/D }
C {devices/lab_pin.sym} 16480 -29420 0 1 {name=p15830 lab=_63951_/Y }
C {sky130_stdcells/nand4_4.sym} 16420 -29420 0 0 {name=X_63951_ }
C {devices/lab_pin.sym} 16360 -29280 0 0 {name=p15831 lab=_75933_/Y }
C {devices/lab_pin.sym} 16360 -29240 0 0 {name=p15832 lab=_75936_/Y }
C {devices/lab_pin.sym} 16480 -29260 0 1 {name=p15833 lab=_75939_/B }
C {sky130_stdcells/xnor2_4.sym} 16420 -29260 0 0 {name=X_75937_ }
C {devices/lab_pin.sym} 16360 -29150 0 0 {name=p15834 lab=_48885_/A }
C {devices/lab_pin.sym} 16360 -29110 0 0 {name=p15835 lab=_48894_/B }
C {devices/lab_pin.sym} 16360 -29070 0 0 {name=p15836 lab=_48894_/C }
C {devices/lab_pin.sym} 16480 -29110 0 1 {name=p15837 lab=_48885_/X }
C {sky130_stdcells/and3_4.sym} 16420 -29110 0 0 {name=X_48885_ }
C {devices/lab_pin.sym} 16380 -28970 0 0 {name=p15838 lab=_63306_/A }
C {devices/lab_pin.sym} 16460 -28970 0 1 {name=p15839 lab=_62930_/B }
C {sky130_stdcells/buf_2.sym} 16420 -28970 0 0 {name=X_62902_ }
C {devices/lab_pin.sym} 16340 -28870 0 0 {name=p15840 lab=_65908_/B }
C {devices/lab_pin.sym} 16340 -28830 0 0 {name=p15841 lab=_43756_/X }
C {devices/lab_pin.sym} 16340 -28790 0 0 {name=p15842 lab=_47835_/X }
C {devices/lab_pin.sym} 16500 -28830 0 1 {name=p15843 lab=_47836_/Y }
C {sky130_stdcells/o21ai_4.sym} 16420 -28830 0 0 {name=X_47836_ }
C {devices/lab_pin.sym} 16340 -28720 0 0 {name=p15844 lab=_87131_/Q }
C {devices/lab_pin.sym} 16340 -28680 0 0 {name=p15845 lab=_66593_/X }
C {devices/lab_pin.sym} 16340 -28640 0 0 {name=p15846 lab=_66594_/X }
C {devices/lab_pin.sym} 16340 -28600 0 0 {name=p15847 lab=_66669_/X }
C {devices/lab_pin.sym} 16500 -28660 0 1 {name=p15848 lab=_66670_/X }
C {sky130_stdcells/a211o_4.sym} 16420 -28660 0 0 {name=X_66670_ }
C {devices/lab_pin.sym} 16340 -28530 0 0 {name=p15849 lab=_78639_/Y }
C {devices/lab_pin.sym} 16340 -28490 0 0 {name=p15850 lab=_78642_/Y }
C {devices/lab_pin.sym} 16340 -28450 0 0 {name=p15851 lab=_78638_/B }
C {devices/lab_pin.sym} 16500 -28490 0 1 {name=p15852 lab=_78657_/B }
C {sky130_stdcells/o21ai_4.sym} 16420 -28490 0 0 {name=X_78656_ }
C {devices/lab_pin.sym} 16380 -28350 0 0 {name=p15853 lab=_60920_/A }
C {devices/lab_pin.sym} 16460 -28350 0 1 {name=p15854 lab=_63947_/C }
C {sky130_stdcells/buf_2.sym} 16420 -28350 0 0 {name=X_63882_ }
C {devices/lab_pin.sym} 16360 -28240 0 0 {name=p15855 lab=_75867_/Y }
C {devices/lab_pin.sym} 16360 -28200 0 0 {name=p15856 lab=_75852_/A }
C {devices/lab_pin.sym} 16480 -28220 0 1 {name=p15857 lab=_75868_/X }
C {sky130_stdcells/and2_4.sym} 16420 -28220 0 0 {name=X_75868_ }
C {devices/lab_pin.sym} 16360 -28110 0 0 {name=p15858 lab=_65621_/A }
C {devices/lab_pin.sym} 16360 -28070 0 0 {name=p15859 lab=_65559_/B }
C {devices/lab_pin.sym} 16360 -28030 0 0 {name=p15860 lab=_84189_/Q }
C {devices/lab_pin.sym} 16480 -28070 0 1 {name=p15861 lab=_65621_/X }
C {sky130_stdcells/and3_4.sym} 16420 -28070 0 0 {name=X_65621_ }
C {devices/lab_pin.sym} 16340 -27950 0 0 {name=p15862 lab=_77596_/B }
C {devices/lab_pin.sym} 16340 -27910 0 0 {name=p15863 lab=_77590_/A }
C {devices/lab_pin.sym} 16340 -27870 0 0 {name=p15864 lab=_77590_/B }
C {devices/lab_pin.sym} 16500 -27910 0 1 {name=p15865 lab=_77607_/Y }
C {sky130_stdcells/a21boi_4.sym} 16420 -27910 0 0 {name=X_77607_ }
C {devices/lab_pin.sym} 16360 -27790 0 0 {name=p15866 lab=_62869_/A }
C {devices/lab_pin.sym} 16360 -27750 0 0 {name=p15867 lab=_62812_/B }
C {devices/lab_pin.sym} 16360 -27710 0 0 {name=p15868 lab=_61969_/X }
C {devices/lab_pin.sym} 16480 -27750 0 1 {name=p15869 lab=_62833_/Y }
C {sky130_stdcells/nand3_4.sym} 16420 -27750 0 0 {name=X_62833_ }
C {devices/lab_pin.sym} 16380 -27610 0 0 {name=p15870 lab=_74818_/Y }
C {devices/lab_pin.sym} 16460 -27610 0 1 {name=p15871 lab=_80664_/D }
C {sky130_stdcells/inv_2.sym} 16420 -27610 0 0 {name=X_74819_ }
C {devices/lab_pin.sym} 16380 -27490 0 0 {name=p15872 lab=_81224_/Q }
C {devices/lab_pin.sym} 16460 -27490 0 1 {name=p15873 lab=_47768_/A }
C {sky130_stdcells/inv_2.sym} 16420 -27490 0 0 {name=X_47767_ }
C {devices/lab_pin.sym} 16380 -27370 0 0 {name=p15874 lab=_78586_/Y }
C {devices/lab_pin.sym} 16460 -27370 0 1 {name=p15875 lab=_78587_/Y }
C {sky130_stdcells/inv_2.sym} 16420 -27370 0 0 {name=X_78587_ }
C {devices/lab_pin.sym} 16380 -27250 0 0 {name=p15876 lab=_45197_/A }
C {devices/lab_pin.sym} 16460 -27250 0 1 {name=p15877 lab=_44979_/X }
C {sky130_stdcells/buf_2.sym} 16420 -27250 0 0 {name=X_44979_ }
C {devices/lab_pin.sym} 16340 -27150 0 0 {name=p15878 lab=_75787_/A }
C {devices/lab_pin.sym} 16340 -27110 0 0 {name=p15879 lab=_75786_/X }
C {devices/lab_pin.sym} 16340 -27070 0 0 {name=p15880 lab=_75798_/X }
C {devices/lab_pin.sym} 16500 -27110 0 1 {name=p15881 lab=_75800_/B }
C {sky130_stdcells/a21oi_4.sym} 16420 -27110 0 0 {name=X_75799_ }
C {devices/lab_pin.sym} 16360 -27000 0 0 {name=p15882 lab=_49500_/A }
C {devices/lab_pin.sym} 16360 -26960 0 0 {name=p15883 lab=_49516_/B }
C {devices/lab_pin.sym} 16360 -26920 0 0 {name=p15884 lab=_49493_/X }
C {devices/lab_pin.sym} 16360 -26880 0 0 {name=p15885 lab=_52720_/D }
C {devices/lab_pin.sym} 16480 -26940 0 1 {name=p15886 lab=_49506_/X }
C {sky130_stdcells/and4_4.sym} 16420 -26940 0 0 {name=X_49506_ }
C {devices/lab_pin.sym} 16340 -26820 0 0 {name=p15887 lab=_68319_/X }
C {devices/lab_pin.sym} 16340 -26780 0 0 {name=p15888 lab=_68077_/Y }
C {devices/lab_pin.sym} 16340 -26740 0 0 {name=p15889 lab=_68326_/X }
C {devices/lab_pin.sym} 16340 -26700 0 0 {name=p15890 lab=_68339_/Y }
C {devices/lab_pin.sym} 16500 -26760 0 1 {name=p15891 lab=_68340_/X }
C {sky130_stdcells/a211o_4.sym} 16420 -26760 0 0 {name=X_68340_ }
C {devices/lab_pin.sym} 16380 -26610 0 0 {name=p15892 lab=clkbuf_7_67_0_CLK/X }
C {devices/lab_pin.sym} 16460 -26610 0 1 {name=p15893 lab=clkbuf_9_269_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 16420 -26610 0 0 {name=Xclkbuf_8_134_0_CLK }
C {devices/lab_pin.sym} 16340 -26510 0 0 {name=p15894 lab=_46713_/Y }
C {devices/lab_pin.sym} 16340 -26470 0 0 {name=p15895 lab=_46704_/X }
C {devices/lab_pin.sym} 16340 -26430 0 0 {name=p15896 lab=_46717_/X }
C {devices/lab_pin.sym} 16500 -26470 0 1 {name=p15897 lab=_46718_/Y }
C {sky130_stdcells/a21oi_4.sym} 16420 -26470 0 0 {name=X_46718_ }
C {devices/lab_pin.sym} 16340 -26360 0 0 {name=p15898 lab=_65503_/X }
C {devices/lab_pin.sym} 16340 -26320 0 0 {name=p15899 lab=_85593_/Q }
C {devices/lab_pin.sym} 16340 -26280 0 0 {name=p15900 lab=_65504_/X }
C {devices/lab_pin.sym} 16340 -26240 0 0 {name=p15901 lab=_65551_/X }
C {devices/lab_pin.sym} 16500 -26300 0 1 {name=p15902 lab=_65552_/X }
C {sky130_stdcells/a211o_4.sym} 16420 -26300 0 0 {name=X_65552_ }
C {devices/lab_pin.sym} 16360 -26160 0 0 {name=p15903 lab=_77537_/Y }
C {devices/lab_pin.sym} 16360 -26120 0 0 {name=p15904 lab=_77538_/B }
C {devices/lab_pin.sym} 16480 -26140 0 1 {name=p15905 lab=_77539_/A }
C {sky130_stdcells/nand2_4.sym} 16420 -26140 0 0 {name=X_77538_ }
C {devices/lab_pin.sym} 16360 -26040 0 0 {name=p15906 lab=_62731_/A }
C {devices/lab_pin.sym} 16360 -26000 0 0 {name=p15907 lab=_59390_/Y }
C {devices/lab_pin.sym} 16360 -25960 0 0 {name=p15908 lab=_62744_/X }
C {devices/lab_pin.sym} 16360 -25920 0 0 {name=p15909 lab=_62717_/X }
C {devices/lab_pin.sym} 16480 -25980 0 1 {name=p15910 lab=_62764_/X }
C {sky130_stdcells/and4_4.sym} 16420 -25980 0 0 {name=X_62764_ }
C {devices/lab_pin.sym} 16380 -25830 0 0 {name=p15911 lab=_47745_/A }
C {devices/lab_pin.sym} 16460 -25830 0 1 {name=p15912 lab=_47698_/X }
C {sky130_stdcells/buf_2.sym} 16420 -25830 0 0 {name=X_47698_ }
C {devices/lab_pin.sym} 16360 -25730 0 0 {name=p15913 lab=_61232_/X }
C {devices/lab_pin.sym} 16360 -25690 0 0 {name=p15914 lab=_61636_/B }
C {devices/lab_pin.sym} 16360 -25650 0 0 {name=p15915 lab=_61207_/X }
C {devices/lab_pin.sym} 16480 -25690 0 1 {name=p15916 lab=_64503_/Y }
C {sky130_stdcells/nand3_4.sym} 16420 -25690 0 0 {name=X_64503_ }
C {devices/lab_pin.sym} 16340 -25570 0 0 {name=p15917 lab=_49432_/Y }
C {devices/lab_pin.sym} 16340 -25530 0 0 {name=p15918 lab=_49434_/X }
C {devices/lab_pin.sym} 16340 -25490 0 0 {name=p15919 lab=_49436_/X }
C {devices/lab_pin.sym} 16500 -25530 0 1 {name=p15920 lab=_49437_/Y }
C {sky130_stdcells/a21oi_4.sym} 16420 -25530 0 0 {name=X_49437_ }
C {devices/lab_pin.sym} 16360 -25420 0 0 {name=p15921 lab=_61715_/A }
C {devices/lab_pin.sym} 16360 -25380 0 0 {name=p15922 lab=_61715_/B }
C {devices/lab_pin.sym} 16360 -25340 0 0 {name=p15923 lab=_61710_/Y }
C {devices/lab_pin.sym} 16360 -25300 0 0 {name=p15924 lab=_61714_/Y }
C {devices/lab_pin.sym} 16480 -25360 0 1 {name=p15925 lab=_61715_/Y }
C {sky130_stdcells/nand4_4.sym} 16420 -25360 0 0 {name=X_61715_ }
C {devices/lab_pin.sym} 16340 -25230 0 0 {name=p15926 lab=_82644_/D }
C {devices/lab_pin.sym} 16340 -25190 0 0 {name=p15927 lab=_68259_/X }
C {devices/lab_pin.sym} 16340 -25150 0 0 {name=p15928 lab=_68270_/X }
C {devices/lab_pin.sym} 16500 -25190 0 1 {name=p15929 lab=_83996_/D }
C {sky130_stdcells/a21bo_4.sym} 16420 -25190 0 0 {name=X_68271_ }
C {devices/lab_pin.sym} 16380 -25050 0 0 {name=p15930 lab=_83685_/Q }
C {devices/lab_pin.sym} 16460 -25050 0 1 {name=p15931 lab=_46650_/A }
C {sky130_stdcells/inv_2.sym} 16420 -25050 0 0 {name=X_46649_ }
C {devices/lab_pin.sym} 16380 -24930 0 0 {name=p15932 lab=_64665_/A }
C {devices/lab_pin.sym} 16460 -24930 0 1 {name=p15933 lab=_65484_/A }
C {sky130_stdcells/buf_2.sym} 16420 -24930 0 0 {name=X_65483_ }
C {devices/lab_pin.sym} 16340 -24830 0 0 {name=p15934 lab=_77455_/Y }
C {devices/lab_pin.sym} 16340 -24790 0 0 {name=p15935 lab=_77467_/Y }
C {devices/lab_pin.sym} 16340 -24750 0 0 {name=p15936 lab=_77468_/Y }
C {devices/lab_pin.sym} 16500 -24790 0 1 {name=p15937 lab=_77478_/A }
C {sky130_stdcells/o21a_4.sym} 16420 -24790 0 0 {name=X_77469_ }
C {devices/lab_pin.sym} 16360 -24680 0 0 {name=p15938 lab=_62669_/A }
C {devices/lab_pin.sym} 16360 -24640 0 0 {name=p15939 lab=_63044_/A }
C {devices/lab_pin.sym} 16360 -24600 0 0 {name=p15940 lab=_62704_/C }
C {devices/lab_pin.sym} 16360 -24560 0 0 {name=p15941 lab=_62669_/D }
C {devices/lab_pin.sym} 16480 -24620 0 1 {name=p15942 lab=_62695_/X }
C {sky130_stdcells/and4_4.sym} 16420 -24620 0 0 {name=X_62695_ }
C {devices/lab_pin.sym} 16380 -24470 0 0 {name=p15943 lab=_67222_/A }
C {devices/lab_pin.sym} 16460 -24470 0 1 {name=p15944 lab=_67248_/A }
C {sky130_stdcells/buf_2.sym} 16420 -24470 0 0 {name=X_67222_ }
C {devices/lab_pin.sym} 16360 -24360 0 0 {name=p15945 lab=_79205_/Y }
C {devices/lab_pin.sym} 16360 -24320 0 0 {name=p15946 lab=_79208_/B }
C {devices/lab_pin.sym} 16480 -24340 0 1 {name=p15947 lab=_79208_/Y }
C {sky130_stdcells/nand2_4.sym} 16420 -24340 0 0 {name=X_79208_ }
C {devices/lab_pin.sym} 16380 -24210 0 0 {name=p15948 lab=clkbuf_9_251_0_CLK/A }
C {devices/lab_pin.sym} 16460 -24210 0 1 {name=p15949 lab=clkbuf_9_250_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 16420 -24210 0 0 {name=Xclkbuf_9_250_0_CLK }
C {devices/lab_pin.sym} 16360 -24110 0 0 {name=p15950 lab=_64494_/A }
C {devices/lab_pin.sym} 16360 -24070 0 0 {name=p15951 lab=_64434_/B }
C {devices/lab_pin.sym} 16360 -24030 0 0 {name=p15952 lab=_64391_/X }
C {devices/lab_pin.sym} 16480 -24070 0 1 {name=p15953 lab=_64434_/X }
C {sky130_stdcells/and3_4.sym} 16420 -24070 0 0 {name=X_64434_ }
C {devices/lab_pin.sym} 16380 -23930 0 0 {name=p15954 lab=_49504_/A }
C {devices/lab_pin.sym} 16460 -23930 0 1 {name=p15955 lab=_49451_/A }
C {sky130_stdcells/buf_2.sym} 16420 -23930 0 0 {name=X_49368_ }
C {devices/lab_pin.sym} 16360 -23830 0 0 {name=p15956 lab=_61634_/A }
C {devices/lab_pin.sym} 16360 -23790 0 0 {name=p15957 lab=_61634_/B }
C {devices/lab_pin.sym} 16360 -23750 0 0 {name=p15958 lab=_79131_/B }
C {devices/lab_pin.sym} 16480 -23790 0 1 {name=p15959 lab=_61646_/Y }
C {sky130_stdcells/nor3_4.sym} 16420 -23790 0 0 {name=X_61646_ }
C {devices/lab_pin.sym} 16360 -23660 0 0 {name=p15960 lab=_80480_/A }
C {devices/lab_pin.sym} 16360 -23620 0 0 {name=p15961 lab=_80480_/B }
C {devices/lab_pin.sym} 16480 -23640 0 1 {name=p15962 lab=_82259_/D }
C {sky130_stdcells/xnor2_4.sym} 16420 -23640 0 0 {name=X_80480_ }
C {devices/lab_pin.sym} 16380 -23510 0 0 {name=p15963 lab=clkbuf_7_74_0_CLK/X }
C {devices/lab_pin.sym} 16460 -23510 0 1 {name=p15964 lab=clkbuf_9_299_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 16420 -23510 0 0 {name=Xclkbuf_8_149_0_CLK }
C {devices/lab_pin.sym} 16360 -23400 0 0 {name=p15965 lab=_48319_/A }
C {devices/lab_pin.sym} 16360 -23360 0 0 {name=p15966 lab=_50365_/B }
C {devices/lab_pin.sym} 16480 -23380 0 1 {name=p15967 lab=_48319_/Y }
C {sky130_stdcells/nand2_4.sym} 16420 -23380 0 0 {name=X_48319_ }
C {devices/lab_pin.sym} 16380 -23250 0 0 {name=p15968 lab=clkbuf_9_72_0_CLK/X }
C {devices/lab_pin.sym} 16460 -23250 0 1 {name=p15969 lab=_83188_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 16420 -23250 0 0 {name=Xclkbuf_10_144_0_CLK }
C {devices/lab_pin.sym} 16380 -23130 0 0 {name=p15970 lab=_66794_/A }
C {devices/lab_pin.sym} 16460 -23130 0 1 {name=p15971 lab=_67153_/X }
C {sky130_stdcells/buf_2.sym} 16420 -23130 0 0 {name=X_67153_ }
C {devices/lab_pin.sym} 16360 -23020 0 0 {name=p15972 lab=_79139_/A }
C {devices/lab_pin.sym} 16360 -22980 0 0 {name=p15973 lab=_84471_/Q }
C {devices/lab_pin.sym} 16480 -23000 0 1 {name=p15974 lab=_79139_/X }
C {sky130_stdcells/xor2_4.sym} 16420 -23000 0 0 {name=X_79139_ }
C {devices/lab_pin.sym} 16380 -22870 0 0 {name=p15975 lab=_64306_/A }
C {devices/lab_pin.sym} 16460 -22870 0 1 {name=p15976 lab=_64379_/B }
C {sky130_stdcells/buf_2.sym} 16420 -22870 0 0 {name=X_64365_ }
C {devices/lab_pin.sym} 16380 -22750 0 0 {name=p15977 lab=_49002_/A }
C {devices/lab_pin.sym} 16460 -22750 0 1 {name=p15978 lab=_49415_/A }
C {sky130_stdcells/buf_2.sym} 16420 -22750 0 0 {name=X_49299_ }
C {devices/lab_pin.sym} 16360 -22650 0 0 {name=p15979 lab=_61546_/A }
C {devices/lab_pin.sym} 16360 -22610 0 0 {name=p15980 lab=_61546_/B }
C {devices/lab_pin.sym} 16360 -22570 0 0 {name=p15981 lab=_61577_/C }
C {devices/lab_pin.sym} 16480 -22610 0 1 {name=p15982 lab=_61577_/Y }
C {sky130_stdcells/nor3_4.sym} 16420 -22610 0 0 {name=X_61577_ }
C {devices/lab_pin.sym} 16380 -22470 0 0 {name=p15983 lab=clkbuf_9_387_0_CLK/X }
C {devices/lab_pin.sym} 16460 -22470 0 1 {name=p15984 lab=_82518_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 16420 -22470 0 0 {name=Xclkbuf_10_774_0_CLK }
C {devices/lab_pin.sym} 16380 -22350 0 0 {name=p15985 lab=_66104_/A }
C {devices/lab_pin.sym} 16460 -22350 0 1 {name=p15986 lab=_66135_/B }
C {sky130_stdcells/buf_2.sym} 16420 -22350 0 0 {name=X_66104_ }
C {devices/lab_pin.sym} 16360 -22250 0 0 {name=p15987 lab=_51330_/A }
C {devices/lab_pin.sym} 16360 -22210 0 0 {name=p15988 lab=_51266_/B }
C {devices/lab_pin.sym} 16360 -22170 0 0 {name=p15989 lab=_51330_/C }
C {devices/lab_pin.sym} 16480 -22210 0 1 {name=p15990 lab=_51330_/X }
C {sky130_stdcells/and3_4.sym} 16420 -22210 0 0 {name=X_51330_ }
C {devices/lab_pin.sym} 16360 -22100 0 0 {name=p15991 lab=_63316_/A }
C {devices/lab_pin.sym} 16360 -22060 0 0 {name=p15992 lab=_63316_/B }
C {devices/lab_pin.sym} 16360 -22020 0 0 {name=p15993 lab=_60588_/X }
C {devices/lab_pin.sym} 16360 -21980 0 0 {name=p15994 lab=_63344_/D }
C {devices/lab_pin.sym} 16480 -22040 0 1 {name=p15995 lab=_63316_/X }
C {sky130_stdcells/or4_4.sym} 16420 -22040 0 0 {name=X_63316_ }
C {devices/lab_pin.sym} 16330 -21890 0 0 {name=p15996 lab=_84231_/CLK }
C {devices/lab_pin.sym} 16330 -21870 0 0 {name=p15997 lab=_84142_/Q }
C {devices/lab_pin.sym} 16510 -21890 0 1 {name=p15998 lab=_82150_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -21880 0 0 {name=X_82150_ }
C {devices/lab_pin.sym} 16380 -21750 0 0 {name=p15999 lab=_60528_/A }
C {devices/lab_pin.sym} 16460 -21750 0 1 {name=p16000 lab=_60529_/A }
C {sky130_stdcells/buf_2.sym} 16420 -21750 0 0 {name=X_60528_ }
C {devices/lab_pin.sym} 16340 -21660 0 0 {name=p16001 lab=_87422_/Q }
C {devices/lab_pin.sym} 16340 -21620 0 0 {name=p16002 lab=_67035_/X }
C {devices/lab_pin.sym} 16340 -21580 0 0 {name=p16003 lab=_66984_/X }
C {devices/lab_pin.sym} 16340 -21540 0 0 {name=p16004 lab=_67083_/X }
C {devices/lab_pin.sym} 16500 -21600 0 1 {name=p16005 lab=_67084_/X }
C {sky130_stdcells/a211o_4.sym} 16420 -21600 0 0 {name=X_67084_ }
C {devices/lab_pin.sym} 16360 -21470 0 0 {name=p16006 lab=_64287_/A }
C {devices/lab_pin.sym} 16360 -21430 0 0 {name=p16007 lab=_84850_/Q }
C {devices/lab_pin.sym} 16360 -21390 0 0 {name=p16008 lab=_64287_/C }
C {devices/lab_pin.sym} 16480 -21430 0 1 {name=p16009 lab=_64296_/Y }
C {sky130_stdcells/nand3_4.sym} 16420 -21430 0 0 {name=X_64296_ }
C {devices/lab_pin.sym} 16330 -21290 0 0 {name=p16010 lab=_80817_/CLK }
C {devices/lab_pin.sym} 16330 -21270 0 0 {name=p16011 lab=_79676_/X }
C {devices/lab_pin.sym} 16510 -21290 0 1 {name=p16012 lab=_75817_/A }
C {sky130_stdcells/dfxtp_4.sym} 16420 -21280 0 0 {name=X_81101_ }
C {devices/lab_pin.sym} 16380 -21150 0 0 {name=p16013 lab=clkbuf_8_132_0_CLK/X }
C {devices/lab_pin.sym} 16460 -21150 0 1 {name=p16014 lab=clkbuf_9_265_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 16420 -21150 0 0 {name=Xclkbuf_9_265_0_CLK }
C {devices/lab_pin.sym} 16360 -21040 0 0 {name=p16015 lab=_65992_/A }
C {devices/lab_pin.sym} 16360 -21000 0 0 {name=p16016 lab=_73780_/B }
C {devices/lab_pin.sym} 16480 -21020 0 1 {name=p16017 lab=_66035_/X }
C {sky130_stdcells/and2_4.sym} 16420 -21020 0 0 {name=X_66035_ }
C {devices/lab_pin.sym} 16360 -20900 0 0 {name=p16018 lab=_51280_/A }
C {devices/lab_pin.sym} 16360 -20860 0 0 {name=p16019 lab=_51261_/B }
C {devices/lab_pin.sym} 16480 -20880 0 1 {name=p16020 lab=_51261_/Y }
C {sky130_stdcells/nand2_4.sym} 16420 -20880 0 0 {name=X_51261_ }
C {devices/lab_pin.sym} 16380 -20750 0 0 {name=p16021 lab=_63247_/A }
C {devices/lab_pin.sym} 16460 -20750 0 1 {name=p16022 lab=_63281_/D }
C {sky130_stdcells/buf_2.sym} 16420 -20750 0 0 {name=X_63247_ }
C {devices/lab_pin.sym} 16330 -20630 0 0 {name=p16023 lab=_81160_/CLK }
C {devices/lab_pin.sym} 16330 -20610 0 0 {name=p16024 lab=_82081_/D }
C {devices/lab_pin.sym} 16510 -20630 0 1 {name=p16025 lab=_82081_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -20620 0 0 {name=X_82081_ }
C {devices/lab_pin.sym} 16360 -20520 0 0 {name=p16026 lab=_60421_/B }
C {devices/lab_pin.sym} 16360 -20480 0 0 {name=p16027 lab=_60459_/B }
C {devices/lab_pin.sym} 16360 -20440 0 0 {name=p16028 lab=_60606_/A }
C {devices/lab_pin.sym} 16360 -20400 0 0 {name=p16029 lab=_60458_/X }
C {devices/lab_pin.sym} 16480 -20460 0 1 {name=p16030 lab=_60460_/A }
C {sky130_stdcells/nand4_4.sym} 16420 -20460 0 0 {name=X_60459_ }
C {devices/lab_pin.sym} 16340 -20330 0 0 {name=p16031 lab=_85715_/Q }
C {devices/lab_pin.sym} 16340 -20290 0 0 {name=p16032 lab=_52984_/X }
C {devices/lab_pin.sym} 16340 -20250 0 0 {name=p16033 lab=_52999_/Y }
C {devices/lab_pin.sym} 16500 -20290 0 1 {name=p16034 lab=_53000_/Y }
C {sky130_stdcells/o21ai_4.sym} 16420 -20290 0 0 {name=X_53000_ }
C {devices/lab_pin.sym} 16380 -20150 0 0 {name=p16035 lab=clkbuf_9_79_0_CLK/X }
C {devices/lab_pin.sym} 16460 -20150 0 1 {name=p16036 lab=_81269_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 16420 -20150 0 0 {name=Xclkbuf_10_159_0_CLK }
C {devices/lab_pin.sym} 16380 -20030 0 0 {name=p16037 lab=_50212_/A }
C {devices/lab_pin.sym} 16460 -20030 0 1 {name=p16038 lab=_50595_/A }
C {sky130_stdcells/buf_2.sym} 16420 -20030 0 0 {name=X_50212_ }
C {devices/lab_pin.sym} 16330 -19910 0 0 {name=p16039 lab=_81928_/CLK }
C {devices/lab_pin.sym} 16330 -19890 0 0 {name=p16040 lab=_81032_/D }
C {devices/lab_pin.sym} 16510 -19910 0 1 {name=p16041 lab=_81032_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -19900 0 0 {name=X_81032_ }
C {devices/lab_pin.sym} 16360 -19800 0 0 {name=p16042 lab=_51191_/X }
C {devices/lab_pin.sym} 16360 -19760 0 0 {name=p16043 lab=_51192_/B }
C {devices/lab_pin.sym} 16360 -19720 0 0 {name=p16044 lab=_51192_/C }
C {devices/lab_pin.sym} 16360 -19680 0 0 {name=p16045 lab=_51192_/D }
C {devices/lab_pin.sym} 16480 -19740 0 1 {name=p16046 lab=_51192_/X }
C {sky130_stdcells/and4_4.sym} 16420 -19740 0 0 {name=X_51192_ }
C {devices/lab_pin.sym} 16380 -19590 0 0 {name=p16047 lab=_60607_/A }
C {devices/lab_pin.sym} 16460 -19590 0 1 {name=p16048 lab=_63192_/D }
C {sky130_stdcells/buf_2.sym} 16420 -19590 0 0 {name=X_63178_ }
C {devices/lab_pin.sym} 16380 -19470 0 0 {name=p16049 lab=clkbuf_9_394_0_CLK/X }
C {devices/lab_pin.sym} 16460 -19470 0 1 {name=p16050 lab=_82152_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 16420 -19470 0 0 {name=Xclkbuf_10_789_0_CLK }
C {devices/lab_pin.sym} 16340 -19370 0 0 {name=p16051 lab=_50140_/Y }
C {devices/lab_pin.sym} 16340 -19330 0 0 {name=p16052 lab=_50141_/X }
C {devices/lab_pin.sym} 16340 -19290 0 0 {name=p16053 lab=_50142_/X }
C {devices/lab_pin.sym} 16500 -19330 0 1 {name=p16054 lab=_86256_/D }
C {sky130_stdcells/a21oi_4.sym} 16420 -19330 0 0 {name=X_50143_ }
C {devices/lab_pin.sym} 16380 -19190 0 0 {name=p16055 lab=_58287_/A }
C {devices/lab_pin.sym} 16460 -19190 0 1 {name=p16056 lab=_62129_/X }
C {sky130_stdcells/buf_2.sym} 16420 -19190 0 0 {name=X_62129_ }
C {devices/lab_pin.sym} 16330 -19070 0 0 {name=p16057 lab=_85558_/CLK }
C {devices/lab_pin.sym} 16330 -19050 0 0 {name=p16058 lab=_85840_/D }
C {devices/lab_pin.sym} 16510 -19070 0 1 {name=p16059 lab=_85840_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -19060 0 0 {name=X_85840_ }
C {devices/lab_pin.sym} 16340 -18960 0 0 {name=p16060 lab=_87896_/Q }
C {devices/lab_pin.sym} 16340 -18920 0 0 {name=p16061 lab=_67888_/X }
C {devices/lab_pin.sym} 16340 -18880 0 0 {name=p16062 lab=_67984_/X }
C {devices/lab_pin.sym} 16340 -18840 0 0 {name=p16063 lab=_67985_/X }
C {devices/lab_pin.sym} 16500 -18900 0 1 {name=p16064 lab=_67986_/X }
C {sky130_stdcells/a211o_4.sym} 16420 -18900 0 0 {name=X_67986_ }
C {devices/lab_pin.sym} 16360 -18760 0 0 {name=p16065 lab=_69092_/A }
C {devices/lab_pin.sym} 16360 -18720 0 0 {name=p16066 lab=_69725_/B }
C {devices/lab_pin.sym} 16480 -18740 0 1 {name=p16067 lab=_69725_/X }
C {sky130_stdcells/and2_4.sym} 16420 -18740 0 0 {name=X_69725_ }
C {devices/lab_pin.sym} 16340 -18630 0 0 {name=p16068 lab=_50072_/Y }
C {devices/lab_pin.sym} 16340 -18590 0 0 {name=p16069 lab=_50068_/X }
C {devices/lab_pin.sym} 16340 -18550 0 0 {name=p16070 lab=_50073_/X }
C {devices/lab_pin.sym} 16500 -18590 0 1 {name=p16071 lab=_86270_/D }
C {sky130_stdcells/a21oi_4.sym} 16420 -18590 0 0 {name=X_50074_ }
C {devices/lab_pin.sym} 16360 -18480 0 0 {name=p16072 lab=_54955_/A }
C {devices/lab_pin.sym} 16360 -18440 0 0 {name=p16073 lab=_54955_/B }
C {devices/lab_pin.sym} 16360 -18400 0 0 {name=p16074 lab=_46617_/A }
C {devices/lab_pin.sym} 16360 -18360 0 0 {name=p16075 lab=_53257_/D }
C {devices/lab_pin.sym} 16480 -18420 0 1 {name=p16076 lab=_54951_/X }
C {sky130_stdcells/and4_4.sym} 16420 -18420 0 0 {name=X_54951_ }
C {devices/lab_pin.sym} 16340 -18300 0 0 {name=p16077 lab=_87876_/Q }
C {devices/lab_pin.sym} 16340 -18260 0 0 {name=p16078 lab=_66935_/X }
C {devices/lab_pin.sym} 16340 -18220 0 0 {name=p16079 lab=_66911_/X }
C {devices/lab_pin.sym} 16340 -18180 0 0 {name=p16080 lab=_66936_/X }
C {devices/lab_pin.sym} 16500 -18240 0 1 {name=p16081 lab=_66937_/X }
C {sky130_stdcells/a211o_4.sym} 16420 -18240 0 0 {name=X_66937_ }
C {devices/lab_pin.sym} 16330 -18090 0 0 {name=p16082 lab=_85773_/CLK }
C {devices/lab_pin.sym} 16330 -18070 0 0 {name=p16083 lab=_52699_/Y }
C {devices/lab_pin.sym} 16510 -18090 0 1 {name=p16084 lab=_85771_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -18080 0 0 {name=X_85771_ }
C {devices/lab_pin.sym} 16330 -17950 0 0 {name=p16085 lab=_85128_/CLK }
C {devices/lab_pin.sym} 16330 -17930 0 0 {name=p16086 lab=_74693_/Y }
C {devices/lab_pin.sym} 16510 -17950 0 1 {name=p16087 lab=_82983_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -17940 0 0 {name=X_82983_ }
C {devices/lab_pin.sym} 16380 -17810 0 0 {name=p16088 lab=clkbuf_9_356_0_CLK/X }
C {devices/lab_pin.sym} 16460 -17810 0 1 {name=p16089 lab=_88245_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 16420 -17810 0 0 {name=Xclkbuf_10_712_0_CLK }
C {devices/lab_pin.sym} 16330 -17690 0 0 {name=p16090 lab=_87790_/CLK }
C {devices/lab_pin.sym} 16330 -17670 0 0 {name=p16091 lab=_87510_/D }
C {devices/lab_pin.sym} 16510 -17690 0 1 {name=p16092 lab=_87510_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -17680 0 0 {name=X_87510_ }
C {devices/lab_pin.sym} 16360 -17560 0 0 {name=p16093 lab=_53902_/A }
C {devices/lab_pin.sym} 16360 -17520 0 0 {name=p16094 lab=_53902_/B }
C {devices/lab_pin.sym} 16480 -17540 0 1 {name=p16095 lab=_53902_/Y }
C {sky130_stdcells/nand2_4.sym} 16420 -17540 0 0 {name=X_53902_ }
C {devices/lab_pin.sym} 16330 -17410 0 0 {name=p16096 lab=_83464_/CLK }
C {devices/lab_pin.sym} 16330 -17390 0 0 {name=p16097 lab=_84722_/D }
C {devices/lab_pin.sym} 16510 -17410 0 1 {name=p16098 lab=_84722_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -17400 0 0 {name=X_84722_ }
C {devices/lab_pin.sym} 16360 -17280 0 0 {name=p16099 lab=_57670_/A }
C {devices/lab_pin.sym} 16360 -17240 0 0 {name=p16100 lab=_57666_/B }
C {devices/lab_pin.sym} 16480 -17260 0 1 {name=p16101 lab=_57670_/Y }
C {sky130_stdcells/nor2_4.sym} 16420 -17260 0 0 {name=X_57670_ }
C {devices/lab_pin.sym} 16330 -17130 0 0 {name=p16102 lab=_81933_/CLK }
C {devices/lab_pin.sym} 16330 -17110 0 0 {name=p16103 lab=_81934_/D }
C {devices/lab_pin.sym} 16510 -17130 0 1 {name=p16104 lab=_77404_/A }
C {sky130_stdcells/dfxtp_4.sym} 16420 -17120 0 0 {name=X_81934_ }
C {devices/lab_pin.sym} 16340 -17010 0 0 {name=p16105 lab=_69650_/X }
C {devices/lab_pin.sym} 16340 -16970 0 0 {name=p16106 lab=_69653_/X }
C {devices/lab_pin.sym} 16340 -16930 0 0 {name=p16107 lab=_69655_/X }
C {devices/lab_pin.sym} 16500 -16970 0 1 {name=p16108 lab=_69656_/Y }
C {sky130_stdcells/a21oi_4.sym} 16420 -16970 0 0 {name=X_69656_ }
C {devices/lab_pin.sym} 16380 -16830 0 0 {name=p16109 lab=_54882_/A }
C {devices/lab_pin.sym} 16460 -16830 0 1 {name=p16110 lab=_54882_/X }
C {sky130_stdcells/buf_2.sym} 16420 -16830 0 0 {name=X_54882_ }
C {devices/lab_pin.sym} 16380 -16710 0 0 {name=p16111 lab=_66868_/A }
C {devices/lab_pin.sym} 16460 -16710 0 1 {name=p16112 lab=_66868_/X }
C {sky130_stdcells/buf_2.sym} 16420 -16710 0 0 {name=X_66868_ }
C {devices/lab_pin.sym} 16380 -16590 0 0 {name=p16113 lab=clkbuf_9_203_0_CLK/A }
C {devices/lab_pin.sym} 16460 -16590 0 1 {name=p16114 lab=clkbuf_9_203_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 16420 -16590 0 0 {name=Xclkbuf_9_203_0_CLK }
C {devices/lab_pin.sym} 16360 -16480 0 0 {name=p16115 lab=_55536_/A }
C {devices/lab_pin.sym} 16360 -16440 0 0 {name=p16116 lab=_55536_/C }
C {devices/lab_pin.sym} 16480 -16460 0 1 {name=p16117 lab=_56621_/X }
C {sky130_stdcells/and2_4.sym} 16420 -16460 0 0 {name=X_56621_ }
C {devices/lab_pin.sym} 16360 -16340 0 0 {name=p16118 lab=_68560_/A }
C {devices/lab_pin.sym} 16360 -16300 0 0 {name=p16119 lab=_68607_/B }
C {devices/lab_pin.sym} 16480 -16320 0 1 {name=p16120 lab=_68607_/X }
C {sky130_stdcells/and2_4.sym} 16420 -16320 0 0 {name=X_68607_ }
C {devices/lab_pin.sym} 16330 -16190 0 0 {name=p16121 lab=_87484_/CLK }
C {devices/lab_pin.sym} 16330 -16170 0 0 {name=p16122 lab=_87441_/D }
C {devices/lab_pin.sym} 16510 -16190 0 1 {name=p16123 lab=_87441_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -16180 0 0 {name=X_87441_ }
C {devices/lab_pin.sym} 16340 -16070 0 0 {name=p16124 lab=_85559_/Q }
C {devices/lab_pin.sym} 16340 -16030 0 0 {name=p16125 lab=_53816_/X }
C {devices/lab_pin.sym} 16340 -15990 0 0 {name=p16126 lab=_53832_/Y }
C {devices/lab_pin.sym} 16500 -16030 0 1 {name=p16127 lab=_53833_/Y }
C {sky130_stdcells/o21ai_4.sym} 16420 -16030 0 0 {name=X_53833_ }
C {devices/lab_pin.sym} 16360 -15900 0 0 {name=p16128 lab=_65702_/A }
C {devices/lab_pin.sym} 16360 -15860 0 0 {name=p16129 lab=_85863_/Q }
C {devices/lab_pin.sym} 16480 -15880 0 1 {name=p16130 lab=_65819_/X }
C {sky130_stdcells/and2_4.sym} 16420 -15880 0 0 {name=X_65819_ }
C {devices/lab_pin.sym} 16330 -15750 0 0 {name=p16131 lab=_84652_/CLK }
C {devices/lab_pin.sym} 16330 -15730 0 0 {name=p16132 lab=_60144_/Y }
C {devices/lab_pin.sym} 16510 -15750 0 1 {name=p16133 lab=_79936_/B }
C {sky130_stdcells/dfxtp_4.sym} 16420 -15740 0 0 {name=X_84653_ }
C {devices/lab_pin.sym} 16330 -15610 0 0 {name=p16134 lab=_84441_/CLK }
C {devices/lab_pin.sym} 16330 -15590 0 0 {name=p16135 lab=_78056_/X }
C {devices/lab_pin.sym} 16510 -15610 0 1 {name=p16136 lab=_81865_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -15600 0 0 {name=X_81865_ }
C {devices/lab_pin.sym} 16340 -15500 0 0 {name=p16137 lab=_44518_/A }
C {devices/lab_pin.sym} 16340 -15460 0 0 {name=p16138 lab=_69457_/X }
C {devices/lab_pin.sym} 16340 -15420 0 0 {name=p16139 lab=_69458_/X }
C {devices/lab_pin.sym} 16340 -15380 0 0 {name=p16140 lab=_69586_/X }
C {devices/lab_pin.sym} 16500 -15440 0 1 {name=p16141 lab=_69587_/X }
C {sky130_stdcells/a211o_4.sym} 16420 -15440 0 0 {name=X_69587_ }
C {devices/lab_pin.sym} 16340 -15320 0 0 {name=p16142 lab=_87370_/Q }
C {devices/lab_pin.sym} 16340 -15280 0 0 {name=p16143 lab=_66797_/X }
C {devices/lab_pin.sym} 16340 -15240 0 0 {name=p16144 lab=_66747_/X }
C {devices/lab_pin.sym} 16340 -15200 0 0 {name=p16145 lab=_66798_/X }
C {devices/lab_pin.sym} 16500 -15260 0 1 {name=p16146 lab=_66799_/X }
C {sky130_stdcells/a211o_4.sym} 16420 -15260 0 0 {name=X_66799_ }
C {devices/lab_pin.sym} 16360 -15120 0 0 {name=p16147 lab=_59326_/X }
C {devices/lab_pin.sym} 16360 -15080 0 0 {name=p16148 lab=_86341_/Q }
C {devices/lab_pin.sym} 16480 -15100 0 1 {name=p16149 lab=_59340_/Y }
C {sky130_stdcells/nor2_4.sym} 16420 -15100 0 0 {name=X_59340_ }
C {devices/lab_pin.sym} 16330 -14970 0 0 {name=p16150 lab=_86155_/CLK }
C {devices/lab_pin.sym} 16330 -14950 0 0 {name=p16151 lab=_83604_/D }
C {devices/lab_pin.sym} 16510 -14970 0 1 {name=p16152 lab=_49093_/A }
C {sky130_stdcells/dfxtp_4.sym} 16420 -14960 0 0 {name=X_83604_ }
C {devices/lab_pin.sym} 16340 -14870 0 0 {name=p16153 lab=_56549_/X }
C {devices/lab_pin.sym} 16340 -14830 0 0 {name=p16154 lab=_45882_/A }
C {devices/lab_pin.sym} 16340 -14790 0 0 {name=p16155 lab=_45898_/X }
C {devices/lab_pin.sym} 16340 -14750 0 0 {name=p16156 lab=_56550_/X }
C {devices/lab_pin.sym} 16340 -14720 0 0 {name=p16157 lab=_56551_/X }
C {devices/lab_pin.sym} 16500 -14790 0 1 {name=p16158 lab=_56552_/Y }
C {sky130_stdcells/a41oi_4.sym} 16420 -14790 0 0 {name=X_56552_ }
C {devices/lab_pin.sym} 16330 -14630 0 0 {name=p16159 lab=_80821_/CLK }
C {devices/lab_pin.sym} 16330 -14610 0 0 {name=p16160 lab=_80816_/D }
C {devices/lab_pin.sym} 16510 -14630 0 1 {name=p16161 lab=_75851_/B }
C {sky130_stdcells/dfxtp_4.sym} 16420 -14620 0 0 {name=X_80816_ }
C {devices/lab_pin.sym} 16340 -14520 0 0 {name=p16162 lab=_68516_/X }
C {devices/lab_pin.sym} 16340 -14480 0 0 {name=p16163 lab=_68525_/Y }
C {devices/lab_pin.sym} 16340 -14440 0 0 {name=p16164 lab=_68447_/X }
C {devices/lab_pin.sym} 16340 -14400 0 0 {name=p16165 lab=_68537_/Y }
C {devices/lab_pin.sym} 16500 -14460 0 1 {name=p16166 lab=_68538_/X }
C {sky130_stdcells/a211o_4.sym} 16420 -14460 0 0 {name=X_68538_ }
C {devices/lab_pin.sym} 16330 -14310 0 0 {name=p16167 lab=_86834_/CLK }
C {devices/lab_pin.sym} 16330 -14290 0 0 {name=p16168 lab=_43535_/X }
C {devices/lab_pin.sym} 16510 -14310 0 1 {name=p16169 lab=_87372_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -14300 0 0 {name=X_87372_ }
C {devices/lab_pin.sym} 16360 -14190 0 0 {name=p16170 lab=_48680_/A }
C {devices/lab_pin.sym} 16360 -14150 0 0 {name=p16171 lab=_53774_/B }
C {devices/lab_pin.sym} 16360 -14110 0 0 {name=p16172 lab=_53774_/C }
C {devices/lab_pin.sym} 16480 -14150 0 1 {name=p16173 lab=_53764_/X }
C {sky130_stdcells/and3_4.sym} 16420 -14150 0 0 {name=X_53764_ }
C {devices/lab_pin.sym} 16330 -14010 0 0 {name=p16174 lab=_84564_/CLK }
C {devices/lab_pin.sym} 16330 -13990 0 0 {name=p16175 lab=_60685_/Y }
C {devices/lab_pin.sym} 16510 -14010 0 1 {name=p16176 lab=_84584_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -14000 0 0 {name=X_84584_ }
C {devices/lab_pin.sym} 16360 -13880 0 0 {name=p16177 lab=_50971_/A }
C {devices/lab_pin.sym} 16360 -13840 0 0 {name=p16178 lab=_50976_/B }
C {devices/lab_pin.sym} 16480 -13860 0 1 {name=p16179 lab=_50976_/Y }
C {sky130_stdcells/nand2_4.sym} 16420 -13860 0 0 {name=X_50976_ }
C {devices/lab_pin.sym} 16330 -13730 0 0 {name=p16180 lab=_81668_/CLK }
C {devices/lab_pin.sym} 16330 -13710 0 0 {name=p16181 lab=_81796_/D }
C {devices/lab_pin.sym} 16510 -13730 0 1 {name=p16182 lab=_47501_/A }
C {sky130_stdcells/dfxtp_4.sym} 16420 -13720 0 0 {name=X_81796_ }
C {devices/lab_pin.sym} 16380 -13590 0 0 {name=p16183 lab=clkbuf_9_363_0_CLK/X }
C {devices/lab_pin.sym} 16460 -13590 0 1 {name=p16184 lab=_86989_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 16420 -13590 0 0 {name=Xclkbuf_10_727_0_CLK }
C {devices/lab_pin.sym} 16360 -13500 0 0 {name=p16185 lab=_55467_/X }
C {devices/lab_pin.sym} 16360 -13460 0 0 {name=p16186 lab=_55646_/A }
C {devices/lab_pin.sym} 16360 -13420 0 0 {name=p16187 lab=_55491_/X }
C {devices/lab_pin.sym} 16360 -13380 0 0 {name=p16188 lab=_55503_/D }
C {devices/lab_pin.sym} 16480 -13440 0 1 {name=p16189 lab=_55503_/Y }
C {sky130_stdcells/nand4_4.sym} 16420 -13440 0 0 {name=X_55503_ }
C {devices/lab_pin.sym} 16330 -13290 0 0 {name=p16190 lab=_86322_/CLK }
C {devices/lab_pin.sym} 16330 -13270 0 0 {name=p16191 lab=_86323_/D }
C {devices/lab_pin.sym} 16510 -13290 0 1 {name=p16192 lab=_86323_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -13280 0 0 {name=X_86323_ }
C {devices/lab_pin.sym} 16380 -13150 0 0 {name=p16193 lab=_52770_/A }
C {devices/lab_pin.sym} 16460 -13150 0 1 {name=p16194 lab=_52724_/B }
C {sky130_stdcells/buf_2.sym} 16420 -13150 0 0 {name=X_52715_ }
C {devices/lab_pin.sym} 16380 -13030 0 0 {name=p16195 lab=_59133_/A }
C {devices/lab_pin.sym} 16460 -13030 0 1 {name=p16196 lab=_59271_/X }
C {sky130_stdcells/buf_2.sym} 16420 -13030 0 0 {name=X_59271_ }
C {devices/lab_pin.sym} 16330 -12910 0 0 {name=p16197 lab=_86535_/CLK }
C {devices/lab_pin.sym} 16330 -12890 0 0 {name=p16198 lab=_83535_/D }
C {devices/lab_pin.sym} 16510 -12910 0 1 {name=p16199 lab=_48105_/A }
C {sky130_stdcells/dfxtp_4.sym} 16420 -12900 0 0 {name=X_83535_ }
C {devices/lab_pin.sym} 16380 -12770 0 0 {name=p16200 lab=_56538_/A }
C {devices/lab_pin.sym} 16460 -12770 0 1 {name=p16201 lab=_56483_/X }
C {sky130_stdcells/buf_2.sym} 16420 -12770 0 0 {name=X_56483_ }
C {devices/lab_pin.sym} 16330 -12650 0 0 {name=p16202 lab=_80835_/CLK }
C {devices/lab_pin.sym} 16330 -12630 0 0 {name=p16203 lab=_80747_/D }
C {devices/lab_pin.sym} 16510 -12650 0 1 {name=p16204 lab=_81123_/D }
C {sky130_stdcells/dfxtp_4.sym} 16420 -12640 0 0 {name=X_80747_ }
C {devices/lab_pin.sym} 16340 -12540 0 0 {name=p16205 lab=_73653_/A }
C {devices/lab_pin.sym} 16340 -12500 0 0 {name=p16206 lab=_68467_/X }
C {devices/lab_pin.sym} 16340 -12460 0 0 {name=p16207 lab=_68385_/X }
C {devices/lab_pin.sym} 16340 -12420 0 0 {name=p16208 lab=_68468_/Y }
C {devices/lab_pin.sym} 16500 -12480 0 1 {name=p16209 lab=_68469_/X }
C {sky130_stdcells/a211o_4.sym} 16420 -12480 0 0 {name=X_68469_ }
C {devices/lab_pin.sym} 16340 -12350 0 0 {name=p16210 lab=_85586_/Q }
C {devices/lab_pin.sym} 16340 -12310 0 0 {name=p16211 lab=_53610_/X }
C {devices/lab_pin.sym} 16340 -12270 0 0 {name=p16212 lab=_53694_/Y }
C {devices/lab_pin.sym} 16500 -12310 0 1 {name=p16213 lab=_53695_/Y }
C {sky130_stdcells/o21ai_4.sym} 16420 -12310 0 0 {name=X_53695_ }
C {devices/lab_pin.sym} 16380 -12170 0 0 {name=p16214 lab=clkbuf_9_219_0_CLK/A }
C {devices/lab_pin.sym} 16460 -12170 0 1 {name=p16215 lab=clkbuf_9_218_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 16420 -12170 0 0 {name=Xclkbuf_9_218_0_CLK }
C {devices/lab_pin.sym} 16360 -12080 0 0 {name=p16216 lab=_71136_/A }
C {devices/lab_pin.sym} 16360 -12040 0 0 {name=p16217 lab=_70500_/B }
C {devices/lab_pin.sym} 16360 -12000 0 0 {name=p16218 lab=_70758_/B }
C {devices/lab_pin.sym} 16360 -11960 0 0 {name=p16219 lab=_70500_/D }
C {devices/lab_pin.sym} 16480 -12020 0 1 {name=p16220 lab=_70500_/Y }
C {sky130_stdcells/nor4_4.sym} 16420 -12020 0 0 {name=X_70500_ }
C {devices/lab_pin.sym} 16360 -11880 0 0 {name=p16221 lab=_58221_/X }
C {devices/lab_pin.sym} 16360 -11840 0 0 {name=p16222 lab=_58238_/B }
C {devices/lab_pin.sym} 16480 -11860 0 1 {name=p16223 lab=_58222_/Y }
C {sky130_stdcells/nor2_4.sym} 16420 -11860 0 0 {name=X_58222_ }
C {devices/lab_pin.sym} 16360 -11760 0 0 {name=p16224 lab=_55415_/A }
C {devices/lab_pin.sym} 16360 -11720 0 0 {name=p16225 lab=_55434_/B }
C {devices/lab_pin.sym} 16360 -11680 0 0 {name=p16226 lab=_55415_/B }
C {devices/lab_pin.sym} 16360 -11640 0 0 {name=p16227 lab=_55415_/C }
C {devices/lab_pin.sym} 16480 -11700 0 1 {name=p16228 lab=_55434_/Y }
C {sky130_stdcells/nand4_4.sym} 16420 -11700 0 0 {name=X_55434_ }
C {devices/lab_pin.sym} 16330 -11550 0 0 {name=p16229 lab=_85554_/CLK }
C {devices/lab_pin.sym} 16330 -11530 0 0 {name=p16230 lab=_50152_/Y }
C {devices/lab_pin.sym} 16510 -11550 0 1 {name=p16231 lab=_65096_/B }
C {sky130_stdcells/dfxtp_4.sym} 16420 -11540 0 0 {name=X_86254_ }
C {devices/lab_pin.sym} 16340 -11430 0 0 {name=p16232 lab=_40577_/X }
C {devices/lab_pin.sym} 16340 -11390 0 0 {name=p16233 lab=_82868_/Q }
C {devices/lab_pin.sym} 16340 -11350 0 0 {name=p16234 lab=_40659_/X }
C {devices/lab_pin.sym} 16500 -11390 0 1 {name=p16235 lab=_40660_/X }
C {sky130_stdcells/o21a_4.sym} 16420 -11390 0 0 {name=X_40660_ }
C {devices/lab_pin.sym} 16340 -11270 0 0 {name=p16236 lab=_85780_/Q }
C {devices/lab_pin.sym} 16340 -11230 0 0 {name=p16237 lab=_52629_/X }
C {devices/lab_pin.sym} 16340 -11190 0 0 {name=p16238 lab=_52645_/Y }
C {devices/lab_pin.sym} 16500 -11230 0 1 {name=p16239 lab=_52646_/Y }
C {sky130_stdcells/o21ai_4.sym} 16420 -11230 0 0 {name=X_52646_ }
C {devices/lab_pin.sym} 16340 -11110 0 0 {name=p16240 lab=_71463_/Y }
C {devices/lab_pin.sym} 16340 -11070 0 0 {name=p16241 lab=_83484_/Q }
C {devices/lab_pin.sym} 16340 -11030 0 0 {name=p16242 lab=_71479_/X }
C {devices/lab_pin.sym} 16500 -11070 0 1 {name=p16243 lab=_83484_/D }
C {sky130_stdcells/a21o_4.sym} 16420 -11070 0 0 {name=X_71480_ }
C {devices/lab_pin.sym} 16330 -10930 0 0 {name=p16244 lab=_85955_/CLK }
C {devices/lab_pin.sym} 16330 -10910 0 0 {name=p16245 lab=_83466_/D }
C {devices/lab_pin.sym} 16510 -10930 0 1 {name=p16246 lab=_47817_/A }
C {sky130_stdcells/dfxtp_4.sym} 16420 -10920 0 0 {name=X_83466_ }
C {sky130_stdcells/decap_3.sym} 16420 -10760 0 0 {name=XPHY_502 }
C {devices/lab_pin.sym} 16330 -10610 0 0 {name=p16247 lab=_80679_/CLK }
C {devices/lab_pin.sym} 16330 -10590 0 0 {name=p16248 lab=_80710_/Q }
C {devices/lab_pin.sym} 16510 -10610 0 1 {name=p16249 lab=_80678_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -10600 0 0 {name=X_80678_ }
C {sky130_stdcells/decap_3.sym} 16420 -10440 0 0 {name=XPHY_513 }
C {sky130_stdcells/decap_3.sym} 16420 -10260 0 0 {name=XPHY_524 }
C {devices/lab_pin.sym} 16330 -10110 0 0 {name=p16250 lab=_86900_/CLK }
C {devices/lab_pin.sym} 16330 -10090 0 0 {name=p16251 lab=_85205_/D }
C {devices/lab_pin.sym} 16510 -10110 0 1 {name=p16252 lab=_56407_/C }
C {sky130_stdcells/dfxtp_4.sym} 16420 -10100 0 0 {name=X_85205_ }
C {devices/lab_pin.sym} 16360 -9990 0 0 {name=p16253 lab=_70442_/A }
C {devices/lab_pin.sym} 16360 -9950 0 0 {name=p16254 lab=_70940_/B }
C {devices/lab_pin.sym} 16360 -9910 0 0 {name=p16255 lab=_70431_/C }
C {devices/lab_pin.sym} 16480 -9950 0 1 {name=p16256 lab=_70431_/Y }
C {sky130_stdcells/nand3_4.sym} 16420 -9950 0 0 {name=X_70431_ }
C {devices/lab_pin.sym} 16380 -9810 0 0 {name=p16257 lab=_72484_/A }
C {devices/lab_pin.sym} 16460 -9810 0 1 {name=p16258 lab=_58153_/X }
C {sky130_stdcells/buf_2.sym} 16420 -9810 0 0 {name=X_58153_ }
C {sky130_stdcells/decap_3.sym} 16420 -9660 0 0 {name=XPHY_535 }
C {devices/lab_pin.sym} 16330 -9510 0 0 {name=p16259 lab=_82820_/CLK }
C {devices/lab_pin.sym} 16330 -9490 0 0 {name=p16260 lab=_82449_/Q }
C {devices/lab_pin.sym} 16510 -9510 0 1 {name=p16261 lab=_78524_/A }
C {sky130_stdcells/dfxtp_4.sym} 16420 -9500 0 0 {name=X_82417_ }
C {devices/lab_pin.sym} 16360 -9380 0 0 {name=p16262 lab=_55336_/X }
C {devices/lab_pin.sym} 16360 -9340 0 0 {name=p16263 lab=_55365_/B }
C {devices/lab_pin.sym} 16480 -9360 0 1 {name=p16264 lab=_55366_/A }
C {sky130_stdcells/and2_4.sym} 16420 -9360 0 0 {name=X_55365_ }
C {devices/lab_pin.sym} 16330 -9230 0 0 {name=p16265 lab=_86500_/CLK }
C {devices/lab_pin.sym} 16330 -9210 0 0 {name=p16266 lab=_50520_/Y }
C {devices/lab_pin.sym} 16510 -9230 0 1 {name=p16267 lab=_86185_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -9220 0 0 {name=X_86185_ }
C {devices/lab_pin.sym} 16360 -9100 0 0 {name=p16268 lab=_52590_/A }
C {devices/lab_pin.sym} 16360 -9060 0 0 {name=p16269 lab=_52577_/B }
C {devices/lab_pin.sym} 16480 -9080 0 1 {name=p16270 lab=_52577_/Y }
C {sky130_stdcells/nand2_4.sym} 16420 -9080 0 0 {name=X_52577_ }
C {devices/lab_pin.sym} 16360 -8970 0 0 {name=p16271 lab=_40344_/A }
C {devices/lab_pin.sym} 16360 -8930 0 0 {name=p16272 lab=_40591_/B }
C {devices/lab_pin.sym} 16360 -8890 0 0 {name=p16273 lab=_40591_/C }
C {devices/lab_pin.sym} 16480 -8930 0 1 {name=p16274 lab=_40591_/X }
C {sky130_stdcells/and3_4.sym} 16420 -8930 0 0 {name=X_40591_ }
C {sky130_stdcells/decap_3.sym} 16420 -8760 0 0 {name=XPHY_546 }
C {devices/lab_pin.sym} 16330 -8610 0 0 {name=p16275 lab=_83431_/CLK }
C {devices/lab_pin.sym} 16330 -8590 0 0 {name=p16276 lab=_71728_/Y }
C {devices/lab_pin.sym} 16510 -8610 0 1 {name=p16277 lab=_83397_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -8600 0 0 {name=X_83397_ }
C {sky130_stdcells/decap_3.sym} 16420 -8440 0 0 {name=XPHY_557 }
C {devices/lab_pin.sym} 16380 -8290 0 0 {name=p16278 lab=clkbuf_4_3_0_CLK/A }
C {devices/lab_pin.sym} 16460 -8290 0 1 {name=p16279 lab=clkbuf_4_3_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 16420 -8290 0 0 {name=Xclkbuf_4_3_0_CLK }
C {sky130_stdcells/decap_3.sym} 16420 -8140 0 0 {name=XPHY_568 }
C {devices/lab_pin.sym} 16340 -8020 0 0 {name=p16280 lab=_57097_/X }
C {devices/lab_pin.sym} 16340 -7980 0 0 {name=p16281 lab=_56589_/X }
C {devices/lab_pin.sym} 16340 -7940 0 0 {name=p16282 lab=_45470_/A }
C {devices/lab_pin.sym} 16340 -7900 0 0 {name=p16283 lab=_57099_/X }
C {devices/lab_pin.sym} 16500 -7960 0 1 {name=p16284 lab=_57104_/X }
C {sky130_stdcells/a2bb2o_4.sym} 16420 -7960 0 0 {name=X_57104_ }
C {devices/lab_pin.sym} 16380 -7810 0 0 {name=p16285 lab=_54316_/A }
C {devices/lab_pin.sym} 16460 -7810 0 1 {name=p16286 lab=_54325_/A }
C {sky130_stdcells/buf_2.sym} 16420 -7810 0 0 {name=X_54316_ }
C {devices/lab_pin.sym} 16380 -7690 0 0 {name=p16287 lab=_42417_/A }
C {devices/lab_pin.sym} 16460 -7690 0 1 {name=p16288 lab=_42330_/X }
C {sky130_stdcells/buf_2.sym} 16420 -7690 0 0 {name=X_42330_ }
C {devices/lab_pin.sym} 16340 -7600 0 0 {name=p16289 lab=_43152_/Y }
C {devices/lab_pin.sym} 16340 -7560 0 0 {name=p16290 lab=_72895_/X }
C {devices/lab_pin.sym} 16340 -7520 0 0 {name=p16291 lab=_72858_/X }
C {devices/lab_pin.sym} 16340 -7480 0 0 {name=p16292 lab=_73149_/Y }
C {devices/lab_pin.sym} 16500 -7540 0 1 {name=p16293 lab=_73150_/X }
C {sky130_stdcells/a211o_4.sym} 16420 -7540 0 0 {name=X_73150_ }
C {sky130_stdcells/decap_3.sym} 16420 -7360 0 0 {name=XPHY_579 }
C {devices/lab_pin.sym} 16330 -7210 0 0 {name=p16294 lab=_85103_/CLK }
C {devices/lab_pin.sym} 16330 -7190 0 0 {name=p16295 lab=_85136_/D }
C {devices/lab_pin.sym} 16510 -7210 0 1 {name=p16296 lab=_56705_/B }
C {sky130_stdcells/dfxtp_4.sym} 16420 -7200 0 0 {name=X_85136_ }
C {devices/lab_pin.sym} 16340 -7090 0 0 {name=p16297 lab=_51525_/Y }
C {devices/lab_pin.sym} 16340 -7050 0 0 {name=p16298 lab=_51503_/X }
C {devices/lab_pin.sym} 16340 -7010 0 0 {name=p16299 lab=_51527_/X }
C {devices/lab_pin.sym} 16500 -7050 0 1 {name=p16300 lab=_51528_/Y }
C {sky130_stdcells/a21oi_4.sym} 16420 -7050 0 0 {name=X_51528_ }
C {devices/lab_pin.sym} 16340 -6950 0 0 {name=p16301 lab=_58079_/X }
C {devices/lab_pin.sym} 16340 -6910 0 0 {name=p16302 lab=_58081_/Y }
C {devices/lab_pin.sym} 16340 -6870 0 0 {name=p16303 lab=_58082_/Y }
C {devices/lab_pin.sym} 16340 -6830 0 0 {name=p16304 lab=_58028_/X }
C {devices/lab_pin.sym} 16340 -6790 0 0 {name=p16305 lab=_58083_/X }
C {devices/lab_pin.sym} 16500 -6870 0 1 {name=p16306 lab=_58084_/X }
C {sky130_stdcells/o32a_4.sym} 16420 -6870 0 0 {name=X_58084_ }
C {devices/lab_pin.sym} 16360 -6720 0 0 {name=p16307 lab=_71003_/A }
C {devices/lab_pin.sym} 16360 -6680 0 0 {name=p16308 lab=_70361_/Y }
C {devices/lab_pin.sym} 16480 -6700 0 1 {name=p16309 lab=_70362_/X }
C {sky130_stdcells/and2_4.sym} 16420 -6700 0 0 {name=X_70362_ }
C {devices/lab_pin.sym} 16330 -6570 0 0 {name=p16310 lab=_82925_/CLK }
C {devices/lab_pin.sym} 16330 -6550 0 0 {name=p16311 lab=_77123_/X }
C {devices/lab_pin.sym} 16510 -6570 0 1 {name=p16312 lab=_48056_/A }
C {sky130_stdcells/dfxtp_4.sym} 16420 -6560 0 0 {name=X_82348_ }
C {devices/lab_pin.sym} 16360 -6440 0 0 {name=p16313 lab=_55296_/A }
C {devices/lab_pin.sym} 16360 -6400 0 0 {name=p16314 lab=_55296_/B }
C {devices/lab_pin.sym} 16480 -6420 0 1 {name=p16315 lab=_55297_/A }
C {sky130_stdcells/and2_4.sym} 16420 -6420 0 0 {name=X_55296_ }
C {devices/lab_pin.sym} 16360 -6300 0 0 {name=p16316 lab=_72091_/X }
C {devices/lab_pin.sym} 16360 -6260 0 0 {name=p16317 lab=_49176_/A }
C {devices/lab_pin.sym} 16480 -6280 0 1 {name=p16318 lab=_72101_/Y }
C {sky130_stdcells/nand2_4.sym} 16420 -6280 0 0 {name=X_72101_ }
C {devices/lab_pin.sym} 16340 -6170 0 0 {name=p16319 lab=_57032_/Y }
C {devices/lab_pin.sym} 16340 -6130 0 0 {name=p16320 lab=_57034_/Y }
C {devices/lab_pin.sym} 16340 -6090 0 0 {name=p16321 lab=_57084_/A }
C {devices/lab_pin.sym} 16500 -6130 0 1 {name=p16322 lab=_57035_/X }
C {sky130_stdcells/a21o_4.sym} 16420 -6130 0 0 {name=X_57035_ }
C {devices/lab_pin.sym} 16340 -6020 0 0 {name=p16323 lab=_41469_/X }
C {devices/lab_pin.sym} 16340 -5980 0 0 {name=p16324 lab=_42258_/X }
C {devices/lab_pin.sym} 16340 -5940 0 0 {name=p16325 lab=_87953_/Q }
C {devices/lab_pin.sym} 16340 -5900 0 0 {name=p16326 lab=_42259_/X }
C {devices/lab_pin.sym} 16500 -5960 0 1 {name=p16327 lab=_42261_/X }
C {sky130_stdcells/a2bb2o_4.sym} 16420 -5960 0 0 {name=X_42261_ }
C {devices/lab_pin.sym} 16360 -5840 0 0 {name=p16328 lab=_54255_/A }
C {devices/lab_pin.sym} 16360 -5800 0 0 {name=p16329 lab=_54246_/X }
C {devices/lab_pin.sym} 16360 -5760 0 0 {name=p16330 lab=_54237_/C }
C {devices/lab_pin.sym} 16360 -5720 0 0 {name=p16331 lab=_53078_/D }
C {devices/lab_pin.sym} 16480 -5780 0 1 {name=p16332 lab=_54247_/X }
C {sky130_stdcells/and4_4.sym} 16420 -5780 0 0 {name=X_54247_ }
C {devices/lab_pin.sym} 16360 -5640 0 0 {name=p16333 lab=_73081_/A }
C {devices/lab_pin.sym} 16360 -5600 0 0 {name=p16334 lab=_73124_/B }
C {devices/lab_pin.sym} 16480 -5620 0 1 {name=p16335 lab=_73081_/Y }
C {sky130_stdcells/nor2_4.sym} 16420 -5620 0 0 {name=X_73081_ }
C {devices/lab_pin.sym} 16330 -5490 0 0 {name=p16336 lab=_85067_/CLK }
C {devices/lab_pin.sym} 16330 -5470 0 0 {name=p16337 lab=_85067_/D }
C {devices/lab_pin.sym} 16510 -5490 0 1 {name=p16338 lab=_57179_/B }
C {sky130_stdcells/dfxtp_4.sym} 16420 -5480 0 0 {name=X_85067_ }
C {devices/lab_pin.sym} 16380 -5350 0 0 {name=p16339 lab=_51211_/A }
C {devices/lab_pin.sym} 16460 -5350 0 1 {name=p16340 lab=_51481_/A }
C {sky130_stdcells/buf_2.sym} 16420 -5350 0 0 {name=X_51459_ }
C {devices/lab_pin.sym} 16340 -5250 0 0 {name=p16341 lab=_70289_/X }
C {devices/lab_pin.sym} 16340 -5210 0 0 {name=p16342 lab=_74796_/A }
C {devices/lab_pin.sym} 16340 -5170 0 0 {name=p16343 lab=_70292_/X }
C {devices/lab_pin.sym} 16500 -5210 0 1 {name=p16344 lab=_83808_/D }
C {sky130_stdcells/a21o_4.sym} 16420 -5210 0 0 {name=X_70293_ }
C {devices/lab_pin.sym} 16330 -5070 0 0 {name=p16345 lab=_82284_/CLK }
C {devices/lab_pin.sym} 16330 -5050 0 0 {name=p16346 lab=_77036_/B }
C {devices/lab_pin.sym} 16510 -5070 0 1 {name=p16347 lab=_40901_/B }
C {sky130_stdcells/dfxtp_4.sym} 16420 -5060 0 0 {name=X_82279_ }
C {devices/lab_pin.sym} 16380 -4930 0 0 {name=p16348 lab=_59571_/C }
C {devices/lab_pin.sym} 16460 -4930 0 1 {name=p16349 lab=_59544_/B }
C {sky130_stdcells/buf_2.sym} 16420 -4930 0 0 {name=X_44000_ }
C {devices/lab_pin.sym} 16360 -4820 0 0 {name=p16350 lab=_41007_/A }
C {devices/lab_pin.sym} 16360 -4780 0 0 {name=p16351 lab=_40694_/A }
C {devices/lab_pin.sym} 16480 -4800 0 1 {name=p16352 lab=_41212_/X }
C {sky130_stdcells/or2_4.sym} 16420 -4800 0 0 {name=X_41212_ }
C {devices/lab_pin.sym} 16340 -4690 0 0 {name=p16353 lab=_83298_/Q }
C {devices/lab_pin.sym} 16340 -4650 0 0 {name=p16354 lab=_72016_/X }
C {devices/lab_pin.sym} 16340 -4610 0 0 {name=p16355 lab=_72031_/Y }
C {devices/lab_pin.sym} 16500 -4650 0 1 {name=p16356 lab=_72032_/Y }
C {sky130_stdcells/o21ai_4.sym} 16420 -4650 0 0 {name=X_72032_ }
C {devices/lab_pin.sym} 16330 -4510 0 0 {name=p16357 lab=_84020_/CLK }
C {devices/lab_pin.sym} 16330 -4490 0 0 {name=p16358 lab=_68183_/X }
C {devices/lab_pin.sym} 16510 -4510 0 1 {name=p16359 lab=_84018_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -4500 0 0 {name=X_84018_ }
C {devices/lab_pin.sym} 16380 -4370 0 0 {name=p16360 lab=_42137_/A }
C {devices/lab_pin.sym} 16460 -4370 0 1 {name=p16361 lab=_42192_/X }
C {sky130_stdcells/buf_2.sym} 16420 -4370 0 0 {name=X_42192_ }
C {devices/lab_pin.sym} 16340 -4270 0 0 {name=p16362 lab=_54176_/Y }
C {devices/lab_pin.sym} 16340 -4230 0 0 {name=p16363 lab=_54171_/X }
C {devices/lab_pin.sym} 16340 -4190 0 0 {name=p16364 lab=_54177_/X }
C {devices/lab_pin.sym} 16500 -4230 0 1 {name=p16365 lab=_54178_/Y }
C {sky130_stdcells/a21oi_4.sym} 16420 -4230 0 0 {name=X_54178_ }
C {devices/lab_pin.sym} 16380 -4090 0 0 {name=p16366 lab=_41143_/A }
C {devices/lab_pin.sym} 16460 -4090 0 1 {name=p16367 lab=_41143_/X }
C {sky130_stdcells/buf_2.sym} 16420 -4090 0 0 {name=X_41143_ }
C {devices/lab_pin.sym} 16360 -4000 0 0 {name=p16368 lab=_53133_/A }
C {devices/lab_pin.sym} 16360 -3960 0 0 {name=p16369 lab=_53133_/B }
C {devices/lab_pin.sym} 16360 -3920 0 0 {name=p16370 lab=_53133_/C }
C {devices/lab_pin.sym} 16360 -3880 0 0 {name=p16371 lab=_53129_/D }
C {devices/lab_pin.sym} 16480 -3940 0 1 {name=p16372 lab=_53129_/X }
C {sky130_stdcells/and4_4.sym} 16420 -3940 0 0 {name=X_53129_ }
C {devices/lab_pin.sym} 16360 -3800 0 0 {name=p16373 lab=_81671_/Q }
C {devices/lab_pin.sym} 16360 -3760 0 0 {name=p16374 lab=_76840_/B }
C {devices/lab_pin.sym} 16480 -3780 0 1 {name=p16375 lab=_76840_/Y }
C {sky130_stdcells/xnor2_4.sym} 16420 -3780 0 0 {name=X_76840_ }
C {devices/lab_pin.sym} 16340 -3670 0 0 {name=p16376 lab=_58982_/X }
C {devices/lab_pin.sym} 16340 -3630 0 0 {name=p16377 lab=_83437_/Q }
C {devices/lab_pin.sym} 16340 -3590 0 0 {name=p16378 lab=_58985_/Y }
C {devices/lab_pin.sym} 16500 -3630 0 1 {name=p16379 lab=_84781_/D }
C {sky130_stdcells/o21a_4.sym} 16420 -3630 0 0 {name=X_58986_ }
C {devices/lab_pin.sym} 16380 -3490 0 0 {name=p16380 lab=_45935_/X }
C {devices/lab_pin.sym} 16460 -3490 0 1 {name=p16381 lab=_45951_/Y }
C {sky130_stdcells/inv_2.sym} 16420 -3490 0 0 {name=X_45951_ }
C {devices/lab_pin.sym} 16360 -3380 0 0 {name=p16382 lab=_82280_/Q }
C {devices/lab_pin.sym} 16360 -3340 0 0 {name=p16383 lab=_41019_/B }
C {devices/lab_pin.sym} 16480 -3360 0 1 {name=p16384 lab=_41074_/X }
C {sky130_stdcells/or2_4.sym} 16420 -3360 0 0 {name=X_41074_ }
C {devices/lab_pin.sym} 16340 -3250 0 0 {name=p16385 lab=_57903_/X }
C {devices/lab_pin.sym} 16340 -3210 0 0 {name=p16386 lab=_85490_/Q }
C {devices/lab_pin.sym} 16340 -3170 0 0 {name=p16387 lab=_57849_/X }
C {devices/lab_pin.sym} 16500 -3210 0 1 {name=p16388 lab=_57937_/X }
C {sky130_stdcells/o21a_4.sym} 16420 -3210 0 0 {name=X_57937_ }
C {devices/lab_pin.sym} 16360 -3080 0 0 {name=p16389 lab=_76771_/A }
C {devices/lab_pin.sym} 16360 -3040 0 0 {name=p16390 lab=_76771_/B }
C {devices/lab_pin.sym} 16480 -3060 0 1 {name=p16391 lab=_76771_/X }
C {sky130_stdcells/xor2_4.sym} 16420 -3060 0 0 {name=X_76771_ }
C {devices/lab_pin.sym} 16340 -2950 0 0 {name=p16392 lab=_73980_/X }
C {devices/lab_pin.sym} 16340 -2910 0 0 {name=p16393 lab=_73981_/Y }
C {devices/lab_pin.sym} 16340 -2870 0 0 {name=p16394 lab=_73982_/X }
C {devices/lab_pin.sym} 16500 -2910 0 1 {name=p16395 lab=_73983_/X }
C {sky130_stdcells/a21o_4.sym} 16420 -2910 0 0 {name=X_73983_ }
C {devices/lab_pin.sym} 16330 -2770 0 0 {name=p16396 lab=_85969_/CLK }
C {devices/lab_pin.sym} 16330 -2750 0 0 {name=p16397 lab=_85969_/D }
C {devices/lab_pin.sym} 16510 -2770 0 1 {name=p16398 lab=_85969_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -2760 0 0 {name=X_85969_ }
C {devices/lab_pin.sym} 16360 -2650 0 0 {name=p16399 lab=_78505_/X }
C {devices/lab_pin.sym} 16360 -2610 0 0 {name=p16400 lab=_78508_/Y }
C {devices/lab_pin.sym} 16360 -2570 0 0 {name=p16401 lab=_78510_/C }
C {devices/lab_pin.sym} 16480 -2610 0 1 {name=p16402 lab=_78510_/Y }
C {sky130_stdcells/nand3_4.sym} 16420 -2610 0 0 {name=X_78510_ }
C {devices/lab_pin.sym} 16340 -2490 0 0 {name=p16403 lab=_44894_/Y }
C {devices/lab_pin.sym} 16340 -2450 0 0 {name=p16404 lab=_44899_/Y }
C {devices/lab_pin.sym} 16340 -2410 0 0 {name=p16405 lab=_44901_/X }
C {devices/lab_pin.sym} 16500 -2450 0 1 {name=p16406 lab=_44902_/X }
C {sky130_stdcells/o21a_4.sym} 16420 -2450 0 0 {name=X_44902_ }
C {devices/lab_pin.sym} 16360 -2320 0 0 {name=p16407 lab=_75722_/A }
C {devices/lab_pin.sym} 16360 -2280 0 0 {name=p16408 lab=_75722_/B }
C {devices/lab_pin.sym} 16480 -2300 0 1 {name=p16409 lab=_75723_/B }
C {sky130_stdcells/nand2_4.sym} 16420 -2300 0 0 {name=X_75722_ }
C {devices/lab_pin.sym} 16330 -2170 0 0 {name=p16410 lab=_87708_/CLK }
C {devices/lab_pin.sym} 16330 -2150 0 0 {name=p16411 lab=_87708_/D }
C {devices/lab_pin.sym} 16510 -2170 0 1 {name=p16412 lab=_67889_/B }
C {sky130_stdcells/dfxtp_4.sym} 16420 -2160 0 0 {name=X_87708_ }
C {devices/lab_pin.sym} 16380 -2030 0 0 {name=p16413 lab=_48613_/A }
C {devices/lab_pin.sym} 16460 -2030 0 1 {name=p16414 lab=_48695_/A }
C {sky130_stdcells/buf_2.sym} 16420 -2030 0 0 {name=X_48670_ }
C {devices/lab_pin.sym} 16340 -1930 0 0 {name=p16415 lab=_72930_/X }
C {devices/lab_pin.sym} 16340 -1890 0 0 {name=p16416 lab=_72933_/X }
C {devices/lab_pin.sym} 16340 -1850 0 0 {name=p16417 lab=_72812_/X }
C {devices/lab_pin.sym} 16500 -1890 0 1 {name=p16418 lab=_72934_/X }
C {sky130_stdcells/a21o_4.sym} 16420 -1890 0 0 {name=X_72934_ }
C {devices/lab_pin.sym} 16360 -1760 0 0 {name=p16419 lab=_84814_/Q }
C {devices/lab_pin.sym} 16360 -1720 0 0 {name=p16420 lab=_84134_/Q }
C {devices/lab_pin.sym} 16480 -1740 0 1 {name=p16421 lab=_79490_/Y }
C {sky130_stdcells/nand2_4.sym} 16420 -1740 0 0 {name=X_79490_ }
C {devices/lab_pin.sym} 16380 -1610 0 0 {name=p16422 lab=_45882_/A }
C {devices/lab_pin.sym} 16460 -1610 0 1 {name=p16423 lab=_45883_/B }
C {sky130_stdcells/buf_2.sym} 16420 -1610 0 0 {name=X_45882_ }
C {devices/lab_pin.sym} 16380 -1490 0 0 {name=p16424 lab=_58696_/A }
C {devices/lab_pin.sym} 16460 -1490 0 1 {name=p16425 lab=_57868_/X }
C {sky130_stdcells/buf_2.sym} 16420 -1490 0 0 {name=X_57868_ }
C {devices/lab_pin.sym} 16380 -1370 0 0 {name=p16426 lab=_47620_/X }
C {devices/lab_pin.sym} 16460 -1370 0 1 {name=p16427 lab=_47649_/A }
C {sky130_stdcells/buf_2.sym} 16420 -1370 0 0 {name=X_47621_ }
C {devices/lab_pin.sym} 16380 -1250 0 0 {name=p16428 lab=_59637_/A }
C {devices/lab_pin.sym} 16460 -1250 0 1 {name=p16429 lab=_59608_/A }
C {sky130_stdcells/buf_2.sym} 16420 -1250 0 0 {name=X_59607_ }
C {devices/lab_pin.sym} 16360 -1140 0 0 {name=p16430 lab=_78450_/A }
C {devices/lab_pin.sym} 16360 -1100 0 0 {name=p16431 lab=_78450_/B }
C {devices/lab_pin.sym} 16480 -1120 0 1 {name=p16432 lab=_78441_/X }
C {sky130_stdcells/or2_4.sym} 16420 -1120 0 0 {name=X_78441_ }
C {devices/lab_pin.sym} 16380 -990 0 0 {name=p16433 lab=_43896_/X }
C {devices/lab_pin.sym} 16460 -990 0 1 {name=p16434 lab=_44833_/X }
C {sky130_stdcells/buf_2.sym} 16420 -990 0 0 {name=X_44833_ }
C {devices/lab_pin.sym} 16340 -890 0 0 {name=p16435 lab=_56649_/X }
C {devices/lab_pin.sym} 16340 -850 0 0 {name=p16436 lab=_57186_/B }
C {devices/lab_pin.sym} 16340 -810 0 0 {name=p16437 lab=_56818_/X }
C {devices/lab_pin.sym} 16500 -850 0 1 {name=p16438 lab=_56820_/A }
C {sky130_stdcells/o21ai_4.sym} 16420 -850 0 0 {name=X_56819_ }
C {devices/lab_pin.sym} 16330 -710 0 0 {name=p16439 lab=_87189_/CLK }
C {devices/lab_pin.sym} 16330 -690 0 0 {name=p16440 lab=_87639_/D }
C {devices/lab_pin.sym} 16510 -710 0 1 {name=p16441 lab=_87639_/Q }
C {sky130_stdcells/dfxtp_4.sym} 16420 -700 0 0 {name=X_87639_ }
C {devices/lab_pin.sym} 17260 -42170 0 0 {name=p16442 lab=_75660_/A }
C {devices/lab_pin.sym} 17260 -42130 0 0 {name=p16443 lab=_75659_/A }
C {devices/lab_pin.sym} 17260 -42090 0 0 {name=p16444 lab=_75652_/Y }
C {devices/lab_pin.sym} 17420 -42130 0 1 {name=p16445 lab=_75653_/Y }
C {sky130_stdcells/a21oi_4.sym} 17340 -42130 0 0 {name=X_75653_ }
C {devices/lab_pin.sym} 17300 -41990 0 0 {name=p16446 lab=_72896_/B }
C {devices/lab_pin.sym} 17380 -41990 0 1 {name=p16447 lab=_72865_/X }
C {sky130_stdcells/buf_2.sym} 17340 -41990 0 0 {name=X_72865_ }
C {devices/lab_pin.sym} 17300 -41870 0 0 {name=p16448 lab=_57866_/A }
C {devices/lab_pin.sym} 17380 -41870 0 1 {name=p16449 lab=_57800_/A }
C {sky130_stdcells/buf_2.sym} 17340 -41870 0 0 {name=X_57799_ }
C {devices/lab_pin.sym} 17260 -41770 0 0 {name=p16450 lab=_45244_/Y }
C {devices/lab_pin.sym} 17260 -41730 0 0 {name=p16451 lab=_74598_/X }
C {devices/lab_pin.sym} 17260 -41690 0 0 {name=p16452 lab=_74603_/X }
C {devices/lab_pin.sym} 17420 -41730 0 1 {name=p16453 lab=_74604_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -41730 0 0 {name=X_74604_ }
C {devices/lab_pin.sym} 17300 -41590 0 0 {name=p16454 lab=_47552_/A }
C {devices/lab_pin.sym} 17380 -41590 0 1 {name=p16455 lab=_53115_/B }
C {sky130_stdcells/buf_2.sym} 17340 -41590 0 0 {name=X_47552_ }
C {devices/lab_pin.sym} 17260 -41490 0 0 {name=p16456 lab=_71805_/X }
C {devices/lab_pin.sym} 17260 -41450 0 0 {name=p16457 lab=_83365_/Q }
C {devices/lab_pin.sym} 17260 -41410 0 0 {name=p16458 lab=_71815_/X }
C {devices/lab_pin.sym} 17420 -41450 0 1 {name=p16459 lab=_71816_/X }
C {sky130_stdcells/a21o_4.sym} 17340 -41450 0 0 {name=X_71816_ }
C {devices/lab_pin.sym} 17280 -41340 0 0 {name=p16460 lab=_43995_/A }
C {devices/lab_pin.sym} 17280 -41300 0 0 {name=p16461 lab=_59876_/B }
C {devices/lab_pin.sym} 17280 -41260 0 0 {name=p16462 lab=_59538_/C }
C {devices/lab_pin.sym} 17280 -41220 0 0 {name=p16463 lab=_59538_/D }
C {devices/lab_pin.sym} 17400 -41280 0 1 {name=p16464 lab=_61078_/B }
C {sky130_stdcells/nand4_4.sym} 17340 -41280 0 0 {name=X_59538_ }
C {devices/lab_pin.sym} 17300 -41130 0 0 {name=p16465 lab=_78371_/Y }
C {devices/lab_pin.sym} 17380 -41130 0 1 {name=p16466 lab=_78375_/A }
C {sky130_stdcells/inv_2.sym} 17340 -41130 0 0 {name=X_78372_ }
C {devices/lab_pin.sym} 17260 -41050 0 0 {name=p16467 lab=_44740_/X }
C {devices/lab_pin.sym} 17260 -41010 0 0 {name=p16468 lab=_44741_/X }
C {devices/lab_pin.sym} 17260 -40970 0 0 {name=p16469 lab=_41331_/X }
C {devices/lab_pin.sym} 17260 -40930 0 0 {name=p16470 lab=_86966_/Q }
C {devices/lab_pin.sym} 17260 -40890 0 0 {name=p16471 lab=_44742_/X }
C {devices/lab_pin.sym} 17420 -40970 0 1 {name=p16472 lab=_44765_/A }
C {sky130_stdcells/o32ai_4.sym} 17340 -40970 0 0 {name=X_44764_ }
C {devices/lab_pin.sym} 17280 -40830 0 0 {name=p16473 lab=_75888_/A }
C {devices/lab_pin.sym} 17280 -40790 0 0 {name=p16474 lab=_75580_/Y }
C {devices/lab_pin.sym} 17280 -40750 0 0 {name=p16475 lab=_75584_/C }
C {devices/lab_pin.sym} 17400 -40790 0 1 {name=p16476 lab=_75584_/Y }
C {sky130_stdcells/nand3_4.sym} 17340 -40790 0 0 {name=X_75584_ }
C {devices/lab_pin.sym} 17300 -40650 0 0 {name=p16477 lab=_88085_/Q }
C {devices/lab_pin.sym} 17380 -40650 0 1 {name=p16478 lab=_41976_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -40650 0 0 {name=X_41976_ }
C {devices/lab_pin.sym} 17280 -40540 0 0 {name=p16479 lab=_42548_/A }
C {devices/lab_pin.sym} 17280 -40500 0 0 {name=p16480 lab=_73000_/B }
C {devices/lab_pin.sym} 17400 -40520 0 1 {name=p16481 lab=_72796_/Y }
C {sky130_stdcells/nor2_4.sym} 17340 -40520 0 0 {name=X_72796_ }
C {devices/lab_pin.sym} 17260 -40410 0 0 {name=p16482 lab=_86731_/Q }
C {devices/lab_pin.sym} 17260 -40370 0 0 {name=p16483 lab=_46474_/X }
C {devices/lab_pin.sym} 17260 -40330 0 0 {name=p16484 lab=_46502_/Y }
C {devices/lab_pin.sym} 17420 -40370 0 1 {name=p16485 lab=_46503_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -40370 0 0 {name=X_46503_ }
C {devices/lab_pin.sym} 17280 -40240 0 0 {name=p16486 lab=_77324_/A }
C {devices/lab_pin.sym} 17280 -40200 0 0 {name=p16487 lab=_82089_/D }
C {devices/lab_pin.sym} 17400 -40220 0 1 {name=p16488 lab=_77323_/Y }
C {sky130_stdcells/nor2_4.sym} 17340 -40220 0 0 {name=X_77323_ }
C {devices/lab_pin.sym} 17300 -40090 0 0 {name=p16489 lab=_43715_/A }
C {devices/lab_pin.sym} 17380 -40090 0 1 {name=p16490 lab=_43715_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -40090 0 0 {name=X_43715_ }
C {devices/lab_pin.sym} 17280 -39980 0 0 {name=p16491 lab=_56460_/B }
C {devices/lab_pin.sym} 17280 -39940 0 0 {name=p16492 lab=_56460_/D }
C {devices/lab_pin.sym} 17400 -39960 0 1 {name=p16493 lab=_74614_/A }
C {sky130_stdcells/nand2_4.sym} 17340 -39960 0 0 {name=X_74535_ }
C {devices/lab_pin.sym} 17280 -39840 0 0 {name=p16494 lab=_40927_/A }
C {devices/lab_pin.sym} 17280 -39800 0 0 {name=p16495 lab=_40842_/X }
C {devices/lab_pin.sym} 17400 -39820 0 1 {name=p16496 lab=_40927_/X }
C {sky130_stdcells/or2_4.sym} 17340 -39820 0 0 {name=X_40927_ }
C {devices/lab_pin.sym} 17260 -39710 0 0 {name=p16497 lab=_86630_/Q }
C {devices/lab_pin.sym} 17260 -39670 0 0 {name=p16498 lab=_47478_/X }
C {devices/lab_pin.sym} 17260 -39630 0 0 {name=p16499 lab=_47482_/Y }
C {devices/lab_pin.sym} 17420 -39670 0 1 {name=p16500 lab=_47483_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -39670 0 0 {name=X_47483_ }
C {devices/lab_pin.sym} 17280 -39560 0 0 {name=p16501 lab=_71173_/A }
C {devices/lab_pin.sym} 17280 -39520 0 0 {name=p16502 lab=_71753_/B }
C {devices/lab_pin.sym} 17280 -39480 0 0 {name=p16503 lab=_71744_/C }
C {devices/lab_pin.sym} 17280 -39440 0 0 {name=p16504 lab=_71744_/D }
C {devices/lab_pin.sym} 17400 -39500 0 1 {name=p16505 lab=_71747_/Y }
C {sky130_stdcells/nand4_4.sym} 17340 -39500 0 0 {name=X_71747_ }
C {devices/lab_pin.sym} 17260 -39370 0 0 {name=p16506 lab=_59462_/X }
C {devices/lab_pin.sym} 17260 -39330 0 0 {name=p16507 lab=_83460_/Q }
C {devices/lab_pin.sym} 17260 -39290 0 0 {name=p16508 lab=_59468_/Y }
C {devices/lab_pin.sym} 17420 -39330 0 1 {name=p16509 lab=_84724_/D }
C {sky130_stdcells/o21a_4.sym} 17340 -39330 0 0 {name=X_59469_ }
C {devices/lab_pin.sym} 17300 -39190 0 0 {name=p16510 lab=_86997_/Q }
C {devices/lab_pin.sym} 17380 -39190 0 1 {name=p16511 lab=_44695_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -39190 0 0 {name=X_44695_ }
C {devices/lab_pin.sym} 17300 -39070 0 0 {name=p16512 lab=_48548_/A }
C {devices/lab_pin.sym} 17380 -39070 0 1 {name=p16513 lab=_49222_/X }
C {sky130_stdcells/buf_2.sym} 17340 -39070 0 0 {name=X_49222_ }
C {devices/lab_pin.sym} 17300 -38950 0 0 {name=p16514 lab=_84819_/Q }
C {devices/lab_pin.sym} 17380 -38950 0 1 {name=p16515 lab=_61500_/X }
C {sky130_stdcells/buf_2.sym} 17340 -38950 0 0 {name=X_61500_ }
C {devices/lab_pin.sym} 17280 -38840 0 0 {name=p16516 lab=_46434_/A }
C {devices/lab_pin.sym} 17280 -38800 0 0 {name=p16517 lab=_51316_/B }
C {devices/lab_pin.sym} 17400 -38820 0 1 {name=p16518 lab=_46434_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -38820 0 0 {name=X_46434_ }
C {devices/lab_pin.sym} 17300 -38690 0 0 {name=p16519 lab=_77254_/A }
C {devices/lab_pin.sym} 17380 -38690 0 1 {name=p16520 lab=_77254_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -38690 0 0 {name=X_77254_ }
C {devices/lab_pin.sym} 17300 -38570 0 0 {name=p16521 lab=_43645_/X }
C {devices/lab_pin.sym} 17380 -38570 0 1 {name=p16522 lab=_87329_/D }
C {sky130_stdcells/inv_2.sym} 17340 -38570 0 0 {name=X_43646_ }
C {devices/lab_pin.sym} 17260 -38490 0 0 {name=p16523 lab=_61548_/B }
C {devices/lab_pin.sym} 17260 -38450 0 0 {name=p16524 lab=_62462_/X }
C {devices/lab_pin.sym} 17260 -38410 0 0 {name=p16525 lab=_62436_/X }
C {devices/lab_pin.sym} 17260 -38370 0 0 {name=p16526 lab=_62478_/X }
C {devices/lab_pin.sym} 17260 -38340 0 0 {name=p16527 lab=_62479_/X }
C {devices/lab_pin.sym} 17420 -38410 0 1 {name=p16528 lab=_62480_/X }
C {sky130_stdcells/a41o_4.sym} 17340 -38410 0 0 {name=X_62480_ }
C {devices/lab_pin.sym} 17280 -38260 0 0 {name=p16529 lab=_74466_/A }
C {devices/lab_pin.sym} 17280 -38220 0 0 {name=p16530 lab=_48593_/A }
C {devices/lab_pin.sym} 17400 -38240 0 1 {name=p16531 lab=_74466_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -38240 0 0 {name=X_74466_ }
C {devices/lab_pin.sym} 17300 -38110 0 0 {name=p16532 lab=_40784_/A }
C {devices/lab_pin.sym} 17380 -38110 0 1 {name=p16533 lab=_40883_/B }
C {sky130_stdcells/buf_2.sym} 17340 -38110 0 0 {name=X_40858_ }
C {devices/lab_pin.sym} 17280 -38010 0 0 {name=p16534 lab=_71680_/A }
C {devices/lab_pin.sym} 17280 -37970 0 0 {name=p16535 lab=_71671_/X }
C {devices/lab_pin.sym} 17280 -37930 0 0 {name=p16536 lab=_71302_/X }
C {devices/lab_pin.sym} 17400 -37970 0 1 {name=p16537 lab=_71678_/Y }
C {sky130_stdcells/nand3_4.sym} 17340 -37970 0 0 {name=X_71678_ }
C {devices/lab_pin.sym} 17300 -37830 0 0 {name=p16538 lab=_76205_/A }
C {devices/lab_pin.sym} 17380 -37830 0 1 {name=p16539 lab=_76205_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -37830 0 0 {name=X_76205_ }
C {devices/lab_pin.sym} 17300 -37710 0 0 {name=p16540 lab=_49052_/A }
C {devices/lab_pin.sym} 17380 -37710 0 1 {name=p16541 lab=_49153_/X }
C {sky130_stdcells/buf_2.sym} 17340 -37710 0 0 {name=X_49153_ }
C {devices/lab_pin.sym} 17280 -37620 0 0 {name=p16542 lab=_59388_/A }
C {devices/lab_pin.sym} 17280 -37580 0 0 {name=p16543 lab=_61452_/B }
C {devices/lab_pin.sym} 17280 -37540 0 0 {name=p16544 lab=_61452_/C }
C {devices/lab_pin.sym} 17280 -37500 0 0 {name=p16545 lab=_61391_/D }
C {devices/lab_pin.sym} 17400 -37560 0 1 {name=p16546 lab=_61431_/Y }
C {sky130_stdcells/nand4_4.sym} 17340 -37560 0 0 {name=X_61431_ }
C {devices/lab_pin.sym} 17280 -37420 0 0 {name=p16547 lab=_87289_/Q }
C {devices/lab_pin.sym} 17280 -37380 0 0 {name=p16548 lab=_73530_/B }
C {devices/lab_pin.sym} 17400 -37400 0 1 {name=p16549 lab=_73417_/Y }
C {sky130_stdcells/nor2_4.sym} 17340 -37400 0 0 {name=X_73417_ }
C {devices/lab_pin.sym} 17300 -37270 0 0 {name=p16550 lab=_46290_/A }
C {devices/lab_pin.sym} 17380 -37270 0 1 {name=p16551 lab=_46366_/A }
C {sky130_stdcells/buf_2.sym} 17340 -37270 0 0 {name=X_46365_ }
C {devices/lab_pin.sym} 17300 -37150 0 0 {name=p16552 lab=_70668_/D }
C {devices/lab_pin.sym} 17380 -37150 0 1 {name=p16553 lab=_71735_/C }
C {sky130_stdcells/buf_2.sym} 17340 -37150 0 0 {name=X_70629_ }
C {devices/lab_pin.sym} 17300 -37030 0 0 {name=p16554 lab=_77184_/X }
C {devices/lab_pin.sym} 17380 -37030 0 1 {name=p16555 lab=_77185_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -37030 0 0 {name=X_77185_ }
C {devices/lab_pin.sym} 17300 -36910 0 0 {name=p16556 lab=_43577_/A }
C {devices/lab_pin.sym} 17380 -36910 0 1 {name=p16557 lab=_87351_/D }
C {sky130_stdcells/inv_2.sym} 17340 -36910 0 0 {name=X_43577_ }
C {devices/lab_pin.sym} 17260 -36810 0 0 {name=p16558 lab=_74394_/Y }
C {devices/lab_pin.sym} 17260 -36770 0 0 {name=p16559 lab=_74370_/X }
C {devices/lab_pin.sym} 17260 -36730 0 0 {name=p16560 lab=_74396_/X }
C {devices/lab_pin.sym} 17420 -36770 0 1 {name=p16561 lab=_83075_/D }
C {sky130_stdcells/a21oi_4.sym} 17340 -36770 0 0 {name=X_74397_ }
C {devices/lab_pin.sym} 17300 -36630 0 0 {name=p16562 lab=_40788_/Y }
C {devices/lab_pin.sym} 17380 -36630 0 1 {name=p16563 lab=_88335_/D }
C {sky130_stdcells/inv_2.sym} 17340 -36630 0 0 {name=X_40789_ }
C {devices/lab_pin.sym} 17300 -36510 0 0 {name=p16564 lab=_48731_/A }
C {devices/lab_pin.sym} 17380 -36510 0 1 {name=p16565 lab=_48142_/A }
C {sky130_stdcells/buf_2.sym} 17340 -36510 0 0 {name=X_48104_ }
C {devices/lab_pin.sym} 17260 -36410 0 0 {name=p16566 lab=_45313_/Y }
C {devices/lab_pin.sym} 17260 -36370 0 0 {name=p16567 lab=_45315_/Y }
C {devices/lab_pin.sym} 17260 -36330 0 0 {name=p16568 lab=_45287_/X }
C {devices/lab_pin.sym} 17420 -36370 0 1 {name=p16569 lab=_45316_/X }
C {sky130_stdcells/a21o_4.sym} 17340 -36370 0 0 {name=X_45316_ }
C {devices/lab_pin.sym} 17280 -36240 0 0 {name=p16570 lab=_76136_/A }
C {devices/lab_pin.sym} 17280 -36200 0 0 {name=p16571 lab=_76136_/B }
C {devices/lab_pin.sym} 17400 -36220 0 1 {name=p16572 lab=_76136_/X }
C {sky130_stdcells/xor2_4.sym} 17340 -36220 0 0 {name=X_76136_ }
C {devices/lab_pin.sym} 17280 -36120 0 0 {name=p16573 lab=_61652_/B }
C {devices/lab_pin.sym} 17280 -36080 0 0 {name=p16574 lab=_64161_/B }
C {devices/lab_pin.sym} 17280 -36040 0 0 {name=p16575 lab=_64150_/C }
C {devices/lab_pin.sym} 17280 -36000 0 0 {name=p16576 lab=_64161_/D }
C {devices/lab_pin.sym} 17400 -36060 0 1 {name=p16577 lab=_64150_/Y }
C {sky130_stdcells/nand4_4.sym} 17340 -36060 0 0 {name=X_64150_ }
C {devices/lab_pin.sym} 17300 -35910 0 0 {name=p16578 lab=_74164_/A }
C {devices/lab_pin.sym} 17380 -35910 0 1 {name=p16579 lab=_42528_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -35910 0 0 {name=X_42528_ }
C {devices/lab_pin.sym} 17280 -35800 0 0 {name=p16580 lab=_49056_/A }
C {devices/lab_pin.sym} 17280 -35760 0 0 {name=p16581 lab=_50153_/B }
C {devices/lab_pin.sym} 17400 -35780 0 1 {name=p16582 lab=_49084_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -35780 0 0 {name=X_49084_ }
C {devices/lab_pin.sym} 17280 -35670 0 0 {name=p16583 lab=_61384_/A }
C {devices/lab_pin.sym} 17280 -35630 0 0 {name=p16584 lab=_61384_/B }
C {devices/lab_pin.sym} 17280 -35590 0 0 {name=p16585 lab=_84487_/Q }
C {devices/lab_pin.sym} 17400 -35630 0 1 {name=p16586 lab=_61362_/Y }
C {sky130_stdcells/nor3_4.sym} 17340 -35630 0 0 {name=X_61362_ }
C {devices/lab_pin.sym} 17260 -35510 0 0 {name=p16587 lab=_73342_/X }
C {devices/lab_pin.sym} 17260 -35470 0 0 {name=p16588 lab=_73346_/X }
C {devices/lab_pin.sym} 17260 -35430 0 0 {name=p16589 lab=_73347_/X }
C {devices/lab_pin.sym} 17420 -35470 0 1 {name=p16590 lab=_73365_/B }
C {sky130_stdcells/a21o_4.sym} 17340 -35470 0 0 {name=X_73348_ }
C {devices/lab_pin.sym} 17280 -35340 0 0 {name=p16591 lab=_46421_/A }
C {devices/lab_pin.sym} 17280 -35300 0 0 {name=p16592 lab=_46295_/X }
C {devices/lab_pin.sym} 17400 -35320 0 1 {name=p16593 lab=_46296_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -35320 0 0 {name=X_46296_ }
C {devices/lab_pin.sym} 17260 -35230 0 0 {name=p16594 lab=_63095_/Y }
C {devices/lab_pin.sym} 17260 -35190 0 0 {name=p16595 lab=_63097_/X }
C {devices/lab_pin.sym} 17260 -35150 0 0 {name=p16596 lab=_63098_/X }
C {devices/lab_pin.sym} 17260 -35110 0 0 {name=p16597 lab=_63100_/X }
C {devices/lab_pin.sym} 17260 -35070 0 0 {name=p16598 lab=_63067_/X }
C {devices/lab_pin.sym} 17420 -35150 0 1 {name=p16599 lab=_63101_/Y }
C {sky130_stdcells/o41ai_4.sym} 17340 -35150 0 0 {name=X_63101_ }
C {devices/lab_pin.sym} 17260 -35010 0 0 {name=p16600 lab=_46493_/X }
C {devices/lab_pin.sym} 17260 -34970 0 0 {name=p16601 lab=_82350_/Q }
C {devices/lab_pin.sym} 17260 -34930 0 0 {name=p16602 lab=_48034_/Y }
C {devices/lab_pin.sym} 17420 -34970 0 1 {name=p16603 lab=_48036_/A }
C {sky130_stdcells/o21ai_4.sym} 17340 -34970 0 0 {name=X_48035_ }
C {devices/lab_pin.sym} 17300 -34830 0 0 {name=p16604 lab=_60312_/Y }
C {devices/lab_pin.sym} 17380 -34830 0 1 {name=p16605 lab=_60313_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -34830 0 0 {name=X_60313_ }
C {devices/lab_pin.sym} 17300 -34710 0 0 {name=p16606 lab=_64466_/B }
C {devices/lab_pin.sym} 17380 -34710 0 1 {name=p16607 lab=_61590_/B }
C {sky130_stdcells/buf_2.sym} 17340 -34710 0 0 {name=X_45247_ }
C {devices/lab_pin.sym} 17280 -34620 0 0 {name=p16608 lab=_64458_/B }
C {devices/lab_pin.sym} 17280 -34580 0 0 {name=p16609 lab=_64179_/B }
C {devices/lab_pin.sym} 17280 -34540 0 0 {name=p16610 lab=_64081_/C }
C {devices/lab_pin.sym} 17280 -34500 0 0 {name=p16611 lab=_64179_/D }
C {devices/lab_pin.sym} 17400 -34560 0 1 {name=p16612 lab=_64081_/Y }
C {sky130_stdcells/nand4_4.sym} 17340 -34560 0 0 {name=X_64081_ }
C {devices/lab_pin.sym} 17280 -34420 0 0 {name=p16613 lab=_76064_/Y }
C {devices/lab_pin.sym} 17280 -34380 0 0 {name=p16614 lab=_76066_/X }
C {devices/lab_pin.sym} 17400 -34400 0 1 {name=p16615 lab=_76067_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -34400 0 0 {name=X_76067_ }
C {devices/lab_pin.sym} 17300 -34270 0 0 {name=p16616 lab=_42458_/Y }
C {devices/lab_pin.sym} 17380 -34270 0 1 {name=p16617 lab=_87857_/D }
C {sky130_stdcells/inv_2.sym} 17340 -34270 0 0 {name=X_42459_ }
C {devices/lab_pin.sym} 17280 -34170 0 0 {name=p16618 lab=_61293_/A }
C {devices/lab_pin.sym} 17280 -34130 0 0 {name=p16619 lab=_61293_/B }
C {devices/lab_pin.sym} 17280 -34090 0 0 {name=p16620 lab=_61278_/B }
C {devices/lab_pin.sym} 17400 -34130 0 1 {name=p16621 lab=_61295_/A }
C {sky130_stdcells/nand3_4.sym} 17340 -34130 0 0 {name=X_61293_ }
C {devices/lab_pin.sym} 17300 -33990 0 0 {name=p16622 lab=_74246_/B }
C {devices/lab_pin.sym} 17380 -33990 0 1 {name=p16623 lab=_73279_/X }
C {sky130_stdcells/buf_2.sym} 17340 -33990 0 0 {name=X_73279_ }
C {devices/lab_pin.sym} 17300 -33870 0 0 {name=p16624 lab=_60508_/A }
C {devices/lab_pin.sym} 17380 -33870 0 1 {name=p16625 lab=_63033_/D }
C {sky130_stdcells/buf_2.sym} 17340 -33870 0 0 {name=X_63032_ }
C {devices/lab_pin.sym} 17280 -33760 0 0 {name=p16626 lab=_75018_/A }
C {devices/lab_pin.sym} 17280 -33720 0 0 {name=p16627 lab=_75017_/Y }
C {devices/lab_pin.sym} 17400 -33740 0 1 {name=p16628 lab=_75023_/A }
C {sky130_stdcells/nor2_4.sym} 17340 -33740 0 0 {name=X_75018_ }
C {devices/lab_pin.sym} 17280 -33630 0 0 {name=p16629 lab=_60244_/A }
C {devices/lab_pin.sym} 17280 -33590 0 0 {name=p16630 lab=_60244_/B }
C {devices/lab_pin.sym} 17280 -33550 0 0 {name=p16631 lab=_79863_/A }
C {devices/lab_pin.sym} 17400 -33590 0 1 {name=p16632 lab=_60244_/Y }
C {sky130_stdcells/nor3_4.sym} 17340 -33590 0 0 {name=X_60244_ }
C {devices/lab_pin.sym} 17260 -33470 0 0 {name=p16633 lab=_56424_/C }
C {devices/lab_pin.sym} 17260 -33430 0 0 {name=p16634 lab=_45176_/X }
C {devices/lab_pin.sym} 17260 -33390 0 0 {name=p16635 lab=_45177_/X }
C {devices/lab_pin.sym} 17420 -33430 0 1 {name=p16636 lab=_45178_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -33430 0 0 {name=X_45178_ }
C {devices/lab_pin.sym} 17300 -33290 0 0 {name=p16637 lab=_72838_/A }
C {devices/lab_pin.sym} 17380 -33290 0 1 {name=p16638 lab=_73284_/A }
C {sky130_stdcells/buf_2.sym} 17340 -33290 0 0 {name=X_44129_ }
C {devices/lab_pin.sym} 17280 -33180 0 0 {name=p16639 lab=_67909_/A }
C {devices/lab_pin.sym} 17280 -33140 0 0 {name=p16640 lab=_67840_/B }
C {devices/lab_pin.sym} 17400 -33160 0 1 {name=p16641 lab=_67840_/X }
C {sky130_stdcells/and2_4.sym} 17340 -33160 0 0 {name=X_67840_ }
C {devices/lab_pin.sym} 17280 -33040 0 0 {name=p16642 lab=_79826_/A }
C {devices/lab_pin.sym} 17280 -33000 0 0 {name=p16643 lab=_84260_/Q }
C {devices/lab_pin.sym} 17400 -33020 0 1 {name=p16644 lab=_79834_/B }
C {sky130_stdcells/xor2_4.sym} 17340 -33020 0 0 {name=X_79826_ }
C {devices/lab_pin.sym} 17280 -32910 0 0 {name=p16645 lab=_60175_/A }
C {devices/lab_pin.sym} 17280 -32870 0 0 {name=p16646 lab=_60312_/C }
C {devices/lab_pin.sym} 17280 -32830 0 0 {name=p16647 lab=_60312_/D }
C {devices/lab_pin.sym} 17400 -32870 0 1 {name=p16648 lab=_61286_/B }
C {sky130_stdcells/nand3_4.sym} 17340 -32870 0 0 {name=X_60175_ }
C {devices/lab_pin.sym} 17300 -32730 0 0 {name=p16649 lab=_49906_/A }
C {devices/lab_pin.sym} 17380 -32730 0 1 {name=p16650 lab=_49986_/X }
C {sky130_stdcells/buf_2.sym} 17340 -32730 0 0 {name=X_49986_ }
C {devices/lab_pin.sym} 17260 -32630 0 0 {name=p16651 lab=_48881_/X }
C {devices/lab_pin.sym} 17260 -32590 0 0 {name=p16652 lab=_81788_/Q }
C {devices/lab_pin.sym} 17260 -32550 0 0 {name=p16653 lab=_48936_/Y }
C {devices/lab_pin.sym} 17420 -32590 0 1 {name=p16654 lab=_48938_/A }
C {sky130_stdcells/o21ai_4.sym} 17340 -32590 0 0 {name=X_48937_ }
C {devices/lab_pin.sym} 17280 -32460 0 0 {name=p16655 lab=_67793_/A }
C {devices/lab_pin.sym} 17280 -32420 0 0 {name=p16656 lab=_87649_/Q }
C {devices/lab_pin.sym} 17400 -32440 0 1 {name=p16657 lab=_67771_/X }
C {sky130_stdcells/and2_4.sym} 17340 -32440 0 0 {name=X_67771_ }
C {devices/lab_pin.sym} 17280 -32320 0 0 {name=p16658 lab=_79757_/A }
C {devices/lab_pin.sym} 17280 -32280 0 0 {name=p16659 lab=_79756_/Y }
C {devices/lab_pin.sym} 17400 -32300 0 1 {name=p16660 lab=_79767_/B }
C {sky130_stdcells/xor2_4.sym} 17340 -32300 0 0 {name=X_79757_ }
C {devices/lab_pin.sym} 17280 -32190 0 0 {name=p16661 lab=_64978_/X }
C {devices/lab_pin.sym} 17280 -32150 0 0 {name=p16662 lab=_65056_/B }
C {devices/lab_pin.sym} 17280 -32110 0 0 {name=p16663 lab=_64982_/X }
C {devices/lab_pin.sym} 17400 -32150 0 1 {name=p16664 lab=_64995_/A }
C {sky130_stdcells/nand3_4.sym} 17340 -32150 0 0 {name=X_64983_ }
C {devices/lab_pin.sym} 17300 -32010 0 0 {name=p16665 lab=_76969_/A }
C {devices/lab_pin.sym} 17380 -32010 0 1 {name=p16666 lab=_81349_/D }
C {sky130_stdcells/inv_2.sym} 17340 -32010 0 0 {name=X_76969_ }
C {devices/lab_pin.sym} 17260 -31920 0 0 {name=p16667 lab=_87512_/Q }
C {devices/lab_pin.sym} 17260 -31880 0 0 {name=p16668 lab=_69442_/X }
C {devices/lab_pin.sym} 17260 -31840 0 0 {name=p16669 lab=_69396_/X }
C {devices/lab_pin.sym} 17260 -31800 0 0 {name=p16670 lab=_69509_/X }
C {devices/lab_pin.sym} 17420 -31860 0 1 {name=p16671 lab=_69510_/X }
C {sky130_stdcells/a211o_4.sym} 17340 -31860 0 0 {name=X_69510_ }
C {devices/lab_pin.sym} 17260 -31740 0 0 {name=p16672 lab=_87885_/Q }
C {devices/lab_pin.sym} 17260 -31700 0 0 {name=p16673 lab=_66697_/X }
C {devices/lab_pin.sym} 17260 -31660 0 0 {name=p16674 lab=_66675_/X }
C {devices/lab_pin.sym} 17260 -31620 0 0 {name=p16675 lab=_66721_/X }
C {devices/lab_pin.sym} 17420 -31680 0 1 {name=p16676 lab=_66722_/X }
C {sky130_stdcells/a211o_4.sym} 17340 -31680 0 0 {name=X_66722_ }
C {devices/lab_pin.sym} 17260 -31550 0 0 {name=p16677 lab=_78700_/Y }
C {devices/lab_pin.sym} 17260 -31510 0 0 {name=p16678 lab=_78706_/B }
C {devices/lab_pin.sym} 17260 -31470 0 0 {name=p16679 lab=_78722_/A }
C {devices/lab_pin.sym} 17420 -31510 0 1 {name=p16680 lab=_78721_/A }
C {sky130_stdcells/o21a_4.sym} 17340 -31510 0 0 {name=X_78708_ }
C {devices/lab_pin.sym} 17300 -31370 0 0 {name=p16681 lab=_64026_/A }
C {devices/lab_pin.sym} 17380 -31370 0 1 {name=p16682 lab=_63934_/X }
C {sky130_stdcells/buf_2.sym} 17340 -31370 0 0 {name=X_63934_ }
C {devices/lab_pin.sym} 17280 -31260 0 0 {name=p16683 lab=_50056_/A }
C {devices/lab_pin.sym} 17280 -31220 0 0 {name=p16684 lab=_48695_/B }
C {devices/lab_pin.sym} 17400 -31240 0 1 {name=p16685 lab=_48868_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -31240 0 0 {name=X_48868_ }
C {devices/lab_pin.sym} 17280 -31120 0 0 {name=p16686 lab=_84214_/Q }
C {devices/lab_pin.sym} 17280 -31080 0 0 {name=p16687 lab=_83262_/Q }
C {devices/lab_pin.sym} 17400 -31100 0 1 {name=p16688 lab=_79688_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -31100 0 0 {name=X_79688_ }
C {devices/lab_pin.sym} 17260 -31000 0 0 {name=p16689 lab=_88029_/Q }
C {devices/lab_pin.sym} 17260 -30960 0 0 {name=p16690 lab=_69315_/X }
C {devices/lab_pin.sym} 17260 -30920 0 0 {name=p16691 lab=_69393_/X }
C {devices/lab_pin.sym} 17260 -30880 0 0 {name=p16692 lab=_69440_/X }
C {devices/lab_pin.sym} 17420 -30940 0 1 {name=p16693 lab=_69441_/X }
C {sky130_stdcells/a211o_4.sym} 17340 -30940 0 0 {name=X_69441_ }
C {devices/lab_pin.sym} 17280 -30800 0 0 {name=p16694 lab=_47819_/A }
C {devices/lab_pin.sym} 17280 -30760 0 0 {name=p16695 lab=_53259_/B }
C {devices/lab_pin.sym} 17400 -30780 0 1 {name=p16696 lab=_47819_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -30780 0 0 {name=X_47819_ }
C {devices/lab_pin.sym} 17280 -30660 0 0 {name=p16697 lab=_66602_/A }
C {devices/lab_pin.sym} 17280 -30620 0 0 {name=p16698 lab=_86803_/Q }
C {devices/lab_pin.sym} 17400 -30640 0 1 {name=p16699 lab=_66653_/X }
C {sky130_stdcells/and2_4.sym} 17340 -30640 0 0 {name=X_66653_ }
C {devices/lab_pin.sym} 17300 -30510 0 0 {name=p16700 lab=_78639_/A }
C {devices/lab_pin.sym} 17380 -30510 0 1 {name=p16701 lab=_78639_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -30510 0 0 {name=X_78639_ }
C {devices/lab_pin.sym} 17260 -30410 0 0 {name=p16702 lab=_63863_/X }
C {devices/lab_pin.sym} 17260 -30370 0 0 {name=p16703 lab=_63833_/X }
C {devices/lab_pin.sym} 17260 -30330 0 0 {name=p16704 lab=_63864_/Y }
C {devices/lab_pin.sym} 17420 -30370 0 1 {name=p16705 lab=_84290_/D }
C {sky130_stdcells/a21oi_4.sym} 17340 -30370 0 0 {name=X_63865_ }
C {devices/lab_pin.sym} 17280 -30240 0 0 {name=p16706 lab=_48793_/A }
C {devices/lab_pin.sym} 17280 -30200 0 0 {name=p16707 lab=_48551_/X }
C {devices/lab_pin.sym} 17400 -30220 0 1 {name=p16708 lab=_48799_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -30220 0 0 {name=X_48799_ }
C {devices/lab_pin.sym} 17300 -30090 0 0 {name=p16709 lab=_84190_/Q }
C {devices/lab_pin.sym} 17380 -30090 0 1 {name=p16710 lab=_65605_/C }
C {sky130_stdcells/inv_2.sym} 17340 -30090 0 0 {name=X_65604_ }
C {devices/lab_pin.sym} 17280 -29990 0 0 {name=p16711 lab=_52524_/A }
C {devices/lab_pin.sym} 17280 -29950 0 0 {name=p16712 lab=_50825_/B }
C {devices/lab_pin.sym} 17280 -29910 0 0 {name=p16713 lab=_50830_/C }
C {devices/lab_pin.sym} 17400 -29950 0 1 {name=p16714 lab=_50830_/X }
C {sky130_stdcells/and3_4.sym} 17340 -29950 0 0 {name=X_50830_ }
C {devices/lab_pin.sym} 17280 -29830 0 0 {name=p16715 lab=_62792_/X }
C {devices/lab_pin.sym} 17280 -29790 0 0 {name=p16716 lab=_62839_/B }
C {devices/lab_pin.sym} 17280 -29750 0 0 {name=p16717 lab=_62816_/C }
C {devices/lab_pin.sym} 17400 -29790 0 1 {name=p16718 lab=_62816_/Y }
C {sky130_stdcells/nor3_4.sym} 17340 -29790 0 0 {name=X_62816_ }
C {devices/lab_pin.sym} 17250 -29650 0 0 {name=p16719 lab=_81362_/CLK }
C {devices/lab_pin.sym} 17250 -29630 0 0 {name=p16720 lab=_81682_/Q }
C {devices/lab_pin.sym} 17430 -29650 0 1 {name=p16721 lab=_81650_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -29640 0 0 {name=X_81650_ }
C {devices/lab_pin.sym} 17280 -29520 0 0 {name=p16722 lab=_69383_/A }
C {devices/lab_pin.sym} 17280 -29480 0 0 {name=p16723 lab=_69372_/B }
C {devices/lab_pin.sym} 17400 -29500 0 1 {name=p16724 lab=_69372_/X }
C {sky130_stdcells/and2_4.sym} 17340 -29500 0 0 {name=X_69372_ }
C {devices/lab_pin.sym} 17260 -29400 0 0 {name=p16725 lab=_44225_/B }
C {devices/lab_pin.sym} 17260 -29360 0 0 {name=p16726 lab=_88403_/Q }
C {devices/lab_pin.sym} 17260 -29320 0 0 {name=p16727 lab=_46212_/A }
C {devices/lab_pin.sym} 17260 -29280 0 0 {name=p16728 lab=_66583_/X }
C {devices/lab_pin.sym} 17420 -29340 0 1 {name=p16729 lab=_66584_/X }
C {sky130_stdcells/a211o_4.sym} 17340 -29340 0 0 {name=X_66584_ }
C {devices/lab_pin.sym} 17280 -29220 0 0 {name=p16730 lab=_61780_/X }
C {devices/lab_pin.sym} 17280 -29180 0 0 {name=p16731 lab=_63860_/B }
C {devices/lab_pin.sym} 17280 -29140 0 0 {name=p16732 lab=_63738_/C }
C {devices/lab_pin.sym} 17280 -29100 0 0 {name=p16733 lab=_63738_/D }
C {devices/lab_pin.sym} 17400 -29160 0 1 {name=p16734 lab=_63796_/Y }
C {sky130_stdcells/nand4_4.sym} 17340 -29160 0 0 {name=X_63796_ }
C {devices/lab_pin.sym} 17280 -29020 0 0 {name=p16735 lab=_80601_/A }
C {devices/lab_pin.sym} 17280 -28980 0 0 {name=p16736 lab=_80600_/Y }
C {devices/lab_pin.sym} 17400 -29000 0 1 {name=p16737 lab=_82270_/D }
C {sky130_stdcells/xor2_4.sym} 17340 -29000 0 0 {name=X_80601_ }
C {devices/lab_pin.sym} 17260 -28890 0 0 {name=p16738 lab=_67990_/X }
C {devices/lab_pin.sym} 17260 -28850 0 0 {name=p16739 lab=_67993_/X }
C {devices/lab_pin.sym} 17260 -28810 0 0 {name=p16740 lab=_68295_/X }
C {devices/lab_pin.sym} 17420 -28850 0 1 {name=p16741 lab=_68323_/Y }
C {sky130_stdcells/a21oi_4.sym} 17340 -28850 0 0 {name=X_68323_ }
C {devices/lab_pin.sym} 17280 -28720 0 0 {name=p16742 lab=_65667_/A }
C {devices/lab_pin.sym} 17280 -28680 0 0 {name=p16743 lab=_72957_/B }
C {devices/lab_pin.sym} 17400 -28700 0 1 {name=p16744 lab=_65535_/X }
C {sky130_stdcells/and2_4.sym} 17340 -28700 0 0 {name=X_65535_ }
C {devices/lab_pin.sym} 17280 -28580 0 0 {name=p16745 lab=_50771_/A }
C {devices/lab_pin.sym} 17280 -28540 0 0 {name=p16746 lab=_49241_/B }
C {devices/lab_pin.sym} 17400 -28560 0 1 {name=p16747 lab=_50761_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -28560 0 0 {name=X_50761_ }
C {devices/lab_pin.sym} 17280 -28450 0 0 {name=p16748 lab=_62766_/A }
C {devices/lab_pin.sym} 17280 -28410 0 0 {name=p16749 lab=_62766_/B }
C {devices/lab_pin.sym} 17280 -28370 0 0 {name=p16750 lab=_84386_/Q }
C {devices/lab_pin.sym} 17400 -28410 0 1 {name=p16751 lab=_62747_/Y }
C {sky130_stdcells/nor3_4.sym} 17340 -28410 0 0 {name=X_62747_ }
C {devices/lab_pin.sym} 17250 -28270 0 0 {name=p16752 lab=_81587_/CLK }
C {devices/lab_pin.sym} 17250 -28250 0 0 {name=p16753 lab=_84181_/Q }
C {devices/lab_pin.sym} 17430 -28270 0 1 {name=p16754 lab=_76753_/A }
C {sky130_stdcells/dfxtp_4.sym} 17340 -28260 0 0 {name=X_81581_ }
C {devices/lab_pin.sym} 17300 -28130 0 0 {name=p16755 lab=_52438_/A }
C {devices/lab_pin.sym} 17380 -28130 0 1 {name=p16756 lab=_52500_/X }
C {sky130_stdcells/buf_2.sym} 17340 -28130 0 0 {name=X_52500_ }
C {devices/lab_pin.sym} 17250 -28010 0 0 {name=p16757 lab=_83325_/CLK }
C {devices/lab_pin.sym} 17250 -27990 0 0 {name=p16758 lab=_71944_/X }
C {devices/lab_pin.sym} 17430 -28010 0 1 {name=p16759 lab=_83320_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -28000 0 0 {name=X_83320_ }
C {devices/lab_pin.sym} 17280 -27880 0 0 {name=p16760 lab=_80531_/B }
C {devices/lab_pin.sym} 17280 -27840 0 0 {name=p16761 lab=_80531_/A }
C {devices/lab_pin.sym} 17400 -27860 0 1 {name=p16762 lab=_80532_/X }
C {sky130_stdcells/and2_4.sym} 17340 -27860 0 0 {name=X_80532_ }
C {devices/lab_pin.sym} 17300 -27730 0 0 {name=p16763 lab=_68097_/A }
C {devices/lab_pin.sym} 17380 -27730 0 1 {name=p16764 lab=_68254_/X }
C {sky130_stdcells/buf_2.sym} 17340 -27730 0 0 {name=X_68254_ }
C {devices/lab_pin.sym} 17280 -27630 0 0 {name=p16765 lab=_47886_/X }
C {devices/lab_pin.sym} 17280 -27590 0 0 {name=p16766 lab=_50475_/B }
C {devices/lab_pin.sym} 17280 -27550 0 0 {name=p16767 lab=_53697_/C }
C {devices/lab_pin.sym} 17400 -27590 0 1 {name=p16768 lab=_53480_/Y }
C {sky130_stdcells/nand3_4.sym} 17340 -27590 0 0 {name=X_53480_ }
C {devices/lab_pin.sym} 17280 -27470 0 0 {name=p16769 lab=_65449_/A }
C {devices/lab_pin.sym} 17280 -27430 0 0 {name=p16770 lab=_65546_/B }
C {devices/lab_pin.sym} 17280 -27390 0 0 {name=p16771 lab=_65466_/C }
C {devices/lab_pin.sym} 17400 -27430 0 1 {name=p16772 lab=_65466_/X }
C {sky130_stdcells/and3_4.sym} 17340 -27430 0 0 {name=X_65466_ }
C {devices/lab_pin.sym} 17300 -27290 0 0 {name=p16773 lab=_50718_/A }
C {devices/lab_pin.sym} 17380 -27290 0 1 {name=p16774 lab=_50695_/A }
C {sky130_stdcells/buf_2.sym} 17340 -27290 0 0 {name=X_50692_ }
C {devices/lab_pin.sym} 17280 -27190 0 0 {name=p16775 lab=_62678_/A }
C {devices/lab_pin.sym} 17280 -27150 0 0 {name=p16776 lab=_60273_/X }
C {devices/lab_pin.sym} 17280 -27110 0 0 {name=p16777 lab=_61762_/X }
C {devices/lab_pin.sym} 17400 -27150 0 1 {name=p16778 lab=_62678_/Y }
C {sky130_stdcells/nand3_4.sym} 17340 -27150 0 0 {name=X_62678_ }
C {devices/lab_pin.sym} 17260 -27030 0 0 {name=p16779 lab=_67199_/X }
C {devices/lab_pin.sym} 17260 -26990 0 0 {name=p16780 lab=_67202_/X }
C {devices/lab_pin.sym} 17260 -26950 0 0 {name=p16781 lab=_67204_/X }
C {devices/lab_pin.sym} 17420 -26990 0 1 {name=p16782 lab=_67205_/X }
C {sky130_stdcells/a21o_4.sym} 17340 -26990 0 0 {name=X_67205_ }
C {devices/lab_pin.sym} 17300 -26850 0 0 {name=p16783 lab=_52431_/A }
C {devices/lab_pin.sym} 17380 -26850 0 1 {name=p16784 lab=_52436_/A }
C {sky130_stdcells/buf_2.sym} 17340 -26850 0 0 {name=X_52431_ }
C {devices/lab_pin.sym} 17260 -26750 0 0 {name=p16785 lab=_79700_/B }
C {devices/lab_pin.sym} 17260 -26710 0 0 {name=p16786 lab=_64373_/X }
C {devices/lab_pin.sym} 17260 -26670 0 0 {name=p16787 lab=_64416_/X }
C {devices/lab_pin.sym} 17420 -26710 0 1 {name=p16788 lab=_64417_/X }
C {sky130_stdcells/a21o_4.sym} 17340 -26710 0 0 {name=X_64417_ }
C {devices/lab_pin.sym} 17250 -26570 0 0 {name=p16789 lab=_84192_/CLK }
C {devices/lab_pin.sym} 17250 -26550 0 0 {name=p16790 lab=_72474_/Y }
C {devices/lab_pin.sym} 17430 -26570 0 1 {name=p16791 lab=_72465_/A }
C {sky130_stdcells/dfxtp_4.sym} 17340 -26560 0 0 {name=X_83251_ }
C {devices/lab_pin.sym} 17280 -26450 0 0 {name=p16792 lab=_61608_/X }
C {devices/lab_pin.sym} 17280 -26410 0 0 {name=p16793 lab=_61629_/B }
C {devices/lab_pin.sym} 17280 -26370 0 0 {name=p16794 lab=_61619_/C }
C {devices/lab_pin.sym} 17400 -26410 0 1 {name=p16795 lab=_61629_/Y }
C {sky130_stdcells/nand3_4.sym} 17340 -26410 0 0 {name=X_61629_ }
C {devices/lab_pin.sym} 17280 -26280 0 0 {name=p16796 lab=_84762_/Q }
C {devices/lab_pin.sym} 17280 -26240 0 0 {name=p16797 lab=_66138_/A }
C {devices/lab_pin.sym} 17400 -26260 0 1 {name=p16798 lab=_80472_/A }
C {sky130_stdcells/xor2_4.sym} 17340 -26260 0 0 {name=X_80463_ }
C {devices/lab_pin.sym} 17260 -26160 0 0 {name=p16799 lab=_68155_/X }
C {devices/lab_pin.sym} 17260 -26120 0 0 {name=p16800 lab=_67151_/Y }
C {devices/lab_pin.sym} 17260 -26080 0 0 {name=p16801 lab=_68168_/X }
C {devices/lab_pin.sym} 17260 -26040 0 0 {name=p16802 lab=_68184_/Y }
C {devices/lab_pin.sym} 17420 -26100 0 1 {name=p16803 lab=_68185_/X }
C {sky130_stdcells/a211o_4.sym} 17340 -26100 0 0 {name=X_68185_ }
C {devices/lab_pin.sym} 17280 -25970 0 0 {name=p16804 lab=_65397_/A }
C {devices/lab_pin.sym} 17280 -25930 0 0 {name=p16805 lab=_65397_/B }
C {devices/lab_pin.sym} 17280 -25890 0 0 {name=p16806 lab=_65397_/C }
C {devices/lab_pin.sym} 17400 -25930 0 1 {name=p16807 lab=_65397_/Y }
C {sky130_stdcells/nor3_4.sym} 17340 -25930 0 0 {name=X_65397_ }
C {devices/lab_pin.sym} 17250 -25790 0 0 {name=p16808 lab=_82961_/CLK }
C {devices/lab_pin.sym} 17250 -25770 0 0 {name=p16809 lab=_82202_/D }
C {devices/lab_pin.sym} 17430 -25790 0 1 {name=p16810 lab=_82202_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -25780 0 0 {name=X_82202_ }
C {devices/lab_pin.sym} 17280 -25660 0 0 {name=p16811 lab=_55224_/A }
C {devices/lab_pin.sym} 17280 -25620 0 0 {name=p16812 lab=_85066_/Q }
C {devices/lab_pin.sym} 17400 -25640 0 1 {name=p16813 lab=_55150_/X }
C {sky130_stdcells/and2_4.sym} 17340 -25640 0 0 {name=X_55150_ }
C {devices/lab_pin.sym} 17280 -25520 0 0 {name=p16814 lab=_67087_/A }
C {devices/lab_pin.sym} 17280 -25480 0 0 {name=p16815 lab=_67136_/B }
C {devices/lab_pin.sym} 17400 -25500 0 1 {name=p16816 lab=_67136_/X }
C {sky130_stdcells/and2_4.sym} 17340 -25500 0 0 {name=X_67136_ }
C {devices/lab_pin.sym} 17280 -25380 0 0 {name=p16817 lab=_52349_/A }
C {devices/lab_pin.sym} 17280 -25340 0 0 {name=p16818 lab=_50153_/B }
C {devices/lab_pin.sym} 17400 -25360 0 1 {name=p16819 lab=_52362_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -25360 0 0 {name=X_52362_ }
C {devices/lab_pin.sym} 17260 -25270 0 0 {name=p16820 lab=_64342_/X }
C {devices/lab_pin.sym} 17260 -25230 0 0 {name=p16821 lab=_64343_/X }
C {devices/lab_pin.sym} 17260 -25190 0 0 {name=p16822 lab=_64345_/X }
C {devices/lab_pin.sym} 17260 -25150 0 0 {name=p16823 lab=_64347_/Y }
C {devices/lab_pin.sym} 17260 -25110 0 0 {name=p16824 lab=_64326_/X }
C {devices/lab_pin.sym} 17420 -25190 0 1 {name=p16825 lab=_64348_/X }
C {sky130_stdcells/o41a_4.sym} 17340 -25190 0 0 {name=X_64348_ }
C {devices/lab_pin.sym} 17250 -25030 0 0 {name=p16826 lab=_81696_/CLK }
C {devices/lab_pin.sym} 17250 -25010 0 0 {name=p16827 lab=_83182_/D }
C {devices/lab_pin.sym} 17430 -25030 0 1 {name=p16828 lab=_83182_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -25020 0 0 {name=X_83182_ }
C {devices/lab_pin.sym} 17280 -24900 0 0 {name=p16829 lab=_80394_/A }
C {devices/lab_pin.sym} 17280 -24860 0 0 {name=p16830 lab=_80394_/B }
C {devices/lab_pin.sym} 17400 -24880 0 1 {name=p16831 lab=_80394_/X }
C {sky130_stdcells/or2_4.sym} 17340 -24880 0 0 {name=X_80394_ }
C {devices/lab_pin.sym} 17260 -24770 0 0 {name=p16832 lab=_54098_/Y }
C {devices/lab_pin.sym} 17260 -24730 0 0 {name=p16833 lab=_53437_/X }
C {devices/lab_pin.sym} 17260 -24690 0 0 {name=p16834 lab=_54100_/X }
C {devices/lab_pin.sym} 17420 -24730 0 1 {name=p16835 lab=_85504_/D }
C {sky130_stdcells/a21oi_4.sym} 17340 -24730 0 0 {name=X_54101_ }
C {devices/lab_pin.sym} 17300 -24590 0 0 {name=p16836 lab=_51263_/A }
C {devices/lab_pin.sym} 17380 -24590 0 1 {name=p16837 lab=_51313_/X }
C {sky130_stdcells/buf_2.sym} 17340 -24590 0 0 {name=X_51313_ }
C {devices/lab_pin.sym} 17250 -24470 0 0 {name=p16838 lab=_82133_/CLK }
C {devices/lab_pin.sym} 17250 -24450 0 0 {name=p16839 lab=_82133_/D }
C {devices/lab_pin.sym} 17430 -24470 0 1 {name=p16840 lab=_82089_/D }
C {sky130_stdcells/dfxtp_4.sym} 17340 -24460 0 0 {name=X_82133_ }
C {devices/lab_pin.sym} 17260 -24350 0 0 {name=p16841 lab=_85322_/Q }
C {devices/lab_pin.sym} 17260 -24310 0 0 {name=p16842 lab=_55072_/X }
C {devices/lab_pin.sym} 17260 -24270 0 0 {name=p16843 lab=_55080_/Y }
C {devices/lab_pin.sym} 17420 -24310 0 1 {name=p16844 lab=_55081_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -24310 0 0 {name=X_55081_ }
C {devices/lab_pin.sym} 17260 -24200 0 0 {name=p16845 lab=_66899_/X }
C {devices/lab_pin.sym} 17260 -24160 0 0 {name=p16846 lab=_67054_/Y }
C {devices/lab_pin.sym} 17260 -24120 0 0 {name=p16847 lab=_67031_/X }
C {devices/lab_pin.sym} 17260 -24080 0 0 {name=p16848 lab=_67066_/Y }
C {devices/lab_pin.sym} 17420 -24140 0 1 {name=p16849 lab=_67067_/X }
C {sky130_stdcells/a211o_4.sym} 17340 -24140 0 0 {name=X_67067_ }
C {devices/lab_pin.sym} 17280 -24000 0 0 {name=p16850 lab=_52293_/A }
C {devices/lab_pin.sym} 17280 -23960 0 0 {name=p16851 lab=_48944_/B }
C {devices/lab_pin.sym} 17400 -23980 0 1 {name=p16852 lab=_52293_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -23980 0 0 {name=X_52293_ }
C {devices/lab_pin.sym} 17260 -23890 0 0 {name=p16853 lab=_64273_/X }
C {devices/lab_pin.sym} 17260 -23850 0 0 {name=p16854 lab=_64275_/X }
C {devices/lab_pin.sym} 17260 -23810 0 0 {name=p16855 lab=_64276_/X }
C {devices/lab_pin.sym} 17260 -23770 0 0 {name=p16856 lab=_64278_/Y }
C {devices/lab_pin.sym} 17260 -23730 0 0 {name=p16857 lab=_64267_/X }
C {devices/lab_pin.sym} 17420 -23810 0 1 {name=p16858 lab=_64279_/X }
C {sky130_stdcells/o41a_4.sym} 17340 -23810 0 0 {name=X_64279_ }
C {devices/lab_pin.sym} 17250 -23650 0 0 {name=p16859 lab=_87990_/CLK }
C {devices/lab_pin.sym} 17250 -23630 0 0 {name=p16860 lab=_42187_/X }
C {devices/lab_pin.sym} 17430 -23650 0 1 {name=p16861 lab=_87990_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -23640 0 0 {name=X_87990_ }
C {devices/lab_pin.sym} 17260 -23530 0 0 {name=p16862 lab=_54029_/Y }
C {devices/lab_pin.sym} 17260 -23490 0 0 {name=p16863 lab=_54006_/X }
C {devices/lab_pin.sym} 17260 -23450 0 0 {name=p16864 lab=_54031_/Y }
C {devices/lab_pin.sym} 17420 -23490 0 1 {name=p16865 lab=_54032_/Y }
C {sky130_stdcells/a21boi_4.sym} 17340 -23490 0 0 {name=X_54032_ }
C {devices/lab_pin.sym} 17260 -23370 0 0 {name=p16866 lab=_66015_/Y }
C {devices/lab_pin.sym} 17260 -23330 0 0 {name=p16867 lab=_65987_/X }
C {devices/lab_pin.sym} 17260 -23290 0 0 {name=p16868 lab=_66017_/Y }
C {devices/lab_pin.sym} 17420 -23330 0 1 {name=p16869 lab=_84162_/D }
C {sky130_stdcells/a21o_4.sym} 17340 -23330 0 0 {name=X_66018_ }
C {devices/lab_pin.sym} 17280 -23200 0 0 {name=p16870 lab=_51240_/A }
C {devices/lab_pin.sym} 17280 -23160 0 0 {name=p16871 lab=_50738_/B }
C {devices/lab_pin.sym} 17400 -23180 0 1 {name=p16872 lab=_51244_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -23180 0 0 {name=X_51244_ }
C {devices/lab_pin.sym} 17250 -23050 0 0 {name=p16873 lab=_86941_/CLK }
C {devices/lab_pin.sym} 17250 -23030 0 0 {name=p16874 lab=_86941_/D }
C {devices/lab_pin.sym} 17430 -23050 0 1 {name=p16875 lab=_67381_/B }
C {sky130_stdcells/dfxtp_4.sym} 17340 -23040 0 0 {name=X_86941_ }
C {devices/lab_pin.sym} 17250 -22910 0 0 {name=p16876 lab=_80928_/CLK }
C {devices/lab_pin.sym} 17250 -22890 0 0 {name=p16877 lab=_84024_/Q }
C {devices/lab_pin.sym} 17430 -22910 0 1 {name=p16878 lab=_77851_/A }
C {sky130_stdcells/dfxtp_4.sym} 17340 -22900 0 0 {name=X_82064_ }
C {devices/lab_pin.sym} 17250 -22770 0 0 {name=p16879 lab=_84150_/CLK }
C {devices/lab_pin.sym} 17250 -22750 0 0 {name=p16880 lab=_84223_/Q }
C {devices/lab_pin.sym} 17430 -22770 0 1 {name=p16881 lab=_81015_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -22760 0 0 {name=X_81015_ }
C {devices/lab_pin.sym} 17260 -22650 0 0 {name=p16882 lab=_58787_/X }
C {devices/lab_pin.sym} 17260 -22610 0 0 {name=p16883 lab=_86092_/Q }
C {devices/lab_pin.sym} 17260 -22570 0 0 {name=p16884 lab=_58839_/X }
C {devices/lab_pin.sym} 17420 -22610 0 1 {name=p16885 lab=_58840_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -22610 0 0 {name=X_58840_ }
C {devices/lab_pin.sym} 17300 -22470 0 0 {name=p16886 lab=_51147_/A }
C {devices/lab_pin.sym} 17380 -22470 0 1 {name=p16887 lab=_51175_/X }
C {sky130_stdcells/buf_2.sym} 17340 -22470 0 0 {name=X_51175_ }
C {devices/lab_pin.sym} 17250 -22350 0 0 {name=p16888 lab=_84418_/CLK }
C {devices/lab_pin.sym} 17250 -22330 0 0 {name=p16889 lab=_45514_/Y }
C {devices/lab_pin.sym} 17430 -22350 0 1 {name=p16890 lab=_63089_/B }
C {sky130_stdcells/dfxtp_4.sym} 17340 -22340 0 0 {name=X_86872_ }
C {devices/lab_pin.sym} 17280 -22220 0 0 {name=p16891 lab=_50106_/A }
C {devices/lab_pin.sym} 17280 -22180 0 0 {name=p16892 lab=_53854_/B }
C {devices/lab_pin.sym} 17400 -22200 0 1 {name=p16893 lab=_50126_/X }
C {sky130_stdcells/and2_4.sym} 17340 -22200 0 0 {name=X_50126_ }
C {devices/lab_pin.sym} 17300 -22070 0 0 {name=p16894 lab=clkbuf_9_325_0_CLK/X }
C {devices/lab_pin.sym} 17380 -22070 0 1 {name=p16895 lab=_88224_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 17340 -22070 0 0 {name=Xclkbuf_10_651_0_CLK }
C {devices/lab_pin.sym} 17250 -21950 0 0 {name=p16896 lab=_85535_/CLK }
C {devices/lab_pin.sym} 17250 -21930 0 0 {name=p16897 lab=_85823_/D }
C {devices/lab_pin.sym} 17430 -21950 0 1 {name=p16898 lab=_85823_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -21940 0 0 {name=X_85823_ }
C {devices/lab_pin.sym} 17260 -21830 0 0 {name=p16899 lab=_58740_/X }
C {devices/lab_pin.sym} 17260 -21790 0 0 {name=p16900 lab=_85457_/Q }
C {devices/lab_pin.sym} 17260 -21750 0 0 {name=p16901 lab=_58770_/X }
C {devices/lab_pin.sym} 17420 -21790 0 1 {name=p16902 lab=_58771_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -21790 0 0 {name=X_58771_ }
C {devices/lab_pin.sym} 17260 -21670 0 0 {name=p16903 lab=_67966_/X }
C {devices/lab_pin.sym} 17260 -21630 0 0 {name=p16904 lab=_67968_/X }
C {devices/lab_pin.sym} 17260 -21590 0 0 {name=p16905 lab=_67875_/X }
C {devices/lab_pin.sym} 17420 -21630 0 1 {name=p16906 lab=_67969_/Y }
C {sky130_stdcells/a21oi_4.sym} 17340 -21630 0 0 {name=X_67969_ }
C {devices/lab_pin.sym} 17280 -21500 0 0 {name=p16907 lab=_55983_/A }
C {devices/lab_pin.sym} 17280 -21460 0 0 {name=p16908 lab=_55983_/B }
C {devices/lab_pin.sym} 17400 -21480 0 1 {name=p16909 lab=_55984_/A }
C {sky130_stdcells/and2_4.sym} 17340 -21480 0 0 {name=X_55983_ }
C {devices/lab_pin.sym} 17280 -21360 0 0 {name=p16910 lab=_57722_/A }
C {devices/lab_pin.sym} 17280 -21320 0 0 {name=p16911 lab=_57697_/X }
C {devices/lab_pin.sym} 17400 -21340 0 1 {name=p16912 lab=_57722_/Y }
C {sky130_stdcells/nor2_4.sym} 17340 -21340 0 0 {name=X_57722_ }
C {devices/lab_pin.sym} 17280 -21220 0 0 {name=p16913 lab=_69685_/A }
C {devices/lab_pin.sym} 17280 -21180 0 0 {name=p16914 lab=_73056_/A }
C {devices/lab_pin.sym} 17400 -21200 0 1 {name=p16915 lab=_69708_/X }
C {sky130_stdcells/and2_4.sym} 17340 -21200 0 0 {name=X_69708_ }
C {devices/lab_pin.sym} 17300 -21070 0 0 {name=p16916 lab=clkbuf_8_71_0_CLK/X }
C {devices/lab_pin.sym} 17380 -21070 0 1 {name=p16917 lab=clkbuf_9_142_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 17340 -21070 0 0 {name=Xclkbuf_9_142_0_CLK }
C {devices/lab_pin.sym} 17260 -20970 0 0 {name=p16918 lab=_64627_/B }
C {devices/lab_pin.sym} 17260 -20930 0 0 {name=p16919 lab=_48861_/X }
C {devices/lab_pin.sym} 17260 -20890 0 0 {name=p16920 lab=_50056_/Y }
C {devices/lab_pin.sym} 17420 -20930 0 1 {name=p16921 lab=_50057_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -20930 0 0 {name=X_50057_ }
C {devices/lab_pin.sym} 17280 -20800 0 0 {name=p16922 lab=_54919_/X }
C {devices/lab_pin.sym} 17280 -20760 0 0 {name=p16923 lab=_47780_/A }
C {devices/lab_pin.sym} 17400 -20780 0 1 {name=p16924 lab=_54934_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -20780 0 0 {name=X_54934_ }
C {devices/lab_pin.sym} 17250 -20650 0 0 {name=p16925 lab=_85754_/CLK }
C {devices/lab_pin.sym} 17250 -20630 0 0 {name=p16926 lab=_52791_/Y }
C {devices/lab_pin.sym} 17430 -20650 0 1 {name=p16927 lab=_85754_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -20640 0 0 {name=X_85754_ }
C {devices/lab_pin.sym} 17260 -20530 0 0 {name=p16928 lab=_50799_/B }
C {devices/lab_pin.sym} 17260 -20490 0 0 {name=p16929 lab=_70961_/A }
C {devices/lab_pin.sym} 17260 -20450 0 0 {name=p16930 lab=_70979_/Y }
C {devices/lab_pin.sym} 17420 -20490 0 1 {name=p16931 lab=_83642_/D }
C {sky130_stdcells/o21ai_4.sym} 17340 -20490 0 0 {name=X_70980_ }
C {devices/lab_pin.sym} 17250 -20350 0 0 {name=p16932 lab=_82965_/CLK }
C {devices/lab_pin.sym} 17250 -20330 0 0 {name=p16933 lab=_82966_/D }
C {devices/lab_pin.sym} 17430 -20350 0 1 {name=p16934 lab=_46727_/A }
C {sky130_stdcells/dfxtp_4.sym} 17340 -20340 0 0 {name=X_82966_ }
C {devices/lab_pin.sym} 17250 -20210 0 0 {name=p16935 lab=_84329_/CLK }
C {devices/lab_pin.sym} 17250 -20190 0 0 {name=p16936 lab=_59748_/Y }
C {devices/lab_pin.sym} 17430 -20210 0 1 {name=p16937 lab=_80539_/A }
C {sky130_stdcells/dfxtp_4.sym} 17340 -20200 0 0 {name=X_84705_ }
C {devices/lab_pin.sym} 17280 -20080 0 0 {name=p16938 lab=_57652_/X }
C {devices/lab_pin.sym} 17280 -20040 0 0 {name=p16939 lab=_57657_/B }
C {devices/lab_pin.sym} 17400 -20060 0 1 {name=p16940 lab=_57653_/Y }
C {sky130_stdcells/nor2_4.sym} 17340 -20060 0 0 {name=X_57653_ }
C {devices/lab_pin.sym} 17250 -19930 0 0 {name=p16941 lab=_82008_/CLK }
C {devices/lab_pin.sym} 17250 -19910 0 0 {name=p16942 lab=_77650_/Y }
C {devices/lab_pin.sym} 17430 -19930 0 1 {name=p16943 lab=_82293_/D }
C {sky130_stdcells/dfxtp_4.sym} 17340 -19920 0 0 {name=X_81917_ }
C {devices/lab_pin.sym} 17260 -19820 0 0 {name=p16944 lab=_87066_/Q }
C {devices/lab_pin.sym} 17260 -19780 0 0 {name=p16945 lab=_66550_/X }
C {devices/lab_pin.sym} 17260 -19740 0 0 {name=p16946 lab=_66552_/X }
C {devices/lab_pin.sym} 17260 -19700 0 0 {name=p16947 lab=_69638_/X }
C {devices/lab_pin.sym} 17420 -19760 0 1 {name=p16948 lab=_69639_/X }
C {sky130_stdcells/a211o_4.sym} 17340 -19760 0 0 {name=X_69639_ }
C {devices/lab_pin.sym} 17300 -19610 0 0 {name=p16949 lab=_54892_/A }
C {devices/lab_pin.sym} 17380 -19610 0 1 {name=p16950 lab=_54865_/X }
C {sky130_stdcells/buf_2.sym} 17340 -19610 0 0 {name=X_54865_ }
C {devices/lab_pin.sym} 17250 -19490 0 0 {name=p16951 lab=_84787_/CLK }
C {devices/lab_pin.sym} 17250 -19470 0 0 {name=p16952 lab=_53166_/Y }
C {devices/lab_pin.sym} 17430 -19490 0 1 {name=p16953 lab=_85685_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -19480 0 0 {name=X_85685_ }
C {devices/lab_pin.sym} 17250 -19350 0 0 {name=p16954 lab=_82896_/CLK }
C {devices/lab_pin.sym} 17250 -19330 0 0 {name=p16955 lab=_78189_/B }
C {devices/lab_pin.sym} 17430 -19350 0 1 {name=p16956 lab=_82897_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -19340 0 0 {name=X_82897_ }
C {devices/lab_pin.sym} 17300 -19210 0 0 {name=p16957 lab=clkbuf_9_333_0_CLK/X }
C {devices/lab_pin.sym} 17380 -19210 0 1 {name=p16958 lab=_88208_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 17340 -19210 0 0 {name=Xclkbuf_10_666_0_CLK }
C {devices/lab_pin.sym} 17280 -19110 0 0 {name=p16959 lab=_56602_/X }
C {devices/lab_pin.sym} 17280 -19070 0 0 {name=p16960 lab=_56604_/B }
C {devices/lab_pin.sym} 17280 -19030 0 0 {name=p16961 lab=_56696_/B }
C {devices/lab_pin.sym} 17400 -19070 0 1 {name=p16962 lab=_56604_/Y }
C {sky130_stdcells/nor3_4.sym} 17340 -19070 0 0 {name=X_56604_ }
C {devices/lab_pin.sym} 17250 -18930 0 0 {name=p16963 lab=_86814_/CLK }
C {devices/lab_pin.sym} 17250 -18910 0 0 {name=p16964 lab=_87424_/D }
C {devices/lab_pin.sym} 17430 -18930 0 1 {name=p16965 lab=_87424_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -18920 0 0 {name=X_87424_ }
C {devices/lab_pin.sym} 17300 -18790 0 0 {name=p16966 lab=_53846_/A }
C {devices/lab_pin.sym} 17380 -18790 0 1 {name=p16967 lab=_53816_/X }
C {sky130_stdcells/buf_2.sym} 17340 -18790 0 0 {name=X_53816_ }
C {devices/lab_pin.sym} 17260 -18710 0 0 {name=p16968 lab=_41824_/X }
C {devices/lab_pin.sym} 17260 -18670 0 0 {name=p16969 lab=_41825_/X }
C {devices/lab_pin.sym} 17260 -18630 0 0 {name=p16970 lab=_40459_/X }
C {devices/lab_pin.sym} 17260 -18590 0 0 {name=p16971 lab=_88132_/Q }
C {devices/lab_pin.sym} 17260 -18550 0 0 {name=p16972 lab=_41821_/X }
C {devices/lab_pin.sym} 17420 -18630 0 1 {name=p16973 lab=_41830_/Y }
C {sky130_stdcells/o32ai_4.sym} 17340 -18630 0 0 {name=X_41830_ }
C {devices/lab_pin.sym} 17280 -18490 0 0 {name=p16974 lab=_72656_/A }
C {devices/lab_pin.sym} 17280 -18450 0 0 {name=p16975 lab=_72656_/B }
C {devices/lab_pin.sym} 17280 -18410 0 0 {name=p16976 lab=_56597_/X }
C {devices/lab_pin.sym} 17400 -18450 0 1 {name=p16977 lab=_72650_/Y }
C {sky130_stdcells/nand3_4.sym} 17340 -18450 0 0 {name=X_72650_ }
C {devices/lab_pin.sym} 17250 -18310 0 0 {name=p16978 lab=_83216_/CLK }
C {devices/lab_pin.sym} 17250 -18290 0 0 {name=p16979 lab=_60316_/Y }
C {devices/lab_pin.sym} 17430 -18310 0 1 {name=p16980 lab=_79742_/A }
C {sky130_stdcells/dfxtp_4.sym} 17340 -18300 0 0 {name=X_84636_ }
C {devices/lab_pin.sym} 17280 -18180 0 0 {name=p16981 lab=_57564_/X }
C {devices/lab_pin.sym} 17280 -18140 0 0 {name=p16982 lab=_53552_/B }
C {devices/lab_pin.sym} 17400 -18160 0 1 {name=p16983 lab=_57584_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -18160 0 0 {name=X_57584_ }
C {devices/lab_pin.sym} 17250 -18030 0 0 {name=p16984 lab=_81928_/CLK }
C {devices/lab_pin.sym} 17250 -18010 0 0 {name=p16985 lab=_81880_/Q }
C {devices/lab_pin.sym} 17430 -18030 0 1 {name=p16986 lab=_77551_/A }
C {sky130_stdcells/dfxtp_4.sym} 17340 -18020 0 0 {name=X_81848_ }
C {devices/lab_pin.sym} 17280 -17900 0 0 {name=p16987 lab=_54790_/A }
C {devices/lab_pin.sym} 17280 -17860 0 0 {name=p16988 lab=_47536_/A }
C {devices/lab_pin.sym} 17400 -17880 0 1 {name=p16989 lab=_54796_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -17880 0 0 {name=X_54796_ }
C {devices/lab_pin.sym} 17260 -17770 0 0 {name=p16990 lab=_71581_/A }
C {devices/lab_pin.sym} 17260 -17730 0 0 {name=p16991 lab=_83442_/Q }
C {devices/lab_pin.sym} 17260 -17690 0 0 {name=p16992 lab=_71600_/Y }
C {devices/lab_pin.sym} 17420 -17730 0 1 {name=p16993 lab=_71601_/X }
C {sky130_stdcells/a21o_4.sym} 17340 -17730 0 0 {name=X_71601_ }
C {devices/lab_pin.sym} 17260 -17610 0 0 {name=p16994 lab=_59320_/Y }
C {devices/lab_pin.sym} 17260 -17570 0 0 {name=p16995 lab=_59322_/Y }
C {devices/lab_pin.sym} 17260 -17530 0 0 {name=p16996 lab=_59278_/X }
C {devices/lab_pin.sym} 17420 -17570 0 1 {name=p16997 lab=_59323_/X }
C {sky130_stdcells/a21o_4.sym} 17340 -17570 0 0 {name=X_59323_ }
C {devices/lab_pin.sym} 17300 -17430 0 0 {name=p16998 lab=clkbuf_8_78_0_CLK/X }
C {devices/lab_pin.sym} 17380 -17430 0 1 {name=p16999 lab=clkbuf_9_157_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 17340 -17430 0 0 {name=Xclkbuf_9_157_0_CLK }
C {devices/lab_pin.sym} 17300 -17310 0 0 {name=p17000 lab=_46187_/A }
C {devices/lab_pin.sym} 17380 -17310 0 1 {name=p17001 lab=_56535_/X }
C {sky130_stdcells/buf_2.sym} 17340 -17310 0 0 {name=X_56535_ }
C {devices/lab_pin.sym} 17260 -17210 0 0 {name=p17002 lab=_41603_/X }
C {devices/lab_pin.sym} 17260 -17170 0 0 {name=p17003 lab=_82888_/Q }
C {devices/lab_pin.sym} 17260 -17130 0 0 {name=p17004 lab=_41760_/X }
C {devices/lab_pin.sym} 17420 -17170 0 1 {name=p17005 lab=_41761_/X }
C {sky130_stdcells/o21a_4.sym} 17340 -17170 0 0 {name=X_41761_ }
C {devices/lab_pin.sym} 17250 -17030 0 0 {name=p17006 lab=_81182_/CLK }
C {devices/lab_pin.sym} 17250 -17010 0 0 {name=p17007 lab=_87355_/D }
C {devices/lab_pin.sym} 17430 -17030 0 1 {name=p17008 lab=_87355_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -17020 0 0 {name=X_87355_ }
C {devices/lab_pin.sym} 17300 -16890 0 0 {name=p17009 lab=clkbuf_2_0_2_CLK/A }
C {devices/lab_pin.sym} 17380 -16890 0 1 {name=p17010 lab=clkbuf_2_0_2_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 17340 -16890 0 0 {name=Xclkbuf_2_0_2_CLK }
C {devices/lab_pin.sym} 17300 -16770 0 0 {name=p17011 lab=_53747_/A }
C {devices/lab_pin.sym} 17380 -16770 0 1 {name=p17012 lab=_53747_/X }
C {sky130_stdcells/buf_2.sym} 17340 -16770 0 0 {name=X_53747_ }
C {devices/lab_pin.sym} 17280 -16670 0 0 {name=p17013 lab=_72581_/A }
C {devices/lab_pin.sym} 17280 -16630 0 0 {name=p17014 lab=_72573_/B }
C {devices/lab_pin.sym} 17280 -16590 0 0 {name=p17015 lab=_79372_/B }
C {devices/lab_pin.sym} 17400 -16630 0 1 {name=p17016 lab=_72581_/Y }
C {sky130_stdcells/nor3_4.sym} 17340 -16630 0 0 {name=X_72581_ }
C {devices/lab_pin.sym} 17300 -16490 0 0 {name=p17017 lab=clkbuf_8_42_0_CLK/X }
C {devices/lab_pin.sym} 17380 -16490 0 1 {name=p17018 lab=clkbuf_9_84_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 17340 -16490 0 0 {name=Xclkbuf_9_84_0_CLK }
C {devices/lab_pin.sym} 17250 -16370 0 0 {name=p17019 lab=_84562_/CLK }
C {devices/lab_pin.sym} 17250 -16350 0 0 {name=p17020 lab=_84567_/D }
C {devices/lab_pin.sym} 17430 -16370 0 1 {name=p17021 lab=_60789_/C }
C {sky130_stdcells/dfxtp_4.sym} 17340 -16360 0 0 {name=X_84567_ }
C {devices/lab_pin.sym} 17280 -16260 0 0 {name=p17022 lab=_50963_/A }
C {devices/lab_pin.sym} 17280 -16220 0 0 {name=p17023 lab=_50963_/B }
C {devices/lab_pin.sym} 17280 -16180 0 0 {name=p17024 lab=_50963_/C }
C {devices/lab_pin.sym} 17280 -16140 0 0 {name=p17025 lab=_46744_/X }
C {devices/lab_pin.sym} 17400 -16200 0 1 {name=p17026 lab=_50959_/X }
C {sky130_stdcells/and4_4.sym} 17340 -16200 0 0 {name=X_50959_ }
C {devices/lab_pin.sym} 17250 -16050 0 0 {name=p17027 lab=_88121_/CLK }
C {devices/lab_pin.sym} 17250 -16030 0 0 {name=p17028 lab=_76100_/X }
C {devices/lab_pin.sym} 17430 -16050 0 1 {name=p17029 lab=_81779_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -16040 0 0 {name=X_81779_ }
C {devices/lab_pin.sym} 17260 -15940 0 0 {name=p17030 lab=_41741_/X }
C {devices/lab_pin.sym} 17260 -15900 0 0 {name=p17031 lab=_43498_/X }
C {devices/lab_pin.sym} 17260 -15860 0 0 {name=p17032 lab=_87390_/Q }
C {devices/lab_pin.sym} 17260 -15820 0 0 {name=p17033 lab=_43499_/X }
C {devices/lab_pin.sym} 17420 -15880 0 1 {name=p17034 lab=_87390_/D }
C {sky130_stdcells/a2bb2o_4.sym} 17340 -15880 0 0 {name=X_43500_ }
C {devices/lab_pin.sym} 17260 -15750 0 0 {name=p17035 lab=_70304_/C }
C {devices/lab_pin.sym} 17260 -15710 0 0 {name=p17036 lab=_74314_/X }
C {devices/lab_pin.sym} 17260 -15670 0 0 {name=p17037 lab=_74319_/Y }
C {devices/lab_pin.sym} 17420 -15710 0 1 {name=p17038 lab=_83100_/D }
C {sky130_stdcells/a21bo_4.sym} 17340 -15710 0 0 {name=X_74320_ }
C {devices/lab_pin.sym} 17250 -15570 0 0 {name=p17039 lab=_86303_/CLK }
C {devices/lab_pin.sym} 17250 -15550 0 0 {name=p17040 lab=_49885_/Y }
C {devices/lab_pin.sym} 17430 -15570 0 1 {name=p17041 lab=_58135_/B }
C {sky130_stdcells/dfxtp_4.sym} 17340 -15560 0 0 {name=X_86306_ }
C {devices/lab_pin.sym} 17300 -15430 0 0 {name=p17042 lab=_40712_/A }
C {devices/lab_pin.sym} 17380 -15430 0 1 {name=p17043 lab=_40712_/X }
C {sky130_stdcells/buf_2.sym} 17340 -15430 0 0 {name=X_40712_ }
C {devices/lab_pin.sym} 17300 -15310 0 0 {name=p17044 lab=_58697_/A }
C {devices/lab_pin.sym} 17380 -15310 0 1 {name=p17045 lab=_59255_/A }
C {sky130_stdcells/buf_2.sym} 17340 -15310 0 0 {name=X_59254_ }
C {devices/lab_pin.sym} 17300 -15190 0 0 {name=p17046 lab=_71527_/Y }
C {devices/lab_pin.sym} 17380 -15190 0 1 {name=p17047 lab=_71602_/C }
C {sky130_stdcells/buf_2.sym} 17340 -15190 0 0 {name=X_71532_ }
C {devices/lab_pin.sym} 17250 -15070 0 0 {name=p17048 lab=_83521_/CLK }
C {devices/lab_pin.sym} 17250 -15050 0 0 {name=p17049 lab=_71384_/X }
C {devices/lab_pin.sym} 17430 -15070 0 1 {name=p17050 lab=_83518_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -15060 0 0 {name=X_83518_ }
C {devices/lab_pin.sym} 17260 -14950 0 0 {name=p17051 lab=_56462_/X }
C {devices/lab_pin.sym} 17260 -14910 0 0 {name=p17052 lab=_55987_/X }
C {devices/lab_pin.sym} 17260 -14870 0 0 {name=p17053 lab=_56465_/Y }
C {devices/lab_pin.sym} 17420 -14910 0 1 {name=p17054 lab=_85185_/D }
C {sky130_stdcells/o21ai_4.sym} 17340 -14910 0 0 {name=X_56466_ }
C {devices/lab_pin.sym} 17260 -14800 0 0 {name=p17055 lab=_41203_/A }
C {devices/lab_pin.sym} 17260 -14760 0 0 {name=p17056 lab=_44474_/X }
C {devices/lab_pin.sym} 17260 -14720 0 0 {name=p17057 lab=_87086_/Q }
C {devices/lab_pin.sym} 17260 -14680 0 0 {name=p17058 lab=_44475_/X }
C {devices/lab_pin.sym} 17420 -14740 0 1 {name=p17059 lab=_44480_/X }
C {sky130_stdcells/a2bb2o_4.sym} 17340 -14740 0 0 {name=X_44480_ }
C {devices/lab_pin.sym} 17250 -14590 0 0 {name=p17060 lab=_87542_/CLK }
C {devices/lab_pin.sym} 17250 -14570 0 0 {name=p17061 lab=_43747_/X }
C {devices/lab_pin.sym} 17430 -14590 0 1 {name=p17062 lab=_73487_/A }
C {sky130_stdcells/dfxtp_4.sym} 17340 -14580 0 0 {name=X_87286_ }
C {devices/lab_pin.sym} 17280 -14460 0 0 {name=p17063 lab=_53662_/X }
C {devices/lab_pin.sym} 17280 -14420 0 0 {name=p17064 lab=_53678_/B }
C {devices/lab_pin.sym} 17400 -14440 0 1 {name=p17065 lab=_53678_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -14440 0 0 {name=X_53678_ }
C {devices/lab_pin.sym} 17260 -14330 0 0 {name=p17066 lab=_41659_/X }
C {devices/lab_pin.sym} 17260 -14290 0 0 {name=p17067 lab=_81750_/Q }
C {devices/lab_pin.sym} 17260 -14250 0 0 {name=p17068 lab=_41691_/X }
C {devices/lab_pin.sym} 17420 -14290 0 1 {name=p17069 lab=_41692_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -14290 0 0 {name=X_41692_ }
C {devices/lab_pin.sym} 17250 -14150 0 0 {name=p17070 lab=_84498_/CLK }
C {devices/lab_pin.sym} 17250 -14130 0 0 {name=p17071 lab=_84498_/D }
C {devices/lab_pin.sym} 17430 -14150 0 1 {name=p17072 lab=_61250_/C }
C {sky130_stdcells/dfxtp_4.sym} 17340 -14140 0 0 {name=X_84498_ }
C {devices/lab_pin.sym} 17300 -14010 0 0 {name=p17073 lab=_64534_/C }
C {devices/lab_pin.sym} 17380 -14010 0 1 {name=p17074 lab=_58207_/A }
C {sky130_stdcells/buf_2.sym} 17340 -14010 0 0 {name=X_58205_ }
C {sky130_stdcells/decap_3.sym} 17340 -13860 0 0 {name=XPHY_310 }
C {devices/lab_pin.sym} 17300 -13710 0 0 {name=p17075 lab=_55417_/A }
C {devices/lab_pin.sym} 17380 -13710 0 1 {name=p17076 lab=_55417_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -13710 0 0 {name=X_55417_ }
C {devices/lab_pin.sym} 17300 -13590 0 0 {name=p17077 lab=_43396_/A }
C {devices/lab_pin.sym} 17380 -13590 0 1 {name=p17078 lab=_43431_/X }
C {sky130_stdcells/buf_2.sym} 17340 -13590 0 0 {name=X_43431_ }
C {devices/lab_pin.sym} 17280 -13480 0 0 {name=p17079 lab=_74038_/A }
C {devices/lab_pin.sym} 17280 -13440 0 0 {name=p17080 lab=_66334_/B }
C {devices/lab_pin.sym} 17400 -13460 0 1 {name=p17081 lab=_74251_/X }
C {sky130_stdcells/and2_4.sym} 17340 -13460 0 0 {name=X_74251_ }
C {devices/lab_pin.sym} 17250 -13330 0 0 {name=p17082 lab=_86237_/CLK }
C {devices/lab_pin.sym} 17250 -13310 0 0 {name=p17083 lab=_50259_/Y }
C {devices/lab_pin.sym} 17430 -13330 0 1 {name=p17084 lab=_86237_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -13320 0 0 {name=X_86237_ }
C {devices/lab_pin.sym} 17300 -13190 0 0 {name=p17085 lab=_40643_/A }
C {devices/lab_pin.sym} 17380 -13190 0 1 {name=p17086 lab=_40643_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -13190 0 0 {name=X_40643_ }
C {sky130_stdcells/decap_3.sym} 17340 -13040 0 0 {name=XPHY_321 }
C {devices/lab_pin.sym} 17300 -12890 0 0 {name=p17087 lab=_52515_/X }
C {devices/lab_pin.sym} 17380 -12890 0 1 {name=p17088 lab=_52629_/X }
C {sky130_stdcells/buf_2.sym} 17340 -12890 0 0 {name=X_52629_ }
C {devices/lab_pin.sym} 17260 -12790 0 0 {name=p17089 lab=_59105_/X }
C {devices/lab_pin.sym} 17260 -12750 0 0 {name=p17090 lab=_85746_/Q }
C {devices/lab_pin.sym} 17260 -12710 0 0 {name=p17091 lab=_59106_/X }
C {devices/lab_pin.sym} 17420 -12750 0 1 {name=p17092 lab=_59185_/X }
C {sky130_stdcells/o21a_4.sym} 17340 -12750 0 0 {name=X_59185_ }
C {devices/lab_pin.sym} 17300 -12610 0 0 {name=p17093 lab=_71463_/A }
C {devices/lab_pin.sym} 17380 -12610 0 1 {name=p17094 lab=_71463_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -12610 0 0 {name=X_71463_ }
C {devices/lab_pin.sym} 17250 -12490 0 0 {name=p17095 lab=_83480_/CLK }
C {devices/lab_pin.sym} 17250 -12470 0 0 {name=p17096 lab=_83449_/D }
C {devices/lab_pin.sym} 17430 -12490 0 1 {name=p17097 lab=_83449_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -12480 0 0 {name=X_83449_ }
C {sky130_stdcells/decap_3.sym} 17340 -12320 0 0 {name=XPHY_332 }
C {devices/lab_pin.sym} 17300 -12170 0 0 {name=p17098 lab=_56435_/A }
C {devices/lab_pin.sym} 17380 -12170 0 1 {name=p17099 lab=_56397_/X }
C {sky130_stdcells/buf_2.sym} 17340 -12170 0 0 {name=X_56397_ }
C {sky130_stdcells/decap_3.sym} 17340 -12020 0 0 {name=XPHY_343 }
C {sky130_stdcells/decap_3.sym} 17340 -11840 0 0 {name=XPHY_354 }
C {devices/lab_pin.sym} 17300 -11690 0 0 {name=p17100 lab=_73704_/A }
C {devices/lab_pin.sym} 17380 -11690 0 1 {name=p17101 lab=_73202_/X }
C {sky130_stdcells/buf_2.sym} 17340 -11690 0 0 {name=X_73202_ }
C {devices/lab_pin.sym} 17280 -11590 0 0 {name=p17102 lab=_46144_/X }
C {devices/lab_pin.sym} 17280 -11550 0 0 {name=p17103 lab=_46150_/B }
C {devices/lab_pin.sym} 17280 -11510 0 0 {name=p17104 lab=_46149_/Y }
C {devices/lab_pin.sym} 17400 -11550 0 1 {name=p17105 lab=_86771_/D }
C {sky130_stdcells/and3_4.sym} 17340 -11550 0 0 {name=X_46150_ }
C {devices/lab_pin.sym} 17280 -11420 0 0 {name=p17106 lab=_58136_/A }
C {devices/lab_pin.sym} 17280 -11380 0 0 {name=p17107 lab=_58136_/B }
C {devices/lab_pin.sym} 17400 -11400 0 1 {name=p17108 lab=_58136_/Y }
C {sky130_stdcells/nor2_4.sym} 17340 -11400 0 0 {name=X_58136_ }
C {devices/lab_pin.sym} 17300 -11270 0 0 {name=p17109 lab=HASH_ADDR[4] }
C {devices/lab_pin.sym} 17380 -11270 0 1 {name=p17110 lab=_70700_/B }
C {sky130_stdcells/buf_2.sym} 17340 -11270 0 0 {name=X_70414_ }
C {sky130_stdcells/decap_3.sym} 17340 -11120 0 0 {name=XPHY_365 }
C {devices/lab_pin.sym} 17260 -11000 0 0 {name=p17111 lab=_41371_/X }
C {devices/lab_pin.sym} 17260 -10960 0 0 {name=p17112 lab=_43356_/X }
C {devices/lab_pin.sym} 17260 -10920 0 0 {name=p17113 lab=_87459_/Q }
C {devices/lab_pin.sym} 17260 -10880 0 0 {name=p17114 lab=_43357_/X }
C {devices/lab_pin.sym} 17420 -10940 0 1 {name=p17115 lab=_43362_/X }
C {sky130_stdcells/a2bb2o_4.sym} 17340 -10940 0 0 {name=X_43362_ }
C {devices/lab_pin.sym} 17300 -10790 0 0 {name=p17116 lab=clkbuf_9_99_0_CLK/A }
C {devices/lab_pin.sym} 17380 -10790 0 1 {name=p17117 lab=clkbuf_9_99_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 17340 -10790 0 0 {name=Xclkbuf_9_99_0_CLK }
C {devices/lab_pin.sym} 17260 -10690 0 0 {name=p17118 lab=_55344_/X }
C {devices/lab_pin.sym} 17260 -10650 0 0 {name=p17119 lab=_55347_/X }
C {devices/lab_pin.sym} 17260 -10610 0 0 {name=p17120 lab=_55309_/X }
C {devices/lab_pin.sym} 17420 -10650 0 1 {name=p17121 lab=_55352_/A }
C {sky130_stdcells/a21o_4.sym} 17340 -10650 0 0 {name=X_55348_ }
C {devices/lab_pin.sym} 17280 -10520 0 0 {name=p17122 lab=_74202_/A }
C {devices/lab_pin.sym} 17280 -10480 0 0 {name=p17123 lab=_74181_/Y }
C {devices/lab_pin.sym} 17400 -10500 0 1 {name=p17124 lab=_74182_/Y }
C {sky130_stdcells/nor2_4.sym} 17340 -10500 0 0 {name=X_74182_ }
C {devices/lab_pin.sym} 17250 -10370 0 0 {name=p17125 lab=_85562_/CLK }
C {devices/lab_pin.sym} 17250 -10350 0 0 {name=p17126 lab=_50611_/Y }
C {devices/lab_pin.sym} 17430 -10370 0 1 {name=p17127 lab=_86168_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -10360 0 0 {name=X_86168_ }
C {devices/lab_pin.sym} 17260 -10270 0 0 {name=p17128 lab=_40550_/X }
C {devices/lab_pin.sym} 17260 -10230 0 0 {name=p17129 lab=_40556_/X }
C {devices/lab_pin.sym} 17260 -10190 0 0 {name=p17130 lab=_40573_/X }
C {devices/lab_pin.sym} 17260 -10150 0 0 {name=p17131 lab=_88370_/Q }
C {devices/lab_pin.sym} 17260 -10110 0 0 {name=p17132 lab=_40568_/X }
C {devices/lab_pin.sym} 17420 -10190 0 1 {name=p17133 lab=_40574_/Y }
C {sky130_stdcells/o32ai_4.sym} 17340 -10190 0 0 {name=X_40574_ }
C {sky130_stdcells/decap_3.sym} 17340 -10000 0 0 {name=XPHY_376 }
C {devices/lab_pin.sym} 17260 -9870 0 0 {name=p17134 lab=_71372_/Y }
C {devices/lab_pin.sym} 17260 -9830 0 0 {name=p17135 lab=_83514_/Q }
C {devices/lab_pin.sym} 17260 -9790 0 0 {name=p17136 lab=_71393_/Y }
C {devices/lab_pin.sym} 17420 -9830 0 1 {name=p17137 lab=_71394_/X }
C {sky130_stdcells/a21o_4.sym} 17340 -9830 0 0 {name=X_71394_ }
C {sky130_stdcells/decap_3.sym} 17340 -9660 0 0 {name=XPHY_387 }
C {devices/lab_pin.sym} 17260 -9530 0 0 {name=p17138 lab=_85268_/Q }
C {devices/lab_pin.sym} 17260 -9490 0 0 {name=p17139 lab=_45073_/X }
C {devices/lab_pin.sym} 17260 -9450 0 0 {name=p17140 lab=_45100_/X }
C {devices/lab_pin.sym} 17420 -9490 0 1 {name=p17141 lab=_45101_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -9490 0 0 {name=X_45101_ }
C {sky130_stdcells/decap_3.sym} 17340 -9320 0 0 {name=XPHY_398 }
C {devices/lab_pin.sym} 17300 -9170 0 0 {name=p17142 lab=clkbuf_9_302_0_CLK/X }
C {devices/lab_pin.sym} 17380 -9170 0 1 {name=p17143 lab=_81975_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 17340 -9170 0 0 {name=Xclkbuf_10_604_0_CLK }
C {devices/lab_pin.sym} 17260 -9090 0 0 {name=p17144 lab=_42307_/X }
C {devices/lab_pin.sym} 17260 -9050 0 0 {name=p17145 lab=_42297_/X }
C {devices/lab_pin.sym} 17260 -9010 0 0 {name=p17146 lab=_41616_/X }
C {devices/lab_pin.sym} 17260 -8970 0 0 {name=p17147 lab=_87926_/Q }
C {devices/lab_pin.sym} 17260 -8930 0 0 {name=p17148 lab=_42298_/X }
C {devices/lab_pin.sym} 17420 -9010 0 1 {name=p17149 lab=_42314_/A }
C {sky130_stdcells/o32ai_4.sym} 17340 -9010 0 0 {name=X_42313_ }
C {devices/lab_pin.sym} 17260 -8880 0 0 {name=p17150 lab=_73062_/X }
C {devices/lab_pin.sym} 17260 -8840 0 0 {name=p17151 lab=_86195_/Q }
C {devices/lab_pin.sym} 17260 -8800 0 0 {name=p17152 lab=_72955_/X }
C {devices/lab_pin.sym} 17260 -8760 0 0 {name=p17153 lab=_73132_/X }
C {devices/lab_pin.sym} 17420 -8820 0 1 {name=p17154 lab=_73133_/X }
C {sky130_stdcells/a211o_4.sym} 17340 -8820 0 0 {name=X_73133_ }
C {devices/lab_pin.sym} 17250 -8670 0 0 {name=p17155 lab=_85152_/CLK }
C {devices/lab_pin.sym} 17250 -8650 0 0 {name=p17156 lab=_85119_/D }
C {devices/lab_pin.sym} 17430 -8670 0 1 {name=p17157 lab=_85119_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -8660 0 0 {name=X_85119_ }
C {devices/lab_pin.sym} 17260 -8550 0 0 {name=p17158 lab=_58043_/X }
C {devices/lab_pin.sym} 17260 -8510 0 0 {name=p17159 lab=_85992_/Q }
C {devices/lab_pin.sym} 17260 -8470 0 0 {name=p17160 lab=_58066_/X }
C {devices/lab_pin.sym} 17420 -8510 0 1 {name=p17161 lab=_58067_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -8510 0 0 {name=X_58067_ }
C {devices/lab_pin.sym} 17260 -8390 0 0 {name=p17162 lab=_70337_/X }
C {devices/lab_pin.sym} 17260 -8350 0 0 {name=p17163 lab=_74769_/A }
C {devices/lab_pin.sym} 17260 -8310 0 0 {name=p17164 lab=_70344_/X }
C {devices/lab_pin.sym} 17420 -8350 0 1 {name=p17165 lab=_70345_/X }
C {sky130_stdcells/a21o_4.sym} 17340 -8350 0 0 {name=X_70345_ }
C {devices/lab_pin.sym} 17260 -8250 0 0 {name=p17166 lab=_46067_/X }
C {devices/lab_pin.sym} 17260 -8210 0 0 {name=p17167 lab=_43046_/A }
C {devices/lab_pin.sym} 17260 -8170 0 0 {name=p17168 lab=_41620_/X }
C {devices/lab_pin.sym} 17260 -8130 0 0 {name=p17169 lab=_67296_/B }
C {devices/lab_pin.sym} 17260 -8090 0 0 {name=p17170 lab=_46068_/X }
C {devices/lab_pin.sym} 17420 -8170 0 1 {name=p17171 lab=_46082_/A }
C {sky130_stdcells/o32ai_4.sym} 17340 -8170 0 0 {name=X_46081_ }
C {devices/lab_pin.sym} 17260 -8040 0 0 {name=p17172 lab=_41179_/X }
C {devices/lab_pin.sym} 17260 -8000 0 0 {name=p17173 lab=_43287_/X }
C {devices/lab_pin.sym} 17260 -7960 0 0 {name=p17174 lab=_87494_/Q }
C {devices/lab_pin.sym} 17260 -7920 0 0 {name=p17175 lab=_43288_/X }
C {devices/lab_pin.sym} 17420 -7980 0 1 {name=p17176 lab=_87494_/D }
C {sky130_stdcells/a2bb2o_4.sym} 17340 -7980 0 0 {name=X_43293_ }
C {devices/lab_pin.sym} 17260 -7860 0 0 {name=p17177 lab=_57058_/B }
C {devices/lab_pin.sym} 17260 -7820 0 0 {name=p17178 lab=_55126_/X }
C {devices/lab_pin.sym} 17260 -7780 0 0 {name=p17179 lab=_55134_/X }
C {devices/lab_pin.sym} 17260 -7740 0 0 {name=p17180 lab=_55278_/Y }
C {devices/lab_pin.sym} 17420 -7800 0 1 {name=p17181 lab=_55279_/X }
C {sky130_stdcells/a211o_4.sym} 17340 -7800 0 0 {name=X_55279_ }
C {devices/lab_pin.sym} 17260 -7680 0 0 {name=p17182 lab=_78976_/Y }
C {devices/lab_pin.sym} 17260 -7640 0 0 {name=p17183 lab=_78978_/B }
C {devices/lab_pin.sym} 17260 -7600 0 0 {name=p17184 lab=_78966_/A }
C {devices/lab_pin.sym} 17260 -7560 0 0 {name=p17185 lab=_82516_/D }
C {devices/lab_pin.sym} 17420 -7620 0 1 {name=p17186 lab=_78990_/X }
C {sky130_stdcells/a2bb2o_4.sym} 17340 -7620 0 0 {name=X_78990_ }
C {devices/lab_pin.sym} 17250 -7470 0 0 {name=p17187 lab=_86100_/CLK }
C {devices/lab_pin.sym} 17250 -7450 0 0 {name=p17188 lab=_50964_/Y }
C {devices/lab_pin.sym} 17430 -7470 0 1 {name=p17189 lab=_86099_/Q }
C {sky130_stdcells/dfxtp_4.sym} 17340 -7460 0 0 {name=X_86099_ }
C {devices/lab_pin.sym} 17300 -7330 0 0 {name=p17190 lab=_83033_/Q }
C {devices/lab_pin.sym} 17380 -7330 0 1 {name=p17191 lab=_74564_/C }
C {sky130_stdcells/inv_2.sym} 17340 -7330 0 0 {name=X_45032_ }
C {devices/lab_pin.sym} 17260 -7250 0 0 {name=p17192 lab=_56782_/X }
C {devices/lab_pin.sym} 17260 -7210 0 0 {name=p17193 lab=_56785_/B }
C {devices/lab_pin.sym} 17260 -7170 0 0 {name=p17194 lab=_56785_/D }
C {devices/lab_pin.sym} 17260 -7130 0 0 {name=p17195 lab=_57024_/D }
C {devices/lab_pin.sym} 17260 -7100 0 0 {name=p17196 lab=_56767_/X }
C {devices/lab_pin.sym} 17420 -7170 0 1 {name=p17197 lab=_57019_/C }
C {sky130_stdcells/a41o_4.sym} 17340 -7170 0 0 {name=X_57018_ }
C {devices/lab_pin.sym} 17300 -7010 0 0 {name=p17198 lab=_42276_/A }
C {devices/lab_pin.sym} 17380 -7010 0 1 {name=p17199 lab=_42244_/X }
C {sky130_stdcells/buf_2.sym} 17340 -7010 0 0 {name=X_42244_ }
C {devices/lab_pin.sym} 17260 -6920 0 0 {name=p17200 lab=_73062_/X }
C {devices/lab_pin.sym} 17260 -6880 0 0 {name=p17201 lab=_86198_/Q }
C {devices/lab_pin.sym} 17260 -6840 0 0 {name=p17202 lab=_72955_/X }
C {devices/lab_pin.sym} 17260 -6800 0 0 {name=p17203 lab=_73063_/X }
C {devices/lab_pin.sym} 17420 -6860 0 1 {name=p17204 lab=_73064_/X }
C {sky130_stdcells/a211o_4.sym} 17340 -6860 0 0 {name=X_73064_ }
C {devices/lab_pin.sym} 17280 -6720 0 0 {name=p17205 lab=_77941_/A }
C {devices/lab_pin.sym} 17280 -6680 0 0 {name=p17206 lab=_77940_/Y }
C {devices/lab_pin.sym} 17400 -6700 0 1 {name=p17207 lab=_77942_/B }
C {sky130_stdcells/xnor2_4.sym} 17340 -6700 0 0 {name=X_77941_ }
C {devices/lab_pin.sym} 17260 -6590 0 0 {name=p17208 lab=_70269_/X }
C {devices/lab_pin.sym} 17260 -6550 0 0 {name=p17209 lab=_74781_/A }
C {devices/lab_pin.sym} 17260 -6510 0 0 {name=p17210 lab=_70275_/X }
C {devices/lab_pin.sym} 17420 -6550 0 1 {name=p17211 lab=_70276_/X }
C {sky130_stdcells/a21o_4.sym} 17340 -6550 0 0 {name=X_70276_ }
C {devices/lab_pin.sym} 17300 -6410 0 0 {name=p17212 lab=clkbuf_9_23_0_CLK/A }
C {devices/lab_pin.sym} 17380 -6410 0 1 {name=p17213 lab=clkbuf_9_22_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 17340 -6410 0 0 {name=Xclkbuf_9_22_0_CLK }
C {devices/lab_pin.sym} 17260 -6310 0 0 {name=p17214 lab=_72013_/Y }
C {devices/lab_pin.sym} 17260 -6270 0 0 {name=p17215 lab=_72009_/X }
C {devices/lab_pin.sym} 17260 -6230 0 0 {name=p17216 lab=_72014_/Y }
C {devices/lab_pin.sym} 17420 -6270 0 1 {name=p17217 lab=_72015_/Y }
C {sky130_stdcells/a21boi_4.sym} 17340 -6270 0 0 {name=X_72015_ }
C {devices/lab_pin.sym} 17260 -6150 0 0 {name=p17218 lab=_49838_/Y }
C {devices/lab_pin.sym} 17260 -6110 0 0 {name=p17219 lab=_49815_/X }
C {devices/lab_pin.sym} 17260 -6070 0 0 {name=p17220 lab=_49839_/X }
C {devices/lab_pin.sym} 17420 -6110 0 1 {name=p17221 lab=_86314_/D }
C {sky130_stdcells/a21oi_4.sym} 17340 -6110 0 0 {name=X_49840_ }
C {devices/lab_pin.sym} 17300 -5970 0 0 {name=p17222 lab=_42175_/A }
C {devices/lab_pin.sym} 17380 -5970 0 1 {name=p17223 lab=_42175_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -5970 0 0 {name=X_42175_ }
C {devices/lab_pin.sym} 17280 -5860 0 0 {name=p17224 lab=_82242_/Q }
C {devices/lab_pin.sym} 17280 -5820 0 0 {name=p17225 lab=_77872_/B }
C {devices/lab_pin.sym} 17400 -5840 0 1 {name=p17226 lab=_77872_/Y }
C {sky130_stdcells/xnor2_4.sym} 17340 -5840 0 0 {name=X_77872_ }
C {devices/lab_pin.sym} 17300 -5710 0 0 {name=p17227 lab=clkbuf_9_309_0_CLK/X }
C {devices/lab_pin.sym} 17380 -5710 0 1 {name=p17228 lab=_82317_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 17340 -5710 0 0 {name=Xclkbuf_10_619_0_CLK }
C {devices/lab_pin.sym} 17280 -5600 0 0 {name=p17229 lab=_79611_/A }
C {devices/lab_pin.sym} 17280 -5560 0 0 {name=p17230 lab=_79611_/B }
C {devices/lab_pin.sym} 17400 -5580 0 1 {name=p17231 lab=_79611_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -5580 0 0 {name=X_79611_ }
C {devices/lab_pin.sym} 17260 -5490 0 0 {name=p17232 lab=_41112_/X }
C {devices/lab_pin.sym} 17260 -5450 0 0 {name=p17233 lab=_41113_/X }
C {devices/lab_pin.sym} 17260 -5410 0 0 {name=p17234 lab=_41125_/X }
C {devices/lab_pin.sym} 17260 -5370 0 0 {name=p17235 lab=_88273_/Q }
C {devices/lab_pin.sym} 17260 -5330 0 0 {name=p17236 lab=_41088_/X }
C {devices/lab_pin.sym} 17420 -5410 0 1 {name=p17237 lab=_41127_/A }
C {sky130_stdcells/o32ai_4.sym} 17340 -5410 0 0 {name=X_41126_ }
C {devices/lab_pin.sym} 17280 -5260 0 0 {name=p17238 lab=_76818_/A }
C {devices/lab_pin.sym} 17280 -5220 0 0 {name=p17239 lab=_76818_/B }
C {devices/lab_pin.sym} 17400 -5240 0 1 {name=p17240 lab=_76823_/X }
C {sky130_stdcells/or2_4.sym} 17340 -5240 0 0 {name=X_76823_ }
C {devices/lab_pin.sym} 17260 -5130 0 0 {name=p17241 lab=_57891_/B }
C {devices/lab_pin.sym} 17260 -5090 0 0 {name=p17242 lab=_49768_/X }
C {devices/lab_pin.sym} 17260 -5050 0 0 {name=p17243 lab=_49770_/Y }
C {devices/lab_pin.sym} 17420 -5090 0 1 {name=p17244 lab=_49771_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -5090 0 0 {name=X_49771_ }
C {devices/lab_pin.sym} 17300 -4950 0 0 {name=p17245 lab=_46983_/A }
C {devices/lab_pin.sym} 17380 -4950 0 1 {name=p17246 lab=_54478_/B }
C {sky130_stdcells/inv_2.sym} 17340 -4950 0 0 {name=X_46983_ }
C {devices/lab_pin.sym} 17300 -4830 0 0 {name=p17247 lab=_84785_/Q }
C {devices/lab_pin.sym} 17380 -4830 0 1 {name=p17248 lab=_58970_/A }
C {sky130_stdcells/inv_2.sym} 17340 -4830 0 0 {name=X_58969_ }
C {devices/lab_pin.sym} 17260 -4730 0 0 {name=p17249 lab=_65455_/B }
C {devices/lab_pin.sym} 17260 -4690 0 0 {name=p17250 lab=_48150_/X }
C {devices/lab_pin.sym} 17260 -4650 0 0 {name=p17251 lab=_48721_/Y }
C {devices/lab_pin.sym} 17420 -4690 0 1 {name=p17252 lab=_48722_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -4690 0 0 {name=X_48722_ }
C {devices/lab_pin.sym} 17300 -4550 0 0 {name=p17253 lab=_79542_/A }
C {devices/lab_pin.sym} 17380 -4550 0 1 {name=p17254 lab=_79542_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -4550 0 0 {name=X_79542_ }
C {devices/lab_pin.sym} 17280 -4450 0 0 {name=p17255 lab=_45890_/X }
C {devices/lab_pin.sym} 17280 -4410 0 0 {name=p17256 lab=_44228_/X }
C {devices/lab_pin.sym} 17280 -4370 0 0 {name=p17257 lab=_45933_/Y }
C {devices/lab_pin.sym} 17400 -4410 0 1 {name=p17258 lab=_45935_/A }
C {sky130_stdcells/and3_4.sym} 17340 -4410 0 0 {name=X_45934_ }
C {devices/lab_pin.sym} 17280 -4280 0 0 {name=p17259 lab=_41057_/A }
C {devices/lab_pin.sym} 17280 -4240 0 0 {name=p17260 lab=_41091_/B }
C {devices/lab_pin.sym} 17400 -4260 0 1 {name=p17261 lab=_41057_/X }
C {sky130_stdcells/or2_4.sym} 17340 -4260 0 0 {name=X_41057_ }
C {devices/lab_pin.sym} 17300 -4130 0 0 {name=p17262 lab=clkbuf_9_37_0_CLK/A }
C {devices/lab_pin.sym} 17380 -4130 0 1 {name=p17263 lab=clkbuf_9_37_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 17340 -4130 0 0 {name=Xclkbuf_9_37_0_CLK }
C {devices/lab_pin.sym} 17300 -4010 0 0 {name=p17264 lab=_81486_/Q }
C {devices/lab_pin.sym} 17380 -4010 0 1 {name=p17265 lab=_76768_/A }
C {sky130_stdcells/inv_2.sym} 17340 -4010 0 0 {name=X_76754_ }
C {devices/lab_pin.sym} 17300 -3890 0 0 {name=p17266 lab=_61980_/A }
C {devices/lab_pin.sym} 17380 -3890 0 1 {name=p17267 lab=_63562_/A }
C {sky130_stdcells/inv_2.sym} 17340 -3890 0 0 {name=X_61980_ }
C {devices/lab_pin.sym} 17260 -3800 0 0 {name=p17268 lab=_43641_/Y }
C {devices/lab_pin.sym} 17260 -3760 0 0 {name=p17269 lab=_73872_/X }
C {devices/lab_pin.sym} 17260 -3720 0 0 {name=p17270 lab=_73894_/X }
C {devices/lab_pin.sym} 17260 -3680 0 0 {name=p17271 lab=_73965_/Y }
C {devices/lab_pin.sym} 17420 -3740 0 1 {name=p17272 lab=_73966_/X }
C {sky130_stdcells/a211o_4.sym} 17340 -3740 0 0 {name=X_73966_ }
C {devices/lab_pin.sym} 17280 -3600 0 0 {name=p17273 lab=_81008_/Q }
C {devices/lab_pin.sym} 17280 -3560 0 0 {name=p17274 lab=_75705_/B }
C {devices/lab_pin.sym} 17400 -3580 0 1 {name=p17275 lab=_80976_/D }
C {sky130_stdcells/xor2_4.sym} 17340 -3580 0 0 {name=X_75705_ }
C {devices/lab_pin.sym} 17300 -3450 0 0 {name=p17276 lab=_48653_/A }
C {devices/lab_pin.sym} 17380 -3450 0 1 {name=p17277 lab=_48654_/A }
C {sky130_stdcells/inv_2.sym} 17340 -3450 0 0 {name=X_48653_ }
C {devices/lab_pin.sym} 17280 -3350 0 0 {name=p17278 lab=_60826_/A }
C {devices/lab_pin.sym} 17280 -3310 0 0 {name=p17279 lab=_60838_/X }
C {devices/lab_pin.sym} 17280 -3270 0 0 {name=p17280 lab=_60931_/C }
C {devices/lab_pin.sym} 17400 -3310 0 1 {name=p17281 lab=_60931_/Y }
C {sky130_stdcells/nor3_4.sym} 17340 -3310 0 0 {name=X_60931_ }
C {devices/lab_pin.sym} 17280 -3180 0 0 {name=p17282 lab=_74389_/B }
C {devices/lab_pin.sym} 17280 -3140 0 0 {name=p17283 lab=_72917_/B }
C {devices/lab_pin.sym} 17400 -3160 0 1 {name=p17284 lab=_72917_/X }
C {sky130_stdcells/xor2_4.sym} 17340 -3160 0 0 {name=X_72917_ }
C {devices/lab_pin.sym} 17280 -3040 0 0 {name=p17285 lab=_84813_/Q }
C {devices/lab_pin.sym} 17280 -3000 0 0 {name=p17286 lab=_84133_/Q }
C {devices/lab_pin.sym} 17400 -3020 0 1 {name=p17287 lab=_79473_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -3020 0 0 {name=X_79473_ }
C {devices/lab_pin.sym} 17260 -2910 0 0 {name=p17288 lab=_45819_/X }
C {devices/lab_pin.sym} 17260 -2870 0 0 {name=p17289 lab=_61685_/A }
C {devices/lab_pin.sym} 17260 -2830 0 0 {name=p17290 lab=_45836_/X }
C {devices/lab_pin.sym} 17420 -2870 0 1 {name=p17291 lab=_45865_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -2870 0 0 {name=X_45865_ }
C {devices/lab_pin.sym} 17280 -2740 0 0 {name=p17292 lab=_76969_/A }
C {devices/lab_pin.sym} 17280 -2700 0 0 {name=p17293 lab=_76686_/A }
C {devices/lab_pin.sym} 17400 -2720 0 1 {name=p17294 lab=_76685_/Y }
C {sky130_stdcells/nand2_4.sym} 17340 -2720 0 0 {name=X_76685_ }
C {devices/lab_pin.sym} 17260 -2610 0 0 {name=p17295 lab=_73893_/X }
C {devices/lab_pin.sym} 17260 -2570 0 0 {name=p17296 lab=_73896_/X }
C {devices/lab_pin.sym} 17260 -2530 0 0 {name=p17297 lab=_73799_/X }
C {devices/lab_pin.sym} 17420 -2570 0 1 {name=p17298 lab=_73913_/B }
C {sky130_stdcells/a21o_4.sym} 17340 -2570 0 0 {name=X_73897_ }
C {devices/lab_pin.sym} 17300 -2430 0 0 {name=p17299 lab=_47792_/A }
C {devices/lab_pin.sym} 17380 -2430 0 1 {name=p17300 lab=_47645_/B }
C {sky130_stdcells/buf_2.sym} 17340 -2430 0 0 {name=X_47604_ }
C {devices/lab_pin.sym} 17280 -2320 0 0 {name=p17301 lab=_78422_/X }
C {devices/lab_pin.sym} 17280 -2280 0 0 {name=p17302 lab=_78423_/Y }
C {devices/lab_pin.sym} 17400 -2300 0 1 {name=p17303 lab=_78450_/C }
C {sky130_stdcells/nand2_4.sym} 17340 -2300 0 0 {name=X_78424_ }
C {devices/lab_pin.sym} 17300 -2170 0 0 {name=p17304 lab=_44816_/A }
C {devices/lab_pin.sym} 17380 -2170 0 1 {name=p17305 lab=_44816_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -2170 0 0 {name=X_44816_ }
C {devices/lab_pin.sym} 17300 -2050 0 0 {name=p17306 lab=_80906_/Q }
C {devices/lab_pin.sym} 17380 -2050 0 1 {name=p17307 lab=_75638_/A }
C {sky130_stdcells/inv_2.sym} 17340 -2050 0 0 {name=X_75636_ }
C {devices/lab_pin.sym} 17260 -1970 0 0 {name=p17308 lab=_58970_/A }
C {devices/lab_pin.sym} 17260 -1930 0 0 {name=p17309 lab=_60667_/A }
C {devices/lab_pin.sym} 17260 -1890 0 0 {name=p17310 lab=_60724_/A }
C {devices/lab_pin.sym} 17260 -1850 0 0 {name=p17311 lab=_62557_/Y }
C {devices/lab_pin.sym} 17260 -1810 0 0 {name=p17312 lab=_60671_/B }
C {devices/lab_pin.sym} 17420 -1890 0 1 {name=p17313 lab=_63650_/Y }
C {sky130_stdcells/o32ai_4.sym} 17340 -1890 0 0 {name=X_63650_ }
C {devices/lab_pin.sym} 17260 -1750 0 0 {name=p17314 lab=_86509_/Q }
C {devices/lab_pin.sym} 17260 -1710 0 0 {name=p17315 lab=_48536_/X }
C {devices/lab_pin.sym} 17260 -1670 0 0 {name=p17316 lab=_48583_/Y }
C {devices/lab_pin.sym} 17420 -1710 0 1 {name=p17317 lab=_48584_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -1710 0 0 {name=X_48584_ }
C {devices/lab_pin.sym} 17280 -1580 0 0 {name=p17318 lab=_61293_/A }
C {devices/lab_pin.sym} 17280 -1540 0 0 {name=p17319 lab=_60861_/X }
C {devices/lab_pin.sym} 17400 -1560 0 1 {name=p17320 lab=_60863_/A }
C {sky130_stdcells/and2_4.sym} 17340 -1560 0 0 {name=X_60862_ }
C {devices/lab_pin.sym} 17280 -1450 0 0 {name=p17321 lab=_72846_/X }
C {devices/lab_pin.sym} 17280 -1410 0 0 {name=p17322 lab=_72848_/B }
C {devices/lab_pin.sym} 17280 -1370 0 0 {name=p17323 lab=_72835_/X }
C {devices/lab_pin.sym} 17400 -1410 0 1 {name=p17324 lab=_72848_/Y }
C {sky130_stdcells/nand3_4.sym} 17340 -1410 0 0 {name=X_72848_ }
C {devices/lab_pin.sym} 17260 -1290 0 0 {name=p17325 lab=_57349_/B }
C {devices/lab_pin.sym} 17260 -1250 0 0 {name=p17326 lab=_44933_/X }
C {devices/lab_pin.sym} 17260 -1210 0 0 {name=p17327 lab=_45795_/X }
C {devices/lab_pin.sym} 17420 -1250 0 1 {name=p17328 lab=_45796_/Y }
C {sky130_stdcells/o21ai_4.sym} 17340 -1250 0 0 {name=X_45796_ }
C {devices/lab_pin.sym} 17280 -1140 0 0 {name=p17329 lab=_62623_/A }
C {devices/lab_pin.sym} 17280 -1100 0 0 {name=p17330 lab=_62151_/X }
C {devices/lab_pin.sym} 17280 -1060 0 0 {name=p17331 lab=_62601_/C }
C {devices/lab_pin.sym} 17280 -1020 0 0 {name=p17332 lab=_62623_/D }
C {devices/lab_pin.sym} 17400 -1080 0 1 {name=p17333 lab=_62601_/X }
C {sky130_stdcells/and4_4.sym} 17340 -1080 0 0 {name=X_62601_ }
C {devices/lab_pin.sym} 17300 -930 0 0 {name=p17334 lab=_47535_/A }
C {devices/lab_pin.sym} 17380 -930 0 1 {name=p17335 lab=_47536_/A }
C {sky130_stdcells/inv_2.sym} 17340 -930 0 0 {name=X_47535_ }
C {devices/lab_pin.sym} 17300 -810 0 0 {name=p17336 lab=_78356_/B }
C {devices/lab_pin.sym} 17380 -810 0 1 {name=p17337 lab=_78355_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -810 0 0 {name=X_78355_ }
C {devices/lab_pin.sym} 17300 -690 0 0 {name=p17338 lab=_44747_/A }
C {devices/lab_pin.sym} 17380 -690 0 1 {name=p17339 lab=_44747_/Y }
C {sky130_stdcells/inv_2.sym} 17340 -690 0 0 {name=X_44747_ }
C {devices/lab_pin.sym} 18220 -42150 0 0 {name=p17340 lab=_63413_/A }
C {devices/lab_pin.sym} 18300 -42150 0 1 {name=p17341 lab=_63581_/X }
C {sky130_stdcells/buf_2.sym} 18260 -42150 0 0 {name=X_63581_ }
C {devices/lab_pin.sym} 18200 -42040 0 0 {name=p17342 lab=_75567_/A }
C {devices/lab_pin.sym} 18200 -42000 0 0 {name=p17343 lab=_75567_/B }
C {devices/lab_pin.sym} 18320 -42020 0 1 {name=p17344 lab=_80769_/D }
C {sky130_stdcells/nand2_4.sym} 18260 -42020 0 0 {name=X_75567_ }
C {devices/lab_pin.sym} 18180 -41920 0 0 {name=p17345 lab=_40716_/X }
C {devices/lab_pin.sym} 18180 -41880 0 0 {name=p17346 lab=_41907_/X }
C {devices/lab_pin.sym} 18180 -41840 0 0 {name=p17347 lab=_74095_/A }
C {devices/lab_pin.sym} 18180 -41800 0 0 {name=p17348 lab=_41912_/X }
C {devices/lab_pin.sym} 18340 -41860 0 1 {name=p17349 lab=_88092_/D }
C {sky130_stdcells/a2bb2o_4.sym} 18260 -41860 0 0 {name=X_41959_ }
C {devices/lab_pin.sym} 18180 -41750 0 0 {name=p17350 lab=_60772_/Y }
C {devices/lab_pin.sym} 18180 -41710 0 0 {name=p17351 lab=_60791_/X }
C {devices/lab_pin.sym} 18180 -41670 0 0 {name=p17352 lab=_60749_/Y }
C {devices/lab_pin.sym} 18180 -41630 0 0 {name=p17353 lab=_60781_/Y }
C {devices/lab_pin.sym} 18180 -41600 0 0 {name=p17354 lab=_60792_/Y }
C {devices/lab_pin.sym} 18340 -41670 0 1 {name=p17355 lab=_84566_/D }
C {sky130_stdcells/a41oi_4.sym} 18260 -41670 0 0 {name=X_60793_ }
C {devices/lab_pin.sym} 18200 -41520 0 0 {name=p17356 lab=_72929_/A }
C {devices/lab_pin.sym} 18200 -41480 0 0 {name=p17357 lab=_65439_/B }
C {devices/lab_pin.sym} 18320 -41500 0 1 {name=p17358 lab=_72779_/X }
C {sky130_stdcells/and2_4.sym} 18260 -41500 0 0 {name=X_72779_ }
C {devices/lab_pin.sym} 18180 -41400 0 0 {name=p17359 lab=_64704_/X }
C {devices/lab_pin.sym} 18180 -41360 0 0 {name=p17360 lab=_83286_/Q }
C {devices/lab_pin.sym} 18180 -41320 0 0 {name=p17361 lab=_64980_/X }
C {devices/lab_pin.sym} 18180 -41280 0 0 {name=p17362 lab=_65319_/X }
C {devices/lab_pin.sym} 18340 -41340 0 1 {name=p17363 lab=_65320_/X }
C {sky130_stdcells/a211o_4.sym} 18260 -41340 0 0 {name=X_65320_ }
C {devices/lab_pin.sym} 18200 -41200 0 0 {name=p17364 lab=_77305_/A }
C {devices/lab_pin.sym} 18200 -41160 0 0 {name=p17365 lab=_82132_/Q }
C {devices/lab_pin.sym} 18320 -41180 0 1 {name=p17366 lab=_77307_/A }
C {sky130_stdcells/nand2_4.sym} 18260 -41180 0 0 {name=X_77306_ }
C {devices/lab_pin.sym} 18220 -41050 0 0 {name=p17367 lab=_62532_/A }
C {devices/lab_pin.sym} 18300 -41050 0 1 {name=p17368 lab=_62532_/X }
C {sky130_stdcells/buf_2.sym} 18260 -41050 0 0 {name=X_62532_ }
C {devices/lab_pin.sym} 18200 -40960 0 0 {name=p17369 lab=_70368_/X }
C {devices/lab_pin.sym} 18200 -40920 0 0 {name=p17370 lab=_74518_/B }
C {devices/lab_pin.sym} 18200 -40880 0 0 {name=p17371 lab=_70880_/C }
C {devices/lab_pin.sym} 18200 -40840 0 0 {name=p17372 lab=_74518_/D }
C {devices/lab_pin.sym} 18320 -40900 0 1 {name=p17373 lab=_74518_/Y }
C {sky130_stdcells/nand4_4.sym} 18260 -40900 0 0 {name=X_74518_ }
C {devices/lab_pin.sym} 18200 -40780 0 0 {name=p17374 lab=_47437_/X }
C {devices/lab_pin.sym} 18200 -40740 0 0 {name=p17375 lab=_47463_/X }
C {devices/lab_pin.sym} 18200 -40700 0 0 {name=p17376 lab=_47466_/C }
C {devices/lab_pin.sym} 18200 -40660 0 0 {name=p17377 lab=_53063_/D }
C {devices/lab_pin.sym} 18320 -40720 0 1 {name=p17378 lab=_47466_/X }
C {sky130_stdcells/and4_4.sym} 18260 -40720 0 0 {name=X_47466_ }
C {devices/lab_pin.sym} 18200 -40580 0 0 {name=p17379 lab=_78279_/X }
C {devices/lab_pin.sym} 18200 -40540 0 0 {name=p17380 lab=_78286_/B }
C {devices/lab_pin.sym} 18320 -40560 0 1 {name=p17381 lab=_78287_/B }
C {sky130_stdcells/xor2_4.sym} 18260 -40560 0 0 {name=X_78286_ }
C {devices/lab_pin.sym} 18220 -40430 0 0 {name=p17382 lab=_44677_/Y }
C {devices/lab_pin.sym} 18300 -40430 0 1 {name=p17383 lab=_44678_/Y }
C {sky130_stdcells/inv_2.sym} 18260 -40430 0 0 {name=X_44678_ }
C {devices/lab_pin.sym} 18200 -40330 0 0 {name=p17384 lab=_75498_/A }
C {devices/lab_pin.sym} 18200 -40290 0 0 {name=p17385 lab=_75495_/Y }
C {devices/lab_pin.sym} 18200 -40250 0 0 {name=p17386 lab=_75497_/Y }
C {devices/lab_pin.sym} 18320 -40290 0 1 {name=p17387 lab=_75503_/A }
C {sky130_stdcells/or3_4.sym} 18260 -40290 0 0 {name=X_75498_ }
C {devices/lab_pin.sym} 18220 -40150 0 0 {name=p17388 lab=_49205_/A }
C {devices/lab_pin.sym} 18300 -40150 0 1 {name=p17389 lab=_49232_/A }
C {sky130_stdcells/buf_2.sym} 18260 -40150 0 0 {name=X_49205_ }
C {devices/lab_pin.sym} 18200 -40040 0 0 {name=p17390 lab=_46408_/A }
C {devices/lab_pin.sym} 18200 -40000 0 0 {name=p17391 lab=_46417_/B }
C {devices/lab_pin.sym} 18320 -40020 0 1 {name=p17392 lab=_46417_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -40020 0 0 {name=X_46417_ }
C {devices/lab_pin.sym} 18180 -39910 0 0 {name=p17393 lab=_65248_/X }
C {devices/lab_pin.sym} 18180 -39870 0 0 {name=p17394 lab=_65250_/X }
C {devices/lab_pin.sym} 18180 -39830 0 0 {name=p17395 lab=_65122_/X }
C {devices/lab_pin.sym} 18340 -39870 0 1 {name=p17396 lab=_65255_/A }
C {sky130_stdcells/a21o_4.sym} 18260 -39870 0 0 {name=X_65251_ }
C {devices/lab_pin.sym} 18200 -39740 0 0 {name=p17397 lab=_77236_/A }
C {devices/lab_pin.sym} 18200 -39700 0 0 {name=p17398 lab=_82083_/D }
C {devices/lab_pin.sym} 18320 -39720 0 1 {name=p17399 lab=_77239_/C }
C {sky130_stdcells/nand2_4.sym} 18260 -39720 0 0 {name=X_77237_ }
C {devices/lab_pin.sym} 18220 -39590 0 0 {name=p17400 lab=_43628_/X }
C {devices/lab_pin.sym} 18300 -39590 0 1 {name=p17401 lab=_87335_/D }
C {sky130_stdcells/inv_2.sym} 18260 -39590 0 0 {name=X_43629_ }
C {devices/lab_pin.sym} 18220 -39470 0 0 {name=p17402 lab=_62463_/A }
C {devices/lab_pin.sym} 18300 -39470 0 1 {name=p17403 lab=_62463_/X }
C {sky130_stdcells/buf_2.sym} 18260 -39470 0 0 {name=X_62463_ }
C {devices/lab_pin.sym} 18200 -39360 0 0 {name=p17404 lab=_46347_/A }
C {devices/lab_pin.sym} 18200 -39320 0 0 {name=p17405 lab=_52188_/B }
C {devices/lab_pin.sym} 18320 -39340 0 1 {name=p17406 lab=_74449_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -39340 0 0 {name=X_74449_ }
C {devices/lab_pin.sym} 18180 -39230 0 0 {name=p17407 lab=_86639_/Q }
C {devices/lab_pin.sym} 18180 -39190 0 0 {name=p17408 lab=_47382_/X }
C {devices/lab_pin.sym} 18180 -39150 0 0 {name=p17409 lab=_47396_/Y }
C {devices/lab_pin.sym} 18340 -39190 0 1 {name=p17410 lab=_47397_/Y }
C {sky130_stdcells/o21ai_4.sym} 18260 -39190 0 0 {name=X_47397_ }
C {devices/lab_pin.sym} 18200 -39060 0 0 {name=p17411 lab=_59450_/Y }
C {devices/lab_pin.sym} 18200 -39020 0 0 {name=p17412 lab=_61086_/X }
C {devices/lab_pin.sym} 18320 -39040 0 1 {name=p17413 lab=_64202_/Y }
C {sky130_stdcells/nor2_4.sym} 18260 -39040 0 0 {name=X_64202_ }
C {devices/lab_pin.sym} 18200 -38920 0 0 {name=p17414 lab=_49117_/A }
C {devices/lab_pin.sym} 18200 -38880 0 0 {name=p17415 lab=_49135_/X }
C {devices/lab_pin.sym} 18320 -38900 0 1 {name=p17416 lab=_49136_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -38900 0 0 {name=X_49136_ }
C {devices/lab_pin.sym} 18220 -38770 0 0 {name=p17417 lab=_61414_/A }
C {devices/lab_pin.sym} 18300 -38770 0 1 {name=p17418 lab=_61434_/B }
C {sky130_stdcells/buf_2.sym} 18260 -38770 0 0 {name=X_61414_ }
C {devices/lab_pin.sym} 18220 -38650 0 0 {name=p17419 lab=_46348_/A }
C {devices/lab_pin.sym} 18300 -38650 0 1 {name=p17420 lab=_46348_/X }
C {sky130_stdcells/buf_2.sym} 18260 -38650 0 0 {name=X_46348_ }
C {devices/lab_pin.sym} 18220 -38530 0 0 {name=p17421 lab=_64902_/A }
C {devices/lab_pin.sym} 18300 -38530 0 1 {name=p17422 lab=_65182_/X }
C {sky130_stdcells/buf_2.sym} 18260 -38530 0 0 {name=X_65182_ }
C {devices/lab_pin.sym} 18200 -38420 0 0 {name=p17423 lab=_82105_/Q }
C {devices/lab_pin.sym} 18200 -38380 0 0 {name=p17424 lab=_77168_/B }
C {devices/lab_pin.sym} 18320 -38400 0 1 {name=p17425 lab=_77168_/X }
C {sky130_stdcells/xor2_4.sym} 18260 -38400 0 0 {name=X_77168_ }
C {devices/lab_pin.sym} 18180 -38310 0 0 {name=p17426 lab=_62385_/X }
C {devices/lab_pin.sym} 18180 -38270 0 0 {name=p17427 lab=_62389_/Y }
C {devices/lab_pin.sym} 18180 -38230 0 0 {name=p17428 lab=_62393_/X }
C {devices/lab_pin.sym} 18180 -38190 0 0 {name=p17429 lab=_84741_/Q }
C {devices/lab_pin.sym} 18180 -38150 0 0 {name=p17430 lab=_62367_/X }
C {devices/lab_pin.sym} 18340 -38230 0 1 {name=p17431 lab=_62394_/Y }
C {sky130_stdcells/o32ai_4.sym} 18260 -38230 0 0 {name=X_62394_ }
C {devices/lab_pin.sym} 18180 -38100 0 0 {name=p17432 lab=_59430_/Y }
C {devices/lab_pin.sym} 18180 -38060 0 0 {name=p17433 lab=_61003_/Y }
C {devices/lab_pin.sym} 18180 -38020 0 0 {name=p17434 lab=_62129_/X }
C {devices/lab_pin.sym} 18180 -37980 0 0 {name=p17435 lab=_60962_/Y }
C {devices/lab_pin.sym} 18340 -38040 0 1 {name=p17436 lab=_64133_/X }
C {sky130_stdcells/a2bb2o_4.sym} 18260 -38040 0 0 {name=X_64133_ }
C {devices/lab_pin.sym} 18180 -37910 0 0 {name=p17437 lab=_76112_/B }
C {devices/lab_pin.sym} 18180 -37870 0 0 {name=p17438 lab=_76112_/A }
C {devices/lab_pin.sym} 18180 -37830 0 0 {name=p17439 lab=_76118_/Y }
C {devices/lab_pin.sym} 18340 -37870 0 1 {name=p17440 lab=_76119_/Y }
C {sky130_stdcells/a21boi_4.sym} 18260 -37870 0 0 {name=X_76119_ }
C {devices/lab_pin.sym} 18220 -37730 0 0 {name=p17441 lab=_61344_/Y }
C {devices/lab_pin.sym} 18300 -37730 0 1 {name=p17442 lab=_61345_/Y }
C {sky130_stdcells/inv_2.sym} 18260 -37730 0 0 {name=X_61345_ }
C {devices/lab_pin.sym} 18200 -37620 0 0 {name=p17443 lab=_48976_/A }
C {devices/lab_pin.sym} 18200 -37580 0 0 {name=p17444 lab=_49067_/B }
C {devices/lab_pin.sym} 18320 -37600 0 1 {name=p17445 lab=_49067_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -37600 0 0 {name=X_49067_ }
C {devices/lab_pin.sym} 18220 -37470 0 0 {name=p17446 lab=_46279_/A }
C {devices/lab_pin.sym} 18300 -37470 0 1 {name=p17447 lab=_46279_/X }
C {sky130_stdcells/buf_2.sym} 18260 -37470 0 0 {name=X_46279_ }
C {devices/lab_pin.sym} 18180 -37380 0 0 {name=p17448 lab=_69943_/X }
C {devices/lab_pin.sym} 18180 -37340 0 0 {name=p17449 lab=_68446_/Y }
C {devices/lab_pin.sym} 18180 -37300 0 0 {name=p17450 lab=_69984_/X }
C {devices/lab_pin.sym} 18180 -37260 0 0 {name=p17451 lab=_69989_/Y }
C {devices/lab_pin.sym} 18340 -37320 0 1 {name=p17452 lab=_69990_/X }
C {sky130_stdcells/a211o_4.sym} 18260 -37320 0 0 {name=X_69990_ }
C {devices/lab_pin.sym} 18200 -37180 0 0 {name=p17453 lab=_77098_/A }
C {devices/lab_pin.sym} 18200 -37140 0 0 {name=p17454 lab=_82287_/D }
C {devices/lab_pin.sym} 18320 -37160 0 1 {name=p17455 lab=_77099_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -37160 0 0 {name=X_77099_ }
C {devices/lab_pin.sym} 18200 -37040 0 0 {name=p17456 lab=_48018_/A }
C {devices/lab_pin.sym} 18200 -37000 0 0 {name=p17457 lab=_47973_/B }
C {devices/lab_pin.sym} 18320 -37020 0 1 {name=p17458 lab=_48018_/X }
C {sky130_stdcells/or2_4.sym} 18260 -37020 0 0 {name=X_48018_ }
C {devices/lab_pin.sym} 18200 -36900 0 0 {name=p17459 lab=_68987_/A }
C {devices/lab_pin.sym} 18200 -36860 0 0 {name=p17460 lab=_68941_/B }
C {devices/lab_pin.sym} 18320 -36880 0 1 {name=p17461 lab=_68941_/X }
C {sky130_stdcells/and2_4.sym} 18260 -36880 0 0 {name=X_68941_ }
C {devices/lab_pin.sym} 18200 -36780 0 0 {name=p17462 lab=_64058_/Y }
C {devices/lab_pin.sym} 18200 -36740 0 0 {name=p17463 lab=_64059_/Y }
C {devices/lab_pin.sym} 18200 -36700 0 0 {name=p17464 lab=_64064_/C }
C {devices/lab_pin.sym} 18200 -36660 0 0 {name=p17465 lab=_64064_/D }
C {devices/lab_pin.sym} 18320 -36720 0 1 {name=p17466 lab=_64064_/X }
C {sky130_stdcells/and4_4.sym} 18260 -36720 0 0 {name=X_64064_ }
C {devices/lab_pin.sym} 18200 -36600 0 0 {name=p17467 lab=_72625_/B }
C {devices/lab_pin.sym} 18200 -36560 0 0 {name=p17468 lab=_61276_/B }
C {devices/lab_pin.sym} 18200 -36520 0 0 {name=p17469 lab=_60402_/A }
C {devices/lab_pin.sym} 18200 -36480 0 0 {name=p17470 lab=_61287_/A }
C {devices/lab_pin.sym} 18320 -36540 0 1 {name=p17471 lab=_61278_/A }
C {sky130_stdcells/and4_4.sym} 18260 -36540 0 0 {name=X_61276_ }
C {devices/lab_pin.sym} 18220 -36390 0 0 {name=p17472 lab=_60410_/B }
C {devices/lab_pin.sym} 18300 -36390 0 1 {name=p17473 lab=_63342_/C }
C {sky130_stdcells/buf_2.sym} 18260 -36390 0 0 {name=X_63015_ }
C {devices/lab_pin.sym} 18220 -36270 0 0 {name=p17474 lab=_60227_/A }
C {devices/lab_pin.sym} 18300 -36270 0 1 {name=p17475 lab=_60228_/A }
C {sky130_stdcells/buf_2.sym} 18260 -36270 0 0 {name=X_60227_ }
C {devices/lab_pin.sym} 18200 -36160 0 0 {name=p17476 lab=_68759_/A }
C {devices/lab_pin.sym} 18200 -36120 0 0 {name=p17477 lab=_87231_/Q }
C {devices/lab_pin.sym} 18320 -36140 0 1 {name=p17478 lab=_68872_/X }
C {sky130_stdcells/and2_4.sym} 18260 -36140 0 0 {name=X_68872_ }
C {devices/lab_pin.sym} 18180 -36040 0 0 {name=p17479 lab=_87391_/Q }
C {devices/lab_pin.sym} 18180 -36000 0 0 {name=p17480 lab=_67751_/X }
C {devices/lab_pin.sym} 18180 -35960 0 0 {name=p17481 lab=_67821_/X }
C {devices/lab_pin.sym} 18180 -35920 0 0 {name=p17482 lab=_67822_/X }
C {devices/lab_pin.sym} 18340 -35980 0 1 {name=p17483 lab=_67823_/X }
C {sky130_stdcells/a211o_4.sym} 18260 -35980 0 0 {name=X_67823_ }
C {devices/lab_pin.sym} 18200 -35840 0 0 {name=p17484 lab=_79786_/X }
C {devices/lab_pin.sym} 18200 -35800 0 0 {name=p17485 lab=_79799_/X }
C {devices/lab_pin.sym} 18320 -35820 0 1 {name=p17486 lab=_79809_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -35820 0 0 {name=X_79809_ }
C {devices/lab_pin.sym} 18220 -35690 0 0 {name=p17487 lab=_60251_/A }
C {devices/lab_pin.sym} 18300 -35690 0 1 {name=p17488 lab=_60159_/A }
C {sky130_stdcells/buf_2.sym} 18260 -35690 0 0 {name=X_60158_ }
C {devices/lab_pin.sym} 18200 -35600 0 0 {name=p17489 lab=_49973_/A }
C {devices/lab_pin.sym} 18200 -35560 0 0 {name=p17490 lab=_49973_/B }
C {devices/lab_pin.sym} 18200 -35520 0 0 {name=p17491 lab=_49973_/C }
C {devices/lab_pin.sym} 18200 -35480 0 0 {name=p17492 lab=_53181_/D }
C {devices/lab_pin.sym} 18320 -35540 0 1 {name=p17493 lab=_49969_/X }
C {sky130_stdcells/and4_4.sym} 18260 -35540 0 0 {name=X_49969_ }
C {devices/lab_pin.sym} 18170 -35390 0 0 {name=p17494 lab=_82820_/CLK }
C {devices/lab_pin.sym} 18170 -35370 0 0 {name=p17495 lab=_82820_/D }
C {devices/lab_pin.sym} 18350 -35390 0 1 {name=p17496 lab=_82820_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -35380 0 0 {name=X_82820_ }
C {devices/lab_pin.sym} 18180 -35270 0 0 {name=p17497 lab=_67750_/X }
C {devices/lab_pin.sym} 18180 -35230 0 0 {name=p17498 lab=_67753_/X }
C {devices/lab_pin.sym} 18180 -35190 0 0 {name=p17499 lab=_67681_/X }
C {devices/lab_pin.sym} 18340 -35230 0 1 {name=p17500 lab=_67754_/X }
C {sky130_stdcells/a21o_4.sym} 18260 -35230 0 0 {name=X_67754_ }
C {devices/lab_pin.sym} 18180 -35110 0 0 {name=p17501 lab=_85719_/Q }
C {devices/lab_pin.sym} 18180 -35070 0 0 {name=p17502 lab=_52957_/X }
C {devices/lab_pin.sym} 18180 -35030 0 0 {name=p17503 lab=_52979_/Y }
C {devices/lab_pin.sym} 18340 -35070 0 1 {name=p17504 lab=_52980_/Y }
C {sky130_stdcells/o21ai_4.sym} 18260 -35070 0 0 {name=X_52980_ }
C {devices/lab_pin.sym} 18180 -34950 0 0 {name=p17505 lab=_60151_/X }
C {devices/lab_pin.sym} 18180 -34910 0 0 {name=p17506 lab=_64953_/Y }
C {devices/lab_pin.sym} 18180 -34870 0 0 {name=p17507 lab=_64965_/Y }
C {devices/lab_pin.sym} 18340 -34910 0 1 {name=p17508 lab=_64966_/Y }
C {sky130_stdcells/o21ai_4.sym} 18260 -34910 0 0 {name=X_64966_ }
C {devices/lab_pin.sym} 18200 -34790 0 0 {name=p17509 lab=_60081_/A }
C {devices/lab_pin.sym} 18200 -34750 0 0 {name=p17510 lab=_60103_/B }
C {devices/lab_pin.sym} 18200 -34710 0 0 {name=p17511 lab=_60089_/C }
C {devices/lab_pin.sym} 18320 -34750 0 1 {name=p17512 lab=_60089_/Y }
C {sky130_stdcells/nor3_4.sym} 18260 -34750 0 0 {name=X_60089_ }
C {devices/lab_pin.sym} 18180 -34640 0 0 {name=p17513 lab=_88398_/Q }
C {devices/lab_pin.sym} 18180 -34600 0 0 {name=p17514 lab=_66633_/X }
C {devices/lab_pin.sym} 18180 -34560 0 0 {name=p17515 lab=_66682_/X }
C {devices/lab_pin.sym} 18180 -34520 0 0 {name=p17516 lab=_66704_/X }
C {devices/lab_pin.sym} 18340 -34580 0 1 {name=p17517 lab=_66705_/X }
C {sky130_stdcells/a211o_4.sym} 18260 -34580 0 0 {name=X_66705_ }
C {devices/lab_pin.sym} 18220 -34430 0 0 {name=p17518 lab=_53199_/A }
C {devices/lab_pin.sym} 18300 -34430 0 1 {name=p17519 lab=_53259_/A }
C {sky130_stdcells/buf_2.sym} 18260 -34430 0 0 {name=X_51931_ }
C {devices/lab_pin.sym} 18220 -34310 0 0 {name=p17520 lab=_60996_/B }
C {devices/lab_pin.sym} 18300 -34310 0 1 {name=p17521 lab=_63949_/C }
C {sky130_stdcells/buf_2.sym} 18260 -34310 0 0 {name=X_63917_ }
C {devices/lab_pin.sym} 18170 -34190 0 0 {name=p17522 lab=_84115_/CLK }
C {devices/lab_pin.sym} 18170 -34170 0 0 {name=p17523 lab=_84135_/Q }
C {devices/lab_pin.sym} 18350 -34190 0 1 {name=p17524 lab=_82751_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -34180 0 0 {name=X_82751_ }
C {devices/lab_pin.sym} 18180 -34070 0 0 {name=p17525 lab=_67682_/X }
C {devices/lab_pin.sym} 18180 -34030 0 0 {name=p17526 lab=_67684_/X }
C {devices/lab_pin.sym} 18180 -33990 0 0 {name=p17527 lab=_67637_/X }
C {devices/lab_pin.sym} 18340 -34030 0 1 {name=p17528 lab=_67685_/Y }
C {sky130_stdcells/a21oi_4.sym} 18260 -34030 0 0 {name=X_67685_ }
C {devices/lab_pin.sym} 18180 -33910 0 0 {name=p17529 lab=_64894_/X }
C {devices/lab_pin.sym} 18180 -33870 0 0 {name=p17530 lab=_64896_/X }
C {devices/lab_pin.sym} 18180 -33830 0 0 {name=p17531 lab=_64701_/X }
C {devices/lab_pin.sym} 18340 -33870 0 1 {name=p17532 lab=_64897_/X }
C {sky130_stdcells/a21o_4.sym} 18260 -33870 0 0 {name=X_64897_ }
C {devices/lab_pin.sym} 18170 -33730 0 0 {name=p17533 lab=_82053_/CLK }
C {devices/lab_pin.sym} 18170 -33710 0 0 {name=p17534 lab=_81702_/D }
C {devices/lab_pin.sym} 18350 -33730 0 1 {name=p17535 lab=_81702_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -33720 0 0 {name=X_81702_ }
C {devices/lab_pin.sym} 18220 -33590 0 0 {name=p17536 lab=_69162_/A }
C {devices/lab_pin.sym} 18300 -33590 0 1 {name=p17537 lab=_69424_/X }
C {sky130_stdcells/buf_2.sym} 18260 -33590 0 0 {name=X_69424_ }
C {devices/lab_pin.sym} 18200 -33480 0 0 {name=p17538 lab=_54649_/X }
C {devices/lab_pin.sym} 18200 -33440 0 0 {name=p17539 lab=_54125_/B }
C {devices/lab_pin.sym} 18320 -33460 0 1 {name=p17540 lab=_54650_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -33460 0 0 {name=X_54650_ }
C {devices/lab_pin.sym} 18180 -33350 0 0 {name=p17541 lab=_66632_/X }
C {devices/lab_pin.sym} 18180 -33310 0 0 {name=p17542 lab=_66635_/X }
C {devices/lab_pin.sym} 18180 -33270 0 0 {name=p17543 lab=_66366_/A }
C {devices/lab_pin.sym} 18340 -33310 0 1 {name=p17544 lab=_66636_/Y }
C {sky130_stdcells/a21oi_4.sym} 18260 -33310 0 0 {name=X_66636_ }
C {devices/lab_pin.sym} 18170 -33170 0 0 {name=p17545 lab=_82206_/CLK }
C {devices/lab_pin.sym} 18170 -33150 0 0 {name=p17546 lab=_54287_/Y }
C {devices/lab_pin.sym} 18350 -33170 0 1 {name=p17547 lab=_85470_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -33160 0 0 {name=X_85470_ }
C {devices/lab_pin.sym} 18200 -33040 0 0 {name=p17548 lab=_51853_/A }
C {devices/lab_pin.sym} 18200 -33000 0 0 {name=p17549 lab=_50998_/B }
C {devices/lab_pin.sym} 18320 -33020 0 1 {name=p17550 lab=_51862_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -33020 0 0 {name=X_51862_ }
C {devices/lab_pin.sym} 18220 -32890 0 0 {name=p17551 lab=_63644_/A }
C {devices/lab_pin.sym} 18300 -32890 0 1 {name=p17552 lab=_63848_/X }
C {sky130_stdcells/buf_2.sym} 18260 -32890 0 0 {name=X_63848_ }
C {devices/lab_pin.sym} 18170 -32770 0 0 {name=p17553 lab=_81190_/CLK }
C {devices/lab_pin.sym} 18170 -32750 0 0 {name=p17554 lab=_82694_/Q }
C {devices/lab_pin.sym} 18350 -32770 0 1 {name=p17555 lab=_82682_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -32760 0 0 {name=X_82682_ }
C {devices/lab_pin.sym} 18200 -32640 0 0 {name=p17556 lab=_53601_/A }
C {devices/lab_pin.sym} 18200 -32600 0 0 {name=p17557 lab=_57637_/B }
C {devices/lab_pin.sym} 18320 -32620 0 1 {name=p17558 lab=_53601_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -32620 0 0 {name=X_53601_ }
C {devices/lab_pin.sym} 18170 -32490 0 0 {name=p17559 lab=_84421_/CLK }
C {devices/lab_pin.sym} 18170 -32470 0 0 {name=p17560 lab=_62284_/Y }
C {devices/lab_pin.sym} 18350 -32490 0 1 {name=p17561 lab=_84421_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -32480 0 0 {name=X_84421_ }
C {devices/lab_pin.sym} 18180 -32370 0 0 {name=p17562 lab=_50811_/Y }
C {devices/lab_pin.sym} 18180 -32330 0 0 {name=p17563 lab=_50801_/X }
C {devices/lab_pin.sym} 18180 -32290 0 0 {name=p17564 lab=_50812_/X }
C {devices/lab_pin.sym} 18340 -32330 0 1 {name=p17565 lab=_50813_/Y }
C {sky130_stdcells/a21oi_4.sym} 18260 -32330 0 0 {name=X_50813_ }
C {devices/lab_pin.sym} 18170 -32190 0 0 {name=p17566 lab=_81695_/CLK }
C {devices/lab_pin.sym} 18170 -32170 0 0 {name=p17567 lab=_76643_/A }
C {devices/lab_pin.sym} 18350 -32190 0 1 {name=p17568 lab=_81825_/D }
C {sky130_stdcells/dfxtp_4.sym} 18260 -32180 0 0 {name=X_81633_ }
C {devices/lab_pin.sym} 18180 -32080 0 0 {name=p17569 lab=_88035_/Q }
C {devices/lab_pin.sym} 18180 -32040 0 0 {name=p17570 lab=_69121_/X }
C {devices/lab_pin.sym} 18180 -32000 0 0 {name=p17571 lab=_69232_/X }
C {devices/lab_pin.sym} 18180 -31960 0 0 {name=p17572 lab=_69354_/X }
C {devices/lab_pin.sym} 18340 -32020 0 1 {name=p17573 lab=_69355_/X }
C {sky130_stdcells/a211o_4.sym} 18260 -32020 0 0 {name=X_69355_ }
C {devices/lab_pin.sym} 18180 -31890 0 0 {name=p17574 lab=_54579_/Y }
C {devices/lab_pin.sym} 18180 -31850 0 0 {name=p17575 lab=_54558_/X }
C {devices/lab_pin.sym} 18180 -31810 0 0 {name=p17576 lab=_54580_/X }
C {devices/lab_pin.sym} 18340 -31850 0 1 {name=p17577 lab=_54581_/Y }
C {sky130_stdcells/a21oi_4.sym} 18260 -31850 0 0 {name=X_54581_ }
C {devices/lab_pin.sym} 18200 -31720 0 0 {name=p17578 lab=_69454_/A }
C {devices/lab_pin.sym} 18200 -31680 0 0 {name=p17579 lab=_66567_/B }
C {devices/lab_pin.sym} 18320 -31700 0 1 {name=p17580 lab=_66567_/X }
C {sky130_stdcells/and2_4.sym} 18260 -31700 0 0 {name=X_66567_ }
C {devices/lab_pin.sym} 18220 -31570 0 0 {name=p17581 lab=_51793_/A }
C {devices/lab_pin.sym} 18300 -31570 0 1 {name=p17582 lab=_51793_/X }
C {sky130_stdcells/buf_2.sym} 18260 -31570 0 0 {name=X_51793_ }
C {devices/lab_pin.sym} 18200 -31480 0 0 {name=p17583 lab=_63772_/Y }
C {devices/lab_pin.sym} 18200 -31440 0 0 {name=p17584 lab=_63775_/Y }
C {devices/lab_pin.sym} 18200 -31400 0 0 {name=p17585 lab=_63777_/Y }
C {devices/lab_pin.sym} 18200 -31360 0 0 {name=p17586 lab=_63779_/D }
C {devices/lab_pin.sym} 18320 -31420 0 1 {name=p17587 lab=_63779_/X }
C {sky130_stdcells/and4_4.sym} 18260 -31420 0 0 {name=X_63779_ }
C {devices/lab_pin.sym} 18180 -31290 0 0 {name=p17588 lab=_56070_/X }
C {devices/lab_pin.sym} 18180 -31250 0 0 {name=p17589 lab=_56305_/X }
C {devices/lab_pin.sym} 18180 -31210 0 0 {name=p17590 lab=_56319_/Y }
C {devices/lab_pin.sym} 18340 -31250 0 1 {name=p17591 lab=_85237_/D }
C {sky130_stdcells/o21ai_4.sym} 18260 -31250 0 0 {name=X_56320_ }
C {devices/lab_pin.sym} 18180 -31140 0 0 {name=p17592 lab=_68272_/X }
C {devices/lab_pin.sym} 18180 -31100 0 0 {name=p17593 lab=_67862_/Y }
C {devices/lab_pin.sym} 18180 -31060 0 0 {name=p17594 lab=_68287_/X }
C {devices/lab_pin.sym} 18180 -31020 0 0 {name=p17595 lab=_68305_/Y }
C {devices/lab_pin.sym} 18340 -31080 0 1 {name=p17596 lab=_68306_/X }
C {sky130_stdcells/a211o_4.sym} 18260 -31080 0 0 {name=X_68306_ }
C {devices/lab_pin.sym} 18170 -30930 0 0 {name=p17597 lab=_88220_/CLK }
C {devices/lab_pin.sym} 18170 -30910 0 0 {name=p17598 lab=_87140_/D }
C {devices/lab_pin.sym} 18350 -30930 0 1 {name=p17599 lab=_87140_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -30920 0 0 {name=X_87140_ }
C {devices/lab_pin.sym} 18180 -30810 0 0 {name=p17600 lab=_85618_/Q }
C {devices/lab_pin.sym} 18180 -30770 0 0 {name=p17601 lab=_53466_/X }
C {devices/lab_pin.sym} 18180 -30730 0 0 {name=p17602 lab=_53531_/Y }
C {devices/lab_pin.sym} 18340 -30770 0 1 {name=p17603 lab=_53532_/Y }
C {sky130_stdcells/o21ai_4.sym} 18260 -30770 0 0 {name=X_53532_ }
C {devices/lab_pin.sym} 18220 -30630 0 0 {name=p17604 lab=_65791_/A }
C {devices/lab_pin.sym} 18300 -30630 0 1 {name=p17605 lab=_65777_/A }
C {sky130_stdcells/buf_2.sym} 18260 -30630 0 0 {name=X_65518_ }
C {devices/lab_pin.sym} 18170 -30510 0 0 {name=p17606 lab=_83227_/CLK }
C {devices/lab_pin.sym} 18170 -30490 0 0 {name=p17607 lab=_84352_/D }
C {devices/lab_pin.sym} 18350 -30510 0 1 {name=p17608 lab=_79414_/A }
C {sky130_stdcells/dfxtp_4.sym} 18260 -30500 0 0 {name=X_84352_ }
C {devices/lab_pin.sym} 18200 -30380 0 0 {name=p17609 lab=_50771_/A }
C {devices/lab_pin.sym} 18200 -30340 0 0 {name=p17610 lab=_50744_/B }
C {devices/lab_pin.sym} 18320 -30360 0 1 {name=p17611 lab=_50744_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -30360 0 0 {name=X_50744_ }
C {devices/lab_pin.sym} 18170 -30230 0 0 {name=p17612 lab=_84064_/CLK }
C {devices/lab_pin.sym} 18170 -30210 0 0 {name=p17613 lab=_76891_/X }
C {devices/lab_pin.sym} 18350 -30230 0 1 {name=p17614 lab=_81564_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -30220 0 0 {name=X_81564_ }
C {devices/lab_pin.sym} 18200 -30100 0 0 {name=p17615 lab=_69286_/A }
C {devices/lab_pin.sym} 18200 -30060 0 0 {name=p17616 lab=_87784_/Q }
C {devices/lab_pin.sym} 18320 -30080 0 1 {name=p17617 lab=_69286_/X }
C {sky130_stdcells/and2_4.sym} 18260 -30080 0 0 {name=X_69286_ }
C {devices/lab_pin.sym} 18220 -29950 0 0 {name=p17618 lab=_68823_/A }
C {devices/lab_pin.sym} 18300 -29950 0 1 {name=p17619 lab=_66499_/B }
C {sky130_stdcells/buf_2.sym} 18260 -29950 0 0 {name=X_66498_ }
C {devices/lab_pin.sym} 18170 -29830 0 0 {name=p17620 lab=_83303_/CLK }
C {devices/lab_pin.sym} 18170 -29810 0 0 {name=p17621 lab=_72011_/Y }
C {devices/lab_pin.sym} 18350 -29830 0 1 {name=p17622 lab=_83303_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -29820 0 0 {name=X_83303_ }
C {devices/lab_pin.sym} 18180 -29710 0 0 {name=p17623 lab=_80505_/X }
C {devices/lab_pin.sym} 18180 -29670 0 0 {name=p17624 lab=_80506_/X }
C {devices/lab_pin.sym} 18180 -29630 0 0 {name=p17625 lab=_80514_/Y }
C {devices/lab_pin.sym} 18340 -29670 0 1 {name=p17626 lab=_80531_/A }
C {sky130_stdcells/a21boi_4.sym} 18260 -29670 0 0 {name=X_80515_ }
C {devices/lab_pin.sym} 18180 -29550 0 0 {name=p17627 lab=_56130_/X }
C {devices/lab_pin.sym} 18180 -29510 0 0 {name=p17628 lab=_56242_/X }
C {devices/lab_pin.sym} 18180 -29470 0 0 {name=p17629 lab=_56250_/Y }
C {devices/lab_pin.sym} 18340 -29510 0 1 {name=p17630 lab=_85259_/D }
C {sky130_stdcells/o21ai_4.sym} 18260 -29510 0 0 {name=X_56251_ }
C {devices/lab_pin.sym} 18180 -29390 0 0 {name=p17631 lab=_82652_/D }
C {devices/lab_pin.sym} 18180 -29350 0 0 {name=p17632 lab=_68220_/X }
C {devices/lab_pin.sym} 18180 -29310 0 0 {name=p17633 lab=_68236_/X }
C {devices/lab_pin.sym} 18340 -29350 0 1 {name=p17634 lab=_68237_/X }
C {sky130_stdcells/a21bo_4.sym} 18260 -29350 0 0 {name=X_68237_ }
C {devices/lab_pin.sym} 18170 -29210 0 0 {name=p17635 lab=_83115_/CLK }
C {devices/lab_pin.sym} 18170 -29190 0 0 {name=p17636 lab=_87071_/D }
C {devices/lab_pin.sym} 18350 -29210 0 1 {name=p17637 lab=_44514_/A }
C {sky130_stdcells/dfxtp_4.sym} 18260 -29200 0 0 {name=X_87071_ }
C {devices/lab_pin.sym} 18180 -29090 0 0 {name=p17638 lab=_53461_/Y }
C {devices/lab_pin.sym} 18180 -29050 0 0 {name=p17639 lab=_53455_/X }
C {devices/lab_pin.sym} 18180 -29010 0 0 {name=p17640 lab=_53462_/Y }
C {devices/lab_pin.sym} 18340 -29050 0 1 {name=p17641 lab=_53463_/Y }
C {sky130_stdcells/a21boi_4.sym} 18260 -29050 0 0 {name=X_53463_ }
C {devices/lab_pin.sym} 18200 -28930 0 0 {name=p17642 lab=_65449_/A }
C {devices/lab_pin.sym} 18200 -28890 0 0 {name=p17643 lab=_65294_/B }
C {devices/lab_pin.sym} 18200 -28850 0 0 {name=p17644 lab=_65449_/C }
C {devices/lab_pin.sym} 18320 -28890 0 1 {name=p17645 lab=_65449_/X }
C {sky130_stdcells/and3_4.sym} 18260 -28890 0 0 {name=X_65449_ }
C {devices/lab_pin.sym} 18170 -28750 0 0 {name=p17646 lab=_84668_/CLK }
C {devices/lab_pin.sym} 18170 -28730 0 0 {name=p17647 lab=_63977_/Y }
C {devices/lab_pin.sym} 18350 -28750 0 1 {name=p17648 lab=_80102_/B }
C {sky130_stdcells/dfxtp_4.sym} 18260 -28740 0 0 {name=X_84283_ }
C {devices/lab_pin.sym} 18180 -28630 0 0 {name=p17649 lab=_86155_/Q }
C {devices/lab_pin.sym} 18180 -28590 0 0 {name=p17650 lab=_50654_/X }
C {devices/lab_pin.sym} 18180 -28550 0 0 {name=p17651 lab=_50674_/Y }
C {devices/lab_pin.sym} 18340 -28590 0 1 {name=p17652 lab=_50675_/Y }
C {sky130_stdcells/o21ai_4.sym} 18260 -28590 0 0 {name=X_50675_ }
C {devices/lab_pin.sym} 18170 -28450 0 0 {name=p17653 lab=_81431_/CLK }
C {devices/lab_pin.sym} 18170 -28430 0 0 {name=p17654 lab=_84063_/Q }
C {devices/lab_pin.sym} 18350 -28450 0 1 {name=p17655 lab=_76839_/A }
C {sky130_stdcells/dfxtp_4.sym} 18260 -28440 0 0 {name=X_81495_ }
C {devices/lab_pin.sym} 18200 -28320 0 0 {name=p17656 lab=_55710_/B }
C {devices/lab_pin.sym} 18200 -28280 0 0 {name=p17657 lab=_45823_/Y }
C {devices/lab_pin.sym} 18320 -28300 0 1 {name=p17658 lab=_55202_/Y }
C {sky130_stdcells/nor2_4.sym} 18260 -28300 0 0 {name=X_55202_ }
C {devices/lab_pin.sym} 18170 -28170 0 0 {name=p17659 lab=_86118_/CLK }
C {devices/lab_pin.sym} 18170 -28150 0 0 {name=p17660 lab=_86022_/D }
C {devices/lab_pin.sym} 18350 -28170 0 1 {name=p17661 lab=_86022_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -28160 0 0 {name=X_86022_ }
C {devices/lab_pin.sym} 18180 -28050 0 0 {name=p17662 lab=_65384_/B }
C {devices/lab_pin.sym} 18180 -28010 0 0 {name=p17663 lab=_52397_/X }
C {devices/lab_pin.sym} 18180 -27970 0 0 {name=p17664 lab=_52413_/Y }
C {devices/lab_pin.sym} 18340 -28010 0 1 {name=p17665 lab=_52414_/Y }
C {sky130_stdcells/o21ai_4.sym} 18260 -28010 0 0 {name=X_52414_ }
C {devices/lab_pin.sym} 18170 -27870 0 0 {name=p17666 lab=_84350_/CLK }
C {devices/lab_pin.sym} 18170 -27850 0 0 {name=p17667 lab=_72560_/Y }
C {devices/lab_pin.sym} 18350 -27870 0 1 {name=p17668 lab=_79436_/B }
C {sky130_stdcells/dfxtp_4.sym} 18260 -27860 0 0 {name=X_83234_ }
C {devices/lab_pin.sym} 18220 -27730 0 0 {name=p17669 lab=_56181_/X }
C {devices/lab_pin.sym} 18300 -27730 0 1 {name=p17670 lab=_56182_/X }
C {sky130_stdcells/buf_2.sym} 18260 -27730 0 0 {name=X_56182_ }
C {devices/lab_pin.sym} 18200 -27620 0 0 {name=p17671 lab=_80435_/X }
C {devices/lab_pin.sym} 18200 -27580 0 0 {name=p17672 lab=_80446_/B }
C {devices/lab_pin.sym} 18320 -27600 0 1 {name=p17673 lab=_80446_/X }
C {sky130_stdcells/and2_4.sym} 18260 -27600 0 0 {name=X_80446_ }
C {devices/lab_pin.sym} 18220 -27470 0 0 {name=p17674 lab=_68168_/A }
C {devices/lab_pin.sym} 18300 -27470 0 1 {name=p17675 lab=_68168_/X }
C {sky130_stdcells/buf_2.sym} 18260 -27470 0 0 {name=X_68168_ }
C {devices/lab_pin.sym} 18180 -27370 0 0 {name=p17676 lab=_53391_/Y }
C {devices/lab_pin.sym} 18180 -27330 0 0 {name=p17677 lab=_53382_/X }
C {devices/lab_pin.sym} 18180 -27290 0 0 {name=p17678 lab=_53393_/X }
C {devices/lab_pin.sym} 18340 -27330 0 1 {name=p17679 lab=_53394_/Y }
C {sky130_stdcells/a21oi_4.sym} 18260 -27330 0 0 {name=X_53394_ }
C {devices/lab_pin.sym} 18180 -27220 0 0 {name=p17680 lab=_87932_/Q }
C {devices/lab_pin.sym} 18180 -27180 0 0 {name=p17681 lab=_67117_/X }
C {devices/lab_pin.sym} 18180 -27140 0 0 {name=p17682 lab=_67046_/X }
C {devices/lab_pin.sym} 18180 -27100 0 0 {name=p17683 lab=_67118_/X }
C {devices/lab_pin.sym} 18340 -27160 0 1 {name=p17684 lab=_67119_/X }
C {sky130_stdcells/a211o_4.sym} 18260 -27160 0 0 {name=X_67119_ }
C {devices/lab_pin.sym} 18220 -27010 0 0 {name=p17685 lab=_55133_/A }
C {devices/lab_pin.sym} 18300 -27010 0 1 {name=p17686 lab=_55133_/X }
C {sky130_stdcells/buf_2.sym} 18260 -27010 0 0 {name=X_55133_ }
C {devices/lab_pin.sym} 18180 -26910 0 0 {name=p17687 lab=_50645_/A }
C {devices/lab_pin.sym} 18180 -26870 0 0 {name=p17688 lab=_50645_/B }
C {devices/lab_pin.sym} 18180 -26830 0 0 {name=p17689 lab=_52280_/X }
C {devices/lab_pin.sym} 18340 -26870 0 1 {name=p17690 lab=_52345_/X }
C {sky130_stdcells/o21a_4.sym} 18260 -26870 0 0 {name=X_52345_ }
C {devices/lab_pin.sym} 18170 -26730 0 0 {name=p17691 lab=_86570_/CLK }
C {devices/lab_pin.sym} 18170 -26710 0 0 {name=p17692 lab=_73103_/X }
C {devices/lab_pin.sym} 18350 -26730 0 1 {name=p17693 lab=_83165_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -26720 0 0 {name=X_83165_ }
C {devices/lab_pin.sym} 18180 -26610 0 0 {name=p17694 lab=_59291_/Y }
C {devices/lab_pin.sym} 18180 -26570 0 0 {name=p17695 lab=_66264_/C }
C {devices/lab_pin.sym} 18180 -26530 0 0 {name=p17696 lab=_80376_/Y }
C {devices/lab_pin.sym} 18340 -26570 0 1 {name=p17697 lab=_80394_/A }
C {sky130_stdcells/o21a_4.sym} 18260 -26570 0 0 {name=X_80377_ }
C {devices/lab_pin.sym} 18180 -26460 0 0 {name=p17698 lab=_68097_/X }
C {devices/lab_pin.sym} 18180 -26420 0 0 {name=p17699 lab=_66623_/Y }
C {devices/lab_pin.sym} 18180 -26380 0 0 {name=p17700 lab=_68089_/X }
C {devices/lab_pin.sym} 18180 -26340 0 0 {name=p17701 lab=_68098_/Y }
C {devices/lab_pin.sym} 18340 -26400 0 1 {name=p17702 lab=_68099_/X }
C {sky130_stdcells/a211o_4.sym} 18260 -26400 0 0 {name=X_68099_ }
C {devices/lab_pin.sym} 18200 -26260 0 0 {name=p17703 lab=_70130_/A }
C {devices/lab_pin.sym} 18200 -26220 0 0 {name=p17704 lab=_70130_/B }
C {devices/lab_pin.sym} 18320 -26240 0 1 {name=p17705 lab=_70131_/C }
C {sky130_stdcells/nor2_4.sym} 18260 -26240 0 0 {name=X_70130_ }
C {devices/lab_pin.sym} 18170 -26110 0 0 {name=p17706 lab=_82116_/CLK }
C {devices/lab_pin.sym} 18170 -26090 0 0 {name=p17707 lab=_82116_/D }
C {devices/lab_pin.sym} 18350 -26110 0 1 {name=p17708 lab=_82116_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -26100 0 0 {name=X_82116_ }
C {devices/lab_pin.sym} 18180 -25990 0 0 {name=p17709 lab=_85325_/Q }
C {devices/lab_pin.sym} 18180 -25950 0 0 {name=p17710 lab=_55046_/X }
C {devices/lab_pin.sym} 18180 -25910 0 0 {name=p17711 lab=_55063_/Y }
C {devices/lab_pin.sym} 18340 -25950 0 1 {name=p17712 lab=_55064_/Y }
C {sky130_stdcells/o21ai_4.sym} 18260 -25950 0 0 {name=X_55064_ }
C {devices/lab_pin.sym} 18220 -25810 0 0 {name=p17713 lab=_62288_/A }
C {devices/lab_pin.sym} 18300 -25810 0 1 {name=p17714 lab=_62504_/A }
C {sky130_stdcells/buf_2.sym} 18260 -25810 0 0 {name=X_59941_ }
C {devices/lab_pin.sym} 18180 -25710 0 0 {name=p17715 lab=_52273_/Y }
C {devices/lab_pin.sym} 18180 -25670 0 0 {name=p17716 lab=_52262_/X }
C {devices/lab_pin.sym} 18180 -25630 0 0 {name=p17717 lab=_52275_/X }
C {devices/lab_pin.sym} 18340 -25670 0 1 {name=p17718 lab=_85855_/D }
C {sky130_stdcells/a21oi_4.sym} 18260 -25670 0 0 {name=X_52276_ }
C {devices/lab_pin.sym} 18170 -25530 0 0 {name=p17719 lab=_87149_/CLK }
C {devices/lab_pin.sym} 18170 -25510 0 0 {name=p17720 lab=_87973_/D }
C {devices/lab_pin.sym} 18350 -25530 0 1 {name=p17721 lab=_87973_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -25520 0 0 {name=X_87973_ }
C {devices/lab_pin.sym} 18170 -25390 0 0 {name=p17722 lab=_83846_/CLK }
C {devices/lab_pin.sym} 18170 -25370 0 0 {name=p17723 lab=_83096_/D }
C {devices/lab_pin.sym} 18350 -25390 0 1 {name=p17724 lab=_70315_/C }
C {sky130_stdcells/dfxtp_4.sym} 18260 -25380 0 0 {name=X_83096_ }
C {devices/lab_pin.sym} 18220 -25250 0 0 {name=p17725 lab=_53773_/A }
C {devices/lab_pin.sym} 18300 -25250 0 1 {name=p17726 lab=_54015_/X }
C {sky130_stdcells/buf_2.sym} 18260 -25250 0 0 {name=X_54015_ }
C {devices/lab_pin.sym} 18200 -25140 0 0 {name=p17727 lab=_51212_/A }
C {devices/lab_pin.sym} 18200 -25100 0 0 {name=p17728 lab=_52918_/B }
C {devices/lab_pin.sym} 18320 -25120 0 1 {name=p17729 lab=_51227_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -25120 0 0 {name=X_51227_ }
C {devices/lab_pin.sym} 18180 -25020 0 0 {name=p17730 lab=_69855_/Y }
C {devices/lab_pin.sym} 18180 -24980 0 0 {name=p17731 lab=_59834_/A }
C {devices/lab_pin.sym} 18180 -24940 0 0 {name=p17732 lab=_70056_/X }
C {devices/lab_pin.sym} 18180 -24900 0 0 {name=p17733 lab=_70060_/Y }
C {devices/lab_pin.sym} 18340 -24960 0 1 {name=p17734 lab=_70061_/X }
C {sky130_stdcells/a211o_4.sym} 18260 -24960 0 0 {name=X_70061_ }
C {devices/lab_pin.sym} 18170 -24810 0 0 {name=p17735 lab=_87652_/CLK }
C {devices/lab_pin.sym} 18170 -24790 0 0 {name=p17736 lab=_86924_/D }
C {devices/lab_pin.sym} 18350 -24810 0 1 {name=p17737 lab=_86924_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -24800 0 0 {name=X_86924_ }
C {devices/lab_pin.sym} 18220 -24670 0 0 {name=p17738 lab=clkbuf_9_295_0_CLK/X }
C {devices/lab_pin.sym} 18300 -24670 0 1 {name=p17739 lab=_83957_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 18260 -24670 0 0 {name=Xclkbuf_10_590_0_CLK }
C {devices/lab_pin.sym} 18170 -24550 0 0 {name=p17740 lab=_82047_/CLK }
C {devices/lab_pin.sym} 18170 -24530 0 0 {name=p17741 lab=_78003_/Y }
C {devices/lab_pin.sym} 18350 -24550 0 1 {name=p17742 lab=_82015_/D }
C {sky130_stdcells/dfxtp_4.sym} 18260 -24540 0 0 {name=X_82047_ }
C {devices/lab_pin.sym} 18220 -24410 0 0 {name=p17743 lab=_59852_/A }
C {devices/lab_pin.sym} 18300 -24410 0 1 {name=p17744 lab=_59873_/B }
C {sky130_stdcells/buf_2.sym} 18260 -24410 0 0 {name=X_59872_ }
C {devices/lab_pin.sym} 18180 -24310 0 0 {name=p17745 lab=_58813_/X }
C {devices/lab_pin.sym} 18180 -24270 0 0 {name=p17746 lab=_85773_/Q }
C {devices/lab_pin.sym} 18180 -24230 0 0 {name=p17747 lab=_58706_/X }
C {devices/lab_pin.sym} 18340 -24270 0 1 {name=p17748 lab=_58823_/X }
C {sky130_stdcells/o21a_4.sym} 18260 -24270 0 0 {name=X_58823_ }
C {devices/lab_pin.sym} 18200 -24140 0 0 {name=p17749 lab=_51167_/A }
C {devices/lab_pin.sym} 18200 -24100 0 0 {name=p17750 lab=_52850_/B }
C {devices/lab_pin.sym} 18320 -24120 0 1 {name=p17751 lab=_51158_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -24120 0 0 {name=X_51158_ }
C {devices/lab_pin.sym} 18170 -23990 0 0 {name=p17752 lab=_86855_/CLK }
C {devices/lab_pin.sym} 18170 -23970 0 0 {name=p17753 lab=_86855_/D }
C {devices/lab_pin.sym} 18350 -23990 0 1 {name=p17754 lab=_62094_/D }
C {sky130_stdcells/dfxtp_4.sym} 18260 -23980 0 0 {name=X_86855_ }
C {devices/lab_pin.sym} 18180 -23870 0 0 {name=p17755 lab=_86262_/Q }
C {devices/lab_pin.sym} 18180 -23830 0 0 {name=p17756 lab=_50088_/X }
C {devices/lab_pin.sym} 18180 -23790 0 0 {name=p17757 lab=_50108_/Y }
C {devices/lab_pin.sym} 18340 -23830 0 1 {name=p17758 lab=_50109_/Y }
C {sky130_stdcells/o21ai_4.sym} 18260 -23830 0 0 {name=X_50109_ }
C {devices/lab_pin.sym} 18200 -23700 0 0 {name=p17759 lab=_73820_/A }
C {devices/lab_pin.sym} 18200 -23660 0 0 {name=p17760 lab=_73624_/X }
C {devices/lab_pin.sym} 18320 -23680 0 1 {name=p17761 lab=_73820_/Y }
C {sky130_stdcells/nor2_4.sym} 18260 -23680 0 0 {name=X_73820_ }
C {devices/lab_pin.sym} 18170 -23550 0 0 {name=p17762 lab=_86040_/CLK }
C {devices/lab_pin.sym} 18170 -23530 0 0 {name=p17763 lab=_52521_/Y }
C {devices/lab_pin.sym} 18350 -23550 0 1 {name=p17764 lab=_65103_/B }
C {sky130_stdcells/dfxtp_4.sym} 18260 -23540 0 0 {name=X_85806_ }
C {devices/lab_pin.sym} 18180 -23440 0 0 {name=p17765 lab=_58738_/Y }
C {devices/lab_pin.sym} 18180 -23400 0 0 {name=p17766 lab=_58739_/X }
C {devices/lab_pin.sym} 18180 -23360 0 0 {name=p17767 lab=_58745_/X }
C {devices/lab_pin.sym} 18180 -23320 0 0 {name=p17768 lab=_58753_/X }
C {devices/lab_pin.sym} 18340 -23380 0 1 {name=p17769 lab=_84803_/D }
C {sky130_stdcells/a22oi_4.sym} 18260 -23380 0 0 {name=X_58754_ }
C {devices/lab_pin.sym} 18200 -23260 0 0 {name=p17770 lab=_51084_/A }
C {devices/lab_pin.sym} 18200 -23220 0 0 {name=p17771 lab=_51071_/B }
C {devices/lab_pin.sym} 18200 -23180 0 0 {name=p17772 lab=_51110_/C }
C {devices/lab_pin.sym} 18200 -23140 0 0 {name=p17773 lab=_52779_/D }
C {devices/lab_pin.sym} 18320 -23200 0 1 {name=p17774 lab=_51089_/X }
C {sky130_stdcells/and4_4.sym} 18260 -23200 0 0 {name=X_51089_ }
C {devices/lab_pin.sym} 18220 -23050 0 0 {name=p17775 lab=_55966_/A }
C {devices/lab_pin.sym} 18300 -23050 0 1 {name=p17776 lab=_55966_/X }
C {sky130_stdcells/buf_2.sym} 18260 -23050 0 0 {name=X_55966_ }
C {devices/lab_pin.sym} 18180 -22960 0 0 {name=p17777 lab=_86840_/Q }
C {devices/lab_pin.sym} 18180 -22920 0 0 {name=p17778 lab=_43987_/B }
C {devices/lab_pin.sym} 18180 -22880 0 0 {name=p17779 lab=_43955_/Y }
C {devices/lab_pin.sym} 18180 -22840 0 0 {name=p17780 lab=_43979_/Y }
C {devices/lab_pin.sym} 18340 -22900 0 1 {name=p17781 lab=_59899_/D }
C {sky130_stdcells/a211o_4.sym} 18260 -22900 0 0 {name=X_43980_ }
C {devices/lab_pin.sym} 18170 -22750 0 0 {name=p17782 lab=_86784_/CLK }
C {devices/lab_pin.sym} 18170 -22730 0 0 {name=p17783 lab=_86786_/D }
C {devices/lab_pin.sym} 18350 -22750 0 1 {name=p17784 lab=_67049_/B }
C {sky130_stdcells/dfxtp_4.sym} 18260 -22740 0 0 {name=X_86786_ }
C {devices/lab_pin.sym} 18170 -22610 0 0 {name=p17785 lab=_82642_/CLK }
C {devices/lab_pin.sym} 18170 -22590 0 0 {name=p17786 lab=_68263_/X }
C {devices/lab_pin.sym} 18350 -22610 0 1 {name=p17787 lab=_83998_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -22600 0 0 {name=X_83998_ }
C {devices/lab_pin.sym} 18220 -22470 0 0 {name=p17788 lab=_44181_/X }
C {devices/lab_pin.sym} 18300 -22470 0 1 {name=p17789 lab=_57705_/X }
C {sky130_stdcells/buf_2.sym} 18260 -22470 0 0 {name=X_57705_ }
C {devices/lab_pin.sym} 18180 -22370 0 0 {name=p17790 lab=_54913_/Y }
C {devices/lab_pin.sym} 18180 -22330 0 0 {name=p17791 lab=_54909_/X }
C {devices/lab_pin.sym} 18180 -22290 0 0 {name=p17792 lab=_54916_/X }
C {devices/lab_pin.sym} 18340 -22330 0 1 {name=p17793 lab=_85354_/D }
C {sky130_stdcells/a21oi_4.sym} 18260 -22330 0 0 {name=X_54917_ }
C {devices/lab_pin.sym} 18220 -22190 0 0 {name=p17794 lab=_42951_/A }
C {devices/lab_pin.sym} 18300 -22190 0 1 {name=p17795 lab=_42931_/X }
C {sky130_stdcells/buf_2.sym} 18260 -22190 0 0 {name=X_42931_ }
C {devices/lab_pin.sym} 18180 -22100 0 0 {name=p17796 lab=_41914_/Y }
C {devices/lab_pin.sym} 18180 -22060 0 0 {name=p17797 lab=_73529_/X }
C {devices/lab_pin.sym} 18180 -22020 0 0 {name=p17798 lab=_73698_/X }
C {devices/lab_pin.sym} 18180 -21980 0 0 {name=p17799 lab=_73750_/Y }
C {devices/lab_pin.sym} 18340 -22040 0 1 {name=p17800 lab=_73751_/X }
C {sky130_stdcells/a211o_4.sym} 18260 -22040 0 0 {name=X_73751_ }
C {devices/lab_pin.sym} 18170 -21890 0 0 {name=p17801 lab=_85738_/CLK }
C {devices/lab_pin.sym} 18170 -21870 0 0 {name=p17802 lab=_52884_/Y }
C {devices/lab_pin.sym} 18350 -21890 0 1 {name=p17803 lab=_85737_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -21880 0 0 {name=X_85737_ }
C {devices/lab_pin.sym} 18180 -21770 0 0 {name=p17804 lab=_49245_/B }
C {devices/lab_pin.sym} 18180 -21730 0 0 {name=p17805 lab=_70961_/X }
C {devices/lab_pin.sym} 18180 -21690 0 0 {name=p17806 lab=_70962_/Y }
C {devices/lab_pin.sym} 18340 -21730 0 1 {name=p17807 lab=_70963_/Y }
C {sky130_stdcells/o21ai_4.sym} 18260 -21730 0 0 {name=X_70963_ }
C {devices/lab_pin.sym} 18180 -21610 0 0 {name=p17808 lab=_58681_/Y }
C {devices/lab_pin.sym} 18180 -21570 0 0 {name=p17809 lab=_58684_/Y }
C {devices/lab_pin.sym} 18180 -21530 0 0 {name=p17810 lab=_58610_/X }
C {devices/lab_pin.sym} 18340 -21570 0 1 {name=p17811 lab=_58685_/X }
C {sky130_stdcells/a21o_4.sym} 18260 -21570 0 0 {name=X_58685_ }
C {devices/lab_pin.sym} 18170 -21430 0 0 {name=p17812 lab=_86697_/CLK }
C {devices/lab_pin.sym} 18170 -21410 0 0 {name=p17813 lab=_82757_/Q }
C {devices/lab_pin.sym} 18350 -21430 0 1 {name=p17814 lab=_82949_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -21420 0 0 {name=X_82949_ }
C {devices/lab_pin.sym} 18180 -21320 0 0 {name=p17815 lab=_85207_/Q }
C {devices/lab_pin.sym} 18180 -21280 0 0 {name=p17816 lab=_44070_/B }
C {devices/lab_pin.sym} 18180 -21240 0 0 {name=p17817 lab=_55627_/X }
C {devices/lab_pin.sym} 18180 -21200 0 0 {name=p17818 lab=_55896_/X }
C {devices/lab_pin.sym} 18340 -21260 0 1 {name=p17819 lab=_55897_/X }
C {sky130_stdcells/a211o_4.sym} 18260 -21260 0 0 {name=X_55897_ }
C {devices/lab_pin.sym} 18220 -21110 0 0 {name=p17820 lab=_72686_/A }
C {devices/lab_pin.sym} 18300 -21110 0 1 {name=p17821 lab=_72702_/X }
C {sky130_stdcells/buf_2.sym} 18260 -21110 0 0 {name=X_72702_ }
C {devices/lab_pin.sym} 18180 -21010 0 0 {name=p17822 lab=_45646_/X }
C {devices/lab_pin.sym} 18180 -20970 0 0 {name=p17823 lab=_45649_/X }
C {devices/lab_pin.sym} 18180 -20930 0 0 {name=p17824 lab=_45602_/X }
C {devices/lab_pin.sym} 18340 -20970 0 1 {name=p17825 lab=_45650_/X }
C {sky130_stdcells/a21o_4.sym} 18260 -20970 0 0 {name=X_45650_ }
C {devices/lab_pin.sym} 18220 -20830 0 0 {name=p17826 lab=_72017_/A }
C {devices/lab_pin.sym} 18300 -20830 0 1 {name=p17827 lab=_71972_/A }
C {sky130_stdcells/buf_2.sym} 18260 -20830 0 0 {name=X_57636_ }
C {devices/lab_pin.sym} 18220 -20710 0 0 {name=p17828 lab=_76470_/A }
C {devices/lab_pin.sym} 18300 -20710 0 1 {name=p17829 lab=_76474_/A }
C {sky130_stdcells/inv_2.sym} 18260 -20710 0 0 {name=X_76470_ }
C {devices/lab_pin.sym} 18180 -20620 0 0 {name=p17830 lab=_41556_/X }
C {devices/lab_pin.sym} 18180 -20580 0 0 {name=p17831 lab=_42852_/X }
C {devices/lab_pin.sym} 18180 -20540 0 0 {name=p17832 lab=_87681_/Q }
C {devices/lab_pin.sym} 18180 -20500 0 0 {name=p17833 lab=_42853_/X }
C {devices/lab_pin.sym} 18340 -20560 0 1 {name=p17834 lab=_42862_/X }
C {sky130_stdcells/a2bb2o_4.sym} 18260 -20560 0 0 {name=X_42862_ }
C {devices/lab_pin.sym} 18200 -20440 0 0 {name=p17835 lab=_54857_/A }
C {devices/lab_pin.sym} 18200 -20400 0 0 {name=p17836 lab=_54857_/B }
C {devices/lab_pin.sym} 18200 -20360 0 0 {name=p17837 lab=_54857_/C }
C {devices/lab_pin.sym} 18200 -20320 0 0 {name=p17838 lab=_53155_/D }
C {devices/lab_pin.sym} 18320 -20380 0 1 {name=p17839 lab=_54848_/X }
C {sky130_stdcells/and4_4.sym} 18260 -20380 0 0 {name=X_54848_ }
C {devices/lab_pin.sym} 18180 -20250 0 0 {name=p17840 lab=_87002_/Q }
C {devices/lab_pin.sym} 18180 -20210 0 0 {name=p17841 lab=_56550_/X }
C {devices/lab_pin.sym} 18180 -20170 0 0 {name=p17842 lab=_73681_/X }
C {devices/lab_pin.sym} 18340 -20210 0 1 {name=p17843 lab=_73694_/C }
C {sky130_stdcells/o21ai_4.sym} 18260 -20210 0 0 {name=X_73682_ }
C {devices/lab_pin.sym} 18170 -20070 0 0 {name=p17844 lab=_85471_/CLK }
C {devices/lab_pin.sym} 18170 -20050 0 0 {name=p17845 lab=_85668_/D }
C {devices/lab_pin.sym} 18350 -20070 0 1 {name=p17846 lab=_85668_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -20060 0 0 {name=X_85668_ }
C {devices/lab_pin.sym} 18180 -19950 0 0 {name=p17847 lab=_50981_/B }
C {devices/lab_pin.sym} 18180 -19910 0 0 {name=p17848 lab=_70885_/X }
C {devices/lab_pin.sym} 18180 -19870 0 0 {name=p17849 lab=_70893_/Y }
C {devices/lab_pin.sym} 18340 -19910 0 1 {name=p17850 lab=_70894_/Y }
C {sky130_stdcells/o21ai_4.sym} 18260 -19910 0 0 {name=X_70894_ }
C {devices/lab_pin.sym} 18180 -19810 0 0 {name=p17851 lab=_44593_/X }
C {devices/lab_pin.sym} 18180 -19770 0 0 {name=p17852 lab=_44594_/X }
C {devices/lab_pin.sym} 18180 -19730 0 0 {name=p17853 lab=_40929_/A }
C {devices/lab_pin.sym} 18180 -19690 0 0 {name=p17854 lab=_44600_/Y }
C {devices/lab_pin.sym} 18180 -19650 0 0 {name=p17855 lab=_44596_/X }
C {devices/lab_pin.sym} 18340 -19730 0 1 {name=p17856 lab=_44601_/Y }
C {sky130_stdcells/o32ai_4.sym} 18260 -19730 0 0 {name=X_44601_ }
C {devices/lab_pin.sym} 18200 -19580 0 0 {name=p17857 lab=_75419_/X }
C {devices/lab_pin.sym} 18200 -19540 0 0 {name=p17858 lab=_75420_/Y }
C {devices/lab_pin.sym} 18320 -19560 0 1 {name=p17859 lab=_75421_/X }
C {sky130_stdcells/xor2_4.sym} 18260 -19560 0 0 {name=X_75421_ }
C {devices/lab_pin.sym} 18170 -19430 0 0 {name=p17860 lab=_87472_/CLK }
C {devices/lab_pin.sym} 18170 -19410 0 0 {name=p17861 lab=_87407_/D }
C {devices/lab_pin.sym} 18350 -19430 0 1 {name=p17862 lab=_87407_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -19420 0 0 {name=X_87407_ }
C {devices/lab_pin.sym} 18220 -19290 0 0 {name=p17863 lab=_48164_/A }
C {devices/lab_pin.sym} 18300 -19290 0 1 {name=p17864 lab=_41813_/X }
C {sky130_stdcells/buf_2.sym} 18260 -19290 0 0 {name=X_41813_ }
C {devices/lab_pin.sym} 18220 -19170 0 0 {name=p17865 lab=_72687_/A }
C {devices/lab_pin.sym} 18300 -19170 0 1 {name=p17866 lab=_72633_/X }
C {sky130_stdcells/buf_2.sym} 18260 -19170 0 0 {name=X_72633_ }
C {devices/lab_pin.sym} 18170 -19050 0 0 {name=p17867 lab=_84590_/CLK }
C {devices/lab_pin.sym} 18170 -19030 0 0 {name=p17868 lab=_60373_/X }
C {devices/lab_pin.sym} 18350 -19050 0 1 {name=p17869 lab=_79538_/A }
C {sky130_stdcells/dfxtp_4.sym} 18260 -19040 0 0 {name=X_84619_ }
C {devices/lab_pin.sym} 18200 -18930 0 0 {name=p17870 lab=_57567_/A }
C {devices/lab_pin.sym} 18200 -18890 0 0 {name=p17871 lab=_49317_/X }
C {devices/lab_pin.sym} 18200 -18850 0 0 {name=p17872 lab=_46603_/X }
C {devices/lab_pin.sym} 18320 -18890 0 1 {name=p17873 lab=_57567_/X }
C {sky130_stdcells/and3_4.sym} 18260 -18890 0 0 {name=X_57567_ }
C {devices/lab_pin.sym} 18220 -18750 0 0 {name=p17874 lab=_85077_/Q }
C {devices/lab_pin.sym} 18300 -18750 0 1 {name=p17875 lab=_45581_/Y }
C {sky130_stdcells/inv_2.sym} 18260 -18750 0 0 {name=X_45581_ }
C {devices/lab_pin.sym} 18170 -18630 0 0 {name=p17876 lab=_88387_/CLK }
C {devices/lab_pin.sym} 18170 -18610 0 0 {name=p17877 lab=_40470_/X }
C {devices/lab_pin.sym} 18350 -18630 0 1 {name=p17878 lab=_88387_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -18620 0 0 {name=X_88387_ }
C {devices/lab_pin.sym} 18180 -18530 0 0 {name=p17879 lab=_42774_/X }
C {devices/lab_pin.sym} 18180 -18490 0 0 {name=p17880 lab=_42775_/X }
C {devices/lab_pin.sym} 18180 -18450 0 0 {name=p17881 lab=_41376_/X }
C {devices/lab_pin.sym} 18180 -18410 0 0 {name=p17882 lab=_87714_/Q }
C {devices/lab_pin.sym} 18180 -18370 0 0 {name=p17883 lab=_42781_/X }
C {devices/lab_pin.sym} 18340 -18450 0 1 {name=p17884 lab=_42794_/A }
C {sky130_stdcells/o32ai_4.sym} 18260 -18450 0 0 {name=X_42793_ }
C {devices/lab_pin.sym} 18220 -18290 0 0 {name=p17885 lab=_54807_/A }
C {devices/lab_pin.sym} 18300 -18290 0 1 {name=p17886 lab=_54798_/A }
C {sky130_stdcells/buf_2.sym} 18260 -18290 0 0 {name=X_54779_ }
C {devices/lab_pin.sym} 18170 -18170 0 0 {name=p17887 lab=_85599_/CLK }
C {devices/lab_pin.sym} 18170 -18150 0 0 {name=p17888 lab=_53632_/Y }
C {devices/lab_pin.sym} 18350 -18170 0 1 {name=p17889 lab=_85599_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -18160 0 0 {name=X_85599_ }
C {devices/lab_pin.sym} 18200 -18040 0 0 {name=p17890 lab=_86664_/Q }
C {devices/lab_pin.sym} 18200 -18000 0 0 {name=p17891 lab=_59306_/B }
C {devices/lab_pin.sym} 18320 -18020 0 1 {name=p17892 lab=_59306_/Y }
C {sky130_stdcells/nor2_4.sym} 18260 -18020 0 0 {name=X_59306_ }
C {devices/lab_pin.sym} 18220 -17890 0 0 {name=p17893 lab=_47320_/A }
C {devices/lab_pin.sym} 18300 -17890 0 1 {name=p17894 lab=_52982_/D }
C {sky130_stdcells/buf_2.sym} 18260 -17890 0 0 {name=X_47320_ }
C {devices/lab_pin.sym} 18200 -17780 0 0 {name=p17895 lab=_82571_/Q }
C {devices/lab_pin.sym} 18200 -17740 0 0 {name=p17896 lab=_82483_/Q }
C {devices/lab_pin.sym} 18320 -17760 0 1 {name=p17897 lab=_78143_/A }
C {sky130_stdcells/xor2_4.sym} 18260 -17760 0 0 {name=X_78140_ }
C {devices/lab_pin.sym} 18220 -17630 0 0 {name=p17898 lab=_44532_/A }
C {devices/lab_pin.sym} 18300 -17630 0 1 {name=p17899 lab=_44533_/A }
C {sky130_stdcells/buf_2.sym} 18260 -17630 0 0 {name=X_44532_ }
C {devices/lab_pin.sym} 18200 -17530 0 0 {name=p17900 lab=_56523_/A }
C {devices/lab_pin.sym} 18200 -17490 0 0 {name=p17901 lab=_56520_/B }
C {devices/lab_pin.sym} 18200 -17450 0 0 {name=p17902 lab=_56518_/C }
C {devices/lab_pin.sym} 18320 -17490 0 1 {name=p17903 lab=_56518_/Y }
C {sky130_stdcells/nand3_4.sym} 18260 -17490 0 0 {name=X_56518_ }
C {devices/lab_pin.sym} 18200 -17370 0 0 {name=p17904 lab=_75348_/Y }
C {devices/lab_pin.sym} 18200 -17330 0 0 {name=p17905 lab=_75349_/Y }
C {devices/lab_pin.sym} 18200 -17290 0 0 {name=p17906 lab=_75351_/Y }
C {devices/lab_pin.sym} 18320 -17330 0 1 {name=p17907 lab=_75354_/A }
C {sky130_stdcells/or3_4.sym} 18260 -17330 0 0 {name=X_75352_ }
C {devices/lab_pin.sym} 18170 -17190 0 0 {name=p17908 lab=_86988_/CLK }
C {devices/lab_pin.sym} 18170 -17170 0 0 {name=p17909 lab=_43622_/Y }
C {devices/lab_pin.sym} 18350 -17190 0 1 {name=p17910 lab=_87338_/Q }
C {sky130_stdcells/dfxtp_4.sym} 18260 -17180 0 0 {name=X_87338_ }
C {devices/lab_pin.sym} 18180 -17070 0 0 {name=p17911 lab=_41577_/X }
C {devices/lab_pin.sym} 18180 -17030 0 0 {name=p17912 lab=_82891_/Q }
C {devices/lab_pin.sym} 18180 -16990 0 0 {name=p17913 lab=_41743_/X }
C {devices/lab_pin.sym} 18340 -17030 0 1 {name=p17914 lab=_41744_/Y }
C {sky130_stdcells/o21ai_4.sym} 18260 -17030 0 0 {name=X_41744_ }
C {devices/lab_pin.sym} 18220 -16890 0 0 {name=p17915 lab=_72564_/A }
C {devices/lab_pin.sym} 18300 -16890 0 1 {name=p17916 lab=_72573_/B }
C {sky130_stdcells/buf_2.sym} 18260 -16890 0 0 {name=X_72564_ }
C {devices/lab_pin.sym} 18180 -16790 0 0 {name=p17917 lab=_57496_/Y }
C {devices/lab_pin.sym} 18180 -16750 0 0 {name=p17918 lab=_46576_/X }
C {devices/lab_pin.sym} 18180 -16710 0 0 {name=p17919 lab=_57497_/Y }
C {devices/lab_pin.sym} 18340 -16750 0 1 {name=p17920 lab=_84992_/D }
C {sky130_stdcells/a21boi_4.sym} 18260 -16750 0 0 {name=X_57498_ }
C {devices/lab_pin.sym} 18220 -16610 0 0 {name=p17921 lab=_74342_/A }
C {devices/lab_pin.sym} 18300 -16610 0 1 {name=p17922 lab=_74310_/B }
C {sky130_stdcells/buf_2.sym} 18260 -16610 0 0 {name=X_74303_ }
C {devices/lab_pin.sym} 18220 -16490 0 0 {name=p17923 lab=_83390_/Q }
C {devices/lab_pin.sym} 18300 -16490 0 1 {name=p17924 lab=_54106_/B }
C {sky130_stdcells/inv_2.sym} 18260 -16490 0 0 {name=X_47251_ }
C {devices/lab_pin.sym} 18220 -16370 0 0 {name=p17925 lab=_58864_/A }
C {devices/lab_pin.sym} 18300 -16370 0 1 {name=p17926 lab=_59237_/X }
C {sky130_stdcells/buf_2.sym} 18260 -16370 0 0 {name=X_59237_ }
C {devices/lab_pin.sym} 18200 -16260 0 0 {name=p17927 lab=_71521_/A }
C {devices/lab_pin.sym} 18200 -16220 0 0 {name=p17928 lab=_70714_/A }
C {devices/lab_pin.sym} 18320 -16240 0 1 {name=p17929 lab=_71515_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -16240 0 0 {name=X_71515_ }
C {devices/lab_pin.sym} 18200 -16120 0 0 {name=p17930 lab=_60746_/C }
C {devices/lab_pin.sym} 18200 -16080 0 0 {name=p17931 lab=_78071_/B }
C {devices/lab_pin.sym} 18320 -16100 0 1 {name=p17932 lab=_78071_/X }
C {sky130_stdcells/xor2_4.sym} 18260 -16100 0 0 {name=X_78071_ }
C {devices/lab_pin.sym} 18180 -16000 0 0 {name=p17933 lab=_41151_/A }
C {devices/lab_pin.sym} 18180 -15960 0 0 {name=p17934 lab=_44453_/X }
C {devices/lab_pin.sym} 18180 -15920 0 0 {name=p17935 lab=_87096_/Q }
C {devices/lab_pin.sym} 18180 -15880 0 0 {name=p17936 lab=_44454_/X }
C {devices/lab_pin.sym} 18340 -15940 0 1 {name=p17937 lab=_87096_/D }
C {sky130_stdcells/a2bb2o_4.sym} 18260 -15940 0 0 {name=X_44463_ }
