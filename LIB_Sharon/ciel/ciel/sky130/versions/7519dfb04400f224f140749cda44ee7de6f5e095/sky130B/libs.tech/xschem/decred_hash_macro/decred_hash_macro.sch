C {devices/lab_pin.sym} 111220 -17270 0 1 {name=p110482 lab=_88144_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 111180 -17270 0 0 {name=Xclkbuf_10_695_0_CLK }
C {devices/lab_pin.sym} 111100 -17170 0 0 {name=p110483 lab=_67119_/X }
C {devices/lab_pin.sym} 111100 -17130 0 0 {name=p110484 lab=_67124_/X }
C {devices/lab_pin.sym} 111100 -17090 0 0 {name=p110485 lab=_67026_/X }
C {devices/lab_pin.sym} 111260 -17130 0 1 {name=p110486 lab=_67130_/A }
C {sky130_stdcells/a21o_4.sym} 111180 -17130 0 0 {name=X_67125_ }
C {devices/lab_pin.sym} 111120 -17010 0 0 {name=p110487 lab=_50142_/A }
C {devices/lab_pin.sym} 111120 -16970 0 0 {name=p110488 lab=_52310_/B }
C {devices/lab_pin.sym} 111120 -16930 0 0 {name=p110489 lab=_52291_/C }
C {devices/lab_pin.sym} 111240 -16970 0 1 {name=p110490 lab=_52351_/X }
C {sky130_stdcells/and3_4.sym} 111180 -16970 0 0 {name=X_52351_ }
C {devices/lab_pin.sym} 111100 -16850 0 0 {name=p110491 lab=_58320_/A }
C {devices/lab_pin.sym} 111100 -16810 0 0 {name=p110492 lab=_64308_/X }
C {devices/lab_pin.sym} 111100 -16770 0 0 {name=p110493 lab=_64336_/Y }
C {devices/lab_pin.sym} 111260 -16810 0 1 {name=p110494 lab=_64337_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -16810 0 0 {name=X_64337_ }
C {devices/lab_pin.sym} 111090 -16670 0 0 {name=p110495 lab=_83161_/CLK }
C {devices/lab_pin.sym} 111090 -16650 0 0 {name=p110496 lab=_72942_/X }
C {devices/lab_pin.sym} 111270 -16670 0 1 {name=p110497 lab=_83171_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -16660 0 0 {name=X_83171_ }
C {devices/lab_pin.sym} 111140 -16530 0 0 {name=p110498 lab=_58382_/A }
C {devices/lab_pin.sym} 111220 -16530 0 1 {name=p110499 lab=_61549_/X }
C {sky130_stdcells/buf_2.sym} 111180 -16530 0 0 {name=X_61549_ }
C {devices/lab_pin.sym} 111120 -16420 0 0 {name=p110500 lab=_80372_/X }
C {devices/lab_pin.sym} 111120 -16380 0 0 {name=p110501 lab=_80383_/B }
C {devices/lab_pin.sym} 111240 -16400 0 1 {name=p110502 lab=_80384_/D }
C {sky130_stdcells/nand2_4.sym} 111180 -16400 0 0 {name=X_80383_ }
C {devices/lab_pin.sym} 111140 -16270 0 0 {name=p110503 lab=clkbuf_8_93_0_CLK/X }
C {devices/lab_pin.sym} 111220 -16270 0 1 {name=p110504 lab=clkbuf_9_186_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 111180 -16270 0 0 {name=Xclkbuf_9_186_0_CLK }
C {devices/lab_pin.sym} 111120 -16160 0 0 {name=p110505 lab=_51298_/A }
C {devices/lab_pin.sym} 111120 -16120 0 0 {name=p110506 lab=_46407_/A }
C {devices/lab_pin.sym} 111240 -16140 0 1 {name=p110507 lab=_51302_/X }
C {sky130_stdcells/and2_4.sym} 111180 -16140 0 0 {name=X_51302_ }
C {devices/lab_pin.sym} 111090 -16010 0 0 {name=p110508 lab=_82485_/CLK }
C {devices/lab_pin.sym} 111090 -15990 0 0 {name=p110509 lab=_77805_/X }
C {devices/lab_pin.sym} 111270 -16010 0 1 {name=p110510 lab=_82110_/D }
C {sky130_stdcells/dfxtp_4.sym} 111180 -16000 0 0 {name=X_82122_ }
C {devices/lab_pin.sym} 111120 -15900 0 0 {name=p110511 lab=_55083_/A }
C {devices/lab_pin.sym} 111120 -15860 0 0 {name=p110512 lab=_55056_/X }
C {devices/lab_pin.sym} 111120 -15820 0 0 {name=p110513 lab=_55070_/C }
C {devices/lab_pin.sym} 111120 -15780 0 0 {name=p110514 lab=_47729_/Y }
C {devices/lab_pin.sym} 111240 -15840 0 1 {name=p110515 lab=_55070_/X }
C {sky130_stdcells/and4_4.sym} 111180 -15840 0 0 {name=X_55070_ }
C {devices/lab_pin.sym} 111140 -15690 0 0 {name=p110516 lab=_67055_/X }
C {devices/lab_pin.sym} 111220 -15690 0 1 {name=p110517 lab=_67056_/X }
C {sky130_stdcells/buf_2.sym} 111180 -15690 0 0 {name=X_67056_ }
C {devices/lab_pin.sym} 111100 -15590 0 0 {name=p110518 lab=_52278_/Y }
C {devices/lab_pin.sym} 111100 -15550 0 0 {name=p110519 lab=_52262_/X }
C {devices/lab_pin.sym} 111100 -15510 0 0 {name=p110520 lab=_52281_/X }
C {devices/lab_pin.sym} 111260 -15550 0 1 {name=p110521 lab=_52282_/Y }
C {sky130_stdcells/a21oi_4.sym} 111180 -15550 0 0 {name=X_52282_ }
C {devices/lab_pin.sym} 111100 -15450 0 0 {name=p110522 lab=_64259_/X }
C {devices/lab_pin.sym} 111100 -15410 0 0 {name=p110523 lab=_64261_/X }
C {devices/lab_pin.sym} 111100 -15370 0 0 {name=p110524 lab=_64262_/X }
C {devices/lab_pin.sym} 111100 -15330 0 0 {name=p110525 lab=_64266_/Y }
C {devices/lab_pin.sym} 111100 -15290 0 0 {name=p110526 lab=_64267_/X }
C {devices/lab_pin.sym} 111260 -15370 0 1 {name=p110527 lab=_64268_/X }
C {sky130_stdcells/o41a_4.sym} 111180 -15370 0 0 {name=X_64268_ }
C {devices/lab_pin.sym} 111100 -15230 0 0 {name=p110528 lab=_85521_/Q }
C {devices/lab_pin.sym} 111100 -15190 0 0 {name=p110529 lab=_54018_/X }
C {devices/lab_pin.sym} 111100 -15150 0 0 {name=p110530 lab=_54020_/Y }
C {devices/lab_pin.sym} 111260 -15190 0 1 {name=p110531 lab=_54021_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -15190 0 0 {name=X_54021_ }
C {devices/lab_pin.sym} 111100 -15080 0 0 {name=p110532 lab=_64714_/X }
C {devices/lab_pin.sym} 111100 -15040 0 0 {name=p110533 lab=_86234_/Q }
C {devices/lab_pin.sym} 111100 -15000 0 0 {name=p110534 lab=_65904_/X }
C {devices/lab_pin.sym} 111100 -14960 0 0 {name=p110535 lab=_66006_/X }
C {devices/lab_pin.sym} 111260 -15020 0 1 {name=p110536 lab=_66007_/X }
C {sky130_stdcells/a211o_4.sym} 111180 -15020 0 0 {name=X_66007_ }
C {devices/lab_pin.sym} 111140 -14870 0 0 {name=p110537 lab=_50113_/A }
C {devices/lab_pin.sym} 111220 -14870 0 1 {name=p110538 lab=_51233_/X }
C {sky130_stdcells/buf_2.sym} 111180 -14870 0 0 {name=X_51233_ }
C {devices/lab_pin.sym} 111140 -14750 0 0 {name=p110539 lab=_60489_/X }
C {devices/lab_pin.sym} 111220 -14750 0 1 {name=p110540 lab=_63295_/C }
C {sky130_stdcells/buf_2.sym} 111180 -14750 0 0 {name=X_63219_ }
C {devices/lab_pin.sym} 111090 -14630 0 0 {name=p110541 lab=_82053_/CLK }
C {devices/lab_pin.sym} 111090 -14610 0 0 {name=p110542 lab=_82053_/D }
C {devices/lab_pin.sym} 111270 -14630 0 1 {name=p110543 lab=_82053_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -14620 0 0 {name=X_82053_ }
C {devices/lab_pin.sym} 111090 -14490 0 0 {name=p110544 lab=_86930_/CLK }
C {devices/lab_pin.sym} 111090 -14470 0 0 {name=p110545 lab=_44831_/X }
C {devices/lab_pin.sym} 111270 -14490 0 1 {name=p110546 lab=_67654_/B }
C {sky130_stdcells/dfxtp_4.sym} 111180 -14480 0 0 {name=X_86930_ }
C {devices/lab_pin.sym} 111140 -14350 0 0 {name=p110547 lab=_64508_/A }
C {devices/lab_pin.sym} 111220 -14350 0 1 {name=p110548 lab=_64490_/B }
C {sky130_stdcells/buf_2.sym} 111180 -14350 0 0 {name=X_64199_ }
C {devices/lab_pin.sym} 111090 -14230 0 0 {name=p110549 lab=_84210_/CLK }
C {devices/lab_pin.sym} 111090 -14210 0 0 {name=p110550 lab=_84212_/Q }
C {devices/lab_pin.sym} 111270 -14230 0 1 {name=p110551 lab=_81004_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -14220 0 0 {name=X_81004_ }
C {devices/lab_pin.sym} 111140 -14090 0 0 {name=p110552 lab=_51191_/A }
C {devices/lab_pin.sym} 111220 -14090 0 1 {name=p110553 lab=_51177_/A }
C {sky130_stdcells/buf_2.sym} 111180 -14090 0 0 {name=X_51164_ }
C {devices/lab_pin.sym} 111090 -13970 0 0 {name=p110554 lab=_86861_/CLK }
C {devices/lab_pin.sym} 111090 -13950 0 0 {name=p110555 lab=_45687_/Y }
C {devices/lab_pin.sym} 111270 -13970 0 1 {name=p110556 lab=_63217_/B }
C {sky130_stdcells/dfxtp_4.sym} 111180 -13960 0 0 {name=X_86861_ }
C {devices/lab_pin.sym} 111120 -13840 0 0 {name=p110557 lab=_50120_/A }
C {devices/lab_pin.sym} 111120 -13800 0 0 {name=p110558 lab=_49006_/X }
C {devices/lab_pin.sym} 111240 -13820 0 1 {name=p110559 lab=_50115_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -13820 0 0 {name=X_50115_ }
C {devices/lab_pin.sym} 111090 -13690 0 0 {name=p110560 lab=_86422_/CLK }
C {devices/lab_pin.sym} 111090 -13670 0 0 {name=p110561 lab=_52489_/Y }
C {devices/lab_pin.sym} 111270 -13690 0 1 {name=p110562 lab=_85812_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -13680 0 0 {name=X_85812_ }
C {devices/lab_pin.sym} 111100 -13570 0 0 {name=p110563 lab=_58667_/X }
C {devices/lab_pin.sym} 111100 -13530 0 0 {name=p110564 lab=_86098_/Q }
C {devices/lab_pin.sym} 111100 -13490 0 0 {name=p110565 lab=_58759_/X }
C {devices/lab_pin.sym} 111260 -13530 0 1 {name=p110566 lab=_58760_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -13530 0 0 {name=X_58760_ }
C {devices/lab_pin.sym} 111120 -13420 0 0 {name=p110567 lab=_51084_/A }
C {devices/lab_pin.sym} 111120 -13380 0 0 {name=p110568 lab=_51115_/B }
C {devices/lab_pin.sym} 111120 -13340 0 0 {name=p110569 lab=_51110_/C }
C {devices/lab_pin.sym} 111120 -13300 0 0 {name=p110570 lab=_52785_/D }
C {devices/lab_pin.sym} 111240 -13360 0 1 {name=p110571 lab=_51095_/X }
C {sky130_stdcells/and4_4.sym} 111180 -13360 0 0 {name=X_51095_ }
C {devices/lab_pin.sym} 111120 -13220 0 0 {name=p110572 lab=_55698_/A }
C {devices/lab_pin.sym} 111120 -13180 0 0 {name=p110573 lab=_85311_/Q }
C {devices/lab_pin.sym} 111240 -13200 0 1 {name=p110574 lab=_55972_/X }
C {sky130_stdcells/and2_4.sym} 111180 -13200 0 0 {name=X_55972_ }
C {devices/lab_pin.sym} 111140 -13070 0 0 {name=p110575 lab=_68644_/A }
C {devices/lab_pin.sym} 111220 -13070 0 1 {name=p110576 lab=_68025_/A }
C {sky130_stdcells/buf_2.sym} 111180 -13070 0 0 {name=X_67958_ }
C {devices/lab_pin.sym} 111090 -12950 0 0 {name=p110577 lab=_87086_/CLK }
C {devices/lab_pin.sym} 111090 -12930 0 0 {name=p110578 lab=_86792_/D }
C {devices/lab_pin.sym} 111270 -12950 0 1 {name=p110579 lab=_86792_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -12940 0 0 {name=X_86792_ }
C {devices/lab_pin.sym} 111140 -12810 0 0 {name=p110580 lab=clkbuf_9_316_0_CLK/X }
C {devices/lab_pin.sym} 111220 -12810 0 1 {name=p110581 lab=_81211_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 111180 -12810 0 0 {name=Xclkbuf_10_633_0_CLK }
C {devices/lab_pin.sym} 111140 -12690 0 0 {name=p110582 lab=_57965_/A }
C {devices/lab_pin.sym} 111220 -12690 0 1 {name=p110583 lab=_57711_/X }
C {sky130_stdcells/buf_2.sym} 111180 -12690 0 0 {name=X_57711_ }
C {devices/lab_pin.sym} 111120 -12600 0 0 {name=p110584 lab=_50050_/A }
C {devices/lab_pin.sym} 111120 -12560 0 0 {name=p110585 lab=_50045_/X }
C {devices/lab_pin.sym} 111120 -12520 0 0 {name=p110586 lab=_51750_/C }
C {devices/lab_pin.sym} 111120 -12480 0 0 {name=p110587 lab=_53257_/D }
C {devices/lab_pin.sym} 111240 -12540 0 1 {name=p110588 lab=_50046_/X }
C {sky130_stdcells/and4_4.sym} 111180 -12540 0 0 {name=X_50046_ }
C {devices/lab_pin.sym} 111100 -12410 0 0 {name=p110589 lab=_54921_/Y }
C {devices/lab_pin.sym} 111100 -12370 0 0 {name=p110590 lab=_54909_/X }
C {devices/lab_pin.sym} 111100 -12330 0 0 {name=p110591 lab=_54922_/X }
C {devices/lab_pin.sym} 111260 -12370 0 1 {name=p110592 lab=_54923_/Y }
C {sky130_stdcells/a21oi_4.sym} 111180 -12370 0 0 {name=X_54923_ }
C {devices/lab_pin.sym} 111120 -12240 0 0 {name=p110593 lab=_66909_/A }
C {devices/lab_pin.sym} 111120 -12200 0 0 {name=p110594 lab=_66908_/X }
C {devices/lab_pin.sym} 111240 -12220 0 1 {name=p110595 lab=_66909_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -12220 0 0 {name=X_66909_ }
C {devices/lab_pin.sym} 111090 -12090 0 0 {name=p110596 lab=_85745_/CLK }
C {devices/lab_pin.sym} 111090 -12070 0 0 {name=p110597 lab=_52854_/Y }
C {devices/lab_pin.sym} 111270 -12090 0 1 {name=p110598 lab=_85743_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -12080 0 0 {name=X_85743_ }
C {devices/lab_pin.sym} 111100 -11970 0 0 {name=p110599 lab=_58591_/X }
C {devices/lab_pin.sym} 111100 -11930 0 0 {name=p110600 lab=_85463_/Q }
C {devices/lab_pin.sym} 111100 -11890 0 0 {name=p110601 lab=_58690_/X }
C {devices/lab_pin.sym} 111260 -11930 0 1 {name=p110602 lab=_58691_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -11930 0 0 {name=X_58691_ }
C {devices/lab_pin.sym} 111090 -11790 0 0 {name=p110603 lab=_82769_/CLK }
C {devices/lab_pin.sym} 111090 -11770 0 0 {name=p110604 lab=_82955_/D }
C {devices/lab_pin.sym} 111270 -11790 0 1 {name=p110605 lab=_82955_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -11780 0 0 {name=X_82955_ }
C {devices/lab_pin.sym} 111120 -11660 0 0 {name=p110606 lab=_67817_/X }
C {devices/lab_pin.sym} 111120 -11620 0 0 {name=p110607 lab=_67889_/B }
C {devices/lab_pin.sym} 111240 -11640 0 1 {name=p110608 lab=_67889_/X }
C {sky130_stdcells/and2_4.sym} 111180 -11640 0 0 {name=X_67889_ }
C {devices/lab_pin.sym} 111140 -11510 0 0 {name=p110609 lab=clkbuf_8_62_0_CLK/X }
C {devices/lab_pin.sym} 111220 -11510 0 1 {name=p110610 lab=clkbuf_9_124_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 111180 -11510 0 0 {name=Xclkbuf_9_124_0_CLK }
C {devices/lab_pin.sym} 111120 -11400 0 0 {name=p110611 lab=_71972_/A }
C {devices/lab_pin.sym} 111120 -11360 0 0 {name=p110612 lab=_48141_/A }
C {devices/lab_pin.sym} 111240 -11380 0 1 {name=p110613 lab=_57642_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -11380 0 0 {name=X_57642_ }
C {devices/lab_pin.sym} 111090 -11250 0 0 {name=p110614 lab=_82131_/CLK }
C {devices/lab_pin.sym} 111090 -11230 0 0 {name=p110615 lab=_81906_/D }
C {devices/lab_pin.sym} 111270 -11250 0 1 {name=p110616 lab=_81906_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -11240 0 0 {name=X_81906_ }
C {devices/lab_pin.sym} 111100 -11140 0 0 {name=p110617 lab=_87067_/Q }
C {devices/lab_pin.sym} 111100 -11100 0 0 {name=p110618 lab=_44225_/B }
C {devices/lab_pin.sym} 111100 -11060 0 0 {name=p110619 lab=_57800_/A }
C {devices/lab_pin.sym} 111100 -11020 0 0 {name=p110620 lab=_69627_/X }
C {devices/lab_pin.sym} 111260 -11080 0 1 {name=p110621 lab=_69628_/X }
C {sky130_stdcells/a211o_4.sym} 111180 -11080 0 0 {name=X_69628_ }
C {devices/lab_pin.sym} 111120 -10940 0 0 {name=p110622 lab=_54850_/A }
C {devices/lab_pin.sym} 111120 -10900 0 0 {name=p110623 lab=_47639_/Y }
C {devices/lab_pin.sym} 111240 -10920 0 1 {name=p110624 lab=_54854_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -10920 0 0 {name=X_54854_ }
C {devices/lab_pin.sym} 111090 -10790 0 0 {name=p110625 lab=_86400_/CLK }
C {devices/lab_pin.sym} 111090 -10770 0 0 {name=p110626 lab=_53224_/Y }
C {devices/lab_pin.sym} 111270 -10790 0 1 {name=p110627 lab=_85674_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -10780 0 0 {name=X_85674_ }
C {devices/lab_pin.sym} 111140 -10650 0 0 {name=p110628 lab=clkbuf_9_51_0_CLK/A }
C {devices/lab_pin.sym} 111220 -10650 0 1 {name=p110629 lab=clkbuf_9_51_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 111180 -10650 0 0 {name=Xclkbuf_9_51_0_CLK }
C {devices/lab_pin.sym} 111090 -10530 0 0 {name=p110630 lab=_82886_/CLK }
C {devices/lab_pin.sym} 111090 -10510 0 0 {name=p110631 lab=_78107_/B }
C {devices/lab_pin.sym} 111270 -10530 0 1 {name=p110632 lab=_82886_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -10520 0 0 {name=X_82886_ }
C {devices/lab_pin.sym} 111090 -10390 0 0 {name=p110633 lab=_87926_/CLK }
C {devices/lab_pin.sym} 111090 -10370 0 0 {name=p110634 lab=_43458_/Y }
C {devices/lab_pin.sym} 111270 -10390 0 1 {name=p110635 lab=_87413_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -10380 0 0 {name=X_87413_ }
C {devices/lab_pin.sym} 111140 -10250 0 0 {name=p110636 lab=_53763_/A }
C {devices/lab_pin.sym} 111220 -10250 0 1 {name=p110637 lab=_53806_/C }
C {sky130_stdcells/buf_2.sym} 111180 -10250 0 0 {name=X_53805_ }
C {devices/lab_pin.sym} 111090 -10130 0 0 {name=p110638 lab=_81857_/CLK }
C {devices/lab_pin.sym} 111090 -10110 0 0 {name=p110639 lab=_60352_/X }
C {devices/lab_pin.sym} 111270 -10130 0 1 {name=p110640 lab=_79629_/A }
C {sky130_stdcells/dfxtp_4.sym} 111180 -10120 0 0 {name=X_84625_ }
C {devices/lab_pin.sym} 111100 -10010 0 0 {name=p110641 lab=_57570_/Y }
C {devices/lab_pin.sym} 111100 -9970 0 0 {name=p110642 lab=_57506_/X }
C {devices/lab_pin.sym} 111100 -9930 0 0 {name=p110643 lab=_57572_/X }
C {devices/lab_pin.sym} 111260 -9970 0 1 {name=p110644 lab=_84977_/D }
C {sky130_stdcells/a21oi_4.sym} 111180 -9970 0 0 {name=X_57573_ }
C {devices/lab_pin.sym} 111100 -9860 0 0 {name=p110645 lab=_87008_/Q }
C {devices/lab_pin.sym} 111100 -9820 0 0 {name=p110646 lab=_44181_/X }
C {devices/lab_pin.sym} 111100 -9780 0 0 {name=p110647 lab=_69430_/X }
C {devices/lab_pin.sym} 111100 -9740 0 0 {name=p110648 lab=_69558_/X }
C {devices/lab_pin.sym} 111260 -9800 0 1 {name=p110649 lab=_69559_/X }
C {sky130_stdcells/a211o_4.sym} 111180 -9800 0 0 {name=X_69559_ }
C {devices/lab_pin.sym} 111090 -9650 0 0 {name=p110650 lab=_82221_/CLK }
C {devices/lab_pin.sym} 111090 -9630 0 0 {name=p110651 lab=_81869_/Q }
C {devices/lab_pin.sym} 111270 -9650 0 1 {name=p110652 lab=_77380_/A }
C {sky130_stdcells/dfxtp_4.sym} 111180 -9640 0 0 {name=X_81837_ }
C {devices/lab_pin.sym} 111090 -9510 0 0 {name=p110653 lab=_88398_/CLK }
C {devices/lab_pin.sym} 111090 -9490 0 0 {name=p110654 lab=_40428_/Y }
C {devices/lab_pin.sym} 111270 -9510 0 1 {name=p110655 lab=_88393_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -9500 0 0 {name=X_88393_ }
C {devices/lab_pin.sym} 111140 -9370 0 0 {name=p110656 lab=_54758_/A }
C {devices/lab_pin.sym} 111220 -9370 0 1 {name=p110657 lab=_54790_/A }
C {sky130_stdcells/buf_2.sym} 111180 -9370 0 0 {name=X_54785_ }
C {devices/lab_pin.sym} 111120 -9260 0 0 {name=p110658 lab=_52027_/A }
C {devices/lab_pin.sym} 111120 -9220 0 0 {name=p110659 lab=_50293_/B }
C {devices/lab_pin.sym} 111240 -9240 0 1 {name=p110660 lab=_51997_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -9240 0 0 {name=X_51997_ }
C {devices/lab_pin.sym} 111140 -9110 0 0 {name=p110661 lab=clkbuf_9_324_0_CLK/X }
C {devices/lab_pin.sym} 111220 -9110 0 1 {name=p110662 lab=_86930_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 111180 -9110 0 0 {name=Xclkbuf_10_648_0_CLK }
C {devices/lab_pin.sym} 111100 -9010 0 0 {name=p110663 lab=_59311_/X }
C {devices/lab_pin.sym} 111100 -8970 0 0 {name=p110664 lab=_85736_/Q }
C {devices/lab_pin.sym} 111100 -8930 0 0 {name=p110665 lab=_59263_/X }
C {devices/lab_pin.sym} 111260 -8970 0 1 {name=p110666 lab=_59312_/X }
C {sky130_stdcells/o21a_4.sym} 111180 -8970 0 0 {name=X_59312_ }
C {devices/lab_pin.sym} 111100 -8850 0 0 {name=p110667 lab=_56130_/X }
C {devices/lab_pin.sym} 111100 -8810 0 0 {name=p110668 lab=_56515_/X }
C {devices/lab_pin.sym} 111100 -8770 0 0 {name=p110669 lab=_56523_/Y }
C {devices/lab_pin.sym} 111260 -8810 0 1 {name=p110670 lab=_56524_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -8810 0 0 {name=X_56524_ }
C {devices/lab_pin.sym} 111140 -8670 0 0 {name=p110671 lab=_41799_/A }
C {devices/lab_pin.sym} 111220 -8670 0 1 {name=p110672 lab=_41750_/X }
C {sky130_stdcells/buf_2.sym} 111180 -8670 0 0 {name=X_41750_ }
C {devices/lab_pin.sym} 111090 -8550 0 0 {name=p110673 lab=_88324_/CLK }
C {devices/lab_pin.sym} 111090 -8530 0 0 {name=p110674 lab=_87344_/D }
C {devices/lab_pin.sym} 111270 -8550 0 1 {name=p110675 lab=_87344_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -8540 0 0 {name=X_87344_ }
C {devices/lab_pin.sym} 111120 -8420 0 0 {name=p110676 lab=_53750_/A }
C {devices/lab_pin.sym} 111120 -8380 0 0 {name=p110677 lab=_48615_/A }
C {devices/lab_pin.sym} 111240 -8400 0 1 {name=p110678 lab=_53736_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -8400 0 0 {name=X_53736_ }
C {devices/lab_pin.sym} 111120 -8290 0 0 {name=p110679 lab=_72517_/A }
C {devices/lab_pin.sym} 111120 -8250 0 0 {name=p110680 lab=_72517_/B }
C {devices/lab_pin.sym} 111120 -8210 0 0 {name=p110681 lab=_72570_/C }
C {devices/lab_pin.sym} 111240 -8250 0 1 {name=p110682 lab=_72570_/Y }
C {sky130_stdcells/nand3_4.sym} 111180 -8250 0 0 {name=X_72570_ }
C {devices/lab_pin.sym} 111090 -8110 0 0 {name=p110683 lab=_84590_/CLK }
C {devices/lab_pin.sym} 111090 -8090 0 0 {name=p110684 lab=_84556_/D }
C {devices/lab_pin.sym} 111270 -8110 0 1 {name=p110685 lab=_84556_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -8100 0 0 {name=X_84556_ }
C {devices/lab_pin.sym} 111120 -8000 0 0 {name=p110686 lab=_50963_/A }
C {devices/lab_pin.sym} 111120 -7960 0 0 {name=p110687 lab=_50941_/B }
C {devices/lab_pin.sym} 111120 -7920 0 0 {name=p110688 lab=_50948_/C }
C {devices/lab_pin.sym} 111120 -7880 0 0 {name=p110689 lab=_46728_/X }
C {devices/lab_pin.sym} 111240 -7940 0 1 {name=p110690 lab=_50948_/X }
C {sky130_stdcells/and4_4.sym} 111180 -7940 0 0 {name=X_50948_ }
C {devices/lab_pin.sym} 111090 -7790 0 0 {name=p110691 lab=_83133_/CLK }
C {devices/lab_pin.sym} 111090 -7770 0 0 {name=p110692 lab=_81768_/D }
C {devices/lab_pin.sym} 111270 -7790 0 1 {name=p110693 lab=_49139_/B }
C {sky130_stdcells/dfxtp_4.sym} 111180 -7780 0 0 {name=X_81768_ }
C {devices/lab_pin.sym} 111140 -7650 0 0 {name=p110694 lab=clkbuf_8_69_0_CLK/X }
C {devices/lab_pin.sym} 111220 -7650 0 1 {name=p110695 lab=clkbuf_9_139_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 111180 -7650 0 0 {name=Xclkbuf_9_139_0_CLK }
C {devices/lab_pin.sym} 111100 -7550 0 0 {name=p110696 lab=_40698_/X }
C {devices/lab_pin.sym} 111100 -7510 0 0 {name=p110697 lab=_82861_/Q }
C {devices/lab_pin.sym} 111100 -7470 0 0 {name=p110698 lab=_40700_/X }
C {devices/lab_pin.sym} 111260 -7510 0 1 {name=p110699 lab=_40702_/A }
C {sky130_stdcells/o21a_4.sym} 111180 -7510 0 0 {name=X_40701_ }
C {devices/lab_pin.sym} 111120 -7380 0 0 {name=p110700 lab=_71521_/A }
C {devices/lab_pin.sym} 111120 -7340 0 0 {name=p110701 lab=_70722_/A }
C {devices/lab_pin.sym} 111240 -7360 0 1 {name=p110702 lab=_71521_/Y }
C {sky130_stdcells/nand2_4.sym} 111180 -7360 0 0 {name=X_71521_ }
C {devices/lab_pin.sym} 111100 -7260 0 0 {name=p110703 lab=_59229_/Y }
C {devices/lab_pin.sym} 111100 -7220 0 0 {name=p110704 lab=_59230_/X }
C {devices/lab_pin.sym} 111100 -7180 0 0 {name=p110705 lab=_59236_/X }
C {devices/lab_pin.sym} 111100 -7140 0 0 {name=p110706 lab=_59242_/X }
C {devices/lab_pin.sym} 111260 -7200 0 1 {name=p110707 lab=_59243_/Y }
C {sky130_stdcells/a22oi_4.sym} 111180 -7200 0 0 {name=X_59243_ }
C {devices/lab_pin.sym} 111090 -7050 0 0 {name=p110708 lab=_83507_/CLK }
C {devices/lab_pin.sym} 111090 -7030 0 0 {name=p110709 lab=_71414_/X }
C {devices/lab_pin.sym} 111270 -7050 0 1 {name=p110710 lab=_83507_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -7040 0 0 {name=X_83507_ }
C {devices/lab_pin.sym} 111140 -6910 0 0 {name=p110711 lab=clkbuf_9_67_0_CLK/A }
C {devices/lab_pin.sym} 111220 -6910 0 1 {name=p110712 lab=clkbuf_9_66_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 111180 -6910 0 0 {name=Xclkbuf_9_66_0_CLK }
C {devices/lab_pin.sym} 111100 -6810 0 0 {name=p110713 lab=_56168_/X }
C {devices/lab_pin.sym} 111100 -6770 0 0 {name=p110714 lab=_56372_/X }
C {devices/lab_pin.sym} 111100 -6730 0 0 {name=p110715 lab=_56454_/Y }
C {devices/lab_pin.sym} 111260 -6770 0 1 {name=p110716 lab=_56455_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -6770 0 0 {name=X_56455_ }
C {devices/lab_pin.sym} 111090 -6630 0 0 {name=p110717 lab=_80719_/CLK }
C {devices/lab_pin.sym} 111090 -6610 0 0 {name=p110718 lab=_75905_/X }
C {devices/lab_pin.sym} 111270 -6630 0 1 {name=p110719 lab=_80687_/D }
C {sky130_stdcells/dfxtp_4.sym} 111180 -6620 0 0 {name=X_80719_ }
C {devices/lab_pin.sym} 111090 -6490 0 0 {name=p110720 lab=_88056_/CLK }
C {devices/lab_pin.sym} 111090 -6470 0 0 {name=p110721 lab=_43768_/Y }
C {devices/lab_pin.sym} 111270 -6490 0 1 {name=p110722 lab=_87275_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -6480 0 0 {name=X_87275_ }
C {devices/lab_pin.sym} 111140 -6350 0 0 {name=p110723 lab=_41680_/Y }
C {devices/lab_pin.sym} 111220 -6350 0 1 {name=p110724 lab=_41681_/X }
C {sky130_stdcells/buf_2.sym} 111180 -6350 0 0 {name=X_41681_ }
C {devices/lab_pin.sym} 111120 -6250 0 0 {name=p110725 lab=_50443_/A }
C {devices/lab_pin.sym} 111120 -6210 0 0 {name=p110726 lab=_53666_/X }
C {devices/lab_pin.sym} 111120 -6170 0 0 {name=p110727 lab=_53667_/C }
C {devices/lab_pin.sym} 111240 -6210 0 1 {name=p110728 lab=_53667_/X }
C {sky130_stdcells/and3_4.sym} 111180 -6210 0 0 {name=X_53667_ }
C {devices/lab_pin.sym} 111090 -6070 0 0 {name=p110729 lab=_84487_/CLK }
C {devices/lab_pin.sym} 111090 -6050 0 0 {name=p110730 lab=_61363_/Y }
C {devices/lab_pin.sym} 111270 -6070 0 1 {name=p110731 lab=_84487_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -6060 0 0 {name=X_84487_ }
C {devices/lab_pin.sym} 111100 -5950 0 0 {name=p110732 lab=_86114_/Q }
C {devices/lab_pin.sym} 111100 -5910 0 0 {name=p110733 lab=_50820_/X }
C {devices/lab_pin.sym} 111100 -5870 0 0 {name=p110734 lab=_50878_/Y }
C {devices/lab_pin.sym} 111260 -5910 0 1 {name=p110735 lab=_50879_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -5910 0 0 {name=X_50879_ }
C {devices/lab_pin.sym} 111090 -5770 0 0 {name=p110736 lab=_84014_/CLK }
C {devices/lab_pin.sym} 111090 -5750 0 0 {name=p110737 lab=_81699_/D }
C {devices/lab_pin.sym} 111270 -5770 0 1 {name=p110738 lab=_81699_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -5760 0 0 {name=X_81699_ }
C {sky130_stdcells/decap_3.sym} 111180 -5600 0 0 {name=XPHY_200 }
C {devices/lab_pin.sym} 111100 -5480 0 0 {name=p110739 lab=_41529_/X }
C {devices/lab_pin.sym} 111100 -5440 0 0 {name=p110740 lab=_43412_/X }
C {devices/lab_pin.sym} 111100 -5400 0 0 {name=p110741 lab=_87429_/Q }
C {devices/lab_pin.sym} 111100 -5360 0 0 {name=p110742 lab=_43413_/X }
C {devices/lab_pin.sym} 111260 -5420 0 1 {name=p110743 lab=_43420_/X }
C {sky130_stdcells/a2bb2o_4.sym} 111180 -5420 0 0 {name=X_43420_ }
C {devices/lab_pin.sym} 111120 -5280 0 0 {name=p110744 lab=_56777_/A }
C {devices/lab_pin.sym} 111120 -5240 0 0 {name=p110745 lab=_55405_/X }
C {devices/lab_pin.sym} 111240 -5260 0 1 {name=p110746 lab=_55415_/A }
C {sky130_stdcells/nand2_4.sym} 111180 -5260 0 0 {name=X_55406_ }
C {devices/lab_pin.sym} 111120 -5140 0 0 {name=p110747 lab=_57637_/B }
C {devices/lab_pin.sym} 111120 -5100 0 0 {name=p110748 lab=_74239_/Y }
C {devices/lab_pin.sym} 111240 -5120 0 1 {name=p110749 lab=_74241_/B }
C {sky130_stdcells/xor2_4.sym} 111180 -5120 0 0 {name=X_74240_ }
C {devices/lab_pin.sym} 111090 -4990 0 0 {name=p110750 lab=_85630_/CLK }
C {devices/lab_pin.sym} 111090 -4970 0 0 {name=p110751 lab=_86226_/D }
C {devices/lab_pin.sym} 111270 -4990 0 1 {name=p110752 lab=_86226_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -4980 0 0 {name=X_86226_ }
C {sky130_stdcells/decap_3.sym} 111180 -4820 0 0 {name=XPHY_211 }
C {devices/lab_pin.sym} 111100 -4690 0 0 {name=p110753 lab=_40628_/X }
C {devices/lab_pin.sym} 111100 -4650 0 0 {name=p110754 lab=_81145_/Q }
C {devices/lab_pin.sym} 111100 -4610 0 0 {name=p110755 lab=_40631_/X }
C {devices/lab_pin.sym} 111260 -4650 0 1 {name=p110756 lab=_40632_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -4650 0 0 {name=X_40632_ }
C {devices/lab_pin.sym} 111140 -4510 0 0 {name=p110757 lab=_52618_/A }
C {devices/lab_pin.sym} 111220 -4510 0 1 {name=p110758 lab=_52619_/A }
C {sky130_stdcells/buf_2.sym} 111180 -4510 0 0 {name=X_52618_ }
C {devices/lab_pin.sym} 111100 -4430 0 0 {name=p110759 lab=_59115_/X }
C {devices/lab_pin.sym} 111100 -4390 0 0 {name=p110760 lab=_59172_/Y }
C {devices/lab_pin.sym} 111100 -4350 0 0 {name=p110761 lab=_59173_/Y }
C {devices/lab_pin.sym} 111100 -4310 0 0 {name=p110762 lab=_59133_/X }
C {devices/lab_pin.sym} 111100 -4270 0 0 {name=p110763 lab=_59119_/X }
C {devices/lab_pin.sym} 111260 -4350 0 1 {name=p110764 lab=_59174_/X }
C {sky130_stdcells/o32a_4.sym} 111180 -4350 0 0 {name=X_59174_ }
C {devices/lab_pin.sym} 111120 -4210 0 0 {name=p110765 lab=_70679_/A }
C {devices/lab_pin.sym} 111120 -4170 0 0 {name=p110766 lab=_71626_/C }
C {devices/lab_pin.sym} 111120 -4130 0 0 {name=p110767 lab=_71450_/C }
C {devices/lab_pin.sym} 111240 -4170 0 1 {name=p110768 lab=_71452_/Y }
C {sky130_stdcells/nor3_4.sym} 111180 -4170 0 0 {name=X_71452_ }
C {devices/lab_pin.sym} 111090 -4030 0 0 {name=p110769 lab=_83438_/CLK }
C {devices/lab_pin.sym} 111090 -4010 0 0 {name=p110770 lab=_83438_/D }
C {devices/lab_pin.sym} 111270 -4030 0 1 {name=p110771 lab=_83438_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -4020 0 0 {name=X_83438_ }
C {devices/lab_pin.sym} 111120 -3910 0 0 {name=p110772 lab=_56383_/X }
C {devices/lab_pin.sym} 111120 -3870 0 0 {name=p110773 lab=_56386_/B }
C {devices/lab_pin.sym} 111120 -3830 0 0 {name=p110774 lab=_56386_/C }
C {devices/lab_pin.sym} 111240 -3870 0 1 {name=p110775 lab=_56386_/Y }
C {sky130_stdcells/nand3_4.sym} 111180 -3870 0 0 {name=X_56386_ }
C {sky130_stdcells/decap_3.sym} 111180 -3700 0 0 {name=XPHY_222 }
C {devices/lab_pin.sym} 111100 -3570 0 0 {name=p110776 lab=_85605_/Q }
C {devices/lab_pin.sym} 111100 -3530 0 0 {name=p110777 lab=_53586_/X }
C {devices/lab_pin.sym} 111100 -3490 0 0 {name=p110778 lab=_53597_/Y }
C {devices/lab_pin.sym} 111260 -3530 0 1 {name=p110779 lab=_53598_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -3530 0 0 {name=X_53598_ }
C {sky130_stdcells/decap_3.sym} 111180 -3360 0 0 {name=XPHY_233 }
C {sky130_stdcells/decap_3.sym} 111180 -3180 0 0 {name=XPHY_244 }
C {devices/lab_pin.sym} 111140 -3030 0 0 {name=p110780 lab=_58846_/A }
C {devices/lab_pin.sym} 111220 -3030 0 1 {name=p110781 lab=_58125_/X }
C {sky130_stdcells/buf_2.sym} 111180 -3030 0 0 {name=X_58125_ }
C {devices/lab_pin.sym} 111100 -2930 0 0 {name=p110782 lab=_51389_/B }
C {devices/lab_pin.sym} 111100 -2890 0 0 {name=p110783 lab=_70364_/A }
C {devices/lab_pin.sym} 111100 -2850 0 0 {name=p110784 lab=_70402_/Y }
C {devices/lab_pin.sym} 111260 -2890 0 1 {name=p110785 lab=_70403_/Y }
C {sky130_stdcells/o21ai_4.sym} 111180 -2890 0 0 {name=X_70403_ }
C {sky130_stdcells/decap_3.sym} 111180 -2720 0 0 {name=XPHY_255 }
C {devices/lab_pin.sym} 111120 -2580 0 0 {name=p110786 lab=_55323_/A }
C {devices/lab_pin.sym} 111120 -2540 0 0 {name=p110787 lab=_56705_/B }
C {devices/lab_pin.sym} 111240 -2560 0 1 {name=p110788 lab=_55337_/X }
C {sky130_stdcells/and2_4.sym} 111180 -2560 0 0 {name=X_55337_ }
C {devices/lab_pin.sym} 111100 -2470 0 0 {name=p110789 lab=_43347_/X }
C {devices/lab_pin.sym} 111100 -2430 0 0 {name=p110790 lab=_43350_/X }
C {devices/lab_pin.sym} 111100 -2390 0 0 {name=p110791 lab=_41341_/X }
C {devices/lab_pin.sym} 111100 -2350 0 0 {name=p110792 lab=_87465_/Q }
C {devices/lab_pin.sym} 111100 -2310 0 0 {name=p110793 lab=_43330_/X }
C {devices/lab_pin.sym} 111260 -2390 0 1 {name=p110794 lab=_43352_/A }
C {sky130_stdcells/o32ai_4.sym} 111180 -2390 0 0 {name=X_43351_ }
C {devices/lab_pin.sym} 111120 -2240 0 0 {name=p110795 lab=_74168_/X }
C {devices/lab_pin.sym} 111120 -2200 0 0 {name=p110796 lab=_74170_/X }
C {devices/lab_pin.sym} 111240 -2220 0 1 {name=p110797 lab=_74181_/A }
C {sky130_stdcells/nand2_4.sym} 111180 -2220 0 0 {name=X_74171_ }
C {devices/lab_pin.sym} 111090 -2090 0 0 {name=p110798 lab=_85837_/CLK }
C {devices/lab_pin.sym} 111090 -2070 0 0 {name=p110799 lab=_50669_/Y }
C {devices/lab_pin.sym} 111270 -2090 0 1 {name=p110800 lab=_86157_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -2080 0 0 {name=X_86157_ }
C {devices/lab_pin.sym} 111140 -1950 0 0 {name=p110801 lab=_51922_/X }
C {devices/lab_pin.sym} 111220 -1950 0 1 {name=p110802 lab=_52549_/X }
C {sky130_stdcells/buf_2.sym} 111180 -1950 0 0 {name=X_52549_ }
C {devices/lab_pin.sym} 111120 -1860 0 0 {name=p110803 lab=_41869_/B }
C {devices/lab_pin.sym} 111120 -1820 0 0 {name=p110804 lab=_42447_/B }
C {devices/lab_pin.sym} 111120 -1780 0 0 {name=p110805 lab=_41869_/A }
C {devices/lab_pin.sym} 111120 -1740 0 0 {name=p110806 lab=_42447_/D }
C {devices/lab_pin.sym} 111240 -1800 0 1 {name=p110807 lab=_40563_/X }
C {sky130_stdcells/and4_4.sym} 111180 -1800 0 0 {name=X_40563_ }
C {sky130_stdcells/decap_3.sym} 111180 -1620 0 0 {name=XPHY_266 }
C {devices/lab_pin.sym} 111120 -1490 0 0 {name=p110808 lab=_70679_/A }
C {devices/lab_pin.sym} 111120 -1450 0 0 {name=p110809 lab=_71377_/B }
C {devices/lab_pin.sym} 111120 -1410 0 0 {name=p110810 lab=_71377_/C }
C {devices/lab_pin.sym} 111240 -1450 0 1 {name=p110811 lab=_71383_/Y }
C {sky130_stdcells/nor3_4.sym} 111180 -1450 0 0 {name=X_71383_ }
C {devices/lab_pin.sym} 111090 -1310 0 0 {name=p110812 lab=_83380_/CLK }
C {devices/lab_pin.sym} 111090 -1290 0 0 {name=p110813 lab=_83369_/D }
C {devices/lab_pin.sym} 111270 -1310 0 1 {name=p110814 lab=_83369_/Q }
C {sky130_stdcells/dfxtp_4.sym} 111180 -1300 0 0 {name=X_83369_ }
C {sky130_stdcells/decap_3.sym} 111180 -1140 0 0 {name=XPHY_277 }
C {sky130_stdcells/decap_3.sym} 111180 -960 0 0 {name=XPHY_288 }
C {devices/lab_pin.sym} 111100 -840 0 0 {name=p110815 lab=_41586_/X }
C {devices/lab_pin.sym} 111100 -800 0 0 {name=p110816 lab=_42290_/X }
C {devices/lab_pin.sym} 111100 -760 0 0 {name=p110817 lab=_87931_/Q }
C {devices/lab_pin.sym} 111100 -720 0 0 {name=p110818 lab=_42291_/X }
C {devices/lab_pin.sym} 111260 -780 0 1 {name=p110819 lab=_87931_/D }
C {sky130_stdcells/a2bb2o_4.sym} 111180 -780 0 0 {name=X_42302_ }
C {devices/lab_pin.sym} 112040 -42160 0 0 {name=p110820 lab=_73121_/X }
C {devices/lab_pin.sym} 112040 -42120 0 0 {name=p110821 lab=_73191_/B }
C {devices/lab_pin.sym} 112160 -42140 0 1 {name=p110822 lab=_73122_/X }
C {sky130_stdcells/and2_4.sym} 112100 -42140 0 0 {name=X_73122_ }
C {devices/lab_pin.sym} 112010 -42010 0 0 {name=p110823 lab=_85042_/CLK }
C {devices/lab_pin.sym} 112010 -41990 0 0 {name=p110824 lab=_85108_/D }
C {devices/lab_pin.sym} 112190 -42010 0 1 {name=p110825 lab=_45597_/A }
C {sky130_stdcells/dfxtp_4.sym} 112100 -42000 0 0 {name=X_85108_ }
C {sky130_stdcells/decap_3.sym} 112100 -41840 0 0 {name=XPHY_299 }
C {devices/lab_pin.sym} 112060 -41690 0 0 {name=p110826 lab=_46070_/A }
C {devices/lab_pin.sym} 112140 -41690 0 1 {name=p110827 lab=_46070_/Y }
C {sky130_stdcells/inv_2.sym} 112100 -41690 0 0 {name=X_46070_ }
C {devices/lab_pin.sym} 112020 -41610 0 0 {name=p110828 lab=_57989_/X }
C {devices/lab_pin.sym} 112020 -41570 0 0 {name=p110829 lab=_58054_/Y }
C {devices/lab_pin.sym} 112020 -41530 0 0 {name=p110830 lab=_58055_/Y }
C {devices/lab_pin.sym} 112020 -41490 0 0 {name=p110831 lab=_58007_/X }
C {devices/lab_pin.sym} 112020 -41450 0 0 {name=p110832 lab=_57993_/X }
C {devices/lab_pin.sym} 112180 -41530 0 1 {name=p110833 lab=_58056_/X }
C {sky130_stdcells/o32a_4.sym} 112100 -41530 0 0 {name=X_58056_ }
C {devices/lab_pin.sym} 112020 -41390 0 0 {name=p110834 lab=_70320_/X }
C {devices/lab_pin.sym} 112020 -41350 0 0 {name=p110835 lab=_83794_/Q }
C {devices/lab_pin.sym} 112020 -41310 0 0 {name=p110836 lab=_70333_/X }
C {devices/lab_pin.sym} 112180 -41350 0 1 {name=p110837 lab=_83794_/D }
C {sky130_stdcells/a21o_4.sym} 112100 -41350 0 0 {name=X_70334_ }
C {devices/lab_pin.sym} 112020 -41240 0 0 {name=p110838 lab=_41147_/X }
C {devices/lab_pin.sym} 112020 -41200 0 0 {name=p110839 lab=_43277_/X }
C {devices/lab_pin.sym} 112020 -41160 0 0 {name=p110840 lab=_87501_/Q }
C {devices/lab_pin.sym} 112020 -41120 0 0 {name=p110841 lab=_43278_/X }
C {devices/lab_pin.sym} 112180 -41180 0 1 {name=p110842 lab=_43282_/X }
C {sky130_stdcells/a2bb2o_4.sym} 112100 -41180 0 0 {name=X_43282_ }
C {devices/lab_pin.sym} 112020 -41060 0 0 {name=p110843 lab=_45811_/A }
C {devices/lab_pin.sym} 112020 -41020 0 0 {name=p110844 lab=_55174_/X }
C {devices/lab_pin.sym} 112020 -40980 0 0 {name=p110845 lab=_55128_/X }
C {devices/lab_pin.sym} 112020 -40940 0 0 {name=p110846 lab=_55267_/X }
C {devices/lab_pin.sym} 112180 -41000 0 1 {name=p110847 lab=_55268_/X }
C {sky130_stdcells/a211o_4.sym} 112100 -41000 0 0 {name=X_55268_ }
C {devices/lab_pin.sym} 112010 -40850 0 0 {name=p110848 lab=_85767_/CLK }
C {devices/lab_pin.sym} 112010 -40830 0 0 {name=p110849 lab=_51025_/Y }
C {devices/lab_pin.sym} 112190 -40850 0 1 {name=p110850 lab=_86088_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -40840 0 0 {name=X_86088_ }
C {devices/lab_pin.sym} 112060 -40710 0 0 {name=p110851 lab=_40494_/A }
C {devices/lab_pin.sym} 112140 -40710 0 1 {name=p110852 lab=_40494_/Y }
C {sky130_stdcells/inv_2.sym} 112100 -40710 0 0 {name=X_40494_ }
C {devices/lab_pin.sym} 112020 -40610 0 0 {name=p110853 lab=_45018_/X }
C {devices/lab_pin.sym} 112020 -40570 0 0 {name=p110854 lab=_45020_/Y }
C {devices/lab_pin.sym} 112020 -40530 0 0 {name=p110855 lab=_44973_/X }
C {devices/lab_pin.sym} 112180 -40570 0 1 {name=p110856 lab=_45021_/Y }
C {sky130_stdcells/a21oi_4.sym} 112100 -40570 0 0 {name=X_45021_ }
C {devices/lab_pin.sym} 112060 -40430 0 0 {name=p110857 lab=_56778_/Y }
C {devices/lab_pin.sym} 112140 -40430 0 1 {name=p110858 lab=_57007_/X }
C {sky130_stdcells/buf_2.sym} 112100 -40430 0 0 {name=X_57007_ }
C {devices/lab_pin.sym} 112060 -40310 0 0 {name=p110859 lab=_42232_/Y }
C {devices/lab_pin.sym} 112140 -40310 0 1 {name=p110860 lab=_87969_/D }
C {sky130_stdcells/inv_2.sym} 112100 -40310 0 0 {name=X_42233_ }
C {devices/lab_pin.sym} 112020 -40210 0 0 {name=p110861 lab=_54216_/Y }
C {devices/lab_pin.sym} 112020 -40170 0 0 {name=p110862 lab=_54197_/X }
C {devices/lab_pin.sym} 112020 -40130 0 0 {name=p110863 lab=_54218_/X }
C {devices/lab_pin.sym} 112180 -40170 0 1 {name=p110864 lab=_54219_/Y }
C {sky130_stdcells/a21oi_4.sym} 112100 -40170 0 0 {name=X_54219_ }
C {devices/lab_pin.sym} 112020 -40060 0 0 {name=p110865 lab=_77908_/A }
C {devices/lab_pin.sym} 112020 -40020 0 0 {name=p110866 lab=_77907_/Y }
C {devices/lab_pin.sym} 112020 -39980 0 0 {name=p110867 lab=_77920_/A }
C {devices/lab_pin.sym} 112020 -39940 0 0 {name=p110868 lab=_77919_/Y }
C {devices/lab_pin.sym} 112180 -40000 0 1 {name=p110869 lab=_77930_/X }
C {sky130_stdcells/o22a_4.sym} 112100 -40000 0 0 {name=X_77930_ }
C {devices/lab_pin.sym} 112040 -39860 0 0 {name=p110870 lab=_87816_/Q }
C {devices/lab_pin.sym} 112040 -39820 0 0 {name=p110871 lab=_73053_/B }
C {devices/lab_pin.sym} 112160 -39840 0 1 {name=p110872 lab=_73053_/Y }
C {sky130_stdcells/nor2_4.sym} 112100 -39840 0 0 {name=X_73053_ }
C {devices/lab_pin.sym} 112010 -39710 0 0 {name=p110873 lab=_85039_/CLK }
C {devices/lab_pin.sym} 112010 -39690 0 0 {name=p110874 lab=_57295_/Y }
C {devices/lab_pin.sym} 112190 -39710 0 1 {name=p110875 lab=_85039_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -39700 0 0 {name=X_85039_ }
C {devices/lab_pin.sym} 112040 -39600 0 0 {name=p110876 lab=_70267_/A }
C {devices/lab_pin.sym} 112040 -39560 0 0 {name=p110877 lab=_70267_/B }
C {devices/lab_pin.sym} 112040 -39520 0 0 {name=p110878 lab=_83178_/Q }
C {devices/lab_pin.sym} 112040 -39480 0 0 {name=p110879 lab=_70264_/X }
C {devices/lab_pin.sym} 112160 -39540 0 1 {name=p110880 lab=_70265_/X }
C {sky130_stdcells/and4_4.sym} 112100 -39540 0 0 {name=X_70265_ }
C {devices/lab_pin.sym} 112060 -39390 0 0 {name=p110881 lab=_55199_/A }
C {devices/lab_pin.sym} 112140 -39390 0 1 {name=p110882 lab=_55200_/C }
C {sky130_stdcells/buf_2.sym} 112100 -39390 0 0 {name=X_55199_ }
C {devices/lab_pin.sym} 112020 -39290 0 0 {name=p110883 lab=_83304_/Q }
C {devices/lab_pin.sym} 112020 -39250 0 0 {name=p110884 lab=_72001_/X }
C {devices/lab_pin.sym} 112020 -39210 0 0 {name=p110885 lab=_72003_/Y }
C {devices/lab_pin.sym} 112180 -39250 0 1 {name=p110886 lab=_72004_/Y }
C {sky130_stdcells/o21ai_4.sym} 112100 -39250 0 0 {name=X_72004_ }
C {devices/lab_pin.sym} 112020 -39140 0 0 {name=p110887 lab=_41203_/X }
C {devices/lab_pin.sym} 112020 -39100 0 0 {name=p110888 lab=_42161_/X }
C {devices/lab_pin.sym} 112020 -39060 0 0 {name=p110889 lab=_88002_/Q }
C {devices/lab_pin.sym} 112020 -39020 0 0 {name=p110890 lab=_42162_/X }
C {devices/lab_pin.sym} 112180 -39080 0 1 {name=p110891 lab=_88002_/D }
C {sky130_stdcells/a2bb2o_4.sym} 112100 -39080 0 0 {name=X_42164_ }
C {devices/lab_pin.sym} 112040 -38940 0 0 {name=p110892 lab=_77861_/A }
C {devices/lab_pin.sym} 112040 -38900 0 0 {name=p110893 lab=_77875_/A }
C {devices/lab_pin.sym} 112160 -38920 0 1 {name=p110894 lab=_77862_/B }
C {sky130_stdcells/xor2_4.sym} 112100 -38920 0 0 {name=X_77861_ }
C {devices/lab_pin.sym} 112040 -38820 0 0 {name=p110895 lab=_70200_/A }
C {devices/lab_pin.sym} 112040 -38780 0 0 {name=p110896 lab=_70200_/B }
C {devices/lab_pin.sym} 112040 -38740 0 0 {name=p110897 lab=_83201_/Q }
C {devices/lab_pin.sym} 112040 -38700 0 0 {name=p110898 lab=_70200_/D }
C {devices/lab_pin.sym} 112160 -38760 0 1 {name=p110899 lab=_70196_/X }
C {sky130_stdcells/and4_4.sym} 112100 -38760 0 0 {name=X_70196_ }
C {devices/lab_pin.sym} 112060 -38610 0 0 {name=p110900 lab=_79599_/Y }
C {devices/lab_pin.sym} 112140 -38610 0 1 {name=p110901 lab=_79608_/A }
C {sky130_stdcells/inv_2.sym} 112100 -38610 0 0 {name=X_79600_ }
C {devices/lab_pin.sym} 112020 -38510 0 0 {name=p110902 lab=_41073_/X }
C {devices/lab_pin.sym} 112020 -38470 0 0 {name=p110903 lab=_40558_/A }
C {devices/lab_pin.sym} 112020 -38430 0 0 {name=p110904 lab=_41114_/X }
C {devices/lab_pin.sym} 112180 -38470 0 1 {name=p110905 lab=_41115_/X }
C {sky130_stdcells/o21a_4.sym} 112100 -38470 0 0 {name=X_41115_ }
C {devices/lab_pin.sym} 112040 -38340 0 0 {name=p110906 lab=_76812_/A }
C {devices/lab_pin.sym} 112040 -38300 0 0 {name=p110907 lab=_76811_/Y }
C {devices/lab_pin.sym} 112160 -38320 0 1 {name=p110908 lab=_76812_/X }
C {sky130_stdcells/xor2_4.sym} 112100 -38320 0 0 {name=X_76812_ }
C {devices/lab_pin.sym} 112060 -38190 0 0 {name=p110909 lab=_49678_/X }
C {devices/lab_pin.sym} 112140 -38190 0 1 {name=p110910 lab=_49779_/A }
C {sky130_stdcells/buf_2.sym} 112100 -38190 0 0 {name=X_49760_ }
C {devices/lab_pin.sym} 112060 -38070 0 0 {name=p110911 lab=_46971_/Y }
C {devices/lab_pin.sym} 112140 -38070 0 1 {name=p110912 lab=_52779_/D }
C {sky130_stdcells/buf_2.sym} 112100 -38070 0 0 {name=X_46972_ }
C {devices/lab_pin.sym} 112060 -37950 0 0 {name=p110913 lab=_41881_/A }
C {devices/lab_pin.sym} 112140 -37950 0 1 {name=p110914 lab=_42096_/A }
C {sky130_stdcells/buf_2.sym} 112100 -37950 0 0 {name=X_42095_ }
C {devices/lab_pin.sym} 112040 -37840 0 0 {name=p110915 lab=_86690_/Q }
C {devices/lab_pin.sym} 112040 -37800 0 0 {name=p110916 lab=_58898_/B }
C {devices/lab_pin.sym} 112160 -37820 0 1 {name=p110917 lab=_58958_/Y }
C {sky130_stdcells/nor2_4.sym} 112100 -37820 0 0 {name=X_58958_ }
C {devices/lab_pin.sym} 112040 -37700 0 0 {name=p110918 lab=_82153_/Q }
C {devices/lab_pin.sym} 112040 -37660 0 0 {name=p110919 lab=_77792_/B }
C {devices/lab_pin.sym} 112160 -37680 0 1 {name=p110920 lab=_77792_/X }
C {sky130_stdcells/xor2_4.sym} 112100 -37680 0 0 {name=X_77792_ }
C {devices/lab_pin.sym} 112040 -37560 0 0 {name=p110921 lab=_48557_/A }
C {devices/lab_pin.sym} 112040 -37520 0 0 {name=p110922 lab=_50556_/B }
C {devices/lab_pin.sym} 112160 -37540 0 1 {name=p110923 lab=_48711_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -37540 0 0 {name=X_48711_ }
C {devices/lab_pin.sym} 112040 -37420 0 0 {name=p110924 lab=_65421_/C }
C {devices/lab_pin.sym} 112040 -37380 0 0 {name=p110925 lab=_83250_/Q }
C {devices/lab_pin.sym} 112160 -37400 0 1 {name=p110926 lab=_79531_/X }
C {sky130_stdcells/or2_4.sym} 112100 -37400 0 0 {name=X_79531_ }
C {devices/lab_pin.sym} 112060 -37270 0 0 {name=p110927 lab=_44247_/A }
C {devices/lab_pin.sym} 112140 -37270 0 1 {name=p110928 lab=_45923_/X }
C {sky130_stdcells/buf_2.sym} 112100 -37270 0 0 {name=X_45923_ }
C {devices/lab_pin.sym} 112020 -37190 0 0 {name=p110929 lab=_41040_/X }
C {devices/lab_pin.sym} 112020 -37150 0 0 {name=p110930 lab=_41041_/X }
C {devices/lab_pin.sym} 112020 -37110 0 0 {name=p110931 lab=_41045_/X }
C {devices/lab_pin.sym} 112020 -37070 0 0 {name=p110932 lab=_69401_/B }
C {devices/lab_pin.sym} 112020 -37030 0 0 {name=p110933 lab=_41037_/X }
C {devices/lab_pin.sym} 112180 -37110 0 1 {name=p110934 lab=_41047_/A }
C {sky130_stdcells/o32ai_4.sym} 112100 -37110 0 0 {name=X_41046_ }
C {devices/lab_pin.sym} 112060 -36950 0 0 {name=p110935 lab=_58610_/A }
C {devices/lab_pin.sym} 112140 -36950 0 1 {name=p110936 lab=_57909_/X }
C {sky130_stdcells/buf_2.sym} 112100 -36950 0 0 {name=X_57909_ }
C {devices/lab_pin.sym} 112040 -36840 0 0 {name=p110937 lab=_76738_/Y }
C {devices/lab_pin.sym} 112040 -36800 0 0 {name=p110938 lab=_76742_/Y }
C {devices/lab_pin.sym} 112160 -36820 0 1 {name=p110939 lab=_76743_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -36820 0 0 {name=X_76743_ }
C {devices/lab_pin.sym} 112020 -36710 0 0 {name=p110940 lab=_86341_/Q }
C {devices/lab_pin.sym} 112020 -36670 0 0 {name=p110941 lab=_49687_/X }
C {devices/lab_pin.sym} 112020 -36630 0 0 {name=p110942 lab=_49690_/Y }
C {devices/lab_pin.sym} 112180 -36670 0 1 {name=p110943 lab=_49691_/Y }
C {sky130_stdcells/o21ai_4.sym} 112100 -36670 0 0 {name=X_49691_ }
C {devices/lab_pin.sym} 112020 -36560 0 0 {name=p110944 lab=_73907_/X }
C {devices/lab_pin.sym} 112020 -36520 0 0 {name=p110945 lab=_84977_/Q }
C {devices/lab_pin.sym} 112020 -36480 0 0 {name=p110946 lab=_73859_/X }
C {devices/lab_pin.sym} 112020 -36440 0 0 {name=p110947 lab=_73954_/X }
C {devices/lab_pin.sym} 112180 -36500 0 1 {name=p110948 lab=_73955_/X }
C {sky130_stdcells/a211o_4.sym} 112100 -36500 0 0 {name=X_73955_ }
C {devices/lab_pin.sym} 112020 -36370 0 0 {name=p110949 lab=_58877_/X }
C {devices/lab_pin.sym} 112020 -36330 0 0 {name=p110950 lab=_85928_/Q }
C {devices/lab_pin.sym} 112020 -36290 0 0 {name=p110951 lab=_58810_/X }
C {devices/lab_pin.sym} 112180 -36330 0 1 {name=p110952 lab=_58889_/X }
C {sky130_stdcells/o21a_4.sym} 112100 -36330 0 0 {name=X_58889_ }
C {devices/lab_pin.sym} 112060 -36190 0 0 {name=p110953 lab=clkbuf_8_9_0_CLK/X }
C {devices/lab_pin.sym} 112140 -36190 0 1 {name=p110954 lab=clkbuf_9_19_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 112100 -36190 0 0 {name=Xclkbuf_9_19_0_CLK }
C {devices/lab_pin.sym} 112040 -36080 0 0 {name=p110955 lab=_73040_/A }
C {devices/lab_pin.sym} 112040 -36040 0 0 {name=p110956 lab=_65501_/B }
C {devices/lab_pin.sym} 112160 -36060 0 1 {name=p110957 lab=_72906_/X }
C {sky130_stdcells/and2_4.sym} 112100 -36060 0 0 {name=X_72906_ }
C {devices/lab_pin.sym} 112040 -35940 0 0 {name=p110958 lab=_48642_/A }
C {devices/lab_pin.sym} 112040 -35900 0 0 {name=p110959 lab=_48642_/B }
C {devices/lab_pin.sym} 112160 -35920 0 1 {name=p110960 lab=_48642_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -35920 0 0 {name=X_48642_ }
C {devices/lab_pin.sym} 112060 -35790 0 0 {name=p110961 lab=_60920_/A }
C {devices/lab_pin.sym} 112140 -35790 0 1 {name=p110962 lab=_63761_/A }
C {sky130_stdcells/buf_2.sym} 112100 -35790 0 0 {name=X_60920_ }
C {devices/lab_pin.sym} 112020 -35690 0 0 {name=p110963 lab=_79442_/Y }
C {devices/lab_pin.sym} 112020 -35650 0 0 {name=p110964 lab=_79482_/B }
C {devices/lab_pin.sym} 112020 -35610 0 0 {name=p110965 lab=_79461_/X }
C {devices/lab_pin.sym} 112180 -35650 0 1 {name=p110966 lab=_79462_/Y }
C {sky130_stdcells/a21boi_4.sym} 112100 -35650 0 0 {name=X_79462_ }
C {devices/lab_pin.sym} 112040 -35520 0 0 {name=p110967 lab=_85091_/Q }
C {devices/lab_pin.sym} 112040 -35480 0 0 {name=p110968 lab=_45824_/B }
C {devices/lab_pin.sym} 112160 -35500 0 1 {name=p110969 lab=_45854_/Y }
C {sky130_stdcells/nor2_4.sym} 112100 -35500 0 0 {name=X_45854_ }
C {devices/lab_pin.sym} 112040 -35380 0 0 {name=p110970 lab=_76666_/Y }
C {devices/lab_pin.sym} 112040 -35340 0 0 {name=p110971 lab=_76673_/Y }
C {devices/lab_pin.sym} 112160 -35360 0 1 {name=p110972 lab=_76674_/X }
C {sky130_stdcells/xor2_4.sym} 112100 -35360 0 0 {name=X_76674_ }
C {devices/lab_pin.sym} 112040 -35240 0 0 {name=p110973 lab=_47967_/Y }
C {devices/lab_pin.sym} 112040 -35200 0 0 {name=p110974 lab=_73886_/B }
C {devices/lab_pin.sym} 112160 -35220 0 1 {name=p110975 lab=_73886_/X }
C {sky130_stdcells/xor2_4.sym} 112100 -35220 0 0 {name=X_73886_ }
C {devices/lab_pin.sym} 112040 -35100 0 0 {name=p110976 lab=_78413_/A }
C {devices/lab_pin.sym} 112040 -35060 0 0 {name=p110977 lab=_78412_/Y }
C {devices/lab_pin.sym} 112160 -35080 0 1 {name=p110978 lab=_78413_/Y }
C {sky130_stdcells/nor2_4.sym} 112100 -35080 0 0 {name=X_78413_ }
C {devices/lab_pin.sym} 112020 -34980 0 0 {name=p110979 lab=_41453_/Y }
C {devices/lab_pin.sym} 112020 -34940 0 0 {name=p110980 lab=_46258_/A }
C {devices/lab_pin.sym} 112020 -34900 0 0 {name=p110981 lab=_86944_/Q }
C {devices/lab_pin.sym} 112020 -34860 0 0 {name=p110982 lab=_40354_/X }
C {devices/lab_pin.sym} 112180 -34920 0 1 {name=p110983 lab=_86944_/D }
C {sky130_stdcells/a2bb2o_4.sym} 112100 -34920 0 0 {name=X_44805_ }
C {devices/lab_pin.sym} 112060 -34770 0 0 {name=p110984 lab=_75625_/A }
C {devices/lab_pin.sym} 112140 -34770 0 1 {name=p110985 lab=_75625_/Y }
C {sky130_stdcells/inv_2.sym} 112100 -34770 0 0 {name=X_75625_ }
C {devices/lab_pin.sym} 112040 -34660 0 0 {name=p110986 lab=_48604_/A }
C {devices/lab_pin.sym} 112040 -34620 0 0 {name=p110987 lab=_48811_/B }
C {devices/lab_pin.sym} 112160 -34640 0 1 {name=p110988 lab=_48573_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -34640 0 0 {name=X_48573_ }
C {devices/lab_pin.sym} 112040 -34530 0 0 {name=p110989 lab=_60162_/A }
C {devices/lab_pin.sym} 112040 -34490 0 0 {name=p110990 lab=_61287_/A }
C {devices/lab_pin.sym} 112040 -34450 0 0 {name=p110991 lab=_59716_/B }
C {devices/lab_pin.sym} 112160 -34490 0 1 {name=p110992 lab=_60851_/X }
C {sky130_stdcells/and3_4.sym} 112100 -34490 0 0 {name=X_60851_ }
C {devices/lab_pin.sym} 112020 -34380 0 0 {name=p110993 lab=_72806_/X }
C {devices/lab_pin.sym} 112020 -34340 0 0 {name=p110994 lab=_86206_/Q }
C {devices/lab_pin.sym} 112020 -34300 0 0 {name=p110995 lab=_72746_/X }
C {devices/lab_pin.sym} 112020 -34260 0 0 {name=p110996 lab=_72836_/X }
C {devices/lab_pin.sym} 112180 -34320 0 1 {name=p110997 lab=_72837_/X }
C {sky130_stdcells/a211o_4.sym} 112100 -34320 0 0 {name=X_72837_ }
C {devices/lab_pin.sym} 112040 -34180 0 0 {name=p110998 lab=_84806_/Q }
C {devices/lab_pin.sym} 112040 -34140 0 0 {name=p110999 lab=_84126_/Q }
C {devices/lab_pin.sym} 112160 -34160 0 1 {name=p111000 lab=_79395_/A }
C {sky130_stdcells/xor2_4.sym} 112100 -34160 0 0 {name=X_79393_ }
C {devices/lab_pin.sym} 112020 -34050 0 0 {name=p111001 lab=_85128_/Q }
C {devices/lab_pin.sym} 112020 -34010 0 0 {name=p111002 lab=_45709_/X }
C {devices/lab_pin.sym} 112020 -33970 0 0 {name=p111003 lab=_45743_/X }
C {devices/lab_pin.sym} 112180 -34010 0 1 {name=p111004 lab=_45785_/X }
C {sky130_stdcells/o21a_4.sym} 112100 -34010 0 0 {name=X_45785_ }
C {devices/lab_pin.sym} 112020 -33910 0 0 {name=p111005 lab=_42984_/X }
C {devices/lab_pin.sym} 112020 -33870 0 0 {name=p111006 lab=_42985_/X }
C {devices/lab_pin.sym} 112020 -33830 0 0 {name=p111007 lab=_40501_/X }
C {devices/lab_pin.sym} 112020 -33790 0 0 {name=p111008 lab=_67104_/B }
C {devices/lab_pin.sym} 112020 -33750 0 0 {name=p111009 lab=_42463_/A }
C {devices/lab_pin.sym} 112180 -33830 0 1 {name=p111010 lab=_42998_/A }
C {sky130_stdcells/o32ai_4.sym} 112100 -33830 0 0 {name=X_42997_ }
C {devices/lab_pin.sym} 112060 -33670 0 0 {name=p111011 lab=_47619_/A }
C {devices/lab_pin.sym} 112140 -33670 0 1 {name=p111012 lab=_47524_/X }
C {sky130_stdcells/buf_2.sym} 112100 -33670 0 0 {name=X_47524_ }
C {devices/lab_pin.sym} 112040 -33560 0 0 {name=p111013 lab=_78344_/A }
C {devices/lab_pin.sym} 112040 -33520 0 0 {name=p111014 lab=_82661_/D }
C {devices/lab_pin.sym} 112160 -33540 0 1 {name=p111015 lab=_78344_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -33540 0 0 {name=X_78344_ }
C {devices/lab_pin.sym} 112060 -33410 0 0 {name=p111016 lab=clkbuf_9_7_0_CLK/A }
C {devices/lab_pin.sym} 112140 -33410 0 1 {name=p111017 lab=clkbuf_9_7_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 112100 -33410 0 0 {name=Xclkbuf_9_7_0_CLK }
C {devices/lab_pin.sym} 112060 -33290 0 0 {name=p111018 lab=_44736_/A }
C {devices/lab_pin.sym} 112140 -33290 0 1 {name=p111019 lab=_44736_/X }
C {sky130_stdcells/buf_2.sym} 112100 -33290 0 0 {name=X_44736_ }
C {devices/lab_pin.sym} 112020 -33200 0 0 {name=p111020 lab=_58380_/A }
C {devices/lab_pin.sym} 112020 -33160 0 0 {name=p111021 lab=_63558_/X }
C {devices/lab_pin.sym} 112020 -33120 0 0 {name=p111022 lab=_61542_/A }
C {devices/lab_pin.sym} 112020 -33080 0 0 {name=p111023 lab=_63559_/X }
C {devices/lab_pin.sym} 112180 -33140 0 1 {name=p111024 lab=_63570_/X }
C {sky130_stdcells/a2bb2o_4.sym} 112100 -33140 0 0 {name=X_63570_ }
C {devices/lab_pin.sym} 112020 -33010 0 0 {name=p111025 lab=_75543_/B }
C {devices/lab_pin.sym} 112020 -32970 0 0 {name=p111026 lab=_75541_/A }
C {devices/lab_pin.sym} 112020 -32930 0 0 {name=p111027 lab=_75555_/Y }
C {devices/lab_pin.sym} 112180 -32970 0 1 {name=p111028 lab=_75557_/B }
C {sky130_stdcells/a21oi_4.sym} 112100 -32970 0 0 {name=X_75556_ }
C {devices/lab_pin.sym} 112020 -32870 0 0 {name=p111029 lab=_41937_/X }
C {devices/lab_pin.sym} 112020 -32830 0 0 {name=p111030 lab=_41919_/X }
C {devices/lab_pin.sym} 112020 -32790 0 0 {name=p111031 lab=_40696_/X }
C {devices/lab_pin.sym} 112020 -32750 0 0 {name=p111032 lab=_41947_/Y }
C {devices/lab_pin.sym} 112020 -32710 0 0 {name=p111033 lab=_41939_/X }
C {devices/lab_pin.sym} 112180 -32790 0 1 {name=p111034 lab=_41948_/Y }
C {sky130_stdcells/o32ai_4.sym} 112100 -32790 0 0 {name=X_41948_ }
C {devices/lab_pin.sym} 112020 -32650 0 0 {name=p111035 lab=_83177_/Q }
C {devices/lab_pin.sym} 112020 -32610 0 0 {name=p111036 lab=_72709_/X }
C {devices/lab_pin.sym} 112020 -32570 0 0 {name=p111037 lab=_72767_/Y }
C {devices/lab_pin.sym} 112180 -32610 0 1 {name=p111038 lab=_83177_/D }
C {sky130_stdcells/a21o_4.sym} 112100 -32610 0 0 {name=X_72768_ }
C {devices/lab_pin.sym} 112020 -32490 0 0 {name=p111039 lab=_60686_/X }
C {devices/lab_pin.sym} 112020 -32450 0 0 {name=p111040 lab=_60689_/Y }
C {devices/lab_pin.sym} 112020 -32410 0 0 {name=p111041 lab=_60781_/Y }
C {devices/lab_pin.sym} 112180 -32450 0 1 {name=p111042 lab=_60782_/Y }
C {sky130_stdcells/a21boi_4.sym} 112100 -32450 0 0 {name=X_60782_ }
C {devices/lab_pin.sym} 112040 -32320 0 0 {name=p111043 lab=_46272_/A }
C {devices/lab_pin.sym} 112040 -32280 0 0 {name=p111044 lab=_48694_/A }
C {devices/lab_pin.sym} 112160 -32300 0 1 {name=p111045 lab=_74507_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -32300 0 0 {name=X_74507_ }
C {devices/lab_pin.sym} 112020 -32190 0 0 {name=p111046 lab=_64454_/A }
C {devices/lab_pin.sym} 112020 -32150 0 0 {name=p111047 lab=_60042_/D }
C {devices/lab_pin.sym} 112020 -32110 0 0 {name=p111048 lab=_62561_/B }
C {devices/lab_pin.sym} 112180 -32150 0 1 {name=p111049 lab=_62521_/Y }
C {sky130_stdcells/o21ai_4.sym} 112100 -32150 0 0 {name=X_62521_ }
C {devices/lab_pin.sym} 112060 -32010 0 0 {name=p111050 lab=_54748_/D }
C {devices/lab_pin.sym} 112140 -32010 0 1 {name=p111051 lab=_53058_/D }
C {sky130_stdcells/buf_2.sym} 112100 -32010 0 0 {name=X_47455_ }
C {devices/lab_pin.sym} 112040 -31910 0 0 {name=p111052 lab=_70526_/A }
C {devices/lab_pin.sym} 112040 -31870 0 0 {name=p111053 lab=_71246_/B }
C {devices/lab_pin.sym} 112040 -31830 0 0 {name=p111054 lab=_70954_/C }
C {devices/lab_pin.sym} 112160 -31870 0 1 {name=p111055 lab=_71719_/Y }
C {sky130_stdcells/nand3_4.sym} 112100 -31870 0 0 {name=X_71719_ }
C {devices/lab_pin.sym} 112040 -31740 0 0 {name=p111056 lab=_78262_/A }
C {devices/lab_pin.sym} 112040 -31700 0 0 {name=p111057 lab=_78262_/B }
C {devices/lab_pin.sym} 112160 -31720 0 1 {name=p111058 lab=_78275_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -31720 0 0 {name=X_78275_ }
C {devices/lab_pin.sym} 112020 -31620 0 0 {name=p111059 lab=_41104_/A }
C {devices/lab_pin.sym} 112020 -31580 0 0 {name=p111060 lab=_44665_/X }
C {devices/lab_pin.sym} 112020 -31540 0 0 {name=p111061 lab=_87009_/Q }
C {devices/lab_pin.sym} 112020 -31500 0 0 {name=p111062 lab=_44666_/X }
C {devices/lab_pin.sym} 112180 -31560 0 1 {name=p111063 lab=_87009_/D }
C {sky130_stdcells/a2bb2o_4.sym} 112100 -31560 0 0 {name=X_44667_ }
C {devices/lab_pin.sym} 112060 -31410 0 0 {name=p111064 lab=_75485_/X }
C {devices/lab_pin.sym} 112140 -31410 0 1 {name=p111065 lab=_75487_/Y }
C {sky130_stdcells/inv_2.sym} 112100 -31410 0 0 {name=X_75487_ }
C {devices/lab_pin.sym} 112060 -31290 0 0 {name=p111066 lab=_42547_/A }
C {devices/lab_pin.sym} 112140 -31290 0 1 {name=p111067 lab=_41879_/X }
C {sky130_stdcells/buf_2.sym} 112100 -31290 0 0 {name=X_41879_ }
C {devices/lab_pin.sym} 112060 -31170 0 0 {name=p111068 lab=_74139_/A }
C {devices/lab_pin.sym} 112140 -31170 0 1 {name=p111069 lab=_72699_/X }
C {sky130_stdcells/buf_2.sym} 112100 -31170 0 0 {name=X_72699_ }
C {devices/lab_pin.sym} 112020 -31070 0 0 {name=p111070 lab=_46403_/X }
C {devices/lab_pin.sym} 112020 -31030 0 0 {name=p111071 lab=_49019_/A }
C {devices/lab_pin.sym} 112020 -30990 0 0 {name=p111072 lab=_46405_/X }
C {devices/lab_pin.sym} 112180 -31030 0 1 {name=p111073 lab=_46407_/A }
C {sky130_stdcells/o21ai_4.sym} 112100 -31030 0 0 {name=X_46406_ }
C {devices/lab_pin.sym} 112040 -30900 0 0 {name=p111074 lab=_65164_/A }
C {devices/lab_pin.sym} 112040 -30860 0 0 {name=p111075 lab=_86409_/Q }
C {devices/lab_pin.sym} 112160 -30880 0 1 {name=p111076 lab=_65240_/X }
C {sky130_stdcells/and2_4.sym} 112100 -30880 0 0 {name=X_65240_ }
C {devices/lab_pin.sym} 112040 -30760 0 0 {name=p111077 lab=_77223_/Y }
C {devices/lab_pin.sym} 112040 -30720 0 0 {name=p111078 lab=_77225_/Y }
C {devices/lab_pin.sym} 112160 -30740 0 1 {name=p111079 lab=_77230_/A }
C {sky130_stdcells/nand2_4.sym} 112100 -30740 0 0 {name=X_77226_ }
C {devices/lab_pin.sym} 112020 -30640 0 0 {name=p111080 lab=_40626_/X }
C {devices/lab_pin.sym} 112020 -30600 0 0 {name=p111081 lab=_43604_/X }
C {devices/lab_pin.sym} 112020 -30560 0 0 {name=p111082 lab=_87340_/Q }
C {devices/lab_pin.sym} 112020 -30520 0 0 {name=p111083 lab=_43607_/X }
C {devices/lab_pin.sym} 112180 -30580 0 1 {name=p111084 lab=_87340_/D }
C {sky130_stdcells/a2bb2o_4.sym} 112100 -30580 0 0 {name=X_43618_ }
C {devices/lab_pin.sym} 112040 -30460 0 0 {name=p111085 lab=_62479_/A }
C {devices/lab_pin.sym} 112040 -30420 0 0 {name=p111086 lab=_63561_/B }
C {devices/lab_pin.sym} 112040 -30380 0 0 {name=p111087 lab=_62479_/C }
C {devices/lab_pin.sym} 112040 -30340 0 0 {name=p111088 lab=_62392_/D }
C {devices/lab_pin.sym} 112160 -30400 0 1 {name=p111089 lab=_62452_/X }
C {sky130_stdcells/and4_4.sym} 112100 -30400 0 0 {name=X_62452_ }
C {devices/lab_pin.sym} 112020 -30270 0 0 {name=p111090 lab=_83066_/Q }
C {devices/lab_pin.sym} 112020 -30230 0 0 {name=p111091 lab=_74387_/X }
C {devices/lab_pin.sym} 112020 -30190 0 0 {name=p111092 lab=_74437_/Y }
C {devices/lab_pin.sym} 112180 -30230 0 1 {name=p111093 lab=_74438_/Y }
C {sky130_stdcells/o21ai_4.sym} 112100 -30230 0 0 {name=X_74438_ }
C {devices/lab_pin.sym} 112060 -30090 0 0 {name=p111094 lab=_47385_/Y }
C {devices/lab_pin.sym} 112140 -30090 0 1 {name=p111095 lab=_53017_/B }
C {sky130_stdcells/buf_2.sym} 112100 -30090 0 0 {name=X_47386_ }
C {devices/lab_pin.sym} 112060 -29970 0 0 {name=p111096 lab=_87041_/Q }
C {devices/lab_pin.sym} 112140 -29970 0 1 {name=p111097 lab=_44598_/Y }
C {sky130_stdcells/inv_2.sym} 112100 -29970 0 0 {name=X_44598_ }
C {devices/lab_pin.sym} 112060 -29850 0 0 {name=p111098 lab=_72077_/B }
C {devices/lab_pin.sym} 112140 -29850 0 1 {name=p111099 lab=_49125_/X }
C {sky130_stdcells/buf_2.sym} 112100 -29850 0 0 {name=X_49125_ }
C {devices/lab_pin.sym} 112060 -29730 0 0 {name=p111100 lab=_61334_/A }
C {devices/lab_pin.sym} 112140 -29730 0 1 {name=p111101 lab=_61403_/X }
C {sky130_stdcells/buf_2.sym} 112100 -29730 0 0 {name=X_61403_ }
C {devices/lab_pin.sym} 112040 -29620 0 0 {name=p111102 lab=_46337_/A }
C {devices/lab_pin.sym} 112040 -29580 0 0 {name=p111103 lab=_46328_/B }
C {devices/lab_pin.sym} 112160 -29600 0 1 {name=p111104 lab=_46337_/X }
C {sky130_stdcells/or2_4.sym} 112100 -29600 0 0 {name=X_46337_ }
C {devices/lab_pin.sym} 112020 -29490 0 0 {name=p111105 lab=_65167_/Y }
C {devices/lab_pin.sym} 112020 -29450 0 0 {name=p111106 lab=_65070_/X }
C {devices/lab_pin.sym} 112020 -29410 0 0 {name=p111107 lab=_65170_/Y }
C {devices/lab_pin.sym} 112180 -29450 0 1 {name=p111108 lab=_84212_/D }
C {sky130_stdcells/a21o_4.sym} 112100 -29450 0 0 {name=X_65171_ }
C {devices/lab_pin.sym} 112040 -29320 0 0 {name=p111109 lab=_77157_/A }
C {devices/lab_pin.sym} 112040 -29280 0 0 {name=p111110 lab=_77157_/B }
C {devices/lab_pin.sym} 112160 -29300 0 1 {name=p111111 lab=_77157_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -29300 0 0 {name=X_77157_ }
C {devices/lab_pin.sym} 112060 -29170 0 0 {name=p111112 lab=_43528_/A }
C {devices/lab_pin.sym} 112140 -29170 0 1 {name=p111113 lab=_43549_/X }
C {sky130_stdcells/buf_2.sym} 112100 -29170 0 0 {name=X_43549_ }
C {devices/lab_pin.sym} 112020 -29070 0 0 {name=p111114 lab=_83080_/Q }
C {devices/lab_pin.sym} 112020 -29030 0 0 {name=p111115 lab=_72066_/X }
C {devices/lab_pin.sym} 112020 -28990 0 0 {name=p111116 lab=_74368_/Y }
C {devices/lab_pin.sym} 112180 -29030 0 1 {name=p111117 lab=_74369_/Y }
C {sky130_stdcells/o21ai_4.sym} 112100 -29030 0 0 {name=X_74369_ }
C {devices/lab_pin.sym} 112020 -28910 0 0 {name=p111118 lab=_62381_/Y }
C {devices/lab_pin.sym} 112020 -28870 0 0 {name=p111119 lab=_62327_/X }
C {devices/lab_pin.sym} 112020 -28830 0 0 {name=p111120 lab=_62382_/Y }
C {devices/lab_pin.sym} 112180 -28870 0 1 {name=p111121 lab=_84414_/D }
C {sky130_stdcells/a21oi_4.sym} 112100 -28870 0 0 {name=X_62383_ }
C {devices/lab_pin.sym} 112040 -28740 0 0 {name=p111122 lab=_81723_/D }
C {devices/lab_pin.sym} 112040 -28700 0 0 {name=p111123 lab=_76109_/B }
C {devices/lab_pin.sym} 112160 -28720 0 1 {name=p111124 lab=_76108_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -28720 0 0 {name=X_76108_ }
C {devices/lab_pin.sym} 112040 -28620 0 0 {name=p111125 lab=_64494_/B }
C {devices/lab_pin.sym} 112040 -28580 0 0 {name=p111126 lab=_64145_/B }
C {devices/lab_pin.sym} 112040 -28540 0 0 {name=p111127 lab=_64179_/C }
C {devices/lab_pin.sym} 112040 -28500 0 0 {name=p111128 lab=_64029_/D }
C {devices/lab_pin.sym} 112160 -28560 0 1 {name=p111129 lab=_64122_/Y }
C {sky130_stdcells/nand4_4.sym} 112100 -28560 0 0 {name=X_64122_ }
C {devices/lab_pin.sym} 112040 -28420 0 0 {name=p111130 lab=_49056_/A }
C {devices/lab_pin.sym} 112040 -28380 0 0 {name=p111131 lab=_50649_/B }
C {devices/lab_pin.sym} 112160 -28400 0 1 {name=p111132 lab=_49056_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -28400 0 0 {name=X_49056_ }
C {devices/lab_pin.sym} 112060 -28270 0 0 {name=p111133 lab=_61334_/A }
C {devices/lab_pin.sym} 112140 -28270 0 1 {name=p111134 lab=_61334_/X }
C {sky130_stdcells/buf_2.sym} 112100 -28270 0 0 {name=X_61334_ }
C {devices/lab_pin.sym} 112040 -28160 0 0 {name=p111135 lab=_46288_/A }
C {devices/lab_pin.sym} 112040 -28120 0 0 {name=p111136 lab=_53949_/B }
C {devices/lab_pin.sym} 112160 -28140 0 1 {name=p111137 lab=_46268_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -28140 0 0 {name=X_46268_ }
C {devices/lab_pin.sym} 112040 -28020 0 0 {name=p111138 lab=_77096_/A }
C {devices/lab_pin.sym} 112040 -27980 0 0 {name=p111139 lab=_77097_/A }
C {devices/lab_pin.sym} 112160 -28000 0 1 {name=p111140 lab=_77089_/B }
C {sky130_stdcells/xor2_4.sym} 112100 -28000 0 0 {name=X_77088_ }
C {devices/lab_pin.sym} 112060 -27870 0 0 {name=p111141 lab=_48734_/A }
C {devices/lab_pin.sym} 112140 -27870 0 1 {name=p111142 lab=_48007_/X }
C {sky130_stdcells/buf_2.sym} 112100 -27870 0 0 {name=X_48007_ }
C {devices/lab_pin.sym} 112060 -27750 0 0 {name=p111143 lab=_45219_/A }
C {devices/lab_pin.sym} 112140 -27750 0 1 {name=p111144 lab=_45219_/X }
C {sky130_stdcells/buf_2.sym} 112100 -27750 0 0 {name=X_45219_ }
C {devices/lab_pin.sym} 112060 -27630 0 0 {name=p111145 lab=_69190_/A }
C {devices/lab_pin.sym} 112140 -27630 0 1 {name=p111146 lab=_69021_/A }
C {sky130_stdcells/buf_2.sym} 112100 -27630 0 0 {name=X_68930_ }
C {devices/lab_pin.sym} 112040 -27530 0 0 {name=p111147 lab=_64053_/A }
C {devices/lab_pin.sym} 112040 -27490 0 0 {name=p111148 lab=_58446_/A }
C {devices/lab_pin.sym} 112040 -27450 0 0 {name=p111149 lab=_64071_/C }
C {devices/lab_pin.sym} 112160 -27490 0 1 {name=p111150 lab=_64053_/X }
C {sky130_stdcells/and3_4.sym} 112100 -27490 0 0 {name=X_64053_ }
C {devices/lab_pin.sym} 112040 -27360 0 0 {name=p111151 lab=_76047_/A }
C {devices/lab_pin.sym} 112040 -27320 0 0 {name=p111152 lab=_76039_/B }
C {devices/lab_pin.sym} 112160 -27340 0 1 {name=p111153 lab=_76040_/B }
C {sky130_stdcells/xor2_4.sym} 112100 -27340 0 0 {name=X_76039_ }
C {devices/lab_pin.sym} 112040 -27230 0 0 {name=p111154 lab=_66518_/B }
C {devices/lab_pin.sym} 112040 -27190 0 0 {name=p111155 lab=_59771_/X }
C {devices/lab_pin.sym} 112040 -27150 0 0 {name=p111156 lab=_61265_/C }
C {devices/lab_pin.sym} 112160 -27190 0 1 {name=p111157 lab=_61265_/X }
C {sky130_stdcells/or3_4.sym} 112100 -27190 0 0 {name=X_61265_ }
C {devices/lab_pin.sym} 112060 -27050 0 0 {name=p111158 lab=_65464_/A }
C {devices/lab_pin.sym} 112140 -27050 0 1 {name=p111159 lab=_46199_/X }
C {sky130_stdcells/buf_2.sym} 112100 -27050 0 0 {name=X_46199_ }
C {devices/lab_pin.sym} 112040 -26960 0 0 {name=p111160 lab=_61323_/A }
C {devices/lab_pin.sym} 112040 -26920 0 0 {name=p111161 lab=_63004_/B }
C {devices/lab_pin.sym} 112040 -26880 0 0 {name=p111162 lab=_63004_/C }
C {devices/lab_pin.sym} 112040 -26840 0 0 {name=p111163 lab=_63252_/B }
C {devices/lab_pin.sym} 112160 -26900 0 1 {name=p111164 lab=_63004_/X }
C {sky130_stdcells/or4_4.sym} 112100 -26900 0 0 {name=X_63004_ }
C {devices/lab_pin.sym} 112060 -26750 0 0 {name=p111165 lab=_60193_/A }
C {devices/lab_pin.sym} 112140 -26750 0 1 {name=p111166 lab=_60217_/A }
C {sky130_stdcells/buf_2.sym} 112100 -26750 0 0 {name=X_60216_ }
C {devices/lab_pin.sym} 112040 -26640 0 0 {name=p111167 lab=_68746_/A }
C {devices/lab_pin.sym} 112040 -26600 0 0 {name=p111168 lab=_68861_/B }
C {devices/lab_pin.sym} 112160 -26620 0 1 {name=p111169 lab=_68861_/Y }
C {sky130_stdcells/nor2_4.sym} 112100 -26620 0 0 {name=X_68861_ }
C {devices/lab_pin.sym} 112060 -26490 0 0 {name=p111170 lab=_61196_/A }
C {devices/lab_pin.sym} 112140 -26490 0 1 {name=p111171 lab=_64377_/A }
C {sky130_stdcells/buf_2.sym} 112100 -26490 0 0 {name=X_61196_ }
C {devices/lab_pin.sym} 112020 -26390 0 0 {name=p111172 lab=_67809_/X }
C {devices/lab_pin.sym} 112020 -26350 0 0 {name=p111173 lab=_67811_/X }
C {devices/lab_pin.sym} 112020 -26310 0 0 {name=p111174 lab=_67742_/X }
C {devices/lab_pin.sym} 112180 -26350 0 1 {name=p111175 lab=_67812_/X }
C {sky130_stdcells/a21o_4.sym} 112100 -26350 0 0 {name=X_67812_ }
C {devices/lab_pin.sym} 112060 -26210 0 0 {name=p111176 lab=_79907_/B }
C {devices/lab_pin.sym} 112140 -26210 0 1 {name=p111177 lab=_60148_/C }
C {sky130_stdcells/inv_2.sym} 112100 -26210 0 0 {name=X_60147_ }
C {devices/lab_pin.sym} 112040 -26120 0 0 {name=p111178 lab=_49973_/A }
C {devices/lab_pin.sym} 112040 -26080 0 0 {name=p111179 lab=_49943_/B }
C {devices/lab_pin.sym} 112040 -26040 0 0 {name=p111180 lab=_49973_/C }
C {devices/lab_pin.sym} 112040 -26000 0 0 {name=p111181 lab=_53170_/D }
C {devices/lab_pin.sym} 112160 -26060 0 1 {name=p111182 lab=_49958_/X }
C {sky130_stdcells/and4_4.sym} 112100 -26060 0 0 {name=X_49958_ }
C {devices/lab_pin.sym} 112060 -25910 0 0 {name=p111183 lab=_69442_/A }
C {devices/lab_pin.sym} 112140 -25910 0 1 {name=p111184 lab=_68792_/X }
C {sky130_stdcells/buf_2.sym} 112100 -25910 0 0 {name=X_68792_ }
C {devices/lab_pin.sym} 112020 -25810 0 0 {name=p111185 lab=_48902_/Y }
C {devices/lab_pin.sym} 112020 -25770 0 0 {name=p111186 lab=_48880_/X }
C {devices/lab_pin.sym} 112020 -25730 0 0 {name=p111187 lab=_48908_/X }
C {devices/lab_pin.sym} 112180 -25770 0 1 {name=p111188 lab=_86463_/D }
C {sky130_stdcells/a21oi_4.sym} 112100 -25770 0 0 {name=X_48909_ }
C {devices/lab_pin.sym} 112020 -25650 0 0 {name=p111189 lab=_67738_/X }
C {devices/lab_pin.sym} 112020 -25610 0 0 {name=p111190 lab=_67741_/X }
C {devices/lab_pin.sym} 112020 -25570 0 0 {name=p111191 lab=_67742_/X }
C {devices/lab_pin.sym} 112180 -25610 0 1 {name=p111192 lab=_67743_/X }
C {sky130_stdcells/a21o_4.sym} 112100 -25610 0 0 {name=X_67743_ }
C {devices/lab_pin.sym} 112040 -25480 0 0 {name=p111193 lab=_79724_/X }
C {devices/lab_pin.sym} 112040 -25440 0 0 {name=p111194 lab=_79728_/Y }
C {devices/lab_pin.sym} 112160 -25460 0 1 {name=p111195 lab=_79729_/X }
C {sky130_stdcells/xor2_4.sym} 112100 -25460 0 0 {name=X_79729_ }
C {devices/lab_pin.sym} 112020 -25360 0 0 {name=p111196 lab=_64817_/X }
C {devices/lab_pin.sym} 112020 -25320 0 0 {name=p111197 lab=_86132_/Q }
C {devices/lab_pin.sym} 112020 -25280 0 0 {name=p111198 lab=_64927_/X }
C {devices/lab_pin.sym} 112020 -25240 0 0 {name=p111199 lab=_64954_/X }
C {devices/lab_pin.sym} 112180 -25300 0 1 {name=p111200 lab=_64955_/X }
C {sky130_stdcells/a211o_4.sym} 112100 -25300 0 0 {name=X_64955_ }
C {devices/lab_pin.sym} 112060 -25150 0 0 {name=p111201 lab=_60359_/A }
C {devices/lab_pin.sym} 112140 -25150 0 1 {name=p111202 lab=_60078_/X }
C {sky130_stdcells/buf_2.sym} 112100 -25150 0 0 {name=X_60078_ }
C {devices/lab_pin.sym} 112040 -25060 0 0 {name=p111203 lab=_49893_/A }
C {devices/lab_pin.sym} 112040 -25020 0 0 {name=p111204 lab=_49893_/B }
C {devices/lab_pin.sym} 112040 -24980 0 0 {name=p111205 lab=_49893_/C }
C {devices/lab_pin.sym} 112040 -24940 0 0 {name=p111206 lab=_53103_/D }
C {devices/lab_pin.sym} 112160 -25000 0 1 {name=p111207 lab=_49889_/X }
C {sky130_stdcells/and4_4.sym} 112100 -25000 0 0 {name=X_49889_ }
C {devices/lab_pin.sym} 112020 -24870 0 0 {name=p111208 lab=_51917_/Y }
C {devices/lab_pin.sym} 112020 -24830 0 0 {name=p111209 lab=_51904_/X }
C {devices/lab_pin.sym} 112020 -24790 0 0 {name=p111210 lab=_51919_/X }
C {devices/lab_pin.sym} 112180 -24830 0 1 {name=p111211 lab=_51920_/Y }
C {sky130_stdcells/a21oi_4.sym} 112100 -24830 0 0 {name=X_51920_ }
C {devices/lab_pin.sym} 112060 -24690 0 0 {name=p111212 lab=_64067_/A }
C {devices/lab_pin.sym} 112140 -24690 0 1 {name=p111213 lab=_63908_/B }
C {sky130_stdcells/buf_2.sym} 112100 -24690 0 0 {name=X_63906_ }
C {devices/lab_pin.sym} 112010 -24570 0 0 {name=p111214 lab=_82740_/CLK }
C {devices/lab_pin.sym} 112010 -24550 0 0 {name=p111215 lab=_66433_/C }
C {devices/lab_pin.sym} 112190 -24570 0 1 {name=p111216 lab=_78975_/A }
C {sky130_stdcells/dfxtp_4.sym} 112100 -24560 0 0 {name=X_82740_ }
C {devices/lab_pin.sym} 112040 -24440 0 0 {name=p111217 lab=_67674_/A }
C {devices/lab_pin.sym} 112040 -24400 0 0 {name=p111218 lab=_67673_/X }
C {devices/lab_pin.sym} 112160 -24420 0 1 {name=p111219 lab=_67674_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -24420 0 0 {name=X_67674_ }
C {devices/lab_pin.sym} 112040 -24300 0 0 {name=p111220 lab=_64836_/A }
C {devices/lab_pin.sym} 112040 -24260 0 0 {name=p111221 lab=_86455_/Q }
C {devices/lab_pin.sym} 112160 -24280 0 1 {name=p111222 lab=_64886_/X }
C {sky130_stdcells/and2_4.sym} 112100 -24280 0 0 {name=X_64886_ }
C {devices/lab_pin.sym} 112020 -24170 0 0 {name=p111223 lab=_69410_/X }
C {devices/lab_pin.sym} 112020 -24130 0 0 {name=p111224 lab=_69412_/X }
C {devices/lab_pin.sym} 112020 -24090 0 0 {name=p111225 lab=_69346_/X }
C {devices/lab_pin.sym} 112180 -24130 0 1 {name=p111226 lab=_69413_/X }
C {sky130_stdcells/a21o_4.sym} 112100 -24130 0 0 {name=X_69413_ }
C {devices/lab_pin.sym} 112060 -23990 0 0 {name=p111227 lab=_66625_/A }
C {devices/lab_pin.sym} 112140 -23990 0 1 {name=p111228 lab=_66651_/A }
C {sky130_stdcells/buf_2.sym} 112100 -23990 0 0 {name=X_66625_ }
C {devices/lab_pin.sym} 112040 -23900 0 0 {name=p111229 lab=_51851_/A }
C {devices/lab_pin.sym} 112040 -23860 0 0 {name=p111230 lab=_51851_/B }
C {devices/lab_pin.sym} 112040 -23820 0 0 {name=p111231 lab=_51851_/C }
C {devices/lab_pin.sym} 112040 -23780 0 0 {name=p111232 lab=_46791_/X }
C {devices/lab_pin.sym} 112160 -23840 0 1 {name=p111233 lab=_51851_/X }
C {sky130_stdcells/and4_4.sym} 112100 -23840 0 0 {name=X_51851_ }
C {devices/lab_pin.sym} 112060 -23690 0 0 {name=p111234 lab=_60996_/B }
C {devices/lab_pin.sym} 112140 -23690 0 1 {name=p111235 lab=_63900_/C }
C {sky130_stdcells/buf_2.sym} 112100 -23690 0 0 {name=X_63837_ }
C {devices/lab_pin.sym} 112010 -23570 0 0 {name=p111236 lab=_82671_/CLK }
C {devices/lab_pin.sym} 112010 -23550 0 0 {name=p111237 lab=_82671_/D }
C {devices/lab_pin.sym} 112190 -23570 0 1 {name=p111238 lab=_78173_/A }
C {sky130_stdcells/dfxtp_4.sym} 112100 -23560 0 0 {name=X_82671_ }
C {devices/lab_pin.sym} 112010 -23430 0 0 {name=p111239 lab=_84409_/CLK }
C {devices/lab_pin.sym} 112010 -23410 0 0 {name=p111240 lab=_84410_/D }
C {devices/lab_pin.sym} 112190 -23430 0 1 {name=p111241 lab=_62442_/C }
C {sky130_stdcells/dfxtp_4.sym} 112100 -23420 0 0 {name=X_84410_ }
C {devices/lab_pin.sym} 112040 -23310 0 0 {name=p111242 lab=_50802_/A }
C {devices/lab_pin.sym} 112040 -23270 0 0 {name=p111243 lab=_50751_/B }
C {devices/lab_pin.sym} 112040 -23230 0 0 {name=p111244 lab=_50751_/C }
C {devices/lab_pin.sym} 112160 -23270 0 1 {name=p111245 lab=_50802_/X }
C {sky130_stdcells/and3_4.sym} 112100 -23270 0 0 {name=X_50802_ }
C {devices/lab_pin.sym} 112010 -23130 0 0 {name=p111246 lab=_81689_/CLK }
C {devices/lab_pin.sym} 112010 -23110 0 0 {name=p111247 lab=_76449_/B }
C {devices/lab_pin.sym} 112190 -23130 0 1 {name=p111248 lab=_81622_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -23120 0 0 {name=X_81622_ }
C {devices/lab_pin.sym} 112040 -23000 0 0 {name=p111249 lab=_69305_/A }
C {devices/lab_pin.sym} 112040 -22960 0 0 {name=p111250 lab=_87268_/Q }
C {devices/lab_pin.sym} 112160 -22980 0 1 {name=p111251 lab=_69344_/X }
C {sky130_stdcells/and2_4.sym} 112100 -22980 0 0 {name=X_69344_ }
C {devices/lab_pin.sym} 112020 -22870 0 0 {name=p111252 lab=_85418_/Q }
C {devices/lab_pin.sym} 112020 -22830 0 0 {name=p111253 lab=_54567_/X }
C {devices/lab_pin.sym} 112020 -22790 0 0 {name=p111254 lab=_54569_/Y }
C {devices/lab_pin.sym} 112180 -22830 0 1 {name=p111255 lab=_54570_/Y }
C {sky130_stdcells/o21ai_4.sym} 112100 -22830 0 0 {name=X_54570_ }
C {devices/lab_pin.sym} 112010 -22690 0 0 {name=p111256 lab=_85485_/CLK }
C {devices/lab_pin.sym} 112010 -22670 0 0 {name=p111257 lab=_54722_/Y }
C {devices/lab_pin.sym} 112190 -22690 0 1 {name=p111258 lab=_85390_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -22680 0 0 {name=X_85390_ }
C {devices/lab_pin.sym} 112060 -22550 0 0 {name=p111259 lab=_66647_/A }
C {devices/lab_pin.sym} 112140 -22550 0 1 {name=p111260 lab=_69853_/A }
C {sky130_stdcells/buf_2.sym} 112100 -22550 0 0 {name=X_66556_ }
C {devices/lab_pin.sym} 112040 -22460 0 0 {name=p111261 lab=_51794_/A }
C {devices/lab_pin.sym} 112040 -22420 0 0 {name=p111262 lab=_51782_/B }
C {devices/lab_pin.sym} 112040 -22380 0 0 {name=p111263 lab=_51794_/C }
C {devices/lab_pin.sym} 112040 -22340 0 0 {name=p111264 lab=_50919_/D }
C {devices/lab_pin.sym} 112160 -22400 0 1 {name=p111265 lab=_51782_/X }
C {sky130_stdcells/and4_4.sym} 112100 -22400 0 0 {name=X_51782_ }
C {devices/lab_pin.sym} 112060 -22250 0 0 {name=p111266 lab=_63849_/A }
C {devices/lab_pin.sym} 112140 -22250 0 1 {name=p111267 lab=_63800_/B }
C {sky130_stdcells/buf_2.sym} 112100 -22250 0 0 {name=X_63768_ }
C {devices/lab_pin.sym} 112020 -22150 0 0 {name=p111268 lab=_53519_/Y }
C {devices/lab_pin.sym} 112020 -22110 0 0 {name=p111269 lab=_53498_/X }
C {devices/lab_pin.sym} 112020 -22070 0 0 {name=p111270 lab=_53520_/Y }
C {devices/lab_pin.sym} 112180 -22110 0 1 {name=p111271 lab=_85621_/D }
C {sky130_stdcells/a21boi_4.sym} 112100 -22110 0 0 {name=X_53521_ }
C {devices/lab_pin.sym} 112020 -21990 0 0 {name=p111272 lab=_65502_/X }
C {devices/lab_pin.sym} 112020 -21950 0 0 {name=p111273 lab=_65506_/X }
C {devices/lab_pin.sym} 112020 -21910 0 0 {name=p111274 lab=_65389_/X }
C {devices/lab_pin.sym} 112180 -21950 0 1 {name=p111275 lab=_65507_/X }
C {sky130_stdcells/a21o_4.sym} 112100 -21950 0 0 {name=X_65507_ }
C {devices/lab_pin.sym} 112010 -21810 0 0 {name=p111276 lab=_84877_/CLK }
C {devices/lab_pin.sym} 112010 -21790 0 0 {name=p111277 lab=_63246_/X }
C {devices/lab_pin.sym} 112190 -21810 0 1 {name=p111278 lab=_79301_/A }
C {sky130_stdcells/dfxtp_4.sym} 112100 -21800 0 0 {name=X_84341_ }
C {devices/lab_pin.sym} 112040 -21680 0 0 {name=p111279 lab=_50738_/A }
C {devices/lab_pin.sym} 112040 -21640 0 0 {name=p111280 lab=_49212_/B }
C {devices/lab_pin.sym} 112160 -21660 0 1 {name=p111281 lab=_50733_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -21660 0 0 {name=X_50733_ }
C {devices/lab_pin.sym} 112020 -21570 0 0 {name=p111282 lab=_62712_/Y }
C {devices/lab_pin.sym} 112020 -21530 0 0 {name=p111283 lab=_62713_/X }
C {devices/lab_pin.sym} 112020 -21490 0 0 {name=p111284 lab=_62715_/Y }
C {devices/lab_pin.sym} 112020 -21450 0 0 {name=p111285 lab=_62716_/Y }
C {devices/lab_pin.sym} 112020 -21420 0 0 {name=p111286 lab=_62718_/X }
C {devices/lab_pin.sym} 112180 -21490 0 1 {name=p111287 lab=_62719_/X }
C {sky130_stdcells/a41o_4.sym} 112100 -21490 0 0 {name=X_62719_ }
C {devices/lab_pin.sym} 112010 -21330 0 0 {name=p111288 lab=_80912_/CLK }
C {devices/lab_pin.sym} 112010 -21310 0 0 {name=p111289 lab=_76790_/X }
C {devices/lab_pin.sym} 112190 -21330 0 1 {name=p111290 lab=_81553_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -21320 0 0 {name=X_81553_ }
C {devices/lab_pin.sym} 112020 -21220 0 0 {name=p111291 lab=_87529_/Q }
C {devices/lab_pin.sym} 112020 -21180 0 0 {name=p111292 lab=_69261_/X }
C {devices/lab_pin.sym} 112020 -21140 0 0 {name=p111293 lab=_69248_/X }
C {devices/lab_pin.sym} 112020 -21100 0 0 {name=p111294 lab=_69274_/X }
C {devices/lab_pin.sym} 112180 -21160 0 1 {name=p111295 lab=_69275_/X }
C {sky130_stdcells/a211o_4.sym} 112100 -21160 0 0 {name=X_69275_ }
C {devices/lab_pin.sym} 112040 -21030 0 0 {name=p111296 lab=_65238_/X }
C {devices/lab_pin.sym} 112040 -20990 0 0 {name=p111297 lab=_66476_/B }
C {devices/lab_pin.sym} 112040 -20950 0 0 {name=p111298 lab=_65241_/X }
C {devices/lab_pin.sym} 112160 -20990 0 1 {name=p111299 lab=_66487_/Y }
C {sky130_stdcells/nand3_4.sym} 112100 -20990 0 0 {name=X_66487_ }
C {devices/lab_pin.sym} 112040 -20880 0 0 {name=p111300 lab=_58364_/A }
C {devices/lab_pin.sym} 112040 -20840 0 0 {name=p111301 lab=_63416_/A }
C {devices/lab_pin.sym} 112040 -20800 0 0 {name=p111302 lab=_63661_/C }
C {devices/lab_pin.sym} 112040 -20760 0 0 {name=p111303 lab=_63699_/D }
C {devices/lab_pin.sym} 112160 -20820 0 1 {name=p111304 lab=_63699_/Y }
C {sky130_stdcells/nand4_4.sym} 112100 -20820 0 0 {name=X_63699_ }
C {devices/lab_pin.sym} 112040 -20690 0 0 {name=p111305 lab=_56250_/A }
C {devices/lab_pin.sym} 112040 -20650 0 0 {name=p111306 lab=_56243_/B }
C {devices/lab_pin.sym} 112040 -20610 0 0 {name=p111307 lab=_85263_/Q }
C {devices/lab_pin.sym} 112160 -20650 0 1 {name=p111308 lab=_56240_/Y }
C {sky130_stdcells/nand3_4.sym} 112100 -20650 0 0 {name=X_56240_ }
C {devices/lab_pin.sym} 112020 -20530 0 0 {name=p111309 lab=_59143_/Y }
C {devices/lab_pin.sym} 112020 -20490 0 0 {name=p111310 lab=_66092_/C }
C {devices/lab_pin.sym} 112020 -20450 0 0 {name=p111311 lab=_80503_/Y }
C {devices/lab_pin.sym} 112180 -20490 0 1 {name=p111312 lab=_80504_/X }
C {sky130_stdcells/o21a_4.sym} 112100 -20490 0 0 {name=X_80504_ }
C {devices/lab_pin.sym} 112020 -20380 0 0 {name=p111313 lab=_68221_/X }
C {devices/lab_pin.sym} 112020 -20340 0 0 {name=p111314 lab=_67387_/Y }
C {devices/lab_pin.sym} 112020 -20300 0 0 {name=p111315 lab=_68207_/X }
C {devices/lab_pin.sym} 112020 -20260 0 0 {name=p111316 lab=_68225_/Y }
C {devices/lab_pin.sym} 112180 -20320 0 1 {name=p111317 lab=_68226_/X }
C {sky130_stdcells/a211o_4.sym} 112100 -20320 0 0 {name=X_68226_ }
C {devices/lab_pin.sym} 112010 -20170 0 0 {name=p111318 lab=_87063_/CLK }
C {devices/lab_pin.sym} 112010 -20150 0 0 {name=p111319 lab=_87060_/D }
C {devices/lab_pin.sym} 112190 -20170 0 1 {name=p111320 lab=_44543_/A }
C {sky130_stdcells/dfxtp_4.sym} 112100 -20160 0 0 {name=X_87060_ }
C {devices/lab_pin.sym} 112060 -20030 0 0 {name=p111321 lab=_54919_/A }
C {devices/lab_pin.sym} 112140 -20030 0 1 {name=p111322 lab=_53460_/A }
C {sky130_stdcells/buf_2.sym} 112100 -20030 0 0 {name=X_53452_ }
C {devices/lab_pin.sym} 112060 -19910 0 0 {name=p111323 lab=_58876_/A }
C {devices/lab_pin.sym} 112140 -19910 0 1 {name=p111324 lab=_65438_/X }
C {sky130_stdcells/buf_2.sym} 112100 -19910 0 0 {name=X_65438_ }
C {devices/lab_pin.sym} 112010 -19790 0 0 {name=p111325 lab=_84269_/CLK }
C {devices/lab_pin.sym} 112010 -19770 0 0 {name=p111326 lab=_84272_/D }
C {devices/lab_pin.sym} 112190 -19790 0 1 {name=p111327 lab=_64130_/C }
C {sky130_stdcells/dfxtp_4.sym} 112100 -19780 0 0 {name=X_84272_ }
C {devices/lab_pin.sym} 112040 -19660 0 0 {name=p111328 lab=_50640_/A }
C {devices/lab_pin.sym} 112040 -19620 0 0 {name=p111329 lab=_53879_/B }
C {devices/lab_pin.sym} 112160 -19640 0 1 {name=p111330 lab=_50664_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -19640 0 0 {name=X_50664_ }
C {devices/lab_pin.sym} 112010 -19510 0 0 {name=p111331 lab=_81431_/CLK }
C {devices/lab_pin.sym} 112010 -19490 0 0 {name=p111332 lab=_84052_/Q }
C {devices/lab_pin.sym} 112190 -19510 0 1 {name=p111333 lab=_76734_/A }
C {sky130_stdcells/dfxtp_4.sym} 112100 -19500 0 0 {name=X_81484_ }
C {devices/lab_pin.sym} 112010 -19370 0 0 {name=p111334 lab=_85725_/CLK }
C {devices/lab_pin.sym} 112010 -19350 0 0 {name=p111335 lab=_86011_/D }
C {devices/lab_pin.sym} 112190 -19370 0 1 {name=p111336 lab=_86011_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -19360 0 0 {name=X_86011_ }
C {devices/lab_pin.sym} 112040 -19240 0 0 {name=p111337 lab=_52385_/A }
C {devices/lab_pin.sym} 112040 -19200 0 0 {name=p111338 lab=_49163_/A }
C {devices/lab_pin.sym} 112160 -19220 0 1 {name=p111339 lab=_52403_/X }
C {sky130_stdcells/and2_4.sym} 112100 -19220 0 0 {name=X_52403_ }
C {devices/lab_pin.sym} 112010 -19090 0 0 {name=p111340 lab=_82272_/CLK }
C {devices/lab_pin.sym} 112010 -19070 0 0 {name=p111341 lab=_72596_/X }
C {devices/lab_pin.sym} 112190 -19090 0 1 {name=p111342 lab=_79321_/B }
C {sky130_stdcells/dfxtp_4.sym} 112100 -19080 0 0 {name=X_83223_ }
C {devices/lab_pin.sym} 112040 -18960 0 0 {name=p111343 lab=_80448_/B }
C {devices/lab_pin.sym} 112040 -18920 0 0 {name=p111344 lab=_80448_/A }
C {devices/lab_pin.sym} 112160 -18940 0 1 {name=p111345 lab=_80435_/X }
C {sky130_stdcells/xor2_4.sym} 112100 -18940 0 0 {name=X_80435_ }
C {devices/lab_pin.sym} 112040 -18830 0 0 {name=p111346 lab=_56171_/A }
C {devices/lab_pin.sym} 112040 -18790 0 0 {name=p111347 lab=_45904_/X }
C {devices/lab_pin.sym} 112040 -18750 0 0 {name=p111348 lab=_56171_/C }
C {devices/lab_pin.sym} 112160 -18790 0 1 {name=p111349 lab=_56172_/A }
C {sky130_stdcells/nand3_4.sym} 112100 -18790 0 0 {name=X_56171_ }
C {devices/lab_pin.sym} 112020 -18680 0 0 {name=p111350 lab=_68155_/X }
C {devices/lab_pin.sym} 112020 -18640 0 0 {name=p111351 lab=_66980_/Y }
C {devices/lab_pin.sym} 112020 -18600 0 0 {name=p111352 lab=_68148_/X }
C {devices/lab_pin.sym} 112020 -18560 0 0 {name=p111353 lab=_68156_/Y }
C {devices/lab_pin.sym} 112180 -18620 0 1 {name=p111354 lab=_68157_/X }
C {sky130_stdcells/a211o_4.sym} 112100 -18620 0 0 {name=X_68157_ }
C {devices/lab_pin.sym} 112060 -18470 0 0 {name=p111355 lab=_53357_/A }
C {devices/lab_pin.sym} 112140 -18470 0 1 {name=p111356 lab=_53388_/C }
C {sky130_stdcells/buf_2.sym} 112100 -18470 0 0 {name=X_53383_ }
C {devices/lab_pin.sym} 112040 -18370 0 0 {name=p111357 lab=_65366_/X }
C {devices/lab_pin.sym} 112040 -18330 0 0 {name=p111358 lab=_65340_/X }
C {devices/lab_pin.sym} 112040 -18290 0 0 {name=p111359 lab=_65368_/X }
C {devices/lab_pin.sym} 112160 -18330 0 1 {name=p111360 lab=_65369_/Y }
C {sky130_stdcells/nand3_4.sym} 112100 -18330 0 0 {name=X_65369_ }
C {devices/lab_pin.sym} 112060 -18190 0 0 {name=p111361 lab=_50595_/A }
C {devices/lab_pin.sym} 112140 -18190 0 1 {name=p111362 lab=_50596_/A }
C {sky130_stdcells/buf_2.sym} 112100 -18190 0 0 {name=X_50595_ }
C {devices/lab_pin.sym} 112060 -18070 0 0 {name=p111363 lab=_44305_/X }
C {devices/lab_pin.sym} 112140 -18070 0 1 {name=p111364 lab=_73195_/A }
C {sky130_stdcells/buf_2.sym} 112100 -18070 0 0 {name=X_55122_ }
C {devices/lab_pin.sym} 112020 -17980 0 0 {name=p111365 lab=_87357_/Q }
C {devices/lab_pin.sym} 112020 -17940 0 0 {name=p111366 lab=_67035_/X }
C {devices/lab_pin.sym} 112020 -17900 0 0 {name=p111367 lab=_67106_/X }
C {devices/lab_pin.sym} 112020 -17860 0 0 {name=p111368 lab=_67107_/X }
C {devices/lab_pin.sym} 112180 -17920 0 1 {name=p111369 lab=_67108_/X }
C {sky130_stdcells/a211o_4.sym} 112100 -17920 0 0 {name=X_67108_ }
C {devices/lab_pin.sym} 112040 -17780 0 0 {name=p111370 lab=_52334_/A }
C {devices/lab_pin.sym} 112040 -17740 0 0 {name=p111371 lab=_49025_/X }
C {devices/lab_pin.sym} 112160 -17760 0 1 {name=p111372 lab=_52334_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -17760 0 0 {name=X_52334_ }
C {devices/lab_pin.sym} 112010 -17630 0 0 {name=p111373 lab=_86534_/CLK }
C {devices/lab_pin.sym} 112010 -17610 0 0 {name=p111374 lab=_83154_/D }
C {devices/lab_pin.sym} 112190 -17630 0 1 {name=p111375 lab=_83154_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -17620 0 0 {name=X_83154_ }
C {devices/lab_pin.sym} 112040 -17500 0 0 {name=p111376 lab=_80366_/A }
C {devices/lab_pin.sym} 112040 -17460 0 0 {name=p111377 lab=_80366_/B }
C {devices/lab_pin.sym} 112160 -17480 0 1 {name=p111378 lab=_80366_/X }
C {sky130_stdcells/xor2_4.sym} 112100 -17480 0 0 {name=X_80366_ }
C {devices/lab_pin.sym} 112060 -17350 0 0 {name=p111379 lab=_67495_/X }
C {devices/lab_pin.sym} 112140 -17350 0 1 {name=p111380 lab=_68088_/X }
C {sky130_stdcells/buf_2.sym} 112100 -17350 0 0 {name=X_68088_ }
C {devices/lab_pin.sym} 112010 -17230 0 0 {name=p111381 lab=_82015_/CLK }
C {devices/lab_pin.sym} 112010 -17210 0 0 {name=p111382 lab=_82105_/D }
C {devices/lab_pin.sym} 112190 -17230 0 1 {name=p111383 lab=_82105_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -17220 0 0 {name=X_82105_ }
C {devices/lab_pin.sym} 112020 -17110 0 0 {name=p111384 lab=_55049_/Y }
C {devices/lab_pin.sym} 112020 -17070 0 0 {name=p111385 lab=_55050_/X }
C {devices/lab_pin.sym} 112020 -17030 0 0 {name=p111386 lab=_55052_/X }
C {devices/lab_pin.sym} 112180 -17070 0 1 {name=p111387 lab=_85328_/D }
C {sky130_stdcells/a21oi_4.sym} 112100 -17070 0 0 {name=X_55053_ }
C {devices/lab_pin.sym} 112060 -16930 0 0 {name=p111388 lab=_62196_/A }
C {devices/lab_pin.sym} 112140 -16930 0 1 {name=p111389 lab=_59931_/A }
C {sky130_stdcells/buf_2.sym} 112100 -16930 0 0 {name=X_59930_ }
C {devices/lab_pin.sym} 112060 -16810 0 0 {name=p111390 lab=_46210_/A }
C {devices/lab_pin.sym} 112140 -16810 0 1 {name=p111391 lab=_67039_/X }
C {sky130_stdcells/buf_2.sym} 112100 -16810 0 0 {name=X_67039_ }
C {devices/lab_pin.sym} 112040 -16700 0 0 {name=p111392 lab=_52250_/A }
C {devices/lab_pin.sym} 112040 -16660 0 0 {name=p111393 lab=_48889_/B }
C {devices/lab_pin.sym} 112160 -16680 0 1 {name=p111394 lab=_52265_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -16680 0 0 {name=X_52265_ }
C {devices/lab_pin.sym} 112010 -16550 0 0 {name=p111395 lab=_83184_/CLK }
C {devices/lab_pin.sym} 112010 -16530 0 0 {name=p111396 lab=_74356_/X }
C {devices/lab_pin.sym} 112190 -16550 0 1 {name=p111397 lab=_83085_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -16540 0 0 {name=X_83085_ }
C {devices/lab_pin.sym} 112010 -16410 0 0 {name=p111398 lab=_87221_/CLK }
C {devices/lab_pin.sym} 112010 -16390 0 0 {name=p111399 lab=_87962_/D }
C {devices/lab_pin.sym} 112190 -16410 0 1 {name=p111400 lab=_87962_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -16400 0 0 {name=X_87962_ }
C {devices/lab_pin.sym} 112040 -16280 0 0 {name=p111401 lab=_80297_/A }
C {devices/lab_pin.sym} 112040 -16240 0 0 {name=p111402 lab=_80297_/B }
C {devices/lab_pin.sym} 112160 -16260 0 1 {name=p111403 lab=_80298_/A }
C {sky130_stdcells/nand2_4.sym} 112100 -16260 0 0 {name=X_80297_ }
C {devices/lab_pin.sym} 112040 -16140 0 0 {name=p111404 lab=_53991_/A }
C {devices/lab_pin.sym} 112040 -16100 0 0 {name=p111405 lab=_52484_/B }
C {devices/lab_pin.sym} 112160 -16120 0 1 {name=p111406 lab=_54004_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -16120 0 0 {name=X_54004_ }
C {devices/lab_pin.sym} 112040 -16000 0 0 {name=p111407 lab=_51212_/A }
C {devices/lab_pin.sym} 112040 -15960 0 0 {name=p111408 lab=_47195_/X }
C {devices/lab_pin.sym} 112160 -15980 0 1 {name=p111409 lab=_51216_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -15980 0 0 {name=X_51216_ }
C {devices/lab_pin.sym} 112010 -15850 0 0 {name=p111410 lab=_86914_/CLK }
C {devices/lab_pin.sym} 112010 -15830 0 0 {name=p111411 lab=_86913_/D }
C {devices/lab_pin.sym} 112190 -15850 0 1 {name=p111412 lab=_68054_/B }
C {sky130_stdcells/dfxtp_4.sym} 112100 -15840 0 0 {name=X_86913_ }
C {devices/lab_pin.sym} 112010 -15710 0 0 {name=p111413 lab=_82009_/CLK }
C {devices/lab_pin.sym} 112010 -15690 0 0 {name=p111414 lab=_82036_/D }
C {devices/lab_pin.sym} 112190 -15710 0 1 {name=p111415 lab=_82036_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -15700 0 0 {name=X_82036_ }
C {devices/lab_pin.sym} 112020 -15600 0 0 {name=p111416 lab=_70040_/X }
C {devices/lab_pin.sym} 112020 -15560 0 0 {name=p111417 lab=_69813_/Y }
C {devices/lab_pin.sym} 112020 -15520 0 0 {name=p111418 lab=_70033_/X }
C {devices/lab_pin.sym} 112020 -15480 0 0 {name=p111419 lab=_70049_/Y }
C {devices/lab_pin.sym} 112180 -15540 0 1 {name=p111420 lab=_70050_/X }
C {sky130_stdcells/a211o_4.sym} 112100 -15540 0 0 {name=X_70050_ }
C {devices/lab_pin.sym} 112020 -15430 0 0 {name=p111421 lab=_59745_/X }
C {devices/lab_pin.sym} 112020 -15390 0 0 {name=p111422 lab=_59768_/Y }
C {devices/lab_pin.sym} 112020 -15350 0 0 {name=p111423 lab=_59858_/Y }
C {devices/lab_pin.sym} 112020 -15310 0 0 {name=p111424 lab=_59859_/Y }
C {devices/lab_pin.sym} 112020 -15280 0 0 {name=p111425 lab=_59860_/Y }
C {devices/lab_pin.sym} 112180 -15350 0 1 {name=p111426 lab=_59861_/Y }
C {sky130_stdcells/a41oi_4.sym} 112100 -15350 0 0 {name=X_59861_ }
C {devices/lab_pin.sym} 112040 -15200 0 0 {name=p111427 lab=_52210_/A }
C {devices/lab_pin.sym} 112040 -15160 0 0 {name=p111428 lab=_48811_/B }
C {devices/lab_pin.sym} 112160 -15180 0 1 {name=p111429 lab=_52196_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -15180 0 0 {name=X_52196_ }
C {devices/lab_pin.sym} 112010 -15050 0 0 {name=p111430 lab=_87636_/CLK }
C {devices/lab_pin.sym} 112010 -15030 0 0 {name=p111431 lab=_87893_/D }
C {devices/lab_pin.sym} 112190 -15050 0 1 {name=p111432 lab=_87893_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -15040 0 0 {name=X_87893_ }
C {devices/lab_pin.sym} 112060 -14910 0 0 {name=p111433 lab=clkbuf_9_286_0_CLK/X }
C {devices/lab_pin.sym} 112140 -14910 0 1 {name=p111434 lab=_87865_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 112100 -14910 0 0 {name=Xclkbuf_10_572_0_CLK }
C {devices/lab_pin.sym} 112020 -14810 0 0 {name=p111435 lab=_58703_/X }
C {devices/lab_pin.sym} 112020 -14770 0 0 {name=p111436 lab=_85454_/Q }
C {devices/lab_pin.sym} 112020 -14730 0 0 {name=p111437 lab=_58811_/X }
C {devices/lab_pin.sym} 112180 -14770 0 1 {name=p111438 lab=_58812_/Y }
C {sky130_stdcells/o21ai_4.sym} 112100 -14770 0 0 {name=X_58812_ }
C {devices/lab_pin.sym} 112060 -14630 0 0 {name=p111439 lab=clkbuf_6_63_0_CLK/A }
C {devices/lab_pin.sym} 112140 -14630 0 1 {name=p111440 lab=clkbuf_6_63_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 112100 -14630 0 0 {name=Xclkbuf_6_63_0_CLK }
C {devices/lab_pin.sym} 112060 -14510 0 0 {name=p111441 lab=_51147_/A }
C {devices/lab_pin.sym} 112140 -14510 0 1 {name=p111442 lab=_51147_/X }
C {sky130_stdcells/buf_2.sym} 112100 -14510 0 0 {name=X_51147_ }
C {devices/lab_pin.sym} 112010 -14390 0 0 {name=p111443 lab=_81084_/CLK }
C {devices/lab_pin.sym} 112010 -14370 0 0 {name=p111444 lab=_86844_/D }
C {devices/lab_pin.sym} 112190 -14390 0 1 {name=p111445 lab=_45889_/A }
C {sky130_stdcells/dfxtp_4.sym} 112100 -14380 0 0 {name=X_86844_ }
C {devices/lab_pin.sym} 112060 -14250 0 0 {name=p111446 lab=_59791_/X }
C {devices/lab_pin.sym} 112140 -14250 0 1 {name=p111447 lab=_84700_/D }
C {sky130_stdcells/inv_2.sym} 112100 -14250 0 0 {name=X_59792_ }
C {devices/lab_pin.sym} 112020 -14150 0 0 {name=p111448 lab=_58714_/X }
C {devices/lab_pin.sym} 112020 -14110 0 0 {name=p111449 lab=_85779_/Q }
C {devices/lab_pin.sym} 112020 -14070 0 0 {name=p111450 lab=_58716_/X }
C {devices/lab_pin.sym} 112180 -14110 0 1 {name=p111451 lab=_58743_/X }
C {sky130_stdcells/o21a_4.sym} 112100 -14110 0 0 {name=X_58743_ }
C {devices/lab_pin.sym} 112040 -14000 0 0 {name=p111452 lab=_51056_/A }
C {devices/lab_pin.sym} 112040 -13960 0 0 {name=p111453 lab=_51071_/B }
C {devices/lab_pin.sym} 112040 -13920 0 0 {name=p111454 lab=_51071_/C }
C {devices/lab_pin.sym} 112040 -13880 0 0 {name=p111455 lab=_52771_/D }
C {devices/lab_pin.sym} 112160 -13940 0 1 {name=p111456 lab=_51078_/X }
C {sky130_stdcells/and4_4.sym} 112100 -13940 0 0 {name=X_51078_ }
C {devices/lab_pin.sym} 112060 -13790 0 0 {name=p111457 lab=_55954_/X }
C {devices/lab_pin.sym} 112140 -13790 0 1 {name=p111458 lab=_56003_/B }
C {sky130_stdcells/buf_2.sym} 112100 -13790 0 0 {name=X_55955_ }
C {devices/lab_pin.sym} 112010 -13670 0 0 {name=p111459 lab=_82886_/CLK }
C {devices/lab_pin.sym} 112010 -13650 0 0 {name=p111460 lab=_86775_/D }
C {devices/lab_pin.sym} 112190 -13670 0 1 {name=p111461 lab=_86775_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -13660 0 0 {name=X_86775_ }
C {devices/lab_pin.sym} 112010 -13530 0 0 {name=p111462 lab=_83987_/CLK }
C {devices/lab_pin.sym} 112010 -13510 0 0 {name=p111463 lab=_68307_/X }
C {devices/lab_pin.sym} 112190 -13530 0 1 {name=p111464 lab=_82635_/D }
C {sky130_stdcells/dfxtp_4.sym} 112100 -13520 0 0 {name=X_83987_ }
C {devices/lab_pin.sym} 112060 -13390 0 0 {name=p111465 lab=_42962_/A }
C {devices/lab_pin.sym} 112140 -13390 0 1 {name=p111466 lab=_42920_/X }
C {sky130_stdcells/buf_2.sym} 112100 -13390 0 0 {name=X_42920_ }
C {devices/lab_pin.sym} 112060 -13270 0 0 {name=p111467 lab=_40595_/X }
C {devices/lab_pin.sym} 112140 -13270 0 1 {name=p111468 lab=_50029_/X }
C {sky130_stdcells/buf_2.sym} 112100 -13270 0 0 {name=X_50029_ }
C {devices/lab_pin.sym} 112020 -13170 0 0 {name=p111469 lab=_54904_/Y }
C {devices/lab_pin.sym} 112020 -13130 0 0 {name=p111470 lab=_54882_/X }
C {devices/lab_pin.sym} 112020 -13090 0 0 {name=p111471 lab=_54905_/X }
C {devices/lab_pin.sym} 112180 -13130 0 1 {name=p111472 lab=_54906_/Y }
C {sky130_stdcells/a21oi_4.sym} 112100 -13130 0 0 {name=X_54906_ }
C {devices/lab_pin.sym} 112060 -12990 0 0 {name=p111473 lab=_73614_/A }
C {devices/lab_pin.sym} 112140 -12990 0 1 {name=p111474 lab=_73740_/X }
C {sky130_stdcells/buf_2.sym} 112100 -12990 0 0 {name=X_73740_ }
C {devices/lab_pin.sym} 112010 -12870 0 0 {name=p111475 lab=_85727_/CLK }
C {devices/lab_pin.sym} 112010 -12850 0 0 {name=p111476 lab=_85726_/D }
C {devices/lab_pin.sym} 112190 -12870 0 1 {name=p111477 lab=_85726_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -12860 0 0 {name=X_85726_ }
C {devices/lab_pin.sym} 112040 -12750 0 0 {name=p111478 lab=_70947_/A }
C {devices/lab_pin.sym} 112040 -12710 0 0 {name=p111479 lab=_70952_/B }
C {devices/lab_pin.sym} 112040 -12670 0 0 {name=p111480 lab=_70954_/C }
C {devices/lab_pin.sym} 112160 -12710 0 1 {name=p111481 lab=_70952_/Y }
C {sky130_stdcells/nand3_4.sym} 112100 -12710 0 0 {name=X_70952_ }
C {devices/lab_pin.sym} 112020 -12600 0 0 {name=p111482 lab=_58663_/Y }
C {devices/lab_pin.sym} 112020 -12560 0 0 {name=p111483 lab=_58624_/X }
C {devices/lab_pin.sym} 112020 -12520 0 0 {name=p111484 lab=_58670_/X }
C {devices/lab_pin.sym} 112020 -12480 0 0 {name=p111485 lab=_58673_/X }
C {devices/lab_pin.sym} 112180 -12540 0 1 {name=p111486 lab=_84809_/D }
C {sky130_stdcells/a22oi_4.sym} 112100 -12540 0 0 {name=X_58674_ }
C {devices/lab_pin.sym} 112010 -12390 0 0 {name=p111487 lab=_81190_/CLK }
C {devices/lab_pin.sym} 112010 -12370 0 0 {name=p111488 lab=_78311_/Y }
C {devices/lab_pin.sym} 112190 -12390 0 1 {name=p111489 lab=_46337_/A }
C {sky130_stdcells/dfxtp_4.sym} 112100 -12380 0 0 {name=X_82938_ }
C {devices/lab_pin.sym} 112020 -12280 0 0 {name=p111490 lab=_85206_/Q }
C {devices/lab_pin.sym} 112020 -12240 0 0 {name=p111491 lab=_55531_/X }
C {devices/lab_pin.sym} 112020 -12200 0 0 {name=p111492 lab=_55610_/A }
C {devices/lab_pin.sym} 112020 -12160 0 0 {name=p111493 lab=_55885_/X }
C {devices/lab_pin.sym} 112180 -12220 0 1 {name=p111494 lab=_55886_/X }
C {sky130_stdcells/a211o_4.sym} 112100 -12220 0 0 {name=X_55886_ }
C {devices/lab_pin.sym} 112060 -12070 0 0 {name=p111495 lab=clkbuf_9_293_0_CLK/X }
C {devices/lab_pin.sym} 112140 -12070 0 1 {name=p111496 lab=_80968_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 112100 -12070 0 0 {name=Xclkbuf_10_587_0_CLK }
C {devices/lab_pin.sym} 112040 -11960 0 0 {name=p111497 lab=_57630_/A }
C {devices/lab_pin.sym} 112040 -11920 0 0 {name=p111498 lab=_53593_/B }
C {devices/lab_pin.sym} 112160 -11940 0 1 {name=p111499 lab=_57625_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -11940 0 0 {name=X_57625_ }
C {devices/lab_pin.sym} 112040 -11840 0 0 {name=p111500 lab=_54857_/A }
C {devices/lab_pin.sym} 112040 -11800 0 0 {name=p111501 lab=_54843_/B }
C {devices/lab_pin.sym} 112040 -11760 0 0 {name=p111502 lab=_54857_/C }
C {devices/lab_pin.sym} 112040 -11720 0 0 {name=p111503 lab=_53144_/D }
C {devices/lab_pin.sym} 112160 -11780 0 1 {name=p111504 lab=_54837_/X }
C {sky130_stdcells/and4_4.sym} 112100 -11780 0 0 {name=X_54837_ }
C {devices/lab_pin.sym} 112060 -11630 0 0 {name=p111505 lab=_42850_/Y }
C {devices/lab_pin.sym} 112140 -11630 0 1 {name=p111506 lab=_42851_/Y }
C {sky130_stdcells/inv_2.sym} 112100 -11630 0 0 {name=X_42851_ }
C {devices/lab_pin.sym} 112040 -11530 0 0 {name=p111507 lab=_73669_/X }
C {devices/lab_pin.sym} 112040 -11490 0 0 {name=p111508 lab=_73655_/X }
C {devices/lab_pin.sym} 112040 -11450 0 0 {name=p111509 lab=_73658_/Y }
C {devices/lab_pin.sym} 112160 -11490 0 1 {name=p111510 lab=_73671_/Y }
C {sky130_stdcells/nand3_4.sym} 112100 -11490 0 0 {name=X_73671_ }
C {devices/lab_pin.sym} 112010 -11350 0 0 {name=p111511 lab=_85433_/CLK }
C {devices/lab_pin.sym} 112010 -11330 0 0 {name=p111512 lab=_85657_/D }
C {devices/lab_pin.sym} 112190 -11350 0 1 {name=p111513 lab=_85657_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -11340 0 0 {name=X_85657_ }
C {devices/lab_pin.sym} 112060 -11210 0 0 {name=p111514 lab=_70882_/Y }
C {devices/lab_pin.sym} 112140 -11210 0 1 {name=p111515 lab=_70884_/B }
C {sky130_stdcells/buf_2.sym} 112100 -11210 0 0 {name=X_70883_ }
C {devices/lab_pin.sym} 112010 -11090 0 0 {name=p111516 lab=_82349_/CLK }
C {devices/lab_pin.sym} 112010 -11070 0 0 {name=p111517 lab=_78213_/B }
C {devices/lab_pin.sym} 112190 -11090 0 1 {name=p111518 lab=_82869_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -11080 0 0 {name=X_82869_ }
C {devices/lab_pin.sym} 112040 -10960 0 0 {name=p111519 lab=_75411_/A }
C {devices/lab_pin.sym} 112040 -10920 0 0 {name=p111520 lab=_80965_/Q }
C {devices/lab_pin.sym} 112160 -10940 0 1 {name=p111521 lab=_75413_/B }
C {sky130_stdcells/nor2_4.sym} 112100 -10940 0 0 {name=X_75410_ }
C {devices/lab_pin.sym} 112060 -10810 0 0 {name=p111522 lab=_41802_/A }
C {devices/lab_pin.sym} 112140 -10810 0 1 {name=p111523 lab=_41802_/X }
C {sky130_stdcells/buf_2.sym} 112100 -10810 0 0 {name=X_41802_ }
C {devices/lab_pin.sym} 112020 -10720 0 0 {name=p111524 lab=_79198_/B }
C {devices/lab_pin.sym} 112020 -10680 0 0 {name=p111525 lab=_72590_/X }
C {devices/lab_pin.sym} 112020 -10640 0 0 {name=p111526 lab=_72621_/Y }
C {devices/lab_pin.sym} 112020 -10600 0 0 {name=p111527 lab=_72612_/X }
C {devices/lab_pin.sym} 112180 -10660 0 1 {name=p111528 lab=_72622_/X }
C {sky130_stdcells/o22a_4.sym} 112100 -10660 0 0 {name=X_72622_ }
C {devices/lab_pin.sym} 112010 -10510 0 0 {name=p111529 lab=_83218_/CLK }
C {devices/lab_pin.sym} 112010 -10490 0 0 {name=p111530 lab=_60514_/X }
C {devices/lab_pin.sym} 112190 -10510 0 1 {name=p111531 lab=_79148_/A }
C {sky130_stdcells/dfxtp_4.sym} 112100 -10500 0 0 {name=X_84608_ }
C {devices/lab_pin.sym} 112060 -10370 0 0 {name=p111532 lab=_44891_/X }
C {devices/lab_pin.sym} 112140 -10370 0 1 {name=p111533 lab=_45570_/X }
C {sky130_stdcells/buf_2.sym} 112100 -10370 0 0 {name=X_45570_ }
C {devices/lab_pin.sym} 112040 -10260 0 0 {name=p111534 lab=_57597_/A }
C {devices/lab_pin.sym} 112040 -10220 0 0 {name=p111535 lab=_50300_/B }
C {devices/lab_pin.sym} 112160 -10240 0 1 {name=p111536 lab=_57556_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -10240 0 0 {name=X_57556_ }
C {devices/lab_pin.sym} 112040 -10120 0 0 {name=p111537 lab=_81266_/Q }
C {devices/lab_pin.sym} 112040 -10080 0 0 {name=p111538 lab=_81522_/D }
C {devices/lab_pin.sym} 112160 -10100 0 1 {name=p111539 lab=_76390_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -10100 0 0 {name=X_76390_ }
C {devices/lab_pin.sym} 112010 -9970 0 0 {name=p111540 lab=_88376_/CLK }
C {devices/lab_pin.sym} 112010 -9950 0 0 {name=p111541 lab=_88376_/D }
C {devices/lab_pin.sym} 112190 -9970 0 1 {name=p111542 lab=_88376_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -9960 0 0 {name=X_88376_ }
C {devices/lab_pin.sym} 112020 -9870 0 0 {name=p111543 lab=_42774_/X }
C {devices/lab_pin.sym} 112020 -9830 0 0 {name=p111544 lab=_42775_/X }
C {devices/lab_pin.sym} 112020 -9790 0 0 {name=p111545 lab=_41341_/X }
C {devices/lab_pin.sym} 112020 -9750 0 0 {name=p111546 lab=_87721_/Q }
C {devices/lab_pin.sym} 112020 -9710 0 0 {name=p111547 lab=_42781_/X }
C {devices/lab_pin.sym} 112180 -9790 0 1 {name=p111548 lab=_42782_/Y }
C {sky130_stdcells/o32ai_4.sym} 112100 -9790 0 0 {name=X_42782_ }
C {devices/lab_pin.sym} 112040 -9640 0 0 {name=p111549 lab=_54758_/X }
C {devices/lab_pin.sym} 112040 -9600 0 0 {name=p111550 lab=_47490_/A }
C {devices/lab_pin.sym} 112160 -9620 0 1 {name=p111551 lab=_54768_/Y }
C {sky130_stdcells/nand2_4.sym} 112100 -9620 0 0 {name=X_54768_ }
C {devices/lab_pin.sym} 112010 -9490 0 0 {name=p111552 lab=_83068_/CLK }
C {devices/lab_pin.sym} 112010 -9470 0 0 {name=p111553 lab=_85588_/D }
C {devices/lab_pin.sym} 112190 -9490 0 1 {name=p111554 lab=_85588_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -9480 0 0 {name=X_85588_ }
C {devices/lab_pin.sym} 112020 -9390 0 0 {name=p111555 lab=_44512_/X }
C {devices/lab_pin.sym} 112020 -9350 0 0 {name=p111556 lab=_44513_/X }
C {devices/lab_pin.sym} 112020 -9310 0 0 {name=p111557 lab=_40776_/A }
C {devices/lab_pin.sym} 112020 -9270 0 0 {name=p111558 lab=_44520_/Y }
C {devices/lab_pin.sym} 112020 -9230 0 0 {name=p111559 lab=_44516_/X }
C {devices/lab_pin.sym} 112180 -9310 0 1 {name=p111560 lab=_44521_/Y }
C {sky130_stdcells/o32ai_4.sym} 112100 -9310 0 0 {name=X_44521_ }
C {devices/lab_pin.sym} 112060 -9150 0 0 {name=p111561 lab=clkbuf_9_255_0_CLK/X }
C {devices/lab_pin.sym} 112140 -9150 0 1 {name=p111562 lab=_82768_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 112100 -9150 0 0 {name=Xclkbuf_10_510_0_CLK }
C {devices/lab_pin.sym} 112040 -9050 0 0 {name=p111563 lab=_56510_/A }
C {devices/lab_pin.sym} 112040 -9010 0 0 {name=p111564 lab=_56507_/B }
C {devices/lab_pin.sym} 112040 -8970 0 0 {name=p111565 lab=_55833_/B }
C {devices/lab_pin.sym} 112160 -9010 0 1 {name=p111566 lab=_56507_/Y }
C {sky130_stdcells/nand3_4.sym} 112100 -9010 0 0 {name=X_56507_ }
C {devices/lab_pin.sym} 112060 -8870 0 0 {name=p111567 lab=_75341_/A }
C {devices/lab_pin.sym} 112140 -8870 0 1 {name=p111568 lab=_75364_/A }
C {sky130_stdcells/inv_2.sym} 112100 -8870 0 0 {name=X_75341_ }
C {devices/lab_pin.sym} 112040 -8760 0 0 {name=p111569 lab=_82893_/Q }
C {devices/lab_pin.sym} 112040 -8720 0 0 {name=p111570 lab=_41653_/X }
C {devices/lab_pin.sym} 112160 -8740 0 1 {name=p111571 lab=_41733_/X }
C {sky130_stdcells/or2_4.sym} 112100 -8740 0 0 {name=X_41733_ }
C {devices/lab_pin.sym} 112010 -8610 0 0 {name=p111572 lab=_87850_/CLK }
C {devices/lab_pin.sym} 112010 -8590 0 0 {name=p111573 lab=_87327_/D }
C {devices/lab_pin.sym} 112190 -8610 0 1 {name=p111574 lab=_87327_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -8600 0 0 {name=X_87327_ }
C {devices/lab_pin.sym} 112020 -8490 0 0 {name=p111575 lab=_85581_/Q }
C {devices/lab_pin.sym} 112020 -8450 0 0 {name=p111576 lab=_53687_/X }
C {devices/lab_pin.sym} 112020 -8410 0 0 {name=p111577 lab=_53718_/Y }
C {devices/lab_pin.sym} 112180 -8450 0 1 {name=p111578 lab=_53719_/Y }
C {sky130_stdcells/o21ai_4.sym} 112100 -8450 0 0 {name=X_53719_ }
C {devices/lab_pin.sym} 112060 -8310 0 0 {name=p111579 lab=_72552_/X }
C {devices/lab_pin.sym} 112140 -8310 0 1 {name=p111580 lab=_83235_/D }
C {sky130_stdcells/inv_2.sym} 112100 -8310 0 0 {name=X_72553_ }
C {devices/lab_pin.sym} 112010 -8190 0 0 {name=p111581 lab=_84534_/CLK }
C {devices/lab_pin.sym} 112010 -8170 0 0 {name=p111582 lab=_84539_/D }
C {devices/lab_pin.sym} 112190 -8190 0 1 {name=p111583 lab=_76987_/A }
C {sky130_stdcells/dfxtp_4.sym} 112100 -8180 0 0 {name=X_84539_ }
C {devices/lab_pin.sym} 112040 -8070 0 0 {name=p111584 lab=_56927_/A }
C {devices/lab_pin.sym} 112040 -8030 0 0 {name=p111585 lab=_57440_/A }
C {devices/lab_pin.sym} 112040 -7990 0 0 {name=p111586 lab=_56927_/C }
C {devices/lab_pin.sym} 112160 -8030 0 1 {name=p111587 lab=_57487_/X }
C {sky130_stdcells/and3_4.sym} 112100 -8030 0 0 {name=X_57487_ }
C {devices/lab_pin.sym} 112060 -7890 0 0 {name=p111588 lab=_54616_/X }
C {devices/lab_pin.sym} 112140 -7890 0 1 {name=p111589 lab=_54699_/X }
C {sky130_stdcells/buf_2.sym} 112100 -7890 0 0 {name=X_54699_ }
C {devices/lab_pin.sym} 112060 -7770 0 0 {name=p111590 lab=_47382_/A }
C {devices/lab_pin.sym} 112140 -7770 0 1 {name=p111591 lab=_47240_/X }
C {sky130_stdcells/buf_2.sym} 112100 -7770 0 0 {name=X_47240_ }
C {devices/lab_pin.sym} 112040 -7660 0 0 {name=p111592 lab=_59226_/A }
C {devices/lab_pin.sym} 112040 -7620 0 0 {name=p111593 lab=_59226_/B }
C {devices/lab_pin.sym} 112160 -7640 0 1 {name=p111594 lab=_59226_/Y }
C {sky130_stdcells/nor2_4.sym} 112100 -7640 0 0 {name=X_59226_ }
C {devices/lab_pin.sym} 112040 -7530 0 0 {name=p111595 lab=_71500_/A }
C {devices/lab_pin.sym} 112040 -7490 0 0 {name=p111596 lab=_71261_/B }
C {devices/lab_pin.sym} 112040 -7450 0 0 {name=p111597 lab=_71504_/C }
C {devices/lab_pin.sym} 112160 -7490 0 1 {name=p111598 lab=_71504_/Y }
C {sky130_stdcells/nand3_4.sym} 112100 -7490 0 0 {name=X_71504_ }
C {devices/lab_pin.sym} 112040 -7360 0 0 {name=p111599 lab=_84565_/Q }
C {devices/lab_pin.sym} 112040 -7320 0 0 {name=p111600 lab=_78060_/B }
C {devices/lab_pin.sym} 112160 -7340 0 1 {name=p111601 lab=_78060_/X }
C {sky130_stdcells/xor2_4.sym} 112100 -7340 0 0 {name=X_78060_ }
C {devices/lab_pin.sym} 112020 -7230 0 0 {name=p111602 lab=_56134_/X }
C {devices/lab_pin.sym} 112020 -7190 0 0 {name=p111603 lab=_56426_/X }
C {devices/lab_pin.sym} 112020 -7150 0 0 {name=p111604 lab=_56437_/Y }
C {devices/lab_pin.sym} 112180 -7190 0 1 {name=p111605 lab=_85194_/D }
C {sky130_stdcells/o21ai_4.sym} 112100 -7190 0 0 {name=X_56438_ }
C {devices/lab_pin.sym} 112060 -7050 0 0 {name=p111606 lab=_46298_/A }
C {devices/lab_pin.sym} 112140 -7050 0 1 {name=p111607 lab=_44602_/A }
C {sky130_stdcells/buf_2.sym} 112100 -7050 0 0 {name=X_44452_ }
C {devices/lab_pin.sym} 112020 -6950 0 0 {name=p111608 lab=_75268_/Y }
C {devices/lab_pin.sym} 112020 -6910 0 0 {name=p111609 lab=_75270_/Y }
C {devices/lab_pin.sym} 112020 -6870 0 0 {name=p111610 lab=_75267_/Y }
C {devices/lab_pin.sym} 112180 -6910 0 1 {name=p111611 lab=_75272_/Y }
C {sky130_stdcells/o21ai_4.sym} 112100 -6910 0 0 {name=X_75272_ }
C {devices/lab_pin.sym} 112010 -6770 0 0 {name=p111612 lab=_87776_/CLK }
C {devices/lab_pin.sym} 112010 -6750 0 0 {name=p111613 lab=_43806_/Y }
C {devices/lab_pin.sym} 112190 -6770 0 1 {name=p111614 lab=_87258_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -6760 0 0 {name=X_87258_ }
C {devices/lab_pin.sym} 112020 -6660 0 0 {name=p111615 lab=_41663_/X }
C {devices/lab_pin.sym} 112020 -6620 0 0 {name=p111616 lab=_41638_/X }
C {devices/lab_pin.sym} 112020 -6580 0 0 {name=p111617 lab=_67482_/B }
C {devices/lab_pin.sym} 112020 -6540 0 0 {name=p111618 lab=_41639_/X }
C {devices/lab_pin.sym} 112180 -6600 0 1 {name=p111619 lab=_88173_/D }
C {sky130_stdcells/a2bb2o_4.sym} 112100 -6600 0 0 {name=X_41664_ }
C {devices/lab_pin.sym} 112060 -6450 0 0 {name=p111620 lab=_72484_/A }
C {devices/lab_pin.sym} 112140 -6450 0 1 {name=p111621 lab=_72484_/X }
C {sky130_stdcells/buf_2.sym} 112100 -6450 0 0 {name=X_72484_ }
C {devices/lab_pin.sym} 112040 -6340 0 0 {name=p111622 lab=_77019_/A }
C {devices/lab_pin.sym} 112040 -6300 0 0 {name=p111623 lab=_77011_/B }
C {devices/lab_pin.sym} 112160 -6320 0 1 {name=p111624 lab=_77015_/A }
C {sky130_stdcells/nor2_4.sym} 112100 -6320 0 0 {name=X_77011_ }
C {devices/lab_pin.sym} 112020 -6220 0 0 {name=p111625 lab=_41485_/X }
C {devices/lab_pin.sym} 112020 -6180 0 0 {name=p111626 lab=_43396_/X }
C {devices/lab_pin.sym} 112020 -6140 0 0 {name=p111627 lab=_87438_/Q }
C {devices/lab_pin.sym} 112020 -6100 0 0 {name=p111628 lab=_43397_/X }
C {devices/lab_pin.sym} 112180 -6160 0 1 {name=p111629 lab=_43403_/X }
C {sky130_stdcells/a2bb2o_4.sym} 112100 -6160 0 0 {name=X_43403_ }
C {devices/lab_pin.sym} 112020 -6030 0 0 {name=p111630 lab=_70130_/A }
C {devices/lab_pin.sym} 112020 -5990 0 0 {name=p111631 lab=_74139_/X }
C {devices/lab_pin.sym} 112020 -5950 0 0 {name=p111632 lab=_74222_/Y }
C {devices/lab_pin.sym} 112180 -5990 0 1 {name=p111633 lab=_83117_/D }
C {sky130_stdcells/a21o_4.sym} 112100 -5990 0 0 {name=X_74223_ }
C {devices/lab_pin.sym} 112010 -5850 0 0 {name=p111634 lab=_85599_/CLK }
C {devices/lab_pin.sym} 112010 -5830 0 0 {name=p111635 lab=_86209_/D }
C {devices/lab_pin.sym} 112190 -5850 0 1 {name=p111636 lab=_86209_/Q }
C {sky130_stdcells/dfxtp_4.sym} 112100 -5840 0 0 {name=X_86209_ }
C {devices/lab_pin.sym} 112040 -5720 0 0 {name=p111637 lab=_40615_/A }
C {devices/lab_pin.sym} 112040 -5680 0 0 {name=p111638 lab=_40588_/B }
C {devices/lab_pin.sym} 112160 -5700 0 1 {name=p111639 lab=_40615_/X }
C {sky130_stdcells/or2_4.sym} 112100 -5700 0 0 {name=X_40615_ }
C {devices/lab_pin.sym} 112040 -5600 0 0 {name=p111640 lab=_47152_/X }
C {devices/lab_pin.sym} 112040 -5560 0 0 {name=p111641 lab=_47133_/B }
C {devices/lab_pin.sym} 112040 -5520 0 0 {name=p111642 lab=_47143_/C }
C {devices/lab_pin.sym} 112040 -5480 0 0 {name=p111643 lab=_52895_/D }
C {devices/lab_pin.sym} 112160 -5540 0 1 {name=p111644 lab=_47171_/X }
C {sky130_stdcells/and4_4.sym} 112100 -5540 0 0 {name=X_47171_ }
C {devices/lab_pin.sym} 112020 -5430 0 0 {name=p111645 lab=_59152_/X }
C {devices/lab_pin.sym} 112020 -5390 0 0 {name=p111646 lab=_59154_/Y }
C {devices/lab_pin.sym} 112020 -5350 0 0 {name=p111647 lab=_59155_/Y }
C {devices/lab_pin.sym} 112020 -5310 0 0 {name=p111648 lab=_58943_/X }
C {devices/lab_pin.sym} 112020 -5270 0 0 {name=p111649 lab=_59156_/X }
C {devices/lab_pin.sym} 112180 -5350 0 1 {name=p111650 lab=_59157_/X }
C {sky130_stdcells/o32a_4.sym} 112100 -5350 0 0 {name=X_59157_ }
C {devices/lab_pin.sym} 112040 -5220 0 0 {name=p111651 lab=_71432_/A }
C {devices/lab_pin.sym} 112040 -5180 0 0 {name=p111652 lab=_71435_/B }
C {devices/lab_pin.sym} 112040 -5140 0 0 {name=p111653 lab=_71435_/C }
C {devices/lab_pin.sym} 112040 -5100 0 0 {name=p111654 lab=_71432_/D }
C {devices/lab_pin.sym} 112160 -5160 0 1 {name=p111655 lab=_71435_/X }
C {sky130_stdcells/and4_4.sym} 112100 -5160 0 0 {name=X_71435_ }
C {devices/lab_pin.sym} 112060 -5010 0 0 {name=p111656 lab=_44352_/X }
C {devices/lab_pin.sym} 112140 -5010 0 1 {name=p111657 lab=_44383_/X }
C {sky130_stdcells/buf_2.sym} 112100 -5010 0 0 {name=X_44383_ }
C {devices/lab_pin.sym} 112040 -4900 0 0 {name=p111658 lab=_56367_/Y }
C {devices/lab_pin.sym} 112040 -4860 0 0 {name=p111659 lab=_56368_/Y }
C {devices/lab_pin.sym} 112160 -4880 0 1 {name=p111660 lab=_85218_/D }
C {sky130_stdcells/nand2_4.sym} 112100 -4880 0 0 {name=X_56369_ }
C {devices/lab_pin.sym} 112010 -4750 0 0 {name=p111661 lab=_87189_/CLK }
C {devices/lab_pin.sym} 112010 -4730 0 0 {name=p111662 lab=_43938_/X }
C {devices/lab_pin.sym} 112190 -4750 0 1 {name=p111663 lab=_68044_/B }
C {sky130_stdcells/dfxtp_4.sym} 112100 -4740 0 0 {name=X_87189_ }
C {devices/lab_pin.sym} 112020 -4630 0 0 {name=p111664 lab=_41344_/X }
C {devices/lab_pin.sym} 112020 -4590 0 0 {name=p111665 lab=_81159_/Q }
C {devices/lab_pin.sym} 112020 -4550 0 0 {name=p111666 lab=_41594_/X }
C {devices/lab_pin.sym} 112180 -4590 0 1 {name=p111667 lab=_41595_/X }
C {sky130_stdcells/o21a_4.sym} 112100 -4590 0 0 {name=X_41595_ }
C {devices/lab_pin.sym} 112060 -4450 0 0 {name=p111668 lab=clkbuf_9_262_0_CLK/X }
C {devices/lab_pin.sym} 112140 -4450 0 1 {name=p111669 lab=_81344_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 112100 -4450 0 0 {name=Xclkbuf_10_525_0_CLK }
C {devices/lab_pin.sym} 112020 -4370 0 0 {name=p111670 lab=_46162_/B }
C {devices/lab_pin.sym} 112020 -4330 0 0 {name=p111671 lab=_46120_/Y }
C {devices/lab_pin.sym} 112020 -4290 0 0 {name=p111672 lab=_46121_/Y }
C {devices/lab_pin.sym} 112020 -4250 0 0 {name=p111673 lab=_46108_/D }
C {devices/lab_pin.sym} 112020 -4220 0 0 {name=p111674 lab=_45909_/X }
C {devices/lab_pin.sym} 112180 -4290 0 1 {name=p111675 lab=_46122_/Y }
C {sky130_stdcells/a41oi_4.sym} 112100 -4290 0 0 {name=X_46122_ }
C {devices/lab_pin.sym} 112060 -4130 0 0 {name=p111676 lab=_58108_/A }
C {devices/lab_pin.sym} 112140 -4130 0 1 {name=p111677 lab=_58108_/Y }
C {sky130_stdcells/inv_2.sym} 112100 -4130 0 0 {name=X_58108_ }
C {devices/lab_pin.sym} 112060 -4010 0 0 {name=p111678 lab=clkbuf_5_8_0_CLK/X }
C {devices/lab_pin.sym} 112140 -4010 0 1 {name=p111679 lab=clkbuf_6_16_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 112100 -4010 0 0 {name=Xclkbuf_6_16_0_CLK }
C {devices/lab_pin.sym} 112020 -3920 0 0 {name=p111680 lab=_41288_/X }
C {devices/lab_pin.sym} 112020 -3880 0 0 {name=p111681 lab=_43325_/X }
C {devices/lab_pin.sym} 112020 -3840 0 0 {name=p111682 lab=_87475_/Q }
C {devices/lab_pin.sym} 112020 -3800 0 0 {name=p111683 lab=_43326_/X }
C {devices/lab_pin.sym} 112180 -3860 0 1 {name=p111684 lab=_87475_/D }
C {sky130_stdcells/a2bb2o_4.sym} 112100 -3860 0 0 {name=X_43334_ }
C {devices/lab_pin.sym} 112020 -3730 0 0 {name=p111685 lab=_74151_/X }
C {devices/lab_pin.sym} 112020 -3690 0 0 {name=p111686 lab=_74153_/X }
C {devices/lab_pin.sym} 112020 -3650 0 0 {name=p111687 lab=_74085_/X }
C {devices/lab_pin.sym} 112180 -3690 0 1 {name=p111688 lab=_74154_/X }
C {sky130_stdcells/a21o_4.sym} 112100 -3690 0 0 {name=X_74154_ }
C {devices/lab_pin.sym} 112040 -3560 0 0 {name=p111689 lab=_40546_/A }
C {devices/lab_pin.sym} 112040 -3520 0 0 {name=p111690 lab=_40467_/B }
C {devices/lab_pin.sym} 112160 -3540 0 1 {name=p111691 lab=_40546_/X }
C {sky130_stdcells/or2_4.sym} 112100 -3540 0 0 {name=X_40546_ }
C {devices/lab_pin.sym} 112020 -3430 0 0 {name=p111692 lab=_59083_/Y }
C {devices/lab_pin.sym} 112020 -3390 0 0 {name=p111693 lab=_59087_/Y }
C {devices/lab_pin.sym} 112020 -3350 0 0 {name=p111694 lab=_58939_/X }
C {devices/lab_pin.sym} 112180 -3390 0 1 {name=p111695 lab=_59088_/X }
C {sky130_stdcells/a21o_4.sym} 112100 -3390 0 0 {name=X_59088_ }
C {devices/lab_pin.sym} 112040 -3280 0 0 {name=p111696 lab=_71366_/A }
C {devices/lab_pin.sym} 112040 -3240 0 0 {name=p111697 lab=_70939_/A }
C {devices/lab_pin.sym} 112040 -3200 0 0 {name=p111698 lab=_70790_/A }
C {devices/lab_pin.sym} 112040 -3160 0 0 {name=p111699 lab=_71365_/X }
C {devices/lab_pin.sym} 112160 -3220 0 1 {name=p111700 lab=_71366_/X }
C {sky130_stdcells/and4_4.sym} 112100 -3220 0 0 {name=X_71366_ }
C {devices/lab_pin.sym} 112020 -3090 0 0 {name=p111701 lab=_69740_/B }
C {devices/lab_pin.sym} 112020 -3050 0 0 {name=p111702 lab=_72731_/X }
C {devices/lab_pin.sym} 112020 -3010 0 0 {name=p111703 lab=_56548_/X }
C {devices/lab_pin.sym} 112180 -3050 0 1 {name=p111704 lab=_73105_/Y }
C {sky130_stdcells/o21ai_4.sym} 112100 -3050 0 0 {name=X_73105_ }
C {devices/lab_pin.sym} 112040 -2920 0 0 {name=p111705 lab=_86634_/Q }
C {devices/lab_pin.sym} 112040 -2880 0 0 {name=p111706 lab=_58039_/B }
C {devices/lab_pin.sym} 112160 -2900 0 1 {name=p111707 lab=_58039_/Y }
C {sky130_stdcells/nor2_4.sym} 112100 -2900 0 0 {name=X_58039_ }
C {devices/lab_pin.sym} 112060 -2770 0 0 {name=p111708 lab=_70317_/A }
C {devices/lab_pin.sym} 112140 -2770 0 1 {name=p111709 lab=_70317_/Y }
C {sky130_stdcells/inv_2.sym} 112100 -2770 0 0 {name=X_70317_ }
C {devices/lab_pin.sym} 112020 -2680 0 0 {name=p111710 lab=_41529_/A }
C {devices/lab_pin.sym} 112020 -2640 0 0 {name=p111711 lab=_46043_/X }
C {devices/lab_pin.sym} 112020 -2600 0 0 {name=p111712 lab=_86792_/Q }
C {devices/lab_pin.sym} 112020 -2560 0 0 {name=p111713 lab=_46044_/X }
C {devices/lab_pin.sym} 112180 -2620 0 1 {name=p111714 lab=_86792_/D }
C {sky130_stdcells/a2bb2o_4.sym} 112100 -2620 0 0 {name=X_46053_ }
C {devices/lab_pin.sym} 112060 -2470 0 0 {name=p111715 lab=_43218_/A }
C {devices/lab_pin.sym} 112140 -2470 0 1 {name=p111716 lab=_43265_/X }
C {sky130_stdcells/buf_2.sym} 112100 -2470 0 0 {name=X_43265_ }
C {devices/lab_pin.sym} 112040 -2360 0 0 {name=p111717 lab=_78948_/Y }
C {devices/lab_pin.sym} 112040 -2320 0 0 {name=p111718 lab=_79115_/A }
C {devices/lab_pin.sym} 112160 -2340 0 1 {name=p111719 lab=_78962_/Y }
C {sky130_stdcells/nor2_4.sym} 112100 -2340 0 0 {name=X_78962_ }
C {devices/lab_pin.sym} 112060 -2210 0 0 {name=p111720 lab=_72877_/A }
C {devices/lab_pin.sym} 112140 -2210 0 1 {name=p111721 lab=_74085_/X }
C {sky130_stdcells/buf_2.sym} 112100 -2210 0 0 {name=X_74085_ }
C {devices/lab_pin.sym} 112060 -2090 0 0 {name=p111722 lab=_44733_/A }
C {devices/lab_pin.sym} 112140 -2090 0 1 {name=p111723 lab=_40477_/X }
C {sky130_stdcells/buf_2.sym} 112100 -2090 0 0 {name=X_40477_ }
C {devices/lab_pin.sym} 112060 -1970 0 0 {name=p111724 lab=_70809_/A }
C {devices/lab_pin.sym} 112140 -1970 0 1 {name=p111725 lab=_71297_/X }
C {sky130_stdcells/buf_2.sym} 112100 -1970 0 0 {name=X_71297_ }
C {devices/lab_pin.sym} 112060 -1850 0 0 {name=p111726 lab=_45153_/A }
C {devices/lab_pin.sym} 112140 -1850 0 1 {name=p111727 lab=_45004_/X }
C {sky130_stdcells/buf_2.sym} 112100 -1850 0 0 {name=X_45004_ }
C {devices/lab_pin.sym} 112020 -1770 0 0 {name=p111728 lab=_42205_/X }
C {devices/lab_pin.sym} 112020 -1730 0 0 {name=p111729 lab=_42200_/X }
C {devices/lab_pin.sym} 112020 -1690 0 0 {name=p111730 lab=_41347_/X }
C {devices/lab_pin.sym} 112020 -1650 0 0 {name=p111731 lab=_87976_/Q }
C {devices/lab_pin.sym} 112020 -1610 0 0 {name=p111732 lab=_42201_/X }
C {devices/lab_pin.sym} 112180 -1690 0 1 {name=p111733 lab=_42217_/A }
C {sky130_stdcells/o32ai_4.sym} 112100 -1690 0 0 {name=X_42216_ }
C {devices/lab_pin.sym} 112020 -1570 0 0 {name=p111734 lab=_60961_/X }
C {devices/lab_pin.sym} 112020 -1530 0 0 {name=p111735 lab=_60911_/X }
C {devices/lab_pin.sym} 112020 -1490 0 0 {name=p111736 lab=_60993_/Y }
C {devices/lab_pin.sym} 112020 -1450 0 0 {name=p111737 lab=_60972_/X }
C {devices/lab_pin.sym} 112020 -1410 0 0 {name=p111738 lab=_61049_/X }
C {devices/lab_pin.sym} 112180 -1490 0 1 {name=p111739 lab=_61050_/X }
C {sky130_stdcells/o41a_4.sym} 112100 -1490 0 0 {name=X_61050_ }
C {devices/lab_pin.sym} 112020 -1360 0 0 {name=p111740 lab=_77899_/Y }
C {devices/lab_pin.sym} 112020 -1320 0 0 {name=p111741 lab=_77900_/Y }
C {devices/lab_pin.sym} 112020 -1280 0 0 {name=p111742 lab=_82068_/Q }
C {devices/lab_pin.sym} 112020 -1240 0 0 {name=p111743 lab=_81940_/D }
C {devices/lab_pin.sym} 112180 -1300 0 1 {name=p111744 lab=_77913_/X }
C {sky130_stdcells/a2bb2o_4.sym} 112100 -1300 0 0 {name=X_77913_ }
C {devices/lab_pin.sym} 112040 -1160 0 0 {name=p111745 lab=_73036_/A }
C {devices/lab_pin.sym} 112040 -1120 0 0 {name=p111746 lab=_73372_/B }
C {devices/lab_pin.sym} 112160 -1140 0 1 {name=p111747 lab=_73036_/Y }
C {sky130_stdcells/nor2_4.sym} 112100 -1140 0 0 {name=X_73036_ }
C {devices/lab_pin.sym} 112060 -1010 0 0 {name=p111748 lab=_70247_/X }
C {devices/lab_pin.sym} 112140 -1010 0 1 {name=p111749 lab=_70260_/B }
C {sky130_stdcells/buf_2.sym} 112100 -1010 0 0 {name=X_70248_ }
C {devices/lab_pin.sym} 112060 -890 0 0 {name=p111750 lab=_43162_/A }
C {devices/lab_pin.sym} 112140 -890 0 1 {name=p111751 lab=_43196_/X }
C {sky130_stdcells/buf_2.sym} 112100 -890 0 0 {name=X_43196_ }
C {devices/lab_pin.sym} 112040 -780 0 0 {name=p111752 lab=_78881_/A }
C {devices/lab_pin.sym} 112040 -740 0 0 {name=p111753 lab=_78888_/A }
C {devices/lab_pin.sym} 112160 -760 0 1 {name=p111754 lab=_78893_/X }
C {sky130_stdcells/and2_4.sym} 112100 -760 0 0 {name=X_78893_ }
C {devices/lab_pin.sym} 112980 -42150 0 0 {name=p111755 lab=clkbuf_2_1_0_CLK/A }
C {devices/lab_pin.sym} 113060 -42150 0 1 {name=p111756 lab=clkbuf_2_1_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 113020 -42150 0 0 {name=Xclkbuf_2_1_0_CLK }
C {devices/lab_pin.sym} 112940 -42070 0 0 {name=p111757 lab=_59998_/Y }
C {devices/lab_pin.sym} 112940 -42030 0 0 {name=p111758 lab=_60000_/Y }
C {devices/lab_pin.sym} 112940 -41990 0 0 {name=p111759 lab=_59969_/X }
C {devices/lab_pin.sym} 112940 -41950 0 0 {name=p111760 lab=_80195_/A }
C {devices/lab_pin.sym} 112940 -41910 0 0 {name=p111761 lab=_59814_/X }
C {devices/lab_pin.sym} 113100 -41990 0 1 {name=p111762 lab=_84676_/D }
C {sky130_stdcells/o32a_4.sym} 113020 -41990 0 0 {name=X_60001_ }
C {devices/lab_pin.sym} 112940 -41850 0 0 {name=p111763 lab=_49810_/Y }
C {devices/lab_pin.sym} 112940 -41810 0 0 {name=p111764 lab=_49787_/X }
C {devices/lab_pin.sym} 112940 -41770 0 0 {name=p111765 lab=_49811_/X }
C {devices/lab_pin.sym} 113100 -41810 0 1 {name=p111766 lab=_49812_/Y }
C {sky130_stdcells/a21oi_4.sym} 113020 -41810 0 0 {name=X_49812_ }
C {devices/lab_pin.sym} 112940 -41700 0 0 {name=p111767 lab=_41157_/X }
C {devices/lab_pin.sym} 112940 -41660 0 0 {name=p111768 lab=_42137_/X }
C {devices/lab_pin.sym} 112940 -41620 0 0 {name=p111769 lab=_88011_/Q }
C {devices/lab_pin.sym} 112940 -41580 0 0 {name=p111770 lab=_42138_/X }
C {devices/lab_pin.sym} 113100 -41640 0 1 {name=p111771 lab=_88011_/D }
C {sky130_stdcells/a2bb2o_4.sym} 113020 -41640 0 0 {name=X_42147_ }
C {devices/lab_pin.sym} 112980 -41490 0 0 {name=p111772 lab=_82063_/Q }
C {devices/lab_pin.sym} 113060 -41490 0 1 {name=p111773 lab=_77844_/Y }
C {sky130_stdcells/inv_2.sym} 113020 -41490 0 0 {name=X_77844_ }
C {devices/lab_pin.sym} 112940 -41390 0 0 {name=p111774 lab=_70169_/X }
C {devices/lab_pin.sym} 112940 -41350 0 0 {name=p111775 lab=_83847_/Q }
C {devices/lab_pin.sym} 112940 -41310 0 0 {name=p111776 lab=_70178_/X }
C {devices/lab_pin.sym} 113100 -41350 0 1 {name=p111777 lab=_83847_/D }
C {sky130_stdcells/a21o_4.sym} 113020 -41350 0 0 {name=X_70179_ }
C {devices/lab_pin.sym} 112980 -41210 0 0 {name=p111778 lab=_49688_/X }
C {devices/lab_pin.sym} 113060 -41210 0 1 {name=p111779 lab=_49757_/A }
C {sky130_stdcells/buf_2.sym} 113020 -41210 0 0 {name=X_49743_ }
C {devices/lab_pin.sym} 112980 -41090 0 0 {name=p111780 lab=_46767_/A }
C {devices/lab_pin.sym} 113060 -41090 0 1 {name=p111781 lab=_46955_/X }
C {sky130_stdcells/buf_2.sym} 113020 -41090 0 0 {name=X_46955_ }
C {devices/lab_pin.sym} 112980 -40970 0 0 {name=p111782 lab=_42025_/A }
C {devices/lab_pin.sym} 113060 -40970 0 1 {name=p111783 lab=_42078_/X }
C {sky130_stdcells/buf_2.sym} 113020 -40970 0 0 {name=X_42078_ }
C {devices/lab_pin.sym} 112960 -40860 0 0 {name=p111784 lab=_82264_/Q }
C {devices/lab_pin.sym} 112960 -40820 0 0 {name=p111785 lab=_77775_/B }
C {devices/lab_pin.sym} 113080 -40840 0 1 {name=p111786 lab=_81928_/D }
C {sky130_stdcells/xor2_4.sym} 113020 -40840 0 0 {name=X_77775_ }
C {devices/lab_pin.sym} 112960 -40730 0 0 {name=p111787 lab=_74987_/A }
C {devices/lab_pin.sym} 112960 -40690 0 0 {name=p111788 lab=_74987_/B }
C {devices/lab_pin.sym} 112960 -40650 0 0 {name=p111789 lab=_74987_/C }
C {devices/lab_pin.sym} 113080 -40690 0 1 {name=p111790 lab=_74988_/B }
C {sky130_stdcells/and3_4.sym} 113020 -40690 0 0 {name=X_74987_ }
C {devices/lab_pin.sym} 112960 -40560 0 0 {name=p111791 lab=_84817_/Q }
C {devices/lab_pin.sym} 112960 -40520 0 0 {name=p111792 lab=_66364_/C }
C {devices/lab_pin.sym} 113080 -40540 0 1 {name=p111793 lab=_79517_/A }
C {sky130_stdcells/xor2_4.sym} 113020 -40540 0 0 {name=X_79514_ }
C {devices/lab_pin.sym} 112940 -40440 0 0 {name=p111794 lab=_42447_/B }
C {devices/lab_pin.sym} 112940 -40400 0 0 {name=p111795 lab=_45884_/A }
C {devices/lab_pin.sym} 112940 -40360 0 0 {name=p111796 lab=_46159_/A }
C {devices/lab_pin.sym} 112940 -40320 0 0 {name=p111797 lab=_45905_/X }
C {devices/lab_pin.sym} 113100 -40380 0 1 {name=p111798 lab=_45907_/A }
C {sky130_stdcells/a211o_4.sym} 113020 -40380 0 0 {name=X_45906_ }
C {devices/lab_pin.sym} 112940 -40260 0 0 {name=p111799 lab=_41028_/X }
C {devices/lab_pin.sym} 112940 -40220 0 0 {name=p111800 lab=_40987_/X }
C {devices/lab_pin.sym} 112940 -40180 0 0 {name=p111801 lab=_69362_/B }
C {devices/lab_pin.sym} 112940 -40140 0 0 {name=p111802 lab=_40989_/X }
C {devices/lab_pin.sym} 113100 -40200 0 1 {name=p111803 lab=_41029_/X }
C {sky130_stdcells/a2bb2o_4.sym} 113020 -40200 0 0 {name=X_41029_ }
C {devices/lab_pin.sym} 112980 -40050 0 0 {name=p111804 lab=_79836_/A }
C {devices/lab_pin.sym} 113060 -40050 0 1 {name=p111805 lab=_64741_/C }
C {sky130_stdcells/inv_2.sym} 113020 -40050 0 0 {name=X_64740_ }
C {devices/lab_pin.sym} 112960 -39940 0 0 {name=p111806 lab=_76726_/A }
C {devices/lab_pin.sym} 112960 -39900 0 0 {name=p111807 lab=_81450_/D }
C {devices/lab_pin.sym} 113080 -39920 0 1 {name=p111808 lab=_76726_/X }
C {sky130_stdcells/xor2_4.sym} 113020 -39920 0 0 {name=X_76726_ }
C {devices/lab_pin.sym} 112940 -39810 0 0 {name=p111809 lab=_49672_/Y }
C {devices/lab_pin.sym} 112940 -39770 0 0 {name=p111810 lab=_49650_/X }
C {devices/lab_pin.sym} 112940 -39730 0 0 {name=p111811 lab=_49673_/X }
C {devices/lab_pin.sym} 113100 -39770 0 1 {name=p111812 lab=_49674_/Y }
C {sky130_stdcells/a21oi_4.sym} 113020 -39770 0 0 {name=X_49674_ }
C {devices/lab_pin.sym} 112960 -39660 0 0 {name=p111813 lab=_61500_/X }
C {devices/lab_pin.sym} 112960 -39620 0 0 {name=p111814 lab=_61933_/X }
C {devices/lab_pin.sym} 112960 -39580 0 0 {name=p111815 lab=_61907_/C }
C {devices/lab_pin.sym} 112960 -39540 0 0 {name=p111816 lab=_61952_/D }
C {devices/lab_pin.sym} 113080 -39600 0 1 {name=p111817 lab=_61952_/Y }
C {sky130_stdcells/nand4_4.sym} 113020 -39600 0 0 {name=X_61952_ }
C {devices/lab_pin.sym} 112940 -39470 0 0 {name=p111818 lab=_70114_/Y }
C {devices/lab_pin.sym} 112940 -39430 0 0 {name=p111819 lab=_73818_/X }
C {devices/lab_pin.sym} 112940 -39390 0 0 {name=p111820 lab=_73937_/Y }
C {devices/lab_pin.sym} 113100 -39430 0 1 {name=p111821 lab=_83130_/D }
C {sky130_stdcells/o21ai_4.sym} 113020 -39430 0 0 {name=X_73938_ }
C {devices/lab_pin.sym} 112980 -39290 0 0 {name=p111822 lab=_46886_/A }
C {devices/lab_pin.sym} 113060 -39290 0 1 {name=p111823 lab=_52732_/B }
C {sky130_stdcells/inv_2.sym} 113020 -39290 0 0 {name=X_46886_ }
C {devices/lab_pin.sym} 112940 -39190 0 0 {name=p111824 lab=_48617_/Y }
C {devices/lab_pin.sym} 112940 -39150 0 0 {name=p111825 lab=_48585_/X }
C {devices/lab_pin.sym} 112940 -39110 0 0 {name=p111826 lab=_48624_/X }
C {devices/lab_pin.sym} 113100 -39150 0 1 {name=p111827 lab=_86506_/D }
C {sky130_stdcells/a21oi_4.sym} 113020 -39150 0 0 {name=X_48625_ }
C {devices/lab_pin.sym} 112940 -39050 0 0 {name=p111828 lab=_60895_/X }
C {devices/lab_pin.sym} 112940 -39010 0 0 {name=p111829 lab=_60901_/X }
C {devices/lab_pin.sym} 112940 -38970 0 0 {name=p111830 lab=_60902_/Y }
C {devices/lab_pin.sym} 112940 -38930 0 0 {name=p111831 lab=_84552_/Q }
C {devices/lab_pin.sym} 112940 -38890 0 0 {name=p111832 lab=_60898_/X }
C {devices/lab_pin.sym} 113100 -38970 0 1 {name=p111833 lab=_84552_/D }
C {sky130_stdcells/o32a_4.sym} 113020 -38970 0 0 {name=X_60903_ }
C {devices/lab_pin.sym} 112940 -38830 0 0 {name=p111834 lab=_58653_/Y }
C {devices/lab_pin.sym} 112940 -38790 0 0 {name=p111835 lab=_66402_/C }
C {devices/lab_pin.sym} 112940 -38750 0 0 {name=p111836 lab=_79444_/Y }
C {devices/lab_pin.sym} 113100 -38790 0 1 {name=p111837 lab=_79449_/A }
C {sky130_stdcells/o21a_4.sym} 113020 -38790 0 0 {name=X_79445_ }
C {devices/lab_pin.sym} 112940 -38670 0 0 {name=p111838 lab=_45819_/X }
C {devices/lab_pin.sym} 112940 -38630 0 0 {name=p111839 lab=_61666_/A }
C {devices/lab_pin.sym} 112940 -38590 0 0 {name=p111840 lab=_45836_/X }
C {devices/lab_pin.sym} 113100 -38630 0 1 {name=p111841 lab=_45837_/Y }
C {sky130_stdcells/o21ai_4.sym} 113020 -38630 0 0 {name=X_45837_ }
C {devices/lab_pin.sym} 112940 -38520 0 0 {name=p111842 lab=_64615_/X }
C {devices/lab_pin.sym} 112940 -38480 0 0 {name=p111843 lab=_85534_/Q }
C {devices/lab_pin.sym} 112940 -38440 0 0 {name=p111844 lab=_64642_/X }
C {devices/lab_pin.sym} 112940 -38400 0 0 {name=p111845 lab=_64670_/X }
C {devices/lab_pin.sym} 113100 -38460 0 1 {name=p111846 lab=_64671_/X }
C {sky130_stdcells/a211o_4.sym} 113020 -38460 0 0 {name=X_64671_ }
C {devices/lab_pin.sym} 112980 -38310 0 0 {name=p111847 lab=_76656_/B }
C {devices/lab_pin.sym} 113060 -38310 0 1 {name=p111848 lab=_76657_/Y }
C {sky130_stdcells/inv_2.sym} 113020 -38310 0 0 {name=X_76657_ }
C {devices/lab_pin.sym} 112940 -38210 0 0 {name=p111849 lab=_61880_/Y }
C {devices/lab_pin.sym} 112940 -38170 0 0 {name=p111850 lab=_61881_/X }
C {devices/lab_pin.sym} 112940 -38130 0 0 {name=p111851 lab=_61882_/Y }
C {devices/lab_pin.sym} 113100 -38170 0 1 {name=p111852 lab=_61883_/Y }
C {sky130_stdcells/a21oi_4.sym} 113020 -38170 0 0 {name=X_61883_ }
C {devices/lab_pin.sym} 112980 -38030 0 0 {name=p111853 lab=_72852_/X }
C {devices/lab_pin.sym} 113060 -38030 0 1 {name=p111854 lab=_73869_/X }
C {sky130_stdcells/buf_2.sym} 113020 -38030 0 0 {name=X_73869_ }
C {devices/lab_pin.sym} 112980 -37910 0 0 {name=p111855 lab=_66410_/A }
C {devices/lab_pin.sym} 113060 -37910 0 1 {name=p111856 lab=_66411_/A }
C {sky130_stdcells/buf_2.sym} 113020 -37910 0 0 {name=X_66410_ }
C {devices/lab_pin.sym} 112960 -37810 0 0 {name=p111857 lab=_63615_/A }
C {devices/lab_pin.sym} 112960 -37770 0 0 {name=p111858 lab=_63615_/B }
C {devices/lab_pin.sym} 112960 -37730 0 0 {name=p111859 lab=_80400_/B }
C {devices/lab_pin.sym} 113080 -37770 0 1 {name=p111860 lab=_63622_/Y }
C {sky130_stdcells/nor3_4.sym} 113020 -37770 0 0 {name=X_63622_ }
C {devices/lab_pin.sym} 112960 -37640 0 0 {name=p111861 lab=_75607_/B }
C {devices/lab_pin.sym} 112960 -37600 0 0 {name=p111862 lab=_75891_/A }
C {devices/lab_pin.sym} 113080 -37620 0 1 {name=p111863 lab=_75608_/Y }
C {sky130_stdcells/nor2_4.sym} 113020 -37620 0 0 {name=X_75608_ }
C {devices/lab_pin.sym} 112980 -37490 0 0 {name=p111864 lab=_48801_/B }
C {devices/lab_pin.sym} 113060 -37490 0 1 {name=p111865 lab=_52188_/B }
C {sky130_stdcells/buf_2.sym} 113020 -37490 0 0 {name=X_48556_ }
C {devices/lab_pin.sym} 112980 -37370 0 0 {name=p111866 lab=_63426_/A }
C {devices/lab_pin.sym} 113060 -37370 0 1 {name=p111867 lab=_60834_/X }
C {sky130_stdcells/buf_2.sym} 113020 -37370 0 0 {name=X_60834_ }
C {devices/lab_pin.sym} 112980 -37250 0 0 {name=p111868 lab=_67863_/A }
C {devices/lab_pin.sym} 113060 -37250 0 1 {name=p111869 lab=_67390_/X }
C {sky130_stdcells/buf_2.sym} 113020 -37250 0 0 {name=X_67390_ }
C {devices/lab_pin.sym} 112960 -37140 0 0 {name=p111870 lab=_79365_/X }
C {devices/lab_pin.sym} 112960 -37100 0 0 {name=p111871 lab=_79354_/X }
C {devices/lab_pin.sym} 113080 -37120 0 1 {name=p111872 lab=_79376_/X }
C {sky130_stdcells/and2_4.sym} 113020 -37120 0 0 {name=X_79376_ }
C {devices/lab_pin.sym} 112980 -36990 0 0 {name=p111873 lab=_57039_/A }
C {devices/lab_pin.sym} 113060 -36990 0 1 {name=p111874 lab=_45768_/Y }
C {sky130_stdcells/inv_2.sym} 113020 -36990 0 0 {name=X_45768_ }
C {devices/lab_pin.sym} 112960 -36890 0 0 {name=p111875 lab=_76586_/X }
C {devices/lab_pin.sym} 112960 -36850 0 0 {name=p111876 lab=_76560_/Y }
C {devices/lab_pin.sym} 112960 -36810 0 0 {name=p111877 lab=_76587_/X }
C {devices/lab_pin.sym} 113080 -36850 0 1 {name=p111878 lab=_76588_/X }
C {sky130_stdcells/and3_4.sym} 113020 -36850 0 0 {name=X_76588_ }
C {devices/lab_pin.sym} 112960 -36720 0 0 {name=p111879 lab=_47517_/A }
C {devices/lab_pin.sym} 112960 -36680 0 0 {name=p111880 lab=_53086_/B }
C {devices/lab_pin.sym} 113080 -36700 0 1 {name=p111881 lab=_47507_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -36700 0 0 {name=X_47507_ }
C {devices/lab_pin.sym} 112960 -36590 0 0 {name=p111882 lab=_66338_/X }
C {devices/lab_pin.sym} 112960 -36550 0 0 {name=p111883 lab=_66385_/B }
C {devices/lab_pin.sym} 112960 -36510 0 0 {name=p111884 lab=_66340_/X }
C {devices/lab_pin.sym} 113080 -36550 0 1 {name=p111885 lab=_66341_/Y }
C {sky130_stdcells/nand3_4.sym} 113020 -36550 0 0 {name=X_66341_ }
C {devices/lab_pin.sym} 112960 -36420 0 0 {name=p111886 lab=_82499_/Q }
C {devices/lab_pin.sym} 112960 -36380 0 0 {name=p111887 lab=_82755_/D }
C {devices/lab_pin.sym} 113080 -36400 0 1 {name=p111888 lab=_82467_/D }
C {sky130_stdcells/xor2_4.sym} 113020 -36400 0 0 {name=X_78327_ }
C {devices/lab_pin.sym} 112980 -36270 0 0 {name=p111889 lab=_44719_/A }
C {devices/lab_pin.sym} 113060 -36270 0 1 {name=p111890 lab=_44719_/Y }
C {sky130_stdcells/inv_2.sym} 113020 -36270 0 0 {name=X_44719_ }
C {devices/lab_pin.sym} 112940 -36190 0 0 {name=p111891 lab=_63495_/X }
C {devices/lab_pin.sym} 112940 -36150 0 0 {name=p111892 lab=_63546_/X }
C {devices/lab_pin.sym} 112940 -36110 0 0 {name=p111893 lab=_63547_/X }
C {devices/lab_pin.sym} 112940 -36070 0 0 {name=p111894 lab=_63551_/X }
C {devices/lab_pin.sym} 112940 -36030 0 0 {name=p111895 lab=_63552_/Y }
C {devices/lab_pin.sym} 113100 -36110 0 1 {name=p111896 lab=_63553_/Y }
C {sky130_stdcells/o41ai_4.sym} 113020 -36110 0 0 {name=X_63553_ }
C {devices/lab_pin.sym} 112940 -35970 0 0 {name=p111897 lab=_75503_/Y }
C {devices/lab_pin.sym} 112940 -35930 0 0 {name=p111898 lab=_75524_/Y }
C {devices/lab_pin.sym} 112940 -35890 0 0 {name=p111899 lab=_75523_/X }
C {devices/lab_pin.sym} 113100 -35930 0 1 {name=p111900 lab=_75539_/X }
C {sky130_stdcells/a21bo_4.sym} 113020 -35930 0 0 {name=X_75539_ }
C {devices/lab_pin.sym} 112960 -35800 0 0 {name=p111901 lab=_60714_/Y }
C {devices/lab_pin.sym} 112960 -35760 0 0 {name=p111902 lab=_60671_/C }
C {devices/lab_pin.sym} 113080 -35780 0 1 {name=p111903 lab=_60765_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -35780 0 0 {name=X_60765_ }
C {devices/lab_pin.sym} 112980 -35650 0 0 {name=p111904 lab=_48487_/A }
C {devices/lab_pin.sym} 113060 -35650 0 1 {name=p111905 lab=_52156_/A }
C {sky130_stdcells/buf_2.sym} 113020 -35650 0 0 {name=X_48487_ }
C {devices/lab_pin.sym} 112980 -35530 0 0 {name=p111906 lab=_63227_/B }
C {devices/lab_pin.sym} 113060 -35530 0 1 {name=p111907 lab=_61561_/A }
C {sky130_stdcells/buf_2.sym} 113020 -35530 0 0 {name=X_45699_ }
C {devices/lab_pin.sym} 112980 -35410 0 0 {name=p111908 lab=_62504_/A }
C {devices/lab_pin.sym} 113060 -35410 0 1 {name=p111909 lab=_62504_/X }
C {sky130_stdcells/buf_2.sym} 113020 -35410 0 0 {name=X_62504_ }
C {devices/lab_pin.sym} 112940 -35320 0 0 {name=p111910 lab=_86979_/Q }
C {devices/lab_pin.sym} 112940 -35280 0 0 {name=p111911 lab=_69058_/X }
C {devices/lab_pin.sym} 112940 -35240 0 0 {name=p111912 lab=_68993_/X }
C {devices/lab_pin.sym} 112940 -35200 0 0 {name=p111913 lab=_69059_/X }
C {devices/lab_pin.sym} 113100 -35260 0 1 {name=p111914 lab=_69060_/X }
C {sky130_stdcells/a211o_4.sym} 113020 -35260 0 0 {name=X_69060_ }
C {devices/lab_pin.sym} 112980 -35110 0 0 {name=p111915 lab=_81803_/Q }
C {devices/lab_pin.sym} 113060 -35110 0 1 {name=p111916 lab=_54739_/D }
C {sky130_stdcells/inv_2.sym} 113020 -35110 0 0 {name=X_47438_ }
C {devices/lab_pin.sym} 112940 -35010 0 0 {name=p111917 lab=_66269_/X }
C {devices/lab_pin.sym} 112940 -34970 0 0 {name=p111918 lab=_66271_/X }
C {devices/lab_pin.sym} 112940 -34930 0 0 {name=p111919 lab=_66240_/X }
C {devices/lab_pin.sym} 113100 -34970 0 1 {name=p111920 lab=_66272_/X }
C {sky130_stdcells/a21o_4.sym} 113020 -34970 0 0 {name=X_66272_ }
C {devices/lab_pin.sym} 112960 -34840 0 0 {name=p111921 lab=_78265_/A }
C {devices/lab_pin.sym} 112960 -34800 0 0 {name=p111922 lab=_82467_/Q }
C {devices/lab_pin.sym} 113080 -34820 0 1 {name=p111923 lab=_78263_/A }
C {sky130_stdcells/xor2_4.sym} 113020 -34820 0 0 {name=X_78258_ }
C {devices/lab_pin.sym} 112980 -34690 0 0 {name=p111924 lab=_63484_/A }
C {devices/lab_pin.sym} 113060 -34690 0 1 {name=p111925 lab=_63496_/A }
C {sky130_stdcells/buf_2.sym} 113020 -34690 0 0 {name=X_63484_ }
C {devices/lab_pin.sym} 112960 -34590 0 0 {name=p111926 lab=_60724_/A }
C {devices/lab_pin.sym} 112960 -34550 0 0 {name=p111927 lab=_60624_/X }
C {devices/lab_pin.sym} 112960 -34510 0 0 {name=p111928 lab=_60659_/A }
C {devices/lab_pin.sym} 113080 -34550 0 1 {name=p111929 lab=_60696_/Y }
C {sky130_stdcells/nand3_4.sym} 113020 -34550 0 0 {name=X_60696_ }
C {devices/lab_pin.sym} 112940 -34430 0 0 {name=p111930 lab=_68008_/X }
C {devices/lab_pin.sym} 112940 -34390 0 0 {name=p111931 lab=_68010_/X }
C {devices/lab_pin.sym} 112940 -34350 0 0 {name=p111932 lab=_67917_/X }
C {devices/lab_pin.sym} 113100 -34390 0 1 {name=p111933 lab=_68011_/X }
C {sky130_stdcells/a21o_4.sym} 113020 -34390 0 0 {name=X_68011_ }
C {devices/lab_pin.sym} 112980 -34250 0 0 {name=p111934 lab=_64565_/A }
C {devices/lab_pin.sym} 113060 -34250 0 1 {name=p111935 lab=_65400_/A }
C {sky130_stdcells/buf_2.sym} 113020 -34250 0 0 {name=X_65223_ }
C {devices/lab_pin.sym} 112960 -34140 0 0 {name=p111936 lab=_77217_/A }
C {devices/lab_pin.sym} 112960 -34100 0 0 {name=p111937 lab=_77217_/B }
C {devices/lab_pin.sym} 113080 -34120 0 1 {name=p111938 lab=_77213_/A }
C {sky130_stdcells/xnor2_4.sym} 113020 -34120 0 0 {name=X_77209_ }
C {devices/lab_pin.sym} 112960 -34020 0 0 {name=p111939 lab=_62406_/A }
C {devices/lab_pin.sym} 112960 -33980 0 0 {name=p111940 lab=_62435_/B }
C {devices/lab_pin.sym} 112960 -33940 0 0 {name=p111941 lab=_62432_/Y }
C {devices/lab_pin.sym} 112960 -33900 0 0 {name=p111942 lab=_62435_/D }
C {devices/lab_pin.sym} 113080 -33960 0 1 {name=p111943 lab=_62435_/Y }
C {sky130_stdcells/nand4_4.sym} 113020 -33960 0 0 {name=X_62435_ }
C {devices/lab_pin.sym} 112980 -33810 0 0 {name=p111944 lab=_47369_/A }
C {devices/lab_pin.sym} 113060 -33810 0 1 {name=p111945 lab=_53008_/D }
C {sky130_stdcells/buf_2.sym} 113020 -33810 0 0 {name=X_47369_ }
C {devices/lab_pin.sym} 112960 -33700 0 0 {name=p111946 lab=_82673_/Q }
C {devices/lab_pin.sym} 112960 -33660 0 0 {name=p111947 lab=_78189_/B }
C {devices/lab_pin.sym} 113080 -33680 0 1 {name=p111948 lab=_78189_/X }
C {sky130_stdcells/xor2_4.sym} 113020 -33680 0 0 {name=X_78189_ }
C {devices/lab_pin.sym} 112960 -33560 0 0 {name=p111949 lab=_49117_/A }
C {devices/lab_pin.sym} 112960 -33520 0 0 {name=p111950 lab=_50674_/B }
C {devices/lab_pin.sym} 113080 -33540 0 1 {name=p111951 lab=_49108_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -33540 0 0 {name=X_49108_ }
C {devices/lab_pin.sym} 112960 -33420 0 0 {name=p111952 lab=_80197_/Y }
C {devices/lab_pin.sym} 112960 -33380 0 0 {name=p111953 lab=_80220_/B }
C {devices/lab_pin.sym} 113080 -33400 0 1 {name=p111954 lab=_80221_/A }
C {sky130_stdcells/nor2_4.sym} 113020 -33400 0 0 {name=X_80220_ }
C {devices/lab_pin.sym} 112960 -33280 0 0 {name=p111955 lab=_65154_/A }
C {devices/lab_pin.sym} 112960 -33240 0 0 {name=p111956 lab=_65153_/X }
C {devices/lab_pin.sym} 113080 -33260 0 1 {name=p111957 lab=_65154_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -33260 0 0 {name=X_65154_ }
C {devices/lab_pin.sym} 112980 -33130 0 0 {name=p111958 lab=_50227_/A }
C {devices/lab_pin.sym} 113060 -33130 0 1 {name=p111959 lab=_50380_/X }
C {sky130_stdcells/buf_2.sym} 113020 -33130 0 0 {name=X_50380_ }
C {devices/lab_pin.sym} 112940 -33050 0 0 {name=p111960 lab=_61447_/B }
C {devices/lab_pin.sym} 112940 -33010 0 0 {name=p111961 lab=_62278_/X }
C {devices/lab_pin.sym} 112940 -32970 0 0 {name=p111962 lab=_62363_/X }
C {devices/lab_pin.sym} 112940 -32930 0 0 {name=p111963 lab=_62323_/X }
C {devices/lab_pin.sym} 112940 -32900 0 0 {name=p111964 lab=_62365_/X }
C {devices/lab_pin.sym} 113100 -32970 0 1 {name=p111965 lab=_62366_/X }
C {sky130_stdcells/a41o_4.sym} 113020 -32970 0 0 {name=X_62366_ }
C {devices/lab_pin.sym} 112940 -32830 0 0 {name=p111966 lab=_61611_/A }
C {devices/lab_pin.sym} 112940 -32790 0 0 {name=p111967 lab=_60967_/X }
C {devices/lab_pin.sym} 112940 -32750 0 0 {name=p111968 lab=_64104_/Y }
C {devices/lab_pin.sym} 113100 -32790 0 1 {name=p111969 lab=_64105_/X }
C {sky130_stdcells/a21bo_4.sym} 113020 -32790 0 0 {name=X_64105_ }
C {devices/lab_pin.sym} 112960 -32660 0 0 {name=p111970 lab=_49039_/A }
C {devices/lab_pin.sym} 112960 -32620 0 0 {name=p111971 lab=_49029_/B }
C {devices/lab_pin.sym} 113080 -32640 0 1 {name=p111972 lab=_49039_/Y }
C {sky130_stdcells/nor2_4.sym} 113020 -32640 0 0 {name=X_49039_ }
C {devices/lab_pin.sym} 112940 -32530 0 0 {name=p111973 lab=_80143_/X }
C {devices/lab_pin.sym} 112940 -32490 0 0 {name=p111974 lab=_80144_/X }
C {devices/lab_pin.sym} 112940 -32450 0 0 {name=p111975 lab=_80150_/Y }
C {devices/lab_pin.sym} 113100 -32490 0 1 {name=p111976 lab=_80151_/Y }
C {sky130_stdcells/a21boi_4.sym} 113020 -32490 0 0 {name=X_80151_ }
C {devices/lab_pin.sym} 112980 -32350 0 0 {name=p111977 lab=_61317_/A }
C {devices/lab_pin.sym} 113060 -32350 0 1 {name=p111978 lab=_61317_/X }
C {sky130_stdcells/buf_2.sym} 113020 -32350 0 0 {name=X_61317_ }
C {devices/lab_pin.sym} 112940 -32260 0 0 {name=p111979 lab=_65059_/X }
C {devices/lab_pin.sym} 112940 -32220 0 0 {name=p111980 lab=_85551_/Q }
C {devices/lab_pin.sym} 112940 -32180 0 0 {name=p111981 lab=_65060_/X }
C {devices/lab_pin.sym} 112940 -32140 0 0 {name=p111982 lab=_65084_/X }
C {devices/lab_pin.sym} 113100 -32200 0 1 {name=p111983 lab=_65085_/X }
C {sky130_stdcells/a211o_4.sym} 113020 -32200 0 0 {name=X_65085_ }
C {devices/lab_pin.sym} 112940 -32080 0 0 {name=p111984 lab=_87041_/Q }
C {devices/lab_pin.sym} 112940 -32040 0 0 {name=p111985 lab=_44181_/X }
C {devices/lab_pin.sym} 112940 -32000 0 0 {name=p111986 lab=_64600_/A }
C {devices/lab_pin.sym} 112940 -31960 0 0 {name=p111987 lab=_69961_/X }
C {devices/lab_pin.sym} 113100 -32020 0 1 {name=p111988 lab=_69962_/X }
C {sky130_stdcells/a211o_4.sym} 113020 -32020 0 0 {name=X_69962_ }
C {devices/lab_pin.sym} 112980 -31870 0 0 {name=p111989 lab=_62522_/B }
C {devices/lab_pin.sym} 113060 -31870 0 1 {name=p111990 lab=_62309_/C }
C {sky130_stdcells/buf_2.sym} 113020 -31870 0 0 {name=X_62297_ }
C {devices/lab_pin.sym} 112960 -31770 0 0 {name=p111991 lab=_52050_/A }
C {devices/lab_pin.sym} 112960 -31730 0 0 {name=p111992 lab=_52098_/B }
C {devices/lab_pin.sym} 112960 -31690 0 0 {name=p111993 lab=_52033_/X }
C {devices/lab_pin.sym} 113080 -31730 0 1 {name=p111994 lab=_52050_/X }
C {sky130_stdcells/and3_4.sym} 113020 -31730 0 0 {name=X_52050_ }
C {devices/lab_pin.sym} 112940 -31630 0 0 {name=p111995 lab=_64031_/X }
C {devices/lab_pin.sym} 112940 -31590 0 0 {name=p111996 lab=_63969_/X }
C {devices/lab_pin.sym} 112940 -31550 0 0 {name=p111997 lab=_64033_/Y }
C {devices/lab_pin.sym} 112940 -31510 0 0 {name=p111998 lab=_64034_/Y }
C {devices/lab_pin.sym} 112940 -31480 0 0 {name=p111999 lab=_64035_/X }
C {devices/lab_pin.sym} 113100 -31550 0 1 {name=p112000 lab=_64036_/X }
C {sky130_stdcells/a41o_4.sym} 113020 -31550 0 0 {name=X_64036_ }
C {devices/lab_pin.sym} 112960 -31400 0 0 {name=p112001 lab=_69004_/A }
C {devices/lab_pin.sym} 112960 -31360 0 0 {name=p112002 lab=_88349_/Q }
C {devices/lab_pin.sym} 113080 -31380 0 1 {name=p112003 lab=_68913_/X }
C {sky130_stdcells/and2_4.sym} 113020 -31380 0 0 {name=X_68913_ }
C {devices/lab_pin.sym} 112980 -31250 0 0 {name=p112004 lab=_63053_/A }
C {devices/lab_pin.sym} 113060 -31250 0 1 {name=p112005 lab=_63004_/B }
C {sky130_stdcells/buf_2.sym} 113020 -31250 0 0 {name=X_61248_ }
C {devices/lab_pin.sym} 112960 -31140 0 0 {name=p112006 lab=_80082_/A }
C {devices/lab_pin.sym} 112960 -31100 0 0 {name=p112007 lab=_80082_/B }
C {devices/lab_pin.sym} 113080 -31120 0 1 {name=p112008 lab=_80088_/B }
C {sky130_stdcells/xor2_4.sym} 113020 -31120 0 0 {name=X_80082_ }
C {devices/lab_pin.sym} 112940 -31010 0 0 {name=p112009 lab=_83889_/Q }
C {devices/lab_pin.sym} 112940 -30970 0 0 {name=p112010 lab=_69831_/X }
C {devices/lab_pin.sym} 112940 -30930 0 0 {name=p112011 lab=_69892_/X }
C {devices/lab_pin.sym} 113100 -30970 0 1 {name=p112012 lab=_83889_/D }
C {sky130_stdcells/a21bo_4.sym} 113020 -30970 0 0 {name=X_69893_ }
C {devices/lab_pin.sym} 112960 -30860 0 0 {name=p112013 lab=_51018_/A }
C {devices/lab_pin.sym} 112960 -30820 0 0 {name=p112014 lab=_50985_/B }
C {devices/lab_pin.sym} 112960 -30780 0 0 {name=p112015 lab=_50985_/C }
C {devices/lab_pin.sym} 112960 -30740 0 0 {name=p112016 lab=_52694_/D }
C {devices/lab_pin.sym} 113080 -30800 0 1 {name=p112017 lab=_51001_/X }
C {sky130_stdcells/and4_4.sym} 113020 -30800 0 0 {name=X_51001_ }
C {devices/lab_pin.sym} 112930 -30650 0 0 {name=p112018 lab=_83906_/CLK }
C {devices/lab_pin.sym} 112930 -30630 0 0 {name=p112019 lab=_69616_/X }
C {devices/lab_pin.sym} 113110 -30650 0 1 {name=p112020 lab=_83910_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -30640 0 0 {name=X_83910_ }
C {devices/lab_pin.sym} 112960 -30520 0 0 {name=p112021 lab=_69004_/A }
C {devices/lab_pin.sym} 112960 -30480 0 0 {name=p112022 lab=_88352_/Q }
C {devices/lab_pin.sym} 113080 -30500 0 1 {name=p112023 lab=_68844_/X }
C {sky130_stdcells/and2_4.sym} 113020 -30500 0 0 {name=X_68844_ }
C {devices/lab_pin.sym} 112960 -30380 0 0 {name=p112024 lab=_61179_/A }
C {devices/lab_pin.sym} 112960 -30340 0 0 {name=p112025 lab=_61120_/Y }
C {devices/lab_pin.sym} 113080 -30360 0 1 {name=p112026 lab=_61180_/A }
C {sky130_stdcells/nor2_4.sym} 113020 -30360 0 0 {name=X_61179_ }
C {devices/lab_pin.sym} 112930 -30230 0 0 {name=p112027 lab=_84921_/CLK }
C {devices/lab_pin.sym} 112930 -30210 0 0 {name=p112028 lab=_84890_/D }
C {devices/lab_pin.sym} 113110 -30230 0 1 {name=p112029 lab=_84890_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -30220 0 0 {name=X_84890_ }
C {devices/lab_pin.sym} 112930 -30090 0 0 {name=p112030 lab=_83835_/CLK }
C {devices/lab_pin.sym} 112930 -30070 0 0 {name=p112031 lab=_70197_/X }
C {devices/lab_pin.sym} 113110 -30090 0 1 {name=p112032 lab=_83841_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -30080 0 0 {name=X_83841_ }
C {devices/lab_pin.sym} 112960 -29960 0 0 {name=p112033 lab=_68938_/A }
C {devices/lab_pin.sym} 112960 -29920 0 0 {name=p112034 lab=_68775_/B }
C {devices/lab_pin.sym} 113080 -29940 0 1 {name=p112035 lab=_68775_/X }
C {sky130_stdcells/and2_4.sym} 113020 -29940 0 0 {name=X_68775_ }
C {devices/lab_pin.sym} 112980 -29810 0 0 {name=p112036 lab=_65757_/A }
C {devices/lab_pin.sym} 113060 -29810 0 1 {name=p112037 lab=_65987_/X }
C {sky130_stdcells/buf_2.sym} 113020 -29810 0 0 {name=X_65987_ }
C {devices/lab_pin.sym} 112960 -29700 0 0 {name=p112038 lab=_55737_/X }
C {devices/lab_pin.sym} 112960 -29660 0 0 {name=p112039 lab=_55739_/X }
C {devices/lab_pin.sym} 113080 -29680 0 1 {name=p112040 lab=_55740_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -29680 0 0 {name=X_55740_ }
C {devices/lab_pin.sym} 112960 -29560 0 0 {name=p112041 lab=_67726_/A }
C {devices/lab_pin.sym} 112960 -29520 0 0 {name=p112042 lab=_67725_/X }
C {devices/lab_pin.sym} 113080 -29540 0 1 {name=p112043 lab=_67726_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -29540 0 0 {name=X_67726_ }
C {devices/lab_pin.sym} 112930 -29410 0 0 {name=p112044 lab=_86560_/CLK }
C {devices/lab_pin.sym} 112930 -29390 0 0 {name=p112045 lab=_48180_/Y }
C {devices/lab_pin.sym} 113110 -29410 0 1 {name=p112046 lab=_73588_/B }
C {sky130_stdcells/dfxtp_4.sym} 113020 -29400 0 0 {name=X_86560_ }
C {devices/lab_pin.sym} 112980 -29270 0 0 {name=p112047 lab=_53221_/A }
C {devices/lab_pin.sym} 113060 -29270 0 1 {name=p112048 lab=_53062_/A }
C {sky130_stdcells/buf_2.sym} 113020 -29270 0 0 {name=X_52952_ }
C {devices/lab_pin.sym} 112940 -29170 0 0 {name=p112049 lab=_64915_/X }
C {devices/lab_pin.sym} 112940 -29130 0 0 {name=p112050 lab=_64926_/Y }
C {devices/lab_pin.sym} 112940 -29090 0 0 {name=p112051 lab=_64937_/Y }
C {devices/lab_pin.sym} 113100 -29130 0 1 {name=p112052 lab=_64938_/Y }
C {sky130_stdcells/o21ai_4.sym} 113020 -29130 0 0 {name=X_64938_ }
C {devices/lab_pin.sym} 112930 -28990 0 0 {name=p112053 lab=_86578_/CLK }
C {devices/lab_pin.sym} 112930 -28970 0 0 {name=p112054 lab=_70446_/Y }
C {devices/lab_pin.sym} 113110 -28990 0 1 {name=p112055 lab=_83772_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -28980 0 0 {name=X_83772_ }
C {devices/lab_pin.sym} 112930 -28850 0 0 {name=p112056 lab=_80813_/CLK }
C {devices/lab_pin.sym} 112930 -28830 0 0 {name=p112057 lab=_80984_/D }
C {devices/lab_pin.sym} 113110 -28850 0 1 {name=p112058 lab=_80984_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -28840 0 0 {name=X_80984_ }
C {devices/lab_pin.sym} 112930 -28710 0 0 {name=p112059 lab=_85507_/CLK }
C {devices/lab_pin.sym} 112930 -28690 0 0 {name=p112060 lab=_54072_/Y }
C {devices/lab_pin.sym} 113110 -28710 0 1 {name=p112061 lab=_85511_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -28700 0 0 {name=X_85511_ }
C {devices/lab_pin.sym} 112940 -28590 0 0 {name=p112062 lab=_85925_/Q }
C {devices/lab_pin.sym} 112940 -28550 0 0 {name=p112063 lab=_51900_/X }
C {devices/lab_pin.sym} 112940 -28510 0 0 {name=p112064 lab=_51902_/Y }
C {devices/lab_pin.sym} 113100 -28550 0 1 {name=p112065 lab=_51903_/Y }
C {sky130_stdcells/o21ai_4.sym} 113020 -28550 0 0 {name=X_51903_ }
C {devices/lab_pin.sym} 112930 -28410 0 0 {name=p112066 lab=_84119_/CLK }
C {devices/lab_pin.sym} 112930 -28390 0 0 {name=p112067 lab=_82723_/D }
C {devices/lab_pin.sym} 113110 -28410 0 1 {name=p112068 lab=_82723_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -28400 0 0 {name=X_82723_ }
C {devices/lab_pin.sym} 112980 -28270 0 0 {name=p112069 lab=_55671_/A }
C {devices/lab_pin.sym} 113060 -28270 0 1 {name=p112070 lab=_55671_/Y }
C {sky130_stdcells/inv_2.sym} 113020 -28270 0 0 {name=X_55671_ }
C {devices/lab_pin.sym} 112980 -28150 0 0 {name=p112071 lab=_64584_/X }
C {devices/lab_pin.sym} 113060 -28150 0 1 {name=p112072 lab=_67657_/X }
C {sky130_stdcells/buf_2.sym} 113020 -28150 0 0 {name=X_67657_ }
C {devices/lab_pin.sym} 112930 -28030 0 0 {name=p112073 lab=_86490_/CLK }
C {devices/lab_pin.sym} 112930 -28010 0 0 {name=p112074 lab=_86491_/D }
C {devices/lab_pin.sym} 113110 -28030 0 1 {name=p112075 lab=_65521_/B }
C {sky130_stdcells/dfxtp_4.sym} 113020 -28020 0 0 {name=X_86491_ }
C {devices/lab_pin.sym} 112960 -27920 0 0 {name=p112076 lab=_52867_/A }
C {devices/lab_pin.sym} 112960 -27880 0 0 {name=p112077 lab=_52879_/B }
C {devices/lab_pin.sym} 112960 -27840 0 0 {name=p112078 lab=_52872_/C }
C {devices/lab_pin.sym} 112960 -27800 0 0 {name=p112079 lab=_51192_/D }
C {devices/lab_pin.sym} 113080 -27860 0 1 {name=p112080 lab=_52883_/X }
C {sky130_stdcells/and4_4.sym} 113020 -27860 0 0 {name=X_52883_ }
C {devices/lab_pin.sym} 112980 -27710 0 0 {name=p112081 lab=_84224_/Q }
C {devices/lab_pin.sym} 113060 -27710 0 1 {name=p112082 lab=_64870_/C }
C {sky130_stdcells/inv_2.sym} 113020 -27710 0 0 {name=X_64869_ }
C {devices/lab_pin.sym} 112940 -27610 0 0 {name=p112083 lab=_57650_/A }
C {devices/lab_pin.sym} 112940 -27570 0 0 {name=p112084 lab=_56672_/Y }
C {devices/lab_pin.sym} 112940 -27530 0 0 {name=p112085 lab=_57409_/Y }
C {devices/lab_pin.sym} 113100 -27570 0 1 {name=p112086 lab=_57410_/Y }
C {sky130_stdcells/a21oi_4.sym} 113020 -27570 0 0 {name=X_57410_ }
C {devices/lab_pin.sym} 112930 -27430 0 0 {name=p112087 lab=_86965_/CLK }
C {devices/lab_pin.sym} 112930 -27410 0 0 {name=p112088 lab=_88230_/D }
C {devices/lab_pin.sym} 113110 -27430 0 1 {name=p112089 lab=_67647_/B }
C {sky130_stdcells/dfxtp_4.sym} 113020 -27420 0 0 {name=X_88230_ }
C {devices/lab_pin.sym} 112980 -27290 0 0 {name=p112090 lab=_54594_/X }
C {devices/lab_pin.sym} 113060 -27290 0 1 {name=p112091 lab=_54636_/A }
C {sky130_stdcells/buf_2.sym} 113020 -27290 0 0 {name=X_54622_ }
C {devices/lab_pin.sym} 112980 -27170 0 0 {name=p112092 lab=_66608_/A }
C {devices/lab_pin.sym} 113060 -27170 0 1 {name=p112093 lab=_66608_/X }
C {sky130_stdcells/buf_2.sym} 113020 -27170 0 0 {name=X_66608_ }
C {devices/lab_pin.sym} 112930 -27050 0 0 {name=p112094 lab=_85764_/CLK }
C {devices/lab_pin.sym} 112930 -27030 0 0 {name=p112095 lab=_85442_/D }
C {devices/lab_pin.sym} 113110 -27050 0 1 {name=p112096 lab=_85442_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -27040 0 0 {name=X_85442_ }
C {devices/lab_pin.sym} 112940 -26930 0 0 {name=p112097 lab=_51831_/Y }
C {devices/lab_pin.sym} 112940 -26890 0 0 {name=p112098 lab=_51823_/X }
C {devices/lab_pin.sym} 112940 -26850 0 0 {name=p112099 lab=_51833_/X }
C {devices/lab_pin.sym} 113100 -26890 0 1 {name=p112100 lab=_51834_/Y }
C {sky130_stdcells/a21oi_4.sym} 113020 -26890 0 0 {name=X_51834_ }
C {devices/lab_pin.sym} 112980 -26750 0 0 {name=p112101 lab=_58408_/A }
C {devices/lab_pin.sym} 113060 -26750 0 1 {name=p112102 lab=_58403_/B }
C {sky130_stdcells/buf_2.sym} 113020 -26750 0 0 {name=X_58390_ }
C {devices/lab_pin.sym} 112930 -26630 0 0 {name=p112103 lab=_81755_/CLK }
C {devices/lab_pin.sym} 112930 -26610 0 0 {name=p112104 lab=_84006_/Q }
C {devices/lab_pin.sym} 113110 -26630 0 1 {name=p112105 lab=_82654_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -26620 0 0 {name=X_82654_ }
C {devices/lab_pin.sym} 112940 -26510 0 0 {name=p112106 lab=_67584_/X }
C {devices/lab_pin.sym} 112940 -26470 0 0 {name=p112107 lab=_67587_/X }
C {devices/lab_pin.sym} 112940 -26430 0 0 {name=p112108 lab=_67401_/X }
C {devices/lab_pin.sym} 113100 -26470 0 1 {name=p112109 lab=_67588_/Y }
C {sky130_stdcells/a21oi_4.sym} 113020 -26470 0 0 {name=X_67588_ }
C {devices/lab_pin.sym} 112960 -26340 0 0 {name=p112110 lab=_56846_/Y }
C {devices/lab_pin.sym} 112960 -26300 0 0 {name=p112111 lab=_57340_/C }
C {devices/lab_pin.sym} 113080 -26320 0 1 {name=p112112 lab=_57341_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -26320 0 0 {name=X_57341_ }
C {devices/lab_pin.sym} 112930 -26190 0 0 {name=p112113 lab=_81250_/CLK }
C {devices/lab_pin.sym} 112930 -26170 0 0 {name=p112114 lab=_76198_/Y }
C {devices/lab_pin.sym} 113110 -26190 0 1 {name=p112115 lab=_81605_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -26180 0 0 {name=X_81605_ }
C {devices/lab_pin.sym} 112940 -26080 0 0 {name=p112116 lab=_69300_/X }
C {devices/lab_pin.sym} 112940 -26040 0 0 {name=p112117 lab=_69324_/Y }
C {devices/lab_pin.sym} 112940 -26000 0 0 {name=p112118 lab=_69325_/X }
C {devices/lab_pin.sym} 112940 -25960 0 0 {name=p112119 lab=_69326_/Y }
C {devices/lab_pin.sym} 113100 -26020 0 1 {name=p112120 lab=_69327_/X }
C {sky130_stdcells/a211o_4.sym} 113020 -26020 0 0 {name=X_69327_ }
C {devices/lab_pin.sym} 112930 -25870 0 0 {name=p112121 lab=_88158_/CLK }
C {devices/lab_pin.sym} 112930 -25850 0 0 {name=p112122 lab=_88161_/D }
C {devices/lab_pin.sym} 113110 -25870 0 1 {name=p112123 lab=_88161_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -25860 0 0 {name=X_88161_ }
C {devices/lab_pin.sym} 112960 -25760 0 0 {name=p112124 lab=_54538_/A }
C {devices/lab_pin.sym} 112960 -25720 0 0 {name=p112125 lab=_54559_/B }
C {devices/lab_pin.sym} 112960 -25680 0 0 {name=p112126 lab=_54538_/C }
C {devices/lab_pin.sym} 112960 -25640 0 0 {name=p112127 lab=_54553_/D }
C {devices/lab_pin.sym} 113080 -25700 0 1 {name=p112128 lab=_54553_/X }
C {sky130_stdcells/and4_4.sym} 113020 -25700 0 0 {name=X_54553_ }
C {devices/lab_pin.sym} 112980 -25550 0 0 {name=p112129 lab=_68347_/A }
C {devices/lab_pin.sym} 113060 -25550 0 1 {name=p112130 lab=_66540_/A }
C {sky130_stdcells/buf_2.sym} 113020 -25550 0 0 {name=X_66539_ }
C {devices/lab_pin.sym} 112930 -25430 0 0 {name=p112131 lab=_83707_/CLK }
C {devices/lab_pin.sym} 112930 -25410 0 0 {name=p112132 lab=_85373_/D }
C {devices/lab_pin.sym} 113110 -25430 0 1 {name=p112133 lab=_85373_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -25420 0 0 {name=X_85373_ }
C {devices/lab_pin.sym} 112960 -25300 0 0 {name=p112134 lab=_51779_/A }
C {devices/lab_pin.sym} 112960 -25260 0 0 {name=p112135 lab=_51765_/B }
C {devices/lab_pin.sym} 113080 -25280 0 1 {name=p112136 lab=_51765_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -25280 0 0 {name=X_51765_ }
C {devices/lab_pin.sym} 112930 -25150 0 0 {name=p112137 lab=_82589_/CLK }
C {devices/lab_pin.sym} 112930 -25130 0 0 {name=p112138 lab=_82617_/Q }
C {devices/lab_pin.sym} 113110 -25150 0 1 {name=p112139 lab=_78241_/A }
C {sky130_stdcells/dfxtp_4.sym} 113020 -25140 0 0 {name=X_82585_ }
C {devices/lab_pin.sym} 112930 -25010 0 0 {name=p112140 lab=_87110_/CLK }
C {devices/lab_pin.sym} 112930 -24990 0 0 {name=p112141 lab=_44433_/X }
C {devices/lab_pin.sym} 113110 -25010 0 1 {name=p112142 lab=_87112_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -25000 0 0 {name=X_87112_ }
C {devices/lab_pin.sym} 112960 -24880 0 0 {name=p112143 lab=_53503_/X }
C {devices/lab_pin.sym} 112960 -24840 0 0 {name=p112144 lab=_53504_/B }
C {devices/lab_pin.sym} 113080 -24860 0 1 {name=p112145 lab=_53504_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -24860 0 0 {name=X_53504_ }
C {devices/lab_pin.sym} 112930 -24730 0 0 {name=p112146 lab=_84321_/CLK }
C {devices/lab_pin.sym} 112930 -24710 0 0 {name=p112147 lab=_63433_/Y }
C {devices/lab_pin.sym} 113110 -24730 0 1 {name=p112148 lab=_80568_/B }
C {sky130_stdcells/dfxtp_4.sym} 113020 -24720 0 0 {name=X_84324_ }
C {devices/lab_pin.sym} 112960 -24600 0 0 {name=p112149 lab=_50738_/A }
C {devices/lab_pin.sym} 112960 -24560 0 0 {name=p112150 lab=_50716_/B }
C {devices/lab_pin.sym} 113080 -24580 0 1 {name=p112151 lab=_50716_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -24580 0 0 {name=X_50716_ }
C {devices/lab_pin.sym} 112930 -24450 0 0 {name=p112152 lab=_81475_/CLK }
C {devices/lab_pin.sym} 112930 -24430 0 0 {name=p112153 lab=_81548_/Q }
C {devices/lab_pin.sym} 113110 -24450 0 1 {name=p112154 lab=_76142_/A }
C {sky130_stdcells/dfxtp_4.sym} 113020 -24440 0 0 {name=X_81536_ }
C {devices/lab_pin.sym} 112960 -24340 0 0 {name=p112155 lab=_56729_/X }
C {devices/lab_pin.sym} 112960 -24300 0 0 {name=p112156 lab=_57023_/A }
C {devices/lab_pin.sym} 112960 -24260 0 0 {name=p112157 lab=_56674_/X }
C {devices/lab_pin.sym} 112960 -24220 0 0 {name=p112158 lab=_57272_/D }
C {devices/lab_pin.sym} 113080 -24280 0 1 {name=p112159 lab=_57273_/B }
C {sky130_stdcells/and4_4.sym} 113020 -24280 0 0 {name=X_57272_ }
C {devices/lab_pin.sym} 112940 -24150 0 0 {name=p112160 lab=_83937_/Q }
C {devices/lab_pin.sym} 112940 -24110 0 0 {name=p112161 lab=_69230_/X }
C {devices/lab_pin.sym} 112940 -24070 0 0 {name=p112162 lab=_69257_/X }
C {devices/lab_pin.sym} 113100 -24110 0 1 {name=p112163 lab=_69258_/X }
C {sky130_stdcells/a21bo_4.sym} 113020 -24110 0 0 {name=X_69258_ }
C {devices/lab_pin.sym} 112930 -23970 0 0 {name=p112164 lab=_87834_/CLK }
C {devices/lab_pin.sym} 112930 -23950 0 0 {name=p112165 lab=_88092_/D }
C {devices/lab_pin.sym} 113110 -23970 0 1 {name=p112166 lab=_74095_/A }
C {sky130_stdcells/dfxtp_4.sym} 113020 -23960 0 0 {name=X_88092_ }
C {devices/lab_pin.sym} 112940 -23850 0 0 {name=p112167 lab=_54479_/Y }
C {devices/lab_pin.sym} 112940 -23810 0 0 {name=p112168 lab=_54475_/X }
C {devices/lab_pin.sym} 112940 -23770 0 0 {name=p112169 lab=_54483_/X }
C {devices/lab_pin.sym} 113100 -23810 0 1 {name=p112170 lab=_54484_/Y }
C {sky130_stdcells/a21oi_4.sym} 113020 -23810 0 0 {name=X_54484_ }
C {devices/lab_pin.sym} 112940 -23690 0 0 {name=p112171 lab=_51692_/Y }
C {devices/lab_pin.sym} 112940 -23650 0 0 {name=p112172 lab=_51693_/X }
C {devices/lab_pin.sym} 112940 -23610 0 0 {name=p112173 lab=_51695_/X }
C {devices/lab_pin.sym} 113100 -23650 0 1 {name=p112174 lab=_85963_/D }
C {sky130_stdcells/a21oi_4.sym} 113020 -23650 0 0 {name=X_51696_ }
C {devices/lab_pin.sym} 112940 -23530 0 0 {name=p112175 lab=_58961_/X }
C {devices/lab_pin.sym} 112940 -23490 0 0 {name=p112176 lab=_85664_/Q }
C {devices/lab_pin.sym} 112940 -23450 0 0 {name=p112177 lab=_59010_/X }
C {devices/lab_pin.sym} 113100 -23490 0 1 {name=p112178 lab=_59011_/X }
C {sky130_stdcells/o21a_4.sym} 113020 -23490 0 0 {name=X_59011_ }
C {devices/lab_pin.sym} 112960 -23370 0 0 {name=p112179 lab=_56214_/A }
C {devices/lab_pin.sym} 112960 -23330 0 0 {name=p112180 lab=_56229_/B }
C {devices/lab_pin.sym} 112960 -23290 0 0 {name=p112181 lab=_56223_/C }
C {devices/lab_pin.sym} 113080 -23330 0 1 {name=p112182 lab=_56223_/Y }
C {sky130_stdcells/nand3_4.sym} 113020 -23330 0 0 {name=X_56223_ }
C {devices/lab_pin.sym} 112980 -23190 0 0 {name=p112183 lab=_68208_/X }
C {devices/lab_pin.sym} 113060 -23190 0 1 {name=p112184 lab=_68209_/X }
C {sky130_stdcells/buf_2.sym} 113020 -23190 0 0 {name=X_68209_ }
C {devices/lab_pin.sym} 112930 -23070 0 0 {name=p112185 lab=_88097_/CLK }
C {devices/lab_pin.sym} 112930 -23050 0 0 {name=p112186 lab=_44592_/Y }
C {devices/lab_pin.sym} 113110 -23070 0 1 {name=p112187 lab=_87043_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -23060 0 0 {name=X_87043_ }
C {devices/lab_pin.sym} 112940 -22950 0 0 {name=p112188 lab=_85634_/Q }
C {devices/lab_pin.sym} 112940 -22910 0 0 {name=p112189 lab=_53431_/X }
C {devices/lab_pin.sym} 112940 -22870 0 0 {name=p112190 lab=_53434_/Y }
C {devices/lab_pin.sym} 113100 -22910 0 1 {name=p112191 lab=_53435_/Y }
C {sky130_stdcells/o21ai_4.sym} 113020 -22910 0 0 {name=X_53435_ }
C {devices/lab_pin.sym} 112930 -22770 0 0 {name=p112192 lab=_83491_/CLK }
C {devices/lab_pin.sym} 112930 -22750 0 0 {name=p112193 lab=_64340_/X }
C {devices/lab_pin.sym} 113110 -22770 0 1 {name=p112194 lab=_79775_/B }
C {sky130_stdcells/dfxtp_4.sym} 113020 -22760 0 0 {name=X_84255_ }
C {devices/lab_pin.sym} 112960 -22640 0 0 {name=p112195 lab=_50640_/A }
C {devices/lab_pin.sym} 112960 -22600 0 0 {name=p112196 lab=_53863_/A }
C {devices/lab_pin.sym} 113080 -22620 0 1 {name=p112197 lab=_50647_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -22620 0 0 {name=X_50647_ }
C {devices/lab_pin.sym} 112940 -22510 0 0 {name=p112198 lab=_83942_/Q }
C {devices/lab_pin.sym} 112940 -22470 0 0 {name=p112199 lab=_69161_/X }
C {devices/lab_pin.sym} 112940 -22430 0 0 {name=p112200 lab=_69188_/X }
C {devices/lab_pin.sym} 113100 -22470 0 1 {name=p112201 lab=_69189_/X }
C {sky130_stdcells/a21bo_4.sym} 113020 -22470 0 0 {name=X_69189_ }
C {devices/lab_pin.sym} 112930 -22330 0 0 {name=p112202 lab=_82648_/CLK }
C {devices/lab_pin.sym} 112930 -22310 0 0 {name=p112203 lab=_76879_/B }
C {devices/lab_pin.sym} 113110 -22330 0 1 {name=p112204 lab=_81467_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -22320 0 0 {name=X_81467_ }
C {devices/lab_pin.sym} 112980 -22190 0 0 {name=p112205 lab=_40399_/Y }
C {devices/lab_pin.sym} 113060 -22190 0 1 {name=p112206 lab=_40400_/X }
C {sky130_stdcells/buf_2.sym} 113020 -22190 0 0 {name=X_40400_ }
C {devices/lab_pin.sym} 112940 -22090 0 0 {name=p112207 lab=_48843_/B }
C {devices/lab_pin.sym} 112940 -22050 0 0 {name=p112208 lab=_71216_/X }
C {devices/lab_pin.sym} 112940 -22010 0 0 {name=p112209 lab=_71219_/Y }
C {devices/lab_pin.sym} 113100 -22050 0 1 {name=p112210 lab=_71220_/Y }
C {sky130_stdcells/o21ai_4.sym} 113020 -22050 0 0 {name=X_71220_ }
C {devices/lab_pin.sym} 112930 -21910 0 0 {name=p112211 lab=_83846_/CLK }
C {devices/lab_pin.sym} 112930 -21890 0 0 {name=p112212 lab=_83206_/D }
C {devices/lab_pin.sym} 113110 -21910 0 1 {name=p112213 lab=_70181_/A }
C {sky130_stdcells/dfxtp_4.sym} 113020 -21900 0 0 {name=X_83206_ }
C {devices/lab_pin.sym} 112960 -21780 0 0 {name=p112214 lab=_80425_/B }
C {devices/lab_pin.sym} 112960 -21740 0 0 {name=p112215 lab=_80418_/B }
C {devices/lab_pin.sym} 113080 -21760 0 1 {name=p112216 lab=_80418_/X }
C {sky130_stdcells/xor2_4.sym} 113020 -21760 0 0 {name=X_80418_ }
C {devices/lab_pin.sym} 112960 -21650 0 0 {name=p112217 lab=_56140_/A }
C {devices/lab_pin.sym} 112960 -21610 0 0 {name=p112218 lab=_56150_/B }
C {devices/lab_pin.sym} 112960 -21570 0 0 {name=p112219 lab=_55707_/B }
C {devices/lab_pin.sym} 113080 -21610 0 1 {name=p112220 lab=_56154_/Y }
C {sky130_stdcells/nand3_4.sym} 113020 -21610 0 0 {name=X_56154_ }
C {devices/lab_pin.sym} 112960 -21480 0 0 {name=p112221 lab=_81743_/Q }
C {devices/lab_pin.sym} 112960 -21440 0 0 {name=p112222 lab=_41379_/X }
C {devices/lab_pin.sym} 113080 -21460 0 1 {name=p112223 lab=_41380_/X }
C {sky130_stdcells/or2_4.sym} 113020 -21460 0 0 {name=X_41380_ }
C {devices/lab_pin.sym} 112980 -21330 0 0 {name=p112224 lab=_53311_/A }
C {devices/lab_pin.sym} 113060 -21330 0 1 {name=p112225 lab=_53371_/A }
C {sky130_stdcells/buf_2.sym} 113020 -21330 0 0 {name=X_53366_ }
C {devices/lab_pin.sym} 112930 -21210 0 0 {name=p112226 lab=_84192_/CLK }
C {devices/lab_pin.sym} 112930 -21190 0 0 {name=p112227 lab=_84186_/D }
C {devices/lab_pin.sym} 113110 -21210 0 1 {name=p112228 lab=_84186_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -21200 0 0 {name=X_84186_ }
C {devices/lab_pin.sym} 112960 -21080 0 0 {name=p112229 lab=_50578_/A }
C {devices/lab_pin.sym} 112960 -21040 0 0 {name=p112230 lab=_50578_/B }
C {devices/lab_pin.sym} 113080 -21060 0 1 {name=p112231 lab=_50578_/X }
C {sky130_stdcells/or2_4.sym} 113020 -21060 0 0 {name=X_50578_ }
C {devices/lab_pin.sym} 112930 -20930 0 0 {name=p112232 lab=_81346_/CLK }
C {devices/lab_pin.sym} 112930 -20910 0 0 {name=p112233 lab=_81398_/D }
C {devices/lab_pin.sym} 113110 -20930 0 1 {name=p112234 lab=_76683_/B }
C {sky130_stdcells/dfxtp_4.sym} 113020 -20920 0 0 {name=X_81398_ }
C {devices/lab_pin.sym} 112940 -20810 0 0 {name=p112235 lab=_55101_/Y }
C {devices/lab_pin.sym} 112940 -20770 0 0 {name=p112236 lab=_55102_/X }
C {devices/lab_pin.sym} 112940 -20730 0 0 {name=p112237 lab=_55104_/X }
C {devices/lab_pin.sym} 113100 -20770 0 1 {name=p112238 lab=_85318_/D }
C {sky130_stdcells/a21oi_4.sym} 113020 -20770 0 0 {name=X_55105_ }
C {devices/lab_pin.sym} 112980 -20630 0 0 {name=p112239 lab=_40330_/Y }
C {devices/lab_pin.sym} 113060 -20630 0 1 {name=p112240 lab=_40331_/X }
C {sky130_stdcells/buf_2.sym} 113020 -20630 0 0 {name=X_40331_ }
C {devices/lab_pin.sym} 112960 -20520 0 0 {name=p112241 lab=_52299_/A }
C {devices/lab_pin.sym} 112960 -20480 0 0 {name=p112242 lab=_48992_/X }
C {devices/lab_pin.sym} 113080 -20500 0 1 {name=p112243 lab=_52317_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -20500 0 0 {name=X_52317_ }
C {devices/lab_pin.sym} 112940 -20390 0 0 {name=p112244 lab=_48391_/X }
C {devices/lab_pin.sym} 112940 -20350 0 0 {name=p112245 lab=_71138_/X }
C {devices/lab_pin.sym} 112940 -20310 0 0 {name=p112246 lab=_71150_/Y }
C {devices/lab_pin.sym} 113100 -20350 0 1 {name=p112247 lab=_83590_/D }
C {sky130_stdcells/o21ai_4.sym} 113020 -20350 0 0 {name=X_71151_ }
C {devices/lab_pin.sym} 112930 -20210 0 0 {name=p112248 lab=_83141_/CLK }
C {devices/lab_pin.sym} 112930 -20190 0 0 {name=p112249 lab=_73769_/Y }
C {devices/lab_pin.sym} 113110 -20210 0 1 {name=p112250 lab=_83137_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -20200 0 0 {name=X_83137_ }
C {devices/lab_pin.sym} 112980 -20070 0 0 {name=p112251 lab=_56084_/Y }
C {devices/lab_pin.sym} 113060 -20070 0 1 {name=p112252 lab=_56085_/X }
C {sky130_stdcells/buf_2.sym} 113020 -20070 0 0 {name=X_56085_ }
C {devices/lab_pin.sym} 112960 -19960 0 0 {name=p112253 lab=_80349_/A }
C {devices/lab_pin.sym} 112960 -19920 0 0 {name=p112254 lab=_80349_/B }
C {devices/lab_pin.sym} 113080 -19940 0 1 {name=p112255 lab=_80350_/C }
C {sky130_stdcells/nand2_4.sym} 113020 -19940 0 0 {name=X_80349_ }
C {devices/lab_pin.sym} 112980 -19810 0 0 {name=p112256 lab=_53352_/A }
C {devices/lab_pin.sym} 113060 -19810 0 1 {name=p112257 lab=_53298_/A }
C {sky130_stdcells/buf_2.sym} 113020 -19810 0 0 {name=X_53297_ }
C {devices/lab_pin.sym} 112960 -19720 0 0 {name=p112258 lab=_70102_/A }
C {devices/lab_pin.sym} 112960 -19680 0 0 {name=p112259 lab=_70099_/Y }
C {devices/lab_pin.sym} 112960 -19640 0 0 {name=p112260 lab=_70100_/Y }
C {devices/lab_pin.sym} 112960 -19600 0 0 {name=p112261 lab=_70101_/Y }
C {devices/lab_pin.sym} 113080 -19660 0 1 {name=p112262 lab=_70102_/Y }
C {sky130_stdcells/nand4_4.sym} 113020 -19660 0 0 {name=X_70102_ }
C {devices/lab_pin.sym} 112980 -19510 0 0 {name=p112263 lab=_43017_/A }
C {devices/lab_pin.sym} 113060 -19510 0 1 {name=p112264 lab=_43050_/X }
C {sky130_stdcells/buf_2.sym} 113020 -19510 0 0 {name=X_43050_ }
C {devices/lab_pin.sym} 112940 -19410 0 0 {name=p112265 lab=_55034_/Y }
C {devices/lab_pin.sym} 112940 -19370 0 0 {name=p112266 lab=_55024_/X }
C {devices/lab_pin.sym} 112940 -19330 0 0 {name=p112267 lab=_55035_/X }
C {devices/lab_pin.sym} 113100 -19370 0 1 {name=p112268 lab=_85331_/D }
C {sky130_stdcells/a21oi_4.sym} 113020 -19370 0 0 {name=X_55036_ }
C {devices/lab_pin.sym} 112980 -19230 0 0 {name=p112269 lab=_59913_/A }
C {devices/lab_pin.sym} 113060 -19230 0 1 {name=p112270 lab=_59913_/X }
C {sky130_stdcells/buf_2.sym} 113020 -19230 0 0 {name=X_59913_ }
C {devices/lab_pin.sym} 112960 -19130 0 0 {name=p112271 lab=_48691_/A }
C {devices/lab_pin.sym} 112960 -19090 0 0 {name=p112272 lab=_52248_/B }
C {devices/lab_pin.sym} 112960 -19050 0 0 {name=p112273 lab=_52267_/C }
C {devices/lab_pin.sym} 113080 -19090 0 1 {name=p112274 lab=_52248_/X }
C {sky130_stdcells/and3_4.sym} 113020 -19090 0 0 {name=X_52248_ }
C {devices/lab_pin.sym} 112960 -18970 0 0 {name=p112275 lab=_71078_/A }
C {devices/lab_pin.sym} 112960 -18930 0 0 {name=p112276 lab=_71082_/B }
C {devices/lab_pin.sym} 112960 -18890 0 0 {name=p112277 lab=_71078_/C }
C {devices/lab_pin.sym} 113080 -18930 0 1 {name=p112278 lab=_71082_/Y }
C {sky130_stdcells/nand3_4.sym} 113020 -18930 0 0 {name=X_71082_ }
C {devices/lab_pin.sym} 112930 -18790 0 0 {name=p112279 lab=_83068_/CLK }
C {devices/lab_pin.sym} 112930 -18770 0 0 {name=p112280 lab=_74432_/Y }
C {devices/lab_pin.sym} 113110 -18790 0 1 {name=p112281 lab=_83068_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -18780 0 0 {name=X_83068_ }
C {devices/lab_pin.sym} 112930 -18650 0 0 {name=p112282 lab=_87883_/CLK }
C {devices/lab_pin.sym} 112930 -18630 0 0 {name=p112283 lab=_42274_/X }
C {devices/lab_pin.sym} 113110 -18650 0 1 {name=p112284 lab=_87945_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -18640 0 0 {name=X_87945_ }
C {devices/lab_pin.sym} 112940 -18550 0 0 {name=p112285 lab=_41998_/X }
C {devices/lab_pin.sym} 112940 -18510 0 0 {name=p112286 lab=_41993_/X }
C {devices/lab_pin.sym} 112940 -18470 0 0 {name=p112287 lab=_40802_/X }
C {devices/lab_pin.sym} 112940 -18430 0 0 {name=p112288 lab=_41999_/Y }
C {devices/lab_pin.sym} 112940 -18390 0 0 {name=p112289 lab=_42000_/X }
C {devices/lab_pin.sym} 113100 -18470 0 1 {name=p112290 lab=_88076_/D }
C {sky130_stdcells/o32ai_4.sym} 113020 -18470 0 0 {name=X_42001_ }
C {devices/lab_pin.sym} 112960 -18320 0 0 {name=p112291 lab=_74910_/A }
C {devices/lab_pin.sym} 112960 -18280 0 0 {name=p112292 lab=_74909_/Y }
C {devices/lab_pin.sym} 113080 -18300 0 1 {name=p112293 lab=_74911_/B }
C {sky130_stdcells/xnor2_4.sym} 113020 -18300 0 0 {name=X_74910_ }
C {devices/lab_pin.sym} 112980 -18170 0 0 {name=p112294 lab=_70056_/A }
C {devices/lab_pin.sym} 113060 -18170 0 1 {name=p112295 lab=_70033_/X }
C {sky130_stdcells/buf_2.sym} 113020 -18170 0 0 {name=X_70033_ }
C {devices/lab_pin.sym} 112930 -18050 0 0 {name=p112296 lab=_82104_/CLK }
C {devices/lab_pin.sym} 112930 -18030 0 0 {name=p112297 lab=_77744_/B }
C {devices/lab_pin.sym} 113110 -18050 0 1 {name=p112298 lab=_81987_/D }
C {sky130_stdcells/dfxtp_4.sym} 113020 -18040 0 0 {name=X_82019_ }
C {devices/lab_pin.sym} 112980 -17910 0 0 {name=p112299 lab=clkbuf_4_6_1_CLK/A }
C {devices/lab_pin.sym} 113060 -17910 0 1 {name=p112300 lab=clkbuf_4_6_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 113020 -17910 0 0 {name=Xclkbuf_4_6_1_CLK }
C {devices/lab_pin.sym} 112940 -17830 0 0 {name=p112301 lab=_59728_/Y }
C {devices/lab_pin.sym} 112940 -17790 0 0 {name=p112302 lab=_59744_/Y }
C {devices/lab_pin.sym} 112940 -17750 0 0 {name=p112303 lab=_59840_/Y }
C {devices/lab_pin.sym} 112940 -17710 0 0 {name=p112304 lab=_59841_/X }
C {devices/lab_pin.sym} 112940 -17680 0 0 {name=p112305 lab=_59843_/Y }
C {devices/lab_pin.sym} 113100 -17750 0 1 {name=p112306 lab=_59844_/Y }
C {sky130_stdcells/a41oi_4.sym} 113020 -17750 0 0 {name=X_59844_ }
C {devices/lab_pin.sym} 112980 -17590 0 0 {name=p112307 lab=_52215_/A }
C {devices/lab_pin.sym} 113060 -17590 0 1 {name=p112308 lab=_52210_/A }
C {sky130_stdcells/buf_2.sym} 113020 -17590 0 0 {name=X_52179_ }
C {devices/lab_pin.sym} 112930 -17470 0 0 {name=p112309 lab=_88394_/CLK }
C {devices/lab_pin.sym} 112930 -17450 0 0 {name=p112310 lab=_42413_/Y }
C {devices/lab_pin.sym} 113110 -17470 0 1 {name=p112311 lab=_87876_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -17460 0 0 {name=X_87876_ }
C {devices/lab_pin.sym} 112980 -17330 0 0 {name=p112312 lab=_75889_/Y }
C {devices/lab_pin.sym} 113060 -17330 0 1 {name=p112313 lab=_75890_/Y }
C {sky130_stdcells/inv_2.sym} 113020 -17330 0 0 {name=X_75890_ }
C {devices/lab_pin.sym} 112960 -17230 0 0 {name=p112314 lab=_46186_/X }
C {devices/lab_pin.sym} 112960 -17190 0 0 {name=p112315 lab=_74842_/B }
C {devices/lab_pin.sym} 112960 -17150 0 0 {name=p112316 lab=_46189_/Y }
C {devices/lab_pin.sym} 113080 -17190 0 1 {name=p112317 lab=_80671_/D }
C {sky130_stdcells/and3_4.sym} 113020 -17190 0 0 {name=X_74841_ }
C {devices/lab_pin.sym} 112930 -17050 0 0 {name=p112318 lab=_86824_/CLK }
C {devices/lab_pin.sym} 112930 -17030 0 0 {name=p112319 lab=_86827_/D }
C {devices/lab_pin.sym} 113110 -17050 0 1 {name=p112320 lab=_86827_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -17040 0 0 {name=X_86827_ }
C {devices/lab_pin.sym} 112960 -16930 0 0 {name=p112321 lab=_59775_/A }
C {devices/lab_pin.sym} 112960 -16890 0 0 {name=p112322 lab=_59660_/C }
C {devices/lab_pin.sym} 112960 -16850 0 0 {name=p112323 lab=_59660_/D }
C {devices/lab_pin.sym} 113080 -16890 0 1 {name=p112324 lab=_59775_/X }
C {sky130_stdcells/and3_4.sym} 113020 -16890 0 0 {name=X_59775_ }
C {devices/lab_pin.sym} 112940 -16770 0 0 {name=p112325 lab=_57416_/A }
C {devices/lab_pin.sym} 112940 -16730 0 0 {name=p112326 lab=_57416_/C }
C {devices/lab_pin.sym} 112940 -16690 0 0 {name=p112327 lab=_44213_/X }
C {devices/lab_pin.sym} 113100 -16730 0 1 {name=p112328 lab=_56987_/Y }
C {sky130_stdcells/a21oi_4.sym} 113020 -16730 0 0 {name=X_56987_ }
C {devices/lab_pin.sym} 112980 -16590 0 0 {name=p112329 lab=_52645_/B }
C {devices/lab_pin.sym} 113060 -16590 0 1 {name=p112330 lab=_46740_/X }
C {sky130_stdcells/buf_2.sym} 113020 -16590 0 0 {name=X_46740_ }
C {devices/lab_pin.sym} 112960 -16480 0 0 {name=p112331 lab=_58699_/A }
C {devices/lab_pin.sym} 112960 -16440 0 0 {name=p112332 lab=_86388_/Q }
C {devices/lab_pin.sym} 113080 -16460 0 1 {name=p112333 lab=_58726_/Y }
C {sky130_stdcells/nor2_4.sym} 113020 -16460 0 0 {name=X_58726_ }
C {devices/lab_pin.sym} 112980 -16330 0 0 {name=p112334 lab=_77559_/X }
C {devices/lab_pin.sym} 113060 -16330 0 1 {name=p112335 lab=_77560_/Y }
C {sky130_stdcells/inv_2.sym} 113020 -16330 0 0 {name=X_77560_ }
C {devices/lab_pin.sym} 112960 -16220 0 0 {name=p112336 lab=_55947_/A }
C {devices/lab_pin.sym} 112960 -16180 0 0 {name=p112337 lab=_85244_/Q }
C {devices/lab_pin.sym} 113080 -16200 0 1 {name=p112338 lab=_55938_/X }
C {sky130_stdcells/and2_4.sym} 113020 -16200 0 0 {name=X_55938_ }
C {devices/lab_pin.sym} 112940 -16100 0 0 {name=p112339 lab=_44293_/B }
C {devices/lab_pin.sym} 112940 -16060 0 0 {name=p112340 lab=_43979_/A }
C {devices/lab_pin.sym} 112940 -16020 0 0 {name=p112341 lab=_43945_/A }
C {devices/lab_pin.sym} 112940 -15980 0 0 {name=p112342 lab=_43951_/Y }
C {devices/lab_pin.sym} 113100 -16040 0 1 {name=p112343 lab=_43952_/X }
C {sky130_stdcells/a211o_4.sym} 113020 -16040 0 0 {name=X_43952_ }
C {devices/lab_pin.sym} 112960 -15920 0 0 {name=p112344 lab=_74768_/Y }
C {devices/lab_pin.sym} 112960 -15880 0 0 {name=p112345 lab=_74772_/B }
C {devices/lab_pin.sym} 112960 -15840 0 0 {name=p112346 lab=_74772_/C }
C {devices/lab_pin.sym} 112960 -15800 0 0 {name=p112347 lab=_74771_/Y }
C {devices/lab_pin.sym} 113080 -15860 0 1 {name=p112348 lab=_74777_/B }
C {sky130_stdcells/and4_4.sym} 113020 -15860 0 0 {name=X_74772_ }
C {devices/lab_pin.sym} 112930 -15710 0 0 {name=p112349 lab=_86758_/CLK }
C {devices/lab_pin.sym} 112930 -15690 0 0 {name=p112350 lab=_46227_/Y }
C {devices/lab_pin.sym} 113110 -15710 0 1 {name=p112351 lab=_44146_/A }
C {sky130_stdcells/dfxtp_4.sym} 113020 -15700 0 0 {name=X_86758_ }
C {devices/lab_pin.sym} 112940 -15590 0 0 {name=p112352 lab=_71982_/Y }
C {devices/lab_pin.sym} 112940 -15550 0 0 {name=p112353 lab=_71978_/X }
C {devices/lab_pin.sym} 112940 -15510 0 0 {name=p112354 lab=_71983_/X }
C {devices/lab_pin.sym} 113100 -15550 0 1 {name=p112355 lab=_83308_/D }
C {sky130_stdcells/a21oi_4.sym} 113020 -15550 0 0 {name=X_71984_ }
C {devices/lab_pin.sym} 112960 -15420 0 0 {name=p112356 lab=_76509_/X }
C {devices/lab_pin.sym} 112960 -15380 0 0 {name=p112357 lab=_76511_/B }
C {devices/lab_pin.sym} 113080 -15400 0 1 {name=p112358 lab=_76511_/X }
C {sky130_stdcells/and2_4.sym} 113020 -15400 0 0 {name=X_76511_ }
C {devices/lab_pin.sym} 112940 -15310 0 0 {name=p112359 lab=_42895_/X }
C {devices/lab_pin.sym} 112940 -15270 0 0 {name=p112360 lab=_42896_/X }
C {devices/lab_pin.sym} 112940 -15230 0 0 {name=p112361 lab=_41667_/X }
C {devices/lab_pin.sym} 112940 -15190 0 0 {name=p112362 lab=_87660_/Q }
C {devices/lab_pin.sym} 112940 -15150 0 0 {name=p112363 lab=_42881_/X }
C {devices/lab_pin.sym} 113100 -15230 0 1 {name=p112364 lab=_42903_/Y }
C {sky130_stdcells/o32ai_4.sym} 113020 -15230 0 0 {name=X_42903_ }
C {devices/lab_pin.sym} 112960 -15080 0 0 {name=p112365 lab=_88108_/Q }
C {devices/lab_pin.sym} 112960 -15040 0 0 {name=p112366 lab=_73649_/X }
C {devices/lab_pin.sym} 113080 -15060 0 1 {name=p112367 lab=_73723_/Y }
C {sky130_stdcells/nor2_4.sym} 113020 -15060 0 0 {name=X_73723_ }
C {devices/lab_pin.sym} 112930 -14930 0 0 {name=p112368 lab=_85709_/CLK }
C {devices/lab_pin.sym} 112930 -14910 0 0 {name=p112369 lab=_85709_/D }
C {devices/lab_pin.sym} 113110 -14930 0 1 {name=p112370 lab=_85709_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -14920 0 0 {name=X_85709_ }
C {devices/lab_pin.sym} 112940 -14810 0 0 {name=p112371 lab=_46664_/Y }
C {devices/lab_pin.sym} 112940 -14770 0 0 {name=p112372 lab=_46654_/X }
C {devices/lab_pin.sym} 112940 -14730 0 0 {name=p112373 lab=_46670_/X }
C {devices/lab_pin.sym} 113100 -14770 0 1 {name=p112374 lab=_46671_/Y }
C {sky130_stdcells/a21oi_4.sym} 113020 -14770 0 0 {name=X_46671_ }
C {devices/lab_pin.sym} 112940 -14650 0 0 {name=p112375 lab=_58112_/X }
C {devices/lab_pin.sym} 112940 -14610 0 0 {name=p112376 lab=_86106_/Q }
C {devices/lab_pin.sym} 112940 -14570 0 0 {name=p112377 lab=_58656_/X }
C {devices/lab_pin.sym} 113100 -14610 0 1 {name=p112378 lab=_58657_/Y }
C {sky130_stdcells/o21ai_4.sym} 113020 -14610 0 0 {name=X_58657_ }
C {devices/lab_pin.sym} 112960 -14500 0 0 {name=p112379 lab=_70935_/A }
C {devices/lab_pin.sym} 112960 -14460 0 0 {name=p112380 lab=_70959_/B }
C {devices/lab_pin.sym} 112960 -14420 0 0 {name=p112381 lab=_71115_/D }
C {devices/lab_pin.sym} 112960 -14380 0 0 {name=p112382 lab=_71115_/B }
C {devices/lab_pin.sym} 113080 -14440 0 1 {name=p112383 lab=_70935_/X }
C {sky130_stdcells/and4_4.sym} 113020 -14440 0 0 {name=X_70935_ }
C {devices/lab_pin.sym} 112940 -14310 0 0 {name=p112384 lab=_77487_/Y }
C {devices/lab_pin.sym} 112940 -14270 0 0 {name=p112385 lab=_77489_/Y }
C {devices/lab_pin.sym} 112940 -14230 0 0 {name=p112386 lab=_77486_/Y }
C {devices/lab_pin.sym} 113100 -14270 0 1 {name=p112387 lab=_77491_/Y }
C {sky130_stdcells/o21ai_4.sym} 113020 -14270 0 0 {name=X_77491_ }
C {devices/lab_pin.sym} 112940 -14160 0 0 {name=p112388 lab=_41294_/X }
C {devices/lab_pin.sym} 112940 -14120 0 0 {name=p112389 lab=_43879_/X }
C {devices/lab_pin.sym} 112940 -14080 0 0 {name=p112390 lab=_87218_/Q }
C {devices/lab_pin.sym} 112940 -14040 0 0 {name=p112391 lab=_43880_/X }
C {devices/lab_pin.sym} 113100 -14100 0 1 {name=p112392 lab=_87218_/D }
C {sky130_stdcells/a2bb2o_4.sym} 113020 -14100 0 0 {name=X_43883_ }
C {devices/lab_pin.sym} 112940 -13970 0 0 {name=p112393 lab=_55866_/X }
C {devices/lab_pin.sym} 112940 -13930 0 0 {name=p112394 lab=_55868_/X }
C {devices/lab_pin.sym} 112940 -13890 0 0 {name=p112395 lab=_55517_/X }
C {devices/lab_pin.sym} 113100 -13930 0 1 {name=p112396 lab=_55872_/A }
C {sky130_stdcells/a21o_4.sym} 113020 -13930 0 0 {name=X_55869_ }
C {devices/lab_pin.sym} 112930 -13790 0 0 {name=p112397 lab=_86688_/CLK }
C {devices/lab_pin.sym} 112930 -13770 0 0 {name=p112398 lab=_46927_/Y }
C {devices/lab_pin.sym} 113110 -13790 0 1 {name=p112399 lab=_58997_/A }
C {sky130_stdcells/dfxtp_4.sym} 113020 -13780 0 0 {name=X_86689_ }
C {devices/lab_pin.sym} 112980 -13650 0 0 {name=p112400 lab=_83588_/Q }
C {devices/lab_pin.sym} 113060 -13650 0 1 {name=p112401 lab=_74389_/B }
C {sky130_stdcells/inv_2.sym} 113020 -13650 0 0 {name=X_48410_ }
C {devices/lab_pin.sym} 112960 -13540 0 0 {name=p112402 lab=_79230_/A }
C {devices/lab_pin.sym} 112960 -13500 0 0 {name=p112403 lab=_79229_/Y }
C {devices/lab_pin.sym} 113080 -13520 0 1 {name=p112404 lab=_79230_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -13520 0 0 {name=X_79230_ }
C {devices/lab_pin.sym} 112960 -13400 0 0 {name=p112405 lab=_45621_/Y }
C {devices/lab_pin.sym} 112960 -13360 0 0 {name=p112406 lab=_44975_/A }
C {devices/lab_pin.sym} 113080 -13380 0 1 {name=p112407 lab=_45622_/X }
C {sky130_stdcells/and2_4.sym} 113020 -13380 0 0 {name=X_45622_ }
C {devices/lab_pin.sym} 112980 -13250 0 0 {name=p112408 lab=_71993_/A }
C {devices/lab_pin.sym} 113060 -13250 0 1 {name=p112409 lab=_57608_/X }
C {sky130_stdcells/buf_2.sym} 113020 -13250 0 0 {name=X_57608_ }
C {devices/lab_pin.sym} 112960 -13140 0 0 {name=p112410 lab=_76419_/Y }
C {devices/lab_pin.sym} 112960 -13100 0 0 {name=p112411 lab=_76433_/X }
C {devices/lab_pin.sym} 113080 -13120 0 1 {name=p112412 lab=_76443_/A }
C {sky130_stdcells/nor2_4.sym} 113020 -13120 0 0 {name=X_76442_ }
C {devices/lab_pin.sym} 112940 -13020 0 0 {name=p112413 lab=_41485_/X }
C {devices/lab_pin.sym} 112940 -12980 0 0 {name=p112414 lab=_42830_/X }
C {devices/lab_pin.sym} 112940 -12940 0 0 {name=p112415 lab=_66689_/B }
C {devices/lab_pin.sym} 112940 -12900 0 0 {name=p112416 lab=_42832_/X }
C {devices/lab_pin.sym} 113100 -12960 0 1 {name=p112417 lab=_42834_/X }
C {sky130_stdcells/a2bb2o_4.sym} 113020 -12960 0 0 {name=X_42834_ }
C {devices/lab_pin.sym} 112960 -12820 0 0 {name=p112418 lab=_49410_/A }
C {devices/lab_pin.sym} 112960 -12780 0 0 {name=p112419 lab=_46662_/X }
C {devices/lab_pin.sym} 113080 -12800 0 1 {name=p112420 lab=_49390_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -12800 0 0 {name=X_49390_ }
C {devices/lab_pin.sym} 112940 -12700 0 0 {name=p112421 lab=_68468_/B }
C {devices/lab_pin.sym} 112940 -12660 0 0 {name=p112422 lab=_73597_/X }
C {devices/lab_pin.sym} 112940 -12620 0 0 {name=p112423 lab=_73652_/X }
C {devices/lab_pin.sym} 112940 -12580 0 0 {name=p112424 lab=_73653_/Y }
C {devices/lab_pin.sym} 113100 -12640 0 1 {name=p112425 lab=_73654_/X }
C {sky130_stdcells/a211o_4.sym} 113020 -12640 0 0 {name=X_73654_ }
C {devices/lab_pin.sym} 112980 -12490 0 0 {name=p112426 lab=_70866_/A }
C {devices/lab_pin.sym} 113060 -12490 0 1 {name=p112427 lab=_70869_/C }
C {sky130_stdcells/buf_2.sym} 113020 -12490 0 0 {name=X_70866_ }
C {devices/lab_pin.sym} 112960 -12380 0 0 {name=p112428 lab=_86719_/Q }
C {devices/lab_pin.sym} 112960 -12340 0 0 {name=p112429 lab=_58614_/B }
C {devices/lab_pin.sym} 113080 -12360 0 1 {name=p112430 lab=_58588_/Y }
C {sky130_stdcells/nor2_4.sym} 113020 -12360 0 0 {name=X_58588_ }
C {devices/lab_pin.sym} 112940 -12250 0 0 {name=p112431 lab=_66326_/B }
C {devices/lab_pin.sym} 112940 -12210 0 0 {name=p112432 lab=_48333_/X }
C {devices/lab_pin.sym} 112940 -12170 0 0 {name=p112433 lab=_48340_/Y }
C {devices/lab_pin.sym} 113100 -12210 0 1 {name=p112434 lab=_48341_/Y }
C {sky130_stdcells/o21ai_4.sym} 113020 -12210 0 0 {name=X_48341_ }
C {devices/lab_pin.sym} 112940 -12110 0 0 {name=p112435 lab=_60053_/X }
C {devices/lab_pin.sym} 112940 -12070 0 0 {name=p112436 lab=_72537_/Y }
C {devices/lab_pin.sym} 112940 -12030 0 0 {name=p112437 lab=_72569_/C }
C {devices/lab_pin.sym} 112940 -11990 0 0 {name=p112438 lab=_72569_/A }
C {devices/lab_pin.sym} 112940 -11960 0 0 {name=p112439 lab=_72604_/Y }
C {devices/lab_pin.sym} 113100 -12030 0 1 {name=p112440 lab=_72605_/Y }
C {sky130_stdcells/a41oi_4.sym} 113020 -12030 0 0 {name=X_72605_ }
C {devices/lab_pin.sym} 112960 -11880 0 0 {name=p112441 lab=_79158_/Y }
C {devices/lab_pin.sym} 112960 -11840 0 0 {name=p112442 lab=_79160_/Y }
C {devices/lab_pin.sym} 113080 -11860 0 1 {name=p112443 lab=_79161_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -11860 0 0 {name=X_79161_ }
C {devices/lab_pin.sym} 112960 -11750 0 0 {name=p112444 lab=_48234_/A }
C {devices/lab_pin.sym} 112960 -11710 0 0 {name=p112445 lab=_46620_/A }
C {devices/lab_pin.sym} 112960 -11670 0 0 {name=p112446 lab=_53697_/B }
C {devices/lab_pin.sym} 113080 -11710 0 1 {name=p112447 lab=_57539_/Y }
C {sky130_stdcells/nand3_4.sym} 113020 -11710 0 0 {name=X_57539_ }
C {devices/lab_pin.sym} 112960 -11580 0 0 {name=p112448 lab=_45553_/A }
C {devices/lab_pin.sym} 112960 -11540 0 0 {name=p112449 lab=_45617_/B }
C {devices/lab_pin.sym} 113080 -11560 0 1 {name=p112450 lab=_45553_/Y }
C {sky130_stdcells/nor2_4.sym} 113020 -11560 0 0 {name=X_45553_ }
C {devices/lab_pin.sym} 112940 -11450 0 0 {name=p112451 lab=_76355_/Y }
C {devices/lab_pin.sym} 112940 -11410 0 0 {name=p112452 lab=_76361_/Y }
C {devices/lab_pin.sym} 112940 -11370 0 0 {name=p112453 lab=_76353_/Y }
C {devices/lab_pin.sym} 113100 -11410 0 1 {name=p112454 lab=_76373_/X }
C {sky130_stdcells/o21a_4.sym} 113020 -11410 0 0 {name=X_76373_ }
C {devices/lab_pin.sym} 112930 -11270 0 0 {name=p112455 lab=_86998_/CLK }
C {devices/lab_pin.sym} 112930 -11250 0 0 {name=p112456 lab=_40658_/Y }
C {devices/lab_pin.sym} 113110 -11270 0 1 {name=p112457 lab=_88359_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113020 -11260 0 0 {name=X_88359_ }
C {devices/lab_pin.sym} 112940 -11160 0 0 {name=p112458 lab=_41294_/X }
C {devices/lab_pin.sym} 112940 -11120 0 0 {name=p112459 lab=_42757_/X }
C {devices/lab_pin.sym} 112940 -11080 0 0 {name=p112460 lab=_67368_/B }
C {devices/lab_pin.sym} 112940 -11040 0 0 {name=p112461 lab=_42759_/X }
C {devices/lab_pin.sym} 113100 -11100 0 1 {name=p112462 lab=_42765_/X }
C {sky130_stdcells/a2bb2o_4.sym} 113020 -11100 0 0 {name=X_42765_ }
C {devices/lab_pin.sym} 112960 -10960 0 0 {name=p112463 lab=_73497_/A }
C {devices/lab_pin.sym} 112960 -10920 0 0 {name=p112464 lab=_65921_/B }
C {devices/lab_pin.sym} 113080 -10940 0 1 {name=p112465 lab=_73585_/X }
C {sky130_stdcells/and2_4.sym} 113020 -10940 0 0 {name=X_73585_ }
C {devices/lab_pin.sym} 112940 -10830 0 0 {name=p112466 lab=_52876_/B }
C {devices/lab_pin.sym} 112940 -10790 0 0 {name=p112467 lab=_70761_/A }
C {devices/lab_pin.sym} 112940 -10750 0 0 {name=p112468 lab=_70796_/Y }
C {devices/lab_pin.sym} 113100 -10790 0 1 {name=p112469 lab=_70797_/Y }
C {sky130_stdcells/o21ai_4.sym} 113020 -10790 0 0 {name=X_70797_ }
C {devices/lab_pin.sym} 112960 -10660 0 0 {name=p112470 lab=_78112_/A }
C {devices/lab_pin.sym} 112960 -10620 0 0 {name=p112471 lab=_78112_/B }
C {devices/lab_pin.sym} 113080 -10640 0 1 {name=p112472 lab=_78112_/X }
C {sky130_stdcells/xor2_4.sym} 113020 -10640 0 0 {name=X_78112_ }
C {devices/lab_pin.sym} 112940 -10540 0 0 {name=p112473 lab=_41259_/A }
C {devices/lab_pin.sym} 112940 -10500 0 0 {name=p112474 lab=_44502_/X }
C {devices/lab_pin.sym} 112940 -10460 0 0 {name=p112475 lab=_87077_/Q }
C {devices/lab_pin.sym} 112940 -10420 0 0 {name=p112476 lab=_44503_/X }
C {devices/lab_pin.sym} 113100 -10480 0 1 {name=p112477 lab=_87077_/D }
C {sky130_stdcells/a2bb2o_4.sym} 113020 -10480 0 0 {name=X_44504_ }
C {devices/lab_pin.sym} 112980 -10330 0 0 {name=p112478 lab=_75323_/X }
C {devices/lab_pin.sym} 113060 -10330 0 1 {name=p112479 lab=_75324_/Y }
C {sky130_stdcells/inv_2.sym} 113020 -10330 0 0 {name=X_75324_ }
C {devices/lab_pin.sym} 112940 -10240 0 0 {name=p112480 lab=_41715_/X }
C {devices/lab_pin.sym} 112940 -10200 0 0 {name=p112481 lab=_41682_/X }
C {devices/lab_pin.sym} 112940 -10160 0 0 {name=p112482 lab=_67724_/B }
C {devices/lab_pin.sym} 112940 -10120 0 0 {name=p112483 lab=_41684_/X }
C {devices/lab_pin.sym} 113100 -10180 0 1 {name=p112484 lab=_41716_/X }
C {sky130_stdcells/a2bb2o_4.sym} 113020 -10180 0 0 {name=X_41716_ }
C {devices/lab_pin.sym} 112940 -10050 0 0 {name=p112485 lab=_66159_/B }
C {devices/lab_pin.sym} 112940 -10010 0 0 {name=p112486 lab=_48241_/X }
C {devices/lab_pin.sym} 112940 -9970 0 0 {name=p112487 lab=_48271_/Y }
C {devices/lab_pin.sym} 113100 -10010 0 1 {name=p112488 lab=_48272_/Y }
C {sky130_stdcells/o21ai_4.sym} 113020 -10010 0 0 {name=X_48272_ }
C {devices/lab_pin.sym} 112980 -9870 0 0 {name=p112489 lab=_60473_/C }
C {devices/lab_pin.sym} 113060 -9870 0 1 {name=p112490 lab=_60602_/B }
C {sky130_stdcells/buf_2.sym} 113020 -9870 0 0 {name=X_60550_ }
C {devices/lab_pin.sym} 112960 -9760 0 0 {name=p112491 lab=_72506_/C }
C {devices/lab_pin.sym} 112960 -9720 0 0 {name=p112492 lab=_72516_/C }
C {devices/lab_pin.sym} 113080 -9740 0 1 {name=p112493 lab=_72537_/B }
C {sky130_stdcells/nor2_4.sym} 113020 -9740 0 0 {name=X_72536_ }
C {devices/lab_pin.sym} 112940 -9630 0 0 {name=p112494 lab=_82655_/Q }
C {devices/lab_pin.sym} 112940 -9590 0 0 {name=p112495 lab=_82527_/D }
C {devices/lab_pin.sym} 112940 -9550 0 0 {name=p112496 lab=_79091_/X }
C {devices/lab_pin.sym} 113100 -9590 0 1 {name=p112497 lab=_79092_/Y }
C {sky130_stdcells/o21ai_4.sym} 113020 -9590 0 0 {name=X_79092_ }
C {devices/lab_pin.sym} 112940 -9470 0 0 {name=p112498 lab=_45478_/X }
C {devices/lab_pin.sym} 112940 -9430 0 0 {name=p112499 lab=_45481_/X }
C {devices/lab_pin.sym} 112940 -9390 0 0 {name=p112500 lab=_45483_/Y }
C {devices/lab_pin.sym} 113100 -9430 0 1 {name=p112501 lab=_45484_/Y }
C {sky130_stdcells/a21oi_4.sym} 113020 -9430 0 0 {name=X_45484_ }
C {devices/lab_pin.sym} 112980 -9290 0 0 {name=p112502 lab=_42681_/A }
C {devices/lab_pin.sym} 113060 -9290 0 1 {name=p112503 lab=_42696_/X }
C {sky130_stdcells/buf_2.sym} 113020 -9290 0 0 {name=X_42696_ }
C {devices/lab_pin.sym} 112940 -9190 0 0 {name=p112504 lab=_57698_/A }
C {devices/lab_pin.sym} 112940 -9150 0 0 {name=p112505 lab=_47192_/X }
C {devices/lab_pin.sym} 112940 -9110 0 0 {name=p112506 lab=_47222_/Y }
C {devices/lab_pin.sym} 113100 -9150 0 1 {name=p112507 lab=_47223_/Y }
C {sky130_stdcells/o21ai_4.sym} 113020 -9150 0 0 {name=X_47223_ }
C {devices/lab_pin.sym} 112940 -9030 0 0 {name=p112508 lab=_59105_/X }
C {devices/lab_pin.sym} 112940 -8990 0 0 {name=p112509 lab=_85744_/Q }
C {devices/lab_pin.sym} 112940 -8950 0 0 {name=p112510 lab=_59106_/X }
C {devices/lab_pin.sym} 113100 -8990 0 1 {name=p112511 lab=_59209_/X }
C {sky130_stdcells/o21a_4.sym} 113020 -8990 0 0 {name=X_59209_ }
C {devices/lab_pin.sym} 112980 -8850 0 0 {name=p112512 lab=clkbuf_9_232_0_CLK/X }
C {devices/lab_pin.sym} 113060 -8850 0 1 {name=p112513 lab=_86372_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 113020 -8850 0 0 {name=Xclkbuf_10_464_0_CLK }
C {devices/lab_pin.sym} 112980 -8730 0 0 {name=p112514 lab=_78043_/A }
C {devices/lab_pin.sym} 113060 -8730 0 1 {name=p112515 lab=_78043_/Y }
C {sky130_stdcells/inv_2.sym} 113020 -8730 0 0 {name=X_78043_ }
C {devices/lab_pin.sym} 112940 -8640 0 0 {name=p112516 lab=_41592_/X }
C {devices/lab_pin.sym} 112940 -8600 0 0 {name=p112517 lab=_44431_/X }
C {devices/lab_pin.sym} 112940 -8560 0 0 {name=p112518 lab=_87110_/Q }
C {devices/lab_pin.sym} 112940 -8520 0 0 {name=p112519 lab=_44432_/X }
C {devices/lab_pin.sym} 113100 -8580 0 1 {name=p112520 lab=_87110_/D }
C {sky130_stdcells/a2bb2o_4.sym} 113020 -8580 0 0 {name=X_44435_ }
C {devices/lab_pin.sym} 112960 -8440 0 0 {name=p112521 lab=_75255_/A }
C {devices/lab_pin.sym} 112960 -8400 0 0 {name=p112522 lab=_80943_/D }
C {devices/lab_pin.sym} 113080 -8420 0 1 {name=p112523 lab=_75258_/B }
C {sky130_stdcells/nor2_4.sym} 113020 -8420 0 0 {name=X_75255_ }
C {devices/lab_pin.sym} 112980 -8290 0 0 {name=p112524 lab=_41646_/Y }
C {devices/lab_pin.sym} 113060 -8290 0 1 {name=p112525 lab=_41647_/X }
C {sky130_stdcells/buf_2.sym} 113020 -8290 0 0 {name=X_41647_ }
C {devices/lab_pin.sym} 112980 -8170 0 0 {name=p112526 lab=_60481_/A }
C {devices/lab_pin.sym} 113060 -8170 0 1 {name=p112527 lab=_60481_/X }
C {sky130_stdcells/buf_2.sym} 113020 -8170 0 0 {name=X_60481_ }
C {devices/lab_pin.sym} 112940 -8070 0 0 {name=p112528 lab=_57709_/X }
C {devices/lab_pin.sym} 112940 -8030 0 0 {name=p112529 lab=_85347_/Q }
C {devices/lab_pin.sym} 112940 -7990 0 0 {name=p112530 lab=_72466_/X }
C {devices/lab_pin.sym} 113100 -8030 0 1 {name=p112531 lab=_72467_/Y }
C {sky130_stdcells/o21ai_4.sym} 113020 -8030 0 0 {name=X_72467_ }
C {devices/lab_pin.sym} 112960 -7920 0 0 {name=p112532 lab=_62194_/A }
C {devices/lab_pin.sym} 112960 -7880 0 0 {name=p112533 lab=_58221_/X }
C {devices/lab_pin.sym} 112960 -7840 0 0 {name=p112534 lab=_62219_/X }
C {devices/lab_pin.sym} 112960 -7800 0 0 {name=p112535 lab=_62244_/D }
C {devices/lab_pin.sym} 113080 -7860 0 1 {name=p112536 lab=_62220_/X }
C {sky130_stdcells/and4_4.sym} 113020 -7860 0 0 {name=X_62220_ }
C {devices/lab_pin.sym} 112960 -7720 0 0 {name=p112537 lab=_74206_/A }
C {devices/lab_pin.sym} 112960 -7680 0 0 {name=p112538 lab=_73577_/B }
C {devices/lab_pin.sym} 113080 -7700 0 1 {name=p112539 lab=_74206_/Y }
C {sky130_stdcells/nor2_4.sym} 113020 -7700 0 0 {name=X_74206_ }
C {devices/lab_pin.sym} 112980 -7570 0 0 {name=p112540 lab=_54576_/D }
C {devices/lab_pin.sym} 113060 -7570 0 1 {name=p112541 lab=_51192_/D }
C {sky130_stdcells/buf_2.sym} 113020 -7570 0 0 {name=X_47154_ }
C {devices/lab_pin.sym} 112960 -7460 0 0 {name=p112542 lab=_71221_/A }
C {devices/lab_pin.sym} 112960 -7420 0 0 {name=p112543 lab=_71418_/B }
C {devices/lab_pin.sym} 113080 -7440 0 1 {name=p112544 lab=_71419_/A }
C {sky130_stdcells/and2_4.sym} 113020 -7440 0 0 {name=X_71418_ }
C {devices/lab_pin.sym} 112940 -7340 0 0 {name=p112545 lab=_41741_/X }
C {devices/lab_pin.sym} 112940 -7300 0 0 {name=p112546 lab=_44364_/X }
C {devices/lab_pin.sym} 112940 -7260 0 0 {name=p112547 lab=_87146_/Q }
C {devices/lab_pin.sym} 112940 -7220 0 0 {name=p112548 lab=_44365_/X }
C {devices/lab_pin.sym} 113100 -7280 0 1 {name=p112549 lab=_44366_/X }
C {sky130_stdcells/a2bb2o_4.sym} 113020 -7280 0 0 {name=X_44366_ }
C {devices/lab_pin.sym} 112960 -7140 0 0 {name=p112550 lab=_75186_/A }
C {devices/lab_pin.sym} 112960 -7100 0 0 {name=p112551 lab=_75186_/B }
C {devices/lab_pin.sym} 113080 -7120 0 1 {name=p112552 lab=_75190_/C }
C {sky130_stdcells/nand2_4.sym} 113020 -7120 0 0 {name=X_75186_ }
C {devices/lab_pin.sym} 112960 -7000 0 0 {name=p112553 lab=_41358_/X }
C {devices/lab_pin.sym} 112960 -6960 0 0 {name=p112554 lab=_82314_/Q }
C {devices/lab_pin.sym} 113080 -6980 0 1 {name=p112555 lab=_41578_/X }
C {sky130_stdcells/or2_4.sym} 113020 -6980 0 0 {name=X_41578_ }
C {devices/lab_pin.sym} 112940 -6870 0 0 {name=p112556 lab=_72327_/X }
C {devices/lab_pin.sym} 112940 -6830 0 0 {name=p112557 lab=_85962_/Q }
C {devices/lab_pin.sym} 112940 -6790 0 0 {name=p112558 lab=_72397_/X }
C {devices/lab_pin.sym} 113100 -6830 0 1 {name=p112559 lab=_72398_/Y }
C {sky130_stdcells/o21ai_4.sym} 113020 -6830 0 0 {name=X_72398_ }
C {devices/lab_pin.sym} 112980 -6690 0 0 {name=p112560 lab=_46104_/Y }
C {devices/lab_pin.sym} 113060 -6690 0 1 {name=p112561 lab=_46214_/C }
C {sky130_stdcells/buf_2.sym} 113020 -6690 0 0 {name=X_46105_ }
C {devices/lab_pin.sym} 112940 -6610 0 0 {name=p112562 lab=_43316_/X }
C {devices/lab_pin.sym} 112940 -6570 0 0 {name=p112563 lab=_43305_/X }
C {devices/lab_pin.sym} 112940 -6530 0 0 {name=p112564 lab=_41234_/X }
C {devices/lab_pin.sym} 112940 -6490 0 0 {name=p112565 lab=_87484_/Q }
C {devices/lab_pin.sym} 112940 -6450 0 0 {name=p112566 lab=_43308_/X }
C {devices/lab_pin.sym} 113100 -6530 0 1 {name=p112567 lab=_43318_/A }
C {sky130_stdcells/o32ai_4.sym} 113020 -6530 0 0 {name=X_43317_ }
C {devices/lab_pin.sym} 112980 -6370 0 0 {name=p112568 lab=_58983_/A }
C {devices/lab_pin.sym} 113060 -6370 0 1 {name=p112569 lab=_62151_/X }
C {sky130_stdcells/buf_2.sym} 113020 -6370 0 0 {name=X_62151_ }
C {devices/lab_pin.sym} 112960 -6260 0 0 {name=p112570 lab=_74117_/A }
C {devices/lab_pin.sym} 112960 -6220 0 0 {name=p112571 lab=_74136_/Y }
C {devices/lab_pin.sym} 113080 -6240 0 1 {name=p112572 lab=_74137_/Y }
C {sky130_stdcells/nor2_4.sym} 113020 -6240 0 0 {name=X_74137_ }
C {devices/lab_pin.sym} 112940 -6140 0 0 {name=p112573 lab=_40528_/X }
C {devices/lab_pin.sym} 112940 -6100 0 0 {name=p112574 lab=_40508_/X }
C {devices/lab_pin.sym} 112940 -6060 0 0 {name=p112575 lab=_88376_/Q }
C {devices/lab_pin.sym} 112940 -6020 0 0 {name=p112576 lab=_40510_/X }
C {devices/lab_pin.sym} 113100 -6080 0 1 {name=p112577 lab=_88376_/D }
C {sky130_stdcells/a2bb2o_4.sym} 113020 -6080 0 0 {name=X_40529_ }
C {devices/lab_pin.sym} 112960 -5960 0 0 {name=p112578 lab=_47067_/A }
C {devices/lab_pin.sym} 112960 -5920 0 0 {name=p112579 lab=_47082_/X }
C {devices/lab_pin.sym} 112960 -5880 0 0 {name=p112580 lab=_47048_/C }
C {devices/lab_pin.sym} 112960 -5840 0 0 {name=p112581 lab=_52846_/D }
C {devices/lab_pin.sym} 113080 -5900 0 1 {name=p112582 lab=_47085_/X }
C {sky130_stdcells/and4_4.sym} 113020 -5900 0 0 {name=X_47085_ }
C {devices/lab_pin.sym} 112960 -5780 0 0 {name=p112583 lab=_71504_/C }
C {devices/lab_pin.sym} 112960 -5740 0 0 {name=p112584 lab=_71160_/C }
C {devices/lab_pin.sym} 112960 -5700 0 0 {name=p112585 lab=_71422_/C }
C {devices/lab_pin.sym} 112960 -5660 0 0 {name=p112586 lab=_71349_/D }
C {devices/lab_pin.sym} 113080 -5720 0 1 {name=p112587 lab=_71349_/X }
C {sky130_stdcells/and4_4.sym} 113020 -5720 0 0 {name=X_71349_ }
C {devices/lab_pin.sym} 112980 -5570 0 0 {name=p112588 lab=_68714_/A }
C {devices/lab_pin.sym} 113060 -5570 0 1 {name=p112589 lab=_69442_/A }
C {sky130_stdcells/buf_2.sym} 113020 -5570 0 0 {name=X_44297_ }
C {devices/lab_pin.sym} 112960 -5460 0 0 {name=p112590 lab=_84928_/Q }
C {devices/lab_pin.sym} 112960 -5420 0 0 {name=p112591 lab=_65817_/C }
C {devices/lab_pin.sym} 113080 -5440 0 1 {name=p112592 lab=_79994_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -5440 0 0 {name=X_79994_ }
C {devices/lab_pin.sym} 112980 -5310 0 0 {name=p112593 lab=clkbuf_9_239_0_CLK/X }
C {devices/lab_pin.sym} 113060 -5310 0 1 {name=p112594 lab=_85773_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 113020 -5310 0 0 {name=Xclkbuf_10_479_0_CLK }
C {devices/lab_pin.sym} 112980 -5190 0 0 {name=p112595 lab=_64323_/A }
C {devices/lab_pin.sym} 113060 -5190 0 1 {name=p112596 lab=_61102_/X }
C {sky130_stdcells/buf_2.sym} 113020 -5190 0 0 {name=X_61102_ }
C {devices/lab_pin.sym} 112940 -5100 0 0 {name=p112597 lab=_41484_/Y }
C {devices/lab_pin.sym} 112940 -5060 0 0 {name=p112598 lab=_46029_/X }
C {devices/lab_pin.sym} 112940 -5020 0 0 {name=p112599 lab=_66691_/B }
C {devices/lab_pin.sym} 112940 -4980 0 0 {name=p112600 lab=_46030_/X }
C {devices/lab_pin.sym} 113100 -5040 0 1 {name=p112601 lab=_46036_/X }
C {sky130_stdcells/a2bb2o_4.sym} 113020 -5040 0 0 {name=X_46036_ }
C {devices/lab_pin.sym} 112980 -4890 0 0 {name=p112602 lab=_43218_/A }
C {devices/lab_pin.sym} 113060 -4890 0 1 {name=p112603 lab=_43248_/X }
C {sky130_stdcells/buf_2.sym} 113020 -4890 0 0 {name=X_43248_ }
C {devices/lab_pin.sym} 112940 -4790 0 0 {name=p112604 lab=_59858_/A }
C {devices/lab_pin.sym} 112940 -4750 0 0 {name=p112605 lab=_61609_/X }
C {devices/lab_pin.sym} 112940 -4710 0 0 {name=p112606 lab=_62081_/X }
C {devices/lab_pin.sym} 113100 -4750 0 1 {name=p112607 lab=_62082_/X }
C {sky130_stdcells/a21o_4.sym} 113020 -4750 0 0 {name=X_62082_ }
C {devices/lab_pin.sym} 112960 -4630 0 0 {name=p112608 lab=_74066_/X }
C {devices/lab_pin.sym} 112960 -4590 0 0 {name=p112609 lab=_74055_/X }
C {devices/lab_pin.sym} 112960 -4550 0 0 {name=p112610 lab=_74057_/Y }
C {devices/lab_pin.sym} 113080 -4590 0 1 {name=p112611 lab=_74068_/Y }
C {sky130_stdcells/nand3_4.sym} 113020 -4590 0 0 {name=X_74068_ }
C {devices/lab_pin.sym} 112940 -4470 0 0 {name=p112612 lab=_78928_/A }
C {devices/lab_pin.sym} 112940 -4430 0 0 {name=p112613 lab=_82512_/D }
C {devices/lab_pin.sym} 112940 -4390 0 0 {name=p112614 lab=_78944_/Y }
C {devices/lab_pin.sym} 113100 -4430 0 1 {name=p112615 lab=_78945_/Y }
C {sky130_stdcells/a21oi_4.sym} 113020 -4430 0 0 {name=X_78945_ }
C {devices/lab_pin.sym} 112940 -4310 0 0 {name=p112616 lab=_65907_/X }
C {devices/lab_pin.sym} 112940 -4270 0 0 {name=p112617 lab=_65909_/X }
C {devices/lab_pin.sym} 112940 -4230 0 0 {name=p112618 lab=_65809_/X }
C {devices/lab_pin.sym} 113100 -4270 0 1 {name=p112619 lab=_65910_/X }
C {sky130_stdcells/a21o_4.sym} 113020 -4270 0 0 {name=X_65910_ }
C {devices/lab_pin.sym} 112960 -4140 0 0 {name=p112620 lab=_53663_/B }
C {devices/lab_pin.sym} 112960 -4100 0 0 {name=p112621 lab=_73019_/B }
C {devices/lab_pin.sym} 113080 -4120 0 1 {name=p112622 lab=_73019_/X }
C {sky130_stdcells/xor2_4.sym} 113020 -4120 0 0 {name=X_73019_ }
C {devices/lab_pin.sym} 112960 -4010 0 0 {name=p112623 lab=_60969_/X }
C {devices/lab_pin.sym} 112960 -3970 0 0 {name=p112624 lab=_61000_/X }
C {devices/lab_pin.sym} 112960 -3930 0 0 {name=p112625 lab=_84534_/Q }
C {devices/lab_pin.sym} 113080 -3970 0 1 {name=p112626 lab=_61033_/X }
C {sky130_stdcells/or3_4.sym} 113020 -3970 0 0 {name=X_61033_ }
C {devices/lab_pin.sym} 112980 -3830 0 0 {name=p112627 lab=_43178_/X }
C {devices/lab_pin.sym} 113060 -3830 0 1 {name=p112628 lab=_43180_/A }
C {sky130_stdcells/buf_2.sym} 113020 -3830 0 0 {name=X_43179_ }
C {devices/lab_pin.sym} 112940 -3740 0 0 {name=p112629 lab=_87366_/Q }
C {devices/lab_pin.sym} 112940 -3700 0 0 {name=p112630 lab=_66797_/X }
C {devices/lab_pin.sym} 112940 -3660 0 0 {name=p112631 lab=_66863_/X }
C {devices/lab_pin.sym} 112940 -3620 0 0 {name=p112632 lab=_66889_/X }
C {devices/lab_pin.sym} 113100 -3680 0 1 {name=p112633 lab=_66890_/X }
C {sky130_stdcells/a211o_4.sym} 113020 -3680 0 0 {name=X_66890_ }
C {devices/lab_pin.sym} 112960 -3540 0 0 {name=p112634 lab=_78877_/B }
C {devices/lab_pin.sym} 112960 -3500 0 0 {name=p112635 lab=_78877_/A }
C {devices/lab_pin.sym} 113080 -3520 0 1 {name=p112636 lab=_78876_/X }
C {sky130_stdcells/or2_4.sym} 113020 -3520 0 0 {name=X_78876_ }
C {devices/lab_pin.sym} 112980 -3390 0 0 {name=p112637 lab=clkbuf_9_201_0_CLK/X }
C {devices/lab_pin.sym} 113060 -3390 0 1 {name=p112638 lab=_85342_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 113020 -3390 0 0 {name=Xclkbuf_10_402_0_CLK }
C {devices/lab_pin.sym} 112960 -3290 0 0 {name=p112639 lab=_65838_/X }
C {devices/lab_pin.sym} 112960 -3250 0 0 {name=p112640 lab=_66423_/B }
C {devices/lab_pin.sym} 112960 -3210 0 0 {name=p112641 lab=_65840_/X }
C {devices/lab_pin.sym} 113080 -3250 0 1 {name=p112642 lab=_65841_/Y }
C {sky130_stdcells/nand3_4.sym} 113020 -3250 0 0 {name=X_65841_ }
C {devices/lab_pin.sym} 112960 -3120 0 0 {name=p112643 lab=_77827_/A }
C {devices/lab_pin.sym} 112960 -3080 0 0 {name=p112644 lab=_77826_/Y }
C {devices/lab_pin.sym} 113080 -3100 0 1 {name=p112645 lab=_77835_/B }
C {sky130_stdcells/xor2_4.sym} 113020 -3100 0 0 {name=X_77827_ }
C {devices/lab_pin.sym} 112980 -2970 0 0 {name=p112646 lab=_53531_/B }
C {devices/lab_pin.sym} 113060 -2970 0 1 {name=p112647 lab=_50306_/B }
C {sky130_stdcells/buf_2.sym} 113020 -2970 0 0 {name=X_47987_ }
C {devices/lab_pin.sym} 112960 -2860 0 0 {name=p112648 lab=_49716_/X }
C {devices/lab_pin.sym} 112960 -2820 0 0 {name=p112649 lab=_52940_/B }
C {devices/lab_pin.sym} 113080 -2840 0 1 {name=p112650 lab=_49726_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -2840 0 0 {name=X_49726_ }
C {devices/lab_pin.sym} 112960 -2720 0 0 {name=p112651 lab=_68560_/A }
C {devices/lab_pin.sym} 112960 -2680 0 0 {name=p112652 lab=_88364_/Q }
C {devices/lab_pin.sym} 113080 -2700 0 1 {name=p112653 lab=_68560_/X }
C {sky130_stdcells/and2_4.sym} 113020 -2700 0 0 {name=X_68560_ }
C {devices/lab_pin.sym} 112960 -2580 0 0 {name=p112654 lab=_46948_/A }
C {devices/lab_pin.sym} 112960 -2540 0 0 {name=p112655 lab=_52760_/B }
C {devices/lab_pin.sym} 113080 -2560 0 1 {name=p112656 lab=_46938_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -2560 0 0 {name=X_46938_ }
C {devices/lab_pin.sym} 112960 -2440 0 0 {name=p112657 lab=_65772_/A }
C {devices/lab_pin.sym} 112960 -2400 0 0 {name=p112658 lab=_65772_/B }
C {devices/lab_pin.sym} 113080 -2420 0 1 {name=p112659 lab=_65772_/Y }
C {sky130_stdcells/nand2_4.sym} 113020 -2420 0 0 {name=X_65772_ }
C {devices/lab_pin.sym} 112980 -2290 0 0 {name=p112660 lab=_77758_/A }
C {devices/lab_pin.sym} 113060 -2290 0 1 {name=p112661 lab=_77758_/Y }
C {sky130_stdcells/inv_2.sym} 113020 -2290 0 0 {name=X_77758_ }
C {devices/lab_pin.sym} 112940 -2210 0 0 {name=p112662 lab=_62980_/Y }
C {devices/lab_pin.sym} 112940 -2170 0 0 {name=p112663 lab=_62642_/B }
C {devices/lab_pin.sym} 112940 -2130 0 0 {name=p112664 lab=_62981_/Y }
C {devices/lab_pin.sym} 112940 -2090 0 0 {name=p112665 lab=_62982_/Y }
C {devices/lab_pin.sym} 112940 -2060 0 0 {name=p112666 lab=_62983_/X }
C {devices/lab_pin.sym} 113100 -2130 0 1 {name=p112667 lab=_62984_/X }
C {sky130_stdcells/a41o_4.sym} 113020 -2130 0 0 {name=X_62984_ }
C {devices/lab_pin.sym} 112980 -1970 0 0 {name=p112668 lab=_68392_/A }
C {devices/lab_pin.sym} 113060 -1970 0 1 {name=p112669 lab=_67987_/A }
C {sky130_stdcells/buf_2.sym} 113020 -1970 0 0 {name=X_67511_ }
C {devices/lab_pin.sym} 112980 -1850 0 0 {name=p112670 lab=_44175_/A }
C {devices/lab_pin.sym} 113060 -1850 0 1 {name=p112671 lab=_65718_/A }
C {sky130_stdcells/buf_2.sym} 113020 -1850 0 0 {name=X_64723_ }
C {devices/lab_pin.sym} 112960 -1740 0 0 {name=p112672 lab=_76696_/X }
C {devices/lab_pin.sym} 112960 -1700 0 0 {name=p112673 lab=_76709_/B }
C {devices/lab_pin.sym} 113080 -1720 0 1 {name=p112674 lab=_76709_/X }
C {sky130_stdcells/and2_4.sym} 113020 -1720 0 0 {name=X_76709_ }
C {devices/lab_pin.sym} 112980 -1590 0 0 {name=p112675 lab=_49657_/A }
C {devices/lab_pin.sym} 113060 -1590 0 1 {name=p112676 lab=_49669_/C }
C {sky130_stdcells/buf_2.sym} 113020 -1590 0 0 {name=X_49657_ }
C {devices/lab_pin.sym} 112960 -1500 0 0 {name=p112677 lab=_61490_/X }
C {devices/lab_pin.sym} 112960 -1460 0 0 {name=p112678 lab=_61933_/X }
C {devices/lab_pin.sym} 112960 -1420 0 0 {name=p112679 lab=_61907_/C }
C {devices/lab_pin.sym} 112960 -1380 0 0 {name=p112680 lab=_61952_/D }
C {devices/lab_pin.sym} 113080 -1440 0 1 {name=p112681 lab=_61935_/Y }
C {sky130_stdcells/nand4_4.sym} 113020 -1440 0 0 {name=X_61935_ }
C {devices/lab_pin.sym} 112960 -1300 0 0 {name=p112682 lab=_44149_/A }
C {devices/lab_pin.sym} 112960 -1260 0 0 {name=p112683 lab=_68491_/B }
C {devices/lab_pin.sym} 113080 -1280 0 1 {name=p112684 lab=_68491_/Y }
C {sky130_stdcells/nor2_4.sym} 113020 -1280 0 0 {name=X_68491_ }
C {devices/lab_pin.sym} 112940 -1170 0 0 {name=p112685 lab=_46864_/Y }
C {devices/lab_pin.sym} 112940 -1130 0 0 {name=p112686 lab=_46844_/X }
C {devices/lab_pin.sym} 112940 -1090 0 0 {name=p112687 lab=_46868_/X }
C {devices/lab_pin.sym} 113100 -1130 0 1 {name=p112688 lab=_86695_/D }
C {sky130_stdcells/a21oi_4.sym} 113020 -1130 0 0 {name=X_46869_ }
C {devices/lab_pin.sym} 112940 -1010 0 0 {name=p112689 lab=_77687_/Y }
C {devices/lab_pin.sym} 112940 -970 0 0 {name=p112690 lab=_77688_/Y }
C {devices/lab_pin.sym} 112940 -930 0 0 {name=p112691 lab=_77690_/B }
C {devices/lab_pin.sym} 113100 -970 0 1 {name=p112692 lab=_77689_/Y }
C {sky130_stdcells/a21oi_4.sym} 113020 -970 0 0 {name=X_77689_ }
C {devices/lab_pin.sym} 112980 -830 0 0 {name=p112693 lab=clkbuf_9_208_0_CLK/X }
C {devices/lab_pin.sym} 113060 -830 0 1 {name=p112694 lab=_82820_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 113020 -830 0 0 {name=Xclkbuf_10_417_0_CLK }
C {devices/lab_pin.sym} 112940 -730 0 0 {name=p112695 lab=_48606_/X }
C {devices/lab_pin.sym} 112940 -690 0 0 {name=p112696 lab=_81771_/Q }
C {devices/lab_pin.sym} 112940 -650 0 0 {name=p112697 lab=_48607_/Y }
C {devices/lab_pin.sym} 113100 -690 0 1 {name=p112698 lab=_48609_/A }
C {sky130_stdcells/o21ai_4.sym} 113020 -690 0 0 {name=X_48608_ }
C {devices/lab_pin.sym} 113900 -42150 0 0 {name=p112699 lab=_67203_/X }
C {devices/lab_pin.sym} 113980 -42150 0 1 {name=p112700 lab=_67442_/X }
C {sky130_stdcells/buf_2.sym} 113940 -42150 0 0 {name=X_67442_ }
C {devices/lab_pin.sym} 113880 -42040 0 0 {name=p112701 lab=_79433_/A }
C {devices/lab_pin.sym} 113880 -42000 0 0 {name=p112702 lab=_79433_/B }
C {devices/lab_pin.sym} 114000 -42020 0 1 {name=p112703 lab=_79428_/Y }
C {sky130_stdcells/xnor2_4.sym} 113940 -42020 0 0 {name=X_79428_ }
C {devices/lab_pin.sym} 113860 -41920 0 0 {name=p112704 lab=_64589_/X }
C {devices/lab_pin.sym} 113860 -41880 0 0 {name=p112705 lab=_85567_/Q }
C {devices/lab_pin.sym} 113860 -41840 0 0 {name=p112706 lab=_64591_/X }
C {devices/lab_pin.sym} 113860 -41800 0 0 {name=p112707 lab=_64653_/X }
C {devices/lab_pin.sym} 114020 -41860 0 1 {name=p112708 lab=_64654_/X }
C {sky130_stdcells/a211o_4.sym} 113940 -41860 0 0 {name=X_64654_ }
C {devices/lab_pin.sym} 113860 -41730 0 0 {name=p112709 lab=_61864_/Y }
C {devices/lab_pin.sym} 113860 -41690 0 0 {name=p112710 lab=_61801_/X }
C {devices/lab_pin.sym} 113860 -41650 0 0 {name=p112711 lab=_61865_/Y }
C {devices/lab_pin.sym} 114020 -41690 0 1 {name=p112712 lab=_61866_/Y }
C {sky130_stdcells/a21oi_4.sym} 113940 -41690 0 0 {name=X_61866_ }
C {devices/lab_pin.sym} 113880 -41580 0 0 {name=p112713 lab=_49571_/X }
C {devices/lab_pin.sym} 113880 -41540 0 0 {name=p112714 lab=_49592_/B }
C {devices/lab_pin.sym} 113880 -41500 0 0 {name=p112715 lab=_49577_/C }
C {devices/lab_pin.sym} 113880 -41460 0 0 {name=p112716 lab=_52801_/D }
C {devices/lab_pin.sym} 114000 -41520 0 1 {name=p112717 lab=_49588_/X }
C {sky130_stdcells/and4_4.sym} 113940 -41520 0 0 {name=X_49588_ }
C {devices/lab_pin.sym} 113860 -41390 0 0 {name=p112718 lab=_63603_/Y }
C {devices/lab_pin.sym} 113860 -41350 0 0 {name=p112719 lab=_63578_/X }
C {devices/lab_pin.sym} 113860 -41310 0 0 {name=p112720 lab=_63604_/Y }
C {devices/lab_pin.sym} 114020 -41350 0 1 {name=p112721 lab=_84310_/D }
C {sky130_stdcells/a21oi_4.sym} 113940 -41350 0 0 {name=X_63605_ }
C {devices/lab_pin.sym} 113880 -41230 0 0 {name=p112722 lab=_60826_/A }
C {devices/lab_pin.sym} 113880 -41190 0 0 {name=p112723 lab=_60810_/B }
C {devices/lab_pin.sym} 113880 -41150 0 0 {name=p112724 lab=_60817_/C }
C {devices/lab_pin.sym} 114000 -41190 0 1 {name=p112725 lab=_60817_/Y }
C {sky130_stdcells/nor3_4.sym} 113940 -41190 0 0 {name=X_60817_ }
C {devices/lab_pin.sym} 113900 -41050 0 0 {name=p112726 lab=_48538_/Y }
C {devices/lab_pin.sym} 113980 -41050 0 1 {name=p112727 lab=_48540_/B }
C {sky130_stdcells/buf_2.sym} 113940 -41050 0 0 {name=X_48539_ }
C {devices/lab_pin.sym} 113880 -40940 0 0 {name=p112728 lab=_79354_/X }
C {devices/lab_pin.sym} 113880 -40900 0 0 {name=p112729 lab=_79358_/Y }
C {devices/lab_pin.sym} 114000 -40920 0 1 {name=p112730 lab=_82834_/D }
C {sky130_stdcells/xor2_4.sym} 113940 -40920 0 0 {name=X_79359_ }
C {devices/lab_pin.sym} 113880 -40800 0 0 {name=p112731 lab=_67324_/A }
C {devices/lab_pin.sym} 113880 -40760 0 0 {name=p112732 lab=_67373_/B }
C {devices/lab_pin.sym} 114000 -40780 0 1 {name=p112733 lab=_67373_/X }
C {sky130_stdcells/and2_4.sym} 113940 -40780 0 0 {name=X_67373_ }
C {devices/lab_pin.sym} 113900 -40650 0 0 {name=p112734 lab=_64584_/X }
C {devices/lab_pin.sym} 113980 -40650 0 1 {name=p112735 lab=_64777_/A }
C {sky130_stdcells/buf_2.sym} 113940 -40650 0 0 {name=X_64585_ }
C {devices/lab_pin.sym} 113900 -40530 0 0 {name=p112736 lab=_61966_/A }
C {devices/lab_pin.sym} 113980 -40530 0 1 {name=p112737 lab=_61846_/C }
C {sky130_stdcells/buf_2.sym} 113940 -40530 0 0 {name=X_61797_ }
C {devices/lab_pin.sym} 113860 -40440 0 0 {name=p112738 lab=_88084_/Q }
C {devices/lab_pin.sym} 113860 -40400 0 0 {name=p112739 lab=_68883_/X }
C {devices/lab_pin.sym} 113860 -40360 0 0 {name=p112740 lab=_68884_/X }
C {devices/lab_pin.sym} 113860 -40320 0 0 {name=p112741 lab=_69111_/Y }
C {devices/lab_pin.sym} 114020 -40380 0 1 {name=p112742 lab=_69112_/X }
C {sky130_stdcells/a211o_4.sym} 113940 -40380 0 0 {name=X_69112_ }
C {devices/lab_pin.sym} 113860 -40260 0 0 {name=p112743 lab=_58697_/A }
C {devices/lab_pin.sym} 113860 -40220 0 0 {name=p112744 lab=_85604_/Q }
C {devices/lab_pin.sym} 113860 -40180 0 0 {name=p112745 lab=_66251_/X }
C {devices/lab_pin.sym} 113860 -40140 0 0 {name=p112746 lab=_66323_/X }
C {devices/lab_pin.sym} 114020 -40200 0 1 {name=p112747 lab=_66324_/X }
C {sky130_stdcells/a211o_4.sym} 113940 -40200 0 0 {name=X_66324_ }
C {devices/lab_pin.sym} 113880 -40060 0 0 {name=p112748 lab=_51545_/A }
C {devices/lab_pin.sym} 113880 -40020 0 0 {name=p112749 lab=_53076_/B }
C {devices/lab_pin.sym} 114000 -40040 0 1 {name=p112750 lab=_51550_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -40040 0 0 {name=X_51550_ }
C {devices/lab_pin.sym} 113900 -39910 0 0 {name=p112751 lab=_63413_/A }
C {devices/lab_pin.sym} 113980 -39910 0 1 {name=p112752 lab=_63537_/C }
C {sky130_stdcells/buf_2.sym} 113940 -39910 0 0 {name=X_63536_ }
C {devices/lab_pin.sym} 113850 -39790 0 0 {name=p112753 lab=_84951_/CLK }
C {devices/lab_pin.sym} 113850 -39770 0 0 {name=p112754 lab=_82178_/Q }
C {devices/lab_pin.sym} 114030 -39790 0 1 {name=p112755 lab=_82370_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -39780 0 0 {name=X_82370_ }
C {devices/lab_pin.sym} 113900 -39650 0 0 {name=p112756 lab=_60667_/A }
C {devices/lab_pin.sym} 113980 -39650 0 1 {name=p112757 lab=_60748_/X }
C {sky130_stdcells/buf_2.sym} 113940 -39650 0 0 {name=X_60748_ }
C {devices/lab_pin.sym} 113880 -39540 0 0 {name=p112758 lab=_50575_/A }
C {devices/lab_pin.sym} 113880 -39500 0 0 {name=p112759 lab=_48820_/B }
C {devices/lab_pin.sym} 114000 -39520 0 1 {name=p112760 lab=_50501_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -39520 0 0 {name=X_50501_ }
C {devices/lab_pin.sym} 113850 -39390 0 0 {name=p112761 lab=_81351_/CLK }
C {devices/lab_pin.sym} 113850 -39370 0 0 {name=p112762 lab=_81321_/D }
C {devices/lab_pin.sym} 114030 -39390 0 1 {name=p112763 lab=_81729_/D }
C {sky130_stdcells/dfxtp_4.sym} 113940 -39380 0 0 {name=X_81321_ }
C {devices/lab_pin.sym} 113860 -39280 0 0 {name=p112764 lab=_87991_/Q }
C {devices/lab_pin.sym} 113860 -39240 0 0 {name=p112765 lab=_68975_/X }
C {devices/lab_pin.sym} 113860 -39200 0 0 {name=p112766 lab=_68976_/X }
C {devices/lab_pin.sym} 113860 -39160 0 0 {name=p112767 lab=_69042_/X }
C {devices/lab_pin.sym} 114020 -39220 0 1 {name=p112768 lab=_69043_/X }
C {sky130_stdcells/a211o_4.sym} 113940 -39220 0 0 {name=X_69043_ }
C {devices/lab_pin.sym} 113900 -39070 0 0 {name=p112769 lab=clkbuf_8_91_0_CLK/A }
C {devices/lab_pin.sym} 113980 -39070 0 1 {name=p112770 lab=clkbuf_8_91_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 113940 -39070 0 0 {name=Xclkbuf_8_91_0_CLK }
C {devices/lab_pin.sym} 113900 -38950 0 0 {name=p112771 lab=_64898_/A }
C {devices/lab_pin.sym} 113980 -38950 0 1 {name=p112772 lab=_66326_/A }
C {sky130_stdcells/buf_2.sym} 113940 -38950 0 0 {name=X_66255_ }
C {devices/lab_pin.sym} 113880 -38840 0 0 {name=p112773 lab=_51481_/A }
C {devices/lab_pin.sym} 113880 -38800 0 0 {name=p112774 lab=_53005_/B }
C {devices/lab_pin.sym} 114000 -38820 0 1 {name=p112775 lab=_51481_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -38820 0 0 {name=X_51481_ }
C {devices/lab_pin.sym} 113900 -38690 0 0 {name=p112776 lab=_63528_/A }
C {devices/lab_pin.sym} 113980 -38690 0 1 {name=p112777 lab=_63517_/A }
C {sky130_stdcells/buf_2.sym} 113940 -38690 0 0 {name=X_63467_ }
C {devices/lab_pin.sym} 113900 -38570 0 0 {name=p112778 lab=_60724_/B }
C {devices/lab_pin.sym} 113980 -38570 0 1 {name=p112779 lab=_63630_/B }
C {sky130_stdcells/buf_2.sym} 113940 -38570 0 0 {name=X_60679_ }
C {devices/lab_pin.sym} 113880 -38460 0 0 {name=p112780 lab=_65206_/A }
C {devices/lab_pin.sym} 113880 -38420 0 0 {name=p112781 lab=_86442_/Q }
C {devices/lab_pin.sym} 114000 -38440 0 1 {name=p112782 lab=_65206_/X }
C {sky130_stdcells/and2_4.sym} 113940 -38440 0 0 {name=X_65206_ }
C {devices/lab_pin.sym} 113860 -38330 0 0 {name=p112783 lab=_85674_/Q }
C {devices/lab_pin.sym} 113860 -38290 0 0 {name=p112784 lab=_53198_/X }
C {devices/lab_pin.sym} 113860 -38250 0 0 {name=p112785 lab=_53219_/Y }
C {devices/lab_pin.sym} 114020 -38290 0 1 {name=p112786 lab=_53220_/Y }
C {sky130_stdcells/o21ai_4.sym} 113940 -38290 0 0 {name=X_53220_ }
C {devices/lab_pin.sym} 113850 -38150 0 0 {name=p112787 lab=_81169_/CLK }
C {devices/lab_pin.sym} 113850 -38130 0 0 {name=p112788 lab=_68095_/X }
C {devices/lab_pin.sym} 114030 -38150 0 1 {name=p112789 lab=_84040_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -38140 0 0 {name=X_84040_ }
C {devices/lab_pin.sym} 113880 -38020 0 0 {name=p112790 lab=_50432_/A }
C {devices/lab_pin.sym} 113880 -37980 0 0 {name=p112791 lab=_52137_/B }
C {devices/lab_pin.sym} 114000 -38000 0 1 {name=p112792 lab=_50432_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -38000 0 0 {name=X_50432_ }
C {devices/lab_pin.sym} 113880 -37900 0 0 {name=p112793 lab=_61502_/A }
C {devices/lab_pin.sym} 113880 -37860 0 0 {name=p112794 lab=_62472_/B }
C {devices/lab_pin.sym} 113880 -37820 0 0 {name=p112795 lab=_62386_/C }
C {devices/lab_pin.sym} 113880 -37780 0 0 {name=p112796 lab=_62431_/D }
C {devices/lab_pin.sym} 114000 -37840 0 1 {name=p112797 lab=_62421_/B }
C {sky130_stdcells/nand4_4.sym} 113940 -37840 0 0 {name=X_62418_ }
C {devices/lab_pin.sym} 113850 -37690 0 0 {name=p112798 lab=_81282_/CLK }
C {devices/lab_pin.sym} 113850 -37670 0 0 {name=p112799 lab=_81284_/Q }
C {devices/lab_pin.sym} 114030 -37690 0 1 {name=p112800 lab=_76171_/A }
C {sky130_stdcells/dfxtp_4.sym} 113940 -37680 0 0 {name=X_81252_ }
C {devices/lab_pin.sym} 113900 -37550 0 0 {name=p112801 lab=_65407_/A }
C {devices/lab_pin.sym} 113980 -37550 0 1 {name=p112802 lab=_66186_/X }
C {sky130_stdcells/buf_2.sym} 113940 -37550 0 0 {name=X_66186_ }
C {devices/lab_pin.sym} 113900 -37430 0 0 {name=p112803 lab=_63398_/A }
C {devices/lab_pin.sym} 113980 -37430 0 1 {name=p112804 lab=_63427_/A }
C {sky130_stdcells/buf_2.sym} 113940 -37430 0 0 {name=X_63398_ }
C {devices/lab_pin.sym} 113880 -37320 0 0 {name=p112805 lab=_84948_/Q }
C {devices/lab_pin.sym} 113880 -37280 0 0 {name=p112806 lab=_84196_/Q }
C {devices/lab_pin.sym} 114000 -37300 0 1 {name=p112807 lab=_80203_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -37300 0 0 {name=X_80203_ }
C {devices/lab_pin.sym} 113880 -37200 0 0 {name=p112808 lab=_53139_/A }
C {devices/lab_pin.sym} 113880 -37160 0 0 {name=p112809 lab=_53159_/B }
C {devices/lab_pin.sym} 113880 -37120 0 0 {name=p112810 lab=_53143_/X }
C {devices/lab_pin.sym} 113880 -37080 0 0 {name=p112811 lab=_53151_/D }
C {devices/lab_pin.sym} 114000 -37140 0 1 {name=p112812 lab=_53151_/X }
C {sky130_stdcells/and4_4.sym} 113940 -37140 0 0 {name=X_53151_ }
C {devices/lab_pin.sym} 113880 -37000 0 0 {name=p112813 lab=_65164_/A }
C {devices/lab_pin.sym} 113880 -36960 0 0 {name=p112814 lab=_86445_/Q }
C {devices/lab_pin.sym} 114000 -36980 0 1 {name=p112815 lab=_65137_/X }
C {sky130_stdcells/and2_4.sym} 113940 -36980 0 0 {name=X_65137_ }
C {devices/lab_pin.sym} 113900 -36850 0 0 {name=p112816 lab=_50594_/A }
C {devices/lab_pin.sym} 113980 -36850 0 1 {name=p112817 lab=_50363_/X }
C {sky130_stdcells/buf_2.sym} 113940 -36850 0 0 {name=X_50363_ }
C {devices/lab_pin.sym} 113880 -36750 0 0 {name=p112818 lab=_62632_/A }
C {devices/lab_pin.sym} 113880 -36710 0 0 {name=p112819 lab=_58506_/A }
C {devices/lab_pin.sym} 113880 -36670 0 0 {name=p112820 lab=_62632_/C }
C {devices/lab_pin.sym} 114000 -36710 0 1 {name=p112821 lab=_62351_/C }
C {sky130_stdcells/nand3_4.sym} 113940 -36710 0 0 {name=X_62349_ }
C {devices/lab_pin.sym} 113850 -36570 0 0 {name=p112822 lab=_86758_/CLK }
C {devices/lab_pin.sym} 113850 -36550 0 0 {name=p112823 lab=_75059_/X }
C {devices/lab_pin.sym} 114030 -36570 0 1 {name=p112824 lab=_81183_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -36560 0 0 {name=X_81183_ }
C {devices/lab_pin.sym} 113900 -36430 0 0 {name=p112825 lab=_51265_/A }
C {devices/lab_pin.sym} 113980 -36430 0 1 {name=p112826 lab=_52135_/B }
C {sky130_stdcells/buf_2.sym} 113940 -36430 0 0 {name=X_52102_ }
C {devices/lab_pin.sym} 113880 -36320 0 0 {name=p112827 lab=_80132_/X }
C {devices/lab_pin.sym} 113880 -36280 0 0 {name=p112828 lab=_80141_/B }
C {devices/lab_pin.sym} 114000 -36300 0 1 {name=p112829 lab=_80134_/Y }
C {sky130_stdcells/xnor2_4.sym} 113940 -36300 0 0 {name=X_80134_ }
C {devices/lab_pin.sym} 113900 -36170 0 0 {name=p112830 lab=_53111_/A }
C {devices/lab_pin.sym} 113980 -36170 0 1 {name=p112831 lab=_53082_/X }
C {sky130_stdcells/buf_2.sym} 113940 -36170 0 0 {name=X_53082_ }
C {devices/lab_pin.sym} 113860 -36080 0 0 {name=p112832 lab=_43199_/A }
C {devices/lab_pin.sym} 113860 -36040 0 0 {name=p112833 lab=_69833_/X }
C {devices/lab_pin.sym} 113860 -36000 0 0 {name=p112834 lab=_68348_/X }
C {devices/lab_pin.sym} 113860 -35960 0 0 {name=p112835 lab=_69944_/X }
C {devices/lab_pin.sym} 114020 -36020 0 1 {name=p112836 lab=_69945_/X }
C {sky130_stdcells/a211o_4.sym} 113940 -36020 0 0 {name=X_69945_ }
C {devices/lab_pin.sym} 113880 -35890 0 0 {name=p112837 lab=_65063_/X }
C {devices/lab_pin.sym} 113880 -35850 0 0 {name=p112838 lab=_65192_/B }
C {devices/lab_pin.sym} 113880 -35810 0 0 {name=p112839 lab=_65067_/X }
C {devices/lab_pin.sym} 114000 -35850 0 1 {name=p112840 lab=_65068_/Y }
C {sky130_stdcells/nand3_4.sym} 113940 -35850 0 0 {name=X_65068_ }
C {devices/lab_pin.sym} 113860 -35730 0 0 {name=p112841 lab=_86229_/Q }
C {devices/lab_pin.sym} 113860 -35690 0 0 {name=p112842 lab=_50282_/X }
C {devices/lab_pin.sym} 113860 -35650 0 0 {name=p112843 lab=_50293_/Y }
C {devices/lab_pin.sym} 114020 -35690 0 1 {name=p112844 lab=_50294_/Y }
C {sky130_stdcells/o21ai_4.sym} 113940 -35690 0 0 {name=X_50294_ }
C {devices/lab_pin.sym} 113850 -35550 0 0 {name=p112845 lab=_85700_/CLK }
C {devices/lab_pin.sym} 113850 -35530 0 0 {name=p112846 lab=_85991_/D }
C {devices/lab_pin.sym} 114030 -35550 0 1 {name=p112847 lab=_85991_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -35540 0 0 {name=X_85991_ }
C {devices/lab_pin.sym} 113900 -35410 0 0 {name=p112848 lab=_51956_/X }
C {devices/lab_pin.sym} 113980 -35410 0 1 {name=p112849 lab=_52033_/X }
C {sky130_stdcells/buf_2.sym} 113940 -35410 0 0 {name=X_52033_ }
C {devices/lab_pin.sym} 113860 -35310 0 0 {name=p112850 lab=_55218_/Y }
C {devices/lab_pin.sym} 113860 -35270 0 0 {name=p112851 lab=_56908_/X }
C {devices/lab_pin.sym} 113860 -35230 0 0 {name=p112852 lab=_56909_/Y }
C {devices/lab_pin.sym} 114020 -35270 0 1 {name=p112853 lab=_56910_/X }
C {sky130_stdcells/a21o_4.sym} 113940 -35270 0 0 {name=X_56910_ }
C {devices/lab_pin.sym} 113850 -35130 0 0 {name=p112854 lab=_82906_/CLK }
C {devices/lab_pin.sym} 113850 -35110 0 0 {name=p112855 lab=_42765_/X }
C {devices/lab_pin.sym} 114030 -35130 0 1 {name=p112856 lab=_67368_/B }
C {sky130_stdcells/dfxtp_4.sym} 113940 -35120 0 0 {name=X_87730_ }
C {devices/lab_pin.sym} 113880 -35020 0 0 {name=p112857 lab=_61541_/B }
C {devices/lab_pin.sym} 113880 -34980 0 0 {name=p112858 lab=_64052_/B }
C {devices/lab_pin.sym} 113880 -34940 0 0 {name=p112859 lab=_64003_/C }
C {devices/lab_pin.sym} 113880 -34900 0 0 {name=p112860 lab=_64052_/D }
C {devices/lab_pin.sym} 114000 -34960 0 1 {name=p112861 lab=_64019_/Y }
C {sky130_stdcells/nand4_4.sym} 113940 -34960 0 0 {name=X_64019_ }
C {devices/lab_pin.sym} 113850 -34810 0 0 {name=p112862 lab=_85489_/CLK }
C {devices/lab_pin.sym} 113850 -34790 0 0 {name=p112863 lab=_57895_/Y }
C {devices/lab_pin.sym} 114030 -34810 0 1 {name=p112864 lab=_84942_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -34800 0 0 {name=X_84942_ }
C {devices/lab_pin.sym} 113880 -34680 0 0 {name=p112865 lab=_80073_/A }
C {devices/lab_pin.sym} 113880 -34640 0 0 {name=p112866 lab=_80064_/Y }
C {devices/lab_pin.sym} 114000 -34660 0 1 {name=p112867 lab=_80065_/Y }
C {sky130_stdcells/xnor2_4.sym} 113940 -34660 0 0 {name=X_80065_ }
C {devices/lab_pin.sym} 113860 -34550 0 0 {name=p112868 lab=_57886_/Y }
C {devices/lab_pin.sym} 113860 -34510 0 0 {name=p112869 lab=_57888_/Y }
C {devices/lab_pin.sym} 113860 -34470 0 0 {name=p112870 lab=_57889_/X }
C {devices/lab_pin.sym} 114020 -34510 0 1 {name=p112871 lab=_57890_/X }
C {sky130_stdcells/a21o_4.sym} 113940 -34510 0 0 {name=X_57890_ }
C {devices/lab_pin.sym} 113860 -34390 0 0 {name=p112872 lab=_69872_/X }
C {devices/lab_pin.sym} 113860 -34350 0 0 {name=p112873 lab=_69875_/X }
C {devices/lab_pin.sym} 113860 -34310 0 0 {name=p112874 lab=_69678_/X }
C {devices/lab_pin.sym} 114020 -34350 0 1 {name=p112875 lab=_69876_/X }
C {sky130_stdcells/a21o_4.sym} 113940 -34350 0 0 {name=X_69876_ }
C {devices/lab_pin.sym} 113900 -34210 0 0 {name=p112876 lab=_56841_/A }
C {devices/lab_pin.sym} 113980 -34210 0 1 {name=p112877 lab=_85129_/D }
C {sky130_stdcells/inv_2.sym} 113940 -34210 0 0 {name=X_56841_ }
C {devices/lab_pin.sym} 113860 -34120 0 0 {name=p112878 lab=_73987_/A }
C {devices/lab_pin.sym} 113860 -34080 0 0 {name=p112879 lab=_68778_/X }
C {devices/lab_pin.sym} 113860 -34040 0 0 {name=p112880 lab=_68800_/X }
C {devices/lab_pin.sym} 113860 -34000 0 0 {name=p112881 lab=_68826_/Y }
C {devices/lab_pin.sym} 114020 -34060 0 1 {name=p112882 lab=_68827_/X }
C {sky130_stdcells/a211o_4.sym} 113940 -34060 0 0 {name=X_68827_ }
C {devices/lab_pin.sym} 113850 -33910 0 0 {name=p112883 lab=_87471_/CLK }
C {devices/lab_pin.sym} 113850 -33890 0 0 {name=p112884 lab=_42902_/X }
C {devices/lab_pin.sym} 114030 -33910 0 1 {name=p112885 lab=_87661_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -33900 0 0 {name=X_87661_ }
C {devices/lab_pin.sym} 113850 -33770 0 0 {name=p112886 lab=_84299_/CLK }
C {devices/lab_pin.sym} 113850 -33750 0 0 {name=p112887 lab=_84873_/D }
C {devices/lab_pin.sym} 114030 -33770 0 1 {name=p112888 lab=_84873_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -33760 0 0 {name=X_84873_ }
C {devices/lab_pin.sym} 113850 -33630 0 0 {name=p112889 lab=_85969_/CLK }
C {devices/lab_pin.sym} 113850 -33610 0 0 {name=p112890 lab=_86612_/D }
C {devices/lab_pin.sym} 114030 -33630 0 1 {name=p112891 lab=_86612_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -33620 0 0 {name=X_86612_ }
C {devices/lab_pin.sym} 113850 -33490 0 0 {name=p112892 lab=_83187_/CLK }
C {devices/lab_pin.sym} 113850 -33470 0 0 {name=p112893 lab=_83824_/D }
C {devices/lab_pin.sym} 114030 -33490 0 1 {name=p112894 lab=_74797_/A }
C {sky130_stdcells/dfxtp_4.sym} 113940 -33480 0 0 {name=X_83824_ }
C {devices/lab_pin.sym} 113900 -33350 0 0 {name=p112895 lab=_59560_/A }
C {devices/lab_pin.sym} 113980 -33350 0 1 {name=p112896 lab=_59890_/C }
C {sky130_stdcells/buf_2.sym} 113940 -33350 0 0 {name=X_59560_ }
C {devices/lab_pin.sym} 113900 -33230 0 0 {name=p112897 lab=_56684_/B }
C {devices/lab_pin.sym} 113980 -33230 0 1 {name=p112898 lab=_56772_/Y }
C {sky130_stdcells/inv_2.sym} 113940 -33230 0 0 {name=X_56772_ }
C {devices/lab_pin.sym} 113900 -33110 0 0 {name=p112899 lab=_69357_/A }
C {devices/lab_pin.sym} 113980 -33110 0 1 {name=p112900 lab=_68759_/A }
C {sky130_stdcells/buf_2.sym} 113940 -33110 0 0 {name=X_68758_ }
C {devices/lab_pin.sym} 113850 -32990 0 0 {name=p112901 lab=_87045_/CLK }
C {devices/lab_pin.sym} 113850 -32970 0 0 {name=p112902 lab=_87592_/D }
C {devices/lab_pin.sym} 114030 -32990 0 1 {name=p112903 lab=_43057_/A }
C {sky130_stdcells/dfxtp_4.sym} 113940 -32980 0 0 {name=X_87592_ }
C {devices/lab_pin.sym} 113860 -32870 0 0 {name=p112904 lab=_53981_/Y }
C {devices/lab_pin.sym} 113860 -32830 0 0 {name=p112905 lab=_53982_/X }
C {devices/lab_pin.sym} 113860 -32790 0 0 {name=p112906 lab=_53983_/Y }
C {devices/lab_pin.sym} 114020 -32830 0 1 {name=p112907 lab=_53984_/Y }
C {sky130_stdcells/a21boi_4.sym} 113940 -32830 0 0 {name=X_53984_ }
C {devices/lab_pin.sym} 113880 -32700 0 0 {name=p112908 lab=_58511_/A }
C {devices/lab_pin.sym} 113880 -32660 0 0 {name=p112909 lab=_58510_/X }
C {devices/lab_pin.sym} 114000 -32680 0 1 {name=p112910 lab=_58511_/Y }
C {sky130_stdcells/nor2_4.sym} 113940 -32680 0 0 {name=X_58511_ }
C {devices/lab_pin.sym} 113860 -32580 0 0 {name=p112911 lab=_56267_/C }
C {devices/lab_pin.sym} 113860 -32540 0 0 {name=p112912 lab=_55126_/A }
C {devices/lab_pin.sym} 113860 -32500 0 0 {name=p112913 lab=_55133_/X }
C {devices/lab_pin.sym} 113860 -32460 0 0 {name=p112914 lab=_55722_/X }
C {devices/lab_pin.sym} 114020 -32520 0 1 {name=p112915 lab=_55723_/X }
C {sky130_stdcells/a211o_4.sym} 113940 -32520 0 0 {name=X_55723_ }
C {devices/lab_pin.sym} 113900 -32370 0 0 {name=p112916 lab=_67014_/X }
C {devices/lab_pin.sym} 113980 -32370 0 1 {name=p112917 lab=_67709_/X }
C {sky130_stdcells/buf_2.sym} 113940 -32370 0 0 {name=X_67709_ }
C {devices/lab_pin.sym} 113850 -32250 0 0 {name=p112918 lab=_86576_/CLK }
C {devices/lab_pin.sym} 113850 -32230 0 0 {name=p112919 lab=_86543_/D }
C {devices/lab_pin.sym} 114030 -32250 0 1 {name=p112920 lab=_66171_/B }
C {sky130_stdcells/dfxtp_4.sym} 113940 -32240 0 0 {name=X_86543_ }
C {devices/lab_pin.sym} 113860 -32130 0 0 {name=p112921 lab=_52932_/Y }
C {devices/lab_pin.sym} 113860 -32090 0 0 {name=p112922 lab=_52920_/X }
C {devices/lab_pin.sym} 113860 -32050 0 0 {name=p112923 lab=_52934_/X }
C {devices/lab_pin.sym} 114020 -32090 0 1 {name=p112924 lab=_85728_/D }
C {sky130_stdcells/a21oi_4.sym} 113940 -32090 0 0 {name=X_52935_ }
C {devices/lab_pin.sym} 113860 -31970 0 0 {name=p112925 lab=_46159_/X }
C {devices/lab_pin.sym} 113860 -31930 0 0 {name=p112926 lab=_59488_/Y }
C {devices/lab_pin.sym} 113860 -31890 0 0 {name=p112927 lab=_59490_/Y }
C {devices/lab_pin.sym} 114020 -31930 0 1 {name=p112928 lab=_59491_/Y }
C {sky130_stdcells/a21oi_4.sym} 113940 -31930 0 0 {name=X_59491_ }
C {devices/lab_pin.sym} 113850 -31790 0 0 {name=p112929 lab=_83421_/CLK }
C {devices/lab_pin.sym} 113850 -31770 0 0 {name=p112930 lab=_83755_/D }
C {devices/lab_pin.sym} 114030 -31790 0 1 {name=p112931 lab=_83755_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -31780 0 0 {name=X_83755_ }
C {devices/lab_pin.sym} 113850 -31650 0 0 {name=p112932 lab=_83957_/CLK }
C {devices/lab_pin.sym} 113850 -31630 0 0 {name=p112933 lab=_80967_/D }
C {devices/lab_pin.sym} 114030 -31650 0 1 {name=p112934 lab=_80955_/D }
C {sky130_stdcells/dfxtp_4.sym} 113940 -31640 0 0 {name=X_80967_ }
C {devices/lab_pin.sym} 113860 -31540 0 0 {name=p112935 lab=_68666_/X }
C {devices/lab_pin.sym} 113860 -31500 0 0 {name=p112936 lab=_68612_/X }
C {devices/lab_pin.sym} 113860 -31460 0 0 {name=p112937 lab=_68678_/Y }
C {devices/lab_pin.sym} 113860 -31420 0 0 {name=p112938 lab=_68688_/Y }
C {devices/lab_pin.sym} 114020 -31480 0 1 {name=p112939 lab=_68689_/X }
C {sky130_stdcells/a211o_4.sym} 113940 -31480 0 0 {name=X_68689_ }
C {devices/lab_pin.sym} 113900 -31330 0 0 {name=p112940 lab=clkbuf_8_45_0_CLK/A }
C {devices/lab_pin.sym} 113980 -31330 0 1 {name=p112941 lab=clkbuf_9_88_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 113940 -31330 0 0 {name=Xclkbuf_8_44_0_CLK }
C {devices/lab_pin.sym} 113860 -31230 0 0 {name=p112942 lab=_52773_/B }
C {devices/lab_pin.sym} 113860 -31190 0 0 {name=p112943 lab=_70699_/X }
C {devices/lab_pin.sym} 113860 -31150 0 0 {name=p112944 lab=_70719_/Y }
C {devices/lab_pin.sym} 114020 -31190 0 1 {name=p112945 lab=_70720_/Y }
C {sky130_stdcells/o21ai_4.sym} 113940 -31190 0 0 {name=X_70720_ }
C {devices/lab_pin.sym} 113880 -31060 0 0 {name=p112946 lab=_58442_/A }
C {devices/lab_pin.sym} 113880 -31020 0 0 {name=p112947 lab=_58426_/X }
C {devices/lab_pin.sym} 114000 -31040 0 1 {name=p112948 lab=_58442_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -31040 0 0 {name=X_58442_ }
C {devices/lab_pin.sym} 113850 -30910 0 0 {name=p112949 lab=_82665_/CLK }
C {devices/lab_pin.sym} 113850 -30890 0 0 {name=p112950 lab=_78958_/X }
C {devices/lab_pin.sym} 114030 -30910 0 1 {name=p112951 lab=_78358_/B }
C {sky130_stdcells/dfxtp_4.sym} 113940 -30900 0 0 {name=X_82706_ }
C {devices/lab_pin.sym} 113900 -30770 0 0 {name=p112952 lab=_55654_/A }
C {devices/lab_pin.sym} 113980 -30770 0 1 {name=p112953 lab=_55654_/X }
C {sky130_stdcells/buf_2.sym} 113940 -30770 0 0 {name=X_55654_ }
C {devices/lab_pin.sym} 113850 -30650 0 0 {name=p112954 lab=_86506_/CLK }
C {devices/lab_pin.sym} 113850 -30630 0 0 {name=p112955 lab=_86474_/D }
C {devices/lab_pin.sym} 114030 -30650 0 1 {name=p112956 lab=_86474_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -30640 0 0 {name=X_86474_ }
C {devices/lab_pin.sym} 113860 -30530 0 0 {name=p112957 lab=_40877_/X }
C {devices/lab_pin.sym} 113860 -30490 0 0 {name=p112958 lab=_82860_/Q }
C {devices/lab_pin.sym} 113860 -30450 0 0 {name=p112959 lab=_40879_/X }
C {devices/lab_pin.sym} 114020 -30490 0 1 {name=p112960 lab=_40881_/A }
C {sky130_stdcells/o21ai_4.sym} 113940 -30490 0 0 {name=X_40880_ }
C {devices/lab_pin.sym} 113900 -30350 0 0 {name=p112961 lab=_52757_/A }
C {devices/lab_pin.sym} 113980 -30350 0 1 {name=p112962 lab=_52867_/A }
C {sky130_stdcells/buf_2.sym} 113940 -30350 0 0 {name=X_52866_ }
C {devices/lab_pin.sym} 113850 -30230 0 0 {name=p112963 lab=_83685_/CLK }
C {devices/lab_pin.sym} 113850 -30210 0 0 {name=p112964 lab=_70842_/Y }
C {devices/lab_pin.sym} 114030 -30230 0 1 {name=p112965 lab=_83686_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -30220 0 0 {name=X_83686_ }
C {devices/lab_pin.sym} 113850 -30090 0 0 {name=p112966 lab=_82067_/CLK }
C {devices/lab_pin.sym} 113850 -30070 0 0 {name=p112967 lab=_84074_/Q }
C {devices/lab_pin.sym} 114030 -30090 0 1 {name=p112968 lab=_75568_/A }
C {sky130_stdcells/dfxtp_4.sym} 113940 -30080 0 0 {name=X_80898_ }
C {devices/lab_pin.sym} 113850 -29950 0 0 {name=p112969 lab=_88215_/CLK }
C {devices/lab_pin.sym} 113850 -29930 0 0 {name=p112970 lab=_88213_/D }
C {devices/lab_pin.sym} 114030 -29950 0 1 {name=p112971 lab=_68047_/B }
C {sky130_stdcells/dfxtp_4.sym} 113940 -29940 0 0 {name=X_88213_ }
C {devices/lab_pin.sym} 113880 -29820 0 0 {name=p112972 lab=_54600_/A }
C {devices/lab_pin.sym} 113880 -29780 0 0 {name=p112973 lab=_53426_/B }
C {devices/lab_pin.sym} 114000 -29800 0 1 {name=p112974 lab=_54605_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -29800 0 0 {name=X_54605_ }
C {devices/lab_pin.sym} 113850 -29670 0 0 {name=p112975 lab=_85651_/CLK }
C {devices/lab_pin.sym} 113850 -29650 0 0 {name=p112976 lab=_54532_/Y }
C {devices/lab_pin.sym} 114030 -29670 0 1 {name=p112977 lab=_85425_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -29660 0 0 {name=X_85425_ }
C {devices/lab_pin.sym} 113900 -29530 0 0 {name=p112978 lab=_51789_/A }
C {devices/lab_pin.sym} 113980 -29530 0 1 {name=p112979 lab=_51817_/X }
C {sky130_stdcells/buf_2.sym} 113940 -29530 0 0 {name=X_51817_ }
C {devices/lab_pin.sym} 113900 -29410 0 0 {name=p112980 lab=_70635_/A }
C {devices/lab_pin.sym} 113980 -29410 0 1 {name=p112981 lab=_70656_/B }
C {sky130_stdcells/buf_2.sym} 113940 -29410 0 0 {name=X_70651_ }
C {devices/lab_pin.sym} 113850 -29290 0 0 {name=p112982 lab=_81746_/CLK }
C {devices/lab_pin.sym} 113850 -29270 0 0 {name=p112983 lab=_83989_/Q }
C {devices/lab_pin.sym} 114030 -29290 0 1 {name=p112984 lab=_82637_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -29280 0 0 {name=X_82637_ }
C {devices/lab_pin.sym} 113900 -29150 0 0 {name=p112985 lab=_84866_/Q }
C {devices/lab_pin.sym} 113980 -29150 0 1 {name=p112986 lab=_58374_/A }
C {sky130_stdcells/buf_2.sym} 113940 -29150 0 0 {name=X_58373_ }
C {devices/lab_pin.sym} 113880 -29040 0 0 {name=p112987 lab=_44064_/X }
C {devices/lab_pin.sym} 113880 -29000 0 0 {name=p112988 lab=_55585_/B }
C {devices/lab_pin.sym} 114000 -29020 0 1 {name=p112989 lab=_55585_/Y }
C {sky130_stdcells/nor2_4.sym} 113940 -29020 0 0 {name=X_55585_ }
C {devices/lab_pin.sym} 113880 -28920 0 0 {name=p112990 lab=_52784_/X }
C {devices/lab_pin.sym} 113880 -28880 0 0 {name=p112991 lab=_52818_/B }
C {devices/lab_pin.sym} 113880 -28840 0 0 {name=p112992 lab=_52789_/X }
C {devices/lab_pin.sym} 113880 -28800 0 0 {name=p112993 lab=_52797_/D }
C {devices/lab_pin.sym} 114000 -28860 0 1 {name=p112994 lab=_52797_/X }
C {sky130_stdcells/and4_4.sym} 113940 -28860 0 0 {name=X_52797_ }
C {sky130_stdcells/decap_3.sym} 113940 -28680 0 0 {name=XPHY_20 }
C {devices/lab_pin.sym} 113860 -28570 0 0 {name=p112995 lab=_56787_/X }
C {devices/lab_pin.sym} 113860 -28530 0 0 {name=p112996 lab=_56785_/B }
C {devices/lab_pin.sym} 113860 -28490 0 0 {name=p112997 lab=_57318_/D }
C {devices/lab_pin.sym} 113860 -28450 0 0 {name=p112998 lab=_56788_/A }
C {devices/lab_pin.sym} 113860 -28420 0 0 {name=p112999 lab=_56810_/X }
C {devices/lab_pin.sym} 114020 -28490 0 1 {name=p113000 lab=_57324_/X }
C {sky130_stdcells/a41o_4.sym} 113940 -28490 0 0 {name=X_57324_ }
C {sky130_stdcells/decap_3.sym} 113940 -28300 0 0 {name=XPHY_31 }
C {devices/lab_pin.sym} 113850 -28150 0 0 {name=p113001 lab=_88144_/CLK }
C {devices/lab_pin.sym} 113850 -28130 0 0 {name=p113002 lab=_88144_/D }
C {devices/lab_pin.sym} 114030 -28150 0 1 {name=p113003 lab=_88144_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -28140 0 0 {name=X_88144_ }
C {devices/lab_pin.sym} 113900 -28010 0 0 {name=p113004 lab=_42550_/A }
C {devices/lab_pin.sym} 113980 -28010 0 1 {name=p113005 lab=_42550_/Y }
C {sky130_stdcells/inv_2.sym} 113940 -28010 0 0 {name=X_42550_ }
C {devices/lab_pin.sym} 113900 -27890 0 0 {name=p113006 lab=_54400_/A }
C {devices/lab_pin.sym} 113980 -27890 0 1 {name=p113007 lab=_54537_/A }
C {sky130_stdcells/buf_2.sym} 113940 -27890 0 0 {name=X_54536_ }
C {devices/lab_pin.sym} 113880 -27780 0 0 {name=p113008 lab=_73370_/A }
C {devices/lab_pin.sym} 113880 -27740 0 0 {name=p113009 lab=_73370_/B }
C {devices/lab_pin.sym} 114000 -27760 0 1 {name=p113010 lab=_73370_/Y }
C {sky130_stdcells/nor2_4.sym} 113940 -27760 0 0 {name=X_73370_ }
C {devices/lab_pin.sym} 113850 -27630 0 0 {name=p113011 lab=_86282_/CLK }
C {devices/lab_pin.sym} 113850 -27610 0 0 {name=p113012 lab=_54906_/Y }
C {devices/lab_pin.sym} 114030 -27630 0 1 {name=p113013 lab=_85356_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -27620 0 0 {name=X_85356_ }
C {sky130_stdcells/decap_3.sym} 113940 -27460 0 0 {name=XPHY_42 }
C {devices/lab_pin.sym} 113900 -27310 0 0 {name=p113014 lab=_51842_/A }
C {devices/lab_pin.sym} 113980 -27310 0 1 {name=p113015 lab=_51814_/A }
C {sky130_stdcells/buf_2.sym} 113940 -27310 0 0 {name=X_51748_ }
C {devices/lab_pin.sym} 113880 -27210 0 0 {name=p113016 lab=_70576_/X }
C {devices/lab_pin.sym} 113880 -27170 0 0 {name=p113017 lab=_74515_/C }
C {devices/lab_pin.sym} 113880 -27130 0 0 {name=p113018 lab=_71735_/A }
C {devices/lab_pin.sym} 114000 -27170 0 1 {name=p113019 lab=_70582_/X }
C {sky130_stdcells/and3_4.sym} 113940 -27170 0 0 {name=X_70582_ }
C {devices/lab_pin.sym} 113850 -27030 0 0 {name=p113020 lab=_82924_/CLK }
C {devices/lab_pin.sym} 113850 -27010 0 0 {name=p113021 lab=_82568_/D }
C {devices/lab_pin.sym} 114030 -27030 0 1 {name=p113022 lab=_82568_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -27020 0 0 {name=X_82568_ }
C {sky130_stdcells/decap_3.sym} 113940 -26860 0 0 {name=XPHY_53 }
C {sky130_stdcells/decap_3.sym} 113940 -26680 0 0 {name=XPHY_64 }
C {devices/lab_pin.sym} 113900 -26530 0 0 {name=p113023 lab=clkbuf_8_59_0_CLK/A }
C {devices/lab_pin.sym} 113980 -26530 0 1 {name=p113024 lab=clkbuf_8_59_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 113940 -26530 0 0 {name=Xclkbuf_8_59_0_CLK }
C {devices/lab_pin.sym} 113880 -26420 0 0 {name=p113025 lab=_81177_/Q }
C {devices/lab_pin.sym} 113880 -26380 0 0 {name=p113026 lab=_41523_/B }
C {devices/lab_pin.sym} 114000 -26400 0 1 {name=p113027 lab=_41501_/X }
C {sky130_stdcells/or2_4.sym} 113940 -26400 0 0 {name=X_41501_ }
C {devices/lab_pin.sym} 113860 -26310 0 0 {name=p113028 lab=_72270_/X }
C {devices/lab_pin.sym} 113860 -26270 0 0 {name=p113029 lab=_72319_/Y }
C {devices/lab_pin.sym} 113860 -26230 0 0 {name=p113030 lab=_72320_/Y }
C {devices/lab_pin.sym} 113860 -26190 0 0 {name=p113031 lab=_72296_/X }
C {devices/lab_pin.sym} 113860 -26150 0 0 {name=p113032 lab=_72274_/X }
C {devices/lab_pin.sym} 114020 -26230 0 1 {name=p113033 lab=_72321_/X }
C {sky130_stdcells/o32a_4.sym} 113940 -26230 0 0 {name=X_72321_ }
C {sky130_stdcells/decap_3.sym} 113940 -26040 0 0 {name=XPHY_75 }
C {devices/lab_pin.sym} 113850 -25890 0 0 {name=p113034 lab=_84308_/CLK }
C {devices/lab_pin.sym} 113850 -25870 0 0 {name=p113035 lab=_63637_/Y }
C {devices/lab_pin.sym} 114030 -25890 0 1 {name=p113036 lab=_63636_/C }
C {sky130_stdcells/dfxtp_4.sym} 113940 -25880 0 0 {name=X_84307_ }
C {devices/lab_pin.sym} 113860 -25770 0 0 {name=p113037 lab=_56613_/X }
C {devices/lab_pin.sym} 113860 -25730 0 0 {name=p113038 lab=_57247_/Y }
C {devices/lab_pin.sym} 113860 -25690 0 0 {name=p113039 lab=_57254_/Y }
C {devices/lab_pin.sym} 114020 -25730 0 1 {name=p113040 lab=_57255_/Y }
C {sky130_stdcells/a21oi_4.sym} 113940 -25730 0 0 {name=X_57255_ }
C {devices/lab_pin.sym} 113850 -25590 0 0 {name=p113041 lab=_82642_/CLK }
C {devices/lab_pin.sym} 113850 -25570 0 0 {name=p113042 lab=_81563_/Q }
C {devices/lab_pin.sym} 114030 -25590 0 1 {name=p113043 lab=_81519_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -25580 0 0 {name=X_81519_ }
C {devices/lab_pin.sym} 113850 -25450 0 0 {name=p113044 lab=_83158_/CLK }
C {devices/lab_pin.sym} 113850 -25430 0 0 {name=p113045 lab=_42003_/Y }
C {devices/lab_pin.sym} 114030 -25450 0 1 {name=p113046 lab=_42002_/A }
C {sky130_stdcells/dfxtp_4.sym} 113940 -25440 0 0 {name=X_88075_ }
C {sky130_stdcells/decap_3.sym} 113940 -25280 0 0 {name=XPHY_86 }
C {devices/lab_pin.sym} 113860 -25170 0 0 {name=p113047 lab=_42466_/X }
C {devices/lab_pin.sym} 113860 -25130 0 0 {name=p113048 lab=_42467_/X }
C {devices/lab_pin.sym} 113860 -25090 0 0 {name=p113049 lab=_40641_/X }
C {devices/lab_pin.sym} 113860 -25050 0 0 {name=p113050 lab=_68588_/A }
C {devices/lab_pin.sym} 113860 -25010 0 0 {name=p113051 lab=_42480_/X }
C {devices/lab_pin.sym} 114020 -25090 0 1 {name=p113052 lab=_42482_/A }
C {sky130_stdcells/o32ai_4.sym} 113940 -25090 0 0 {name=X_42481_ }
C {devices/lab_pin.sym} 113880 -24960 0 0 {name=p113053 lab=_54453_/X }
C {devices/lab_pin.sym} 113880 -24920 0 0 {name=p113054 lab=_54471_/B }
C {devices/lab_pin.sym} 113880 -24880 0 0 {name=p113055 lab=_54471_/C }
C {devices/lab_pin.sym} 113880 -24840 0 0 {name=p113056 lab=_46964_/A }
C {devices/lab_pin.sym} 114000 -24900 0 1 {name=p113057 lab=_54467_/X }
C {sky130_stdcells/and4_4.sym} 113940 -24900 0 0 {name=X_54467_ }
C {devices/lab_pin.sym} 113850 -24750 0 0 {name=p113058 lab=_83013_/CLK }
C {devices/lab_pin.sym} 113850 -24730 0 0 {name=p113059 lab=_56151_/Y }
C {devices/lab_pin.sym} 114030 -24750 0 1 {name=p113060 lab=_55761_/B }
C {sky130_stdcells/dfxtp_4.sym} 113940 -24740 0 0 {name=X_85287_ }
C {devices/lab_pin.sym} 113880 -24640 0 0 {name=p113061 lab=_51657_/X }
C {devices/lab_pin.sym} 113880 -24600 0 0 {name=p113062 lab=_51684_/B }
C {devices/lab_pin.sym} 113880 -24560 0 0 {name=p113063 lab=_51684_/C }
C {devices/lab_pin.sym} 113880 -24520 0 0 {name=p113064 lab=_53203_/D }
C {devices/lab_pin.sym} 114000 -24580 0 1 {name=p113065 lab=_51679_/X }
C {sky130_stdcells/and4_4.sym} 113940 -24580 0 0 {name=X_51679_ }
C {sky130_stdcells/decap_3.sym} 113940 -24400 0 0 {name=XPHY_97 }
C {devices/lab_pin.sym} 113850 -24250 0 0 {name=p113066 lab=_82924_/CLK }
C {devices/lab_pin.sym} 113850 -24230 0 0 {name=p113067 lab=_82499_/D }
C {devices/lab_pin.sym} 114030 -24250 0 1 {name=p113068 lab=_82499_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -24240 0 0 {name=X_82499_ }
C {devices/lab_pin.sym} 113880 -24120 0 0 {name=p113069 lab=_44220_/A }
C {devices/lab_pin.sym} 113880 -24080 0 0 {name=p113070 lab=_44220_/B }
C {devices/lab_pin.sym} 114000 -24100 0 1 {name=p113071 lab=_44220_/Y }
C {sky130_stdcells/nor2_4.sym} 113940 -24100 0 0 {name=X_44220_ }
C {devices/lab_pin.sym} 113880 -23990 0 0 {name=p113072 lab=_56200_/X }
C {devices/lab_pin.sym} 113880 -23950 0 0 {name=p113073 lab=_56205_/X }
C {devices/lab_pin.sym} 113880 -23910 0 0 {name=p113074 lab=_56206_/C }
C {devices/lab_pin.sym} 114000 -23950 0 1 {name=p113075 lab=_56206_/Y }
C {sky130_stdcells/nand3_4.sym} 113940 -23950 0 0 {name=X_56206_ }
C {devices/lab_pin.sym} 113880 -23820 0 0 {name=p113076 lab=_81149_/D }
C {devices/lab_pin.sym} 113880 -23780 0 0 {name=p113077 lab=_75040_/B }
C {devices/lab_pin.sym} 114000 -23800 0 1 {name=p113078 lab=_75051_/B }
C {sky130_stdcells/nand2_4.sym} 113940 -23800 0 0 {name=X_75040_ }
C {devices/lab_pin.sym} 113850 -23670 0 0 {name=p113079 lab=_87026_/CLK }
C {devices/lab_pin.sym} 113850 -23650 0 0 {name=p113080 lab=_44631_/Y }
C {devices/lab_pin.sym} 114030 -23670 0 1 {name=p113081 lab=_87026_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -23660 0 0 {name=X_87026_ }
C {devices/lab_pin.sym} 113860 -23550 0 0 {name=p113082 lab=_41412_/X }
C {devices/lab_pin.sym} 113860 -23510 0 0 {name=p113083 lab=_82886_/Q }
C {devices/lab_pin.sym} 113860 -23470 0 0 {name=p113084 lab=_41431_/X }
C {devices/lab_pin.sym} 114020 -23510 0 1 {name=p113085 lab=_41432_/Y }
C {sky130_stdcells/o21ai_4.sym} 113940 -23510 0 0 {name=X_41432_ }
C {devices/lab_pin.sym} 113900 -23370 0 0 {name=p113086 lab=_53282_/A }
C {devices/lab_pin.sym} 113980 -23370 0 1 {name=p113087 lab=_53418_/X }
C {sky130_stdcells/buf_2.sym} 113940 -23370 0 0 {name=X_53418_ }
C {devices/lab_pin.sym} 113900 -23250 0 0 {name=p113088 lab=_57696_/X }
C {devices/lab_pin.sym} 113980 -23250 0 1 {name=p113089 lab=_72348_/B }
C {sky130_stdcells/buf_2.sym} 113940 -23250 0 0 {name=X_72252_ }
C {devices/lab_pin.sym} 113850 -23130 0 0 {name=p113090 lab=_84458_/CLK }
C {devices/lab_pin.sym} 113850 -23110 0 0 {name=p113091 lab=_64519_/X }
C {devices/lab_pin.sym} 114030 -23130 0 1 {name=p113092 lab=_79581_/B }
C {sky130_stdcells/dfxtp_4.sym} 113940 -23120 0 0 {name=X_84238_ }
C {devices/lab_pin.sym} 113880 -23000 0 0 {name=p113093 lab=_56691_/A }
C {devices/lab_pin.sym} 113880 -22960 0 0 {name=p113094 lab=_57186_/B }
C {devices/lab_pin.sym} 114000 -22980 0 1 {name=p113095 lab=_57187_/A }
C {sky130_stdcells/or2_4.sym} 113940 -22980 0 0 {name=X_57186_ }
C {devices/lab_pin.sym} 113860 -22870 0 0 {name=p113096 lab=_85449_/Q }
C {devices/lab_pin.sym} 113860 -22830 0 0 {name=p113097 lab=_54376_/X }
C {devices/lab_pin.sym} 113860 -22790 0 0 {name=p113098 lab=_54397_/Y }
C {devices/lab_pin.sym} 114020 -22830 0 1 {name=p113099 lab=_54398_/Y }
C {sky130_stdcells/o21ai_4.sym} 113940 -22830 0 0 {name=X_54398_ }
C {devices/lab_pin.sym} 113860 -22710 0 0 {name=p113100 lab=_48811_/B }
C {devices/lab_pin.sym} 113860 -22670 0 0 {name=p113101 lab=_71190_/X }
C {devices/lab_pin.sym} 113860 -22630 0 0 {name=p113102 lab=_71202_/Y }
C {devices/lab_pin.sym} 114020 -22670 0 1 {name=p113103 lab=_83574_/D }
C {sky130_stdcells/o21ai_4.sym} 113940 -22670 0 0 {name=X_71203_ }
C {devices/lab_pin.sym} 113900 -22530 0 0 {name=p113104 lab=_44150_/X }
C {devices/lab_pin.sym} 113980 -22530 0 1 {name=p113105 lab=_44151_/X }
C {sky130_stdcells/buf_2.sym} 113940 -22530 0 0 {name=X_44151_ }
C {devices/lab_pin.sym} 113860 -22430 0 0 {name=p113106 lab=_56112_/X }
C {devices/lab_pin.sym} 113860 -22390 0 0 {name=p113107 lab=_56134_/X }
C {devices/lab_pin.sym} 113860 -22350 0 0 {name=p113108 lab=_56136_/Y }
C {devices/lab_pin.sym} 114020 -22390 0 1 {name=p113109 lab=_85290_/D }
C {sky130_stdcells/o21ai_4.sym} 113940 -22390 0 0 {name=X_56137_ }
C {devices/lab_pin.sym} 113860 -22270 0 0 {name=p113110 lab=_53346_/Y }
C {devices/lab_pin.sym} 113860 -22230 0 0 {name=p113111 lab=_53328_/X }
C {devices/lab_pin.sym} 113860 -22190 0 0 {name=p113112 lab=_53348_/X }
C {devices/lab_pin.sym} 114020 -22230 0 1 {name=p113113 lab=_85650_/D }
C {sky130_stdcells/a21oi_4.sym} 113940 -22230 0 0 {name=X_53349_ }
C {devices/lab_pin.sym} 113900 -22090 0 0 {name=p113114 lab=_41253_/A }
C {devices/lab_pin.sym} 113980 -22090 0 1 {name=p113115 lab=_41363_/X }
C {sky130_stdcells/buf_2.sym} 113940 -22090 0 0 {name=X_41363_ }
C {devices/lab_pin.sym} 113860 -21990 0 0 {name=p113116 lab=_72155_/X }
C {devices/lab_pin.sym} 113860 -21950 0 0 {name=p113117 lab=_85692_/Q }
C {devices/lab_pin.sym} 113860 -21910 0 0 {name=p113118 lab=_72156_/X }
C {devices/lab_pin.sym} 114020 -21950 0 1 {name=p113119 lab=_72183_/X }
C {sky130_stdcells/o21a_4.sym} 113940 -21950 0 0 {name=X_72183_ }
C {devices/lab_pin.sym} 113850 -21810 0 0 {name=p113120 lab=_82748_/CLK }
C {devices/lab_pin.sym} 113850 -21790 0 0 {name=p113121 lab=_84169_/D }
C {devices/lab_pin.sym} 114030 -21810 0 1 {name=p113122 lab=_65916_/C }
C {sky130_stdcells/dfxtp_4.sym} 113940 -21800 0 0 {name=X_84169_ }
C {devices/lab_pin.sym} 113900 -21670 0 0 {name=p113123 lab=_43101_/Y }
C {devices/lab_pin.sym} 113980 -21670 0 1 {name=p113124 lab=_87575_/D }
C {sky130_stdcells/inv_2.sym} 113940 -21670 0 0 {name=X_43102_ }
C {devices/lab_pin.sym} 113860 -21570 0 0 {name=p113125 lab=_50721_/B }
C {devices/lab_pin.sym} 113860 -21530 0 0 {name=p113126 lab=_71117_/A }
C {devices/lab_pin.sym} 113860 -21490 0 0 {name=p113127 lab=_71133_/Y }
C {devices/lab_pin.sym} 114020 -21530 0 1 {name=p113128 lab=_71134_/Y }
C {sky130_stdcells/o21ai_4.sym} 113940 -21530 0 0 {name=X_71134_ }
C {devices/lab_pin.sym} 113900 -21390 0 0 {name=p113129 lab=_44081_/X }
C {devices/lab_pin.sym} 113980 -21390 0 1 {name=p113130 lab=_55620_/A }
C {sky130_stdcells/buf_2.sym} 113940 -21390 0 0 {name=X_44082_ }
C {devices/lab_pin.sym} 113880 -21290 0 0 {name=p113131 lab=_55995_/X }
C {devices/lab_pin.sym} 113880 -21250 0 0 {name=p113132 lab=_55863_/X }
C {devices/lab_pin.sym} 113880 -21210 0 0 {name=p113133 lab=_56073_/A }
C {devices/lab_pin.sym} 114000 -21250 0 1 {name=p113134 lab=_56068_/X }
C {sky130_stdcells/and3_4.sym} 113940 -21250 0 0 {name=X_56068_ }
C {devices/lab_pin.sym} 113900 -21110 0 0 {name=p113135 lab=_41294_/A }
C {devices/lab_pin.sym} 113980 -21110 0 1 {name=p113136 lab=_41294_/X }
C {sky130_stdcells/buf_2.sym} 113940 -21110 0 0 {name=X_41294_ }
C {devices/lab_pin.sym} 113880 -21000 0 0 {name=p113137 lab=_84543_/Q }
C {devices/lab_pin.sym} 113880 -20960 0 0 {name=p113138 lab=_84415_/Q }
C {devices/lab_pin.sym} 114000 -20980 0 1 {name=p113139 lab=_76991_/X }
C {sky130_stdcells/xor2_4.sym} 113940 -20980 0 0 {name=X_76991_ }
C {devices/lab_pin.sym} 113900 -20850 0 0 {name=p113140 lab=_47910_/A }
C {devices/lab_pin.sym} 113980 -20850 0 1 {name=p113141 lab=_57523_/B }
C {sky130_stdcells/inv_2.sym} 113940 -20850 0 0 {name=X_47910_ }
C {devices/lab_pin.sym} 113900 -20730 0 0 {name=p113142 lab=_43024_/A }
C {devices/lab_pin.sym} 113980 -20730 0 1 {name=p113143 lab=_43058_/A }
C {sky130_stdcells/buf_2.sym} 113940 -20730 0 0 {name=X_43033_ }
C {devices/lab_pin.sym} 113860 -20630 0 0 {name=p113144 lab=_55016_/Y }
C {devices/lab_pin.sym} 113860 -20590 0 0 {name=p113145 lab=_54998_/X }
C {devices/lab_pin.sym} 113860 -20550 0 0 {name=p113146 lab=_55018_/X }
C {devices/lab_pin.sym} 114020 -20590 0 1 {name=p113147 lab=_55019_/Y }
C {sky130_stdcells/a21oi_4.sym} 113940 -20590 0 0 {name=X_55019_ }
C {devices/lab_pin.sym} 113880 -20460 0 0 {name=p113148 lab=_78729_/A }
C {devices/lab_pin.sym} 113880 -20420 0 0 {name=p113149 lab=_82686_/D }
C {devices/lab_pin.sym} 114000 -20440 0 1 {name=p113150 lab=_78731_/A }
C {sky130_stdcells/nand2_4.sym} 113940 -20440 0 0 {name=X_78730_ }
C {devices/lab_pin.sym} 113860 -20330 0 0 {name=p113151 lab=_48944_/B }
C {devices/lab_pin.sym} 113860 -20290 0 0 {name=p113152 lab=_71046_/X }
C {devices/lab_pin.sym} 113860 -20250 0 0 {name=p113153 lab=_71064_/Y }
C {devices/lab_pin.sym} 114020 -20290 0 1 {name=p113154 lab=_71065_/Y }
C {sky130_stdcells/o21ai_4.sym} 113940 -20290 0 0 {name=X_71065_ }
C {devices/lab_pin.sym} 113860 -20170 0 0 {name=p113155 lab=_75936_/Y }
C {devices/lab_pin.sym} 113860 -20130 0 0 {name=p113156 lab=_75941_/Y }
C {devices/lab_pin.sym} 113860 -20090 0 0 {name=p113157 lab=_75933_/B }
C {devices/lab_pin.sym} 114020 -20130 0 1 {name=p113158 lab=_75942_/Y }
C {sky130_stdcells/a21oi_4.sym} 113940 -20130 0 0 {name=X_75942_ }
C {devices/lab_pin.sym} 113850 -19990 0 0 {name=p113159 lab=_88376_/CLK }
C {devices/lab_pin.sym} 113850 -19970 0 0 {name=p113160 lab=_87928_/D }
C {devices/lab_pin.sym} 114030 -19990 0 1 {name=p113161 lab=_87928_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -19980 0 0 {name=X_87928_ }
C {devices/lab_pin.sym} 113860 -19870 0 0 {name=p113162 lab=_86464_/Q }
C {devices/lab_pin.sym} 113860 -19830 0 0 {name=p113163 lab=_48669_/X }
C {devices/lab_pin.sym} 113860 -19790 0 0 {name=p113164 lab=_48889_/Y }
C {devices/lab_pin.sym} 114020 -19830 0 1 {name=p113165 lab=_48890_/Y }
C {sky130_stdcells/o21ai_4.sym} 113940 -19830 0 0 {name=X_48890_ }
C {devices/lab_pin.sym} 113860 -19710 0 0 {name=p113166 lab=_69689_/X }
C {devices/lab_pin.sym} 113860 -19670 0 0 {name=p113167 lab=_69692_/X }
C {devices/lab_pin.sym} 113860 -19630 0 0 {name=p113168 lab=_70001_/X }
C {devices/lab_pin.sym} 114020 -19670 0 1 {name=p113169 lab=_70016_/Y }
C {sky130_stdcells/a21oi_4.sym} 113940 -19670 0 0 {name=X_70016_ }
C {devices/lab_pin.sym} 113900 -19530 0 0 {name=p113170 lab=_47841_/A }
C {devices/lab_pin.sym} 113980 -19530 0 1 {name=p113171 lab=_47855_/A }
C {sky130_stdcells/buf_2.sym} 113940 -19530 0 0 {name=X_47841_ }
C {devices/lab_pin.sym} 113860 -19440 0 0 {name=p113172 lab=_80413_/A }
C {devices/lab_pin.sym} 113860 -19400 0 0 {name=p113173 lab=_59822_/X }
C {devices/lab_pin.sym} 113860 -19360 0 0 {name=p113174 lab=_59826_/Y }
C {devices/lab_pin.sym} 113860 -19320 0 0 {name=p113175 lab=_59812_/Y }
C {devices/lab_pin.sym} 114020 -19380 0 1 {name=p113176 lab=_84693_/D }
C {sky130_stdcells/o22a_4.sym} 113940 -19380 0 0 {name=X_59827_ }
C {devices/lab_pin.sym} 113880 -19240 0 0 {name=p113177 lab=_78661_/A }
C {devices/lab_pin.sym} 113880 -19200 0 0 {name=p113178 lab=_82694_/Q }
C {devices/lab_pin.sym} 114000 -19220 0 1 {name=p113179 lab=_78661_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -19220 0 0 {name=X_78661_ }
C {devices/lab_pin.sym} 113900 -19090 0 0 {name=p113180 lab=_75875_/C }
C {devices/lab_pin.sym} 113980 -19090 0 1 {name=p113181 lab=_75873_/Y }
C {sky130_stdcells/inv_2.sym} 113940 -19090 0 0 {name=X_75873_ }
C {devices/lab_pin.sym} 113850 -18970 0 0 {name=p113182 lab=_87859_/CLK }
C {devices/lab_pin.sym} 113850 -18950 0 0 {name=p113183 lab=_87859_/D }
C {devices/lab_pin.sym} 114030 -18970 0 1 {name=p113184 lab=_68361_/A }
C {sky130_stdcells/dfxtp_4.sym} 113940 -18960 0 0 {name=X_87859_ }
C {devices/lab_pin.sym} 113880 -18840 0 0 {name=p113185 lab=_77612_/A }
C {devices/lab_pin.sym} 113880 -18800 0 0 {name=p113186 lab=_82108_/D }
C {devices/lab_pin.sym} 114000 -18820 0 1 {name=p113187 lab=_77612_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -18820 0 0 {name=X_77612_ }
C {devices/lab_pin.sym} 113900 -18690 0 0 {name=p113188 lab=_74824_/A }
C {devices/lab_pin.sym} 113980 -18690 0 1 {name=p113189 lab=_80661_/D }
C {sky130_stdcells/inv_2.sym} 113940 -18690 0 0 {name=X_74824_ }
C {devices/lab_pin.sym} 113900 -18570 0 0 {name=p113190 lab=_47771_/Y }
C {devices/lab_pin.sym} 113980 -18570 0 1 {name=p113191 lab=_53236_/B }
C {sky130_stdcells/buf_2.sym} 113940 -18570 0 0 {name=X_47772_ }
C {devices/lab_pin.sym} 113900 -18450 0 0 {name=p113192 lab=_59687_/Y }
C {devices/lab_pin.sym} 113980 -18450 0 1 {name=p113193 lab=_59758_/X }
C {sky130_stdcells/buf_2.sym} 113940 -18450 0 0 {name=X_59758_ }
C {devices/lab_pin.sym} 113860 -18350 0 0 {name=p113194 lab=_78600_/A }
C {devices/lab_pin.sym} 113860 -18310 0 0 {name=p113195 lab=_78581_/B }
C {devices/lab_pin.sym} 113860 -18270 0 0 {name=p113196 lab=_78575_/B }
C {devices/lab_pin.sym} 114020 -18310 0 1 {name=p113197 lab=_78593_/B }
C {sky130_stdcells/o21ai_4.sym} 113940 -18310 0 0 {name=X_78592_ }
C {devices/lab_pin.sym} 113860 -18190 0 0 {name=p113198 lab=_56390_/C }
C {devices/lab_pin.sym} 113860 -18150 0 0 {name=p113199 lab=_44945_/X }
C {devices/lab_pin.sym} 113860 -18110 0 0 {name=p113200 lab=_44983_/X }
C {devices/lab_pin.sym} 114020 -18150 0 1 {name=p113201 lab=_44984_/Y }
C {sky130_stdcells/o21ai_4.sym} 113940 -18150 0 0 {name=X_44984_ }
C {devices/lab_pin.sym} 113860 -18030 0 0 {name=p113202 lab=_49509_/Y }
C {devices/lab_pin.sym} 113860 -17990 0 0 {name=p113203 lab=_49487_/X }
C {devices/lab_pin.sym} 113860 -17950 0 0 {name=p113204 lab=_49510_/X }
C {devices/lab_pin.sym} 114020 -17990 0 1 {name=p113205 lab=_86374_/D }
C {sky130_stdcells/a21oi_4.sym} 113940 -17990 0 0 {name=X_49511_ }
C {devices/lab_pin.sym} 113880 -17860 0 0 {name=p113206 lab=_46733_/A }
C {devices/lab_pin.sym} 113880 -17820 0 0 {name=p113207 lab=_51807_/B }
C {devices/lab_pin.sym} 114000 -17840 0 1 {name=p113208 lab=_46723_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -17840 0 0 {name=X_46723_ }
C {devices/lab_pin.sym} 113860 -17730 0 0 {name=p113209 lab=_58705_/Y }
C {devices/lab_pin.sym} 113860 -17690 0 0 {name=p113210 lab=_58708_/Y }
C {devices/lab_pin.sym} 113860 -17650 0 0 {name=p113211 lab=_58610_/X }
C {devices/lab_pin.sym} 114020 -17690 0 1 {name=p113212 lab=_58709_/X }
C {sky130_stdcells/a21o_4.sym} 113940 -17690 0 0 {name=X_58709_ }
C {devices/lab_pin.sym} 113880 -17560 0 0 {name=p113213 lab=_77561_/C }
C {devices/lab_pin.sym} 113880 -17520 0 0 {name=p113214 lab=_77561_/D }
C {devices/lab_pin.sym} 114000 -17540 0 1 {name=p113215 lab=_77547_/A }
C {sky130_stdcells/nand2_4.sym} 113940 -17540 0 0 {name=X_77543_ }
C {devices/lab_pin.sym} 113860 -17440 0 0 {name=p113216 lab=_41437_/X }
C {devices/lab_pin.sym} 113860 -17400 0 0 {name=p113217 lab=_43928_/X }
C {devices/lab_pin.sym} 113860 -17360 0 0 {name=p113218 lab=_68000_/B }
C {devices/lab_pin.sym} 113860 -17320 0 0 {name=p113219 lab=_43929_/X }
C {devices/lab_pin.sym} 114020 -17380 0 1 {name=p113220 lab=_87191_/D }
C {sky130_stdcells/a2bb2o_4.sym} 113940 -17380 0 0 {name=X_43935_ }
C {devices/lab_pin.sym} 113880 -17250 0 0 {name=p113221 lab=_70586_/X }
C {devices/lab_pin.sym} 113880 -17210 0 0 {name=p113222 lab=_74755_/B }
C {devices/lab_pin.sym} 113880 -17170 0 0 {name=p113223 lab=_74753_/X }
C {devices/lab_pin.sym} 114000 -17210 0 1 {name=p113224 lab=_74755_/X }
C {sky130_stdcells/and3_4.sym} 113940 -17210 0 0 {name=X_74755_ }
C {devices/lab_pin.sym} 113880 -17080 0 0 {name=p113225 lab=_71972_/A }
C {devices/lab_pin.sym} 113880 -17040 0 0 {name=p113226 lab=_48899_/Y }
C {devices/lab_pin.sym} 114000 -17060 0 1 {name=p113227 lab=_71967_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -17060 0 0 {name=X_71967_ }
C {devices/lab_pin.sym} 113880 -16940 0 0 {name=p113228 lab=_59689_/A }
C {devices/lab_pin.sym} 113880 -16900 0 0 {name=p113229 lab=_59689_/B }
C {devices/lab_pin.sym} 114000 -16920 0 1 {name=p113230 lab=_59689_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -16920 0 0 {name=X_59689_ }
C {devices/lab_pin.sym} 113860 -16830 0 0 {name=p113231 lab=_61703_/X }
C {devices/lab_pin.sym} 113860 -16790 0 0 {name=p113232 lab=_61715_/Y }
C {devices/lab_pin.sym} 113860 -16750 0 0 {name=p113233 lab=_61717_/X }
C {devices/lab_pin.sym} 113860 -16710 0 0 {name=p113234 lab=_58147_/A }
C {devices/lab_pin.sym} 113860 -16670 0 0 {name=p113235 lab=_61719_/X }
C {devices/lab_pin.sym} 114020 -16750 0 1 {name=p113236 lab=_61720_/Y }
C {sky130_stdcells/o32ai_4.sym} 113940 -16750 0 0 {name=X_61720_ }
C {devices/lab_pin.sym} 113860 -16610 0 0 {name=p113237 lab=_49439_/Y }
C {devices/lab_pin.sym} 113860 -16570 0 0 {name=p113238 lab=_49434_/X }
C {devices/lab_pin.sym} 113860 -16530 0 0 {name=p113239 lab=_49441_/X }
C {devices/lab_pin.sym} 114020 -16570 0 1 {name=p113240 lab=_49442_/Y }
C {sky130_stdcells/a21oi_4.sym} 113940 -16570 0 0 {name=X_49442_ }
C {devices/lab_pin.sym} 113860 -16450 0 0 {name=p113241 lab=_44684_/Y }
C {devices/lab_pin.sym} 113860 -16410 0 0 {name=p113242 lab=_73420_/X }
C {devices/lab_pin.sym} 113860 -16370 0 0 {name=p113243 lab=_73705_/Y }
C {devices/lab_pin.sym} 114020 -16410 0 1 {name=p113244 lab=_73719_/C }
C {sky130_stdcells/a21o_4.sym} 113940 -16410 0 0 {name=X_73706_ }
C {devices/lab_pin.sym} 113900 -16270 0 0 {name=p113245 lab=_70913_/A }
C {devices/lab_pin.sym} 113980 -16270 0 1 {name=p113246 lab=_70919_/D }
C {sky130_stdcells/buf_2.sym} 113940 -16270 0 0 {name=X_70918_ }
C {devices/lab_pin.sym} 113900 -16150 0 0 {name=p113247 lab=_46751_/A }
C {devices/lab_pin.sym} 113980 -16150 0 1 {name=p113248 lab=_46654_/X }
C {sky130_stdcells/buf_2.sym} 113940 -16150 0 0 {name=X_46654_ }
C {devices/lab_pin.sym} 113860 -16050 0 0 {name=p113249 lab=_77475_/A }
C {devices/lab_pin.sym} 113860 -16010 0 0 {name=p113250 lab=_77475_/B }
C {devices/lab_pin.sym} 113860 -15970 0 0 {name=p113251 lab=_77473_/Y }
C {devices/lab_pin.sym} 114020 -16010 0 1 {name=p113252 lab=_77478_/B }
C {sky130_stdcells/o21a_4.sym} 113940 -16010 0 0 {name=X_77474_ }
C {devices/lab_pin.sym} 113860 -15910 0 0 {name=p113253 lab=_43862_/X }
C {devices/lab_pin.sym} 113860 -15870 0 0 {name=p113254 lab=_43854_/X }
C {devices/lab_pin.sym} 113860 -15830 0 0 {name=p113255 lab=_41245_/X }
C {devices/lab_pin.sym} 113860 -15790 0 0 {name=p113256 lab=_87227_/Q }
C {devices/lab_pin.sym} 113860 -15750 0 0 {name=p113257 lab=_43863_/X }
C {devices/lab_pin.sym} 114020 -15830 0 1 {name=p113258 lab=_43867_/A }
C {sky130_stdcells/o32ai_4.sym} 113940 -15830 0 0 {name=X_43866_ }
C {devices/lab_pin.sym} 113860 -15690 0 0 {name=p113259 lab=_82985_/Q }
C {devices/lab_pin.sym} 113860 -15650 0 0 {name=p113260 lab=_74656_/X }
C {devices/lab_pin.sym} 113860 -15610 0 0 {name=p113261 lab=_74685_/Y }
C {devices/lab_pin.sym} 114020 -15650 0 1 {name=p113262 lab=_74687_/A }
C {sky130_stdcells/o21ai_4.sym} 113940 -15650 0 0 {name=X_74686_ }
C {devices/lab_pin.sym} 113880 -15540 0 0 {name=p113263 lab=_70374_/X }
C {devices/lab_pin.sym} 113880 -15500 0 0 {name=p113264 lab=_71893_/X }
C {devices/lab_pin.sym} 113880 -15460 0 0 {name=p113265 lab=_71755_/X }
C {devices/lab_pin.sym} 113880 -15420 0 0 {name=p113266 lab=_71898_/D }
C {devices/lab_pin.sym} 114000 -15480 0 1 {name=p113267 lab=_71898_/Y }
C {sky130_stdcells/nand4_4.sym} 113940 -15480 0 0 {name=X_71898_ }
C {devices/lab_pin.sym} 113880 -15340 0 0 {name=p113268 lab=_79213_/A }
C {devices/lab_pin.sym} 113880 -15300 0 0 {name=p113269 lab=_79212_/Y }
C {devices/lab_pin.sym} 114000 -15320 0 1 {name=p113270 lab=_79213_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -15320 0 0 {name=X_79213_ }
C {devices/lab_pin.sym} 113860 -15210 0 0 {name=p113271 lab=_85140_/Q }
C {devices/lab_pin.sym} 113860 -15170 0 0 {name=p113272 lab=_45464_/X }
C {devices/lab_pin.sym} 113860 -15130 0 0 {name=p113273 lab=_44964_/X }
C {devices/lab_pin.sym} 114020 -15170 0 1 {name=p113274 lab=_45605_/Y }
C {sky130_stdcells/o21ai_4.sym} 113940 -15170 0 0 {name=X_45605_ }
C {devices/lab_pin.sym} 113860 -15050 0 0 {name=p113275 lab=_76408_/Y }
C {devices/lab_pin.sym} 113860 -15010 0 0 {name=p113276 lab=_76409_/Y }
C {devices/lab_pin.sym} 113860 -14970 0 0 {name=p113277 lab=_76410_/Y }
C {devices/lab_pin.sym} 114020 -15010 0 1 {name=p113278 lab=_76425_/X }
C {sky130_stdcells/o21a_4.sym} 113940 -15010 0 0 {name=X_76425_ }
C {devices/lab_pin.sym} 113900 -14870 0 0 {name=p113279 lab=_42723_/A }
C {devices/lab_pin.sym} 113980 -14870 0 1 {name=p113280 lab=_42817_/X }
C {sky130_stdcells/buf_2.sym} 113940 -14870 0 0 {name=X_42817_ }
C {devices/lab_pin.sym} 113860 -14770 0 0 {name=p113281 lab=_58587_/B }
C {devices/lab_pin.sym} 113860 -14730 0 0 {name=p113282 lab=_49360_/X }
C {devices/lab_pin.sym} 113860 -14690 0 0 {name=p113283 lab=_49372_/Y }
C {devices/lab_pin.sym} 114020 -14730 0 1 {name=p113284 lab=_49373_/Y }
C {sky130_stdcells/o21ai_4.sym} 113940 -14730 0 0 {name=X_49373_ }
C {devices/lab_pin.sym} 113900 -14590 0 0 {name=p113285 lab=_61400_/X }
C {devices/lab_pin.sym} 113980 -14590 0 1 {name=p113286 lab=_61675_/C }
C {sky130_stdcells/buf_2.sym} 113940 -14590 0 0 {name=X_61651_ }
C {devices/lab_pin.sym} 113860 -14500 0 0 {name=p113287 lab=_73605_/X }
C {devices/lab_pin.sym} 113860 -14460 0 0 {name=p113288 lab=_86238_/Q }
C {devices/lab_pin.sym} 113860 -14420 0 0 {name=p113289 lab=_44194_/X }
C {devices/lab_pin.sym} 113860 -14380 0 0 {name=p113290 lab=_73636_/X }
C {devices/lab_pin.sym} 114020 -14440 0 1 {name=p113291 lab=_73637_/X }
C {sky130_stdcells/a211o_4.sym} 113940 -14440 0 0 {name=X_73637_ }
C {devices/lab_pin.sym} 113900 -14290 0 0 {name=p113292 lab=_83779_/Q }
C {devices/lab_pin.sym} 113980 -14290 0 1 {name=p113293 lab=_46585_/Y }
C {sky130_stdcells/inv_2.sym} 113940 -14290 0 0 {name=X_46585_ }
C {devices/lab_pin.sym} 113880 -14200 0 0 {name=p113294 lab=_70903_/A }
C {devices/lab_pin.sym} 113880 -14160 0 0 {name=p113295 lab=_70890_/B }
C {devices/lab_pin.sym} 113880 -14120 0 0 {name=p113296 lab=_70849_/C }
C {devices/lab_pin.sym} 113880 -14080 0 0 {name=p113297 lab=_70860_/D }
C {devices/lab_pin.sym} 114000 -14140 0 1 {name=p113298 lab=_70849_/Y }
C {sky130_stdcells/nand4_4.sym} 113940 -14140 0 0 {name=X_70849_ }
C {devices/lab_pin.sym} 113900 -13990 0 0 {name=p113299 lab=_43760_/A }
C {devices/lab_pin.sym} 113980 -13990 0 1 {name=p113300 lab=_43797_/X }
C {sky130_stdcells/buf_2.sym} 113940 -13990 0 0 {name=X_43797_ }
C {devices/lab_pin.sym} 113900 -13870 0 0 {name=p113301 lab=_48112_/B }
C {devices/lab_pin.sym} 113980 -13870 0 1 {name=p113302 lab=_50368_/B }
C {sky130_stdcells/buf_2.sym} 113940 -13870 0 0 {name=X_48324_ }
C {devices/lab_pin.sym} 113880 -13770 0 0 {name=p113303 lab=_60488_/B }
C {devices/lab_pin.sym} 113880 -13730 0 0 {name=p113304 lab=_60602_/B }
C {devices/lab_pin.sym} 113880 -13690 0 0 {name=p113305 lab=_60421_/B }
C {devices/lab_pin.sym} 114000 -13730 0 1 {name=p113306 lab=_60603_/C }
C {sky130_stdcells/nand3_4.sym} 113940 -13730 0 0 {name=X_60602_ }
C {devices/lab_pin.sym} 113880 -13600 0 0 {name=p113307 lab=_79144_/A }
C {devices/lab_pin.sym} 113880 -13560 0 0 {name=p113308 lab=_84476_/Q }
C {devices/lab_pin.sym} 114000 -13580 0 1 {name=p113309 lab=_79144_/X }
C {sky130_stdcells/xor2_4.sym} 113940 -13580 0 0 {name=X_79144_ }
C {devices/lab_pin.sym} 113860 -13480 0 0 {name=p113310 lab=_45533_/Y }
C {devices/lab_pin.sym} 113860 -13440 0 0 {name=p113311 lab=_45516_/X }
C {devices/lab_pin.sym} 113860 -13400 0 0 {name=p113312 lab=_45471_/X }
C {devices/lab_pin.sym} 113860 -13360 0 0 {name=p113313 lab=_45535_/Y }
C {devices/lab_pin.sym} 114020 -13420 0 1 {name=p113314 lab=_45536_/X }
C {sky130_stdcells/a211o_4.sym} 113940 -13420 0 0 {name=X_45536_ }
C {devices/lab_pin.sym} 113860 -13310 0 0 {name=p113315 lab=_64363_/X }
C {devices/lab_pin.sym} 113860 -13270 0 0 {name=p113316 lab=_64364_/X }
C {devices/lab_pin.sym} 113860 -13230 0 0 {name=p113317 lab=_64366_/X }
C {devices/lab_pin.sym} 113860 -13190 0 0 {name=p113318 lab=_64369_/Y }
C {devices/lab_pin.sym} 113860 -13150 0 0 {name=p113319 lab=_64326_/X }
C {devices/lab_pin.sym} 114020 -13230 0 1 {name=p113320 lab=_64370_/X }
C {sky130_stdcells/o41a_4.sym} 113940 -13230 0 0 {name=X_64370_ }
C {devices/lab_pin.sym} 113880 -13080 0 0 {name=p113321 lab=_76356_/A }
C {devices/lab_pin.sym} 113880 -13040 0 0 {name=p113322 lab=_76325_/A }
C {devices/lab_pin.sym} 114000 -13060 0 1 {name=p113323 lab=_76356_/Y }
C {sky130_stdcells/nor2_4.sym} 113940 -13060 0 0 {name=X_76356_ }
C {devices/lab_pin.sym} 113860 -12970 0 0 {name=p113324 lab=_42739_/X }
C {devices/lab_pin.sym} 113860 -12930 0 0 {name=p113325 lab=_42740_/X }
C {devices/lab_pin.sym} 113860 -12890 0 0 {name=p113326 lab=_41234_/X }
C {devices/lab_pin.sym} 113860 -12850 0 0 {name=p113327 lab=_68941_/B }
C {devices/lab_pin.sym} 113860 -12810 0 0 {name=p113328 lab=_42732_/X }
C {devices/lab_pin.sym} 114020 -12890 0 1 {name=p113329 lab=_42749_/A }
C {sky130_stdcells/o32ai_4.sym} 113940 -12890 0 0 {name=X_42748_ }
C {devices/lab_pin.sym} 113880 -12760 0 0 {name=p113330 lab=_61582_/A }
C {devices/lab_pin.sym} 113880 -12720 0 0 {name=p113331 lab=_72550_/A }
C {devices/lab_pin.sym} 113880 -12680 0 0 {name=p113332 lab=_72506_/C }
C {devices/lab_pin.sym} 113880 -12640 0 0 {name=p113333 lab=_61367_/D }
C {devices/lab_pin.sym} 114000 -12700 0 1 {name=p113334 lab=_61582_/Y }
C {sky130_stdcells/nand4_4.sym} 113940 -12700 0 0 {name=X_61582_ }
C {devices/lab_pin.sym} 113880 -12560 0 0 {name=p113335 lab=_73588_/A }
C {devices/lab_pin.sym} 113880 -12520 0 0 {name=p113336 lab=_73568_/B }
C {devices/lab_pin.sym} 114000 -12540 0 1 {name=p113337 lab=_73568_/X }
C {sky130_stdcells/and2_4.sym} 113940 -12540 0 0 {name=X_73568_ }
C {devices/lab_pin.sym} 113860 -12450 0 0 {name=p113338 lab=_59436_/Y }
C {devices/lab_pin.sym} 113860 -12410 0 0 {name=p113339 lab=_63259_/X }
C {devices/lab_pin.sym} 113860 -12370 0 0 {name=p113340 lab=_63234_/X }
C {devices/lab_pin.sym} 113860 -12330 0 0 {name=p113341 lab=_58985_/A }
C {devices/lab_pin.sym} 113860 -12290 0 0 {name=p113342 lab=_63235_/X }
C {devices/lab_pin.sym} 114020 -12370 0 1 {name=p113343 lab=_63321_/Y }
C {sky130_stdcells/o32ai_4.sym} 113940 -12370 0 0 {name=X_63321_ }
C {devices/lab_pin.sym} 113860 -12230 0 0 {name=p113344 lab=_75305_/X }
C {devices/lab_pin.sym} 113860 -12190 0 0 {name=p113345 lab=_75276_/Y }
C {devices/lab_pin.sym} 113860 -12150 0 0 {name=p113346 lab=_75306_/Y }
C {devices/lab_pin.sym} 114020 -12190 0 1 {name=p113347 lab=_75307_/X }
C {sky130_stdcells/a21o_4.sym} 113940 -12190 0 0 {name=X_75307_ }
C {devices/lab_pin.sym} 113860 -12070 0 0 {name=p113348 lab=_66119_/B }
C {devices/lab_pin.sym} 113860 -12030 0 0 {name=p113349 lab=_48241_/X }
C {devices/lab_pin.sym} 113860 -11990 0 0 {name=p113350 lab=_48254_/Y }
C {devices/lab_pin.sym} 114020 -12030 0 1 {name=p113351 lab=_48255_/Y }
C {sky130_stdcells/o21ai_4.sym} 113940 -12030 0 0 {name=X_48255_ }
C {devices/lab_pin.sym} 113900 -11890 0 0 {name=p113352 lab=_60442_/C }
C {devices/lab_pin.sym} 113980 -11890 0 1 {name=p113353 lab=_60533_/Y }
C {sky130_stdcells/inv_2.sym} 113940 -11890 0 0 {name=X_60533_ }
C {devices/lab_pin.sym} 113900 -11770 0 0 {name=p113354 lab=_72555_/B }
C {devices/lab_pin.sym} 113980 -11770 0 1 {name=p113355 lab=_72597_/C }
C {sky130_stdcells/buf_2.sym} 113940 -11770 0 0 {name=X_72519_ }
C {devices/lab_pin.sym} 113900 -11650 0 0 {name=p113356 lab=_79087_/B }
C {devices/lab_pin.sym} 113980 -11650 0 1 {name=p113357 lab=_79075_/Y }
C {sky130_stdcells/inv_2.sym} 113940 -11650 0 0 {name=X_79075_ }
C {devices/lab_pin.sym} 113900 -11530 0 0 {name=p113358 lab=_63051_/B }
C {devices/lab_pin.sym} 113980 -11530 0 1 {name=p113359 lab=_61378_/A }
C {sky130_stdcells/buf_2.sym} 113940 -11530 0 0 {name=X_45467_ }
C {devices/lab_pin.sym} 113880 -11420 0 0 {name=p113360 lab=_81355_/Q }
C {devices/lab_pin.sym} 113880 -11380 0 0 {name=p113361 lab=_81611_/D }
C {devices/lab_pin.sym} 114000 -11400 0 1 {name=p113362 lab=_76287_/X }
C {sky130_stdcells/xor2_4.sym} 113940 -11400 0 0 {name=X_76287_ }
C {devices/lab_pin.sym} 113900 -11270 0 0 {name=p113363 lab=_42651_/X }
C {devices/lab_pin.sym} 113980 -11270 0 1 {name=p113364 lab=_42679_/X }
C {sky130_stdcells/buf_2.sym} 113940 -11270 0 0 {name=X_42679_ }
C {devices/lab_pin.sym} 113860 -11170 0 0 {name=p113365 lab=_73496_/X }
C {devices/lab_pin.sym} 113860 -11130 0 0 {name=p113366 lab=_73498_/X }
C {devices/lab_pin.sym} 113860 -11090 0 0 {name=p113367 lab=_73383_/X }
C {devices/lab_pin.sym} 114020 -11130 0 1 {name=p113368 lab=_73502_/A }
C {sky130_stdcells/a21o_4.sym} 113940 -11130 0 0 {name=X_73499_ }
C {devices/lab_pin.sym} 113880 -11000 0 0 {name=p113369 lab=_47196_/A }
C {devices/lab_pin.sym} 113880 -10960 0 0 {name=p113370 lab=_51222_/B }
C {devices/lab_pin.sym} 114000 -10980 0 1 {name=p113371 lab=_47206_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -10980 0 0 {name=X_47206_ }
C {devices/lab_pin.sym} 113900 -10850 0 0 {name=p113372 lab=_65595_/X }
C {devices/lab_pin.sym} 113980 -10850 0 1 {name=p113373 lab=_66040_/X }
C {sky130_stdcells/buf_2.sym} 113940 -10850 0 0 {name=X_66040_ }
C {devices/lab_pin.sym} 113900 -10730 0 0 {name=p113374 lab=_78025_/X }
C {devices/lab_pin.sym} 113980 -10730 0 1 {name=p113375 lab=_78027_/B }
C {sky130_stdcells/inv_2.sym} 113940 -10730 0 0 {name=X_78026_ }
C {devices/lab_pin.sym} 113900 -10610 0 0 {name=p113376 lab=_44418_/A }
C {devices/lab_pin.sym} 113980 -10610 0 1 {name=p113377 lab=_87119_/D }
C {sky130_stdcells/inv_2.sym} 113940 -10610 0 0 {name=X_44418_ }
C {devices/lab_pin.sym} 113880 -10520 0 0 {name=p113378 lab=_61580_/X }
C {devices/lab_pin.sym} 113880 -10480 0 0 {name=p113379 lab=_63252_/B }
C {devices/lab_pin.sym} 113880 -10440 0 0 {name=p113380 lab=_60602_/B }
C {devices/lab_pin.sym} 113880 -10400 0 0 {name=p113381 lab=_60570_/C }
C {devices/lab_pin.sym} 114000 -10460 0 1 {name=p113382 lab=_63252_/Y }
C {sky130_stdcells/nand4_4.sym} 113940 -10460 0 0 {name=X_63252_ }
C {devices/lab_pin.sym} 113900 -10310 0 0 {name=p113383 lab=_81070_/Q }
C {devices/lab_pin.sym} 113980 -10310 0 1 {name=p113384 lab=_75240_/A }
C {sky130_stdcells/inv_2.sym} 113940 -10310 0 0 {name=X_75238_ }
C {devices/lab_pin.sym} 113900 -10190 0 0 {name=p113385 lab=_48186_/A }
C {devices/lab_pin.sym} 113980 -10190 0 1 {name=p113386 lab=_48535_/A }
C {sky130_stdcells/buf_2.sym} 113940 -10190 0 0 {name=X_48186_ }
C {devices/lab_pin.sym} 113900 -10070 0 0 {name=p113387 lab=_60515_/C }
C {devices/lab_pin.sym} 113980 -10070 0 1 {name=p113388 lab=_60476_/C }
C {sky130_stdcells/buf_2.sym} 113940 -10070 0 0 {name=X_60464_ }
C {devices/lab_pin.sym} 113880 -9960 0 0 {name=p113389 lab=_85057_/Q }
C {devices/lab_pin.sym} 113880 -9920 0 0 {name=p113390 lab=_45397_/X }
C {devices/lab_pin.sym} 114000 -9940 0 1 {name=p113391 lab=_45398_/Y }
C {sky130_stdcells/nor2_4.sym} 113940 -9940 0 0 {name=X_45398_ }
C {devices/lab_pin.sym} 113900 -9810 0 0 {name=p113392 lab=_62203_/A }
C {devices/lab_pin.sym} 113980 -9810 0 1 {name=p113393 lab=_62203_/Y }
C {sky130_stdcells/inv_2.sym} 113940 -9810 0 0 {name=X_62203_ }
C {devices/lab_pin.sym} 113880 -9700 0 0 {name=p113394 lab=_47109_/A }
C {devices/lab_pin.sym} 113880 -9660 0 0 {name=p113395 lab=_52876_/B }
C {devices/lab_pin.sym} 114000 -9680 0 1 {name=p113396 lab=_47137_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -9680 0 0 {name=X_47137_ }
C {devices/lab_pin.sym} 113900 -9550 0 0 {name=p113397 lab=_44348_/Y }
C {devices/lab_pin.sym} 113980 -9550 0 1 {name=p113398 lab=_87153_/D }
C {sky130_stdcells/inv_2.sym} 113940 -9550 0 0 {name=X_44349_ }
C {devices/lab_pin.sym} 113880 -9440 0 0 {name=p113399 lab=_80681_/Q }
C {devices/lab_pin.sym} 113880 -9400 0 0 {name=p113400 lab=_80937_/D }
C {devices/lab_pin.sym} 114000 -9420 0 1 {name=p113401 lab=_75169_/Y }
C {sky130_stdcells/nor2_4.sym} 113940 -9420 0 0 {name=X_75169_ }
C {devices/lab_pin.sym} 113900 -9290 0 0 {name=p113402 lab=_63018_/X }
C {devices/lab_pin.sym} 113980 -9290 0 1 {name=p113403 lab=_63183_/X }
C {sky130_stdcells/buf_2.sym} 113940 -9290 0 0 {name=X_63183_ }
C {devices/lab_pin.sym} 113880 -9180 0 0 {name=p113404 lab=_60501_/A }
C {devices/lab_pin.sym} 113880 -9140 0 0 {name=p113405 lab=_60440_/A }
C {devices/lab_pin.sym} 114000 -9160 0 1 {name=p113406 lab=_60395_/X }
C {sky130_stdcells/and2_4.sym} 113940 -9160 0 0 {name=X_60395_ }
C {devices/lab_pin.sym} 113860 -9050 0 0 {name=p113407 lab=_62132_/Y }
C {devices/lab_pin.sym} 113860 -9010 0 0 {name=p113408 lab=_62101_/X }
C {devices/lab_pin.sym} 113860 -8970 0 0 {name=p113409 lab=_62133_/Y }
C {devices/lab_pin.sym} 114020 -9010 0 1 {name=p113410 lab=_84431_/D }
C {sky130_stdcells/a21oi_4.sym} 113940 -9010 0 0 {name=X_62134_ }
C {devices/lab_pin.sym} 113860 -8890 0 0 {name=p113411 lab=_47064_/Y }
C {devices/lab_pin.sym} 113860 -8850 0 0 {name=p113412 lab=_47035_/X }
C {devices/lab_pin.sym} 113860 -8810 0 0 {name=p113413 lab=_47067_/X }
C {devices/lab_pin.sym} 114020 -8850 0 1 {name=p113414 lab=_47068_/Y }
C {sky130_stdcells/a21oi_4.sym} 113940 -8850 0 0 {name=X_47068_ }
C {devices/lab_pin.sym} 113900 -8710 0 0 {name=p113415 lab=_68370_/A }
C {devices/lab_pin.sym} 113980 -8710 0 1 {name=p113416 lab=_67991_/X }
C {sky130_stdcells/buf_2.sym} 113940 -8710 0 0 {name=X_67991_ }
C {devices/lab_pin.sym} 113880 -8610 0 0 {name=p113417 lab=_79977_/A }
C {devices/lab_pin.sym} 113880 -8570 0 0 {name=p113418 lab=_79973_/Y }
C {devices/lab_pin.sym} 113880 -8530 0 0 {name=p113419 lab=_79976_/Y }
C {devices/lab_pin.sym} 114000 -8570 0 1 {name=p113420 lab=_79980_/A }
C {sky130_stdcells/nand3_4.sym} 113940 -8570 0 0 {name=X_79977_ }
C {devices/lab_pin.sym} 113860 -8460 0 0 {name=p113421 lab=_40527_/Y }
C {devices/lab_pin.sym} 113860 -8420 0 0 {name=p113422 lab=_46007_/X }
C {devices/lab_pin.sym} 113860 -8380 0 0 {name=p113423 lab=_67215_/B }
C {devices/lab_pin.sym} 113860 -8340 0 0 {name=p113424 lab=_46008_/X }
C {devices/lab_pin.sym} 114020 -8400 0 1 {name=p113425 lab=_46019_/X }
C {sky130_stdcells/a2bb2o_4.sym} 113940 -8400 0 0 {name=X_46019_ }
C {devices/lab_pin.sym} 113860 -8280 0 0 {name=p113426 lab=_69579_/X }
C {devices/lab_pin.sym} 113860 -8240 0 0 {name=p113427 lab=_69727_/Y }
C {devices/lab_pin.sym} 113860 -8200 0 0 {name=p113428 lab=_69672_/X }
C {devices/lab_pin.sym} 113860 -8160 0 0 {name=p113429 lab=_69729_/Y }
C {devices/lab_pin.sym} 114020 -8220 0 1 {name=p113430 lab=_69730_/X }
C {sky130_stdcells/a211o_4.sym} 113940 -8220 0 0 {name=X_69730_ }
C {devices/lab_pin.sym} 113880 -8080 0 0 {name=p113431 lab=_66942_/A }
C {devices/lab_pin.sym} 113880 -8040 0 0 {name=p113432 lab=_88132_/Q }
C {devices/lab_pin.sym} 114000 -8060 0 1 {name=p113433 lab=_66942_/X }
C {sky130_stdcells/and2_4.sym} 113940 -8060 0 0 {name=X_66942_ }
C {devices/lab_pin.sym} 113880 -7960 0 0 {name=p113434 lab=_84836_/Q }
C {devices/lab_pin.sym} 113880 -7920 0 0 {name=p113435 lab=_62065_/B }
C {devices/lab_pin.sym} 113880 -7880 0 0 {name=p113436 lab=_62063_/X }
C {devices/lab_pin.sym} 113880 -7840 0 0 {name=p113437 lab=_62065_/D }
C {devices/lab_pin.sym} 114000 -7900 0 1 {name=p113438 lab=_62066_/D }
C {sky130_stdcells/nand4_4.sym} 113940 -7900 0 0 {name=X_62065_ }
C {devices/lab_pin.sym} 113900 -7750 0 0 {name=p113439 lab=clkbuf_9_170_0_CLK/X }
C {devices/lab_pin.sym} 113980 -7750 0 1 {name=p113440 lab=_85738_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 113940 -7750 0 0 {name=Xclkbuf_10_341_0_CLK }
C {devices/lab_pin.sym} 113900 -7630 0 0 {name=p113441 lab=_78928_/A }
C {devices/lab_pin.sym} 113980 -7630 0 1 {name=p113442 lab=_78928_/Y }
C {sky130_stdcells/inv_2.sym} 113940 -7630 0 0 {name=X_78928_ }
C {devices/lab_pin.sym} 113900 -7510 0 0 {name=p113443 lab=clkbuf_9_485_0_CLK/X }
C {devices/lab_pin.sym} 113980 -7510 0 1 {name=p113444 lab=_83589_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 113940 -7510 0 0 {name=Xclkbuf_10_971_0_CLK }
C {devices/lab_pin.sym} 113880 -7400 0 0 {name=p113445 lab=_60944_/Y }
C {devices/lab_pin.sym} 113880 -7360 0 0 {name=p113446 lab=_64102_/B }
C {devices/lab_pin.sym} 114000 -7380 0 1 {name=p113447 lab=_61016_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -7380 0 0 {name=X_61016_ }
C {devices/lab_pin.sym} 113880 -7260 0 0 {name=p113448 lab=_69661_/A }
C {devices/lab_pin.sym} 113880 -7220 0 0 {name=p113449 lab=_69661_/B }
C {devices/lab_pin.sym} 114000 -7240 0 1 {name=p113450 lab=_69661_/Y }
C {sky130_stdcells/nor2_4.sym} 113940 -7240 0 0 {name=X_69661_ }
C {devices/lab_pin.sym} 113860 -7140 0 0 {name=p113451 lab=_66757_/X }
C {devices/lab_pin.sym} 113860 -7100 0 0 {name=p113452 lab=_66859_/Y }
C {devices/lab_pin.sym} 113860 -7060 0 0 {name=p113453 lab=_66793_/X }
C {devices/lab_pin.sym} 113860 -7020 0 0 {name=p113454 lab=_66872_/Y }
C {devices/lab_pin.sym} 114020 -7080 0 1 {name=p113455 lab=_66873_/X }
C {sky130_stdcells/a211o_4.sym} 113940 -7080 0 0 {name=X_66873_ }
C {devices/lab_pin.sym} 113900 -6930 0 0 {name=p113456 lab=_78858_/Y }
C {devices/lab_pin.sym} 113980 -6930 0 1 {name=p113457 lab=_78859_/Y }
C {sky130_stdcells/inv_2.sym} 113940 -6930 0 0 {name=X_78859_ }
C {devices/lab_pin.sym} 113900 -6810 0 0 {name=p113458 lab=_60111_/X }
C {devices/lab_pin.sym} 113980 -6810 0 1 {name=p113459 lab=_68612_/X }
C {sky130_stdcells/buf_2.sym} 113940 -6810 0 0 {name=X_68612_ }
C {devices/lab_pin.sym} 113900 -6690 0 0 {name=p113460 lab=clkbuf_8_231_0_CLK/X }
C {devices/lab_pin.sym} 113980 -6690 0 1 {name=p113461 lab=clkbuf_9_462_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 113940 -6690 0 0 {name=Xclkbuf_9_462_0_CLK }
C {devices/lab_pin.sym} 113900 -6570 0 0 {name=p113462 lab=_65595_/X }
C {devices/lab_pin.sym} 113980 -6570 0 1 {name=p113463 lab=_65824_/X }
C {sky130_stdcells/buf_2.sym} 113940 -6570 0 0 {name=X_65824_ }
C {devices/lab_pin.sym} 113880 -6460 0 0 {name=p113464 lab=_69580_/A }
C {devices/lab_pin.sym} 113880 -6420 0 0 {name=p113465 lab=_72800_/A }
C {devices/lab_pin.sym} 114000 -6440 0 1 {name=p113466 lab=_69592_/X }
C {sky130_stdcells/and2_4.sym} 113940 -6440 0 0 {name=X_69592_ }
C {devices/lab_pin.sym} 113850 -6310 0 0 {name=p113467 lab=_81883_/CLK }
C {devices/lab_pin.sym} 113850 -6290 0 0 {name=p113468 lab=_78061_/X }
C {devices/lab_pin.sym} 114030 -6310 0 1 {name=p113469 lab=_81870_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -6300 0 0 {name=X_81870_ }
C {devices/lab_pin.sym} 113900 -6170 0 0 {name=p113470 lab=clkbuf_9_178_0_CLK/X }
C {devices/lab_pin.sym} 113980 -6170 0 1 {name=p113471 lab=_85712_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 113940 -6170 0 0 {name=Xclkbuf_10_356_0_CLK }
C {devices/lab_pin.sym} 113860 -6070 0 0 {name=p113472 lab=_49704_/Y }
C {devices/lab_pin.sym} 113860 -6030 0 0 {name=p113473 lab=_49706_/X }
C {devices/lab_pin.sym} 113860 -5990 0 0 {name=p113474 lab=_49708_/X }
C {devices/lab_pin.sym} 114020 -6030 0 1 {name=p113475 lab=_86338_/D }
C {sky130_stdcells/a21oi_4.sym} 113940 -6030 0 0 {name=X_49709_ }
C {devices/lab_pin.sym} 113880 -5900 0 0 {name=p113476 lab=_68542_/X }
C {devices/lab_pin.sym} 113880 -5860 0 0 {name=p113477 lab=_68543_/B }
C {devices/lab_pin.sym} 114000 -5880 0 1 {name=p113478 lab=_68543_/X }
C {sky130_stdcells/and2_4.sym} 113940 -5880 0 0 {name=X_68543_ }
C {devices/lab_pin.sym} 113850 -5750 0 0 {name=p113479 lab=_80821_/CLK }
C {devices/lab_pin.sym} 113850 -5730 0 0 {name=p113480 lab=_80821_/D }
C {devices/lab_pin.sym} 114030 -5750 0 1 {name=p113481 lab=_75599_/B }
C {sky130_stdcells/dfxtp_4.sym} 113940 -5740 0 0 {name=X_80821_ }
C {devices/lab_pin.sym} 113880 -5630 0 0 {name=p113482 lab=_65752_/X }
C {devices/lab_pin.sym} 113880 -5590 0 0 {name=p113483 lab=_65741_/B }
C {devices/lab_pin.sym} 113880 -5550 0 0 {name=p113484 lab=_65754_/X }
C {devices/lab_pin.sym} 114000 -5590 0 1 {name=p113485 lab=_65756_/B }
C {sky130_stdcells/nand3_4.sym} 113940 -5590 0 0 {name=X_65755_ }
C {devices/lab_pin.sym} 113880 -5460 0 0 {name=p113486 lab=_50971_/A }
C {devices/lab_pin.sym} 113880 -5420 0 0 {name=p113487 lab=_50981_/B }
C {devices/lab_pin.sym} 114000 -5440 0 1 {name=p113488 lab=_50981_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -5440 0 0 {name=X_50981_ }
C {devices/lab_pin.sym} 113880 -5340 0 0 {name=p113489 lab=_62967_/A }
C {devices/lab_pin.sym} 113880 -5300 0 0 {name=p113490 lab=_63326_/A }
C {devices/lab_pin.sym} 113880 -5260 0 0 {name=p113491 lab=_62939_/X }
C {devices/lab_pin.sym} 113880 -5220 0 0 {name=p113492 lab=_62967_/D }
C {devices/lab_pin.sym} 114000 -5280 0 1 {name=p113493 lab=_62967_/X }
C {sky130_stdcells/and4_4.sym} 113940 -5280 0 0 {name=X_62967_ }
C {devices/lab_pin.sym} 113900 -5130 0 0 {name=p113494 lab=clkbuf_9_493_0_CLK/X }
C {devices/lab_pin.sym} 113980 -5130 0 1 {name=p113495 lab=_83306_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 113940 -5130 0 0 {name=Xclkbuf_10_986_0_CLK }
C {devices/lab_pin.sym} 113880 -5040 0 0 {name=p113496 lab=_52704_/A }
C {devices/lab_pin.sym} 113880 -5000 0 0 {name=p113497 lab=_52724_/B }
C {devices/lab_pin.sym} 113880 -4960 0 0 {name=p113498 lab=_52708_/X }
C {devices/lab_pin.sym} 113880 -4920 0 0 {name=p113499 lab=_52720_/D }
C {devices/lab_pin.sym} 114000 -4980 0 1 {name=p113500 lab=_52720_/X }
C {sky130_stdcells/and4_4.sym} 113940 -4980 0 0 {name=X_52720_ }
C {devices/lab_pin.sym} 113900 -4830 0 0 {name=p113501 lab=_64706_/A }
C {devices/lab_pin.sym} 113980 -4830 0 1 {name=p113502 lab=_64980_/A }
C {sky130_stdcells/buf_2.sym} 113940 -4830 0 0 {name=X_64706_ }
C {devices/lab_pin.sym} 113850 -4710 0 0 {name=p113503 lab=_86570_/CLK }
C {devices/lab_pin.sym} 113850 -4690 0 0 {name=p113504 lab=_83540_/D }
C {devices/lab_pin.sym} 114030 -4710 0 1 {name=p113505 lab=_83540_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -4700 0 0 {name=X_83540_ }
C {devices/lab_pin.sym} 113850 -4570 0 0 {name=p113506 lab=_81041_/CLK }
C {devices/lab_pin.sym} 113850 -4550 0 0 {name=p113507 lab=_75285_/X }
C {devices/lab_pin.sym} 114030 -4570 0 1 {name=p113508 lab=_81128_/D }
C {sky130_stdcells/dfxtp_4.sym} 113940 -4560 0 0 {name=X_80752_ }
C {devices/lab_pin.sym} 113860 -4470 0 0 {name=p113509 lab=_57670_/A }
C {devices/lab_pin.sym} 113860 -4430 0 0 {name=p113510 lab=_61902_/X }
C {devices/lab_pin.sym} 113860 -4390 0 0 {name=p113511 lab=_61916_/X }
C {devices/lab_pin.sym} 113860 -4350 0 0 {name=p113512 lab=_61870_/X }
C {devices/lab_pin.sym} 113860 -4320 0 0 {name=p113513 lab=_61917_/X }
C {devices/lab_pin.sym} 114020 -4390 0 1 {name=p113514 lab=_61918_/X }
C {sky130_stdcells/a41o_4.sym} 113940 -4390 0 0 {name=X_61918_ }
C {devices/lab_pin.sym} 113900 -4230 0 0 {name=p113515 lab=_68474_/A }
C {devices/lab_pin.sym} 113980 -4230 0 1 {name=p113516 lab=_69004_/A }
C {sky130_stdcells/buf_2.sym} 113940 -4230 0 0 {name=X_68474_ }
C {devices/lab_pin.sym} 113900 -4110 0 0 {name=p113517 lab=_65486_/A }
C {devices/lab_pin.sym} 113980 -4110 0 1 {name=p113518 lab=_65702_/A }
C {sky130_stdcells/buf_2.sym} 113940 -4110 0 0 {name=X_65686_ }
C {devices/lab_pin.sym} 113860 -4020 0 0 {name=p113519 lab=_58490_/A }
C {devices/lab_pin.sym} 113860 -3980 0 0 {name=p113520 lab=_60304_/A }
C {devices/lab_pin.sym} 113860 -3940 0 0 {name=p113521 lab=_64454_/A }
C {devices/lab_pin.sym} 113860 -3900 0 0 {name=p113522 lab=_62875_/X }
C {devices/lab_pin.sym} 114020 -3960 0 1 {name=p113523 lab=_62898_/X }
C {sky130_stdcells/o22a_4.sym} 113940 -3960 0 0 {name=X_62898_ }
C {devices/lab_pin.sym} 113900 -3810 0 0 {name=p113524 lab=clkbuf_8_238_0_CLK/X }
C {devices/lab_pin.sym} 113980 -3810 0 1 {name=p113525 lab=clkbuf_9_477_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 113940 -3810 0 0 {name=Xclkbuf_9_477_0_CLK }
C {devices/lab_pin.sym} 113860 -3720 0 0 {name=p113526 lab=_67166_/X }
C {devices/lab_pin.sym} 113860 -3680 0 0 {name=p113527 lab=_67413_/Y }
C {devices/lab_pin.sym} 113860 -3640 0 0 {name=p113528 lab=_67390_/X }
C {devices/lab_pin.sym} 113860 -3600 0 0 {name=p113529 lab=_67424_/Y }
C {devices/lab_pin.sym} 114020 -3660 0 1 {name=p113530 lab=_67425_/X }
C {sky130_stdcells/a211o_4.sym} 113940 -3660 0 0 {name=X_67425_ }
C {devices/lab_pin.sym} 113880 -3520 0 0 {name=p113531 lab=_52637_/A }
C {devices/lab_pin.sym} 113880 -3480 0 0 {name=p113532 lab=_52651_/B }
C {devices/lab_pin.sym} 114000 -3500 0 1 {name=p113533 lab=_52651_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -3500 0 0 {name=X_52651_ }
C {devices/lab_pin.sym} 113900 -3370 0 0 {name=p113534 lab=_66104_/A }
C {devices/lab_pin.sym} 113980 -3370 0 1 {name=p113535 lab=_64637_/X }
C {sky130_stdcells/buf_2.sym} 113940 -3370 0 0 {name=X_64637_ }
C {devices/lab_pin.sym} 113850 -3250 0 0 {name=p113536 lab=_85959_/CLK }
C {devices/lab_pin.sym} 113850 -3230 0 0 {name=p113537 lab=_83471_/D }
C {devices/lab_pin.sym} 114030 -3250 0 1 {name=p113538 lab=_47771_/A }
C {sky130_stdcells/dfxtp_4.sym} 113940 -3240 0 0 {name=X_83471_ }
C {devices/lab_pin.sym} 113880 -3130 0 0 {name=p113539 lab=_61865_/A }
C {devices/lab_pin.sym} 113880 -3090 0 0 {name=p113540 lab=_61865_/B }
C {devices/lab_pin.sym} 113880 -3050 0 0 {name=p113541 lab=_78073_/B }
C {devices/lab_pin.sym} 114000 -3090 0 1 {name=p113542 lab=_61849_/Y }
C {sky130_stdcells/nor3_4.sym} 113940 -3090 0 0 {name=X_61849_ }
C {devices/lab_pin.sym} 113850 -2950 0 0 {name=p113543 lab=_80679_/CLK }
C {devices/lab_pin.sym} 113850 -2930 0 0 {name=p113544 lab=_80683_/D }
C {devices/lab_pin.sym} 114030 -2950 0 1 {name=p113545 lab=_80683_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -2940 0 0 {name=X_80683_ }
C {devices/lab_pin.sym} 113850 -2810 0 0 {name=p113546 lab=_85180_/CLK }
C {devices/lab_pin.sym} 113850 -2790 0 0 {name=p113547 lab=_85210_/D }
C {devices/lab_pin.sym} 114030 -2810 0 1 {name=p113548 lab=_56395_/C }
C {sky130_stdcells/dfxtp_4.sym} 113940 -2800 0 0 {name=X_85210_ }
C {devices/lab_pin.sym} 113900 -2670 0 0 {name=p113549 lab=_51629_/A }
C {devices/lab_pin.sym} 113980 -2670 0 1 {name=p113550 lab=_51619_/A }
C {sky130_stdcells/buf_2.sym} 113940 -2670 0 0 {name=X_51602_ }
C {devices/lab_pin.sym} 113850 -2550 0 0 {name=p113551 lab=_82833_/CLK }
C {devices/lab_pin.sym} 113850 -2530 0 0 {name=p113552 lab=_82454_/Q }
C {devices/lab_pin.sym} 114030 -2550 0 1 {name=p113553 lab=_78608_/A }
C {sky130_stdcells/dfxtp_4.sym} 113940 -2540 0 0 {name=X_82422_ }
C {devices/lab_pin.sym} 113860 -2430 0 0 {name=p113554 lab=_55443_/A }
C {devices/lab_pin.sym} 113860 -2390 0 0 {name=p113555 lab=_55367_/Y }
C {devices/lab_pin.sym} 113860 -2350 0 0 {name=p113556 lab=_55443_/C }
C {devices/lab_pin.sym} 114020 -2390 0 1 {name=p113557 lab=_55370_/X }
C {sky130_stdcells/a21bo_4.sym} 113940 -2390 0 0 {name=X_55370_ }
C {devices/lab_pin.sym} 113880 -2260 0 0 {name=p113558 lab=_67333_/A }
C {devices/lab_pin.sym} 113880 -2220 0 0 {name=p113559 lab=_67356_/B }
C {devices/lab_pin.sym} 114000 -2240 0 1 {name=p113560 lab=_67356_/X }
C {sky130_stdcells/and2_4.sym} 113940 -2240 0 0 {name=X_67356_ }
C {devices/lab_pin.sym} 113850 -2110 0 0 {name=p113561 lab=_86506_/CLK }
C {devices/lab_pin.sym} 113850 -2090 0 0 {name=p113562 lab=_86190_/D }
C {devices/lab_pin.sym} 114030 -2110 0 1 {name=p113563 lab=_86190_/Q }
C {sky130_stdcells/dfxtp_4.sym} 113940 -2100 0 0 {name=X_86190_ }
C {devices/lab_pin.sym} 113900 -1970 0 0 {name=p113564 lab=_64667_/A }
C {devices/lab_pin.sym} 113980 -1970 0 1 {name=p113565 lab=_64611_/A }
C {sky130_stdcells/buf_2.sym} 113940 -1970 0 0 {name=X_64568_ }
C {devices/lab_pin.sym} 113880 -1860 0 0 {name=p113566 lab=_52590_/A }
C {devices/lab_pin.sym} 113880 -1820 0 0 {name=p113567 lab=_46624_/Y }
C {devices/lab_pin.sym} 114000 -1840 0 1 {name=p113568 lab=_52582_/Y }
C {sky130_stdcells/nand2_4.sym} 113940 -1840 0 0 {name=X_52582_ }
C {sky130_stdcells/decap_3.sym} 113940 -1680 0 0 {name=XPHY_607 }
C {sky130_stdcells/decap_3.sym} 113940 -1500 0 0 {name=XPHY_618 }
C {devices/lab_pin.sym} 113900 -1350 0 0 {name=p113569 lab=_54321_/A }
C {devices/lab_pin.sym} 113980 -1350 0 1 {name=p113570 lab=_54322_/A }
C {sky130_stdcells/buf_2.sym} 113940 -1350 0 0 {name=X_54321_ }
C {devices/lab_pin.sym} 113860 -1250 0 0 {name=p113571 lab=_66305_/Y }
C {devices/lab_pin.sym} 113860 -1210 0 0 {name=p113572 lab=_66278_/X }
C {devices/lab_pin.sym} 113860 -1170 0 0 {name=p113573 lab=_66306_/X }
C {devices/lab_pin.sym} 114020 -1210 0 1 {name=p113574 lab=_84142_/D }
C {sky130_stdcells/a21o_4.sym} 113940 -1210 0 0 {name=X_66307_ }
C {sky130_stdcells/decap_3.sym} 113940 -1040 0 0 {name=XPHY_629 }
C {devices/lab_pin.sym} 113850 -890 0 0 {name=p113575 lab=_85057_/CLK }
C {devices/lab_pin.sym} 113850 -870 0 0 {name=p113576 lab=_85141_/D }
C {devices/lab_pin.sym} 114030 -890 0 1 {name=p113577 lab=_55499_/B }
C {sky130_stdcells/dfxtp_4.sym} 113940 -880 0 0 {name=X_85141_ }
C {devices/lab_pin.sym} 113880 -780 0 0 {name=p113578 lab=_51521_/X }
C {devices/lab_pin.sym} 113880 -740 0 0 {name=p113579 lab=_51553_/B }
C {devices/lab_pin.sym} 113880 -700 0 0 {name=p113580 lab=_51533_/C }
C {devices/lab_pin.sym} 113880 -660 0 0 {name=p113581 lab=_53058_/D }
C {devices/lab_pin.sym} 114000 -720 0 1 {name=p113582 lab=_51533_/X }
C {sky130_stdcells/and4_4.sym} 113940 -720 0 0 {name=X_51533_ }
C {devices/lab_pin.sym} 114820 -42150 0 0 {name=p113583 lab=clkbuf_8_200_0_CLK/X }
C {devices/lab_pin.sym} 114900 -42150 0 1 {name=p113584 lab=clkbuf_9_400_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 114860 -42150 0 0 {name=Xclkbuf_9_400_0_CLK }
C {devices/lab_pin.sym} 114820 -42030 0 0 {name=p113585 lab=_63458_/A }
C {devices/lab_pin.sym} 114900 -42030 0 1 {name=p113586 lab=_63520_/C }
C {sky130_stdcells/buf_2.sym} 114860 -42030 0 0 {name=X_63519_ }
C {devices/lab_pin.sym} 114770 -41910 0 0 {name=p113587 lab=_87345_/CLK }
C {devices/lab_pin.sym} 114770 -41890 0 0 {name=p113588 lab=_77161_/X }
C {devices/lab_pin.sym} 114950 -41910 0 1 {name=p113589 lab=_82353_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -41900 0 0 {name=X_82353_ }
C {devices/lab_pin.sym} 114800 -41780 0 0 {name=p113590 lab=_67308_/A }
C {devices/lab_pin.sym} 114800 -41740 0 0 {name=p113591 lab=_67287_/B }
C {devices/lab_pin.sym} 114920 -41760 0 1 {name=p113592 lab=_67287_/X }
C {sky130_stdcells/and2_4.sym} 114860 -41760 0 0 {name=X_67287_ }
C {devices/lab_pin.sym} 114780 -41650 0 0 {name=p113593 lab=_64492_/Y }
C {devices/lab_pin.sym} 114780 -41610 0 0 {name=p113594 lab=_64498_/X }
C {devices/lab_pin.sym} 114780 -41570 0 0 {name=p113595 lab=_64442_/X }
C {devices/lab_pin.sym} 114940 -41610 0 1 {name=p113596 lab=_64499_/X }
C {sky130_stdcells/o21a_4.sym} 114860 -41610 0 0 {name=X_64499_ }
C {devices/lab_pin.sym} 114780 -41490 0 0 {name=p113597 lab=_57038_/X }
C {devices/lab_pin.sym} 114780 -41450 0 0 {name=p113598 lab=_46178_/X }
C {devices/lab_pin.sym} 114780 -41410 0 0 {name=p113599 lab=_57039_/Y }
C {devices/lab_pin.sym} 114940 -41450 0 1 {name=p113600 lab=_57040_/Y }
C {sky130_stdcells/a21oi_4.sym} 114860 -41450 0 0 {name=X_57040_ }
C {devices/lab_pin.sym} 114770 -41310 0 0 {name=p113601 lab=_81304_/CLK }
C {devices/lab_pin.sym} 114770 -41290 0 0 {name=p113602 lab=_76992_/X }
C {devices/lab_pin.sym} 114950 -41310 0 1 {name=p113603 lab=_81304_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -41300 0 0 {name=X_81304_ }
C {devices/lab_pin.sym} 114780 -41190 0 0 {name=p113604 lab=_69022_/X }
C {devices/lab_pin.sym} 114780 -41150 0 0 {name=p113605 lab=_69024_/X }
C {devices/lab_pin.sym} 114780 -41110 0 0 {name=p113606 lab=_69025_/X }
C {devices/lab_pin.sym} 114940 -41150 0 1 {name=p113607 lab=_69026_/X }
C {sky130_stdcells/a21o_4.sym} 114860 -41150 0 0 {name=X_69026_ }
C {devices/lab_pin.sym} 114780 -41030 0 0 {name=p113608 lab=_85476_/Q }
C {devices/lab_pin.sym} 114780 -40990 0 0 {name=p113609 lab=_54249_/X }
C {devices/lab_pin.sym} 114780 -40950 0 0 {name=p113610 lab=_54251_/Y }
C {devices/lab_pin.sym} 114940 -40990 0 1 {name=p113611 lab=_54252_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -40990 0 0 {name=X_54252_ }
C {devices/lab_pin.sym} 114800 -40860 0 0 {name=p113612 lab=_66237_/X }
C {devices/lab_pin.sym} 114800 -40820 0 0 {name=p113613 lab=_66238_/B }
C {devices/lab_pin.sym} 114920 -40840 0 1 {name=p113614 lab=_66238_/X }
C {sky130_stdcells/and2_4.sym} 114860 -40840 0 0 {name=X_66238_ }
C {devices/lab_pin.sym} 114770 -40710 0 0 {name=p113615 lab=_85040_/CLK }
C {devices/lab_pin.sym} 114770 -40690 0 0 {name=p113616 lab=_85072_/D }
C {devices/lab_pin.sym} 114950 -40710 0 1 {name=p113617 lab=_45659_/A }
C {sky130_stdcells/dfxtp_4.sym} 114860 -40700 0 0 {name=X_85072_ }
C {devices/lab_pin.sym} 114800 -40580 0 0 {name=p113618 lab=_51481_/A }
C {devices/lab_pin.sym} 114800 -40540 0 0 {name=p113619 lab=_52991_/B }
C {devices/lab_pin.sym} 114920 -40560 0 1 {name=p113620 lab=_51464_/Y }
C {sky130_stdcells/nand2_4.sym} 114860 -40560 0 0 {name=X_51464_ }
C {devices/lab_pin.sym} 114770 -40430 0 0 {name=p113621 lab=_82284_/CLK }
C {devices/lab_pin.sym} 114770 -40410 0 0 {name=p113622 lab=_82284_/D }
C {devices/lab_pin.sym} 114950 -40430 0 1 {name=p113623 lab=_40879_/B }
C {sky130_stdcells/dfxtp_4.sym} 114860 -40420 0 0 {name=X_82284_ }
C {devices/lab_pin.sym} 114820 -40290 0 0 {name=p113624 lab=clkbuf_9_462_0_CLK/X }
C {devices/lab_pin.sym} 114900 -40290 0 1 {name=p113625 lab=_83145_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 114860 -40290 0 0 {name=Xclkbuf_10_924_0_CLK }
C {devices/lab_pin.sym} 114800 -40200 0 0 {name=p113626 lab=_53211_/A }
C {devices/lab_pin.sym} 114800 -40160 0 0 {name=p113627 lab=_53211_/B }
C {devices/lab_pin.sym} 114800 -40120 0 0 {name=p113628 lab=_53195_/X }
C {devices/lab_pin.sym} 114800 -40080 0 0 {name=p113629 lab=_53203_/D }
C {devices/lab_pin.sym} 114920 -40140 0 1 {name=p113630 lab=_53203_/X }
C {sky130_stdcells/and4_4.sym} 114860 -40140 0 0 {name=X_53203_ }
C {devices/lab_pin.sym} 114770 -39990 0 0 {name=p113631 lab=_82067_/CLK }
C {devices/lab_pin.sym} 114770 -39970 0 0 {name=p113632 lab=_68163_/X }
C {devices/lab_pin.sym} 114950 -39990 0 1 {name=p113633 lab=_84023_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -39980 0 0 {name=X_84023_ }
C {devices/lab_pin.sym} 114780 -39870 0 0 {name=p113634 lab=_86205_/Q }
C {devices/lab_pin.sym} 114780 -39830 0 0 {name=p113635 lab=_50387_/X }
C {devices/lab_pin.sym} 114780 -39790 0 0 {name=p113636 lab=_50414_/Y }
C {devices/lab_pin.sym} 114940 -39830 0 1 {name=p113637 lab=_50415_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -39830 0 0 {name=X_50415_ }
C {devices/lab_pin.sym} 114770 -39690 0 0 {name=p113638 lab=_85332_/CLK }
C {devices/lab_pin.sym} 114770 -39670 0 0 {name=p113639 lab=_81043_/Q }
C {devices/lab_pin.sym} 114950 -39690 0 1 {name=p113640 lab=_47662_/A }
C {sky130_stdcells/dfxtp_4.sym} 114860 -39680 0 0 {name=X_81235_ }
C {devices/lab_pin.sym} 114780 -39570 0 0 {name=p113641 lab=_54180_/Y }
C {devices/lab_pin.sym} 114780 -39530 0 0 {name=p113642 lab=_54171_/X }
C {devices/lab_pin.sym} 114780 -39490 0 0 {name=p113643 lab=_54182_/X }
C {devices/lab_pin.sym} 114940 -39530 0 1 {name=p113644 lab=_85489_/D }
C {sky130_stdcells/a21oi_4.sym} 114860 -39530 0 0 {name=X_54183_ }
C {devices/lab_pin.sym} 114780 -39420 0 0 {name=p113645 lab=_64971_/X }
C {devices/lab_pin.sym} 114780 -39380 0 0 {name=p113646 lab=_85615_/Q }
C {devices/lab_pin.sym} 114780 -39340 0 0 {name=p113647 lab=_44261_/X }
C {devices/lab_pin.sym} 114780 -39300 0 0 {name=p113648 lab=_66168_/X }
C {devices/lab_pin.sym} 114940 -39360 0 1 {name=p113649 lab=_66169_/X }
C {sky130_stdcells/a211o_4.sym} 114860 -39360 0 0 {name=X_66169_ }
C {devices/lab_pin.sym} 114780 -39230 0 0 {name=p113650 lab=_65413_/B }
C {devices/lab_pin.sym} 114780 -39190 0 0 {name=p113651 lab=_51387_/X }
C {devices/lab_pin.sym} 114780 -39150 0 0 {name=p113652 lab=_51394_/Y }
C {devices/lab_pin.sym} 114940 -39190 0 1 {name=p113653 lab=_51395_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -39190 0 0 {name=X_51395_ }
C {devices/lab_pin.sym} 114820 -39050 0 0 {name=p113654 lab=clkbuf_9_415_0_CLK/A }
C {devices/lab_pin.sym} 114900 -39050 0 1 {name=p113655 lab=clkbuf_9_415_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 114860 -39050 0 0 {name=Xclkbuf_9_415_0_CLK }
C {devices/lab_pin.sym} 114780 -38950 0 0 {name=p113656 lab=_53132_/Y }
C {devices/lab_pin.sym} 114780 -38910 0 0 {name=p113657 lab=_53111_/X }
C {devices/lab_pin.sym} 114780 -38870 0 0 {name=p113658 lab=_53133_/X }
C {devices/lab_pin.sym} 114940 -38910 0 1 {name=p113659 lab=_53134_/Y }
C {sky130_stdcells/a21oi_4.sym} 114860 -38910 0 0 {name=X_53134_ }
C {devices/lab_pin.sym} 114780 -38790 0 0 {name=p113660 lab=_86219_/Q }
C {devices/lab_pin.sym} 114780 -38750 0 0 {name=p113661 lab=_50333_/X }
C {devices/lab_pin.sym} 114780 -38710 0 0 {name=p113662 lab=_50345_/Y }
C {devices/lab_pin.sym} 114940 -38750 0 1 {name=p113663 lab=_50346_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -38750 0 0 {name=X_50346_ }
C {devices/lab_pin.sym} 114770 -38610 0 0 {name=p113664 lab=_81125_/CLK }
C {devices/lab_pin.sym} 114770 -38590 0 0 {name=p113665 lab=_74935_/B }
C {devices/lab_pin.sym} 114950 -38610 0 1 {name=p113666 lab=_81166_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -38600 0 0 {name=X_81166_ }
C {devices/lab_pin.sym} 114800 -38480 0 0 {name=p113667 lab=_58990_/Y }
C {devices/lab_pin.sym} 114800 -38440 0 0 {name=p113668 lab=_58988_/B }
C {devices/lab_pin.sym} 114920 -38460 0 1 {name=p113669 lab=_58991_/Y }
C {sky130_stdcells/nand2_4.sym} 114860 -38460 0 0 {name=X_58991_ }
C {devices/lab_pin.sym} 114820 -38330 0 0 {name=p113670 lab=clkbuf_9_154_0_CLK/X }
C {devices/lab_pin.sym} 114900 -38330 0 1 {name=p113671 lab=_85491_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 114860 -38330 0 0 {name=Xclkbuf_10_309_0_CLK }
C {devices/lab_pin.sym} 114800 -38220 0 0 {name=p113672 lab=_80103_/Y }
C {devices/lab_pin.sym} 114800 -38180 0 0 {name=p113673 lab=_80117_/B }
C {devices/lab_pin.sym} 114920 -38200 0 1 {name=p113674 lab=_80117_/X }
C {sky130_stdcells/and2_4.sym} 114860 -38200 0 0 {name=X_80117_ }
C {devices/lab_pin.sym} 114820 -38070 0 0 {name=p113675 lab=_53065_/A }
C {devices/lab_pin.sym} 114900 -38070 0 1 {name=p113676 lab=_53065_/X }
C {sky130_stdcells/buf_2.sym} 114860 -38070 0 0 {name=X_53065_ }
C {devices/lab_pin.sym} 114780 -37970 0 0 {name=p113677 lab=_57938_/Y }
C {devices/lab_pin.sym} 114780 -37930 0 0 {name=p113678 lab=_57941_/Y }
C {devices/lab_pin.sym} 114780 -37890 0 0 {name=p113679 lab=_57909_/X }
C {devices/lab_pin.sym} 114940 -37930 0 1 {name=p113680 lab=_57942_/X }
C {sky130_stdcells/a21o_4.sym} 114860 -37930 0 0 {name=X_57942_ }
C {devices/lab_pin.sym} 114780 -37810 0 0 {name=p113681 lab=_83886_/Q }
C {devices/lab_pin.sym} 114780 -37770 0 0 {name=p113682 lab=_69894_/X }
C {devices/lab_pin.sym} 114780 -37730 0 0 {name=p113683 lab=_69927_/X }
C {devices/lab_pin.sym} 114940 -37770 0 1 {name=p113684 lab=_69928_/X }
C {sky130_stdcells/a21bo_4.sym} 114860 -37770 0 0 {name=X_69928_ }
C {devices/lab_pin.sym} 114800 -37640 0 0 {name=p113685 lab=_50251_/X }
C {devices/lab_pin.sym} 114800 -37600 0 0 {name=p113686 lab=_47932_/B }
C {devices/lab_pin.sym} 114920 -37620 0 1 {name=p113687 lab=_50277_/Y }
C {sky130_stdcells/nand2_4.sym} 114860 -37620 0 0 {name=X_50277_ }
C {devices/lab_pin.sym} 114770 -37490 0 0 {name=p113688 lab=_85974_/CLK }
C {devices/lab_pin.sym} 114770 -37470 0 0 {name=p113689 lab=_85974_/D }
C {devices/lab_pin.sym} 114950 -37490 0 1 {name=p113690 lab=_85974_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -37480 0 0 {name=X_85974_ }
C {devices/lab_pin.sym} 114770 -37350 0 0 {name=p113691 lab=_80679_/CLK }
C {devices/lab_pin.sym} 114770 -37330 0 0 {name=p113692 lab=_79633_/X }
C {devices/lab_pin.sym} 114950 -37350 0 1 {name=p113693 lab=_81097_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -37340 0 0 {name=X_81097_ }
C {devices/lab_pin.sym} 114820 -37210 0 0 {name=p113694 lab=clkbuf_9_469_0_CLK/X }
C {devices/lab_pin.sym} 114900 -37210 0 1 {name=p113695 lab=_87553_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 114860 -37210 0 0 {name=Xclkbuf_10_939_0_CLK }
C {devices/lab_pin.sym} 114820 -37090 0 0 {name=p113696 lab=clkbuf_6_1_0_CLK/A }
C {devices/lab_pin.sym} 114900 -37090 0 1 {name=p113697 lab=clkbuf_6_0_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 114860 -37090 0 0 {name=Xclkbuf_6_0_0_CLK }
C {devices/lab_pin.sym} 114780 -36990 0 0 {name=p113698 lab=_66141_/B }
C {devices/lab_pin.sym} 114780 -36950 0 0 {name=p113699 lab=_52013_/X }
C {devices/lab_pin.sym} 114780 -36910 0 0 {name=p113700 lab=_52015_/Y }
C {devices/lab_pin.sym} 114940 -36950 0 1 {name=p113701 lab=_52016_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -36950 0 0 {name=X_52016_ }
C {devices/lab_pin.sym} 114770 -36810 0 0 {name=p113702 lab=_87210_/CLK }
C {devices/lab_pin.sym} 114770 -36790 0 0 {name=p113703 lab=_42798_/Y }
C {devices/lab_pin.sym} 114950 -36810 0 1 {name=p113704 lab=_87713_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -36800 0 0 {name=X_87713_ }
C {devices/lab_pin.sym} 114770 -36670 0 0 {name=p113705 lab=_84922_/CLK }
C {devices/lab_pin.sym} 114770 -36650 0 0 {name=p113706 lab=_84925_/D }
C {devices/lab_pin.sym} 114950 -36670 0 1 {name=p113707 lab=_84925_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -36660 0 0 {name=X_84925_ }
C {devices/lab_pin.sym} 114800 -36540 0 0 {name=p113708 lab=_84934_/Q }
C {devices/lab_pin.sym} 114800 -36500 0 0 {name=p113709 lab=_84182_/Q }
C {devices/lab_pin.sym} 114920 -36520 0 1 {name=p113710 lab=_80048_/X }
C {sky130_stdcells/xor2_4.sym} 114860 -36520 0 0 {name=X_80048_ }
C {devices/lab_pin.sym} 114780 -36430 0 0 {name=p113711 lab=_57868_/X }
C {devices/lab_pin.sym} 114780 -36390 0 0 {name=p113712 lab=_57870_/Y }
C {devices/lab_pin.sym} 114780 -36350 0 0 {name=p113713 lab=_57871_/Y }
C {devices/lab_pin.sym} 114780 -36310 0 0 {name=p113714 lab=_57822_/X }
C {devices/lab_pin.sym} 114780 -36270 0 0 {name=p113715 lab=_57872_/X }
C {devices/lab_pin.sym} 114940 -36350 0 1 {name=p113716 lab=_57873_/X }
C {sky130_stdcells/o32a_4.sym} 114860 -36350 0 0 {name=X_57873_ }
C {devices/lab_pin.sym} 114820 -36190 0 0 {name=p113717 lab=_69859_/A }
C {devices/lab_pin.sym} 114900 -36190 0 1 {name=p113718 lab=_69860_/B }
C {sky130_stdcells/inv_2.sym} 114860 -36190 0 0 {name=X_69859_ }
C {devices/lab_pin.sym} 114820 -36070 0 0 {name=p113719 lab=_59611_/X }
C {devices/lab_pin.sym} 114900 -36070 0 1 {name=p113720 lab=_60626_/A }
C {sky130_stdcells/buf_2.sym} 114860 -36070 0 0 {name=X_59612_ }
C {devices/lab_pin.sym} 114820 -35950 0 0 {name=p113721 lab=_45835_/A }
C {devices/lab_pin.sym} 114900 -35950 0 1 {name=p113722 lab=_56824_/X }
C {sky130_stdcells/buf_2.sym} 114860 -35950 0 0 {name=X_56824_ }
C {devices/lab_pin.sym} 114770 -35830 0 0 {name=p113723 lab=_87644_/CLK }
C {devices/lab_pin.sym} 114770 -35810 0 0 {name=p113724 lab=_42933_/X }
C {devices/lab_pin.sym} 114950 -35830 0 1 {name=p113725 lab=_87644_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -35820 0 0 {name=X_87644_ }
C {devices/lab_pin.sym} 114820 -35690 0 0 {name=p113726 lab=_73378_/A }
C {devices/lab_pin.sym} 114900 -35690 0 1 {name=p113727 lab=_72870_/X }
C {sky130_stdcells/buf_2.sym} 114860 -35690 0 0 {name=X_72870_ }
C {devices/lab_pin.sym} 114770 -35570 0 0 {name=p113728 lab=_84263_/CLK }
C {devices/lab_pin.sym} 114770 -35550 0 0 {name=p113729 lab=_84856_/D }
C {devices/lab_pin.sym} 114950 -35570 0 1 {name=p113730 lab=_84856_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -35560 0 0 {name=X_84856_ }
C {devices/lab_pin.sym} 114800 -35450 0 0 {name=p113731 lab=_70504_/A }
C {devices/lab_pin.sym} 114800 -35410 0 0 {name=p113732 lab=_71779_/B }
C {devices/lab_pin.sym} 114800 -35370 0 0 {name=p113733 lab=_71049_/A }
C {devices/lab_pin.sym} 114920 -35410 0 1 {name=p113734 lab=_71821_/X }
C {sky130_stdcells/and3_4.sym} 114860 -35410 0 0 {name=X_71821_ }
C {devices/lab_pin.sym} 114820 -35270 0 0 {name=p113735 lab=_59543_/A }
C {devices/lab_pin.sym} 114900 -35270 0 1 {name=p113736 lab=_59544_/D }
C {sky130_stdcells/buf_2.sym} 114860 -35270 0 0 {name=X_59543_ }
C {devices/lab_pin.sym} 114770 -35150 0 0 {name=p113737 lab=_83813_/CLK }
C {devices/lab_pin.sym} 114770 -35130 0 0 {name=p113738 lab=_83807_/D }
C {devices/lab_pin.sym} 114950 -35150 0 1 {name=p113739 lab=_83807_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -35140 0 0 {name=X_83807_ }
C {devices/lab_pin.sym} 114820 -35010 0 0 {name=p113740 lab=_56679_/B }
C {devices/lab_pin.sym} 114900 -35010 0 1 {name=p113741 lab=_56755_/X }
C {sky130_stdcells/buf_2.sym} 114860 -35010 0 0 {name=X_56755_ }
C {devices/lab_pin.sym} 114770 -34890 0 0 {name=p113742 lab=_88326_/CLK }
C {devices/lab_pin.sym} 114770 -34870 0 0 {name=p113743 lab=_87575_/D }
C {devices/lab_pin.sym} 114950 -34890 0 1 {name=p113744 lab=_74206_/A }
C {sky130_stdcells/dfxtp_4.sym} 114860 -34880 0 0 {name=X_87575_ }
C {devices/lab_pin.sym} 114780 -34790 0 0 {name=p113745 lab=_41965_/X }
C {devices/lab_pin.sym} 114780 -34750 0 0 {name=p113746 lab=_41975_/X }
C {devices/lab_pin.sym} 114780 -34710 0 0 {name=p113747 lab=_40767_/X }
C {devices/lab_pin.sym} 114780 -34670 0 0 {name=p113748 lab=_41980_/Y }
C {devices/lab_pin.sym} 114780 -34630 0 0 {name=p113749 lab=_41967_/X }
C {devices/lab_pin.sym} 114940 -34710 0 1 {name=p113750 lab=_88083_/D }
C {sky130_stdcells/o32ai_4.sym} 114860 -34710 0 0 {name=X_41981_ }
C {devices/lab_pin.sym} 114780 -34570 0 0 {name=p113751 lab=_85532_/Q }
C {devices/lab_pin.sym} 114780 -34530 0 0 {name=p113752 lab=_53940_/X }
C {devices/lab_pin.sym} 114780 -34490 0 0 {name=p113753 lab=_53966_/Y }
C {devices/lab_pin.sym} 114940 -34530 0 1 {name=p113754 lab=_53967_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -34530 0 0 {name=X_53967_ }
C {devices/lab_pin.sym} 114770 -34390 0 0 {name=p113755 lab=_84787_/CLK }
C {devices/lab_pin.sym} 114770 -34370 0 0 {name=p113756 lab=_58955_/Y }
C {devices/lab_pin.sym} 114950 -34390 0 1 {name=p113757 lab=_84787_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -34380 0 0 {name=X_84787_ }
C {devices/lab_pin.sym} 114770 -34250 0 0 {name=p113758 lab=_82288_/CLK }
C {devices/lab_pin.sym} 114770 -34230 0 0 {name=p113759 lab=_81999_/D }
C {devices/lab_pin.sym} 114950 -34250 0 1 {name=p113760 lab=_77098_/A }
C {sky130_stdcells/dfxtp_4.sym} 114860 -34240 0 0 {name=X_81999_ }
C {devices/lab_pin.sym} 114820 -34110 0 0 {name=p113761 lab=_43719_/X }
C {devices/lab_pin.sym} 114900 -34110 0 1 {name=p113762 lab=_43720_/Y }
C {sky130_stdcells/inv_2.sym} 114860 -34110 0 0 {name=X_43720_ }
C {devices/lab_pin.sym} 114780 -34010 0 0 {name=p113763 lab=_55703_/X }
C {devices/lab_pin.sym} 114780 -33970 0 0 {name=p113764 lab=_55705_/X }
C {devices/lab_pin.sym} 114780 -33930 0 0 {name=p113765 lab=_55138_/X }
C {devices/lab_pin.sym} 114940 -33970 0 1 {name=p113766 lab=_55706_/X }
C {sky130_stdcells/a21o_4.sym} 114860 -33970 0 0 {name=X_55706_ }
C {devices/lab_pin.sym} 114770 -33830 0 0 {name=p113767 lab=_86523_/CLK }
C {devices/lab_pin.sym} 114770 -33810 0 0 {name=p113768 lab=_86526_/D }
C {devices/lab_pin.sym} 114950 -33830 0 1 {name=p113769 lab=_72843_/B }
C {sky130_stdcells/dfxtp_4.sym} 114860 -33820 0 0 {name=X_86526_ }
C {devices/lab_pin.sym} 114820 -33690 0 0 {name=p113770 lab=_74549_/A }
C {devices/lab_pin.sym} 114900 -33690 0 1 {name=p113771 lab=_74541_/A }
C {sky130_stdcells/buf_2.sym} 114860 -33690 0 0 {name=X_74540_ }
C {devices/lab_pin.sym} 114820 -33570 0 0 {name=p113772 lab=_40932_/A }
C {devices/lab_pin.sym} 114900 -33570 0 1 {name=p113773 lab=_40932_/X }
C {sky130_stdcells/buf_2.sym} 114860 -33570 0 0 {name=X_40932_ }
C {devices/lab_pin.sym} 114800 -33460 0 0 {name=p113774 lab=_52910_/A }
C {devices/lab_pin.sym} 114800 -33420 0 0 {name=p113775 lab=_52918_/B }
C {devices/lab_pin.sym} 114920 -33440 0 1 {name=p113776 lab=_52918_/Y }
C {sky130_stdcells/nand2_4.sym} 114860 -33440 0 0 {name=X_52918_ }
C {devices/lab_pin.sym} 114780 -33330 0 0 {name=p113777 lab=_52944_/B }
C {devices/lab_pin.sym} 114780 -33290 0 0 {name=p113778 lab=_71737_/X }
C {devices/lab_pin.sym} 114780 -33250 0 0 {name=p113779 lab=_71751_/Y }
C {devices/lab_pin.sym} 114940 -33290 0 1 {name=p113780 lab=_71752_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -33290 0 0 {name=X_71752_ }
C {devices/lab_pin.sym} 114800 -33160 0 0 {name=p113781 lab=_59474_/A }
C {devices/lab_pin.sym} 114800 -33120 0 0 {name=p113782 lab=_59478_/B }
C {devices/lab_pin.sym} 114920 -33140 0 1 {name=p113783 lab=_59474_/Y }
C {sky130_stdcells/nand2_4.sym} 114860 -33140 0 0 {name=X_59474_ }
C {devices/lab_pin.sym} 114770 -33010 0 0 {name=p113784 lab=_83736_/CLK }
C {devices/lab_pin.sym} 114770 -32990 0 0 {name=p113785 lab=_83738_/D }
C {devices/lab_pin.sym} 114950 -33010 0 1 {name=p113786 lab=_47359_/A }
C {sky130_stdcells/dfxtp_4.sym} 114860 -33000 0 0 {name=X_83738_ }
C {devices/lab_pin.sym} 114800 -32880 0 0 {name=p113787 lab=_85137_/Q }
C {devices/lab_pin.sym} 114800 -32840 0 0 {name=p113788 lab=_44253_/X }
C {devices/lab_pin.sym} 114920 -32860 0 1 {name=p113789 lab=_56686_/X }
C {sky130_stdcells/or2_4.sym} 114860 -32860 0 0 {name=X_56686_ }
C {devices/lab_pin.sym} 114800 -32740 0 0 {name=p113790 lab=_53898_/A }
C {devices/lab_pin.sym} 114800 -32700 0 0 {name=p113791 lab=_72072_/B }
C {devices/lab_pin.sym} 114920 -32720 0 1 {name=p113792 lab=_53898_/Y }
C {sky130_stdcells/nand2_4.sym} 114860 -32720 0 0 {name=X_53898_ }
C {devices/lab_pin.sym} 114820 -32590 0 0 {name=p113793 lab=_70866_/A }
C {devices/lab_pin.sym} 114900 -32590 0 1 {name=p113794 lab=_70703_/X }
C {sky130_stdcells/buf_2.sym} 114860 -32590 0 0 {name=X_70703_ }
C {devices/lab_pin.sym} 114820 -32470 0 0 {name=p113795 lab=_58425_/A }
C {devices/lab_pin.sym} 114900 -32470 0 1 {name=p113796 lab=_58984_/A }
C {sky130_stdcells/buf_2.sym} 114860 -32470 0 0 {name=X_58425_ }
C {devices/lab_pin.sym} 114820 -32350 0 0 {name=p113797 lab=_87326_/Q }
C {devices/lab_pin.sym} 114900 -32350 0 1 {name=p113798 lab=_68888_/B }
C {sky130_stdcells/inv_2.sym} 114860 -32350 0 0 {name=X_43651_ }
C {devices/lab_pin.sym} 114800 -32240 0 0 {name=p113799 lab=_44087_/B }
C {devices/lab_pin.sym} 114800 -32200 0 0 {name=p113800 lab=_45393_/Y }
C {devices/lab_pin.sym} 114920 -32220 0 1 {name=p113801 lab=_55637_/Y }
C {sky130_stdcells/nor2_4.sym} 114860 -32220 0 0 {name=X_55637_ }
C {devices/lab_pin.sym} 114780 -32110 0 0 {name=p113802 lab=_83059_/Q }
C {devices/lab_pin.sym} 114780 -32070 0 0 {name=p113803 lab=_74441_/X }
C {devices/lab_pin.sym} 114780 -32030 0 0 {name=p113804 lab=_74470_/Y }
C {devices/lab_pin.sym} 114940 -32070 0 1 {name=p113805 lab=_74471_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -32070 0 0 {name=X_74471_ }
C {devices/lab_pin.sym} 114770 -31930 0 0 {name=p113806 lab=_83303_/CLK }
C {devices/lab_pin.sym} 114770 -31910 0 0 {name=p113807 lab=_86457_/D }
C {devices/lab_pin.sym} 114950 -31930 0 1 {name=p113808 lab=_86457_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -31920 0 0 {name=X_86457_ }
C {devices/lab_pin.sym} 114820 -31790 0 0 {name=p113809 lab=_52767_/A }
C {devices/lab_pin.sym} 114900 -31790 0 1 {name=p113810 lab=_52850_/A }
C {sky130_stdcells/buf_2.sym} 114860 -31790 0 0 {name=X_52849_ }
C {devices/lab_pin.sym} 114820 -31670 0 0 {name=p113811 lab=_40862_/Y }
C {devices/lab_pin.sym} 114900 -31670 0 1 {name=p113812 lab=_40863_/Y }
C {sky130_stdcells/inv_2.sym} 114860 -31670 0 0 {name=X_40863_ }
C {devices/lab_pin.sym} 114800 -31570 0 0 {name=p113813 lab=_71570_/X }
C {devices/lab_pin.sym} 114800 -31530 0 0 {name=p113814 lab=_71626_/B }
C {devices/lab_pin.sym} 114800 -31490 0 0 {name=p113815 lab=_71289_/B }
C {devices/lab_pin.sym} 114920 -31530 0 1 {name=p113816 lab=_71683_/Y }
C {sky130_stdcells/nor3_4.sym} 114860 -31530 0 0 {name=X_71683_ }
C {devices/lab_pin.sym} 114770 -31390 0 0 {name=p113817 lab=_86091_/CLK }
C {devices/lab_pin.sym} 114770 -31370 0 0 {name=p113818 lab=_70900_/Y }
C {devices/lab_pin.sym} 114950 -31390 0 1 {name=p113819 lab=_83669_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -31380 0 0 {name=X_83669_ }
C {devices/lab_pin.sym} 114820 -31250 0 0 {name=p113820 lab=_76196_/B }
C {devices/lab_pin.sym} 114900 -31250 0 1 {name=p113821 lab=_76210_/Y }
C {sky130_stdcells/inv_2.sym} 114860 -31250 0 0 {name=X_76210_ }
C {devices/lab_pin.sym} 114780 -31170 0 0 {name=p113822 lab=_42590_/X }
C {devices/lab_pin.sym} 114780 -31130 0 0 {name=p113823 lab=_42592_/X }
C {devices/lab_pin.sym} 114780 -31090 0 0 {name=p113824 lab=_40885_/X }
C {devices/lab_pin.sym} 114780 -31050 0 0 {name=p113825 lab=_69859_/A }
C {devices/lab_pin.sym} 114780 -31010 0 0 {name=p113826 lab=_42597_/X }
C {devices/lab_pin.sym} 114940 -31090 0 1 {name=p113827 lab=_42603_/A }
C {sky130_stdcells/o32ai_4.sym} 114860 -31090 0 0 {name=X_42602_ }
C {devices/lab_pin.sym} 114780 -30950 0 0 {name=p113828 lab=_88313_/Q }
C {devices/lab_pin.sym} 114780 -30910 0 0 {name=p113829 lab=_73059_/X }
C {devices/lab_pin.sym} 114780 -30870 0 0 {name=p113830 lab=_73421_/X }
C {devices/lab_pin.sym} 114940 -30910 0 1 {name=p113831 lab=_73422_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -30910 0 0 {name=X_73422_ }
C {devices/lab_pin.sym} 114770 -30770 0 0 {name=p113832 lab=_85505_/CLK }
C {devices/lab_pin.sym} 114770 -30750 0 0 {name=p113833 lab=_85408_/D }
C {devices/lab_pin.sym} 114950 -30770 0 1 {name=p113834 lab=_85408_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -30760 0 0 {name=X_85408_ }
C {devices/lab_pin.sym} 114780 -30650 0 0 {name=p113835 lab=_86743_/Q }
C {devices/lab_pin.sym} 114780 -30610 0 0 {name=p113836 lab=_46364_/X }
C {devices/lab_pin.sym} 114780 -30570 0 0 {name=p113837 lab=_46369_/Y }
C {devices/lab_pin.sym} 114940 -30610 0 1 {name=p113838 lab=_46370_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -30610 0 0 {name=X_46370_ }
C {devices/lab_pin.sym} 114820 -30470 0 0 {name=p113839 lab=_70633_/X }
C {devices/lab_pin.sym} 114900 -30470 0 1 {name=p113840 lab=_70635_/A }
C {sky130_stdcells/buf_2.sym} 114860 -30470 0 0 {name=X_70634_ }
C {devices/lab_pin.sym} 114800 -30360 0 0 {name=p113841 lab=_58151_/A }
C {devices/lab_pin.sym} 114800 -30320 0 0 {name=p113842 lab=_58356_/B }
C {devices/lab_pin.sym} 114920 -30340 0 1 {name=p113843 lab=_58356_/Y }
C {sky130_stdcells/nor2_4.sym} 114860 -30340 0 0 {name=X_58356_ }
C {devices/lab_pin.sym} 114800 -30220 0 0 {name=p113844 lab=_77202_/A }
C {devices/lab_pin.sym} 114800 -30180 0 0 {name=p113845 lab=_77189_/Y }
C {devices/lab_pin.sym} 114920 -30200 0 1 {name=p113846 lab=_77191_/B }
C {sky130_stdcells/xor2_4.sym} 114860 -30200 0 0 {name=X_77190_ }
C {devices/lab_pin.sym} 114800 -30090 0 0 {name=p113847 lab=_46612_/A }
C {devices/lab_pin.sym} 114800 -30050 0 0 {name=p113848 lab=_40591_/C }
C {devices/lab_pin.sym} 114800 -30010 0 0 {name=p113849 lab=_43175_/C }
C {devices/lab_pin.sym} 114920 -30050 0 1 {name=p113850 lab=_48144_/A }
C {sky130_stdcells/and3_4.sym} 114860 -30050 0 0 {name=X_43582_ }
C {devices/lab_pin.sym} 114780 -29940 0 0 {name=p113851 lab=_45494_/A }
C {devices/lab_pin.sym} 114780 -29900 0 0 {name=p113852 lab=_55527_/X }
C {devices/lab_pin.sym} 114780 -29860 0 0 {name=p113853 lab=_44098_/X }
C {devices/lab_pin.sym} 114780 -29820 0 0 {name=p113854 lab=_55567_/X }
C {devices/lab_pin.sym} 114940 -29880 0 1 {name=p113855 lab=_55568_/X }
C {sky130_stdcells/a211o_4.sym} 114860 -29880 0 0 {name=X_55568_ }
C {devices/lab_pin.sym} 114770 -29730 0 0 {name=p113856 lab=_83676_/CLK }
C {devices/lab_pin.sym} 114770 -29710 0 0 {name=p113857 lab=_49437_/Y }
C {devices/lab_pin.sym} 114950 -29730 0 1 {name=p113858 lab=_86388_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -29720 0 0 {name=X_86388_ }
C {devices/lab_pin.sym} 114820 -29590 0 0 {name=p113859 lab=_40756_/A }
C {devices/lab_pin.sym} 114900 -29590 0 1 {name=p113860 lab=_40794_/X }
C {sky130_stdcells/buf_2.sym} 114860 -29590 0 0 {name=X_40794_ }
C {devices/lab_pin.sym} 114820 -29470 0 0 {name=p113861 lab=_63312_/B }
C {devices/lab_pin.sym} 114900 -29470 0 1 {name=p113862 lab=_61649_/B }
C {sky130_stdcells/buf_2.sym} 114860 -29470 0 0 {name=X_45321_ }
C {devices/lab_pin.sym} 114800 -29360 0 0 {name=p113863 lab=_85037_/Q }
C {devices/lab_pin.sym} 114800 -29320 0 0 {name=p113864 lab=_56997_/X }
C {devices/lab_pin.sym} 114920 -29340 0 1 {name=p113865 lab=_57307_/Y }
C {sky130_stdcells/nor2_4.sym} 114860 -29340 0 0 {name=X_57307_ }
C {devices/lab_pin.sym} 114770 -29210 0 0 {name=p113866 lab=_87116_/CLK }
C {devices/lab_pin.sym} 114770 -29190 0 0 {name=p113867 lab=_41843_/Y }
C {devices/lab_pin.sym} 114950 -29210 0 1 {name=p113868 lab=_88127_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -29200 0 0 {name=X_88127_ }
C {devices/lab_pin.sym} 114800 -29080 0 0 {name=p113869 lab=_76143_/B }
C {devices/lab_pin.sym} 114800 -29040 0 0 {name=p113870 lab=_76143_/A }
C {devices/lab_pin.sym} 114920 -29060 0 1 {name=p113871 lab=_76142_/B }
C {sky130_stdcells/xor2_4.sym} 114860 -29060 0 0 {name=X_76141_ }
C {devices/lab_pin.sym} 114820 -28930 0 0 {name=p113872 lab=_42532_/Y }
C {devices/lab_pin.sym} 114900 -28930 0 1 {name=p113873 lab=_87831_/D }
C {sky130_stdcells/inv_2.sym} 114860 -28930 0 0 {name=X_42533_ }
C {devices/lab_pin.sym} 114780 -28830 0 0 {name=p113874 lab=_85427_/Q }
C {devices/lab_pin.sym} 114780 -28790 0 0 {name=p113875 lab=_54512_/X }
C {devices/lab_pin.sym} 114780 -28750 0 0 {name=p113876 lab=_54518_/Y }
C {devices/lab_pin.sym} 114940 -28790 0 1 {name=p113877 lab=_54519_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -28790 0 0 {name=X_54519_ }
C {devices/lab_pin.sym} 114800 -28660 0 0 {name=p113878 lab=_73353_/A }
C {devices/lab_pin.sym} 114800 -28620 0 0 {name=p113879 lab=_85866_/Q }
C {devices/lab_pin.sym} 114920 -28640 0 1 {name=p113880 lab=_73353_/X }
C {sky130_stdcells/and2_4.sym} 114860 -28640 0 0 {name=X_73353_ }
C {devices/lab_pin.sym} 114770 -28510 0 0 {name=p113881 lab=_85372_/CLK }
C {devices/lab_pin.sym} 114770 -28490 0 0 {name=p113882 lab=_54993_/Y }
C {devices/lab_pin.sym} 114950 -28510 0 1 {name=p113883 lab=_85339_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -28500 0 0 {name=X_85339_ }
C {devices/lab_pin.sym} 114780 -28390 0 0 {name=p113884 lab=_70532_/Y }
C {devices/lab_pin.sym} 114780 -28350 0 0 {name=p113885 lab=_83748_/Q }
C {devices/lab_pin.sym} 114780 -28310 0 0 {name=p113886 lab=_70564_/Y }
C {devices/lab_pin.sym} 114940 -28350 0 1 {name=p113887 lab=_83748_/D }
C {sky130_stdcells/a21o_4.sym} 114860 -28350 0 0 {name=X_70565_ }
C {devices/lab_pin.sym} 114820 -28210 0 0 {name=p113888 lab=_58287_/A }
C {devices/lab_pin.sym} 114900 -28210 0 1 {name=p113889 lab=_58287_/Y }
C {sky130_stdcells/inv_2.sym} 114860 -28210 0 0 {name=X_58287_ }
C {devices/lab_pin.sym} 114800 -28100 0 0 {name=p113890 lab=_55826_/A }
C {devices/lab_pin.sym} 114800 -28060 0 0 {name=p113891 lab=_55499_/B }
C {devices/lab_pin.sym} 114920 -28080 0 1 {name=p113892 lab=_55499_/X }
C {sky130_stdcells/and2_4.sym} 114860 -28080 0 0 {name=X_55499_ }
C {devices/lab_pin.sym} 114820 -27950 0 0 {name=p113893 lab=_57590_/B }
C {devices/lab_pin.sym} 114900 -27950 0 1 {name=p113894 lab=_52036_/B }
C {sky130_stdcells/buf_2.sym} 114860 -27950 0 0 {name=X_48040_ }
C {devices/lab_pin.sym} 114780 -27870 0 0 {name=p113895 lab=_72299_/X }
C {devices/lab_pin.sym} 114780 -27830 0 0 {name=p113896 lab=_72301_/Y }
C {devices/lab_pin.sym} 114780 -27790 0 0 {name=p113897 lab=_72302_/Y }
C {devices/lab_pin.sym} 114780 -27750 0 0 {name=p113898 lab=_72194_/X }
C {devices/lab_pin.sym} 114780 -27710 0 0 {name=p113899 lab=_72303_/X }
C {devices/lab_pin.sym} 114940 -27790 0 1 {name=p113900 lab=_72304_/X }
C {sky130_stdcells/o32a_4.sym} 114860 -27790 0 0 {name=X_72304_ }
C {devices/lab_pin.sym} 114820 -27630 0 0 {name=p113901 lab=_45252_/A }
C {devices/lab_pin.sym} 114900 -27630 0 1 {name=p113902 lab=_45252_/X }
C {sky130_stdcells/buf_2.sym} 114860 -27630 0 0 {name=X_45252_ }
C {devices/lab_pin.sym} 114820 -27510 0 0 {name=p113903 lab=_57235_/Y }
C {devices/lab_pin.sym} 114900 -27510 0 1 {name=p113904 lab=_57238_/X }
C {sky130_stdcells/buf_2.sym} 114860 -27510 0 0 {name=X_57238_ }
C {devices/lab_pin.sym} 114780 -27410 0 0 {name=p113905 lab=_76067_/Y }
C {devices/lab_pin.sym} 114780 -27370 0 0 {name=p113906 lab=_76068_/A }
C {devices/lab_pin.sym} 114780 -27330 0 0 {name=p113907 lab=_76071_/Y }
C {devices/lab_pin.sym} 114940 -27370 0 1 {name=p113908 lab=_76073_/B }
C {sky130_stdcells/a21boi_4.sym} 114860 -27370 0 0 {name=X_76072_ }
C {devices/lab_pin.sym} 114770 -27230 0 0 {name=p113909 lab=_88062_/CLK }
C {devices/lab_pin.sym} 114770 -27210 0 0 {name=p113910 lab=_88058_/D }
C {devices/lab_pin.sym} 114950 -27230 0 1 {name=p113911 lab=_88058_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -27220 0 0 {name=X_88058_ }
C {devices/lab_pin.sym} 114780 -27130 0 0 {name=p113912 lab=_42460_/X }
C {devices/lab_pin.sym} 114780 -27090 0 0 {name=p113913 lab=_42049_/X }
C {devices/lab_pin.sym} 114780 -27050 0 0 {name=p113914 lab=_40590_/X }
C {devices/lab_pin.sym} 114780 -27010 0 0 {name=p113915 lab=_68440_/B }
C {devices/lab_pin.sym} 114780 -26970 0 0 {name=p113916 lab=_42463_/X }
C {devices/lab_pin.sym} 114940 -27050 0 1 {name=p113917 lab=_42464_/Y }
C {sky130_stdcells/o32ai_4.sym} 114860 -27050 0 0 {name=X_42464_ }
C {devices/lab_pin.sym} 114820 -26890 0 0 {name=p113918 lab=_73284_/A }
C {devices/lab_pin.sym} 114900 -26890 0 1 {name=p113919 lab=_73284_/X }
C {sky130_stdcells/buf_2.sym} 114860 -26890 0 0 {name=X_73284_ }
C {devices/lab_pin.sym} 114820 -26770 0 0 {name=p113920 lab=_70496_/A }
C {devices/lab_pin.sym} 114900 -26770 0 1 {name=p113921 lab=_71115_/C }
C {sky130_stdcells/buf_2.sym} 114860 -26770 0 0 {name=X_70496_ }
C {devices/lab_pin.sym} 114780 -26670 0 0 {name=p113922 lab=_44201_/Y }
C {devices/lab_pin.sym} 114780 -26630 0 0 {name=p113923 lab=_44202_/X }
C {devices/lab_pin.sym} 114780 -26590 0 0 {name=p113924 lab=_44220_/B }
C {devices/lab_pin.sym} 114940 -26630 0 1 {name=p113925 lab=_87182_/D }
C {sky130_stdcells/a21oi_4.sym} 114860 -26630 0 0 {name=X_44203_ }
C {devices/lab_pin.sym} 114800 -26500 0 0 {name=p113926 lab=_75023_/A }
C {devices/lab_pin.sym} 114800 -26460 0 0 {name=p113927 lab=_75023_/B }
C {devices/lab_pin.sym} 114920 -26480 0 1 {name=p113928 lab=_75024_/B }
C {sky130_stdcells/xnor2_4.sym} 114860 -26480 0 0 {name=X_75023_ }
C {devices/lab_pin.sym} 114800 -26360 0 0 {name=p113929 lab=_84922_/Q }
C {devices/lab_pin.sym} 114800 -26320 0 0 {name=p113930 lab=_65901_/C }
C {devices/lab_pin.sym} 114920 -26340 0 1 {name=p113931 lab=_79900_/X }
C {sky130_stdcells/or2_4.sym} 114860 -26340 0 0 {name=X_79900_ }
C {devices/lab_pin.sym} 114770 -26210 0 0 {name=p113932 lab=_88283_/CLK }
C {devices/lab_pin.sym} 114770 -26190 0 0 {name=p113933 lab=_87009_/D }
C {devices/lab_pin.sym} 114950 -26210 0 1 {name=p113934 lab=_87009_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -26200 0 0 {name=X_87009_ }
C {devices/lab_pin.sym} 114780 -26090 0 0 {name=p113935 lab=_41412_/X }
C {devices/lab_pin.sym} 114780 -26050 0 0 {name=p113936 lab=_82889_/Q }
C {devices/lab_pin.sym} 114780 -26010 0 0 {name=p113937 lab=_41414_/X }
C {devices/lab_pin.sym} 114940 -26050 0 1 {name=p113938 lab=_41415_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -26050 0 0 {name=X_41415_ }
C {devices/lab_pin.sym} 114780 -25940 0 0 {name=p113939 lab=_72224_/Y }
C {devices/lab_pin.sym} 114780 -25900 0 0 {name=p113940 lab=_72152_/X }
C {devices/lab_pin.sym} 114780 -25860 0 0 {name=p113941 lab=_72231_/X }
C {devices/lab_pin.sym} 114780 -25820 0 0 {name=p113942 lab=_72234_/X }
C {devices/lab_pin.sym} 114940 -25880 0 1 {name=p113943 lab=_83272_/D }
C {sky130_stdcells/a22oi_4.sym} 114860 -25880 0 0 {name=X_72235_ }
C {devices/lab_pin.sym} 114780 -25750 0 0 {name=p113944 lab=_45180_/X }
C {devices/lab_pin.sym} 114780 -25710 0 0 {name=p113945 lab=_45182_/Y }
C {devices/lab_pin.sym} 114780 -25670 0 0 {name=p113946 lab=_45125_/X }
C {devices/lab_pin.sym} 114940 -25710 0 1 {name=p113947 lab=_45183_/Y }
C {sky130_stdcells/a21oi_4.sym} 114860 -25710 0 0 {name=X_45183_ }
C {devices/lab_pin.sym} 114780 -25610 0 0 {name=p113948 lab=_56737_/X }
C {devices/lab_pin.sym} 114780 -25570 0 0 {name=p113949 lab=_56800_/X }
C {devices/lab_pin.sym} 114780 -25530 0 0 {name=p113950 lab=_56810_/X }
C {devices/lab_pin.sym} 114780 -25490 0 0 {name=p113951 lab=_57156_/X }
C {devices/lab_pin.sym} 114780 -25460 0 0 {name=p113952 lab=_56767_/X }
C {devices/lab_pin.sym} 114940 -25530 0 1 {name=p113953 lab=_57169_/X }
C {sky130_stdcells/a41o_4.sym} 114860 -25530 0 0 {name=X_57169_ }
C {devices/lab_pin.sym} 114780 -25400 0 0 {name=p113954 lab=_40408_/X }
C {devices/lab_pin.sym} 114780 -25360 0 0 {name=p113955 lab=_42388_/X }
C {devices/lab_pin.sym} 114780 -25320 0 0 {name=p113956 lab=_87883_/Q }
C {devices/lab_pin.sym} 114780 -25280 0 0 {name=p113957 lab=_42389_/X }
C {devices/lab_pin.sym} 114940 -25340 0 1 {name=p113958 lab=_87883_/D }
C {sky130_stdcells/a2bb2o_4.sym} 114860 -25340 0 0 {name=X_42395_ }
C {devices/lab_pin.sym} 114800 -25220 0 0 {name=p113959 lab=_44196_/A }
C {devices/lab_pin.sym} 114800 -25180 0 0 {name=p113960 lab=_44196_/B }
C {devices/lab_pin.sym} 114800 -25140 0 0 {name=p113961 lab=_44128_/X }
C {devices/lab_pin.sym} 114800 -25100 0 0 {name=p113962 lab=_44134_/D }
C {devices/lab_pin.sym} 114920 -25160 0 1 {name=p113963 lab=_44134_/X }
C {sky130_stdcells/and4_4.sym} 114860 -25160 0 0 {name=X_44134_ }
C {devices/lab_pin.sym} 114780 -25030 0 0 {name=p113964 lab=_79819_/A }
C {devices/lab_pin.sym} 114780 -24990 0 0 {name=p113965 lab=_79818_/Y }
C {devices/lab_pin.sym} 114780 -24950 0 0 {name=p113966 lab=_79830_/X }
C {devices/lab_pin.sym} 114940 -24990 0 1 {name=p113967 lab=_79831_/X }
C {sky130_stdcells/a21o_4.sym} 114860 -24990 0 0 {name=X_79831_ }
C {devices/lab_pin.sym} 114780 -24870 0 0 {name=p113968 lab=_41344_/X }
C {devices/lab_pin.sym} 114780 -24830 0 0 {name=p113969 lab=_81750_/Q }
C {devices/lab_pin.sym} 114780 -24790 0 0 {name=p113970 lab=_41345_/X }
C {devices/lab_pin.sym} 114940 -24830 0 1 {name=p113971 lab=_41346_/X }
C {sky130_stdcells/o21a_4.sym} 114860 -24830 0 0 {name=X_41346_ }
C {devices/lab_pin.sym} 114820 -24690 0 0 {name=p113972 lab=_60179_/Y }
C {devices/lab_pin.sym} 114900 -24690 0 1 {name=p113973 lab=_60291_/C }
C {sky130_stdcells/buf_2.sym} 114860 -24690 0 0 {name=X_60180_ }
C {devices/lab_pin.sym} 114820 -24570 0 0 {name=p113974 lab=_57708_/X }
C {devices/lab_pin.sym} 114900 -24570 0 1 {name=p113975 lab=_72166_/X }
C {sky130_stdcells/buf_2.sym} 114860 -24570 0 0 {name=X_72166_ }
C {devices/lab_pin.sym} 114780 -24470 0 0 {name=p113976 lab=_49989_/Y }
C {devices/lab_pin.sym} 114780 -24430 0 0 {name=p113977 lab=_49977_/X }
C {devices/lab_pin.sym} 114780 -24390 0 0 {name=p113978 lab=_49990_/X }
C {devices/lab_pin.sym} 114940 -24430 0 1 {name=p113979 lab=_86286_/D }
C {sky130_stdcells/a21oi_4.sym} 114860 -24430 0 0 {name=X_49991_ }
C {devices/lab_pin.sym} 114820 -24290 0 0 {name=p113980 lab=_71117_/A }
C {devices/lab_pin.sym} 114900 -24290 0 1 {name=p113981 lab=_71117_/X }
C {sky130_stdcells/buf_2.sym} 114860 -24290 0 0 {name=X_71117_ }
C {devices/lab_pin.sym} 114820 -24170 0 0 {name=p113982 lab=_83619_/Q }
C {devices/lab_pin.sym} 114900 -24170 0 1 {name=p113983 lab=_71987_/B }
C {sky130_stdcells/inv_2.sym} 114860 -24170 0 0 {name=X_48942_ }
C {devices/lab_pin.sym} 114820 -24050 0 0 {name=p113984 lab=_44064_/X }
C {devices/lab_pin.sym} 114900 -24050 0 1 {name=p113985 lab=_44086_/A }
C {sky130_stdcells/buf_2.sym} 114860 -24050 0 0 {name=X_44065_ }
C {devices/lab_pin.sym} 114780 -23950 0 0 {name=p113986 lab=_64942_/C }
C {devices/lab_pin.sym} 114780 -23910 0 0 {name=p113987 lab=_72263_/Y }
C {devices/lab_pin.sym} 114780 -23870 0 0 {name=p113988 lab=_79761_/Y }
C {devices/lab_pin.sym} 114940 -23910 0 1 {name=p113989 lab=_79762_/X }
C {sky130_stdcells/o21a_4.sym} 114860 -23910 0 0 {name=X_79762_ }
C {devices/lab_pin.sym} 114820 -23770 0 0 {name=p113990 lab=_41276_/X }
C {devices/lab_pin.sym} 114900 -23770 0 1 {name=p113991 lab=_41277_/X }
C {sky130_stdcells/buf_2.sym} 114860 -23770 0 0 {name=X_41277_ }
C {devices/lab_pin.sym} 114800 -23660 0 0 {name=p113992 lab=_61055_/C }
C {devices/lab_pin.sym} 114800 -23620 0 0 {name=p113993 lab=_84398_/Q }
C {devices/lab_pin.sym} 114920 -23640 0 1 {name=p113994 lab=_76974_/X }
C {sky130_stdcells/xor2_4.sym} 114860 -23640 0 0 {name=X_76974_ }
C {devices/lab_pin.sym} 114780 -23530 0 0 {name=p113995 lab=_83285_/Q }
C {devices/lab_pin.sym} 114780 -23490 0 0 {name=p113996 lab=_72090_/X }
C {devices/lab_pin.sym} 114780 -23450 0 0 {name=p113997 lab=_72096_/Y }
C {devices/lab_pin.sym} 114940 -23490 0 1 {name=p113998 lab=_72097_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -23490 0 0 {name=X_72097_ }
C {devices/lab_pin.sym} 114820 -23350 0 0 {name=p113999 lab=_43030_/A }
C {devices/lab_pin.sym} 114900 -23350 0 1 {name=p114000 lab=_43017_/A }
C {sky130_stdcells/buf_2.sym} 114860 -23350 0 0 {name=X_43016_ }
C {devices/lab_pin.sym} 114800 -23250 0 0 {name=p114001 lab=_78709_/Y }
C {devices/lab_pin.sym} 114800 -23210 0 0 {name=p114002 lab=_78713_/B }
C {devices/lab_pin.sym} 114800 -23170 0 0 {name=p114003 lab=_78712_/Y }
C {devices/lab_pin.sym} 114920 -23210 0 1 {name=p114004 lab=_78713_/X }
C {sky130_stdcells/or3_4.sym} 114860 -23210 0 0 {name=X_78713_ }
C {devices/lab_pin.sym} 114820 -23070 0 0 {name=p114005 lab=_70832_/A }
C {devices/lab_pin.sym} 114900 -23070 0 1 {name=p114006 lab=_71049_/A }
C {sky130_stdcells/buf_2.sym} 114860 -23070 0 0 {name=X_71048_ }
C {devices/lab_pin.sym} 114800 -22960 0 0 {name=p114007 lab=_81506_/Q }
C {devices/lab_pin.sym} 114800 -22920 0 0 {name=p114008 lab=_75925_/B }
C {devices/lab_pin.sym} 114920 -22940 0 1 {name=p114009 lab=_75925_/X }
C {sky130_stdcells/xor2_4.sym} 114860 -22940 0 0 {name=X_75925_ }
C {devices/lab_pin.sym} 114780 -22830 0 0 {name=p114010 lab=_86466_/Q }
C {devices/lab_pin.sym} 114780 -22790 0 0 {name=p114011 lab=_48861_/X }
C {devices/lab_pin.sym} 114780 -22750 0 0 {name=p114012 lab=_48872_/Y }
C {devices/lab_pin.sym} 114940 -22790 0 1 {name=p114013 lab=_48873_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -22790 0 0 {name=X_48873_ }
C {devices/lab_pin.sym} 114800 -22660 0 0 {name=p114014 lab=_79689_/Y }
C {devices/lab_pin.sym} 114800 -22620 0 0 {name=p114015 lab=_79692_/Y }
C {devices/lab_pin.sym} 114920 -22640 0 1 {name=p114016 lab=_79704_/A }
C {sky130_stdcells/xor2_4.sym} 114860 -22640 0 0 {name=X_79693_ }
C {devices/lab_pin.sym} 114780 -22530 0 0 {name=p114017 lab=_47820_/Y }
C {devices/lab_pin.sym} 114780 -22490 0 0 {name=p114018 lab=_47791_/X }
C {devices/lab_pin.sym} 114780 -22450 0 0 {name=p114019 lab=_47823_/X }
C {devices/lab_pin.sym} 114940 -22490 0 1 {name=p114020 lab=_86594_/D }
C {sky130_stdcells/a21oi_4.sym} 114860 -22490 0 0 {name=X_47824_ }
C {devices/lab_pin.sym} 114800 -22360 0 0 {name=p114021 lab=_78644_/A }
C {devices/lab_pin.sym} 114800 -22320 0 0 {name=p114022 lab=_82776_/D }
C {devices/lab_pin.sym} 114920 -22340 0 1 {name=p114023 lab=_82488_/D }
C {sky130_stdcells/xor2_4.sym} 114860 -22340 0 0 {name=X_78644_ }
C {devices/lab_pin.sym} 114820 -22210 0 0 {name=p114024 lab=_60871_/Y }
C {devices/lab_pin.sym} 114900 -22210 0 1 {name=p114025 lab=_63920_/B }
C {sky130_stdcells/buf_2.sym} 114860 -22210 0 0 {name=X_63870_ }
C {devices/lab_pin.sym} 114820 -22090 0 0 {name=p114026 lab=_75830_/B }
C {devices/lab_pin.sym} 114900 -22090 0 1 {name=p114027 lab=_80798_/D }
C {sky130_stdcells/inv_2.sym} 114860 -22090 0 0 {name=X_75856_ }
C {devices/lab_pin.sym} 114800 -21990 0 0 {name=p114028 lab=_62773_/X }
C {devices/lab_pin.sym} 114800 -21950 0 0 {name=p114029 lab=_62812_/B }
C {devices/lab_pin.sym} 114800 -21910 0 0 {name=p114030 lab=_61954_/X }
C {devices/lab_pin.sym} 114920 -21950 0 1 {name=p114031 lab=_62821_/Y }
C {sky130_stdcells/nand3_4.sym} 114860 -21950 0 0 {name=X_62821_ }
C {devices/lab_pin.sym} 114800 -21840 0 0 {name=p114032 lab=_74807_/A }
C {devices/lab_pin.sym} 114800 -21800 0 0 {name=p114033 lab=_74775_/A }
C {devices/lab_pin.sym} 114800 -21760 0 0 {name=p114034 lab=_70884_/A }
C {devices/lab_pin.sym} 114800 -21720 0 0 {name=p114035 lab=_70662_/X }
C {devices/lab_pin.sym} 114920 -21780 0 1 {name=p114036 lab=_74810_/B }
C {sky130_stdcells/nand4_4.sym} 114860 -21780 0 0 {name=X_74807_ }
C {devices/lab_pin.sym} 114820 -21630 0 0 {name=p114037 lab=_47661_/A }
C {devices/lab_pin.sym} 114900 -21630 0 1 {name=p114038 lab=_47777_/C }
C {sky130_stdcells/buf_2.sym} 114860 -21630 0 0 {name=X_47755_ }
C {devices/lab_pin.sym} 114800 -21520 0 0 {name=p114039 lab=_78575_/A }
C {devices/lab_pin.sym} 114800 -21480 0 0 {name=p114040 lab=_78575_/B }
C {devices/lab_pin.sym} 114920 -21500 0 1 {name=p114041 lab=_78575_/X }
C {sky130_stdcells/and2_4.sym} 114860 -21500 0 0 {name=X_78575_ }
C {devices/lab_pin.sym} 114820 -21370 0 0 {name=p114042 lab=_45193_/A }
C {devices/lab_pin.sym} 114900 -21370 0 1 {name=p114043 lab=_45734_/A }
C {sky130_stdcells/buf_2.sym} 114860 -21370 0 0 {name=X_44967_ }
C {devices/lab_pin.sym} 114800 -21260 0 0 {name=p114044 lab=_75787_/A }
C {devices/lab_pin.sym} 114800 -21220 0 0 {name=p114045 lab=_75786_/X }
C {devices/lab_pin.sym} 114920 -21240 0 1 {name=p114046 lab=_75793_/A }
C {sky130_stdcells/xor2_4.sym} 114860 -21240 0 0 {name=X_75787_ }
C {devices/lab_pin.sym} 114780 -21130 0 0 {name=p114047 lab=_83169_/Q }
C {devices/lab_pin.sym} 114780 -21090 0 0 {name=p114048 lab=_72943_/X }
C {devices/lab_pin.sym} 114780 -21050 0 0 {name=p114049 lab=_72998_/X }
C {devices/lab_pin.sym} 114940 -21090 0 1 {name=p114050 lab=_72999_/X }
C {sky130_stdcells/a21o_4.sym} 114860 -21090 0 0 {name=X_72999_ }
C {devices/lab_pin.sym} 114820 -20950 0 0 {name=p114051 lab=_82968_/Q }
C {devices/lab_pin.sym} 114900 -20950 0 1 {name=p114052 lab=_46706_/Y }
C {sky130_stdcells/inv_2.sym} 114860 -20950 0 0 {name=X_46706_ }
C {devices/lab_pin.sym} 114820 -20830 0 0 {name=p114053 lab=_65407_/A }
C {devices/lab_pin.sym} 114900 -20830 0 1 {name=p114054 lab=_65540_/X }
C {sky130_stdcells/buf_2.sym} 114860 -20830 0 0 {name=X_65540_ }
C {devices/lab_pin.sym} 114780 -20730 0 0 {name=p114055 lab=_77522_/Y }
C {devices/lab_pin.sym} 114780 -20690 0 0 {name=p114056 lab=_77501_/Y }
C {devices/lab_pin.sym} 114780 -20650 0 0 {name=p114057 lab=_77525_/X }
C {devices/lab_pin.sym} 114940 -20690 0 1 {name=p114058 lab=_77526_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -20690 0 0 {name=X_77526_ }
C {devices/lab_pin.sym} 114780 -20590 0 0 {name=p114059 lab=_43916_/X }
C {devices/lab_pin.sym} 114780 -20550 0 0 {name=p114060 lab=_43902_/X }
C {devices/lab_pin.sym} 114780 -20510 0 0 {name=p114061 lab=_41387_/X }
C {devices/lab_pin.sym} 114780 -20470 0 0 {name=p114062 lab=_87200_/Q }
C {devices/lab_pin.sym} 114780 -20430 0 0 {name=p114063 lab=_43917_/X }
C {devices/lab_pin.sym} 114940 -20510 0 1 {name=p114064 lab=_43918_/Y }
C {sky130_stdcells/o32ai_4.sym} 114860 -20510 0 0 {name=X_43918_ }
C {devices/lab_pin.sym} 114820 -20350 0 0 {name=p114065 lab=_60273_/A }
C {devices/lab_pin.sym} 114900 -20350 0 1 {name=p114066 lab=_62762_/B }
C {sky130_stdcells/buf_2.sym} 114860 -20350 0 0 {name=X_62752_ }
C {devices/lab_pin.sym} 114820 -20230 0 0 {name=p114067 lab=_74738_/A }
C {devices/lab_pin.sym} 114900 -20230 0 1 {name=p114068 lab=_74740_/B }
C {sky130_stdcells/inv_2.sym} 114860 -20230 0 0 {name=X_74738_ }
C {devices/lab_pin.sym} 114820 -20110 0 0 {name=p114069 lab=_83552_/Q }
C {devices/lab_pin.sym} 114900 -20110 0 1 {name=p114070 lab=_54880_/B }
C {sky130_stdcells/inv_2.sym} 114860 -20110 0 0 {name=X_47686_ }
C {devices/lab_pin.sym} 114820 -19990 0 0 {name=p114071 lab=_45757_/A }
C {devices/lab_pin.sym} 114900 -19990 0 1 {name=p114072 lab=_44898_/X }
C {sky130_stdcells/buf_2.sym} 114860 -19990 0 0 {name=X_44898_ }
C {devices/lab_pin.sym} 114800 -19900 0 0 {name=p114073 lab=_49420_/A }
C {devices/lab_pin.sym} 114800 -19860 0 0 {name=p114074 lab=_49447_/B }
C {devices/lab_pin.sym} 114800 -19820 0 0 {name=p114075 lab=_49420_/C }
C {devices/lab_pin.sym} 114800 -19780 0 0 {name=p114076 lab=_46728_/X }
C {devices/lab_pin.sym} 114920 -19840 0 1 {name=p114077 lab=_49425_/X }
C {sky130_stdcells/and4_4.sym} 114860 -19840 0 0 {name=X_49425_ }
C {devices/lab_pin.sym} 114800 -19720 0 0 {name=p114078 lab=_61770_/A }
C {devices/lab_pin.sym} 114800 -19680 0 0 {name=p114079 lab=_61770_/B }
C {devices/lab_pin.sym} 114800 -19640 0 0 {name=p114080 lab=_59477_/A }
C {devices/lab_pin.sym} 114800 -19600 0 0 {name=p114081 lab=_61770_/D }
C {devices/lab_pin.sym} 114920 -19660 0 1 {name=p114082 lab=_61703_/X }
C {sky130_stdcells/and4_4.sym} 114860 -19660 0 0 {name=X_61703_ }
C {devices/lab_pin.sym} 114820 -19510 0 0 {name=p114083 lab=_46637_/A }
C {devices/lab_pin.sym} 114900 -19510 0 1 {name=p114084 lab=_46638_/A }
C {sky130_stdcells/inv_2.sym} 114860 -19510 0 0 {name=X_46637_ }
C {devices/lab_pin.sym} 114800 -19400 0 0 {name=p114085 lab=_65592_/A }
C {devices/lab_pin.sym} 114800 -19360 0 0 {name=p114086 lab=_72840_/B }
C {devices/lab_pin.sym} 114920 -19380 0 1 {name=p114087 lab=_65471_/X }
C {sky130_stdcells/and2_4.sym} 114860 -19380 0 0 {name=X_65471_ }
C {devices/lab_pin.sym} 114800 -19260 0 0 {name=p114088 lab=_77455_/Y }
C {devices/lab_pin.sym} 114800 -19220 0 0 {name=p114089 lab=_77456_/X }
C {devices/lab_pin.sym} 114920 -19240 0 1 {name=p114090 lab=_77458_/B }
C {sky130_stdcells/xor2_4.sym} 114860 -19240 0 0 {name=X_77457_ }
C {devices/lab_pin.sym} 114820 -19110 0 0 {name=p114091 lab=_43848_/Y }
C {devices/lab_pin.sym} 114900 -19110 0 1 {name=p114092 lab=_87236_/D }
C {sky130_stdcells/inv_2.sym} 114860 -19110 0 0 {name=X_43849_ }
C {devices/lab_pin.sym} 114800 -19020 0 0 {name=p114093 lab=_61356_/X }
C {devices/lab_pin.sym} 114800 -18980 0 0 {name=p114094 lab=_62694_/B }
C {devices/lab_pin.sym} 114800 -18940 0 0 {name=p114095 lab=_62694_/C }
C {devices/lab_pin.sym} 114800 -18900 0 0 {name=p114096 lab=_62664_/D }
C {devices/lab_pin.sym} 114920 -18960 0 1 {name=p114097 lab=_62683_/Y }
C {sky130_stdcells/nand4_4.sym} 114860 -18960 0 0 {name=X_62683_ }
C {devices/lab_pin.sym} 114820 -18810 0 0 {name=p114098 lab=_74669_/A }
C {devices/lab_pin.sym} 114900 -18810 0 1 {name=p114099 lab=_82991_/D }
C {sky130_stdcells/inv_2.sym} 114860 -18810 0 0 {name=X_74669_ }
C {devices/lab_pin.sym} 114780 -18710 0 0 {name=p114100 lab=_80903_/D }
C {devices/lab_pin.sym} 114780 -18670 0 0 {name=p114101 lab=_67092_/X }
C {devices/lab_pin.sym} 114780 -18630 0 0 {name=p114102 lab=_67209_/X }
C {devices/lab_pin.sym} 114940 -18670 0 1 {name=p114103 lab=_67210_/X }
C {sky130_stdcells/a21bo_4.sym} 114860 -18670 0 0 {name=X_67210_ }
C {devices/lab_pin.sym} 114800 -18550 0 0 {name=p114104 lab=_64402_/X }
C {devices/lab_pin.sym} 114800 -18510 0 0 {name=p114105 lab=_64421_/X }
C {devices/lab_pin.sym} 114800 -18470 0 0 {name=p114106 lab=_64422_/C }
C {devices/lab_pin.sym} 114920 -18510 0 1 {name=p114107 lab=_64422_/X }
C {sky130_stdcells/and3_4.sym} 114860 -18510 0 0 {name=X_64422_ }
C {devices/lab_pin.sym} 114820 -18370 0 0 {name=p114108 lab=_81652_/Q }
C {devices/lab_pin.sym} 114900 -18370 0 1 {name=p114109 lab=_76408_/Y }
C {sky130_stdcells/inv_2.sym} 114860 -18370 0 0 {name=X_76408_ }
C {devices/lab_pin.sym} 114800 -18260 0 0 {name=p114110 lab=_49302_/A }
C {devices/lab_pin.sym} 114800 -18220 0 0 {name=p114111 lab=_51394_/B }
C {devices/lab_pin.sym} 114920 -18240 0 1 {name=p114112 lab=_49356_/Y }
C {sky130_stdcells/nand2_4.sym} 114860 -18240 0 0 {name=X_49356_ }
C {devices/lab_pin.sym} 114800 -18130 0 0 {name=p114113 lab=_61634_/A }
C {devices/lab_pin.sym} 114800 -18090 0 0 {name=p114114 lab=_61634_/B }
C {devices/lab_pin.sym} 114800 -18050 0 0 {name=p114115 lab=_79132_/B }
C {devices/lab_pin.sym} 114920 -18090 0 1 {name=p114116 lab=_61634_/Y }
C {sky130_stdcells/nor3_4.sym} 114860 -18090 0 0 {name=X_61634_ }
C {devices/lab_pin.sym} 114780 -17970 0 0 {name=p114117 lab=_67181_/X }
C {devices/lab_pin.sym} 114780 -17930 0 0 {name=p114118 lab=_67184_/X }
C {devices/lab_pin.sym} 114780 -17890 0 0 {name=p114119 lab=_68169_/X }
C {devices/lab_pin.sym} 114940 -17930 0 1 {name=p114120 lab=_68190_/Y }
C {sky130_stdcells/a21oi_4.sym} 114860 -17930 0 0 {name=X_68190_ }
C {devices/lab_pin.sym} 114780 -17810 0 0 {name=p114121 lab=_46525_/X }
C {devices/lab_pin.sym} 114780 -17770 0 0 {name=p114122 lab=_81189_/Q }
C {devices/lab_pin.sym} 114780 -17730 0 0 {name=p114123 lab=_46567_/X }
C {devices/lab_pin.sym} 114940 -17770 0 1 {name=p114124 lab=_51380_/B }
C {sky130_stdcells/o21ai_4.sym} 114860 -17770 0 0 {name=X_46568_ }
C {devices/lab_pin.sym} 114780 -17650 0 0 {name=p114125 lab=_77396_/B }
C {devices/lab_pin.sym} 114780 -17610 0 0 {name=p114126 lab=_77374_/B }
C {devices/lab_pin.sym} 114780 -17570 0 0 {name=p114127 lab=_77387_/X }
C {devices/lab_pin.sym} 114940 -17610 0 1 {name=p114128 lab=_77388_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -17610 0 0 {name=X_77388_ }
C {devices/lab_pin.sym} 114820 -17470 0 0 {name=p114129 lab=_48079_/B }
C {devices/lab_pin.sym} 114900 -17470 0 1 {name=p114130 lab=_57609_/B }
C {sky130_stdcells/buf_2.sym} 114860 -17470 0 0 {name=X_48307_ }
C {devices/lab_pin.sym} 114820 -17350 0 0 {name=p114131 lab=_64608_/A }
C {devices/lab_pin.sym} 114900 -17350 0 1 {name=p114132 lab=_67141_/X }
C {sky130_stdcells/buf_2.sym} 114860 -17350 0 0 {name=X_67141_ }
C {devices/lab_pin.sym} 114800 -17240 0 0 {name=p114133 lab=_79127_/A }
C {devices/lab_pin.sym} 114800 -17200 0 0 {name=p114134 lab=_61690_/C }
C {devices/lab_pin.sym} 114920 -17220 0 1 {name=p114135 lab=_79127_/X }
C {sky130_stdcells/xor2_4.sym} 114860 -17220 0 0 {name=X_79127_ }
C {devices/lab_pin.sym} 114820 -17090 0 0 {name=p114136 lab=_57397_/B }
C {devices/lab_pin.sym} 114900 -17090 0 1 {name=p114137 lab=_45519_/Y }
C {sky130_stdcells/inv_2.sym} 114860 -17090 0 0 {name=X_45519_ }
C {devices/lab_pin.sym} 114800 -16990 0 0 {name=p114138 lab=_64319_/X }
C {devices/lab_pin.sym} 114800 -16950 0 0 {name=p114139 lab=_64353_/B }
C {devices/lab_pin.sym} 114800 -16910 0 0 {name=p114140 lab=_64333_/X }
C {devices/lab_pin.sym} 114920 -16950 0 1 {name=p114141 lab=_64353_/X }
C {sky130_stdcells/and3_4.sym} 114860 -16950 0 0 {name=X_64353_ }
C {devices/lab_pin.sym} 114800 -16820 0 0 {name=p114142 lab=_76313_/X }
C {devices/lab_pin.sym} 114800 -16780 0 0 {name=p114143 lab=_76317_/B }
C {devices/lab_pin.sym} 114920 -16800 0 1 {name=p114144 lab=_76339_/X }
C {sky130_stdcells/xor2_4.sym} 114860 -16800 0 0 {name=X_76339_ }
C {devices/lab_pin.sym} 114800 -16680 0 0 {name=p114145 lab=_49287_/A }
C {devices/lab_pin.sym} 114800 -16640 0 0 {name=p114146 lab=_51316_/B }
C {devices/lab_pin.sym} 114920 -16660 0 1 {name=p114147 lab=_49287_/Y }
C {sky130_stdcells/nand2_4.sym} 114860 -16660 0 0 {name=X_49287_ }
C {devices/lab_pin.sym} 114780 -16570 0 0 {name=p114148 lab=_61558_/Y }
C {devices/lab_pin.sym} 114780 -16530 0 0 {name=p114149 lab=_61560_/Y }
C {devices/lab_pin.sym} 114780 -16490 0 0 {name=p114150 lab=_61525_/X }
C {devices/lab_pin.sym} 114780 -16450 0 0 {name=p114151 lab=_61561_/Y }
C {devices/lab_pin.sym} 114780 -16420 0 0 {name=p114152 lab=_61564_/Y }
C {devices/lab_pin.sym} 114940 -16490 0 1 {name=p114153 lab=_61565_/X }
C {sky130_stdcells/a41o_4.sym} 114860 -16490 0 0 {name=X_61565_ }
C {devices/lab_pin.sym} 114780 -16350 0 0 {name=p114154 lab=_46492_/Y }
C {devices/lab_pin.sym} 114780 -16310 0 0 {name=p114155 lab=_46445_/X }
C {devices/lab_pin.sym} 114780 -16270 0 0 {name=p114156 lab=_46498_/X }
C {devices/lab_pin.sym} 114940 -16310 0 1 {name=p114157 lab=_46499_/Y }
C {sky130_stdcells/a21oi_4.sym} 114860 -16310 0 0 {name=X_46499_ }
C {devices/lab_pin.sym} 114820 -16170 0 0 {name=p114158 lab=_44173_/X }
C {devices/lab_pin.sym} 114900 -16170 0 1 {name=p114159 lab=_63528_/A }
C {sky130_stdcells/buf_2.sym} 114860 -16170 0 0 {name=X_63304_ }
C {devices/lab_pin.sym} 114820 -16050 0 0 {name=p114160 lab=_47957_/B }
C {devices/lab_pin.sym} 114900 -16050 0 1 {name=p114161 lab=_53516_/B }
C {sky130_stdcells/buf_2.sym} 114860 -16050 0 0 {name=X_48238_ }
C {devices/lab_pin.sym} 114800 -15950 0 0 {name=p114162 lab=_60435_/A }
C {devices/lab_pin.sym} 114800 -15910 0 0 {name=p114163 lab=_60516_/B }
C {devices/lab_pin.sym} 114800 -15870 0 0 {name=p114164 lab=_60515_/Y }
C {devices/lab_pin.sym} 114920 -15910 0 1 {name=p114165 lab=_60516_/Y }
C {sky130_stdcells/nand3_4.sym} 114860 -15910 0 0 {name=X_60516_ }
C {devices/lab_pin.sym} 114780 -15800 0 0 {name=p114166 lab=_87358_/Q }
C {devices/lab_pin.sym} 114780 -15760 0 0 {name=p114167 lab=_66997_/X }
C {devices/lab_pin.sym} 114780 -15720 0 0 {name=p114168 lab=_66998_/X }
C {devices/lab_pin.sym} 114780 -15680 0 0 {name=p114169 lab=_67071_/X }
C {devices/lab_pin.sym} 114940 -15740 0 1 {name=p114170 lab=_67072_/X }
C {sky130_stdcells/a211o_4.sym} 114860 -15740 0 0 {name=X_67072_ }
C {devices/lab_pin.sym} 114800 -15600 0 0 {name=p114171 lab=_79058_/A }
C {devices/lab_pin.sym} 114800 -15560 0 0 {name=p114172 lab=_79058_/B }
C {devices/lab_pin.sym} 114920 -15580 0 1 {name=p114173 lab=_82621_/D }
C {sky130_stdcells/nand2_4.sym} 114860 -15580 0 0 {name=X_79058_ }
C {devices/lab_pin.sym} 114800 -15470 0 0 {name=p114174 lab=_64275_/A }
C {devices/lab_pin.sym} 114800 -15430 0 0 {name=p114175 lab=_64284_/B }
C {devices/lab_pin.sym} 114800 -15390 0 0 {name=p114176 lab=_64274_/X }
C {devices/lab_pin.sym} 114920 -15430 0 1 {name=p114177 lab=_64284_/X }
C {sky130_stdcells/and3_4.sym} 114860 -15430 0 0 {name=X_64284_ }
C {devices/lab_pin.sym} 114800 -15310 0 0 {name=p114178 lab=_61518_/A }
C {devices/lab_pin.sym} 114800 -15270 0 0 {name=p114179 lab=_61518_/B }
C {devices/lab_pin.sym} 114800 -15230 0 0 {name=p114180 lab=_84476_/Q }
C {devices/lab_pin.sym} 114920 -15270 0 1 {name=p114181 lab=_61496_/Y }
C {sky130_stdcells/nor3_4.sym} 114860 -15270 0 0 {name=X_61496_ }
C {devices/lab_pin.sym} 114780 -15160 0 0 {name=p114182 lab=_65990_/X }
C {devices/lab_pin.sym} 114780 -15120 0 0 {name=p114183 lab=_86233_/Q }
C {devices/lab_pin.sym} 114780 -15080 0 0 {name=p114184 lab=_66021_/X }
C {devices/lab_pin.sym} 114780 -15040 0 0 {name=p114185 lab=_66022_/X }
C {devices/lab_pin.sym} 114940 -15100 0 1 {name=p114186 lab=_66023_/X }
C {sky130_stdcells/a211o_4.sym} 114860 -15100 0 0 {name=X_66023_ }
C {devices/lab_pin.sym} 114800 -14960 0 0 {name=p114187 lab=_78009_/A }
C {devices/lab_pin.sym} 114800 -14920 0 0 {name=p114188 lab=_78024_/A }
C {devices/lab_pin.sym} 114920 -14940 0 1 {name=p114189 lab=_78018_/A }
C {sky130_stdcells/xnor2_4.sym} 114860 -14940 0 0 {name=X_78009_ }
C {devices/lab_pin.sym} 114820 -14810 0 0 {name=p114190 lab=_63118_/A }
C {devices/lab_pin.sym} 114900 -14810 0 1 {name=p114191 lab=_63235_/X }
C {sky130_stdcells/buf_2.sym} 114860 -14810 0 0 {name=X_63235_ }
C {devices/lab_pin.sym} 114820 -14690 0 0 {name=p114192 lab=_48897_/A }
C {devices/lab_pin.sym} 114900 -14690 0 1 {name=p114193 lab=_48169_/X }
C {sky130_stdcells/buf_2.sym} 114860 -14690 0 0 {name=X_48169_ }
C {devices/lab_pin.sym} 114800 -14590 0 0 {name=p114194 lab=_60447_/A }
C {devices/lab_pin.sym} 114800 -14550 0 0 {name=p114195 lab=_60447_/B }
C {devices/lab_pin.sym} 114800 -14510 0 0 {name=p114196 lab=_60515_/A }
C {devices/lab_pin.sym} 114920 -14550 0 1 {name=p114197 lab=_60529_/B }
C {sky130_stdcells/nor3_4.sym} 114860 -14550 0 0 {name=X_60447_ }
C {devices/lab_pin.sym} 114780 -14430 0 0 {name=p114198 lab=_86244_/Q }
C {devices/lab_pin.sym} 114780 -14390 0 0 {name=p114199 lab=_50185_/X }
C {devices/lab_pin.sym} 114780 -14350 0 0 {name=p114200 lab=_50199_/Y }
C {devices/lab_pin.sym} 114940 -14390 0 1 {name=p114201 lab=_50200_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -14390 0 0 {name=X_50200_ }
C {devices/lab_pin.sym} 114770 -14250 0 0 {name=p114202 lab=_84150_/CLK }
C {devices/lab_pin.sym} 114770 -14230 0 0 {name=p114203 lab=_84228_/Q }
C {devices/lab_pin.sym} 114950 -14250 0 1 {name=p114204 lab=_81020_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -14240 0 0 {name=X_81020_ }
C {devices/lab_pin.sym} 114780 -14130 0 0 {name=p114205 lab=_86059_/Q }
C {devices/lab_pin.sym} 114780 -14090 0 0 {name=p114206 lab=_51156_/X }
C {devices/lab_pin.sym} 114780 -14050 0 0 {name=p114207 lab=_51179_/Y }
C {devices/lab_pin.sym} 114940 -14090 0 1 {name=p114208 lab=_51180_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -14090 0 0 {name=X_51180_ }
C {devices/lab_pin.sym} 114800 -13980 0 0 {name=p114209 lab=_63154_/X }
C {devices/lab_pin.sym} 114800 -13940 0 0 {name=p114210 lab=_64378_/B }
C {devices/lab_pin.sym} 114800 -13900 0 0 {name=p114211 lab=_63165_/X }
C {devices/lab_pin.sym} 114800 -13860 0 0 {name=p114212 lab=_63121_/D }
C {devices/lab_pin.sym} 114920 -13920 0 1 {name=p114213 lab=_63166_/X }
C {sky130_stdcells/and4_4.sym} 114860 -13920 0 0 {name=X_63166_ }
C {devices/lab_pin.sym} 114820 -13770 0 0 {name=p114214 lab=clkbuf_9_140_0_CLK/X }
C {devices/lab_pin.sym} 114900 -13770 0 1 {name=p114215 lab=_83482_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 114860 -13770 0 0 {name=Xclkbuf_10_280_0_CLK }
C {devices/lab_pin.sym} 114800 -13670 0 0 {name=p114216 lab=_60639_/A }
C {devices/lab_pin.sym} 114800 -13630 0 0 {name=p114217 lab=_59536_/A }
C {devices/lab_pin.sym} 114800 -13590 0 0 {name=p114218 lab=_61285_/C }
C {devices/lab_pin.sym} 114920 -13630 0 1 {name=p114219 lab=_60378_/Y }
C {sky130_stdcells/nand3_4.sym} 114860 -13630 0 0 {name=X_60378_ }
C {devices/lab_pin.sym} 114800 -13500 0 0 {name=p114220 lab=_50131_/A }
C {devices/lab_pin.sym} 114800 -13460 0 0 {name=p114221 lab=_53858_/B }
C {devices/lab_pin.sym} 114920 -13480 0 1 {name=p114222 lab=_50131_/X }
C {sky130_stdcells/and2_4.sym} 114860 -13480 0 0 {name=X_50131_ }
C {devices/lab_pin.sym} 114820 -13350 0 0 {name=p114223 lab=_62088_/B }
C {devices/lab_pin.sym} 114900 -13350 0 1 {name=p114224 lab=_62117_/X }
C {sky130_stdcells/buf_2.sym} 114860 -13350 0 0 {name=X_62117_ }
C {devices/lab_pin.sym} 114820 -13230 0 0 {name=p114225 lab=_66554_/X }
C {devices/lab_pin.sym} 114900 -13230 0 1 {name=p114226 lab=_68044_/A }
C {sky130_stdcells/buf_2.sym} 114860 -13230 0 0 {name=X_67974_ }
C {devices/lab_pin.sym} 114800 -13140 0 0 {name=p114227 lab=_63097_/A }
C {devices/lab_pin.sym} 114800 -13100 0 0 {name=p114228 lab=_64305_/B }
C {devices/lab_pin.sym} 114800 -13060 0 0 {name=p114229 lab=_63085_/C }
C {devices/lab_pin.sym} 114800 -13020 0 0 {name=p114230 lab=_63085_/D }
C {devices/lab_pin.sym} 114920 -13080 0 1 {name=p114231 lab=_63097_/X }
C {sky130_stdcells/and4_4.sym} 114860 -13080 0 0 {name=X_63097_ }
C {devices/lab_pin.sym} 114820 -12930 0 0 {name=p114232 lab=clkbuf_9_31_0_CLK/X }
C {devices/lab_pin.sym} 114900 -12930 0 1 {name=p114233 lab=_85034_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 114860 -12930 0 0 {name=Xclkbuf_10_62_0_CLK }
C {devices/lab_pin.sym} 114800 -12820 0 0 {name=p114234 lab=_69680_/A }
C {devices/lab_pin.sym} 114800 -12780 0 0 {name=p114235 lab=_88328_/Q }
C {devices/lab_pin.sym} 114920 -12800 0 1 {name=p114236 lab=_69713_/X }
C {sky130_stdcells/and2_4.sym} 114860 -12800 0 0 {name=X_69713_ }
C {devices/lab_pin.sym} 114820 -12670 0 0 {name=p114237 lab=_47832_/A }
C {devices/lab_pin.sym} 114900 -12670 0 1 {name=p114238 lab=_50063_/A }
C {sky130_stdcells/buf_2.sym} 114860 -12670 0 0 {name=X_50062_ }
C {devices/lab_pin.sym} 114820 -12550 0 0 {name=p114239 lab=_66563_/A }
C {devices/lab_pin.sym} 114900 -12550 0 1 {name=p114240 lab=_67046_/A }
C {sky130_stdcells/buf_2.sym} 114860 -12550 0 0 {name=X_66925_ }
C {devices/lab_pin.sym} 114820 -12430 0 0 {name=p114241 lab=_61719_/A }
C {devices/lab_pin.sym} 114900 -12430 0 1 {name=p114242 lab=_62048_/X }
C {sky130_stdcells/buf_2.sym} 114860 -12430 0 0 {name=X_62048_ }
C {devices/lab_pin.sym} 114770 -12310 0 0 {name=p114243 lab=_82394_/CLK }
C {devices/lab_pin.sym} 114770 -12290 0 0 {name=p114244 lab=_82779_/Q }
C {devices/lab_pin.sym} 114950 -12310 0 1 {name=p114245 lab=_46680_/A }
C {sky130_stdcells/dfxtp_4.sym} 114860 -12300 0 0 {name=X_82971_ }
C {devices/lab_pin.sym} 114770 -12170 0 0 {name=p114246 lab=_84355_/CLK }
C {devices/lab_pin.sym} 114770 -12150 0 0 {name=p114247 lab=_59703_/Y }
C {devices/lab_pin.sym} 114950 -12170 0 1 {name=p114248 lab=_80588_/A }
C {sky130_stdcells/dfxtp_4.sym} 114860 -12160 0 0 {name=X_84710_ }
C {devices/lab_pin.sym} 114820 -12030 0 0 {name=p114249 lab=_64732_/A }
C {devices/lab_pin.sym} 114900 -12030 0 1 {name=p114250 lab=_69644_/X }
C {sky130_stdcells/buf_2.sym} 114860 -12030 0 0 {name=X_69644_ }
C {devices/lab_pin.sym} 114770 -11910 0 0 {name=p114251 lab=_82145_/CLK }
C {devices/lab_pin.sym} 114770 -11890 0 0 {name=p114252 lab=_81922_/D }
C {devices/lab_pin.sym} 114950 -11910 0 1 {name=p114253 lab=_81922_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -11900 0 0 {name=X_81922_ }
C {devices/lab_pin.sym} 114820 -11770 0 0 {name=p114254 lab=clkbuf_6_53_0_CLK/X }
C {devices/lab_pin.sym} 114900 -11770 0 1 {name=p114255 lab=clkbuf_8_215_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 114860 -11770 0 0 {name=Xclkbuf_7_107_0_CLK }
C {devices/lab_pin.sym} 114820 -11650 0 0 {name=p114256 lab=clkbuf_9_147_0_CLK/X }
C {devices/lab_pin.sym} 114900 -11650 0 1 {name=p114257 lab=_83402_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 114860 -11650 0 0 {name=Xclkbuf_10_295_0_CLK }
C {devices/lab_pin.sym} 114780 -11550 0 0 {name=p114258 lab=_54868_/Y }
C {devices/lab_pin.sym} 114780 -11510 0 0 {name=p114259 lab=_54856_/X }
C {devices/lab_pin.sym} 114780 -11470 0 0 {name=p114260 lab=_54869_/X }
C {devices/lab_pin.sym} 114940 -11510 0 1 {name=p114261 lab=_54870_/Y }
C {sky130_stdcells/a21oi_4.sym} 114860 -11510 0 0 {name=X_54870_ }
C {devices/lab_pin.sym} 114780 -11390 0 0 {name=p114262 lab=_66853_/X }
C {devices/lab_pin.sym} 114780 -11350 0 0 {name=p114263 lab=_66855_/X }
C {devices/lab_pin.sym} 114780 -11310 0 0 {name=p114264 lab=_66787_/X }
C {devices/lab_pin.sym} 114940 -11350 0 1 {name=p114265 lab=_66859_/A }
C {sky130_stdcells/a21o_4.sym} 114860 -11350 0 0 {name=X_66856_ }
C {devices/lab_pin.sym} 114770 -11210 0 0 {name=p114266 lab=_85688_/CLK }
C {devices/lab_pin.sym} 114770 -11190 0 0 {name=p114267 lab=_85690_/D }
C {devices/lab_pin.sym} 114950 -11210 0 1 {name=p114268 lab=_85690_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -11200 0 0 {name=X_85690_ }
C {devices/lab_pin.sym} 114800 -11080 0 0 {name=p114269 lab=_71994_/B }
C {devices/lab_pin.sym} 114800 -11040 0 0 {name=p114270 lab=_53821_/B }
C {devices/lab_pin.sym} 114920 -11060 0 1 {name=p114271 lab=_53821_/Y }
C {sky130_stdcells/nand2_4.sym} 114860 -11060 0 0 {name=X_53821_ }
C {devices/lab_pin.sym} 114800 -10940 0 0 {name=p114272 lab=_65807_/A }
C {devices/lab_pin.sym} 114800 -10900 0 0 {name=p114273 lab=_86472_/Q }
C {devices/lab_pin.sym} 114920 -10920 0 1 {name=p114274 lab=_65807_/X }
C {sky130_stdcells/and2_4.sym} 114860 -10920 0 0 {name=X_65807_ }
C {devices/lab_pin.sym} 114770 -10790 0 0 {name=p114275 lab=_84620_/CLK }
C {devices/lab_pin.sym} 114770 -10770 0 0 {name=p114276 lab=_60287_/X }
C {devices/lab_pin.sym} 114950 -10790 0 1 {name=p114277 lab=_79797_/A }
C {sky130_stdcells/dfxtp_4.sym} 114860 -10780 0 0 {name=X_84641_ }
C {devices/lab_pin.sym} 114820 -10650 0 0 {name=p114278 lab=_69575_/A }
C {devices/lab_pin.sym} 114900 -10650 0 1 {name=p114279 lab=_69575_/X }
C {sky130_stdcells/buf_2.sym} 114860 -10650 0 0 {name=X_69575_ }
C {devices/lab_pin.sym} 114770 -10530 0 0 {name=p114280 lab=_82515_/CLK }
C {devices/lab_pin.sym} 114770 -10510 0 0 {name=p114281 lab=_81885_/Q }
C {devices/lab_pin.sym} 114950 -10530 0 1 {name=p114282 lab=_77630_/A }
C {sky130_stdcells/dfxtp_4.sym} 114860 -10520 0 0 {name=X_81853_ }
C {devices/lab_pin.sym} 114820 -10390 0 0 {name=p114283 lab=_66547_/A }
C {devices/lab_pin.sym} 114900 -10390 0 1 {name=p114284 lab=_66787_/X }
C {sky130_stdcells/buf_2.sym} 114860 -10390 0 0 {name=X_66787_ }
C {devices/lab_pin.sym} 114820 -10270 0 0 {name=p114285 lab=clkbuf_9_38_0_CLK/X }
C {devices/lab_pin.sym} 114900 -10270 0 1 {name=p114286 lab=_84418_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 114860 -10270 0 0 {name=Xclkbuf_10_77_0_CLK }
C {devices/lab_pin.sym} 114800 -10180 0 0 {name=p114287 lab=_64401_/B }
C {devices/lab_pin.sym} 114800 -10140 0 0 {name=p114288 lab=_64029_/B }
C {devices/lab_pin.sym} 114800 -10100 0 0 {name=p114289 lab=_63951_/C }
C {devices/lab_pin.sym} 114800 -10060 0 0 {name=p114290 lab=_64015_/D }
C {devices/lab_pin.sym} 114920 -10120 0 1 {name=p114291 lab=_63999_/Y }
C {sky130_stdcells/nand4_4.sym} 114860 -10120 0 0 {name=X_63999_ }
C {devices/lab_pin.sym} 114800 -9990 0 0 {name=p114292 lab=_56538_/A }
C {devices/lab_pin.sym} 114800 -9950 0 0 {name=p114293 lab=_56535_/X }
C {devices/lab_pin.sym} 114800 -9910 0 0 {name=p114294 lab=_55724_/B }
C {devices/lab_pin.sym} 114920 -9950 0 1 {name=p114295 lab=_56540_/Y }
C {sky130_stdcells/nand3_4.sym} 114860 -9950 0 0 {name=X_56540_ }
C {devices/lab_pin.sym} 114770 -9810 0 0 {name=p114296 lab=_80804_/CLK }
C {devices/lab_pin.sym} 114770 -9790 0 0 {name=p114297 lab=_80804_/D }
C {devices/lab_pin.sym} 114950 -9810 0 1 {name=p114298 lab=_75733_/B }
C {sky130_stdcells/dfxtp_4.sym} 114860 -9800 0 0 {name=X_80804_ }
C {devices/lab_pin.sym} 114820 -9670 0 0 {name=p114299 lab=_66560_/X }
C {devices/lab_pin.sym} 114900 -9670 0 1 {name=p114300 lab=_69007_/A }
C {sky130_stdcells/buf_2.sym} 114860 -9670 0 0 {name=X_68526_ }
C {devices/lab_pin.sym} 114770 -9550 0 0 {name=p114301 lab=_86796_/CLK }
C {devices/lab_pin.sym} 114770 -9530 0 0 {name=p114302 lab=_87360_/D }
C {devices/lab_pin.sym} 114950 -9550 0 1 {name=p114303 lab=_87360_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -9540 0 0 {name=X_87360_ }
C {devices/lab_pin.sym} 114800 -9430 0 0 {name=p114304 lab=_48849_/A }
C {devices/lab_pin.sym} 114800 -9390 0 0 {name=p114305 lab=_53748_/B }
C {devices/lab_pin.sym} 114800 -9350 0 0 {name=p114306 lab=_53748_/C }
C {devices/lab_pin.sym} 114920 -9390 0 1 {name=p114307 lab=_53752_/X }
C {sky130_stdcells/and3_4.sym} 114860 -9390 0 0 {name=X_53752_ }
C {devices/lab_pin.sym} 114820 -9250 0 0 {name=p114308 lab=clkbuf_8_223_0_CLK/A }
C {devices/lab_pin.sym} 114900 -9250 0 1 {name=p114309 lab=clkbuf_9_446_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 114860 -9250 0 0 {name=Xclkbuf_8_223_0_CLK }
C {devices/lab_pin.sym} 114820 -9130 0 0 {name=p114310 lab=_64834_/A }
C {devices/lab_pin.sym} 114900 -9130 0 1 {name=p114311 lab=_65741_/B }
C {sky130_stdcells/buf_2.sym} 114860 -9130 0 0 {name=X_65738_ }
C {devices/lab_pin.sym} 114770 -9010 0 0 {name=p114312 lab=_84583_/CLK }
C {devices/lab_pin.sym} 114770 -8990 0 0 {name=p114313 lab=_60764_/Y }
C {devices/lab_pin.sym} 114950 -9010 0 1 {name=p114314 lab=_84572_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -9000 0 0 {name=X_84572_ }
C {devices/lab_pin.sym} 114780 -8890 0 0 {name=p114315 lab=_50962_/Y }
C {devices/lab_pin.sym} 114780 -8850 0 0 {name=p114316 lab=_50957_/X }
C {devices/lab_pin.sym} 114780 -8810 0 0 {name=p114317 lab=_50963_/X }
C {devices/lab_pin.sym} 114940 -8850 0 1 {name=p114318 lab=_50964_/Y }
C {sky130_stdcells/a21oi_4.sym} 114860 -8850 0 0 {name=X_50964_ }
C {devices/lab_pin.sym} 114770 -8710 0 0 {name=p114319 lab=_88121_/CLK }
C {devices/lab_pin.sym} 114770 -8690 0 0 {name=p114320 lab=_76136_/X }
C {devices/lab_pin.sym} 114950 -8710 0 1 {name=p114321 lab=_81784_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -8700 0 0 {name=X_81784_ }
C {devices/lab_pin.sym} 114770 -8570 0 0 {name=p114322 lab=_86627_/CLK }
C {devices/lab_pin.sym} 114770 -8550 0 0 {name=p114323 lab=_86311_/D }
C {devices/lab_pin.sym} 114950 -8570 0 1 {name=p114324 lab=_58070_/B }
C {sky130_stdcells/dfxtp_4.sym} 114860 -8560 0 0 {name=X_86311_ }
C {devices/lab_pin.sym} 114820 -8430 0 0 {name=p114325 lab=_52648_/A }
C {devices/lab_pin.sym} 114900 -8430 0 1 {name=p114326 lab=_52704_/A }
C {sky130_stdcells/buf_2.sym} 114860 -8430 0 0 {name=X_52703_ }
C {devices/lab_pin.sym} 114770 -8310 0 0 {name=p114327 lab=_83526_/CLK }
C {devices/lab_pin.sym} 114770 -8290 0 0 {name=p114328 lab=_71367_/X }
C {devices/lab_pin.sym} 114950 -8310 0 1 {name=p114329 lab=_83523_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -8300 0 0 {name=X_83523_ }
C {devices/lab_pin.sym} 114820 -8170 0 0 {name=p114330 lab=_56448_/X }
C {devices/lab_pin.sym} 114900 -8170 0 1 {name=p114331 lab=_56472_/B }
C {sky130_stdcells/buf_2.sym} 114860 -8170 0 0 {name=X_56471_ }
C {devices/lab_pin.sym} 114780 -8080 0 0 {name=p114332 lab=_87100_/Q }
C {devices/lab_pin.sym} 114780 -8040 0 0 {name=p114333 lab=_68455_/X }
C {devices/lab_pin.sym} 114780 -8000 0 0 {name=p114334 lab=_68370_/X }
C {devices/lab_pin.sym} 114780 -7960 0 0 {name=p114335 lab=_68456_/X }
C {devices/lab_pin.sym} 114940 -8020 0 1 {name=p114336 lab=_68457_/X }
C {sky130_stdcells/a211o_4.sym} 114860 -8020 0 0 {name=X_68457_ }
C {devices/lab_pin.sym} 114770 -7870 0 0 {name=p114337 lab=_82211_/CLK }
C {devices/lab_pin.sym} 114770 -7850 0 0 {name=p114338 lab=_80735_/D }
C {devices/lab_pin.sym} 114950 -7870 0 1 {name=p114339 lab=_80703_/D }
C {sky130_stdcells/dfxtp_4.sym} 114860 -7860 0 0 {name=X_80735_ }
C {devices/lab_pin.sym} 114770 -7730 0 0 {name=p114340 lab=_87553_/CLK }
C {devices/lab_pin.sym} 114770 -7710 0 0 {name=p114341 lab=_87291_/D }
C {devices/lab_pin.sym} 114950 -7730 0 1 {name=p114342 lab=_43732_/A }
C {sky130_stdcells/dfxtp_4.sym} 114860 -7720 0 0 {name=X_87291_ }
C {devices/lab_pin.sym} 114800 -7600 0 0 {name=p114343 lab=_53662_/X }
C {devices/lab_pin.sym} 114800 -7560 0 0 {name=p114344 lab=_74428_/B }
C {devices/lab_pin.sym} 114920 -7580 0 1 {name=p114345 lab=_53683_/Y }
C {sky130_stdcells/nand2_4.sym} 114860 -7580 0 0 {name=X_53683_ }
C {devices/lab_pin.sym} 114820 -7450 0 0 {name=p114346 lab=_65669_/A }
C {devices/lab_pin.sym} 114900 -7450 0 1 {name=p114347 lab=_65669_/X }
C {sky130_stdcells/buf_2.sym} 114860 -7450 0 0 {name=X_65669_ }
C {devices/lab_pin.sym} 114820 -7330 0 0 {name=p114348 lab=_46616_/A }
C {devices/lab_pin.sym} 114900 -7330 0 1 {name=p114349 lab=_51033_/A }
C {sky130_stdcells/buf_2.sym} 114860 -7330 0 0 {name=X_50895_ }
C {devices/lab_pin.sym} 114820 -7210 0 0 {name=p114350 lab=_64544_/C }
C {devices/lab_pin.sym} 114900 -7210 0 1 {name=p114351 lab=_58210_/X }
C {sky130_stdcells/buf_2.sym} 114860 -7210 0 0 {name=X_58210_ }
C {devices/lab_pin.sym} 114800 -7100 0 0 {name=p114352 lab=_56807_/A }
C {devices/lab_pin.sym} 114800 -7060 0 0 {name=p114353 lab=_56807_/C }
C {devices/lab_pin.sym} 114920 -7080 0 1 {name=p114354 lab=_55422_/Y }
C {sky130_stdcells/nand2_4.sym} 114860 -7080 0 0 {name=X_55422_ }
C {devices/lab_pin.sym} 114770 -6950 0 0 {name=p114355 lab=_83594_/CLK }
C {devices/lab_pin.sym} 114770 -6930 0 0 {name=p114356 lab=_50210_/Y }
C {devices/lab_pin.sym} 114950 -6950 0 1 {name=p114357 lab=_86242_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -6940 0 0 {name=X_86242_ }
C {devices/lab_pin.sym} 114800 -6820 0 0 {name=p114358 lab=_67381_/A }
C {devices/lab_pin.sym} 114800 -6780 0 0 {name=p114359 lab=_87216_/Q }
C {devices/lab_pin.sym} 114920 -6800 0 1 {name=p114360 lab=_67408_/X }
C {sky130_stdcells/and2_4.sym} 114860 -6800 0 0 {name=X_67408_ }
C {devices/lab_pin.sym} 114820 -6670 0 0 {name=p114361 lab=_52605_/A }
C {devices/lab_pin.sym} 114900 -6670 0 1 {name=p114362 lab=_52654_/B }
C {sky130_stdcells/buf_2.sym} 114860 -6670 0 0 {name=X_52634_ }
C {devices/lab_pin.sym} 114780 -6590 0 0 {name=p114363 lab=_59152_/X }
C {devices/lab_pin.sym} 114780 -6550 0 0 {name=p114364 lab=_59188_/Y }
C {devices/lab_pin.sym} 114780 -6510 0 0 {name=p114365 lab=_59189_/Y }
C {devices/lab_pin.sym} 114780 -6470 0 0 {name=p114366 lab=_59169_/X }
C {devices/lab_pin.sym} 114780 -6430 0 0 {name=p114367 lab=_59156_/X }
C {devices/lab_pin.sym} 114940 -6510 0 1 {name=p114368 lab=_59190_/X }
C {sky130_stdcells/o32a_4.sym} 114860 -6510 0 0 {name=X_59190_ }
C {devices/lab_pin.sym} 114770 -6350 0 0 {name=p114369 lab=_83457_/CLK }
C {devices/lab_pin.sym} 114770 -6330 0 0 {name=p114370 lab=_71566_/X }
C {devices/lab_pin.sym} 114950 -6350 0 1 {name=p114371 lab=_83454_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -6340 0 0 {name=X_83454_ }
C {devices/lab_pin.sym} 114770 -6210 0 0 {name=p114372 lab=_84407_/CLK }
C {devices/lab_pin.sym} 114770 -6190 0 0 {name=p114373 lab=_74843_/Y }
C {devices/lab_pin.sym} 114950 -6210 0 1 {name=p114374 lab=_80666_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -6200 0 0 {name=X_80666_ }
C {devices/lab_pin.sym} 114780 -6100 0 0 {name=p114375 lab=_73577_/A }
C {devices/lab_pin.sym} 114780 -6060 0 0 {name=p114376 lab=_68384_/X }
C {devices/lab_pin.sym} 114780 -6020 0 0 {name=p114377 lab=_68385_/X }
C {devices/lab_pin.sym} 114780 -5980 0 0 {name=p114378 lab=_68387_/Y }
C {devices/lab_pin.sym} 114940 -6040 0 1 {name=p114379 lab=_68388_/X }
C {sky130_stdcells/a211o_4.sym} 114860 -6040 0 0 {name=X_68388_ }
C {sky130_stdcells/decap_3.sym} 114860 -5860 0 0 {name=XPHY_404 }
C {devices/lab_pin.sym} 114780 -5730 0 0 {name=p114380 lab=_58065_/X }
C {devices/lab_pin.sym} 114780 -5690 0 0 {name=p114381 lab=_85698_/Q }
C {devices/lab_pin.sym} 114780 -5650 0 0 {name=p114382 lab=_58089_/X }
C {devices/lab_pin.sym} 114940 -5690 0 1 {name=p114383 lab=_58141_/X }
C {sky130_stdcells/o21a_4.sym} 114860 -5690 0 0 {name=X_58141_ }
C {devices/lab_pin.sym} 114770 -5550 0 0 {name=p114384 lab=_82443_/CLK }
C {devices/lab_pin.sym} 114770 -5530 0 0 {name=p114385 lab=_82437_/Q }
C {devices/lab_pin.sym} 114950 -5550 0 1 {name=p114386 lab=_78344_/A }
C {sky130_stdcells/dfxtp_4.sym} 114860 -5540 0 0 {name=X_82405_ }
C {sky130_stdcells/decap_3.sym} 114860 -5380 0 0 {name=XPHY_415 }
C {devices/lab_pin.sym} 114820 -5230 0 0 {name=p114387 lab=clkbuf_8_239_0_CLK/A }
C {devices/lab_pin.sym} 114900 -5230 0 1 {name=p114388 lab=clkbuf_8_238_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 114860 -5230 0 0 {name=Xclkbuf_8_238_0_CLK }
C {devices/lab_pin.sym} 114800 -5120 0 0 {name=p114389 lab=_55445_/A }
C {devices/lab_pin.sym} 114800 -5080 0 0 {name=p114390 lab=_55445_/C }
C {devices/lab_pin.sym} 114920 -5100 0 1 {name=p114391 lab=_55353_/X }
C {sky130_stdcells/and2_4.sym} 114860 -5100 0 0 {name=X_55353_ }
C {devices/lab_pin.sym} 114780 -5000 0 0 {name=p114392 lab=_86975_/Q }
C {devices/lab_pin.sym} 114780 -4960 0 0 {name=p114393 lab=_67311_/X }
C {devices/lab_pin.sym} 114780 -4920 0 0 {name=p114394 lab=_67313_/X }
C {devices/lab_pin.sym} 114780 -4880 0 0 {name=p114395 lab=_67338_/X }
C {devices/lab_pin.sym} 114940 -4940 0 1 {name=p114396 lab=_67339_/X }
C {sky130_stdcells/a211o_4.sym} 114860 -4940 0 0 {name=X_67339_ }
C {devices/lab_pin.sym} 114770 -4790 0 0 {name=p114397 lab=_83307_/CLK }
C {devices/lab_pin.sym} 114770 -4770 0 0 {name=p114398 lab=_50585_/Y }
C {devices/lab_pin.sym} 114950 -4790 0 1 {name=p114399 lab=_86173_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -4780 0 0 {name=X_86173_ }
C {devices/lab_pin.sym} 114800 -4660 0 0 {name=p114400 lab=_52280_/X }
C {devices/lab_pin.sym} 114800 -4620 0 0 {name=p114401 lab=_52565_/B }
C {devices/lab_pin.sym} 114920 -4640 0 1 {name=p114402 lab=_52565_/Y }
C {sky130_stdcells/nand2_4.sym} 114860 -4640 0 0 {name=X_52565_ }
C {devices/lab_pin.sym} 114820 -4510 0 0 {name=p114403 lab=clkbuf_9_116_0_CLK/X }
C {devices/lab_pin.sym} 114900 -4510 0 1 {name=p114404 lab=_81121_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 114860 -4510 0 0 {name=Xclkbuf_10_233_0_CLK }
C {sky130_stdcells/decap_3.sym} 114860 -4360 0 0 {name=XPHY_426 }
C {devices/lab_pin.sym} 114770 -4210 0 0 {name=p114405 lab=_83415_/CLK }
C {devices/lab_pin.sym} 114770 -4190 0 0 {name=p114406 lab=_83385_/D }
C {devices/lab_pin.sym} 114950 -4210 0 1 {name=p114407 lab=_83385_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -4200 0 0 {name=X_83385_ }
C {devices/lab_pin.sym} 114780 -4100 0 0 {name=p114408 lab=_80596_/B }
C {devices/lab_pin.sym} 114780 -4060 0 0 {name=p114409 lab=_80596_/A }
C {devices/lab_pin.sym} 114780 -4020 0 0 {name=p114410 lab=_80566_/Y }
C {devices/lab_pin.sym} 114780 -3980 0 0 {name=p114411 lab=_80570_/B }
C {devices/lab_pin.sym} 114940 -4040 0 1 {name=p114412 lab=_80598_/C }
C {sky130_stdcells/a211o_4.sym} 114860 -4040 0 0 {name=X_80597_ }
C {sky130_stdcells/decap_3.sym} 114860 -3860 0 0 {name=XPHY_437 }
C {sky130_stdcells/decap_3.sym} 114860 -3680 0 0 {name=XPHY_448 }
C {devices/lab_pin.sym} 114780 -3550 0 0 {name=p114413 lab=_54301_/Y }
C {devices/lab_pin.sym} 114780 -3510 0 0 {name=p114414 lab=_54285_/X }
C {devices/lab_pin.sym} 114780 -3470 0 0 {name=p114415 lab=_54303_/X }
C {devices/lab_pin.sym} 114940 -3510 0 1 {name=p114416 lab=_54304_/Y }
C {sky130_stdcells/a21oi_4.sym} 114860 -3510 0 0 {name=X_54304_ }
C {devices/lab_pin.sym} 114820 -3370 0 0 {name=p114417 lab=clkbuf_9_431_0_CLK/X }
C {devices/lab_pin.sym} 114900 -3370 0 1 {name=p114418 lab=_85527_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 114860 -3370 0 0 {name=Xclkbuf_10_863_0_CLK }
C {sky130_stdcells/decap_3.sym} 114860 -3220 0 0 {name=XPHY_459 }
C {devices/lab_pin.sym} 114770 -3070 0 0 {name=p114419 lab=_82979_/CLK }
C {devices/lab_pin.sym} 114770 -3050 0 0 {name=p114420 lab=_85124_/D }
C {devices/lab_pin.sym} 114950 -3070 0 1 {name=p114421 lab=_56898_/A }
C {sky130_stdcells/dfxtp_4.sym} 114860 -3060 0 0 {name=X_85124_ }
C {devices/lab_pin.sym} 114800 -2960 0 0 {name=p114422 lab=_51509_/A }
C {devices/lab_pin.sym} 114800 -2920 0 0 {name=p114423 lab=_51527_/B }
C {devices/lab_pin.sym} 114800 -2880 0 0 {name=p114424 lab=_51522_/C }
C {devices/lab_pin.sym} 114800 -2840 0 0 {name=p114425 lab=_53044_/D }
C {devices/lab_pin.sym} 114920 -2900 0 1 {name=p114426 lab=_51516_/X }
C {sky130_stdcells/and4_4.sym} 114860 -2900 0 0 {name=X_51516_ }
C {devices/lab_pin.sym} 114800 -2780 0 0 {name=p114427 lab=_70348_/A }
C {devices/lab_pin.sym} 114800 -2740 0 0 {name=p114428 lab=_70348_/B }
C {devices/lab_pin.sym} 114800 -2700 0 0 {name=p114429 lab=_83082_/Q }
C {devices/lab_pin.sym} 114800 -2660 0 0 {name=p114430 lab=_70348_/D }
C {devices/lab_pin.sym} 114920 -2720 0 1 {name=p114431 lab=_70350_/X }
C {sky130_stdcells/and4_4.sym} 114860 -2720 0 0 {name=X_70350_ }
C {devices/lab_pin.sym} 114780 -2610 0 0 {name=p114432 lab=_58010_/X }
C {devices/lab_pin.sym} 114780 -2570 0 0 {name=p114433 lab=_58070_/Y }
C {devices/lab_pin.sym} 114780 -2530 0 0 {name=p114434 lab=_58071_/Y }
C {devices/lab_pin.sym} 114780 -2490 0 0 {name=p114435 lab=_58028_/X }
C {devices/lab_pin.sym} 114780 -2450 0 0 {name=p114436 lab=_58015_/X }
C {devices/lab_pin.sym} 114940 -2530 0 1 {name=p114437 lab=_58072_/X }
C {sky130_stdcells/o32a_4.sym} 114860 -2530 0 0 {name=X_58072_ }
C {devices/lab_pin.sym} 114770 -2370 0 0 {name=p114438 lab=_83974_/CLK }
C {devices/lab_pin.sym} 114770 -2350 0 0 {name=p114439 lab=_77220_/B }
C {devices/lab_pin.sym} 114950 -2370 0 1 {name=p114440 lab=_82336_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -2360 0 0 {name=X_82336_ }
C {devices/lab_pin.sym} 114780 -2250 0 0 {name=p114441 lab=_56868_/A }
C {devices/lab_pin.sym} 114780 -2210 0 0 {name=p114442 lab=_56868_/B }
C {devices/lab_pin.sym} 114780 -2170 0 0 {name=p114443 lab=_55671_/A }
C {devices/lab_pin.sym} 114940 -2210 0 1 {name=p114444 lab=_55284_/X }
C {sky130_stdcells/a21o_4.sym} 114860 -2210 0 0 {name=X_55284_ }
C {devices/lab_pin.sym} 114820 -2070 0 0 {name=p114445 lab=_52496_/A }
C {devices/lab_pin.sym} 114900 -2070 0 1 {name=p114446 lab=_52496_/X }
C {sky130_stdcells/buf_2.sym} 114860 -2070 0 0 {name=X_52496_ }
C {devices/lab_pin.sym} 114820 -1950 0 0 {name=p114447 lab=clkbuf_9_7_0_CLK/X }
C {devices/lab_pin.sym} 114900 -1950 0 1 {name=p114448 lab=_85311_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 114860 -1950 0 0 {name=Xclkbuf_10_15_0_CLK }
C {devices/lab_pin.sym} 114820 -1830 0 0 {name=p114449 lab=_57023_/A }
C {devices/lab_pin.sym} 114900 -1830 0 1 {name=p114450 lab=_57023_/X }
C {sky130_stdcells/buf_2.sym} 114860 -1830 0 0 {name=X_57023_ }
C {devices/lab_pin.sym} 114780 -1740 0 0 {name=p114451 lab=_87993_/Q }
C {devices/lab_pin.sym} 114780 -1700 0 0 {name=p114452 lab=_69007_/X }
C {devices/lab_pin.sym} 114780 -1660 0 0 {name=p114453 lab=_68916_/X }
C {devices/lab_pin.sym} 114780 -1620 0 0 {name=p114454 lab=_69008_/X }
C {devices/lab_pin.sym} 114940 -1680 0 1 {name=p114455 lab=_69009_/X }
C {sky130_stdcells/a211o_4.sym} 114860 -1680 0 0 {name=X_69009_ }
C {devices/lab_pin.sym} 114780 -1550 0 0 {name=p114456 lab=_85479_/Q }
C {devices/lab_pin.sym} 114780 -1510 0 0 {name=p114457 lab=_54220_/X }
C {devices/lab_pin.sym} 114780 -1470 0 0 {name=p114458 lab=_54234_/Y }
C {devices/lab_pin.sym} 114940 -1510 0 1 {name=p114459 lab=_54235_/Y }
C {sky130_stdcells/o21ai_4.sym} 114860 -1510 0 0 {name=X_54235_ }
C {devices/lab_pin.sym} 114820 -1370 0 0 {name=p114460 lab=clkbuf_9_355_0_CLK/A }
C {devices/lab_pin.sym} 114900 -1370 0 1 {name=p114461 lab=clkbuf_9_354_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 114860 -1370 0 0 {name=Xclkbuf_9_354_0_CLK }
C {devices/lab_pin.sym} 114770 -1250 0 0 {name=p114462 lab=_85152_/CLK }
C {devices/lab_pin.sym} 114770 -1230 0 0 {name=p114463 lab=_85055_/D }
C {devices/lab_pin.sym} 114950 -1250 0 1 {name=p114464 lab=_45426_/A }
C {sky130_stdcells/dfxtp_4.sym} 114860 -1240 0 0 {name=X_85055_ }
C {devices/lab_pin.sym} 114820 -1110 0 0 {name=p114465 lab=_51010_/A }
C {devices/lab_pin.sym} 114900 -1110 0 1 {name=p114466 lab=_51557_/A }
C {sky130_stdcells/buf_2.sym} 114860 -1110 0 0 {name=X_51447_ }
C {devices/lab_pin.sym} 114780 -1010 0 0 {name=p114467 lab=_74762_/A }
C {devices/lab_pin.sym} 114780 -970 0 0 {name=p114468 lab=_70157_/A }
C {devices/lab_pin.sym} 114780 -930 0 0 {name=p114469 lab=_70280_/Y }
C {devices/lab_pin.sym} 114940 -970 0 1 {name=p114470 lab=_83812_/D }
C {sky130_stdcells/o21ai_4.sym} 114860 -970 0 0 {name=X_70281_ }
C {devices/lab_pin.sym} 114770 -830 0 0 {name=p114471 lab=_83515_/CLK }
C {devices/lab_pin.sym} 114770 -810 0 0 {name=p114472 lab=_82267_/D }
C {devices/lab_pin.sym} 114950 -830 0 1 {name=p114473 lab=_82267_/Q }
C {sky130_stdcells/dfxtp_4.sym} 114860 -820 0 0 {name=X_82267_ }
C {devices/lab_pin.sym} 114780 -720 0 0 {name=p114474 lab=_41199_/X }
C {devices/lab_pin.sym} 114780 -680 0 0 {name=p114475 lab=_41181_/X }
C {devices/lab_pin.sym} 114780 -640 0 0 {name=p114476 lab=_68775_/B }
C {devices/lab_pin.sym} 114780 -600 0 0 {name=p114477 lab=_41182_/X }
C {devices/lab_pin.sym} 114940 -660 0 1 {name=p114478 lab=_88259_/D }
C {sky130_stdcells/a2bb2o_4.sym} 114860 -660 0 0 {name=X_41200_ }
C {devices/lab_pin.sym} 115720 -42160 0 0 {name=p114479 lab=_71993_/X }
C {devices/lab_pin.sym} 115720 -42120 0 0 {name=p114480 lab=_53844_/B }
C {devices/lab_pin.sym} 115840 -42140 0 1 {name=p114481 lab=_72020_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -42140 0 0 {name=X_72020_ }
C {devices/lab_pin.sym} 115690 -42010 0 0 {name=p114482 lab=_81746_/CLK }
C {devices/lab_pin.sym} 115690 -41990 0 0 {name=p114483 lab=_84006_/D }
C {devices/lab_pin.sym} 115870 -42010 0 1 {name=p114484 lab=_84006_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -42000 0 0 {name=X_84006_ }
C {devices/lab_pin.sym} 115740 -41870 0 0 {name=p114485 lab=clkbuf_9_124_0_CLK/X }
C {devices/lab_pin.sym} 115820 -41870 0 1 {name=p114486 lab=_82221_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 115780 -41870 0 0 {name=Xclkbuf_10_248_0_CLK }
C {devices/lab_pin.sym} 115690 -41750 0 0 {name=p114487 lab=_85315_/CLK }
C {devices/lab_pin.sym} 115690 -41730 0 0 {name=p114488 lab=_81026_/Q }
C {devices/lab_pin.sym} 115870 -41750 0 1 {name=p114489 lab=_81218_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -41740 0 0 {name=X_81218_ }
C {devices/lab_pin.sym} 115700 -41630 0 0 {name=p114490 lab=_54163_/Y }
C {devices/lab_pin.sym} 115700 -41590 0 0 {name=p114491 lab=_54144_/X }
C {devices/lab_pin.sym} 115700 -41550 0 0 {name=p114492 lab=_54165_/X }
C {devices/lab_pin.sym} 115860 -41590 0 1 {name=p114493 lab=_85492_/D }
C {sky130_stdcells/a21oi_4.sym} 115780 -41590 0 0 {name=X_54166_ }
C {devices/lab_pin.sym} 115740 -41450 0 0 {name=p114494 lab=_42180_/A }
C {devices/lab_pin.sym} 115820 -41450 0 1 {name=p114495 lab=_87995_/D }
C {sky130_stdcells/inv_2.sym} 115780 -41450 0 0 {name=X_42180_ }
C {devices/lab_pin.sym} 115720 -41340 0 0 {name=p114496 lab=_51364_/A }
C {devices/lab_pin.sym} 115720 -41300 0 0 {name=p114497 lab=_51378_/B }
C {devices/lab_pin.sym} 115840 -41320 0 1 {name=p114498 lab=_51378_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -41320 0 0 {name=X_51378_ }
C {devices/lab_pin.sym} 115690 -41190 0 0 {name=p114499 lab=_82390_/CLK }
C {devices/lab_pin.sym} 115690 -41170 0 0 {name=p114500 lab=_82198_/D }
C {devices/lab_pin.sym} 115870 -41190 0 1 {name=p114501 lab=_82390_/D }
C {sky130_stdcells/dfxtp_4.sym} 115780 -41180 0 0 {name=X_82198_ }
C {devices/lab_pin.sym} 115740 -41050 0 0 {name=p114502 lab=clkbuf_9_439_0_CLK/X }
C {devices/lab_pin.sym} 115820 -41050 0 1 {name=p114503 lab=_86592_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 115780 -41050 0 0 {name=Xclkbuf_10_878_0_CLK }
C {devices/lab_pin.sym} 115700 -40960 0 0 {name=p114504 lab=_41130_/X }
C {devices/lab_pin.sym} 115700 -40920 0 0 {name=p114505 lab=_41109_/X }
C {devices/lab_pin.sym} 115700 -40880 0 0 {name=p114506 lab=_88272_/Q }
C {devices/lab_pin.sym} 115700 -40840 0 0 {name=p114507 lab=_41110_/X }
C {devices/lab_pin.sym} 115860 -40900 0 1 {name=p114508 lab=_41131_/X }
C {sky130_stdcells/a2bb2o_4.sym} 115780 -40900 0 0 {name=X_41131_ }
C {devices/lab_pin.sym} 115740 -40750 0 0 {name=p114509 lab=_53195_/A }
C {devices/lab_pin.sym} 115820 -40750 0 1 {name=p114510 lab=_53133_/C }
C {sky130_stdcells/buf_2.sym} 115780 -40750 0 0 {name=X_53117_ }
C {devices/lab_pin.sym} 115700 -40650 0 0 {name=p114511 lab=_86222_/Q }
C {devices/lab_pin.sym} 115700 -40610 0 0 {name=p114512 lab=_50238_/X }
C {devices/lab_pin.sym} 115700 -40570 0 0 {name=p114513 lab=_50328_/Y }
C {devices/lab_pin.sym} 115860 -40610 0 1 {name=p114514 lab=_50329_/Y }
C {sky130_stdcells/o21ai_4.sym} 115780 -40610 0 0 {name=X_50329_ }
C {devices/lab_pin.sym} 115690 -40470 0 0 {name=p114515 lab=_82284_/CLK }
C {devices/lab_pin.sym} 115690 -40450 0 0 {name=p114516 lab=_81149_/D }
C {devices/lab_pin.sym} 115870 -40470 0 1 {name=p114517 lab=_81149_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -40460 0 0 {name=X_81149_ }
C {devices/lab_pin.sym} 115720 -40340 0 0 {name=p114518 lab=_53434_/A }
C {devices/lab_pin.sym} 115720 -40300 0 0 {name=p114519 lab=_54097_/B }
C {devices/lab_pin.sym} 115840 -40320 0 1 {name=p114520 lab=_54097_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -40320 0 0 {name=X_54097_ }
C {devices/lab_pin.sym} 115700 -40210 0 0 {name=p114521 lab=_58559_/X }
C {devices/lab_pin.sym} 115700 -40170 0 0 {name=p114522 lab=_83440_/Q }
C {devices/lab_pin.sym} 115700 -40130 0 0 {name=p114523 lab=_58973_/Y }
C {devices/lab_pin.sym} 115860 -40170 0 1 {name=p114524 lab=_84784_/D }
C {sky130_stdcells/o21a_4.sym} 115780 -40170 0 0 {name=X_58974_ }
C {devices/lab_pin.sym} 115740 -40030 0 0 {name=p114525 lab=clkbuf_8_184_0_CLK/X }
C {devices/lab_pin.sym} 115820 -40030 0 1 {name=p114526 lab=clkbuf_9_369_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 115780 -40030 0 0 {name=Xclkbuf_9_369_0_CLK }
C {devices/lab_pin.sym} 115720 -39920 0 0 {name=p114527 lab=_40937_/A }
C {devices/lab_pin.sym} 115720 -39880 0 0 {name=p114528 lab=_41062_/B }
C {devices/lab_pin.sym} 115840 -39900 0 1 {name=p114529 lab=_41062_/X }
C {sky130_stdcells/or2_4.sym} 115780 -39900 0 0 {name=X_41062_ }
C {devices/lab_pin.sym} 115720 -39800 0 0 {name=p114530 lab=_53048_/A }
C {devices/lab_pin.sym} 115720 -39760 0 0 {name=p114531 lab=_53063_/B }
C {devices/lab_pin.sym} 115720 -39720 0 0 {name=p114532 lab=_53058_/C }
C {devices/lab_pin.sym} 115720 -39680 0 0 {name=p114533 lab=_53048_/D }
C {devices/lab_pin.sym} 115840 -39740 0 1 {name=p114534 lab=_53048_/X }
C {sky130_stdcells/and4_4.sym} 115780 -39740 0 0 {name=X_53048_ }
C {devices/lab_pin.sym} 115700 -39610 0 0 {name=p114535 lab=_57760_/X }
C {devices/lab_pin.sym} 115700 -39570 0 0 {name=p114536 lab=_85395_/Q }
C {devices/lab_pin.sym} 115700 -39530 0 0 {name=p114537 lab=_57924_/X }
C {devices/lab_pin.sym} 115860 -39570 0 1 {name=p114538 lab=_57925_/Y }
C {sky130_stdcells/o21ai_4.sym} 115780 -39570 0 0 {name=X_57925_ }
C {devices/lab_pin.sym} 115700 -39460 0 0 {name=p114539 lab=_73850_/X }
C {devices/lab_pin.sym} 115700 -39420 0 0 {name=p114540 lab=_86224_/Q }
C {devices/lab_pin.sym} 115700 -39380 0 0 {name=p114541 lab=_73948_/X }
C {devices/lab_pin.sym} 115700 -39340 0 0 {name=p114542 lab=_73970_/X }
C {devices/lab_pin.sym} 115860 -39400 0 1 {name=p114543 lab=_73971_/X }
C {sky130_stdcells/a211o_4.sym} 115780 -39400 0 0 {name=X_73971_ }
C {devices/lab_pin.sym} 115690 -39250 0 0 {name=p114544 lab=_85957_/CLK }
C {devices/lab_pin.sym} 115690 -39230 0 0 {name=p114545 lab=_85957_/D }
C {devices/lab_pin.sym} 115870 -39250 0 1 {name=p114546 lab=_85957_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -39240 0 0 {name=X_85957_ }
C {devices/lab_pin.sym} 115700 -39130 0 0 {name=p114547 lab=_75704_/B }
C {devices/lab_pin.sym} 115700 -39090 0 0 {name=p114548 lab=_75696_/X }
C {devices/lab_pin.sym} 115700 -39050 0 0 {name=p114549 lab=_75709_/Y }
C {devices/lab_pin.sym} 115860 -39090 0 1 {name=p114550 lab=_75710_/Y }
C {sky130_stdcells/a21oi_4.sym} 115780 -39090 0 0 {name=X_75710_ }
C {devices/lab_pin.sym} 115740 -38950 0 0 {name=p114551 lab=clkbuf_9_400_0_CLK/X }
C {devices/lab_pin.sym} 115820 -38950 0 1 {name=p114552 lab=_82604_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 115780 -38950 0 0 {name=Xclkbuf_10_801_0_CLK }
C {devices/lab_pin.sym} 115720 -38840 0 0 {name=p114553 lab=_87821_/Q }
C {devices/lab_pin.sym} 115720 -38800 0 0 {name=p114554 lab=_73000_/B }
C {devices/lab_pin.sym} 115840 -38820 0 1 {name=p114555 lab=_72922_/Y }
C {sky130_stdcells/nor2_4.sym} 115780 -38820 0 0 {name=X_72922_ }
C {devices/lab_pin.sym} 115690 -38690 0 0 {name=p114556 lab=_84903_/CLK }
C {devices/lab_pin.sym} 115690 -38670 0 0 {name=p114557 lab=_84908_/D }
C {devices/lab_pin.sym} 115870 -38690 0 1 {name=p114558 lab=_64534_/C }
C {sky130_stdcells/dfxtp_4.sym} 115780 -38680 0 0 {name=X_84908_ }
C {devices/lab_pin.sym} 115740 -38550 0 0 {name=p114559 lab=_85026_/Q }
C {devices/lab_pin.sym} 115820 -38550 0 1 {name=p114560 lab=_45870_/Y }
C {sky130_stdcells/inv_2.sym} 115780 -38550 0 0 {name=X_45870_ }
C {devices/lab_pin.sym} 115700 -38460 0 0 {name=p114561 lab=_84945_/Q }
C {devices/lab_pin.sym} 115700 -38420 0 0 {name=p114562 lab=_57819_/X }
C {devices/lab_pin.sym} 115700 -38380 0 0 {name=p114563 lab=_57847_/X }
C {devices/lab_pin.sym} 115700 -38340 0 0 {name=p114564 lab=_57855_/X }
C {devices/lab_pin.sym} 115860 -38400 0 1 {name=p114565 lab=_57856_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 115780 -38400 0 0 {name=X_57856_ }
C {devices/lab_pin.sym} 115720 -38260 0 0 {name=p114566 lab=_81687_/Q }
C {devices/lab_pin.sym} 115720 -38220 0 0 {name=p114567 lab=_76690_/B }
C {devices/lab_pin.sym} 115840 -38240 0 1 {name=p114568 lab=_81351_/D }
C {sky130_stdcells/xor2_4.sym} 115780 -38240 0 0 {name=X_76690_ }
C {devices/lab_pin.sym} 115690 -38110 0 0 {name=p114569 lab=_85888_/CLK }
C {devices/lab_pin.sym} 115690 -38090 0 0 {name=p114570 lab=_52104_/Y }
C {devices/lab_pin.sym} 115870 -38110 0 1 {name=p114571 lab=_65439_/B }
C {sky130_stdcells/dfxtp_4.sym} 115780 -38100 0 0 {name=X_85888_ }
C {devices/lab_pin.sym} 115740 -37970 0 0 {name=p114572 lab=_46001_/A }
C {devices/lab_pin.sym} 115820 -37970 0 1 {name=p114573 lab=_44821_/X }
C {sky130_stdcells/buf_2.sym} 115780 -37970 0 0 {name=X_44821_ }
C {devices/lab_pin.sym} 115720 -37870 0 0 {name=p114574 lab=_56807_/A }
C {devices/lab_pin.sym} 115720 -37830 0 0 {name=p114575 lab=_46237_/A }
C {devices/lab_pin.sym} 115720 -37790 0 0 {name=p114576 lab=_56807_/C }
C {devices/lab_pin.sym} 115840 -37830 0 1 {name=p114577 lab=_57029_/A }
C {sky130_stdcells/nand3_4.sym} 115780 -37830 0 0 {name=X_56807_ }
C {devices/lab_pin.sym} 115690 -37690 0 0 {name=p114578 lab=_87883_/CLK }
C {devices/lab_pin.sym} 115690 -37670 0 0 {name=p114579 lab=_87627_/D }
C {devices/lab_pin.sym} 115870 -37690 0 1 {name=p114580 lab=_87627_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -37680 0 0 {name=X_87627_ }
C {devices/lab_pin.sym} 115720 -37560 0 0 {name=p114581 lab=_75641_/A }
C {devices/lab_pin.sym} 115720 -37520 0 0 {name=p114582 lab=_75641_/B }
C {devices/lab_pin.sym} 115840 -37540 0 1 {name=p114583 lab=_75641_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -37540 0 0 {name=X_75641_ }
C {devices/lab_pin.sym} 115740 -37410 0 0 {name=p114584 lab=_72852_/X }
C {devices/lab_pin.sym} 115820 -37410 0 1 {name=p114585 lab=_72853_/X }
C {sky130_stdcells/buf_2.sym} 115780 -37410 0 0 {name=X_72853_ }
C {devices/lab_pin.sym} 115690 -37290 0 0 {name=p114586 lab=_84839_/CLK }
C {devices/lab_pin.sym} 115690 -37270 0 0 {name=p114587 lab=_84839_/D }
C {devices/lab_pin.sym} 115870 -37290 0 1 {name=p114588 lab=_64422_/C }
C {sky130_stdcells/dfxtp_4.sym} 115780 -37280 0 0 {name=X_84839_ }
C {devices/lab_pin.sym} 115740 -37150 0 0 {name=p114589 lab=_64567_/A }
C {devices/lab_pin.sym} 115820 -37150 0 1 {name=p114590 lab=_64616_/A }
C {sky130_stdcells/buf_2.sym} 115780 -37150 0 0 {name=X_57787_ }
C {devices/lab_pin.sym} 115740 -37030 0 0 {name=p114591 lab=_54973_/A }
C {devices/lab_pin.sym} 115820 -37030 0 1 {name=p114592 lab=_55013_/C }
C {sky130_stdcells/buf_2.sym} 115780 -37030 0 0 {name=X_54999_ }
C {devices/lab_pin.sym} 115740 -36910 0 0 {name=p114593 lab=_47540_/A }
C {devices/lab_pin.sym} 115820 -36910 0 1 {name=p114594 lab=_53107_/D }
C {sky130_stdcells/buf_2.sym} 115780 -36910 0 0 {name=X_47540_ }
C {devices/lab_pin.sym} 115740 -36790 0 0 {name=p114595 lab=_71804_/A }
C {devices/lab_pin.sym} 115820 -36790 0 1 {name=p114596 lab=_71804_/Y }
C {sky130_stdcells/inv_2.sym} 115780 -36790 0 0 {name=X_71804_ }
C {devices/lab_pin.sym} 115740 -36670 0 0 {name=p114597 lab=_60385_/A }
C {devices/lab_pin.sym} 115820 -36670 0 1 {name=p114598 lab=_59602_/C }
C {sky130_stdcells/inv_2.sym} 115780 -36670 0 0 {name=X_59526_ }
C {devices/lab_pin.sym} 115720 -36570 0 0 {name=p114599 lab=_78360_/A }
C {devices/lab_pin.sym} 115720 -36530 0 0 {name=p114600 lab=_78360_/B }
C {devices/lab_pin.sym} 115720 -36490 0 0 {name=p114601 lab=_78376_/B }
C {devices/lab_pin.sym} 115840 -36530 0 1 {name=p114602 lab=_78364_/C }
C {sky130_stdcells/nand3_4.sym} 115780 -36530 0 0 {name=X_78360_ }
C {devices/lab_pin.sym} 115700 -36420 0 0 {name=p114603 lab=_41294_/A }
C {devices/lab_pin.sym} 115700 -36380 0 0 {name=p114604 lab=_44665_/X }
C {devices/lab_pin.sym} 115700 -36340 0 0 {name=p114605 lab=_86974_/Q }
C {devices/lab_pin.sym} 115700 -36300 0 0 {name=p114606 lab=_44666_/X }
C {devices/lab_pin.sym} 115860 -36360 0 1 {name=p114607 lab=_44752_/X }
C {sky130_stdcells/a2bb2o_4.sym} 115780 -36360 0 0 {name=X_44752_ }
C {devices/lab_pin.sym} 115740 -36210 0 0 {name=p114608 lab=_56737_/X }
C {devices/lab_pin.sym} 115820 -36210 0 1 {name=p114609 lab=_56738_/X }
C {sky130_stdcells/buf_2.sym} 115780 -36210 0 0 {name=X_56738_ }
C {devices/lab_pin.sym} 115740 -36090 0 0 {name=p114610 lab=_80818_/Q }
C {devices/lab_pin.sym} 115820 -36090 0 1 {name=p114611 lab=_75573_/A }
C {sky130_stdcells/inv_2.sym} 115780 -36090 0 0 {name=X_75572_ }
C {devices/lab_pin.sym} 115690 -35970 0 0 {name=p114612 lab=_87553_/CLK }
C {devices/lab_pin.sym} 115690 -35950 0 0 {name=p114613 lab=_87558_/D }
C {devices/lab_pin.sym} 115870 -35970 0 1 {name=p114614 lab=_73108_/A }
C {sky130_stdcells/dfxtp_4.sym} 115780 -35960 0 0 {name=X_87558_ }
C {devices/lab_pin.sym} 115700 -35870 0 0 {name=p114615 lab=_41937_/X }
C {devices/lab_pin.sym} 115700 -35830 0 0 {name=p114616 lab=_41956_/X }
C {devices/lab_pin.sym} 115700 -35790 0 0 {name=p114617 lab=_40729_/X }
C {devices/lab_pin.sym} 115700 -35750 0 0 {name=p114618 lab=_41963_/Y }
C {devices/lab_pin.sym} 115700 -35710 0 0 {name=p114619 lab=_41939_/X }
C {devices/lab_pin.sym} 115860 -35790 0 1 {name=p114620 lab=_88090_/D }
C {sky130_stdcells/o32ai_4.sym} 115780 -35790 0 0 {name=X_41964_ }
C {devices/lab_pin.sym} 115740 -35630 0 0 {name=p114621 lab=_72784_/A }
C {devices/lab_pin.sym} 115820 -35630 0 1 {name=p114622 lab=_73238_/A }
C {sky130_stdcells/buf_2.sym} 115780 -35630 0 0 {name=X_72784_ }
C {devices/lab_pin.sym} 115740 -35510 0 0 {name=p114623 lab=clkbuf_9_408_0_CLK/X }
C {devices/lab_pin.sym} 115820 -35510 0 1 {name=p114624 lab=_82675_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 115780 -35510 0 0 {name=Xclkbuf_10_816_0_CLK }
C {devices/lab_pin.sym} 115720 -35410 0 0 {name=p114625 lab=_77311_/A }
C {devices/lab_pin.sym} 115720 -35370 0 0 {name=p114626 lab=_77308_/A }
C {devices/lab_pin.sym} 115720 -35330 0 0 {name=p114627 lab=_77307_/A }
C {devices/lab_pin.sym} 115840 -35370 0 1 {name=p114628 lab=_77315_/B }
C {sky130_stdcells/nand3_4.sym} 115780 -35370 0 0 {name=X_77311_ }
C {devices/lab_pin.sym} 115740 -35230 0 0 {name=p114629 lab=_43703_/A }
C {devices/lab_pin.sym} 115820 -35230 0 1 {name=p114630 lab=_69737_/B }
C {sky130_stdcells/inv_2.sym} 115780 -35230 0 0 {name=X_43703_ }
C {devices/lab_pin.sym} 115720 -35140 0 0 {name=p114631 lab=_74523_/A }
C {devices/lab_pin.sym} 115720 -35100 0 0 {name=p114632 lab=_74518_/B }
C {devices/lab_pin.sym} 115720 -35060 0 0 {name=p114633 lab=_70880_/C }
C {devices/lab_pin.sym} 115720 -35020 0 0 {name=p114634 lab=_74531_/D }
C {devices/lab_pin.sym} 115840 -35080 0 1 {name=p114635 lab=_74523_/Y }
C {sky130_stdcells/nand4_4.sym} 115780 -35080 0 0 {name=X_74523_ }
C {devices/lab_pin.sym} 115690 -34930 0 0 {name=p114636 lab=_85859_/CLK }
C {devices/lab_pin.sym} 115690 -34910 0 0 {name=p114637 lab=_86509_/D }
C {devices/lab_pin.sym} 115870 -34930 0 1 {name=p114638 lab=_86509_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -34920 0 0 {name=X_86509_ }
C {devices/lab_pin.sym} 115740 -34790 0 0 {name=p114639 lab=_40568_/A }
C {devices/lab_pin.sym} 115820 -34790 0 1 {name=p114640 lab=_40995_/A }
C {sky130_stdcells/buf_2.sym} 115780 -34790 0 0 {name=X_40915_ }
C {devices/lab_pin.sym} 115700 -34690 0 0 {name=p114641 lab=_86631_/Q }
C {devices/lab_pin.sym} 115700 -34650 0 0 {name=p114642 lab=_47429_/X }
C {devices/lab_pin.sym} 115700 -34610 0 0 {name=p114643 lab=_47470_/Y }
C {devices/lab_pin.sym} 115860 -34650 0 1 {name=p114644 lab=_47471_/Y }
C {sky130_stdcells/o21ai_4.sym} 115780 -34650 0 0 {name=X_47471_ }
C {devices/lab_pin.sym} 115720 -34540 0 0 {name=p114645 lab=_71735_/A }
C {devices/lab_pin.sym} 115720 -34500 0 0 {name=p114646 lab=_71115_/D }
C {devices/lab_pin.sym} 115720 -34460 0 0 {name=p114647 lab=_71735_/C }
C {devices/lab_pin.sym} 115720 -34420 0 0 {name=p114648 lab=_71735_/D }
C {devices/lab_pin.sym} 115840 -34480 0 1 {name=p114649 lab=_71735_/X }
C {sky130_stdcells/and4_4.sym} 115780 -34480 0 0 {name=X_71735_ }
C {devices/lab_pin.sym} 115720 -34340 0 0 {name=p114650 lab=_58548_/A }
C {devices/lab_pin.sym} 115720 -34300 0 0 {name=p114651 lab=_59457_/B }
C {devices/lab_pin.sym} 115840 -34320 0 1 {name=p114652 lab=_59457_/Y }
C {sky130_stdcells/nor2_4.sym} 115780 -34320 0 0 {name=X_59457_ }
C {devices/lab_pin.sym} 115700 -34210 0 0 {name=p114653 lab=_78286_/B }
C {devices/lab_pin.sym} 115700 -34170 0 0 {name=p114654 lab=_78289_/X }
C {devices/lab_pin.sym} 115700 -34130 0 0 {name=p114655 lab=_78290_/Y }
C {devices/lab_pin.sym} 115860 -34170 0 1 {name=p114656 lab=_78291_/Y }
C {sky130_stdcells/a21boi_4.sym} 115780 -34170 0 0 {name=X_78291_ }
C {devices/lab_pin.sym} 115740 -34030 0 0 {name=p114657 lab=_44682_/Y }
C {devices/lab_pin.sym} 115820 -34030 0 1 {name=p114658 lab=_87002_/D }
C {sky130_stdcells/inv_2.sym} 115780 -34030 0 0 {name=X_44683_ }
C {devices/lab_pin.sym} 115740 -33910 0 0 {name=p114659 lab=_56774_/C }
C {devices/lab_pin.sym} 115820 -33910 0 1 {name=p114660 lab=_56725_/B }
C {sky130_stdcells/buf_2.sym} 115780 -33910 0 0 {name=X_56669_ }
C {devices/lab_pin.sym} 115690 -33790 0 0 {name=p114661 lab=_87758_/CLK }
C {devices/lab_pin.sym} 115690 -33770 0 0 {name=p114662 lab=_87489_/D }
C {devices/lab_pin.sym} 115870 -33790 0 1 {name=p114663 lab=_87489_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -33780 0 0 {name=X_87489_ }
C {devices/lab_pin.sym} 115700 -33690 0 0 {name=p114664 lab=_41894_/X }
C {devices/lab_pin.sym} 115700 -33650 0 0 {name=p114665 lab=_41879_/X }
C {devices/lab_pin.sym} 115700 -33610 0 0 {name=p114666 lab=_40605_/X }
C {devices/lab_pin.sym} 115700 -33570 0 0 {name=p114667 lab=_73650_/A }
C {devices/lab_pin.sym} 115700 -33530 0 0 {name=p114668 lab=_41882_/X }
C {devices/lab_pin.sym} 115860 -33610 0 1 {name=p114669 lab=_41895_/Y }
C {sky130_stdcells/o32ai_4.sym} 115780 -33610 0 0 {name=X_41895_ }
C {devices/lab_pin.sym} 115720 -33470 0 0 {name=p114670 lab=_49210_/A }
C {devices/lab_pin.sym} 115720 -33430 0 0 {name=p114671 lab=_49210_/B }
C {devices/lab_pin.sym} 115720 -33390 0 0 {name=p114672 lab=_53944_/C }
C {devices/lab_pin.sym} 115840 -33430 0 1 {name=p114673 lab=_49210_/Y }
C {sky130_stdcells/nor3_4.sym} 115780 -33430 0 0 {name=X_49210_ }
C {devices/lab_pin.sym} 115700 -33310 0 0 {name=p114674 lab=_86738_/Q }
C {devices/lab_pin.sym} 115700 -33270 0 0 {name=p114675 lab=_46292_/X }
C {devices/lab_pin.sym} 115700 -33230 0 0 {name=p114676 lab=_46421_/Y }
C {devices/lab_pin.sym} 115860 -33270 0 1 {name=p114677 lab=_46422_/Y }
C {sky130_stdcells/o21ai_4.sym} 115780 -33270 0 0 {name=X_46422_ }
C {devices/lab_pin.sym} 115740 -33130 0 0 {name=p114678 lab=_58408_/A }
C {devices/lab_pin.sym} 115820 -33130 0 1 {name=p114679 lab=_58415_/B }
C {sky130_stdcells/buf_2.sym} 115780 -33130 0 0 {name=X_58408_ }
C {devices/lab_pin.sym} 115740 -33010 0 0 {name=p114680 lab=clkbuf_9_307_0_CLK/A }
C {devices/lab_pin.sym} 115820 -33010 0 1 {name=p114681 lab=clkbuf_9_307_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 115780 -33010 0 0 {name=Xclkbuf_9_307_0_CLK }
C {devices/lab_pin.sym} 115720 -32900 0 0 {name=p114682 lab=_77233_/A }
C {devices/lab_pin.sym} 115720 -32860 0 0 {name=p114683 lab=_82082_/D }
C {devices/lab_pin.sym} 115840 -32880 0 1 {name=p114684 lab=_77242_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -32880 0 0 {name=X_77242_ }
C {devices/lab_pin.sym} 115740 -32750 0 0 {name=p114685 lab=_47834_/A }
C {devices/lab_pin.sym} 115820 -32750 0 1 {name=p114686 lab=_43634_/X }
C {sky130_stdcells/buf_2.sym} 115780 -32750 0 0 {name=X_43634_ }
C {devices/lab_pin.sym} 115720 -32650 0 0 {name=p114687 lab=_48567_/A }
C {devices/lab_pin.sym} 115720 -32610 0 0 {name=p114688 lab=_74478_/B }
C {devices/lab_pin.sym} 115720 -32570 0 0 {name=p114689 lab=_74425_/X }
C {devices/lab_pin.sym} 115840 -32610 0 1 {name=p114690 lab=_74454_/X }
C {sky130_stdcells/and3_4.sym} 115780 -32610 0 0 {name=X_74454_ }
C {devices/lab_pin.sym} 115700 -32500 0 0 {name=p114691 lab=_40845_/X }
C {devices/lab_pin.sym} 115700 -32460 0 0 {name=p114692 lab=_40821_/X }
C {devices/lab_pin.sym} 115700 -32420 0 0 {name=p114693 lab=_88324_/Q }
C {devices/lab_pin.sym} 115700 -32380 0 0 {name=p114694 lab=_40822_/X }
C {devices/lab_pin.sym} 115860 -32440 0 1 {name=p114695 lab=_88324_/D }
C {sky130_stdcells/a2bb2o_4.sym} 115780 -32440 0 0 {name=X_40846_ }
C {devices/lab_pin.sym} 115720 -32310 0 0 {name=p114696 lab=_70426_/A }
C {devices/lab_pin.sym} 115720 -32270 0 0 {name=p114697 lab=_71261_/B }
C {devices/lab_pin.sym} 115720 -32230 0 0 {name=p114698 lab=_71641_/A }
C {devices/lab_pin.sym} 115840 -32270 0 1 {name=p114699 lab=_71666_/Y }
C {sky130_stdcells/nand3_4.sym} 115780 -32270 0 0 {name=X_71666_ }
C {devices/lab_pin.sym} 115720 -32140 0 0 {name=p114700 lab=_59388_/A }
C {devices/lab_pin.sym} 115720 -32100 0 0 {name=p114701 lab=_58988_/B }
C {devices/lab_pin.sym} 115840 -32120 0 1 {name=p114702 lab=_59388_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -32120 0 0 {name=X_59388_ }
C {devices/lab_pin.sym} 115700 -32010 0 0 {name=p114703 lab=_50693_/A }
C {devices/lab_pin.sym} 115700 -31970 0 0 {name=p114704 lab=_50693_/B }
C {devices/lab_pin.sym} 115700 -31930 0 0 {name=p114705 lab=_48908_/A }
C {devices/lab_pin.sym} 115860 -31970 0 1 {name=p114706 lab=_49141_/X }
C {sky130_stdcells/o21a_4.sym} 115780 -31970 0 0 {name=X_49141_ }
C {devices/lab_pin.sym} 115700 -31850 0 0 {name=p114707 lab=_73402_/X }
C {devices/lab_pin.sym} 115700 -31810 0 0 {name=p114708 lab=_73404_/X }
C {devices/lab_pin.sym} 115700 -31770 0 0 {name=p114709 lab=_73262_/X }
C {devices/lab_pin.sym} 115860 -31810 0 1 {name=p114710 lab=_73409_/A }
C {sky130_stdcells/a21o_4.sym} 115780 -31810 0 0 {name=X_73405_ }
C {devices/lab_pin.sym} 115720 -31680 0 0 {name=p114711 lab=_46362_/A }
C {devices/lab_pin.sym} 115720 -31640 0 0 {name=p114712 lab=_53983_/B }
C {devices/lab_pin.sym} 115840 -31660 0 1 {name=p114713 lab=_46353_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -31660 0 0 {name=X_46353_ }
C {devices/lab_pin.sym} 115720 -31560 0 0 {name=p114714 lab=_70722_/A }
C {devices/lab_pin.sym} 115720 -31520 0 0 {name=p114715 lab=_70620_/B }
C {devices/lab_pin.sym} 115720 -31480 0 0 {name=p114716 lab=_70620_/C }
C {devices/lab_pin.sym} 115720 -31440 0 0 {name=p114717 lab=_70620_/D }
C {devices/lab_pin.sym} 115840 -31500 0 1 {name=p114718 lab=_70617_/Y }
C {sky130_stdcells/nand4_4.sym} 115780 -31500 0 0 {name=X_70617_ }
C {devices/lab_pin.sym} 115720 -31360 0 0 {name=p114719 lab=_58338_/Y }
C {devices/lab_pin.sym} 115720 -31320 0 0 {name=p114720 lab=_58364_/B }
C {devices/lab_pin.sym} 115840 -31340 0 1 {name=p114721 lab=_58339_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -31340 0 0 {name=X_58339_ }
C {devices/lab_pin.sym} 115720 -31230 0 0 {name=p114722 lab=_77173_/A }
C {devices/lab_pin.sym} 115720 -31190 0 0 {name=p114723 lab=_77173_/B }
C {devices/lab_pin.sym} 115720 -31150 0 0 {name=p114724 lab=_77173_/C }
C {devices/lab_pin.sym} 115840 -31190 0 1 {name=p114725 lab=_77173_/X }
C {sky130_stdcells/and3_4.sym} 115780 -31190 0 0 {name=X_77173_ }
C {devices/lab_pin.sym} 115740 -31050 0 0 {name=p114726 lab=_43564_/Y }
C {devices/lab_pin.sym} 115820 -31050 0 1 {name=p114727 lab=_43565_/Y }
C {sky130_stdcells/inv_2.sym} 115780 -31050 0 0 {name=X_43565_ }
C {devices/lab_pin.sym} 115720 -30940 0 0 {name=p114728 lab=_74391_/A }
C {devices/lab_pin.sym} 115720 -30900 0 0 {name=p114729 lab=_52119_/B }
C {devices/lab_pin.sym} 115840 -30920 0 1 {name=p114730 lab=_74385_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -30920 0 0 {name=X_74385_ }
C {devices/lab_pin.sym} 115700 -30820 0 0 {name=p114731 lab=_40776_/X }
C {devices/lab_pin.sym} 115700 -30780 0 0 {name=p114732 lab=_40754_/X }
C {devices/lab_pin.sym} 115700 -30740 0 0 {name=p114733 lab=_69597_/B }
C {devices/lab_pin.sym} 115700 -30700 0 0 {name=p114734 lab=_40756_/X }
C {devices/lab_pin.sym} 115860 -30760 0 1 {name=p114735 lab=_88337_/D }
C {sky130_stdcells/a2bb2o_4.sym} 115780 -30760 0 0 {name=X_40777_ }
C {devices/lab_pin.sym} 115740 -30610 0 0 {name=p114736 lab=_71528_/X }
C {devices/lab_pin.sym} 115820 -30610 0 1 {name=p114737 lab=_71626_/B }
C {sky130_stdcells/buf_2.sym} 115780 -30610 0 0 {name=X_71597_ }
C {devices/lab_pin.sym} 115700 -30510 0 0 {name=p114738 lab=_55761_/B }
C {devices/lab_pin.sym} 115700 -30470 0 0 {name=p114739 lab=_45269_/X }
C {devices/lab_pin.sym} 115700 -30430 0 0 {name=p114740 lab=_45303_/X }
C {devices/lab_pin.sym} 115860 -30470 0 1 {name=p114741 lab=_45304_/X }
C {sky130_stdcells/o21a_4.sym} 115780 -30470 0 0 {name=X_45304_ }
C {devices/lab_pin.sym} 115720 -30350 0 0 {name=p114742 lab=_76112_/A }
C {devices/lab_pin.sym} 115720 -30310 0 0 {name=p114743 lab=_76126_/A }
C {devices/lab_pin.sym} 115720 -30270 0 0 {name=p114744 lab=_76127_/B }
C {devices/lab_pin.sym} 115840 -30310 0 1 {name=p114745 lab=_76124_/Y }
C {sky130_stdcells/nand3_4.sym} 115780 -30310 0 0 {name=X_76124_ }
C {devices/lab_pin.sym} 115700 -30210 0 0 {name=p114746 lab=_42486_/X }
C {devices/lab_pin.sym} 115700 -30170 0 0 {name=p114747 lab=_42501_/X }
C {devices/lab_pin.sym} 115700 -30130 0 0 {name=p114748 lab=_40712_/X }
C {devices/lab_pin.sym} 115700 -30090 0 0 {name=p114749 lab=_68910_/B }
C {devices/lab_pin.sym} 115700 -30050 0 0 {name=p114750 lab=_42489_/X }
C {devices/lab_pin.sym} 115860 -30130 0 1 {name=p114751 lab=_42516_/Y }
C {sky130_stdcells/o32ai_4.sym} 115780 -30130 0 0 {name=X_42516_ }
C {devices/lab_pin.sym} 115740 -29970 0 0 {name=p114752 lab=_49072_/A }
C {devices/lab_pin.sym} 115820 -29970 0 1 {name=p114753 lab=_53877_/B }
C {sky130_stdcells/inv_2.sym} 115780 -29970 0 0 {name=X_49072_ }
C {devices/lab_pin.sym} 115720 -29860 0 0 {name=p114754 lab=_73333_/X }
C {devices/lab_pin.sym} 115720 -29820 0 0 {name=p114755 lab=_73335_/X }
C {devices/lab_pin.sym} 115840 -29840 0 1 {name=p114756 lab=_73336_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -29840 0 0 {name=X_73336_ }
C {devices/lab_pin.sym} 115740 -29710 0 0 {name=p114757 lab=_72592_/A }
C {devices/lab_pin.sym} 115820 -29710 0 1 {name=p114758 lab=_61384_/A }
C {sky130_stdcells/buf_2.sym} 115780 -29710 0 0 {name=X_61350_ }
C {devices/lab_pin.sym} 115700 -29610 0 0 {name=p114759 lab=_86750_/Q }
C {devices/lab_pin.sym} 115700 -29570 0 0 {name=p114760 lab=_46279_/X }
C {devices/lab_pin.sym} 115700 -29530 0 0 {name=p114761 lab=_46283_/Y }
C {devices/lab_pin.sym} 115860 -29570 0 1 {name=p114762 lab=_46284_/Y }
C {sky130_stdcells/o21ai_4.sym} 115780 -29570 0 0 {name=X_46284_ }
C {devices/lab_pin.sym} 115740 -29430 0 0 {name=p114763 lab=_71857_/A }
C {devices/lab_pin.sym} 115820 -29430 0 1 {name=p114764 lab=_71698_/A }
C {sky130_stdcells/buf_2.sym} 115780 -29430 0 0 {name=X_70548_ }
C {devices/lab_pin.sym} 115700 -29350 0 0 {name=p114765 lab=_43495_/X }
C {devices/lab_pin.sym} 115700 -29310 0 0 {name=p114766 lab=_43475_/X }
C {devices/lab_pin.sym} 115700 -29270 0 0 {name=p114767 lab=_41735_/X }
C {devices/lab_pin.sym} 115700 -29230 0 0 {name=p114768 lab=_87391_/Q }
C {devices/lab_pin.sym} 115700 -29190 0 0 {name=p114769 lab=_43479_/X }
C {devices/lab_pin.sym} 115860 -29270 0 1 {name=p114770 lab=_43497_/A }
C {sky130_stdcells/o32ai_4.sym} 115780 -29270 0 0 {name=X_43496_ }
C {devices/lab_pin.sym} 115740 -29110 0 0 {name=p114771 lab=_48022_/Y }
C {devices/lab_pin.sym} 115820 -29110 0 1 {name=p114772 lab=_48024_/B }
C {sky130_stdcells/buf_2.sym} 115780 -29110 0 0 {name=X_48023_ }
C {devices/lab_pin.sym} 115700 -29020 0 0 {name=p114773 lab=_79775_/A }
C {devices/lab_pin.sym} 115700 -28980 0 0 {name=p114774 lab=_59822_/X }
C {devices/lab_pin.sym} 115700 -28940 0 0 {name=p114775 lab=_60299_/Y }
C {devices/lab_pin.sym} 115700 -28900 0 0 {name=p114776 lab=_60300_/Y }
C {devices/lab_pin.sym} 115860 -28960 0 1 {name=p114777 lab=_60301_/X }
C {sky130_stdcells/o22a_4.sym} 115780 -28960 0 0 {name=X_60301_ }
C {devices/lab_pin.sym} 115700 -28830 0 0 {name=p114778 lab=_45202_/X }
C {devices/lab_pin.sym} 115700 -28790 0 0 {name=p114779 lab=_61579_/B }
C {devices/lab_pin.sym} 115700 -28750 0 0 {name=p114780 lab=_45219_/X }
C {devices/lab_pin.sym} 115860 -28790 0 1 {name=p114781 lab=_45235_/Y }
C {sky130_stdcells/o21ai_4.sym} 115780 -28790 0 0 {name=X_45235_ }
C {devices/lab_pin.sym} 115720 -28660 0 0 {name=p114782 lab=_81717_/D }
C {devices/lab_pin.sym} 115720 -28620 0 0 {name=p114783 lab=_76056_/B }
C {devices/lab_pin.sym} 115840 -28640 0 1 {name=p114784 lab=_76063_/B }
C {sky130_stdcells/or2_4.sym} 115780 -28640 0 0 {name=X_76055_ }
C {devices/lab_pin.sym} 115720 -28540 0 0 {name=p114785 lab=_42447_/A }
C {devices/lab_pin.sym} 115720 -28500 0 0 {name=p114786 lab=_42447_/B }
