C {devices/lab_pin.sym} 136860 -7540 0 0 {name=p136336 lab=_66225_/X }
C {devices/lab_pin.sym} 136860 -7500 0 0 {name=p136337 lab=_84966_/Q }
C {devices/lab_pin.sym} 136860 -7460 0 0 {name=p136338 lab=_66118_/X }
C {devices/lab_pin.sym} 136860 -7420 0 0 {name=p136339 lab=_66301_/X }
C {devices/lab_pin.sym} 137020 -7480 0 1 {name=p136340 lab=_66303_/B }
C {sky130_stdcells/a211o_4.sym} 136940 -7480 0 0 {name=X_66302_ }
C {devices/lab_pin.sym} 136900 -7330 0 0 {name=p136341 lab=clkbuf_8_41_0_CLK/A }
C {devices/lab_pin.sym} 136980 -7330 0 1 {name=p136342 lab=clkbuf_8_40_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 136940 -7330 0 0 {name=Xclkbuf_8_40_0_CLK }
C {devices/lab_pin.sym} 136880 -7240 0 0 {name=p136343 lab=_59407_/A }
C {devices/lab_pin.sym} 136880 -7200 0 0 {name=p136344 lab=_63491_/B }
C {devices/lab_pin.sym} 136880 -7160 0 0 {name=p136345 lab=_63514_/C }
C {devices/lab_pin.sym} 136880 -7120 0 0 {name=p136346 lab=_63491_/D }
C {devices/lab_pin.sym} 137000 -7180 0 1 {name=p136347 lab=_63514_/Y }
C {sky130_stdcells/nand4_4.sym} 136940 -7180 0 0 {name=X_63514_ }
C {devices/lab_pin.sym} 136900 -7030 0 0 {name=p136348 lab=_48448_/A }
C {devices/lab_pin.sym} 136980 -7030 0 1 {name=p136349 lab=_48449_/A }
C {sky130_stdcells/inv_2.sym} 136940 -7030 0 0 {name=X_48448_ }
C {devices/lab_pin.sym} 136900 -6910 0 0 {name=p136350 lab=_60725_/Y }
C {devices/lab_pin.sym} 136980 -6910 0 1 {name=p136351 lab=_60726_/Y }
C {sky130_stdcells/inv_2.sym} 136940 -6910 0 0 {name=X_60726_ }
C {devices/lab_pin.sym} 136860 -6820 0 0 {name=p136352 lab=_67141_/X }
C {devices/lab_pin.sym} 136860 -6780 0 0 {name=p136353 lab=_67268_/Y }
C {devices/lab_pin.sym} 136860 -6740 0 0 {name=p136354 lab=_67269_/X }
C {devices/lab_pin.sym} 136860 -6700 0 0 {name=p136355 lab=_67281_/Y }
C {devices/lab_pin.sym} 137020 -6760 0 1 {name=p136356 lab=_67282_/X }
C {sky130_stdcells/a211o_4.sym} 136940 -6760 0 0 {name=X_67282_ }
C {devices/lab_pin.sym} 136880 -6620 0 0 {name=p136357 lab=_79266_/X }
C {devices/lab_pin.sym} 136880 -6580 0 0 {name=p136358 lab=_79276_/B }
C {devices/lab_pin.sym} 137000 -6600 0 1 {name=p136359 lab=_79268_/Y }
C {sky130_stdcells/xnor2_4.sym} 136940 -6600 0 0 {name=X_79268_ }
C {devices/lab_pin.sym} 136880 -6490 0 0 {name=p136360 lab=_64494_/A }
C {devices/lab_pin.sym} 136880 -6450 0 0 {name=p136361 lab=_64494_/B }
C {devices/lab_pin.sym} 136880 -6410 0 0 {name=p136362 lab=_64207_/A }
C {devices/lab_pin.sym} 137000 -6450 0 1 {name=p136363 lab=_64494_/X }
C {sky130_stdcells/and3_4.sym} 136940 -6450 0 0 {name=X_64494_ }
C {devices/lab_pin.sym} 136880 -6320 0 0 {name=p136364 lab=_69021_/A }
C {devices/lab_pin.sym} 136880 -6280 0 0 {name=p136365 lab=_74186_/A }
C {devices/lab_pin.sym} 137000 -6300 0 1 {name=p136366 lab=_69021_/X }
C {sky130_stdcells/and2_4.sym} 136940 -6300 0 0 {name=X_69021_ }
C {devices/lab_pin.sym} 136860 -6190 0 0 {name=p136367 lab=_66230_/Y }
C {devices/lab_pin.sym} 136860 -6150 0 0 {name=p136368 lab=_66205_/X }
C {devices/lab_pin.sym} 136860 -6110 0 0 {name=p136369 lab=_66232_/X }
C {devices/lab_pin.sym} 137020 -6150 0 1 {name=p136370 lab=_84147_/D }
C {sky130_stdcells/a21o_4.sym} 136940 -6150 0 0 {name=X_66233_ }
C {devices/lab_pin.sym} 136880 -6020 0 0 {name=p136371 lab=_78228_/A }
C {devices/lab_pin.sym} 136880 -5980 0 0 {name=p136372 lab=_78228_/B }
C {devices/lab_pin.sym} 137000 -6000 0 1 {name=p136373 lab=_78225_/A }
C {sky130_stdcells/xor2_4.sym} 136940 -6000 0 0 {name=X_78219_ }
C {devices/lab_pin.sym} 136860 -5910 0 0 {name=p136374 lab=_63434_/X }
C {devices/lab_pin.sym} 136860 -5870 0 0 {name=p136375 lab=_63435_/X }
C {devices/lab_pin.sym} 136860 -5830 0 0 {name=p136376 lab=_63438_/X }
C {devices/lab_pin.sym} 136860 -5790 0 0 {name=p136377 lab=_63442_/X }
C {devices/lab_pin.sym} 136860 -5750 0 0 {name=p136378 lab=_63444_/Y }
C {devices/lab_pin.sym} 137020 -5830 0 1 {name=p136379 lab=_63445_/Y }
C {sky130_stdcells/o41ai_4.sym} 136940 -5830 0 0 {name=X_63445_ }
C {devices/lab_pin.sym} 136900 -5670 0 0 {name=p136380 lab=_48379_/A }
C {devices/lab_pin.sym} 136980 -5670 0 1 {name=p136381 lab=_74373_/B }
C {sky130_stdcells/inv_2.sym} 136940 -5670 0 0 {name=X_48379_ }
C {devices/lab_pin.sym} 136900 -5550 0 0 {name=p136382 lab=_60713_/A }
C {devices/lab_pin.sym} 136980 -5550 0 1 {name=p136383 lab=_63540_/A }
C {sky130_stdcells/buf_2.sym} 136940 -5550 0 0 {name=X_60657_ }
C {devices/lab_pin.sym} 136880 -5440 0 0 {name=p136384 lab=_79197_/Y }
C {devices/lab_pin.sym} 136880 -5400 0 0 {name=p136385 lab=_79198_/Y }
C {devices/lab_pin.sym} 137000 -5420 0 1 {name=p136386 lab=_79203_/A }
C {sky130_stdcells/nand2_4.sym} 136940 -5420 0 0 {name=X_79199_ }
C {devices/lab_pin.sym} 136880 -5300 0 0 {name=p136387 lab=_50432_/A }
C {devices/lab_pin.sym} 136880 -5260 0 0 {name=p136388 lab=_48391_/X }
C {devices/lab_pin.sym} 137000 -5280 0 1 {name=p136389 lab=_50410_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -5280 0 0 {name=X_50410_ }
C {devices/lab_pin.sym} 136850 -5150 0 0 {name=p136390 lab=_81227_/CLK }
C {devices/lab_pin.sym} 136850 -5130 0 0 {name=p136391 lab=_81038_/Q }
C {devices/lab_pin.sym} 137030 -5150 0 1 {name=p136392 lab=_81230_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -5140 0 0 {name=X_81230_ }
C {devices/lab_pin.sym} 136880 -5030 0 0 {name=p136393 lab=_66164_/A }
C {devices/lab_pin.sym} 136880 -4990 0 0 {name=p136394 lab=_66164_/B }
C {devices/lab_pin.sym} 136880 -4950 0 0 {name=p136395 lab=_66164_/C }
C {devices/lab_pin.sym} 137000 -4990 0 1 {name=p136396 lab=_66164_/Y }
C {sky130_stdcells/nor3_4.sym} 136940 -4990 0 0 {name=X_66164_ }
C {devices/lab_pin.sym} 136860 -4870 0 0 {name=p136397 lab=_86019_/Q }
C {devices/lab_pin.sym} 136860 -4830 0 0 {name=p136398 lab=_51387_/X }
C {devices/lab_pin.sym} 136860 -4790 0 0 {name=p136399 lab=_51389_/Y }
C {devices/lab_pin.sym} 137020 -4830 0 1 {name=p136400 lab=_51390_/Y }
C {sky130_stdcells/o21ai_4.sym} 136940 -4830 0 0 {name=X_51390_ }
C {devices/lab_pin.sym} 136880 -4710 0 0 {name=p136401 lab=_63400_/A }
C {devices/lab_pin.sym} 136880 -4670 0 0 {name=p136402 lab=_63376_/B }
C {devices/lab_pin.sym} 136880 -4630 0 0 {name=p136403 lab=_63400_/C }
C {devices/lab_pin.sym} 137000 -4670 0 1 {name=p136404 lab=_63376_/X }
C {sky130_stdcells/and3_4.sym} 136940 -4670 0 0 {name=X_63376_ }
C {devices/lab_pin.sym} 136900 -4530 0 0 {name=p136405 lab=_60588_/A }
C {devices/lab_pin.sym} 136980 -4530 0 1 {name=p136406 lab=_60588_/X }
C {sky130_stdcells/buf_2.sym} 136940 -4530 0 0 {name=X_60588_ }
C {devices/lab_pin.sym} 136900 -4410 0 0 {name=p136407 lab=clkbuf_8_55_0_CLK/A }
C {devices/lab_pin.sym} 136980 -4410 0 1 {name=p136408 lab=clkbuf_8_55_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 136940 -4410 0 0 {name=Xclkbuf_8_55_0_CLK }
C {devices/lab_pin.sym} 136880 -4300 0 0 {name=p136409 lab=_64946_/A }
C {devices/lab_pin.sym} 136880 -4260 0 0 {name=p136410 lab=_65115_/B }
C {devices/lab_pin.sym} 137000 -4280 0 1 {name=p136411 lab=_65115_/X }
C {sky130_stdcells/and2_4.sym} 136940 -4280 0 0 {name=X_65115_ }
C {devices/lab_pin.sym} 136880 -4160 0 0 {name=p136412 lab=_50317_/X }
C {devices/lab_pin.sym} 136880 -4120 0 0 {name=p136413 lab=_50341_/B }
C {devices/lab_pin.sym} 137000 -4140 0 1 {name=p136414 lab=_50341_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -4140 0 0 {name=X_50341_ }
C {devices/lab_pin.sym} 136900 -4010 0 0 {name=p136415 lab=_62033_/A }
C {devices/lab_pin.sym} 136980 -4010 0 1 {name=p136416 lab=_62327_/X }
C {sky130_stdcells/buf_2.sym} 136940 -4010 0 0 {name=X_62327_ }
C {devices/lab_pin.sym} 136850 -3890 0 0 {name=p136417 lab=_81125_/CLK }
C {devices/lab_pin.sym} 136850 -3870 0 0 {name=p136418 lab=_74895_/B }
C {devices/lab_pin.sym} 137030 -3890 0 1 {name=p136419 lab=_41584_/A }
C {sky130_stdcells/dfxtp_4.sym} 136940 -3880 0 0 {name=X_81161_ }
C {devices/lab_pin.sym} 136860 -3780 0 0 {name=p136420 lab=_65990_/X }
C {devices/lab_pin.sym} 136860 -3740 0 0 {name=p136421 lab=_86228_/Q }
C {devices/lab_pin.sym} 136860 -3700 0 0 {name=p136422 lab=_66021_/X }
C {devices/lab_pin.sym} 136860 -3660 0 0 {name=p136423 lab=_66094_/X }
C {devices/lab_pin.sym} 137020 -3720 0 1 {name=p136424 lab=_66095_/X }
C {sky130_stdcells/a211o_4.sym} 136940 -3720 0 0 {name=X_66095_ }
C {devices/lab_pin.sym} 136880 -3580 0 0 {name=p136425 lab=_80121_/A }
C {devices/lab_pin.sym} 136880 -3540 0 0 {name=p136426 lab=_80121_/B }
C {devices/lab_pin.sym} 137000 -3560 0 1 {name=p136427 lab=_80112_/Y }
C {sky130_stdcells/xnor2_4.sym} 136940 -3560 0 0 {name=X_80112_ }
C {devices/lab_pin.sym} 136880 -3440 0 0 {name=p136428 lab=_53040_/X }
C {devices/lab_pin.sym} 136880 -3400 0 0 {name=p136429 lab=_53060_/B }
C {devices/lab_pin.sym} 137000 -3420 0 1 {name=p136430 lab=_53060_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -3420 0 0 {name=X_53060_ }
C {devices/lab_pin.sym} 136900 -3290 0 0 {name=p136431 lab=_84217_/Q }
C {devices/lab_pin.sym} 136980 -3290 0 1 {name=p136432 lab=_65047_/C }
C {sky130_stdcells/inv_2.sym} 136940 -3290 0 0 {name=X_65046_ }
C {devices/lab_pin.sym} 136880 -3180 0 0 {name=p136433 lab=_69877_/A }
C {devices/lab_pin.sym} 136880 -3140 0 0 {name=p136434 lab=_69923_/B }
C {devices/lab_pin.sym} 137000 -3160 0 1 {name=p136435 lab=_69923_/X }
C {sky130_stdcells/and2_4.sym} 136940 -3160 0 0 {name=X_69923_ }
C {devices/lab_pin.sym} 136880 -3040 0 0 {name=p136436 lab=_50251_/X }
C {devices/lab_pin.sym} 136880 -3000 0 0 {name=p136437 lab=_47924_/B }
C {devices/lab_pin.sym} 137000 -3020 0 1 {name=p136438 lab=_50272_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -3020 0 0 {name=X_50272_ }
C {devices/lab_pin.sym} 136860 -2910 0 0 {name=p136439 lab=_59931_/X }
C {devices/lab_pin.sym} 136860 -2870 0 0 {name=p136440 lab=_61780_/X }
C {devices/lab_pin.sym} 136860 -2830 0 0 {name=p136441 lab=_62257_/X }
C {devices/lab_pin.sym} 137020 -2870 0 1 {name=p136442 lab=_62258_/X }
C {sky130_stdcells/a21o_4.sym} 136940 -2870 0 0 {name=X_62258_ }
C {devices/lab_pin.sym} 136850 -2730 0 0 {name=p136443 lab=_82084_/CLK }
C {devices/lab_pin.sym} 136850 -2710 0 0 {name=p136444 lab=_79563_/Y }
C {devices/lab_pin.sym} 137030 -2730 0 1 {name=p136445 lab=_81092_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -2720 0 0 {name=X_81092_ }
C {devices/lab_pin.sym} 136880 -2610 0 0 {name=p136446 lab=_50308_/A }
C {devices/lab_pin.sym} 136880 -2570 0 0 {name=p136447 lab=_51972_/X }
C {devices/lab_pin.sym} 136880 -2530 0 0 {name=p136448 lab=_51958_/C }
C {devices/lab_pin.sym} 137000 -2570 0 1 {name=p136449 lab=_52011_/X }
C {sky130_stdcells/and3_4.sym} 136940 -2570 0 0 {name=X_52011_ }
C {devices/lab_pin.sym} 136900 -2430 0 0 {name=p136450 lab=_64303_/A }
C {devices/lab_pin.sym} 136980 -2430 0 1 {name=p136451 lab=_64234_/B }
C {sky130_stdcells/buf_2.sym} 136940 -2430 0 0 {name=X_61209_ }
C {devices/lab_pin.sym} 136880 -2320 0 0 {name=p136452 lab=_80025_/Y }
C {devices/lab_pin.sym} 136880 -2280 0 0 {name=p136453 lab=_80043_/B }
C {devices/lab_pin.sym} 137000 -2300 0 1 {name=p136454 lab=_80043_/X }
C {sky130_stdcells/or2_4.sym} 136940 -2300 0 0 {name=X_80043_ }
C {devices/lab_pin.sym} 136850 -2170 0 0 {name=p136455 lab=_84905_/CLK }
C {devices/lab_pin.sym} 136850 -2150 0 0 {name=p136456 lab=_84920_/D }
C {devices/lab_pin.sym} 137030 -2170 0 1 {name=p136457 lab=_58149_/A }
C {sky130_stdcells/dfxtp_4.sym} 136940 -2160 0 0 {name=X_84920_ }
C {devices/lab_pin.sym} 136860 -2060 0 0 {name=p136458 lab=_44573_/A }
C {devices/lab_pin.sym} 136860 -2020 0 0 {name=p136459 lab=_66550_/X }
C {devices/lab_pin.sym} 136860 -1980 0 0 {name=p136460 lab=_66552_/X }
C {devices/lab_pin.sym} 136860 -1940 0 0 {name=p136461 lab=_69853_/X }
C {devices/lab_pin.sym} 137020 -2000 0 1 {name=p136462 lab=_69855_/B }
C {sky130_stdcells/a211o_4.sym} 136940 -2000 0 0 {name=X_69854_ }
C {devices/lab_pin.sym} 136860 -1880 0 0 {name=p136463 lab=_63348_/A }
C {devices/lab_pin.sym} 136860 -1840 0 0 {name=p136464 lab=_59700_/Y }
C {devices/lab_pin.sym} 136860 -1800 0 0 {name=p136465 lab=_61695_/A }
C {devices/lab_pin.sym} 136860 -1760 0 0 {name=p136466 lab=_59840_/A }
C {devices/lab_pin.sym} 137020 -1820 0 1 {name=p136467 lab=_62189_/X }
C {sky130_stdcells/a2bb2o_4.sym} 136940 -1820 0 0 {name=X_62189_ }
C {devices/lab_pin.sym} 136860 -1700 0 0 {name=p136468 lab=_87586_/Q }
C {devices/lab_pin.sym} 136860 -1660 0 0 {name=p136469 lab=_68757_/X }
C {devices/lab_pin.sym} 136860 -1620 0 0 {name=p136470 lab=_68731_/X }
C {devices/lab_pin.sym} 136860 -1580 0 0 {name=p136471 lab=_68804_/Y }
C {devices/lab_pin.sym} 137020 -1640 0 1 {name=p136472 lab=_68805_/X }
C {sky130_stdcells/a211o_4.sym} 136940 -1640 0 0 {name=X_68805_ }
C {devices/lab_pin.sym} 136850 -1490 0 0 {name=p136473 lab=_83438_/CLK }
C {devices/lab_pin.sym} 136850 -1470 0 0 {name=p136474 lab=_84851_/D }
C {devices/lab_pin.sym} 137030 -1490 0 1 {name=p136475 lab=_84851_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -1480 0 0 {name=X_84851_ }
C {devices/lab_pin.sym} 136880 -1360 0 0 {name=p136476 lab=_69785_/A }
C {devices/lab_pin.sym} 136880 -1320 0 0 {name=p136477 lab=_69785_/B }
C {devices/lab_pin.sym} 137000 -1340 0 1 {name=p136478 lab=_69785_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -1340 0 0 {name=X_69785_ }
C {devices/lab_pin.sym} 136900 -1210 0 0 {name=p136479 lab=_66642_/A }
C {devices/lab_pin.sym} 136980 -1210 0 1 {name=p136480 lab=_66997_/X }
C {sky130_stdcells/buf_2.sym} 136940 -1210 0 0 {name=X_66997_ }
C {devices/lab_pin.sym} 136850 -1090 0 0 {name=p136481 lab=_83820_/CLK }
C {devices/lab_pin.sym} 136850 -1070 0 0 {name=p136482 lab=_70309_/X }
C {devices/lab_pin.sym} 137030 -1090 0 1 {name=p136483 lab=_74729_/A }
C {sky130_stdcells/dfxtp_4.sym} 136940 -1080 0 0 {name=X_83802_ }
C {devices/lab_pin.sym} 136880 -970 0 0 {name=p136484 lab=_56593_/A }
C {devices/lab_pin.sym} 136880 -930 0 0 {name=p136485 lab=_56750_/B }
C {devices/lab_pin.sym} 136880 -890 0 0 {name=p136486 lab=_56749_/X }
C {devices/lab_pin.sym} 137000 -930 0 1 {name=p136487 lab=_56750_/Y }
C {sky130_stdcells/nand3_4.sym} 136940 -930 0 0 {name=X_56750_ }
C {devices/lab_pin.sym} 136860 -820 0 0 {name=p136488 lab=_86993_/Q }
C {devices/lab_pin.sym} 136860 -780 0 0 {name=p136489 lab=_68707_/X }
C {devices/lab_pin.sym} 136860 -740 0 0 {name=p136490 lab=_68630_/X }
C {devices/lab_pin.sym} 136860 -700 0 0 {name=p136491 lab=_68735_/X }
C {devices/lab_pin.sym} 137020 -760 0 1 {name=p136492 lab=_68736_/X }
C {sky130_stdcells/a211o_4.sym} 136940 -760 0 0 {name=X_68736_ }
C {devices/lab_pin.sym} 137770 -42150 0 0 {name=p136493 lab=_83153_/CLK }
C {devices/lab_pin.sym} 137770 -42130 0 0 {name=p136494 lab=_87570_/D }
C {devices/lab_pin.sym} 137950 -42150 0 1 {name=p136495 lab=_43115_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -42140 0 0 {name=X_87570_ }
C {devices/lab_pin.sym} 137780 -42030 0 0 {name=p136496 lab=_85533_/Q }
C {devices/lab_pin.sym} 137780 -41990 0 0 {name=p136497 lab=_53940_/X }
C {devices/lab_pin.sym} 137780 -41950 0 0 {name=p136498 lab=_53961_/Y }
C {devices/lab_pin.sym} 137940 -41990 0 1 {name=p136499 lab=_53962_/Y }
C {sky130_stdcells/o21ai_4.sym} 137860 -41990 0 0 {name=X_53962_ }
C {devices/lab_pin.sym} 137780 -41880 0 0 {name=p136500 lab=_65859_/X }
C {devices/lab_pin.sym} 137780 -41840 0 0 {name=p136501 lab=_85630_/Q }
C {devices/lab_pin.sym} 137780 -41800 0 0 {name=p136502 lab=_65860_/X }
C {devices/lab_pin.sym} 137780 -41760 0 0 {name=p136503 lab=_65947_/X }
C {devices/lab_pin.sym} 137940 -41820 0 1 {name=p136504 lab=_65948_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -41820 0 0 {name=X_65948_ }
C {devices/lab_pin.sym} 137770 -41670 0 0 {name=p136505 lab=_83438_/CLK }
C {devices/lab_pin.sym} 137770 -41650 0 0 {name=p136506 lab=_84782_/D }
C {devices/lab_pin.sym} 137950 -41670 0 1 {name=p136507 lab=_84782_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -41660 0 0 {name=X_84782_ }
C {devices/lab_pin.sym} 137770 -41530 0 0 {name=p136508 lab=_81994_/CLK }
C {devices/lab_pin.sym} 137770 -41510 0 0 {name=p136509 lab=_81994_/D }
C {devices/lab_pin.sym} 137950 -41530 0 1 {name=p136510 lab=_77050_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -41520 0 0 {name=X_81994_ }
C {devices/lab_pin.sym} 137820 -41390 0 0 {name=p136511 lab=_55701_/A }
C {devices/lab_pin.sym} 137900 -41390 0 1 {name=p136512 lab=_74284_/C }
C {sky130_stdcells/buf_2.sym} 137860 -41390 0 0 {name=X_55701_ }
C {devices/lab_pin.sym} 137770 -41270 0 0 {name=p136513 lab=_83584_/CLK }
C {devices/lab_pin.sym} 137770 -41250 0 0 {name=p136514 lab=_48453_/Y }
C {devices/lab_pin.sym} 137950 -41270 0 1 {name=p136515 lab=_72993_/B }
C {sky130_stdcells/dfxtp_4.sym} 137860 -41260 0 0 {name=X_86521_ }
C {devices/lab_pin.sym} 137780 -41150 0 0 {name=p136516 lab=_52911_/Y }
C {devices/lab_pin.sym} 137780 -41110 0 0 {name=p136517 lab=_52892_/X }
C {devices/lab_pin.sym} 137780 -41070 0 0 {name=p136518 lab=_52912_/X }
C {devices/lab_pin.sym} 137940 -41110 0 1 {name=p136519 lab=_52913_/Y }
C {sky130_stdcells/a21oi_4.sym} 137860 -41110 0 0 {name=X_52913_ }
C {devices/lab_pin.sym} 137770 -40970 0 0 {name=p136520 lab=_86317_/CLK }
C {devices/lab_pin.sym} 137770 -40950 0 0 {name=p136521 lab=_83733_/D }
C {devices/lab_pin.sym} 137950 -40970 0 1 {name=p136522 lab=_47410_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -40960 0 0 {name=X_83733_ }
C {devices/lab_pin.sym} 137820 -40830 0 0 {name=p136523 lab=_83327_/Q }
C {devices/lab_pin.sym} 137900 -40830 0 1 {name=p136524 lab=_56684_/C }
C {sky130_stdcells/buf_2.sym} 137860 -40830 0 0 {name=X_56681_ }
C {devices/lab_pin.sym} 137770 -40710 0 0 {name=p136525 lab=_80968_/CLK }
C {devices/lab_pin.sym} 137770 -40690 0 0 {name=p136526 lab=_80945_/D }
C {devices/lab_pin.sym} 137950 -40710 0 1 {name=p136527 lab=_80945_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -40700 0 0 {name=X_80945_ }
C {devices/lab_pin.sym} 137820 -40570 0 0 {name=p136528 lab=_57803_/A }
C {devices/lab_pin.sym} 137900 -40570 0 1 {name=p136529 lab=_68669_/A }
C {sky130_stdcells/buf_2.sym} 137860 -40570 0 0 {name=X_68667_ }
C {devices/lab_pin.sym} 137800 -40470 0 0 {name=p136530 lab=_50677_/A }
C {devices/lab_pin.sym} 137800 -40430 0 0 {name=p136531 lab=_53875_/B }
C {devices/lab_pin.sym} 137800 -40390 0 0 {name=p136532 lab=_53888_/C }
C {devices/lab_pin.sym} 137920 -40430 0 1 {name=p136533 lab=_53893_/X }
C {sky130_stdcells/and3_4.sym} 137860 -40430 0 0 {name=X_53893_ }
C {devices/lab_pin.sym} 137780 -40320 0 0 {name=p136534 lab=_65876_/X }
C {devices/lab_pin.sym} 137780 -40280 0 0 {name=p136535 lab=_85571_/Q }
C {devices/lab_pin.sym} 137780 -40240 0 0 {name=p136536 lab=_65669_/X }
C {devices/lab_pin.sym} 137780 -40200 0 0 {name=p136537 lab=_65878_/X }
C {devices/lab_pin.sym} 137940 -40260 0 1 {name=p136538 lab=_65879_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -40260 0 0 {name=X_65879_ }
C {devices/lab_pin.sym} 137820 -40110 0 0 {name=p136539 lab=_84852_/Q }
C {devices/lab_pin.sym} 137900 -40110 0 1 {name=p136540 lab=_58421_/A }
C {sky130_stdcells/inv_2.sym} 137860 -40110 0 0 {name=X_58420_ }
C {devices/lab_pin.sym} 137780 -40020 0 0 {name=p136541 lab=_45416_/A }
C {devices/lab_pin.sym} 137780 -39980 0 0 {name=p136542 lab=_55605_/X }
C {devices/lab_pin.sym} 137780 -39940 0 0 {name=p136543 lab=_44101_/A }
C {devices/lab_pin.sym} 137780 -39900 0 0 {name=p136544 lab=_55631_/X }
C {devices/lab_pin.sym} 137940 -39960 0 1 {name=p136545 lab=_55632_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -39960 0 0 {name=X_55632_ }
C {devices/lab_pin.sym} 137820 -39810 0 0 {name=p136546 lab=_57776_/A }
C {devices/lab_pin.sym} 137900 -39810 0 1 {name=p136547 lab=_68442_/A }
C {sky130_stdcells/buf_2.sym} 137860 -39810 0 0 {name=X_67618_ }
C {devices/lab_pin.sym} 137770 -39690 0 0 {name=p136548 lab=_85535_/CLK }
C {devices/lab_pin.sym} 137770 -39670 0 0 {name=p136549 lab=_49023_/Y }
C {devices/lab_pin.sym} 137950 -39690 0 1 {name=p136550 lab=_64951_/B }
C {sky130_stdcells/dfxtp_4.sym} 137860 -39680 0 0 {name=X_86452_ }
C {devices/lab_pin.sym} 137780 -39570 0 0 {name=p136551 lab=_85744_/Q }
C {devices/lab_pin.sym} 137780 -39530 0 0 {name=p136552 lab=_52821_/X }
C {devices/lab_pin.sym} 137780 -39490 0 0 {name=p136553 lab=_52843_/Y }
C {devices/lab_pin.sym} 137940 -39530 0 1 {name=p136554 lab=_52844_/Y }
C {sky130_stdcells/o21ai_4.sym} 137860 -39530 0 0 {name=X_52844_ }
C {devices/lab_pin.sym} 137770 -39390 0 0 {name=p136555 lab=_86089_/CLK }
C {devices/lab_pin.sym} 137770 -39370 0 0 {name=p136556 lab=_83664_/D }
C {devices/lab_pin.sym} 137950 -39390 0 1 {name=p136557 lab=_46850_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -39380 0 0 {name=X_83664_ }
C {devices/lab_pin.sym} 137770 -39250 0 0 {name=p136558 lab=_80849_/CLK }
C {devices/lab_pin.sym} 137770 -39230 0 0 {name=p136559 lab=_75667_/B }
C {devices/lab_pin.sym} 137950 -39250 0 1 {name=p136560 lab=_80876_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -39240 0 0 {name=X_80876_ }
C {devices/lab_pin.sym} 137820 -39110 0 0 {name=p136561 lab=_68479_/A }
C {devices/lab_pin.sym} 137900 -39110 0 1 {name=p136562 lab=_68599_/A }
C {sky130_stdcells/buf_2.sym} 137860 -39110 0 0 {name=X_68598_ }
C {devices/lab_pin.sym} 137770 -38990 0 0 {name=p136563 lab=_85499_/CLK }
C {devices/lab_pin.sym} 137770 -38970 0 0 {name=p136564 lab=_54653_/Y }
C {devices/lab_pin.sym} 137950 -38990 0 1 {name=p136565 lab=_85403_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -38980 0 0 {name=X_85403_ }
C {devices/lab_pin.sym} 137820 -38850 0 0 {name=p136566 lab=_84871_/Q }
C {devices/lab_pin.sym} 137900 -38850 0 1 {name=p136567 lab=_58352_/A }
C {sky130_stdcells/buf_2.sym} 137860 -38850 0 0 {name=X_58351_ }
C {devices/lab_pin.sym} 137770 -38730 0 0 {name=p136568 lab=_82711_/CLK }
C {devices/lab_pin.sym} 137770 -38710 0 0 {name=p136569 lab=_79001_/B }
C {devices/lab_pin.sym} 137950 -38730 0 1 {name=p136570 lab=_82615_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -38720 0 0 {name=X_82615_ }
C {devices/lab_pin.sym} 137820 -38590 0 0 {name=p136571 lab=_55826_/A }
C {devices/lab_pin.sym} 137900 -38590 0 1 {name=p136572 lab=_55836_/A }
C {sky130_stdcells/buf_2.sym} 137860 -38590 0 0 {name=X_55563_ }
C {devices/lab_pin.sym} 137770 -38470 0 0 {name=p136573 lab=_86384_/CLK }
C {devices/lab_pin.sym} 137770 -38450 0 0 {name=p136574 lab=_86383_/D }
C {devices/lab_pin.sym} 137950 -38470 0 1 {name=p136575 lab=_58800_/B }
C {sky130_stdcells/dfxtp_4.sym} 137860 -38460 0 0 {name=X_86383_ }
C {devices/lab_pin.sym} 137780 -38350 0 0 {name=p136576 lab=_67546_/X }
C {devices/lab_pin.sym} 137780 -38310 0 0 {name=p136577 lab=_67548_/X }
C {devices/lab_pin.sym} 137780 -38270 0 0 {name=p136578 lab=_67502_/X }
C {devices/lab_pin.sym} 137940 -38310 0 1 {name=p136579 lab=_67555_/A }
C {sky130_stdcells/a21o_4.sym} 137860 -38310 0 0 {name=X_67549_ }
C {devices/lab_pin.sym} 137800 -38200 0 0 {name=p136580 lab=_52775_/A }
C {devices/lab_pin.sym} 137800 -38160 0 0 {name=p136581 lab=_52775_/B }
C {devices/lab_pin.sym} 137800 -38120 0 0 {name=p136582 lab=_52775_/C }
C {devices/lab_pin.sym} 137800 -38080 0 0 {name=p136583 lab=_52775_/D }
C {devices/lab_pin.sym} 137920 -38140 0 1 {name=p136584 lab=_52775_/X }
C {sky130_stdcells/and4_4.sym} 137860 -38140 0 0 {name=X_52775_ }
C {devices/lab_pin.sym} 137770 -37990 0 0 {name=p136585 lab=_86749_/CLK }
C {devices/lab_pin.sym} 137770 -37970 0 0 {name=p136586 lab=_71132_/Y }
C {devices/lab_pin.sym} 137950 -37990 0 1 {name=p136587 lab=_49184_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -37980 0 0 {name=X_83595_ }
C {devices/lab_pin.sym} 137820 -37850 0 0 {name=p136588 lab=_57302_/A }
C {devices/lab_pin.sym} 137900 -37850 0 1 {name=p136589 lab=_57302_/Y }
C {sky130_stdcells/inv_2.sym} 137860 -37850 0 0 {name=X_57302_ }
C {devices/lab_pin.sym} 137770 -37730 0 0 {name=p136590 lab=_87865_/CLK }
C {devices/lab_pin.sym} 137770 -37710 0 0 {name=p136591 lab=_88122_/D }
C {devices/lab_pin.sym} 137950 -37730 0 1 {name=p136592 lab=_67183_/B }
C {sky130_stdcells/dfxtp_4.sym} 137860 -37720 0 0 {name=X_88122_ }
C {devices/lab_pin.sym} 137800 -37600 0 0 {name=p136593 lab=_54518_/A }
C {devices/lab_pin.sym} 137800 -37560 0 0 {name=p136594 lab=_53336_/B }
C {devices/lab_pin.sym} 137920 -37580 0 1 {name=p136595 lab=_54514_/Y }
C {sky130_stdcells/nand2_4.sym} 137860 -37580 0 0 {name=X_54514_ }
C {devices/lab_pin.sym} 137770 -37450 0 0 {name=p136596 lab=_85334_/CLK }
C {devices/lab_pin.sym} 137770 -37430 0 0 {name=p136597 lab=_55019_/Y }
C {devices/lab_pin.sym} 137950 -37450 0 1 {name=p136598 lab=_85334_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -37440 0 0 {name=X_85334_ }
C {devices/lab_pin.sym} 137800 -37340 0 0 {name=p136599 lab=_51709_/X }
C {devices/lab_pin.sym} 137800 -37300 0 0 {name=p136600 lab=_51721_/X }
C {devices/lab_pin.sym} 137800 -37260 0 0 {name=p136601 lab=_51715_/C }
C {devices/lab_pin.sym} 137800 -37220 0 0 {name=p136602 lab=_53249_/D }
C {devices/lab_pin.sym} 137920 -37280 0 1 {name=p136603 lab=_51726_/X }
C {sky130_stdcells/and4_4.sym} 137860 -37280 0 0 {name=X_51726_ }
C {devices/lab_pin.sym} 137780 -37150 0 0 {name=p136604 lab=_70533_/X }
C {devices/lab_pin.sym} 137780 -37110 0 0 {name=p136605 lab=_83749_/Q }
C {devices/lab_pin.sym} 137780 -37070 0 0 {name=p136606 lab=_70559_/Y }
C {devices/lab_pin.sym} 137940 -37110 0 1 {name=p136607 lab=_83749_/D }
C {sky130_stdcells/a21o_4.sym} 137860 -37110 0 0 {name=X_70560_ }
C {devices/lab_pin.sym} 137820 -36970 0 0 {name=p136608 lab=_58341_/A }
C {devices/lab_pin.sym} 137900 -36970 0 1 {name=p136609 lab=_58282_/X }
C {sky130_stdcells/buf_2.sym} 137860 -36970 0 0 {name=X_58282_ }
C {devices/lab_pin.sym} 137770 -36850 0 0 {name=p136610 lab=_82541_/CLK }
C {devices/lab_pin.sym} 137770 -36830 0 0 {name=p136611 lab=_83866_/Q }
C {devices/lab_pin.sym} 137950 -36850 0 1 {name=p136612 lab=_82546_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -36840 0 0 {name=X_82546_ }
C {devices/lab_pin.sym} 137780 -36740 0 0 {name=p136613 lab=_45582_/A }
C {devices/lab_pin.sym} 137780 -36700 0 0 {name=p136614 lab=_55492_/X }
C {devices/lab_pin.sym} 137780 -36660 0 0 {name=p136615 lab=_44047_/X }
C {devices/lab_pin.sym} 137780 -36620 0 0 {name=p136616 lab=_55493_/Y }
C {devices/lab_pin.sym} 137940 -36680 0 1 {name=p136617 lab=_55494_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -36680 0 0 {name=X_55494_ }
C {devices/lab_pin.sym} 137820 -36530 0 0 {name=p136618 lab=_57327_/B }
C {devices/lab_pin.sym} 137900 -36530 0 1 {name=p136619 lab=_57326_/C }
C {sky130_stdcells/buf_2.sym} 137860 -36530 0 0 {name=X_57233_ }
C {devices/lab_pin.sym} 137780 -36440 0 0 {name=p136620 lab=_88045_/Q }
C {devices/lab_pin.sym} 137780 -36400 0 0 {name=p136621 lab=_69217_/X }
C {devices/lab_pin.sym} 137780 -36360 0 0 {name=p136622 lab=_68976_/X }
C {devices/lab_pin.sym} 137780 -36320 0 0 {name=p136623 lab=_69218_/X }
C {devices/lab_pin.sym} 137940 -36380 0 1 {name=p136624 lab=_69219_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -36380 0 0 {name=X_69219_ }
C {devices/lab_pin.sym} 137770 -36230 0 0 {name=p136625 lab=_88324_/CLK }
C {devices/lab_pin.sym} 137770 -36210 0 0 {name=p136626 lab=_42062_/Y }
C {devices/lab_pin.sym} 137950 -36230 0 1 {name=p136627 lab=_88053_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -36220 0 0 {name=X_88053_ }
C {devices/lab_pin.sym} 137780 -36110 0 0 {name=p136628 lab=_54443_/Y }
C {devices/lab_pin.sym} 137780 -36070 0 0 {name=p136629 lab=_54422_/X }
C {devices/lab_pin.sym} 137780 -36030 0 0 {name=p136630 lab=_54444_/X }
C {devices/lab_pin.sym} 137940 -36070 0 1 {name=p136631 lab=_85441_/D }
C {sky130_stdcells/a21oi_4.sym} 137860 -36070 0 0 {name=X_54445_ }
C {devices/lab_pin.sym} 137770 -35930 0 0 {name=p136632 lab=_83025_/CLK }
C {devices/lab_pin.sym} 137770 -35910 0 0 {name=p136633 lab=_56236_/Y }
C {devices/lab_pin.sym} 137950 -35930 0 1 {name=p136634 lab=_85265_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -35920 0 0 {name=X_85265_ }
C {devices/lab_pin.sym} 137820 -35790 0 0 {name=p136635 lab=_52593_/A }
C {devices/lab_pin.sym} 137900 -35790 0 1 {name=p136636 lab=_51657_/X }
C {sky130_stdcells/buf_2.sym} 137860 -35790 0 0 {name=X_51657_ }
C {devices/lab_pin.sym} 137820 -35670 0 0 {name=p136637 lab=HASH_ADDR[0] }
C {devices/lab_pin.sym} 137900 -35670 0 1 {name=p136638 lab=_70491_/Y }
C {sky130_stdcells/inv_2.sym} 137860 -35670 0 0 {name=X_70491_ }
C {devices/lab_pin.sym} 137770 -35550 0 0 {name=p136639 lab=_82570_/CLK }
C {devices/lab_pin.sym} 137770 -35530 0 0 {name=p136640 lab=_78469_/X }
C {devices/lab_pin.sym} 137950 -35550 0 1 {name=p136641 lab=_78103_/B }
C {sky130_stdcells/dfxtp_4.sym} 137860 -35540 0 0 {name=X_82477_ }
C {devices/lab_pin.sym} 137770 -35410 0 0 {name=p136642 lab=_83139_/CLK }
C {devices/lab_pin.sym} 137770 -35390 0 0 {name=p136643 lab=_87004_/D }
C {devices/lab_pin.sym} 137950 -35410 0 1 {name=p136644 lab=_44675_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -35400 0 0 {name=X_87004_ }
C {devices/lab_pin.sym} 137820 -35270 0 0 {name=p136645 lab=_41410_/A }
C {devices/lab_pin.sym} 137900 -35270 0 1 {name=p136646 lab=_41410_/Y }
C {sky130_stdcells/inv_2.sym} 137860 -35270 0 0 {name=X_41410_ }
C {devices/lab_pin.sym} 137780 -35170 0 0 {name=p136647 lab=_72228_/X }
C {devices/lab_pin.sym} 137780 -35130 0 0 {name=p136648 lab=_85976_/Q }
C {devices/lab_pin.sym} 137780 -35090 0 0 {name=p136649 lab=_72229_/X }
C {devices/lab_pin.sym} 137940 -35130 0 1 {name=p136650 lab=_72230_/Y }
C {sky130_stdcells/o21ai_4.sym} 137860 -35130 0 0 {name=X_72230_ }
C {devices/lab_pin.sym} 137770 -34990 0 0 {name=p136651 lab=_84228_/CLK }
C {devices/lab_pin.sym} 137770 -34970 0 0 {name=p136652 lab=_84216_/D }
C {devices/lab_pin.sym} 137950 -34990 0 1 {name=p136653 lab=_84216_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -34980 0 0 {name=X_84216_ }
C {devices/lab_pin.sym} 137780 -34870 0 0 {name=p136654 lab=_86168_/Q }
C {devices/lab_pin.sym} 137780 -34830 0 0 {name=p136655 lab=_50563_/X }
C {devices/lab_pin.sym} 137780 -34790 0 0 {name=p136656 lab=_50607_/Y }
C {devices/lab_pin.sym} 137940 -34830 0 1 {name=p136657 lab=_50608_/Y }
C {sky130_stdcells/o21ai_4.sym} 137860 -34830 0 0 {name=X_50608_ }
C {devices/lab_pin.sym} 137770 -34690 0 0 {name=p136658 lab=_81428_/CLK }
C {devices/lab_pin.sym} 137770 -34670 0 0 {name=p136659 lab=_81460_/Q }
C {devices/lab_pin.sym} 137950 -34690 0 1 {name=p136660 lab=_76058_/B }
C {sky130_stdcells/dfxtp_4.sym} 137860 -34680 0 0 {name=X_81428_ }
C {devices/lab_pin.sym} 137800 -34580 0 0 {name=p136661 lab=_57170_/B }
C {devices/lab_pin.sym} 137800 -34540 0 0 {name=p136662 lab=_56808_/A }
C {devices/lab_pin.sym} 137800 -34500 0 0 {name=p136663 lab=_57155_/D }
C {devices/lab_pin.sym} 137800 -34460 0 0 {name=p136664 lab=_57129_/Y }
C {devices/lab_pin.sym} 137920 -34520 0 1 {name=p136665 lab=_57164_/X }
C {sky130_stdcells/and4_4.sym} 137860 -34520 0 0 {name=X_57164_ }
C {devices/lab_pin.sym} 137780 -34400 0 0 {name=p136666 lab=_40391_/X }
C {devices/lab_pin.sym} 137780 -34360 0 0 {name=p136667 lab=_42388_/X }
C {devices/lab_pin.sym} 137780 -34320 0 0 {name=p136668 lab=_87887_/Q }
C {devices/lab_pin.sym} 137780 -34280 0 0 {name=p136669 lab=_42389_/X }
C {devices/lab_pin.sym} 137940 -34340 0 1 {name=p136670 lab=_87887_/D }
C {sky130_stdcells/a2bb2o_4.sym} 137860 -34340 0 0 {name=X_42390_ }
C {devices/lab_pin.sym} 137820 -34190 0 0 {name=p136671 lab=_54376_/A }
C {devices/lab_pin.sym} 137900 -34190 0 1 {name=p136672 lab=_54376_/X }
C {sky130_stdcells/buf_2.sym} 137860 -34190 0 0 {name=X_54376_ }
C {devices/lab_pin.sym} 137770 -34070 0 0 {name=p136673 lab=_80670_/CLK }
C {devices/lab_pin.sym} 137770 -34050 0 0 {name=p136674 lab=_85196_/D }
C {devices/lab_pin.sym} 137950 -34070 0 1 {name=p136675 lab=_85196_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -34060 0 0 {name=X_85196_ }
C {devices/lab_pin.sym} 137800 -33960 0 0 {name=p136676 lab=_51580_/A }
C {devices/lab_pin.sym} 137800 -33920 0 0 {name=p136677 lab=_51603_/B }
C {devices/lab_pin.sym} 137800 -33880 0 0 {name=p136678 lab=_51603_/C }
C {devices/lab_pin.sym} 137800 -33840 0 0 {name=p136679 lab=_53113_/D }
C {devices/lab_pin.sym} 137920 -33900 0 1 {name=p136680 lab=_51588_/X }
C {sky130_stdcells/and4_4.sym} 137860 -33900 0 0 {name=X_51588_ }
C {devices/lab_pin.sym} 137800 -33770 0 0 {name=p136681 lab=_56131_/A }
C {devices/lab_pin.sym} 137800 -33730 0 0 {name=p136682 lab=_56115_/B }
C {devices/lab_pin.sym} 137800 -33690 0 0 {name=p136683 lab=_85293_/Q }
C {devices/lab_pin.sym} 137920 -33730 0 1 {name=p136684 lab=_56115_/Y }
C {sky130_stdcells/nand3_4.sym} 137860 -33730 0 0 {name=X_56115_ }
C {devices/lab_pin.sym} 137820 -33590 0 0 {name=p136685 lab=_41340_/X }
C {devices/lab_pin.sym} 137900 -33590 0 1 {name=p136686 lab=_41341_/X }
C {sky130_stdcells/buf_2.sym} 137860 -33590 0 0 {name=X_41341_ }
C {devices/lab_pin.sym} 137780 -33490 0 0 {name=p136687 lab=_85654_/Q }
C {devices/lab_pin.sym} 137780 -33450 0 0 {name=p136688 lab=_53324_/X }
C {devices/lab_pin.sym} 137780 -33410 0 0 {name=p136689 lab=_53326_/Y }
C {devices/lab_pin.sym} 137940 -33450 0 1 {name=p136690 lab=_53327_/Y }
C {sky130_stdcells/o21ai_4.sym} 137860 -33450 0 0 {name=X_53327_ }
C {devices/lab_pin.sym} 137820 -33310 0 0 {name=p136691 lab=_57790_/X }
C {devices/lab_pin.sym} 137900 -33310 0 1 {name=p136692 lab=_72162_/B }
C {sky130_stdcells/buf_2.sym} 137860 -33310 0 0 {name=X_72161_ }
C {devices/lab_pin.sym} 137770 -33190 0 0 {name=p136693 lab=_84231_/CLK }
C {devices/lab_pin.sym} 137770 -33170 0 0 {name=p136694 lab=_84147_/D }
C {devices/lab_pin.sym} 137950 -33190 0 1 {name=p136695 lab=_80397_/B }
C {sky130_stdcells/dfxtp_4.sym} 137860 -33180 0 0 {name=X_84147_ }
C {devices/lab_pin.sym} 137800 -33070 0 0 {name=p136696 lab=_48667_/A }
C {devices/lab_pin.sym} 137800 -33030 0 0 {name=p136697 lab=_50552_/B }
C {devices/lab_pin.sym} 137800 -32990 0 0 {name=p136698 lab=_50552_/C }
C {devices/lab_pin.sym} 137920 -33030 0 1 {name=p136699 lab=_50539_/X }
C {sky130_stdcells/and3_4.sym} 137860 -33030 0 0 {name=X_50539_ }
C {devices/lab_pin.sym} 137780 -32930 0 0 {name=p136700 lab=_56561_/X }
C {devices/lab_pin.sym} 137780 -32890 0 0 {name=p136701 lab=_57087_/X }
C {devices/lab_pin.sym} 137780 -32850 0 0 {name=p136702 lab=_56931_/X }
C {devices/lab_pin.sym} 137780 -32810 0 0 {name=p136703 lab=_45386_/A }
C {devices/lab_pin.sym} 137780 -32770 0 0 {name=p136704 lab=_57192_/A }
C {devices/lab_pin.sym} 137940 -32850 0 1 {name=p136705 lab=_85089_/D }
C {sky130_stdcells/a32o_4.sym} 137860 -32850 0 0 {name=X_57095_ }
C {devices/lab_pin.sym} 137770 -32690 0 0 {name=p136706 lab=_81492_/CLK }
C {devices/lab_pin.sym} 137770 -32670 0 0 {name=p136707 lab=_81359_/D }
C {devices/lab_pin.sym} 137950 -32690 0 1 {name=p136708 lab=_76343_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -32680 0 0 {name=X_81359_ }
C {devices/lab_pin.sym} 137820 -32550 0 0 {name=p136709 lab=_71003_/A }
C {devices/lab_pin.sym} 137900 -32550 0 1 {name=p136710 lab=_71112_/X }
C {sky130_stdcells/buf_2.sym} 137860 -32550 0 0 {name=X_71112_ }
C {devices/lab_pin.sym} 137820 -32430 0 0 {name=p136711 lab=_44059_/X }
C {devices/lab_pin.sym} 137900 -32430 0 1 {name=p136712 lab=_44060_/X }
C {sky130_stdcells/buf_2.sym} 137860 -32430 0 0 {name=X_44060_ }
C {devices/lab_pin.sym} 137800 -32320 0 0 {name=p136713 lab=_55907_/X }
C {devices/lab_pin.sym} 137800 -32280 0 0 {name=p136714 lab=_55914_/X }
C {devices/lab_pin.sym} 137920 -32300 0 1 {name=p136715 lab=_74306_/C }
C {sky130_stdcells/and2_4.sym} 137860 -32300 0 0 {name=X_56046_ }
C {devices/lab_pin.sym} 137820 -32170 0 0 {name=p136716 lab=_41271_/Y }
C {devices/lab_pin.sym} 137900 -32170 0 1 {name=p136717 lab=_41272_/X }
C {sky130_stdcells/buf_2.sym} 137860 -32170 0 0 {name=X_41272_ }
C {devices/lab_pin.sym} 137780 -32070 0 0 {name=p136718 lab=_53256_/Y }
C {devices/lab_pin.sym} 137780 -32030 0 0 {name=p136719 lab=_53242_/X }
C {devices/lab_pin.sym} 137780 -31990 0 0 {name=p136720 lab=_53257_/X }
C {devices/lab_pin.sym} 137940 -32030 0 1 {name=p136721 lab=_85667_/D }
C {sky130_stdcells/a21oi_4.sym} 137860 -32030 0 0 {name=X_53258_ }
C {devices/lab_pin.sym} 137800 -31900 0 0 {name=p136722 lab=_72091_/X }
C {devices/lab_pin.sym} 137800 -31860 0 0 {name=p136723 lab=_53917_/B }
C {devices/lab_pin.sym} 137920 -31880 0 1 {name=p136724 lab=_72092_/Y }
C {sky130_stdcells/nand2_4.sym} 137860 -31880 0 0 {name=X_72092_ }
C {devices/lab_pin.sym} 137770 -31750 0 0 {name=p136725 lab=_84014_/CLK }
C {devices/lab_pin.sym} 137770 -31730 0 0 {name=p136726 lab=_67235_/X }
C {devices/lab_pin.sym} 137950 -31750 0 1 {name=p136727 lab=_84078_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -31740 0 0 {name=X_84078_ }
C {devices/lab_pin.sym} 137780 -31640 0 0 {name=p136728 lab=_40548_/X }
C {devices/lab_pin.sym} 137780 -31600 0 0 {name=p136729 lab=_51934_/A }
C {devices/lab_pin.sym} 137780 -31560 0 0 {name=p136730 lab=_87604_/Q }
C {devices/lab_pin.sym} 137780 -31520 0 0 {name=p136731 lab=_42634_/A }
C {devices/lab_pin.sym} 137940 -31580 0 1 {name=p136732 lab=_87604_/D }
C {sky130_stdcells/a2bb2o_4.sym} 137860 -31580 0 0 {name=X_43011_ }
C {devices/lab_pin.sym} 137780 -31450 0 0 {name=p136733 lab=_52207_/Y }
C {devices/lab_pin.sym} 137780 -31410 0 0 {name=p136734 lab=_52117_/X }
C {devices/lab_pin.sym} 137780 -31370 0 0 {name=p136735 lab=_52208_/Y }
C {devices/lab_pin.sym} 137940 -31410 0 1 {name=p136736 lab=_85868_/D }
C {sky130_stdcells/a21boi_4.sym} 137860 -31410 0 0 {name=X_52209_ }
C {devices/lab_pin.sym} 137800 -31300 0 0 {name=p136737 lab=_71041_/X }
C {devices/lab_pin.sym} 137800 -31260 0 0 {name=p136738 lab=_70588_/A }
C {devices/lab_pin.sym} 137800 -31220 0 0 {name=p136739 lab=_71276_/C }
C {devices/lab_pin.sym} 137800 -31180 0 0 {name=p136740 lab=_71039_/D }
C {devices/lab_pin.sym} 137920 -31240 0 1 {name=p136741 lab=_71043_/Y }
C {sky130_stdcells/nand4_4.sym} 137860 -31240 0 0 {name=X_71043_ }
C {devices/lab_pin.sym} 137770 -31090 0 0 {name=p136742 lab=_85269_/CLK }
C {devices/lab_pin.sym} 137770 -31070 0 0 {name=p136743 lab=_83029_/D }
C {devices/lab_pin.sym} 137950 -31090 0 1 {name=p136744 lab=_45094_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -31080 0 0 {name=X_83029_ }
C {devices/lab_pin.sym} 137770 -30950 0 0 {name=p136745 lab=_87394_/CLK }
C {devices/lab_pin.sym} 137770 -30930 0 0 {name=p136746 lab=_42354_/X }
C {devices/lab_pin.sym} 137950 -30950 0 1 {name=p136747 lab=_87906_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -30940 0 0 {name=X_87906_ }
C {devices/lab_pin.sym} 137800 -30820 0 0 {name=p136748 lab=_84518_/Q }
C {devices/lab_pin.sym} 137800 -30780 0 0 {name=p136749 lab=_84390_/Q }
C {devices/lab_pin.sym} 137920 -30800 0 1 {name=p136750 lab=_75920_/X }
C {sky130_stdcells/xor2_4.sym} 137860 -30800 0 0 {name=X_75920_ }
C {devices/lab_pin.sym} 137820 -30670 0 0 {name=p136751 lab=_53189_/A }
C {devices/lab_pin.sym} 137900 -30670 0 1 {name=p136752 lab=_53189_/X }
C {sky130_stdcells/buf_2.sym} 137860 -30670 0 0 {name=X_53189_ }
C {devices/lab_pin.sym} 137820 -30550 0 0 {name=p136753 lab=_59805_/A }
C {devices/lab_pin.sym} 137900 -30550 0 1 {name=p136754 lab=_59805_/Y }
C {sky130_stdcells/inv_2.sym} 137860 -30550 0 0 {name=X_59805_ }
C {devices/lab_pin.sym} 137800 -30440 0 0 {name=p136755 lab=_81104_/Q }
C {devices/lab_pin.sym} 137800 -30400 0 0 {name=p136756 lab=_75851_/B }
C {devices/lab_pin.sym} 137920 -30420 0 1 {name=p136757 lab=_75867_/A }
C {sky130_stdcells/xnor2_4.sym} 137860 -30420 0 0 {name=X_75851_ }
C {devices/lab_pin.sym} 137770 -30290 0 0 {name=p136758 lab=_87588_/CLK }
C {devices/lab_pin.sym} 137770 -30270 0 0 {name=p136759 lab=_42516_/Y }
C {devices/lab_pin.sym} 137950 -30290 0 1 {name=p136760 lab=_74071_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -30280 0 0 {name=X_87837_ }
C {devices/lab_pin.sym} 137820 -30150 0 0 {name=p136761 lab=_45926_/X }
C {devices/lab_pin.sym} 137900 -30150 0 1 {name=p136762 lab=_57997_/X }
C {sky130_stdcells/buf_2.sym} 137860 -30150 0 0 {name=X_57997_ }
C {devices/lab_pin.sym} 137780 -30070 0 0 {name=p136763 lab=_83848_/Q }
C {devices/lab_pin.sym} 137780 -30030 0 0 {name=p136764 lab=_74735_/X }
C {devices/lab_pin.sym} 137780 -29990 0 0 {name=p136765 lab=_74799_/X }
C {devices/lab_pin.sym} 137780 -29950 0 0 {name=p136766 lab=_74800_/X }
C {devices/lab_pin.sym} 137780 -29910 0 0 {name=p136767 lab=_74801_/X }
C {devices/lab_pin.sym} 137940 -29990 0 1 {name=p136768 lab=_74802_/Y }
C {sky130_stdcells/a2111oi_4.sym} 137860 -29990 0 0 {name=X_74802_ }
C {devices/lab_pin.sym} 137780 -29850 0 0 {name=p136769 lab=_47744_/Y }
C {devices/lab_pin.sym} 137780 -29810 0 0 {name=p136770 lab=_47745_/X }
C {devices/lab_pin.sym} 137780 -29770 0 0 {name=p136771 lab=_47749_/X }
C {devices/lab_pin.sym} 137940 -29810 0 1 {name=p136772 lab=_86602_/D }
C {sky130_stdcells/a21oi_4.sym} 137860 -29810 0 0 {name=X_47750_ }
C {devices/lab_pin.sym} 137820 -29670 0 0 {name=p136773 lab=_59842_/A }
C {devices/lab_pin.sym} 137900 -29670 0 1 {name=p136774 lab=_59737_/A }
C {sky130_stdcells/buf_2.sym} 137860 -29670 0 0 {name=X_59736_ }
C {devices/lab_pin.sym} 137780 -29570 0 0 {name=p136775 lab=_78569_/B }
C {devices/lab_pin.sym} 137780 -29530 0 0 {name=p136776 lab=_78569_/C }
C {devices/lab_pin.sym} 137780 -29490 0 0 {name=p136777 lab=_78569_/A }
C {devices/lab_pin.sym} 137940 -29530 0 1 {name=p136778 lab=_78574_/C }
C {sky130_stdcells/o21ai_4.sym} 137860 -29530 0 0 {name=X_78570_ }
C {devices/lab_pin.sym} 137780 -29410 0 0 {name=p136779 lab=_44957_/Y }
C {devices/lab_pin.sym} 137780 -29370 0 0 {name=p136780 lab=_44961_/Y }
C {devices/lab_pin.sym} 137780 -29330 0 0 {name=p136781 lab=_44889_/X }
C {devices/lab_pin.sym} 137940 -29370 0 1 {name=p136782 lab=_44962_/X }
C {sky130_stdcells/a21o_4.sym} 137860 -29370 0 0 {name=X_44962_ }
C {devices/lab_pin.sym} 137780 -29260 0 0 {name=p136783 lab=_44214_/X }
C {devices/lab_pin.sym} 137780 -29220 0 0 {name=p136784 lab=_56584_/X }
C {devices/lab_pin.sym} 137780 -29180 0 0 {name=p136785 lab=_85117_/Q }
C {devices/lab_pin.sym} 137780 -29140 0 0 {name=p136786 lab=_56947_/X }
C {devices/lab_pin.sym} 137940 -29200 0 1 {name=p136787 lab=_85117_/D }
C {sky130_stdcells/a2bb2o_4.sym} 137860 -29200 0 0 {name=X_56948_ }
C {devices/lab_pin.sym} 137800 -29060 0 0 {name=p136788 lab=_75771_/Y }
C {devices/lab_pin.sym} 137800 -29020 0 0 {name=p136789 lab=_75775_/Y }
C {devices/lab_pin.sym} 137920 -29040 0 1 {name=p136790 lab=_75782_/Y }
C {sky130_stdcells/nor2_4.sym} 137860 -29040 0 0 {name=X_75782_ }
C {devices/lab_pin.sym} 137770 -28910 0 0 {name=p136791 lab=_87520_/CLK }
C {devices/lab_pin.sym} 137770 -28890 0 0 {name=p136792 lab=_42692_/Y }
C {devices/lab_pin.sym} 137950 -28910 0 1 {name=p136793 lab=_87768_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -28900 0 0 {name=X_87768_ }
C {devices/lab_pin.sym} 137780 -28800 0 0 {name=p136794 lab=_72978_/X }
C {devices/lab_pin.sym} 137780 -28760 0 0 {name=p136795 lab=_83073_/Q }
C {devices/lab_pin.sym} 137780 -28720 0 0 {name=p136796 lab=_72992_/X }
C {devices/lab_pin.sym} 137780 -28680 0 0 {name=p136797 lab=_72993_/X }
C {devices/lab_pin.sym} 137940 -28740 0 1 {name=p136798 lab=_72994_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -28740 0 0 {name=X_72994_ }
C {devices/lab_pin.sym} 137820 -28590 0 0 {name=p136799 lab=_54314_/B }
C {devices/lab_pin.sym} 137900 -28590 0 1 {name=p136800 lab=_46701_/X }
C {sky130_stdcells/buf_2.sym} 137860 -28590 0 0 {name=X_46701_ }
C {devices/lab_pin.sym} 137800 -28480 0 0 {name=p136801 lab=_77502_/A }
C {devices/lab_pin.sym} 137800 -28440 0 0 {name=p136802 lab=_77514_/A }
C {devices/lab_pin.sym} 137920 -28460 0 1 {name=p136803 lab=_77521_/Y }
C {sky130_stdcells/nor2_4.sym} 137860 -28460 0 0 {name=X_77521_ }
C {devices/lab_pin.sym} 137820 -28330 0 0 {name=p136804 lab=_43913_/A }
C {devices/lab_pin.sym} 137900 -28330 0 1 {name=p136805 lab=_87202_/D }
C {sky130_stdcells/inv_2.sym} 137860 -28330 0 0 {name=X_43913_ }
C {devices/lab_pin.sym} 137780 -28250 0 0 {name=p136806 lab=_83826_/Q }
C {devices/lab_pin.sym} 137780 -28210 0 0 {name=p136807 lab=_74716_/X }
C {devices/lab_pin.sym} 137780 -28170 0 0 {name=p136808 lab=_74720_/X }
C {devices/lab_pin.sym} 137780 -28130 0 0 {name=p136809 lab=_74730_/Y }
C {devices/lab_pin.sym} 137780 -28090 0 0 {name=p136810 lab=_74732_/X }
C {devices/lab_pin.sym} 137940 -28170 0 1 {name=p136811 lab=_80643_/A }
C {sky130_stdcells/a2111o_4.sym} 137860 -28170 0 0 {name=X_74733_ }
C {devices/lab_pin.sym} 137770 -28010 0 0 {name=p136812 lab=_86398_/CLK }
C {devices/lab_pin.sym} 137770 -27990 0 0 {name=p136813 lab=_86719_/D }
C {devices/lab_pin.sym} 137950 -28010 0 1 {name=p136814 lab=_86719_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -28000 0 0 {name=X_86719_ }
C {devices/lab_pin.sym} 137780 -27890 0 0 {name=p136815 lab=_86609_/Q }
C {devices/lab_pin.sym} 137780 -27850 0 0 {name=p136816 lab=_47666_/X }
C {devices/lab_pin.sym} 137780 -27810 0 0 {name=p136817 lab=_47680_/Y }
C {devices/lab_pin.sym} 137940 -27850 0 1 {name=p136818 lab=_47681_/Y }
C {sky130_stdcells/o21ai_4.sym} 137860 -27850 0 0 {name=X_47681_ }
C {devices/lab_pin.sym} 137800 -27740 0 0 {name=p136819 lab=_74523_/A }
C {devices/lab_pin.sym} 137800 -27700 0 0 {name=p136820 lab=_71001_/C }
C {devices/lab_pin.sym} 137800 -27660 0 0 {name=p136821 lab=_71349_/D }
C {devices/lab_pin.sym} 137800 -27620 0 0 {name=p136822 lab=_71945_/D }
C {devices/lab_pin.sym} 137920 -27680 0 1 {name=p136823 lab=_71945_/Y }
C {sky130_stdcells/nand4_4.sym} 137860 -27680 0 0 {name=X_71945_ }
C {devices/lab_pin.sym} 137820 -27530 0 0 {name=p136824 lab=_59824_/B }
C {devices/lab_pin.sym} 137900 -27530 0 1 {name=p136825 lab=_59668_/B }
C {sky130_stdcells/buf_2.sym} 137860 -27530 0 0 {name=X_59667_ }
C {devices/lab_pin.sym} 137820 -27410 0 0 {name=p136826 lab=_44892_/X }
C {devices/lab_pin.sym} 137900 -27410 0 1 {name=p136827 lab=_44894_/B }
C {sky130_stdcells/buf_2.sym} 137860 -27410 0 0 {name=X_44893_ }
C {devices/lab_pin.sym} 137800 -27310 0 0 {name=p136828 lab=_56645_/Y }
C {devices/lab_pin.sym} 137800 -27270 0 0 {name=p136829 lab=_56860_/X }
C {devices/lab_pin.sym} 137800 -27230 0 0 {name=p136830 lab=_83330_/Q }
C {devices/lab_pin.sym} 137920 -27270 0 1 {name=p136831 lab=_56880_/B }
C {sky130_stdcells/nand3_4.sym} 137860 -27270 0 0 {name=X_56879_ }
C {devices/lab_pin.sym} 137770 -27130 0 0 {name=p136832 lab=_87888_/CLK }
C {devices/lab_pin.sym} 137770 -27110 0 0 {name=p136833 lab=_42825_/X }
C {devices/lab_pin.sym} 137950 -27130 0 1 {name=p136834 lab=_66535_/B }
C {sky130_stdcells/dfxtp_4.sym} 137860 -27120 0 0 {name=X_87699_ }
C {devices/lab_pin.sym} 137800 -27020 0 0 {name=p136835 lab=_49420_/A }
C {devices/lab_pin.sym} 137800 -26980 0 0 {name=p136836 lab=_49420_/B }
C {devices/lab_pin.sym} 137800 -26940 0 0 {name=p136837 lab=_49420_/C }
C {devices/lab_pin.sym} 137800 -26900 0 0 {name=p136838 lab=_46716_/X }
C {devices/lab_pin.sym} 137920 -26960 0 1 {name=p136839 lab=_49420_/X }
C {sky130_stdcells/and4_4.sym} 137860 -26960 0 0 {name=X_49420_ }
C {devices/lab_pin.sym} 137780 -26830 0 0 {name=p136840 lab=_46627_/Y }
C {devices/lab_pin.sym} 137780 -26790 0 0 {name=p136841 lab=_46598_/X }
C {devices/lab_pin.sym} 137780 -26750 0 0 {name=p136842 lab=_46631_/X }
C {devices/lab_pin.sym} 137940 -26790 0 1 {name=p136843 lab=_86720_/D }
C {sky130_stdcells/a21oi_4.sym} 137860 -26790 0 0 {name=X_46632_ }
C {devices/lab_pin.sym} 137820 -26650 0 0 {name=p136844 lab=_58618_/A }
C {devices/lab_pin.sym} 137900 -26650 0 1 {name=p136845 lab=_58618_/X }
C {sky130_stdcells/buf_2.sym} 137860 -26650 0 0 {name=X_58618_ }
C {devices/lab_pin.sym} 137800 -26540 0 0 {name=p136846 lab=_77452_/A }
C {devices/lab_pin.sym} 137800 -26500 0 0 {name=p136847 lab=_77451_/X }
C {devices/lab_pin.sym} 137920 -26520 0 1 {name=p136848 lab=_82193_/D }
C {sky130_stdcells/xnor2_4.sym} 137860 -26520 0 0 {name=X_77452_ }
C {devices/lab_pin.sym} 137780 -26420 0 0 {name=p136849 lab=_41179_/X }
C {devices/lab_pin.sym} 137780 -26380 0 0 {name=p136850 lab=_43842_/X }
C {devices/lab_pin.sym} 137780 -26340 0 0 {name=p136851 lab=_87238_/Q }
C {devices/lab_pin.sym} 137780 -26300 0 0 {name=p136852 lab=_43843_/X }
C {devices/lab_pin.sym} 137940 -26360 0 1 {name=p136853 lab=_43844_/X }
C {sky130_stdcells/a2bb2o_4.sym} 137860 -26360 0 0 {name=X_43844_ }
C {devices/lab_pin.sym} 137820 -26210 0 0 {name=p136854 lab=_74664_/A }
C {devices/lab_pin.sym} 137900 -26210 0 1 {name=p136855 lab=_74664_/Y }
C {sky130_stdcells/inv_2.sym} 137860 -26210 0 0 {name=X_74664_ }
C {devices/lab_pin.sym} 137800 -26120 0 0 {name=p136856 lab=_70543_/Y }
C {devices/lab_pin.sym} 137800 -26080 0 0 {name=p136857 lab=_71883_/B }
C {devices/lab_pin.sym} 137800 -26040 0 0 {name=p136858 lab=_71873_/X }
C {devices/lab_pin.sym} 137800 -26000 0 0 {name=p136859 lab=_71874_/D }
C {devices/lab_pin.sym} 137920 -26060 0 1 {name=p136860 lab=_71876_/Y }
C {sky130_stdcells/nor4_4.sym} 137860 -26060 0 0 {name=X_71876_ }
C {devices/lab_pin.sym} 137800 -25940 0 0 {name=p136861 lab=_59598_/A }
C {devices/lab_pin.sym} 137800 -25900 0 0 {name=p136862 lab=_59544_/A }
C {devices/lab_pin.sym} 137800 -25860 0 0 {name=p136863 lab=_59544_/B }
C {devices/lab_pin.sym} 137800 -25820 0 0 {name=p136864 lab=_59544_/D }
C {devices/lab_pin.sym} 137920 -25880 0 1 {name=p136865 lab=_60630_/C }
C {sky130_stdcells/nand4_4.sym} 137860 -25880 0 0 {name=X_59598_ }
C {devices/lab_pin.sym} 137820 -25730 0 0 {name=p136866 lab=clkbuf_9_176_0_CLK/X }
C {devices/lab_pin.sym} 137900 -25730 0 1 {name=p136867 lab=_83736_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 137860 -25730 0 0 {name=Xclkbuf_10_352_0_CLK }
C {devices/lab_pin.sym} 137800 -25620 0 0 {name=p136868 lab=_76400_/X }
C {devices/lab_pin.sym} 137800 -25580 0 0 {name=p136869 lab=_76403_/B }
C {devices/lab_pin.sym} 137920 -25600 0 1 {name=p136870 lab=_76406_/A }
C {sky130_stdcells/nand2_4.sym} 137860 -25600 0 0 {name=X_76403_ }
C {devices/lab_pin.sym} 137780 -25490 0 0 {name=p136871 lab=_49349_/Y }
C {devices/lab_pin.sym} 137780 -25450 0 0 {name=p136872 lab=_48194_/X }
C {devices/lab_pin.sym} 137780 -25410 0 0 {name=p136873 lab=_49350_/Y }
C {devices/lab_pin.sym} 137940 -25450 0 1 {name=p136874 lab=_86404_/D }
C {sky130_stdcells/a21boi_4.sym} 137860 -25450 0 0 {name=X_49351_ }
C {devices/lab_pin.sym} 137820 -25310 0 0 {name=p136875 lab=_72874_/A }
C {devices/lab_pin.sym} 137900 -25310 0 1 {name=p136876 lab=_73641_/A }
C {sky130_stdcells/buf_2.sym} 137860 -25310 0 0 {name=X_73615_ }
C {devices/lab_pin.sym} 137820 -25190 0 0 {name=p136877 lab=_83781_/Q }
C {devices/lab_pin.sym} 137900 -25190 0 1 {name=p136878 lab=_54077_/B }
C {sky130_stdcells/inv_2.sym} 137860 -25190 0 0 {name=X_46563_ }
C {devices/lab_pin.sym} 137800 -25090 0 0 {name=p136879 lab=_70358_/X }
C {devices/lab_pin.sym} 137800 -25050 0 0 {name=p136880 lab=_70827_/B }
C {devices/lab_pin.sym} 137800 -25010 0 0 {name=p136881 lab=_70827_/C }
C {devices/lab_pin.sym} 137920 -25050 0 1 {name=p136882 lab=_70828_/A }
C {sky130_stdcells/nor3_4.sym} 137860 -25050 0 0 {name=X_70827_ }
C {devices/lab_pin.sym} 137780 -24930 0 0 {name=p136883 lab=_58334_/X }
C {devices/lab_pin.sym} 137780 -24890 0 0 {name=p136884 lab=_58546_/Y }
C {devices/lab_pin.sym} 137780 -24850 0 0 {name=p136885 lab=_58548_/Y }
C {devices/lab_pin.sym} 137940 -24890 0 1 {name=p136886 lab=_58549_/Y }
C {sky130_stdcells/a21oi_4.sym} 137860 -24890 0 0 {name=X_58549_ }
C {devices/lab_pin.sym} 137780 -24770 0 0 {name=p136887 lab=_77382_/B }
C {devices/lab_pin.sym} 137780 -24730 0 0 {name=p136888 lab=_77381_/Y }
C {devices/lab_pin.sym} 137780 -24690 0 0 {name=p136889 lab=_77382_/A }
C {devices/lab_pin.sym} 137940 -24730 0 1 {name=p136890 lab=_77383_/Y }
C {sky130_stdcells/o21ai_4.sym} 137860 -24730 0 0 {name=X_77383_ }
C {devices/lab_pin.sym} 137820 -24590 0 0 {name=p136891 lab=_43756_/A }
C {devices/lab_pin.sym} 137900 -24590 0 1 {name=p136892 lab=_43776_/A }
C {sky130_stdcells/buf_2.sym} 137860 -24590 0 0 {name=X_43775_ }
C {devices/lab_pin.sym} 137780 -24490 0 0 {name=p136893 lab=_45199_/A }
C {devices/lab_pin.sym} 137780 -24450 0 0 {name=p136894 lab=_74582_/X }
C {devices/lab_pin.sym} 137780 -24410 0 0 {name=p136895 lab=_74594_/X }
C {devices/lab_pin.sym} 137940 -24450 0 1 {name=p136896 lab=_83022_/D }
C {sky130_stdcells/o21ai_4.sym} 137860 -24450 0 0 {name=X_74595_ }
C {devices/lab_pin.sym} 137820 -24310 0 0 {name=p136897 lab=_40941_/A }
C {devices/lab_pin.sym} 137900 -24310 0 1 {name=p136898 lab=_40987_/X }
C {sky130_stdcells/buf_2.sym} 137860 -24310 0 0 {name=X_40987_ }
C {devices/lab_pin.sym} 137820 -24190 0 0 {name=p136899 lab=clkbuf_9_491_0_CLK/X }
C {devices/lab_pin.sym} 137900 -24190 0 1 {name=p136900 lab=_85837_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 137860 -24190 0 0 {name=Xclkbuf_10_982_0_CLK }
C {devices/lab_pin.sym} 137820 -24070 0 0 {name=p136901 lab=_48193_/X }
C {devices/lab_pin.sym} 137900 -24070 0 1 {name=p136902 lab=_48302_/X }
C {sky130_stdcells/buf_2.sym} 137860 -24070 0 0 {name=X_48302_ }
C {devices/lab_pin.sym} 137800 -23960 0 0 {name=p136903 lab=_79122_/A }
C {devices/lab_pin.sym} 137800 -23920 0 0 {name=p136904 lab=_79122_/B }
C {devices/lab_pin.sym} 137920 -23940 0 1 {name=p136905 lab=_82499_/D }
C {sky130_stdcells/nand2_4.sym} 137860 -23940 0 0 {name=X_79122_ }
C {devices/lab_pin.sym} 137780 -23830 0 0 {name=p136906 lab=_45506_/X }
C {devices/lab_pin.sym} 137780 -23790 0 0 {name=p136907 lab=_45510_/X }
C {devices/lab_pin.sym} 137780 -23750 0 0 {name=p136908 lab=_45513_/Y }
C {devices/lab_pin.sym} 137940 -23790 0 1 {name=p136909 lab=_45514_/Y }
C {sky130_stdcells/a21oi_4.sym} 137860 -23790 0 0 {name=X_45514_ }
C {devices/lab_pin.sym} 137800 -23670 0 0 {name=p136910 lab=_76330_/Y }
C {devices/lab_pin.sym} 137800 -23630 0 0 {name=p136911 lab=_76331_/Y }
C {devices/lab_pin.sym} 137800 -23590 0 0 {name=p136912 lab=_76333_/Y }
C {devices/lab_pin.sym} 137920 -23630 0 1 {name=p136913 lab=_76336_/A }
C {sky130_stdcells/or3_4.sym} 137860 -23630 0 0 {name=X_76334_ }
C {devices/lab_pin.sym} 137780 -23520 0 0 {name=p136914 lab=_41179_/X }
C {devices/lab_pin.sym} 137780 -23480 0 0 {name=p136915 lab=_42717_/X }
C {devices/lab_pin.sym} 137780 -23440 0 0 {name=p136916 lab=_87750_/Q }
C {devices/lab_pin.sym} 137780 -23400 0 0 {name=p136917 lab=_42718_/X }
C {devices/lab_pin.sym} 137940 -23460 0 1 {name=p136918 lab=_87750_/D }
C {sky130_stdcells/a2bb2o_4.sym} 137860 -23460 0 0 {name=X_42726_ }
C {devices/lab_pin.sym} 137820 -23310 0 0 {name=p136919 lab=_71959_/A }
C {devices/lab_pin.sym} 137900 -23310 0 1 {name=p136920 lab=_49283_/B }
C {sky130_stdcells/buf_2.sym} 137860 -23310 0 0 {name=X_49282_ }
C {devices/lab_pin.sym} 137800 -23210 0 0 {name=p136921 lab=_61541_/A }
C {devices/lab_pin.sym} 137800 -23170 0 0 {name=p136922 lab=_61560_/B }
C {devices/lab_pin.sym} 137800 -23130 0 0 {name=p136923 lab=_61541_/C }
C {devices/lab_pin.sym} 137920 -23170 0 1 {name=p136924 lab=_61560_/Y }
C {sky130_stdcells/nand3_4.sym} 137860 -23170 0 0 {name=X_61560_ }
C {devices/lab_pin.sym} 137820 -23030 0 0 {name=p136925 lab=_73367_/A }
C {devices/lab_pin.sym} 137900 -23030 0 1 {name=p136926 lab=_73546_/X }
C {sky130_stdcells/buf_2.sym} 137860 -23030 0 0 {name=X_73546_ }
C {devices/lab_pin.sym} 137820 -22910 0 0 {name=p136927 lab=_81196_/Q }
C {devices/lab_pin.sym} 137900 -22910 0 1 {name=p136928 lab=_46495_/B }
C {sky130_stdcells/inv_2.sym} 137860 -22910 0 0 {name=X_46494_ }
C {devices/lab_pin.sym} 137800 -22810 0 0 {name=p136929 lab=_70758_/A }
C {devices/lab_pin.sym} 137800 -22770 0 0 {name=p136930 lab=_70758_/B }
C {devices/lab_pin.sym} 137800 -22730 0 0 {name=p136931 lab=_70758_/C }
C {devices/lab_pin.sym} 137920 -22770 0 1 {name=p136932 lab=_70764_/A }
C {sky130_stdcells/nor3_4.sym} 137860 -22770 0 0 {name=X_70758_ }
C {devices/lab_pin.sym} 137820 -22630 0 0 {name=p136933 lab=clkbuf_8_236_0_CLK/X }
C {devices/lab_pin.sym} 137900 -22630 0 1 {name=p136934 lab=clkbuf_9_473_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 137860 -22630 0 0 {name=Xclkbuf_9_473_0_CLK }
C {devices/lab_pin.sym} 137820 -22510 0 0 {name=p136935 lab=_48193_/X }
C {devices/lab_pin.sym} 137900 -22510 0 1 {name=p136936 lab=_48233_/X }
C {sky130_stdcells/buf_2.sym} 137860 -22510 0 0 {name=X_48233_ }
C {devices/lab_pin.sym} 137780 -22420 0 0 {name=p136937 lab=_79149_/A }
C {devices/lab_pin.sym} 137780 -22380 0 0 {name=p136938 lab=_60246_/X }
C {devices/lab_pin.sym} 137780 -22340 0 0 {name=p136939 lab=_60586_/D }
C {devices/lab_pin.sym} 137780 -22300 0 0 {name=p136940 lab=_60510_/Y }
C {devices/lab_pin.sym} 137940 -22360 0 1 {name=p136941 lab=_60511_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 137860 -22360 0 0 {name=X_60511_ }
C {devices/lab_pin.sym} 137800 -22220 0 0 {name=p136942 lab=_79053_/A }
C {devices/lab_pin.sym} 137800 -22180 0 0 {name=p136943 lab=_79053_/B }
C {devices/lab_pin.sym} 137920 -22200 0 1 {name=p136944 lab=_79054_/A }
C {sky130_stdcells/nand2_4.sym} 137860 -22200 0 0 {name=X_79053_ }
C {devices/lab_pin.sym} 137780 -22100 0 0 {name=p136945 lab=_55596_/B }
C {devices/lab_pin.sym} 137780 -22060 0 0 {name=p136946 lab=_45412_/X }
C {devices/lab_pin.sym} 137780 -22020 0 0 {name=p136947 lab=_45443_/X }
C {devices/lab_pin.sym} 137780 -21980 0 0 {name=p136948 lab=_45444_/Y }
C {devices/lab_pin.sym} 137940 -22040 0 1 {name=p136949 lab=_45445_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -22040 0 0 {name=X_45445_ }
C {devices/lab_pin.sym} 137780 -21910 0 0 {name=p136950 lab=_76261_/X }
C {devices/lab_pin.sym} 137780 -21870 0 0 {name=p136951 lab=_76262_/Y }
C {devices/lab_pin.sym} 137780 -21830 0 0 {name=p136952 lab=_76264_/Y }
C {devices/lab_pin.sym} 137940 -21870 0 1 {name=p136953 lab=_76267_/A }
C {sky130_stdcells/a21o_4.sym} 137860 -21870 0 0 {name=X_76265_ }
C {devices/lab_pin.sym} 137820 -21730 0 0 {name=p136954 lab=_42657_/A }
C {devices/lab_pin.sym} 137900 -21730 0 1 {name=p136955 lab=_42657_/Y }
C {sky130_stdcells/inv_2.sym} 137860 -21730 0 0 {name=X_42657_ }
C {devices/lab_pin.sym} 137780 -21640 0 0 {name=p136956 lab=_73359_/X }
C {devices/lab_pin.sym} 137780 -21600 0 0 {name=p136957 lab=_83053_/Q }
C {devices/lab_pin.sym} 137780 -21560 0 0 {name=p136958 lab=_73406_/X }
C {devices/lab_pin.sym} 137780 -21520 0 0 {name=p136959 lab=_73476_/X }
C {devices/lab_pin.sym} 137940 -21580 0 1 {name=p136960 lab=_73477_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -21580 0 0 {name=X_73477_ }
C {devices/lab_pin.sym} 137800 -21450 0 0 {name=p136961 lab=_61482_/A }
C {devices/lab_pin.sym} 137800 -21410 0 0 {name=p136962 lab=_61490_/X }
C {devices/lab_pin.sym} 137800 -21370 0 0 {name=p136963 lab=_61482_/C }
C {devices/lab_pin.sym} 137920 -21410 0 1 {name=p136964 lab=_61491_/Y }
C {sky130_stdcells/nand3_4.sym} 137860 -21410 0 0 {name=X_61491_ }
C {devices/lab_pin.sym} 137800 -21290 0 0 {name=p136965 lab=_70689_/A }
C {devices/lab_pin.sym} 137800 -21250 0 0 {name=p136966 lab=_70692_/B }
C {devices/lab_pin.sym} 137800 -21210 0 0 {name=p136967 lab=_70692_/C }
C {devices/lab_pin.sym} 137920 -21250 0 1 {name=p136968 lab=_70689_/Y }
C {sky130_stdcells/nor3_4.sym} 137860 -21250 0 0 {name=X_70689_ }
C {devices/lab_pin.sym} 137820 -21110 0 0 {name=p136969 lab=clkbuf_9_183_0_CLK/X }
C {devices/lab_pin.sym} 137900 -21110 0 1 {name=p136970 lab=_85700_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 137860 -21110 0 0 {name=Xclkbuf_10_367_0_CLK }
C {devices/lab_pin.sym} 137820 -20990 0 0 {name=p136971 lab=_78006_/B }
C {devices/lab_pin.sym} 137900 -20990 0 1 {name=p136972 lab=_78004_/Y }
C {sky130_stdcells/inv_2.sym} 137860 -20990 0 0 {name=X_78004_ }
C {devices/lab_pin.sym} 137820 -20870 0 0 {name=p136973 lab=_75216_/A }
C {devices/lab_pin.sym} 137900 -20870 0 1 {name=p136974 lab=_75216_/Y }
C {sky130_stdcells/inv_2.sym} 137860 -20870 0 0 {name=X_75216_ }
C {devices/lab_pin.sym} 137800 -20780 0 0 {name=p136975 lab=_63230_/A }
C {devices/lab_pin.sym} 137800 -20740 0 0 {name=p136976 lab=_63316_/B }
C {devices/lab_pin.sym} 137800 -20700 0 0 {name=p136977 lab=_63295_/C }
C {devices/lab_pin.sym} 137800 -20660 0 0 {name=p136978 lab=_63267_/D }
C {devices/lab_pin.sym} 137920 -20720 0 1 {name=p136979 lab=_63230_/X }
C {sky130_stdcells/or4_4.sym} 137860 -20720 0 0 {name=X_63230_ }
C {devices/lab_pin.sym} 137820 -20570 0 0 {name=p136980 lab=_41607_/X }
C {devices/lab_pin.sym} 137900 -20570 0 1 {name=p136981 lab=_41608_/X }
C {sky130_stdcells/buf_2.sym} 137860 -20570 0 0 {name=X_41608_ }
C {devices/lab_pin.sym} 137800 -20470 0 0 {name=p136982 lab=_48164_/A }
C {devices/lab_pin.sym} 137800 -20430 0 0 {name=p136983 lab=_57489_/B }
C {devices/lab_pin.sym} 137800 -20390 0 0 {name=p136984 lab=_48163_/X }
C {devices/lab_pin.sym} 137920 -20430 0 1 {name=p136985 lab=_48164_/Y }
C {sky130_stdcells/nand3_4.sym} 137860 -20430 0 0 {name=X_48164_ }
C {devices/lab_pin.sym} 137800 -20310 0 0 {name=p136986 lab=_60399_/B }
C {devices/lab_pin.sym} 137800 -20270 0 0 {name=p136987 lab=_60583_/A }
C {devices/lab_pin.sym} 137800 -20230 0 0 {name=p136988 lab=_60442_/C }
C {devices/lab_pin.sym} 137920 -20270 0 1 {name=p136989 lab=_60445_/A }
C {sky130_stdcells/nor3_4.sym} 137860 -20270 0 0 {name=X_60442_ }
C {devices/lab_pin.sym} 137800 -20140 0 0 {name=p136990 lab=_72428_/A }
C {devices/lab_pin.sym} 137800 -20100 0 0 {name=p136991 lab=_72428_/B }
C {devices/lab_pin.sym} 137920 -20120 0 1 {name=p136992 lab=_72428_/Y }
C {sky130_stdcells/nor2_4.sym} 137860 -20120 0 0 {name=X_72428_ }
C {devices/lab_pin.sym} 137780 -20010 0 0 {name=p136993 lab=_56458_/C }
C {devices/lab_pin.sym} 137780 -19970 0 0 {name=p136994 lab=_45326_/X }
C {devices/lab_pin.sym} 137780 -19930 0 0 {name=p136995 lab=_45375_/X }
C {devices/lab_pin.sym} 137940 -19970 0 1 {name=p136996 lab=_45376_/Y }
C {sky130_stdcells/o21ai_4.sym} 137860 -19970 0 0 {name=X_45376_ }
C {devices/lab_pin.sym} 137800 -19850 0 0 {name=p136997 lab=_76194_/Y }
C {devices/lab_pin.sym} 137800 -19810 0 0 {name=p136998 lab=_76196_/B }
C {devices/lab_pin.sym} 137800 -19770 0 0 {name=p136999 lab=_76192_/X }
C {devices/lab_pin.sym} 137920 -19810 0 1 {name=p137000 lab=_76196_/Y }
C {sky130_stdcells/nand3_4.sym} 137860 -19810 0 0 {name=X_76196_ }
C {devices/lab_pin.sym} 137820 -19670 0 0 {name=p137001 lab=clkbuf_9_498_0_CLK/X }
C {devices/lab_pin.sym} 137900 -19670 0 1 {name=p137002 lab=_85884_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 137860 -19670 0 0 {name=Xclkbuf_10_997_0_CLK }
C {devices/lab_pin.sym} 137820 -19550 0 0 {name=p137003 lab=_42588_/A }
C {devices/lab_pin.sym} 137900 -19550 0 1 {name=p137004 lab=_42588_/Y }
C {sky130_stdcells/inv_2.sym} 137860 -19550 0 0 {name=X_42588_ }
C {devices/lab_pin.sym} 137820 -19430 0 0 {name=p137005 lab=_47115_/A }
C {devices/lab_pin.sym} 137900 -19430 0 1 {name=p137006 lab=_47116_/A }
C {sky130_stdcells/inv_2.sym} 137860 -19430 0 0 {name=X_47115_ }
C {devices/lab_pin.sym} 137820 -19310 0 0 {name=p137007 lab=_40509_/X }
C {devices/lab_pin.sym} 137900 -19310 0 1 {name=p137008 lab=_44327_/X }
C {sky130_stdcells/buf_2.sym} 137860 -19310 0 0 {name=X_44327_ }
C {devices/lab_pin.sym} 137800 -19220 0 0 {name=p137009 lab=_63161_/A }
C {devices/lab_pin.sym} 137800 -19180 0 0 {name=p137010 lab=_63113_/B }
C {devices/lab_pin.sym} 137800 -19140 0 0 {name=p137011 lab=_63161_/C }
C {devices/lab_pin.sym} 137800 -19100 0 0 {name=p137012 lab=_63149_/X }
C {devices/lab_pin.sym} 137920 -19160 0 1 {name=p137013 lab=_63161_/X }
C {sky130_stdcells/or4_4.sym} 137860 -19160 0 0 {name=X_63161_ }
C {devices/lab_pin.sym} 137800 -19020 0 0 {name=p137014 lab=_75144_/Y }
C {devices/lab_pin.sym} 137800 -18980 0 0 {name=p137015 lab=_75146_/Y }
C {devices/lab_pin.sym} 137920 -19000 0 1 {name=p137016 lab=_75147_/Y }
C {sky130_stdcells/nor2_4.sym} 137860 -19000 0 0 {name=X_75147_ }
C {devices/lab_pin.sym} 137820 -18870 0 0 {name=p137017 lab=_41538_/Y }
C {devices/lab_pin.sym} 137900 -18870 0 1 {name=p137018 lab=_41539_/Y }
C {sky130_stdcells/inv_2.sym} 137860 -18870 0 0 {name=X_41539_ }
C {devices/lab_pin.sym} 137780 -18780 0 0 {name=p137019 lab=_79538_/A }
C {devices/lab_pin.sym} 137780 -18740 0 0 {name=p137020 lab=_60323_/X }
C {devices/lab_pin.sym} 137780 -18700 0 0 {name=p137021 lab=_60372_/Y }
C {devices/lab_pin.sym} 137780 -18660 0 0 {name=p137022 lab=_60337_/Y }
C {devices/lab_pin.sym} 137940 -18720 0 1 {name=p137023 lab=_60373_/X }
C {sky130_stdcells/o22a_4.sym} 137860 -18720 0 0 {name=X_60373_ }
C {devices/lab_pin.sym} 137780 -18590 0 0 {name=p137024 lab=_72287_/X }
C {devices/lab_pin.sym} 137780 -18550 0 0 {name=p137025 lab=_85325_/Q }
C {devices/lab_pin.sym} 137780 -18510 0 0 {name=p137026 lab=_72324_/X }
C {devices/lab_pin.sym} 137940 -18550 0 1 {name=p137027 lab=_72359_/X }
C {sky130_stdcells/o21a_4.sym} 137860 -18550 0 0 {name=X_72359_ }
C {devices/lab_pin.sym} 137820 -18410 0 0 {name=p137028 lab=_48461_/A }
C {devices/lab_pin.sym} 137900 -18410 0 1 {name=p137029 lab=_48449_/B }
C {sky130_stdcells/buf_2.sym} 137860 -18410 0 0 {name=X_48095_ }
C {devices/lab_pin.sym} 137820 -18290 0 0 {name=p137030 lab=clkbuf_9_489_0_CLK/A }
C {devices/lab_pin.sym} 137900 -18290 0 1 {name=p137031 lab=clkbuf_9_488_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 137860 -18290 0 0 {name=Xclkbuf_9_488_0_CLK }
C {devices/lab_pin.sym} 137800 -18200 0 0 {name=p137032 lab=_61627_/B }
C {devices/lab_pin.sym} 137800 -18160 0 0 {name=p137033 lab=_62161_/B }
C {devices/lab_pin.sym} 137800 -18120 0 0 {name=p137034 lab=_62128_/C }
C {devices/lab_pin.sym} 137800 -18080 0 0 {name=p137035 lab=_62011_/X }
C {devices/lab_pin.sym} 137920 -18140 0 1 {name=p137036 lab=_62112_/Y }
C {sky130_stdcells/nand4_4.sym} 137860 -18140 0 0 {name=X_62112_ }
C {devices/lab_pin.sym} 137820 -17990 0 0 {name=p137037 lab=_47046_/A }
C {devices/lab_pin.sym} 137900 -17990 0 1 {name=p137038 lab=_47047_/A }
C {sky130_stdcells/inv_2.sym} 137860 -17990 0 0 {name=X_47046_ }
C {devices/lab_pin.sym} 137800 -17880 0 0 {name=p137039 lab=_44258_/A }
C {devices/lab_pin.sym} 137800 -17840 0 0 {name=p137040 lab=_44256_/A }
C {devices/lab_pin.sym} 137920 -17860 0 1 {name=p137041 lab=_44258_/Y }
C {sky130_stdcells/nor2_4.sym} 137860 -17860 0 0 {name=X_44258_ }
C {devices/lab_pin.sym} 137800 -17740 0 0 {name=p137042 lab=_79957_/B }
C {devices/lab_pin.sym} 137800 -17700 0 0 {name=p137043 lab=_79957_/C }
C {devices/lab_pin.sym} 137920 -17720 0 1 {name=p137044 lab=_79955_/Y }
C {sky130_stdcells/nand2_4.sym} 137860 -17720 0 0 {name=X_79955_ }
C {devices/lab_pin.sym} 137800 -17620 0 0 {name=p137045 lab=_58177_/Y }
C {devices/lab_pin.sym} 137800 -17580 0 0 {name=p137046 lab=_63081_/B }
C {devices/lab_pin.sym} 137800 -17540 0 0 {name=p137047 lab=_63081_/C }
C {devices/lab_pin.sym} 137800 -17500 0 0 {name=p137048 lab=_63092_/D }
C {devices/lab_pin.sym} 137920 -17560 0 1 {name=p137049 lab=_63092_/X }
C {sky130_stdcells/or4_4.sym} 137860 -17560 0 0 {name=X_63092_ }
C {devices/lab_pin.sym} 137800 -17420 0 0 {name=p137050 lab=_75075_/Y }
C {devices/lab_pin.sym} 137800 -17380 0 0 {name=p137051 lab=_75077_/Y }
C {devices/lab_pin.sym} 137920 -17400 0 1 {name=p137052 lab=_75078_/Y }
C {sky130_stdcells/nor2_4.sym} 137860 -17400 0 0 {name=X_75078_ }
C {devices/lab_pin.sym} 137820 -17270 0 0 {name=p137053 lab=clkbuf_9_460_0_CLK/X }
C {devices/lab_pin.sym} 137900 -17270 0 1 {name=p137054 lab=_87068_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 137860 -17270 0 0 {name=Xclkbuf_10_920_0_CLK }
C {devices/lab_pin.sym} 137820 -17150 0 0 {name=p137055 lab=_43209_/A }
C {devices/lab_pin.sym} 137900 -17150 0 1 {name=p137056 lab=_43209_/Y }
C {sky130_stdcells/inv_2.sym} 137860 -17150 0 0 {name=X_43209_ }
C {devices/lab_pin.sym} 137800 -17040 0 0 {name=p137057 lab=_66823_/A }
C {devices/lab_pin.sym} 137800 -17000 0 0 {name=p137058 lab=_66920_/B }
C {devices/lab_pin.sym} 137920 -17020 0 1 {name=p137059 lab=_66920_/X }
C {sky130_stdcells/and2_4.sym} 137860 -17020 0 0 {name=X_66920_ }
C {devices/lab_pin.sym} 137800 -16920 0 0 {name=p137060 lab=_61568_/B }
C {devices/lab_pin.sym} 137800 -16880 0 0 {name=p137061 lab=_61995_/X }
C {devices/lab_pin.sym} 137800 -16840 0 0 {name=p137062 lab=_62010_/X }
C {devices/lab_pin.sym} 137800 -16800 0 0 {name=p137063 lab=_62011_/X }
C {devices/lab_pin.sym} 137920 -16860 0 1 {name=p137064 lab=_62047_/C }
C {sky130_stdcells/nand4_4.sym} 137860 -16860 0 0 {name=X_62043_ }
C {devices/lab_pin.sym} 137780 -16730 0 0 {name=p137065 lab=_74027_/X }
C {devices/lab_pin.sym} 137780 -16690 0 0 {name=p137066 lab=_74028_/Y }
C {devices/lab_pin.sym} 137780 -16650 0 0 {name=p137067 lab=_73982_/X }
C {devices/lab_pin.sym} 137940 -16690 0 1 {name=p137068 lab=_74029_/X }
C {sky130_stdcells/a21o_4.sym} 137860 -16690 0 0 {name=X_74029_ }
C {devices/lab_pin.sym} 137780 -16570 0 0 {name=p137069 lab=_78894_/Y }
C {devices/lab_pin.sym} 137780 -16530 0 0 {name=p137070 lab=_78898_/Y }
C {devices/lab_pin.sym} 137780 -16490 0 0 {name=p137071 lab=_78900_/A }
C {devices/lab_pin.sym} 137940 -16530 0 1 {name=p137072 lab=_78906_/Y }
C {sky130_stdcells/a21boi_4.sym} 137860 -16530 0 0 {name=X_78906_ }
C {devices/lab_pin.sym} 137820 -16390 0 0 {name=p137073 lab=_72806_/A }
C {devices/lab_pin.sym} 137900 -16390 0 1 {name=p137074 lab=_44189_/X }
C {sky130_stdcells/buf_2.sym} 137860 -16390 0 0 {name=X_44189_ }
C {devices/lab_pin.sym} 137780 -16290 0 0 {name=p137075 lab=_79871_/X }
C {devices/lab_pin.sym} 137780 -16250 0 0 {name=p137076 lab=_79873_/B }
C {devices/lab_pin.sym} 137780 -16210 0 0 {name=p137077 lab=_79885_/Y }
C {devices/lab_pin.sym} 137940 -16250 0 1 {name=p137078 lab=_79886_/Y }
C {sky130_stdcells/a21boi_4.sym} 137860 -16250 0 0 {name=X_79886_ }
C {devices/lab_pin.sym} 137820 -16110 0 0 {name=p137079 lab=clkbuf_9_411_0_CLK/A }
C {devices/lab_pin.sym} 137900 -16110 0 1 {name=p137080 lab=clkbuf_9_411_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 137860 -16110 0 0 {name=Xclkbuf_9_411_0_CLK }
C {devices/lab_pin.sym} 137820 -15990 0 0 {name=p137081 lab=_66534_/A }
C {devices/lab_pin.sym} 137900 -15990 0 1 {name=p137082 lab=_66851_/X }
C {sky130_stdcells/buf_2.sym} 137860 -15990 0 0 {name=X_66851_ }
C {devices/lab_pin.sym} 137800 -15880 0 0 {name=p137083 lab=_78834_/X }
C {devices/lab_pin.sym} 137800 -15840 0 0 {name=p137084 lab=_78837_/B }
C {devices/lab_pin.sym} 137920 -15860 0 1 {name=p137085 lab=_78838_/B }
C {sky130_stdcells/xor2_4.sym} 137860 -15860 0 0 {name=X_78837_ }
C {devices/lab_pin.sym} 137780 -15750 0 0 {name=p137086 lab=_48946_/X }
C {devices/lab_pin.sym} 137780 -15710 0 0 {name=p137087 lab=_48485_/A }
C {devices/lab_pin.sym} 137780 -15670 0 0 {name=p137088 lab=_48996_/Y }
C {devices/lab_pin.sym} 137940 -15710 0 1 {name=p137089 lab=_48998_/A }
C {sky130_stdcells/a21o_4.sym} 137860 -15710 0 0 {name=X_48997_ }
C {devices/lab_pin.sym} 137820 -15570 0 0 {name=p137090 lab=clkbuf_9_152_0_CLK/X }
C {devices/lab_pin.sym} 137900 -15570 0 1 {name=p137091 lab=_83362_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 137860 -15570 0 0 {name=Xclkbuf_10_305_0_CLK }
C {devices/lab_pin.sym} 137800 -15470 0 0 {name=p137092 lab=_65888_/A }
C {devices/lab_pin.sym} 137800 -15430 0 0 {name=p137093 lab=_65802_/B }
C {devices/lab_pin.sym} 137800 -15390 0 0 {name=p137094 lab=_65802_/C }
C {devices/lab_pin.sym} 137920 -15430 0 1 {name=p137095 lab=_65802_/Y }
C {sky130_stdcells/nor3_4.sym} 137860 -15430 0 0 {name=X_65802_ }
C {devices/lab_pin.sym} 137820 -15290 0 0 {name=p137096 lab=_66547_/A }
C {devices/lab_pin.sym} 137900 -15290 0 1 {name=p137097 lab=_69570_/X }
C {sky130_stdcells/buf_2.sym} 137860 -15290 0 0 {name=X_69570_ }
C {devices/lab_pin.sym} 137820 -15170 0 0 {name=p137098 lab=_47840_/A }
C {devices/lab_pin.sym} 137900 -15170 0 1 {name=p137099 lab=_47948_/X }
C {sky130_stdcells/buf_2.sym} 137860 -15170 0 0 {name=X_47948_ }
C {devices/lab_pin.sym} 137800 -15060 0 0 {name=p137100 lab=_66760_/A }
C {devices/lab_pin.sym} 137800 -15020 0 0 {name=p137101 lab=_87690_/Q }
C {devices/lab_pin.sym} 137920 -15040 0 1 {name=p137102 lab=_66782_/X }
C {sky130_stdcells/and2_4.sym} 137860 -15040 0 0 {name=X_66782_ }
C {devices/lab_pin.sym} 137820 -14910 0 0 {name=p137103 lab=_78767_/Y }
C {devices/lab_pin.sym} 137900 -14910 0 1 {name=p137104 lab=_78769_/B }
C {sky130_stdcells/inv_2.sym} 137860 -14910 0 0 {name=X_78768_ }
C {devices/lab_pin.sym} 137820 -14790 0 0 {name=p137105 lab=_63912_/X }
C {devices/lab_pin.sym} 137900 -14790 0 1 {name=p137106 lab=_63994_/X }
C {sky130_stdcells/buf_2.sym} 137860 -14790 0 0 {name=X_63994_ }
C {devices/lab_pin.sym} 137820 -14670 0 0 {name=p137107 lab=clkbuf_9_467_0_CLK/X }
C {devices/lab_pin.sym} 137900 -14670 0 1 {name=p137108 lab=_87285_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 137860 -14670 0 0 {name=Xclkbuf_10_935_0_CLK }
C {devices/lab_pin.sym} 137780 -14580 0 0 {name=p137109 lab=_88109_/Q }
C {devices/lab_pin.sym} 137780 -14540 0 0 {name=p137110 lab=_68069_/X }
C {devices/lab_pin.sym} 137780 -14500 0 0 {name=p137111 lab=_68439_/X }
C {devices/lab_pin.sym} 137780 -14460 0 0 {name=p137112 lab=_68520_/Y }
C {devices/lab_pin.sym} 137940 -14520 0 1 {name=p137113 lab=_68521_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -14520 0 0 {name=X_68521_ }
C {devices/lab_pin.sym} 137820 -14370 0 0 {name=p137114 lab=_64828_/A }
C {devices/lab_pin.sym} 137900 -14370 0 1 {name=p137115 lab=_65733_/X }
C {sky130_stdcells/buf_2.sym} 137860 -14370 0 0 {name=X_65733_ }
C {devices/lab_pin.sym} 137800 -14270 0 0 {name=p137116 lab=_77710_/A }
C {devices/lab_pin.sym} 137800 -14230 0 0 {name=p137117 lab=_77709_/X }
C {devices/lab_pin.sym} 137800 -14190 0 0 {name=p137118 lab=_77717_/A }
C {devices/lab_pin.sym} 137920 -14230 0 1 {name=p137119 lab=_77723_/C }
C {sky130_stdcells/nand3_4.sym} 137860 -14230 0 0 {name=X_77719_ }
C {devices/lab_pin.sym} 137800 -14100 0 0 {name=p137120 lab=_58287_/Y }
C {devices/lab_pin.sym} 137800 -14060 0 0 {name=p137121 lab=_60337_/C }
C {devices/lab_pin.sym} 137920 -14080 0 1 {name=p137122 lab=_62945_/Y }
C {sky130_stdcells/nor2_4.sym} 137860 -14080 0 0 {name=X_62945_ }
C {devices/lab_pin.sym} 137780 -13970 0 0 {name=p137123 lab=_47866_/Y }
C {devices/lab_pin.sym} 137780 -13930 0 0 {name=p137124 lab=_47846_/X }
C {devices/lab_pin.sym} 137780 -13890 0 0 {name=p137125 lab=_47878_/X }
C {devices/lab_pin.sym} 137940 -13930 0 1 {name=p137126 lab=_86590_/D }
C {sky130_stdcells/a21oi_4.sym} 137860 -13930 0 0 {name=X_47879_ }
C {devices/lab_pin.sym} 137800 -13800 0 0 {name=p137127 lab=_78697_/X }
C {devices/lab_pin.sym} 137800 -13760 0 0 {name=p137128 lab=_78722_/A }
C {devices/lab_pin.sym} 137920 -13780 0 1 {name=p137129 lab=_78700_/A }
C {sky130_stdcells/and2_4.sym} 137860 -13780 0 0 {name=X_78699_ }
C {devices/lab_pin.sym} 137820 -13650 0 0 {name=p137130 lab=clkbuf_9_427_0_CLK/A }
C {devices/lab_pin.sym} 137900 -13650 0 1 {name=p137131 lab=clkbuf_9_426_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 137860 -13650 0 0 {name=Xclkbuf_9_426_0_CLK }
C {devices/lab_pin.sym} 137780 -13550 0 0 {name=p137132 lab=_86354_/Q }
C {devices/lab_pin.sym} 137780 -13510 0 0 {name=p137133 lab=_49606_/X }
C {devices/lab_pin.sym} 137780 -13470 0 0 {name=p137134 lab=_49617_/Y }
C {devices/lab_pin.sym} 137940 -13510 0 1 {name=p137135 lab=_49618_/Y }
C {sky130_stdcells/o21ai_4.sym} 137860 -13510 0 0 {name=X_49618_ }
C {devices/lab_pin.sym} 137800 -13380 0 0 {name=p137136 lab=_68452_/A }
C {devices/lab_pin.sym} 137800 -13340 0 0 {name=p137137 lab=_87248_/Q }
C {devices/lab_pin.sym} 137920 -13360 0 1 {name=p137138 lab=_68452_/X }
C {sky130_stdcells/and2_4.sym} 137860 -13360 0 0 {name=X_68452_ }
C {devices/lab_pin.sym} 137770 -13230 0 0 {name=p137139 lab=_81048_/CLK }
C {devices/lab_pin.sym} 137770 -13210 0 0 {name=p137140 lab=_75916_/X }
C {devices/lab_pin.sym} 137950 -13230 0 1 {name=p137141 lab=_80730_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -13220 0 0 {name=X_80730_ }
C {devices/lab_pin.sym} 137800 -13100 0 0 {name=p137142 lab=_65664_/A }
C {devices/lab_pin.sym} 137800 -13060 0 0 {name=p137143 lab=_65663_/Y }
C {devices/lab_pin.sym} 137920 -13080 0 1 {name=p137144 lab=_65664_/Y }
C {sky130_stdcells/nand2_4.sym} 137860 -13080 0 0 {name=X_65664_ }
C {devices/lab_pin.sym} 137820 -12950 0 0 {name=p137145 lab=_50918_/A }
C {devices/lab_pin.sym} 137900 -12950 0 1 {name=p137146 lab=_50908_/A }
C {sky130_stdcells/buf_2.sym} 137860 -12950 0 0 {name=X_50890_ }
C {devices/lab_pin.sym} 137800 -12860 0 0 {name=p137147 lab=_58483_/A }
C {devices/lab_pin.sym} 137800 -12820 0 0 {name=p137148 lab=_62841_/X }
C {devices/lab_pin.sym} 137800 -12780 0 0 {name=p137149 lab=_60309_/C }
C {devices/lab_pin.sym} 137800 -12740 0 0 {name=p137150 lab=_60202_/A }
C {devices/lab_pin.sym} 137920 -12800 0 1 {name=p137151 lab=_62876_/Y }
C {sky130_stdcells/nand4_4.sym} 137860 -12800 0 0 {name=X_62876_ }
C {devices/lab_pin.sym} 137780 -12680 0 0 {name=p137152 lab=_67305_/X }
C {devices/lab_pin.sym} 137780 -12640 0 0 {name=p137153 lab=_67387_/Y }
C {devices/lab_pin.sym} 137780 -12600 0 0 {name=p137154 lab=_67390_/X }
C {devices/lab_pin.sym} 137780 -12560 0 0 {name=p137155 lab=_67402_/Y }
C {devices/lab_pin.sym} 137940 -12620 0 1 {name=p137156 lab=_67403_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -12620 0 0 {name=X_67403_ }
C {devices/lab_pin.sym} 137820 -12470 0 0 {name=p137157 lab=_64615_/A }
C {devices/lab_pin.sym} 137900 -12470 0 1 {name=p137158 lab=_64615_/X }
C {sky130_stdcells/buf_2.sym} 137860 -12470 0 0 {name=X_64615_ }
C {devices/lab_pin.sym} 137800 -12380 0 0 {name=p137159 lab=_49561_/A }
C {devices/lab_pin.sym} 137800 -12340 0 0 {name=p137160 lab=_49537_/B }
C {devices/lab_pin.sym} 137800 -12300 0 0 {name=p137161 lab=_49548_/X }
C {devices/lab_pin.sym} 137800 -12260 0 0 {name=p137162 lab=_52763_/D }
C {devices/lab_pin.sym} 137920 -12320 0 1 {name=p137163 lab=_49549_/X }
C {sky130_stdcells/and4_4.sym} 137860 -12320 0 0 {name=X_49549_ }
C {devices/lab_pin.sym} 137800 -12200 0 0 {name=p137164 lab=_61839_/A }
C {devices/lab_pin.sym} 137800 -12160 0 0 {name=p137165 lab=_61839_/B }
C {devices/lab_pin.sym} 137800 -12120 0 0 {name=p137166 lab=_61839_/C }
C {devices/lab_pin.sym} 137800 -12080 0 0 {name=p137167 lab=_63079_/B }
C {devices/lab_pin.sym} 137920 -12140 0 1 {name=p137168 lab=_61827_/X }
C {sky130_stdcells/and4_4.sym} 137860 -12140 0 0 {name=X_61827_ }
C {devices/lab_pin.sym} 137770 -11990 0 0 {name=p137169 lab=_80657_/CLK }
C {devices/lab_pin.sym} 137770 -11970 0 0 {name=p137170 lab=_80661_/D }
C {devices/lab_pin.sym} 137950 -11990 0 1 {name=p137171 lab=_46087_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -11980 0 0 {name=X_80661_ }
C {devices/lab_pin.sym} 137820 -11850 0 0 {name=p137172 lab=_45924_/A }
C {devices/lab_pin.sym} 137900 -11850 0 1 {name=p137173 lab=_68384_/A }
C {sky130_stdcells/buf_2.sym} 137860 -11850 0 0 {name=X_68383_ }
C {devices/lab_pin.sym} 137820 -11730 0 0 {name=p137174 lab=_64666_/A }
C {devices/lab_pin.sym} 137900 -11730 0 1 {name=p137175 lab=_65595_/X }
C {sky130_stdcells/buf_2.sym} 137860 -11730 0 0 {name=X_65595_ }
C {devices/lab_pin.sym} 137770 -11610 0 0 {name=p137176 lab=_82965_/CLK }
C {devices/lab_pin.sym} 137770 -11590 0 0 {name=p137177 lab=_82208_/Q }
C {devices/lab_pin.sym} 137950 -11610 0 1 {name=p137178 lab=_82400_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -11600 0 0 {name=X_82400_ }
C {devices/lab_pin.sym} 137780 -11500 0 0 {name=p137179 lab=_87987_/Q }
C {devices/lab_pin.sym} 137780 -11460 0 0 {name=p137180 lab=_67236_/X }
C {devices/lab_pin.sym} 137780 -11420 0 0 {name=p137181 lab=_67284_/X }
C {devices/lab_pin.sym} 137780 -11380 0 0 {name=p137182 lab=_67333_/X }
C {devices/lab_pin.sym} 137940 -11440 0 1 {name=p137183 lab=_67334_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -11440 0 0 {name=X_67334_ }
C {devices/lab_pin.sym} 137780 -11310 0 0 {name=p137184 lab=_65335_/B }
C {devices/lab_pin.sym} 137780 -11270 0 0 {name=p137185 lab=_52549_/X }
C {devices/lab_pin.sym} 137780 -11230 0 0 {name=p137186 lab=_52559_/Y }
C {devices/lab_pin.sym} 137940 -11270 0 1 {name=p137187 lab=_52560_/Y }
C {sky130_stdcells/o21ai_4.sym} 137860 -11270 0 0 {name=X_52560_ }
C {devices/lab_pin.sym} 137800 -11150 0 0 {name=p137188 lab=_64546_/A }
C {devices/lab_pin.sym} 137800 -11110 0 0 {name=p137189 lab=_64225_/B }
C {devices/lab_pin.sym} 137800 -11070 0 0 {name=p137190 lab=_64546_/C }
C {devices/lab_pin.sym} 137920 -11110 0 1 {name=p137191 lab=_64546_/X }
C {sky130_stdcells/and3_4.sym} 137860 -11110 0 0 {name=X_64546_ }
C {devices/lab_pin.sym} 137770 -10970 0 0 {name=p137192 lab=_83380_/CLK }
C {devices/lab_pin.sym} 137770 -10950 0 0 {name=p137193 lab=_71776_/X }
C {devices/lab_pin.sym} 137950 -10970 0 1 {name=p137194 lab=_83380_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -10960 0 0 {name=X_83380_ }
C {devices/lab_pin.sym} 137780 -10870 0 0 {name=p137195 lab=_58225_/X }
C {devices/lab_pin.sym} 137780 -10830 0 0 {name=p137196 lab=_61728_/X }
C {devices/lab_pin.sym} 137780 -10790 0 0 {name=p137197 lab=_61756_/X }
C {devices/lab_pin.sym} 137780 -10750 0 0 {name=p137198 lab=_59591_/A }
C {devices/lab_pin.sym} 137780 -10720 0 0 {name=p137199 lab=_61757_/X }
C {devices/lab_pin.sym} 137940 -10790 0 1 {name=p137200 lab=_61758_/X }
C {sky130_stdcells/a41o_4.sym} 137860 -10790 0 0 {name=X_61758_ }
C {devices/lab_pin.sym} 137820 -10630 0 0 {name=p137201 lab=_80581_/X }
C {devices/lab_pin.sym} 137900 -10630 0 1 {name=p137202 lab=_80592_/Y }
C {sky130_stdcells/inv_2.sym} 137860 -10630 0 0 {name=X_80592_ }
C {sky130_stdcells/decap_3.sym} 137860 -10480 0 0 {name=XPHY_409 }
C {devices/lab_pin.sym} 137820 -10330 0 0 {name=p137203 lab=_51539_/A }
C {devices/lab_pin.sym} 137900 -10330 0 1 {name=p137204 lab=_51511_/X }
C {sky130_stdcells/buf_2.sym} 137860 -10330 0 0 {name=X_51511_ }
C {devices/lab_pin.sym} 137770 -10210 0 0 {name=p137205 lab=_87086_/CLK }
C {devices/lab_pin.sym} 137770 -10190 0 0 {name=p137206 lab=_77182_/B }
C {devices/lab_pin.sym} 137950 -10210 0 1 {name=p137207 lab=_82331_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -10200 0 0 {name=X_82331_ }
C {devices/lab_pin.sym} 137780 -10090 0 0 {name=p137208 lab=_60694_/B }
C {devices/lab_pin.sym} 137780 -10050 0 0 {name=p137209 lab=_60696_/Y }
C {devices/lab_pin.sym} 137780 -10010 0 0 {name=p137210 lab=_60708_/Y }
C {devices/lab_pin.sym} 137940 -10050 0 1 {name=p137211 lab=_60709_/X }
C {sky130_stdcells/o21a_4.sym} 137860 -10050 0 0 {name=X_60709_ }
C {devices/lab_pin.sym} 137780 -9930 0 0 {name=p137212 lab=_67260_/X }
C {devices/lab_pin.sym} 137780 -9890 0 0 {name=p137213 lab=_67263_/X }
C {devices/lab_pin.sym} 137780 -9850 0 0 {name=p137214 lab=_67264_/X }
C {devices/lab_pin.sym} 137940 -9890 0 1 {name=p137215 lab=_67268_/A }
C {sky130_stdcells/a21o_4.sym} 137860 -9890 0 0 {name=X_67265_ }
C {devices/lab_pin.sym} 137780 -9770 0 0 {name=p137216 lab=_64974_/B }
C {devices/lab_pin.sym} 137780 -9730 0 0 {name=p137217 lab=_52470_/X }
C {devices/lab_pin.sym} 137780 -9690 0 0 {name=p137218 lab=_52490_/Y }
C {devices/lab_pin.sym} 137940 -9730 0 1 {name=p137219 lab=_52491_/Y }
C {sky130_stdcells/o21ai_4.sym} 137860 -9730 0 0 {name=X_52491_ }
C {devices/lab_pin.sym} 137800 -9620 0 0 {name=p137220 lab=_61238_/C }
C {devices/lab_pin.sym} 137800 -9580 0 0 {name=p137221 lab=_64457_/C }
C {devices/lab_pin.sym} 137800 -9540 0 0 {name=p137222 lab=_64475_/Y }
C {devices/lab_pin.sym} 137800 -9500 0 0 {name=p137223 lab=_64477_/D }
C {devices/lab_pin.sym} 137920 -9560 0 1 {name=p137224 lab=_64477_/Y }
C {sky130_stdcells/nand4_4.sym} 137860 -9560 0 0 {name=X_64477_ }
C {devices/lab_pin.sym} 137780 -9450 0 0 {name=p137225 lab=_61682_/Y }
C {devices/lab_pin.sym} 137780 -9410 0 0 {name=p137226 lab=_61684_/Y }
C {devices/lab_pin.sym} 137780 -9370 0 0 {name=p137227 lab=_61334_/A }
C {devices/lab_pin.sym} 137780 -9330 0 0 {name=p137228 lab=_61685_/Y }
C {devices/lab_pin.sym} 137780 -9300 0 0 {name=p137229 lab=_61688_/Y }
C {devices/lab_pin.sym} 137940 -9370 0 1 {name=p137230 lab=_61689_/X }
C {sky130_stdcells/a41o_4.sym} 137860 -9370 0 0 {name=X_61689_ }
C {devices/lab_pin.sym} 137800 -9220 0 0 {name=p137231 lab=_69004_/A }
C {devices/lab_pin.sym} 137800 -9180 0 0 {name=p137232 lab=_69004_/B }
C {devices/lab_pin.sym} 137920 -9200 0 1 {name=p137233 lab=_69004_/X }
C {sky130_stdcells/and2_4.sym} 137860 -9200 0 0 {name=X_69004_ }
C {devices/lab_pin.sym} 137800 -9080 0 0 {name=p137234 lab=_54230_/A }
C {devices/lab_pin.sym} 137800 -9040 0 0 {name=p137235 lab=_53060_/B }
C {devices/lab_pin.sym} 137920 -9060 0 1 {name=p137236 lab=_54230_/Y }
C {sky130_stdcells/nand2_4.sym} 137860 -9060 0 0 {name=X_54230_ }
C {devices/lab_pin.sym} 137800 -8950 0 0 {name=p137237 lab=_66216_/A }
C {devices/lab_pin.sym} 137800 -8910 0 0 {name=p137238 lab=_64633_/B }
C {devices/lab_pin.sym} 137800 -8870 0 0 {name=p137239 lab=_66216_/C }
C {devices/lab_pin.sym} 137920 -8910 0 1 {name=p137240 lab=_66216_/Y }
C {sky130_stdcells/nand3_4.sym} 137860 -8910 0 0 {name=X_66216_ }
C {devices/lab_pin.sym} 137770 -8770 0 0 {name=p137241 lab=_85050_/CLK }
C {devices/lab_pin.sym} 137770 -8750 0 0 {name=p137242 lab=_85050_/D }
C {devices/lab_pin.sym} 137950 -8770 0 1 {name=p137243 lab=_45504_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -8760 0 0 {name=X_85050_ }
C {devices/lab_pin.sym} 137820 -8630 0 0 {name=p137244 lab=_51170_/A }
C {devices/lab_pin.sym} 137900 -8630 0 1 {name=p137245 lab=_51467_/C }
C {sky130_stdcells/buf_2.sym} 137860 -8630 0 0 {name=X_51442_ }
C {devices/lab_pin.sym} 137800 -8530 0 0 {name=p137246 lab=_63400_/A }
C {devices/lab_pin.sym} 137800 -8490 0 0 {name=p137247 lab=_84900_/Q }
C {devices/lab_pin.sym} 137800 -8450 0 0 {name=p137248 lab=_63463_/C }
C {devices/lab_pin.sym} 137920 -8490 0 1 {name=p137249 lab=_63428_/X }
C {sky130_stdcells/and3_4.sym} 137860 -8490 0 0 {name=X_63428_ }
C {devices/lab_pin.sym} 137770 -8350 0 0 {name=p137250 lab=_82253_/CLK }
C {devices/lab_pin.sym} 137770 -8330 0 0 {name=p137251 lab=_82262_/D }
C {devices/lab_pin.sym} 137950 -8350 0 1 {name=p137252 lab=_82262_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -8340 0 0 {name=X_82262_ }
C {devices/lab_pin.sym} 137780 -8240 0 0 {name=p137253 lab=_87109_/Q }
C {devices/lab_pin.sym} 137780 -8200 0 0 {name=p137254 lab=_67193_/X }
C {devices/lab_pin.sym} 137780 -8160 0 0 {name=p137255 lab=_67194_/X }
C {devices/lab_pin.sym} 137780 -8120 0 0 {name=p137256 lab=_67195_/X }
C {devices/lab_pin.sym} 137940 -8180 0 1 {name=p137257 lab=_67196_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -8180 0 0 {name=X_67196_ }
C {devices/lab_pin.sym} 137770 -8030 0 0 {name=p137258 lab=_81755_/CLK }
C {devices/lab_pin.sym} 137770 -8010 0 0 {name=p137259 lab=_68250_/X }
C {devices/lab_pin.sym} 137950 -8030 0 1 {name=p137260 lab=_84001_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -8020 0 0 {name=X_84001_ }
C {devices/lab_pin.sym} 137770 -7890 0 0 {name=p137261 lab=_82288_/CLK }
C {devices/lab_pin.sym} 137770 -7870 0 0 {name=p137262 lab=_81213_/D }
C {devices/lab_pin.sym} 137950 -7890 0 1 {name=p137263 lab=_46302_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -7880 0 0 {name=X_81213_ }
C {devices/lab_pin.sym} 137780 -7770 0 0 {name=p137264 lab=_54159_/Y }
C {devices/lab_pin.sym} 137780 -7730 0 0 {name=p137265 lab=_54144_/X }
C {devices/lab_pin.sym} 137780 -7690 0 0 {name=p137266 lab=_54160_/X }
C {devices/lab_pin.sym} 137940 -7730 0 1 {name=p137267 lab=_85493_/D }
C {sky130_stdcells/a21oi_4.sym} 137860 -7730 0 0 {name=X_54161_ }
C {devices/lab_pin.sym} 137780 -7620 0 0 {name=p137268 lab=_57761_/X }
C {devices/lab_pin.sym} 137780 -7580 0 0 {name=p137269 lab=_84977_/Q }
C {devices/lab_pin.sym} 137780 -7540 0 0 {name=p137270 lab=_65950_/X }
C {devices/lab_pin.sym} 137780 -7500 0 0 {name=p137271 lab=_66146_/X }
C {devices/lab_pin.sym} 137940 -7560 0 1 {name=p137272 lab=_66147_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -7560 0 0 {name=X_66147_ }
C {devices/lab_pin.sym} 137780 -7430 0 0 {name=p137273 lab=_51371_/Y }
C {devices/lab_pin.sym} 137780 -7390 0 0 {name=p137274 lab=_51366_/X }
C {devices/lab_pin.sym} 137780 -7350 0 0 {name=p137275 lab=_51372_/X }
C {devices/lab_pin.sym} 137940 -7390 0 1 {name=p137276 lab=_51373_/Y }
C {sky130_stdcells/a21oi_4.sym} 137860 -7390 0 0 {name=X_51373_ }
C {devices/lab_pin.sym} 137800 -7260 0 0 {name=p137277 lab=_58403_/A }
C {devices/lab_pin.sym} 137800 -7220 0 0 {name=p137278 lab=_63370_/A }
C {devices/lab_pin.sym} 137920 -7240 0 1 {name=p137279 lab=_63359_/Y }
C {sky130_stdcells/nor2_4.sym} 137860 -7240 0 0 {name=X_63359_ }
C {devices/lab_pin.sym} 137770 -7110 0 0 {name=p137280 lab=_82386_/CLK }
C {devices/lab_pin.sym} 137770 -7090 0 0 {name=p137281 lab=_82193_/D }
C {devices/lab_pin.sym} 137950 -7110 0 1 {name=p137282 lab=_82193_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -7100 0 0 {name=X_82193_ }
C {devices/lab_pin.sym} 137820 -6970 0 0 {name=p137283 lab=_53112_/A }
C {devices/lab_pin.sym} 137900 -6970 0 1 {name=p137284 lab=_53133_/A }
C {sky130_stdcells/buf_2.sym} 137860 -6970 0 0 {name=X_53112_ }
C {devices/lab_pin.sym} 137800 -6860 0 0 {name=p137285 lab=_50317_/X }
C {devices/lab_pin.sym} 137800 -6820 0 0 {name=p137286 lab=_48024_/B }
C {devices/lab_pin.sym} 137920 -6840 0 1 {name=p137287 lab=_50324_/Y }
C {sky130_stdcells/nand2_4.sym} 137860 -6840 0 0 {name=X_50324_ }
C {devices/lab_pin.sym} 137770 -6710 0 0 {name=p137288 lab=_81197_/CLK }
C {devices/lab_pin.sym} 137770 -6690 0 0 {name=p137289 lab=_80768_/Q }
C {devices/lab_pin.sym} 137950 -6710 0 1 {name=p137290 lab=_40639_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -6700 0 0 {name=X_81144_ }
C {devices/lab_pin.sym} 137780 -6590 0 0 {name=p137291 lab=_54090_/Y }
C {devices/lab_pin.sym} 137780 -6550 0 0 {name=p137292 lab=_54051_/X }
C {devices/lab_pin.sym} 137780 -6510 0 0 {name=p137293 lab=_54091_/X }
C {devices/lab_pin.sym} 137940 -6550 0 1 {name=p137294 lab=_54092_/Y }
C {sky130_stdcells/a21oi_4.sym} 137860 -6550 0 0 {name=X_54092_ }
C {devices/lab_pin.sym} 137820 -6410 0 0 {name=p137295 lab=_65969_/A }
C {devices/lab_pin.sym} 137900 -6410 0 1 {name=p137296 lab=_66123_/A }
C {sky130_stdcells/buf_2.sym} 137860 -6410 0 0 {name=X_66078_ }
C {devices/lab_pin.sym} 137820 -6290 0 0 {name=p137297 lab=_53069_/A }
C {devices/lab_pin.sym} 137900 -6290 0 1 {name=p137298 lab=_53063_/B }
C {sky130_stdcells/buf_2.sym} 137860 -6290 0 0 {name=X_53043_ }
C {devices/lab_pin.sym} 137780 -6210 0 0 {name=p137299 lab=_57781_/X }
C {devices/lab_pin.sym} 137780 -6170 0 0 {name=p137300 lab=_57918_/Y }
C {devices/lab_pin.sym} 137780 -6130 0 0 {name=p137301 lab=_57919_/Y }
C {devices/lab_pin.sym} 137780 -6090 0 0 {name=p137302 lab=_57893_/X }
C {devices/lab_pin.sym} 137780 -6050 0 0 {name=p137303 lab=_57795_/X }
C {devices/lab_pin.sym} 137940 -6130 0 1 {name=p137304 lab=_57920_/X }
C {sky130_stdcells/o32a_4.sym} 137860 -6130 0 0 {name=X_57920_ }
C {devices/lab_pin.sym} 137800 -5980 0 0 {name=p137305 lab=_64924_/A }
C {devices/lab_pin.sym} 137800 -5940 0 0 {name=p137306 lab=_65029_/B }
C {devices/lab_pin.sym} 137920 -5960 0 1 {name=p137307 lab=_65029_/X }
C {sky130_stdcells/and2_4.sym} 137860 -5960 0 0 {name=X_65029_ }
C {devices/lab_pin.sym} 137800 -5840 0 0 {name=p137308 lab=_69906_/A }
C {devices/lab_pin.sym} 137800 -5800 0 0 {name=p137309 lab=_87289_/Q }
C {devices/lab_pin.sym} 137920 -5820 0 1 {name=p137310 lab=_69906_/X }
C {sky130_stdcells/and2_4.sym} 137860 -5820 0 0 {name=X_69906_ }
C {devices/lab_pin.sym} 137820 -5690 0 0 {name=p137311 lab=_54043_/B }
C {devices/lab_pin.sym} 137900 -5690 0 1 {name=p137312 lab=_50475_/B }
C {sky130_stdcells/buf_2.sym} 137860 -5690 0 0 {name=X_50255_ }
C {devices/lab_pin.sym} 137770 -5570 0 0 {name=p137313 lab=_85471_/CLK }
C {devices/lab_pin.sym} 137770 -5550 0 0 {name=p137314 lab=_85952_/D }
C {devices/lab_pin.sym} 137950 -5570 0 1 {name=p137315 lab=_85952_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -5560 0 0 {name=X_85952_ }
C {devices/lab_pin.sym} 137770 -5430 0 0 {name=p137316 lab=_81070_/CLK }
C {devices/lab_pin.sym} 137770 -5410 0 0 {name=p137317 lab=_81107_/Q }
C {devices/lab_pin.sym} 137950 -5430 0 1 {name=p137318 lab=_81075_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -5420 0 0 {name=X_81075_ }
C {devices/lab_pin.sym} 137800 -5300 0 0 {name=p137319 lab=_84932_/Q }
C {devices/lab_pin.sym} 137800 -5260 0 0 {name=p137320 lab=_84180_/Q }
C {devices/lab_pin.sym} 137920 -5280 0 1 {name=p137321 lab=_80026_/X }
C {sky130_stdcells/xor2_4.sym} 137860 -5280 0 0 {name=X_80026_ }
C {devices/lab_pin.sym} 137770 -5150 0 0 {name=p137322 lab=_84903_/CLK }
C {devices/lab_pin.sym} 137770 -5130 0 0 {name=p137323 lab=_58227_/Y }
C {devices/lab_pin.sym} 137950 -5150 0 1 {name=p137324 lab=_58225_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -5140 0 0 {name=X_84903_ }
C {devices/lab_pin.sym} 137780 -5030 0 0 {name=p137325 lab=_57811_/X }
C {devices/lab_pin.sym} 137780 -4990 0 0 {name=p137326 lab=_85401_/Q }
C {devices/lab_pin.sym} 137780 -4950 0 0 {name=p137327 lab=_57850_/X }
C {devices/lab_pin.sym} 137940 -4990 0 1 {name=p137328 lab=_57851_/Y }
C {sky130_stdcells/o21ai_4.sym} 137860 -4990 0 0 {name=X_57851_ }
C {devices/lab_pin.sym} 137820 -4850 0 0 {name=p137329 lab=_69751_/A }
C {devices/lab_pin.sym} 137900 -4850 0 1 {name=p137330 lab=_69837_/X }
C {sky130_stdcells/buf_2.sym} 137860 -4850 0 0 {name=X_69837_ }
C {devices/lab_pin.sym} 137820 -4730 0 0 {name=p137331 lab=_50063_/A }
C {devices/lab_pin.sym} 137900 -4730 0 1 {name=p137332 lab=_51286_/A }
C {sky130_stdcells/buf_2.sym} 137860 -4730 0 0 {name=X_50186_ }
C {devices/lab_pin.sym} 137770 -4610 0 0 {name=p137333 lab=_86490_/CLK }
C {devices/lab_pin.sym} 137770 -4590 0 0 {name=p137334 lab=_52131_/Y }
C {devices/lab_pin.sym} 137950 -4610 0 1 {name=p137335 lab=_65519_/B }
C {sky130_stdcells/dfxtp_4.sym} 137860 -4600 0 0 {name=X_85883_ }
C {devices/lab_pin.sym} 137800 -4500 0 0 {name=p137336 lab=_56755_/X }
C {devices/lab_pin.sym} 137800 -4460 0 0 {name=p137337 lab=_57140_/B }
C {devices/lab_pin.sym} 137800 -4420 0 0 {name=p137338 lab=_56759_/X }
C {devices/lab_pin.sym} 137800 -4380 0 0 {name=p137339 lab=_83322_/Q }
C {devices/lab_pin.sym} 137920 -4440 0 1 {name=p137340 lab=_56803_/A }
C {sky130_stdcells/and4_4.sym} 137860 -4440 0 0 {name=X_56802_ }
C {devices/lab_pin.sym} 137770 -4290 0 0 {name=p137341 lab=_87883_/CLK }
C {devices/lab_pin.sym} 137770 -4270 0 0 {name=p137342 lab=_42978_/Y }
C {devices/lab_pin.sym} 137950 -4290 0 1 {name=p137343 lab=_87622_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -4280 0 0 {name=X_87622_ }
C {devices/lab_pin.sym} 137770 -4150 0 0 {name=p137344 lab=_84308_/CLK }
C {devices/lab_pin.sym} 137770 -4130 0 0 {name=p137345 lab=_84834_/D }
C {devices/lab_pin.sym} 137950 -4150 0 1 {name=p137346 lab=_84834_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -4140 0 0 {name=X_84834_ }
C {devices/lab_pin.sym} 137820 -4010 0 0 {name=p137347 lab=_68714_/A }
C {devices/lab_pin.sym} 137900 -4010 0 1 {name=p137348 lab=_68342_/A }
C {sky130_stdcells/buf_2.sym} 137860 -4010 0 0 {name=X_57782_ }
C {devices/lab_pin.sym} 137820 -3890 0 0 {name=p137349 lab=_69768_/A }
C {devices/lab_pin.sym} 137900 -3890 0 1 {name=p137350 lab=_69768_/X }
C {sky130_stdcells/buf_2.sym} 137860 -3890 0 0 {name=X_69768_ }
C {devices/lab_pin.sym} 137820 -3770 0 0 {name=p137351 lab=_55072_/A }
C {devices/lab_pin.sym} 137900 -3770 0 1 {name=p137352 lab=_54994_/X }
C {sky130_stdcells/buf_2.sym} 137860 -3770 0 0 {name=X_54994_ }
C {devices/lab_pin.sym} 137820 -3650 0 0 {name=p137353 lab=_59521_/A }
C {devices/lab_pin.sym} 137900 -3650 0 1 {name=p137354 lab=_59571_/B }
C {sky130_stdcells/buf_2.sym} 137860 -3650 0 0 {name=X_59521_ }
C {devices/lab_pin.sym} 137820 -3530 0 0 {name=p137355 lab=_56739_/A }
C {devices/lab_pin.sym} 137900 -3530 0 1 {name=p137356 lab=_56733_/X }
C {sky130_stdcells/buf_2.sym} 137860 -3530 0 0 {name=X_56733_ }
C {devices/lab_pin.sym} 137780 -3440 0 0 {name=p137357 lab=_87493_/Q }
C {devices/lab_pin.sym} 137780 -3400 0 0 {name=p137358 lab=_68472_/A }
C {devices/lab_pin.sym} 137780 -3360 0 0 {name=p137359 lab=_68545_/X }
C {devices/lab_pin.sym} 137780 -3320 0 0 {name=p137360 lab=_68718_/X }
C {devices/lab_pin.sym} 137940 -3380 0 1 {name=p137361 lab=_68719_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -3380 0 0 {name=X_68719_ }
C {devices/lab_pin.sym} 137770 -3230 0 0 {name=p137362 lab=_87553_/CLK }
C {devices/lab_pin.sym} 137770 -3210 0 0 {name=p137363 lab=_43160_/Y }
C {devices/lab_pin.sym} 137950 -3230 0 1 {name=p137364 lab=_73228_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -3220 0 0 {name=X_87553_ }
C {devices/lab_pin.sym} 137780 -3110 0 0 {name=p137365 lab=_53943_/Y }
C {devices/lab_pin.sym} 137780 -3070 0 0 {name=p137366 lab=_53892_/X }
C {devices/lab_pin.sym} 137780 -3030 0 0 {name=p137367 lab=_53944_/Y }
C {devices/lab_pin.sym} 137940 -3070 0 1 {name=p137368 lab=_85537_/D }
C {sky130_stdcells/a21oi_4.sym} 137860 -3070 0 0 {name=X_53945_ }
C {devices/lab_pin.sym} 137770 -2930 0 0 {name=p137369 lab=_84760_/CLK }
C {devices/lab_pin.sym} 137770 -2910 0 0 {name=p137370 lab=_84765_/D }
C {devices/lab_pin.sym} 137950 -2930 0 1 {name=p137371 lab=_59143_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -2920 0 0 {name=X_84765_ }
C {devices/lab_pin.sym} 137770 -2790 0 0 {name=p137372 lab=_82234_/CLK }
C {devices/lab_pin.sym} 137770 -2770 0 0 {name=p137373 lab=_83905_/Q }
C {devices/lab_pin.sym} 137950 -2790 0 1 {name=p137374 lab=_81977_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -2780 0 0 {name=X_81977_ }
C {devices/lab_pin.sym} 137780 -2680 0 0 {name=p137375 lab=_73033_/A }
C {devices/lab_pin.sym} 137780 -2640 0 0 {name=p137376 lab=_44299_/A }
C {devices/lab_pin.sym} 137780 -2600 0 0 {name=p137377 lab=_68933_/X }
C {devices/lab_pin.sym} 137780 -2560 0 0 {name=p137378 lab=_69698_/Y }
C {devices/lab_pin.sym} 137940 -2620 0 1 {name=p137379 lab=_69699_/X }
C {sky130_stdcells/a211o_4.sym} 137860 -2620 0 0 {name=X_69699_ }
C {devices/lab_pin.sym} 137770 -2470 0 0 {name=p137380 lab=_86500_/CLK }
C {devices/lab_pin.sym} 137770 -2450 0 0 {name=p137381 lab=_48646_/Y }
C {devices/lab_pin.sym} 137950 -2470 0 1 {name=p137382 lab=_86504_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -2460 0 0 {name=X_86504_ }
C {devices/lab_pin.sym} 137780 -2370 0 0 {name=p137383 lab=_40870_/X }
C {devices/lab_pin.sym} 137780 -2330 0 0 {name=p137384 lab=_40871_/X }
C {devices/lab_pin.sym} 137780 -2290 0 0 {name=p137385 lab=_40909_/X }
C {devices/lab_pin.sym} 137780 -2250 0 0 {name=p137386 lab=_69923_/B }
C {devices/lab_pin.sym} 137780 -2210 0 0 {name=p137387 lab=_40867_/X }
C {devices/lab_pin.sym} 137940 -2290 0 1 {name=p137388 lab=_40911_/A }
C {sky130_stdcells/o32ai_4.sym} 137860 -2290 0 0 {name=X_40910_ }
C {devices/lab_pin.sym} 137780 -2150 0 0 {name=p137389 lab=_58236_/Y }
C {devices/lab_pin.sym} 137780 -2110 0 0 {name=p137390 lab=_71718_/X }
C {devices/lab_pin.sym} 137780 -2070 0 0 {name=p137391 lab=_71729_/Y }
C {devices/lab_pin.sym} 137940 -2110 0 1 {name=p137392 lab=_83396_/D }
C {sky130_stdcells/o21ai_4.sym} 137860 -2110 0 0 {name=X_71730_ }
C {devices/lab_pin.sym} 137770 -1970 0 0 {name=p137393 lab=_83716_/CLK }
C {devices/lab_pin.sym} 137770 -1950 0 0 {name=p137394 lab=_70723_/Y }
C {devices/lab_pin.sym} 137950 -1970 0 1 {name=p137395 lab=_83716_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -1960 0 0 {name=X_83716_ }
C {devices/lab_pin.sym} 137780 -1850 0 0 {name=p137396 lab=_59442_/X }
C {devices/lab_pin.sym} 137780 -1810 0 0 {name=p137397 lab=_83465_/Q }
C {devices/lab_pin.sym} 137780 -1770 0 0 {name=p137398 lab=_59451_/Y }
C {devices/lab_pin.sym} 137940 -1810 0 1 {name=p137399 lab=_59452_/X }
C {sky130_stdcells/o21a_4.sym} 137860 -1810 0 0 {name=X_59452_ }
C {devices/lab_pin.sym} 137800 -1690 0 0 {name=p137400 lab=_56593_/A }
C {devices/lab_pin.sym} 137800 -1650 0 0 {name=p137401 lab=_83329_/Q }
C {devices/lab_pin.sym} 137800 -1610 0 0 {name=p137402 lab=_56663_/X }
C {devices/lab_pin.sym} 137920 -1650 0 1 {name=p137403 lab=_56664_/Y }
C {sky130_stdcells/nand3_4.sym} 137860 -1650 0 0 {name=X_56664_ }
C {devices/lab_pin.sym} 137770 -1510 0 0 {name=p137404 lab=_80928_/CLK }
C {devices/lab_pin.sym} 137770 -1490 0 0 {name=p137405 lab=_84104_/Q }
C {devices/lab_pin.sym} 137950 -1510 0 1 {name=p137406 lab=_75852_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -1500 0 0 {name=X_80928_ }
C {devices/lab_pin.sym} 137770 -1370 0 0 {name=p137407 lab=_87484_/CLK }
C {devices/lab_pin.sym} 137770 -1350 0 0 {name=p137408 lab=_87484_/D }
C {devices/lab_pin.sym} 137950 -1370 0 1 {name=p137409 lab=_87484_/Q }
C {sky130_stdcells/dfxtp_4.sym} 137860 -1360 0 0 {name=X_87484_ }
C {devices/lab_pin.sym} 137820 -1230 0 0 {name=p137410 lab=_41881_/A }
C {devices/lab_pin.sym} 137900 -1230 0 1 {name=p137411 lab=_41967_/A }
C {sky130_stdcells/buf_2.sym} 137860 -1230 0 0 {name=X_41890_ }
C {devices/lab_pin.sym} 137780 -1130 0 0 {name=p137412 lab=_53873_/Y }
C {devices/lab_pin.sym} 137780 -1090 0 0 {name=p137413 lab=_53829_/X }
C {devices/lab_pin.sym} 137780 -1050 0 0 {name=p137414 lab=_53875_/X }
C {devices/lab_pin.sym} 137940 -1090 0 1 {name=p137415 lab=_53876_/Y }
C {sky130_stdcells/a21oi_4.sym} 137860 -1090 0 0 {name=X_53876_ }
C {devices/lab_pin.sym} 137770 -950 0 0 {name=p137416 lab=_84713_/CLK }
C {devices/lab_pin.sym} 137770 -930 0 0 {name=p137417 lab=_84696_/D }
C {devices/lab_pin.sym} 137950 -950 0 1 {name=p137418 lab=_80442_/A }
C {sky130_stdcells/dfxtp_4.sym} 137860 -940 0 0 {name=X_84696_ }
C {devices/lab_pin.sym} 137800 -820 0 0 {name=p137419 lab=_58403_/A }
C {devices/lab_pin.sym} 137800 -780 0 0 {name=p137420 lab=_58403_/B }
C {devices/lab_pin.sym} 137920 -800 0 1 {name=p137421 lab=_58403_/Y }
C {sky130_stdcells/nand2_4.sym} 137860 -800 0 0 {name=X_58403_ }
C {devices/lab_pin.sym} 137820 -670 0 0 {name=p137422 lab=_55615_/A }
C {devices/lab_pin.sym} 137900 -670 0 1 {name=p137423 lab=_55615_/X }
C {sky130_stdcells/buf_2.sym} 137860 -670 0 0 {name=X_55615_ }
C {devices/lab_pin.sym} 138690 -42150 0 0 {name=p137424 lab=_86436_/CLK }
C {devices/lab_pin.sym} 138690 -42130 0 0 {name=p137425 lab=_86435_/D }
C {devices/lab_pin.sym} 138870 -42150 0 1 {name=p137426 lab=_65392_/B }
C {sky130_stdcells/dfxtp_4.sym} 138780 -42140 0 0 {name=X_86435_ }
C {devices/lab_pin.sym} 138740 -42010 0 0 {name=p137427 lab=_40840_/Y }
C {devices/lab_pin.sym} 138820 -42010 0 1 {name=p137428 lab=_88325_/D }
C {sky130_stdcells/inv_2.sym} 138780 -42010 0 0 {name=X_40841_ }
C {devices/lab_pin.sym} 138720 -41920 0 0 {name=p137429 lab=_52818_/A }
C {devices/lab_pin.sym} 138720 -41880 0 0 {name=p137430 lab=_52831_/B }
C {devices/lab_pin.sym} 138720 -41840 0 0 {name=p137431 lab=_52818_/C }
C {devices/lab_pin.sym} 138720 -41800 0 0 {name=p137432 lab=_52827_/D }
C {devices/lab_pin.sym} 138840 -41860 0 1 {name=p137433 lab=_52827_/X }
C {sky130_stdcells/and4_4.sym} 138780 -41860 0 0 {name=X_52827_ }
C {devices/lab_pin.sym} 138700 -41730 0 0 {name=p137434 lab=_59381_/X }
C {devices/lab_pin.sym} 138700 -41690 0 0 {name=p137435 lab=_86050_/Q }
C {devices/lab_pin.sym} 138700 -41650 0 0 {name=p137436 lab=_59382_/X }
C {devices/lab_pin.sym} 138860 -41690 0 1 {name=p137437 lab=_59383_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -41690 0 0 {name=X_59383_ }
C {devices/lab_pin.sym} 138700 -41570 0 0 {name=p137438 lab=_58518_/Y }
C {devices/lab_pin.sym} 138700 -41530 0 0 {name=p137439 lab=_71649_/X }
C {devices/lab_pin.sym} 138700 -41490 0 0 {name=p137440 lab=_71660_/Y }
C {devices/lab_pin.sym} 138860 -41530 0 1 {name=p137441 lab=_83421_/D }
C {sky130_stdcells/o21ai_4.sym} 138780 -41530 0 0 {name=X_71661_ }
C {devices/lab_pin.sym} 138690 -41390 0 0 {name=p137442 lab=_86422_/CLK }
C {devices/lab_pin.sym} 138690 -41370 0 0 {name=p137443 lab=_70968_/Y }
C {devices/lab_pin.sym} 138870 -41390 0 1 {name=p137444 lab=_83647_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -41380 0 0 {name=X_83647_ }
C {devices/lab_pin.sym} 138720 -41260 0 0 {name=p137445 lab=_56595_/A }
C {devices/lab_pin.sym} 138720 -41220 0 0 {name=p137446 lab=_56595_/B }
C {devices/lab_pin.sym} 138840 -41240 0 1 {name=p137447 lab=_56596_/A }
C {sky130_stdcells/and2_4.sym} 138780 -41240 0 0 {name=X_56595_ }
C {devices/lab_pin.sym} 138690 -41110 0 0 {name=p137448 lab=_83974_/CLK }
C {devices/lab_pin.sym} 138690 -41090 0 0 {name=p137449 lab=_80891_/Q }
C {devices/lab_pin.sym} 138870 -41110 0 1 {name=p137450 lab=_75032_/B }
C {sky130_stdcells/dfxtp_4.sym} 138780 -41100 0 0 {name=X_80859_ }
C {devices/lab_pin.sym} 138700 -40990 0 0 {name=p137451 lab=_44581_/Y }
C {devices/lab_pin.sym} 138700 -40950 0 0 {name=p137452 lab=_73006_/X }
C {devices/lab_pin.sym} 138700 -40910 0 0 {name=p137453 lab=_73399_/Y }
C {devices/lab_pin.sym} 138860 -40950 0 1 {name=p137454 lab=_73412_/C }
C {sky130_stdcells/a21o_4.sym} 138780 -40950 0 0 {name=X_73400_ }
C {devices/lab_pin.sym} 138740 -40810 0 0 {name=p137455 lab=_70611_/X }
C {devices/lab_pin.sym} 138820 -40810 0 1 {name=p137456 lab=_70620_/C }
C {sky130_stdcells/buf_2.sym} 138780 -40810 0 0 {name=X_70612_ }
C {devices/lab_pin.sym} 138740 -40690 0 0 {name=p137457 lab=_58334_/A }
C {devices/lab_pin.sym} 138820 -40690 0 1 {name=p137458 lab=_58334_/X }
C {sky130_stdcells/buf_2.sym} 138780 -40690 0 0 {name=X_58334_ }
C {devices/lab_pin.sym} 138700 -40590 0 0 {name=p137459 lab=_55543_/X }
C {devices/lab_pin.sym} 138700 -40550 0 0 {name=p137460 lab=_55545_/X }
C {devices/lab_pin.sym} 138700 -40510 0 0 {name=p137461 lab=_55516_/X }
C {devices/lab_pin.sym} 138860 -40550 0 1 {name=p137462 lab=_55546_/X }
C {sky130_stdcells/a21o_4.sym} 138780 -40550 0 0 {name=X_55546_ }
C {devices/lab_pin.sym} 138740 -40410 0 0 {name=p137463 lab=_53443_/A }
C {devices/lab_pin.sym} 138820 -40410 0 1 {name=p137464 lab=_43560_/X }
C {sky130_stdcells/buf_2.sym} 138780 -40410 0 0 {name=X_43560_ }
C {devices/lab_pin.sym} 138700 -40310 0 0 {name=p137465 lab=_83078_/Q }
C {devices/lab_pin.sym} 138700 -40270 0 0 {name=p137466 lab=_74377_/X }
C {devices/lab_pin.sym} 138700 -40230 0 0 {name=p137467 lab=_74379_/Y }
C {devices/lab_pin.sym} 138860 -40270 0 1 {name=p137468 lab=_74380_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -40270 0 0 {name=X_74380_ }
C {devices/lab_pin.sym} 138690 -40130 0 0 {name=p137469 lab=_83716_/CLK }
C {devices/lab_pin.sym} 138690 -40110 0 0 {name=p137470 lab=_86366_/D }
C {devices/lab_pin.sym} 138870 -40130 0 1 {name=p137471 lab=_86366_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -40120 0 0 {name=X_86366_ }
C {devices/lab_pin.sym} 138700 -40020 0 0 {name=p137472 lab=_40771_/X }
C {devices/lab_pin.sym} 138700 -39980 0 0 {name=p137473 lab=_40754_/X }
C {devices/lab_pin.sym} 138700 -39940 0 0 {name=p137474 lab=_88338_/Q }
C {devices/lab_pin.sym} 138700 -39900 0 0 {name=p137475 lab=_40756_/X }
C {devices/lab_pin.sym} 138860 -39960 0 1 {name=p137476 lab=_40772_/X }
C {sky130_stdcells/a2bb2o_4.sym} 138780 -39960 0 0 {name=X_40772_ }
C {devices/lab_pin.sym} 138720 -39840 0 0 {name=p137477 lab=_52775_/A }
C {devices/lab_pin.sym} 138720 -39800 0 0 {name=p137478 lab=_52746_/B }
C {devices/lab_pin.sym} 138720 -39760 0 0 {name=p137479 lab=_52746_/C }
C {devices/lab_pin.sym} 138720 -39720 0 0 {name=p137480 lab=_52758_/D }
C {devices/lab_pin.sym} 138840 -39780 0 1 {name=p137481 lab=_52758_/X }
C {sky130_stdcells/and4_4.sym} 138780 -39780 0 0 {name=X_52758_ }
C {devices/lab_pin.sym} 138720 -39650 0 0 {name=p137482 lab=_70558_/X }
C {devices/lab_pin.sym} 138720 -39610 0 0 {name=p137483 lab=_71590_/B }
C {devices/lab_pin.sym} 138720 -39570 0 0 {name=p137484 lab=_71582_/X }
C {devices/lab_pin.sym} 138840 -39610 0 1 {name=p137485 lab=_71592_/Y }
C {sky130_stdcells/nor3_4.sym} 138780 -39610 0 0 {name=X_71592_ }
C {devices/lab_pin.sym} 138690 -39470 0 0 {name=p137486 lab=_83313_/CLK }
C {devices/lab_pin.sym} 138690 -39450 0 0 {name=p137487 lab=_71186_/Y }
C {devices/lab_pin.sym} 138870 -39470 0 1 {name=p137488 lab=_83578_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -39460 0 0 {name=X_83578_ }
C {devices/lab_pin.sym} 138690 -39330 0 0 {name=p137489 lab=_87595_/CLK }
C {devices/lab_pin.sym} 138690 -39310 0 0 {name=p137490 lab=_88105_/D }
C {devices/lab_pin.sym} 138870 -39330 0 1 {name=p137491 lab=_88105_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -39320 0 0 {name=X_88105_ }
C {devices/lab_pin.sym} 138700 -39230 0 0 {name=p137492 lab=_42495_/X }
C {devices/lab_pin.sym} 138700 -39190 0 0 {name=p137493 lab=_42496_/X }
C {devices/lab_pin.sym} 138700 -39150 0 0 {name=p137494 lab=_40702_/X }
C {devices/lab_pin.sym} 138700 -39110 0 0 {name=p137495 lab=_87839_/Q }
C {devices/lab_pin.sym} 138700 -39070 0 0 {name=p137496 lab=_42506_/X }
C {devices/lab_pin.sym} 138860 -39150 0 1 {name=p137497 lab=_42511_/Y }
C {sky130_stdcells/o32ai_4.sym} 138780 -39150 0 0 {name=X_42511_ }
C {devices/lab_pin.sym} 138720 -39000 0 0 {name=p137498 lab=_73381_/A }
C {devices/lab_pin.sym} 138720 -38960 0 0 {name=p137499 lab=_86475_/Q }
C {devices/lab_pin.sym} 138840 -38980 0 1 {name=p137500 lab=_73331_/X }
C {sky130_stdcells/and2_4.sym} 138780 -38980 0 0 {name=X_73331_ }
C {devices/lab_pin.sym} 138690 -38850 0 0 {name=p137501 lab=_85317_/CLK }
C {devices/lab_pin.sym} 138690 -38830 0 0 {name=p137502 lab=_55109_/Y }
C {devices/lab_pin.sym} 138870 -38850 0 1 {name=p137503 lab=_85317_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -38840 0 0 {name=X_85317_ }
C {devices/lab_pin.sym} 138740 -38710 0 0 {name=p137504 lab=_52593_/A }
C {devices/lab_pin.sym} 138820 -38710 0 1 {name=p137505 lab=_51709_/X }
C {sky130_stdcells/buf_2.sym} 138780 -38710 0 0 {name=X_51709_ }
C {devices/lab_pin.sym} 138740 -38590 0 0 {name=p137506 lab=DATA_TO_HASH[6] }
C {devices/lab_pin.sym} 138820 -38590 0 1 {name=p137507 lab=_70543_/Y }
C {sky130_stdcells/inv_2.sym} 138780 -38590 0 0 {name=X_70543_ }
C {devices/lab_pin.sym} 138690 -38470 0 0 {name=p137508 lab=_82529_/CLK }
C {devices/lab_pin.sym} 138690 -38450 0 0 {name=p137509 lab=_82529_/D }
C {devices/lab_pin.sym} 138870 -38470 0 1 {name=p137510 lab=_78798_/A }
C {sky130_stdcells/dfxtp_4.sym} 138780 -38460 0 0 {name=X_82529_ }
C {devices/lab_pin.sym} 138720 -38340 0 0 {name=p137511 lab=_58264_/Y }
C {devices/lab_pin.sym} 138720 -38300 0 0 {name=p137512 lab=_58268_/B }
C {devices/lab_pin.sym} 138840 -38320 0 1 {name=p137513 lab=_58265_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -38320 0 0 {name=X_58265_ }
C {devices/lab_pin.sym} 138700 -38220 0 0 {name=p137514 lab=_41715_/X }
C {devices/lab_pin.sym} 138700 -38180 0 0 {name=p137515 lab=_43484_/X }
C {devices/lab_pin.sym} 138700 -38140 0 0 {name=p137516 lab=_87395_/Q }
C {devices/lab_pin.sym} 138700 -38100 0 0 {name=p137517 lab=_43485_/X }
C {devices/lab_pin.sym} 138860 -38160 0 1 {name=p137518 lab=_87395_/D }
C {sky130_stdcells/a2bb2o_4.sym} 138780 -38160 0 0 {name=X_43491_ }
C {devices/lab_pin.sym} 138720 -38020 0 0 {name=p137519 lab=_55477_/A }
C {devices/lab_pin.sym} 138720 -37980 0 0 {name=p137520 lab=_85139_/Q }
C {devices/lab_pin.sym} 138840 -38000 0 1 {name=p137521 lab=_55477_/X }
C {sky130_stdcells/and2_4.sym} 138780 -38000 0 0 {name=X_55477_ }
C {devices/lab_pin.sym} 138690 -37870 0 0 {name=p137522 lab=_86297_/CLK }
C {devices/lab_pin.sym} 138690 -37850 0 0 {name=p137523 lab=_49933_/Y }
C {devices/lab_pin.sym} 138870 -37870 0 1 {name=p137524 lab=_72220_/B }
C {sky130_stdcells/dfxtp_4.sym} 138780 -37860 0 0 {name=X_86297_ }
C {devices/lab_pin.sym} 138740 -37730 0 0 {name=p137525 lab=_52770_/A }
C {devices/lab_pin.sym} 138820 -37730 0 1 {name=p137526 lab=_52694_/B }
C {sky130_stdcells/buf_2.sym} 138780 -37730 0 0 {name=X_52689_ }
C {devices/lab_pin.sym} 138700 -37630 0 0 {name=p137527 lab=_56124_/C }
C {devices/lab_pin.sym} 138700 -37590 0 0 {name=p137528 lab=_45194_/X }
C {devices/lab_pin.sym} 138700 -37550 0 0 {name=p137529 lab=_45229_/X }
C {devices/lab_pin.sym} 138860 -37590 0 1 {name=p137530 lab=_45230_/X }
C {sky130_stdcells/o21a_4.sym} 138780 -37590 0 0 {name=X_45230_ }
C {devices/lab_pin.sym} 138720 -37470 0 0 {name=p137531 lab=_57215_/X }
C {devices/lab_pin.sym} 138720 -37430 0 0 {name=p137532 lab=_57665_/A }
C {devices/lab_pin.sym} 138720 -37390 0 0 {name=p137533 lab=_57196_/Y }
C {devices/lab_pin.sym} 138840 -37430 0 1 {name=p137534 lab=_57216_/Y }
C {sky130_stdcells/nand3_4.sym} 138780 -37430 0 0 {name=X_57216_ }
C {devices/lab_pin.sym} 138720 -37300 0 0 {name=p137535 lab=_81339_/Q }
C {devices/lab_pin.sym} 138720 -37260 0 0 {name=p137536 lab=_76041_/B }
C {devices/lab_pin.sym} 138840 -37280 0 1 {name=p137537 lab=_76050_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -37280 0 0 {name=X_76050_ }
C {devices/lab_pin.sym} 138700 -37180 0 0 {name=p137538 lab=_40538_/X }
C {devices/lab_pin.sym} 138700 -37140 0 0 {name=p137539 lab=_42434_/X }
C {devices/lab_pin.sym} 138700 -37100 0 0 {name=p137540 lab=_87862_/Q }
C {devices/lab_pin.sym} 138700 -37060 0 0 {name=p137541 lab=_42435_/X }
C {devices/lab_pin.sym} 138860 -37120 0 1 {name=p137542 lab=_87862_/D }
C {sky130_stdcells/a2bb2o_4.sym} 138780 -37120 0 0 {name=X_42442_ }
C {devices/lab_pin.sym} 138690 -36970 0 0 {name=p137543 lab=_88036_/CLK }
C {devices/lab_pin.sym} 138690 -36950 0 0 {name=p137544 lab=_42101_/Y }
C {devices/lab_pin.sym} 138870 -36970 0 1 {name=p137545 lab=_88036_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -36960 0 0 {name=X_88036_ }
C {devices/lab_pin.sym} 138740 -36830 0 0 {name=p137546 lab=_54401_/A }
C {devices/lab_pin.sym} 138820 -36830 0 1 {name=p137547 lab=_54429_/C }
C {sky130_stdcells/buf_2.sym} 138780 -36830 0 0 {name=X_54428_ }
C {devices/lab_pin.sym} 138740 -36710 0 0 {name=p137548 lab=_73262_/A }
C {devices/lab_pin.sym} 138820 -36710 0 1 {name=p137549 lab=_73262_/X }
C {sky130_stdcells/buf_2.sym} 138780 -36710 0 0 {name=X_73262_ }
C {devices/lab_pin.sym} 138690 -36590 0 0 {name=p137550 lab=_85248_/CLK }
C {devices/lab_pin.sym} 138690 -36570 0 0 {name=p137551 lab=_85248_/D }
C {devices/lab_pin.sym} 138870 -36590 0 1 {name=p137552 lab=_55976_/B }
C {sky130_stdcells/dfxtp_4.sym} 138780 -36580 0 0 {name=X_85248_ }
C {devices/lab_pin.sym} 138700 -36470 0 0 {name=p137553 lab=_58350_/Y }
C {devices/lab_pin.sym} 138700 -36430 0 0 {name=p137554 lab=_70458_/X }
C {devices/lab_pin.sym} 138700 -36390 0 0 {name=p137555 lab=_70473_/Y }
C {devices/lab_pin.sym} 138860 -36430 0 1 {name=p137556 lab=_70474_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -36430 0 0 {name=X_70474_ }
C {devices/lab_pin.sym} 138740 -36290 0 0 {name=p137557 lab=_58196_/A }
C {devices/lab_pin.sym} 138820 -36290 0 1 {name=p137558 lab=_58196_/Y }
C {sky130_stdcells/inv_2.sym} 138780 -36290 0 0 {name=X_58196_ }
C {devices/lab_pin.sym} 138720 -36180 0 0 {name=p137559 lab=_75001_/A }
C {devices/lab_pin.sym} 138720 -36140 0 0 {name=p137560 lab=_75000_/X }
C {devices/lab_pin.sym} 138840 -36160 0 1 {name=p137561 lab=_75001_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -36160 0 0 {name=X_75001_ }
C {devices/lab_pin.sym} 138700 -36060 0 0 {name=p137562 lab=_83274_/Q }
C {devices/lab_pin.sym} 138700 -36020 0 0 {name=p137563 lab=_72115_/X }
C {devices/lab_pin.sym} 138700 -35980 0 0 {name=p137564 lab=_72206_/X }
C {devices/lab_pin.sym} 138700 -35940 0 0 {name=p137565 lab=_72212_/X }
C {devices/lab_pin.sym} 138860 -36000 0 1 {name=p137566 lab=_72213_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 138780 -36000 0 0 {name=X_72213_ }
C {devices/lab_pin.sym} 138740 -35850 0 0 {name=p137567 lab=_45237_/A }
C {devices/lab_pin.sym} 138820 -35850 0 1 {name=p137568 lab=_45161_/X }
C {sky130_stdcells/buf_2.sym} 138780 -35850 0 0 {name=X_45161_ }
C {devices/lab_pin.sym} 138700 -35750 0 0 {name=p137569 lab=_57121_/X }
C {devices/lab_pin.sym} 138700 -35710 0 0 {name=p137570 lab=_57145_/Y }
C {devices/lab_pin.sym} 138700 -35670 0 0 {name=p137571 lab=_57146_/Y }
C {devices/lab_pin.sym} 138860 -35710 0 1 {name=p137572 lab=_57147_/X }
C {sky130_stdcells/a21bo_4.sym} 138780 -35710 0 0 {name=X_57147_ }
C {devices/lab_pin.sym} 138740 -35570 0 0 {name=p137573 lab=_50523_/A }
C {devices/lab_pin.sym} 138820 -35570 0 1 {name=p137574 lab=_42373_/X }
C {sky130_stdcells/buf_2.sym} 138780 -35570 0 0 {name=X_42373_ }
C {devices/lab_pin.sym} 138700 -35470 0 0 {name=p137575 lab=_54356_/Y }
C {devices/lab_pin.sym} 138700 -35430 0 0 {name=p137576 lab=_54338_/X }
C {devices/lab_pin.sym} 138700 -35390 0 0 {name=p137577 lab=_54358_/X }
C {devices/lab_pin.sym} 138860 -35430 0 1 {name=p137578 lab=_85457_/D }
C {sky130_stdcells/a21oi_4.sym} 138780 -35430 0 0 {name=X_54359_ }
C {devices/lab_pin.sym} 138740 -35290 0 0 {name=p137579 lab=_73193_/A }
C {devices/lab_pin.sym} 138820 -35290 0 1 {name=p137580 lab=_73193_/X }
C {sky130_stdcells/buf_2.sym} 138780 -35290 0 0 {name=X_73193_ }
C {devices/lab_pin.sym} 138690 -35170 0 0 {name=p137581 lab=_85277_/CLK }
C {devices/lab_pin.sym} 138690 -35150 0 0 {name=p137582 lab=_85179_/D }
C {devices/lab_pin.sym} 138870 -35170 0 1 {name=p137583 lab=_55931_/B }
C {sky130_stdcells/dfxtp_4.sym} 138780 -35160 0 0 {name=X_85179_ }
C {devices/lab_pin.sym} 138740 -35030 0 0 {name=p137584 lab=_44111_/X }
C {devices/lab_pin.sym} 138820 -35030 0 1 {name=p137585 lab=_44112_/X }
C {sky130_stdcells/buf_2.sym} 138780 -35030 0 0 {name=X_44112_ }
C {devices/lab_pin.sym} 138740 -34910 0 0 {name=p137586 lab=_41143_/A }
C {devices/lab_pin.sym} 138820 -34910 0 1 {name=p137587 lab=_41324_/X }
C {sky130_stdcells/buf_2.sym} 138780 -34910 0 0 {name=X_41324_ }
C {devices/lab_pin.sym} 138700 -34810 0 0 {name=p137588 lab=_59346_/X }
C {devices/lab_pin.sym} 138700 -34770 0 0 {name=p137589 lab=_85343_/Q }
C {devices/lab_pin.sym} 138700 -34730 0 0 {name=p137590 lab=_72120_/X }
C {devices/lab_pin.sym} 138860 -34770 0 1 {name=p137591 lab=_72144_/X }
C {sky130_stdcells/o21a_4.sym} 138780 -34770 0 0 {name=X_72144_ }
C {devices/lab_pin.sym} 138700 -34650 0 0 {name=p137592 lab=_45089_/Y }
C {devices/lab_pin.sym} 138700 -34610 0 0 {name=p137593 lab=_45091_/Y }
C {devices/lab_pin.sym} 138700 -34570 0 0 {name=p137594 lab=_45063_/X }
C {devices/lab_pin.sym} 138860 -34610 0 1 {name=p137595 lab=_45092_/X }
C {sky130_stdcells/a21o_4.sym} 138780 -34610 0 0 {name=X_45092_ }
C {devices/lab_pin.sym} 138700 -34500 0 0 {name=p137596 lab=_45842_/Y }
C {devices/lab_pin.sym} 138700 -34460 0 0 {name=p137597 lab=_56943_/X }
C {devices/lab_pin.sym} 138700 -34420 0 0 {name=p137598 lab=_57076_/X }
C {devices/lab_pin.sym} 138700 -34380 0 0 {name=p137599 lab=_57077_/Y }
C {devices/lab_pin.sym} 138860 -34440 0 1 {name=p137600 lab=_85092_/D }
C {sky130_stdcells/a22oi_4.sym} 138780 -34440 0 0 {name=X_57078_ }
C {devices/lab_pin.sym} 138740 -34290 0 0 {name=p137601 lab=_48920_/A }
C {devices/lab_pin.sym} 138820 -34290 0 1 {name=p137602 lab=_48920_/Y }
C {sky130_stdcells/inv_2.sym} 138780 -34290 0 0 {name=X_48920_ }
C {devices/lab_pin.sym} 138740 -34170 0 0 {name=p137603 lab=_55133_/A }
C {devices/lab_pin.sym} 138820 -34170 0 1 {name=p137604 lab=_44043_/X }
C {sky130_stdcells/buf_2.sym} 138780 -34170 0 0 {name=X_44043_ }
C {devices/lab_pin.sym} 138740 -34050 0 0 {name=p137605 lab=_56169_/A }
C {devices/lab_pin.sym} 138820 -34050 0 1 {name=p137606 lab=_56029_/X }
C {sky130_stdcells/buf_2.sym} 138780 -34050 0 0 {name=X_56029_ }
C {devices/lab_pin.sym} 138700 -33950 0 0 {name=p137607 lab=_64997_/C }
C {devices/lab_pin.sym} 138700 -33910 0 0 {name=p137608 lab=_72286_/Y }
C {devices/lab_pin.sym} 138700 -33870 0 0 {name=p137609 lab=_79739_/Y }
C {devices/lab_pin.sym} 138860 -33910 0 1 {name=p137610 lab=_79740_/X }
C {sky130_stdcells/o21a_4.sym} 138780 -33910 0 0 {name=X_79740_ }
C {devices/lab_pin.sym} 138740 -33770 0 0 {name=p137611 lab=_41143_/A }
C {devices/lab_pin.sym} 138820 -33770 0 1 {name=p137612 lab=_41255_/X }
C {sky130_stdcells/buf_2.sym} 138780 -33770 0 0 {name=X_41255_ }
C {devices/lab_pin.sym} 138720 -33660 0 0 {name=p137613 lab=_72075_/A }
C {devices/lab_pin.sym} 138720 -33620 0 0 {name=p137614 lab=_53902_/B }
C {devices/lab_pin.sym} 138840 -33640 0 1 {name=p137615 lab=_72075_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -33640 0 0 {name=X_72075_ }
C {devices/lab_pin.sym} 138720 -33520 0 0 {name=p137616 lab=_76948_/Y }
C {devices/lab_pin.sym} 138720 -33480 0 0 {name=p137617 lab=_76952_/B }
C {devices/lab_pin.sym} 138840 -33500 0 1 {name=p137618 lab=_76957_/A }
C {sky130_stdcells/nand2_4.sym} 138780 -33500 0 0 {name=X_76952_ }
C {devices/lab_pin.sym} 138740 -33370 0 0 {name=p137619 lab=_71026_/A }
C {devices/lab_pin.sym} 138820 -33370 0 1 {name=p137620 lab=_71030_/C }
C {sky130_stdcells/buf_2.sym} 138780 -33370 0 0 {name=X_71026_ }
C {devices/lab_pin.sym} 138720 -33260 0 0 {name=p137621 lab=_75903_/A }
C {devices/lab_pin.sym} 138720 -33220 0 0 {name=p137622 lab=_84373_/Q }
C {devices/lab_pin.sym} 138840 -33240 0 1 {name=p137623 lab=_75903_/X }
C {sky130_stdcells/xor2_4.sym} 138780 -33240 0 0 {name=X_75903_ }
C {devices/lab_pin.sym} 138720 -33120 0 0 {name=p137624 lab=_48851_/A }
C {devices/lab_pin.sym} 138720 -33080 0 0 {name=p137625 lab=_48851_/B }
C {devices/lab_pin.sym} 138840 -33100 0 1 {name=p137626 lab=_48851_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -33100 0 0 {name=X_48851_ }
C {devices/lab_pin.sym} 138720 -32980 0 0 {name=p137627 lab=_79671_/A }
C {devices/lab_pin.sym} 138720 -32940 0 0 {name=p137628 lab=_84245_/Q }
C {devices/lab_pin.sym} 138840 -32960 0 1 {name=p137629 lab=_79677_/B }
C {sky130_stdcells/xor2_4.sym} 138780 -32960 0 0 {name=X_79671_ }
C {devices/lab_pin.sym} 138740 -32830 0 0 {name=p137630 lab=_41186_/A }
C {devices/lab_pin.sym} 138820 -32830 0 1 {name=p137631 lab=_41197_/B }
C {sky130_stdcells/buf_2.sym} 138780 -32830 0 0 {name=X_41186_ }
C {devices/lab_pin.sym} 138700 -32730 0 0 {name=p137632 lab=_76873_/Y }
C {devices/lab_pin.sym} 138700 -32690 0 0 {name=p137633 lab=_76874_/Y }
C {devices/lab_pin.sym} 138700 -32650 0 0 {name=p137634 lab=_76882_/Y }
C {devices/lab_pin.sym} 138860 -32690 0 1 {name=p137635 lab=_76888_/C }
C {sky130_stdcells/o21a_4.sym} 138780 -32690 0 0 {name=X_76883_ }
C {devices/lab_pin.sym} 138740 -32550 0 0 {name=p137636 lab=_81220_/Q }
C {devices/lab_pin.sym} 138820 -32550 0 1 {name=p137637 lab=_47803_/A }
C {sky130_stdcells/inv_2.sym} 138780 -32550 0 0 {name=X_47802_ }
C {devices/lab_pin.sym} 138720 -32440 0 0 {name=p137638 lab=_78640_/C }
C {devices/lab_pin.sym} 138720 -32400 0 0 {name=p137639 lab=_78621_/Y }
C {devices/lab_pin.sym} 138840 -32420 0 1 {name=p137640 lab=_78626_/A }
C {sky130_stdcells/nand2_4.sym} 138780 -32420 0 0 {name=X_78622_ }
C {devices/lab_pin.sym} 138700 -32330 0 0 {name=p137641 lab=_75821_/B }
C {devices/lab_pin.sym} 138700 -32290 0 0 {name=p137642 lab=_75821_/A }
C {devices/lab_pin.sym} 138700 -32250 0 0 {name=p137643 lab=_75810_/C }
C {devices/lab_pin.sym} 138700 -32210 0 0 {name=p137644 lab=_75810_/B }
C {devices/lab_pin.sym} 138700 -32170 0 0 {name=p137645 lab=_75833_/Y }
C {devices/lab_pin.sym} 138860 -32250 0 1 {name=p137646 lab=_75834_/X }
C {sky130_stdcells/o41a_4.sym} 138780 -32250 0 0 {name=X_75834_ }
C {devices/lab_pin.sym} 138740 -32090 0 0 {name=p137647 lab=_48837_/A }
C {devices/lab_pin.sym} 138820 -32090 0 1 {name=p137648 lab=_48793_/A }
C {sky130_stdcells/buf_2.sym} 138780 -32090 0 0 {name=X_48782_ }
C {devices/lab_pin.sym} 138740 -31970 0 0 {name=p137649 lab=_45980_/A }
C {devices/lab_pin.sym} 138820 -31970 0 1 {name=p137650 lab=_45994_/X }
C {sky130_stdcells/buf_2.sym} 138780 -31970 0 0 {name=X_45994_ }
C {devices/lab_pin.sym} 138740 -31850 0 0 {name=p137651 lab=_83547_/Q }
C {devices/lab_pin.sym} 138820 -31850 0 1 {name=p137652 lab=_54907_/B }
C {sky130_stdcells/inv_2.sym} 138780 -31850 0 0 {name=X_47733_ }
C {devices/lab_pin.sym} 138700 -31770 0 0 {name=p137653 lab=_59713_/Y }
C {devices/lab_pin.sym} 138700 -31730 0 0 {name=p137654 lab=_59688_/X }
C {devices/lab_pin.sym} 138700 -31690 0 0 {name=p137655 lab=_59689_/Y }
C {devices/lab_pin.sym} 138700 -31650 0 0 {name=p137656 lab=_59717_/Y }
C {devices/lab_pin.sym} 138700 -31620 0 0 {name=p137657 lab=_59718_/Y }
C {devices/lab_pin.sym} 138860 -31690 0 1 {name=p137658 lab=_59719_/Y }
C {sky130_stdcells/a41oi_4.sym} 138780 -31690 0 0 {name=X_59719_ }
C {devices/lab_pin.sym} 138700 -31550 0 0 {name=p137659 lab=_78554_/A }
C {devices/lab_pin.sym} 138700 -31510 0 0 {name=p137660 lab=_78554_/B }
C {devices/lab_pin.sym} 138700 -31470 0 0 {name=p137661 lab=_78552_/Y }
C {devices/lab_pin.sym} 138860 -31510 0 1 {name=p137662 lab=_78557_/B }
C {sky130_stdcells/o21a_4.sym} 138780 -31510 0 0 {name=X_78553_ }
C {devices/lab_pin.sym} 138740 -31370 0 0 {name=p137663 lab=_45827_/B }
C {devices/lab_pin.sym} 138820 -31370 0 1 {name=p137664 lab=_44945_/X }
C {sky130_stdcells/buf_2.sym} 138780 -31370 0 0 {name=X_44945_ }
C {devices/lab_pin.sym} 138700 -31270 0 0 {name=p137665 lab=_75759_/B }
C {devices/lab_pin.sym} 138700 -31230 0 0 {name=p137666 lab=_75759_/A }
C {devices/lab_pin.sym} 138700 -31190 0 0 {name=p137667 lab=_75764_/Y }
C {devices/lab_pin.sym} 138860 -31230 0 1 {name=p137668 lab=_75765_/Y }
C {sky130_stdcells/a21oi_4.sym} 138780 -31230 0 0 {name=X_75765_ }
C {devices/lab_pin.sym} 138700 -31120 0 0 {name=p137669 lab=_42002_/Y }
C {devices/lab_pin.sym} 138700 -31080 0 0 {name=p137670 lab=_72771_/A }
C {devices/lab_pin.sym} 138700 -31040 0 0 {name=p137671 lab=_72889_/X }
C {devices/lab_pin.sym} 138700 -31000 0 0 {name=p137672 lab=_72976_/Y }
C {devices/lab_pin.sym} 138860 -31060 0 1 {name=p137673 lab=_72977_/X }
C {sky130_stdcells/a211o_4.sym} 138780 -31060 0 0 {name=X_72977_ }
C {devices/lab_pin.sym} 138700 -30950 0 0 {name=p137674 lab=_60961_/X }
C {devices/lab_pin.sym} 138700 -30910 0 0 {name=p137675 lab=_60987_/Y }
C {devices/lab_pin.sym} 138700 -30870 0 0 {name=p137676 lab=_60935_/X }
C {devices/lab_pin.sym} 138700 -30830 0 0 {name=p137677 lab=_60989_/X }
C {devices/lab_pin.sym} 138700 -30790 0 0 {name=p137678 lab=_60990_/X }
C {devices/lab_pin.sym} 138860 -30870 0 1 {name=p137679 lab=_84544_/D }
C {sky130_stdcells/o41a_4.sym} 138780 -30870 0 0 {name=X_60991_ }
C {devices/lab_pin.sym} 138700 -30730 0 0 {name=p137680 lab=_77486_/Y }
C {devices/lab_pin.sym} 138700 -30690 0 0 {name=p137681 lab=_77487_/Y }
C {devices/lab_pin.sym} 138700 -30650 0 0 {name=p137682 lab=_77488_/Y }
C {devices/lab_pin.sym} 138860 -30690 0 1 {name=p137683 lab=_77512_/A }
C {sky130_stdcells/o21a_4.sym} 138780 -30690 0 0 {name=X_77504_ }
C {devices/lab_pin.sym} 138740 -30550 0 0 {name=p137684 lab=clkbuf_9_145_0_CLK/X }
C {devices/lab_pin.sym} 138820 -30550 0 1 {name=p137685 lab=_84360_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 138780 -30550 0 0 {name=Xclkbuf_10_291_0_CLK }
C {devices/lab_pin.sym} 138740 -30430 0 0 {name=p137686 lab=clkbuf_6_51_0_CLK/X }
C {devices/lab_pin.sym} 138820 -30430 0 1 {name=p137687 lab=clkbuf_8_207_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 138780 -30430 0 0 {name=Xclkbuf_7_103_0_CLK }
C {devices/lab_pin.sym} 138720 -30340 0 0 {name=p137688 lab=_74716_/A }
C {devices/lab_pin.sym} 138720 -30300 0 0 {name=p137689 lab=_71846_/A }
C {devices/lab_pin.sym} 138720 -30260 0 0 {name=p137690 lab=_70758_/C }
C {devices/lab_pin.sym} 138720 -30220 0 0 {name=p137691 lab=_70730_/X }
C {devices/lab_pin.sym} 138840 -30280 0 1 {name=p137692 lab=_74716_/X }
C {sky130_stdcells/and4_4.sym} 138780 -30280 0 0 {name=X_74716_ }
C {devices/lab_pin.sym} 138740 -30130 0 0 {name=p137693 lab=_62847_/A }
C {devices/lab_pin.sym} 138820 -30130 0 1 {name=p137694 lab=_62731_/A }
C {sky130_stdcells/buf_2.sym} 138780 -30130 0 0 {name=X_62730_ }
C {devices/lab_pin.sym} 138720 -30040 0 0 {name=p137695 lab=_47655_/A }
C {devices/lab_pin.sym} 138720 -30000 0 0 {name=p137696 lab=_47692_/B }
C {devices/lab_pin.sym} 138720 -29960 0 0 {name=p137697 lab=_47692_/C }
C {devices/lab_pin.sym} 138720 -29920 0 0 {name=p137698 lab=_53177_/D }
C {devices/lab_pin.sym} 138840 -29980 0 1 {name=p137699 lab=_47664_/X }
C {sky130_stdcells/and4_4.sym} 138780 -29980 0 0 {name=X_47664_ }
C {devices/lab_pin.sym} 138720 -29860 0 0 {name=p137700 lab=_74527_/A }
C {devices/lab_pin.sym} 138720 -29820 0 0 {name=p137701 lab=_70979_/C }
C {devices/lab_pin.sym} 138720 -29780 0 0 {name=p137702 lab=_71940_/C }
C {devices/lab_pin.sym} 138720 -29740 0 0 {name=p137703 lab=_71928_/D }
C {devices/lab_pin.sym} 138840 -29800 0 1 {name=p137704 lab=_71928_/Y }
C {sky130_stdcells/nand4_4.sym} 138780 -29800 0 0 {name=X_71928_ }
C {devices/lab_pin.sym} 138720 -29660 0 0 {name=p137705 lab=_78472_/A }
C {devices/lab_pin.sym} 138720 -29620 0 0 {name=p137706 lab=_82670_/D }
C {devices/lab_pin.sym} 138840 -29640 0 1 {name=p137707 lab=_78484_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -29640 0 0 {name=X_78484_ }
C {devices/lab_pin.sym} 138700 -29530 0 0 {name=p137708 lab=_56287_/C }
C {devices/lab_pin.sym} 138700 -29490 0 0 {name=p137709 lab=_44874_/X }
C {devices/lab_pin.sym} 138700 -29450 0 0 {name=p137710 lab=_44875_/X }
C {devices/lab_pin.sym} 138860 -29490 0 1 {name=p137711 lab=_44876_/X }
C {sky130_stdcells/o21a_4.sym} 138780 -29490 0 0 {name=X_44876_ }
C {devices/lab_pin.sym} 138720 -29360 0 0 {name=p137712 lab=_75696_/A }
C {devices/lab_pin.sym} 138720 -29320 0 0 {name=p137713 lab=_75695_/Y }
C {devices/lab_pin.sym} 138840 -29340 0 1 {name=p137714 lab=_75696_/X }
C {sky130_stdcells/xor2_4.sym} 138780 -29340 0 0 {name=X_75696_ }
C {devices/lab_pin.sym} 138720 -29220 0 0 {name=p137715 lab=_49410_/A }
C {devices/lab_pin.sym} 138720 -29180 0 0 {name=p137716 lab=_51791_/B }
C {devices/lab_pin.sym} 138840 -29200 0 1 {name=p137717 lab=_49403_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -29200 0 0 {name=X_49403_ }
C {devices/lab_pin.sym} 138740 -29070 0 0 {name=p137718 lab=_46614_/X }
C {devices/lab_pin.sym} 138820 -29070 0 1 {name=p137719 lab=_46647_/B }
C {sky130_stdcells/buf_2.sym} 138780 -29070 0 0 {name=X_46615_ }
C {devices/lab_pin.sym} 138740 -28950 0 0 {name=p137720 lab=_77416_/A }
C {devices/lab_pin.sym} 138820 -28950 0 1 {name=p137721 lab=_77435_/Y }
C {sky130_stdcells/inv_2.sym} 138780 -28950 0 0 {name=X_77435_ }
C {devices/lab_pin.sym} 138700 -28860 0 0 {name=p137722 lab=_41130_/X }
C {devices/lab_pin.sym} 138700 -28820 0 0 {name=p137723 lab=_43817_/X }
C {devices/lab_pin.sym} 138700 -28780 0 0 {name=p137724 lab=_87248_/Q }
C {devices/lab_pin.sym} 138700 -28740 0 0 {name=p137725 lab=_43818_/X }
C {devices/lab_pin.sym} 138860 -28800 0 1 {name=p137726 lab=_43827_/X }
C {sky130_stdcells/a2bb2o_4.sym} 138780 -28800 0 0 {name=X_43827_ }
C {devices/lab_pin.sym} 138720 -28670 0 0 {name=p137727 lab=_62678_/A }
C {devices/lab_pin.sym} 138720 -28630 0 0 {name=p137728 lab=_60273_/X }
C {devices/lab_pin.sym} 138720 -28590 0 0 {name=p137729 lab=_61744_/X }
C {devices/lab_pin.sym} 138840 -28630 0 1 {name=p137730 lab=_62661_/Y }
C {sky130_stdcells/nand3_4.sym} 138780 -28630 0 0 {name=X_62661_ }
C {devices/lab_pin.sym} 138720 -28500 0 0 {name=p137731 lab=_74642_/X }
C {devices/lab_pin.sym} 138720 -28460 0 0 {name=p137732 lab=_45527_/A }
C {devices/lab_pin.sym} 138840 -28480 0 1 {name=p137733 lab=_74647_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -28480 0 0 {name=X_74647_ }
C {devices/lab_pin.sym} 138740 -28350 0 0 {name=p137734 lab=clkbuf_9_36_0_CLK/X }
C {devices/lab_pin.sym} 138820 -28350 0 1 {name=p137735 lab=_86869_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 138780 -28350 0 0 {name=Xclkbuf_10_73_0_CLK }
C {devices/lab_pin.sym} 138720 -28260 0 0 {name=p137736 lab=_47595_/A }
C {devices/lab_pin.sym} 138720 -28220 0 0 {name=p137737 lab=_47595_/B }
C {devices/lab_pin.sym} 138720 -28180 0 0 {name=p137738 lab=_47595_/C }
C {devices/lab_pin.sym} 138720 -28140 0 0 {name=p137739 lab=_53139_/D }
C {devices/lab_pin.sym} 138840 -28200 0 1 {name=p137740 lab=_47595_/X }
C {sky130_stdcells/and4_4.sym} 138780 -28200 0 0 {name=X_47595_ }
C {devices/lab_pin.sym} 138720 -28080 0 0 {name=p137741 lab=_71859_/A }
C {devices/lab_pin.sym} 138720 -28040 0 0 {name=p137742 lab=_71857_/B }
C {devices/lab_pin.sym} 138720 -28000 0 0 {name=p137743 lab=_71851_/X }
C {devices/lab_pin.sym} 138720 -27960 0 0 {name=p137744 lab=_71857_/D }
C {devices/lab_pin.sym} 138840 -28020 0 1 {name=p137745 lab=_71859_/Y }
C {sky130_stdcells/nor4_4.sym} 138780 -28020 0 0 {name=X_71859_ }
C {devices/lab_pin.sym} 138720 -27880 0 0 {name=p137746 lab=_63562_/A }
C {devices/lab_pin.sym} 138720 -27840 0 0 {name=p137747 lab=_61226_/X }
C {devices/lab_pin.sym} 138840 -27860 0 1 {name=p137748 lab=_64400_/Y }
C {sky130_stdcells/nor2_4.sym} 138780 -27860 0 0 {name=X_64400_ }
C {devices/lab_pin.sym} 138720 -27740 0 0 {name=p137749 lab=_84842_/Q }
C {devices/lab_pin.sym} 138720 -27700 0 0 {name=p137750 lab=_61323_/B }
C {devices/lab_pin.sym} 138840 -27720 0 1 {name=p137751 lab=_61613_/A }
C {sky130_stdcells/or2_4.sym} 138780 -27720 0 0 {name=X_61612_ }
C {devices/lab_pin.sym} 138740 -27590 0 0 {name=p137752 lab=_48163_/X }
C {devices/lab_pin.sym} 138820 -27590 0 1 {name=p137753 lab=_49334_/X }
C {sky130_stdcells/buf_2.sym} 138780 -27590 0 0 {name=X_49334_ }
C {devices/lab_pin.sym} 138740 -27470 0 0 {name=p137754 lab=_54069_/B }
C {devices/lab_pin.sym} 138820 -27470 0 1 {name=p137755 lab=_50858_/B }
C {sky130_stdcells/buf_2.sym} 138780 -27470 0 0 {name=X_46546_ }
C {devices/lab_pin.sym} 138740 -27350 0 0 {name=p137756 lab=_65607_/A }
C {devices/lab_pin.sym} 138820 -27350 0 1 {name=p137757 lab=_65548_/B }
C {sky130_stdcells/buf_2.sym} 138780 -27350 0 0 {name=X_65380_ }
C {devices/lab_pin.sym} 138700 -27250 0 0 {name=p137758 lab=_77353_/A }
C {devices/lab_pin.sym} 138700 -27210 0 0 {name=p137759 lab=_82091_/D }
C {devices/lab_pin.sym} 138700 -27170 0 0 {name=p137760 lab=_77360_/C }
C {devices/lab_pin.sym} 138860 -27210 0 1 {name=p137761 lab=_77387_/A }
C {sky130_stdcells/a21boi_4.sym} 138780 -27210 0 0 {name=X_77366_ }
C {devices/lab_pin.sym} 138740 -27070 0 0 {name=p137762 lab=_43757_/Y }
C {devices/lab_pin.sym} 138820 -27070 0 1 {name=p137763 lab=_87281_/D }
C {sky130_stdcells/inv_2.sym} 138780 -27070 0 0 {name=X_43758_ }
C {devices/lab_pin.sym} 138700 -26990 0 0 {name=p137764 lab=_62585_/X }
C {devices/lab_pin.sym} 138700 -26950 0 0 {name=p137765 lab=_62589_/Y }
C {devices/lab_pin.sym} 138700 -26910 0 0 {name=p137766 lab=_62591_/X }
C {devices/lab_pin.sym} 138700 -26870 0 0 {name=p137767 lab=_84870_/Q }
C {devices/lab_pin.sym} 138700 -26830 0 0 {name=p137768 lab=_62572_/X }
C {devices/lab_pin.sym} 138860 -26910 0 1 {name=p137769 lab=_62592_/Y }
C {sky130_stdcells/o32ai_4.sym} 138780 -26910 0 0 {name=X_62592_ }
C {devices/lab_pin.sym} 138700 -26780 0 0 {name=p137770 lab=_74575_/X }
C {devices/lab_pin.sym} 138700 -26740 0 0 {name=p137771 lab=_74569_/X }
C {devices/lab_pin.sym} 138700 -26700 0 0 {name=p137772 lab=_56073_/Y }
C {devices/lab_pin.sym} 138700 -26660 0 0 {name=p137773 lab=_74570_/X }
C {devices/lab_pin.sym} 138860 -26720 0 1 {name=p137774 lab=_74578_/X }
C {sky130_stdcells/a211o_4.sym} 138780 -26720 0 0 {name=X_74578_ }
C {devices/lab_pin.sym} 138740 -26570 0 0 {name=p137775 lab=clkbuf_6_59_0_CLK/X }
C {devices/lab_pin.sym} 138820 -26570 0 1 {name=p137776 lab=clkbuf_8_237_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 138780 -26570 0 0 {name=Xclkbuf_7_118_0_CLK }
C {devices/lab_pin.sym} 138720 -26460 0 0 {name=p137777 lab=_82833_/Q }
C {devices/lab_pin.sym} 138720 -26420 0 0 {name=p137778 lab=_82545_/Q }
C {devices/lab_pin.sym} 138840 -26440 0 1 {name=p137779 lab=_82529_/D }
C {sky130_stdcells/xor2_4.sym} 138780 -26440 0 0 {name=X_79105_ }
C {devices/lab_pin.sym} 138720 -26320 0 0 {name=p137780 lab=_59399_/A }
C {devices/lab_pin.sym} 138720 -26280 0 0 {name=p137781 lab=_64316_/B }
C {devices/lab_pin.sym} 138840 -26300 0 1 {name=p137782 lab=_64331_/Y }
C {sky130_stdcells/nor2_4.sym} 138780 -26300 0 0 {name=X_64331_ }
C {devices/lab_pin.sym} 138720 -26180 0 0 {name=p137783 lab=_76313_/X }
C {devices/lab_pin.sym} 138720 -26140 0 0 {name=p137784 lab=_76317_/B }
C {devices/lab_pin.sym} 138840 -26160 0 1 {name=p137785 lab=_76325_/A }
C {sky130_stdcells/xnor2_4.sym} 138780 -26160 0 0 {name=X_76317_ }
C {devices/lab_pin.sym} 138740 -26030 0 0 {name=p137786 lab=_42709_/A }
C {devices/lab_pin.sym} 138820 -26030 0 1 {name=p137787 lab=_42709_/Y }
C {sky130_stdcells/inv_2.sym} 138780 -26030 0 0 {name=X_42709_ }
C {devices/lab_pin.sym} 138720 -25920 0 0 {name=p137788 lab=_49261_/A }
C {devices/lab_pin.sym} 138720 -25880 0 0 {name=p137789 lab=_49265_/B }
C {devices/lab_pin.sym} 138840 -25900 0 1 {name=p137790 lab=_49265_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -25900 0 0 {name=X_49265_ }
C {devices/lab_pin.sym} 138720 -25800 0 0 {name=p137791 lab=_58438_/A }
C {devices/lab_pin.sym} 138720 -25760 0 0 {name=p137792 lab=_61563_/B }
C {devices/lab_pin.sym} 138720 -25720 0 0 {name=p137793 lab=_61563_/C }
C {devices/lab_pin.sym} 138720 -25680 0 0 {name=p137794 lab=_61514_/D }
C {devices/lab_pin.sym} 138840 -25740 0 1 {name=p137795 lab=_61544_/A }
C {sky130_stdcells/nand4_4.sym} 138780 -25740 0 0 {name=X_61543_ }
C {devices/lab_pin.sym} 138740 -25590 0 0 {name=p137796 lab=_72730_/X }
C {devices/lab_pin.sym} 138820 -25590 0 1 {name=p137797 lab=_73529_/X }
C {sky130_stdcells/buf_2.sym} 138780 -25590 0 0 {name=X_73529_ }
C {devices/lab_pin.sym} 138740 -25470 0 0 {name=p137798 lab=_52522_/B }
C {devices/lab_pin.sym} 138820 -25470 0 1 {name=p137799 lab=_50827_/B }
C {sky130_stdcells/buf_2.sym} 138780 -25470 0 0 {name=X_46477_ }
C {devices/lab_pin.sym} 138720 -25360 0 0 {name=p137800 lab=_77285_/C }
C {devices/lab_pin.sym} 138720 -25320 0 0 {name=p137801 lab=_77279_/Y }
C {devices/lab_pin.sym} 138840 -25340 0 1 {name=p137802 lab=_77297_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -25340 0 0 {name=X_77297_ }
C {devices/lab_pin.sym} 138700 -25240 0 0 {name=p137803 lab=_40802_/X }
C {devices/lab_pin.sym} 138700 -25200 0 0 {name=p137804 lab=_43685_/X }
C {devices/lab_pin.sym} 138700 -25160 0 0 {name=p137805 lab=_72947_/A }
C {devices/lab_pin.sym} 138700 -25120 0 0 {name=p137806 lab=_43686_/X }
C {devices/lab_pin.sym} 138860 -25180 0 1 {name=p137807 lab=_43689_/X }
C {sky130_stdcells/a2bb2o_4.sym} 138780 -25180 0 0 {name=X_43689_ }
C {devices/lab_pin.sym} 138700 -25050 0 0 {name=p137808 lab=_86554_/Q }
C {devices/lab_pin.sym} 138700 -25010 0 0 {name=p137809 lab=_48188_/X }
C {devices/lab_pin.sym} 138700 -24970 0 0 {name=p137810 lab=_48215_/Y }
C {devices/lab_pin.sym} 138860 -25010 0 1 {name=p137811 lab=_48216_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -25010 0 0 {name=X_48216_ }
C {devices/lab_pin.sym} 138700 -24900 0 0 {name=p137812 lab=_87423_/Q }
C {devices/lab_pin.sym} 138700 -24860 0 0 {name=p137813 lab=_66997_/X }
C {devices/lab_pin.sym} 138700 -24820 0 0 {name=p137814 lab=_66998_/X }
C {devices/lab_pin.sym} 138700 -24780 0 0 {name=p137815 lab=_67049_/X }
C {devices/lab_pin.sym} 138860 -24840 0 1 {name=p137816 lab=_67050_/X }
C {sky130_stdcells/a211o_4.sym} 138780 -24840 0 0 {name=X_67050_ }
C {devices/lab_pin.sym} 138720 -24700 0 0 {name=p137817 lab=_79031_/B }
C {devices/lab_pin.sym} 138720 -24660 0 0 {name=p137818 lab=_79029_/Y }
C {devices/lab_pin.sym} 138840 -24680 0 1 {name=p137819 lab=_79037_/C }
C {sky130_stdcells/nand2_4.sym} 138780 -24680 0 0 {name=X_79036_ }
C {devices/lab_pin.sym} 138700 -24570 0 0 {name=p137820 lab=_45424_/X }
C {devices/lab_pin.sym} 138700 -24530 0 0 {name=p137821 lab=_45427_/X }
C {devices/lab_pin.sym} 138700 -24490 0 0 {name=p137822 lab=_45361_/X }
C {devices/lab_pin.sym} 138860 -24530 0 1 {name=p137823 lab=_45428_/X }
C {sky130_stdcells/a21o_4.sym} 138780 -24530 0 0 {name=X_45428_ }
C {devices/lab_pin.sym} 138740 -24390 0 0 {name=p137824 lab=clkbuf_9_44_0_CLK/X }
C {devices/lab_pin.sym} 138820 -24390 0 1 {name=p137825 lab=_84408_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 138780 -24390 0 0 {name=Xclkbuf_10_88_0_CLK }
C {devices/lab_pin.sym} 138720 -24290 0 0 {name=p137826 lab=_64248_/A }
C {devices/lab_pin.sym} 138720 -24250 0 0 {name=p137827 lab=_64248_/B }
C {devices/lab_pin.sym} 138720 -24210 0 0 {name=p137828 lab=_84717_/Q }
C {devices/lab_pin.sym} 138840 -24250 0 1 {name=p137829 lab=_64262_/X }
C {sky130_stdcells/and3_4.sym} 138780 -24250 0 0 {name=X_64262_ }
C {devices/lab_pin.sym} 138740 -24110 0 0 {name=p137830 lab=_81641_/Q }
C {devices/lab_pin.sym} 138820 -24110 0 1 {name=p137831 lab=_76248_/Y }
C {sky130_stdcells/inv_2.sym} 138780 -24110 0 0 {name=X_76248_ }
C {devices/lab_pin.sym} 138740 -23990 0 0 {name=p137832 lab=_61413_/A }
C {devices/lab_pin.sym} 138820 -23990 0 1 {name=p137833 lab=_61518_/A }
C {sky130_stdcells/buf_2.sym} 138780 -23990 0 0 {name=X_61474_ }
C {devices/lab_pin.sym} 138740 -23870 0 0 {name=p137834 lab=_53936_/B }
C {devices/lab_pin.sym} 138820 -23870 0 1 {name=p137835 lab=_50721_/B }
C {sky130_stdcells/buf_2.sym} 138780 -23870 0 0 {name=X_49196_ }
C {devices/lab_pin.sym} 138700 -23770 0 0 {name=p137836 lab=_65700_/X }
C {devices/lab_pin.sym} 138700 -23730 0 0 {name=p137837 lab=_65999_/Y }
C {devices/lab_pin.sym} 138700 -23690 0 0 {name=p137838 lab=_66000_/Y }
C {devices/lab_pin.sym} 138860 -23730 0 1 {name=p137839 lab=_66001_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -23730 0 0 {name=X_66001_ }
C {devices/lab_pin.sym} 138740 -23590 0 0 {name=p137840 lab=_60452_/X }
C {devices/lab_pin.sym} 138820 -23590 0 1 {name=p137841 lab=_63288_/A }
C {sky130_stdcells/buf_2.sym} 138780 -23590 0 0 {name=X_63213_ }
C {devices/lab_pin.sym} 138740 -23470 0 0 {name=p137842 lab=clkbuf_8_235_0_CLK/A }
C {devices/lab_pin.sym} 138820 -23470 0 1 {name=p137843 lab=clkbuf_9_469_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 138780 -23470 0 0 {name=Xclkbuf_8_234_0_CLK }
C {devices/lab_pin.sym} 138700 -23370 0 0 {name=p137844 lab=_48134_/X }
C {devices/lab_pin.sym} 138700 -23330 0 0 {name=p137845 lab=_82915_/Q }
C {devices/lab_pin.sym} 138700 -23290 0 0 {name=p137846 lab=_48146_/X }
C {devices/lab_pin.sym} 138860 -23330 0 1 {name=p137847 lab=_48148_/B }
C {sky130_stdcells/o21ai_4.sym} 138780 -23330 0 0 {name=X_48147_ }
C {devices/lab_pin.sym} 138740 -23190 0 0 {name=p137848 lab=_60420_/A }
C {devices/lab_pin.sym} 138820 -23190 0 1 {name=p137849 lab=_60441_/B }
C {sky130_stdcells/buf_2.sym} 138780 -23190 0 0 {name=X_60425_ }
C {devices/lab_pin.sym} 138700 -23090 0 0 {name=p137850 lab=_56454_/C }
C {devices/lab_pin.sym} 138700 -23050 0 0 {name=p137851 lab=_45326_/X }
C {devices/lab_pin.sym} 138700 -23010 0 0 {name=p137852 lab=_45358_/X }
C {devices/lab_pin.sym} 138860 -23050 0 1 {name=p137853 lab=_45359_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -23050 0 0 {name=X_45359_ }
C {devices/lab_pin.sym} 138720 -22940 0 0 {name=p137854 lab=_64189_/Y }
C {devices/lab_pin.sym} 138720 -22900 0 0 {name=p137855 lab=_64190_/Y }
C {devices/lab_pin.sym} 138720 -22860 0 0 {name=p137856 lab=_64191_/Y }
C {devices/lab_pin.sym} 138720 -22820 0 0 {name=p137857 lab=_64193_/D }
C {devices/lab_pin.sym} 138840 -22880 0 1 {name=p137858 lab=_64193_/X }
C {sky130_stdcells/and4_4.sym} 138780 -22880 0 0 {name=X_64193_ }
C {devices/lab_pin.sym} 138700 -22750 0 0 {name=p137859 lab=_76174_/Y }
C {devices/lab_pin.sym} 138700 -22710 0 0 {name=p137860 lab=_76177_/Y }
C {devices/lab_pin.sym} 138700 -22670 0 0 {name=p137861 lab=_76178_/Y }
C {devices/lab_pin.sym} 138860 -22710 0 1 {name=p137862 lab=_76179_/Y }
C {sky130_stdcells/a21oi_4.sym} 138780 -22710 0 0 {name=X_76179_ }
C {devices/lab_pin.sym} 138740 -22570 0 0 {name=p137863 lab=_60503_/X }
C {devices/lab_pin.sym} 138820 -22570 0 1 {name=p137864 lab=_63144_/X }
C {sky130_stdcells/buf_2.sym} 138780 -22570 0 0 {name=X_63144_ }
C {devices/lab_pin.sym} 138700 -22470 0 0 {name=p137865 lab=_48075_/X }
C {devices/lab_pin.sym} 138700 -22430 0 0 {name=p137866 lab=_82922_/Q }
C {devices/lab_pin.sym} 138700 -22390 0 0 {name=p137867 lab=_48077_/X }
C {devices/lab_pin.sym} 138860 -22430 0 1 {name=p137868 lab=_48079_/B }
C {sky130_stdcells/o21ai_4.sym} 138780 -22430 0 0 {name=X_48078_ }
C {devices/lab_pin.sym} 138740 -22290 0 0 {name=p137869 lab=_60355_/Y }
C {devices/lab_pin.sym} 138820 -22290 0 1 {name=p137870 lab=_60356_/Y }
C {sky130_stdcells/inv_2.sym} 138780 -22290 0 0 {name=X_60356_ }
C {devices/lab_pin.sym} 138740 -22170 0 0 {name=p137871 lab=clkbuf_9_5_0_CLK/X }
C {devices/lab_pin.sym} 138820 -22170 0 1 {name=p137872 lab=_85244_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 138780 -22170 0 0 {name=Xclkbuf_10_11_0_CLK }
C {devices/lab_pin.sym} 138720 -22080 0 0 {name=p137873 lab=_47029_/A }
C {devices/lab_pin.sym} 138720 -22040 0 0 {name=p137874 lab=_47029_/B }
C {devices/lab_pin.sym} 138720 -22000 0 0 {name=p137875 lab=_47029_/C }
C {devices/lab_pin.sym} 138720 -21960 0 0 {name=p137876 lab=_52811_/D }
C {devices/lab_pin.sym} 138840 -22020 0 1 {name=p137877 lab=_47029_/X }
C {sky130_stdcells/and4_4.sym} 138780 -22020 0 0 {name=X_47029_ }
C {devices/lab_pin.sym} 138740 -21870 0 0 {name=p137878 lab=clkbuf_9_351_0_CLK/A }
C {devices/lab_pin.sym} 138820 -21870 0 1 {name=p137879 lab=clkbuf_9_350_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 138780 -21870 0 0 {name=Xclkbuf_9_350_0_CLK }
C {devices/lab_pin.sym} 138700 -21780 0 0 {name=p137880 lab=_87961_/Q }
C {devices/lab_pin.sym} 138700 -21740 0 0 {name=p137881 lab=_67950_/X }
C {devices/lab_pin.sym} 138700 -21700 0 0 {name=p137882 lab=_67879_/X }
C {devices/lab_pin.sym} 138700 -21660 0 0 {name=p137883 lab=_67951_/X }
C {devices/lab_pin.sym} 138860 -21720 0 1 {name=p137884 lab=_67952_/X }
C {sky130_stdcells/a211o_4.sym} 138780 -21720 0 0 {name=X_67952_ }
C {devices/lab_pin.sym} 138720 -21600 0 0 {name=p137885 lab=_63038_/A }
C {devices/lab_pin.sym} 138720 -21560 0 0 {name=p137886 lab=_64284_/B }
C {devices/lab_pin.sym} 138720 -21520 0 0 {name=p137887 lab=_63085_/C }
C {devices/lab_pin.sym} 138720 -21480 0 0 {name=p137888 lab=_63085_/D }
C {devices/lab_pin.sym} 138840 -21540 0 1 {name=p137889 lab=_63075_/X }
C {sky130_stdcells/and4_4.sym} 138780 -21540 0 0 {name=X_63075_ }
C {devices/lab_pin.sym} 138720 -21400 0 0 {name=p137890 lab=_79936_/Y }
C {devices/lab_pin.sym} 138720 -21360 0 0 {name=p137891 lab=_79937_/Y }
C {devices/lab_pin.sym} 138840 -21380 0 1 {name=p137892 lab=_79942_/A }
C {sky130_stdcells/nand2_4.sym} 138780 -21380 0 0 {name=X_79938_ }
C {devices/lab_pin.sym} 138700 -21280 0 0 {name=p137893 lab=_79797_/A }
C {devices/lab_pin.sym} 138700 -21240 0 0 {name=p137894 lab=_59822_/X }
C {devices/lab_pin.sym} 138700 -21200 0 0 {name=p137895 lab=_60284_/Y }
C {devices/lab_pin.sym} 138700 -21160 0 0 {name=p137896 lab=_60286_/X }
C {devices/lab_pin.sym} 138860 -21220 0 1 {name=p137897 lab=_60287_/X }
C {sky130_stdcells/o22a_4.sym} 138780 -21220 0 0 {name=X_60287_ }
C {devices/lab_pin.sym} 138740 -21070 0 0 {name=p137898 lab=clkbuf_8_249_0_CLK/A }
C {devices/lab_pin.sym} 138820 -21070 0 1 {name=p137899 lab=clkbuf_9_499_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 138780 -21070 0 0 {name=Xclkbuf_8_249_0_CLK }
C {devices/lab_pin.sym} 138740 -20950 0 0 {name=p137900 lab=clkbuf_9_122_0_CLK/X }
C {devices/lab_pin.sym} 138820 -20950 0 1 {name=p137901 lab=_84583_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 138780 -20950 0 0 {name=Xclkbuf_10_244_0_CLK }
C {devices/lab_pin.sym} 138720 -20860 0 0 {name=p137902 lab=_50050_/A }
C {devices/lab_pin.sym} 138720 -20820 0 0 {name=p137903 lab=_50040_/B }
C {devices/lab_pin.sym} 138720 -20780 0 0 {name=p137904 lab=_51750_/C }
C {devices/lab_pin.sym} 138720 -20740 0 0 {name=p137905 lab=_53253_/D }
C {devices/lab_pin.sym} 138840 -20800 0 1 {name=p137906 lab=_50040_/X }
C {sky130_stdcells/and4_4.sym} 138780 -20800 0 0 {name=X_50040_ }
C {devices/lab_pin.sym} 138720 -20660 0 0 {name=p137907 lab=_66902_/X }
C {devices/lab_pin.sym} 138720 -20620 0 0 {name=p137908 lab=_86792_/Q }
C {devices/lab_pin.sym} 138840 -20640 0 1 {name=p137909 lab=_66903_/X }
C {sky130_stdcells/and2_4.sym} 138780 -20640 0 0 {name=X_66903_ }
C {devices/lab_pin.sym} 138720 -20540 0 0 {name=p137910 lab=_61558_/B }
C {devices/lab_pin.sym} 138720 -20500 0 0 {name=p137911 lab=_61995_/X }
C {devices/lab_pin.sym} 138720 -20460 0 0 {name=p137912 lab=_62010_/X }
C {devices/lab_pin.sym} 138720 -20420 0 0 {name=p137913 lab=_62011_/X }
C {devices/lab_pin.sym} 138840 -20480 0 1 {name=p137914 lab=_62026_/Y }
C {sky130_stdcells/nand4_4.sym} 138780 -20480 0 0 {name=X_62026_ }
C {devices/lab_pin.sym} 138700 -20360 0 0 {name=p137915 lab=_87388_/Q }
C {devices/lab_pin.sym} 138700 -20320 0 0 {name=p137916 lab=_67834_/X }
C {devices/lab_pin.sym} 138700 -20280 0 0 {name=p137917 lab=_67835_/X }
C {devices/lab_pin.sym} 138700 -20240 0 0 {name=p137918 lab=_67882_/X }
C {devices/lab_pin.sym} 138860 -20300 0 1 {name=p137919 lab=_67883_/X }
C {sky130_stdcells/a211o_4.sym} 138780 -20300 0 0 {name=X_67883_ }
C {devices/lab_pin.sym} 138720 -20160 0 0 {name=p137920 lab=_64663_/C }
C {devices/lab_pin.sym} 138720 -20120 0 0 {name=p137921 lab=_83279_/Q }
C {devices/lab_pin.sym} 138840 -20140 0 1 {name=p137922 lab=_79869_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -20140 0 0 {name=X_79869_ }
C {devices/lab_pin.sym} 138740 -20010 0 0 {name=p137923 lab=clkbuf_9_437_0_CLK/X }
C {devices/lab_pin.sym} 138820 -20010 0 1 {name=p137924 lab=_86235_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 138780 -20010 0 0 {name=Xclkbuf_10_874_0_CLK }
C {devices/lab_pin.sym} 138690 -19890 0 0 {name=p137925 lab=_82104_/CLK }
C {devices/lab_pin.sym} 138690 -19870 0 0 {name=p137926 lab=_77375_/X }
C {devices/lab_pin.sym} 138870 -19890 0 1 {name=p137927 lab=_82276_/D }
C {sky130_stdcells/dfxtp_4.sym} 138780 -19880 0 0 {name=X_81900_ }
C {devices/lab_pin.sym} 138720 -19760 0 0 {name=p137928 lab=_69908_/A }
C {devices/lab_pin.sym} 138720 -19720 0 0 {name=p137929 lab=_69622_/B }
C {devices/lab_pin.sym} 138840 -19740 0 1 {name=p137930 lab=_69622_/Y }
C {sky130_stdcells/nor2_4.sym} 138780 -19740 0 0 {name=X_69622_ }
C {devices/lab_pin.sym} 138740 -19610 0 0 {name=p137931 lab=_66717_/A }
C {devices/lab_pin.sym} 138820 -19610 0 1 {name=p137932 lab=_66834_/X }
C {sky130_stdcells/buf_2.sym} 138780 -19610 0 0 {name=X_66834_ }
C {devices/lab_pin.sym} 138740 -19490 0 0 {name=p137933 lab=clkbuf_9_13_0_CLK/X }
C {devices/lab_pin.sym} 138820 -19490 0 1 {name=p137934 lab=_85138_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 138780 -19490 0 0 {name=Xclkbuf_10_26_0_CLK }
C {devices/lab_pin.sym} 138690 -19370 0 0 {name=p137935 lab=_82368_/CLK }
C {devices/lab_pin.sym} 138690 -19350 0 0 {name=p137936 lab=_82472_/Q }
C {devices/lab_pin.sym} 138870 -19370 0 1 {name=p137937 lab=_82880_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -19360 0 0 {name=X_82880_ }
C {devices/lab_pin.sym} 138740 -19230 0 0 {name=p137938 lab=clkbuf_9_365_0_CLK/A }
C {devices/lab_pin.sym} 138820 -19230 0 1 {name=p137939 lab=clkbuf_9_365_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 138780 -19230 0 0 {name=Xclkbuf_9_365_0_CLK }
C {devices/lab_pin.sym} 138720 -19120 0 0 {name=p137940 lab=_69956_/A }
C {devices/lab_pin.sym} 138720 -19080 0 0 {name=p137941 lab=_69553_/B }
C {devices/lab_pin.sym} 138840 -19100 0 1 {name=p137942 lab=_69553_/X }
C {sky130_stdcells/and2_4.sym} 138780 -19100 0 0 {name=X_69553_ }
C {devices/lab_pin.sym} 138690 -18970 0 0 {name=p137943 lab=_81859_/CLK }
C {devices/lab_pin.sym} 138690 -18950 0 0 {name=p137944 lab=_81863_/Q }
C {devices/lab_pin.sym} 138870 -18970 0 1 {name=p137945 lab=_77294_/A }
C {sky130_stdcells/dfxtp_4.sym} 138780 -18960 0 0 {name=X_81831_ }
C {devices/lab_pin.sym} 138720 -18840 0 0 {name=p137946 lab=_66664_/X }
C {devices/lab_pin.sym} 138720 -18800 0 0 {name=p137947 lab=_66765_/B }
C {devices/lab_pin.sym} 138840 -18820 0 1 {name=p137948 lab=_66765_/X }
C {sky130_stdcells/and2_4.sym} 138780 -18820 0 0 {name=X_66765_ }
C {devices/lab_pin.sym} 138700 -18710 0 0 {name=p137949 lab=_73827_/B }
C {devices/lab_pin.sym} 138700 -18670 0 0 {name=p137950 lab=_51960_/X }
C {devices/lab_pin.sym} 138700 -18630 0 0 {name=p137951 lab=_51990_/Y }
C {devices/lab_pin.sym} 138860 -18670 0 1 {name=p137952 lab=_51991_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -18670 0 0 {name=X_51991_ }
C {devices/lab_pin.sym} 138700 -18550 0 0 {name=p137953 lab=_63975_/X }
C {devices/lab_pin.sym} 138700 -18510 0 0 {name=p137954 lab=_63913_/X }
C {devices/lab_pin.sym} 138700 -18470 0 0 {name=p137955 lab=_63976_/Y }
C {devices/lab_pin.sym} 138860 -18510 0 1 {name=p137956 lab=_63977_/Y }
C {sky130_stdcells/a21oi_4.sym} 138780 -18510 0 0 {name=X_63977_ }
C {devices/lab_pin.sym} 138740 -18370 0 0 {name=p137957 lab=clkbuf_9_129_0_CLK/X }
C {devices/lab_pin.sym} 138820 -18370 0 1 {name=p137958 lab=_84877_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 138780 -18370 0 0 {name=Xclkbuf_10_259_0_CLK }
C {devices/lab_pin.sym} 138740 -18250 0 0 {name=p137959 lab=_68757_/A }
C {devices/lab_pin.sym} 138820 -18250 0 1 {name=p137960 lab=_68504_/X }
C {sky130_stdcells/buf_2.sym} 138780 -18250 0 0 {name=X_68504_ }
C {devices/lab_pin.sym} 138740 -18130 0 0 {name=p137961 lab=_53755_/A }
C {devices/lab_pin.sym} 138820 -18130 0 1 {name=p137962 lab=_53750_/A }
C {sky130_stdcells/buf_2.sym} 138780 -18130 0 0 {name=X_53730_ }
C {devices/lab_pin.sym} 138700 -18040 0 0 {name=p137963 lab=_65623_/X }
C {devices/lab_pin.sym} 138700 -18000 0 0 {name=p137964 lab=_86190_/Q }
C {devices/lab_pin.sym} 138700 -17960 0 0 {name=p137965 lab=_65517_/X }
C {devices/lab_pin.sym} 138700 -17920 0 0 {name=p137966 lab=_65715_/X }
C {devices/lab_pin.sym} 138860 -17980 0 1 {name=p137967 lab=_65716_/X }
C {sky130_stdcells/a211o_4.sym} 138780 -17980 0 0 {name=X_65716_ }
C {devices/lab_pin.sym} 138690 -17830 0 0 {name=p137968 lab=_84293_/CLK }
C {devices/lab_pin.sym} 138690 -17810 0 0 {name=p137969 lab=_60932_/Y }
C {devices/lab_pin.sym} 138870 -17830 0 1 {name=p137970 lab=_60931_/C }
C {sky130_stdcells/dfxtp_4.sym} 138780 -17820 0 0 {name=X_84550_ }
C {devices/lab_pin.sym} 138700 -17710 0 0 {name=p137971 lab=_50940_/Y }
C {devices/lab_pin.sym} 138700 -17670 0 0 {name=p137972 lab=_50928_/X }
C {devices/lab_pin.sym} 138700 -17630 0 0 {name=p137973 lab=_50941_/X }
C {devices/lab_pin.sym} 138860 -17670 0 1 {name=p137974 lab=_50942_/Y }
C {sky130_stdcells/a21oi_4.sym} 138780 -17670 0 0 {name=X_50942_ }
C {devices/lab_pin.sym} 138720 -17560 0 0 {name=p137975 lab=_60337_/A }
C {devices/lab_pin.sym} 138720 -17520 0 0 {name=p137976 lab=_62949_/B }
C {devices/lab_pin.sym} 138720 -17480 0 0 {name=p137977 lab=_62928_/C }
C {devices/lab_pin.sym} 138720 -17440 0 0 {name=p137978 lab=_62928_/D }
C {devices/lab_pin.sym} 138840 -17500 0 1 {name=p137979 lab=_62928_/Y }
C {sky130_stdcells/nand4_4.sym} 138780 -17500 0 0 {name=X_62928_ }
C {devices/lab_pin.sym} 138690 -17350 0 0 {name=p137980 lab=_86582_/CLK }
C {devices/lab_pin.sym} 138690 -17330 0 0 {name=p137981 lab=_81762_/D }
C {devices/lab_pin.sym} 138870 -17350 0 1 {name=p137982 lab=_81762_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -17340 0 0 {name=X_81762_ }
C {devices/lab_pin.sym} 138700 -17230 0 0 {name=p137983 lab=_69481_/X }
C {devices/lab_pin.sym} 138700 -17190 0 0 {name=p137984 lab=_69483_/X }
C {devices/lab_pin.sym} 138700 -17150 0 0 {name=p137985 lab=_69385_/X }
C {devices/lab_pin.sym} 138860 -17190 0 1 {name=p137986 lab=_69484_/X }
C {sky130_stdcells/a21o_4.sym} 138780 -17190 0 0 {name=X_69484_ }
C {devices/lab_pin.sym} 138740 -17050 0 0 {name=p137987 lab=clkbuf_9_444_0_CLK/X }
C {devices/lab_pin.sym} 138820 -17050 0 1 {name=p137988 lab=_86045_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 138780 -17050 0 0 {name=Xclkbuf_10_889_0_CLK }
C {devices/lab_pin.sym} 138720 -16940 0 0 {name=p137989 lab=_66693_/X }
C {devices/lab_pin.sym} 138720 -16900 0 0 {name=p137990 lab=_66695_/X }
C {devices/lab_pin.sym} 138840 -16920 0 1 {name=p137991 lab=_66696_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -16920 0 0 {name=X_66696_ }
C {devices/lab_pin.sym} 138690 -16790 0 0 {name=p137992 lab=_83498_/CLK }
C {devices/lab_pin.sym} 138690 -16770 0 0 {name=p137993 lab=_71433_/X }
C {devices/lab_pin.sym} 138870 -16790 0 1 {name=p137994 lab=_83501_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -16780 0 0 {name=X_83501_ }
C {devices/lab_pin.sym} 138700 -16670 0 0 {name=p137995 lab=_83975_/Q }
C {devices/lab_pin.sym} 138700 -16630 0 0 {name=p137996 lab=_68338_/X }
C {devices/lab_pin.sym} 138700 -16590 0 0 {name=p137997 lab=_68434_/X }
C {devices/lab_pin.sym} 138860 -16630 0 1 {name=p137998 lab=_68435_/X }
C {sky130_stdcells/a21bo_4.sym} 138780 -16630 0 0 {name=X_68435_ }
C {devices/lab_pin.sym} 138690 -16490 0 0 {name=p137999 lab=_80679_/CLK }
C {devices/lab_pin.sym} 138690 -16470 0 0 {name=p138000 lab=_75899_/X }
C {devices/lab_pin.sym} 138870 -16490 0 1 {name=p138001 lab=_80681_/D }
C {sky130_stdcells/dfxtp_4.sym} 138780 -16480 0 0 {name=X_80713_ }
C {devices/lab_pin.sym} 138740 -16350 0 0 {name=p138002 lab=_53661_/A }
C {devices/lab_pin.sym} 138820 -16350 0 1 {name=p138003 lab=_53755_/A }
C {sky130_stdcells/buf_2.sym} 138780 -16350 0 0 {name=X_53661_ }
C {devices/lab_pin.sym} 138720 -16250 0 0 {name=p138004 lab=_64990_/X }
C {devices/lab_pin.sym} 138720 -16210 0 0 {name=p138005 lab=_65647_/B }
C {devices/lab_pin.sym} 138720 -16170 0 0 {name=p138006 lab=_64993_/X }
C {devices/lab_pin.sym} 138840 -16210 0 1 {name=p138007 lab=_65647_/Y }
C {sky130_stdcells/nand3_4.sym} 138780 -16210 0 0 {name=X_65647_ }
C {devices/lab_pin.sym} 138690 -16070 0 0 {name=p138008 lab=_84481_/CLK }
C {devices/lab_pin.sym} 138690 -16050 0 0 {name=p138009 lab=_61435_/Y }
C {devices/lab_pin.sym} 138870 -16070 0 1 {name=p138010 lab=_61434_/C }
C {sky130_stdcells/dfxtp_4.sym} 138780 -16060 0 0 {name=X_84481_ }
C {devices/lab_pin.sym} 138700 -15950 0 0 {name=p138011 lab=_50871_/Y }
C {devices/lab_pin.sym} 138700 -15910 0 0 {name=p138012 lab=_50243_/X }
C {devices/lab_pin.sym} 138700 -15870 0 0 {name=p138013 lab=_50872_/Y }
C {devices/lab_pin.sym} 138860 -15910 0 1 {name=p138014 lab=_50873_/Y }
C {sky130_stdcells/a21boi_4.sym} 138780 -15910 0 0 {name=X_50873_ }
C {devices/lab_pin.sym} 138740 -15770 0 0 {name=p138015 lab=_62681_/X }
C {devices/lab_pin.sym} 138820 -15770 0 1 {name=p138016 lab=_62859_/X }
C {sky130_stdcells/buf_2.sym} 138780 -15770 0 0 {name=X_62859_ }
C {devices/lab_pin.sym} 138690 -15650 0 0 {name=p138017 lab=_81269_/CLK }
C {devices/lab_pin.sym} 138690 -15630 0 0 {name=p138018 lab=_80211_/X }
C {devices/lab_pin.sym} 138870 -15650 0 1 {name=p138019 lab=_81693_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -15640 0 0 {name=X_81693_ }
C {devices/lab_pin.sym} 138740 -15510 0 0 {name=p138020 lab=_55400_/A }
C {devices/lab_pin.sym} 138820 -15510 0 1 {name=p138021 lab=_55400_/Y }
C {sky130_stdcells/inv_2.sym} 138780 -15510 0 0 {name=X_55400_ }
C {devices/lab_pin.sym} 138690 -15390 0 0 {name=p138022 lab=_86570_/CLK }
C {devices/lab_pin.sym} 138690 -15370 0 0 {name=p138023 lab=_86220_/D }
C {devices/lab_pin.sym} 138870 -15390 0 1 {name=p138024 lab=_86220_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -15380 0 0 {name=X_86220_ }
C {devices/lab_pin.sym} 138720 -15260 0 0 {name=p138025 lab=_52624_/A }
C {devices/lab_pin.sym} 138720 -15220 0 0 {name=p138026 lab=_46685_/A }
C {devices/lab_pin.sym} 138840 -15240 0 1 {name=p138027 lab=_52612_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -15240 0 0 {name=X_52612_ }
C {devices/lab_pin.sym} 138690 -15110 0 0 {name=p138028 lab=_83431_/CLK }
C {devices/lab_pin.sym} 138690 -15090 0 0 {name=p138029 lab=_71633_/Y }
C {devices/lab_pin.sym} 138870 -15110 0 1 {name=p138030 lab=_83432_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -15100 0 0 {name=X_83432_ }
C {devices/lab_pin.sym} 138700 -14990 0 0 {name=p138031 lab=_56005_/X }
C {devices/lab_pin.sym} 138700 -14950 0 0 {name=p138032 lab=_56378_/X }
C {devices/lab_pin.sym} 138700 -14910 0 0 {name=p138033 lab=_56379_/Y }
C {devices/lab_pin.sym} 138860 -14950 0 1 {name=p138034 lab=_56380_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -14950 0 0 {name=X_56380_ }
C {devices/lab_pin.sym} 138740 -14800 0 0 {name=p138035 lab=_80644_/A }
C {devices/lab_pin.sym} 138740 -14760 0 0 {name=p138036 lab=_74708_/Y }
C {devices/lab_pin.sym} 138820 -14800 0 1 {name=p138037 lab=DATA_FROM_HASH[1] }
C {sky130_stdcells/ebufn_2.sym} 138780 -14800 0 0 {name=X_80644_ }
C {devices/lab_pin.sym} 138740 -14670 0 0 {name=p138038 lab=_57803_/A }
C {devices/lab_pin.sym} 138820 -14670 0 1 {name=p138039 lab=_68366_/X }
C {sky130_stdcells/buf_2.sym} 138780 -14670 0 0 {name=X_68366_ }
C {devices/lab_pin.sym} 138700 -14570 0 0 {name=p138040 lab=_53589_/Y }
C {devices/lab_pin.sym} 138700 -14530 0 0 {name=p138041 lab=_53574_/X }
C {devices/lab_pin.sym} 138700 -14490 0 0 {name=p138042 lab=_53591_/Y }
C {devices/lab_pin.sym} 138860 -14530 0 1 {name=p138043 lab=_85607_/D }
C {sky130_stdcells/a21boi_4.sym} 138780 -14530 0 0 {name=X_53592_ }
C {devices/lab_pin.sym} 138720 -14400 0 0 {name=p138044 lab=_65731_/A }
C {devices/lab_pin.sym} 138720 -14360 0 0 {name=p138045 lab=_73040_/B }
C {devices/lab_pin.sym} 138840 -14380 0 1 {name=p138046 lab=_65578_/X }
C {sky130_stdcells/and2_4.sym} 138780 -14380 0 0 {name=X_65578_ }
C {devices/lab_pin.sym} 138740 -14250 0 0 {name=p138047 lab=clkbuf_9_406_0_CLK/X }
C {devices/lab_pin.sym} 138820 -14250 0 1 {name=p138048 lab=_82859_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 138780 -14250 0 0 {name=Xclkbuf_10_812_0_CLK }
C {devices/lab_pin.sym} 138720 -14140 0 0 {name=p138049 lab=_55329_/Y }
C {devices/lab_pin.sym} 138720 -14100 0 0 {name=p138050 lab=_55330_/X }
C {devices/lab_pin.sym} 138840 -14120 0 1 {name=p138051 lab=_55356_/A }
C {sky130_stdcells/nand2_4.sym} 138780 -14120 0 0 {name=X_55331_ }
C {devices/lab_pin.sym} 138720 -14000 0 0 {name=p138052 lab=_67248_/A }
C {devices/lab_pin.sym} 138720 -13960 0 0 {name=p138053 lab=_87668_/Q }
C {devices/lab_pin.sym} 138840 -13980 0 1 {name=p138054 lab=_67317_/X }
C {sky130_stdcells/and2_4.sym} 138780 -13980 0 0 {name=X_67317_ }
C {devices/lab_pin.sym} 138690 -13850 0 0 {name=p138055 lab=_85542_/CLK }
C {devices/lab_pin.sym} 138690 -13830 0 0 {name=p138056 lab=_86151_/D }
C {devices/lab_pin.sym} 138870 -13850 0 1 {name=p138057 lab=_86151_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -13840 0 0 {name=X_86151_ }
C {devices/lab_pin.sym} 138720 -13720 0 0 {name=p138058 lab=_52542_/X }
C {devices/lab_pin.sym} 138720 -13680 0 0 {name=p138059 lab=_50850_/B }
C {devices/lab_pin.sym} 138840 -13700 0 1 {name=p138060 lab=_52543_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -13700 0 0 {name=X_52543_ }
C {sky130_stdcells/decap_3.sym} 138780 -13540 0 0 {name=XPHY_206 }
C {devices/lab_pin.sym} 138700 -13410 0 0 {name=p138061 lab=_64522_/Y }
C {devices/lab_pin.sym} 138700 -13370 0 0 {name=p138062 lab=_64528_/X }
C {devices/lab_pin.sym} 138700 -13330 0 0 {name=p138063 lab=_60074_/X }
C {devices/lab_pin.sym} 138860 -13370 0 1 {name=p138064 lab=_64529_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -13370 0 0 {name=X_64529_ }
C {devices/lab_pin.sym} 138690 -13230 0 0 {name=p138065 lab=_83362_/CLK }
C {devices/lab_pin.sym} 138690 -13210 0 0 {name=p138066 lab=_83363_/D }
C {devices/lab_pin.sym} 138870 -13230 0 1 {name=p138067 lab=_83363_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -13220 0 0 {name=X_83363_ }
C {devices/lab_pin.sym} 138720 -13100 0 0 {name=p138068 lab=_80570_/Y }
C {devices/lab_pin.sym} 138720 -13060 0 0 {name=p138069 lab=_80574_/Y }
C {devices/lab_pin.sym} 138840 -13080 0 1 {name=p138070 lab=_82268_/D }
C {sky130_stdcells/xor2_4.sym} 138780 -13080 0 0 {name=X_80575_ }
C {devices/lab_pin.sym} 138700 -12980 0 0 {name=p138071 lab=_68272_/X }
C {devices/lab_pin.sym} 138700 -12940 0 0 {name=p138072 lab=_67815_/Y }
C {devices/lab_pin.sym} 138700 -12900 0 0 {name=p138073 lab=_68287_/X }
C {devices/lab_pin.sym} 138700 -12860 0 0 {name=p138074 lab=_68296_/Y }
C {devices/lab_pin.sym} 138860 -12920 0 1 {name=p138075 lab=_68297_/X }
C {sky130_stdcells/a211o_4.sym} 138780 -12920 0 0 {name=X_68297_ }
C {sky130_stdcells/decap_3.sym} 138780 -12740 0 0 {name=XPHY_217 }
C {sky130_stdcells/decap_3.sym} 138780 -12560 0 0 {name=XPHY_228 }
C {sky130_stdcells/decap_3.sym} 138780 -12380 0 0 {name=XPHY_239 }
C {devices/lab_pin.sym} 138690 -12230 0 0 {name=p138076 lab=_85039_/CLK }
C {devices/lab_pin.sym} 138690 -12210 0 0 {name=p138077 lab=_85102_/D }
C {devices/lab_pin.sym} 138870 -12230 0 1 {name=p138078 lab=_85102_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -12220 0 0 {name=X_85102_ }
C {devices/lab_pin.sym} 138740 -12090 0 0 {name=p138079 lab=clkbuf_9_303_0_CLK/A }
C {devices/lab_pin.sym} 138820 -12090 0 1 {name=p138080 lab=clkbuf_9_303_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 138780 -12090 0 0 {name=Xclkbuf_9_303_0_CLK }
C {devices/lab_pin.sym} 138700 -11990 0 0 {name=p138081 lab=_57983_/X }
C {devices/lab_pin.sym} 138700 -11950 0 0 {name=p138082 lab=_85385_/Q }
C {devices/lab_pin.sym} 138700 -11910 0 0 {name=p138083 lab=_58049_/X }
C {devices/lab_pin.sym} 138860 -11950 0 1 {name=p138084 lab=_58050_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -11950 0 0 {name=X_58050_ }
C {devices/lab_pin.sym} 138690 -11810 0 0 {name=p138085 lab=_81179_/CLK }
C {devices/lab_pin.sym} 138690 -11790 0 0 {name=p138086 lab=_77060_/B }
C {devices/lab_pin.sym} 138870 -11810 0 1 {name=p138087 lab=_82314_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -11800 0 0 {name=X_82314_ }
C {devices/lab_pin.sym} 138720 -11680 0 0 {name=p138088 lab=_67248_/A }
C {devices/lab_pin.sym} 138720 -11640 0 0 {name=p138089 lab=_67248_/B }
C {devices/lab_pin.sym} 138840 -11660 0 1 {name=p138090 lab=_67248_/X }
C {sky130_stdcells/and2_4.sym} 138780 -11660 0 0 {name=X_67248_ }
C {devices/lab_pin.sym} 138700 -11560 0 0 {name=p138091 lab=_82985_/Q }
C {devices/lab_pin.sym} 138700 -11520 0 0 {name=p138092 lab=_44059_/A }
C {devices/lab_pin.sym} 138700 -11480 0 0 {name=p138093 lab=_55140_/X }
C {devices/lab_pin.sym} 138700 -11440 0 0 {name=p138094 lab=_55261_/X }
C {devices/lab_pin.sym} 138860 -11500 0 1 {name=p138095 lab=_55264_/C }
C {sky130_stdcells/a211o_4.sym} 138780 -11500 0 0 {name=X_55262_ }
C {devices/lab_pin.sym} 138690 -11350 0 0 {name=p138096 lab=_85764_/CLK }
C {devices/lab_pin.sym} 138690 -11330 0 0 {name=p138097 lab=_51057_/Y }
C {devices/lab_pin.sym} 138870 -11350 0 1 {name=p138098 lab=_86082_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -11340 0 0 {name=X_86082_ }
C {devices/lab_pin.sym} 138720 -11220 0 0 {name=p138099 lab=_52468_/A }
C {devices/lab_pin.sym} 138720 -11180 0 0 {name=p138100 lab=_53993_/B }
C {devices/lab_pin.sym} 138840 -11200 0 1 {name=p138101 lab=_52474_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -11200 0 0 {name=X_52474_ }
C {devices/lab_pin.sym} 138690 -11070 0 0 {name=p138102 lab=_85536_/CLK }
C {devices/lab_pin.sym} 138690 -11050 0 0 {name=p138103 lab=_83294_/D }
C {devices/lab_pin.sym} 138870 -11070 0 1 {name=p138104 lab=_83294_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -11060 0 0 {name=X_83294_ }
C {devices/lab_pin.sym} 138740 -10930 0 0 {name=p138105 lab=_57001_/A }
C {devices/lab_pin.sym} 138820 -10930 0 1 {name=p138106 lab=_85103_/D }
C {sky130_stdcells/inv_2.sym} 138780 -10930 0 0 {name=X_57001_ }
C {devices/lab_pin.sym} 138720 -10840 0 0 {name=p138107 lab=_54208_/X }
C {devices/lab_pin.sym} 138720 -10800 0 0 {name=p138108 lab=_54191_/B }
C {devices/lab_pin.sym} 138720 -10760 0 0 {name=p138109 lab=_54209_/C }
C {devices/lab_pin.sym} 138720 -10720 0 0 {name=p138110 lab=_53048_/D }
C {devices/lab_pin.sym} 138840 -10780 0 1 {name=p138111 lab=_54213_/X }
C {sky130_stdcells/and4_4.sym} 138780 -10780 0 0 {name=X_54213_ }
C {devices/lab_pin.sym} 138690 -10630 0 0 {name=p138112 lab=_83335_/CLK }
C {devices/lab_pin.sym} 138690 -10610 0 0 {name=p138113 lab=_85033_/D }
C {devices/lab_pin.sym} 138870 -10630 0 1 {name=p138114 lab=_85033_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -10620 0 0 {name=X_85033_ }
C {devices/lab_pin.sym} 138700 -10510 0 0 {name=p138115 lab=_86012_/Q }
C {devices/lab_pin.sym} 138700 -10470 0 0 {name=p138116 lab=_51402_/X }
C {devices/lab_pin.sym} 138700 -10430 0 0 {name=p138117 lab=_51424_/Y }
C {devices/lab_pin.sym} 138860 -10470 0 1 {name=p138118 lab=_51425_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -10470 0 0 {name=X_51425_ }
C {devices/lab_pin.sym} 138690 -10330 0 0 {name=p138119 lab=_82263_/CLK }
C {devices/lab_pin.sym} 138690 -10310 0 0 {name=p138120 lab=_80322_/X }
C {devices/lab_pin.sym} 138870 -10330 0 1 {name=p138121 lab=_82245_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -10320 0 0 {name=X_82245_ }
C {devices/lab_pin.sym} 138700 -10220 0 0 {name=p138122 lab=_82989_/Q }
C {devices/lab_pin.sym} 138700 -10180 0 0 {name=p138123 lab=_55190_/X }
C {devices/lab_pin.sym} 138700 -10140 0 0 {name=p138124 lab=_44095_/A }
C {devices/lab_pin.sym} 138700 -10100 0 0 {name=p138125 lab=_55192_/X }
C {devices/lab_pin.sym} 138860 -10160 0 1 {name=p138126 lab=_55193_/X }
C {sky130_stdcells/a211o_4.sym} 138780 -10160 0 0 {name=X_55193_ }
C {devices/lab_pin.sym} 138720 -10020 0 0 {name=p138127 lab=_67133_/A }
C {devices/lab_pin.sym} 138720 -9980 0 0 {name=p138128 lab=_67179_/B }
C {devices/lab_pin.sym} 138840 -10000 0 1 {name=p138129 lab=_67179_/X }
C {sky130_stdcells/and2_4.sym} 138780 -10000 0 0 {name=X_67179_ }
C {devices/lab_pin.sym} 138740 -9870 0 0 {name=p138130 lab=clkbuf_9_413_0_CLK/X }
C {devices/lab_pin.sym} 138820 -9870 0 1 {name=p138131 lab=_82369_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 138780 -9870 0 0 {name=Xclkbuf_10_827_0_CLK }
C {devices/lab_pin.sym} 138740 -9750 0 0 {name=p138132 lab=_53436_/X }
C {devices/lab_pin.sym} 138820 -9750 0 1 {name=p138133 lab=_54144_/X }
C {sky130_stdcells/buf_2.sym} 138780 -9750 0 0 {name=X_54144_ }
C {devices/lab_pin.sym} 138720 -9640 0 0 {name=p138134 lab=_51306_/X }
C {devices/lab_pin.sym} 138720 -9600 0 0 {name=p138135 lab=_51356_/B }
C {devices/lab_pin.sym} 138840 -9620 0 1 {name=p138136 lab=_51356_/X }
C {sky130_stdcells/and2_4.sym} 138780 -9620 0 0 {name=X_51356_ }
C {devices/lab_pin.sym} 138720 -9520 0 0 {name=p138137 lab=_70200_/A }
C {devices/lab_pin.sym} 138720 -9480 0 0 {name=p138138 lab=_70200_/B }
C {devices/lab_pin.sym} 138720 -9440 0 0 {name=p138139 lab=_83203_/Q }
C {devices/lab_pin.sym} 138720 -9400 0 0 {name=p138140 lab=_70200_/D }
C {devices/lab_pin.sym} 138840 -9460 0 1 {name=p138141 lab=_70190_/X }
C {sky130_stdcells/and4_4.sym} 138780 -9460 0 0 {name=X_70190_ }
C {devices/lab_pin.sym} 138690 -9310 0 0 {name=p138142 lab=_84115_/CLK }
C {devices/lab_pin.sym} 138690 -9290 0 0 {name=p138143 lab=_84168_/Q }
C {devices/lab_pin.sym} 138870 -9310 0 1 {name=p138144 lab=_82176_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -9300 0 0 {name=X_82176_ }
C {devices/lab_pin.sym} 138740 -9170 0 0 {name=p138145 lab=clkbuf_9_318_0_CLK/A }
C {devices/lab_pin.sym} 138820 -9170 0 1 {name=p138146 lab=clkbuf_9_318_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 138780 -9170 0 0 {name=Xclkbuf_9_318_0_CLK }
C {devices/lab_pin.sym} 138700 -9070 0 0 {name=p138147 lab=_86226_/Q }
C {devices/lab_pin.sym} 138700 -9030 0 0 {name=p138148 lab=_50238_/X }
C {devices/lab_pin.sym} 138700 -8990 0 0 {name=p138149 lab=_50306_/Y }
C {devices/lab_pin.sym} 138860 -9030 0 1 {name=p138150 lab=_50307_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -9030 0 0 {name=X_50307_ }
C {devices/lab_pin.sym} 138690 -8890 0 0 {name=p138151 lab=_81125_/CLK }
C {devices/lab_pin.sym} 138690 -8870 0 0 {name=p138152 lab=_81127_/D }
C {devices/lab_pin.sym} 138870 -8890 0 1 {name=p138153 lab=_40732_/A }
C {sky130_stdcells/dfxtp_4.sym} 138780 -8880 0 0 {name=X_81127_ }
C {devices/lab_pin.sym} 138720 -8760 0 0 {name=p138154 lab=_58941_/A }
C {devices/lab_pin.sym} 138720 -8720 0 0 {name=p138155 lab=_86371_/Q }
C {devices/lab_pin.sym} 138840 -8740 0 1 {name=p138156 lab=_58952_/Y }
C {sky130_stdcells/nor2_4.sym} 138780 -8740 0 0 {name=X_58952_ }
C {devices/lab_pin.sym} 138720 -8620 0 0 {name=p138157 lab=_53801_/B }
C {devices/lab_pin.sym} 138720 -8580 0 0 {name=p138158 lab=_54075_/B }
C {devices/lab_pin.sym} 138840 -8600 0 1 {name=p138159 lab=_54075_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -8600 0 0 {name=X_54075_ }
C {devices/lab_pin.sym} 138720 -8480 0 0 {name=p138160 lab=_51296_/A }
C {devices/lab_pin.sym} 138720 -8440 0 0 {name=p138161 lab=_50777_/B }
C {devices/lab_pin.sym} 138840 -8460 0 1 {name=p138162 lab=_51287_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -8460 0 0 {name=X_51287_ }
C {devices/lab_pin.sym} 138690 -8330 0 0 {name=p138163 lab=_86984_/CLK }
C {devices/lab_pin.sym} 138690 -8310 0 0 {name=p138164 lab=_86984_/D }
C {devices/lab_pin.sym} 138870 -8330 0 1 {name=p138165 lab=_44727_/A }
C {sky130_stdcells/dfxtp_4.sym} 138780 -8320 0 0 {name=X_86984_ }
C {devices/lab_pin.sym} 138740 -8190 0 0 {name=p138166 lab=_40999_/A }
C {devices/lab_pin.sym} 138820 -8190 0 1 {name=p138167 lab=_41040_/X }
C {sky130_stdcells/buf_2.sym} 138780 -8190 0 0 {name=X_41040_ }
C {devices/lab_pin.sym} 138700 -8090 0 0 {name=p138168 lab=_85710_/Q }
C {devices/lab_pin.sym} 138700 -8050 0 0 {name=p138169 lab=_53010_/X }
C {devices/lab_pin.sym} 138700 -8010 0 0 {name=p138170 lab=_53025_/Y }
C {devices/lab_pin.sym} 138860 -8050 0 1 {name=p138171 lab=_53026_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -8050 0 0 {name=X_53026_ }
C {devices/lab_pin.sym} 138740 -7910 0 0 {name=p138172 lab=_58605_/A }
C {devices/lab_pin.sym} 138820 -7910 0 1 {name=p138173 lab=_57903_/X }
C {sky130_stdcells/buf_2.sym} 138780 -7910 0 0 {name=X_57903_ }
C {devices/lab_pin.sym} 138740 -7790 0 0 {name=p138174 lab=_50464_/A }
C {devices/lab_pin.sym} 138820 -7790 0 1 {name=p138175 lab=_50238_/X }
C {sky130_stdcells/buf_2.sym} 138780 -7790 0 0 {name=X_50238_ }
C {devices/lab_pin.sym} 138690 -7670 0 0 {name=p138176 lab=_86096_/CLK }
C {devices/lab_pin.sym} 138690 -7650 0 0 {name=p138177 lab=_51852_/Y }
C {devices/lab_pin.sym} 138870 -7670 0 1 {name=p138178 lab=_85935_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -7660 0 0 {name=X_85935_ }
C {devices/lab_pin.sym} 138690 -7530 0 0 {name=p138179 lab=_81059_/CLK }
C {devices/lab_pin.sym} 138690 -7510 0 0 {name=p138180 lab=_81090_/Q }
C {devices/lab_pin.sym} 138870 -7530 0 1 {name=p138181 lab=_81058_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -7520 0 0 {name=X_81058_ }
C {devices/lab_pin.sym} 138740 -7390 0 0 {name=p138182 lab=_59053_/A }
C {devices/lab_pin.sym} 138820 -7390 0 1 {name=p138183 lab=_58883_/X }
C {sky130_stdcells/buf_2.sym} 138780 -7390 0 0 {name=X_58883_ }
C {devices/lab_pin.sym} 138740 -7270 0 0 {name=p138184 lab=clkbuf_5_2_0_CLK/A }
C {devices/lab_pin.sym} 138820 -7270 0 1 {name=p138185 lab=clkbuf_6_7_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 138780 -7270 0 0 {name=Xclkbuf_5_3_0_CLK }
C {devices/lab_pin.sym} 138740 -7150 0 0 {name=p138186 lab=_72892_/B }
C {devices/lab_pin.sym} 138820 -7150 0 1 {name=p138187 lab=_72900_/X }
C {sky130_stdcells/buf_2.sym} 138780 -7150 0 0 {name=X_72900_ }
C {devices/lab_pin.sym} 138720 -7040 0 0 {name=p138188 lab=_80000_/A }
C {devices/lab_pin.sym} 138720 -7000 0 0 {name=p138189 lab=_79999_/X }
C {devices/lab_pin.sym} 138840 -7020 0 1 {name=p138190 lab=_80011_/B }
C {sky130_stdcells/or2_4.sym} 138780 -7020 0 0 {name=X_80009_ }
C {devices/lab_pin.sym} 138700 -6930 0 0 {name=p138191 lab=_57801_/X }
C {devices/lab_pin.sym} 138700 -6890 0 0 {name=p138192 lab=_57832_/Y }
C {devices/lab_pin.sym} 138700 -6850 0 0 {name=p138193 lab=_57833_/Y }
C {devices/lab_pin.sym} 138700 -6810 0 0 {name=p138194 lab=_57822_/X }
C {devices/lab_pin.sym} 138700 -6770 0 0 {name=p138195 lab=_57809_/X }
C {devices/lab_pin.sym} 138860 -6850 0 1 {name=p138196 lab=_57834_/X }
C {sky130_stdcells/o32a_4.sym} 138780 -6850 0 0 {name=X_57834_ }
C {devices/lab_pin.sym} 138720 -6700 0 0 {name=p138197 lab=_50169_/A }
C {devices/lab_pin.sym} 138720 -6660 0 0 {name=p138198 lab=_50169_/B }
C {devices/lab_pin.sym} 138840 -6680 0 1 {name=p138199 lab=_50169_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -6680 0 0 {name=X_50169_ }
C {devices/lab_pin.sym} 138720 -6560 0 0 {name=p138200 lab=_73829_/X }
C {devices/lab_pin.sym} 138720 -6520 0 0 {name=p138201 lab=_66097_/B }
C {devices/lab_pin.sym} 138840 -6540 0 1 {name=p138202 lab=_73880_/X }
C {sky130_stdcells/and2_4.sym} 138780 -6540 0 0 {name=X_73880_ }
C {devices/lab_pin.sym} 138690 -6410 0 0 {name=p138203 lab=_85866_/CLK }
C {devices/lab_pin.sym} 138690 -6390 0 0 {name=p138204 lab=_85866_/D }
C {devices/lab_pin.sym} 138870 -6410 0 1 {name=p138205 lab=_85866_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -6400 0 0 {name=X_85866_ }
C {devices/lab_pin.sym} 138690 -6270 0 0 {name=p138206 lab=_87348_/CLK }
C {devices/lab_pin.sym} 138690 -6250 0 0 {name=p138207 lab=_87605_/D }
C {devices/lab_pin.sym} 138870 -6270 0 1 {name=p138208 lab=_67285_/B }
C {sky130_stdcells/dfxtp_4.sym} 138780 -6260 0 0 {name=X_87605_ }
C {devices/lab_pin.sym} 138720 -6140 0 0 {name=p138209 lab=_72831_/A }
C {devices/lab_pin.sym} 138720 -6100 0 0 {name=p138210 lab=_72924_/B }
C {devices/lab_pin.sym} 138840 -6120 0 1 {name=p138211 lab=_72831_/Y }
C {sky130_stdcells/nor2_4.sym} 138780 -6120 0 0 {name=X_72831_ }
C {devices/lab_pin.sym} 138690 -5990 0 0 {name=p138212 lab=_84815_/CLK }
C {devices/lab_pin.sym} 138690 -5970 0 0 {name=p138213 lab=_84817_/D }
C {devices/lab_pin.sym} 138870 -5990 0 1 {name=p138214 lab=_84817_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -5980 0 0 {name=X_84817_ }
C {devices/lab_pin.sym} 138700 -5870 0 0 {name=p138215 lab=_57760_/X }
C {devices/lab_pin.sym} 138700 -5830 0 0 {name=p138216 lab=_85405_/Q }
C {devices/lab_pin.sym} 138700 -5790 0 0 {name=p138217 lab=_57764_/X }
C {devices/lab_pin.sym} 138860 -5830 0 1 {name=p138218 lab=_57765_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -5830 0 0 {name=X_57765_ }
C {devices/lab_pin.sym} 138700 -5730 0 0 {name=p138219 lab=_42984_/X }
C {devices/lab_pin.sym} 138700 -5690 0 0 {name=p138220 lab=_42985_/X }
C {devices/lab_pin.sym} 138700 -5650 0 0 {name=p138221 lab=_40491_/X }
C {devices/lab_pin.sym} 138700 -5610 0 0 {name=p138222 lab=_87615_/Q }
C {devices/lab_pin.sym} 138700 -5570 0 0 {name=p138223 lab=_42463_/A }
C {devices/lab_pin.sym} 138860 -5650 0 1 {name=p138224 lab=_42992_/A }
C {sky130_stdcells/o32ai_4.sym} 138780 -5650 0 0 {name=X_42991_ }
C {devices/lab_pin.sym} 138700 -5510 0 0 {name=p138225 lab=_85342_/Q }
C {devices/lab_pin.sym} 138700 -5470 0 0 {name=p138226 lab=_54967_/X }
C {devices/lab_pin.sym} 138700 -5430 0 0 {name=p138227 lab=_54976_/Y }
C {devices/lab_pin.sym} 138860 -5470 0 1 {name=p138228 lab=_54977_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -5470 0 0 {name=X_54977_ }
C {devices/lab_pin.sym} 138690 -5330 0 0 {name=p138229 lab=_85800_/CLK }
C {devices/lab_pin.sym} 138690 -5310 0 0 {name=p138230 lab=_85797_/D }
C {devices/lab_pin.sym} 138870 -5330 0 1 {name=p138231 lab=_65335_/B }
C {sky130_stdcells/dfxtp_4.sym} 138780 -5320 0 0 {name=X_85797_ }
C {devices/lab_pin.sym} 138740 -5190 0 0 {name=p138232 lab=_59504_/A }
C {devices/lab_pin.sym} 138820 -5190 0 1 {name=p138233 lab=_59504_/Y }
C {sky130_stdcells/inv_2.sym} 138780 -5190 0 0 {name=X_59504_ }
C {devices/lab_pin.sym} 138740 -5070 0 0 {name=p138234 lab=_44730_/A }
C {devices/lab_pin.sym} 138820 -5070 0 1 {name=p138235 lab=_44730_/Y }
C {sky130_stdcells/inv_2.sym} 138780 -5070 0 0 {name=X_44730_ }
C {devices/lab_pin.sym} 138740 -4950 0 0 {name=p138236 lab=_56715_/Y }
C {devices/lab_pin.sym} 138820 -4950 0 1 {name=p138237 lab=_57416_/C }
C {sky130_stdcells/buf_2.sym} 138780 -4950 0 0 {name=X_56716_ }
C {devices/lab_pin.sym} 138740 -4830 0 0 {name=p138238 lab=_75551_/B }
C {devices/lab_pin.sym} 138820 -4830 0 1 {name=p138239 lab=_75550_/Y }
C {sky130_stdcells/inv_2.sym} 138780 -4830 0 0 {name=X_75550_ }
C {devices/lab_pin.sym} 138690 -4710 0 0 {name=p138240 lab=_88087_/CLK }
C {devices/lab_pin.sym} 138690 -4690 0 0 {name=p138241 lab=_43210_/X }
C {devices/lab_pin.sym} 138870 -4710 0 1 {name=p138242 lab=_87536_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -4700 0 0 {name=X_87536_ }
C {devices/lab_pin.sym} 138700 -4610 0 0 {name=p138243 lab=_41937_/X }
C {devices/lab_pin.sym} 138700 -4570 0 0 {name=p138244 lab=_41919_/X }
C {devices/lab_pin.sym} 138700 -4530 0 0 {name=p138245 lab=_40678_/X }
C {devices/lab_pin.sym} 138700 -4490 0 0 {name=p138246 lab=_41941_/Y }
C {devices/lab_pin.sym} 138700 -4450 0 0 {name=p138247 lab=_41939_/X }
C {devices/lab_pin.sym} 138860 -4530 0 1 {name=p138248 lab=_88099_/D }
C {sky130_stdcells/o32ai_4.sym} 138780 -4530 0 0 {name=X_41942_ }
C {devices/lab_pin.sym} 138700 -4390 0 0 {name=p138249 lab=_85540_/Q }
C {devices/lab_pin.sym} 138700 -4350 0 0 {name=p138250 lab=_53921_/X }
C {devices/lab_pin.sym} 138700 -4310 0 0 {name=p138251 lab=_53927_/Y }
C {devices/lab_pin.sym} 138860 -4350 0 1 {name=p138252 lab=_53928_/Y }
C {sky130_stdcells/o21ai_4.sym} 138780 -4350 0 0 {name=X_53928_ }
C {devices/lab_pin.sym} 138720 -4220 0 0 {name=p138253 lab=_48357_/Y }
C {devices/lab_pin.sym} 138720 -4180 0 0 {name=p138254 lab=_72762_/B }
C {devices/lab_pin.sym} 138840 -4200 0 1 {name=p138255 lab=_72762_/X }
C {sky130_stdcells/xor2_4.sym} 138780 -4200 0 0 {name=X_72762_ }
C {devices/lab_pin.sym} 138690 -4070 0 0 {name=p138256 lab=_84760_/CLK }
C {devices/lab_pin.sym} 138690 -4050 0 0 {name=p138257 lab=_59363_/Y }
C {devices/lab_pin.sym} 138870 -4070 0 1 {name=p138258 lab=_84748_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -4060 0 0 {name=X_84748_ }
C {devices/lab_pin.sym} 138740 -3930 0 0 {name=p138259 lab=_58805_/A }
C {devices/lab_pin.sym} 138820 -3930 0 1 {name=p138260 lab=_57696_/X }
C {sky130_stdcells/buf_2.sym} 138780 -3930 0 0 {name=X_57696_ }
C {devices/lab_pin.sym} 138720 -3830 0 0 {name=p138261 lab=_74501_/A }
C {devices/lab_pin.sym} 138720 -3790 0 0 {name=p138262 lab=_74501_/B }
C {devices/lab_pin.sym} 138720 -3750 0 0 {name=p138263 lab=_74501_/C }
C {devices/lab_pin.sym} 138840 -3790 0 1 {name=p138264 lab=_74501_/X }
C {sky130_stdcells/and3_4.sym} 138780 -3790 0 0 {name=X_74501_ }
C {devices/lab_pin.sym} 138720 -3660 0 0 {name=p138265 lab=_70700_/A }
C {devices/lab_pin.sym} 138720 -3620 0 0 {name=p138266 lab=_70700_/B }
C {devices/lab_pin.sym} 138840 -3640 0 1 {name=p138267 lab=_71713_/Y }
C {sky130_stdcells/nand2_4.sym} 138780 -3640 0 0 {name=X_71713_ }
C {devices/lab_pin.sym} 138700 -3530 0 0 {name=p138268 lab=_59417_/X }
C {devices/lab_pin.sym} 138700 -3490 0 0 {name=p138269 lab=_83342_/Q }
C {devices/lab_pin.sym} 138700 -3450 0 0 {name=p138270 lab=_59434_/Y }
C {devices/lab_pin.sym} 138860 -3490 0 1 {name=p138271 lab=_84734_/D }
C {sky130_stdcells/o21a_4.sym} 138780 -3490 0 0 {name=X_59435_ }
C {devices/lab_pin.sym} 138700 -3390 0 0 {name=p138272 lab=_45893_/C }
C {devices/lab_pin.sym} 138700 -3350 0 0 {name=p138273 lab=_44292_/A }
C {devices/lab_pin.sym} 138700 -3310 0 0 {name=p138274 lab=_46173_/X }
C {devices/lab_pin.sym} 138700 -3270 0 0 {name=p138275 lab=_56647_/A4 }
C {devices/lab_pin.sym} 138700 -3240 0 0 {name=p138276 lab=_56646_/Y }
C {devices/lab_pin.sym} 138860 -3310 0 1 {name=p138277 lab=_56647_/X }
C {sky130_stdcells/a41o_4.sym} 138780 -3310 0 0 {name=X_56647_ }
C {devices/lab_pin.sym} 138700 -3190 0 0 {name=p138278 lab=_44658_/X }
C {devices/lab_pin.sym} 138700 -3150 0 0 {name=p138279 lab=_44659_/X }
C {devices/lab_pin.sym} 138700 -3110 0 0 {name=p138280 lab=_41086_/X }
C {devices/lab_pin.sym} 138700 -3070 0 0 {name=p138281 lab=_87012_/Q }
C {devices/lab_pin.sym} 138700 -3030 0 0 {name=p138282 lab=_44660_/X }
C {devices/lab_pin.sym} 138860 -3110 0 1 {name=p138283 lab=_44662_/A }
C {sky130_stdcells/o32ai_4.sym} 138780 -3110 0 0 {name=X_44661_ }
C {devices/lab_pin.sym} 138700 -2970 0 0 {name=p138284 lab=_75477_/X }
C {devices/lab_pin.sym} 138700 -2930 0 0 {name=p138285 lab=_75478_/Y }
C {devices/lab_pin.sym} 138700 -2890 0 0 {name=p138286 lab=_75480_/Y }
C {devices/lab_pin.sym} 138860 -2930 0 1 {name=p138287 lab=_75481_/X }
C {sky130_stdcells/a21o_4.sym} 138780 -2930 0 0 {name=X_75481_ }
C {devices/lab_pin.sym} 138690 -2790 0 0 {name=p138288 lab=_86934_/CLK }
C {devices/lab_pin.sym} 138690 -2770 0 0 {name=p138289 lab=_87467_/D }
C {devices/lab_pin.sym} 138870 -2790 0 1 {name=p138290 lab=_87467_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -2780 0 0 {name=X_87467_ }
C {devices/lab_pin.sym} 138700 -2690 0 0 {name=p138291 lab=_57491_/B }
C {devices/lab_pin.sym} 138700 -2650 0 0 {name=p138292 lab=_50731_/A }
C {devices/lab_pin.sym} 138700 -2610 0 0 {name=p138293 lab=_40560_/X }
C {devices/lab_pin.sym} 138700 -2570 0 0 {name=p138294 lab=_73552_/A }
C {devices/lab_pin.sym} 138700 -2530 0 0 {name=p138295 lab=_41872_/X }
C {devices/lab_pin.sym} 138860 -2610 0 1 {name=p138296 lab=_41873_/Y }
C {sky130_stdcells/o32ai_4.sym} 138780 -2610 0 0 {name=X_41873_ }
C {devices/lab_pin.sym} 138700 -2470 0 0 {name=p138297 lab=_53857_/Y }
C {devices/lab_pin.sym} 138700 -2430 0 0 {name=p138298 lab=_53838_/X }
C {devices/lab_pin.sym} 138700 -2390 0 0 {name=p138299 lab=_53858_/Y }
C {devices/lab_pin.sym} 138860 -2430 0 1 {name=p138300 lab=_85554_/D }
C {sky130_stdcells/a21boi_4.sym} 138780 -2430 0 0 {name=X_53859_ }
C {devices/lab_pin.sym} 138720 -2310 0 0 {name=p138301 lab=_72697_/A }
C {devices/lab_pin.sym} 138720 -2270 0 0 {name=p138302 lab=_72697_/B }
C {devices/lab_pin.sym} 138720 -2230 0 0 {name=p138303 lab=_55423_/B }
C {devices/lab_pin.sym} 138840 -2270 0 1 {name=p138304 lab=_72693_/Y }
C {sky130_stdcells/nand3_4.sym} 138780 -2270 0 0 {name=X_72693_ }
C {devices/lab_pin.sym} 138690 -2130 0 0 {name=p138305 lab=_84396_/CLK }
C {devices/lab_pin.sym} 138690 -2110 0 0 {name=p138306 lab=_84679_/D }
C {devices/lab_pin.sym} 138870 -2130 0 1 {name=p138307 lab=_59982_/C }
C {sky130_stdcells/dfxtp_4.sym} 138780 -2120 0 0 {name=X_84679_ }
C {devices/lab_pin.sym} 138740 -1990 0 0 {name=p138308 lab=_46259_/A }
C {devices/lab_pin.sym} 138820 -1990 0 1 {name=p138309 lab=_46401_/A }
C {sky130_stdcells/buf_2.sym} 138780 -1990 0 0 {name=X_46400_ }
C {devices/lab_pin.sym} 138720 -1880 0 0 {name=p138310 lab=_82112_/Q }
C {devices/lab_pin.sym} 138720 -1840 0 0 {name=p138311 lab=_77220_/B }
C {devices/lab_pin.sym} 138840 -1860 0 1 {name=p138312 lab=_77220_/X }
C {sky130_stdcells/xor2_4.sym} 138780 -1860 0 0 {name=X_77220_ }
C {devices/lab_pin.sym} 138700 -1760 0 0 {name=p138313 lab=_40604_/X }
C {devices/lab_pin.sym} 138700 -1720 0 0 {name=p138314 lab=_43609_/X }
C {devices/lab_pin.sym} 138700 -1680 0 0 {name=p138315 lab=_68468_/B }
C {devices/lab_pin.sym} 138700 -1640 0 0 {name=p138316 lab=_43611_/X }
C {devices/lab_pin.sym} 138860 -1700 0 1 {name=p138317 lab=_43613_/A }
C {sky130_stdcells/a2bb2o_4.sym} 138780 -1700 0 0 {name=X_43612_ }
C {devices/lab_pin.sym} 138690 -1550 0 0 {name=p138318 lab=_85516_/CLK }
C {devices/lab_pin.sym} 138690 -1530 0 0 {name=p138319 lab=_49284_/Y }
C {devices/lab_pin.sym} 138870 -1550 0 1 {name=p138320 lab=_86418_/Q }
C {sky130_stdcells/dfxtp_4.sym} 138780 -1540 0 0 {name=X_86418_ }
C {devices/lab_pin.sym} 138700 -1430 0 0 {name=p138321 lab=_74429_/Y }
C {devices/lab_pin.sym} 138700 -1390 0 0 {name=p138322 lab=_74430_/X }
C {devices/lab_pin.sym} 138700 -1350 0 0 {name=p138323 lab=_74431_/X }
C {devices/lab_pin.sym} 138860 -1390 0 1 {name=p138324 lab=_74432_/Y }
C {sky130_stdcells/a21oi_4.sym} 138780 -1390 0 0 {name=X_74432_ }
C {devices/lab_pin.sym} 138720 -1260 0 0 {name=p138325 lab=_82869_/Q }
C {devices/lab_pin.sym} 138720 -1220 0 0 {name=p138326 lab=_40847_/B }
C {devices/lab_pin.sym} 138840 -1240 0 1 {name=p138327 lab=_40824_/X }
C {sky130_stdcells/or2_4.sym} 138780 -1240 0 0 {name=X_40824_ }
C {devices/lab_pin.sym} 138720 -1140 0 0 {name=p138328 lab=_47380_/A }
C {devices/lab_pin.sym} 138720 -1100 0 0 {name=p138329 lab=_47408_/B }
C {devices/lab_pin.sym} 138720 -1060 0 0 {name=p138330 lab=_47377_/X }
C {devices/lab_pin.sym} 138720 -1020 0 0 {name=p138331 lab=_53015_/D }
C {devices/lab_pin.sym} 138840 -1080 0 1 {name=p138332 lab=_47380_/X }
C {sky130_stdcells/and4_4.sym} 138780 -1080 0 0 {name=X_47380_ }
C {devices/lab_pin.sym} 138700 -950 0 0 {name=p138333 lab=_59292_/X }
C {devices/lab_pin.sym} 138700 -910 0 0 {name=p138334 lab=_85635_/Q }
C {devices/lab_pin.sym} 138700 -870 0 0 {name=p138335 lab=_59365_/X }
C {devices/lab_pin.sym} 138860 -910 0 1 {name=p138336 lab=_59366_/X }
C {sky130_stdcells/o21a_4.sym} 138780 -910 0 0 {name=X_59366_ }
C {devices/lab_pin.sym} 138720 -790 0 0 {name=p138337 lab=_71637_/A }
C {devices/lab_pin.sym} 138720 -750 0 0 {name=p138338 lab=_71232_/B }
C {devices/lab_pin.sym} 138720 -710 0 0 {name=p138339 lab=_71644_/C }
C {devices/lab_pin.sym} 138840 -750 0 1 {name=p138340 lab=_71644_/Y }
C {sky130_stdcells/nand3_4.sym} 138780 -750 0 0 {name=X_71644_ }
C {devices/lab_pin.sym} 139660 -42150 0 0 {name=p138341 lab=_44591_/Y }
C {devices/lab_pin.sym} 139740 -42150 0 1 {name=p138342 lab=_44592_/Y }
C {sky130_stdcells/inv_2.sym} 139700 -42150 0 0 {name=X_44592_ }
C {devices/lab_pin.sym} 139660 -42030 0 0 {name=p138343 lab=_56577_/Y }
C {devices/lab_pin.sym} 139740 -42030 0 1 {name=p138344 lab=_56578_/X }
C {sky130_stdcells/buf_2.sym} 139700 -42030 0 0 {name=X_56578_ }
C {devices/lab_pin.sym} 139610 -41910 0 0 {name=p138345 lab=_87150_/CLK }
C {devices/lab_pin.sym} 139610 -41890 0 0 {name=p138346 lab=_87398_/D }
C {devices/lab_pin.sym} 139790 -41910 0 1 {name=p138347 lab=_87398_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -41900 0 0 {name=X_87398_ }
C {devices/lab_pin.sym} 139640 -41780 0 0 {name=p138348 lab=_46288_/A }
C {devices/lab_pin.sym} 139640 -41740 0 0 {name=p138349 lab=_52454_/B }
C {devices/lab_pin.sym} 139760 -41760 0 1 {name=p138350 lab=_46331_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -41760 0 0 {name=X_46331_ }
C {devices/lab_pin.sym} 139640 -41640 0 0 {name=p138351 lab=_58317_/A }
C {devices/lab_pin.sym} 139640 -41600 0 0 {name=p138352 lab=_58326_/B }
C {devices/lab_pin.sym} 139760 -41620 0 1 {name=p138353 lab=_58317_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -41620 0 0 {name=X_58317_ }
C {devices/lab_pin.sym} 139640 -41500 0 0 {name=p138354 lab=_77151_/A }
C {devices/lab_pin.sym} 139640 -41460 0 0 {name=p138355 lab=_77151_/B }
C {devices/lab_pin.sym} 139760 -41480 0 1 {name=p138356 lab=_77152_/B }
C {sky130_stdcells/xnor2_4.sym} 139700 -41480 0 0 {name=X_77151_ }
C {devices/lab_pin.sym} 139620 -41390 0 0 {name=p138357 lab=_43542_/X }
C {devices/lab_pin.sym} 139620 -41350 0 0 {name=p138358 lab=_43523_/X }
C {devices/lab_pin.sym} 139620 -41310 0 0 {name=p138359 lab=_40440_/X }
C {devices/lab_pin.sym} 139620 -41270 0 0 {name=p138360 lab=_87367_/Q }
C {devices/lab_pin.sym} 139620 -41230 0 0 {name=p138361 lab=_43528_/X }
C {devices/lab_pin.sym} 139780 -41310 0 1 {name=p138362 lab=_43544_/A }
C {sky130_stdcells/o32ai_4.sym} 139700 -41310 0 0 {name=X_43543_ }
C {devices/lab_pin.sym} 139640 -41160 0 0 {name=p138363 lab=_55534_/A }
C {devices/lab_pin.sym} 139640 -41120 0 0 {name=p138364 lab=_55529_/B }
C {devices/lab_pin.sym} 139760 -41140 0 1 {name=p138365 lab=_55529_/X }
C {sky130_stdcells/and2_4.sym} 139700 -41140 0 0 {name=X_55529_ }
C {devices/lab_pin.sym} 139640 -41020 0 0 {name=p138366 lab=_72068_/A }
C {devices/lab_pin.sym} 139640 -40980 0 0 {name=p138367 lab=_48357_/Y }
C {devices/lab_pin.sym} 139760 -41000 0 1 {name=p138368 lab=_74363_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -41000 0 0 {name=X_74363_ }
C {devices/lab_pin.sym} 139610 -40870 0 0 {name=p138369 lab=_86351_/CLK }
C {devices/lab_pin.sym} 139610 -40850 0 0 {name=p138370 lab=_49647_/Y }
C {devices/lab_pin.sym} 139790 -40870 0 1 {name=p138371 lab=_59244_/B }
C {sky130_stdcells/dfxtp_4.sym} 139700 -40860 0 0 {name=X_86349_ }
C {devices/lab_pin.sym} 139660 -40730 0 0 {name=p138372 lab=_40755_/A }
C {devices/lab_pin.sym} 139740 -40730 0 1 {name=p138373 lab=_40756_/A }
C {sky130_stdcells/buf_2.sym} 139700 -40730 0 0 {name=X_40755_ }
C {devices/lab_pin.sym} 139660 -40610 0 0 {name=p138374 lab=_59297_/A }
C {devices/lab_pin.sym} 139740 -40610 0 1 {name=p138375 lab=_59297_/X }
C {sky130_stdcells/buf_2.sym} 139700 -40610 0 0 {name=X_59297_ }
C {devices/lab_pin.sym} 139620 -40510 0 0 {name=p138376 lab=_71556_/Y }
C {devices/lab_pin.sym} 139620 -40470 0 0 {name=p138377 lab=_58336_/B }
C {devices/lab_pin.sym} 139620 -40430 0 0 {name=p138378 lab=_71574_/Y }
C {devices/lab_pin.sym} 139780 -40470 0 1 {name=p138379 lab=_83451_/D }
C {sky130_stdcells/a21o_4.sym} 139700 -40470 0 0 {name=X_71575_ }
C {devices/lab_pin.sym} 139620 -40350 0 0 {name=p138380 lab=_76094_/A }
C {devices/lab_pin.sym} 139620 -40310 0 0 {name=p138381 lab=_76099_/B }
C {devices/lab_pin.sym} 139620 -40270 0 0 {name=p138382 lab=_76093_/A }
C {devices/lab_pin.sym} 139780 -40310 0 1 {name=p138383 lab=_76102_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -40310 0 0 {name=X_76102_ }
C {devices/lab_pin.sym} 139620 -40190 0 0 {name=p138384 lab=_50645_/A }
C {devices/lab_pin.sym} 139620 -40150 0 0 {name=p138385 lab=_50645_/B }
C {devices/lab_pin.sym} 139620 -40110 0 0 {name=p138386 lab=_48917_/X }
C {devices/lab_pin.sym} 139780 -40150 0 1 {name=p138387 lab=_49050_/X }
C {sky130_stdcells/o21a_4.sym} 139700 -40150 0 0 {name=X_49050_ }
C {devices/lab_pin.sym} 139620 -40030 0 0 {name=p138388 lab=_73301_/X }
C {devices/lab_pin.sym} 139620 -39990 0 0 {name=p138389 lab=_73303_/X }
C {devices/lab_pin.sym} 139620 -39950 0 0 {name=p138390 lab=_73313_/X }
C {devices/lab_pin.sym} 139780 -39990 0 1 {name=p138391 lab=_73314_/X }
C {sky130_stdcells/a21o_4.sym} 139700 -39990 0 0 {name=X_73314_ }
C {devices/lab_pin.sym} 139640 -39870 0 0 {name=p138392 lab=_70526_/A }
C {devices/lab_pin.sym} 139640 -39830 0 0 {name=p138393 lab=_74533_/A }
C {devices/lab_pin.sym} 139640 -39790 0 0 {name=p138394 lab=_70962_/C }
C {devices/lab_pin.sym} 139760 -39830 0 1 {name=p138395 lab=_70526_/Y }
C {sky130_stdcells/nand3_4.sym} 139700 -39830 0 0 {name=X_70526_ }
C {devices/lab_pin.sym} 139660 -39690 0 0 {name=p138396 lab=_46348_/A }
C {devices/lab_pin.sym} 139740 -39690 0 1 {name=p138397 lab=_46262_/X }
C {sky130_stdcells/buf_2.sym} 139700 -39690 0 0 {name=X_46262_ }
C {devices/lab_pin.sym} 139640 -39580 0 0 {name=p138398 lab=_81998_/Q }
C {devices/lab_pin.sym} 139640 -39540 0 0 {name=p138399 lab=_81910_/Q }
C {devices/lab_pin.sym} 139760 -39560 0 1 {name=p138400 lab=_77096_/A }
C {sky130_stdcells/xor2_4.sym} 139700 -39560 0 0 {name=X_77082_ }
C {devices/lab_pin.sym} 139640 -39440 0 0 {name=p138401 lab=_58248_/A }
C {devices/lab_pin.sym} 139640 -39400 0 0 {name=p138402 lab=_58248_/B }
C {devices/lab_pin.sym} 139760 -39420 0 1 {name=p138403 lab=_58248_/Y }
C {sky130_stdcells/nor2_4.sym} 139700 -39420 0 0 {name=X_58248_ }
C {devices/lab_pin.sym} 139660 -39290 0 0 {name=p138404 lab=_43474_/A }
C {devices/lab_pin.sym} 139740 -39290 0 1 {name=p138405 lab=_87404_/D }
C {sky130_stdcells/inv_2.sym} 139700 -39290 0 0 {name=X_43474_ }
C {devices/lab_pin.sym} 139620 -39190 0 0 {name=p138406 lab=_70275_/C }
C {devices/lab_pin.sym} 139620 -39150 0 0 {name=p138407 lab=_74288_/X }
C {devices/lab_pin.sym} 139620 -39110 0 0 {name=p138408 lab=_74293_/Y }
C {devices/lab_pin.sym} 139780 -39150 0 1 {name=p138409 lab=_74294_/X }
C {sky130_stdcells/a21bo_4.sym} 139700 -39150 0 0 {name=X_74294_ }
C {devices/lab_pin.sym} 139660 -39010 0 0 {name=p138410 lab=_40686_/A }
C {devices/lab_pin.sym} 139740 -39010 0 1 {name=p138411 lab=_40835_/A }
C {sky130_stdcells/buf_2.sym} 139700 -39010 0 0 {name=X_40686_ }
C {devices/lab_pin.sym} 139660 -38890 0 0 {name=p138412 lab=_48731_/A }
C {devices/lab_pin.sym} 139740 -38890 0 1 {name=p138413 lab=_48004_/A }
C {sky130_stdcells/buf_2.sym} 139700 -38890 0 0 {name=X_48001_ }
C {devices/lab_pin.sym} 139620 -38790 0 0 {name=p138414 lab=_45208_/Y }
C {devices/lab_pin.sym} 139620 -38750 0 0 {name=p138415 lab=_45211_/Y }
C {devices/lab_pin.sym} 139620 -38710 0 0 {name=p138416 lab=_45212_/X }
C {devices/lab_pin.sym} 139780 -38750 0 1 {name=p138417 lab=_45213_/X }
C {sky130_stdcells/a21o_4.sym} 139700 -38750 0 0 {name=X_45213_ }
C {devices/lab_pin.sym} 139640 -38620 0 0 {name=p138418 lab=_81714_/D }
C {devices/lab_pin.sym} 139640 -38580 0 0 {name=p138419 lab=_76042_/B }
C {devices/lab_pin.sym} 139760 -38600 0 1 {name=p138420 lab=_76047_/A }
C {sky130_stdcells/xor2_4.sym} 139700 -38600 0 0 {name=X_76033_ }
C {devices/lab_pin.sym} 139610 -38470 0 0 {name=p138421 lab=_87249_/CLK }
C {devices/lab_pin.sym} 139610 -38450 0 0 {name=p138422 lab=_88019_/D }
C {devices/lab_pin.sym} 139790 -38470 0 1 {name=p138423 lab=_88019_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -38460 0 0 {name=X_88019_ }
C {devices/lab_pin.sym} 139620 -38360 0 0 {name=p138424 lab=_40497_/X }
C {devices/lab_pin.sym} 139620 -38320 0 0 {name=p138425 lab=_42414_/X }
C {devices/lab_pin.sym} 139620 -38280 0 0 {name=p138426 lab=_87870_/Q }
C {devices/lab_pin.sym} 139620 -38240 0 0 {name=p138427 lab=_42415_/X }
C {devices/lab_pin.sym} 139780 -38300 0 1 {name=p138428 lab=_87870_/D }
C {sky130_stdcells/a2bb2o_4.sym} 139700 -38300 0 0 {name=X_42425_ }
C {devices/lab_pin.sym} 139620 -38170 0 0 {name=p138429 lab=_73243_/X }
C {devices/lab_pin.sym} 139620 -38130 0 0 {name=p138430 lab=_73244_/Y }
C {devices/lab_pin.sym} 139620 -38090 0 0 {name=p138431 lab=_73221_/X }
C {devices/lab_pin.sym} 139780 -38130 0 1 {name=p138432 lab=_73245_/Y }
C {sky130_stdcells/a21oi_4.sym} 139700 -38130 0 0 {name=X_73245_ }
C {devices/lab_pin.sym} 139640 -38000 0 0 {name=p138433 lab=_46207_/B }
C {devices/lab_pin.sym} 139640 -37960 0 0 {name=p138434 lab=_46217_/C }
C {devices/lab_pin.sym} 139760 -37980 0 1 {name=p138435 lab=_46222_/B }
C {sky130_stdcells/and2_4.sym} 139700 -37980 0 0 {name=X_46193_ }
C {devices/lab_pin.sym} 139640 -37860 0 0 {name=p138436 lab=_70455_/Y }
C {devices/lab_pin.sym} 139640 -37820 0 0 {name=p138437 lab=_71462_/B }
C {devices/lab_pin.sym} 139760 -37840 0 1 {name=p138438 lab=_70457_/X }
C {sky130_stdcells/and2_4.sym} 139700 -37840 0 0 {name=X_70457_ }
C {devices/lab_pin.sym} 139640 -37720 0 0 {name=p138439 lab=_64292_/A }
C {devices/lab_pin.sym} 139640 -37680 0 0 {name=p138440 lab=_58217_/B }
C {devices/lab_pin.sym} 139760 -37700 0 1 {name=p138441 lab=_58179_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -37700 0 0 {name=X_58179_ }
C {devices/lab_pin.sym} 139660 -37570 0 0 {name=p138442 lab=_60189_/A }
C {devices/lab_pin.sym} 139740 -37570 0 1 {name=p138443 lab=_60309_/D }
C {sky130_stdcells/buf_2.sym} 139700 -37570 0 0 {name=X_60210_ }
C {devices/lab_pin.sym} 139660 -37450 0 0 {name=p138444 lab=_45219_/A }
C {devices/lab_pin.sym} 139740 -37450 0 1 {name=p138445 lab=_45144_/X }
C {sky130_stdcells/buf_2.sym} 139700 -37450 0 0 {name=X_45144_ }
C {devices/lab_pin.sym} 139660 -37330 0 0 {name=p138446 lab=_42290_/A }
C {devices/lab_pin.sym} 139740 -37330 0 1 {name=p138447 lab=_42356_/X }
C {sky130_stdcells/buf_2.sym} 139700 -37330 0 0 {name=X_42356_ }
C {devices/lab_pin.sym} 139660 -37210 0 0 {name=p138448 lab=_61188_/B }
C {devices/lab_pin.sym} 139740 -37210 0 1 {name=p138449 lab=_61190_/X }
C {sky130_stdcells/buf_2.sym} 139700 -37210 0 0 {name=X_61190_ }
C {devices/lab_pin.sym} 139620 -37120 0 0 {name=p138450 lab=_69776_/Y }
C {devices/lab_pin.sym} 139620 -37080 0 0 {name=p138451 lab=_73195_/A }
C {devices/lab_pin.sym} 139620 -37040 0 0 {name=p138452 lab=_72889_/X }
C {devices/lab_pin.sym} 139620 -37000 0 0 {name=p138453 lab=_73175_/Y }
C {devices/lab_pin.sym} 139780 -37060 0 1 {name=p138454 lab=_73176_/X }
C {sky130_stdcells/a211o_4.sym} 139700 -37060 0 0 {name=X_73176_ }
C {devices/lab_pin.sym} 139660 -36910 0 0 {name=p138455 lab=_70997_/A }
C {devices/lab_pin.sym} 139740 -36910 0 1 {name=p138456 lab=_74527_/A }
C {sky130_stdcells/buf_2.sym} 139700 -36910 0 0 {name=X_70388_ }
C {devices/lab_pin.sym} 139660 -36790 0 0 {name=p138457 lab=clkbuf_7_81_0_CLK/A }
C {devices/lab_pin.sym} 139740 -36790 0 1 {name=p138458 lab=clkbuf_7_80_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 139700 -36790 0 0 {name=Xclkbuf_7_80_0_CLK }
C {devices/lab_pin.sym} 139660 -36670 0 0 {name=p138459 lab=_41181_/A }
C {devices/lab_pin.sym} 139740 -36670 0 1 {name=p138460 lab=_41307_/X }
C {sky130_stdcells/buf_2.sym} 139700 -36670 0 0 {name=X_41307_ }
C {devices/lab_pin.sym} 139620 -36580 0 0 {name=p138461 lab=_83281_/Q }
C {devices/lab_pin.sym} 139620 -36540 0 0 {name=p138462 lab=_72115_/X }
C {devices/lab_pin.sym} 139620 -36500 0 0 {name=p138463 lab=_72119_/X }
C {devices/lab_pin.sym} 139620 -36460 0 0 {name=p138464 lab=_72126_/X }
C {devices/lab_pin.sym} 139780 -36520 0 1 {name=p138465 lab=_72127_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 139700 -36520 0 0 {name=X_72127_ }
C {devices/lab_pin.sym} 139620 -36390 0 0 {name=p138466 lab=_59913_/X }
C {devices/lab_pin.sym} 139620 -36350 0 0 {name=p138467 lab=_60011_/X }
C {devices/lab_pin.sym} 139620 -36310 0 0 {name=p138468 lab=_60100_/Y }
C {devices/lab_pin.sym} 139780 -36350 0 1 {name=p138469 lab=_60141_/Y }
C {sky130_stdcells/a21boi_4.sym} 139700 -36350 0 0 {name=X_60141_ }
C {devices/lab_pin.sym} 139660 -36210 0 0 {name=p138470 lab=_46308_/A }
C {devices/lab_pin.sym} 139740 -36210 0 1 {name=p138471 lab=_49973_/A }
C {sky130_stdcells/buf_2.sym} 139700 -36210 0 0 {name=X_49952_ }
C {devices/lab_pin.sym} 139620 -36110 0 0 {name=p138472 lab=_56221_/C }
C {devices/lab_pin.sym} 139620 -36070 0 0 {name=p138473 lab=_45073_/X }
C {devices/lab_pin.sym} 139620 -36030 0 0 {name=p138474 lab=_45074_/X }
C {devices/lab_pin.sym} 139780 -36070 0 1 {name=p138475 lab=_45075_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -36070 0 0 {name=X_45075_ }
C {devices/lab_pin.sym} 139660 -35930 0 0 {name=p138476 lab=_42287_/A }
C {devices/lab_pin.sym} 139740 -35930 0 1 {name=p138477 lab=_87939_/D }
C {sky130_stdcells/inv_2.sym} 139700 -35930 0 0 {name=X_42287_ }
C {devices/lab_pin.sym} 139640 -35820 0 0 {name=p138478 lab=_77984_/A }
C {devices/lab_pin.sym} 139640 -35780 0 0 {name=p138479 lab=_77983_/Y }
C {devices/lab_pin.sym} 139760 -35800 0 1 {name=p138480 lab=_77984_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -35800 0 0 {name=X_77984_ }
C {devices/lab_pin.sym} 139660 -35670 0 0 {name=p138481 lab=_48903_/A }
C {devices/lab_pin.sym} 139740 -35670 0 1 {name=p138482 lab=_48908_/A }
C {sky130_stdcells/buf_2.sym} 139700 -35670 0 0 {name=X_48903_ }
C {devices/lab_pin.sym} 139640 -35560 0 0 {name=p138483 lab=_44006_/X }
C {devices/lab_pin.sym} 139640 -35520 0 0 {name=p138484 lab=_44025_/X }
C {devices/lab_pin.sym} 139760 -35540 0 1 {name=p138485 lab=_44026_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -35540 0 0 {name=X_44026_ }
C {devices/lab_pin.sym} 139640 -35420 0 0 {name=p138486 lab=_79721_/X }
C {devices/lab_pin.sym} 139640 -35380 0 0 {name=p138487 lab=_79722_/X }
C {devices/lab_pin.sym} 139760 -35400 0 1 {name=p138488 lab=_79724_/B }
C {sky130_stdcells/xnor2_4.sym} 139700 -35400 0 0 {name=X_79723_ }
C {devices/lab_pin.sym} 139660 -35270 0 0 {name=p138489 lab=_41237_/Y }
C {devices/lab_pin.sym} 139740 -35270 0 1 {name=p138490 lab=_88252_/D }
C {sky130_stdcells/inv_2.sym} 139700 -35270 0 0 {name=X_41238_ }
C {devices/lab_pin.sym} 139640 -35160 0 0 {name=p138491 lab=_60056_/A }
C {devices/lab_pin.sym} 139640 -35120 0 0 {name=p138492 lab=_59931_/A }
C {devices/lab_pin.sym} 139760 -35140 0 1 {name=p138493 lab=_60072_/Y }
C {sky130_stdcells/nor2_4.sym} 139700 -35140 0 0 {name=X_60072_ }
C {devices/lab_pin.sym} 139620 -35030 0 0 {name=p138494 lab=_83293_/Q }
C {devices/lab_pin.sym} 139620 -34990 0 0 {name=p138495 lab=_72001_/X }
C {devices/lab_pin.sym} 139620 -34950 0 0 {name=p138496 lab=_72057_/Y }
C {devices/lab_pin.sym} 139780 -34990 0 1 {name=p138497 lab=_72058_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -34990 0 0 {name=X_72058_ }
C {devices/lab_pin.sym} 139620 -34880 0 0 {name=p138498 lab=_76918_/A }
C {devices/lab_pin.sym} 139620 -34840 0 0 {name=p138499 lab=_76918_/B }
C {devices/lab_pin.sym} 139620 -34800 0 0 {name=p138500 lab=_76906_/A }
C {devices/lab_pin.sym} 139620 -34760 0 0 {name=p138501 lab=_76934_/Y }
C {devices/lab_pin.sym} 139780 -34820 0 1 {name=p138502 lab=_76935_/X }
C {sky130_stdcells/a2bb2o_4.sym} 139700 -34820 0 0 {name=X_76935_ }
C {devices/lab_pin.sym} 139620 -34690 0 0 {name=p138503 lab=_58135_/B }
C {devices/lab_pin.sym} 139620 -34650 0 0 {name=p138504 lab=_49880_/X }
C {devices/lab_pin.sym} 139620 -34610 0 0 {name=p138505 lab=_49882_/Y }
C {devices/lab_pin.sym} 139780 -34650 0 1 {name=p138506 lab=_49883_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -34650 0 0 {name=X_49883_ }
C {devices/lab_pin.sym} 139640 -34540 0 0 {name=p138507 lab=_58511_/A }
C {devices/lab_pin.sym} 139640 -34500 0 0 {name=p138508 lab=_63900_/B }
C {devices/lab_pin.sym} 139640 -34460 0 0 {name=p138509 lab=_63900_/C }
C {devices/lab_pin.sym} 139640 -34420 0 0 {name=p138510 lab=_63900_/D }
C {devices/lab_pin.sym} 139760 -34480 0 1 {name=p138511 lab=_63903_/B }
C {sky130_stdcells/nand4_4.sym} 139700 -34480 0 0 {name=X_63900_ }
C {devices/lab_pin.sym} 139620 -34350 0 0 {name=p138512 lab=_49320_/B }
C {devices/lab_pin.sym} 139620 -34310 0 0 {name=p138513 lab=_70983_/A }
C {devices/lab_pin.sym} 139620 -34270 0 0 {name=p138514 lab=_71008_/Y }
C {devices/lab_pin.sym} 139780 -34310 0 1 {name=p138515 lab=_71009_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -34310 0 0 {name=X_71009_ }
C {devices/lab_pin.sym} 139640 -34190 0 0 {name=p138516 lab=_52218_/A }
C {devices/lab_pin.sym} 139640 -34150 0 0 {name=p138517 lab=_48849_/B }
C {devices/lab_pin.sym} 139640 -34110 0 0 {name=p138518 lab=_48849_/C }
C {devices/lab_pin.sym} 139760 -34150 0 1 {name=p138519 lab=_48834_/X }
C {sky130_stdcells/and3_4.sym} 139700 -34150 0 0 {name=X_48834_ }
C {devices/lab_pin.sym} 139640 -34020 0 0 {name=p138520 lab=_79651_/X }
C {devices/lab_pin.sym} 139640 -33980 0 0 {name=p138521 lab=_79653_/Y }
C {devices/lab_pin.sym} 139760 -34000 0 1 {name=p138522 lab=_79654_/Y }
C {sky130_stdcells/xnor2_4.sym} 139700 -34000 0 0 {name=X_79654_ }
C {devices/lab_pin.sym} 139660 -33870 0 0 {name=p138523 lab=_41168_/Y }
C {devices/lab_pin.sym} 139740 -33870 0 1 {name=p138524 lab=_41169_/X }
C {sky130_stdcells/buf_2.sym} 139700 -33870 0 0 {name=X_41169_ }
C {devices/lab_pin.sym} 139640 -33770 0 0 {name=p138525 lab=_64876_/X }
C {devices/lab_pin.sym} 139640 -33730 0 0 {name=p138526 lab=_64712_/B }
C {devices/lab_pin.sym} 139640 -33690 0 0 {name=p138527 lab=_64879_/X }
C {devices/lab_pin.sym} 139760 -33730 0 1 {name=p138528 lab=_64880_/Y }
C {sky130_stdcells/nand3_4.sym} 139700 -33730 0 0 {name=X_64880_ }
C {devices/lab_pin.sym} 139640 -33600 0 0 {name=p138529 lab=_76849_/A }
C {devices/lab_pin.sym} 139640 -33560 0 0 {name=p138530 lab=_76862_/A }
C {devices/lab_pin.sym} 139760 -33580 0 1 {name=p138531 lab=_76866_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -33580 0 0 {name=X_76866_ }
C {devices/lab_pin.sym} 139660 -33450 0 0 {name=p138532 lab=clkbuf_7_95_0_CLK/A }
C {devices/lab_pin.sym} 139740 -33450 0 1 {name=p138533 lab=clkbuf_7_95_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 139700 -33450 0 0 {name=Xclkbuf_7_95_0_CLK }
C {devices/lab_pin.sym} 139620 -33350 0 0 {name=p138534 lab=_78601_/Y }
C {devices/lab_pin.sym} 139620 -33310 0 0 {name=p138535 lab=_78581_/B }
C {devices/lab_pin.sym} 139620 -33270 0 0 {name=p138536 lab=_78604_/X }
C {devices/lab_pin.sym} 139780 -33310 0 1 {name=p138537 lab=_78605_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -33310 0 0 {name=X_78605_ }
C {devices/lab_pin.sym} 139640 -33190 0 0 {name=p138538 lab=_63831_/A }
C {devices/lab_pin.sym} 139640 -33150 0 0 {name=p138539 lab=_64272_/A }
C {devices/lab_pin.sym} 139640 -33110 0 0 {name=p138540 lab=_63765_/C }
C {devices/lab_pin.sym} 139760 -33150 0 1 {name=p138541 lab=_63831_/X }
C {sky130_stdcells/and3_4.sym} 139700 -33150 0 0 {name=X_63831_ }
C {devices/lab_pin.sym} 139640 -33020 0 0 {name=p138542 lab=_75817_/A }
C {devices/lab_pin.sym} 139640 -32980 0 0 {name=p138543 lab=_75817_/B }
C {devices/lab_pin.sym} 139760 -33000 0 1 {name=p138544 lab=_75817_/Y }
C {sky130_stdcells/xnor2_4.sym} 139700 -33000 0 0 {name=X_75817_ }
C {devices/lab_pin.sym} 139660 -32870 0 0 {name=p138545 lab=_48790_/A }
C {devices/lab_pin.sym} 139740 -32870 0 1 {name=p138546 lab=_48786_/C }
C {sky130_stdcells/buf_2.sym} 139700 -32870 0 0 {name=X_48765_ }
C {devices/lab_pin.sym} 139640 -32760 0 0 {name=p138547 lab=_84206_/Q }
C {devices/lab_pin.sym} 139640 -32720 0 0 {name=p138548 lab=_83254_/Q }
C {devices/lab_pin.sym} 139760 -32740 0 1 {name=p138549 lab=_79585_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -32740 0 0 {name=X_79585_ }
C {devices/lab_pin.sym} 139620 -32640 0 0 {name=p138550 lab=_40403_/Y }
C {devices/lab_pin.sym} 139620 -32600 0 0 {name=p138551 lab=_45974_/X }
C {devices/lab_pin.sym} 139620 -32560 0 0 {name=p138552 lab=_86831_/Q }
C {devices/lab_pin.sym} 139620 -32520 0 0 {name=p138553 lab=_45976_/X }
C {devices/lab_pin.sym} 139780 -32580 0 1 {name=p138554 lab=_45977_/X }
C {sky130_stdcells/a2bb2o_4.sym} 139700 -32580 0 0 {name=X_45977_ }
C {devices/lab_pin.sym} 139660 -32430 0 0 {name=p138555 lab=_76773_/Y }
C {devices/lab_pin.sym} 139740 -32430 0 1 {name=p138556 lab=_81360_/D }
C {sky130_stdcells/inv_2.sym} 139700 -32430 0 0 {name=X_76797_ }
C {devices/lab_pin.sym} 139660 -32310 0 0 {name=p138557 lab=_47716_/A }
C {devices/lab_pin.sym} 139740 -32310 0 1 {name=p138558 lab=_54898_/B }
C {sky130_stdcells/inv_2.sym} 139700 -32310 0 0 {name=X_47716_ }
C {devices/lab_pin.sym} 139660 -32190 0 0 {name=p138559 lab=_69457_/A }
C {devices/lab_pin.sym} 139740 -32190 0 1 {name=p138560 lab=_66550_/X }
C {sky130_stdcells/buf_2.sym} 139700 -32190 0 0 {name=X_66550_ }
C {devices/lab_pin.sym} 139640 -32080 0 0 {name=p138561 lab=_78534_/Y }
C {devices/lab_pin.sym} 139640 -32040 0 0 {name=p138562 lab=_78536_/B }
C {devices/lab_pin.sym} 139760 -32060 0 1 {name=p138563 lab=_78536_/X }
C {sky130_stdcells/xor2_4.sym} 139700 -32060 0 0 {name=X_78536_ }
C {devices/lab_pin.sym} 139620 -31950 0 0 {name=p138564 lab=_56198_/C }
C {devices/lab_pin.sym} 139620 -31910 0 0 {name=p138565 lab=_44911_/X }
C {devices/lab_pin.sym} 139620 -31870 0 0 {name=p138566 lab=_44927_/X }
C {devices/lab_pin.sym} 139780 -31910 0 1 {name=p138567 lab=_44928_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -31910 0 0 {name=X_44928_ }
C {devices/lab_pin.sym} 139640 -31800 0 0 {name=p138568 lab=_61330_/X }
C {devices/lab_pin.sym} 139640 -31760 0 0 {name=p138569 lab=_63781_/B }
C {devices/lab_pin.sym} 139640 -31720 0 0 {name=p138570 lab=_63781_/C }
C {devices/lab_pin.sym} 139640 -31680 0 0 {name=p138571 lab=_63761_/X }
C {devices/lab_pin.sym} 139760 -31740 0 1 {name=p138572 lab=_63762_/Y }
C {sky130_stdcells/nand4_4.sym} 139700 -31740 0 0 {name=X_63762_ }
C {devices/lab_pin.sym} 139640 -31600 0 0 {name=p138573 lab=_81013_/Q }
C {devices/lab_pin.sym} 139640 -31560 0 0 {name=p138574 lab=_75748_/B }
C {devices/lab_pin.sym} 139760 -31580 0 1 {name=p138575 lab=_75748_/X }
C {sky130_stdcells/xor2_4.sym} 139700 -31580 0 0 {name=X_75748_ }
C {devices/lab_pin.sym} 139660 -31450 0 0 {name=p138576 lab=_60928_/X }
C {devices/lab_pin.sym} 139740 -31450 0 1 {name=p138577 lab=_64191_/D }
C {sky130_stdcells/buf_2.sym} 139700 -31450 0 0 {name=X_60974_ }
C {devices/lab_pin.sym} 139620 -31350 0 0 {name=p138578 lab=_86499_/Q }
C {devices/lab_pin.sym} 139620 -31310 0 0 {name=p138579 lab=_48669_/X }
C {devices/lab_pin.sym} 139620 -31270 0 0 {name=p138580 lab=_48695_/Y }
C {devices/lab_pin.sym} 139780 -31310 0 1 {name=p138581 lab=_48696_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -31310 0 0 {name=X_48696_ }
C {devices/lab_pin.sym} 139640 -31180 0 0 {name=p138582 lab=_65184_/A }
C {devices/lab_pin.sym} 139640 -31140 0 0 {name=p138583 lab=_65501_/B }
C {devices/lab_pin.sym} 139760 -31160 0 1 {name=p138584 lab=_65501_/X }
C {sky130_stdcells/and2_4.sym} 139700 -31160 0 0 {name=X_65501_ }
C {devices/lab_pin.sym} 139660 -31030 0 0 {name=p138585 lab=_62949_/B }
C {devices/lab_pin.sym} 139740 -31030 0 1 {name=p138586 lab=_62713_/X }
C {sky130_stdcells/buf_2.sym} 139700 -31030 0 0 {name=X_62713_ }
C {devices/lab_pin.sym} 139660 -30910 0 0 {name=p138587 lab=_83628_/Q }
C {devices/lab_pin.sym} 139740 -30910 0 1 {name=p138588 lab=_54859_/B }
C {sky130_stdcells/inv_2.sym} 139700 -30910 0 0 {name=X_47647_ }
C {devices/lab_pin.sym} 139640 -30810 0 0 {name=p138589 lab=_65215_/X }
C {devices/lab_pin.sym} 139640 -30770 0 0 {name=p138590 lab=_66476_/B }
C {devices/lab_pin.sym} 139640 -30730 0 0 {name=p138591 lab=_65217_/X }
C {devices/lab_pin.sym} 139760 -30770 0 1 {name=p138592 lab=_66481_/Y }
C {sky130_stdcells/nand3_4.sym} 139700 -30770 0 0 {name=X_66481_ }
C {devices/lab_pin.sym} 139620 -30650 0 0 {name=p138593 lab=_78475_/B }
C {devices/lab_pin.sym} 139620 -30610 0 0 {name=p138594 lab=_78453_/B }
C {devices/lab_pin.sym} 139620 -30570 0 0 {name=p138595 lab=_78466_/X }
C {devices/lab_pin.sym} 139780 -30610 0 1 {name=p138596 lab=_78467_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -30610 0 0 {name=X_78467_ }
C {devices/lab_pin.sym} 139620 -30510 0 0 {name=p138597 lab=_44857_/X }
C {devices/lab_pin.sym} 139620 -30470 0 0 {name=p138598 lab=_44844_/X }
C {devices/lab_pin.sym} 139620 -30430 0 0 {name=p138599 lab=_41772_/X }
C {devices/lab_pin.sym} 139620 -30390 0 0 {name=p138600 lab=_67988_/B }
C {devices/lab_pin.sym} 139620 -30350 0 0 {name=p138601 lab=_44858_/X }
C {devices/lab_pin.sym} 139780 -30430 0 1 {name=p138602 lab=_44860_/A }
C {sky130_stdcells/o32ai_4.sym} 139700 -30430 0 0 {name=X_44859_ }
C {devices/lab_pin.sym} 139620 -30290 0 0 {name=p138603 lab=_63688_/Y }
C {devices/lab_pin.sym} 139620 -30250 0 0 {name=p138604 lab=_63679_/X }
C {devices/lab_pin.sym} 139620 -30210 0 0 {name=p138605 lab=_63692_/Y }
C {devices/lab_pin.sym} 139780 -30250 0 1 {name=p138606 lab=_84301_/D }
C {sky130_stdcells/a21oi_4.sym} 139700 -30250 0 0 {name=X_63693_ }
C {devices/lab_pin.sym} 139640 -30120 0 0 {name=p138607 lab=_75666_/A }
C {devices/lab_pin.sym} 139640 -30080 0 0 {name=p138608 lab=_75674_/A }
C {devices/lab_pin.sym} 139760 -30100 0 1 {name=p138609 lab=_75679_/X }
C {sky130_stdcells/and2_4.sym} 139700 -30100 0 0 {name=X_75679_ }
C {devices/lab_pin.sym} 139660 -29970 0 0 {name=p138610 lab=_68160_/A }
C {devices/lab_pin.sym} 139740 -29970 0 1 {name=p138611 lab=_68220_/X }
C {sky130_stdcells/buf_2.sym} 139700 -29970 0 0 {name=X_68220_ }
C {devices/lab_pin.sym} 139640 -29870 0 0 {name=p138612 lab=_64595_/X }
C {devices/lab_pin.sym} 139640 -29830 0 0 {name=p138613 lab=_65340_/X }
C {devices/lab_pin.sym} 139640 -29790 0 0 {name=p138614 lab=_64604_/X }
C {devices/lab_pin.sym} 139760 -29830 0 1 {name=p138615 lab=_65432_/Y }
C {sky130_stdcells/nand3_4.sym} 139700 -29830 0 0 {name=X_65432_ }
C {devices/lab_pin.sym} 139620 -29710 0 0 {name=p138616 lab=_77381_/A }
C {devices/lab_pin.sym} 139620 -29670 0 0 {name=p138617 lab=_77382_/X }
C {devices/lab_pin.sym} 139620 -29630 0 0 {name=p138618 lab=_77417_/B }
C {devices/lab_pin.sym} 139780 -29670 0 1 {name=p138619 lab=_77418_/X }
C {sky130_stdcells/a21o_4.sym} 139700 -29670 0 0 {name=X_77418_ }
C {devices/lab_pin.sym} 139660 -29530 0 0 {name=p138620 lab=_62644_/A }
C {devices/lab_pin.sym} 139740 -29530 0 1 {name=p138621 lab=_62644_/X }
C {sky130_stdcells/buf_2.sym} 139700 -29530 0 0 {name=X_62644_ }
C {devices/lab_pin.sym} 139660 -29410 0 0 {name=p138622 lab=_47578_/A }
C {devices/lab_pin.sym} 139740 -29410 0 1 {name=p138623 lab=_53129_/D }
C {sky130_stdcells/buf_2.sym} 139700 -29410 0 0 {name=X_47578_ }
C {devices/lab_pin.sym} 139620 -29310 0 0 {name=p138624 lab=_78365_/A }
C {devices/lab_pin.sym} 139620 -29270 0 0 {name=p138625 lab=_78379_/A }
C {devices/lab_pin.sym} 139620 -29230 0 0 {name=p138626 lab=_78380_/A }
C {devices/lab_pin.sym} 139780 -29270 0 1 {name=p138627 lab=_78398_/X }
C {sky130_stdcells/a21o_4.sym} 139700 -29270 0 0 {name=X_78398_ }
C {devices/lab_pin.sym} 139660 -29130 0 0 {name=p138628 lab=_71959_/A }
C {devices/lab_pin.sym} 139740 -29130 0 1 {name=p138629 lab=_49317_/X }
C {sky130_stdcells/buf_2.sym} 139700 -29130 0 0 {name=X_49317_ }
C {devices/lab_pin.sym} 139620 -29030 0 0 {name=p138630 lab=_82066_/D }
C {devices/lab_pin.sym} 139620 -28990 0 0 {name=p138631 lab=_68140_/X }
C {devices/lab_pin.sym} 139620 -28950 0 0 {name=p138632 lab=_68150_/X }
C {devices/lab_pin.sym} 139780 -28990 0 1 {name=p138633 lab=_68151_/X }
C {sky130_stdcells/a21bo_4.sym} 139700 -28990 0 0 {name=X_68151_ }
C {devices/lab_pin.sym} 139620 -28870 0 0 {name=p138634 lab=_46525_/X }
C {devices/lab_pin.sym} 139620 -28830 0 0 {name=p138635 lab=_49129_/A }
C {devices/lab_pin.sym} 139620 -28790 0 0 {name=p138636 lab=_46528_/X }
C {devices/lab_pin.sym} 139780 -28830 0 1 {name=p138637 lab=_51360_/B }
C {sky130_stdcells/o21ai_4.sym} 139700 -28830 0 0 {name=X_46529_ }
C {devices/lab_pin.sym} 139660 -28690 0 0 {name=p138638 lab=_65718_/A }
C {devices/lab_pin.sym} 139740 -28690 0 1 {name=p138639 lab=_65363_/X }
C {sky130_stdcells/buf_2.sym} 139700 -28690 0 0 {name=X_65363_ }
C {devices/lab_pin.sym} 139620 -28590 0 0 {name=p138640 lab=_77319_/X }
C {devices/lab_pin.sym} 139620 -28550 0 0 {name=p138641 lab=_77347_/Y }
C {devices/lab_pin.sym} 139620 -28510 0 0 {name=p138642 lab=_77348_/X }
C {devices/lab_pin.sym} 139780 -28550 0 1 {name=p138643 lab=_77349_/X }
C {sky130_stdcells/o21a_4.sym} 139700 -28550 0 0 {name=X_77349_ }
C {devices/lab_pin.sym} 139620 -28430 0 0 {name=p138644 lab=_62573_/Y }
C {devices/lab_pin.sym} 139620 -28390 0 0 {name=p138645 lab=_62540_/X }
C {devices/lab_pin.sym} 139620 -28350 0 0 {name=p138646 lab=_62574_/Y }
C {devices/lab_pin.sym} 139780 -28390 0 1 {name=p138647 lab=_84400_/D }
C {sky130_stdcells/a21oi_4.sym} 139700 -28390 0 0 {name=X_62575_ }
C {devices/lab_pin.sym} 139660 -28250 0 0 {name=p138648 lab=clkbuf_6_16_0_CLK/X }
C {devices/lab_pin.sym} 139740 -28250 0 1 {name=p138649 lab=clkbuf_8_67_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 139700 -28250 0 0 {name=Xclkbuf_7_33_0_CLK }
C {devices/lab_pin.sym} 139640 -28140 0 0 {name=p138650 lab=_67099_/X }
C {devices/lab_pin.sym} 139640 -28100 0 0 {name=p138651 lab=_67101_/X }
C {devices/lab_pin.sym} 139760 -28120 0 1 {name=p138652 lab=_67102_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -28120 0 0 {name=X_67102_ }
C {devices/lab_pin.sym} 139660 -27990 0 0 {name=p138653 lab=_64314_/A }
C {devices/lab_pin.sym} 139740 -27990 0 1 {name=p138654 lab=_64314_/X }
C {sky130_stdcells/buf_2.sym} 139700 -27990 0 0 {name=X_64314_ }
C {devices/lab_pin.sym} 139660 -27870 0 0 {name=p138655 lab=clkbuf_7_86_0_CLK/X }
C {devices/lab_pin.sym} 139740 -27870 0 1 {name=p138656 lab=clkbuf_9_347_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 139700 -27870 0 0 {name=Xclkbuf_8_173_0_CLK }
C {devices/lab_pin.sym} 139660 -27750 0 0 {name=p138657 lab=_49215_/A }
C {devices/lab_pin.sym} 139740 -27750 0 1 {name=p138658 lab=_49263_/A }
C {sky130_stdcells/buf_2.sym} 139700 -27750 0 0 {name=X_49248_ }
C {devices/lab_pin.sym} 139660 -27630 0 0 {name=p138659 lab=_72528_/A }
C {devices/lab_pin.sym} 139740 -27630 0 1 {name=p138660 lab=_61542_/B }
C {sky130_stdcells/buf_2.sym} 139700 -27630 0 0 {name=X_61526_ }
C {devices/lab_pin.sym} 139640 -27530 0 0 {name=p138661 lab=_80358_/Y }
C {devices/lab_pin.sym} 139640 -27490 0 0 {name=p138662 lab=_80360_/B }
C {devices/lab_pin.sym} 139640 -27450 0 0 {name=p138663 lab=_80350_/B }
C {devices/lab_pin.sym} 139760 -27490 0 1 {name=p138664 lab=_80361_/B }
C {sky130_stdcells/nand3_4.sym} 139700 -27490 0 0 {name=X_80360_ }
C {devices/lab_pin.sym} 139620 -27370 0 0 {name=p138665 lab=_68079_/X }
C {devices/lab_pin.sym} 139620 -27330 0 0 {name=p138666 lab=_68081_/X }
C {devices/lab_pin.sym} 139620 -27290 0 0 {name=p138667 lab=_68033_/X }
C {devices/lab_pin.sym} 139780 -27330 0 1 {name=p138668 lab=_68082_/X }
C {sky130_stdcells/a21o_4.sym} 139700 -27330 0 0 {name=X_68082_ }
C {devices/lab_pin.sym} 139640 -27210 0 0 {name=p138669 lab=_65268_/A }
C {devices/lab_pin.sym} 139640 -27170 0 0 {name=p138670 lab=_65294_/B }
C {devices/lab_pin.sym} 139640 -27130 0 0 {name=p138671 lab=_65294_/C }
C {devices/lab_pin.sym} 139760 -27170 0 1 {name=p138672 lab=_65294_/X }
C {sky130_stdcells/and3_4.sym} 139700 -27170 0 0 {name=X_65294_ }
C {devices/lab_pin.sym} 139640 -27040 0 0 {name=p138673 lab=_67057_/A }
C {devices/lab_pin.sym} 139640 -27000 0 0 {name=p138674 lab=_67033_/B }
C {devices/lab_pin.sym} 139760 -27020 0 1 {name=p138675 lab=_67033_/X }
C {sky130_stdcells/and2_4.sym} 139700 -27020 0 0 {name=X_67033_ }
C {devices/lab_pin.sym} 139640 -26900 0 0 {name=p138676 lab=_82745_/Q }
C {devices/lab_pin.sym} 139640 -26860 0 0 {name=p138677 lab=_79019_/B }
C {devices/lab_pin.sym} 139760 -26880 0 1 {name=p138678 lab=_82713_/D }
C {sky130_stdcells/xor2_4.sym} 139700 -26880 0 0 {name=X_79019_ }
C {devices/lab_pin.sym} 139640 -26780 0 0 {name=p138679 lab=_64273_/A }
C {devices/lab_pin.sym} 139640 -26740 0 0 {name=p138680 lab=_64273_/B }
C {devices/lab_pin.sym} 139640 -26700 0 0 {name=p138681 lab=_63400_/B }
C {devices/lab_pin.sym} 139640 -26660 0 0 {name=p138682 lab=_64221_/X }
C {devices/lab_pin.sym} 139760 -26720 0 1 {name=p138683 lab=_64245_/X }
C {sky130_stdcells/and4_4.sym} 139700 -26720 0 0 {name=X_64245_ }
C {devices/lab_pin.sym} 139640 -26580 0 0 {name=p138684 lab=_49179_/A }
C {devices/lab_pin.sym} 139640 -26540 0 0 {name=p138685 lab=_49161_/B }
C {devices/lab_pin.sym} 139760 -26560 0 1 {name=p138686 lab=_49179_/Y }
C {sky130_stdcells/nor2_4.sym} 139700 -26560 0 0 {name=X_49179_ }
C {devices/lab_pin.sym} 139620 -26450 0 0 {name=p138687 lab=_61454_/X }
C {devices/lab_pin.sym} 139620 -26410 0 0 {name=p138688 lab=_61455_/X }
C {devices/lab_pin.sym} 139620 -26370 0 0 {name=p138689 lab=_61456_/Y }
C {devices/lab_pin.sym} 139780 -26410 0 1 {name=p138690 lab=_61457_/Y }
C {sky130_stdcells/a21oi_4.sym} 139700 -26410 0 0 {name=X_61457_ }
C {devices/lab_pin.sym} 139640 -26280 0 0 {name=p138691 lab=_84748_/Q }
C {devices/lab_pin.sym} 139640 -26240 0 0 {name=p138692 lab=_84140_/Q }
C {devices/lab_pin.sym} 139760 -26260 0 1 {name=p138693 lab=_80292_/B }
C {sky130_stdcells/nand2_4.sym} 139700 -26260 0 0 {name=X_80291_ }
C {devices/lab_pin.sym} 139660 -26130 0 0 {name=p138694 lab=_51074_/A }
C {devices/lab_pin.sym} 139740 -26130 0 1 {name=p138695 lab=_51211_/A }
C {sky130_stdcells/buf_2.sym} 139700 -26130 0 0 {name=X_51210_ }
C {devices/lab_pin.sym} 139610 -26010 0 0 {name=p138696 lab=_81985_/CLK }
C {devices/lab_pin.sym} 139610 -25990 0 0 {name=p138697 lab=_77843_/B }
C {devices/lab_pin.sym} 139790 -26010 0 1 {name=p138698 lab=_81998_/D }
C {sky130_stdcells/dfxtp_4.sym} 139700 -26000 0 0 {name=X_82030_ }
C {devices/lab_pin.sym} 139640 -25890 0 0 {name=p138699 lab=_60408_/A }
C {devices/lab_pin.sym} 139640 -25850 0 0 {name=p138700 lab=_60406_/X }
C {devices/lab_pin.sym} 139640 -25810 0 0 {name=p138701 lab=_60408_/C }
C {devices/lab_pin.sym} 139760 -25850 0 1 {name=p138702 lab=_60408_/X }
C {sky130_stdcells/and3_4.sym} 139700 -25850 0 0 {name=X_60408_ }
C {devices/lab_pin.sym} 139640 -25720 0 0 {name=p138703 lab=_52210_/A }
C {devices/lab_pin.sym} 139640 -25680 0 0 {name=p138704 lab=_48561_/B }
C {devices/lab_pin.sym} 139760 -25700 0 1 {name=p138705 lab=_52190_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -25700 0 0 {name=X_52190_ }
C {devices/lab_pin.sym} 139660 -25570 0 0 {name=p138706 lab=clkbuf_6_24_0_CLK/X }
C {devices/lab_pin.sym} 139740 -25570 0 1 {name=p138707 lab=clkbuf_8_97_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 139700 -25570 0 0 {name=Xclkbuf_7_48_0_CLK }
C {devices/lab_pin.sym} 139620 -25470 0 0 {name=p138708 lab=_64174_/X }
C {devices/lab_pin.sym} 139620 -25430 0 0 {name=p138709 lab=_64129_/X }
C {devices/lab_pin.sym} 139620 -25390 0 0 {name=p138710 lab=_64175_/Y }
C {devices/lab_pin.sym} 139780 -25430 0 1 {name=p138711 lab=_64176_/Y }
C {sky130_stdcells/a21oi_4.sym} 139700 -25430 0 0 {name=X_64176_ }
C {devices/lab_pin.sym} 139640 -25310 0 0 {name=p138712 lab=_61377_/A }
C {devices/lab_pin.sym} 139640 -25270 0 0 {name=p138713 lab=_61387_/X }
C {devices/lab_pin.sym} 139640 -25230 0 0 {name=p138714 lab=_61377_/C }
C {devices/lab_pin.sym} 139760 -25270 0 1 {name=p138715 lab=_61388_/Y }
C {sky130_stdcells/nand3_4.sym} 139700 -25270 0 0 {name=X_61388_ }
C {devices/lab_pin.sym} 139660 -25130 0 0 {name=p138716 lab=clkbuf_7_94_0_CLK/X }
C {devices/lab_pin.sym} 139740 -25130 0 1 {name=p138717 lab=clkbuf_8_188_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 139700 -25130 0 0 {name=Xclkbuf_8_188_0_CLK }
C {devices/lab_pin.sym} 139660 -25010 0 0 {name=p138718 lab=_51141_/A }
C {devices/lab_pin.sym} 139740 -25010 0 1 {name=p138719 lab=_51141_/X }
C {sky130_stdcells/buf_2.sym} 139700 -25010 0 0 {name=X_51141_ }
C {devices/lab_pin.sym} 139660 -24890 0 0 {name=p138720 lab=clkbuf_9_91_0_CLK/X }
C {devices/lab_pin.sym} 139740 -24890 0 1 {name=p138721 lab=_83322_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 139700 -24890 0 0 {name=Xclkbuf_10_183_0_CLK }
C {devices/lab_pin.sym} 139640 -24800 0 0 {name=p138722 lab=_63127_/A }
C {devices/lab_pin.sym} 139640 -24760 0 0 {name=p138723 lab=_63113_/B }
C {devices/lab_pin.sym} 139640 -24720 0 0 {name=p138724 lab=_63103_/C }
C {devices/lab_pin.sym} 139640 -24680 0 0 {name=p138725 lab=_63092_/D }
C {devices/lab_pin.sym} 139760 -24740 0 1 {name=p138726 lab=_63127_/X }
C {sky130_stdcells/or4_4.sym} 139700 -24740 0 0 {name=X_63127_ }
C {devices/lab_pin.sym} 139640 -24610 0 0 {name=p138727 lab=_60317_/A }
C {devices/lab_pin.sym} 139640 -24570 0 0 {name=p138728 lab=_60319_/X }
C {devices/lab_pin.sym} 139640 -24530 0 0 {name=p138729 lab=_79658_/A }
C {devices/lab_pin.sym} 139760 -24570 0 1 {name=p138730 lab=_60339_/Y }
C {sky130_stdcells/nor3_4.sym} 139700 -24570 0 0 {name=X_60339_ }
C {devices/lab_pin.sym} 139640 -24440 0 0 {name=p138731 lab=_69027_/A }
C {devices/lab_pin.sym} 139640 -24400 0 0 {name=p138732 lab=_68984_/B }
C {devices/lab_pin.sym} 139760 -24420 0 1 {name=p138733 lab=_68984_/X }
C {sky130_stdcells/and2_4.sym} 139700 -24420 0 0 {name=X_68984_ }
C {devices/lab_pin.sym} 139620 -24310 0 0 {name=p138734 lab=_51070_/Y }
C {devices/lab_pin.sym} 139620 -24270 0 0 {name=p138735 lab=_51065_/X }
C {devices/lab_pin.sym} 139620 -24230 0 0 {name=p138736 lab=_51071_/X }
C {devices/lab_pin.sym} 139780 -24270 0 1 {name=p138737 lab=_51072_/Y }
C {sky130_stdcells/a21oi_4.sym} 139700 -24270 0 0 {name=X_51072_ }
C {devices/lab_pin.sym} 139660 -24130 0 0 {name=p138738 lab=_68479_/A }
C {devices/lab_pin.sym} 139740 -24130 0 1 {name=p138739 lab=_68028_/A }
C {sky130_stdcells/buf_2.sym} 139700 -24130 0 0 {name=X_67935_ }
C {devices/lab_pin.sym} 139620 -24030 0 0 {name=p138740 lab=_79467_/A }
C {devices/lab_pin.sym} 139620 -23990 0 0 {name=p138741 lab=_63008_/X }
C {devices/lab_pin.sym} 139620 -23950 0 0 {name=p138742 lab=_63057_/Y }
C {devices/lab_pin.sym} 139780 -23990 0 1 {name=p138743 lab=_63058_/X }
C {sky130_stdcells/a21o_4.sym} 139700 -23990 0 0 {name=X_63058_ }
C {devices/lab_pin.sym} 139610 -23850 0 0 {name=p138744 lab=_82629_/CLK }
C {devices/lab_pin.sym} 139610 -23830 0 0 {name=p138745 lab=_83981_/D }
C {devices/lab_pin.sym} 139790 -23850 0 1 {name=p138746 lab=_82629_/D }
C {sky130_stdcells/dfxtp_4.sym} 139700 -23840 0 0 {name=X_83981_ }
C {devices/lab_pin.sym} 139640 -23720 0 0 {name=p138747 lab=_50027_/A }
C {devices/lab_pin.sym} 139640 -23680 0 0 {name=p138748 lab=_53236_/B }
C {devices/lab_pin.sym} 139760 -23700 0 1 {name=p138749 lab=_50023_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -23700 0 0 {name=X_50023_ }
C {devices/lab_pin.sym} 139660 -23570 0 0 {name=p138750 lab=_54900_/A }
C {devices/lab_pin.sym} 139740 -23570 0 1 {name=p138751 lab=_54910_/B }
C {sky130_stdcells/buf_2.sym} 139700 -23570 0 0 {name=X_54900_ }
C {devices/lab_pin.sym} 139640 -23480 0 0 {name=p138752 lab=_61549_/X }
C {devices/lab_pin.sym} 139640 -23440 0 0 {name=p138753 lab=_62007_/X }
C {devices/lab_pin.sym} 139640 -23400 0 0 {name=p138754 lab=_61967_/C }
C {devices/lab_pin.sym} 139640 -23360 0 0 {name=p138755 lab=_62008_/X }
C {devices/lab_pin.sym} 139760 -23420 0 1 {name=p138756 lab=_62015_/B }
C {sky130_stdcells/nand4_4.sym} 139700 -23420 0 0 {name=X_62009_ }
C {devices/lab_pin.sym} 139610 -23270 0 0 {name=p138757 lab=_85718_/CLK }
C {devices/lab_pin.sym} 139610 -23250 0 0 {name=p138758 lab=_85720_/D }
C {devices/lab_pin.sym} 139790 -23270 0 1 {name=p138759 lab=_85720_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -23260 0 0 {name=X_85720_ }
C {devices/lab_pin.sym} 139660 -23130 0 0 {name=p138760 lab=clkbuf_7_55_0_CLK/X }
C {devices/lab_pin.sym} 139740 -23130 0 1 {name=p138761 lab=clkbuf_9_222_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 139700 -23130 0 0 {name=Xclkbuf_8_111_0_CLK }
C {devices/lab_pin.sym} 139610 -23010 0 0 {name=p138762 lab=_82931_/CLK }
C {devices/lab_pin.sym} 139610 -22990 0 0 {name=p138763 lab=_78261_/X }
C {devices/lab_pin.sym} 139790 -23010 0 1 {name=p138764 lab=_82932_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -23000 0 0 {name=X_82932_ }
C {devices/lab_pin.sym} 139620 -22900 0 0 {name=p138765 lab=_45094_/A }
C {devices/lab_pin.sym} 139620 -22860 0 0 {name=p138766 lab=_55531_/X }
C {devices/lab_pin.sym} 139620 -22820 0 0 {name=p138767 lab=_55533_/X }
C {devices/lab_pin.sym} 139620 -22780 0 0 {name=p138768 lab=_55879_/X }
C {devices/lab_pin.sym} 139780 -22840 0 1 {name=p138769 lab=_55880_/X }
C {sky130_stdcells/a211o_4.sym} 139700 -22840 0 0 {name=X_55880_ }
C {devices/lab_pin.sym} 139640 -22700 0 0 {name=p138770 lab=_67817_/X }
C {devices/lab_pin.sym} 139640 -22660 0 0 {name=p138771 lab=_87645_/Q }
C {devices/lab_pin.sym} 139760 -22680 0 1 {name=p138772 lab=_67866_/X }
C {sky130_stdcells/and2_4.sym} 139700 -22680 0 0 {name=X_67866_ }
C {devices/lab_pin.sym} 139660 -22550 0 0 {name=p138773 lab=clkbuf_9_99_0_CLK/X }
C {devices/lab_pin.sym} 139740 -22550 0 1 {name=p138774 lab=_84273_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 139700 -22550 0 0 {name=Xclkbuf_10_198_0_CLK }
C {devices/lab_pin.sym} 139640 -22440 0 0 {name=p138775 lab=_69605_/A }
C {devices/lab_pin.sym} 139640 -22400 0 0 {name=p138776 lab=_72831_/A }
C {devices/lab_pin.sym} 139760 -22420 0 1 {name=p138777 lab=_69605_/X }
C {sky130_stdcells/and2_4.sym} 139700 -22420 0 0 {name=X_69605_ }
C {devices/lab_pin.sym} 139640 -22320 0 0 {name=p138778 lab=_54825_/A }
C {devices/lab_pin.sym} 139640 -22280 0 0 {name=p138779 lab=_54843_/B }
C {devices/lab_pin.sym} 139640 -22240 0 0 {name=p138780 lab=_54831_/C }
C {devices/lab_pin.sym} 139640 -22200 0 0 {name=p138781 lab=_53139_/D }
C {devices/lab_pin.sym} 139760 -22260 0 1 {name=p138782 lab=_54831_/X }
C {sky130_stdcells/and4_4.sym} 139700 -22260 0 0 {name=X_54831_ }
C {devices/lab_pin.sym} 139640 -22120 0 0 {name=p138783 lab=_66795_/A }
C {devices/lab_pin.sym} 139640 -22080 0 0 {name=p138784 lab=_66817_/B }
C {devices/lab_pin.sym} 139760 -22100 0 1 {name=p138785 lab=_66817_/X }
C {sky130_stdcells/and2_4.sym} 139700 -22100 0 0 {name=X_66817_ }
C {devices/lab_pin.sym} 139610 -21970 0 0 {name=p138786 lab=_85651_/CLK }
C {devices/lab_pin.sym} 139610 -21950 0 0 {name=p138787 lab=_53344_/Y }
C {devices/lab_pin.sym} 139790 -21970 0 1 {name=p138788 lab=_85651_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -21960 0 0 {name=X_85651_ }
C {devices/lab_pin.sym} 139610 -21830 0 0 {name=p138789 lab=_82859_/CLK }
C {devices/lab_pin.sym} 139610 -21810 0 0 {name=p138790 lab=_78177_/B }
C {devices/lab_pin.sym} 139790 -21830 0 1 {name=p138791 lab=_82863_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -21820 0 0 {name=X_82863_ }
C {devices/lab_pin.sym} 139620 -21720 0 0 {name=p138792 lab=_87456_/Q }
C {devices/lab_pin.sym} 139620 -21680 0 0 {name=p138793 lab=_67751_/X }
C {devices/lab_pin.sym} 139620 -21640 0 0 {name=p138794 lab=_67702_/X }
C {devices/lab_pin.sym} 139620 -21600 0 0 {name=p138795 lab=_67796_/X }
C {devices/lab_pin.sym} 139780 -21660 0 1 {name=p138796 lab=_67797_/X }
C {sky130_stdcells/a211o_4.sym} 139700 -21660 0 0 {name=X_67797_ }
C {devices/lab_pin.sym} 139610 -21510 0 0 {name=p138797 lab=_84477_/CLK }
C {devices/lab_pin.sym} 139610 -21490 0 0 {name=p138798 lab=_60548_/Y }
C {devices/lab_pin.sym} 139790 -21510 0 1 {name=p138799 lab=_79142_/A }
C {sky130_stdcells/dfxtp_4.sym} 139700 -21500 0 0 {name=X_84602_ }
C {devices/lab_pin.sym} 139660 -21370 0 0 {name=p138800 lab=_46542_/X }
C {devices/lab_pin.sym} 139740 -21370 0 1 {name=p138801 lab=_57550_/X }
C {sky130_stdcells/buf_2.sym} 139700 -21370 0 0 {name=X_57550_ }
C {devices/lab_pin.sym} 139610 -21250 0 0 {name=p138802 lab=_81689_/CLK }
C {devices/lab_pin.sym} 139610 -21230 0 0 {name=p138803 lab=_81622_/Q }
C {devices/lab_pin.sym} 139790 -21250 0 1 {name=p138804 lab=_81814_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -21240 0 0 {name=X_81814_ }
C {devices/lab_pin.sym} 139640 -21120 0 0 {name=p138805 lab=_44022_/X }
C {devices/lab_pin.sym} 139640 -21080 0 0 {name=p138806 lab=_69536_/B }
C {devices/lab_pin.sym} 139760 -21100 0 1 {name=p138807 lab=_69536_/X }
C {sky130_stdcells/and2_4.sym} 139700 -21100 0 0 {name=X_69536_ }
C {devices/lab_pin.sym} 139610 -20970 0 0 {name=p138808 lab=_86982_/CLK }
C {devices/lab_pin.sym} 139610 -20950 0 0 {name=p138809 lab=_40575_/Y }
C {devices/lab_pin.sym} 139790 -20970 0 1 {name=p138810 lab=_88370_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -20960 0 0 {name=X_88370_ }
C {devices/lab_pin.sym} 139620 -20850 0 0 {name=p138811 lab=_54760_/Y }
C {devices/lab_pin.sym} 139620 -20810 0 0 {name=p138812 lab=_54747_/X }
C {devices/lab_pin.sym} 139620 -20770 0 0 {name=p138813 lab=_54761_/X }
C {devices/lab_pin.sym} 139780 -20810 0 1 {name=p138814 lab=_85383_/D }
C {sky130_stdcells/a21oi_4.sym} 139700 -20810 0 0 {name=X_54762_ }
C {devices/lab_pin.sym} 139640 -20680 0 0 {name=p138815 lab=_66819_/A }
C {devices/lab_pin.sym} 139640 -20640 0 0 {name=p138816 lab=_86799_/Q }
C {devices/lab_pin.sym} 139760 -20660 0 1 {name=p138817 lab=_66748_/X }
C {sky130_stdcells/and2_4.sym} 139700 -20660 0 0 {name=X_66748_ }
C {devices/lab_pin.sym} 139610 -20530 0 0 {name=p138818 lab=_86506_/CLK }
C {devices/lab_pin.sym} 139610 -20510 0 0 {name=p138819 lab=_53717_/Y }
C {devices/lab_pin.sym} 139790 -20530 0 1 {name=p138820 lab=_85582_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -20520 0 0 {name=X_85582_ }
C {devices/lab_pin.sym} 139620 -20410 0 0 {name=p138821 lab=_51971_/Y }
C {devices/lab_pin.sym} 139620 -20370 0 0 {name=p138822 lab=_51951_/X }
C {devices/lab_pin.sym} 139620 -20330 0 0 {name=p138823 lab=_51973_/X }
C {devices/lab_pin.sym} 139780 -20370 0 1 {name=p138824 lab=_85914_/D }
C {sky130_stdcells/a21oi_4.sym} 139700 -20370 0 0 {name=X_51974_ }
C {devices/lab_pin.sym} 139610 -20230 0 0 {name=p138825 lab=_82797_/CLK }
C {devices/lab_pin.sym} 139610 -20210 0 0 {name=p138826 lab=_82826_/Q }
C {devices/lab_pin.sym} 139790 -20230 0 1 {name=p138827 lab=_78418_/A }
C {sky130_stdcells/dfxtp_4.sym} 139700 -20220 0 0 {name=X_82794_ }
C {devices/lab_pin.sym} 139640 -20110 0 0 {name=p138828 lab=_56510_/A }
C {devices/lab_pin.sym} 139640 -20070 0 0 {name=p138829 lab=_56507_/B }
C {devices/lab_pin.sym} 139640 -20030 0 0 {name=p138830 lab=_56501_/C }
C {devices/lab_pin.sym} 139760 -20070 0 1 {name=p138831 lab=_56501_/Y }
C {sky130_stdcells/nand3_4.sym} 139700 -20070 0 0 {name=X_56501_ }
C {devices/lab_pin.sym} 139660 -19930 0 0 {name=p138832 lab=clkbuf_7_63_0_CLK/X }
C {devices/lab_pin.sym} 139740 -19930 0 1 {name=p138833 lab=clkbuf_9_253_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 139700 -19930 0 0 {name=Xclkbuf_8_126_0_CLK }
C {devices/lab_pin.sym} 139610 -19810 0 0 {name=p138834 lab=_87577_/CLK }
C {devices/lab_pin.sym} 139610 -19790 0 0 {name=p138835 lab=_87321_/D }
C {devices/lab_pin.sym} 139790 -19810 0 1 {name=p138836 lab=_74166_/A }
C {sky130_stdcells/dfxtp_4.sym} 139700 -19800 0 0 {name=X_87321_ }
C {devices/lab_pin.sym} 139640 -19680 0 0 {name=p138837 lab=_53713_/A }
C {devices/lab_pin.sym} 139640 -19640 0 0 {name=p138838 lab=_48572_/A }
C {devices/lab_pin.sym} 139760 -19660 0 1 {name=p138839 lab=_53713_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -19660 0 0 {name=X_53713_ }
C {devices/lab_pin.sym} 139610 -19530 0 0 {name=p138840 lab=_84538_/CLK }
C {devices/lab_pin.sym} 139610 -19510 0 0 {name=p138841 lab=_84533_/D }
C {devices/lab_pin.sym} 139790 -19530 0 1 {name=p138842 lab=_76981_/A }
C {sky130_stdcells/dfxtp_4.sym} 139700 -19520 0 0 {name=X_84533_ }
C {devices/lab_pin.sym} 139620 -19410 0 0 {name=p138843 lab=_50922_/Y }
C {devices/lab_pin.sym} 139620 -19370 0 0 {name=p138844 lab=_50902_/X }
C {devices/lab_pin.sym} 139620 -19330 0 0 {name=p138845 lab=_50924_/X }
C {devices/lab_pin.sym} 139780 -19370 0 1 {name=p138846 lab=_86106_/D }
C {sky130_stdcells/a21oi_4.sym} 139700 -19370 0 0 {name=X_50925_ }
C {devices/lab_pin.sym} 139660 -19230 0 0 {name=p138847 lab=clkbuf_9_60_0_CLK/X }
C {devices/lab_pin.sym} 139740 -19230 0 1 {name=p138848 lab=_84293_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 139700 -19230 0 0 {name=Xclkbuf_10_121_0_CLK }
C {devices/lab_pin.sym} 139610 -19110 0 0 {name=p138849 lab=_82642_/CLK }
C {devices/lab_pin.sym} 139610 -19090 0 0 {name=p138850 lab=_81745_/D }
C {devices/lab_pin.sym} 139790 -19110 0 1 {name=p138851 lab=_41369_/A }
C {sky130_stdcells/dfxtp_4.sym} 139700 -19100 0 0 {name=X_81745_ }
C {devices/lab_pin.sym} 139660 -18970 0 0 {name=p138852 lab=_57481_/A }
C {devices/lab_pin.sym} 139740 -18970 0 1 {name=p138853 lab=_84996_/D }
C {sky130_stdcells/inv_2.sym} 139700 -18970 0 0 {name=X_57481_ }
C {devices/lab_pin.sym} 139620 -18880 0 0 {name=p138854 lab=_88027_/Q }
C {devices/lab_pin.sym} 139620 -18840 0 0 {name=p138855 lab=_69424_/X }
C {devices/lab_pin.sym} 139620 -18800 0 0 {name=p138856 lab=_69465_/X }
C {devices/lab_pin.sym} 139620 -18760 0 0 {name=p138857 lab=_69466_/X }
C {devices/lab_pin.sym} 139780 -18820 0 1 {name=p138858 lab=_69467_/X }
C {sky130_stdcells/a211o_4.sym} 139700 -18820 0 0 {name=X_69467_ }
C {devices/lab_pin.sym} 139660 -18670 0 0 {name=p138859 lab=_54284_/A }
C {devices/lab_pin.sym} 139740 -18670 0 1 {name=p138860 lab=_54693_/X }
C {sky130_stdcells/buf_2.sym} 139700 -18670 0 0 {name=X_54693_ }
C {devices/lab_pin.sym} 139640 -18560 0 0 {name=p138861 lab=_66602_/A }
C {devices/lab_pin.sym} 139640 -18520 0 0 {name=p138862 lab=_86834_/Q }
C {devices/lab_pin.sym} 139760 -18540 0 1 {name=p138863 lab=_66679_/X }
C {sky130_stdcells/and2_4.sym} 139700 -18540 0 0 {name=X_66679_ }
C {devices/lab_pin.sym} 139660 -18410 0 0 {name=p138864 lab=_58847_/A }
C {devices/lab_pin.sym} 139740 -18410 0 1 {name=p138865 lab=_59220_/X }
C {sky130_stdcells/buf_2.sym} 139700 -18410 0 0 {name=X_59220_ }
C {devices/lab_pin.sym} 139660 -18290 0 0 {name=p138866 lab=clkbuf_9_375_0_CLK/X }
C {devices/lab_pin.sym} 139740 -18290 0 1 {name=p138867 lab=_87758_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 139700 -18290 0 0 {name=Xclkbuf_10_751_0_CLK }
C {devices/lab_pin.sym} 139620 -18190 0 0 {name=p138868 lab=_56121_/X }
C {devices/lab_pin.sym} 139620 -18150 0 0 {name=p138869 lab=_56426_/X }
C {devices/lab_pin.sym} 139620 -18110 0 0 {name=p138870 lab=_56431_/Y }
C {devices/lab_pin.sym} 139780 -18150 0 1 {name=p138871 lab=_85196_/D }
C {sky130_stdcells/o21ai_4.sym} 139700 -18150 0 0 {name=X_56432_ }
C {devices/lab_pin.sym} 139640 -18020 0 0 {name=p138872 lab=_69001_/A }
C {devices/lab_pin.sym} 139640 -17980 0 0 {name=p138873 lab=_68418_/B }
C {devices/lab_pin.sym} 139760 -18000 0 1 {name=p138874 lab=_68418_/Y }
C {sky130_stdcells/nor2_4.sym} 139700 -18000 0 0 {name=X_68418_ }
C {devices/lab_pin.sym} 139610 -17870 0 0 {name=p138875 lab=_87766_/CLK }
C {devices/lab_pin.sym} 139610 -17850 0 0 {name=p138876 lab=_87252_/D }
C {devices/lab_pin.sym} 139790 -17870 0 1 {name=p138877 lab=_69555_/B }
C {sky130_stdcells/dfxtp_4.sym} 139700 -17860 0 0 {name=X_87252_ }
C {devices/lab_pin.sym} 139620 -17750 0 0 {name=p138878 lab=_85596_/Q }
C {devices/lab_pin.sym} 139620 -17710 0 0 {name=p138879 lab=_53610_/X }
C {devices/lab_pin.sym} 139620 -17670 0 0 {name=p138880 lab=_53643_/Y }
C {devices/lab_pin.sym} 139780 -17710 0 1 {name=p138881 lab=_53644_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -17710 0 0 {name=X_53644_ }
C {devices/lab_pin.sym} 139610 -17570 0 0 {name=p138882 lab=_84469_/CLK }
C {devices/lab_pin.sym} 139610 -17550 0 0 {name=p138883 lab=_61635_/Y }
C {devices/lab_pin.sym} 139790 -17570 0 1 {name=p138884 lab=_79132_/B }
C {sky130_stdcells/dfxtp_4.sym} 139700 -17560 0 0 {name=X_84464_ }
C {devices/lab_pin.sym} 139660 -17430 0 0 {name=p138885 lab=_50213_/X }
C {devices/lab_pin.sym} 139740 -17430 0 1 {name=p138886 lab=_50856_/X }
C {sky130_stdcells/buf_2.sym} 139700 -17430 0 0 {name=X_50856_ }
C {devices/lab_pin.sym} 139610 -17310 0 0 {name=p138887 lab=_81660_/CLK }
C {devices/lab_pin.sym} 139610 -17290 0 0 {name=p138888 lab=_80036_/X }
C {devices/lab_pin.sym} 139790 -17310 0 1 {name=p138889 lab=_81676_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -17300 0 0 {name=X_81676_ }
C {devices/lab_pin.sym} 139620 -17200 0 0 {name=p138890 lab=_87520_/Q }
C {devices/lab_pin.sym} 139620 -17160 0 0 {name=p138891 lab=_69261_/X }
C {devices/lab_pin.sym} 139620 -17120 0 0 {name=p138892 lab=_69396_/X }
C {devices/lab_pin.sym} 139620 -17080 0 0 {name=p138893 lab=_69397_/X }
C {devices/lab_pin.sym} 139780 -17140 0 1 {name=p138894 lab=_69398_/X }
C {sky130_stdcells/a211o_4.sym} 139700 -17140 0 0 {name=X_69398_ }
C {devices/lab_pin.sym} 139610 -16990 0 0 {name=p138895 lab=_86203_/CLK }
C {devices/lab_pin.sym} 139610 -16970 0 0 {name=p138896 lab=_86203_/D }
C {devices/lab_pin.sym} 139790 -16990 0 1 {name=p138897 lab=_86203_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -16980 0 0 {name=X_86203_ }
C {devices/lab_pin.sym} 139620 -16870 0 0 {name=p138898 lab=_59148_/Y }
C {devices/lab_pin.sym} 139620 -16830 0 0 {name=p138899 lab=_59150_/Y }
C {devices/lab_pin.sym} 139620 -16790 0 0 {name=p138900 lab=_58939_/X }
C {devices/lab_pin.sym} 139780 -16830 0 1 {name=p138901 lab=_59151_/X }
C {sky130_stdcells/a21o_4.sym} 139700 -16830 0 0 {name=X_59151_ }
C {devices/lab_pin.sym} 139660 -16690 0 0 {name=p138902 lab=clkbuf_9_243_0_CLK/A }
C {devices/lab_pin.sym} 139740 -16690 0 1 {name=p138903 lab=clkbuf_9_242_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 139700 -16690 0 0 {name=Xclkbuf_9_242_0_CLK }
C {devices/lab_pin.sym} 139610 -16570 0 0 {name=p138904 lab=_83415_/CLK }
C {devices/lab_pin.sym} 139610 -16550 0 0 {name=p138905 lab=_83415_/D }
C {devices/lab_pin.sym} 139790 -16570 0 1 {name=p138906 lab=_83415_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -16560 0 0 {name=X_83415_ }
C {devices/lab_pin.sym} 139640 -16440 0 0 {name=p138907 lab=_84776_/Q }
C {devices/lab_pin.sym} 139640 -16400 0 0 {name=p138908 lab=_84168_/Q }
C {devices/lab_pin.sym} 139760 -16420 0 1 {name=p138909 lab=_80627_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -16420 0 0 {name=X_80627_ }
C {devices/lab_pin.sym} 139640 -16310 0 0 {name=p138910 lab=_56360_/A }
C {devices/lab_pin.sym} 139640 -16270 0 0 {name=p138911 lab=_56363_/B }
C {devices/lab_pin.sym} 139640 -16230 0 0 {name=p138912 lab=_55722_/B }
C {devices/lab_pin.sym} 139760 -16270 0 1 {name=p138913 lab=_56363_/Y }
C {sky130_stdcells/nand3_4.sym} 139700 -16270 0 0 {name=X_56363_ }
C {devices/lab_pin.sym} 139660 -16130 0 0 {name=p138914 lab=_69178_/A }
C {devices/lab_pin.sym} 139740 -16130 0 1 {name=p138915 lab=_69906_/A }
C {sky130_stdcells/buf_2.sym} 139700 -16130 0 0 {name=X_68349_ }
C {devices/lab_pin.sym} 139610 -16010 0 0 {name=p138916 lab=_87183_/CLK }
C {devices/lab_pin.sym} 139610 -15990 0 0 {name=p138917 lab=_44200_/Y }
C {devices/lab_pin.sym} 139790 -16010 0 1 {name=p138918 lab=_43983_/A }
C {sky130_stdcells/dfxtp_4.sym} 139700 -16000 0 0 {name=X_87183_ }
C {devices/lab_pin.sym} 139640 -15880 0 0 {name=p138919 lab=_53565_/A }
C {devices/lab_pin.sym} 139640 -15840 0 0 {name=p138920 lab=_57609_/B }
C {devices/lab_pin.sym} 139760 -15860 0 1 {name=p138921 lab=_53575_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -15860 0 0 {name=X_53575_ }
C {devices/lab_pin.sym} 139610 -15730 0 0 {name=p138922 lab=_84396_/CLK }
C {devices/lab_pin.sym} 139610 -15710 0 0 {name=p138923 lab=_62627_/Y }
C {devices/lab_pin.sym} 139790 -15730 0 1 {name=p138924 lab=_84395_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -15720 0 0 {name=X_84395_ }
C {devices/lab_pin.sym} 139660 -15590 0 0 {name=p138925 lab=_50718_/A }
C {devices/lab_pin.sym} 139740 -15590 0 1 {name=p138926 lab=_50787_/X }
C {sky130_stdcells/buf_2.sym} 139700 -15590 0 0 {name=X_50787_ }
C {devices/lab_pin.sym} 139620 -15490 0 0 {name=p138927 lab=_58085_/X }
C {devices/lab_pin.sym} 139620 -15450 0 0 {name=p138928 lab=_85381_/Q }
C {devices/lab_pin.sym} 139620 -15410 0 0 {name=p138929 lab=_58101_/X }
C {devices/lab_pin.sym} 139780 -15450 0 1 {name=p138930 lab=_58102_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -15450 0 0 {name=X_58102_ }
C {devices/lab_pin.sym} 139640 -15320 0 0 {name=p138931 lab=_55323_/A }
C {devices/lab_pin.sym} 139640 -15280 0 0 {name=p138932 lab=_85135_/Q }
C {devices/lab_pin.sym} 139760 -15300 0 1 {name=p138933 lab=_55314_/X }
C {sky130_stdcells/and2_4.sym} 139700 -15300 0 0 {name=X_55314_ }
C {devices/lab_pin.sym} 139660 -15170 0 0 {name=p138934 lab=clkbuf_9_68_0_CLK/X }
C {devices/lab_pin.sym} 139740 -15170 0 1 {name=p138935 lab=_81296_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 139700 -15170 0 0 {name=Xclkbuf_10_136_0_CLK }
C {devices/lab_pin.sym} 139610 -15050 0 0 {name=p138936 lab=_85527_/CLK }
C {devices/lab_pin.sym} 139610 -15030 0 0 {name=p138937 lab=_86134_/D }
C {devices/lab_pin.sym} 139790 -15050 0 1 {name=p138938 lab=_86134_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -15040 0 0 {name=X_86134_ }
C {devices/lab_pin.sym} 139640 -14920 0 0 {name=p138939 lab=_82307_/Q }
C {devices/lab_pin.sym} 139640 -14880 0 0 {name=p138940 lab=_40467_/B }
C {devices/lab_pin.sym} 139760 -14900 0 1 {name=p138941 lab=_40540_/X }
C {sky130_stdcells/or2_4.sym} 139700 -14900 0 0 {name=X_40540_ }
C {devices/lab_pin.sym} 139640 -14780 0 0 {name=p138942 lab=_52518_/A }
C {devices/lab_pin.sym} 139640 -14740 0 0 {name=p138943 lab=_52526_/B }
C {devices/lab_pin.sym} 139760 -14760 0 1 {name=p138944 lab=_52526_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -14760 0 0 {name=X_52526_ }
C {devices/lab_pin.sym} 139620 -14650 0 0 {name=p138945 lab=_58934_/X }
C {devices/lab_pin.sym} 139620 -14610 0 0 {name=p138946 lab=_85658_/Q }
C {devices/lab_pin.sym} 139620 -14570 0 0 {name=p138947 lab=_59081_/X }
C {devices/lab_pin.sym} 139780 -14610 0 1 {name=p138948 lab=_59082_/X }
C {sky130_stdcells/o21a_4.sym} 139700 -14610 0 0 {name=X_59082_ }
C {devices/lab_pin.sym} 139620 -14490 0 0 {name=p138949 lab=_71344_/X }
C {devices/lab_pin.sym} 139620 -14450 0 0 {name=p138950 lab=_83526_/Q }
C {devices/lab_pin.sym} 139620 -14410 0 0 {name=p138951 lab=_71359_/X }
C {devices/lab_pin.sym} 139780 -14450 0 1 {name=p138952 lab=_71360_/X }
C {sky130_stdcells/a21o_4.sym} 139700 -14450 0 0 {name=X_71360_ }
C {devices/lab_pin.sym} 139610 -14310 0 0 {name=p138953 lab=_82251_/CLK }
C {devices/lab_pin.sym} 139610 -14290 0 0 {name=p138954 lab=_83346_/D }
C {devices/lab_pin.sym} 139790 -14310 0 1 {name=p138955 lab=_83346_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -14300 0 0 {name=X_83346_ }
C {devices/lab_pin.sym} 139620 -14190 0 0 {name=p138956 lab=_56284_/X }
C {devices/lab_pin.sym} 139620 -14150 0 0 {name=p138957 lab=_56016_/X }
C {devices/lab_pin.sym} 139620 -14110 0 0 {name=p138958 lab=_56293_/Y }
C {devices/lab_pin.sym} 139780 -14150 0 1 {name=p138959 lab=_56294_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -14150 0 0 {name=X_56294_ }
C {devices/lab_pin.sym} 139640 -14020 0 0 {name=p138960 lab=_84771_/Q }
C {devices/lab_pin.sym} 139640 -13980 0 0 {name=p138961 lab=_84163_/Q }
C {devices/lab_pin.sym} 139760 -14000 0 1 {name=p138962 lab=_80560_/A }
C {sky130_stdcells/xor2_4.sym} 139700 -14000 0 0 {name=X_80558_ }
C {devices/lab_pin.sym} 139660 -13870 0 0 {name=p138963 lab=clkbuf_9_383_0_CLK/X }
C {devices/lab_pin.sym} 139740 -13870 0 1 {name=p138964 lab=_87782_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 139700 -13870 0 0 {name=Xclkbuf_10_766_0_CLK }
C {devices/lab_pin.sym} 139620 -13770 0 0 {name=p138965 lab=_57966_/X }
C {devices/lab_pin.sym} 139620 -13730 0 0 {name=p138966 lab=_85707_/Q }
C {devices/lab_pin.sym} 139620 -13690 0 0 {name=p138967 lab=_58020_/X }
C {devices/lab_pin.sym} 139780 -13730 0 1 {name=p138968 lab=_58033_/X }
C {sky130_stdcells/o21a_4.sym} 139700 -13730 0 0 {name=X_58033_ }
C {devices/lab_pin.sym} 139660 -13590 0 0 {name=p138969 lab=_70247_/X }
C {devices/lab_pin.sym} 139740 -13590 0 1 {name=p138970 lab=_70328_/B }
C {sky130_stdcells/buf_2.sym} 139700 -13590 0 0 {name=X_70311_ }
C {devices/lab_pin.sym} 139660 -13470 0 0 {name=p138971 lab=_55245_/A }
C {devices/lab_pin.sym} 139740 -13470 0 1 {name=p138972 lab=_55276_/A }
C {sky130_stdcells/buf_2.sym} 139700 -13470 0 0 {name=X_55245_ }
C {devices/lab_pin.sym} 139610 -13350 0 0 {name=p138973 lab=_85748_/CLK }
C {devices/lab_pin.sym} 139610 -13330 0 0 {name=p138974 lab=_51151_/Y }
C {devices/lab_pin.sym} 139790 -13350 0 1 {name=p138975 lab=_86065_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -13340 0 0 {name=X_86065_ }
C {devices/lab_pin.sym} 139620 -13230 0 0 {name=p138976 lab=_85818_/Q }
C {devices/lab_pin.sym} 139620 -13190 0 0 {name=p138977 lab=_52438_/X }
C {devices/lab_pin.sym} 139620 -13150 0 0 {name=p138978 lab=_52456_/Y }
C {devices/lab_pin.sym} 139780 -13190 0 1 {name=p138979 lab=_52457_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -13190 0 0 {name=X_52457_ }
C {devices/lab_pin.sym} 139660 -13050 0 0 {name=p138980 lab=_40947_/A }
C {devices/lab_pin.sym} 139740 -13050 0 1 {name=p138981 lab=_40471_/X }
C {sky130_stdcells/buf_2.sym} 139700 -13050 0 0 {name=X_40471_ }
C {devices/lab_pin.sym} 139660 -12930 0 0 {name=p138982 lab=_71287_/Y }
C {devices/lab_pin.sym} 139740 -12930 0 1 {name=p138983 lab=_71291_/Y }
C {sky130_stdcells/inv_2.sym} 139700 -12930 0 0 {name=X_71291_ }
C {devices/lab_pin.sym} 139610 -12810 0 0 {name=p138984 lab=_83278_/CLK }
C {devices/lab_pin.sym} 139610 -12790 0 0 {name=p138985 lab=_83277_/D }
C {devices/lab_pin.sym} 139790 -12810 0 1 {name=p138986 lab=_72165_/A }
C {sky130_stdcells/dfxtp_4.sym} 139700 -12800 0 0 {name=X_83277_ }
C {devices/lab_pin.sym} 139640 -12680 0 0 {name=p138987 lab=_80489_/A }
C {devices/lab_pin.sym} 139640 -12640 0 0 {name=p138988 lab=_80489_/B }
C {devices/lab_pin.sym} 139760 -12660 0 1 {name=p138989 lab=_80489_/X }
C {sky130_stdcells/or2_4.sym} 139700 -12660 0 0 {name=X_80489_ }
C {devices/lab_pin.sym} 139660 -12530 0 0 {name=p138990 lab=clkbuf_8_128_0_CLK/X }
C {devices/lab_pin.sym} 139740 -12530 0 1 {name=p138991 lab=clkbuf_9_257_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 139700 -12530 0 0 {name=Xclkbuf_9_257_0_CLK }
C {devices/lab_pin.sym} 139660 -12410 0 0 {name=p138992 lab=_42162_/A }
C {devices/lab_pin.sym} 139740 -12410 0 1 {name=p138993 lab=_42210_/X }
C {sky130_stdcells/buf_2.sym} 139700 -12410 0 0 {name=X_42210_ }
C {devices/lab_pin.sym} 139660 -12290 0 0 {name=p138994 lab=_44127_/X }
C {devices/lab_pin.sym} 139740 -12290 0 1 {name=p138995 lab=_73030_/X }
C {sky130_stdcells/buf_2.sym} 139700 -12290 0 0 {name=X_73030_ }
C {devices/lab_pin.sym} 139610 -12170 0 0 {name=p138996 lab=_85049_/CLK }
C {devices/lab_pin.sym} 139610 -12150 0 0 {name=p138997 lab=_85016_/D }
C {devices/lab_pin.sym} 139790 -12170 0 1 {name=p138998 lab=_85016_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -12160 0 0 {name=X_85016_ }
C {devices/lab_pin.sym} 139640 -12040 0 0 {name=p138999 lab=_51403_/X }
C {devices/lab_pin.sym} 139640 -12000 0 0 {name=p139000 lab=_52936_/B }
C {devices/lab_pin.sym} 139760 -12020 0 1 {name=p139001 lab=_51408_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -12020 0 0 {name=X_51408_ }
C {devices/lab_pin.sym} 139620 -11910 0 0 {name=p139002 lab=_70238_/X }
C {devices/lab_pin.sym} 139620 -11870 0 0 {name=p139003 lab=_74804_/B }
C {devices/lab_pin.sym} 139620 -11830 0 0 {name=p139004 lab=_70241_/X }
C {devices/lab_pin.sym} 139780 -11870 0 1 {name=p139005 lab=_83825_/D }
C {sky130_stdcells/a21o_4.sym} 139700 -11870 0 0 {name=X_70242_ }
C {devices/lab_pin.sym} 139610 -11730 0 0 {name=p139006 lab=_82515_/CLK }
C {devices/lab_pin.sym} 139610 -11710 0 0 {name=p139007 lab=_82260_/Q }
C {devices/lab_pin.sym} 139790 -11730 0 1 {name=p139008 lab=_82228_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -11720 0 0 {name=X_82228_ }
C {devices/lab_pin.sym} 139660 -11590 0 0 {name=p139009 lab=_43190_/A }
C {devices/lab_pin.sym} 139740 -11590 0 1 {name=p139010 lab=_43190_/Y }
C {sky130_stdcells/inv_2.sym} 139700 -11590 0 0 {name=X_43190_ }
C {devices/lab_pin.sym} 139660 -11470 0 0 {name=p139011 lab=_85132_/Q }
C {devices/lab_pin.sym} 139740 -11470 0 1 {name=p139012 lab=_55176_/Y }
C {sky130_stdcells/inv_2.sym} 139700 -11470 0 0 {name=X_55176_ }
C {devices/lab_pin.sym} 139620 -11370 0 0 {name=p139013 lab=_65247_/B }
C {devices/lab_pin.sym} 139620 -11330 0 0 {name=p139014 lab=_52372_/X }
C {devices/lab_pin.sym} 139620 -11290 0 0 {name=p139015 lab=_52387_/Y }
C {devices/lab_pin.sym} 139780 -11330 0 1 {name=p139016 lab=_52388_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -11330 0 0 {name=X_52388_ }
C {devices/lab_pin.sym} 139660 -11190 0 0 {name=p139017 lab=_42077_/A }
C {devices/lab_pin.sym} 139740 -11190 0 1 {name=p139018 lab=_42141_/X }
C {sky130_stdcells/buf_2.sym} 139700 -11190 0 0 {name=X_42141_ }
C {devices/lab_pin.sym} 139660 -11070 0 0 {name=p139019 lab=_53418_/X }
C {devices/lab_pin.sym} 139740 -11070 0 1 {name=p139020 lab=_54127_/X }
C {sky130_stdcells/buf_2.sym} 139700 -11070 0 0 {name=X_54127_ }
C {devices/lab_pin.sym} 139660 -10950 0 0 {name=p139021 lab=_51793_/A }
C {devices/lab_pin.sym} 139740 -10950 0 1 {name=p139022 lab=_51339_/X }
C {sky130_stdcells/buf_2.sym} 139700 -10950 0 0 {name=X_51339_ }
C {devices/lab_pin.sym} 139660 -10830 0 0 {name=p139023 lab=_70232_/A }
C {devices/lab_pin.sym} 139740 -10830 0 1 {name=p139024 lab=_70183_/B }
C {sky130_stdcells/buf_2.sym} 139700 -10830 0 0 {name=X_70173_ }
C {devices/lab_pin.sym} 139610 -10710 0 0 {name=p139025 lab=_84197_/CLK }
C {devices/lab_pin.sym} 139610 -10690 0 0 {name=p139026 lab=_84151_/Q }
C {devices/lab_pin.sym} 139790 -10710 0 1 {name=p139027 lab=_82159_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -10700 0 0 {name=X_82159_ }
C {devices/lab_pin.sym} 139660 -10570 0 0 {name=p139028 lab=_59976_/A }
C {devices/lab_pin.sym} 139740 -10570 0 1 {name=p139029 lab=_62576_/C }
C {sky130_stdcells/buf_2.sym} 139700 -10570 0 0 {name=X_59984_ }
C {devices/lab_pin.sym} 139620 -10470 0 0 {name=p139030 lab=_58934_/X }
C {devices/lab_pin.sym} 139620 -10430 0 0 {name=p139031 lab=_85924_/Q }
C {devices/lab_pin.sym} 139620 -10390 0 0 {name=p139032 lab=_58793_/X }
C {devices/lab_pin.sym} 139780 -10430 0 1 {name=p139033 lab=_58935_/X }
C {sky130_stdcells/o21a_4.sym} 139700 -10430 0 0 {name=X_58935_ }
C {devices/lab_pin.sym} 139640 -10300 0 0 {name=p139034 lab=_54020_/A }
C {devices/lab_pin.sym} 139640 -10260 0 0 {name=p139035 lab=_54058_/B }
C {devices/lab_pin.sym} 139760 -10280 0 1 {name=p139036 lab=_54058_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -10280 0 0 {name=X_54058_ }
C {devices/lab_pin.sym} 139660 -10150 0 0 {name=p139037 lab=_51719_/A }
C {devices/lab_pin.sym} 139740 -10150 0 1 {name=p139038 lab=_42072_/X }
C {sky130_stdcells/buf_2.sym} 139700 -10150 0 0 {name=X_42072_ }
C {devices/lab_pin.sym} 139640 -10040 0 0 {name=p139039 lab=_74987_/B }
C {devices/lab_pin.sym} 139640 -10000 0 0 {name=p139040 lab=_74987_/C }
C {devices/lab_pin.sym} 139760 -10020 0 1 {name=p139041 lab=_74981_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -10020 0 0 {name=X_74981_ }
C {devices/lab_pin.sym} 139610 -9890 0 0 {name=p139042 lab=_86934_/CLK }
C {devices/lab_pin.sym} 139610 -9870 0 0 {name=p139043 lab=_86967_/D }
C {devices/lab_pin.sym} 139790 -9890 0 1 {name=p139044 lab=_86967_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -9880 0 0 {name=X_86967_ }
C {devices/lab_pin.sym} 139640 -9770 0 0 {name=p139045 lab=_42447_/C }
C {devices/lab_pin.sym} 139640 -9730 0 0 {name=p139046 lab=_45893_/B }
C {devices/lab_pin.sym} 139640 -9690 0 0 {name=p139047 lab=_45893_/C }
C {devices/lab_pin.sym} 139760 -9730 0 1 {name=p139048 lab=_45900_/Y }
C {sky130_stdcells/nor3_4.sym} 139700 -9730 0 0 {name=X_45900_ }
C {devices/lab_pin.sym} 139660 -9590 0 0 {name=p139049 lab=_41022_/Y }
C {devices/lab_pin.sym} 139740 -9590 0 1 {name=p139050 lab=_88292_/D }
C {sky130_stdcells/inv_2.sym} 139700 -9590 0 0 {name=X_41023_ }
C {devices/lab_pin.sym} 139620 -9490 0 0 {name=p139051 lab=_53006_/Y }
C {devices/lab_pin.sym} 139620 -9450 0 0 {name=p139052 lab=_53001_/X }
C {devices/lab_pin.sym} 139620 -9410 0 0 {name=p139053 lab=_53008_/X }
C {devices/lab_pin.sym} 139780 -9450 0 1 {name=p139054 lab=_53009_/Y }
C {sky130_stdcells/a21oi_4.sym} 139700 -9450 0 0 {name=X_53009_ }
C {devices/lab_pin.sym} 139640 -9320 0 0 {name=p139055 lab=_76708_/A }
C {devices/lab_pin.sym} 139640 -9280 0 0 {name=p139056 lab=_76707_/X }
C {devices/lab_pin.sym} 139760 -9300 0 1 {name=p139057 lab=_76720_/X }
C {sky130_stdcells/or2_4.sym} 139700 -9300 0 0 {name=X_76720_ }
C {devices/lab_pin.sym} 139610 -9170 0 0 {name=p139058 lab=_86558_/CLK }
C {devices/lab_pin.sym} 139610 -9150 0 0 {name=p139059 lab=_85918_/D }
C {devices/lab_pin.sym} 139790 -9170 0 1 {name=p139060 lab=_73636_/B }
C {sky130_stdcells/dfxtp_4.sym} 139700 -9160 0 0 {name=X_85918_ }
C {devices/lab_pin.sym} 139620 -9060 0 0 {name=p139061 lab=_73930_/X }
C {devices/lab_pin.sym} 139620 -9020 0 0 {name=p139062 lab=_84978_/Q }
C {devices/lab_pin.sym} 139620 -8980 0 0 {name=p139063 lab=_45885_/X }
C {devices/lab_pin.sym} 139620 -8940 0 0 {name=p139064 lab=_73931_/X }
C {devices/lab_pin.sym} 139780 -9000 0 1 {name=p139065 lab=_73932_/X }
C {sky130_stdcells/a211o_4.sym} 139700 -9000 0 0 {name=X_73932_ }
C {devices/lab_pin.sym} 139640 -8860 0 0 {name=p139066 lab=_46860_/X }
C {devices/lab_pin.sym} 139640 -8820 0 0 {name=p139067 lab=_51037_/B }
C {devices/lab_pin.sym} 139760 -8840 0 1 {name=p139068 lab=_46880_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -8840 0 0 {name=X_46880_ }
C {devices/lab_pin.sym} 139640 -8720 0 0 {name=p139069 lab=_58941_/A }
C {devices/lab_pin.sym} 139640 -8680 0 0 {name=p139070 lab=_86378_/Q }
C {devices/lab_pin.sym} 139760 -8700 0 1 {name=p139071 lab=_58866_/Y }
C {sky130_stdcells/nor2_4.sym} 139700 -8700 0 0 {name=X_58866_ }
C {devices/lab_pin.sym} 139610 -8570 0 0 {name=p139072 lab=_86887_/CLK }
C {devices/lab_pin.sym} 139610 -8550 0 0 {name=p139073 lab=_45112_/Y }
C {devices/lab_pin.sym} 139790 -8570 0 1 {name=p139074 lab=_64364_/B }
C {sky130_stdcells/dfxtp_4.sym} 139700 -8560 0 0 {name=X_86898_ }
C {devices/lab_pin.sym} 139660 -8430 0 0 {name=p139075 lab=clkbuf_9_352_0_CLK/X }
C {devices/lab_pin.sym} 139740 -8430 0 1 {name=p139076 lab=_86784_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 139700 -8430 0 0 {name=Xclkbuf_10_704_0_CLK }
C {devices/lab_pin.sym} 139660 -8310 0 0 {name=p139077 lab=_82981_/Q }
C {devices/lab_pin.sym} 139740 -8310 0 1 {name=p139078 lab=_45832_/A }
C {sky130_stdcells/inv_2.sym} 139700 -8310 0 0 {name=X_45831_ }
C {devices/lab_pin.sym} 139620 -8210 0 0 {name=p139079 lab=_57813_/Y }
C {devices/lab_pin.sym} 139620 -8170 0 0 {name=p139080 lab=_57816_/Y }
C {devices/lab_pin.sym} 139620 -8130 0 0 {name=p139081 lab=_57718_/X }
C {devices/lab_pin.sym} 139780 -8170 0 1 {name=p139082 lab=_57817_/X }
C {sky130_stdcells/a21o_4.sym} 139700 -8170 0 0 {name=X_57817_ }
C {devices/lab_pin.sym} 139640 -8040 0 0 {name=p139083 lab=_76650_/Y }
C {devices/lab_pin.sym} 139640 -8000 0 0 {name=p139084 lab=_81682_/Q }
C {devices/lab_pin.sym} 139760 -8020 0 1 {name=p139085 lab=_76651_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -8020 0 0 {name=X_76651_ }
C {devices/lab_pin.sym} 139640 -7900 0 0 {name=p139086 lab=_73863_/A }
C {devices/lab_pin.sym} 139640 -7860 0 0 {name=p139087 lab=_73863_/B }
C {devices/lab_pin.sym} 139760 -7880 0 1 {name=p139088 lab=_73864_/B }
C {sky130_stdcells/nand2_4.sym} 139700 -7880 0 0 {name=X_73863_ }
C {devices/lab_pin.sym} 139610 -7750 0 0 {name=p139089 lab=_85558_/CLK }
C {devices/lab_pin.sym} 139610 -7730 0 0 {name=p139090 lab=_85849_/D }
C {devices/lab_pin.sym} 139790 -7750 0 1 {name=p139091 lab=_64826_/B }
C {sky130_stdcells/dfxtp_4.sym} 139700 -7740 0 0 {name=X_85849_ }
C {devices/lab_pin.sym} 139620 -7630 0 0 {name=p139092 lab=_58714_/X }
C {devices/lab_pin.sym} 139620 -7590 0 0 {name=p139093 lab=_85775_/Q }
C {devices/lab_pin.sym} 139620 -7550 0 0 {name=p139094 lab=_58716_/X }
C {devices/lab_pin.sym} 139780 -7590 0 1 {name=p139095 lab=_58797_/X }
C {sky130_stdcells/o21a_4.sym} 139700 -7590 0 0 {name=X_58797_ }
C {devices/lab_pin.sym} 139620 -7470 0 0 {name=p139096 lab=_75601_/Y }
C {devices/lab_pin.sym} 139620 -7430 0 0 {name=p139097 lab=_75588_/Y }
C {devices/lab_pin.sym} 139620 -7390 0 0 {name=p139098 lab=_75595_/A }
C {devices/lab_pin.sym} 139780 -7430 0 1 {name=p139099 lab=_75602_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -7430 0 0 {name=X_75602_ }
C {devices/lab_pin.sym} 139660 -7290 0 0 {name=p139100 lab=_48550_/A }
C {devices/lab_pin.sym} 139740 -7290 0 1 {name=p139101 lab=_48550_/Y }
C {sky130_stdcells/inv_2.sym} 139700 -7290 0 0 {name=X_48550_ }
C {devices/lab_pin.sym} 139660 -7170 0 0 {name=p139102 lab=_72814_/A }
C {devices/lab_pin.sym} 139740 -7170 0 1 {name=p139103 lab=_73306_/A }
C {sky130_stdcells/buf_2.sym} 139700 -7170 0 0 {name=X_72814_ }
C {devices/lab_pin.sym} 139620 -7070 0 0 {name=p139104 lab=_58738_/Y }
C {devices/lab_pin.sym} 139620 -7030 0 0 {name=p139105 lab=_66435_/Y }
C {devices/lab_pin.sym} 139620 -6990 0 0 {name=p139106 lab=_79369_/Y }
C {devices/lab_pin.sym} 139780 -7030 0 1 {name=p139107 lab=_79374_/A }
C {sky130_stdcells/o21a_4.sym} 139700 -7030 0 0 {name=X_79370_ }
C {devices/lab_pin.sym} 139620 -6910 0 0 {name=p139108 lab=_45759_/X }
C {devices/lab_pin.sym} 139620 -6870 0 0 {name=p139109 lab=_45761_/Y }
C {devices/lab_pin.sym} 139620 -6830 0 0 {name=p139110 lab=_45714_/X }
C {devices/lab_pin.sym} 139780 -6870 0 1 {name=p139111 lab=_45762_/Y }
C {sky130_stdcells/a21oi_4.sym} 139700 -6870 0 0 {name=X_45762_ }
C {devices/lab_pin.sym} 139620 -6750 0 0 {name=p139112 lab=_46224_/X }
C {devices/lab_pin.sym} 139620 -6710 0 0 {name=p139113 lab=_85406_/Q }
C {devices/lab_pin.sym} 139620 -6670 0 0 {name=p139114 lab=_57747_/X }
C {devices/lab_pin.sym} 139780 -6710 0 1 {name=p139115 lab=_57748_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -6710 0 0 {name=X_57748_ }
C {devices/lab_pin.sym} 139640 -6580 0 0 {name=p139116 lab=_76614_/A }
C {devices/lab_pin.sym} 139640 -6540 0 0 {name=p139117 lab=_76614_/C }
C {devices/lab_pin.sym} 139760 -6560 0 1 {name=p139118 lab=_76583_/A }
C {sky130_stdcells/and2_4.sym} 139700 -6560 0 0 {name=X_76582_ }
C {devices/lab_pin.sym} 139620 -6470 0 0 {name=p139119 lab=_42970_/X }
C {devices/lab_pin.sym} 139620 -6430 0 0 {name=p139120 lab=_42971_/X }
C {devices/lab_pin.sym} 139620 -6390 0 0 {name=p139121 lab=_40440_/X }
C {devices/lab_pin.sym} 139620 -6350 0 0 {name=p139122 lab=_66861_/B }
C {devices/lab_pin.sym} 139620 -6310 0 0 {name=p139123 lab=_42954_/X }
C {devices/lab_pin.sym} 139780 -6390 0 1 {name=p139124 lab=_42975_/A }
C {sky130_stdcells/o32ai_4.sym} 139700 -6390 0 0 {name=X_42974_ }
C {devices/lab_pin.sym} 139620 -6250 0 0 {name=p139125 lab=_70106_/Y }
C {devices/lab_pin.sym} 139620 -6210 0 0 {name=p139126 lab=_73697_/X }
C {devices/lab_pin.sym} 139620 -6170 0 0 {name=p139127 lab=_73793_/X }
C {devices/lab_pin.sym} 139780 -6210 0 1 {name=p139128 lab=_73794_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -6210 0 0 {name=X_73794_ }
C {devices/lab_pin.sym} 139660 -6070 0 0 {name=p139129 lab=_47501_/A }
C {devices/lab_pin.sym} 139740 -6070 0 1 {name=p139130 lab=_47502_/A }
C {sky130_stdcells/inv_2.sym} 139700 -6070 0 0 {name=X_47501_ }
C {devices/lab_pin.sym} 139640 -5960 0 0 {name=p139131 lab=_78312_/A }
C {devices/lab_pin.sym} 139640 -5920 0 0 {name=p139132 lab=_82658_/D }
C {devices/lab_pin.sym} 139760 -5940 0 1 {name=p139133 lab=_78321_/Y }
C {sky130_stdcells/nand2_4.sym} 139700 -5940 0 0 {name=X_78321_ }
C {devices/lab_pin.sym} 139660 -5810 0 0 {name=p139134 lab=_41936_/A }
C {devices/lab_pin.sym} 139740 -5810 0 1 {name=p139135 lab=_44713_/X }
C {sky130_stdcells/buf_2.sym} 139700 -5810 0 0 {name=X_44713_ }
C {devices/lab_pin.sym} 139640 -5710 0 0 {name=p139136 lab=_75530_/Y }
C {devices/lab_pin.sym} 139640 -5670 0 0 {name=p139137 lab=_75533_/B }
C {devices/lab_pin.sym} 139640 -5630 0 0 {name=p139138 lab=_75531_/Y }
C {devices/lab_pin.sym} 139760 -5670 0 1 {name=p139139 lab=_75533_/Y }
C {sky130_stdcells/nand3_4.sym} 139700 -5670 0 0 {name=X_75533_ }
C {devices/lab_pin.sym} 139610 -5530 0 0 {name=p139140 lab=_87273_/CLK }
C {devices/lab_pin.sym} 139610 -5510 0 0 {name=p139141 lab=_43249_/X }
C {devices/lab_pin.sym} 139790 -5530 0 1 {name=p139142 lab=_87519_/Q }
C {sky130_stdcells/dfxtp_4.sym} 139700 -5520 0 0 {name=X_87519_ }
C {devices/lab_pin.sym} 139660 -5390 0 0 {name=p139143 lab=_41925_/A }
C {devices/lab_pin.sym} 139740 -5390 0 1 {name=p139144 lab=_88103_/D }
C {sky130_stdcells/inv_2.sym} 139700 -5390 0 0 {name=X_41925_ }
C {devices/lab_pin.sym} 139660 -5270 0 0 {name=p139145 lab=_73073_/A }
C {devices/lab_pin.sym} 139740 -5270 0 1 {name=p139146 lab=_48482_/B }
C {sky130_stdcells/buf_2.sym} 139700 -5270 0 0 {name=X_48481_ }
C {devices/lab_pin.sym} 139660 -5150 0 0 {name=p139147 lab=_72745_/A }
C {devices/lab_pin.sym} 139740 -5150 0 1 {name=p139148 lab=_73351_/A }
C {sky130_stdcells/buf_2.sym} 139700 -5150 0 0 {name=X_72745_ }
C {devices/lab_pin.sym} 139620 -5050 0 0 {name=p139149 lab=_85038_/Q }
C {devices/lab_pin.sym} 139620 -5010 0 0 {name=p139150 lab=_45675_/X }
C {devices/lab_pin.sym} 139620 -4970 0 0 {name=p139151 lab=_45692_/X }
C {devices/lab_pin.sym} 139780 -5010 0 1 {name=p139152 lab=_45693_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -5010 0 0 {name=X_45693_ }
C {devices/lab_pin.sym} 139660 -4870 0 0 {name=p139153 lab=_84955_/Q }
C {devices/lab_pin.sym} 139740 -4870 0 1 {name=p139154 lab=_57680_/A }
C {sky130_stdcells/buf_2.sym} 139700 -4870 0 0 {name=X_57679_ }
C {devices/lab_pin.sym} 139660 -4750 0 0 {name=p139155 lab=clkbuf_9_359_0_CLK/X }
C {devices/lab_pin.sym} 139740 -4750 0 1 {name=p139156 lab=_87757_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 139700 -4750 0 0 {name=Xclkbuf_10_719_0_CLK }
C {devices/lab_pin.sym} 139660 -4630 0 0 {name=p139157 lab=_47431_/Y }
C {devices/lab_pin.sym} 139740 -4630 0 1 {name=p139158 lab=_53046_/B }
C {sky130_stdcells/buf_2.sym} 139700 -4630 0 0 {name=X_47432_ }
C {devices/lab_pin.sym} 139660 -4510 0 0 {name=p139159 lab=_84738_/Q }
C {devices/lab_pin.sym} 139740 -4510 0 1 {name=p139160 lab=_59419_/A }
C {sky130_stdcells/inv_2.sym} 139700 -4510 0 0 {name=X_59418_ }
C {devices/lab_pin.sym} 139640 -4410 0 0 {name=p139161 lab=_78252_/A }
C {devices/lab_pin.sym} 139640 -4370 0 0 {name=p139162 lab=_78241_/X }
C {devices/lab_pin.sym} 139640 -4330 0 0 {name=p139163 lab=_78252_/C }
C {devices/lab_pin.sym} 139760 -4370 0 1 {name=p139164 lab=_78252_/X }
C {sky130_stdcells/and3_4.sym} 139700 -4370 0 0 {name=X_78252_ }
C {devices/lab_pin.sym} 139660 -4230 0 0 {name=p139165 lab=_44644_/A }
C {devices/lab_pin.sym} 139740 -4230 0 1 {name=p139166 lab=_44644_/Y }
C {sky130_stdcells/inv_2.sym} 139700 -4230 0 0 {name=X_44644_ }
C {devices/lab_pin.sym} 139640 -4120 0 0 {name=p139167 lab=_75462_/X }
C {devices/lab_pin.sym} 139640 -4080 0 0 {name=p139168 lab=_75507_/A }
C {devices/lab_pin.sym} 139760 -4100 0 1 {name=p139169 lab=_75506_/C }
C {sky130_stdcells/and2_4.sym} 139700 -4100 0 0 {name=X_75464_ }
C {devices/lab_pin.sym} 139660 -3970 0 0 {name=p139170 lab=_41856_/A }
C {devices/lab_pin.sym} 139740 -3970 0 1 {name=p139171 lab=_88119_/D }
C {sky130_stdcells/inv_2.sym} 139700 -3970 0 0 {name=X_41856_ }
C {devices/lab_pin.sym} 139640 -3860 0 0 {name=p139172 lab=_60686_/X }
C {devices/lab_pin.sym} 139640 -3820 0 0 {name=p139173 lab=_60689_/Y }
C {devices/lab_pin.sym} 139760 -3840 0 1 {name=p139174 lab=_60690_/X }
C {sky130_stdcells/and2_4.sym} 139700 -3840 0 0 {name=X_60690_ }
C {devices/lab_pin.sym} 139620 -3730 0 0 {name=p139175 lab=_83194_/Q }
C {devices/lab_pin.sym} 139620 -3690 0 0 {name=p139176 lab=_72672_/X }
C {devices/lab_pin.sym} 139620 -3650 0 0 {name=p139177 lab=_72675_/Y }
C {devices/lab_pin.sym} 139780 -3690 0 1 {name=p139178 lab=_72676_/X }
C {sky130_stdcells/a21bo_4.sym} 139700 -3690 0 0 {name=X_72676_ }
C {devices/lab_pin.sym} 139640 -3560 0 0 {name=p139179 lab=_77188_/X }
C {devices/lab_pin.sym} 139640 -3520 0 0 {name=p139180 lab=_77203_/B }
C {devices/lab_pin.sym} 139760 -3540 0 1 {name=p139181 lab=_77205_/A }
C {sky130_stdcells/or2_4.sym} 139700 -3540 0 0 {name=X_77203_ }
C {devices/lab_pin.sym} 139620 -3430 0 0 {name=p139182 lab=_83071_/Q }
C {devices/lab_pin.sym} 139620 -3390 0 0 {name=p139183 lab=_74412_/X }
C {devices/lab_pin.sym} 139620 -3350 0 0 {name=p139184 lab=_74414_/Y }
C {devices/lab_pin.sym} 139780 -3390 0 1 {name=p139185 lab=_74415_/Y }
C {sky130_stdcells/o21ai_4.sym} 139700 -3390 0 0 {name=X_74415_ }
C {devices/lab_pin.sym} 139620 -3280 0 0 {name=p139186 lab=_40806_/X }
C {devices/lab_pin.sym} 139620 -3240 0 0 {name=p139187 lab=_40793_/X }
C {devices/lab_pin.sym} 139620 -3200 0 0 {name=p139188 lab=_88331_/Q }
C {devices/lab_pin.sym} 139620 -3160 0 0 {name=p139189 lab=_40794_/X }
C {devices/lab_pin.sym} 139780 -3220 0 1 {name=p139190 lab=_40807_/X }
C {sky130_stdcells/a2bb2o_4.sym} 139700 -3220 0 0 {name=X_40807_ }
C {devices/lab_pin.sym} 139660 -3070 0 0 {name=p139191 lab=_47363_/A }
C {devices/lab_pin.sym} 139740 -3070 0 1 {name=p139192 lab=_47414_/A }
C {sky130_stdcells/buf_2.sym} 139700 -3070 0 0 {name=X_47363_ }
C {devices/lab_pin.sym} 139620 -2970 0 0 {name=p139193 lab=_71625_/Y }
C {devices/lab_pin.sym} 139620 -2930 0 0 {name=p139194 lab=_83433_/Q }
C {devices/lab_pin.sym} 139620 -2890 0 0 {name=p139195 lab=_71626_/Y }
C {devices/lab_pin.sym} 139780 -2930 0 1 {name=p139196 lab=_71627_/X }
C {sky130_stdcells/a21o_4.sym} 139700 -2930 0 0 {name=X_71627_ }
C {devices/lab_pin.sym} 139620 -2810 0 0 {name=p139197 lab=_59311_/X }
C {devices/lab_pin.sym} 139620 -2770 0 0 {name=p139198 lab=_85733_/Q }
C {devices/lab_pin.sym} 139620 -2730 0 0 {name=p139199 lab=_59334_/X }
C {devices/lab_pin.sym} 139780 -2770 0 1 {name=p139200 lab=_59349_/X }
C {sky130_stdcells/o21a_4.sym} 139700 -2770 0 0 {name=X_59349_ }
C {devices/lab_pin.sym} 139640 -2640 0 0 {name=p139201 lab=_78183_/A }
C {devices/lab_pin.sym} 139640 -2600 0 0 {name=p139202 lab=_82489_/Q }
C {devices/lab_pin.sym} 139760 -2620 0 1 {name=p139203 lab=_78191_/B }
C {sky130_stdcells/or2_4.sym} 139700 -2620 0 0 {name=X_78183_ }
C {devices/lab_pin.sym} 139620 -2530 0 0 {name=p139204 lab=_44565_/X }
C {devices/lab_pin.sym} 139620 -2490 0 0 {name=p139205 lab=_44567_/X }
C {devices/lab_pin.sym} 139620 -2450 0 0 {name=p139206 lab=_40885_/X }
C {devices/lab_pin.sym} 139620 -2410 0 0 {name=p139207 lab=_87049_/Q }
C {devices/lab_pin.sym} 139620 -2370 0 0 {name=p139208 lab=_44568_/X }
C {devices/lab_pin.sym} 139780 -2450 0 1 {name=p139209 lab=_44575_/Y }
C {sky130_stdcells/o32ai_4.sym} 139700 -2450 0 0 {name=X_44575_ }
C {devices/lab_pin.sym} 139660 -2290 0 0 {name=p139210 lab=_75394_/Y }
C {devices/lab_pin.sym} 139740 -2290 0 1 {name=p139211 lab=_75396_/C }
C {sky130_stdcells/inv_2.sym} 139700 -2290 0 0 {name=X_75395_ }
C {devices/lab_pin.sym} 139620 -2210 0 0 {name=p139212 lab=_41753_/X }
C {devices/lab_pin.sym} 139620 -2170 0 0 {name=p139213 lab=_41754_/X }
C {devices/lab_pin.sym} 139620 -2130 0 0 {name=p139214 lab=_41786_/X }
C {devices/lab_pin.sym} 139620 -2090 0 0 {name=p139215 lab=_88149_/Q }
C {devices/lab_pin.sym} 139620 -2050 0 0 {name=p139216 lab=_41736_/X }
C {devices/lab_pin.sym} 139780 -2130 0 1 {name=p139217 lab=_41788_/A }
C {sky130_stdcells/o32ai_4.sym} 139700 -2130 0 0 {name=X_41787_ }
C {devices/lab_pin.sym} 139640 -1990 0 0 {name=p139218 lab=_52370_/A }
C {devices/lab_pin.sym} 139640 -1950 0 0 {name=p139219 lab=_49113_/B }
C {devices/lab_pin.sym} 139640 -1910 0 0 {name=p139220 lab=_49091_/C }
C {devices/lab_pin.sym} 139760 -1950 0 1 {name=p139221 lab=_49102_/X }
C {sky130_stdcells/and3_4.sym} 139700 -1950 0 0 {name=X_49102_ }
C {devices/lab_pin.sym} 139660 -1810 0 0 {name=p139222 lab=_46313_/Y }
C {devices/lab_pin.sym} 139740 -1810 0 1 {name=p139223 lab=_51261_/B }
C {sky130_stdcells/buf_2.sym} 139700 -1810 0 0 {name=X_46314_ }
C {devices/lab_pin.sym} 139640 -1700 0 0 {name=p139224 lab=_77134_/A }
C {devices/lab_pin.sym} 139640 -1660 0 0 {name=p139225 lab=_82293_/D }
C {devices/lab_pin.sym} 139760 -1680 0 1 {name=p139226 lab=_77141_/C }
C {sky130_stdcells/nand2_4.sym} 139700 -1680 0 0 {name=X_77134_ }
C {devices/lab_pin.sym} 139620 -1580 0 0 {name=p139227 lab=_40387_/X }
C {devices/lab_pin.sym} 139620 -1540 0 0 {name=p139228 lab=_43513_/X }
C {devices/lab_pin.sym} 139620 -1500 0 0 {name=p139229 lab=_87376_/Q }
C {devices/lab_pin.sym} 139620 -1460 0 0 {name=p139230 lab=_43514_/X }
C {devices/lab_pin.sym} 139780 -1520 0 1 {name=p139231 lab=_43526_/X }
C {sky130_stdcells/a2bb2o_4.sym} 139700 -1520 0 0 {name=X_43526_ }
C {devices/lab_pin.sym} 139660 -1370 0 0 {name=p139232 lab=_59896_/X }
C {devices/lab_pin.sym} 139740 -1370 0 1 {name=p139233 lab=_62420_/B }
C {sky130_stdcells/buf_2.sym} 139700 -1370 0 0 {name=X_62360_ }
C {devices/lab_pin.sym} 139620 -1270 0 0 {name=p139234 lab=_83090_/Q }
C {devices/lab_pin.sym} 139620 -1230 0 0 {name=p139235 lab=_74340_/X }
C {devices/lab_pin.sym} 139620 -1190 0 0 {name=p139236 lab=_74345_/Y }
C {devices/lab_pin.sym} 139780 -1230 0 1 {name=p139237 lab=_83090_/D }
C {sky130_stdcells/a21bo_4.sym} 139700 -1230 0 0 {name=X_74346_ }
C {devices/lab_pin.sym} 139620 -1110 0 0 {name=p139238 lab=_40731_/X }
C {devices/lab_pin.sym} 139620 -1070 0 0 {name=p139239 lab=_82854_/Q }
C {devices/lab_pin.sym} 139620 -1030 0 0 {name=p139240 lab=_40737_/X }
C {devices/lab_pin.sym} 139780 -1070 0 1 {name=p139241 lab=_40739_/A }
C {sky130_stdcells/o21ai_4.sym} 139700 -1070 0 0 {name=X_40738_ }
C {devices/lab_pin.sym} 139660 -930 0 0 {name=p139242 lab=_47294_/A }
C {devices/lab_pin.sym} 139740 -930 0 1 {name=p139243 lab=_52967_/D }
C {sky130_stdcells/buf_2.sym} 139700 -930 0 0 {name=X_47294_ }
C {devices/lab_pin.sym} 139660 -810 0 0 {name=p139244 lab=_71164_/B }
C {devices/lab_pin.sym} 139740 -810 0 1 {name=p139245 lab=_71558_/X }
C {sky130_stdcells/buf_2.sym} 139700 -810 0 0 {name=X_71558_ }
C {devices/lab_pin.sym} 139620 -710 0 0 {name=p139246 lab=_49027_/Y }
C {devices/lab_pin.sym} 139620 -670 0 0 {name=p139247 lab=_48985_/X }
C {devices/lab_pin.sym} 139620 -630 0 0 {name=p139248 lab=_49032_/X }
C {devices/lab_pin.sym} 139780 -670 0 1 {name=p139249 lab=_86451_/D }
C {sky130_stdcells/a21oi_4.sym} 139700 -670 0 0 {name=X_49033_ }
C {devices/lab_pin.sym} 140580 -42150 0 0 {name=p139250 lab=_72529_/C }
C {devices/lab_pin.sym} 140660 -42150 0 1 {name=p139251 lab=_72506_/C }
C {sky130_stdcells/buf_2.sym} 140620 -42150 0 0 {name=X_61311_ }
C {devices/lab_pin.sym} 140540 -42050 0 0 {name=p139252 lab=_44803_/A }
C {devices/lab_pin.sym} 140540 -42010 0 0 {name=p139253 lab=_46241_/X }
C {devices/lab_pin.sym} 140540 -41970 0 0 {name=p139254 lab=_46244_/Y }
C {devices/lab_pin.sym} 140700 -42010 0 1 {name=p139255 lab=_46245_/X }
C {sky130_stdcells/o21a_4.sym} 140620 -42010 0 0 {name=X_46245_ }
C {devices/lab_pin.sym} 140560 -41890 0 0 {name=p139256 lab=_70511_/A }
C {devices/lab_pin.sym} 140560 -41850 0 0 {name=p139257 lab=_70940_/B }
C {devices/lab_pin.sym} 140560 -41810 0 0 {name=p139258 lab=_70508_/X }
C {devices/lab_pin.sym} 140680 -41850 0 1 {name=p139259 lab=_70509_/Y }
C {sky130_stdcells/nand3_4.sym} 140620 -41850 0 0 {name=X_70509_ }
C {sky130_stdcells/decap_3.sym} 140620 -41680 0 0 {name=XPHY_570 }
C {devices/lab_pin.sym} 140560 -41540 0 0 {name=p139260 lab=_77065_/A }
C {devices/lab_pin.sym} 140560 -41500 0 0 {name=p139261 lab=_77065_/B }
C {devices/lab_pin.sym} 140680 -41520 0 1 {name=p139262 lab=_77065_/X }
C {sky130_stdcells/xor2_4.sym} 140620 -41520 0 0 {name=X_77065_ }
C {devices/lab_pin.sym} 140540 -41430 0 0 {name=p139263 lab=_43449_/X }
C {devices/lab_pin.sym} 140540 -41390 0 0 {name=p139264 lab=_43452_/X }
C {devices/lab_pin.sym} 140540 -41350 0 0 {name=p139265 lab=_41621_/X }
C {devices/lab_pin.sym} 140540 -41310 0 0 {name=p139266 lab=_87413_/Q }
C {devices/lab_pin.sym} 140540 -41270 0 0 {name=p139267 lab=_43456_/X }
C {devices/lab_pin.sym} 140700 -41350 0 1 {name=p139268 lab=_43458_/A }
C {sky130_stdcells/o32ai_4.sym} 140620 -41350 0 0 {name=X_43457_ }
C {devices/lab_pin.sym} 140540 -41220 0 0 {name=p139269 lab=_72730_/X }
C {devices/lab_pin.sym} 140540 -41180 0 0 {name=p139270 lab=_84962_/Q }
C {devices/lab_pin.sym} 140540 -41140 0 0 {name=p139271 lab=_74021_/X }
C {devices/lab_pin.sym} 140540 -41100 0 0 {name=p139272 lab=_74276_/X }
C {devices/lab_pin.sym} 140700 -41160 0 1 {name=p139273 lab=_74278_/B }
C {sky130_stdcells/a211o_4.sym} 140620 -41160 0 0 {name=X_74277_ }
C {devices/lab_pin.sym} 140580 -41010 0 0 {name=p139274 lab=_62572_/A }
C {devices/lab_pin.sym} 140660 -41010 0 1 {name=p139275 lab=_62634_/A }
C {sky130_stdcells/buf_2.sym} 140620 -41010 0 0 {name=X_62291_ }
C {sky130_stdcells/decap_3.sym} 140620 -40860 0 0 {name=XPHY_581 }
C {devices/lab_pin.sym} 140580 -40710 0 0 {name=p139276 lab=_40669_/A }
C {devices/lab_pin.sym} 140660 -40710 0 1 {name=p139277 lab=_88357_/D }
C {sky130_stdcells/inv_2.sym} 140620 -40710 0 0 {name=X_40669_ }
C {devices/lab_pin.sym} 140560 -40610 0 0 {name=p139278 lab=_71488_/X }
C {devices/lab_pin.sym} 140560 -40570 0 0 {name=p139279 lab=_71422_/C }
C {devices/lab_pin.sym} 140560 -40530 0 0 {name=p139280 lab=_70483_/B }
C {devices/lab_pin.sym} 140680 -40570 0 1 {name=p139281 lab=_71489_/X }
C {sky130_stdcells/and3_4.sym} 140620 -40570 0 0 {name=X_71489_ }
C {sky130_stdcells/decap_3.sym} 140620 -40400 0 0 {name=XPHY_592 }
C {devices/lab_pin.sym} 140560 -40260 0 0 {name=p139282 lab=_81519_/Q }
C {devices/lab_pin.sym} 140560 -40220 0 0 {name=p139283 lab=_81743_/D }
C {devices/lab_pin.sym} 140680 -40240 0 1 {name=p139284 lab=_81768_/D }
C {sky130_stdcells/xor2_4.sym} 140620 -40240 0 0 {name=X_76016_ }
C {devices/lab_pin.sym} 140560 -40140 0 0 {name=p139285 lab=_62005_/A }
C {devices/lab_pin.sym} 140560 -40100 0 0 {name=p139286 lab=_64046_/B }
C {devices/lab_pin.sym} 140560 -40060 0 0 {name=p139287 lab=_64046_/C }
C {devices/lab_pin.sym} 140560 -40020 0 0 {name=p139288 lab=_64016_/D }
C {devices/lab_pin.sym} 140680 -40080 0 1 {name=p139289 lab=_64030_/Y }
C {sky130_stdcells/nand4_4.sym} 140620 -40080 0 0 {name=X_64030_ }
C {devices/lab_pin.sym} 140540 -39970 0 0 {name=p139290 lab=_42401_/X }
C {devices/lab_pin.sym} 140540 -39930 0 0 {name=p139291 lab=_42397_/X }
C {devices/lab_pin.sym} 140540 -39890 0 0 {name=p139292 lab=_40452_/X }
C {devices/lab_pin.sym} 140540 -39850 0 0 {name=p139293 lab=_87877_/Q }
C {devices/lab_pin.sym} 140540 -39810 0 0 {name=p139294 lab=_42398_/X }
C {devices/lab_pin.sym} 140700 -39890 0 1 {name=p139295 lab=_42408_/Y }
C {sky130_stdcells/o32ai_4.sym} 140620 -39890 0 0 {name=X_42408_ }
C {devices/lab_pin.sym} 140540 -39760 0 0 {name=p139296 lab=_75902_/A }
C {devices/lab_pin.sym} 140540 -39720 0 0 {name=p139297 lab=_60979_/X }
C {devices/lab_pin.sym} 140540 -39680 0 0 {name=p139298 lab=_61163_/Y }
C {devices/lab_pin.sym} 140540 -39640 0 0 {name=p139299 lab=_61241_/X }
C {devices/lab_pin.sym} 140700 -39700 0 1 {name=p139300 lab=_61242_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 140620 -39700 0 0 {name=X_61242_ }
C {devices/lab_pin.sym} 140560 -39560 0 0 {name=p139301 lab=_73228_/A }
C {devices/lab_pin.sym} 140560 -39520 0 0 {name=p139302 lab=_73228_/B }
C {devices/lab_pin.sym} 140680 -39540 0 1 {name=p139303 lab=_73228_/Y }
C {sky130_stdcells/nor2_4.sym} 140620 -39540 0 0 {name=X_73228_ }
C {devices/lab_pin.sym} 140540 -39430 0 0 {name=p139304 lab=_46174_/X }
C {devices/lab_pin.sym} 140540 -39390 0 0 {name=p139305 lab=_46175_/Y }
C {devices/lab_pin.sym} 140540 -39350 0 0 {name=p139306 lab=_46158_/B }
C {devices/lab_pin.sym} 140700 -39390 0 1 {name=p139307 lab=_86767_/D }
C {sky130_stdcells/o21ai_4.sym} 140620 -39390 0 0 {name=X_46176_ }
C {devices/lab_pin.sym} 140580 -39250 0 0 {name=p139308 lab=_43397_/A }
C {devices/lab_pin.sym} 140660 -39250 0 1 {name=p139309 lab=_43388_/X }
C {sky130_stdcells/buf_2.sym} 140620 -39250 0 0 {name=X_43388_ }
C {devices/lab_pin.sym} 140580 -39130 0 0 {name=p139310 lab=_45350_/A }
C {devices/lab_pin.sym} 140660 -39130 0 1 {name=p139311 lab=_45127_/X }
C {sky130_stdcells/buf_2.sym} 140620 -39130 0 0 {name=X_45127_ }
C {devices/lab_pin.sym} 140540 -39050 0 0 {name=p139312 lab=_42330_/X }
C {devices/lab_pin.sym} 140540 -39010 0 0 {name=p139313 lab=_42319_/X }
C {devices/lab_pin.sym} 140540 -38970 0 0 {name=p139314 lab=_41688_/X }
C {devices/lab_pin.sym} 140540 -38930 0 0 {name=p139315 lab=_87913_/Q }
C {devices/lab_pin.sym} 140540 -38890 0 0 {name=p139316 lab=_42320_/X }
C {devices/lab_pin.sym} 140700 -38970 0 1 {name=p139317 lab=_42340_/A }
C {sky130_stdcells/o32ai_4.sym} 140620 -38970 0 0 {name=X_42339_ }
C {devices/lab_pin.sym} 140580 -38810 0 0 {name=p139318 lab=_61173_/A }
C {devices/lab_pin.sym} 140660 -38810 0 1 {name=p139319 lab=_61173_/Y }
C {sky130_stdcells/inv_2.sym} 140620 -38810 0 0 {name=X_61173_ }
C {devices/lab_pin.sym} 140540 -38720 0 0 {name=p139320 lab=_72870_/X }
C {devices/lab_pin.sym} 140540 -38680 0 0 {name=p139321 lab=_86194_/Q }
C {devices/lab_pin.sym} 140540 -38640 0 0 {name=p139322 lab=_72905_/X }
C {devices/lab_pin.sym} 140540 -38600 0 0 {name=p139323 lab=_73158_/X }
C {devices/lab_pin.sym} 140700 -38660 0 1 {name=p139324 lab=_73159_/X }
C {sky130_stdcells/a211o_4.sym} 140620 -38660 0 0 {name=X_73159_ }
C {devices/lab_pin.sym} 140580 -38510 0 0 {name=p139325 lab=_59852_/A }
C {devices/lab_pin.sym} 140660 -38510 0 1 {name=p139326 lab=_60214_/B }
C {sky130_stdcells/buf_2.sym} 140620 -38510 0 0 {name=X_60124_ }
C {devices/lab_pin.sym} 140580 -38390 0 0 {name=p139327 lab=_49854_/A }
C {devices/lab_pin.sym} 140660 -38390 0 1 {name=p139328 lab=_49955_/A }
C {sky130_stdcells/buf_2.sym} 140620 -38390 0 0 {name=X_49935_ }
C {devices/lab_pin.sym} 140540 -38290 0 0 {name=p139329 lab=_56219_/C }
C {devices/lab_pin.sym} 140540 -38250 0 0 {name=p139330 lab=_44998_/X }
C {devices/lab_pin.sym} 140540 -38210 0 0 {name=p139331 lab=_45057_/X }
C {devices/lab_pin.sym} 140700 -38250 0 1 {name=p139332 lab=_45058_/Y }
C {sky130_stdcells/o21ai_4.sym} 140620 -38250 0 0 {name=X_45058_ }
C {devices/lab_pin.sym} 140560 -38120 0 0 {name=p139333 lab=_65980_/X }
C {devices/lab_pin.sym} 140560 -38080 0 0 {name=p139334 lab=_73689_/B }
C {devices/lab_pin.sym} 140680 -38100 0 1 {name=p139335 lab=_65981_/X }
C {sky130_stdcells/and2_4.sym} 140620 -38100 0 0 {name=X_65981_ }
C {devices/lab_pin.sym} 140560 -37990 0 0 {name=p139336 lab=_77960_/Y }
C {devices/lab_pin.sym} 140560 -37950 0 0 {name=p139337 lab=_77967_/B }
C {devices/lab_pin.sym} 140560 -37910 0 0 {name=p139338 lab=_77967_/C }
C {devices/lab_pin.sym} 140680 -37950 0 1 {name=p139339 lab=_77967_/Y }
C {sky130_stdcells/nand3_4.sym} 140620 -37950 0 0 {name=X_77967_ }
C {devices/lab_pin.sym} 140580 -37810 0 0 {name=p139340 lab=_57686_/A }
C {devices/lab_pin.sym} 140660 -37810 0 1 {name=p139341 lab=_44247_/A }
C {sky130_stdcells/buf_2.sym} 140620 -37810 0 0 {name=X_44009_ }
C {devices/lab_pin.sym} 140540 -37720 0 0 {name=p139342 lab=_87395_/Q }
C {devices/lab_pin.sym} 140540 -37680 0 0 {name=p139343 lab=_67717_/X }
C {devices/lab_pin.sym} 140540 -37640 0 0 {name=p139344 lab=_67718_/X }
C {devices/lab_pin.sym} 140540 -37600 0 0 {name=p139345 lab=_67719_/X }
C {devices/lab_pin.sym} 140700 -37660 0 1 {name=p139346 lab=_67720_/X }
C {sky130_stdcells/a211o_4.sym} 140620 -37660 0 0 {name=X_67720_ }
C {devices/lab_pin.sym} 140560 -37520 0 0 {name=p139347 lab=_79692_/Y }
C {devices/lab_pin.sym} 140560 -37480 0 0 {name=p139348 lab=_79689_/Y }
C {devices/lab_pin.sym} 140680 -37500 0 1 {name=p139349 lab=_79706_/X }
C {sky130_stdcells/and2_4.sym} 140620 -37500 0 0 {name=X_79706_ }
C {devices/lab_pin.sym} 140540 -37400 0 0 {name=p139350 lab=_64858_/X }
C {devices/lab_pin.sym} 140540 -37360 0 0 {name=p139351 lab=_85557_/Q }
C {devices/lab_pin.sym} 140540 -37320 0 0 {name=p139352 lab=_64859_/X }
C {devices/lab_pin.sym} 140540 -37280 0 0 {name=p139353 lab=_64931_/X }
C {devices/lab_pin.sym} 140700 -37340 0 1 {name=p139354 lab=_64932_/X }
C {sky130_stdcells/a211o_4.sym} 140620 -37340 0 0 {name=X_64932_ }
C {devices/lab_pin.sym} 140580 -37190 0 0 {name=p139355 lab=_60055_/A }
C {devices/lab_pin.sym} 140660 -37190 0 1 {name=p139356 lab=_60056_/A }
C {sky130_stdcells/buf_2.sym} 140620 -37190 0 0 {name=X_60055_ }
C {devices/lab_pin.sym} 140560 -37080 0 0 {name=p139357 lab=_76918_/A }
C {devices/lab_pin.sym} 140560 -37040 0 0 {name=p139358 lab=_76918_/B }
C {devices/lab_pin.sym} 140680 -37060 0 1 {name=p139359 lab=_76931_/B }
C {sky130_stdcells/xor2_4.sym} 140620 -37060 0 0 {name=X_76918_ }
C {devices/lab_pin.sym} 140560 -36960 0 0 {name=p139360 lab=_49851_/A }
C {devices/lab_pin.sym} 140560 -36920 0 0 {name=p139361 lab=_49884_/B }
C {devices/lab_pin.sym} 140560 -36880 0 0 {name=p139362 lab=_49862_/C }
C {devices/lab_pin.sym} 140560 -36840 0 0 {name=p139363 lab=_53078_/D }
C {devices/lab_pin.sym} 140680 -36900 0 1 {name=p139364 lab=_49866_/X }
C {sky130_stdcells/and4_4.sym} 140620 -36900 0 0 {name=X_49866_ }
C {devices/lab_pin.sym} 140560 -36760 0 0 {name=p139365 lab=_82164_/Q }
C {devices/lab_pin.sym} 140560 -36720 0 0 {name=p139366 lab=_82036_/D }
C {devices/lab_pin.sym} 140680 -36740 0 1 {name=p139367 lab=_82132_/D }
C {sky130_stdcells/xor2_4.sym} 140620 -36740 0 0 {name=X_77898_ }
C {devices/lab_pin.sym} 140540 -36630 0 0 {name=p139368 lab=_86477_/Q }
C {devices/lab_pin.sym} 140540 -36590 0 0 {name=p139369 lab=_48809_/X }
C {devices/lab_pin.sym} 140540 -36550 0 0 {name=p139370 lab=_48816_/Y }
C {devices/lab_pin.sym} 140700 -36590 0 1 {name=p139371 lab=_48817_/Y }
C {sky130_stdcells/o21ai_4.sym} 140620 -36590 0 0 {name=X_48817_ }
C {devices/lab_pin.sym} 140580 -36450 0 0 {name=p139372 lab=_68402_/A }
C {devices/lab_pin.sym} 140660 -36450 0 1 {name=p139373 lab=_67651_/X }
C {sky130_stdcells/buf_2.sym} 140620 -36450 0 0 {name=X_67651_ }
C {devices/lab_pin.sym} 140560 -36340 0 0 {name=p139374 lab=_60346_/C }
C {devices/lab_pin.sym} 140560 -36300 0 0 {name=p139375 lab=_79637_/B }
C {devices/lab_pin.sym} 140680 -36320 0 1 {name=p139376 lab=_79646_/B }
C {sky130_stdcells/xor2_4.sym} 140620 -36320 0 0 {name=X_79637_ }
C {devices/lab_pin.sym} 140580 -36190 0 0 {name=p139377 lab=_44170_/A }
C {devices/lab_pin.sym} 140660 -36190 0 1 {name=p139378 lab=_64991_/A }
C {sky130_stdcells/buf_2.sym} 140620 -36190 0 0 {name=X_64863_ }
C {devices/lab_pin.sym} 140580 -36070 0 0 {name=p139379 lab=_76849_/A }
C {devices/lab_pin.sym} 140660 -36070 0 1 {name=p139380 lab=_76854_/A }
C {sky130_stdcells/inv_2.sym} 140620 -36070 0 0 {name=X_76849_ }
C {devices/lab_pin.sym} 140540 -35970 0 0 {name=p139381 lab=_49792_/Y }
C {devices/lab_pin.sym} 140540 -35930 0 0 {name=p139382 lab=_49787_/X }
C {devices/lab_pin.sym} 140540 -35890 0 0 {name=p139383 lab=_49796_/X }
C {devices/lab_pin.sym} 140700 -35930 0 1 {name=p139384 lab=_86322_/D }
C {sky130_stdcells/a21oi_4.sym} 140620 -35930 0 0 {name=X_49797_ }
C {devices/lab_pin.sym} 140560 -35800 0 0 {name=p139385 lab=_66602_/A }
C {devices/lab_pin.sym} 140560 -35760 0 0 {name=p139386 lab=_66602_/B }
C {devices/lab_pin.sym} 140680 -35780 0 1 {name=p139387 lab=_66602_/X }
C {sky130_stdcells/and2_4.sym} 140620 -35780 0 0 {name=X_66602_ }
C {devices/lab_pin.sym} 140560 -35680 0 0 {name=p139388 lab=_61376_/X }
C {devices/lab_pin.sym} 140560 -35640 0 0 {name=p139389 lab=_63781_/B }
C {devices/lab_pin.sym} 140560 -35600 0 0 {name=p139390 lab=_63814_/C }
C {devices/lab_pin.sym} 140560 -35560 0 0 {name=p139391 lab=_63761_/X }
C {devices/lab_pin.sym} 140680 -35620 0 1 {name=p139392 lab=_63814_/Y }
C {sky130_stdcells/nand4_4.sym} 140620 -35620 0 0 {name=X_63814_ }
C {devices/lab_pin.sym} 140560 -35490 0 0 {name=p139393 lab=_52135_/A }
C {devices/lab_pin.sym} 140560 -35450 0 0 {name=p139394 lab=_48766_/B }
C {devices/lab_pin.sym} 140560 -35410 0 0 {name=p139395 lab=_48761_/C }
C {devices/lab_pin.sym} 140680 -35450 0 1 {name=p139396 lab=_48748_/X }
C {sky130_stdcells/and3_4.sym} 140620 -35450 0 0 {name=X_48748_ }
C {devices/lab_pin.sym} 140560 -35320 0 0 {name=p139397 lab=_67582_/A }
C {devices/lab_pin.sym} 140560 -35280 0 0 {name=p139398 lab=_87209_/Q }
C {devices/lab_pin.sym} 140680 -35300 0 1 {name=p139399 lab=_67582_/X }
C {sky130_stdcells/and2_4.sym} 140620 -35300 0 0 {name=X_67582_ }
C {devices/lab_pin.sym} 140560 -35180 0 0 {name=p139400 lab=_79567_/Y }
C {devices/lab_pin.sym} 140560 -35140 0 0 {name=p139401 lab=_79568_/B }
C {devices/lab_pin.sym} 140680 -35160 0 1 {name=p139402 lab=_79569_/B }
C {sky130_stdcells/nand2_4.sym} 140620 -35160 0 0 {name=X_79568_ }
C {devices/lab_pin.sym} 140560 -35040 0 0 {name=p139403 lab=_64769_/A }
C {devices/lab_pin.sym} 140560 -35000 0 0 {name=p139404 lab=_64794_/B }
C {devices/lab_pin.sym} 140680 -35020 0 1 {name=p139405 lab=_64794_/X }
C {sky130_stdcells/and2_4.sym} 140620 -35020 0 0 {name=X_64794_ }
C {devices/lab_pin.sym} 140580 -34890 0 0 {name=p139406 lab=_69223_/A }
C {devices/lab_pin.sym} 140660 -34890 0 1 {name=p139407 lab=_69322_/A }
C {sky130_stdcells/buf_2.sym} 140620 -34890 0 0 {name=X_69321_ }
C {devices/lab_pin.sym} 140580 -34770 0 0 {name=p139408 lab=_66565_/A }
C {devices/lab_pin.sym} 140660 -34770 0 1 {name=p139409 lab=_66534_/A }
C {sky130_stdcells/buf_2.sym} 140620 -34770 0 0 {name=X_66533_ }
C {devices/lab_pin.sym} 140560 -34660 0 0 {name=p139410 lab=_78519_/A }
C {devices/lab_pin.sym} 140560 -34620 0 0 {name=p139411 lab=_78519_/B }
C {devices/lab_pin.sym} 140680 -34640 0 1 {name=p139412 lab=_82768_/D }
C {sky130_stdcells/xor2_4.sym} 140620 -34640 0 0 {name=X_78519_ }
C {devices/lab_pin.sym} 140560 -34530 0 0 {name=p139413 lab=_63701_/A }
C {devices/lab_pin.sym} 140560 -34490 0 0 {name=p139414 lab=_63701_/B }
C {devices/lab_pin.sym} 140560 -34450 0 0 {name=p139415 lab=_63745_/C }
C {devices/lab_pin.sym} 140680 -34490 0 1 {name=p139416 lab=_63745_/Y }
C {sky130_stdcells/nor3_4.sym} 140620 -34490 0 0 {name=X_63745_ }
C {devices/lab_pin.sym} 140580 -34350 0 0 {name=p139417 lab=_48623_/A }
C {devices/lab_pin.sym} 140660 -34350 0 1 {name=p139418 lab=_48894_/C }
C {sky130_stdcells/buf_2.sym} 140620 -34350 0 0 {name=X_48679_ }
C {devices/lab_pin.sym} 140560 -34240 0 0 {name=p139419 lab=_63781_/C }
C {devices/lab_pin.sym} 140560 -34200 0 0 {name=p139420 lab=_60957_/B }
C {devices/lab_pin.sym} 140680 -34220 0 1 {name=p139421 lab=_60957_/Y }
C {sky130_stdcells/nor2_4.sym} 140620 -34220 0 0 {name=X_60957_ }
C {devices/lab_pin.sym} 140560 -34100 0 0 {name=p139422 lab=_84815_/Q }
C {devices/lab_pin.sym} 140560 -34060 0 0 {name=p139423 lab=_84135_/Q }
C {devices/lab_pin.sym} 140680 -34080 0 1 {name=p139424 lab=_79499_/Y }
C {sky130_stdcells/nand2_4.sym} 140620 -34080 0 0 {name=X_79499_ }
C {devices/lab_pin.sym} 140560 -33960 0 0 {name=p139425 lab=_50695_/A }
C {devices/lab_pin.sym} 140560 -33920 0 0 {name=p139426 lab=_50710_/B }
C {devices/lab_pin.sym} 140680 -33940 0 1 {name=p139427 lab=_50710_/Y }
C {sky130_stdcells/nand2_4.sym} 140620 -33940 0 0 {name=X_50710_ }
C {devices/lab_pin.sym} 140530 -33810 0 0 {name=p139428 lab=_82053_/CLK }
C {devices/lab_pin.sym} 140530 -33790 0 0 {name=p139429 lab=_81542_/Q }
C {devices/lab_pin.sym} 140710 -33810 0 1 {name=p139430 lab=_81530_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -33800 0 0 {name=X_81530_ }
C {devices/lab_pin.sym} 140540 -33690 0 0 {name=p139431 lab=_69247_/X }
C {devices/lab_pin.sym} 140540 -33650 0 0 {name=p139432 lab=_69250_/X }
C {devices/lab_pin.sym} 140540 -33610 0 0 {name=p139433 lab=_69251_/X }
C {devices/lab_pin.sym} 140700 -33650 0 1 {name=p139434 lab=_69255_/A }
C {sky130_stdcells/a21o_4.sym} 140620 -33650 0 0 {name=X_69252_ }
C {devices/lab_pin.sym} 140560 -33530 0 0 {name=p139435 lab=_66433_/A }
C {devices/lab_pin.sym} 140560 -33490 0 0 {name=p139436 lab=_66419_/X }
C {devices/lab_pin.sym} 140560 -33450 0 0 {name=p139437 lab=_84118_/Q }
C {devices/lab_pin.sym} 140680 -33490 0 1 {name=p139438 lab=_66464_/X }
C {sky130_stdcells/and3_4.sym} 140620 -33490 0 0 {name=X_66464_ }
C {devices/lab_pin.sym} 140540 -33370 0 0 {name=p139439 lab=_51687_/Y }
C {devices/lab_pin.sym} 140540 -33330 0 0 {name=p139440 lab=_51667_/X }
C {devices/lab_pin.sym} 140540 -33290 0 0 {name=p139441 lab=_51689_/X }
C {devices/lab_pin.sym} 140700 -33330 0 1 {name=p139442 lab=_85964_/D }
C {sky130_stdcells/a21oi_4.sym} 140620 -33330 0 0 {name=X_51690_ }
C {devices/lab_pin.sym} 140540 -33220 0 0 {name=p139443 lab=_61649_/B }
C {devices/lab_pin.sym} 140540 -33180 0 0 {name=p139444 lab=_63609_/X }
C {devices/lab_pin.sym} 140540 -33140 0 0 {name=p139445 lab=_63674_/X }
C {devices/lab_pin.sym} 140540 -33100 0 0 {name=p139446 lab=_63675_/X }
C {devices/lab_pin.sym} 140700 -33160 0 1 {name=p139447 lab=_63676_/X }
C {sky130_stdcells/a211o_4.sym} 140620 -33160 0 0 {name=X_63676_ }
C {devices/lab_pin.sym} 140580 -33010 0 0 {name=p139448 lab=_60863_/X }
C {devices/lab_pin.sym} 140660 -33010 0 1 {name=p139449 lab=_60888_/Y }
C {sky130_stdcells/inv_2.sym} 140620 -33010 0 0 {name=X_60888_ }
C {devices/lab_pin.sym} 140540 -32910 0 0 {name=p139450 lab=_82053_/D }
C {devices/lab_pin.sym} 140540 -32870 0 0 {name=p139451 lab=_68200_/X }
C {devices/lab_pin.sym} 140540 -32830 0 0 {name=p139452 lab=_68202_/X }
C {devices/lab_pin.sym} 140700 -32870 0 1 {name=p139453 lab=_68203_/X }
C {sky130_stdcells/a21bo_4.sym} 140620 -32870 0 0 {name=X_68203_ }
C {devices/lab_pin.sym} 140580 -32730 0 0 {name=p139454 lab=clkbuf_9_511_0_CLK/X }
C {devices/lab_pin.sym} 140660 -32730 0 1 {name=p139455 lab=_86500_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 140620 -32730 0 0 {name=Xclkbuf_10_1023_0_CLK }
C {devices/lab_pin.sym} 140540 -32630 0 0 {name=p139456 lab=_65412_/X }
C {devices/lab_pin.sym} 140540 -32590 0 0 {name=p139457 lab=_65414_/X }
C {devices/lab_pin.sym} 140540 -32550 0 0 {name=p139458 lab=_65287_/X }
C {devices/lab_pin.sym} 140700 -32590 0 1 {name=p139459 lab=_65415_/X }
C {sky130_stdcells/a21o_4.sym} 140620 -32590 0 0 {name=X_65415_ }
C {devices/lab_pin.sym} 140540 -32470 0 0 {name=p139460 lab=_50637_/Y }
C {devices/lab_pin.sym} 140540 -32430 0 0 {name=p139461 lab=_50619_/X }
C {devices/lab_pin.sym} 140540 -32390 0 0 {name=p139462 lab=_50640_/Y }
C {devices/lab_pin.sym} 140700 -32430 0 1 {name=p139463 lab=_50641_/Y }
C {sky130_stdcells/a21boi_4.sym} 140620 -32430 0 0 {name=X_50641_ }
C {devices/lab_pin.sym} 140540 -32310 0 0 {name=p139464 lab=_62625_/Y }
C {devices/lab_pin.sym} 140540 -32270 0 0 {name=p139465 lab=_62593_/X }
C {devices/lab_pin.sym} 140540 -32230 0 0 {name=p139466 lab=_62626_/Y }
C {devices/lab_pin.sym} 140700 -32270 0 1 {name=p139467 lab=_62627_/Y }
C {sky130_stdcells/a21oi_4.sym} 140620 -32270 0 0 {name=X_62627_ }
C {devices/lab_pin.sym} 140530 -32130 0 0 {name=p139468 lab=_81461_/CLK }
C {devices/lab_pin.sym} 140530 -32110 0 0 {name=p139469 lab=_76826_/B }
C {devices/lab_pin.sym} 140710 -32130 0 1 {name=p139470 lab=_81461_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -32120 0 0 {name=X_81461_ }
C {devices/lab_pin.sym} 140580 -31990 0 0 {name=p139471 lab=_69183_/A }
C {devices/lab_pin.sym} 140660 -31990 0 1 {name=p139472 lab=_69183_/X }
C {sky130_stdcells/buf_2.sym} 140620 -31990 0 0 {name=X_69183_ }
C {devices/lab_pin.sym} 140560 -31890 0 0 {name=p139473 lab=_66389_/A }
C {devices/lab_pin.sym} 140560 -31850 0 0 {name=p139474 lab=_66389_/B }
C {devices/lab_pin.sym} 140560 -31810 0 0 {name=p139475 lab=_66395_/C }
C {devices/lab_pin.sym} 140680 -31850 0 1 {name=p139476 lab=_66395_/Y }
C {sky130_stdcells/nor3_4.sym} 140620 -31850 0 0 {name=X_66395_ }
C {devices/lab_pin.sym} 140530 -31710 0 0 {name=p139477 lab=_83843_/CLK }
C {devices/lab_pin.sym} 140530 -31690 0 0 {name=p139478 lab=_83200_/D }
C {devices/lab_pin.sym} 140710 -31710 0 1 {name=p139479 lab=_70198_/C }
C {sky130_stdcells/dfxtp_4.sym} 140620 -31700 0 0 {name=X_83200_ }
C {devices/lab_pin.sym} 140560 -31580 0 0 {name=p139480 lab=_84757_/Q }
C {devices/lab_pin.sym} 140560 -31540 0 0 {name=p139481 lab=_80419_/B }
C {devices/lab_pin.sym} 140680 -31560 0 1 {name=p139482 lab=_80412_/X }
C {sky130_stdcells/xor2_4.sym} 140620 -31560 0 0 {name=X_80412_ }
C {devices/lab_pin.sym} 140540 -31450 0 0 {name=p139483 lab=_66844_/X }
C {devices/lab_pin.sym} 140540 -31410 0 0 {name=p139484 lab=_66846_/X }
C {devices/lab_pin.sym} 140540 -31370 0 0 {name=p139485 lab=_68133_/X }
C {devices/lab_pin.sym} 140700 -31410 0 1 {name=p139486 lab=_68134_/Y }
C {sky130_stdcells/a21oi_4.sym} 140620 -31410 0 0 {name=X_68134_ }
C {devices/lab_pin.sym} 140560 -31280 0 0 {name=p139487 lab=_53353_/A }
C {devices/lab_pin.sym} 140560 -31240 0 0 {name=p139488 lab=_53360_/B }
C {devices/lab_pin.sym} 140680 -31260 0 1 {name=p139489 lab=_53360_/Y }
C {sky130_stdcells/nand2_4.sym} 140620 -31260 0 0 {name=X_53360_ }
C {devices/lab_pin.sym} 140540 -31150 0 0 {name=p139490 lab=_65198_/X }
C {devices/lab_pin.sym} 140540 -31110 0 0 {name=p139491 lab=_65333_/Y }
C {devices/lab_pin.sym} 140540 -31070 0 0 {name=p139492 lab=_65345_/Y }
C {devices/lab_pin.sym} 140700 -31110 0 1 {name=p139493 lab=_65346_/Y }
C {sky130_stdcells/o21ai_4.sym} 140620 -31110 0 0 {name=X_65346_ }
C {devices/lab_pin.sym} 140530 -30970 0 0 {name=p139494 lab=_84194_/CLK }
C {devices/lab_pin.sym} 140530 -30950 0 0 {name=p139495 lab=_84180_/D }
C {devices/lab_pin.sym} 140710 -30970 0 1 {name=p139496 lab=_84180_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -30960 0 0 {name=X_84180_ }
C {devices/lab_pin.sym} 140580 -30830 0 0 {name=p139497 lab=_50572_/A }
C {devices/lab_pin.sym} 140660 -30830 0 1 {name=p139498 lab=_50580_/A }
C {sky130_stdcells/buf_2.sym} 140620 -30830 0 0 {name=X_50572_ }
C {devices/lab_pin.sym} 140540 -30740 0 0 {name=p139499 lab=_62557_/Y }
C {devices/lab_pin.sym} 140540 -30700 0 0 {name=p139500 lab=_59945_/Y }
C {devices/lab_pin.sym} 140540 -30660 0 0 {name=p139501 lab=_84785_/Q }
C {devices/lab_pin.sym} 140540 -30620 0 0 {name=p139502 lab=_59931_/A }
C {devices/lab_pin.sym} 140700 -30680 0 1 {name=p139503 lab=_62558_/X }
C {sky130_stdcells/a2bb2o_4.sym} 140620 -30680 0 0 {name=X_62558_ }
C {devices/lab_pin.sym} 140530 -30530 0 0 {name=p139504 lab=_81473_/CLK }
C {devices/lab_pin.sym} 140530 -30510 0 0 {name=p139505 lab=_83928_/Q }
C {devices/lab_pin.sym} 140710 -30530 0 1 {name=p139506 lab=_76929_/B }
C {sky130_stdcells/dfxtp_4.sym} 140620 -30520 0 0 {name=X_81392_ }
C {devices/lab_pin.sym} 140540 -30410 0 0 {name=p139507 lab=_52308_/Y }
C {devices/lab_pin.sym} 140540 -30370 0 0 {name=p139508 lab=_52289_/X }
C {devices/lab_pin.sym} 140540 -30330 0 0 {name=p139509 lab=_52310_/X }
C {devices/lab_pin.sym} 140700 -30370 0 1 {name=p139510 lab=_85848_/D }
C {sky130_stdcells/a21oi_4.sym} 140620 -30370 0 0 {name=X_52311_ }
C {devices/lab_pin.sym} 140530 -30230 0 0 {name=p139511 lab=_83561_/CLK }
C {devices/lab_pin.sym} 140530 -30210 0 0 {name=p139512 lab=_73915_/Y }
C {devices/lab_pin.sym} 140710 -30230 0 1 {name=p139513 lab=_70113_/A }
C {sky130_stdcells/dfxtp_4.sym} 140620 -30220 0 0 {name=X_83131_ }
C {devices/lab_pin.sym} 140560 -30110 0 0 {name=p139514 lab=_61499_/A }
C {devices/lab_pin.sym} 140560 -30070 0 0 {name=p139515 lab=_61509_/B }
C {devices/lab_pin.sym} 140560 -30030 0 0 {name=p139516 lab=_61459_/X }
C {devices/lab_pin.sym} 140680 -30070 0 1 {name=p139517 lab=_61509_/Y }
C {sky130_stdcells/nand3_4.sym} 140620 -30070 0 0 {name=X_61509_ }
C {devices/lab_pin.sym} 140560 -29940 0 0 {name=p139518 lab=_80347_/A }
C {devices/lab_pin.sym} 140560 -29900 0 0 {name=p139519 lab=_80347_/B }
C {devices/lab_pin.sym} 140680 -29920 0 1 {name=p139520 lab=_80343_/X }
C {sky130_stdcells/xor2_4.sym} 140620 -29920 0 0 {name=X_80343_ }
C {devices/lab_pin.sym} 140540 -29810 0 0 {name=p139521 lab=_81475_/D }
C {devices/lab_pin.sym} 140540 -29770 0 0 {name=p139522 lab=_68040_/X }
C {devices/lab_pin.sym} 140540 -29730 0 0 {name=p139523 lab=_68064_/X }
C {devices/lab_pin.sym} 140700 -29770 0 1 {name=p139524 lab=_68065_/X }
C {sky130_stdcells/a21bo_4.sym} 140620 -29770 0 0 {name=X_68065_ }
C {devices/lab_pin.sym} 140540 -29650 0 0 {name=p139525 lab=_85660_/Q }
C {devices/lab_pin.sym} 140540 -29610 0 0 {name=p139526 lab=_53268_/X }
C {devices/lab_pin.sym} 140540 -29570 0 0 {name=p139527 lab=_53290_/Y }
C {devices/lab_pin.sym} 140700 -29610 0 1 {name=p139528 lab=_53291_/Y }
C {sky130_stdcells/o21ai_4.sym} 140620 -29610 0 0 {name=X_53291_ }
C {devices/lab_pin.sym} 140580 -29470 0 0 {name=p139529 lab=_64851_/A }
C {devices/lab_pin.sym} 140660 -29470 0 1 {name=p139530 lab=_65277_/X }
C {sky130_stdcells/buf_2.sym} 140620 -29470 0 0 {name=X_65277_ }
C {devices/lab_pin.sym} 140580 -29350 0 0 {name=p139531 lab=_62236_/A }
C {devices/lab_pin.sym} 140660 -29350 0 1 {name=p139532 lab=_62566_/B }
C {sky130_stdcells/buf_2.sym} 140620 -29350 0 0 {name=X_62489_ }
C {devices/lab_pin.sym} 140580 -29230 0 0 {name=p139533 lab=_54927_/A }
C {devices/lab_pin.sym} 140660 -29230 0 1 {name=p139534 lab=_55030_/X }
C {sky130_stdcells/buf_2.sym} 140620 -29230 0 0 {name=X_55030_ }
C {devices/lab_pin.sym} 140540 -29130 0 0 {name=p139535 lab=_67010_/X }
C {devices/lab_pin.sym} 140540 -29090 0 0 {name=p139536 lab=_67012_/X }
C {devices/lab_pin.sym} 140540 -29050 0 0 {name=p139537 lab=_67015_/X }
C {devices/lab_pin.sym} 140700 -29090 0 1 {name=p139538 lab=_67016_/Y }
C {sky130_stdcells/a21oi_4.sym} 140620 -29090 0 0 {name=X_67016_ }
C {devices/lab_pin.sym} 140540 -28970 0 0 {name=p139539 lab=_85861_/Q }
C {devices/lab_pin.sym} 140540 -28930 0 0 {name=p139540 lab=_52239_/X }
C {devices/lab_pin.sym} 140540 -28890 0 0 {name=p139541 lab=_52241_/Y }
C {devices/lab_pin.sym} 140700 -28930 0 1 {name=p139542 lab=_52242_/Y }
C {sky130_stdcells/o21ai_4.sym} 140620 -28930 0 0 {name=X_52242_ }
C {devices/lab_pin.sym} 140540 -28810 0 0 {name=p139543 lab=_59454_/A }
C {devices/lab_pin.sym} 140540 -28770 0 0 {name=p139544 lab=_64226_/X }
C {devices/lab_pin.sym} 140540 -28730 0 0 {name=p139545 lab=_64227_/Y }
C {devices/lab_pin.sym} 140700 -28770 0 1 {name=p139546 lab=_64228_/Y }
C {sky130_stdcells/o21ai_4.sym} 140620 -28770 0 0 {name=X_64228_ }
C {devices/lab_pin.sym} 140530 -28630 0 0 {name=p139547 lab=_85571_/CLK }
C {devices/lab_pin.sym} 140530 -28610 0 0 {name=p139548 lab=_74460_/Y }
C {devices/lab_pin.sym} 140710 -28630 0 1 {name=p139549 lab=_83062_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -28620 0 0 {name=X_83062_ }
C {devices/lab_pin.sym} 140560 -28500 0 0 {name=p139550 lab=_84747_/Q }
C {devices/lab_pin.sym} 140560 -28460 0 0 {name=p139551 lab=_84139_/Q }
C {devices/lab_pin.sym} 140680 -28480 0 1 {name=p139552 lab=_80274_/Y }
C {sky130_stdcells/nand2_4.sym} 140620 -28480 0 0 {name=X_80274_ }
C {devices/lab_pin.sym} 140530 -28350 0 0 {name=p139553 lab=_82009_/CLK }
C {devices/lab_pin.sym} 140530 -28330 0 0 {name=p139554 lab=_82013_/D }
C {devices/lab_pin.sym} 140710 -28350 0 1 {name=p139555 lab=_77194_/A }
C {sky130_stdcells/dfxtp_4.sym} 140620 -28340 0 0 {name=X_82013_ }
C {devices/lab_pin.sym} 140560 -28220 0 0 {name=p139556 lab=_52168_/A }
C {devices/lab_pin.sym} 140560 -28180 0 0 {name=p139557 lab=_48788_/B }
C {devices/lab_pin.sym} 140680 -28200 0 1 {name=p139558 lab=_52173_/Y }
C {sky130_stdcells/nand2_4.sym} 140620 -28200 0 0 {name=X_52173_ }
C {devices/lab_pin.sym} 140560 -28100 0 0 {name=p139559 lab=_64155_/Y }
C {devices/lab_pin.sym} 140560 -28060 0 0 {name=p139560 lab=_64159_/B }
C {devices/lab_pin.sym} 140560 -28020 0 0 {name=p139561 lab=_64157_/Y }
C {devices/lab_pin.sym} 140560 -27980 0 0 {name=p139562 lab=_64159_/D }
C {devices/lab_pin.sym} 140680 -28040 0 1 {name=p139563 lab=_64159_/X }
C {sky130_stdcells/and4_4.sym} 140620 -28040 0 0 {name=X_64159_ }
C {devices/lab_pin.sym} 140530 -27890 0 0 {name=p139564 lab=_88128_/CLK }
C {devices/lab_pin.sym} 140530 -27870 0 0 {name=p139565 lab=_87870_/D }
C {devices/lab_pin.sym} 140710 -27890 0 1 {name=p139566 lab=_87870_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -27880 0 0 {name=X_87870_ }
C {devices/lab_pin.sym} 140540 -27770 0 0 {name=p139567 lab=_86069_/Q }
C {devices/lab_pin.sym} 140540 -27730 0 0 {name=p139568 lab=_51101_/X }
C {devices/lab_pin.sym} 140540 -27690 0 0 {name=p139569 lab=_51123_/Y }
C {devices/lab_pin.sym} 140700 -27730 0 1 {name=p139570 lab=_51124_/Y }
C {sky130_stdcells/o21ai_4.sym} 140620 -27730 0 0 {name=X_51124_ }
C {devices/lab_pin.sym} 140530 -27590 0 0 {name=p139571 lab=_88245_/CLK }
C {devices/lab_pin.sym} 140530 -27570 0 0 {name=p139572 lab=_86821_/D }
C {devices/lab_pin.sym} 140710 -27590 0 1 {name=p139573 lab=_66975_/B }
C {sky130_stdcells/dfxtp_4.sym} 140620 -27580 0 0 {name=X_86821_ }
C {devices/lab_pin.sym} 140540 -27470 0 0 {name=p139574 lab=_56696_/A }
C {devices/lab_pin.sym} 140540 -27430 0 0 {name=p139575 lab=_44220_/B }
C {devices/lab_pin.sym} 140540 -27390 0 0 {name=p139576 lab=_56980_/Y }
C {devices/lab_pin.sym} 140700 -27430 0 1 {name=p139577 lab=_85105_/D }
C {sky130_stdcells/a21oi_4.sym} 140620 -27430 0 0 {name=X_56981_ }
C {devices/lab_pin.sym} 140560 -27300 0 0 {name=p139578 lab=_69011_/A }
C {devices/lab_pin.sym} 140560 -27260 0 0 {name=p139579 lab=_87227_/Q }
C {devices/lab_pin.sym} 140680 -27280 0 1 {name=p139580 lab=_68967_/X }
C {sky130_stdcells/and2_4.sym} 140620 -27280 0 0 {name=X_68967_ }
C {devices/lab_pin.sym} 140560 -27160 0 0 {name=p139581 lab=_58659_/A }
C {devices/lab_pin.sym} 140560 -27120 0 0 {name=p139582 lab=_58720_/B }
C {devices/lab_pin.sym} 140680 -27140 0 1 {name=p139583 lab=_58720_/Y }
C {sky130_stdcells/nor2_4.sym} 140620 -27140 0 0 {name=X_58720_ }
C {devices/lab_pin.sym} 140580 -27010 0 0 {name=p139584 lab=_50973_/A }
C {devices/lab_pin.sym} 140660 -27010 0 1 {name=p139585 lab=_51056_/A }
C {sky130_stdcells/buf_2.sym} 140620 -27010 0 0 {name=X_51055_ }
C {devices/lab_pin.sym} 140540 -26920 0 0 {name=p139586 lab=_56392_/C }
C {devices/lab_pin.sym} 140540 -26880 0 0 {name=p139587 lab=_55641_/A }
C {devices/lab_pin.sym} 140540 -26840 0 0 {name=p139588 lab=_55610_/X }
C {devices/lab_pin.sym} 140540 -26800 0 0 {name=p139589 lab=_55931_/X }
C {devices/lab_pin.sym} 140700 -26860 0 1 {name=p139590 lab=_55932_/X }
C {sky130_stdcells/a211o_4.sym} 140620 -26860 0 0 {name=X_55932_ }
C {devices/lab_pin.sym} 140540 -26730 0 0 {name=p139591 lab=_67913_/X }
C {devices/lab_pin.sym} 140540 -26690 0 0 {name=p139592 lab=_67916_/X }
C {devices/lab_pin.sym} 140540 -26650 0 0 {name=p139593 lab=_67917_/X }
C {devices/lab_pin.sym} 140700 -26690 0 1 {name=p139594 lab=_67918_/X }
C {sky130_stdcells/a21o_4.sym} 140620 -26690 0 0 {name=X_67918_ }
C {devices/lab_pin.sym} 140530 -26550 0 0 {name=p139595 lab=_85535_/CLK }
C {devices/lab_pin.sym} 140530 -26530 0 0 {name=p139596 lab=_86752_/D }
C {devices/lab_pin.sym} 140710 -26550 0 1 {name=p139597 lab=_86752_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -26540 0 0 {name=X_86752_ }
C {devices/lab_pin.sym} 140530 -26410 0 0 {name=p139598 lab=_81994_/CLK }
C {devices/lab_pin.sym} 140530 -26390 0 0 {name=p139599 lab=_68712_/X }
C {devices/lab_pin.sym} 140710 -26410 0 1 {name=p139600 lab=_83964_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -26400 0 0 {name=X_83964_ }
C {devices/lab_pin.sym} 140560 -26280 0 0 {name=p139601 lab=_68759_/A }
C {devices/lab_pin.sym} 140560 -26240 0 0 {name=p139602 lab=_68898_/B }
C {devices/lab_pin.sym} 140680 -26260 0 1 {name=p139603 lab=_68898_/X }
C {sky130_stdcells/and2_4.sym} 140620 -26260 0 0 {name=X_68898_ }
C {devices/lab_pin.sym} 140540 -26150 0 0 {name=p139604 lab=_50002_/Y }
C {devices/lab_pin.sym} 140540 -26110 0 0 {name=p139605 lab=_50003_/X }
C {devices/lab_pin.sym} 140540 -26070 0 0 {name=p139606 lab=_50005_/X }
C {devices/lab_pin.sym} 140700 -26110 0 1 {name=p139607 lab=_86283_/D }
C {sky130_stdcells/a21oi_4.sym} 140620 -26110 0 0 {name=X_50006_ }
C {devices/lab_pin.sym} 140530 -25970 0 0 {name=p139608 lab=_85700_/CLK }
C {devices/lab_pin.sym} 140530 -25950 0 0 {name=p139609 lab=_85703_/D }
C {devices/lab_pin.sym} 140710 -25970 0 1 {name=p139610 lab=_85703_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -25960 0 0 {name=X_85703_ }
C {devices/lab_pin.sym} 140540 -25870 0 0 {name=p139611 lab=_58631_/X }
C {devices/lab_pin.sym} 140540 -25830 0 0 {name=p139612 lab=_58648_/Y }
C {devices/lab_pin.sym} 140540 -25790 0 0 {name=p139613 lab=_58649_/Y }
C {devices/lab_pin.sym} 140540 -25750 0 0 {name=p139614 lab=_58650_/X }
C {devices/lab_pin.sym} 140540 -25710 0 0 {name=p139615 lab=_58636_/X }
C {devices/lab_pin.sym} 140700 -25790 0 1 {name=p139616 lab=_58651_/X }
C {sky130_stdcells/o32a_4.sym} 140620 -25790 0 0 {name=X_58651_ }
C {devices/lab_pin.sym} 140530 -25630 0 0 {name=p139617 lab=_86582_/CLK }
C {devices/lab_pin.sym} 140530 -25610 0 0 {name=p139618 lab=_78139_/X }
C {devices/lab_pin.sym} 140710 -25630 0 1 {name=p139619 lab=_82915_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -25620 0 0 {name=X_82915_ }
C {devices/lab_pin.sym} 140580 -25490 0 0 {name=p139620 lab=_55862_/X }
C {devices/lab_pin.sym} 140660 -25490 0 1 {name=p139621 lab=_55863_/X }
C {sky130_stdcells/buf_2.sym} 140620 -25490 0 0 {name=X_55863_ }
C {devices/lab_pin.sym} 140540 -25400 0 0 {name=p139622 lab=_86954_/Q }
C {devices/lab_pin.sym} 140540 -25360 0 0 {name=p139623 lab=_67825_/X }
C {devices/lab_pin.sym} 140540 -25320 0 0 {name=p139624 lab=_67755_/X }
C {devices/lab_pin.sym} 140540 -25280 0 0 {name=p139625 lab=_67848_/X }
C {devices/lab_pin.sym} 140700 -25340 0 1 {name=p139626 lab=_67849_/X }
C {sky130_stdcells/a211o_4.sym} 140620 -25340 0 0 {name=X_67849_ }
C {devices/lab_pin.sym} 140530 -25190 0 0 {name=p139627 lab=_86361_/CLK }
C {devices/lab_pin.sym} 140530 -25170 0 0 {name=p139628 lab=_46982_/Y }
C {devices/lab_pin.sym} 140710 -25190 0 1 {name=p139629 lab=_59068_/A }
C {sky130_stdcells/dfxtp_4.sym} 140620 -25180 0 0 {name=X_86683_ }
C {devices/lab_pin.sym} 140530 -25050 0 0 {name=p139630 lab=_82299_/CLK }
C {devices/lab_pin.sym} 140530 -25030 0 0 {name=p139631 lab=_83895_/D }
C {devices/lab_pin.sym} 140710 -25050 0 1 {name=p139632 lab=_81967_/D }
C {sky130_stdcells/dfxtp_4.sym} 140620 -25040 0 0 {name=X_83895_ }
C {devices/lab_pin.sym} 140540 -24930 0 0 {name=p139633 lab=_57600_/Y }
C {devices/lab_pin.sym} 140540 -24890 0 0 {name=p139634 lab=_57592_/X }
C {devices/lab_pin.sym} 140540 -24850 0 0 {name=p139635 lab=_57601_/X }
C {devices/lab_pin.sym} 140700 -24890 0 1 {name=p139636 lab=_84971_/D }
C {sky130_stdcells/a21oi_4.sym} 140620 -24890 0 0 {name=X_57602_ }
C {devices/lab_pin.sym} 140560 -24760 0 0 {name=p139637 lab=_54823_/A }
C {devices/lab_pin.sym} 140560 -24720 0 0 {name=p139638 lab=_47561_/Y }
C {devices/lab_pin.sym} 140680 -24740 0 1 {name=p139639 lab=_54814_/Y }
C {sky130_stdcells/nand2_4.sym} 140620 -24740 0 0 {name=X_54814_ }
C {devices/lab_pin.sym} 140530 -24610 0 0 {name=p139640 lab=_86655_/CLK }
C {devices/lab_pin.sym} 140530 -24590 0 0 {name=p139641 lab=_53440_/Y }
C {devices/lab_pin.sym} 140710 -24610 0 1 {name=p139642 lab=_85634_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -24600 0 0 {name=X_85634_ }
C {devices/lab_pin.sym} 140560 -24500 0 0 {name=p139643 lab=_70860_/A }
C {devices/lab_pin.sym} 140560 -24460 0 0 {name=p139644 lab=_71088_/C }
C {devices/lab_pin.sym} 140560 -24420 0 0 {name=p139645 lab=_70863_/C }
C {devices/lab_pin.sym} 140560 -24380 0 0 {name=p139646 lab=_70860_/D }
C {devices/lab_pin.sym} 140680 -24440 0 1 {name=p139647 lab=_70860_/Y }
C {sky130_stdcells/nand4_4.sym} 140620 -24440 0 0 {name=X_70860_ }
C {devices/lab_pin.sym} 140540 -24310 0 0 {name=p139648 lab=_58140_/X }
C {devices/lab_pin.sym} 140540 -24270 0 0 {name=p139649 lab=_86112_/Q }
C {devices/lab_pin.sym} 140540 -24230 0 0 {name=p139650 lab=_58581_/X }
C {devices/lab_pin.sym} 140700 -24270 0 1 {name=p139651 lab=_58582_/Y }
C {sky130_stdcells/o21ai_4.sym} 140620 -24270 0 0 {name=X_58582_ }
C {devices/lab_pin.sym} 140530 -24130 0 0 {name=p139652 lab=_81019_/CLK }
C {devices/lab_pin.sym} 140530 -24110 0 0 {name=p139653 lab=_82846_/D }
C {devices/lab_pin.sym} 140710 -24130 0 1 {name=p139654 lab=_82814_/D }
C {sky130_stdcells/dfxtp_4.sym} 140620 -24120 0 0 {name=X_82846_ }
C {devices/lab_pin.sym} 140560 -24000 0 0 {name=p139655 lab=_55794_/A }
C {devices/lab_pin.sym} 140560 -23960 0 0 {name=p139656 lab=_85164_/Q }
C {devices/lab_pin.sym} 140680 -23980 0 1 {name=p139657 lab=_55794_/X }
C {sky130_stdcells/and2_4.sym} 140620 -23980 0 0 {name=X_55794_ }
C {devices/lab_pin.sym} 140560 -23860 0 0 {name=p139658 lab=_57528_/X }
C {devices/lab_pin.sym} 140560 -23820 0 0 {name=p139659 lab=_53501_/B }
C {devices/lab_pin.sym} 140680 -23840 0 1 {name=p139660 lab=_57533_/Y }
C {sky130_stdcells/nand2_4.sym} 140620 -23840 0 0 {name=X_57533_ }
C {devices/lab_pin.sym} 140580 -23710 0 0 {name=p139661 lab=clkbuf_9_345_0_CLK/X }
C {devices/lab_pin.sym} 140660 -23710 0 1 {name=p139662 lab=_86914_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 140620 -23710 0 0 {name=Xclkbuf_10_690_0_CLK }
C {devices/lab_pin.sym} 140540 -23610 0 0 {name=p139663 lab=_81382_/D }
C {devices/lab_pin.sym} 140540 -23570 0 0 {name=p139664 lab=_69504_/X }
C {devices/lab_pin.sym} 140540 -23530 0 0 {name=p139665 lab=_69518_/X }
C {devices/lab_pin.sym} 140700 -23570 0 1 {name=p139666 lab=_83918_/D }
C {sky130_stdcells/a21bo_4.sym} 140620 -23570 0 0 {name=X_69519_ }
C {devices/lab_pin.sym} 140530 -23430 0 0 {name=p139667 lab=_87859_/CLK }
C {devices/lab_pin.sym} 140530 -23410 0 0 {name=p139668 lab=_88353_/D }
C {devices/lab_pin.sym} 140710 -23430 0 1 {name=p139669 lab=_88353_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -23420 0 0 {name=X_88353_ }
C {devices/lab_pin.sym} 140560 -23300 0 0 {name=p139670 lab=_54731_/X }
C {devices/lab_pin.sym} 140560 -23260 0 0 {name=p139671 lab=_47451_/A }
C {devices/lab_pin.sym} 140680 -23280 0 1 {name=p139672 lab=_54745_/Y }
C {sky130_stdcells/nand2_4.sym} 140620 -23280 0 0 {name=X_54745_ }
C {devices/lab_pin.sym} 140530 -23150 0 0 {name=p139673 lab=_85561_/CLK }
C {devices/lab_pin.sym} 140530 -23130 0 0 {name=p139674 lab=_85565_/D }
C {devices/lab_pin.sym} 140710 -23150 0 1 {name=p139675 lab=_85565_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -23140 0 0 {name=X_85565_ }
C {devices/lab_pin.sym} 140580 -23010 0 0 {name=p139676 lab=_51956_/X }
C {devices/lab_pin.sym} 140660 -23010 0 1 {name=p139677 lab=_51958_/C }
C {sky130_stdcells/buf_2.sym} 140620 -23010 0 0 {name=X_51957_ }
C {devices/lab_pin.sym} 140560 -22920 0 0 {name=p139678 lab=_70903_/A }
C {devices/lab_pin.sym} 140560 -22880 0 0 {name=p139679 lab=_70791_/B }
C {devices/lab_pin.sym} 140560 -22840 0 0 {name=p139680 lab=_70791_/C }
C {devices/lab_pin.sym} 140560 -22800 0 0 {name=p139681 lab=_70791_/D }
C {devices/lab_pin.sym} 140680 -22860 0 1 {name=p139682 lab=_70791_/Y }
C {sky130_stdcells/nand4_4.sym} 140620 -22860 0 0 {name=X_70791_ }
C {devices/lab_pin.sym} 140530 -22710 0 0 {name=p139683 lab=_82206_/CLK }
C {devices/lab_pin.sym} 140530 -22690 0 0 {name=p139684 lab=_82777_/D }
C {devices/lab_pin.sym} 140710 -22710 0 1 {name=p139685 lab=_82777_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -22700 0 0 {name=X_82777_ }
C {devices/lab_pin.sym} 140530 -22570 0 0 {name=p139686 lab=_87820_/CLK }
C {devices/lab_pin.sym} 140530 -22550 0 0 {name=p139687 lab=_43697_/X }
C {devices/lab_pin.sym} 140710 -22570 0 1 {name=p139688 lab=_73056_/A }
C {sky130_stdcells/dfxtp_4.sym} 140620 -22560 0 0 {name=X_87304_ }
C {devices/lab_pin.sym} 140580 -22430 0 0 {name=p139689 lab=_41709_/X }
C {devices/lab_pin.sym} 140660 -22430 0 1 {name=p139690 lab=_41710_/X }
C {sky130_stdcells/buf_2.sym} 140620 -22430 0 0 {name=X_41710_ }
C {devices/lab_pin.sym} 140580 -22310 0 0 {name=p139691 lab=_72530_/A }
C {devices/lab_pin.sym} 140660 -22310 0 1 {name=p139692 lab=_72569_/A }
C {sky130_stdcells/buf_2.sym} 140620 -22310 0 0 {name=X_72530_ }
C {devices/lab_pin.sym} 140530 -22190 0 0 {name=p139693 lab=_84498_/CLK }
C {devices/lab_pin.sym} 140530 -22170 0 0 {name=p139694 lab=_84516_/D }
C {devices/lab_pin.sym} 140710 -22190 0 1 {name=p139695 lab=_61165_/C }
C {sky130_stdcells/dfxtp_4.sym} 140620 -22180 0 0 {name=X_84516_ }
C {devices/lab_pin.sym} 140560 -22080 0 0 {name=p139696 lab=_50908_/A }
C {devices/lab_pin.sym} 140560 -22040 0 0 {name=p139697 lab=_50919_/B }
C {devices/lab_pin.sym} 140560 -22000 0 0 {name=p139698 lab=_50897_/X }
C {devices/lab_pin.sym} 140560 -21960 0 0 {name=p139699 lab=_51772_/D }
C {devices/lab_pin.sym} 140680 -22020 0 1 {name=p139700 lab=_50908_/X }
C {sky130_stdcells/and4_4.sym} 140620 -22020 0 0 {name=X_50908_ }
C {devices/lab_pin.sym} 140580 -21870 0 0 {name=p139701 lab=clkbuf_8_90_0_CLK/X }
C {devices/lab_pin.sym} 140660 -21870 0 1 {name=p139702 lab=clkbuf_9_181_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 140620 -21870 0 0 {name=Xclkbuf_9_181_0_CLK }
C {devices/lab_pin.sym} 140530 -21750 0 0 {name=p139703 lab=_84079_/CLK }
C {devices/lab_pin.sym} 140530 -21730 0 0 {name=p139704 lab=_81728_/D }
C {devices/lab_pin.sym} 140710 -21750 0 1 {name=p139705 lab=_41119_/A }
C {sky130_stdcells/dfxtp_4.sym} 140620 -21740 0 0 {name=X_81728_ }
C {devices/lab_pin.sym} 140540 -21630 0 0 {name=p139706 lab=_57441_/X }
C {devices/lab_pin.sym} 140540 -21590 0 0 {name=p139707 lab=_83335_/Q }
C {devices/lab_pin.sym} 140540 -21550 0 0 {name=p139708 lab=_57463_/X }
C {devices/lab_pin.sym} 140700 -21590 0 1 {name=p139709 lab=_57464_/X }
C {sky130_stdcells/o21a_4.sym} 140620 -21590 0 0 {name=X_57464_ }
C {devices/lab_pin.sym} 140530 -21450 0 0 {name=p139710 lab=_87011_/CLK }
C {devices/lab_pin.sym} 140530 -21430 0 0 {name=p139711 lab=_88284_/D }
C {devices/lab_pin.sym} 140710 -21450 0 1 {name=p139712 lab=_88284_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -21440 0 0 {name=X_88284_ }
C {devices/lab_pin.sym} 140580 -21310 0 0 {name=p139713 lab=_42689_/Y }
C {devices/lab_pin.sym} 140660 -21310 0 1 {name=p139714 lab=_87769_/D }
C {sky130_stdcells/inv_2.sym} 140620 -21310 0 0 {name=X_42690_ }
C {devices/lab_pin.sym} 140580 -21190 0 0 {name=p139715 lab=_54729_/A }
C {devices/lab_pin.sym} 140660 -21190 0 1 {name=p139716 lab=_54676_/X }
C {sky130_stdcells/buf_2.sym} 140620 -21190 0 0 {name=X_54676_ }
C {devices/lab_pin.sym} 140530 -21070 0 0 {name=p139717 lab=_83745_/CLK }
C {devices/lab_pin.sym} 140530 -21050 0 0 {name=p139718 lab=_85496_/D }
C {devices/lab_pin.sym} 140710 -21070 0 1 {name=p139719 lab=_85496_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -21060 0 0 {name=X_85496_ }
C {devices/lab_pin.sym} 140540 -20950 0 0 {name=p139720 lab=_51885_/Y }
C {devices/lab_pin.sym} 140540 -20910 0 0 {name=p139721 lab=_51877_/X }
C {devices/lab_pin.sym} 140540 -20870 0 0 {name=p139722 lab=_51887_/X }
C {devices/lab_pin.sym} 140700 -20910 0 1 {name=p139723 lab=_51888_/Y }
C {sky130_stdcells/a21oi_4.sym} 140620 -20910 0 0 {name=X_51888_ }
C {devices/lab_pin.sym} 140540 -20800 0 0 {name=p139724 lab=_84761_/Q }
C {devices/lab_pin.sym} 140540 -20760 0 0 {name=p139725 lab=_59129_/X }
C {devices/lab_pin.sym} 140540 -20720 0 0 {name=p139726 lab=_59195_/X }
C {devices/lab_pin.sym} 140540 -20680 0 0 {name=p139727 lab=_59202_/X }
C {devices/lab_pin.sym} 140700 -20740 0 1 {name=p139728 lab=_84761_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 140620 -20740 0 0 {name=X_59203_ }
C {devices/lab_pin.sym} 140540 -20610 0 0 {name=p139729 lab=_56079_/X }
C {devices/lab_pin.sym} 140540 -20570 0 0 {name=p139730 lab=_56409_/X }
C {devices/lab_pin.sym} 140540 -20530 0 0 {name=p139731 lab=_56414_/Y }
C {devices/lab_pin.sym} 140700 -20570 0 1 {name=p139732 lab=_85203_/D }
C {sky130_stdcells/o21ai_4.sym} 140620 -20570 0 0 {name=X_56415_ }
C {devices/lab_pin.sym} 140530 -20430 0 0 {name=p139733 lab=_87235_/CLK }
C {devices/lab_pin.sym} 140530 -20410 0 0 {name=p139734 lab=_43850_/X }
C {devices/lab_pin.sym} 140710 -20430 0 1 {name=p139735 lab=_87235_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -20420 0 0 {name=X_87235_ }
C {devices/lab_pin.sym} 140560 -20300 0 0 {name=p139736 lab=_82911_/Q }
C {devices/lab_pin.sym} 140560 -20260 0 0 {name=p139737 lab=_41624_/B }
C {devices/lab_pin.sym} 140680 -20280 0 1 {name=p139738 lab=_41641_/X }
C {sky130_stdcells/or2_4.sym} 140620 -20280 0 0 {name=X_41641_ }
C {devices/lab_pin.sym} 140580 -20150 0 0 {name=p139739 lab=_54067_/A }
C {devices/lab_pin.sym} 140660 -20150 0 1 {name=p139740 lab=_53656_/A }
C {sky130_stdcells/buf_2.sym} 140620 -20150 0 0 {name=X_53627_ }
C {devices/lab_pin.sym} 140560 -20040 0 0 {name=p139741 lab=_72461_/A }
C {devices/lab_pin.sym} 140560 -20000 0 0 {name=p139742 lab=_72461_/B }
C {devices/lab_pin.sym} 140680 -20020 0 1 {name=p139743 lab=_72461_/Y }
C {sky130_stdcells/nor2_4.sym} 140620 -20020 0 0 {name=X_72461_ }
C {devices/lab_pin.sym} 140530 -19890 0 0 {name=p139744 lab=_84452_/CLK }
C {devices/lab_pin.sym} 140530 -19870 0 0 {name=p139745 lab=_61900_/Y }
C {devices/lab_pin.sym} 140710 -19890 0 1 {name=p139746 lab=_78070_/B }
C {sky130_stdcells/dfxtp_4.sym} 140620 -19880 0 0 {name=X_84447_ }
C {devices/lab_pin.sym} 140580 -19750 0 0 {name=p139747 lab=_50957_/A }
C {devices/lab_pin.sym} 140660 -19750 0 1 {name=p139748 lab=_50839_/X }
C {sky130_stdcells/buf_2.sym} 140620 -19750 0 0 {name=X_50839_ }
C {devices/lab_pin.sym} 140580 -19630 0 0 {name=p139749 lab=_57380_/X }
C {devices/lab_pin.sym} 140660 -19630 0 1 {name=p139750 lab=_57395_/X }
C {sky130_stdcells/buf_2.sym} 140620 -19630 0 0 {name=X_57395_ }
C {devices/lab_pin.sym} 140530 -19510 0 0 {name=p139751 lab=_81279_/CLK }
C {devices/lab_pin.sym} 140530 -19490 0 0 {name=p139752 lab=_76728_/A }
C {devices/lab_pin.sym} 140710 -19510 0 1 {name=p139753 lab=_81659_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -19500 0 0 {name=X_81659_ }
C {devices/lab_pin.sym} 140560 -19380 0 0 {name=p139754 lab=_53593_/B }
C {devices/lab_pin.sym} 140560 -19340 0 0 {name=p139755 lab=_74200_/B }
C {devices/lab_pin.sym} 140680 -19360 0 1 {name=p139756 lab=_74201_/B }
C {sky130_stdcells/xor2_4.sym} 140620 -19360 0 0 {name=X_74200_ }
C {devices/lab_pin.sym} 140540 -19270 0 0 {name=p139757 lab=_59115_/X }
C {devices/lab_pin.sym} 140540 -19230 0 0 {name=p139758 lab=_59130_/Y }
C {devices/lab_pin.sym} 140540 -19190 0 0 {name=p139759 lab=_59131_/Y }
C {devices/lab_pin.sym} 140540 -19150 0 0 {name=p139760 lab=_59133_/X }
C {devices/lab_pin.sym} 140540 -19110 0 0 {name=p139761 lab=_59119_/X }
C {devices/lab_pin.sym} 140700 -19190 0 1 {name=p139762 lab=_59134_/X }
C {sky130_stdcells/o32a_4.sym} 140620 -19190 0 0 {name=X_59134_ }
C {devices/lab_pin.sym} 140540 -19050 0 0 {name=p139763 lab=_71396_/Y }
C {devices/lab_pin.sym} 140540 -19010 0 0 {name=p139764 lab=_83508_/Q }
C {devices/lab_pin.sym} 140540 -18970 0 0 {name=p139765 lab=_71411_/Y }
C {devices/lab_pin.sym} 140700 -19010 0 1 {name=p139766 lab=_71412_/X }
C {sky130_stdcells/a21o_4.sym} 140620 -19010 0 0 {name=X_71412_ }
C {devices/lab_pin.sym} 140540 -18910 0 0 {name=p139767 lab=_44350_/X }
C {devices/lab_pin.sym} 140540 -18870 0 0 {name=p139768 lab=_44351_/X }
C {devices/lab_pin.sym} 140540 -18830 0 0 {name=p139769 lab=_41735_/X }
C {devices/lab_pin.sym} 140540 -18790 0 0 {name=p139770 lab=_87147_/Q }
C {devices/lab_pin.sym} 140540 -18750 0 0 {name=p139771 lab=_44353_/X }
C {devices/lab_pin.sym} 140700 -18830 0 1 {name=p139772 lab=_44361_/A }
C {sky130_stdcells/o32ai_4.sym} 140620 -18830 0 0 {name=X_44360_ }
C {devices/lab_pin.sym} 140540 -18690 0 0 {name=p139773 lab=_56130_/X }
C {devices/lab_pin.sym} 140540 -18650 0 0 {name=p139774 lab=_56337_/X }
C {devices/lab_pin.sym} 140540 -18610 0 0 {name=p139775 lab=_56345_/Y }
C {devices/lab_pin.sym} 140700 -18650 0 1 {name=p139776 lab=_85227_/D }
C {sky130_stdcells/o21ai_4.sym} 140620 -18650 0 0 {name=X_56346_ }
C {devices/lab_pin.sym} 140560 -18520 0 0 {name=p139777 lab=_75180_/A }
C {devices/lab_pin.sym} 140560 -18480 0 0 {name=p139778 lab=_75179_/Y }
C {devices/lab_pin.sym} 140680 -18500 0 1 {name=p139779 lab=_75182_/A }
C {sky130_stdcells/nor2_4.sym} 140620 -18500 0 0 {name=X_75180_ }
C {devices/lab_pin.sym} 140530 -18370 0 0 {name=p139780 lab=_81746_/CLK }
C {devices/lab_pin.sym} 140530 -18350 0 0 {name=p139781 lab=_87166_/D }
C {devices/lab_pin.sym} 140710 -18370 0 1 {name=p139782 lab=_87166_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -18360 0 0 {name=X_87166_ }
C {devices/lab_pin.sym} 140560 -18240 0 0 {name=p139783 lab=_53622_/A }
C {devices/lab_pin.sym} 140560 -18200 0 0 {name=p139784 lab=_57590_/B }
C {devices/lab_pin.sym} 140680 -18220 0 1 {name=p139785 lab=_53558_/Y }
C {sky130_stdcells/nand2_4.sym} 140620 -18220 0 0 {name=X_53558_ }
C {devices/lab_pin.sym} 140560 -18100 0 0 {name=p139786 lab=_41572_/A }
C {devices/lab_pin.sym} 140560 -18060 0 0 {name=p139787 lab=_41563_/B }
C {devices/lab_pin.sym} 140680 -18080 0 1 {name=p139788 lab=_41572_/X }
C {sky130_stdcells/or2_4.sym} 140620 -18080 0 0 {name=X_41572_ }
C {devices/lab_pin.sym} 140540 -17970 0 0 {name=p139789 lab=_72388_/Y }
C {devices/lab_pin.sym} 140540 -17930 0 0 {name=p139790 lab=_72391_/Y }
C {devices/lab_pin.sym} 140540 -17890 0 0 {name=p139791 lab=_72344_/X }
C {devices/lab_pin.sym} 140700 -17930 0 1 {name=p139792 lab=_72392_/X }
C {sky130_stdcells/a21o_4.sym} 140620 -17930 0 0 {name=X_72392_ }
C {devices/lab_pin.sym} 140530 -17790 0 0 {name=p139793 lab=_84507_/CLK }
C {devices/lab_pin.sym} 140530 -17770 0 0 {name=p139794 lab=_84378_/D }
C {devices/lab_pin.sym} 140710 -17790 0 1 {name=p139795 lab=_84378_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -17780 0 0 {name=X_84378_ }
C {devices/lab_pin.sym} 140540 -17690 0 0 {name=p139796 lab=_43296_/X }
C {devices/lab_pin.sym} 140540 -17650 0 0 {name=p139797 lab=_43305_/X }
C {devices/lab_pin.sym} 140540 -17610 0 0 {name=p139798 lab=_41220_/X }
C {devices/lab_pin.sym} 140540 -17570 0 0 {name=p139799 lab=_87487_/Q }
C {devices/lab_pin.sym} 140540 -17530 0 0 {name=p139800 lab=_43308_/X }
C {devices/lab_pin.sym} 140700 -17610 0 1 {name=p139801 lab=_43312_/A }
C {sky130_stdcells/o32ai_4.sym} 140620 -17610 0 0 {name=X_43311_ }
C {devices/lab_pin.sym} 140540 -17470 0 0 {name=p139802 lab=_74128_/X }
C {devices/lab_pin.sym} 140540 -17430 0 0 {name=p139803 lab=_74130_/X }
C {devices/lab_pin.sym} 140540 -17390 0 0 {name=p139804 lab=_74085_/X }
C {devices/lab_pin.sym} 140700 -17430 0 1 {name=p139805 lab=_74134_/A }
C {sky130_stdcells/a21o_4.sym} 140620 -17430 0 0 {name=X_74131_ }
C {devices/lab_pin.sym} 140530 -17290 0 0 {name=p139806 lab=_86121_/CLK }
C {devices/lab_pin.sym} 140530 -17270 0 0 {name=p139807 lab=_50869_/Y }
C {devices/lab_pin.sym} 140710 -17290 0 1 {name=p139808 lab=_86117_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -17280 0 0 {name=X_86117_ }
C {devices/lab_pin.sym} 140580 -17150 0 0 {name=p139809 lab=clkbuf_8_98_0_CLK/X }
C {devices/lab_pin.sym} 140660 -17150 0 1 {name=p139810 lab=clkbuf_9_196_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 140620 -17150 0 0 {name=Xclkbuf_9_196_0_CLK }
C {devices/lab_pin.sym} 140540 -17050 0 0 {name=p139811 lab=_40463_/X }
C {devices/lab_pin.sym} 140540 -17010 0 0 {name=p139812 lab=_81159_/Q }
C {devices/lab_pin.sym} 140540 -16970 0 0 {name=p139813 lab=_40522_/X }
C {devices/lab_pin.sym} 140700 -17010 0 1 {name=p139814 lab=_40523_/Y }
C {sky130_stdcells/o21ai_4.sym} 140620 -17010 0 0 {name=X_40523_ }
C {devices/lab_pin.sym} 140560 -16890 0 0 {name=p139815 lab=_50812_/A }
C {devices/lab_pin.sym} 140560 -16850 0 0 {name=p139816 lab=_52509_/B }
C {devices/lab_pin.sym} 140560 -16810 0 0 {name=p139817 lab=_52498_/C }
C {devices/lab_pin.sym} 140680 -16850 0 1 {name=p139818 lab=_52509_/X }
C {sky130_stdcells/and3_4.sym} 140620 -16850 0 0 {name=X_52509_ }
C {devices/lab_pin.sym} 140580 -16710 0 0 {name=p139819 lab=_71343_/A }
C {devices/lab_pin.sym} 140660 -16710 0 1 {name=p139820 lab=_71344_/A }
C {sky130_stdcells/inv_2.sym} 140620 -16710 0 0 {name=X_71343_ }
C {devices/lab_pin.sym} 140540 -16620 0 0 {name=p139821 lab=_84772_/Q }
C {devices/lab_pin.sym} 140540 -16580 0 0 {name=p139822 lab=_59043_/X }
C {devices/lab_pin.sym} 140540 -16540 0 0 {name=p139823 lab=_59058_/X }
C {devices/lab_pin.sym} 140540 -16500 0 0 {name=p139824 lab=_59064_/X }
C {devices/lab_pin.sym} 140700 -16560 0 1 {name=p139825 lab=_84772_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 140620 -16560 0 0 {name=X_59065_ }
C {devices/lab_pin.sym} 140530 -16410 0 0 {name=p139826 lab=_83337_/CLK }
C {devices/lab_pin.sym} 140530 -16390 0 0 {name=p139827 lab=_83329_/D }
C {devices/lab_pin.sym} 140710 -16410 0 1 {name=p139828 lab=_83329_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -16400 0 0 {name=X_83329_ }
C {devices/lab_pin.sym} 140580 -16270 0 0 {name=p139829 lab=_44290_/X }
C {devices/lab_pin.sym} 140660 -16270 0 1 {name=p139830 lab=_44292_/A }
C {sky130_stdcells/buf_2.sym} 140620 -16270 0 0 {name=X_44291_ }
C {devices/lab_pin.sym} 140580 -16150 0 0 {name=p139831 lab=_56277_/A }
C {devices/lab_pin.sym} 140660 -16150 0 1 {name=p139832 lab=_56279_/A }
C {sky130_stdcells/inv_2.sym} 140620 -16150 0 0 {name=X_56277_ }
C {devices/lab_pin.sym} 140530 -16030 0 0 {name=p139833 lab=_88272_/CLK }
C {devices/lab_pin.sym} 140530 -16010 0 0 {name=p139834 lab=_44462_/X }
C {devices/lab_pin.sym} 140710 -16030 0 1 {name=p139835 lab=_87097_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -16020 0 0 {name=X_87097_ }
C {devices/lab_pin.sym} 140540 -15910 0 0 {name=p139836 lab=_53487_/Y }
C {devices/lab_pin.sym} 140540 -15870 0 0 {name=p139837 lab=_53455_/X }
C {devices/lab_pin.sym} 140540 -15830 0 0 {name=p139838 lab=_53488_/Y }
C {devices/lab_pin.sym} 140700 -15870 0 1 {name=p139839 lab=_85627_/D }
C {sky130_stdcells/a21boi_4.sym} 140620 -15870 0 0 {name=X_53489_ }
C {devices/lab_pin.sym} 140580 -15730 0 0 {name=p139840 lab=_45975_/X }
C {devices/lab_pin.sym} 140660 -15730 0 1 {name=p139841 lab=_46030_/X }
C {sky130_stdcells/buf_2.sym} 140620 -15730 0 0 {name=X_46030_ }
C {devices/lab_pin.sym} 140540 -15650 0 0 {name=p139842 lab=_58010_/X }
C {devices/lab_pin.sym} 140540 -15610 0 0 {name=p139843 lab=_58012_/Y }
C {devices/lab_pin.sym} 140540 -15570 0 0 {name=p139844 lab=_58013_/Y }
C {devices/lab_pin.sym} 140540 -15530 0 0 {name=p139845 lab=_57899_/X }
C {devices/lab_pin.sym} 140540 -15490 0 0 {name=p139846 lab=_58015_/X }
C {devices/lab_pin.sym} 140700 -15570 0 1 {name=p139847 lab=_58016_/X }
C {sky130_stdcells/o32a_4.sym} 140620 -15570 0 0 {name=X_58016_ }
C {devices/lab_pin.sym} 140540 -15450 0 0 {name=p139848 lab=_43241_/X }
C {devices/lab_pin.sym} 140540 -15410 0 0 {name=p139849 lab=_43229_/X }
C {devices/lab_pin.sym} 140540 -15370 0 0 {name=p139850 lab=_41036_/X }
C {devices/lab_pin.sym} 140540 -15330 0 0 {name=p139851 lab=_87521_/Q }
C {devices/lab_pin.sym} 140540 -15290 0 0 {name=p139852 lab=_43232_/X }
C {devices/lab_pin.sym} 140700 -15370 0 1 {name=p139853 lab=_43243_/A }
C {sky130_stdcells/o32ai_4.sym} 140620 -15370 0 0 {name=X_43242_ }
C {devices/lab_pin.sym} 140540 -15230 0 0 {name=p139854 lab=_55218_/Y }
C {devices/lab_pin.sym} 140540 -15190 0 0 {name=p139855 lab=_55226_/Y }
C {devices/lab_pin.sym} 140540 -15150 0 0 {name=p139856 lab=_55227_/Y }
C {devices/lab_pin.sym} 140700 -15190 0 1 {name=p139857 lab=_55228_/Y }
C {sky130_stdcells/o21ai_4.sym} 140620 -15190 0 0 {name=X_55228_ }
C {devices/lab_pin.sym} 140540 -15070 0 0 {name=p139858 lab=_74059_/X }
C {devices/lab_pin.sym} 140540 -15030 0 0 {name=p139859 lab=_74061_/X }
C {devices/lab_pin.sym} 140540 -14990 0 0 {name=p139860 lab=_74019_/X }
C {devices/lab_pin.sym} 140700 -15030 0 1 {name=p139861 lab=_74065_/A }
C {sky130_stdcells/a21o_4.sym} 140620 -15030 0 0 {name=X_74062_ }
C {devices/lab_pin.sym} 140530 -14890 0 0 {name=p139862 lab=_85536_/CLK }
C {devices/lab_pin.sym} 140530 -14870 0 0 {name=p139863 lab=_51243_/Y }
C {devices/lab_pin.sym} 140710 -14890 0 1 {name=p139864 lab=_64617_/B }
C {sky130_stdcells/dfxtp_4.sym} 140620 -14880 0 0 {name=X_86048_ }
C {devices/lab_pin.sym} 140580 -14750 0 0 {name=p139865 lab=_40454_/A }
C {devices/lab_pin.sym} 140660 -14750 0 1 {name=p139866 lab=_40454_/Y }
C {sky130_stdcells/inv_2.sym} 140620 -14750 0 0 {name=X_40454_ }
C {devices/lab_pin.sym} 140560 -14660 0 0 {name=p139867 lab=_71173_/A }
C {devices/lab_pin.sym} 140560 -14620 0 0 {name=p139868 lab=_71276_/B }
C {devices/lab_pin.sym} 140560 -14580 0 0 {name=p139869 lab=_71276_/C }
C {devices/lab_pin.sym} 140560 -14540 0 0 {name=p139870 lab=_71276_/D }
C {devices/lab_pin.sym} 140680 -14600 0 1 {name=p139871 lab=_71274_/Y }
C {sky130_stdcells/nand4_4.sym} 140620 -14600 0 0 {name=X_71274_ }
C {devices/lab_pin.sym} 140540 -14480 0 0 {name=p139872 lab=_72959_/X }
C {devices/lab_pin.sym} 140540 -14440 0 0 {name=p139873 lab=_85592_/Q }
C {devices/lab_pin.sym} 140540 -14400 0 0 {name=p139874 lab=_72839_/X }
C {devices/lab_pin.sym} 140540 -14360 0 0 {name=p139875 lab=_73012_/X }
C {devices/lab_pin.sym} 140700 -14420 0 1 {name=p139876 lab=_73013_/X }
C {sky130_stdcells/a211o_4.sym} 140620 -14420 0 0 {name=X_73013_ }
C {devices/lab_pin.sym} 140560 -14300 0 0 {name=p139877 lab=_70229_/A }
C {devices/lab_pin.sym} 140560 -14260 0 0 {name=p139878 lab=_70229_/B }
C {devices/lab_pin.sym} 140560 -14220 0 0 {name=p139879 lab=_70225_/C }
C {devices/lab_pin.sym} 140560 -14180 0 0 {name=p139880 lab=_70229_/D }
C {devices/lab_pin.sym} 140680 -14240 0 1 {name=p139881 lab=_70225_/X }
C {sky130_stdcells/and4_4.sym} 140620 -14240 0 0 {name=X_70225_ }
C {devices/lab_pin.sym} 140560 -14100 0 0 {name=p139882 lab=_55159_/A }
C {devices/lab_pin.sym} 140560 -14060 0 0 {name=p139883 lab=_85130_/Q }
C {devices/lab_pin.sym} 140680 -14080 0 1 {name=p139884 lab=_55159_/X }
C {sky130_stdcells/and2_4.sym} 140620 -14080 0 0 {name=X_55159_ }
C {devices/lab_pin.sym} 140540 -13990 0 0 {name=p139885 lab=_43162_/X }
C {devices/lab_pin.sym} 140540 -13950 0 0 {name=p139886 lab=_43167_/X }
C {devices/lab_pin.sym} 140540 -13910 0 0 {name=p139887 lab=_40885_/X }
C {devices/lab_pin.sym} 140540 -13870 0 0 {name=p139888 lab=_73323_/A }
C {devices/lab_pin.sym} 140540 -13830 0 0 {name=p139889 lab=_43172_/X }
C {devices/lab_pin.sym} 140700 -13910 0 1 {name=p139890 lab=_43174_/A }
C {sky130_stdcells/o32ai_4.sym} 140620 -13910 0 0 {name=X_43173_ }
C {devices/lab_pin.sym} 140580 -13750 0 0 {name=p139891 lab=_78870_/A }
C {devices/lab_pin.sym} 140660 -13750 0 1 {name=p139892 lab=_78886_/A }
C {sky130_stdcells/inv_2.sym} 140620 -13750 0 0 {name=X_78870_ }
C {devices/lab_pin.sym} 140560 -13640 0 0 {name=p139893 lab=_82334_/Q }
C {devices/lab_pin.sym} 140560 -13600 0 0 {name=p139894 lab=_40385_/B }
C {devices/lab_pin.sym} 140680 -13620 0 1 {name=p139895 lab=_40385_/X }
C {sky130_stdcells/or2_4.sym} 140620 -13620 0 0 {name=X_40385_ }
C {devices/lab_pin.sym} 140580 -13490 0 0 {name=p139896 lab=_42124_/A }
C {devices/lab_pin.sym} 140660 -13490 0 1 {name=p139897 lab=_88024_/D }
C {sky130_stdcells/inv_2.sym} 140620 -13490 0 0 {name=X_42124_ }
C {devices/lab_pin.sym} 140540 -13390 0 0 {name=p139898 lab=_82059_/Q }
C {devices/lab_pin.sym} 140540 -13350 0 0 {name=p139899 lab=_77818_/Y }
C {devices/lab_pin.sym} 140540 -13310 0 0 {name=p139900 lab=_77820_/X }
C {devices/lab_pin.sym} 140700 -13350 0 1 {name=p139901 lab=_77822_/B }
C {sky130_stdcells/o21ai_4.sym} 140620 -13350 0 0 {name=X_77821_ }
C {devices/lab_pin.sym} 140580 -13210 0 0 {name=p139902 lab=_70155_/X }
C {devices/lab_pin.sym} 140660 -13210 0 1 {name=p139903 lab=_70157_/A }
C {sky130_stdcells/buf_2.sym} 140620 -13210 0 0 {name=X_70156_ }
C {devices/lab_pin.sym} 140580 -13090 0 0 {name=p139904 lab=_47857_/X }
C {devices/lab_pin.sym} 140660 -13090 0 1 {name=p139905 lab=_47981_/X }
C {sky130_stdcells/buf_2.sym} 140620 -13090 0 0 {name=X_47981_ }
C {devices/lab_pin.sym} 140540 -12990 0 0 {name=p139906 lab=_59966_/Y }
C {devices/lab_pin.sym} 140540 -12950 0 0 {name=p139907 lab=_59935_/A }
C {devices/lab_pin.sym} 140540 -12910 0 0 {name=p139908 lab=_59985_/A }
C {devices/lab_pin.sym} 140700 -12950 0 1 {name=p139909 lab=_59968_/B }
C {sky130_stdcells/a21o_4.sym} 140620 -12950 0 0 {name=X_59967_ }
C {devices/lab_pin.sym} 140530 -12810 0 0 {name=p139910 lab=_88001_/CLK }
C {devices/lab_pin.sym} 140530 -12790 0 0 {name=p139911 lab=_42172_/Y }
C {devices/lab_pin.sym} 140710 -12810 0 1 {name=p139912 lab=_87999_/Q }
C {sky130_stdcells/dfxtp_4.sym} 140620 -12800 0 0 {name=X_87999_ }
C {devices/lab_pin.sym} 140540 -12690 0 0 {name=p139913 lab=_49718_/Y }
C {devices/lab_pin.sym} 140540 -12650 0 0 {name=p139914 lab=_49706_/X }
C {devices/lab_pin.sym} 140540 -12610 0 0 {name=p139915 lab=_49719_/X }
C {devices/lab_pin.sym} 140700 -12650 0 1 {name=p139916 lab=_86336_/D }
C {sky130_stdcells/a21oi_4.sym} 140620 -12650 0 0 {name=X_49720_ }
C {devices/lab_pin.sym} 140580 -12510 0 0 {name=p139917 lab=clkbuf_9_321_0_CLK/X }
C {devices/lab_pin.sym} 140660 -12510 0 1 {name=p139918 lab=_87653_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 140620 -12510 0 0 {name=Xclkbuf_10_643_0_CLK }
C {devices/lab_pin.sym} 140580 -12390 0 0 {name=p139919 lab=_82400_/Q }
C {devices/lab_pin.sym} 140660 -12390 0 1 {name=p139920 lab=_54449_/D }
C {sky130_stdcells/inv_2.sym} 140620 -12390 0 0 {name=X_46932_ }
C {devices/lab_pin.sym} 140540 -12310 0 0 {name=p139921 lab=_42052_/X }
C {devices/lab_pin.sym} 140540 -12270 0 0 {name=p139922 lab=_42043_/X }
C {devices/lab_pin.sym} 140540 -12230 0 0 {name=p139923 lab=_40914_/X }
C {devices/lab_pin.sym} 140540 -12190 0 0 {name=p139924 lab=_73462_/A }
C {devices/lab_pin.sym} 140540 -12150 0 0 {name=p139925 lab=_42044_/X }
C {devices/lab_pin.sym} 140700 -12230 0 1 {name=p139926 lab=_42056_/A }
C {sky130_stdcells/o32ai_4.sym} 140620 -12230 0 0 {name=X_42055_ }
C {devices/lab_pin.sym} 140580 -12070 0 0 {name=p139927 lab=_58918_/A }
C {devices/lab_pin.sym} 140660 -12070 0 1 {name=p139928 lab=_58918_/X }
C {sky130_stdcells/buf_2.sym} 140620 -12070 0 0 {name=X_58918_ }
C {devices/lab_pin.sym} 140560 -11960 0 0 {name=p139929 lab=_77752_/A }
C {devices/lab_pin.sym} 140560 -11920 0 0 {name=p139930 lab=_77758_/A }
C {devices/lab_pin.sym} 140680 -11940 0 1 {name=p139931 lab=_77753_/B }
C {sky130_stdcells/nand2_4.sym} 140620 -11940 0 0 {name=X_77752_ }
C {devices/lab_pin.sym} 140560 -11820 0 0 {name=p139932 lab=_80946_/Q }
C {devices/lab_pin.sym} 140560 -11780 0 0 {name=p139933 lab=_74964_/B }
C {devices/lab_pin.sym} 140680 -11800 0 1 {name=p139934 lab=_74964_/X }
C {sky130_stdcells/xor2_4.sym} 140620 -11800 0 0 {name=X_74964_ }
C {devices/lab_pin.sym} 140540 -11700 0 0 {name=p139935 lab=_69603_/X }
C {devices/lab_pin.sym} 140540 -11660 0 0 {name=p139936 lab=_69937_/Y }
C {devices/lab_pin.sym} 140540 -11620 0 0 {name=p139937 lab=_70081_/X }
C {devices/lab_pin.sym} 140540 -11580 0 0 {name=p139938 lab=_70086_/Y }
C {devices/lab_pin.sym} 140700 -11640 0 1 {name=p139939 lab=_70087_/X }
C {sky130_stdcells/a211o_4.sym} 140620 -11640 0 0 {name=X_70087_ }
C {devices/lab_pin.sym} 140580 -11490 0 0 {name=p139940 lab=_59898_/A }
C {devices/lab_pin.sym} 140660 -11490 0 1 {name=p139941 lab=_60058_/B }
C {sky130_stdcells/buf_2.sym} 140620 -11490 0 0 {name=X_59898_ }
C {devices/lab_pin.sym} 140580 -11370 0 0 {name=p139942 lab=_41005_/Y }
C {devices/lab_pin.sym} 140660 -11370 0 1 {name=p139943 lab=_41006_/Y }
C {sky130_stdcells/inv_2.sym} 140620 -11370 0 0 {name=X_41006_ }
C {devices/lab_pin.sym} 140580 -11250 0 0 {name=p139944 lab=_76703_/A }
C {devices/lab_pin.sym} 140660 -11250 0 1 {name=p139945 lab=_76703_/Y }
C {sky130_stdcells/inv_2.sym} 140620 -11250 0 0 {name=X_76703_ }
C {devices/lab_pin.sym} 140580 -11130 0 0 {name=p139946 lab=clkbuf_8_67_0_CLK/X }
C {devices/lab_pin.sym} 140660 -11130 0 1 {name=p139947 lab=clkbuf_9_134_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 140620 -11130 0 0 {name=Xclkbuf_9_134_0_CLK }
C {devices/lab_pin.sym} 140580 -11010 0 0 {name=p139948 lab=_49571_/A }
C {devices/lab_pin.sym} 140660 -11010 0 1 {name=p139949 lab=_49651_/X }
C {sky130_stdcells/buf_2.sym} 140620 -11010 0 0 {name=X_49651_ }
C {devices/lab_pin.sym} 140540 -10910 0 0 {name=p139950 lab=_70117_/A }
C {devices/lab_pin.sym} 140540 -10870 0 0 {name=p139951 lab=_73818_/X }
C {devices/lab_pin.sym} 140540 -10830 0 0 {name=p139952 lab=_73914_/X }
C {devices/lab_pin.sym} 140700 -10870 0 1 {name=p139953 lab=_73915_/Y }
C {sky130_stdcells/o21ai_4.sym} 140620 -10870 0 0 {name=X_73915_ }
C {devices/lab_pin.sym} 140560 -10740 0 0 {name=p139954 lab=_46860_/X }
C {devices/lab_pin.sym} 140560 -10700 0 0 {name=p139955 lab=_51026_/B }
C {devices/lab_pin.sym} 140680 -10720 0 1 {name=p139956 lab=_46863_/Y }
C {sky130_stdcells/nand2_4.sym} 140620 -10720 0 0 {name=X_46863_ }
C {devices/lab_pin.sym} 140540 -10610 0 0 {name=p139957 lab=_58796_/X }
C {devices/lab_pin.sym} 140540 -10570 0 0 {name=p139958 lab=_86091_/Q }
C {devices/lab_pin.sym} 140540 -10530 0 0 {name=p139959 lab=_58848_/X }
C {devices/lab_pin.sym} 140700 -10570 0 1 {name=p139960 lab=_58849_/Y }
C {sky130_stdcells/o21ai_4.sym} 140620 -10570 0 0 {name=X_58849_ }
C {devices/lab_pin.sym} 140580 -10430 0 0 {name=p139961 lab=_77687_/B }
C {devices/lab_pin.sym} 140660 -10430 0 1 {name=p139962 lab=_77688_/B }
C {sky130_stdcells/inv_2.sym} 140620 -10430 0 0 {name=X_77683_ }
C {devices/lab_pin.sym} 140580 -10310 0 0 {name=p139963 lab=clkbuf_9_61_0_CLK/A }
C {devices/lab_pin.sym} 140660 -10310 0 1 {name=p139964 lab=clkbuf_9_61_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 140620 -10310 0 0 {name=Xclkbuf_9_61_0_CLK }
C {devices/lab_pin.sym} 140560 -10200 0 0 {name=p139965 lab=_80937_/Q }
C {devices/lab_pin.sym} 140560 -10160 0 0 {name=p139966 lab=_74895_/B }
C {devices/lab_pin.sym} 140680 -10180 0 1 {name=p139967 lab=_81186_/D }
C {sky130_stdcells/xor2_4.sym} 140620 -10180 0 0 {name=X_74895_ }
C {devices/lab_pin.sym} 140580 -10050 0 0 {name=p139968 lab=_48602_/A }
C {devices/lab_pin.sym} 140660 -10050 0 1 {name=p139969 lab=_48602_/Y }
C {sky130_stdcells/inv_2.sym} 140620 -10050 0 0 {name=X_48602_ }
C {devices/lab_pin.sym} 140540 -9950 0 0 {name=p139970 lab=_79401_/B }
C {devices/lab_pin.sym} 140540 -9910 0 0 {name=p139971 lab=_79418_/X }
C {devices/lab_pin.sym} 140540 -9870 0 0 {name=p139972 lab=_79421_/Y }
C {devices/lab_pin.sym} 140700 -9910 0 1 {name=p139973 lab=_79422_/Y }
C {sky130_stdcells/a21oi_4.sym} 140620 -9910 0 0 {name=X_79422_ }
C {devices/lab_pin.sym} 140540 -9790 0 0 {name=p139974 lab=_45810_/X }
C {devices/lab_pin.sym} 140540 -9750 0 0 {name=p139975 lab=_45813_/X }
C {devices/lab_pin.sym} 140540 -9710 0 0 {name=p139976 lab=_45757_/X }
C {devices/lab_pin.sym} 140700 -9750 0 1 {name=p139977 lab=_45814_/X }
C {sky130_stdcells/a21o_4.sym} 140620 -9750 0 0 {name=X_45814_ }
C {devices/lab_pin.sym} 140540 -9630 0 0 {name=p139978 lab=_76620_/X }
C {devices/lab_pin.sym} 140540 -9590 0 0 {name=p139979 lab=_81664_/Q }
C {devices/lab_pin.sym} 140540 -9550 0 0 {name=p139980 lab=_76633_/Y }
C {devices/lab_pin.sym} 140700 -9590 0 1 {name=p139981 lab=_76634_/Y }
C {sky130_stdcells/a21oi_4.sym} 140620 -9590 0 0 {name=X_76634_ }
C {devices/lab_pin.sym} 140540 -9470 0 0 {name=p139982 lab=_86361_/Q }
C {devices/lab_pin.sym} 140540 -9430 0 0 {name=p139983 lab=_49579_/X }
C {devices/lab_pin.sym} 140540 -9390 0 0 {name=p139984 lab=_49581_/Y }
C {devices/lab_pin.sym} 140700 -9430 0 1 {name=p139985 lab=_49582_/Y }
C {sky130_stdcells/o21ai_4.sym} 140620 -9430 0 0 {name=X_49582_ }
C {devices/lab_pin.sym} 140560 -9320 0 0 {name=p139986 lab=_61427_/B }
C {devices/lab_pin.sym} 140560 -9280 0 0 {name=p139987 lab=_61843_/B }
C {devices/lab_pin.sym} 140560 -9240 0 0 {name=p139988 lab=_61860_/C }
C {devices/lab_pin.sym} 140560 -9200 0 0 {name=p139989 lab=_61860_/D }
C {devices/lab_pin.sym} 140680 -9260 0 1 {name=p139990 lab=_61860_/Y }
C {sky130_stdcells/nand4_4.sym} 140620 -9260 0 0 {name=X_61860_ }
C {devices/lab_pin.sym} 140540 -9140 0 0 {name=p139991 lab=_68672_/B }
C {devices/lab_pin.sym} 140540 -9100 0 0 {name=p139992 lab=_73597_/X }
C {devices/lab_pin.sym} 140540 -9060 0 0 {name=p139993 lab=_73772_/X }
C {devices/lab_pin.sym} 140540 -9020 0 0 {name=p139994 lab=_73845_/Y }
C {devices/lab_pin.sym} 140700 -9080 0 1 {name=p139995 lab=_73846_/X }
C {sky130_stdcells/a211o_4.sym} 140620 -9080 0 0 {name=X_73846_ }
C {devices/lab_pin.sym} 140580 -8930 0 0 {name=p139996 lab=_46794_/A }
C {devices/lab_pin.sym} 140660 -8930 0 1 {name=p139997 lab=_52677_/B }
C {sky130_stdcells/inv_2.sym} 140620 -8930 0 0 {name=X_46794_ }
C {devices/lab_pin.sym} 140580 -8810 0 0 {name=p139998 lab=clkbuf_9_329_0_CLK/X }
C {devices/lab_pin.sym} 140660 -8810 0 1 {name=p139999 lab=_87671_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 140620 -8810 0 0 {name=Xclkbuf_10_658_0_CLK }
C {devices/lab_pin.sym} 140560 -8710 0 0 {name=p140000 lab=_48533_/A }
C {devices/lab_pin.sym} 140560 -8670 0 0 {name=p140001 lab=_48500_/X }
C {devices/lab_pin.sym} 140560 -8630 0 0 {name=p140002 lab=_48533_/C }
C {devices/lab_pin.sym} 140680 -8670 0 1 {name=p140003 lab=_48533_/X }
C {sky130_stdcells/and3_4.sym} 140620 -8670 0 0 {name=X_48533_ }
C {devices/lab_pin.sym} 140540 -8570 0 0 {name=p140004 lab=_60684_/X }
C {devices/lab_pin.sym} 140540 -8530 0 0 {name=p140005 lab=_60692_/X }
C {devices/lab_pin.sym} 140540 -8490 0 0 {name=p140006 lab=_60737_/Y }
C {devices/lab_pin.sym} 140540 -8450 0 0 {name=p140007 lab=_60809_/Y }
C {devices/lab_pin.sym} 140540 -8420 0 0 {name=p140008 lab=_60810_/Y }
C {devices/lab_pin.sym} 140700 -8490 0 1 {name=p140009 lab=_84561_/D }
C {sky130_stdcells/a41oi_4.sym} 140620 -8490 0 0 {name=X_60811_ }
C {devices/lab_pin.sym} 140560 -8340 0 0 {name=p140010 lab=_79351_/X }
C {devices/lab_pin.sym} 140560 -8300 0 0 {name=p140011 lab=_79360_/B }
C {devices/lab_pin.sym} 140680 -8320 0 1 {name=p140012 lab=_79353_/Y }
C {sky130_stdcells/xnor2_4.sym} 140620 -8320 0 0 {name=X_79353_ }
C {devices/lab_pin.sym} 140580 -8190 0 0 {name=p140013 lab=_45745_/A }
C {devices/lab_pin.sym} 140660 -8190 0 1 {name=p140014 lab=_74679_/B }
C {sky130_stdcells/inv_2.sym} 140620 -8190 0 0 {name=X_45745_ }
C {devices/lab_pin.sym} 140580 -8070 0 0 {name=p140015 lab=_76563_/X }
C {devices/lab_pin.sym} 140660 -8070 0 1 {name=p140016 lab=_76566_/A }
C {sky130_stdcells/inv_2.sym} 140620 -8070 0 0 {name=X_76565_ }
C {devices/lab_pin.sym} 140540 -7980 0 0 {name=p140017 lab=_40387_/X }
C {devices/lab_pin.sym} 140540 -7940 0 0 {name=p140018 lab=_42950_/X }
C {devices/lab_pin.sym} 140540 -7900 0 0 {name=p140019 lab=_87632_/Q }
C {devices/lab_pin.sym} 140540 -7860 0 0 {name=p140020 lab=_42951_/X }
C {devices/lab_pin.sym} 140700 -7920 0 1 {name=p140021 lab=_42957_/X }
C {sky130_stdcells/a2bb2o_4.sym} 140620 -7920 0 0 {name=X_42957_ }
C {devices/lab_pin.sym} 140560 -7800 0 0 {name=p140022 lab=_61839_/A }
C {devices/lab_pin.sym} 140560 -7760 0 0 {name=p140023 lab=_61791_/B }
C {devices/lab_pin.sym} 140560 -7720 0 0 {name=p140024 lab=_61732_/X }
C {devices/lab_pin.sym} 140560 -7680 0 0 {name=p140025 lab=_63051_/B }
C {devices/lab_pin.sym} 140680 -7740 0 1 {name=p140026 lab=_61791_/X }
C {sky130_stdcells/and4_4.sym} 140620 -7740 0 0 {name=X_61791_ }
C {devices/lab_pin.sym} 140580 -7590 0 0 {name=p140027 lab=_72899_/A }
C {devices/lab_pin.sym} 140660 -7590 0 1 {name=p140028 lab=_73777_/X }
C {sky130_stdcells/buf_2.sym} 140620 -7590 0 0 {name=X_73777_ }
C {devices/lab_pin.sym} 140580 -7470 0 0 {name=p140029 lab=_70944_/A }
C {devices/lab_pin.sym} 140660 -7470 0 1 {name=p140030 lab=_70990_/A }
C {sky130_stdcells/buf_2.sym} 140620 -7470 0 0 {name=X_70989_ }
C {devices/lab_pin.sym} 140580 -7350 0 0 {name=p140031 lab=clkbuf_8_74_0_CLK/X }
C {devices/lab_pin.sym} 140660 -7350 0 1 {name=p140032 lab=clkbuf_9_149_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 140620 -7350 0 0 {name=Xclkbuf_9_149_0_CLK }
C {devices/lab_pin.sym} 140580 -7230 0 0 {name=p140033 lab=_78306_/C }
C {devices/lab_pin.sym} 140660 -7230 0 1 {name=p140034 lab=_78304_/Y }
C {sky130_stdcells/inv_2.sym} 140620 -7230 0 0 {name=X_78304_ }
C {devices/lab_pin.sym} 140560 -7130 0 0 {name=p140035 lab=_63554_/A }
C {devices/lab_pin.sym} 140560 -7090 0 0 {name=p140036 lab=_63554_/B }
C {devices/lab_pin.sym} 140560 -7050 0 0 {name=p140037 lab=_84316_/Q }
C {devices/lab_pin.sym} 140680 -7090 0 1 {name=p140038 lab=_63530_/Y }
C {sky130_stdcells/nor3_4.sym} 140620 -7090 0 0 {name=X_63530_ }
C {devices/lab_pin.sym} 140560 -6960 0 0 {name=p140039 lab=_80703_/Q }
C {devices/lab_pin.sym} 140560 -6920 0 0 {name=p140040 lab=_80959_/D }
C {devices/lab_pin.sym} 140680 -6940 0 1 {name=p140041 lab=_75516_/Y }
C {sky130_stdcells/nor2_4.sym} 140620 -6940 0 0 {name=X_75516_ }
C {devices/lab_pin.sym} 140580 -6810 0 0 {name=p140042 lab=_41902_/A }
C {devices/lab_pin.sym} 140660 -6810 0 1 {name=p140043 lab=_50256_/A }
C {sky130_stdcells/buf_2.sym} 140620 -6810 0 0 {name=X_41908_ }
C {devices/lab_pin.sym} 140580 -6690 0 0 {name=p140044 lab=_48464_/A }
C {devices/lab_pin.sym} 140660 -6690 0 1 {name=p140045 lab=_50443_/A }
C {sky130_stdcells/buf_2.sym} 140620 -6690 0 0 {name=X_48464_ }
C {devices/lab_pin.sym} 140560 -6580 0 0 {name=p140046 lab=_72728_/A }
C {devices/lab_pin.sym} 140560 -6540 0 0 {name=p140047 lab=_72769_/B }
C {devices/lab_pin.sym} 140680 -6560 0 1 {name=p140048 lab=_72728_/Y }
C {sky130_stdcells/nor2_4.sym} 140620 -6560 0 0 {name=X_72728_ }
C {devices/lab_pin.sym} 140580 -6430 0 0 {name=p140049 lab=_63370_/A }
C {devices/lab_pin.sym} 140660 -6430 0 1 {name=p140050 lab=_63648_/B }
C {sky130_stdcells/buf_2.sym} 140620 -6430 0 0 {name=X_60742_ }
C {devices/lab_pin.sym} 140580 -6310 0 0 {name=p140051 lab=clkbuf_8_38_0_CLK/X }
C {devices/lab_pin.sym} 140660 -6310 0 1 {name=p140052 lab=clkbuf_9_76_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 140620 -6310 0 0 {name=Xclkbuf_9_76_0_CLK }
C {devices/lab_pin.sym} 140560 -6200 0 0 {name=p140053 lab=_79281_/X }
C {devices/lab_pin.sym} 140560 -6160 0 0 {name=p140054 lab=_79283_/Y }
C {devices/lab_pin.sym} 140680 -6180 0 1 {name=p140055 lab=_82827_/D }
C {sky130_stdcells/xnor2_4.sym} 140620 -6180 0 0 {name=X_79284_ }
C {devices/lab_pin.sym} 140540 -6070 0 0 {name=p140056 lab=_57419_/A }
C {devices/lab_pin.sym} 140540 -6030 0 0 {name=p140057 lab=_45357_/X }
C {devices/lab_pin.sym} 140540 -5990 0 0 {name=p140058 lab=_45339_/X }
C {devices/lab_pin.sym} 140700 -6030 0 1 {name=p140059 lab=_45676_/X }
C {sky130_stdcells/o21a_4.sym} 140620 -6030 0 0 {name=X_45676_ }
C {devices/lab_pin.sym} 140560 -5910 0 0 {name=p140060 lab=_76491_/X }
C {devices/lab_pin.sym} 140560 -5870 0 0 {name=p140061 lab=_76494_/Y }
C {devices/lab_pin.sym} 140560 -5830 0 0 {name=p140062 lab=_76492_/Y }
C {devices/lab_pin.sym} 140680 -5870 0 1 {name=p140063 lab=_76513_/D }
C {sky130_stdcells/nand3_4.sym} 140620 -5870 0 0 {name=X_76496_ }
C {devices/lab_pin.sym} 140540 -5760 0 0 {name=p140064 lab=_41626_/X }
C {devices/lab_pin.sym} 140540 -5720 0 0 {name=p140065 lab=_42886_/X }
C {devices/lab_pin.sym} 140540 -5680 0 0 {name=p140066 lab=_87668_/Q }
C {devices/lab_pin.sym} 140540 -5640 0 0 {name=p140067 lab=_42887_/X }
C {devices/lab_pin.sym} 140700 -5700 0 1 {name=p140068 lab=_87668_/D }
C {sky130_stdcells/a2bb2o_4.sym} 140620 -5700 0 0 {name=X_42888_ }
C {devices/lab_pin.sym} 140580 -5550 0 0 {name=p140069 lab=_47556_/A }
C {devices/lab_pin.sym} 140660 -5550 0 1 {name=p140070 lab=_47415_/X }
C {sky130_stdcells/buf_2.sym} 140620 -5550 0 0 {name=X_47415_ }
C {devices/lab_pin.sym} 140560 -5440 0 0 {name=p140071 lab=_82583_/Q }
C {devices/lab_pin.sym} 140560 -5400 0 0 {name=p140072 lab=_82495_/Q }
C {devices/lab_pin.sym} 140680 -5420 0 1 {name=p140073 lab=_78235_/Y }
C {sky130_stdcells/nor2_4.sym} 140620 -5420 0 0 {name=X_78235_ }
C {devices/lab_pin.sym} 140580 -5290 0 0 {name=p140074 lab=_44627_/A }
C {devices/lab_pin.sym} 140660 -5290 0 1 {name=p140075 lab=_44627_/Y }
C {sky130_stdcells/inv_2.sym} 140620 -5290 0 0 {name=X_44627_ }
C {devices/lab_pin.sym} 140580 -5170 0 0 {name=p140076 lab=_63398_/A }
C {devices/lab_pin.sym} 140660 -5170 0 1 {name=p140077 lab=_63488_/A }
C {sky130_stdcells/buf_2.sym} 140620 -5170 0 0 {name=X_63461_ }
C {devices/lab_pin.sym} 140540 -5070 0 0 {name=p140078 lab=_75443_/Y }
C {devices/lab_pin.sym} 140540 -5030 0 0 {name=p140079 lab=_75445_/Y }
C {devices/lab_pin.sym} 140540 -4990 0 0 {name=p140080 lab=_75442_/Y }
C {devices/lab_pin.sym} 140700 -5030 0 1 {name=p140081 lab=_75448_/B }
C {sky130_stdcells/o21ai_4.sym} 140620 -5030 0 0 {name=X_75447_ }
C {devices/lab_pin.sym} 140580 -4890 0 0 {name=p140082 lab=_41802_/A }
C {devices/lab_pin.sym} 140660 -4890 0 1 {name=p140083 lab=_41839_/X }
C {sky130_stdcells/buf_2.sym} 140620 -4890 0 0 {name=X_41839_ }
C {devices/lab_pin.sym} 140540 -4790 0 0 {name=p140084 lab=_48043_/X }
C {devices/lab_pin.sym} 140540 -4750 0 0 {name=p140085 lab=_48914_/B }
C {devices/lab_pin.sym} 140540 -4710 0 0 {name=p140086 lab=_48394_/Y }
C {devices/lab_pin.sym} 140700 -4750 0 1 {name=p140087 lab=_74381_/A }
C {sky130_stdcells/o21ai_4.sym} 140620 -4750 0 0 {name=X_48395_ }
C {devices/lab_pin.sym} 140580 -4610 0 0 {name=p140088 lab=_72250_/A }
C {devices/lab_pin.sym} 140660 -4610 0 1 {name=p140089 lab=_60673_/X }
C {sky130_stdcells/buf_2.sym} 140620 -4610 0 0 {name=X_60673_ }
C {devices/lab_pin.sym} 140580 -4490 0 0 {name=p140090 lab=_72687_/A }
C {devices/lab_pin.sym} 140660 -4490 0 1 {name=p140091 lab=_72668_/A }
C {sky130_stdcells/buf_2.sym} 140620 -4490 0 0 {name=X_72659_ }
C {devices/lab_pin.sym} 140580 -4370 0 0 {name=p140092 lab=_64667_/A }
C {devices/lab_pin.sym} 140660 -4370 0 1 {name=p140093 lab=_65225_/A }
C {sky130_stdcells/buf_2.sym} 140620 -4370 0 0 {name=X_65200_ }
C {devices/lab_pin.sym} 140580 -4250 0 0 {name=p140094 lab=_62179_/X }
C {devices/lab_pin.sym} 140660 -4250 0 1 {name=p140095 lab=_62412_/X }
C {sky130_stdcells/buf_2.sym} 140620 -4250 0 0 {name=X_62412_ }
C {devices/lab_pin.sym} 140540 -4150 0 0 {name=p140096 lab=_57919_/A }
C {devices/lab_pin.sym} 140540 -4110 0 0 {name=p140097 lab=_47332_/X }
C {devices/lab_pin.sym} 140540 -4070 0 0 {name=p140098 lab=_47345_/Y }
C {devices/lab_pin.sym} 140700 -4110 0 1 {name=p140099 lab=_47346_/Y }
C {sky130_stdcells/o21ai_4.sym} 140620 -4110 0 0 {name=X_47346_ }
C {devices/lab_pin.sym} 140580 -3970 0 0 {name=p140100 lab=_66180_/A }
C {devices/lab_pin.sym} 140660 -3970 0 1 {name=p140101 lab=_66180_/X }
C {sky130_stdcells/buf_2.sym} 140620 -3970 0 0 {name=X_66180_ }
C {devices/lab_pin.sym} 140560 -3860 0 0 {name=p140102 lab=_78166_/A }
C {devices/lab_pin.sym} 140560 -3820 0 0 {name=p140103 lab=_78165_/X }
C {devices/lab_pin.sym} 140680 -3840 0 1 {name=p140104 lab=_78166_/Y }
C {sky130_stdcells/nand2_4.sym} 140620 -3840 0 0 {name=X_78166_ }
C {devices/lab_pin.sym} 140540 -3750 0 0 {name=p140105 lab=_44554_/X }
C {devices/lab_pin.sym} 140540 -3710 0 0 {name=p140106 lab=_44555_/X }
C {devices/lab_pin.sym} 140540 -3670 0 0 {name=p140107 lab=_40845_/A }
C {devices/lab_pin.sym} 140540 -3630 0 0 {name=p140108 lab=_44556_/Y }
C {devices/lab_pin.sym} 140540 -3590 0 0 {name=p140109 lab=_44557_/X }
C {devices/lab_pin.sym} 140700 -3670 0 1 {name=p140110 lab=_87056_/D }
C {sky130_stdcells/o32ai_4.sym} 140620 -3670 0 0 {name=X_44558_ }
C {devices/lab_pin.sym} 140560 -3530 0 0 {name=p140111 lab=_63305_/X }
C {devices/lab_pin.sym} 140560 -3490 0 0 {name=p140112 lab=_63392_/B }
C {devices/lab_pin.sym} 140560 -3450 0 0 {name=p140113 lab=_63392_/C }
C {devices/lab_pin.sym} 140680 -3490 0 1 {name=p140114 lab=_63392_/Y }
C {sky130_stdcells/nor3_4.sym} 140620 -3490 0 0 {name=X_63392_ }
C {devices/lab_pin.sym} 140580 -3350 0 0 {name=p140115 lab=_75381_/B }
C {devices/lab_pin.sym} 140660 -3350 0 1 {name=p140116 lab=_75378_/Y }
C {sky130_stdcells/inv_2.sym} 140620 -3350 0 0 {name=X_75378_ }
C {devices/lab_pin.sym} 140540 -3260 0 0 {name=p140117 lab=_64999_/X }
C {devices/lab_pin.sym} 140540 -3220 0 0 {name=p140118 lab=_86157_/Q }
C {devices/lab_pin.sym} 140540 -3180 0 0 {name=p140119 lab=_65127_/X }
C {devices/lab_pin.sym} 140540 -3140 0 0 {name=p140120 lab=_65130_/X }
C {devices/lab_pin.sym} 140700 -3200 0 1 {name=p140121 lab=_65131_/X }
C {sky130_stdcells/a211o_4.sym} 140620 -3200 0 0 {name=X_65131_ }
C {devices/lab_pin.sym} 140560 -3060 0 0 {name=p140122 lab=_77111_/X }
C {devices/lab_pin.sym} 140560 -3020 0 0 {name=p140123 lab=_77126_/A }
C {devices/lab_pin.sym} 140680 -3040 0 1 {name=p140124 lab=_77118_/B }
C {sky130_stdcells/xor2_4.sym} 140620 -3040 0 0 {name=X_77117_ }
C {devices/lab_pin.sym} 140540 -2940 0 0 {name=p140125 lab=_41768_/X }
C {devices/lab_pin.sym} 140540 -2900 0 0 {name=p140126 lab=_43498_/X }
C {devices/lab_pin.sym} 140540 -2860 0 0 {name=p140127 lab=_87385_/Q }
C {devices/lab_pin.sym} 140540 -2820 0 0 {name=p140128 lab=_43499_/X }
C {devices/lab_pin.sym} 140700 -2880 0 1 {name=p140129 lab=_43509_/X }
C {sky130_stdcells/a2bb2o_4.sym} 140620 -2880 0 0 {name=X_43509_ }
C {devices/lab_pin.sym} 140580 -2730 0 0 {name=p140130 lab=_74342_/A }
C {devices/lab_pin.sym} 140660 -2730 0 1 {name=p140131 lab=_74338_/B }
C {sky130_stdcells/buf_2.sym} 140620 -2730 0 0 {name=X_74329_ }
C {devices/lab_pin.sym} 140540 -2630 0 0 {name=p140132 lab=_62339_/Y }
C {devices/lab_pin.sym} 140540 -2590 0 0 {name=p140133 lab=_62327_/X }
C {devices/lab_pin.sym} 140540 -2550 0 0 {name=p140134 lab=_62342_/Y }
C {devices/lab_pin.sym} 140700 -2590 0 1 {name=p140135 lab=_84417_/D }
C {sky130_stdcells/a21oi_4.sym} 140620 -2590 0 0 {name=X_62343_ }
C {devices/lab_pin.sym} 140580 -2450 0 0 {name=p140136 lab=_83387_/Q }
C {devices/lab_pin.sym} 140660 -2450 0 1 {name=p140137 lab=_54125_/B }
C {sky130_stdcells/inv_2.sym} 140620 -2450 0 0 {name=X_47277_ }
C {devices/lab_pin.sym} 140560 -2340 0 0 {name=p140138 lab=_82565_/Q }
C {devices/lab_pin.sym} 140560 -2300 0 0 {name=p140139 lab=_78103_/B }
C {devices/lab_pin.sym} 140680 -2320 0 1 {name=p140140 lab=_78100_/A }
C {sky130_stdcells/xnor2_4.sym} 140620 -2320 0 0 {name=X_78097_ }
C {devices/lab_pin.sym} 140540 -2230 0 0 {name=p140141 lab=_44481_/X }
C {devices/lab_pin.sym} 140540 -2190 0 0 {name=p140142 lab=_44482_/X }
C {devices/lab_pin.sym} 140540 -2150 0 0 {name=p140143 lab=_41219_/X }
C {devices/lab_pin.sym} 140540 -2110 0 0 {name=p140144 lab=_87083_/Q }
C {devices/lab_pin.sym} 140540 -2070 0 0 {name=p140145 lab=_44484_/X }
C {devices/lab_pin.sym} 140700 -2150 0 1 {name=p140146 lab=_44489_/Y }
C {sky130_stdcells/o32ai_4.sym} 140620 -2150 0 0 {name=X_44489_ }
C {devices/lab_pin.sym} 140560 -2000 0 0 {name=p140147 lab=_49007_/A }
C {devices/lab_pin.sym} 140560 -1960 0 0 {name=p140148 lab=_49015_/X }
C {devices/lab_pin.sym} 140680 -1980 0 1 {name=p140149 lab=_49016_/Y }
C {sky130_stdcells/nand2_4.sym} 140620 -1980 0 0 {name=X_49016_ }
C {devices/lab_pin.sym} 140560 -1880 0 0 {name=p140150 lab=_46228_/A }
C {devices/lab_pin.sym} 140560 -1840 0 0 {name=p140151 lab=_46090_/Y }
C {devices/lab_pin.sym} 140560 -1800 0 0 {name=p140152 lab=_46214_/C }
C {devices/lab_pin.sym} 140560 -1760 0 0 {name=p140153 lab=_46214_/D }
C {devices/lab_pin.sym} 140680 -1820 0 1 {name=p140154 lab=_46228_/Y }
C {sky130_stdcells/nand4_4.sym} 140620 -1820 0 0 {name=X_46228_ }
C {devices/lab_pin.sym} 140540 -1700 0 0 {name=p140155 lab=_65059_/X }
C {devices/lab_pin.sym} 140540 -1660 0 0 {name=p140156 lab=_85552_/Q }
C {devices/lab_pin.sym} 140540 -1620 0 0 {name=p140157 lab=_65060_/X }
C {devices/lab_pin.sym} 140540 -1580 0 0 {name=p140158 lab=_65061_/X }
C {devices/lab_pin.sym} 140700 -1640 0 1 {name=p140159 lab=_65062_/X }
C {sky130_stdcells/a211o_4.sym} 140620 -1640 0 0 {name=X_65062_ }
C {devices/lab_pin.sym} 140560 -1500 0 0 {name=p140160 lab=_77045_/X }
C {devices/lab_pin.sym} 140560 -1460 0 0 {name=p140161 lab=_77048_/B }
C {devices/lab_pin.sym} 140680 -1480 0 1 {name=p140162 lab=_77049_/B }
C {sky130_stdcells/xor2_4.sym} 140620 -1480 0 0 {name=X_77048_ }
C {devices/lab_pin.sym} 140560 -1380 0 0 {name=p140163 lab=_61376_/X }
C {devices/lab_pin.sym} 140560 -1340 0 0 {name=p140164 lab=_59898_/A }
C {devices/lab_pin.sym} 140560 -1300 0 0 {name=p140165 lab=_62233_/C }
C {devices/lab_pin.sym} 140560 -1260 0 0 {name=p140166 lab=_62597_/D }
C {devices/lab_pin.sym} 140680 -1320 0 1 {name=p140167 lab=_62274_/Y }
C {sky130_stdcells/nand4_4.sym} 140620 -1320 0 0 {name=X_62274_ }
C {devices/lab_pin.sym} 140560 -1200 0 0 {name=p140168 lab=_64412_/C }
C {devices/lab_pin.sym} 140560 -1160 0 0 {name=p140169 lab=_63934_/X }
C {devices/lab_pin.sym} 140560 -1120 0 0 {name=p140170 lab=_64091_/C }
C {devices/lab_pin.sym} 140560 -1080 0 0 {name=p140171 lab=_64027_/D }
C {devices/lab_pin.sym} 140680 -1140 0 1 {name=p140172 lab=_64013_/Y }
C {sky130_stdcells/nand4_4.sym} 140620 -1140 0 0 {name=X_64013_ }
C {devices/lab_pin.sym} 140560 -1010 0 0 {name=p140173 lab=_64361_/A }
C {devices/lab_pin.sym} 140560 -970 0 0 {name=p140174 lab=_61128_/A }
C {devices/lab_pin.sym} 140560 -930 0 0 {name=p140175 lab=_64221_/A }
C {devices/lab_pin.sym} 140680 -970 0 1 {name=p140176 lab=_64419_/B }
C {sky130_stdcells/nand3_4.sym} 140620 -970 0 0 {name=X_61225_ }
C {devices/lab_pin.sym} 140580 -830 0 0 {name=p140177 lab=_46159_/A }
C {devices/lab_pin.sym} 140660 -830 0 1 {name=p140178 lab=_46159_/X }
C {sky130_stdcells/buf_2.sym} 140620 -830 0 0 {name=X_46159_ }
C {devices/lab_pin.sym} 140580 -710 0 0 {name=p140179 lab=_70012_/A }
C {devices/lab_pin.sym} 140660 -710 0 1 {name=p140180 lab=_69870_/X }
C {sky130_stdcells/buf_2.sym} 140620 -710 0 0 {name=X_69870_ }
C {devices/lab_pin.sym} 141500 -42150 0 0 {name=p140181 lab=clkbuf_8_7_0_CLK/X }
C {devices/lab_pin.sym} 141580 -42150 0 1 {name=p140182 lab=clkbuf_9_14_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 141540 -42150 0 0 {name=Xclkbuf_9_14_0_CLK }
C {devices/lab_pin.sym} 141460 -42060 0 0 {name=p140183 lab=_87085_/Q }
C {devices/lab_pin.sym} 141460 -42020 0 0 {name=p140184 lab=_68818_/X }
C {devices/lab_pin.sym} 141460 -41980 0 0 {name=p140185 lab=_68819_/X }
C {devices/lab_pin.sym} 141460 -41940 0 0 {name=p140186 lab=_68820_/X }
C {devices/lab_pin.sym} 141620 -42000 0 1 {name=p140187 lab=_68821_/X }
C {sky130_stdcells/a211o_4.sym} 141540 -42000 0 0 {name=X_68821_ }
C {devices/lab_pin.sym} 141460 -41870 0 0 {name=p140188 lab=_61271_/A }
C {devices/lab_pin.sym} 141460 -41830 0 0 {name=p140189 lab=_61176_/B }
C {devices/lab_pin.sym} 141460 -41790 0 0 {name=p140190 lab=_61195_/A }
C {devices/lab_pin.sym} 141620 -41830 0 1 {name=p140191 lab=_61156_/X }
C {sky130_stdcells/a21o_4.sym} 141540 -41830 0 0 {name=X_61156_ }
C {devices/lab_pin.sym} 141460 -41710 0 0 {name=p140192 lab=_78993_/B }
C {devices/lab_pin.sym} 141460 -41670 0 0 {name=p140193 lab=_78993_/A }
C {devices/lab_pin.sym} 141460 -41630 0 0 {name=p140194 lab=_78998_/Y }
C {devices/lab_pin.sym} 141620 -41670 0 1 {name=p140195 lab=_78999_/Y }
C {sky130_stdcells/a21oi_4.sym} 141540 -41670 0 0 {name=X_78999_ }
C {devices/lab_pin.sym} 141480 -41550 0 0 {name=p140196 lab=_60125_/A }
C {devices/lab_pin.sym} 141480 -41510 0 0 {name=p140197 lab=_60103_/B }
C {devices/lab_pin.sym} 141480 -41470 0 0 {name=p140198 lab=_60107_/C }
C {devices/lab_pin.sym} 141600 -41510 0 1 {name=p140199 lab=_60107_/Y }
C {sky130_stdcells/nor3_4.sym} 141540 -41510 0 0 {name=X_60107_ }
C {devices/lab_pin.sym} 141480 -41380 0 0 {name=p140200 lab=_49928_/A }
C {devices/lab_pin.sym} 141480 -41340 0 0 {name=p140201 lab=_53131_/B }
C {devices/lab_pin.sym} 141600 -41360 0 1 {name=p140202 lab=_49918_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -41360 0 0 {name=X_49918_ }
C {devices/lab_pin.sym} 141460 -41250 0 0 {name=p140203 lab=_68749_/X }
C {devices/lab_pin.sym} 141460 -41210 0 0 {name=p140204 lab=_68751_/X }
C {devices/lab_pin.sym} 141460 -41170 0 0 {name=p140205 lab=_68477_/X }
C {devices/lab_pin.sym} 141620 -41210 0 1 {name=p140206 lab=_68752_/Y }
C {sky130_stdcells/a21oi_4.sym} 141540 -41210 0 0 {name=X_68752_ }
C {devices/lab_pin.sym} 141500 -41070 0 0 {name=p140207 lab=_66391_/A }
C {devices/lab_pin.sym} 141580 -41070 0 1 {name=p140208 lab=_65967_/B }
C {sky130_stdcells/buf_2.sym} 141540 -41070 0 0 {name=X_65964_ }
C {devices/lab_pin.sym} 141500 -40950 0 0 {name=p140209 lab=_61070_/X }
C {devices/lab_pin.sym} 141580 -40950 0 1 {name=p140210 lab=_61122_/B }
C {sky130_stdcells/buf_2.sym} 141540 -40950 0 0 {name=X_61087_ }
C {devices/lab_pin.sym} 141500 -40830 0 0 {name=p140211 lab=clkbuf_9_3_0_CLK/A }
C {devices/lab_pin.sym} 141580 -40830 0 1 {name=p140212 lab=clkbuf_9_2_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 141540 -40830 0 0 {name=Xclkbuf_9_2_0_CLK }
C {devices/lab_pin.sym} 141480 -40720 0 0 {name=p140213 lab=_67678_/X }
C {devices/lab_pin.sym} 141480 -40680 0 0 {name=p140214 lab=_87204_/Q }
C {devices/lab_pin.sym} 141600 -40700 0 1 {name=p140215 lab=_67703_/X }
C {sky130_stdcells/and2_4.sym} 141540 -40700 0 0 {name=X_67703_ }
C {devices/lab_pin.sym} 141500 -40570 0 0 {name=p140216 lab=_64561_/A }
C {devices/lab_pin.sym} 141580 -40570 0 1 {name=p140217 lab=_64915_/X }
C {sky130_stdcells/buf_2.sym} 141540 -40570 0 0 {name=X_64915_ }
C {devices/lab_pin.sym} 141500 -40450 0 0 {name=p140218 lab=clkbuf_9_29_0_CLK/A }
C {devices/lab_pin.sym} 141580 -40450 0 1 {name=p140219 lab=clkbuf_9_29_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 141540 -40450 0 0 {name=Xclkbuf_9_29_0_CLK }
C {devices/lab_pin.sym} 141460 -40350 0 0 {name=p140220 lab=_60027_/X }
C {devices/lab_pin.sym} 141460 -40310 0 0 {name=p140221 lab=_59995_/X }
C {devices/lab_pin.sym} 141460 -40270 0 0 {name=p140222 lab=_72584_/C }
C {devices/lab_pin.sym} 141620 -40310 0 1 {name=p140223 lab=_60038_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -40310 0 0 {name=X_60038_ }
C {devices/lab_pin.sym} 141460 -40190 0 0 {name=p140224 lab=_58058_/B }
C {devices/lab_pin.sym} 141460 -40150 0 0 {name=p140225 lab=_49825_/X }
C {devices/lab_pin.sym} 141460 -40110 0 0 {name=p140226 lab=_49848_/Y }
C {devices/lab_pin.sym} 141620 -40150 0 1 {name=p140227 lab=_49849_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -40150 0 0 {name=X_49849_ }
C {devices/lab_pin.sym} 141450 -40010 0 0 {name=p140228 lab=_80961_/CLK }
C {devices/lab_pin.sym} 141450 -39990 0 0 {name=p140229 lab=_80961_/D }
C {devices/lab_pin.sym} 141630 -40010 0 1 {name=p140230 lab=_75076_/B }
C {sky130_stdcells/dfxtp_4.sym} 141540 -40000 0 0 {name=X_80961_ }
C {devices/lab_pin.sym} 141500 -39870 0 0 {name=p140231 lab=_68389_/A }
C {devices/lab_pin.sym} 141580 -39870 0 1 {name=p140232 lab=_69035_/A }
C {sky130_stdcells/buf_2.sym} 141540 -39870 0 0 {name=X_68683_ }
C {devices/lab_pin.sym} 141500 -39750 0 0 {name=p140233 lab=_64611_/A }
C {devices/lab_pin.sym} 141580 -39750 0 1 {name=p140234 lab=_65896_/A }
C {sky130_stdcells/buf_2.sym} 141540 -39750 0 0 {name=X_65895_ }
C {devices/lab_pin.sym} 141450 -39630 0 0 {name=p140235 lab=_84115_/CLK }
C {devices/lab_pin.sym} 141450 -39610 0 0 {name=p140236 lab=_82700_/D }
C {devices/lab_pin.sym} 141630 -39630 0 1 {name=p140237 lab=_82700_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -39620 0 0 {name=X_82700_ }
C {devices/lab_pin.sym} 141480 -39500 0 0 {name=p140238 lab=_67539_/X }
C {devices/lab_pin.sym} 141480 -39460 0 0 {name=p140239 lab=_67634_/B }
C {devices/lab_pin.sym} 141600 -39480 0 1 {name=p140240 lab=_67634_/X }
C {sky130_stdcells/and2_4.sym} 141540 -39480 0 0 {name=X_67634_ }
C {devices/lab_pin.sym} 141460 -39370 0 0 {name=p140241 lab=_85741_/Q }
C {devices/lab_pin.sym} 141460 -39330 0 0 {name=p140242 lab=_52848_/X }
C {devices/lab_pin.sym} 141460 -39290 0 0 {name=p140243 lab=_52859_/Y }
C {devices/lab_pin.sym} 141620 -39330 0 1 {name=p140244 lab=_52860_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -39330 0 0 {name=X_52860_ }
C {devices/lab_pin.sym} 141500 -39190 0 0 {name=p140245 lab=_64615_/A }
C {devices/lab_pin.sym} 141580 -39190 0 1 {name=p140246 lab=_64846_/X }
C {sky130_stdcells/buf_2.sym} 141540 -39190 0 0 {name=X_64846_ }
C {devices/lab_pin.sym} 141450 -39070 0 0 {name=p140247 lab=_83681_/CLK }
C {devices/lab_pin.sym} 141450 -39050 0 0 {name=p140248 lab=_70864_/Y }
C {devices/lab_pin.sym} 141630 -39070 0 1 {name=p140249 lab=_46700_/A }
C {sky130_stdcells/dfxtp_4.sym} 141540 -39060 0 0 {name=X_83680_ }
C {devices/lab_pin.sym} 141450 -38930 0 0 {name=p140250 lab=_80740_/CLK }
C {devices/lab_pin.sym} 141450 -38910 0 0 {name=p140251 lab=_80892_/D }
C {devices/lab_pin.sym} 141630 -38930 0 1 {name=p140252 lab=_80892_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -38920 0 0 {name=X_80892_ }
C {devices/lab_pin.sym} 141460 -38810 0 0 {name=p140253 lab=_51808_/Y }
C {devices/lab_pin.sym} 141460 -38770 0 0 {name=p140254 lab=_51793_/X }
C {devices/lab_pin.sym} 141460 -38730 0 0 {name=p140255 lab=_51810_/X }
C {devices/lab_pin.sym} 141620 -38770 0 1 {name=p140256 lab=_51811_/Y }
C {sky130_stdcells/a21oi_4.sym} 141540 -38770 0 0 {name=X_51811_ }
C {devices/lab_pin.sym} 141450 -38630 0 0 {name=p140257 lab=_88180_/CLK }
C {devices/lab_pin.sym} 141450 -38610 0 0 {name=p140258 lab=_83983_/Q }
C {devices/lab_pin.sym} 141630 -38630 0 1 {name=p140259 lab=_78857_/B }
C {sky130_stdcells/dfxtp_4.sym} 141540 -38620 0 0 {name=X_82631_ }
C {devices/lab_pin.sym} 141460 -38510 0 0 {name=p140260 lab=_67562_/X }
C {devices/lab_pin.sym} 141460 -38470 0 0 {name=p140261 lab=_67564_/X }
C {devices/lab_pin.sym} 141460 -38430 0 0 {name=p140262 lab=_67423_/X }
C {devices/lab_pin.sym} 141620 -38470 0 1 {name=p140263 lab=_67565_/Y }
C {sky130_stdcells/a21oi_4.sym} 141540 -38470 0 0 {name=X_67565_ }
C {devices/lab_pin.sym} 141460 -38350 0 0 {name=p140264 lab=_52788_/Y }
C {devices/lab_pin.sym} 141460 -38310 0 0 {name=p140265 lab=_52783_/X }
C {devices/lab_pin.sym} 141460 -38270 0 0 {name=p140266 lab=_52790_/X }
C {devices/lab_pin.sym} 141620 -38310 0 1 {name=p140267 lab=_52791_/Y }
C {sky130_stdcells/a21oi_4.sym} 141540 -38310 0 0 {name=X_52791_ }
C {devices/lab_pin.sym} 141500 -38170 0 0 {name=p140268 lab=_64777_/A }
C {devices/lab_pin.sym} 141580 -38170 0 1 {name=p140269 lab=_64778_/A }
C {sky130_stdcells/buf_2.sym} 141540 -38170 0 0 {name=X_64777_ }
C {devices/lab_pin.sym} 141480 -38070 0 0 {name=p140270 lab=_62002_/A }
C {devices/lab_pin.sym} 141480 -38030 0 0 {name=p140271 lab=_62002_/B }
C {devices/lab_pin.sym} 141480 -37990 0 0 {name=p140272 lab=_78064_/B }
C {devices/lab_pin.sym} 141600 -38030 0 1 {name=p140273 lab=_61989_/Y }
C {sky130_stdcells/nor3_4.sym} 141540 -38030 0 0 {name=X_61989_ }
C {devices/lab_pin.sym} 141500 -37890 0 0 {name=p140274 lab=_45915_/X }
C {devices/lab_pin.sym} 141580 -37890 0 1 {name=p140275 lab=_69305_/A }
C {sky130_stdcells/buf_2.sym} 141540 -37890 0 0 {name=X_69304_ }
C {devices/lab_pin.sym} 141500 -37770 0 0 {name=p140276 lab=_54475_/A }
C {devices/lab_pin.sym} 141580 -37770 0 1 {name=p140277 lab=_54530_/X }
C {sky130_stdcells/buf_2.sym} 141540 -37770 0 0 {name=X_54530_ }
C {devices/lab_pin.sym} 141450 -37650 0 0 {name=p140278 lab=_85959_/CLK }
C {devices/lab_pin.sym} 141450 -37630 0 0 {name=p140279 lab=_54938_/Y }
C {devices/lab_pin.sym} 141630 -37650 0 1 {name=p140280 lab=_85350_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -37640 0 0 {name=X_85350_ }
C {devices/lab_pin.sym} 141500 -37510 0 0 {name=p140281 lab=_82723_/D }
C {devices/lab_pin.sym} 141580 -37510 0 1 {name=p140282 lab=_79165_/B }
C {sky130_stdcells/inv_2.sym} 141540 -37510 0 0 {name=X_66516_ }
C {devices/lab_pin.sym} 141480 -37420 0 0 {name=p140283 lab=_52588_/A }
C {devices/lab_pin.sym} 141480 -37380 0 0 {name=p140284 lab=_51721_/X }
C {devices/lab_pin.sym} 141480 -37340 0 0 {name=p140285 lab=_54286_/C }
C {devices/lab_pin.sym} 141480 -37300 0 0 {name=p140286 lab=_53261_/D }
C {devices/lab_pin.sym} 141600 -37360 0 1 {name=p140287 lab=_51742_/X }
C {sky130_stdcells/and4_4.sym} 141540 -37360 0 0 {name=X_51742_ }
C {devices/lab_pin.sym} 141500 -37210 0 0 {name=p140288 lab=_64012_/A }
C {devices/lab_pin.sym} 141580 -37210 0 1 {name=p140289 lab=_63731_/D }
C {sky130_stdcells/buf_2.sym} 141540 -37210 0 0 {name=X_63728_ }
C {devices/lab_pin.sym} 141450 -37090 0 0 {name=p140290 lab=_82595_/CLK }
C {devices/lab_pin.sym} 141450 -37070 0 0 {name=p140291 lab=_82562_/D }
C {devices/lab_pin.sym} 141630 -37090 0 1 {name=p140292 lab=_78083_/A }
C {sky130_stdcells/dfxtp_4.sym} 141540 -37080 0 0 {name=X_82562_ }
C {devices/lab_pin.sym} 141500 -36950 0 0 {name=p140293 lab=_67495_/X }
C {devices/lab_pin.sym} 141580 -36950 0 1 {name=p140294 lab=_67496_/X }
C {sky130_stdcells/buf_2.sym} 141540 -36950 0 0 {name=X_67496_ }
C {sky130_stdcells/decap_3.sym} 141540 -36800 0 0 {name=XPHY_15 }
C {devices/lab_pin.sym} 141450 -36650 0 0 {name=p140295 lab=_84299_/CLK }
C {devices/lab_pin.sym} 141450 -36630 0 0 {name=p140296 lab=_84301_/D }
C {devices/lab_pin.sym} 141630 -36650 0 1 {name=p140297 lab=_80310_/B }
C {sky130_stdcells/dfxtp_4.sym} 141540 -36640 0 0 {name=X_84301_ }
C {sky130_stdcells/decap_3.sym} 141540 -36480 0 0 {name=XPHY_26 }
C {devices/lab_pin.sym} 141450 -36330 0 0 {name=p140298 lab=_82067_/CLK }
C {devices/lab_pin.sym} 141450 -36310 0 0 {name=p140299 lab=_81513_/D }
C {devices/lab_pin.sym} 141630 -36330 0 1 {name=p140300 lab=_75971_/A }
C {sky130_stdcells/dfxtp_4.sym} 141540 -36320 0 0 {name=X_81513_ }
C {devices/lab_pin.sym} 141460 -36220 0 0 {name=p140301 lab=_88044_/Q }
C {devices/lab_pin.sym} 141460 -36180 0 0 {name=p140302 lab=_69121_/X }
C {devices/lab_pin.sym} 141460 -36140 0 0 {name=p140303 lab=_69232_/X }
C {devices/lab_pin.sym} 141460 -36100 0 0 {name=p140304 lab=_69234_/X }
C {devices/lab_pin.sym} 141620 -36160 0 1 {name=p140305 lab=_69235_/X }
C {sky130_stdcells/a211o_4.sym} 141540 -36160 0 0 {name=X_69235_ }
C {devices/lab_pin.sym} 141460 -36030 0 0 {name=p140306 lab=_85438_/Q }
C {devices/lab_pin.sym} 141460 -35990 0 0 {name=p140307 lab=_54457_/X }
C {devices/lab_pin.sym} 141460 -35950 0 0 {name=p140308 lab=_54460_/Y }
C {devices/lab_pin.sym} 141620 -35990 0 1 {name=p140309 lab=_54461_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -35990 0 0 {name=X_54461_ }
C {devices/lab_pin.sym} 141480 -35870 0 0 {name=p140310 lab=_66145_/X }
C {devices/lab_pin.sym} 141480 -35830 0 0 {name=p140311 lab=_66397_/X }
C {devices/lab_pin.sym} 141480 -35790 0 0 {name=p140312 lab=_66147_/X }
C {devices/lab_pin.sym} 141600 -35830 0 1 {name=p140313 lab=_66447_/Y }
C {sky130_stdcells/nand3_4.sym} 141540 -35830 0 0 {name=X_66447_ }
C {devices/lab_pin.sym} 141450 -35690 0 0 {name=p140314 lab=_85249_/CLK }
C {devices/lab_pin.sym} 141450 -35670 0 0 {name=p140315 lab=_85281_/D }
C {devices/lab_pin.sym} 141630 -35690 0 1 {name=p140316 lab=_56192_/C }
C {sky130_stdcells/dfxtp_4.sym} 141540 -35680 0 0 {name=X_85281_ }
C {devices/lab_pin.sym} 141480 -35580 0 0 {name=p140317 lab=_51657_/X }
C {devices/lab_pin.sym} 141480 -35540 0 0 {name=p140318 lab=_51684_/B }
C {devices/lab_pin.sym} 141480 -35500 0 0 {name=p140319 lab=_51684_/C }
C {devices/lab_pin.sym} 141480 -35460 0 0 {name=p140320 lab=_53196_/D }
C {devices/lab_pin.sym} 141600 -35520 0 1 {name=p140321 lab=_51673_/X }
C {sky130_stdcells/and4_4.sym} 141540 -35520 0 0 {name=X_51673_ }
C {sky130_stdcells/decap_3.sym} 141540 -35340 0 0 {name=XPHY_37 }
C {devices/lab_pin.sym} 141480 -35210 0 0 {name=p140322 lab=_63697_/A }
C {devices/lab_pin.sym} 141480 -35170 0 0 {name=p140323 lab=_58187_/A }
C {devices/lab_pin.sym} 141480 -35130 0 0 {name=p140324 lab=_63537_/C }
C {devices/lab_pin.sym} 141600 -35170 0 1 {name=p140325 lab=_63659_/X }
C {sky130_stdcells/and3_4.sym} 141540 -35170 0 0 {name=X_63659_ }
C {devices/lab_pin.sym} 141450 -35030 0 0 {name=p140326 lab=_82702_/CLK }
C {devices/lab_pin.sym} 141450 -35010 0 0 {name=p140327 lab=_82493_/D }
C {devices/lab_pin.sym} 141630 -35030 0 1 {name=p140328 lab=_78213_/B }
C {sky130_stdcells/dfxtp_4.sym} 141540 -35020 0 0 {name=X_82493_ }
C {sky130_stdcells/decap_3.sym} 141540 -34860 0 0 {name=XPHY_48 }
C {sky130_stdcells/decap_3.sym} 141540 -34680 0 0 {name=XPHY_59 }
C {devices/lab_pin.sym} 141500 -34530 0 0 {name=p140329 lab=_56255_/A }
C {devices/lab_pin.sym} 141580 -34530 0 1 {name=p140330 lab=_56200_/X }
C {sky130_stdcells/buf_2.sym} 141540 -34530 0 0 {name=X_56200_ }
C {devices/lab_pin.sym} 141450 -34410 0 0 {name=p140331 lab=_87026_/CLK }
C {devices/lab_pin.sym} 141450 -34390 0 0 {name=p140332 lab=_44644_/Y }
C {devices/lab_pin.sym} 141630 -34410 0 1 {name=p140333 lab=_87020_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -34400 0 0 {name=X_87020_ }
C {devices/lab_pin.sym} 141480 -34280 0 0 {name=p140334 lab=_53405_/X }
C {devices/lab_pin.sym} 141480 -34240 0 0 {name=p140335 lab=_54587_/B }
C {devices/lab_pin.sym} 141600 -34260 0 1 {name=p140336 lab=_53412_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -34260 0 0 {name=X_53412_ }
C {devices/lab_pin.sym} 141450 -34130 0 0 {name=p140337 lab=_85346_/CLK }
C {devices/lab_pin.sym} 141450 -34110 0 0 {name=p140338 lab=_84232_/D }
C {devices/lab_pin.sym} 141630 -34130 0 1 {name=p140339 lab=_81024_/D }
C {sky130_stdcells/dfxtp_4.sym} 141540 -34120 0 0 {name=X_84232_ }
C {devices/lab_pin.sym} 141480 -34000 0 0 {name=p140340 lab=_50624_/A }
C {devices/lab_pin.sym} 141480 -33960 0 0 {name=p140341 lab=_53844_/B }
C {devices/lab_pin.sym} 141600 -33980 0 1 {name=p140342 lab=_50624_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -33980 0 0 {name=X_50624_ }
C {devices/lab_pin.sym} 141450 -33850 0 0 {name=p140343 lab=_81412_/CLK }
C {devices/lab_pin.sym} 141450 -33830 0 0 {name=p140344 lab=_76674_/X }
C {devices/lab_pin.sym} 141630 -33850 0 1 {name=p140345 lab=_81412_/D }
C {sky130_stdcells/dfxtp_4.sym} 141540 -33840 0 0 {name=X_81444_ }
C {devices/lab_pin.sym} 141460 -33730 0 0 {name=p140346 lab=_57178_/Y }
C {devices/lab_pin.sym} 141460 -33690 0 0 {name=p140347 lab=_57179_/Y }
C {devices/lab_pin.sym} 141460 -33650 0 0 {name=p140348 lab=_57112_/X }
C {devices/lab_pin.sym} 141620 -33690 0 1 {name=p140349 lab=_57180_/Y }
C {sky130_stdcells/a21oi_4.sym} 141540 -33690 0 0 {name=X_57180_ }
C {devices/lab_pin.sym} 141460 -33580 0 0 {name=p140350 lab=_87537_/Q }
C {devices/lab_pin.sym} 141460 -33540 0 0 {name=p140351 lab=_68958_/X }
C {devices/lab_pin.sym} 141460 -33500 0 0 {name=p140352 lab=_69113_/X }
C {devices/lab_pin.sym} 141460 -33460 0 0 {name=p140353 lab=_69165_/X }
C {devices/lab_pin.sym} 141620 -33520 0 1 {name=p140354 lab=_69166_/X }
C {sky130_stdcells/a211o_4.sym} 141540 -33520 0 0 {name=X_69166_ }
C {devices/lab_pin.sym} 141480 -33380 0 0 {name=p140355 lab=_54378_/A }
C {devices/lab_pin.sym} 141480 -33340 0 0 {name=p140356 lab=_52700_/B }
C {devices/lab_pin.sym} 141600 -33360 0 1 {name=p140357 lab=_54392_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -33360 0 0 {name=X_54392_ }
C {devices/lab_pin.sym} 141500 -33230 0 0 {name=p140358 lab=_65307_/A }
C {devices/lab_pin.sym} 141580 -33230 0 1 {name=p140359 lab=_66433_/A }
C {sky130_stdcells/buf_2.sym} 141540 -33230 0 0 {name=X_66378_ }
C {devices/lab_pin.sym} 141480 -33130 0 0 {name=p140360 lab=_56131_/A }
C {devices/lab_pin.sym} 141480 -33090 0 0 {name=p140361 lab=_56140_/B }
C {devices/lab_pin.sym} 141480 -33050 0 0 {name=p140362 lab=_85291_/Q }
C {devices/lab_pin.sym} 141600 -33090 0 1 {name=p140363 lab=_56131_/Y }
C {sky130_stdcells/nand3_4.sym} 141540 -33090 0 0 {name=X_56131_ }
C {devices/lab_pin.sym} 141460 -32970 0 0 {name=p140364 lab=_66750_/X }
C {devices/lab_pin.sym} 141460 -32930 0 0 {name=p140365 lab=_66753_/X }
C {devices/lab_pin.sym} 141460 -32890 0 0 {name=p140366 lab=_68062_/X }
C {devices/lab_pin.sym} 141620 -32930 0 1 {name=p140367 lab=_68117_/Y }
C {sky130_stdcells/a21oi_4.sym} 141540 -32930 0 0 {name=X_68117_ }
C {devices/lab_pin.sym} 141480 -32820 0 0 {name=p140368 lab=_53339_/A }
C {devices/lab_pin.sym} 141480 -32780 0 0 {name=p140369 lab=_53330_/B }
C {devices/lab_pin.sym} 141480 -32740 0 0 {name=p140370 lab=_53330_/C }
C {devices/lab_pin.sym} 141480 -32700 0 0 {name=p140371 lab=_52831_/D }
C {devices/lab_pin.sym} 141600 -32760 0 1 {name=p140372 lab=_53343_/X }
C {sky130_stdcells/and4_4.sym} 141540 -32760 0 0 {name=X_53343_ }
C {devices/lab_pin.sym} 141460 -32630 0 0 {name=p140373 lab=_65325_/X }
C {devices/lab_pin.sym} 141460 -32590 0 0 {name=p140374 lab=_65328_/X }
C {devices/lab_pin.sym} 141460 -32550 0 0 {name=p140375 lab=_65277_/X }
C {devices/lab_pin.sym} 141620 -32590 0 1 {name=p140376 lab=_65333_/A }
C {sky130_stdcells/a21o_4.sym} 141540 -32590 0 0 {name=X_65329_ }
C {devices/lab_pin.sym} 141450 -32450 0 0 {name=p140377 lab=_84166_/CLK }
C {devices/lab_pin.sym} 141450 -32430 0 0 {name=p140378 lab=_66005_/X }
C {devices/lab_pin.sym} 141630 -32450 0 1 {name=p140379 lab=_84163_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -32440 0 0 {name=X_84163_ }
C {devices/lab_pin.sym} 141460 -32330 0 0 {name=p140380 lab=_86178_/Q }
C {devices/lab_pin.sym} 141460 -32290 0 0 {name=p140381 lab=_50499_/X }
C {devices/lab_pin.sym} 141460 -32250 0 0 {name=p140382 lab=_50554_/Y }
C {devices/lab_pin.sym} 141620 -32290 0 1 {name=p140383 lab=_50555_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -32290 0 0 {name=X_50555_ }
C {devices/lab_pin.sym} 141450 -32150 0 0 {name=p140384 lab=_81362_/CLK }
C {devices/lab_pin.sym} 141450 -32130 0 0 {name=p140385 lab=_76933_/Y }
C {devices/lab_pin.sym} 141630 -32150 0 1 {name=p140386 lab=_81375_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -32140 0 0 {name=X_81375_ }
C {devices/lab_pin.sym} 141460 -32040 0 0 {name=p140387 lab=_87989_/Q }
C {devices/lab_pin.sym} 141460 -32000 0 0 {name=p140388 lab=_69007_/X }
C {devices/lab_pin.sym} 141460 -31960 0 0 {name=p140389 lab=_69051_/X }
C {devices/lab_pin.sym} 141460 -31920 0 0 {name=p140390 lab=_69096_/X }
C {devices/lab_pin.sym} 141620 -31980 0 1 {name=p140391 lab=_69097_/X }
C {sky130_stdcells/a211o_4.sym} 141540 -31980 0 0 {name=X_69097_ }
C {devices/lab_pin.sym} 141450 -31830 0 0 {name=p140392 lab=_83145_/CLK }
C {devices/lab_pin.sym} 141450 -31810 0 0 {name=p140393 lab=_83114_/D }
C {devices/lab_pin.sym} 141630 -31830 0 1 {name=p140394 lab=_70133_/A }
C {sky130_stdcells/dfxtp_4.sym} 141540 -31820 0 0 {name=X_83114_ }
C {devices/lab_pin.sym} 141460 -31710 0 0 {name=p140395 lab=_56058_/X }
C {devices/lab_pin.sym} 141460 -31670 0 0 {name=p140396 lab=_56060_/X }
C {devices/lab_pin.sym} 141460 -31630 0 0 {name=p140397 lab=_56061_/Y }
C {devices/lab_pin.sym} 141620 -31670 0 1 {name=p140398 lab=_85303_/D }
C {sky130_stdcells/o21ai_4.sym} 141540 -31670 0 0 {name=X_56062_ }
C {devices/lab_pin.sym} 141500 -31530 0 0 {name=p140399 lab=_80325_/X }
C {devices/lab_pin.sym} 141580 -31530 0 1 {name=p140400 lab=_80326_/X }
C {sky130_stdcells/buf_2.sym} 141540 -31530 0 0 {name=X_80326_ }
C {devices/lab_pin.sym} 141460 -31440 0 0 {name=p140401 lab=_86945_/Q }
C {devices/lab_pin.sym} 141460 -31400 0 0 {name=p140402 lab=_68023_/X }
C {devices/lab_pin.sym} 141460 -31360 0 0 {name=p140403 lab=_68024_/X }
C {devices/lab_pin.sym} 141460 -31320 0 0 {name=p140404 lab=_68047_/X }
C {devices/lab_pin.sym} 141620 -31380 0 1 {name=p140405 lab=_68049_/B }
C {sky130_stdcells/a211o_4.sym} 141540 -31380 0 0 {name=X_68048_ }
C {devices/lab_pin.sym} 141480 -31260 0 0 {name=p140406 lab=_51914_/A }
C {devices/lab_pin.sym} 141480 -31220 0 0 {name=p140407 lab=_53274_/B }
C {devices/lab_pin.sym} 141480 -31180 0 0 {name=p140408 lab=_53293_/C }
C {devices/lab_pin.sym} 141480 -31140 0 0 {name=p140409 lab=_52758_/D }
C {devices/lab_pin.sym} 141600 -31200 0 1 {name=p140410 lab=_53274_/X }
C {sky130_stdcells/and4_4.sym} 141540 -31200 0 0 {name=X_53274_ }
C {devices/lab_pin.sym} 141450 -31050 0 0 {name=p140411 lab=_80928_/CLK }
C {devices/lab_pin.sym} 141450 -31030 0 0 {name=p140412 lab=_66849_/X }
C {devices/lab_pin.sym} 141630 -31050 0 1 {name=p140413 lab=_80918_/D }
C {sky130_stdcells/dfxtp_4.sym} 141540 -31040 0 0 {name=X_84094_ }
C {devices/lab_pin.sym} 141460 -30930 0 0 {name=p140414 lab=_86191_/Q }
C {devices/lab_pin.sym} 141460 -30890 0 0 {name=p140415 lab=_50464_/X }
C {devices/lab_pin.sym} 141460 -30850 0 0 {name=p140416 lab=_50485_/Y }
C {devices/lab_pin.sym} 141620 -30890 0 1 {name=p140417 lab=_50486_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -30890 0 0 {name=X_50486_ }
C {devices/lab_pin.sym} 141480 -30780 0 0 {name=p140418 lab=_55013_/A }
C {devices/lab_pin.sym} 141480 -30740 0 0 {name=p140419 lab=_55026_/B }
C {devices/lab_pin.sym} 141480 -30700 0 0 {name=p140420 lab=_55013_/C }
C {devices/lab_pin.sym} 141480 -30660 0 0 {name=p140421 lab=_55013_/D }
C {devices/lab_pin.sym} 141600 -30720 0 1 {name=p140422 lab=_55013_/X }
C {sky130_stdcells/and4_4.sym} 141540 -30720 0 0 {name=X_55013_ }
C {devices/lab_pin.sym} 141480 -30580 0 0 {name=p140423 lab=_52220_/A }
C {devices/lab_pin.sym} 141480 -30540 0 0 {name=p140424 lab=_48843_/B }
C {devices/lab_pin.sym} 141600 -30560 0 1 {name=p140425 lab=_52225_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -30560 0 0 {name=X_52225_ }
C {devices/lab_pin.sym} 141450 -30430 0 0 {name=p140426 lab=_83046_/CLK }
C {devices/lab_pin.sym} 141450 -30410 0 0 {name=p140427 lab=_74528_/Y }
C {devices/lab_pin.sym} 141630 -30430 0 1 {name=p140428 lab=_47031_/A }
C {sky130_stdcells/dfxtp_4.sym} 141540 -30420 0 0 {name=X_83045_ }
C {devices/lab_pin.sym} 141450 -30290 0 0 {name=p140429 lab=_87922_/CLK }
C {devices/lab_pin.sym} 141450 -30270 0 0 {name=p140430 lab=_87922_/D }
C {devices/lab_pin.sym} 141630 -30290 0 1 {name=p140431 lab=_87922_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -30280 0 0 {name=X_87922_ }
C {devices/lab_pin.sym} 141480 -30160 0 0 {name=p140432 lab=_80257_/A }
C {devices/lab_pin.sym} 141480 -30120 0 0 {name=p140433 lab=_80256_/X }
C {devices/lab_pin.sym} 141600 -30140 0 1 {name=p140434 lab=_80257_/Y }
C {sky130_stdcells/xnor2_4.sym} 141540 -30140 0 0 {name=X_80257_ }
C {devices/lab_pin.sym} 141500 -30010 0 0 {name=p140435 lab=_70048_/A }
C {devices/lab_pin.sym} 141580 -30010 0 1 {name=p140436 lab=_70010_/X }
C {sky130_stdcells/buf_2.sym} 141540 -30010 0 0 {name=X_70010_ }
C {devices/lab_pin.sym} 141460 -29930 0 0 {name=p140437 lab=_59805_/Y }
C {devices/lab_pin.sym} 141460 -29890 0 0 {name=p140438 lab=_59840_/A }
C {devices/lab_pin.sym} 141460 -29850 0 0 {name=p140439 lab=_59820_/Y }
C {devices/lab_pin.sym} 141460 -29810 0 0 {name=p140440 lab=_80422_/A }
C {devices/lab_pin.sym} 141460 -29770 0 0 {name=p140441 lab=_59814_/X }
C {devices/lab_pin.sym} 141620 -29850 0 1 {name=p140442 lab=_84694_/D }
C {sky130_stdcells/o32a_4.sym} 141540 -29850 0 0 {name=X_59821_ }
C {devices/lab_pin.sym} 141480 -29710 0 0 {name=p140443 lab=_52156_/A }
C {devices/lab_pin.sym} 141480 -29670 0 0 {name=p140444 lab=_52140_/X }
C {devices/lab_pin.sym} 141480 -29630 0 0 {name=p140445 lab=_52156_/C }
C {devices/lab_pin.sym} 141600 -29670 0 1 {name=p140446 lab=_52156_/X }
C {sky130_stdcells/and3_4.sym} 141540 -29670 0 0 {name=X_52156_ }
C {devices/lab_pin.sym} 141450 -29530 0 0 {name=p140447 lab=_87068_/CLK }
C {devices/lab_pin.sym} 141450 -29510 0 0 {name=p140448 lab=_42474_/Y }
C {devices/lab_pin.sym} 141630 -29530 0 1 {name=p140449 lab=_73699_/A }
C {sky130_stdcells/dfxtp_4.sym} 141540 -29520 0 0 {name=X_87853_ }
C {devices/lab_pin.sym} 141480 -29400 0 0 {name=p140450 lab=_80184_/Y }
C {devices/lab_pin.sym} 141480 -29360 0 0 {name=p140451 lab=_80187_/Y }
C {devices/lab_pin.sym} 141600 -29380 0 1 {name=p140452 lab=_80198_/B }
C {sky130_stdcells/xor2_4.sym} 141540 -29380 0 0 {name=X_80188_ }
C {devices/lab_pin.sym} 141460 -29280 0 0 {name=p140453 lab=_69640_/Y }
C {devices/lab_pin.sym} 141460 -29240 0 0 {name=p140454 lab=_69916_/X }
C {devices/lab_pin.sym} 141460 -29200 0 0 {name=p140455 lab=_69984_/X }
C {devices/lab_pin.sym} 141460 -29160 0 0 {name=p140456 lab=_69998_/Y }
C {devices/lab_pin.sym} 141620 -29220 0 1 {name=p140457 lab=_69999_/X }
C {sky130_stdcells/a211o_4.sym} 141540 -29220 0 0 {name=X_69999_ }
C {devices/lab_pin.sym} 141480 -29080 0 0 {name=p140458 lab=_51112_/A }
C {devices/lab_pin.sym} 141480 -29040 0 0 {name=p140459 lab=_52799_/B }
C {devices/lab_pin.sym} 141600 -29060 0 1 {name=p140460 lab=_51107_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -29060 0 0 {name=X_51107_ }
C {devices/lab_pin.sym} 141450 -28930 0 0 {name=p140461 lab=_87995_/CLK }
C {devices/lab_pin.sym} 141450 -28910 0 0 {name=p140462 lab=_46031_/X }
C {devices/lab_pin.sym} 141630 -28930 0 1 {name=p140463 lab=_86804_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -28920 0 0 {name=X_86804_ }
C {devices/lab_pin.sym} 141500 -28790 0 0 {name=p140464 lab=_59752_/A }
C {devices/lab_pin.sym} 141580 -28790 0 1 {name=p140465 lab=_60312_/D }
C {sky130_stdcells/buf_2.sym} 141540 -28790 0 0 {name=X_59752_ }
C {devices/lab_pin.sym} 141480 -28680 0 0 {name=p140466 lab=_52083_/A }
C {devices/lab_pin.sym} 141480 -28640 0 0 {name=p140467 lab=_50385_/B }
C {devices/lab_pin.sym} 141600 -28660 0 1 {name=p140468 lab=_52087_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -28660 0 0 {name=X_52087_ }
C {devices/lab_pin.sym} 141500 -28530 0 0 {name=p140469 lab=_56940_/Y }
C {devices/lab_pin.sym} 141580 -28530 0 1 {name=p140470 lab=_56989_/A }
C {sky130_stdcells/buf_2.sym} 141540 -28530 0 0 {name=X_56964_ }
C {devices/lab_pin.sym} 141450 -28410 0 0 {name=p140471 lab=_87544_/CLK }
C {devices/lab_pin.sym} 141450 -28390 0 0 {name=p140472 lab=_42657_/Y }
C {devices/lab_pin.sym} 141630 -28410 0 1 {name=p140473 lab=_87784_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -28400 0 0 {name=X_87784_ }
C {devices/lab_pin.sym} 141450 -28270 0 0 {name=p140474 lab=_85005_/CLK }
C {devices/lab_pin.sym} 141450 -28250 0 0 {name=p140475 lab=_84996_/D }
C {devices/lab_pin.sym} 141630 -28270 0 1 {name=p140476 lab=_84996_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -28260 0 0 {name=X_84996_ }
C {devices/lab_pin.sym} 141500 -28130 0 0 {name=p140477 lab=_58703_/A }
C {devices/lab_pin.sym} 141580 -28130 0 1 {name=p140478 lab=_58703_/X }
C {sky130_stdcells/buf_2.sym} 141540 -28130 0 0 {name=X_58703_ }
C {devices/lab_pin.sym} 141460 -28030 0 0 {name=p140479 lab=_86085_/Q }
C {devices/lab_pin.sym} 141460 -27990 0 0 {name=p140480 lab=_51020_/X }
C {devices/lab_pin.sym} 141460 -27950 0 0 {name=p140481 lab=_51037_/Y }
C {devices/lab_pin.sym} 141620 -27990 0 1 {name=p140482 lab=_51038_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -27990 0 0 {name=X_51038_ }
C {devices/lab_pin.sym} 141480 -27860 0 0 {name=p140483 lab=_55949_/A }
C {devices/lab_pin.sym} 141480 -27820 0 0 {name=p140484 lab=_55915_/B }
C {devices/lab_pin.sym} 141600 -27840 0 1 {name=p140485 lab=_55915_/X }
C {sky130_stdcells/and2_4.sym} 141540 -27840 0 0 {name=X_55915_ }
C {devices/lab_pin.sym} 141450 -27710 0 0 {name=p140486 lab=_86127_/CLK }
C {devices/lab_pin.sym} 141450 -27690 0 0 {name=p140487 lab=_86735_/D }
C {devices/lab_pin.sym} 141630 -27710 0 1 {name=p140488 lab=_86735_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -27700 0 0 {name=X_86735_ }
C {devices/lab_pin.sym} 141460 -27590 0 0 {name=p140489 lab=_71958_/Y }
C {devices/lab_pin.sym} 141460 -27550 0 0 {name=p140490 lab=_57592_/X }
C {devices/lab_pin.sym} 141460 -27510 0 0 {name=p140491 lab=_71960_/X }
C {devices/lab_pin.sym} 141620 -27550 0 1 {name=p140492 lab=_71961_/Y }
C {sky130_stdcells/a21oi_4.sym} 141540 -27550 0 0 {name=X_71961_ }
C {devices/lab_pin.sym} 141500 -27410 0 0 {name=p140493 lab=_59683_/A }
C {devices/lab_pin.sym} 141580 -27410 0 1 {name=p140494 lab=_59687_/C }
C {sky130_stdcells/inv_2.sym} 141540 -27410 0 0 {name=X_59683_ }
C {devices/lab_pin.sym} 141450 -27290 0 0 {name=p140495 lab=_83973_/CLK }
C {devices/lab_pin.sym} 141450 -27270 0 0 {name=p140496 lab=_83947_/D }
C {devices/lab_pin.sym} 141630 -27290 0 1 {name=p140497 lab=_80803_/D }
C {sky130_stdcells/dfxtp_4.sym} 141540 -27280 0 0 {name=X_83947_ }
C {devices/lab_pin.sym} 141460 -27170 0 0 {name=p140498 lab=_56893_/Y }
C {devices/lab_pin.sym} 141460 -27130 0 0 {name=p140499 lab=_56894_/Y }
C {devices/lab_pin.sym} 141460 -27090 0 0 {name=p140500 lab=_45888_/A }
C {devices/lab_pin.sym} 141620 -27130 0 1 {name=p140501 lab=_56895_/X }
C {sky130_stdcells/o21a_4.sym} 141540 -27130 0 0 {name=X_56895_ }
C {devices/lab_pin.sym} 141460 -27020 0 0 {name=p140502 lab=_41899_/Y }
C {devices/lab_pin.sym} 141460 -26980 0 0 {name=p140503 lab=_73529_/X }
C {devices/lab_pin.sym} 141460 -26940 0 0 {name=p140504 lab=_73698_/X }
C {devices/lab_pin.sym} 141460 -26900 0 0 {name=p140505 lab=_73699_/Y }
C {devices/lab_pin.sym} 141620 -26960 0 1 {name=p140506 lab=_73700_/X }
C {sky130_stdcells/a211o_4.sym} 141540 -26960 0 0 {name=X_73700_ }
C {devices/lab_pin.sym} 141480 -26820 0 0 {name=p140507 lab=_58634_/A }
C {devices/lab_pin.sym} 141480 -26780 0 0 {name=p140508 lab=_58649_/B }
C {devices/lab_pin.sym} 141600 -26800 0 1 {name=p140509 lab=_58634_/Y }
C {sky130_stdcells/nor2_4.sym} 141540 -26800 0 0 {name=X_58634_ }
C {devices/lab_pin.sym} 141500 -26670 0 0 {name=p140510 lab=_70908_/A }
C {devices/lab_pin.sym} 141580 -26670 0 1 {name=p140511 lab=_70913_/A }
C {sky130_stdcells/inv_2.sym} 141540 -26670 0 0 {name=X_70912_ }
C {devices/lab_pin.sym} 141500 -26550 0 0 {name=p140512 lab=_43859_/Y }
C {devices/lab_pin.sym} 141580 -26550 0 1 {name=p140513 lab=_87230_/D }
C {sky130_stdcells/inv_2.sym} 141540 -26550 0 0 {name=X_43860_ }
C {devices/lab_pin.sym} 141480 -26440 0 0 {name=p140514 lab=_44079_/X }
C {devices/lab_pin.sym} 141480 -26400 0 0 {name=p140515 lab=_55846_/B }
C {devices/lab_pin.sym} 141600 -26420 0 1 {name=p140516 lab=_55846_/X }
C {sky130_stdcells/and2_4.sym} 141540 -26420 0 0 {name=X_55846_ }
C {devices/lab_pin.sym} 141460 -26310 0 0 {name=p140517 lab=_74675_/X }
C {devices/lab_pin.sym} 141460 -26270 0 0 {name=p140518 lab=_56814_/A }
C {devices/lab_pin.sym} 141460 -26230 0 0 {name=p140519 lab=_74679_/Y }
C {devices/lab_pin.sym} 141620 -26270 0 1 {name=p140520 lab=_74680_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -26270 0 0 {name=X_74680_ }
C {devices/lab_pin.sym} 141450 -26130 0 0 {name=p140521 lab=_86351_/CLK }
C {devices/lab_pin.sym} 141450 -26110 0 0 {name=p140522 lab=_86666_/D }
C {devices/lab_pin.sym} 141630 -26130 0 1 {name=p140523 lab=_86666_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -26120 0 0 {name=X_86666_ }
C {devices/lab_pin.sym} 141500 -25990 0 0 {name=p140524 lab=_71891_/Y }
C {devices/lab_pin.sym} 141580 -25990 0 1 {name=p140525 lab=_71892_/X }
C {sky130_stdcells/buf_2.sym} 141540 -25990 0 0 {name=X_71892_ }
C {devices/lab_pin.sym} 141450 -25870 0 0 {name=p140526 lab=_82558_/CLK }
C {devices/lab_pin.sym} 141450 -25850 0 0 {name=p140527 lab=_83878_/D }
C {devices/lab_pin.sym} 141630 -25870 0 1 {name=p140528 lab=_82558_/D }
C {sky130_stdcells/dfxtp_4.sym} 141540 -25860 0 0 {name=X_83878_ }
C {devices/lab_pin.sym} 141460 -25770 0 0 {name=p140529 lab=_42795_/X }
C {devices/lab_pin.sym} 141460 -25730 0 0 {name=p140530 lab=_42796_/X }
C {devices/lab_pin.sym} 141460 -25690 0 0 {name=p140531 lab=_41424_/X }
C {devices/lab_pin.sym} 141460 -25650 0 0 {name=p140532 lab=_87706_/Q }
C {devices/lab_pin.sym} 141460 -25610 0 0 {name=p140533 lab=_42805_/X }
C {devices/lab_pin.sym} 141620 -25690 0 1 {name=p140534 lab=_42812_/A }
C {sky130_stdcells/o32ai_4.sym} 141540 -25690 0 0 {name=X_42811_ }
C {devices/lab_pin.sym} 141460 -25550 0 0 {name=p140535 lab=_73626_/X }
C {devices/lab_pin.sym} 141460 -25510 0 0 {name=p140536 lab=_73630_/X }
C {devices/lab_pin.sym} 141460 -25470 0 0 {name=p140537 lab=_56549_/X }
C {devices/lab_pin.sym} 141620 -25510 0 1 {name=p140538 lab=_73646_/B }
C {sky130_stdcells/a21o_4.sym} 141540 -25510 0 0 {name=X_73631_ }
C {devices/lab_pin.sym} 141450 -25370 0 0 {name=p140539 lab=_85630_/CLK }
C {devices/lab_pin.sym} 141450 -25350 0 0 {name=p140540 lab=_85617_/D }
C {devices/lab_pin.sym} 141630 -25370 0 1 {name=p140541 lab=_85617_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -25360 0 0 {name=X_85617_ }
C {devices/lab_pin.sym} 141500 -25230 0 0 {name=p140542 lab=_70862_/A }
C {devices/lab_pin.sym} 141580 -25230 0 1 {name=p140543 lab=_70860_/D }
C {sky130_stdcells/buf_2.sym} 141540 -25230 0 0 {name=X_70843_ }
C {devices/lab_pin.sym} 141500 -25110 0 0 {name=p140544 lab=_58676_/A }
C {devices/lab_pin.sym} 141580 -25110 0 1 {name=p140545 lab=_58614_/B }
C {sky130_stdcells/buf_2.sym} 141540 -25110 0 0 {name=X_58565_ }
C {devices/lab_pin.sym} 141450 -24990 0 0 {name=p140546 lab=_82462_/CLK }
C {devices/lab_pin.sym} 141450 -24970 0 0 {name=p140547 lab=_82829_/D }
C {devices/lab_pin.sym} 141630 -24990 0 1 {name=p140548 lab=_82829_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -24980 0 0 {name=X_82829_ }
C {devices/lab_pin.sym} 141500 -24850 0 0 {name=p140549 lab=_43776_/A }
C {devices/lab_pin.sym} 141580 -24850 0 1 {name=p140550 lab=_43791_/X }
C {sky130_stdcells/buf_2.sym} 141540 -24850 0 0 {name=X_43791_ }
C {devices/lab_pin.sym} 141460 -24760 0 0 {name=p140551 lab=_85194_/Q }
C {devices/lab_pin.sym} 141460 -24720 0 0 {name=p140552 lab=_55272_/X }
C {devices/lab_pin.sym} 141460 -24680 0 0 {name=p140553 lab=_55300_/X }
C {devices/lab_pin.sym} 141460 -24640 0 0 {name=p140554 lab=_55776_/X }
C {devices/lab_pin.sym} 141620 -24700 0 1 {name=p140555 lab=_55777_/X }
C {sky130_stdcells/a211o_4.sym} 141540 -24700 0 0 {name=X_55777_ }
C {devices/lab_pin.sym} 141450 -24550 0 0 {name=p140556 lab=_85957_/CLK }
C {devices/lab_pin.sym} 141450 -24530 0 0 {name=p140557 lab=_47796_/Y }
C {devices/lab_pin.sym} 141630 -24550 0 1 {name=p140558 lab=_72447_/A }
C {sky130_stdcells/dfxtp_4.sym} 141540 -24540 0 0 {name=X_86597_ }
C {devices/lab_pin.sym} 141480 -24440 0 0 {name=p140559 lab=_52997_/A }
C {devices/lab_pin.sym} 141480 -24400 0 0 {name=p140560 lab=_52997_/B }
C {devices/lab_pin.sym} 141480 -24360 0 0 {name=p140561 lab=_52997_/C }
C {devices/lab_pin.sym} 141480 -24320 0 0 {name=p140562 lab=_52989_/D }
C {devices/lab_pin.sym} 141600 -24380 0 1 {name=p140563 lab=_52989_/X }
C {sky130_stdcells/and4_4.sym} 141540 -24380 0 0 {name=X_52989_ }
C {devices/lab_pin.sym} 141500 -24230 0 0 {name=p140564 lab=_45452_/A }
C {devices/lab_pin.sym} 141580 -24230 0 1 {name=p140565 lab=_45530_/X }
C {sky130_stdcells/buf_2.sym} 141540 -24230 0 0 {name=X_45530_ }
C {devices/lab_pin.sym} 141480 -24120 0 0 {name=p140566 lab=_57497_/A }
C {devices/lab_pin.sym} 141480 -24080 0 0 {name=p140567 lab=_48207_/X }
C {devices/lab_pin.sym} 141600 -24100 0 1 {name=p140568 lab=_57516_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -24100 0 0 {name=X_57516_ }
C {devices/lab_pin.sym} 141460 -23990 0 0 {name=p140569 lab=_76330_/Y }
C {devices/lab_pin.sym} 141460 -23950 0 0 {name=p140570 lab=_76331_/Y }
C {devices/lab_pin.sym} 141460 -23910 0 0 {name=p140571 lab=_76332_/Y }
C {devices/lab_pin.sym} 141620 -23950 0 1 {name=p140572 lab=_76350_/X }
C {sky130_stdcells/o21a_4.sym} 141540 -23950 0 0 {name=X_76350_ }
C {devices/lab_pin.sym} 141450 -23810 0 0 {name=p140573 lab=_88337_/CLK }
C {devices/lab_pin.sym} 141450 -23790 0 0 {name=p140574 lab=_88336_/D }
C {devices/lab_pin.sym} 141630 -23810 0 1 {name=p140575 lab=_69612_/B }
C {sky130_stdcells/dfxtp_4.sym} 141540 -23800 0 0 {name=X_88336_ }
C {devices/lab_pin.sym} 141500 -23670 0 0 {name=p140576 lab=_42741_/Y }
C {devices/lab_pin.sym} 141580 -23670 0 1 {name=p140577 lab=_87742_/D }
C {sky130_stdcells/inv_2.sym} 141540 -23670 0 0 {name=X_42742_ }
C {devices/lab_pin.sym} 141460 -23570 0 0 {name=p140578 lab=_54724_/Y }
C {devices/lab_pin.sym} 141460 -23530 0 0 {name=p140579 lab=_54720_/X }
C {devices/lab_pin.sym} 141460 -23490 0 0 {name=p140580 lab=_54727_/X }
C {devices/lab_pin.sym} 141620 -23530 0 1 {name=p140581 lab=_54728_/Y }
C {sky130_stdcells/a21oi_4.sym} 141540 -23530 0 0 {name=X_54728_ }
C {devices/lab_pin.sym} 141460 -23420 0 0 {name=p140582 lab=_73378_/X }
C {devices/lab_pin.sym} 141460 -23380 0 0 {name=p140583 lab=_86241_/Q }
C {devices/lab_pin.sym} 141460 -23340 0 0 {name=p140584 lab=_73446_/X }
C {devices/lab_pin.sym} 141460 -23300 0 0 {name=p140585 lab=_73561_/X }
C {devices/lab_pin.sym} 141620 -23360 0 1 {name=p140586 lab=_73562_/X }
C {sky130_stdcells/a211o_4.sym} 141540 -23360 0 0 {name=X_73562_ }
C {devices/lab_pin.sym} 141450 -23210 0 0 {name=p140587 lab=_85837_/CLK }
C {devices/lab_pin.sym} 141450 -23190 0 0 {name=p140588 lab=_85548_/D }
C {devices/lab_pin.sym} 141630 -23210 0 1 {name=p140589 lab=_85548_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -23200 0 0 {name=X_85548_ }
C {devices/lab_pin.sym} 141500 -23070 0 0 {name=p140590 lab=_70862_/A }
C {devices/lab_pin.sym} 141580 -23070 0 1 {name=p140591 lab=_70791_/D }
C {sky130_stdcells/buf_2.sym} 141540 -23070 0 0 {name=X_70774_ }
C {devices/lab_pin.sym} 141460 -22970 0 0 {name=p140592 lab=_58492_/X }
C {devices/lab_pin.sym} 141460 -22930 0 0 {name=p140593 lab=_58493_/Y }
C {devices/lab_pin.sym} 141460 -22890 0 0 {name=p140594 lab=_58495_/Y }
C {devices/lab_pin.sym} 141620 -22930 0 1 {name=p140595 lab=_84835_/D }
C {sky130_stdcells/a21oi_4.sym} 141540 -22930 0 0 {name=X_58496_ }
C {devices/lab_pin.sym} 141480 -22800 0 0 {name=p140596 lab=_75299_/Y }
C {devices/lab_pin.sym} 141480 -22760 0 0 {name=p140597 lab=_75301_/B }
C {devices/lab_pin.sym} 141600 -22780 0 1 {name=p140598 lab=_75301_/X }
C {sky130_stdcells/xor2_4.sym} 141540 -22780 0 0 {name=X_75301_ }
C {devices/lab_pin.sym} 141500 -22650 0 0 {name=p140599 lab=_72512_/X }
C {devices/lab_pin.sym} 141580 -22650 0 1 {name=p140600 lab=_72513_/Y }
C {sky130_stdcells/inv_2.sym} 141540 -22650 0 0 {name=X_72513_ }
C {devices/lab_pin.sym} 141460 -22560 0 0 {name=p140601 lab=_55585_/B }
C {devices/lab_pin.sym} 141460 -22520 0 0 {name=p140602 lab=_45412_/X }
C {devices/lab_pin.sym} 141460 -22480 0 0 {name=p140603 lab=_45443_/X }
C {devices/lab_pin.sym} 141460 -22440 0 0 {name=p140604 lab=_45460_/Y }
C {devices/lab_pin.sym} 141620 -22500 0 1 {name=p140605 lab=_45461_/X }
C {sky130_stdcells/a211o_4.sym} 141540 -22500 0 0 {name=X_45461_ }
C {devices/lab_pin.sym} 141500 -22350 0 0 {name=p140606 lab=_57447_/A }
C {devices/lab_pin.sym} 141580 -22350 0 1 {name=p140607 lab=_57447_/Y }
C {sky130_stdcells/inv_2.sym} 141540 -22350 0 0 {name=X_57447_ }
C {devices/lab_pin.sym} 141500 -22230 0 0 {name=p140608 lab=_76281_/A }
C {devices/lab_pin.sym} 141580 -22230 0 1 {name=p140609 lab=_76282_/A }
C {sky130_stdcells/inv_2.sym} 141540 -22230 0 0 {name=X_76281_ }
C {devices/lab_pin.sym} 141450 -22110 0 0 {name=p140610 lab=_88267_/CLK }
C {devices/lab_pin.sym} 141450 -22090 0 0 {name=p140611 lab=_88267_/D }
C {devices/lab_pin.sym} 141630 -22110 0 1 {name=p140612 lab=_88267_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -22100 0 0 {name=X_88267_ }
C {devices/lab_pin.sym} 141460 -21990 0 0 {name=p140613 lab=_54655_/Y }
C {devices/lab_pin.sym} 141460 -21950 0 0 {name=p140614 lab=_54638_/X }
C {devices/lab_pin.sym} 141460 -21910 0 0 {name=p140615 lab=_54658_/X }
C {devices/lab_pin.sym} 141620 -21950 0 1 {name=p140616 lab=_85402_/D }
C {sky130_stdcells/a21oi_4.sym} 141540 -21950 0 0 {name=X_54659_ }
C {devices/lab_pin.sym} 141500 -21810 0 0 {name=p140617 lab=_42580_/A }
C {devices/lab_pin.sym} 141580 -21810 0 1 {name=p140618 lab=_42673_/X }
C {sky130_stdcells/buf_2.sym} 141540 -21810 0 0 {name=X_42673_ }
C {devices/lab_pin.sym} 141460 -21710 0 0 {name=p140619 lab=_44595_/Y }
C {devices/lab_pin.sym} 141460 -21670 0 0 {name=p140620 lab=_73491_/X }
C {devices/lab_pin.sym} 141460 -21630 0 0 {name=p140621 lab=_73492_/Y }
C {devices/lab_pin.sym} 141620 -21670 0 1 {name=p140622 lab=_73493_/X }
C {sky130_stdcells/a21o_4.sym} 141540 -21670 0 0 {name=X_73493_ }
C {devices/lab_pin.sym} 141450 -21530 0 0 {name=p140623 lab=_84926_/CLK }
C {devices/lab_pin.sym} 141450 -21510 0 0 {name=p140624 lab=_54238_/Y }
C {devices/lab_pin.sym} 141630 -21530 0 1 {name=p140625 lab=_85479_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -21520 0 0 {name=X_85479_ }
C {devices/lab_pin.sym} 141500 -21390 0 0 {name=p140626 lab=_82372_/Q }
C {devices/lab_pin.sym} 141580 -21390 0 1 {name=p140627 lab=_47201_/A }
C {sky130_stdcells/inv_2.sym} 141540 -21390 0 0 {name=X_47200_ }
C {devices/lab_pin.sym} 141460 -21290 0 0 {name=p140628 lab=_78021_/A }
C {devices/lab_pin.sym} 141460 -21250 0 0 {name=p140629 lab=_78021_/C }
C {devices/lab_pin.sym} 141460 -21210 0 0 {name=p140630 lab=_82176_/Q }
C {devices/lab_pin.sym} 141620 -21250 0 1 {name=p140631 lab=_78020_/Y }
C {sky130_stdcells/a21oi_4.sym} 141540 -21250 0 0 {name=X_78020_ }
C {devices/lab_pin.sym} 141500 -21110 0 0 {name=p140632 lab=_44363_/X }
C {devices/lab_pin.sym} 141580 -21110 0 1 {name=p140633 lab=_44412_/X }
C {sky130_stdcells/buf_2.sym} 141540 -21110 0 0 {name=X_44412_ }
C {devices/lab_pin.sym} 141480 -21000 0 0 {name=p140634 lab=_75223_/Y }
C {devices/lab_pin.sym} 141480 -20960 0 0 {name=p140635 lab=_75245_/A }
C {devices/lab_pin.sym} 141600 -20980 0 1 {name=p140636 lab=_75242_/A }
C {sky130_stdcells/xor2_4.sym} 141540 -20980 0 0 {name=X_75232_ }
C {devices/lab_pin.sym} 141450 -20850 0 0 {name=p140637 lab=_82906_/CLK }
C {devices/lab_pin.sym} 141450 -20830 0 0 {name=p140638 lab=_87218_/D }
C {devices/lab_pin.sym} 141630 -20850 0 1 {name=p140639 lab=_87218_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -20840 0 0 {name=X_87218_ }
C {devices/lab_pin.sym} 141480 -20720 0 0 {name=p140640 lab=_41624_/A }
C {devices/lab_pin.sym} 141480 -20680 0 0 {name=p140641 lab=_41624_/B }
C {devices/lab_pin.sym} 141600 -20700 0 1 {name=p140642 lab=_41624_/X }
