C {devices/lab_pin.sym} 22780 -23050 0 0 {name=p22357 lab=_68893_/X }
C {devices/lab_pin.sym} 22780 -23010 0 0 {name=p22358 lab=_70044_/X }
C {devices/lab_pin.sym} 22940 -23050 0 1 {name=p22359 lab=_70060_/Y }
C {sky130_stdcells/a21oi_4.sym} 22860 -23050 0 0 {name=X_70060_ }
C {devices/lab_pin.sym} 22770 -22910 0 0 {name=p22360 lab=_87144_/CLK }
C {devices/lab_pin.sym} 22770 -22890 0 0 {name=p22361 lab=_86923_/D }
C {devices/lab_pin.sym} 22950 -22910 0 1 {name=p22362 lab=_86923_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -22900 0 0 {name=X_86923_ }
C {devices/lab_pin.sym} 22770 -22770 0 0 {name=p22363 lab=_82047_/CLK }
C {devices/lab_pin.sym} 22770 -22750 0 0 {name=p22364 lab=_77994_/B }
C {devices/lab_pin.sym} 22950 -22770 0 1 {name=p22365 lab=_82046_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -22760 0 0 {name=X_82046_ }
C {devices/lab_pin.sym} 22780 -22670 0 0 {name=p22366 lab=_59651_/A }
C {devices/lab_pin.sym} 22780 -22630 0 0 {name=p22367 lab=_59797_/Y }
C {devices/lab_pin.sym} 22780 -22590 0 0 {name=p22368 lab=_59825_/X }
C {devices/lab_pin.sym} 22780 -22550 0 0 {name=p22369 lab=_59847_/Y }
C {devices/lab_pin.sym} 22780 -22520 0 0 {name=p22370 lab=_59870_/Y }
C {devices/lab_pin.sym} 22940 -22590 0 1 {name=p22371 lab=_59871_/Y }
C {sky130_stdcells/a41oi_4.sym} 22860 -22590 0 0 {name=X_59871_ }
C {devices/lab_pin.sym} 22780 -22450 0 0 {name=p22372 lab=_58703_/X }
C {devices/lab_pin.sym} 22780 -22410 0 0 {name=p22373 lab=_85453_/Q }
C {devices/lab_pin.sym} 22780 -22370 0 0 {name=p22374 lab=_58821_/X }
C {devices/lab_pin.sym} 22940 -22410 0 1 {name=p22375 lab=_58822_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -22410 0 0 {name=X_58822_ }
C {devices/lab_pin.sym} 22820 -22270 0 0 {name=p22376 lab=_51129_/A }
C {devices/lab_pin.sym} 22900 -22270 0 1 {name=p22377 lab=_51167_/A }
C {sky130_stdcells/buf_2.sym} 22860 -22270 0 0 {name=X_51157_ }
C {devices/lab_pin.sym} 22770 -22150 0 0 {name=p22378 lab=_84408_/CLK }
C {devices/lab_pin.sym} 22770 -22130 0 0 {name=p22379 lab=_86854_/D }
C {devices/lab_pin.sym} 22950 -22150 0 1 {name=p22380 lab=_63292_/B }
C {sky130_stdcells/dfxtp_4.sym} 22860 -22140 0 0 {name=X_86854_ }
C {devices/lab_pin.sym} 22800 -22020 0 0 {name=p22381 lab=_50103_/A }
C {devices/lab_pin.sym} 22800 -21980 0 0 {name=p22382 lab=_48992_/X }
C {devices/lab_pin.sym} 22920 -22000 0 1 {name=p22383 lab=_50108_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -22000 0 0 {name=X_50108_ }
C {devices/lab_pin.sym} 22770 -21870 0 0 {name=p22384 lab=_86040_/CLK }
C {devices/lab_pin.sym} 22770 -21850 0 0 {name=p22385 lab=_52525_/Y }
C {devices/lab_pin.sym} 22950 -21870 0 1 {name=p22386 lab=_65115_/B }
C {sky130_stdcells/dfxtp_4.sym} 22860 -21860 0 0 {name=X_85805_ }
C {devices/lab_pin.sym} 22780 -21770 0 0 {name=p22387 lab=_58748_/X }
C {devices/lab_pin.sym} 22780 -21730 0 0 {name=p22388 lab=_58750_/Y }
C {devices/lab_pin.sym} 22780 -21690 0 0 {name=p22389 lab=_58751_/Y }
C {devices/lab_pin.sym} 22780 -21650 0 0 {name=p22390 lab=_58650_/X }
C {devices/lab_pin.sym} 22780 -21610 0 0 {name=p22391 lab=_58752_/X }
C {devices/lab_pin.sym} 22940 -21690 0 1 {name=p22392 lab=_58753_/X }
C {sky130_stdcells/o32a_4.sym} 22860 -21690 0 0 {name=X_58753_ }
C {devices/lab_pin.sym} 22820 -21530 0 0 {name=p22393 lab=_51141_/A }
C {devices/lab_pin.sym} 22900 -21530 0 1 {name=p22394 lab=_51110_/C }
C {sky130_stdcells/buf_2.sym} 22860 -21530 0 0 {name=X_51088_ }
C {devices/lab_pin.sym} 22800 -21420 0 0 {name=p22395 lab=_55965_/A }
C {devices/lab_pin.sym} 22800 -21380 0 0 {name=p22396 lab=_55965_/B }
C {devices/lab_pin.sym} 22920 -21400 0 1 {name=p22397 lab=_55966_/A }
C {sky130_stdcells/and2_4.sym} 22860 -21400 0 0 {name=X_55965_ }
C {devices/lab_pin.sym} 22770 -21270 0 0 {name=p22398 lab=_82317_/CLK }
C {devices/lab_pin.sym} 22770 -21250 0 0 {name=p22399 lab=_86785_/D }
C {devices/lab_pin.sym} 22950 -21270 0 1 {name=p22400 lab=_86785_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -21260 0 0 {name=X_86785_ }
C {devices/lab_pin.sym} 22770 -21130 0 0 {name=p22401 lab=_82642_/CLK }
C {devices/lab_pin.sym} 22770 -21110 0 0 {name=p22402 lab=_68266_/X }
C {devices/lab_pin.sym} 22950 -21130 0 1 {name=p22403 lab=_83997_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -21120 0 0 {name=X_83997_ }
C {devices/lab_pin.sym} 22780 -21030 0 0 {name=p22404 lab=_46213_/X }
C {devices/lab_pin.sym} 22780 -20990 0 0 {name=p22405 lab=_57692_/Y }
C {devices/lab_pin.sym} 22780 -20950 0 0 {name=p22406 lab=_57698_/Y }
C {devices/lab_pin.sym} 22780 -20910 0 0 {name=p22407 lab=_57700_/X }
C {devices/lab_pin.sym} 22780 -20870 0 0 {name=p22408 lab=_57703_/X }
C {devices/lab_pin.sym} 22940 -20950 0 1 {name=p22409 lab=_57704_/X }
C {sky130_stdcells/o32a_4.sym} 22860 -20950 0 0 {name=X_57704_ }
C {devices/lab_pin.sym} 22820 -20790 0 0 {name=p22410 lab=_42962_/A }
C {devices/lab_pin.sym} 22900 -20790 0 1 {name=p22411 lab=_42930_/X }
C {sky130_stdcells/buf_2.sym} 22860 -20790 0 0 {name=X_42930_ }
C {devices/lab_pin.sym} 22780 -20690 0 0 {name=p22412 lab=_72461_/B }
C {devices/lab_pin.sym} 22780 -20650 0 0 {name=p22413 lab=_48170_/X }
C {devices/lab_pin.sym} 22780 -20610 0 0 {name=p22414 lab=_50038_/Y }
C {devices/lab_pin.sym} 22940 -20650 0 1 {name=p22415 lab=_50039_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -20650 0 0 {name=X_50039_ }
C {devices/lab_pin.sym} 22800 -20540 0 0 {name=p22416 lab=_54932_/A }
C {devices/lab_pin.sym} 22800 -20500 0 0 {name=p22417 lab=_54910_/B }
C {devices/lab_pin.sym} 22800 -20460 0 0 {name=p22418 lab=_54932_/C }
C {devices/lab_pin.sym} 22800 -20420 0 0 {name=p22419 lab=_53223_/D }
C {devices/lab_pin.sym} 22920 -20480 0 1 {name=p22420 lab=_54916_/X }
C {sky130_stdcells/and4_4.sym} 22860 -20480 0 0 {name=X_54916_ }
C {devices/lab_pin.sym} 22800 -20340 0 0 {name=p22421 lab=_73750_/A }
C {devices/lab_pin.sym} 22800 -20300 0 0 {name=p22422 lab=_73624_/X }
C {devices/lab_pin.sym} 22920 -20320 0 1 {name=p22423 lab=_73750_/Y }
C {sky130_stdcells/nor2_4.sym} 22860 -20320 0 0 {name=X_73750_ }
C {devices/lab_pin.sym} 22770 -20190 0 0 {name=p22424 lab=_85738_/CLK }
C {devices/lab_pin.sym} 22770 -20170 0 0 {name=p22425 lab=_52888_/Y }
C {devices/lab_pin.sym} 22950 -20190 0 1 {name=p22426 lab=_85736_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -20180 0 0 {name=X_85736_ }
C {devices/lab_pin.sym} 22780 -20070 0 0 {name=p22427 lab=_58618_/X }
C {devices/lab_pin.sym} 22780 -20030 0 0 {name=p22428 lab=_86104_/Q }
C {devices/lab_pin.sym} 22780 -19990 0 0 {name=p22429 lab=_58683_/X }
C {devices/lab_pin.sym} 22940 -20030 0 1 {name=p22430 lab=_58684_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -20030 0 0 {name=X_58684_ }
C {devices/lab_pin.sym} 22800 -19910 0 0 {name=p22431 lab=_70969_/A }
C {devices/lab_pin.sym} 22800 -19870 0 0 {name=p22432 lab=_70940_/B }
C {devices/lab_pin.sym} 22800 -19830 0 0 {name=p22433 lab=_70962_/C }
C {devices/lab_pin.sym} 22920 -19870 0 1 {name=p22434 lab=_70962_/Y }
C {sky130_stdcells/nand3_4.sym} 22860 -19870 0 0 {name=X_70962_ }
C {devices/lab_pin.sym} 22770 -19730 0 0 {name=p22435 lab=_82768_/CLK }
C {devices/lab_pin.sym} 22770 -19710 0 0 {name=p22436 lab=_82948_/D }
C {devices/lab_pin.sym} 22950 -19730 0 1 {name=p22437 lab=_82948_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -19720 0 0 {name=X_82948_ }
C {devices/lab_pin.sym} 22800 -19600 0 0 {name=p22438 lab=_55903_/A }
C {devices/lab_pin.sym} 22800 -19560 0 0 {name=p22439 lab=_55896_/B }
C {devices/lab_pin.sym} 22920 -19580 0 1 {name=p22440 lab=_55896_/X }
C {sky130_stdcells/and2_4.sym} 22860 -19580 0 0 {name=X_55896_ }
C {devices/lab_pin.sym} 22780 -19470 0 0 {name=p22441 lab=_83184_/Q }
C {devices/lab_pin.sym} 22780 -19430 0 0 {name=p22442 lab=_72699_/X }
C {devices/lab_pin.sym} 22780 -19390 0 0 {name=p22443 lab=_72700_/X }
C {devices/lab_pin.sym} 22940 -19430 0 1 {name=p22444 lab=_72701_/X }
C {sky130_stdcells/a21o_4.sym} 22860 -19430 0 0 {name=X_72701_ }
C {devices/lab_pin.sym} 22820 -19290 0 0 {name=p22445 lab=_71985_/A }
C {devices/lab_pin.sym} 22900 -19290 0 1 {name=p22446 lab=_57635_/X }
C {sky130_stdcells/buf_2.sym} 22860 -19290 0 0 {name=X_57635_ }
C {devices/lab_pin.sym} 22780 -19200 0 0 {name=p22447 lab=_41552_/X }
C {devices/lab_pin.sym} 22780 -19160 0 0 {name=p22448 lab=_42852_/X }
C {devices/lab_pin.sym} 22780 -19120 0 0 {name=p22449 lab=_66982_/B }
C {devices/lab_pin.sym} 22780 -19080 0 0 {name=p22450 lab=_42853_/X }
C {devices/lab_pin.sym} 22940 -19140 0 1 {name=p22451 lab=_42861_/X }
C {sky130_stdcells/a2bb2o_4.sym} 22860 -19140 0 0 {name=X_42861_ }
C {devices/lab_pin.sym} 22820 -18990 0 0 {name=p22452 lab=_54900_/A }
C {devices/lab_pin.sym} 22900 -18990 0 1 {name=p22453 lab=_54857_/B }
C {sky130_stdcells/buf_2.sym} 22860 -18990 0 0 {name=X_54847_ }
C {devices/lab_pin.sym} 22770 -18870 0 0 {name=p22454 lab=_85471_/CLK }
C {devices/lab_pin.sym} 22770 -18850 0 0 {name=p22455 lab=_85667_/D }
C {devices/lab_pin.sym} 22950 -18870 0 1 {name=p22456 lab=_85667_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -18860 0 0 {name=X_85667_ }
C {devices/lab_pin.sym} 22780 -18750 0 0 {name=p22457 lab=_68498_/B }
C {devices/lab_pin.sym} 22780 -18710 0 0 {name=p22458 lab=_73279_/X }
C {devices/lab_pin.sym} 22780 -18670 0 0 {name=p22459 lab=_73656_/X }
C {devices/lab_pin.sym} 22940 -18710 0 1 {name=p22460 lab=_73681_/X }
C {sky130_stdcells/o21a_4.sym} 22860 -18710 0 0 {name=X_73681_ }
C {devices/lab_pin.sym} 22800 -18600 0 0 {name=p22461 lab=_70867_/A }
C {devices/lab_pin.sym} 22800 -18560 0 0 {name=p22462 lab=_70890_/B }
C {devices/lab_pin.sym} 22800 -18520 0 0 {name=p22463 lab=_70890_/C }
C {devices/lab_pin.sym} 22800 -18480 0 0 {name=p22464 lab=_70899_/D }
C {devices/lab_pin.sym} 22920 -18540 0 1 {name=p22465 lab=_70893_/Y }
C {sky130_stdcells/nand4_4.sym} 22860 -18540 0 0 {name=X_70893_ }
C {devices/lab_pin.sym} 22770 -18390 0 0 {name=p22466 lab=_82879_/CLK }
C {devices/lab_pin.sym} 22770 -18370 0 0 {name=p22467 lab=_78296_/B }
C {devices/lab_pin.sym} 22950 -18390 0 1 {name=p22468 lab=_82879_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -18380 0 0 {name=X_82879_ }
C {devices/lab_pin.sym} 22820 -18250 0 0 {name=p22469 lab=_87040_/Q }
C {devices/lab_pin.sym} 22900 -18250 0 1 {name=p22470 lab=_44600_/Y }
C {sky130_stdcells/inv_2.sym} 22860 -18250 0 0 {name=X_44600_ }
C {devices/lab_pin.sym} 22770 -18130 0 0 {name=p22471 lab=_88171_/CLK }
C {devices/lab_pin.sym} 22770 -18110 0 0 {name=p22472 lab=_43470_/Y }
C {devices/lab_pin.sym} 22950 -18130 0 1 {name=p22473 lab=_87406_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -18120 0 0 {name=X_87406_ }
C {devices/lab_pin.sym} 22780 -18010 0 0 {name=p22474 lab=_75403_/Y }
C {devices/lab_pin.sym} 22780 -17970 0 0 {name=p22475 lab=_75406_/Y }
C {devices/lab_pin.sym} 22780 -17930 0 0 {name=p22476 lab=_75401_/Y }
C {devices/lab_pin.sym} 22940 -17970 0 1 {name=p22477 lab=_75420_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -17970 0 0 {name=X_75420_ }
C {devices/lab_pin.sym} 22820 -17830 0 0 {name=p22478 lab=_48192_/A }
C {devices/lab_pin.sym} 22900 -17830 0 1 {name=p22479 lab=_48164_/A }
C {sky130_stdcells/buf_2.sym} 22860 -17830 0 0 {name=X_41812_ }
C {devices/lab_pin.sym} 22820 -17710 0 0 {name=p22480 lab=_45891_/X }
C {devices/lab_pin.sym} 22900 -17710 0 1 {name=p22481 lab=_72687_/A }
C {sky130_stdcells/buf_2.sym} 22860 -17710 0 0 {name=X_72632_ }
C {devices/lab_pin.sym} 22770 -17590 0 0 {name=p22482 lab=_84620_/CLK }
C {devices/lab_pin.sym} 22770 -17570 0 0 {name=p22483 lab=_84618_/D }
C {devices/lab_pin.sym} 22950 -17590 0 1 {name=p22484 lab=_60374_/C }
C {sky130_stdcells/dfxtp_4.sym} 22860 -17580 0 0 {name=X_84618_ }
C {devices/lab_pin.sym} 22780 -17470 0 0 {name=p22485 lab=_45574_/X }
C {devices/lab_pin.sym} 22780 -17430 0 0 {name=p22486 lab=_45577_/X }
C {devices/lab_pin.sym} 22780 -17390 0 0 {name=p22487 lab=_45579_/Y }
C {devices/lab_pin.sym} 22940 -17430 0 1 {name=p22488 lab=_86868_/D }
C {sky130_stdcells/a21oi_4.sym} 22860 -17430 0 0 {name=X_45580_ }
C {devices/lab_pin.sym} 22780 -17310 0 0 {name=p22489 lab=_84978_/Q }
C {devices/lab_pin.sym} 22780 -17270 0 0 {name=p22490 lab=_57562_/X }
C {devices/lab_pin.sym} 22780 -17230 0 0 {name=p22491 lab=_57565_/Y }
C {devices/lab_pin.sym} 22940 -17270 0 1 {name=p22492 lab=_57566_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -17270 0 0 {name=X_57566_ }
C {devices/lab_pin.sym} 22780 -17160 0 0 {name=p22493 lab=_41371_/X }
C {devices/lab_pin.sym} 22780 -17120 0 0 {name=p22494 lab=_42787_/X }
C {devices/lab_pin.sym} 22780 -17080 0 0 {name=p22495 lab=_67727_/B }
C {devices/lab_pin.sym} 22780 -17040 0 0 {name=p22496 lab=_42788_/X }
C {devices/lab_pin.sym} 22940 -17100 0 1 {name=p22497 lab=_87715_/D }
C {sky130_stdcells/a2bb2o_4.sym} 22860 -17100 0 0 {name=X_42792_ }
C {devices/lab_pin.sym} 22770 -16950 0 0 {name=p22498 lab=_88386_/CLK }
C {devices/lab_pin.sym} 22770 -16930 0 0 {name=p22499 lab=_88386_/D }
C {devices/lab_pin.sym} 22950 -16950 0 1 {name=p22500 lab=_88386_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -16940 0 0 {name=X_88386_ }
C {devices/lab_pin.sym} 22780 -16830 0 0 {name=p22501 lab=_85379_/Q }
C {devices/lab_pin.sym} 22780 -16790 0 0 {name=p22502 lab=_54757_/X }
C {devices/lab_pin.sym} 22780 -16750 0 0 {name=p22503 lab=_54777_/Y }
C {devices/lab_pin.sym} 22940 -16790 0 1 {name=p22504 lab=_54778_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -16790 0 0 {name=X_54778_ }
C {devices/lab_pin.sym} 22770 -16650 0 0 {name=p22505 lab=_85590_/CLK }
C {devices/lab_pin.sym} 22770 -16630 0 0 {name=p22506 lab=_53637_/Y }
C {devices/lab_pin.sym} 22950 -16650 0 1 {name=p22507 lab=_85598_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -16640 0 0 {name=X_85598_ }
C {devices/lab_pin.sym} 22820 -16510 0 0 {name=p22508 lab=_57696_/X }
C {devices/lab_pin.sym} 22900 -16510 0 1 {name=p22509 lab=_59306_/B }
C {sky130_stdcells/buf_2.sym} 22860 -16510 0 0 {name=X_59305_ }
C {devices/lab_pin.sym} 22820 -16390 0 0 {name=p22510 lab=_44531_/A }
C {devices/lab_pin.sym} 22900 -16390 0 1 {name=p22511 lab=_44531_/Y }
C {sky130_stdcells/inv_2.sym} 22860 -16390 0 0 {name=X_44531_ }
C {devices/lab_pin.sym} 22780 -16290 0 0 {name=p22512 lab=_56109_/X }
C {devices/lab_pin.sym} 22780 -16250 0 0 {name=p22513 lab=_56515_/X }
C {devices/lab_pin.sym} 22780 -16210 0 0 {name=p22514 lab=_56516_/Y }
C {devices/lab_pin.sym} 22940 -16250 0 1 {name=p22515 lab=_85166_/D }
C {sky130_stdcells/o21ai_4.sym} 22860 -16250 0 0 {name=X_56517_ }
C {devices/lab_pin.sym} 22820 -16110 0 0 {name=p22516 lab=_75351_/A }
C {devices/lab_pin.sym} 22900 -16110 0 1 {name=p22517 lab=_75351_/Y }
C {sky130_stdcells/inv_2.sym} 22860 -16110 0 0 {name=X_75351_ }
C {devices/lab_pin.sym} 22800 -16000 0 0 {name=p22518 lab=_40620_/X }
C {devices/lab_pin.sym} 22800 -15960 0 0 {name=p22519 lab=_41743_/B }
C {devices/lab_pin.sym} 22920 -15980 0 1 {name=p22520 lab=_41743_/X }
C {sky130_stdcells/or2_4.sym} 22860 -15980 0 0 {name=X_41743_ }
C {devices/lab_pin.sym} 22770 -15850 0 0 {name=p22521 lab=_87595_/CLK }
C {devices/lab_pin.sym} 22770 -15830 0 0 {name=p22522 lab=_87337_/D }
C {devices/lab_pin.sym} 22950 -15850 0 1 {name=p22523 lab=_73797_/A }
C {sky130_stdcells/dfxtp_4.sym} 22860 -15840 0 0 {name=X_87337_ }
C {devices/lab_pin.sym} 22820 -15710 0 0 {name=p22524 lab=_53729_/A }
C {devices/lab_pin.sym} 22900 -15710 0 1 {name=p22525 lab=_53729_/X }
C {sky130_stdcells/buf_2.sym} 22860 -15710 0 0 {name=X_53729_ }
C {devices/lab_pin.sym} 22800 -15610 0 0 {name=p22526 lab=_72525_/A }
C {devices/lab_pin.sym} 22800 -15570 0 0 {name=p22527 lab=_72563_/B }
C {devices/lab_pin.sym} 22800 -15530 0 0 {name=p22528 lab=_72563_/C }
C {devices/lab_pin.sym} 22920 -15570 0 1 {name=p22529 lab=_72570_/C }
C {sky130_stdcells/nand3_4.sym} 22860 -15570 0 0 {name=X_72563_ }
C {devices/lab_pin.sym} 22770 -15430 0 0 {name=p22530 lab=_84549_/CLK }
C {devices/lab_pin.sym} 22770 -15410 0 0 {name=p22531 lab=_84549_/D }
C {devices/lab_pin.sym} 22950 -15430 0 1 {name=p22532 lab=_60947_/C }
C {sky130_stdcells/dfxtp_4.sym} 22860 -15420 0 0 {name=X_84549_ }
C {devices/lab_pin.sym} 22800 -15300 0 0 {name=p22533 lab=_57497_/A }
C {devices/lab_pin.sym} 22800 -15260 0 0 {name=p22534 lab=_48178_/X }
C {devices/lab_pin.sym} 22920 -15280 0 1 {name=p22535 lab=_57497_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -15280 0 0 {name=X_57497_ }
C {devices/lab_pin.sym} 22820 -15150 0 0 {name=p22536 lab=_72704_/A }
C {devices/lab_pin.sym} 22900 -15150 0 1 {name=p22537 lab=_74302_/X }
C {sky130_stdcells/buf_2.sym} 22860 -15150 0 0 {name=X_74302_ }
C {devices/lab_pin.sym} 22780 -15050 0 0 {name=p22538 lab=_47245_/Y }
C {devices/lab_pin.sym} 22780 -15010 0 0 {name=p22539 lab=_47224_/X }
C {devices/lab_pin.sym} 22780 -14970 0 0 {name=p22540 lab=_47249_/X }
C {devices/lab_pin.sym} 22940 -15010 0 1 {name=p22541 lab=_86655_/D }
C {sky130_stdcells/a21oi_4.sym} 22860 -15010 0 0 {name=X_47250_ }
C {devices/lab_pin.sym} 22820 -14870 0 0 {name=p22542 lab=_71525_/A }
C {devices/lab_pin.sym} 22900 -14870 0 1 {name=p22543 lab=_71521_/A }
C {sky130_stdcells/buf_2.sym} 22860 -14870 0 0 {name=X_71514_ }
C {devices/lab_pin.sym} 22780 -14770 0 0 {name=p22544 lab=_59233_/Y }
C {devices/lab_pin.sym} 22780 -14730 0 0 {name=p22545 lab=_59235_/Y }
C {devices/lab_pin.sym} 22780 -14690 0 0 {name=p22546 lab=_59165_/X }
C {devices/lab_pin.sym} 22940 -14730 0 1 {name=p22547 lab=_59236_/X }
C {sky130_stdcells/a21o_4.sym} 22860 -14730 0 0 {name=X_59236_ }
C {devices/lab_pin.sym} 22800 -14600 0 0 {name=p22548 lab=_84575_/Q }
C {devices/lab_pin.sym} 22800 -14560 0 0 {name=p22549 lab=_78070_/B }
C {devices/lab_pin.sym} 22920 -14580 0 1 {name=p22550 lab=_78070_/X }
C {sky130_stdcells/xor2_4.sym} 22860 -14580 0 0 {name=X_78070_ }
C {devices/lab_pin.sym} 22780 -14480 0 0 {name=p22551 lab=_41147_/A }
C {devices/lab_pin.sym} 22780 -14440 0 0 {name=p22552 lab=_44453_/X }
C {devices/lab_pin.sym} 22780 -14400 0 0 {name=p22553 lab=_87097_/Q }
C {devices/lab_pin.sym} 22780 -14360 0 0 {name=p22554 lab=_44454_/X }
C {devices/lab_pin.sym} 22940 -14420 0 1 {name=p22555 lab=_44462_/X }
C {sky130_stdcells/a2bb2o_4.sym} 22860 -14420 0 0 {name=X_44462_ }
C {devices/lab_pin.sym} 22820 -14270 0 0 {name=p22556 lab=_44207_/A }
C {devices/lab_pin.sym} 22900 -14270 0 1 {name=p22557 lab=_56448_/X }
C {sky130_stdcells/buf_2.sym} 22860 -14270 0 0 {name=X_56448_ }
C {devices/lab_pin.sym} 22780 -14170 0 0 {name=p22558 lab=_75280_/X }
C {devices/lab_pin.sym} 22780 -14130 0 0 {name=p22559 lab=_75263_/X }
C {devices/lab_pin.sym} 22780 -14090 0 0 {name=p22560 lab=_75281_/Y }
C {devices/lab_pin.sym} 22940 -14130 0 1 {name=p22561 lab=_75282_/Y }
C {sky130_stdcells/a21oi_4.sym} 22860 -14130 0 0 {name=X_75282_ }
C {devices/lab_pin.sym} 22770 -13990 0 0 {name=p22562 lab=_87525_/CLK }
C {devices/lab_pin.sym} 22770 -13970 0 0 {name=p22563 lab=_87268_/D }
C {devices/lab_pin.sym} 22950 -13990 0 1 {name=p22564 lab=_87268_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -13980 0 0 {name=X_87268_ }
C {devices/lab_pin.sym} 22800 -13860 0 0 {name=p22565 lab=_41674_/A }
C {devices/lab_pin.sym} 22800 -13820 0 0 {name=p22566 lab=_41653_/X }
C {devices/lab_pin.sym} 22920 -13840 0 1 {name=p22567 lab=_41674_/X }
C {sky130_stdcells/or2_4.sym} 22860 -13840 0 0 {name=X_41674_ }
C {devices/lab_pin.sym} 22800 -13720 0 0 {name=p22568 lab=_63611_/A }
C {devices/lab_pin.sym} 22800 -13680 0 0 {name=p22569 lab=_72488_/B }
C {devices/lab_pin.sym} 22920 -13700 0 1 {name=p22570 lab=_72494_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -13700 0 0 {name=X_72494_ }
C {devices/lab_pin.sym} 22820 -13570 0 0 {name=p22571 lab=_44228_/X }
C {devices/lab_pin.sym} 22900 -13570 0 1 {name=p22572 lab=_58425_/A }
C {sky130_stdcells/buf_2.sym} 22860 -13570 0 0 {name=X_46201_ }
C {sky130_stdcells/decap_3.sym} 22860 -13420 0 0 {name=XPHY_130 }
C {devices/lab_pin.sym} 22800 -13280 0 0 {name=p22573 lab=_77021_/A }
C {devices/lab_pin.sym} 22800 -13240 0 0 {name=p22574 lab=_77020_/Y }
C {devices/lab_pin.sym} 22920 -13260 0 1 {name=p22575 lab=_77022_/B }
C {sky130_stdcells/xor2_4.sym} 22860 -13260 0 0 {name=X_77021_ }
C {devices/lab_pin.sym} 22820 -13130 0 0 {name=p22576 lab=_43397_/A }
C {devices/lab_pin.sym} 22900 -13130 0 1 {name=p22577 lab=_43413_/X }
C {sky130_stdcells/buf_2.sym} 22860 -13130 0 0 {name=X_43413_ }
C {devices/lab_pin.sym} 22780 -13040 0 0 {name=p22578 lab=_45931_/X }
C {devices/lab_pin.sym} 22780 -13000 0 0 {name=p22579 lab=_86212_/Q }
C {devices/lab_pin.sym} 22780 -12960 0 0 {name=p22580 lab=_72985_/X }
C {devices/lab_pin.sym} 22780 -12920 0 0 {name=p22581 lab=_74232_/X }
C {devices/lab_pin.sym} 22940 -12980 0 1 {name=p22582 lab=_74233_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -12980 0 0 {name=X_74233_ }
C {devices/lab_pin.sym} 22770 -12830 0 0 {name=p22583 lab=_85599_/CLK }
C {devices/lab_pin.sym} 22770 -12810 0 0 {name=p22584 lab=_86219_/D }
C {devices/lab_pin.sym} 22950 -12830 0 1 {name=p22585 lab=_86219_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -12820 0 0 {name=X_86219_ }
C {sky130_stdcells/decap_3.sym} 22860 -12660 0 0 {name=XPHY_141 }
C {devices/lab_pin.sym} 22780 -12530 0 0 {name=p22586 lab=_40621_/X }
C {devices/lab_pin.sym} 22780 -12490 0 0 {name=p22587 lab=_82874_/Q }
C {devices/lab_pin.sym} 22780 -12450 0 0 {name=p22588 lab=_40624_/X }
C {devices/lab_pin.sym} 22940 -12490 0 1 {name=p22589 lab=_40625_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -12490 0 0 {name=X_40625_ }
C {devices/lab_pin.sym} 22800 -12380 0 0 {name=p22590 lab=_47152_/X }
C {devices/lab_pin.sym} 22800 -12340 0 0 {name=p22591 lab=_47181_/B }
C {devices/lab_pin.sym} 22800 -12300 0 0 {name=p22592 lab=_47143_/C }
C {devices/lab_pin.sym} 22800 -12260 0 0 {name=p22593 lab=_52900_/D }
C {devices/lab_pin.sym} 22920 -12320 0 1 {name=p22594 lab=_47181_/X }
C {sky130_stdcells/and4_4.sym} 22860 -12320 0 0 {name=X_47181_ }
C {devices/lab_pin.sym} 22800 -12180 0 0 {name=p22595 lab=_59154_/A }
C {devices/lab_pin.sym} 22800 -12140 0 0 {name=p22596 lab=_59167_/B }
C {devices/lab_pin.sym} 22920 -12160 0 1 {name=p22597 lab=_59167_/Y }
C {sky130_stdcells/nor2_4.sym} 22860 -12160 0 0 {name=X_59167_ }
C {devices/lab_pin.sym} 22820 -12030 0 0 {name=p22598 lab=_71444_/Y }
C {devices/lab_pin.sym} 22900 -12030 0 1 {name=p22599 lab=_71445_/X }
C {sky130_stdcells/buf_2.sym} 22860 -12030 0 0 {name=X_71445_ }
C {devices/lab_pin.sym} 22780 -11940 0 0 {name=p22600 lab=_41479_/X }
C {devices/lab_pin.sym} 22780 -11900 0 0 {name=p22601 lab=_44377_/X }
C {devices/lab_pin.sym} 22780 -11860 0 0 {name=p22602 lab=_87131_/Q }
C {devices/lab_pin.sym} 22780 -11820 0 0 {name=p22603 lab=_44379_/X }
C {devices/lab_pin.sym} 22940 -11880 0 1 {name=p22604 lab=_44393_/X }
C {sky130_stdcells/a2bb2o_4.sym} 22860 -11880 0 0 {name=X_44393_ }
C {devices/lab_pin.sym} 22800 -11750 0 0 {name=p22605 lab=_56458_/A }
C {devices/lab_pin.sym} 22800 -11710 0 0 {name=p22606 lab=_56363_/B }
C {devices/lab_pin.sym} 22800 -11670 0 0 {name=p22607 lab=_56379_/C }
C {devices/lab_pin.sym} 22920 -11710 0 1 {name=p22608 lab=_56379_/Y }
C {sky130_stdcells/nand3_4.sym} 22860 -11710 0 0 {name=X_56379_ }
C {sky130_stdcells/decap_3.sym} 22860 -11540 0 0 {name=XPHY_152 }
C {devices/lab_pin.sym} 22770 -11390 0 0 {name=p22609 lab=_87720_/CLK }
C {devices/lab_pin.sym} 22770 -11370 0 0 {name=p22610 lab=_43920_/X }
C {devices/lab_pin.sym} 22950 -11390 0 1 {name=p22611 lab=_67810_/B }
C {sky130_stdcells/dfxtp_4.sym} 22860 -11380 0 0 {name=X_87199_ }
C {sky130_stdcells/decap_3.sym} 22860 -11220 0 0 {name=XPHY_163 }
C {sky130_stdcells/decap_3.sym} 22860 -11040 0 0 {name=XPHY_174 }
C {devices/lab_pin.sym} 22800 -10900 0 0 {name=p22612 lab=_46111_/B }
C {devices/lab_pin.sym} 22800 -10860 0 0 {name=p22613 lab=_74846_/B }
C {devices/lab_pin.sym} 22920 -10880 0 1 {name=p22614 lab=_46207_/B }
C {sky130_stdcells/nor2_4.sym} 22860 -10880 0 0 {name=X_46132_ }
C {devices/lab_pin.sym} 22780 -10790 0 0 {name=p22615 lab=_57989_/X }
C {devices/lab_pin.sym} 22780 -10750 0 0 {name=p22616 lab=_58116_/Y }
C {devices/lab_pin.sym} 22780 -10710 0 0 {name=p22617 lab=_58117_/Y }
C {devices/lab_pin.sym} 22780 -10670 0 0 {name=p22618 lab=_58007_/X }
C {devices/lab_pin.sym} 22780 -10630 0 0 {name=p22619 lab=_57993_/X }
C {devices/lab_pin.sym} 22940 -10710 0 1 {name=p22620 lab=_58118_/X }
C {sky130_stdcells/o32a_4.sym} 22860 -10710 0 0 {name=X_58118_ }
C {sky130_stdcells/decap_3.sym} 22860 -10520 0 0 {name=XPHY_185 }
C {devices/lab_pin.sym} 22780 -10410 0 0 {name=p22621 lab=_43316_/X }
C {devices/lab_pin.sym} 22780 -10370 0 0 {name=p22622 lab=_43319_/X }
C {devices/lab_pin.sym} 22780 -10330 0 0 {name=p22623 lab=_41321_/X }
C {devices/lab_pin.sym} 22780 -10290 0 0 {name=p22624 lab=_87468_/Q }
C {devices/lab_pin.sym} 22780 -10250 0 0 {name=p22625 lab=_43330_/X }
C {devices/lab_pin.sym} 22940 -10330 0 1 {name=p22626 lab=_43344_/Y }
C {sky130_stdcells/o32ai_4.sym} 22860 -10330 0 0 {name=X_43344_ }
C {devices/lab_pin.sym} 22800 -10180 0 0 {name=p22627 lab=_74164_/A }
C {devices/lab_pin.sym} 22800 -10140 0 0 {name=p22628 lab=_73152_/X }
C {devices/lab_pin.sym} 22920 -10160 0 1 {name=p22629 lab=_74164_/Y }
C {sky130_stdcells/nor2_4.sym} 22860 -10160 0 0 {name=X_74164_ }
C {sky130_stdcells/decap_3.sym} 22860 -10000 0 0 {name=XPHY_196 }
C {devices/lab_pin.sym} 22820 -9850 0 0 {name=p22630 lab=_40556_/A }
C {devices/lab_pin.sym} 22900 -9850 0 1 {name=p22631 lab=_40556_/X }
C {sky130_stdcells/buf_2.sym} 22860 -9850 0 0 {name=X_40556_ }
C {devices/lab_pin.sym} 22820 -9730 0 0 {name=p22632 lab=_71458_/C }
C {devices/lab_pin.sym} 22900 -9730 0 1 {name=p22633 lab=_71377_/C }
C {sky130_stdcells/buf_2.sym} 22860 -9730 0 0 {name=X_71376_ }
C {devices/lab_pin.sym} 22780 -9630 0 0 {name=p22634 lab=_59073_/X }
C {devices/lab_pin.sym} 22780 -9590 0 0 {name=p22635 lab=_85753_/Q }
C {devices/lab_pin.sym} 22780 -9550 0 0 {name=p22636 lab=_59037_/X }
C {devices/lab_pin.sym} 22940 -9590 0 1 {name=p22637 lab=_59098_/X }
C {sky130_stdcells/o21a_4.sym} 22860 -9590 0 0 {name=X_59098_ }
C {devices/lab_pin.sym} 22780 -9480 0 0 {name=p22638 lab=_72988_/X }
C {devices/lab_pin.sym} 22780 -9440 0 0 {name=p22639 lab=_85588_/Q }
C {devices/lab_pin.sym} 22780 -9400 0 0 {name=p22640 lab=_73092_/A }
C {devices/lab_pin.sym} 22780 -9360 0 0 {name=p22641 lab=_73114_/X }
C {devices/lab_pin.sym} 22940 -9420 0 1 {name=p22642 lab=_73115_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -9420 0 0 {name=X_73115_ }
C {devices/lab_pin.sym} 22780 -9300 0 0 {name=p22643 lab=_41559_/Y }
C {devices/lab_pin.sym} 22780 -9260 0 0 {name=p22644 lab=_46061_/X }
C {devices/lab_pin.sym} 22780 -9220 0 0 {name=p22645 lab=_86787_/Q }
C {devices/lab_pin.sym} 22780 -9180 0 0 {name=p22646 lab=_46062_/X }
C {devices/lab_pin.sym} 22940 -9240 0 1 {name=p22647 lab=_46063_/X }
C {sky130_stdcells/a2bb2o_4.sym} 22860 -9240 0 0 {name=X_46063_ }
C {devices/lab_pin.sym} 22780 -9110 0 0 {name=p22648 lab=_57997_/X }
C {devices/lab_pin.sym} 22780 -9070 0 0 {name=p22649 lab=_85481_/Q }
C {devices/lab_pin.sym} 22780 -9030 0 0 {name=p22650 lab=_57923_/X }
C {devices/lab_pin.sym} 22940 -9070 0 1 {name=p22651 lab=_58049_/X }
C {sky130_stdcells/o21a_4.sym} 22860 -9070 0 0 {name=X_58049_ }
C {devices/lab_pin.sym} 22780 -8950 0 0 {name=p22652 lab=_70325_/Y }
C {devices/lab_pin.sym} 22780 -8910 0 0 {name=p22653 lab=_70157_/A }
C {devices/lab_pin.sym} 22780 -8870 0 0 {name=p22654 lab=_70326_/Y }
C {devices/lab_pin.sym} 22940 -8910 0 1 {name=p22655 lab=_83796_/D }
C {sky130_stdcells/o21ai_4.sym} 22860 -8910 0 0 {name=X_70327_ }
C {devices/lab_pin.sym} 22820 -8770 0 0 {name=p22656 lab=_43274_/Y }
C {devices/lab_pin.sym} 22900 -8770 0 1 {name=p22657 lab=_43275_/Y }
C {sky130_stdcells/inv_2.sym} 22860 -8770 0 0 {name=X_43275_ }
C {devices/lab_pin.sym} 22800 -8660 0 0 {name=p22658 lab=_74095_/A }
C {devices/lab_pin.sym} 22800 -8620 0 0 {name=p22659 lab=_74095_/B }
C {devices/lab_pin.sym} 22920 -8640 0 1 {name=p22660 lab=_74095_/Y }
C {sky130_stdcells/nor2_4.sym} 22860 -8640 0 0 {name=X_74095_ }
C {devices/lab_pin.sym} 22780 -8530 0 0 {name=p22661 lab=_78959_/Y }
C {devices/lab_pin.sym} 22780 -8490 0 0 {name=p22662 lab=_78960_/Y }
C {devices/lab_pin.sym} 22780 -8450 0 0 {name=p22663 lab=_78971_/X }
C {devices/lab_pin.sym} 22940 -8490 0 1 {name=p22664 lab=_78972_/Y }
C {sky130_stdcells/a21oi_4.sym} 22860 -8490 0 0 {name=X_78972_ }
C {devices/lab_pin.sym} 22820 -8350 0 0 {name=p22665 lab=_40362_/X }
C {devices/lab_pin.sym} 22900 -8350 0 1 {name=p22666 lab=_44382_/A }
C {sky130_stdcells/buf_2.sym} 22860 -8350 0 0 {name=X_40487_ }
C {devices/lab_pin.sym} 22780 -8250 0 0 {name=p22667 lab=_56211_/C }
C {devices/lab_pin.sym} 22780 -8210 0 0 {name=p22668 lab=_44998_/X }
C {devices/lab_pin.sym} 22780 -8170 0 0 {name=p22669 lab=_45013_/X }
C {devices/lab_pin.sym} 22940 -8210 0 1 {name=p22670 lab=_45014_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -8210 0 0 {name=X_45014_ }
C {devices/lab_pin.sym} 22820 -8070 0 0 {name=p22671 lab=_42199_/X }
C {devices/lab_pin.sym} 22900 -8070 0 1 {name=p22672 lab=_42226_/X }
C {sky130_stdcells/buf_2.sym} 22860 -8070 0 0 {name=X_42226_ }
C {devices/lab_pin.sym} 22780 -7970 0 0 {name=p22673 lab=_84524_/Q }
C {devices/lab_pin.sym} 22780 -7930 0 0 {name=p22674 lab=_60349_/X }
C {devices/lab_pin.sym} 22780 -7890 0 0 {name=p22675 lab=_61059_/X }
C {devices/lab_pin.sym} 22940 -7930 0 1 {name=p22676 lab=_84524_/D }
C {sky130_stdcells/o21a_4.sym} 22860 -7930 0 0 {name=X_61060_ }
C {devices/lab_pin.sym} 22780 -7820 0 0 {name=p22677 lab=_56181_/X }
C {devices/lab_pin.sym} 22780 -7780 0 0 {name=p22678 lab=_83071_/Q }
C {devices/lab_pin.sym} 22780 -7740 0 0 {name=p22679 lab=_72880_/X }
C {devices/lab_pin.sym} 22780 -7700 0 0 {name=p22680 lab=_73045_/X }
C {devices/lab_pin.sym} 22940 -7760 0 1 {name=p22681 lab=_73046_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -7760 0 0 {name=X_73046_ }
C {devices/lab_pin.sym} 22800 -7620 0 0 {name=p22682 lab=_77923_/A }
C {devices/lab_pin.sym} 22800 -7580 0 0 {name=p22683 lab=_77922_/Y }
C {devices/lab_pin.sym} 22920 -7600 0 1 {name=p22684 lab=_82039_/D }
C {sky130_stdcells/xnor2_4.sym} 22860 -7600 0 0 {name=X_77923_ }
C {devices/lab_pin.sym} 22800 -7500 0 0 {name=p22685 lab=_70260_/A }
C {devices/lab_pin.sym} 22800 -7460 0 0 {name=p22686 lab=_70260_/B }
C {devices/lab_pin.sym} 22800 -7420 0 0 {name=p22687 lab=_83180_/Q }
C {devices/lab_pin.sym} 22800 -7380 0 0 {name=p22688 lab=_70260_/D }
C {devices/lab_pin.sym} 22920 -7440 0 1 {name=p22689 lab=_70258_/X }
C {sky130_stdcells/and4_4.sym} 22860 -7440 0 0 {name=X_70258_ }
C {devices/lab_pin.sym} 22820 -7290 0 0 {name=p22690 lab=_62478_/A }
C {devices/lab_pin.sym} 22900 -7290 0 1 {name=p22691 lab=_60011_/X }
C {sky130_stdcells/buf_2.sym} 22860 -7290 0 0 {name=X_60011_ }
C {devices/lab_pin.sym} 22820 -7170 0 0 {name=p22692 lab=_49794_/X }
C {devices/lab_pin.sym} 22900 -7170 0 1 {name=p22693 lab=_49830_/C }
C {sky130_stdcells/buf_2.sym} 22860 -7170 0 0 {name=X_49822_ }
C {devices/lab_pin.sym} 22780 -7080 0 0 {name=p22694 lab=_41179_/X }
C {devices/lab_pin.sym} 22780 -7040 0 0 {name=p22695 lab=_42148_/X }
C {devices/lab_pin.sym} 22780 -7000 0 0 {name=p22696 lab=_88006_/Q }
C {devices/lab_pin.sym} 22780 -6960 0 0 {name=p22697 lab=_42150_/X }
C {devices/lab_pin.sym} 22940 -7020 0 1 {name=p22698 lab=_88006_/D }
C {sky130_stdcells/a2bb2o_4.sym} 22860 -7020 0 0 {name=X_42157_ }
C {devices/lab_pin.sym} 22800 -6880 0 0 {name=p22699 lab=_77842_/A }
C {devices/lab_pin.sym} 22800 -6840 0 0 {name=p22700 lab=_77849_/A }
C {devices/lab_pin.sym} 22920 -6860 0 1 {name=p22701 lab=_77854_/X }
C {sky130_stdcells/and2_4.sym} 22860 -6860 0 0 {name=X_77854_ }
C {devices/lab_pin.sym} 22780 -6750 0 0 {name=p22702 lab=_70169_/X }
C {devices/lab_pin.sym} 22780 -6710 0 0 {name=p22703 lab=_83844_/Q }
C {devices/lab_pin.sym} 22780 -6670 0 0 {name=p22704 lab=_70188_/X }
C {devices/lab_pin.sym} 22940 -6710 0 1 {name=p22705 lab=_83844_/D }
C {sky130_stdcells/a21o_4.sym} 22860 -6710 0 0 {name=X_70189_ }
C {devices/lab_pin.sym} 22820 -6570 0 0 {name=p22706 lab=_41107_/Y }
C {devices/lab_pin.sym} 22900 -6570 0 1 {name=p22707 lab=_41108_/X }
C {sky130_stdcells/buf_2.sym} 22860 -6570 0 0 {name=X_41108_ }
C {devices/lab_pin.sym} 22800 -6460 0 0 {name=p22708 lab=_76805_/A }
C {devices/lab_pin.sym} 22800 -6420 0 0 {name=p22709 lab=_76804_/Y }
C {devices/lab_pin.sym} 22920 -6440 0 1 {name=p22710 lab=_76808_/A }
C {sky130_stdcells/xor2_4.sym} 22860 -6440 0 0 {name=X_76805_ }
C {devices/lab_pin.sym} 22800 -6320 0 0 {name=p22711 lab=_49757_/A }
C {devices/lab_pin.sym} 22800 -6280 0 0 {name=p22712 lab=_52969_/B }
C {devices/lab_pin.sym} 22920 -6300 0 1 {name=p22713 lab=_49753_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -6300 0 0 {name=X_49753_ }
C {devices/lab_pin.sym} 22800 -6200 0 0 {name=p22714 lab=_46981_/A }
C {devices/lab_pin.sym} 22800 -6160 0 0 {name=p22715 lab=_46944_/B }
C {devices/lab_pin.sym} 22800 -6120 0 0 {name=p22716 lab=_46981_/C }
C {devices/lab_pin.sym} 22800 -6080 0 0 {name=p22717 lab=_52775_/D }
C {devices/lab_pin.sym} 22920 -6140 0 1 {name=p22718 lab=_46965_/X }
C {sky130_stdcells/and4_4.sym} 22860 -6140 0 0 {name=X_46965_ }
C {devices/lab_pin.sym} 22780 -6030 0 0 {name=p22719 lab=_42083_/X }
C {devices/lab_pin.sym} 22780 -5990 0 0 {name=p22720 lab=_42077_/X }
C {devices/lab_pin.sym} 22780 -5950 0 0 {name=p22721 lab=_40994_/X }
C {devices/lab_pin.sym} 22780 -5910 0 0 {name=p22722 lab=_88040_/Q }
C {devices/lab_pin.sym} 22780 -5870 0 0 {name=p22723 lab=_42078_/X }
C {devices/lab_pin.sym} 22940 -5950 0 1 {name=p22724 lab=_42088_/Y }
C {sky130_stdcells/o32ai_4.sym} 22860 -5950 0 0 {name=X_42088_ }
C {devices/lab_pin.sym} 22800 -5800 0 0 {name=p22725 lab=_82152_/Q }
C {devices/lab_pin.sym} 22800 -5760 0 0 {name=p22726 lab=_77785_/B }
C {devices/lab_pin.sym} 22920 -5780 0 1 {name=p22727 lab=_82120_/D }
C {sky130_stdcells/xor2_4.sym} 22860 -5780 0 0 {name=X_77785_ }
C {devices/lab_pin.sym} 22800 -5660 0 0 {name=p22728 lab=_74994_/X }
C {devices/lab_pin.sym} 22800 -5620 0 0 {name=p22729 lab=_74996_/Y }
C {devices/lab_pin.sym} 22920 -5640 0 1 {name=p22730 lab=_74998_/B }
C {sky130_stdcells/xnor2_4.sym} 22860 -5640 0 0 {name=X_74997_ }
C {devices/lab_pin.sym} 22820 -5510 0 0 {name=p22731 lab=_48704_/A }
C {devices/lab_pin.sym} 22900 -5510 0 1 {name=p22732 lab=_48704_/Y }
C {sky130_stdcells/inv_2.sym} 22860 -5510 0 0 {name=X_48704_ }
C {devices/lab_pin.sym} 22800 -5400 0 0 {name=p22733 lab=_79524_/A }
C {devices/lab_pin.sym} 22800 -5360 0 0 {name=p22734 lab=_79163_/Y }
C {devices/lab_pin.sym} 22920 -5380 0 1 {name=p22735 lab=_79525_/B }
C {sky130_stdcells/nand2_4.sym} 22860 -5380 0 0 {name=X_79524_ }
C {devices/lab_pin.sym} 22820 -5250 0 0 {name=p22736 lab=_41039_/A }
C {devices/lab_pin.sym} 22900 -5250 0 1 {name=p22737 lab=_41039_/Y }
C {sky130_stdcells/inv_2.sym} 22860 -5250 0 0 {name=X_41039_ }
C {devices/lab_pin.sym} 22820 -5130 0 0 {name=p22738 lab=_45915_/X }
C {devices/lab_pin.sym} 22900 -5130 0 1 {name=p22739 lab=_69626_/A }
C {sky130_stdcells/buf_2.sym} 22860 -5130 0 0 {name=X_45916_ }
C {devices/lab_pin.sym} 22780 -5040 0 0 {name=p22740 lab=_64657_/X }
C {devices/lab_pin.sym} 22780 -5000 0 0 {name=p22741 lab=_86748_/Q }
C {devices/lab_pin.sym} 22780 -4960 0 0 {name=p22742 lab=_64733_/X }
C {devices/lab_pin.sym} 22780 -4920 0 0 {name=p22743 lab=_64749_/X }
C {devices/lab_pin.sym} 22940 -4980 0 1 {name=p22744 lab=_64750_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -4980 0 0 {name=X_64750_ }
C {devices/lab_pin.sym} 22800 -4840 0 0 {name=p22745 lab=_76736_/A }
C {devices/lab_pin.sym} 22800 -4800 0 0 {name=p22746 lab=_76735_/Y }
C {devices/lab_pin.sym} 22920 -4820 0 1 {name=p22747 lab=_76744_/A }
C {sky130_stdcells/xor2_4.sym} 22860 -4820 0 0 {name=X_76736_ }
C {devices/lab_pin.sym} 22820 -4690 0 0 {name=p22748 lab=_59721_/X }
C {devices/lab_pin.sym} 22900 -4690 0 1 {name=p22749 lab=_61962_/X }
C {sky130_stdcells/buf_2.sym} 22860 -4690 0 0 {name=X_61962_ }
C {devices/lab_pin.sym} 22820 -4570 0 0 {name=p22750 lab=_49657_/A }
C {devices/lab_pin.sym} 22900 -4570 0 1 {name=p22751 lab=_49685_/C }
C {sky130_stdcells/buf_2.sym} 22860 -4570 0 0 {name=X_49684_ }
C {devices/lab_pin.sym} 22820 -4450 0 0 {name=p22752 lab=_73948_/A }
C {devices/lab_pin.sym} 22900 -4450 0 1 {name=p22753 lab=_73948_/X }
C {sky130_stdcells/buf_2.sym} 22860 -4450 0 0 {name=X_73948_ }
C {devices/lab_pin.sym} 22800 -4360 0 0 {name=p22754 lab=_46868_/A }
C {devices/lab_pin.sym} 22800 -4320 0 0 {name=p22755 lab=_46896_/B }
C {devices/lab_pin.sym} 22800 -4280 0 0 {name=p22756 lab=_46868_/C }
C {devices/lab_pin.sym} 22800 -4240 0 0 {name=p22757 lab=_52735_/D }
C {devices/lab_pin.sym} 22920 -4300 0 1 {name=p22758 lab=_46896_/X }
C {sky130_stdcells/and4_4.sym} 22860 -4300 0 0 {name=X_46896_ }
C {devices/lab_pin.sym} 22800 -4170 0 0 {name=p22759 lab=_63701_/A }
C {devices/lab_pin.sym} 22800 -4130 0 0 {name=p22760 lab=_63701_/B }
C {devices/lab_pin.sym} 22800 -4090 0 0 {name=p22761 lab=_80293_/A }
C {devices/lab_pin.sym} 22920 -4130 0 1 {name=p22762 lab=_63701_/Y }
C {sky130_stdcells/nor3_4.sym} 22860 -4130 0 0 {name=X_63701_ }
C {devices/lab_pin.sym} 22780 -4010 0 0 {name=p22763 lab=_60908_/X }
C {devices/lab_pin.sym} 22780 -3970 0 0 {name=p22764 lab=_60911_/X }
C {devices/lab_pin.sym} 22780 -3930 0 0 {name=p22765 lab=_60994_/A }
C {devices/lab_pin.sym} 22940 -3970 0 1 {name=p22766 lab=_60913_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -3970 0 0 {name=X_60913_ }
C {devices/lab_pin.sym} 22820 -3830 0 0 {name=p22767 lab=_48635_/A }
C {devices/lab_pin.sym} 22900 -3830 0 1 {name=p22768 lab=_48657_/B }
C {sky130_stdcells/buf_2.sym} 22860 -3830 0 0 {name=X_48635_ }
C {devices/lab_pin.sym} 22800 -3720 0 0 {name=p22769 lab=_58623_/A }
C {devices/lab_pin.sym} 22800 -3680 0 0 {name=p22770 lab=_79455_/B }
C {devices/lab_pin.sym} 22920 -3700 0 1 {name=p22771 lab=_79455_/X }
C {sky130_stdcells/xor2_4.sym} 22860 -3700 0 0 {name=X_79455_ }
C {devices/lab_pin.sym} 22820 -3570 0 0 {name=p22772 lab=_45847_/A }
C {devices/lab_pin.sym} 22900 -3570 0 1 {name=p22773 lab=_74700_/B }
C {sky130_stdcells/inv_2.sym} 22860 -3570 0 0 {name=X_45847_ }
C {devices/lab_pin.sym} 22780 -3480 0 0 {name=p22774 lab=_64678_/X }
C {devices/lab_pin.sym} 22780 -3440 0 0 {name=p22775 lab=_85566_/Q }
C {devices/lab_pin.sym} 22780 -3400 0 0 {name=p22776 lab=_64679_/X }
C {devices/lab_pin.sym} 22780 -3360 0 0 {name=p22777 lab=_64680_/X }
C {devices/lab_pin.sym} 22940 -3420 0 1 {name=p22778 lab=_64681_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -3420 0 0 {name=X_64681_ }
C {devices/lab_pin.sym} 22820 -3270 0 0 {name=p22779 lab=_76967_/B }
C {devices/lab_pin.sym} 22900 -3270 0 1 {name=p22780 lab=_76667_/Y }
C {sky130_stdcells/inv_2.sym} 22860 -3270 0 0 {name=X_76667_ }
C {devices/lab_pin.sym} 22800 -3180 0 0 {name=p22781 lab=_61891_/X }
C {devices/lab_pin.sym} 22800 -3140 0 0 {name=p22782 lab=_61846_/B }
C {devices/lab_pin.sym} 22800 -3100 0 0 {name=p22783 lab=_61878_/C }
C {devices/lab_pin.sym} 22800 -3060 0 0 {name=p22784 lab=_61910_/D }
C {devices/lab_pin.sym} 22920 -3120 0 1 {name=p22785 lab=_61893_/Y }
C {sky130_stdcells/nand4_4.sym} 22860 -3120 0 0 {name=X_61893_ }
C {devices/lab_pin.sym} 22780 -3000 0 0 {name=p22786 lab=_73850_/X }
C {devices/lab_pin.sym} 22780 -2960 0 0 {name=p22787 lab=_86228_/Q }
C {devices/lab_pin.sym} 22780 -2920 0 0 {name=p22788 lab=_73804_/X }
C {devices/lab_pin.sym} 22780 -2880 0 0 {name=p22789 lab=_73878_/X }
C {devices/lab_pin.sym} 22940 -2940 0 1 {name=p22790 lab=_73879_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -2940 0 0 {name=X_73879_ }
C {devices/lab_pin.sym} 22800 -2810 0 0 {name=p22791 lab=_66433_/A }
C {devices/lab_pin.sym} 22800 -2770 0 0 {name=p22792 lab=_66419_/X }
C {devices/lab_pin.sym} 22800 -2730 0 0 {name=p22793 lab=_66420_/C }
C {devices/lab_pin.sym} 22920 -2770 0 1 {name=p22794 lab=_66420_/X }
C {sky130_stdcells/and3_4.sym} 22860 -2770 0 0 {name=X_66420_ }
C {devices/lab_pin.sym} 22780 -2650 0 0 {name=p22795 lab=_78402_/Y }
C {devices/lab_pin.sym} 22780 -2610 0 0 {name=p22796 lab=_78404_/Y }
C {devices/lab_pin.sym} 22780 -2570 0 0 {name=p22797 lab=_78405_/Y }
C {devices/lab_pin.sym} 22940 -2610 0 1 {name=p22798 lab=_78411_/A }
C {sky130_stdcells/o21ai_4.sym} 22860 -2610 0 0 {name=X_78406_ }
C {devices/lab_pin.sym} 22820 -2470 0 0 {name=p22799 lab=_63632_/A }
C {devices/lab_pin.sym} 22900 -2470 0 1 {name=p22800 lab=_63661_/C }
C {sky130_stdcells/buf_2.sym} 22860 -2470 0 0 {name=X_63632_ }
C {devices/lab_pin.sym} 22800 -2360 0 0 {name=p22801 lab=_81112_/Q }
C {devices/lab_pin.sym} 22800 -2320 0 0 {name=p22802 lab=_80824_/Q }
C {devices/lab_pin.sym} 22920 -2340 0 1 {name=p22803 lab=_80776_/D }
C {sky130_stdcells/xor2_4.sym} 22860 -2340 0 0 {name=X_75618_ }
C {devices/lab_pin.sym} 22780 -2230 0 0 {name=p22804 lab=_48563_/X }
C {devices/lab_pin.sym} 22780 -2190 0 0 {name=p22805 lab=_82351_/Q }
C {devices/lab_pin.sym} 22780 -2150 0 0 {name=p22806 lab=_48565_/Y }
C {devices/lab_pin.sym} 22940 -2190 0 1 {name=p22807 lab=_48567_/A }
C {sky130_stdcells/o21ai_4.sym} 22860 -2190 0 0 {name=X_48566_ }
C {devices/lab_pin.sym} 22820 -2050 0 0 {name=p22808 lab=_60843_/X }
C {devices/lab_pin.sym} 22900 -2050 0 1 {name=p22809 lab=_60844_/X }
C {sky130_stdcells/buf_2.sym} 22860 -2050 0 0 {name=X_60844_ }
C {devices/lab_pin.sym} 22800 -1940 0 0 {name=p22810 lab=_79384_/X }
C {devices/lab_pin.sym} 22800 -1900 0 0 {name=p22811 lab=_79391_/B }
C {devices/lab_pin.sym} 22920 -1920 0 1 {name=p22812 lab=_79386_/Y }
C {sky130_stdcells/xnor2_4.sym} 22860 -1920 0 0 {name=X_79386_ }
C {devices/lab_pin.sym} 22780 -1810 0 0 {name=p22813 lab=_45748_/X }
C {devices/lab_pin.sym} 22780 -1770 0 0 {name=p22814 lab=_63280_/B }
C {devices/lab_pin.sym} 22780 -1730 0 0 {name=p22815 lab=_45765_/X }
C {devices/lab_pin.sym} 22940 -1770 0 1 {name=p22816 lab=_45778_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -1770 0 0 {name=X_45778_ }
C {devices/lab_pin.sym} 22780 -1650 0 0 {name=p22817 lab=_76597_/B }
C {devices/lab_pin.sym} 22780 -1610 0 0 {name=p22818 lab=_76596_/Y }
C {devices/lab_pin.sym} 22780 -1570 0 0 {name=p22819 lab=_76593_/Y }
C {devices/lab_pin.sym} 22940 -1610 0 1 {name=p22820 lab=_76598_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -1610 0 0 {name=X_76598_ }
C {devices/lab_pin.sym} 22800 -1480 0 0 {name=p22821 lab=_47517_/A }
C {devices/lab_pin.sym} 22800 -1440 0 0 {name=p22822 lab=_53095_/B }
C {devices/lab_pin.sym} 22920 -1460 0 1 {name=p22823 lab=_47517_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -1460 0 0 {name=X_47517_ }
C {devices/lab_pin.sym} 22780 -1360 0 0 {name=p22824 lab=_58697_/A }
C {devices/lab_pin.sym} 22780 -1320 0 0 {name=p22825 lab=_85602_/Q }
C {devices/lab_pin.sym} 22780 -1280 0 0 {name=p22826 lab=_66349_/X }
C {devices/lab_pin.sym} 22780 -1240 0 0 {name=p22827 lab=_66350_/X }
C {devices/lab_pin.sym} 22940 -1300 0 1 {name=p22828 lab=_66351_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -1300 0 0 {name=X_66351_ }
C {devices/lab_pin.sym} 22800 -1170 0 0 {name=p22829 lab=_78335_/Y }
C {devices/lab_pin.sym} 22800 -1130 0 0 {name=p22830 lab=_78334_/Y }
C {devices/lab_pin.sym} 22800 -1090 0 0 {name=p22831 lab=_78337_/C }
C {devices/lab_pin.sym} 22920 -1130 0 1 {name=p22832 lab=_78338_/A }
C {sky130_stdcells/nand3_4.sym} 22860 -1130 0 0 {name=X_78337_ }
C {devices/lab_pin.sym} 22780 -1030 0 0 {name=p22833 lab=_44712_/X }
C {devices/lab_pin.sym} 22780 -990 0 0 {name=p22834 lab=_44713_/X }
C {devices/lab_pin.sym} 22780 -950 0 0 {name=p22835 lab=_40724_/X }
C {devices/lab_pin.sym} 22780 -910 0 0 {name=p22836 lab=_74119_/A }
C {devices/lab_pin.sym} 22780 -870 0 0 {name=p22837 lab=_44714_/X }
C {devices/lab_pin.sym} 22940 -950 0 1 {name=p22838 lab=_44730_/A }
C {sky130_stdcells/o32ai_4.sym} 22860 -950 0 0 {name=X_44729_ }
C {devices/lab_pin.sym} 22780 -820 0 0 {name=p22839 lab=_61521_/B }
C {devices/lab_pin.sym} 22780 -780 0 0 {name=p22840 lab=_63548_/X }
C {devices/lab_pin.sym} 22780 -740 0 0 {name=p22841 lab=_63561_/X }
C {devices/lab_pin.sym} 22780 -700 0 0 {name=p22842 lab=_63562_/Y }
C {devices/lab_pin.sym} 22940 -760 0 1 {name=p22843 lab=_63563_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -760 0 0 {name=X_63563_ }
C {devices/lab_pin.sym} 23720 -42160 0 0 {name=p22844 lab=_75546_/Y }
C {devices/lab_pin.sym} 23720 -42120 0 0 {name=p22845 lab=_75562_/A }
C {devices/lab_pin.sym} 23840 -42140 0 1 {name=p22846 lab=_75551_/B }
C {sky130_stdcells/nand2_4.sym} 23780 -42140 0 0 {name=X_75549_ }
C {devices/lab_pin.sym} 23700 -42030 0 0 {name=p22847 lab=_48471_/X }
C {devices/lab_pin.sym} 23700 -41990 0 0 {name=p22848 lab=_47963_/A }
C {devices/lab_pin.sym} 23700 -41950 0 0 {name=p22849 lab=_48496_/Y }
C {devices/lab_pin.sym} 23860 -41990 0 1 {name=p22850 lab=_48498_/A }
C {sky130_stdcells/o21ai_4.sym} 23780 -41990 0 0 {name=X_48497_ }
C {devices/lab_pin.sym} 23740 -41850 0 0 {name=p22851 lab=_60267_/A }
C {devices/lab_pin.sym} 23820 -41850 0 1 {name=p22852 lab=_70021_/C }
C {sky130_stdcells/buf_2.sym} 23780 -41850 0 0 {name=X_60775_ }
C {devices/lab_pin.sym} 23720 -41740 0 0 {name=p22853 lab=_57694_/X }
C {devices/lab_pin.sym} 23720 -41700 0 0 {name=p22854 lab=_86022_/Q }
C {devices/lab_pin.sym} 23840 -41720 0 1 {name=p22855 lab=_65302_/X }
C {sky130_stdcells/and2_4.sym} 23780 -41720 0 0 {name=X_65302_ }
C {devices/lab_pin.sym} 23700 -41610 0 0 {name=p22856 lab=_62512_/Y }
C {devices/lab_pin.sym} 23700 -41570 0 0 {name=p22857 lab=_62467_/X }
C {devices/lab_pin.sym} 23700 -41530 0 0 {name=p22858 lab=_62513_/Y }
C {devices/lab_pin.sym} 23860 -41570 0 1 {name=p22859 lab=_84405_/D }
C {sky130_stdcells/a21oi_4.sym} 23780 -41570 0 0 {name=X_62514_ }
C {devices/lab_pin.sym} 23700 -41460 0 0 {name=p22860 lab=_41973_/A }
C {devices/lab_pin.sym} 23700 -41420 0 0 {name=p22861 lab=_68958_/X }
C {devices/lab_pin.sym} 23700 -41380 0 0 {name=p22862 lab=_68745_/X }
C {devices/lab_pin.sym} 23700 -41340 0 0 {name=p22863 lab=_69069_/Y }
C {devices/lab_pin.sym} 23860 -41400 0 1 {name=p22864 lab=_69070_/X }
C {sky130_stdcells/a211o_4.sym} 23780 -41400 0 0 {name=X_69070_ }
C {devices/lab_pin.sym} 23720 -41280 0 0 {name=p22865 lab=_47437_/X }
C {devices/lab_pin.sym} 23720 -41240 0 0 {name=p22866 lab=_47415_/X }
C {devices/lab_pin.sym} 23720 -41200 0 0 {name=p22867 lab=_47466_/C }
C {devices/lab_pin.sym} 23720 -41160 0 0 {name=p22868 lab=_53052_/D }
C {devices/lab_pin.sym} 23840 -41220 0 1 {name=p22869 lab=_47448_/X }
C {sky130_stdcells/and4_4.sym} 23780 -41220 0 0 {name=X_47448_ }
C {devices/lab_pin.sym} 23740 -41070 0 0 {name=p22870 lab=_65516_/A }
C {devices/lab_pin.sym} 23820 -41070 0 1 {name=p22871 lab=_66282_/X }
C {sky130_stdcells/buf_2.sym} 23780 -41070 0 0 {name=X_66282_ }
C {devices/lab_pin.sym} 23700 -40970 0 0 {name=p22872 lab=_78264_/Y }
C {devices/lab_pin.sym} 23700 -40930 0 0 {name=p22873 lab=_78256_/B }
C {devices/lab_pin.sym} 23700 -40890 0 0 {name=p22874 lab=_78282_/A }
C {devices/lab_pin.sym} 23860 -40930 0 1 {name=p22875 lab=_78268_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -40930 0 0 {name=X_78268_ }
C {devices/lab_pin.sym} 23700 -40810 0 0 {name=p22876 lab=_63492_/Y }
C {devices/lab_pin.sym} 23700 -40770 0 0 {name=p22877 lab=_63455_/X }
C {devices/lab_pin.sym} 23700 -40730 0 0 {name=p22878 lab=_63493_/Y }
C {devices/lab_pin.sym} 23860 -40770 0 1 {name=p22879 lab=_84319_/D }
C {sky130_stdcells/a21oi_4.sym} 23780 -40770 0 0 {name=X_63494_ }
C {devices/lab_pin.sym} 23740 -40630 0 0 {name=p22880 lab=clkbuf_9_325_0_CLK/X }
C {devices/lab_pin.sym} 23820 -40630 0 1 {name=p22881 lab=_88232_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 23780 -40630 0 0 {name=Xclkbuf_10_650_0_CLK }
C {devices/lab_pin.sym} 23700 -40540 0 0 {name=p22882 lab=_87382_/Q }
C {devices/lab_pin.sym} 23700 -40500 0 0 {name=p22883 lab=_67953_/X }
C {devices/lab_pin.sym} 23700 -40460 0 0 {name=p22884 lab=_67954_/X }
C {devices/lab_pin.sym} 23700 -40420 0 0 {name=p22885 lab=_68020_/X }
C {devices/lab_pin.sym} 23860 -40480 0 1 {name=p22886 lab=_68021_/X }
C {sky130_stdcells/a211o_4.sym} 23780 -40480 0 0 {name=X_68021_ }
C {devices/lab_pin.sym} 23720 -40340 0 0 {name=p22887 lab=_65233_/A }
C {devices/lab_pin.sym} 23720 -40300 0 0 {name=p22888 lab=_65233_/B }
C {devices/lab_pin.sym} 23840 -40320 0 1 {name=p22889 lab=_65233_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -40320 0 0 {name=X_65233_ }
C {devices/lab_pin.sym} 23720 -40200 0 0 {name=p22890 lab=_77219_/A }
C {devices/lab_pin.sym} 23720 -40160 0 0 {name=p22891 lab=_77219_/B }
C {devices/lab_pin.sym} 23840 -40180 0 1 {name=p22892 lab=_77220_/B }
C {sky130_stdcells/xor2_4.sym} 23780 -40180 0 0 {name=X_77219_ }
C {devices/lab_pin.sym} 23740 -40050 0 0 {name=p22893 lab=_62198_/Y }
C {devices/lab_pin.sym} 23820 -40050 0 1 {name=p22894 lab=_62493_/A }
C {sky130_stdcells/buf_2.sym} 23780 -40050 0 0 {name=X_62445_ }
C {devices/lab_pin.sym} 23740 -39930 0 0 {name=p22895 lab=_47379_/A }
C {devices/lab_pin.sym} 23820 -39930 0 1 {name=p22896 lab=_53015_/D }
C {sky130_stdcells/buf_2.sym} 23780 -39930 0 0 {name=X_47379_ }
C {devices/lab_pin.sym} 23720 -39820 0 0 {name=p22897 lab=_78199_/A }
C {devices/lab_pin.sym} 23720 -39780 0 0 {name=p22898 lab=_78199_/B }
C {devices/lab_pin.sym} 23840 -39800 0 1 {name=p22899 lab=_78199_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -39800 0 0 {name=X_78199_ }
C {devices/lab_pin.sym} 23740 -39670 0 0 {name=p22900 lab=clkbuf_8_70_0_CLK/X }
C {devices/lab_pin.sym} 23820 -39670 0 1 {name=p22901 lab=clkbuf_9_141_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 23780 -39670 0 0 {name=Xclkbuf_9_141_0_CLK }
C {devices/lab_pin.sym} 23700 -39570 0 0 {name=p22902 lab=_86442_/Q }
C {devices/lab_pin.sym} 23700 -39530 0 0 {name=p22903 lab=_49104_/X }
C {devices/lab_pin.sym} 23700 -39490 0 0 {name=p22904 lab=_49117_/Y }
C {devices/lab_pin.sym} 23860 -39530 0 1 {name=p22905 lab=_49118_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -39530 0 0 {name=X_49118_ }
C {devices/lab_pin.sym} 23700 -39410 0 0 {name=p22906 lab=_80216_/A }
C {devices/lab_pin.sym} 23700 -39370 0 0 {name=p22907 lab=_80215_/X }
C {devices/lab_pin.sym} 23700 -39330 0 0 {name=p22908 lab=_80229_/Y }
C {devices/lab_pin.sym} 23860 -39370 0 1 {name=p22909 lab=_80230_/Y }
C {sky130_stdcells/a21boi_4.sym} 23780 -39370 0 0 {name=X_80230_ }
C {devices/lab_pin.sym} 23720 -39240 0 0 {name=p22910 lab=_65164_/A }
C {devices/lab_pin.sym} 23720 -39200 0 0 {name=p22911 lab=_65164_/B }
C {devices/lab_pin.sym} 23840 -39220 0 1 {name=p22912 lab=_65164_/X }
C {sky130_stdcells/and2_4.sym} 23780 -39220 0 0 {name=X_65164_ }
C {devices/lab_pin.sym} 23700 -39110 0 0 {name=p22913 lab=_86210_/Q }
C {devices/lab_pin.sym} 23700 -39070 0 0 {name=p22914 lab=_50387_/X }
C {devices/lab_pin.sym} 23700 -39030 0 0 {name=p22915 lab=_50389_/Y }
C {devices/lab_pin.sym} 23860 -39070 0 1 {name=p22916 lab=_50390_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -39070 0 0 {name=X_50390_ }
C {devices/lab_pin.sym} 23740 -38930 0 0 {name=p22917 lab=_62522_/B }
C {devices/lab_pin.sym} 23820 -38930 0 1 {name=p22918 lab=_62420_/C }
C {sky130_stdcells/buf_2.sym} 23780 -38930 0 0 {name=X_62376_ }
C {devices/lab_pin.sym} 23700 -38850 0 0 {name=p22919 lab=_64077_/Y }
C {devices/lab_pin.sym} 23700 -38810 0 0 {name=p22920 lab=_64110_/Y }
C {devices/lab_pin.sym} 23700 -38770 0 0 {name=p22921 lab=_64111_/X }
C {devices/lab_pin.sym} 23700 -38730 0 0 {name=p22922 lab=_64113_/X }
C {devices/lab_pin.sym} 23700 -38690 0 0 {name=p22923 lab=_64114_/X }
C {devices/lab_pin.sym} 23860 -38770 0 1 {name=p22924 lab=_64115_/Y }
C {sky130_stdcells/o41ai_4.sym} 23780 -38770 0 0 {name=X_64115_ }
C {devices/lab_pin.sym} 23720 -38620 0 0 {name=p22925 lab=_49049_/A }
C {devices/lab_pin.sym} 23720 -38580 0 0 {name=p22926 lab=_48959_/B }
C {devices/lab_pin.sym} 23840 -38600 0 1 {name=p22927 lab=_50645_/B }
C {sky130_stdcells/nor2_4.sym} 23780 -38600 0 0 {name=X_49049_ }
C {devices/lab_pin.sym} 23700 -38490 0 0 {name=p22928 lab=_59829_/X }
C {devices/lab_pin.sym} 23700 -38450 0 0 {name=p22929 lab=_61325_/Y }
C {devices/lab_pin.sym} 23700 -38410 0 0 {name=p22930 lab=_61326_/X }
C {devices/lab_pin.sym} 23860 -38450 0 1 {name=p22931 lab=_84489_/D }
C {sky130_stdcells/o21a_4.sym} 23780 -38450 0 0 {name=X_61327_ }
C {devices/lab_pin.sym} 23700 -38330 0 0 {name=p22932 lab=_80139_/Y }
C {devices/lab_pin.sym} 23700 -38290 0 0 {name=p22933 lab=_80157_/X }
C {devices/lab_pin.sym} 23700 -38250 0 0 {name=p22934 lab=_80160_/Y }
C {devices/lab_pin.sym} 23860 -38290 0 1 {name=p22935 lab=_80162_/B }
C {sky130_stdcells/a21oi_4.sym} 23780 -38290 0 0 {name=X_80161_ }
C {devices/lab_pin.sym} 23740 -38150 0 0 {name=p22936 lab=clkbuf_9_332_0_CLK/X }
C {devices/lab_pin.sym} 23820 -38150 0 1 {name=p22937 lab=_87684_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 23780 -38150 0 0 {name=Xclkbuf_10_665_0_CLK }
C {devices/lab_pin.sym} 23700 -38060 0 0 {name=p22938 lab=_64944_/X }
C {devices/lab_pin.sym} 23700 -38020 0 0 {name=p22939 lab=_86158_/Q }
C {devices/lab_pin.sym} 23700 -37980 0 0 {name=p22940 lab=_65022_/X }
C {devices/lab_pin.sym} 23700 -37940 0 0 {name=p22941 lab=_65094_/X }
C {devices/lab_pin.sym} 23860 -38000 0 1 {name=p22942 lab=_65095_/X }
C {sky130_stdcells/a211o_4.sym} 23780 -38000 0 0 {name=X_65095_ }
C {devices/lab_pin.sym} 23720 -37860 0 0 {name=p22943 lab=_69853_/A }
C {devices/lab_pin.sym} 23720 -37820 0 0 {name=p22944 lab=_69972_/B }
C {devices/lab_pin.sym} 23840 -37840 0 1 {name=p22945 lab=_69972_/X }
C {sky130_stdcells/and2_4.sym} 23780 -37840 0 0 {name=X_69972_ }
C {devices/lab_pin.sym} 23720 -37720 0 0 {name=p22946 lab=_52014_/X }
C {devices/lab_pin.sym} 23720 -37680 0 0 {name=p22947 lab=_50358_/B }
C {devices/lab_pin.sym} 23840 -37700 0 1 {name=p22948 lab=_52060_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -37700 0 0 {name=X_52060_ }
C {devices/lab_pin.sym} 23700 -37590 0 0 {name=p22949 lab=_68919_/X }
C {devices/lab_pin.sym} 23700 -37550 0 0 {name=p22950 lab=_68921_/X }
C {devices/lab_pin.sym} 23700 -37510 0 0 {name=p22951 lab=_68922_/X }
C {devices/lab_pin.sym} 23860 -37550 0 1 {name=p22952 lab=_68923_/X }
C {sky130_stdcells/a21o_4.sym} 23780 -37550 0 0 {name=X_68923_ }
C {devices/lab_pin.sym} 23720 -37440 0 0 {name=p22953 lab=_62022_/A }
C {devices/lab_pin.sym} 23720 -37400 0 0 {name=p22954 lab=_64046_/B }
C {devices/lab_pin.sym} 23720 -37360 0 0 {name=p22955 lab=_64046_/C }
C {devices/lab_pin.sym} 23720 -37320 0 0 {name=p22956 lab=_64045_/X }
C {devices/lab_pin.sym} 23840 -37380 0 1 {name=p22957 lab=_64047_/D }
C {sky130_stdcells/nand4_4.sym} 23780 -37380 0 0 {name=X_64046_ }
C {devices/lab_pin.sym} 23740 -37230 0 0 {name=p22958 lab=_61258_/A }
C {devices/lab_pin.sym} 23820 -37230 0 1 {name=p22959 lab=_61258_/Y }
C {sky130_stdcells/inv_2.sym} 23780 -37230 0 0 {name=X_61258_ }
C {devices/lab_pin.sym} 23720 -37120 0 0 {name=p22960 lab=_80092_/A }
C {devices/lab_pin.sym} 23720 -37080 0 0 {name=p22961 lab=_80091_/X }
C {devices/lab_pin.sym} 23840 -37100 0 1 {name=p22962 lab=_80105_/B }
C {sky130_stdcells/xnor2_4.sym} 23780 -37100 0 0 {name=X_80092_ }
C {devices/lab_pin.sym} 23740 -36970 0 0 {name=p22963 lab=clkbuf_8_78_0_CLK/X }
C {devices/lab_pin.sym} 23820 -36970 0 1 {name=p22964 lab=clkbuf_9_156_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 23780 -36970 0 0 {name=Xclkbuf_9_156_0_CLK }
C {devices/lab_pin.sym} 23740 -36850 0 0 {name=p22965 lab=_51039_/A }
C {devices/lab_pin.sym} 23820 -36850 0 1 {name=p22966 lab=_51011_/X }
C {sky130_stdcells/buf_2.sym} 23780 -36850 0 0 {name=X_51011_ }
C {devices/lab_pin.sym} 23740 -36730 0 0 {name=p22967 lab=clkbuf_9_83_0_CLK/A }
C {devices/lab_pin.sym} 23820 -36730 0 1 {name=p22968 lab=clkbuf_9_83_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 23780 -36730 0 0 {name=Xclkbuf_9_83_0_CLK }
C {devices/lab_pin.sym} 23740 -36610 0 0 {name=p22969 lab=_62644_/A }
C {devices/lab_pin.sym} 23820 -36610 0 1 {name=p22970 lab=_60211_/A }
C {sky130_stdcells/buf_2.sym} 23780 -36610 0 0 {name=X_60209_ }
C {devices/lab_pin.sym} 23690 -36490 0 0 {name=p22971 lab=_81507_/CLK }
C {devices/lab_pin.sym} 23690 -36470 0 0 {name=p22972 lab=_83920_/D }
C {devices/lab_pin.sym} 23870 -36490 0 1 {name=p22973 lab=_81384_/D }
C {sky130_stdcells/dfxtp_4.sym} 23780 -36480 0 0 {name=X_83920_ }
C {devices/lab_pin.sym} 23700 -36380 0 0 {name=p22974 lab=_87084_/Q }
C {devices/lab_pin.sym} 23700 -36340 0 0 {name=p22975 lab=_68832_/X }
C {devices/lab_pin.sym} 23700 -36300 0 0 {name=p22976 lab=_68762_/X }
C {devices/lab_pin.sym} 23700 -36260 0 0 {name=p22977 lab=_68853_/X }
C {devices/lab_pin.sym} 23860 -36320 0 1 {name=p22978 lab=_68854_/X }
C {sky130_stdcells/a211o_4.sym} 23780 -36320 0 0 {name=X_68854_ }
C {devices/lab_pin.sym} 23700 -36200 0 0 {name=p22979 lab=_84511_/Q }
C {devices/lab_pin.sym} 23700 -36160 0 0 {name=p22980 lab=_60719_/X }
C {devices/lab_pin.sym} 23700 -36120 0 0 {name=p22981 lab=_59753_/Y }
C {devices/lab_pin.sym} 23700 -36080 0 0 {name=p22982 lab=_61188_/Y }
C {devices/lab_pin.sym} 23860 -36140 0 1 {name=p22983 lab=_61189_/X }
C {sky130_stdcells/o22a_4.sym} 23780 -36140 0 0 {name=X_61189_ }
C {devices/lab_pin.sym} 23700 -36010 0 0 {name=p22984 lab=_81486_/D }
C {devices/lab_pin.sym} 23700 -35970 0 0 {name=p22985 lab=_67688_/X }
C {devices/lab_pin.sym} 23700 -35930 0 0 {name=p22986 lab=_67804_/X }
C {devices/lab_pin.sym} 23860 -35970 0 1 {name=p22987 lab=_84054_/D }
C {sky130_stdcells/a21bo_4.sym} 23780 -35970 0 0 {name=X_67805_ }
C {devices/lab_pin.sym} 23690 -35830 0 0 {name=p22988 lab=_86988_/CLK }
C {devices/lab_pin.sym} 23690 -35810 0 0 {name=p22989 lab=_70094_/X }
C {devices/lab_pin.sym} 23870 -35830 0 1 {name=p22990 lab=_82531_/D }
C {sky130_stdcells/dfxtp_4.sym} 23780 -35820 0 0 {name=X_83851_ }
C {devices/lab_pin.sym} 23720 -35700 0 0 {name=p22991 lab=_68785_/A }
C {devices/lab_pin.sym} 23720 -35660 0 0 {name=p22992 lab=_88355_/Q }
C {devices/lab_pin.sym} 23840 -35680 0 1 {name=p22993 lab=_68785_/X }
C {sky130_stdcells/and2_4.sym} 23780 -35680 0 0 {name=X_68785_ }
C {devices/lab_pin.sym} 23720 -35560 0 0 {name=p22994 lab=_65980_/X }
C {devices/lab_pin.sym} 23720 -35520 0 0 {name=p22995 lab=_65997_/B }
C {devices/lab_pin.sym} 23840 -35540 0 1 {name=p22996 lab=_65997_/X }
C {sky130_stdcells/and2_4.sym} 23780 -35540 0 0 {name=X_65997_ }
C {devices/lab_pin.sym} 23690 -35410 0 0 {name=p22997 lab=_84177_/CLK }
C {devices/lab_pin.sym} 23690 -35390 0 0 {name=p22998 lab=_82834_/Q }
C {devices/lab_pin.sym} 23870 -35410 0 1 {name=p22999 lab=_82802_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -35400 0 0 {name=X_82802_ }
C {devices/lab_pin.sym} 23720 -35280 0 0 {name=p23000 lab=_55252_/A }
C {devices/lab_pin.sym} 23720 -35240 0 0 {name=p23001 lab=_85160_/Q }
C {devices/lab_pin.sym} 23840 -35260 0 1 {name=p23002 lab=_55750_/X }
C {sky130_stdcells/and2_4.sym} 23780 -35260 0 0 {name=X_55750_ }
C {devices/lab_pin.sym} 23700 -35150 0 0 {name=p23003 lab=_84057_/Q }
C {devices/lab_pin.sym} 23700 -35110 0 0 {name=p23004 lab=_67688_/X }
C {devices/lab_pin.sym} 23700 -35070 0 0 {name=p23005 lab=_67735_/X }
C {devices/lab_pin.sym} 23860 -35110 0 1 {name=p23006 lab=_67736_/X }
C {sky130_stdcells/a21bo_4.sym} 23780 -35110 0 0 {name=X_67736_ }
C {devices/lab_pin.sym} 23690 -34970 0 0 {name=p23007 lab=_86570_/CLK }
C {devices/lab_pin.sym} 23690 -34950 0 0 {name=p23008 lab=_86570_/D }
C {devices/lab_pin.sym} 23870 -34970 0 1 {name=p23009 lab=_66238_/B }
C {sky130_stdcells/dfxtp_4.sym} 23780 -34960 0 0 {name=X_86570_ }
C {devices/lab_pin.sym} 23720 -34840 0 0 {name=p23010 lab=_64948_/A }
C {devices/lab_pin.sym} 23720 -34800 0 0 {name=p23011 lab=_64948_/B }
C {devices/lab_pin.sym} 23840 -34820 0 1 {name=p23012 lab=_64948_/X }
C {sky130_stdcells/and2_4.sym} 23780 -34820 0 0 {name=X_64948_ }
C {devices/lab_pin.sym} 23740 -34690 0 0 {name=p23013 lab=_53069_/A }
C {devices/lab_pin.sym} 23820 -34690 0 1 {name=p23014 lab=_52982_/B }
C {sky130_stdcells/buf_2.sym} 23780 -34690 0 0 {name=X_52962_ }
C {devices/lab_pin.sym} 23690 -34570 0 0 {name=p23015 lab=_83783_/CLK }
C {devices/lab_pin.sym} 23690 -34550 0 0 {name=p23016 lab=_70385_/Y }
C {devices/lab_pin.sym} 23870 -34570 0 1 {name=p23017 lab=_83782_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -34560 0 0 {name=X_83782_ }
C {devices/lab_pin.sym} 23690 -34430 0 0 {name=p23018 lab=_81985_/CLK }
C {devices/lab_pin.sym} 23690 -34410 0 0 {name=p23019 lab=_65421_/C }
C {devices/lab_pin.sym} 23870 -34430 0 1 {name=p23020 lab=_75571_/A }
C {sky130_stdcells/dfxtp_4.sym} 23780 -34420 0 0 {name=X_80994_ }
C {devices/lab_pin.sym} 23740 -34290 0 0 {name=p23021 lab=clkbuf_9_99_0_CLK/A }
C {devices/lab_pin.sym} 23820 -34290 0 1 {name=p23022 lab=clkbuf_9_98_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 23780 -34290 0 0 {name=Xclkbuf_9_98_0_CLK }
C {devices/lab_pin.sym} 23720 -34200 0 0 {name=p23023 lab=_54699_/X }
C {devices/lab_pin.sym} 23720 -34160 0 0 {name=p23024 lab=_54707_/B }
C {devices/lab_pin.sym} 23720 -34120 0 0 {name=p23025 lab=_54721_/C }
C {devices/lab_pin.sym} 23720 -34080 0 0 {name=p23026 lab=_47369_/A }
C {devices/lab_pin.sym} 23840 -34140 0 1 {name=p23027 lab=_54701_/X }
C {sky130_stdcells/and4_4.sym} 23780 -34140 0 0 {name=X_54701_ }
C {devices/lab_pin.sym} 23690 -33990 0 0 {name=p23028 lab=_85815_/CLK }
C {devices/lab_pin.sym} 23690 -33970 0 0 {name=p23029 lab=_85521_/D }
C {devices/lab_pin.sym} 23870 -33990 0 1 {name=p23030 lab=_85521_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -33980 0 0 {name=X_85521_ }
C {devices/lab_pin.sym} 23740 -33850 0 0 {name=p23031 lab=_51804_/A }
C {devices/lab_pin.sym} 23820 -33850 0 1 {name=p23032 lab=_51914_/A }
C {sky130_stdcells/buf_2.sym} 23780 -33850 0 0 {name=X_51913_ }
C {devices/lab_pin.sym} 23690 -33730 0 0 {name=p23033 lab=_82692_/CLK }
C {devices/lab_pin.sym} 23690 -33710 0 0 {name=p23034 lab=_66469_/C }
C {devices/lab_pin.sym} 23870 -33730 0 1 {name=p23035 lab=_82733_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -33720 0 0 {name=X_82733_ }
C {devices/lab_pin.sym} 23720 -33600 0 0 {name=p23036 lab=_55681_/A }
C {devices/lab_pin.sym} 23720 -33560 0 0 {name=p23037 lab=_55680_/Y }
C {devices/lab_pin.sym} 23840 -33580 0 1 {name=p23038 lab=_55681_/X }
C {sky130_stdcells/xor2_4.sym} 23780 -33580 0 0 {name=X_55681_ }
C {devices/lab_pin.sym} 23720 -33460 0 0 {name=p23039 lab=_67615_/X }
C {devices/lab_pin.sym} 23720 -33420 0 0 {name=p23040 lab=_67667_/B }
C {devices/lab_pin.sym} 23840 -33440 0 1 {name=p23041 lab=_67667_/X }
C {sky130_stdcells/and2_4.sym} 23780 -33440 0 0 {name=X_67667_ }
C {devices/lab_pin.sym} 23740 -33310 0 0 {name=p23042 lab=clkbuf_9_301_0_CLK/X }
C {devices/lab_pin.sym} 23820 -33310 0 1 {name=p23043 lab=_81989_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 23780 -33310 0 0 {name=Xclkbuf_10_603_0_CLK }
C {devices/lab_pin.sym} 23740 -33190 0 0 {name=p23044 lab=_52620_/A }
C {devices/lab_pin.sym} 23820 -33190 0 1 {name=p23045 lab=_52893_/X }
C {sky130_stdcells/buf_2.sym} 23780 -33190 0 0 {name=X_52893_ }
C {devices/lab_pin.sym} 23700 -33100 0 0 {name=p23046 lab=_64809_/X }
C {devices/lab_pin.sym} 23700 -33060 0 0 {name=p23047 lab=_86743_/Q }
C {devices/lab_pin.sym} 23700 -33020 0 0 {name=p23048 lab=_64864_/X }
C {devices/lab_pin.sym} 23700 -32980 0 0 {name=p23049 lab=_64878_/X }
C {devices/lab_pin.sym} 23860 -33040 0 1 {name=p23050 lab=_64879_/X }
C {sky130_stdcells/a211o_4.sym} 23780 -33040 0 0 {name=X_64879_ }
C {devices/lab_pin.sym} 23700 -32910 0 0 {name=p23051 lab=_57275_/X }
C {devices/lab_pin.sym} 23700 -32870 0 0 {name=p23052 lab=_56727_/X }
C {devices/lab_pin.sym} 23700 -32830 0 0 {name=p23053 lab=_57419_/X }
C {devices/lab_pin.sym} 23860 -32870 0 1 {name=p23054 lab=_57420_/X }
C {sky130_stdcells/o21a_4.sym} 23780 -32870 0 0 {name=X_57420_ }
C {devices/lab_pin.sym} 23700 -32750 0 0 {name=p23055 lab=_68852_/X }
C {devices/lab_pin.sym} 23700 -32710 0 0 {name=p23056 lab=_68854_/X }
C {devices/lab_pin.sym} 23700 -32670 0 0 {name=p23057 lab=_69295_/X }
C {devices/lab_pin.sym} 23860 -32710 0 1 {name=p23058 lab=_69406_/Y }
C {sky130_stdcells/a21oi_4.sym} 23780 -32710 0 0 {name=X_69406_ }
C {devices/lab_pin.sym} 23690 -32570 0 0 {name=p23059 lab=_87408_/CLK }
C {devices/lab_pin.sym} 23690 -32550 0 0 {name=p23060 lab=_88240_/D }
C {devices/lab_pin.sym} 23870 -32570 0 1 {name=p23061 lab=_67411_/B }
C {sky130_stdcells/dfxtp_4.sym} 23780 -32560 0 0 {name=X_88240_ }
C {devices/lab_pin.sym} 23720 -32440 0 0 {name=p23062 lab=_54636_/A }
C {devices/lab_pin.sym} 23720 -32400 0 0 {name=p23063 lab=_54106_/B }
C {devices/lab_pin.sym} 23840 -32420 0 1 {name=p23064 lab=_54632_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -32420 0 0 {name=X_54632_ }
C {devices/lab_pin.sym} 23720 -32300 0 0 {name=p23065 lab=_68999_/A }
C {devices/lab_pin.sym} 23720 -32260 0 0 {name=p23066 lab=_66618_/B }
C {devices/lab_pin.sym} 23840 -32280 0 1 {name=p23067 lab=_66618_/X }
C {sky130_stdcells/and2_4.sym} 23780 -32280 0 0 {name=X_66618_ }
C {devices/lab_pin.sym} 23690 -32150 0 0 {name=p23068 lab=_85773_/CLK }
C {devices/lab_pin.sym} 23690 -32130 0 0 {name=p23069 lab=_85452_/D }
C {devices/lab_pin.sym} 23870 -32150 0 1 {name=p23070 lab=_85452_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -32140 0 0 {name=X_85452_ }
C {devices/lab_pin.sym} 23720 -32040 0 0 {name=p23071 lab=_51851_/A }
C {devices/lab_pin.sym} 23720 -32000 0 0 {name=p23072 lab=_51851_/B }
C {devices/lab_pin.sym} 23720 -31960 0 0 {name=p23073 lab=_51851_/C }
C {devices/lab_pin.sym} 23720 -31920 0 0 {name=p23074 lab=_46783_/X }
C {devices/lab_pin.sym} 23840 -31980 0 1 {name=p23075 lab=_51844_/X }
C {sky130_stdcells/and4_4.sym} 23780 -31980 0 0 {name=X_51844_ }
C {devices/lab_pin.sym} 23690 -31830 0 0 {name=p23076 lab=_82879_/CLK }
C {devices/lab_pin.sym} 23690 -31810 0 0 {name=p23077 lab=_82664_/D }
C {devices/lab_pin.sym} 23870 -31830 0 1 {name=p23078 lab=_82664_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -31820 0 0 {name=X_82664_ }
C {devices/lab_pin.sym} 23700 -31710 0 0 {name=p23079 lab=_67593_/X }
C {devices/lab_pin.sym} 23700 -31670 0 0 {name=p23080 lab=_67597_/X }
C {devices/lab_pin.sym} 23700 -31630 0 0 {name=p23081 lab=_67502_/X }
C {devices/lab_pin.sym} 23860 -31670 0 1 {name=p23082 lab=_67602_/A }
C {sky130_stdcells/a21o_4.sym} 23780 -31670 0 0 {name=X_67598_ }
C {devices/lab_pin.sym} 23740 -31530 0 0 {name=p23083 lab=clkbuf_8_10_0_CLK/X }
C {devices/lab_pin.sym} 23820 -31530 0 1 {name=p23084 lab=clkbuf_9_21_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 23780 -31530 0 0 {name=Xclkbuf_9_21_0_CLK }
C {devices/lab_pin.sym} 23690 -31410 0 0 {name=p23085 lab=_84403_/CLK }
C {devices/lab_pin.sym} 23690 -31390 0 0 {name=p23086 lab=_84403_/D }
C {devices/lab_pin.sym} 23870 -31410 0 1 {name=p23087 lab=_62541_/C }
C {sky130_stdcells/dfxtp_4.sym} 23780 -31400 0 0 {name=X_84403_ }
C {devices/lab_pin.sym} 23690 -31270 0 0 {name=p23088 lab=_81615_/CLK }
C {devices/lab_pin.sym} 23690 -31250 0 0 {name=p23089 lab=_81615_/D }
C {devices/lab_pin.sym} 23870 -31270 0 1 {name=p23090 lab=_81807_/D }
C {sky130_stdcells/dfxtp_4.sym} 23780 -31260 0 0 {name=X_81615_ }
C {devices/lab_pin.sym} 23720 -31140 0 0 {name=p23091 lab=_57351_/A }
C {devices/lab_pin.sym} 23720 -31100 0 0 {name=p23092 lab=_57351_/B }
C {devices/lab_pin.sym} 23840 -31120 0 1 {name=p23093 lab=_57351_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -31120 0 0 {name=X_57351_ }
C {devices/lab_pin.sym} 23700 -31010 0 0 {name=p23094 lab=_69334_/X }
C {devices/lab_pin.sym} 23700 -30970 0 0 {name=p23095 lab=_69336_/X }
C {devices/lab_pin.sym} 23700 -30930 0 0 {name=p23096 lab=_69142_/X }
C {devices/lab_pin.sym} 23860 -30970 0 1 {name=p23097 lab=_69337_/Y }
C {sky130_stdcells/a21oi_4.sym} 23780 -30970 0 0 {name=X_69337_ }
C {devices/lab_pin.sym} 23690 -30830 0 0 {name=p23098 lab=_88171_/CLK }
C {devices/lab_pin.sym} 23690 -30810 0 0 {name=p23099 lab=_41678_/Y }
C {devices/lab_pin.sym} 23870 -30830 0 1 {name=p23100 lab=_88171_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -30820 0 0 {name=X_88171_ }
C {devices/lab_pin.sym} 23740 -30690 0 0 {name=p23101 lab=_54481_/A }
C {devices/lab_pin.sym} 23820 -30690 0 1 {name=p23102 lab=_54565_/A }
C {sky130_stdcells/buf_2.sym} 23780 -30690 0 0 {name=X_54563_ }
C {devices/lab_pin.sym} 23740 -30570 0 0 {name=p23103 lab=_68342_/A }
C {devices/lab_pin.sym} 23820 -30570 0 1 {name=p23104 lab=_69457_/A }
C {sky130_stdcells/buf_2.sym} 23780 -30570 0 0 {name=X_66549_ }
C {devices/lab_pin.sym} 23690 -30450 0 0 {name=p23105 lab=_85379_/CLK }
C {devices/lab_pin.sym} 23690 -30430 0 0 {name=p23106 lab=_85383_/D }
C {devices/lab_pin.sym} 23870 -30450 0 1 {name=p23107 lab=_85383_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -30440 0 0 {name=X_85383_ }
C {devices/lab_pin.sym} 23700 -30330 0 0 {name=p23108 lab=_85948_/Q }
C {devices/lab_pin.sym} 23700 -30290 0 0 {name=p23109 lab=_51763_/X }
C {devices/lab_pin.sym} 23700 -30250 0 0 {name=p23110 lab=_51774_/Y }
C {devices/lab_pin.sym} 23860 -30290 0 1 {name=p23111 lab=_51775_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -30290 0 0 {name=X_51775_ }
C {devices/lab_pin.sym} 23690 -30150 0 0 {name=p23112 lab=_82595_/CLK }
C {devices/lab_pin.sym} 23690 -30130 0 0 {name=p23113 lab=_78821_/B }
C {devices/lab_pin.sym} 23870 -30150 0 1 {name=p23114 lab=_82595_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -30140 0 0 {name=X_82595_ }
C {devices/lab_pin.sym} 23700 -30030 0 0 {name=p23115 lab=_56031_/X }
C {devices/lab_pin.sym} 23700 -29990 0 0 {name=p23116 lab=_56290_/X }
C {devices/lab_pin.sym} 23700 -29950 0 0 {name=p23117 lab=_56301_/Y }
C {devices/lab_pin.sym} 23860 -29990 0 1 {name=p23118 lab=_56302_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -29990 0 0 {name=X_56302_ }
C {devices/lab_pin.sym} 23690 -29850 0 0 {name=p23119 lab=_88201_/CLK }
C {devices/lab_pin.sym} 23690 -29830 0 0 {name=p23120 lab=_87122_/D }
C {devices/lab_pin.sym} 23870 -29850 0 1 {name=p23121 lab=_87122_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -29840 0 0 {name=X_87122_ }
C {devices/lab_pin.sym} 23720 -29720 0 0 {name=p23122 lab=_53509_/A }
C {devices/lab_pin.sym} 23720 -29680 0 0 {name=p23123 lab=_53514_/B }
C {devices/lab_pin.sym} 23840 -29700 0 1 {name=p23124 lab=_53514_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -29700 0 0 {name=X_53514_ }
C {devices/lab_pin.sym} 23690 -29570 0 0 {name=p23125 lab=_82272_/CLK }
C {devices/lab_pin.sym} 23690 -29550 0 0 {name=p23126 lab=_63319_/Y }
C {devices/lab_pin.sym} 23870 -29570 0 1 {name=p23127 lab=_79211_/B }
C {sky130_stdcells/dfxtp_4.sym} 23780 -29560 0 0 {name=X_84334_ }
C {devices/lab_pin.sym} 23700 -29450 0 0 {name=p23128 lab=_50722_/Y }
C {devices/lab_pin.sym} 23700 -29410 0 0 {name=p23129 lab=_50676_/X }
C {devices/lab_pin.sym} 23700 -29370 0 0 {name=p23130 lab=_50725_/X }
C {devices/lab_pin.sym} 23860 -29410 0 1 {name=p23131 lab=_50726_/Y }
C {sky130_stdcells/a21oi_4.sym} 23780 -29410 0 0 {name=X_50726_ }
C {devices/lab_pin.sym} 23740 -29270 0 0 {name=p23132 lab=clkbuf_9_309_0_CLK/X }
C {devices/lab_pin.sym} 23820 -29270 0 1 {name=p23133 lab=_81182_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 23780 -29270 0 0 {name=Xclkbuf_10_618_0_CLK }
C {devices/lab_pin.sym} 23700 -29170 0 0 {name=p23134 lab=_57281_/X }
C {devices/lab_pin.sym} 23700 -29130 0 0 {name=p23135 lab=_57273_/Y }
C {devices/lab_pin.sym} 23700 -29090 0 0 {name=p23136 lab=_56704_/X }
C {devices/lab_pin.sym} 23860 -29130 0 1 {name=p23137 lab=_57282_/Y }
C {sky130_stdcells/a21oi_4.sym} 23780 -29130 0 0 {name=X_57282_ }
C {devices/lab_pin.sym} 23690 -28990 0 0 {name=p23138 lab=_81344_/CLK }
C {devices/lab_pin.sym} 23690 -28970 0 0 {name=p23139 lab=_76726_/X }
C {devices/lab_pin.sym} 23870 -28990 0 1 {name=p23140 lab=_81546_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -28980 0 0 {name=X_81546_ }
C {devices/lab_pin.sym} 23700 -28870 0 0 {name=p23141 lab=_68606_/X }
C {devices/lab_pin.sym} 23700 -28830 0 0 {name=p23142 lab=_68608_/X }
C {devices/lab_pin.sym} 23700 -28790 0 0 {name=p23143 lab=_69212_/X }
C {devices/lab_pin.sym} 23860 -28830 0 1 {name=p23144 lab=_69268_/Y }
C {sky130_stdcells/a21oi_4.sym} 23780 -28830 0 0 {name=X_69268_ }
C {devices/lab_pin.sym} 23720 -28720 0 0 {name=p23145 lab=_54483_/A }
C {devices/lab_pin.sym} 23720 -28680 0 0 {name=p23146 lab=_54503_/B }
C {devices/lab_pin.sym} 23720 -28640 0 0 {name=p23147 lab=_54483_/C }
C {devices/lab_pin.sym} 23720 -28600 0 0 {name=p23148 lab=_54494_/D }
C {devices/lab_pin.sym} 23840 -28660 0 1 {name=p23149 lab=_54494_/X }
C {sky130_stdcells/and4_4.sym} 23780 -28660 0 0 {name=X_54494_ }
C {devices/lab_pin.sym} 23700 -28530 0 0 {name=p23150 lab=_58961_/X }
C {devices/lab_pin.sym} 23700 -28490 0 0 {name=p23151 lab=_85663_/Q }
C {devices/lab_pin.sym} 23700 -28450 0 0 {name=p23152 lab=_59010_/X }
C {devices/lab_pin.sym} 23860 -28490 0 1 {name=p23153 lab=_59021_/X }
C {sky130_stdcells/o21a_4.sym} 23780 -28490 0 0 {name=X_59021_ }
C {devices/lab_pin.sym} 23720 -28370 0 0 {name=p23154 lab=_56233_/A }
C {devices/lab_pin.sym} 23720 -28330 0 0 {name=p23155 lab=_56243_/B }
C {devices/lab_pin.sym} 23720 -28290 0 0 {name=p23156 lab=_56233_/C }
C {devices/lab_pin.sym} 23840 -28330 0 1 {name=p23157 lab=_56233_/Y }
C {sky130_stdcells/nand3_4.sym} 23780 -28330 0 0 {name=X_56233_ }
C {devices/lab_pin.sym} 23700 -28210 0 0 {name=p23158 lab=_82657_/D }
C {devices/lab_pin.sym} 23700 -28170 0 0 {name=p23159 lab=_68200_/X }
C {devices/lab_pin.sym} 23700 -28130 0 0 {name=p23160 lab=_68218_/X }
C {devices/lab_pin.sym} 23860 -28170 0 1 {name=p23161 lab=_68219_/X }
C {sky130_stdcells/a21bo_4.sym} 23780 -28170 0 0 {name=X_68219_ }
C {devices/lab_pin.sym} 23690 -28030 0 0 {name=p23162 lab=_88062_/CLK }
C {devices/lab_pin.sym} 23690 -28010 0 0 {name=p23163 lab=_44564_/Y }
C {devices/lab_pin.sym} 23870 -28030 0 1 {name=p23164 lab=_87053_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -28020 0 0 {name=X_87053_ }
C {devices/lab_pin.sym} 23700 -27910 0 0 {name=p23165 lab=_85633_/Q }
C {devices/lab_pin.sym} 23700 -27870 0 0 {name=p23166 lab=_43021_/X }
C {devices/lab_pin.sym} 23700 -27830 0 0 {name=p23167 lab=_53444_/X }
C {devices/lab_pin.sym} 23860 -27870 0 1 {name=p23168 lab=_53445_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -27870 0 0 {name=X_53445_ }
C {devices/lab_pin.sym} 23690 -27730 0 0 {name=p23169 lab=_84623_/CLK }
C {devices/lab_pin.sym} 23690 -27710 0 0 {name=p23170 lab=_64216_/Y }
C {devices/lab_pin.sym} 23870 -27730 0 1 {name=p23171 lab=_79883_/B }
C {sky130_stdcells/dfxtp_4.sym} 23780 -27720 0 0 {name=X_84265_ }
C {devices/lab_pin.sym} 23720 -27600 0 0 {name=p23172 lab=_50657_/A }
C {devices/lab_pin.sym} 23720 -27560 0 0 {name=p23173 lab=_50144_/B }
C {devices/lab_pin.sym} 23840 -27580 0 1 {name=p23174 lab=_50657_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -27580 0 0 {name=X_50657_ }
C {devices/lab_pin.sym} 23740 -27450 0 0 {name=p23175 lab=clkbuf_8_54_0_CLK/X }
C {devices/lab_pin.sym} 23820 -27450 0 1 {name=p23176 lab=clkbuf_9_109_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 23780 -27450 0 0 {name=Xclkbuf_9_109_0_CLK }
C {devices/lab_pin.sym} 23690 -27330 0 0 {name=p23177 lab=_88121_/CLK }
C {devices/lab_pin.sym} 23690 -27310 0 0 {name=p23178 lab=_81477_/D }
C {devices/lab_pin.sym} 23870 -27330 0 1 {name=p23179 lab=_81477_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -27320 0 0 {name=X_81477_ }
C {devices/lab_pin.sym} 23700 -27210 0 0 {name=p23180 lab=_68484_/X }
C {devices/lab_pin.sym} 23700 -27170 0 0 {name=p23181 lab=_68486_/X }
C {devices/lab_pin.sym} 23700 -27130 0 0 {name=p23182 lab=_69061_/X }
C {devices/lab_pin.sym} 23860 -27170 0 1 {name=p23183 lab=_69199_/Y }
C {sky130_stdcells/a21oi_4.sym} 23780 -27170 0 0 {name=X_69199_ }
C {devices/lab_pin.sym} 23740 -27030 0 0 {name=p23184 lab=clkbuf_9_37_0_CLK/A }
C {devices/lab_pin.sym} 23820 -27030 0 1 {name=p23185 lab=clkbuf_9_36_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 23780 -27030 0 0 {name=Xclkbuf_9_36_0_CLK }
C {devices/lab_pin.sym} 23690 -26910 0 0 {name=p23186 lab=_85718_/CLK }
C {devices/lab_pin.sym} 23690 -26890 0 0 {name=p23187 lab=_51474_/Y }
C {devices/lab_pin.sym} 23870 -26910 0 1 {name=p23188 lab=_86004_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -26900 0 0 {name=X_86004_ }
C {devices/lab_pin.sym} 23740 -26770 0 0 {name=p23189 lab=_40409_/X }
C {devices/lab_pin.sym} 23820 -26770 0 1 {name=p23190 lab=_40410_/X }
C {sky130_stdcells/buf_2.sym} 23780 -26770 0 0 {name=X_40410_ }
C {devices/lab_pin.sym} 23720 -26670 0 0 {name=p23191 lab=_71232_/A }
C {devices/lab_pin.sym} 23720 -26630 0 0 {name=p23192 lab=_71230_/B }
C {devices/lab_pin.sym} 23720 -26590 0 0 {name=p23193 lab=_71232_/C }
C {devices/lab_pin.sym} 23840 -26630 0 1 {name=p23194 lab=_71230_/Y }
C {sky130_stdcells/nand3_4.sym} 23780 -26630 0 0 {name=X_71230_ }
C {devices/lab_pin.sym} 23690 -26490 0 0 {name=p23195 lab=_83216_/CLK }
C {devices/lab_pin.sym} 23690 -26470 0 0 {name=p23196 lab=_72613_/X }
C {devices/lab_pin.sym} 23870 -26490 0 1 {name=p23197 lab=_79245_/B }
C {sky130_stdcells/dfxtp_4.sym} 23780 -26480 0 0 {name=X_83216_ }
C {devices/lab_pin.sym} 23700 -26370 0 0 {name=p23198 lab=_80425_/Y }
C {devices/lab_pin.sym} 23700 -26330 0 0 {name=p23199 lab=_80408_/Y }
C {devices/lab_pin.sym} 23700 -26290 0 0 {name=p23200 lab=_80427_/X }
C {devices/lab_pin.sym} 23860 -26330 0 1 {name=p23201 lab=_80429_/B }
C {sky130_stdcells/o21ai_4.sym} 23780 -26330 0 0 {name=X_80428_ }
C {devices/lab_pin.sym} 23740 -26190 0 0 {name=p23202 lab=_56164_/A }
C {devices/lab_pin.sym} 23820 -26190 0 1 {name=p23203 lab=_56164_/X }
C {sky130_stdcells/buf_2.sym} 23780 -26190 0 0 {name=X_56164_ }
C {devices/lab_pin.sym} 23740 -26070 0 0 {name=p23204 lab=_41389_/Y }
C {devices/lab_pin.sym} 23820 -26070 0 1 {name=p23205 lab=_88224_/D }
C {sky130_stdcells/inv_2.sym} 23780 -26070 0 0 {name=X_41390_ }
C {devices/lab_pin.sym} 23720 -25980 0 0 {name=p23206 lab=_53371_/A }
C {devices/lab_pin.sym} 23720 -25940 0 0 {name=p23207 lab=_53388_/B }
C {devices/lab_pin.sym} 23720 -25900 0 0 {name=p23208 lab=_53371_/C }
C {devices/lab_pin.sym} 23720 -25860 0 0 {name=p23209 lab=_52861_/D }
C {devices/lab_pin.sym} 23840 -25920 0 1 {name=p23210 lab=_53376_/X }
C {sky130_stdcells/and4_4.sym} 23780 -25920 0 0 {name=X_53376_ }
C {devices/lab_pin.sym} 23690 -25770 0 0 {name=p23211 lab=_85315_/CLK }
C {devices/lab_pin.sym} 23690 -25750 0 0 {name=p23212 lab=_84196_/D }
C {devices/lab_pin.sym} 23870 -25770 0 1 {name=p23213 lab=_84196_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -25760 0 0 {name=X_84196_ }
C {devices/lab_pin.sym} 23720 -25650 0 0 {name=p23214 lab=_52291_/A }
C {devices/lab_pin.sym} 23720 -25610 0 0 {name=p23215 lab=_50560_/X }
C {devices/lab_pin.sym} 23720 -25570 0 0 {name=p23216 lab=_50568_/C }
C {devices/lab_pin.sym} 23840 -25610 0 1 {name=p23217 lab=_50588_/X }
C {sky130_stdcells/and3_4.sym} 23780 -25610 0 0 {name=X_50588_ }
C {devices/lab_pin.sym} 23700 -25490 0 0 {name=p23218 lab=_85315_/Q }
C {devices/lab_pin.sym} 23700 -25450 0 0 {name=p23219 lab=_55098_/X }
C {devices/lab_pin.sym} 23700 -25410 0 0 {name=p23220 lab=_55114_/Y }
C {devices/lab_pin.sym} 23860 -25450 0 1 {name=p23221 lab=_55115_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -25450 0 0 {name=X_55115_ }
C {devices/lab_pin.sym} 23740 -25310 0 0 {name=p23222 lab=_47363_/A }
C {devices/lab_pin.sym} 23820 -25310 0 1 {name=p23223 lab=_74492_/A }
C {sky130_stdcells/buf_2.sym} 23780 -25310 0 0 {name=X_40341_ }
C {devices/lab_pin.sym} 23700 -25210 0 0 {name=p23224 lab=_85845_/Q }
C {devices/lab_pin.sym} 23700 -25170 0 0 {name=p23225 lab=_52324_/X }
C {devices/lab_pin.sym} 23700 -25130 0 0 {name=p23226 lab=_52326_/Y }
C {devices/lab_pin.sym} 23860 -25170 0 1 {name=p23227 lab=_52327_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -25170 0 0 {name=X_52327_ }
C {devices/lab_pin.sym} 23700 -25050 0 0 {name=p23228 lab=_48435_/B }
C {devices/lab_pin.sym} 23700 -25010 0 0 {name=p23229 lab=_71138_/A }
C {devices/lab_pin.sym} 23700 -24970 0 0 {name=p23230 lab=_71160_/Y }
C {devices/lab_pin.sym} 23860 -25010 0 1 {name=p23231 lab=_83586_/D }
C {sky130_stdcells/o21ai_4.sym} 23780 -25010 0 0 {name=X_71161_ }
C {devices/lab_pin.sym} 23690 -24870 0 0 {name=p23232 lab=_86218_/CLK }
C {devices/lab_pin.sym} 23690 -24850 0 0 {name=p23233 lab=_83147_/D }
C {devices/lab_pin.sym} 23870 -24870 0 1 {name=p23234 lab=_83147_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -24860 0 0 {name=X_83147_ }
C {devices/lab_pin.sym} 23740 -24730 0 0 {name=p23235 lab=_45765_/A }
C {devices/lab_pin.sym} 23820 -24730 0 1 {name=p23236 lab=_56115_/B }
C {sky130_stdcells/buf_2.sym} 23780 -24730 0 0 {name=X_56095_ }
C {devices/lab_pin.sym} 23700 -24630 0 0 {name=p23237 lab=_80360_/B }
C {devices/lab_pin.sym} 23700 -24590 0 0 {name=p23238 lab=_80350_/B }
C {devices/lab_pin.sym} 23700 -24550 0 0 {name=p23239 lab=_80358_/Y }
C {devices/lab_pin.sym} 23860 -24590 0 1 {name=p23240 lab=_80361_/A }
C {sky130_stdcells/a21o_4.sym} 23780 -24590 0 0 {name=X_80359_ }
C {devices/lab_pin.sym} 23720 -24480 0 0 {name=p23241 lab=_70108_/Y }
C {devices/lab_pin.sym} 23720 -24440 0 0 {name=p23242 lab=_70109_/Y }
C {devices/lab_pin.sym} 23720 -24400 0 0 {name=p23243 lab=_70112_/C }
C {devices/lab_pin.sym} 23720 -24360 0 0 {name=p23244 lab=_70111_/Y }
C {devices/lab_pin.sym} 23840 -24420 0 1 {name=p23245 lab=_70118_/C }
C {sky130_stdcells/nand4_4.sym} 23780 -24420 0 0 {name=X_70112_ }
C {devices/lab_pin.sym} 23740 -24270 0 0 {name=p23246 lab=_55072_/A }
C {devices/lab_pin.sym} 23820 -24270 0 1 {name=p23247 lab=_55046_/X }
C {sky130_stdcells/buf_2.sym} 23780 -24270 0 0 {name=X_55046_ }
C {devices/lab_pin.sym} 23740 -24150 0 0 {name=p23248 lab=_59909_/Y }
C {devices/lab_pin.sym} 23820 -24150 0 1 {name=p23249 lab=_59923_/Y }
C {sky130_stdcells/inv_2.sym} 23780 -24150 0 0 {name=X_59923_ }
C {devices/lab_pin.sym} 23740 -24030 0 0 {name=p23250 lab=_43024_/A }
C {devices/lab_pin.sym} 23820 -24030 0 1 {name=p23251 lab=_43121_/A }
C {sky130_stdcells/buf_2.sym} 23780 -24030 0 0 {name=X_43060_ }
C {devices/lab_pin.sym} 23700 -23930 0 0 {name=p23252 lab=_52338_/B }
C {devices/lab_pin.sym} 23700 -23890 0 0 {name=p23253 lab=_71070_/A }
C {devices/lab_pin.sym} 23700 -23850 0 0 {name=p23254 lab=_71091_/Y }
C {devices/lab_pin.sym} 23860 -23890 0 1 {name=p23255 lab=_71092_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -23890 0 0 {name=X_71092_ }
C {devices/lab_pin.sym} 23700 -23770 0 0 {name=p23256 lab=_52256_/Y }
C {devices/lab_pin.sym} 23700 -23730 0 0 {name=p23257 lab=_52117_/X }
C {devices/lab_pin.sym} 23700 -23690 0 0 {name=p23258 lab=_52257_/Y }
C {devices/lab_pin.sym} 23860 -23730 0 1 {name=p23259 lab=_52258_/Y }
C {sky130_stdcells/a21boi_4.sym} 23780 -23730 0 0 {name=X_52258_ }
C {devices/lab_pin.sym} 23690 -23590 0 0 {name=p23260 lab=_86523_/CLK }
C {devices/lab_pin.sym} 23690 -23570 0 0 {name=p23261 lab=_74382_/Y }
C {devices/lab_pin.sym} 23870 -23590 0 1 {name=p23262 lab=_83078_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -23580 0 0 {name=X_83078_ }
C {devices/lab_pin.sym} 23690 -23450 0 0 {name=p23263 lab=_87126_/CLK }
C {devices/lab_pin.sym} 23690 -23430 0 0 {name=p23264 lab=_87955_/D }
C {devices/lab_pin.sym} 23870 -23450 0 1 {name=p23265 lab=_87955_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -23440 0 0 {name=X_87955_ }
C {devices/lab_pin.sym} 23740 -23310 0 0 {name=p23266 lab=_88072_/Q }
C {devices/lab_pin.sym} 23820 -23310 0 1 {name=p23267 lab=_42011_/Y }
C {sky130_stdcells/inv_2.sym} 23780 -23310 0 0 {name=X_42011_ }
C {devices/lab_pin.sym} 23740 -23190 0 0 {name=p23268 lab=_51128_/A }
C {devices/lab_pin.sym} 23820 -23190 0 1 {name=p23269 lab=_51209_/X }
C {sky130_stdcells/buf_2.sym} 23780 -23190 0 0 {name=X_51209_ }
C {devices/lab_pin.sym} 23690 -23070 0 0 {name=p23270 lab=_84420_/CLK }
C {devices/lab_pin.sym} 23690 -23050 0 0 {name=p23271 lab=_44997_/Y }
C {devices/lab_pin.sym} 23870 -23070 0 1 {name=p23272 lab=_64275_/B }
C {sky130_stdcells/dfxtp_4.sym} 23780 -23060 0 0 {name=X_86906_ }
C {devices/lab_pin.sym} 23720 -22940 0 0 {name=p23273 lab=_74920_/A }
C {devices/lab_pin.sym} 23720 -22900 0 0 {name=p23274 lab=_74920_/B }
C {devices/lab_pin.sym} 23840 -22920 0 1 {name=p23275 lab=_81189_/D }
C {sky130_stdcells/xor2_4.sym} 23780 -22920 0 0 {name=X_74920_ }
C {devices/lab_pin.sym} 23690 -22790 0 0 {name=p23276 lab=_82131_/CLK }
C {devices/lab_pin.sym} 23690 -22770 0 0 {name=p23277 lab=_77831_/B }
C {devices/lab_pin.sym} 23870 -22790 0 1 {name=p23278 lab=_82029_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -22780 0 0 {name=X_82029_ }
C {devices/lab_pin.sym} 23700 -22670 0 0 {name=p23279 lab=_82545_/D }
C {devices/lab_pin.sym} 23700 -22630 0 0 {name=p23280 lab=_70029_/X }
C {devices/lab_pin.sym} 23700 -22590 0 0 {name=p23281 lab=_70042_/X }
C {devices/lab_pin.sym} 23860 -22630 0 1 {name=p23282 lab=_70043_/X }
C {sky130_stdcells/a21bo_4.sym} 23780 -22630 0 0 {name=X_70043_ }
C {devices/lab_pin.sym} 23700 -22530 0 0 {name=p23283 lab=_59727_/X }
C {devices/lab_pin.sym} 23700 -22490 0 0 {name=p23284 lab=_59850_/Y }
C {devices/lab_pin.sym} 23700 -22450 0 0 {name=p23285 lab=_59762_/Y }
C {devices/lab_pin.sym} 23700 -22410 0 0 {name=p23286 lab=_59733_/Y }
C {devices/lab_pin.sym} 23700 -22380 0 0 {name=p23287 lab=_59853_/Y }
C {devices/lab_pin.sym} 23860 -22450 0 1 {name=p23288 lab=_59854_/Y }
C {sky130_stdcells/a41oi_4.sym} 23780 -22450 0 0 {name=X_59854_ }
C {devices/lab_pin.sym} 23700 -22310 0 0 {name=p23289 lab=_52187_/Y }
C {devices/lab_pin.sym} 23700 -22270 0 0 {name=p23290 lab=_52117_/X }
C {devices/lab_pin.sym} 23700 -22230 0 0 {name=p23291 lab=_52188_/Y }
C {devices/lab_pin.sym} 23860 -22270 0 1 {name=p23292 lab=_85872_/D }
C {sky130_stdcells/a21boi_4.sym} 23780 -22270 0 0 {name=X_52189_ }
C {devices/lab_pin.sym} 23690 -22130 0 0 {name=p23293 lab=_87625_/CLK }
C {devices/lab_pin.sym} 23690 -22110 0 0 {name=p23294 lab=_87886_/D }
C {devices/lab_pin.sym} 23870 -22130 0 1 {name=p23295 lab=_87886_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -22120 0 0 {name=X_87886_ }
C {devices/lab_pin.sym} 23740 -21990 0 0 {name=p23296 lab=_58805_/A }
C {devices/lab_pin.sym} 23820 -21990 0 1 {name=p23297 lab=_58897_/A }
C {sky130_stdcells/buf_2.sym} 23780 -21990 0 0 {name=X_58805_ }
C {devices/lab_pin.sym} 23720 -21880 0 0 {name=p23298 lab=_81123_/D }
C {devices/lab_pin.sym} 23720 -21840 0 0 {name=p23299 lab=_80835_/Q }
C {devices/lab_pin.sym} 23840 -21860 0 1 {name=p23300 lab=_74852_/B }
C {sky130_stdcells/xor2_4.sym} 23780 -21860 0 0 {name=X_74851_ }
C {devices/lab_pin.sym} 23690 -21730 0 0 {name=p23301 lab=_87995_/CLK }
C {devices/lab_pin.sym} 23690 -21710 0 0 {name=p23302 lab=_45966_/X }
C {devices/lab_pin.sym} 23870 -21730 0 1 {name=p23303 lab=_66602_/B }
C {sky130_stdcells/dfxtp_4.sym} 23780 -21720 0 0 {name=X_86837_ }
C {devices/lab_pin.sym} 23720 -21610 0 0 {name=p23304 lab=_59737_/A }
C {devices/lab_pin.sym} 23720 -21570 0 0 {name=p23305 lab=_59848_/B }
C {devices/lab_pin.sym} 23720 -21530 0 0 {name=p23306 lab=_80497_/A }
C {devices/lab_pin.sym} 23840 -21570 0 1 {name=p23307 lab=_59785_/Y }
C {sky130_stdcells/nor3_4.sym} 23780 -21570 0 0 {name=X_59785_ }
C {devices/lab_pin.sym} 23740 -21430 0 0 {name=p23308 lab=_44184_/X }
C {devices/lab_pin.sym} 23820 -21430 0 1 {name=p23309 lab=_56997_/X }
C {sky130_stdcells/buf_2.sym} 23780 -21430 0 0 {name=X_56997_ }
C {devices/lab_pin.sym} 23700 -21330 0 0 {name=p23310 lab=_88361_/Q }
C {devices/lab_pin.sym} 23700 -21290 0 0 {name=p23311 lab=_73801_/X }
C {devices/lab_pin.sym} 23700 -21250 0 0 {name=p23312 lab=_73704_/X }
C {devices/lab_pin.sym} 23860 -21290 0 1 {name=p23313 lab=_73802_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -21290 0 0 {name=X_73802_ }
C {devices/lab_pin.sym} 23700 -21170 0 0 {name=p23314 lab=_58751_/A }
C {devices/lab_pin.sym} 23700 -21130 0 0 {name=p23315 lab=_46719_/X }
C {devices/lab_pin.sym} 23700 -21090 0 0 {name=p23316 lab=_46749_/Y }
C {devices/lab_pin.sym} 23860 -21130 0 1 {name=p23317 lab=_46750_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -21130 0 0 {name=X_46750_ }
C {devices/lab_pin.sym} 23700 -21010 0 0 {name=p23318 lab=_58732_/Y }
C {devices/lab_pin.sym} 23700 -20970 0 0 {name=p23319 lab=_58734_/Y }
C {devices/lab_pin.sym} 23700 -20930 0 0 {name=p23320 lab=_58735_/X }
C {devices/lab_pin.sym} 23860 -20970 0 1 {name=p23321 lab=_58736_/X }
C {sky130_stdcells/a21o_4.sym} 23780 -20970 0 0 {name=X_58736_ }
C {devices/lab_pin.sym} 23720 -20850 0 0 {name=p23322 lab=_77570_/A }
C {devices/lab_pin.sym} 23720 -20810 0 0 {name=p23323 lab=_77567_/Y }
C {devices/lab_pin.sym} 23720 -20770 0 0 {name=p23324 lab=_77570_/C }
C {devices/lab_pin.sym} 23840 -20810 0 1 {name=p23325 lab=_77575_/A }
C {sky130_stdcells/or3_4.sym} 23780 -20810 0 0 {name=X_77570_ }
C {devices/lab_pin.sym} 23720 -20680 0 0 {name=p23326 lab=_43957_/A }
C {devices/lab_pin.sym} 23720 -20640 0 0 {name=p23327 lab=_87178_/Q }
C {devices/lab_pin.sym} 23840 -20660 0 1 {name=p23328 lab=_43962_/X }
C {sky130_stdcells/and2_4.sym} 23780 -20660 0 0 {name=X_43962_ }
C {devices/lab_pin.sym} 23700 -20560 0 0 {name=p23329 lab=_56203_/C }
C {devices/lab_pin.sym} 23700 -20520 0 0 {name=p23330 lab=_55605_/X }
C {devices/lab_pin.sym} 23700 -20480 0 0 {name=p23331 lab=_44090_/B }
C {devices/lab_pin.sym} 23700 -20440 0 0 {name=p23332 lab=_55947_/X }
C {devices/lab_pin.sym} 23860 -20500 0 1 {name=p23333 lab=_55948_/X }
C {sky130_stdcells/a211o_4.sym} 23780 -20500 0 0 {name=X_55948_ }
C {devices/lab_pin.sym} 23690 -20350 0 0 {name=p23334 lab=_86218_/CLK }
C {devices/lab_pin.sym} 23690 -20330 0 0 {name=p23335 lab=_46172_/Y }
C {devices/lab_pin.sym} 23870 -20350 0 1 {name=p23336 lab=_72838_/A }
C {sky130_stdcells/dfxtp_4.sym} 23780 -20340 0 0 {name=X_86768_ }
C {devices/lab_pin.sym} 23720 -20230 0 0 {name=p23337 lab=_74723_/X }
C {devices/lab_pin.sym} 23720 -20190 0 0 {name=p23338 lab=_74782_/B }
C {devices/lab_pin.sym} 23720 -20150 0 0 {name=p23339 lab=_74745_/D }
C {devices/lab_pin.sym} 23840 -20190 0 1 {name=p23340 lab=_74782_/Y }
C {sky130_stdcells/nand3_4.sym} 23780 -20190 0 0 {name=X_74782_ }
C {devices/lab_pin.sym} 23720 -20060 0 0 {name=p23341 lab=_71993_/X }
C {devices/lab_pin.sym} 23720 -20020 0 0 {name=p23342 lab=_71994_/B }
C {devices/lab_pin.sym} 23840 -20040 0 1 {name=p23343 lab=_71994_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -20040 0 0 {name=X_71994_ }
C {devices/lab_pin.sym} 23700 -19930 0 0 {name=p23344 lab=_45694_/X }
C {devices/lab_pin.sym} 23700 -19890 0 0 {name=p23345 lab=_45698_/Y }
C {devices/lab_pin.sym} 23700 -19850 0 0 {name=p23346 lab=_45700_/Y }
C {devices/lab_pin.sym} 23860 -19890 0 1 {name=p23347 lab=_45701_/Y }
C {sky130_stdcells/a21oi_4.sym} 23780 -19890 0 0 {name=X_45701_ }
C {devices/lab_pin.sym} 23720 -19760 0 0 {name=p23348 lab=_76522_/A }
C {devices/lab_pin.sym} 23720 -19720 0 0 {name=p23349 lab=_76522_/B }
C {devices/lab_pin.sym} 23840 -19740 0 1 {name=p23350 lab=_76521_/Y }
C {sky130_stdcells/nor2_4.sym} 23780 -19740 0 0 {name=X_76521_ }
C {devices/lab_pin.sym} 23700 -19640 0 0 {name=p23351 lab=_41701_/X }
C {devices/lab_pin.sym} 23700 -19600 0 0 {name=p23352 lab=_42900_/X }
C {devices/lab_pin.sym} 23700 -19560 0 0 {name=p23353 lab=_67652_/B }
C {devices/lab_pin.sym} 23700 -19520 0 0 {name=p23354 lab=_42901_/X }
C {devices/lab_pin.sym} 23860 -19580 0 1 {name=p23355 lab=_42913_/X }
C {sky130_stdcells/a2bb2o_4.sym} 23780 -19580 0 0 {name=X_42913_ }
C {devices/lab_pin.sym} 23720 -19440 0 0 {name=p23356 lab=_73733_/A }
C {devices/lab_pin.sym} 23720 -19400 0 0 {name=p23357 lab=_66006_/B }
C {devices/lab_pin.sym} 23840 -19420 0 1 {name=p23358 lab=_73733_/X }
C {sky130_stdcells/and2_4.sym} 23780 -19420 0 0 {name=X_73733_ }
C {devices/lab_pin.sym} 23690 -19290 0 0 {name=p23359 lab=_85718_/CLK }
C {devices/lab_pin.sym} 23690 -19270 0 0 {name=p23360 lab=_52983_/Y }
C {devices/lab_pin.sym} 23870 -19290 0 1 {name=p23361 lab=_85719_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -19280 0 0 {name=X_85719_ }
C {devices/lab_pin.sym} 23740 -19150 0 0 {name=p23362 lab=_46680_/Y }
C {devices/lab_pin.sym} 23820 -19150 0 1 {name=p23363 lab=_50919_/D }
C {sky130_stdcells/buf_2.sym} 23780 -19150 0 0 {name=X_46681_ }
C {devices/lab_pin.sym} 23740 -19030 0 0 {name=p23364 lab=_58796_/A }
C {devices/lab_pin.sym} 23820 -19030 0 1 {name=p23365 lab=_58667_/X }
C {sky130_stdcells/buf_2.sym} 23780 -19030 0 0 {name=X_58667_ }
C {devices/lab_pin.sym} 23720 -18930 0 0 {name=p23366 lab=_70947_/A }
C {devices/lab_pin.sym} 23720 -18890 0 0 {name=p23367 lab=_70945_/B }
C {devices/lab_pin.sym} 23720 -18850 0 0 {name=p23368 lab=_70947_/C }
C {devices/lab_pin.sym} 23840 -18890 0 1 {name=p23369 lab=_70945_/Y }
C {sky130_stdcells/nand3_4.sym} 23780 -18890 0 0 {name=X_70945_ }
C {devices/lab_pin.sym} 23740 -18750 0 0 {name=p23370 lab=_43892_/Y }
C {devices/lab_pin.sym} 23820 -18750 0 1 {name=p23371 lab=_87212_/D }
C {sky130_stdcells/inv_2.sym} 23780 -18750 0 0 {name=X_43893_ }
C {devices/lab_pin.sym} 23720 -18640 0 0 {name=p23372 lab=_44081_/X }
C {devices/lab_pin.sym} 23720 -18600 0 0 {name=p23373 lab=_55879_/B }
C {devices/lab_pin.sym} 23840 -18620 0 1 {name=p23374 lab=_55879_/X }
C {sky130_stdcells/and2_4.sym} 23780 -18620 0 0 {name=X_55879_ }
C {devices/lab_pin.sym} 23690 -18490 0 0 {name=p23375 lab=_86701_/CLK }
C {devices/lab_pin.sym} 23690 -18470 0 0 {name=p23376 lab=_86699_/D }
C {devices/lab_pin.sym} 23870 -18490 0 1 {name=p23377 lab=_58853_/A }
C {sky130_stdcells/dfxtp_4.sym} 23780 -18480 0 0 {name=X_86699_ }
C {devices/lab_pin.sym} 23740 -18350 0 0 {name=p23378 lab=_48897_/A }
C {devices/lab_pin.sym} 23820 -18350 0 1 {name=p23379 lab=_48613_/A }
C {sky130_stdcells/buf_2.sym} 23780 -18350 0 0 {name=X_48420_ }
C {devices/lab_pin.sym} 23720 -18250 0 0 {name=p23380 lab=_79248_/C }
C {devices/lab_pin.sym} 23720 -18210 0 0 {name=p23381 lab=_79240_/B }
C {devices/lab_pin.sym} 23720 -18170 0 0 {name=p23382 lab=_79235_/B }
C {devices/lab_pin.sym} 23840 -18210 0 1 {name=p23383 lab=_79240_/Y }
C {sky130_stdcells/nand3_4.sym} 23780 -18210 0 0 {name=X_79240_ }
C {devices/lab_pin.sym} 23740 -18070 0 0 {name=p23384 lab=_45734_/A }
C {devices/lab_pin.sym} 23820 -18070 0 1 {name=p23385 lab=_45632_/X }
C {sky130_stdcells/buf_2.sym} 23780 -18070 0 0 {name=X_45632_ }
C {devices/lab_pin.sym} 23700 -17970 0 0 {name=p23386 lab=_84968_/Q }
C {devices/lab_pin.sym} 23700 -17930 0 0 {name=p23387 lab=_57615_/X }
C {devices/lab_pin.sym} 23700 -17890 0 0 {name=p23388 lab=_57617_/Y }
C {devices/lab_pin.sym} 23860 -17930 0 1 {name=p23389 lab=_57618_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -17930 0 0 {name=X_57618_ }
C {devices/lab_pin.sym} 23740 -17790 0 0 {name=p23390 lab=_76451_/Y }
C {devices/lab_pin.sym} 23820 -17790 0 1 {name=p23391 lab=_76455_/B }
C {sky130_stdcells/inv_2.sym} 23780 -17790 0 0 {name=X_76452_ }
C {devices/lab_pin.sym} 23700 -17710 0 0 {name=p23392 lab=_42816_/X }
C {devices/lab_pin.sym} 23700 -17670 0 0 {name=p23393 lab=_42817_/X }
C {devices/lab_pin.sym} 23700 -17630 0 0 {name=p23394 lab=_41515_/X }
C {devices/lab_pin.sym} 23700 -17590 0 0 {name=p23395 lab=_66828_/B }
C {devices/lab_pin.sym} 23700 -17550 0 0 {name=p23396 lab=_42836_/X }
C {devices/lab_pin.sym} 23860 -17630 0 1 {name=p23397 lab=_42845_/A }
C {sky130_stdcells/o32ai_4.sym} 23780 -17630 0 0 {name=X_42844_ }
C {devices/lab_pin.sym} 23700 -17490 0 0 {name=p23398 lab=_73660_/X }
C {devices/lab_pin.sym} 23700 -17450 0 0 {name=p23399 lab=_73663_/X }
C {devices/lab_pin.sym} 23700 -17410 0 0 {name=p23400 lab=_73612_/X }
C {devices/lab_pin.sym} 23860 -17450 0 1 {name=p23401 lab=_73668_/A }
C {sky130_stdcells/a21o_4.sym} 23780 -17450 0 0 {name=X_73664_ }
C {devices/lab_pin.sym} 23720 -17340 0 0 {name=p23402 lab=_70903_/A }
C {devices/lab_pin.sym} 23720 -17300 0 0 {name=p23403 lab=_70869_/B }
C {devices/lab_pin.sym} 23720 -17260 0 0 {name=p23404 lab=_70869_/C }
C {devices/lab_pin.sym} 23720 -17220 0 0 {name=p23405 lab=_70875_/X }
C {devices/lab_pin.sym} 23840 -17280 0 1 {name=p23406 lab=_70876_/Y }
C {sky130_stdcells/nand4_4.sym} 23780 -17280 0 0 {name=X_70876_ }
C {devices/lab_pin.sym} 23700 -17160 0 0 {name=p23407 lab=_84815_/Q }
C {devices/lab_pin.sym} 23700 -17120 0 0 {name=p23408 lab=_58095_/X }
C {devices/lab_pin.sym} 23700 -17080 0 0 {name=p23409 lab=_58590_/X }
C {devices/lab_pin.sym} 23700 -17040 0 0 {name=p23410 lab=_58597_/X }
C {devices/lab_pin.sym} 23860 -17100 0 1 {name=p23411 lab=_84815_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 23780 -17100 0 0 {name=X_58598_ }
C {devices/lab_pin.sym} 23740 -16950 0 0 {name=p23412 lab=_75403_/A }
C {devices/lab_pin.sym} 23820 -16950 0 1 {name=p23413 lab=_75403_/Y }
C {sky130_stdcells/inv_2.sym} 23780 -16950 0 0 {name=X_75403_ }
C {devices/lab_pin.sym} 23740 -16830 0 0 {name=p23414 lab=_48163_/X }
C {devices/lab_pin.sym} 23820 -16830 0 1 {name=p23415 lab=_48392_/A }
C {sky130_stdcells/buf_2.sym} 23780 -16830 0 0 {name=X_48351_ }
C {devices/lab_pin.sym} 23720 -16730 0 0 {name=p23416 lab=_72581_/A }
C {devices/lab_pin.sym} 23720 -16690 0 0 {name=p23417 lab=_72604_/B }
C {devices/lab_pin.sym} 23720 -16650 0 0 {name=p23418 lab=_79231_/B }
C {devices/lab_pin.sym} 23840 -16690 0 1 {name=p23419 lab=_72615_/Y }
C {sky130_stdcells/nor3_4.sym} 23780 -16690 0 0 {name=X_72615_ }
C {devices/lab_pin.sym} 23720 -16570 0 0 {name=p23420 lab=_79171_/A }
C {devices/lab_pin.sym} 23720 -16530 0 0 {name=p23421 lab=_79171_/B }
C {devices/lab_pin.sym} 23720 -16490 0 0 {name=p23422 lab=_79171_/C }
C {devices/lab_pin.sym} 23840 -16530 0 1 {name=p23423 lab=_79171_/Y }
C {sky130_stdcells/nand3_4.sym} 23780 -16530 0 0 {name=X_79171_ }
C {devices/lab_pin.sym} 23740 -16390 0 0 {name=p23424 lab=_63124_/B }
C {devices/lab_pin.sym} 23820 -16390 0 1 {name=p23425 lab=_61451_/A }
C {sky130_stdcells/buf_2.sym} 23780 -16390 0 0 {name=X_45563_ }
C {devices/lab_pin.sym} 23700 -16290 0 0 {name=p23426 lab=_57547_/Y }
C {devices/lab_pin.sym} 23700 -16250 0 0 {name=p23427 lab=_57543_/X }
C {devices/lab_pin.sym} 23700 -16210 0 0 {name=p23428 lab=_57548_/Y }
C {devices/lab_pin.sym} 23860 -16250 0 1 {name=p23429 lab=_84981_/D }
C {sky130_stdcells/a21boi_4.sym} 23780 -16250 0 0 {name=X_57549_ }
C {devices/lab_pin.sym} 23700 -16130 0 0 {name=p23430 lab=_76347_/A }
C {devices/lab_pin.sym} 23700 -16090 0 0 {name=p23431 lab=_76348_/X }
C {devices/lab_pin.sym} 23700 -16050 0 0 {name=p23432 lab=_76371_/X }
C {devices/lab_pin.sym} 23860 -16090 0 1 {name=p23433 lab=_76383_/X }
C {sky130_stdcells/a21bo_4.sym} 23780 -16090 0 0 {name=X_76383_ }
C {devices/lab_pin.sym} 23690 -15950 0 0 {name=p23434 lab=_86982_/CLK }
C {devices/lab_pin.sym} 23690 -15930 0 0 {name=p23435 lab=_40583_/Y }
C {devices/lab_pin.sym} 23870 -15950 0 1 {name=p23436 lab=_88369_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -15940 0 0 {name=X_88369_ }
C {devices/lab_pin.sym} 23740 -15810 0 0 {name=p23437 lab=_42723_/A }
C {devices/lab_pin.sym} 23820 -15810 0 1 {name=p23438 lab=_42775_/X }
C {sky130_stdcells/buf_2.sym} 23780 -15810 0 0 {name=X_42775_ }
C {devices/lab_pin.sym} 23720 -15700 0 0 {name=p23439 lab=_73595_/A }
C {devices/lab_pin.sym} 23720 -15660 0 0 {name=p23440 lab=_73228_/B }
C {devices/lab_pin.sym} 23840 -15680 0 1 {name=p23441 lab=_73595_/Y }
C {sky130_stdcells/nor2_4.sym} 23780 -15680 0 0 {name=X_73595_ }
C {devices/lab_pin.sym} 23740 -15550 0 0 {name=p23442 lab=_47302_/A }
C {devices/lab_pin.sym} 23820 -15550 0 1 {name=p23443 lab=_52971_/D }
C {sky130_stdcells/buf_2.sym} 23780 -15550 0 0 {name=X_47302_ }
C {devices/lab_pin.sym} 23740 -15430 0 0 {name=p23444 lab=_78121_/X }
C {devices/lab_pin.sym} 23820 -15430 0 1 {name=p23445 lab=_78123_/B }
C {sky130_stdcells/buf_2.sym} 23780 -15430 0 0 {name=X_78122_ }
C {devices/lab_pin.sym} 23740 -15310 0 0 {name=p23446 lab=_44514_/A }
C {devices/lab_pin.sym} 23820 -15310 0 1 {name=p23447 lab=_44514_/Y }
C {sky130_stdcells/inv_2.sym} 23780 -15310 0 0 {name=X_44514_ }
C {devices/lab_pin.sym} 23720 -15210 0 0 {name=p23448 lab=_75330_/Y }
C {devices/lab_pin.sym} 23720 -15170 0 0 {name=p23449 lab=_75331_/Y }
C {devices/lab_pin.sym} 23720 -15130 0 0 {name=p23450 lab=_75333_/Y }
C {devices/lab_pin.sym} 23840 -15170 0 1 {name=p23451 lab=_75334_/X }
C {sky130_stdcells/or3_4.sym} 23780 -15170 0 0 {name=X_75334_ }
C {devices/lab_pin.sym} 23700 -15050 0 0 {name=p23452 lab=_41717_/X }
C {devices/lab_pin.sym} 23700 -15010 0 0 {name=p23453 lab=_81743_/Q }
C {devices/lab_pin.sym} 23700 -14970 0 0 {name=p23454 lab=_41725_/X }
C {devices/lab_pin.sym} 23860 -15010 0 1 {name=p23455 lab=_41727_/A }
C {sky130_stdcells/o21ai_4.sym} 23780 -15010 0 0 {name=X_41726_ }
C {devices/lab_pin.sym} 23720 -14880 0 0 {name=p23456 lab=_48275_/X }
C {devices/lab_pin.sym} 23720 -14840 0 0 {name=p23457 lab=_50326_/B }
C {devices/lab_pin.sym} 23840 -14860 0 1 {name=p23458 lab=_48282_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -14860 0 0 {name=X_48282_ }
C {devices/lab_pin.sym} 23720 -14750 0 0 {name=p23459 lab=_60612_/A }
C {devices/lab_pin.sym} 23720 -14710 0 0 {name=p23460 lab=_60526_/B }
C {devices/lab_pin.sym} 23720 -14670 0 0 {name=p23461 lab=_79140_/A }
C {devices/lab_pin.sym} 23840 -14710 0 1 {name=p23462 lab=_60560_/Y }
C {sky130_stdcells/nor3_4.sym} 23780 -14710 0 0 {name=X_60560_ }
C {devices/lab_pin.sym} 23700 -14610 0 0 {name=p23463 lab=_72528_/Y }
C {devices/lab_pin.sym} 23700 -14570 0 0 {name=p23464 lab=_72575_/A }
C {devices/lab_pin.sym} 23700 -14530 0 0 {name=p23465 lab=_72555_/B }
C {devices/lab_pin.sym} 23700 -14490 0 0 {name=p23466 lab=_65307_/A }
C {devices/lab_pin.sym} 23700 -14450 0 0 {name=p23467 lab=_64789_/A }
C {devices/lab_pin.sym} 23860 -14530 0 1 {name=p23468 lab=_72546_/Y }
C {sky130_stdcells/a32oi_4.sym} 23780 -14530 0 0 {name=X_72546_ }
C {devices/lab_pin.sym} 23740 -14370 0 0 {name=p23469 lab=_45494_/A }
C {devices/lab_pin.sym} 23820 -14370 0 1 {name=p23470 lab=_45495_/A }
C {sky130_stdcells/inv_2.sym} 23780 -14370 0 0 {name=X_45494_ }
C {devices/lab_pin.sym} 23700 -14270 0 0 {name=p23471 lab=_57722_/A }
C {devices/lab_pin.sym} 23700 -14230 0 0 {name=p23472 lab=_47192_/X }
C {devices/lab_pin.sym} 23700 -14190 0 0 {name=p23473 lab=_47232_/Y }
C {devices/lab_pin.sym} 23860 -14230 0 1 {name=p23474 lab=_47233_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -14230 0 0 {name=X_47233_ }
C {devices/lab_pin.sym} 23740 -14090 0 0 {name=p23475 lab=_58846_/A }
C {devices/lab_pin.sym} 23820 -14090 0 1 {name=p23476 lab=_59219_/X }
C {sky130_stdcells/buf_2.sym} 23780 -14090 0 0 {name=X_59219_ }
C {devices/lab_pin.sym} 23720 -13980 0 0 {name=p23477 lab=_60822_/C }
C {devices/lab_pin.sym} 23720 -13940 0 0 {name=p23478 lab=_78053_/B }
C {devices/lab_pin.sym} 23840 -13960 0 1 {name=p23479 lab=_78053_/X }
C {sky130_stdcells/xor2_4.sym} 23780 -13960 0 0 {name=X_78053_ }
C {devices/lab_pin.sym} 23700 -13860 0 0 {name=p23480 lab=_41626_/X }
C {devices/lab_pin.sym} 23700 -13820 0 0 {name=p23481 lab=_44431_/X }
C {devices/lab_pin.sym} 23700 -13780 0 0 {name=p23482 lab=_87104_/Q }
C {devices/lab_pin.sym} 23700 -13740 0 0 {name=p23483 lab=_44432_/X }
C {devices/lab_pin.sym} 23860 -13800 0 1 {name=p23484 lab=_87104_/D }
C {sky130_stdcells/a2bb2o_4.sym} 23780 -13800 0 0 {name=X_44445_ }
C {devices/lab_pin.sym} 23720 -13660 0 0 {name=p23485 lab=_75279_/B }
C {devices/lab_pin.sym} 23720 -13620 0 0 {name=p23486 lab=_75265_/B }
C {devices/lab_pin.sym} 23840 -13640 0 1 {name=p23487 lab=_81039_/D }
C {sky130_stdcells/xor2_4.sym} 23780 -13640 0 0 {name=X_75265_ }
C {devices/lab_pin.sym} 23700 -13550 0 0 {name=p23488 lab=_41611_/X }
C {devices/lab_pin.sym} 23700 -13510 0 0 {name=p23489 lab=_41613_/X }
C {devices/lab_pin.sym} 23700 -13470 0 0 {name=p23490 lab=_41656_/X }
C {devices/lab_pin.sym} 23700 -13430 0 0 {name=p23491 lab=_67468_/B }
C {devices/lab_pin.sym} 23700 -13390 0 0 {name=p23492 lab=_41608_/X }
C {devices/lab_pin.sym} 23860 -13470 0 1 {name=p23493 lab=_41658_/A }
C {sky130_stdcells/o32ai_4.sym} 23780 -13470 0 0 {name=X_41657_ }
C {devices/lab_pin.sym} 23700 -13350 0 0 {name=p23494 lab=_72413_/X }
C {devices/lab_pin.sym} 23700 -13310 0 0 {name=p23495 lab=_72475_/Y }
C {devices/lab_pin.sym} 23700 -13270 0 0 {name=p23496 lab=_72476_/Y }
C {devices/lab_pin.sym} 23700 -13230 0 0 {name=p23497 lab=_57793_/X }
C {devices/lab_pin.sym} 23700 -13190 0 0 {name=p23498 lab=_72417_/X }
C {devices/lab_pin.sym} 23860 -13270 0 1 {name=p23499 lab=_72477_/X }
C {sky130_stdcells/o32a_4.sym} 23780 -13270 0 0 {name=X_72477_ }
C {devices/lab_pin.sym} 23700 -13130 0 0 {name=p23500 lab=_60476_/D }
C {devices/lab_pin.sym} 23700 -13090 0 0 {name=p23501 lab=_63004_/C }
C {devices/lab_pin.sym} 23700 -13050 0 0 {name=p23502 lab=_60341_/A }
C {devices/lab_pin.sym} 23860 -13090 0 1 {name=p23503 lab=_60491_/X }
C {sky130_stdcells/o21a_4.sym} 23780 -13090 0 0 {name=X_60491_ }
C {devices/lab_pin.sym} 23720 -12960 0 0 {name=p23504 lab=_81986_/Q }
C {devices/lab_pin.sym} 23720 -12920 0 0 {name=p23505 lab=_82274_/D }
C {devices/lab_pin.sym} 23840 -12940 0 1 {name=p23506 lab=_77004_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -12940 0 0 {name=X_77004_ }
C {devices/lab_pin.sym} 23700 -12830 0 0 {name=p23507 lab=_74213_/X }
C {devices/lab_pin.sym} 23700 -12790 0 0 {name=p23508 lab=_74215_/X }
C {devices/lab_pin.sym} 23700 -12750 0 0 {name=p23509 lab=_56547_/X }
C {devices/lab_pin.sym} 23860 -12790 0 1 {name=p23510 lab=_74216_/X }
C {sky130_stdcells/a21o_4.sym} 23780 -12790 0 0 {name=X_74216_ }
C {devices/lab_pin.sym} 23740 -12650 0 0 {name=p23511 lab=_62522_/B }
C {devices/lab_pin.sym} 23820 -12650 0 1 {name=p23512 lab=_62233_/C }
C {sky130_stdcells/buf_2.sym} 23780 -12650 0 0 {name=X_62230_ }
C {devices/lab_pin.sym} 23720 -12540 0 0 {name=p23513 lab=_47943_/A }
C {devices/lab_pin.sym} 23720 -12500 0 0 {name=p23514 lab=_82876_/Q }
C {devices/lab_pin.sym} 23840 -12520 0 1 {name=p23515 lab=_40608_/X }
C {sky130_stdcells/or2_4.sym} 23780 -12520 0 0 {name=X_40608_ }
C {devices/lab_pin.sym} 23700 -12410 0 0 {name=p23516 lab=_47160_/Y }
C {devices/lab_pin.sym} 23700 -12370 0 0 {name=p23517 lab=_47128_/X }
C {devices/lab_pin.sym} 23700 -12330 0 0 {name=p23518 lab=_47163_/X }
C {devices/lab_pin.sym} 23860 -12370 0 1 {name=p23519 lab=_47164_/Y }
C {sky130_stdcells/a21oi_4.sym} 23780 -12370 0 0 {name=X_47164_ }
C {devices/lab_pin.sym} 23700 -12250 0 0 {name=p23520 lab=_71420_/X }
C {devices/lab_pin.sym} 23700 -12210 0 0 {name=p23521 lab=_83503_/Q }
C {devices/lab_pin.sym} 23700 -12170 0 0 {name=p23522 lab=_71427_/X }
C {devices/lab_pin.sym} 23860 -12210 0 1 {name=p23523 lab=_83503_/D }
C {sky130_stdcells/a21o_4.sym} 23780 -12210 0 0 {name=X_71428_ }
C {devices/lab_pin.sym} 23700 -12100 0 0 {name=p23524 lab=_41778_/X }
C {devices/lab_pin.sym} 23700 -12060 0 0 {name=p23525 lab=_44364_/X }
C {devices/lab_pin.sym} 23700 -12020 0 0 {name=p23526 lab=_87139_/Q }
C {devices/lab_pin.sym} 23700 -11980 0 0 {name=p23527 lab=_44365_/X }
C {devices/lab_pin.sym} 23860 -12040 0 1 {name=p23528 lab=_87139_/D }
C {sky130_stdcells/a2bb2o_4.sym} 23780 -12040 0 0 {name=X_44376_ }
C {devices/lab_pin.sym} 23700 -11910 0 0 {name=p23529 lab=_75192_/Y }
C {devices/lab_pin.sym} 23700 -11870 0 0 {name=p23530 lab=_75135_/Y }
C {devices/lab_pin.sym} 23700 -11830 0 0 {name=p23531 lab=_75195_/X }
C {devices/lab_pin.sym} 23860 -11870 0 1 {name=p23532 lab=_75196_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -11870 0 0 {name=X_75196_ }
C {devices/lab_pin.sym} 23740 -11730 0 0 {name=p23533 lab=_41411_/X }
C {devices/lab_pin.sym} 23820 -11730 0 1 {name=p23534 lab=_41588_/X }
C {sky130_stdcells/buf_2.sym} 23780 -11730 0 0 {name=X_41588_ }
C {devices/lab_pin.sym} 23720 -11620 0 0 {name=p23535 lab=_46115_/A }
C {devices/lab_pin.sym} 23720 -11580 0 0 {name=p23536 lab=_46094_/A }
C {devices/lab_pin.sym} 23840 -11600 0 1 {name=p23537 lab=_46204_/C }
C {sky130_stdcells/nor2_4.sym} 23780 -11600 0 0 {name=X_46115_ }
C {devices/lab_pin.sym} 23700 -11500 0 0 {name=p23538 lab=_41268_/X }
C {devices/lab_pin.sym} 23700 -11460 0 0 {name=p23539 lab=_43325_/X }
C {devices/lab_pin.sym} 23700 -11420 0 0 {name=p23540 lab=_87479_/Q }
C {devices/lab_pin.sym} 23700 -11380 0 0 {name=p23541 lab=_43326_/X }
C {devices/lab_pin.sym} 23860 -11440 0 1 {name=p23542 lab=_87479_/D }
C {sky130_stdcells/a2bb2o_4.sym} 23780 -11440 0 0 {name=X_43327_ }
C {devices/lab_pin.sym} 23720 -11320 0 0 {name=p23543 lab=_61673_/B }
C {devices/lab_pin.sym} 23720 -11280 0 0 {name=p23544 lab=_62161_/B }
C {devices/lab_pin.sym} 23720 -11240 0 0 {name=p23545 lab=_62187_/C }
C {devices/lab_pin.sym} 23720 -11200 0 0 {name=p23546 lab=_61706_/X }
C {devices/lab_pin.sym} 23840 -11260 0 1 {name=p23547 lab=_62161_/Y }
C {sky130_stdcells/nand4_4.sym} 23780 -11260 0 0 {name=X_62161_ }
C {devices/lab_pin.sym} 23700 -11130 0 0 {name=p23548 lab=_74144_/X }
C {devices/lab_pin.sym} 23700 -11090 0 0 {name=p23549 lab=_74146_/X }
C {devices/lab_pin.sym} 23700 -11050 0 0 {name=p23550 lab=_72737_/A }
C {devices/lab_pin.sym} 23860 -11090 0 1 {name=p23551 lab=_74147_/X }
C {sky130_stdcells/a21o_4.sym} 23780 -11090 0 0 {name=X_74147_ }
C {devices/lab_pin.sym} 23700 -10980 0 0 {name=p23552 lab=_40538_/X }
C {devices/lab_pin.sym} 23700 -10940 0 0 {name=p23553 lab=_40508_/X }
C {devices/lab_pin.sym} 23700 -10900 0 0 {name=p23554 lab=_88374_/Q }
C {devices/lab_pin.sym} 23700 -10860 0 0 {name=p23555 lab=_40510_/X }
C {devices/lab_pin.sym} 23860 -10920 0 1 {name=p23556 lab=_88374_/D }
C {sky130_stdcells/a2bb2o_4.sym} 23780 -10920 0 0 {name=X_40539_ }
C {devices/lab_pin.sym} 23700 -10790 0 0 {name=p23557 lab=_47090_/Y }
C {devices/lab_pin.sym} 23700 -10750 0 0 {name=p23558 lab=_47081_/X }
C {devices/lab_pin.sym} 23700 -10710 0 0 {name=p23559 lab=_47094_/X }
C {devices/lab_pin.sym} 23860 -10750 0 1 {name=p23560 lab=_86671_/D }
C {sky130_stdcells/a21oi_4.sym} 23780 -10750 0 0 {name=X_47095_ }
C {devices/lab_pin.sym} 23720 -10640 0 0 {name=p23561 lab=_71504_/C }
C {devices/lab_pin.sym} 23720 -10600 0 0 {name=p23562 lab=_71351_/X }
C {devices/lab_pin.sym} 23720 -10560 0 0 {name=p23563 lab=_70778_/A }
C {devices/lab_pin.sym} 23720 -10520 0 0 {name=p23564 lab=_71363_/D }
C {devices/lab_pin.sym} 23840 -10580 0 1 {name=p23565 lab=_71359_/X }
C {sky130_stdcells/and4_4.sym} 23780 -10580 0 0 {name=X_71359_ }
C {devices/lab_pin.sym} 23740 -10430 0 0 {name=p23566 lab=_61112_/A }
C {devices/lab_pin.sym} 23820 -10430 0 1 {name=p23567 lab=_61112_/X }
C {sky130_stdcells/buf_2.sym} 23780 -10430 0 0 {name=X_61112_ }
C {devices/lab_pin.sym} 23740 -10310 0 0 {name=p23568 lab=_40556_/A }
C {devices/lab_pin.sym} 23820 -10310 0 1 {name=p23569 lab=_46046_/X }
C {sky130_stdcells/buf_2.sym} 23780 -10310 0 0 {name=X_46046_ }
C {devices/lab_pin.sym} 23700 -10230 0 0 {name=p23570 lab=_43241_/X }
C {devices/lab_pin.sym} 23700 -10190 0 0 {name=p23571 lab=_43244_/X }
C {devices/lab_pin.sym} 23700 -10150 0 0 {name=p23572 lab=_41082_/X }
C {devices/lab_pin.sym} 23700 -10110 0 0 {name=p23573 lab=_87513_/Q }
C {devices/lab_pin.sym} 23700 -10070 0 0 {name=p23574 lab=_43250_/X }
C {devices/lab_pin.sym} 23860 -10150 0 1 {name=p23575 lab=_43259_/A }
C {sky130_stdcells/o32ai_4.sym} 23780 -10150 0 0 {name=X_43258_ }
C {devices/lab_pin.sym} 23720 -10020 0 0 {name=p23576 lab=_62055_/A }
C {devices/lab_pin.sym} 23720 -9980 0 0 {name=p23577 lab=_84913_/Q }
C {devices/lab_pin.sym} 23720 -9940 0 0 {name=p23578 lab=_61755_/X }
C {devices/lab_pin.sym} 23720 -9900 0 0 {name=p23579 lab=_61728_/A }
C {devices/lab_pin.sym} 23840 -9960 0 1 {name=p23580 lab=_62092_/X }
C {sky130_stdcells/and4_4.sym} 23780 -9960 0 0 {name=X_62092_ }
C {devices/lab_pin.sym} 23700 -9830 0 0 {name=p23581 lab=_78940_/A }
C {devices/lab_pin.sym} 23700 -9790 0 0 {name=p23582 lab=_82513_/D }
C {devices/lab_pin.sym} 23700 -9750 0 0 {name=p23583 lab=_78954_/X }
C {devices/lab_pin.sym} 23860 -9790 0 1 {name=p23584 lab=_78956_/B }
C {sky130_stdcells/o21ai_4.sym} 23780 -9790 0 0 {name=X_78955_ }
C {devices/lab_pin.sym} 23700 -9670 0 0 {name=p23585 lab=_44725_/Y }
C {devices/lab_pin.sym} 23700 -9630 0 0 {name=p23586 lab=_73491_/X }
C {devices/lab_pin.sym} 23700 -9590 0 0 {name=p23587 lab=_74077_/Y }
C {devices/lab_pin.sym} 23860 -9630 0 1 {name=p23588 lab=_74078_/X }
C {sky130_stdcells/a21o_4.sym} 23780 -9630 0 0 {name=X_74078_ }
C {devices/lab_pin.sym} 23740 -9490 0 0 {name=p23589 lab=_42258_/A }
C {devices/lab_pin.sym} 23820 -9490 0 1 {name=p23590 lab=_42209_/X }
C {sky130_stdcells/buf_2.sym} 23780 -9490 0 0 {name=X_42209_ }
C {devices/lab_pin.sym} 23700 -9400 0 0 {name=p23591 lab=_65654_/X }
C {devices/lab_pin.sym} 23700 -9360 0 0 {name=p23592 lab=_86240_/Q }
C {devices/lab_pin.sym} 23700 -9320 0 0 {name=p23593 lab=_65761_/X }
C {devices/lab_pin.sym} 23700 -9280 0 0 {name=p23594 lab=_65919_/X }
C {devices/lab_pin.sym} 23860 -9340 0 1 {name=p23595 lab=_65920_/X }
C {sky130_stdcells/a211o_4.sym} 23780 -9340 0 0 {name=X_65920_ }
C {devices/lab_pin.sym} 23700 -9230 0 0 {name=p23596 lab=_61004_/Y }
C {devices/lab_pin.sym} 23700 -9190 0 0 {name=p23597 lab=_61030_/Y }
C {devices/lab_pin.sym} 23700 -9150 0 0 {name=p23598 lab=_61042_/Y }
C {devices/lab_pin.sym} 23700 -9110 0 0 {name=p23599 lab=_84530_/Q }
C {devices/lab_pin.sym} 23700 -9070 0 0 {name=p23600 lab=_59509_/X }
C {devices/lab_pin.sym} 23860 -9150 0 1 {name=p23601 lab=_61043_/X }
C {sky130_stdcells/o32a_4.sym} 23780 -9150 0 0 {name=X_61043_ }
C {devices/lab_pin.sym} 23740 -8990 0 0 {name=p23602 lab=_77906_/A }
C {devices/lab_pin.sym} 23820 -8990 0 1 {name=p23603 lab=_77908_/A }
C {sky130_stdcells/inv_2.sym} 23780 -8990 0 0 {name=X_77906_ }
C {devices/lab_pin.sym} 23700 -8890 0 0 {name=p23604 lab=_88329_/Q }
C {devices/lab_pin.sym} 23700 -8850 0 0 {name=p23605 lab=_73026_/X }
C {devices/lab_pin.sym} 23700 -8810 0 0 {name=p23606 lab=_73028_/X }
C {devices/lab_pin.sym} 23860 -8850 0 1 {name=p23607 lab=_73029_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -8850 0 0 {name=X_73029_ }
C {devices/lab_pin.sym} 23740 -8710 0 0 {name=p23608 lab=_43189_/A }
C {devices/lab_pin.sym} 23820 -8710 0 1 {name=p23609 lab=_53944_/A }
C {sky130_stdcells/buf_2.sym} 23780 -8710 0 0 {name=X_43189_ }
C {devices/lab_pin.sym} 23720 -8600 0 0 {name=p23610 lab=_78886_/A }
C {devices/lab_pin.sym} 23720 -8560 0 0 {name=p23611 lab=_78896_/A }
C {devices/lab_pin.sym} 23840 -8580 0 1 {name=p23612 lab=_78886_/Y }
C {sky130_stdcells/nor2_4.sym} 23780 -8580 0 0 {name=X_78886_ }
C {devices/lab_pin.sym} 23700 -8470 0 0 {name=p23613 lab=_57958_/B }
C {devices/lab_pin.sym} 23700 -8430 0 0 {name=p23614 lab=_49798_/X }
C {devices/lab_pin.sym} 23700 -8390 0 0 {name=p23615 lab=_49804_/Y }
C {devices/lab_pin.sym} 23860 -8430 0 1 {name=p23616 lab=_49805_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -8430 0 0 {name=X_49805_ }
C {devices/lab_pin.sym} 23720 -8300 0 0 {name=p23617 lab=_65812_/A }
C {devices/lab_pin.sym} 23720 -8260 0 0 {name=p23618 lab=_86501_/Q }
C {devices/lab_pin.sym} 23840 -8280 0 1 {name=p23619 lab=_65851_/X }
C {sky130_stdcells/and2_4.sym} 23780 -8280 0 0 {name=X_65851_ }
C {devices/lab_pin.sym} 23740 -8150 0 0 {name=p23620 lab=_77826_/Y }
C {devices/lab_pin.sym} 23820 -8150 0 1 {name=p23621 lab=_81933_/D }
C {sky130_stdcells/inv_2.sym} 23780 -8150 0 0 {name=X_77837_ }
C {devices/lab_pin.sym} 23700 -8050 0 0 {name=p23622 lab=_47989_/Y }
C {devices/lab_pin.sym} 23700 -8010 0 0 {name=p23623 lab=_47954_/X }
C {devices/lab_pin.sym} 23700 -7970 0 0 {name=p23624 lab=_47996_/X }
C {devices/lab_pin.sym} 23860 -8010 0 1 {name=p23625 lab=_47997_/Y }
C {sky130_stdcells/a21oi_4.sym} 23780 -8010 0 0 {name=X_47997_ }
C {devices/lab_pin.sym} 23700 -7900 0 0 {name=p23626 lab=_64650_/X }
C {devices/lab_pin.sym} 23700 -7860 0 0 {name=p23627 lab=_86170_/Q }
C {devices/lab_pin.sym} 23700 -7820 0 0 {name=p23628 lab=_64776_/X }
C {devices/lab_pin.sym} 23700 -7780 0 0 {name=p23629 lab=_64801_/X }
C {devices/lab_pin.sym} 23860 -7840 0 1 {name=p23630 lab=_64802_/X }
C {sky130_stdcells/a211o_4.sym} 23780 -7840 0 0 {name=X_64802_ }
C {devices/lab_pin.sym} 23720 -7700 0 0 {name=p23631 lab=_49716_/X }
C {devices/lab_pin.sym} 23720 -7660 0 0 {name=p23632 lab=_52950_/B }
C {devices/lab_pin.sym} 23840 -7680 0 1 {name=p23633 lab=_49736_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -7680 0 0 {name=X_49736_ }
C {devices/lab_pin.sym} 23740 -7550 0 0 {name=p23634 lab=_69796_/A }
C {devices/lab_pin.sym} 23820 -7550 0 1 {name=p23635 lab=_68570_/X }
C {sky130_stdcells/buf_2.sym} 23780 -7550 0 0 {name=X_68570_ }
C {devices/lab_pin.sym} 23720 -7440 0 0 {name=p23636 lab=_46948_/A }
C {devices/lab_pin.sym} 23720 -7400 0 0 {name=p23637 lab=_52768_/B }
C {devices/lab_pin.sym} 23840 -7420 0 1 {name=p23638 lab=_46948_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -7420 0 0 {name=X_46948_ }
C {devices/lab_pin.sym} 23740 -7290 0 0 {name=p23639 lab=_65782_/A }
C {devices/lab_pin.sym} 23820 -7290 0 1 {name=p23640 lab=_65812_/A }
C {sky130_stdcells/buf_2.sym} 23780 -7290 0 0 {name=X_65782_ }
C {devices/lab_pin.sym} 23720 -7180 0 0 {name=p23641 lab=_82150_/Q }
C {devices/lab_pin.sym} 23720 -7140 0 0 {name=p23642 lab=_77768_/B }
C {devices/lab_pin.sym} 23840 -7160 0 1 {name=p23643 lab=_77768_/X }
C {sky130_stdcells/xor2_4.sym} 23780 -7160 0 0 {name=X_77768_ }
C {devices/lab_pin.sym} 23740 -7030 0 0 {name=p23644 lab=_63306_/A }
C {devices/lab_pin.sym} 23820 -7030 0 1 {name=p23645 lab=_63285_/B }
C {sky130_stdcells/buf_2.sym} 23780 -7030 0 0 {name=X_62994_ }
C {devices/lab_pin.sym} 23700 -6930 0 0 {name=p23646 lab=_81498_/D }
C {devices/lab_pin.sym} 23700 -6890 0 0 {name=p23647 lab=_67449_/X }
C {devices/lab_pin.sym} 23700 -6850 0 0 {name=p23648 lab=_67520_/X }
C {devices/lab_pin.sym} 23860 -6890 0 1 {name=p23649 lab=_84066_/D }
C {sky130_stdcells/a21bo_4.sym} 23780 -6890 0 0 {name=X_67521_ }
C {devices/lab_pin.sym} 23700 -6770 0 0 {name=p23650 lab=_79491_/Y }
C {devices/lab_pin.sym} 23700 -6730 0 0 {name=p23651 lab=_79494_/Y }
C {devices/lab_pin.sym} 23700 -6690 0 0 {name=p23652 lab=_79506_/X }
C {devices/lab_pin.sym} 23860 -6730 0 1 {name=p23653 lab=_79507_/X }
C {sky130_stdcells/a21o_4.sym} 23780 -6730 0 0 {name=X_79507_ }
C {devices/lab_pin.sym} 23740 -6590 0 0 {name=p23654 lab=_64600_/A }
C {devices/lab_pin.sym} 23820 -6590 0 1 {name=p23655 lab=_64733_/X }
C {sky130_stdcells/buf_2.sym} 23780 -6590 0 0 {name=X_64733_ }
C {devices/lab_pin.sym} 23720 -6480 0 0 {name=p23656 lab=_76719_/A }
C {devices/lab_pin.sym} 23720 -6440 0 0 {name=p23657 lab=_76718_/Y }
C {devices/lab_pin.sym} 23840 -6460 0 1 {name=p23658 lab=_76719_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -6460 0 0 {name=X_76719_ }
C {devices/lab_pin.sym} 23700 -6350 0 0 {name=p23659 lab=_86345_/Q }
C {devices/lab_pin.sym} 23700 -6310 0 0 {name=p23660 lab=_49660_/X }
C {devices/lab_pin.sym} 23700 -6270 0 0 {name=p23661 lab=_49666_/Y }
C {devices/lab_pin.sym} 23860 -6310 0 1 {name=p23662 lab=_49667_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -6310 0 0 {name=X_49667_ }
C {devices/lab_pin.sym} 23740 -6170 0 0 {name=p23663 lab=_59765_/A }
C {devices/lab_pin.sym} 23820 -6170 0 1 {name=p23664 lab=_61945_/X }
C {sky130_stdcells/buf_2.sym} 23780 -6170 0 0 {name=X_61945_ }
C {devices/lab_pin.sym} 23740 -6050 0 0 {name=p23665 lab=_52726_/B }
C {devices/lab_pin.sym} 23820 -6050 0 1 {name=p23666 lab=_51037_/B }
C {sky130_stdcells/buf_2.sym} 23780 -6050 0 0 {name=X_46879_ }
C {devices/lab_pin.sym} 23720 -5940 0 0 {name=p23667 lab=_77712_/A }
C {devices/lab_pin.sym} 23720 -5900 0 0 {name=p23668 lab=_82124_/Q }
C {devices/lab_pin.sym} 23840 -5920 0 1 {name=p23669 lab=_77699_/X }
C {sky130_stdcells/xor2_4.sym} 23780 -5920 0 0 {name=X_77699_ }
C {devices/lab_pin.sym} 23740 -5790 0 0 {name=p23670 lab=_81770_/Q }
C {devices/lab_pin.sym} 23820 -5790 0 1 {name=p23671 lab=_48618_/Y }
C {sky130_stdcells/inv_2.sym} 23780 -5790 0 0 {name=X_48618_ }
C {devices/lab_pin.sym} 23700 -5700 0 0 {name=p23672 lab=_87982_/Q }
C {devices/lab_pin.sym} 23700 -5660 0 0 {name=p23673 lab=_67355_/X }
C {devices/lab_pin.sym} 23700 -5620 0 0 {name=p23674 lab=_67405_/X }
C {devices/lab_pin.sym} 23700 -5580 0 0 {name=p23675 lab=_67451_/X }
C {devices/lab_pin.sym} 23860 -5640 0 1 {name=p23676 lab=_67452_/X }
C {sky130_stdcells/a211o_4.sym} 23780 -5640 0 0 {name=X_67452_ }
C {devices/lab_pin.sym} 23720 -5500 0 0 {name=p23677 lab=_79438_/A }
C {devices/lab_pin.sym} 23720 -5460 0 0 {name=p23678 lab=_79438_/B }
C {devices/lab_pin.sym} 23840 -5480 0 1 {name=p23679 lab=_79459_/A }
C {sky130_stdcells/xor2_4.sym} 23780 -5480 0 0 {name=X_79438_ }
C {devices/lab_pin.sym} 23700 -5370 0 0 {name=p23680 lab=_64661_/Y }
C {devices/lab_pin.sym} 23700 -5330 0 0 {name=p23681 lab=_64662_/X }
C {devices/lab_pin.sym} 23700 -5290 0 0 {name=p23682 lab=_64663_/X }
C {devices/lab_pin.sym} 23860 -5330 0 1 {name=p23683 lab=_84231_/D }
C {sky130_stdcells/a21o_4.sym} 23780 -5330 0 0 {name=X_64664_ }
C {devices/lab_pin.sym} 23720 -5220 0 0 {name=p23684 lab=_49610_/A }
C {devices/lab_pin.sym} 23720 -5180 0 0 {name=p23685 lab=_49592_/B }
C {devices/lab_pin.sym} 23720 -5140 0 0 {name=p23686 lab=_49577_/C }
C {devices/lab_pin.sym} 23720 -5100 0 0 {name=p23687 lab=_52811_/D }
C {devices/lab_pin.sym} 23840 -5160 0 1 {name=p23688 lab=_49598_/X }
C {sky130_stdcells/and4_4.sym} 23780 -5160 0 0 {name=X_49598_ }
C {devices/lab_pin.sym} 23740 -5010 0 0 {name=p23689 lab=_84880_/Q }
C {devices/lab_pin.sym} 23820 -5010 0 1 {name=p23690 lab=_61876_/X }
C {sky130_stdcells/buf_2.sym} 23780 -5010 0 0 {name=X_61876_ }
C {devices/lab_pin.sym} 23700 -4910 0 0 {name=p23691 lab=_66399_/Y }
C {devices/lab_pin.sym} 23700 -4870 0 0 {name=p23692 lab=_66377_/X }
C {devices/lab_pin.sym} 23700 -4830 0 0 {name=p23693 lab=_66402_/Y }
C {devices/lab_pin.sym} 23860 -4870 0 1 {name=p23694 lab=_84130_/D }
C {sky130_stdcells/a21o_4.sym} 23780 -4870 0 0 {name=X_66403_ }
C {devices/lab_pin.sym} 23720 -4750 0 0 {name=p23695 lab=_63615_/A }
C {devices/lab_pin.sym} 23720 -4710 0 0 {name=p23696 lab=_63615_/B }
C {devices/lab_pin.sym} 23720 -4670 0 0 {name=p23697 lab=_80413_/B }
C {devices/lab_pin.sym} 23840 -4710 0 1 {name=p23698 lab=_63615_/Y }
C {sky130_stdcells/nor3_4.sym} 23780 -4710 0 0 {name=X_63615_ }
C {devices/lab_pin.sym} 23740 -4570 0 0 {name=p23699 lab=_49223_/A }
C {devices/lab_pin.sym} 23820 -4570 0 1 {name=p23700 lab=_49212_/A }
C {sky130_stdcells/buf_2.sym} 23780 -4570 0 0 {name=X_48549_ }
C {devices/lab_pin.sym} 23700 -4490 0 0 {name=p23701 lab=_60692_/X }
C {devices/lab_pin.sym} 23700 -4450 0 0 {name=p23702 lab=_60825_/Y }
C {devices/lab_pin.sym} 23700 -4410 0 0 {name=p23703 lab=_60708_/Y }
C {devices/lab_pin.sym} 23700 -4370 0 0 {name=p23704 lab=_60795_/X }
C {devices/lab_pin.sym} 23700 -4340 0 0 {name=p23705 lab=_60826_/Y }
C {devices/lab_pin.sym} 23860 -4410 0 1 {name=p23706 lab=_84557_/D }
C {sky130_stdcells/a41oi_4.sym} 23780 -4410 0 0 {name=X_60827_ }
C {devices/lab_pin.sym} 23740 -4250 0 0 {name=p23707 lab=_67025_/X }
C {devices/lab_pin.sym} 23820 -4250 0 1 {name=p23708 lab=_67383_/X }
C {sky130_stdcells/buf_2.sym} 23780 -4250 0 0 {name=X_67383_ }
C {devices/lab_pin.sym} 23720 -4140 0 0 {name=p23709 lab=_79362_/X }
C {devices/lab_pin.sym} 23720 -4100 0 0 {name=p23710 lab=_79369_/B }
C {devices/lab_pin.sym} 23840 -4120 0 1 {name=p23711 lab=_79369_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -4120 0 0 {name=X_79369_ }
C {devices/lab_pin.sym} 23700 -4010 0 0 {name=p23712 lab=_64588_/X }
C {devices/lab_pin.sym} 23700 -3970 0 0 {name=p23713 lab=_64594_/X }
C {devices/lab_pin.sym} 23700 -3930 0 0 {name=p23714 lab=_59297_/A }
C {devices/lab_pin.sym} 23860 -3970 0 1 {name=p23715 lab=_64595_/X }
C {sky130_stdcells/a21o_4.sym} 23780 -3970 0 0 {name=X_64595_ }
C {devices/lab_pin.sym} 23690 -3830 0 0 {name=p23716 lab=_81351_/CLK }
C {devices/lab_pin.sym} 23690 -3810 0 0 {name=p23717 lab=_81400_/D }
C {devices/lab_pin.sym} 23870 -3830 0 1 {name=p23718 lab=_76696_/B }
C {sky130_stdcells/dfxtp_4.sym} 23780 -3820 0 0 {name=X_81400_ }
C {devices/lab_pin.sym} 23720 -3700 0 0 {name=p23719 lab=_69134_/A }
C {devices/lab_pin.sym} 23720 -3660 0 0 {name=p23720 lab=_69122_/B }
C {devices/lab_pin.sym} 23840 -3680 0 1 {name=p23721 lab=_69122_/X }
C {sky130_stdcells/and2_4.sym} 23780 -3680 0 0 {name=X_69122_ }
C {devices/lab_pin.sym} 23720 -3560 0 0 {name=p23722 lab=_57694_/X }
C {devices/lab_pin.sym} 23720 -3520 0 0 {name=p23723 lab=_66334_/B }
C {devices/lab_pin.sym} 23840 -3540 0 1 {name=p23724 lab=_66334_/X }
C {sky130_stdcells/and2_4.sym} 23780 -3540 0 0 {name=X_66334_ }
C {devices/lab_pin.sym} 23700 -3430 0 0 {name=p23725 lab=_51556_/Y }
C {devices/lab_pin.sym} 23700 -3390 0 0 {name=p23726 lab=_51557_/X }
C {devices/lab_pin.sym} 23700 -3350 0 0 {name=p23727 lab=_51559_/X }
C {devices/lab_pin.sym} 23860 -3390 0 1 {name=p23728 lab=_85988_/D }
C {sky130_stdcells/a21oi_4.sym} 23780 -3390 0 0 {name=X_51560_ }
C {devices/lab_pin.sym} 23720 -3280 0 0 {name=p23729 lab=_63546_/A }
C {devices/lab_pin.sym} 23720 -3240 0 0 {name=p23730 lab=_58533_/A }
C {devices/lab_pin.sym} 23720 -3200 0 0 {name=p23731 lab=_63520_/C }
C {devices/lab_pin.sym} 23720 -3160 0 0 {name=p23732 lab=_63546_/D }
C {devices/lab_pin.sym} 23840 -3220 0 1 {name=p23733 lab=_63546_/X }
C {sky130_stdcells/and4_4.sym} 23780 -3220 0 0 {name=X_63546_ }
C {devices/lab_pin.sym} 23690 -3070 0 0 {name=p23734 lab=_82381_/CLK }
C {devices/lab_pin.sym} 23690 -3050 0 0 {name=p23735 lab=_82188_/Q }
C {devices/lab_pin.sym} 23870 -3070 0 1 {name=p23736 lab=_82380_/Q }
C {sky130_stdcells/dfxtp_4.sym} 23780 -3060 0 0 {name=X_82380_ }
C {devices/lab_pin.sym} 23740 -2930 0 0 {name=p23737 lab=_60703_/Y }
C {devices/lab_pin.sym} 23820 -2930 0 1 {name=p23738 lab=_60758_/X }
C {sky130_stdcells/buf_2.sym} 23780 -2930 0 0 {name=X_60758_ }
C {devices/lab_pin.sym} 23720 -2830 0 0 {name=p23739 lab=_50511_/A }
C {devices/lab_pin.sym} 23720 -2790 0 0 {name=p23740 lab=_50526_/B }
C {devices/lab_pin.sym} 23720 -2750 0 0 {name=p23741 lab=_50526_/C }
C {devices/lab_pin.sym} 23840 -2790 0 1 {name=p23742 lab=_50511_/X }
C {sky130_stdcells/and3_4.sym} 23780 -2790 0 0 {name=X_50511_ }
C {devices/lab_pin.sym} 23690 -2650 0 0 {name=p23743 lab=_83926_/CLK }
C {devices/lab_pin.sym} 23690 -2630 0 0 {name=p23744 lab=_76407_/X }
C {devices/lab_pin.sym} 23870 -2650 0 1 {name=p23745 lab=_81707_/D }
C {sky130_stdcells/dfxtp_4.sym} 23780 -2640 0 0 {name=X_81331_ }
C {devices/lab_pin.sym} 23720 -2520 0 0 {name=p23746 lab=_69735_/A }
C {devices/lab_pin.sym} 23720 -2480 0 0 {name=p23747 lab=_69053_/B }
C {devices/lab_pin.sym} 23840 -2500 0 1 {name=p23748 lab=_69053_/Y }
C {sky130_stdcells/nor2_4.sym} 23780 -2500 0 0 {name=X_69053_ }
C {devices/lab_pin.sym} 23700 -2390 0 0 {name=p23749 lab=_66261_/Y }
C {devices/lab_pin.sym} 23700 -2350 0 0 {name=p23750 lab=_66205_/X }
C {devices/lab_pin.sym} 23700 -2310 0 0 {name=p23751 lab=_66264_/Y }
C {devices/lab_pin.sym} 23860 -2350 0 1 {name=p23752 lab=_84145_/D }
C {sky130_stdcells/a21o_4.sym} 23780 -2350 0 0 {name=X_66265_ }
C {devices/lab_pin.sym} 23720 -2220 0 0 {name=p23753 lab=_51491_/A }
C {devices/lab_pin.sym} 23720 -2180 0 0 {name=p23754 lab=_53017_/B }
C {devices/lab_pin.sym} 23840 -2200 0 1 {name=p23755 lab=_51491_/Y }
C {sky130_stdcells/nand2_4.sym} 23780 -2200 0 0 {name=X_51491_ }
C {devices/lab_pin.sym} 23700 -2100 0 0 {name=p23756 lab=_61437_/B }
C {devices/lab_pin.sym} 23700 -2060 0 0 {name=p23757 lab=_63426_/X }
C {devices/lab_pin.sym} 23700 -2020 0 0 {name=p23758 lab=_63474_/X }
C {devices/lab_pin.sym} 23700 -1980 0 0 {name=p23759 lab=_63476_/X }
C {devices/lab_pin.sym} 23860 -2040 0 1 {name=p23760 lab=_63477_/X }
C {sky130_stdcells/a211o_4.sym} 23780 -2040 0 0 {name=X_63477_ }
C {devices/lab_pin.sym} 23700 -1910 0 0 {name=p23761 lab=_60632_/X }
C {devices/lab_pin.sym} 23700 -1870 0 0 {name=p23762 lab=_60714_/A }
C {devices/lab_pin.sym} 23700 -1830 0 0 {name=p23763 lab=_60713_/A }
C {devices/lab_pin.sym} 23860 -1870 0 1 {name=p23764 lab=_60689_/Y }
C {sky130_stdcells/o21ai_4.sym} 23780 -1870 0 0 {name=X_60689_ }
C {devices/lab_pin.sym} 23700 -1760 0 0 {name=p23765 lab=_86947_/Q }
C {devices/lab_pin.sym} 23700 -1720 0 0 {name=p23766 lab=_67906_/X }
C {devices/lab_pin.sym} 23700 -1680 0 0 {name=p23767 lab=_67908_/X }
C {devices/lab_pin.sym} 23700 -1640 0 0 {name=p23768 lab=_68003_/X }
C {devices/lab_pin.sym} 23860 -1700 0 1 {name=p23769 lab=_68004_/X }
C {sky130_stdcells/a211o_4.sym} 23780 -1700 0 0 {name=X_68004_ }
C {devices/lab_pin.sym} 23720 -1580 0 0 {name=p23770 lab=_53217_/A }
C {devices/lab_pin.sym} 23720 -1540 0 0 {name=p23771 lab=_53244_/B }
C {devices/lab_pin.sym} 23720 -1500 0 0 {name=p23772 lab=_53222_/X }
C {devices/lab_pin.sym} 23720 -1460 0 0 {name=p23773 lab=_53230_/D }
C {devices/lab_pin.sym} 23840 -1520 0 1 {name=p23774 lab=_53230_/X }
C {sky130_stdcells/and4_4.sym} 23780 -1520 0 0 {name=X_53230_ }
C {devices/lab_pin.sym} 23720 -1380 0 0 {name=p23775 lab=_65164_/A }
C {devices/lab_pin.sym} 23720 -1340 0 0 {name=p23776 lab=_86410_/Q }
C {devices/lab_pin.sym} 23840 -1360 0 1 {name=p23777 lab=_65216_/X }
C {sky130_stdcells/and2_4.sym} 23780 -1360 0 0 {name=X_65216_ }
C {devices/lab_pin.sym} 23690 -1230 0 0 {name=p23778 lab=_84049_/CLK }
C {devices/lab_pin.sym} 23690 -1210 0 0 {name=p23779 lab=_84050_/D }
C {devices/lab_pin.sym} 23870 -1230 0 1 {name=p23780 lab=_81482_/D }
C {sky130_stdcells/dfxtp_4.sym} 23780 -1220 0 0 {name=X_84050_ }
C {devices/lab_pin.sym} 23740 -1090 0 0 {name=p23781 lab=_50510_/A }
C {devices/lab_pin.sym} 23820 -1090 0 1 {name=p23782 lab=_50462_/C }
C {sky130_stdcells/buf_2.sym} 23780 -1090 0 0 {name=X_50442_ }
C {devices/lab_pin.sym} 23740 -970 0 0 {name=p23783 lab=_62193_/A }
C {devices/lab_pin.sym} 23820 -970 0 1 {name=p23784 lab=_62608_/D }
C {sky130_stdcells/buf_2.sym} 23780 -970 0 0 {name=X_62428_ }
C {devices/lab_pin.sym} 23690 -850 0 0 {name=p23785 lab=_81296_/CLK }
C {devices/lab_pin.sym} 23690 -830 0 0 {name=p23786 lab=_81262_/D }
C {devices/lab_pin.sym} 23870 -850 0 1 {name=p23787 lab=_76328_/A }
C {sky130_stdcells/dfxtp_4.sym} 23780 -840 0 0 {name=X_81262_ }
C {devices/lab_pin.sym} 23720 -720 0 0 {name=p23788 lab=_65763_/A }
C {devices/lab_pin.sym} 23720 -680 0 0 {name=p23789 lab=_85901_/Q }
C {devices/lab_pin.sym} 23840 -700 0 1 {name=p23790 lab=_66196_/X }
C {sky130_stdcells/and2_4.sym} 23780 -700 0 0 {name=X_66196_ }
C {devices/lab_pin.sym} 24610 -42150 0 0 {name=p23791 lab=_83001_/CLK }
C {devices/lab_pin.sym} 24610 -42130 0 0 {name=p23792 lab=_83001_/D }
C {devices/lab_pin.sym} 24790 -42150 0 1 {name=p23793 lab=_45526_/A }
C {sky130_stdcells/dfxtp_4.sym} 24700 -42140 0 0 {name=X_83001_ }
C {devices/lab_pin.sym} 24620 -42030 0 0 {name=p23794 lab=_57753_/Y }
C {devices/lab_pin.sym} 24620 -41990 0 0 {name=p23795 lab=_65498_/C }
C {devices/lab_pin.sym} 24620 -41950 0 0 {name=p23796 lab=_80212_/Y }
C {devices/lab_pin.sym} 24780 -41990 0 1 {name=p23797 lab=_80213_/X }
C {sky130_stdcells/o21a_4.sym} 24700 -41990 0 0 {name=X_80213_ }
C {devices/lab_pin.sym} 24640 -41860 0 0 {name=p23798 lab=_53147_/X }
C {devices/lab_pin.sym} 24640 -41820 0 0 {name=p23799 lab=_53161_/B }
C {devices/lab_pin.sym} 24760 -41840 0 1 {name=p23800 lab=_53161_/Y }
C {sky130_stdcells/nand2_4.sym} 24700 -41840 0 0 {name=X_53161_ }
C {devices/lab_pin.sym} 24640 -41720 0 0 {name=p23801 lab=_65227_/A }
C {devices/lab_pin.sym} 24640 -41680 0 0 {name=p23802 lab=_65147_/B }
C {devices/lab_pin.sym} 24760 -41700 0 1 {name=p23803 lab=_65147_/X }
C {sky130_stdcells/and2_4.sym} 24700 -41700 0 0 {name=X_65147_ }
C {devices/lab_pin.sym} 24620 -41590 0 0 {name=p23804 lab=_50371_/Y }
C {devices/lab_pin.sym} 24620 -41550 0 0 {name=p23805 lab=_50351_/X }
C {devices/lab_pin.sym} 24620 -41510 0 0 {name=p23806 lab=_50372_/Y }
C {devices/lab_pin.sym} 24780 -41550 0 1 {name=p23807 lab=_50373_/Y }
C {sky130_stdcells/a21boi_4.sym} 24700 -41550 0 0 {name=X_50373_ }
C {devices/lab_pin.sym} 24640 -41430 0 0 {name=p23808 lab=_62319_/A }
C {devices/lab_pin.sym} 24640 -41390 0 0 {name=p23809 lab=_58511_/A }
C {devices/lab_pin.sym} 24640 -41350 0 0 {name=p23810 lab=_62319_/C }
C {devices/lab_pin.sym} 24760 -41390 0 1 {name=p23811 lab=_62359_/Y }
C {sky130_stdcells/nand3_4.sym} 24700 -41390 0 0 {name=X_62359_ }
C {devices/lab_pin.sym} 24610 -41250 0 0 {name=p23812 lab=_81190_/CLK }
C {devices/lab_pin.sym} 24610 -41230 0 0 {name=p23813 lab=_74949_/X }
C {devices/lab_pin.sym} 24790 -41250 0 1 {name=p23814 lab=_49129_/A }
C {sky130_stdcells/dfxtp_4.sym} 24700 -41240 0 0 {name=X_81193_ }
C {devices/lab_pin.sym} 24620 -41130 0 0 {name=p23815 lab=_72836_/B }
C {devices/lab_pin.sym} 24620 -41090 0 0 {name=p23816 lab=_52089_/X }
C {devices/lab_pin.sym} 24620 -41050 0 0 {name=p23817 lab=_52111_/Y }
C {devices/lab_pin.sym} 24780 -41090 0 1 {name=p23818 lab=_52112_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -41090 0 0 {name=X_52112_ }
C {devices/lab_pin.sym} 24640 -40960 0 0 {name=p23819 lab=_60047_/C }
C {devices/lab_pin.sym} 24640 -40920 0 0 {name=p23820 lab=_63914_/C }
C {devices/lab_pin.sym} 24760 -40940 0 1 {name=p23821 lab=_80144_/X }
C {sky130_stdcells/xor2_4.sym} 24700 -40940 0 0 {name=X_80144_ }
C {devices/lab_pin.sym} 24660 -40810 0 0 {name=p23822 lab=_52126_/A }
C {devices/lab_pin.sym} 24740 -40810 0 1 {name=p23823 lab=_53172_/A }
C {sky130_stdcells/buf_2.sym} 24700 -40810 0 0 {name=X_53092_ }
C {devices/lab_pin.sym} 24620 -40710 0 0 {name=p23824 lab=_65075_/X }
C {devices/lab_pin.sym} 24620 -40670 0 0 {name=p23825 lab=_65077_/X }
C {devices/lab_pin.sym} 24620 -40630 0 0 {name=p23826 lab=_64574_/X }
C {devices/lab_pin.sym} 24780 -40670 0 1 {name=p23827 lab=_65078_/X }
C {sky130_stdcells/a21o_4.sym} 24700 -40670 0 0 {name=X_65078_ }
C {devices/lab_pin.sym} 24660 -40530 0 0 {name=p23828 lab=_69988_/A }
C {devices/lab_pin.sym} 24740 -40530 0 1 {name=p23829 lab=_69955_/X }
C {sky130_stdcells/buf_2.sym} 24700 -40530 0 0 {name=X_69955_ }
C {devices/lab_pin.sym} 24640 -40420 0 0 {name=p23830 lab=_52070_/A }
C {devices/lab_pin.sym} 24640 -40380 0 0 {name=p23831 lab=_50341_/B }
C {devices/lab_pin.sym} 24760 -40400 0 1 {name=p23832 lab=_52043_/Y }
C {sky130_stdcells/nand2_4.sym} 24700 -40400 0 0 {name=X_52043_ }
C {devices/lab_pin.sym} 24640 -40280 0 0 {name=p23833 lab=_56552_/Y }
C {devices/lab_pin.sym} 24640 -40240 0 0 {name=p23834 lab=_56920_/B }
C {devices/lab_pin.sym} 24760 -40260 0 1 {name=p23835 lab=_56921_/C }
C {sky130_stdcells/nand2_4.sym} 24700 -40260 0 0 {name=X_56920_ }
C {devices/lab_pin.sym} 24620 -40150 0 0 {name=p23836 lab=_83956_/Q }
C {devices/lab_pin.sym} 24620 -40110 0 0 {name=p23837 lab=_68838_/X }
C {devices/lab_pin.sym} 24620 -40070 0 0 {name=p23838 lab=_68905_/X }
C {devices/lab_pin.sym} 24780 -40110 0 1 {name=p23839 lab=_83956_/D }
C {sky130_stdcells/a21bo_4.sym} 24700 -40110 0 0 {name=X_68906_ }
C {devices/lab_pin.sym} 24640 -40000 0 0 {name=p23840 lab=_64420_/B }
C {devices/lab_pin.sym} 24640 -39960 0 0 {name=p23841 lab=_64029_/B }
C {devices/lab_pin.sym} 24640 -39920 0 0 {name=p23842 lab=_64029_/C }
C {devices/lab_pin.sym} 24640 -39880 0 0 {name=p23843 lab=_64029_/D }
C {devices/lab_pin.sym} 24760 -39940 0 1 {name=p23844 lab=_64029_/Y }
C {sky130_stdcells/nand4_4.sym} 24700 -39940 0 0 {name=X_64029_ }
C {devices/lab_pin.sym} 24610 -39790 0 0 {name=p23845 lab=_87487_/CLK }
C {devices/lab_pin.sym} 24610 -39770 0 0 {name=p23846 lab=_42749_/Y }
C {devices/lab_pin.sym} 24790 -39790 0 1 {name=p23847 lab=_68941_/B }
C {sky130_stdcells/dfxtp_4.sym} 24700 -39780 0 0 {name=X_87740_ }
C {devices/lab_pin.sym} 24610 -39650 0 0 {name=p23848 lab=_85404_/CLK }
C {devices/lab_pin.sym} 24610 -39630 0 0 {name=p23849 lab=_84952_/D }
C {devices/lab_pin.sym} 24790 -39650 0 1 {name=p23850 lab=_84952_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -39640 0 0 {name=X_84952_ }
C {devices/lab_pin.sym} 24640 -39520 0 0 {name=p23851 lab=_80074_/B }
C {devices/lab_pin.sym} 24640 -39480 0 0 {name=p23852 lab=_80058_/X }
C {devices/lab_pin.sym} 24760 -39500 0 1 {name=p23853 lab=_80075_/X }
C {sky130_stdcells/and2_4.sym} 24700 -39500 0 0 {name=X_80075_ }
C {devices/lab_pin.sym} 24620 -39400 0 0 {name=p23854 lab=_73374_/A }
C {devices/lab_pin.sym} 24620 -39360 0 0 {name=p23855 lab=_69837_/X }
C {devices/lab_pin.sym} 24620 -39320 0 0 {name=p23856 lab=_69779_/X }
C {devices/lab_pin.sym} 24620 -39280 0 0 {name=p23857 lab=_69885_/Y }
C {devices/lab_pin.sym} 24780 -39340 0 1 {name=p23858 lab=_69886_/X }
C {sky130_stdcells/a211o_4.sym} 24700 -39340 0 0 {name=X_69886_ }
C {devices/lab_pin.sym} 24610 -39190 0 0 {name=p23859 lab=_81975_/CLK }
C {devices/lab_pin.sym} 24610 -39170 0 0 {name=p23860 lab=_83903_/D }
C {devices/lab_pin.sym} 24790 -39190 0 1 {name=p23861 lab=_81975_/D }
C {sky130_stdcells/dfxtp_4.sym} 24700 -39180 0 0 {name=X_83903_ }
C {devices/lab_pin.sym} 24620 -39070 0 0 {name=p23862 lab=_56848_/X }
C {devices/lab_pin.sym} 24620 -39030 0 0 {name=p23863 lab=_56850_/X }
C {devices/lab_pin.sym} 24620 -38990 0 0 {name=p23864 lab=_56842_/X }
C {devices/lab_pin.sym} 24780 -39030 0 1 {name=p23865 lab=_56851_/X }
C {sky130_stdcells/o21a_4.sym} 24700 -39030 0 0 {name=X_56851_ }
C {devices/lab_pin.sym} 24620 -38910 0 0 {name=p23866 lab=_83959_/Q }
C {devices/lab_pin.sym} 24620 -38870 0 0 {name=p23867 lab=_68713_/X }
C {devices/lab_pin.sym} 24620 -38830 0 0 {name=p23868 lab=_68836_/X }
C {devices/lab_pin.sym} 24780 -38870 0 1 {name=p23869 lab=_68837_/X }
C {sky130_stdcells/a21bo_4.sym} 24700 -38870 0 0 {name=X_68837_ }
C {devices/lab_pin.sym} 24610 -38730 0 0 {name=p23870 lab=_87671_/CLK }
C {devices/lab_pin.sym} 24610 -38710 0 0 {name=p23871 lab=_87671_/D }
C {devices/lab_pin.sym} 24790 -38730 0 1 {name=p23872 lab=_67248_/B }
C {sky130_stdcells/dfxtp_4.sym} 24700 -38720 0 0 {name=X_87671_ }
C {devices/lab_pin.sym} 24610 -38590 0 0 {name=p23873 lab=_84883_/CLK }
C {devices/lab_pin.sym} 24610 -38570 0 0 {name=p23874 lab=_58306_/Y }
C {devices/lab_pin.sym} 24790 -38590 0 1 {name=p23875 lab=_64546_/C }
C {sky130_stdcells/dfxtp_4.sym} 24700 -38580 0 0 {name=X_84883_ }
C {devices/lab_pin.sym} 24660 -38450 0 0 {name=p23876 lab=_55802_/A }
C {devices/lab_pin.sym} 24740 -38450 0 1 {name=p23877 lab=_55802_/X }
C {sky130_stdcells/buf_2.sym} 24700 -38450 0 0 {name=X_55802_ }
C {devices/lab_pin.sym} 24610 -38330 0 0 {name=p23878 lab=_85981_/CLK }
C {devices/lab_pin.sym} 24610 -38310 0 0 {name=p23879 lab=_47560_/Y }
C {devices/lab_pin.sym} 24790 -38330 0 1 {name=p23880 lab=_72162_/A }
C {sky130_stdcells/dfxtp_4.sym} 24700 -38320 0 0 {name=X_86622_ }
C {devices/lab_pin.sym} 24660 -38190 0 0 {name=p23881 lab=_59570_/A }
C {devices/lab_pin.sym} 24740 -38190 0 1 {name=p23882 lab=_60639_/A }
C {sky130_stdcells/inv_2.sym} 24700 -38190 0 0 {name=X_59570_ }
C {devices/lab_pin.sym} 24610 -38070 0 0 {name=p23883 lab=_83191_/CLK }
C {devices/lab_pin.sym} 24610 -38050 0 0 {name=p23884 lab=_83834_/D }
C {devices/lab_pin.sym} 24790 -38070 0 1 {name=p23885 lab=_83834_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -38060 0 0 {name=X_83834_ }
C {devices/lab_pin.sym} 24660 -37930 0 0 {name=p23886 lab=_56729_/X }
C {devices/lab_pin.sym} 24740 -37930 0 1 {name=p23887 lab=_56782_/X }
C {sky130_stdcells/buf_2.sym} 24700 -37930 0 0 {name=X_56782_ }
C {devices/lab_pin.sym} 24640 -37820 0 0 {name=p23888 lab=_68542_/X }
C {devices/lab_pin.sym} 24640 -37780 0 0 {name=p23889 lab=_68768_/B }
C {devices/lab_pin.sym} 24760 -37800 0 1 {name=p23890 lab=_68768_/X }
C {sky130_stdcells/and2_4.sym} 24700 -37800 0 0 {name=X_68768_ }
C {devices/lab_pin.sym} 24620 -37690 0 0 {name=p23891 lab=_53992_/Y }
C {devices/lab_pin.sym} 24620 -37650 0 0 {name=p23892 lab=_53982_/X }
C {devices/lab_pin.sym} 24620 -37610 0 0 {name=p23893 lab=_53993_/Y }
C {devices/lab_pin.sym} 24780 -37650 0 1 {name=p23894 lab=_53994_/Y }
C {sky130_stdcells/a21boi_4.sym} 24700 -37650 0 0 {name=X_53994_ }
C {devices/lab_pin.sym} 24660 -37510 0 0 {name=p23895 lab=clkbuf_9_271_0_CLK/X }
C {devices/lab_pin.sym} 24740 -37510 0 1 {name=p23896 lab=_84020_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 24700 -37510 0 0 {name=Xclkbuf_10_542_0_CLK }
C {devices/lab_pin.sym} 24660 -37390 0 0 {name=p23897 lab=clkbuf_6_33_0_CLK/A }
C {devices/lab_pin.sym} 24740 -37390 0 1 {name=p23898 lab=clkbuf_7_67_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 24700 -37390 0 0 {name=Xclkbuf_6_33_0_CLK }
C {devices/lab_pin.sym} 24620 -37290 0 0 {name=p23899 lab=_58517_/X }
C {devices/lab_pin.sym} 24620 -37250 0 0 {name=p23900 lab=_58518_/Y }
C {devices/lab_pin.sym} 24620 -37210 0 0 {name=p23901 lab=_58520_/Y }
C {devices/lab_pin.sym} 24780 -37250 0 1 {name=p23902 lab=_58521_/Y }
C {sky130_stdcells/a21oi_4.sym} 24700 -37250 0 0 {name=X_58521_ }
C {devices/lab_pin.sym} 24620 -37140 0 0 {name=p23903 lab=_56450_/C }
C {devices/lab_pin.sym} 24620 -37100 0 0 {name=p23904 lab=_55126_/A }
C {devices/lab_pin.sym} 24620 -37060 0 0 {name=p23905 lab=_55128_/A }
C {devices/lab_pin.sym} 24620 -37020 0 0 {name=p23906 lab=_55732_/X }
C {devices/lab_pin.sym} 24780 -37080 0 1 {name=p23907 lab=_55733_/X }
C {sky130_stdcells/a211o_4.sym} 24700 -37080 0 0 {name=X_55733_ }
C {devices/lab_pin.sym} 24640 -36940 0 0 {name=p23908 lab=_67615_/X }
C {devices/lab_pin.sym} 24640 -36900 0 0 {name=p23909 lab=_67719_/B }
C {devices/lab_pin.sym} 24760 -36920 0 1 {name=p23910 lab=_67719_/X }
C {sky130_stdcells/and2_4.sym} 24700 -36920 0 0 {name=X_67719_ }
C {devices/lab_pin.sym} 24610 -36790 0 0 {name=p23911 lab=_86553_/CLK }
C {devices/lab_pin.sym} 24610 -36770 0 0 {name=p23912 lab=_86553_/D }
C {devices/lab_pin.sym} 24790 -36790 0 1 {name=p23913 lab=_66028_/B }
C {sky130_stdcells/dfxtp_4.sym} 24700 -36780 0 0 {name=X_86553_ }
C {devices/lab_pin.sym} 24620 -36670 0 0 {name=p23914 lab=_85725_/Q }
C {devices/lab_pin.sym} 24620 -36630 0 0 {name=p23915 lab=_52929_/X }
C {devices/lab_pin.sym} 24620 -36590 0 0 {name=p23916 lab=_52944_/Y }
C {devices/lab_pin.sym} 24780 -36630 0 1 {name=p23917 lab=_52945_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -36630 0 0 {name=X_52945_ }
C {devices/lab_pin.sym} 24610 -36490 0 0 {name=p23918 lab=_83763_/CLK }
C {devices/lab_pin.sym} 24610 -36470 0 0 {name=p23919 lab=_70481_/X }
C {devices/lab_pin.sym} 24790 -36490 0 1 {name=p23920 lab=_83765_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -36480 0 0 {name=X_83765_ }
C {devices/lab_pin.sym} 24610 -36350 0 0 {name=p23921 lab=_81061_/CLK }
C {devices/lab_pin.sym} 24610 -36330 0 0 {name=p23922 lab=_75712_/X }
C {devices/lab_pin.sym} 24790 -36350 0 1 {name=p23923 lab=_75109_/B }
C {sky130_stdcells/dfxtp_4.sym} 24700 -36340 0 0 {name=X_80977_ }
C {devices/lab_pin.sym} 24640 -36220 0 0 {name=p23924 lab=_69092_/A }
C {devices/lab_pin.sym} 24640 -36180 0 0 {name=p23925 lab=_68699_/B }
C {devices/lab_pin.sym} 24760 -36200 0 1 {name=p23926 lab=_68699_/X }
C {sky130_stdcells/and2_4.sym} 24700 -36200 0 0 {name=X_68699_ }
C {devices/lab_pin.sym} 24610 -36070 0 0 {name=p23927 lab=_85505_/CLK }
C {devices/lab_pin.sym} 24610 -36050 0 0 {name=p23928 lab=_85504_/D }
C {devices/lab_pin.sym} 24790 -36070 0 1 {name=p23929 lab=_85504_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -36060 0 0 {name=X_85504_ }
C {devices/lab_pin.sym} 24660 -35930 0 0 {name=p23930 lab=_71266_/A }
C {devices/lab_pin.sym} 24740 -35930 0 1 {name=p23931 lab=_70730_/X }
C {sky130_stdcells/buf_2.sym} 24700 -35930 0 0 {name=X_70730_ }
C {devices/lab_pin.sym} 24640 -35820 0 0 {name=p23932 lab=_58452_/A }
C {devices/lab_pin.sym} 24640 -35780 0 0 {name=p23933 lab=_58498_/B }
C {devices/lab_pin.sym} 24760 -35800 0 1 {name=p23934 lab=_58452_/Y }
C {sky130_stdcells/nand2_4.sym} 24700 -35800 0 0 {name=X_58452_ }
C {devices/lab_pin.sym} 24610 -35670 0 0 {name=p23935 lab=_82715_/CLK }
C {devices/lab_pin.sym} 24610 -35650 0 0 {name=p23936 lab=_82716_/D }
C {devices/lab_pin.sym} 24790 -35670 0 1 {name=p23937 lab=_82672_/D }
C {sky130_stdcells/dfxtp_4.sym} 24700 -35660 0 0 {name=X_82716_ }
C {devices/lab_pin.sym} 24640 -35540 0 0 {name=p23938 lab=_55662_/Y }
C {devices/lab_pin.sym} 24640 -35500 0 0 {name=p23939 lab=_55663_/Y }
C {devices/lab_pin.sym} 24760 -35520 0 1 {name=p23940 lab=_55664_/Y }
C {sky130_stdcells/nand2_4.sym} 24700 -35520 0 0 {name=X_55664_ }
C {devices/lab_pin.sym} 24610 -35390 0 0 {name=p23941 lab=_86196_/CLK }
C {devices/lab_pin.sym} 24610 -35370 0 0 {name=p23942 lab=_48780_/Y }
C {devices/lab_pin.sym} 24790 -35390 0 1 {name=p23943 lab=_86484_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -35380 0 0 {name=X_86484_ }
C {devices/lab_pin.sym} 24660 -35250 0 0 {name=p23944 lab=_40889_/Y }
C {devices/lab_pin.sym} 24740 -35250 0 1 {name=p23945 lab=_40890_/X }
C {sky130_stdcells/buf_2.sym} 24700 -35250 0 0 {name=X_40890_ }
C {devices/lab_pin.sym} 24640 -35140 0 0 {name=p23946 lab=_52885_/A }
C {devices/lab_pin.sym} 24640 -35100 0 0 {name=p23947 lab=_52876_/B }
C {devices/lab_pin.sym} 24760 -35120 0 1 {name=p23948 lab=_52876_/Y }
C {sky130_stdcells/nand2_4.sym} 24700 -35120 0 0 {name=X_52876_ }
C {devices/lab_pin.sym} 24610 -34990 0 0 {name=p23949 lab=_85645_/CLK }
C {devices/lab_pin.sym} 24610 -34970 0 0 {name=p23950 lab=_70811_/Y }
C {devices/lab_pin.sym} 24790 -34990 0 1 {name=p23951 lab=_47157_/A }
C {sky130_stdcells/dfxtp_4.sym} 24700 -34980 0 0 {name=X_83696_ }
C {devices/lab_pin.sym} 24620 -34880 0 0 {name=p23952 lab=_57394_/X }
C {devices/lab_pin.sym} 24620 -34840 0 0 {name=p23953 lab=_56630_/X }
C {devices/lab_pin.sym} 24620 -34800 0 0 {name=p23954 lab=_85014_/Q }
C {devices/lab_pin.sym} 24620 -34760 0 0 {name=p23955 lab=_57395_/X }
C {devices/lab_pin.sym} 24780 -34820 0 1 {name=p23956 lab=_57403_/X }
C {sky130_stdcells/a2bb2o_4.sym} 24700 -34820 0 0 {name=X_57403_ }
C {devices/lab_pin.sym} 24610 -34670 0 0 {name=p23957 lab=_88232_/CLK }
C {devices/lab_pin.sym} 24610 -34650 0 0 {name=p23958 lab=_88223_/D }
C {devices/lab_pin.sym} 24790 -34670 0 1 {name=p23959 lab=_67813_/B }
C {sky130_stdcells/dfxtp_4.sym} 24700 -34660 0 0 {name=X_88223_ }
C {devices/lab_pin.sym} 24620 -34550 0 0 {name=p23960 lab=_85409_/Q }
C {devices/lab_pin.sym} 24620 -34510 0 0 {name=p23961 lab=_54593_/X }
C {devices/lab_pin.sym} 24620 -34470 0 0 {name=p23962 lab=_54614_/Y }
C {devices/lab_pin.sym} 24780 -34510 0 1 {name=p23963 lab=_54615_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -34510 0 0 {name=X_54615_ }
C {devices/lab_pin.sym} 24610 -34370 0 0 {name=p23964 lab=_85754_/CLK }
C {devices/lab_pin.sym} 24610 -34350 0 0 {name=p23965 lab=_85435_/D }
C {devices/lab_pin.sym} 24790 -34370 0 1 {name=p23966 lab=_85435_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -34360 0 0 {name=X_85435_ }
C {devices/lab_pin.sym} 24620 -34250 0 0 {name=p23967 lab=_85939_/Q }
C {devices/lab_pin.sym} 24620 -34210 0 0 {name=p23968 lab=_51817_/X }
C {devices/lab_pin.sym} 24620 -34170 0 0 {name=p23969 lab=_51826_/Y }
C {devices/lab_pin.sym} 24780 -34210 0 1 {name=p23970 lab=_51827_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -34210 0 0 {name=X_51827_ }
C {devices/lab_pin.sym} 24660 -34070 0 0 {name=p23971 lab=_70886_/A }
C {devices/lab_pin.sym} 24740 -34070 0 1 {name=p23972 lab=_70884_/A }
C {sky130_stdcells/buf_2.sym} 24700 -34070 0 0 {name=X_70661_ }
C {devices/lab_pin.sym} 24640 -33960 0 0 {name=p23973 lab=_58383_/A }
C {devices/lab_pin.sym} 24640 -33920 0 0 {name=p23974 lab=_58369_/X }
C {devices/lab_pin.sym} 24760 -33940 0 1 {name=p23975 lab=_58383_/Y }
C {sky130_stdcells/nand2_4.sym} 24700 -33940 0 0 {name=X_58383_ }
C {devices/lab_pin.sym} 24660 -33810 0 0 {name=p23976 lab=clkbuf_9_278_0_CLK/X }
C {devices/lab_pin.sym} 24740 -33810 0 1 {name=p23977 lab=_87922_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 24700 -33810 0 0 {name=Xclkbuf_10_557_0_CLK }
C {devices/lab_pin.sym} 24610 -33690 0 0 {name=p23978 lab=_84003_/CLK }
C {devices/lab_pin.sym} 24610 -33670 0 0 {name=p23979 lab=_83999_/Q }
C {devices/lab_pin.sym} 24790 -33690 0 1 {name=p23980 lab=_82647_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -33680 0 0 {name=X_82647_ }
C {devices/lab_pin.sym} 24620 -33580 0 0 {name=p23981 lab=_45440_/A }
C {devices/lab_pin.sym} 24620 -33540 0 0 {name=p23982 lab=_55571_/X }
C {devices/lab_pin.sym} 24620 -33500 0 0 {name=p23983 lab=_44049_/X }
C {devices/lab_pin.sym} 24620 -33460 0 0 {name=p23984 lab=_55594_/Y }
C {devices/lab_pin.sym} 24780 -33520 0 1 {name=p23985 lab=_55595_/X }
C {sky130_stdcells/a211o_4.sym} 24700 -33520 0 0 {name=X_55595_ }
C {devices/lab_pin.sym} 24660 -33370 0 0 {name=p23986 lab=clkbuf_6_49_0_CLK/A }
C {devices/lab_pin.sym} 24740 -33370 0 1 {name=p23987 lab=clkbuf_7_96_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 24700 -33370 0 0 {name=Xclkbuf_6_48_0_CLK }
C {devices/lab_pin.sym} 24640 -33260 0 0 {name=p23988 lab=_72461_/A }
C {devices/lab_pin.sym} 24640 -33220 0 0 {name=p23989 lab=_72400_/B }
C {devices/lab_pin.sym} 24760 -33240 0 1 {name=p23990 lab=_72400_/Y }
C {sky130_stdcells/nor2_4.sym} 24700 -33240 0 0 {name=X_72400_ }
C {devices/lab_pin.sym} 24620 -33140 0 0 {name=p23991 lab=_45947_/B }
C {devices/lab_pin.sym} 24620 -33100 0 0 {name=p23992 lab=_85033_/Q }
C {devices/lab_pin.sym} 24620 -33060 0 0 {name=p23993 lab=_57333_/X }
C {devices/lab_pin.sym} 24620 -33020 0 0 {name=p23994 lab=_57331_/B }
C {devices/lab_pin.sym} 24780 -33080 0 1 {name=p23995 lab=_57335_/B }
C {sky130_stdcells/a211o_4.sym} 24700 -33080 0 0 {name=X_57334_ }
C {devices/lab_pin.sym} 24610 -32930 0 0 {name=p23996 lab=_88220_/CLK }
C {devices/lab_pin.sym} 24610 -32910 0 0 {name=p23997 lab=_41764_/Y }
C {devices/lab_pin.sym} 24790 -32930 0 1 {name=p23998 lab=_67932_/B }
C {sky130_stdcells/dfxtp_4.sym} 24700 -32920 0 0 {name=X_88154_ }
C {devices/lab_pin.sym} 24640 -32800 0 0 {name=p23999 lab=_54546_/A }
C {devices/lab_pin.sym} 24640 -32760 0 0 {name=p24000 lab=_53369_/B }
C {devices/lab_pin.sym} 24760 -32780 0 1 {name=p24001 lab=_54546_/Y }
C {sky130_stdcells/nand2_4.sym} 24700 -32780 0 0 {name=X_54546_ }
C {devices/lab_pin.sym} 24660 -32650 0 0 {name=p24002 lab=_72945_/A }
C {devices/lab_pin.sym} 24740 -32650 0 1 {name=p24003 lab=_69661_/B }
C {sky130_stdcells/inv_2.sym} 24700 -32650 0 0 {name=X_42560_ }
C {devices/lab_pin.sym} 24620 -32560 0 0 {name=p24004 lab=_73378_/X }
C {devices/lab_pin.sym} 24620 -32520 0 0 {name=p24005 lab=_86185_/Q }
C {devices/lab_pin.sym} 24620 -32480 0 0 {name=p24006 lab=_72905_/X }
C {devices/lab_pin.sym} 24620 -32440 0 0 {name=p24007 lab=_73379_/X }
C {devices/lab_pin.sym} 24780 -32500 0 1 {name=p24008 lab=_73380_/X }
C {sky130_stdcells/a211o_4.sym} 24700 -32500 0 0 {name=X_73380_ }
C {devices/lab_pin.sym} 24610 -32350 0 0 {name=p24009 lab=_83630_/CLK }
C {devices/lab_pin.sym} 24610 -32330 0 0 {name=p24010 lab=_54853_/Y }
C {devices/lab_pin.sym} 24790 -32350 0 1 {name=p24011 lab=_85366_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -32340 0 0 {name=X_85366_ }
C {devices/lab_pin.sym} 24640 -32220 0 0 {name=p24012 lab=_51758_/A }
C {devices/lab_pin.sym} 24640 -32180 0 0 {name=p24013 lab=_50893_/B }
C {devices/lab_pin.sym} 24760 -32200 0 1 {name=p24014 lab=_51758_/Y }
C {sky130_stdcells/nand2_4.sym} 24700 -32200 0 0 {name=X_51758_ }
C {devices/lab_pin.sym} 24660 -32070 0 0 {name=p24015 lab=_74731_/A }
C {devices/lab_pin.sym} 24740 -32070 0 1 {name=p24016 lab=_74716_/A }
C {sky130_stdcells/buf_2.sym} 24700 -32070 0 0 {name=X_70592_ }
C {devices/lab_pin.sym} 24610 -31950 0 0 {name=p24017 lab=_82610_/CLK }
C {devices/lab_pin.sym} 24610 -31930 0 0 {name=p24018 lab=_82578_/D }
C {devices/lab_pin.sym} 24790 -31950 0 1 {name=p24019 lab=_78199_/A }
C {sky130_stdcells/dfxtp_4.sym} 24700 -31940 0 0 {name=X_82578_ }
C {devices/lab_pin.sym} 24610 -31810 0 0 {name=p24020 lab=_87926_/CLK }
C {devices/lab_pin.sym} 24610 -31790 0 0 {name=p24021 lab=_87105_/D }
C {devices/lab_pin.sym} 24790 -31810 0 1 {name=p24022 lab=_87105_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -31800 0 0 {name=X_87105_ }
C {devices/lab_pin.sym} 24660 -31670 0 0 {name=p24023 lab=_41510_/Y }
C {devices/lab_pin.sym} 24740 -31670 0 1 {name=p24024 lab=_41511_/X }
C {sky130_stdcells/buf_2.sym} 24700 -31670 0 0 {name=X_41511_ }
C {devices/lab_pin.sym} 24640 -31560 0 0 {name=p24025 lab=_72366_/A }
C {devices/lab_pin.sym} 24640 -31520 0 0 {name=p24026 lab=_86288_/Q }
C {devices/lab_pin.sym} 24760 -31540 0 1 {name=p24027 lab=_72331_/Y }
C {sky130_stdcells/nor2_4.sym} 24700 -31540 0 0 {name=X_72331_ }
C {devices/lab_pin.sym} 24610 -31410 0 0 {name=p24028 lab=_84321_/CLK }
C {devices/lab_pin.sym} 24610 -31390 0 0 {name=p24029 lab=_63518_/Y }
C {devices/lab_pin.sym} 24790 -31410 0 1 {name=p24030 lab=_63517_/C }
C {sky130_stdcells/dfxtp_4.sym} 24700 -31400 0 0 {name=X_84317_ }
C {devices/lab_pin.sym} 24620 -31290 0 0 {name=p24031 lab=_86149_/Q }
C {devices/lab_pin.sym} 24620 -31250 0 0 {name=p24032 lab=_50706_/X }
C {devices/lab_pin.sym} 24620 -31210 0 0 {name=p24033 lab=_50708_/Y }
C {devices/lab_pin.sym} 24780 -31250 0 1 {name=p24034 lab=_50709_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -31250 0 0 {name=X_50709_ }
C {devices/lab_pin.sym} 24610 -31110 0 0 {name=p24035 lab=_82053_/CLK }
C {devices/lab_pin.sym} 24610 -31090 0 0 {name=p24036 lab=_81541_/Q }
C {devices/lab_pin.sym} 24790 -31110 0 1 {name=p24037 lab=_81529_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -31100 0 0 {name=X_81529_ }
C {devices/lab_pin.sym} 24620 -31000 0 0 {name=p24038 lab=_57331_/B }
C {devices/lab_pin.sym} 24620 -30960 0 0 {name=p24039 lab=_57264_/Y }
C {devices/lab_pin.sym} 24620 -30920 0 0 {name=p24040 lab=_56664_/Y }
C {devices/lab_pin.sym} 24620 -30880 0 0 {name=p24041 lab=_56972_/Y }
C {devices/lab_pin.sym} 24780 -30940 0 1 {name=p24042 lab=_57265_/X }
C {sky130_stdcells/a2bb2o_4.sym} 24700 -30940 0 0 {name=X_57265_ }
C {devices/lab_pin.sym} 24620 -30830 0 0 {name=p24043 lab=_42466_/X }
C {devices/lab_pin.sym} 24620 -30790 0 0 {name=p24044 lab=_42467_/X }
C {devices/lab_pin.sym} 24620 -30750 0 0 {name=p24045 lab=_40656_/X }
C {devices/lab_pin.sym} 24620 -30710 0 0 {name=p24046 lab=_68668_/A }
C {devices/lab_pin.sym} 24620 -30670 0 0 {name=p24047 lab=_42480_/X }
C {devices/lab_pin.sym} 24780 -30750 0 1 {name=p24048 lab=_42492_/A }
C {sky130_stdcells/o32ai_4.sym} 24700 -30750 0 0 {name=X_42491_ }
C {devices/lab_pin.sym} 24610 -30590 0 0 {name=p24049 lab=_88085_/CLK }
C {devices/lab_pin.sym} 24610 -30570 0 0 {name=p24050 lab=_88085_/D }
C {devices/lab_pin.sym} 24790 -30590 0 1 {name=p24051 lab=_88085_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -30580 0 0 {name=X_88085_ }
C {devices/lab_pin.sym} 24620 -30470 0 0 {name=p24052 lab=_54474_/Y }
C {devices/lab_pin.sym} 24620 -30430 0 0 {name=p24053 lab=_54475_/X }
C {devices/lab_pin.sym} 24620 -30390 0 0 {name=p24054 lab=_54476_/X }
C {devices/lab_pin.sym} 24780 -30430 0 1 {name=p24055 lab=_85435_/D }
C {sky130_stdcells/a21oi_4.sym} 24700 -30430 0 0 {name=X_54477_ }
C {devices/lab_pin.sym} 24610 -30290 0 0 {name=p24056 lab=_85297_/CLK }
C {devices/lab_pin.sym} 24610 -30270 0 0 {name=p24057 lab=_56097_/Y }
C {devices/lab_pin.sym} 24790 -30290 0 1 {name=p24058 lab=_85297_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -30280 0 0 {name=X_85297_ }
C {devices/lab_pin.sym} 24640 -30180 0 0 {name=p24059 lab=_51695_/A }
C {devices/lab_pin.sym} 24640 -30140 0 0 {name=p24060 lab=_51684_/B }
C {devices/lab_pin.sym} 24640 -30100 0 0 {name=p24061 lab=_51695_/C }
C {devices/lab_pin.sym} 24640 -30060 0 0 {name=p24062 lab=_53211_/D }
C {devices/lab_pin.sym} 24760 -30120 0 1 {name=p24063 lab=_51689_/X }
C {sky130_stdcells/and4_4.sym} 24700 -30120 0 0 {name=X_51689_ }
C {devices/lab_pin.sym} 24620 -29990 0 0 {name=p24064 lab=_59000_/Y }
C {devices/lab_pin.sym} 24620 -29950 0 0 {name=p24065 lab=_59003_/Y }
C {devices/lab_pin.sym} 24620 -29910 0 0 {name=p24066 lab=_58966_/X }
C {devices/lab_pin.sym} 24780 -29950 0 1 {name=p24067 lab=_59004_/X }
C {sky130_stdcells/a21o_4.sym} 24700 -29950 0 0 {name=X_59004_ }
C {devices/lab_pin.sym} 24660 -29810 0 0 {name=p24068 lab=_56995_/A }
C {devices/lab_pin.sym} 24740 -29810 0 1 {name=p24069 lab=_44231_/A }
C {sky130_stdcells/buf_2.sym} 24700 -29810 0 0 {name=X_44230_ }
C {devices/lab_pin.sym} 24640 -29710 0 0 {name=p24070 lab=_56214_/A }
C {devices/lab_pin.sym} 24640 -29670 0 0 {name=p24071 lab=_56205_/X }
C {devices/lab_pin.sym} 24640 -29630 0 0 {name=p24072 lab=_56216_/C }
C {devices/lab_pin.sym} 24760 -29670 0 1 {name=p24073 lab=_56216_/Y }
C {sky130_stdcells/nand3_4.sym} 24700 -29670 0 0 {name=X_56216_ }
C {devices/lab_pin.sym} 24640 -29550 0 0 {name=p24074 lab=_75039_/X }
C {devices/lab_pin.sym} 24640 -29510 0 0 {name=p24075 lab=_75042_/A }
C {devices/lab_pin.sym} 24640 -29470 0 0 {name=p24076 lab=_75042_/B }
C {devices/lab_pin.sym} 24760 -29510 0 1 {name=p24077 lab=_75050_/Y }
C {sky130_stdcells/nand3_4.sym} 24700 -29510 0 0 {name=X_75050_ }
C {devices/lab_pin.sym} 24660 -29370 0 0 {name=p24078 lab=_41441_/X }
C {devices/lab_pin.sym} 24740 -29370 0 1 {name=p24079 lab=_41442_/X }
C {sky130_stdcells/buf_2.sym} 24700 -29370 0 0 {name=X_41442_ }
C {devices/lab_pin.sym} 24660 -29250 0 0 {name=p24080 lab=_46167_/Y }
C {devices/lab_pin.sym} 24740 -29250 0 1 {name=p24081 lab=_86769_/D }
C {sky130_stdcells/buf_8.sym} 24700 -29250 0 0 {name=Xpsn_inst_psn_buff_0 }
C {devices/lab_pin.sym} 24610 -29130 0 0 {name=p24082 lab=_86989_/CLK }
C {devices/lab_pin.sym} 24610 -29110 0 0 {name=p24083 lab=_44608_/X }
C {devices/lab_pin.sym} 24790 -29130 0 1 {name=p24084 lab=_87036_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -29120 0 0 {name=X_87036_ }
C {devices/lab_pin.sym} 24660 -28990 0 0 {name=p24085 lab=_53347_/A }
C {devices/lab_pin.sym} 24740 -28990 0 1 {name=p24086 lab=_53428_/X }
C {sky130_stdcells/buf_2.sym} 24700 -28990 0 0 {name=X_53428_ }
C {devices/lab_pin.sym} 24620 -28900 0 0 {name=p24087 lab=_83270_/Q }
C {devices/lab_pin.sym} 24620 -28860 0 0 {name=p24088 lab=_72250_/X }
C {devices/lab_pin.sym} 24620 -28820 0 0 {name=p24089 lab=_72254_/X }
C {devices/lab_pin.sym} 24620 -28780 0 0 {name=p24090 lab=_72261_/X }
C {devices/lab_pin.sym} 24780 -28840 0 1 {name=p24091 lab=_83270_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 24700 -28840 0 0 {name=X_72262_ }
C {devices/lab_pin.sym} 24610 -28690 0 0 {name=p24092 lab=_84849_/CLK }
C {devices/lab_pin.sym} 24610 -28670 0 0 {name=p24093 lab=_64417_/X }
C {devices/lab_pin.sym} 24790 -28690 0 1 {name=p24094 lab=_79700_/B }
C {sky130_stdcells/dfxtp_4.sym} 24700 -28680 0 0 {name=X_84248_ }
C {devices/lab_pin.sym} 24640 -28570 0 0 {name=p24095 lab=_56859_/X }
C {devices/lab_pin.sym} 24640 -28530 0 0 {name=p24096 lab=_56675_/X }
C {devices/lab_pin.sym} 24640 -28490 0 0 {name=p24097 lab=_56876_/X }
C {devices/lab_pin.sym} 24760 -28530 0 1 {name=p24098 lab=_57196_/Y }
C {sky130_stdcells/nand3_4.sym} 24700 -28530 0 0 {name=X_57196_ }
C {devices/lab_pin.sym} 24640 -28400 0 0 {name=p24099 lab=_48022_/Y }
C {devices/lab_pin.sym} 24640 -28360 0 0 {name=p24100 lab=_74001_/B }
C {devices/lab_pin.sym} 24760 -28380 0 1 {name=p24101 lab=_74002_/B }
C {sky130_stdcells/xor2_4.sym} 24700 -28380 0 0 {name=X_74001_ }
C {devices/lab_pin.sym} 24640 -28270 0 0 {name=p24102 lab=_71211_/A }
C {devices/lab_pin.sym} 24640 -28230 0 0 {name=p24103 lab=_71091_/B }
C {devices/lab_pin.sym} 24640 -28190 0 0 {name=p24104 lab=_71219_/C }
C {devices/lab_pin.sym} 24760 -28230 0 1 {name=p24105 lab=_71213_/Y }
C {sky130_stdcells/nand3_4.sym} 24700 -28230 0 0 {name=X_71213_ }
C {devices/lab_pin.sym} 24640 -28100 0 0 {name=p24106 lab=_56147_/A }
C {devices/lab_pin.sym} 24640 -28060 0 0 {name=p24107 lab=_56117_/A }
C {devices/lab_pin.sym} 24760 -28080 0 1 {name=p24108 lab=_56148_/A }
C {sky130_stdcells/xor2_4.sym} 24700 -28080 0 0 {name=X_56147_ }
C {devices/lab_pin.sym} 24620 -27970 0 0 {name=p24109 lab=_44159_/X }
C {devices/lab_pin.sym} 24620 -27930 0 0 {name=p24110 lab=_44160_/Y }
C {devices/lab_pin.sym} 24620 -27890 0 0 {name=p24111 lab=_44163_/B }
C {devices/lab_pin.sym} 24780 -27930 0 1 {name=p24112 lab=_87185_/D }
C {sky130_stdcells/a21oi_4.sym} 24700 -27930 0 0 {name=X_44161_ }
C {devices/lab_pin.sym} 24660 -27790 0 0 {name=p24113 lab=_41072_/X }
C {devices/lab_pin.sym} 24740 -27790 0 1 {name=p24114 lab=_41373_/X }
C {sky130_stdcells/buf_2.sym} 24700 -27790 0 0 {name=X_41373_ }
C {devices/lab_pin.sym} 24620 -27690 0 0 {name=p24115 lab=_53354_/Y }
C {devices/lab_pin.sym} 24620 -27650 0 0 {name=p24116 lab=_53355_/X }
C {devices/lab_pin.sym} 24620 -27610 0 0 {name=p24117 lab=_53358_/X }
C {devices/lab_pin.sym} 24780 -27650 0 1 {name=p24118 lab=_85649_/D }
C {sky130_stdcells/a21oi_4.sym} 24700 -27650 0 0 {name=X_53359_ }
C {devices/lab_pin.sym} 24640 -27520 0 0 {name=p24119 lab=_72193_/A }
C {devices/lab_pin.sym} 24640 -27480 0 0 {name=p24120 lab=_72193_/B }
C {devices/lab_pin.sym} 24760 -27500 0 1 {name=p24121 lab=_72193_/Y }
C {sky130_stdcells/nor2_4.sym} 24700 -27500 0 0 {name=X_72193_ }
C {devices/lab_pin.sym} 24610 -27370 0 0 {name=p24122 lab=_84175_/CLK }
C {devices/lab_pin.sym} 24610 -27350 0 0 {name=p24123 lab=_84179_/D }
C {devices/lab_pin.sym} 24790 -27370 0 1 {name=p24124 lab=_84179_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -27360 0 0 {name=X_84179_ }
C {devices/lab_pin.sym} 24660 -27230 0 0 {name=p24125 lab=_43112_/A }
C {devices/lab_pin.sym} 24740 -27230 0 1 {name=p24126 lab=_87572_/D }
C {sky130_stdcells/inv_2.sym} 24700 -27230 0 0 {name=X_43112_ }
C {devices/lab_pin.sym} 24660 -27110 0 0 {name=p24127 lab=_49140_/B }
C {devices/lab_pin.sym} 24740 -27110 0 1 {name=p24128 lab=_40324_/X }
C {sky130_stdcells/buf_2.sym} 24700 -27110 0 0 {name=X_40324_ }
C {devices/lab_pin.sym} 24620 -27010 0 0 {name=p24129 lab=_48368_/X }
C {devices/lab_pin.sym} 24620 -26970 0 0 {name=p24130 lab=_71138_/X }
C {devices/lab_pin.sym} 24620 -26930 0 0 {name=p24131 lab=_71143_/Y }
C {devices/lab_pin.sym} 24780 -26970 0 1 {name=p24132 lab=_83592_/D }
C {sky130_stdcells/o21ai_4.sym} 24700 -26970 0 0 {name=X_71144_ }
C {devices/lab_pin.sym} 24660 -26830 0 0 {name=p24133 lab=_80666_/Q }
C {devices/lab_pin.sym} 24740 -26830 0 1 {name=p24134 lab=_55158_/A }
C {sky130_stdcells/inv_2.sym} 24700 -26830 0 0 {name=X_44092_ }
C {devices/lab_pin.sym} 24640 -26720 0 0 {name=p24135 lab=_55863_/X }
C {devices/lab_pin.sym} 24640 -26680 0 0 {name=p24136 lab=_55995_/X }
C {devices/lab_pin.sym} 24760 -26700 0 1 {name=p24137 lab=_56079_/A }
C {sky130_stdcells/xnor2_4.sym} 24700 -26700 0 0 {name=X_56078_ }
C {devices/lab_pin.sym} 24640 -26590 0 0 {name=p24138 lab=_50270_/A }
C {devices/lab_pin.sym} 24640 -26550 0 0 {name=p24139 lab=_49312_/C }
C {devices/lab_pin.sym} 24640 -26510 0 0 {name=p24140 lab=_47919_/X }
C {devices/lab_pin.sym} 24760 -26550 0 1 {name=p24141 lab=_47920_/X }
C {sky130_stdcells/and3_4.sym} 24700 -26550 0 0 {name=X_47920_ }
C {devices/lab_pin.sym} 24660 -26410 0 0 {name=p24142 lab=_43043_/A }
C {devices/lab_pin.sym} 24740 -26410 0 1 {name=p24143 lab=_43043_/Y }
C {sky130_stdcells/inv_2.sym} 24700 -26410 0 0 {name=X_43043_ }
C {devices/lab_pin.sym} 24620 -26310 0 0 {name=p24144 lab=_85332_/Q }
C {devices/lab_pin.sym} 24620 -26270 0 0 {name=p24145 lab=_55020_/X }
C {devices/lab_pin.sym} 24620 -26230 0 0 {name=p24146 lab=_55028_/Y }
C {devices/lab_pin.sym} 24780 -26270 0 1 {name=p24147 lab=_55029_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -26270 0 0 {name=X_55029_ }
C {devices/lab_pin.sym} 24640 -26140 0 0 {name=p24148 lab=_60418_/D }
C {devices/lab_pin.sym} 24640 -26100 0 0 {name=p24149 lab=_61070_/B }
C {devices/lab_pin.sym} 24760 -26120 0 1 {name=p24150 lab=_59906_/X }
C {sky130_stdcells/and2_4.sym} 24700 -26120 0 0 {name=X_59906_ }
C {devices/lab_pin.sym} 24640 -26020 0 0 {name=p24151 lab=_78701_/A }
C {devices/lab_pin.sym} 24640 -25980 0 0 {name=p24152 lab=_78701_/B }
C {devices/lab_pin.sym} 24640 -25940 0 0 {name=p24153 lab=_78700_/A }
C {devices/lab_pin.sym} 24640 -25900 0 0 {name=p24154 lab=_78720_/A }
C {devices/lab_pin.sym} 24760 -25960 0 1 {name=p24155 lab=_78740_/X }
C {sky130_stdcells/and4_4.sym} 24700 -25960 0 0 {name=X_78740_ }
C {devices/lab_pin.sym} 24660 -25810 0 0 {name=p24156 lab=_70809_/A }
C {devices/lab_pin.sym} 24740 -25810 0 1 {name=p24157 lab=_71076_/B }
C {sky130_stdcells/buf_2.sym} 24700 -25810 0 0 {name=X_71075_ }
C {devices/lab_pin.sym} 24640 -25700 0 0 {name=p24158 lab=_81702_/D }
C {devices/lab_pin.sym} 24640 -25660 0 0 {name=p24159 lab=_75952_/B }
C {devices/lab_pin.sym} 24760 -25680 0 1 {name=p24160 lab=_75952_/Y }
C {sky130_stdcells/nand2_4.sym} 24700 -25680 0 0 {name=X_75952_ }
C {devices/lab_pin.sym} 24610 -25550 0 0 {name=p24161 lab=_88128_/CLK }
C {devices/lab_pin.sym} 24610 -25530 0 0 {name=p24162 lab=_87938_/D }
C {devices/lab_pin.sym} 24790 -25550 0 1 {name=p24163 lab=_87938_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -25540 0 0 {name=X_87938_ }
C {devices/lab_pin.sym} 24620 -25430 0 0 {name=p24164 lab=_74887_/C }
C {devices/lab_pin.sym} 24620 -25390 0 0 {name=p24165 lab=_74899_/Y }
C {devices/lab_pin.sym} 24620 -25350 0 0 {name=p24166 lab=_74902_/Y }
C {devices/lab_pin.sym} 24780 -25390 0 1 {name=p24167 lab=_74904_/B }
C {sky130_stdcells/o21a_4.sym} 24700 -25390 0 0 {name=X_74903_ }
C {devices/lab_pin.sym} 24620 -25270 0 0 {name=p24168 lab=_68674_/X }
C {devices/lab_pin.sym} 24620 -25230 0 0 {name=p24169 lab=_68677_/X }
C {devices/lab_pin.sym} 24620 -25190 0 0 {name=p24170 lab=_70005_/X }
C {devices/lab_pin.sym} 24780 -25230 0 1 {name=p24171 lab=_70026_/Y }
C {sky130_stdcells/a21oi_4.sym} 24700 -25230 0 0 {name=X_70026_ }
C {devices/lab_pin.sym} 24640 -25100 0 0 {name=p24172 lab=_47848_/X }
C {devices/lab_pin.sym} 24640 -25060 0 0 {name=p24173 lab=_47851_/B }
C {devices/lab_pin.sym} 24760 -25080 0 1 {name=p24174 lab=_47851_/X }
C {sky130_stdcells/and2_4.sym} 24700 -25080 0 0 {name=X_47851_ }
C {devices/lab_pin.sym} 24640 -24970 0 0 {name=p24175 lab=_59772_/A }
C {devices/lab_pin.sym} 24640 -24930 0 0 {name=p24176 lab=_59837_/B }
C {devices/lab_pin.sym} 24640 -24890 0 0 {name=p24177 lab=_80391_/A }
C {devices/lab_pin.sym} 24760 -24930 0 1 {name=p24178 lab=_59837_/Y }
C {sky130_stdcells/nor3_4.sym} 24700 -24930 0 0 {name=X_59837_ }
C {devices/lab_pin.sym} 24640 -24820 0 0 {name=p24179 lab=_78638_/A }
C {devices/lab_pin.sym} 24640 -24780 0 0 {name=p24180 lab=_78653_/X }
C {devices/lab_pin.sym} 24640 -24740 0 0 {name=p24181 lab=_78638_/B }
C {devices/lab_pin.sym} 24640 -24700 0 0 {name=p24182 lab=_78655_/B }
C {devices/lab_pin.sym} 24760 -24760 0 1 {name=p24183 lab=_78671_/X }
C {sky130_stdcells/and4_4.sym} 24700 -24760 0 0 {name=X_78671_ }
C {devices/lab_pin.sym} 24610 -24610 0 0 {name=p24184 lab=_82888_/CLK }
C {devices/lab_pin.sym} 24610 -24590 0 0 {name=p24185 lab=_42427_/Y }
C {devices/lab_pin.sym} 24790 -24610 0 1 {name=p24186 lab=_87869_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -24600 0 0 {name=X_87869_ }
C {devices/lab_pin.sym} 24660 -24470 0 0 {name=p24187 lab=_75750_/Y }
C {devices/lab_pin.sym} 24740 -24470 0 1 {name=p24188 lab=_75883_/Y }
C {sky130_stdcells/inv_2.sym} 24700 -24470 0 0 {name=X_75883_ }
C {devices/lab_pin.sym} 24640 -24380 0 0 {name=p24189 lab=_46784_/A }
C {devices/lab_pin.sym} 24640 -24340 0 0 {name=p24190 lab=_46830_/B }
C {devices/lab_pin.sym} 24640 -24300 0 0 {name=p24191 lab=_46784_/C }
C {devices/lab_pin.sym} 24640 -24260 0 0 {name=p24192 lab=_52681_/D }
C {devices/lab_pin.sym} 24760 -24320 0 1 {name=p24193 lab=_46802_/X }
C {sky130_stdcells/and4_4.sym} 24700 -24320 0 0 {name=X_46802_ }
C {devices/lab_pin.sym} 24640 -24180 0 0 {name=p24194 lab=_77622_/A }
C {devices/lab_pin.sym} 24640 -24140 0 0 {name=p24195 lab=_77596_/A }
C {devices/lab_pin.sym} 24760 -24160 0 1 {name=p24196 lab=_77622_/X }
C {sky130_stdcells/and2_4.sym} 24700 -24160 0 0 {name=X_77622_ }
C {devices/lab_pin.sym} 24640 -24040 0 0 {name=p24197 lab=_74844_/A }
C {devices/lab_pin.sym} 24640 -24000 0 0 {name=p24198 lab=_46114_/A }
C {devices/lab_pin.sym} 24760 -24020 0 1 {name=p24199 lab=_74835_/A }
C {sky130_stdcells/nand2_4.sym} 24700 -24020 0 0 {name=X_74834_ }
C {devices/lab_pin.sym} 24620 -23910 0 0 {name=p24200 lab=_86598_/Q }
C {devices/lab_pin.sym} 24620 -23870 0 0 {name=p24201 lab=_47760_/X }
C {devices/lab_pin.sym} 24620 -23830 0 0 {name=p24202 lab=_47781_/Y }
C {devices/lab_pin.sym} 24780 -23870 0 1 {name=p24203 lab=_47782_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -23870 0 0 {name=X_47782_ }
C {devices/lab_pin.sym} 24620 -23770 0 0 {name=p24204 lab=_61770_/B }
C {devices/lab_pin.sym} 24620 -23730 0 0 {name=p24205 lab=_59731_/Y }
C {devices/lab_pin.sym} 24620 -23690 0 0 {name=p24206 lab=_61770_/D }
C {devices/lab_pin.sym} 24620 -23650 0 0 {name=p24207 lab=_59836_/D }
C {devices/lab_pin.sym} 24620 -23620 0 0 {name=p24208 lab=_59816_/A }
C {devices/lab_pin.sym} 24780 -23690 0 1 {name=p24209 lab=_59768_/Y }
C {sky130_stdcells/a41oi_4.sym} 24700 -23690 0 0 {name=X_59768_ }
C {devices/lab_pin.sym} 24660 -23530 0 0 {name=p24210 lab=_45835_/A }
C {devices/lab_pin.sym} 24740 -23530 0 1 {name=p24211 lab=_45219_/A }
C {sky130_stdcells/buf_2.sym} 24700 -23530 0 0 {name=X_44994_ }
C {devices/lab_pin.sym} 24660 -23410 0 0 {name=p24212 lab=_49548_/A }
C {devices/lab_pin.sym} 24740 -23410 0 1 {name=p24213 lab=_49522_/C }
C {sky130_stdcells/buf_2.sym} 24700 -23410 0 0 {name=X_49521_ }
C {devices/lab_pin.sym} 24640 -23300 0 0 {name=p24214 lab=_46733_/A }
C {devices/lab_pin.sym} 24640 -23260 0 0 {name=p24215 lab=_51812_/B }
C {devices/lab_pin.sym} 24760 -23280 0 1 {name=p24216 lab=_46733_/Y }
C {sky130_stdcells/nand2_4.sym} 24700 -23280 0 0 {name=X_46733_ }
C {devices/lab_pin.sym} 24660 -23150 0 0 {name=p24217 lab=clkbuf_8_1_0_CLK/A }
C {devices/lab_pin.sym} 24740 -23150 0 1 {name=p24218 lab=clkbuf_9_3_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 24700 -23150 0 0 {name=Xclkbuf_8_1_0_CLK }
C {devices/lab_pin.sym} 24620 -23050 0 0 {name=p24219 lab=_58713_/Y }
C {devices/lab_pin.sym} 24620 -23010 0 0 {name=p24220 lab=_58718_/Y }
C {devices/lab_pin.sym} 24620 -22970 0 0 {name=p24221 lab=_58646_/X }
C {devices/lab_pin.sym} 24780 -23010 0 1 {name=p24222 lab=_58719_/X }
C {sky130_stdcells/a21o_4.sym} 24700 -23010 0 0 {name=X_58719_ }
C {devices/lab_pin.sym} 24640 -22890 0 0 {name=p24223 lab=_77553_/A }
C {devices/lab_pin.sym} 24640 -22850 0 0 {name=p24224 lab=_77553_/B }
C {devices/lab_pin.sym} 24640 -22810 0 0 {name=p24225 lab=_77552_/Y }
C {devices/lab_pin.sym} 24760 -22850 0 1 {name=p24226 lab=_77553_/X }
C {sky130_stdcells/or3_4.sym} 24700 -22850 0 0 {name=X_77553_ }
C {devices/lab_pin.sym} 24660 -22710 0 0 {name=p24227 lab=_43945_/A }
C {devices/lab_pin.sym} 24740 -22710 0 1 {name=p24228 lab=_43945_/Y }
C {sky130_stdcells/inv_2.sym} 24700 -22710 0 0 {name=X_43945_ }
C {devices/lab_pin.sym} 24640 -22610 0 0 {name=p24229 lab=_70576_/X }
C {devices/lab_pin.sym} 24640 -22570 0 0 {name=p24230 lab=_83828_/Q }
C {devices/lab_pin.sym} 24640 -22530 0 0 {name=p24231 lab=_74764_/A }
C {devices/lab_pin.sym} 24760 -22570 0 1 {name=p24232 lab=_74765_/X }
C {sky130_stdcells/and3_4.sym} 24700 -22570 0 0 {name=X_74765_ }
C {devices/lab_pin.sym} 24620 -22450 0 0 {name=p24233 lab=_83309_/Q }
C {devices/lab_pin.sym} 24620 -22410 0 0 {name=p24234 lab=_57615_/X }
C {devices/lab_pin.sym} 24620 -22370 0 0 {name=p24235 lab=_71976_/Y }
C {devices/lab_pin.sym} 24780 -22410 0 1 {name=p24236 lab=_71977_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -22410 0 0 {name=X_71977_ }
C {devices/lab_pin.sym} 24640 -22290 0 0 {name=p24237 lab=_59699_/A }
C {devices/lab_pin.sym} 24640 -22250 0 0 {name=p24238 lab=_59722_/A }
C {devices/lab_pin.sym} 24640 -22210 0 0 {name=p24239 lab=_61755_/A }
C {devices/lab_pin.sym} 24760 -22250 0 1 {name=p24240 lab=_59797_/A }
C {sky130_stdcells/and3_4.sym} 24700 -22250 0 0 {name=X_59699_ }
C {devices/lab_pin.sym} 24660 -22110 0 0 {name=p24241 lab=_76503_/Y }
C {devices/lab_pin.sym} 24740 -22110 0 1 {name=p24242 lab=_76504_/Y }
C {sky130_stdcells/inv_2.sym} 24700 -22110 0 0 {name=X_76504_ }
C {devices/lab_pin.sym} 24640 -22020 0 0 {name=p24243 lab=_49447_/A }
C {devices/lab_pin.sym} 24640 -21980 0 0 {name=p24244 lab=_49456_/B }
C {devices/lab_pin.sym} 24640 -21940 0 0 {name=p24245 lab=_49447_/C }
C {devices/lab_pin.sym} 24640 -21900 0 0 {name=p24246 lab=_46775_/X }
C {devices/lab_pin.sym} 24760 -21960 0 1 {name=p24247 lab=_49452_/X }
C {sky130_stdcells/and4_4.sym} 24700 -21960 0 0 {name=X_49452_ }
C {devices/lab_pin.sym} 24640 -21820 0 0 {name=p24248 lab=_73716_/A }
C {devices/lab_pin.sym} 24640 -21780 0 0 {name=p24249 lab=_73715_/X }
C {devices/lab_pin.sym} 24760 -21800 0 1 {name=p24250 lab=_73717_/B }
C {sky130_stdcells/nand2_4.sym} 24700 -21800 0 0 {name=X_73716_ }
C {devices/lab_pin.sym} 24660 -21670 0 0 {name=p24251 lab=_59806_/A }
C {devices/lab_pin.sym} 24740 -21670 0 1 {name=p24252 lab=_61730_/X }
C {sky130_stdcells/buf_2.sym} 24700 -21670 0 0 {name=X_61730_ }
C {devices/lab_pin.sym} 24620 -21570 0 0 {name=p24253 lab=_58634_/A }
C {devices/lab_pin.sym} 24620 -21530 0 0 {name=p24254 lab=_46622_/X }
C {devices/lab_pin.sym} 24620 -21490 0 0 {name=p24255 lab=_46663_/Y }
C {devices/lab_pin.sym} 24780 -21530 0 1 {name=p24256 lab=_46664_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -21530 0 0 {name=X_46664_ }
C {devices/lab_pin.sym} 24640 -21420 0 0 {name=p24257 lab=_70903_/A }
C {devices/lab_pin.sym} 24640 -21380 0 0 {name=p24258 lab=_70863_/C }
C {devices/lab_pin.sym} 24640 -21340 0 0 {name=p24259 lab=_70925_/X }
C {devices/lab_pin.sym} 24640 -21300 0 0 {name=p24260 lab=_70919_/D }
C {devices/lab_pin.sym} 24760 -21360 0 1 {name=p24261 lab=_70928_/Y }
C {sky130_stdcells/nand4_4.sym} 24700 -21360 0 0 {name=X_70928_ }
C {devices/lab_pin.sym} 24640 -21220 0 0 {name=p24262 lab=_77481_/Y }
C {devices/lab_pin.sym} 24640 -21180 0 0 {name=p24263 lab=_77484_/B }
C {devices/lab_pin.sym} 24760 -21200 0 1 {name=p24264 lab=_82195_/D }
C {sky130_stdcells/xor2_4.sym} 24700 -21200 0 0 {name=X_77484_ }
C {devices/lab_pin.sym} 24660 -21070 0 0 {name=p24265 lab=_43854_/A }
C {devices/lab_pin.sym} 24740 -21070 0 1 {name=p24266 lab=_43876_/X }
C {sky130_stdcells/buf_2.sym} 24700 -21070 0 0 {name=X_43876_ }
C {devices/lab_pin.sym} 24660 -20950 0 0 {name=p24267 lab=_74695_/X }
C {devices/lab_pin.sym} 24740 -20950 0 1 {name=p24268 lab=_82982_/D }
C {sky130_stdcells/inv_2.sym} 24700 -20950 0 0 {name=X_74696_ }
C {devices/lab_pin.sym} 24660 -20830 0 0 {name=p24269 lab=_49247_/A }
C {devices/lab_pin.sym} 24740 -20830 0 1 {name=p24270 lab=_48403_/X }
C {sky130_stdcells/buf_2.sym} 24700 -20830 0 0 {name=X_48403_ }
C {devices/lab_pin.sym} 24640 -20730 0 0 {name=p24271 lab=_79221_/Y }
C {devices/lab_pin.sym} 24640 -20690 0 0 {name=p24272 lab=_79217_/Y }
C {devices/lab_pin.sym} 24640 -20650 0 0 {name=p24273 lab=_79218_/X }
C {devices/lab_pin.sym} 24760 -20690 0 1 {name=p24274 lab=_79224_/B }
C {sky130_stdcells/nand3_4.sym} 24700 -20690 0 0 {name=X_79223_ }
C {devices/lab_pin.sym} 24660 -20550 0 0 {name=p24275 lab=_85011_/Q }
C {devices/lab_pin.sym} 24740 -20550 0 1 {name=p24276 lab=_45615_/Y }
C {sky130_stdcells/inv_2.sym} 24700 -20550 0 0 {name=X_45615_ }
C {devices/lab_pin.sym} 24640 -20440 0 0 {name=p24277 lab=_76433_/X }
C {devices/lab_pin.sym} 24640 -20400 0 0 {name=p24278 lab=_76435_/B }
C {devices/lab_pin.sym} 24760 -20420 0 1 {name=p24279 lab=_76435_/Y }
C {sky130_stdcells/xnor2_4.sym} 24700 -20420 0 0 {name=X_76435_ }
C {devices/lab_pin.sym} 24620 -20320 0 0 {name=p24280 lab=_41469_/X }
C {devices/lab_pin.sym} 24620 -20280 0 0 {name=p24281 lab=_42821_/X }
C {devices/lab_pin.sym} 24620 -20240 0 0 {name=p24282 lab=_66626_/B }
C {devices/lab_pin.sym} 24620 -20200 0 0 {name=p24283 lab=_42822_/X }
C {devices/lab_pin.sym} 24780 -20260 0 1 {name=p24284 lab=_87697_/D }
C {sky130_stdcells/a2bb2o_4.sym} 24700 -20260 0 0 {name=X_42827_ }
C {devices/lab_pin.sym} 24620 -20130 0 0 {name=p24285 lab=_58613_/B }
C {devices/lab_pin.sym} 24620 -20090 0 0 {name=p24286 lab=_49360_/X }
C {devices/lab_pin.sym} 24620 -20050 0 0 {name=p24287 lab=_49382_/Y }
C {devices/lab_pin.sym} 24780 -20090 0 1 {name=p24288 lab=_49383_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -20090 0 0 {name=X_49383_ }
C {devices/lab_pin.sym} 24640 -19970 0 0 {name=p24289 lab=_61690_/A }
C {devices/lab_pin.sym} 24640 -19930 0 0 {name=p24290 lab=_61690_/B }
C {devices/lab_pin.sym} 24640 -19890 0 0 {name=p24291 lab=_79130_/B }
C {devices/lab_pin.sym} 24760 -19930 0 1 {name=p24292 lab=_61661_/Y }
C {sky130_stdcells/nor3_4.sym} 24700 -19930 0 0 {name=X_61661_ }
C {devices/lab_pin.sym} 24620 -19810 0 0 {name=p24293 lab=_73645_/X }
C {devices/lab_pin.sym} 24620 -19770 0 0 {name=p24294 lab=_73646_/Y }
C {devices/lab_pin.sym} 24620 -19730 0 0 {name=p24295 lab=_73546_/X }
C {devices/lab_pin.sym} 24780 -19770 0 1 {name=p24296 lab=_73647_/X }
C {sky130_stdcells/a21o_4.sym} 24700 -19770 0 0 {name=X_73647_ }
C {devices/lab_pin.sym} 24660 -19630 0 0 {name=p24297 lab=_70866_/A }
C {devices/lab_pin.sym} 24740 -19630 0 1 {name=p24298 lab=_70863_/C }
C {sky130_stdcells/buf_2.sym} 24700 -19630 0 0 {name=X_70859_ }
C {devices/lab_pin.sym} 24660 -19510 0 0 {name=p24299 lab=_52571_/B }
C {devices/lab_pin.sym} 24740 -19510 0 1 {name=p24300 lab=_51394_/B }
C {sky130_stdcells/buf_2.sym} 24700 -19510 0 0 {name=X_46595_ }
C {devices/lab_pin.sym} 24640 -19410 0 0 {name=p24301 lab=_63400_/A }
C {devices/lab_pin.sym} 24640 -19370 0 0 {name=p24302 lab=_63400_/B }
C {devices/lab_pin.sym} 24640 -19330 0 0 {name=p24303 lab=_63400_/C }
C {devices/lab_pin.sym} 24760 -19370 0 1 {name=p24304 lab=_63400_/X }
C {sky130_stdcells/and3_4.sym} 24700 -19370 0 0 {name=X_63400_ }
C {devices/lab_pin.sym} 24660 -19230 0 0 {name=p24305 lab=_49223_/A }
C {devices/lab_pin.sym} 24740 -19230 0 1 {name=p24306 lab=_48401_/A }
C {sky130_stdcells/buf_2.sym} 24700 -19230 0 0 {name=X_48334_ }
C {devices/lab_pin.sym} 24640 -19130 0 0 {name=p24307 lab=_60612_/A }
C {devices/lab_pin.sym} 24640 -19090 0 0 {name=p24308 lab=_60612_/B }
C {devices/lab_pin.sym} 24640 -19050 0 0 {name=p24309 lab=_60612_/C }
C {devices/lab_pin.sym} 24760 -19090 0 1 {name=p24310 lab=_60612_/Y }
C {sky130_stdcells/nor3_4.sym} 24700 -19090 0 0 {name=X_60612_ }
C {devices/lab_pin.sym} 24640 -18960 0 0 {name=p24311 lab=_79154_/A }
C {devices/lab_pin.sym} 24640 -18920 0 0 {name=p24312 lab=_79154_/B }
C {devices/lab_pin.sym} 24760 -18940 0 1 {name=p24313 lab=_82462_/D }
C {sky130_stdcells/xor2_4.sym} 24700 -18940 0 0 {name=X_79154_ }
C {devices/lab_pin.sym} 24620 -18830 0 0 {name=p24314 lab=_45540_/X }
C {devices/lab_pin.sym} 24620 -18790 0 0 {name=p24315 lab=_45543_/X }
C {devices/lab_pin.sym} 24620 -18750 0 0 {name=p24316 lab=_45545_/Y }
C {devices/lab_pin.sym} 24780 -18790 0 1 {name=p24317 lab=_45546_/Y }
C {sky130_stdcells/a21oi_4.sym} 24700 -18790 0 0 {name=X_45546_ }
C {devices/lab_pin.sym} 24640 -18660 0 0 {name=p24318 lab=_76366_/A }
C {devices/lab_pin.sym} 24640 -18620 0 0 {name=p24319 lab=_76366_/B }
C {devices/lab_pin.sym} 24760 -18640 0 1 {name=p24320 lab=_76369_/B }
C {sky130_stdcells/nor2_4.sym} 24700 -18640 0 0 {name=X_76366_ }
C {devices/lab_pin.sym} 24660 -18510 0 0 {name=p24321 lab=_64263_/A }
C {devices/lab_pin.sym} 24740 -18510 0 1 {name=p24322 lab=_64380_/X }
C {sky130_stdcells/buf_2.sym} 24700 -18510 0 0 {name=X_64380_ }
C {devices/lab_pin.sym} 24660 -18390 0 0 {name=p24323 lab=_42680_/A }
C {devices/lab_pin.sym} 24740 -18390 0 1 {name=p24324 lab=_42822_/A }
C {sky130_stdcells/buf_2.sym} 24700 -18390 0 0 {name=X_42758_ }
C {devices/lab_pin.sym} 24620 -18300 0 0 {name=p24325 lab=_68387_/B }
C {devices/lab_pin.sym} 24620 -18260 0 0 {name=p24326 lab=_73030_/X }
C {devices/lab_pin.sym} 24620 -18220 0 0 {name=p24327 lab=_73486_/X }
C {devices/lab_pin.sym} 24620 -18180 0 0 {name=p24328 lab=_73577_/Y }
C {devices/lab_pin.sym} 24780 -18240 0 1 {name=p24329 lab=_73578_/X }
C {sky130_stdcells/a211o_4.sym} 24700 -18240 0 0 {name=X_73578_ }
C {devices/lab_pin.sym} 24660 -18090 0 0 {name=p24330 lab=_61400_/X }
C {devices/lab_pin.sym} 24740 -18090 0 1 {name=p24331 lab=_61619_/C }
C {sky130_stdcells/buf_2.sym} 24700 -18090 0 0 {name=X_61592_ }
C {devices/lab_pin.sym} 24620 -17990 0 0 {name=p24332 lab=_78103_/Y }
C {devices/lab_pin.sym} 24620 -17950 0 0 {name=p24333 lab=_78099_/Y }
C {devices/lab_pin.sym} 24620 -17910 0 0 {name=p24334 lab=_78104_/Y }
C {devices/lab_pin.sym} 24780 -17950 0 1 {name=p24335 lab=_78105_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -17950 0 0 {name=X_78105_ }
C {devices/lab_pin.sym} 24660 -17810 0 0 {name=p24336 lab=_81075_/Q }
C {devices/lab_pin.sym} 24740 -17810 0 1 {name=p24337 lab=_75317_/Y }
C {sky130_stdcells/inv_2.sym} 24700 -17810 0 0 {name=X_75317_ }
C {devices/lab_pin.sym} 24640 -17720 0 0 {name=p24338 lab=_60454_/A }
C {devices/lab_pin.sym} 24640 -17680 0 0 {name=p24339 lab=_64535_/B }
C {devices/lab_pin.sym} 24640 -17640 0 0 {name=p24340 lab=_60441_/B }
C {devices/lab_pin.sym} 24640 -17600 0 0 {name=p24341 lab=_60473_/B }
C {devices/lab_pin.sym} 24760 -17660 0 1 {name=p24342 lab=_63331_/X }
C {sky130_stdcells/and4_4.sym} 24700 -17660 0 0 {name=X_63331_ }
C {devices/lab_pin.sym} 24620 -17530 0 0 {name=p24343 lab=_41628_/X }
C {devices/lab_pin.sym} 24620 -17490 0 0 {name=p24344 lab=_81746_/Q }
C {devices/lab_pin.sym} 24620 -17450 0 0 {name=p24345 lab=_41708_/X }
C {devices/lab_pin.sym} 24780 -17490 0 1 {name=p24346 lab=_41709_/X }
C {sky130_stdcells/o21a_4.sym} 24700 -17490 0 0 {name=X_41709_ }
C {devices/lab_pin.sym} 24640 -17360 0 0 {name=p24347 lab=_48264_/X }
C {devices/lab_pin.sym} 24640 -17320 0 0 {name=p24348 lab=_50310_/B }
C {devices/lab_pin.sym} 24760 -17340 0 1 {name=p24349 lab=_48265_/Y }
C {sky130_stdcells/nand2_4.sym} 24700 -17340 0 0 {name=X_48265_ }
C {devices/lab_pin.sym} 24640 -17230 0 0 {name=p24350 lab=_60481_/A }
C {devices/lab_pin.sym} 24640 -17190 0 0 {name=p24351 lab=_60543_/B }
C {devices/lab_pin.sym} 24640 -17150 0 0 {name=p24352 lab=_60542_/Y }
C {devices/lab_pin.sym} 24760 -17190 0 1 {name=p24353 lab=_60543_/Y }
C {sky130_stdcells/nand3_4.sym} 24700 -17190 0 0 {name=X_60543_ }
C {devices/lab_pin.sym} 24640 -17070 0 0 {name=p24354 lab=_72528_/Y }
C {devices/lab_pin.sym} 24640 -17030 0 0 {name=p24355 lab=_72550_/C }
C {devices/lab_pin.sym} 24640 -16990 0 0 {name=p24356 lab=_72529_/C }
C {devices/lab_pin.sym} 24760 -17030 0 1 {name=p24357 lab=_72530_/A }
C {sky130_stdcells/nand3_4.sym} 24700 -17030 0 0 {name=X_72529_ }
C {devices/lab_pin.sym} 24640 -16900 0 0 {name=p24358 lab=_82800_/D }
C {devices/lab_pin.sym} 24640 -16860 0 0 {name=p24359 lab=_82544_/Q }
C {devices/lab_pin.sym} 24760 -16880 0 1 {name=p24360 lab=_79086_/B }
C {sky130_stdcells/xnor2_4.sym} 24700 -16880 0 0 {name=X_79085_ }
C {devices/lab_pin.sym} 24620 -16780 0 0 {name=p24361 lab=_45474_/Y }
C {devices/lab_pin.sym} 24620 -16740 0 0 {name=p24362 lab=_45412_/X }
C {devices/lab_pin.sym} 24620 -16700 0 0 {name=p24363 lab=_45443_/X }
C {devices/lab_pin.sym} 24620 -16660 0 0 {name=p24364 lab=_45476_/Y }
C {devices/lab_pin.sym} 24780 -16720 0 1 {name=p24365 lab=_45477_/X }
C {sky130_stdcells/a211o_4.sym} 24700 -16720 0 0 {name=X_45477_ }
C {devices/lab_pin.sym} 24640 -16580 0 0 {name=p24366 lab=_81356_/Q }
C {devices/lab_pin.sym} 24640 -16540 0 0 {name=p24367 lab=_76297_/B }
C {devices/lab_pin.sym} 24760 -16560 0 1 {name=p24368 lab=_76297_/X }
C {sky130_stdcells/xor2_4.sym} 24700 -16560 0 0 {name=X_76297_ }
C {devices/lab_pin.sym} 24620 -16470 0 0 {name=p24369 lab=_42687_/X }
C {devices/lab_pin.sym} 24620 -16430 0 0 {name=p24370 lab=_42688_/X }
C {devices/lab_pin.sym} 24620 -16390 0 0 {name=p24371 lab=_41082_/X }
C {devices/lab_pin.sym} 24620 -16350 0 0 {name=p24372 lab=_87769_/Q }
C {devices/lab_pin.sym} 24620 -16310 0 0 {name=p24373 lab=_42673_/X }
C {devices/lab_pin.sym} 24780 -16390 0 1 {name=p24374 lab=_42689_/Y }
C {sky130_stdcells/o32ai_4.sym} 24700 -16390 0 0 {name=X_42689_ }
C {devices/lab_pin.sym} 24660 -16230 0 0 {name=p24375 lab=_82370_/Q }
C {devices/lab_pin.sym} 24740 -16230 0 1 {name=p24376 lab=_54612_/D }
C {sky130_stdcells/inv_2.sym} 24700 -16230 0 0 {name=X_47216_ }
C {devices/lab_pin.sym} 24640 -16120 0 0 {name=p24377 lab=_65992_/A }
C {devices/lab_pin.sym} 24640 -16080 0 0 {name=p24378 lab=_85911_/Q }
C {devices/lab_pin.sym} 24760 -16100 0 1 {name=p24379 lab=_66050_/X }
C {sky130_stdcells/and2_4.sym} 24700 -16100 0 0 {name=X_66050_ }
C {devices/lab_pin.sym} 24640 -15990 0 0 {name=p24380 lab=_78033_/A }
C {devices/lab_pin.sym} 24640 -15950 0 0 {name=p24381 lab=_82177_/Q }
C {devices/lab_pin.sym} 24640 -15910 0 0 {name=p24382 lab=_78033_/B }
C {devices/lab_pin.sym} 24760 -15950 0 1 {name=p24383 lab=_78037_/B }
C {sky130_stdcells/nand3_4.sym} 24700 -15950 0 0 {name=X_78036_ }
C {devices/lab_pin.sym} 24660 -15810 0 0 {name=p24384 lab=_44352_/X }
C {devices/lab_pin.sym} 24740 -15810 0 1 {name=p24385 lab=_44428_/X }
C {sky130_stdcells/buf_2.sym} 24700 -15810 0 0 {name=X_44428_ }
C {devices/lab_pin.sym} 24660 -15690 0 0 {name=p24386 lab=_60458_/X }
C {devices/lab_pin.sym} 24740 -15690 0 1 {name=p24387 lab=_63332_/D }
C {sky130_stdcells/buf_2.sym} 24700 -15690 0 0 {name=X_63262_ }
C {devices/lab_pin.sym} 24620 -15590 0 0 {name=p24388 lab=_75243_/Y }
C {devices/lab_pin.sym} 24620 -15550 0 0 {name=p24389 lab=_75219_/Y }
C {devices/lab_pin.sym} 24620 -15510 0 0 {name=p24390 lab=_75247_/X }
C {devices/lab_pin.sym} 24780 -15550 0 1 {name=p24391 lab=_75248_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -15550 0 0 {name=X_75248_ }
C {devices/lab_pin.sym} 24640 -15420 0 0 {name=p24392 lab=_60493_/A }
C {devices/lab_pin.sym} 24640 -15380 0 0 {name=p24393 lab=_60556_/B }
C {devices/lab_pin.sym} 24760 -15400 0 1 {name=p24394 lab=_60475_/A }
C {sky130_stdcells/nand2_4.sym} 24700 -15400 0 0 {name=X_60474_ }
C {devices/lab_pin.sym} 24640 -15290 0 0 {name=p24395 lab=_48196_/A }
C {devices/lab_pin.sym} 24640 -15250 0 0 {name=p24396 lab=_46487_/B }
C {devices/lab_pin.sym} 24640 -15210 0 0 {name=p24397 lab=_48195_/X }
C {devices/lab_pin.sym} 24760 -15250 0 1 {name=p24398 lab=_48196_/X }
C {sky130_stdcells/and3_4.sym} 24700 -15250 0 0 {name=X_48196_ }
C {devices/lab_pin.sym} 24620 -15140 0 0 {name=p24399 lab=_64999_/X }
C {devices/lab_pin.sym} 24620 -15100 0 0 {name=p24400 lab=_86130_/Q }
C {devices/lab_pin.sym} 24620 -15060 0 0 {name=p24401 lab=_64927_/X }
C {devices/lab_pin.sym} 24620 -15020 0 0 {name=p24402 lab=_65000_/X }
C {devices/lab_pin.sym} 24780 -15080 0 1 {name=p24403 lab=_65001_/X }
C {sky130_stdcells/a211o_4.sym} 24700 -15080 0 0 {name=X_65001_ }
C {devices/lab_pin.sym} 24660 -14930 0 0 {name=p24404 lab=_62572_/A }
C {devices/lab_pin.sym} 24740 -14930 0 1 {name=p24405 lab=_62214_/A }
C {sky130_stdcells/buf_2.sym} 24700 -14930 0 0 {name=X_62213_ }
C {devices/lab_pin.sym} 24660 -14810 0 0 {name=p24406 lab=_47147_/A }
C {devices/lab_pin.sym} 24740 -14810 0 1 {name=p24407 lab=_47150_/A }
C {sky130_stdcells/buf_2.sym} 24700 -14810 0 0 {name=X_47147_ }
C {devices/lab_pin.sym} 24620 -14720 0 0 {name=p24408 lab=_41731_/X }
C {devices/lab_pin.sym} 24620 -14680 0 0 {name=p24409 lab=_44345_/X }
C {devices/lab_pin.sym} 24620 -14640 0 0 {name=p24410 lab=_87148_/Q }
C {devices/lab_pin.sym} 24620 -14600 0 0 {name=p24411 lab=_44346_/X }
C {devices/lab_pin.sym} 24780 -14660 0 1 {name=p24412 lab=_87148_/D }
C {sky130_stdcells/a2bb2o_4.sym} 24700 -14660 0 0 {name=X_44359_ }
C {devices/lab_pin.sym} 24660 -14510 0 0 {name=p24413 lab=_60458_/X }
C {devices/lab_pin.sym} 24740 -14510 0 1 {name=p24414 lab=_63239_/D }
C {sky130_stdcells/buf_2.sym} 24700 -14510 0 0 {name=X_63193_ }
C {devices/lab_pin.sym} 24660 -14390 0 0 {name=p24415 lab=_75179_/A }
C {devices/lab_pin.sym} 24740 -14390 0 1 {name=p24416 lab=_75179_/Y }
C {sky130_stdcells/inv_2.sym} 24700 -14390 0 0 {name=X_75179_ }
C {devices/lab_pin.sym} 24640 -14290 0 0 {name=p24417 lab=_62144_/A }
C {devices/lab_pin.sym} 24640 -14250 0 0 {name=p24418 lab=_62121_/X }
C {devices/lab_pin.sym} 24640 -14210 0 0 {name=p24419 lab=_78053_/B }
C {devices/lab_pin.sym} 24760 -14250 0 1 {name=p24420 lab=_62144_/Y }
C {sky130_stdcells/nor3_4.sym} 24700 -14250 0 0 {name=X_62144_ }
C {devices/lab_pin.sym} 24660 -14110 0 0 {name=p24421 lab=_53360_/B }
C {devices/lab_pin.sym} 24740 -14110 0 1 {name=p24422 lab=_52843_/B }
C {sky130_stdcells/buf_2.sym} 24700 -14110 0 0 {name=X_47078_ }
C {devices/lab_pin.sym} 24640 -14010 0 0 {name=p24423 lab=_79985_/Y }
C {devices/lab_pin.sym} 24640 -13970 0 0 {name=p24424 lab=_79972_/Y }
C {devices/lab_pin.sym} 24640 -13930 0 0 {name=p24425 lab=_79973_/Y }
C {devices/lab_pin.sym} 24760 -13970 0 1 {name=p24426 lab=_79988_/B }
C {sky130_stdcells/nand3_4.sym} 24700 -13970 0 0 {name=X_79987_ }
C {devices/lab_pin.sym} 24660 -13830 0 0 {name=p24427 lab=_45962_/X }
C {devices/lab_pin.sym} 24740 -13830 0 1 {name=p24428 lab=_46029_/X }
C {sky130_stdcells/buf_2.sym} 24700 -13830 0 0 {name=X_46029_ }
C {devices/lab_pin.sym} 24640 -13720 0 0 {name=p24429 lab=_69680_/A }
C {devices/lab_pin.sym} 24640 -13680 0 0 {name=p24430 lab=_69740_/B }
C {devices/lab_pin.sym} 24760 -13700 0 1 {name=p24431 lab=_69740_/X }
C {sky130_stdcells/and2_4.sym} 24700 -13700 0 0 {name=X_69740_ }
C {devices/lab_pin.sym} 24620 -13590 0 0 {name=p24432 lab=_66949_/X }
C {devices/lab_pin.sym} 24620 -13550 0 0 {name=p24433 lab=_66951_/X }
C {devices/lab_pin.sym} 24620 -13510 0 0 {name=p24434 lab=_66905_/X }
C {devices/lab_pin.sym} 24780 -13550 0 1 {name=p24435 lab=_66952_/X }
C {sky130_stdcells/a21o_4.sym} 24700 -13550 0 0 {name=X_66952_ }
C {devices/lab_pin.sym} 24660 -13410 0 0 {name=p24436 lab=_84891_/Q }
C {devices/lab_pin.sym} 24740 -13410 0 1 {name=p24437 lab=_63629_/B }
C {sky130_stdcells/buf_2.sym} 24700 -13410 0 0 {name=X_62075_ }
C {devices/lab_pin.sym} 24640 -13300 0 0 {name=p24438 lab=_78938_/A }
C {devices/lab_pin.sym} 24640 -13260 0 0 {name=p24439 lab=_78952_/A }
C {devices/lab_pin.sym} 24760 -13280 0 1 {name=p24440 lab=_78939_/B }
C {sky130_stdcells/xor2_4.sym} 24700 -13280 0 0 {name=X_78938_ }
C {devices/lab_pin.sym} 24660 -13150 0 0 {name=p24441 lab=_65516_/A }
C {devices/lab_pin.sym} 24740 -13150 0 1 {name=p24442 lab=_65903_/X }
C {sky130_stdcells/buf_2.sym} 24700 -13150 0 0 {name=X_65903_ }
C {devices/lab_pin.sym} 24620 -13070 0 0 {name=p24443 lab=_60968_/X }
C {devices/lab_pin.sym} 24620 -13030 0 0 {name=p24444 lab=_61024_/Y }
C {devices/lab_pin.sym} 24620 -12990 0 0 {name=p24445 lab=_61025_/X }
C {devices/lab_pin.sym} 24620 -12950 0 0 {name=p24446 lab=_84536_/Q }
C {devices/lab_pin.sym} 24620 -12910 0 0 {name=p24447 lab=_61020_/X }
C {devices/lab_pin.sym} 24780 -12990 0 1 {name=p24448 lab=_84536_/D }
C {sky130_stdcells/o32a_4.sym} 24700 -12990 0 0 {name=X_61026_ }
C {devices/lab_pin.sym} 24620 -12850 0 0 {name=p24449 lab=_81978_/D }
C {devices/lab_pin.sym} 24620 -12810 0 0 {name=p24450 lab=_69632_/X }
C {devices/lab_pin.sym} 24620 -12770 0 0 {name=p24451 lab=_69670_/X }
C {devices/lab_pin.sym} 24780 -12810 0 1 {name=p24452 lab=_83906_/D }
C {sky130_stdcells/a21bo_4.sym} 24700 -12810 0 0 {name=X_69671_ }
C {devices/lab_pin.sym} 24660 -12670 0 0 {name=p24453 lab=_66647_/A }
C {devices/lab_pin.sym} 24740 -12670 0 1 {name=p24454 lab=_66956_/A }
C {sky130_stdcells/buf_2.sym} 24700 -12670 0 0 {name=X_66883_ }
C {devices/lab_pin.sym} 24640 -12560 0 0 {name=p24455 lab=_78869_/A }
C {devices/lab_pin.sym} 24640 -12520 0 0 {name=p24456 lab=_78869_/B }
C {devices/lab_pin.sym} 24760 -12540 0 1 {name=p24457 lab=_78869_/X }
C {sky130_stdcells/xor2_4.sym} 24700 -12540 0 0 {name=X_78869_ }
C {devices/lab_pin.sym} 24610 -12410 0 0 {name=p24458 lab=_84074_/CLK }
C {devices/lab_pin.sym} 24610 -12390 0 0 {name=p24459 lab=_80900_/D }
C {devices/lab_pin.sym} 24790 -12410 0 1 {name=p24460 lab=_80900_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -12400 0 0 {name=X_80900_ }
C {devices/lab_pin.sym} 24620 -12300 0 0 {name=p24461 lab=_86997_/Q }
C {devices/lab_pin.sym} 24620 -12260 0 0 {name=p24462 lab=_68472_/X }
C {devices/lab_pin.sym} 24620 -12220 0 0 {name=p24463 lab=_68473_/X }
C {devices/lab_pin.sym} 24620 -12180 0 0 {name=p24464 lab=_68621_/X }
C {devices/lab_pin.sym} 24780 -12240 0 1 {name=p24465 lab=_68622_/X }
C {sky130_stdcells/a211o_4.sym} 24700 -12240 0 0 {name=X_68622_ }
C {devices/lab_pin.sym} 24640 -12100 0 0 {name=p24466 lab=_57788_/X }
C {devices/lab_pin.sym} 24640 -12060 0 0 {name=p24467 lab=_85862_/Q }
C {devices/lab_pin.sym} 24760 -12080 0 1 {name=p24468 lab=_65834_/X }
C {sky130_stdcells/and2_4.sym} 24700 -12080 0 0 {name=X_65834_ }
C {devices/lab_pin.sym} 24610 -11950 0 0 {name=p24469 lab=_81928_/CLK }
C {devices/lab_pin.sym} 24610 -11930 0 0 {name=p24470 lab=_78071_/X }
C {devices/lab_pin.sym} 24790 -11950 0 1 {name=p24471 lab=_81880_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -11940 0 0 {name=X_81880_ }
C {devices/lab_pin.sym} 24640 -11840 0 0 {name=p24472 lab=_49708_/A }
C {devices/lab_pin.sym} 24640 -11800 0 0 {name=p24473 lab=_49697_/B }
C {devices/lab_pin.sym} 24640 -11760 0 0 {name=p24474 lab=_49724_/C }
C {devices/lab_pin.sym} 24640 -11720 0 0 {name=p24475 lab=_52934_/D }
C {devices/lab_pin.sym} 24760 -11780 0 1 {name=p24476 lab=_49719_/X }
C {sky130_stdcells/and4_4.sym} 24700 -11780 0 0 {name=X_49719_ }
C {devices/lab_pin.sym} 24610 -11630 0 0 {name=p24477 lab=_81065_/CLK }
C {devices/lab_pin.sym} 24610 -11610 0 0 {name=p24478 lab=_83975_/Q }
C {devices/lab_pin.sym} 24790 -11630 0 1 {name=p24479 lab=_80831_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -11620 0 0 {name=X_80831_ }
C {devices/lab_pin.sym} 24640 -11500 0 0 {name=p24480 lab=_68553_/A }
C {devices/lab_pin.sym} 24640 -11460 0 0 {name=p24481 lab=_87340_/Q }
C {devices/lab_pin.sym} 24760 -11480 0 1 {name=p24482 lab=_68553_/X }
C {sky130_stdcells/and2_4.sym} 24700 -11480 0 0 {name=X_68553_ }
C {devices/lab_pin.sym} 24640 -11360 0 0 {name=p24483 lab=_65735_/A }
C {devices/lab_pin.sym} 24640 -11320 0 0 {name=p24484 lab=_86475_/Q }
C {devices/lab_pin.sym} 24760 -11340 0 1 {name=p24485 lab=_65765_/X }
C {sky130_stdcells/and2_4.sym} 24700 -11340 0 0 {name=X_65765_ }
C {devices/lab_pin.sym} 24660 -11210 0 0 {name=p24486 lab=_50991_/A }
C {devices/lab_pin.sym} 24740 -11210 0 1 {name=p24487 lab=_51101_/A }
C {sky130_stdcells/buf_2.sym} 24700 -11210 0 0 {name=X_50991_ }
C {devices/lab_pin.sym} 24640 -11110 0 0 {name=p24488 lab=_62988_/A }
C {devices/lab_pin.sym} 24640 -11070 0 0 {name=p24489 lab=_62988_/B }
C {devices/lab_pin.sym} 24640 -11030 0 0 {name=p24490 lab=_84364_/Q }
C {devices/lab_pin.sym} 24760 -11070 0 1 {name=p24491 lab=_62977_/Y }
C {sky130_stdcells/nor3_4.sym} 24700 -11070 0 0 {name=X_62977_ }
C {devices/lab_pin.sym} 24640 -10940 0 0 {name=p24492 lab=_67575_/A }
C {devices/lab_pin.sym} 24640 -10900 0 0 {name=p24493 lab=_88172_/Q }
C {devices/lab_pin.sym} 24760 -10920 0 1 {name=p24494 lab=_67504_/X }
C {sky130_stdcells/and2_4.sym} 24700 -10920 0 0 {name=X_67504_ }
C {devices/lab_pin.sym} 24640 -10820 0 0 {name=p24495 lab=_52729_/X }
C {devices/lab_pin.sym} 24640 -10780 0 0 {name=p24496 lab=_52724_/B }
C {devices/lab_pin.sym} 24640 -10740 0 0 {name=p24497 lab=_52708_/X }
C {devices/lab_pin.sym} 24640 -10700 0 0 {name=p24498 lab=_52730_/D }
C {devices/lab_pin.sym} 24760 -10760 0 1 {name=p24499 lab=_52730_/X }
C {sky130_stdcells/and4_4.sym} 24700 -10760 0 0 {name=X_52730_ }
C {devices/lab_pin.sym} 24660 -10610 0 0 {name=p24500 lab=_65790_/A }
C {devices/lab_pin.sym} 24740 -10610 0 1 {name=p24501 lab=_64716_/X }
C {sky130_stdcells/buf_2.sym} 24700 -10610 0 0 {name=X_64716_ }
C {devices/lab_pin.sym} 24610 -10490 0 0 {name=p24502 lab=_83550_/CLK }
C {devices/lab_pin.sym} 24610 -10470 0 0 {name=p24503 lab=_83550_/D }
C {devices/lab_pin.sym} 24790 -10490 0 1 {name=p24504 lab=_47704_/A }
C {sky130_stdcells/dfxtp_4.sym} 24700 -10480 0 0 {name=X_83550_ }
C {devices/lab_pin.sym} 24620 -10370 0 0 {name=p24505 lab=_61926_/Y }
C {devices/lab_pin.sym} 24620 -10330 0 0 {name=p24506 lab=_61881_/X }
C {devices/lab_pin.sym} 24620 -10290 0 0 {name=p24507 lab=_61927_/Y }
C {devices/lab_pin.sym} 24780 -10330 0 1 {name=p24508 lab=_84445_/D }
C {sky130_stdcells/a21oi_4.sym} 24700 -10330 0 0 {name=X_61928_ }
C {devices/lab_pin.sym} 24620 -10210 0 0 {name=p24509 lab=_68481_/X }
C {devices/lab_pin.sym} 24620 -10170 0 0 {name=p24510 lab=_68483_/X }
C {devices/lab_pin.sym} 24620 -10130 0 0 {name=p24511 lab=_68429_/X }
C {devices/lab_pin.sym} 24780 -10170 0 1 {name=p24512 lab=_68484_/X }
C {sky130_stdcells/a21o_4.sym} 24700 -10170 0 0 {name=X_68484_ }
C {devices/lab_pin.sym} 24610 -10030 0 0 {name=p24513 lab=_81994_/CLK }
C {devices/lab_pin.sym} 24610 -10010 0 0 {name=p24514 lab=_75440_/X }
C {devices/lab_pin.sym} 24790 -10030 0 1 {name=p24515 lab=_80762_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -10020 0 0 {name=X_80762_ }
C {devices/lab_pin.sym} 24620 -9910 0 0 {name=p24516 lab=_65533_/X }
C {devices/lab_pin.sym} 24620 -9870 0 0 {name=p24517 lab=_65694_/Y }
C {devices/lab_pin.sym} 24620 -9830 0 0 {name=p24518 lab=_65695_/Y }
C {devices/lab_pin.sym} 24780 -9870 0 1 {name=p24519 lab=_65696_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -9870 0 0 {name=X_65696_ }
C {devices/lab_pin.sym} 24610 -9730 0 0 {name=p24520 lab=_82942_/CLK }
C {devices/lab_pin.sym} 24610 -9710 0 0 {name=p24521 lab=_82501_/D }
C {devices/lab_pin.sym} 24790 -9730 0 1 {name=p24522 lab=_78356_/A }
C {sky130_stdcells/dfxtp_4.sym} 24700 -9720 0 0 {name=X_82501_ }
C {devices/lab_pin.sym} 24620 -9620 0 0 {name=p24523 lab=_87163_/Q }
C {devices/lab_pin.sym} 24620 -9580 0 0 {name=p24524 lab=_67432_/X }
C {devices/lab_pin.sym} 24620 -9540 0 0 {name=p24525 lab=_67433_/X }
C {devices/lab_pin.sym} 24620 -9500 0 0 {name=p24526 lab=_67434_/X }
C {devices/lab_pin.sym} 24780 -9560 0 1 {name=p24527 lab=_67435_/X }
C {sky130_stdcells/a211o_4.sym} 24700 -9560 0 0 {name=X_67435_ }
C {devices/lab_pin.sym} 24640 -9440 0 0 {name=p24528 lab=_52648_/X }
C {devices/lab_pin.sym} 24640 -9400 0 0 {name=p24529 lab=_52661_/B }
C {devices/lab_pin.sym} 24640 -9360 0 0 {name=p24530 lab=_52654_/C }
C {devices/lab_pin.sym} 24640 -9320 0 0 {name=p24531 lab=_52661_/D }
C {devices/lab_pin.sym} 24760 -9380 0 1 {name=p24532 lab=_52661_/X }
C {sky130_stdcells/and4_4.sym} 24700 -9380 0 0 {name=X_52661_ }
C {devices/lab_pin.sym} 24640 -9240 0 0 {name=p24533 lab=_64773_/A }
C {devices/lab_pin.sym} 24640 -9200 0 0 {name=p24534 lab=_64647_/B }
C {devices/lab_pin.sym} 24760 -9220 0 1 {name=p24535 lab=_64647_/X }
C {sky130_stdcells/and2_4.sym} 24700 -9220 0 0 {name=X_64647_ }
C {devices/lab_pin.sym} 24610 -9090 0 0 {name=p24536 lab=_83415_/CLK }
C {devices/lab_pin.sym} 24610 -9070 0 0 {name=p24537 lab=_71490_/X }
C {devices/lab_pin.sym} 24790 -9090 0 1 {name=p24538 lab=_83481_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -9080 0 0 {name=X_83481_ }
C {devices/lab_pin.sym} 24660 -8950 0 0 {name=p24539 lab=_59823_/X }
C {devices/lab_pin.sym} 24740 -8950 0 1 {name=p24540 lab=_61860_/D }
C {sky130_stdcells/buf_2.sym} 24700 -8950 0 0 {name=X_61859_ }
C {devices/lab_pin.sym} 24610 -8830 0 0 {name=p24541 lab=_80697_/CLK }
C {devices/lab_pin.sym} 24610 -8810 0 0 {name=p24542 lab=_80725_/Q }
C {devices/lab_pin.sym} 24790 -8830 0 1 {name=p24543 lab=_80693_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -8820 0 0 {name=X_80693_ }
C {devices/lab_pin.sym} 24660 -8690 0 0 {name=p24544 lab=_54400_/A }
C {devices/lab_pin.sym} 24740 -8690 0 1 {name=p24545 lab=_54401_/A }
C {sky130_stdcells/buf_2.sym} 24700 -8690 0 0 {name=X_54400_ }
C {devices/lab_pin.sym} 24610 -8570 0 0 {name=p24546 lab=_85186_/CLK }
C {devices/lab_pin.sym} 24610 -8550 0 0 {name=p24547 lab=_85220_/D }
C {devices/lab_pin.sym} 24790 -8570 0 1 {name=p24548 lab=_55722_/B }
C {sky130_stdcells/dfxtp_4.sym} 24700 -8560 0 0 {name=X_85220_ }
C {devices/lab_pin.sym} 24620 -8450 0 0 {name=p24549 lab=_85978_/Q }
C {devices/lab_pin.sym} 24620 -8410 0 0 {name=p24550 lab=_51594_/X }
C {devices/lab_pin.sym} 24620 -8370 0 0 {name=p24551 lab=_51611_/Y }
C {devices/lab_pin.sym} 24780 -8410 0 1 {name=p24552 lab=_51612_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -8410 0 0 {name=X_51612_ }
C {devices/lab_pin.sym} 24610 -8270 0 0 {name=p24553 lab=_82462_/CLK }
C {devices/lab_pin.sym} 24610 -8250 0 0 {name=p24554 lab=_82464_/Q }
C {devices/lab_pin.sym} 24790 -8270 0 1 {name=p24555 lab=_78788_/A }
C {sky130_stdcells/dfxtp_4.sym} 24700 -8260 0 0 {name=X_82432_ }
C {devices/lab_pin.sym} 24620 -8150 0 0 {name=p24556 lab=_55383_/A }
C {devices/lab_pin.sym} 24620 -8110 0 0 {name=p24557 lab=_55377_/Y }
C {devices/lab_pin.sym} 24620 -8070 0 0 {name=p24558 lab=_55379_/Y }
C {devices/lab_pin.sym} 24780 -8110 0 1 {name=p24559 lab=_55380_/Y }
C {sky130_stdcells/a21oi_4.sym} 24700 -8110 0 0 {name=X_55380_ }
C {devices/lab_pin.sym} 24620 -8000 0 0 {name=p24560 lab=_87166_/Q }
C {devices/lab_pin.sym} 24620 -7960 0 0 {name=p24561 lab=_67311_/X }
C {devices/lab_pin.sym} 24620 -7920 0 0 {name=p24562 lab=_67313_/X }
C {devices/lab_pin.sym} 24620 -7880 0 0 {name=p24563 lab=_67365_/X }
C {devices/lab_pin.sym} 24780 -7940 0 1 {name=p24564 lab=_67366_/X }
C {sky130_stdcells/a211o_4.sym} 24700 -7940 0 0 {name=X_67366_ }
C {devices/lab_pin.sym} 24660 -7790 0 0 {name=p24565 lab=_52496_/A }
C {devices/lab_pin.sym} 24740 -7790 0 1 {name=p24566 lab=_52592_/X }
C {sky130_stdcells/buf_2.sym} 24700 -7790 0 0 {name=X_52592_ }
C {devices/lab_pin.sym} 24660 -7670 0 0 {name=p24567 lab=_44170_/A }
C {devices/lab_pin.sym} 24740 -7670 0 1 {name=p24568 lab=_64772_/A }
C {sky130_stdcells/buf_2.sym} 24700 -7670 0 0 {name=X_64578_ }
C {sky130_stdcells/decap_3.sym} 24700 -7520 0 0 {name=XPHY_707 }
C {devices/lab_pin.sym} 24620 -7400 0 0 {name=p24569 lab=_87073_/Q }
C {devices/lab_pin.sym} 24620 -7360 0 0 {name=p24570 lab=_69058_/X }
C {devices/lab_pin.sym} 24620 -7320 0 0 {name=p24571 lab=_69103_/X }
C {devices/lab_pin.sym} 24620 -7280 0 0 {name=p24572 lab=_69104_/X }
C {devices/lab_pin.sym} 24780 -7340 0 1 {name=p24573 lab=_69105_/X }
C {sky130_stdcells/a211o_4.sym} 24700 -7340 0 0 {name=X_69105_ }
C {devices/lab_pin.sym} 24620 -7210 0 0 {name=p24574 lab=_54328_/Y }
C {devices/lab_pin.sym} 24620 -7170 0 0 {name=p24575 lab=_54311_/X }
C {devices/lab_pin.sym} 24620 -7130 0 0 {name=p24576 lab=_54330_/X }
C {devices/lab_pin.sym} 24780 -7170 0 1 {name=p24577 lab=_85462_/D }
C {sky130_stdcells/a21oi_4.sym} 24700 -7170 0 0 {name=X_54331_ }
C {devices/lab_pin.sym} 24620 -7050 0 0 {name=p24578 lab=_66294_/X }
C {devices/lab_pin.sym} 24620 -7010 0 0 {name=p24579 lab=_66315_/Y }
C {devices/lab_pin.sym} 24620 -6970 0 0 {name=p24580 lab=_66316_/Y }
C {devices/lab_pin.sym} 24780 -7010 0 1 {name=p24581 lab=_66317_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -7010 0 0 {name=X_66317_ }
C {devices/lab_pin.sym} 24610 -6870 0 0 {name=p24582 lab=_85213_/CLK }
C {devices/lab_pin.sym} 24610 -6850 0 0 {name=p24583 lab=_85151_/D }
C {devices/lab_pin.sym} 24790 -6870 0 1 {name=p24584 lab=_55622_/B }
C {sky130_stdcells/dfxtp_4.sym} 24700 -6860 0 0 {name=X_85151_ }
C {devices/lab_pin.sym} 24640 -6760 0 0 {name=p24585 lab=_51521_/X }
C {devices/lab_pin.sym} 24640 -6720 0 0 {name=p24586 lab=_51553_/B }
C {devices/lab_pin.sym} 24640 -6680 0 0 {name=p24587 lab=_51533_/C }
C {devices/lab_pin.sym} 24640 -6640 0 0 {name=p24588 lab=_53070_/D }
C {devices/lab_pin.sym} 24760 -6700 0 1 {name=p24589 lab=_51543_/X }
C {sky130_stdcells/and4_4.sym} 24700 -6700 0 0 {name=X_51543_ }
C {devices/lab_pin.sym} 24660 -6550 0 0 {name=p24590 lab=_63468_/A }
C {devices/lab_pin.sym} 24740 -6550 0 1 {name=p24591 lab=_63554_/B }
C {sky130_stdcells/buf_2.sym} 24700 -6550 0 0 {name=X_63529_ }
C {devices/lab_pin.sym} 24610 -6430 0 0 {name=p24592 lab=_84981_/CLK }
C {devices/lab_pin.sym} 24610 -6410 0 0 {name=p24593 lab=_82363_/D }
C {devices/lab_pin.sym} 24790 -6430 0 1 {name=p24594 lab=_82363_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -6420 0 0 {name=X_82363_ }
C {devices/lab_pin.sym} 24620 -6320 0 0 {name=p24595 lab=_87413_/Q }
C {devices/lab_pin.sym} 24620 -6280 0 0 {name=p24596 lab=_67274_/X }
C {devices/lab_pin.sym} 24620 -6240 0 0 {name=p24597 lab=_67226_/X }
C {devices/lab_pin.sym} 24620 -6200 0 0 {name=p24598 lab=_67296_/X }
C {devices/lab_pin.sym} 24780 -6260 0 1 {name=p24599 lab=_67297_/X }
C {sky130_stdcells/a211o_4.sym} 24700 -6260 0 0 {name=X_67297_ }
C {devices/lab_pin.sym} 24610 -6110 0 0 {name=p24600 lab=_81169_/CLK }
C {devices/lab_pin.sym} 24610 -6090 0 0 {name=p24601 lab=_84102_/D }
C {devices/lab_pin.sym} 24790 -6110 0 1 {name=p24602 lab=_84102_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -6100 0 0 {name=X_84102_ }
C {devices/lab_pin.sym} 24640 -5980 0 0 {name=p24603 lab=_57050_/A }
C {devices/lab_pin.sym} 24640 -5940 0 0 {name=p24604 lab=_56953_/A }
C {devices/lab_pin.sym} 24760 -5960 0 1 {name=p24605 lab=_57051_/A }
C {sky130_stdcells/nand2_4.sym} 24700 -5960 0 0 {name=X_57050_ }
C {devices/lab_pin.sym} 24610 -5830 0 0 {name=p24606 lab=_84020_/CLK }
C {devices/lab_pin.sym} 24610 -5810 0 0 {name=p24607 lab=_76157_/X }
C {devices/lab_pin.sym} 24790 -5830 0 1 {name=p24608 lab=_81722_/D }
C {sky130_stdcells/dfxtp_4.sym} 24700 -5820 0 0 {name=X_81314_ }
C {devices/lab_pin.sym} 24620 -5710 0 0 {name=p24609 lab=_69032_/X }
C {devices/lab_pin.sym} 24620 -5670 0 0 {name=p24610 lab=_69034_/X }
C {devices/lab_pin.sym} 24620 -5630 0 0 {name=p24611 lab=_69035_/X }
C {devices/lab_pin.sym} 24780 -5670 0 1 {name=p24612 lab=_69036_/X }
C {sky130_stdcells/a21o_4.sym} 24700 -5670 0 0 {name=X_69036_ }
C {devices/lab_pin.sym} 24620 -5550 0 0 {name=p24613 lab=_85474_/Q }
C {devices/lab_pin.sym} 24620 -5510 0 0 {name=p24614 lab=_54249_/X }
C {devices/lab_pin.sym} 24620 -5470 0 0 {name=p24615 lab=_54261_/Y }
C {devices/lab_pin.sym} 24780 -5510 0 1 {name=p24616 lab=_54262_/Y }
C {sky130_stdcells/o21ai_4.sym} 24700 -5510 0 0 {name=X_54262_ }
C {devices/lab_pin.sym} 24620 -5390 0 0 {name=p24617 lab=_66246_/Y }
C {devices/lab_pin.sym} 24620 -5350 0 0 {name=p24618 lab=_66205_/X }
C {devices/lab_pin.sym} 24620 -5310 0 0 {name=p24619 lab=_66247_/X }
C {devices/lab_pin.sym} 24780 -5350 0 1 {name=p24620 lab=_84146_/D }
C {sky130_stdcells/a21o_4.sym} 24700 -5350 0 0 {name=X_66248_ }
C {devices/lab_pin.sym} 24610 -5210 0 0 {name=p24621 lab=_85083_/CLK }
C {devices/lab_pin.sym} 24610 -5190 0 0 {name=p24622 lab=_85082_/D }
C {devices/lab_pin.sym} 24790 -5210 0 1 {name=p24623 lab=_45500_/A }
C {sky130_stdcells/dfxtp_4.sym} 24700 -5200 0 0 {name=X_85082_ }
C {devices/lab_pin.sym} 24620 -5090 0 0 {name=p24624 lab=_51470_/Y }
C {devices/lab_pin.sym} 24620 -5050 0 0 {name=p24625 lab=_51448_/X }
C {devices/lab_pin.sym} 24620 -5010 0 0 {name=p24626 lab=_51473_/X }
C {devices/lab_pin.sym} 24780 -5050 0 1 {name=p24627 lab=_51474_/Y }
C {sky130_stdcells/a21oi_4.sym} 24700 -5050 0 0 {name=X_51474_ }
C {devices/lab_pin.sym} 24610 -4910 0 0 {name=p24628 lab=_82103_/CLK }
C {devices/lab_pin.sym} 24610 -4890 0 0 {name=p24629 lab=_81918_/Q }
C {devices/lab_pin.sym} 24790 -4910 0 1 {name=p24630 lab=_82294_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -4900 0 0 {name=X_82294_ }
C {devices/lab_pin.sym} 24640 -4800 0 0 {name=p24631 lab=_56001_/A }
C {devices/lab_pin.sym} 24640 -4760 0 0 {name=p24632 lab=_55927_/X }
C {devices/lab_pin.sym} 24640 -4720 0 0 {name=p24633 lab=_55956_/B }
C {devices/lab_pin.sym} 24640 -4680 0 0 {name=p24634 lab=_74297_/C }
C {devices/lab_pin.sym} 24760 -4740 0 1 {name=p24635 lab=_56002_/A }
C {sky130_stdcells/nand4_4.sym} 24700 -4740 0 0 {name=X_56001_ }
C {devices/lab_pin.sym} 24640 -4600 0 0 {name=p24636 lab=_53219_/A }
C {devices/lab_pin.sym} 24640 -4560 0 0 {name=p24637 lab=_53213_/B }
C {devices/lab_pin.sym} 24760 -4580 0 1 {name=p24638 lab=_53213_/Y }
C {sky130_stdcells/nand2_4.sym} 24700 -4580 0 0 {name=X_53213_ }
C {devices/lab_pin.sym} 24610 -4450 0 0 {name=p24639 lab=_81154_/CLK }
C {devices/lab_pin.sym} 24610 -4430 0 0 {name=p24640 lab=_84033_/D }
C {devices/lab_pin.sym} 24790 -4450 0 1 {name=p24641 lab=_82073_/D }
C {sky130_stdcells/dfxtp_4.sym} 24700 -4440 0 0 {name=X_84033_ }
C {devices/lab_pin.sym} 24640 -4330 0 0 {name=p24642 lab=_48744_/A }
C {devices/lab_pin.sym} 24640 -4290 0 0 {name=p24643 lab=_50430_/B }
C {devices/lab_pin.sym} 24640 -4250 0 0 {name=p24644 lab=_50435_/C }
C {devices/lab_pin.sym} 24760 -4290 0 1 {name=p24645 lab=_50425_/X }
C {sky130_stdcells/and3_4.sym} 24700 -4290 0 0 {name=X_50425_ }
C {devices/lab_pin.sym} 24610 -4150 0 0 {name=p24646 lab=_85342_/CLK }
C {devices/lab_pin.sym} 24610 -4130 0 0 {name=p24647 lab=_81053_/Q }
C {devices/lab_pin.sym} 24790 -4150 0 1 {name=p24648 lab=_81245_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -4140 0 0 {name=X_81245_ }
C {devices/lab_pin.sym} 24660 -4010 0 0 {name=p24649 lab=_54249_/A }
C {devices/lab_pin.sym} 24740 -4010 0 1 {name=p24650 lab=_54193_/X }
C {sky130_stdcells/buf_2.sym} 24700 -4010 0 0 {name=X_54193_ }
C {devices/lab_pin.sym} 24660 -3890 0 0 {name=p24651 lab=_66366_/A }
C {devices/lab_pin.sym} 24740 -3890 0 1 {name=p24652 lab=_66179_/X }
C {sky130_stdcells/buf_2.sym} 24700 -3890 0 0 {name=X_66179_ }
C {devices/lab_pin.sym} 24640 -3800 0 0 {name=p24653 lab=_53139_/A }
C {devices/lab_pin.sym} 24640 -3760 0 0 {name=p24654 lab=_53133_/B }
C {devices/lab_pin.sym} 24640 -3720 0 0 {name=p24655 lab=_53143_/X }
C {devices/lab_pin.sym} 24640 -3680 0 0 {name=p24656 lab=_53144_/D }
C {devices/lab_pin.sym} 24760 -3740 0 1 {name=p24657 lab=_53144_/X }
C {sky130_stdcells/and4_4.sym} 24700 -3740 0 0 {name=X_53144_ }
C {devices/lab_pin.sym} 24640 -3600 0 0 {name=p24658 lab=_50356_/A }
C {devices/lab_pin.sym} 24640 -3560 0 0 {name=p24659 lab=_50356_/B }
C {devices/lab_pin.sym} 24760 -3580 0 1 {name=p24660 lab=_50356_/Y }
C {sky130_stdcells/nand2_4.sym} 24700 -3580 0 0 {name=X_50356_ }
C {devices/lab_pin.sym} 24610 -3450 0 0 {name=p24661 lab=_82335_/CLK }
C {devices/lab_pin.sym} 24610 -3430 0 0 {name=p24662 lab=_75007_/B }
C {devices/lab_pin.sym} 24790 -3450 0 1 {name=p24663 lab=_81176_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -3440 0 0 {name=X_81176_ }
C {devices/lab_pin.sym} 24640 -3320 0 0 {name=p24664 lab=_80109_/X }
C {devices/lab_pin.sym} 24640 -3280 0 0 {name=p24665 lab=_80112_/Y }
C {devices/lab_pin.sym} 24760 -3300 0 1 {name=p24666 lab=_80127_/X }
C {sky130_stdcells/or2_4.sym} 24700 -3300 0 0 {name=X_80127_ }
C {devices/lab_pin.sym} 24620 -3190 0 0 {name=p24667 lab=_53073_/Y }
C {devices/lab_pin.sym} 24620 -3150 0 0 {name=p24668 lab=_53056_/X }
C {devices/lab_pin.sym} 24620 -3110 0 0 {name=p24669 lab=_53074_/X }
C {devices/lab_pin.sym} 24780 -3150 0 1 {name=p24670 lab=_85702_/D }
C {sky130_stdcells/a21oi_4.sym} 24700 -3150 0 0 {name=X_53075_ }
C {devices/lab_pin.sym} 24640 -3020 0 0 {name=p24671 lab=_57952_/A }
C {devices/lab_pin.sym} 24640 -2980 0 0 {name=p24672 lab=_57952_/B }
C {devices/lab_pin.sym} 24760 -3000 0 1 {name=p24673 lab=_57952_/Y }
C {sky130_stdcells/nor2_4.sym} 24700 -3000 0 0 {name=X_57952_ }
C {devices/lab_pin.sym} 24660 -2870 0 0 {name=p24674 lab=_70012_/A }
C {devices/lab_pin.sym} 24740 -2870 0 1 {name=p24675 lab=_69938_/X }
C {sky130_stdcells/buf_2.sym} 24700 -2870 0 0 {name=X_69938_ }
C {devices/lab_pin.sym} 24640 -2770 0 0 {name=p24676 lab=_48234_/A }
C {devices/lab_pin.sym} 24640 -2730 0 0 {name=p24677 lab=_50475_/B }
C {devices/lab_pin.sym} 24640 -2690 0 0 {name=p24678 lab=_50257_/X }
C {devices/lab_pin.sym} 24760 -2730 0 1 {name=p24679 lab=_50287_/Y }
C {sky130_stdcells/nand3_4.sym} 24700 -2730 0 0 {name=X_50287_ }
C {devices/lab_pin.sym} 24610 -2590 0 0 {name=p24680 lab=_85697_/CLK }
C {devices/lab_pin.sym} 24610 -2570 0 0 {name=p24681 lab=_51581_/Y }
C {devices/lab_pin.sym} 24790 -2590 0 1 {name=p24682 lab=_85984_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -2580 0 0 {name=X_85984_ }
C {devices/lab_pin.sym} 24620 -2470 0 0 {name=p24683 lab=_52020_/Y }
C {devices/lab_pin.sym} 24620 -2430 0 0 {name=p24684 lab=_52022_/X }
C {devices/lab_pin.sym} 24620 -2390 0 0 {name=p24685 lab=_52025_/Y }
C {devices/lab_pin.sym} 24780 -2430 0 1 {name=p24686 lab=_85904_/D }
C {sky130_stdcells/a21boi_4.sym} 24700 -2430 0 0 {name=X_52026_ }
C {devices/lab_pin.sym} 24620 -2310 0 0 {name=p24687 lab=_46237_/A }
C {devices/lab_pin.sym} 24620 -2270 0 0 {name=p24688 lab=_56901_/Y }
C {devices/lab_pin.sym} 24620 -2230 0 0 {name=p24689 lab=_56902_/Y }
C {devices/lab_pin.sym} 24780 -2270 0 1 {name=p24690 lab=_56903_/X }
C {sky130_stdcells/o21a_4.sym} 24700 -2270 0 0 {name=X_56903_ }
C {devices/lab_pin.sym} 24610 -2130 0 0 {name=p24691 lab=_86930_/CLK }
C {devices/lab_pin.sym} 24610 -2110 0 0 {name=p24692 lab=_42778_/X }
C {devices/lab_pin.sym} 24790 -2130 0 1 {name=p24693 lab=_87723_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -2120 0 0 {name=X_87723_ }
C {devices/lab_pin.sym} 24610 -1990 0 0 {name=p24694 lab=_86317_/CLK }
C {devices/lab_pin.sym} 24610 -1970 0 0 {name=p24695 lab=_84935_/D }
C {devices/lab_pin.sym} 24790 -1990 0 1 {name=p24696 lab=_84935_/Q }
C {sky130_stdcells/dfxtp_4.sym} 24700 -1980 0 0 {name=X_84935_ }
C {devices/lab_pin.sym} 24620 -1870 0 0 {name=p24697 lab=_57980_/Y }
C {devices/lab_pin.sym} 24620 -1830 0 0 {name=p24698 lab=_65728_/C }
C {devices/lab_pin.sym} 24620 -1790 0 0 {name=p24699 lab=_80057_/Y }
C {devices/lab_pin.sym} 24780 -1830 0 1 {name=p24700 lab=_80058_/X }
C {sky130_stdcells/o21a_4.sym} 24700 -1830 0 0 {name=X_80058_ }
C {devices/lab_pin.sym} 24660 -1690 0 0 {name=p24701 lab=_84942_/Q }
C {devices/lab_pin.sym} 24740 -1690 0 1 {name=p24702 lab=_57883_/Y }
C {sky130_stdcells/inv_2.sym} 24700 -1690 0 0 {name=X_57883_ }
C {devices/lab_pin.sym} 24620 -1590 0 0 {name=p24703 lab=_81963_/D }
C {devices/lab_pin.sym} 24620 -1550 0 0 {name=p24704 lab=_69831_/X }
C {devices/lab_pin.sym} 24620 -1510 0 0 {name=p24705 lab=_69868_/X }
C {devices/lab_pin.sym} 24780 -1550 0 1 {name=p24706 lab=_69869_/X }
C {sky130_stdcells/a21bo_4.sym} 24700 -1550 0 0 {name=X_69869_ }
C {devices/lab_pin.sym} 24660 -1410 0 0 {name=p24707 lab=clkbuf_9_240_0_CLK/X }
C {devices/lab_pin.sym} 24740 -1410 0 1 {name=p24708 lab=_86610_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 24700 -1410 0 0 {name=Xclkbuf_10_481_0_CLK }
C {devices/lab_pin.sym} 24640 -1320 0 0 {name=p24709 lab=_74523_/A }
C {devices/lab_pin.sym} 24640 -1280 0 0 {name=p24710 lab=_71893_/X }
C {devices/lab_pin.sym} 24640 -1240 0 0 {name=p24711 lab=_71755_/X }
C {devices/lab_pin.sym} 24640 -1200 0 0 {name=p24712 lab=_71898_/D }
C {devices/lab_pin.sym} 24760 -1260 0 1 {name=p24713 lab=_71900_/Y }
C {sky130_stdcells/nand4_4.sym} 24700 -1260 0 0 {name=X_71900_ }
C {devices/lab_pin.sym} 24660 -1110 0 0 {name=p24714 lab=_59622_/A }
C {devices/lab_pin.sym} 24740 -1110 0 1 {name=p24715 lab=_60615_/A }
C {sky130_stdcells/inv_2.sym} 24700 -1110 0 0 {name=X_59622_ }
C {devices/lab_pin.sym} 24620 -1010 0 0 {name=p24716 lab=_56832_/X }
C {devices/lab_pin.sym} 24620 -970 0 0 {name=p24717 lab=_55681_/X }
C {devices/lab_pin.sym} 24620 -930 0 0 {name=p24718 lab=_56833_/Y }
C {devices/lab_pin.sym} 24780 -970 0 1 {name=p24719 lab=_56838_/A }
C {sky130_stdcells/a21o_4.sym} 24700 -970 0 0 {name=X_56834_ }
C {devices/lab_pin.sym} 24610 -830 0 0 {name=p24720 lab=_86930_/CLK }
C {devices/lab_pin.sym} 24610 -810 0 0 {name=p24721 lab=_42913_/X }
C {devices/lab_pin.sym} 24790 -830 0 1 {name=p24722 lab=_67652_/B }
C {sky130_stdcells/dfxtp_4.sym} 24700 -820 0 0 {name=X_87654_ }
C {devices/lab_pin.sym} 24660 -690 0 0 {name=p24723 lab=_72880_/A }
C {devices/lab_pin.sym} 24740 -690 0 1 {name=p24724 lab=_72880_/X }
C {sky130_stdcells/buf_2.sym} 24700 -690 0 0 {name=X_72880_ }
C {devices/lab_pin.sym} 25530 -42150 0 0 {name=p24725 lab=_84299_/CLK }
C {devices/lab_pin.sym} 25530 -42130 0 0 {name=p24726 lab=_84866_/D }
C {devices/lab_pin.sym} 25710 -42150 0 1 {name=p24727 lab=_84866_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -42140 0 0 {name=X_84866_ }
C {devices/lab_pin.sym} 25530 -42010 0 0 {name=p24728 lab=_86610_/CLK }
C {devices/lab_pin.sym} 25530 -41990 0 0 {name=p24729 lab=_86605_/D }
C {devices/lab_pin.sym} 25710 -42010 0 1 {name=p24730 lab=_72368_/A }
C {sky130_stdcells/dfxtp_4.sym} 25620 -42000 0 0 {name=X_86605_ }
C {devices/lab_pin.sym} 25560 -41900 0 0 {name=p24731 lab=_71829_/X }
C {devices/lab_pin.sym} 25560 -41860 0 0 {name=p24732 lab=_71839_/B }
C {devices/lab_pin.sym} 25560 -41820 0 0 {name=p24733 lab=_70768_/A }
C {devices/lab_pin.sym} 25560 -41780 0 0 {name=p24734 lab=_71826_/X }
C {devices/lab_pin.sym} 25680 -41840 0 1 {name=p24735 lab=_71831_/X }
C {sky130_stdcells/and4_4.sym} 25620 -41840 0 0 {name=X_71831_ }
C {devices/lab_pin.sym} 25530 -41690 0 0 {name=p24736 lab=_83842_/CLK }
C {devices/lab_pin.sym} 25530 -41670 0 0 {name=p24737 lab=_83817_/D }
C {devices/lab_pin.sym} 25710 -41690 0 1 {name=p24738 lab=_74807_/A }
C {sky130_stdcells/dfxtp_4.sym} 25620 -41680 0 0 {name=X_83817_ }
C {devices/lab_pin.sym} 25580 -41550 0 0 {name=p24739 lab=_59552_/Y }
C {devices/lab_pin.sym} 25660 -41550 0 1 {name=p24740 lab=_59661_/D }
C {sky130_stdcells/inv_2.sym} 25620 -41550 0 0 {name=X_59553_ }
C {devices/lab_pin.sym} 25560 -41450 0 0 {name=p24741 lab=_56765_/A }
C {devices/lab_pin.sym} 25560 -41410 0 0 {name=p24742 lab=_56753_/Y }
C {devices/lab_pin.sym} 25560 -41370 0 0 {name=p24743 lab=_56764_/Y }
C {devices/lab_pin.sym} 25680 -41410 0 1 {name=p24744 lab=_56765_/Y }
C {sky130_stdcells/nand3_4.sym} 25620 -41410 0 0 {name=X_56765_ }
C {devices/lab_pin.sym} 25580 -41270 0 0 {name=p24745 lab=_41990_/Y }
C {devices/lab_pin.sym} 25660 -41270 0 1 {name=p24746 lab=_41991_/Y }
C {sky130_stdcells/inv_2.sym} 25620 -41270 0 0 {name=X_41991_ }
C {devices/lab_pin.sym} 25530 -41150 0 0 {name=p24747 lab=_88108_/CLK }
C {devices/lab_pin.sym} 25530 -41130 0 0 {name=p24748 lab=_87585_/D }
C {devices/lab_pin.sym} 25710 -41150 0 1 {name=p24749 lab=_73989_/A }
C {sky130_stdcells/dfxtp_4.sym} 25620 -41140 0 0 {name=X_87585_ }
C {devices/lab_pin.sym} 25540 -41030 0 0 {name=p24750 lab=_85530_/Q }
C {devices/lab_pin.sym} 25540 -40990 0 0 {name=p24751 lab=_53955_/X }
C {devices/lab_pin.sym} 25540 -40950 0 0 {name=p24752 lab=_53976_/Y }
C {devices/lab_pin.sym} 25700 -40990 0 1 {name=p24753 lab=_53977_/Y }
C {sky130_stdcells/o21ai_4.sym} 25620 -40990 0 0 {name=X_53977_ }
C {devices/lab_pin.sym} 25530 -40850 0 0 {name=p24754 lab=_84797_/CLK }
C {devices/lab_pin.sym} 25530 -40830 0 0 {name=p24755 lab=_84797_/D }
C {devices/lab_pin.sym} 25710 -40850 0 1 {name=p24756 lab=_84797_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -40840 0 0 {name=X_84797_ }
C {devices/lab_pin.sym} 25580 -40710 0 0 {name=p24757 lab=_83424_/Q }
C {devices/lab_pin.sym} 25660 -40710 0 1 {name=p24758 lab=_58504_/Y }
C {sky130_stdcells/inv_2.sym} 25620 -40710 0 0 {name=X_58504_ }
C {devices/lab_pin.sym} 25580 -40590 0 0 {name=p24759 lab=_43729_/X }
C {devices/lab_pin.sym} 25660 -40590 0 1 {name=p24760 lab=_43730_/Y }
C {sky130_stdcells/inv_2.sym} 25620 -40590 0 0 {name=X_43730_ }
C {devices/lab_pin.sym} 25540 -40500 0 0 {name=p24761 lab=_56454_/C }
C {devices/lab_pin.sym} 25540 -40460 0 0 {name=p24762 lab=_55126_/A }
C {devices/lab_pin.sym} 25540 -40420 0 0 {name=p24763 lab=_55128_/A }
C {devices/lab_pin.sym} 25540 -40380 0 0 {name=p24764 lab=_55715_/X }
C {devices/lab_pin.sym} 25700 -40440 0 1 {name=p24765 lab=_55716_/X }
C {sky130_stdcells/a211o_4.sym} 25620 -40440 0 0 {name=X_55716_ }
C {devices/lab_pin.sym} 25580 -40290 0 0 {name=p24766 lab=_74549_/Y }
C {devices/lab_pin.sym} 25660 -40290 0 1 {name=p24767 lab=_74625_/A }
C {sky130_stdcells/buf_2.sym} 25620 -40290 0 0 {name=X_74550_ }
C {devices/lab_pin.sym} 25530 -40170 0 0 {name=p24768 lab=_86210_/CLK }
C {devices/lab_pin.sym} 25530 -40150 0 0 {name=p24769 lab=_48318_/Y }
C {devices/lab_pin.sym} 25710 -40170 0 1 {name=p24770 lab=_86536_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -40160 0 0 {name=X_86536_ }
C {devices/lab_pin.sym} 25580 -40030 0 0 {name=p24771 lab=_40756_/A }
C {devices/lab_pin.sym} 25660 -40030 0 1 {name=p24772 lab=_40942_/X }
C {sky130_stdcells/buf_2.sym} 25620 -40030 0 0 {name=X_40942_ }
C {devices/lab_pin.sym} 25540 -39930 0 0 {name=p24773 lab=_52925_/Y }
C {devices/lab_pin.sym} 25540 -39890 0 0 {name=p24774 lab=_52920_/X }
C {devices/lab_pin.sym} 25540 -39850 0 0 {name=p24775 lab=_52927_/X }
C {devices/lab_pin.sym} 25700 -39890 0 1 {name=p24776 lab=_85729_/D }
C {sky130_stdcells/a21oi_4.sym} 25620 -39890 0 0 {name=X_52928_ }
C {devices/lab_pin.sym} 25580 -39750 0 0 {name=p24777 lab=_59484_/A }
C {devices/lab_pin.sym} 25660 -39750 0 1 {name=p24778 lab=_59484_/Y }
C {sky130_stdcells/inv_2.sym} 25620 -39750 0 0 {name=X_59484_ }
C {devices/lab_pin.sym} 25580 -39630 0 0 {name=p24779 lab=_71761_/Y }
C {devices/lab_pin.sym} 25660 -39630 0 1 {name=p24780 lab=_71762_/X }
C {sky130_stdcells/buf_2.sym} 25620 -39630 0 0 {name=X_71762_ }
C {devices/lab_pin.sym} 25530 -39510 0 0 {name=p24781 lab=_83749_/CLK }
C {devices/lab_pin.sym} 25530 -39490 0 0 {name=p24782 lab=_83748_/D }
C {devices/lab_pin.sym} 25710 -39510 0 1 {name=p24783 lab=_83748_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -39500 0 0 {name=X_83748_ }
C {devices/lab_pin.sym} 25560 -39380 0 0 {name=p24784 lab=_56696_/A }
C {devices/lab_pin.sym} 25560 -39340 0 0 {name=p24785 lab=_56696_/B }
C {devices/lab_pin.sym} 25680 -39360 0 1 {name=p24786 lab=_56696_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -39360 0 0 {name=X_56696_ }
C {devices/lab_pin.sym} 25580 -39230 0 0 {name=p24787 lab=clkbuf_9_248_0_CLK/X }
C {devices/lab_pin.sym} 25660 -39230 0 1 {name=p24788 lab=_86384_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 25620 -39230 0 0 {name=Xclkbuf_10_496_0_CLK }
C {devices/lab_pin.sym} 25540 -39140 0 0 {name=p24789 lab=_73163_/X }
C {devices/lab_pin.sym} 25540 -39100 0 0 {name=p24790 lab=_83052_/Q }
C {devices/lab_pin.sym} 25540 -39060 0 0 {name=p24791 lab=_73385_/X }
C {devices/lab_pin.sym} 25540 -39020 0 0 {name=p24792 lab=_73500_/X }
C {devices/lab_pin.sym} 25700 -39080 0 1 {name=p24793 lab=_73501_/X }
C {sky130_stdcells/a211o_4.sym} 25620 -39080 0 0 {name=X_73501_ }
C {devices/lab_pin.sym} 25580 -38930 0 0 {name=p24794 lab=_70848_/A }
C {devices/lab_pin.sym} 25660 -38930 0 1 {name=p24795 lab=_70713_/X }
C {sky130_stdcells/buf_2.sym} 25620 -38930 0 0 {name=X_70713_ }
C {devices/lab_pin.sym} 25540 -38830 0 0 {name=p24796 lab=_58423_/X }
C {devices/lab_pin.sym} 25540 -38790 0 0 {name=p24797 lab=_83481_/Q }
C {devices/lab_pin.sym} 25540 -38750 0 0 {name=p24798 lab=_58434_/Y }
C {devices/lab_pin.sym} 25700 -38790 0 1 {name=p24799 lab=_84849_/D }
C {sky130_stdcells/o21a_4.sym} 25620 -38790 0 0 {name=X_58435_ }
C {devices/lab_pin.sym} 25560 -38680 0 0 {name=p24800 lab=_56650_/B }
C {devices/lab_pin.sym} 25560 -38640 0 0 {name=p24801 lab=_55467_/X }
C {devices/lab_pin.sym} 25560 -38600 0 0 {name=p24802 lab=_55646_/X }
C {devices/lab_pin.sym} 25560 -38560 0 0 {name=p24803 lab=_55503_/D }
C {devices/lab_pin.sym} 25680 -38620 0 1 {name=p24804 lab=_55647_/X }
C {sky130_stdcells/and4_4.sym} 25620 -38620 0 0 {name=X_55647_ }
C {devices/lab_pin.sym} 25580 -38470 0 0 {name=p24805 lab=_43611_/A }
C {devices/lab_pin.sym} 25660 -38470 0 1 {name=p24806 lab=_43661_/X }
C {sky130_stdcells/buf_2.sym} 25620 -38470 0 0 {name=X_43661_ }
C {devices/lab_pin.sym} 25540 -38370 0 0 {name=p24807 lab=_83057_/Q }
C {devices/lab_pin.sym} 25540 -38330 0 0 {name=p24808 lab=_74474_/X }
C {devices/lab_pin.sym} 25540 -38290 0 0 {name=p24809 lab=_74480_/Y }
C {devices/lab_pin.sym} 25700 -38330 0 1 {name=p24810 lab=_74481_/Y }
C {sky130_stdcells/o21ai_4.sym} 25620 -38330 0 0 {name=X_74481_ }
C {devices/lab_pin.sym} 25530 -38190 0 0 {name=p24811 lab=_83311_/CLK }
C {devices/lab_pin.sym} 25530 -38170 0 0 {name=p24812 lab=_86467_/D }
C {devices/lab_pin.sym} 25710 -38190 0 1 {name=p24813 lab=_86467_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -38180 0 0 {name=X_86467_ }
C {devices/lab_pin.sym} 25540 -38070 0 0 {name=p24814 lab=_40857_/X }
C {devices/lab_pin.sym} 25540 -38030 0 0 {name=p24815 lab=_41048_/A }
C {devices/lab_pin.sym} 25540 -37990 0 0 {name=p24816 lab=_40872_/X }
C {devices/lab_pin.sym} 25700 -38030 0 1 {name=p24817 lab=_40873_/X }
C {sky130_stdcells/o21a_4.sym} 25620 -38030 0 0 {name=X_40873_ }
C {devices/lab_pin.sym} 25560 -37900 0 0 {name=p24818 lab=_52850_/A }
C {devices/lab_pin.sym} 25560 -37860 0 0 {name=p24819 lab=_52859_/B }
C {devices/lab_pin.sym} 25680 -37880 0 1 {name=p24820 lab=_52859_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -37880 0 0 {name=X_52859_ }
C {devices/lab_pin.sym} 25530 -37750 0 0 {name=p24821 lab=_86104_/CLK }
C {devices/lab_pin.sym} 25530 -37730 0 0 {name=p24822 lab=_70868_/Y }
C {devices/lab_pin.sym} 25710 -37750 0 1 {name=p24823 lab=_83679_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -37740 0 0 {name=X_83679_ }
C {devices/lab_pin.sym} 25560 -37630 0 0 {name=p24824 lab=_71626_/A }
C {devices/lab_pin.sym} 25560 -37590 0 0 {name=p24825 lab=_71690_/A }
C {devices/lab_pin.sym} 25560 -37550 0 0 {name=p24826 lab=_71874_/D }
C {devices/lab_pin.sym} 25680 -37590 0 1 {name=p24827 lab=_71693_/Y }
C {sky130_stdcells/nor3_4.sym} 25620 -37590 0 0 {name=X_71693_ }
C {devices/lab_pin.sym} 25540 -37470 0 0 {name=p24828 lab=_45392_/X }
C {devices/lab_pin.sym} 25540 -37430 0 0 {name=p24829 lab=_45399_/X }
C {devices/lab_pin.sym} 25540 -37390 0 0 {name=p24830 lab=_45361_/X }
C {devices/lab_pin.sym} 25700 -37430 0 1 {name=p24831 lab=_45400_/X }
C {sky130_stdcells/a21o_4.sym} 25620 -37430 0 0 {name=X_45400_ }
C {devices/lab_pin.sym} 25540 -37310 0 0 {name=p24832 lab=_76217_/X }
C {devices/lab_pin.sym} 25540 -37270 0 0 {name=p24833 lab=_76221_/C }
C {devices/lab_pin.sym} 25540 -37230 0 0 {name=p24834 lab=_76219_/Y }
C {devices/lab_pin.sym} 25700 -37270 0 1 {name=p24835 lab=_76220_/Y }
C {sky130_stdcells/a21oi_4.sym} 25620 -37270 0 0 {name=X_76220_ }
C {devices/lab_pin.sym} 25530 -37130 0 0 {name=p24836 lab=_87950_/CLK }
C {devices/lab_pin.sym} 25530 -37110 0 0 {name=p24837 lab=_88206_/D }
C {devices/lab_pin.sym} 25710 -37130 0 1 {name=p24838 lab=_66694_/B }
C {sky130_stdcells/dfxtp_4.sym} 25620 -37120 0 0 {name=X_88206_ }
C {devices/lab_pin.sym} 25580 -36990 0 0 {name=p24839 lab=_42612_/A }
C {devices/lab_pin.sym} 25660 -36990 0 1 {name=p24840 lab=_42612_/X }
C {sky130_stdcells/buf_2.sym} 25620 -36990 0 0 {name=X_42612_ }
C {devices/lab_pin.sym} 25560 -36880 0 0 {name=p24841 lab=_48647_/Y }
C {devices/lab_pin.sym} 25560 -36840 0 0 {name=p24842 lab=_73432_/B }
C {devices/lab_pin.sym} 25680 -36860 0 1 {name=p24843 lab=_73432_/X }
C {sky130_stdcells/xor2_4.sym} 25620 -36860 0 0 {name=X_73432_ }
C {devices/lab_pin.sym} 25530 -36730 0 0 {name=p24844 lab=_85643_/CLK }
C {devices/lab_pin.sym} 25530 -36710 0 0 {name=p24845 lab=_54572_/Y }
C {devices/lab_pin.sym} 25710 -36730 0 1 {name=p24846 lab=_85418_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -36720 0 0 {name=X_85418_ }
C {devices/lab_pin.sym} 25560 -36600 0 0 {name=p24847 lab=_46380_/A }
C {devices/lab_pin.sym} 25560 -36560 0 0 {name=p24848 lab=_46380_/B }
C {devices/lab_pin.sym} 25680 -36580 0 1 {name=p24849 lab=_46380_/X }
C {sky130_stdcells/or2_4.sym} 25620 -36580 0 0 {name=X_46380_ }
C {devices/lab_pin.sym} 25540 -36470 0 0 {name=p24850 lab=_53017_/B }
C {devices/lab_pin.sym} 25540 -36430 0 0 {name=p24851 lab=_70632_/X }
C {devices/lab_pin.sym} 25540 -36390 0 0 {name=p24852 lab=_70643_/Y }
C {devices/lab_pin.sym} 25700 -36430 0 1 {name=p24853 lab=_83736_/D }
C {sky130_stdcells/o21ai_4.sym} 25620 -36430 0 0 {name=X_70644_ }
C {devices/lab_pin.sym} 25580 -36290 0 0 {name=p24854 lab=_58328_/A }
C {devices/lab_pin.sym} 25660 -36290 0 1 {name=p24855 lab=_58366_/X }
C {sky130_stdcells/buf_2.sym} 25620 -36290 0 0 {name=X_58366_ }
C {devices/lab_pin.sym} 25580 -36170 0 0 {name=p24856 lab=_43605_/A }
C {devices/lab_pin.sym} 25660 -36170 0 1 {name=p24857 lab=_43611_/A }
C {sky130_stdcells/buf_2.sym} 25620 -36170 0 0 {name=X_43592_ }
C {devices/lab_pin.sym} 25560 -36060 0 0 {name=p24858 lab=_44081_/X }
C {devices/lab_pin.sym} 25560 -36020 0 0 {name=p24859 lab=_85148_/Q }
C {devices/lab_pin.sym} 25680 -36040 0 1 {name=p24860 lab=_55578_/X }
C {sky130_stdcells/and2_4.sym} 25620 -36040 0 0 {name=X_55578_ }
C {devices/lab_pin.sym} 25530 -35910 0 0 {name=p24861 lab=_86398_/CLK }
C {devices/lab_pin.sym} 25530 -35890 0 0 {name=p24862 lab=_86398_/D }
C {devices/lab_pin.sym} 25710 -35910 0 1 {name=p24863 lab=_86398_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -35900 0 0 {name=X_86398_ }
C {devices/lab_pin.sym} 25580 -35770 0 0 {name=p24864 lab=_45331_/A }
C {devices/lab_pin.sym} 25660 -35770 0 1 {name=p24865 lab=_45331_/Y }
C {sky130_stdcells/inv_2.sym} 25620 -35770 0 0 {name=X_45331_ }
C {devices/lab_pin.sym} 25580 -35650 0 0 {name=p24866 lab=_57317_/A }
C {devices/lab_pin.sym} 25660 -35650 0 1 {name=p24867 lab=_57317_/Y }
C {sky130_stdcells/inv_2.sym} 25620 -35650 0 0 {name=X_57317_ }
C {devices/lab_pin.sym} 25540 -35550 0 0 {name=p24868 lab=_76150_/A }
C {devices/lab_pin.sym} 25540 -35510 0 0 {name=p24869 lab=_76150_/B }
C {devices/lab_pin.sym} 25540 -35470 0 0 {name=p24870 lab=_81537_/Q }
C {devices/lab_pin.sym} 25700 -35510 0 1 {name=p24871 lab=_76151_/Y }
C {sky130_stdcells/a21oi_4.sym} 25620 -35510 0 0 {name=X_76151_ }
C {devices/lab_pin.sym} 25530 -35370 0 0 {name=p24872 lab=_88398_/CLK }
C {devices/lab_pin.sym} 25530 -35350 0 0 {name=p24873 lab=_41818_/Y }
C {devices/lab_pin.sym} 25710 -35370 0 1 {name=p24874 lab=_88137_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -35360 0 0 {name=X_88137_ }
C {devices/lab_pin.sym} 25580 -35230 0 0 {name=p24875 lab=_72728_/A }
C {devices/lab_pin.sym} 25660 -35230 0 1 {name=p24876 lab=_42543_/Y }
C {sky130_stdcells/inv_2.sym} 25620 -35230 0 0 {name=X_42543_ }
C {devices/lab_pin.sym} 25540 -35130 0 0 {name=p24877 lab=_85425_/Q }
C {devices/lab_pin.sym} 25540 -35090 0 0 {name=p24878 lab=_54512_/X }
C {devices/lab_pin.sym} 25540 -35050 0 0 {name=p24879 lab=_54528_/Y }
C {devices/lab_pin.sym} 25700 -35090 0 1 {name=p24880 lab=_54529_/Y }
C {sky130_stdcells/o21ai_4.sym} 25620 -35090 0 0 {name=X_54529_ }
C {devices/lab_pin.sym} 25560 -34960 0 0 {name=p24881 lab=_48615_/A }
C {devices/lab_pin.sym} 25560 -34920 0 0 {name=p24882 lab=_73363_/B }
C {devices/lab_pin.sym} 25680 -34940 0 1 {name=p24883 lab=_73363_/X }
C {sky130_stdcells/xor2_4.sym} 25620 -34940 0 0 {name=X_73363_ }
C {devices/lab_pin.sym} 25530 -34810 0 0 {name=p24884 lab=_85957_/CLK }
C {devices/lab_pin.sym} 25530 -34790 0 0 {name=p24885 lab=_54943_/Y }
C {devices/lab_pin.sym} 25710 -34810 0 1 {name=p24886 lab=_85349_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -34800 0 0 {name=X_85349_ }
C {devices/lab_pin.sym} 25580 -34670 0 0 {name=p24887 lab=HASH_ADDR[4] }
C {devices/lab_pin.sym} 25660 -34670 0 1 {name=p24888 lab=_70933_/B }
C {sky130_stdcells/inv_2.sym} 25620 -34670 0 0 {name=X_70575_ }
C {devices/lab_pin.sym} 25540 -34570 0 0 {name=p24889 lab=_58282_/X }
C {devices/lab_pin.sym} 25540 -34530 0 0 {name=p24890 lab=_58294_/Y }
C {devices/lab_pin.sym} 25540 -34490 0 0 {name=p24891 lab=_58296_/Y }
C {devices/lab_pin.sym} 25700 -34530 0 1 {name=p24892 lab=_84885_/D }
C {sky130_stdcells/a21oi_4.sym} 25620 -34530 0 0 {name=X_58297_ }
C {devices/lab_pin.sym} 25580 -34390 0 0 {name=p24893 lab=clkbuf_4_11_0_CLK/X }
C {devices/lab_pin.sym} 25660 -34390 0 1 {name=p24894 lab=clkbuf_5_23_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 25620 -34390 0 0 {name=Xclkbuf_4_11_1_CLK }
C {devices/lab_pin.sym} 25560 -34280 0 0 {name=p24895 lab=_75102_/A }
C {devices/lab_pin.sym} 25560 -34240 0 0 {name=p24896 lab=_75102_/B }
C {devices/lab_pin.sym} 25680 -34260 0 1 {name=p24897 lab=_75104_/A }
C {sky130_stdcells/nand2_4.sym} 25620 -34260 0 0 {name=X_75102_ }
C {devices/lab_pin.sym} 25540 -34150 0 0 {name=p24898 lab=_72287_/X }
C {devices/lab_pin.sym} 25540 -34110 0 0 {name=p24899 lab=_85329_/Q }
C {devices/lab_pin.sym} 25540 -34070 0 0 {name=p24900 lab=_72225_/X }
C {devices/lab_pin.sym} 25700 -34110 0 1 {name=p24901 lab=_72314_/X }
C {sky130_stdcells/o21a_4.sym} 25620 -34110 0 0 {name=X_72314_ }
C {devices/lab_pin.sym} 25580 -33970 0 0 {name=p24902 lab=_48731_/A }
C {devices/lab_pin.sym} 25660 -33970 0 1 {name=p24903 lab=_48092_/A }
C {sky130_stdcells/buf_2.sym} 25620 -33970 0 0 {name=X_48050_ }
C {devices/lab_pin.sym} 25540 -33870 0 0 {name=p24904 lab=_45255_/X }
C {devices/lab_pin.sym} 25540 -33830 0 0 {name=p24905 lab=_45259_/Y }
C {devices/lab_pin.sym} 25540 -33790 0 0 {name=p24906 lab=_45261_/Y }
C {devices/lab_pin.sym} 25700 -33830 0 1 {name=p24907 lab=_45262_/Y }
C {sky130_stdcells/a21oi_4.sym} 25620 -33830 0 0 {name=X_45262_ }
C {devices/lab_pin.sym} 25560 -33700 0 0 {name=p24908 lab=_76082_/A }
C {devices/lab_pin.sym} 25560 -33660 0 0 {name=p24909 lab=_76081_/Y }
C {devices/lab_pin.sym} 25680 -33680 0 1 {name=p24910 lab=_76083_/B }
C {sky130_stdcells/xor2_4.sym} 25620 -33680 0 0 {name=X_76082_ }
C {devices/lab_pin.sym} 25580 -33550 0 0 {name=p24911 lab=_57327_/B }
C {devices/lab_pin.sym} 25660 -33550 0 1 {name=p24912 lab=_57340_/C }
C {sky130_stdcells/buf_2.sym} 25620 -33550 0 0 {name=X_57248_ }
C {devices/lab_pin.sym} 25530 -33430 0 0 {name=p24913 lab=_87820_/CLK }
C {devices/lab_pin.sym} 25530 -33410 0 0 {name=p24914 lab=_42021_/Y }
C {devices/lab_pin.sym} 25710 -33430 0 1 {name=p24915 lab=_88068_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -33420 0 0 {name=X_88068_ }
C {devices/lab_pin.sym} 25540 -33330 0 0 {name=p24916 lab=_42460_/X }
C {devices/lab_pin.sym} 25540 -33290 0 0 {name=p24917 lab=_42472_/X }
C {devices/lab_pin.sym} 25540 -33250 0 0 {name=p24918 lab=_40617_/X }
C {devices/lab_pin.sym} 25540 -33210 0 0 {name=p24919 lab=_68520_/B }
C {devices/lab_pin.sym} 25540 -33170 0 0 {name=p24920 lab=_42463_/X }
C {devices/lab_pin.sym} 25700 -33250 0 1 {name=p24921 lab=_42474_/Y }
C {sky130_stdcells/o32ai_4.sym} 25620 -33250 0 0 {name=X_42474_ }
C {devices/lab_pin.sym} 25540 -33110 0 0 {name=p24922 lab=_73292_/X }
C {devices/lab_pin.sym} 25540 -33070 0 0 {name=p24923 lab=_73293_/Y }
C {devices/lab_pin.sym} 25540 -33030 0 0 {name=p24924 lab=_73221_/X }
C {devices/lab_pin.sym} 25700 -33070 0 1 {name=p24925 lab=_73294_/Y }
C {sky130_stdcells/a21oi_4.sym} 25620 -33070 0 0 {name=X_73294_ }
C {devices/lab_pin.sym} 25540 -32950 0 0 {name=p24926 lab=_46996_/Y }
C {devices/lab_pin.sym} 25540 -32910 0 0 {name=p24927 lab=_46987_/X }
C {devices/lab_pin.sym} 25540 -32870 0 0 {name=p24928 lab=_47000_/X }
C {devices/lab_pin.sym} 25700 -32910 0 1 {name=p24929 lab=_86681_/D }
C {sky130_stdcells/a21oi_4.sym} 25620 -32910 0 0 {name=X_47001_ }
C {devices/lab_pin.sym} 25580 -32770 0 0 {name=p24930 lab=_57019_/A }
C {devices/lab_pin.sym} 25660 -32770 0 1 {name=p24931 lab=_44213_/X }
C {sky130_stdcells/buf_2.sym} 25620 -32770 0 0 {name=X_44213_ }
C {devices/lab_pin.sym} 25560 -32660 0 0 {name=p24932 lab=_84923_/Q }
C {devices/lab_pin.sym} 25560 -32620 0 0 {name=p24933 lab=_84171_/Q }
C {devices/lab_pin.sym} 25680 -32640 0 1 {name=p24934 lab=_79912_/A }
C {sky130_stdcells/nor2_4.sym} 25620 -32640 0 0 {name=X_79910_ }
C {devices/lab_pin.sym} 25560 -32520 0 0 {name=p24935 lab=_81147_/D }
C {devices/lab_pin.sym} 25560 -32480 0 0 {name=p24936 lab=_75032_/B }
C {devices/lab_pin.sym} 25680 -32500 0 1 {name=p24937 lab=_75033_/Y }
C {sky130_stdcells/nor2_4.sym} 25620 -32500 0 0 {name=X_75033_ }
C {devices/lab_pin.sym} 25530 -32370 0 0 {name=p24938 lab=_88301_/CLK }
C {devices/lab_pin.sym} 25530 -32350 0 0 {name=p24939 lab=_44645_/X }
C {devices/lab_pin.sym} 25710 -32370 0 1 {name=p24940 lab=_87019_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -32360 0 0 {name=X_87019_ }
C {devices/lab_pin.sym} 25540 -32270 0 0 {name=p24941 lab=_41399_/X }
C {devices/lab_pin.sym} 25540 -32230 0 0 {name=p24942 lab=_41400_/X }
C {devices/lab_pin.sym} 25540 -32190 0 0 {name=p24943 lab=_41424_/X }
C {devices/lab_pin.sym} 25540 -32150 0 0 {name=p24944 lab=_88218_/Q }
C {devices/lab_pin.sym} 25540 -32110 0 0 {name=p24945 lab=_41388_/X }
C {devices/lab_pin.sym} 25700 -32190 0 1 {name=p24946 lab=_41425_/Y }
C {sky130_stdcells/o32ai_4.sym} 25620 -32190 0 0 {name=X_41425_ }
C {devices/lab_pin.sym} 25560 -32040 0 0 {name=p24947 lab=_72220_/A }
C {devices/lab_pin.sym} 25560 -32000 0 0 {name=p24948 lab=_86295_/Q }
C {devices/lab_pin.sym} 25680 -32020 0 1 {name=p24949 lab=_72245_/Y }
C {sky130_stdcells/nor2_4.sym} 25620 -32020 0 0 {name=X_72245_ }
C {devices/lab_pin.sym} 25580 -31890 0 0 {name=p24950 lab=_45193_/A }
C {devices/lab_pin.sym} 25660 -31890 0 1 {name=p24951 lab=_45709_/A }
C {sky130_stdcells/buf_2.sym} 25620 -31890 0 0 {name=X_45193_ }
C {devices/lab_pin.sym} 25560 -31780 0 0 {name=p24952 lab=_57179_/A }
C {devices/lab_pin.sym} 25560 -31740 0 0 {name=p24953 lab=_57179_/B }
C {devices/lab_pin.sym} 25680 -31760 0 1 {name=p24954 lab=_57179_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -31760 0 0 {name=X_57179_ }
C {devices/lab_pin.sym} 25580 -31630 0 0 {name=p24955 lab=clkbuf_9_217_0_CLK/X }
C {devices/lab_pin.sym} 25660 -31630 0 1 {name=p24956 lab=_84228_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 25620 -31630 0 0 {name=Xclkbuf_10_434_0_CLK }
C {devices/lab_pin.sym} 25560 -31520 0 0 {name=p24957 lab=_44160_/A }
C {devices/lab_pin.sym} 25560 -31480 0 0 {name=p24958 lab=_87186_/Q }
C {devices/lab_pin.sym} 25680 -31500 0 1 {name=p24959 lab=_44144_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -31500 0 0 {name=X_44144_ }
C {devices/lab_pin.sym} 25540 -31390 0 0 {name=p24960 lab=_79828_/Y }
C {devices/lab_pin.sym} 25540 -31350 0 0 {name=p24961 lab=_79832_/Y }
C {devices/lab_pin.sym} 25540 -31310 0 0 {name=p24962 lab=_79840_/X }
C {devices/lab_pin.sym} 25700 -31350 0 1 {name=p24963 lab=_79842_/B }
C {sky130_stdcells/o21ai_4.sym} 25620 -31350 0 0 {name=X_79841_ }
C {devices/lab_pin.sym} 25580 -31210 0 0 {name=p24964 lab=_41355_/Y }
C {devices/lab_pin.sym} 25660 -31210 0 1 {name=p24965 lab=_41356_/X }
C {sky130_stdcells/buf_2.sym} 25620 -31210 0 0 {name=X_41356_ }
C {devices/lab_pin.sym} 25580 -31090 0 0 {name=p24966 lab=_60189_/Y }
C {devices/lab_pin.sym} 25660 -31090 0 1 {name=p24967 lab=_60324_/B }
C {sky130_stdcells/buf_2.sym} 25620 -31090 0 0 {name=X_60190_ }
C {devices/lab_pin.sym} 25580 -30970 0 0 {name=p24968 lab=_72176_/A }
C {devices/lab_pin.sym} 25660 -30970 0 1 {name=p24969 lab=_72176_/X }
C {sky130_stdcells/buf_2.sym} 25620 -30970 0 0 {name=X_72176_ }
C {devices/lab_pin.sym} 25560 -30870 0 0 {name=p24970 lab=_71129_/A }
C {devices/lab_pin.sym} 25560 -30830 0 0 {name=p24971 lab=_71082_/B }
C {devices/lab_pin.sym} 25560 -30790 0 0 {name=p24972 lab=_71119_/C }
C {devices/lab_pin.sym} 25680 -30830 0 1 {name=p24973 lab=_71127_/Y }
C {sky130_stdcells/nand3_4.sym} 25620 -30830 0 0 {name=X_71127_ }
C {devices/lab_pin.sym} 25580 -30690 0 0 {name=p24974 lab=_48612_/A }
C {devices/lab_pin.sym} 25660 -30690 0 1 {name=p24975 lab=_48952_/X }
C {sky130_stdcells/buf_2.sym} 25620 -30690 0 0 {name=X_48952_ }
C {devices/lab_pin.sym} 25580 -30570 0 0 {name=p24976 lab=_55741_/A }
C {devices/lab_pin.sym} 25660 -30570 0 1 {name=p24977 lab=_55159_/A }
C {sky130_stdcells/buf_2.sym} 25620 -30570 0 0 {name=X_44075_ }
C {devices/lab_pin.sym} 25560 -30460 0 0 {name=p24978 lab=_84222_/Q }
C {devices/lab_pin.sym} 25560 -30420 0 0 {name=p24979 lab=_83270_/Q }
C {devices/lab_pin.sym} 25680 -30440 0 1 {name=p24980 lab=_79772_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -30440 0 0 {name=X_79772_ }
C {devices/lab_pin.sym} 25540 -30330 0 0 {name=p24981 lab=_41255_/X }
C {devices/lab_pin.sym} 25540 -30290 0 0 {name=p24982 lab=_82913_/Q }
C {devices/lab_pin.sym} 25540 -30250 0 0 {name=p24983 lab=_41286_/X }
C {devices/lab_pin.sym} 25700 -30290 0 1 {name=p24984 lab=_41287_/Y }
C {sky130_stdcells/o21ai_4.sym} 25620 -30290 0 0 {name=X_41287_ }
C {devices/lab_pin.sym} 25560 -30160 0 0 {name=p24985 lab=_84536_/Q }
C {devices/lab_pin.sym} 25560 -30120 0 0 {name=p24986 lab=_76984_/B }
C {devices/lab_pin.sym} 25680 -30140 0 1 {name=p24987 lab=_76984_/X }
C {sky130_stdcells/xor2_4.sym} 25620 -30140 0 0 {name=X_76984_ }
C {devices/lab_pin.sym} 25580 -30010 0 0 {name=p24988 lab=_47846_/A }
C {devices/lab_pin.sym} 25660 -30010 0 1 {name=p24989 lab=_47903_/X }
C {sky130_stdcells/buf_2.sym} 25620 -30010 0 0 {name=X_47903_ }
C {devices/lab_pin.sym} 25540 -29930 0 0 {name=p24990 lab=_42439_/X }
C {devices/lab_pin.sym} 25540 -29890 0 0 {name=p24991 lab=_43017_/X }
C {devices/lab_pin.sym} 25540 -29850 0 0 {name=p24992 lab=_40573_/X }
C {devices/lab_pin.sym} 25540 -29810 0 0 {name=p24993 lab=_73577_/A }
C {devices/lab_pin.sym} 25540 -29770 0 0 {name=p24994 lab=_43025_/X }
C {devices/lab_pin.sym} 25700 -29850 0 1 {name=p24995 lab=_43027_/A }
C {sky130_stdcells/o32ai_4.sym} 25620 -29850 0 0 {name=X_43026_ }
C {devices/lab_pin.sym} 25560 -29700 0 0 {name=p24996 lab=_78700_/Y }
C {devices/lab_pin.sym} 25560 -29660 0 0 {name=p24997 lab=_78706_/B }
C {devices/lab_pin.sym} 25680 -29680 0 1 {name=p24998 lab=_78723_/Y }
C {sky130_stdcells/nor2_4.sym} 25620 -29680 0 0 {name=X_78723_ }
C {devices/lab_pin.sym} 25560 -29570 0 0 {name=p24999 lab=_71058_/A }
C {devices/lab_pin.sym} 25560 -29530 0 0 {name=p25000 lab=_71080_/B }
C {devices/lab_pin.sym} 25560 -29490 0 0 {name=p25001 lab=_71055_/C }
C {devices/lab_pin.sym} 25680 -29530 0 1 {name=p25002 lab=_71058_/Y }
C {sky130_stdcells/nand3_4.sym} 25620 -29530 0 0 {name=X_71058_ }
C {devices/lab_pin.sym} 25560 -29400 0 0 {name=p25003 lab=_81699_/D }
C {devices/lab_pin.sym} 25560 -29360 0 0 {name=p25004 lab=_75927_/B }
C {devices/lab_pin.sym} 25680 -29380 0 1 {name=p25005 lab=_75935_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -29380 0 0 {name=X_75935_ }
C {devices/lab_pin.sym} 25580 -29250 0 0 {name=p25006 lab=clkbuf_9_224_0_CLK/X }
C {devices/lab_pin.sym} 25660 -29250 0 1 {name=p25007 lab=_86303_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 25620 -29250 0 0 {name=Xclkbuf_10_449_0_CLK }
C {devices/lab_pin.sym} 25540 -29150 0 0 {name=p25008 lab=_48881_/X }
C {devices/lab_pin.sym} 25540 -29110 0 0 {name=p25009 lab=_81793_/Q }
C {devices/lab_pin.sym} 25540 -29070 0 0 {name=p25010 lab=_48882_/Y }
C {devices/lab_pin.sym} 25700 -29110 0 1 {name=p25011 lab=_48884_/A }
C {sky130_stdcells/o21ai_4.sym} 25620 -29110 0 0 {name=X_48883_ }
C {devices/lab_pin.sym} 25540 -29010 0 0 {name=p25012 lab=_62897_/Y }
C {devices/lab_pin.sym} 25540 -28970 0 0 {name=p25013 lab=_60337_/A }
C {devices/lab_pin.sym} 25540 -28930 0 0 {name=p25014 lab=_62650_/X }
C {devices/lab_pin.sym} 25540 -28890 0 0 {name=p25015 lab=_62898_/X }
C {devices/lab_pin.sym} 25540 -28860 0 0 {name=p25016 lab=_62899_/Y }
C {devices/lab_pin.sym} 25700 -28930 0 1 {name=p25017 lab=_62900_/X }
C {sky130_stdcells/a41o_4.sym} 25620 -28930 0 0 {name=X_62900_ }
C {devices/lab_pin.sym} 25580 -28770 0 0 {name=p25018 lab=_70009_/A }
C {devices/lab_pin.sym} 25660 -28770 0 1 {name=p25019 lab=_70048_/A }
C {sky130_stdcells/buf_2.sym} 25620 -28770 0 0 {name=X_70009_ }
C {devices/lab_pin.sym} 25560 -28670 0 0 {name=p25020 lab=_47834_/A }
C {devices/lab_pin.sym} 25560 -28630 0 0 {name=p25021 lab=_57489_/B }
C {devices/lab_pin.sym} 25560 -28590 0 0 {name=p25022 lab=_47841_/A }
C {devices/lab_pin.sym} 25680 -28630 0 1 {name=p25023 lab=_47834_/Y }
C {sky130_stdcells/nand3_4.sym} 25620 -28630 0 0 {name=X_47834_ }
C {devices/lab_pin.sym} 25560 -28510 0 0 {name=p25024 lab=_78654_/A }
C {devices/lab_pin.sym} 25560 -28470 0 0 {name=p25025 lab=_78652_/Y }
C {devices/lab_pin.sym} 25560 -28430 0 0 {name=p25026 lab=_78654_/C }
C {devices/lab_pin.sym} 25680 -28470 0 1 {name=p25027 lab=_78655_/B }
C {sky130_stdcells/nand3_4.sym} 25620 -28470 0 0 {name=X_78654_ }
C {devices/lab_pin.sym} 25560 -28350 0 0 {name=p25028 lab=_63848_/X }
C {devices/lab_pin.sym} 25560 -28310 0 0 {name=p25029 lab=_63849_/X }
C {devices/lab_pin.sym} 25560 -28270 0 0 {name=p25030 lab=_84289_/Q }
C {devices/lab_pin.sym} 25680 -28310 0 1 {name=p25031 lab=_63880_/Y }
C {sky130_stdcells/nor3_4.sym} 25620 -28310 0 0 {name=X_63880_ }
C {devices/lab_pin.sym} 25560 -28180 0 0 {name=p25032 lab=_75863_/Y }
C {devices/lab_pin.sym} 25560 -28140 0 0 {name=p25033 lab=_75865_/Y }
C {devices/lab_pin.sym} 25680 -28160 0 1 {name=p25034 lab=_80992_/D }
C {sky130_stdcells/nor2_4.sym} 25620 -28160 0 0 {name=X_75866_ }
C {devices/lab_pin.sym} 25560 -28040 0 0 {name=p25035 lab=_77603_/X }
C {devices/lab_pin.sym} 25560 -28000 0 0 {name=p25036 lab=_77604_/Y }
C {devices/lab_pin.sym} 25680 -28020 0 1 {name=p25037 lab=_77605_/X }
C {sky130_stdcells/and2_4.sym} 25620 -28020 0 0 {name=X_77605_ }
C {devices/lab_pin.sym} 25580 -27890 0 0 {name=p25038 lab=_74817_/A }
C {devices/lab_pin.sym} 25660 -27890 0 1 {name=p25039 lab=_74817_/Y }
C {sky130_stdcells/inv_2.sym} 25620 -27890 0 0 {name=X_74817_ }
C {devices/lab_pin.sym} 25580 -27770 0 0 {name=p25040 lab=_62886_/A }
C {devices/lab_pin.sym} 25660 -27770 0 1 {name=p25041 lab=_62831_/X }
C {sky130_stdcells/buf_2.sym} 25620 -27770 0 0 {name=X_62831_ }
C {devices/lab_pin.sym} 25540 -27670 0 0 {name=p25042 lab=_86600_/Q }
C {devices/lab_pin.sym} 25540 -27630 0 0 {name=p25043 lab=_47760_/X }
C {devices/lab_pin.sym} 25540 -27590 0 0 {name=p25044 lab=_47764_/Y }
C {devices/lab_pin.sym} 25700 -27630 0 1 {name=p25045 lab=_47765_/Y }
C {sky130_stdcells/o21ai_4.sym} 25620 -27630 0 0 {name=X_47765_ }
C {devices/lab_pin.sym} 25560 -27500 0 0 {name=p25046 lab=_78586_/A }
C {devices/lab_pin.sym} 25560 -27460 0 0 {name=p25047 lab=_82677_/D }
C {devices/lab_pin.sym} 25680 -27480 0 1 {name=p25048 lab=_78585_/Y }
C {sky130_stdcells/nor2_4.sym} 25620 -27480 0 0 {name=X_78585_ }
C {devices/lab_pin.sym} 25540 -27370 0 0 {name=p25049 lab=_44975_/X }
C {devices/lab_pin.sym} 25540 -27330 0 0 {name=p25050 lab=_61375_/B }
C {devices/lab_pin.sym} 25540 -27290 0 0 {name=p25051 lab=_44907_/X }
C {devices/lab_pin.sym} 25700 -27330 0 1 {name=p25052 lab=_44977_/Y }
C {sky130_stdcells/o21ai_4.sym} 25620 -27330 0 0 {name=X_44977_ }
C {devices/lab_pin.sym} 25560 -27200 0 0 {name=p25053 lab=_75802_/B }
C {devices/lab_pin.sym} 25560 -27160 0 0 {name=p25054 lab=_75796_/Y }
C {devices/lab_pin.sym} 25680 -27180 0 1 {name=p25055 lab=_75800_/A }
C {sky130_stdcells/xor2_4.sym} 25620 -27180 0 0 {name=X_75797_ }
C {devices/lab_pin.sym} 25580 -27050 0 0 {name=p25056 lab=_49504_/A }
C {devices/lab_pin.sym} 25660 -27050 0 1 {name=p25057 lab=_49614_/A }
C {sky130_stdcells/buf_2.sym} 25620 -27050 0 0 {name=X_49504_ }
C {devices/lab_pin.sym} 25580 -26930 0 0 {name=p25058 lab=_54325_/D }
C {devices/lab_pin.sym} 25660 -26930 0 1 {name=p25059 lab=_46716_/X }
C {sky130_stdcells/buf_2.sym} 25620 -26930 0 0 {name=X_46716_ }
C {devices/lab_pin.sym} 25540 -26840 0 0 {name=p25060 lab=_65438_/X }
C {devices/lab_pin.sym} 25540 -26800 0 0 {name=p25061 lab=_86201_/Q }
C {devices/lab_pin.sym} 25540 -26760 0 0 {name=p25062 lab=_65182_/X }
C {devices/lab_pin.sym} 25540 -26720 0 0 {name=p25063 lab=_65549_/X }
C {devices/lab_pin.sym} 25700 -26780 0 1 {name=p25064 lab=_65550_/X }
C {sky130_stdcells/a211o_4.sym} 25620 -26780 0 0 {name=X_65550_ }
C {devices/lab_pin.sym} 25540 -26650 0 0 {name=p25065 lab=_77537_/A }
C {devices/lab_pin.sym} 25540 -26610 0 0 {name=p25066 lab=_77537_/B }
C {devices/lab_pin.sym} 25540 -26570 0 0 {name=p25067 lab=_77535_/Y }
C {devices/lab_pin.sym} 25700 -26610 0 1 {name=p25068 lab=_77540_/B }
C {sky130_stdcells/o21a_4.sym} 25620 -26610 0 0 {name=X_77536_ }
C {devices/lab_pin.sym} 25580 -26470 0 0 {name=p25069 lab=_43927_/X }
C {devices/lab_pin.sym} 25660 -26470 0 1 {name=p25070 lab=_43928_/X }
C {sky130_stdcells/buf_2.sym} 25620 -26470 0 0 {name=X_43928_ }
C {devices/lab_pin.sym} 25560 -26370 0 0 {name=p25071 lab=_62727_/A }
C {devices/lab_pin.sym} 25560 -26330 0 0 {name=p25072 lab=_62762_/B }
C {devices/lab_pin.sym} 25560 -26290 0 0 {name=p25073 lab=_61876_/X }
C {devices/lab_pin.sym} 25680 -26330 0 1 {name=p25074 lab=_62762_/Y }
C {sky130_stdcells/nand3_4.sym} 25620 -26330 0 0 {name=X_62762_ }
C {devices/lab_pin.sym} 25560 -26220 0 0 {name=p25075 lab=_74748_/A }
C {devices/lab_pin.sym} 25560 -26180 0 0 {name=p25076 lab=_70638_/A }
C {devices/lab_pin.sym} 25560 -26140 0 0 {name=p25077 lab=_74797_/C }
C {devices/lab_pin.sym} 25560 -26100 0 0 {name=p25078 lab=_74769_/D }
C {devices/lab_pin.sym} 25680 -26160 0 1 {name=p25079 lab=_74748_/Y }
C {sky130_stdcells/nand4_4.sym} 25620 -26160 0 0 {name=X_74748_ }
C {devices/lab_pin.sym} 25560 -26020 0 0 {name=p25080 lab=_47696_/A }
C {devices/lab_pin.sym} 25560 -25980 0 0 {name=p25081 lab=_53193_/B }
C {devices/lab_pin.sym} 25680 -26000 0 1 {name=p25082 lab=_47696_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -26000 0 0 {name=X_47696_ }
C {devices/lab_pin.sym} 25560 -25900 0 0 {name=p25083 lab=_61140_/X }
C {devices/lab_pin.sym} 25560 -25860 0 0 {name=p25084 lab=_64523_/B }
C {devices/lab_pin.sym} 25560 -25820 0 0 {name=p25085 lab=_58194_/A }
C {devices/lab_pin.sym} 25560 -25780 0 0 {name=p25086 lab=_64523_/D }
C {devices/lab_pin.sym} 25680 -25840 0 1 {name=p25087 lab=_64501_/X }
C {sky130_stdcells/and4_4.sym} 25620 -25840 0 0 {name=X_64501_ }
C {devices/lab_pin.sym} 25580 -25690 0 0 {name=p25088 lab=_61712_/X }
C {devices/lab_pin.sym} 25660 -25690 0 1 {name=p25089 lab=_62128_/B }
C {sky130_stdcells/buf_2.sym} 25620 -25690 0 0 {name=X_61713_ }
C {devices/lab_pin.sym} 25580 -25570 0 0 {name=p25090 lab=_49407_/A }
C {devices/lab_pin.sym} 25660 -25570 0 1 {name=p25091 lab=_49447_/A }
C {sky130_stdcells/buf_2.sym} 25620 -25570 0 0 {name=X_49435_ }
C {devices/lab_pin.sym} 25560 -25480 0 0 {name=p25092 lab=_46670_/A }
C {devices/lab_pin.sym} 25560 -25440 0 0 {name=p25093 lab=_46647_/B }
C {devices/lab_pin.sym} 25560 -25400 0 0 {name=p25094 lab=_46659_/C }
C {devices/lab_pin.sym} 25560 -25360 0 0 {name=p25095 lab=_51768_/D }
C {devices/lab_pin.sym} 25680 -25420 0 1 {name=p25096 lab=_46647_/X }
C {sky130_stdcells/and4_4.sym} 25620 -25420 0 0 {name=X_46647_ }
C {devices/lab_pin.sym} 25560 -25290 0 0 {name=p25097 lab=_65449_/A }
C {devices/lab_pin.sym} 25560 -25250 0 0 {name=p25098 lab=_65546_/B }
C {devices/lab_pin.sym} 25560 -25210 0 0 {name=p25099 lab=_65481_/C }
C {devices/lab_pin.sym} 25680 -25250 0 1 {name=p25100 lab=_65481_/X }
C {sky130_stdcells/and3_4.sym} 25620 -25250 0 0 {name=X_65481_ }
C {devices/lab_pin.sym} 25560 -25120 0 0 {name=p25101 lab=_77468_/A }
C {devices/lab_pin.sym} 25560 -25080 0 0 {name=p25102 lab=_77468_/B }
C {devices/lab_pin.sym} 25680 -25100 0 1 {name=p25103 lab=_77467_/Y }
C {sky130_stdcells/nor2_4.sym} 25620 -25100 0 0 {name=X_77467_ }
C {devices/lab_pin.sym} 25540 -25010 0 0 {name=p25104 lab=_43846_/X }
C {devices/lab_pin.sym} 25540 -24970 0 0 {name=p25105 lab=_43854_/X }
C {devices/lab_pin.sym} 25540 -24930 0 0 {name=p25106 lab=_41225_/X }
C {devices/lab_pin.sym} 25540 -24890 0 0 {name=p25107 lab=_68898_/B }
C {devices/lab_pin.sym} 25540 -24850 0 0 {name=p25108 lab=_43847_/X }
C {devices/lab_pin.sym} 25700 -24930 0 1 {name=p25109 lab=_43859_/Y }
C {sky130_stdcells/o32ai_4.sym} 25620 -24930 0 0 {name=X_43859_ }
C {devices/lab_pin.sym} 25560 -24790 0 0 {name=p25110 lab=_62678_/A }
C {devices/lab_pin.sym} 25560 -24750 0 0 {name=p25111 lab=_62727_/B }
C {devices/lab_pin.sym} 25560 -24710 0 0 {name=p25112 lab=_61780_/X }
C {devices/lab_pin.sym} 25680 -24750 0 1 {name=p25113 lab=_62693_/Y }
C {sky130_stdcells/nand3_4.sym} 25620 -24750 0 0 {name=X_62693_ }
C {devices/lab_pin.sym} 25560 -24620 0 0 {name=p25114 lab=_74679_/A }
C {devices/lab_pin.sym} 25560 -24580 0 0 {name=p25115 lab=_74679_/B }
C {devices/lab_pin.sym} 25680 -24600 0 1 {name=p25116 lab=_74679_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -24600 0 0 {name=X_74679_ }
C {devices/lab_pin.sym} 25560 -24480 0 0 {name=p25117 lab=_67220_/A }
C {devices/lab_pin.sym} 25560 -24440 0 0 {name=p25118 lab=_67219_/X }
C {devices/lab_pin.sym} 25680 -24460 0 1 {name=p25119 lab=_67220_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -24460 0 0 {name=X_67220_ }
C {devices/lab_pin.sym} 25560 -24340 0 0 {name=p25120 lab=_79205_/C }
C {devices/lab_pin.sym} 25560 -24300 0 0 {name=p25121 lab=_79205_/B }
C {devices/lab_pin.sym} 25680 -24320 0 1 {name=p25122 lab=_79206_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -24320 0 0 {name=X_79206_ }
C {devices/lab_pin.sym} 25560 -24200 0 0 {name=p25123 lab=_63598_/A }
C {devices/lab_pin.sym} 25560 -24160 0 0 {name=p25124 lab=_64419_/B }
C {devices/lab_pin.sym} 25680 -24180 0 1 {name=p25125 lab=_64432_/Y }
C {sky130_stdcells/nor2_4.sym} 25620 -24180 0 0 {name=X_64432_ }
C {devices/lab_pin.sym} 25560 -24060 0 0 {name=p25126 lab=_76418_/A }
C {devices/lab_pin.sym} 25560 -24020 0 0 {name=p25127 lab=_76417_/Y }
C {devices/lab_pin.sym} 25680 -24040 0 1 {name=p25128 lab=_76418_/X }
C {sky130_stdcells/and2_4.sym} 25620 -24040 0 0 {name=X_76418_ }
C {devices/lab_pin.sym} 25560 -23920 0 0 {name=p25129 lab=_49382_/A }
C {devices/lab_pin.sym} 25560 -23880 0 0 {name=p25130 lab=_46625_/X }
C {devices/lab_pin.sym} 25680 -23900 0 1 {name=p25131 lab=_49366_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -23900 0 0 {name=X_49366_ }
C {devices/lab_pin.sym} 25580 -23770 0 0 {name=p25132 lab=_61348_/A }
C {devices/lab_pin.sym} 25660 -23770 0 1 {name=p25133 lab=_61645_/A }
C {sky130_stdcells/buf_2.sym} 25620 -23770 0 0 {name=X_61644_ }
C {devices/lab_pin.sym} 25580 -23650 0 0 {name=p25134 lab=_47904_/A }
C {devices/lab_pin.sym} 25660 -23650 0 1 {name=p25135 lab=_46578_/X }
C {sky130_stdcells/buf_2.sym} 25620 -23650 0 0 {name=X_46578_ }
C {devices/lab_pin.sym} 25580 -23530 0 0 {name=p25136 lab=_77386_/A }
C {devices/lab_pin.sym} 25660 -23530 0 1 {name=p25137 lab=_77398_/Y }
C {sky130_stdcells/inv_2.sym} 25620 -23530 0 0 {name=X_77398_ }
C {devices/lab_pin.sym} 25560 -23430 0 0 {name=p25138 lab=_50360_/A }
C {devices/lab_pin.sym} 25560 -23390 0 0 {name=p25139 lab=_48286_/X }
C {devices/lab_pin.sym} 25560 -23350 0 0 {name=p25140 lab=_48287_/C }
C {devices/lab_pin.sym} 25680 -23390 0 1 {name=p25141 lab=_48317_/X }
C {sky130_stdcells/and3_4.sym} 25620 -23390 0 0 {name=X_48317_ }
C {devices/lab_pin.sym} 25560 -23260 0 0 {name=p25142 lab=_67148_/X }
C {devices/lab_pin.sym} 25560 -23220 0 0 {name=p25143 lab=_67150_/X }
C {devices/lab_pin.sym} 25680 -23240 0 1 {name=p25144 lab=_67151_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -23240 0 0 {name=X_67151_ }
C {devices/lab_pin.sym} 25560 -23120 0 0 {name=p25145 lab=_79137_/A }
C {devices/lab_pin.sym} 25560 -23080 0 0 {name=p25146 lab=_61577_/C }
C {devices/lab_pin.sym} 25680 -23100 0 1 {name=p25147 lab=_79137_/X }
C {sky130_stdcells/xor2_4.sym} 25620 -23100 0 0 {name=X_79137_ }
C {devices/lab_pin.sym} 25580 -22970 0 0 {name=p25148 lab=_63100_/B }
C {devices/lab_pin.sym} 25660 -22970 0 1 {name=p25149 lab=_61430_/A }
C {sky130_stdcells/buf_2.sym} 25620 -22970 0 0 {name=X_45529_ }
C {devices/lab_pin.sym} 25560 -22880 0 0 {name=p25150 lab=_64363_/A }
C {devices/lab_pin.sym} 25560 -22840 0 0 {name=p25151 lab=_64363_/B }
C {devices/lab_pin.sym} 25560 -22800 0 0 {name=p25152 lab=_63524_/B }
C {devices/lab_pin.sym} 25560 -22760 0 0 {name=p25153 lab=_64318_/D }
C {devices/lab_pin.sym} 25680 -22820 0 1 {name=p25154 lab=_64363_/X }
C {sky130_stdcells/and4_4.sym} 25620 -22820 0 0 {name=X_64363_ }
C {devices/lab_pin.sym} 25540 -22690 0 0 {name=p25155 lab=_76348_/B }
C {devices/lab_pin.sym} 25540 -22650 0 0 {name=p25156 lab=_76348_/C }
C {devices/lab_pin.sym} 25540 -22610 0 0 {name=p25157 lab=_76344_/Y }
C {devices/lab_pin.sym} 25700 -22650 0 1 {name=p25158 lab=_76349_/Y }
C {sky130_stdcells/o21ai_4.sym} 25620 -22650 0 0 {name=X_76349_ }
C {devices/lab_pin.sym} 25540 -22550 0 0 {name=p25159 lab=_61568_/Y }
C {devices/lab_pin.sym} 25540 -22510 0 0 {name=p25160 lab=_61570_/Y }
C {devices/lab_pin.sym} 25540 -22470 0 0 {name=p25161 lab=_61525_/X }
C {devices/lab_pin.sym} 25540 -22430 0 0 {name=p25162 lab=_61572_/Y }
C {devices/lab_pin.sym} 25540 -22400 0 0 {name=p25163 lab=_61574_/Y }
C {devices/lab_pin.sym} 25700 -22470 0 1 {name=p25164 lab=_61575_/X }
C {sky130_stdcells/a41o_4.sym} 25620 -22470 0 0 {name=X_61575_ }
C {devices/lab_pin.sym} 25560 -22320 0 0 {name=p25165 lab=_49273_/A }
C {devices/lab_pin.sym} 25560 -22280 0 0 {name=p25166 lab=_50816_/B }
C {devices/lab_pin.sym} 25680 -22300 0 1 {name=p25167 lab=_49297_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -22300 0 0 {name=X_49297_ }
C {devices/lab_pin.sym} 25540 -22200 0 0 {name=p25168 lab=_66040_/X }
C {devices/lab_pin.sym} 25540 -22160 0 0 {name=p25169 lab=_84980_/Q }
C {devices/lab_pin.sym} 25540 -22120 0 0 {name=p25170 lab=_66027_/X }
C {devices/lab_pin.sym} 25540 -22080 0 0 {name=p25171 lab=_66101_/X }
C {devices/lab_pin.sym} 25700 -22140 0 1 {name=p25172 lab=_66102_/X }
C {sky130_stdcells/a211o_4.sym} 25620 -22140 0 0 {name=X_66102_ }
C {devices/lab_pin.sym} 25560 -22020 0 0 {name=p25173 lab=_60433_/A }
C {devices/lab_pin.sym} 25560 -21980 0 0 {name=p25174 lab=_63314_/B }
C {devices/lab_pin.sym} 25560 -21940 0 0 {name=p25175 lab=_63333_/C }
C {devices/lab_pin.sym} 25560 -21900 0 0 {name=p25176 lab=_63240_/X }
C {devices/lab_pin.sym} 25680 -21960 0 1 {name=p25177 lab=_63314_/X }
C {sky130_stdcells/and4_4.sym} 25620 -21960 0 0 {name=X_63314_ }
C {devices/lab_pin.sym} 25540 -21830 0 0 {name=p25178 lab=_48245_/Y }
C {devices/lab_pin.sym} 25540 -21790 0 0 {name=p25179 lab=_48226_/X }
C {devices/lab_pin.sym} 25540 -21750 0 0 {name=p25180 lab=_48247_/Y }
C {devices/lab_pin.sym} 25700 -21790 0 1 {name=p25181 lab=_86549_/D }
C {sky130_stdcells/a21boi_4.sym} 25620 -21790 0 0 {name=X_48248_ }
C {devices/lab_pin.sym} 25560 -21670 0 0 {name=p25182 lab=_60526_/A }
C {devices/lab_pin.sym} 25560 -21630 0 0 {name=p25183 lab=_60526_/B }
C {devices/lab_pin.sym} 25560 -21590 0 0 {name=p25184 lab=_79146_/A }
C {devices/lab_pin.sym} 25680 -21630 0 1 {name=p25185 lab=_60526_/Y }
C {sky130_stdcells/nor3_4.sym} 25620 -21630 0 0 {name=X_60526_ }
C {devices/lab_pin.sym} 25580 -21490 0 0 {name=p25186 lab=_67082_/A }
C {devices/lab_pin.sym} 25660 -21490 0 1 {name=p25187 lab=_67133_/A }
C {sky130_stdcells/buf_2.sym} 25620 -21490 0 0 {name=X_67082_ }
C {devices/lab_pin.sym} 25540 -21410 0 0 {name=p25188 lab=_79055_/B }
C {devices/lab_pin.sym} 25540 -21370 0 0 {name=p25189 lab=_79055_/A }
C {devices/lab_pin.sym} 25540 -21330 0 0 {name=p25190 lab=_79044_/C }
C {devices/lab_pin.sym} 25540 -21290 0 0 {name=p25191 lab=_79044_/B }
C {devices/lab_pin.sym} 25540 -21250 0 0 {name=p25192 lab=_79067_/Y }
C {devices/lab_pin.sym} 25700 -21330 0 1 {name=p25193 lab=_79068_/X }
C {sky130_stdcells/o41a_4.sym} 25620 -21330 0 0 {name=X_79068_ }
C {devices/lab_pin.sym} 25580 -21170 0 0 {name=p25194 lab=clkbuf_9_509_0_CLK/A }
C {devices/lab_pin.sym} 25660 -21170 0 1 {name=p25195 lab=clkbuf_9_508_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 25620 -21170 0 0 {name=Xclkbuf_9_508_0_CLK }
C {devices/lab_pin.sym} 25560 -21070 0 0 {name=p25196 lab=_64275_/A }
C {devices/lab_pin.sym} 25560 -21030 0 0 {name=p25197 lab=_64294_/B }
C {devices/lab_pin.sym} 25560 -20990 0 0 {name=p25198 lab=_64274_/X }
C {devices/lab_pin.sym} 25680 -21030 0 1 {name=p25199 lab=_64294_/X }
C {sky130_stdcells/and3_4.sym} 25620 -21030 0 0 {name=X_64294_ }
C {devices/lab_pin.sym} 25560 -20910 0 0 {name=p25200 lab=_65970_/A }
C {devices/lab_pin.sym} 25560 -20870 0 0 {name=p25201 lab=_66004_/B }
C {devices/lab_pin.sym} 25560 -20830 0 0 {name=p25202 lab=_84161_/Q }
C {devices/lab_pin.sym} 25680 -20870 0 1 {name=p25203 lab=_66033_/X }
C {sky130_stdcells/and3_4.sym} 25620 -20870 0 0 {name=X_66033_ }
C {devices/lab_pin.sym} 25560 -20740 0 0 {name=p25204 lab=_78018_/B }
C {devices/lab_pin.sym} 25560 -20700 0 0 {name=p25205 lab=_78018_/A }
C {devices/lab_pin.sym} 25680 -20720 0 1 {name=p25206 lab=_78021_/C }
C {sky130_stdcells/nand2_4.sym} 25620 -20720 0 0 {name=X_78019_ }
C {devices/lab_pin.sym} 25540 -20610 0 0 {name=p25207 lab=_63243_/Y }
C {devices/lab_pin.sym} 25540 -20570 0 0 {name=p25208 lab=_63244_/X }
C {devices/lab_pin.sym} 25540 -20530 0 0 {name=p25209 lab=_63231_/X }
C {devices/lab_pin.sym} 25700 -20570 0 1 {name=p25210 lab=_63245_/Y }
C {sky130_stdcells/a21oi_4.sym} 25620 -20570 0 0 {name=X_63245_ }
C {devices/lab_pin.sym} 25560 -20440 0 0 {name=p25211 lab=_48184_/A }
C {devices/lab_pin.sym} 25560 -20400 0 0 {name=p25212 lab=_48178_/X }
C {devices/lab_pin.sym} 25680 -20420 0 1 {name=p25213 lab=_48179_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -20420 0 0 {name=X_48179_ }
C {devices/lab_pin.sym} 25580 -20290 0 0 {name=p25214 lab=_60456_/X }
C {devices/lab_pin.sym} 25660 -20290 0 1 {name=p25215 lab=_60457_/Y }
C {sky130_stdcells/inv_2.sym} 25620 -20290 0 0 {name=X_60457_ }
C {devices/lab_pin.sym} 25580 -20170 0 0 {name=p25216 lab=clkbuf_8_61_0_CLK/A }
C {devices/lab_pin.sym} 25660 -20170 0 1 {name=p25217 lab=clkbuf_8_61_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 25620 -20170 0 0 {name=Xclkbuf_8_61_0_CLK }
C {devices/lab_pin.sym} 25540 -20070 0 0 {name=p25218 lab=_50208_/Y }
C {devices/lab_pin.sym} 25540 -20030 0 0 {name=p25219 lab=_50191_/X }
C {devices/lab_pin.sym} 25540 -19990 0 0 {name=p25220 lab=_50209_/X }
C {devices/lab_pin.sym} 25700 -20030 0 1 {name=p25221 lab=_50210_/Y }
C {sky130_stdcells/a21oi_4.sym} 25620 -20030 0 0 {name=X_50210_ }
C {devices/lab_pin.sym} 25530 -19890 0 0 {name=p25222 lab=_81061_/CLK }
C {devices/lab_pin.sym} 25530 -19870 0 0 {name=p25223 lab=_81030_/D }
C {devices/lab_pin.sym} 25710 -19890 0 1 {name=p25224 lab=_81222_/D }
C {sky130_stdcells/dfxtp_4.sym} 25620 -19880 0 0 {name=X_81030_ }
C {devices/lab_pin.sym} 25540 -19770 0 0 {name=p25225 lab=_86057_/Q }
C {devices/lab_pin.sym} 25540 -19730 0 0 {name=p25226 lab=_51183_/X }
C {devices/lab_pin.sym} 25540 -19690 0 0 {name=p25227 lab=_51189_/Y }
C {devices/lab_pin.sym} 25700 -19730 0 1 {name=p25228 lab=_51190_/Y }
C {sky130_stdcells/o21ai_4.sym} 25620 -19730 0 0 {name=X_51190_ }
C {devices/lab_pin.sym} 25580 -19590 0 0 {name=p25229 lab=_63118_/A }
C {devices/lab_pin.sym} 25660 -19590 0 1 {name=p25230 lab=_63176_/X }
C {sky130_stdcells/buf_2.sym} 25620 -19590 0 0 {name=X_63176_ }
C {devices/lab_pin.sym} 25580 -19470 0 0 {name=p25231 lab=_60387_/X }
C {devices/lab_pin.sym} 25660 -19470 0 1 {name=p25232 lab=_60606_/A }
C {sky130_stdcells/buf_2.sym} 25620 -19470 0 0 {name=X_60388_ }
C {devices/lab_pin.sym} 25580 -19350 0 0 {name=p25233 lab=_50092_/A }
C {devices/lab_pin.sym} 25660 -19350 0 1 {name=p25234 lab=_50141_/X }
C {sky130_stdcells/buf_2.sym} 25620 -19350 0 0 {name=X_50141_ }
C {devices/lab_pin.sym} 25540 -19250 0 0 {name=p25235 lab=_61716_/X }
C {devices/lab_pin.sym} 25540 -19210 0 0 {name=p25236 lab=_61636_/B }
C {devices/lab_pin.sym} 25540 -19170 0 0 {name=p25237 lab=_62126_/X }
C {devices/lab_pin.sym} 25700 -19210 0 1 {name=p25238 lab=_62127_/X }
C {sky130_stdcells/a21o_4.sym} 25620 -19210 0 0 {name=X_62127_ }
C {devices/lab_pin.sym} 25580 -19070 0 0 {name=p25239 lab=_68651_/A }
C {devices/lab_pin.sym} 25660 -19070 0 1 {name=p25240 lab=_67984_/X }
C {sky130_stdcells/buf_2.sym} 25620 -19070 0 0 {name=X_67984_ }
C {devices/lab_pin.sym} 25540 -18980 0 0 {name=p25241 lab=_73083_/A }
C {devices/lab_pin.sym} 25540 -18940 0 0 {name=p25242 lab=_68640_/X }
C {devices/lab_pin.sym} 25540 -18900 0 0 {name=p25243 lab=_68070_/X }
C {devices/lab_pin.sym} 25540 -18860 0 0 {name=p25244 lab=_69722_/Y }
C {devices/lab_pin.sym} 25700 -18920 0 1 {name=p25245 lab=_69723_/X }
C {sky130_stdcells/a211o_4.sym} 25620 -18920 0 0 {name=X_69723_ }
C {devices/lab_pin.sym} 25540 -18790 0 0 {name=p25246 lab=_86270_/Q }
C {devices/lab_pin.sym} 25540 -18750 0 0 {name=p25247 lab=_50061_/X }
C {devices/lab_pin.sym} 25540 -18710 0 0 {name=p25248 lab=_50071_/Y }
C {devices/lab_pin.sym} 25700 -18750 0 1 {name=p25249 lab=_50072_/Y }
C {sky130_stdcells/o21ai_4.sym} 25620 -18750 0 0 {name=X_50072_ }
C {devices/lab_pin.sym} 25580 -18610 0 0 {name=p25250 lab=_69582_/A }
C {devices/lab_pin.sym} 25660 -18610 0 1 {name=p25251 lab=_66935_/X }
C {sky130_stdcells/buf_2.sym} 25620 -18610 0 0 {name=X_66935_ }
C {devices/lab_pin.sym} 25540 -18510 0 0 {name=p25252 lab=_61716_/X }
C {devices/lab_pin.sym} 25540 -18470 0 0 {name=p25253 lab=_61579_/B }
C {devices/lab_pin.sym} 25540 -18430 0 0 {name=p25254 lab=_62057_/X }
C {devices/lab_pin.sym} 25700 -18470 0 1 {name=p25255 lab=_62058_/X }
C {sky130_stdcells/a21o_4.sym} 25620 -18470 0 0 {name=X_62058_ }
C {devices/lab_pin.sym} 25530 -18330 0 0 {name=p25256 lab=_82987_/CLK }
C {devices/lab_pin.sym} 25530 -18310 0 0 {name=p25257 lab=_82981_/D }
C {devices/lab_pin.sym} 25710 -18330 0 1 {name=p25258 lab=_82981_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -18320 0 0 {name=X_82981_ }
C {devices/lab_pin.sym} 25580 -18190 0 0 {name=p25259 lab=clkbuf_8_77_0_CLK/A }
C {devices/lab_pin.sym} 25660 -18190 0 1 {name=p25260 lab=clkbuf_8_76_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 25620 -18190 0 0 {name=Xclkbuf_8_76_0_CLK }
C {devices/lab_pin.sym} 25580 -18070 0 0 {name=p25261 lab=clkbuf_6_4_0_CLK/X }
C {devices/lab_pin.sym} 25660 -18070 0 1 {name=p25262 lab=clkbuf_7_8_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 25620 -18070 0 0 {name=Xclkbuf_7_8_0_CLK }
C {devices/lab_pin.sym} 25580 -17950 0 0 {name=p25263 lab=_53900_/A }
C {devices/lab_pin.sym} 25660 -17950 0 1 {name=p25264 lab=_53929_/A }
C {sky130_stdcells/buf_2.sym} 25620 -17950 0 0 {name=X_53900_ }
C {devices/lab_pin.sym} 25540 -17870 0 0 {name=p25265 lab=_61004_/Y }
C {devices/lab_pin.sym} 25540 -17830 0 0 {name=p25266 lab=_61008_/Y }
C {devices/lab_pin.sym} 25540 -17790 0 0 {name=p25267 lab=_60938_/A }
C {devices/lab_pin.sym} 25540 -17750 0 0 {name=p25268 lab=_76990_/A }
C {devices/lab_pin.sym} 25540 -17710 0 0 {name=p25269 lab=_60898_/X }
C {devices/lab_pin.sym} 25700 -17790 0 1 {name=p25270 lab=_84542_/D }
C {sky130_stdcells/o32a_4.sym} 25620 -17790 0 0 {name=X_61009_ }
C {devices/lab_pin.sym} 25530 -17630 0 0 {name=p25271 lab=_84727_/CLK }
C {devices/lab_pin.sym} 25530 -17610 0 0 {name=p25272 lab=_84720_/D }
C {devices/lab_pin.sym} 25710 -17630 0 1 {name=p25273 lab=_64225_/C }
C {sky130_stdcells/dfxtp_4.sym} 25620 -17620 0 0 {name=X_84720_ }
C {devices/lab_pin.sym} 25530 -17490 0 0 {name=p25274 lab=_83906_/CLK }
C {devices/lab_pin.sym} 25530 -17470 0 0 {name=p25275 lab=_77838_/Y }
C {devices/lab_pin.sym} 25710 -17490 0 1 {name=p25276 lab=_81932_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -17480 0 0 {name=X_81932_ }
C {devices/lab_pin.sym} 25580 -17350 0 0 {name=p25277 lab=_69654_/A }
C {devices/lab_pin.sym} 25660 -17350 0 1 {name=p25278 lab=_69655_/A }
C {sky130_stdcells/buf_2.sym} 25620 -17350 0 0 {name=X_69654_ }
C {devices/lab_pin.sym} 25560 -17240 0 0 {name=p25279 lab=_54885_/A }
C {devices/lab_pin.sym} 25560 -17200 0 0 {name=p25280 lab=_54880_/B }
C {devices/lab_pin.sym} 25680 -17220 0 1 {name=p25281 lab=_54880_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -17220 0 0 {name=X_54880_ }
C {devices/lab_pin.sym} 25540 -17110 0 0 {name=p25282 lab=_66862_/X }
C {devices/lab_pin.sym} 25540 -17070 0 0 {name=p25283 lab=_66865_/X }
C {devices/lab_pin.sym} 25540 -17030 0 0 {name=p25284 lab=_66843_/X }
C {devices/lab_pin.sym} 25700 -17070 0 1 {name=p25285 lab=_66866_/X }
C {sky130_stdcells/a21o_4.sym} 25620 -17070 0 0 {name=X_66866_ }
C {devices/lab_pin.sym} 25540 -16960 0 0 {name=p25286 lab=_87498_/Q }
C {devices/lab_pin.sym} 25540 -16920 0 0 {name=p25287 lab=_68504_/X }
C {devices/lab_pin.sym} 25540 -16880 0 0 {name=p25288 lab=_68601_/X }
C {devices/lab_pin.sym} 25540 -16840 0 0 {name=p25289 lab=_68604_/X }
C {devices/lab_pin.sym} 25700 -16900 0 1 {name=p25290 lab=_68605_/X }
C {sky130_stdcells/a211o_4.sym} 25620 -16900 0 0 {name=X_68605_ }
C {devices/lab_pin.sym} 25540 -16770 0 0 {name=p25291 lab=_53828_/Y }
C {devices/lab_pin.sym} 25540 -16730 0 0 {name=p25292 lab=_53829_/X }
C {devices/lab_pin.sym} 25540 -16690 0 0 {name=p25293 lab=_53830_/X }
C {devices/lab_pin.sym} 25700 -16730 0 1 {name=p25294 lab=_53831_/Y }
C {sky130_stdcells/a21oi_4.sym} 25620 -16730 0 0 {name=X_53831_ }
C {devices/lab_pin.sym} 25560 -16610 0 0 {name=p25295 lab=_65855_/A }
C {devices/lab_pin.sym} 25560 -16570 0 0 {name=p25296 lab=_65916_/B }
C {devices/lab_pin.sym} 25560 -16530 0 0 {name=p25297 lab=_65817_/C }
C {devices/lab_pin.sym} 25680 -16570 0 1 {name=p25298 lab=_65817_/X }
C {sky130_stdcells/and3_4.sym} 25620 -16570 0 0 {name=X_65817_ }
C {devices/lab_pin.sym} 25530 -16430 0 0 {name=p25299 lab=_84652_/CLK }
C {devices/lab_pin.sym} 25530 -16410 0 0 {name=p25300 lab=_60149_/X }
C {devices/lab_pin.sym} 25710 -16430 0 1 {name=p25301 lab=_79907_/B }
C {sky130_stdcells/dfxtp_4.sym} 25620 -16420 0 0 {name=X_84651_ }
C {devices/lab_pin.sym} 25530 -16290 0 0 {name=p25302 lab=_84375_/CLK }
C {devices/lab_pin.sym} 25530 -16270 0 0 {name=p25303 lab=_78054_/X }
C {devices/lab_pin.sym} 25710 -16290 0 1 {name=p25304 lab=_81863_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -16280 0 0 {name=X_81863_ }
C {devices/lab_pin.sym} 25540 -16170 0 0 {name=p25305 lab=_69581_/X }
C {devices/lab_pin.sym} 25540 -16130 0 0 {name=p25306 lab=_69584_/X }
C {devices/lab_pin.sym} 25540 -16090 0 0 {name=p25307 lab=_69570_/X }
C {devices/lab_pin.sym} 25700 -16130 0 1 {name=p25308 lab=_69585_/X }
C {sky130_stdcells/a21o_4.sym} 25620 -16130 0 0 {name=X_69585_ }
C {devices/lab_pin.sym} 25580 -15990 0 0 {name=p25309 lab=_69162_/A }
C {devices/lab_pin.sym} 25660 -15990 0 1 {name=p25310 lab=_66797_/X }
C {sky130_stdcells/buf_2.sym} 25620 -15990 0 0 {name=X_66797_ }
C {devices/lab_pin.sym} 25530 -15870 0 0 {name=p25311 lab=_85557_/CLK }
C {devices/lab_pin.sym} 25530 -15850 0 0 {name=p25312 lab=_71114_/Y }
C {devices/lab_pin.sym} 25710 -15870 0 1 {name=p25313 lab=_49115_/A }
C {sky130_stdcells/dfxtp_4.sym} 25620 -15860 0 0 {name=X_83602_ }
C {devices/lab_pin.sym} 25580 -15730 0 0 {name=p25314 lab=_72973_/B }
C {devices/lab_pin.sym} 25660 -15730 0 1 {name=p25315 lab=_56550_/X }
C {sky130_stdcells/buf_2.sym} 25620 -15730 0 0 {name=X_56550_ }
C {devices/lab_pin.sym} 25530 -15610 0 0 {name=p25316 lab=_80821_/CLK }
C {devices/lab_pin.sym} 25530 -15590 0 0 {name=p25317 lab=_83958_/Q }
C {devices/lab_pin.sym} 25710 -15610 0 1 {name=p25318 lab=_75829_/B }
C {sky130_stdcells/dfxtp_4.sym} 25620 -15600 0 0 {name=X_80814_ }
C {devices/lab_pin.sym} 25540 -15500 0 0 {name=p25319 lab=_87097_/Q }
C {devices/lab_pin.sym} 25540 -15460 0 0 {name=p25320 lab=_68455_/X }
C {devices/lab_pin.sym} 25540 -15420 0 0 {name=p25321 lab=_68509_/X }
C {devices/lab_pin.sym} 25540 -15380 0 0 {name=p25322 lab=_68535_/X }
C {devices/lab_pin.sym} 25700 -15440 0 1 {name=p25323 lab=_68536_/X }
C {sky130_stdcells/a211o_4.sym} 25620 -15440 0 0 {name=X_68536_ }
C {devices/lab_pin.sym} 25530 -15290 0 0 {name=p25324 lab=_87373_/CLK }
C {devices/lab_pin.sym} 25530 -15270 0 0 {name=p25325 lab=_87370_/D }
C {devices/lab_pin.sym} 25710 -15290 0 1 {name=p25326 lab=_87370_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -15280 0 0 {name=X_87370_ }
C {devices/lab_pin.sym} 25540 -15170 0 0 {name=p25327 lab=_85573_/Q }
C {devices/lab_pin.sym} 25540 -15130 0 0 {name=p25328 lab=_53754_/X }
C {devices/lab_pin.sym} 25540 -15090 0 0 {name=p25329 lab=_53761_/Y }
C {devices/lab_pin.sym} 25700 -15130 0 1 {name=p25330 lab=_53762_/Y }
C {sky130_stdcells/o21ai_4.sym} 25620 -15130 0 0 {name=X_53762_ }
C {devices/lab_pin.sym} 25560 -15000 0 0 {name=p25331 lab=_65731_/A }
C {devices/lab_pin.sym} 25560 -14960 0 0 {name=p25332 lab=_85868_/Q }
C {devices/lab_pin.sym} 25680 -14980 0 1 {name=p25333 lab=_65748_/X }
C {sky130_stdcells/and2_4.sym} 25620 -14980 0 0 {name=X_65748_ }
C {devices/lab_pin.sym} 25530 -14850 0 0 {name=p25334 lab=_84590_/CLK }
C {devices/lab_pin.sym} 25530 -14830 0 0 {name=p25335 lab=_60706_/Y }
C {devices/lab_pin.sym} 25710 -14850 0 1 {name=p25336 lab=_84582_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -14840 0 0 {name=X_84582_ }
C {devices/lab_pin.sym} 25560 -14740 0 0 {name=p25337 lab=_50973_/X }
C {devices/lab_pin.sym} 25560 -14700 0 0 {name=p25338 lab=_50963_/B }
C {devices/lab_pin.sym} 25560 -14660 0 0 {name=p25339 lab=_50963_/C }
C {devices/lab_pin.sym} 25560 -14620 0 0 {name=p25340 lab=_46775_/X }
C {devices/lab_pin.sym} 25680 -14680 0 1 {name=p25341 lab=_50974_/X }
C {sky130_stdcells/and4_4.sym} 25620 -14680 0 0 {name=X_50974_ }
C {devices/lab_pin.sym} 25530 -14530 0 0 {name=p25342 lab=_81794_/CLK }
C {devices/lab_pin.sym} 25530 -14510 0 0 {name=p25343 lab=_81602_/Q }
C {devices/lab_pin.sym} 25710 -14530 0 1 {name=p25344 lab=_81794_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -14520 0 0 {name=X_81794_ }
C {devices/lab_pin.sym} 25560 -14400 0 0 {name=p25345 lab=_55501_/A }
C {devices/lab_pin.sym} 25560 -14360 0 0 {name=p25346 lab=_55500_/X }
C {devices/lab_pin.sym} 25680 -14380 0 1 {name=p25347 lab=_55501_/X }
C {sky130_stdcells/and2_4.sym} 25620 -14380 0 0 {name=X_55501_ }
C {devices/lab_pin.sym} 25530 -14250 0 0 {name=p25348 lab=_86640_/CLK }
C {devices/lab_pin.sym} 25530 -14230 0 0 {name=p25349 lab=_86321_/D }
C {devices/lab_pin.sym} 25710 -14250 0 1 {name=p25350 lab=_57952_/B }
C {sky130_stdcells/dfxtp_4.sym} 25620 -14240 0 0 {name=X_86321_ }
C {devices/lab_pin.sym} 25560 -14120 0 0 {name=p25351 lab=_52718_/A }
C {devices/lab_pin.sym} 25560 -14080 0 0 {name=p25352 lab=_52713_/B }
C {devices/lab_pin.sym} 25680 -14100 0 1 {name=p25353 lab=_52713_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -14100 0 0 {name=X_52713_ }
C {devices/lab_pin.sym} 25530 -13970 0 0 {name=p25354 lab=_86213_/CLK }
C {devices/lab_pin.sym} 25530 -13950 0 0 {name=p25355 lab=_83533_/D }
C {devices/lab_pin.sym} 25710 -13970 0 1 {name=p25356 lab=_83533_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -13960 0 0 {name=X_83533_ }
C {devices/lab_pin.sym} 25560 -13850 0 0 {name=p25357 lab=_56474_/X }
C {devices/lab_pin.sym} 25560 -13810 0 0 {name=p25358 lab=_56472_/B }
C {devices/lab_pin.sym} 25560 -13770 0 0 {name=p25359 lab=_55931_/B }
C {devices/lab_pin.sym} 25680 -13810 0 1 {name=p25360 lab=_56481_/Y }
C {sky130_stdcells/nand3_4.sym} 25620 -13810 0 0 {name=X_56481_ }
C {devices/lab_pin.sym} 25530 -13670 0 0 {name=p25361 lab=_80962_/CLK }
C {devices/lab_pin.sym} 25530 -13650 0 0 {name=p25362 lab=_75183_/X }
C {devices/lab_pin.sym} 25710 -13670 0 1 {name=p25363 lab=_81153_/D }
C {sky130_stdcells/dfxtp_4.sym} 25620 -13660 0 0 {name=X_80745_ }
C {devices/lab_pin.sym} 25580 -13530 0 0 {name=p25364 lab=_68384_/A }
C {devices/lab_pin.sym} 25660 -13530 0 1 {name=p25365 lab=_68467_/X }
C {sky130_stdcells/buf_2.sym} 25620 -13530 0 0 {name=X_68467_ }
C {devices/lab_pin.sym} 25540 -13430 0 0 {name=p25366 lab=_53690_/Y }
C {devices/lab_pin.sym} 25540 -13390 0 0 {name=p25367 lab=_53680_/X }
C {devices/lab_pin.sym} 25540 -13350 0 0 {name=p25368 lab=_53692_/X }
C {devices/lab_pin.sym} 25700 -13390 0 1 {name=p25369 lab=_85587_/D }
C {sky130_stdcells/a21oi_4.sym} 25620 -13390 0 0 {name=X_53693_ }
C {devices/lab_pin.sym} 25540 -13270 0 0 {name=p25370 lab=_65533_/X }
C {devices/lab_pin.sym} 25540 -13230 0 0 {name=p25371 lab=_65676_/Y }
C {devices/lab_pin.sym} 25540 -13190 0 0 {name=p25372 lab=_65678_/Y }
C {devices/lab_pin.sym} 25700 -13230 0 1 {name=p25373 lab=_65679_/Y }
C {sky130_stdcells/o21ai_4.sym} 25620 -13230 0 0 {name=X_65679_ }
C {devices/lab_pin.sym} 25580 -13090 0 0 {name=p25374 lab=_83400_/Q }
C {devices/lab_pin.sym} 25660 -13090 0 1 {name=p25375 lab=_58220_/Y }
C {sky130_stdcells/inv_2.sym} 25620 -13090 0 0 {name=X_58220_ }
C {devices/lab_pin.sym} 25540 -12990 0 0 {name=p25376 lab=_56777_/A }
C {devices/lab_pin.sym} 25540 -12950 0 0 {name=p25377 lab=_55405_/X }
C {devices/lab_pin.sym} 25540 -12910 0 0 {name=p25378 lab=_55411_/Y }
C {devices/lab_pin.sym} 25700 -12950 0 1 {name=p25379 lab=_55432_/Y }
C {sky130_stdcells/a21boi_4.sym} 25620 -12950 0 0 {name=X_55432_ }
C {devices/lab_pin.sym} 25540 -12840 0 0 {name=p25380 lab=_87408_/Q }
C {devices/lab_pin.sym} 25540 -12800 0 0 {name=p25381 lab=_67394_/X }
C {devices/lab_pin.sym} 25540 -12760 0 0 {name=p25382 lab=_67344_/X }
C {devices/lab_pin.sym} 25540 -12720 0 0 {name=p25383 lab=_67417_/X }
C {devices/lab_pin.sym} 25700 -12780 0 1 {name=p25384 lab=_67418_/X }
C {sky130_stdcells/a211o_4.sym} 25620 -12780 0 0 {name=X_67418_ }
C {devices/lab_pin.sym} 25530 -12630 0 0 {name=p25385 lab=_85554_/CLK }
C {devices/lab_pin.sym} 25530 -12610 0 0 {name=p25386 lab=_86252_/D }
C {devices/lab_pin.sym} 25710 -12630 0 1 {name=p25387 lab=_86252_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -12620 0 0 {name=X_86252_ }
C {devices/lab_pin.sym} 25540 -12510 0 0 {name=p25388 lab=_52642_/Y }
C {devices/lab_pin.sym} 25540 -12470 0 0 {name=p25389 lab=_52619_/X }
C {devices/lab_pin.sym} 25540 -12430 0 0 {name=p25390 lab=_52643_/X }
C {devices/lab_pin.sym} 25700 -12470 0 1 {name=p25391 lab=_85781_/D }
C {sky130_stdcells/a21oi_4.sym} 25620 -12470 0 0 {name=X_52644_ }
C {devices/lab_pin.sym} 25530 -12330 0 0 {name=p25392 lab=_83464_/CLK }
C {devices/lab_pin.sym} 25530 -12310 0 0 {name=p25393 lab=_83464_/D }
C {devices/lab_pin.sym} 25710 -12330 0 1 {name=p25394 lab=_83464_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -12320 0 0 {name=X_83464_ }
C {devices/lab_pin.sym} 25530 -12190 0 0 {name=p25395 lab=_80676_/CLK }
C {devices/lab_pin.sym} 25530 -12170 0 0 {name=p25396 lab=_80676_/D }
C {devices/lab_pin.sym} 25710 -12190 0 1 {name=p25397 lab=_80676_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -12180 0 0 {name=X_80676_ }
C {devices/lab_pin.sym} 25540 -12080 0 0 {name=p25398 lab=_87006_/Q }
C {devices/lab_pin.sym} 25540 -12040 0 0 {name=p25399 lab=_68394_/X }
C {devices/lab_pin.sym} 25540 -12000 0 0 {name=p25400 lab=_44246_/A }
C {devices/lab_pin.sym} 25540 -11960 0 0 {name=p25401 lab=_68397_/X }
C {devices/lab_pin.sym} 25700 -12020 0 1 {name=p25402 lab=_68398_/X }
C {sky130_stdcells/a211o_4.sym} 25620 -12020 0 0 {name=X_68398_ }
C {devices/lab_pin.sym} 25580 -11870 0 0 {name=p25403 lab=clkbuf_7_7_0_CLK/X }
C {devices/lab_pin.sym} 25660 -11870 0 1 {name=p25404 lab=clkbuf_9_29_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 25620 -11870 0 0 {name=Xclkbuf_8_14_0_CLK }
C {sky130_stdcells/decap_3.sym} 25620 -11720 0 0 {name=XPHY_504 }
C {devices/lab_pin.sym} 25530 -11570 0 0 {name=p25405 lab=_85168_/CLK }
C {devices/lab_pin.sym} 25530 -11550 0 0 {name=p25406 lab=_85203_/D }
C {devices/lab_pin.sym} 25710 -11570 0 1 {name=p25407 lab=_56414_/C }
C {sky130_stdcells/dfxtp_4.sym} 25620 -11560 0 0 {name=X_85203_ }
C {devices/lab_pin.sym} 25560 -11440 0 0 {name=p25408 lab=_58151_/A }
C {devices/lab_pin.sym} 25560 -11400 0 0 {name=p25409 lab=_58151_/B }
C {devices/lab_pin.sym} 25680 -11420 0 1 {name=p25410 lab=_58151_/Y }
C {sky130_stdcells/nor2_4.sym} 25620 -11420 0 0 {name=X_58151_ }
C {sky130_stdcells/decap_3.sym} 25620 -11260 0 0 {name=XPHY_515 }
C {devices/lab_pin.sym} 25530 -11110 0 0 {name=p25411 lab=_82828_/CLK }
C {devices/lab_pin.sym} 25530 -11090 0 0 {name=p25412 lab=_82447_/Q }
C {devices/lab_pin.sym} 25710 -11110 0 1 {name=p25413 lab=_78489_/A }
C {sky130_stdcells/dfxtp_4.sym} 25620 -11100 0 0 {name=X_82415_ }
C {devices/lab_pin.sym} 25560 -10990 0 0 {name=p25414 lab=_55329_/Y }
C {devices/lab_pin.sym} 25560 -10950 0 0 {name=p25415 lab=_55363_/B }
C {devices/lab_pin.sym} 25560 -10910 0 0 {name=p25416 lab=_55330_/X }
C {devices/lab_pin.sym} 25680 -10950 0 1 {name=p25417 lab=_56708_/C }
C {sky130_stdcells/nand3_4.sym} 25620 -10950 0 0 {name=X_55363_ }
C {devices/lab_pin.sym} 25560 -10820 0 0 {name=p25418 lab=_67324_/A }
C {devices/lab_pin.sym} 25560 -10780 0 0 {name=p25419 lab=_67349_/B }
C {devices/lab_pin.sym} 25680 -10800 0 1 {name=p25420 lab=_67349_/X }
C {sky130_stdcells/and2_4.sym} 25620 -10800 0 0 {name=X_67349_ }
C {devices/lab_pin.sym} 25530 -10670 0 0 {name=p25421 lab=_86505_/CLK }
C {devices/lab_pin.sym} 25530 -10650 0 0 {name=p25422 lab=_86183_/D }
C {devices/lab_pin.sym} 25710 -10670 0 1 {name=p25423 lab=_86183_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -10660 0 0 {name=X_86183_ }
C {sky130_stdcells/decap_3.sym} 25620 -10500 0 0 {name=XPHY_526 }
C {devices/lab_pin.sym} 25580 -10350 0 0 {name=p25424 lab=_52515_/X }
C {devices/lab_pin.sym} 25660 -10350 0 1 {name=p25425 lab=_52575_/X }
C {sky130_stdcells/buf_2.sym} 25620 -10350 0 0 {name=X_52575_ }
C {devices/lab_pin.sym} 25530 -10230 0 0 {name=p25426 lab=_83756_/CLK }
C {devices/lab_pin.sym} 25530 -10210 0 0 {name=p25427 lab=_71732_/Y }
C {devices/lab_pin.sym} 25710 -10230 0 1 {name=p25428 lab=_58240_/A }
C {sky130_stdcells/dfxtp_4.sym} 25620 -10220 0 0 {name=X_83395_ }
C {sky130_stdcells/decap_3.sym} 25620 -10060 0 0 {name=XPHY_537 }
C {sky130_stdcells/decap_3.sym} 25620 -9880 0 0 {name=XPHY_548 }
C {devices/lab_pin.sym} 25540 -9760 0 0 {name=p25429 lab=_57097_/X }
C {devices/lab_pin.sym} 25540 -9720 0 0 {name=p25430 lab=_56578_/X }
C {devices/lab_pin.sym} 25540 -9680 0 0 {name=p25431 lab=_85086_/Q }
C {devices/lab_pin.sym} 25540 -9640 0 0 {name=p25432 lab=_57099_/X }
C {devices/lab_pin.sym} 25700 -9700 0 1 {name=p25433 lab=_85086_/D }
C {sky130_stdcells/a2bb2o_4.sym} 25620 -9700 0 0 {name=X_57102_ }
C {devices/lab_pin.sym} 25560 -9560 0 0 {name=p25434 lab=_54314_/A }
C {devices/lab_pin.sym} 25560 -9520 0 0 {name=p25435 lab=_54314_/B }
C {devices/lab_pin.sym} 25680 -9540 0 1 {name=p25436 lab=_54314_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -9540 0 0 {name=X_54314_ }
C {sky130_stdcells/decap_3.sym} 25620 -9380 0 0 {name=XPHY_559 }
C {devices/lab_pin.sym} 25530 -9230 0 0 {name=p25437 lab=_85134_/CLK }
C {devices/lab_pin.sym} 25530 -9210 0 0 {name=p25438 lab=_56765_/Y }
C {devices/lab_pin.sym} 25710 -9230 0 1 {name=p25439 lab=_85134_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -9220 0 0 {name=X_85134_ }
C {devices/lab_pin.sym} 25580 -9090 0 0 {name=p25440 lab=_51552_/A }
C {devices/lab_pin.sym} 25660 -9090 0 1 {name=p25441 lab=_51533_/C }
C {sky130_stdcells/buf_2.sym} 25620 -9090 0 0 {name=X_51526_ }
C {devices/lab_pin.sym} 25560 -8980 0 0 {name=p25442 lab=_86630_/Q }
C {devices/lab_pin.sym} 25560 -8940 0 0 {name=p25443 lab=_58136_/B }
C {devices/lab_pin.sym} 25680 -8960 0 1 {name=p25444 lab=_58082_/Y }
C {sky130_stdcells/nor2_4.sym} 25620 -8960 0 0 {name=X_58082_ }
C {devices/lab_pin.sym} 25560 -8850 0 0 {name=p25445 lab=_70827_/C }
C {devices/lab_pin.sym} 25560 -8810 0 0 {name=p25446 lab=_70358_/X }
C {devices/lab_pin.sym} 25560 -8770 0 0 {name=p25447 lab=_70907_/B }
C {devices/lab_pin.sym} 25680 -8810 0 1 {name=p25448 lab=_70361_/A }
C {sky130_stdcells/nand3_4.sym} 25620 -8810 0 0 {name=X_70360_ }
C {devices/lab_pin.sym} 25530 -8670 0 0 {name=p25449 lab=_86753_/CLK }
C {devices/lab_pin.sym} 25530 -8650 0 0 {name=p25450 lab=_82346_/D }
C {devices/lab_pin.sym} 25710 -8670 0 1 {name=p25451 lab=_48077_/A }
C {sky130_stdcells/dfxtp_4.sym} 25620 -8660 0 0 {name=X_82346_ }
C {devices/lab_pin.sym} 25560 -8540 0 0 {name=p25452 lab=_55293_/X }
C {devices/lab_pin.sym} 25560 -8500 0 0 {name=p25453 lab=_55162_/Y }
C {devices/lab_pin.sym} 25680 -8520 0 1 {name=p25454 lab=_55417_/A }
C {sky130_stdcells/and2_4.sym} 25620 -8520 0 0 {name=X_55294_ }
C {devices/lab_pin.sym} 25540 -8430 0 0 {name=p25455 lab=_56787_/X }
C {devices/lab_pin.sym} 25540 -8390 0 0 {name=p25456 lab=_56994_/D }
C {devices/lab_pin.sym} 25540 -8350 0 0 {name=p25457 lab=_56732_/X }
C {devices/lab_pin.sym} 25540 -8310 0 0 {name=p25458 lab=_56788_/X }
C {devices/lab_pin.sym} 25540 -8280 0 0 {name=p25459 lab=_56821_/X }
C {devices/lab_pin.sym} 25700 -8350 0 1 {name=p25460 lab=_57034_/C }
C {sky130_stdcells/a41o_4.sym} 25620 -8350 0 0 {name=X_57033_ }
C {devices/lab_pin.sym} 25540 -8220 0 0 {name=p25461 lab=_68907_/X }
C {devices/lab_pin.sym} 25540 -8180 0 0 {name=p25462 lab=_68882_/X }
C {devices/lab_pin.sym} 25540 -8140 0 0 {name=p25463 lab=_69006_/Y }
C {devices/lab_pin.sym} 25540 -8100 0 0 {name=p25464 lab=_69018_/Y }
C {devices/lab_pin.sym} 25700 -8160 0 1 {name=p25465 lab=_69019_/X }
C {sky130_stdcells/a211o_4.sym} 25620 -8160 0 0 {name=X_69019_ }
C {devices/lab_pin.sym} 25580 -8010 0 0 {name=p25466 lab=_54245_/A }
C {devices/lab_pin.sym} 25660 -8010 0 1 {name=p25467 lab=_54329_/A }
C {sky130_stdcells/buf_2.sym} 25620 -8010 0 0 {name=X_54245_ }
C {devices/lab_pin.sym} 25530 -7890 0 0 {name=p25468 lab=_84998_/CLK }
C {devices/lab_pin.sym} 25530 -7870 0 0 {name=p25469 lab=_57195_/Y }
C {devices/lab_pin.sym} 25710 -7890 0 1 {name=p25470 lab=_85065_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -7880 0 0 {name=X_85065_ }
C {devices/lab_pin.sym} 25540 -7770 0 0 {name=p25471 lab=_51455_/Y }
C {devices/lab_pin.sym} 25540 -7730 0 0 {name=p25472 lab=_51448_/X }
C {devices/lab_pin.sym} 25540 -7690 0 0 {name=p25473 lab=_51456_/X }
C {devices/lab_pin.sym} 25700 -7730 0 1 {name=p25474 lab=_51457_/Y }
C {sky130_stdcells/a21oi_4.sym} 25620 -7730 0 0 {name=X_51457_ }
C {devices/lab_pin.sym} 25540 -7610 0 0 {name=p25475 lab=_70289_/X }
C {devices/lab_pin.sym} 25540 -7570 0 0 {name=p25476 lab=_74809_/A }
C {devices/lab_pin.sym} 25540 -7530 0 0 {name=p25477 lab=_70290_/X }
C {devices/lab_pin.sym} 25700 -7570 0 1 {name=p25478 lab=_83809_/D }
C {sky130_stdcells/a21o_4.sym} 25620 -7570 0 0 {name=X_70291_ }
C {devices/lab_pin.sym} 25580 -7430 0 0 {name=p25479 lab=clkbuf_8_29_0_CLK/A }
C {devices/lab_pin.sym} 25660 -7430 0 1 {name=p25480 lab=clkbuf_9_59_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 25620 -7430 0 0 {name=Xclkbuf_8_29_0_CLK }
C {devices/lab_pin.sym} 25530 -7310 0 0 {name=p25481 lab=_82339_/CLK }
C {devices/lab_pin.sym} 25530 -7290 0 0 {name=p25482 lab=_82277_/D }
C {devices/lab_pin.sym} 25710 -7310 0 1 {name=p25483 lab=_40912_/B }
C {sky130_stdcells/dfxtp_4.sym} 25620 -7300 0 0 {name=X_82277_ }
C {devices/lab_pin.sym} 25540 -7210 0 0 {name=p25484 lab=_41205_/X }
C {devices/lab_pin.sym} 25540 -7170 0 0 {name=p25485 lab=_41206_/X }
C {devices/lab_pin.sym} 25540 -7130 0 0 {name=p25486 lab=_41209_/X }
C {devices/lab_pin.sym} 25540 -7090 0 0 {name=p25487 lab=_68820_/B }
C {devices/lab_pin.sym} 25540 -7050 0 0 {name=p25488 lab=_41194_/X }
C {devices/lab_pin.sym} 25700 -7130 0 1 {name=p25489 lab=_41210_/Y }
C {sky130_stdcells/o32ai_4.sym} 25620 -7130 0 0 {name=X_41210_ }
C {devices/lab_pin.sym} 25540 -6990 0 0 {name=p25490 lab=_72028_/Y }
C {devices/lab_pin.sym} 25540 -6950 0 0 {name=p25491 lab=_72009_/X }
C {devices/lab_pin.sym} 25540 -6910 0 0 {name=p25492 lab=_72029_/Y }
C {devices/lab_pin.sym} 25700 -6950 0 1 {name=p25493 lab=_83299_/D }
C {sky130_stdcells/a21boi_4.sym} 25620 -6950 0 0 {name=X_72030_ }
C {devices/lab_pin.sym} 25530 -6810 0 0 {name=p25494 lab=_84014_/CLK }
C {devices/lab_pin.sym} 25530 -6790 0 0 {name=p25495 lab=_84016_/D }
C {devices/lab_pin.sym} 25710 -6810 0 1 {name=p25496 lab=_84016_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -6800 0 0 {name=X_84016_ }
C {devices/lab_pin.sym} 25560 -6690 0 0 {name=p25497 lab=_48388_/A }
C {devices/lab_pin.sym} 25560 -6650 0 0 {name=p25498 lab=_50430_/B }
C {devices/lab_pin.sym} 25560 -6610 0 0 {name=p25499 lab=_50435_/C }
C {devices/lab_pin.sym} 25680 -6650 0 1 {name=p25500 lab=_50408_/X }
C {sky130_stdcells/and3_4.sym} 25620 -6650 0 0 {name=X_50408_ }
C {devices/lab_pin.sym} 25530 -6510 0 0 {name=p25501 lab=_81227_/CLK }
C {devices/lab_pin.sym} 25530 -6490 0 0 {name=p25502 lab=_81036_/Q }
C {devices/lab_pin.sym} 25710 -6510 0 1 {name=p25503 lab=_81228_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -6500 0 0 {name=X_81228_ }
C {devices/lab_pin.sym} 25580 -6370 0 0 {name=p25504 lab=clkbuf_3_0_1_CLK/A }
C {devices/lab_pin.sym} 25660 -6370 0 1 {name=p25505 lab=clkbuf_3_0_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 25620 -6370 0 0 {name=Xclkbuf_3_0_1_CLK }
C {devices/lab_pin.sym} 25540 -6280 0 0 {name=p25506 lab=_41282_/X }
C {devices/lab_pin.sym} 25540 -6240 0 0 {name=p25507 lab=_42183_/X }
C {devices/lab_pin.sym} 25540 -6200 0 0 {name=p25508 lab=_87988_/Q }
C {devices/lab_pin.sym} 25540 -6160 0 0 {name=p25509 lab=_42184_/X }
C {devices/lab_pin.sym} 25700 -6220 0 1 {name=p25510 lab=_87988_/D }
C {sky130_stdcells/a2bb2o_4.sym} 25620 -6220 0 0 {name=X_42190_ }
C {devices/lab_pin.sym} 25540 -6090 0 0 {name=p25511 lab=_85490_/Q }
C {devices/lab_pin.sym} 25540 -6050 0 0 {name=p25512 lab=_54167_/X }
C {devices/lab_pin.sym} 25540 -6010 0 0 {name=p25513 lab=_54175_/Y }
C {devices/lab_pin.sym} 25700 -6050 0 1 {name=p25514 lab=_54176_/Y }
C {sky130_stdcells/o21ai_4.sym} 25620 -6050 0 0 {name=X_54176_ }
C {devices/lab_pin.sym} 25580 -5910 0 0 {name=p25515 lab=_51790_/A }
C {devices/lab_pin.sym} 25660 -5910 0 1 {name=p25516 lab=_51758_/A }
C {sky130_stdcells/buf_2.sym} 25620 -5910 0 0 {name=X_51388_ }
C {devices/lab_pin.sym} 25580 -5790 0 0 {name=p25517 lab=_41141_/A }
C {devices/lab_pin.sym} 25660 -5790 0 1 {name=p25518 lab=_41141_/Y }
C {sky130_stdcells/inv_2.sym} 25620 -5790 0 0 {name=X_41141_ }
C {devices/lab_pin.sym} 25560 -5680 0 0 {name=p25519 lab=_53121_/X }
C {devices/lab_pin.sym} 25560 -5640 0 0 {name=p25520 lab=_53127_/B }
C {devices/lab_pin.sym} 25680 -5660 0 1 {name=p25521 lab=_53127_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -5660 0 0 {name=X_53127_ }
C {devices/lab_pin.sym} 25560 -5550 0 0 {name=p25522 lab=_52039_/A }
C {devices/lab_pin.sym} 25560 -5510 0 0 {name=p25523 lab=_50331_/B }
C {devices/lab_pin.sym} 25560 -5470 0 0 {name=p25524 lab=_50338_/X }
C {devices/lab_pin.sym} 25680 -5510 0 1 {name=p25525 lab=_50339_/X }
C {sky130_stdcells/and3_4.sym} 25620 -5510 0 0 {name=X_50339_ }
C {devices/lab_pin.sym} 25530 -5370 0 0 {name=p25526 lab=_81160_/CLK }
C {devices/lab_pin.sym} 25530 -5350 0 0 {name=p25527 lab=_74879_/B }
C {devices/lab_pin.sym} 25710 -5370 0 1 {name=p25528 lab=_81159_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -5360 0 0 {name=X_81159_ }
C {devices/lab_pin.sym} 25580 -5230 0 0 {name=p25529 lab=_58984_/A }
C {devices/lab_pin.sym} 25660 -5230 0 1 {name=p25530 lab=_58988_/B }
C {sky130_stdcells/buf_2.sym} 25620 -5230 0 0 {name=X_58984_ }
C {devices/lab_pin.sym} 25560 -5140 0 0 {name=p25531 lab=_53074_/A }
C {devices/lab_pin.sym} 25560 -5100 0 0 {name=p25532 lab=_53063_/B }
C {devices/lab_pin.sym} 25560 -5060 0 0 {name=p25533 lab=_53058_/C }
C {devices/lab_pin.sym} 25560 -5020 0 0 {name=p25534 lab=_53058_/D }
C {devices/lab_pin.sym} 25680 -5080 0 1 {name=p25535 lab=_53058_/X }
C {sky130_stdcells/and4_4.sym} 25620 -5080 0 0 {name=X_53058_ }
C {devices/lab_pin.sym} 25560 -4940 0 0 {name=p25536 lab=_86642_/Q }
C {devices/lab_pin.sym} 25560 -4900 0 0 {name=p25537 lab=_57845_/X }
C {devices/lab_pin.sym} 25680 -4920 0 1 {name=p25538 lab=_57935_/Y }
C {sky130_stdcells/nor2_4.sym} 25620 -4920 0 0 {name=X_57935_ }
C {devices/lab_pin.sym} 25580 -4790 0 0 {name=p25539 lab=_47825_/A }
C {devices/lab_pin.sym} 25660 -4790 0 1 {name=p25540 lab=_41072_/X }
C {sky130_stdcells/buf_2.sym} 25620 -4790 0 0 {name=X_41072_ }
C {devices/lab_pin.sym} 25560 -4690 0 0 {name=p25541 lab=_73979_/X }
C {devices/lab_pin.sym} 25560 -4650 0 0 {name=p25542 lab=_73967_/X }
C {devices/lab_pin.sym} 25560 -4610 0 0 {name=p25543 lab=_73981_/C }
C {devices/lab_pin.sym} 25680 -4650 0 1 {name=p25544 lab=_73981_/Y }
C {sky130_stdcells/nand3_4.sym} 25620 -4650 0 0 {name=X_73981_ }
C {devices/lab_pin.sym} 25530 -4510 0 0 {name=p25545 lab=_85679_/CLK }
C {devices/lab_pin.sym} 25530 -4490 0 0 {name=p25546 lab=_85967_/D }
C {devices/lab_pin.sym} 25710 -4510 0 1 {name=p25547 lab=_85967_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -4500 0 0 {name=X_85967_ }
C {devices/lab_pin.sym} 25560 -4380 0 0 {name=p25548 lab=_51947_/A }
C {devices/lab_pin.sym} 25560 -4340 0 0 {name=p25549 lab=_50306_/B }
C {devices/lab_pin.sym} 25680 -4360 0 1 {name=p25550 lab=_52009_/Y }
C {sky130_stdcells/nand2_4.sym} 25620 -4360 0 0 {name=X_52009_ }
C {devices/lab_pin.sym} 25580 -4230 0 0 {name=p25551 lab=_44904_/A }
C {devices/lab_pin.sym} 25660 -4230 0 1 {name=p25552 lab=_45819_/A }
C {sky130_stdcells/buf_2.sym} 25620 -4230 0 0 {name=X_44900_ }
C {devices/lab_pin.sym} 25540 -4140 0 0 {name=p25553 lab=_75708_/A }
C {devices/lab_pin.sym} 25540 -4100 0 0 {name=p25554 lab=_75707_/Y }
C {devices/lab_pin.sym} 25540 -4060 0 0 {name=p25555 lab=_75694_/A }
C {devices/lab_pin.sym} 25540 -4020 0 0 {name=p25556 lab=_75719_/Y }
C {devices/lab_pin.sym} 25700 -4080 0 1 {name=p25557 lab=_75720_/X }
C {sky130_stdcells/a2bb2o_4.sym} 25620 -4080 0 0 {name=X_75720_ }
C {devices/lab_pin.sym} 25530 -3930 0 0 {name=p25558 lab=_87446_/CLK }
C {devices/lab_pin.sym} 25530 -3910 0 0 {name=p25559 lab=_87706_/D }
C {devices/lab_pin.sym} 25710 -3930 0 1 {name=p25560 lab=_87706_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -3920 0 0 {name=X_87706_ }
C {devices/lab_pin.sym} 25560 -3800 0 0 {name=p25561 lab=_73093_/A }
C {devices/lab_pin.sym} 25560 -3760 0 0 {name=p25562 lab=_65521_/B }
C {devices/lab_pin.sym} 25680 -3780 0 1 {name=p25563 lab=_72932_/X }
C {sky130_stdcells/and2_4.sym} 25620 -3780 0 0 {name=X_72932_ }
C {devices/lab_pin.sym} 25530 -3650 0 0 {name=p25564 lab=_84905_/CLK }
C {devices/lab_pin.sym} 25530 -3630 0 0 {name=p25565 lab=_58161_/X }
C {devices/lab_pin.sym} 25710 -3650 0 1 {name=p25566 lab=_84918_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -3640 0 0 {name=X_84918_ }
C {devices/lab_pin.sym} 25540 -3530 0 0 {name=p25567 lab=_45873_/X }
C {devices/lab_pin.sym} 25540 -3490 0 0 {name=p25568 lab=_45877_/Y }
C {devices/lab_pin.sym} 25540 -3450 0 0 {name=p25569 lab=_45879_/Y }
C {devices/lab_pin.sym} 25700 -3490 0 1 {name=p25570 lab=_45880_/Y }
C {sky130_stdcells/a21oi_4.sym} 25620 -3490 0 0 {name=X_45880_ }
C {devices/lab_pin.sym} 25580 -3350 0 0 {name=p25571 lab=_57866_/A }
C {devices/lab_pin.sym} 25660 -3350 0 1 {name=p25572 lab=_58827_/A }
C {sky130_stdcells/buf_2.sym} 25620 -3350 0 0 {name=X_57866_ }
C {devices/lab_pin.sym} 25530 -3230 0 0 {name=p25573 lab=_84970_/CLK }
C {devices/lab_pin.sym} 25530 -3210 0 0 {name=p25574 lab=_85898_/D }
C {devices/lab_pin.sym} 25710 -3230 0 1 {name=p25575 lab=_74104_/B }
C {sky130_stdcells/dfxtp_4.sym} 25620 -3220 0 0 {name=X_85898_ }
C {devices/lab_pin.sym} 25580 -3090 0 0 {name=p25576 lab=_59604_/X }
C {devices/lab_pin.sym} 25660 -3090 0 1 {name=p25577 lab=_59605_/Y }
C {sky130_stdcells/inv_2.sym} 25620 -3090 0 0 {name=X_59605_ }
C {devices/lab_pin.sym} 25540 -3000 0 0 {name=p25578 lab=_41700_/Y }
C {devices/lab_pin.sym} 25540 -2960 0 0 {name=p25579 lab=_44817_/X }
C {devices/lab_pin.sym} 25540 -2920 0 0 {name=p25580 lab=_67654_/B }
C {devices/lab_pin.sym} 25540 -2880 0 0 {name=p25581 lab=_44818_/X }
C {devices/lab_pin.sym} 25700 -2940 0 1 {name=p25582 lab=_44831_/X }
C {sky130_stdcells/a2bb2o_4.sym} 25620 -2940 0 0 {name=X_44831_ }
C {devices/lab_pin.sym} 25560 -2800 0 0 {name=p25583 lab=_56816_/Y }
C {devices/lab_pin.sym} 25560 -2760 0 0 {name=p25584 lab=_56713_/A }
C {devices/lab_pin.sym} 25680 -2780 0 1 {name=p25585 lab=_56817_/X }
C {sky130_stdcells/xor2_4.sym} 25620 -2780 0 0 {name=X_56817_ }
C {devices/lab_pin.sym} 25560 -2660 0 0 {name=p25586 lab=_75649_/Y }
C {devices/lab_pin.sym} 25560 -2620 0 0 {name=p25587 lab=_75650_/Y }
C {devices/lab_pin.sym} 25680 -2640 0 1 {name=p25588 lab=_75659_/B }
C {sky130_stdcells/xor2_4.sym} 25620 -2640 0 0 {name=X_75651_ }
C {devices/lab_pin.sym} 25530 -2510 0 0 {name=p25589 lab=_87636_/CLK }
C {devices/lab_pin.sym} 25530 -2490 0 0 {name=p25590 lab=_87637_/D }
C {devices/lab_pin.sym} 25710 -2510 0 1 {name=p25591 lab=_68051_/B }
C {sky130_stdcells/dfxtp_4.sym} 25620 -2500 0 0 {name=X_87637_ }
C {devices/lab_pin.sym} 25540 -2390 0 0 {name=p25592 lab=_72856_/X }
C {devices/lab_pin.sym} 25540 -2350 0 0 {name=p25593 lab=_72860_/X }
C {devices/lab_pin.sym} 25540 -2310 0 0 {name=p25594 lab=_72862_/X }
C {devices/lab_pin.sym} 25700 -2350 0 1 {name=p25595 lab=_72869_/A }
C {sky130_stdcells/a21o_4.sym} 25620 -2350 0 0 {name=X_72863_ }
C {devices/lab_pin.sym} 25530 -2210 0 0 {name=p25596 lab=_84849_/CLK }
C {devices/lab_pin.sym} 25530 -2190 0 0 {name=p25597 lab=_84849_/D }
C {devices/lab_pin.sym} 25710 -2210 0 1 {name=p25598 lab=_84849_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -2200 0 0 {name=X_84849_ }
C {devices/lab_pin.sym} 25540 -2100 0 0 {name=p25599 lab=_57753_/Y }
C {devices/lab_pin.sym} 25540 -2060 0 0 {name=p25600 lab=_57758_/X }
C {devices/lab_pin.sym} 25540 -2020 0 0 {name=p25601 lab=_57780_/X }
C {devices/lab_pin.sym} 25540 -1980 0 0 {name=p25602 lab=_57796_/X }
C {devices/lab_pin.sym} 25700 -2040 0 1 {name=p25603 lab=_84949_/D }
C {sky130_stdcells/a22oi_4.sym} 25620 -2040 0 0 {name=X_57797_ }
C {devices/lab_pin.sym} 25540 -1910 0 0 {name=p25604 lab=_45232_/A }
C {devices/lab_pin.sym} 25540 -1870 0 0 {name=p25605 lab=_74598_/X }
C {devices/lab_pin.sym} 25540 -1830 0 0 {name=p25606 lab=_74601_/X }
C {devices/lab_pin.sym} 25700 -1870 0 1 {name=p25607 lab=_74602_/Y }
C {sky130_stdcells/o21ai_4.sym} 25620 -1870 0 0 {name=X_74602_ }
C {devices/lab_pin.sym} 25540 -1750 0 0 {name=p25608 lab=_47546_/Y }
C {devices/lab_pin.sym} 25540 -1710 0 0 {name=p25609 lab=_47509_/X }
C {devices/lab_pin.sym} 25540 -1670 0 0 {name=p25610 lab=_47549_/X }
C {devices/lab_pin.sym} 25700 -1710 0 1 {name=p25611 lab=_47550_/Y }
C {sky130_stdcells/a21oi_4.sym} 25620 -1710 0 0 {name=X_47550_ }
C {devices/lab_pin.sym} 25540 -1590 0 0 {name=p25612 lab=_71805_/X }
C {devices/lab_pin.sym} 25540 -1550 0 0 {name=p25613 lab=_83366_/Q }
C {devices/lab_pin.sym} 25540 -1510 0 0 {name=p25614 lab=_71813_/X }
C {devices/lab_pin.sym} 25700 -1550 0 1 {name=p25615 lab=_83366_/D }
C {sky130_stdcells/a21o_4.sym} 25620 -1550 0 0 {name=X_71814_ }
C {devices/lab_pin.sym} 25560 -1440 0 0 {name=p25616 lab=_59536_/A }
C {devices/lab_pin.sym} 25560 -1400 0 0 {name=p25617 lab=_60175_/A }
C {devices/lab_pin.sym} 25560 -1360 0 0 {name=p25618 lab=_59716_/B }
C {devices/lab_pin.sym} 25560 -1320 0 0 {name=p25619 lab=_61285_/C }
C {devices/lab_pin.sym} 25680 -1380 0 1 {name=p25620 lab=_59537_/A }
C {sky130_stdcells/nand4_4.sym} 25620 -1380 0 0 {name=X_59536_ }
C {devices/lab_pin.sym} 25560 -1240 0 0 {name=p25621 lab=_78370_/A }
C {devices/lab_pin.sym} 25560 -1200 0 0 {name=p25622 lab=_82758_/D }
C {devices/lab_pin.sym} 25680 -1220 0 1 {name=p25623 lab=_82470_/D }
C {sky130_stdcells/xor2_4.sym} 25620 -1220 0 0 {name=X_78370_ }
C {devices/lab_pin.sym} 25580 -1090 0 0 {name=p25624 lab=_44762_/A }
C {devices/lab_pin.sym} 25660 -1090 0 1 {name=p25625 lab=_44762_/Y }
C {sky130_stdcells/inv_2.sym} 25620 -1090 0 0 {name=X_44762_ }
C {devices/lab_pin.sym} 25580 -970 0 0 {name=p25626 lab=_56721_/Y }
C {devices/lab_pin.sym} 25660 -970 0 1 {name=p25627 lab=_56750_/B }
C {sky130_stdcells/inv_2.sym} 25620 -970 0 0 {name=X_56748_ }
C {devices/lab_pin.sym} 25540 -870 0 0 {name=p25628 lab=_75888_/A }
C {devices/lab_pin.sym} 25540 -830 0 0 {name=p25629 lab=_75580_/Y }
C {devices/lab_pin.sym} 25540 -790 0 0 {name=p25630 lab=_75584_/C }
C {devices/lab_pin.sym} 25700 -830 0 1 {name=p25631 lab=_75583_/A }
C {sky130_stdcells/a21oi_4.sym} 25620 -830 0 0 {name=X_75582_ }
C {devices/lab_pin.sym} 25530 -690 0 0 {name=p25632 lab=_86534_/CLK }
C {devices/lab_pin.sym} 25530 -670 0 0 {name=p25633 lab=_43120_/Y }
C {devices/lab_pin.sym} 25710 -690 0 1 {name=p25634 lab=_87568_/Q }
C {sky130_stdcells/dfxtp_4.sym} 25620 -680 0 0 {name=X_87568_ }
C {devices/lab_pin.sym} 26460 -42190 0 0 {name=p25635 lab=_41965_/X }
C {devices/lab_pin.sym} 26460 -42150 0 0 {name=p25636 lab=_41956_/X }
C {devices/lab_pin.sym} 26460 -42110 0 0 {name=p25637 lab=_40749_/X }
C {devices/lab_pin.sym} 26460 -42070 0 0 {name=p25638 lab=_41973_/Y }
C {devices/lab_pin.sym} 26460 -42030 0 0 {name=p25639 lab=_41967_/X }
C {devices/lab_pin.sym} 26620 -42110 0 1 {name=p25640 lab=_41974_/Y }
C {sky130_stdcells/o32ai_4.sym} 26540 -42110 0 0 {name=X_41974_ }
C {devices/lab_pin.sym} 26500 -41950 0 0 {name=p25641 lab=_72943_/A }
C {devices/lab_pin.sym} 26580 -41950 0 1 {name=p25642 lab=_72794_/X }
C {sky130_stdcells/buf_2.sym} 26540 -41950 0 0 {name=X_72794_ }
C {devices/lab_pin.sym} 26500 -41830 0 0 {name=p25643 lab=_46500_/Y }
C {devices/lab_pin.sym} 26580 -41830 0 1 {name=p25644 lab=_51350_/B }
C {sky130_stdcells/buf_2.sym} 26540 -41830 0 0 {name=X_46501_ }
C {devices/lab_pin.sym} 26480 -41720 0 0 {name=p25645 lab=_77317_/X }
C {devices/lab_pin.sym} 26480 -41680 0 0 {name=p25646 lab=_77320_/Y }
C {devices/lab_pin.sym} 26600 -41700 0 1 {name=p25647 lab=_82184_/D }
C {sky130_stdcells/xor2_4.sym} 26540 -41700 0 0 {name=X_77321_ }
C {devices/lab_pin.sym} 26500 -41570 0 0 {name=p25648 lab=_43713_/A }
C {devices/lab_pin.sym} 26580 -41570 0 1 {name=p25649 lab=_69793_/B }
C {sky130_stdcells/inv_2.sym} 26540 -41570 0 0 {name=X_43713_ }
C {devices/lab_pin.sym} 26480 -41480 0 0 {name=p25650 lab=_74533_/A }
C {devices/lab_pin.sym} 26480 -41440 0 0 {name=p25651 lab=_74531_/B }
C {devices/lab_pin.sym} 26480 -41400 0 0 {name=p25652 lab=_74531_/C }
C {devices/lab_pin.sym} 26480 -41360 0 0 {name=p25653 lab=_74533_/D }
C {devices/lab_pin.sym} 26600 -41420 0 1 {name=p25654 lab=_74533_/Y }
C {sky130_stdcells/nand4_4.sym} 26540 -41420 0 0 {name=X_74533_ }
C {devices/lab_pin.sym} 26450 -41270 0 0 {name=p25655 lab=_86516_/CLK }
C {devices/lab_pin.sym} 26450 -41250 0 0 {name=p25656 lab=_48477_/Y }
C {devices/lab_pin.sym} 26630 -41270 0 1 {name=p25657 lab=_65584_/B }
C {sky130_stdcells/dfxtp_4.sym} 26540 -41260 0 0 {name=X_86519_ }
C {devices/lab_pin.sym} 26500 -41130 0 0 {name=p25658 lab=_40924_/Y }
C {devices/lab_pin.sym} 26580 -41130 0 1 {name=p25659 lab=_40925_/X }
C {sky130_stdcells/buf_2.sym} 26540 -41130 0 0 {name=X_40925_ }
C {devices/lab_pin.sym} 26500 -41010 0 0 {name=p25660 lab=_47481_/A }
C {devices/lab_pin.sym} 26580 -41010 0 1 {name=p25661 lab=_53072_/B }
C {sky130_stdcells/buf_2.sym} 26540 -41010 0 0 {name=X_47481_ }
C {devices/lab_pin.sym} 26460 -40910 0 0 {name=p25662 lab=_52931_/B }
C {devices/lab_pin.sym} 26460 -40870 0 0 {name=p25663 lab=_71737_/X }
C {devices/lab_pin.sym} 26460 -40830 0 0 {name=p25664 lab=_71744_/Y }
C {devices/lab_pin.sym} 26620 -40870 0 1 {name=p25665 lab=_83392_/D }
C {sky130_stdcells/o21ai_4.sym} 26540 -40870 0 0 {name=X_71745_ }
C {devices/lab_pin.sym} 26500 -40730 0 0 {name=p25666 lab=_84724_/Q }
C {devices/lab_pin.sym} 26580 -40730 0 1 {name=p25667 lab=_59467_/Y }
C {sky130_stdcells/inv_2.sym} 26540 -40730 0 0 {name=X_59467_ }
C {devices/lab_pin.sym} 26460 -40650 0 0 {name=p25668 lab=_44679_/X }
C {devices/lab_pin.sym} 26460 -40610 0 0 {name=p25669 lab=_44680_/X }
C {devices/lab_pin.sym} 26460 -40570 0 0 {name=p25670 lab=_40641_/X }
C {devices/lab_pin.sym} 26460 -40530 0 0 {name=p25671 lab=_86998_/Q }
C {devices/lab_pin.sym} 26460 -40490 0 0 {name=p25672 lab=_44681_/X }
C {devices/lab_pin.sym} 26620 -40570 0 1 {name=p25673 lab=_44694_/A }
C {sky130_stdcells/o32ai_4.sym} 26540 -40570 0 0 {name=X_44693_ }
C {devices/lab_pin.sym} 26480 -40440 0 0 {name=p25674 lab=_56674_/X }
C {devices/lab_pin.sym} 26480 -40400 0 0 {name=p25675 lab=_56679_/B }
C {devices/lab_pin.sym} 26480 -40360 0 0 {name=p25676 lab=_57140_/B }
C {devices/lab_pin.sym} 26480 -40320 0 0 {name=p25677 lab=_83336_/Q }
C {devices/lab_pin.sym} 26600 -40380 0 1 {name=p25678 lab=_56680_/A }
C {sky130_stdcells/and4_4.sym} 26540 -40380 0 0 {name=X_56679_ }
C {devices/lab_pin.sym} 26450 -40230 0 0 {name=p25679 lab=_87757_/CLK }
C {devices/lab_pin.sym} 26450 -40210 0 0 {name=p25680 lab=_87499_/D }
C {devices/lab_pin.sym} 26630 -40230 0 1 {name=p25681 lab=_87499_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -40220 0 0 {name=X_87499_ }
C {devices/lab_pin.sym} 26480 -40100 0 0 {name=p25682 lab=_49220_/A }
C {devices/lab_pin.sym} 26480 -40060 0 0 {name=p25683 lab=_53953_/B }
C {devices/lab_pin.sym} 26600 -40080 0 1 {name=p25684 lab=_49220_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -40080 0 0 {name=X_49220_ }
C {devices/lab_pin.sym} 26500 -39950 0 0 {name=p25685 lab=_83641_/Q }
C {devices/lab_pin.sym} 26580 -39950 0 1 {name=p25686 lab=_46433_/A }
C {sky130_stdcells/inv_2.sym} 26540 -39950 0 0 {name=X_46432_ }
C {devices/lab_pin.sym} 26480 -39840 0 0 {name=p25687 lab=_58418_/A }
C {devices/lab_pin.sym} 26480 -39800 0 0 {name=p25688 lab=_58415_/B }
C {devices/lab_pin.sym} 26600 -39820 0 1 {name=p25689 lab=_58418_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -39820 0 0 {name=X_58418_ }
C {devices/lab_pin.sym} 26480 -39710 0 0 {name=p25690 lab=_77252_/A }
C {devices/lab_pin.sym} 26480 -39670 0 0 {name=p25691 lab=_77254_/A }
C {devices/lab_pin.sym} 26480 -39630 0 0 {name=p25692 lab=_77253_/A }
C {devices/lab_pin.sym} 26600 -39670 0 1 {name=p25693 lab=_77252_/Y }
C {sky130_stdcells/nand3_4.sym} 26540 -39670 0 0 {name=X_77252_ }
C {devices/lab_pin.sym} 26500 -39530 0 0 {name=p25694 lab=_87329_/Q }
C {devices/lab_pin.sym} 26580 -39530 0 1 {name=p25695 lab=_43644_/Y }
C {sky130_stdcells/inv_2.sym} 26540 -39530 0 0 {name=X_43644_ }
C {devices/lab_pin.sym} 26480 -39430 0 0 {name=p25696 lab=_48589_/A }
C {devices/lab_pin.sym} 26480 -39390 0 0 {name=p25697 lab=_74478_/B }
C {devices/lab_pin.sym} 26480 -39350 0 0 {name=p25698 lab=_74478_/C }
C {devices/lab_pin.sym} 26600 -39390 0 1 {name=p25699 lab=_74464_/X }
C {sky130_stdcells/and3_4.sym} 26540 -39390 0 0 {name=X_74464_ }
C {devices/lab_pin.sym} 26500 -39250 0 0 {name=p25700 lab=_40855_/Y }
C {devices/lab_pin.sym} 26580 -39250 0 1 {name=p25701 lab=_88322_/D }
C {sky130_stdcells/inv_2.sym} 26540 -39250 0 0 {name=X_40856_ }
C {devices/lab_pin.sym} 26480 -39150 0 0 {name=p25702 lab=_71680_/A }
C {devices/lab_pin.sym} 26480 -39110 0 0 {name=p25703 lab=_71671_/X }
C {devices/lab_pin.sym} 26480 -39070 0 0 {name=p25704 lab=_70472_/X }
C {devices/lab_pin.sym} 26600 -39110 0 1 {name=p25705 lab=_71676_/Y }
C {sky130_stdcells/nand3_4.sym} 26540 -39110 0 0 {name=X_71676_ }
C {devices/lab_pin.sym} 26500 -38970 0 0 {name=p25706 lab=_59398_/A }
C {devices/lab_pin.sym} 26580 -38970 0 1 {name=p25707 lab=_59399_/B }
C {sky130_stdcells/buf_2.sym} 26540 -38970 0 0 {name=X_59398_ }
C {devices/lab_pin.sym} 26480 -38870 0 0 {name=p25708 lab=_76200_/X }
C {devices/lab_pin.sym} 26480 -38830 0 0 {name=p25709 lab=_81638_/Q }
C {devices/lab_pin.sym} 26480 -38790 0 0 {name=p25710 lab=_76201_/Y }
C {devices/lab_pin.sym} 26600 -38830 0 1 {name=p25711 lab=_76219_/A }
C {sky130_stdcells/nand3_4.sym} 26540 -38830 0 0 {name=X_76203_ }
C {devices/lab_pin.sym} 26480 -38700 0 0 {name=p25712 lab=_49080_/A }
C {devices/lab_pin.sym} 26480 -38660 0 0 {name=p25713 lab=_50183_/B }
C {devices/lab_pin.sym} 26600 -38680 0 1 {name=p25714 lab=_49151_/X }
C {sky130_stdcells/and2_4.sym} 26540 -38680 0 0 {name=X_49151_ }
C {devices/lab_pin.sym} 26480 -38560 0 0 {name=p25715 lab=_73415_/A }
C {devices/lab_pin.sym} 26480 -38520 0 0 {name=p25716 lab=_73053_/B }
C {devices/lab_pin.sym} 26600 -38540 0 1 {name=p25717 lab=_73415_/Y }
C {sky130_stdcells/nor2_4.sym} 26540 -38540 0 0 {name=X_73415_ }
C {devices/lab_pin.sym} 26460 -38430 0 0 {name=p25718 lab=_46358_/Y }
C {devices/lab_pin.sym} 26460 -38390 0 0 {name=p25719 lab=_46346_/X }
C {devices/lab_pin.sym} 26460 -38350 0 0 {name=p25720 lab=_46362_/Y }
C {devices/lab_pin.sym} 26620 -38390 0 1 {name=p25721 lab=_86744_/D }
C {sky130_stdcells/a21boi_4.sym} 26540 -38390 0 0 {name=X_46363_ }
C {devices/lab_pin.sym} 26500 -38250 0 0 {name=p25722 lab=_70627_/A }
C {devices/lab_pin.sym} 26580 -38250 0 1 {name=p25723 lab=_71115_/D }
C {sky130_stdcells/buf_2.sym} 26540 -38250 0 0 {name=X_70627_ }
C {devices/lab_pin.sym} 26460 -38150 0 0 {name=p25724 lab=_58328_/X }
C {devices/lab_pin.sym} 26460 -38110 0 0 {name=p25725 lab=_83768_/Q }
C {devices/lab_pin.sym} 26460 -38070 0 0 {name=p25726 lab=_58348_/Y }
C {devices/lab_pin.sym} 26620 -38110 0 1 {name=p25727 lab=_58349_/X }
C {sky130_stdcells/o21a_4.sym} 26540 -38110 0 0 {name=X_58349_ }
C {devices/lab_pin.sym} 26480 -37980 0 0 {name=p25728 lab=_82012_/Q }
C {devices/lab_pin.sym} 26480 -37940 0 0 {name=p25729 lab=_82300_/D }
C {devices/lab_pin.sym} 26600 -37960 0 1 {name=p25730 lab=_77202_/A }
C {sky130_stdcells/xor2_4.sym} 26540 -37960 0 0 {name=X_77183_ }
C {devices/lab_pin.sym} 26460 -37860 0 0 {name=p25731 lab=_40528_/X }
C {devices/lab_pin.sym} 26460 -37820 0 0 {name=p25732 lab=_53455_/A }
C {devices/lab_pin.sym} 26460 -37780 0 0 {name=p25733 lab=_87352_/Q }
C {devices/lab_pin.sym} 26460 -37740 0 0 {name=p25734 lab=_43185_/A }
C {devices/lab_pin.sym} 26620 -37800 0 1 {name=p25735 lab=_87352_/D }
C {sky130_stdcells/a2bb2o_4.sym} 26540 -37800 0 0 {name=X_43575_ }
C {devices/lab_pin.sym} 26500 -37650 0 0 {name=p25736 lab=_74453_/A }
C {devices/lab_pin.sym} 26580 -37650 0 1 {name=p25737 lab=_74395_/X }
C {sky130_stdcells/buf_2.sym} 26540 -37650 0 0 {name=X_74395_ }
C {devices/lab_pin.sym} 26500 -37530 0 0 {name=p25738 lab=_40787_/A }
C {devices/lab_pin.sym} 26580 -37530 0 1 {name=p25739 lab=_40787_/X }
C {sky130_stdcells/buf_2.sym} 26540 -37530 0 0 {name=X_40787_ }
C {devices/lab_pin.sym} 26500 -37410 0 0 {name=p25740 lab=_47838_/X }
C {devices/lab_pin.sym} 26580 -37410 0 1 {name=p25741 lab=_48781_/A }
C {sky130_stdcells/buf_2.sym} 26540 -37410 0 0 {name=X_48102_ }
C {devices/lab_pin.sym} 26460 -37310 0 0 {name=p25742 lab=_56536_/C }
C {devices/lab_pin.sym} 26460 -37270 0 0 {name=p25743 lab=_45284_/X }
C {devices/lab_pin.sym} 26460 -37230 0 0 {name=p25744 lab=_45265_/X }
C {devices/lab_pin.sym} 26620 -37270 0 1 {name=p25745 lab=_45314_/X }
C {sky130_stdcells/o21a_4.sym} 26540 -37270 0 0 {name=X_45314_ }
C {devices/lab_pin.sym} 26460 -37150 0 0 {name=p25746 lab=_76129_/B }
C {devices/lab_pin.sym} 26460 -37110 0 0 {name=p25747 lab=_76132_/X }
C {devices/lab_pin.sym} 26460 -37070 0 0 {name=p25748 lab=_76133_/Y }
C {devices/lab_pin.sym} 26620 -37110 0 1 {name=p25749 lab=_76134_/Y }
C {sky130_stdcells/a21boi_4.sym} 26540 -37110 0 0 {name=X_76134_ }
C {devices/lab_pin.sym} 26460 -37010 0 0 {name=p25750 lab=_42517_/X }
C {devices/lab_pin.sym} 26460 -36970 0 0 {name=p25751 lab=_42501_/X }
C {devices/lab_pin.sym} 26460 -36930 0 0 {name=p25752 lab=_40729_/X }
C {devices/lab_pin.sym} 26460 -36890 0 0 {name=p25753 lab=_42525_/Y }
C {devices/lab_pin.sym} 26460 -36850 0 0 {name=p25754 lab=_42519_/X }
C {devices/lab_pin.sym} 26620 -36930 0 1 {name=p25755 lab=_87834_/D }
C {sky130_stdcells/o32ai_4.sym} 26540 -36930 0 0 {name=X_42526_ }
C {devices/lab_pin.sym} 26500 -36770 0 0 {name=p25756 lab=_49082_/A }
C {devices/lab_pin.sym} 26580 -36770 0 1 {name=p25757 lab=_49083_/A }
C {sky130_stdcells/inv_2.sym} 26540 -36770 0 0 {name=X_49082_ }
C {devices/lab_pin.sym} 26500 -36650 0 0 {name=p25758 lab=_61359_/Y }
C {devices/lab_pin.sym} 26580 -36650 0 1 {name=p25759 lab=_61360_/Y }
C {sky130_stdcells/inv_2.sym} 26540 -36650 0 0 {name=X_61360_ }
C {devices/lab_pin.sym} 26460 -36560 0 0 {name=p25760 lab=_42041_/Y }
C {devices/lab_pin.sym} 26460 -36520 0 0 {name=p25761 lab=_73298_/X }
C {devices/lab_pin.sym} 26460 -36480 0 0 {name=p25762 lab=_73344_/X }
C {devices/lab_pin.sym} 26460 -36440 0 0 {name=p25763 lab=_73345_/Y }
C {devices/lab_pin.sym} 26620 -36500 0 1 {name=p25764 lab=_73346_/X }
C {sky130_stdcells/a211o_4.sym} 26540 -36500 0 0 {name=X_73346_ }
C {devices/lab_pin.sym} 26500 -36350 0 0 {name=p25765 lab=_46294_/A }
C {devices/lab_pin.sym} 26580 -36350 0 1 {name=p25766 lab=_46295_/A }
C {sky130_stdcells/inv_2.sym} 26540 -36350 0 0 {name=X_46294_ }
C {devices/lab_pin.sym} 26500 -36230 0 0 {name=p25767 lab=_71883_/A }
C {devices/lab_pin.sym} 26580 -36230 0 1 {name=p25768 lab=_70558_/X }
C {sky130_stdcells/buf_2.sym} 26540 -36230 0 0 {name=X_70558_ }
C {devices/lab_pin.sym} 26500 -36110 0 0 {name=p25769 lab=clkbuf_9_186_0_CLK/X }
C {devices/lab_pin.sym} 26580 -36110 0 1 {name=p25770 lab=_85751_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 26540 -36110 0 0 {name=Xclkbuf_10_373_0_CLK }
C {devices/lab_pin.sym} 26460 -36010 0 0 {name=p25771 lab=_66183_/B }
C {devices/lab_pin.sym} 26460 -35970 0 0 {name=p25772 lab=_47998_/X }
C {devices/lab_pin.sym} 26460 -35930 0 0 {name=p25773 lab=_48032_/Y }
C {devices/lab_pin.sym} 26620 -35970 0 1 {name=p25774 lab=_48033_/Y }
C {sky130_stdcells/o21ai_4.sym} 26540 -35970 0 0 {name=X_48033_ }
C {devices/lab_pin.sym} 26460 -35860 0 0 {name=p25775 lab=_79755_/A }
C {devices/lab_pin.sym} 26460 -35820 0 0 {name=p25776 lab=_59822_/X }
C {devices/lab_pin.sym} 26460 -35780 0 0 {name=p25777 lab=_60300_/Y }
C {devices/lab_pin.sym} 26460 -35740 0 0 {name=p25778 lab=_60310_/X }
C {devices/lab_pin.sym} 26620 -35800 0 1 {name=p25779 lab=_84637_/D }
C {sky130_stdcells/o22a_4.sym} 26540 -35800 0 0 {name=X_60311_ }
C {devices/lab_pin.sym} 26480 -35660 0 0 {name=p25780 lab=_45244_/Y }
C {devices/lab_pin.sym} 26480 -35620 0 0 {name=p25781 lab=_45199_/B }
C {devices/lab_pin.sym} 26600 -35640 0 1 {name=p25782 lab=_45245_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -35640 0 0 {name=X_45245_ }
C {devices/lab_pin.sym} 26480 -35530 0 0 {name=p25783 lab=_76063_/B }
C {devices/lab_pin.sym} 26480 -35490 0 0 {name=p25784 lab=_81716_/D }
C {devices/lab_pin.sym} 26480 -35450 0 0 {name=p25785 lab=_76058_/B }
C {devices/lab_pin.sym} 26600 -35490 0 1 {name=p25786 lab=_76065_/Y }
C {sky130_stdcells/nand3_4.sym} 26540 -35490 0 0 {name=X_76065_ }
C {devices/lab_pin.sym} 26500 -35350 0 0 {name=p25787 lab=_42456_/Y }
C {devices/lab_pin.sym} 26580 -35350 0 1 {name=p25788 lab=_87858_/D }
C {sky130_stdcells/inv_2.sym} 26540 -35350 0 0 {name=X_42457_ }
C {devices/lab_pin.sym} 26500 -35230 0 0 {name=p25789 lab=_61290_/X }
C {devices/lab_pin.sym} 26580 -35230 0 1 {name=p25790 lab=_61292_/A }
C {sky130_stdcells/buf_2.sym} 26540 -35230 0 0 {name=X_61291_ }
C {devices/lab_pin.sym} 26460 -35130 0 0 {name=p25791 lab=_73274_/X }
C {devices/lab_pin.sym} 26460 -35090 0 0 {name=p25792 lab=_73276_/X }
C {devices/lab_pin.sym} 26460 -35050 0 0 {name=p25793 lab=_73200_/X }
C {devices/lab_pin.sym} 26620 -35090 0 1 {name=p25794 lab=_73277_/X }
C {sky130_stdcells/a21o_4.sym} 26540 -35090 0 0 {name=X_73277_ }
C {devices/lab_pin.sym} 26480 -34970 0 0 {name=p25795 lab=_71323_/A }
C {devices/lab_pin.sym} 26480 -34930 0 0 {name=p25796 lab=_71500_/C }
C {devices/lab_pin.sym} 26480 -34890 0 0 {name=p25797 lab=_71779_/B }
C {devices/lab_pin.sym} 26600 -34930 0 1 {name=p25798 lab=_70489_/Y }
C {sky130_stdcells/nand3_4.sym} 26540 -34930 0 0 {name=X_70489_ }
C {devices/lab_pin.sym} 26480 -34820 0 0 {name=p25799 lab=_60476_/A }
C {devices/lab_pin.sym} 26480 -34780 0 0 {name=p25800 lab=_63030_/B }
C {devices/lab_pin.sym} 26480 -34740 0 0 {name=p25801 lab=_63030_/C }
C {devices/lab_pin.sym} 26480 -34700 0 0 {name=p25802 lab=_60541_/C }
C {devices/lab_pin.sym} 26600 -34760 0 1 {name=p25803 lab=_63030_/X }
C {sky130_stdcells/and4_4.sym} 26540 -34760 0 0 {name=X_63030_ }
C {devices/lab_pin.sym} 26480 -34620 0 0 {name=p25804 lab=_81146_/D }
C {devices/lab_pin.sym} 26480 -34580 0 0 {name=p25805 lab=_75016_/B }
C {devices/lab_pin.sym} 26600 -34600 0 1 {name=p25806 lab=_75016_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -34600 0 0 {name=X_75016_ }
C {devices/lab_pin.sym} 26500 -34470 0 0 {name=p25807 lab=_41407_/X }
C {devices/lab_pin.sym} 26580 -34470 0 1 {name=p25808 lab=_41408_/X }
C {sky130_stdcells/buf_2.sym} 26540 -34470 0 0 {name=X_41408_ }
C {devices/lab_pin.sym} 26500 -34350 0 0 {name=p25809 lab=_59085_/A }
C {devices/lab_pin.sym} 26580 -34350 0 1 {name=p25810 lab=_72228_/X }
C {sky130_stdcells/buf_2.sym} 26540 -34350 0 0 {name=X_72228_ }
C {devices/lab_pin.sym} 26500 -34230 0 0 {name=p25811 lab=_60036_/A }
C {devices/lab_pin.sym} 26580 -34230 0 1 {name=p25812 lab=_60525_/A }
C {sky130_stdcells/buf_2.sym} 26540 -34230 0 0 {name=X_60242_ }
C {devices/lab_pin.sym} 26500 -34110 0 0 {name=p25813 lab=_45252_/A }
C {devices/lab_pin.sym} 26580 -34110 0 1 {name=p25814 lab=_45176_/X }
C {sky130_stdcells/buf_2.sym} 26540 -34110 0 0 {name=X_45176_ }
C {devices/lab_pin.sym} 26500 -33990 0 0 {name=p25815 lab=_42373_/X }
C {devices/lab_pin.sym} 26580 -33990 0 1 {name=p25816 lab=_42388_/X }
C {sky130_stdcells/buf_2.sym} 26540 -33990 0 0 {name=X_42388_ }
C {devices/lab_pin.sym} 26500 -33870 0 0 {name=p25817 lab=clkbuf_9_495_0_CLK/A }
C {devices/lab_pin.sym} 26580 -33870 0 1 {name=p25818 lab=clkbuf_9_494_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 26540 -33870 0 0 {name=Xclkbuf_9_494_0_CLK }
C {devices/lab_pin.sym} 26500 -33750 0 0 {name=p25819 lab=_44126_/X }
C {devices/lab_pin.sym} 26580 -33750 0 1 {name=p25820 lab=_44127_/X }
C {sky130_stdcells/buf_2.sym} 26540 -33750 0 0 {name=X_44127_ }
C {devices/lab_pin.sym} 26460 -33650 0 0 {name=p25821 lab=_79816_/X }
C {devices/lab_pin.sym} 26460 -33610 0 0 {name=p25822 lab=_79817_/X }
C {devices/lab_pin.sym} 26460 -33570 0 0 {name=p25823 lab=_79823_/Y }
C {devices/lab_pin.sym} 26620 -33610 0 1 {name=p25824 lab=_79840_/A }
C {sky130_stdcells/a21boi_4.sym} 26540 -33610 0 0 {name=X_79824_ }
C {devices/lab_pin.sym} 26480 -33480 0 0 {name=p25825 lab=_41686_/B }
C {devices/lab_pin.sym} 26480 -33440 0 0 {name=p25826 lab=_41275_/B }
C {devices/lab_pin.sym} 26600 -33460 0 1 {name=p25827 lab=_41339_/X }
C {sky130_stdcells/or2_4.sym} 26540 -33460 0 0 {name=X_41339_ }
C {devices/lab_pin.sym} 26500 -33330 0 0 {name=p25828 lab=_60406_/B }
C {devices/lab_pin.sym} 26580 -33330 0 1 {name=p25829 lab=_72625_/A }
C {sky130_stdcells/buf_2.sym} 26540 -33330 0 0 {name=X_60173_ }
C {devices/lab_pin.sym} 26460 -33230 0 0 {name=p25830 lab=_72154_/Y }
C {devices/lab_pin.sym} 26460 -33190 0 0 {name=p25831 lab=_72158_/Y }
C {devices/lab_pin.sym} 26460 -33150 0 0 {name=p25832 lab=_59297_/X }
C {devices/lab_pin.sym} 26620 -33190 0 1 {name=p25833 lab=_72159_/X }
C {sky130_stdcells/a21o_4.sym} 26540 -33190 0 0 {name=X_72159_ }
C {devices/lab_pin.sym} 26480 -33080 0 0 {name=p25834 lab=_49995_/A }
C {devices/lab_pin.sym} 26480 -33040 0 0 {name=p25835 lab=_49973_/B }
C {devices/lab_pin.sym} 26480 -33000 0 0 {name=p25836 lab=_50005_/C }
C {devices/lab_pin.sym} 26480 -32960 0 0 {name=p25837 lab=_53196_/D }
C {devices/lab_pin.sym} 26600 -33020 0 1 {name=p25838 lab=_49984_/X }
C {sky130_stdcells/and4_4.sym} 26540 -33020 0 0 {name=X_49984_ }
C {devices/lab_pin.sym} 26500 -32870 0 0 {name=p25839 lab=clkbuf_9_194_0_CLK/X }
C {devices/lab_pin.sym} 26580 -32870 0 1 {name=p25840 lab=_84350_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 26540 -32870 0 0 {name=Xclkbuf_10_388_0_CLK }
C {devices/lab_pin.sym} 26500 -32750 0 0 {name=p25841 lab=_48985_/A }
C {devices/lab_pin.sym} 26580 -32750 0 1 {name=p25842 lab=_48935_/X }
C {sky130_stdcells/buf_2.sym} 26540 -32750 0 0 {name=X_48935_ }
C {devices/lab_pin.sym} 26500 -32630 0 0 {name=p25843 lab=_44058_/A }
C {devices/lab_pin.sym} 26580 -32630 0 1 {name=p25844 lab=_44059_/A }
C {sky130_stdcells/buf_2.sym} 26540 -32630 0 0 {name=X_44058_ }
C {devices/lab_pin.sym} 26480 -32520 0 0 {name=p25845 lab=_79755_/A }
C {devices/lab_pin.sym} 26480 -32480 0 0 {name=p25846 lab=_79755_/B }
C {devices/lab_pin.sym} 26600 -32500 0 1 {name=p25847 lab=_79761_/B }
C {sky130_stdcells/xor2_4.sym} 26540 -32500 0 0 {name=X_79755_ }
C {devices/lab_pin.sym} 26480 -32380 0 0 {name=p25848 lab=_65319_/A }
C {devices/lab_pin.sym} 26480 -32340 0 0 {name=p25849 lab=_86419_/Q }
C {devices/lab_pin.sym} 26600 -32360 0 1 {name=p25850 lab=_64981_/X }
C {sky130_stdcells/and2_4.sym} 26540 -32360 0 0 {name=X_64981_ }
C {devices/lab_pin.sym} 26480 -32240 0 0 {name=p25851 lab=_81684_/Q }
C {devices/lab_pin.sym} 26480 -32200 0 0 {name=p25852 lab=_76967_/B }
C {devices/lab_pin.sym} 26600 -32220 0 1 {name=p25853 lab=_76967_/Y }
C {sky130_stdcells/xnor2_4.sym} 26540 -32220 0 0 {name=X_76967_ }
C {devices/lab_pin.sym} 26460 -32120 0 0 {name=p25854 lab=_40538_/X }
C {devices/lab_pin.sym} 26460 -32080 0 0 {name=p25855 lab=_51934_/A }
C {devices/lab_pin.sym} 26460 -32040 0 0 {name=p25856 lab=_67259_/B }
C {devices/lab_pin.sym} 26460 -32000 0 0 {name=p25857 lab=_42634_/A }
C {devices/lab_pin.sym} 26620 -32060 0 1 {name=p25858 lab=_87606_/D }
C {sky130_stdcells/a2bb2o_4.sym} 26540 -32060 0 0 {name=X_43009_ }
C {devices/lab_pin.sym} 26480 -31920 0 0 {name=p25859 lab=_78700_/Y }
C {devices/lab_pin.sym} 26480 -31880 0 0 {name=p25860 lab=_78706_/B }
C {devices/lab_pin.sym} 26600 -31900 0 1 {name=p25861 lab=_82780_/D }
C {sky130_stdcells/xor2_4.sym} 26540 -31900 0 0 {name=X_78706_ }
C {devices/lab_pin.sym} 26480 -31780 0 0 {name=p25862 lab=_66720_/A }
C {devices/lab_pin.sym} 26480 -31740 0 0 {name=p25863 lab=_66719_/X }
C {devices/lab_pin.sym} 26600 -31760 0 1 {name=p25864 lab=_66720_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -31760 0 0 {name=X_66720_ }
C {devices/lab_pin.sym} 26500 -31630 0 0 {name=p25865 lab=_63749_/A }
C {devices/lab_pin.sym} 26580 -31630 0 1 {name=p25866 lab=_63947_/B }
C {sky130_stdcells/buf_2.sym} 26540 -31630 0 0 {name=X_63932_ }
C {devices/lab_pin.sym} 26480 -31520 0 0 {name=p25867 lab=_61165_/C }
C {devices/lab_pin.sym} 26480 -31480 0 0 {name=p25868 lab=_75918_/B }
C {devices/lab_pin.sym} 26600 -31500 0 1 {name=p25869 lab=_75918_/X }
C {sky130_stdcells/xor2_4.sym} 26540 -31500 0 0 {name=X_75918_ }
C {devices/lab_pin.sym} 26480 -31390 0 0 {name=p25870 lab=_48691_/A }
C {devices/lab_pin.sym} 26480 -31350 0 0 {name=p25871 lab=_48859_/B }
C {devices/lab_pin.sym} 26480 -31310 0 0 {name=p25872 lab=_48854_/C }
C {devices/lab_pin.sym} 26600 -31350 0 1 {name=p25873 lab=_48866_/X }
C {sky130_stdcells/and3_4.sym} 26540 -31350 0 0 {name=X_48866_ }
C {devices/lab_pin.sym} 26460 -31230 0 0 {name=p25874 lab=_79683_/Y }
C {devices/lab_pin.sym} 26460 -31190 0 0 {name=p25875 lab=_79666_/Y }
C {devices/lab_pin.sym} 26460 -31150 0 0 {name=p25876 lab=_79685_/X }
C {devices/lab_pin.sym} 26620 -31190 0 1 {name=p25877 lab=_79686_/Y }
C {sky130_stdcells/o21ai_4.sym} 26540 -31190 0 0 {name=X_79686_ }
C {devices/lab_pin.sym} 26500 -31050 0 0 {name=p25878 lab=_76897_/Y }
C {devices/lab_pin.sym} 26580 -31050 0 1 {name=p25879 lab=_76899_/B }
C {sky130_stdcells/inv_2.sym} 26540 -31050 0 0 {name=X_76898_ }
C {devices/lab_pin.sym} 26500 -30930 0 0 {name=p25880 lab=clkbuf_9_155_0_CLK/X }
C {devices/lab_pin.sym} 26580 -30930 0 1 {name=p25881 lab=_85489_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 26540 -30930 0 0 {name=Xclkbuf_10_311_0_CLK }
C {devices/lab_pin.sym} 26500 -30810 0 0 {name=p25882 lab=_47817_/A }
C {devices/lab_pin.sym} 26580 -30810 0 1 {name=p25883 lab=_47818_/A }
C {sky130_stdcells/inv_2.sym} 26540 -30810 0 0 {name=X_47817_ }
C {devices/lab_pin.sym} 26480 -30700 0 0 {name=p25884 lab=_66651_/A }
C {devices/lab_pin.sym} 26480 -30660 0 0 {name=p25885 lab=_66651_/B }
C {devices/lab_pin.sym} 26600 -30680 0 1 {name=p25886 lab=_66651_/X }
C {sky130_stdcells/and2_4.sym} 26540 -30680 0 0 {name=X_66651_ }
C {devices/lab_pin.sym} 26480 -30570 0 0 {name=p25887 lab=_78632_/X }
C {devices/lab_pin.sym} 26480 -30530 0 0 {name=p25888 lab=_78637_/B }
C {devices/lab_pin.sym} 26480 -30490 0 0 {name=p25889 lab=_78637_/C }
C {devices/lab_pin.sym} 26600 -30530 0 1 {name=p25890 lab=_78638_/B }
C {sky130_stdcells/nand3_4.sym} 26540 -30530 0 0 {name=X_78637_ }
C {devices/lab_pin.sym} 26460 -30430 0 0 {name=p25891 lab=_63859_/X }
C {devices/lab_pin.sym} 26460 -30390 0 0 {name=p25892 lab=_63810_/X }
C {devices/lab_pin.sym} 26460 -30350 0 0 {name=p25893 lab=_63860_/Y }
C {devices/lab_pin.sym} 26460 -30310 0 0 {name=p25894 lab=_63861_/Y }
C {devices/lab_pin.sym} 26460 -30280 0 0 {name=p25895 lab=_63862_/X }
C {devices/lab_pin.sym} 26620 -30350 0 1 {name=p25896 lab=_63863_/X }
C {sky130_stdcells/a41o_4.sym} 26540 -30350 0 0 {name=X_63863_ }
C {devices/lab_pin.sym} 26480 -30200 0 0 {name=p25897 lab=_75846_/A }
C {devices/lab_pin.sym} 26480 -30160 0 0 {name=p25898 lab=_81023_/Q }
C {devices/lab_pin.sym} 26600 -30180 0 1 {name=p25899 lab=_75849_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -30180 0 0 {name=X_75849_ }
C {devices/lab_pin.sym} 26480 -30070 0 0 {name=p25900 lab=_52182_/A }
C {devices/lab_pin.sym} 26480 -30030 0 0 {name=p25901 lab=_48829_/B }
C {devices/lab_pin.sym} 26480 -29990 0 0 {name=p25902 lab=_48814_/C }
C {devices/lab_pin.sym} 26600 -30030 0 1 {name=p25903 lab=_48797_/X }
C {sky130_stdcells/and3_4.sym} 26540 -30030 0 0 {name=X_48797_ }
C {devices/lab_pin.sym} 26500 -29890 0 0 {name=p25904 lab=clkbuf_9_470_0_CLK/X }
C {devices/lab_pin.sym} 26580 -29890 0 1 {name=p25905 lab=_87542_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 26540 -29890 0 0 {name=Xclkbuf_10_941_0_CLK }
C {devices/lab_pin.sym} 26500 -29770 0 0 {name=p25906 lab=_65529_/A }
C {devices/lab_pin.sym} 26580 -29770 0 1 {name=p25907 lab=_65602_/X }
C {sky130_stdcells/buf_2.sym} 26540 -29770 0 0 {name=X_65602_ }
C {devices/lab_pin.sym} 26480 -29680 0 0 {name=p25908 lab=_62789_/A }
C {devices/lab_pin.sym} 26480 -29640 0 0 {name=p25909 lab=_63161_/A }
C {devices/lab_pin.sym} 26480 -29600 0 0 {name=p25910 lab=_62848_/C }
C {devices/lab_pin.sym} 26480 -29560 0 0 {name=p25911 lab=_62789_/D }
C {devices/lab_pin.sym} 26600 -29620 0 1 {name=p25912 lab=_62814_/X }
C {sky130_stdcells/and4_4.sym} 26540 -29620 0 0 {name=X_62814_ }
C {devices/lab_pin.sym} 26460 -29500 0 0 {name=p25913 lab=_88034_/Q }
C {devices/lab_pin.sym} 26460 -29460 0 0 {name=p25914 lab=_69368_/X }
C {devices/lab_pin.sym} 26460 -29420 0 0 {name=p25915 lab=_69232_/X }
C {devices/lab_pin.sym} 26460 -29380 0 0 {name=p25916 lab=_69369_/X }
C {devices/lab_pin.sym} 26620 -29440 0 1 {name=p25917 lab=_69370_/X }
C {sky130_stdcells/a211o_4.sym} 26540 -29440 0 0 {name=X_69370_ }
C {devices/lab_pin.sym} 26500 -29290 0 0 {name=p25918 lab=_55083_/D }
C {devices/lab_pin.sym} 26580 -29290 0 1 {name=p25919 lab=_53223_/D }
C {sky130_stdcells/buf_2.sym} 26540 -29290 0 0 {name=X_47748_ }
C {devices/lab_pin.sym} 26500 -29170 0 0 {name=p25920 lab=_68474_/A }
C {devices/lab_pin.sym} 26580 -29170 0 1 {name=p25921 lab=_66683_/A }
C {sky130_stdcells/buf_2.sym} 26540 -29170 0 0 {name=X_66582_ }
C {devices/lab_pin.sym} 26500 -29050 0 0 {name=p25922 lab=_78568_/A }
C {devices/lab_pin.sym} 26580 -29050 0 1 {name=p25923 lab=_78569_/C }
C {sky130_stdcells/inv_2.sym} 26540 -29050 0 0 {name=X_78568_ }
C {devices/lab_pin.sym} 26480 -28960 0 0 {name=p25924 lab=_63787_/Y }
C {devices/lab_pin.sym} 26480 -28920 0 0 {name=p25925 lab=_63789_/Y }
C {devices/lab_pin.sym} 26480 -28880 0 0 {name=p25926 lab=_63791_/Y }
C {devices/lab_pin.sym} 26480 -28840 0 0 {name=p25927 lab=_63794_/D }
C {devices/lab_pin.sym} 26600 -28900 0 1 {name=p25928 lab=_63794_/X }
C {sky130_stdcells/and4_4.sym} 26540 -28900 0 0 {name=X_63794_ }
C {devices/lab_pin.sym} 26500 -28750 0 0 {name=p25929 lab=clkbuf_8_216_0_CLK/X }
C {devices/lab_pin.sym} 26580 -28750 0 1 {name=p25930 lab=clkbuf_9_432_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 26540 -28750 0 0 {name=Xclkbuf_9_432_0_CLK }
C {devices/lab_pin.sym} 26460 -28660 0 0 {name=p25931 lab=_68319_/X }
C {devices/lab_pin.sym} 26460 -28620 0 0 {name=p25932 lab=_67961_/Y }
C {devices/lab_pin.sym} 26460 -28580 0 0 {name=p25933 lab=_68308_/X }
C {devices/lab_pin.sym} 26460 -28540 0 0 {name=p25934 lab=_68320_/Y }
C {devices/lab_pin.sym} 26620 -28600 0 1 {name=p25935 lab=_68321_/X }
C {sky130_stdcells/a211o_4.sym} 26540 -28600 0 0 {name=X_68321_ }
C {devices/lab_pin.sym} 26500 -28450 0 0 {name=p25936 lab=_65198_/A }
C {devices/lab_pin.sym} 26580 -28450 0 1 {name=p25937 lab=_65533_/X }
C {sky130_stdcells/buf_2.sym} 26540 -28450 0 0 {name=X_65533_ }
C {devices/lab_pin.sym} 26480 -28340 0 0 {name=p25938 lab=_77519_/A }
C {devices/lab_pin.sym} 26480 -28300 0 0 {name=p25939 lab=_77518_/X }
C {devices/lab_pin.sym} 26600 -28320 0 1 {name=p25940 lab=_77520_/B }
C {sky130_stdcells/xor2_4.sym} 26540 -28320 0 0 {name=X_77519_ }
C {devices/lab_pin.sym} 26480 -28220 0 0 {name=p25941 lab=_62731_/A }
C {devices/lab_pin.sym} 26480 -28180 0 0 {name=p25942 lab=_58177_/Y }
C {devices/lab_pin.sym} 26480 -28140 0 0 {name=p25943 lab=_62744_/X }
C {devices/lab_pin.sym} 26480 -28100 0 0 {name=p25944 lab=_62717_/X }
C {devices/lab_pin.sym} 26600 -28160 0 1 {name=p25945 lab=_62745_/X }
C {sky130_stdcells/and4_4.sym} 26540 -28160 0 0 {name=X_62745_ }
C {devices/lab_pin.sym} 26500 -28010 0 0 {name=p25946 lab=_47679_/A }
C {devices/lab_pin.sym} 26580 -28010 0 1 {name=p25947 lab=_53183_/B }
C {sky130_stdcells/buf_2.sym} 26540 -28010 0 0 {name=X_47679_ }
C {devices/lab_pin.sym} 26480 -27900 0 0 {name=p25948 lab=_78499_/A }
C {devices/lab_pin.sym} 26480 -27860 0 0 {name=p25949 lab=_78498_/Y }
C {devices/lab_pin.sym} 26600 -27880 0 1 {name=p25950 lab=_82767_/D }
C {sky130_stdcells/xor2_4.sym} 26540 -27880 0 0 {name=X_78499_ }
C {devices/lab_pin.sym} 26500 -27750 0 0 {name=p25951 lab=clkbuf_9_163_0_CLK/X }
C {devices/lab_pin.sym} 26580 -27750 0 1 {name=p25952 lab=_86340_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 26540 -27750 0 0 {name=Xclkbuf_10_326_0_CLK }
C {devices/lab_pin.sym} 26480 -27640 0 0 {name=p25953 lab=_49418_/A }
C {devices/lab_pin.sym} 26480 -27600 0 0 {name=p25954 lab=_51800_/B }
C {devices/lab_pin.sym} 26600 -27620 0 1 {name=p25955 lab=_49418_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -27620 0 0 {name=X_49418_ }
C {devices/lab_pin.sym} 26480 -27500 0 0 {name=p25956 lab=_80530_/A }
C {devices/lab_pin.sym} 26480 -27460 0 0 {name=p25957 lab=_80513_/A }
C {devices/lab_pin.sym} 26600 -27480 0 1 {name=p25958 lab=_80530_/X }
C {sky130_stdcells/and2_4.sym} 26540 -27480 0 0 {name=X_80530_ }
C {devices/lab_pin.sym} 26460 -27380 0 0 {name=p25959 lab=_68246_/X }
C {devices/lab_pin.sym} 26460 -27340 0 0 {name=p25960 lab=_67555_/Y }
C {devices/lab_pin.sym} 26460 -27300 0 0 {name=p25961 lab=_68247_/X }
C {devices/lab_pin.sym} 26460 -27260 0 0 {name=p25962 lab=_68251_/Y }
C {devices/lab_pin.sym} 26620 -27320 0 1 {name=p25963 lab=_68252_/X }
C {sky130_stdcells/a211o_4.sym} 26540 -27320 0 0 {name=X_68252_ }
C {devices/lab_pin.sym} 26500 -27170 0 0 {name=p25964 lab=_65464_/A }
C {devices/lab_pin.sym} 26580 -27170 0 1 {name=p25965 lab=_65929_/A }
C {sky130_stdcells/buf_2.sym} 26540 -27170 0 0 {name=X_65464_ }
C {devices/lab_pin.sym} 26500 -27050 0 0 {name=p25966 lab=clkbuf_9_478_0_CLK/X }
C {devices/lab_pin.sym} 26580 -27050 0 1 {name=p25967 lab=_86534_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 26540 -27050 0 0 {name=Xclkbuf_10_956_0_CLK }
C {devices/lab_pin.sym} 26480 -26940 0 0 {name=p25968 lab=_50682_/A }
C {devices/lab_pin.sym} 26480 -26900 0 0 {name=p25969 lab=_49135_/X }
C {devices/lab_pin.sym} 26600 -26920 0 1 {name=p25970 lab=_50690_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -26920 0 0 {name=X_50690_ }
C {devices/lab_pin.sym} 26480 -26820 0 0 {name=p25971 lab=_62658_/A }
C {devices/lab_pin.sym} 26480 -26780 0 0 {name=p25972 lab=_64236_/C }
C {devices/lab_pin.sym} 26480 -26740 0 0 {name=p25973 lab=_62676_/C }
C {devices/lab_pin.sym} 26480 -26700 0 0 {name=p25974 lab=_62657_/X }
C {devices/lab_pin.sym} 26600 -26760 0 1 {name=p25975 lab=_62676_/X }
C {sky130_stdcells/and4_4.sym} 26540 -26760 0 0 {name=X_62676_ }
C {devices/lab_pin.sym} 26500 -26610 0 0 {name=p25976 lab=_68389_/A }
C {devices/lab_pin.sym} 26580 -26610 0 1 {name=p25977 lab=_67203_/X }
C {sky130_stdcells/buf_2.sym} 26540 -26610 0 0 {name=X_67203_ }
C {devices/lab_pin.sym} 26460 -26530 0 0 {name=p25978 lab=_64410_/Y }
C {devices/lab_pin.sym} 26460 -26490 0 0 {name=p25979 lab=_64411_/X }
C {devices/lab_pin.sym} 26460 -26450 0 0 {name=p25980 lab=_64412_/X }
C {devices/lab_pin.sym} 26460 -26410 0 0 {name=p25981 lab=_64414_/Y }
C {devices/lab_pin.sym} 26460 -26370 0 0 {name=p25982 lab=_64384_/X }
C {devices/lab_pin.sym} 26620 -26450 0 1 {name=p25983 lab=_64415_/X }
C {sky130_stdcells/o41a_4.sym} 26540 -26450 0 0 {name=X_64415_ }
C {devices/lab_pin.sym} 26460 -26310 0 0 {name=p25984 lab=_65367_/B }
C {devices/lab_pin.sym} 26460 -26270 0 0 {name=p25985 lab=_49334_/X }
C {devices/lab_pin.sym} 26460 -26230 0 0 {name=p25986 lab=_49348_/Y }
C {devices/lab_pin.sym} 26620 -26270 0 1 {name=p25987 lab=_49349_/Y }
C {sky130_stdcells/o21ai_4.sym} 26540 -26270 0 0 {name=X_49349_ }
C {devices/lab_pin.sym} 26480 -26150 0 0 {name=p25988 lab=_61636_/A }
C {devices/lab_pin.sym} 26480 -26110 0 0 {name=p25989 lab=_61627_/B }
C {devices/lab_pin.sym} 26480 -26070 0 0 {name=p25990 lab=_61590_/C }
C {devices/lab_pin.sym} 26600 -26110 0 1 {name=p25991 lab=_61627_/Y }
C {sky130_stdcells/nand3_4.sym} 26540 -26110 0 0 {name=X_61627_ }
C {devices/lab_pin.sym} 26480 -25980 0 0 {name=p25992 lab=_84761_/Q }
C {devices/lab_pin.sym} 26480 -25940 0 0 {name=p25993 lab=_84153_/Q }
C {devices/lab_pin.sym} 26600 -25960 0 1 {name=p25994 lab=_80461_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -25960 0 0 {name=X_80461_ }
C {devices/lab_pin.sym} 26460 -25850 0 0 {name=p25995 lab=_84018_/Q }
C {devices/lab_pin.sym} 26460 -25810 0 0 {name=p25996 lab=_68180_/X }
C {devices/lab_pin.sym} 26460 -25770 0 0 {name=p25997 lab=_68182_/X }
C {devices/lab_pin.sym} 26620 -25810 0 1 {name=p25998 lab=_68183_/X }
C {sky130_stdcells/a21bo_4.sym} 26540 -25810 0 0 {name=X_68183_ }
C {devices/lab_pin.sym} 26480 -25680 0 0 {name=p25999 lab=_65395_/A }
C {devices/lab_pin.sym} 26480 -25640 0 0 {name=p26000 lab=_65394_/Y }
C {devices/lab_pin.sym} 26600 -25660 0 1 {name=p26001 lab=_65395_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -25660 0 0 {name=X_65395_ }
C {devices/lab_pin.sym} 26500 -25530 0 0 {name=p26002 lab=clkbuf_9_446_0_CLK/A }
C {devices/lab_pin.sym} 26580 -25530 0 1 {name=p26003 lab=clkbuf_9_447_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 26540 -25530 0 0 {name=Xclkbuf_9_447_0_CLK }
C {devices/lab_pin.sym} 26450 -25410 0 0 {name=p26004 lab=_83681_/CLK }
C {devices/lab_pin.sym} 26450 -25390 0 0 {name=p26005 lab=_82200_/D }
C {devices/lab_pin.sym} 26630 -25410 0 1 {name=p26006 lab=_82392_/D }
C {sky130_stdcells/dfxtp_4.sym} 26540 -25400 0 0 {name=X_82200_ }
C {devices/lab_pin.sym} 26460 -25300 0 0 {name=p26007 lab=_87356_/Q }
C {devices/lab_pin.sym} 26460 -25260 0 0 {name=p26008 lab=_67035_/X }
C {devices/lab_pin.sym} 26460 -25220 0 0 {name=p26009 lab=_67106_/X }
C {devices/lab_pin.sym} 26460 -25180 0 0 {name=p26010 lab=_67133_/X }
C {devices/lab_pin.sym} 26620 -25240 0 1 {name=p26011 lab=_67134_/X }
C {sky130_stdcells/a211o_4.sym} 26540 -25240 0 0 {name=X_67134_ }
C {devices/lab_pin.sym} 26480 -25100 0 0 {name=p26012 lab=_52385_/A }
C {devices/lab_pin.sym} 26480 -25060 0 0 {name=p26013 lab=_49079_/A }
C {devices/lab_pin.sym} 26600 -25080 0 1 {name=p26014 lab=_52360_/X }
C {sky130_stdcells/and2_4.sym} 26540 -25080 0 0 {name=X_52360_ }
C {devices/lab_pin.sym} 26480 -24970 0 0 {name=p26015 lab=_64336_/A }
C {devices/lab_pin.sym} 26480 -24930 0 0 {name=p26016 lab=_58546_/A }
C {devices/lab_pin.sym} 26480 -24890 0 0 {name=p26017 lab=_64323_/X }
C {devices/lab_pin.sym} 26600 -24930 0 1 {name=p26018 lab=_64346_/Y }
C {sky130_stdcells/nand3_4.sym} 26540 -24930 0 0 {name=X_64346_ }
C {devices/lab_pin.sym} 26450 -24790 0 0 {name=p26019 lab=_83820_/CLK }
C {devices/lab_pin.sym} 26450 -24770 0 0 {name=p26020 lab=_83180_/D }
C {devices/lab_pin.sym} 26630 -24790 0 1 {name=p26021 lab=_83180_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -24780 0 0 {name=X_83180_ }
C {devices/lab_pin.sym} 26480 -24670 0 0 {name=p26022 lab=_61558_/A }
C {devices/lab_pin.sym} 26480 -24630 0 0 {name=p26023 lab=_61558_/B }
C {devices/lab_pin.sym} 26480 -24590 0 0 {name=p26024 lab=_61538_/C }
C {devices/lab_pin.sym} 26600 -24630 0 1 {name=p26025 lab=_61558_/Y }
C {sky130_stdcells/nand3_4.sym} 26540 -24630 0 0 {name=X_61558_ }
C {devices/lab_pin.sym} 26480 -24500 0 0 {name=p26026 lab=_80390_/X }
C {devices/lab_pin.sym} 26480 -24460 0 0 {name=p26027 lab=_80391_/X }
C {devices/lab_pin.sym} 26600 -24480 0 1 {name=p26028 lab=_80406_/A }
C {sky130_stdcells/xnor2_4.sym} 26540 -24480 0 0 {name=X_80392_ }
C {devices/lab_pin.sym} 26480 -24360 0 0 {name=p26029 lab=_51310_/X }
C {devices/lab_pin.sym} 26480 -24320 0 0 {name=p26030 lab=_50799_/B }
C {devices/lab_pin.sym} 26600 -24340 0 1 {name=p26031 lab=_51311_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -24340 0 0 {name=X_51311_ }
C {devices/lab_pin.sym} 26450 -24210 0 0 {name=p26032 lab=_82131_/CLK }
C {devices/lab_pin.sym} 26450 -24190 0 0 {name=p26033 lab=_82131_/D }
C {devices/lab_pin.sym} 26630 -24210 0 1 {name=p26034 lab=_77294_/B }
C {sky130_stdcells/dfxtp_4.sym} 26540 -24200 0 0 {name=X_82131_ }
C {devices/lab_pin.sym} 26500 -24070 0 0 {name=p26035 lab=_61287_/A }
C {devices/lab_pin.sym} 26580 -24070 0 1 {name=p26036 lab=_60509_/Y }
C {sky130_stdcells/inv_2.sym} 26540 -24070 0 0 {name=X_60509_ }
C {devices/lab_pin.sym} 26460 -23980 0 0 {name=p26037 lab=_88383_/Q }
C {devices/lab_pin.sym} 26460 -23940 0 0 {name=p26038 lab=_66988_/X }
C {devices/lab_pin.sym} 26460 -23900 0 0 {name=p26039 lab=_67040_/X }
C {devices/lab_pin.sym} 26460 -23860 0 0 {name=p26040 lab=_67064_/X }
C {devices/lab_pin.sym} 26620 -23920 0 1 {name=p26041 lab=_67065_/X }
C {sky130_stdcells/a211o_4.sym} 26540 -23920 0 0 {name=X_67065_ }
C {devices/lab_pin.sym} 26480 -23790 0 0 {name=p26042 lab=_52291_/A }
C {devices/lab_pin.sym} 26480 -23750 0 0 {name=p26043 lab=_52267_/B }
C {devices/lab_pin.sym} 26480 -23710 0 0 {name=p26044 lab=_52291_/C }
C {devices/lab_pin.sym} 26600 -23750 0 1 {name=p26045 lab=_52291_/X }
C {sky130_stdcells/and3_4.sym} 26540 -23750 0 0 {name=X_52291_ }
C {devices/lab_pin.sym} 26480 -23630 0 0 {name=p26046 lab=_64287_/A }
C {devices/lab_pin.sym} 26480 -23590 0 0 {name=p26047 lab=_84852_/Q }
C {devices/lab_pin.sym} 26480 -23550 0 0 {name=p26048 lab=_64287_/C }
C {devices/lab_pin.sym} 26600 -23590 0 1 {name=p26049 lab=_64277_/Y }
C {sky130_stdcells/nand3_4.sym} 26540 -23590 0 0 {name=X_64277_ }
C {devices/lab_pin.sym} 26480 -23470 0 0 {name=p26050 lab=_61437_/A }
C {devices/lab_pin.sym} 26480 -23430 0 0 {name=p26051 lab=_61489_/B }
C {devices/lab_pin.sym} 26480 -23390 0 0 {name=p26052 lab=_61459_/X }
C {devices/lab_pin.sym} 26600 -23430 0 1 {name=p26053 lab=_61489_/Y }
C {sky130_stdcells/nand3_4.sym} 26540 -23430 0 0 {name=X_61489_ }
C {devices/lab_pin.sym} 26500 -23290 0 0 {name=p26054 lab=_53929_/A }
C {devices/lab_pin.sym} 26580 -23290 0 1 {name=p26055 lab=_54031_/A }
C {sky130_stdcells/buf_2.sym} 26540 -23290 0 0 {name=X_54030_ }
C {devices/lab_pin.sym} 26500 -23170 0 0 {name=p26056 lab=_84162_/Q }
C {devices/lab_pin.sym} 26580 -23170 0 1 {name=p26057 lab=_66016_/Y }
C {sky130_stdcells/inv_2.sym} 26540 -23170 0 0 {name=X_66016_ }
C {devices/lab_pin.sym} 26480 -23060 0 0 {name=p26058 lab=_51242_/A }
C {devices/lab_pin.sym} 26480 -23020 0 0 {name=p26059 lab=_46267_/A }
C {devices/lab_pin.sym} 26600 -23040 0 1 {name=p26060 lab=_51242_/X }
C {sky130_stdcells/and2_4.sym} 26540 -23040 0 0 {name=X_51242_ }
C {devices/lab_pin.sym} 26460 -22950 0 0 {name=p26061 lab=_63223_/Y }
C {devices/lab_pin.sym} 26460 -22910 0 0 {name=p26062 lab=_63225_/X }
C {devices/lab_pin.sym} 26460 -22870 0 0 {name=p26063 lab=_63226_/X }
C {devices/lab_pin.sym} 26460 -22830 0 0 {name=p26064 lab=_63227_/X }
C {devices/lab_pin.sym} 26460 -22790 0 0 {name=p26065 lab=_63183_/X }
C {devices/lab_pin.sym} 26620 -22870 0 1 {name=p26066 lab=_63228_/Y }
C {sky130_stdcells/o41ai_4.sym} 26540 -22870 0 0 {name=X_63228_ }
C {devices/lab_pin.sym} 26450 -22710 0 0 {name=p26067 lab=_84105_/CLK }
C {devices/lab_pin.sym} 26450 -22690 0 0 {name=p26068 lab=_82062_/D }
C {devices/lab_pin.sym} 26630 -22710 0 1 {name=p26069 lab=_77832_/A }
C {sky130_stdcells/dfxtp_4.sym} 26540 -22700 0 0 {name=X_82062_ }
C {devices/lab_pin.sym} 26450 -22570 0 0 {name=p26070 lab=_84150_/CLK }
C {devices/lab_pin.sym} 26450 -22550 0 0 {name=p26071 lab=_84221_/Q }
C {devices/lab_pin.sym} 26630 -22570 0 1 {name=p26072 lab=_81013_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -22560 0 0 {name=X_81013_ }
C {devices/lab_pin.sym} 26480 -22440 0 0 {name=p26073 lab=_51167_/A }
C {devices/lab_pin.sym} 26480 -22400 0 0 {name=p26074 lab=_52863_/B }
C {devices/lab_pin.sym} 26600 -22420 0 1 {name=p26075 lab=_51173_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -22420 0 0 {name=X_51173_ }
C {devices/lab_pin.sym} 26460 -22330 0 0 {name=p26076 lab=_63153_/Y }
C {devices/lab_pin.sym} 26460 -22290 0 0 {name=p26077 lab=_63155_/X }
C {devices/lab_pin.sym} 26460 -22250 0 0 {name=p26078 lab=_63156_/X }
C {devices/lab_pin.sym} 26460 -22210 0 0 {name=p26079 lab=_63158_/X }
C {devices/lab_pin.sym} 26460 -22170 0 0 {name=p26080 lab=_63125_/X }
C {devices/lab_pin.sym} 26620 -22250 0 1 {name=p26081 lab=_63159_/Y }
C {sky130_stdcells/o41ai_4.sym} 26540 -22250 0 0 {name=X_63159_ }
C {devices/lab_pin.sym} 26450 -22090 0 0 {name=p26082 lab=_86873_/CLK }
C {devices/lab_pin.sym} 26450 -22070 0 0 {name=p26083 lab=_45546_/Y }
C {devices/lab_pin.sym} 26630 -22090 0 1 {name=p26084 lab=_63110_/B }
C {sky130_stdcells/dfxtp_4.sym} 26540 -22080 0 0 {name=X_86870_ }
C {devices/lab_pin.sym} 26480 -21960 0 0 {name=p26085 lab=_50120_/A }
C {devices/lab_pin.sym} 26480 -21920 0 0 {name=p26086 lab=_49025_/X }
C {devices/lab_pin.sym} 26600 -21940 0 1 {name=p26087 lab=_50124_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -21940 0 0 {name=X_50124_ }
C {devices/lab_pin.sym} 26450 -21810 0 0 {name=p26088 lab=_86045_/CLK }
C {devices/lab_pin.sym} 26450 -21790 0 0 {name=p26089 lab=_85821_/D }
C {devices/lab_pin.sym} 26630 -21810 0 1 {name=p26090 lab=_64694_/B }
C {sky130_stdcells/dfxtp_4.sym} 26540 -21800 0 0 {name=X_85821_ }
C {devices/lab_pin.sym} 26480 -21680 0 0 {name=p26091 lab=_55698_/A }
C {devices/lab_pin.sym} 26480 -21640 0 0 {name=p26092 lab=_85312_/Q }
C {devices/lab_pin.sym} 26600 -21660 0 1 {name=p26093 lab=_55981_/X }
C {sky130_stdcells/and2_4.sym} 26540 -21660 0 0 {name=X_55981_ }
C {devices/lab_pin.sym} 26480 -21540 0 0 {name=p26094 lab=_67992_/A }
C {devices/lab_pin.sym} 26480 -21500 0 0 {name=p26095 lab=_88153_/Q }
C {devices/lab_pin.sym} 26600 -21520 0 1 {name=p26096 lab=_67967_/X }
C {sky130_stdcells/and2_4.sym} 26540 -21520 0 0 {name=X_67967_ }
C {devices/lab_pin.sym} 26500 -21390 0 0 {name=p26097 lab=clkbuf_4_5_1_CLK/X }
C {devices/lab_pin.sym} 26580 -21390 0 1 {name=p26098 lab=clkbuf_6_23_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 26540 -21390 0 0 {name=Xclkbuf_5_11_0_CLK }
C {devices/lab_pin.sym} 26460 -21300 0 0 {name=p26099 lab=_84953_/Q }
C {devices/lab_pin.sym} 26460 -21260 0 0 {name=p26100 lab=_57691_/X }
C {devices/lab_pin.sym} 26460 -21220 0 0 {name=p26101 lab=_57704_/X }
C {devices/lab_pin.sym} 26460 -21180 0 0 {name=p26102 lab=_57719_/X }
C {devices/lab_pin.sym} 26620 -21240 0 1 {name=p26103 lab=_84953_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 26540 -21240 0 0 {name=X_57720_ }
C {devices/lab_pin.sym} 26460 -21120 0 0 {name=p26104 lab=_69281_/Y }
C {devices/lab_pin.sym} 26460 -21080 0 0 {name=p26105 lab=_69644_/X }
C {devices/lab_pin.sym} 26460 -21040 0 0 {name=p26106 lab=_69672_/X }
C {devices/lab_pin.sym} 26460 -21000 0 0 {name=p26107 lab=_69705_/Y }
C {devices/lab_pin.sym} 26620 -21060 0 1 {name=p26108 lab=_69706_/X }
C {sky130_stdcells/a211o_4.sym} 26540 -21060 0 0 {name=X_69706_ }
C {devices/lab_pin.sym} 26460 -20930 0 0 {name=p26109 lab=_50053_/Y }
C {devices/lab_pin.sym} 26460 -20890 0 0 {name=p26110 lab=_48865_/X }
C {devices/lab_pin.sym} 26460 -20850 0 0 {name=p26111 lab=_50054_/X }
C {devices/lab_pin.sym} 26620 -20890 0 1 {name=p26112 lab=_86273_/D }
C {sky130_stdcells/a21oi_4.sym} 26540 -20890 0 0 {name=X_50055_ }
C {devices/lab_pin.sym} 26480 -20780 0 0 {name=p26113 lab=_54932_/A }
C {devices/lab_pin.sym} 26480 -20740 0 0 {name=p26114 lab=_54942_/B }
C {devices/lab_pin.sym} 26480 -20700 0 0 {name=p26115 lab=_54932_/C }
C {devices/lab_pin.sym} 26480 -20660 0 0 {name=p26116 lab=_53238_/D }
C {devices/lab_pin.sym} 26600 -20720 0 1 {name=p26117 lab=_54932_/X }
C {sky130_stdcells/and4_4.sym} 26540 -20720 0 0 {name=X_54932_ }
C {devices/lab_pin.sym} 26460 -20590 0 0 {name=p26118 lab=_66913_/X }
C {devices/lab_pin.sym} 26460 -20550 0 0 {name=p26119 lab=_66917_/X }
C {devices/lab_pin.sym} 26460 -20510 0 0 {name=p26120 lab=_66843_/X }
C {devices/lab_pin.sym} 26620 -20550 0 1 {name=p26121 lab=_66918_/X }
C {sky130_stdcells/a21o_4.sym} 26540 -20550 0 0 {name=X_66918_ }
C {devices/lab_pin.sym} 26450 -20410 0 0 {name=p26122 lab=_85751_/CLK }
C {devices/lab_pin.sym} 26450 -20390 0 0 {name=p26123 lab=_85752_/D }
C {devices/lab_pin.sym} 26630 -20410 0 1 {name=p26124 lab=_85752_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -20400 0 0 {name=X_85752_ }
C {devices/lab_pin.sym} 26450 -20270 0 0 {name=p26125 lab=_82774_/CLK }
C {devices/lab_pin.sym} 26450 -20250 0 0 {name=p26126 lab=_82964_/D }
C {devices/lab_pin.sym} 26630 -20270 0 1 {name=p26127 lab=_82964_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -20260 0 0 {name=X_82964_ }
C {devices/lab_pin.sym} 26460 -20150 0 0 {name=p26128 lab=_67893_/X }
C {devices/lab_pin.sym} 26460 -20110 0 0 {name=p26129 lab=_67896_/X }
C {devices/lab_pin.sym} 26460 -20070 0 0 {name=p26130 lab=_67897_/X }
C {devices/lab_pin.sym} 26620 -20110 0 1 {name=p26131 lab=_67898_/Y }
C {sky130_stdcells/a21oi_4.sym} 26540 -20110 0 0 {name=X_67898_ }
C {devices/lab_pin.sym} 26450 -19970 0 0 {name=p26132 lab=_84713_/CLK }
C {devices/lab_pin.sym} 26450 -19950 0 0 {name=p26133 lab=_59774_/Y }
C {devices/lab_pin.sym} 26630 -19970 0 1 {name=p26134 lab=_80517_/A }
C {sky130_stdcells/dfxtp_4.sym} 26540 -19960 0 0 {name=X_84703_ }
C {devices/lab_pin.sym} 26500 -19830 0 0 {name=p26135 lab=_83761_/Q }
C {devices/lab_pin.sym} 26580 -19830 0 1 {name=p26136 lab=_57651_/Y }
C {sky130_stdcells/inv_2.sym} 26540 -19830 0 0 {name=X_57651_ }
C {devices/lab_pin.sym} 26450 -19710 0 0 {name=p26137 lab=_82008_/CLK }
C {devices/lab_pin.sym} 26450 -19690 0 0 {name=p26138 lab=_81915_/D }
C {devices/lab_pin.sym} 26630 -19710 0 1 {name=p26139 lab=_77127_/B }
C {sky130_stdcells/dfxtp_4.sym} 26540 -19700 0 0 {name=X_81915_ }
C {devices/lab_pin.sym} 26500 -19570 0 0 {name=p26140 lab=clkbuf_9_454_0_CLK/X }
C {devices/lab_pin.sym} 26580 -19570 0 1 {name=p26141 lab=_87851_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 26540 -19570 0 0 {name=Xclkbuf_10_909_0_CLK }
C {devices/lab_pin.sym} 26460 -19470 0 0 {name=p26142 lab=_69634_/X }
C {devices/lab_pin.sym} 26460 -19430 0 0 {name=p26143 lab=_69636_/X }
C {devices/lab_pin.sym} 26460 -19390 0 0 {name=p26144 lab=_69570_/X }
C {devices/lab_pin.sym} 26620 -19430 0 1 {name=p26145 lab=_69637_/X }
C {sky130_stdcells/a21o_4.sym} 26540 -19430 0 0 {name=X_69637_ }
C {devices/lab_pin.sym} 26480 -19320 0 0 {name=p26146 lab=_54883_/A }
C {devices/lab_pin.sym} 26480 -19280 0 0 {name=p26147 lab=_54857_/B }
C {devices/lab_pin.sym} 26480 -19240 0 0 {name=p26148 lab=_54883_/C }
C {devices/lab_pin.sym} 26480 -19200 0 0 {name=p26149 lab=_53170_/D }
C {devices/lab_pin.sym} 26600 -19260 0 1 {name=p26150 lab=_54863_/X }
C {sky130_stdcells/and4_4.sym} 26540 -19260 0 0 {name=X_54863_ }
C {devices/lab_pin.sym} 26460 -19130 0 0 {name=p26151 lab=_80918_/D }
C {devices/lab_pin.sym} 26460 -19090 0 0 {name=p26152 lab=_66734_/X }
C {devices/lab_pin.sym} 26460 -19050 0 0 {name=p26153 lab=_66848_/X }
C {devices/lab_pin.sym} 26620 -19090 0 1 {name=p26154 lab=_66849_/X }
C {sky130_stdcells/a21bo_4.sym} 26540 -19090 0 0 {name=X_66849_ }
C {devices/lab_pin.sym} 26450 -18950 0 0 {name=p26155 lab=_84787_/CLK }
C {devices/lab_pin.sym} 26450 -18930 0 0 {name=p26156 lab=_85683_/D }
C {devices/lab_pin.sym} 26630 -18950 0 1 {name=p26157 lab=_85683_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -18940 0 0 {name=X_85683_ }
C {devices/lab_pin.sym} 26450 -18810 0 0 {name=p26158 lab=_86941_/CLK }
C {devices/lab_pin.sym} 26450 -18790 0 0 {name=p26159 lab=_78173_/B }
C {devices/lab_pin.sym} 26630 -18810 0 1 {name=p26160 lab=_41725_/A }
C {sky130_stdcells/dfxtp_4.sym} 26540 -18800 0 0 {name=X_82895_ }
C {devices/lab_pin.sym} 26500 -18670 0 0 {name=p26161 lab=_56774_/A }
C {devices/lab_pin.sym} 26580 -18670 0 1 {name=p26162 lab=_56602_/X }
C {sky130_stdcells/buf_2.sym} 26540 -18670 0 0 {name=X_56602_ }
C {devices/lab_pin.sym} 26450 -18550 0 0 {name=p26163 lab=_82317_/CLK }
C {devices/lab_pin.sym} 26450 -18530 0 0 {name=p26164 lab=_43437_/X }
C {devices/lab_pin.sym} 26630 -18550 0 1 {name=p26165 lab=_87422_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -18540 0 0 {name=X_87422_ }
C {devices/lab_pin.sym} 26480 -18420 0 0 {name=p26166 lab=_53825_/A }
C {devices/lab_pin.sym} 26480 -18380 0 0 {name=p26167 lab=_71989_/B }
C {devices/lab_pin.sym} 26600 -18400 0 1 {name=p26168 lab=_53814_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -18400 0 0 {name=X_53814_ }
C {devices/lab_pin.sym} 26450 -18270 0 0 {name=p26169 lab=_84634_/CLK }
C {devices/lab_pin.sym} 26450 -18250 0 0 {name=p26170 lab=_84634_/D }
C {devices/lab_pin.sym} 26630 -18270 0 1 {name=p26171 lab=_79722_/A }
C {sky130_stdcells/dfxtp_4.sym} 26540 -18260 0 0 {name=X_84634_ }
C {devices/lab_pin.sym} 26500 -18130 0 0 {name=p26172 lab=clkbuf_5_27_0_CLK/A }
C {devices/lab_pin.sym} 26580 -18130 0 1 {name=p26173 lab=clkbuf_6_53_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 26540 -18130 0 0 {name=Xclkbuf_5_26_0_CLK }
C {devices/lab_pin.sym} 26480 -18020 0 0 {name=p26174 lab=_57597_/A }
C {devices/lab_pin.sym} 26480 -17980 0 0 {name=p26175 lab=_50326_/B }
C {devices/lab_pin.sym} 26600 -18000 0 1 {name=p26176 lab=_57582_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -18000 0 0 {name=X_57582_ }
C {devices/lab_pin.sym} 26450 -17870 0 0 {name=p26177 lab=_82221_/CLK }
C {devices/lab_pin.sym} 26450 -17850 0 0 {name=p26178 lab=_81846_/D }
C {devices/lab_pin.sym} 26630 -17870 0 1 {name=p26179 lab=_77518_/A }
C {sky130_stdcells/dfxtp_4.sym} 26540 -17860 0 0 {name=X_81846_ }
C {devices/lab_pin.sym} 26480 -17740 0 0 {name=p26180 lab=_68934_/X }
C {devices/lab_pin.sym} 26480 -17700 0 0 {name=p26181 lab=_42543_/Y }
C {devices/lab_pin.sym} 26600 -17720 0 1 {name=p26182 lab=_69568_/Y }
C {sky130_stdcells/nor2_4.sym} 26540 -17720 0 0 {name=X_69568_ }
C {devices/lab_pin.sym} 26480 -17620 0 0 {name=p26183 lab=_54798_/A }
C {devices/lab_pin.sym} 26480 -17580 0 0 {name=p26184 lab=_54816_/B }
C {devices/lab_pin.sym} 26480 -17540 0 0 {name=p26185 lab=_54798_/C }
C {devices/lab_pin.sym} 26480 -17500 0 0 {name=p26186 lab=_53103_/D }
C {devices/lab_pin.sym} 26600 -17560 0 1 {name=p26187 lab=_54794_/X }
C {sky130_stdcells/and4_4.sym} 26540 -17560 0 0 {name=X_54794_ }
C {devices/lab_pin.sym} 26460 -17430 0 0 {name=p26188 lab=_59311_/X }
C {devices/lab_pin.sym} 26460 -17390 0 0 {name=p26189 lab=_85735_/Q }
C {devices/lab_pin.sym} 26460 -17350 0 0 {name=p26190 lab=_59263_/X }
C {devices/lab_pin.sym} 26620 -17390 0 1 {name=p26191 lab=_59321_/X }
C {sky130_stdcells/o21a_4.sym} 26540 -17390 0 0 {name=X_59321_ }
C {devices/lab_pin.sym} 26480 -17270 0 0 {name=p26192 lab=_56533_/A }
C {devices/lab_pin.sym} 26480 -17230 0 0 {name=p26193 lab=_56533_/B }
C {devices/lab_pin.sym} 26480 -17190 0 0 {name=p26194 lab=_85159_/Q }
C {devices/lab_pin.sym} 26600 -17230 0 1 {name=p26195 lab=_56533_/Y }
C {sky130_stdcells/nand3_4.sym} 26540 -17230 0 0 {name=X_56533_ }
C {devices/lab_pin.sym} 26460 -17120 0 0 {name=p26196 lab=_87597_/Q }
C {devices/lab_pin.sym} 26460 -17080 0 0 {name=p26197 lab=_68066_/X }
C {devices/lab_pin.sym} 26460 -17040 0 0 {name=p26198 lab=_68517_/X }
C {devices/lab_pin.sym} 26460 -17000 0 0 {name=p26199 lab=_68518_/X }
C {devices/lab_pin.sym} 26620 -17060 0 1 {name=p26200 lab=_68519_/X }
C {sky130_stdcells/a211o_4.sym} 26540 -17060 0 0 {name=X_68519_ }
C {devices/lab_pin.sym} 26450 -16910 0 0 {name=p26201 lab=_81182_/CLK }
C {devices/lab_pin.sym} 26450 -16890 0 0 {name=p26202 lab=_87353_/D }
C {devices/lab_pin.sym} 26630 -16910 0 1 {name=p26203 lab=_87353_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -16900 0 0 {name=X_87353_ }
C {devices/lab_pin.sym} 26480 -16780 0 0 {name=p26204 lab=_53750_/A }
C {devices/lab_pin.sym} 26480 -16740 0 0 {name=p26205 lab=_48639_/A }
C {devices/lab_pin.sym} 26600 -16760 0 1 {name=p26206 lab=_53745_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -16760 0 0 {name=X_53745_ }
C {devices/lab_pin.sym} 26450 -16630 0 0 {name=p26207 lab=_84603_/CLK }
C {devices/lab_pin.sym} 26450 -16610 0 0 {name=p26208 lab=_84565_/D }
C {devices/lab_pin.sym} 26630 -16630 0 1 {name=p26209 lab=_84565_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -16620 0 0 {name=X_84565_ }
C {devices/lab_pin.sym} 26500 -16490 0 0 {name=p26210 lab=_50957_/A }
C {devices/lab_pin.sym} 26580 -16490 0 1 {name=p26211 lab=_50957_/X }
C {sky130_stdcells/buf_2.sym} 26540 -16490 0 0 {name=X_50957_ }
C {devices/lab_pin.sym} 26480 -16380 0 0 {name=p26212 lab=_69496_/X }
C {devices/lab_pin.sym} 26480 -16340 0 0 {name=p26213 lab=_69498_/X }
C {devices/lab_pin.sym} 26600 -16360 0 1 {name=p26214 lab=_69499_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -16360 0 0 {name=X_69499_ }
C {devices/lab_pin.sym} 26450 -16230 0 0 {name=p26215 lab=_83133_/CLK }
C {devices/lab_pin.sym} 26450 -16210 0 0 {name=p26216 lab=_81777_/D }
C {devices/lab_pin.sym} 26630 -16230 0 1 {name=p26217 lab=_49048_/B }
C {sky130_stdcells/dfxtp_4.sym} 26540 -16220 0 0 {name=X_81777_ }
C {devices/lab_pin.sym} 26450 -16090 0 0 {name=p26218 lab=_86303_/CLK }
C {devices/lab_pin.sym} 26450 -16070 0 0 {name=p26219 lab=_49894_/Y }
C {devices/lab_pin.sym} 26630 -16090 0 1 {name=p26220 lab=_72128_/B }
C {sky130_stdcells/dfxtp_4.sym} 26540 -16080 0 0 {name=X_86304_ }
C {devices/lab_pin.sym} 26480 -15960 0 0 {name=p26221 lab=_40710_/A }
C {devices/lab_pin.sym} 26480 -15920 0 0 {name=p26222 lab=_40710_/B }
C {devices/lab_pin.sym} 26600 -15940 0 1 {name=p26223 lab=_40710_/X }
C {sky130_stdcells/or2_4.sym} 26540 -15940 0 0 {name=X_40710_ }
C {devices/lab_pin.sym} 26460 -15840 0 0 {name=p26224 lab=_84757_/Q }
C {devices/lab_pin.sym} 26460 -15800 0 0 {name=p26225 lab=_59129_/X }
C {devices/lab_pin.sym} 26460 -15760 0 0 {name=p26226 lab=_59246_/X }
C {devices/lab_pin.sym} 26460 -15720 0 0 {name=p26227 lab=_59251_/X }
C {devices/lab_pin.sym} 26620 -15780 0 1 {name=p26228 lab=_59252_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 26540 -15780 0 0 {name=X_59252_ }
C {devices/lab_pin.sym} 26500 -15630 0 0 {name=p26229 lab=_71530_/A }
C {devices/lab_pin.sym} 26580 -15630 0 1 {name=p26230 lab=_71530_/Y }
C {sky130_stdcells/inv_2.sym} 26540 -15630 0 0 {name=X_71530_ }
C {devices/lab_pin.sym} 26450 -15510 0 0 {name=p26231 lab=_83520_/CLK }
C {devices/lab_pin.sym} 26450 -15490 0 0 {name=p26232 lab=_83516_/D }
C {devices/lab_pin.sym} 26630 -15510 0 1 {name=p26233 lab=_83516_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -15500 0 0 {name=X_83516_ }
C {devices/lab_pin.sym} 26500 -15370 0 0 {name=p26234 lab=_56525_/A }
C {devices/lab_pin.sym} 26580 -15370 0 1 {name=p26235 lab=_56545_/A }
C {sky130_stdcells/buf_2.sym} 26540 -15370 0 0 {name=X_56464_ }
C {devices/lab_pin.sym} 26450 -15250 0 0 {name=p26236 lab=_80728_/CLK }
C {devices/lab_pin.sym} 26450 -15230 0 0 {name=p26237 lab=_75914_/X }
C {devices/lab_pin.sym} 26630 -15250 0 1 {name=p26238 lab=_80696_/D }
C {sky130_stdcells/dfxtp_4.sym} 26540 -15240 0 0 {name=X_80728_ }
C {devices/lab_pin.sym} 26450 -15110 0 0 {name=p26239 lab=_87824_/CLK }
C {devices/lab_pin.sym} 26450 -15090 0 0 {name=p26240 lab=_87284_/D }
C {devices/lab_pin.sym} 26630 -15110 0 1 {name=p26241 lab=_69967_/B }
C {sky130_stdcells/dfxtp_4.sym} 26540 -15100 0 0 {name=X_87284_ }
C {devices/lab_pin.sym} 26500 -14970 0 0 {name=p26242 lab=_41690_/A }
C {devices/lab_pin.sym} 26580 -14970 0 1 {name=p26243 lab=_41690_/Y }
C {sky130_stdcells/inv_2.sym} 26540 -14970 0 0 {name=X_41690_ }
C {devices/lab_pin.sym} 26480 -14870 0 0 {name=p26244 lab=_52156_/A }
C {devices/lab_pin.sym} 26480 -14830 0 0 {name=p26245 lab=_53666_/X }
C {devices/lab_pin.sym} 26480 -14790 0 0 {name=p26246 lab=_53692_/C }
C {devices/lab_pin.sym} 26600 -14830 0 1 {name=p26247 lab=_53676_/X }
C {sky130_stdcells/and3_4.sym} 26540 -14830 0 0 {name=X_53676_ }
C {devices/lab_pin.sym} 26450 -14690 0 0 {name=p26248 lab=_84501_/CLK }
C {devices/lab_pin.sym} 26450 -14670 0 0 {name=p26249 lab=_61258_/Y }
C {devices/lab_pin.sym} 26630 -14690 0 1 {name=p26250 lab=_75898_/A }
C {sky130_stdcells/dfxtp_4.sym} 26540 -14680 0 0 {name=X_84496_ }
C {devices/lab_pin.sym} 26480 -14560 0 0 {name=p26251 lab=_50906_/A }
C {devices/lab_pin.sym} 26480 -14520 0 0 {name=p26252 lab=_46625_/X }
C {devices/lab_pin.sym} 26600 -14540 0 1 {name=p26253 lab=_50888_/Y }
C {sky130_stdcells/nand2_4.sym} 26540 -14540 0 0 {name=X_50888_ }
C {devices/lab_pin.sym} 26460 -14430 0 0 {name=p26254 lab=_58191_/X }
C {devices/lab_pin.sym} 26460 -14390 0 0 {name=p26255 lab=_58200_/Y }
C {devices/lab_pin.sym} 26460 -14350 0 0 {name=p26256 lab=_58202_/Y }
C {devices/lab_pin.sym} 26620 -14390 0 1 {name=p26257 lab=_84909_/D }
C {sky130_stdcells/a21oi_4.sym} 26540 -14390 0 0 {name=X_58203_ }
C {devices/lab_pin.sym} 26480 -14270 0 0 {name=p26258 lab=_55415_/A }
C {devices/lab_pin.sym} 26480 -14230 0 0 {name=p26259 lab=_55415_/B }
C {devices/lab_pin.sym} 26480 -14190 0 0 {name=p26260 lab=_55415_/C }
C {devices/lab_pin.sym} 26600 -14230 0 1 {name=p26261 lab=_55683_/A }
C {sky130_stdcells/and3_4.sym} 26540 -14230 0 0 {name=X_55415_ }
C {devices/lab_pin.sym} 26450 -14090 0 0 {name=p26262 lab=_86235_/CLK }
C {devices/lab_pin.sym} 26450 -14070 0 0 {name=p26263 lab=_86235_/D }
C {devices/lab_pin.sym} 26630 -14090 0 1 {name=p26264 lab=_86235_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -14080 0 0 {name=X_86235_ }
C {sky130_stdcells/decap_3.sym} 26540 -13920 0 0 {name=XPHY_301 }
C {devices/lab_pin.sym} 26500 -13770 0 0 {name=p26265 lab=_40640_/X }
C {devices/lab_pin.sym} 26580 -13770 0 1 {name=p26266 lab=_40641_/X }
C {sky130_stdcells/buf_2.sym} 26540 -13770 0 0 {name=X_40641_ }
C {devices/lab_pin.sym} 26480 -13680 0 0 {name=p26267 lab=_52643_/A }
C {devices/lab_pin.sym} 26480 -13640 0 0 {name=p26268 lab=_52605_/X }
C {devices/lab_pin.sym} 26480 -13600 0 0 {name=p26269 lab=_52643_/C }
C {devices/lab_pin.sym} 26480 -13560 0 0 {name=p26270 lab=_46707_/X }
C {devices/lab_pin.sym} 26600 -13620 0 1 {name=p26271 lab=_52627_/X }
C {sky130_stdcells/and4_4.sym} 26540 -13620 0 0 {name=X_52627_ }
C {devices/lab_pin.sym} 26460 -13490 0 0 {name=p26272 lab=_59160_/X }
C {devices/lab_pin.sym} 26460 -13450 0 0 {name=p26273 lab=_85650_/Q }
C {devices/lab_pin.sym} 26460 -13410 0 0 {name=p26274 lab=_59081_/X }
C {devices/lab_pin.sym} 26620 -13450 0 1 {name=p26275 lab=_59183_/X }
C {sky130_stdcells/o21a_4.sym} 26540 -13450 0 0 {name=X_59183_ }
C {devices/lab_pin.sym} 26460 -13330 0 0 {name=p26276 lab=_71444_/Y }
C {devices/lab_pin.sym} 26460 -13290 0 0 {name=p26277 lab=_83490_/Q }
C {devices/lab_pin.sym} 26460 -13250 0 0 {name=p26278 lab=_71460_/Y }
C {devices/lab_pin.sym} 26620 -13290 0 1 {name=p26279 lab=_71461_/X }
C {sky130_stdcells/a21o_4.sym} 26540 -13290 0 0 {name=X_71461_ }
C {devices/lab_pin.sym} 26450 -13150 0 0 {name=p26280 lab=_83480_/CLK }
C {devices/lab_pin.sym} 26450 -13130 0 0 {name=p26281 lab=_83447_/D }
C {devices/lab_pin.sym} 26630 -13150 0 1 {name=p26282 lab=_83447_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -13140 0 0 {name=X_83447_ }
C {devices/lab_pin.sym} 26480 -13030 0 0 {name=p26283 lab=_56383_/X }
C {devices/lab_pin.sym} 26480 -12990 0 0 {name=p26284 lab=_56386_/B }
C {devices/lab_pin.sym} 26480 -12950 0 0 {name=p26285 lab=_56395_/C }
C {devices/lab_pin.sym} 26600 -12990 0 1 {name=p26286 lab=_56395_/Y }
C {sky130_stdcells/nand3_4.sym} 26540 -12990 0 0 {name=X_56395_ }
C {sky130_stdcells/decap_3.sym} 26540 -12820 0 0 {name=XPHY_312 }
C {devices/lab_pin.sym} 26450 -12670 0 0 {name=p26287 lab=_80657_/CLK }
C {devices/lab_pin.sym} 26450 -12650 0 0 {name=p26288 lab=_74822_/Y }
C {devices/lab_pin.sym} 26630 -12670 0 1 {name=p26289 lab=_46141_/A }
C {sky130_stdcells/dfxtp_4.sym} 26540 -12660 0 0 {name=X_80659_ }
C {sky130_stdcells/decap_3.sym} 26540 -12500 0 0 {name=XPHY_323 }
C {sky130_stdcells/decap_3.sym} 26540 -12320 0 0 {name=XPHY_334 }
C {devices/lab_pin.sym} 26500 -12170 0 0 {name=p26290 lab=_72951_/A }
C {devices/lab_pin.sym} 26580 -12170 0 1 {name=p26291 lab=_73200_/X }
C {sky130_stdcells/buf_2.sym} 26540 -12170 0 0 {name=X_73200_ }
C {devices/lab_pin.sym} 26460 -12080 0 0 {name=p26292 lab=_79903_/A }
C {devices/lab_pin.sym} 26460 -12040 0 0 {name=p26293 lab=_57981_/X }
C {devices/lab_pin.sym} 26460 -12000 0 0 {name=p26294 lab=_58129_/X }
C {devices/lab_pin.sym} 26460 -11960 0 0 {name=p26295 lab=_58133_/X }
C {devices/lab_pin.sym} 26620 -12020 0 1 {name=p26296 lab=_84923_/D }
C {sky130_stdcells/a22oi_4.sym} 26540 -12020 0 0 {name=X_58134_ }
C {devices/lab_pin.sym} 26500 -11870 0 0 {name=p26297 lab=_70412_/A }
C {devices/lab_pin.sym} 26580 -11870 0 1 {name=p26298 lab=_70412_/X }
C {sky130_stdcells/buf_2.sym} 26540 -11870 0 0 {name=X_70412_ }
C {sky130_stdcells/decap_3.sym} 26540 -11720 0 0 {name=XPHY_345 }
C {devices/lab_pin.sym} 26460 -11600 0 0 {name=p26299 lab=_41361_/X }
C {devices/lab_pin.sym} 26460 -11560 0 0 {name=p26300 lab=_43356_/X }
C {devices/lab_pin.sym} 26460 -11520 0 0 {name=p26301 lab=_87461_/Q }
C {devices/lab_pin.sym} 26460 -11480 0 0 {name=p26302 lab=_43357_/X }
C {devices/lab_pin.sym} 26620 -11540 0 1 {name=p26303 lab=_87461_/D }
C {sky130_stdcells/a2bb2o_4.sym} 26540 -11540 0 0 {name=X_43360_ }
C {devices/lab_pin.sym} 26480 -11400 0 0 {name=p26304 lab=_55305_/X }
C {devices/lab_pin.sym} 26480 -11360 0 0 {name=p26305 lab=_55346_/B }
C {devices/lab_pin.sym} 26600 -11380 0 1 {name=p26306 lab=_55346_/Y }
C {sky130_stdcells/nor2_4.sym} 26540 -11380 0 0 {name=X_55346_ }
C {devices/lab_pin.sym} 26480 -11260 0 0 {name=p26307 lab=_53588_/B }
C {devices/lab_pin.sym} 26480 -11220 0 0 {name=p26308 lab=_74180_/B }
C {devices/lab_pin.sym} 26600 -11240 0 1 {name=p26309 lab=_74181_/B }
C {sky130_stdcells/xor2_4.sym} 26540 -11240 0 0 {name=X_74180_ }
C {devices/lab_pin.sym} 26450 -11110 0 0 {name=p26310 lab=_83303_/CLK }
C {devices/lab_pin.sym} 26450 -11090 0 0 {name=p26311 lab=_50621_/Y }
C {devices/lab_pin.sym} 26630 -11110 0 1 {name=p26312 lab=_86166_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -11100 0 0 {name=X_86166_ }
C {devices/lab_pin.sym} 26460 -10990 0 0 {name=p26313 lab=_52556_/Y }
C {devices/lab_pin.sym} 26460 -10950 0 0 {name=p26314 lab=_52541_/X }
C {devices/lab_pin.sym} 26460 -10910 0 0 {name=p26315 lab=_52557_/Y }
C {devices/lab_pin.sym} 26620 -10950 0 1 {name=p26316 lab=_85798_/D }
C {sky130_stdcells/a21boi_4.sym} 26540 -10950 0 0 {name=X_52558_ }
C {devices/lab_pin.sym} 26460 -10830 0 0 {name=p26317 lab=_40380_/X }
C {devices/lab_pin.sym} 26460 -10790 0 0 {name=p26318 lab=_82880_/Q }
C {devices/lab_pin.sym} 26460 -10750 0 0 {name=p26319 lab=_40571_/X }
C {devices/lab_pin.sym} 26620 -10790 0 1 {name=p26320 lab=_40573_/A }
C {sky130_stdcells/o21a_4.sym} 26540 -10790 0 0 {name=X_40572_ }
C {sky130_stdcells/decap_3.sym} 26540 -10620 0 0 {name=XPHY_356 }
C {devices/lab_pin.sym} 26460 -10490 0 0 {name=p26321 lab=_71372_/Y }
C {devices/lab_pin.sym} 26460 -10450 0 0 {name=p26322 lab=_83515_/Q }
C {devices/lab_pin.sym} 26460 -10410 0 0 {name=p26323 lab=_71391_/Y }
C {devices/lab_pin.sym} 26620 -10450 0 1 {name=p26324 lab=_71392_/X }
C {sky130_stdcells/a21o_4.sym} 26540 -10450 0 0 {name=X_71392_ }
C {devices/lab_pin.sym} 26450 -10310 0 0 {name=p26325 lab=_83380_/CLK }
C {devices/lab_pin.sym} 26450 -10290 0 0 {name=p26326 lab=_83378_/D }
C {devices/lab_pin.sym} 26630 -10310 0 1 {name=p26327 lab=_83378_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -10300 0 0 {name=X_83378_ }
C {sky130_stdcells/decap_3.sym} 26540 -10140 0 0 {name=XPHY_367 }
C {sky130_stdcells/decap_3.sym} 26540 -9960 0 0 {name=XPHY_378 }
C {devices/lab_pin.sym} 26460 -9850 0 0 {name=p26328 lab=_42307_/X }
C {devices/lab_pin.sym} 26460 -9810 0 0 {name=p26329 lab=_42297_/X }
C {devices/lab_pin.sym} 26460 -9770 0 0 {name=p26330 lab=_41606_/X }
C {devices/lab_pin.sym} 26460 -9730 0 0 {name=p26331 lab=_87927_/Q }
C {devices/lab_pin.sym} 26460 -9690 0 0 {name=p26332 lab=_42298_/X }
C {devices/lab_pin.sym} 26620 -9770 0 1 {name=p26333 lab=_42312_/A }
C {sky130_stdcells/o32ai_4.sym} 26540 -9770 0 0 {name=X_42311_ }
C {devices/lab_pin.sym} 26460 -9630 0 0 {name=p26334 lab=_87057_/Q }
C {devices/lab_pin.sym} 26460 -9590 0 0 {name=p26335 lab=_73129_/X }
C {devices/lab_pin.sym} 26460 -9550 0 0 {name=p26336 lab=_73130_/X }
C {devices/lab_pin.sym} 26620 -9590 0 1 {name=p26337 lab=_73131_/Y }
C {sky130_stdcells/o21ai_4.sym} 26540 -9590 0 0 {name=X_73131_ }
C {devices/lab_pin.sym} 26450 -9450 0 0 {name=p26338 lab=_85114_/CLK }
C {devices/lab_pin.sym} 26450 -9430 0 0 {name=p26339 lab=_85117_/D }
C {devices/lab_pin.sym} 26630 -9450 0 1 {name=p26340 lab=_85117_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -9440 0 0 {name=X_85117_ }
C {sky130_stdcells/decap_3.sym} 26540 -9280 0 0 {name=XPHY_389 }
C {devices/lab_pin.sym} 26480 -9160 0 0 {name=p26341 lab=_51509_/A }
C {devices/lab_pin.sym} 26480 -9120 0 0 {name=p26342 lab=_51527_/B }
C {devices/lab_pin.sym} 26480 -9080 0 0 {name=p26343 lab=_51522_/C }
C {devices/lab_pin.sym} 26480 -9040 0 0 {name=p26344 lab=_53036_/D }
C {devices/lab_pin.sym} 26600 -9100 0 1 {name=p26345 lab=_51509_/X }
C {sky130_stdcells/and4_4.sym} 26540 -9100 0 0 {name=X_51509_ }
C {devices/lab_pin.sym} 26460 -8970 0 0 {name=p26346 lab=_70337_/X }
C {devices/lab_pin.sym} 26460 -8930 0 0 {name=p26347 lab=_74780_/A }
C {devices/lab_pin.sym} 26460 -8890 0 0 {name=p26348 lab=_70342_/X }
C {devices/lab_pin.sym} 26620 -8930 0 1 {name=p26349 lab=_83790_/D }
C {sky130_stdcells/a21o_4.sym} 26540 -8930 0 0 {name=X_70343_ }
C {devices/lab_pin.sym} 26500 -8790 0 0 {name=p26350 lab=_58813_/A }
C {devices/lab_pin.sym} 26580 -8790 0 1 {name=p26351 lab=_58065_/X }
C {sky130_stdcells/buf_2.sym} 26540 -8790 0 0 {name=X_58065_ }
C {devices/lab_pin.sym} 26450 -8670 0 0 {name=p26352 lab=_82327_/CLK }
C {devices/lab_pin.sym} 26450 -8650 0 0 {name=p26353 lab=_77168_/B }
C {devices/lab_pin.sym} 26630 -8670 0 1 {name=p26354 lab=_82329_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -8660 0 0 {name=X_82329_ }
C {devices/lab_pin.sym} 26460 -8570 0 0 {name=p26355 lab=_43260_/X }
C {devices/lab_pin.sym} 26460 -8530 0 0 {name=p26356 lab=_43269_/X }
C {devices/lab_pin.sym} 26460 -8490 0 0 {name=p26357 lab=_41174_/X }
C {devices/lab_pin.sym} 26460 -8450 0 0 {name=p26358 lab=_87495_/Q }
C {devices/lab_pin.sym} 26460 -8410 0 0 {name=p26359 lab=_43273_/X }
C {devices/lab_pin.sym} 26620 -8490 0 1 {name=p26360 lab=_43292_/A }
C {sky130_stdcells/o32ai_4.sym} 26540 -8490 0 0 {name=X_43291_ }
C {devices/lab_pin.sym} 26460 -8360 0 0 {name=p26361 lab=_57349_/B }
C {devices/lab_pin.sym} 26460 -8320 0 0 {name=p26362 lab=_55272_/A }
C {devices/lab_pin.sym} 26460 -8280 0 0 {name=p26363 lab=_55128_/X }
C {devices/lab_pin.sym} 26460 -8240 0 0 {name=p26364 lab=_55276_/X }
C {devices/lab_pin.sym} 26620 -8300 0 1 {name=p26365 lab=_55277_/X }
C {sky130_stdcells/a211o_4.sym} 26540 -8300 0 0 {name=X_55277_ }
C {devices/lab_pin.sym} 26450 -8150 0 0 {name=p26366 lab=_86096_/CLK }
C {devices/lab_pin.sym} 26450 -8130 0 0 {name=p26367 lab=_86097_/D }
C {devices/lab_pin.sym} 26630 -8150 0 1 {name=p26368 lab=_86097_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -8140 0 0 {name=X_86097_ }
C {devices/lab_pin.sym} 26460 -8030 0 0 {name=p26369 lab=_52485_/Y }
C {devices/lab_pin.sym} 26460 -7990 0 0 {name=p26370 lab=_52486_/X }
C {devices/lab_pin.sym} 26460 -7950 0 0 {name=p26371 lab=_52488_/Y }
C {devices/lab_pin.sym} 26620 -7990 0 1 {name=p26372 lab=_52489_/Y }
C {sky130_stdcells/a21boi_4.sym} 26540 -7990 0 0 {name=X_52489_ }
C {devices/lab_pin.sym} 26460 -7870 0 0 {name=p26373 lab=_45026_/Y }
C {devices/lab_pin.sym} 26460 -7830 0 0 {name=p26374 lab=_45029_/Y }
C {devices/lab_pin.sym} 26460 -7790 0 0 {name=p26375 lab=_44986_/X }
C {devices/lab_pin.sym} 26620 -7830 0 1 {name=p26376 lab=_45030_/X }
C {sky130_stdcells/a21o_4.sym} 26540 -7830 0 0 {name=X_45030_ }
C {devices/lab_pin.sym} 26460 -7710 0 0 {name=p26377 lab=_56966_/X }
C {devices/lab_pin.sym} 26460 -7670 0 0 {name=p26378 lab=_57007_/X }
C {devices/lab_pin.sym} 26460 -7630 0 0 {name=p26379 lab=_57015_/Y }
C {devices/lab_pin.sym} 26620 -7670 0 1 {name=p26380 lab=_57017_/A }
C {sky130_stdcells/o21ai_4.sym} 26540 -7670 0 0 {name=X_57016_ }
C {devices/lab_pin.sym} 26460 -7560 0 0 {name=p26381 lab=_41416_/X }
C {devices/lab_pin.sym} 26460 -7520 0 0 {name=p26382 lab=_42222_/X }
C {devices/lab_pin.sym} 26460 -7480 0 0 {name=p26383 lab=_87963_/Q }
C {devices/lab_pin.sym} 26460 -7440 0 0 {name=p26384 lab=_42224_/X }
C {devices/lab_pin.sym} 26620 -7500 0 1 {name=p26385 lab=_87963_/D }
C {sky130_stdcells/a2bb2o_4.sym} 26540 -7500 0 0 {name=X_42242_ }
C {devices/lab_pin.sym} 26480 -7380 0 0 {name=p26386 lab=_54208_/X }
C {devices/lab_pin.sym} 26480 -7340 0 0 {name=p26387 lab=_54237_/B }
C {devices/lab_pin.sym} 26480 -7300 0 0 {name=p26388 lab=_54237_/C }
C {devices/lab_pin.sym} 26480 -7260 0 0 {name=p26389 lab=_53058_/D }
C {devices/lab_pin.sym} 26600 -7320 0 1 {name=p26390 lab=_54228_/X }
C {sky130_stdcells/and4_4.sym} 26540 -7320 0 0 {name=X_54228_ }
C {devices/lab_pin.sym} 26500 -7170 0 0 {name=p26391 lab=_72806_/A }
C {devices/lab_pin.sym} 26580 -7170 0 1 {name=p26392 lab=_73062_/X }
C {sky130_stdcells/buf_2.sym} 26540 -7170 0 0 {name=X_73062_ }
C {devices/lab_pin.sym} 26450 -7050 0 0 {name=p26393 lab=_85083_/CLK }
C {devices/lab_pin.sym} 26450 -7030 0 0 {name=p26394 lab=_85048_/D }
C {devices/lab_pin.sym} 26630 -7050 0 1 {name=p26395 lab=_85048_/Q }
C {sky130_stdcells/dfxtp_4.sym} 26540 -7040 0 0 {name=X_85048_ }
C {devices/lab_pin.sym} 26460 -6930 0 0 {name=p26396 lab=_74788_/A }
C {devices/lab_pin.sym} 26460 -6890 0 0 {name=p26397 lab=_70157_/X }
C {devices/lab_pin.sym} 26460 -6850 0 0 {name=p26398 lab=_70273_/Y }
C {devices/lab_pin.sym} 26620 -6890 0 1 {name=p26399 lab=_83815_/D }
C {sky130_stdcells/o21ai_4.sym} 26540 -6890 0 0 {name=X_70274_ }
C {devices/lab_pin.sym} 26460 -6770 0 0 {name=p26400 lab=_83302_/Q }
C {devices/lab_pin.sym} 26460 -6730 0 0 {name=p26401 lab=_71985_/X }
C {devices/lab_pin.sym} 26460 -6690 0 0 {name=p26402 lab=_72012_/Y }
C {devices/lab_pin.sym} 26620 -6730 0 1 {name=p26403 lab=_72013_/Y }
C {sky130_stdcells/o21ai_4.sym} 26540 -6730 0 0 {name=X_72013_ }
C {devices/lab_pin.sym} 26460 -6610 0 0 {name=p26404 lab=_85493_/Q }
C {devices/lab_pin.sym} 26460 -6570 0 0 {name=p26405 lab=_54140_/X }
C {devices/lab_pin.sym} 26460 -6530 0 0 {name=p26406 lab=_54158_/Y }
C {devices/lab_pin.sym} 26620 -6570 0 1 {name=p26407 lab=_54159_/Y }
C {sky130_stdcells/o21ai_4.sym} 26540 -6570 0 0 {name=X_54159_ }
C {devices/lab_pin.sym} 26500 -6430 0 0 {name=p26408 lab=_42083_/A }
C {devices/lab_pin.sym} 26580 -6430 0 1 {name=p26409 lab=_42173_/X }
C {sky130_stdcells/buf_2.sym} 26540 -6430 0 0 {name=X_42173_ }
C {devices/lab_pin.sym} 26480 -6320 0 0 {name=p26410 lab=_82161_/Q }
C {devices/lab_pin.sym} 26480 -6280 0 0 {name=p26411 lab=_82033_/D }
C {devices/lab_pin.sym} 26600 -6300 0 1 {name=p26412 lab=_82129_/D }
C {sky130_stdcells/xor2_4.sym} 26540 -6300 0 0 {name=X_77870_ }
C {devices/lab_pin.sym} 26460 -6190 0 0 {name=p26413 lab=_41073_/X }
C {devices/lab_pin.sym} 26460 -6150 0 0 {name=p26414 lab=_40579_/A }
C {devices/lab_pin.sym} 26460 -6110 0 0 {name=p26415 lab=_41123_/X }
C {devices/lab_pin.sym} 26620 -6150 0 1 {name=p26416 lab=_41124_/X }
C {sky130_stdcells/o21a_4.sym} 26540 -6150 0 0 {name=X_41124_ }
C {devices/lab_pin.sym} 26480 -6020 0 0 {name=p26417 lab=_81637_/D }
C {devices/lab_pin.sym} 26480 -5980 0 0 {name=p26418 lab=_76821_/B }
C {devices/lab_pin.sym} 26600 -6000 0 1 {name=p26419 lab=_76821_/Y }
C {sky130_stdcells/xnor2_4.sym} 26540 -6000 0 0 {name=X_76821_ }
C {devices/lab_pin.sym} 26480 -5900 0 0 {name=p26420 lab=_46981_/A }
C {devices/lab_pin.sym} 26480 -5860 0 0 {name=p26421 lab=_46944_/B }
C {devices/lab_pin.sym} 26480 -5820 0 0 {name=p26422 lab=_46981_/C }
C {devices/lab_pin.sym} 26480 -5780 0 0 {name=p26423 lab=_52785_/D }
C {devices/lab_pin.sym} 26600 -5840 0 1 {name=p26424 lab=_46981_/X }
C {sky130_stdcells/and4_4.sym} 26540 -5840 0 0 {name=X_46981_ }
C {devices/lab_pin.sym} 26460 -5710 0 0 {name=p26425 lab=_58963_/Y }
C {devices/lab_pin.sym} 26460 -5670 0 0 {name=p26426 lab=_58965_/Y }
C {devices/lab_pin.sym} 26460 -5630 0 0 {name=p26427 lab=_58966_/X }
C {devices/lab_pin.sym} 26620 -5670 0 1 {name=p26428 lab=_58967_/X }
C {sky130_stdcells/a21o_4.sym} 26540 -5670 0 0 {name=X_58967_ }
C {devices/lab_pin.sym} 26450 -5530 0 0 {name=p26429 lab=_88363_/CLK }
C {devices/lab_pin.sym} 26450 -5510 0 0 {name=p26430 lab=_44692_/Y }
C {devices/lab_pin.sym} 26630 -5530 0 1 {name=p26431 lab=_44691_/A }
C {sky130_stdcells/dfxtp_4.sym} 26540 -5520 0 0 {name=X_86999_ }
C {devices/lab_pin.sym} 26460 -5410 0 0 {name=p26432 lab=_48718_/Y }
C {devices/lab_pin.sym} 26460 -5370 0 0 {name=p26433 lab=_48156_/X }
C {devices/lab_pin.sym} 26460 -5330 0 0 {name=p26434 lab=_48719_/X }
C {devices/lab_pin.sym} 26620 -5370 0 1 {name=p26435 lab=_86496_/D }
C {sky130_stdcells/a21oi_4.sym} 26540 -5370 0 0 {name=X_48720_ }
C {devices/lab_pin.sym} 26480 -5250 0 0 {name=p26436 lab=_79536_/Y }
C {devices/lab_pin.sym} 26480 -5210 0 0 {name=p26437 lab=_79544_/A }
C {devices/lab_pin.sym} 26480 -5170 0 0 {name=p26438 lab=_79540_/C }
C {devices/lab_pin.sym} 26600 -5210 0 1 {name=p26439 lab=_79546_/A }
C {sky130_stdcells/nand3_4.sym} 26540 -5210 0 0 {name=X_79540_ }
C {devices/lab_pin.sym} 26480 -5090 0 0 {name=p26440 lab=_45930_/X }
C {devices/lab_pin.sym} 26480 -5050 0 0 {name=p26441 lab=_72739_/A }
C {devices/lab_pin.sym} 26480 -5010 0 0 {name=p26442 lab=_45931_/X }
C {devices/lab_pin.sym} 26600 -5050 0 1 {name=p26443 lab=_45932_/Y }
C {sky130_stdcells/nand3_4.sym} 26540 -5050 0 0 {name=X_45932_ }
C {devices/lab_pin.sym} 26460 -4950 0 0 {name=p26444 lab=_41040_/X }
C {devices/lab_pin.sym} 26460 -4910 0 0 {name=p26445 lab=_41041_/X }
C {devices/lab_pin.sym} 26460 -4870 0 0 {name=p26446 lab=_41054_/X }
C {devices/lab_pin.sym} 26460 -4830 0 0 {name=p26447 lab=_69431_/B }
C {devices/lab_pin.sym} 26460 -4790 0 0 {name=p26448 lab=_41037_/X }
C {devices/lab_pin.sym} 26620 -4870 0 1 {name=p26449 lab=_41056_/A }
C {sky130_stdcells/o32ai_4.sym} 26540 -4870 0 0 {name=X_41055_ }
C {devices/lab_pin.sym} 26480 -4720 0 0 {name=p26450 lab=_57952_/A }
C {devices/lab_pin.sym} 26480 -4680 0 0 {name=p26451 lab=_57918_/B }
C {devices/lab_pin.sym} 26600 -4700 0 1 {name=p26452 lab=_57918_/Y }
C {sky130_stdcells/nor2_4.sym} 26540 -4700 0 0 {name=X_57918_ }
C {devices/lab_pin.sym} 26480 -4580 0 0 {name=p26453 lab=_76757_/B }
C {devices/lab_pin.sym} 26480 -4540 0 0 {name=p26454 lab=_76751_/Y }
C {devices/lab_pin.sym} 26600 -4560 0 1 {name=p26455 lab=_76753_/B }
C {sky130_stdcells/xnor2_4.sym} 26540 -4560 0 0 {name=X_76752_ }
C {devices/lab_pin.sym} 26460 -4460 0 0 {name=p26456 lab=_68802_/B }
C {devices/lab_pin.sym} 26460 -4420 0 0 {name=p26457 lab=_73891_/X }
C {devices/lab_pin.sym} 26460 -4380 0 0 {name=p26458 lab=_73962_/X }
C {devices/lab_pin.sym} 26460 -4340 0 0 {name=p26459 lab=_73963_/Y }
C {devices/lab_pin.sym} 26620 -4400 0 1 {name=p26460 lab=_73964_/X }
C {sky130_stdcells/a211o_4.sym} 26540 -4400 0 0 {name=X_73964_ }
C {devices/lab_pin.sym} 26480 -4260 0 0 {name=p26461 lab=_86695_/Q }
C {devices/lab_pin.sym} 26480 -4220 0 0 {name=p26462 lab=_58898_/B }
C {devices/lab_pin.sym} 26600 -4240 0 1 {name=p26463 lab=_58898_/Y }
C {sky130_stdcells/nor2_4.sym} 26540 -4240 0 0 {name=X_58898_ }
C {devices/lab_pin.sym} 26480 -4120 0 0 {name=p26464 lab=_75703_/A }
C {devices/lab_pin.sym} 26480 -4080 0 0 {name=p26465 lab=_75702_/Y }
C {devices/lab_pin.sym} 26600 -4100 0 1 {name=p26466 lab=_75704_/B }
C {sky130_stdcells/nand2_4.sym} 26540 -4100 0 0 {name=X_75703_ }
C {devices/lab_pin.sym} 26500 -3970 0 0 {name=p26467 lab=_48651_/A }
C {devices/lab_pin.sym} 26580 -3970 0 1 {name=p26468 lab=_48651_/X }
C {sky130_stdcells/buf_2.sym} 26540 -3970 0 0 {name=X_48651_ }
C {devices/lab_pin.sym} 26460 -3880 0 0 {name=p26469 lab=_56181_/X }
C {devices/lab_pin.sym} 26460 -3840 0 0 {name=p26470 lab=_83076_/Q }
C {devices/lab_pin.sym} 26460 -3800 0 0 {name=p26471 lab=_72880_/X }
C {devices/lab_pin.sym} 26460 -3760 0 0 {name=p26472 lab=_72914_/X }
C {devices/lab_pin.sym} 26620 -3820 0 1 {name=p26473 lab=_72916_/B }
C {sky130_stdcells/a211o_4.sym} 26540 -3820 0 0 {name=X_72915_ }
C {devices/lab_pin.sym} 26460 -3690 0 0 {name=p26474 lab=_79481_/A }
C {devices/lab_pin.sym} 26460 -3650 0 0 {name=p26475 lab=_79462_/Y }
C {devices/lab_pin.sym} 26460 -3610 0 0 {name=p26476 lab=_79470_/X }
C {devices/lab_pin.sym} 26620 -3650 0 1 {name=p26477 lab=_79471_/Y }
C {sky130_stdcells/o21ai_4.sym} 26540 -3650 0 0 {name=X_79471_ }
C {devices/lab_pin.sym} 26460 -3530 0 0 {name=p26478 lab=_45860_/X }
C {devices/lab_pin.sym} 26460 -3490 0 0 {name=p26479 lab=_45862_/Y }
C {devices/lab_pin.sym} 26460 -3450 0 0 {name=p26480 lab=_45803_/X }
C {devices/lab_pin.sym} 26620 -3490 0 1 {name=p26481 lab=_45863_/Y }
C {sky130_stdcells/a21oi_4.sym} 26540 -3490 0 0 {name=X_45863_ }
C {devices/lab_pin.sym} 26500 -3350 0 0 {name=p26482 lab=_58679_/A }
C {devices/lab_pin.sym} 26580 -3350 0 1 {name=p26483 lab=_57849_/X }
C {sky130_stdcells/buf_2.sym} 26540 -3350 0 0 {name=X_57849_ }
C {devices/lab_pin.sym} 26480 -3240 0 0 {name=p26484 lab=_81686_/Q }
C {devices/lab_pin.sym} 26480 -3200 0 0 {name=p26485 lab=_76683_/B }
C {devices/lab_pin.sym} 26600 -3220 0 1 {name=p26486 lab=_81350_/D }
C {sky130_stdcells/xor2_4.sym} 26540 -3220 0 0 {name=X_76683_ }
C {devices/lab_pin.sym} 26480 -3100 0 0 {name=p26487 lab=_73895_/A }
C {devices/lab_pin.sym} 26480 -3060 0 0 {name=p26488 lab=_73873_/B }
C {devices/lab_pin.sym} 26600 -3080 0 1 {name=p26489 lab=_73895_/Y }
C {sky130_stdcells/nor2_4.sym} 26540 -3080 0 0 {name=X_73895_ }
C {devices/lab_pin.sym} 26500 -2950 0 0 {name=p26490 lab=_47745_/A }
C {devices/lab_pin.sym} 26580 -2950 0 1 {name=p26491 lab=_47602_/X }
C {sky130_stdcells/buf_2.sym} 26540 -2950 0 0 {name=X_47602_ }
C {devices/lab_pin.sym} 26460 -2850 0 0 {name=p26492 lab=_78423_/A }
C {devices/lab_pin.sym} 26460 -2810 0 0 {name=p26493 lab=_78423_/C }
C {devices/lab_pin.sym} 26460 -2770 0 0 {name=p26494 lab=_78421_/Y }
C {devices/lab_pin.sym} 26620 -2810 0 1 {name=p26495 lab=_78422_/X }
C {sky130_stdcells/a21o_4.sym} 26540 -2810 0 0 {name=X_78422_ }
C {devices/lab_pin.sym} 26460 -2700 0 0 {name=p26496 lab=_41651_/A }
C {devices/lab_pin.sym} 26460 -2660 0 0 {name=p26497 lab=_43939_/X }
C {devices/lab_pin.sym} 26460 -2620 0 0 {name=p26498 lab=_67429_/B }
C {devices/lab_pin.sym} 26460 -2580 0 0 {name=p26499 lab=_43941_/X }
C {devices/lab_pin.sym} 26620 -2640 0 1 {name=p26500 lab=_86939_/D }
C {sky130_stdcells/a2bb2o_4.sym} 26540 -2640 0 0 {name=X_44814_ }
C {devices/lab_pin.sym} 26480 -2500 0 0 {name=p26501 lab=_75639_/B }
C {devices/lab_pin.sym} 26480 -2460 0 0 {name=p26502 lab=_75633_/Y }
C {devices/lab_pin.sym} 26600 -2480 0 1 {name=p26503 lab=_75635_/B }
C {sky130_stdcells/xor2_4.sym} 26540 -2480 0 0 {name=X_75634_ }
C {devices/lab_pin.sym} 26500 -2350 0 0 {name=p26504 lab=_48582_/A }
C {devices/lab_pin.sym} 26580 -2350 0 1 {name=p26505 lab=_48816_/B }
C {sky130_stdcells/buf_2.sym} 26540 -2350 0 0 {name=X_48582_ }
C {devices/lab_pin.sym} 26480 -2240 0 0 {name=p26506 lab=_61277_/B }
C {devices/lab_pin.sym} 26480 -2200 0 0 {name=p26507 lab=_61277_/C }
C {devices/lab_pin.sym} 26600 -2220 0 1 {name=p26508 lab=_61293_/A }
C {sky130_stdcells/nor2_4.sym} 26540 -2220 0 0 {name=X_60860_ }
C {devices/lab_pin.sym} 26480 -2100 0 0 {name=p26509 lab=_48391_/A }
C {devices/lab_pin.sym} 26480 -2060 0 0 {name=p26510 lab=_72846_/B }
C {devices/lab_pin.sym} 26600 -2080 0 1 {name=p26511 lab=_72846_/X }
C {sky130_stdcells/xor2_4.sym} 26540 -2080 0 0 {name=X_72846_ }
C {devices/lab_pin.sym} 26460 -1980 0 0 {name=p26512 lab=_45792_/Y }
C {devices/lab_pin.sym} 26460 -1940 0 0 {name=p26513 lab=_45394_/X }
C {devices/lab_pin.sym} 26460 -1900 0 0 {name=p26514 lab=_45720_/X }
C {devices/lab_pin.sym} 26460 -1860 0 0 {name=p26515 lab=_45793_/Y }
C {devices/lab_pin.sym} 26620 -1920 0 1 {name=p26516 lab=_45794_/X }
C {sky130_stdcells/a211o_4.sym} 26540 -1920 0 0 {name=X_45794_ }
C {devices/lab_pin.sym} 26480 -1800 0 0 {name=p26517 lab=_47530_/X }
C {devices/lab_pin.sym} 26480 -1760 0 0 {name=p26518 lab=_47549_/B }
C {devices/lab_pin.sym} 26480 -1720 0 0 {name=p26519 lab=_47519_/X }
C {devices/lab_pin.sym} 26480 -1680 0 0 {name=p26520 lab=_53103_/D }
C {devices/lab_pin.sym} 26600 -1740 0 1 {name=p26521 lab=_47533_/X }
C {sky130_stdcells/and4_4.sym} 26540 -1740 0 0 {name=X_47533_ }
C {devices/lab_pin.sym} 26480 -1610 0 0 {name=p26522 lab=_59557_/A }
C {devices/lab_pin.sym} 26480 -1570 0 0 {name=p26523 lab=_59562_/B }
C {devices/lab_pin.sym} 26480 -1530 0 0 {name=p26524 lab=_59519_/C }
C {devices/lab_pin.sym} 26600 -1570 0 1 {name=p26525 lab=_59520_/A }
C {sky130_stdcells/nand3_4.sym} 26540 -1570 0 0 {name=X_59519_ }
C {devices/lab_pin.sym} 26480 -1450 0 0 {name=p26526 lab=_78353_/A }
C {devices/lab_pin.sym} 26480 -1410 0 0 {name=p26527 lab=_78353_/B }
C {devices/lab_pin.sym} 26480 -1370 0 0 {name=p26528 lab=_78353_/C }
C {devices/lab_pin.sym} 26600 -1410 0 1 {name=p26529 lab=_78354_/B }
C {sky130_stdcells/nand3_4.sym} 26540 -1410 0 0 {name=X_78353_ }
C {devices/lab_pin.sym} 26500 -1270 0 0 {name=p26530 lab=_44745_/A }
C {devices/lab_pin.sym} 26580 -1270 0 1 {name=p26531 lab=_44745_/Y }
C {sky130_stdcells/inv_2.sym} 26540 -1270 0 0 {name=X_44745_ }
C {devices/lab_pin.sym} 26480 -1160 0 0 {name=p26532 lab=_81057_/D }
C {devices/lab_pin.sym} 26480 -1120 0 0 {name=p26533 lab=_75564_/Y }
C {devices/lab_pin.sym} 26600 -1140 0 1 {name=p26534 lab=_75567_/A }
C {sky130_stdcells/nand2_4.sym} 26540 -1140 0 0 {name=X_75565_ }
C {devices/lab_pin.sym} 26480 -1030 0 0 {name=p26535 lab=_60785_/Y }
C {devices/lab_pin.sym} 26480 -990 0 0 {name=p26536 lab=_60820_/A }
C {devices/lab_pin.sym} 26480 -950 0 0 {name=p26537 lab=_60708_/Y }
C {devices/lab_pin.sym} 26600 -990 0 1 {name=p26538 lab=_60791_/X }
C {sky130_stdcells/and3_4.sym} 26540 -990 0 0 {name=X_60791_ }
C {devices/lab_pin.sym} 26500 -850 0 0 {name=p26539 lab=_41957_/A }
C {devices/lab_pin.sym} 26580 -850 0 1 {name=p26540 lab=_41957_/Y }
C {sky130_stdcells/inv_2.sym} 26540 -850 0 0 {name=X_41957_ }
C {devices/lab_pin.sym} 26460 -750 0 0 {name=p26541 lab=_88338_/Q }
C {devices/lab_pin.sym} 26460 -710 0 0 {name=p26542 lab=_56939_/X }
C {devices/lab_pin.sym} 26460 -670 0 0 {name=p26543 lab=_72776_/X }
C {devices/lab_pin.sym} 26620 -710 0 1 {name=p26544 lab=_72777_/Y }
C {sky130_stdcells/o21ai_4.sym} 26540 -710 0 0 {name=X_72777_ }
C {devices/lab_pin.sym} 27400 -42160 0 0 {name=p26545 lab=_81927_/Q }
C {devices/lab_pin.sym} 27400 -42120 0 0 {name=p26546 lab=_82183_/D }
C {devices/lab_pin.sym} 27520 -42140 0 1 {name=p26547 lab=_81895_/D }
C {sky130_stdcells/xor2_4.sym} 27460 -42140 0 0 {name=X_77304_ }
C {devices/lab_pin.sym} 27420 -42010 0 0 {name=p26548 lab=_62198_/Y }
C {devices/lab_pin.sym} 27500 -42010 0 1 {name=p26549 lab=_62622_/A }
C {sky130_stdcells/buf_2.sym} 27460 -42010 0 0 {name=X_62530_ }
C {devices/lab_pin.sym} 27420 -41890 0 0 {name=p26550 lab=_74515_/X }
C {devices/lab_pin.sym} 27500 -41890 0 1 {name=p26551 lab=_74516_/X }
C {sky130_stdcells/buf_2.sym} 27460 -41890 0 0 {name=X_74516_ }
C {devices/lab_pin.sym} 27380 -41790 0 0 {name=p26552 lab=_40931_/A }
C {devices/lab_pin.sym} 27380 -41750 0 0 {name=p26553 lab=_41085_/A }
C {devices/lab_pin.sym} 27380 -41710 0 0 {name=p26554 lab=_40907_/X }
C {devices/lab_pin.sym} 27540 -41750 0 1 {name=p26555 lab=_40908_/X }
C {sky130_stdcells/o21a_4.sym} 27460 -41750 0 0 {name=X_40908_ }
C {devices/lab_pin.sym} 27420 -41610 0 0 {name=p26556 lab=_47464_/A }
C {devices/lab_pin.sym} 27500 -41610 0 1 {name=p26557 lab=_47465_/A }
C {sky130_stdcells/inv_2.sym} 27460 -41610 0 0 {name=X_47464_ }
C {devices/lab_pin.sym} 27380 -41510 0 0 {name=p26558 lab=_58233_/Y }
C {devices/lab_pin.sym} 27380 -41470 0 0 {name=p26559 lab=_71718_/X }
C {devices/lab_pin.sym} 27380 -41430 0 0 {name=p26560 lab=_71727_/Y }
C {devices/lab_pin.sym} 27540 -41470 0 1 {name=p26561 lab=_71728_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -41470 0 0 {name=X_71728_ }
C {devices/lab_pin.sym} 27400 -41350 0 0 {name=p26562 lab=_78282_/X }
C {devices/lab_pin.sym} 27400 -41310 0 0 {name=p26563 lab=_78284_/B }
C {devices/lab_pin.sym} 27400 -41270 0 0 {name=p26564 lab=_78283_/Y }
C {devices/lab_pin.sym} 27520 -41310 0 1 {name=p26565 lab=_78284_/X }
C {sky130_stdcells/and3_4.sym} 27460 -41310 0 0 {name=X_78284_ }
C {devices/lab_pin.sym} 27380 -41210 0 0 {name=p26566 lab=_44593_/X }
C {devices/lab_pin.sym} 27380 -41170 0 0 {name=p26567 lab=_44594_/X }
C {devices/lab_pin.sym} 27380 -41130 0 0 {name=p26568 lab=_40590_/A }
C {devices/lab_pin.sym} 27380 -41090 0 0 {name=p26569 lab=_44675_/Y }
C {devices/lab_pin.sym} 27380 -41050 0 0 {name=p26570 lab=_44596_/X }
C {devices/lab_pin.sym} 27540 -41130 0 1 {name=p26571 lab=_87004_/D }
C {sky130_stdcells/o32ai_4.sym} 27460 -41130 0 0 {name=X_44676_ }
C {devices/lab_pin.sym} 27400 -40980 0 0 {name=p26572 lab=_80702_/Q }
C {devices/lab_pin.sym} 27400 -40940 0 0 {name=p26573 lab=_80958_/D }
C {devices/lab_pin.sym} 27520 -40960 0 1 {name=p26574 lab=_75497_/A }
C {sky130_stdcells/nand2_4.sym} 27460 -40960 0 0 {name=X_75496_ }
C {devices/lab_pin.sym} 27420 -40830 0 0 {name=p26575 lab=_42547_/A }
C {devices/lab_pin.sym} 27500 -40830 0 1 {name=p26576 lab=_41888_/X }
C {sky130_stdcells/buf_2.sym} 27460 -40830 0 0 {name=X_41888_ }
C {devices/lab_pin.sym} 27380 -40730 0 0 {name=p26577 lab=_49198_/Y }
C {devices/lab_pin.sym} 27380 -40690 0 0 {name=p26578 lab=_49189_/X }
C {devices/lab_pin.sym} 27380 -40650 0 0 {name=p26579 lab=_49202_/X }
C {devices/lab_pin.sym} 27540 -40690 0 1 {name=p26580 lab=_86434_/D }
C {sky130_stdcells/a21oi_4.sym} 27460 -40690 0 0 {name=X_49203_ }
C {devices/lab_pin.sym} 27380 -40570 0 0 {name=p26581 lab=_46403_/X }
C {devices/lab_pin.sym} 27380 -40530 0 0 {name=p26582 lab=_49029_/A }
C {devices/lab_pin.sym} 27380 -40490 0 0 {name=p26583 lab=_46414_/X }
C {devices/lab_pin.sym} 27540 -40530 0 1 {name=p26584 lab=_46416_/A }
C {sky130_stdcells/o21ai_4.sym} 27460 -40530 0 0 {name=X_46415_ }
C {devices/lab_pin.sym} 27400 -40400 0 0 {name=p26585 lab=_81922_/Q }
C {devices/lab_pin.sym} 27400 -40360 0 0 {name=p26586 lab=_82178_/D }
C {devices/lab_pin.sym} 27520 -40380 0 1 {name=p26587 lab=_77235_/X }
C {sky130_stdcells/xor2_4.sym} 27460 -40380 0 0 {name=X_77235_ }
C {devices/lab_pin.sym} 27420 -40250 0 0 {name=p26588 lab=_87335_/Q }
C {devices/lab_pin.sym} 27500 -40250 0 1 {name=p26589 lab=_68672_/B }
C {sky130_stdcells/inv_2.sym} 27460 -40250 0 0 {name=X_43627_ }
C {devices/lab_pin.sym} 27400 -40160 0 0 {name=p26590 lab=_62493_/A }
C {devices/lab_pin.sym} 27400 -40120 0 0 {name=p26591 lab=_62458_/Y }
C {devices/lab_pin.sym} 27400 -40080 0 0 {name=p26592 lab=_62461_/C }
C {devices/lab_pin.sym} 27400 -40040 0 0 {name=p26593 lab=_62461_/D }
C {devices/lab_pin.sym} 27520 -40100 0 1 {name=p26594 lab=_62461_/Y }
C {sky130_stdcells/nand4_4.sym} 27460 -40100 0 0 {name=X_62461_ }
C {devices/lab_pin.sym} 27400 -39960 0 0 {name=p26595 lab=_74466_/A }
C {devices/lab_pin.sym} 27400 -39920 0 0 {name=p26596 lab=_48550_/Y }
C {devices/lab_pin.sym} 27520 -39940 0 1 {name=p26597 lab=_74447_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -39940 0 0 {name=X_74447_ }
C {devices/lab_pin.sym} 27420 -39810 0 0 {name=p26598 lab=_40839_/A }
C {devices/lab_pin.sym} 27500 -39810 0 1 {name=p26599 lab=_40839_/X }
C {sky130_stdcells/buf_2.sym} 27460 -39810 0 0 {name=X_40839_ }
C {devices/lab_pin.sym} 27420 -39690 0 0 {name=p26600 lab=_47394_/Y }
C {devices/lab_pin.sym} 27500 -39690 0 1 {name=p26601 lab=_53021_/B }
C {sky130_stdcells/buf_2.sym} 27460 -39690 0 0 {name=X_47395_ }
C {devices/lab_pin.sym} 27380 -39590 0 0 {name=p26602 lab=_58513_/Y }
C {devices/lab_pin.sym} 27380 -39550 0 0 {name=p26603 lab=_71649_/X }
C {devices/lab_pin.sym} 27380 -39510 0 0 {name=p26604 lab=_71658_/Y }
C {devices/lab_pin.sym} 27540 -39550 0 1 {name=p26605 lab=_71659_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -39550 0 0 {name=X_71659_ }
C {devices/lab_pin.sym} 27400 -39430 0 0 {name=p26606 lab=_64490_/A }
C {devices/lab_pin.sym} 27400 -39390 0 0 {name=p26607 lab=_64490_/B }
C {devices/lab_pin.sym} 27400 -39350 0 0 {name=p26608 lab=_64200_/C }
C {devices/lab_pin.sym} 27520 -39390 0 1 {name=p26609 lab=_64200_/Y }
C {sky130_stdcells/nor3_4.sym} 27460 -39390 0 0 {name=X_64200_ }
C {devices/lab_pin.sym} 27420 -39250 0 0 {name=p26610 lab=clkbuf_6_62_0_CLK/X }
C {devices/lab_pin.sym} 27500 -39250 0 1 {name=p26611 lab=clkbuf_8_249_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 27460 -39250 0 0 {name=Xclkbuf_7_124_0_CLK }
C {devices/lab_pin.sym} 27420 -39130 0 0 {name=p26612 lab=_83600_/Q }
C {devices/lab_pin.sym} 27500 -39130 0 1 {name=p26613 lab=_49135_/A }
C {sky130_stdcells/inv_2.sym} 27460 -39130 0 0 {name=X_49134_ }
C {devices/lab_pin.sym} 27420 -39010 0 0 {name=p26614 lab=_61412_/A }
C {devices/lab_pin.sym} 27500 -39010 0 1 {name=p26615 lab=_61413_/A }
C {sky130_stdcells/buf_2.sym} 27460 -39010 0 0 {name=X_61412_ }
C {devices/lab_pin.sym} 27420 -38890 0 0 {name=p26616 lab=_46258_/A }
C {devices/lab_pin.sym} 27500 -38890 0 1 {name=p26617 lab=_46346_/X }
C {sky130_stdcells/buf_2.sym} 27460 -38890 0 0 {name=X_46346_ }
C {devices/lab_pin.sym} 27380 -38800 0 0 {name=p26618 lab=_65178_/X }
C {devices/lab_pin.sym} 27380 -38760 0 0 {name=p26619 lab=_86731_/Q }
C {devices/lab_pin.sym} 27380 -38720 0 0 {name=p26620 lab=_65108_/X }
C {devices/lab_pin.sym} 27380 -38680 0 0 {name=p26621 lab=_65179_/X }
C {devices/lab_pin.sym} 27540 -38740 0 1 {name=p26622 lab=_65180_/X }
C {sky130_stdcells/a211o_4.sym} 27460 -38740 0 0 {name=X_65180_ }
C {devices/lab_pin.sym} 27380 -38610 0 0 {name=p26623 lab=_77174_/B }
C {devices/lab_pin.sym} 27380 -38570 0 0 {name=p26624 lab=_81920_/Q }
C {devices/lab_pin.sym} 27380 -38530 0 0 {name=p26625 lab=_77165_/Y }
C {devices/lab_pin.sym} 27540 -38570 0 1 {name=p26626 lab=_77167_/B }
C {sky130_stdcells/a21oi_4.sym} 27460 -38570 0 0 {name=X_77166_ }
C {devices/lab_pin.sym} 27380 -38470 0 0 {name=p26627 lab=_43557_/X }
C {devices/lab_pin.sym} 27380 -38430 0 0 {name=p26628 lab=_43546_/X }
C {devices/lab_pin.sym} 27380 -38390 0 0 {name=p26629 lab=_40480_/X }
C {devices/lab_pin.sym} 27380 -38350 0 0 {name=p26630 lab=_87361_/Q }
C {devices/lab_pin.sym} 27380 -38310 0 0 {name=p26631 lab=_43549_/X }
C {devices/lab_pin.sym} 27540 -38390 0 1 {name=p26632 lab=_43558_/Y }
C {sky130_stdcells/o32ai_4.sym} 27460 -38390 0 0 {name=X_43558_ }
C {devices/lab_pin.sym} 27420 -38230 0 0 {name=p26633 lab=_57563_/X }
C {devices/lab_pin.sym} 27500 -38230 0 1 {name=p26634 lab=_74408_/A }
C {sky130_stdcells/buf_2.sym} 27460 -38230 0 0 {name=X_74378_ }
C {devices/lab_pin.sym} 27400 -38140 0 0 {name=p26635 lab=_62337_/A }
C {devices/lab_pin.sym} 27400 -38100 0 0 {name=p26636 lab=_61922_/X }
C {devices/lab_pin.sym} 27400 -38060 0 0 {name=p26637 lab=_62364_/X }
C {devices/lab_pin.sym} 27400 -38020 0 0 {name=p26638 lab=_62392_/D }
C {devices/lab_pin.sym} 27520 -38080 0 1 {name=p26639 lab=_62392_/X }
C {sky130_stdcells/and4_4.sym} 27460 -38080 0 0 {name=X_62392_ }
C {devices/lab_pin.sym} 27400 -37940 0 0 {name=p26640 lab=_76126_/A }
C {devices/lab_pin.sym} 27400 -37900 0 0 {name=p26641 lab=_76127_/B }
C {devices/lab_pin.sym} 27520 -37920 0 1 {name=p26642 lab=_76117_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -37920 0 0 {name=X_76117_ }
C {devices/lab_pin.sym} 27380 -37810 0 0 {name=p26643 lab=_64128_/X }
C {devices/lab_pin.sym} 27380 -37770 0 0 {name=p26644 lab=_64129_/X }
C {devices/lab_pin.sym} 27380 -37730 0 0 {name=p26645 lab=_64130_/Y }
C {devices/lab_pin.sym} 27540 -37770 0 1 {name=p26646 lab=_84272_/D }
C {sky130_stdcells/a21oi_4.sym} 27460 -37770 0 0 {name=X_64131_ }
C {devices/lab_pin.sym} 27420 -37630 0 0 {name=p26647 lab=_74005_/A }
C {devices/lab_pin.sym} 27500 -37630 0 1 {name=p26648 lab=_42509_/Y }
C {sky130_stdcells/inv_2.sym} 27460 -37630 0 0 {name=X_42509_ }
C {devices/lab_pin.sym} 27400 -37520 0 0 {name=p26649 lab=_49056_/A }
C {devices/lab_pin.sym} 27400 -37480 0 0 {name=p26650 lab=_50144_/B }
C {devices/lab_pin.sym} 27520 -37500 0 1 {name=p26651 lab=_49065_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -37500 0 0 {name=X_49065_ }
C {devices/lab_pin.sym} 27400 -37380 0 0 {name=p26652 lab=_73495_/A }
C {devices/lab_pin.sym} 27400 -37340 0 0 {name=p26653 lab=_85867_/Q }
C {devices/lab_pin.sym} 27520 -37360 0 1 {name=p26654 lab=_73329_/X }
C {sky130_stdcells/and2_4.sym} 27460 -37360 0 0 {name=X_73329_ }
C {devices/lab_pin.sym} 27420 -37230 0 0 {name=p26655 lab=_61342_/X }
C {devices/lab_pin.sym} 27500 -37230 0 1 {name=p26656 lab=_61368_/D }
C {sky130_stdcells/buf_2.sym} 27460 -37230 0 0 {name=X_61343_ }
C {devices/lab_pin.sym} 27420 -37110 0 0 {name=p26657 lab=clkbuf_9_47_0_CLK/X }
C {devices/lab_pin.sym} 27500 -37110 0 1 {name=p26658 lab=_84915_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 27460 -37110 0 0 {name=Xclkbuf_10_94_0_CLK }
C {devices/lab_pin.sym} 27400 -37000 0 0 {name=p26659 lab=_46288_/A }
C {devices/lab_pin.sym} 27400 -36960 0 0 {name=p26660 lab=_53953_/B }
C {devices/lab_pin.sym} 27520 -36980 0 1 {name=p26661 lab=_46277_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -36980 0 0 {name=X_46277_ }
C {devices/lab_pin.sym} 27400 -36860 0 0 {name=p26662 lab=_77097_/A }
C {devices/lab_pin.sym} 27400 -36820 0 0 {name=p26663 lab=_77097_/B }
C {devices/lab_pin.sym} 27520 -36840 0 1 {name=p26664 lab=_77097_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -36840 0 0 {name=X_77097_ }
C {devices/lab_pin.sym} 27380 -36750 0 0 {name=p26665 lab=_43472_/X }
C {devices/lab_pin.sym} 27380 -36710 0 0 {name=p26666 lab=_43475_/X }
C {devices/lab_pin.sym} 27380 -36670 0 0 {name=p26667 lab=_41710_/X }
C {devices/lab_pin.sym} 27380 -36630 0 0 {name=p26668 lab=_87396_/Q }
C {devices/lab_pin.sym} 27380 -36590 0 0 {name=p26669 lab=_43479_/X }
C {devices/lab_pin.sym} 27540 -36670 0 1 {name=p26670 lab=_43490_/A }
C {sky130_stdcells/o32ai_4.sym} 27460 -36670 0 0 {name=X_43489_ }
C {devices/lab_pin.sym} 27400 -36520 0 0 {name=p26671 lab=_48004_/A }
C {devices/lab_pin.sym} 27400 -36480 0 0 {name=p26672 lab=_48016_/B }
C {devices/lab_pin.sym} 27520 -36500 0 1 {name=p26673 lab=_48016_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -36500 0 0 {name=X_48016_ }
C {devices/lab_pin.sym} 27420 -36370 0 0 {name=p26674 lab=clkbuf_8_241_0_CLK/A }
C {devices/lab_pin.sym} 27500 -36370 0 1 {name=p26675 lab=clkbuf_8_240_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 27460 -36370 0 0 {name=Xclkbuf_8_240_0_CLK }
C {devices/lab_pin.sym} 27420 -36250 0 0 {name=p26676 lab=_80672_/Q }
C {devices/lab_pin.sym} 27500 -36250 0 1 {name=p26677 lab=_45651_/A }
C {sky130_stdcells/buf_2.sym} 27460 -36250 0 0 {name=X_45228_ }
C {devices/lab_pin.sym} 27420 -36130 0 0 {name=p26678 lab=_60906_/X }
C {devices/lab_pin.sym} 27500 -36130 0 1 {name=p26679 lab=_64158_/C }
C {sky130_stdcells/buf_2.sym} 27460 -36130 0 0 {name=X_64062_ }
C {devices/lab_pin.sym} 27400 -36020 0 0 {name=p26680 lab=_76039_/B }
C {devices/lab_pin.sym} 27400 -35980 0 0 {name=p26681 lab=_76048_/B }
C {devices/lab_pin.sym} 27520 -36000 0 1 {name=p26682 lab=_76048_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -36000 0 0 {name=X_76048_ }
C {devices/lab_pin.sym} 27400 -35890 0 0 {name=p26683 lab=_61262_/A }
C {devices/lab_pin.sym} 27400 -35850 0 0 {name=p26684 lab=_72544_/B }
C {devices/lab_pin.sym} 27400 -35810 0 0 {name=p26685 lab=_84490_/Q }
C {devices/lab_pin.sym} 27520 -35850 0 1 {name=p26686 lab=_61274_/Y }
C {sky130_stdcells/nor3_4.sym} 27460 -35850 0 0 {name=X_61274_ }
C {devices/lab_pin.sym} 27420 -35710 0 0 {name=p26687 lab=_60383_/A }
C {devices/lab_pin.sym} 27500 -35710 0 1 {name=p26688 lab=_63014_/D }
C {sky130_stdcells/buf_2.sym} 27460 -35710 0 0 {name=X_63013_ }
C {devices/lab_pin.sym} 27420 -35590 0 0 {name=p26689 lab=_60291_/C }
C {devices/lab_pin.sym} 27500 -35590 0 1 {name=p26690 lab=_60255_/B }
C {sky130_stdcells/buf_2.sym} 27460 -35590 0 0 {name=X_60225_ }
C {devices/lab_pin.sym} 27380 -35490 0 0 {name=p26691 lab=_45127_/X }
C {devices/lab_pin.sym} 27380 -35450 0 0 {name=p26692 lab=_61521_/B }
C {devices/lab_pin.sym} 27380 -35410 0 0 {name=p26693 lab=_45144_/X }
C {devices/lab_pin.sym} 27540 -35450 0 1 {name=p26694 lab=_45159_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -35450 0 0 {name=X_45159_ }
C {devices/lab_pin.sym} 27420 -35310 0 0 {name=p26695 lab=_68757_/A }
C {devices/lab_pin.sym} 27500 -35310 0 1 {name=p26696 lab=_68870_/X }
C {sky130_stdcells/buf_2.sym} 27460 -35310 0 0 {name=X_68870_ }
C {devices/lab_pin.sym} 27400 -35200 0 0 {name=p26697 lab=_79807_/A }
C {devices/lab_pin.sym} 27400 -35160 0 0 {name=p26698 lab=_79807_/B }
C {devices/lab_pin.sym} 27520 -35180 0 1 {name=p26699 lab=_79820_/B }
C {sky130_stdcells/xnor2_4.sym} 27460 -35180 0 0 {name=X_79807_ }
C {devices/lab_pin.sym} 27420 -35050 0 0 {name=p26700 lab=_68450_/A }
C {devices/lab_pin.sym} 27500 -35050 0 1 {name=p26701 lab=_67821_/X }
C {sky130_stdcells/buf_2.sym} 27460 -35050 0 0 {name=X_67821_ }
C {devices/lab_pin.sym} 27420 -34930 0 0 {name=p26702 lab=_60193_/A }
C {devices/lab_pin.sym} 27500 -34930 0 1 {name=p26703 lab=_60156_/Y }
C {sky130_stdcells/inv_2.sym} 27460 -34930 0 0 {name=X_60156_ }
C {devices/lab_pin.sym} 27380 -34830 0 0 {name=p26704 lab=_72301_/B }
C {devices/lab_pin.sym} 27380 -34790 0 0 {name=p26705 lab=_49960_/X }
C {devices/lab_pin.sym} 27380 -34750 0 0 {name=p26706 lab=_49966_/Y }
C {devices/lab_pin.sym} 27540 -34790 0 1 {name=p26707 lab=_49967_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -34790 0 0 {name=X_49967_ }
C {devices/lab_pin.sym} 27400 -34660 0 0 {name=p26708 lab=_77999_/A }
C {devices/lab_pin.sym} 27400 -34620 0 0 {name=p26709 lab=_77999_/B }
C {devices/lab_pin.sym} 27520 -34640 0 1 {name=p26710 lab=_78000_/A }
C {sky130_stdcells/nor2_4.sym} 27460 -34640 0 0 {name=X_77999_ }
C {devices/lab_pin.sym} 27420 -34510 0 0 {name=p26711 lab=clkbuf_8_255_0_CLK/A }
C {devices/lab_pin.sym} 27500 -34510 0 1 {name=p26712 lab=clkbuf_9_510_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 27460 -34510 0 0 {name=Xclkbuf_8_255_0_CLK }
C {devices/lab_pin.sym} 27420 -34390 0 0 {name=p26713 lab=clkbuf_9_125_0_CLK/X }
C {devices/lab_pin.sym} 27500 -34390 0 1 {name=p26714 lab=_81872_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 27460 -34390 0 0 {name=Xclkbuf_10_250_0_CLK }
C {devices/lab_pin.sym} 27380 -34290 0 0 {name=p26715 lab=_50578_/A }
C {devices/lab_pin.sym} 27380 -34250 0 0 {name=p26716 lab=_50578_/B }
C {devices/lab_pin.sym} 27380 -34210 0 0 {name=p26717 lab=_48917_/X }
C {devices/lab_pin.sym} 27540 -34250 0 1 {name=p26718 lab=_48918_/X }
C {sky130_stdcells/o21a_4.sym} 27460 -34250 0 0 {name=X_48918_ }
C {devices/lab_pin.sym} 27400 -34120 0 0 {name=p26719 lab=_67678_/X }
C {devices/lab_pin.sym} 27400 -34080 0 0 {name=p26720 lab=_67752_/B }
C {devices/lab_pin.sym} 27520 -34100 0 1 {name=p26721 lab=_67752_/X }
C {sky130_stdcells/and2_4.sym} 27460 -34100 0 0 {name=X_67752_ }
C {devices/lab_pin.sym} 27400 -33980 0 0 {name=p26722 lab=_79735_/X }
C {devices/lab_pin.sym} 27400 -33940 0 0 {name=p26723 lab=_79737_/Y }
C {devices/lab_pin.sym} 27520 -33960 0 1 {name=p26724 lab=_79738_/Y }
C {sky130_stdcells/xnor2_4.sym} 27460 -33960 0 0 {name=X_79738_ }
C {devices/lab_pin.sym} 27380 -33860 0 0 {name=p26725 lab=_64934_/X }
C {devices/lab_pin.sym} 27380 -33820 0 0 {name=p26726 lab=_86740_/Q }
C {devices/lab_pin.sym} 27380 -33780 0 0 {name=p26727 lab=_64864_/X }
C {devices/lab_pin.sym} 27380 -33740 0 0 {name=p26728 lab=_64963_/X }
C {devices/lab_pin.sym} 27540 -33800 0 1 {name=p26729 lab=_64964_/X }
C {sky130_stdcells/a211o_4.sym} 27460 -33800 0 0 {name=X_64964_ }
C {devices/lab_pin.sym} 27380 -33670 0 0 {name=p26730 lab=_62548_/B }
C {devices/lab_pin.sym} 27380 -33630 0 0 {name=p26731 lab=_62576_/C }
C {devices/lab_pin.sym} 27380 -33590 0 0 {name=p26732 lab=_70056_/A }
C {devices/lab_pin.sym} 27540 -33630 0 1 {name=p26733 lab=_60087_/Y }
C {sky130_stdcells/a21oi_4.sym} 27460 -33630 0 0 {name=X_60087_ }
C {devices/lab_pin.sym} 27420 -33490 0 0 {name=p26734 lab=_49925_/A }
C {devices/lab_pin.sym} 27500 -33490 0 1 {name=p26735 lab=_49904_/A }
C {sky130_stdcells/buf_2.sym} 27460 -33490 0 0 {name=X_49898_ }
C {devices/lab_pin.sym} 27420 -33370 0 0 {name=p26736 lab=clkbuf_9_440_0_CLK/X }
C {devices/lab_pin.sym} 27500 -33370 0 1 {name=p26737 lab=_86733_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 27460 -33370 0 0 {name=Xclkbuf_10_880_0_CLK }
C {devices/lab_pin.sym} 27420 -33250 0 0 {name=p26738 lab=_68474_/A }
C {devices/lab_pin.sym} 27500 -33250 0 1 {name=p26739 lab=_66728_/A }
C {sky130_stdcells/buf_2.sym} 27460 -33250 0 0 {name=X_66703_ }
C {devices/lab_pin.sym} 27380 -33150 0 0 {name=p26740 lab=_63911_/X }
C {devices/lab_pin.sym} 27380 -33110 0 0 {name=p26741 lab=_63913_/X }
C {devices/lab_pin.sym} 27380 -33070 0 0 {name=p26742 lab=_63914_/Y }
C {devices/lab_pin.sym} 27540 -33110 0 1 {name=p26743 lab=_84287_/D }
C {sky130_stdcells/a21oi_4.sym} 27460 -33110 0 0 {name=X_63915_ }
C {devices/lab_pin.sym} 27420 -32970 0 0 {name=p26744 lab=clkbuf_9_16_0_CLK/X }
C {devices/lab_pin.sym} 27500 -32970 0 1 {name=p26745 lab=_85152_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 27460 -32970 0 0 {name=Xclkbuf_10_32_0_CLK }
C {devices/lab_pin.sym} 27400 -32870 0 0 {name=p26746 lab=_48849_/A }
C {devices/lab_pin.sym} 27400 -32830 0 0 {name=p26747 lab=_48849_/B }
C {devices/lab_pin.sym} 27400 -32790 0 0 {name=p26748 lab=_48849_/C }
C {devices/lab_pin.sym} 27520 -32830 0 1 {name=p26749 lab=_48849_/X }
C {sky130_stdcells/and3_4.sym} 27460 -32830 0 0 {name=X_48849_ }
C {devices/lab_pin.sym} 27400 -32700 0 0 {name=p26750 lab=_67658_/X }
C {devices/lab_pin.sym} 27400 -32660 0 0 {name=p26751 lab=_67683_/B }
C {devices/lab_pin.sym} 27520 -32680 0 1 {name=p26752 lab=_67683_/X }
C {sky130_stdcells/and2_4.sym} 27460 -32680 0 0 {name=X_67683_ }
C {devices/lab_pin.sym} 27380 -32570 0 0 {name=p26753 lab=_65170_/C }
C {devices/lab_pin.sym} 27380 -32530 0 0 {name=p26754 lab=_72371_/Y }
C {devices/lab_pin.sym} 27380 -32490 0 0 {name=p26755 lab=_79668_/Y }
C {devices/lab_pin.sym} 27540 -32530 0 1 {name=p26756 lab=_79669_/X }
C {sky130_stdcells/o21a_4.sym} 27460 -32530 0 0 {name=X_79669_ }
C {devices/lab_pin.sym} 27400 -32400 0 0 {name=p26757 lab=_65836_/A }
C {devices/lab_pin.sym} 27400 -32360 0 0 {name=p26758 lab=_86038_/Q }
C {devices/lab_pin.sym} 27520 -32380 0 1 {name=p26759 lab=_64895_/X }
C {sky130_stdcells/and2_4.sym} 27460 -32380 0 0 {name=X_64895_ }
C {devices/lab_pin.sym} 27420 -32250 0 0 {name=p26760 lab=clkbuf_9_370_0_CLK/A }
C {devices/lab_pin.sym} 27500 -32250 0 1 {name=p26761 lab=clkbuf_9_371_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 27460 -32250 0 0 {name=Xclkbuf_9_371_0_CLK }
C {devices/lab_pin.sym} 27370 -32130 0 0 {name=p26762 lab=_84014_/CLK }
C {devices/lab_pin.sym} 27370 -32110 0 0 {name=p26763 lab=_81700_/D }
C {devices/lab_pin.sym} 27550 -32130 0 1 {name=p26764 lab=_41096_/B }
C {sky130_stdcells/dfxtp_4.sym} 27460 -32120 0 0 {name=X_81700_ }
C {devices/lab_pin.sym} 27420 -31990 0 0 {name=p26765 lab=_64636_/A }
C {devices/lab_pin.sym} 27500 -31990 0 1 {name=p26766 lab=_69746_/A }
C {sky130_stdcells/buf_2.sym} 27460 -31990 0 0 {name=X_69422_ }
C {devices/lab_pin.sym} 27400 -31880 0 0 {name=p26767 lab=_66683_/A }
C {devices/lab_pin.sym} 27400 -31840 0 0 {name=p26768 lab=_66634_/B }
C {devices/lab_pin.sym} 27520 -31860 0 1 {name=p26769 lab=_66634_/X }
C {sky130_stdcells/and2_4.sym} 27460 -31860 0 0 {name=X_66634_ }
C {devices/lab_pin.sym} 27400 -31760 0 0 {name=p26770 lab=_51870_/A }
C {devices/lab_pin.sym} 27400 -31720 0 0 {name=p26771 lab=_51851_/B }
C {devices/lab_pin.sym} 27400 -31680 0 0 {name=p26772 lab=_51851_/C }
C {devices/lab_pin.sym} 27400 -31640 0 0 {name=p26773 lab=_46810_/X }
C {devices/lab_pin.sym} 27520 -31700 0 1 {name=p26774 lab=_51860_/X }
C {sky130_stdcells/and4_4.sym} 27460 -31700 0 0 {name=X_51860_ }
C {devices/lab_pin.sym} 27400 -31570 0 0 {name=p26775 lab=_63831_/A }
C {devices/lab_pin.sym} 27400 -31530 0 0 {name=p26776 lab=_64282_/A }
C {devices/lab_pin.sym} 27400 -31490 0 0 {name=p26777 lab=_63862_/C }
C {devices/lab_pin.sym} 27520 -31530 0 1 {name=p26778 lab=_63846_/X }
C {sky130_stdcells/and3_4.sym} 27460 -31530 0 0 {name=X_63846_ }
C {devices/lab_pin.sym} 27370 -31390 0 0 {name=p26779 lab=_81216_/CLK }
C {devices/lab_pin.sym} 27370 -31370 0 0 {name=p26780 lab=_82692_/Q }
C {devices/lab_pin.sym} 27550 -31390 0 1 {name=p26781 lab=_78240_/A }
C {sky130_stdcells/dfxtp_4.sym} 27460 -31380 0 0 {name=X_82680_ }
C {devices/lab_pin.sym} 27420 -31250 0 0 {name=p26782 lab=clkbuf_9_132_0_CLK/X }
C {devices/lab_pin.sym} 27500 -31250 0 1 {name=p26783 lab=_84869_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 27460 -31250 0 0 {name=Xclkbuf_10_265_0_CLK }
C {devices/lab_pin.sym} 27380 -31150 0 0 {name=p26784 lab=_86128_/Q }
C {devices/lab_pin.sym} 27380 -31110 0 0 {name=p26785 lab=_50727_/X }
C {devices/lab_pin.sym} 27380 -31070 0 0 {name=p26786 lab=_50810_/Y }
C {devices/lab_pin.sym} 27540 -31110 0 1 {name=p26787 lab=_50811_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -31110 0 0 {name=X_50811_ }
C {devices/lab_pin.sym} 27370 -30970 0 0 {name=p26788 lab=_81631_/CLK }
C {devices/lab_pin.sym} 27370 -30950 0 0 {name=p26789 lab=_81631_/D }
C {devices/lab_pin.sym} 27550 -30970 0 1 {name=p26790 lab=_81631_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -30960 0 0 {name=X_81631_ }
C {devices/lab_pin.sym} 27380 -30850 0 0 {name=p26791 lab=_83930_/Q }
