C {devices/lab_pin.sym} 44850 -17830 0 0 {name=p44457 lab=_57262_/X }
C {devices/lab_pin.sym} 45030 -17850 0 1 {name=p44458 lab=_45600_/A }
C {sky130_stdcells/dfxtp_4.sym} 44940 -17840 0 0 {name=X_85044_ }
C {devices/lab_pin.sym} 44860 -17730 0 0 {name=p44459 lab=_86010_/Q }
C {devices/lab_pin.sym} 44860 -17690 0 0 {name=p44460 lab=_51429_/X }
C {devices/lab_pin.sym} 44860 -17650 0 0 {name=p44461 lab=_51435_/Y }
C {devices/lab_pin.sym} 45020 -17690 0 1 {name=p44462 lab=_51436_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -17690 0 0 {name=X_51436_ }
C {devices/lab_pin.sym} 44880 -17580 0 0 {name=p44463 lab=_70267_/A }
C {devices/lab_pin.sym} 44880 -17540 0 0 {name=p44464 lab=_70267_/B }
C {devices/lab_pin.sym} 44880 -17500 0 0 {name=p44465 lab=_83112_/Q }
C {devices/lab_pin.sym} 44880 -17460 0 0 {name=p44466 lab=_70264_/X }
C {devices/lab_pin.sym} 45000 -17520 0 1 {name=p44467 lab=_70270_/X }
C {sky130_stdcells/and4_4.sym} 44940 -17520 0 0 {name=X_70270_ }
C {devices/lab_pin.sym} 44850 -17370 0 0 {name=p44468 lab=_85381_/CLK }
C {devices/lab_pin.sym} 44850 -17350 0 0 {name=p44469 lab=_82256_/D }
C {devices/lab_pin.sym} 45030 -17370 0 1 {name=p44470 lab=_82256_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -17360 0 0 {name=X_82256_ }
C {devices/lab_pin.sym} 44900 -17230 0 0 {name=p44471 lab=clkbuf_8_168_0_CLK/X }
C {devices/lab_pin.sym} 44980 -17230 0 1 {name=p44472 lab=clkbuf_9_336_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 44940 -17230 0 0 {name=Xclkbuf_9_336_0_CLK }
C {devices/lab_pin.sym} 44850 -17110 0 0 {name=p44473 lab=_81211_/CLK }
C {devices/lab_pin.sym} 44850 -17090 0 0 {name=p44474 lab=_75054_/X }
C {devices/lab_pin.sym} 45030 -17110 0 1 {name=p44475 lab=_48986_/A }
C {sky130_stdcells/dfxtp_4.sym} 44940 -17100 0 0 {name=X_81207_ }
C {devices/lab_pin.sym} 44900 -16970 0 0 {name=p44476 lab=_53418_/X }
C {devices/lab_pin.sym} 44980 -16970 0 1 {name=p44477 lab=_54160_/A }
C {sky130_stdcells/buf_2.sym} 44940 -16970 0 0 {name=X_54155_ }
C {devices/lab_pin.sym} 44900 -16850 0 0 {name=p44478 lab=_51282_/A }
C {devices/lab_pin.sym} 44980 -16850 0 1 {name=p44479 lab=_51367_/X }
C {sky130_stdcells/buf_2.sym} 44940 -16850 0 0 {name=X_51367_ }
C {devices/lab_pin.sym} 44850 -16730 0 0 {name=p44480 lab=_84951_/CLK }
C {devices/lab_pin.sym} 44850 -16710 0 0 {name=p44481 lab=_82187_/D }
C {devices/lab_pin.sym} 45030 -16730 0 1 {name=p44482 lab=_82187_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -16720 0 0 {name=X_82187_ }
C {devices/lab_pin.sym} 44860 -16610 0 0 {name=p44483 lab=_41100_/X }
C {devices/lab_pin.sym} 44860 -16570 0 0 {name=p44484 lab=_40571_/A }
C {devices/lab_pin.sym} 44860 -16530 0 0 {name=p44485 lab=_41119_/X }
C {devices/lab_pin.sym} 45020 -16570 0 1 {name=p44486 lab=_41121_/A }
C {sky130_stdcells/o21ai_4.sym} 44940 -16570 0 0 {name=X_41120_ }
C {devices/lab_pin.sym} 44860 -16450 0 0 {name=p44487 lab=_85696_/Q }
C {devices/lab_pin.sym} 44860 -16410 0 0 {name=p44488 lab=_53093_/X }
C {devices/lab_pin.sym} 44860 -16370 0 0 {name=p44489 lab=_53105_/Y }
C {devices/lab_pin.sym} 45020 -16410 0 1 {name=p44490 lab=_53106_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -16410 0 0 {name=X_53106_ }
C {devices/lab_pin.sym} 44880 -16280 0 0 {name=p44491 lab=_50317_/X }
C {devices/lab_pin.sym} 44880 -16240 0 0 {name=p44492 lab=_48016_/B }
C {devices/lab_pin.sym} 45000 -16260 0 1 {name=p44493 lab=_50318_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -16260 0 0 {name=X_50318_ }
C {devices/lab_pin.sym} 44850 -16130 0 0 {name=p44494 lab=_82327_/CLK }
C {devices/lab_pin.sym} 44850 -16110 0 0 {name=p44495 lab=_80762_/Q }
C {devices/lab_pin.sym} 45030 -16130 0 1 {name=p44496 lab=_40671_/A }
C {sky130_stdcells/dfxtp_4.sym} 44940 -16120 0 0 {name=X_81138_ }
C {devices/lab_pin.sym} 44860 -16010 0 0 {name=p44497 lab=_58925_/X }
C {devices/lab_pin.sym} 44860 -15970 0 0 {name=p44498 lab=_85442_/Q }
C {devices/lab_pin.sym} 44860 -15930 0 0 {name=p44499 lab=_58962_/X }
C {devices/lab_pin.sym} 45020 -15970 0 1 {name=p44500 lab=_58963_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -15970 0 0 {name=X_58963_ }
C {devices/lab_pin.sym} 44860 -15850 0 0 {name=p44501 lab=_85507_/Q }
C {devices/lab_pin.sym} 44860 -15810 0 0 {name=p44502 lab=_54067_/X }
C {devices/lab_pin.sym} 44860 -15770 0 0 {name=p44503 lab=_54085_/Y }
C {devices/lab_pin.sym} 45020 -15810 0 1 {name=p44504 lab=_54086_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -15810 0 0 {name=X_54086_ }
C {devices/lab_pin.sym} 44880 -15680 0 0 {name=p44505 lab=_51298_/A }
C {devices/lab_pin.sym} 44880 -15640 0 0 {name=p44506 lab=_46391_/A }
C {devices/lab_pin.sym} 45000 -15660 0 1 {name=p44507 lab=_51298_/X }
C {sky130_stdcells/and2_4.sym} 44940 -15660 0 0 {name=X_51298_ }
C {devices/lab_pin.sym} 44850 -15530 0 0 {name=p44508 lab=_86998_/CLK }
C {devices/lab_pin.sym} 44850 -15510 0 0 {name=p44509 lab=_44700_/Y }
C {devices/lab_pin.sym} 45030 -15530 0 1 {name=p44510 lab=_86995_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -15520 0 0 {name=X_86995_ }
C {devices/lab_pin.sym} 44860 -15410 0 0 {name=p44511 lab=_53034_/Y }
C {devices/lab_pin.sym} 44860 -15370 0 0 {name=p44512 lab=_53028_/X }
C {devices/lab_pin.sym} 44860 -15330 0 0 {name=p44513 lab=_53036_/X }
C {devices/lab_pin.sym} 45020 -15370 0 1 {name=p44514 lab=_85709_/D }
C {sky130_stdcells/a21oi_4.sym} 44940 -15370 0 0 {name=X_53037_ }
C {devices/lab_pin.sym} 44860 -15250 0 0 {name=p44515 lab=_57760_/X }
C {devices/lab_pin.sym} 44860 -15210 0 0 {name=p44516 lab=_85396_/Q }
C {devices/lab_pin.sym} 44860 -15170 0 0 {name=p44517 lab=_57913_/X }
C {devices/lab_pin.sym} 45020 -15210 0 1 {name=p44518 lab=_57914_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -15210 0 0 {name=X_57914_ }
C {devices/lab_pin.sym} 44860 -15100 0 0 {name=p44519 lab=_41050_/X }
C {devices/lab_pin.sym} 44860 -15060 0 0 {name=p44520 lab=_40987_/X }
C {devices/lab_pin.sym} 44860 -15020 0 0 {name=p44521 lab=_69415_/B }
C {devices/lab_pin.sym} 44860 -14980 0 0 {name=p44522 lab=_40989_/X }
C {devices/lab_pin.sym} 45020 -15040 0 1 {name=p44523 lab=_88287_/D }
C {sky130_stdcells/a2bb2o_4.sym} 44940 -15040 0 0 {name=X_41051_ }
C {devices/lab_pin.sym} 44860 -14910 0 0 {name=p44524 lab=_50241_/Y }
C {devices/lab_pin.sym} 44860 -14870 0 0 {name=p44525 lab=_50243_/X }
C {devices/lab_pin.sym} 44860 -14830 0 0 {name=p44526 lab=_50248_/X }
C {devices/lab_pin.sym} 45020 -14870 0 1 {name=p44527 lab=_86238_/D }
C {sky130_stdcells/a21oi_4.sym} 44940 -14870 0 0 {name=X_50249_ }
C {devices/lab_pin.sym} 44860 -14750 0 0 {name=p44528 lab=_73958_/X }
C {devices/lab_pin.sym} 44860 -14710 0 0 {name=p44529 lab=_73959_/Y }
C {devices/lab_pin.sym} 44860 -14670 0 0 {name=p44530 lab=_73839_/X }
C {devices/lab_pin.sym} 45020 -14710 0 1 {name=p44531 lab=_73960_/X }
C {sky130_stdcells/a21o_4.sym} 44940 -14710 0 0 {name=X_73960_ }
C {devices/lab_pin.sym} 44850 -14570 0 0 {name=p44532 lab=_82206_/CLK }
C {devices/lab_pin.sym} 44850 -14550 0 0 {name=p44533 lab=_85946_/D }
C {devices/lab_pin.sym} 45030 -14570 0 1 {name=p44534 lab=_85946_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -14560 0 0 {name=X_85946_ }
C {devices/lab_pin.sym} 44850 -14430 0 0 {name=p44535 lab=_80817_/CLK }
C {devices/lab_pin.sym} 44850 -14410 0 0 {name=p44536 lab=_75817_/A }
C {devices/lab_pin.sym} 45030 -14430 0 1 {name=p44537 lab=_75224_/A }
C {sky130_stdcells/dfxtp_4.sym} 44940 -14420 0 0 {name=X_81069_ }
C {devices/lab_pin.sym} 44860 -14310 0 0 {name=p44538 lab=_58890_/Y }
C {devices/lab_pin.sym} 44860 -14270 0 0 {name=p44539 lab=_58893_/Y }
C {devices/lab_pin.sym} 44860 -14230 0 0 {name=p44540 lab=_58883_/X }
C {devices/lab_pin.sym} 45020 -14270 0 1 {name=p44541 lab=_58894_/X }
C {sky130_stdcells/a21o_4.sym} 44940 -14270 0 0 {name=X_58894_ }
C {devices/lab_pin.sym} 44880 -14140 0 0 {name=p44542 lab=_73381_/A }
C {devices/lab_pin.sym} 44880 -14100 0 0 {name=p44543 lab=_72911_/B }
C {devices/lab_pin.sym} 45000 -14120 0 1 {name=p44544 lab=_72911_/X }
C {sky130_stdcells/and2_4.sym} 44940 -14120 0 0 {name=X_72911_ }
C {devices/lab_pin.sym} 44900 -13990 0 0 {name=p44545 lab=_58676_/A }
C {devices/lab_pin.sym} 44980 -13990 0 1 {name=p44546 lab=_57845_/X }
C {sky130_stdcells/buf_2.sym} 44940 -13990 0 0 {name=X_57845_ }
C {devices/lab_pin.sym} 44900 -13870 0 0 {name=p44547 lab=_73250_/A }
C {devices/lab_pin.sym} 44980 -13870 0 1 {name=p44548 lab=_73891_/X }
C {sky130_stdcells/buf_2.sym} 44940 -13870 0 0 {name=X_73891_ }
C {devices/lab_pin.sym} 44850 -13750 0 0 {name=p44549 lab=_86193_/CLK }
C {devices/lab_pin.sym} 44850 -13730 0 0 {name=p44550 lab=_85877_/D }
C {devices/lab_pin.sym} 45030 -13750 0 1 {name=p44551 lab=_85877_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -13740 0 0 {name=X_85877_ }
C {devices/lab_pin.sym} 44900 -13610 0 0 {name=p44552 lab=_44810_/A }
C {devices/lab_pin.sym} 44980 -13610 0 1 {name=p44553 lab=_86943_/D }
C {sky130_stdcells/inv_2.sym} 44940 -13610 0 0 {name=X_44810_ }
C {devices/lab_pin.sym} 44880 -13500 0 0 {name=p44554 lab=_75630_/A }
C {devices/lab_pin.sym} 44880 -13460 0 0 {name=p44555 lab=_75629_/X }
C {devices/lab_pin.sym} 45000 -13480 0 1 {name=p44556 lab=_75639_/B }
C {sky130_stdcells/xnor2_4.sym} 44940 -13480 0 0 {name=X_75630_ }
C {devices/lab_pin.sym} 44850 -13350 0 0 {name=p44557 lab=_88387_/CLK }
C {devices/lab_pin.sym} 44850 -13330 0 0 {name=p44558 lab=_87616_/D }
C {devices/lab_pin.sym} 45030 -13350 0 1 {name=p44559 lab=_87616_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -13340 0 0 {name=X_87616_ }
C {devices/lab_pin.sym} 44860 -13230 0 0 {name=p44560 lab=_72837_/X }
C {devices/lab_pin.sym} 44860 -13190 0 0 {name=p44561 lab=_72841_/X }
C {devices/lab_pin.sym} 44860 -13150 0 0 {name=p44562 lab=_72812_/X }
C {devices/lab_pin.sym} 45020 -13190 0 1 {name=p44563 lab=_72845_/A }
C {sky130_stdcells/a21o_4.sym} 44940 -13190 0 0 {name=X_72842_ }
C {devices/lab_pin.sym} 44850 -13050 0 0 {name=p44564 lab=_84829_/CLK }
C {devices/lab_pin.sym} 44850 -13030 0 0 {name=p44565 lab=_84828_/D }
C {devices/lab_pin.sym} 45030 -13050 0 1 {name=p44566 lab=_84828_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -13040 0 0 {name=X_84828_ }
C {devices/lab_pin.sym} 44860 -12930 0 0 {name=p44567 lab=_45748_/X }
C {devices/lab_pin.sym} 44860 -12890 0 0 {name=p44568 lab=_61630_/A }
C {devices/lab_pin.sym} 44860 -12850 0 0 {name=p44569 lab=_45765_/X }
C {devices/lab_pin.sym} 45020 -12890 0 1 {name=p44570 lab=_45790_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -12890 0 0 {name=X_45790_ }
C {devices/lab_pin.sym} 44900 -12750 0 0 {name=p44571 lab=_57776_/A }
C {devices/lab_pin.sym} 44980 -12750 0 1 {name=p44572 lab=_69768_/A }
C {sky130_stdcells/buf_2.sym} 44940 -12750 0 0 {name=X_57776_ }
C {devices/lab_pin.sym} 44860 -12650 0 0 {name=p44573 lab=_54986_/Y }
C {devices/lab_pin.sym} 44860 -12610 0 0 {name=p44574 lab=_54971_/X }
C {devices/lab_pin.sym} 44860 -12570 0 0 {name=p44575 lab=_54987_/X }
C {devices/lab_pin.sym} 45020 -12610 0 1 {name=p44576 lab=_54988_/Y }
C {sky130_stdcells/a21oi_4.sym} 44940 -12610 0 0 {name=X_54988_ }
C {devices/lab_pin.sym} 44880 -12480 0 0 {name=p44577 lab=_59876_/B }
C {devices/lab_pin.sym} 44880 -12440 0 0 {name=p44578 lab=_59521_/A }
C {devices/lab_pin.sym} 45000 -12460 0 1 {name=p44579 lab=_59557_/A }
C {sky130_stdcells/nor2_4.sym} 44940 -12460 0 0 {name=X_59515_ }
C {devices/lab_pin.sym} 44900 -12330 0 0 {name=p44580 lab=_41936_/A }
C {devices/lab_pin.sym} 44980 -12330 0 1 {name=p44581 lab=_44741_/X }
C {sky130_stdcells/buf_2.sym} 44940 -12330 0 0 {name=X_44741_ }
C {devices/lab_pin.sym} 44900 -12210 0 0 {name=p44582 lab=_56726_/X }
C {devices/lab_pin.sym} 44980 -12210 0 1 {name=p44583 lab=_56727_/X }
C {sky130_stdcells/buf_2.sym} 44940 -12210 0 0 {name=X_56727_ }
C {devices/lab_pin.sym} 44880 -12100 0 0 {name=p44584 lab=_75553_/Y }
C {devices/lab_pin.sym} 44880 -12060 0 0 {name=p44585 lab=_75561_/B }
C {devices/lab_pin.sym} 45000 -12080 0 1 {name=p44586 lab=_75561_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -12080 0 0 {name=X_75561_ }
C {devices/lab_pin.sym} 44850 -11950 0 0 {name=p44587 lab=_87814_/CLK }
C {devices/lab_pin.sym} 44850 -11930 0 0 {name=p44588 lab=_87547_/D }
C {devices/lab_pin.sym} 45030 -11950 0 1 {name=p44589 lab=_73374_/A }
C {sky130_stdcells/dfxtp_4.sym} 44940 -11940 0 0 {name=X_87547_ }
C {devices/lab_pin.sym} 44900 -11810 0 0 {name=p44590 lab=_42025_/A }
C {devices/lab_pin.sym} 44980 -11810 0 1 {name=p44591 lab=_41953_/X }
C {sky130_stdcells/buf_2.sym} 44940 -11810 0 0 {name=X_41953_ }
C {devices/lab_pin.sym} 44860 -11710 0 0 {name=p44592 lab=_53937_/Y }
C {devices/lab_pin.sym} 44860 -11670 0 0 {name=p44593 lab=_53892_/X }
C {devices/lab_pin.sym} 44860 -11630 0 0 {name=p44594 lab=_53938_/X }
C {devices/lab_pin.sym} 45020 -11670 0 1 {name=p44595 lab=_85538_/D }
C {sky130_stdcells/a21oi_4.sym} 44940 -11670 0 0 {name=X_53939_ }
C {devices/lab_pin.sym} 44850 -11530 0 0 {name=p44596 lab=_85485_/CLK }
C {devices/lab_pin.sym} 44850 -11510 0 0 {name=p44597 lab=_84759_/D }
C {devices/lab_pin.sym} 45030 -11530 0 1 {name=p44598 lab=_84759_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -11520 0 0 {name=X_84759_ }
C {devices/lab_pin.sym} 44860 -11420 0 0 {name=p44599 lab=_43115_/Y }
C {devices/lab_pin.sym} 44860 -11380 0 0 {name=p44600 lab=_72731_/X }
C {devices/lab_pin.sym} 44860 -11340 0 0 {name=p44601 lab=_56935_/X }
C {devices/lab_pin.sym} 44860 -11300 0 0 {name=p44602 lab=_72772_/Y }
C {devices/lab_pin.sym} 45020 -11360 0 1 {name=p44603 lab=_72773_/X }
C {sky130_stdcells/a211o_4.sym} 44940 -11360 0 0 {name=X_72773_ }
C {devices/lab_pin.sym} 44900 -11210 0 0 {name=p44604 lab=_77300_/A }
C {devices/lab_pin.sym} 44980 -11210 0 1 {name=p44605 lab=_77301_/B }
C {sky130_stdcells/inv_2.sym} 44940 -11210 0 0 {name=X_77300_ }
C {devices/lab_pin.sym} 44860 -11110 0 0 {name=p44606 lab=_83050_/Q }
C {devices/lab_pin.sym} 44860 -11070 0 0 {name=p44607 lab=_74387_/X }
C {devices/lab_pin.sym} 44860 -11030 0 0 {name=p44608 lab=_74511_/Y }
C {devices/lab_pin.sym} 45020 -11070 0 1 {name=p44609 lab=_74512_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -11070 0 0 {name=X_74512_ }
C {devices/lab_pin.sym} 44900 -10930 0 0 {name=p44610 lab=_40793_/A }
C {devices/lab_pin.sym} 44980 -10930 0 1 {name=p44611 lab=_40904_/X }
C {sky130_stdcells/buf_2.sym} 44940 -10930 0 0 {name=X_40904_ }
C {devices/lab_pin.sym} 44880 -10820 0 0 {name=p44612 lab=_47444_/A }
C {devices/lab_pin.sym} 44880 -10780 0 0 {name=p44613 lab=_53060_/B }
C {devices/lab_pin.sym} 45000 -10800 0 1 {name=p44614 lab=_47460_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -10800 0 0 {name=X_47460_ }
C {devices/lab_pin.sym} 44900 -10670 0 0 {name=p44615 lab=_70939_/A }
C {devices/lab_pin.sym} 44980 -10670 0 1 {name=p44616 lab=_71724_/X }
C {sky130_stdcells/buf_2.sym} 44940 -10670 0 0 {name=X_71724_ }
C {devices/lab_pin.sym} 44860 -10570 0 0 {name=p44617 lab=_59442_/X }
C {devices/lab_pin.sym} 44860 -10530 0 0 {name=p44618 lab=_83339_/Q }
C {devices/lab_pin.sym} 44860 -10490 0 0 {name=p44619 lab=_59445_/Y }
C {devices/lab_pin.sym} 45020 -10530 0 1 {name=p44620 lab=_84731_/D }
C {sky130_stdcells/o21a_4.sym} 44940 -10530 0 0 {name=X_59446_ }
C {devices/lab_pin.sym} 44880 -10420 0 0 {name=p44621 lab=_78262_/X }
C {devices/lab_pin.sym} 44880 -10380 0 0 {name=p44622 lab=_78280_/B }
C {devices/lab_pin.sym} 44880 -10340 0 0 {name=p44623 lab=_78274_/A }
C {devices/lab_pin.sym} 44880 -10300 0 0 {name=p44624 lab=_78284_/B }
C {devices/lab_pin.sym} 45000 -10360 0 1 {name=p44625 lab=_78280_/Y }
C {sky130_stdcells/nand4_4.sym} 44940 -10360 0 0 {name=X_78280_ }
C {devices/lab_pin.sym} 44900 -10210 0 0 {name=p44626 lab=_44672_/A }
C {devices/lab_pin.sym} 44980 -10210 0 1 {name=p44627 lab=_44672_/Y }
C {sky130_stdcells/inv_2.sym} 44940 -10210 0 0 {name=X_44672_ }
C {devices/lab_pin.sym} 44880 -10100 0 0 {name=p44628 lab=_83335_/Q }
C {devices/lab_pin.sym} 44880 -10060 0 0 {name=p44629 lab=_83334_/Q }
C {devices/lab_pin.sym} 45000 -10080 0 1 {name=p44630 lab=_56700_/C }
C {sky130_stdcells/nand2_4.sym} 44940 -10080 0 0 {name=X_56658_ }
C {devices/lab_pin.sym} 44900 -9950 0 0 {name=p44631 lab=_75492_/A }
C {devices/lab_pin.sym} 44980 -9950 0 1 {name=p44632 lab=_75492_/Y }
C {sky130_stdcells/inv_2.sym} 44940 -9950 0 0 {name=X_75492_ }
C {devices/lab_pin.sym} 44850 -9830 0 0 {name=p44633 lab=_87990_/CLK }
C {devices/lab_pin.sym} 44850 -9810 0 0 {name=p44634 lab=_43328_/X }
C {devices/lab_pin.sym} 45030 -9830 0 1 {name=p44635 lab=_87478_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -9820 0 0 {name=X_87478_ }
C {devices/lab_pin.sym} 44900 -9690 0 0 {name=p44636 lab=_41884_/A }
C {devices/lab_pin.sym} 44980 -9690 0 1 {name=p44637 lab=_41884_/Y }
C {sky130_stdcells/inv_2.sym} 44940 -9690 0 0 {name=X_41884_ }
C {devices/lab_pin.sym} 44900 -9570 0 0 {name=p44638 lab=_46411_/A }
C {devices/lab_pin.sym} 44980 -9570 0 1 {name=p44639 lab=_46412_/B }
C {sky130_stdcells/buf_2.sym} 44940 -9570 0 0 {name=X_46411_ }
C {devices/lab_pin.sym} 44900 -9450 0 0 {name=p44640 lab=_77230_/Y }
C {devices/lab_pin.sym} 44980 -9450 0 1 {name=p44641 lab=_77231_/Y }
C {sky130_stdcells/inv_2.sym} 44940 -9450 0 0 {name=X_77231_ }
C {devices/lab_pin.sym} 44860 -9360 0 0 {name=p44642 lab=_40646_/X }
C {devices/lab_pin.sym} 44860 -9320 0 0 {name=p44643 lab=_43604_/X }
C {devices/lab_pin.sym} 44860 -9280 0 0 {name=p44644 lab=_73797_/A }
C {devices/lab_pin.sym} 44860 -9240 0 0 {name=p44645 lab=_43607_/X }
C {devices/lab_pin.sym} 45020 -9300 0 1 {name=p44646 lab=_87337_/D }
C {sky130_stdcells/a2bb2o_4.sym} 44940 -9300 0 0 {name=X_43623_ }
C {devices/lab_pin.sym} 44900 -9150 0 0 {name=p44647 lab=_44116_/B }
C {devices/lab_pin.sym} 44980 -9150 0 1 {name=p44648 lab=_55641_/A }
C {sky130_stdcells/buf_2.sym} 44940 -9150 0 0 {name=X_55609_ }
C {devices/lab_pin.sym} 44880 -9040 0 0 {name=p44649 lab=_74442_/X }
C {devices/lab_pin.sym} 44880 -9000 0 0 {name=p44650 lab=_48538_/Y }
C {devices/lab_pin.sym} 45000 -9020 0 1 {name=p44651 lab=_74443_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -9020 0 0 {name=X_74443_ }
C {devices/lab_pin.sym} 44850 -8890 0 0 {name=p44652 lab=_86246_/CLK }
C {devices/lab_pin.sym} 44850 -8870 0 0 {name=p44653 lab=_86429_/D }
C {devices/lab_pin.sym} 45030 -8890 0 1 {name=p44654 lab=_64710_/B }
C {sky130_stdcells/dfxtp_4.sym} 44940 -8880 0 0 {name=X_86429_ }
C {devices/lab_pin.sym} 44900 -8750 0 0 {name=p44655 lab=_40835_/A }
C {devices/lab_pin.sym} 44980 -8750 0 1 {name=p44656 lab=_40835_/X }
C {sky130_stdcells/buf_2.sym} 44940 -8750 0 0 {name=X_40835_ }
C {devices/lab_pin.sym} 44900 -8630 0 0 {name=p44657 lab=_47391_/A }
C {devices/lab_pin.sym} 44980 -8630 0 1 {name=p44658 lab=_53019_/D }
C {sky130_stdcells/buf_2.sym} 44940 -8630 0 0 {name=X_47391_ }
C {devices/lab_pin.sym} 44900 -8510 0 0 {name=p44659 lab=_71655_/A }
C {devices/lab_pin.sym} 44980 -8510 0 1 {name=p44660 lab=_71660_/C }
C {sky130_stdcells/buf_2.sym} 44940 -8510 0 0 {name=X_71655_ }
C {devices/lab_pin.sym} 44880 -8400 0 0 {name=p44661 lab=_59377_/A }
C {devices/lab_pin.sym} 44880 -8360 0 0 {name=p44662 lab=_59306_/B }
C {devices/lab_pin.sym} 45000 -8380 0 1 {name=p44663 lab=_59377_/Y }
C {sky130_stdcells/nor2_4.sym} 44940 -8380 0 0 {name=X_59377_ }
C {devices/lab_pin.sym} 44900 -8250 0 0 {name=p44664 lab=_56589_/A }
C {devices/lab_pin.sym} 44980 -8250 0 1 {name=p44665 lab=_56589_/X }
C {sky130_stdcells/buf_2.sym} 44940 -8250 0 0 {name=X_56589_ }
C {devices/lab_pin.sym} 44860 -8150 0 0 {name=p44666 lab=_49128_/X }
C {devices/lab_pin.sym} 44860 -8110 0 0 {name=p44667 lab=_48632_/A }
C {devices/lab_pin.sym} 44860 -8070 0 0 {name=p44668 lab=_49129_/Y }
C {devices/lab_pin.sym} 45020 -8110 0 1 {name=p44669 lab=_52385_/B }
C {sky130_stdcells/a21o_4.sym} 44940 -8110 0 0 {name=X_49130_ }
C {devices/lab_pin.sym} 44900 -7970 0 0 {name=p44670 lab=_83649_/Q }
C {devices/lab_pin.sym} 44980 -7970 0 1 {name=p44671 lab=_53980_/B }
C {sky130_stdcells/inv_2.sym} 44940 -7970 0 0 {name=X_46342_ }
C {devices/lab_pin.sym} 44880 -7880 0 0 {name=p44672 lab=_70717_/A }
C {devices/lab_pin.sym} 44880 -7840 0 0 {name=p44673 lab=_70613_/B }
C {devices/lab_pin.sym} 44880 -7800 0 0 {name=p44674 lab=_74533_/D }
C {devices/lab_pin.sym} 44880 -7760 0 0 {name=p44675 lab=_70594_/X }
C {devices/lab_pin.sym} 45000 -7820 0 1 {name=p44676 lab=_70606_/Y }
C {sky130_stdcells/nand4_4.sym} 44940 -7820 0 0 {name=X_70606_ }
C {devices/lab_pin.sym} 44900 -7670 0 0 {name=p44677 lab=_58328_/A }
C {devices/lab_pin.sym} 44980 -7670 0 1 {name=p44678 lab=_58328_/X }
C {sky130_stdcells/buf_2.sym} 44940 -7670 0 0 {name=X_58328_ }
C {devices/lab_pin.sym} 44880 -7560 0 0 {name=p44679 lab=_77163_/A }
C {devices/lab_pin.sym} 44880 -7520 0 0 {name=p44680 lab=_81921_/Q }
C {devices/lab_pin.sym} 45000 -7540 0 1 {name=p44681 lab=_77173_/B }
C {sky130_stdcells/or2_4.sym} 44940 -7540 0 0 {name=X_77162_ }
C {devices/lab_pin.sym} 44860 -7440 0 0 {name=p44682 lab=_40469_/X }
C {devices/lab_pin.sym} 44860 -7400 0 0 {name=p44683 lab=_43532_/X }
C {devices/lab_pin.sym} 44860 -7360 0 0 {name=p44684 lab=_87363_/Q }
C {devices/lab_pin.sym} 44860 -7320 0 0 {name=p44685 lab=_43533_/X }
C {devices/lab_pin.sym} 45020 -7380 0 1 {name=p44686 lab=_87363_/D }
C {sky130_stdcells/a2bb2o_4.sym} 44940 -7380 0 0 {name=X_43554_ }
C {devices/lab_pin.sym} 44860 -7250 0 0 {name=p44687 lab=_83079_/Q }
C {devices/lab_pin.sym} 44860 -7210 0 0 {name=p44688 lab=_72066_/X }
C {devices/lab_pin.sym} 44860 -7170 0 0 {name=p44689 lab=_74373_/Y }
C {devices/lab_pin.sym} 45020 -7210 0 1 {name=p44690 lab=_74374_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -7210 0 0 {name=X_74374_ }
C {devices/lab_pin.sym} 44860 -7090 0 0 {name=p44691 lab=_40731_/X }
C {devices/lab_pin.sym} 44860 -7050 0 0 {name=p44692 lab=_82305_/Q }
C {devices/lab_pin.sym} 44860 -7010 0 0 {name=p44693 lab=_40765_/X }
C {devices/lab_pin.sym} 45020 -7050 0 1 {name=p44694 lab=_40767_/A }
C {sky130_stdcells/o21ai_4.sym} 44940 -7050 0 0 {name=X_40766_ }
C {devices/lab_pin.sym} 44880 -6930 0 0 {name=p44695 lab=_71586_/A }
C {devices/lab_pin.sym} 44880 -6890 0 0 {name=p44696 lab=_71590_/B }
C {devices/lab_pin.sym} 44880 -6850 0 0 {name=p44697 lab=_71582_/X }
C {devices/lab_pin.sym} 45000 -6890 0 1 {name=p44698 lab=_71586_/Y }
C {sky130_stdcells/nor3_4.sym} 44940 -6890 0 0 {name=X_71586_ }
C {devices/lab_pin.sym} 44880 -6760 0 0 {name=p44699 lab=_76113_/A }
C {devices/lab_pin.sym} 44880 -6720 0 0 {name=p44700 lab=_76113_/B }
C {devices/lab_pin.sym} 45000 -6740 0 1 {name=p44701 lab=_76113_/X }
C {sky130_stdcells/xor2_4.sym} 44940 -6740 0 0 {name=X_76113_ }
C {devices/lab_pin.sym} 44900 -6610 0 0 {name=p44702 lab=_42505_/A }
C {devices/lab_pin.sym} 44980 -6610 0 1 {name=p44703 lab=_87842_/D }
C {sky130_stdcells/inv_2.sym} 44940 -6610 0 0 {name=X_42505_ }
C {devices/lab_pin.sym} 44880 -6510 0 0 {name=p44704 lab=_50142_/A }
C {devices/lab_pin.sym} 44880 -6470 0 0 {name=p44705 lab=_48940_/B }
C {devices/lab_pin.sym} 44880 -6430 0 0 {name=p44706 lab=_48928_/C }
C {devices/lab_pin.sym} 45000 -6470 0 1 {name=p44707 lab=_49061_/X }
C {sky130_stdcells/and3_4.sym} 44940 -6470 0 0 {name=X_49061_ }
C {devices/lab_pin.sym} 44860 -6350 0 0 {name=p44708 lab=_73321_/X }
C {devices/lab_pin.sym} 44860 -6310 0 0 {name=p44709 lab=_73324_/X }
C {devices/lab_pin.sym} 44860 -6270 0 0 {name=p44710 lab=_72862_/X }
C {devices/lab_pin.sym} 45020 -6310 0 1 {name=p44711 lab=_73325_/X }
C {sky130_stdcells/a21o_4.sym} 44940 -6310 0 0 {name=X_73325_ }
C {devices/lab_pin.sym} 44860 -6190 0 0 {name=p44712 lab=_86751_/Q }
C {devices/lab_pin.sym} 44860 -6150 0 0 {name=p44713 lab=_46250_/X }
C {devices/lab_pin.sym} 44860 -6110 0 0 {name=p44714 lab=_46272_/Y }
C {devices/lab_pin.sym} 45020 -6150 0 1 {name=p44715 lab=_46273_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -6150 0 0 {name=X_46273_ }
C {devices/lab_pin.sym} 44900 -6010 0 0 {name=p44716 lab=_70530_/Y }
C {devices/lab_pin.sym} 44980 -6010 0 1 {name=p44717 lab=_70554_/A }
C {sky130_stdcells/buf_2.sym} 44940 -6010 0 0 {name=X_70537_ }
C {devices/lab_pin.sym} 44880 -5900 0 0 {name=p44718 lab=_58259_/A }
C {devices/lab_pin.sym} 44880 -5860 0 0 {name=p44719 lab=_58268_/B }
C {devices/lab_pin.sym} 45000 -5880 0 1 {name=p44720 lab=_58259_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -5880 0 0 {name=X_58259_ }
C {devices/lab_pin.sym} 44880 -5760 0 0 {name=p44721 lab=_77096_/B }
C {devices/lab_pin.sym} 44880 -5720 0 0 {name=p44722 lab=_77093_/B }
C {devices/lab_pin.sym} 45000 -5740 0 1 {name=p44723 lab=_77094_/B }
C {sky130_stdcells/xnor2_4.sym} 44940 -5740 0 0 {name=X_77093_ }
C {devices/lab_pin.sym} 44900 -5610 0 0 {name=p44724 lab=_43466_/X }
C {devices/lab_pin.sym} 44980 -5610 0 1 {name=p44725 lab=_43485_/X }
C {sky130_stdcells/buf_2.sym} 44940 -5610 0 0 {name=X_43485_ }
C {devices/lab_pin.sym} 44860 -5520 0 0 {name=p44726 lab=_40696_/X }
C {devices/lab_pin.sym} 44860 -5480 0 0 {name=p44727 lab=_40651_/X }
C {devices/lab_pin.sym} 44860 -5440 0 0 {name=p44728 lab=_88352_/Q }
C {devices/lab_pin.sym} 44860 -5400 0 0 {name=p44729 lab=_40652_/X }
C {devices/lab_pin.sym} 45020 -5460 0 1 {name=p44730 lab=_40697_/X }
C {sky130_stdcells/a2bb2o_4.sym} 44940 -5460 0 0 {name=X_40697_ }
C {devices/lab_pin.sym} 44880 -5330 0 0 {name=p44731 lab=_50314_/A }
C {devices/lab_pin.sym} 44880 -5290 0 0 {name=p44732 lab=_48069_/B }
C {devices/lab_pin.sym} 44880 -5250 0 0 {name=p44733 lab=_47919_/X }
C {devices/lab_pin.sym} 45000 -5290 0 1 {name=p44734 lab=_48012_/X }
C {sky130_stdcells/and3_4.sym} 44940 -5290 0 0 {name=X_48012_ }
C {devices/lab_pin.sym} 44860 -5170 0 0 {name=p44735 lab=_85260_/Q }
C {devices/lab_pin.sym} 44860 -5130 0 0 {name=p44736 lab=_45222_/X }
C {devices/lab_pin.sym} 44860 -5090 0 0 {name=p44737 lab=_45223_/X }
C {devices/lab_pin.sym} 45020 -5130 0 1 {name=p44738 lab=_45224_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -5130 0 0 {name=X_45224_ }
C {devices/lab_pin.sym} 44880 -5000 0 0 {name=p44739 lab=_76047_/B }
C {devices/lab_pin.sym} 44880 -4960 0 0 {name=p44740 lab=_76043_/Y }
C {devices/lab_pin.sym} 45000 -4980 0 1 {name=p44741 lab=_81747_/D }
C {sky130_stdcells/xnor2_4.sym} 44940 -4980 0 0 {name=X_76044_ }
C {devices/lab_pin.sym} 44860 -4880 0 0 {name=p44742 lab=_40524_/X }
C {devices/lab_pin.sym} 44860 -4840 0 0 {name=p44743 lab=_42434_/X }
C {devices/lab_pin.sym} 44860 -4800 0 0 {name=p44744 lab=_87865_/Q }
C {devices/lab_pin.sym} 44860 -4760 0 0 {name=p44745 lab=_42435_/X }
C {devices/lab_pin.sym} 45020 -4820 0 1 {name=p44746 lab=_87865_/D }
C {sky130_stdcells/a2bb2o_4.sym} 44940 -4820 0 0 {name=X_42436_ }
C {devices/lab_pin.sym} 44860 -4700 0 0 {name=p44747 lab=_84492_/Q }
C {devices/lab_pin.sym} 44860 -4660 0 0 {name=p44748 lab=_60979_/X }
C {devices/lab_pin.sym} 44860 -4620 0 0 {name=p44749 lab=_61097_/X }
C {devices/lab_pin.sym} 44860 -4580 0 0 {name=p44750 lab=_61170_/Y }
C {devices/lab_pin.sym} 45020 -4640 0 1 {name=p44751 lab=_84492_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 44940 -4640 0 0 {name=X_61270_ }
C {devices/lab_pin.sym} 44860 -4510 0 0 {name=p44752 lab=_87052_/Q }
C {devices/lab_pin.sym} 44860 -4470 0 0 {name=p44753 lab=_73129_/X }
C {devices/lab_pin.sym} 44860 -4430 0 0 {name=p44754 lab=_73255_/X }
C {devices/lab_pin.sym} 45020 -4470 0 1 {name=p44755 lab=_73270_/C }
C {sky130_stdcells/o21ai_4.sym} 44940 -4470 0 0 {name=X_73256_ }
C {devices/lab_pin.sym} 44900 -4330 0 0 {name=p44756 lab=_71483_/B }
C {devices/lab_pin.sym} 44980 -4330 0 1 {name=p44757 lab=_71366_/A }
C {sky130_stdcells/buf_2.sym} 44940 -4330 0 0 {name=X_70468_ }
C {devices/lab_pin.sym} 44880 -4240 0 0 {name=p44758 lab=_60221_/A }
C {devices/lab_pin.sym} 44880 -4200 0 0 {name=p44759 lab=_60344_/A }
C {devices/lab_pin.sym} 44880 -4160 0 0 {name=p44760 lab=_60344_/B }
C {devices/lab_pin.sym} 44880 -4120 0 0 {name=p44761 lab=_60344_/C }
C {devices/lab_pin.sym} 45000 -4180 0 1 {name=p44762 lab=_60299_/A }
C {sky130_stdcells/nand4_4.sym} 44940 -4180 0 0 {name=X_60221_ }
C {devices/lab_pin.sym} 44860 -4050 0 0 {name=p44763 lab=_72196_/X }
C {devices/lab_pin.sym} 44860 -4010 0 0 {name=p44764 lab=_85338_/Q }
C {devices/lab_pin.sym} 44860 -3970 0 0 {name=p44765 lab=_72120_/X }
C {devices/lab_pin.sym} 45020 -4010 0 1 {name=p44766 lab=_72207_/X }
C {sky130_stdcells/o21a_4.sym} 44940 -4010 0 0 {name=X_72207_ }
C {devices/lab_pin.sym} 44900 -3870 0 0 {name=p44767 lab=_83025_/Q }
C {devices/lab_pin.sym} 44980 -3870 0 1 {name=p44768 lab=_45156_/A }
C {sky130_stdcells/inv_2.sym} 44940 -3870 0 0 {name=X_45155_ }
C {devices/lab_pin.sym} 44900 -3750 0 0 {name=p44769 lab=_42367_/A }
C {devices/lab_pin.sym} 44980 -3750 0 1 {name=p44770 lab=_42367_/Y }
C {sky130_stdcells/inv_2.sym} 44940 -3750 0 0 {name=X_42367_ }
C {devices/lab_pin.sym} 44860 -3660 0 0 {name=p44771 lab=_44189_/X }
C {devices/lab_pin.sym} 44860 -3620 0 0 {name=p44772 lab=_83065_/Q }
C {devices/lab_pin.sym} 44860 -3580 0 0 {name=p44773 lab=_73238_/A }
C {devices/lab_pin.sym} 44860 -3540 0 0 {name=p44774 lab=_73186_/X }
C {devices/lab_pin.sym} 45020 -3600 0 1 {name=p44775 lab=_73188_/B }
C {sky130_stdcells/a211o_4.sym} 44940 -3600 0 0 {name=X_73187_ }
C {devices/lab_pin.sym} 44900 -3450 0 0 {name=p44776 lab=DATA_TO_HASH[1] }
C {devices/lab_pin.sym} 44980 -3450 0 1 {name=p44777 lab=_70400_/A }
C {sky130_stdcells/buf_2.sym} 44940 -3450 0 0 {name=X_70399_ }
C {devices/lab_pin.sym} 44880 -3350 0 0 {name=p44778 lab=_44104_/Y }
C {devices/lab_pin.sym} 44880 -3310 0 0 {name=p44779 lab=_86840_/Q }
C {devices/lab_pin.sym} 44880 -3270 0 0 {name=p44780 lab=_44106_/C }
C {devices/lab_pin.sym} 45000 -3310 0 1 {name=p44781 lab=_44107_/C }
C {sky130_stdcells/nand3_4.sym} 44940 -3310 0 0 {name=X_44106_ }
C {devices/lab_pin.sym} 44880 -3180 0 0 {name=p44782 lab=_79796_/X }
C {devices/lab_pin.sym} 44880 -3140 0 0 {name=p44783 lab=_79798_/B }
C {devices/lab_pin.sym} 45000 -3160 0 1 {name=p44784 lab=_79803_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -3160 0 0 {name=X_79803_ }
C {devices/lab_pin.sym} 44900 -3030 0 0 {name=p44785 lab=_41317_/Y }
C {devices/lab_pin.sym} 44980 -3030 0 1 {name=p44786 lab=_88237_/D }
C {sky130_stdcells/inv_2.sym} 44940 -3030 0 0 {name=X_41318_ }
C {devices/lab_pin.sym} 44900 -2910 0 0 {name=p44787 lab=_60152_/A }
C {devices/lab_pin.sym} 44980 -2910 0 1 {name=p44788 lab=_60153_/C }
C {sky130_stdcells/inv_2.sym} 44940 -2910 0 0 {name=X_60152_ }
C {devices/lab_pin.sym} 44900 -2790 0 0 {name=p44789 lab=_59255_/A }
C {devices/lab_pin.sym} 44980 -2790 0 1 {name=p44790 lab=_72277_/A }
C {sky130_stdcells/buf_2.sym} 44940 -2790 0 0 {name=X_72138_ }
C {devices/lab_pin.sym} 44860 -2690 0 0 {name=p44791 lab=_72294_/B }
C {devices/lab_pin.sym} 44860 -2650 0 0 {name=p44792 lab=_49960_/X }
C {devices/lab_pin.sym} 44860 -2610 0 0 {name=p44793 lab=_49962_/Y }
C {devices/lab_pin.sym} 45020 -2650 0 1 {name=p44794 lab=_49963_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -2650 0 0 {name=X_49963_ }
C {devices/lab_pin.sym} 44860 -2530 0 0 {name=p44795 lab=_45078_/X }
C {devices/lab_pin.sym} 44860 -2490 0 0 {name=p44796 lab=_45083_/Y }
C {devices/lab_pin.sym} 44860 -2450 0 0 {name=p44797 lab=_45085_/Y }
C {devices/lab_pin.sym} 45020 -2490 0 1 {name=p44798 lab=_45086_/Y }
C {sky130_stdcells/a21oi_4.sym} 44940 -2490 0 0 {name=X_45086_ }
C {devices/lab_pin.sym} 44900 -2350 0 0 {name=p44799 lab=_42276_/A }
C {devices/lab_pin.sym} 44980 -2350 0 1 {name=p44800 lab=_42298_/X }
C {sky130_stdcells/buf_2.sym} 44940 -2350 0 0 {name=X_42298_ }
C {devices/lab_pin.sym} 44900 -2230 0 0 {name=p44801 lab=_82079_/Q }
C {devices/lab_pin.sym} 44980 -2230 0 1 {name=p44802 lab=_77997_/A }
C {sky130_stdcells/inv_2.sym} 44940 -2230 0 0 {name=X_77995_ }
C {devices/lab_pin.sym} 44880 -2120 0 0 {name=p44803 lab=_48914_/A }
C {devices/lab_pin.sym} 44880 -2080 0 0 {name=p44804 lab=_48914_/B }
C {devices/lab_pin.sym} 45000 -2100 0 1 {name=p44805 lab=_50578_/A }
C {sky130_stdcells/nor2_4.sym} 44940 -2100 0 0 {name=X_48914_ }
C {devices/lab_pin.sym} 44900 -1970 0 0 {name=p44806 lab=_44036_/Y }
C {devices/lab_pin.sym} 44980 -1970 0 1 {name=p44807 lab=_44037_/X }
C {sky130_stdcells/buf_2.sym} 44940 -1970 0 0 {name=X_44037_ }
C {devices/lab_pin.sym} 44880 -1860 0 0 {name=p44808 lab=_79732_/X }
C {devices/lab_pin.sym} 44880 -1820 0 0 {name=p44809 lab=_79739_/B }
C {devices/lab_pin.sym} 45000 -1840 0 1 {name=p44810 lab=_79734_/Y }
C {sky130_stdcells/xnor2_4.sym} 44940 -1840 0 0 {name=X_79734_ }
C {devices/lab_pin.sym} 44860 -1730 0 0 {name=p44811 lab=_41184_/X }
C {devices/lab_pin.sym} 44860 -1690 0 0 {name=p44812 lab=_40727_/A }
C {devices/lab_pin.sym} 44860 -1650 0 0 {name=p44813 lab=_41248_/X }
C {devices/lab_pin.sym} 45020 -1690 0 1 {name=p44814 lab=_41249_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -1690 0 0 {name=X_41249_ }
C {devices/lab_pin.sym} 44860 -1570 0 0 {name=p44815 lab=_64955_/X }
C {devices/lab_pin.sym} 44860 -1530 0 0 {name=p44816 lab=_64958_/X }
C {devices/lab_pin.sym} 44860 -1490 0 0 {name=p44817 lab=_64959_/X }
C {devices/lab_pin.sym} 45020 -1530 0 1 {name=p44818 lab=_64960_/X }
C {sky130_stdcells/a21o_4.sym} 44940 -1530 0 0 {name=X_64960_ }
C {devices/lab_pin.sym} 44900 -1390 0 0 {name=p44819 lab=_62463_/A }
C {devices/lab_pin.sym} 44980 -1390 0 1 {name=p44820 lab=_60084_/A }
C {sky130_stdcells/buf_2.sym} 44940 -1390 0 0 {name=X_60083_ }
C {devices/lab_pin.sym} 44860 -1290 0 0 {name=p44821 lab=_83291_/Q }
C {devices/lab_pin.sym} 44860 -1250 0 0 {name=p44822 lab=_72066_/X }
C {devices/lab_pin.sym} 44860 -1210 0 0 {name=p44823 lab=_72068_/Y }
C {devices/lab_pin.sym} 45020 -1250 0 1 {name=p44824 lab=_72069_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -1250 0 0 {name=X_72069_ }
C {devices/lab_pin.sym} 44880 -1120 0 0 {name=p44825 lab=_81376_/D }
C {devices/lab_pin.sym} 44880 -1080 0 0 {name=p44826 lab=_76946_/B }
C {devices/lab_pin.sym} 45000 -1100 0 1 {name=p44827 lab=_76946_/X }
C {sky130_stdcells/and2_4.sym} 44940 -1100 0 0 {name=X_76946_ }
C {devices/lab_pin.sym} 44860 -990 0 0 {name=p44828 lab=_49892_/Y }
C {devices/lab_pin.sym} 44860 -950 0 0 {name=p44829 lab=_49870_/X }
C {devices/lab_pin.sym} 44860 -910 0 0 {name=p44830 lab=_49893_/X }
C {devices/lab_pin.sym} 45020 -950 0 1 {name=p44831 lab=_49894_/Y }
C {sky130_stdcells/a21oi_4.sym} 44940 -950 0 0 {name=X_49894_ }
C {devices/lab_pin.sym} 44860 -850 0 0 {name=p44832 lab=_63903_/X }
C {devices/lab_pin.sym} 44860 -810 0 0 {name=p44833 lab=_63890_/X }
C {devices/lab_pin.sym} 44860 -770 0 0 {name=p44834 lab=_63905_/Y }
C {devices/lab_pin.sym} 44860 -730 0 0 {name=p44835 lab=_63908_/Y }
C {devices/lab_pin.sym} 44860 -700 0 0 {name=p44836 lab=_63910_/X }
C {devices/lab_pin.sym} 45020 -770 0 1 {name=p44837 lab=_63911_/X }
C {sky130_stdcells/a41o_4.sym} 44940 -770 0 0 {name=X_63911_ }
C {devices/lab_pin.sym} 45800 -42170 0 0 {name=p44838 lab=_48845_/A }
C {devices/lab_pin.sym} 45800 -42130 0 0 {name=p44839 lab=_48849_/B }
C {devices/lab_pin.sym} 45800 -42090 0 0 {name=p44840 lab=_48849_/C }
C {devices/lab_pin.sym} 45920 -42130 0 1 {name=p44841 lab=_48845_/X }
C {sky130_stdcells/and3_4.sym} 45860 -42130 0 0 {name=X_48845_ }
C {devices/lab_pin.sym} 45780 -42010 0 0 {name=p44842 lab=_79652_/X }
C {devices/lab_pin.sym} 45780 -41970 0 0 {name=p44843 lab=_79663_/X }
C {devices/lab_pin.sym} 45780 -41930 0 0 {name=p44844 lab=_79664_/X }
C {devices/lab_pin.sym} 45940 -41970 0 1 {name=p44845 lab=_79665_/Y }
C {sky130_stdcells/a21oi_4.sym} 45860 -41970 0 0 {name=X_79665_ }
C {devices/lab_pin.sym} 45800 -41850 0 0 {name=p44846 lab=_64870_/A }
C {devices/lab_pin.sym} 45800 -41810 0 0 {name=p44847 lab=_64870_/B }
C {devices/lab_pin.sym} 45800 -41770 0 0 {name=p44848 lab=_64891_/C }
C {devices/lab_pin.sym} 45920 -41810 0 1 {name=p44849 lab=_64891_/Y }
C {sky130_stdcells/nor3_4.sym} 45860 -41810 0 0 {name=X_64891_ }
C {devices/lab_pin.sym} 45780 -41690 0 0 {name=p44850 lab=_81498_/Q }
C {devices/lab_pin.sym} 45780 -41650 0 0 {name=p44851 lab=_81370_/D }
C {devices/lab_pin.sym} 45780 -41610 0 0 {name=p44852 lab=_76876_/X }
C {devices/lab_pin.sym} 45940 -41650 0 1 {name=p44853 lab=_76877_/Y }
C {sky130_stdcells/a21oi_4.sym} 45860 -41650 0 0 {name=X_76877_ }
C {devices/lab_pin.sym} 45800 -41520 0 0 {name=p44854 lab=_66602_/A }
C {devices/lab_pin.sym} 45800 -41480 0 0 {name=p44855 lab=_86804_/Q }
C {devices/lab_pin.sym} 45920 -41500 0 1 {name=p44856 lab=_66630_/X }
C {sky130_stdcells/and2_4.sym} 45860 -41500 0 0 {name=X_66630_ }
C {devices/lab_pin.sym} 45800 -41380 0 0 {name=p44857 lab=_78616_/A }
C {devices/lab_pin.sym} 45800 -41340 0 0 {name=p44858 lab=_78616_/B }
C {devices/lab_pin.sym} 45920 -41360 0 1 {name=p44859 lab=_78616_/Y }
C {sky130_stdcells/nor2_4.sym} 45860 -41360 0 0 {name=X_78616_ }
C {devices/lab_pin.sym} 45800 -41260 0 0 {name=p44860 lab=_63836_/Y }
C {devices/lab_pin.sym} 45800 -41220 0 0 {name=p44861 lab=_63838_/Y }
C {devices/lab_pin.sym} 45800 -41180 0 0 {name=p44862 lab=_63840_/Y }
C {devices/lab_pin.sym} 45800 -41140 0 0 {name=p44863 lab=_63841_/Y }
C {devices/lab_pin.sym} 45920 -41200 0 1 {name=p44864 lab=_63842_/X }
C {sky130_stdcells/and4_4.sym} 45860 -41200 0 0 {name=X_63842_ }
C {devices/lab_pin.sym} 45820 -41050 0 0 {name=p44865 lab=_80926_/Q }
C {devices/lab_pin.sym} 45900 -41050 0 1 {name=p44866 lab=_75830_/A }
C {sky130_stdcells/inv_2.sym} 45860 -41050 0 0 {name=X_75828_ }
C {devices/lab_pin.sym} 45780 -40950 0 0 {name=p44867 lab=_48774_/Y }
C {devices/lab_pin.sym} 45780 -40910 0 0 {name=p44868 lab=_48760_/X }
C {devices/lab_pin.sym} 45780 -40870 0 0 {name=p44869 lab=_48775_/X }
C {devices/lab_pin.sym} 45940 -40910 0 1 {name=p44870 lab=_86485_/D }
C {sky130_stdcells/a21oi_4.sym} 45860 -40910 0 0 {name=X_48776_ }
C {devices/lab_pin.sym} 45780 -40790 0 0 {name=p44871 lab=_79580_/A }
C {devices/lab_pin.sym} 45780 -40750 0 0 {name=p44872 lab=_79580_/B }
C {devices/lab_pin.sym} 45780 -40710 0 0 {name=p44873 lab=_79575_/Y }
C {devices/lab_pin.sym} 45940 -40750 0 1 {name=p44874 lab=_79596_/Y }
C {sky130_stdcells/o21ai_4.sym} 45860 -40750 0 0 {name=X_79596_ }
C {devices/lab_pin.sym} 45780 -40650 0 0 {name=p44875 lab=_45980_/X }
C {devices/lab_pin.sym} 45780 -40610 0 0 {name=p44876 lab=_45987_/X }
C {devices/lab_pin.sym} 45780 -40570 0 0 {name=p44877 lab=_40439_/X }
C {devices/lab_pin.sym} 45780 -40530 0 0 {name=p44878 lab=_86826_/Q }
C {devices/lab_pin.sym} 45780 -40490 0 0 {name=p44879 lab=_45982_/X }
C {devices/lab_pin.sym} 45940 -40570 0 1 {name=p44880 lab=_45989_/A }
C {sky130_stdcells/o32ai_4.sym} 45860 -40570 0 0 {name=X_45988_ }
C {devices/lab_pin.sym} 45800 -40420 0 0 {name=p44881 lab=_47715_/X }
C {devices/lab_pin.sym} 45800 -40380 0 0 {name=p44882 lab=_53209_/B }
C {devices/lab_pin.sym} 45920 -40400 0 1 {name=p44883 lab=_47727_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -40400 0 0 {name=X_47727_ }
C {devices/lab_pin.sym} 45820 -40270 0 0 {name=p44884 lab=_66560_/X }
C {devices/lab_pin.sym} 45900 -40270 0 1 {name=p44885 lab=_69582_/A }
C {sky130_stdcells/buf_2.sym} 45860 -40270 0 0 {name=X_66561_ }
C {devices/lab_pin.sym} 45800 -40160 0 0 {name=p44886 lab=_78547_/A }
C {devices/lab_pin.sym} 45800 -40120 0 0 {name=p44887 lab=_82674_/D }
C {devices/lab_pin.sym} 45920 -40140 0 1 {name=p44888 lab=_78547_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -40140 0 0 {name=X_78547_ }
C {devices/lab_pin.sym} 45800 -40020 0 0 {name=p44889 lab=_44937_/Y }
C {devices/lab_pin.sym} 45800 -39980 0 0 {name=p44890 lab=_44939_/B }
C {devices/lab_pin.sym} 45920 -40000 0 1 {name=p44891 lab=_44939_/X }
C {sky130_stdcells/and2_4.sym} 45860 -40000 0 0 {name=X_44939_ }
C {devices/lab_pin.sym} 45820 -39870 0 0 {name=p44892 lab=_60867_/Y }
C {devices/lab_pin.sym} 45900 -39870 0 1 {name=p44893 lab=_64026_/A }
C {sky130_stdcells/buf_2.sym} 45860 -39870 0 0 {name=X_63773_ }
C {devices/lab_pin.sym} 45800 -39760 0 0 {name=p44894 lab=_75759_/A }
C {devices/lab_pin.sym} 45800 -39720 0 0 {name=p44895 lab=_75759_/B }
C {devices/lab_pin.sym} 45920 -39740 0 1 {name=p44896 lab=_75760_/B }
C {sky130_stdcells/xor2_4.sym} 45860 -39740 0 0 {name=X_75759_ }
C {devices/lab_pin.sym} 45780 -39640 0 0 {name=p44897 lab=_60911_/X }
C {devices/lab_pin.sym} 45780 -39600 0 0 {name=p44898 lab=_60921_/X }
C {devices/lab_pin.sym} 45780 -39560 0 0 {name=p44899 lab=_63738_/B }
C {devices/lab_pin.sym} 45780 -39520 0 0 {name=p44900 lab=_63738_/D }
C {devices/lab_pin.sym} 45940 -39580 0 1 {name=p44901 lab=_60985_/Y }
C {sky130_stdcells/a22oi_4.sym} 45860 -39580 0 0 {name=X_60985_ }
C {devices/lab_pin.sym} 45820 -39430 0 0 {name=p44902 lab=_64731_/A }
C {devices/lab_pin.sym} 45900 -39430 0 1 {name=p44903 lab=_68300_/X }
C {sky130_stdcells/buf_2.sym} 45860 -39430 0 0 {name=X_68300_ }
C {devices/lab_pin.sym} 45800 -39320 0 0 {name=p44904 lab=_65512_/A }
C {devices/lab_pin.sym} 45800 -39280 0 0 {name=p44905 lab=_65511_/Y }
C {devices/lab_pin.sym} 45920 -39300 0 1 {name=p44906 lab=_65512_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -39300 0 0 {name=X_65512_ }
C {devices/lab_pin.sym} 45820 -39170 0 0 {name=p44907 lab=_60199_/X }
C {devices/lab_pin.sym} 45900 -39170 0 1 {name=p44908 lab=_62738_/D }
C {sky130_stdcells/buf_2.sym} 45860 -39170 0 0 {name=X_62724_ }
C {devices/lab_pin.sym} 45780 -39080 0 0 {name=p44909 lab=_87029_/Q }
C {devices/lab_pin.sym} 45780 -39040 0 0 {name=p44910 lab=_69277_/X }
C {devices/lab_pin.sym} 45780 -39000 0 0 {name=p44911 lab=_69278_/X }
C {devices/lab_pin.sym} 45780 -38960 0 0 {name=p44912 lab=_69279_/X }
C {devices/lab_pin.sym} 45940 -39020 0 1 {name=p44913 lab=_69280_/X }
C {sky130_stdcells/a211o_4.sym} 45860 -39020 0 0 {name=X_69280_ }
C {devices/lab_pin.sym} 45820 -38870 0 0 {name=p44914 lab=_54867_/B }
C {devices/lab_pin.sym} 45900 -38870 0 1 {name=p44915 lab=_53174_/B }
C {sky130_stdcells/buf_2.sym} 45860 -38870 0 0 {name=X_47658_ }
C {devices/lab_pin.sym} 45820 -38750 0 0 {name=p44916 lab=_66391_/A }
C {devices/lab_pin.sym} 45900 -38750 0 1 {name=p44917 lab=_66521_/B }
C {sky130_stdcells/buf_2.sym} 45860 -38750 0 0 {name=X_66492_ }
C {devices/lab_pin.sym} 45800 -38640 0 0 {name=p44918 lab=_78464_/X }
C {devices/lab_pin.sym} 45800 -38600 0 0 {name=p44919 lab=_78478_/B }
C {devices/lab_pin.sym} 45920 -38620 0 1 {name=p44920 lab=_78478_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -38620 0 0 {name=X_78478_ }
C {devices/lab_pin.sym} 45780 -38510 0 0 {name=p44921 lab=_84006_/Q }
C {devices/lab_pin.sym} 45780 -38470 0 0 {name=p44922 lab=_68220_/X }
C {devices/lab_pin.sym} 45780 -38430 0 0 {name=p44923 lab=_68230_/X }
C {devices/lab_pin.sym} 45940 -38470 0 1 {name=p44924 lab=_84006_/D }
C {sky130_stdcells/a21bo_4.sym} 45860 -38470 0 0 {name=X_68231_ }
C {devices/lab_pin.sym} 45780 -38350 0 0 {name=p44925 lab=_86721_/Q }
C {devices/lab_pin.sym} 45780 -38310 0 0 {name=p44926 lab=_46474_/X }
C {devices/lab_pin.sym} 45780 -38270 0 0 {name=p44927 lab=_46608_/Y }
C {devices/lab_pin.sym} 45940 -38310 0 1 {name=p44928 lab=_46609_/Y }
C {sky130_stdcells/o21ai_4.sym} 45860 -38310 0 0 {name=X_46609_ }
C {devices/lab_pin.sym} 45780 -38190 0 0 {name=p44929 lab=_65440_/X }
C {devices/lab_pin.sym} 45780 -38150 0 0 {name=p44930 lab=_65442_/X }
C {devices/lab_pin.sym} 45780 -38110 0 0 {name=p44931 lab=_65389_/X }
C {devices/lab_pin.sym} 45940 -38150 0 1 {name=p44932 lab=_65446_/A }
C {sky130_stdcells/a21o_4.sym} 45860 -38150 0 0 {name=X_65443_ }
C {devices/lab_pin.sym} 45820 -38010 0 0 {name=p44933 lab=_77428_/X }
C {devices/lab_pin.sym} 45900 -38010 0 1 {name=p44934 lab=_77431_/B }
C {sky130_stdcells/inv_2.sym} 45860 -38010 0 0 {name=X_77429_ }
C {devices/lab_pin.sym} 45800 -37900 0 0 {name=p44935 lab=_60204_/A }
C {devices/lab_pin.sym} 45800 -37860 0 0 {name=p44936 lab=_60156_/Y }
C {devices/lab_pin.sym} 45920 -37880 0 1 {name=p44937 lab=_62655_/Y }
C {sky130_stdcells/nor2_4.sym} 45860 -37880 0 0 {name=X_62655_ }
C {devices/lab_pin.sym} 45820 -37750 0 0 {name=p44938 lab=_83706_/Q }
C {devices/lab_pin.sym} 45900 -37750 0 1 {name=p44939 lab=_47589_/Y }
C {sky130_stdcells/inv_2.sym} 45860 -37750 0 0 {name=X_47589_ }
C {devices/lab_pin.sym} 45820 -37630 0 0 {name=p44940 lab=clkbuf_7_50_0_CLK/A }
C {devices/lab_pin.sym} 45900 -37630 0 1 {name=p44941 lab=clkbuf_7_51_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 45860 -37630 0 0 {name=Xclkbuf_7_51_0_CLK }
C {devices/lab_pin.sym} 45800 -37520 0 0 {name=p44942 lab=_49327_/X }
C {devices/lab_pin.sym} 45800 -37480 0 0 {name=p44943 lab=_50850_/B }
C {devices/lab_pin.sym} 45920 -37500 0 1 {name=p44944 lab=_49328_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -37500 0 0 {name=X_49328_ }
C {devices/lab_pin.sym} 45780 -37390 0 0 {name=p44945 lab=_61602_/X }
C {devices/lab_pin.sym} 45780 -37350 0 0 {name=p44946 lab=_61576_/X }
C {devices/lab_pin.sym} 45780 -37310 0 0 {name=p44947 lab=_61605_/Y }
C {devices/lab_pin.sym} 45940 -37350 0 1 {name=p44948 lab=_84467_/D }
C {sky130_stdcells/a21oi_4.sym} 45860 -37350 0 0 {name=X_61606_ }
C {devices/lab_pin.sym} 45780 -37230 0 0 {name=p44949 lab=_59216_/Y }
C {devices/lab_pin.sym} 45780 -37190 0 0 {name=p44950 lab=_66177_/C }
C {devices/lab_pin.sym} 45780 -37150 0 0 {name=p44951 lab=_80439_/Y }
C {devices/lab_pin.sym} 45940 -37190 0 1 {name=p44952 lab=_80458_/A }
C {sky130_stdcells/o21a_4.sym} 45860 -37190 0 0 {name=X_80440_ }
C {devices/lab_pin.sym} 45780 -37080 0 0 {name=p44953 lab=_68155_/X }
C {devices/lab_pin.sym} 45780 -37040 0 0 {name=p44954 lab=_67005_/Y }
C {devices/lab_pin.sym} 45780 -37000 0 0 {name=p44955 lab=_68148_/X }
C {devices/lab_pin.sym} 45780 -36960 0 0 {name=p44956 lab=_68161_/Y }
C {devices/lab_pin.sym} 45940 -37020 0 1 {name=p44957 lab=_68162_/X }
C {sky130_stdcells/a211o_4.sym} 45860 -37020 0 0 {name=X_68162_ }
C {devices/lab_pin.sym} 45780 -36890 0 0 {name=p44958 lab=_65370_/Y }
C {devices/lab_pin.sym} 45780 -36850 0 0 {name=p44959 lab=_65347_/X }
C {devices/lab_pin.sym} 45780 -36810 0 0 {name=p44960 lab=_65373_/Y }
C {devices/lab_pin.sym} 45940 -36850 0 1 {name=p44961 lab=_84204_/D }
C {sky130_stdcells/a21o_4.sym} 45860 -36850 0 0 {name=X_65374_ }
C {devices/lab_pin.sym} 45820 -36710 0 0 {name=p44962 lab=clkbuf_7_95_0_CLK/X }
C {devices/lab_pin.sym} 45900 -36710 0 1 {name=p44963 lab=clkbuf_9_382_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 45860 -36710 0 0 {name=Xclkbuf_8_191_0_CLK }
C {devices/lab_pin.sym} 45800 -36620 0 0 {name=p44964 lab=_61655_/A }
C {devices/lab_pin.sym} 45800 -36580 0 0 {name=p44965 lab=_62566_/B }
C {devices/lab_pin.sym} 45800 -36540 0 0 {name=p44966 lab=_62501_/X }
C {devices/lab_pin.sym} 45800 -36500 0 0 {name=p44967 lab=_62597_/D }
C {devices/lab_pin.sym} 45920 -36560 0 1 {name=p44968 lab=_62586_/Y }
C {sky130_stdcells/nand4_4.sym} 45860 -36560 0 0 {name=X_62586_ }
C {devices/lab_pin.sym} 45820 -36410 0 0 {name=p44969 lab=_66410_/A }
C {devices/lab_pin.sym} 45900 -36410 0 1 {name=p44970 lab=_67113_/X }
C {sky130_stdcells/buf_2.sym} 45860 -36410 0 0 {name=X_67113_ }
C {devices/lab_pin.sym} 45780 -36310 0 0 {name=p44971 lab=_58317_/A }
C {devices/lab_pin.sym} 45780 -36270 0 0 {name=p44972 lab=_64308_/X }
C {devices/lab_pin.sym} 45780 -36230 0 0 {name=p44973 lab=_64324_/Y }
C {devices/lab_pin.sym} 45940 -36270 0 1 {name=p44974 lab=_64325_/Y }
C {sky130_stdcells/o21ai_4.sym} 45860 -36270 0 0 {name=X_64325_ }
C {devices/lab_pin.sym} 45800 -36140 0 0 {name=p44975 lab=_49263_/A }
C {devices/lab_pin.sym} 45800 -36100 0 0 {name=p44976 lab=_53993_/B }
C {devices/lab_pin.sym} 45920 -36120 0 1 {name=p44977 lab=_49259_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -36120 0 0 {name=X_49259_ }
C {devices/lab_pin.sym} 45780 -36010 0 0 {name=p44978 lab=_61533_/X }
C {devices/lab_pin.sym} 45780 -35970 0 0 {name=p44979 lab=_61517_/X }
C {devices/lab_pin.sym} 45780 -35930 0 0 {name=p44980 lab=_61536_/Y }
C {devices/lab_pin.sym} 45940 -35970 0 1 {name=p44981 lab=_61537_/Y }
C {sky130_stdcells/a21oi_4.sym} 45860 -35970 0 0 {name=X_61537_ }
C {devices/lab_pin.sym} 45800 -35840 0 0 {name=p44982 lab=_80371_/A }
C {devices/lab_pin.sym} 45800 -35800 0 0 {name=p44983 lab=_80371_/B }
C {devices/lab_pin.sym} 45920 -35820 0 1 {name=p44984 lab=_80372_/B }
C {sky130_stdcells/xor2_4.sym} 45860 -35820 0 0 {name=X_80371_ }
C {devices/lab_pin.sym} 45780 -35710 0 0 {name=p44985 lab=_66607_/X }
C {devices/lab_pin.sym} 45780 -35670 0 0 {name=p44986 lab=_66610_/X }
C {devices/lab_pin.sym} 45780 -35630 0 0 {name=p44987 lab=_67897_/X }
C {devices/lab_pin.sym} 45940 -35670 0 1 {name=p44988 lab=_68093_/Y }
C {sky130_stdcells/a21oi_4.sym} 45860 -35670 0 0 {name=X_68093_ }
C {devices/lab_pin.sym} 45770 -35530 0 0 {name=p44989 lab=_82860_/CLK }
C {devices/lab_pin.sym} 45770 -35510 0 0 {name=p44990 lab=_82110_/D }
C {devices/lab_pin.sym} 45950 -35530 0 1 {name=p44991 lab=_77208_/A }
C {sky130_stdcells/dfxtp_4.sym} 45860 -35520 0 0 {name=X_82110_ }
C {devices/lab_pin.sym} 45780 -35420 0 0 {name=p44992 lab=_66947_/X }
C {devices/lab_pin.sym} 45780 -35380 0 0 {name=p44993 lab=_67030_/Y }
C {devices/lab_pin.sym} 45780 -35340 0 0 {name=p44994 lab=_67031_/X }
C {devices/lab_pin.sym} 45780 -35300 0 0 {name=p44995 lab=_67043_/Y }
C {devices/lab_pin.sym} 45940 -35360 0 1 {name=p44996 lab=_67044_/X }
C {sky130_stdcells/a211o_4.sym} 45860 -35360 0 0 {name=X_67044_ }
C {devices/lab_pin.sym} 45820 -35210 0 0 {name=p44997 lab=_52126_/A }
C {devices/lab_pin.sym} 45900 -35210 0 1 {name=p44998 lab=_52271_/A }
C {sky130_stdcells/buf_2.sym} 45860 -35210 0 0 {name=X_52270_ }
C {devices/lab_pin.sym} 45820 -35090 0 0 {name=p44999 lab=_64315_/A }
C {devices/lab_pin.sym} 45900 -35090 0 1 {name=p45000 lab=_64301_/B }
C {sky130_stdcells/buf_2.sym} 45860 -35090 0 0 {name=X_64256_ }
C {devices/lab_pin.sym} 45770 -34970 0 0 {name=p45001 lab=_81627_/CLK }
C {devices/lab_pin.sym} 45770 -34950 0 0 {name=p45002 lab=_83090_/D }
C {devices/lab_pin.sym} 45950 -34970 0 1 {name=p45003 lab=_83090_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -34960 0 0 {name=X_83090_ }
C {devices/lab_pin.sym} 45800 -34860 0 0 {name=p45004 lab=_61468_/A }
C {devices/lab_pin.sym} 45800 -34820 0 0 {name=p45005 lab=_61468_/B }
C {devices/lab_pin.sym} 45800 -34780 0 0 {name=p45006 lab=_61467_/X }
C {devices/lab_pin.sym} 45800 -34740 0 0 {name=p45007 lab=_61451_/D }
C {devices/lab_pin.sym} 45920 -34800 0 1 {name=p45008 lab=_61468_/Y }
C {sky130_stdcells/nand4_4.sym} 45860 -34800 0 0 {name=X_61468_ }
C {devices/lab_pin.sym} 45820 -34650 0 0 {name=p45009 lab=clkbuf_7_67_0_CLK/A }
C {devices/lab_pin.sym} 45900 -34650 0 1 {name=p45010 lab=clkbuf_7_66_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 45860 -34650 0 0 {name=Xclkbuf_7_66_0_CLK }
C {devices/lab_pin.sym} 45780 -34550 0 0 {name=p45011 lab=_51217_/Y }
C {devices/lab_pin.sym} 45780 -34510 0 0 {name=p45012 lab=_51201_/X }
C {devices/lab_pin.sym} 45780 -34470 0 0 {name=p45013 lab=_51220_/X }
C {devices/lab_pin.sym} 45940 -34510 0 1 {name=p45014 lab=_51221_/Y }
C {sky130_stdcells/a21oi_4.sym} 45860 -34510 0 0 {name=X_51221_ }
C {devices/lab_pin.sym} 45780 -34410 0 0 {name=p45015 lab=_63201_/Y }
C {devices/lab_pin.sym} 45780 -34370 0 0 {name=p45016 lab=_63202_/X }
C {devices/lab_pin.sym} 45780 -34330 0 0 {name=p45017 lab=_63205_/X }
C {devices/lab_pin.sym} 45780 -34290 0 0 {name=p45018 lab=_63206_/X }
C {devices/lab_pin.sym} 45780 -34250 0 0 {name=p45019 lab=_63183_/X }
C {devices/lab_pin.sym} 45940 -34330 0 1 {name=p45020 lab=_63207_/Y }
C {sky130_stdcells/o41ai_4.sym} 45860 -34330 0 0 {name=X_63207_ }
C {devices/lab_pin.sym} 45770 -34170 0 0 {name=p45021 lab=_82009_/CLK }
C {devices/lab_pin.sym} 45770 -34150 0 0 {name=p45022 lab=_77942_/B }
C {devices/lab_pin.sym} 45950 -34170 0 1 {name=p45023 lab=_82041_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -34160 0 0 {name=X_82041_ }
C {devices/lab_pin.sym} 45820 -34030 0 0 {name=p45024 lab=_60502_/A }
C {devices/lab_pin.sym} 45900 -34030 0 1 {name=p45025 lab=_60420_/A }
C {sky130_stdcells/buf_2.sym} 45860 -34030 0 0 {name=X_60419_ }
C {devices/lab_pin.sym} 45800 -33930 0 0 {name=p45026 lab=_64187_/A }
C {devices/lab_pin.sym} 45800 -33890 0 0 {name=p45027 lab=_64187_/B }
C {devices/lab_pin.sym} 45800 -33850 0 0 {name=p45028 lab=_79908_/B }
C {devices/lab_pin.sym} 45920 -33890 0 1 {name=p45029 lab=_64187_/Y }
C {sky130_stdcells/nor3_4.sym} 45860 -33890 0 0 {name=X_64187_ }
C {devices/lab_pin.sym} 45820 -33750 0 0 {name=p45030 lab=_84851_/Q }
C {devices/lab_pin.sym} 45900 -33750 0 1 {name=p45031 lab=_61399_/X }
C {sky130_stdcells/buf_2.sym} 45860 -33750 0 0 {name=X_61399_ }
C {devices/lab_pin.sym} 45800 -33640 0 0 {name=p45032 lab=_51130_/A }
C {devices/lab_pin.sym} 45800 -33600 0 0 {name=p45033 lab=_52843_/B }
C {devices/lab_pin.sym} 45920 -33620 0 1 {name=p45034 lab=_51152_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -33620 0 0 {name=X_51152_ }
C {devices/lab_pin.sym} 45780 -33530 0 0 {name=p45035 lab=_63132_/Y }
C {devices/lab_pin.sym} 45780 -33490 0 0 {name=p45036 lab=_63133_/X }
C {devices/lab_pin.sym} 45780 -33450 0 0 {name=p45037 lab=_63135_/X }
C {devices/lab_pin.sym} 45780 -33410 0 0 {name=p45038 lab=_63137_/X }
C {devices/lab_pin.sym} 45780 -33370 0 0 {name=p45039 lab=_63125_/X }
C {devices/lab_pin.sym} 45940 -33450 0 1 {name=p45040 lab=_63138_/Y }
C {sky130_stdcells/o41ai_4.sym} 45860 -33450 0 0 {name=X_63138_ }
C {devices/lab_pin.sym} 45780 -33320 0 0 {name=p45041 lab=_86982_/Q }
C {devices/lab_pin.sym} 45780 -33280 0 0 {name=p45042 lab=_68948_/X }
C {devices/lab_pin.sym} 45780 -33240 0 0 {name=p45043 lab=_68993_/X }
C {devices/lab_pin.sym} 45780 -33200 0 0 {name=p45044 lab=_68994_/X }
C {devices/lab_pin.sym} 45940 -33260 0 1 {name=p45045 lab=_68995_/X }
C {sky130_stdcells/a211o_4.sym} 45860 -33260 0 0 {name=X_68995_ }
C {devices/lab_pin.sym} 45800 -33120 0 0 {name=p45046 lab=_50103_/A }
C {devices/lab_pin.sym} 45800 -33080 0 0 {name=p45047 lab=_48982_/X }
C {devices/lab_pin.sym} 45920 -33100 0 1 {name=p45048 lab=_50103_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -33100 0 0 {name=X_50103_ }
C {devices/lab_pin.sym} 45770 -32970 0 0 {name=p45049 lab=_85800_/CLK }
C {devices/lab_pin.sym} 45770 -32950 0 0 {name=p45050 lab=_85800_/D }
C {devices/lab_pin.sym} 45950 -32970 0 1 {name=p45051 lab=_85800_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -32960 0 0 {name=X_85800_ }
C {devices/lab_pin.sym} 45820 -32830 0 0 {name=p45052 lab=_51191_/A }
C {devices/lab_pin.sym} 45900 -32830 0 1 {name=p45053 lab=_51084_/A }
C {sky130_stdcells/buf_2.sym} 45860 -32830 0 0 {name=X_51083_ }
C {devices/lab_pin.sym} 45800 -32720 0 0 {name=p45054 lab=_55691_/A }
C {devices/lab_pin.sym} 45800 -32680 0 0 {name=p45055 lab=_55960_/B }
C {devices/lab_pin.sym} 45920 -32700 0 1 {name=p45056 lab=_55960_/X }
C {sky130_stdcells/and2_4.sym} 45860 -32700 0 0 {name=X_55960_ }
C {devices/lab_pin.sym} 45780 -32600 0 0 {name=p45057 lab=_67782_/X }
C {devices/lab_pin.sym} 45780 -32560 0 0 {name=p45058 lab=_67934_/Y }
C {devices/lab_pin.sym} 45780 -32520 0 0 {name=p45059 lab=_67863_/X }
C {devices/lab_pin.sym} 45780 -32480 0 0 {name=p45060 lab=_67945_/Y }
C {devices/lab_pin.sym} 45940 -32540 0 1 {name=p45061 lab=_67946_/X }
C {sky130_stdcells/a211o_4.sym} 45860 -32540 0 0 {name=X_67946_ }
C {devices/lab_pin.sym} 45800 -32420 0 0 {name=p45062 lab=_63069_/A }
C {devices/lab_pin.sym} 45800 -32380 0 0 {name=p45063 lab=_63081_/B }
C {devices/lab_pin.sym} 45800 -32340 0 0 {name=p45064 lab=_63081_/C }
C {devices/lab_pin.sym} 45800 -32300 0 0 {name=p45065 lab=_63033_/D }
C {devices/lab_pin.sym} 45920 -32360 0 1 {name=p45066 lab=_63069_/X }
C {sky130_stdcells/or4_4.sym} 45860 -32360 0 0 {name=X_63069_ }
C {devices/lab_pin.sym} 45770 -32210 0 0 {name=p45067 lab=_86814_/CLK }
C {devices/lab_pin.sym} 45770 -32190 0 0 {name=p45068 lab=_46075_/Y }
C {devices/lab_pin.sym} 45950 -32210 0 1 {name=p45069 lab=_86780_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -32200 0 0 {name=X_86780_ }
C {devices/lab_pin.sym} 45770 -32070 0 0 {name=p45070 lab=_82896_/CLK }
C {devices/lab_pin.sym} 45770 -32050 0 0 {name=p45071 lab=_83992_/D }
C {devices/lab_pin.sym} 45950 -32070 0 1 {name=p45072 lab=_82640_/D }
C {sky130_stdcells/dfxtp_4.sym} 45860 -32060 0 0 {name=X_83992_ }
C {devices/lab_pin.sym} 45780 -31950 0 0 {name=p45073 lab=_86277_/Q }
C {devices/lab_pin.sym} 45780 -31910 0 0 {name=p45074 lab=_50012_/X }
C {devices/lab_pin.sym} 45780 -31870 0 0 {name=p45075 lab=_50033_/Y }
C {devices/lab_pin.sym} 45940 -31910 0 1 {name=p45076 lab=_50034_/Y }
C {sky130_stdcells/o21ai_4.sym} 45860 -31910 0 0 {name=X_50034_ }
C {devices/lab_pin.sym} 45780 -31790 0 0 {name=p45077 lab=_54908_/Y }
C {devices/lab_pin.sym} 45780 -31750 0 0 {name=p45078 lab=_54909_/X }
C {devices/lab_pin.sym} 45780 -31710 0 0 {name=p45079 lab=_54910_/X }
C {devices/lab_pin.sym} 45940 -31750 0 1 {name=p45080 lab=_85355_/D }
C {sky130_stdcells/a21oi_4.sym} 45860 -31750 0 0 {name=X_54911_ }
C {devices/lab_pin.sym} 45770 -31610 0 0 {name=p45081 lab=_85635_/CLK }
C {devices/lab_pin.sym} 45770 -31590 0 0 {name=p45082 lab=_52917_/Y }
C {devices/lab_pin.sym} 45950 -31610 0 1 {name=p45083 lab=_85731_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -31600 0 0 {name=X_85731_ }
C {devices/lab_pin.sym} 45770 -31470 0 0 {name=p45084 lab=_82925_/CLK }
C {devices/lab_pin.sym} 45770 -31450 0 0 {name=p45085 lab=_78107_/X }
C {devices/lab_pin.sym} 45950 -31470 0 1 {name=p45086 lab=_46274_/A }
C {sky130_stdcells/dfxtp_4.sym} 45860 -31460 0 0 {name=X_82943_ }
C {devices/lab_pin.sym} 45800 -31340 0 0 {name=p45087 lab=_55891_/A }
C {devices/lab_pin.sym} 45800 -31300 0 0 {name=p45088 lab=_55890_/X }
C {devices/lab_pin.sym} 45920 -31320 0 1 {name=p45089 lab=_55891_/X }
C {sky130_stdcells/and2_4.sym} 45860 -31320 0 0 {name=X_55891_ }
C {devices/lab_pin.sym} 45780 -31220 0 0 {name=p45090 lab=_67664_/X }
C {devices/lab_pin.sym} 45780 -31180 0 0 {name=p45091 lab=_67862_/Y }
C {devices/lab_pin.sym} 45780 -31140 0 0 {name=p45092 lab=_67863_/X }
C {devices/lab_pin.sym} 45780 -31100 0 0 {name=p45093 lab=_67876_/Y }
C {devices/lab_pin.sym} 45940 -31160 0 1 {name=p45094 lab=_67877_/X }
C {sky130_stdcells/a211o_4.sym} 45860 -31160 0 0 {name=X_67877_ }
C {devices/lab_pin.sym} 45800 -31020 0 0 {name=p45095 lab=_57630_/A }
C {devices/lab_pin.sym} 45800 -30980 0 0 {name=p45096 lab=_48122_/Y }
C {devices/lab_pin.sym} 45920 -31000 0 1 {name=p45097 lab=_57630_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -31000 0 0 {name=X_57630_ }
C {devices/lab_pin.sym} 45780 -30890 0 0 {name=p45098 lab=_83910_/Q }
C {devices/lab_pin.sym} 45780 -30850 0 0 {name=p45099 lab=_69564_/X }
C {devices/lab_pin.sym} 45780 -30810 0 0 {name=p45100 lab=_69615_/X }
C {devices/lab_pin.sym} 45940 -30850 0 1 {name=p45101 lab=_69616_/X }
C {sky130_stdcells/a21bo_4.sym} 45860 -30850 0 0 {name=X_69616_ }
C {devices/lab_pin.sym} 45780 -30730 0 0 {name=p45102 lab=_85368_/Q }
C {devices/lab_pin.sym} 45780 -30690 0 0 {name=p45103 lab=_54839_/X }
C {devices/lab_pin.sym} 45780 -30650 0 0 {name=p45104 lab=_54841_/Y }
C {devices/lab_pin.sym} 45940 -30690 0 1 {name=p45105 lab=_54842_/Y }
C {sky130_stdcells/o21ai_4.sym} 45860 -30690 0 0 {name=X_54842_ }
C {devices/lab_pin.sym} 45800 -30560 0 0 {name=p45106 lab=_66760_/A }
C {devices/lab_pin.sym} 45800 -30520 0 0 {name=p45107 lab=_66828_/B }
C {devices/lab_pin.sym} 45920 -30540 0 1 {name=p45108 lab=_66828_/X }
C {sky130_stdcells/and2_4.sym} 45860 -30540 0 0 {name=X_66828_ }
C {devices/lab_pin.sym} 45770 -30410 0 0 {name=p45109 lab=_85439_/CLK }
C {devices/lab_pin.sym} 45770 -30390 0 0 {name=p45110 lab=_53285_/Y }
C {devices/lab_pin.sym} 45950 -30410 0 1 {name=p45111 lab=_85662_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -30400 0 0 {name=X_85662_ }
C {devices/lab_pin.sym} 45770 -30270 0 0 {name=p45112 lab=_82855_/CLK }
C {devices/lab_pin.sym} 45770 -30250 0 0 {name=p45113 lab=_78248_/B }
C {devices/lab_pin.sym} 45950 -30270 0 1 {name=p45114 lab=_82874_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -30260 0 0 {name=X_82874_ }
C {devices/lab_pin.sym} 45770 -30130 0 0 {name=p45115 lab=_87397_/CLK }
C {devices/lab_pin.sym} 45770 -30110 0 0 {name=p45116 lab=_87401_/D }
C {devices/lab_pin.sym} 45950 -30130 0 1 {name=p45117 lab=_87401_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -30120 0 0 {name=X_87401_ }
C {devices/lab_pin.sym} 45770 -29990 0 0 {name=p45118 lab=_84606_/CLK }
C {devices/lab_pin.sym} 45770 -29970 0 0 {name=p45119 lab=_60478_/Y }
C {devices/lab_pin.sym} 45950 -29990 0 1 {name=p45120 lab=_79153_/A }
C {sky130_stdcells/dfxtp_4.sym} 45860 -29980 0 0 {name=X_84613_ }
C {devices/lab_pin.sym} 45780 -29870 0 0 {name=p45121 lab=_57559_/Y }
C {devices/lab_pin.sym} 45780 -29830 0 0 {name=p45122 lab=_57543_/X }
C {devices/lab_pin.sym} 45780 -29790 0 0 {name=p45123 lab=_57560_/Y }
C {devices/lab_pin.sym} 45940 -29830 0 1 {name=p45124 lab=_84979_/D }
C {sky130_stdcells/a21boi_4.sym} 45860 -29830 0 0 {name=X_57561_ }
C {devices/lab_pin.sym} 45770 -29690 0 0 {name=p45125 lab=_81695_/CLK }
C {devices/lab_pin.sym} 45770 -29670 0 0 {name=p45126 lab=_81825_/D }
C {devices/lab_pin.sym} 45950 -29690 0 1 {name=p45127 lab=_47226_/A }
C {sky130_stdcells/dfxtp_4.sym} 45860 -29680 0 0 {name=X_81825_ }
C {devices/lab_pin.sym} 45820 -29550 0 0 {name=p45128 lab=clkbuf_7_72_0_CLK/X }
C {devices/lab_pin.sym} 45900 -29550 0 1 {name=p45129 lab=clkbuf_8_144_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 45860 -29550 0 0 {name=Xclkbuf_8_144_0_CLK }
C {devices/lab_pin.sym} 45800 -29440 0 0 {name=p45130 lab=_44022_/X }
C {devices/lab_pin.sym} 45800 -29400 0 0 {name=p45131 lab=_69547_/B }
C {devices/lab_pin.sym} 45920 -29420 0 1 {name=p45132 lab=_69547_/X }
C {sky130_stdcells/and2_4.sym} 45860 -29420 0 0 {name=X_69547_ }
C {devices/lab_pin.sym} 45770 -29290 0 0 {name=p45133 lab=_87116_/CLK }
C {devices/lab_pin.sym} 45770 -29270 0 0 {name=p45134 lab=_40503_/Y }
C {devices/lab_pin.sym} 45950 -29290 0 1 {name=p45135 lab=_88381_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -29280 0 0 {name=X_88381_ }
C {devices/lab_pin.sym} 45780 -29170 0 0 {name=p45136 lab=_85380_/Q }
C {devices/lab_pin.sym} 45780 -29130 0 0 {name=p45137 lab=_54757_/X }
C {devices/lab_pin.sym} 45780 -29090 0 0 {name=p45138 lab=_54772_/Y }
C {devices/lab_pin.sym} 45940 -29130 0 1 {name=p45139 lab=_54773_/Y }
C {sky130_stdcells/o21ai_4.sym} 45860 -29130 0 0 {name=X_54773_ }
C {devices/lab_pin.sym} 45820 -28990 0 0 {name=p45140 lab=_66758_/X }
C {devices/lab_pin.sym} 45900 -28990 0 1 {name=p45141 lab=_66759_/X }
C {sky130_stdcells/buf_2.sym} 45860 -28990 0 0 {name=X_66759_ }
C {devices/lab_pin.sym} 45770 -28870 0 0 {name=p45142 lab=_85593_/CLK }
C {devices/lab_pin.sym} 45770 -28850 0 0 {name=p45143 lab=_85593_/D }
C {devices/lab_pin.sym} 45950 -28870 0 1 {name=p45144 lab=_85593_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -28860 0 0 {name=X_85593_ }
C {devices/lab_pin.sym} 45800 -28740 0 0 {name=p45145 lab=_51947_/A }
C {devices/lab_pin.sym} 45800 -28700 0 0 {name=p45146 lab=_48231_/B }
C {devices/lab_pin.sym} 45920 -28720 0 1 {name=p45147 lab=_51985_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -28720 0 0 {name=X_51985_ }
C {devices/lab_pin.sym} 45800 -28600 0 0 {name=p45148 lab=_86665_/Q }
C {devices/lab_pin.sym} 45800 -28560 0 0 {name=p45149 lab=_59226_/B }
C {devices/lab_pin.sym} 45920 -28580 0 1 {name=p45150 lab=_59300_/Y }
C {sky130_stdcells/nor2_4.sym} 45860 -28580 0 0 {name=X_59300_ }
C {devices/lab_pin.sym} 45820 -28450 0 0 {name=p45151 lab=_56525_/A }
C {devices/lab_pin.sym} 45900 -28450 0 1 {name=p45152 lab=_56523_/A }
C {sky130_stdcells/buf_2.sym} 45860 -28450 0 0 {name=X_56512_ }
C {devices/lab_pin.sym} 45770 -28330 0 0 {name=p45153 lab=_87045_/CLK }
C {devices/lab_pin.sym} 45770 -28310 0 0 {name=p45154 lab=_87332_/D }
C {devices/lab_pin.sym} 45950 -28330 0 1 {name=p45155 lab=_73921_/A }
C {sky130_stdcells/dfxtp_4.sym} 45860 -28320 0 0 {name=X_87332_ }
C {devices/lab_pin.sym} 45800 -28200 0 0 {name=p45156 lab=_53791_/A }
C {devices/lab_pin.sym} 45800 -28160 0 0 {name=p45157 lab=_48593_/A }
C {devices/lab_pin.sym} 45920 -28180 0 1 {name=p45158 lab=_53724_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -28180 0 0 {name=X_53724_ }
C {devices/lab_pin.sym} 45770 -28050 0 0 {name=p45159 lab=_84549_/CLK }
C {devices/lab_pin.sym} 45770 -28030 0 0 {name=p45160 lab=_84544_/D }
C {devices/lab_pin.sym} 45950 -28050 0 1 {name=p45161 lab=_84544_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -28040 0 0 {name=X_84544_ }
C {devices/lab_pin.sym} 45820 -27910 0 0 {name=p45162 lab=_50819_/X }
C {devices/lab_pin.sym} 45900 -27910 0 1 {name=p45163 lab=_50936_/X }
C {sky130_stdcells/buf_2.sym} 45860 -27910 0 0 {name=X_50936_ }
C {devices/lab_pin.sym} 45780 -27810 0 0 {name=p45164 lab=_57490_/Y }
C {devices/lab_pin.sym} 45780 -27770 0 0 {name=p45165 lab=_47791_/X }
C {devices/lab_pin.sym} 45780 -27730 0 0 {name=p45166 lab=_57491_/Y }
C {devices/lab_pin.sym} 45940 -27770 0 1 {name=p45167 lab=_57492_/Y }
C {sky130_stdcells/a21oi_4.sym} 45860 -27770 0 0 {name=X_57492_ }
C {devices/lab_pin.sym} 45770 -27630 0 0 {name=p45168 lab=_81756_/CLK }
C {devices/lab_pin.sym} 45770 -27610 0 0 {name=p45169 lab=_76113_/B }
C {devices/lab_pin.sym} 45950 -27630 0 1 {name=p45170 lab=_41310_/A }
C {sky130_stdcells/dfxtp_4.sym} 45860 -27620 0 0 {name=X_81756_ }
C {devices/lab_pin.sym} 45820 -27490 0 0 {name=p45171 lab=_69478_/A }
C {devices/lab_pin.sym} 45900 -27490 0 1 {name=p45172 lab=_69478_/X }
C {sky130_stdcells/buf_2.sym} 45860 -27490 0 0 {name=X_69478_ }
C {devices/lab_pin.sym} 45820 -27370 0 0 {name=p45173 lab=_57708_/X }
C {devices/lab_pin.sym} 45900 -27370 0 1 {name=p45174 lab=_59231_/X }
C {sky130_stdcells/buf_2.sym} 45860 -27370 0 0 {name=X_59231_ }
C {devices/lab_pin.sym} 45780 -27270 0 0 {name=p45175 lab=_56144_/X }
C {devices/lab_pin.sym} 45780 -27230 0 0 {name=p45176 lab=_56439_/X }
C {devices/lab_pin.sym} 45780 -27190 0 0 {name=p45177 lab=_56442_/Y }
C {devices/lab_pin.sym} 45940 -27230 0 1 {name=p45178 lab=_85192_/D }
C {sky130_stdcells/o21ai_4.sym} 45860 -27230 0 0 {name=X_56443_ }
C {devices/lab_pin.sym} 45820 -27090 0 0 {name=p45179 lab=_68429_/A }
C {devices/lab_pin.sym} 45900 -27090 0 1 {name=p45180 lab=_68429_/X }
C {sky130_stdcells/buf_2.sym} 45860 -27090 0 0 {name=X_68429_ }
C {devices/lab_pin.sym} 45770 -26970 0 0 {name=p45181 lab=_81834_/CLK }
C {devices/lab_pin.sym} 45770 -26950 0 0 {name=p45182 lab=_75893_/X }
C {devices/lab_pin.sym} 45950 -26970 0 1 {name=p45183 lab=_80675_/D }
C {sky130_stdcells/dfxtp_4.sym} 45860 -26960 0 0 {name=X_80707_ }
C {devices/lab_pin.sym} 45770 -26830 0 0 {name=p45184 lab=_87273_/CLK }
C {devices/lab_pin.sym} 45770 -26810 0 0 {name=p45185 lab=_87263_/D }
C {devices/lab_pin.sym} 45950 -26830 0 1 {name=p45186 lab=_69411_/B }
C {sky130_stdcells/dfxtp_4.sym} 45860 -26820 0 0 {name=X_87263_ }
C {devices/lab_pin.sym} 45780 -26710 0 0 {name=p45187 lab=_53652_/Y }
C {devices/lab_pin.sym} 45780 -26670 0 0 {name=p45188 lab=_53653_/X }
C {devices/lab_pin.sym} 45780 -26630 0 0 {name=p45189 lab=_53654_/X }
C {devices/lab_pin.sym} 45940 -26670 0 1 {name=p45190 lab=_85594_/D }
C {sky130_stdcells/a21oi_4.sym} 45860 -26670 0 0 {name=X_53655_ }
C {devices/lab_pin.sym} 45820 -26530 0 0 {name=p45191 lab=clkbuf_8_130_0_CLK/X }
C {devices/lab_pin.sym} 45900 -26530 0 1 {name=p45192 lab=clkbuf_9_260_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 45860 -26530 0 0 {name=Xclkbuf_9_260_0_CLK }
C {devices/lab_pin.sym} 45820 -26410 0 0 {name=p45193 lab=clkbuf_6_9_0_CLK/X }
C {devices/lab_pin.sym} 45900 -26410 0 1 {name=p45194 lab=clkbuf_8_39_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 45860 -26410 0 0 {name=Xclkbuf_7_19_0_CLK }
C {devices/lab_pin.sym} 45770 -26290 0 0 {name=p45195 lab=_84477_/CLK }
C {devices/lab_pin.sym} 45770 -26270 0 0 {name=p45196 lab=_84475_/D }
C {devices/lab_pin.sym} 45950 -26290 0 1 {name=p45197 lab=_84475_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -26280 0 0 {name=X_84475_ }
C {devices/lab_pin.sym} 45780 -26170 0 0 {name=p45198 lab=_86117_/Q }
C {devices/lab_pin.sym} 45780 -26130 0 0 {name=p45199 lab=_50856_/X }
C {devices/lab_pin.sym} 45780 -26090 0 0 {name=p45200 lab=_50866_/Y }
C {devices/lab_pin.sym} 45940 -26130 0 1 {name=p45201 lab=_50867_/Y }
C {sky130_stdcells/o21ai_4.sym} 45860 -26130 0 0 {name=X_50867_ }
C {devices/lab_pin.sym} 45770 -25990 0 0 {name=p45202 lab=_81801_/CLK }
C {devices/lab_pin.sym} 45770 -25970 0 0 {name=p45203 lab=_81687_/D }
C {devices/lab_pin.sym} 45950 -25990 0 1 {name=p45204 lab=_81687_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -25980 0 0 {name=X_81687_ }
C {devices/lab_pin.sym} 45770 -25850 0 0 {name=p45205 lab=_86213_/CLK }
C {devices/lab_pin.sym} 45770 -25830 0 0 {name=p45206 lab=_50373_/Y }
C {devices/lab_pin.sym} 45950 -25850 0 1 {name=p45207 lab=_86214_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -25840 0 0 {name=X_86214_ }
C {devices/lab_pin.sym} 45820 -25710 0 0 {name=p45208 lab=_48461_/A }
C {devices/lab_pin.sym} 45900 -25710 0 1 {name=p45209 lab=_40620_/X }
C {sky130_stdcells/buf_2.sym} 45860 -25710 0 0 {name=X_40620_ }
C {devices/lab_pin.sym} 45820 -25590 0 0 {name=p45210 lab=clkbuf_7_79_0_CLK/X }
C {devices/lab_pin.sym} 45900 -25590 0 1 {name=p45211 lab=clkbuf_9_318_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 45860 -25590 0 0 {name=Xclkbuf_8_159_0_CLK }
C {devices/lab_pin.sym} 45800 -25500 0 0 {name=p45212 lab=_52614_/A }
C {devices/lab_pin.sym} 45800 -25460 0 0 {name=p45213 lab=_52605_/X }
C {devices/lab_pin.sym} 45800 -25420 0 0 {name=p45214 lab=_52622_/C }
C {devices/lab_pin.sym} 45800 -25380 0 0 {name=p45215 lab=_51777_/D }
C {devices/lab_pin.sym} 45920 -25440 0 1 {name=p45216 lab=_52606_/X }
C {sky130_stdcells/and4_4.sym} 45860 -25440 0 0 {name=X_52606_ }
C {devices/lab_pin.sym} 45780 -25310 0 0 {name=p45217 lab=_59146_/X }
C {devices/lab_pin.sym} 45780 -25270 0 0 {name=p45218 lab=_85428_/Q }
C {devices/lab_pin.sym} 45780 -25230 0 0 {name=p45219 lab=_59161_/X }
C {devices/lab_pin.sym} 45940 -25270 0 1 {name=p45220 lab=_59162_/Y }
C {sky130_stdcells/o21ai_4.sym} 45860 -25270 0 0 {name=X_59162_ }
C {devices/lab_pin.sym} 45780 -25150 0 0 {name=p45221 lab=_71419_/Y }
C {devices/lab_pin.sym} 45780 -25110 0 0 {name=p45222 lab=_83498_/Q }
C {devices/lab_pin.sym} 45780 -25070 0 0 {name=p45223 lab=_71439_/X }
C {devices/lab_pin.sym} 45940 -25110 0 1 {name=p45224 lab=_71440_/X }
C {sky130_stdcells/a21o_4.sym} 45860 -25110 0 0 {name=X_71440_ }
C {devices/lab_pin.sym} 45770 -24970 0 0 {name=p45225 lab=_82386_/CLK }
C {devices/lab_pin.sym} 45770 -24950 0 0 {name=p45226 lab=_71647_/Y }
C {devices/lab_pin.sym} 45950 -24970 0 1 {name=p45227 lab=_59504_/A }
C {sky130_stdcells/dfxtp_4.sym} 45860 -24960 0 0 {name=X_83426_ }
C {devices/lab_pin.sym} 45820 -24830 0 0 {name=p45228 lab=clkbuf_9_77_0_CLK/X }
C {devices/lab_pin.sym} 45900 -24830 0 1 {name=p45229 lab=_81330_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 45860 -24830 0 0 {name=Xclkbuf_10_154_0_CLK }
C {sky130_stdcells/decap_3.sym} 45860 -24680 0 0 {name=XPHY_102 }
C {devices/lab_pin.sym} 45820 -24530 0 0 {name=p45230 lab=_56435_/A }
C {devices/lab_pin.sym} 45900 -24530 0 1 {name=p45231 lab=_56458_/A }
C {sky130_stdcells/buf_2.sym} 45860 -24530 0 0 {name=X_56374_ }
C {devices/lab_pin.sym} 45780 -24440 0 0 {name=p45232 lab=_41796_/Y }
C {devices/lab_pin.sym} 45780 -24400 0 0 {name=p45233 lab=_46258_/A }
C {devices/lab_pin.sym} 45780 -24360 0 0 {name=p45234 lab=_88403_/Q }
C {devices/lab_pin.sym} 45780 -24320 0 0 {name=p45235 lab=_40354_/X }
C {devices/lab_pin.sym} 45940 -24380 0 1 {name=p45236 lab=_88403_/D }
C {sky130_stdcells/a2bb2o_4.sym} 45860 -24380 0 0 {name=X_80638_ }
C {devices/lab_pin.sym} 45770 -24230 0 0 {name=p45237 lab=_87446_/CLK }
C {devices/lab_pin.sym} 45770 -24210 0 0 {name=p45238 lab=_43932_/Y }
C {devices/lab_pin.sym} 45950 -24230 0 1 {name=p45239 lab=_67939_/B }
C {sky130_stdcells/dfxtp_4.sym} 45860 -24220 0 0 {name=X_87194_ }
C {devices/lab_pin.sym} 45820 -24090 0 0 {name=p45240 lab=_53846_/A }
C {devices/lab_pin.sym} 45900 -24090 0 1 {name=p45241 lab=_53586_/X }
C {sky130_stdcells/buf_2.sym} 45860 -24090 0 0 {name=X_53586_ }
C {sky130_stdcells/decap_3.sym} 45860 -23940 0 0 {name=XPHY_113 }
C {devices/lab_pin.sym} 45780 -23810 0 0 {name=p45242 lab=_50796_/Y }
C {devices/lab_pin.sym} 45780 -23770 0 0 {name=p45243 lab=_50792_/X }
C {devices/lab_pin.sym} 45780 -23730 0 0 {name=p45244 lab=_50797_/Y }
C {devices/lab_pin.sym} 45940 -23770 0 1 {name=p45245 lab=_50798_/Y }
C {sky130_stdcells/a21boi_4.sym} 45860 -23770 0 0 {name=X_50798_ }
C {sky130_stdcells/decap_3.sym} 45860 -23600 0 0 {name=XPHY_124 }
C {devices/lab_pin.sym} 45780 -23470 0 0 {name=p45246 lab=_57947_/X }
C {devices/lab_pin.sym} 45780 -23430 0 0 {name=p45247 lab=_85700_/Q }
C {devices/lab_pin.sym} 45780 -23390 0 0 {name=p45248 lab=_57948_/X }
C {devices/lab_pin.sym} 45940 -23430 0 1 {name=p45249 lab=_58113_/X }
C {sky130_stdcells/o21a_4.sym} 45860 -23430 0 0 {name=X_58113_ }
C {sky130_stdcells/decap_3.sym} 45860 -23260 0 0 {name=XPHY_135 }
C {devices/lab_pin.sym} 45820 -23110 0 0 {name=p45250 lab=clkbuf_9_392_0_CLK/X }
C {devices/lab_pin.sym} 45900 -23110 0 1 {name=p45251 lab=_82803_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 45860 -23110 0 0 {name=Xclkbuf_10_784_0_CLK }
C {devices/lab_pin.sym} 45780 -23010 0 0 {name=p45252 lab=_55322_/X }
C {devices/lab_pin.sym} 45780 -22970 0 0 {name=p45253 lab=_55324_/X }
C {devices/lab_pin.sym} 45780 -22930 0 0 {name=p45254 lab=_83750_/Q }
C {devices/lab_pin.sym} 45940 -22970 0 1 {name=p45255 lab=_55325_/X }
C {sky130_stdcells/a21o_4.sym} 45860 -22970 0 0 {name=X_55325_ }
C {devices/lab_pin.sym} 45770 -22830 0 0 {name=p45256 lab=_86145_/CLK }
C {devices/lab_pin.sym} 45770 -22810 0 0 {name=p45257 lab=_86145_/D }
C {devices/lab_pin.sym} 45950 -22830 0 1 {name=p45258 lab=_86145_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -22820 0 0 {name=X_86145_ }
C {devices/lab_pin.sym} 45800 -22700 0 0 {name=p45259 lab=_52487_/X }
C {devices/lab_pin.sym} 45800 -22660 0 0 {name=p45260 lab=_49322_/B }
C {devices/lab_pin.sym} 45920 -22680 0 1 {name=p45261 lab=_52537_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -22680 0 0 {name=X_52537_ }
C {sky130_stdcells/decap_3.sym} 45860 -22520 0 0 {name=XPHY_146 }
C {devices/lab_pin.sym} 45820 -22370 0 0 {name=p45262 lab=_43175_/B }
C {devices/lab_pin.sym} 45900 -22370 0 1 {name=p45263 lab=_40591_/C }
C {sky130_stdcells/inv_2.sym} 45860 -22370 0 0 {name=X_40551_ }
C {devices/lab_pin.sym} 45800 -22260 0 0 {name=p45264 lab=_71163_/A }
C {devices/lab_pin.sym} 45800 -22220 0 0 {name=p45265 lab=_71342_/B }
C {devices/lab_pin.sym} 45920 -22240 0 1 {name=p45266 lab=_71372_/A }
C {sky130_stdcells/nor2_4.sym} 45860 -22240 0 0 {name=X_71371_ }
C {devices/lab_pin.sym} 45800 -22120 0 0 {name=p45267 lab=_59029_/A }
C {devices/lab_pin.sym} 45800 -22080 0 0 {name=p45268 lab=_86361_/Q }
C {devices/lab_pin.sym} 45920 -22100 0 1 {name=p45269 lab=_59093_/Y }
C {sky130_stdcells/nor2_4.sym} 45860 -22100 0 0 {name=X_59093_ }
C {devices/lab_pin.sym} 45770 -21970 0 0 {name=p45270 lab=_83421_/CLK }
C {devices/lab_pin.sym} 45770 -21950 0 0 {name=p45271 lab=_83357_/D }
C {devices/lab_pin.sym} 45950 -21970 0 1 {name=p45272 lab=_83357_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -21960 0 0 {name=X_83357_ }
C {devices/lab_pin.sym} 45800 -21840 0 0 {name=p45273 lab=_80567_/X }
C {devices/lab_pin.sym} 45800 -21800 0 0 {name=p45274 lab=_80569_/B }
C {devices/lab_pin.sym} 45920 -21820 0 1 {name=p45275 lab=_80570_/B }
C {sky130_stdcells/xnor2_4.sym} 45860 -21820 0 0 {name=X_80569_ }
C {sky130_stdcells/decap_3.sym} 45860 -21660 0 0 {name=XPHY_157 }
C {sky130_stdcells/decap_3.sym} 45860 -21480 0 0 {name=XPHY_168 }
C {devices/lab_pin.sym} 45780 -21350 0 0 {name=p45276 lab=_73107_/X }
C {devices/lab_pin.sym} 45780 -21310 0 0 {name=p45277 lab=_73109_/X }
C {devices/lab_pin.sym} 45780 -21270 0 0 {name=p45278 lab=_72982_/X }
C {devices/lab_pin.sym} 45940 -21310 0 1 {name=p45279 lab=_73110_/X }
C {sky130_stdcells/a21o_4.sym} 45860 -21310 0 0 {name=X_73110_ }
C {sky130_stdcells/decap_3.sym} 45860 -21140 0 0 {name=XPHY_179 }
C {devices/lab_pin.sym} 45780 -21010 0 0 {name=p45280 lab=_57966_/X }
C {devices/lab_pin.sym} 45780 -20970 0 0 {name=p45281 lab=_85706_/Q }
C {devices/lab_pin.sym} 45780 -20930 0 0 {name=p45282 lab=_58020_/X }
C {devices/lab_pin.sym} 45940 -20970 0 1 {name=p45283 lab=_58044_/X }
C {sky130_stdcells/o21a_4.sym} 45860 -20970 0 0 {name=X_58044_ }
C {devices/lab_pin.sym} 45820 -20830 0 0 {name=p45284 lab=clkbuf_9_274_0_CLK/A }
C {devices/lab_pin.sym} 45900 -20830 0 1 {name=p45285 lab=clkbuf_9_275_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 45860 -20830 0 0 {name=Xclkbuf_9_275_0_CLK }
C {devices/lab_pin.sym} 45780 -20730 0 0 {name=p45286 lab=_70320_/X }
C {devices/lab_pin.sym} 45780 -20690 0 0 {name=p45287 lab=_74782_/B }
C {devices/lab_pin.sym} 45780 -20650 0 0 {name=p45288 lab=_70321_/X }
C {devices/lab_pin.sym} 45940 -20690 0 1 {name=p45289 lab=_83798_/D }
C {sky130_stdcells/a21o_4.sym} 45860 -20690 0 0 {name=X_70322_ }
C {devices/lab_pin.sym} 45770 -20550 0 0 {name=p45290 lab=_81179_/CLK }
C {devices/lab_pin.sym} 45770 -20530 0 0 {name=p45291 lab=_77016_/Y }
C {devices/lab_pin.sym} 45950 -20550 0 1 {name=p45292 lab=_82308_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -20540 0 0 {name=X_82308_ }
C {devices/lab_pin.sym} 45780 -20450 0 0 {name=p45293 lab=_43260_/X }
C {devices/lab_pin.sym} 45780 -20410 0 0 {name=p45294 lab=_43269_/X }
C {devices/lab_pin.sym} 45780 -20370 0 0 {name=p45295 lab=_41116_/X }
C {devices/lab_pin.sym} 45780 -20330 0 0 {name=p45296 lab=_87507_/Q }
C {devices/lab_pin.sym} 45780 -20290 0 0 {name=p45297 lab=_43250_/X }
C {devices/lab_pin.sym} 45940 -20370 0 1 {name=p45298 lab=_43270_/Y }
C {sky130_stdcells/o32ai_4.sym} 45860 -20370 0 0 {name=X_43270_ }
C {devices/lab_pin.sym} 45800 -20220 0 0 {name=p45299 lab=_55135_/A }
C {devices/lab_pin.sym} 45800 -20180 0 0 {name=p45300 lab=_85001_/Q }
C {devices/lab_pin.sym} 45920 -20200 0 1 {name=p45301 lab=_55256_/X }
C {sky130_stdcells/and2_4.sym} 45860 -20200 0 0 {name=X_55256_ }
C {devices/lab_pin.sym} 45800 -20080 0 0 {name=p45302 lab=_74090_/A }
C {devices/lab_pin.sym} 45800 -20040 0 0 {name=p45303 lab=_74090_/B }
C {devices/lab_pin.sym} 45920 -20060 0 1 {name=p45304 lab=_74090_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -20060 0 0 {name=X_74090_ }
C {devices/lab_pin.sym} 45770 -19930 0 0 {name=p45305 lab=_85757_/CLK }
C {devices/lab_pin.sym} 45770 -19910 0 0 {name=p45306 lab=_86076_/D }
C {devices/lab_pin.sym} 45950 -19930 0 1 {name=p45307 lab=_86076_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -19920 0 0 {name=X_86076_ }
C {devices/lab_pin.sym} 45820 -19790 0 0 {name=p45308 lab=_40481_/Y }
C {devices/lab_pin.sym} 45900 -19790 0 1 {name=p45309 lab=_88385_/D }
C {sky130_stdcells/inv_2.sym} 45860 -19790 0 0 {name=X_40482_ }
C {devices/lab_pin.sym} 45800 -19680 0 0 {name=p45310 lab=_52468_/A }
C {devices/lab_pin.sym} 45800 -19640 0 0 {name=p45311 lab=_52468_/B }
C {devices/lab_pin.sym} 45920 -19660 0 1 {name=p45312 lab=_52468_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -19660 0 0 {name=X_52468_ }
C {devices/lab_pin.sym} 45770 -19530 0 0 {name=p45313 lab=_85542_/CLK }
C {devices/lab_pin.sym} 45770 -19510 0 0 {name=p45314 lab=_83288_/D }
C {devices/lab_pin.sym} 45950 -19530 0 1 {name=p45315 lab=_83288_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -19520 0 0 {name=X_83288_ }
C {devices/lab_pin.sym} 45780 -19420 0 0 {name=p45316 lab=_41367_/X }
C {devices/lab_pin.sym} 45780 -19380 0 0 {name=p45317 lab=_42209_/X }
C {devices/lab_pin.sym} 45780 -19340 0 0 {name=p45318 lab=_87972_/Q }
C {devices/lab_pin.sym} 45780 -19300 0 0 {name=p45319 lab=_42210_/X }
C {devices/lab_pin.sym} 45940 -19360 0 1 {name=p45320 lab=_42221_/X }
C {sky130_stdcells/a2bb2o_4.sym} 45860 -19360 0 0 {name=X_42221_ }
C {devices/lab_pin.sym} 45820 -19210 0 0 {name=p45321 lab=_53282_/A }
C {devices/lab_pin.sym} 45900 -19210 0 1 {name=p45322 lab=_54316_/A }
C {sky130_stdcells/buf_2.sym} 45860 -19210 0 0 {name=X_54207_ }
C {devices/lab_pin.sym} 45820 -19090 0 0 {name=p45323 lab=clkbuf_9_84_0_CLK/X }
C {devices/lab_pin.sym} 45900 -19090 0 1 {name=p45324 lab=_81582_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 45860 -19090 0 0 {name=Xclkbuf_10_169_0_CLK }
C {devices/lab_pin.sym} 45780 -19000 0 0 {name=p45325 lab=_72870_/X }
C {devices/lab_pin.sym} 45780 -18960 0 0 {name=p45326 lab=_86199_/Q }
C {devices/lab_pin.sym} 45780 -18920 0 0 {name=p45327 lab=_72905_/X }
C {devices/lab_pin.sym} 45780 -18880 0 0 {name=p45328 lab=_73040_/X }
C {devices/lab_pin.sym} 45940 -18940 0 1 {name=p45329 lab=_73041_/X }
C {sky130_stdcells/a211o_4.sym} 45860 -18940 0 0 {name=X_73041_ }
C {devices/lab_pin.sym} 45770 -18790 0 0 {name=p45330 lab=_85031_/CLK }
C {devices/lab_pin.sym} 45770 -18770 0 0 {name=p45331 lab=_85027_/D }
C {devices/lab_pin.sym} 45950 -18790 0 1 {name=p45332 lab=_85027_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -18780 0 0 {name=X_85027_ }
C {devices/lab_pin.sym} 45780 -18670 0 0 {name=p45333 lab=_86013_/Q }
C {devices/lab_pin.sym} 45780 -18630 0 0 {name=p45334 lab=_51402_/X }
C {devices/lab_pin.sym} 45780 -18590 0 0 {name=p45335 lab=_51418_/Y }
C {devices/lab_pin.sym} 45940 -18630 0 1 {name=p45336 lab=_51419_/Y }
C {sky130_stdcells/o21ai_4.sym} 45860 -18630 0 0 {name=X_51419_ }
C {devices/lab_pin.sym} 45800 -18520 0 0 {name=p45337 lab=_70260_/A }
C {devices/lab_pin.sym} 45800 -18480 0 0 {name=p45338 lab=_70260_/B }
C {devices/lab_pin.sym} 45800 -18440 0 0 {name=p45339 lab=_83182_/Q }
C {devices/lab_pin.sym} 45800 -18400 0 0 {name=p45340 lab=_70260_/D }
C {devices/lab_pin.sym} 45920 -18460 0 1 {name=p45341 lab=_70253_/X }
C {sky130_stdcells/and4_4.sym} 45860 -18460 0 0 {name=X_70253_ }
C {devices/lab_pin.sym} 45770 -18310 0 0 {name=p45342 lab=_82531_/CLK }
C {devices/lab_pin.sym} 45770 -18290 0 0 {name=p45343 lab=_82271_/Q }
C {devices/lab_pin.sym} 45950 -18310 0 1 {name=p45344 lab=_82239_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -18300 0 0 {name=X_82239_ }
C {devices/lab_pin.sym} 45780 -18200 0 0 {name=p45345 lab=_85101_/Q }
C {devices/lab_pin.sym} 45780 -18160 0 0 {name=p45346 lab=_55145_/A }
C {devices/lab_pin.sym} 45780 -18120 0 0 {name=p45347 lab=_44044_/X }
C {devices/lab_pin.sym} 45780 -18080 0 0 {name=p45348 lab=_55186_/Y }
C {devices/lab_pin.sym} 45940 -18140 0 1 {name=p45349 lab=_55187_/X }
C {sky130_stdcells/a211o_4.sym} 45860 -18140 0 0 {name=X_55187_ }
C {devices/lab_pin.sym} 45820 -17990 0 0 {name=p45350 lab=_52630_/A }
C {devices/lab_pin.sym} 45900 -17990 0 1 {name=p45351 lab=_52602_/A }
C {sky130_stdcells/buf_2.sym} 45860 -17990 0 0 {name=X_52399_ }
C {devices/lab_pin.sym} 45820 -17870 0 0 {name=p45352 lab=clkbuf_9_399_0_CLK/X }
C {devices/lab_pin.sym} 45900 -17870 0 1 {name=p45353 lab=_84111_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 45860 -17870 0 0 {name=Xclkbuf_10_799_0_CLK }
C {devices/lab_pin.sym} 45780 -17780 0 0 {name=p45354 lab=_41165_/X }
C {devices/lab_pin.sym} 45780 -17740 0 0 {name=p45355 lab=_42148_/X }
C {devices/lab_pin.sym} 45780 -17700 0 0 {name=p45356 lab=_88009_/Q }
C {devices/lab_pin.sym} 45780 -17660 0 0 {name=p45357 lab=_42150_/X }
C {devices/lab_pin.sym} 45940 -17720 0 1 {name=p45358 lab=_88009_/D }
C {sky130_stdcells/a2bb2o_4.sym} 45860 -17720 0 0 {name=X_42152_ }
C {devices/lab_pin.sym} 45780 -17590 0 0 {name=p45359 lab=_54135_/Y }
C {devices/lab_pin.sym} 45780 -17550 0 0 {name=p45360 lab=_54117_/X }
C {devices/lab_pin.sym} 45780 -17510 0 0 {name=p45361 lab=_54137_/X }
C {devices/lab_pin.sym} 45940 -17550 0 1 {name=p45362 lab=_54138_/Y }
C {sky130_stdcells/a21oi_4.sym} 45860 -17550 0 0 {name=X_54138_ }
C {devices/lab_pin.sym} 45780 -17430 0 0 {name=p45363 lab=_70169_/X }
C {devices/lab_pin.sym} 45780 -17390 0 0 {name=p45364 lab=_83845_/Q }
C {devices/lab_pin.sym} 45780 -17350 0 0 {name=p45365 lab=_70183_/X }
C {devices/lab_pin.sym} 45940 -17390 0 1 {name=p45366 lab=_83845_/D }
C {sky130_stdcells/a21o_4.sym} 45860 -17390 0 0 {name=X_70184_ }
C {devices/lab_pin.sym} 45820 -17250 0 0 {name=p45367 lab=_59995_/A }
C {devices/lab_pin.sym} 45900 -17250 0 1 {name=p45368 lab=_59995_/X }
C {sky130_stdcells/buf_2.sym} 45860 -17250 0 0 {name=X_59995_ }
C {devices/lab_pin.sym} 45780 -17150 0 0 {name=p45369 lab=_41100_/X }
C {devices/lab_pin.sym} 45780 -17110 0 0 {name=p45370 lab=_81699_/Q }
C {devices/lab_pin.sym} 45780 -17070 0 0 {name=p45371 lab=_41102_/X }
C {devices/lab_pin.sym} 45940 -17110 0 1 {name=p45372 lab=_41104_/A }
C {sky130_stdcells/o21ai_4.sym} 45860 -17110 0 0 {name=X_41103_ }
C {devices/lab_pin.sym} 45800 -16980 0 0 {name=p45373 lab=_76795_/Y }
C {devices/lab_pin.sym} 45800 -16940 0 0 {name=p45374 lab=_76800_/B }
C {devices/lab_pin.sym} 45920 -16960 0 1 {name=p45375 lab=_76801_/B }
C {sky130_stdcells/nand2_4.sym} 45860 -16960 0 0 {name=X_76800_ }
C {devices/lab_pin.sym} 45780 -16850 0 0 {name=p45376 lab=_86685_/Q }
C {devices/lab_pin.sym} 45780 -16810 0 0 {name=p45377 lab=_46955_/X }
C {devices/lab_pin.sym} 45780 -16770 0 0 {name=p45378 lab=_46959_/Y }
C {devices/lab_pin.sym} 45940 -16810 0 1 {name=p45379 lab=_46960_/Y }
C {sky130_stdcells/o21ai_4.sym} 45860 -16810 0 0 {name=X_46960_ }
C {devices/lab_pin.sym} 45820 -16670 0 0 {name=p45380 lab=_42083_/A }
C {devices/lab_pin.sym} 45900 -16670 0 1 {name=p45381 lab=_42083_/X }
C {sky130_stdcells/buf_2.sym} 45860 -16670 0 0 {name=X_42083_ }
C {devices/lab_pin.sym} 45820 -16550 0 0 {name=p45382 lab=_84787_/Q }
C {devices/lab_pin.sym} 45900 -16550 0 1 {name=p45383 lab=_58946_/Y }
C {sky130_stdcells/inv_2.sym} 45860 -16550 0 0 {name=X_58946_ }
C {devices/lab_pin.sym} 45800 -16440 0 0 {name=p45384 lab=_54068_/X }
C {devices/lab_pin.sym} 45800 -16400 0 0 {name=p45385 lab=_54069_/B }
C {devices/lab_pin.sym} 45920 -16420 0 1 {name=p45386 lab=_54069_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -16420 0 0 {name=X_54069_ }
C {devices/lab_pin.sym} 45800 -16300 0 0 {name=p45387 lab=_81927_/D }
C {devices/lab_pin.sym} 45800 -16260 0 0 {name=p45388 lab=_77780_/B }
C {devices/lab_pin.sym} 45920 -16280 0 1 {name=p45389 lab=_77780_/X }
C {sky130_stdcells/and2_4.sym} 45860 -16280 0 0 {name=X_77780_ }
C {devices/lab_pin.sym} 45800 -16160 0 0 {name=p45390 lab=_74986_/X }
C {devices/lab_pin.sym} 45800 -16120 0 0 {name=p45391 lab=_75001_/A }
C {devices/lab_pin.sym} 45920 -16140 0 1 {name=p45392 lab=_74993_/B }
C {sky130_stdcells/xor2_4.sym} 45860 -16140 0 0 {name=X_74992_ }
C {devices/lab_pin.sym} 45770 -16010 0 0 {name=p45393 lab=_82538_/CLK }
C {devices/lab_pin.sym} 45770 -15990 0 0 {name=p45394 lab=_86978_/D }
C {devices/lab_pin.sym} 45950 -16010 0 1 {name=p45395 lab=_44745_/A }
C {sky130_stdcells/dfxtp_4.sym} 45860 -16000 0 0 {name=X_86978_ }
C {devices/lab_pin.sym} 45820 -15870 0 0 {name=p45396 lab=_44184_/X }
C {devices/lab_pin.sym} 45900 -15870 0 1 {name=p45397 lab=_57673_/A }
C {sky130_stdcells/buf_2.sym} 45860 -15870 0 0 {name=X_45911_ }
C {devices/lab_pin.sym} 45820 -15750 0 0 {name=p45398 lab=clkbuf_9_361_0_CLK/X }
C {devices/lab_pin.sym} 45900 -15750 0 1 {name=p45399 lab=_87011_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 45860 -15750 0 0 {name=Xclkbuf_10_722_0_CLK }
C {devices/lab_pin.sym} 45800 -15640 0 0 {name=p45400 lab=_41034_/A }
C {devices/lab_pin.sym} 45800 -15600 0 0 {name=p45401 lab=_41019_/B }
C {devices/lab_pin.sym} 45920 -15620 0 1 {name=p45402 lab=_41034_/X }
C {sky130_stdcells/or2_4.sym} 45860 -15620 0 0 {name=X_41034_ }
C {devices/lab_pin.sym} 45780 -15510 0 0 {name=p45403 lab=_76724_/Y }
C {devices/lab_pin.sym} 45780 -15470 0 0 {name=p45404 lab=_76725_/A }
C {devices/lab_pin.sym} 45780 -15430 0 0 {name=p45405 lab=_76730_/Y }
C {devices/lab_pin.sym} 45940 -15470 0 1 {name=p45406 lab=_76731_/Y }
C {sky130_stdcells/a21oi_4.sym} 45860 -15470 0 0 {name=X_76731_ }
C {devices/lab_pin.sym} 45780 -15360 0 0 {name=p45407 lab=_43070_/Y }
C {devices/lab_pin.sym} 45780 -15320 0 0 {name=p45408 lab=_72900_/X }
C {devices/lab_pin.sym} 45780 -15280 0 0 {name=p45409 lab=_73894_/X }
C {devices/lab_pin.sym} 45780 -15240 0 0 {name=p45410 lab=_73942_/Y }
C {devices/lab_pin.sym} 45940 -15300 0 1 {name=p45411 lab=_73943_/X }
C {sky130_stdcells/a211o_4.sym} 45860 -15300 0 0 {name=X_73943_ }
C {devices/lab_pin.sym} 45770 -15150 0 0 {name=p45412 lab=_86089_/CLK }
C {devices/lab_pin.sym} 45770 -15130 0 0 {name=p45413 lab=_51883_/Y }
C {devices/lab_pin.sym} 45950 -15150 0 1 {name=p45414 lab=_85929_/Q }
C {sky130_stdcells/dfxtp_4.sym} 45860 -15140 0 0 {name=X_85929_ }
C {devices/lab_pin.sym} 45820 -15010 0 0 {name=p45415 lab=_47081_/A }
C {devices/lab_pin.sym} 45900 -15010 0 1 {name=p45416 lab=_46891_/X }
C {sky130_stdcells/buf_2.sym} 45860 -15010 0 0 {name=X_46891_ }
C {devices/lab_pin.sym} 45820 -14890 0 0 {name=p45417 lab=_58877_/A }
C {devices/lab_pin.sym} 45900 -14890 0 1 {name=p45418 lab=_58877_/X }
C {sky130_stdcells/buf_2.sym} 45860 -14890 0 0 {name=X_58877_ }
C {devices/lab_pin.sym} 45820 -14770 0 0 {name=p45419 lab=_81769_/Q }
C {devices/lab_pin.sym} 45900 -14770 0 1 {name=p45420 lab=_48632_/A }
C {sky130_stdcells/inv_2.sym} 45860 -14770 0 0 {name=X_48630_ }
C {devices/lab_pin.sym} 45800 -14660 0 0 {name=p45421 lab=_79438_/A }
C {devices/lab_pin.sym} 45800 -14620 0 0 {name=p45422 lab=_79438_/B }
C {devices/lab_pin.sym} 45920 -14640 0 1 {name=p45423 lab=_79450_/Y }
C {sky130_stdcells/nor2_4.sym} 45860 -14640 0 0 {name=X_79450_ }
C {devices/lab_pin.sym} 45820 -14510 0 0 {name=p45424 lab=_85092_/Q }
C {devices/lab_pin.sym} 45900 -14510 0 1 {name=p45425 lab=_45842_/Y }
C {sky130_stdcells/inv_2.sym} 45860 -14510 0 0 {name=X_45842_ }
C {devices/lab_pin.sym} 45820 -14390 0 0 {name=p45426 lab=clkbuf_8_106_0_CLK/X }
C {devices/lab_pin.sym} 45900 -14390 0 1 {name=p45427 lab=clkbuf_9_213_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 45860 -14390 0 0 {name=Xclkbuf_9_213_0_CLK }
C {devices/lab_pin.sym} 45780 -14290 0 0 {name=p45428 lab=_57726_/X }
C {devices/lab_pin.sym} 45780 -14250 0 0 {name=p45429 lab=_86011_/Q }
C {devices/lab_pin.sym} 45780 -14210 0 0 {name=p45430 lab=_57827_/X }
C {devices/lab_pin.sym} 45940 -14250 0 1 {name=p45431 lab=_57828_/Y }
C {sky130_stdcells/o21ai_4.sym} 45860 -14250 0 0 {name=X_57828_ }
C {devices/lab_pin.sym} 45800 -14130 0 0 {name=p45432 lab=_76662_/A }
C {devices/lab_pin.sym} 45800 -14090 0 0 {name=p45433 lab=_76658_/Y }
C {devices/lab_pin.sym} 45800 -14050 0 0 {name=p45434 lab=_76662_/C }
C {devices/lab_pin.sym} 45920 -14090 0 1 {name=p45435 lab=_76662_/Y }
C {sky130_stdcells/nand3_4.sym} 45860 -14090 0 0 {name=X_76662_ }
C {devices/lab_pin.sym} 45780 -13980 0 0 {name=p45436 lab=_68695_/B }
C {devices/lab_pin.sym} 45780 -13940 0 0 {name=p45437 lab=_73872_/X }
C {devices/lab_pin.sym} 45780 -13900 0 0 {name=p45438 lab=_73772_/X }
C {devices/lab_pin.sym} 45780 -13860 0 0 {name=p45439 lab=_73873_/Y }
C {devices/lab_pin.sym} 45940 -13920 0 1 {name=p45440 lab=_73874_/X }
C {sky130_stdcells/a211o_4.sym} 45860 -13920 0 0 {name=X_73874_ }
C {devices/lab_pin.sym} 45800 -13780 0 0 {name=p45441 lab=_82504_/Q }
C {devices/lab_pin.sym} 45800 -13740 0 0 {name=p45442 lab=_82760_/D }
C {devices/lab_pin.sym} 45920 -13760 0 1 {name=p45443 lab=_78401_/X }
C {sky130_stdcells/xor2_4.sym} 45860 -13760 0 0 {name=X_78401_ }
C {devices/lab_pin.sym} 45800 -13640 0 0 {name=p45444 lab=_75621_/A }
C {devices/lab_pin.sym} 45800 -13600 0 0 {name=p45445 lab=_80775_/D }
C {devices/lab_pin.sym} 45920 -13620 0 1 {name=p45446 lab=_75616_/A }
C {sky130_stdcells/xnor2_4.sym} 45860 -13620 0 0 {name=X_75613_ }
C {devices/lab_pin.sym} 45820 -13490 0 0 {name=p45447 lab=clkbuf_9_53_0_CLK/X }
C {devices/lab_pin.sym} 45900 -13490 0 1 {name=p45448 lab=_87178_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 45860 -13490 0 0 {name=Xclkbuf_10_107_0_CLK }
C {devices/lab_pin.sym} 45800 -13380 0 0 {name=p45449 lab=_48604_/A }
C {devices/lab_pin.sym} 45800 -13340 0 0 {name=p45450 lab=_48561_/B }
C {devices/lab_pin.sym} 45920 -13360 0 1 {name=p45451 lab=_48561_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -13360 0 0 {name=X_48561_ }
C {devices/lab_pin.sym} 45800 -13240 0 0 {name=p45452 lab=_42550_/A }
C {devices/lab_pin.sym} 45800 -13200 0 0 {name=p45453 lab=_73000_/B }
C {devices/lab_pin.sym} 45920 -13220 0 1 {name=p45454 lab=_72825_/Y }
C {sky130_stdcells/nor2_4.sym} 45860 -13220 0 0 {name=X_72825_ }
C {devices/lab_pin.sym} 45800 -13100 0 0 {name=p45455 lab=_79375_/Y }
C {devices/lab_pin.sym} 45800 -13060 0 0 {name=p45456 lab=_79381_/B }
C {devices/lab_pin.sym} 45920 -13080 0 1 {name=p45457 lab=_82836_/D }
C {sky130_stdcells/xor2_4.sym} 45860 -13080 0 0 {name=X_79381_ }
C {devices/lab_pin.sym} 45780 -12970 0 0 {name=p45458 lab=_45770_/X }
C {devices/lab_pin.sym} 45780 -12930 0 0 {name=p45459 lab=_45772_/Y }
C {devices/lab_pin.sym} 45780 -12890 0 0 {name=p45460 lab=_45757_/X }
C {devices/lab_pin.sym} 45940 -12930 0 1 {name=p45461 lab=_45773_/X }
C {sky130_stdcells/a21o_4.sym} 45860 -12930 0 0 {name=X_45773_ }
C {devices/lab_pin.sym} 45820 -12790 0 0 {name=p45462 lab=_57837_/A }
C {devices/lab_pin.sym} 45900 -12790 0 1 {name=p45463 lab=_57759_/X }
C {sky130_stdcells/buf_2.sym} 45860 -12790 0 0 {name=X_57759_ }
C {devices/lab_pin.sym} 45820 -12670 0 0 {name=p45464 lab=_76593_/A }
C {devices/lab_pin.sym} 45900 -12670 0 1 {name=p45465 lab=_76593_/Y }
C {sky130_stdcells/inv_2.sym} 45860 -12670 0 0 {name=X_76593_ }
C {devices/lab_pin.sym} 45820 -12550 0 0 {name=p45466 lab=_41992_/A }
C {devices/lab_pin.sym} 45900 -12550 0 1 {name=p45467 lab=_42985_/X }
C {sky130_stdcells/buf_2.sym} 45860 -12550 0 0 {name=X_42985_ }
C {devices/lab_pin.sym} 45820 -12430 0 0 {name=p45468 lab=clkbuf_9_368_0_CLK/X }
C {devices/lab_pin.sym} 45900 -12430 0 1 {name=p45469 lab=_87990_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 45860 -12430 0 0 {name=Xclkbuf_10_737_0_CLK }
C {devices/lab_pin.sym} 45820 -12310 0 0 {name=p45470 lab=_47511_/Y }
C {devices/lab_pin.sym} 45900 -12310 0 1 {name=p45471 lab=_53090_/D }
C {sky130_stdcells/buf_2.sym} 45860 -12310 0 0 {name=X_47512_ }
C {devices/lab_pin.sym} 45820 -12190 0 0 {name=p45472 lab=_78332_/A }
C {devices/lab_pin.sym} 45900 -12190 0 1 {name=p45473 lab=_78332_/Y }
C {sky130_stdcells/inv_2.sym} 45860 -12190 0 0 {name=X_78332_ }
C {devices/lab_pin.sym} 45820 -12070 0 0 {name=p45474 lab=_44723_/Y }
C {devices/lab_pin.sym} 45900 -12070 0 1 {name=p45475 lab=_44724_/Y }
C {sky130_stdcells/inv_2.sym} 45860 -12070 0 0 {name=X_44724_ }
C {devices/lab_pin.sym} 45800 -11960 0 0 {name=p45476 lab=_75540_/X }
C {devices/lab_pin.sym} 45800 -11920 0 0 {name=p45477 lab=_75543_/X }
C {devices/lab_pin.sym} 45920 -11940 0 1 {name=p45478 lab=_75544_/X }
C {sky130_stdcells/xor2_4.sym} 45860 -11940 0 0 {name=X_75544_ }
C {devices/lab_pin.sym} 45820 -11810 0 0 {name=p45479 lab=_41936_/A }
C {devices/lab_pin.sym} 45900 -11810 0 1 {name=p45480 lab=_41998_/A }
C {sky130_stdcells/buf_2.sym} 45860 -11810 0 0 {name=X_41936_ }
C {devices/lab_pin.sym} 45820 -11690 0 0 {name=p45481 lab=_53678_/B }
C {devices/lab_pin.sym} 45900 -11690 0 1 {name=p45482 lab=_52158_/B }
C {sky130_stdcells/buf_2.sym} 45860 -11690 0 0 {name=X_48492_ }
C {devices/lab_pin.sym} 45820 -11570 0 0 {name=p45483 lab=_44124_/A }
C {devices/lab_pin.sym} 45900 -11570 0 1 {name=p45484 lab=_72757_/A }
C {sky130_stdcells/buf_2.sym} 45860 -11570 0 0 {name=X_72756_ }
C {devices/lab_pin.sym} 45820 -11450 0 0 {name=p45485 lab=_60770_/A }
C {devices/lab_pin.sym} 45900 -11450 0 1 {name=p45486 lab=_63696_/A }
C {sky130_stdcells/buf_2.sym} 45860 -11450 0 0 {name=X_60770_ }
C {devices/lab_pin.sym} 45820 -11330 0 0 {name=p45487 lab=clkbuf_8_114_0_CLK/X }
C {devices/lab_pin.sym} 45900 -11330 0 1 {name=p45488 lab=clkbuf_9_228_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 45860 -11330 0 0 {name=Xclkbuf_9_228_0_CLK }
C {devices/lab_pin.sym} 45820 -11210 0 0 {name=p45489 lab=_47442_/Y }
C {devices/lab_pin.sym} 45900 -11210 0 1 {name=p45490 lab=_53050_/B }
C {sky130_stdcells/buf_2.sym} 45860 -11210 0 0 {name=X_47443_ }
C {devices/lab_pin.sym} 45780 -11110 0 0 {name=p45491 lab=_58303_/Y }
C {devices/lab_pin.sym} 45780 -11070 0 0 {name=p45492 lab=_71695_/X }
C {devices/lab_pin.sym} 45780 -11030 0 0 {name=p45493 lab=_71706_/Y }
C {devices/lab_pin.sym} 45940 -11070 0 1 {name=p45494 lab=_83403_/D }
C {sky130_stdcells/o21ai_4.sym} 45860 -11070 0 0 {name=X_71707_ }
C {devices/lab_pin.sym} 45780 -10950 0 0 {name=p45495 lab=_59426_/X }
C {devices/lab_pin.sym} 45780 -10910 0 0 {name=p45496 lab=_59427_/Y }
C {devices/lab_pin.sym} 45780 -10870 0 0 {name=p45497 lab=_59428_/Y }
C {devices/lab_pin.sym} 45940 -10910 0 1 {name=p45498 lab=_84736_/D }
C {sky130_stdcells/a21oi_4.sym} 45860 -10910 0 0 {name=X_59429_ }
C {devices/lab_pin.sym} 45800 -10780 0 0 {name=p45499 lab=_78263_/A }
C {devices/lab_pin.sym} 45800 -10740 0 0 {name=p45500 lab=_78263_/B }
C {devices/lab_pin.sym} 45920 -10760 0 1 {name=p45501 lab=_78280_/B }
C {sky130_stdcells/and2_4.sym} 45860 -10760 0 0 {name=X_78263_ }
C {devices/lab_pin.sym} 45820 -10630 0 0 {name=p45502 lab=_44655_/A }
C {devices/lab_pin.sym} 45900 -10630 0 1 {name=p45503 lab=_44655_/Y }
C {sky130_stdcells/inv_2.sym} 45860 -10630 0 0 {name=X_44655_ }
C {devices/lab_pin.sym} 45800 -10520 0 0 {name=p45504 lab=_75475_/A }
C {devices/lab_pin.sym} 45800 -10480 0 0 {name=p45505 lab=_75475_/B }
C {devices/lab_pin.sym} 45920 -10500 0 1 {name=p45506 lab=_75475_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -10500 0 0 {name=X_75475_ }
C {devices/lab_pin.sym} 45820 -10370 0 0 {name=p45507 lab=_42429_/A }
C {devices/lab_pin.sym} 45900 -10370 0 1 {name=p45508 lab=_41992_/A }
C {sky130_stdcells/buf_2.sym} 45860 -10370 0 0 {name=X_41867_ }
C {devices/lab_pin.sym} 45820 -10250 0 0 {name=p45509 lab=_72687_/A }
C {devices/lab_pin.sym} 45900 -10250 0 1 {name=p45510 lab=_72697_/A }
C {sky130_stdcells/buf_2.sym} 45860 -10250 0 0 {name=X_72687_ }
C {devices/lab_pin.sym} 45800 -10140 0 0 {name=p45511 lab=_82111_/Q }
C {devices/lab_pin.sym} 45800 -10100 0 0 {name=p45512 lab=_77214_/B }
C {devices/lab_pin.sym} 45920 -10120 0 1 {name=p45513 lab=_77214_/X }
C {sky130_stdcells/xor2_4.sym} 45860 -10120 0 0 {name=X_77214_ }
C {devices/lab_pin.sym} 45820 -9990 0 0 {name=p45514 lab=_43606_/A }
C {devices/lab_pin.sym} 45900 -9990 0 1 {name=p45515 lab=_43607_/A }
C {sky130_stdcells/buf_2.sym} 45860 -9990 0 0 {name=X_43606_ }
C {sky130_stdcells/decap_3.sym} 45860 -9840 0 0 {name=XPHY_4 }
C {devices/lab_pin.sym} 45820 -9690 0 0 {name=p45516 lab=_62214_/A }
C {devices/lab_pin.sym} 45900 -9690 0 1 {name=p45517 lab=_62440_/X }
C {sky130_stdcells/buf_2.sym} 45860 -9690 0 0 {name=X_62440_ }
C {devices/lab_pin.sym} 45800 -9590 0 0 {name=p45518 lab=_48498_/A }
C {devices/lab_pin.sym} 45800 -9550 0 0 {name=p45519 lab=_74420_/X }
C {devices/lab_pin.sym} 45800 -9510 0 0 {name=p45520 lab=_74425_/X }
C {devices/lab_pin.sym} 45920 -9550 0 1 {name=p45521 lab=_74426_/X }
C {sky130_stdcells/and3_4.sym} 45860 -9550 0 0 {name=X_74426_ }
C {devices/lab_pin.sym} 45800 -9420 0 0 {name=p45522 lab=_82870_/Q }
C {devices/lab_pin.sym} 45800 -9380 0 0 {name=p45523 lab=_40779_/B }
C {devices/lab_pin.sym} 45920 -9400 0 1 {name=p45524 lab=_40818_/X }
C {sky130_stdcells/or2_4.sym} 45860 -9400 0 0 {name=X_40818_ }
C {devices/lab_pin.sym} 45800 -9280 0 0 {name=p45525 lab=_47333_/X }
C {devices/lab_pin.sym} 45800 -9240 0 0 {name=p45526 lab=_53012_/B }
C {devices/lab_pin.sym} 45920 -9260 0 1 {name=p45527 lab=_47374_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -9260 0 0 {name=X_47374_ }
C {devices/lab_pin.sym} 45780 -9150 0 0 {name=p45528 lab=_59488_/Y }
C {devices/lab_pin.sym} 45780 -9110 0 0 {name=p45529 lab=_71628_/X }
C {devices/lab_pin.sym} 45780 -9070 0 0 {name=p45530 lab=_71637_/Y }
C {devices/lab_pin.sym} 45940 -9110 0 1 {name=p45531 lab=_71638_/Y }
C {sky130_stdcells/o21ai_4.sym} 45860 -9110 0 0 {name=X_71638_ }
C {devices/lab_pin.sym} 45800 -8980 0 0 {name=p45532 lab=_78193_/Y }
C {devices/lab_pin.sym} 45800 -8940 0 0 {name=p45533 lab=_78191_/C }
C {devices/lab_pin.sym} 45920 -8960 0 1 {name=p45534 lab=_78194_/X }
C {sky130_stdcells/and2_4.sym} 45860 -8960 0 0 {name=X_78194_ }
C {devices/lab_pin.sym} 45820 -8830 0 0 {name=p45535 lab=_44586_/A }
C {devices/lab_pin.sym} 45900 -8830 0 1 {name=p45536 lab=_87044_/D }
C {sky130_stdcells/inv_2.sym} 45860 -8830 0 0 {name=X_44586_ }
C {devices/lab_pin.sym} 45780 -8740 0 0 {name=p45537 lab=_41797_/X }
C {devices/lab_pin.sym} 45780 -8700 0 0 {name=p45538 lab=_41750_/X }
C {devices/lab_pin.sym} 45780 -8660 0 0 {name=p45539 lab=_66583_/B }
C {devices/lab_pin.sym} 45780 -8620 0 0 {name=p45540 lab=_41751_/X }
C {devices/lab_pin.sym} 45940 -8680 0 1 {name=p45541 lab=_88147_/D }
C {sky130_stdcells/a2bb2o_4.sym} 45860 -8680 0 0 {name=X_41798_ }
C {devices/lab_pin.sym} 45800 -8550 0 0 {name=p45542 lab=_50677_/A }
C {devices/lab_pin.sym} 45800 -8510 0 0 {name=p45543 lab=_49113_/B }
C {devices/lab_pin.sym} 45800 -8470 0 0 {name=p45544 lab=_49091_/C }
C {devices/lab_pin.sym} 45920 -8510 0 1 {name=p45545 lab=_49113_/X }
C {sky130_stdcells/and3_4.sym} 45860 -8510 0 0 {name=X_49113_ }
C {devices/lab_pin.sym} 45820 -8370 0 0 {name=p45546 lab=_53971_/B }
C {devices/lab_pin.sym} 45900 -8370 0 1 {name=p45547 lab=_50757_/B }
C {sky130_stdcells/buf_2.sym} 45860 -8370 0 0 {name=X_46325_ }
C {devices/lab_pin.sym} 45800 -8260 0 0 {name=p45548 lab=_77142_/Y }
C {devices/lab_pin.sym} 45800 -8220 0 0 {name=p45549 lab=_77144_/X }
C {devices/lab_pin.sym} 45920 -8240 0 1 {name=p45550 lab=_77146_/B }
C {sky130_stdcells/nand2_4.sym} 45860 -8240 0 0 {name=X_77145_ }
C {devices/lab_pin.sym} 45780 -8140 0 0 {name=p45551 lab=_40418_/X }
C {devices/lab_pin.sym} 45780 -8100 0 0 {name=p45552 lab=_43532_/X }
C {devices/lab_pin.sym} 45780 -8060 0 0 {name=p45553 lab=_87370_/Q }
C {devices/lab_pin.sym} 45780 -8020 0 0 {name=p45554 lab=_43533_/X }
C {devices/lab_pin.sym} 45940 -8080 0 1 {name=p45555 lab=_87370_/D }
C {sky130_stdcells/a2bb2o_4.sym} 45860 -8080 0 0 {name=X_43537_ }
C {devices/lab_pin.sym} 45800 -7950 0 0 {name=p45556 lab=_45954_/X }
C {devices/lab_pin.sym} 45800 -7910 0 0 {name=p45557 lab=_58334_/A }
C {devices/lab_pin.sym} 45800 -7870 0 0 {name=p45558 lab=_56163_/A }
C {devices/lab_pin.sym} 45920 -7910 0 1 {name=p45559 lab=_74357_/Y }
C {sky130_stdcells/nand3_4.sym} 45860 -7910 0 0 {name=X_74357_ }
C {devices/lab_pin.sym} 45800 -7800 0 0 {name=p45560 lab=_62344_/X }
C {devices/lab_pin.sym} 45800 -7760 0 0 {name=p45561 lab=_57664_/X }
C {devices/lab_pin.sym} 45800 -7720 0 0 {name=p45562 lab=_62315_/C }
C {devices/lab_pin.sym} 45800 -7680 0 0 {name=p45563 lab=_62355_/X }
C {devices/lab_pin.sym} 45920 -7740 0 1 {name=p45564 lab=_62371_/X }
C {sky130_stdcells/and4_4.sym} 45860 -7740 0 0 {name=X_62371_ }
C {devices/lab_pin.sym} 45820 -7590 0 0 {name=p45565 lab=_40748_/Y }
C {devices/lab_pin.sym} 45900 -7590 0 1 {name=p45566 lab=_40749_/X }
C {sky130_stdcells/buf_2.sym} 45860 -7590 0 0 {name=X_40749_ }
C {devices/lab_pin.sym} 45780 -7490 0 0 {name=p45567 lab=_71557_/X }
C {devices/lab_pin.sym} 45780 -7450 0 0 {name=p45568 lab=_83453_/Q }
C {devices/lab_pin.sym} 45780 -7410 0 0 {name=p45569 lab=_71568_/Y }
C {devices/lab_pin.sym} 45940 -7450 0 1 {name=p45570 lab=_71569_/X }
C {sky130_stdcells/a21o_4.sym} 45860 -7450 0 0 {name=X_71569_ }
C {devices/lab_pin.sym} 45800 -7320 0 0 {name=p45571 lab=_58970_/A }
C {devices/lab_pin.sym} 45800 -7280 0 0 {name=p45572 lab=_64102_/B }
C {devices/lab_pin.sym} 45920 -7300 0 1 {name=p45573 lab=_64110_/Y }
C {sky130_stdcells/nor2_4.sym} 45860 -7300 0 0 {name=X_64110_ }
C {devices/lab_pin.sym} 45820 -7170 0 0 {name=p45574 lab=_49044_/A }
C {devices/lab_pin.sym} 45900 -7170 0 1 {name=p45575 lab=_53860_/B }
C {sky130_stdcells/inv_2.sym} 45860 -7170 0 0 {name=X_49044_ }
C {devices/lab_pin.sym} 45820 -7050 0 0 {name=p45576 lab=_61321_/Y }
C {devices/lab_pin.sym} 45900 -7050 0 1 {name=p45577 lab=_61323_/B }
C {sky130_stdcells/buf_2.sym} 45860 -7050 0 0 {name=X_61322_ }
C {devices/lab_pin.sym} 45780 -6960 0 0 {name=p45578 lab=_73210_/X }
C {devices/lab_pin.sym} 45780 -6920 0 0 {name=p45579 lab=_85580_/Q }
C {devices/lab_pin.sym} 45780 -6880 0 0 {name=p45580 lab=_73284_/X }
C {devices/lab_pin.sym} 45780 -6840 0 0 {name=p45581 lab=_73307_/X }
C {devices/lab_pin.sym} 45940 -6900 0 1 {name=p45582 lab=_73308_/X }
C {sky130_stdcells/a211o_4.sym} 45860 -6900 0 0 {name=X_73308_ }
C {devices/lab_pin.sym} 45800 -6760 0 0 {name=p45583 lab=_46272_/A }
C {devices/lab_pin.sym} 45800 -6720 0 0 {name=p45584 lab=_49212_/B }
C {devices/lab_pin.sym} 45920 -6740 0 1 {name=p45585 lab=_46256_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -6740 0 0 {name=X_46256_ }
C {sky130_stdcells/decap_3.sym} 45860 -6580 0 0 {name=XPHY_680 }
C {devices/lab_pin.sym} 45800 -6440 0 0 {name=p45586 lab=_65090_/A }
C {devices/lab_pin.sym} 45800 -6400 0 0 {name=p45587 lab=_65089_/Y }
C {devices/lab_pin.sym} 45920 -6420 0 1 {name=p45588 lab=_65090_/Y }
C {sky130_stdcells/nand2_4.sym} 45860 -6420 0 0 {name=X_65090_ }
C {devices/lab_pin.sym} 45800 -6300 0 0 {name=p45589 lab=_81997_/Q }
C {devices/lab_pin.sym} 45800 -6260 0 0 {name=p45590 lab=_82285_/D }
C {devices/lab_pin.sym} 45920 -6280 0 1 {name=p45591 lab=_77086_/B }
C {sky130_stdcells/nand2_4.sym} 45860 -6280 0 0 {name=X_77076_ }
C {devices/lab_pin.sym} 45780 -6180 0 0 {name=p45592 lab=_41651_/X }
C {devices/lab_pin.sym} 45780 -6140 0 0 {name=p45593 lab=_43465_/X }
C {devices/lab_pin.sym} 45780 -6100 0 0 {name=p45594 lab=_87407_/Q }
C {devices/lab_pin.sym} 45780 -6060 0 0 {name=p45595 lab=_43467_/X }
C {devices/lab_pin.sym} 45940 -6120 0 1 {name=p45596 lab=_87407_/D }
C {sky130_stdcells/a2bb2o_4.sym} 45860 -6120 0 0 {name=X_43468_ }
C {devices/lab_pin.sym} 45820 -5970 0 0 {name=p45597 lab=_72686_/A }
C {devices/lab_pin.sym} 45900 -5970 0 1 {name=p45598 lab=_74288_/X }
C {sky130_stdcells/buf_2.sym} 45860 -5970 0 0 {name=X_74288_ }
C {sky130_stdcells/decap_3.sym} 45860 -5820 0 0 {name=XPHY_691 }
C {devices/lab_pin.sym} 45780 -5690 0 0 {name=p45599 lab=_56341_/C }
C {devices/lab_pin.sym} 45780 -5650 0 0 {name=p45600 lab=_45206_/X }
C {devices/lab_pin.sym} 45780 -5610 0 0 {name=p45601 lab=_45161_/X }
C {devices/lab_pin.sym} 45940 -5650 0 1 {name=p45602 lab=_45207_/X }
C {sky130_stdcells/o21a_4.sym} 45860 -5650 0 0 {name=X_45207_ }
C {devices/lab_pin.sym} 45820 -5510 0 0 {name=p45603 lab=_60930_/C }
C {devices/lab_pin.sym} 45900 -5510 0 1 {name=p45604 lab=_64091_/D }
C {sky130_stdcells/buf_2.sym} 45860 -5510 0 0 {name=X_64041_ }
C {devices/lab_pin.sym} 45800 -5400 0 0 {name=p45605 lab=_81713_/D }
C {devices/lab_pin.sym} 45800 -5360 0 0 {name=p45606 lab=_76027_/B }
C {devices/lab_pin.sym} 45920 -5380 0 1 {name=p45607 lab=_76028_/B }
C {sky130_stdcells/nand2_4.sym} 45860 -5380 0 0 {name=X_76027_ }
C {devices/lab_pin.sym} 45820 -5250 0 0 {name=p45608 lab=_42419_/A }
C {devices/lab_pin.sym} 45900 -5250 0 1 {name=p45609 lab=_42419_/Y }
C {sky130_stdcells/inv_2.sym} 45860 -5250 0 0 {name=X_42419_ }
C {devices/lab_pin.sym} 45780 -5150 0 0 {name=p45610 lab=_61153_/C }
C {devices/lab_pin.sym} 45780 -5110 0 0 {name=p45611 lab=_61271_/A }
C {devices/lab_pin.sym} 45780 -5070 0 0 {name=p45612 lab=_61202_/B }
C {devices/lab_pin.sym} 45940 -5110 0 1 {name=p45613 lab=_61254_/D }
C {sky130_stdcells/o21ai_4.sym} 45860 -5110 0 0 {name=X_61253_ }
C {devices/lab_pin.sym} 45800 -4980 0 0 {name=p45614 lab=_73239_/A }
C {devices/lab_pin.sym} 45800 -4940 0 0 {name=p45615 lab=_86511_/Q }
C {devices/lab_pin.sym} 45920 -4960 0 1 {name=p45616 lab=_73239_/X }
C {sky130_stdcells/and2_4.sym} 45860 -4960 0 0 {name=X_73239_ }
C {devices/lab_pin.sym} 45820 -4830 0 0 {name=p45617 lab=_46187_/A }
C {devices/lab_pin.sym} 45900 -4830 0 1 {name=p45618 lab=_74842_/B }
C {sky130_stdcells/buf_2.sym} 45860 -4830 0 0 {name=X_46187_ }
C {devices/lab_pin.sym} 45820 -4710 0 0 {name=p45619 lab=_43296_/A }
C {devices/lab_pin.sym} 45900 -4710 0 1 {name=p45620 lab=_43399_/X }
C {sky130_stdcells/buf_2.sym} 45860 -4710 0 0 {name=X_43399_ }
C {devices/lab_pin.sym} 45820 -4590 0 0 {name=p45621 lab=_60204_/A }
C {devices/lab_pin.sym} 45900 -4590 0 1 {name=p45622 lab=_60288_/C }
C {sky130_stdcells/buf_2.sym} 45860 -4590 0 0 {name=X_60204_ }
C {devices/lab_pin.sym} 45780 -4490 0 0 {name=p45623 lab=_45133_/Y }
C {devices/lab_pin.sym} 45780 -4450 0 0 {name=p45624 lab=_45136_/Y }
C {devices/lab_pin.sym} 45780 -4410 0 0 {name=p45625 lab=_45137_/X }
C {devices/lab_pin.sym} 45940 -4450 0 1 {name=p45626 lab=_45138_/X }
C {sky130_stdcells/a21o_4.sym} 45860 -4450 0 0 {name=X_45138_ }
C {devices/lab_pin.sym} 45780 -4340 0 0 {name=p45627 lab=_84513_/Q }
C {devices/lab_pin.sym} 45780 -4300 0 0 {name=p45628 lab=_60979_/X }
C {devices/lab_pin.sym} 45780 -4260 0 0 {name=p45629 lab=_61176_/Y }
C {devices/lab_pin.sym} 45780 -4220 0 0 {name=p45630 lab=_61183_/Y }
C {devices/lab_pin.sym} 45940 -4280 0 1 {name=p45631 lab=_84513_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 45860 -4280 0 0 {name=X_61184_ }
C {devices/lab_pin.sym} 45780 -4150 0 0 {name=p45632 lab=_67794_/X }
C {devices/lab_pin.sym} 45780 -4110 0 0 {name=p45633 lab=_67797_/X }
C {devices/lab_pin.sym} 45780 -4070 0 0 {name=p45634 lab=_67799_/X }
C {devices/lab_pin.sym} 45940 -4110 0 1 {name=p45635 lab=_67800_/X }
C {sky130_stdcells/a21o_4.sym} 45860 -4110 0 0 {name=X_67800_ }
C {devices/lab_pin.sym} 45820 -3970 0 0 {name=p45636 lab=_60134_/X }
C {devices/lab_pin.sym} 45900 -3970 0 1 {name=p45637 lab=_84656_/D }
C {sky130_stdcells/inv_2.sym} 45860 -3970 0 0 {name=X_60135_ }
C {devices/lab_pin.sym} 45780 -3870 0 0 {name=p45638 lab=_72251_/B }
C {devices/lab_pin.sym} 45780 -3830 0 0 {name=p45639 lab=_49934_/X }
C {devices/lab_pin.sym} 45780 -3790 0 0 {name=p45640 lab=_49945_/Y }
C {devices/lab_pin.sym} 45940 -3830 0 1 {name=p45641 lab=_49946_/Y }
C {sky130_stdcells/o21ai_4.sym} 45860 -3830 0 0 {name=X_49946_ }
C {devices/lab_pin.sym} 45820 -3690 0 0 {name=p45642 lab=_64334_/B }
C {devices/lab_pin.sym} 45900 -3690 0 1 {name=p45643 lab=_61447_/B }
C {sky130_stdcells/buf_2.sym} 45860 -3690 0 0 {name=X_45069_ }
C {devices/lab_pin.sym} 45780 -3600 0 0 {name=p45644 lab=_43070_/A }
C {devices/lab_pin.sym} 45780 -3560 0 0 {name=p45645 lab=_68778_/X }
C {devices/lab_pin.sym} 45780 -3520 0 0 {name=p45646 lab=_68552_/X }
C {devices/lab_pin.sym} 45780 -3480 0 0 {name=p45647 lab=_68779_/X }
C {devices/lab_pin.sym} 45940 -3540 0 1 {name=p45648 lab=_68780_/X }
C {sky130_stdcells/a211o_4.sym} 45860 -3540 0 0 {name=X_68780_ }
C {devices/lab_pin.sym} 45800 -3400 0 0 {name=p45649 lab=_65992_/A }
C {devices/lab_pin.sym} 45800 -3360 0 0 {name=p45650 lab=_73707_/B }
C {devices/lab_pin.sym} 45920 -3380 0 1 {name=p45651 lab=_65992_/X }
C {sky130_stdcells/and2_4.sym} 45860 -3380 0 0 {name=X_65992_ }
C {devices/lab_pin.sym} 45800 -3260 0 0 {name=p45652 lab=_77975_/Y }
C {devices/lab_pin.sym} 45800 -3220 0 0 {name=p45653 lab=_77977_/Y }
C {devices/lab_pin.sym} 45920 -3240 0 1 {name=p45654 lab=_77980_/C }
C {sky130_stdcells/nor2_4.sym} 45860 -3240 0 0 {name=X_77978_ }
C {devices/lab_pin.sym} 45780 -3130 0 0 {name=p45655 lab=_67728_/X }
C {devices/lab_pin.sym} 45780 -3090 0 0 {name=p45656 lab=_67730_/X }
C {devices/lab_pin.sym} 45780 -3050 0 0 {name=p45657 lab=_67681_/X }
C {devices/lab_pin.sym} 45940 -3090 0 1 {name=p45658 lab=_67731_/X }
C {sky130_stdcells/a21o_4.sym} 45860 -3090 0 0 {name=X_67731_ }
C {devices/lab_pin.sym} 45780 -2970 0 0 {name=p45659 lab=_79703_/Y }
C {devices/lab_pin.sym} 45780 -2930 0 0 {name=p45660 lab=_79708_/Y }
C {devices/lab_pin.sym} 45780 -2890 0 0 {name=p45661 lab=_79716_/X }
C {devices/lab_pin.sym} 45940 -2930 0 1 {name=p45662 lab=_79717_/Y }
C {sky130_stdcells/o21ai_4.sym} 45860 -2930 0 0 {name=X_79717_ }
C {devices/lab_pin.sym} 45780 -2810 0 0 {name=p45663 lab=_64938_/Y }
C {devices/lab_pin.sym} 45780 -2770 0 0 {name=p45664 lab=_64939_/X }
C {devices/lab_pin.sym} 45780 -2730 0 0 {name=p45665 lab=_64942_/Y }
C {devices/lab_pin.sym} 45940 -2770 0 1 {name=p45666 lab=_84221_/D }
C {sky130_stdcells/a21o_4.sym} 45860 -2770 0 0 {name=X_64943_ }
C {devices/lab_pin.sym} 45820 -2630 0 0 {name=p45667 lab=_59842_/A }
C {devices/lab_pin.sym} 45900 -2630 0 1 {name=p45668 lab=_60081_/A }
C {sky130_stdcells/buf_2.sym} 45860 -2630 0 0 {name=X_60066_ }
C {devices/lab_pin.sym} 45800 -2520 0 0 {name=p45669 lab=_81680_/Q }
C {devices/lab_pin.sym} 45800 -2480 0 0 {name=p45670 lab=_76929_/B }
C {devices/lab_pin.sym} 45920 -2500 0 1 {name=p45671 lab=_76945_/A }
C {sky130_stdcells/xnor2_4.sym} 45860 -2500 0 0 {name=X_76929_ }
C {devices/lab_pin.sym} 45800 -2400 0 0 {name=p45672 lab=_49893_/A }
C {devices/lab_pin.sym} 45800 -2360 0 0 {name=p45673 lab=_49884_/B }
C {devices/lab_pin.sym} 45800 -2320 0 0 {name=p45674 lab=_49893_/C }
C {devices/lab_pin.sym} 45800 -2280 0 0 {name=p45675 lab=_53090_/D }
C {devices/lab_pin.sym} 45920 -2340 0 1 {name=p45676 lab=_49877_/X }
C {sky130_stdcells/and4_4.sym} 45860 -2340 0 0 {name=X_49877_ }
C {devices/lab_pin.sym} 45820 -2190 0 0 {name=p45677 lab=_48853_/A }
C {devices/lab_pin.sym} 45900 -2190 0 1 {name=p45678 lab=_48849_/C }
C {sky130_stdcells/buf_2.sym} 45860 -2190 0 0 {name=X_48828_ }
C {devices/lab_pin.sym} 45780 -2100 0 0 {name=p45679 lab=_67522_/X }
C {devices/lab_pin.sym} 45780 -2060 0 0 {name=p45680 lab=_67649_/Y }
C {devices/lab_pin.sym} 45780 -2020 0 0 {name=p45681 lab=_67624_/X }
C {devices/lab_pin.sym} 45780 -1980 0 0 {name=p45682 lab=_67661_/Y }
C {devices/lab_pin.sym} 45940 -2040 0 1 {name=p45683 lab=_67662_/X }
C {sky130_stdcells/a211o_4.sym} 45860 -2040 0 0 {name=X_67662_ }
C {devices/lab_pin.sym} 45800 -1900 0 0 {name=p45684 lab=_84211_/Q }
C {devices/lab_pin.sym} 45800 -1860 0 0 {name=p45685 lab=_83259_/Q }
C {devices/lab_pin.sym} 45920 -1880 0 1 {name=p45686 lab=_79648_/X }
C {sky130_stdcells/xor2_4.sym} 45860 -1880 0 0 {name=X_79648_ }
C {devices/lab_pin.sym} 45800 -1760 0 0 {name=p45687 lab=_64804_/A }
C {devices/lab_pin.sym} 45800 -1720 0 0 {name=p45688 lab=_64874_/B }
C {devices/lab_pin.sym} 45920 -1740 0 1 {name=p45689 lab=_64874_/X }
C {sky130_stdcells/and2_4.sym} 45860 -1740 0 0 {name=X_64874_ }
C {devices/lab_pin.sym} 45800 -1620 0 0 {name=p45690 lab=_69322_/A }
C {devices/lab_pin.sym} 45800 -1580 0 0 {name=p45691 lab=_69401_/B }
C {devices/lab_pin.sym} 45920 -1600 0 1 {name=p45692 lab=_69401_/X }
C {sky130_stdcells/and2_4.sym} 45860 -1600 0 0 {name=X_69401_ }
C {devices/lab_pin.sym} 45780 -1490 0 0 {name=p45693 lab=_84104_/Q }
C {devices/lab_pin.sym} 45780 -1450 0 0 {name=p45694 lab=_59803_/X }
C {devices/lab_pin.sym} 45780 -1410 0 0 {name=p45695 lab=_66612_/X }
C {devices/lab_pin.sym} 45940 -1450 0 1 {name=p45696 lab=_84104_/D }
C {sky130_stdcells/a21bo_4.sym} 45860 -1450 0 0 {name=X_66613_ }
C {devices/lab_pin.sym} 45800 -1340 0 0 {name=p45697 lab=_61811_/X }
C {devices/lab_pin.sym} 45800 -1300 0 0 {name=p45698 lab=_63860_/B }
C {devices/lab_pin.sym} 45800 -1260 0 0 {name=p45699 lab=_63860_/C }
C {devices/lab_pin.sym} 45800 -1220 0 0 {name=p45700 lab=_63860_/D }
C {devices/lab_pin.sym} 45920 -1280 0 1 {name=p45701 lab=_63825_/Y }
C {sky130_stdcells/nand4_4.sym} 45860 -1280 0 0 {name=X_63825_ }
C {devices/lab_pin.sym} 45820 -1130 0 0 {name=p45702 lab=_48759_/A }
C {devices/lab_pin.sym} 45900 -1130 0 1 {name=p45703 lab=_48840_/A }
C {sky130_stdcells/buf_2.sym} 45860 -1130 0 0 {name=X_48759_ }
C {devices/lab_pin.sym} 45780 -1040 0 0 {name=p45704 lab=_87976_/Q }
C {devices/lab_pin.sym} 45780 -1000 0 0 {name=p45705 lab=_67591_/X }
C {devices/lab_pin.sym} 45780 -960 0 0 {name=p45706 lab=_67524_/X }
C {devices/lab_pin.sym} 45780 -920 0 0 {name=p45707 lab=_67592_/X }
C {devices/lab_pin.sym} 45940 -980 0 1 {name=p45708 lab=_67593_/X }
C {sky130_stdcells/a211o_4.sym} 45860 -980 0 0 {name=X_67593_ }
C {devices/lab_pin.sym} 45780 -850 0 0 {name=p45709 lab=_79547_/Y }
C {devices/lab_pin.sym} 45780 -810 0 0 {name=p45710 lab=_79561_/Y }
C {devices/lab_pin.sym} 45780 -770 0 0 {name=p45711 lab=_79559_/Y }
C {devices/lab_pin.sym} 45940 -810 0 1 {name=p45712 lab=_79580_/B }
C {sky130_stdcells/a21oi_4.sym} 45860 -810 0 0 {name=X_79579_ }
C {devices/lab_pin.sym} 45770 -670 0 0 {name=p45713 lab=_83184_/CLK }
C {devices/lab_pin.sym} 45770 -650 0 0 {name=p45714 lab=_81610_/D }
C {devices/lab_pin.sym} 45950 -670 0 1 {name=p45715 lab=_81802_/D }
C {sky130_stdcells/dfxtp_4.sym} 45860 -660 0 0 {name=X_81610_ }
C {devices/lab_pin.sym} 46720 -42160 0 0 {name=p45716 lab=_69236_/A }
C {devices/lab_pin.sym} 46720 -42120 0 0 {name=p45717 lab=_69332_/B }
C {devices/lab_pin.sym} 46840 -42140 0 1 {name=p45718 lab=_69332_/X }
C {sky130_stdcells/and2_4.sym} 46780 -42140 0 0 {name=X_69332_ }
C {devices/lab_pin.sym} 46720 -42020 0 0 {name=p45719 lab=_68999_/A }
C {devices/lab_pin.sym} 46720 -41980 0 0 {name=p45720 lab=_66544_/B }
C {devices/lab_pin.sym} 46840 -42000 0 1 {name=p45721 lab=_66544_/X }
C {sky130_stdcells/and2_4.sym} 46780 -42000 0 0 {name=X_66544_ }
C {devices/lab_pin.sym} 46720 -41880 0 0 {name=p45722 lab=_51779_/A }
C {devices/lab_pin.sym} 46720 -41840 0 0 {name=p45723 lab=_51770_/B }
C {devices/lab_pin.sym} 46840 -41860 0 1 {name=p45724 lab=_51770_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -41860 0 0 {name=X_51770_ }
C {devices/lab_pin.sym} 46740 -41730 0 0 {name=p45725 lab=_64045_/A }
C {devices/lab_pin.sym} 46820 -41730 0 1 {name=p45726 lab=_64192_/D }
C {sky130_stdcells/buf_2.sym} 46780 -41730 0 0 {name=X_63756_ }
C {devices/lab_pin.sym} 46690 -41610 0 0 {name=p45727 lab=_82671_/CLK }
C {devices/lab_pin.sym} 46690 -41590 0 0 {name=p45728 lab=_82622_/Q }
C {devices/lab_pin.sym} 46870 -41610 0 1 {name=p45729 lab=_82590_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -41600 0 0 {name=X_82590_ }
C {devices/lab_pin.sym} 46700 -41490 0 0 {name=p45730 lab=_60950_/Y }
C {devices/lab_pin.sym} 46700 -41450 0 0 {name=p45731 lab=_60993_/B }
C {devices/lab_pin.sym} 46700 -41410 0 0 {name=p45732 lab=_60967_/X }
C {devices/lab_pin.sym} 46860 -41450 0 1 {name=p45733 lab=_60968_/X }
C {sky130_stdcells/a21o_4.sym} 46780 -41450 0 0 {name=X_60968_ }
C {devices/lab_pin.sym} 46720 -41320 0 0 {name=p45734 lab=_50657_/A }
C {devices/lab_pin.sym} 46720 -41280 0 0 {name=p45735 lab=_50721_/B }
C {devices/lab_pin.sym} 46840 -41300 0 1 {name=p45736 lab=_50721_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -41300 0 0 {name=X_50721_ }
C {devices/lab_pin.sym} 46700 -41190 0 0 {name=p45737 lab=_62705_/X }
C {devices/lab_pin.sym} 46700 -41150 0 0 {name=p45738 lab=_62652_/X }
C {devices/lab_pin.sym} 46700 -41110 0 0 {name=p45739 lab=_62706_/Y }
C {devices/lab_pin.sym} 46860 -41150 0 1 {name=p45740 lab=_62707_/Y }
C {sky130_stdcells/a21oi_4.sym} 46780 -41150 0 0 {name=X_62707_ }
C {devices/lab_pin.sym} 46690 -41010 0 0 {name=p45741 lab=_81412_/CLK }
C {devices/lab_pin.sym} 46690 -40990 0 0 {name=p45742 lab=_76682_/X }
C {devices/lab_pin.sym} 46870 -41010 0 1 {name=p45743 lab=_81541_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -41000 0 0 {name=X_81541_ }
C {devices/lab_pin.sym} 46700 -40900 0 0 {name=p45744 lab=_87530_/Q }
C {devices/lab_pin.sym} 46700 -40860 0 0 {name=p45745 lab=_69261_/X }
C {devices/lab_pin.sym} 46700 -40820 0 0 {name=p45746 lab=_69248_/X }
C {devices/lab_pin.sym} 46700 -40780 0 0 {name=p45747 lab=_69262_/X }
C {devices/lab_pin.sym} 46860 -40840 0 1 {name=p45748 lab=_69263_/X }
C {sky130_stdcells/a211o_4.sym} 46780 -40840 0 0 {name=X_69263_ }
C {devices/lab_pin.sym} 46740 -40690 0 0 {name=p45749 lab=_66411_/A }
C {devices/lab_pin.sym} 46820 -40690 0 1 {name=p45750 lab=_66475_/X }
C {sky130_stdcells/buf_2.sym} 46780 -40690 0 0 {name=X_66475_ }
C {devices/lab_pin.sym} 46720 -40600 0 0 {name=p45751 lab=_58360_/A }
C {devices/lab_pin.sym} 46720 -40560 0 0 {name=p45752 lab=_63416_/A }
C {devices/lab_pin.sym} 46720 -40520 0 0 {name=p45753 lab=_63661_/C }
C {devices/lab_pin.sym} 46720 -40480 0 0 {name=p45754 lab=_63699_/D }
C {devices/lab_pin.sym} 46840 -40540 0 1 {name=p45755 lab=_63687_/Y }
C {sky130_stdcells/nand4_4.sym} 46780 -40540 0 0 {name=X_63687_ }
C {devices/lab_pin.sym} 46700 -40430 0 0 {name=p45756 lab=_60881_/Y }
C {devices/lab_pin.sym} 46700 -40390 0 0 {name=p45757 lab=_61036_/C }
C {devices/lab_pin.sym} 46700 -40350 0 0 {name=p45758 lab=_60897_/Y }
C {devices/lab_pin.sym} 46700 -40310 0 0 {name=p45759 lab=_84553_/Q }
C {devices/lab_pin.sym} 46700 -40270 0 0 {name=p45760 lab=_60898_/X }
C {devices/lab_pin.sym} 46860 -40350 0 1 {name=p45761 lab=_60899_/X }
C {sky130_stdcells/o32a_4.sym} 46780 -40350 0 0 {name=X_60899_ }
C {devices/lab_pin.sym} 46700 -40220 0 0 {name=p45762 lab=_68196_/X }
C {devices/lab_pin.sym} 46700 -40180 0 0 {name=p45763 lab=_67316_/Y }
C {devices/lab_pin.sym} 46700 -40140 0 0 {name=p45764 lab=_68207_/X }
C {devices/lab_pin.sym} 46700 -40100 0 0 {name=p45765 lab=_68213_/Y }
C {devices/lab_pin.sym} 46860 -40160 0 1 {name=p45766 lab=_68214_/X }
C {sky130_stdcells/a211o_4.sym} 46780 -40160 0 0 {name=X_68214_ }
C {devices/lab_pin.sym} 46700 -40030 0 0 {name=p45767 lab=_53435_/Y }
C {devices/lab_pin.sym} 46700 -39990 0 0 {name=p45768 lab=_53437_/X }
C {devices/lab_pin.sym} 46700 -39950 0 0 {name=p45769 lab=_53439_/X }
C {devices/lab_pin.sym} 46860 -39990 0 1 {name=p45770 lab=_53440_/Y }
C {sky130_stdcells/a21oi_4.sym} 46780 -39990 0 0 {name=X_53440_ }
C {devices/lab_pin.sym} 46700 -39880 0 0 {name=p45771 lab=_65272_/X }
C {devices/lab_pin.sym} 46700 -39840 0 0 {name=p45772 lab=_85601_/Q }
C {devices/lab_pin.sym} 46700 -39800 0 0 {name=p45773 lab=_65326_/X }
C {devices/lab_pin.sym} 46700 -39760 0 0 {name=p45774 lab=_65425_/X }
C {devices/lab_pin.sym} 46860 -39820 0 1 {name=p45775 lab=_65426_/X }
C {sky130_stdcells/a211o_4.sym} 46780 -39820 0 0 {name=X_65426_ }
C {devices/lab_pin.sym} 46690 -39670 0 0 {name=p45776 lab=_84314_/CLK }
C {devices/lab_pin.sym} 46690 -39650 0 0 {name=p45777 lab=_84260_/D }
C {devices/lab_pin.sym} 46870 -39670 0 1 {name=p45778 lab=_84260_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -39660 0 0 {name=X_84260_ }
C {devices/lab_pin.sym} 46720 -39550 0 0 {name=p45779 lab=_50142_/A }
C {devices/lab_pin.sym} 46720 -39510 0 0 {name=p45780 lab=_50651_/X }
C {devices/lab_pin.sym} 46720 -39470 0 0 {name=p45781 lab=_50568_/C }
C {devices/lab_pin.sym} 46840 -39510 0 1 {name=p45782 lab=_50652_/X }
C {sky130_stdcells/and3_4.sym} 46780 -39510 0 0 {name=X_50652_ }
C {devices/lab_pin.sym} 46720 -39380 0 0 {name=p45783 lab=_59478_/A }
C {devices/lab_pin.sym} 46720 -39340 0 0 {name=p45784 lab=_60337_/C }
C {devices/lab_pin.sym} 46840 -39360 0 1 {name=p45785 lab=_62638_/Y }
C {sky130_stdcells/nor2_4.sym} 46780 -39360 0 0 {name=X_62638_ }
C {devices/lab_pin.sym} 46690 -39230 0 0 {name=p45786 lab=_81322_/CLK }
C {devices/lab_pin.sym} 46690 -39210 0 0 {name=p45787 lab=_76938_/X }
C {devices/lab_pin.sym} 46870 -39230 0 1 {name=p45788 lab=_81440_/D }
C {sky130_stdcells/dfxtp_4.sym} 46780 -39220 0 0 {name=X_81472_ }
C {devices/lab_pin.sym} 46700 -39120 0 0 {name=p45789 lab=_87535_/Q }
C {devices/lab_pin.sym} 46700 -39080 0 0 {name=p45790 lab=_69044_/X }
C {devices/lab_pin.sym} 46700 -39040 0 0 {name=p45791 lab=_68979_/X }
C {devices/lab_pin.sym} 46700 -39000 0 0 {name=p45792 lab=_69193_/X }
C {devices/lab_pin.sym} 46860 -39060 0 1 {name=p45793 lab=_69194_/X }
C {sky130_stdcells/a211o_4.sym} 46780 -39060 0 0 {name=X_69194_ }
C {devices/lab_pin.sym} 46690 -38910 0 0 {name=p45794 lab=_83216_/CLK }
C {devices/lab_pin.sym} 46690 -38890 0 0 {name=p45795 lab=_72627_/Y }
C {devices/lab_pin.sym} 46870 -38910 0 1 {name=p45796 lab=_79168_/A }
C {sky130_stdcells/dfxtp_4.sym} 46780 -38900 0 0 {name=X_83211_ }
C {devices/lab_pin.sym} 46720 -38780 0 0 {name=p45797 lab=_80423_/A }
C {devices/lab_pin.sym} 46720 -38740 0 0 {name=p45798 lab=_80423_/B }
C {devices/lab_pin.sym} 46840 -38760 0 1 {name=p45799 lab=_80436_/B }
C {sky130_stdcells/xnor2_4.sym} 46780 -38760 0 0 {name=X_80423_ }
C {devices/lab_pin.sym} 46700 -38650 0 0 {name=p45800 lab=_66918_/X }
C {devices/lab_pin.sym} 46700 -38610 0 0 {name=p45801 lab=_66921_/X }
C {devices/lab_pin.sym} 46700 -38570 0 0 {name=p45802 lab=_68133_/X }
C {devices/lab_pin.sym} 46860 -38610 0 1 {name=p45803 lab=_68145_/Y }
C {sky130_stdcells/a21oi_4.sym} 46780 -38610 0 0 {name=X_68145_ }
C {devices/lab_pin.sym} 46720 -38500 0 0 {name=p45804 lab=_53371_/A }
C {devices/lab_pin.sym} 46720 -38460 0 0 {name=p45805 lab=_53371_/B }
C {devices/lab_pin.sym} 46720 -38420 0 0 {name=p45806 lab=_53371_/C }
C {devices/lab_pin.sym} 46720 -38380 0 0 {name=p45807 lab=_52857_/D }
C {devices/lab_pin.sym} 46840 -38440 0 1 {name=p45808 lab=_53371_/X }
C {sky130_stdcells/and4_4.sym} 46780 -38440 0 0 {name=X_53371_ }
C {devices/lab_pin.sym} 46720 -38300 0 0 {name=p45809 lab=_65408_/A }
C {devices/lab_pin.sym} 46720 -38260 0 0 {name=p45810 lab=_65357_/B }
C {devices/lab_pin.sym} 46840 -38280 0 1 {name=p45811 lab=_65357_/X }
C {sky130_stdcells/and2_4.sym} 46780 -38280 0 0 {name=X_65357_ }
C {devices/lab_pin.sym} 46690 -38150 0 0 {name=p45812 lab=_84192_/CLK }
C {devices/lab_pin.sym} 46690 -38130 0 0 {name=p45813 lab=_84191_/D }
C {devices/lab_pin.sym} 46870 -38150 0 1 {name=p45814 lab=_84191_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -38140 0 0 {name=X_84191_ }
C {devices/lab_pin.sym} 46700 -38030 0 0 {name=p45815 lab=_86173_/Q }
C {devices/lab_pin.sym} 46700 -37990 0 0 {name=p45816 lab=_50563_/X }
C {devices/lab_pin.sym} 46700 -37950 0 0 {name=p45817 lab=_50582_/Y }
C {devices/lab_pin.sym} 46860 -37990 0 1 {name=p45818 lab=_50583_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -37990 0 0 {name=X_50583_ }
C {devices/lab_pin.sym} 46720 -37880 0 0 {name=p45819 lab=_62622_/A }
C {devices/lab_pin.sym} 46720 -37840 0 0 {name=p45820 lab=_62569_/B }
C {devices/lab_pin.sym} 46720 -37800 0 0 {name=p45821 lab=_62569_/C }
C {devices/lab_pin.sym} 46720 -37760 0 0 {name=p45822 lab=_62569_/D }
C {devices/lab_pin.sym} 46840 -37820 0 1 {name=p45823 lab=_62569_/Y }
C {sky130_stdcells/nand4_4.sym} 46780 -37820 0 0 {name=X_62569_ }
C {devices/lab_pin.sym} 46720 -37680 0 0 {name=p45824 lab=_55118_/A }
C {devices/lab_pin.sym} 46720 -37640 0 0 {name=p45825 lab=_47798_/A }
C {devices/lab_pin.sym} 46840 -37660 0 1 {name=p45826 lab=_55110_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -37660 0 0 {name=X_55110_ }
C {devices/lab_pin.sym} 46740 -37530 0 0 {name=p45827 lab=_52322_/A }
C {devices/lab_pin.sym} 46820 -37530 0 1 {name=p45828 lab=_52515_/A }
C {sky130_stdcells/buf_2.sym} 46780 -37530 0 0 {name=X_52322_ }
C {devices/lab_pin.sym} 46740 -37410 0 0 {name=p45829 lab=_64249_/A }
C {devices/lab_pin.sym} 46820 -37410 0 1 {name=p45830 lab=_64308_/X }
C {sky130_stdcells/buf_2.sym} 46780 -37410 0 0 {name=X_64308_ }
C {devices/lab_pin.sym} 46690 -37290 0 0 {name=p45831 lab=_83115_/CLK }
C {devices/lab_pin.sym} 46690 -37270 0 0 {name=p45832 lab=_73648_/Y }
C {devices/lab_pin.sym} 46870 -37290 0 1 {name=p45833 lab=_83142_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -37280 0 0 {name=X_83142_ }
C {devices/lab_pin.sym} 46740 -37150 0 0 {name=p45834 lab=_56089_/X }
C {devices/lab_pin.sym} 46820 -37150 0 1 {name=p45835 lab=_56098_/A }
C {sky130_stdcells/buf_2.sym} 46780 -37150 0 0 {name=X_56090_ }
C {devices/lab_pin.sym} 46700 -37050 0 0 {name=p45836 lab=_80338_/Y }
C {devices/lab_pin.sym} 46700 -37010 0 0 {name=p45837 lab=_80334_/Y }
C {devices/lab_pin.sym} 46700 -36970 0 0 {name=p45838 lab=_80336_/Y }
C {devices/lab_pin.sym} 46860 -37010 0 1 {name=p45839 lab=_80354_/Y }
C {sky130_stdcells/a21boi_4.sym} 46780 -37010 0 0 {name=X_80354_ }
C {devices/lab_pin.sym} 46700 -36900 0 0 {name=p45840 lab=_86944_/Q }
C {devices/lab_pin.sym} 46700 -36860 0 0 {name=p45841 lab=_68023_/X }
C {devices/lab_pin.sym} 46700 -36820 0 0 {name=p45842 lab=_68024_/X }
C {devices/lab_pin.sym} 46700 -36780 0 0 {name=p45843 lab=_68075_/X }
C {devices/lab_pin.sym} 46860 -36840 0 1 {name=p45844 lab=_68077_/B }
C {sky130_stdcells/a211o_4.sym} 46780 -36840 0 0 {name=X_68076_ }
C {devices/lab_pin.sym} 46700 -36710 0 0 {name=p45845 lab=_65283_/X }
C {devices/lab_pin.sym} 46700 -36670 0 0 {name=p45846 lab=_65286_/X }
C {devices/lab_pin.sym} 46700 -36630 0 0 {name=p45847 lab=_65287_/X }
C {devices/lab_pin.sym} 46860 -36670 0 1 {name=p45848 lab=_65288_/X }
C {sky130_stdcells/a21o_4.sym} 46780 -36670 0 0 {name=X_65288_ }
C {devices/lab_pin.sym} 46720 -36540 0 0 {name=p45849 lab=_55037_/A }
C {devices/lab_pin.sym} 46720 -36500 0 0 {name=p45850 lab=_47679_/A }
C {devices/lab_pin.sym} 46840 -36520 0 1 {name=p45851 lab=_55041_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -36520 0 0 {name=X_55041_ }
C {devices/lab_pin.sym} 46700 -36410 0 0 {name=p45852 lab=_67020_/X }
C {devices/lab_pin.sym} 46700 -36370 0 0 {name=p45853 lab=_67024_/X }
C {devices/lab_pin.sym} 46700 -36330 0 0 {name=p45854 lab=_67026_/X }
C {devices/lab_pin.sym} 46860 -36370 0 1 {name=p45855 lab=_67027_/X }
C {sky130_stdcells/a21o_4.sym} 46780 -36370 0 0 {name=X_67027_ }
C {devices/lab_pin.sym} 46720 -36250 0 0 {name=p45856 lab=_48702_/A }
C {devices/lab_pin.sym} 46720 -36210 0 0 {name=p45857 lab=_52267_/B }
C {devices/lab_pin.sym} 46720 -36170 0 0 {name=p45858 lab=_52267_/C }
C {devices/lab_pin.sym} 46840 -36210 0 1 {name=p45859 lab=_52253_/X }
C {sky130_stdcells/and3_4.sym} 46780 -36210 0 0 {name=X_52253_ }
C {devices/lab_pin.sym} 46700 -36110 0 0 {name=p45860 lab=_64234_/X }
C {devices/lab_pin.sym} 46700 -36070 0 0 {name=p45861 lab=_64235_/X }
C {devices/lab_pin.sym} 46700 -36030 0 0 {name=p45862 lab=_64236_/X }
C {devices/lab_pin.sym} 46700 -35990 0 0 {name=p45863 lab=_64238_/Y }
C {devices/lab_pin.sym} 46700 -35950 0 0 {name=p45864 lab=_64229_/X }
C {devices/lab_pin.sym} 46860 -36030 0 1 {name=p45865 lab=_64239_/X }
C {sky130_stdcells/o41a_4.sym} 46780 -36030 0 0 {name=X_64239_ }
C {devices/lab_pin.sym} 46690 -35870 0 0 {name=p45866 lab=_83584_/CLK }
C {devices/lab_pin.sym} 46690 -35850 0 0 {name=p45867 lab=_83073_/D }
C {devices/lab_pin.sym} 46870 -35870 0 1 {name=p45868 lab=_83073_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -35860 0 0 {name=X_83073_ }
C {devices/lab_pin.sym} 46690 -35730 0 0 {name=p45869 lab=_87950_/CLK }
C {devices/lab_pin.sym} 46690 -35710 0 0 {name=p45870 lab=_42265_/X }
C {devices/lab_pin.sym} 46870 -35730 0 1 {name=p45871 lab=_87950_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -35720 0 0 {name=X_87950_ }
C {devices/lab_pin.sym} 46720 -35600 0 0 {name=p45872 lab=_80283_/Y }
C {devices/lab_pin.sym} 46720 -35560 0 0 {name=p45873 lab=_80284_/Y }
C {devices/lab_pin.sym} 46840 -35580 0 1 {name=p45874 lab=_80286_/B }
C {sky130_stdcells/nand2_4.sym} 46780 -35580 0 0 {name=X_80285_ }
C {devices/lab_pin.sym} 46700 -35470 0 0 {name=p45875 lab=_51200_/Y }
C {devices/lab_pin.sym} 46700 -35430 0 0 {name=p45876 lab=_51201_/X }
C {devices/lab_pin.sym} 46700 -35390 0 0 {name=p45877 lab=_51203_/X }
C {devices/lab_pin.sym} 46860 -35430 0 1 {name=p45878 lab=_51204_/Y }
C {sky130_stdcells/a21oi_4.sym} 46780 -35430 0 0 {name=X_51204_ }
C {devices/lab_pin.sym} 46690 -35290 0 0 {name=p45879 lab=_85177_/CLK }
C {devices/lab_pin.sym} 46690 -35270 0 0 {name=p45880 lab=_45072_/Y }
C {devices/lab_pin.sym} 46870 -35290 0 1 {name=p45881 lab=_64334_/B }
C {sky130_stdcells/dfxtp_4.sym} 46780 -35280 0 0 {name=X_86901_ }
C {devices/lab_pin.sym} 46690 -35150 0 0 {name=p45882 lab=_81989_/CLK }
C {devices/lab_pin.sym} 46690 -35130 0 0 {name=p45883 lab=_77785_/B }
C {devices/lab_pin.sym} 46870 -35150 0 1 {name=p45884 lab=_81992_/D }
C {sky130_stdcells/dfxtp_4.sym} 46780 -35140 0 0 {name=X_82024_ }
C {devices/lab_pin.sym} 46740 -35010 0 0 {name=p45885 lab=_52438_/A }
C {devices/lab_pin.sym} 46820 -35010 0 1 {name=p45886 lab=_52184_/X }
C {sky130_stdcells/buf_2.sym} 46780 -35010 0 0 {name=X_52184_ }
C {devices/lab_pin.sym} 46690 -34890 0 0 {name=p45887 lab=_87625_/CLK }
C {devices/lab_pin.sym} 46690 -34870 0 0 {name=p45888 lab=_87881_/D }
C {devices/lab_pin.sym} 46870 -34890 0 1 {name=p45889 lab=_87881_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -34880 0 0 {name=X_87881_ }
C {devices/lab_pin.sym} 46720 -34760 0 0 {name=p45890 lab=_58763_/A }
C {devices/lab_pin.sym} 46720 -34720 0 0 {name=p45891 lab=_58800_/B }
C {devices/lab_pin.sym} 46840 -34740 0 1 {name=p45892 lab=_58800_/Y }
C {sky130_stdcells/nor2_4.sym} 46780 -34740 0 0 {name=X_58800_ }
C {devices/lab_pin.sym} 46700 -34630 0 0 {name=p45893 lab=_86067_/Q }
C {devices/lab_pin.sym} 46700 -34590 0 0 {name=p45894 lab=_51128_/X }
C {devices/lab_pin.sym} 46700 -34550 0 0 {name=p45895 lab=_51134_/Y }
C {devices/lab_pin.sym} 46860 -34590 0 1 {name=p45896 lab=_51135_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -34590 0 0 {name=X_51135_ }
C {devices/lab_pin.sym} 46690 -34450 0 0 {name=p45897 lab=_87225_/CLK }
C {devices/lab_pin.sym} 46690 -34430 0 0 {name=p45898 lab=_86832_/D }
C {devices/lab_pin.sym} 46870 -34450 0 1 {name=p45899 lab=_86832_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -34440 0 0 {name=X_86832_ }
C {devices/lab_pin.sym} 46740 -34310 0 0 {name=p45900 lab=_59780_/A }
C {devices/lab_pin.sym} 46820 -34310 0 1 {name=p45901 lab=_59780_/Y }
C {sky130_stdcells/inv_2.sym} 46780 -34310 0 0 {name=X_59780_ }
C {devices/lab_pin.sym} 46740 -34190 0 0 {name=p45902 lab=_56991_/Y }
C {devices/lab_pin.sym} 46820 -34190 0 1 {name=p45903 lab=_56994_/D }
C {sky130_stdcells/buf_2.sym} 46780 -34190 0 0 {name=X_56992_ }
C {devices/lab_pin.sym} 46700 -34100 0 0 {name=p45904 lab=_87994_/Q }
C {devices/lab_pin.sym} 46700 -34060 0 0 {name=p45905 lab=_68975_/X }
C {devices/lab_pin.sym} 46700 -34020 0 0 {name=p45906 lab=_68976_/X }
C {devices/lab_pin.sym} 46700 -33980 0 0 {name=p45907 lab=_68977_/X }
C {devices/lab_pin.sym} 46860 -34040 0 1 {name=p45908 lab=_68978_/X }
C {sky130_stdcells/a211o_4.sym} 46780 -34040 0 0 {name=X_68978_ }
C {devices/lab_pin.sym} 46700 -33910 0 0 {name=p45909 lab=_58730_/X }
C {devices/lab_pin.sym} 46700 -33870 0 0 {name=p45910 lab=_85940_/Q }
C {devices/lab_pin.sym} 46700 -33830 0 0 {name=p45911 lab=_58679_/X }
C {devices/lab_pin.sym} 46860 -33870 0 1 {name=p45912 lab=_58731_/X }
C {sky130_stdcells/o21a_4.sym} 46780 -33870 0 0 {name=X_58731_ }
C {devices/lab_pin.sym} 46740 -33730 0 0 {name=p45913 lab=_51013_/A }
C {devices/lab_pin.sym} 46820 -33730 0 1 {name=p45914 lab=_51071_/B }
C {sky130_stdcells/buf_2.sym} 46780 -33730 0 0 {name=X_51066_ }
C {devices/lab_pin.sym} 46720 -33620 0 0 {name=p45915 lab=_67955_/A }
C {devices/lab_pin.sym} 46720 -33580 0 0 {name=p45916 lab=_67929_/B }
C {devices/lab_pin.sym} 46840 -33600 0 1 {name=p45917 lab=_67929_/X }
C {sky130_stdcells/and2_4.sym} 46780 -33600 0 0 {name=X_67929_ }
C {devices/lab_pin.sym} 46720 -33480 0 0 {name=p45918 lab=_44085_/C }
C {devices/lab_pin.sym} 46720 -33440 0 0 {name=p45919 lab=_55943_/B }
C {devices/lab_pin.sym} 46840 -33460 0 1 {name=p45920 lab=_55943_/X }
C {sky130_stdcells/and2_4.sym} 46780 -33460 0 0 {name=X_55943_ }
C {devices/lab_pin.sym} 46690 -33330 0 0 {name=p45921 lab=_80672_/CLK }
C {devices/lab_pin.sym} 46690 -33310 0 0 {name=p45922 lab=_86763_/D }
C {devices/lab_pin.sym} 46870 -33330 0 1 {name=p45923 lab=_46186_/A }
C {sky130_stdcells/dfxtp_4.sym} 46780 -33320 0 0 {name=X_86763_ }
C {devices/lab_pin.sym} 46690 -33190 0 0 {name=p45924 lab=_80961_/CLK }
C {devices/lab_pin.sym} 46690 -33170 0 0 {name=p45925 lab=_68435_/X }
C {devices/lab_pin.sym} 46870 -33190 0 1 {name=p45926 lab=_83975_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -33180 0 0 {name=X_83975_ }
C {devices/lab_pin.sym} 46700 -33070 0 0 {name=p45927 lab=_50015_/Y }
C {devices/lab_pin.sym} 46700 -33030 0 0 {name=p45928 lab=_50003_/X }
C {devices/lab_pin.sym} 46700 -32990 0 0 {name=p45929 lab=_50016_/X }
C {devices/lab_pin.sym} 46860 -33030 0 1 {name=p45930 lab=_86281_/D }
C {sky130_stdcells/a21oi_4.sym} 46780 -33030 0 0 {name=X_50017_ }
C {devices/lab_pin.sym} 46690 -32890 0 0 {name=p45931 lab=_84757_/CLK }
C {devices/lab_pin.sym} 46690 -32870 0 0 {name=p45932 lab=_53009_/Y }
C {devices/lab_pin.sym} 46870 -32890 0 1 {name=p45933 lab=_85714_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -32880 0 0 {name=X_85714_ }
C {devices/lab_pin.sym} 46720 -32770 0 0 {name=p45934 lab=_70942_/A }
C {devices/lab_pin.sym} 46720 -32730 0 0 {name=p45935 lab=_70940_/B }
C {devices/lab_pin.sym} 46720 -32690 0 0 {name=p45936 lab=_70947_/C }
C {devices/lab_pin.sym} 46840 -32730 0 1 {name=p45937 lab=_70940_/Y }
C {sky130_stdcells/nand3_4.sym} 46780 -32730 0 0 {name=X_70940_ }
C {devices/lab_pin.sym} 46700 -32620 0 0 {name=p45938 lab=_58653_/Y }
C {devices/lab_pin.sym} 46700 -32580 0 0 {name=p45939 lab=_58624_/X }
C {devices/lab_pin.sym} 46700 -32540 0 0 {name=p45940 lab=_58658_/X }
C {devices/lab_pin.sym} 46700 -32500 0 0 {name=p45941 lab=_58661_/X }
C {devices/lab_pin.sym} 46860 -32560 0 1 {name=p45942 lab=_84810_/D }
C {sky130_stdcells/a22oi_4.sym} 46780 -32560 0 0 {name=X_58662_ }
C {devices/lab_pin.sym} 46690 -32410 0 0 {name=p45943 lab=_81198_/CLK }
C {devices/lab_pin.sym} 46690 -32390 0 0 {name=p45944 lab=_78218_/X }
C {devices/lab_pin.sym} 46870 -32410 0 1 {name=p45945 lab=_82926_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -32400 0 0 {name=X_82926_ }
C {devices/lab_pin.sym} 46720 -32280 0 0 {name=p45946 lab=_55843_/A }
C {devices/lab_pin.sym} 46720 -32240 0 0 {name=p45947 lab=_55874_/B }
C {devices/lab_pin.sym} 46840 -32260 0 1 {name=p45948 lab=_55874_/X }
C {sky130_stdcells/and2_4.sym} 46780 -32260 0 0 {name=X_55874_ }
C {devices/lab_pin.sym} 46690 -32130 0 0 {name=p45949 lab=_86695_/CLK }
C {devices/lab_pin.sym} 46690 -32110 0 0 {name=p45950 lab=_86694_/D }
C {devices/lab_pin.sym} 46870 -32130 0 1 {name=p45951 lab=_86694_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -32120 0 0 {name=X_86694_ }
C {devices/lab_pin.sym} 46720 -32000 0 0 {name=p45952 lab=_57608_/X }
C {devices/lab_pin.sym} 46720 -31960 0 0 {name=p45953 lab=_50356_/B }
C {devices/lab_pin.sym} 46840 -31980 0 1 {name=p45954 lab=_57613_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -31980 0 0 {name=X_57613_ }
C {devices/lab_pin.sym} 46720 -31880 0 0 {name=p45955 lab=_54825_/A }
C {devices/lab_pin.sym} 46720 -31840 0 0 {name=p45956 lab=_54843_/B }
C {devices/lab_pin.sym} 46720 -31800 0 0 {name=p45957 lab=_54831_/C }
C {devices/lab_pin.sym} 46720 -31760 0 0 {name=p45958 lab=_53133_/D }
C {devices/lab_pin.sym} 46840 -31820 0 1 {name=p45959 lab=_54825_/X }
C {sky130_stdcells/and4_4.sym} 46780 -31820 0 0 {name=X_54825_ }
C {devices/lab_pin.sym} 46690 -31670 0 0 {name=p45960 lab=_85645_/CLK }
C {devices/lab_pin.sym} 46690 -31650 0 0 {name=p45961 lab=_85645_/D }
C {devices/lab_pin.sym} 46870 -31670 0 1 {name=p45962 lab=_85645_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -31660 0 0 {name=X_85645_ }
C {devices/lab_pin.sym} 46720 -31560 0 0 {name=p45963 lab=_70871_/A }
C {devices/lab_pin.sym} 46720 -31520 0 0 {name=p45964 lab=_70869_/B }
C {devices/lab_pin.sym} 46720 -31480 0 0 {name=p45965 lab=_70869_/C }
C {devices/lab_pin.sym} 46720 -31440 0 0 {name=p45966 lab=_70869_/D }
C {devices/lab_pin.sym} 46840 -31500 0 1 {name=p45967 lab=_70871_/Y }
C {sky130_stdcells/nand4_4.sym} 46780 -31500 0 0 {name=X_70871_ }
C {devices/lab_pin.sym} 46700 -31370 0 0 {name=p45968 lab=_58591_/X }
C {devices/lab_pin.sym} 46700 -31330 0 0 {name=p45969 lab=_85471_/Q }
C {devices/lab_pin.sym} 46700 -31290 0 0 {name=p45970 lab=_58592_/X }
C {devices/lab_pin.sym} 46860 -31330 0 1 {name=p45971 lab=_58593_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -31330 0 0 {name=X_58593_ }
C {devices/lab_pin.sym} 46690 -31190 0 0 {name=p45972 lab=_82349_/CLK }
C {devices/lab_pin.sym} 46690 -31170 0 0 {name=p45973 lab=_78124_/B }
C {devices/lab_pin.sym} 46870 -31190 0 1 {name=p45974 lab=_82857_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -31180 0 0 {name=X_82857_ }
C {devices/lab_pin.sym} 46700 -31070 0 0 {name=p45975 lab=_72537_/B }
C {devices/lab_pin.sym} 46700 -31030 0 0 {name=p45976 lab=_72549_/B }
C {devices/lab_pin.sym} 46700 -30990 0 0 {name=p45977 lab=_61112_/X }
C {devices/lab_pin.sym} 46860 -31030 0 1 {name=p45978 lab=_72610_/X }
C {sky130_stdcells/a21bo_4.sym} 46780 -31030 0 0 {name=X_72610_ }
C {devices/lab_pin.sym} 46720 -30900 0 0 {name=p45979 lab=_57531_/A }
C {devices/lab_pin.sym} 46720 -30860 0 0 {name=p45980 lab=_53516_/B }
C {devices/lab_pin.sym} 46840 -30880 0 1 {name=p45981 lab=_57544_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -30880 0 0 {name=X_57544_ }
C {devices/lab_pin.sym} 46690 -30750 0 0 {name=p45982 lab=_81808_/CLK }
C {devices/lab_pin.sym} 46690 -30730 0 0 {name=p45983 lab=_81808_/D }
C {devices/lab_pin.sym} 46870 -30750 0 1 {name=p45984 lab=_81808_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -30740 0 0 {name=X_81808_ }
C {devices/lab_pin.sym} 46690 -30610 0 0 {name=p45985 lab=_88363_/CLK }
C {devices/lab_pin.sym} 46690 -30590 0 0 {name=p45986 lab=_88364_/D }
C {devices/lab_pin.sym} 46870 -30610 0 1 {name=p45987 lab=_88364_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -30600 0 0 {name=X_88364_ }
C {devices/lab_pin.sym} 46700 -30500 0 0 {name=p45988 lab=_41306_/X }
C {devices/lab_pin.sym} 46700 -30460 0 0 {name=p45989 lab=_42767_/X }
C {devices/lab_pin.sym} 46700 -30420 0 0 {name=p45990 lab=_67437_/B }
C {devices/lab_pin.sym} 46700 -30380 0 0 {name=p45991 lab=_42768_/X }
C {devices/lab_pin.sym} 46860 -30440 0 1 {name=p45992 lab=_42770_/X }
C {sky130_stdcells/a2bb2o_4.sym} 46780 -30440 0 0 {name=X_42770_ }
C {devices/lab_pin.sym} 46700 -30310 0 0 {name=p45993 lab=_54751_/Y }
C {devices/lab_pin.sym} 46700 -30270 0 0 {name=p45994 lab=_54747_/X }
C {devices/lab_pin.sym} 46700 -30230 0 0 {name=p45995 lab=_54755_/X }
C {devices/lab_pin.sym} 46860 -30270 0 1 {name=p45996 lab=_85384_/D }
C {sky130_stdcells/a21oi_4.sym} 46780 -30270 0 0 {name=X_54756_ }
C {devices/lab_pin.sym} 46720 -30140 0 0 {name=p45997 lab=_73590_/A }
C {devices/lab_pin.sym} 46720 -30100 0 0 {name=p45998 lab=_73589_/X }
C {devices/lab_pin.sym} 46840 -30120 0 1 {name=p45999 lab=_73591_/B }
C {sky130_stdcells/nand2_4.sym} 46780 -30120 0 0 {name=X_73590_ }
C {devices/lab_pin.sym} 46690 -29990 0 0 {name=p46000 lab=_86500_/CLK }
C {devices/lab_pin.sym} 46690 -29970 0 0 {name=p46001 lab=_53749_/Y }
C {devices/lab_pin.sym} 46870 -29990 0 1 {name=p46002 lab=_85576_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -29980 0 0 {name=X_85576_ }
C {devices/lab_pin.sym} 46720 -29860 0 0 {name=p46003 lab=_51941_/A }
C {devices/lab_pin.sym} 46720 -29820 0 0 {name=p46004 lab=_53488_/B }
C {devices/lab_pin.sym} 46840 -29840 0 1 {name=p46005 lab=_51968_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -29840 0 0 {name=X_51968_ }
C {devices/lab_pin.sym} 46690 -29710 0 0 {name=p46006 lab=_83238_/CLK }
C {devices/lab_pin.sym} 46690 -29690 0 0 {name=p46007 lab=_82820_/Q }
C {devices/lab_pin.sym} 46870 -29710 0 1 {name=p46008 lab=_78331_/B }
C {sky130_stdcells/dfxtp_4.sym} 46780 -29700 0 0 {name=X_82788_ }
C {devices/lab_pin.sym} 46740 -29570 0 0 {name=p46009 lab=clkbuf_9_504_0_CLK/X }
C {devices/lab_pin.sym} 46820 -29570 0 1 {name=p46010 lab=_83307_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 46780 -29570 0 0 {name=Xclkbuf_10_1009_0_CLK }
C {devices/lab_pin.sym} 46690 -29450 0 0 {name=p46011 lab=_83153_/CLK }
C {devices/lab_pin.sym} 46690 -29430 0 0 {name=p46012 lab=_43678_/X }
C {devices/lab_pin.sym} 46870 -29450 0 1 {name=p46013 lab=_87315_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -29440 0 0 {name=X_87315_ }
C {devices/lab_pin.sym} 46740 -29310 0 0 {name=p46014 lab=_41720_/Y }
C {devices/lab_pin.sym} 46820 -29310 0 1 {name=p46015 lab=_41721_/X }
C {sky130_stdcells/buf_2.sym} 46780 -29310 0 0 {name=X_41721_ }
C {devices/lab_pin.sym} 46720 -29200 0 0 {name=p46016 lab=_53778_/A }
C {devices/lab_pin.sym} 46720 -29160 0 0 {name=p46017 lab=_52188_/B }
C {devices/lab_pin.sym} 46840 -29180 0 1 {name=p46018 lab=_53707_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -29180 0 0 {name=X_53707_ }
C {devices/lab_pin.sym} 46740 -29050 0 0 {name=p46019 lab=_72540_/Y }
C {devices/lab_pin.sym} 46820 -29050 0 1 {name=p46020 lab=_72579_/B }
C {sky130_stdcells/inv_2.sym} 46780 -29050 0 0 {name=X_72541_ }
C {devices/lab_pin.sym} 46690 -28930 0 0 {name=p46021 lab=_84287_/CLK }
C {devices/lab_pin.sym} 46690 -28910 0 0 {name=p46022 lab=_84527_/D }
C {devices/lab_pin.sym} 46870 -28930 0 1 {name=p46023 lab=_76975_/A }
C {sky130_stdcells/dfxtp_4.sym} 46780 -28920 0 0 {name=X_84527_ }
C {devices/lab_pin.sym} 46720 -28820 0 0 {name=p46024 lab=_50941_/A }
C {devices/lab_pin.sym} 46720 -28780 0 0 {name=p46025 lab=_50919_/B }
C {devices/lab_pin.sym} 46720 -28740 0 0 {name=p46026 lab=_50897_/X }
C {devices/lab_pin.sym} 46720 -28700 0 0 {name=p46027 lab=_50919_/D }
C {devices/lab_pin.sym} 46840 -28760 0 1 {name=p46028 lab=_50919_/X }
C {sky130_stdcells/and4_4.sym} 46780 -28760 0 0 {name=X_50919_ }
C {devices/lab_pin.sym} 46740 -28610 0 0 {name=p46029 lab=_56649_/X }
C {devices/lab_pin.sym} 46820 -28610 0 1 {name=p46030 lab=_74139_/A }
C {sky130_stdcells/buf_2.sym} 46780 -28610 0 0 {name=X_57475_ }
C {devices/lab_pin.sym} 46690 -28490 0 0 {name=p46031 lab=_81783_/CLK }
C {devices/lab_pin.sym} 46690 -28470 0 0 {name=p46032 lab=_81739_/D }
C {devices/lab_pin.sym} 46870 -28490 0 1 {name=p46033 lab=_41743_/B }
C {sky130_stdcells/dfxtp_4.sym} 46780 -28480 0 0 {name=X_81739_ }
C {devices/lab_pin.sym} 46690 -28350 0 0 {name=p46034 lab=_87790_/CLK }
C {devices/lab_pin.sym} 46690 -28330 0 0 {name=p46035 lab=_41006_/Y }
C {devices/lab_pin.sym} 46870 -28350 0 1 {name=p46036 lab=_88295_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -28340 0 0 {name=X_88295_ }
C {devices/lab_pin.sym} 46720 -28220 0 0 {name=p46037 lab=_54682_/A }
C {devices/lab_pin.sym} 46720 -28180 0 0 {name=p46038 lab=_47344_/A }
C {devices/lab_pin.sym} 46840 -28200 0 1 {name=p46039 lab=_54687_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -28200 0 0 {name=X_54687_ }
C {devices/lab_pin.sym} 46700 -28090 0 0 {name=p46040 lab=_51896_/Y }
C {devices/lab_pin.sym} 46700 -28050 0 0 {name=p46041 lab=_51877_/X }
C {devices/lab_pin.sym} 46700 -28010 0 0 {name=p46042 lab=_51898_/X }
C {devices/lab_pin.sym} 46860 -28050 0 1 {name=p46043 lab=_51899_/Y }
C {sky130_stdcells/a21oi_4.sym} 46780 -28050 0 0 {name=X_51899_ }
C {devices/lab_pin.sym} 46700 -27950 0 0 {name=p46044 lab=_59152_/X }
C {devices/lab_pin.sym} 46700 -27910 0 0 {name=p46045 lab=_59212_/Y }
C {devices/lab_pin.sym} 46700 -27870 0 0 {name=p46046 lab=_59213_/Y }
C {devices/lab_pin.sym} 46700 -27830 0 0 {name=p46047 lab=_59169_/X }
C {devices/lab_pin.sym} 46700 -27790 0 0 {name=p46048 lab=_59156_/X }
C {devices/lab_pin.sym} 46860 -27870 0 1 {name=p46049 lab=_59214_/X }
C {sky130_stdcells/o32a_4.sym} 46780 -27870 0 0 {name=X_59214_ }
C {devices/lab_pin.sym} 46740 -27710 0 0 {name=p46050 lab=_56439_/A }
C {devices/lab_pin.sym} 46820 -27710 0 1 {name=p46051 lab=_56426_/X }
C {sky130_stdcells/buf_2.sym} 46780 -27710 0 0 {name=X_56426_ }
C {devices/lab_pin.sym} 46740 -27590 0 0 {name=p46052 lab=_44439_/Y }
C {devices/lab_pin.sym} 46820 -27590 0 1 {name=p46053 lab=_87107_/D }
C {sky130_stdcells/inv_2.sym} 46780 -27590 0 0 {name=X_44440_ }
C {devices/lab_pin.sym} 46720 -27480 0 0 {name=p46054 lab=_75258_/X }
C {devices/lab_pin.sym} 46720 -27440 0 0 {name=p46055 lab=_75259_/Y }
C {devices/lab_pin.sym} 46840 -27460 0 1 {name=p46056 lab=_75261_/B }
C {sky130_stdcells/and2_4.sym} 46780 -27460 0 0 {name=X_75260_ }
C {devices/lab_pin.sym} 46690 -27330 0 0 {name=p46057 lab=_87249_/CLK }
C {devices/lab_pin.sym} 46690 -27310 0 0 {name=p46058 lab=_43830_/Y }
C {devices/lab_pin.sym} 46870 -27330 0 1 {name=p46059 lab=_87246_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -27320 0 0 {name=X_87246_ }
C {devices/lab_pin.sym} 46720 -27200 0 0 {name=p46060 lab=_53611_/X }
C {devices/lab_pin.sym} 46720 -27160 0 0 {name=p46061 lab=_74383_/B }
C {devices/lab_pin.sym} 46840 -27180 0 1 {name=p46062 lab=_53638_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -27180 0 0 {name=X_53638_ }
C {devices/lab_pin.sym} 46700 -27080 0 0 {name=p46063 lab=_41651_/X }
C {devices/lab_pin.sym} 46700 -27040 0 0 {name=p46064 lab=_41638_/X }
C {devices/lab_pin.sym} 46700 -27000 0 0 {name=p46065 lab=_67434_/B }
C {devices/lab_pin.sym} 46700 -26960 0 0 {name=p46066 lab=_41639_/X }
C {devices/lab_pin.sym} 46860 -27020 0 1 {name=p46067 lab=_88175_/D }
C {sky130_stdcells/a2bb2o_4.sym} 46780 -27020 0 0 {name=X_41652_ }
C {devices/lab_pin.sym} 46720 -26880 0 0 {name=p46068 lab=_86595_/Q }
C {devices/lab_pin.sym} 46720 -26840 0 0 {name=p46069 lab=_72401_/B }
C {devices/lab_pin.sym} 46840 -26860 0 1 {name=p46070 lab=_72472_/Y }
C {sky130_stdcells/nor2_4.sym} 46780 -26860 0 0 {name=X_72472_ }
C {devices/lab_pin.sym} 46690 -26730 0 0 {name=p46071 lab=_84458_/CLK }
C {devices/lab_pin.sym} 46690 -26710 0 0 {name=p46072 lab=_61701_/Y }
C {devices/lab_pin.sym} 46870 -26730 0 1 {name=p46073 lab=_84458_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -26720 0 0 {name=X_84458_ }
C {devices/lab_pin.sym} 46720 -26600 0 0 {name=p46074 lab=_74208_/X }
C {devices/lab_pin.sym} 46720 -26560 0 0 {name=p46075 lab=_74210_/Y }
C {devices/lab_pin.sym} 46840 -26580 0 1 {name=p46076 lab=_74211_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -26580 0 0 {name=X_74211_ }
C {devices/lab_pin.sym} 46720 -26460 0 0 {name=p46077 lab=_47943_/A }
C {devices/lab_pin.sym} 46720 -26420 0 0 {name=p46078 lab=_82877_/Q }
C {devices/lab_pin.sym} 46840 -26440 0 1 {name=p46079 lab=_40603_/X }
C {sky130_stdcells/or2_4.sym} 46780 -26440 0 0 {name=X_40603_ }
C {devices/lab_pin.sym} 46740 -26310 0 0 {name=p46080 lab=_72358_/A }
C {devices/lab_pin.sym} 46820 -26310 0 1 {name=p46081 lab=_59145_/X }
C {sky130_stdcells/buf_2.sym} 46780 -26310 0 0 {name=X_59145_ }
C {devices/lab_pin.sym} 46700 -26210 0 0 {name=p46082 lab=_71420_/X }
C {devices/lab_pin.sym} 46700 -26170 0 0 {name=p46083 lab=_83505_/Q }
C {devices/lab_pin.sym} 46700 -26130 0 0 {name=p46084 lab=_71422_/X }
C {devices/lab_pin.sym} 46860 -26170 0 1 {name=p46085 lab=_83505_/D }
C {sky130_stdcells/a21o_4.sym} 46780 -26170 0 0 {name=X_71423_ }
C {devices/lab_pin.sym} 46690 -26030 0 0 {name=p46086 lab=_83338_/CLK }
C {devices/lab_pin.sym} 46690 -26010 0 0 {name=p46087 lab=_83409_/D }
C {devices/lab_pin.sym} 46870 -26030 0 1 {name=p46088 lab=_83409_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -26020 0 0 {name=X_83409_ }
C {devices/lab_pin.sym} 46700 -25930 0 0 {name=p46089 lab=_44350_/X }
C {devices/lab_pin.sym} 46700 -25890 0 0 {name=p46090 lab=_44351_/X }
C {devices/lab_pin.sym} 46700 -25850 0 0 {name=p46091 lab=_41762_/X }
C {devices/lab_pin.sym} 46700 -25810 0 0 {name=p46092 lab=_87142_/Q }
C {devices/lab_pin.sym} 46700 -25770 0 0 {name=p46093 lab=_44353_/X }
C {devices/lab_pin.sym} 46860 -25850 0 1 {name=p46094 lab=_44372_/A }
C {sky130_stdcells/o32ai_4.sym} 46780 -25850 0 0 {name=X_44371_ }
C {devices/lab_pin.sym} 46700 -25710 0 0 {name=p46095 lab=_56148_/X }
C {devices/lab_pin.sym} 46700 -25670 0 0 {name=p46096 lab=_56350_/X }
C {devices/lab_pin.sym} 46700 -25630 0 0 {name=p46097 lab=_56356_/Y }
C {devices/lab_pin.sym} 46860 -25670 0 1 {name=p46098 lab=_85223_/D }
C {sky130_stdcells/o21ai_4.sym} 46780 -25670 0 0 {name=X_56357_ }
C {devices/lab_pin.sym} 46720 -25540 0 0 {name=p46099 lab=_75189_/X }
C {devices/lab_pin.sym} 46720 -25500 0 0 {name=p46100 lab=_75190_/Y }
C {devices/lab_pin.sym} 46840 -25520 0 1 {name=p46101 lab=_75217_/A }
C {sky130_stdcells/nand2_4.sym} 46780 -25520 0 0 {name=X_75191_ }
C {devices/lab_pin.sym} 46700 -25420 0 0 {name=p46102 lab=_41580_/X }
C {devices/lab_pin.sym} 46700 -25380 0 0 {name=p46103 lab=_41581_/X }
C {devices/lab_pin.sym} 46700 -25340 0 0 {name=p46104 lab=_67128_/B }
C {devices/lab_pin.sym} 46700 -25300 0 0 {name=p46105 lab=_41582_/X }
C {devices/lab_pin.sym} 46860 -25360 0 1 {name=p46106 lab=_88188_/D }
C {sky130_stdcells/a2bb2o_4.sym} 46780 -25360 0 0 {name=X_41583_ }
C {devices/lab_pin.sym} 46690 -25210 0 0 {name=p46107 lab=_87174_/CLK }
C {devices/lab_pin.sym} 46690 -25190 0 0 {name=p46108 lab=_87177_/D }
C {devices/lab_pin.sym} 46870 -25210 0 1 {name=p46109 lab=_43971_/A }
C {sky130_stdcells/dfxtp_4.sym} 46780 -25200 0 0 {name=X_87177_ }
C {devices/lab_pin.sym} 46740 -25070 0 0 {name=p46110 lab=_53671_/A }
C {devices/lab_pin.sym} 46820 -25070 0 1 {name=p46111 lab=_53620_/C }
C {sky130_stdcells/buf_2.sym} 46780 -25070 0 0 {name=X_53569_ }
C {devices/lab_pin.sym} 46690 -24950 0 0 {name=p46112 lab=_84555_/CLK }
C {devices/lab_pin.sym} 46690 -24930 0 0 {name=p46113 lab=_62707_/Y }
C {devices/lab_pin.sym} 46870 -24950 0 1 {name=p46114 lab=_84389_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -24940 0 0 {name=X_84389_ }
C {devices/lab_pin.sym} 46740 -24810 0 0 {name=p46115 lab=_46092_/X }
C {devices/lab_pin.sym} 46820 -24810 0 1 {name=p46116 lab=_46162_/B }
C {sky130_stdcells/inv_2.sym} 46780 -24810 0 0 {name=X_46110_ }
C {devices/lab_pin.sym} 46700 -24720 0 0 {name=p46117 lab=_41250_/X }
C {devices/lab_pin.sym} 46700 -24680 0 0 {name=p46118 lab=_43300_/X }
C {devices/lab_pin.sym} 46700 -24640 0 0 {name=p46119 lab=_87482_/Q }
C {devices/lab_pin.sym} 46700 -24600 0 0 {name=p46120 lab=_43302_/X }
C {devices/lab_pin.sym} 46860 -24660 0 1 {name=p46121 lab=_87482_/D }
C {sky130_stdcells/a2bb2o_4.sym} 46780 -24660 0 0 {name=X_43322_ }
C {devices/lab_pin.sym} 46700 -24540 0 0 {name=p46122 lab=_45673_/A }
C {devices/lab_pin.sym} 46700 -24500 0 0 {name=p46123 lab=_55305_/X }
C {devices/lab_pin.sym} 46700 -24460 0 0 {name=p46124 lab=_44045_/X }
C {devices/lab_pin.sym} 46700 -24420 0 0 {name=p46125 lab=_55307_/Y }
C {devices/lab_pin.sym} 46860 -24480 0 1 {name=p46126 lab=_55308_/X }
C {sky130_stdcells/a211o_4.sym} 46780 -24480 0 0 {name=X_55308_ }
C {devices/lab_pin.sym} 46700 -24350 0 0 {name=p46127 lab=_88346_/Q }
C {devices/lab_pin.sym} 46700 -24310 0 0 {name=p46128 lab=_73633_/X }
C {devices/lab_pin.sym} 46700 -24270 0 0 {name=p46129 lab=_73028_/X }
C {devices/lab_pin.sym} 46860 -24310 0 1 {name=p46130 lab=_74142_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -24310 0 0 {name=X_74142_ }
C {devices/lab_pin.sym} 46690 -24170 0 0 {name=p46131 lab=_86139_/CLK }
C {devices/lab_pin.sym} 46690 -24150 0 0 {name=p46132 lab=_50813_/Y }
C {devices/lab_pin.sym} 46870 -24170 0 1 {name=p46133 lab=_86128_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -24160 0 0 {name=X_86128_ }
C {devices/lab_pin.sym} 46740 -24030 0 0 {name=p46134 lab=_40534_/A }
C {devices/lab_pin.sym} 46820 -24030 0 1 {name=p46135 lab=_88375_/D }
C {sky130_stdcells/inv_2.sym} 46780 -24030 0 0 {name=X_40534_ }
C {devices/lab_pin.sym} 46700 -23930 0 0 {name=p46136 lab=_59072_/Y }
C {devices/lab_pin.sym} 46700 -23890 0 0 {name=p46137 lab=_59075_/Y }
C {devices/lab_pin.sym} 46700 -23850 0 0 {name=p46138 lab=_59053_/X }
C {devices/lab_pin.sym} 46860 -23890 0 1 {name=p46139 lab=_59076_/X }
C {sky130_stdcells/a21o_4.sym} 46780 -23890 0 0 {name=X_59076_ }
C {devices/lab_pin.sym} 46700 -23770 0 0 {name=p46140 lab=_59226_/A }
C {devices/lab_pin.sym} 46700 -23730 0 0 {name=p46141 lab=_47050_/X }
C {devices/lab_pin.sym} 46700 -23690 0 0 {name=p46142 lab=_47089_/Y }
C {devices/lab_pin.sym} 46860 -23730 0 1 {name=p46143 lab=_47090_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -23730 0 0 {name=X_47090_ }
C {devices/lab_pin.sym} 46720 -23620 0 0 {name=p46144 lab=_71504_/C }
C {devices/lab_pin.sym} 46720 -23580 0 0 {name=p46145 lab=_71351_/X }
C {devices/lab_pin.sym} 46720 -23540 0 0 {name=p46146 lab=_71424_/C }
C {devices/lab_pin.sym} 46720 -23500 0 0 {name=p46147 lab=_71363_/D }
C {devices/lab_pin.sym} 46840 -23560 0 1 {name=p46148 lab=_71354_/X }
C {sky130_stdcells/and4_4.sym} 46780 -23560 0 0 {name=X_71354_ }
C {devices/lab_pin.sym} 46700 -23430 0 0 {name=p46149 lab=_56284_/X }
C {devices/lab_pin.sym} 46700 -23390 0 0 {name=p46150 lab=_55987_/X }
C {devices/lab_pin.sym} 46700 -23350 0 0 {name=p46151 lab=_56287_/Y }
C {devices/lab_pin.sym} 46860 -23390 0 1 {name=p46152 lab=_85249_/D }
C {sky130_stdcells/o21ai_4.sym} 46780 -23390 0 0 {name=X_56288_ }
C {devices/lab_pin.sym} 46720 -23260 0 0 {name=p46153 lab=_86635_/Q }
C {devices/lab_pin.sym} 46720 -23220 0 0 {name=p46154 lab=_58039_/B }
C {devices/lab_pin.sym} 46840 -23240 0 1 {name=p46155 lab=_58027_/Y }
C {sky130_stdcells/nor2_4.sym} 46780 -23240 0 0 {name=X_58027_ }
C {devices/lab_pin.sym} 46700 -23130 0 0 {name=p46156 lab=_70303_/X }
C {devices/lab_pin.sym} 46700 -23090 0 0 {name=p46157 lab=_83804_/Q }
C {devices/lab_pin.sym} 46700 -23050 0 0 {name=p46158 lab=_70304_/X }
C {devices/lab_pin.sym} 46860 -23090 0 1 {name=p46159 lab=_83804_/D }
C {sky130_stdcells/a21o_4.sym} 46780 -23090 0 0 {name=X_70305_ }
C {devices/lab_pin.sym} 46700 -22980 0 0 {name=p46160 lab=_41502_/Y }
C {devices/lab_pin.sym} 46700 -22940 0 0 {name=p46161 lab=_46029_/X }
C {devices/lab_pin.sym} 46700 -22900 0 0 {name=p46162 lab=_66765_/B }
C {devices/lab_pin.sym} 46700 -22860 0 0 {name=p46163 lab=_46030_/X }
C {devices/lab_pin.sym} 46860 -22920 0 1 {name=p46164 lab=_86798_/D }
C {sky130_stdcells/a2bb2o_4.sym} 46780 -22920 0 0 {name=X_46041_ }
C {devices/lab_pin.sym} 46700 -22800 0 0 {name=p46165 lab=_41059_/X }
C {devices/lab_pin.sym} 46700 -22760 0 0 {name=p46166 lab=_43247_/X }
C {devices/lab_pin.sym} 46700 -22720 0 0 {name=p46167 lab=_87517_/Q }
C {devices/lab_pin.sym} 46700 -22680 0 0 {name=p46168 lab=_43248_/X }
C {devices/lab_pin.sym} 46860 -22740 0 1 {name=p46169 lab=_87517_/D }
C {sky130_stdcells/a2bb2o_4.sym} 46780 -22740 0 0 {name=X_43253_ }
C {devices/lab_pin.sym} 46740 -22590 0 0 {name=p46170 lab=_55243_/B }
C {devices/lab_pin.sym} 46820 -22590 0 1 {name=p46171 lab=_55240_/B }
C {sky130_stdcells/inv_2.sym} 46780 -22590 0 0 {name=X_55239_ }
C {devices/lab_pin.sym} 46720 -22480 0 0 {name=p46172 lab=_78948_/Y }
C {devices/lab_pin.sym} 46720 -22440 0 0 {name=p46173 lab=_79115_/A }
C {devices/lab_pin.sym} 46840 -22460 0 1 {name=p46174 lab=_78957_/A }
C {sky130_stdcells/xor2_4.sym} 46780 -22460 0 0 {name=X_78950_ }
C {devices/lab_pin.sym} 46690 -22330 0 0 {name=p46175 lab=_85741_/CLK }
C {devices/lab_pin.sym} 46690 -22310 0 0 {name=p46176 lab=_51182_/Y }
C {devices/lab_pin.sym} 46870 -22330 0 1 {name=p46177 lab=_86059_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -22320 0 0 {name=X_86059_ }
C {devices/lab_pin.sym} 46740 -22190 0 0 {name=p46178 lab=_72978_/A }
C {devices/lab_pin.sym} 46820 -22190 0 1 {name=p46179 lab=_74073_/X }
C {sky130_stdcells/buf_2.sym} 46780 -22190 0 0 {name=X_74073_ }
C {devices/lab_pin.sym} 46740 -22070 0 0 {name=p46180 lab=_40784_/A }
C {devices/lab_pin.sym} 46820 -22070 0 1 {name=p46181 lab=_40932_/A }
C {sky130_stdcells/buf_2.sym} 46780 -22070 0 0 {name=X_40465_ }
C {devices/lab_pin.sym} 46720 -21980 0 0 {name=p46182 lab=_71041_/X }
C {devices/lab_pin.sym} 46720 -21940 0 0 {name=p46183 lab=_71268_/A }
C {devices/lab_pin.sym} 46720 -21900 0 0 {name=p46184 lab=_71279_/C }
C {devices/lab_pin.sym} 46720 -21860 0 0 {name=p46185 lab=_70638_/A }
C {devices/lab_pin.sym} 46840 -21920 0 1 {name=p46186 lab=_71285_/Y }
C {sky130_stdcells/nand4_4.sym} 46780 -21920 0 0 {name=X_71285_ }
C {devices/lab_pin.sym} 46740 -21770 0 0 {name=p46187 lab=_43161_/A }
C {devices/lab_pin.sym} 46820 -21770 0 1 {name=p46188 lab=_42204_/X }
C {sky130_stdcells/buf_2.sym} 46780 -21770 0 0 {name=X_42204_ }
C {devices/lab_pin.sym} 46720 -21660 0 0 {name=p46189 lab=_77899_/Y }
C {devices/lab_pin.sym} 46720 -21620 0 0 {name=p46190 lab=_77900_/Y }
C {devices/lab_pin.sym} 46840 -21640 0 1 {name=p46191 lab=_77904_/A }
C {sky130_stdcells/xor2_4.sym} 46780 -21640 0 0 {name=X_77901_ }
C {devices/lab_pin.sym} 46720 -21520 0 0 {name=p46192 lab=_73024_/A }
C {devices/lab_pin.sym} 46720 -21480 0 0 {name=p46193 lab=_73024_/B }
C {devices/lab_pin.sym} 46840 -21500 0 1 {name=p46194 lab=_73024_/Y }
C {sky130_stdcells/nor2_4.sym} 46780 -21500 0 0 {name=X_73024_ }
C {devices/lab_pin.sym} 46720 -21400 0 0 {name=p46195 lab=_70239_/A }
C {devices/lab_pin.sym} 46720 -21360 0 0 {name=p46196 lab=_70239_/B }
C {devices/lab_pin.sym} 46720 -21320 0 0 {name=p46197 lab=_70236_/C }
C {devices/lab_pin.sym} 46720 -21280 0 0 {name=p46198 lab=_70239_/D }
C {devices/lab_pin.sym} 46840 -21340 0 1 {name=p46199 lab=_70236_/X }
C {sky130_stdcells/and4_4.sym} 46780 -21340 0 0 {name=X_70236_ }
C {devices/lab_pin.sym} 46740 -21190 0 0 {name=p46200 lab=_43217_/A }
C {devices/lab_pin.sym} 46820 -21190 0 1 {name=p46201 lab=_43185_/A }
C {sky130_stdcells/buf_2.sym} 46780 -21190 0 0 {name=X_43184_ }
C {devices/lab_pin.sym} 46720 -21080 0 0 {name=p46202 lab=_78881_/A }
C {devices/lab_pin.sym} 46720 -21040 0 0 {name=p46203 lab=_78880_/Y }
C {devices/lab_pin.sym} 46840 -21060 0 1 {name=p46204 lab=_78882_/B }
C {sky130_stdcells/xor2_4.sym} 46780 -21060 0 0 {name=X_78881_ }
C {devices/lab_pin.sym} 46700 -20970 0 0 {name=p46205 lab=_57491_/A }
C {devices/lab_pin.sym} 46700 -20930 0 0 {name=p46206 lab=_40364_/X }
C {devices/lab_pin.sym} 46700 -20890 0 0 {name=p46207 lab=_40395_/X }
C {devices/lab_pin.sym} 46700 -20850 0 0 {name=p46208 lab=_88398_/Q }
C {devices/lab_pin.sym} 46700 -20810 0 0 {name=p46209 lab=_40375_/X }
C {devices/lab_pin.sym} 46860 -20890 0 1 {name=p46210 lab=_40396_/Y }
C {sky130_stdcells/o32ai_4.sym} 46780 -20890 0 0 {name=X_40396_ }
C {devices/lab_pin.sym} 46720 -20740 0 0 {name=p46211 lab=_49809_/A }
C {devices/lab_pin.sym} 46720 -20700 0 0 {name=p46212 lab=_53012_/B }
C {devices/lab_pin.sym} 46840 -20720 0 1 {name=p46213 lab=_49800_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -20720 0 0 {name=X_49800_ }
C {devices/lab_pin.sym} 46740 -20590 0 0 {name=p46214 lab=_42134_/Y }
C {devices/lab_pin.sym} 46820 -20590 0 1 {name=p46215 lab=_42135_/Y }
C {sky130_stdcells/inv_2.sym} 46780 -20590 0 0 {name=X_42135_ }
C {devices/lab_pin.sym} 46740 -20470 0 0 {name=p46216 lab=_77832_/A }
C {devices/lab_pin.sym} 46820 -20470 0 1 {name=p46217 lab=_77847_/A }
C {sky130_stdcells/inv_2.sym} 46780 -20470 0 0 {name=X_77832_ }
C {devices/lab_pin.sym} 46740 -20350 0 0 {name=p46218 lab=clkbuf_9_330_0_CLK/X }
C {devices/lab_pin.sym} 46820 -20350 0 1 {name=p46219 lab=_82888_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 46780 -20350 0 0 {name=Xclkbuf_10_661_0_CLK }
C {devices/lab_pin.sym} 46740 -20230 0 0 {name=p46220 lab=_70157_/A }
C {devices/lab_pin.sym} 46820 -20230 0 1 {name=p46221 lab=_70337_/A }
C {sky130_stdcells/inv_2.sym} 46780 -20230 0 0 {name=X_70167_ }
C {devices/lab_pin.sym} 46700 -20130 0 0 {name=p46222 lab=_46493_/X }
C {devices/lab_pin.sym} 46700 -20090 0 0 {name=p46223 lab=_82354_/Q }
C {devices/lab_pin.sym} 46700 -20050 0 0 {name=p46224 lab=_47991_/Y }
C {devices/lab_pin.sym} 46860 -20090 0 1 {name=p46225 lab=_57567_/A }
C {sky130_stdcells/o21ai_4.sym} 46780 -20090 0 0 {name=X_47992_ }
C {devices/lab_pin.sym} 46720 -19960 0 0 {name=p46226 lab=_59974_/Y }
C {devices/lab_pin.sym} 46720 -19920 0 0 {name=p46227 lab=_59977_/Y }
C {devices/lab_pin.sym} 46840 -19940 0 1 {name=p46228 lab=_59978_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -19940 0 0 {name=X_59978_ }
C {devices/lab_pin.sym} 46700 -19830 0 0 {name=p46229 lab=_86333_/Q }
C {devices/lab_pin.sym} 46700 -19790 0 0 {name=p46230 lab=_49715_/X }
C {devices/lab_pin.sym} 46700 -19750 0 0 {name=p46231 lab=_49730_/Y }
C {devices/lab_pin.sym} 46860 -19790 0 1 {name=p46232 lab=_49731_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -19790 0 0 {name=X_49731_ }
C {devices/lab_pin.sym} 46740 -19650 0 0 {name=p46233 lab=_46942_/Y }
C {devices/lab_pin.sym} 46820 -19650 0 1 {name=p46234 lab=_52763_/D }
C {sky130_stdcells/buf_2.sym} 46780 -19650 0 0 {name=X_46943_ }
C {devices/lab_pin.sym} 46700 -19560 0 0 {name=p46235 lab=_40939_/X }
C {devices/lab_pin.sym} 46700 -19520 0 0 {name=p46236 lab=_41907_/X }
C {devices/lab_pin.sym} 46700 -19480 0 0 {name=p46237 lab=_88050_/Q }
C {devices/lab_pin.sym} 46700 -19440 0 0 {name=p46238 lab=_41912_/X }
C {devices/lab_pin.sym} 46860 -19500 0 1 {name=p46239 lab=_88050_/D }
C {sky130_stdcells/a2bb2o_4.sym} 46780 -19500 0 0 {name=X_42066_ }
C {devices/lab_pin.sym} 46700 -19370 0 0 {name=p46240 lab=_58904_/X }
C {devices/lab_pin.sym} 46700 -19330 0 0 {name=p46241 lab=_85765_/Q }
C {devices/lab_pin.sym} 46700 -19290 0 0 {name=p46242 lab=_58928_/X }
C {devices/lab_pin.sym} 46860 -19330 0 1 {name=p46243 lab=_58929_/X }
C {sky130_stdcells/o21a_4.sym} 46780 -19330 0 0 {name=X_58929_ }
C {devices/lab_pin.sym} 46740 -19190 0 0 {name=p46244 lab=clkbuf_8_76_0_CLK/X }
C {devices/lab_pin.sym} 46820 -19190 0 1 {name=p46245 lab=clkbuf_9_152_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 46780 -19190 0 0 {name=Xclkbuf_9_152_0_CLK }
C {devices/lab_pin.sym} 46720 -19080 0 0 {name=p46246 lab=_77771_/B }
C {devices/lab_pin.sym} 46720 -19040 0 0 {name=p46247 lab=_81926_/D }
C {devices/lab_pin.sym} 46840 -19060 0 1 {name=p46248 lab=_77763_/Y }
C {sky130_stdcells/xnor2_4.sym} 46780 -19060 0 0 {name=X_77763_ }
C {devices/lab_pin.sym} 46700 -18950 0 0 {name=p46249 lab=_74966_/Y }
C {devices/lab_pin.sym} 46700 -18910 0 0 {name=p46250 lab=_74973_/Y }
C {devices/lab_pin.sym} 46700 -18870 0 0 {name=p46251 lab=_74974_/Y }
C {devices/lab_pin.sym} 46860 -18910 0 1 {name=p46252 lab=_74975_/X }
C {sky130_stdcells/o21a_4.sym} 46780 -18910 0 0 {name=X_74975_ }
C {devices/lab_pin.sym} 46740 -18770 0 0 {name=p46253 lab=_83135_/Q }
C {devices/lab_pin.sym} 46820 -18770 0 1 {name=p46254 lab=_70102_/A }
C {sky130_stdcells/inv_2.sym} 46780 -18770 0 0 {name=X_70098_ }
C {devices/lab_pin.sym} 46720 -18660 0 0 {name=p46255 lab=_79502_/A }
C {devices/lab_pin.sym} 46720 -18620 0 0 {name=p46256 lab=_79502_/B }
C {devices/lab_pin.sym} 46840 -18640 0 1 {name=p46257 lab=_79503_/B }
C {sky130_stdcells/xor2_4.sym} 46780 -18640 0 0 {name=X_79502_ }
C {devices/lab_pin.sym} 46700 -18550 0 0 {name=p46258 lab=_40999_/X }
C {devices/lab_pin.sym} 46700 -18510 0 0 {name=p46259 lab=_41000_/X }
C {devices/lab_pin.sym} 46700 -18470 0 0 {name=p46260 lab=_41016_/X }
C {devices/lab_pin.sym} 46700 -18430 0 0 {name=p46261 lab=_88293_/Q }
C {devices/lab_pin.sym} 46700 -18390 0 0 {name=p46262 lab=_40995_/X }
C {devices/lab_pin.sym} 46860 -18470 0 1 {name=p46263 lab=_41018_/A }
C {sky130_stdcells/o32ai_4.sym} 46780 -18470 0 0 {name=X_41017_ }
C {devices/lab_pin.sym} 46740 -18310 0 0 {name=p46264 lab=_76714_/A }
C {devices/lab_pin.sym} 46820 -18310 0 1 {name=p46265 lab=_76714_/Y }
C {sky130_stdcells/inv_2.sym} 46780 -18310 0 0 {name=X_76714_ }
C {devices/lab_pin.sym} 46720 -18200 0 0 {name=p46266 lab=_49661_/X }
C {devices/lab_pin.sym} 46720 -18160 0 0 {name=p46267 lab=_52876_/B }
C {devices/lab_pin.sym} 46840 -18180 0 1 {name=p46268 lab=_49662_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -18180 0 0 {name=X_49662_ }
C {devices/lab_pin.sym} 46720 -18080 0 0 {name=p46269 lab=_61939_/X }
C {devices/lab_pin.sym} 46720 -18040 0 0 {name=p46270 lab=_61924_/B }
C {devices/lab_pin.sym} 46720 -18000 0 0 {name=p46271 lab=_61878_/C }
C {devices/lab_pin.sym} 46720 -17960 0 0 {name=p46272 lab=_61910_/D }
C {devices/lab_pin.sym} 46840 -18020 0 1 {name=p46273 lab=_61940_/Y }
C {sky130_stdcells/nand4_4.sym} 46780 -18020 0 0 {name=X_61940_ }
C {devices/lab_pin.sym} 46700 -17900 0 0 {name=p46274 lab=_72894_/X }
C {devices/lab_pin.sym} 46700 -17860 0 0 {name=p46275 lab=_86226_/Q }
C {devices/lab_pin.sym} 46700 -17820 0 0 {name=p46276 lab=_45896_/X }
C {devices/lab_pin.sym} 46700 -17780 0 0 {name=p46277 lab=_73925_/X }
C {devices/lab_pin.sym} 46860 -17840 0 1 {name=p46278 lab=_73926_/X }
C {sky130_stdcells/a211o_4.sym} 46780 -17840 0 0 {name=X_73926_ }
C {devices/lab_pin.sym} 46740 -17690 0 0 {name=p46279 lab=_82950_/Q }
C {devices/lab_pin.sym} 46820 -17690 0 1 {name=p46280 lab=_54417_/D }
C {sky130_stdcells/inv_2.sym} 46780 -17690 0 0 {name=X_46874_ }
C {devices/lab_pin.sym} 46740 -17570 0 0 {name=p46281 lab=_77694_/A }
C {devices/lab_pin.sym} 46820 -17570 0 1 {name=p46282 lab=_77695_/A }
C {sky130_stdcells/inv_2.sym} 46780 -17570 0 0 {name=X_77694_ }
C {devices/lab_pin.sym} 46740 -17450 0 0 {name=p46283 lab=_48613_/A }
C {devices/lab_pin.sym} 46820 -17450 0 1 {name=p46284 lab=_48661_/A }
C {sky130_stdcells/buf_2.sym} 46780 -17450 0 0 {name=X_48613_ }
C {devices/lab_pin.sym} 46740 -17330 0 0 {name=p46285 lab=clkbuf_9_338_0_CLK/X }
C {devices/lab_pin.sym} 46820 -17330 0 1 {name=p46286 lab=_87144_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 46780 -17330 0 0 {name=Xclkbuf_10_676_0_CLK }
C {devices/lab_pin.sym} 46720 -17220 0 0 {name=p46287 lab=_79433_/A }
C {devices/lab_pin.sym} 46720 -17180 0 0 {name=p46288 lab=_79433_/B }
C {devices/lab_pin.sym} 46840 -17200 0 1 {name=p46289 lab=_79433_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -17200 0 0 {name=X_79433_ }
C {devices/lab_pin.sym} 46700 -17100 0 0 {name=p46290 lab=_45823_/Y }
C {devices/lab_pin.sym} 46700 -17060 0 0 {name=p46291 lab=_45394_/X }
C {devices/lab_pin.sym} 46700 -17020 0 0 {name=p46292 lab=_45571_/X }
C {devices/lab_pin.sym} 46700 -16980 0 0 {name=p46293 lab=_45824_/Y }
C {devices/lab_pin.sym} 46860 -17040 0 1 {name=p46294 lab=_45825_/X }
C {sky130_stdcells/a211o_4.sym} 46780 -17040 0 0 {name=X_45825_ }
C {devices/lab_pin.sym} 46720 -16900 0 0 {name=p46295 lab=_76645_/A }
C {devices/lab_pin.sym} 46720 -16860 0 0 {name=p46296 lab=_76644_/Y }
C {devices/lab_pin.sym} 46840 -16880 0 1 {name=p46297 lab=_76645_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -16880 0 0 {name=X_76645_ }
C {devices/lab_pin.sym} 46700 -16770 0 0 {name=p46298 lab=_49591_/Y }
C {devices/lab_pin.sym} 46700 -16730 0 0 {name=p46299 lab=_49570_/X }
C {devices/lab_pin.sym} 46700 -16690 0 0 {name=p46300 lab=_49592_/X }
C {devices/lab_pin.sym} 46860 -16730 0 1 {name=p46301 lab=_86359_/D }
C {sky130_stdcells/a21oi_4.sym} 46780 -16730 0 0 {name=X_49593_ }
C {devices/lab_pin.sym} 46740 -16590 0 0 {name=p46302 lab=_73262_/A }
C {devices/lab_pin.sym} 46820 -16590 0 1 {name=p46303 lab=_73857_/X }
C {sky130_stdcells/buf_2.sym} 46780 -16590 0 0 {name=X_73857_ }
C {devices/lab_pin.sym} 46720 -16500 0 0 {name=p46304 lab=_61871_/A }
C {devices/lab_pin.sym} 46720 -16460 0 0 {name=p46305 lab=_61839_/B }
C {devices/lab_pin.sym} 46720 -16420 0 0 {name=p46306 lab=_61839_/C }
C {devices/lab_pin.sym} 46720 -16380 0 0 {name=p46307 lab=_63110_/B }
C {devices/lab_pin.sym} 46840 -16440 0 1 {name=p46308 lab=_61871_/X }
C {sky130_stdcells/and4_4.sym} 46780 -16440 0 0 {name=X_61871_ }
C {devices/lab_pin.sym} 46720 -16300 0 0 {name=p46309 lab=_63657_/A }
C {devices/lab_pin.sym} 46720 -16260 0 0 {name=p46310 lab=_63610_/B }
C {devices/lab_pin.sym} 46840 -16280 0 1 {name=p46311 lab=_63610_/X }
C {sky130_stdcells/and2_4.sym} 46780 -16280 0 0 {name=X_63610_ }
C {devices/lab_pin.sym} 46740 -16150 0 0 {name=p46312 lab=clkbuf_8_83_0_CLK/X }
C {devices/lab_pin.sym} 46820 -16150 0 1 {name=p46313 lab=clkbuf_9_167_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 46780 -16150 0 0 {name=Xclkbuf_9_167_0_CLK }
C {devices/lab_pin.sym} 46740 -16030 0 0 {name=p46314 lab=_48544_/A }
C {devices/lab_pin.sym} 46820 -16030 0 1 {name=p46315 lab=_52182_/A }
C {sky130_stdcells/buf_2.sym} 46780 -16030 0 0 {name=X_48544_ }
C {devices/lab_pin.sym} 46720 -15930 0 0 {name=p46316 lab=_64561_/A }
C {devices/lab_pin.sym} 46720 -15890 0 0 {name=p46317 lab=_57872_/A }
C {devices/lab_pin.sym} 46720 -15850 0 0 {name=p46318 lab=_60822_/C }
C {devices/lab_pin.sym} 46840 -15890 0 1 {name=p46319 lab=_60822_/X }
C {sky130_stdcells/or3_4.sym} 46780 -15890 0 0 {name=X_60822_ }
C {devices/lab_pin.sym} 46700 -15780 0 0 {name=p46320 lab=_72806_/X }
C {devices/lab_pin.sym} 46700 -15740 0 0 {name=p46321 lab=_86207_/Q }
C {devices/lab_pin.sym} 46700 -15700 0 0 {name=p46322 lab=_72746_/X }
C {devices/lab_pin.sym} 46700 -15660 0 0 {name=p46323 lab=_72807_/X }
C {devices/lab_pin.sym} 46860 -15720 0 1 {name=p46324 lab=_72808_/X }
C {sky130_stdcells/a211o_4.sym} 46780 -15720 0 0 {name=X_72808_ }
C {devices/lab_pin.sym} 46720 -15580 0 0 {name=p46325 lab=_79362_/X }
C {devices/lab_pin.sym} 46720 -15540 0 0 {name=p46326 lab=_79369_/B }
C {devices/lab_pin.sym} 46840 -15560 0 1 {name=p46327 lab=_79364_/Y }
C {sky130_stdcells/xnor2_4.sym} 46780 -15560 0 0 {name=X_79364_ }
C {devices/lab_pin.sym} 46700 -15450 0 0 {name=p46328 lab=_57326_/B }
C {devices/lab_pin.sym} 46700 -15410 0 0 {name=p46329 lab=_45675_/X }
C {devices/lab_pin.sym} 46700 -15370 0 0 {name=p46330 lab=_45755_/X }
C {devices/lab_pin.sym} 46860 -15410 0 1 {name=p46331 lab=_45756_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -15410 0 0 {name=X_45756_ }
C {devices/lab_pin.sym} 46740 -15270 0 0 {name=p46332 lab=_44175_/A }
C {devices/lab_pin.sym} 46820 -15270 0 1 {name=p46333 lab=_64829_/A }
C {sky130_stdcells/buf_2.sym} 46780 -15270 0 0 {name=X_64590_ }
C {devices/lab_pin.sym} 46720 -15170 0 0 {name=p46334 lab=_76572_/Y }
C {devices/lab_pin.sym} 46720 -15130 0 0 {name=p46335 lab=_76576_/B }
C {devices/lab_pin.sym} 46720 -15090 0 0 {name=p46336 lab=_76575_/Y }
C {devices/lab_pin.sym} 46840 -15130 0 1 {name=p46337 lab=_76576_/X }
C {sky130_stdcells/or3_4.sym} 46780 -15130 0 0 {name=X_76576_ }
C {devices/lab_pin.sym} 46740 -14990 0 0 {name=p46338 lab=_42968_/A }
C {devices/lab_pin.sym} 46820 -14990 0 1 {name=p46339 lab=_42968_/Y }
C {sky130_stdcells/inv_2.sym} 46780 -14990 0 0 {name=X_42968_ }
C {devices/lab_pin.sym} 46700 -14900 0 0 {name=p46340 lab=_73786_/X }
C {devices/lab_pin.sym} 46700 -14860 0 0 {name=p46341 lab=_84984_/Q }
C {devices/lab_pin.sym} 46700 -14820 0 0 {name=p46342 lab=_73740_/X }
C {devices/lab_pin.sym} 46700 -14780 0 0 {name=p46343 lab=_73787_/X }
C {devices/lab_pin.sym} 46860 -14840 0 1 {name=p46344 lab=_73789_/B }
C {sky130_stdcells/a211o_4.sym} 46780 -14840 0 0 {name=X_73788_ }
C {devices/lab_pin.sym} 46740 -14690 0 0 {name=p46345 lab=clkbuf_9_94_0_CLK/A }
C {devices/lab_pin.sym} 46820 -14690 0 1 {name=p46346 lab=clkbuf_9_94_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 46780 -14690 0 0 {name=Xclkbuf_9_94_0_CLK }
C {devices/lab_pin.sym} 46720 -14580 0 0 {name=p46347 lab=_78316_/A }
C {devices/lab_pin.sym} 46720 -14540 0 0 {name=p46348 lab=_82659_/D }
C {devices/lab_pin.sym} 46840 -14560 0 1 {name=p46349 lab=_78318_/A }
C {sky130_stdcells/or2_4.sym} 46780 -14560 0 0 {name=X_78315_ }
C {devices/lab_pin.sym} 46740 -14430 0 0 {name=p46350 lab=_44529_/A }
C {devices/lab_pin.sym} 46820 -14430 0 1 {name=p46351 lab=_44707_/X }
C {sky130_stdcells/buf_2.sym} 46780 -14430 0 0 {name=X_44707_ }
C {devices/lab_pin.sym} 46720 -14340 0 0 {name=p46352 lab=_59415_/A }
C {devices/lab_pin.sym} 46720 -14300 0 0 {name=p46353 lab=_63541_/B }
C {devices/lab_pin.sym} 46720 -14260 0 0 {name=p46354 lab=_63514_/C }
C {devices/lab_pin.sym} 46720 -14220 0 0 {name=p46355 lab=_63541_/D }
C {devices/lab_pin.sym} 46840 -14280 0 1 {name=p46356 lab=_63541_/Y }
C {sky130_stdcells/nand4_4.sym} 46780 -14280 0 0 {name=X_63541_ }
C {devices/lab_pin.sym} 46700 -14150 0 0 {name=p46357 lab=_75505_/Y }
C {devices/lab_pin.sym} 46700 -14110 0 0 {name=p46358 lab=_75538_/B }
C {devices/lab_pin.sym} 46700 -14070 0 0 {name=p46359 lab=_75503_/Y }
C {devices/lab_pin.sym} 46860 -14110 0 1 {name=p46360 lab=_75528_/B }
C {sky130_stdcells/o21a_4.sym} 46780 -14110 0 0 {name=X_75527_ }
C {devices/lab_pin.sym} 46740 -13970 0 0 {name=p46361 lab=_42477_/A }
C {devices/lab_pin.sym} 46820 -13970 0 1 {name=p46362 lab=_41919_/X }
C {sky130_stdcells/buf_2.sym} 46780 -13970 0 0 {name=X_41919_ }
C {devices/lab_pin.sym} 46740 -13850 0 0 {name=p46363 lab=_74416_/A }
C {devices/lab_pin.sym} 46820 -13850 0 1 {name=p46364 lab=_50447_/A }
C {sky130_stdcells/buf_2.sym} 46780 -13850 0 0 {name=X_48475_ }
C {devices/lab_pin.sym} 46700 -13770 0 0 {name=p46365 lab=_60748_/X }
C {devices/lab_pin.sym} 46700 -13730 0 0 {name=p46366 lab=_60750_/X }
C {devices/lab_pin.sym} 46700 -13690 0 0 {name=p46367 lab=_60684_/X }
C {devices/lab_pin.sym} 46700 -13650 0 0 {name=p46368 lab=_60726_/Y }
C {devices/lab_pin.sym} 46700 -13620 0 0 {name=p46369 lab=_60752_/Y }
C {devices/lab_pin.sym} 46860 -13690 0 1 {name=p46370 lab=_60753_/Y }
C {sky130_stdcells/a41oi_4.sym} 46780 -13690 0 0 {name=X_60753_ }
C {devices/lab_pin.sym} 46740 -13530 0 0 {name=p46371 lab=_72739_/A }
C {devices/lab_pin.sym} 46820 -13530 0 1 {name=p46372 lab=_72739_/X }
C {sky130_stdcells/buf_2.sym} 46780 -13530 0 0 {name=X_72739_ }
C {devices/lab_pin.sym} 46700 -13430 0 0 {name=p46373 lab=_79282_/X }
C {devices/lab_pin.sym} 46700 -13390 0 0 {name=p46374 lab=_79293_/X }
C {devices/lab_pin.sym} 46700 -13350 0 0 {name=p46375 lab=_79294_/X }
C {devices/lab_pin.sym} 46860 -13390 0 1 {name=p46376 lab=_79295_/Y }
C {sky130_stdcells/a21oi_4.sym} 46780 -13390 0 0 {name=X_79295_ }
C {devices/lab_pin.sym} 46700 -13270 0 0 {name=p46377 lab=_45679_/X }
C {devices/lab_pin.sym} 46700 -13230 0 0 {name=p46378 lab=_45683_/Y }
C {devices/lab_pin.sym} 46700 -13190 0 0 {name=p46379 lab=_45686_/Y }
C {devices/lab_pin.sym} 46860 -13230 0 1 {name=p46380 lab=_45687_/Y }
C {sky130_stdcells/a21oi_4.sym} 46780 -13230 0 0 {name=X_45687_ }
C {devices/lab_pin.sym} 46740 -13090 0 0 {name=p46381 lab=_51949_/A }
C {devices/lab_pin.sym} 46820 -13090 0 1 {name=p46382 lab=_42962_/A }
C {sky130_stdcells/buf_2.sym} 46780 -13090 0 0 {name=X_42899_ }
C {devices/lab_pin.sym} 46740 -12970 0 0 {name=p46383 lab=_47426_/A }
C {devices/lab_pin.sym} 46820 -12970 0 1 {name=p46384 lab=_53044_/D }
C {sky130_stdcells/buf_2.sym} 46780 -12970 0 0 {name=X_47426_ }
C {devices/lab_pin.sym} 46720 -12870 0 0 {name=p46385 lab=_65796_/X }
C {devices/lab_pin.sym} 46720 -12830 0 0 {name=p46386 lab=_66276_/B }
C {devices/lab_pin.sym} 46720 -12790 0 0 {name=p46387 lab=_65798_/X }
C {devices/lab_pin.sym} 46840 -12830 0 1 {name=p46388 lab=_66260_/Y }
C {sky130_stdcells/nand3_4.sym} 46780 -12830 0 0 {name=X_66260_ }
C {devices/lab_pin.sym} 46720 -12700 0 0 {name=p46389 lab=_78246_/A }
C {devices/lab_pin.sym} 46720 -12660 0 0 {name=p46390 lab=_78245_/Y }
C {devices/lab_pin.sym} 46840 -12680 0 1 {name=p46391 lab=_78247_/B }
C {sky130_stdcells/xor2_4.sym} 46780 -12680 0 0 {name=X_78246_ }
C {devices/lab_pin.sym} 46740 -12550 0 0 {name=p46392 lab=_44679_/A }
C {devices/lab_pin.sym} 46820 -12550 0 1 {name=p46393 lab=_44638_/X }
C {sky130_stdcells/buf_2.sym} 46780 -12550 0 0 {name=X_44638_ }
C {devices/lab_pin.sym} 46740 -12430 0 0 {name=p46394 lab=_75458_/A }
C {devices/lab_pin.sym} 46820 -12430 0 1 {name=p46395 lab=_75458_/X }
C {sky130_stdcells/buf_2.sym} 46780 -12430 0 0 {name=X_75458_ }
C {devices/lab_pin.sym} 46720 -12340 0 0 {name=p46396 lab=_63448_/A }
C {devices/lab_pin.sym} 46720 -12300 0 0 {name=p46397 lab=_58506_/A }
C {devices/lab_pin.sym} 46720 -12260 0 0 {name=p46398 lab=_63458_/X }
C {devices/lab_pin.sym} 46720 -12220 0 0 {name=p46399 lab=_63496_/D }
C {devices/lab_pin.sym} 46840 -12280 0 1 {name=p46400 lab=_63472_/X }
C {sky130_stdcells/and4_4.sym} 46780 -12280 0 0 {name=X_63472_ }
C {devices/lab_pin.sym} 46700 -12160 0 0 {name=p46401 lab=_63416_/A }
C {devices/lab_pin.sym} 46700 -12120 0 0 {name=p46402 lab=_60732_/C }
C {devices/lab_pin.sym} 46700 -12080 0 0 {name=p46403 lab=_60804_/C }
C {devices/lab_pin.sym} 46700 -12040 0 0 {name=p46404 lab=_63699_/D }
C {devices/lab_pin.sym} 46860 -12100 0 1 {name=p46405 lab=_60684_/X }
C {sky130_stdcells/a211o_4.sym} 46780 -12100 0 0 {name=X_60684_ }
C {devices/lab_pin.sym} 46740 -11950 0 0 {name=p46406 lab=_65859_/A }
C {devices/lab_pin.sym} 46820 -11950 0 1 {name=p46407 lab=_65211_/X }
C {sky130_stdcells/buf_2.sym} 46780 -11950 0 0 {name=X_65211_ }
C {devices/lab_pin.sym} 46720 -11860 0 0 {name=p46408 lab=_62479_/A }
C {devices/lab_pin.sym} 46720 -11820 0 0 {name=p46409 lab=_61954_/X }
C {devices/lab_pin.sym} 46720 -11780 0 0 {name=p46410 lab=_62364_/X }
C {devices/lab_pin.sym} 46720 -11740 0 0 {name=p46411 lab=_62392_/D }
C {devices/lab_pin.sym} 46840 -11800 0 1 {name=p46412 lab=_62423_/X }
C {sky130_stdcells/and4_4.sym} 46780 -11800 0 0 {name=X_62423_ }
C {devices/lab_pin.sym} 46700 -11670 0 0 {name=p46413 lab=_83072_/Q }
C {devices/lab_pin.sym} 46700 -11630 0 0 {name=p46414 lab=_74377_/X }
C {devices/lab_pin.sym} 46700 -11590 0 0 {name=p46415 lab=_74408_/Y }
C {devices/lab_pin.sym} 46860 -11630 0 1 {name=p46416 lab=_74409_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -11630 0 0 {name=X_74409_ }
C {devices/lab_pin.sym} 46720 -11520 0 0 {name=p46417 lab=_47380_/A }
C {devices/lab_pin.sym} 46720 -11480 0 0 {name=p46418 lab=_47349_/B }
C {devices/lab_pin.sym} 46720 -11440 0 0 {name=p46419 lab=_47370_/C }
C {devices/lab_pin.sym} 46720 -11400 0 0 {name=p46420 lab=_53003_/D }
C {devices/lab_pin.sym} 46840 -11460 0 1 {name=p46421 lab=_47357_/X }
C {sky130_stdcells/and4_4.sym} 46780 -11460 0 0 {name=X_47357_ }
C {devices/lab_pin.sym} 46700 -11330 0 0 {name=p46422 lab=_66179_/X }
C {devices/lab_pin.sym} 46700 -11290 0 0 {name=p46423 lab=_66189_/Y }
C {devices/lab_pin.sym} 46700 -11250 0 0 {name=p46424 lab=_66190_/Y }
C {devices/lab_pin.sym} 46860 -11290 0 1 {name=p46425 lab=_66191_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -11290 0 0 {name=X_66191_ }
C {devices/lab_pin.sym} 46720 -11160 0 0 {name=p46426 lab=_78177_/A }
C {devices/lab_pin.sym} 46720 -11120 0 0 {name=p46427 lab=_78177_/B }
C {devices/lab_pin.sym} 46840 -11140 0 1 {name=p46428 lab=_78177_/Y }
C {sky130_stdcells/nor2_4.sym} 46780 -11140 0 0 {name=X_78177_ }
C {devices/lab_pin.sym} 46700 -11050 0 0 {name=p46429 lab=_44565_/X }
C {devices/lab_pin.sym} 46700 -11010 0 0 {name=p46430 lab=_44567_/X }
C {devices/lab_pin.sym} 46700 -10970 0 0 {name=p46431 lab=_40866_/X }
C {devices/lab_pin.sym} 46700 -10930 0 0 {name=p46432 lab=_87052_/Q }
C {devices/lab_pin.sym} 46700 -10890 0 0 {name=p46433 lab=_44568_/X }
C {devices/lab_pin.sym} 46860 -10970 0 1 {name=p46434 lab=_44570_/A }
C {sky130_stdcells/o32ai_4.sym} 46780 -10970 0 0 {name=X_44569_ }
C {devices/lab_pin.sym} 46700 -10830 0 0 {name=p46435 lab=_75369_/Y }
C {devices/lab_pin.sym} 46700 -10790 0 0 {name=p46436 lab=_75404_/B }
C {devices/lab_pin.sym} 46700 -10750 0 0 {name=p46437 lab=_75404_/A }
C {devices/lab_pin.sym} 46860 -10790 0 1 {name=p46438 lab=_75390_/B }
C {sky130_stdcells/a21boi_4.sym} 46780 -10790 0 0 {name=X_75389_ }
C {devices/lab_pin.sym} 46740 -10650 0 0 {name=p46439 lab=_46308_/A }
C {devices/lab_pin.sym} 46820 -10650 0 1 {name=p46440 lab=_46428_/B }
C {sky130_stdcells/buf_2.sym} 46780 -10650 0 0 {name=X_46308_ }
C {devices/lab_pin.sym} 46720 -10550 0 0 {name=p46441 lab=_65047_/A }
C {devices/lab_pin.sym} 46720 -10510 0 0 {name=p46442 lab=_65047_/B }
C {devices/lab_pin.sym} 46720 -10470 0 0 {name=p46443 lab=_65142_/C }
C {devices/lab_pin.sym} 46840 -10510 0 1 {name=p46444 lab=_65142_/Y }
C {sky130_stdcells/nor3_4.sym} 46780 -10510 0 0 {name=X_65142_ }
C {devices/lab_pin.sym} 46740 -10370 0 0 {name=p46445 lab=clkbuf_9_307_0_CLK/X }
C {devices/lab_pin.sym} 46820 -10370 0 1 {name=p46446 lab=_80854_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 46780 -10370 0 0 {name=Xclkbuf_10_614_0_CLK }
C {devices/lab_pin.sym} 46720 -10260 0 0 {name=p46447 lab=_77127_/A }
C {devices/lab_pin.sym} 46720 -10220 0 0 {name=p46448 lab=_77127_/B }
C {devices/lab_pin.sym} 46840 -10240 0 1 {name=p46449 lab=_77128_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -10240 0 0 {name=X_77128_ }
C {devices/lab_pin.sym} 46700 -10130 0 0 {name=p46450 lab=_62352_/Y }
C {devices/lab_pin.sym} 46700 -10090 0 0 {name=p46451 lab=_62327_/X }
C {devices/lab_pin.sym} 46700 -10050 0 0 {name=p46452 lab=_62353_/Y }
C {devices/lab_pin.sym} 46860 -10090 0 1 {name=p46453 lab=_84416_/D }
C {sky130_stdcells/a21oi_4.sym} 46780 -10090 0 0 {name=X_62354_ }
C {devices/lab_pin.sym} 46740 -9950 0 0 {name=p46454 lab=_83386_/Q }
C {devices/lab_pin.sym} 46820 -9950 0 1 {name=p46455 lab=_54130_/B }
C {sky130_stdcells/inv_2.sym} 46780 -9950 0 0 {name=X_47288_ }
C {devices/lab_pin.sym} 46720 -9850 0 0 {name=p46456 lab=_61305_/A }
C {devices/lab_pin.sym} 46720 -9810 0 0 {name=p46457 lab=_61301_/X }
C {devices/lab_pin.sym} 46720 -9770 0 0 {name=p46458 lab=_72583_/C }
C {devices/lab_pin.sym} 46840 -9810 0 1 {name=p46459 lab=_61305_/Y }
C {sky130_stdcells/nand3_4.sym} 46780 -9810 0 0 {name=X_61305_ }
C {devices/lab_pin.sym} 46700 -9690 0 0 {name=p46460 lab=_64992_/B }
C {devices/lab_pin.sym} 46700 -9650 0 0 {name=p46461 lab=_49003_/X }
C {devices/lab_pin.sym} 46700 -9610 0 0 {name=p46462 lab=_49026_/Y }
C {devices/lab_pin.sym} 46860 -9650 0 1 {name=p46463 lab=_49027_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -9650 0 0 {name=X_49027_ }
C {devices/lab_pin.sym} 46740 -9510 0 0 {name=p46464 lab=_46239_/A }
C {devices/lab_pin.sym} 46820 -9510 0 1 {name=p46465 lab=_48882_/A }
C {sky130_stdcells/inv_2.sym} 46780 -9510 0 0 {name=X_46239_ }
C {devices/lab_pin.sym} 46700 -9410 0 0 {name=p46466 lab=_65069_/Y }
C {devices/lab_pin.sym} 46700 -9370 0 0 {name=p46467 lab=_65070_/X }
C {devices/lab_pin.sym} 46700 -9330 0 0 {name=p46468 lab=_65072_/Y }
C {devices/lab_pin.sym} 46860 -9370 0 1 {name=p46469 lab=_84216_/D }
C {sky130_stdcells/a21o_4.sym} 46780 -9370 0 0 {name=X_65073_ }
C {devices/lab_pin.sym} 46740 -9230 0 0 {name=p46470 lab=clkbuf_8_52_0_CLK/X }
C {devices/lab_pin.sym} 46820 -9230 0 1 {name=p46471 lab=clkbuf_9_105_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 46780 -9230 0 0 {name=Xclkbuf_9_105_0_CLK }
C {devices/lab_pin.sym} 46700 -9140 0 0 {name=p46472 lab=_87042_/Q }
C {devices/lab_pin.sym} 46700 -9100 0 0 {name=p46473 lab=_44225_/B }
C {devices/lab_pin.sym} 46700 -9060 0 0 {name=p46474 lab=_57800_/A }
C {devices/lab_pin.sym} 46700 -9020 0 0 {name=p46475 lab=_69949_/X }
C {devices/lab_pin.sym} 46860 -9080 0 1 {name=p46476 lab=_69950_/X }
C {sky130_stdcells/a211o_4.sym} 46780 -9080 0 0 {name=X_69950_ }
C {devices/lab_pin.sym} 46720 -8940 0 0 {name=p46477 lab=_77067_/A }
C {devices/lab_pin.sym} 46720 -8900 0 0 {name=p46478 lab=_77068_/A }
C {devices/lab_pin.sym} 46840 -8920 0 1 {name=p46479 lab=_77060_/B }
C {sky130_stdcells/xor2_4.sym} 46780 -8920 0 0 {name=X_77059_ }
C {devices/lab_pin.sym} 46740 -8790 0 0 {name=p46480 lab=_62276_/X }
C {devices/lab_pin.sym} 46820 -8790 0 1 {name=p46481 lab=_62285_/X }
C {sky130_stdcells/buf_2.sym} 46780 -8790 0 0 {name=X_62285_ }
C {devices/lab_pin.sym} 46740 -8670 0 0 {name=p46482 lab=clkbuf_9_33_0_CLK/A }
C {devices/lab_pin.sym} 46820 -8670 0 1 {name=p46483 lab=clkbuf_9_32_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 46780 -8670 0 0 {name=Xclkbuf_9_32_0_CLK }
C {devices/lab_pin.sym} 46740 -8550 0 0 {name=p46484 lab=_63749_/A }
C {devices/lab_pin.sym} 46820 -8550 0 1 {name=p46485 lab=_64118_/B }
C {sky130_stdcells/buf_2.sym} 46780 -8550 0 0 {name=X_64024_ }
C {devices/lab_pin.sym} 46740 -8430 0 0 {name=p46486 lab=_69014_/A }
C {devices/lab_pin.sym} 46820 -8430 0 1 {name=p46487 lab=_68994_/A }
C {sky130_stdcells/buf_2.sym} 46780 -8430 0 0 {name=X_68901_ }
C {devices/lab_pin.sym} 46720 -8320 0 0 {name=p46488 lab=_61198_/X }
C {devices/lab_pin.sym} 46720 -8280 0 0 {name=p46489 lab=_64203_/B }
C {devices/lab_pin.sym} 46840 -8300 0 1 {name=p46490 lab=_61237_/D }
C {sky130_stdcells/nand2_4.sym} 46780 -8300 0 0 {name=X_61236_ }
C {devices/lab_pin.sym} 46720 -8180 0 0 {name=p46491 lab=_80068_/X }
C {devices/lab_pin.sym} 46720 -8140 0 0 {name=p46492 lab=_80069_/X }
C {devices/lab_pin.sym} 46840 -8160 0 1 {name=p46493 lab=_80070_/Y }
C {sky130_stdcells/xnor2_4.sym} 46780 -8160 0 0 {name=X_80070_ }
C {devices/lab_pin.sym} 46700 -8050 0 0 {name=p46494 lab=_81962_/D }
C {devices/lab_pin.sym} 46700 -8010 0 0 {name=p46495 lab=_69831_/X }
C {devices/lab_pin.sym} 46700 -7970 0 0 {name=p46496 lab=_69880_/X }
C {devices/lab_pin.sym} 46860 -8010 0 1 {name=p46497 lab=_83890_/D }
C {sky130_stdcells/a21bo_4.sym} 46780 -8010 0 0 {name=X_69881_ }
C {devices/lab_pin.sym} 46740 -7870 0 0 {name=p46498 lab=clkbuf_9_314_0_CLK/X }
C {devices/lab_pin.sym} 46820 -7870 0 1 {name=p46499 lab=_81970_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 46780 -7870 0 0 {name=Xclkbuf_10_629_0_CLK }
C {devices/lab_pin.sym} 46740 -7750 0 0 {name=p46500 lab=_68059_/A }
C {devices/lab_pin.sym} 46820 -7750 0 1 {name=p46501 lab=_68832_/X }
C {sky130_stdcells/buf_2.sym} 46780 -7750 0 0 {name=X_68832_ }
C {devices/lab_pin.sym} 46700 -7650 0 0 {name=p46502 lab=_61097_/X }
C {devices/lab_pin.sym} 46700 -7610 0 0 {name=p46503 lab=_61103_/X }
C {devices/lab_pin.sym} 46700 -7570 0 0 {name=p46504 lab=_59980_/X }
C {devices/lab_pin.sym} 46860 -7610 0 1 {name=p46505 lab=_61167_/Y }
C {sky130_stdcells/a21oi_4.sym} 46780 -7610 0 0 {name=X_61167_ }
C {devices/lab_pin.sym} 46720 -7490 0 0 {name=p46506 lab=_62244_/D }
C {devices/lab_pin.sym} 46720 -7450 0 0 {name=p46507 lab=_59950_/B }
C {devices/lab_pin.sym} 46720 -7410 0 0 {name=p46508 lab=_59977_/B }
C {devices/lab_pin.sym} 46840 -7450 0 1 {name=p46509 lab=_60118_/X }
C {sky130_stdcells/and3_4.sym} 46780 -7450 0 0 {name=X_60118_ }
C {devices/lab_pin.sym} 46700 -7330 0 0 {name=p46510 lab=_72220_/B }
C {devices/lab_pin.sym} 46700 -7290 0 0 {name=p46511 lab=_49906_/X }
C {devices/lab_pin.sym} 46700 -7250 0 0 {name=p46512 lab=_49928_/Y }
C {devices/lab_pin.sym} 46860 -7290 0 1 {name=p46513 lab=_49929_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -7290 0 0 {name=X_49929_ }
C {devices/lab_pin.sym} 46720 -7160 0 0 {name=p46514 lab=_68735_/A }
C {devices/lab_pin.sym} 46720 -7120 0 0 {name=p46515 lab=_68763_/B }
C {devices/lab_pin.sym} 46840 -7140 0 1 {name=p46516 lab=_68763_/X }
C {sky130_stdcells/and2_4.sym} 46780 -7140 0 0 {name=X_68763_ }
C {devices/lab_pin.sym} 46740 -7010 0 0 {name=p46517 lab=clkbuf_9_47_0_CLK/A }
C {devices/lab_pin.sym} 46820 -7010 0 1 {name=p46518 lab=clkbuf_9_47_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 46780 -7010 0 0 {name=Xclkbuf_9_47_0_CLK }
C {devices/lab_pin.sym} 46740 -6890 0 0 {name=p46519 lab=_68347_/A }
C {devices/lab_pin.sym} 46820 -6890 0 1 {name=p46520 lab=_65976_/A }
C {sky130_stdcells/buf_2.sym} 46780 -6890 0 0 {name=X_65975_ }
C {devices/lab_pin.sym} 46740 -6770 0 0 {name=p46521 lab=_61083_/C }
C {devices/lab_pin.sym} 46820 -6770 0 1 {name=p46522 lab=_61172_/A }
C {sky130_stdcells/buf_2.sym} 46780 -6770 0 0 {name=X_61098_ }
C {devices/lab_pin.sym} 46720 -6660 0 0 {name=p46523 lab=_67690_/X }
C {devices/lab_pin.sym} 46720 -6620 0 0 {name=p46524 lab=_67714_/B }
C {devices/lab_pin.sym} 46840 -6640 0 1 {name=p46525 lab=_67714_/X }
C {sky130_stdcells/and2_4.sym} 46780 -6640 0 0 {name=X_67714_ }
C {devices/lab_pin.sym} 46720 -6520 0 0 {name=p46526 lab=_52944_/A }
C {devices/lab_pin.sym} 46720 -6480 0 0 {name=p46527 lab=_52940_/B }
C {devices/lab_pin.sym} 46840 -6500 0 1 {name=p46528 lab=_52940_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -6500 0 0 {name=X_52940_ }
C {devices/lab_pin.sym} 46720 -6380 0 0 {name=p46529 lab=_64926_/A }
C {devices/lab_pin.sym} 46720 -6340 0 0 {name=p46530 lab=_64926_/B }
C {devices/lab_pin.sym} 46840 -6360 0 1 {name=p46531 lab=_64926_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -6360 0 0 {name=X_64926_ }
C {devices/lab_pin.sym} 46740 -6230 0 0 {name=p46532 lab=_60049_/A }
C {devices/lab_pin.sym} 46820 -6230 0 1 {name=p46533 lab=_60049_/Y }
C {sky130_stdcells/inv_2.sym} 46780 -6230 0 0 {name=X_60049_ }
C {devices/lab_pin.sym} 46690 -6110 0 0 {name=p46534 lab=_83421_/CLK }
C {devices/lab_pin.sym} 46690 -6090 0 0 {name=p46535 lab=_83760_/D }
C {devices/lab_pin.sym} 46870 -6110 0 1 {name=p46536 lab=_57655_/A }
C {sky130_stdcells/dfxtp_4.sym} 46780 -6100 0 0 {name=X_83760_ }
C {devices/lab_pin.sym} 46690 -5970 0 0 {name=p46537 lab=_80931_/CLK }
C {devices/lab_pin.sym} 46690 -5950 0 0 {name=p46538 lab=_75667_/X }
C {devices/lab_pin.sym} 46870 -5970 0 1 {name=p46539 lab=_75554_/B }
C {sky130_stdcells/dfxtp_4.sym} 46780 -5960 0 0 {name=X_80972_ }
C {devices/lab_pin.sym} 46700 -5860 0 0 {name=p46540 lab=_88102_/Q }
C {devices/lab_pin.sym} 46700 -5820 0 0 {name=p46541 lab=_68636_/X }
C {devices/lab_pin.sym} 46700 -5780 0 0 {name=p46542 lab=_68691_/X }
C {devices/lab_pin.sym} 46700 -5740 0 0 {name=p46543 lab=_68693_/Y }
C {devices/lab_pin.sym} 46860 -5800 0 1 {name=p46544 lab=_68694_/X }
C {sky130_stdcells/a211o_4.sym} 46780 -5800 0 0 {name=X_68694_ }
C {devices/lab_pin.sym} 46740 -5650 0 0 {name=p46545 lab=clkbuf_2_2_2_CLK/X }
C {devices/lab_pin.sym} 46820 -5650 0 1 {name=p46546 lab=clkbuf_3_5_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 46780 -5650 0 0 {name=Xclkbuf_3_5_0_CLK }
C {devices/lab_pin.sym} 46690 -5530 0 0 {name=p46547 lab=_82711_/CLK }
C {devices/lab_pin.sym} 46690 -5510 0 0 {name=p46548 lab=_82711_/D }
C {devices/lab_pin.sym} 46870 -5530 0 1 {name=p46549 lab=_82667_/D }
C {sky130_stdcells/dfxtp_4.sym} 46780 -5520 0 0 {name=X_82711_ }
C {devices/lab_pin.sym} 46700 -5420 0 0 {name=p46550 lab=_87462_/Q }
C {devices/lab_pin.sym} 46700 -5380 0 0 {name=p46551 lab=_67594_/X }
C {devices/lab_pin.sym} 46700 -5340 0 0 {name=p46552 lab=_67595_/X }
C {devices/lab_pin.sym} 46700 -5300 0 0 {name=p46553 lab=_67644_/X }
C {devices/lab_pin.sym} 46860 -5360 0 1 {name=p46554 lab=_67645_/X }
C {sky130_stdcells/a211o_4.sym} 46780 -5360 0 0 {name=X_67645_ }
C {devices/lab_pin.sym} 46740 -5210 0 0 {name=p46555 lab=_52845_/A }
C {devices/lab_pin.sym} 46820 -5210 0 1 {name=p46556 lab=_52872_/C }
C {sky130_stdcells/buf_2.sym} 46780 -5210 0 0 {name=X_52871_ }
C {devices/lab_pin.sym} 46700 -5120 0 0 {name=p46557 lab=_64817_/X }
C {devices/lab_pin.sym} 46700 -5080 0 0 {name=p46558 lab=_86136_/Q }
C {devices/lab_pin.sym} 46700 -5040 0 0 {name=p46559 lab=_64776_/X }
C {devices/lab_pin.sym} 46700 -5000 0 0 {name=p46560 lab=_64856_/X }
C {devices/lab_pin.sym} 46860 -5060 0 1 {name=p46561 lab=_64857_/X }
C {sky130_stdcells/a211o_4.sym} 46780 -5060 0 0 {name=X_64857_ }
C {devices/lab_pin.sym} 46690 -4910 0 0 {name=p46562 lab=_85635_/CLK }
C {devices/lab_pin.sym} 46690 -4890 0 0 {name=p46563 lab=_83691_/D }
C {devices/lab_pin.sym} 46870 -4910 0 1 {name=p46564 lab=_47204_/A }
C {sky130_stdcells/dfxtp_4.sym} 46780 -4900 0 0 {name=X_83691_ }
C {devices/lab_pin.sym} 46700 -4790 0 0 {name=p46565 lab=_85410_/Q }
C {devices/lab_pin.sym} 46700 -4750 0 0 {name=p46566 lab=_54593_/X }
C {devices/lab_pin.sym} 46700 -4710 0 0 {name=p46567 lab=_54609_/Y }
C {devices/lab_pin.sym} 46860 -4750 0 1 {name=p46568 lab=_54610_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -4750 0 0 {name=X_54610_ }
C {devices/lab_pin.sym} 46690 -4610 0 0 {name=p46569 lab=_85431_/CLK }
C {devices/lab_pin.sym} 46690 -4590 0 0 {name=p46570 lab=_54504_/Y }
C {devices/lab_pin.sym} 46870 -4610 0 1 {name=p46571 lab=_85430_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -4600 0 0 {name=X_85430_ }
C {devices/lab_pin.sym} 46740 -4470 0 0 {name=p46572 lab=_51822_/A }
C {devices/lab_pin.sym} 46820 -4470 0 1 {name=p46573 lab=_51823_/A }
C {sky130_stdcells/buf_2.sym} 46780 -4470 0 0 {name=X_51822_ }
C {devices/lab_pin.sym} 46720 -4380 0 0 {name=p46574 lab=_58232_/X }
C {devices/lab_pin.sym} 46720 -4340 0 0 {name=p46575 lab=_63858_/B }
C {devices/lab_pin.sym} 46720 -4300 0 0 {name=p46576 lab=_63858_/C }
C {devices/lab_pin.sym} 46720 -4260 0 0 {name=p46577 lab=_63793_/D }
C {devices/lab_pin.sym} 46840 -4320 0 1 {name=p46578 lab=_63809_/D }
C {sky130_stdcells/nand4_4.sym} 46780 -4320 0 0 {name=X_63808_ }
C {devices/lab_pin.sym} 46690 -4170 0 0 {name=p46579 lab=_82642_/CLK }
C {devices/lab_pin.sym} 46690 -4150 0 0 {name=p46580 lab=_83994_/Q }
C {devices/lab_pin.sym} 46870 -4170 0 1 {name=p46581 lab=_78948_/A }
C {sky130_stdcells/dfxtp_4.sym} 46780 -4160 0 0 {name=X_82642_ }
C {devices/lab_pin.sym} 46720 -4040 0 0 {name=p46582 lab=_55908_/A }
C {devices/lab_pin.sym} 46720 -4000 0 0 {name=p46583 lab=_55590_/B }
C {devices/lab_pin.sym} 46840 -4020 0 1 {name=p46584 lab=_55590_/X }
C {sky130_stdcells/and2_4.sym} 46780 -4020 0 0 {name=X_55590_ }
C {devices/lab_pin.sym} 46700 -3920 0 0 {name=p46585 lab=_87157_/Q }
C {devices/lab_pin.sym} 46700 -3880 0 0 {name=p46586 lab=_67551_/X }
C {devices/lab_pin.sym} 46700 -3840 0 0 {name=p46587 lab=_67552_/X }
C {devices/lab_pin.sym} 46700 -3800 0 0 {name=p46588 lab=_67575_/X }
C {devices/lab_pin.sym} 46860 -3860 0 1 {name=p46589 lab=_67577_/B }
C {sky130_stdcells/a211o_4.sym} 46780 -3860 0 0 {name=X_67576_ }
C {devices/lab_pin.sym} 46740 -3710 0 0 {name=p46590 lab=_66002_/A }
C {devices/lab_pin.sym} 46820 -3710 0 1 {name=p46591 lab=_64789_/A }
C {sky130_stdcells/buf_2.sym} 46780 -3710 0 0 {name=X_64788_ }
C {devices/lab_pin.sym} 46740 -3590 0 0 {name=p46592 lab=_69315_/A }
C {devices/lab_pin.sym} 46820 -3590 0 1 {name=p46593 lab=_69315_/X }
C {sky130_stdcells/buf_2.sym} 46780 -3590 0 0 {name=X_69315_ }
C {devices/lab_pin.sym} 46740 -3470 0 0 {name=p46594 lab=_54486_/A }
C {devices/lab_pin.sym} 46820 -3470 0 1 {name=p46595 lab=_54546_/A }
C {sky130_stdcells/buf_2.sym} 46780 -3470 0 0 {name=X_54541_ }
C {devices/lab_pin.sym} 46740 -3350 0 0 {name=p46596 lab=_44147_/A }
C {devices/lab_pin.sym} 46820 -3350 0 1 {name=p46597 lab=_68386_/A }
C {sky130_stdcells/buf_2.sym} 46780 -3350 0 0 {name=X_66527_ }
C {devices/lab_pin.sym} 46690 -3230 0 0 {name=p46598 lab=_86289_/CLK }
C {devices/lab_pin.sym} 46690 -3210 0 0 {name=p46599 lab=_85361_/D }
C {devices/lab_pin.sym} 46870 -3230 0 1 {name=p46600 lab=_85361_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -3220 0 0 {name=X_85361_ }
C {devices/lab_pin.sym} 46700 -3110 0 0 {name=p46601 lab=_85952_/Q }
C {devices/lab_pin.sym} 46700 -3070 0 0 {name=p46602 lab=_51387_/X }
C {devices/lab_pin.sym} 46700 -3030 0 0 {name=p46603 lab=_51752_/Y }
C {devices/lab_pin.sym} 46860 -3070 0 1 {name=p46604 lab=_51753_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -3070 0 0 {name=X_51753_ }
C {devices/lab_pin.sym} 46700 -2950 0 0 {name=p46605 lab=_84905_/Q }
C {devices/lab_pin.sym} 46700 -2910 0 0 {name=p46606 lab=_60921_/X }
C {devices/lab_pin.sym} 46700 -2870 0 0 {name=p46607 lab=_60895_/X }
C {devices/lab_pin.sym} 46860 -2910 0 1 {name=p46608 lab=_63739_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -2910 0 0 {name=X_63739_ }
C {devices/lab_pin.sym} 46690 -2770 0 0 {name=p46609 lab=_82604_/CLK }
C {devices/lab_pin.sym} 46690 -2750 0 0 {name=p46610 lab=_82605_/Q }
C {devices/lab_pin.sym} 46870 -2770 0 1 {name=p46611 lab=_78154_/A }
C {sky130_stdcells/dfxtp_4.sym} 46780 -2760 0 0 {name=X_82573_ }
C {devices/lab_pin.sym} 46690 -2630 0 0 {name=p46612 lab=_88272_/CLK }
C {devices/lab_pin.sym} 46690 -2610 0 0 {name=p46613 lab=_87100_/D }
C {devices/lab_pin.sym} 46870 -2630 0 1 {name=p46614 lab=_87100_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -2620 0 0 {name=X_87100_ }
C {devices/lab_pin.sym} 46690 -2490 0 0 {name=p46615 lab=_84314_/CLK }
C {devices/lab_pin.sym} 46690 -2470 0 0 {name=p46616 lab=_63580_/Y }
C {devices/lab_pin.sym} 46870 -2490 0 1 {name=p46617 lab=_80442_/B }
C {sky130_stdcells/dfxtp_4.sym} 46780 -2480 0 0 {name=X_84312_ }
C {devices/lab_pin.sym} 46720 -2360 0 0 {name=p46618 lab=_50695_/A }
C {devices/lab_pin.sym} 46720 -2320 0 0 {name=p46619 lab=_53919_/B }
C {devices/lab_pin.sym} 46840 -2340 0 1 {name=p46620 lab=_50704_/Y }
C {sky130_stdcells/nand2_4.sym} 46780 -2340 0 0 {name=X_50704_ }
C {devices/lab_pin.sym} 46700 -2240 0 0 {name=p46621 lab=_57243_/X }
C {devices/lab_pin.sym} 46700 -2200 0 0 {name=p46622 lab=_56634_/X }
C {devices/lab_pin.sym} 46700 -2160 0 0 {name=p46623 lab=_45585_/A }
C {devices/lab_pin.sym} 46700 -2120 0 0 {name=p46624 lab=_57245_/X }
C {devices/lab_pin.sym} 46860 -2180 0 1 {name=p46625 lab=_57260_/X }
C {sky130_stdcells/a2bb2o_4.sym} 46780 -2180 0 0 {name=X_57260_ }
C {devices/lab_pin.sym} 46690 -2030 0 0 {name=p46626 lab=_81532_/CLK }
C {devices/lab_pin.sym} 46690 -2010 0 0 {name=p46627 lab=_81568_/Q }
C {devices/lab_pin.sym} 46870 -2030 0 1 {name=p46628 lab=_76054_/A }
C {sky130_stdcells/dfxtp_4.sym} 46780 -2020 0 0 {name=X_81524_ }
C {devices/lab_pin.sym} 46720 -1900 0 0 {name=p46629 lab=_69191_/A }
C {devices/lab_pin.sym} 46720 -1860 0 0 {name=p46630 lab=_87787_/Q }
C {devices/lab_pin.sym} 46840 -1880 0 1 {name=p46631 lab=_69246_/X }
C {sky130_stdcells/and2_4.sym} 46780 -1880 0 0 {name=X_69246_ }
C {devices/lab_pin.sym} 46690 -1750 0 0 {name=p46632 lab=_87824_/CLK }
C {devices/lab_pin.sym} 46690 -1730 0 0 {name=p46633 lab=_88080_/D }
C {devices/lab_pin.sym} 46870 -1750 0 1 {name=p46634 lab=_88080_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -1740 0 0 {name=X_88080_ }
C {devices/lab_pin.sym} 46700 -1630 0 0 {name=p46635 lab=_54470_/Y }
C {devices/lab_pin.sym} 46700 -1590 0 0 {name=p46636 lab=_54448_/X }
C {devices/lab_pin.sym} 46700 -1550 0 0 {name=p46637 lab=_54471_/X }
C {devices/lab_pin.sym} 46860 -1590 0 1 {name=p46638 lab=_85436_/D }
C {sky130_stdcells/a21oi_4.sym} 46780 -1590 0 0 {name=X_54472_ }
C {devices/lab_pin.sym} 46720 -1470 0 0 {name=p46639 lab=_66173_/A }
C {devices/lab_pin.sym} 46720 -1430 0 0 {name=p46640 lab=_66517_/B }
C {devices/lab_pin.sym} 46720 -1390 0 0 {name=p46641 lab=_66173_/C }
C {devices/lab_pin.sym} 46840 -1430 0 1 {name=p46642 lab=_66458_/Y }
C {sky130_stdcells/nand3_4.sym} 46780 -1430 0 0 {name=X_66458_ }
C {devices/lab_pin.sym} 46690 -1290 0 0 {name=p46643 lab=_80671_/CLK }
C {devices/lab_pin.sym} 46690 -1270 0 0 {name=p46644 lab=_56125_/Y }
C {devices/lab_pin.sym} 46870 -1290 0 1 {name=p46645 lab=_56124_/C }
C {sky130_stdcells/dfxtp_4.sym} 46780 -1280 0 0 {name=X_85292_ }
C {devices/lab_pin.sym} 46720 -1180 0 0 {name=p46646 lab=_51695_/A }
C {devices/lab_pin.sym} 46720 -1140 0 0 {name=p46647 lab=_51684_/B }
C {devices/lab_pin.sym} 46720 -1100 0 0 {name=p46648 lab=_51684_/C }
C {devices/lab_pin.sym} 46720 -1060 0 0 {name=p46649 lab=_53207_/D }
C {devices/lab_pin.sym} 46840 -1120 0 1 {name=p46650 lab=_51684_/X }
C {sky130_stdcells/and4_4.sym} 46780 -1120 0 0 {name=X_51684_ }
C {devices/lab_pin.sym} 46720 -990 0 0 {name=p46651 lab=_56200_/X }
C {devices/lab_pin.sym} 46720 -950 0 0 {name=p46652 lab=_56205_/X }
C {devices/lab_pin.sym} 46720 -910 0 0 {name=p46653 lab=_56211_/C }
C {devices/lab_pin.sym} 46840 -950 0 1 {name=p46654 lab=_56211_/Y }
C {sky130_stdcells/nand3_4.sym} 46780 -950 0 0 {name=X_56211_ }
C {devices/lab_pin.sym} 46690 -810 0 0 {name=p46655 lab=_87333_/CLK }
C {devices/lab_pin.sym} 46690 -790 0 0 {name=p46656 lab=_87031_/D }
C {devices/lab_pin.sym} 46870 -810 0 1 {name=p46657 lab=_87031_/Q }
C {sky130_stdcells/dfxtp_4.sym} 46780 -800 0 0 {name=X_87031_ }
C {devices/lab_pin.sym} 46700 -690 0 0 {name=p46658 lab=_85636_/Q }
C {devices/lab_pin.sym} 46700 -650 0 0 {name=p46659 lab=_53404_/X }
C {devices/lab_pin.sym} 46700 -610 0 0 {name=p46660 lab=_53422_/Y }
C {devices/lab_pin.sym} 46860 -650 0 1 {name=p46661 lab=_53423_/Y }
C {sky130_stdcells/o21ai_4.sym} 46780 -650 0 0 {name=X_53423_ }
C {devices/lab_pin.sym} 47620 -42180 0 0 {name=p46662 lab=_65252_/X }
C {devices/lab_pin.sym} 47620 -42140 0 0 {name=p46663 lab=_83282_/Q }
C {devices/lab_pin.sym} 47620 -42100 0 0 {name=p46664 lab=_65407_/X }
C {devices/lab_pin.sym} 47620 -42060 0 0 {name=p46665 lab=_65408_/X }
C {devices/lab_pin.sym} 47780 -42120 0 1 {name=p46666 lab=_65409_/X }
C {sky130_stdcells/a211o_4.sym} 47700 -42120 0 0 {name=X_65409_ }
C {devices/lab_pin.sym} 47610 -41970 0 0 {name=p46667 lab=_84458_/CLK }
C {devices/lab_pin.sym} 47610 -41950 0 0 {name=p46668 lab=_64472_/X }
C {devices/lab_pin.sym} 47790 -41970 0 1 {name=p46669 lab=_79649_/B }
C {sky130_stdcells/dfxtp_4.sym} 47700 -41960 0 0 {name=X_84243_ }
C {devices/lab_pin.sym} 47620 -41850 0 0 {name=p46670 lab=_50633_/Y }
C {devices/lab_pin.sym} 47620 -41810 0 0 {name=p46671 lab=_50619_/X }
C {devices/lab_pin.sym} 47620 -41770 0 0 {name=p46672 lab=_50634_/Y }
C {devices/lab_pin.sym} 47780 -41810 0 1 {name=p46673 lab=_86163_/D }
C {sky130_stdcells/a21boi_4.sym} 47700 -41810 0 0 {name=X_50635_ }
C {devices/lab_pin.sym} 47620 -41690 0 0 {name=p46674 lab=_57331_/A }
C {devices/lab_pin.sym} 47620 -41650 0 0 {name=p46675 lab=_57331_/C }
C {devices/lab_pin.sym} 47620 -41610 0 0 {name=p46676 lab=_57121_/X }
C {devices/lab_pin.sym} 47780 -41650 0 1 {name=p46677 lab=_57195_/A }
C {sky130_stdcells/a21o_4.sym} 47700 -41650 0 0 {name=X_57191_ }
C {devices/lab_pin.sym} 47610 -41510 0 0 {name=p46678 lab=_81333_/CLK }
C {devices/lab_pin.sym} 47610 -41490 0 0 {name=p46679 lab=_76771_/B }
C {devices/lab_pin.sym} 47790 -41510 0 1 {name=p46680 lab=_81423_/D }
C {sky130_stdcells/dfxtp_4.sym} 47700 -41500 0 0 {name=X_81455_ }
C {devices/lab_pin.sym} 47620 -41400 0 0 {name=p46681 lab=_88048_/Q }
C {devices/lab_pin.sym} 47620 -41360 0 0 {name=p46682 lab=_68975_/X }
C {devices/lab_pin.sym} 47620 -41320 0 0 {name=p46683 lab=_68976_/X }
C {devices/lab_pin.sym} 47620 -41280 0 0 {name=p46684 lab=_69176_/X }
C {devices/lab_pin.sym} 47780 -41340 0 1 {name=p46685 lab=_69177_/X }
C {sky130_stdcells/a211o_4.sym} 47700 -41340 0 0 {name=X_69177_ }
C {devices/lab_pin.sym} 47640 -41210 0 0 {name=p46686 lab=_66389_/A }
C {devices/lab_pin.sym} 47640 -41170 0 0 {name=p46687 lab=_66389_/B }
C {devices/lab_pin.sym} 47640 -41130 0 0 {name=p46688 lab=_66389_/C }
C {devices/lab_pin.sym} 47760 -41170 0 1 {name=p46689 lab=_66389_/Y }
C {sky130_stdcells/nor3_4.sym} 47700 -41170 0 0 {name=X_66389_ }
C {devices/lab_pin.sym} 47660 -41030 0 0 {name=p46690 lab=_56142_/A }
C {devices/lab_pin.sym} 47740 -41030 0 1 {name=p46691 lab=_56142_/X }
C {sky130_stdcells/buf_2.sym} 47700 -41030 0 0 {name=X_56142_ }
C {devices/lab_pin.sym} 47640 -40920 0 0 {name=p46692 lab=_80406_/A }
C {devices/lab_pin.sym} 47640 -40880 0 0 {name=p46693 lab=_80406_/B }
C {devices/lab_pin.sym} 47760 -40900 0 1 {name=p46694 lab=_80406_/X }
C {sky130_stdcells/and2_4.sym} 47700 -40900 0 0 {name=X_80406_ }
C {devices/lab_pin.sym} 47660 -40770 0 0 {name=p46695 lab=_68089_/A }
C {devices/lab_pin.sym} 47740 -40770 0 1 {name=p46696 lab=_68128_/X }
C {sky130_stdcells/buf_2.sym} 47700 -40770 0 0 {name=X_68128_ }
C {devices/lab_pin.sym} 47620 -40670 0 0 {name=p46697 lab=_85649_/Q }
C {devices/lab_pin.sym} 47620 -40630 0 0 {name=p46698 lab=_53351_/X }
C {devices/lab_pin.sym} 47620 -40590 0 0 {name=p46699 lab=_53353_/Y }
C {devices/lab_pin.sym} 47780 -40630 0 1 {name=p46700 lab=_53354_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -40630 0 0 {name=X_53354_ }
C {devices/lab_pin.sym} 47660 -40490 0 0 {name=p46701 lab=_71215_/Y }
C {devices/lab_pin.sym} 47740 -40490 0 1 {name=p46702 lab=_71216_/A }
C {sky130_stdcells/buf_8.sym} 47700 -40490 0 0 {name=Xpsn_inst_psn_buff_5 }
C {devices/lab_pin.sym} 47610 -40370 0 0 {name=p46703 lab=_85346_/CLK }
C {devices/lab_pin.sym} 47610 -40350 0 0 {name=p46704 lab=_84174_/D }
C {devices/lab_pin.sym} 47790 -40370 0 1 {name=p46705 lab=_84174_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -40360 0 0 {name=X_84174_ }
C {devices/lab_pin.sym} 47620 -40250 0 0 {name=p46706 lab=_86176_/Q }
C {devices/lab_pin.sym} 47620 -40210 0 0 {name=p46707 lab=_50563_/X }
C {devices/lab_pin.sym} 47620 -40170 0 0 {name=p46708 lab=_50565_/Y }
C {devices/lab_pin.sym} 47780 -40210 0 1 {name=p46709 lab=_50566_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -40210 0 0 {name=X_50566_ }
C {devices/lab_pin.sym} 47610 -40070 0 0 {name=p46710 lab=_81352_/CLK }
C {devices/lab_pin.sym} 47610 -40050 0 0 {name=p46711 lab=_83922_/Q }
C {devices/lab_pin.sym} 47790 -40070 0 1 {name=p46712 lab=_76864_/B }
C {sky130_stdcells/dfxtp_4.sym} 47700 -40060 0 0 {name=X_81386_ }
C {devices/lab_pin.sym} 47640 -39940 0 0 {name=p46713 lab=_52295_/A }
C {devices/lab_pin.sym} 47640 -39900 0 0 {name=p46714 lab=_48969_/A }
C {devices/lab_pin.sym} 47760 -39920 0 1 {name=p46715 lab=_52305_/X }
C {sky130_stdcells/and2_4.sym} 47700 -39920 0 0 {name=X_52305_ }
C {devices/lab_pin.sym} 47610 -39790 0 0 {name=p46716 lab=_83145_/CLK }
C {devices/lab_pin.sym} 47610 -39770 0 0 {name=p46717 lab=_74050_/Y }
C {devices/lab_pin.sym} 47790 -39790 0 1 {name=p46718 lab=_70110_/A }
C {sky130_stdcells/dfxtp_4.sym} 47700 -39780 0 0 {name=X_83125_ }
C {devices/lab_pin.sym} 47640 -39660 0 0 {name=p46719 lab=_56073_/A }
C {devices/lab_pin.sym} 47640 -39620 0 0 {name=p46720 lab=_55864_/X }
C {devices/lab_pin.sym} 47760 -39640 0 1 {name=p46721 lab=_56073_/Y }
C {sky130_stdcells/xnor2_4.sym} 47700 -39640 0 0 {name=X_56073_ }
C {devices/lab_pin.sym} 47640 -39520 0 0 {name=p46722 lab=_80334_/Y }
C {devices/lab_pin.sym} 47640 -39480 0 0 {name=p46723 lab=_80336_/Y }
C {devices/lab_pin.sym} 47760 -39500 0 1 {name=p46724 lab=_80337_/Y }
C {sky130_stdcells/nand2_4.sym} 47700 -39500 0 0 {name=X_80337_ }
C {devices/lab_pin.sym} 47660 -39370 0 0 {name=p46725 lab=_68059_/A }
C {devices/lab_pin.sym} 47740 -39370 0 1 {name=p46726 lab=_68059_/X }
C {sky130_stdcells/buf_2.sym} 47700 -39370 0 0 {name=X_68059_ }
C {devices/lab_pin.sym} 47620 -39270 0 0 {name=p46727 lab=_53281_/Y }
C {devices/lab_pin.sym} 47620 -39230 0 0 {name=p46728 lab=_53272_/X }
C {devices/lab_pin.sym} 47620 -39190 0 0 {name=p46729 lab=_53284_/X }
C {devices/lab_pin.sym} 47780 -39230 0 1 {name=p46730 lab=_53285_/Y }
C {sky130_stdcells/a21oi_4.sym} 47700 -39230 0 0 {name=X_53285_ }
C {devices/lab_pin.sym} 47640 -39110 0 0 {name=p46731 lab=_52204_/A }
C {devices/lab_pin.sym} 47640 -39070 0 0 {name=p46732 lab=_50526_/B }
C {devices/lab_pin.sym} 47640 -39030 0 0 {name=p46733 lab=_50497_/C }
C {devices/lab_pin.sym} 47760 -39070 0 1 {name=p46734 lab=_50497_/X }
C {sky130_stdcells/and3_4.sym} 47700 -39070 0 0 {name=X_50497_ }
C {devices/lab_pin.sym} 47660 -38930 0 0 {name=p46735 lab=_54253_/A }
C {devices/lab_pin.sym} 47740 -38930 0 1 {name=p46736 lab=_55024_/X }
C {sky130_stdcells/buf_2.sym} 47700 -38930 0 0 {name=X_55024_ }
C {devices/lab_pin.sym} 47640 -38830 0 0 {name=p46737 lab=_59901_/A }
C {devices/lab_pin.sym} 47640 -38790 0 0 {name=p46738 lab=_59705_/X }
C {devices/lab_pin.sym} 47640 -38750 0 0 {name=p46739 lab=_59901_/C }
C {devices/lab_pin.sym} 47760 -38790 0 1 {name=p46740 lab=_59901_/Y }
C {sky130_stdcells/nand3_4.sym} 47700 -38790 0 0 {name=X_59901_ }
C {devices/lab_pin.sym} 47620 -38670 0 0 {name=p46741 lab=_85862_/Q }
C {devices/lab_pin.sym} 47620 -38630 0 0 {name=p46742 lab=_52214_/X }
C {devices/lab_pin.sym} 47620 -38590 0 0 {name=p46743 lab=_52235_/Y }
C {devices/lab_pin.sym} 47780 -38630 0 1 {name=p46744 lab=_52236_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -38630 0 0 {name=X_52236_ }
C {devices/lab_pin.sym} 47660 -38490 0 0 {name=p46745 lab=_71070_/A }
C {devices/lab_pin.sym} 47740 -38490 0 1 {name=p46746 lab=_71070_/X }
C {sky130_stdcells/buf_2.sym} 47700 -38490 0 0 {name=X_71070_ }
C {devices/lab_pin.sym} 47610 -38370 0 0 {name=p46747 lab=_85571_/CLK }
C {devices/lab_pin.sym} 47610 -38350 0 0 {name=p46748 lab=_83056_/D }
C {devices/lab_pin.sym} 47790 -38370 0 1 {name=p46749 lab=_83056_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -38360 0 0 {name=X_83056_ }
C {devices/lab_pin.sym} 47610 -38230 0 0 {name=p46750 lab=_87421_/CLK }
C {devices/lab_pin.sym} 47610 -38210 0 0 {name=p46751 lab=_42300_/Y }
C {devices/lab_pin.sym} 47790 -38230 0 1 {name=p46752 lab=_87933_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -38220 0 0 {name=X_87933_ }
C {devices/lab_pin.sym} 47640 -38100 0 0 {name=p46753 lab=_80267_/Y }
C {devices/lab_pin.sym} 47640 -38060 0 0 {name=p46754 lab=_80268_/B }
C {devices/lab_pin.sym} 47760 -38080 0 1 {name=p46755 lab=_80268_/Y }
C {sky130_stdcells/nand2_4.sym} 47700 -38080 0 0 {name=X_80268_ }
C {devices/lab_pin.sym} 47640 -37970 0 0 {name=p46756 lab=_70021_/A }
C {devices/lab_pin.sym} 47640 -37930 0 0 {name=p46757 lab=_70020_/X }
C {devices/lab_pin.sym} 47640 -37890 0 0 {name=p46758 lab=_70021_/C }
C {devices/lab_pin.sym} 47760 -37930 0 1 {name=p46759 lab=_70021_/Y }
C {sky130_stdcells/nand3_4.sym} 47700 -37930 0 0 {name=X_70021_ }
C {devices/lab_pin.sym} 47610 -37790 0 0 {name=p46760 lab=_82008_/CLK }
C {devices/lab_pin.sym} 47610 -37770 0 0 {name=p46761 lab=_82007_/D }
C {devices/lab_pin.sym} 47790 -37790 0 1 {name=p46762 lab=_77157_/A }
C {sky130_stdcells/dfxtp_4.sym} 47700 -37780 0 0 {name=X_82007_ }
C {devices/lab_pin.sym} 47660 -37650 0 0 {name=p46763 lab=_59831_/X }
C {devices/lab_pin.sym} 47740 -37650 0 1 {name=p46764 lab=_59834_/A }
C {sky130_stdcells/buf_2.sym} 47700 -37650 0 0 {name=X_59832_ }
C {devices/lab_pin.sym} 47620 -37550 0 0 {name=p46765 lab=_52164_/Y }
C {devices/lab_pin.sym} 47620 -37510 0 0 {name=p46766 lab=_52145_/X }
C {devices/lab_pin.sym} 47620 -37470 0 0 {name=p46767 lab=_52166_/X }
C {devices/lab_pin.sym} 47780 -37510 0 1 {name=p46768 lab=_85876_/D }
C {sky130_stdcells/a21oi_4.sym} 47700 -37510 0 0 {name=X_52167_ }
C {devices/lab_pin.sym} 47610 -37370 0 0 {name=p46769 lab=_87865_/CLK }
C {devices/lab_pin.sym} 47610 -37350 0 0 {name=p46770 lab=_87864_/D }
C {devices/lab_pin.sym} 47790 -37370 0 1 {name=p46771 lab=_87864_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -37360 0 0 {name=X_87864_ }
C {devices/lab_pin.sym} 47620 -37260 0 0 {name=p46772 lab=_80173_/Y }
C {devices/lab_pin.sym} 47620 -37220 0 0 {name=p46773 lab=_80176_/Y }
C {devices/lab_pin.sym} 47620 -37180 0 0 {name=p46774 lab=_80184_/Y }
C {devices/lab_pin.sym} 47620 -37140 0 0 {name=p46775 lab=_80187_/Y }
C {devices/lab_pin.sym} 47780 -37200 0 1 {name=p46776 lab=_80199_/X }
C {sky130_stdcells/o22a_4.sym} 47700 -37200 0 0 {name=X_80199_ }
C {devices/lab_pin.sym} 47620 -37070 0 0 {name=p46777 lab=_86070_/Q }
C {devices/lab_pin.sym} 47620 -37030 0 0 {name=p46778 lab=_51101_/X }
C {devices/lab_pin.sym} 47620 -36990 0 0 {name=p46779 lab=_51117_/Y }
C {devices/lab_pin.sym} 47780 -37030 0 1 {name=p46780 lab=_51118_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -37030 0 0 {name=X_51118_ }
C {devices/lab_pin.sym} 47610 -36890 0 0 {name=p46781 lab=_81182_/CLK }
C {devices/lab_pin.sym} 47610 -36870 0 0 {name=p46782 lab=_86815_/D }
C {devices/lab_pin.sym} 47790 -36890 0 1 {name=p46783 lab=_67133_/B }
C {sky130_stdcells/dfxtp_4.sym} 47700 -36880 0 0 {name=X_86815_ }
C {devices/lab_pin.sym} 47640 -36770 0 0 {name=p46784 lab=_59763_/A }
C {devices/lab_pin.sym} 47640 -36730 0 0 {name=p46785 lab=_59716_/A }
C {devices/lab_pin.sym} 47640 -36690 0 0 {name=p46786 lab=_59716_/B }
C {devices/lab_pin.sym} 47760 -36730 0 1 {name=p46787 lab=_59763_/X }
C {sky130_stdcells/and3_4.sym} 47700 -36730 0 0 {name=X_59763_ }
C {devices/lab_pin.sym} 47640 -36610 0 0 {name=p46788 lab=_53620_/A }
C {devices/lab_pin.sym} 47640 -36570 0 0 {name=p46789 lab=_52098_/B }
C {devices/lab_pin.sym} 47640 -36530 0 0 {name=p46790 lab=_52097_/X }
C {devices/lab_pin.sym} 47760 -36570 0 1 {name=p46791 lab=_52098_/X }
C {sky130_stdcells/and3_4.sym} 47700 -36570 0 0 {name=X_52098_ }
C {devices/lab_pin.sym} 47640 -36450 0 0 {name=p46792 lab=_57193_/D }
C {devices/lab_pin.sym} 47640 -36410 0 0 {name=p46793 lab=_56922_/X }
C {devices/lab_pin.sym} 47640 -36370 0 0 {name=p46794 lab=_83329_/Q }
C {devices/lab_pin.sym} 47760 -36410 0 1 {name=p46795 lab=_56975_/Y }
C {sky130_stdcells/nor3_4.sym} 47700 -36410 0 0 {name=X_56975_ }
C {devices/lab_pin.sym} 47610 -36270 0 0 {name=p46796 lab=_88084_/CLK }
C {devices/lab_pin.sym} 47610 -36250 0 0 {name=p46797 lab=_42635_/X }
C {devices/lab_pin.sym} 47790 -36270 0 1 {name=p46798 lab=_87795_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -36260 0 0 {name=X_87795_ }
C {devices/lab_pin.sym} 47660 -36130 0 0 {name=p46799 lab=_58846_/A }
C {devices/lab_pin.sym} 47740 -36130 0 1 {name=p46800 lab=_58714_/X }
C {sky130_stdcells/buf_2.sym} 47700 -36130 0 0 {name=X_58714_ }
C {devices/lab_pin.sym} 47640 -36020 0 0 {name=p46801 lab=_51058_/A }
C {devices/lab_pin.sym} 47640 -35980 0 0 {name=p46802 lab=_46899_/X }
C {devices/lab_pin.sym} 47760 -36000 0 1 {name=p46803 lab=_51049_/Y }
C {sky130_stdcells/nand2_4.sym} 47700 -36000 0 0 {name=X_51049_ }
C {devices/lab_pin.sym} 47640 -35880 0 0 {name=p46804 lab=_55926_/A }
C {devices/lab_pin.sym} 47640 -35840 0 0 {name=p46805 lab=_55926_/B }
C {devices/lab_pin.sym} 47760 -35860 0 1 {name=p46806 lab=_55926_/X }
C {sky130_stdcells/and2_4.sym} 47700 -35860 0 0 {name=X_55926_ }
C {devices/lab_pin.sym} 47660 -35730 0 0 {name=p46807 lab=_43605_/A }
C {devices/lab_pin.sym} 47740 -35730 0 1 {name=p46808 lab=_45964_/A }
C {sky130_stdcells/buf_2.sym} 47700 -35730 0 0 {name=X_43940_ }
C {devices/lab_pin.sym} 47640 -35640 0 0 {name=p46809 lab=_74760_/A }
C {devices/lab_pin.sym} 47640 -35600 0 0 {name=p46810 lab=_74720_/C }
C {devices/lab_pin.sym} 47640 -35560 0 0 {name=p46811 lab=_74804_/D }
C {devices/lab_pin.sym} 47640 -35520 0 0 {name=p46812 lab=_74780_/D }
C {devices/lab_pin.sym} 47760 -35580 0 1 {name=p46813 lab=_74760_/Y }
C {sky130_stdcells/nand4_4.sym} 47700 -35580 0 0 {name=X_74760_ }
C {devices/lab_pin.sym} 47610 -35430 0 0 {name=p46814 lab=_85818_/CLK }
C {devices/lab_pin.sym} 47610 -35410 0 0 {name=p46815 lab=_86746_/D }
C {devices/lab_pin.sym} 47790 -35430 0 1 {name=p46816 lab=_86746_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -35420 0 0 {name=X_86746_ }
C {devices/lab_pin.sym} 47640 -35300 0 0 {name=p46817 lab=_71972_/A }
C {devices/lab_pin.sym} 47640 -35260 0 0 {name=p46818 lab=_71972_/B }
C {devices/lab_pin.sym} 47760 -35280 0 1 {name=p46819 lab=_71972_/Y }
C {sky130_stdcells/nand2_4.sym} 47700 -35280 0 0 {name=X_71972_ }
C {devices/lab_pin.sym} 47610 -35150 0 0 {name=p46820 lab=_80821_/CLK }
C {devices/lab_pin.sym} 47610 -35130 0 0 {name=p46821 lab=_68857_/X }
C {devices/lab_pin.sym} 47790 -35150 0 1 {name=p46822 lab=_83958_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -35140 0 0 {name=X_83958_ }
C {devices/lab_pin.sym} 47660 -35010 0 0 {name=p46823 lab=_62185_/B }
C {devices/lab_pin.sym} 47740 -35010 0 1 {name=p46824 lab=_62183_/A }
C {sky130_stdcells/buf_2.sym} 47700 -35010 0 0 {name=X_59694_ }
C {devices/lab_pin.sym} 47640 -34900 0 0 {name=p46825 lab=_73711_/A }
C {devices/lab_pin.sym} 47640 -34860 0 0 {name=p46826 lab=_73711_/B }
C {devices/lab_pin.sym} 47760 -34880 0 1 {name=p46827 lab=_73711_/X }
C {sky130_stdcells/and2_4.sym} 47700 -34880 0 0 {name=X_73711_ }
C {devices/lab_pin.sym} 47620 -34770 0 0 {name=p46828 lab=_58112_/X }
C {devices/lab_pin.sym} 47620 -34730 0 0 {name=p46829 lab=_86107_/Q }
C {devices/lab_pin.sym} 47620 -34690 0 0 {name=p46830 lab=_58644_/X }
C {devices/lab_pin.sym} 47780 -34730 0 1 {name=p46831 lab=_58645_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -34730 0 0 {name=X_58645_ }
C {devices/lab_pin.sym} 47640 -34620 0 0 {name=p46832 lab=_70871_/A }
C {devices/lab_pin.sym} 47640 -34580 0 0 {name=p46833 lab=_70914_/B }
C {devices/lab_pin.sym} 47640 -34540 0 0 {name=p46834 lab=_70914_/C }
C {devices/lab_pin.sym} 47640 -34500 0 0 {name=p46835 lab=_70919_/D }
C {devices/lab_pin.sym} 47760 -34560 0 1 {name=p46836 lab=_70923_/Y }
C {sky130_stdcells/nand4_4.sym} 47700 -34560 0 0 {name=X_70923_ }
C {devices/lab_pin.sym} 47610 -34410 0 0 {name=p46837 lab=_87416_/CLK }
C {devices/lab_pin.sym} 47610 -34390 0 0 {name=p46838 lab=_78278_/B }
C {devices/lab_pin.sym} 47790 -34410 0 1 {name=p46839 lab=_82909_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -34400 0 0 {name=X_82909_ }
C {devices/lab_pin.sym} 47620 -34300 0 0 {name=p46840 lab=_41250_/X }
C {devices/lab_pin.sym} 47620 -34260 0 0 {name=p46841 lab=_43868_/X }
C {devices/lab_pin.sym} 47620 -34220 0 0 {name=p46842 lab=_68980_/B }
C {devices/lab_pin.sym} 47620 -34180 0 0 {name=p46843 lab=_43870_/X }
C {devices/lab_pin.sym} 47780 -34240 0 1 {name=p46844 lab=_43871_/X }
C {sky130_stdcells/a2bb2o_4.sym} 47700 -34240 0 0 {name=X_43871_ }
C {devices/lab_pin.sym} 47640 -34100 0 0 {name=p46845 lab=_44079_/X }
C {devices/lab_pin.sym} 47640 -34060 0 0 {name=p46846 lab=_55857_/B }
C {devices/lab_pin.sym} 47760 -34080 0 1 {name=p46847 lab=_55857_/X }
C {sky130_stdcells/and2_4.sym} 47700 -34080 0 0 {name=X_55857_ }
C {devices/lab_pin.sym} 47640 -33960 0 0 {name=p46848 lab=_74691_/A }
C {devices/lab_pin.sym} 47640 -33920 0 0 {name=p46849 lab=_74691_/B }
C {devices/lab_pin.sym} 47760 -33940 0 1 {name=p46850 lab=_74691_/Y }
C {sky130_stdcells/nand2_4.sym} 47700 -33940 0 0 {name=X_74691_ }
C {devices/lab_pin.sym} 47610 -33810 0 0 {name=p46851 lab=_86359_/CLK }
C {devices/lab_pin.sym} 47610 -33790 0 0 {name=p46852 lab=_86677_/D }
C {devices/lab_pin.sym} 47790 -33810 0 1 {name=p46853 lab=_86677_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -33800 0 0 {name=X_86677_ }
C {devices/lab_pin.sym} 47610 -33670 0 0 {name=p46854 lab=_82339_/CLK }
C {devices/lab_pin.sym} 47610 -33650 0 0 {name=p46855 lab=_83889_/D }
C {devices/lab_pin.sym} 47790 -33670 0 1 {name=p46856 lab=_83889_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -33660 0 0 {name=X_83889_ }
C {devices/lab_pin.sym} 47620 -33550 0 0 {name=p46857 lab=_45603_/X }
C {devices/lab_pin.sym} 47620 -33510 0 0 {name=p46858 lab=_45606_/X }
C {devices/lab_pin.sym} 47620 -33470 0 0 {name=p46859 lab=_45609_/Y }
C {devices/lab_pin.sym} 47780 -33510 0 1 {name=p46860 lab=_86866_/D }
C {sky130_stdcells/a21oi_4.sym} 47700 -33510 0 0 {name=X_45610_ }
C {devices/lab_pin.sym} 47640 -33390 0 0 {name=p46861 lab=_76430_/A }
C {devices/lab_pin.sym} 47640 -33350 0 0 {name=p46862 lab=_76430_/B }
C {devices/lab_pin.sym} 47640 -33310 0 0 {name=p46863 lab=_76430_/C }
C {devices/lab_pin.sym} 47760 -33350 0 1 {name=p46864 lab=_76430_/X }
C {sky130_stdcells/or3_4.sym} 47700 -33350 0 0 {name=X_76430_ }
C {devices/lab_pin.sym} 47660 -33210 0 0 {name=p46865 lab=_42822_/A }
C {devices/lab_pin.sym} 47740 -33210 0 1 {name=p46866 lab=_42822_/X }
C {sky130_stdcells/buf_2.sym} 47700 -33210 0 0 {name=X_42822_ }
C {devices/lab_pin.sym} 47660 -33090 0 0 {name=p46867 lab=_54400_/A }
C {devices/lab_pin.sym} 47740 -33090 0 1 {name=p46868 lab=_54889_/A }
C {sky130_stdcells/buf_2.sym} 47700 -33090 0 0 {name=X_54808_ }
C {devices/lab_pin.sym} 47620 -33000 0 0 {name=p46869 lab=_72829_/X }
C {devices/lab_pin.sym} 47620 -32960 0 0 {name=p46870 lab=_84990_/Q }
C {devices/lab_pin.sym} 47620 -32920 0 0 {name=p46871 lab=_73614_/X }
C {devices/lab_pin.sym} 47620 -32880 0 0 {name=p46872 lab=_73641_/X }
C {devices/lab_pin.sym} 47780 -32940 0 1 {name=p46873 lab=_73642_/X }
C {sky130_stdcells/a211o_4.sym} 47700 -32940 0 0 {name=X_73642_ }
C {devices/lab_pin.sym} 47610 -32790 0 0 {name=p46874 lab=_86237_/CLK }
C {devices/lab_pin.sym} 47610 -32770 0 0 {name=p46875 lab=_53485_/Y }
C {devices/lab_pin.sym} 47790 -32790 0 1 {name=p46876 lab=_85628_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -32780 0 0 {name=X_85628_ }
C {devices/lab_pin.sym} 47620 -32670 0 0 {name=p46877 lab=_46578_/X }
C {devices/lab_pin.sym} 47620 -32630 0 0 {name=p46878 lab=_49190_/A }
C {devices/lab_pin.sym} 47620 -32590 0 0 {name=p46879 lab=_46589_/X }
C {devices/lab_pin.sym} 47780 -32630 0 1 {name=p46880 lab=_46591_/A }
C {sky130_stdcells/o21ai_4.sym} 47700 -32630 0 0 {name=X_46590_ }
C {devices/lab_pin.sym} 47640 -32500 0 0 {name=p46881 lab=_58576_/A }
C {devices/lab_pin.sym} 47640 -32460 0 0 {name=p46882 lab=_58576_/B }
C {devices/lab_pin.sym} 47760 -32480 0 1 {name=p46883 lab=_58576_/Y }
C {sky130_stdcells/nor2_4.sym} 47700 -32480 0 0 {name=X_58576_ }
C {devices/lab_pin.sym} 47640 -32360 0 0 {name=p46884 lab=_70854_/A }
C {devices/lab_pin.sym} 47640 -32320 0 0 {name=p46885 lab=_70698_/A }
C {devices/lab_pin.sym} 47760 -32340 0 1 {name=p46886 lab=_70855_/A }
C {sky130_stdcells/nor2_4.sym} 47700 -32340 0 0 {name=X_70854_ }
C {devices/lab_pin.sym} 47640 -32220 0 0 {name=p46887 lab=_55761_/A }
C {devices/lab_pin.sym} 47640 -32180 0 0 {name=p46888 lab=_85291_/Q }
C {devices/lab_pin.sym} 47760 -32200 0 1 {name=p46889 lab=_55788_/X }
C {sky130_stdcells/and2_4.sym} 47700 -32200 0 0 {name=X_55788_ }
C {devices/lab_pin.sym} 47660 -32070 0 0 {name=p46890 lab=_46542_/X }
C {devices/lab_pin.sym} 47740 -32070 0 1 {name=p46891 lab=_57527_/X }
C {sky130_stdcells/buf_2.sym} 47700 -32070 0 0 {name=X_57527_ }
C {devices/lab_pin.sym} 47640 -31960 0 0 {name=p46892 lab=_83000_/Q }
C {devices/lab_pin.sym} 47640 -31920 0 0 {name=p46893 lab=_45604_/B }
C {devices/lab_pin.sym} 47760 -31940 0 1 {name=p46894 lab=_45541_/Y }
C {sky130_stdcells/nor2_4.sym} 47700 -31940 0 0 {name=X_45541_ }
C {devices/lab_pin.sym} 47620 -31830 0 0 {name=p46895 lab=_76324_/Y }
C {devices/lab_pin.sym} 47620 -31790 0 0 {name=p46896 lab=_76356_/Y }
C {devices/lab_pin.sym} 47620 -31750 0 0 {name=p46897 lab=_76360_/Y }
C {devices/lab_pin.sym} 47780 -31790 0 1 {name=p46898 lab=_76361_/Y }
C {sky130_stdcells/a21oi_4.sym} 47700 -31790 0 0 {name=X_76361_ }
C {devices/lab_pin.sym} 47610 -31650 0 0 {name=p46899 lab=_87859_/CLK }
C {devices/lab_pin.sym} 47610 -31630 0 0 {name=p46900 lab=_40726_/Y }
C {devices/lab_pin.sym} 47790 -31650 0 1 {name=p46901 lab=_88347_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -31640 0 0 {name=X_88347_ }
C {devices/lab_pin.sym} 47620 -31540 0 0 {name=p46902 lab=_41250_/X }
C {devices/lab_pin.sym} 47620 -31500 0 0 {name=p46903 lab=_42745_/X }
C {devices/lab_pin.sym} 47620 -31460 0 0 {name=p46904 lab=_68977_/B }
C {devices/lab_pin.sym} 47620 -31420 0 0 {name=p46905 lab=_42746_/X }
C {devices/lab_pin.sym} 47780 -31480 0 1 {name=p46906 lab=_42753_/X }
C {sky130_stdcells/a2bb2o_4.sym} 47700 -31480 0 0 {name=X_42753_ }
C {devices/lab_pin.sym} 47640 -31360 0 0 {name=p46907 lab=_54748_/A }
C {devices/lab_pin.sym} 47640 -31320 0 0 {name=p46908 lab=_54755_/B }
C {devices/lab_pin.sym} 47640 -31280 0 0 {name=p46909 lab=_54748_/C }
C {devices/lab_pin.sym} 47640 -31240 0 0 {name=p46910 lab=_54739_/D }
C {devices/lab_pin.sym} 47760 -31300 0 1 {name=p46911 lab=_54739_/X }
C {sky130_stdcells/and4_4.sym} 47700 -31300 0 0 {name=X_54739_ }
C {devices/lab_pin.sym} 47640 -31160 0 0 {name=p46912 lab=_74117_/A }
C {devices/lab_pin.sym} 47640 -31120 0 0 {name=p46913 lab=_73572_/Y }
C {devices/lab_pin.sym} 47760 -31140 0 1 {name=p46914 lab=_73573_/Y }
C {sky130_stdcells/nor2_4.sym} 47700 -31140 0 0 {name=X_73573_ }
C {devices/lab_pin.sym} 47610 -31010 0 0 {name=p46915 lab=_83305_/CLK }
C {devices/lab_pin.sym} 47610 -30990 0 0 {name=p46916 lab=_53835_/Y }
C {devices/lab_pin.sym} 47790 -31010 0 1 {name=p46917 lab=_85559_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -31000 0 0 {name=X_85559_ }
C {devices/lab_pin.sym} 47620 -30890 0 0 {name=p46918 lab=_52859_/B }
C {devices/lab_pin.sym} 47620 -30850 0 0 {name=p46919 lab=_70761_/X }
C {devices/lab_pin.sym} 47620 -30810 0 0 {name=p46920 lab=_70784_/Y }
C {devices/lab_pin.sym} 47780 -30850 0 1 {name=p46921 lab=_70785_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -30850 0 0 {name=X_70785_ }
C {devices/lab_pin.sym} 47640 -30720 0 0 {name=p46922 lab=_78100_/A }
C {devices/lab_pin.sym} 47640 -30680 0 0 {name=p46923 lab=_78099_/Y }
C {devices/lab_pin.sym} 47760 -30700 0 1 {name=p46924 lab=_78101_/B }
C {sky130_stdcells/xor2_4.sym} 47700 -30700 0 0 {name=X_78100_ }
C {devices/lab_pin.sym} 47640 -30580 0 0 {name=p46925 lab=_80690_/Q }
C {devices/lab_pin.sym} 47640 -30540 0 0 {name=p46926 lab=_80990_/Q }
C {devices/lab_pin.sym} 47760 -30560 0 1 {name=p46927 lab=_75312_/Y }
C {sky130_stdcells/nand2_4.sym} 47700 -30560 0 0 {name=X_75312_ }
C {devices/lab_pin.sym} 47620 -30450 0 0 {name=p46928 lab=_41603_/X }
C {devices/lab_pin.sym} 47620 -30410 0 0 {name=p46929 lab=_82899_/Q }
C {devices/lab_pin.sym} 47620 -30370 0 0 {name=p46930 lab=_41703_/X }
C {devices/lab_pin.sym} 47780 -30410 0 1 {name=p46931 lab=_41704_/X }
C {sky130_stdcells/o21a_4.sym} 47700 -30410 0 0 {name=X_41704_ }
C {devices/lab_pin.sym} 47620 -30290 0 0 {name=p46932 lab=_86546_/Q }
C {devices/lab_pin.sym} 47620 -30250 0 0 {name=p46933 lab=_48188_/X }
C {devices/lab_pin.sym} 47620 -30210 0 0 {name=p46934 lab=_48259_/Y }
C {devices/lab_pin.sym} 47780 -30250 0 1 {name=p46935 lab=_48260_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -30250 0 0 {name=X_48260_ }
C {devices/lab_pin.sym} 47660 -30110 0 0 {name=p46936 lab=_72602_/A }
C {devices/lab_pin.sym} 47740 -30110 0 1 {name=p46937 lab=_72525_/A }
C {sky130_stdcells/buf_2.sym} 47700 -30110 0 0 {name=X_72524_ }
C {devices/lab_pin.sym} 47660 -29990 0 0 {name=p46938 lab=_79080_/A }
C {devices/lab_pin.sym} 47740 -29990 0 1 {name=p46939 lab=_82623_/D }
C {sky130_stdcells/inv_2.sym} 47700 -29990 0 0 {name=X_79080_ }
C {devices/lab_pin.sym} 47640 -29880 0 0 {name=p46940 lab=_85116_/Q }
C {devices/lab_pin.sym} 47640 -29840 0 0 {name=p46941 lab=_45456_/X }
C {devices/lab_pin.sym} 47760 -29860 0 1 {name=p46942 lab=_45472_/Y }
C {sky130_stdcells/nor2_4.sym} 47700 -29860 0 0 {name=X_45472_ }
C {devices/lab_pin.sym} 47640 -29740 0 0 {name=p46943 lab=_55248_/B }
C {devices/lab_pin.sym} 47640 -29700 0 0 {name=p46944 lab=_57463_/B }
C {devices/lab_pin.sym} 47760 -29720 0 1 {name=p46945 lab=_57458_/X }
C {sky130_stdcells/or2_4.sym} 47700 -29720 0 0 {name=X_57458_ }
C {devices/lab_pin.sym} 47660 -29590 0 0 {name=p46946 lab=_76291_/X }
C {devices/lab_pin.sym} 47740 -29590 0 1 {name=p46947 lab=_76296_/A }
C {sky130_stdcells/inv_2.sym} 47700 -29590 0 0 {name=X_76292_ }
C {devices/lab_pin.sym} 47620 -29500 0 0 {name=p46948 lab=_41070_/X }
C {devices/lab_pin.sym} 47620 -29460 0 0 {name=p46949 lab=_42679_/X }
C {devices/lab_pin.sym} 47620 -29420 0 0 {name=p46950 lab=_69466_/B }
C {devices/lab_pin.sym} 47620 -29380 0 0 {name=p46951 lab=_42681_/X }
C {devices/lab_pin.sym} 47780 -29440 0 1 {name=p46952 lab=_42684_/X }
C {sky130_stdcells/a2bb2o_4.sym} 47700 -29440 0 0 {name=X_42684_ }
C {devices/lab_pin.sym} 47610 -29290 0 0 {name=p46953 lab=_82301_/CLK }
C {devices/lab_pin.sym} 47610 -29270 0 0 {name=p46954 lab=_88278_/D }
C {devices/lab_pin.sym} 47790 -29290 0 1 {name=p46955 lab=_69536_/B }
C {sky130_stdcells/dfxtp_4.sym} 47700 -29280 0 0 {name=X_88278_ }
C {devices/lab_pin.sym} 47620 -29170 0 0 {name=p46956 lab=_47207_/Y }
C {devices/lab_pin.sym} 47620 -29130 0 0 {name=p46957 lab=_47177_/X }
C {devices/lab_pin.sym} 47620 -29090 0 0 {name=p46958 lab=_47210_/X }
C {devices/lab_pin.sym} 47780 -29130 0 1 {name=p46959 lab=_47211_/Y }
C {sky130_stdcells/a21oi_4.sym} 47700 -29130 0 0 {name=X_47211_ }
C {devices/lab_pin.sym} 47640 -29000 0 0 {name=p46960 lab=_78031_/A }
C {devices/lab_pin.sym} 47640 -28960 0 0 {name=p46961 lab=_78031_/B }
C {devices/lab_pin.sym} 47760 -28980 0 1 {name=p46962 lab=_78033_/A }
C {sky130_stdcells/nand2_4.sym} 47700 -28980 0 0 {name=X_78031_ }
C {devices/lab_pin.sym} 47660 -28850 0 0 {name=p46963 lab=_44422_/Y }
C {devices/lab_pin.sym} 47740 -28850 0 1 {name=p46964 lab=_87115_/D }
C {sky130_stdcells/inv_2.sym} 47700 -28850 0 0 {name=X_44423_ }
C {devices/lab_pin.sym} 47660 -28730 0 0 {name=p46965 lab=_56439_/A }
C {devices/lab_pin.sym} 47740 -28730 0 1 {name=p46966 lab=_56409_/X }
C {sky130_stdcells/buf_2.sym} 47700 -28730 0 0 {name=X_56409_ }
C {devices/lab_pin.sym} 47660 -28610 0 0 {name=p46967 lab=_75243_/A }
C {devices/lab_pin.sym} 47740 -28610 0 1 {name=p46968 lab=_75243_/Y }
C {sky130_stdcells/inv_2.sym} 47700 -28610 0 0 {name=X_75243_ }
C {devices/lab_pin.sym} 47620 -28510 0 0 {name=p46969 lab=_41577_/X }
C {devices/lab_pin.sym} 47620 -28470 0 0 {name=p46970 lab=_82912_/Q }
C {devices/lab_pin.sym} 47620 -28430 0 0 {name=p46971 lab=_41634_/X }
C {devices/lab_pin.sym} 47780 -28470 0 1 {name=p46972 lab=_41635_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -28470 0 0 {name=X_41635_ }
C {devices/lab_pin.sym} 47610 -28330 0 0 {name=p46973 lab=_87235_/CLK }
C {devices/lab_pin.sym} 47610 -28310 0 0 {name=p46974 lab=_43861_/X }
C {devices/lab_pin.sym} 47790 -28330 0 1 {name=p46975 lab=_68920_/B }
C {sky130_stdcells/dfxtp_4.sym} 47700 -28320 0 0 {name=X_87229_ }
C {devices/lab_pin.sym} 47620 -28210 0 0 {name=p46976 lab=_86558_/Q }
C {devices/lab_pin.sym} 47620 -28170 0 0 {name=p46977 lab=_48188_/X }
C {devices/lab_pin.sym} 47620 -28130 0 0 {name=p46978 lab=_48190_/Y }
C {devices/lab_pin.sym} 47780 -28170 0 1 {name=p46979 lab=_48191_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -28170 0 0 {name=X_48191_ }
C {devices/lab_pin.sym} 47660 -28030 0 0 {name=p46980 lab=_83252_/Q }
C {devices/lab_pin.sym} 47740 -28030 0 1 {name=p46981 lab=_79549_/B }
C {sky130_stdcells/inv_2.sym} 47700 -28030 0 0 {name=X_72455_ }
C {devices/lab_pin.sym} 47620 -27940 0 0 {name=p46982 lab=_57384_/X }
C {devices/lab_pin.sym} 47620 -27900 0 0 {name=p46983 lab=_56584_/X }
C {devices/lab_pin.sym} 47620 -27860 0 0 {name=p46984 lab=_85021_/Q }
C {devices/lab_pin.sym} 47620 -27820 0 0 {name=p46985 lab=_57385_/X }
C {devices/lab_pin.sym} 47780 -27880 0 1 {name=p46986 lab=_57389_/X }
C {sky130_stdcells/a2bb2o_4.sym} 47700 -27880 0 0 {name=X_57389_ }
C {devices/lab_pin.sym} 47660 -27730 0 0 {name=p46987 lab=_54571_/D }
C {devices/lab_pin.sym} 47740 -27730 0 1 {name=p46988 lab=_52879_/D }
C {sky130_stdcells/buf_2.sym} 47700 -27730 0 0 {name=X_47142_ }
C {devices/lab_pin.sym} 47620 -27640 0 0 {name=p46989 lab=_84767_/Q }
C {devices/lab_pin.sym} 47620 -27600 0 0 {name=p46990 lab=_59043_/X }
C {devices/lab_pin.sym} 47620 -27560 0 0 {name=p46991 lab=_59120_/X }
C {devices/lab_pin.sym} 47620 -27520 0 0 {name=p46992 lab=_59127_/X }
C {devices/lab_pin.sym} 47780 -27580 0 1 {name=p46993 lab=_59128_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 47700 -27580 0 0 {name=X_59128_ }
C {devices/lab_pin.sym} 47640 -27450 0 0 {name=p46994 lab=_70679_/A }
C {devices/lab_pin.sym} 47640 -27410 0 0 {name=p46995 lab=_71404_/B }
C {devices/lab_pin.sym} 47640 -27370 0 0 {name=p46996 lab=_71411_/C }
C {devices/lab_pin.sym} 47760 -27410 0 1 {name=p46997 lab=_71406_/Y }
C {sky130_stdcells/nor3_4.sym} 47700 -27410 0 0 {name=X_71406_ }
C {devices/lab_pin.sym} 47620 -27310 0 0 {name=p46998 lab=_44350_/X }
C {devices/lab_pin.sym} 47620 -27270 0 0 {name=p46999 lab=_44351_/X }
C {devices/lab_pin.sym} 47620 -27230 0 0 {name=p47000 lab=_41710_/X }
C {devices/lab_pin.sym} 47620 -27190 0 0 {name=p47001 lab=_87152_/Q }
C {devices/lab_pin.sym} 47620 -27150 0 0 {name=p47002 lab=_44353_/X }
C {devices/lab_pin.sym} 47780 -27230 0 1 {name=p47003 lab=_44355_/A }
C {sky130_stdcells/o32ai_4.sym} 47700 -27230 0 0 {name=X_44354_ }
C {devices/lab_pin.sym} 47660 -27070 0 0 {name=p47004 lab=_75169_/Y }
C {devices/lab_pin.sym} 47740 -27070 0 1 {name=p47005 lab=_75175_/A }
C {sky130_stdcells/inv_2.sym} 47700 -27070 0 0 {name=X_75174_ }
C {devices/lab_pin.sym} 47620 -26990 0 0 {name=p47006 lab=_41540_/X }
C {devices/lab_pin.sym} 47620 -26950 0 0 {name=p47007 lab=_41541_/X }
C {devices/lab_pin.sym} 47620 -26910 0 0 {name=p47008 lab=_41565_/X }
C {devices/lab_pin.sym} 47620 -26870 0 0 {name=p47009 lab=_67052_/B }
C {devices/lab_pin.sym} 47620 -26830 0 0 {name=p47010 lab=_41537_/X }
C {devices/lab_pin.sym} 47780 -26910 0 1 {name=p47011 lab=_41567_/A }
C {sky130_stdcells/o32ai_4.sym} 47700 -26910 0 0 {name=X_41566_ }
C {devices/lab_pin.sym} 47660 -26750 0 0 {name=p47012 lab=_72255_/A }
C {devices/lab_pin.sym} 47740 -26750 0 1 {name=p47013 lab=_72386_/X }
C {sky130_stdcells/buf_2.sym} 47700 -26750 0 0 {name=X_72386_ }
C {devices/lab_pin.sym} 47660 -26630 0 0 {name=p47014 lab=_43305_/A }
C {devices/lab_pin.sym} 47740 -26630 0 1 {name=p47015 lab=_43305_/X }
C {sky130_stdcells/buf_2.sym} 47700 -26630 0 0 {name=X_43305_ }
C {devices/lab_pin.sym} 47620 -26530 0 0 {name=p47016 lab=_74122_/X }
C {devices/lab_pin.sym} 47620 -26490 0 0 {name=p47017 lab=_74124_/X }
C {devices/lab_pin.sym} 47620 -26450 0 0 {name=p47018 lab=_72737_/A }
C {devices/lab_pin.sym} 47780 -26490 0 1 {name=p47019 lab=_74125_/X }
C {sky130_stdcells/a21o_4.sym} 47700 -26490 0 0 {name=X_74125_ }
C {devices/lab_pin.sym} 47660 -26350 0 0 {name=p47020 lab=_40516_/Y }
C {devices/lab_pin.sym} 47740 -26350 0 1 {name=p47021 lab=_88379_/D }
C {sky130_stdcells/inv_2.sym} 47700 -26350 0 0 {name=X_40517_ }
C {devices/lab_pin.sym} 47660 -26230 0 0 {name=p47022 lab=_82385_/Q }
C {devices/lab_pin.sym} 47740 -26230 0 1 {name=p47023 lab=_47074_/A }
C {sky130_stdcells/inv_2.sym} 47700 -26230 0 0 {name=X_47073_ }
C {devices/lab_pin.sym} 47620 -26130 0 0 {name=p47024 lab=_59048_/X }
C {devices/lab_pin.sym} 47620 -26090 0 0 {name=p47025 lab=_85660_/Q }
C {devices/lab_pin.sym} 47620 -26050 0 0 {name=p47026 lab=_59010_/X }
C {devices/lab_pin.sym} 47780 -26090 0 1 {name=p47027 lab=_59059_/X }
C {sky130_stdcells/o21a_4.sym} 47700 -26090 0 0 {name=X_59059_ }
C {devices/lab_pin.sym} 47660 -25950 0 0 {name=p47028 lab=_71337_/A }
C {devices/lab_pin.sym} 47740 -25950 0 1 {name=p47029 lab=_71338_/A }
C {sky130_stdcells/buf_2.sym} 47700 -25950 0 0 {name=X_71337_ }
C {devices/lab_pin.sym} 47640 -25850 0 0 {name=p47030 lab=_45950_/A }
C {devices/lab_pin.sym} 47640 -25810 0 0 {name=p47031 lab=_44268_/A }
C {devices/lab_pin.sym} 47640 -25770 0 0 {name=p47032 lab=_44210_/X }
C {devices/lab_pin.sym} 47760 -25810 0 1 {name=p47033 lab=_44285_/Y }
C {sky130_stdcells/nor3_4.sym} 47700 -25810 0 0 {name=X_44285_ }
C {devices/lab_pin.sym} 47640 -25680 0 0 {name=p47034 lab=_79982_/A }
C {devices/lab_pin.sym} 47640 -25640 0 0 {name=p47035 lab=_79981_/Y }
C {devices/lab_pin.sym} 47760 -25660 0 1 {name=p47036 lab=_79982_/X }
C {sky130_stdcells/xor2_4.sym} 47700 -25660 0 0 {name=X_79982_ }
C {devices/lab_pin.sym} 47620 -25550 0 0 {name=p47037 lab=_41344_/X }
C {devices/lab_pin.sym} 47620 -25510 0 0 {name=p47038 lab=_40402_/B }
C {devices/lab_pin.sym} 47620 -25470 0 0 {name=p47039 lab=_41496_/X }
C {devices/lab_pin.sym} 47780 -25510 0 1 {name=p47040 lab=_41497_/X }
C {sky130_stdcells/o21a_4.sym} 47700 -25510 0 0 {name=X_41497_ }
C {devices/lab_pin.sym} 47620 -25400 0 0 {name=p47041 lab=_40537_/Y }
C {devices/lab_pin.sym} 47620 -25360 0 0 {name=p47042 lab=_46022_/X }
C {devices/lab_pin.sym} 47620 -25320 0 0 {name=p47043 lab=_86809_/Q }
C {devices/lab_pin.sym} 47620 -25280 0 0 {name=p47044 lab=_46023_/X }
C {devices/lab_pin.sym} 47780 -25340 0 1 {name=p47045 lab=_86809_/D }
C {sky130_stdcells/a2bb2o_4.sym} 47700 -25340 0 0 {name=X_46024_ }
C {devices/lab_pin.sym} 47660 -25190 0 0 {name=p47046 lab=_43236_/A }
C {devices/lab_pin.sym} 47740 -25190 0 1 {name=p47047 lab=_87525_/D }
C {sky130_stdcells/inv_2.sym} 47700 -25190 0 0 {name=X_43236_ }
C {devices/lab_pin.sym} 47640 -25100 0 0 {name=p47048 lab=_62037_/X }
C {devices/lab_pin.sym} 47640 -25060 0 0 {name=p47049 lab=_62021_/B }
C {devices/lab_pin.sym} 47640 -25020 0 0 {name=p47050 lab=_58495_/A }
C {devices/lab_pin.sym} 47640 -24980 0 0 {name=p47051 lab=_62020_/X }
C {devices/lab_pin.sym} 47760 -25040 0 1 {name=p47052 lab=_62070_/X }
C {sky130_stdcells/and4_4.sym} 47700 -25040 0 0 {name=X_62070_ }
C {devices/lab_pin.sym} 47620 -24910 0 0 {name=p47053 lab=_68892_/B }
C {devices/lab_pin.sym} 47620 -24870 0 0 {name=p47054 lab=_72899_/X }
C {devices/lab_pin.sym} 47620 -24830 0 0 {name=p47055 lab=_73898_/X }
C {devices/lab_pin.sym} 47780 -24870 0 1 {name=p47056 lab=_74056_/X }
C {sky130_stdcells/o21a_4.sym} 47700 -24870 0 0 {name=X_74056_ }
C {devices/lab_pin.sym} 47660 -24730 0 0 {name=p47057 lab=_78923_/B }
C {devices/lab_pin.sym} 47740 -24730 0 1 {name=p47058 lab=_82511_/D }
C {sky130_stdcells/inv_2.sym} 47700 -24730 0 0 {name=X_78933_ }
C {devices/lab_pin.sym} 47620 -24650 0 0 {name=p47059 lab=_40437_/X }
C {devices/lab_pin.sym} 47620 -24610 0 0 {name=p47060 lab=_40443_/X }
C {devices/lab_pin.sym} 47620 -24570 0 0 {name=p47061 lab=_40446_/X }
C {devices/lab_pin.sym} 47620 -24530 0 0 {name=p47062 lab=_88390_/Q }
C {devices/lab_pin.sym} 47620 -24490 0 0 {name=p47063 lab=_40447_/X }
C {devices/lab_pin.sym} 47780 -24570 0 1 {name=p47064 lab=_40448_/Y }
C {sky130_stdcells/o32ai_4.sym} 47700 -24570 0 0 {name=X_40448_ }
C {devices/lab_pin.sym} 47660 -24410 0 0 {name=p47065 lab=_71268_/A }
C {devices/lab_pin.sym} 47740 -24410 0 1 {name=p47066 lab=_71276_/B }
C {sky130_stdcells/buf_2.sym} 47700 -24410 0 0 {name=X_71268_ }
C {devices/lab_pin.sym} 47660 -24290 0 0 {name=p47067 lab=_73007_/A }
C {devices/lab_pin.sym} 47740 -24290 0 1 {name=p47068 lab=_73007_/X }
C {sky130_stdcells/buf_2.sym} 47700 -24290 0 0 {name=X_73007_ }
C {devices/lab_pin.sym} 47620 -24210 0 0 {name=p47069 lab=_61018_/Y }
C {devices/lab_pin.sym} 47620 -24170 0 0 {name=p47070 lab=_60952_/X }
C {devices/lab_pin.sym} 47620 -24130 0 0 {name=p47071 lab=_61019_/X }
C {devices/lab_pin.sym} 47620 -24090 0 0 {name=p47072 lab=_76986_/A }
C {devices/lab_pin.sym} 47620 -24050 0 0 {name=p47073 lab=_61020_/X }
C {devices/lab_pin.sym} 47780 -24130 0 1 {name=p47074 lab=_84538_/D }
C {sky130_stdcells/o32a_4.sym} 47700 -24130 0 0 {name=X_61021_ }
C {devices/lab_pin.sym} 47640 -24000 0 0 {name=p47075 lab=_70229_/A }
C {devices/lab_pin.sym} 47640 -23960 0 0 {name=p47076 lab=_70229_/B }
C {devices/lab_pin.sym} 47640 -23920 0 0 {name=p47077 lab=_70219_/C }
C {devices/lab_pin.sym} 47640 -23880 0 0 {name=p47078 lab=_70229_/D }
C {devices/lab_pin.sym} 47760 -23940 0 1 {name=p47079 lab=_70219_/X }
C {sky130_stdcells/and4_4.sym} 47700 -23940 0 0 {name=X_70219_ }
C {devices/lab_pin.sym} 47660 -23790 0 0 {name=p47080 lab=_43167_/A }
C {devices/lab_pin.sym} 47740 -23790 0 1 {name=p47081 lab=_43167_/X }
C {sky130_stdcells/buf_2.sym} 47700 -23790 0 0 {name=X_43167_ }
C {devices/lab_pin.sym} 47640 -23680 0 0 {name=p47082 lab=_78877_/B }
C {devices/lab_pin.sym} 47640 -23640 0 0 {name=p47083 lab=_78877_/A }
C {devices/lab_pin.sym} 47760 -23660 0 1 {name=p47084 lab=_78868_/A }
C {sky130_stdcells/xnor2_4.sym} 47700 -23660 0 0 {name=X_78864_ }
C {devices/lab_pin.sym} 47660 -23530 0 0 {name=p47085 lab=_47825_/A }
C {devices/lab_pin.sym} 47740 -23530 0 1 {name=p47086 lab=_40380_/A }
C {sky130_stdcells/buf_2.sym} 47700 -23530 0 0 {name=X_40379_ }
C {devices/lab_pin.sym} 47640 -23430 0 0 {name=p47087 lab=_71197_/A }
C {devices/lab_pin.sym} 47640 -23390 0 0 {name=p47088 lab=_71055_/B }
C {devices/lab_pin.sym} 47640 -23350 0 0 {name=p47089 lab=_71197_/C }
C {devices/lab_pin.sym} 47760 -23390 0 1 {name=p47090 lab=_71199_/Y }
C {sky130_stdcells/nand3_4.sym} 47700 -23390 0 0 {name=X_71199_ }
C {devices/lab_pin.sym} 47620 -23290 0 0 {name=p47091 lab=_42099_/X }
C {devices/lab_pin.sym} 47620 -23250 0 0 {name=p47092 lab=_42116_/X }
C {devices/lab_pin.sym} 47620 -23210 0 0 {name=p47093 lab=_41076_/X }
C {devices/lab_pin.sym} 47620 -23170 0 0 {name=p47094 lab=_88026_/Q }
C {devices/lab_pin.sym} 47620 -23130 0 0 {name=p47095 lab=_42117_/X }
C {devices/lab_pin.sym} 47780 -23210 0 1 {name=p47096 lab=_42118_/Y }
C {sky130_stdcells/o32ai_4.sym} 47700 -23210 0 0 {name=X_42118_ }
C {devices/lab_pin.sym} 47640 -23060 0 0 {name=p47097 lab=_77828_/A }
C {devices/lab_pin.sym} 47640 -23020 0 0 {name=p47098 lab=_77814_/Y }
C {devices/lab_pin.sym} 47760 -23040 0 1 {name=p47099 lab=_77835_/A }
C {sky130_stdcells/xor2_4.sym} 47700 -23040 0 0 {name=X_77815_ }
C {devices/lab_pin.sym} 47640 -22920 0 0 {name=p47100 lab=_47946_/A }
C {devices/lab_pin.sym} 47640 -22880 0 0 {name=p47101 lab=_47975_/B }
C {devices/lab_pin.sym} 47760 -22900 0 1 {name=p47102 lab=_47975_/X }
C {sky130_stdcells/and2_4.sym} 47700 -22900 0 0 {name=X_47975_ }
C {devices/lab_pin.sym} 47660 -22770 0 0 {name=p47103 lab=_43098_/A }
C {devices/lab_pin.sym} 47740 -22770 0 1 {name=p47104 lab=_43098_/Y }
C {sky130_stdcells/inv_2.sym} 47700 -22770 0 0 {name=X_43098_ }
C {devices/lab_pin.sym} 47640 -22660 0 0 {name=p47105 lab=_78795_/A }
C {devices/lab_pin.sym} 47640 -22620 0 0 {name=p47106 lab=_78795_/B }
C {devices/lab_pin.sym} 47760 -22640 0 1 {name=p47107 lab=_78797_/A }
C {sky130_stdcells/nand2_4.sym} 47700 -22640 0 0 {name=X_78795_ }
C {devices/lab_pin.sym} 47620 -22530 0 0 {name=p47108 lab=_49711_/Y }
C {devices/lab_pin.sym} 47620 -22490 0 0 {name=p47109 lab=_49706_/X }
C {devices/lab_pin.sym} 47620 -22450 0 0 {name=p47110 lab=_49713_/X }
C {devices/lab_pin.sym} 47780 -22490 0 1 {name=p47111 lab=_49714_/Y }
C {sky130_stdcells/a21oi_4.sym} 47700 -22490 0 0 {name=X_49714_ }
C {devices/lab_pin.sym} 47640 -22380 0 0 {name=p47112 lab=_46915_/X }
C {devices/lab_pin.sym} 47640 -22340 0 0 {name=p47113 lab=_46896_/B }
C {devices/lab_pin.sym} 47640 -22300 0 0 {name=p47114 lab=_46926_/C }
C {devices/lab_pin.sym} 47640 -22260 0 0 {name=p47115 lab=_52750_/D }
C {devices/lab_pin.sym} 47760 -22320 0 1 {name=p47116 lab=_46926_/X }
C {sky130_stdcells/and4_4.sym} 47700 -22320 0 0 {name=X_46926_ }
C {devices/lab_pin.sym} 47660 -22170 0 0 {name=p47117 lab=_41993_/A }
C {devices/lab_pin.sym} 47740 -22170 0 1 {name=p47118 lab=_42049_/X }
C {sky130_stdcells/buf_2.sym} 47700 -22170 0 0 {name=X_42049_ }
C {devices/lab_pin.sym} 47640 -22070 0 0 {name=p47119 lab=_65188_/X }
C {devices/lab_pin.sym} 47640 -22030 0 0 {name=p47120 lab=_65653_/B }
C {devices/lab_pin.sym} 47640 -21990 0 0 {name=p47121 lab=_65191_/X }
C {devices/lab_pin.sym} 47760 -22030 0 1 {name=p47122 lab=_65772_/A }
C {sky130_stdcells/nand3_4.sym} 47700 -22030 0 0 {name=X_65760_ }
C {devices/lab_pin.sym} 47660 -21890 0 0 {name=p47123 lab=_81972_/Q }
C {devices/lab_pin.sym} 47740 -21890 0 1 {name=p47124 lab=_77747_/B }
C {sky130_stdcells/inv_2.sym} 47700 -21890 0 0 {name=X_77746_ }
C {devices/lab_pin.sym} 47640 -21790 0 0 {name=p47125 lab=_74958_/A }
C {devices/lab_pin.sym} 47640 -21750 0 0 {name=p47126 lab=_74958_/B }
C {devices/lab_pin.sym} 47640 -21710 0 0 {name=p47127 lab=_74961_/B }
C {devices/lab_pin.sym} 47760 -21750 0 1 {name=p47128 lab=_74959_/B }
C {sky130_stdcells/and3_4.sym} 47700 -21750 0 0 {name=X_74958_ }
C {devices/lab_pin.sym} 47620 -21650 0 0 {name=p47129 lab=_58207_/A }
C {devices/lab_pin.sym} 47620 -21610 0 0 {name=p47130 lab=_62924_/C }
C {devices/lab_pin.sym} 47620 -21570 0 0 {name=p47131 lab=_62827_/X }
C {devices/lab_pin.sym} 47620 -21530 0 0 {name=p47132 lab=_62644_/X }
C {devices/lab_pin.sym} 47620 -21500 0 0 {name=p47133 lab=_62971_/X }
C {devices/lab_pin.sym} 47780 -21570 0 1 {name=p47134 lab=_62972_/Y }
C {sky130_stdcells/a41oi_4.sym} 47700 -21570 0 0 {name=X_62972_ }
C {devices/lab_pin.sym} 47620 -21440 0 0 {name=p47135 lab=_64704_/X }
C {devices/lab_pin.sym} 47620 -21400 0 0 {name=p47136 lab=_86749_/Q }
C {devices/lab_pin.sym} 47620 -21360 0 0 {name=p47137 lab=_64707_/X }
C {devices/lab_pin.sym} 47620 -21320 0 0 {name=p47138 lab=_64710_/X }
C {devices/lab_pin.sym} 47780 -21380 0 1 {name=p47139 lab=_64711_/X }
C {sky130_stdcells/a211o_4.sym} 47700 -21380 0 0 {name=X_64711_ }
C {devices/lab_pin.sym} 47620 -21250 0 0 {name=p47140 lab=_59244_/B }
C {devices/lab_pin.sym} 47620 -21210 0 0 {name=p47141 lab=_49632_/X }
C {devices/lab_pin.sym} 47620 -21170 0 0 {name=p47142 lab=_49644_/Y }
C {devices/lab_pin.sym} 47780 -21210 0 1 {name=p47143 lab=_49645_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -21210 0 0 {name=X_49645_ }
C {devices/lab_pin.sym} 47660 -21070 0 0 {name=p47144 lab=_61712_/X }
C {devices/lab_pin.sym} 47740 -21070 0 1 {name=p47145 lab=_61924_/B }
C {sky130_stdcells/buf_2.sym} 47700 -21070 0 0 {name=X_61923_ }
C {devices/lab_pin.sym} 47620 -20980 0 0 {name=p47146 lab=_73907_/X }
C {devices/lab_pin.sym} 47620 -20940 0 0 {name=p47147 lab=_84979_/Q }
C {devices/lab_pin.sym} 47620 -20900 0 0 {name=p47148 lab=_73859_/X }
C {devices/lab_pin.sym} 47620 -20860 0 0 {name=p47149 lab=_73908_/X }
C {devices/lab_pin.sym} 47780 -20920 0 1 {name=p47150 lab=_73910_/B }
C {sky130_stdcells/a211o_4.sym} 47700 -20920 0 0 {name=X_73909_ }
C {devices/lab_pin.sym} 47640 -20800 0 0 {name=p47151 lab=_46830_/A }
C {devices/lab_pin.sym} 47640 -20760 0 0 {name=p47152 lab=_46845_/X }
C {devices/lab_pin.sym} 47640 -20720 0 0 {name=p47153 lab=_46868_/C }
C {devices/lab_pin.sym} 47640 -20680 0 0 {name=p47154 lab=_52716_/D }
C {devices/lab_pin.sym} 47760 -20740 0 1 {name=p47155 lab=_46857_/X }
C {sky130_stdcells/and4_4.sym} 47700 -20740 0 0 {name=X_46857_ }
C {devices/lab_pin.sym} 47620 -20610 0 0 {name=p47156 lab=_65688_/X }
C {devices/lab_pin.sym} 47620 -20570 0 0 {name=p47157 lab=_65690_/X }
C {devices/lab_pin.sym} 47620 -20530 0 0 {name=p47158 lab=_65642_/X }
C {devices/lab_pin.sym} 47780 -20570 0 1 {name=p47159 lab=_65694_/A }
C {sky130_stdcells/a21o_4.sym} 47700 -20570 0 0 {name=X_65691_ }
C {devices/lab_pin.sym} 47620 -20450 0 0 {name=p47160 lab=_77673_/Y }
C {devices/lab_pin.sym} 47620 -20410 0 0 {name=p47161 lab=_77675_/Y }
C {devices/lab_pin.sym} 47620 -20370 0 0 {name=p47162 lab=_77676_/A }
C {devices/lab_pin.sym} 47780 -20410 0 1 {name=p47163 lab=_77677_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -20410 0 0 {name=X_77677_ }
C {devices/lab_pin.sym} 47660 -20270 0 0 {name=p47164 lab=_74889_/A }
C {devices/lab_pin.sym} 47740 -20270 0 1 {name=p47165 lab=_74890_/B }
C {sky130_stdcells/buf_2.sym} 47700 -20270 0 0 {name=X_74889_ }
C {devices/lab_pin.sym} 47620 -20180 0 0 {name=p47166 lab=_87407_/Q }
C {devices/lab_pin.sym} 47620 -20140 0 0 {name=p47167 lab=_67358_/X }
C {devices/lab_pin.sym} 47620 -20100 0 0 {name=p47168 lab=_67360_/X }
C {devices/lab_pin.sym} 47620 -20060 0 0 {name=p47169 lab=_67429_/X }
C {devices/lab_pin.sym} 47780 -20120 0 1 {name=p47170 lab=_67430_/X }
C {sky130_stdcells/a211o_4.sym} 47700 -20120 0 0 {name=X_67430_ }
C {devices/lab_pin.sym} 47640 -19980 0 0 {name=p47171 lab=_79416_/A }
C {devices/lab_pin.sym} 47640 -19940 0 0 {name=p47172 lab=_79416_/B }
C {devices/lab_pin.sym} 47760 -19960 0 1 {name=p47173 lab=_79439_/A }
C {sky130_stdcells/xor2_4.sym} 47700 -19960 0 0 {name=X_79416_ }
C {devices/lab_pin.sym} 47660 -19830 0 0 {name=p47174 lab=_45808_/A }
C {devices/lab_pin.sym} 47740 -19830 0 1 {name=p47175 lab=_45808_/Y }
C {sky130_stdcells/inv_2.sym} 47700 -19830 0 0 {name=X_45808_ }
C {devices/lab_pin.sym} 47660 -19710 0 0 {name=p47176 lab=_64642_/A }
C {devices/lab_pin.sym} 47740 -19710 0 1 {name=p47177 lab=_64642_/X }
C {sky130_stdcells/buf_2.sym} 47700 -19710 0 0 {name=X_64642_ }
C {devices/lab_pin.sym} 47660 -19590 0 0 {name=p47178 lab=_76628_/A }
C {devices/lab_pin.sym} 47740 -19590 0 1 {name=p47179 lab=_76628_/Y }
C {sky130_stdcells/inv_2.sym} 47700 -19590 0 0 {name=X_76628_ }
C {devices/lab_pin.sym} 47620 -19510 0 0 {name=p47180 lab=_57652_/X }
C {devices/lab_pin.sym} 47620 -19470 0 0 {name=p47181 lab=_61824_/X }
C {devices/lab_pin.sym} 47620 -19430 0 0 {name=p47182 lab=_61838_/X }
C {devices/lab_pin.sym} 47620 -19390 0 0 {name=p47183 lab=_61790_/X }
C {devices/lab_pin.sym} 47620 -19360 0 0 {name=p47184 lab=_61853_/X }
C {devices/lab_pin.sym} 47780 -19430 0 1 {name=p47185 lab=_61854_/X }
C {sky130_stdcells/a41o_4.sym} 47700 -19430 0 0 {name=X_61854_ }
C {devices/lab_pin.sym} 47660 -19270 0 0 {name=p47186 lab=_49548_/A }
C {devices/lab_pin.sym} 47740 -19270 0 1 {name=p47187 lab=_49577_/C }
C {sky130_stdcells/buf_2.sym} 47700 -19270 0 0 {name=X_49576_ }
C {devices/lab_pin.sym} 47640 -19160 0 0 {name=p47188 lab=_46806_/A }
C {devices/lab_pin.sym} 47640 -19120 0 0 {name=p47189 lab=_50981_/B }
C {devices/lab_pin.sym} 47760 -19140 0 1 {name=p47190 lab=_46788_/Y }
C {sky130_stdcells/nand2_4.sym} 47700 -19140 0 0 {name=X_46788_ }
C {devices/lab_pin.sym} 47660 -19010 0 0 {name=p47191 lab=_60804_/Y }
C {devices/lab_pin.sym} 47740 -19010 0 1 {name=p47192 lab=_60805_/Y }
C {sky130_stdcells/inv_2.sym} 47700 -19010 0 0 {name=X_60805_ }
C {devices/lab_pin.sym} 47640 -18900 0 0 {name=p47193 lab=_48515_/A }
C {devices/lab_pin.sym} 47640 -18860 0 0 {name=p47194 lab=_48788_/B }
C {devices/lab_pin.sym} 47760 -18880 0 1 {name=p47195 lab=_48527_/Y }
C {sky130_stdcells/nand2_4.sym} 47700 -18880 0 0 {name=X_48527_ }
C {devices/lab_pin.sym} 47620 -18770 0 0 {name=p47196 lab=_79333_/Y }
C {devices/lab_pin.sym} 47620 -18730 0 0 {name=p47197 lab=_79339_/B }
C {devices/lab_pin.sym} 47620 -18690 0 0 {name=p47198 lab=_79346_/X }
C {devices/lab_pin.sym} 47780 -18730 0 1 {name=p47199 lab=_79347_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -18730 0 0 {name=X_79347_ }
C {devices/lab_pin.sym} 47640 -18600 0 0 {name=p47200 lab=_67308_/A }
C {devices/lab_pin.sym} 47640 -18560 0 0 {name=p47201 lab=_67361_/B }
C {devices/lab_pin.sym} 47760 -18580 0 1 {name=p47202 lab=_67361_/X }
C {sky130_stdcells/and2_4.sym} 47700 -18580 0 0 {name=X_67361_ }
C {devices/lab_pin.sym} 47660 -18450 0 0 {name=p47203 lab=_45193_/A }
C {devices/lab_pin.sym} 47740 -18450 0 1 {name=p47204 lab=_45740_/B }
C {sky130_stdcells/buf_2.sym} 47700 -18450 0 0 {name=X_45739_ }
C {devices/lab_pin.sym} 47620 -18360 0 0 {name=p47205 lab=_44149_/X }
C {devices/lab_pin.sym} 47620 -18320 0 0 {name=p47206 lab=_85537_/Q }
C {devices/lab_pin.sym} 47620 -18280 0 0 {name=p47207 lab=_64571_/X }
C {devices/lab_pin.sym} 47620 -18240 0 0 {name=p47208 lab=_64572_/X }
C {devices/lab_pin.sym} 47780 -18300 0 1 {name=p47209 lab=_64573_/X }
C {sky130_stdcells/a211o_4.sym} 47700 -18300 0 0 {name=X_64573_ }
C {devices/lab_pin.sym} 47660 -18150 0 0 {name=p47210 lab=_76559_/A }
C {devices/lab_pin.sym} 47740 -18150 0 1 {name=p47211 lab=_76559_/Y }
C {sky130_stdcells/inv_2.sym} 47700 -18150 0 0 {name=X_76559_ }
C {devices/lab_pin.sym} 47620 -18050 0 0 {name=p47212 lab=_61783_/Y }
C {devices/lab_pin.sym} 47620 -18010 0 0 {name=p47213 lab=_61699_/X }
C {devices/lab_pin.sym} 47620 -17970 0 0 {name=p47214 lab=_61784_/Y }
C {devices/lab_pin.sym} 47780 -18010 0 1 {name=p47215 lab=_61785_/Y }
C {sky130_stdcells/a21oi_4.sym} 47700 -18010 0 0 {name=X_61785_ }
C {devices/lab_pin.sym} 47640 -17880 0 0 {name=p47216 lab=_69236_/A }
C {devices/lab_pin.sym} 47640 -17840 0 0 {name=p47217 lab=_69100_/B }
C {devices/lab_pin.sym} 47760 -17860 0 1 {name=p47218 lab=_69100_/X }
C {sky130_stdcells/and2_4.sym} 47700 -17860 0 0 {name=X_69100_ }
C {devices/lab_pin.sym} 47620 -17750 0 0 {name=p47219 lab=_66309_/X }
C {devices/lab_pin.sym} 47620 -17710 0 0 {name=p47220 lab=_66311_/X }
C {devices/lab_pin.sym} 47620 -17670 0 0 {name=p47221 lab=_66240_/X }
C {devices/lab_pin.sym} 47780 -17710 0 1 {name=p47222 lab=_66312_/X }
C {sky130_stdcells/a21o_4.sym} 47700 -17710 0 0 {name=X_66312_ }
C {devices/lab_pin.sym} 47640 -17590 0 0 {name=p47223 lab=_63512_/A }
C {devices/lab_pin.sym} 47640 -17550 0 0 {name=p47224 lab=_63524_/B }
C {devices/lab_pin.sym} 47640 -17510 0 0 {name=p47225 lab=_63476_/C }
C {devices/lab_pin.sym} 47760 -17550 0 1 {name=p47226 lab=_63524_/X }
C {sky130_stdcells/and3_4.sym} 47700 -17550 0 0 {name=X_63524_ }
C {devices/lab_pin.sym} 47660 -17410 0 0 {name=p47227 lab=_48934_/A }
C {devices/lab_pin.sym} 47740 -17410 0 1 {name=p47228 lab=_48651_/A }
C {sky130_stdcells/buf_2.sym} 47700 -17410 0 0 {name=X_48458_ }
C {devices/lab_pin.sym} 47660 -17290 0 0 {name=p47229 lab=_63400_/C }
C {devices/lab_pin.sym} 47740 -17290 0 1 {name=p47230 lab=_60736_/X }
C {sky130_stdcells/buf_2.sym} 47700 -17290 0 0 {name=X_60736_ }
C {devices/lab_pin.sym} 47640 -17180 0 0 {name=p47231 lab=_67292_/A }
C {devices/lab_pin.sym} 47640 -17140 0 0 {name=p47232 lab=_67291_/X }
C {devices/lab_pin.sym} 47760 -17160 0 1 {name=p47233 lab=_67292_/Y }
C {sky130_stdcells/nand2_4.sym} 47700 -17160 0 0 {name=X_67292_ }
C {devices/lab_pin.sym} 47640 -17040 0 0 {name=p47234 lab=_84795_/Q }
C {devices/lab_pin.sym} 47640 -17000 0 0 {name=p47235 lab=_84115_/Q }
C {devices/lab_pin.sym} 47760 -17020 0 1 {name=p47236 lab=_79278_/X }
C {sky130_stdcells/xor2_4.sym} 47700 -17020 0 0 {name=X_79278_ }
C {devices/lab_pin.sym} 47640 -16900 0 0 {name=p47237 lab=_69134_/A }
C {devices/lab_pin.sym} 47640 -16860 0 0 {name=p47238 lab=_69031_/B }
C {devices/lab_pin.sym} 47760 -16880 0 1 {name=p47239 lab=_69031_/X }
C {sky130_stdcells/and2_4.sym} 47700 -16880 0 0 {name=X_69031_ }
C {devices/lab_pin.sym} 47620 -16770 0 0 {name=p47240 lab=_47405_/Y }
C {devices/lab_pin.sym} 47620 -16730 0 0 {name=p47241 lab=_47364_/X }
C {devices/lab_pin.sym} 47620 -16690 0 0 {name=p47242 lab=_47408_/X }
C {devices/lab_pin.sym} 47780 -16730 0 1 {name=p47243 lab=_47409_/Y }
C {sky130_stdcells/a21oi_4.sym} 47700 -16730 0 0 {name=X_47409_ }
C {devices/lab_pin.sym} 47620 -16620 0 0 {name=p47244 lab=_66225_/X }
C {devices/lab_pin.sym} 47620 -16580 0 0 {name=p47245 lab=_84970_/Q }
C {devices/lab_pin.sym} 47620 -16540 0 0 {name=p47246 lab=_66186_/X }
C {devices/lab_pin.sym} 47620 -16500 0 0 {name=p47247 lab=_66242_/X }
C {devices/lab_pin.sym} 47780 -16560 0 1 {name=p47248 lab=_66244_/B }
C {sky130_stdcells/a211o_4.sym} 47700 -16560 0 0 {name=X_66243_ }
C {devices/lab_pin.sym} 47620 -16430 0 0 {name=p47249 lab=_78234_/A }
C {devices/lab_pin.sym} 47620 -16390 0 0 {name=p47250 lab=_78225_/A }
C {devices/lab_pin.sym} 47620 -16350 0 0 {name=p47251 lab=_78228_/Y }
C {devices/lab_pin.sym} 47780 -16390 0 1 {name=p47252 lab=_78229_/Y }
C {sky130_stdcells/a21boi_4.sym} 47700 -16390 0 0 {name=X_78229_ }
C {devices/lab_pin.sym} 47660 -16250 0 0 {name=p47253 lab=_63516_/A }
C {devices/lab_pin.sym} 47740 -16250 0 1 {name=p47254 lab=_63455_/X }
C {sky130_stdcells/buf_2.sym} 47700 -16250 0 0 {name=X_63455_ }
C {devices/lab_pin.sym} 47660 -16130 0 0 {name=p47255 lab=clkbuf_9_276_0_CLK/X }
C {devices/lab_pin.sym} 47740 -16130 0 1 {name=p47256 lab=_82896_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 47700 -16130 0 0 {name=Xclkbuf_10_553_0_CLK }
C {devices/lab_pin.sym} 47660 -16010 0 0 {name=p47257 lab=clkbuf_6_45_0_CLK/A }
C {devices/lab_pin.sym} 47740 -16010 0 1 {name=p47258 lab=clkbuf_7_89_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 47700 -16010 0 0 {name=Xclkbuf_6_44_0_CLK }
C {devices/lab_pin.sym} 47620 -15910 0 0 {name=p47259 lab=_48382_/Y }
C {devices/lab_pin.sym} 47620 -15870 0 0 {name=p47260 lab=_48383_/X }
C {devices/lab_pin.sym} 47620 -15830 0 0 {name=p47261 lab=_48388_/X }
C {devices/lab_pin.sym} 47780 -15870 0 1 {name=p47262 lab=_48389_/Y }
C {sky130_stdcells/a21oi_4.sym} 47700 -15870 0 0 {name=X_48389_ }
C {devices/lab_pin.sym} 47660 -15730 0 0 {name=p47263 lab=_60667_/A }
C {devices/lab_pin.sym} 47740 -15730 0 1 {name=p47264 lab=_60667_/Y }
C {sky130_stdcells/inv_2.sym} 47700 -15730 0 0 {name=X_60667_ }
C {devices/lab_pin.sym} 47620 -15630 0 0 {name=p47265 lab=_86204_/Q }
C {devices/lab_pin.sym} 47620 -15590 0 0 {name=p47266 lab=_50387_/X }
C {devices/lab_pin.sym} 47620 -15550 0 0 {name=p47267 lab=_50419_/Y }
C {devices/lab_pin.sym} 47780 -15590 0 1 {name=p47268 lab=_50420_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -15590 0 0 {name=X_50420_ }
C {devices/lab_pin.sym} 47610 -15450 0 0 {name=p47269 lab=_85334_/CLK }
C {devices/lab_pin.sym} 47610 -15430 0 0 {name=p47270 lab=_81048_/Q }
C {devices/lab_pin.sym} 47790 -15450 0 1 {name=p47271 lab=_81240_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -15440 0 0 {name=X_81240_ }
C {devices/lab_pin.sym} 47640 -15340 0 0 {name=p47272 lab=_62406_/A }
C {devices/lab_pin.sym} 47640 -15300 0 0 {name=p47273 lab=_62401_/Y }
C {devices/lab_pin.sym} 47640 -15260 0 0 {name=p47274 lab=_62406_/C }
C {devices/lab_pin.sym} 47640 -15220 0 0 {name=p47275 lab=_62405_/Y }
C {devices/lab_pin.sym} 47760 -15280 0 1 {name=p47276 lab=_62406_/Y }
C {sky130_stdcells/nand4_4.sym} 47700 -15280 0 0 {name=X_62406_ }
C {devices/lab_pin.sym} 47620 -15150 0 0 {name=p47277 lab=_66068_/X }
C {devices/lab_pin.sym} 47620 -15110 0 0 {name=p47278 lab=_65710_/Y }
C {devices/lab_pin.sym} 47620 -15070 0 0 {name=p47279 lab=_66173_/Y }
C {devices/lab_pin.sym} 47780 -15110 0 1 {name=p47280 lab=_66174_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -15110 0 0 {name=X_66174_ }
C {devices/lab_pin.sym} 47640 -14980 0 0 {name=p47281 lab=_63374_/A }
C {devices/lab_pin.sym} 47640 -14940 0 0 {name=p47282 lab=_61762_/X }
C {devices/lab_pin.sym} 47760 -14960 0 1 {name=p47283 lab=_63386_/X }
C {sky130_stdcells/and2_4.sym} 47700 -14960 0 0 {name=X_63386_ }
C {devices/lab_pin.sym} 47640 -14840 0 0 {name=p47284 lab=_60533_/Y }
C {devices/lab_pin.sym} 47640 -14800 0 0 {name=p47285 lab=_60566_/A }
C {devices/lab_pin.sym} 47760 -14820 0 1 {name=p47286 lab=_60598_/Y }
C {sky130_stdcells/nand2_4.sym} 47700 -14820 0 0 {name=X_60598_ }
C {devices/lab_pin.sym} 47620 -14720 0 0 {name=p47287 lab=_65099_/X }
C {devices/lab_pin.sym} 47620 -14680 0 0 {name=p47288 lab=_86733_/Q }
C {devices/lab_pin.sym} 47620 -14640 0 0 {name=p47289 lab=_65028_/X }
C {devices/lab_pin.sym} 47620 -14600 0 0 {name=p47290 lab=_65124_/X }
C {devices/lab_pin.sym} 47780 -14660 0 1 {name=p47291 lab=_65125_/X }
C {sky130_stdcells/a211o_4.sym} 47700 -14660 0 0 {name=X_65125_ }
C {devices/lab_pin.sym} 47660 -14510 0 0 {name=p47292 lab=_50227_/A }
C {devices/lab_pin.sym} 47740 -14510 0 1 {name=p47293 lab=_50351_/X }
C {sky130_stdcells/buf_2.sym} 47700 -14510 0 0 {name=X_50351_ }
C {devices/lab_pin.sym} 47640 -14420 0 0 {name=p47294 lab=_62337_/A }
C {devices/lab_pin.sym} 47640 -14380 0 0 {name=p47295 lab=_61861_/X }
C {devices/lab_pin.sym} 47640 -14340 0 0 {name=p47296 lab=_62237_/X }
C {devices/lab_pin.sym} 47640 -14300 0 0 {name=p47297 lab=_62280_/D }
C {devices/lab_pin.sym} 47760 -14360 0 1 {name=p47298 lab=_62337_/X }
C {sky130_stdcells/and4_4.sym} 47700 -14360 0 0 {name=X_62337_ }
C {devices/lab_pin.sym} 47610 -14210 0 0 {name=p47299 lab=_81179_/CLK }
C {devices/lab_pin.sym} 47610 -14190 0 0 {name=p47300 lab=_74969_/B }
C {devices/lab_pin.sym} 47790 -14210 0 1 {name=p47301 lab=_81171_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -14200 0 0 {name=X_81171_ }
C {devices/lab_pin.sym} 47620 -14090 0 0 {name=p47302 lab=_57912_/Y }
C {devices/lab_pin.sym} 47620 -14050 0 0 {name=p47303 lab=_65634_/C }
C {devices/lab_pin.sym} 47620 -14010 0 0 {name=p47304 lab=_80121_/Y }
C {devices/lab_pin.sym} 47780 -14050 0 1 {name=p47305 lab=_80122_/X }
C {sky130_stdcells/o21a_4.sym} 47700 -14050 0 0 {name=X_80122_ }
C {devices/lab_pin.sym} 47660 -13910 0 0 {name=p47306 lab=clkbuf_9_284_0_CLK/X }
C {devices/lab_pin.sym} 47740 -13910 0 1 {name=p47307 lab=_87416_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 47700 -13910 0 0 {name=Xclkbuf_10_568_0_CLK }
C {devices/lab_pin.sym} 47660 -13790 0 0 {name=p47308 lab=_44134_/D }
C {devices/lab_pin.sym} 47740 -13790 0 1 {name=p47309 lab=_55686_/C }
C {sky130_stdcells/buf_2.sym} 47700 -13790 0 0 {name=Xpsn_inst_psn_buff_12 }
C {devices/lab_pin.sym} 47640 -13700 0 0 {name=p47310 lab=_53074_/A }
C {devices/lab_pin.sym} 47640 -13660 0 0 {name=p47311 lab=_53069_/X }
C {devices/lab_pin.sym} 47640 -13620 0 0 {name=p47312 lab=_53074_/C }
C {devices/lab_pin.sym} 47640 -13580 0 0 {name=p47313 lab=_53070_/D }
C {devices/lab_pin.sym} 47760 -13640 0 1 {name=p47314 lab=_53070_/X }
C {sky130_stdcells/and4_4.sym} 47700 -13640 0 0 {name=X_53070_ }
C {devices/lab_pin.sym} 47640 -13510 0 0 {name=p47315 lab=_65053_/X }
C {devices/lab_pin.sym} 47640 -13470 0 0 {name=p47316 lab=_65056_/B }
C {devices/lab_pin.sym} 47640 -13430 0 0 {name=p47317 lab=_65055_/X }
C {devices/lab_pin.sym} 47760 -13470 0 1 {name=p47318 lab=_65056_/Y }
C {sky130_stdcells/nand3_4.sym} 47700 -13470 0 0 {name=X_65056_ }
C {devices/lab_pin.sym} 47620 -13360 0 0 {name=p47319 lab=_73465_/A }
C {devices/lab_pin.sym} 47620 -13320 0 0 {name=p47320 lab=_69837_/X }
C {devices/lab_pin.sym} 47620 -13280 0 0 {name=p47321 lab=_68741_/X }
C {devices/lab_pin.sym} 47620 -13240 0 0 {name=p47322 lab=_69932_/Y }
C {devices/lab_pin.sym} 47780 -13300 0 1 {name=p47323 lab=_69933_/X }
C {sky130_stdcells/a211o_4.sym} 47700 -13300 0 0 {name=X_69933_ }
C {devices/lab_pin.sym} 47660 -13150 0 0 {name=p47324 lab=clkbuf_6_59_0_CLK/A }
C {devices/lab_pin.sym} 47740 -13150 0 1 {name=p47325 lab=clkbuf_6_59_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 47700 -13150 0 0 {name=Xclkbuf_6_59_0_CLK }
C {devices/lab_pin.sym} 47660 -13030 0 0 {name=p47326 lab=_53441_/A }
C {devices/lab_pin.sym} 47740 -13030 0 1 {name=p47327 lab=_53447_/A }
C {sky130_stdcells/buf_2.sym} 47700 -13030 0 0 {name=Xpsn_inst_psn_buff_23 }
C {devices/lab_pin.sym} 47660 -12910 0 0 {name=p47328 lab=_50219_/X }
C {devices/lab_pin.sym} 47740 -12910 0 1 {name=p47329 lab=_50282_/X }
C {sky130_stdcells/buf_2.sym} 47700 -12910 0 0 {name=X_50282_ }
C {devices/lab_pin.sym} 47620 -12810 0 0 {name=p47330 lab=_62264_/Y }
C {devices/lab_pin.sym} 47620 -12770 0 0 {name=p47331 lab=_62253_/X }
C {devices/lab_pin.sym} 47620 -12730 0 0 {name=p47332 lab=_62267_/Y }
C {devices/lab_pin.sym} 47780 -12770 0 1 {name=p47333 lab=_84422_/D }
C {sky130_stdcells/a21oi_4.sym} 47700 -12770 0 0 {name=X_62268_ }
C {devices/lab_pin.sym} 47660 -12630 0 0 {name=p47334 lab=_52021_/A }
C {devices/lab_pin.sym} 47740 -12630 0 1 {name=p47335 lab=_52462_/A }
C {sky130_stdcells/buf_2.sym} 47700 -12630 0 0 {name=X_52021_ }
C {devices/lab_pin.sym} 47660 -12510 0 0 {name=p47336 lab=_60034_/X }
C {devices/lab_pin.sym} 47740 -12510 0 1 {name=p47337 lab=_64074_/A }
C {sky130_stdcells/buf_2.sym} 47700 -12510 0 0 {name=X_64007_ }
C {devices/lab_pin.sym} 47620 -12420 0 0 {name=p47338 lab=_61218_/Y }
C {devices/lab_pin.sym} 47620 -12380 0 0 {name=p47339 lab=_61125_/A }
C {devices/lab_pin.sym} 47620 -12340 0 0 {name=p47340 lab=_84505_/Q }
C {devices/lab_pin.sym} 47620 -12300 0 0 {name=p47341 lab=_59803_/X }
C {devices/lab_pin.sym} 47780 -12360 0 1 {name=p47342 lab=_84505_/D }
C {sky130_stdcells/a2bb2o_4.sym} 47700 -12360 0 0 {name=X_61219_ }
C {devices/lab_pin.sym} 47610 -12210 0 0 {name=p47343 lab=_84930_/CLK }
C {devices/lab_pin.sym} 47610 -12190 0 0 {name=p47344 lab=_84930_/D }
C {devices/lab_pin.sym} 47790 -12210 0 1 {name=p47345 lab=_84930_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -12200 0 0 {name=X_84930_ }
C {devices/lab_pin.sym} 47620 -12100 0 0 {name=p47346 lab=_80025_/Y }
C {devices/lab_pin.sym} 47620 -12060 0 0 {name=p47347 lab=_80043_/B }
C {devices/lab_pin.sym} 47620 -12020 0 0 {name=p47348 lab=_80042_/A }
C {devices/lab_pin.sym} 47620 -11980 0 0 {name=p47349 lab=_80041_/Y }
C {devices/lab_pin.sym} 47780 -12040 0 1 {name=p47350 lab=_80053_/X }
C {sky130_stdcells/o22a_4.sym} 47700 -12040 0 0 {name=X_80053_ }
C {devices/lab_pin.sym} 47620 -11910 0 0 {name=p47351 lab=_69861_/X }
C {devices/lab_pin.sym} 47620 -11870 0 0 {name=p47352 lab=_69863_/X }
C {devices/lab_pin.sym} 47620 -11830 0 0 {name=p47353 lab=_66579_/X }
C {devices/lab_pin.sym} 47780 -11870 0 1 {name=p47354 lab=_69864_/X }
C {sky130_stdcells/a21o_4.sym} 47700 -11870 0 0 {name=X_69864_ }
C {devices/lab_pin.sym} 47660 -11730 0 0 {name=p47355 lab=_62198_/Y }
C {devices/lab_pin.sym} 47740 -11730 0 1 {name=p47356 lab=_62572_/A }
C {sky130_stdcells/buf_2.sym} 47700 -11730 0 0 {name=X_62199_ }
C {devices/lab_pin.sym} 47640 -11620 0 0 {name=p47357 lab=_68770_/X }
C {devices/lab_pin.sym} 47640 -11580 0 0 {name=p47358 lab=_68815_/B }
C {devices/lab_pin.sym} 47760 -11600 0 1 {name=p47359 lab=_68815_/X }
C {sky130_stdcells/and2_4.sym} 47700 -11600 0 0 {name=X_68815_ }
C {devices/lab_pin.sym} 47610 -11470 0 0 {name=p47360 lab=_84250_/CLK }
C {devices/lab_pin.sym} 47610 -11450 0 0 {name=p47361 lab=_84861_/D }
C {devices/lab_pin.sym} 47790 -11470 0 1 {name=p47362 lab=_84861_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -11460 0 0 {name=X_84861_ }
C {devices/lab_pin.sym} 47620 -11350 0 0 {name=p47363 lab=_69792_/X }
C {devices/lab_pin.sym} 47620 -11310 0 0 {name=p47364 lab=_69794_/X }
C {devices/lab_pin.sym} 47620 -11270 0 0 {name=p47365 lab=_69768_/X }
C {devices/lab_pin.sym} 47780 -11310 0 1 {name=p47366 lab=_69795_/X }
C {sky130_stdcells/a21o_4.sym} 47700 -11310 0 0 {name=X_69795_ }
C {devices/lab_pin.sym} 47610 -11170 0 0 {name=p47367 lab=_86600_/CLK }
C {devices/lab_pin.sym} 47610 -11150 0 0 {name=p47368 lab=_86600_/D }
C {devices/lab_pin.sym} 47790 -11170 0 1 {name=p47369 lab=_86600_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -11160 0 0 {name=X_86600_ }
C {devices/lab_pin.sym} 47610 -11030 0 0 {name=p47370 lab=_83842_/CLK }
C {devices/lab_pin.sym} 47610 -11010 0 0 {name=p47371 lab=_83812_/D }
C {devices/lab_pin.sym} 47790 -11030 0 1 {name=p47372 lab=_83812_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -11020 0 0 {name=X_83812_ }
C {devices/lab_pin.sym} 47660 -10890 0 0 {name=p47373 lab=_56759_/X }
C {devices/lab_pin.sym} 47740 -10890 0 1 {name=p47374 lab=_56788_/A }
C {sky130_stdcells/buf_2.sym} 47700 -10890 0 0 {name=X_56760_ }
C {devices/lab_pin.sym} 47640 -10780 0 0 {name=p47375 lab=_68746_/A }
C {devices/lab_pin.sym} 47640 -10740 0 0 {name=p47376 lab=_68746_/B }
C {devices/lab_pin.sym} 47760 -10760 0 1 {name=p47377 lab=_68746_/Y }
C {sky130_stdcells/nor2_4.sym} 47700 -10760 0 0 {name=X_68746_ }
C {devices/lab_pin.sym} 47610 -10630 0 0 {name=p47378 lab=_87542_/CLK }
C {devices/lab_pin.sym} 47610 -10610 0 0 {name=p47379 lab=_87580_/D }
C {devices/lab_pin.sym} 47790 -10630 0 1 {name=p47380 lab=_87580_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -10620 0 0 {name=X_87580_ }
C {devices/lab_pin.sym} 47620 -10510 0 0 {name=p47381 lab=_85531_/Q }
C {devices/lab_pin.sym} 47620 -10470 0 0 {name=p47382 lab=_53955_/X }
C {devices/lab_pin.sym} 47620 -10430 0 0 {name=p47383 lab=_53971_/Y }
C {devices/lab_pin.sym} 47780 -10470 0 1 {name=p47384 lab=_53972_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -10470 0 0 {name=X_53972_ }
C {devices/lab_pin.sym} 47620 -10360 0 0 {name=p47385 lab=_72123_/A }
C {devices/lab_pin.sym} 47620 -10320 0 0 {name=p47386 lab=_86237_/Q }
C {devices/lab_pin.sym} 47620 -10280 0 0 {name=p47387 lab=_45922_/X }
C {devices/lab_pin.sym} 47620 -10240 0 0 {name=p47388 lab=_65957_/X }
C {devices/lab_pin.sym} 47780 -10300 0 1 {name=p47389 lab=_65958_/X }
C {sky130_stdcells/a211o_4.sym} 47700 -10300 0 0 {name=X_65958_ }
C {devices/lab_pin.sym} 47610 -10150 0 0 {name=p47390 lab=_86697_/CLK }
C {devices/lab_pin.sym} 47610 -10130 0 0 {name=p47391 lab=_58895_/Y }
C {devices/lab_pin.sym} 47790 -10150 0 1 {name=p47392 lab=_84792_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -10140 0 0 {name=X_84792_ }
C {devices/lab_pin.sym} 47660 -10010 0 0 {name=p47393 lab=_55711_/A }
C {devices/lab_pin.sym} 47740 -10010 0 1 {name=p47394 lab=_55711_/X }
C {sky130_stdcells/buf_2.sym} 47700 -10010 0 0 {name=X_55711_ }
C {devices/lab_pin.sym} 47610 -9890 0 0 {name=p47395 lab=_86490_/CLK }
C {devices/lab_pin.sym} 47610 -9870 0 0 {name=p47396 lab=_86531_/D }
C {devices/lab_pin.sym} 47790 -9890 0 1 {name=p47397 lab=_86531_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -9880 0 0 {name=X_86531_ }
C {devices/lab_pin.sym} 47620 -9770 0 0 {name=p47398 lab=_52919_/Y }
C {devices/lab_pin.sym} 47620 -9730 0 0 {name=p47399 lab=_52920_/X }
C {devices/lab_pin.sym} 47620 -9690 0 0 {name=p47400 lab=_52922_/X }
C {devices/lab_pin.sym} 47780 -9730 0 1 {name=p47401 lab=_52923_/Y }
C {sky130_stdcells/a21oi_4.sym} 47700 -9730 0 0 {name=X_52923_ }
C {devices/lab_pin.sym} 47640 -9600 0 0 {name=p47402 lab=_64877_/X }
C {devices/lab_pin.sym} 47640 -9560 0 0 {name=p47403 lab=_86454_/Q }
C {devices/lab_pin.sym} 47760 -9580 0 1 {name=p47404 lab=_64909_/X }
C {sky130_stdcells/and2_4.sym} 47700 -9580 0 0 {name=X_64909_ }
C {devices/lab_pin.sym} 47610 -9450 0 0 {name=p47405 lab=_86322_/CLK }
C {devices/lab_pin.sym} 47610 -9430 0 0 {name=p47406 lab=_83743_/D }
C {devices/lab_pin.sym} 47790 -9450 0 1 {name=p47407 lab=_47313_/A }
C {sky130_stdcells/dfxtp_4.sym} 47700 -9440 0 0 {name=X_83743_ }
C {devices/lab_pin.sym} 47660 -9310 0 0 {name=p47408 lab=_56691_/A }
C {devices/lab_pin.sym} 47740 -9310 0 1 {name=p47409 lab=_72765_/A }
C {sky130_stdcells/buf_2.sym} 47700 -9310 0 0 {name=X_56691_ }
C {devices/lab_pin.sym} 47610 -9190 0 0 {name=p47410 lab=_80740_/CLK }
C {devices/lab_pin.sym} 47610 -9170 0 0 {name=p47411 lab=_80955_/D }
C {devices/lab_pin.sym} 47790 -9190 0 1 {name=p47412 lab=_80955_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -9180 0 0 {name=X_80955_ }
C {devices/lab_pin.sym} 47620 -9080 0 0 {name=p47413 lab=_86995_/Q }
C {devices/lab_pin.sym} 47620 -9040 0 0 {name=p47414 lab=_68394_/X }
C {devices/lab_pin.sym} 47620 -9000 0 0 {name=p47415 lab=_68421_/X }
C {devices/lab_pin.sym} 47620 -8960 0 0 {name=p47416 lab=_68676_/X }
C {devices/lab_pin.sym} 47780 -9020 0 1 {name=p47417 lab=_68677_/X }
C {sky130_stdcells/a211o_4.sym} 47700 -9020 0 0 {name=X_68677_ }
C {devices/lab_pin.sym} 47620 -8890 0 0 {name=p47418 lab=_65886_/Y }
C {devices/lab_pin.sym} 47620 -8850 0 0 {name=p47419 lab=_65830_/X }
C {devices/lab_pin.sym} 47620 -8810 0 0 {name=p47420 lab=_65888_/Y }
C {devices/lab_pin.sym} 47780 -8850 0 1 {name=p47421 lab=_84171_/D }
C {sky130_stdcells/a21o_4.sym} 47700 -8850 0 0 {name=X_65889_ }
C {devices/lab_pin.sym} 47640 -8720 0 0 {name=p47422 lab=_58151_/A }
C {devices/lab_pin.sym} 47640 -8680 0 0 {name=p47423 lab=_83362_/Q }
C {devices/lab_pin.sym} 47760 -8700 0 1 {name=p47424 lab=_58430_/Y }
C {sky130_stdcells/nor2_4.sym} 47700 -8700 0 0 {name=X_58430_ }
C {devices/lab_pin.sym} 47660 -8570 0 0 {name=p47425 lab=clkbuf_9_253_0_CLK/X }
C {devices/lab_pin.sym} 47740 -8570 0 1 {name=p47426 lab=_84807_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 47700 -8570 0 0 {name=Xclkbuf_10_506_0_CLK }
C {devices/lab_pin.sym} 47620 -8480 0 0 {name=p47427 lab=_83009_/Q }
C {devices/lab_pin.sym} 47620 -8440 0 0 {name=p47428 lab=_55619_/A }
C {devices/lab_pin.sym} 47620 -8400 0 0 {name=p47429 lab=_44101_/A }
C {devices/lab_pin.sym} 47620 -8360 0 0 {name=p47430 lab=_55641_/Y }
C {devices/lab_pin.sym} 47780 -8420 0 1 {name=p47431 lab=_55642_/X }
C {sky130_stdcells/a211o_4.sym} 47700 -8420 0 0 {name=X_55642_ }
C {devices/lab_pin.sym} 47660 -8270 0 0 {name=p47432 lab=_67987_/A }
C {devices/lab_pin.sym} 47740 -8270 0 1 {name=p47433 lab=_67628_/X }
C {sky130_stdcells/buf_2.sym} 47700 -8270 0 0 {name=X_67628_ }
C {devices/lab_pin.sym} 47610 -8150 0 0 {name=p47434 lab=_83623_/CLK }
C {devices/lab_pin.sym} 47610 -8130 0 0 {name=p47435 lab=_48919_/Y }
C {devices/lab_pin.sym} 47790 -8150 0 1 {name=p47436 lab=_64684_/B }
C {sky130_stdcells/dfxtp_4.sym} 47700 -8140 0 0 {name=X_86462_ }
C {devices/lab_pin.sym} 47620 -8030 0 0 {name=p47437 lab=_52851_/Y }
C {devices/lab_pin.sym} 47620 -7990 0 0 {name=p47438 lab=_52839_/X }
C {devices/lab_pin.sym} 47620 -7950 0 0 {name=p47439 lab=_52853_/X }
C {devices/lab_pin.sym} 47780 -7990 0 1 {name=p47440 lab=_52854_/Y }
C {sky130_stdcells/a21oi_4.sym} 47700 -7990 0 0 {name=X_52854_ }
C {devices/lab_pin.sym} 47610 -7850 0 0 {name=p47441 lab=_83673_/CLK }
C {devices/lab_pin.sym} 47610 -7830 0 0 {name=p47442 lab=_70881_/Y }
C {devices/lab_pin.sym} 47790 -7850 0 1 {name=p47443 lab=_83674_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -7840 0 0 {name=X_83674_ }
C {devices/lab_pin.sym} 47610 -7710 0 0 {name=p47444 lab=_80740_/CLK }
C {devices/lab_pin.sym} 47610 -7690 0 0 {name=p47445 lab=_75760_/B }
C {devices/lab_pin.sym} 47790 -7710 0 1 {name=p47446 lab=_80854_/D }
C {sky130_stdcells/dfxtp_4.sym} 47700 -7700 0 0 {name=X_80886_ }
C {devices/lab_pin.sym} 47610 -7570 0 0 {name=p47447 lab=_88201_/CLK }
C {devices/lab_pin.sym} 47610 -7550 0 0 {name=p47448 lab=_41512_/X }
C {devices/lab_pin.sym} 47790 -7570 0 1 {name=p47449 lab=_88201_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -7560 0 0 {name=X_88201_ }
C {devices/lab_pin.sym} 47610 -7430 0 0 {name=p47450 lab=_83690_/CLK }
C {devices/lab_pin.sym} 47610 -7410 0 0 {name=p47451 lab=_85413_/D }
C {devices/lab_pin.sym} 47790 -7430 0 1 {name=p47452 lab=_85413_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -7420 0 0 {name=X_85413_ }
C {devices/lab_pin.sym} 47640 -7320 0 0 {name=p47453 lab=_51805_/A }
C {devices/lab_pin.sym} 47640 -7280 0 0 {name=p47454 lab=_51794_/B }
C {devices/lab_pin.sym} 47640 -7240 0 0 {name=p47455 lab=_51794_/C }
C {devices/lab_pin.sym} 47640 -7200 0 0 {name=p47456 lab=_46716_/X }
C {devices/lab_pin.sym} 47760 -7260 0 1 {name=p47457 lab=_51805_/X }
C {sky130_stdcells/and4_4.sym} 47700 -7260 0 0 {name=X_51805_ }
C {devices/lab_pin.sym} 47620 -7130 0 0 {name=p47458 lab=_58328_/X }
C {devices/lab_pin.sym} 47620 -7090 0 0 {name=p47459 lab=_83765_/Q }
C {devices/lab_pin.sym} 47620 -7050 0 0 {name=p47460 lab=_58360_/Y }
C {devices/lab_pin.sym} 47780 -7090 0 1 {name=p47461 lab=_84869_/D }
C {sky130_stdcells/o21a_4.sym} 47700 -7090 0 0 {name=X_58361_ }
C {devices/lab_pin.sym} 47610 -6950 0 0 {name=p47462 lab=_82743_/CLK }
C {devices/lab_pin.sym} 47610 -6930 0 0 {name=p47463 lab=_82625_/D }
C {devices/lab_pin.sym} 47790 -6950 0 1 {name=p47464 lab=_82625_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -6940 0 0 {name=X_82625_ }
C {devices/lab_pin.sym} 47640 -6820 0 0 {name=p47465 lab=_55572_/X }
C {devices/lab_pin.sym} 47640 -6780 0 0 {name=p47466 lab=_45470_/Y }
C {devices/lab_pin.sym} 47760 -6800 0 1 {name=p47467 lab=_55573_/Y }
C {sky130_stdcells/nor2_4.sym} 47700 -6800 0 0 {name=X_55573_ }
C {devices/lab_pin.sym} 47640 -6680 0 0 {name=p47468 lab=_67582_/A }
C {devices/lab_pin.sym} 47640 -6640 0 0 {name=p47469 lab=_67559_/B }
C {devices/lab_pin.sym} 47760 -6660 0 1 {name=p47470 lab=_67559_/X }
C {sky130_stdcells/and2_4.sym} 47700 -6660 0 0 {name=X_67559_ }
C {devices/lab_pin.sym} 47610 -6530 0 0 {name=p47471 lab=_86393_/CLK }
C {devices/lab_pin.sym} 47610 -6510 0 0 {name=p47472 lab=_86393_/D }
C {devices/lab_pin.sym} 47790 -6530 0 1 {name=p47473 lab=_86393_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -6520 0 0 {name=X_86393_ }
C {devices/lab_pin.sym} 47640 -6420 0 0 {name=p47474 lab=_52784_/X }
C {devices/lab_pin.sym} 47640 -6380 0 0 {name=p47475 lab=_52775_/B }
C {devices/lab_pin.sym} 47640 -6340 0 0 {name=p47476 lab=_52775_/C }
C {devices/lab_pin.sym} 47640 -6300 0 0 {name=p47477 lab=_52785_/D }
C {devices/lab_pin.sym} 47760 -6360 0 1 {name=p47478 lab=_52785_/X }
C {sky130_stdcells/and4_4.sym} 47700 -6360 0 0 {name=X_52785_ }
C {devices/lab_pin.sym} 47620 -6230 0 0 {name=p47479 lab=_57311_/X }
C {devices/lab_pin.sym} 47620 -6190 0 0 {name=p47480 lab=_57303_/Y }
C {devices/lab_pin.sym} 47620 -6150 0 0 {name=p47481 lab=_56704_/X }
C {devices/lab_pin.sym} 47780 -6190 0 1 {name=p47482 lab=_57312_/Y }
C {sky130_stdcells/a21oi_4.sym} 47700 -6190 0 0 {name=X_57312_ }
C {devices/lab_pin.sym} 47610 -6050 0 0 {name=p47483 lab=_88394_/CLK }
C {devices/lab_pin.sym} 47610 -6030 0 0 {name=p47484 lab=_41831_/Y }
C {devices/lab_pin.sym} 47790 -6050 0 1 {name=p47485 lab=_88132_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -6040 0 0 {name=X_88132_ }
C {devices/lab_pin.sym} 47640 -5920 0 0 {name=p47486 lab=_54518_/A }
C {devices/lab_pin.sym} 47640 -5880 0 0 {name=p47487 lab=_53345_/B }
C {devices/lab_pin.sym} 47760 -5900 0 1 {name=p47488 lab=_54524_/Y }
C {sky130_stdcells/nand2_4.sym} 47700 -5900 0 0 {name=X_54524_ }
C {devices/lab_pin.sym} 47610 -5770 0 0 {name=p47489 lab=_83711_/CLK }
C {devices/lab_pin.sym} 47610 -5750 0 0 {name=p47490 lab=_54965_/Y }
C {devices/lab_pin.sym} 47790 -5770 0 1 {name=p47491 lab=_85344_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -5760 0 0 {name=X_85344_ }
C {devices/lab_pin.sym} 47620 -5650 0 0 {name=p47492 lab=_51733_/Y }
C {devices/lab_pin.sym} 47620 -5610 0 0 {name=p47493 lab=_51719_/X }
C {devices/lab_pin.sym} 47620 -5570 0 0 {name=p47494 lab=_51735_/X }
C {devices/lab_pin.sym} 47780 -5610 0 1 {name=p47495 lab=_85955_/D }
C {sky130_stdcells/a21oi_4.sym} 47700 -5610 0 0 {name=X_51736_ }
C {devices/lab_pin.sym} 47660 -5470 0 0 {name=p47496 lab=DATA_TO_HASH[0] }
C {devices/lab_pin.sym} 47740 -5470 0 1 {name=p47497 lab=_70570_/Y }
C {sky130_stdcells/inv_2.sym} 47700 -5470 0 0 {name=X_70570_ }
C {devices/lab_pin.sym} 47640 -5360 0 0 {name=p47498 lab=_63672_/B }
C {devices/lab_pin.sym} 47640 -5320 0 0 {name=p47499 lab=_58248_/B }
C {devices/lab_pin.sym} 47760 -5340 0 1 {name=p47500 lab=_58292_/Y }
C {sky130_stdcells/nor2_4.sym} 47700 -5340 0 0 {name=X_58292_ }
C {devices/lab_pin.sym} 47610 -5210 0 0 {name=p47501 lab=_82557_/CLK }
C {devices/lab_pin.sym} 47610 -5190 0 0 {name=p47502 lab=_82556_/D }
C {devices/lab_pin.sym} 47790 -5210 0 1 {name=p47503 lab=_82556_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -5200 0 0 {name=X_82556_ }
C {devices/lab_pin.sym} 47620 -5090 0 0 {name=p47504 lab=_83939_/Q }
C {devices/lab_pin.sym} 47620 -5050 0 0 {name=p47505 lab=_69161_/X }
C {devices/lab_pin.sym} 47620 -5010 0 0 {name=p47506 lab=_69228_/X }
C {devices/lab_pin.sym} 47780 -5050 0 1 {name=p47507 lab=_69229_/X }
C {sky130_stdcells/a21bo_4.sym} 47700 -5050 0 0 {name=X_69229_ }
C {devices/lab_pin.sym} 47660 -4910 0 0 {name=p47508 lab=_44287_/X }
C {devices/lab_pin.sym} 47740 -4910 0 1 {name=p47509 lab=_57243_/X }
C {sky130_stdcells/buf_2.sym} 47700 -4910 0 0 {name=X_57243_ }
C {devices/lab_pin.sym} 47610 -4790 0 0 {name=p47510 lab=_81507_/CLK }
C {devices/lab_pin.sym} 47610 -4770 0 0 {name=p47511 lab=_76158_/B }
C {devices/lab_pin.sym} 47790 -4790 0 1 {name=p47512 lab=_75929_/A }
C {sky130_stdcells/dfxtp_4.sym} 47700 -4780 0 0 {name=X_81507_ }
C {devices/lab_pin.sym} 47610 -4650 0 0 {name=p47513 lab=_87814_/CLK }
C {devices/lab_pin.sym} 47610 -4630 0 0 {name=p47514 lab=_42034_/Y }
C {devices/lab_pin.sym} 47790 -4650 0 1 {name=p47515 lab=_73273_/A }
C {sky130_stdcells/dfxtp_4.sym} 47700 -4640 0 0 {name=X_88063_ }
C {devices/lab_pin.sym} 47640 -4540 0 0 {name=p47516 lab=_54453_/X }
C {devices/lab_pin.sym} 47640 -4500 0 0 {name=p47517 lab=_54440_/B }
C {devices/lab_pin.sym} 47640 -4460 0 0 {name=p47518 lab=_54471_/C }
C {devices/lab_pin.sym} 47640 -4420 0 0 {name=p47519 lab=_46942_/Y }
C {devices/lab_pin.sym} 47760 -4480 0 1 {name=p47520 lab=_54455_/X }
C {sky130_stdcells/and4_4.sym} 47700 -4480 0 0 {name=X_54455_ }
C {devices/lab_pin.sym} 47610 -4330 0 0 {name=p47521 lab=_85277_/CLK }
C {devices/lab_pin.sym} 47610 -4310 0 0 {name=p47522 lab=_85275_/D }
C {devices/lab_pin.sym} 47790 -4330 0 1 {name=p47523 lab=_56208_/C }
C {sky130_stdcells/dfxtp_4.sym} 47700 -4320 0 0 {name=X_85275_ }
C {devices/lab_pin.sym} 47660 -4190 0 0 {name=p47524 lab=_51639_/A }
C {devices/lab_pin.sym} 47740 -4190 0 1 {name=p47525 lab=_51667_/X }
C {sky130_stdcells/buf_2.sym} 47700 -4190 0 0 {name=X_51667_ }
C {devices/lab_pin.sym} 47610 -4070 0 0 {name=p47526 lab=_82580_/CLK }
C {devices/lab_pin.sym} 47610 -4050 0 0 {name=p47527 lab=_82487_/D }
C {devices/lab_pin.sym} 47790 -4070 0 1 {name=p47528 lab=_78177_/B }
C {sky130_stdcells/dfxtp_4.sym} 47700 -4060 0 0 {name=X_82487_ }
C {devices/lab_pin.sym} 47610 -3930 0 0 {name=p47529 lab=_88288_/CLK }
C {devices/lab_pin.sym} 47610 -3910 0 0 {name=p47530 lab=_44655_/Y }
C {devices/lab_pin.sym} 47790 -3930 0 1 {name=p47531 lab=_87014_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -3920 0 0 {name=X_87014_ }
C {devices/lab_pin.sym} 47620 -3820 0 0 {name=p47532 lab=_41416_/X }
C {devices/lab_pin.sym} 47620 -3780 0 0 {name=p47533 lab=_41418_/X }
C {devices/lab_pin.sym} 47620 -3740 0 0 {name=p47534 lab=_67909_/B }
C {devices/lab_pin.sym} 47620 -3700 0 0 {name=p47535 lab=_41419_/X }
C {devices/lab_pin.sym} 47780 -3760 0 1 {name=p47536 lab=_88219_/D }
C {sky130_stdcells/a2bb2o_4.sym} 47700 -3760 0 0 {name=X_41420_ }
C {devices/lab_pin.sym} 47640 -3620 0 0 {name=p47537 lab=_53405_/X }
C {devices/lab_pin.sym} 47640 -3580 0 0 {name=p47538 lab=_47165_/Y }
C {devices/lab_pin.sym} 47760 -3600 0 1 {name=p47539 lab=_53406_/Y }
C {sky130_stdcells/nand2_4.sym} 47700 -3600 0 0 {name=X_53406_ }
C {devices/lab_pin.sym} 47660 -3470 0 0 {name=p47540 lab=_72155_/A }
C {devices/lab_pin.sym} 47740 -3470 0 1 {name=p47541 lab=_72240_/X }
C {sky130_stdcells/buf_2.sym} 47700 -3470 0 0 {name=X_72240_ }
C {devices/lab_pin.sym} 47610 -3350 0 0 {name=p47542 lab=_85315_/CLK }
C {devices/lab_pin.sym} 47610 -3330 0 0 {name=p47543 lab=_84226_/D }
C {devices/lab_pin.sym} 47790 -3350 0 1 {name=p47544 lab=_84226_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -3340 0 0 {name=X_84226_ }
C {devices/lab_pin.sym} 47620 -3230 0 0 {name=p47545 lab=_86166_/Q }
C {devices/lab_pin.sym} 47620 -3190 0 0 {name=p47546 lab=_50594_/X }
C {devices/lab_pin.sym} 47620 -3150 0 0 {name=p47547 lab=_50617_/Y }
C {devices/lab_pin.sym} 47780 -3190 0 1 {name=p47548 lab=_50618_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -3190 0 0 {name=X_50618_ }
C {devices/lab_pin.sym} 47620 -3070 0 0 {name=p47549 lab=_57172_/Y }
C {devices/lab_pin.sym} 47620 -3030 0 0 {name=p47550 lab=_57173_/Y }
C {devices/lab_pin.sym} 47620 -2990 0 0 {name=p47551 lab=_57121_/X }
C {devices/lab_pin.sym} 47780 -3030 0 1 {name=p47552 lab=_57175_/B }
C {sky130_stdcells/o21ai_4.sym} 47700 -3030 0 0 {name=X_57174_ }
C {devices/lab_pin.sym} 47610 -2890 0 0 {name=p47553 lab=_81532_/CLK }
C {devices/lab_pin.sym} 47610 -2870 0 0 {name=p47554 lab=_81470_/Q }
C {devices/lab_pin.sym} 47790 -2890 0 1 {name=p47555 lab=_76133_/B }
C {sky130_stdcells/dfxtp_4.sym} 47700 -2880 0 0 {name=X_81438_ }
C {devices/lab_pin.sym} 47640 -2780 0 0 {name=p47556 lab=_54395_/A }
C {devices/lab_pin.sym} 47640 -2740 0 0 {name=p47557 lab=_54395_/B }
C {devices/lab_pin.sym} 47640 -2700 0 0 {name=p47558 lab=_54395_/C }
C {devices/lab_pin.sym} 47640 -2660 0 0 {name=p47559 lab=_46820_/Y }
C {devices/lab_pin.sym} 47760 -2720 0 1 {name=p47560 lab=_54386_/X }
C {sky130_stdcells/and4_4.sym} 47700 -2720 0 0 {name=X_54386_ }
C {devices/lab_pin.sym} 47640 -2600 0 0 {name=p47561 lab=_51580_/A }
C {devices/lab_pin.sym} 47640 -2560 0 0 {name=p47562 lab=_51603_/B }
C {devices/lab_pin.sym} 47640 -2520 0 0 {name=p47563 lab=_51603_/C }
C {devices/lab_pin.sym} 47640 -2480 0 0 {name=p47564 lab=_53125_/D }
C {devices/lab_pin.sym} 47760 -2540 0 1 {name=p47565 lab=_51598_/X }
C {sky130_stdcells/and4_4.sym} 47700 -2540 0 0 {name=X_51598_ }
C {devices/lab_pin.sym} 47620 -2410 0 0 {name=p47566 lab=_56112_/X }
C {devices/lab_pin.sym} 47620 -2370 0 0 {name=p47567 lab=_56121_/X }
C {devices/lab_pin.sym} 47620 -2330 0 0 {name=p47568 lab=_56124_/Y }
C {devices/lab_pin.sym} 47780 -2370 0 1 {name=p47569 lab=_56125_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -2370 0 0 {name=X_56125_ }
C {devices/lab_pin.sym} 47620 -2250 0 0 {name=p47570 lab=_41324_/X }
C {devices/lab_pin.sym} 47620 -2210 0 0 {name=p47571 lab=_82901_/Q }
C {devices/lab_pin.sym} 47620 -2170 0 0 {name=p47572 lab=_41350_/X }
C {devices/lab_pin.sym} 47780 -2210 0 1 {name=p47573 lab=_41351_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -2210 0 0 {name=X_41351_ }
C {devices/lab_pin.sym} 47620 -2090 0 0 {name=p47574 lab=_85652_/Q }
C {devices/lab_pin.sym} 47620 -2050 0 0 {name=p47575 lab=_53324_/X }
C {devices/lab_pin.sym} 47620 -2010 0 0 {name=p47576 lab=_53336_/Y }
C {devices/lab_pin.sym} 47780 -2050 0 1 {name=p47577 lab=_53337_/Y }
C {sky130_stdcells/o21ai_4.sym} 47700 -2050 0 0 {name=X_53337_ }
C {devices/lab_pin.sym} 47620 -1930 0 0 {name=p47578 lab=_72168_/Y }
C {devices/lab_pin.sym} 47620 -1890 0 0 {name=p47579 lab=_72170_/Y }
C {devices/lab_pin.sym} 47620 -1850 0 0 {name=p47580 lab=_59297_/X }
C {devices/lab_pin.sym} 47780 -1890 0 1 {name=p47581 lab=_72171_/X }
C {sky130_stdcells/a21o_4.sym} 47700 -1890 0 0 {name=X_72171_ }
C {devices/lab_pin.sym} 47610 -1750 0 0 {name=p47582 lab=_84161_/CLK }
C {devices/lab_pin.sym} 47610 -1730 0 0 {name=p47583 lab=_66093_/X }
C {devices/lab_pin.sym} 47790 -1750 0 1 {name=p47584 lab=_84157_/Q }
C {sky130_stdcells/dfxtp_4.sym} 47700 -1740 0 0 {name=X_84157_ }
C {devices/lab_pin.sym} 47640 -1620 0 0 {name=p47585 lab=_50541_/A }
C {devices/lab_pin.sym} 47640 -1580 0 0 {name=p47586 lab=_48695_/B }
C {devices/lab_pin.sym} 47760 -1600 0 1 {name=p47587 lab=_50549_/Y }
C {sky130_stdcells/nand2_4.sym} 47700 -1600 0 0 {name=X_50549_ }
C {devices/lab_pin.sym} 47610 -1470 0 0 {name=p47588 lab=_81428_/CLK }
C {devices/lab_pin.sym} 47610 -1450 0 0 {name=p47589 lab=_76867_/Y }
C {devices/lab_pin.sym} 47790 -1470 0 1 {name=p47590 lab=_76500_/A }
C {sky130_stdcells/dfxtp_4.sym} 47700 -1460 0 0 {name=X_81369_ }
C {devices/lab_pin.sym} 47620 -1350 0 0 {name=p47591 lab=_49135_/X }
C {devices/lab_pin.sym} 47620 -1310 0 0 {name=p47592 lab=_71117_/X }
C {devices/lab_pin.sym} 47620 -1270 0 0 {name=p47593 lab=_71121_/Y }
C {devices/lab_pin.sym} 47780 -1310 0 1 {name=p47594 lab=_83600_/D }
C {sky130_stdcells/o21ai_4.sym} 47700 -1310 0 0 {name=X_71122_ }
C {devices/lab_pin.sym} 47610 -1170 0 0 {name=p47595 lab=_82998_/CLK }
C {devices/lab_pin.sym} 47610 -1150 0 0 {name=p47596 lab=_74298_/X }
C {devices/lab_pin.sym} 47790 -1170 0 1 {name=p47597 lab=_70280_/A }
C {sky130_stdcells/dfxtp_4.sym} 47700 -1160 0 0 {name=X_83108_ }
C {devices/lab_pin.sym} 47640 -1050 0 0 {name=p47598 lab=_87176_/Q }
C {devices/lab_pin.sym} 47640 -1010 0 0 {name=p47599 lab=_44070_/B }
C {devices/lab_pin.sym} 47640 -970 0 0 {name=p47600 lab=_43972_/B }
C {devices/lab_pin.sym} 47760 -1010 0 1 {name=p47601 lab=_44071_/A }
C {sky130_stdcells/nor3_4.sym} 47700 -1010 0 0 {name=X_44070_ }
C {devices/lab_pin.sym} 47640 -890 0 0 {name=p47602 lab=_56052_/A }
C {devices/lab_pin.sym} 47640 -850 0 0 {name=p47603 lab=_56052_/B }
C {devices/lab_pin.sym} 47640 -810 0 0 {name=p47604 lab=_55915_/B }
C {devices/lab_pin.sym} 47760 -850 0 1 {name=p47605 lab=_56056_/Y }
C {sky130_stdcells/nand3_4.sym} 47700 -850 0 0 {name=X_56056_ }
C {devices/lab_pin.sym} 47660 -710 0 0 {name=p47606 lab=_41281_/Y }
C {devices/lab_pin.sym} 47740 -710 0 1 {name=p47607 lab=_41282_/X }
C {sky130_stdcells/buf_2.sym} 47700 -710 0 0 {name=X_41282_ }
C {devices/lab_pin.sym} 48580 -42150 0 0 {name=p47608 lab=_51900_/A }
C {devices/lab_pin.sym} 48660 -42150 0 1 {name=p47609 lab=_53268_/X }
C {sky130_stdcells/buf_2.sym} 48620 -42150 0 0 {name=X_53268_ }
C {devices/lab_pin.sym} 48530 -42030 0 0 {name=p47610 lab=_83918_/CLK }
C {devices/lab_pin.sym} 48530 -42010 0 0 {name=p47611 lab=_66993_/X }
C {devices/lab_pin.sym} 48710 -42030 0 1 {name=p47612 lab=_84088_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -42020 0 0 {name=X_84088_ }
C {devices/lab_pin.sym} 48580 -41890 0 0 {name=p47613 lab=_43024_/A }
C {devices/lab_pin.sym} 48660 -41890 0 1 {name=p47614 lab=_43021_/X }
C {sky130_stdcells/buf_2.sym} 48620 -41890 0 0 {name=X_43021_ }
C {devices/lab_pin.sym} 48560 -41780 0 0 {name=p47615 lab=_55011_/A }
C {devices/lab_pin.sym} 48560 -41740 0 0 {name=p47616 lab=_47610_/A }
C {devices/lab_pin.sym} 48680 -41760 0 1 {name=p47617 lab=_55007_/Y }
C {sky130_stdcells/nand2_4.sym} 48620 -41760 0 0 {name=X_55007_ }
C {devices/lab_pin.sym} 48540 -41650 0 0 {name=p47618 lab=_52217_/Y }
C {devices/lab_pin.sym} 48540 -41610 0 0 {name=p47619 lab=_52203_/X }
C {devices/lab_pin.sym} 48540 -41570 0 0 {name=p47620 lab=_52218_/X }
C {devices/lab_pin.sym} 48700 -41610 0 1 {name=p47621 lab=_85866_/D }
C {sky130_stdcells/a21oi_4.sym} 48620 -41610 0 0 {name=X_52219_ }
C {devices/lab_pin.sym} 48540 -41490 0 0 {name=p47622 lab=_48889_/B }
C {devices/lab_pin.sym} 48540 -41450 0 0 {name=p47623 lab=_71047_/X }
C {devices/lab_pin.sym} 48540 -41410 0 0 {name=p47624 lab=_71052_/Y }
C {devices/lab_pin.sym} 48700 -41450 0 1 {name=p47625 lab=_71053_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -41450 0 0 {name=X_71053_ }
C {devices/lab_pin.sym} 48560 -41320 0 0 {name=p47626 lab=_81700_/D }
C {devices/lab_pin.sym} 48560 -41280 0 0 {name=p47627 lab=_75930_/B }
C {devices/lab_pin.sym} 48680 -41300 0 1 {name=p47628 lab=_75933_/A }
C {sky130_stdcells/nor2_4.sym} 48620 -41300 0 0 {name=X_75930_ }
C {devices/lab_pin.sym} 48530 -41170 0 0 {name=p47629 lab=_85311_/CLK }
C {devices/lab_pin.sym} 48530 -41150 0 0 {name=p47630 lab=_74546_/Y }
C {devices/lab_pin.sym} 48710 -41170 0 1 {name=p47631 lab=_74545_/C }
C {sky130_stdcells/dfxtp_4.sym} 48620 -41160 0 0 {name=X_83039_ }
C {devices/lab_pin.sym} 48530 -41030 0 0 {name=p47632 lab=_88171_/CLK }
C {devices/lab_pin.sym} 48530 -41010 0 0 {name=p47633 lab=_42335_/Y }
C {devices/lab_pin.sym} 48710 -41030 0 1 {name=p47634 lab=_87916_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -41020 0 0 {name=X_87916_ }
C {devices/lab_pin.sym} 48580 -40890 0 0 {name=p47635 lab=_53199_/A }
C {devices/lab_pin.sym} 48660 -40890 0 1 {name=p47636 lab=_53219_/A }
C {sky130_stdcells/buf_2.sym} 48620 -40890 0 0 {name=X_53199_ }
C {devices/lab_pin.sym} 48540 -40790 0 0 {name=p47637 lab=_82555_/D }
C {devices/lab_pin.sym} 48540 -40750 0 0 {name=p47638 lab=_69988_/X }
C {devices/lab_pin.sym} 48540 -40710 0 0 {name=p47639 lab=_70003_/X }
C {devices/lab_pin.sym} 48700 -40750 0 1 {name=p47640 lab=_70004_/X }
C {sky130_stdcells/a21bo_4.sym} 48620 -40750 0 0 {name=X_70004_ }
C {devices/lab_pin.sym} 48540 -40650 0 0 {name=p47641 lab=_59805_/Y }
C {devices/lab_pin.sym} 48540 -40610 0 0 {name=p47642 lab=_59840_/A }
C {devices/lab_pin.sym} 48540 -40570 0 0 {name=p47643 lab=_59812_/Y }
C {devices/lab_pin.sym} 48540 -40530 0 0 {name=p47644 lab=_80442_/A }
C {devices/lab_pin.sym} 48540 -40490 0 0 {name=p47645 lab=_59814_/X }
C {devices/lab_pin.sym} 48700 -40570 0 1 {name=p47646 lab=_84696_/D }
C {sky130_stdcells/o32a_4.sym} 48620 -40570 0 0 {name=X_59815_ }
C {devices/lab_pin.sym} 48560 -40420 0 0 {name=p47647 lab=_75860_/A }
C {devices/lab_pin.sym} 48560 -40380 0 0 {name=p47648 lab=_75860_/B }
C {devices/lab_pin.sym} 48680 -40400 0 1 {name=p47649 lab=_75864_/A }
C {sky130_stdcells/or2_4.sym} 48620 -40400 0 0 {name=X_75861_ }
C {devices/lab_pin.sym} 48530 -40270 0 0 {name=p47650 lab=_87850_/CLK }
C {devices/lab_pin.sym} 48530 -40250 0 0 {name=p47651 lab=_87847_/D }
C {devices/lab_pin.sym} 48710 -40270 0 1 {name=p47652 lab=_68668_/A }
C {sky130_stdcells/dfxtp_4.sym} 48620 -40260 0 0 {name=X_87847_ }
C {devices/lab_pin.sym} 48560 -40140 0 0 {name=p47653 lab=_77601_/A }
C {devices/lab_pin.sym} 48560 -40100 0 0 {name=p47654 lab=_82107_/D }
C {devices/lab_pin.sym} 48680 -40120 0 1 {name=p47655 lab=_77600_/Y }
C {sky130_stdcells/nor2_4.sym} 48620 -40120 0 0 {name=X_77600_ }
C {devices/lab_pin.sym} 48540 -40010 0 0 {name=p47656 lab=_46168_/Y }
C {devices/lab_pin.sym} 48540 -39970 0 0 {name=p47657 lab=_46169_/Y }
C {devices/lab_pin.sym} 48540 -39930 0 0 {name=p47658 lab=_46171_/Y }
C {devices/lab_pin.sym} 48700 -39970 0 1 {name=p47659 lab=_80665_/D }
C {sky130_stdcells/a21oi_4.sym} 48620 -39970 0 0 {name=X_74812_ }
C {devices/lab_pin.sym} 48580 -39830 0 0 {name=p47660 lab=_47714_/A }
C {devices/lab_pin.sym} 48660 -39830 0 1 {name=p47661 lab=_47760_/X }
C {sky130_stdcells/buf_2.sym} 48620 -39830 0 0 {name=X_47760_ }
C {devices/lab_pin.sym} 48560 -39720 0 0 {name=p47662 lab=_59689_/A }
C {devices/lab_pin.sym} 48560 -39680 0 0 {name=p47663 lab=_59631_/B }
C {devices/lab_pin.sym} 48680 -39700 0 1 {name=p47664 lab=_59746_/Y }
C {sky130_stdcells/nand2_4.sym} 48620 -39700 0 0 {name=X_59746_ }
C {devices/lab_pin.sym} 48540 -39590 0 0 {name=p47665 lab=_78561_/A }
C {devices/lab_pin.sym} 48540 -39550 0 0 {name=p47666 lab=_78577_/X }
C {devices/lab_pin.sym} 48540 -39510 0 0 {name=p47667 lab=_78579_/Y }
C {devices/lab_pin.sym} 48700 -39550 0 1 {name=p47668 lab=_78581_/B }
C {sky130_stdcells/a21oi_4.sym} 48620 -39550 0 0 {name=X_78580_ }
C {devices/lab_pin.sym} 48580 -39410 0 0 {name=p47669 lab=_44972_/A }
C {devices/lab_pin.sym} 48660 -39410 0 1 {name=p47670 lab=_44972_/X }
C {sky130_stdcells/buf_2.sym} 48620 -39410 0 0 {name=X_44972_ }
C {devices/lab_pin.sym} 48540 -39310 0 0 {name=p47671 lab=_56613_/X }
C {devices/lab_pin.sym} 48540 -39270 0 0 {name=p47672 lab=_56952_/X }
C {devices/lab_pin.sym} 48540 -39230 0 0 {name=p47673 lab=_56957_/Y }
C {devices/lab_pin.sym} 48700 -39270 0 1 {name=p47674 lab=_85113_/D }
C {sky130_stdcells/a21oi_4.sym} 48620 -39270 0 0 {name=X_56958_ }
C {devices/lab_pin.sym} 48540 -39150 0 0 {name=p47675 lab=_75788_/Y }
C {devices/lab_pin.sym} 48540 -39110 0 0 {name=p47676 lab=_75775_/Y }
C {devices/lab_pin.sym} 48540 -39070 0 0 {name=p47677 lab=_75791_/Y }
C {devices/lab_pin.sym} 48700 -39110 0 1 {name=p47678 lab=_75793_/B }
C {sky130_stdcells/o21ai_4.sym} 48620 -39110 0 0 {name=X_75792_ }
C {devices/lab_pin.sym} 48530 -38970 0 0 {name=p47679 lab=_87533_/CLK }
C {devices/lab_pin.sym} 48530 -38950 0 0 {name=p47680 lab=_87778_/D }
C {devices/lab_pin.sym} 48710 -38970 0 1 {name=p47681 lab=_87778_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -38960 0 0 {name=X_87778_ }
C {devices/lab_pin.sym} 48580 -38830 0 0 {name=p47682 lab=_52632_/B }
C {devices/lab_pin.sym} 48660 -38830 0 1 {name=p47683 lab=_51800_/B }
C {sky130_stdcells/buf_2.sym} 48620 -38830 0 0 {name=X_46711_ }
C {devices/lab_pin.sym} 48540 -38730 0 0 {name=p47684 lab=_77519_/A }
C {devices/lab_pin.sym} 48540 -38690 0 0 {name=p47685 lab=_77529_/Y }
C {devices/lab_pin.sym} 48540 -38650 0 0 {name=p47686 lab=_77530_/Y }
C {devices/lab_pin.sym} 48700 -38690 0 1 {name=p47687 lab=_77540_/A }
C {sky130_stdcells/o21a_4.sym} 48620 -38690 0 0 {name=X_77531_ }
C {devices/lab_pin.sym} 48580 -38550 0 0 {name=p47688 lab=_43922_/Y }
C {devices/lab_pin.sym} 48660 -38550 0 1 {name=p47689 lab=_87197_/D }
C {sky130_stdcells/inv_2.sym} 48620 -38550 0 0 {name=X_43923_ }
C {devices/lab_pin.sym} 48540 -38460 0 0 {name=p47690 lab=_56216_/C }
C {devices/lab_pin.sym} 48540 -38420 0 0 {name=p47691 lab=_44106_/C }
C {devices/lab_pin.sym} 48540 -38380 0 0 {name=p47692 lab=_44051_/A }
C {devices/lab_pin.sym} 48540 -38340 0 0 {name=p47693 lab=_55908_/X }
C {devices/lab_pin.sym} 48700 -38400 0 1 {name=p47694 lab=_55909_/X }
C {sky130_stdcells/a211o_4.sym} 48620 -38400 0 0 {name=X_55909_ }
C {devices/lab_pin.sym} 48580 -38250 0 0 {name=p47695 lab=_70730_/X }
C {devices/lab_pin.sym} 48660 -38250 0 1 {name=p47696 lab=_74804_/C }
C {sky130_stdcells/buf_2.sym} 48620 -38250 0 0 {name=X_74743_ }
C {devices/lab_pin.sym} 48530 -38130 0 0 {name=p47697 lab=_86121_/CLK }
C {devices/lab_pin.sym} 48530 -38110 0 0 {name=p47698 lab=_46532_/Y }
C {devices/lab_pin.sym} 48710 -38130 0 1 {name=p47699 lab=_86729_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -38120 0 0 {name=X_86729_ }
C {devices/lab_pin.sym} 48580 -37990 0 0 {name=p47700 lab=_47691_/A }
C {devices/lab_pin.sym} 48660 -37990 0 1 {name=p47701 lab=_53191_/D }
C {sky130_stdcells/buf_2.sym} 48620 -37990 0 0 {name=X_47691_ }
C {devices/lab_pin.sym} 48560 -37890 0 0 {name=p47702 lab=_71867_/A }
C {devices/lab_pin.sym} 48560 -37850 0 0 {name=p47703 lab=_70538_/X }
C {devices/lab_pin.sym} 48560 -37810 0 0 {name=p47704 lab=_71404_/B }
C {devices/lab_pin.sym} 48680 -37850 0 1 {name=p47705 lab=_71955_/Y }
C {sky130_stdcells/nor3_4.sym} 48620 -37850 0 0 {name=X_71955_ }
C {devices/lab_pin.sym} 48540 -37750 0 0 {name=p47706 lab=_59655_/X }
C {devices/lab_pin.sym} 48540 -37710 0 0 {name=p47707 lab=_59687_/B }
C {devices/lab_pin.sym} 48540 -37670 0 0 {name=p47708 lab=_59651_/C }
C {devices/lab_pin.sym} 48540 -37630 0 0 {name=p47709 lab=_59763_/A }
C {devices/lab_pin.sym} 48540 -37600 0 0 {name=p47710 lab=_59676_/Y }
C {devices/lab_pin.sym} 48700 -37670 0 1 {name=p47711 lab=_59677_/Y }
C {sky130_stdcells/a41oi_4.sym} 48620 -37670 0 0 {name=X_59677_ }
C {devices/lab_pin.sym} 48560 -37520 0 0 {name=p47712 lab=_55288_/A }
C {devices/lab_pin.sym} 48560 -37480 0 0 {name=p47713 lab=_56889_/B }
C {devices/lab_pin.sym} 48680 -37500 0 1 {name=p47714 lab=_56889_/X }
C {sky130_stdcells/and2_4.sym} 48620 -37500 0 0 {name=X_56889_ }
C {devices/lab_pin.sym} 48540 -37390 0 0 {name=p47715 lab=_49428_/Y }
C {devices/lab_pin.sym} 48540 -37350 0 0 {name=p47716 lab=_49405_/X }
C {devices/lab_pin.sym} 48540 -37310 0 0 {name=p47717 lab=_49429_/X }
C {devices/lab_pin.sym} 48700 -37350 0 1 {name=p47718 lab=_49430_/Y }
C {sky130_stdcells/a21oi_4.sym} 48620 -37350 0 0 {name=X_49430_ }
C {devices/lab_pin.sym} 48540 -37230 0 0 {name=p47719 lab=_51008_/B }
C {devices/lab_pin.sym} 48540 -37190 0 0 {name=p47720 lab=_70885_/A }
C {devices/lab_pin.sym} 48540 -37150 0 0 {name=p47721 lab=_70905_/Y }
C {devices/lab_pin.sym} 48700 -37190 0 1 {name=p47722 lab=_83666_/D }
C {sky130_stdcells/o21ai_4.sym} 48620 -37190 0 0 {name=X_70906_ }
C {devices/lab_pin.sym} 48540 -37070 0 0 {name=p47723 lab=_58125_/X }
C {devices/lab_pin.sym} 48540 -37030 0 0 {name=p47724 lab=_85788_/Q }
C {devices/lab_pin.sym} 48540 -36990 0 0 {name=p47725 lab=_58126_/X }
C {devices/lab_pin.sym} 48700 -37030 0 1 {name=p47726 lab=_58628_/X }
C {sky130_stdcells/o21a_4.sym} 48620 -37030 0 0 {name=X_58628_ }
C {devices/lab_pin.sym} 48580 -36890 0 0 {name=p47727 lab=_52590_/B }
C {devices/lab_pin.sym} 48660 -36890 0 1 {name=p47728 lab=_51765_/B }
C {sky130_stdcells/buf_2.sym} 48620 -36890 0 0 {name=X_46642_ }
C {devices/lab_pin.sym} 48540 -36790 0 0 {name=p47729 lab=_77447_/X }
C {devices/lab_pin.sym} 48540 -36750 0 0 {name=p47730 lab=_77448_/Y }
C {devices/lab_pin.sym} 48540 -36710 0 0 {name=p47731 lab=_77442_/X }
C {devices/lab_pin.sym} 48700 -36750 0 1 {name=p47732 lab=_77462_/Y }
C {sky130_stdcells/a21boi_4.sym} 48620 -36750 0 0 {name=X_77462_ }
C {devices/lab_pin.sym} 48580 -36610 0 0 {name=p47733 lab=_43854_/A }
C {devices/lab_pin.sym} 48660 -36610 0 1 {name=p47734 lab=_43854_/X }
C {sky130_stdcells/buf_2.sym} 48620 -36610 0 0 {name=X_43854_ }
C {devices/lab_pin.sym} 48540 -36510 0 0 {name=p47735 lab=_74630_/X }
C {devices/lab_pin.sym} 48540 -36470 0 0 {name=p47736 lab=_57007_/X }
C {devices/lab_pin.sym} 48540 -36430 0 0 {name=p47737 lab=_74673_/Y }
C {devices/lab_pin.sym} 48700 -36470 0 1 {name=p47738 lab=_74674_/X }
C {sky130_stdcells/o21a_4.sym} 48620 -36470 0 0 {name=X_74674_ }
C {devices/lab_pin.sym} 48540 -36350 0 0 {name=p47739 lab=_71870_/Y }
C {devices/lab_pin.sym} 48540 -36310 0 0 {name=p47740 lab=_83340_/Q }
C {devices/lab_pin.sym} 48540 -36270 0 0 {name=p47741 lab=_71885_/Y }
C {devices/lab_pin.sym} 48700 -36310 0 1 {name=p47742 lab=_71886_/X }
C {sky130_stdcells/a21o_4.sym} 48620 -36310 0 0 {name=X_71886_ }
C {devices/lab_pin.sym} 48580 -36170 0 0 {name=p47743 lab=_79201_/A }
C {devices/lab_pin.sym} 48660 -36170 0 1 {name=p47744 lab=_79201_/Y }
C {sky130_stdcells/inv_2.sym} 48620 -36170 0 0 {name=X_79201_ }
C {devices/lab_pin.sym} 48540 -36070 0 0 {name=p47745 lab=_76409_/Y }
C {devices/lab_pin.sym} 48540 -36030 0 0 {name=p47746 lab=_76411_/Y }
C {devices/lab_pin.sym} 48540 -35990 0 0 {name=p47747 lab=_76408_/Y }
C {devices/lab_pin.sym} 48700 -36030 0 1 {name=p47748 lab=_76417_/C }
C {sky130_stdcells/o21ai_4.sym} 48620 -36030 0 0 {name=X_76413_ }
C {devices/lab_pin.sym} 48580 -35890 0 0 {name=p47749 lab=_42700_/A }
C {devices/lab_pin.sym} 48660 -35890 0 1 {name=p47750 lab=_42805_/X }
C {sky130_stdcells/buf_2.sym} 48620 -35890 0 0 {name=X_42805_ }
C {devices/lab_pin.sym} 48580 -35770 0 0 {name=p47751 lab=_49205_/A }
C {devices/lab_pin.sym} 48660 -35770 0 1 {name=p47752 lab=_49382_/A }
C {sky130_stdcells/buf_2.sym} 48620 -35770 0 0 {name=X_49361_ }
C {devices/lab_pin.sym} 48560 -35660 0 0 {name=p47753 lab=_87856_/Q }
C {devices/lab_pin.sym} 48560 -35620 0 0 {name=p47754 lab=_73624_/X }
C {devices/lab_pin.sym} 48680 -35640 0 1 {name=p47755 lab=_73625_/Y }
C {sky130_stdcells/nor2_4.sym} 48620 -35640 0 0 {name=X_73625_ }
C {devices/lab_pin.sym} 48580 -35510 0 0 {name=p47756 lab=_52563_/B }
C {devices/lab_pin.sym} 48660 -35510 0 1 {name=p47757 lab=_50870_/B }
C {sky130_stdcells/buf_2.sym} 48620 -35510 0 0 {name=X_46573_ }
C {devices/lab_pin.sym} 48540 -35410 0 0 {name=p47758 lab=_46625_/X }
C {devices/lab_pin.sym} 48540 -35370 0 0 {name=p47759 lab=_70831_/X }
C {devices/lab_pin.sym} 48540 -35330 0 0 {name=p47760 lab=_70836_/Y }
C {devices/lab_pin.sym} 48700 -35370 0 1 {name=p47761 lab=_70837_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -35370 0 0 {name=X_70837_ }
C {devices/lab_pin.sym} 48580 -35230 0 0 {name=p47762 lab=_58423_/A }
C {devices/lab_pin.sym} 48660 -35230 0 1 {name=p47763 lab=_58559_/X }
C {sky130_stdcells/buf_2.sym} 48620 -35230 0 0 {name=X_58559_ }
C {devices/lab_pin.sym} 48560 -35120 0 0 {name=p47764 lab=_77406_/A }
C {devices/lab_pin.sym} 48560 -35080 0 0 {name=p47765 lab=_82094_/D }
C {devices/lab_pin.sym} 48680 -35100 0 1 {name=p47766 lab=_77394_/B }
C {sky130_stdcells/xor2_4.sym} 48620 -35100 0 0 {name=X_77393_ }
C {devices/lab_pin.sym} 48580 -34970 0 0 {name=p47767 lab=_43784_/Y }
C {devices/lab_pin.sym} 48660 -34970 0 1 {name=p47768 lab=_87269_/D }
C {sky130_stdcells/inv_2.sym} 48620 -34970 0 0 {name=X_43785_ }
C {devices/lab_pin.sym} 48580 -34850 0 0 {name=p47769 lab=_40996_/Y }
C {devices/lab_pin.sym} 48660 -34850 0 1 {name=p47770 lab=_40997_/Y }
C {sky130_stdcells/inv_2.sym} 48620 -34850 0 0 {name=X_40997_ }
C {devices/lab_pin.sym} 48580 -34730 0 0 {name=p47771 lab=_48088_/B }
C {devices/lab_pin.sym} 48660 -34730 0 1 {name=p47772 lab=_50356_/B }
C {sky130_stdcells/buf_2.sym} 48620 -34730 0 0 {name=X_48312_ }
C {devices/lab_pin.sym} 48560 -34620 0 0 {name=p47773 lab=_79132_/A }
C {devices/lab_pin.sym} 48560 -34580 0 0 {name=p47774 lab=_79132_/B }
C {devices/lab_pin.sym} 48680 -34600 0 1 {name=p47775 lab=_79132_/X }
C {sky130_stdcells/xor2_4.sym} 48620 -34600 0 0 {name=X_79132_ }
C {devices/lab_pin.sym} 48540 -34490 0 0 {name=p47776 lab=_45518_/X }
C {devices/lab_pin.sym} 48540 -34450 0 0 {name=p47777 lab=_45522_/X }
C {devices/lab_pin.sym} 48540 -34410 0 0 {name=p47778 lab=_45523_/X }
C {devices/lab_pin.sym} 48700 -34450 0 1 {name=p47779 lab=_45524_/X }
C {sky130_stdcells/a21o_4.sym} 48620 -34450 0 0 {name=X_45524_ }
C {devices/lab_pin.sym} 48580 -34310 0 0 {name=p47780 lab=_81648_/Q }
C {devices/lab_pin.sym} 48660 -34310 0 1 {name=p47781 lab=_76344_/Y }
C {sky130_stdcells/inv_2.sym} 48620 -34310 0 0 {name=X_76344_ }
C {devices/lab_pin.sym} 48580 -34190 0 0 {name=p47782 lab=_42736_/A }
C {devices/lab_pin.sym} 48660 -34190 0 1 {name=p47783 lab=_87744_/D }
C {sky130_stdcells/inv_2.sym} 48620 -34190 0 0 {name=X_42736_ }
C {devices/lab_pin.sym} 48560 -34090 0 0 {name=p47784 lab=_61541_/A }
C {devices/lab_pin.sym} 48560 -34050 0 0 {name=p47785 lab=_61570_/B }
C {devices/lab_pin.sym} 48560 -34010 0 0 {name=p47786 lab=_61541_/C }
C {devices/lab_pin.sym} 48680 -34050 0 1 {name=p47787 lab=_61570_/Y }
C {sky130_stdcells/nand3_4.sym} 48620 -34050 0 0 {name=X_61570_ }
C {devices/lab_pin.sym} 48540 -33930 0 0 {name=p47788 lab=_65054_/B }
C {devices/lab_pin.sym} 48540 -33890 0 0 {name=p47789 lab=_49204_/X }
C {devices/lab_pin.sym} 48540 -33850 0 0 {name=p47790 lab=_49291_/Y }
C {devices/lab_pin.sym} 48700 -33890 0 1 {name=p47791 lab=_49292_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -33890 0 0 {name=X_49292_ }
C {devices/lab_pin.sym} 48540 -33770 0 0 {name=p47792 lab=_73553_/X }
C {devices/lab_pin.sym} 48540 -33730 0 0 {name=p47793 lab=_73555_/X }
C {devices/lab_pin.sym} 48540 -33690 0 0 {name=p47794 lab=_73489_/X }
C {devices/lab_pin.sym} 48700 -33730 0 1 {name=p47795 lab=_73556_/X }
C {sky130_stdcells/a21o_4.sym} 48620 -33730 0 0 {name=X_73556_ }
C {devices/lab_pin.sym} 48580 -33590 0 0 {name=p47796 lab=_70768_/A }
C {devices/lab_pin.sym} 48660 -33590 0 1 {name=p47797 lab=_70863_/A }
C {sky130_stdcells/buf_2.sym} 48620 -33590 0 0 {name=X_70768_ }
C {devices/lab_pin.sym} 48580 -33470 0 0 {name=p47798 lab=_49223_/A }
C {devices/lab_pin.sym} 48660 -33470 0 1 {name=p47799 lab=_48244_/A }
C {sky130_stdcells/buf_2.sym} 48620 -33470 0 0 {name=X_48243_ }
C {devices/lab_pin.sym} 48560 -33370 0 0 {name=p47800 lab=_60400_/Y }
C {devices/lab_pin.sym} 48560 -33330 0 0 {name=p47801 lab=_60430_/Y }
C {devices/lab_pin.sym} 48560 -33290 0 0 {name=p47802 lab=_60482_/A }
C {devices/lab_pin.sym} 48680 -33330 0 1 {name=p47803 lab=_60522_/A }
C {sky130_stdcells/nand3_4.sym} 48620 -33330 0 0 {name=X_60521_ }
C {devices/lab_pin.sym} 48580 -33190 0 0 {name=p47804 lab=_72507_/A }
C {devices/lab_pin.sym} 48660 -33190 0 1 {name=p47805 lab=_72508_/A }
C {sky130_stdcells/inv_2.sym} 48620 -33190 0 0 {name=X_72507_ }
C {devices/lab_pin.sym} 48560 -33080 0 0 {name=p47806 lab=_82830_/Q }
C {devices/lab_pin.sym} 48560 -33040 0 0 {name=p47807 lab=_82542_/Q }
C {devices/lab_pin.sym} 48680 -33060 0 1 {name=p47808 lab=_79064_/B }
C {sky130_stdcells/xnor2_4.sym} 48620 -33060 0 0 {name=X_79063_ }
C {devices/lab_pin.sym} 48580 -32930 0 0 {name=p47809 lab=_45455_/A }
C {devices/lab_pin.sym} 48660 -32930 0 1 {name=p47810 lab=_45455_/Y }
C {sky130_stdcells/inv_2.sym} 48620 -32930 0 0 {name=X_45455_ }
C {devices/lab_pin.sym} 48560 -32820 0 0 {name=p47811 lab=_81259_/Q }
C {devices/lab_pin.sym} 48560 -32780 0 0 {name=p47812 lab=_81515_/D }
C {devices/lab_pin.sym} 48680 -32800 0 1 {name=p47813 lab=_76276_/B }
C {sky130_stdcells/xor2_4.sym} 48620 -32800 0 0 {name=X_76275_ }
C {devices/lab_pin.sym} 48540 -32710 0 0 {name=p47814 lab=_42665_/X }
C {devices/lab_pin.sym} 48540 -32670 0 0 {name=p47815 lab=_42666_/X }
C {devices/lab_pin.sym} 48540 -32630 0 0 {name=p47816 lab=_41021_/X }
C {devices/lab_pin.sym} 48540 -32590 0 0 {name=p47817 lab=_87780_/Q }
C {devices/lab_pin.sym} 48540 -32550 0 0 {name=p47818 lab=_42658_/X }
C {devices/lab_pin.sym} 48700 -32630 0 1 {name=p47819 lab=_42667_/Y }
C {sky130_stdcells/o32ai_4.sym} 48620 -32630 0 0 {name=X_42667_ }
C {devices/lab_pin.sym} 48560 -32480 0 0 {name=p47820 lab=_73487_/A }
C {devices/lab_pin.sym} 48560 -32440 0 0 {name=p47821 lab=_72896_/B }
C {devices/lab_pin.sym} 48680 -32460 0 1 {name=p47822 lab=_73487_/Y }
C {sky130_stdcells/nor2_4.sym} 48620 -32460 0 0 {name=X_73487_ }
C {devices/lab_pin.sym} 48580 -32330 0 0 {name=p47823 lab=_70699_/A }
C {devices/lab_pin.sym} 48660 -32330 0 1 {name=p47824 lab=_70699_/X }
C {sky130_stdcells/buf_2.sym} 48620 -32330 0 0 {name=X_70699_ }
C {devices/lab_pin.sym} 48540 -32240 0 0 {name=p47825 lab=_77997_/A }
C {devices/lab_pin.sym} 48540 -32200 0 0 {name=p47826 lab=_78012_/A }
C {devices/lab_pin.sym} 48540 -32160 0 0 {name=p47827 lab=_82078_/Q }
C {devices/lab_pin.sym} 48540 -32120 0 0 {name=p47828 lab=_78013_/Y }
C {devices/lab_pin.sym} 48700 -32180 0 1 {name=p47829 lab=_78014_/X }
C {sky130_stdcells/a2bb2o_4.sym} 48620 -32180 0 0 {name=X_78014_ }
C {devices/lab_pin.sym} 48580 -32030 0 0 {name=p47830 lab=_44352_/X }
C {devices/lab_pin.sym} 48660 -32030 0 1 {name=p47831 lab=_44406_/X }
C {sky130_stdcells/buf_2.sym} 48620 -32030 0 0 {name=X_44406_ }
C {devices/lab_pin.sym} 48580 -31910 0 0 {name=p47832 lab=_60482_/Y }
C {devices/lab_pin.sym} 48660 -31910 0 1 {name=p47833 lab=_63240_/X }
C {sky130_stdcells/buf_2.sym} 48620 -31910 0 0 {name=X_63240_ }
C {devices/lab_pin.sym} 48560 -31800 0 0 {name=p47834 lab=_75226_/A }
C {devices/lab_pin.sym} 48560 -31760 0 0 {name=p47835 lab=_80985_/Q }
C {devices/lab_pin.sym} 48680 -31780 0 1 {name=p47836 lab=_75226_/Y }
C {sky130_stdcells/nand2_4.sym} 48620 -31780 0 0 {name=X_75226_ }
C {devices/lab_pin.sym} 48580 -31650 0 0 {name=p47837 lab=_41617_/Y }
C {devices/lab_pin.sym} 48660 -31650 0 1 {name=p47838 lab=_88182_/D }
C {sky130_stdcells/inv_2.sym} 48620 -31650 0 0 {name=X_41618_ }
C {devices/lab_pin.sym} 48540 -31550 0 0 {name=p47839 lab=_73588_/B }
C {devices/lab_pin.sym} 48540 -31510 0 0 {name=p47840 lab=_48170_/X }
C {devices/lab_pin.sym} 48540 -31470 0 0 {name=p47841 lab=_48173_/Y }
C {devices/lab_pin.sym} 48700 -31510 0 1 {name=p47842 lab=_48174_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -31510 0 0 {name=X_48174_ }
C {devices/lab_pin.sym} 48560 -31380 0 0 {name=p47843 lab=_60387_/X }
C {devices/lab_pin.sym} 48560 -31340 0 0 {name=p47844 lab=_60430_/Y }
C {devices/lab_pin.sym} 48680 -31360 0 1 {name=p47845 lab=_60452_/X }
C {sky130_stdcells/and2_4.sym} 48620 -31360 0 0 {name=X_60452_ }
C {devices/lab_pin.sym} 48540 -31270 0 0 {name=p47846 lab=_72413_/X }
C {devices/lab_pin.sym} 48540 -31230 0 0 {name=p47847 lab=_72436_/Y }
C {devices/lab_pin.sym} 48540 -31190 0 0 {name=p47848 lab=_72437_/Y }
C {devices/lab_pin.sym} 48540 -31150 0 0 {name=p47849 lab=_57793_/X }
C {devices/lab_pin.sym} 48540 -31110 0 0 {name=p47850 lab=_72417_/X }
C {devices/lab_pin.sym} 48700 -31190 0 1 {name=p47851 lab=_72438_/X }
C {sky130_stdcells/o32a_4.sym} 48620 -31190 0 0 {name=X_72438_ }
C {devices/lab_pin.sym} 48580 -31030 0 0 {name=p47852 lab=_45386_/A }
C {devices/lab_pin.sym} 48660 -31030 0 1 {name=p47853 lab=_55635_/B }
C {sky130_stdcells/inv_2.sym} 48620 -31030 0 0 {name=X_45386_ }
C {devices/lab_pin.sym} 48540 -30950 0 0 {name=p47854 lab=_42590_/X }
C {devices/lab_pin.sym} 48540 -30910 0 0 {name=p47855 lab=_42592_/X }
C {devices/lab_pin.sym} 48540 -30870 0 0 {name=p47856 lab=_40874_/X }
C {devices/lab_pin.sym} 48540 -30830 0 0 {name=p47857 lab=_87807_/Q }
C {devices/lab_pin.sym} 48540 -30790 0 0 {name=p47858 lab=_42597_/X }
C {devices/lab_pin.sym} 48700 -30870 0 1 {name=p47859 lab=_42599_/A }
C {sky130_stdcells/o32ai_4.sym} 48620 -30870 0 0 {name=X_42598_ }
C {devices/lab_pin.sym} 48560 -30720 0 0 {name=p47860 lab=_47109_/A }
C {devices/lab_pin.sym} 48560 -30680 0 0 {name=p47861 lab=_52869_/B }
C {devices/lab_pin.sym} 48680 -30700 0 1 {name=p47862 lab=_47125_/Y }
C {sky130_stdcells/nand2_4.sym} 48620 -30700 0 0 {name=X_47125_ }
C {devices/lab_pin.sym} 48580 -30570 0 0 {name=p47863 lab=_44336_/Y }
C {devices/lab_pin.sym} 48660 -30570 0 1 {name=p47864 lab=_87160_/D }
C {sky130_stdcells/inv_2.sym} 48620 -30570 0 0 {name=X_44337_ }
C {devices/lab_pin.sym} 48560 -30480 0 0 {name=p47865 lab=_59413_/Y }
C {devices/lab_pin.sym} 48560 -30440 0 0 {name=p47866 lab=_63170_/X }
C {devices/lab_pin.sym} 48560 -30400 0 0 {name=p47867 lab=_63161_/C }
C {devices/lab_pin.sym} 48560 -30360 0 0 {name=p47868 lab=_63149_/X }
C {devices/lab_pin.sym} 48680 -30420 0 1 {name=p47869 lab=_63171_/X }
C {sky130_stdcells/or4_4.sym} 48620 -30420 0 0 {name=X_63171_ }
C {devices/lab_pin.sym} 48560 -30290 0 0 {name=p47870 lab=_75156_/Y }
C {devices/lab_pin.sym} 48560 -30250 0 0 {name=p47871 lab=_75157_/B }
C {devices/lab_pin.sym} 48560 -30210 0 0 {name=p47872 lab=_75153_/A }
C {devices/lab_pin.sym} 48680 -30250 0 1 {name=p47873 lab=_75161_/B }
C {sky130_stdcells/nand3_4.sym} 48620 -30250 0 0 {name=X_75157_ }
C {devices/lab_pin.sym} 48580 -30110 0 0 {name=p47874 lab=_41482_/A }
C {devices/lab_pin.sym} 48660 -30110 0 1 {name=p47875 lab=_41584_/B }
C {sky130_stdcells/buf_2.sym} 48620 -30110 0 0 {name=X_41549_ }
C {devices/lab_pin.sym} 48540 -30030 0 0 {name=p47876 lab=_72270_/X }
C {devices/lab_pin.sym} 48540 -29990 0 0 {name=p47877 lab=_72366_/Y }
C {devices/lab_pin.sym} 48540 -29950 0 0 {name=p47878 lab=_72368_/Y }
C {devices/lab_pin.sym} 48540 -29910 0 0 {name=p47879 lab=_72296_/X }
C {devices/lab_pin.sym} 48540 -29870 0 0 {name=p47880 lab=_72274_/X }
C {devices/lab_pin.sym} 48700 -29950 0 1 {name=p47881 lab=_72369_/X }
C {sky130_stdcells/o32a_4.sym} 48620 -29950 0 0 {name=X_72369_ }
C {devices/lab_pin.sym} 48580 -29790 0 0 {name=p47882 lab=_60383_/A }
C {devices/lab_pin.sym} 48660 -29790 0 1 {name=p47883 lab=_60515_/C }
C {sky130_stdcells/buf_2.sym} 48620 -29790 0 0 {name=X_60383_ }
C {devices/lab_pin.sym} 48580 -29670 0 0 {name=p47884 lab=_72910_/A }
C {devices/lab_pin.sym} 48660 -29670 0 1 {name=p47885 lab=_74152_/A }
C {sky130_stdcells/buf_2.sym} 48620 -29670 0 0 {name=X_74108_ }
C {devices/lab_pin.sym} 48560 -29570 0 0 {name=p47886 lab=_62144_/A }
C {devices/lab_pin.sym} 48560 -29530 0 0 {name=p47887 lab=_62121_/X }
C {devices/lab_pin.sym} 48560 -29490 0 0 {name=p47888 lab=_62122_/C }
C {devices/lab_pin.sym} 48680 -29530 0 1 {name=p47889 lab=_62122_/Y }
C {sky130_stdcells/nor3_4.sym} 48620 -29530 0 0 {name=X_62122_ }
C {devices/lab_pin.sym} 48580 -29390 0 0 {name=p47890 lab=_46961_/X }
C {devices/lab_pin.sym} 48660 -29390 0 1 {name=p47891 lab=_47067_/A }
C {sky130_stdcells/buf_2.sym} 48620 -29390 0 0 {name=X_47056_ }
C {devices/lab_pin.sym} 48560 -29290 0 0 {name=p47892 lab=_44268_/A }
C {devices/lab_pin.sym} 48560 -29250 0 0 {name=p47893 lab=_43986_/A }
C {devices/lab_pin.sym} 48560 -29210 0 0 {name=p47894 lab=_44242_/C }
C {devices/lab_pin.sym} 48680 -29250 0 1 {name=p47895 lab=_44268_/Y }
C {sky130_stdcells/nand3_4.sym} 48620 -29250 0 0 {name=X_44268_ }
C {devices/lab_pin.sym} 48560 -29120 0 0 {name=p47896 lab=_75086_/A }
C {devices/lab_pin.sym} 48560 -29080 0 0 {name=p47897 lab=_75079_/B }
C {devices/lab_pin.sym} 48680 -29100 0 1 {name=p47898 lab=_75088_/Y }
C {sky130_stdcells/nand2_4.sym} 48620 -29100 0 0 {name=X_75088_ }
C {devices/lab_pin.sym} 48540 -28990 0 0 {name=p47899 lab=_79947_/Y }
C {devices/lab_pin.sym} 48540 -28950 0 0 {name=p47900 lab=_79948_/Y }
C {devices/lab_pin.sym} 48540 -28910 0 0 {name=p47901 lab=_79944_/Y }
C {devices/lab_pin.sym} 48700 -28950 0 1 {name=p47902 lab=_79965_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -28950 0 0 {name=X_79965_ }
C {devices/lab_pin.sym} 48580 -28810 0 0 {name=p47903 lab=_45962_/X }
C {devices/lab_pin.sym} 48660 -28810 0 1 {name=p47904 lab=_46007_/X }
C {sky130_stdcells/buf_2.sym} 48620 -28810 0 0 {name=X_46007_ }
C {devices/lab_pin.sym} 48540 -28720 0 0 {name=p47905 lab=_40968_/X }
C {devices/lab_pin.sym} 48540 -28680 0 0 {name=p47906 lab=_43216_/X }
C {devices/lab_pin.sym} 48540 -28640 0 0 {name=p47907 lab=_87533_/Q }
C {devices/lab_pin.sym} 48540 -28600 0 0 {name=p47908 lab=_43218_/X }
C {devices/lab_pin.sym} 48700 -28660 0 1 {name=p47909 lab=_43219_/X }
C {sky130_stdcells/a2bb2o_4.sym} 48620 -28660 0 0 {name=X_43219_ }
C {devices/lab_pin.sym} 48540 -28540 0 0 {name=p47910 lab=_87428_/Q }
C {devices/lab_pin.sym} 48540 -28500 0 0 {name=p47911 lab=_66878_/X }
C {devices/lab_pin.sym} 48540 -28460 0 0 {name=p47912 lab=_66879_/X }
C {devices/lab_pin.sym} 48540 -28420 0 0 {name=p47913 lab=_66929_/X }
C {devices/lab_pin.sym} 48700 -28480 0 1 {name=p47914 lab=_66930_/X }
C {sky130_stdcells/a211o_4.sym} 48620 -28480 0 0 {name=X_66930_ }
C {devices/lab_pin.sym} 48540 -28350 0 0 {name=p47915 lab=_62049_/Y }
C {devices/lab_pin.sym} 48540 -28310 0 0 {name=p47916 lab=_62033_/X }
C {devices/lab_pin.sym} 48540 -28270 0 0 {name=p47917 lab=_62052_/Y }
C {devices/lab_pin.sym} 48700 -28310 0 1 {name=p47918 lab=_62053_/Y }
C {sky130_stdcells/a21oi_4.sym} 48620 -28310 0 0 {name=X_62053_ }
C {devices/lab_pin.sym} 48540 -28200 0 0 {name=p47919 lab=_74012_/X }
C {devices/lab_pin.sym} 48540 -28160 0 0 {name=p47920 lab=_86221_/Q }
C {devices/lab_pin.sym} 48540 -28120 0 0 {name=p47921 lab=_73948_/X }
C {devices/lab_pin.sym} 48540 -28080 0 0 {name=p47922 lab=_74038_/X }
C {devices/lab_pin.sym} 48700 -28140 0 1 {name=p47923 lab=_74039_/X }
C {sky130_stdcells/a211o_4.sym} 48620 -28140 0 0 {name=X_74039_ }
C {devices/lab_pin.sym} 48540 -28020 0 0 {name=p47924 lab=_78902_/Y }
C {devices/lab_pin.sym} 48540 -27980 0 0 {name=p47925 lab=_78903_/Y }
C {devices/lab_pin.sym} 48540 -27940 0 0 {name=p47926 lab=_82636_/Q }
C {devices/lab_pin.sym} 48540 -27900 0 0 {name=p47927 lab=_82508_/D }
C {devices/lab_pin.sym} 48700 -27960 0 1 {name=p47928 lab=_78916_/X }
C {sky130_stdcells/a2bb2o_4.sym} 48620 -27960 0 0 {name=X_78916_ }
C {devices/lab_pin.sym} 48580 -27810 0 0 {name=p47929 lab=_57043_/B }
C {devices/lab_pin.sym} 48660 -27810 0 1 {name=p47930 lab=_44220_/B }
C {sky130_stdcells/buf_2.sym} 48620 -27810 0 0 {name=X_44199_ }
C {devices/lab_pin.sym} 48580 -27690 0 0 {name=p47931 lab=_64200_/C }
C {devices/lab_pin.sym} 48660 -27690 0 1 {name=p47932 lab=_79896_/Y }
C {sky130_stdcells/inv_2.sym} 48620 -27690 0 0 {name=X_79896_ }
C {devices/lab_pin.sym} 48580 -27570 0 0 {name=p47933 lab=_61003_/Y }
C {devices/lab_pin.sym} 48660 -27570 0 1 {name=p47934 lab=_61004_/Y }
C {sky130_stdcells/inv_2.sym} 48620 -27570 0 0 {name=X_61004_ }
C {devices/lab_pin.sym} 48560 -27460 0 0 {name=p47935 lab=_66912_/A }
C {devices/lab_pin.sym} 48560 -27420 0 0 {name=p47936 lab=_66861_/B }
C {devices/lab_pin.sym} 48680 -27440 0 1 {name=p47937 lab=_66861_/X }
C {sky130_stdcells/and2_4.sym} 48620 -27440 0 0 {name=X_66861_ }
C {devices/lab_pin.sym} 48560 -27320 0 0 {name=p47938 lab=_78857_/B }
C {devices/lab_pin.sym} 48560 -27280 0 0 {name=p47939 lab=_78857_/A }
C {devices/lab_pin.sym} 48680 -27300 0 1 {name=p47940 lab=_78874_/B }
C {sky130_stdcells/xnor2_4.sym} 48620 -27300 0 0 {name=X_78847_ }
C {devices/lab_pin.sym} 48540 -27200 0 0 {name=p47941 lab=_88010_/Q }
C {devices/lab_pin.sym} 48540 -27160 0 0 {name=p47942 lab=_68527_/X }
C {devices/lab_pin.sym} 48540 -27120 0 0 {name=p47943 lab=_68501_/X }
C {devices/lab_pin.sym} 48540 -27080 0 0 {name=p47944 lab=_68599_/X }
C {devices/lab_pin.sym} 48700 -27140 0 1 {name=p47945 lab=_68600_/X }
C {sky130_stdcells/a211o_4.sym} 48620 -27140 0 0 {name=X_68600_ }
C {devices/lab_pin.sym} 48560 -27000 0 0 {name=p47946 lab=_65812_/A }
C {devices/lab_pin.sym} 48560 -26960 0 0 {name=p47947 lab=_86504_/Q }
C {devices/lab_pin.sym} 48680 -26980 0 1 {name=p47948 lab=_65812_/X }
C {sky130_stdcells/and2_4.sym} 48620 -26980 0 0 {name=X_65812_ }
C {devices/lab_pin.sym} 48560 -26860 0 0 {name=p47949 lab=_69580_/A }
C {devices/lab_pin.sym} 48560 -26820 0 0 {name=p47950 lab=_87314_/Q }
C {devices/lab_pin.sym} 48680 -26840 0 1 {name=p47951 lab=_69580_/X }
C {sky130_stdcells/and2_4.sym} 48620 -26840 0 0 {name=X_69580_ }
C {devices/lab_pin.sym} 48540 -26730 0 0 {name=p47952 lab=_47953_/Y }
C {devices/lab_pin.sym} 48540 -26690 0 0 {name=p47953 lab=_47954_/X }
C {devices/lab_pin.sym} 48540 -26650 0 0 {name=p47954 lab=_47957_/X }
C {devices/lab_pin.sym} 48700 -26690 0 1 {name=p47955 lab=_86582_/D }
C {sky130_stdcells/a21oi_4.sym} 48620 -26690 0 0 {name=X_47958_ }
C {devices/lab_pin.sym} 48580 -26550 0 0 {name=p47956 lab=_59801_/A }
C {devices/lab_pin.sym} 48660 -26550 0 1 {name=p47957 lab=_66910_/A }
C {sky130_stdcells/buf_2.sym} 48620 -26550 0 0 {name=X_66792_ }
C {devices/lab_pin.sym} 48560 -26440 0 0 {name=p47958 lab=_78778_/A }
C {devices/lab_pin.sym} 48560 -26400 0 0 {name=p47959 lab=_78778_/B }
C {devices/lab_pin.sym} 48680 -26420 0 1 {name=p47960 lab=_78778_/X }
C {sky130_stdcells/xor2_4.sym} 48620 -26420 0 0 {name=X_78778_ }
C {devices/lab_pin.sym} 48540 -26320 0 0 {name=p47961 lab=_87501_/Q }
C {devices/lab_pin.sym} 48540 -26280 0 0 {name=p47962 lab=_68504_/X }
C {devices/lab_pin.sym} 48540 -26240 0 0 {name=p47963 lab=_68450_/X }
C {devices/lab_pin.sym} 48540 -26200 0 0 {name=p47964 lab=_68530_/X }
C {devices/lab_pin.sym} 48700 -26260 0 1 {name=p47965 lab=_68531_/X }
C {sky130_stdcells/a211o_4.sym} 48620 -26260 0 0 {name=X_68531_ }
C {devices/lab_pin.sym} 48580 -26110 0 0 {name=p47966 lab=_46249_/A }
C {devices/lab_pin.sym} 48660 -26110 0 1 {name=p47967 lab=_46909_/X }
C {sky130_stdcells/buf_2.sym} 48620 -26110 0 0 {name=X_46909_ }
C {devices/lab_pin.sym} 48580 -25990 0 0 {name=p47968 lab=_64739_/A }
C {devices/lab_pin.sym} 48660 -25990 0 1 {name=p47969 lab=_65888_/A }
C {sky130_stdcells/buf_2.sym} 48620 -25990 0 0 {name=X_65743_ }
C {devices/lab_pin.sym} 48580 -25870 0 0 {name=p47970 lab=_77732_/B }
C {devices/lab_pin.sym} 48660 -25870 0 1 {name=p47971 lab=_77730_/A }
C {sky130_stdcells/inv_2.sym} 48620 -25870 0 0 {name=X_77729_ }
C {devices/lab_pin.sym} 48560 -25780 0 0 {name=p47972 lab=_62971_/A }
C {devices/lab_pin.sym} 48560 -25740 0 0 {name=p47973 lab=_84886_/Q }
C {devices/lab_pin.sym} 48560 -25700 0 0 {name=p47974 lab=_60302_/X }
C {devices/lab_pin.sym} 48560 -25660 0 0 {name=p47975 lab=_62979_/D }
C {devices/lab_pin.sym} 48680 -25720 0 1 {name=p47976 lab=_62955_/X }
C {sky130_stdcells/and4_4.sym} 48620 -25720 0 0 {name=X_62955_ }
C {devices/lab_pin.sym} 48580 -25570 0 0 {name=p47977 lab=_83556_/Q }
C {devices/lab_pin.sym} 48660 -25570 0 1 {name=p47978 lab=_73692_/A }
C {sky130_stdcells/inv_2.sym} 48620 -25570 0 0 {name=X_47889_ }
C {devices/lab_pin.sym} 48540 -25490 0 0 {name=p47979 lab=_57664_/X }
C {devices/lab_pin.sym} 48540 -25450 0 0 {name=p47980 lab=_61902_/X }
C {devices/lab_pin.sym} 48540 -25410 0 0 {name=p47981 lab=_61838_/X }
C {devices/lab_pin.sym} 48540 -25370 0 0 {name=p47982 lab=_61870_/X }
C {devices/lab_pin.sym} 48540 -25340 0 0 {name=p47983 lab=_61905_/X }
C {devices/lab_pin.sym} 48700 -25410 0 1 {name=p47984 lab=_61906_/X }
C {sky130_stdcells/a41o_4.sym} 48620 -25410 0 0 {name=X_61906_ }
C {devices/lab_pin.sym} 48540 -25270 0 0 {name=p47985 lab=_86352_/Q }
C {devices/lab_pin.sym} 48540 -25230 0 0 {name=p47986 lab=_49606_/X }
C {devices/lab_pin.sym} 48540 -25190 0 0 {name=p47987 lab=_49627_/Y }
C {devices/lab_pin.sym} 48700 -25230 0 1 {name=p47988 lab=_49628_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -25230 0 0 {name=X_49628_ }
C {devices/lab_pin.sym} 48530 -25090 0 0 {name=p47989 lab=_80740_/CLK }
C {devices/lab_pin.sym} 48530 -25070 0 0 {name=p47990 lab=_75108_/X }
C {devices/lab_pin.sym} 48710 -25090 0 1 {name=p47991 lab=_75042_/A }
C {sky130_stdcells/dfxtp_4.sym} 48620 -25080 0 0 {name=X_80740_ }
C {devices/lab_pin.sym} 48580 -24950 0 0 {name=p47992 lab=_68586_/A }
C {devices/lab_pin.sym} 48660 -24950 0 1 {name=p47993 lab=_68462_/X }
C {sky130_stdcells/buf_2.sym} 48620 -24950 0 0 {name=X_68462_ }
C {devices/lab_pin.sym} 48560 -24840 0 0 {name=p47994 lab=_65825_/A }
C {devices/lab_pin.sym} 48560 -24800 0 0 {name=p47995 lab=_86513_/Q }
C {devices/lab_pin.sym} 48680 -24820 0 1 {name=p47996 lab=_65674_/X }
C {sky130_stdcells/and2_4.sym} 48620 -24820 0 0 {name=X_65674_ }
C {devices/lab_pin.sym} 48580 -24690 0 0 {name=p47997 lab=_62886_/A }
C {devices/lab_pin.sym} 48660 -24690 0 1 {name=p47998 lab=_62886_/X }
C {sky130_stdcells/buf_2.sym} 48620 -24690 0 0 {name=X_62886_ }
C {devices/lab_pin.sym} 48560 -24580 0 0 {name=p47999 lab=_67410_/X }
C {devices/lab_pin.sym} 48560 -24540 0 0 {name=p48000 lab=_67413_/B }
C {devices/lab_pin.sym} 48680 -24560 0 1 {name=p48001 lab=_67413_/Y }
C {sky130_stdcells/nand2_4.sym} 48620 -24560 0 0 {name=X_67413_ }
C {devices/lab_pin.sym} 48540 -24460 0 0 {name=p48002 lab=_59345_/X }
C {devices/lab_pin.sym} 48540 -24420 0 0 {name=p48003 lab=_86176_/Q }
C {devices/lab_pin.sym} 48540 -24380 0 0 {name=p48004 lab=_64583_/X }
C {devices/lab_pin.sym} 48540 -24340 0 0 {name=p48005 lab=_64624_/X }
C {devices/lab_pin.sym} 48700 -24400 0 1 {name=p48006 lab=_64625_/X }
C {sky130_stdcells/a211o_4.sym} 48620 -24400 0 0 {name=X_64625_ }
C {devices/lab_pin.sym} 48540 -24270 0 0 {name=p48007 lab=_59044_/B }
C {devices/lab_pin.sym} 48540 -24230 0 0 {name=p48008 lab=_49551_/X }
C {devices/lab_pin.sym} 48540 -24190 0 0 {name=p48009 lab=_49558_/Y }
C {devices/lab_pin.sym} 48700 -24230 0 1 {name=p48010 lab=_49559_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -24230 0 0 {name=X_49559_ }
C {devices/lab_pin.sym} 48560 -24120 0 0 {name=p48011 lab=_61823_/A }
C {devices/lab_pin.sym} 48560 -24080 0 0 {name=p48012 lab=_61823_/B }
C {devices/lab_pin.sym} 48560 -24040 0 0 {name=p48013 lab=_63448_/B }
C {devices/lab_pin.sym} 48560 -24000 0 0 {name=p48014 lab=_61788_/X }
C {devices/lab_pin.sym} 48680 -24060 0 1 {name=p48015 lab=_61837_/X }
C {sky130_stdcells/and4_4.sym} 48620 -24060 0 0 {name=X_61837_ }
C {devices/lab_pin.sym} 48530 -23910 0 0 {name=p48016 lab=_80671_/CLK }
C {devices/lab_pin.sym} 48530 -23890 0 0 {name=p48017 lab=_80671_/D }
C {devices/lab_pin.sym} 48710 -23910 0 1 {name=p48018 lab=_80671_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -23900 0 0 {name=X_80671_ }
C {devices/lab_pin.sym} 48580 -23770 0 0 {name=p48019 lab=_69607_/A }
C {devices/lab_pin.sym} 48660 -23770 0 1 {name=p48020 lab=_68394_/A }
C {sky130_stdcells/buf_2.sym} 48620 -23770 0 0 {name=X_68393_ }
C {devices/lab_pin.sym} 48530 -23650 0 0 {name=p48021 lab=_82443_/CLK }
C {devices/lab_pin.sym} 48530 -23630 0 0 {name=p48022 lab=_82410_/D }
C {devices/lab_pin.sym} 48710 -23650 0 1 {name=p48023 lab=_78417_/A }
C {sky130_stdcells/dfxtp_4.sym} 48620 -23640 0 0 {name=X_82410_ }
C {devices/lab_pin.sym} 48580 -23510 0 0 {name=p48024 lab=_67226_/A }
C {devices/lab_pin.sym} 48660 -23510 0 1 {name=p48025 lab=_67344_/X }
C {sky130_stdcells/buf_2.sym} 48620 -23510 0 0 {name=X_67344_ }
C {devices/lab_pin.sym} 48540 -23410 0 0 {name=p48026 lab=_52568_/Y }
C {devices/lab_pin.sym} 48540 -23370 0 0 {name=p48027 lab=_51951_/X }
C {devices/lab_pin.sym} 48540 -23330 0 0 {name=p48028 lab=_52569_/Y }
C {devices/lab_pin.sym} 48700 -23370 0 1 {name=p48029 lab=_85795_/D }
C {sky130_stdcells/a21boi_4.sym} 48620 -23370 0 0 {name=X_52570_ }
C {devices/lab_pin.sym} 48560 -23250 0 0 {name=p48030 lab=_64455_/X }
C {devices/lab_pin.sym} 48560 -23210 0 0 {name=p48031 lab=_61694_/B }
C {devices/lab_pin.sym} 48560 -23170 0 0 {name=p48032 lab=_61102_/X }
C {devices/lab_pin.sym} 48680 -23210 0 1 {name=p48033 lab=_64556_/Y }
C {sky130_stdcells/nand3_4.sym} 48620 -23210 0 0 {name=X_64556_ }
C {devices/lab_pin.sym} 48530 -23070 0 0 {name=p48034 lab=_85407_/CLK }
C {devices/lab_pin.sym} 48530 -23050 0 0 {name=p48035 lab=_83390_/D }
C {devices/lab_pin.sym} 48710 -23070 0 1 {name=p48036 lab=_83390_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -23060 0 0 {name=X_83390_ }
C {devices/lab_pin.sym} 48580 -22930 0 0 {name=p48037 lab=clkbuf_9_246_0_CLK/X }
C {devices/lab_pin.sym} 48660 -22930 0 1 {name=p48038 lab=_86400_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 48620 -22930 0 0 {name=Xclkbuf_10_492_0_CLK }
C {devices/lab_pin.sym} 48560 -22830 0 0 {name=p48039 lab=_61752_/A }
C {devices/lab_pin.sym} 48560 -22790 0 0 {name=p48040 lab=_61723_/X }
C {devices/lab_pin.sym} 48560 -22750 0 0 {name=p48041 lab=_78078_/B }
C {devices/lab_pin.sym} 48680 -22790 0 1 {name=p48042 lab=_61768_/Y }
C {sky130_stdcells/nor3_4.sym} 48620 -22790 0 0 {name=X_61768_ }
C {sky130_stdcells/decap_3.sym} 48620 -22620 0 0 {name=XPHY_509 }
C {devices/lab_pin.sym} 48580 -22470 0 0 {name=p48043 lab=_51629_/A }
C {devices/lab_pin.sym} 48660 -22470 0 1 {name=p48044 lab=_51521_/X }
C {sky130_stdcells/buf_2.sym} 48620 -22470 0 0 {name=X_51521_ }
C {devices/lab_pin.sym} 48560 -22370 0 0 {name=p48045 lab=_63517_/A }
C {devices/lab_pin.sym} 48560 -22330 0 0 {name=p48046 lab=_63517_/B }
C {devices/lab_pin.sym} 48560 -22290 0 0 {name=p48047 lab=_80506_/B }
C {devices/lab_pin.sym} 48680 -22330 0 1 {name=p48048 lab=_63507_/Y }
C {sky130_stdcells/nor3_4.sym} 48620 -22330 0 0 {name=X_63507_ }
C {devices/lab_pin.sym} 48530 -22190 0 0 {name=p48049 lab=_86753_/CLK }
C {devices/lab_pin.sym} 48530 -22170 0 0 {name=p48050 lab=_82341_/D }
C {devices/lab_pin.sym} 48710 -22190 0 1 {name=p48051 lab=_82341_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -22180 0 0 {name=X_82341_ }
C {devices/lab_pin.sym} 48580 -22050 0 0 {name=p48052 lab=_59756_/A }
C {devices/lab_pin.sym} 48660 -22050 0 1 {name=p48053 lab=_60719_/X }
C {sky130_stdcells/buf_2.sym} 48620 -22050 0 0 {name=X_60719_ }
C {devices/lab_pin.sym} 48560 -21940 0 0 {name=p48054 lab=_67250_/A }
C {devices/lab_pin.sym} 48560 -21900 0 0 {name=p48055 lab=_86777_/Q }
C {devices/lab_pin.sym} 48680 -21920 0 1 {name=p48056 lab=_67275_/X }
C {sky130_stdcells/and2_4.sym} 48620 -21920 0 0 {name=X_67275_ }
C {devices/lab_pin.sym} 48560 -21810 0 0 {name=p48057 lab=_61182_/X }
C {devices/lab_pin.sym} 48560 -21770 0 0 {name=p48058 lab=_61618_/X }
C {devices/lab_pin.sym} 48560 -21730 0 0 {name=p48059 lab=_64211_/C }
C {devices/lab_pin.sym} 48680 -21770 0 1 {name=p48060 lab=_64487_/Y }
C {sky130_stdcells/nand3_4.sym} 48620 -21770 0 0 {name=X_64487_ }
C {devices/lab_pin.sym} 48580 -21630 0 0 {name=p48061 lab=_61645_/A }
C {devices/lab_pin.sym} 48660 -21630 0 1 {name=p48062 lab=_61699_/X }
C {sky130_stdcells/buf_2.sym} 48620 -21630 0 0 {name=X_61699_ }
C {devices/lab_pin.sym} 48580 -21510 0 0 {name=p48063 lab=_69014_/A }
C {devices/lab_pin.sym} 48660 -21510 0 1 {name=p48064 lab=_69059_/A }
C {sky130_stdcells/buf_2.sym} 48620 -21510 0 0 {name=X_69014_ }
C {devices/lab_pin.sym} 48540 -21410 0 0 {name=p48065 lab=_85478_/Q }
C {devices/lab_pin.sym} 48540 -21370 0 0 {name=p48066 lab=_54220_/X }
C {devices/lab_pin.sym} 48540 -21330 0 0 {name=p48067 lab=_54239_/Y }
C {devices/lab_pin.sym} 48700 -21370 0 1 {name=p48068 lab=_54240_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -21370 0 0 {name=X_54240_ }
C {devices/lab_pin.sym} 48560 -21240 0 0 {name=p48069 lab=_66226_/A }
C {devices/lab_pin.sym} 48560 -21200 0 0 {name=p48070 lab=_86539_/Q }
C {devices/lab_pin.sym} 48680 -21220 0 1 {name=p48071 lab=_66226_/X }
C {sky130_stdcells/and2_4.sym} 48620 -21220 0 0 {name=X_66226_ }
C {devices/lab_pin.sym} 48530 -21090 0 0 {name=p48072 lab=_85034_/CLK }
C {devices/lab_pin.sym} 48530 -21070 0 0 {name=p48073 lab=_85060_/D }
C {devices/lab_pin.sym} 48710 -21090 0 1 {name=p48074 lab=_85060_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -21080 0 0 {name=X_85060_ }
C {devices/lab_pin.sym} 48560 -20980 0 0 {name=p48075 lab=_51456_/A }
C {devices/lab_pin.sym} 48560 -20940 0 0 {name=p48076 lab=_51473_/B }
C {devices/lab_pin.sym} 48560 -20900 0 0 {name=p48077 lab=_51467_/C }
C {devices/lab_pin.sym} 48560 -20860 0 0 {name=p48078 lab=_52977_/D }
C {devices/lab_pin.sym} 48680 -20920 0 1 {name=p48079 lab=_51452_/X }
C {sky130_stdcells/and4_4.sym} 48620 -20920 0 0 {name=X_51452_ }
C {devices/lab_pin.sym} 48540 -20800 0 0 {name=p48080 lab=_58424_/Y }
C {devices/lab_pin.sym} 48540 -20760 0 0 {name=p48081 lab=_63436_/X }
C {devices/lab_pin.sym} 48540 -20720 0 0 {name=p48082 lab=_61406_/A }
C {devices/lab_pin.sym} 48540 -20680 0 0 {name=p48083 lab=_63437_/X }
C {devices/lab_pin.sym} 48700 -20740 0 1 {name=p48084 lab=_63438_/X }
C {sky130_stdcells/a2bb2o_4.sym} 48620 -20740 0 0 {name=X_63438_ }
C {devices/lab_pin.sym} 48530 -20590 0 0 {name=p48085 lab=_82272_/CLK }
C {devices/lab_pin.sym} 48530 -20570 0 0 {name=p48086 lab=_82272_/D }
C {devices/lab_pin.sym} 48710 -20590 0 1 {name=p48087 lab=_82272_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -20580 0 0 {name=X_82272_ }
C {devices/lab_pin.sym} 48530 -20450 0 0 {name=p48088 lab=_81475_/CLK }
C {devices/lab_pin.sym} 48530 -20430 0 0 {name=p48089 lab=_68212_/X }
C {devices/lab_pin.sym} 48710 -20450 0 1 {name=p48090 lab=_84011_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -20440 0 0 {name=X_84011_ }
C {devices/lab_pin.sym} 48580 -20310 0 0 {name=p48091 lab=_50464_/A }
C {devices/lab_pin.sym} 48660 -20310 0 1 {name=p48092 lab=_50403_/X }
C {sky130_stdcells/buf_2.sym} 48620 -20310 0 0 {name=X_50403_ }
C {devices/lab_pin.sym} 48530 -20190 0 0 {name=p48093 lab=_85351_/CLK }
C {devices/lab_pin.sym} 48530 -20170 0 0 {name=p48094 lab=_81031_/Q }
C {devices/lab_pin.sym} 48710 -20190 0 1 {name=p48095 lab=_81223_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -20180 0 0 {name=X_81223_ }
C {devices/lab_pin.sym} 48580 -20050 0 0 {name=p48096 lab=_53436_/X }
C {devices/lab_pin.sym} 48660 -20050 0 1 {name=p48097 lab=_54171_/X }
C {sky130_stdcells/buf_2.sym} 48620 -20050 0 0 {name=X_54171_ }
C {devices/lab_pin.sym} 48540 -19950 0 0 {name=p48098 lab=_66154_/X }
C {devices/lab_pin.sym} 48540 -19910 0 0 {name=p48099 lab=_66156_/X }
C {devices/lab_pin.sym} 48540 -19870 0 0 {name=p48100 lab=_65961_/X }
C {devices/lab_pin.sym} 48700 -19910 0 1 {name=p48101 lab=_66453_/A }
C {sky130_stdcells/a21o_4.sym} 48620 -19910 0 0 {name=X_66157_ }
C {devices/lab_pin.sym} 48540 -19790 0 0 {name=p48102 lab=_86020_/Q }
C {devices/lab_pin.sym} 48540 -19750 0 0 {name=p48103 lab=_51362_/X }
C {devices/lab_pin.sym} 48540 -19710 0 0 {name=p48104 lab=_51382_/Y }
C {devices/lab_pin.sym} 48700 -19750 0 1 {name=p48105 lab=_51383_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -19750 0 0 {name=X_51383_ }
C {devices/lab_pin.sym} 48560 -19640 0 0 {name=p48106 lab=_63410_/A }
C {devices/lab_pin.sym} 48560 -19600 0 0 {name=p48107 lab=_63369_/B }
C {devices/lab_pin.sym} 48560 -19560 0 0 {name=p48108 lab=_63384_/C }
C {devices/lab_pin.sym} 48560 -19520 0 0 {name=p48109 lab=_63384_/D }
C {devices/lab_pin.sym} 48680 -19580 0 1 {name=p48110 lab=_63369_/X }
C {sky130_stdcells/and4_4.sym} 48620 -19580 0 0 {name=X_63369_ }
C {devices/lab_pin.sym} 48560 -19440 0 0 {name=p48111 lab=_53121_/X }
C {devices/lab_pin.sym} 48560 -19400 0 0 {name=p48112 lab=_53122_/B }
C {devices/lab_pin.sym} 48680 -19420 0 1 {name=p48113 lab=_53122_/Y }
C {sky130_stdcells/nand2_4.sym} 48620 -19420 0 0 {name=X_53122_ }
C {devices/lab_pin.sym} 48580 -19290 0 0 {name=p48114 lab=_64991_/A }
C {devices/lab_pin.sym} 48660 -19290 0 1 {name=p48115 lab=_65108_/X }
C {sky130_stdcells/buf_2.sym} 48620 -19290 0 0 {name=X_65108_ }
C {devices/lab_pin.sym} 48580 -19170 0 0 {name=p48116 lab=_50213_/X }
C {devices/lab_pin.sym} 48660 -19170 0 1 {name=p48117 lab=_50398_/A }
C {sky130_stdcells/buf_2.sym} 48620 -19170 0 0 {name=X_50334_ }
C {devices/lab_pin.sym} 48530 -19050 0 0 {name=p48118 lab=_81154_/CLK }
C {devices/lab_pin.sym} 48530 -19030 0 0 {name=p48119 lab=_74849_/B }
C {devices/lab_pin.sym} 48710 -19050 0 1 {name=p48120 lab=_41624_/A }
C {sky130_stdcells/dfxtp_4.sym} 48620 -19040 0 0 {name=X_81154_ }
C {devices/lab_pin.sym} 48540 -18940 0 0 {name=p48121 lab=_65924_/X }
C {devices/lab_pin.sym} 48540 -18900 0 0 {name=p48122 lab=_84981_/Q }
C {devices/lab_pin.sym} 48540 -18860 0 0 {name=p48123 lab=_65950_/X }
C {devices/lab_pin.sym} 48540 -18820 0 0 {name=p48124 lab=_66087_/X }
C {devices/lab_pin.sym} 48700 -18880 0 1 {name=p48125 lab=_66426_/C }
C {sky130_stdcells/a211o_4.sym} 48620 -18880 0 0 {name=X_66088_ }
C {devices/lab_pin.sym} 48560 -18740 0 0 {name=p48126 lab=_80089_/X }
C {devices/lab_pin.sym} 48560 -18700 0 0 {name=p48127 lab=_80105_/B }
C {devices/lab_pin.sym} 48680 -18720 0 1 {name=p48128 lab=_80105_/X }
C {sky130_stdcells/or2_4.sym} 48620 -18720 0 0 {name=X_80105_ }
C {devices/lab_pin.sym} 48540 -18610 0 0 {name=p48129 lab=_53051_/Y }
C {devices/lab_pin.sym} 48540 -18570 0 0 {name=p48130 lab=_53028_/X }
C {devices/lab_pin.sym} 48540 -18530 0 0 {name=p48131 lab=_53052_/X }
C {devices/lab_pin.sym} 48700 -18570 0 1 {name=p48132 lab=_53053_/Y }
C {sky130_stdcells/a21oi_4.sym} 48620 -18570 0 0 {name=X_53053_ }
C {devices/lab_pin.sym} 48560 -18440 0 0 {name=p48133 lab=_57952_/A }
C {devices/lab_pin.sym} 48560 -18400 0 0 {name=p48134 lab=_86323_/Q }
C {devices/lab_pin.sym} 48680 -18420 0 1 {name=p48135 lab=_57930_/Y }
C {sky130_stdcells/nor2_4.sym} 48620 -18420 0 0 {name=X_57930_ }
C {devices/lab_pin.sym} 48540 -18310 0 0 {name=p48136 lab=_65033_/X }
C {devices/lab_pin.sym} 48540 -18270 0 0 {name=p48137 lab=_65038_/X }
C {devices/lab_pin.sym} 48540 -18230 0 0 {name=p48138 lab=_64959_/X }
C {devices/lab_pin.sym} 48700 -18270 0 1 {name=p48139 lab=_65039_/X }
C {sky130_stdcells/a21o_4.sym} 48620 -18270 0 0 {name=X_65039_ }
C {devices/lab_pin.sym} 48580 -18130 0 0 {name=p48140 lab=_64834_/A }
C {devices/lab_pin.sym} 48660 -18130 0 1 {name=p48141 lab=_69916_/X }
C {sky130_stdcells/buf_2.sym} 48620 -18130 0 0 {name=X_69916_ }
C {devices/lab_pin.sym} 48540 -18030 0 0 {name=p48142 lab=_86235_/Q }
C {devices/lab_pin.sym} 48540 -17990 0 0 {name=p48143 lab=_50250_/X }
C {devices/lab_pin.sym} 48540 -17950 0 0 {name=p48144 lab=_50264_/Y }
C {devices/lab_pin.sym} 48700 -17990 0 1 {name=p48145 lab=_50265_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -17990 0 0 {name=X_50265_ }
C {devices/lab_pin.sym} 48530 -17850 0 0 {name=p48146 lab=_85962_/CLK }
C {devices/lab_pin.sym} 48530 -17830 0 0 {name=p48147 lab=_85962_/D }
C {devices/lab_pin.sym} 48710 -17850 0 1 {name=p48148 lab=_85962_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -17840 0 0 {name=X_85962_ }
C {devices/lab_pin.sym} 48530 -17710 0 0 {name=p48149 lab=_81087_/CLK }
C {devices/lab_pin.sym} 48530 -17690 0 0 {name=p48150 lab=_75669_/A }
C {devices/lab_pin.sym} 48710 -17710 0 1 {name=p48151 lab=_75473_/A }
C {sky130_stdcells/dfxtp_4.sym} 48620 -17700 0 0 {name=X_81085_ }
C {devices/lab_pin.sym} 48580 -17570 0 0 {name=p48152 lab=clkbuf_9_215_0_CLK/X }
C {devices/lab_pin.sym} 48660 -17570 0 1 {name=p48153 lab=_82833_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 48620 -17570 0 0 {name=Xclkbuf_10_430_0_CLK }
C {devices/lab_pin.sym} 48540 -17470 0 0 {name=p48154 lab=_52002_/Y }
C {devices/lab_pin.sym} 48540 -17430 0 0 {name=p48155 lab=_51981_/X }
C {devices/lab_pin.sym} 48540 -17390 0 0 {name=p48156 lab=_52003_/Y }
C {devices/lab_pin.sym} 48700 -17430 0 1 {name=p48157 lab=_85908_/D }
C {sky130_stdcells/a21boi_4.sym} 48620 -17430 0 0 {name=X_52004_ }
C {devices/lab_pin.sym} 48530 -17290 0 0 {name=p48158 lab=_88201_/CLK }
C {devices/lab_pin.sym} 48530 -17270 0 0 {name=p48159 lab=_42823_/X }
C {devices/lab_pin.sym} 48710 -17290 0 1 {name=p48160 lab=_87701_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -17280 0 0 {name=X_87701_ }
C {devices/lab_pin.sym} 48560 -17160 0 0 {name=p48161 lab=_80030_/Y }
C {devices/lab_pin.sym} 48560 -17120 0 0 {name=p48162 lab=_80035_/Y }
C {devices/lab_pin.sym} 48680 -17140 0 1 {name=p48163 lab=_80036_/X }
C {sky130_stdcells/xor2_4.sym} 48620 -17140 0 0 {name=X_80036_ }
C {devices/lab_pin.sym} 48530 -17010 0 0 {name=p48164 lab=_84906_/CLK }
C {devices/lab_pin.sym} 48530 -16990 0 0 {name=p48165 lab=_58185_/Y }
C {devices/lab_pin.sym} 48710 -17010 0 1 {name=p48166 lab=_84913_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -17000 0 0 {name=X_84913_ }
C {devices/lab_pin.sym} 48540 -16890 0 0 {name=p48167 lab=_57811_/X }
C {devices/lab_pin.sym} 48540 -16850 0 0 {name=p48168 lab=_85400_/Q }
C {devices/lab_pin.sym} 48540 -16810 0 0 {name=p48169 lab=_57860_/X }
C {devices/lab_pin.sym} 48700 -16850 0 1 {name=p48170 lab=_57861_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -16850 0 0 {name=X_57861_ }
C {devices/lab_pin.sym} 48540 -16730 0 0 {name=p48171 lab=_83893_/Q }
C {devices/lab_pin.sym} 48540 -16690 0 0 {name=p48172 lab=_69831_/X }
C {devices/lab_pin.sym} 48540 -16650 0 0 {name=p48173 lab=_69846_/X }
C {devices/lab_pin.sym} 48700 -16690 0 1 {name=p48174 lab=_83893_/D }
C {sky130_stdcells/a21bo_4.sym} 48620 -16690 0 0 {name=X_69847_ }
C {devices/lab_pin.sym} 48540 -16570 0 0 {name=p48175 lab=_65327_/B }
C {devices/lab_pin.sym} 48540 -16530 0 0 {name=p48176 lab=_50185_/X }
C {devices/lab_pin.sym} 48540 -16490 0 0 {name=p48177 lab=_50195_/Y }
C {devices/lab_pin.sym} 48700 -16530 0 1 {name=p48178 lab=_50196_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -16530 0 0 {name=X_50196_ }
C {devices/lab_pin.sym} 48530 -16390 0 0 {name=p48179 lab=_86203_/CLK }
C {devices/lab_pin.sym} 48530 -16370 0 0 {name=p48180 lab=_52080_/Y }
C {devices/lab_pin.sym} 48710 -16390 0 1 {name=p48181 lab=_85893_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -16380 0 0 {name=X_85893_ }
C {devices/lab_pin.sym} 48560 -16280 0 0 {name=p48182 lab=_60392_/B }
C {devices/lab_pin.sym} 48560 -16240 0 0 {name=p48183 lab=_60174_/C }
C {devices/lab_pin.sym} 48560 -16200 0 0 {name=p48184 lab=_60636_/B }
C {devices/lab_pin.sym} 48560 -16160 0 0 {name=p48185 lab=_60407_/A }
C {devices/lab_pin.sym} 48680 -16220 0 1 {name=p48186 lab=_59600_/X }
C {sky130_stdcells/and4_4.sym} 48620 -16220 0 0 {name=X_59600_ }
C {devices/lab_pin.sym} 48540 -16100 0 0 {name=p48187 lab=_56808_/Y }
C {devices/lab_pin.sym} 48540 -16060 0 0 {name=p48188 lab=_56811_/Y }
C {devices/lab_pin.sym} 48540 -16020 0 0 {name=p48189 lab=_56794_/Y }
C {devices/lab_pin.sym} 48540 -15980 0 0 {name=p48190 lab=_56688_/X }
C {devices/lab_pin.sym} 48700 -16040 0 1 {name=p48191 lab=_56812_/X }
C {sky130_stdcells/a211o_4.sym} 48620 -16040 0 0 {name=X_56812_ }
C {devices/lab_pin.sym} 48530 -15890 0 0 {name=p48192 lab=_87888_/CLK }
C {devices/lab_pin.sym} 48530 -15870 0 0 {name=p48193 lab=_42957_/X }
C {devices/lab_pin.sym} 48710 -15890 0 1 {name=p48194 lab=_87632_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -15880 0 0 {name=X_87632_ }
C {devices/lab_pin.sym} 48530 -15750 0 0 {name=p48195 lab=_84299_/CLK }
C {devices/lab_pin.sym} 48530 -15730 0 0 {name=p48196 lab=_84844_/D }
C {devices/lab_pin.sym} 48710 -15750 0 1 {name=p48197 lab=_84844_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -15740 0 0 {name=X_84844_ }
C {devices/lab_pin.sym} 48560 -15620 0 0 {name=p48198 lab=_57792_/A }
C {devices/lab_pin.sym} 48560 -15580 0 0 {name=p48199 lab=_57791_/X }
C {devices/lab_pin.sym} 48680 -15600 0 1 {name=p48200 lab=_57792_/Y }
C {sky130_stdcells/nor2_4.sym} 48620 -15600 0 0 {name=X_57792_ }
C {devices/lab_pin.sym} 48540 -15500 0 0 {name=p48201 lab=_73175_/A }
C {devices/lab_pin.sym} 48540 -15460 0 0 {name=p48202 lab=_69747_/X }
C {devices/lab_pin.sym} 48540 -15420 0 0 {name=p48203 lab=_68691_/X }
C {devices/lab_pin.sym} 48540 -15380 0 0 {name=p48204 lab=_69777_/Y }
C {devices/lab_pin.sym} 48700 -15440 0 1 {name=p48205 lab=_69778_/X }
C {sky130_stdcells/a211o_4.sym} 48620 -15440 0 0 {name=X_69778_ }
C {devices/lab_pin.sym} 48580 -15290 0 0 {name=p48206 lab=_61183_/A }
C {devices/lab_pin.sym} 48660 -15290 0 1 {name=p48207 lab=_59532_/A }
C {sky130_stdcells/inv_2.sym} 48620 -15290 0 0 {name=X_59531_ }
C {devices/lab_pin.sym} 48580 -15170 0 0 {name=p48208 lab=_56852_/A }
C {devices/lab_pin.sym} 48660 -15170 0 1 {name=p48209 lab=_57179_/A }
C {sky130_stdcells/buf_2.sym} 48620 -15170 0 0 {name=X_56743_ }
C {devices/lab_pin.sym} 48540 -15080 0 0 {name=p48210 lab=_73892_/A }
C {devices/lab_pin.sym} 48540 -15040 0 0 {name=p48211 lab=_68650_/X }
C {devices/lab_pin.sym} 48540 -15000 0 0 {name=p48212 lab=_68651_/X }
C {devices/lab_pin.sym} 48540 -14960 0 0 {name=p48213 lab=_68728_/Y }
C {devices/lab_pin.sym} 48700 -15020 0 1 {name=p48214 lab=_68729_/X }
C {sky130_stdcells/a211o_4.sym} 48620 -15020 0 0 {name=X_68729_ }
C {devices/lab_pin.sym} 48580 -14870 0 0 {name=p48215 lab=clkbuf_9_222_0_CLK/X }
C {devices/lab_pin.sym} 48660 -14870 0 1 {name=p48216 lab=_85351_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 48620 -14870 0 0 {name=Xclkbuf_10_445_0_CLK }
C {devices/lab_pin.sym} 48530 -14750 0 0 {name=p48217 lab=_83158_/CLK }
C {devices/lab_pin.sym} 48530 -14730 0 0 {name=p48218 lab=_43136_/Y }
C {devices/lab_pin.sym} 48710 -14750 0 1 {name=p48219 lab=_87563_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -14740 0 0 {name=X_87563_ }
C {devices/lab_pin.sym} 48580 -14610 0 0 {name=p48220 lab=_53921_/A }
C {devices/lab_pin.sym} 48660 -14610 0 1 {name=p48221 lab=_53955_/X }
C {sky130_stdcells/buf_2.sym} 48620 -14610 0 0 {name=X_53955_ }
C {devices/lab_pin.sym} 48530 -14490 0 0 {name=p48222 lab=_86688_/CLK }
C {devices/lab_pin.sym} 48530 -14470 0 0 {name=p48223 lab=_84775_/D }
C {devices/lab_pin.sym} 48710 -14490 0 1 {name=p48224 lab=_84775_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -14480 0 0 {name=X_84775_ }
C {devices/lab_pin.sym} 48530 -14350 0 0 {name=p48225 lab=_82104_/CLK }
C {devices/lab_pin.sym} 48530 -14330 0 0 {name=p48226 lab=_81987_/D }
C {devices/lab_pin.sym} 48710 -14350 0 1 {name=p48227 lab=_77013_/A }
C {sky130_stdcells/dfxtp_4.sym} 48620 -14340 0 0 {name=X_81987_ }
C {devices/lab_pin.sym} 48530 -14210 0 0 {name=p48228 lab=_83572_/CLK }
C {devices/lab_pin.sym} 48530 -14190 0 0 {name=p48229 lab=_86514_/D }
C {devices/lab_pin.sym} 48710 -14210 0 1 {name=p48230 lab=_86514_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -14200 0 0 {name=X_86514_ }
C {devices/lab_pin.sym} 48540 -14090 0 0 {name=p48231 lab=_40877_/X }
C {devices/lab_pin.sym} 48540 -14050 0 0 {name=p48232 lab=_82852_/Q }
C {devices/lab_pin.sym} 48540 -14010 0 0 {name=p48233 lab=_40919_/X }
C {devices/lab_pin.sym} 48700 -14050 0 1 {name=p48234 lab=_40921_/A }
C {sky130_stdcells/o21ai_4.sym} 48620 -14050 0 0 {name=X_40920_ }
C {devices/lab_pin.sym} 48540 -13930 0 0 {name=p48235 lab=_85733_/Q }
C {devices/lab_pin.sym} 48540 -13890 0 0 {name=p48236 lab=_52902_/X }
C {devices/lab_pin.sym} 48540 -13850 0 0 {name=p48237 lab=_52905_/Y }
C {devices/lab_pin.sym} 48700 -13890 0 1 {name=p48238 lab=_52906_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -13890 0 0 {name=X_52906_ }
C {devices/lab_pin.sym} 48580 -13750 0 0 {name=p48239 lab=_71753_/D }
C {devices/lab_pin.sym} 48660 -13750 0 1 {name=p48240 lab=_71744_/D }
C {sky130_stdcells/buf_2.sym} 48620 -13750 0 0 {name=X_71740_ }
C {devices/lab_pin.sym} 48530 -13630 0 0 {name=p48241 lab=_85381_/CLK }
C {devices/lab_pin.sym} 48530 -13610 0 0 {name=p48242 lab=_83726_/D }
C {devices/lab_pin.sym} 48710 -13630 0 1 {name=p48243 lab=_47480_/A }
C {sky130_stdcells/dfxtp_4.sym} 48620 -13620 0 0 {name=X_83726_ }
C {devices/lab_pin.sym} 48580 -13490 0 0 {name=p48244 lab=_58982_/A }
C {devices/lab_pin.sym} 48660 -13490 0 1 {name=p48245 lab=_59462_/X }
C {sky130_stdcells/buf_2.sym} 48620 -13490 0 0 {name=X_59462_ }
C {devices/lab_pin.sym} 48580 -13370 0 0 {name=p48246 lab=_56655_/A }
C {devices/lab_pin.sym} 48660 -13370 0 1 {name=p48247 lab=_56674_/X }
C {sky130_stdcells/buf_2.sym} 48620 -13370 0 0 {name=X_56674_ }
C {devices/lab_pin.sym} 48530 -13250 0 0 {name=p48248 lab=_80776_/CLK }
C {devices/lab_pin.sym} 48530 -13230 0 0 {name=p48249 lab=_80938_/D }
C {devices/lab_pin.sym} 48710 -13250 0 1 {name=p48250 lab=_74906_/A }
C {sky130_stdcells/dfxtp_4.sym} 48620 -13240 0 0 {name=X_80938_ }
C {devices/lab_pin.sym} 48530 -13110 0 0 {name=p48251 lab=_87749_/CLK }
C {devices/lab_pin.sym} 48530 -13090 0 0 {name=p48252 lab=_87494_/D }
C {devices/lab_pin.sym} 48710 -13110 0 1 {name=p48253 lab=_87494_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -13100 0 0 {name=X_87494_ }
C {devices/lab_pin.sym} 48560 -12980 0 0 {name=p48254 lab=_53871_/X }
C {devices/lab_pin.sym} 48560 -12940 0 0 {name=p48255 lab=_53886_/B }
C {devices/lab_pin.sym} 48680 -12960 0 1 {name=p48256 lab=_53886_/Y }
C {sky130_stdcells/nand2_4.sym} 48620 -12960 0 0 {name=X_53886_ }
C {devices/lab_pin.sym} 48540 -12850 0 0 {name=p48257 lab=_58406_/X }
C {devices/lab_pin.sym} 48540 -12810 0 0 {name=p48258 lab=_83367_/Q }
C {devices/lab_pin.sym} 48540 -12770 0 0 {name=p48259 lab=_58412_/Y }
C {devices/lab_pin.sym} 48700 -12810 0 1 {name=p48260 lab=_58413_/X }
C {sky130_stdcells/o21a_4.sym} 48620 -12810 0 0 {name=X_58413_ }
C {devices/lab_pin.sym} 48560 -12680 0 0 {name=p48261 lab=_44087_/B }
C {devices/lab_pin.sym} 48560 -12640 0 0 {name=p48262 lab=_55625_/B }
C {devices/lab_pin.sym} 48680 -12660 0 1 {name=p48263 lab=_55625_/Y }
C {sky130_stdcells/nor2_4.sym} 48620 -12660 0 0 {name=X_55625_ }
C {devices/lab_pin.sym} 48530 -12530 0 0 {name=p48264 lab=_86155_/CLK }
C {devices/lab_pin.sym} 48530 -12510 0 0 {name=p48265 lab=_86445_/D }
C {devices/lab_pin.sym} 48710 -12530 0 1 {name=p48266 lab=_86445_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -12520 0 0 {name=X_86445_ }
C {devices/lab_pin.sym} 48580 -12390 0 0 {name=p48267 lab=_40850_/Y }
C {devices/lab_pin.sym} 48660 -12390 0 1 {name=p48268 lab=_88323_/D }
C {sky130_stdcells/inv_2.sym} 48620 -12390 0 0 {name=X_40851_ }
C {devices/lab_pin.sym} 48560 -12280 0 0 {name=p48269 lab=_52843_/A }
C {devices/lab_pin.sym} 48560 -12240 0 0 {name=p48270 lab=_52837_/B }
C {devices/lab_pin.sym} 48680 -12260 0 1 {name=p48271 lab=_52837_/Y }
C {sky130_stdcells/nand2_4.sym} 48620 -12260 0 0 {name=X_52837_ }
C {devices/lab_pin.sym} 48580 -12130 0 0 {name=p48272 lab=_71641_/A }
C {devices/lab_pin.sym} 48660 -12130 0 1 {name=p48273 lab=_71671_/X }
C {sky130_stdcells/buf_2.sym} 48620 -12130 0 0 {name=X_71671_ }
C {devices/lab_pin.sym} 48540 -12030 0 0 {name=p48274 lab=_58982_/X }
C {devices/lab_pin.sym} 48540 -11990 0 0 {name=p48275 lab=_83488_/Q }
C {devices/lab_pin.sym} 48540 -11950 0 0 {name=p48276 lab=_59392_/Y }
C {devices/lab_pin.sym} 48700 -11990 0 1 {name=p48277 lab=_84744_/D }
C {sky130_stdcells/o21a_4.sym} 48620 -11990 0 0 {name=X_59393_ }
C {devices/lab_pin.sym} 48530 -11850 0 0 {name=p48278 lab=_85822_/CLK }
C {devices/lab_pin.sym} 48530 -11830 0 0 {name=p48279 lab=_83657_/D }
C {devices/lab_pin.sym} 48710 -11850 0 1 {name=p48280 lab=_46242_/A }
C {sky130_stdcells/dfxtp_4.sym} 48620 -11840 0 0 {name=X_83657_ }
C {devices/lab_pin.sym} 48530 -11710 0 0 {name=p48281 lab=_81125_/CLK }
C {devices/lab_pin.sym} 48530 -11690 0 0 {name=p48282 lab=_75604_/B }
C {devices/lab_pin.sym} 48710 -11710 0 1 {name=p48283 lab=_80837_/D }
C {sky130_stdcells/dfxtp_4.sym} 48620 -11700 0 0 {name=X_80869_ }
C {devices/lab_pin.sym} 48560 -11580 0 0 {name=p48284 lab=_48639_/A }
C {devices/lab_pin.sym} 48560 -11540 0 0 {name=p48285 lab=_73409_/Y }
C {devices/lab_pin.sym} 48680 -11560 0 1 {name=p48286 lab=_73410_/X }
C {sky130_stdcells/xor2_4.sym} 48620 -11560 0 0 {name=X_73410_ }
C {devices/lab_pin.sym} 48580 -11430 0 0 {name=p48287 lab=_70824_/A }
C {devices/lab_pin.sym} 48660 -11430 0 1 {name=p48288 lab=_70727_/A }
C {sky130_stdcells/buf_2.sym} 48620 -11430 0 0 {name=X_70622_ }
C {devices/lab_pin.sym} 48530 -11310 0 0 {name=p48289 lab=_82702_/CLK }
C {devices/lab_pin.sym} 48530 -11290 0 0 {name=p48290 lab=_78939_/B }
C {devices/lab_pin.sym} 48710 -11310 0 1 {name=p48291 lab=_82576_/D }
C {sky130_stdcells/dfxtp_4.sym} 48620 -11300 0 0 {name=X_82608_ }
C {devices/lab_pin.sym} 48560 -11180 0 0 {name=p48292 lab=_58344_/A }
C {devices/lab_pin.sym} 48560 -11140 0 0 {name=p48293 lab=_58344_/B }
C {devices/lab_pin.sym} 48680 -11160 0 1 {name=p48294 lab=_58344_/Y }
C {sky130_stdcells/nor2_4.sym} 48620 -11160 0 0 {name=X_58344_ }
C {devices/lab_pin.sym} 48540 -11070 0 0 {name=p48295 lab=_43557_/X }
C {devices/lab_pin.sym} 48540 -11030 0 0 {name=p48296 lab=_43563_/X }
C {devices/lab_pin.sym} 48540 -10990 0 0 {name=p48297 lab=_40515_/X }
C {devices/lab_pin.sym} 48540 -10950 0 0 {name=p48298 lab=_87355_/Q }
C {devices/lab_pin.sym} 48540 -10910 0 0 {name=p48299 lab=_43058_/A }
C {devices/lab_pin.sym} 48700 -10990 0 1 {name=p48300 lab=_43570_/Y }
C {sky130_stdcells/o32ai_4.sym} 48620 -10990 0 0 {name=X_43570_ }
C {devices/lab_pin.sym} 48540 -10860 0 0 {name=p48301 lab=_45504_/A }
C {devices/lab_pin.sym} 48540 -10820 0 0 {name=p48302 lab=_55522_/X }
C {devices/lab_pin.sym} 48540 -10780 0 0 {name=p48303 lab=_55513_/X }
C {devices/lab_pin.sym} 48540 -10740 0 0 {name=p48304 lab=_55555_/Y }
C {devices/lab_pin.sym} 48700 -10800 0 1 {name=p48305 lab=_55556_/X }
C {sky130_stdcells/a211o_4.sym} 48620 -10800 0 0 {name=X_55556_ }
C {devices/lab_pin.sym} 48530 -10650 0 0 {name=p48306 lab=_83666_/CLK }
C {devices/lab_pin.sym} 48530 -10630 0 0 {name=p48307 lab=_86376_/D }
C {devices/lab_pin.sym} 48710 -10650 0 1 {name=p48308 lab=_86376_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -10640 0 0 {name=X_86376_ }
C {devices/lab_pin.sym} 48540 -10530 0 0 {name=p48309 lab=_83076_/Q }
C {devices/lab_pin.sym} 48540 -10490 0 0 {name=p48310 lab=_74387_/X }
C {devices/lab_pin.sym} 48540 -10450 0 0 {name=p48311 lab=_74389_/Y }
C {devices/lab_pin.sym} 48700 -10490 0 1 {name=p48312 lab=_74390_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -10490 0 0 {name=X_74390_ }
C {devices/lab_pin.sym} 48540 -10380 0 0 {name=p48313 lab=_40781_/X }
C {devices/lab_pin.sym} 48540 -10340 0 0 {name=p48314 lab=_40754_/X }
C {devices/lab_pin.sym} 48540 -10300 0 0 {name=p48315 lab=_69612_/B }
C {devices/lab_pin.sym} 48540 -10260 0 0 {name=p48316 lab=_40756_/X }
C {devices/lab_pin.sym} 48700 -10320 0 1 {name=p48317 lab=_88336_/D }
C {sky130_stdcells/a2bb2o_4.sym} 48620 -10320 0 0 {name=X_40782_ }
C {devices/lab_pin.sym} 48560 -10180 0 0 {name=p48318 lab=_52773_/A }
C {devices/lab_pin.sym} 48560 -10140 0 0 {name=p48319 lab=_52768_/B }
C {devices/lab_pin.sym} 48680 -10160 0 1 {name=p48320 lab=_52768_/Y }
C {sky130_stdcells/nand2_4.sym} 48620 -10160 0 0 {name=X_52768_ }
C {devices/lab_pin.sym} 48530 -10030 0 0 {name=p48321 lab=_86525_/CLK }
C {devices/lab_pin.sym} 48530 -10010 0 0 {name=p48322 lab=_71156_/Y }
C {devices/lab_pin.sym} 48710 -10030 0 1 {name=p48323 lab=_83588_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -10020 0 0 {name=X_83588_ }
C {devices/lab_pin.sym} 48530 -9890 0 0 {name=p48324 lab=_88108_/CLK }
C {devices/lab_pin.sym} 48530 -9870 0 0 {name=p48325 lab=_88115_/D }
C {devices/lab_pin.sym} 48710 -9890 0 1 {name=p48326 lab=_73552_/A }
C {sky130_stdcells/dfxtp_4.sym} 48620 -9880 0 0 {name=X_88115_ }
C {devices/lab_pin.sym} 48580 -9750 0 0 {name=p48327 lab=_42610_/A }
C {devices/lab_pin.sym} 48660 -9750 0 1 {name=p48328 lab=_42521_/X }
C {sky130_stdcells/buf_2.sym} 48620 -9750 0 0 {name=X_42521_ }
C {devices/lab_pin.sym} 48580 -9630 0 0 {name=p48329 lab=_54481_/A }
C {devices/lab_pin.sym} 48660 -9630 0 1 {name=p48330 lab=_54509_/A }
C {sky130_stdcells/buf_2.sym} 48620 -9630 0 0 {name=X_54507_ }
C {devices/lab_pin.sym} 48560 -9520 0 0 {name=p48331 lab=_73341_/A }
C {devices/lab_pin.sym} 48560 -9480 0 0 {name=p48332 lab=_73196_/B }
C {devices/lab_pin.sym} 48680 -9500 0 1 {name=p48333 lab=_73341_/Y }
C {sky130_stdcells/nor2_4.sym} 48620 -9500 0 0 {name=X_73341_ }
C {devices/lab_pin.sym} 48530 -9370 0 0 {name=p48334 lab=_83550_/CLK }
C {devices/lab_pin.sym} 48530 -9350 0 0 {name=p48335 lab=_85327_/D }
C {devices/lab_pin.sym} 48710 -9370 0 1 {name=p48336 lab=_85327_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -9360 0 0 {name=X_85327_ }
C {devices/lab_pin.sym} 48580 -9230 0 0 {name=p48337 lab=_51719_/A }
C {devices/lab_pin.sym} 48660 -9230 0 1 {name=p48338 lab=_51719_/X }
C {sky130_stdcells/buf_2.sym} 48620 -9230 0 0 {name=X_51719_ }
C {devices/lab_pin.sym} 48580 -9110 0 0 {name=p48339 lab=_70552_/Y }
C {devices/lab_pin.sym} 48660 -9110 0 1 {name=p48340 lab=_71859_/A }
C {sky130_stdcells/buf_2.sym} 48620 -9110 0 0 {name=X_70553_ }
C {devices/lab_pin.sym} 48540 -9010 0 0 {name=p48341 lab=_58271_/X }
C {devices/lab_pin.sym} 48540 -8970 0 0 {name=p48342 lab=_83443_/Q }
C {devices/lab_pin.sym} 48540 -8930 0 0 {name=p48343 lab=_58274_/Y }
C {devices/lab_pin.sym} 48700 -8970 0 1 {name=p48344 lab=_84891_/D }
C {sky130_stdcells/o21a_4.sym} 48620 -8970 0 0 {name=X_58275_ }
C {devices/lab_pin.sym} 48530 -8830 0 0 {name=p48345 lab=_82541_/CLK }
C {devices/lab_pin.sym} 48530 -8810 0 0 {name=p48346 lab=_83859_/Q }
C {devices/lab_pin.sym} 48710 -8830 0 1 {name=p48347 lab=_82539_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -8820 0 0 {name=X_82539_ }
C {devices/lab_pin.sym} 48580 -8690 0 0 {name=p48348 lab=_55453_/X }
C {devices/lab_pin.sym} 48660 -8690 0 1 {name=p48349 lab=_55489_/A }
C {sky130_stdcells/buf_2.sym} 48620 -8690 0 0 {name=X_55487_ }
C {devices/lab_pin.sym} 48540 -8590 0 0 {name=p48350 lab=_52697_/Y }
C {devices/lab_pin.sym} 48540 -8550 0 0 {name=p48351 lab=_52673_/X }
C {devices/lab_pin.sym} 48540 -8510 0 0 {name=p48352 lab=_52698_/X }
C {devices/lab_pin.sym} 48700 -8550 0 1 {name=p48353 lab=_52699_/Y }
C {sky130_stdcells/a21oi_4.sym} 48620 -8550 0 0 {name=X_52699_ }
C {devices/lab_pin.sym} 48540 -8430 0 0 {name=p48354 lab=_56523_/C }
C {devices/lab_pin.sym} 48540 -8390 0 0 {name=p48355 lab=_45209_/X }
C {devices/lab_pin.sym} 48540 -8350 0 0 {name=p48356 lab=_45189_/X }
C {devices/lab_pin.sym} 48700 -8390 0 1 {name=p48357 lab=_45240_/X }
C {sky130_stdcells/o21a_4.sym} 48620 -8390 0 0 {name=X_45240_ }
C {devices/lab_pin.sym} 48540 -8280 0 0 {name=p48358 lab=_45947_/B }
C {devices/lab_pin.sym} 48540 -8240 0 0 {name=p48359 lab=_85059_/Q }
C {devices/lab_pin.sym} 48540 -8200 0 0 {name=p48360 lab=_57225_/Y }
C {devices/lab_pin.sym} 48540 -8160 0 0 {name=p48361 lab=_57158_/C }
C {devices/lab_pin.sym} 48700 -8220 0 1 {name=p48362 lab=_57226_/X }
C {sky130_stdcells/a211o_4.sym} 48620 -8220 0 0 {name=X_57226_ }
C {devices/lab_pin.sym} 48560 -8080 0 0 {name=p48363 lab=_76057_/Y }
C {devices/lab_pin.sym} 48560 -8040 0 0 {name=p48364 lab=_76060_/B }
C {devices/lab_pin.sym} 48680 -8060 0 1 {name=p48365 lab=_76061_/B }
C {sky130_stdcells/xor2_4.sym} 48620 -8060 0 0 {name=X_76060_ }
C {devices/lab_pin.sym} 48530 -7930 0 0 {name=p48366 lab=_87789_/CLK }
C {devices/lab_pin.sym} 48530 -7910 0 0 {name=p48367 lab=_42074_/X }
C {devices/lab_pin.sym} 48710 -7930 0 1 {name=p48368 lab=_88046_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -7920 0 0 {name=X_88046_ }
C {devices/lab_pin.sym} 48540 -7810 0 0 {name=p48369 lab=_85442_/Q }
C {devices/lab_pin.sym} 48540 -7770 0 0 {name=p48370 lab=_54431_/X }
C {devices/lab_pin.sym} 48540 -7730 0 0 {name=p48371 lab=_54437_/Y }
C {devices/lab_pin.sym} 48700 -7770 0 1 {name=p48372 lab=_54438_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -7770 0 0 {name=X_54438_ }
C {devices/lab_pin.sym} 48580 -7630 0 0 {name=p48373 lab=_42488_/A }
C {devices/lab_pin.sym} 48660 -7630 0 1 {name=p48374 lab=_42612_/A }
C {sky130_stdcells/buf_2.sym} 48620 -7630 0 0 {name=X_42452_ }
C {devices/lab_pin.sym} 48540 -7530 0 0 {name=p48375 lab=_83158_/Q }
C {devices/lab_pin.sym} 48540 -7490 0 0 {name=p48376 lab=_73193_/X }
C {devices/lab_pin.sym} 48540 -7450 0 0 {name=p48377 lab=_73271_/Y }
C {devices/lab_pin.sym} 48700 -7490 0 1 {name=p48378 lab=_73272_/X }
C {sky130_stdcells/a21o_4.sym} 48620 -7490 0 0 {name=X_73272_ }
C {devices/lab_pin.sym} 48530 -7350 0 0 {name=p48379 lab=_85257_/CLK }
C {devices/lab_pin.sym} 48530 -7330 0 0 {name=p48380 lab=_56254_/Y }
C {devices/lab_pin.sym} 48710 -7350 0 1 {name=p48381 lab=_56253_/C }
C {sky130_stdcells/dfxtp_4.sym} 48620 -7340 0 0 {name=X_85258_ }
C {devices/lab_pin.sym} 48540 -7230 0 0 {name=p48382 lab=_70466_/Y }
C {devices/lab_pin.sym} 48540 -7190 0 0 {name=p48383 lab=_83764_/Q }
C {devices/lab_pin.sym} 48540 -7150 0 0 {name=p48384 lab=_70483_/X }
C {devices/lab_pin.sym} 48700 -7190 0 1 {name=p48385 lab=_83764_/D }
C {sky130_stdcells/a21o_4.sym} 48620 -7190 0 0 {name=X_70484_ }
C {devices/lab_pin.sym} 48540 -7070 0 0 {name=p48386 lab=_75001_/Y }
C {devices/lab_pin.sym} 48540 -7030 0 0 {name=p48387 lab=_75004_/X }
C {devices/lab_pin.sym} 48540 -6990 0 0 {name=p48388 lab=_74999_/X }
C {devices/lab_pin.sym} 48700 -7030 0 1 {name=p48389 lab=_75011_/Y }
C {sky130_stdcells/a21boi_4.sym} 48620 -7030 0 0 {name=X_75011_ }
C {devices/lab_pin.sym} 48580 -6890 0 0 {name=p48390 lab=_41402_/X }
C {devices/lab_pin.sym} 48660 -6890 0 1 {name=p48391 lab=_41403_/X }
C {sky130_stdcells/buf_2.sym} 48620 -6890 0 0 {name=X_41403_ }
C {devices/lab_pin.sym} 48540 -6800 0 0 {name=p48392 lab=_72214_/Y }
C {devices/lab_pin.sym} 48540 -6760 0 0 {name=p48393 lab=_72152_/X }
C {devices/lab_pin.sym} 48540 -6720 0 0 {name=p48394 lab=_72219_/X }
C {devices/lab_pin.sym} 48540 -6680 0 0 {name=p48395 lab=_72222_/X }
C {devices/lab_pin.sym} 48700 -6740 0 1 {name=p48396 lab=_83273_/D }
C {sky130_stdcells/a22oi_4.sym} 48620 -6740 0 0 {name=X_72223_ }
C {devices/lab_pin.sym} 48530 -6590 0 0 {name=p48397 lab=_85315_/CLK }
C {devices/lab_pin.sym} 48530 -6570 0 0 {name=p48398 lab=_65246_/X }
C {devices/lab_pin.sym} 48710 -6590 0 1 {name=p48399 lab=_84209_/Q }
C {sky130_stdcells/dfxtp_4.sym} 48620 -6580 0 0 {name=X_84209_ }
C {devices/lab_pin.sym} 48580 -6450 0 0 {name=p48400 lab=_64411_/B }
C {devices/lab_pin.sym} 48660 -6450 0 1 {name=p48401 lab=_61538_/B }
C {sky130_stdcells/buf_2.sym} 48620 -6450 0 0 {name=X_45171_ }
C {devices/lab_pin.sym} 48540 -6370 0 0 {name=p48402 lab=_56801_/X }
C {devices/lab_pin.sym} 48540 -6330 0 0 {name=p48403 lab=_57170_/B }
C {devices/lab_pin.sym} 48540 -6290 0 0 {name=p48404 lab=_57155_/D }
C {devices/lab_pin.sym} 48540 -6250 0 0 {name=p48405 lab=_57156_/X }
C {devices/lab_pin.sym} 48540 -6220 0 0 {name=p48406 lab=_57003_/B }
C {devices/lab_pin.sym} 48700 -6290 0 1 {name=p48407 lab=_57158_/B }
C {sky130_stdcells/a41oi_4.sym} 48620 -6290 0 0 {name=X_57157_ }
C {devices/lab_pin.sym} 48540 -6160 0 0 {name=p48408 lab=_41797_/X }
C {devices/lab_pin.sym} 48540 -6120 0 0 {name=p48409 lab=_42374_/X }
C {devices/lab_pin.sym} 48540 -6080 0 0 {name=p48410 lab=_87891_/Q }
C {devices/lab_pin.sym} 48540 -6040 0 0 {name=p48411 lab=_42375_/X }
C {devices/lab_pin.sym} 48700 -6100 0 1 {name=p48412 lab=_87891_/D }
C {sky130_stdcells/a2bb2o_4.sym} 48620 -6100 0 0 {name=X_42383_ }
C {devices/lab_pin.sym} 48560 -5960 0 0 {name=p48413 lab=_54355_/A }
C {devices/lab_pin.sym} 48560 -5920 0 0 {name=p48414 lab=_52677_/B }
C {devices/lab_pin.sym} 48680 -5940 0 1 {name=p48415 lab=_54369_/Y }
C {sky130_stdcells/nand2_4.sym} 48620 -5940 0 0 {name=X_54369_ }
C {devices/lab_pin.sym} 48530 -5810 0 0 {name=p48416 lab=_85156_/CLK }
C {devices/lab_pin.sym} 48530 -5790 0 0 {name=p48417 lab=_85189_/D }
C {devices/lab_pin.sym} 48710 -5810 0 1 {name=p48418 lab=_56450_/C }
C {sky130_stdcells/dfxtp_4.sym} 48620 -5800 0 0 {name=X_85189_ }
C {devices/lab_pin.sym} 48580 -5670 0 0 {name=p48419 lab=HASH_EN }
C {devices/lab_pin.sym} 48660 -5670 0 1 {name=p48420 lab=_44196_/B }
C {sky130_stdcells/buf_2.sym} 48620 -5670 0 0 {name=X_44122_ }
C {devices/lab_pin.sym} 48560 -5560 0 0 {name=p48421 lab=_56108_/A }
C {devices/lab_pin.sym} 48560 -5520 0 0 {name=p48422 lab=_56108_/B }
C {devices/lab_pin.sym} 48680 -5540 0 1 {name=p48423 lab=_56109_/A }
C {sky130_stdcells/xnor2_4.sym} 48620 -5540 0 0 {name=X_56108_ }
C {devices/lab_pin.sym} 48540 -5450 0 0 {name=p48424 lab=_41239_/X }
C {devices/lab_pin.sym} 48540 -5410 0 0 {name=p48425 lab=_41241_/X }
C {devices/lab_pin.sym} 48540 -5370 0 0 {name=p48426 lab=_41332_/X }
C {devices/lab_pin.sym} 48540 -5330 0 0 {name=p48427 lab=_67553_/B }
C {devices/lab_pin.sym} 48540 -5290 0 0 {name=p48428 lab=_41333_/X }
C {devices/lab_pin.sym} 48700 -5370 0 1 {name=p48429 lab=_41334_/Y }
C {sky130_stdcells/o32ai_4.sym} 48620 -5370 0 0 {name=X_41334_ }
C {devices/lab_pin.sym} 48580 -5210 0 0 {name=p48430 lab=clkbuf_9_505_0_CLK/A }
C {devices/lab_pin.sym} 48660 -5210 0 1 {name=p48431 lab=clkbuf_9_504_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 48620 -5210 0 0 {name=Xclkbuf_9_504_0_CLK }
C {devices/lab_pin.sym} 48540 -5110 0 0 {name=p48432 lab=_59231_/X }
C {devices/lab_pin.sym} 48540 -5070 0 0 {name=p48433 lab=_85374_/Q }
C {devices/lab_pin.sym} 48540 -5030 0 0 {name=p48434 lab=_72153_/X }
C {devices/lab_pin.sym} 48700 -5070 0 1 {name=p48435 lab=_72154_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -5070 0 0 {name=X_72154_ }
C {devices/lab_pin.sym} 48580 -4930 0 0 {name=p48436 lab=_72814_/A }
C {devices/lab_pin.sym} 48660 -4930 0 1 {name=p48437 lab=_73183_/A }
C {sky130_stdcells/buf_2.sym} 48620 -4930 0 0 {name=X_57088_ }
C {devices/lab_pin.sym} 48540 -4830 0 0 {name=p48438 lab=_49073_/X }
C {devices/lab_pin.sym} 48540 -4790 0 0 {name=p48439 lab=_71095_/X }
C {devices/lab_pin.sym} 48540 -4750 0 0 {name=p48440 lab=_71104_/Y }
C {devices/lab_pin.sym} 48700 -4790 0 1 {name=p48441 lab=_83606_/D }
C {sky130_stdcells/o21ai_4.sym} 48620 -4790 0 0 {name=X_71105_ }
C {devices/lab_pin.sym} 48580 -4650 0 0 {name=p48442 lab=_48930_/A }
C {devices/lab_pin.sym} 48660 -4650 0 1 {name=p48443 lab=_48931_/A }
C {sky130_stdcells/inv_2.sym} 48620 -4650 0 0 {name=X_48930_ }
C {devices/lab_pin.sym} 48560 -4540 0 0 {name=p48444 lab=_55927_/X }
C {devices/lab_pin.sym} 48560 -4500 0 0 {name=p48445 lab=_56001_/A }
C {devices/lab_pin.sym} 48680 -4520 0 1 {name=p48446 lab=_56039_/Y }
C {sky130_stdcells/xnor2_4.sym} 48620 -4520 0 0 {name=X_56039_ }
C {devices/lab_pin.sym} 48580 -4390 0 0 {name=p48447 lab=_44053_/A }
C {devices/lab_pin.sym} 48660 -4390 0 1 {name=p48448 lab=_44202_/A }
C {sky130_stdcells/inv_2.sym} 48620 -4390 0 0 {name=X_44053_ }
C {devices/lab_pin.sym} 48540 -4290 0 0 {name=p48449 lab=_79728_/Y }
C {devices/lab_pin.sym} 48540 -4250 0 0 {name=p48450 lab=_79746_/X }
C {devices/lab_pin.sym} 48540 -4210 0 0 {name=p48451 lab=_79749_/Y }
C {devices/lab_pin.sym} 48700 -4250 0 1 {name=p48452 lab=_79750_/Y }
C {sky130_stdcells/a21oi_4.sym} 48620 -4250 0 0 {name=X_79750_ }
C {devices/lab_pin.sym} 48540 -4140 0 0 {name=p48453 lab=_41264_/X }
C {devices/lab_pin.sym} 48540 -4100 0 0 {name=p48454 lab=_41251_/X }
C {devices/lab_pin.sym} 48540 -4060 0 0 {name=p48455 lab=_88248_/Q }
C {devices/lab_pin.sym} 48540 -4020 0 0 {name=p48456 lab=_41253_/X }
C {devices/lab_pin.sym} 48700 -4080 0 1 {name=p48457 lab=_41265_/X }
C {sky130_stdcells/a2bb2o_4.sym} 48620 -4080 0 0 {name=X_41265_ }
C {devices/lab_pin.sym} 48540 -3950 0 0 {name=p48458 lab=_72082_/Y }
C {devices/lab_pin.sym} 48540 -3910 0 0 {name=p48459 lab=_72083_/X }
C {devices/lab_pin.sym} 48540 -3870 0 0 {name=p48460 lab=_72084_/Y }
C {devices/lab_pin.sym} 48700 -3910 0 1 {name=p48461 lab=_83288_/D }
C {sky130_stdcells/a21boi_4.sym} 48620 -3910 0 0 {name=X_72085_ }
C {devices/lab_pin.sym} 48580 -3770 0 0 {name=p48462 lab=_76840_/Y }
C {devices/lab_pin.sym} 48660 -3770 0 1 {name=p48463 lab=_81367_/D }
C {sky130_stdcells/inv_2.sym} 48620 -3770 0 0 {name=X_76962_ }
C {devices/lab_pin.sym} 48540 -3680 0 0 {name=p48464 lab=_40528_/X }
C {devices/lab_pin.sym} 48540 -3640 0 0 {name=p48465 lab=_42994_/X }
C {devices/lab_pin.sym} 48540 -3600 0 0 {name=p48466 lab=_87608_/Q }
C {devices/lab_pin.sym} 48540 -3560 0 0 {name=p48467 lab=_42995_/X }
C {devices/lab_pin.sym} 48700 -3620 0 1 {name=p48468 lab=_43004_/X }
C {sky130_stdcells/a2bb2o_4.sym} 48620 -3620 0 0 {name=X_43004_ }
C {devices/lab_pin.sym} 48560 -3480 0 0 {name=p48469 lab=_78701_/A }
C {devices/lab_pin.sym} 48560 -3440 0 0 {name=p48470 lab=_78701_/B }
C {devices/lab_pin.sym} 48680 -3460 0 1 {name=p48471 lab=_78701_/X }
C {sky130_stdcells/and2_4.sym} 48620 -3460 0 0 {name=X_78701_ }
C {devices/lab_pin.sym} 48560 -3360 0 0 {name=p48472 lab=_71181_/A }
C {devices/lab_pin.sym} 48560 -3320 0 0 {name=p48473 lab=_71030_/B }
C {devices/lab_pin.sym} 48560 -3280 0 0 {name=p48474 lab=_71030_/C }
C {devices/lab_pin.sym} 48560 -3240 0 0 {name=p48475 lab=_71039_/D }
C {devices/lab_pin.sym} 48680 -3300 0 1 {name=p48476 lab=_71036_/Y }
C {sky130_stdcells/nand4_4.sym} 48620 -3300 0 0 {name=X_71036_ }
C {devices/lab_pin.sym} 48560 -3160 0 0 {name=p48477 lab=_84511_/Q }
C {devices/lab_pin.sym} 48560 -3120 0 0 {name=p48478 lab=_84383_/Q }
C {devices/lab_pin.sym} 48680 -3140 0 1 {name=p48479 lab=_75913_/X }
C {sky130_stdcells/xor2_4.sym} 48620 -3140 0 0 {name=X_75913_ }
C {devices/lab_pin.sym} 48580 -3010 0 0 {name=p48480 lab=_48836_/A }
C {devices/lab_pin.sym} 48660 -3010 0 1 {name=p48481 lab=_48861_/X }
C {sky130_stdcells/buf_2.sym} 48620 -3010 0 0 {name=X_48861_ }
C {devices/lab_pin.sym} 48560 -2900 0 0 {name=p48482 lab=_79679_/X }
C {devices/lab_pin.sym} 48560 -2860 0 0 {name=p48483 lab=_79681_/B }
C {devices/lab_pin.sym} 48680 -2880 0 1 {name=p48484 lab=_79682_/B }
C {sky130_stdcells/xnor2_4.sym} 48620 -2880 0 0 {name=X_79681_ }
C {devices/lab_pin.sym} 48580 -2750 0 0 {name=p48485 lab=_41196_/A }
C {devices/lab_pin.sym} 48660 -2750 0 1 {name=p48486 lab=_88260_/D }
C {sky130_stdcells/inv_2.sym} 48620 -2750 0 0 {name=X_41196_ }
C {devices/lab_pin.sym} 48580 -2630 0 0 {name=p48487 lab=_76893_/A }
C {devices/lab_pin.sym} 48660 -2630 0 1 {name=p48488 lab=_76893_/Y }
C {sky130_stdcells/inv_2.sym} 48620 -2630 0 0 {name=X_76893_ }
C {devices/lab_pin.sym} 48580 -2510 0 0 {name=p48489 lab=_49379_/A }
C {devices/lab_pin.sym} 48660 -2510 0 1 {name=p48490 lab=_49374_/A }
C {sky130_stdcells/buf_2.sym} 48620 -2510 0 0 {name=X_47812_ }
C {devices/lab_pin.sym} 48560 -2410 0 0 {name=p48491 lab=_78628_/Y }
C {devices/lab_pin.sym} 48560 -2370 0 0 {name=p48492 lab=_78632_/B }
C {devices/lab_pin.sym} 48560 -2330 0 0 {name=p48493 lab=_78632_/C }
C {devices/lab_pin.sym} 48680 -2370 0 1 {name=p48494 lab=_78632_/X }
C {sky130_stdcells/or3_4.sym} 48620 -2370 0 0 {name=X_78632_ }
C {devices/lab_pin.sym} 48540 -2250 0 0 {name=p48495 lab=_75836_/A }
C {devices/lab_pin.sym} 48540 -2210 0 0 {name=p48496 lab=_75836_/B }
C {devices/lab_pin.sym} 48540 -2170 0 0 {name=p48497 lab=_75843_/Y }
C {devices/lab_pin.sym} 48700 -2210 0 1 {name=p48498 lab=_75844_/Y }
C {sky130_stdcells/o21ai_4.sym} 48620 -2210 0 0 {name=X_75844_ }
C {devices/lab_pin.sym} 48540 -2090 0 0 {name=p48499 lab=_48789_/Y }
C {devices/lab_pin.sym} 48540 -2050 0 0 {name=p48500 lab=_48785_/X }
C {devices/lab_pin.sym} 48540 -2010 0 0 {name=p48501 lab=_48791_/X }
C {devices/lab_pin.sym} 48700 -2050 0 1 {name=p48502 lab=_48792_/Y }
C {sky130_stdcells/a21oi_4.sym} 48620 -2050 0 0 {name=X_48792_ }
C {devices/lab_pin.sym} 48560 -1920 0 0 {name=p48503 lab=_47715_/X }
C {devices/lab_pin.sym} 48560 -1880 0 0 {name=p48504 lab=_53219_/B }
C {devices/lab_pin.sym} 48680 -1900 0 1 {name=p48505 lab=_47743_/Y }
C {sky130_stdcells/nand2_4.sym} 48620 -1900 0 0 {name=X_47743_ }
C {devices/lab_pin.sym} 48580 -1770 0 0 {name=p48506 lab=_59635_/Y }
C {devices/lab_pin.sym} 48660 -1770 0 1 {name=p48507 lab=_59730_/A }
C {sky130_stdcells/buf_2.sym} 48620 -1770 0 0 {name=X_59729_ }
C {devices/lab_pin.sym} 48560 -1660 0 0 {name=p48508 lab=_78563_/A }
C {devices/lab_pin.sym} 48560 -1620 0 0 {name=p48509 lab=_78562_/X }
C {devices/lab_pin.sym} 48680 -1640 0 1 {name=p48510 lab=_82771_/D }
C {sky130_stdcells/xor2_4.sym} 48620 -1640 0 0 {name=X_78563_ }
C {devices/lab_pin.sym} 48540 -1530 0 0 {name=p48511 lab=_44948_/X }
C {devices/lab_pin.sym} 48540 -1490 0 0 {name=p48512 lab=_44952_/X }
C {devices/lab_pin.sym} 48540 -1450 0 0 {name=p48513 lab=_44954_/Y }
C {devices/lab_pin.sym} 48700 -1490 0 1 {name=p48514 lab=_44955_/Y }
C {sky130_stdcells/a21oi_4.sym} 48620 -1490 0 0 {name=X_44955_ }
C {devices/lab_pin.sym} 48580 -1350 0 0 {name=p48515 lab=clkbuf_8_73_0_CLK/A }
C {devices/lab_pin.sym} 48660 -1350 0 1 {name=p48516 lab=clkbuf_8_72_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 48620 -1350 0 0 {name=Xclkbuf_8_72_0_CLK }
C {devices/lab_pin.sym} 48540 -1250 0 0 {name=p48517 lab=_75759_/B }
C {devices/lab_pin.sym} 48540 -1210 0 0 {name=p48518 lab=_75772_/X }
C {devices/lab_pin.sym} 48540 -1170 0 0 {name=p48519 lab=_75774_/Y }
C {devices/lab_pin.sym} 48700 -1210 0 1 {name=p48520 lab=_75775_/Y }
C {sky130_stdcells/a21oi_4.sym} 48620 -1210 0 0 {name=X_75775_ }
C {devices/lab_pin.sym} 48540 -1100 0 0 {name=p48521 lab=_72978_/A }
C {devices/lab_pin.sym} 48540 -1060 0 0 {name=p48522 lab=_86201_/Q }
C {devices/lab_pin.sym} 48540 -1020 0 0 {name=p48523 lab=_72985_/X }
C {devices/lab_pin.sym} 48540 -980 0 0 {name=p48524 lab=_72986_/X }
C {devices/lab_pin.sym} 48700 -1040 0 1 {name=p48525 lab=_72987_/X }
C {sky130_stdcells/a211o_4.sym} 48620 -1040 0 0 {name=X_72987_ }
C {devices/lab_pin.sym} 48580 -890 0 0 {name=p48526 lab=clkbuf_6_2_0_CLK/X }
C {devices/lab_pin.sym} 48660 -890 0 1 {name=p48527 lab=clkbuf_8_9_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 48620 -890 0 0 {name=Xclkbuf_7_4_0_CLK }
C {devices/lab_pin.sym} 48560 -780 0 0 {name=p48528 lab=_77514_/A }
C {devices/lab_pin.sym} 48560 -740 0 0 {name=p48529 lab=_77514_/B }
C {devices/lab_pin.sym} 48680 -760 0 1 {name=p48530 lab=_82197_/D }
C {sky130_stdcells/xnor2_4.sym} 48620 -760 0 0 {name=X_77514_ }
C {devices/lab_pin.sym} 49460 -42180 0 0 {name=p48531 lab=_41356_/X }
C {devices/lab_pin.sym} 49460 -42140 0 0 {name=p48532 lab=_43886_/X }
C {devices/lab_pin.sym} 49460 -42100 0 0 {name=p48533 lab=_67644_/B }
C {devices/lab_pin.sym} 49460 -42060 0 0 {name=p48534 lab=_43887_/X }
C {devices/lab_pin.sym} 49620 -42120 0 1 {name=p48535 lab=_43906_/X }
C {sky130_stdcells/a2bb2o_4.sym} 49540 -42120 0 0 {name=X_43906_ }
C {devices/lab_pin.sym} 49480 -41990 0 0 {name=p48536 lab=_62727_/A }
C {devices/lab_pin.sym} 49480 -41950 0 0 {name=p48537 lab=_62727_/B }
C {devices/lab_pin.sym} 49480 -41910 0 0 {name=p48538 lab=_61844_/X }
C {devices/lab_pin.sym} 49600 -41950 0 1 {name=p48539 lab=_62740_/Y }
C {sky130_stdcells/nand3_4.sym} 49540 -41950 0 0 {name=X_62740_ }
C {devices/lab_pin.sym} 49500 -41810 0 0 {name=p48540 lab=_70730_/X }
C {devices/lab_pin.sym} 49580 -41810 0 1 {name=p48541 lab=_74796_/C }
C {sky130_stdcells/buf_2.sym} 49540 -41810 0 0 {name=X_74726_ }
C {devices/lab_pin.sym} 49500 -41690 0 0 {name=p48542 lab=_47674_/A }
C {devices/lab_pin.sym} 49580 -41690 0 1 {name=p48543 lab=_47675_/A }
C {sky130_stdcells/inv_2.sym} 49540 -41690 0 0 {name=X_47674_ }
C {devices/lab_pin.sym} 49480 -41580 0 0 {name=p48544 lab=_70554_/A }
C {devices/lab_pin.sym} 49480 -41540 0 0 {name=p48545 lab=_71411_/B }
C {devices/lab_pin.sym} 49600 -41560 0 1 {name=p48546 lab=_71938_/Y }
C {sky130_stdcells/nor2_4.sym} 49540 -41560 0 0 {name=X_71938_ }
C {devices/lab_pin.sym} 49500 -41430 0 0 {name=p48547 lab=_78494_/A }
C {devices/lab_pin.sym} 49580 -41430 0 1 {name=p48548 lab=_78515_/A }
C {sky130_stdcells/buf_2.sym} 49540 -41430 0 0 {name=X_78494_ }
C {devices/lab_pin.sym} 49460 -41330 0 0 {name=p48549 lab=_85217_/Q }
C {devices/lab_pin.sym} 49460 -41290 0 0 {name=p48550 lab=_44880_/X }
C {devices/lab_pin.sym} 49460 -41250 0 0 {name=p48551 lab=_44885_/X }
C {devices/lab_pin.sym} 49620 -41290 0 1 {name=p48552 lab=_44886_/Y }
C {sky130_stdcells/o21ai_4.sym} 49540 -41290 0 0 {name=X_44886_ }
C {devices/lab_pin.sym} 49480 -41180 0 0 {name=p48553 lab=_49420_/A }
C {devices/lab_pin.sym} 49480 -41140 0 0 {name=p48554 lab=_49420_/B }
C {devices/lab_pin.sym} 49480 -41100 0 0 {name=p48555 lab=_49420_/C }
C {devices/lab_pin.sym} 49480 -41060 0 0 {name=p48556 lab=_46707_/X }
C {devices/lab_pin.sym} 49600 -41120 0 1 {name=p48557 lab=_49413_/X }
C {sky130_stdcells/and4_4.sym} 49540 -41120 0 0 {name=X_49413_ }
C {devices/lab_pin.sym} 49500 -40970 0 0 {name=p48558 lab=_46624_/Y }
C {devices/lab_pin.sym} 49580 -40970 0 1 {name=p48559 lab=_46625_/X }
C {sky130_stdcells/buf_2.sym} 49540 -40970 0 0 {name=X_46625_ }
C {devices/lab_pin.sym} 49480 -40860 0 0 {name=p48560 lab=_77444_/A }
C {devices/lab_pin.sym} 49480 -40820 0 0 {name=p48561 lab=_77444_/B }
C {devices/lab_pin.sym} 49600 -40840 0 1 {name=p48562 lab=_77446_/A }
C {sky130_stdcells/nand2_4.sym} 49540 -40840 0 0 {name=X_77445_ }
C {devices/lab_pin.sym} 49460 -40740 0 0 {name=p48563 lab=_41165_/X }
C {devices/lab_pin.sym} 49460 -40700 0 0 {name=p48564 lab=_43832_/X }
C {devices/lab_pin.sym} 49460 -40660 0 0 {name=p48565 lab=_68627_/B }
C {devices/lab_pin.sym} 49460 -40620 0 0 {name=p48566 lab=_43833_/X }
C {devices/lab_pin.sym} 49620 -40680 0 1 {name=p48567 lab=_87241_/D }
C {sky130_stdcells/a2bb2o_4.sym} 49540 -40680 0 0 {name=X_43837_ }
C {devices/lab_pin.sym} 49500 -40530 0 0 {name=p48568 lab=_62671_/A }
C {devices/lab_pin.sym} 49580 -40530 0 1 {name=p48569 lab=_62673_/A }
C {sky130_stdcells/buf_2.sym} 49540 -40530 0 0 {name=X_62671_ }
C {devices/lab_pin.sym} 49480 -40420 0 0 {name=p48570 lab=_74694_/A }
C {devices/lab_pin.sym} 49480 -40380 0 0 {name=p48571 lab=_45638_/A }
C {devices/lab_pin.sym} 49600 -40400 0 1 {name=p48572 lab=_74657_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -40400 0 0 {name=X_74657_ }
C {devices/lab_pin.sym} 49480 -40290 0 0 {name=p48573 lab=_71823_/A }
C {devices/lab_pin.sym} 49480 -40250 0 0 {name=p48574 lab=_71713_/Y }
C {devices/lab_pin.sym} 49480 -40210 0 0 {name=p48575 lab=_70454_/Y }
C {devices/lab_pin.sym} 49600 -40250 0 1 {name=p48576 lab=_71870_/A }
C {sky130_stdcells/nor3_4.sym} 49540 -40250 0 0 {name=X_71869_ }
C {devices/lab_pin.sym} 49480 -40120 0 0 {name=p48577 lab=_63573_/A }
C {devices/lab_pin.sym} 49480 -40080 0 0 {name=p48578 lab=_61226_/X }
C {devices/lab_pin.sym} 49600 -40100 0 1 {name=p48579 lab=_64410_/Y }
C {sky130_stdcells/nor2_4.sym} 49540 -40100 0 0 {name=X_64410_ }
C {devices/lab_pin.sym} 49480 -39980 0 0 {name=p48580 lab=_49352_/A }
C {devices/lab_pin.sym} 49480 -39940 0 0 {name=p48581 lab=_51378_/B }
C {devices/lab_pin.sym} 49600 -39960 0 1 {name=p48582 lab=_49344_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -39960 0 0 {name=X_49344_ }
C {devices/lab_pin.sym} 49460 -39860 0 0 {name=p48583 lab=_73605_/X }
C {devices/lab_pin.sym} 49460 -39820 0 0 {name=p48584 lab=_86239_/Q }
C {devices/lab_pin.sym} 49460 -39780 0 0 {name=p48585 lab=_44194_/X }
C {devices/lab_pin.sym} 49460 -39740 0 0 {name=p48586 lab=_73607_/X }
C {devices/lab_pin.sym} 49620 -39800 0 1 {name=p48587 lab=_73608_/X }
C {sky130_stdcells/a211o_4.sym} 49540 -39800 0 0 {name=X_73608_ }
C {devices/lab_pin.sym} 49500 -39650 0 0 {name=p48588 lab=_61621_/X }
C {devices/lab_pin.sym} 49580 -39650 0 1 {name=p48589 lab=_61622_/Y }
C {sky130_stdcells/inv_2.sym} 49540 -39650 0 0 {name=X_61622_ }
C {devices/lab_pin.sym} 49500 -39530 0 0 {name=p48590 lab=clkbuf_8_87_0_CLK/A }
C {devices/lab_pin.sym} 49580 -39530 0 1 {name=p48591 lab=clkbuf_8_87_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 49540 -39530 0 0 {name=Xclkbuf_8_87_0_CLK }
C {devices/lab_pin.sym} 49480 -39420 0 0 {name=p48592 lab=_46547_/A }
C {devices/lab_pin.sym} 49480 -39380 0 0 {name=p48593 lab=_50862_/B }
C {devices/lab_pin.sym} 49600 -39400 0 1 {name=p48594 lab=_46556_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -39400 0 0 {name=X_46556_ }
C {devices/lab_pin.sym} 49460 -39290 0 0 {name=p48595 lab=_65385_/X }
C {devices/lab_pin.sym} 49460 -39250 0 0 {name=p48596 lab=_65388_/X }
C {devices/lab_pin.sym} 49460 -39210 0 0 {name=p48597 lab=_65389_/X }
C {devices/lab_pin.sym} 49620 -39250 0 1 {name=p48598 lab=_65390_/X }
C {sky130_stdcells/a21o_4.sym} 49540 -39250 0 0 {name=X_65390_ }
C {devices/lab_pin.sym} 49480 -39120 0 0 {name=p48599 lab=_77376_/A }
C {devices/lab_pin.sym} 49480 -39080 0 0 {name=p48600 lab=_77376_/B }
C {devices/lab_pin.sym} 49600 -39100 0 1 {name=p48601 lab=_77376_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -39100 0 0 {name=X_77376_ }
C {devices/lab_pin.sym} 49500 -38970 0 0 {name=p48602 lab=_43767_/Y }
C {devices/lab_pin.sym} 49580 -38970 0 1 {name=p48603 lab=_43768_/Y }
C {sky130_stdcells/inv_2.sym} 49540 -38970 0 0 {name=X_43768_ }
C {devices/lab_pin.sym} 49460 -38870 0 0 {name=p48604 lab=_56094_/X }
C {devices/lab_pin.sym} 49460 -38830 0 0 {name=p48605 lab=_74625_/A }
C {devices/lab_pin.sym} 49460 -38790 0 0 {name=p48606 lab=_74587_/Y }
C {devices/lab_pin.sym} 49620 -38830 0 1 {name=p48607 lab=_83025_/D }
C {sky130_stdcells/a21boi_4.sym} 49540 -38830 0 0 {name=X_74588_ }
C {devices/lab_pin.sym} 49500 -38690 0 0 {name=p48608 lab=_79115_/A }
C {devices/lab_pin.sym} 49580 -38690 0 1 {name=p48609 lab=_79115_/Y }
C {sky130_stdcells/inv_2.sym} 49540 -38690 0 0 {name=X_79115_ }
C {devices/lab_pin.sym} 49500 -38570 0 0 {name=p48610 lab=_45705_/A }
C {devices/lab_pin.sym} 49580 -38570 0 1 {name=p48611 lab=_45507_/X }
C {sky130_stdcells/buf_2.sym} 49540 -38570 0 0 {name=X_45507_ }
C {devices/lab_pin.sym} 49480 -38460 0 0 {name=p48612 lab=_59403_/A }
C {devices/lab_pin.sym} 49480 -38420 0 0 {name=p48613 lab=_64316_/B }
C {devices/lab_pin.sym} 49600 -38440 0 1 {name=p48614 lab=_64341_/Y }
C {sky130_stdcells/nor2_4.sym} 49540 -38440 0 0 {name=X_64341_ }
C {devices/lab_pin.sym} 49480 -38320 0 0 {name=p48615 lab=_76328_/A }
C {devices/lab_pin.sym} 49480 -38280 0 0 {name=p48616 lab=_81518_/D }
C {devices/lab_pin.sym} 49600 -38300 0 1 {name=p48617 lab=_76327_/Y }
C {sky130_stdcells/nor2_4.sym} 49540 -38300 0 0 {name=X_76327_ }
C {devices/lab_pin.sym} 49460 -38200 0 0 {name=p48618 lab=_41169_/X }
C {devices/lab_pin.sym} 49460 -38160 0 0 {name=p48619 lab=_42717_/X }
C {devices/lab_pin.sym} 49460 -38120 0 0 {name=p48620 lab=_87752_/Q }
C {devices/lab_pin.sym} 49460 -38080 0 0 {name=p48621 lab=_42718_/X }
C {devices/lab_pin.sym} 49620 -38140 0 1 {name=p48622 lab=_87752_/D }
C {sky130_stdcells/a2bb2o_4.sym} 49540 -38140 0 0 {name=X_42719_ }
C {devices/lab_pin.sym} 49480 -38000 0 0 {name=p48623 lab=_49261_/A }
C {devices/lab_pin.sym} 49480 -37960 0 0 {name=p48624 lab=_46412_/B }
C {devices/lab_pin.sym} 49600 -37980 0 1 {name=p48625 lab=_49275_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -37980 0 0 {name=X_49275_ }
C {devices/lab_pin.sym} 49500 -37850 0 0 {name=p48626 lab=_61553_/A }
C {devices/lab_pin.sym} 49580 -37850 0 1 {name=p48627 lab=_61553_/Y }
C {sky130_stdcells/inv_2.sym} 49540 -37850 0 0 {name=X_61553_ }
C {devices/lab_pin.sym} 49460 -37750 0 0 {name=p48628 lab=_73536_/X }
C {devices/lab_pin.sym} 49460 -37710 0 0 {name=p48629 lab=_73538_/X }
C {devices/lab_pin.sym} 49460 -37670 0 0 {name=p48630 lab=_72949_/X }
C {devices/lab_pin.sym} 49620 -37710 0 1 {name=p48631 lab=_73542_/A }
C {sky130_stdcells/a21o_4.sym} 49540 -37710 0 0 {name=X_73539_ }
C {devices/lab_pin.sym} 49480 -37590 0 0 {name=p48632 lab=_52524_/A }
C {devices/lab_pin.sym} 49480 -37550 0 0 {name=p48633 lab=_46487_/B }
C {devices/lab_pin.sym} 49480 -37510 0 0 {name=p48634 lab=_46472_/C }
C {devices/lab_pin.sym} 49600 -37550 0 1 {name=p48635 lab=_46487_/X }
C {sky130_stdcells/and3_4.sym} 49540 -37550 0 0 {name=X_46487_ }
C {devices/lab_pin.sym} 49500 -37410 0 0 {name=p48636 lab=_87303_/Q }
C {devices/lab_pin.sym} 49580 -37410 0 1 {name=p48637 lab=_69722_/B }
C {sky130_stdcells/inv_2.sym} 49540 -37410 0 0 {name=X_43699_ }
C {devices/lab_pin.sym} 49500 -37290 0 0 {name=p48638 lab=_48226_/A }
C {devices/lab_pin.sym} 49580 -37290 0 1 {name=p48639 lab=_48226_/X }
C {sky130_stdcells/buf_2.sym} 49540 -37290 0 0 {name=X_48226_ }
C {devices/lab_pin.sym} 49500 -37170 0 0 {name=p48640 lab=_60503_/X }
C {devices/lab_pin.sym} 49580 -37170 0 1 {name=p48641 lab=_60595_/C }
C {sky130_stdcells/buf_2.sym} 49540 -37170 0 0 {name=X_60504_ }
C {devices/lab_pin.sym} 49460 -37080 0 0 {name=p48642 lab=_87359_/Q }
C {devices/lab_pin.sym} 49460 -37040 0 0 {name=p48643 lab=_67035_/X }
C {devices/lab_pin.sym} 49460 -37000 0 0 {name=p48644 lab=_66984_/X }
C {devices/lab_pin.sym} 49460 -36960 0 0 {name=p48645 lab=_67059_/X }
C {devices/lab_pin.sym} 49620 -37020 0 1 {name=p48646 lab=_67060_/X }
C {sky130_stdcells/a211o_4.sym} 49540 -37020 0 0 {name=X_67060_ }
C {devices/lab_pin.sym} 49500 -36870 0 0 {name=p48647 lab=_79045_/X }
C {devices/lab_pin.sym} 49580 -36870 0 1 {name=p48648 lab=_79047_/B }
C {sky130_stdcells/buf_2.sym} 49540 -36870 0 0 {name=X_79046_ }
C {devices/lab_pin.sym} 49500 -36750 0 0 {name=p48649 lab=_85086_/Q }
C {devices/lab_pin.sym} 49580 -36750 0 1 {name=p48650 lab=_45438_/Y }
C {sky130_stdcells/inv_2.sym} 49540 -36750 0 0 {name=X_45438_ }
C {devices/lab_pin.sym} 49480 -36640 0 0 {name=p48651 lab=_64272_/A }
C {devices/lab_pin.sym} 49480 -36600 0 0 {name=p48652 lab=_64301_/B }
C {devices/lab_pin.sym} 49600 -36620 0 1 {name=p48653 lab=_64272_/Y }
C {sky130_stdcells/nor2_4.sym} 49540 -36620 0 0 {name=X_64272_ }
C {devices/lab_pin.sym} 49480 -36500 0 0 {name=p48654 lab=_76268_/D }
C {devices/lab_pin.sym} 49480 -36460 0 0 {name=p48655 lab=_76257_/Y }
C {devices/lab_pin.sym} 49600 -36480 0 1 {name=p48656 lab=_76258_/Y }
C {sky130_stdcells/xnor2_4.sym} 49540 -36480 0 0 {name=X_76258_ }
C {devices/lab_pin.sym} 49480 -36380 0 0 {name=p48657 lab=_59407_/A }
C {devices/lab_pin.sym} 49480 -36340 0 0 {name=p48658 lab=_61484_/B }
C {devices/lab_pin.sym} 49480 -36300 0 0 {name=p48659 lab=_61484_/C }
C {devices/lab_pin.sym} 49480 -36260 0 0 {name=p48660 lab=_61452_/D }
C {devices/lab_pin.sym} 49600 -36320 0 1 {name=p48661 lab=_61485_/A }
C {sky130_stdcells/nand4_4.sym} 49540 -36320 0 0 {name=X_61484_ }
C {devices/lab_pin.sym} 49500 -36170 0 0 {name=p48662 lab=clkbuf_7_5_0_CLK/X }
C {devices/lab_pin.sym} 49580 -36170 0 1 {name=p48663 lab=clkbuf_8_10_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 49540 -36170 0 0 {name=Xclkbuf_8_10_0_CLK }
C {devices/lab_pin.sym} 49500 -36050 0 0 {name=p48664 lab=_64611_/A }
C {devices/lab_pin.sym} 49580 -36050 0 1 {name=p48665 lab=_66011_/X }
C {sky130_stdcells/buf_2.sym} 49540 -36050 0 0 {name=X_66011_ }
C {devices/lab_pin.sym} 49460 -35950 0 0 {name=p48666 lab=_75196_/Y }
C {devices/lab_pin.sym} 49460 -35910 0 0 {name=p48667 lab=_75189_/X }
C {devices/lab_pin.sym} 49460 -35870 0 0 {name=p48668 lab=_75190_/Y }
C {devices/lab_pin.sym} 49620 -35910 0 1 {name=p48669 lab=_75210_/B }
C {sky130_stdcells/a21boi_4.sym} 49540 -35910 0 0 {name=X_75209_ }
C {devices/lab_pin.sym} 49460 -35810 0 0 {name=p48670 lab=_58385_/Y }
C {devices/lab_pin.sym} 49460 -35770 0 0 {name=p48671 lab=_63190_/X }
C {devices/lab_pin.sym} 49460 -35730 0 0 {name=p48672 lab=_63175_/X }
C {devices/lab_pin.sym} 49460 -35690 0 0 {name=p48673 lab=_58261_/Y }
C {devices/lab_pin.sym} 49460 -35650 0 0 {name=p48674 lab=_63176_/X }
C {devices/lab_pin.sym} 49620 -35730 0 1 {name=p48675 lab=_63223_/Y }
C {sky130_stdcells/o32ai_4.sym} 49540 -35730 0 0 {name=X_63223_ }
C {devices/lab_pin.sym} 49480 -35580 0 0 {name=p48676 lab=_47943_/A }
C {devices/lab_pin.sym} 49480 -35540 0 0 {name=p48677 lab=_48157_/B }
C {devices/lab_pin.sym} 49600 -35560 0 1 {name=p48678 lab=_48157_/X }
C {sky130_stdcells/or2_4.sym} 49540 -35560 0 0 {name=X_48157_ }
C {devices/lab_pin.sym} 49480 -35450 0 0 {name=p48679 lab=_60435_/A }
C {devices/lab_pin.sym} 49480 -35410 0 0 {name=p48680 lab=_72577_/B }
C {devices/lab_pin.sym} 49480 -35370 0 0 {name=p48681 lab=_60435_/C }
C {devices/lab_pin.sym} 49600 -35410 0 1 {name=p48682 lab=_60435_/Y }
C {sky130_stdcells/nand3_4.sym} 49540 -35410 0 0 {name=X_60435_ }
C {devices/lab_pin.sym} 49500 -35270 0 0 {name=p48683 lab=_45369_/A }
C {devices/lab_pin.sym} 49580 -35270 0 1 {name=p48684 lab=_45452_/A }
C {sky130_stdcells/buf_2.sym} 49540 -35270 0 0 {name=X_45369_ }
C {devices/lab_pin.sym} 49480 -35170 0 0 {name=p48685 lab=_76189_/A }
C {devices/lab_pin.sym} 49480 -35130 0 0 {name=p48686 lab=_76189_/B }
C {devices/lab_pin.sym} 49480 -35090 0 0 {name=p48687 lab=_76187_/Y }
C {devices/lab_pin.sym} 49600 -35130 0 1 {name=p48688 lab=_76193_/C }
C {sky130_stdcells/nand3_4.sym} 49540 -35130 0 0 {name=X_76189_ }
C {devices/lab_pin.sym} 49500 -34990 0 0 {name=p48689 lab=_53373_/B }
C {devices/lab_pin.sym} 49580 -34990 0 1 {name=p48690 lab=_52859_/B }
C {sky130_stdcells/buf_2.sym} 49540 -34990 0 0 {name=X_47108_ }
C {devices/lab_pin.sym} 49500 -34870 0 0 {name=p48691 lab=_60452_/X }
C {devices/lab_pin.sym} 49580 -34870 0 1 {name=p48692 lab=_63154_/X }
C {sky130_stdcells/buf_2.sym} 49540 -34870 0 0 {name=X_63154_ }
C {devices/lab_pin.sym} 49460 -34790 0 0 {name=p48693 lab=_60359_/X }
C {devices/lab_pin.sym} 49460 -34750 0 0 {name=p48694 lab=_60363_/Y }
C {devices/lab_pin.sym} 49460 -34710 0 0 {name=p48695 lab=_59892_/Y }
C {devices/lab_pin.sym} 49460 -34670 0 0 {name=p48696 lab=_60285_/A }
C {devices/lab_pin.sym} 49460 -34640 0 0 {name=p48697 lab=_60365_/Y }
C {devices/lab_pin.sym} 49620 -34710 0 1 {name=p48698 lab=_60366_/Y }
C {sky130_stdcells/a41oi_4.sym} 49540 -34710 0 0 {name=X_60366_ }
C {devices/lab_pin.sym} 49480 -34560 0 0 {name=p48699 lab=_48138_/A }
C {devices/lab_pin.sym} 49480 -34520 0 0 {name=p48700 lab=_48088_/B }
C {devices/lab_pin.sym} 49600 -34540 0 1 {name=p48701 lab=_48088_/X }
C {sky130_stdcells/and2_4.sym} 49540 -34540 0 0 {name=X_48088_ }
C {devices/lab_pin.sym} 49500 -34410 0 0 {name=p48702 lab=_59668_/B }
C {devices/lab_pin.sym} 49580 -34410 0 1 {name=p48703 lab=_62105_/X }
C {sky130_stdcells/buf_2.sym} 49540 -34410 0 0 {name=X_62105_ }
C {devices/lab_pin.sym} 49480 -34320 0 0 {name=p48704 lab=_47029_/A }
C {devices/lab_pin.sym} 49480 -34280 0 0 {name=p48705 lab=_47039_/B }
C {devices/lab_pin.sym} 49480 -34240 0 0 {name=p48706 lab=_47029_/C }
C {devices/lab_pin.sym} 49480 -34200 0 0 {name=p48707 lab=_52818_/D }
C {devices/lab_pin.sym} 49600 -34260 0 1 {name=p48708 lab=_47039_/X }
C {sky130_stdcells/and4_4.sym} 49540 -34260 0 0 {name=X_47039_ }
C {devices/lab_pin.sym} 49500 -34110 0 0 {name=p48709 lab=clkbuf_8_25_0_CLK/A }
C {devices/lab_pin.sym} 49580 -34110 0 1 {name=p48710 lab=clkbuf_9_51_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 49540 -34110 0 0 {name=Xclkbuf_8_25_0_CLK }
C {devices/lab_pin.sym} 49480 -34000 0 0 {name=p48711 lab=_68028_/A }
C {devices/lab_pin.sym} 49480 -33960 0 0 {name=p48712 lab=_87641_/Q }
C {devices/lab_pin.sym} 49600 -33980 0 1 {name=p48713 lab=_67962_/X }
C {sky130_stdcells/and2_4.sym} 49540 -33980 0 0 {name=X_67962_ }
C {devices/lab_pin.sym} 49460 -33870 0 0 {name=p48714 lab=_79932_/A }
C {devices/lab_pin.sym} 49460 -33830 0 0 {name=p48715 lab=_79931_/B }
C {devices/lab_pin.sym} 49460 -33790 0 0 {name=p48716 lab=_79928_/Y }
C {devices/lab_pin.sym} 49620 -33830 0 1 {name=p48717 lab=_79948_/Y }
C {sky130_stdcells/a21oi_4.sym} 49540 -33830 0 0 {name=X_79948_ }
C {devices/lab_pin.sym} 49480 -33720 0 0 {name=p48718 lab=_63038_/A }
C {devices/lab_pin.sym} 49480 -33680 0 0 {name=p48719 lab=_64294_/B }
C {devices/lab_pin.sym} 49480 -33640 0 0 {name=p48720 lab=_63085_/C }
C {devices/lab_pin.sym} 49480 -33600 0 0 {name=p48721 lab=_63085_/D }
C {devices/lab_pin.sym} 49600 -33660 0 1 {name=p48722 lab=_63085_/X }
C {sky130_stdcells/and4_4.sym} 49540 -33660 0 0 {name=X_63085_ }
C {devices/lab_pin.sym} 49480 -33540 0 0 {name=p48723 lab=_57686_/A }
C {devices/lab_pin.sym} 49480 -33500 0 0 {name=p48724 lab=_59741_/A }
C {devices/lab_pin.sym} 49480 -33460 0 0 {name=p48725 lab=_59705_/X }
C {devices/lab_pin.sym} 49480 -33420 0 0 {name=p48726 lab=_62640_/C }
C {devices/lab_pin.sym} 49600 -33480 0 1 {name=p48727 lab=_60298_/C }
C {sky130_stdcells/nand4_4.sym} 49540 -33480 0 0 {name=X_60297_ }
C {devices/lab_pin.sym} 49460 -33360 0 0 {name=p48728 lab=_73036_/A }
C {devices/lab_pin.sym} 49460 -33320 0 0 {name=p48729 lab=_68377_/X }
C {devices/lab_pin.sym} 49460 -33280 0 0 {name=p48730 lab=_66574_/X }
C {devices/lab_pin.sym} 49460 -33240 0 0 {name=p48731 lab=_69700_/Y }
C {devices/lab_pin.sym} 49620 -33300 0 1 {name=p48732 lab=_69701_/X }
C {sky130_stdcells/a211o_4.sym} 49540 -33300 0 0 {name=X_69701_ }
C {devices/lab_pin.sym} 49480 -33180 0 0 {name=p48733 lab=_50050_/A }
C {devices/lab_pin.sym} 49480 -33140 0 0 {name=p48734 lab=_50045_/X }
C {devices/lab_pin.sym} 49480 -33100 0 0 {name=p48735 lab=_51750_/C }
C {devices/lab_pin.sym} 49480 -33060 0 0 {name=p48736 lab=_53261_/D }
C {devices/lab_pin.sym} 49600 -33120 0 1 {name=p48737 lab=_50050_/X }
C {sky130_stdcells/and4_4.sym} 49540 -33120 0 0 {name=X_50050_ }
C {devices/lab_pin.sym} 49460 -33000 0 0 {name=p48738 lab=_87877_/Q }
C {devices/lab_pin.sym} 49460 -32960 0 0 {name=p48739 lab=_66816_/X }
C {devices/lab_pin.sym} 49460 -32920 0 0 {name=p48740 lab=_66911_/X }
C {devices/lab_pin.sym} 49460 -32880 0 0 {name=p48741 lab=_66912_/X }
C {devices/lab_pin.sym} 49620 -32940 0 1 {name=p48742 lab=_66913_/X }
C {sky130_stdcells/a211o_4.sym} 49540 -32940 0 0 {name=X_66913_ }
C {devices/lab_pin.sym} 49500 -32790 0 0 {name=p48743 lab=_59721_/A }
C {devices/lab_pin.sym} 49580 -32790 0 1 {name=p48744 lab=_62094_/B }
C {sky130_stdcells/buf_2.sym} 49540 -32790 0 0 {name=X_62036_ }
C {devices/lab_pin.sym} 49460 -32690 0 0 {name=p48745 lab=_67890_/X }
C {devices/lab_pin.sym} 49460 -32650 0 0 {name=p48746 lab=_67892_/X }
C {devices/lab_pin.sym} 49460 -32610 0 0 {name=p48747 lab=_67799_/X }
C {devices/lab_pin.sym} 49620 -32650 0 1 {name=p48748 lab=_67893_/X }
C {sky130_stdcells/a21o_4.sym} 49540 -32650 0 0 {name=X_67893_ }
C {devices/lab_pin.sym} 49480 -32520 0 0 {name=p48749 lab=_79874_/X }
C {devices/lab_pin.sym} 49480 -32480 0 0 {name=p48750 lab=_79878_/Y }
C {devices/lab_pin.sym} 49600 -32500 0 1 {name=p48751 lab=_79879_/X }
C {sky130_stdcells/xor2_4.sym} 49540 -32500 0 0 {name=X_79879_ }
C {devices/lab_pin.sym} 49450 -32370 0 0 {name=p48752 lab=_82005_/CLK }
C {devices/lab_pin.sym} 49450 -32350 0 0 {name=p48753 lab=_81910_/D }
C {devices/lab_pin.sym} 49630 -32370 0 1 {name=p48754 lab=_81910_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -32360 0 0 {name=X_81910_ }
C {devices/lab_pin.sym} 49500 -32230 0 0 {name=p48755 lab=_69696_/A }
C {devices/lab_pin.sym} 49580 -32230 0 1 {name=p48756 lab=_69632_/X }
C {sky130_stdcells/buf_2.sym} 49540 -32230 0 0 {name=X_69632_ }
C {devices/lab_pin.sym} 49460 -32130 0 0 {name=p48757 lab=_66839_/X }
C {devices/lab_pin.sym} 49460 -32090 0 0 {name=p48758 lab=_66842_/X }
C {devices/lab_pin.sym} 49460 -32050 0 0 {name=p48759 lab=_66843_/X }
C {devices/lab_pin.sym} 49620 -32090 0 1 {name=p48760 lab=_66844_/X }
C {sky130_stdcells/a21o_4.sym} 49540 -32090 0 0 {name=X_66844_ }
C {devices/lab_pin.sym} 49450 -31950 0 0 {name=p48761 lab=_83987_/CLK }
C {devices/lab_pin.sym} 49450 -31930 0 0 {name=p48762 lab=_78139_/B }
C {devices/lab_pin.sym} 49630 -31950 0 1 {name=p48763 lab=_41747_/A }
C {sky130_stdcells/dfxtp_4.sym} 49540 -31940 0 0 {name=X_82890_ }
C {devices/lab_pin.sym} 49450 -31810 0 0 {name=p48764 lab=_81094_/CLK }
C {devices/lab_pin.sym} 49450 -31790 0 0 {name=p48765 lab=_81841_/D }
C {devices/lab_pin.sym} 49630 -31810 0 1 {name=p48766 lab=_77444_/A }
C {sky130_stdcells/dfxtp_4.sym} 49540 -31800 0 0 {name=X_81841_ }
C {devices/lab_pin.sym} 49460 -31690 0 0 {name=p48767 lab=_83914_/Q }
C {devices/lab_pin.sym} 49460 -31650 0 0 {name=p48768 lab=_69504_/X }
C {devices/lab_pin.sym} 49460 -31610 0 0 {name=p48769 lab=_69562_/X }
C {devices/lab_pin.sym} 49620 -31650 0 1 {name=p48770 lab=_83914_/D }
C {sky130_stdcells/a21bo_4.sym} 49540 -31650 0 0 {name=X_69563_ }
C {devices/lab_pin.sym} 49460 -31540 0 0 {name=p48771 lab=_87371_/Q }
C {devices/lab_pin.sym} 49460 -31500 0 0 {name=p48772 lab=_66678_/X }
C {devices/lab_pin.sym} 49460 -31460 0 0 {name=p48773 lab=_66747_/X }
C {devices/lab_pin.sym} 49460 -31420 0 0 {name=p48774 lab=_66774_/X }
C {devices/lab_pin.sym} 49620 -31480 0 1 {name=p48775 lab=_66775_/X }
C {sky130_stdcells/a211o_4.sym} 49540 -31480 0 0 {name=X_66775_ }
C {devices/lab_pin.sym} 49480 -31360 0 0 {name=p48776 lab=_61969_/X }
C {devices/lab_pin.sym} 49480 -31320 0 0 {name=p48777 lab=_63955_/X }
C {devices/lab_pin.sym} 49480 -31280 0 0 {name=p48778 lab=_64050_/C }
C {devices/lab_pin.sym} 49480 -31240 0 0 {name=p48779 lab=_64033_/D }
C {devices/lab_pin.sym} 49600 -31300 0 1 {name=p48780 lab=_63987_/Y }
C {sky130_stdcells/nand4_4.sym} 49540 -31300 0 0 {name=X_63987_ }
C {devices/lab_pin.sym} 49460 -31180 0 0 {name=p48781 lab=_68376_/X }
C {devices/lab_pin.sym} 49460 -31140 0 0 {name=p48782 lab=_66524_/B }
C {devices/lab_pin.sym} 49460 -31100 0 0 {name=p48783 lab=_68500_/Y }
C {devices/lab_pin.sym} 49460 -31060 0 0 {name=p48784 lab=_68513_/Y }
C {devices/lab_pin.sym} 49620 -31120 0 1 {name=p48785 lab=_68514_/X }
C {sky130_stdcells/a211o_4.sym} 49540 -31120 0 0 {name=X_68514_ }
C {devices/lab_pin.sym} 49460 -30990 0 0 {name=p48786 lab=_53737_/Y }
C {devices/lab_pin.sym} 49460 -30950 0 0 {name=p48787 lab=_53715_/X }
C {devices/lab_pin.sym} 49460 -30910 0 0 {name=p48788 lab=_53739_/X }
C {devices/lab_pin.sym} 49620 -30950 0 1 {name=p48789 lab=_85578_/D }
C {sky130_stdcells/a21oi_4.sym} 49540 -30950 0 0 {name=X_53740_ }
C {devices/lab_pin.sym} 49460 -30830 0 0 {name=p48790 lab=_65516_/X }
C {devices/lab_pin.sym} 49460 -30790 0 0 {name=p48791 lab=_65102_/Y }
C {devices/lab_pin.sym} 49460 -30750 0 0 {name=p48792 lab=_65725_/Y }
C {devices/lab_pin.sym} 49620 -30790 0 1 {name=p48793 lab=_65726_/Y }
C {sky130_stdcells/o21ai_4.sym} 49540 -30790 0 0 {name=X_65726_ }
C {devices/lab_pin.sym} 49450 -30650 0 0 {name=p48794 lab=_84562_/CLK }
C {devices/lab_pin.sym} 49450 -30630 0 0 {name=p48795 lab=_84560_/D }
C {devices/lab_pin.sym} 49630 -30650 0 1 {name=p48796 lab=_84560_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -30640 0 0 {name=X_84560_ }
C {devices/lab_pin.sym} 49500 -30510 0 0 {name=p48797 lab=_50952_/A }
C {devices/lab_pin.sym} 49580 -30510 0 1 {name=p48798 lab=_50963_/C }
C {sky130_stdcells/buf_2.sym} 49540 -30510 0 0 {name=X_50952_ }
C {devices/lab_pin.sym} 49480 -30420 0 0 {name=p48799 lab=_61629_/B }
C {devices/lab_pin.sym} 49480 -30380 0 0 {name=p48800 lab=_62936_/X }
C {devices/lab_pin.sym} 49480 -30340 0 0 {name=p48801 lab=_62982_/C }
C {devices/lab_pin.sym} 49480 -30300 0 0 {name=p48802 lab=_62908_/X }
C {devices/lab_pin.sym} 49600 -30360 0 1 {name=p48803 lab=_62938_/Y }
C {sky130_stdcells/nand4_4.sym} 49540 -30360 0 0 {name=X_62938_ }
C {devices/lab_pin.sym} 49480 -30220 0 0 {name=p48804 lab=_69454_/A }
C {devices/lab_pin.sym} 49480 -30180 0 0 {name=p48805 lab=_69494_/B }
C {devices/lab_pin.sym} 49600 -30200 0 1 {name=p48806 lab=_69494_/X }
C {sky130_stdcells/and2_4.sym} 49540 -30200 0 0 {name=X_69494_ }
C {devices/lab_pin.sym} 49450 -30070 0 0 {name=p48807 lab=_82368_/CLK }
C {devices/lab_pin.sym} 49450 -30050 0 0 {name=p48808 lab=_81772_/D }
C {devices/lab_pin.sym} 49630 -30070 0 1 {name=p48809 lab=_81772_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -30060 0 0 {name=X_81772_ }
C {devices/lab_pin.sym} 49450 -29930 0 0 {name=p48810 lab=_83507_/CLK }
C {devices/lab_pin.sym} 49450 -29910 0 0 {name=p48811 lab=_83511_/D }
C {devices/lab_pin.sym} 49630 -29930 0 1 {name=p48812 lab=_83511_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -29920 0 0 {name=X_83511_ }
C {devices/lab_pin.sym} 49450 -29790 0 0 {name=p48813 lab=_80676_/CLK }
C {devices/lab_pin.sym} 49450 -29770 0 0 {name=p48814 lab=_80723_/D }
C {devices/lab_pin.sym} 49630 -29790 0 1 {name=p48815 lab=_80691_/D }
C {sky130_stdcells/dfxtp_4.sym} 49540 -29780 0 0 {name=X_80723_ }
C {devices/lab_pin.sym} 49460 -29680 0 0 {name=p48816 lab=_44675_/A }
C {devices/lab_pin.sym} 49460 -29640 0 0 {name=p48817 lab=_68023_/X }
C {devices/lab_pin.sym} 49460 -29600 0 0 {name=p48818 lab=_68024_/X }
C {devices/lab_pin.sym} 49460 -29560 0 0 {name=p48819 lab=_68444_/X }
C {devices/lab_pin.sym} 49620 -29620 0 1 {name=p48820 lab=_68445_/X }
C {sky130_stdcells/a211o_4.sym} 49540 -29620 0 0 {name=X_68445_ }
C {devices/lab_pin.sym} 49480 -29480 0 0 {name=p48821 lab=_65735_/A }
C {devices/lab_pin.sym} 49480 -29440 0 0 {name=p48822 lab=_86482_/Q }
C {devices/lab_pin.sym} 49600 -29460 0 1 {name=p48823 lab=_65657_/X }
C {sky130_stdcells/and2_4.sym} 49540 -29460 0 0 {name=X_65657_ }
C {devices/lab_pin.sym} 49500 -29330 0 0 {name=p48824 lab=_53671_/A }
C {devices/lab_pin.sym} 49580 -29330 0 1 {name=p48825 lab=_53692_/C }
C {sky130_stdcells/buf_2.sym} 49540 -29330 0 0 {name=X_53671_ }
C {devices/lab_pin.sym} 49450 -29210 0 0 {name=p48826 lab=_84241_/CLK }
C {devices/lab_pin.sym} 49450 -29190 0 0 {name=p48827 lab=_61273_/X }
C {devices/lab_pin.sym} 49630 -29210 0 1 {name=p48828 lab=_84491_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -29200 0 0 {name=X_84491_ }
C {devices/lab_pin.sym} 49500 -29070 0 0 {name=p48829 lab=_50728_/A }
C {devices/lab_pin.sym} 49580 -29070 0 1 {name=p48830 lab=_50906_/A }
C {sky130_stdcells/buf_2.sym} 49540 -29070 0 0 {name=X_50883_ }
C {devices/lab_pin.sym} 49480 -28970 0 0 {name=p48831 lab=_62869_/A }
C {devices/lab_pin.sym} 49480 -28930 0 0 {name=p48832 lab=_62935_/B }
C {devices/lab_pin.sym} 49480 -28890 0 0 {name=p48833 lab=_63585_/B }
C {devices/lab_pin.sym} 49600 -28930 0 1 {name=p48834 lab=_62869_/Y }
C {sky130_stdcells/nand3_4.sym} 49540 -28930 0 0 {name=X_62869_ }
C {devices/lab_pin.sym} 49480 -28800 0 0 {name=p48835 lab=_55399_/X }
C {devices/lab_pin.sym} 49480 -28760 0 0 {name=p48836 lab=_55409_/Y }
C {devices/lab_pin.sym} 49600 -28780 0 1 {name=p48837 lab=_55410_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -28780 0 0 {name=X_55410_ }
C {devices/lab_pin.sym} 49450 -28650 0 0 {name=p48838 lab=_86235_/CLK }
C {devices/lab_pin.sym} 49450 -28630 0 0 {name=p48839 lab=_50292_/Y }
C {devices/lab_pin.sym} 49630 -28650 0 1 {name=p48840 lab=_86230_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -28640 0 0 {name=X_86230_ }
C {devices/lab_pin.sym} 49480 -28540 0 0 {name=p48841 lab=_52643_/A }
C {devices/lab_pin.sym} 49480 -28500 0 0 {name=p48842 lab=_52605_/X }
C {devices/lab_pin.sym} 49480 -28460 0 0 {name=p48843 lab=_52622_/C }
C {devices/lab_pin.sym} 49480 -28420 0 0 {name=p48844 lab=_52622_/D }
C {devices/lab_pin.sym} 49600 -28480 0 1 {name=p48845 lab=_52622_/X }
C {sky130_stdcells/and4_4.sym} 49540 -28480 0 0 {name=X_52622_ }
C {devices/lab_pin.sym} 49500 -28330 0 0 {name=p48846 lab=_64608_/A }
C {devices/lab_pin.sym} 49580 -28330 0 1 {name=p48847 lab=_66195_/B }
C {sky130_stdcells/buf_2.sym} 49540 -28330 0 0 {name=X_64608_ }
C {devices/lab_pin.sym} 49450 -28210 0 0 {name=p48848 lab=_83763_/CLK }
C {devices/lab_pin.sym} 49450 -28190 0 0 {name=p48849 lab=_71601_/X }
C {devices/lab_pin.sym} 49630 -28210 0 1 {name=p48850 lab=_83442_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -28200 0 0 {name=X_83442_ }
C {devices/lab_pin.sym} 49480 -28090 0 0 {name=p48851 lab=_56383_/X }
C {devices/lab_pin.sym} 49480 -28050 0 0 {name=p48852 lab=_56386_/B }
C {devices/lab_pin.sym} 49480 -28010 0 0 {name=p48853 lab=_56390_/C }
C {devices/lab_pin.sym} 49600 -28050 0 1 {name=p48854 lab=_56390_/Y }
C {sky130_stdcells/nand3_4.sym} 49540 -28050 0 0 {name=X_56390_ }
C {devices/lab_pin.sym} 49450 -27910 0 0 {name=p48855 lab=_86772_/CLK }
C {devices/lab_pin.sym} 49450 -27890 0 0 {name=p48856 lab=_80654_/D }
C {devices/lab_pin.sym} 49630 -27910 0 1 {name=p48857 lab=_74846_/B }
C {sky130_stdcells/dfxtp_4.sym} 49540 -27900 0 0 {name=X_80654_ }
C {devices/lab_pin.sym} 49500 -27770 0 0 {name=p48858 lab=_68376_/A }
C {devices/lab_pin.sym} 49580 -27770 0 1 {name=p48859 lab=_68376_/X }
C {sky130_stdcells/buf_2.sym} 49540 -27770 0 0 {name=X_68376_ }
C {devices/lab_pin.sym} 49480 -27670 0 0 {name=p48860 lab=_65559_/A }
C {devices/lab_pin.sym} 49480 -27630 0 0 {name=p48861 lab=_65559_/B }
C {devices/lab_pin.sym} 49480 -27590 0 0 {name=p48862 lab=_84191_/Q }
C {devices/lab_pin.sym} 49600 -27630 0 1 {name=p48863 lab=_65588_/X }
C {sky130_stdcells/and3_4.sym} 49540 -27630 0 0 {name=X_65588_ }
C {devices/lab_pin.sym} 49480 -27500 0 0 {name=p48864 lab=_55445_/B }
C {devices/lab_pin.sym} 49480 -27460 0 0 {name=p48865 lab=_55445_/D }
C {devices/lab_pin.sym} 49600 -27480 0 1 {name=p48866 lab=_55362_/A }
C {sky130_stdcells/and2_4.sym} 49540 -27480 0 0 {name=X_55341_ }
C {devices/lab_pin.sym} 49460 -27380 0 0 {name=p48867 lab=_67305_/X }
C {devices/lab_pin.sym} 49460 -27340 0 0 {name=p48868 lab=_67316_/Y }
C {devices/lab_pin.sym} 49460 -27300 0 0 {name=p48869 lab=_67269_/X }
C {devices/lab_pin.sym} 49460 -27260 0 0 {name=p48870 lab=_67326_/Y }
C {devices/lab_pin.sym} 49620 -27320 0 1 {name=p48871 lab=_67327_/X }
C {sky130_stdcells/a211o_4.sym} 49540 -27320 0 0 {name=X_67327_ }
C {devices/lab_pin.sym} 49450 -27170 0 0 {name=p48872 lab=_85557_/CLK }
C {devices/lab_pin.sym} 49450 -27150 0 0 {name=p48873 lab=_50648_/Y }
C {devices/lab_pin.sym} 49630 -27170 0 1 {name=p48874 lab=_86161_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -27160 0 0 {name=X_86161_ }
C {devices/lab_pin.sym} 49480 -27040 0 0 {name=p48875 lab=_52542_/X }
C {devices/lab_pin.sym} 49480 -27000 0 0 {name=p48876 lab=_54071_/B }
C {devices/lab_pin.sym} 49600 -27020 0 1 {name=p48877 lab=_52553_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -27020 0 0 {name=X_52553_ }
C {sky130_stdcells/decap_3.sym} 49540 -26860 0 0 {name=XPHY_306 }
C {devices/lab_pin.sym} 49460 -26750 0 0 {name=p48878 lab=_64534_/X }
C {devices/lab_pin.sym} 49460 -26710 0 0 {name=p48879 lab=_64535_/X }
C {devices/lab_pin.sym} 49460 -26670 0 0 {name=p48880 lab=_64536_/X }
C {devices/lab_pin.sym} 49460 -26630 0 0 {name=p48881 lab=_64538_/Y }
C {devices/lab_pin.sym} 49460 -26590 0 0 {name=p48882 lab=_64219_/B }
C {devices/lab_pin.sym} 49620 -26670 0 1 {name=p48883 lab=_64539_/X }
C {sky130_stdcells/o41a_4.sym} 49540 -26670 0 0 {name=X_64539_ }
C {devices/lab_pin.sym} 49450 -26510 0 0 {name=p48884 lab=_83372_/CLK }
C {devices/lab_pin.sym} 49450 -26490 0 0 {name=p48885 lab=_71795_/Y }
C {devices/lab_pin.sym} 49630 -26510 0 1 {name=p48886 lab=_83373_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -26500 0 0 {name=X_83373_ }
C {devices/lab_pin.sym} 49480 -26380 0 0 {name=p48887 lab=_84773_/Q }
C {devices/lab_pin.sym} 49480 -26340 0 0 {name=p48888 lab=_65970_/C }
C {devices/lab_pin.sym} 49600 -26360 0 1 {name=p48889 lab=_80585_/Y }
