C {devices/lab_pin.sym} 123980 -11200 0 0 {name=p123400 lab=_66899_/X }
C {devices/lab_pin.sym} 123980 -11160 0 0 {name=p123401 lab=_66909_/Y }
C {devices/lab_pin.sym} 123980 -11120 0 0 {name=p123402 lab=_66910_/X }
C {devices/lab_pin.sym} 123980 -11080 0 0 {name=p123403 lab=_66922_/Y }
C {devices/lab_pin.sym} 124140 -11140 0 1 {name=p123404 lab=_66923_/X }
C {sky130_stdcells/a211o_4.sym} 124060 -11140 0 0 {name=X_66923_ }
C {devices/lab_pin.sym} 124000 -11020 0 0 {name=p123405 lab=_63610_/B }
C {devices/lab_pin.sym} 124000 -10980 0 0 {name=p123406 lab=_61999_/B }
C {devices/lab_pin.sym} 124000 -10940 0 0 {name=p123407 lab=_62046_/C }
C {devices/lab_pin.sym} 124000 -10900 0 0 {name=p123408 lab=_62046_/D }
C {devices/lab_pin.sym} 124120 -10960 0 1 {name=p123409 lab=_62047_/D }
C {sky130_stdcells/nand4_4.sym} 124060 -10960 0 0 {name=X_62046_ }
C {devices/lab_pin.sym} 124000 -10820 0 0 {name=p123410 lab=_82733_/Q }
C {devices/lab_pin.sym} 124000 -10780 0 0 {name=p123411 lab=_78909_/B }
C {devices/lab_pin.sym} 124120 -10800 0 1 {name=p123412 lab=_78909_/X }
C {sky130_stdcells/xor2_4.sym} 124060 -10800 0 0 {name=X_78909_ }
C {devices/lab_pin.sym} 124020 -10670 0 0 {name=p123413 lab=_79889_/A }
C {devices/lab_pin.sym} 124100 -10670 0 1 {name=p123414 lab=_79890_/B }
C {sky130_stdcells/inv_2.sym} 124060 -10670 0 0 {name=X_79889_ }
C {devices/lab_pin.sym} 124020 -10550 0 0 {name=p123415 lab=clkbuf_9_269_0_CLK/X }
C {devices/lab_pin.sym} 124100 -10550 0 1 {name=p123416 lab=_82053_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 124060 -10550 0 0 {name=Xclkbuf_10_538_0_CLK }
C {devices/lab_pin.sym} 124020 -10430 0 0 {name=p123417 lab=clkbuf_6_29_0_CLK/A }
C {devices/lab_pin.sym} 124100 -10430 0 1 {name=p123418 lab=clkbuf_7_58_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 124060 -10430 0 0 {name=Xclkbuf_6_29_0_CLK }
C {devices/lab_pin.sym} 123980 -10340 0 0 {name=p123419 lab=_69579_/X }
C {devices/lab_pin.sym} 123980 -10300 0 0 {name=p123420 lab=_69640_/Y }
C {devices/lab_pin.sym} 123980 -10260 0 0 {name=p123421 lab=_69604_/X }
C {devices/lab_pin.sym} 123980 -10220 0 0 {name=p123422 lab=_69641_/Y }
C {devices/lab_pin.sym} 124140 -10280 0 1 {name=p123423 lab=_69642_/X }
C {sky130_stdcells/a211o_4.sym} 124060 -10280 0 0 {name=X_69642_ }
C {devices/lab_pin.sym} 123970 -10130 0 0 {name=p123424 lab=_82015_/CLK }
C {devices/lab_pin.sym} 123970 -10110 0 0 {name=p123425 lab=_77708_/Y }
C {devices/lab_pin.sym} 124150 -10130 0 1 {name=p123426 lab=_81920_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -10120 0 0 {name=X_81920_ }
C {devices/lab_pin.sym} 124000 -10000 0 0 {name=p123427 lab=_66785_/A }
C {devices/lab_pin.sym} 124000 -9960 0 0 {name=p123428 lab=_86794_/Q }
C {devices/lab_pin.sym} 124120 -9980 0 1 {name=p123429 lab=_66854_/X }
C {sky130_stdcells/and2_4.sym} 124060 -9980 0 0 {name=X_66854_ }
C {devices/lab_pin.sym} 123980 -9880 0 0 {name=p123430 lab=_65623_/X }
C {devices/lab_pin.sym} 123980 -9840 0 0 {name=p123431 lab=_86184_/Q }
C {devices/lab_pin.sym} 123980 -9800 0 0 {name=p123432 lab=_65790_/X }
C {devices/lab_pin.sym} 123980 -9760 0 0 {name=p123433 lab=_65804_/X }
C {devices/lab_pin.sym} 124140 -9820 0 1 {name=p123434 lab=_65805_/X }
C {sky130_stdcells/a211o_4.sym} 124060 -9820 0 0 {name=X_65805_ }
C {devices/lab_pin.sym} 123970 -9670 0 0 {name=p123435 lab=_81872_/CLK }
C {devices/lab_pin.sym} 123970 -9650 0 0 {name=p123436 lab=_81883_/Q }
C {devices/lab_pin.sym} 124150 -9670 0 1 {name=p123437 lab=_77601_/A }
C {sky130_stdcells/dfxtp_4.sym} 124060 -9660 0 0 {name=X_81851_ }
C {devices/lab_pin.sym} 123980 -9560 0 0 {name=p123438 lab=_44514_/A }
C {devices/lab_pin.sym} 123980 -9520 0 0 {name=p123439 lab=_69457_/X }
C {devices/lab_pin.sym} 123980 -9480 0 0 {name=p123440 lab=_69458_/X }
C {devices/lab_pin.sym} 123980 -9440 0 0 {name=p123441 lab=_69572_/X }
C {devices/lab_pin.sym} 124140 -9500 0 1 {name=p123442 lab=_69574_/B }
C {sky130_stdcells/a211o_4.sym} 124060 -9500 0 0 {name=X_69573_ }
C {devices/lab_pin.sym} 124000 -9360 0 0 {name=p123443 lab=_66785_/A }
C {devices/lab_pin.sym} 124000 -9320 0 0 {name=p123444 lab=_66785_/B }
C {devices/lab_pin.sym} 124120 -9340 0 1 {name=p123445 lab=_66785_/X }
C {sky130_stdcells/and2_4.sym} 124060 -9340 0 0 {name=X_66785_ }
C {devices/lab_pin.sym} 124000 -9240 0 0 {name=p123446 lab=_63196_/B }
C {devices/lab_pin.sym} 124000 -9200 0 0 {name=p123447 lab=_63947_/B }
C {devices/lab_pin.sym} 124000 -9160 0 0 {name=p123448 lab=_64040_/C }
C {devices/lab_pin.sym} 124000 -9120 0 0 {name=p123449 lab=_64025_/D }
C {devices/lab_pin.sym} 124120 -9180 0 1 {name=p123450 lab=_63997_/Y }
C {sky130_stdcells/nand4_4.sym} 124060 -9180 0 0 {name=X_63997_ }
C {devices/lab_pin.sym} 123970 -9030 0 0 {name=p123451 lab=_83973_/CLK }
C {devices/lab_pin.sym} 123970 -9010 0 0 {name=p123452 lab=_80802_/D }
C {devices/lab_pin.sym} 124150 -9030 0 1 {name=p123453 lab=_75714_/B }
C {sky130_stdcells/dfxtp_4.sym} 124060 -9020 0 0 {name=X_80802_ }
C {devices/lab_pin.sym} 123980 -8920 0 0 {name=p123454 lab=_87001_/Q }
C {devices/lab_pin.sym} 123980 -8880 0 0 {name=p123455 lab=_68023_/X }
C {devices/lab_pin.sym} 123980 -8840 0 0 {name=p123456 lab=_68024_/X }
C {devices/lab_pin.sym} 123980 -8800 0 0 {name=p123457 lab=_68523_/X }
C {devices/lab_pin.sym} 124140 -8860 0 1 {name=p123458 lab=_68525_/B }
C {sky130_stdcells/a211o_4.sym} 124060 -8860 0 0 {name=X_68524_ }
C {devices/lab_pin.sym} 124000 -8720 0 0 {name=p123459 lab=_53750_/A }
C {devices/lab_pin.sym} 124000 -8680 0 0 {name=p123460 lab=_48647_/Y }
C {devices/lab_pin.sym} 124120 -8700 0 1 {name=p123461 lab=_53750_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -8700 0 0 {name=X_53750_ }
C {devices/lab_pin.sym} 123980 -8600 0 0 {name=p123462 lab=_65733_/X }
C {devices/lab_pin.sym} 123980 -8560 0 0 {name=p123463 lab=_85581_/Q }
C {devices/lab_pin.sym} 123980 -8520 0 0 {name=p123464 lab=_65734_/X }
C {devices/lab_pin.sym} 123980 -8480 0 0 {name=p123465 lab=_65735_/X }
C {devices/lab_pin.sym} 124140 -8540 0 1 {name=p123466 lab=_65736_/X }
C {sky130_stdcells/a211o_4.sym} 124060 -8540 0 0 {name=X_65736_ }
C {devices/lab_pin.sym} 123970 -8390 0 0 {name=p123467 lab=_84603_/CLK }
C {devices/lab_pin.sym} 123970 -8370 0 0 {name=p123468 lab=_60774_/X }
C {devices/lab_pin.sym} 124150 -8390 0 1 {name=p123469 lab=_84570_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -8380 0 0 {name=X_84570_ }
C {devices/lab_pin.sym} 123980 -8270 0 0 {name=p123470 lab=_86099_/Q }
C {devices/lab_pin.sym} 123980 -8230 0 0 {name=p123471 lab=_50936_/X }
C {devices/lab_pin.sym} 123980 -8190 0 0 {name=p123472 lab=_50961_/Y }
C {devices/lab_pin.sym} 124140 -8230 0 1 {name=p123473 lab=_50962_/Y }
C {sky130_stdcells/o21ai_4.sym} 124060 -8230 0 0 {name=X_50962_ }
C {devices/lab_pin.sym} 124000 -8110 0 0 {name=p123474 lab=_62927_/A }
C {devices/lab_pin.sym} 124000 -8070 0 0 {name=p123475 lab=_62926_/B }
C {devices/lab_pin.sym} 124000 -8030 0 0 {name=p123476 lab=_62948_/C }
C {devices/lab_pin.sym} 124120 -8070 0 1 {name=p123477 lab=_62948_/Y }
C {sky130_stdcells/nand3_4.sym} 124060 -8070 0 0 {name=X_62948_ }
C {devices/lab_pin.sym} 123970 -7930 0 0 {name=p123478 lab=_81703_/CLK }
C {devices/lab_pin.sym} 123970 -7910 0 0 {name=p123479 lab=_76121_/X }
C {devices/lab_pin.sym} 124150 -7930 0 1 {name=p123480 lab=_48484_/A }
C {sky130_stdcells/dfxtp_4.sym} 124060 -7920 0 0 {name=X_81782_ }
C {devices/lab_pin.sym} 123980 -7810 0 0 {name=p123481 lab=_85770_/Q }
C {devices/lab_pin.sym} 123980 -7770 0 0 {name=p123482 lab=_52684_/X }
C {devices/lab_pin.sym} 123980 -7730 0 0 {name=p123483 lab=_52700_/Y }
C {devices/lab_pin.sym} 124140 -7770 0 1 {name=p123484 lab=_52701_/Y }
C {sky130_stdcells/o21ai_4.sym} 124060 -7770 0 0 {name=X_52701_ }
C {devices/lab_pin.sym} 123970 -7630 0 0 {name=p123485 lab=_83521_/CLK }
C {devices/lab_pin.sym} 123970 -7610 0 0 {name=p123486 lab=_83521_/D }
C {devices/lab_pin.sym} 124150 -7630 0 1 {name=p123487 lab=_83521_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -7620 0 0 {name=X_83521_ }
C {devices/lab_pin.sym} 123970 -7490 0 0 {name=p123488 lab=_84280_/CLK }
C {devices/lab_pin.sym} 123970 -7470 0 0 {name=p123489 lab=_80733_/D }
C {devices/lab_pin.sym} 124150 -7490 0 1 {name=p123490 lab=_80733_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -7480 0 0 {name=X_80733_ }
C {devices/lab_pin.sym} 124020 -7350 0 0 {name=p123491 lab=_68059_/A }
C {devices/lab_pin.sym} 124100 -7350 0 1 {name=p123492 lab=_68455_/X }
C {sky130_stdcells/buf_2.sym} 124060 -7350 0 0 {name=X_68455_ }
C {devices/lab_pin.sym} 124000 -7250 0 0 {name=p123493 lab=_52161_/A }
C {devices/lab_pin.sym} 124000 -7210 0 0 {name=p123494 lab=_53666_/X }
C {devices/lab_pin.sym} 124000 -7170 0 0 {name=p123495 lab=_53692_/C }
C {devices/lab_pin.sym} 124120 -7210 0 1 {name=p123496 lab=_53681_/X }
C {sky130_stdcells/and3_4.sym} 124060 -7210 0 0 {name=X_53681_ }
C {devices/lab_pin.sym} 124000 -7080 0 0 {name=p123497 lab=_65667_/A }
C {devices/lab_pin.sym} 124000 -7040 0 0 {name=p123498 lab=_85873_/Q }
C {devices/lab_pin.sym} 124120 -7060 0 1 {name=p123499 lab=_65667_/X }
C {sky130_stdcells/and2_4.sym} 124060 -7060 0 0 {name=X_65667_ }
C {devices/lab_pin.sym} 124000 -6940 0 0 {name=p123500 lab=_50906_/A }
C {devices/lab_pin.sym} 124000 -6900 0 0 {name=p123501 lab=_50893_/B }
C {devices/lab_pin.sym} 124120 -6920 0 1 {name=p123502 lab=_50893_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -6920 0 0 {name=X_50893_ }
C {devices/lab_pin.sym} 124000 -6820 0 0 {name=p123503 lab=_61560_/B }
C {devices/lab_pin.sym} 124000 -6780 0 0 {name=p123504 lab=_62858_/X }
C {devices/lab_pin.sym} 124000 -6740 0 0 {name=p123505 lab=_62859_/X }
C {devices/lab_pin.sym} 124000 -6700 0 0 {name=p123506 lab=_62889_/D }
C {devices/lab_pin.sym} 124120 -6760 0 1 {name=p123507 lab=_62879_/Y }
C {sky130_stdcells/nand4_4.sym} 124060 -6760 0 0 {name=X_62879_ }
C {devices/lab_pin.sym} 124000 -6630 0 0 {name=p123508 lab=_55416_/Y }
C {devices/lab_pin.sym} 124000 -6590 0 0 {name=p123509 lab=_55296_/B }
C {devices/lab_pin.sym} 124000 -6550 0 0 {name=p123510 lab=_55417_/Y }
C {devices/lab_pin.sym} 124120 -6590 0 1 {name=p123511 lab=_56807_/C }
C {sky130_stdcells/nand3_4.sym} 124060 -6590 0 0 {name=X_55420_ }
C {devices/lab_pin.sym} 124000 -6460 0 0 {name=p123512 lab=_67333_/A }
C {devices/lab_pin.sym} 124000 -6420 0 0 {name=p123513 lab=_67406_/B }
C {devices/lab_pin.sym} 124120 -6440 0 1 {name=p123514 lab=_67406_/X }
C {sky130_stdcells/and2_4.sym} 124060 -6440 0 0 {name=X_67406_ }
C {devices/lab_pin.sym} 123970 -6310 0 0 {name=p123515 lab=_86436_/CLK }
C {devices/lab_pin.sym} 123970 -6290 0 0 {name=p123516 lab=_50231_/Y }
C {devices/lab_pin.sym} 124150 -6310 0 1 {name=p123517 lab=_86240_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -6300 0 0 {name=X_86240_ }
C {devices/lab_pin.sym} 124000 -6180 0 0 {name=p123518 lab=_52637_/A }
C {devices/lab_pin.sym} 124000 -6140 0 0 {name=p123519 lab=_52632_/B }
C {devices/lab_pin.sym} 124120 -6160 0 1 {name=p123520 lab=_52632_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -6160 0 0 {name=X_52632_ }
C {devices/lab_pin.sym} 123980 -6060 0 0 {name=p123521 lab=_64615_/X }
C {devices/lab_pin.sym} 123980 -6020 0 0 {name=p123522 lab=_85536_/Q }
C {devices/lab_pin.sym} 123980 -5980 0 0 {name=p123523 lab=_64571_/X }
C {devices/lab_pin.sym} 123980 -5940 0 0 {name=p123524 lab=_64617_/X }
C {devices/lab_pin.sym} 124140 -6000 0 1 {name=p123525 lab=_64618_/X }
C {sky130_stdcells/a211o_4.sym} 124060 -6000 0 0 {name=X_64618_ }
C {devices/lab_pin.sym} 123970 -5850 0 0 {name=p123526 lab=_83451_/CLK }
C {devices/lab_pin.sym} 123970 -5830 0 0 {name=p123527 lab=_71573_/X }
C {devices/lab_pin.sym} 124150 -5850 0 1 {name=p123528 lab=_83452_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -5840 0 0 {name=X_83452_ }
C {devices/lab_pin.sym} 123970 -5710 0 0 {name=p123529 lab=_80664_/CLK }
C {devices/lab_pin.sym} 123970 -5690 0 0 {name=p123530 lab=_80664_/D }
C {devices/lab_pin.sym} 124150 -5710 0 1 {name=p123531 lab=_46085_/A }
C {sky130_stdcells/dfxtp_4.sym} 124060 -5700 0 0 {name=X_80664_ }
C {devices/lab_pin.sym} 124020 -5570 0 0 {name=p123532 lab=_68386_/A }
C {devices/lab_pin.sym} 124100 -5570 0 1 {name=p123533 lab=_69001_/A }
C {sky130_stdcells/buf_2.sym} 124060 -5570 0 0 {name=X_68386_ }
C {devices/lab_pin.sym} 123980 -5480 0 0 {name=p123534 lab=_65596_/X }
C {devices/lab_pin.sym} 123980 -5440 0 0 {name=p123535 lab=_83070_/Q }
C {devices/lab_pin.sym} 123980 -5400 0 0 {name=p123536 lab=_65540_/X }
C {devices/lab_pin.sym} 123980 -5360 0 0 {name=p123537 lab=_65597_/X }
C {devices/lab_pin.sym} 124140 -5420 0 1 {name=p123538 lab=_65599_/B }
C {sky130_stdcells/a211o_4.sym} 124060 -5420 0 0 {name=X_65598_ }
C {devices/lab_pin.sym} 123970 -5270 0 0 {name=p123539 lab=_82797_/CLK }
C {devices/lab_pin.sym} 123970 -5250 0 0 {name=p123540 lab=_82435_/Q }
C {devices/lab_pin.sym} 124150 -5270 0 1 {name=p123541 lab=_78316_/A }
C {sky130_stdcells/dfxtp_4.sym} 124060 -5260 0 0 {name=X_82403_ }
C {devices/lab_pin.sym} 123980 -5150 0 0 {name=p123542 lab=_55352_/A }
C {devices/lab_pin.sym} 123980 -5110 0 0 {name=p123543 lab=_55352_/C }
C {devices/lab_pin.sym} 123980 -5070 0 0 {name=p123544 lab=_83753_/Q }
C {devices/lab_pin.sym} 124140 -5110 0 1 {name=p123545 lab=_55445_/A }
C {sky130_stdcells/a21o_4.sym} 124060 -5110 0 0 {name=X_55351_ }
C {devices/lab_pin.sym} 123980 -4990 0 0 {name=p123546 lab=_67334_/X }
C {devices/lab_pin.sym} 123980 -4950 0 0 {name=p123547 lab=_67336_/X }
C {devices/lab_pin.sym} 123980 -4910 0 0 {name=p123548 lab=_67264_/X }
C {devices/lab_pin.sym} 124140 -4950 0 1 {name=p123549 lab=_67340_/A }
C {sky130_stdcells/a21o_4.sym} 124060 -4950 0 0 {name=X_67337_ }
C {devices/lab_pin.sym} 123970 -4810 0 0 {name=p123550 lab=_85566_/CLK }
C {devices/lab_pin.sym} 123970 -4790 0 0 {name=p123551 lab=_86171_/D }
C {devices/lab_pin.sym} 124150 -4810 0 1 {name=p123552 lab=_86171_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -4800 0 0 {name=X_86171_ }
C {sky130_stdcells/decap_3.sym} 124060 -4640 0 0 {name=XPHY_406 }
C {devices/lab_pin.sym} 124000 -4500 0 0 {name=p123553 lab=_52567_/A }
C {devices/lab_pin.sym} 124000 -4460 0 0 {name=p123554 lab=_52563_/B }
C {devices/lab_pin.sym} 124120 -4480 0 1 {name=p123555 lab=_52563_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -4480 0 0 {name=X_52563_ }
C {devices/lab_pin.sym} 123980 -4390 0 0 {name=p123556 lab=_64544_/X }
C {devices/lab_pin.sym} 123980 -4350 0 0 {name=p123557 lab=_64545_/X }
C {devices/lab_pin.sym} 123980 -4310 0 0 {name=p123558 lab=_64546_/X }
C {devices/lab_pin.sym} 123980 -4270 0 0 {name=p123559 lab=_64548_/Y }
C {devices/lab_pin.sym} 123980 -4230 0 0 {name=p123560 lab=_64219_/B }
C {devices/lab_pin.sym} 124140 -4310 0 1 {name=p123561 lab=_64549_/X }
C {sky130_stdcells/o41a_4.sym} 124060 -4310 0 0 {name=X_64549_ }
C {devices/lab_pin.sym} 123970 -4150 0 0 {name=p123562 lab=_83415_/CLK }
C {devices/lab_pin.sym} 123970 -4130 0 0 {name=p123563 lab=_83383_/D }
C {devices/lab_pin.sym} 124150 -4150 0 1 {name=p123564 lab=_83383_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -4140 0 0 {name=X_83383_ }
C {devices/lab_pin.sym} 123980 -4050 0 0 {name=p123565 lab=_80557_/X }
C {devices/lab_pin.sym} 123980 -4010 0 0 {name=p123566 lab=_80561_/B }
C {devices/lab_pin.sym} 123980 -3970 0 0 {name=p123567 lab=_80572_/X }
C {devices/lab_pin.sym} 123980 -3930 0 0 {name=p123568 lab=_80570_/Y }
C {devices/lab_pin.sym} 123980 -3890 0 0 {name=p123569 lab=_80592_/Y }
C {devices/lab_pin.sym} 124140 -3970 0 1 {name=p123570 lab=_80598_/A }
C {sky130_stdcells/a2111o_4.sym} 124060 -3970 0 0 {name=X_80595_ }
C {sky130_stdcells/decap_3.sym} 124060 -3780 0 0 {name=XPHY_417 }
C {sky130_stdcells/decap_3.sym} 124060 -3600 0 0 {name=XPHY_428 }
C {devices/lab_pin.sym} 124020 -3450 0 0 {name=p123571 lab=_54329_/A }
C {devices/lab_pin.sym} 124100 -3450 0 1 {name=p123572 lab=_54325_/B }
C {sky130_stdcells/buf_2.sym} 124060 -3450 0 0 {name=X_54302_ }
C {sky130_stdcells/decap_3.sym} 124060 -3300 0 0 {name=XPHY_439 }
C {devices/lab_pin.sym} 123970 -3150 0 0 {name=p123573 lab=_82980_/CLK }
C {devices/lab_pin.sym} 123970 -3130 0 0 {name=p123574 lab=_56929_/X }
C {devices/lab_pin.sym} 124150 -3150 0 1 {name=p123575 lab=_85122_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -3140 0 0 {name=X_85122_ }
C {devices/lab_pin.sym} 124000 -3020 0 0 {name=p123576 lab=_51514_/A }
C {devices/lab_pin.sym} 124000 -2980 0 0 {name=p123577 lab=_53041_/B }
C {devices/lab_pin.sym} 124120 -3000 0 1 {name=p123578 lab=_51514_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -3000 0 0 {name=X_51514_ }
C {devices/lab_pin.sym} 124000 -2880 0 0 {name=p123579 lab=_58070_/A }
C {devices/lab_pin.sym} 124000 -2840 0 0 {name=p123580 lab=_58070_/B }
C {devices/lab_pin.sym} 124120 -2860 0 1 {name=p123581 lab=_58070_/Y }
C {sky130_stdcells/nor2_4.sym} 124060 -2860 0 0 {name=X_58070_ }
C {devices/lab_pin.sym} 123970 -2730 0 0 {name=p123582 lab=_88268_/CLK }
C {devices/lab_pin.sym} 123970 -2710 0 0 {name=p123583 lab=_77208_/B }
C {devices/lab_pin.sym} 124150 -2730 0 1 {name=p123584 lab=_82334_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -2720 0 0 {name=X_82334_ }
C {devices/lab_pin.sym} 124000 -2600 0 0 {name=p123585 lab=_55145_/A }
C {devices/lab_pin.sym} 124000 -2560 0 0 {name=p123586 lab=_55282_/B }
C {devices/lab_pin.sym} 124120 -2580 0 1 {name=p123587 lab=_55282_/Y }
C {sky130_stdcells/nor2_4.sym} 124060 -2580 0 0 {name=X_55282_ }
C {devices/lab_pin.sym} 124000 -2460 0 0 {name=p123588 lab=_67268_/A }
C {devices/lab_pin.sym} 124000 -2420 0 0 {name=p123589 lab=_67267_/X }
C {devices/lab_pin.sym} 124120 -2440 0 1 {name=p123590 lab=_67268_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -2440 0 0 {name=X_67268_ }
C {devices/lab_pin.sym} 124000 -2320 0 0 {name=p123591 lab=_52448_/A }
C {devices/lab_pin.sym} 124000 -2280 0 0 {name=p123592 lab=_52494_/B }
C {devices/lab_pin.sym} 124120 -2300 0 1 {name=p123593 lab=_52494_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -2300 0 0 {name=X_52494_ }
C {devices/lab_pin.sym} 123980 -2190 0 0 {name=p123594 lab=_57019_/X }
C {devices/lab_pin.sym} 123980 -2150 0 0 {name=p123595 lab=_57020_/Y }
C {devices/lab_pin.sym} 123980 -2110 0 0 {name=p123596 lab=_56952_/A }
C {devices/lab_pin.sym} 124140 -2150 0 1 {name=p123597 lab=_57021_/Y }
C {sky130_stdcells/o21ai_4.sym} 124060 -2150 0 0 {name=X_57021_ }
C {devices/lab_pin.sym} 124020 -2010 0 0 {name=p123598 lab=_69007_/A }
C {devices/lab_pin.sym} 124100 -2010 0 1 {name=p123599 lab=_69007_/X }
C {sky130_stdcells/buf_2.sym} 124060 -2010 0 0 {name=X_69007_ }
C {devices/lab_pin.sym} 123980 -1910 0 0 {name=p123600 lab=_54231_/Y }
C {devices/lab_pin.sym} 123980 -1870 0 0 {name=p123601 lab=_54226_/X }
C {devices/lab_pin.sym} 123980 -1830 0 0 {name=p123602 lab=_54232_/X }
C {devices/lab_pin.sym} 124140 -1870 0 1 {name=p123603 lab=_54233_/Y }
C {sky130_stdcells/a21oi_4.sym} 124060 -1870 0 0 {name=X_54233_ }
C {devices/lab_pin.sym} 123980 -1750 0 0 {name=p123604 lab=_66217_/Y }
C {devices/lab_pin.sym} 123980 -1710 0 0 {name=p123605 lab=_66205_/X }
C {devices/lab_pin.sym} 123980 -1670 0 0 {name=p123606 lab=_66218_/X }
C {devices/lab_pin.sym} 124140 -1710 0 1 {name=p123607 lab=_66219_/X }
C {sky130_stdcells/a21o_4.sym} 124060 -1710 0 0 {name=X_66219_ }
C {devices/lab_pin.sym} 123970 -1570 0 0 {name=p123608 lab=_85114_/CLK }
C {devices/lab_pin.sym} 123970 -1550 0 0 {name=p123609 lab=_85053_/D }
C {devices/lab_pin.sym} 124150 -1570 0 1 {name=p123610 lab=_45460_/A }
C {sky130_stdcells/dfxtp_4.sym} 124060 -1560 0 0 {name=X_85053_ }
C {devices/lab_pin.sym} 124000 -1440 0 0 {name=p123611 lab=_51430_/X }
C {devices/lab_pin.sym} 124000 -1400 0 0 {name=p123612 lab=_52973_/B }
C {devices/lab_pin.sym} 124120 -1420 0 1 {name=p123613 lab=_51445_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -1420 0 0 {name=X_51445_ }
C {devices/lab_pin.sym} 123970 -1290 0 0 {name=p123614 lab=_83520_/CLK }
C {devices/lab_pin.sym} 123970 -1270 0 0 {name=p123615 lab=_80544_/X }
C {devices/lab_pin.sym} 124150 -1290 0 1 {name=p123616 lab=_82265_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -1280 0 0 {name=X_82265_ }
C {devices/lab_pin.sym} 123980 -1180 0 0 {name=p123617 lab=_87865_/Q }
C {devices/lab_pin.sym} 123980 -1140 0 0 {name=p123618 lab=_67176_/X }
C {devices/lab_pin.sym} 123980 -1100 0 0 {name=p123619 lab=_67153_/X }
C {devices/lab_pin.sym} 123980 -1060 0 0 {name=p123620 lab=_67198_/X }
C {devices/lab_pin.sym} 124140 -1120 0 1 {name=p123621 lab=_67199_/X }
C {sky130_stdcells/a211o_4.sym} 124060 -1120 0 0 {name=X_67199_ }
C {devices/lab_pin.sym} 123970 -970 0 0 {name=p123622 lab=_81746_/CLK }
C {devices/lab_pin.sym} 123970 -950 0 0 {name=p123623 lab=_68237_/X }
C {devices/lab_pin.sym} 124150 -970 0 1 {name=p123624 lab=_82652_/D }
C {sky130_stdcells/dfxtp_4.sym} 124060 -960 0 0 {name=X_84004_ }
C {devices/lab_pin.sym} 123970 -830 0 0 {name=p123625 lab=_81216_/CLK }
C {devices/lab_pin.sym} 123970 -810 0 0 {name=p123626 lab=_81216_/D }
C {devices/lab_pin.sym} 124150 -830 0 1 {name=p123627 lab=_81216_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -820 0 0 {name=X_81216_ }
C {devices/lab_pin.sym} 124020 -690 0 0 {name=p123628 lab=_54217_/A }
C {devices/lab_pin.sym} 124100 -690 0 1 {name=p123629 lab=_54186_/B }
C {sky130_stdcells/buf_2.sym} 124060 -690 0 0 {name=X_54164_ }
C {devices/lab_pin.sym} 124920 -42160 0 0 {name=p123630 lab=_51367_/X }
C {devices/lab_pin.sym} 124920 -42120 0 0 {name=p123631 lab=_51376_/B }
C {devices/lab_pin.sym} 125040 -42140 0 1 {name=p123632 lab=_51376_/X }
C {sky130_stdcells/and2_4.sym} 124980 -42140 0 0 {name=X_51376_ }
C {devices/lab_pin.sym} 124890 -42010 0 0 {name=p123633 lab=_85491_/CLK }
C {devices/lab_pin.sym} 124890 -41990 0 0 {name=p123634 lab=_82196_/D }
C {devices/lab_pin.sym} 125070 -42010 0 1 {name=p123635 lab=_82196_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -42000 0 0 {name=X_82196_ }
C {devices/lab_pin.sym} 124920 -41880 0 0 {name=p123636 lab=_53115_/A }
C {devices/lab_pin.sym} 124920 -41840 0 0 {name=p123637 lab=_53115_/B }
C {devices/lab_pin.sym} 125040 -41860 0 1 {name=p123638 lab=_53115_/Y }
C {sky130_stdcells/nand2_4.sym} 124980 -41860 0 0 {name=X_53115_ }
C {devices/lab_pin.sym} 124900 -41750 0 0 {name=p123639 lab=_50325_/Y }
C {devices/lab_pin.sym} 124900 -41710 0 0 {name=p123640 lab=_50299_/X }
C {devices/lab_pin.sym} 124900 -41670 0 0 {name=p123641 lab=_50326_/Y }
C {devices/lab_pin.sym} 125060 -41710 0 1 {name=p123642 lab=_50327_/Y }
C {sky130_stdcells/a21boi_4.sym} 124980 -41710 0 0 {name=X_50327_ }
C {devices/lab_pin.sym} 124890 -41570 0 0 {name=p123643 lab=_81197_/CLK }
C {devices/lab_pin.sym} 124890 -41550 0 0 {name=p123644 lab=_81147_/D }
C {devices/lab_pin.sym} 125070 -41570 0 1 {name=p123645 lab=_40615_/A }
C {sky130_stdcells/dfxtp_4.sym} 124980 -41560 0 0 {name=X_81147_ }
C {devices/lab_pin.sym} 124920 -41460 0 0 {name=p123646 lab=_53420_/A }
C {devices/lab_pin.sym} 124920 -41420 0 0 {name=p123647 lab=_53428_/X }
C {devices/lab_pin.sym} 124920 -41380 0 0 {name=p123648 lab=_54111_/C }
C {devices/lab_pin.sym} 124920 -41340 0 0 {name=p123649 lab=_52927_/D }
C {devices/lab_pin.sym} 125040 -41400 0 1 {name=p123650 lab=_54095_/X }
C {sky130_stdcells/and4_4.sym} 124980 -41400 0 0 {name=X_54095_ }
C {devices/lab_pin.sym} 124940 -41250 0 0 {name=p123651 lab=_84784_/Q }
C {devices/lab_pin.sym} 125020 -41250 0 1 {name=p123652 lab=_58973_/A }
C {sky130_stdcells/inv_2.sym} 124980 -41250 0 0 {name=X_58972_ }
C {devices/lab_pin.sym} 124920 -41140 0 0 {name=p123653 lab=_53040_/X }
C {devices/lab_pin.sym} 124920 -41100 0 0 {name=p123654 lab=_53046_/B }
C {devices/lab_pin.sym} 125040 -41120 0 1 {name=p123655 lab=_53046_/Y }
C {sky130_stdcells/nand2_4.sym} 124980 -41120 0 0 {name=X_53046_ }
C {devices/lab_pin.sym} 124940 -40990 0 0 {name=p123656 lab=_58793_/A }
C {devices/lab_pin.sym} 125020 -40990 0 1 {name=p123657 lab=_57923_/X }
C {sky130_stdcells/buf_2.sym} 124980 -40990 0 0 {name=X_57923_ }
C {devices/lab_pin.sym} 124900 -40900 0 0 {name=p123658 lab=_41059_/X }
C {devices/lab_pin.sym} 124900 -40860 0 0 {name=p123659 lab=_40987_/X }
C {devices/lab_pin.sym} 124900 -40820 0 0 {name=p123660 lab=_88285_/Q }
C {devices/lab_pin.sym} 124900 -40780 0 0 {name=p123661 lab=_40989_/X }
C {devices/lab_pin.sym} 125060 -40840 0 1 {name=p123662 lab=_41060_/X }
C {sky130_stdcells/a2bb2o_4.sym} 124980 -40840 0 0 {name=X_41060_ }
C {devices/lab_pin.sym} 124900 -40720 0 0 {name=p123663 lab=_88057_/Q }
C {devices/lab_pin.sym} 124900 -40680 0 0 {name=p123664 lab=_68377_/X }
C {devices/lab_pin.sym} 124900 -40640 0 0 {name=p123665 lab=_69465_/X }
C {devices/lab_pin.sym} 124900 -40600 0 0 {name=p123666 lab=_69908_/Y }
C {devices/lab_pin.sym} 125060 -40660 0 1 {name=p123667 lab=_69909_/X }
C {sky130_stdcells/a211o_4.sym} 124980 -40660 0 0 {name=X_69909_ }
C {devices/lab_pin.sym} 124920 -40530 0 0 {name=p123668 lab=_47886_/X }
C {devices/lab_pin.sym} 124920 -40490 0 0 {name=p123669 lab=_50475_/B }
C {devices/lab_pin.sym} 124920 -40450 0 0 {name=p123670 lab=_50257_/X }
C {devices/lab_pin.sym} 125040 -40490 0 1 {name=p123671 lab=_50258_/Y }
C {sky130_stdcells/nand3_4.sym} 124980 -40490 0 0 {name=X_50258_ }
C {devices/lab_pin.sym} 124890 -40350 0 0 {name=p123672 lab=_85955_/CLK }
C {devices/lab_pin.sym} 124890 -40330 0 0 {name=p123673 lab=_85955_/D }
C {devices/lab_pin.sym} 125070 -40350 0 1 {name=p123674 lab=_85955_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -40340 0 0 {name=X_85955_ }
C {devices/lab_pin.sym} 124890 -40210 0 0 {name=p123675 lab=_81121_/CLK }
C {devices/lab_pin.sym} 124890 -40190 0 0 {name=p123676 lab=_81110_/Q }
C {devices/lab_pin.sym} 125070 -40210 0 1 {name=p123677 lab=_75360_/A }
C {sky130_stdcells/dfxtp_4.sym} 124980 -40200 0 0 {name=X_81078_ }
C {devices/lab_pin.sym} 124900 -40090 0 0 {name=p123678 lab=_83172_/Q }
C {devices/lab_pin.sym} 124900 -40050 0 0 {name=p123679 lab=_72794_/X }
C {devices/lab_pin.sym} 124900 -40010 0 0 {name=p123680 lab=_72919_/Y }
C {devices/lab_pin.sym} 125060 -40050 0 1 {name=p123681 lab=_83172_/D }
C {sky130_stdcells/a21o_4.sym} 124980 -40050 0 0 {name=X_72920_ }
C {devices/lab_pin.sym} 124920 -39920 0 0 {name=p123682 lab=_80025_/Y }
C {devices/lab_pin.sym} 124920 -39880 0 0 {name=p123683 lab=_80043_/B }
C {devices/lab_pin.sym} 125040 -39900 0 1 {name=p123684 lab=_80030_/A }
C {sky130_stdcells/xor2_4.sym} 124980 -39900 0 0 {name=X_80029_ }
C {devices/lab_pin.sym} 124890 -39770 0 0 {name=p123685 lab=_84906_/CLK }
C {devices/lab_pin.sym} 124890 -39750 0 0 {name=p123686 lab=_84906_/D }
C {devices/lab_pin.sym} 125070 -39770 0 1 {name=p123687 lab=_84906_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -39760 0 0 {name=X_84906_ }
C {devices/lab_pin.sym} 124900 -39650 0 0 {name=p123688 lab=_57838_/X }
C {devices/lab_pin.sym} 124900 -39610 0 0 {name=p123689 lab=_86009_/Q }
C {devices/lab_pin.sym} 124900 -39570 0 0 {name=p123690 lab=_57853_/X }
C {devices/lab_pin.sym} 125060 -39610 0 1 {name=p123691 lab=_57854_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -39610 0 0 {name=X_57854_ }
C {devices/lab_pin.sym} 124900 -39490 0 0 {name=p123692 lab=_65315_/B }
C {devices/lab_pin.sym} 124900 -39450 0 0 {name=p123693 lab=_50185_/X }
C {devices/lab_pin.sym} 124900 -39410 0 0 {name=p123694 lab=_50188_/Y }
C {devices/lab_pin.sym} 125060 -39450 0 1 {name=p123695 lab=_50189_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -39450 0 0 {name=X_50189_ }
C {devices/lab_pin.sym} 124890 -39310 0 0 {name=p123696 lab=_85888_/CLK }
C {devices/lab_pin.sym} 124890 -39290 0 0 {name=p123697 lab=_85886_/D }
C {devices/lab_pin.sym} 125070 -39310 0 1 {name=p123698 lab=_72836_/B }
C {sky130_stdcells/dfxtp_4.sym} 124980 -39300 0 0 {name=X_85886_ }
C {devices/lab_pin.sym} 124900 -39190 0 0 {name=p123699 lab=_56801_/X }
C {devices/lab_pin.sym} 124900 -39150 0 0 {name=p123700 lab=_57170_/B }
C {devices/lab_pin.sym} 124900 -39110 0 0 {name=p123701 lab=_56804_/Y }
C {devices/lab_pin.sym} 125060 -39150 0 1 {name=p123702 lab=_56805_/X }
C {sky130_stdcells/o21a_4.sym} 124980 -39150 0 0 {name=X_56805_ }
C {devices/lab_pin.sym} 124890 -39010 0 0 {name=p123703 lab=_87625_/CLK }
C {devices/lab_pin.sym} 124890 -38990 0 0 {name=p123704 lab=_42968_/Y }
C {devices/lab_pin.sym} 125070 -39010 0 1 {name=p123705 lab=_66808_/B }
C {sky130_stdcells/dfxtp_4.sym} 124980 -39000 0 0 {name=X_87625_ }
C {devices/lab_pin.sym} 124940 -38870 0 0 {name=p123706 lab=_74139_/A }
C {devices/lab_pin.sym} 125020 -38870 0 1 {name=p123707 lab=_73050_/A }
C {sky130_stdcells/buf_2.sym} 124980 -38870 0 0 {name=X_72851_ }
C {devices/lab_pin.sym} 124890 -38750 0 0 {name=p123708 lab=_84837_/CLK }
C {devices/lab_pin.sym} 124890 -38730 0 0 {name=p123709 lab=_84837_/D }
C {devices/lab_pin.sym} 125070 -38750 0 1 {name=p123710 lab=_84837_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -38740 0 0 {name=X_84837_ }
C {devices/lab_pin.sym} 124940 -38610 0 0 {name=p123711 lab=_58749_/A }
C {devices/lab_pin.sym} 125020 -38610 0 1 {name=p123712 lab=_57952_/A }
C {sky130_stdcells/buf_2.sym} 124980 -38610 0 0 {name=X_57785_ }
C {devices/lab_pin.sym} 124900 -38510 0 0 {name=p123713 lab=_85338_/Q }
C {devices/lab_pin.sym} 124900 -38470 0 0 {name=p123714 lab=_54994_/X }
C {devices/lab_pin.sym} 124900 -38430 0 0 {name=p123715 lab=_54996_/Y }
C {devices/lab_pin.sym} 125060 -38470 0 1 {name=p123716 lab=_54997_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -38470 0 0 {name=X_54997_ }
C {devices/lab_pin.sym} 124900 -38350 0 0 {name=p123717 lab=_71800_/Y }
C {devices/lab_pin.sym} 124900 -38310 0 0 {name=p123718 lab=_83370_/Q }
C {devices/lab_pin.sym} 124900 -38270 0 0 {name=p123719 lab=_71801_/X }
C {devices/lab_pin.sym} 125060 -38310 0 1 {name=p123720 lab=_83370_/D }
C {sky130_stdcells/a21o_4.sym} 124980 -38310 0 0 {name=X_71802_ }
C {devices/lab_pin.sym} 124940 -38170 0 0 {name=p123721 lab=_59563_/A }
C {devices/lab_pin.sym} 125020 -38170 0 1 {name=p123722 lab=_59890_/B }
C {sky130_stdcells/buf_2.sym} 124980 -38170 0 0 {name=X_59524_ }
C {devices/lab_pin.sym} 124920 -38080 0 0 {name=p123723 lab=_56730_/X }
C {devices/lab_pin.sym} 124920 -38040 0 0 {name=p123724 lab=_56732_/X }
C {devices/lab_pin.sym} 124920 -38000 0 0 {name=p123725 lab=_56733_/X }
C {devices/lab_pin.sym} 124920 -37960 0 0 {name=p123726 lab=_56735_/X }
C {devices/lab_pin.sym} 125040 -38020 0 1 {name=p123727 lab=_56736_/X }
C {sky130_stdcells/and4_4.sym} 124980 -38020 0 0 {name=X_56736_ }
C {devices/lab_pin.sym} 124940 -37870 0 0 {name=p123728 lab=_44749_/Y }
C {devices/lab_pin.sym} 125020 -37870 0 1 {name=p123729 lab=_86976_/D }
C {sky130_stdcells/inv_2.sym} 124980 -37870 0 0 {name=X_44750_ }
C {devices/lab_pin.sym} 124920 -37760 0 0 {name=p123730 lab=_75570_/A }
C {devices/lab_pin.sym} 124920 -37720 0 0 {name=p123731 lab=_75887_/A }
C {devices/lab_pin.sym} 125040 -37740 0 1 {name=p123732 lab=_75571_/B }
C {sky130_stdcells/xor2_4.sym} 124980 -37740 0 0 {name=X_75570_ }
C {devices/lab_pin.sym} 124890 -37610 0 0 {name=p123733 lab=_87821_/CLK }
C {devices/lab_pin.sym} 124890 -37590 0 0 {name=p123734 lab=_43153_/Y }
C {devices/lab_pin.sym} 125070 -37610 0 1 {name=p123735 lab=_87556_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -37600 0 0 {name=X_87556_ }
C {devices/lab_pin.sym} 124940 -37470 0 0 {name=p123736 lab=_41961_/Y }
C {devices/lab_pin.sym} 125020 -37470 0 1 {name=p123737 lab=_88091_/D }
C {sky130_stdcells/inv_2.sym} 124980 -37470 0 0 {name=X_41962_ }
C {devices/lab_pin.sym} 124940 -37350 0 0 {name=p123738 lab=_53838_/A }
C {devices/lab_pin.sym} 125020 -37350 0 1 {name=p123739 lab=_53948_/X }
C {sky130_stdcells/buf_2.sym} 124980 -37350 0 0 {name=X_53948_ }
C {devices/lab_pin.sym} 124900 -37260 0 0 {name=p123740 lab=_72750_/X }
C {devices/lab_pin.sym} 124900 -37220 0 0 {name=p123741 lab=_85600_/Q }
C {devices/lab_pin.sym} 124900 -37180 0 0 {name=p123742 lab=_44130_/X }
C {devices/lab_pin.sym} 124900 -37140 0 0 {name=p123743 lab=_72781_/X }
C {devices/lab_pin.sym} 125060 -37200 0 1 {name=p123744 lab=_72782_/X }
C {sky130_stdcells/a211o_4.sym} 124980 -37200 0 0 {name=X_72782_ }
C {devices/lab_pin.sym} 124890 -37050 0 0 {name=p123745 lab=_85342_/CLK }
C {devices/lab_pin.sym} 124890 -37030 0 0 {name=p123746 lab=_59114_/Y }
C {devices/lab_pin.sym} 125070 -37050 0 1 {name=p123747 lab=_84768_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -37040 0 0 {name=X_84768_ }
C {devices/lab_pin.sym} 124900 -36940 0 0 {name=p123748 lab=_40826_/A }
C {devices/lab_pin.sym} 124900 -36900 0 0 {name=p123749 lab=_43698_/X }
C {devices/lab_pin.sym} 124900 -36860 0 0 {name=p123750 lab=_69722_/B }
C {devices/lab_pin.sym} 124900 -36820 0 0 {name=p123751 lab=_43700_/X }
C {devices/lab_pin.sym} 125060 -36880 0 1 {name=p123752 lab=_43701_/X }
C {sky130_stdcells/a2bb2o_4.sym} 124980 -36880 0 0 {name=X_43701_ }
C {devices/lab_pin.sym} 124900 -36750 0 0 {name=p123753 lab=_52799_/B }
C {devices/lab_pin.sym} 124900 -36710 0 0 {name=p123754 lab=_74517_/X }
C {devices/lab_pin.sym} 124900 -36670 0 0 {name=p123755 lab=_74520_/Y }
C {devices/lab_pin.sym} 125060 -36710 0 1 {name=p123756 lab=_74521_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -36710 0 0 {name=X_74521_ }
C {devices/lab_pin.sym} 124890 -36570 0 0 {name=p123757 lab=_85859_/CLK }
C {devices/lab_pin.sym} 124890 -36550 0 0 {name=p123758 lab=_48611_/Y }
C {devices/lab_pin.sym} 125070 -36570 0 1 {name=p123759 lab=_86507_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -36560 0 0 {name=X_86507_ }
C {devices/lab_pin.sym} 124900 -36450 0 0 {name=p123760 lab=_40324_/X }
C {devices/lab_pin.sym} 124900 -36410 0 0 {name=p123761 lab=_82853_/Q }
C {devices/lab_pin.sym} 124900 -36370 0 0 {name=p123762 lab=_40912_/X }
C {devices/lab_pin.sym} 125060 -36410 0 1 {name=p123763 lab=_40913_/X }
C {sky130_stdcells/o21a_4.sym} 124980 -36410 0 0 {name=X_40913_ }
C {devices/lab_pin.sym} 124890 -36270 0 0 {name=p123764 lab=_83721_/CLK }
C {devices/lab_pin.sym} 124890 -36250 0 0 {name=p123765 lab=_83719_/D }
C {devices/lab_pin.sym} 125070 -36270 0 1 {name=p123766 lab=_46936_/A }
C {sky130_stdcells/dfxtp_4.sym} 124980 -36260 0 0 {name=X_83719_ }
C {devices/lab_pin.sym} 124920 -36150 0 0 {name=p123767 lab=_71729_/A }
C {devices/lab_pin.sym} 124920 -36110 0 0 {name=p123768 lab=_71261_/B }
C {devices/lab_pin.sym} 124920 -36070 0 0 {name=p123769 lab=_71724_/X }
C {devices/lab_pin.sym} 125040 -36110 0 1 {name=p123770 lab=_71733_/Y }
C {sky130_stdcells/nand3_4.sym} 124980 -36110 0 0 {name=X_71733_ }
C {devices/lab_pin.sym} 124900 -35990 0 0 {name=p123771 lab=_59442_/X }
C {devices/lab_pin.sym} 124900 -35950 0 0 {name=p123772 lab=_83464_/Q }
C {devices/lab_pin.sym} 124900 -35910 0 0 {name=p123773 lab=_59454_/Y }
C {devices/lab_pin.sym} 125060 -35950 0 1 {name=p123774 lab=_59455_/X }
C {sky130_stdcells/o21a_4.sym} 124980 -35950 0 0 {name=X_59455_ }
C {devices/lab_pin.sym} 124940 -35810 0 0 {name=p123775 lab=_44714_/A }
C {devices/lab_pin.sym} 125020 -35810 0 1 {name=p123776 lab=_44681_/X }
C {sky130_stdcells/buf_2.sym} 124980 -35810 0 0 {name=X_44681_ }
C {devices/lab_pin.sym} 124940 -35690 0 0 {name=p123777 lab=_56666_/Y }
C {devices/lab_pin.sym} 125020 -35690 0 1 {name=p123778 lab=_56667_/Y }
C {sky130_stdcells/inv_2.sym} 124980 -35690 0 0 {name=X_56667_ }
C {devices/lab_pin.sym} 124890 -35570 0 0 {name=p123779 lab=_87487_/CLK }
C {devices/lab_pin.sym} 124890 -35550 0 0 {name=p123780 lab=_87487_/D }
C {devices/lab_pin.sym} 125070 -35570 0 1 {name=p123781 lab=_87487_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -35560 0 0 {name=X_87487_ }
C {devices/lab_pin.sym} 124940 -35430 0 0 {name=p123782 lab=_42059_/A }
C {devices/lab_pin.sym} 125020 -35430 0 1 {name=p123783 lab=_43047_/A }
C {sky130_stdcells/buf_2.sym} 124980 -35430 0 0 {name=X_41893_ }
C {devices/lab_pin.sym} 124920 -35320 0 0 {name=p123784 lab=_53844_/A }
C {devices/lab_pin.sym} 124920 -35280 0 0 {name=p123785 lab=_53879_/B }
C {devices/lab_pin.sym} 125040 -35300 0 1 {name=p123786 lab=_53879_/Y }
C {sky130_stdcells/nand2_4.sym} 124980 -35300 0 0 {name=X_53879_ }
C {devices/lab_pin.sym} 124890 -35170 0 0 {name=p123787 lab=_84329_/CLK }
C {devices/lab_pin.sym} 124890 -35150 0 0 {name=p123788 lab=_84699_/D }
C {devices/lab_pin.sym} 125070 -35170 0 1 {name=p123789 lab=_80475_/A }
C {sky130_stdcells/dfxtp_4.sym} 124980 -35160 0 0 {name=X_84699_ }
C {devices/lab_pin.sym} 124940 -35030 0 0 {name=p123790 lab=_52494_/B }
C {devices/lab_pin.sym} 125020 -35030 0 1 {name=p123791 lab=_50799_/B }
C {sky130_stdcells/buf_2.sym} 124980 -35030 0 0 {name=X_46420_ }
C {devices/lab_pin.sym} 124940 -34910 0 0 {name=p123792 lab=_58423_/A }
C {devices/lab_pin.sym} 125020 -34910 0 1 {name=p123793 lab=_58406_/X }
C {sky130_stdcells/buf_2.sym} 124980 -34910 0 0 {name=X_58406_ }
C {devices/lab_pin.sym} 124920 -34800 0 0 {name=p123794 lab=_77233_/A }
C {devices/lab_pin.sym} 124920 -34760 0 0 {name=p123795 lab=_82082_/D }
C {devices/lab_pin.sym} 125040 -34780 0 1 {name=p123796 lab=_77241_/A }
C {sky130_stdcells/nor2_4.sym} 124980 -34780 0 0 {name=X_77240_ }
C {devices/lab_pin.sym} 124940 -34650 0 0 {name=p123797 lab=_43632_/A }
C {devices/lab_pin.sym} 125020 -34650 0 1 {name=p123798 lab=_43632_/Y }
C {sky130_stdcells/inv_2.sym} 124980 -34650 0 0 {name=X_43632_ }
C {devices/lab_pin.sym} 124940 -34530 0 0 {name=p123799 lab=_55617_/X }
C {devices/lab_pin.sym} 125020 -34530 0 1 {name=p123800 lab=_55619_/A }
C {sky130_stdcells/buf_2.sym} 124980 -34530 0 0 {name=X_55618_ }
C {devices/lab_pin.sym} 124900 -34430 0 0 {name=p123801 lab=_83063_/Q }
C {devices/lab_pin.sym} 124900 -34390 0 0 {name=p123802 lab=_74441_/X }
C {devices/lab_pin.sym} 124900 -34350 0 0 {name=p123803 lab=_74451_/Y }
C {devices/lab_pin.sym} 125060 -34390 0 1 {name=p123804 lab=_74452_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -34390 0 0 {name=X_74452_ }
C {devices/lab_pin.sym} 124890 -34250 0 0 {name=p123805 lab=_85542_/CLK }
C {devices/lab_pin.sym} 124890 -34230 0 0 {name=p123806 lab=_86438_/D }
C {devices/lab_pin.sym} 125070 -34250 0 1 {name=p123807 lab=_65319_/B }
C {sky130_stdcells/dfxtp_4.sym} 124980 -34240 0 0 {name=X_86438_ }
C {devices/lab_pin.sym} 124900 -34130 0 0 {name=p123808 lab=_40817_/X }
C {devices/lab_pin.sym} 124900 -34090 0 0 {name=p123809 lab=_82290_/Q }
C {devices/lab_pin.sym} 124900 -34050 0 0 {name=p123810 lab=_40843_/X }
C {devices/lab_pin.sym} 125060 -34090 0 1 {name=p123811 lab=_40845_/A }
C {sky130_stdcells/o21ai_4.sym} 124980 -34090 0 0 {name=X_40844_ }
C {devices/lab_pin.sym} 124920 -33970 0 0 {name=p123812 lab=_71660_/A }
C {devices/lab_pin.sym} 124920 -33930 0 0 {name=p123813 lab=_71232_/B }
C {devices/lab_pin.sym} 124920 -33890 0 0 {name=p123814 lab=_71660_/C }
C {devices/lab_pin.sym} 125040 -33930 0 1 {name=p123815 lab=_71664_/Y }
C {sky130_stdcells/nand3_4.sym} 124980 -33930 0 0 {name=X_71664_ }
C {devices/lab_pin.sym} 124940 -33790 0 0 {name=p123816 lab=_84745_/Q }
C {devices/lab_pin.sym} 125020 -33790 0 1 {name=p123817 lab=_63103_/A }
C {sky130_stdcells/inv_2.sym} 124980 -33790 0 0 {name=X_59386_ }
C {devices/lab_pin.sym} 124900 -33710 0 0 {name=p123818 lab=_56629_/B }
C {devices/lab_pin.sym} 124900 -33670 0 0 {name=p123819 lab=_56580_/B }
C {devices/lab_pin.sym} 124900 -33630 0 0 {name=p123820 lab=_55552_/X }
C {devices/lab_pin.sym} 124900 -33590 0 0 {name=p123821 lab=_72652_/C }
C {devices/lab_pin.sym} 124900 -33560 0 0 {name=p123822 lab=_56597_/X }
C {devices/lab_pin.sym} 125060 -33630 0 1 {name=p123823 lab=_56598_/Y }
C {sky130_stdcells/a41oi_4.sym} 124980 -33630 0 0 {name=X_56598_ }
C {devices/lab_pin.sym} 124920 -33480 0 0 {name=p123824 lab=_73426_/A }
C {devices/lab_pin.sym} 124920 -33440 0 0 {name=p123825 lab=_86472_/Q }
C {devices/lab_pin.sym} 125040 -33460 0 1 {name=p123826 lab=_73403_/X }
C {sky130_stdcells/and2_4.sym} 124980 -33460 0 0 {name=X_73403_ }
C {devices/lab_pin.sym} 124940 -33330 0 0 {name=p123827 lab=_70786_/A }
C {devices/lab_pin.sym} 125020 -33330 0 1 {name=p123828 lab=_70722_/A }
C {sky130_stdcells/buf_2.sym} 124980 -33330 0 0 {name=X_70615_ }
C {devices/lab_pin.sym} 124900 -33230 0 0 {name=p123829 lab=_46348_/X }
C {devices/lab_pin.sym} 124900 -33190 0 0 {name=p123830 lab=_48967_/A }
C {devices/lab_pin.sym} 124900 -33150 0 0 {name=p123831 lab=_46350_/X }
C {devices/lab_pin.sym} 125060 -33190 0 1 {name=p123832 lab=_51278_/B }
C {sky130_stdcells/o21ai_4.sym} 124980 -33190 0 0 {name=X_46351_ }
C {devices/lab_pin.sym} 124900 -33070 0 0 {name=p123833 lab=_58334_/X }
C {devices/lab_pin.sym} 124900 -33030 0 0 {name=p123834 lab=_58335_/Y }
C {devices/lab_pin.sym} 124900 -32990 0 0 {name=p123835 lab=_58336_/Y }
C {devices/lab_pin.sym} 125060 -33030 0 1 {name=p123836 lab=_84875_/D }
C {sky130_stdcells/a21oi_4.sym} 124980 -33030 0 0 {name=X_58337_ }
C {devices/lab_pin.sym} 124940 -32890 0 0 {name=p123837 lab=_77171_/A }
C {devices/lab_pin.sym} 125020 -32890 0 1 {name=p123838 lab=_77172_/B }
C {sky130_stdcells/inv_2.sym} 124980 -32890 0 0 {name=X_77171_ }
C {devices/lab_pin.sym} 124940 -32770 0 0 {name=p123839 lab=_43760_/A }
C {devices/lab_pin.sym} 125020 -32770 0 1 {name=p123840 lab=_43563_/X }
C {sky130_stdcells/buf_2.sym} 124980 -32770 0 0 {name=X_43563_ }
C {devices/lab_pin.sym} 124920 -32660 0 0 {name=p123841 lab=_55549_/A }
C {devices/lab_pin.sym} 124920 -32620 0 0 {name=p123842 lab=_56614_/B }
C {devices/lab_pin.sym} 125040 -32640 0 1 {name=p123843 lab=_55549_/X }
C {sky130_stdcells/and2_4.sym} 124980 -32640 0 0 {name=X_55549_ }
C {devices/lab_pin.sym} 124890 -32510 0 0 {name=p123844 lab=_83721_/CLK }
C {devices/lab_pin.sym} 124890 -32490 0 0 {name=p123845 lab=_49538_/Y }
C {devices/lab_pin.sym} 125070 -32510 0 1 {name=p123846 lab=_86369_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -32500 0 0 {name=X_86369_ }
C {devices/lab_pin.sym} 124920 -32380 0 0 {name=p123847 lab=_72091_/X }
C {devices/lab_pin.sym} 124920 -32340 0 0 {name=p123848 lab=_74383_/B }
C {devices/lab_pin.sym} 125040 -32360 0 1 {name=p123849 lab=_74383_/Y }
C {sky130_stdcells/nand2_4.sym} 124980 -32360 0 0 {name=X_74383_ }
C {devices/lab_pin.sym} 124900 -32250 0 0 {name=p123850 lab=_40773_/X }
C {devices/lab_pin.sym} 124900 -32210 0 0 {name=p123851 lab=_82303_/Q }
C {devices/lab_pin.sym} 124900 -32170 0 0 {name=p123852 lab=_40774_/X }
C {devices/lab_pin.sym} 125060 -32210 0 1 {name=p123853 lab=_40776_/A }
C {sky130_stdcells/o21ai_4.sym} 124980 -32210 0 0 {name=X_40775_ }
C {devices/lab_pin.sym} 124920 -32090 0 0 {name=p123854 lab=_71570_/X }
C {devices/lab_pin.sym} 124920 -32050 0 0 {name=p123855 lab=_71590_/B }
C {devices/lab_pin.sym} 124920 -32010 0 0 {name=p123856 lab=_71598_/C }
C {devices/lab_pin.sym} 125040 -32050 0 1 {name=p123857 lab=_71595_/Y }
C {sky130_stdcells/nor3_4.sym} 124980 -32050 0 0 {name=X_71595_ }
C {devices/lab_pin.sym} 124900 -31930 0 0 {name=p123858 lab=_45299_/Y }
C {devices/lab_pin.sym} 124900 -31890 0 0 {name=p123859 lab=_45301_/Y }
C {devices/lab_pin.sym} 124900 -31850 0 0 {name=p123860 lab=_45287_/X }
C {devices/lab_pin.sym} 125060 -31890 0 1 {name=p123861 lab=_45302_/X }
C {sky130_stdcells/a21o_4.sym} 124980 -31890 0 0 {name=X_45302_ }
C {devices/lab_pin.sym} 124920 -31760 0 0 {name=p123862 lab=_81726_/D }
C {devices/lab_pin.sym} 124920 -31720 0 0 {name=p123863 lab=_76133_/B }
C {devices/lab_pin.sym} 125040 -31740 0 1 {name=p123864 lab=_76122_/X }
C {sky130_stdcells/xor2_4.sym} 124980 -31740 0 0 {name=X_76122_ }
C {devices/lab_pin.sym} 124890 -31610 0 0 {name=p123865 lab=_88108_/CLK }
C {devices/lab_pin.sym} 124890 -31590 0 0 {name=p123866 lab=_41913_/X }
C {devices/lab_pin.sym} 125070 -31610 0 1 {name=p123867 lab=_88108_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -31600 0 0 {name=X_88108_ }
C {devices/lab_pin.sym} 124940 -31470 0 0 {name=p123868 lab=_42514_/A }
C {devices/lab_pin.sym} 125020 -31470 0 1 {name=p123869 lab=_42514_/Y }
C {sky130_stdcells/inv_2.sym} 124980 -31470 0 0 {name=X_42514_ }
C {devices/lab_pin.sym} 124920 -31370 0 0 {name=p123870 lab=_52355_/A }
C {devices/lab_pin.sym} 124920 -31330 0 0 {name=p123871 lab=_48940_/B }
C {devices/lab_pin.sym} 124920 -31290 0 0 {name=p123872 lab=_48928_/C }
C {devices/lab_pin.sym} 125040 -31330 0 1 {name=p123873 lab=_49070_/X }
C {sky130_stdcells/and3_4.sym} 124980 -31330 0 0 {name=X_49070_ }
C {devices/lab_pin.sym} 124920 -31200 0 0 {name=p123874 lab=_73386_/A }
C {devices/lab_pin.sym} 124920 -31160 0 0 {name=p123875 lab=_86507_/Q }
C {devices/lab_pin.sym} 125040 -31180 0 1 {name=p123876 lab=_73334_/X }
C {sky130_stdcells/and2_4.sym} 124980 -31180 0 0 {name=X_73334_ }
C {devices/lab_pin.sym} 124940 -31050 0 0 {name=p123877 lab=_52440_/B }
C {devices/lab_pin.sym} 125020 -31050 0 1 {name=p123878 lab=_50744_/B }
C {sky130_stdcells/buf_2.sym} 124980 -31050 0 0 {name=X_46282_ }
C {devices/lab_pin.sym} 124900 -30950 0 0 {name=p123879 lab=_70533_/X }
C {devices/lab_pin.sym} 124900 -30910 0 0 {name=p123880 lab=_83752_/Q }
C {devices/lab_pin.sym} 124900 -30870 0 0 {name=p123881 lab=_70545_/Y }
C {devices/lab_pin.sym} 125060 -30910 0 1 {name=p123882 lab=_70546_/X }
C {sky130_stdcells/a21o_4.sym} 124980 -30910 0 0 {name=X_70546_ }
C {devices/lab_pin.sym} 124920 -30780 0 0 {name=p123883 lab=_58268_/A }
C {devices/lab_pin.sym} 124920 -30740 0 0 {name=p123884 lab=_58268_/B }
C {devices/lab_pin.sym} 125040 -30760 0 1 {name=p123885 lab=_58268_/Y }
C {sky130_stdcells/nand2_4.sym} 124980 -30760 0 0 {name=X_58268_ }
C {devices/lab_pin.sym} 124900 -30660 0 0 {name=p123886 lab=_41731_/X }
C {devices/lab_pin.sym} 124900 -30620 0 0 {name=p123887 lab=_43484_/X }
C {devices/lab_pin.sym} 124900 -30580 0 0 {name=p123888 lab=_87392_/Q }
C {devices/lab_pin.sym} 124900 -30540 0 0 {name=p123889 lab=_43485_/X }
C {devices/lab_pin.sym} 125060 -30600 0 1 {name=p123890 lab=_87392_/D }
C {sky130_stdcells/a2bb2o_4.sym} 124980 -30600 0 0 {name=X_43494_ }
C {devices/lab_pin.sym} 124900 -30470 0 0 {name=p123891 lab=_48017_/Y }
C {devices/lab_pin.sym} 124900 -30430 0 0 {name=p123892 lab=_48007_/X }
C {devices/lab_pin.sym} 124900 -30390 0 0 {name=p123893 lab=_48020_/X }
C {devices/lab_pin.sym} 125060 -30430 0 1 {name=p123894 lab=_86576_/D }
C {sky130_stdcells/a21oi_4.sym} 124980 -30430 0 0 {name=X_48021_ }
C {devices/lab_pin.sym} 124900 -30310 0 0 {name=p123895 lab=_45230_/X }
C {devices/lab_pin.sym} 124900 -30270 0 0 {name=p123896 lab=_45232_/Y }
C {devices/lab_pin.sym} 124900 -30230 0 0 {name=p123897 lab=_45200_/X }
C {devices/lab_pin.sym} 125060 -30270 0 1 {name=p123898 lab=_45233_/Y }
C {sky130_stdcells/a21oi_4.sym} 124980 -30270 0 0 {name=X_45233_ }
C {devices/lab_pin.sym} 124900 -30150 0 0 {name=p123899 lab=_57068_/X }
C {devices/lab_pin.sym} 124900 -30110 0 0 {name=p123900 lab=_57153_/B }
C {devices/lab_pin.sym} 124900 -30070 0 0 {name=p123901 lab=_57218_/Y }
C {devices/lab_pin.sym} 125060 -30110 0 1 {name=p123902 lab=_85061_/D }
C {sky130_stdcells/a21o_4.sym} 124980 -30110 0 0 {name=X_57219_ }
C {devices/lab_pin.sym} 124920 -29980 0 0 {name=p123903 lab=_76063_/A }
C {devices/lab_pin.sym} 124920 -29940 0 0 {name=p123904 lab=_76052_/Y }
C {devices/lab_pin.sym} 125040 -29960 0 1 {name=p123905 lab=_81748_/D }
C {sky130_stdcells/xor2_4.sym} 124980 -29960 0 0 {name=X_76053_ }
C {devices/lab_pin.sym} 124890 -29830 0 0 {name=p123906 lab=_88044_/CLK }
C {devices/lab_pin.sym} 124890 -29810 0 0 {name=p123907 lab=_88039_/D }
C {devices/lab_pin.sym} 125070 -29830 0 1 {name=p123908 lab=_88039_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -29820 0 0 {name=X_88039_ }
C {devices/lab_pin.sym} 124940 -29690 0 0 {name=p123909 lab=_40556_/A }
C {devices/lab_pin.sym} 125020 -29690 0 1 {name=p123910 lab=_51238_/B }
C {sky130_stdcells/buf_2.sym} 124980 -29690 0 0 {name=X_42445_ }
C {devices/lab_pin.sym} 124920 -29580 0 0 {name=p123911 lab=_73407_/A }
C {devices/lab_pin.sym} 124920 -29540 0 0 {name=p123912 lab=_86510_/Q }
C {devices/lab_pin.sym} 125040 -29560 0 1 {name=p123913 lab=_73265_/X }
C {sky130_stdcells/and2_4.sym} 124980 -29560 0 0 {name=X_73265_ }
C {devices/lab_pin.sym} 124920 -29450 0 0 {name=p123914 lab=_71706_/A }
C {devices/lab_pin.sym} 124920 -29410 0 0 {name=p123915 lab=_70483_/B }
C {devices/lab_pin.sym} 124920 -29370 0 0 {name=p123916 lab=_70476_/X }
C {devices/lab_pin.sym} 125040 -29410 0 1 {name=p123917 lab=_70477_/X }
C {sky130_stdcells/and3_4.sym} 124980 -29410 0 0 {name=X_70477_ }
C {devices/lab_pin.sym} 124900 -29290 0 0 {name=p123918 lab=_58191_/X }
C {devices/lab_pin.sym} 124900 -29250 0 0 {name=p123919 lab=_58196_/Y }
C {devices/lab_pin.sym} 124900 -29210 0 0 {name=p123920 lab=_58198_/Y }
C {devices/lab_pin.sym} 125060 -29250 0 1 {name=p123921 lab=_58199_/Y }
C {sky130_stdcells/a21oi_4.sym} 124980 -29250 0 0 {name=X_58199_ }
C {devices/lab_pin.sym} 124900 -29130 0 0 {name=p123922 lab=_74995_/Y }
C {devices/lab_pin.sym} 124900 -29090 0 0 {name=p123923 lab=_75002_/Y }
C {devices/lab_pin.sym} 124900 -29050 0 0 {name=p123924 lab=_75003_/Y }
C {devices/lab_pin.sym} 125060 -29090 0 1 {name=p123925 lab=_75004_/X }
C {sky130_stdcells/o21a_4.sym} 124980 -29090 0 0 {name=X_75004_ }
C {devices/lab_pin.sym} 124900 -28970 0 0 {name=p123926 lab=_72166_/X }
C {devices/lab_pin.sym} 124900 -28930 0 0 {name=p123927 lab=_85369_/Q }
C {devices/lab_pin.sym} 124900 -28890 0 0 {name=p123928 lab=_72215_/X }
C {devices/lab_pin.sym} 125060 -28930 0 1 {name=p123929 lab=_72216_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -28930 0 0 {name=X_72216_ }
C {devices/lab_pin.sym} 124920 -28810 0 0 {name=p123930 lab=_60244_/A }
C {devices/lab_pin.sym} 124920 -28770 0 0 {name=p123931 lab=_60214_/B }
C {devices/lab_pin.sym} 124920 -28730 0 0 {name=p123932 lab=_79872_/A }
C {devices/lab_pin.sym} 125040 -28770 0 1 {name=p123933 lab=_60230_/Y }
C {sky130_stdcells/nor3_4.sym} 124980 -28770 0 0 {name=X_60230_ }
C {devices/lab_pin.sym} 124900 -28650 0 0 {name=p123934 lab=_56510_/C }
C {devices/lab_pin.sym} 124900 -28610 0 0 {name=p123935 lab=_45134_/X }
C {devices/lab_pin.sym} 124900 -28570 0 0 {name=p123936 lab=_45116_/X }
C {devices/lab_pin.sym} 125060 -28610 0 1 {name=p123937 lab=_45164_/X }
C {sky130_stdcells/o21a_4.sym} 124980 -28610 0 0 {name=X_45164_ }
C {devices/lab_pin.sym} 124900 -28500 0 0 {name=p123938 lab=_41778_/X }
C {devices/lab_pin.sym} 124900 -28460 0 0 {name=p123939 lab=_42374_/X }
C {devices/lab_pin.sym} 124900 -28420 0 0 {name=p123940 lab=_87895_/Q }
C {devices/lab_pin.sym} 124900 -28380 0 0 {name=p123941 lab=_42375_/X }
C {devices/lab_pin.sym} 125060 -28440 0 1 {name=p123942 lab=_87895_/D }
C {sky130_stdcells/a2bb2o_4.sym} 124980 -28440 0 0 {name=X_42376_ }
C {devices/lab_pin.sym} 124920 -28300 0 0 {name=p123943 lab=_73196_/A }
C {devices/lab_pin.sym} 124920 -28260 0 0 {name=p123944 lab=_73196_/B }
C {devices/lab_pin.sym} 125040 -28280 0 1 {name=p123945 lab=_73196_/Y }
C {sky130_stdcells/nor2_4.sym} 124980 -28280 0 0 {name=X_73196_ }
C {devices/lab_pin.sym} 124940 -28150 0 0 {name=p123946 lab=_44115_/A }
C {devices/lab_pin.sym} 125020 -28150 0 1 {name=p123947 lab=_44118_/B }
C {sky130_stdcells/buf_2.sym} 124980 -28150 0 0 {name=X_44115_ }
C {devices/lab_pin.sym} 124900 -28050 0 0 {name=p123948 lab=_79809_/Y }
C {devices/lab_pin.sym} 124900 -28010 0 0 {name=p123949 lab=_79793_/B }
C {devices/lab_pin.sym} 124900 -27970 0 0 {name=p123950 lab=_79811_/X }
C {devices/lab_pin.sym} 125060 -28010 0 1 {name=p123951 lab=_79812_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -28010 0 0 {name=X_79812_ }
C {devices/lab_pin.sym} 124900 -27890 0 0 {name=p123952 lab=_41324_/X }
C {devices/lab_pin.sym} 124900 -27850 0 0 {name=p123953 lab=_41674_/A }
C {devices/lab_pin.sym} 124900 -27810 0 0 {name=p123954 lab=_41326_/X }
C {devices/lab_pin.sym} 125060 -27850 0 1 {name=p123955 lab=_41327_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -27850 0 0 {name=X_41327_ }
C {devices/lab_pin.sym} 124940 -27710 0 0 {name=p123956 lab=_60222_/C }
C {devices/lab_pin.sym} 125020 -27710 0 1 {name=p123957 lab=_61287_/A }
C {sky130_stdcells/buf_2.sym} 124980 -27710 0 0 {name=X_60161_ }
C {devices/lab_pin.sym} 124900 -27610 0 0 {name=p123958 lab=_72123_/X }
C {devices/lab_pin.sym} 124900 -27570 0 0 {name=p123959 lab=_85695_/Q }
C {devices/lab_pin.sym} 124900 -27530 0 0 {name=p123960 lab=_72146_/X }
C {devices/lab_pin.sym} 125060 -27570 0 1 {name=p123961 lab=_72147_/X }
C {sky130_stdcells/o21a_4.sym} 124980 -27570 0 0 {name=X_72147_ }
C {devices/lab_pin.sym} 124900 -27450 0 0 {name=p123962 lab=_86289_/Q }
C {devices/lab_pin.sym} 124900 -27410 0 0 {name=p123963 lab=_49960_/X }
C {devices/lab_pin.sym} 124900 -27370 0 0 {name=p123964 lab=_49971_/Y }
C {devices/lab_pin.sym} 125060 -27410 0 1 {name=p123965 lab=_49972_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -27410 0 0 {name=X_49972_ }
C {devices/lab_pin.sym} 124920 -27280 0 0 {name=p123966 lab=_45095_/A }
C {devices/lab_pin.sym} 124920 -27240 0 0 {name=p123967 lab=_45067_/B }
C {devices/lab_pin.sym} 125040 -27260 0 1 {name=p123968 lab=_45095_/Y }
C {sky130_stdcells/nand2_4.sym} 124980 -27260 0 0 {name=X_45095_ }
C {devices/lab_pin.sym} 124900 -27150 0 0 {name=p123969 lab=_86461_/Q }
C {devices/lab_pin.sym} 124900 -27110 0 0 {name=p123970 lab=_48896_/X }
C {devices/lab_pin.sym} 124900 -27070 0 0 {name=p123971 lab=_48922_/Y }
C {devices/lab_pin.sym} 125060 -27110 0 1 {name=p123972 lab=_48923_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -27110 0 0 {name=X_48923_ }
C {devices/lab_pin.sym} 124940 -26970 0 0 {name=p123973 lab=_44045_/X }
C {devices/lab_pin.sym} 125020 -26970 0 1 {name=p123974 lab=_44046_/X }
C {sky130_stdcells/buf_2.sym} 124980 -26970 0 0 {name=X_44046_ }
C {devices/lab_pin.sym} 124920 -26860 0 0 {name=p123975 lab=_79741_/X }
C {devices/lab_pin.sym} 124920 -26820 0 0 {name=p123976 lab=_79742_/X }
C {devices/lab_pin.sym} 125040 -26840 0 1 {name=p123977 lab=_79743_/Y }
C {sky130_stdcells/xnor2_4.sym} 124980 -26840 0 0 {name=X_79743_ }
C {devices/lab_pin.sym} 124900 -26730 0 0 {name=p123978 lab=_41255_/X }
C {devices/lab_pin.sym} 124900 -26690 0 0 {name=p123979 lab=_40732_/A }
C {devices/lab_pin.sym} 124900 -26650 0 0 {name=p123980 lab=_41257_/X }
C {devices/lab_pin.sym} 125060 -26690 0 1 {name=p123981 lab=_41259_/A }
C {sky130_stdcells/o21ai_4.sym} 124980 -26690 0 0 {name=X_41258_ }
C {devices/lab_pin.sym} 124900 -26570 0 0 {name=p123982 lab=_83289_/Q }
C {devices/lab_pin.sym} 124900 -26530 0 0 {name=p123983 lab=_72051_/X }
C {devices/lab_pin.sym} 124900 -26490 0 0 {name=p123984 lab=_72077_/Y }
C {devices/lab_pin.sym} 125060 -26530 0 1 {name=p123985 lab=_72078_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -26530 0 0 {name=X_72078_ }
C {devices/lab_pin.sym} 124940 -26390 0 0 {name=p123986 lab=_81601_/Q }
C {devices/lab_pin.sym} 125020 -26390 0 1 {name=p123987 lab=_76955_/Y }
C {sky130_stdcells/inv_2.sym} 124980 -26390 0 0 {name=X_76955_ }
C {devices/lab_pin.sym} 124920 -26300 0 0 {name=p123988 lab=_60042_/D }
C {devices/lab_pin.sym} 124920 -26260 0 0 {name=p123989 lab=_60092_/B }
C {devices/lab_pin.sym} 124920 -26220 0 0 {name=p123990 lab=_60091_/Y }
C {devices/lab_pin.sym} 124920 -26180 0 0 {name=p123991 lab=_60058_/Y }
C {devices/lab_pin.sym} 125040 -26240 0 1 {name=p123992 lab=_60092_/Y }
C {sky130_stdcells/nand4_4.sym} 124980 -26240 0 0 {name=X_60092_ }
C {devices/lab_pin.sym} 124920 -26120 0 0 {name=p123993 lab=_64343_/B }
C {devices/lab_pin.sym} 124920 -26080 0 0 {name=p123994 lab=_63920_/B }
C {devices/lab_pin.sym} 124920 -26040 0 0 {name=p123995 lab=_63951_/C }
C {devices/lab_pin.sym} 124920 -26000 0 0 {name=p123996 lab=_63920_/D }
C {devices/lab_pin.sym} 125040 -26060 0 1 {name=p123997 lab=_63920_/Y }
C {sky130_stdcells/nand4_4.sym} 124980 -26060 0 0 {name=X_63920_ }
C {devices/lab_pin.sym} 124920 -25920 0 0 {name=p123998 lab=_61223_/C }
C {devices/lab_pin.sym} 124920 -25880 0 0 {name=p123999 lab=_62864_/C }
C {devices/lab_pin.sym} 125040 -25900 0 1 {name=p124000 lab=_75906_/X }
C {sky130_stdcells/xor2_4.sym} 124980 -25900 0 0 {name=X_75906_ }
C {devices/lab_pin.sym} 124940 -25770 0 0 {name=p124001 lab=_70994_/A }
C {devices/lab_pin.sym} 125020 -25770 0 1 {name=p124002 lab=_71175_/A }
C {sky130_stdcells/buf_2.sym} 124980 -25770 0 0 {name=X_71029_ }
C {devices/lab_pin.sym} 124940 -25650 0 0 {name=p124003 lab=clkbuf_4_4_1_CLK/A }
C {devices/lab_pin.sym} 125020 -25650 0 1 {name=p124004 lab=clkbuf_4_4_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 124980 -25650 0 0 {name=Xclkbuf_4_4_1_CLK }
C {devices/lab_pin.sym} 124920 -25550 0 0 {name=p124005 lab=_48667_/A }
C {devices/lab_pin.sym} 124920 -25510 0 0 {name=p124006 lab=_48849_/B }
C {devices/lab_pin.sym} 124920 -25470 0 0 {name=p124007 lab=_48854_/C }
C {devices/lab_pin.sym} 125040 -25510 0 1 {name=p124008 lab=_48854_/X }
C {sky130_stdcells/and3_4.sym} 124980 -25510 0 0 {name=X_48854_ }
C {devices/lab_pin.sym} 124920 -25380 0 0 {name=p124009 lab=_79660_/A }
C {devices/lab_pin.sym} 124920 -25340 0 0 {name=p124010 lab=_79659_/Y }
C {devices/lab_pin.sym} 125040 -25360 0 1 {name=p124011 lab=_79674_/X }
C {sky130_stdcells/or2_4.sym} 124980 -25360 0 0 {name=X_79674_ }
C {devices/lab_pin.sym} 124940 -25230 0 0 {name=p124012 lab=_41189_/A }
C {devices/lab_pin.sym} 125020 -25230 0 1 {name=p124013 lab=_41189_/X }
C {sky130_stdcells/buf_2.sym} 124980 -25230 0 0 {name=X_41189_ }
C {devices/lab_pin.sym} 124940 -25110 0 0 {name=p124014 lab=_76885_/X }
C {devices/lab_pin.sym} 125020 -25110 0 1 {name=p124015 lab=_76888_/B }
C {sky130_stdcells/inv_2.sym} 124980 -25110 0 0 {name=X_76886_ }
C {devices/lab_pin.sym} 124900 -25010 0 0 {name=p124016 lab=_47800_/Y }
C {devices/lab_pin.sym} 124900 -24970 0 0 {name=p124017 lab=_47791_/X }
C {devices/lab_pin.sym} 124900 -24930 0 0 {name=p124018 lab=_47804_/X }
C {devices/lab_pin.sym} 125060 -24970 0 1 {name=p124019 lab=_86596_/D }
C {sky130_stdcells/a21oi_4.sym} 124980 -24970 0 0 {name=X_47805_ }
C {devices/lab_pin.sym} 124900 -24850 0 0 {name=p124020 lab=_78605_/Y }
C {devices/lab_pin.sym} 124900 -24810 0 0 {name=p124021 lab=_78640_/B }
C {devices/lab_pin.sym} 124900 -24770 0 0 {name=p124022 lab=_78640_/A }
C {devices/lab_pin.sym} 125060 -24810 0 1 {name=p124023 lab=_78625_/Y }
C {sky130_stdcells/a21boi_4.sym} 124980 -24810 0 0 {name=X_78625_ }
C {devices/lab_pin.sym} 124900 -24690 0 0 {name=p124024 lab=_63847_/X }
C {devices/lab_pin.sym} 124900 -24650 0 0 {name=p124025 lab=_63833_/X }
C {devices/lab_pin.sym} 124900 -24610 0 0 {name=p124026 lab=_63850_/Y }
C {devices/lab_pin.sym} 125060 -24650 0 1 {name=p124027 lab=_63851_/Y }
C {sky130_stdcells/a21oi_4.sym} 124980 -24650 0 0 {name=X_63851_ }
C {devices/lab_pin.sym} 124920 -24520 0 0 {name=p124028 lab=_81022_/Q }
C {devices/lab_pin.sym} 124920 -24480 0 0 {name=p124029 lab=_80894_/D }
C {devices/lab_pin.sym} 125040 -24500 0 1 {name=p124030 lab=_80990_/D }
C {sky130_stdcells/xor2_4.sym} 124980 -24500 0 0 {name=X_75837_ }
C {devices/lab_pin.sym} 124940 -24370 0 0 {name=p124031 lab=_48840_/A }
C {devices/lab_pin.sym} 125020 -24370 0 1 {name=p124032 lab=_48785_/X }
C {sky130_stdcells/buf_2.sym} 124980 -24370 0 0 {name=X_48785_ }
C {devices/lab_pin.sym} 124940 -24250 0 0 {name=p124033 lab=_45996_/Y }
C {devices/lab_pin.sym} 125020 -24250 0 1 {name=p124034 lab=_86823_/D }
C {sky130_stdcells/inv_2.sym} 124980 -24250 0 0 {name=X_45997_ }
C {devices/lab_pin.sym} 124920 -24160 0 0 {name=p124035 lab=_61481_/X }
C {devices/lab_pin.sym} 124920 -24120 0 0 {name=p124036 lab=_62834_/B }
C {devices/lab_pin.sym} 124920 -24080 0 0 {name=p124037 lab=_62801_/X }
C {devices/lab_pin.sym} 124920 -24040 0 0 {name=p124038 lab=_62834_/D }
C {devices/lab_pin.sym} 125040 -24100 0 1 {name=p124039 lab=_62802_/Y }
C {sky130_stdcells/nand4_4.sym} 124980 -24100 0 0 {name=X_62802_ }
C {devices/lab_pin.sym} 124900 -23970 0 0 {name=p124040 lab=_72384_/A }
C {devices/lab_pin.sym} 124900 -23930 0 0 {name=p124041 lab=_47714_/X }
C {devices/lab_pin.sym} 124900 -23890 0 0 {name=p124042 lab=_47735_/Y }
C {devices/lab_pin.sym} 125060 -23930 0 1 {name=p124043 lab=_47736_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -23930 0 0 {name=X_47736_ }
C {devices/lab_pin.sym} 124940 -23790 0 0 {name=p124044 lab=_68392_/A }
C {devices/lab_pin.sym} 125020 -23790 0 1 {name=p124045 lab=_69162_/A }
C {sky130_stdcells/buf_2.sym} 124980 -23790 0 0 {name=X_66570_ }
C {devices/lab_pin.sym} 124940 -23670 0 0 {name=p124046 lab=_78555_/Y }
C {devices/lab_pin.sym} 125020 -23670 0 1 {name=p124047 lab=_78556_/Y }
C {sky130_stdcells/inv_2.sym} 124980 -23670 0 0 {name=X_78556_ }
C {devices/lab_pin.sym} 124900 -23570 0 0 {name=p124048 lab=_44944_/Y }
C {devices/lab_pin.sym} 124900 -23530 0 0 {name=p124049 lab=_44947_/Y }
C {devices/lab_pin.sym} 124900 -23490 0 0 {name=p124050 lab=_44889_/X }
C {devices/lab_pin.sym} 125060 -23530 0 1 {name=p124051 lab=_44948_/X }
C {sky130_stdcells/a21o_4.sym} 124980 -23530 0 0 {name=X_44948_ }
C {devices/lab_pin.sym} 124920 -23410 0 0 {name=p124052 lab=_63765_/A }
C {devices/lab_pin.sym} 124920 -23370 0 0 {name=p124053 lab=_63389_/A }
C {devices/lab_pin.sym} 124920 -23330 0 0 {name=p124054 lab=_63765_/C }
C {devices/lab_pin.sym} 125040 -23370 0 1 {name=p124055 lab=_63782_/X }
C {sky130_stdcells/and3_4.sym} 124980 -23370 0 0 {name=X_63782_ }
C {devices/lab_pin.sym} 124940 -23230 0 0 {name=p124056 lab=_80920_/Q }
C {devices/lab_pin.sym} 125020 -23230 0 1 {name=p124057 lab=_75768_/Y }
C {sky130_stdcells/inv_2.sym} 124980 -23230 0 0 {name=X_75768_ }
C {devices/lab_pin.sym} 124920 -23130 0 0 {name=p124058 lab=_60994_/A }
C {devices/lab_pin.sym} 124920 -23090 0 0 {name=p124059 lab=_60994_/B }
C {devices/lab_pin.sym} 124920 -23050 0 0 {name=p124060 lab=_60993_/B }
C {devices/lab_pin.sym} 125040 -23090 0 1 {name=p124061 lab=_60994_/Y }
C {sky130_stdcells/nand3_4.sym} 124980 -23090 0 0 {name=X_60994_ }
C {devices/lab_pin.sym} 124920 -22960 0 0 {name=p124062 lab=_65285_/A }
C {devices/lab_pin.sym} 124920 -22920 0 0 {name=p124063 lab=_65521_/B }
C {devices/lab_pin.sym} 125040 -22940 0 1 {name=p124064 lab=_65521_/X }
C {sky130_stdcells/and2_4.sym} 124980 -22940 0 0 {name=X_65521_ }
C {devices/lab_pin.sym} 124920 -22820 0 0 {name=p124065 lab=_77507_/A }
C {devices/lab_pin.sym} 124920 -22780 0 0 {name=p124066 lab=_82101_/D }
C {devices/lab_pin.sym} 125040 -22800 0 1 {name=p124067 lab=_77508_/A }
C {sky130_stdcells/nand2_4.sym} 124980 -22800 0 0 {name=X_77507_ }
C {devices/lab_pin.sym} 124940 -22670 0 0 {name=p124068 lab=_62671_/A }
C {devices/lab_pin.sym} 125020 -22670 0 1 {name=p124069 lab=_62766_/A }
C {sky130_stdcells/buf_2.sym} 124980 -22670 0 0 {name=X_62733_ }
C {devices/lab_pin.sym} 124940 -22550 0 0 {name=p124070 lab=_70732_/X }
C {devices/lab_pin.sym} 125020 -22550 0 1 {name=p124071 lab=_74804_/D }
C {sky130_stdcells/buf_2.sym} 124980 -22550 0 0 {name=X_74719_ }
C {devices/lab_pin.sym} 124940 -22430 0 0 {name=p124072 lab=_47620_/X }
C {devices/lab_pin.sym} 125020 -22430 0 1 {name=p124073 lab=_47696_/A }
C {sky130_stdcells/buf_2.sym} 124980 -22430 0 0 {name=X_47667_ }
C {devices/lab_pin.sym} 124940 -22310 0 0 {name=p124074 lab=_82799_/Q }
C {devices/lab_pin.sym} 125020 -22310 0 1 {name=p124075 lab=_78487_/Y }
C {sky130_stdcells/inv_2.sym} 124980 -22310 0 0 {name=X_78487_ }
C {devices/lab_pin.sym} 124940 -22190 0 0 {name=p124076 lab=_44932_/A }
C {devices/lab_pin.sym} 125020 -22190 0 1 {name=p124077 lab=_45827_/B }
C {sky130_stdcells/buf_2.sym} 124980 -22190 0 0 {name=X_44879_ }
C {devices/lab_pin.sym} 124940 -22070 0 0 {name=p124078 lab=_75688_/Y }
C {devices/lab_pin.sym} 125020 -22070 0 1 {name=p124079 lab=_80783_/D }
C {sky130_stdcells/inv_2.sym} 124980 -22070 0 0 {name=X_75699_ }
C {devices/lab_pin.sym} 124940 -21950 0 0 {name=p124080 lab=_49406_/A }
C {devices/lab_pin.sym} 125020 -21950 0 1 {name=p124081 lab=_49407_/A }
C {sky130_stdcells/buf_2.sym} 124980 -21950 0 0 {name=X_49406_ }
C {devices/lab_pin.sym} 124900 -21850 0 0 {name=p124082 lab=_67489_/X }
C {devices/lab_pin.sym} 124900 -21810 0 0 {name=p124083 lab=_67491_/X }
C {devices/lab_pin.sym} 124900 -21770 0 0 {name=p124084 lab=_68239_/X }
C {devices/lab_pin.sym} 125060 -21810 0 1 {name=p124085 lab=_68240_/Y }
C {sky130_stdcells/a21oi_4.sym} 124980 -21810 0 0 {name=X_68240_ }
C {devices/lab_pin.sym} 124940 -21670 0 0 {name=p124086 lab=_82977_/Q }
C {devices/lab_pin.sym} 125020 -21670 0 1 {name=p124087 lab=_46619_/A }
C {sky130_stdcells/inv_2.sym} 124980 -21670 0 0 {name=X_46618_ }
C {devices/lab_pin.sym} 124900 -21580 0 0 {name=p124088 lab=_65350_/X }
C {devices/lab_pin.sym} 124900 -21540 0 0 {name=p124089 lab=_86207_/Q }
C {devices/lab_pin.sym} 124900 -21500 0 0 {name=p124090 lab=_65400_/X }
C {devices/lab_pin.sym} 124900 -21460 0 0 {name=p124091 lab=_65451_/X }
C {devices/lab_pin.sym} 125060 -21520 0 1 {name=p124092 lab=_65452_/X }
C {sky130_stdcells/a211o_4.sym} 124980 -21520 0 0 {name=X_65452_ }
C {devices/lab_pin.sym} 124900 -21390 0 0 {name=p124093 lab=_77418_/X }
C {devices/lab_pin.sym} 124900 -21350 0 0 {name=p124094 lab=_77436_/Y }
C {devices/lab_pin.sym} 124900 -21310 0 0 {name=p124095 lab=_77437_/Y }
C {devices/lab_pin.sym} 125060 -21350 0 1 {name=p124096 lab=_77438_/Y }
C {sky130_stdcells/a21oi_4.sym} 124980 -21350 0 0 {name=X_77438_ }
C {devices/lab_pin.sym} 124920 -21240 0 0 {name=p124097 lab=_61330_/X }
C {devices/lab_pin.sym} 124920 -21200 0 0 {name=p124098 lab=_62664_/B }
C {devices/lab_pin.sym} 124920 -21160 0 0 {name=p124099 lab=_60324_/A }
C {devices/lab_pin.sym} 124920 -21120 0 0 {name=p124100 lab=_62664_/D }
C {devices/lab_pin.sym} 125040 -21180 0 1 {name=p124101 lab=_62664_/Y }
C {sky130_stdcells/nand4_4.sym} 124980 -21180 0 0 {name=X_62664_ }
C {devices/lab_pin.sym} 124940 -21030 0 0 {name=p124102 lab=_47598_/A }
C {devices/lab_pin.sym} 125020 -21030 0 1 {name=p124103 lab=_53141_/B }
C {sky130_stdcells/buf_2.sym} 124980 -21030 0 0 {name=X_47598_ }
C {devices/lab_pin.sym} 124920 -20930 0 0 {name=p124104 lab=_64402_/X }
C {devices/lab_pin.sym} 124920 -20890 0 0 {name=p124105 lab=_64379_/B }
C {devices/lab_pin.sym} 124920 -20850 0 0 {name=p124106 lab=_84841_/Q }
C {devices/lab_pin.sym} 125040 -20890 0 1 {name=p124107 lab=_64403_/X }
C {sky130_stdcells/and3_4.sym} 124980 -20890 0 0 {name=X_64403_ }
C {devices/lab_pin.sym} 124900 -20770 0 0 {name=p124108 lab=_65279_/B }
C {devices/lab_pin.sym} 124900 -20730 0 0 {name=p124109 lab=_49334_/X }
C {devices/lab_pin.sym} 124900 -20690 0 0 {name=p124110 lab=_49336_/Y }
C {devices/lab_pin.sym} 125060 -20730 0 1 {name=p124111 lab=_49337_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -20730 0 0 {name=X_49337_ }
C {devices/lab_pin.sym} 124920 -20610 0 0 {name=p124112 lab=_61634_/A }
C {devices/lab_pin.sym} 124920 -20570 0 0 {name=p124113 lab=_61634_/B }
C {devices/lab_pin.sym} 124920 -20530 0 0 {name=p124114 lab=_79134_/B }
C {devices/lab_pin.sym} 125040 -20570 0 1 {name=p124115 lab=_61615_/Y }
C {sky130_stdcells/nor3_4.sym} 124980 -20570 0 0 {name=X_61615_ }
C {devices/lab_pin.sym} 124900 -20460 0 0 {name=p124116 lab=_68144_/X }
C {devices/lab_pin.sym} 124900 -20420 0 0 {name=p124117 lab=_67054_/Y }
C {devices/lab_pin.sym} 124900 -20380 0 0 {name=p124118 lab=_68168_/X }
C {devices/lab_pin.sym} 124900 -20340 0 0 {name=p124119 lab=_68170_/Y }
C {devices/lab_pin.sym} 125060 -20400 0 1 {name=p124120 lab=_68171_/X }
C {sky130_stdcells/a211o_4.sym} 124980 -20400 0 0 {name=X_68171_ }
C {devices/lab_pin.sym} 124920 -20260 0 0 {name=p124121 lab=_82919_/Q }
C {devices/lab_pin.sym} 124920 -20220 0 0 {name=p124122 lab=_46527_/X }
C {devices/lab_pin.sym} 125040 -20240 0 1 {name=p124123 lab=_46549_/X }
C {sky130_stdcells/or2_4.sym} 124980 -20240 0 0 {name=X_46549_ }
C {devices/lab_pin.sym} 124920 -20130 0 0 {name=p124124 lab=_65379_/X }
C {devices/lab_pin.sym} 124920 -20090 0 0 {name=p124125 lab=_65548_/B }
C {devices/lab_pin.sym} 124920 -20050 0 0 {name=p124126 lab=_65383_/C }
C {devices/lab_pin.sym} 125040 -20090 0 1 {name=p124127 lab=_65395_/A }
C {sky130_stdcells/nand3_4.sym} 124980 -20090 0 0 {name=X_65383_ }
C {devices/lab_pin.sym} 124920 -19960 0 0 {name=p124128 lab=_77387_/A }
C {devices/lab_pin.sym} 124920 -19920 0 0 {name=p124129 lab=_77387_/B }
C {devices/lab_pin.sym} 125040 -19940 0 1 {name=p124130 lab=_77369_/X }
C {sky130_stdcells/xor2_4.sym} 124980 -19940 0 0 {name=X_77369_ }
C {devices/lab_pin.sym} 124900 -19830 0 0 {name=p124131 lab=_62592_/Y }
C {devices/lab_pin.sym} 124900 -19790 0 0 {name=p124132 lab=_62593_/X }
C {devices/lab_pin.sym} 124900 -19750 0 0 {name=p124133 lab=_62594_/Y }
C {devices/lab_pin.sym} 125060 -19790 0 1 {name=p124134 lab=_84398_/D }
C {sky130_stdcells/a21oi_4.sym} 124980 -19790 0 0 {name=X_62595_ }
C {devices/lab_pin.sym} 124940 -19650 0 0 {name=p124135 lab=_66879_/A }
C {devices/lab_pin.sym} 125020 -19650 0 1 {name=p124136 lab=_67122_/X }
C {sky130_stdcells/buf_2.sym} 124980 -19650 0 0 {name=X_67122_ }
C {devices/lab_pin.sym} 124920 -19540 0 0 {name=p124137 lab=_79104_/Y }
C {devices/lab_pin.sym} 124920 -19500 0 0 {name=p124138 lab=_79108_/B }
C {devices/lab_pin.sym} 125040 -19520 0 1 {name=p124139 lab=_79110_/A }
C {sky130_stdcells/nand2_4.sym} 124980 -19520 0 0 {name=X_79108_ }
C {devices/lab_pin.sym} 124920 -19410 0 0 {name=p124140 lab=_64319_/X }
C {devices/lab_pin.sym} 124920 -19370 0 0 {name=p124141 lab=_64334_/B }
C {devices/lab_pin.sym} 124920 -19330 0 0 {name=p124142 lab=_64333_/X }
C {devices/lab_pin.sym} 125040 -19370 0 1 {name=p124143 lab=_64334_/X }
C {sky130_stdcells/and3_4.sym} 124980 -19370 0 0 {name=X_64334_ }
C {devices/lab_pin.sym} 124900 -19250 0 0 {name=p124144 lab=_49266_/Y }
C {devices/lab_pin.sym} 124900 -19210 0 0 {name=p124145 lab=_49247_/X }
C {devices/lab_pin.sym} 124900 -19170 0 0 {name=p124146 lab=_49267_/Y }
C {devices/lab_pin.sym} 125060 -19210 0 1 {name=p124147 lab=_49268_/Y }
C {sky130_stdcells/a21boi_4.sym} 124980 -19210 0 0 {name=X_49268_ }
C {devices/lab_pin.sym} 124920 -19090 0 0 {name=p124148 lab=_61546_/A }
C {devices/lab_pin.sym} 124920 -19050 0 0 {name=p124149 lab=_61546_/B }
C {devices/lab_pin.sym} 124920 -19010 0 0 {name=p124150 lab=_61546_/C }
C {devices/lab_pin.sym} 125040 -19050 0 1 {name=p124151 lab=_61546_/Y }
C {sky130_stdcells/nor3_4.sym} 124980 -19050 0 0 {name=X_61546_ }
C {devices/lab_pin.sym} 124920 -18920 0 0 {name=p124152 lab=_80378_/X }
C {devices/lab_pin.sym} 124920 -18880 0 0 {name=p124153 lab=_80380_/B }
C {devices/lab_pin.sym} 125040 -18900 0 1 {name=p124154 lab=_80394_/B }
C {sky130_stdcells/xnor2_4.sym} 124980 -18900 0 0 {name=X_80380_ }
C {devices/lab_pin.sym} 124940 -18770 0 0 {name=p124155 lab=clkbuf_9_231_0_CLK/X }
C {devices/lab_pin.sym} 125020 -18770 0 1 {name=p124156 lab=_85969_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 124980 -18770 0 0 {name=Xclkbuf_10_462_0_CLK }
C {devices/lab_pin.sym} 124920 -18660 0 0 {name=p124157 lab=_48204_/X }
C {devices/lab_pin.sym} 124920 -18620 0 0 {name=p124158 lab=_47924_/B }
C {devices/lab_pin.sym} 125040 -18640 0 1 {name=p124159 lab=_48219_/Y }
C {sky130_stdcells/nand2_4.sym} 124980 -18640 0 0 {name=X_48219_ }
C {devices/lab_pin.sym} 124900 -18540 0 0 {name=p124160 lab=_87115_/Q }
C {devices/lab_pin.sym} 124900 -18500 0 0 {name=p124161 lab=_66954_/X }
C {devices/lab_pin.sym} 124900 -18460 0 0 {name=p124162 lab=_66955_/X }
C {devices/lab_pin.sym} 124900 -18420 0 0 {name=p124163 lab=_67052_/X }
C {devices/lab_pin.sym} 125060 -18480 0 1 {name=p124164 lab=_67053_/X }
C {sky130_stdcells/a211o_4.sym} 124980 -18480 0 0 {name=X_67053_ }
C {devices/lab_pin.sym} 124900 -18350 0 0 {name=p124165 lab=_79029_/Y }
C {devices/lab_pin.sym} 124900 -18310 0 0 {name=p124166 lab=_79031_/B }
C {devices/lab_pin.sym} 124900 -18270 0 0 {name=p124167 lab=_79038_/Y }
C {devices/lab_pin.sym} 125060 -18310 0 1 {name=p124168 lab=_79044_/C }
C {sky130_stdcells/o21a_4.sym} 124980 -18310 0 0 {name=X_79039_ }
C {devices/lab_pin.sym} 124920 -18190 0 0 {name=p124169 lab=_64287_/A }
C {devices/lab_pin.sym} 124920 -18150 0 0 {name=p124170 lab=_84853_/Q }
C {devices/lab_pin.sym} 124920 -18110 0 0 {name=p124171 lab=_64287_/C }
C {devices/lab_pin.sym} 125040 -18150 0 1 {name=p124172 lab=_64265_/Y }
C {sky130_stdcells/nand3_4.sym} 124980 -18150 0 0 {name=X_64265_ }
C {devices/lab_pin.sym} 124920 -18020 0 0 {name=p124173 lab=_46600_/B }
C {devices/lab_pin.sym} 124920 -17980 0 0 {name=p124174 lab=_46348_/A }
C {devices/lab_pin.sym} 125040 -18000 0 1 {name=p124175 lab=_49199_/Y }
C {sky130_stdcells/nand2_4.sym} 124980 -18000 0 0 {name=X_49199_ }
C {devices/lab_pin.sym} 124920 -17890 0 0 {name=p124176 lab=_61518_/A }
C {devices/lab_pin.sym} 124920 -17850 0 0 {name=p124177 lab=_61518_/B }
C {devices/lab_pin.sym} 124920 -17810 0 0 {name=p124178 lab=_84478_/Q }
C {devices/lab_pin.sym} 125040 -17850 0 1 {name=p124179 lab=_61477_/Y }
C {sky130_stdcells/nor3_4.sym} 124980 -17850 0 0 {name=X_61477_ }
C {devices/lab_pin.sym} 124920 -17730 0 0 {name=p124180 lab=_65970_/A }
C {devices/lab_pin.sym} 124920 -17690 0 0 {name=p124181 lab=_66004_/B }
C {devices/lab_pin.sym} 124920 -17650 0 0 {name=p124182 lab=_84163_/Q }
C {devices/lab_pin.sym} 125040 -17690 0 1 {name=p124183 lab=_66004_/X }
C {sky130_stdcells/and3_4.sym} 124980 -17690 0 0 {name=X_66004_ }
C {devices/lab_pin.sym} 124940 -17550 0 0 {name=p124184 lab=_51149_/A }
C {devices/lab_pin.sym} 125020 -17550 0 1 {name=p124185 lab=_51230_/X }
C {sky130_stdcells/buf_2.sym} 124980 -17550 0 0 {name=X_51230_ }
C {devices/lab_pin.sym} 124940 -17430 0 0 {name=p124186 lab=_60469_/X }
C {devices/lab_pin.sym} 125020 -17430 0 1 {name=p124187 lab=_63216_/X }
C {sky130_stdcells/buf_2.sym} 124980 -17430 0 0 {name=X_63216_ }
C {devices/lab_pin.sym} 124890 -17310 0 0 {name=p124188 lab=_84074_/CLK }
C {devices/lab_pin.sym} 124890 -17290 0 0 {name=p124189 lab=_82050_/D }
C {devices/lab_pin.sym} 125070 -17310 0 1 {name=p124190 lab=_82050_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -17300 0 0 {name=X_82050_ }
C {devices/lab_pin.sym} 124940 -17170 0 0 {name=p124191 lab=_64386_/A }
C {devices/lab_pin.sym} 125020 -17170 0 1 {name=p124192 lab=_72577_/B }
C {sky130_stdcells/buf_2.sym} 124980 -17170 0 0 {name=X_60428_ }
C {devices/lab_pin.sym} 124920 -17060 0 0 {name=p124193 lab=_84866_/Q }
C {devices/lab_pin.sym} 124920 -17020 0 0 {name=p124194 lab=_64136_/B }
C {devices/lab_pin.sym} 125040 -17040 0 1 {name=p124195 lab=_64196_/Y }
C {sky130_stdcells/nor2_4.sym} 124980 -17040 0 0 {name=X_64196_ }
C {devices/lab_pin.sym} 124890 -16910 0 0 {name=p124196 lab=_80776_/CLK }
C {devices/lab_pin.sym} 124890 -16890 0 0 {name=p124197 lab=_84209_/Q }
C {devices/lab_pin.sym} 125070 -16910 0 1 {name=p124198 lab=_75635_/A }
C {sky130_stdcells/dfxtp_4.sym} 124980 -16900 0 0 {name=X_81001_ }
C {devices/lab_pin.sym} 124900 -16790 0 0 {name=p124199 lab=_51159_/Y }
C {devices/lab_pin.sym} 124900 -16750 0 0 {name=p124200 lab=_51147_/X }
C {devices/lab_pin.sym} 124900 -16710 0 0 {name=p124201 lab=_51160_/X }
C {devices/lab_pin.sym} 125060 -16750 0 1 {name=p124202 lab=_51161_/Y }
C {sky130_stdcells/a21oi_4.sym} 124980 -16750 0 0 {name=X_51161_ }
C {devices/lab_pin.sym} 124920 -16640 0 0 {name=p124203 lab=_63100_/A }
C {devices/lab_pin.sym} 124920 -16600 0 0 {name=p124204 lab=_63147_/B }
C {devices/lab_pin.sym} 124920 -16560 0 0 {name=p124205 lab=_63147_/C }
C {devices/lab_pin.sym} 124920 -16520 0 0 {name=p124206 lab=_63124_/D }
C {devices/lab_pin.sym} 125040 -16580 0 1 {name=p124207 lab=_63147_/X }
C {sky130_stdcells/and4_4.sym} 124980 -16580 0 0 {name=X_63147_ }
C {devices/lab_pin.sym} 124940 -16430 0 0 {name=p124208 lab=_60359_/A }
C {devices/lab_pin.sym} 125020 -16430 0 1 {name=p124209 lab=_60359_/X }
C {sky130_stdcells/buf_2.sym} 124980 -16430 0 0 {name=X_60359_ }
C {devices/lab_pin.sym} 124940 -16310 0 0 {name=p124210 lab=clkbuf_9_238_0_CLK/X }
C {devices/lab_pin.sym} 125020 -16310 0 1 {name=p124211 lab=_85770_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 124980 -16310 0 0 {name=Xclkbuf_10_477_0_CLK }
C {devices/lab_pin.sym} 124940 -16190 0 0 {name=p124212 lab=_48808_/A }
C {devices/lab_pin.sym} 125020 -16190 0 1 {name=p124213 lab=_50113_/A }
C {sky130_stdcells/buf_2.sym} 124980 -16190 0 0 {name=X_50112_ }
C {devices/lab_pin.sym} 124900 -16090 0 0 {name=p124214 lab=_86075_/Q }
C {devices/lab_pin.sym} 124900 -16050 0 0 {name=p124215 lab=_51073_/X }
C {devices/lab_pin.sym} 124900 -16010 0 0 {name=p124216 lab=_51091_/Y }
C {devices/lab_pin.sym} 125060 -16050 0 1 {name=p124217 lab=_51092_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -16050 0 0 {name=X_51092_ }
C {devices/lab_pin.sym} 124920 -15920 0 0 {name=p124218 lab=_67955_/A }
C {devices/lab_pin.sym} 124920 -15880 0 0 {name=p124219 lab=_67955_/B }
C {devices/lab_pin.sym} 125040 -15900 0 1 {name=p124220 lab=_67955_/X }
C {sky130_stdcells/and2_4.sym} 124980 -15900 0 0 {name=X_67955_ }
C {devices/lab_pin.sym} 124940 -15770 0 0 {name=p124221 lab=_63342_/C }
C {devices/lab_pin.sym} 125020 -15770 0 1 {name=p124222 lab=_63079_/C }
C {sky130_stdcells/buf_2.sym} 124980 -15770 0 0 {name=X_63078_ }
C {devices/lab_pin.sym} 124900 -15670 0 0 {name=p124223 lab=_72471_/B }
C {devices/lab_pin.sym} 124900 -15630 0 0 {name=p124224 lab=_48170_/X }
C {devices/lab_pin.sym} 124900 -15590 0 0 {name=p124225 lab=_50042_/Y }
C {devices/lab_pin.sym} 125060 -15630 0 1 {name=p124226 lab=_50043_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -15630 0 0 {name=X_50043_ }
C {devices/lab_pin.sym} 124920 -15500 0 0 {name=p124227 lab=_54919_/X }
C {devices/lab_pin.sym} 124920 -15460 0 0 {name=p124228 lab=_47752_/A }
C {devices/lab_pin.sym} 125040 -15480 0 1 {name=p124229 lab=_54920_/Y }
C {sky130_stdcells/nand2_4.sym} 124980 -15480 0 0 {name=X_54920_ }
C {devices/lab_pin.sym} 124900 -15370 0 0 {name=p124230 lab=_66901_/X }
C {devices/lab_pin.sym} 124900 -15330 0 0 {name=p124231 lab=_66904_/X }
C {devices/lab_pin.sym} 124900 -15290 0 0 {name=p124232 lab=_66905_/X }
C {devices/lab_pin.sym} 125060 -15330 0 1 {name=p124233 lab=_66909_/A }
C {sky130_stdcells/a21o_4.sym} 124980 -15330 0 0 {name=X_66906_ }
C {devices/lab_pin.sym} 124920 -15220 0 0 {name=p124234 lab=_62027_/X }
C {devices/lab_pin.sym} 124920 -15180 0 0 {name=p124235 lab=_61999_/B }
C {devices/lab_pin.sym} 124920 -15140 0 0 {name=p124236 lab=_62046_/C }
C {devices/lab_pin.sym} 124920 -15100 0 0 {name=p124237 lab=_61971_/D }
C {devices/lab_pin.sym} 125040 -15160 0 1 {name=p124238 lab=_62030_/D }
C {sky130_stdcells/nand4_4.sym} 124980 -15160 0 0 {name=X_62029_ }
C {devices/lab_pin.sym} 124890 -15010 0 0 {name=p124239 lab=_85741_/CLK }
C {devices/lab_pin.sym} 124890 -14990 0 0 {name=p124240 lab=_52868_/Y }
C {devices/lab_pin.sym} 125070 -15010 0 1 {name=p124241 lab=_85740_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -15000 0 0 {name=X_85740_ }
C {devices/lab_pin.sym} 124890 -14870 0 0 {name=p124242 lab=_82965_/CLK }
C {devices/lab_pin.sym} 124890 -14850 0 0 {name=p124243 lab=_82760_/Q }
C {devices/lab_pin.sym} 125070 -14870 0 1 {name=p124244 lab=_82952_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -14860 0 0 {name=X_82952_ }
C {devices/lab_pin.sym} 124900 -14760 0 0 {name=p124245 lab=_87144_/Q }
C {devices/lab_pin.sym} 124900 -14720 0 0 {name=p124246 lab=_67788_/X }
C {devices/lab_pin.sym} 124900 -14680 0 0 {name=p124247 lab=_67789_/X }
C {devices/lab_pin.sym} 124900 -14640 0 0 {name=p124248 lab=_67885_/X }
C {devices/lab_pin.sym} 125060 -14700 0 1 {name=p124249 lab=_67887_/B }
C {sky130_stdcells/a211o_4.sym} 124980 -14700 0 0 {name=X_67886_ }
C {devices/lab_pin.sym} 124940 -14550 0 0 {name=p124250 lab=clkbuf_9_200_0_CLK/X }
C {devices/lab_pin.sym} 125020 -14550 0 1 {name=p124251 lab=_82263_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 124980 -14550 0 0 {name=Xclkbuf_10_400_0_CLK }
C {devices/lab_pin.sym} 124890 -14430 0 0 {name=p124252 lab=_81985_/CLK }
C {devices/lab_pin.sym} 124890 -14410 0 0 {name=p124253 lab=_81903_/D }
C {devices/lab_pin.sym} 125070 -14430 0 1 {name=p124254 lab=_77036_/B }
C {sky130_stdcells/dfxtp_4.sym} 124980 -14420 0 0 {name=X_81903_ }
C {devices/lab_pin.sym} 124900 -14310 0 0 {name=p124255 lab=_69620_/X }
C {devices/lab_pin.sym} 124900 -14270 0 0 {name=p124256 lab=_69623_/X }
C {devices/lab_pin.sym} 124900 -14230 0 0 {name=p124257 lab=_69624_/X }
C {devices/lab_pin.sym} 125060 -14270 0 1 {name=p124258 lab=_69625_/X }
C {sky130_stdcells/a21o_4.sym} 124980 -14270 0 0 {name=X_69625_ }
C {devices/lab_pin.sym} 124900 -14150 0 0 {name=p124259 lab=_85366_/Q }
C {devices/lab_pin.sym} 124900 -14110 0 0 {name=p124260 lab=_54839_/X }
C {devices/lab_pin.sym} 124900 -14070 0 0 {name=p124261 lab=_54850_/Y }
C {devices/lab_pin.sym} 125060 -14110 0 1 {name=p124262 lab=_54851_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -14110 0 0 {name=X_54851_ }
C {devices/lab_pin.sym} 124920 -13980 0 0 {name=p124263 lab=_66832_/X }
C {devices/lab_pin.sym} 124920 -13940 0 0 {name=p124264 lab=_66836_/X }
C {devices/lab_pin.sym} 125040 -13960 0 1 {name=p124265 lab=_66837_/Y }
C {sky130_stdcells/nand2_4.sym} 124980 -13960 0 0 {name=X_66837_ }
C {devices/lab_pin.sym} 124890 -13830 0 0 {name=p124266 lab=_84815_/CLK }
C {devices/lab_pin.sym} 124890 -13810 0 0 {name=p124267 lab=_85671_/D }
C {devices/lab_pin.sym} 125070 -13830 0 1 {name=p124268 lab=_85671_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -13820 0 0 {name=X_85671_ }
C {devices/lab_pin.sym} 124890 -13690 0 0 {name=p124269 lab=_82886_/CLK }
C {devices/lab_pin.sym} 124890 -13670 0 0 {name=p124270 lab=_78085_/Y }
C {devices/lab_pin.sym} 125070 -13690 0 1 {name=p124271 lab=_82883_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -13680 0 0 {name=X_82883_ }
C {devices/lab_pin.sym} 124890 -13550 0 0 {name=p124272 lab=_87922_/CLK }
C {devices/lab_pin.sym} 124890 -13530 0 0 {name=p124273 lab=_43462_/X }
C {devices/lab_pin.sym} 125070 -13550 0 1 {name=p124274 lab=_87410_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -13540 0 0 {name=X_87410_ }
C {devices/lab_pin.sym} 124900 -13430 0 0 {name=p124275 lab=_53797_/Y }
C {devices/lab_pin.sym} 124900 -13390 0 0 {name=p124276 lab=_53799_/X }
C {devices/lab_pin.sym} 124900 -13350 0 0 {name=p124277 lab=_53801_/Y }
C {devices/lab_pin.sym} 125060 -13390 0 1 {name=p124278 lab=_53802_/Y }
C {sky130_stdcells/a21boi_4.sym} 124980 -13390 0 0 {name=X_53802_ }
C {devices/lab_pin.sym} 124890 -13250 0 0 {name=p124279 lab=_84620_/CLK }
C {devices/lab_pin.sym} 124890 -13230 0 0 {name=p124280 lab=_60366_/Y }
C {devices/lab_pin.sym} 125070 -13250 0 1 {name=p124281 lab=_79581_/A }
C {sky130_stdcells/dfxtp_4.sym} 124980 -13240 0 0 {name=X_84622_ }
C {devices/lab_pin.sym} 124900 -13130 0 0 {name=p124282 lab=_84977_/Q }
C {devices/lab_pin.sym} 124900 -13090 0 0 {name=p124283 lab=_57562_/X }
C {devices/lab_pin.sym} 124900 -13050 0 0 {name=p124284 lab=_57569_/Y }
C {devices/lab_pin.sym} 125060 -13090 0 1 {name=p124285 lab=_57570_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -13090 0 0 {name=X_57570_ }
C {devices/lab_pin.sym} 124890 -12950 0 0 {name=p124286 lab=_81834_/CLK }
C {devices/lab_pin.sym} 124890 -12930 0 0 {name=p124287 lab=_81866_/Q }
C {devices/lab_pin.sym} 125070 -12950 0 1 {name=p124288 lab=_77338_/A }
C {sky130_stdcells/dfxtp_4.sym} 124980 -12940 0 0 {name=X_81834_ }
C {devices/lab_pin.sym} 124900 -12840 0 0 {name=p124289 lab=_87508_/Q }
C {devices/lab_pin.sym} 124900 -12800 0 0 {name=p124290 lab=_69468_/X }
C {devices/lab_pin.sym} 124900 -12760 0 0 {name=p124291 lab=_59036_/A }
C {devices/lab_pin.sym} 124900 -12720 0 0 {name=p124292 lab=_69555_/X }
C {devices/lab_pin.sym} 125060 -12780 0 1 {name=p124293 lab=_69556_/X }
C {sky130_stdcells/a211o_4.sym} 124980 -12780 0 0 {name=X_69556_ }
C {devices/lab_pin.sym} 124890 -12630 0 0 {name=p124294 lab=_88394_/CLK }
C {devices/lab_pin.sym} 124890 -12610 0 0 {name=p124295 lab=_88390_/D }
C {devices/lab_pin.sym} 125070 -12630 0 1 {name=p124296 lab=_88390_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -12620 0 0 {name=X_88390_ }
C {devices/lab_pin.sym} 124900 -12510 0 0 {name=p124297 lab=_54778_/Y }
C {devices/lab_pin.sym} 124900 -12470 0 0 {name=p124298 lab=_54774_/X }
C {devices/lab_pin.sym} 124900 -12430 0 0 {name=p124299 lab=_54781_/X }
C {devices/lab_pin.sym} 125060 -12470 0 1 {name=p124300 lab=_85379_/D }
C {sky130_stdcells/a21oi_4.sym} 124980 -12470 0 0 {name=X_54782_ }
C {devices/lab_pin.sym} 124940 -12330 0 0 {name=p124301 lab=_66647_/A }
C {devices/lab_pin.sym} 125020 -12330 0 1 {name=p124302 lab=_66769_/A }
C {sky130_stdcells/buf_2.sym} 124980 -12330 0 0 {name=X_66768_ }
C {devices/lab_pin.sym} 124940 -12210 0 0 {name=p124303 lab=_51928_/X }
C {devices/lab_pin.sym} 125020 -12210 0 1 {name=p124304 lab=_51994_/X }
C {sky130_stdcells/buf_2.sym} 124980 -12210 0 0 {name=X_51994_ }
C {devices/lab_pin.sym} 124900 -12110 0 0 {name=p124305 lab=_56121_/X }
C {devices/lab_pin.sym} 124900 -12070 0 0 {name=p124306 lab=_56515_/X }
C {devices/lab_pin.sym} 124900 -12030 0 0 {name=p124307 lab=_56520_/Y }
C {devices/lab_pin.sym} 125060 -12070 0 1 {name=p124308 lab=_85164_/D }
C {sky130_stdcells/o21ai_4.sym} 124980 -12070 0 0 {name=X_56521_ }
C {devices/lab_pin.sym} 124900 -11950 0 0 {name=p124309 lab=_68503_/X }
C {devices/lab_pin.sym} 124900 -11910 0 0 {name=p124310 lab=_68506_/X }
C {devices/lab_pin.sym} 124900 -11870 0 0 {name=p124311 lab=_68429_/X }
C {devices/lab_pin.sym} 125060 -11910 0 1 {name=p124312 lab=_68507_/X }
C {sky130_stdcells/a21o_4.sym} 124980 -11910 0 0 {name=X_68507_ }
C {devices/lab_pin.sym} 124890 -11770 0 0 {name=p124313 lab=_87070_/CLK }
C {devices/lab_pin.sym} 124890 -11750 0 0 {name=p124314 lab=_43617_/X }
C {devices/lab_pin.sym} 125070 -11770 0 1 {name=p124315 lab=_87341_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -11760 0 0 {name=X_87341_ }
C {devices/lab_pin.sym} 124940 -11630 0 0 {name=p124316 lab=_53733_/A }
C {devices/lab_pin.sym} 125020 -11630 0 1 {name=p124317 lab=_53748_/B }
C {sky130_stdcells/buf_2.sym} 124980 -11630 0 0 {name=X_53733_ }
C {devices/lab_pin.sym} 124920 -11520 0 0 {name=p124318 lab=_65779_/A }
C {devices/lab_pin.sym} 124920 -11480 0 0 {name=p124319 lab=_86478_/Q }
C {devices/lab_pin.sym} 125040 -11500 0 1 {name=p124320 lab=_65719_/X }
C {sky130_stdcells/and2_4.sym} 124980 -11500 0 0 {name=X_65719_ }
C {devices/lab_pin.sym} 124890 -11370 0 0 {name=p124321 lab=_84529_/CLK }
C {devices/lab_pin.sym} 124890 -11350 0 0 {name=p124322 lab=_60899_/X }
C {devices/lab_pin.sym} 125070 -11370 0 1 {name=p124323 lab=_84553_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -11360 0 0 {name=X_84553_ }
C {devices/lab_pin.sym} 124940 -11230 0 0 {name=p124324 lab=_50256_/A }
C {devices/lab_pin.sym} 125020 -11230 0 1 {name=p124325 lab=_50946_/A }
C {sky130_stdcells/buf_2.sym} 124980 -11230 0 0 {name=X_50945_ }
C {devices/lab_pin.sym} 124890 -11110 0 0 {name=p124326 lab=_84003_/CLK }
C {devices/lab_pin.sym} 124890 -11090 0 0 {name=p124327 lab=_75996_/X }
C {devices/lab_pin.sym} 125070 -11110 0 1 {name=p124328 lab=_48675_/A }
C {sky130_stdcells/dfxtp_4.sym} 124980 -11100 0 0 {name=X_81765_ }
C {devices/lab_pin.sym} 124900 -11000 0 0 {name=p124329 lab=_87014_/Q }
C {devices/lab_pin.sym} 124900 -10960 0 0 {name=p124330 lab=_69485_/X }
C {devices/lab_pin.sym} 124900 -10920 0 0 {name=p124331 lab=_69361_/X }
C {devices/lab_pin.sym} 124900 -10880 0 0 {name=p124332 lab=_69486_/X }
C {devices/lab_pin.sym} 125060 -10940 0 1 {name=p124333 lab=_69487_/X }
C {sky130_stdcells/a211o_4.sym} 124980 -10940 0 0 {name=X_69487_ }
C {devices/lab_pin.sym} 124900 -10820 0 0 {name=p124334 lab=_87886_/Q }
C {devices/lab_pin.sym} 124900 -10780 0 0 {name=p124335 lab=_66697_/X }
C {devices/lab_pin.sym} 124900 -10740 0 0 {name=p124336 lab=_66675_/X }
C {devices/lab_pin.sym} 124900 -10700 0 0 {name=p124337 lab=_66698_/X }
C {devices/lab_pin.sym} 125060 -10760 0 1 {name=p124338 lab=_66699_/X }
C {sky130_stdcells/a211o_4.sym} 124980 -10760 0 0 {name=X_66699_ }
C {devices/lab_pin.sym} 124940 -10610 0 0 {name=p124339 lab=clkbuf_9_207_0_CLK/X }
C {devices/lab_pin.sym} 125020 -10610 0 1 {name=p124340 lab=_85332_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 124980 -10610 0 0 {name=Xclkbuf_10_415_0_CLK }
C {devices/lab_pin.sym} 124920 -10500 0 0 {name=p124341 lab=_59240_/A }
C {devices/lab_pin.sym} 124920 -10460 0 0 {name=p124342 lab=_59226_/B }
C {devices/lab_pin.sym} 125040 -10480 0 1 {name=p124343 lab=_59240_/Y }
C {sky130_stdcells/nor2_4.sym} 124980 -10480 0 0 {name=X_59240_ }
C {devices/lab_pin.sym} 124890 -10350 0 0 {name=p124344 lab=_84223_/CLK }
C {devices/lab_pin.sym} 124890 -10330 0 0 {name=p124345 lab=_71425_/X }
C {devices/lab_pin.sym} 125070 -10350 0 1 {name=p124346 lab=_83504_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -10340 0 0 {name=X_83504_ }
C {devices/lab_pin.sym} 124920 -10230 0 0 {name=p124347 lab=_56377_/X }
C {devices/lab_pin.sym} 124920 -10190 0 0 {name=p124348 lab=_56454_/B }
C {devices/lab_pin.sym} 124920 -10150 0 0 {name=p124349 lab=_56452_/C }
C {devices/lab_pin.sym} 125040 -10190 0 1 {name=p124350 lab=_56452_/Y }
C {sky130_stdcells/nand3_4.sym} 124980 -10190 0 0 {name=X_56452_ }
C {devices/lab_pin.sym} 124890 -10050 0 0 {name=p124351 lab=_80681_/CLK }
C {devices/lab_pin.sym} 124890 -10030 0 0 {name=p124352 lab=_75902_/X }
C {devices/lab_pin.sym} 125070 -10050 0 1 {name=p124353 lab=_80716_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -10040 0 0 {name=X_80716_ }
C {devices/lab_pin.sym} 124900 -9940 0 0 {name=p124354 lab=_43032_/A }
C {devices/lab_pin.sym} 124900 -9900 0 0 {name=p124355 lab=_68066_/X }
C {devices/lab_pin.sym} 124900 -9860 0 0 {name=p124356 lab=_68436_/X }
C {devices/lab_pin.sym} 124900 -9820 0 0 {name=p124357 lab=_68437_/X }
C {devices/lab_pin.sym} 125060 -9880 0 1 {name=p124358 lab=_68438_/X }
C {sky130_stdcells/a211o_4.sym} 124980 -9880 0 0 {name=X_68438_ }
C {devices/lab_pin.sym} 124890 -9730 0 0 {name=p124359 lab=_88044_/CLK }
C {devices/lab_pin.sym} 124890 -9710 0 0 {name=p124360 lab=_87272_/D }
C {devices/lab_pin.sym} 125070 -9730 0 1 {name=p124361 lab=_69288_/B }
C {sky130_stdcells/dfxtp_4.sym} 124980 -9720 0 0 {name=X_87272_ }
C {devices/lab_pin.sym} 124900 -9610 0 0 {name=p124362 lab=_85592_/Q }
C {devices/lab_pin.sym} 124900 -9570 0 0 {name=p124363 lab=_53660_/X }
C {devices/lab_pin.sym} 124900 -9530 0 0 {name=p124364 lab=_53663_/Y }
C {devices/lab_pin.sym} 125060 -9570 0 1 {name=p124365 lab=_53664_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -9570 0 0 {name=X_53664_ }
C {devices/lab_pin.sym} 124890 -9430 0 0 {name=p124366 lab=_84481_/CLK }
C {devices/lab_pin.sym} 124890 -9410 0 0 {name=p124367 lab=_84484_/D }
C {devices/lab_pin.sym} 125070 -9430 0 1 {name=p124368 lab=_79152_/B }
C {sky130_stdcells/dfxtp_4.sym} 124980 -9420 0 0 {name=X_84484_ }
C {devices/lab_pin.sym} 124920 -9300 0 0 {name=p124369 lab=_50228_/X }
C {devices/lab_pin.sym} 124920 -9260 0 0 {name=p124370 lab=_54087_/B }
C {devices/lab_pin.sym} 125040 -9280 0 1 {name=p124371 lab=_50876_/Y }
C {sky130_stdcells/nand2_4.sym} 124980 -9280 0 0 {name=X_50876_ }
C {devices/lab_pin.sym} 124890 -9150 0 0 {name=p124372 lab=_81696_/CLK }
C {devices/lab_pin.sym} 124890 -9130 0 0 {name=p124373 lab=_80248_/X }
C {devices/lab_pin.sym} 125070 -9150 0 1 {name=p124374 lab=_76773_/A }
C {sky130_stdcells/dfxtp_4.sym} 124980 -9140 0 0 {name=X_81696_ }
C {devices/lab_pin.sym} 124920 -9020 0 0 {name=p124375 lab=_55403_/A }
C {devices/lab_pin.sym} 124920 -8980 0 0 {name=p124376 lab=_55403_/B }
C {devices/lab_pin.sym} 125040 -9000 0 1 {name=p124377 lab=_56777_/A }
C {sky130_stdcells/nand2_4.sym} 124980 -9000 0 0 {name=X_55403_ }
C {devices/lab_pin.sym} 124890 -8870 0 0 {name=p124378 lab=_83544_/CLK }
C {devices/lab_pin.sym} 124890 -8850 0 0 {name=p124379 lab=_50327_/Y }
C {devices/lab_pin.sym} 125070 -8870 0 1 {name=p124380 lab=_86223_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -8860 0 0 {name=X_86223_ }
C {devices/lab_pin.sym} 124900 -8750 0 0 {name=p124381 lab=_52613_/Y }
C {devices/lab_pin.sym} 124900 -8710 0 0 {name=p124382 lab=_52592_/X }
C {devices/lab_pin.sym} 124900 -8670 0 0 {name=p124383 lab=_52614_/X }
C {devices/lab_pin.sym} 125060 -8710 0 1 {name=p124384 lab=_52615_/Y }
C {sky130_stdcells/a21oi_4.sym} 124980 -8710 0 0 {name=X_52615_ }
C {devices/lab_pin.sym} 124900 -8600 0 0 {name=p124385 lab=_59159_/Y }
C {devices/lab_pin.sym} 124900 -8560 0 0 {name=p124386 lab=_59145_/X }
C {devices/lab_pin.sym} 124900 -8520 0 0 {name=p124387 lab=_59166_/X }
C {devices/lab_pin.sym} 124900 -8480 0 0 {name=p124388 lab=_59170_/X }
C {devices/lab_pin.sym} 125060 -8540 0 1 {name=p124389 lab=_59171_/Y }
C {sky130_stdcells/a22oi_4.sym} 124980 -8540 0 0 {name=X_59171_ }
C {devices/lab_pin.sym} 124890 -8390 0 0 {name=p124390 lab=_83491_/CLK }
C {devices/lab_pin.sym} 124890 -8370 0 0 {name=p124391 lab=_83435_/D }
C {devices/lab_pin.sym} 125070 -8390 0 1 {name=p124392 lab=_83435_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -8380 0 0 {name=X_83435_ }
C {devices/lab_pin.sym} 124940 -8250 0 0 {name=p124393 lab=_56439_/A }
C {devices/lab_pin.sym} 125020 -8250 0 1 {name=p124394 lab=_56383_/X }
C {sky130_stdcells/buf_2.sym} 124980 -8250 0 0 {name=X_56383_ }
C {devices/lab_pin.sym} 124940 -8120 0 0 {name=p124395 lab=_74785_/X }
C {devices/lab_pin.sym} 124940 -8080 0 0 {name=p124396 lab=_74711_/Y }
C {devices/lab_pin.sym} 125020 -8120 0 1 {name=p124397 lab=DATA_FROM_HASH[4] }
C {sky130_stdcells/ebufn_2.sym} 124980 -8120 0 0 {name=X_80647_ }
C {devices/lab_pin.sym} 124900 -8010 0 0 {name=p124398 lab=_68363_/X }
C {devices/lab_pin.sym} 124900 -7970 0 0 {name=p124399 lab=_68368_/X }
C {devices/lab_pin.sym} 124900 -7930 0 0 {name=p124400 lab=_68033_/X }
C {devices/lab_pin.sym} 125060 -7970 0 1 {name=p124401 lab=_68369_/X }
C {sky130_stdcells/a21o_4.sym} 124980 -7970 0 0 {name=X_68369_ }
C {devices/lab_pin.sym} 124920 -7840 0 0 {name=p124402 lab=_53604_/A }
C {devices/lab_pin.sym} 124920 -7800 0 0 {name=p124403 lab=_50372_/B }
C {devices/lab_pin.sym} 125040 -7820 0 1 {name=p124404 lab=_53595_/Y }
C {sky130_stdcells/nand2_4.sym} 124980 -7820 0 0 {name=X_53595_ }
C {sky130_stdcells/decap_3.sym} 124980 -7660 0 0 {name=XPHY_203 }
C {sky130_stdcells/decap_3.sym} 124980 -7480 0 0 {name=XPHY_214 }
C {devices/lab_pin.sym} 124900 -7350 0 0 {name=p124405 lab=_57983_/X }
C {devices/lab_pin.sym} 124900 -7310 0 0 {name=p124406 lab=_85379_/Q }
C {devices/lab_pin.sym} 124900 -7270 0 0 {name=p124407 lab=_58121_/X }
C {devices/lab_pin.sym} 125060 -7310 0 1 {name=p124408 lab=_58122_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -7310 0 0 {name=X_58122_ }
C {devices/lab_pin.sym} 124940 -7170 0 0 {name=p124409 lab=_70400_/A }
C {devices/lab_pin.sym} 125020 -7170 0 1 {name=p124410 lab=_71005_/A }
C {sky130_stdcells/buf_2.sym} 124980 -7170 0 0 {name=X_70400_ }
C {sky130_stdcells/decap_3.sym} 124980 -7020 0 0 {name=XPHY_225 }
C {devices/lab_pin.sym} 124920 -6880 0 0 {name=p124411 lab=_55306_/X }
C {devices/lab_pin.sym} 124920 -6840 0 0 {name=p124412 lab=_45659_/Y }
C {devices/lab_pin.sym} 125040 -6860 0 1 {name=p124413 lab=_55334_/Y }
C {sky130_stdcells/nor2_4.sym} 124980 -6860 0 0 {name=X_55334_ }
C {devices/lab_pin.sym} 124890 -6730 0 0 {name=p124414 lab=_86154_/CLK }
C {devices/lab_pin.sym} 124890 -6710 0 0 {name=p124415 lab=_50685_/Y }
C {devices/lab_pin.sym} 125070 -6730 0 1 {name=p124416 lab=_86154_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -6720 0 0 {name=X_86154_ }
C {devices/lab_pin.sym} 124940 -6590 0 0 {name=p124417 lab=_40559_/X }
C {devices/lab_pin.sym} 125020 -6590 0 1 {name=p124418 lab=_40560_/X }
C {sky130_stdcells/buf_2.sym} 124980 -6590 0 0 {name=X_40560_ }
C {devices/lab_pin.sym} 124900 -6490 0 0 {name=p124419 lab=_85800_/Q }
C {devices/lab_pin.sym} 124900 -6450 0 0 {name=p124420 lab=_52500_/X }
C {devices/lab_pin.sym} 124900 -6410 0 0 {name=p124421 lab=_52545_/Y }
C {devices/lab_pin.sym} 125060 -6450 0 1 {name=p124422 lab=_52546_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -6450 0 0 {name=X_52546_ }
C {sky130_stdcells/decap_3.sym} 124980 -6280 0 0 {name=XPHY_236 }
C {devices/lab_pin.sym} 124900 -6150 0 0 {name=p124423 lab=_71373_/X }
C {devices/lab_pin.sym} 124900 -6110 0 0 {name=p124424 lab=_83520_/Q }
C {devices/lab_pin.sym} 124900 -6070 0 0 {name=p124425 lab=_71379_/Y }
C {devices/lab_pin.sym} 125060 -6110 0 1 {name=p124426 lab=_83520_/D }
C {sky130_stdcells/a21o_4.sym} 124980 -6110 0 0 {name=X_71380_ }
C {devices/lab_pin.sym} 124890 -5970 0 0 {name=p124427 lab=_83367_/CLK }
C {devices/lab_pin.sym} 124890 -5950 0 0 {name=p124428 lab=_83366_/D }
C {devices/lab_pin.sym} 125070 -5970 0 1 {name=p124429 lab=_83366_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -5960 0 0 {name=X_83366_ }
C {devices/lab_pin.sym} 124920 -5840 0 0 {name=p124430 lab=_84773_/Q }
C {devices/lab_pin.sym} 124920 -5800 0 0 {name=p124431 lab=_65970_/C }
C {devices/lab_pin.sym} 125040 -5820 0 1 {name=p124432 lab=_80580_/A }
C {sky130_stdcells/xor2_4.sym} 124980 -5820 0 0 {name=X_80578_ }
C {sky130_stdcells/decap_3.sym} 124980 -5660 0 0 {name=XPHY_247 }
C {sky130_stdcells/decap_3.sym} 124980 -5480 0 0 {name=XPHY_258 }
C {sky130_stdcells/decap_3.sym} 124980 -5300 0 0 {name=XPHY_269 }
C {devices/lab_pin.sym} 124890 -5150 0 0 {name=p124433 lab=_85041_/CLK }
C {devices/lab_pin.sym} 124890 -5130 0 0 {name=p124434 lab=_85105_/D }
C {devices/lab_pin.sym} 125070 -5150 0 1 {name=p124435 lab=_85105_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -5140 0 0 {name=X_85105_ }
C {devices/lab_pin.sym} 124940 -5010 0 0 {name=p124436 lab=_70154_/X }
C {devices/lab_pin.sym} 125020 -5010 0 1 {name=p124437 lab=_70333_/B }
C {sky130_stdcells/buf_2.sym} 124980 -5010 0 0 {name=X_70331_ }
C {devices/lab_pin.sym} 124900 -4910 0 0 {name=p124438 lab=_58050_/Y }
C {devices/lab_pin.sym} 124900 -4870 0 0 {name=p124439 lab=_58052_/Y }
C {devices/lab_pin.sym} 124900 -4830 0 0 {name=p124440 lab=_58003_/X }
C {devices/lab_pin.sym} 125060 -4870 0 1 {name=p124441 lab=_58053_/X }
C {sky130_stdcells/a21o_4.sym} 124980 -4870 0 0 {name=X_58053_ }
C {devices/lab_pin.sym} 124890 -4730 0 0 {name=p124442 lab=_82317_/CLK }
C {devices/lab_pin.sym} 124890 -4710 0 0 {name=p124443 lab=_77081_/B }
C {devices/lab_pin.sym} 125070 -4730 0 1 {name=p124444 lab=_40489_/A }
C {sky130_stdcells/dfxtp_4.sym} 124980 -4720 0 0 {name=X_82317_ }
C {devices/lab_pin.sym} 124920 -4620 0 0 {name=p124445 lab=_55290_/A }
C {devices/lab_pin.sym} 124920 -4580 0 0 {name=p124446 lab=_55678_/A }
C {devices/lab_pin.sym} 124920 -4540 0 0 {name=p124447 lab=_55263_/X }
C {devices/lab_pin.sym} 124920 -4500 0 0 {name=p124448 lab=_55264_/Y }
C {devices/lab_pin.sym} 125040 -4560 0 1 {name=p124449 lab=_55265_/Y }
C {sky130_stdcells/nand4_4.sym} 124980 -4560 0 0 {name=X_55265_ }
C {devices/lab_pin.sym} 124890 -4410 0 0 {name=p124450 lab=_85764_/CLK }
C {devices/lab_pin.sym} 124890 -4390 0 0 {name=p124451 lab=_86085_/D }
C {devices/lab_pin.sym} 125070 -4410 0 1 {name=p124452 lab=_86085_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -4400 0 0 {name=X_86085_ }
C {devices/lab_pin.sym} 124940 -4270 0 0 {name=p124453 lab=_40490_/X }
C {devices/lab_pin.sym} 125020 -4270 0 1 {name=p124454 lab=_40491_/X }
C {sky130_stdcells/buf_2.sym} 124980 -4270 0 0 {name=X_40491_ }
C {devices/lab_pin.sym} 124900 -4170 0 0 {name=p124455 lab=_85814_/Q }
C {devices/lab_pin.sym} 124900 -4130 0 0 {name=p124456 lab=_52470_/X }
C {devices/lab_pin.sym} 124900 -4090 0 0 {name=p124457 lab=_52476_/Y }
C {devices/lab_pin.sym} 125060 -4130 0 1 {name=p124458 lab=_52477_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -4130 0 0 {name=X_52477_ }
C {devices/lab_pin.sym} 124890 -3990 0 0 {name=p124459 lab=_83297_/CLK }
C {devices/lab_pin.sym} 124890 -3970 0 0 {name=p124460 lab=_72039_/Y }
C {devices/lab_pin.sym} 125070 -3990 0 1 {name=p124461 lab=_83297_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -3980 0 0 {name=X_83297_ }
C {devices/lab_pin.sym} 124920 -3870 0 0 {name=p124462 lab=_46155_/X }
C {devices/lab_pin.sym} 124920 -3830 0 0 {name=p124463 lab=_57004_/B }
C {devices/lab_pin.sym} 124920 -3790 0 0 {name=p124464 lab=_57004_/C }
C {devices/lab_pin.sym} 125040 -3830 0 1 {name=p124465 lab=_57004_/Y }
C {sky130_stdcells/nor3_4.sym} 124980 -3830 0 0 {name=X_57004_ }
C {devices/lab_pin.sym} 124940 -3690 0 0 {name=p124466 lab=_42230_/A }
C {devices/lab_pin.sym} 125020 -3690 0 1 {name=p124467 lab=_87970_/D }
C {sky130_stdcells/inv_2.sym} 124980 -3690 0 0 {name=X_42230_ }
C {devices/lab_pin.sym} 124900 -3590 0 0 {name=p124468 lab=_85482_/Q }
C {devices/lab_pin.sym} 124900 -3550 0 0 {name=p124469 lab=_54193_/X }
C {devices/lab_pin.sym} 124900 -3510 0 0 {name=p124470 lab=_54215_/Y }
C {devices/lab_pin.sym} 125060 -3550 0 1 {name=p124471 lab=_54216_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -3550 0 0 {name=X_54216_ }
C {devices/lab_pin.sym} 124920 -3420 0 0 {name=p124472 lab=_73050_/A }
C {devices/lab_pin.sym} 124920 -3380 0 0 {name=p124473 lab=_73049_/Y }
C {devices/lab_pin.sym} 125040 -3400 0 1 {name=p124474 lab=_73050_/Y }
C {sky130_stdcells/nor2_4.sym} 124980 -3400 0 0 {name=X_73050_ }
C {devices/lab_pin.sym} 124890 -3270 0 0 {name=p124475 lab=_84998_/CLK }
C {devices/lab_pin.sym} 124890 -3250 0 0 {name=p124476 lab=_57317_/Y }
C {devices/lab_pin.sym} 125070 -3270 0 1 {name=p124477 lab=_85036_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -3260 0 0 {name=X_85036_ }
C {devices/lab_pin.sym} 124940 -3130 0 0 {name=p124478 lab=_50991_/A }
C {devices/lab_pin.sym} 125020 -3130 0 1 {name=p124479 lab=_51539_/A }
C {sky130_stdcells/buf_2.sym} 124980 -3130 0 0 {name=X_51428_ }
C {devices/lab_pin.sym} 124940 -3010 0 0 {name=p124480 lab=_70246_/A }
C {devices/lab_pin.sym} 125020 -3010 0 1 {name=p124481 lab=_70267_/A }
C {sky130_stdcells/buf_2.sym} 124980 -3010 0 0 {name=X_70262_ }
C {devices/lab_pin.sym} 124890 -2890 0 0 {name=p124482 lab=_82248_/CLK }
C {devices/lab_pin.sym} 124890 -2870 0 0 {name=p124483 lab=_80366_/X }
C {devices/lab_pin.sym} 125070 -2890 0 1 {name=p124484 lab=_82248_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -2880 0 0 {name=X_82248_ }
C {devices/lab_pin.sym} 124920 -2760 0 0 {name=p124485 lab=_55196_/A }
C {devices/lab_pin.sym} 124920 -2720 0 0 {name=p124486 lab=_55196_/B }
C {devices/lab_pin.sym} 125040 -2740 0 1 {name=p124487 lab=_55400_/A }
C {sky130_stdcells/and2_4.sym} 124980 -2740 0 0 {name=X_55196_ }
C {devices/lab_pin.sym} 124940 -2610 0 0 {name=p124488 lab=_72001_/A }
C {devices/lab_pin.sym} 125020 -2610 0 1 {name=p124489 lab=_72001_/X }
C {sky130_stdcells/buf_2.sym} 124980 -2610 0 0 {name=X_72001_ }
C {devices/lab_pin.sym} 124920 -2520 0 0 {name=p124490 lab=_54127_/X }
C {devices/lab_pin.sym} 124920 -2480 0 0 {name=p124491 lab=_54160_/B }
C {devices/lab_pin.sym} 124920 -2440 0 0 {name=p124492 lab=_54146_/X }
C {devices/lab_pin.sym} 124920 -2400 0 0 {name=p124493 lab=_52977_/D }
C {devices/lab_pin.sym} 125040 -2460 0 1 {name=p124494 lab=_54147_/X }
C {sky130_stdcells/and4_4.sym} 124980 -2460 0 0 {name=X_54147_ }
C {devices/lab_pin.sym} 124940 -2310 0 0 {name=p124495 lab=_42137_/A }
C {devices/lab_pin.sym} 125020 -2310 0 1 {name=p124496 lab=_42161_/X }
C {sky130_stdcells/buf_2.sym} 124980 -2310 0 0 {name=X_42161_ }
C {devices/lab_pin.sym} 124900 -2210 0 0 {name=p124497 lab=_86025_/Q }
C {devices/lab_pin.sym} 124900 -2170 0 0 {name=p124498 lab=_51332_/X }
C {devices/lab_pin.sym} 124900 -2130 0 0 {name=p124499 lab=_51358_/Y }
C {devices/lab_pin.sym} 125060 -2170 0 1 {name=p124500 lab=_51359_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -2170 0 0 {name=X_51359_ }
C {devices/lab_pin.sym} 124920 -2060 0 0 {name=p124501 lab=_70193_/A }
C {devices/lab_pin.sym} 124920 -2020 0 0 {name=p124502 lab=_70160_/X }
C {devices/lab_pin.sym} 124920 -1980 0 0 {name=p124503 lab=_70162_/X }
C {devices/lab_pin.sym} 124920 -1940 0 0 {name=p124504 lab=_70164_/X }
C {devices/lab_pin.sym} 125040 -2000 0 1 {name=p124505 lab=_70193_/Y }
C {sky130_stdcells/nand4_4.sym} 124980 -2000 0 0 {name=X_70193_ }
C {devices/lab_pin.sym} 124890 -1850 0 0 {name=p124506 lab=_84951_/CLK }
C {devices/lab_pin.sym} 124890 -1830 0 0 {name=p124507 lab=_82179_/D }
C {devices/lab_pin.sym} 125070 -1850 0 1 {name=p124508 lab=_82371_/D }
C {sky130_stdcells/dfxtp_4.sym} 124980 -1840 0 0 {name=X_82179_ }
C {devices/lab_pin.sym} 124940 -1710 0 0 {name=p124509 lab=_40999_/A }
C {devices/lab_pin.sym} 125020 -1710 0 1 {name=p124510 lab=_41112_/X }
C {sky130_stdcells/buf_2.sym} 124980 -1710 0 0 {name=X_41112_ }
C {devices/lab_pin.sym} 124900 -1630 0 0 {name=p124511 lab=_42083_/X }
C {devices/lab_pin.sym} 124900 -1590 0 0 {name=p124512 lab=_42077_/X }
C {devices/lab_pin.sym} 124900 -1550 0 0 {name=p124513 lab=_41009_/X }
C {devices/lab_pin.sym} 124900 -1510 0 0 {name=p124514 lab=_88038_/Q }
C {devices/lab_pin.sym} 124900 -1470 0 0 {name=p124515 lab=_42078_/X }
C {devices/lab_pin.sym} 125060 -1550 0 1 {name=p124516 lab=_42093_/A }
C {sky130_stdcells/o32ai_4.sym} 124980 -1550 0 0 {name=X_42092_ }
C {devices/lab_pin.sym} 124900 -1420 0 0 {name=p124517 lab=_58946_/Y }
C {devices/lab_pin.sym} 124900 -1380 0 0 {name=p124518 lab=_58857_/X }
C {devices/lab_pin.sym} 124900 -1340 0 0 {name=p124519 lab=_58951_/X }
C {devices/lab_pin.sym} 124900 -1300 0 0 {name=p124520 lab=_58954_/X }
C {devices/lab_pin.sym} 125060 -1360 0 1 {name=p124521 lab=_58955_/Y }
C {sky130_stdcells/a22oi_4.sym} 124980 -1360 0 0 {name=X_58955_ }
C {devices/lab_pin.sym} 124900 -1230 0 0 {name=p124522 lab=_85509_/Q }
C {devices/lab_pin.sym} 124900 -1190 0 0 {name=p124523 lab=_54067_/X }
C {devices/lab_pin.sym} 124900 -1150 0 0 {name=p124524 lab=_54077_/Y }
C {devices/lab_pin.sym} 125060 -1190 0 1 {name=p124525 lab=_54078_/Y }
C {sky130_stdcells/o21ai_4.sym} 124980 -1190 0 0 {name=X_54078_ }
C {devices/lab_pin.sym} 124890 -1050 0 0 {name=p124526 lab=_86998_/CLK }
C {devices/lab_pin.sym} 124890 -1030 0 0 {name=p124527 lab=_44722_/Y }
C {devices/lab_pin.sym} 125070 -1050 0 1 {name=p124528 lab=_86987_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124980 -1040 0 0 {name=X_86987_ }
C {devices/lab_pin.sym} 124940 -910 0 0 {name=p124529 lab=_45920_/A }
C {devices/lab_pin.sym} 125020 -910 0 1 {name=p124530 lab=_64565_/A }
C {sky130_stdcells/buf_2.sym} 124980 -910 0 0 {name=X_45920_ }
C {devices/lab_pin.sym} 124920 -800 0 0 {name=p124531 lab=_41007_/A }
C {devices/lab_pin.sym} 124920 -760 0 0 {name=p124532 lab=_41043_/B }
C {devices/lab_pin.sym} 125040 -780 0 1 {name=p124533 lab=_41043_/X }
C {sky130_stdcells/or2_4.sym} 124980 -780 0 0 {name=X_41043_ }
C {devices/lab_pin.sym} 125860 -42150 0 0 {name=p124534 lab=_52620_/A }
C {devices/lab_pin.sym} 125940 -42150 0 1 {name=p124535 lab=_53112_/A }
C {sky130_stdcells/buf_2.sym} 125900 -42150 0 0 {name=X_53029_ }
C {devices/lab_pin.sym} 125820 -42050 0 0 {name=p124536 lab=_57852_/X }
C {devices/lab_pin.sym} 125820 -42010 0 0 {name=p124537 lab=_85717_/Q }
C {devices/lab_pin.sym} 125820 -41970 0 0 {name=p124538 lab=_57878_/X }
C {devices/lab_pin.sym} 125980 -42010 0 1 {name=p124539 lab=_57906_/X }
C {sky130_stdcells/o21a_4.sym} 125900 -42010 0 0 {name=X_57906_ }
C {devices/lab_pin.sym} 125860 -41870 0 0 {name=p124540 lab=_76715_/Y }
C {devices/lab_pin.sym} 125940 -41870 0 1 {name=p124541 lab=_81354_/D }
C {sky130_stdcells/inv_2.sym} 125900 -41870 0 0 {name=X_76740_ }
C {devices/lab_pin.sym} 125820 -41780 0 0 {name=p124542 lab=_73854_/X }
C {devices/lab_pin.sym} 125820 -41740 0 0 {name=p124543 lab=_85617_/Q }
C {devices/lab_pin.sym} 125820 -41700 0 0 {name=p124544 lab=_73903_/X }
C {devices/lab_pin.sym} 125820 -41660 0 0 {name=p124545 lab=_73951_/X }
C {devices/lab_pin.sym} 125980 -41720 0 1 {name=p124546 lab=_73952_/X }
C {sky130_stdcells/a211o_4.sym} 125900 -41720 0 0 {name=X_73952_ }
C {devices/lab_pin.sym} 125810 -41570 0 0 {name=p124547 lab=_86096_/CLK }
C {devices/lab_pin.sym} 125810 -41550 0 0 {name=p124548 lab=_51834_/Y }
C {devices/lab_pin.sym} 125990 -41570 0 1 {name=p124549 lab=_85938_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -41560 0 0 {name=X_85938_ }
C {devices/lab_pin.sym} 125840 -41440 0 0 {name=p124550 lab=_58872_/A }
C {devices/lab_pin.sym} 125840 -41400 0 0 {name=p124551 lab=_86376_/Q }
C {devices/lab_pin.sym} 125960 -41420 0 1 {name=p124552 lab=_58886_/Y }
C {sky130_stdcells/nor2_4.sym} 125900 -41420 0 0 {name=X_58886_ }
C {devices/lab_pin.sym} 125820 -41310 0 0 {name=p124553 lab=_44526_/Y }
C {devices/lab_pin.sym} 125820 -41270 0 0 {name=p124554 lab=_72899_/X }
C {devices/lab_pin.sym} 125820 -41230 0 0 {name=p124555 lab=_72902_/Y }
C {devices/lab_pin.sym} 125980 -41270 0 1 {name=p124556 lab=_72904_/B }
C {sky130_stdcells/a21o_4.sym} 125900 -41270 0 0 {name=X_72903_ }
C {devices/lab_pin.sym} 125860 -41130 0 0 {name=p124557 lab=_57837_/A }
C {devices/lab_pin.sym} 125940 -41130 0 1 {name=p124558 lab=_58618_/A }
C {sky130_stdcells/buf_2.sym} 125900 -41130 0 0 {name=X_57837_ }
C {devices/lab_pin.sym} 125820 -41030 0 0 {name=p124559 lab=_45819_/X }
C {devices/lab_pin.sym} 125820 -40990 0 0 {name=p124560 lab=_61676_/A }
C {devices/lab_pin.sym} 125820 -40950 0 0 {name=p124561 lab=_45836_/X }
C {devices/lab_pin.sym} 125980 -40990 0 1 {name=p124562 lab=_45851_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -40990 0 0 {name=X_45851_ }
C {devices/lab_pin.sym} 125820 -40870 0 0 {name=p124563 lab=_76668_/X }
C {devices/lab_pin.sym} 125820 -40830 0 0 {name=p124564 lab=_76669_/Y }
C {devices/lab_pin.sym} 125820 -40790 0 0 {name=p124565 lab=_76672_/B }
C {devices/lab_pin.sym} 125980 -40830 0 1 {name=p124566 lab=_76673_/A }
C {sky130_stdcells/a21o_4.sym} 125900 -40830 0 0 {name=X_76671_ }
C {devices/lab_pin.sym} 125810 -40690 0 0 {name=p124567 lab=_85859_/CLK }
C {devices/lab_pin.sym} 125810 -40670 0 0 {name=p124568 lab=_85869_/D }
C {devices/lab_pin.sym} 125990 -40690 0 1 {name=p124569 lab=_85869_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -40680 0 0 {name=X_85869_ }
C {devices/lab_pin.sym} 125840 -40560 0 0 {name=p124570 lab=_73954_/A }
C {devices/lab_pin.sym} 125840 -40520 0 0 {name=p124571 lab=_66101_/B }
C {devices/lab_pin.sym} 125960 -40540 0 1 {name=p124572 lab=_73883_/X }
C {sky130_stdcells/and2_4.sym} 125900 -40540 0 0 {name=X_73883_ }
C {devices/lab_pin.sym} 125820 -40430 0 0 {name=p124573 lab=_78411_/A }
C {devices/lab_pin.sym} 125820 -40390 0 0 {name=p124574 lab=_78411_/B }
C {devices/lab_pin.sym} 125820 -40350 0 0 {name=p124575 lab=_78409_/Y }
C {devices/lab_pin.sym} 125980 -40390 0 1 {name=p124576 lab=_78413_/A }
C {sky130_stdcells/a21oi_4.sym} 125900 -40390 0 0 {name=X_78410_ }
C {devices/lab_pin.sym} 125860 -40250 0 0 {name=p124577 lab=_44802_/A }
C {devices/lab_pin.sym} 125940 -40250 0 1 {name=p124578 lab=_44802_/Y }
C {sky130_stdcells/inv_2.sym} 125900 -40250 0 0 {name=X_44802_ }
C {devices/lab_pin.sym} 125810 -40130 0 0 {name=p124579 lab=_82899_/CLK }
C {devices/lab_pin.sym} 125810 -40110 0 0 {name=p124580 lab=_43004_/X }
C {devices/lab_pin.sym} 125990 -40130 0 1 {name=p124581 lab=_87608_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -40120 0 0 {name=X_87608_ }
C {devices/lab_pin.sym} 125860 -39990 0 0 {name=p124582 lab=_75622_/A }
C {devices/lab_pin.sym} 125940 -39990 0 1 {name=p124583 lab=_75622_/Y }
C {sky130_stdcells/inv_2.sym} 125900 -39990 0 0 {name=X_75622_ }
C {devices/lab_pin.sym} 125820 -39890 0 0 {name=p124584 lab=_48562_/Y }
C {devices/lab_pin.sym} 125820 -39850 0 0 {name=p124585 lab=_48517_/X }
C {devices/lab_pin.sym} 125820 -39810 0 0 {name=p124586 lab=_48569_/X }
C {devices/lab_pin.sym} 125980 -39850 0 1 {name=p124587 lab=_86511_/D }
C {sky130_stdcells/a21oi_4.sym} 125900 -39850 0 0 {name=X_48570_ }
C {devices/lab_pin.sym} 125820 -39730 0 0 {name=p124588 lab=_69612_/B }
C {devices/lab_pin.sym} 125820 -39690 0 0 {name=p124589 lab=_72803_/X }
C {devices/lab_pin.sym} 125820 -39650 0 0 {name=p124590 lab=_72776_/X }
C {devices/lab_pin.sym} 125980 -39690 0 1 {name=p124591 lab=_72834_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -39690 0 0 {name=X_72834_ }
C {devices/lab_pin.sym} 125840 -39560 0 0 {name=p124592 lab=_79387_/X }
C {devices/lab_pin.sym} 125840 -39520 0 0 {name=p124593 lab=_79390_/B }
C {devices/lab_pin.sym} 125960 -39540 0 1 {name=p124594 lab=_82837_/D }
C {sky130_stdcells/xor2_4.sym} 125900 -39540 0 0 {name=X_79390_ }
C {devices/lab_pin.sym} 125820 -39430 0 0 {name=p124595 lab=_55248_/B }
C {devices/lab_pin.sym} 125820 -39390 0 0 {name=p124596 lab=_45705_/X }
C {devices/lab_pin.sym} 125820 -39350 0 0 {name=p124597 lab=_45389_/X }
C {devices/lab_pin.sym} 125980 -39390 0 1 {name=p124598 lab=_45782_/X }
C {sky130_stdcells/o21a_4.sym} 125900 -39390 0 0 {name=X_45782_ }
C {devices/lab_pin.sym} 125860 -39250 0 0 {name=p124599 lab=_58784_/A }
C {devices/lab_pin.sym} 125940 -39250 0 1 {name=p124600 lab=_64923_/A }
C {sky130_stdcells/buf_2.sym} 125900 -39250 0 0 {name=X_57768_ }
C {devices/lab_pin.sym} 125860 -39130 0 0 {name=p124601 lab=_52021_/A }
C {devices/lab_pin.sym} 125940 -39130 0 1 {name=p124602 lab=_42994_/X }
C {sky130_stdcells/buf_2.sym} 125900 -39130 0 0 {name=X_42994_ }
C {devices/lab_pin.sym} 125860 -39010 0 0 {name=p124603 lab=_47521_/A }
C {devices/lab_pin.sym} 125940 -39010 0 1 {name=p124604 lab=_53099_/D }
C {sky130_stdcells/buf_2.sym} 125900 -39010 0 0 {name=X_47521_ }
C {devices/lab_pin.sym} 125820 -38910 0 0 {name=p124605 lab=_46159_/X }
C {devices/lab_pin.sym} 125820 -38870 0 0 {name=p124606 lab=_59504_/Y }
C {devices/lab_pin.sym} 125820 -38830 0 0 {name=p124607 lab=_59506_/Y }
C {devices/lab_pin.sym} 125980 -38870 0 1 {name=p124608 lab=_59507_/Y }
C {sky130_stdcells/a21oi_4.sym} 125900 -38870 0 0 {name=X_59507_ }
C {devices/lab_pin.sym} 125840 -38740 0 0 {name=p124609 lab=_78341_/A }
C {devices/lab_pin.sym} 125840 -38700 0 0 {name=p124610 lab=_82756_/D }
C {devices/lab_pin.sym} 125960 -38720 0 1 {name=p124611 lab=_78341_/X }
C {sky130_stdcells/xor2_4.sym} 125900 -38720 0 0 {name=X_78341_ }
C {devices/lab_pin.sym} 125860 -38590 0 0 {name=p124612 lab=_44733_/A }
C {devices/lab_pin.sym} 125940 -38590 0 1 {name=p124613 lab=_49210_/A }
C {sky130_stdcells/buf_2.sym} 125900 -38590 0 0 {name=X_44733_ }
C {devices/lab_pin.sym} 125840 -38490 0 0 {name=p124614 lab=_56719_/A }
C {devices/lab_pin.sym} 125840 -38450 0 0 {name=p124615 lab=_56719_/B }
C {devices/lab_pin.sym} 125840 -38410 0 0 {name=p124616 lab=_46237_/A }
C {devices/lab_pin.sym} 125960 -38450 0 1 {name=p124617 lab=_56724_/A }
C {sky130_stdcells/nand3_4.sym} 125900 -38450 0 0 {name=X_56719_ }
C {devices/lab_pin.sym} 125840 -38320 0 0 {name=p124618 lab=_75562_/A }
C {devices/lab_pin.sym} 125840 -38280 0 0 {name=p124619 lab=_75552_/X }
C {devices/lab_pin.sym} 125960 -38300 0 1 {name=p124620 lab=_75553_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -38300 0 0 {name=X_75553_ }
C {devices/lab_pin.sym} 125810 -38170 0 0 {name=p124621 lab=_88087_/CLK }
C {devices/lab_pin.sym} 125810 -38150 0 0 {name=p124622 lab=_43205_/X }
C {devices/lab_pin.sym} 125990 -38170 0 1 {name=p124623 lab=_87539_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -38160 0 0 {name=X_87539_ }
C {devices/lab_pin.sym} 125820 -38070 0 0 {name=p124624 lab=_41932_/X }
C {devices/lab_pin.sym} 125820 -38030 0 0 {name=p124625 lab=_41927_/X }
C {devices/lab_pin.sym} 125820 -37990 0 0 {name=p124626 lab=_40691_/X }
C {devices/lab_pin.sym} 125820 -37950 0 0 {name=p124627 lab=_73987_/A }
C {devices/lab_pin.sym} 125820 -37910 0 0 {name=p124628 lab=_41928_/X }
C {devices/lab_pin.sym} 125980 -37990 0 1 {name=p124629 lab=_41945_/Y }
C {sky130_stdcells/o32ai_4.sym} 125900 -37990 0 0 {name=X_41945_ }
C {devices/lab_pin.sym} 125860 -37830 0 0 {name=p124630 lab=_72765_/A }
C {devices/lab_pin.sym} 125940 -37830 0 1 {name=p124631 lab=_74140_/A }
C {sky130_stdcells/buf_2.sym} 125900 -37830 0 0 {name=X_72765_ }
C {devices/lab_pin.sym} 125860 -37710 0 0 {name=p124632 lab=_58602_/A }
C {devices/lab_pin.sym} 125940 -37710 0 1 {name=p124633 lab=_58098_/A }
C {sky130_stdcells/buf_2.sym} 125900 -37710 0 0 {name=X_57699_ }
C {devices/lab_pin.sym} 125860 -37590 0 0 {name=p124634 lab=clkbuf_8_43_0_CLK/A }
C {devices/lab_pin.sym} 125940 -37590 0 1 {name=p124635 lab=clkbuf_8_42_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 125900 -37590 0 0 {name=Xclkbuf_8_42_0_CLK }
C {devices/lab_pin.sym} 125820 -37490 0 0 {name=p124636 lab=_83052_/Q }
C {devices/lab_pin.sym} 125820 -37450 0 0 {name=p124637 lab=_46250_/X }
C {devices/lab_pin.sym} 125820 -37410 0 0 {name=p124638 lab=_74503_/Y }
C {devices/lab_pin.sym} 125980 -37450 0 1 {name=p124639 lab=_74504_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -37450 0 0 {name=X_74504_ }
C {devices/lab_pin.sym} 125840 -37320 0 0 {name=p124640 lab=_47444_/A }
C {devices/lab_pin.sym} 125840 -37280 0 0 {name=p124641 lab=_53054_/B }
C {devices/lab_pin.sym} 125960 -37300 0 1 {name=p124642 lab=_47452_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -37300 0 0 {name=X_47452_ }
C {devices/lab_pin.sym} 125840 -37200 0 0 {name=p124643 lab=_71160_/C }
C {devices/lab_pin.sym} 125840 -37160 0 0 {name=p124644 lab=_71716_/B }
C {devices/lab_pin.sym} 125840 -37120 0 0 {name=p124645 lab=_70763_/A }
C {devices/lab_pin.sym} 125840 -37080 0 0 {name=p124646 lab=_71716_/D }
C {devices/lab_pin.sym} 125960 -37140 0 1 {name=p124647 lab=_71716_/X }
C {sky130_stdcells/and4_4.sym} 125900 -37140 0 0 {name=X_71716_ }
C {devices/lab_pin.sym} 125820 -37010 0 0 {name=p124648 lab=_59426_/X }
C {devices/lab_pin.sym} 125820 -36970 0 0 {name=p124649 lab=_59436_/Y }
C {devices/lab_pin.sym} 125820 -36930 0 0 {name=p124650 lab=_59437_/Y }
C {devices/lab_pin.sym} 125980 -36970 0 1 {name=p124651 lab=_59438_/Y }
C {sky130_stdcells/a21oi_4.sym} 125900 -36970 0 0 {name=X_59438_ }
C {devices/lab_pin.sym} 125860 -36830 0 0 {name=p124652 lab=_78271_/X }
C {devices/lab_pin.sym} 125940 -36830 0 1 {name=p124653 lab=_78274_/A }
C {sky130_stdcells/buf_2.sym} 125900 -36830 0 0 {name=X_78272_ }
C {devices/lab_pin.sym} 125820 -36740 0 0 {name=p124654 lab=_41098_/A }
C {devices/lab_pin.sym} 125820 -36700 0 0 {name=p124655 lab=_44648_/X }
C {devices/lab_pin.sym} 125820 -36660 0 0 {name=p124656 lab=_87010_/Q }
C {devices/lab_pin.sym} 125820 -36620 0 0 {name=p124657 lab=_44650_/X }
C {devices/lab_pin.sym} 125980 -36680 0 1 {name=p124658 lab=_44664_/X }
C {sky130_stdcells/a2bb2o_4.sym} 125900 -36680 0 0 {name=X_44664_ }
C {devices/lab_pin.sym} 125860 -36530 0 0 {name=p124659 lab=_75506_/D }
C {devices/lab_pin.sym} 125940 -36530 0 1 {name=p124660 lab=_75486_/A }
C {sky130_stdcells/inv_2.sym} 125900 -36530 0 0 {name=X_75484_ }
C {devices/lab_pin.sym} 125860 -36410 0 0 {name=p124661 lab=_41875_/Y }
C {devices/lab_pin.sym} 125940 -36410 0 1 {name=p124662 lab=_88114_/D }
C {sky130_stdcells/inv_2.sym} 125900 -36410 0 0 {name=X_41876_ }
C {devices/lab_pin.sym} 125820 -36310 0 0 {name=p124663 lab=_70239_/C }
C {devices/lab_pin.sym} 125820 -36270 0 0 {name=p124664 lab=_72686_/X }
C {devices/lab_pin.sym} 125820 -36230 0 0 {name=p124665 lab=_72695_/Y }
C {devices/lab_pin.sym} 125980 -36270 0 1 {name=p124666 lab=_83186_/D }
C {sky130_stdcells/a21bo_4.sym} 125900 -36270 0 0 {name=X_72696_ }
C {devices/lab_pin.sym} 125860 -36130 0 0 {name=p124667 lab=_47904_/A }
C {devices/lab_pin.sym} 125940 -36130 0 1 {name=p124668 lab=_46403_/X }
C {sky130_stdcells/buf_2.sym} 125900 -36130 0 0 {name=X_46403_ }
C {devices/lab_pin.sym} 125840 -36020 0 0 {name=p124669 lab=_77223_/A }
C {devices/lab_pin.sym} 125840 -35980 0 0 {name=p124670 lab=_77222_/Y }
C {devices/lab_pin.sym} 125960 -36000 0 1 {name=p124671 lab=_77223_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -36000 0 0 {name=X_77223_ }
C {devices/lab_pin.sym} 125820 -35900 0 0 {name=p124672 lab=_40610_/A }
C {devices/lab_pin.sym} 125820 -35860 0 0 {name=p124673 lab=_43609_/X }
C {devices/lab_pin.sym} 125820 -35820 0 0 {name=p124674 lab=_68495_/B }
C {devices/lab_pin.sym} 125820 -35780 0 0 {name=p124675 lab=_43611_/X }
C {devices/lab_pin.sym} 125980 -35840 0 1 {name=p124676 lab=_43616_/A }
C {sky130_stdcells/a2bb2o_4.sym} 125900 -35840 0 0 {name=X_43615_ }
C {devices/lab_pin.sym} 125840 -35710 0 0 {name=p124677 lab=_48522_/A }
C {devices/lab_pin.sym} 125840 -35670 0 0 {name=p124678 lab=_74420_/X }
C {devices/lab_pin.sym} 125840 -35630 0 0 {name=p124679 lab=_74425_/X }
C {devices/lab_pin.sym} 125960 -35670 0 1 {name=p124680 lab=_74435_/X }
C {sky130_stdcells/and3_4.sym} 125900 -35670 0 0 {name=X_74435_ }
C {devices/lab_pin.sym} 125820 -35570 0 0 {name=p124681 lab=_40758_/X }
C {devices/lab_pin.sym} 125820 -35530 0 0 {name=p124682 lab=_40759_/X }
C {devices/lab_pin.sym} 125820 -35490 0 0 {name=p124683 lab=_40826_/X }
C {devices/lab_pin.sym} 125820 -35450 0 0 {name=p124684 lab=_69725_/B }
C {devices/lab_pin.sym} 125820 -35410 0 0 {name=p124685 lab=_40744_/X }
C {devices/lab_pin.sym} 125980 -35490 0 1 {name=p124686 lab=_40828_/A }
C {sky130_stdcells/o32ai_4.sym} 125900 -35490 0 0 {name=X_40827_ }
C {devices/lab_pin.sym} 125860 -35330 0 0 {name=p124687 lab=_57563_/A }
C {devices/lab_pin.sym} 125940 -35330 0 1 {name=p124688 lab=_47525_/A }
C {sky130_stdcells/buf_2.sym} 125900 -35330 0 0 {name=X_47383_ }
C {devices/lab_pin.sym} 125820 -35230 0 0 {name=p124689 lab=_59219_/X }
C {devices/lab_pin.sym} 125820 -35190 0 0 {name=p124690 lab=_85731_/Q }
C {devices/lab_pin.sym} 125820 -35150 0 0 {name=p124691 lab=_59220_/X }
C {devices/lab_pin.sym} 125980 -35190 0 1 {name=p124692 lab=_59369_/X }
C {sky130_stdcells/o21a_4.sym} 125900 -35190 0 0 {name=X_59369_ }
C {devices/lab_pin.sym} 125820 -35070 0 0 {name=p124693 lab=_59504_/Y }
C {devices/lab_pin.sym} 125820 -35030 0 0 {name=p124694 lab=_71628_/A }
C {devices/lab_pin.sym} 125820 -34990 0 0 {name=p124695 lab=_71646_/Y }
C {devices/lab_pin.sym} 125980 -35030 0 1 {name=p124696 lab=_71647_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -35030 0 0 {name=X_71647_ }
C {devices/lab_pin.sym} 125860 -34890 0 0 {name=p124697 lab=_87042_/Q }
C {devices/lab_pin.sym} 125940 -34890 0 1 {name=p124698 lab=_44595_/Y }
C {sky130_stdcells/inv_2.sym} 125900 -34890 0 0 {name=X_44595_ }
C {devices/lab_pin.sym} 125840 -34780 0 0 {name=p124699 lab=_49080_/A }
C {devices/lab_pin.sym} 125840 -34740 0 0 {name=p124700 lab=_53902_/B }
C {devices/lab_pin.sym} 125960 -34760 0 1 {name=p124701 lab=_49122_/X }
C {sky130_stdcells/and2_4.sym} 125900 -34760 0 0 {name=X_49122_ }
C {devices/lab_pin.sym} 125860 -34630 0 0 {name=p124702 lab=_61302_/Y }
C {devices/lab_pin.sym} 125940 -34630 0 1 {name=p124703 lab=_61400_/X }
C {sky130_stdcells/buf_2.sym} 125900 -34630 0 0 {name=X_61400_ }
C {devices/lab_pin.sym} 125860 -34510 0 0 {name=p124704 lab=_53976_/B }
C {devices/lab_pin.sym} 125940 -34510 0 1 {name=p124705 lab=_49241_/B }
C {sky130_stdcells/buf_2.sym} 125900 -34510 0 0 {name=X_46334_ }
C {devices/lab_pin.sym} 125840 -34400 0 0 {name=p124706 lab=_77154_/A }
C {devices/lab_pin.sym} 125840 -34360 0 0 {name=p124707 lab=_77151_/A }
C {devices/lab_pin.sym} 125960 -34380 0 1 {name=p124708 lab=_77155_/B }
C {sky130_stdcells/and2_4.sym} 125900 -34380 0 0 {name=X_77154_ }
C {devices/lab_pin.sym} 125860 -34250 0 0 {name=p124709 lab=_43760_/A }
C {devices/lab_pin.sym} 125940 -34250 0 1 {name=p124710 lab=_43546_/X }
C {sky130_stdcells/buf_2.sym} 125900 -34250 0 0 {name=X_43546_ }
C {devices/lab_pin.sym} 125820 -34170 0 0 {name=p124711 lab=_61460_/B }
C {devices/lab_pin.sym} 125820 -34130 0 0 {name=p124712 lab=_62278_/X }
C {devices/lab_pin.sym} 125820 -34090 0 0 {name=p124713 lab=_62363_/X }
C {devices/lab_pin.sym} 125820 -34050 0 0 {name=p124714 lab=_62323_/X }
C {devices/lab_pin.sym} 125820 -34020 0 0 {name=p124715 lab=_62379_/X }
C {devices/lab_pin.sym} 125980 -34090 0 1 {name=p124716 lab=_62380_/X }
C {sky130_stdcells/a41o_4.sym} 125900 -34090 0 0 {name=X_62380_ }
C {devices/lab_pin.sym} 125840 -33950 0 0 {name=p124717 lab=_74366_/A }
C {devices/lab_pin.sym} 125840 -33910 0 0 {name=p124718 lab=_72113_/B }
C {devices/lab_pin.sym} 125840 -33870 0 0 {name=p124719 lab=_74366_/C }
C {devices/lab_pin.sym} 125960 -33910 0 1 {name=p124720 lab=_74366_/X }
C {sky130_stdcells/and3_4.sym} 125900 -33910 0 0 {name=X_74366_ }
C {devices/lab_pin.sym} 125860 -33770 0 0 {name=p124721 lab=_40835_/A }
C {devices/lab_pin.sym} 125940 -33770 0 1 {name=p124722 lab=_40758_/X }
C {sky130_stdcells/buf_2.sym} 125900 -33770 0 0 {name=X_40758_ }
C {devices/lab_pin.sym} 125820 -33670 0 0 {name=p124723 lab=_71556_/Y }
C {devices/lab_pin.sym} 125820 -33630 0 0 {name=p124724 lab=_83450_/Q }
C {devices/lab_pin.sym} 125820 -33590 0 0 {name=p124725 lab=_71577_/Y }
C {devices/lab_pin.sym} 125980 -33630 0 1 {name=p124726 lab=_71578_/X }
C {sky130_stdcells/a21o_4.sym} 125900 -33630 0 0 {name=X_71578_ }
C {devices/lab_pin.sym} 125860 -33490 0 0 {name=p124727 lab=clkbuf_8_57_0_CLK/A }
C {devices/lab_pin.sym} 125940 -33490 0 1 {name=p124728 lab=clkbuf_8_57_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 125900 -33490 0 0 {name=Xclkbuf_8_57_0_CLK }
C {devices/lab_pin.sym} 125840 -33380 0 0 {name=p124729 lab=_81724_/D }
C {devices/lab_pin.sym} 125840 -33340 0 0 {name=p124730 lab=_76126_/C }
C {devices/lab_pin.sym} 125960 -33360 0 1 {name=p124731 lab=_76112_/A }
C {sky130_stdcells/xor2_4.sym} 125900 -33360 0 0 {name=X_76105_ }
C {devices/lab_pin.sym} 125860 -33230 0 0 {name=p124732 lab=_48898_/A }
C {devices/lab_pin.sym} 125940 -33230 0 1 {name=p124733 lab=_49056_/A }
C {sky130_stdcells/buf_2.sym} 125900 -33230 0 0 {name=X_49053_ }
C {devices/lab_pin.sym} 125820 -33130 0 0 {name=p124734 lab=_83156_/Q }
C {devices/lab_pin.sym} 125820 -33090 0 0 {name=p124735 lab=_73193_/X }
C {devices/lab_pin.sym} 125820 -33050 0 0 {name=p124736 lab=_73316_/Y }
C {devices/lab_pin.sym} 125980 -33090 0 1 {name=p124737 lab=_73317_/X }
C {sky130_stdcells/a21o_4.sym} 125900 -33090 0 0 {name=X_73317_ }
C {devices/lab_pin.sym} 125860 -32950 0 0 {name=p124738 lab=_72563_/C }
C {devices/lab_pin.sym} 125940 -32950 0 1 {name=p124739 lab=_61377_/C }
C {sky130_stdcells/buf_2.sym} 125900 -32950 0 0 {name=X_61331_ }
C {devices/lab_pin.sym} 125840 -32840 0 0 {name=p124740 lab=_46265_/A }
C {devices/lab_pin.sym} 125840 -32800 0 0 {name=p124741 lab=_46328_/B }
C {devices/lab_pin.sym} 125960 -32820 0 1 {name=p124742 lab=_46265_/X }
C {sky130_stdcells/or2_4.sym} 125900 -32820 0 0 {name=X_46265_ }
C {devices/lab_pin.sym} 125860 -32690 0 0 {name=p124743 lab=_70694_/A }
C {devices/lab_pin.sym} 125940 -32690 0 1 {name=p124744 lab=_71823_/A }
C {sky130_stdcells/buf_2.sym} 125900 -32690 0 0 {name=X_70529_ }
C {devices/lab_pin.sym} 125840 -32590 0 0 {name=p124745 lab=_77077_/A }
C {devices/lab_pin.sym} 125840 -32550 0 0 {name=p124746 lab=_77066_/A }
C {devices/lab_pin.sym} 125840 -32510 0 0 {name=p124747 lab=_82284_/D }
C {devices/lab_pin.sym} 125960 -32550 0 1 {name=p124748 lab=_77085_/Y }
C {sky130_stdcells/nand3_4.sym} 125900 -32550 0 0 {name=X_77085_ }
C {devices/lab_pin.sym} 125860 -32410 0 0 {name=p124749 lab=_43477_/A }
C {devices/lab_pin.sym} 125940 -32410 0 1 {name=p124750 lab=_43477_/Y }
C {sky130_stdcells/inv_2.sym} 125900 -32410 0 0 {name=X_43477_ }
C {devices/lab_pin.sym} 125840 -32310 0 0 {name=p124751 lab=_74297_/A }
C {devices/lab_pin.sym} 125840 -32270 0 0 {name=p124752 lab=_74297_/B }
C {devices/lab_pin.sym} 125840 -32230 0 0 {name=p124753 lab=_74297_/C }
C {devices/lab_pin.sym} 125960 -32270 0 1 {name=p124754 lab=_74297_/Y }
C {sky130_stdcells/nand3_4.sym} 125900 -32270 0 0 {name=X_74297_ }
C {devices/lab_pin.sym} 125840 -32140 0 0 {name=p124755 lab=_40689_/A }
C {devices/lab_pin.sym} 125840 -32100 0 0 {name=p124756 lab=_40654_/B }
C {devices/lab_pin.sym} 125960 -32120 0 1 {name=p124757 lab=_40689_/X }
C {sky130_stdcells/or2_4.sym} 125900 -32120 0 0 {name=X_40689_ }
C {devices/lab_pin.sym} 125840 -32000 0 0 {name=p124758 lab=_48004_/A }
C {devices/lab_pin.sym} 125840 -31960 0 0 {name=p124759 lab=_50310_/B }
C {devices/lab_pin.sym} 125960 -31980 0 1 {name=p124760 lab=_48004_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -31980 0 0 {name=X_48004_ }
C {devices/lab_pin.sym} 125840 -31860 0 0 {name=p124761 lab=_45216_/A }
C {devices/lab_pin.sym} 125840 -31820 0 0 {name=p124762 lab=_45199_/B }
C {devices/lab_pin.sym} 125960 -31840 0 1 {name=p124763 lab=_45216_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -31840 0 0 {name=X_45216_ }
C {devices/lab_pin.sym} 125840 -31740 0 0 {name=p124764 lab=_62027_/X }
C {devices/lab_pin.sym} 125840 -31700 0 0 {name=p124765 lab=_64095_/B }
C {devices/lab_pin.sym} 125840 -31660 0 0 {name=p124766 lab=_64050_/C }
C {devices/lab_pin.sym} 125840 -31620 0 0 {name=p124767 lab=_64095_/D }
C {devices/lab_pin.sym} 125960 -31680 0 1 {name=p124768 lab=_64050_/Y }
C {sky130_stdcells/nand4_4.sym} 125900 -31680 0 0 {name=X_64050_ }
C {devices/lab_pin.sym} 125840 -31550 0 0 {name=p124769 lab=_76028_/A }
C {devices/lab_pin.sym} 125840 -31510 0 0 {name=p124770 lab=_81712_/D }
C {devices/lab_pin.sym} 125840 -31470 0 0 {name=p124771 lab=_76036_/C }
C {devices/lab_pin.sym} 125960 -31510 0 1 {name=p124772 lab=_76037_/A }
C {sky130_stdcells/nand3_4.sym} 125900 -31510 0 0 {name=X_76036_ }
C {devices/lab_pin.sym} 125820 -31400 0 0 {name=p124773 lab=_40507_/X }
C {devices/lab_pin.sym} 125820 -31360 0 0 {name=p124774 lab=_42414_/X }
C {devices/lab_pin.sym} 125820 -31320 0 0 {name=p124775 lab=_87868_/Q }
C {devices/lab_pin.sym} 125820 -31280 0 0 {name=p124776 lab=_42415_/X }
C {devices/lab_pin.sym} 125980 -31340 0 1 {name=p124777 lab=_42428_/X }
C {sky130_stdcells/a2bb2o_4.sym} 125900 -31340 0 0 {name=X_42428_ }
C {devices/lab_pin.sym} 125840 -31210 0 0 {name=p124778 lab=_61262_/A }
C {devices/lab_pin.sym} 125840 -31170 0 0 {name=p124779 lab=_72544_/B }
C {devices/lab_pin.sym} 125840 -31130 0 0 {name=p124780 lab=_61262_/C }
C {devices/lab_pin.sym} 125960 -31170 0 1 {name=p124781 lab=_61262_/Y }
C {sky130_stdcells/nor3_4.sym} 125900 -31170 0 0 {name=X_61262_ }
C {devices/lab_pin.sym} 125820 -31060 0 0 {name=p124782 lab=_69820_/Y }
C {devices/lab_pin.sym} 125820 -31020 0 0 {name=p124783 lab=_73224_/X }
C {devices/lab_pin.sym} 125820 -30980 0 0 {name=p124784 lab=_73194_/X }
C {devices/lab_pin.sym} 125820 -30940 0 0 {name=p124785 lab=_73247_/Y }
C {devices/lab_pin.sym} 125980 -31000 0 1 {name=p124786 lab=_73248_/X }
C {sky130_stdcells/a211o_4.sym} 125900 -31000 0 0 {name=X_73248_ }
C {devices/lab_pin.sym} 125840 -30870 0 0 {name=p124787 lab=_46196_/A }
C {devices/lab_pin.sym} 125840 -30830 0 0 {name=p124788 lab=_74842_/B }
C {devices/lab_pin.sym} 125840 -30790 0 0 {name=p124789 lab=_46195_/Y }
C {devices/lab_pin.sym} 125960 -30830 0 1 {name=p124790 lab=_86762_/D }
C {sky130_stdcells/and3_4.sym} 125900 -30830 0 0 {name=X_46196_ }
C {devices/lab_pin.sym} 125860 -30690 0 0 {name=p124791 lab=_63001_/A }
C {devices/lab_pin.sym} 125940 -30690 0 1 {name=p124792 lab=_63281_/B }
C {sky130_stdcells/buf_2.sym} 125900 -30690 0 0 {name=X_63001_ }
C {devices/lab_pin.sym} 125860 -30570 0 0 {name=p124793 lab=_60105_/X }
C {devices/lab_pin.sym} 125940 -30570 0 1 {name=p124794 lab=_60244_/A }
C {sky130_stdcells/buf_2.sym} 125900 -30570 0 0 {name=X_60213_ }
C {devices/lab_pin.sym} 125860 -30450 0 0 {name=p124795 lab=_45297_/A }
C {devices/lab_pin.sym} 125940 -30450 0 1 {name=p124796 lab=_45147_/X }
C {sky130_stdcells/buf_2.sym} 125900 -30450 0 0 {name=X_45147_ }
C {devices/lab_pin.sym} 125820 -30370 0 0 {name=p124797 lab=_42350_/X }
C {devices/lab_pin.sym} 125820 -30330 0 0 {name=p124798 lab=_42346_/X }
C {devices/lab_pin.sym} 125820 -30290 0 0 {name=p124799 lab=_41735_/X }
C {devices/lab_pin.sym} 125820 -30250 0 0 {name=p124800 lab=_87903_/Q }
C {devices/lab_pin.sym} 125820 -30210 0 0 {name=p124801 lab=_42347_/X }
C {devices/lab_pin.sym} 125980 -30290 0 1 {name=p124802 lab=_42360_/A }
C {sky130_stdcells/o32ai_4.sym} 125900 -30290 0 0 {name=X_42359_ }
C {devices/lab_pin.sym} 125820 -30170 0 0 {name=p124803 lab=_61190_/X }
C {devices/lab_pin.sym} 125820 -30130 0 0 {name=p124804 lab=_61154_/X }
C {devices/lab_pin.sym} 125820 -30090 0 0 {name=p124805 lab=_61170_/Y }
C {devices/lab_pin.sym} 125820 -30050 0 0 {name=p124806 lab=_61173_/Y }
C {devices/lab_pin.sym} 125820 -30020 0 0 {name=p124807 lab=_61192_/Y }
C {devices/lab_pin.sym} 125980 -30090 0 1 {name=p124808 lab=_84510_/D }
C {sky130_stdcells/a41oi_4.sym} 125900 -30090 0 0 {name=X_61193_ }
C {devices/lab_pin.sym} 125820 -29950 0 0 {name=p124809 lab=_73176_/X }
C {devices/lab_pin.sym} 125820 -29910 0 0 {name=p124810 lab=_73178_/X }
C {devices/lab_pin.sym} 125820 -29870 0 0 {name=p124811 lab=_72866_/X }
C {devices/lab_pin.sym} 125980 -29910 0 1 {name=p124812 lab=_73179_/X }
C {sky130_stdcells/a21o_4.sym} 125900 -29910 0 0 {name=X_73179_ }
C {devices/lab_pin.sym} 125860 -29770 0 0 {name=p124813 lab=_60143_/X }
C {devices/lab_pin.sym} 125940 -29770 0 1 {name=p124814 lab=_60144_/Y }
C {sky130_stdcells/inv_2.sym} 125900 -29770 0 0 {name=X_60144_ }
C {devices/lab_pin.sym} 125840 -29660 0 0 {name=p124815 lab=_49955_/A }
C {devices/lab_pin.sym} 125840 -29620 0 0 {name=p124816 lab=_53167_/B }
C {devices/lab_pin.sym} 125960 -29640 0 1 {name=p124817 lab=_49955_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -29640 0 0 {name=X_49955_ }
C {devices/lab_pin.sym} 125820 -29530 0 0 {name=p124818 lab=_45075_/Y }
C {devices/lab_pin.sym} 125820 -29490 0 0 {name=p124819 lab=_45077_/Y }
C {devices/lab_pin.sym} 125820 -29450 0 0 {name=p124820 lab=_45063_/X }
C {devices/lab_pin.sym} 125980 -29490 0 1 {name=p124821 lab=_45078_/X }
C {sky130_stdcells/a21o_4.sym} 125900 -29490 0 0 {name=X_45078_ }
C {devices/lab_pin.sym} 125840 -29360 0 0 {name=p124822 lab=_77999_/A }
C {devices/lab_pin.sym} 125840 -29320 0 0 {name=p124823 lab=_77999_/B }
C {devices/lab_pin.sym} 125960 -29340 0 1 {name=p124824 lab=_78010_/A }
C {sky130_stdcells/xor2_4.sym} 125900 -29340 0 0 {name=X_77987_ }
C {devices/lab_pin.sym} 125820 -29230 0 0 {name=p124825 lab=_46240_/A }
C {devices/lab_pin.sym} 125820 -29190 0 0 {name=p124826 lab=_48384_/Y }
C {devices/lab_pin.sym} 125820 -29150 0 0 {name=p124827 lab=_48905_/Y }
C {devices/lab_pin.sym} 125980 -29190 0 1 {name=p124828 lab=_52275_/B }
C {sky130_stdcells/a21o_4.sym} 125900 -29190 0 0 {name=X_48906_ }
C {devices/lab_pin.sym} 125860 -29050 0 0 {name=p124829 lab=_64731_/A }
C {devices/lab_pin.sym} 125940 -29050 0 1 {name=p124830 lab=_60371_/A }
C {sky130_stdcells/buf_2.sym} 125900 -29050 0 0 {name=X_44029_ }
C {devices/lab_pin.sym} 125840 -28940 0 0 {name=p124831 lab=_67739_/X }
C {devices/lab_pin.sym} 125840 -28900 0 0 {name=p124832 lab=_86926_/Q }
C {devices/lab_pin.sym} 125960 -28920 0 1 {name=p124833 lab=_67740_/X }
C {sky130_stdcells/and2_4.sym} 125900 -28920 0 0 {name=X_67740_ }
C {devices/lab_pin.sym} 125820 -28820 0 0 {name=p124834 lab=_79702_/A }
C {devices/lab_pin.sym} 125820 -28780 0 0 {name=p124835 lab=_79701_/Y }
C {devices/lab_pin.sym} 125820 -28740 0 0 {name=p124836 lab=_79711_/X }
C {devices/lab_pin.sym} 125820 -28700 0 0 {name=p124837 lab=_79714_/Y }
C {devices/lab_pin.sym} 125980 -28760 0 1 {name=p124838 lab=_79726_/X }
C {sky130_stdcells/o22a_4.sym} 125900 -28760 0 0 {name=X_79726_ }
C {devices/lab_pin.sym} 125820 -28640 0 0 {name=p124839 lab=_64797_/X }
C {devices/lab_pin.sym} 125820 -28600 0 0 {name=p124840 lab=_83300_/Q }
C {devices/lab_pin.sym} 125820 -28560 0 0 {name=p124841 lab=_64772_/X }
C {devices/lab_pin.sym} 125820 -28520 0 0 {name=p124842 lab=_64951_/X }
C {devices/lab_pin.sym} 125980 -28580 0 1 {name=p124843 lab=_64953_/B }
C {sky130_stdcells/a211o_4.sym} 125900 -28580 0 0 {name=X_64952_ }
C {devices/lab_pin.sym} 125820 -28470 0 0 {name=p124844 lab=_60071_/X }
C {devices/lab_pin.sym} 125820 -28430 0 0 {name=p124845 lab=_60073_/Y }
C {devices/lab_pin.sym} 125820 -28390 0 0 {name=p124846 lab=_59969_/X }
C {devices/lab_pin.sym} 125820 -28350 0 0 {name=p124847 lab=_80091_/A }
C {devices/lab_pin.sym} 125820 -28310 0 0 {name=p124848 lab=_60074_/X }
C {devices/lab_pin.sym} 125980 -28390 0 1 {name=p124849 lab=_60075_/Y }
C {sky130_stdcells/o32ai_4.sym} 125900 -28390 0 0 {name=X_60075_ }
C {devices/lab_pin.sym} 125840 -28240 0 0 {name=p124850 lab=_76939_/A }
C {devices/lab_pin.sym} 125840 -28200 0 0 {name=p124851 lab=_76938_/B }
C {devices/lab_pin.sym} 125960 -28220 0 1 {name=p124852 lab=_76938_/X }
C {sky130_stdcells/xor2_4.sym} 125900 -28220 0 0 {name=X_76938_ }
C {devices/lab_pin.sym} 125840 -28100 0 0 {name=p124853 lab=_49901_/A }
C {devices/lab_pin.sym} 125840 -28060 0 0 {name=p124854 lab=_53101_/B }
C {devices/lab_pin.sym} 125960 -28080 0 1 {name=p124855 lab=_49886_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -28080 0 0 {name=X_49886_ }
C {devices/lab_pin.sym} 125840 -27980 0 0 {name=p124856 lab=_63899_/Y }
C {devices/lab_pin.sym} 125840 -27940 0 0 {name=p124857 lab=_63903_/B }
C {devices/lab_pin.sym} 125840 -27900 0 0 {name=p124858 lab=_63901_/Y }
C {devices/lab_pin.sym} 125840 -27860 0 0 {name=p124859 lab=_63903_/D }
C {devices/lab_pin.sym} 125960 -27920 0 1 {name=p124860 lab=_63903_/X }
C {sky130_stdcells/and4_4.sym} 125900 -27920 0 0 {name=X_63903_ }
C {devices/lab_pin.sym} 125860 -27770 0 0 {name=p124861 lab=_48837_/A }
C {devices/lab_pin.sym} 125940 -27770 0 1 {name=p124862 lab=_48851_/A }
C {sky130_stdcells/buf_2.sym} 125900 -27770 0 0 {name=X_48837_ }
C {devices/lab_pin.sym} 125840 -27660 0 0 {name=p124863 lab=_84212_/Q }
C {devices/lab_pin.sym} 125840 -27620 0 0 {name=p124864 lab=_83260_/Q }
C {devices/lab_pin.sym} 125960 -27640 0 1 {name=p124865 lab=_79657_/X }
C {sky130_stdcells/xor2_4.sym} 125900 -27640 0 0 {name=X_79657_ }
C {devices/lab_pin.sym} 125860 -27510 0 0 {name=p124866 lab=_67312_/X }
C {devices/lab_pin.sym} 125940 -27510 0 1 {name=p124867 lab=_67671_/X }
C {sky130_stdcells/buf_2.sym} 125900 -27510 0 0 {name=X_67671_ }
C {devices/lab_pin.sym} 125840 -27400 0 0 {name=p124868 lab=_64883_/A }
C {devices/lab_pin.sym} 125840 -27360 0 0 {name=p124869 lab=_86263_/Q }
C {devices/lab_pin.sym} 125960 -27380 0 1 {name=p124870 lab=_64883_/X }
C {sky130_stdcells/and2_4.sym} 125900 -27380 0 0 {name=X_64883_ }
C {devices/lab_pin.sym} 125820 -27270 0 0 {name=p124871 lab=_81497_/Q }
C {devices/lab_pin.sym} 125820 -27230 0 0 {name=p124872 lab=_76867_/Y }
C {devices/lab_pin.sym} 125820 -27190 0 0 {name=p124873 lab=_76868_/X }
C {devices/lab_pin.sym} 125980 -27230 0 1 {name=p124874 lab=_76869_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -27230 0 0 {name=X_76869_ }
C {devices/lab_pin.sym} 125820 -27120 0 0 {name=p124875 lab=_88031_/Q }
C {devices/lab_pin.sym} 125820 -27080 0 0 {name=p124876 lab=_69162_/X }
C {devices/lab_pin.sym} 125820 -27040 0 0 {name=p124877 lab=_69202_/X }
C {devices/lab_pin.sym} 125820 -27000 0 0 {name=p124878 lab=_69409_/X }
C {devices/lab_pin.sym} 125980 -27060 0 1 {name=p124879 lab=_69410_/X }
C {sky130_stdcells/a211o_4.sym} 125900 -27060 0 0 {name=X_69410_ }
C {devices/lab_pin.sym} 125820 -26940 0 0 {name=p124880 lab=_88401_/Q }
C {devices/lab_pin.sym} 125820 -26900 0 0 {name=p124881 lab=_66593_/X }
C {devices/lab_pin.sym} 125820 -26860 0 0 {name=p124882 lab=_66594_/X }
C {devices/lab_pin.sym} 125820 -26820 0 0 {name=p124883 lab=_66621_/X }
C {devices/lab_pin.sym} 125980 -26880 0 1 {name=p124884 lab=_66622_/X }
C {sky130_stdcells/a211o_4.sym} 125900 -26880 0 0 {name=X_66622_ }
C {devices/lab_pin.sym} 125840 -26740 0 0 {name=p124885 lab=_78608_/A }
C {devices/lab_pin.sym} 125840 -26700 0 0 {name=p124886 lab=_82678_/D }
C {devices/lab_pin.sym} 125960 -26720 0 1 {name=p124887 lab=_78608_/Y }
C {sky130_stdcells/nor2_4.sym} 125900 -26720 0 0 {name=X_78608_ }
C {devices/lab_pin.sym} 125840 -26610 0 0 {name=p124888 lab=_63800_/A }
C {devices/lab_pin.sym} 125840 -26570 0 0 {name=p124889 lab=_63800_/B }
C {devices/lab_pin.sym} 125840 -26530 0 0 {name=p124890 lab=_84292_/Q }
C {devices/lab_pin.sym} 125960 -26570 0 1 {name=p124891 lab=_63834_/Y }
C {sky130_stdcells/nor3_4.sym} 125900 -26570 0 0 {name=X_63834_ }
C {devices/lab_pin.sym} 125840 -26440 0 0 {name=p124892 lab=_48777_/A }
C {devices/lab_pin.sym} 125840 -26400 0 0 {name=p124893 lab=_48482_/B }
C {devices/lab_pin.sym} 125960 -26420 0 1 {name=p124894 lab=_48768_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -26420 0 0 {name=X_48768_ }
C {devices/lab_pin.sym} 125840 -26310 0 0 {name=p124895 lab=_79588_/A }
C {devices/lab_pin.sym} 125840 -26270 0 0 {name=p124896 lab=_79586_/A }
C {devices/lab_pin.sym} 125840 -26230 0 0 {name=p124897 lab=_79585_/Y }
C {devices/lab_pin.sym} 125960 -26270 0 1 {name=p124898 lab=_79588_/Y }
C {sky130_stdcells/nand3_4.sym} 125900 -26270 0 0 {name=X_79588_ }
C {devices/lab_pin.sym} 125840 -26140 0 0 {name=p124899 lab=_69302_/A }
C {devices/lab_pin.sym} 125840 -26100 0 0 {name=p124900 lab=_87780_/Q }
C {devices/lab_pin.sym} 125960 -26120 0 1 {name=p124901 lab=_69341_/X }
C {sky130_stdcells/and2_4.sym} 125900 -26120 0 0 {name=X_69341_ }
C {devices/lab_pin.sym} 125820 -26010 0 0 {name=p124902 lab=_72368_/A }
C {devices/lab_pin.sym} 125820 -25970 0 0 {name=p124903 lab=_47714_/X }
C {devices/lab_pin.sym} 125820 -25930 0 0 {name=p124904 lab=_47718_/Y }
C {devices/lab_pin.sym} 125980 -25970 0 1 {name=p124905 lab=_47719_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -25970 0 0 {name=X_47719_ }
C {devices/lab_pin.sym} 125860 -25830 0 0 {name=p124906 lab=_44019_/A }
C {devices/lab_pin.sym} 125940 -25830 0 1 {name=p124907 lab=_66553_/X }
C {sky130_stdcells/buf_2.sym} 125900 -25830 0 0 {name=X_66553_ }
C {devices/lab_pin.sym} 125860 -25710 0 0 {name=p124908 lab=_78538_/X }
C {devices/lab_pin.sym} 125940 -25710 0 1 {name=p124909 lab=_78539_/Y }
C {sky130_stdcells/inv_2.sym} 125900 -25710 0 0 {name=X_78539_ }
C {devices/lab_pin.sym} 125840 -25610 0 0 {name=p124910 lab=_63765_/A }
C {devices/lab_pin.sym} 125840 -25570 0 0 {name=p124911 lab=_63380_/A }
C {devices/lab_pin.sym} 125840 -25530 0 0 {name=p124912 lab=_63765_/C }
C {devices/lab_pin.sym} 125960 -25570 0 1 {name=p124913 lab=_63765_/X }
C {sky130_stdcells/and3_4.sym} 125900 -25570 0 0 {name=X_63765_ }
C {devices/lab_pin.sym} 125840 -25440 0 0 {name=p124914 lab=_48697_/Y }
C {devices/lab_pin.sym} 125840 -25400 0 0 {name=p124915 lab=_48699_/B }
C {devices/lab_pin.sym} 125960 -25420 0 1 {name=p124916 lab=_48699_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -25420 0 0 {name=X_48699_ }
C {devices/lab_pin.sym} 125840 -25310 0 0 {name=p124917 lab=_60969_/X }
C {devices/lab_pin.sym} 125840 -25270 0 0 {name=p124918 lab=_60835_/X }
C {devices/lab_pin.sym} 125840 -25230 0 0 {name=p124919 lab=_84546_/Q }
C {devices/lab_pin.sym} 125960 -25270 0 1 {name=p124920 lab=_60977_/X }
C {sky130_stdcells/or3_4.sym} 125900 -25270 0 0 {name=X_60977_ }
C {devices/lab_pin.sym} 125860 -25130 0 0 {name=p124921 lab=_64829_/A }
C {devices/lab_pin.sym} 125940 -25130 0 1 {name=p124922 lab=_65504_/X }
C {sky130_stdcells/buf_2.sym} 125900 -25130 0 0 {name=X_65504_ }
C {devices/lab_pin.sym} 125820 -25030 0 0 {name=p124923 lab=_86145_/Q }
C {devices/lab_pin.sym} 125820 -24990 0 0 {name=p124924 lab=_50727_/X }
C {devices/lab_pin.sym} 125820 -24950 0 0 {name=p124925 lab=_50729_/Y }
C {devices/lab_pin.sym} 125980 -24990 0 1 {name=p124926 lab=_50730_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -24990 0 0 {name=X_50730_ }
C {devices/lab_pin.sym} 125840 -24880 0 0 {name=p124927 lab=_61387_/X }
C {devices/lab_pin.sym} 125840 -24840 0 0 {name=p124928 lab=_62694_/B }
C {devices/lab_pin.sym} 125840 -24800 0 0 {name=p124929 lab=_62694_/C }
C {devices/lab_pin.sym} 125840 -24760 0 0 {name=p124930 lab=_62664_/D }
C {devices/lab_pin.sym} 125960 -24820 0 1 {name=p124931 lab=_62716_/Y }
C {sky130_stdcells/nand4_4.sym} 125900 -24820 0 0 {name=X_62716_ }
C {devices/lab_pin.sym} 125810 -24670 0 0 {name=p124932 lab=_80912_/CLK }
C {devices/lab_pin.sym} 125810 -24650 0 0 {name=p124933 lab=_81550_/D }
C {devices/lab_pin.sym} 125990 -24670 0 1 {name=p124934 lab=_76155_/B }
C {sky130_stdcells/dfxtp_4.sym} 125900 -24660 0 0 {name=X_81550_ }
C {devices/lab_pin.sym} 125820 -24560 0 0 {name=p124935 lab=_88041_/Q }
C {devices/lab_pin.sym} 125820 -24520 0 0 {name=p124936 lab=_69217_/X }
C {devices/lab_pin.sym} 125820 -24480 0 0 {name=p124937 lab=_69245_/X }
C {devices/lab_pin.sym} 125820 -24440 0 0 {name=p124938 lab=_69271_/X }
C {devices/lab_pin.sym} 125980 -24500 0 1 {name=p124939 lab=_69272_/X }
C {sky130_stdcells/a211o_4.sym} 125900 -24500 0 0 {name=X_69272_ }
C {devices/lab_pin.sym} 125860 -24350 0 0 {name=p124940 lab=_84114_/Q }
C {devices/lab_pin.sym} 125940 -24350 0 1 {name=p124941 lab=_66484_/Y }
C {sky130_stdcells/inv_2.sym} 125900 -24350 0 0 {name=X_66484_ }
C {devices/lab_pin.sym} 125840 -24240 0 0 {name=p124942 lab=_63696_/A }
C {devices/lab_pin.sym} 125840 -24200 0 0 {name=p124943 lab=_62162_/X }
C {devices/lab_pin.sym} 125960 -24220 0 1 {name=p124944 lab=_63696_/X }
C {sky130_stdcells/and2_4.sym} 125900 -24220 0 0 {name=X_63696_ }
C {devices/lab_pin.sym} 125820 -24110 0 0 {name=p124945 lab=_80487_/Y }
C {devices/lab_pin.sym} 125820 -24070 0 0 {name=p124946 lab=_80492_/Y }
C {devices/lab_pin.sym} 125820 -24030 0 0 {name=p124947 lab=_80500_/X }
C {devices/lab_pin.sym} 125980 -24070 0 1 {name=p124948 lab=_80501_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -24070 0 0 {name=X_80501_ }
C {devices/lab_pin.sym} 125820 -23960 0 0 {name=p124949 lab=_68221_/X }
C {devices/lab_pin.sym} 125820 -23920 0 0 {name=p124950 lab=_67367_/Y }
C {devices/lab_pin.sym} 125820 -23880 0 0 {name=p124951 lab=_68207_/X }
C {devices/lab_pin.sym} 125820 -23840 0 0 {name=p124952 lab=_68222_/Y }
C {devices/lab_pin.sym} 125980 -23900 0 1 {name=p124953 lab=_68223_/X }
C {sky130_stdcells/a211o_4.sym} 125900 -23900 0 0 {name=X_68223_ }
C {devices/lab_pin.sym} 125840 -23770 0 0 {name=p124954 lab=_65449_/A }
C {devices/lab_pin.sym} 125840 -23730 0 0 {name=p124955 lab=_65294_/B }
C {devices/lab_pin.sym} 125840 -23690 0 0 {name=p124956 lab=_84201_/Q }
C {devices/lab_pin.sym} 125960 -23730 0 1 {name=p124957 lab=_65435_/X }
C {sky130_stdcells/and3_4.sym} 125900 -23730 0 0 {name=X_65435_ }
C {devices/lab_pin.sym} 125820 -23610 0 0 {name=p124958 lab=_50658_/Y }
C {devices/lab_pin.sym} 125820 -23570 0 0 {name=p124959 lab=_50609_/X }
C {devices/lab_pin.sym} 125820 -23530 0 0 {name=p124960 lab=_50660_/X }
C {devices/lab_pin.sym} 125980 -23570 0 1 {name=p124961 lab=_86159_/D }
C {sky130_stdcells/a21oi_4.sym} 125900 -23570 0 0 {name=X_50661_ }
C {devices/lab_pin.sym} 125820 -23450 0 0 {name=p124962 lab=_59450_/Y }
C {devices/lab_pin.sym} 125820 -23410 0 0 {name=p124963 lab=_60284_/A }
C {devices/lab_pin.sym} 125820 -23370 0 0 {name=p124964 lab=_62646_/Y }
C {devices/lab_pin.sym} 125980 -23410 0 1 {name=p124965 lab=_62647_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -23410 0 0 {name=X_62647_ }
C {devices/lab_pin.sym} 125810 -23270 0 0 {name=p124966 lab=_81344_/CLK }
C {devices/lab_pin.sym} 125810 -23250 0 0 {name=p124967 lab=_81481_/D }
C {devices/lab_pin.sym} 125990 -23270 0 1 {name=p124968 lab=_76708_/A }
C {sky130_stdcells/dfxtp_4.sym} 125900 -23260 0 0 {name=X_81481_ }
C {devices/lab_pin.sym} 125860 -23130 0 0 {name=p124969 lab=_52602_/A }
C {devices/lab_pin.sym} 125940 -23130 0 1 {name=p124970 lab=_52400_/X }
C {sky130_stdcells/buf_2.sym} 125900 -23130 0 0 {name=X_52400_ }
C {devices/lab_pin.sym} 125810 -23010 0 0 {name=p124971 lab=_84487_/CLK }
C {devices/lab_pin.sym} 125810 -22990 0 0 {name=p124972 lab=_72603_/X }
C {devices/lab_pin.sym} 125990 -23010 0 1 {name=p124973 lab=_83220_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -23000 0 0 {name=X_83220_ }
C {devices/lab_pin.sym} 125840 -22880 0 0 {name=p124974 lab=_84759_/Q }
C {devices/lab_pin.sym} 125840 -22840 0 0 {name=p124975 lab=_84151_/Q }
C {devices/lab_pin.sym} 125960 -22860 0 1 {name=p124976 lab=_80432_/X }
C {sky130_stdcells/xor2_4.sym} 125900 -22860 0 0 {name=X_80432_ }
C {devices/lab_pin.sym} 125820 -22750 0 0 {name=p124977 lab=_82065_/D }
C {devices/lab_pin.sym} 125820 -22710 0 0 {name=p124978 lab=_68140_/X }
C {devices/lab_pin.sym} 125820 -22670 0 0 {name=p124979 lab=_68153_/X }
C {devices/lab_pin.sym} 125980 -22710 0 1 {name=p124980 lab=_84025_/D }
C {sky130_stdcells/a21bo_4.sym} 125900 -22710 0 0 {name=X_68154_ }
C {devices/lab_pin.sym} 125840 -22580 0 0 {name=p124981 lab=_53386_/A }
C {devices/lab_pin.sym} 125840 -22540 0 0 {name=p124982 lab=_47116_/A }
C {devices/lab_pin.sym} 125960 -22560 0 1 {name=p124983 lab=_53380_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -22560 0 0 {name=X_53380_ }
C {devices/lab_pin.sym} 125820 -22450 0 0 {name=p124984 lab=_65361_/X }
C {devices/lab_pin.sym} 125820 -22410 0 0 {name=p124985 lab=_65365_/X }
C {devices/lab_pin.sym} 125820 -22370 0 0 {name=p124986 lab=_65287_/X }
C {devices/lab_pin.sym} 125980 -22410 0 1 {name=p124987 lab=_65366_/X }
C {sky130_stdcells/a21o_4.sym} 125900 -22410 0 0 {name=X_65366_ }
C {devices/lab_pin.sym} 125840 -22280 0 0 {name=p124988 lab=_50580_/A }
C {devices/lab_pin.sym} 125840 -22240 0 0 {name=p124989 lab=_71989_/B }
C {devices/lab_pin.sym} 125960 -22260 0 1 {name=p124990 lab=_50592_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -22260 0 0 {name=X_50592_ }
C {devices/lab_pin.sym} 125820 -22160 0 0 {name=p124991 lab=_62577_/Y }
C {devices/lab_pin.sym} 125820 -22120 0 0 {name=p124992 lab=_59945_/Y }
C {devices/lab_pin.sym} 125820 -22080 0 0 {name=p124993 lab=_62948_/C }
C {devices/lab_pin.sym} 125820 -22040 0 0 {name=p124994 lab=_59931_/A }
C {devices/lab_pin.sym} 125980 -22100 0 1 {name=p124995 lab=_62578_/X }
C {sky130_stdcells/a2bb2o_4.sym} 125900 -22100 0 0 {name=X_62578_ }
C {devices/lab_pin.sym} 125820 -21980 0 0 {name=p124996 lab=_87869_/Q }
C {devices/lab_pin.sym} 125820 -21940 0 0 {name=p124997 lab=_67056_/X }
C {devices/lab_pin.sym} 125820 -21900 0 0 {name=p124998 lab=_67032_/X }
C {devices/lab_pin.sym} 125820 -21860 0 0 {name=p124999 lab=_67104_/X }
C {devices/lab_pin.sym} 125980 -21920 0 1 {name=p125000 lab=_67105_/X }
C {sky130_stdcells/a211o_4.sym} 125900 -21920 0 0 {name=X_67105_ }
C {devices/lab_pin.sym} 125820 -21790 0 0 {name=p125001 lab=_85844_/Q }
C {devices/lab_pin.sym} 125820 -21750 0 0 {name=p125002 lab=_52324_/X }
C {devices/lab_pin.sym} 125820 -21710 0 0 {name=p125003 lab=_52330_/Y }
C {devices/lab_pin.sym} 125980 -21750 0 1 {name=p125004 lab=_52331_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -21750 0 0 {name=X_52331_ }
C {devices/lab_pin.sym} 125860 -21610 0 0 {name=p125005 lab=_64221_/A }
C {devices/lab_pin.sym} 125940 -21610 0 1 {name=p125006 lab=_64318_/D }
C {sky130_stdcells/buf_2.sym} 125900 -21610 0 0 {name=X_64317_ }
C {devices/lab_pin.sym} 125810 -21490 0 0 {name=p125007 lab=_86535_/CLK }
C {devices/lab_pin.sym} 125810 -21470 0 0 {name=p125008 lab=_83151_/D }
C {devices/lab_pin.sym} 125990 -21490 0 1 {name=p125009 lab=_83151_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -21480 0 0 {name=X_83151_ }
C {devices/lab_pin.sym} 125860 -21350 0 0 {name=p125010 lab=_61686_/A }
C {devices/lab_pin.sym} 125940 -21350 0 1 {name=p125011 lab=_61563_/B }
C {sky130_stdcells/buf_2.sym} 125900 -21350 0 0 {name=X_61529_ }
C {devices/lab_pin.sym} 125840 -21240 0 0 {name=p125012 lab=_80337_/Y }
C {devices/lab_pin.sym} 125840 -21200 0 0 {name=p125013 lab=_80353_/Y }
C {devices/lab_pin.sym} 125960 -21220 0 1 {name=p125014 lab=_80363_/Y }
C {sky130_stdcells/nor2_4.sym} 125900 -21220 0 0 {name=X_80363_ }
C {devices/lab_pin.sym} 125820 -21110 0 0 {name=p125015 lab=_68082_/X }
C {devices/lab_pin.sym} 125820 -21070 0 0 {name=p125016 lab=_68084_/X }
C {devices/lab_pin.sym} 125820 -21030 0 0 {name=p125017 lab=_68062_/X }
C {devices/lab_pin.sym} 125980 -21070 0 1 {name=p125018 lab=_68085_/Y }
C {sky130_stdcells/a21oi_4.sym} 125900 -21070 0 0 {name=X_68085_ }
C {devices/lab_pin.sym} 125860 -20930 0 0 {name=p125019 lab=_64656_/A }
C {devices/lab_pin.sym} 125940 -20930 0 1 {name=p125020 lab=_72123_/A }
C {sky130_stdcells/buf_2.sym} 125900 -20930 0 0 {name=X_65297_ }
C {devices/lab_pin.sym} 125810 -20810 0 0 {name=p125021 lab=_82343_/CLK }
C {devices/lab_pin.sym} 125810 -20790 0 0 {name=p125022 lab=_82114_/Q }
C {devices/lab_pin.sym} 125990 -20810 0 1 {name=p125023 lab=_82102_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -20800 0 0 {name=X_82102_ }
C {devices/lab_pin.sym} 125860 -20670 0 0 {name=p125024 lab=_55102_/A }
C {devices/lab_pin.sym} 125940 -20670 0 1 {name=p125025 lab=_55050_/X }
C {sky130_stdcells/buf_2.sym} 125900 -20670 0 0 {name=X_55050_ }
C {devices/lab_pin.sym} 125840 -20560 0 0 {name=p125026 lab=_66961_/X }
C {devices/lab_pin.sym} 125840 -20520 0 0 {name=p125027 lab=_86787_/Q }
C {devices/lab_pin.sym} 125960 -20540 0 1 {name=p125028 lab=_67036_/X }
C {sky130_stdcells/and2_4.sym} 125900 -20540 0 0 {name=X_67036_ }
C {devices/lab_pin.sym} 125860 -20410 0 0 {name=p125029 lab=_52262_/A }
C {devices/lab_pin.sym} 125940 -20410 0 1 {name=p125030 lab=_52262_/X }
C {sky130_stdcells/buf_2.sym} 125900 -20410 0 0 {name=X_52262_ }
C {devices/lab_pin.sym} 125840 -20310 0 0 {name=p125031 lab=_64248_/A }
C {devices/lab_pin.sym} 125840 -20270 0 0 {name=p125032 lab=_64248_/B }
C {devices/lab_pin.sym} 125840 -20230 0 0 {name=p125033 lab=_64248_/C }
C {devices/lab_pin.sym} 125960 -20270 0 1 {name=p125034 lab=_64248_/X }
C {sky130_stdcells/and3_4.sym} 125900 -20270 0 0 {name=X_64248_ }
C {devices/lab_pin.sym} 125810 -20130 0 0 {name=p125035 lab=_83184_/CLK }
C {devices/lab_pin.sym} 125810 -20110 0 0 {name=p125036 lab=_74362_/X }
C {devices/lab_pin.sym} 125990 -20130 0 1 {name=p125037 lab=_83082_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -20120 0 0 {name=X_83082_ }
C {devices/lab_pin.sym} 125840 -20000 0 0 {name=p125038 lab=_80293_/Y }
C {devices/lab_pin.sym} 125840 -19960 0 0 {name=p125039 lab=_80294_/B }
C {devices/lab_pin.sym} 125960 -19980 0 1 {name=p125040 lab=_80297_/A }
C {sky130_stdcells/nand2_4.sym} 125900 -19980 0 0 {name=X_80294_ }
C {devices/lab_pin.sym} 125820 -19870 0 0 {name=p125041 lab=_85525_/Q }
C {devices/lab_pin.sym} 125820 -19830 0 0 {name=p125042 lab=_53989_/X }
C {devices/lab_pin.sym} 125820 -19790 0 0 {name=p125043 lab=_54000_/Y }
C {devices/lab_pin.sym} 125980 -19830 0 1 {name=p125044 lab=_54001_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -19830 0 0 {name=X_54001_ }
C {devices/lab_pin.sym} 125820 -19710 0 0 {name=p125045 lab=_86053_/Q }
C {devices/lab_pin.sym} 125820 -19670 0 0 {name=p125046 lab=_51209_/X }
C {devices/lab_pin.sym} 125820 -19630 0 0 {name=p125047 lab=_51212_/Y }
C {devices/lab_pin.sym} 125980 -19670 0 1 {name=p125048 lab=_51213_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -19670 0 0 {name=X_51213_ }
C {devices/lab_pin.sym} 125810 -19530 0 0 {name=p125049 lab=_84538_/CLK }
C {devices/lab_pin.sym} 125810 -19510 0 0 {name=p125050 lab=_44924_/Y }
C {devices/lab_pin.sym} 125990 -19530 0 1 {name=p125051 lab=_64223_/B }
C {sky130_stdcells/dfxtp_4.sym} 125900 -19520 0 0 {name=X_86910_ }
C {devices/lab_pin.sym} 125810 -19390 0 0 {name=p125052 lab=_82005_/CLK }
C {devices/lab_pin.sym} 125810 -19370 0 0 {name=p125053 lab=_82033_/D }
C {devices/lab_pin.sym} 125990 -19390 0 1 {name=p125054 lab=_82001_/D }
C {sky130_stdcells/dfxtp_4.sym} 125900 -19380 0 0 {name=X_82033_ }
C {devices/lab_pin.sym} 125860 -19250 0 0 {name=p125055 lab=_52247_/A }
C {devices/lab_pin.sym} 125940 -19250 0 1 {name=p125056 lab=_52218_/C }
C {sky130_stdcells/buf_2.sym} 125900 -19250 0 0 {name=X_52193_ }
C {devices/lab_pin.sym} 125840 -19160 0 0 {name=p125057 lab=_64545_/B }
C {devices/lab_pin.sym} 125840 -19120 0 0 {name=p125058 lab=_64179_/B }
C {devices/lab_pin.sym} 125840 -19080 0 0 {name=p125059 lab=_64179_/C }
C {devices/lab_pin.sym} 125840 -19040 0 0 {name=p125060 lab=_64179_/D }
C {devices/lab_pin.sym} 125960 -19100 0 1 {name=p125061 lab=_64181_/C }
C {sky130_stdcells/nand4_4.sym} 125900 -19100 0 0 {name=X_64179_ }
C {devices/lab_pin.sym} 125810 -18950 0 0 {name=p125062 lab=_87995_/CLK }
C {devices/lab_pin.sym} 125810 -18930 0 0 {name=p125063 lab=_42384_/X }
C {devices/lab_pin.sym} 125990 -18950 0 1 {name=p125064 lab=_87890_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -18940 0 0 {name=X_87890_ }
C {devices/lab_pin.sym} 125840 -18820 0 0 {name=p125065 lab=_51130_/A }
C {devices/lab_pin.sym} 125840 -18780 0 0 {name=p125066 lab=_52837_/B }
C {devices/lab_pin.sym} 125960 -18800 0 1 {name=p125067 lab=_51144_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -18800 0 0 {name=X_51144_ }
C {devices/lab_pin.sym} 125810 -18670 0 0 {name=p125068 lab=_86841_/CLK }
C {devices/lab_pin.sym} 125810 -18650 0 0 {name=p125069 lab=_45939_/Y }
C {devices/lab_pin.sym} 125990 -18670 0 1 {name=p125070 lab=_86841_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -18660 0 0 {name=X_86841_ }
C {devices/lab_pin.sym} 125840 -18540 0 0 {name=p125071 lab=_68987_/A }
C {devices/lab_pin.sym} 125840 -18500 0 0 {name=p125072 lab=_74145_/A }
C {devices/lab_pin.sym} 125960 -18520 0 1 {name=p125073 lab=_68987_/X }
C {sky130_stdcells/and2_4.sym} 125900 -18520 0 0 {name=X_68987_ }
C {devices/lab_pin.sym} 125860 -18390 0 0 {name=p125074 lab=_58858_/A }
C {devices/lab_pin.sym} 125940 -18390 0 1 {name=p125075 lab=_58740_/X }
C {sky130_stdcells/buf_2.sym} 125900 -18390 0 0 {name=X_58740_ }
C {devices/lab_pin.sym} 125840 -18280 0 0 {name=p125076 lab=_44085_/C }
C {devices/lab_pin.sym} 125840 -18240 0 0 {name=p125077 lab=_56027_/C }
C {devices/lab_pin.sym} 125960 -18260 0 1 {name=p125078 lab=_55952_/X }
C {sky130_stdcells/and2_4.sym} 125900 -18260 0 0 {name=X_55952_ }
C {devices/lab_pin.sym} 125860 -18130 0 0 {name=p125079 lab=_51129_/A }
C {devices/lab_pin.sym} 125940 -18130 0 1 {name=p125080 lab=_51097_/A }
C {sky130_stdcells/buf_2.sym} 125900 -18130 0 0 {name=X_51075_ }
C {devices/lab_pin.sym} 125860 -18010 0 0 {name=p125081 lab=_68450_/A }
C {devices/lab_pin.sym} 125940 -18010 0 1 {name=p125082 lab=_67938_/X }
C {sky130_stdcells/buf_2.sym} 125900 -18010 0 0 {name=X_67938_ }
C {devices/lab_pin.sym} 125810 -17890 0 0 {name=p125083 lab=_86772_/CLK }
C {devices/lab_pin.sym} 125810 -17870 0 0 {name=p125084 lab=_46140_/X }
C {devices/lab_pin.sym} 125990 -17890 0 1 {name=p125085 lab=_43012_/B }
C {sky130_stdcells/dfxtp_4.sym} 125900 -17880 0 0 {name=X_86772_ }
C {devices/lab_pin.sym} 125810 -17750 0 0 {name=p125086 lab=_87671_/CLK }
C {devices/lab_pin.sym} 125810 -17730 0 0 {name=p125087 lab=_83984_/D }
C {devices/lab_pin.sym} 125990 -17750 0 1 {name=p125088 lab=_82632_/D }
C {sky130_stdcells/dfxtp_4.sym} 125900 -17740 0 0 {name=X_83984_ }
C {devices/lab_pin.sym} 125820 -17630 0 0 {name=p125089 lab=_50024_/Y }
C {devices/lab_pin.sym} 125820 -17590 0 0 {name=p125090 lab=_50003_/X }
C {devices/lab_pin.sym} 125820 -17550 0 0 {name=p125091 lab=_50025_/X }
C {devices/lab_pin.sym} 125980 -17590 0 1 {name=p125092 lab=_50026_/Y }
C {sky130_stdcells/a21oi_4.sym} 125900 -17590 0 0 {name=X_50026_ }
C {devices/lab_pin.sym} 125840 -17460 0 0 {name=p125093 lab=_54893_/X }
C {devices/lab_pin.sym} 125840 -17420 0 0 {name=p125094 lab=_54903_/B }
C {devices/lab_pin.sym} 125960 -17440 0 1 {name=p125095 lab=_54903_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -17440 0 0 {name=X_54903_ }
C {devices/lab_pin.sym} 125810 -17310 0 0 {name=p125096 lab=_84746_/CLK }
C {devices/lab_pin.sym} 125810 -17290 0 0 {name=p125097 lab=_85723_/D }
C {devices/lab_pin.sym} 125990 -17310 0 1 {name=p125098 lab=_85723_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -17300 0 0 {name=X_85723_ }
C {devices/lab_pin.sym} 125840 -17180 0 0 {name=p125099 lab=_58659_/A }
C {devices/lab_pin.sym} 125840 -17140 0 0 {name=p125100 lab=_86393_/Q }
C {devices/lab_pin.sym} 125960 -17160 0 1 {name=p125101 lab=_58671_/Y }
C {sky130_stdcells/nor2_4.sym} 125900 -17160 0 0 {name=X_58671_ }
C {devices/lab_pin.sym} 125810 -17030 0 0 {name=p125102 lab=_82933_/CLK }
C {devices/lab_pin.sym} 125810 -17010 0 0 {name=p125103 lab=_78287_/X }
C {devices/lab_pin.sym} 125990 -17030 0 1 {name=p125104 lab=_46371_/A }
C {sky130_stdcells/dfxtp_4.sym} 125900 -17020 0 0 {name=X_82935_ }
C {devices/lab_pin.sym} 125840 -16900 0 0 {name=p125105 lab=_44081_/X }
C {devices/lab_pin.sym} 125840 -16860 0 0 {name=p125106 lab=_56317_/C }
C {devices/lab_pin.sym} 125960 -16880 0 1 {name=p125107 lab=_55883_/X }
C {sky130_stdcells/and2_4.sym} 125900 -16880 0 0 {name=X_55883_ }
C {devices/lab_pin.sym} 125840 -16760 0 0 {name=p125108 lab=_67891_/A }
C {devices/lab_pin.sym} 125840 -16720 0 0 {name=p125109 lab=_86921_/Q }
C {devices/lab_pin.sym} 125960 -16740 0 1 {name=p125110 lab=_67869_/X }
C {sky130_stdcells/and2_4.sym} 125900 -16740 0 0 {name=X_67869_ }
C {devices/lab_pin.sym} 125820 -16630 0 0 {name=p125111 lab=_84967_/Q }
C {devices/lab_pin.sym} 125820 -16590 0 0 {name=p125112 lab=_57603_/X }
C {devices/lab_pin.sym} 125820 -16550 0 0 {name=p125113 lab=_57621_/Y }
C {devices/lab_pin.sym} 125980 -16590 0 1 {name=p125114 lab=_57622_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -16590 0 0 {name=X_57622_ }
C {devices/lab_pin.sym} 125840 -16460 0 0 {name=p125115 lab=_69648_/A }
C {devices/lab_pin.sym} 125840 -16420 0 0 {name=p125116 lab=_42550_/Y }
C {devices/lab_pin.sym} 125960 -16440 0 1 {name=p125117 lab=_69608_/Y }
C {sky130_stdcells/nor2_4.sym} 125900 -16440 0 0 {name=X_69608_ }
C {devices/lab_pin.sym} 125860 -16310 0 0 {name=p125118 lab=clkbuf_9_461_0_CLK/A }
C {devices/lab_pin.sym} 125940 -16310 0 1 {name=p125119 lab=clkbuf_9_460_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 125900 -16310 0 0 {name=Xclkbuf_9_460_0_CLK }
C {devices/lab_pin.sym} 125820 -16210 0 0 {name=p125120 lab=_85369_/Q }
C {devices/lab_pin.sym} 125820 -16170 0 0 {name=p125121 lab=_54812_/X }
C {devices/lab_pin.sym} 125820 -16130 0 0 {name=p125122 lab=_54833_/Y }
C {devices/lab_pin.sym} 125980 -16170 0 1 {name=p125123 lab=_54834_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -16170 0 0 {name=X_54834_ }
C {devices/lab_pin.sym} 125810 -16030 0 0 {name=p125124 lab=_85751_/CLK }
C {devices/lab_pin.sym} 125810 -16010 0 0 {name=p125125 lab=_85654_/D }
C {devices/lab_pin.sym} 125990 -16030 0 1 {name=p125126 lab=_85654_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -16020 0 0 {name=X_85654_ }
C {devices/lab_pin.sym} 125840 -15920 0 0 {name=p125127 lab=_70905_/A }
C {devices/lab_pin.sym} 125840 -15880 0 0 {name=p125128 lab=_70880_/B }
C {devices/lab_pin.sym} 125840 -15840 0 0 {name=p125129 lab=_70880_/C }
C {devices/lab_pin.sym} 125840 -15800 0 0 {name=p125130 lab=_70875_/X }
C {devices/lab_pin.sym} 125960 -15860 0 1 {name=p125131 lab=_70880_/Y }
C {sky130_stdcells/nand4_4.sym} 125900 -15860 0 0 {name=X_70880_ }
C {devices/lab_pin.sym} 125810 -15710 0 0 {name=p125132 lab=_82855_/CLK }
C {devices/lab_pin.sym} 125810 -15690 0 0 {name=p125133 lab=_78199_/B }
C {devices/lab_pin.sym} 125990 -15710 0 1 {name=p125134 lab=_82866_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -15700 0 0 {name=X_82866_ }
C {devices/lab_pin.sym} 125860 -15570 0 0 {name=p125135 lab=clkbuf_9_177_0_CLK/X }
C {devices/lab_pin.sym} 125940 -15570 0 1 {name=p125136 lab=_86317_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 125900 -15570 0 0 {name=Xclkbuf_10_354_0_CLK }
C {devices/lab_pin.sym} 125810 -15450 0 0 {name=p125137 lab=_84606_/CLK }
C {devices/lab_pin.sym} 125810 -15430 0 0 {name=p125138 lab=_60531_/Y }
C {devices/lab_pin.sym} 125990 -15450 0 1 {name=p125139 lab=_79145_/A }
C {sky130_stdcells/dfxtp_4.sym} 125900 -15440 0 0 {name=X_84605_ }
C {devices/lab_pin.sym} 125840 -15320 0 0 {name=p125140 lab=_57552_/X }
C {devices/lab_pin.sym} 125840 -15280 0 0 {name=p125141 lab=_47967_/Y }
C {devices/lab_pin.sym} 125960 -15300 0 1 {name=p125142 lab=_57553_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -15300 0 0 {name=X_57553_ }
C {devices/lab_pin.sym} 125810 -15170 0 0 {name=p125143 lab=_81689_/CLK }
C {devices/lab_pin.sym} 125810 -15150 0 0 {name=p125144 lab=_81625_/Q }
C {devices/lab_pin.sym} 125990 -15170 0 1 {name=p125145 lab=_81817_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -15160 0 0 {name=X_81817_ }
C {devices/lab_pin.sym} 125820 -15050 0 0 {name=p125146 lab=_69080_/X }
C {devices/lab_pin.sym} 125820 -15010 0 0 {name=p125147 lab=_69082_/X }
C {devices/lab_pin.sym} 125820 -14970 0 0 {name=p125148 lab=_69500_/X }
C {devices/lab_pin.sym} 125980 -15010 0 1 {name=p125149 lab=_69539_/Y }
C {sky130_stdcells/a21oi_4.sym} 125900 -15010 0 0 {name=X_69539_ }
C {devices/lab_pin.sym} 125810 -14870 0 0 {name=p125150 lab=_87416_/CLK }
C {devices/lab_pin.sym} 125810 -14850 0 0 {name=p125151 lab=_88373_/D }
C {devices/lab_pin.sym} 125990 -14870 0 1 {name=p125152 lab=_88373_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -14860 0 0 {name=X_88373_ }
C {devices/lab_pin.sym} 125860 -14730 0 0 {name=p125153 lab=_54656_/X }
C {devices/lab_pin.sym} 125940 -14730 0 1 {name=p125154 lab=_54788_/B }
C {sky130_stdcells/buf_2.sym} 125900 -14730 0 0 {name=X_54765_ }
C {devices/lab_pin.sym} 125810 -14610 0 0 {name=p125155 lab=_86193_/CLK }
C {devices/lab_pin.sym} 125810 -14590 0 0 {name=p125156 lab=_85585_/D }
C {devices/lab_pin.sym} 125990 -14610 0 1 {name=p125157 lab=_85585_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -14600 0 0 {name=X_85585_ }
C {devices/lab_pin.sym} 125840 -14480 0 0 {name=p125158 lab=_51941_/A }
C {devices/lab_pin.sym} 125840 -14440 0 0 {name=p125159 lab=_50275_/B }
C {devices/lab_pin.sym} 125960 -14460 0 1 {name=p125160 lab=_51977_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -14460 0 0 {name=X_51977_ }
C {devices/lab_pin.sym} 125810 -14330 0 0 {name=p125161 lab=_82797_/CLK }
C {devices/lab_pin.sym} 125810 -14310 0 0 {name=p125162 lab=_82829_/Q }
C {devices/lab_pin.sym} 125990 -14330 0 1 {name=p125163 lab=_82797_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -14320 0 0 {name=X_82797_ }
C {devices/lab_pin.sym} 125860 -14190 0 0 {name=p125164 lab=clkbuf_9_492_0_CLK/X }
C {devices/lab_pin.sym} 125940 -14190 0 1 {name=p125165 lab=_86498_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 125900 -14190 0 0 {name=Xclkbuf_10_984_0_CLK }
C {devices/lab_pin.sym} 125820 -14090 0 0 {name=p125166 lab=_56079_/X }
C {devices/lab_pin.sym} 125820 -14050 0 0 {name=p125167 lab=_56499_/X }
C {devices/lab_pin.sym} 125820 -14010 0 0 {name=p125168 lab=_56503_/Y }
C {devices/lab_pin.sym} 125980 -14050 0 1 {name=p125169 lab=_85171_/D }
C {sky130_stdcells/o21ai_4.sym} 125900 -14050 0 0 {name=X_56504_ }
C {devices/lab_pin.sym} 125810 -13910 0 0 {name=p125170 lab=_87577_/CLK }
C {devices/lab_pin.sym} 125810 -13890 0 0 {name=p125171 lab=_87324_/D }
C {devices/lab_pin.sym} 125990 -13910 0 1 {name=p125172 lab=_74097_/A }
C {sky130_stdcells/dfxtp_4.sym} 125900 -13900 0 0 {name=X_87324_ }
C {devices/lab_pin.sym} 125820 -13790 0 0 {name=p125173 lab=_41717_/X }
C {devices/lab_pin.sym} 125820 -13750 0 0 {name=p125174 lab=_81742_/Q }
C {devices/lab_pin.sym} 125820 -13710 0 0 {name=p125175 lab=_41729_/X }
C {devices/lab_pin.sym} 125980 -13750 0 1 {name=p125176 lab=_41730_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -13750 0 0 {name=X_41730_ }
C {devices/lab_pin.sym} 125840 -13630 0 0 {name=p125177 lab=_52199_/A }
C {devices/lab_pin.sym} 125840 -13590 0 0 {name=p125178 lab=_53720_/B }
C {devices/lab_pin.sym} 125840 -13550 0 0 {name=p125179 lab=_53734_/C }
C {devices/lab_pin.sym} 125960 -13590 0 1 {name=p125180 lab=_53716_/X }
C {sky130_stdcells/and3_4.sym} 125900 -13590 0 0 {name=X_53716_ }
C {devices/lab_pin.sym} 125840 -13470 0 0 {name=p125181 lab=_72550_/A }
C {devices/lab_pin.sym} 125840 -13430 0 0 {name=p125182 lab=_72555_/B }
C {devices/lab_pin.sym} 125840 -13390 0 0 {name=p125183 lab=_72550_/C }
C {devices/lab_pin.sym} 125960 -13430 0 1 {name=p125184 lab=_72572_/B }
C {sky130_stdcells/nand3_4.sym} 125900 -13430 0 0 {name=X_72550_ }
C {devices/lab_pin.sym} 125810 -13290 0 0 {name=p125185 lab=_84531_/CLK }
C {devices/lab_pin.sym} 125810 -13270 0 0 {name=p125186 lab=_84536_/D }
C {devices/lab_pin.sym} 125990 -13290 0 1 {name=p125187 lab=_84536_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -13280 0 0 {name=X_84536_ }
C {devices/lab_pin.sym} 125860 -13150 0 0 {name=p125188 lab=_50957_/A }
C {devices/lab_pin.sym} 125940 -13150 0 1 {name=p125189 lab=_50928_/X }
C {sky130_stdcells/buf_2.sym} 125900 -13150 0 0 {name=X_50928_ }
C {devices/lab_pin.sym} 125840 -13040 0 0 {name=p125190 lab=_57484_/A }
C {devices/lab_pin.sym} 125840 -13000 0 0 {name=p125191 lab=_57225_/Y }
C {devices/lab_pin.sym} 125960 -13020 0 1 {name=p125192 lab=_57485_/C }
C {sky130_stdcells/nand2_4.sym} 125900 -13020 0 0 {name=X_57484_ }
C {devices/lab_pin.sym} 125810 -12890 0 0 {name=p125193 lab=_81514_/CLK }
C {devices/lab_pin.sym} 125810 -12870 0 0 {name=p125194 lab=_81748_/D }
C {devices/lab_pin.sym} 125990 -12890 0 1 {name=p125195 lab=_41699_/B }
C {sky130_stdcells/dfxtp_4.sym} 125900 -12880 0 0 {name=X_81748_ }
C {devices/lab_pin.sym} 125820 -12770 0 0 {name=p125196 lab=_54692_/Y }
C {devices/lab_pin.sym} 125820 -12730 0 0 {name=p125197 lab=_54694_/X }
C {devices/lab_pin.sym} 125820 -12690 0 0 {name=p125198 lab=_54695_/X }
C {devices/lab_pin.sym} 125980 -12730 0 1 {name=p125199 lab=_54696_/Y }
C {sky130_stdcells/a21oi_4.sym} 125900 -12730 0 0 {name=X_54696_ }
C {devices/lab_pin.sym} 125860 -12590 0 0 {name=p125200 lab=clkbuf_9_475_0_CLK/A }
C {devices/lab_pin.sym} 125940 -12590 0 1 {name=p125201 lab=clkbuf_9_475_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 125900 -12590 0 0 {name=Xclkbuf_9_475_0_CLK }
C {devices/lab_pin.sym} 125820 -12490 0 0 {name=p125202 lab=_59218_/Y }
C {devices/lab_pin.sym} 125820 -12450 0 0 {name=p125203 lab=_59222_/Y }
C {devices/lab_pin.sym} 125820 -12410 0 0 {name=p125204 lab=_59165_/X }
C {devices/lab_pin.sym} 125980 -12450 0 1 {name=p125205 lab=_59223_/X }
C {sky130_stdcells/a21o_4.sym} 125900 -12450 0 0 {name=X_59223_ }
C {devices/lab_pin.sym} 125820 -12330 0 0 {name=p125206 lab=_58454_/Y }
C {devices/lab_pin.sym} 125820 -12290 0 0 {name=p125207 lab=_71486_/A }
C {devices/lab_pin.sym} 125820 -12250 0 0 {name=p125208 lab=_71500_/Y }
C {devices/lab_pin.sym} 125980 -12290 0 1 {name=p125209 lab=_83476_/D }
C {sky130_stdcells/o21ai_4.sym} 125900 -12290 0 0 {name=X_71501_ }
C {devices/lab_pin.sym} 125860 -12150 0 0 {name=p125210 lab=_56435_/A }
C {devices/lab_pin.sym} 125940 -12150 0 1 {name=p125211 lab=_56446_/A }
C {sky130_stdcells/buf_2.sym} 125900 -12150 0 0 {name=X_56435_ }
C {devices/lab_pin.sym} 125810 -12030 0 0 {name=p125212 lab=_87260_/CLK }
C {devices/lab_pin.sym} 125810 -12010 0 0 {name=p125213 lab=_87255_/D }
C {devices/lab_pin.sym} 125990 -12030 0 1 {name=p125214 lab=_69523_/B }
C {sky130_stdcells/dfxtp_4.sym} 125900 -12020 0 0 {name=X_87255_ }
C {devices/lab_pin.sym} 125840 -11900 0 0 {name=p125215 lab=_53656_/A }
C {devices/lab_pin.sym} 125840 -11860 0 0 {name=p125216 lab=_53647_/B }
C {devices/lab_pin.sym} 125960 -11880 0 1 {name=p125217 lab=_53647_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -11880 0 0 {name=X_53647_ }
C {devices/lab_pin.sym} 125840 -11760 0 0 {name=p125218 lab=_41661_/A }
C {devices/lab_pin.sym} 125840 -11720 0 0 {name=p125219 lab=_41660_/X }
C {devices/lab_pin.sym} 125960 -11740 0 1 {name=p125220 lab=_41661_/X }
C {sky130_stdcells/or2_4.sym} 125900 -11740 0 0 {name=X_41661_ }
C {devices/lab_pin.sym} 125820 -11630 0 0 {name=p125221 lab=_57697_/X }
C {devices/lab_pin.sym} 125820 -11590 0 0 {name=p125222 lab=_85954_/Q }
C {devices/lab_pin.sym} 125820 -11550 0 0 {name=p125223 lab=_72480_/X }
C {devices/lab_pin.sym} 125980 -11590 0 1 {name=p125224 lab=_72481_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -11590 0 0 {name=X_72481_ }
C {devices/lab_pin.sym} 125810 -11450 0 0 {name=p125225 lab=_82452_/CLK }
C {devices/lab_pin.sym} 125810 -11430 0 0 {name=p125226 lab=_84467_/D }
C {devices/lab_pin.sym} 125990 -11450 0 1 {name=p125227 lab=_79135_/B }
C {sky130_stdcells/dfxtp_4.sym} 125900 -11440 0 0 {name=X_84467_ }
C {devices/lab_pin.sym} 125820 -11330 0 0 {name=p125228 lab=_86119_/Q }
C {devices/lab_pin.sym} 125820 -11290 0 0 {name=p125229 lab=_50856_/X }
C {devices/lab_pin.sym} 125820 -11250 0 0 {name=p125230 lab=_50858_/Y }
C {devices/lab_pin.sym} 125980 -11290 0 1 {name=p125231 lab=_50859_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -11290 0 0 {name=X_50859_ }
C {devices/lab_pin.sym} 125810 -11150 0 0 {name=p125232 lab=_81259_/CLK }
C {devices/lab_pin.sym} 125810 -11130 0 0 {name=p125233 lab=_80065_/Y }
C {devices/lab_pin.sym} 125990 -11150 0 1 {name=p125234 lab=_76917_/A }
C {sky130_stdcells/dfxtp_4.sym} 125900 -11140 0 0 {name=X_81679_ }
C {devices/lab_pin.sym} 125860 -11010 0 0 {name=p125235 lab=clkbuf_9_184_0_CLK/X }
C {devices/lab_pin.sym} 125940 -11010 0 1 {name=p125236 lab=_83046_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 125900 -11010 0 0 {name=Xclkbuf_10_369_0_CLK }
C {devices/lab_pin.sym} 125820 -10930 0 0 {name=p125237 lab=_43399_/X }
C {devices/lab_pin.sym} 125820 -10890 0 0 {name=p125238 lab=_43375_/X }
C {devices/lab_pin.sym} 125820 -10850 0 0 {name=p125239 lab=_41473_/X }
C {devices/lab_pin.sym} 125820 -10810 0 0 {name=p125240 lab=_87440_/Q }
C {devices/lab_pin.sym} 125820 -10770 0 0 {name=p125241 lab=_43378_/X }
C {devices/lab_pin.sym} 125980 -10850 0 1 {name=p125242 lab=_43400_/Y }
C {sky130_stdcells/o32ai_4.sym} 125900 -10850 0 0 {name=X_43400_ }
C {devices/lab_pin.sym} 125840 -10700 0 0 {name=p125243 lab=_48122_/Y }
C {devices/lab_pin.sym} 125840 -10660 0 0 {name=p125244 lab=_74220_/B }
C {devices/lab_pin.sym} 125960 -10680 0 1 {name=p125245 lab=_74221_/B }
C {sky130_stdcells/xor2_4.sym} 125900 -10680 0 0 {name=X_74220_ }
C {devices/lab_pin.sym} 125810 -10550 0 0 {name=p125246 lab=_86490_/CLK }
C {devices/lab_pin.sym} 125810 -10530 0 0 {name=p125247 lab=_50413_/Y }
C {devices/lab_pin.sym} 125990 -10550 0 1 {name=p125248 lab=_86206_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -10540 0 0 {name=X_86206_ }
C {devices/lab_pin.sym} 125860 -10410 0 0 {name=p125249 lab=_40832_/A }
C {devices/lab_pin.sym} 125940 -10410 0 1 {name=p125250 lab=_40612_/X }
C {sky130_stdcells/buf_2.sym} 125900 -10410 0 0 {name=X_40612_ }
C {devices/lab_pin.sym} 125840 -10320 0 0 {name=p125251 lab=_71432_/A }
C {devices/lab_pin.sym} 125840 -10280 0 0 {name=p125252 lab=_71432_/B }
C {devices/lab_pin.sym} 125840 -10240 0 0 {name=p125253 lab=_70782_/A }
C {devices/lab_pin.sym} 125840 -10200 0 0 {name=p125254 lab=_71432_/D }
C {devices/lab_pin.sym} 125960 -10260 0 1 {name=p125255 lab=_71432_/X }
C {sky130_stdcells/and4_4.sym} 125900 -10260 0 0 {name=X_71432_ }
C {devices/lab_pin.sym} 125840 -10120 0 0 {name=p125256 lab=_59154_/A }
C {devices/lab_pin.sym} 125840 -10080 0 0 {name=p125257 lab=_86357_/Q }
C {devices/lab_pin.sym} 125960 -10100 0 1 {name=p125258 lab=_59154_/Y }
C {sky130_stdcells/nor2_4.sym} 125900 -10100 0 0 {name=X_59154_ }
C {devices/lab_pin.sym} 125810 -9970 0 0 {name=p125259 lab=_83414_/CLK }
C {devices/lab_pin.sym} 125810 -9950 0 0 {name=p125260 lab=_71667_/Y }
C {devices/lab_pin.sym} 125990 -9970 0 1 {name=p125261 lab=_58530_/A }
C {sky130_stdcells/dfxtp_4.sym} 125900 -9960 0 0 {name=X_83418_ }
C {devices/lab_pin.sym} 125820 -9860 0 0 {name=p125262 lab=_41782_/X }
C {devices/lab_pin.sym} 125820 -9820 0 0 {name=p125263 lab=_44377_/X }
C {devices/lab_pin.sym} 125820 -9780 0 0 {name=p125264 lab=_87138_/Q }
C {devices/lab_pin.sym} 125820 -9740 0 0 {name=p125265 lab=_44379_/X }
C {devices/lab_pin.sym} 125980 -9800 0 1 {name=p125266 lab=_87138_/D }
C {sky130_stdcells/a2bb2o_4.sym} 125900 -9800 0 0 {name=X_44380_ }
C {devices/lab_pin.sym} 125820 -9670 0 0 {name=p125267 lab=_56168_/X }
C {devices/lab_pin.sym} 125820 -9630 0 0 {name=p125268 lab=_56284_/X }
C {devices/lab_pin.sym} 125820 -9590 0 0 {name=p125269 lab=_56365_/Y }
C {devices/lab_pin.sym} 125980 -9630 0 1 {name=p125270 lab=_85219_/D }
C {sky130_stdcells/o21ai_4.sym} 125900 -9630 0 0 {name=X_56366_ }
C {devices/lab_pin.sym} 125860 -9490 0 0 {name=p125271 lab=_41591_/Y }
C {devices/lab_pin.sym} 125940 -9490 0 1 {name=p125272 lab=_41592_/X }
C {sky130_stdcells/buf_2.sym} 125900 -9490 0 0 {name=X_41592_ }
C {devices/lab_pin.sym} 125810 -9370 0 0 {name=p125273 lab=_83753_/CLK }
C {devices/lab_pin.sym} 125810 -9350 0 0 {name=p125274 lab=_87186_/D }
C {devices/lab_pin.sym} 125990 -9370 0 1 {name=p125275 lab=_87186_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -9360 0 0 {name=X_87186_ }
C {devices/lab_pin.sym} 125820 -9250 0 0 {name=p125276 lab=_85609_/Q }
C {devices/lab_pin.sym} 125820 -9210 0 0 {name=p125277 lab=_53540_/X }
C {devices/lab_pin.sym} 125820 -9170 0 0 {name=p125278 lab=_53577_/Y }
C {devices/lab_pin.sym} 125980 -9210 0 1 {name=p125279 lab=_53578_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -9210 0 0 {name=X_53578_ }
C {devices/lab_pin.sym} 125860 -9070 0 0 {name=p125280 lab=clkbuf_9_499_0_CLK/X }
C {devices/lab_pin.sym} 125940 -9070 0 1 {name=p125281 lab=_86516_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 125900 -9070 0 0 {name=Xclkbuf_10_999_0_CLK }
C {devices/lab_pin.sym} 125810 -8950 0 0 {name=p125282 lab=_83242_/CLK }
C {devices/lab_pin.sym} 125810 -8930 0 0 {name=p125283 lab=_84398_/D }
C {devices/lab_pin.sym} 125990 -8950 0 1 {name=p125284 lab=_84398_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -8940 0 0 {name=X_84398_ }
C {devices/lab_pin.sym} 125860 -8810 0 0 {name=p125285 lab=_58610_/A }
C {devices/lab_pin.sym} 125940 -8810 0 1 {name=p125286 lab=_58105_/X }
C {sky130_stdcells/buf_2.sym} 125900 -8810 0 0 {name=X_58105_ }
C {devices/lab_pin.sym} 125820 -8730 0 0 {name=p125287 lab=_43316_/X }
C {devices/lab_pin.sym} 125820 -8690 0 0 {name=p125288 lab=_43319_/X }
C {devices/lab_pin.sym} 125820 -8650 0 0 {name=p125289 lab=_41277_/X }
C {devices/lab_pin.sym} 125820 -8610 0 0 {name=p125290 lab=_87477_/Q }
C {devices/lab_pin.sym} 125820 -8570 0 0 {name=p125291 lab=_43330_/X }
C {devices/lab_pin.sym} 125980 -8650 0 1 {name=p125292 lab=_43332_/A }
C {sky130_stdcells/o32ai_4.sym} 125900 -8650 0 0 {name=X_43331_ }
C {devices/lab_pin.sym} 125840 -8500 0 0 {name=p125293 lab=_55317_/A }
C {devices/lab_pin.sym} 125840 -8460 0 0 {name=p125294 lab=_55317_/B }
C {devices/lab_pin.sym} 125960 -8480 0 1 {name=p125295 lab=_55317_/X }
C {sky130_stdcells/and2_4.sym} 125900 -8480 0 0 {name=X_55317_ }
C {devices/lab_pin.sym} 125820 -8380 0 0 {name=p125296 lab=_74080_/X }
C {devices/lab_pin.sym} 125820 -8340 0 0 {name=p125297 lab=_86216_/Q }
C {devices/lab_pin.sym} 125820 -8300 0 0 {name=p125298 lab=_74103_/X }
C {devices/lab_pin.sym} 125820 -8260 0 0 {name=p125299 lab=_74150_/X }
C {devices/lab_pin.sym} 125980 -8320 0 1 {name=p125300 lab=_74151_/X }
C {sky130_stdcells/a211o_4.sym} 125900 -8320 0 0 {name=X_74151_ }
C {devices/lab_pin.sym} 125810 -8170 0 0 {name=p125301 lab=_85529_/CLK }
C {devices/lab_pin.sym} 125810 -8150 0 0 {name=p125302 lab=_50770_/Y }
C {devices/lab_pin.sym} 125990 -8170 0 1 {name=p125303 lab=_86137_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -8160 0 0 {name=X_86137_ }
C {devices/lab_pin.sym} 125860 -8030 0 0 {name=p125304 lab=_40409_/X }
C {devices/lab_pin.sym} 125940 -8030 0 1 {name=p125305 lab=_40543_/X }
C {sky130_stdcells/buf_2.sym} 125900 -8030 0 0 {name=X_40543_ }
C {devices/lab_pin.sym} 125820 -7930 0 0 {name=p125306 lab=_52527_/Y }
C {devices/lab_pin.sym} 125820 -7890 0 0 {name=p125307 lab=_52496_/X }
C {devices/lab_pin.sym} 125820 -7850 0 0 {name=p125308 lab=_52528_/X }
C {devices/lab_pin.sym} 125980 -7890 0 1 {name=p125309 lab=_52529_/Y }
C {sky130_stdcells/a21oi_4.sym} 125900 -7890 0 0 {name=X_52529_ }
C {devices/lab_pin.sym} 125860 -7750 0 0 {name=p125310 lab=_59085_/A }
C {devices/lab_pin.sym} 125940 -7750 0 1 {name=p125311 lab=_59085_/X }
C {sky130_stdcells/buf_2.sym} 125900 -7750 0 0 {name=X_59085_ }
C {devices/lab_pin.sym} 125840 -7660 0 0 {name=p125312 lab=_71366_/A }
C {devices/lab_pin.sym} 125840 -7620 0 0 {name=p125313 lab=_71351_/X }
C {devices/lab_pin.sym} 125840 -7580 0 0 {name=p125314 lab=_71435_/C }
C {devices/lab_pin.sym} 125840 -7540 0 0 {name=p125315 lab=_71363_/D }
C {devices/lab_pin.sym} 125960 -7600 0 1 {name=p125316 lab=_71363_/X }
C {sky130_stdcells/and4_4.sym} 125900 -7600 0 0 {name=X_71363_ }
C {devices/lab_pin.sym} 125810 -7450 0 0 {name=p125317 lab=_83763_/CLK }
C {devices/lab_pin.sym} 125810 -7430 0 0 {name=p125318 lab=_83349_/D }
C {devices/lab_pin.sym} 125990 -7450 0 1 {name=p125319 lab=_83349_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -7440 0 0 {name=X_83349_ }
C {devices/lab_pin.sym} 125820 -7330 0 0 {name=p125320 lab=_56020_/X }
C {devices/lab_pin.sym} 125820 -7290 0 0 {name=p125321 lab=_56290_/X }
C {devices/lab_pin.sym} 125820 -7250 0 0 {name=p125322 lab=_56296_/Y }
C {devices/lab_pin.sym} 125980 -7290 0 1 {name=p125323 lab=_56297_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -7290 0 0 {name=X_56297_ }
C {devices/lab_pin.sym} 125820 -7170 0 0 {name=p125324 lab=_73100_/X }
C {devices/lab_pin.sym} 125820 -7130 0 0 {name=p125325 lab=_73101_/Y }
C {devices/lab_pin.sym} 125820 -7090 0 0 {name=p125326 lab=_72970_/X }
C {devices/lab_pin.sym} 125980 -7130 0 1 {name=p125327 lab=_73102_/Y }
C {sky130_stdcells/a21oi_4.sym} 125900 -7130 0 0 {name=X_73102_ }
C {devices/lab_pin.sym} 125820 -7030 0 0 {name=p125328 lab=_46046_/X }
C {devices/lab_pin.sym} 125820 -6990 0 0 {name=p125329 lab=_46032_/X }
C {devices/lab_pin.sym} 125820 -6950 0 0 {name=p125330 lab=_41519_/X }
C {devices/lab_pin.sym} 125820 -6910 0 0 {name=p125331 lab=_86794_/Q }
C {devices/lab_pin.sym} 125820 -6870 0 0 {name=p125332 lab=_46047_/X }
C {devices/lab_pin.sym} 125980 -6950 0 1 {name=p125333 lab=_46051_/A }
C {sky130_stdcells/o32ai_4.sym} 125900 -6950 0 0 {name=X_46050_ }
C {devices/lab_pin.sym} 125820 -6810 0 0 {name=p125334 lab=_58032_/Y }
C {devices/lab_pin.sym} 125820 -6770 0 0 {name=p125335 lab=_58034_/Y }
C {devices/lab_pin.sym} 125820 -6730 0 0 {name=p125336 lab=_58035_/X }
C {devices/lab_pin.sym} 125980 -6770 0 1 {name=p125337 lab=_58036_/X }
C {sky130_stdcells/a21o_4.sym} 125900 -6770 0 0 {name=X_58036_ }
C {devices/lab_pin.sym} 125820 -6650 0 0 {name=p125338 lab=_70303_/X }
C {devices/lab_pin.sym} 125820 -6610 0 0 {name=p125339 lab=_74808_/B }
C {devices/lab_pin.sym} 125820 -6570 0 0 {name=p125340 lab=_70313_/X }
C {devices/lab_pin.sym} 125980 -6610 0 1 {name=p125341 lab=_70314_/X }
C {sky130_stdcells/a21o_4.sym} 125900 -6610 0 0 {name=X_70314_ }
C {devices/lab_pin.sym} 125840 -6480 0 0 {name=p125342 lab=_55135_/A }
C {devices/lab_pin.sym} 125840 -6440 0 0 {name=p125343 lab=_55248_/B }
C {devices/lab_pin.sym} 125960 -6460 0 1 {name=p125344 lab=_55248_/X }
C {sky130_stdcells/and2_4.sym} 125900 -6460 0 0 {name=X_55248_ }
C {devices/lab_pin.sym} 125860 -6330 0 0 {name=p125345 lab=_43261_/Y }
C {devices/lab_pin.sym} 125940 -6330 0 1 {name=p125346 lab=_43262_/Y }
C {sky130_stdcells/inv_2.sym} 125900 -6330 0 0 {name=X_43262_ }
C {devices/lab_pin.sym} 125820 -6240 0 0 {name=p125347 lab=_74080_/X }
C {devices/lab_pin.sym} 125820 -6200 0 0 {name=p125348 lab=_86219_/Q }
C {devices/lab_pin.sym} 125820 -6160 0 0 {name=p125349 lab=_73446_/X }
C {devices/lab_pin.sym} 125820 -6120 0 0 {name=p125350 lab=_74081_/X }
C {devices/lab_pin.sym} 125980 -6180 0 1 {name=p125351 lab=_74082_/X }
C {sky130_stdcells/a211o_4.sym} 125900 -6180 0 0 {name=X_74082_ }
C {devices/lab_pin.sym} 125810 -6030 0 0 {name=p125352 lab=_85748_/CLK }
C {devices/lab_pin.sym} 125810 -6010 0 0 {name=p125353 lab=_86068_/D }
C {devices/lab_pin.sym} 125990 -6030 0 1 {name=p125354 lab=_86068_/Q }
C {sky130_stdcells/dfxtp_4.sym} 125900 -6020 0 0 {name=X_86068_ }
C {devices/lab_pin.sym} 125860 -5890 0 0 {name=p125355 lab=_40473_/X }
C {devices/lab_pin.sym} 125940 -5890 0 1 {name=p125356 lab=_40474_/X }
C {sky130_stdcells/buf_2.sym} 125900 -5890 0 0 {name=X_40474_ }
C {devices/lab_pin.sym} 125860 -5770 0 0 {name=p125357 lab=_71185_/B }
C {devices/lab_pin.sym} 125940 -5770 0 1 {name=p125358 lab=_71303_/B }
C {sky130_stdcells/buf_2.sym} 125900 -5770 0 0 {name=X_71294_ }
C {devices/lab_pin.sym} 125820 -5670 0 0 {name=p125359 lab=_55931_/B }
C {devices/lab_pin.sym} 125820 -5630 0 0 {name=p125360 lab=_44982_/X }
C {devices/lab_pin.sym} 125820 -5590 0 0 {name=p125361 lab=_44959_/X }
C {devices/lab_pin.sym} 125980 -5630 0 1 {name=p125362 lab=_45001_/X }
C {sky130_stdcells/o21a_4.sym} 125900 -5630 0 0 {name=X_45001_ }
C {devices/lab_pin.sym} 125860 -5490 0 0 {name=p125363 lab=clkbuf_9_461_0_CLK/X }
C {devices/lab_pin.sym} 125940 -5490 0 1 {name=p125364 lab=_87070_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 125900 -5490 0 0 {name=Xclkbuf_10_922_0_CLK }
C {devices/lab_pin.sym} 125860 -5370 0 0 {name=p125365 lab=_42212_/Y }
C {devices/lab_pin.sym} 125940 -5370 0 1 {name=p125366 lab=_87978_/D }
C {sky130_stdcells/inv_2.sym} 125900 -5370 0 0 {name=X_42213_ }
C {devices/lab_pin.sym} 125860 -5250 0 0 {name=p125367 lab=_77909_/X }
C {devices/lab_pin.sym} 125940 -5250 0 1 {name=p125368 lab=_77910_/Y }
C {sky130_stdcells/inv_2.sym} 125900 -5250 0 0 {name=X_77910_ }
C {devices/lab_pin.sym} 125840 -5140 0 0 {name=p125369 lab=_73033_/A }
C {devices/lab_pin.sym} 125840 -5100 0 0 {name=p125370 lab=_73372_/B }
C {devices/lab_pin.sym} 125960 -5120 0 1 {name=p125371 lab=_73033_/Y }
C {sky130_stdcells/nor2_4.sym} 125900 -5120 0 0 {name=X_73033_ }
C {devices/lab_pin.sym} 125810 -4990 0 0 {name=p125372 lab=_85013_/CLK }
C {devices/lab_pin.sym} 125810 -4970 0 0 {name=p125373 lab=_57393_/Y }
C {devices/lab_pin.sym} 125990 -4990 0 1 {name=p125374 lab=_57392_/B }
C {sky130_stdcells/dfxtp_4.sym} 125900 -4980 0 0 {name=X_85019_ }
C {devices/lab_pin.sym} 125860 -4850 0 0 {name=p125375 lab=_70127_/X }
C {devices/lab_pin.sym} 125940 -4850 0 1 {name=p125376 lab=_70246_/A }
C {sky130_stdcells/buf_2.sym} 125900 -4850 0 0 {name=X_70245_ }
C {devices/lab_pin.sym} 125820 -4770 0 0 {name=p125377 lab=_43031_/X }
C {devices/lab_pin.sym} 125820 -4730 0 0 {name=p125378 lab=_43125_/X }
C {devices/lab_pin.sym} 125820 -4690 0 0 {name=p125379 lab=_40903_/X }
C {devices/lab_pin.sym} 125820 -4650 0 0 {name=p125380 lab=_43192_/Y }
C {devices/lab_pin.sym} 125820 -4610 0 0 {name=p125381 lab=_43142_/X }
C {devices/lab_pin.sym} 125980 -4690 0 1 {name=p125382 lab=_43193_/Y }
C {sky130_stdcells/o32ai_4.sym} 125900 -4690 0 0 {name=X_43193_ }
C {devices/lab_pin.sym} 125820 -4550 0 0 {name=p125383 lab=_55171_/X }
C {devices/lab_pin.sym} 125820 -4510 0 0 {name=p125384 lab=_55178_/X }
C {devices/lab_pin.sym} 125820 -4470 0 0 {name=p125385 lab=_83748_/Q }
C {devices/lab_pin.sym} 125980 -4510 0 1 {name=p125386 lab=_55179_/X }
C {sky130_stdcells/a21o_4.sym} 125900 -4510 0 0 {name=X_55179_ }
C {devices/lab_pin.sym} 125860 -4370 0 0 {name=p125387 lab=_82636_/Q }
C {devices/lab_pin.sym} 125940 -4370 0 1 {name=p125388 lab=_78890_/Y }
C {sky130_stdcells/inv_2.sym} 125900 -4370 0 0 {name=X_78890_ }
C {devices/lab_pin.sym} 125860 -4250 0 0 {name=p125389 lab=clkbuf_9_413_0_CLK/A }
C {devices/lab_pin.sym} 125940 -4250 0 1 {name=p125390 lab=clkbuf_9_413_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 125900 -4250 0 0 {name=Xclkbuf_9_413_0_CLK }
C {devices/lab_pin.sym} 125860 -4130 0 0 {name=p125391 lab=_42143_/Y }
C {devices/lab_pin.sym} 125940 -4130 0 1 {name=p125392 lab=_88014_/D }
C {sky130_stdcells/inv_2.sym} 125900 -4130 0 0 {name=X_42144_ }
C {devices/lab_pin.sym} 125840 -4020 0 0 {name=p125393 lab=_77841_/A }
C {devices/lab_pin.sym} 125840 -3980 0 0 {name=p125394 lab=_77840_/Y }
C {devices/lab_pin.sym} 125960 -4000 0 1 {name=p125395 lab=_77841_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -4000 0 0 {name=X_77841_ }
C {devices/lab_pin.sym} 125840 -3900 0 0 {name=p125396 lab=_70183_/A }
C {devices/lab_pin.sym} 125840 -3860 0 0 {name=p125397 lab=_70183_/B }
C {devices/lab_pin.sym} 125840 -3820 0 0 {name=p125398 lab=_70176_/C }
C {devices/lab_pin.sym} 125840 -3780 0 0 {name=p125399 lab=_70183_/D }
C {devices/lab_pin.sym} 125960 -3840 0 1 {name=p125400 lab=_70176_/X }
C {sky130_stdcells/and4_4.sym} 125900 -3840 0 0 {name=X_70176_ }
C {devices/lab_pin.sym} 125860 -3690 0 0 {name=p125401 lab=_62609_/D }
C {devices/lab_pin.sym} 125940 -3690 0 1 {name=p125402 lab=_59987_/X }
C {sky130_stdcells/buf_2.sym} 125900 -3690 0 0 {name=X_59987_ }
C {devices/lab_pin.sym} 125860 -3570 0 0 {name=p125403 lab=clkbuf_9_153_0_CLK/X }
C {devices/lab_pin.sym} 125940 -3570 0 1 {name=p125404 lab=_83367_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 125900 -3570 0 0 {name=Xclkbuf_10_307_0_CLK }
C {devices/lab_pin.sym} 125820 -3470 0 0 {name=p125405 lab=_49737_/Y }
C {devices/lab_pin.sym} 125820 -3430 0 0 {name=p125406 lab=_49732_/X }
C {devices/lab_pin.sym} 125820 -3390 0 0 {name=p125407 lab=_49739_/X }
C {devices/lab_pin.sym} 125980 -3430 0 1 {name=p125408 lab=_86332_/D }
C {sky130_stdcells/a21oi_4.sym} 125900 -3430 0 0 {name=X_49740_ }
C {devices/lab_pin.sym} 125860 -3290 0 0 {name=p125409 lab=_46952_/A }
C {devices/lab_pin.sym} 125940 -3290 0 1 {name=p125410 lab=_52771_/D }
C {sky130_stdcells/buf_2.sym} 125900 -3290 0 0 {name=X_46952_ }
C {devices/lab_pin.sym} 125820 -3200 0 0 {name=p125411 lab=_40968_/X }
C {devices/lab_pin.sym} 125820 -3160 0 0 {name=p125412 lab=_42072_/X }
C {devices/lab_pin.sym} 125820 -3120 0 0 {name=p125413 lab=_88045_/Q }
C {devices/lab_pin.sym} 125820 -3080 0 0 {name=p125414 lab=_42073_/X }
C {devices/lab_pin.sym} 125980 -3140 0 1 {name=p125415 lab=_42075_/X }
C {sky130_stdcells/a2bb2o_4.sym} 125900 -3140 0 0 {name=X_42075_ }
C {devices/lab_pin.sym} 125820 -3010 0 0 {name=p125416 lab=_58796_/X }
C {devices/lab_pin.sym} 125820 -2970 0 0 {name=p125417 lab=_86084_/Q }
C {devices/lab_pin.sym} 125820 -2930 0 0 {name=p125418 lab=_58937_/X }
C {devices/lab_pin.sym} 125980 -2970 0 1 {name=p125419 lab=_58938_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -2970 0 0 {name=X_58938_ }
C {devices/lab_pin.sym} 125820 -2850 0 0 {name=p125420 lab=_77763_/Y }
C {devices/lab_pin.sym} 125820 -2810 0 0 {name=p125421 lab=_77766_/Y }
C {devices/lab_pin.sym} 125820 -2770 0 0 {name=p125422 lab=_77771_/Y }
C {devices/lab_pin.sym} 125980 -2810 0 1 {name=p125423 lab=_77773_/B }
C {sky130_stdcells/o21ai_4.sym} 125900 -2810 0 0 {name=X_77772_ }
C {devices/lab_pin.sym} 125840 -2680 0 0 {name=p125424 lab=_74981_/Y }
C {devices/lab_pin.sym} 125840 -2640 0 0 {name=p125425 lab=_74983_/Y }
C {devices/lab_pin.sym} 125960 -2660 0 1 {name=p125426 lab=_74985_/B }
C {sky130_stdcells/xor2_4.sym} 125900 -2660 0 0 {name=X_74984_ }
C {devices/lab_pin.sym} 125860 -2530 0 0 {name=p125427 lab=clkbuf_9_468_0_CLK/X }
C {devices/lab_pin.sym} 125940 -2530 0 1 {name=p125428 lab=_88326_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 125900 -2530 0 0 {name=Xclkbuf_10_937_0_CLK }
C {devices/lab_pin.sym} 125840 -2420 0 0 {name=p125429 lab=_79500_/Y }
C {devices/lab_pin.sym} 125840 -2380 0 0 {name=p125430 lab=_79504_/B }
C {devices/lab_pin.sym} 125960 -2400 0 1 {name=p125431 lab=_79512_/B }
C {sky130_stdcells/or2_4.sym} 125900 -2400 0 0 {name=X_79511_ }
C {devices/lab_pin.sym} 125840 -2280 0 0 {name=p125432 lab=_41026_/A }
C {devices/lab_pin.sym} 125840 -2240 0 0 {name=p125433 lab=_41091_/B }
C {devices/lab_pin.sym} 125960 -2260 0 1 {name=p125434 lab=_41026_/X }
C {sky130_stdcells/or2_4.sym} 125900 -2260 0 0 {name=X_41026_ }
C {devices/lab_pin.sym} 125860 -2130 0 0 {name=p125435 lab=_44128_/X }
C {devices/lab_pin.sym} 125940 -2130 0 1 {name=p125436 lab=_72973_/B }
C {sky130_stdcells/buf_2.sym} 125900 -2130 0 0 {name=X_45903_ }
C {devices/lab_pin.sym} 125820 -2030 0 0 {name=p125437 lab=_76703_/Y }
C {devices/lab_pin.sym} 125820 -1990 0 0 {name=p125438 lab=_76719_/A }
C {devices/lab_pin.sym} 125820 -1950 0 0 {name=p125439 lab=_76722_/X }
C {devices/lab_pin.sym} 125980 -1990 0 1 {name=p125440 lab=_76723_/Y }
C {sky130_stdcells/a21oi_4.sym} 125900 -1990 0 0 {name=X_76723_ }
C {devices/lab_pin.sym} 125840 -1860 0 0 {name=p125441 lab=_49661_/X }
C {devices/lab_pin.sym} 125840 -1820 0 0 {name=p125442 lab=_52885_/B }
C {devices/lab_pin.sym} 125960 -1840 0 1 {name=p125443 lab=_49671_/Y }
C {sky130_stdcells/nand2_4.sym} 125900 -1840 0 0 {name=X_49671_ }
C {devices/lab_pin.sym} 125840 -1720 0 0 {name=p125444 lab=_73924_/Y }
C {devices/lab_pin.sym} 125840 -1680 0 0 {name=p125445 lab=_73935_/B }
C {devices/lab_pin.sym} 125960 -1700 0 1 {name=p125446 lab=_73937_/A }
C {sky130_stdcells/xor2_4.sym} 125900 -1700 0 0 {name=X_73935_ }
C {devices/lab_pin.sym} 125860 -1570 0 0 {name=p125447 lab=_54423_/D }
C {devices/lab_pin.sym} 125940 -1570 0 1 {name=p125448 lab=_52730_/D }
C {sky130_stdcells/buf_2.sym} 125900 -1570 0 0 {name=X_46883_ }
C {devices/lab_pin.sym} 125820 -1490 0 0 {name=p125449 lab=_58864_/X }
C {devices/lab_pin.sym} 125820 -1450 0 0 {name=p125450 lab=_58866_/Y }
C {devices/lab_pin.sym} 125820 -1410 0 0 {name=p125451 lab=_58867_/Y }
C {devices/lab_pin.sym} 125820 -1370 0 0 {name=p125452 lab=_58766_/X }
C {devices/lab_pin.sym} 125820 -1330 0 0 {name=p125453 lab=_58868_/X }
C {devices/lab_pin.sym} 125980 -1410 0 1 {name=p125454 lab=_58869_/X }
C {sky130_stdcells/o32a_4.sym} 125900 -1410 0 0 {name=X_58869_ }
C {devices/lab_pin.sym} 125860 -1250 0 0 {name=p125455 lab=clkbuf_9_429_0_CLK/A }
C {devices/lab_pin.sym} 125940 -1250 0 1 {name=p125456 lab=clkbuf_9_428_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 125900 -1250 0 0 {name=Xclkbuf_9_428_0_CLK }
C {devices/lab_pin.sym} 125860 -1130 0 0 {name=p125457 lab=_47872_/A }
C {devices/lab_pin.sym} 125940 -1130 0 1 {name=p125458 lab=_48623_/A }
C {sky130_stdcells/buf_2.sym} 125900 -1130 0 0 {name=X_48622_ }
C {devices/lab_pin.sym} 125860 -1010 0 0 {name=p125459 lab=_60888_/Y }
C {devices/lab_pin.sym} 125940 -1010 0 1 {name=p125460 lab=_60910_/B }
C {sky130_stdcells/buf_2.sym} 125900 -1010 0 0 {name=X_60900_ }
C {devices/lab_pin.sym} 125820 -910 0 0 {name=p125461 lab=_79439_/Y }
C {devices/lab_pin.sym} 125820 -870 0 0 {name=p125462 lab=_79422_/Y }
C {devices/lab_pin.sym} 125820 -830 0 0 {name=p125463 lab=_79441_/X }
C {devices/lab_pin.sym} 125980 -870 0 1 {name=p125464 lab=_79442_/Y }
C {sky130_stdcells/o21ai_4.sym} 125900 -870 0 0 {name=X_79442_ }
C {devices/lab_pin.sym} 125860 -730 0 0 {name=p125465 lab=_63324_/B }
C {devices/lab_pin.sym} 125940 -730 0 1 {name=p125466 lab=_61666_/A }
C {sky130_stdcells/buf_2.sym} 125900 -730 0 0 {name=X_45834_ }
C {devices/lab_pin.sym} 126740 -42170 0 0 {name=p125467 lab=_76651_/Y }
C {devices/lab_pin.sym} 126740 -42130 0 0 {name=p125468 lab=_76653_/Y }
C {devices/lab_pin.sym} 126740 -42090 0 0 {name=p125469 lab=_76648_/A }
C {devices/lab_pin.sym} 126900 -42130 0 1 {name=p125470 lab=_76664_/A }
C {sky130_stdcells/a21oi_4.sym} 126820 -42130 0 0 {name=X_76654_ }
C {devices/lab_pin.sym} 126740 -42030 0 0 {name=p125471 lab=_61869_/X }
C {devices/lab_pin.sym} 126740 -41990 0 0 {name=p125472 lab=_61872_/X }
C {devices/lab_pin.sym} 126740 -41950 0 0 {name=p125473 lab=_61879_/Y }
C {devices/lab_pin.sym} 126740 -41910 0 0 {name=p125474 lab=_84744_/Q }
C {devices/lab_pin.sym} 126740 -41870 0 0 {name=p125475 lab=_61815_/X }
C {devices/lab_pin.sym} 126900 -41950 0 1 {name=p125476 lab=_61880_/Y }
C {sky130_stdcells/o32ai_4.sym} 126820 -41950 0 0 {name=X_61880_ }
C {devices/lab_pin.sym} 126760 -41810 0 0 {name=p125477 lab=_73864_/X }
C {devices/lab_pin.sym} 126760 -41770 0 0 {name=p125478 lab=_73866_/B }
C {devices/lab_pin.sym} 126760 -41730 0 0 {name=p125479 lab=_73866_/C }
C {devices/lab_pin.sym} 126880 -41770 0 1 {name=p125480 lab=_73866_/Y }
C {sky130_stdcells/nand3_4.sym} 126820 -41770 0 0 {name=X_73866_ }
C {devices/lab_pin.sym} 126760 -41640 0 0 {name=p125481 lab=_81110_/Q }
C {devices/lab_pin.sym} 126760 -41600 0 0 {name=p125482 lab=_75605_/B }
C {devices/lab_pin.sym} 126880 -41620 0 1 {name=p125483 lab=_80774_/D }
C {sky130_stdcells/xor2_4.sym} 126820 -41620 0 0 {name=X_75605_ }
C {devices/lab_pin.sym} 126740 -41510 0 0 {name=p125484 lab=_86512_/Q }
C {devices/lab_pin.sym} 126740 -41470 0 0 {name=p125485 lab=_48548_/X }
C {devices/lab_pin.sym} 126740 -41430 0 0 {name=p125486 lab=_48552_/Y }
C {devices/lab_pin.sym} 126900 -41470 0 1 {name=p125487 lab=_48553_/Y }
C {sky130_stdcells/o21ai_4.sym} 126820 -41470 0 0 {name=X_48553_ }
C {devices/lab_pin.sym} 126760 -41340 0 0 {name=p125488 lab=_72816_/X }
C {devices/lab_pin.sym} 126760 -41300 0 0 {name=p125489 lab=_72817_/B }
C {devices/lab_pin.sym} 126880 -41320 0 1 {name=p125490 lab=_72817_/X }
C {sky130_stdcells/and2_4.sym} 126820 -41320 0 0 {name=X_72817_ }
C {devices/lab_pin.sym} 126780 -41190 0 0 {name=p125491 lab=_60830_/X }
C {devices/lab_pin.sym} 126860 -41190 0 1 {name=p125492 lab=_84556_/D }
C {sky130_stdcells/inv_2.sym} 126820 -41190 0 0 {name=X_60831_ }
C {devices/lab_pin.sym} 126760 -41080 0 0 {name=p125493 lab=_79373_/A }
C {devices/lab_pin.sym} 126760 -41040 0 0 {name=p125494 lab=_79373_/B }
C {devices/lab_pin.sym} 126880 -41060 0 1 {name=p125495 lab=_79373_/Y }
C {sky130_stdcells/xnor2_4.sym} 126820 -41060 0 0 {name=X_79373_ }
C {devices/lab_pin.sym} 126780 -40930 0 0 {name=p125496 lab=_45765_/A }
C {devices/lab_pin.sym} 126860 -40930 0 1 {name=p125497 lab=_45765_/X }
C {sky130_stdcells/buf_2.sym} 126820 -40930 0 0 {name=X_45765_ }
C {devices/lab_pin.sym} 126760 -40840 0 0 {name=p125498 lab=_76541_/B }
C {devices/lab_pin.sym} 126760 -40800 0 0 {name=p125499 lab=_76559_/Y }
C {devices/lab_pin.sym} 126760 -40760 0 0 {name=p125500 lab=_76541_/A }
C {devices/lab_pin.sym} 126760 -40720 0 0 {name=p125501 lab=_76560_/Y }
C {devices/lab_pin.sym} 126880 -40780 0 1 {name=p125502 lab=_76585_/Y }
C {sky130_stdcells/nand4_4.sym} 126820 -40780 0 0 {name=X_76585_ }
C {devices/lab_pin.sym} 126740 -40670 0 0 {name=p125503 lab=_42970_/X }
C {devices/lab_pin.sym} 126740 -40630 0 0 {name=p125504 lab=_42971_/X }
C {devices/lab_pin.sym} 126740 -40590 0 0 {name=p125505 lab=_40446_/X }
C {devices/lab_pin.sym} 126740 -40550 0 0 {name=p125506 lab=_87622_/Q }
C {devices/lab_pin.sym} 126740 -40510 0 0 {name=p125507 lab=_42976_/X }
C {devices/lab_pin.sym} 126900 -40590 0 1 {name=p125508 lab=_42978_/A }
C {sky130_stdcells/o32ai_4.sym} 126820 -40590 0 0 {name=X_42977_ }
C {devices/lab_pin.sym} 126760 -40440 0 0 {name=p125509 lab=_73797_/A }
C {devices/lab_pin.sym} 126760 -40400 0 0 {name=p125510 lab=_73701_/B }
C {devices/lab_pin.sym} 126880 -40420 0 1 {name=p125511 lab=_73797_/Y }
C {sky130_stdcells/nor2_4.sym} 126820 -40420 0 0 {name=X_73797_ }
C {devices/lab_pin.sym} 126740 -40310 0 0 {name=p125512 lab=_47500_/Y }
C {devices/lab_pin.sym} 126740 -40270 0 0 {name=p125513 lab=_47462_/X }
C {devices/lab_pin.sym} 126740 -40230 0 0 {name=p125514 lab=_47503_/X }
C {devices/lab_pin.sym} 126900 -40270 0 1 {name=p125515 lab=_47504_/Y }
C {sky130_stdcells/a21oi_4.sym} 126820 -40270 0 0 {name=X_47504_ }
C {devices/lab_pin.sym} 126760 -40150 0 0 {name=p125516 lab=_78317_/X }
C {devices/lab_pin.sym} 126760 -40110 0 0 {name=p125517 lab=_78324_/B }
C {devices/lab_pin.sym} 126760 -40070 0 0 {name=p125518 lab=_78335_/A }
C {devices/lab_pin.sym} 126880 -40110 0 1 {name=p125519 lab=_78325_/B }
C {sky130_stdcells/nand3_4.sym} 126820 -40110 0 0 {name=X_78324_ }
C {devices/lab_pin.sym} 126780 -39970 0 0 {name=p125520 lab=_44716_/A }
C {devices/lab_pin.sym} 126860 -39970 0 1 {name=p125521 lab=_86990_/D }
C {sky130_stdcells/inv_2.sym} 126820 -39970 0 0 {name=X_44716_ }
C {devices/lab_pin.sym} 126760 -39870 0 0 {name=p125522 lab=_63512_/A }
C {devices/lab_pin.sym} 126760 -39830 0 0 {name=p125523 lab=_84954_/Q }
C {devices/lab_pin.sym} 126760 -39790 0 0 {name=p125524 lab=_63537_/C }
C {devices/lab_pin.sym} 126880 -39830 0 1 {name=p125525 lab=_63550_/X }
C {sky130_stdcells/and3_4.sym} 126820 -39830 0 0 {name=X_63550_ }
C {devices/lab_pin.sym} 126760 -39720 0 0 {name=p125526 lab=_75536_/A }
C {devices/lab_pin.sym} 126760 -39680 0 0 {name=p125527 lab=_75523_/X }
C {devices/lab_pin.sym} 126760 -39640 0 0 {name=p125528 lab=_75503_/Y }
C {devices/lab_pin.sym} 126760 -39600 0 0 {name=p125529 lab=_75524_/Y }
C {devices/lab_pin.sym} 126880 -39660 0 1 {name=p125530 lab=_75536_/X }
C {sky130_stdcells/and4_4.sym} 126820 -39660 0 0 {name=X_75536_ }
C {devices/lab_pin.sym} 126780 -39510 0 0 {name=p125531 lab=_42000_/A }
C {devices/lab_pin.sym} 126860 -39510 0 1 {name=p125532 lab=_41928_/X }
C {sky130_stdcells/buf_2.sym} 126820 -39510 0 0 {name=X_41928_ }
C {devices/lab_pin.sym} 126780 -39390 0 0 {name=p125533 lab=_48484_/A }
C {devices/lab_pin.sym} 126860 -39390 0 1 {name=p125534 lab=_48485_/A }
C {sky130_stdcells/inv_2.sym} 126820 -39390 0 0 {name=X_48484_ }
C {devices/lab_pin.sym} 126740 -39310 0 0 {name=p125535 lab=_60739_/X }
C {devices/lab_pin.sym} 126740 -39270 0 0 {name=p125536 lab=_60759_/Y }
C {devices/lab_pin.sym} 126740 -39230 0 0 {name=p125537 lab=_60722_/Y }
C {devices/lab_pin.sym} 126740 -39190 0 0 {name=p125538 lab=_60726_/Y }
C {devices/lab_pin.sym} 126740 -39160 0 0 {name=p125539 lab=_60761_/Y }
C {devices/lab_pin.sym} 126900 -39230 0 1 {name=p125540 lab=_84573_/D }
C {sky130_stdcells/a41oi_4.sym} 126820 -39230 0 0 {name=X_60762_ }
C {devices/lab_pin.sym} 126760 -39080 0 0 {name=p125541 lab=_72929_/A }
C {devices/lab_pin.sym} 126760 -39040 0 0 {name=p125542 lab=_65423_/B }
C {devices/lab_pin.sym} 126880 -39060 0 1 {name=p125543 lab=_72748_/X }
C {sky130_stdcells/and2_4.sym} 126820 -39060 0 0 {name=X_72748_ }
C {devices/lab_pin.sym} 126780 -38930 0 0 {name=p125544 lab=_82990_/Q }
C {devices/lab_pin.sym} 126860 -38930 0 1 {name=p125545 lab=_45697_/A }
C {sky130_stdcells/inv_2.sym} 126820 -38930 0 0 {name=X_45696_ }
C {devices/lab_pin.sym} 126780 -38810 0 0 {name=p125546 lab=_62501_/A }
C {devices/lab_pin.sym} 126860 -38810 0 1 {name=p125547 lab=_62501_/X }
C {sky130_stdcells/buf_2.sym} 126820 -38810 0 0 {name=X_62501_ }
C {devices/lab_pin.sym} 126780 -38690 0 0 {name=p125548 lab=_46610_/A }
C {devices/lab_pin.sym} 126860 -38690 0 1 {name=p125549 lab=_49406_/A }
C {sky130_stdcells/buf_2.sym} 126820 -38690 0 0 {name=X_47435_ }
C {devices/lab_pin.sym} 126740 -38590 0 0 {name=p125550 lab=_78239_/B }
C {devices/lab_pin.sym} 126740 -38550 0 0 {name=p125551 lab=_78252_/X }
C {devices/lab_pin.sym} 126740 -38510 0 0 {name=p125552 lab=_78254_/Y }
C {devices/lab_pin.sym} 126900 -38550 0 1 {name=p125553 lab=_78256_/B }
C {sky130_stdcells/a21oi_4.sym} 126820 -38550 0 0 {name=X_78255_ }
C {devices/lab_pin.sym} 126780 -38410 0 0 {name=p125554 lab=_44647_/A }
C {devices/lab_pin.sym} 126860 -38410 0 1 {name=p125555 lab=_44647_/Y }
C {sky130_stdcells/inv_2.sym} 126820 -38410 0 0 {name=X_44647_ }
C {devices/lab_pin.sym} 126780 -38290 0 0 {name=p125556 lab=_75467_/A }
C {devices/lab_pin.sym} 126860 -38290 0 1 {name=p125557 lab=_75467_/Y }
C {sky130_stdcells/inv_2.sym} 126820 -38290 0 0 {name=X_75467_ }
C {devices/lab_pin.sym} 126740 -38210 0 0 {name=p125558 lab=_63434_/X }
C {devices/lab_pin.sym} 126740 -38170 0 0 {name=p125559 lab=_63472_/X }
C {devices/lab_pin.sym} 126740 -38130 0 0 {name=p125560 lab=_63473_/X }
C {devices/lab_pin.sym} 126740 -38090 0 0 {name=p125561 lab=_63477_/X }
C {devices/lab_pin.sym} 126740 -38050 0 0 {name=p125562 lab=_63480_/Y }
C {devices/lab_pin.sym} 126900 -38130 0 1 {name=p125563 lab=_63481_/Y }
C {sky130_stdcells/o41ai_4.sym} 126820 -38130 0 0 {name=X_63481_ }
C {devices/lab_pin.sym} 126740 -38000 0 0 {name=p125564 lab=_40542_/X }
C {devices/lab_pin.sym} 126740 -37960 0 0 {name=p125565 lab=_48226_/A }
C {devices/lab_pin.sym} 126740 -37920 0 0 {name=p125566 lab=_67290_/B }
C {devices/lab_pin.sym} 126740 -37880 0 0 {name=p125567 lab=_40599_/A }
C {devices/lab_pin.sym} 126900 -37940 0 1 {name=p125568 lab=_88117_/D }
C {sky130_stdcells/a2bb2o_4.sym} 126820 -37940 0 0 {name=X_41859_ }
C {devices/lab_pin.sym} 126760 -37810 0 0 {name=p125569 lab=_72683_/A }
C {devices/lab_pin.sym} 126760 -37770 0 0 {name=p125570 lab=_72683_/B }
C {devices/lab_pin.sym} 126760 -37730 0 0 {name=p125571 lab=_55392_/A }
C {devices/lab_pin.sym} 126880 -37770 0 1 {name=p125572 lab=_72679_/Y }
C {sky130_stdcells/nand3_4.sym} 126820 -37770 0 0 {name=X_72679_ }
C {devices/lab_pin.sym} 126780 -37630 0 0 {name=p125573 lab=_63478_/A }
C {devices/lab_pin.sym} 126860 -37630 0 1 {name=p125574 lab=_63389_/B }
C {sky130_stdcells/buf_2.sym} 126820 -37630 0 0 {name=X_60693_ }
C {devices/lab_pin.sym} 126780 -37510 0 0 {name=p125575 lab=_84210_/Q }
C {devices/lab_pin.sym} 126860 -37510 0 1 {name=p125576 lab=_65221_/C }
C {sky130_stdcells/inv_2.sym} 126820 -37510 0 0 {name=X_65220_ }
C {devices/lab_pin.sym} 126740 -37410 0 0 {name=p125577 lab=_77201_/Y }
C {devices/lab_pin.sym} 126740 -37370 0 0 {name=p125578 lab=_77177_/B }
C {devices/lab_pin.sym} 126740 -37330 0 0 {name=p125579 lab=_77205_/X }
C {devices/lab_pin.sym} 126900 -37370 0 1 {name=p125580 lab=_77207_/B }
C {sky130_stdcells/o21ai_4.sym} 126820 -37370 0 0 {name=X_77206_ }
C {devices/lab_pin.sym} 126760 -37240 0 0 {name=p125581 lab=_74413_/X }
C {devices/lab_pin.sym} 126760 -37200 0 0 {name=p125582 lab=_73073_/A }
C {devices/lab_pin.sym} 126880 -37220 0 1 {name=p125583 lab=_74418_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -37220 0 0 {name=X_74418_ }
C {devices/lab_pin.sym} 126760 -37110 0 0 {name=p125584 lab=_62448_/A }
C {devices/lab_pin.sym} 126760 -37070 0 0 {name=p125585 lab=_58533_/A }
C {devices/lab_pin.sym} 126760 -37030 0 0 {name=p125586 lab=_62375_/C }
C {devices/lab_pin.sym} 126880 -37070 0 1 {name=p125587 lab=_62432_/Y }
C {sky130_stdcells/nand3_4.sym} 126820 -37070 0 0 {name=X_62432_ }
C {devices/lab_pin.sym} 126780 -36930 0 0 {name=p125588 lab=_49504_/A }
C {devices/lab_pin.sym} 126860 -36930 0 1 {name=p125589 lab=_47556_/A }
C {sky130_stdcells/buf_2.sym} 126820 -36930 0 0 {name=X_47366_ }
C {devices/lab_pin.sym} 126760 -36820 0 0 {name=p125590 lab=_78193_/B }
C {devices/lab_pin.sym} 126760 -36780 0 0 {name=p125591 lab=_78174_/B }
C {devices/lab_pin.sym} 126880 -36800 0 1 {name=p125592 lab=_78186_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -36800 0 0 {name=X_78186_ }
C {devices/lab_pin.sym} 126740 -36710 0 0 {name=p125593 lab=_44554_/X }
C {devices/lab_pin.sym} 126740 -36670 0 0 {name=p125594 lab=_44555_/X }
C {devices/lab_pin.sym} 126740 -36630 0 0 {name=p125595 lab=_40889_/Y }
C {devices/lab_pin.sym} 126740 -36590 0 0 {name=p125596 lab=_44577_/Y }
C {devices/lab_pin.sym} 126740 -36550 0 0 {name=p125597 lab=_44557_/X }
C {devices/lab_pin.sym} 126900 -36630 0 1 {name=p125598 lab=_87048_/D }
C {sky130_stdcells/o32ai_4.sym} 126820 -36630 0 0 {name=X_44578_ }
C {devices/lab_pin.sym} 126740 -36490 0 0 {name=p125599 lab=_75378_/Y }
C {devices/lab_pin.sym} 126740 -36450 0 0 {name=p125600 lab=_75375_/Y }
C {devices/lab_pin.sym} 126740 -36410 0 0 {name=p125601 lab=_75376_/Y }
C {devices/lab_pin.sym} 126900 -36450 0 1 {name=p125602 lab=_75399_/A }
C {sky130_stdcells/o21a_4.sym} 126820 -36450 0 0 {name=X_75398_ }
C {devices/lab_pin.sym} 126780 -36310 0 0 {name=p125603 lab=_48898_/A }
C {devices/lab_pin.sym} 126860 -36310 0 1 {name=p125604 lab=_49117_/A }
C {sky130_stdcells/buf_2.sym} 126820 -36310 0 0 {name=X_49105_ }
C {devices/lab_pin.sym} 126780 -36190 0 0 {name=p125605 lab=_46317_/A }
C {devices/lab_pin.sym} 126860 -36190 0 1 {name=p125606 lab=_46505_/A }
C {sky130_stdcells/buf_2.sym} 126820 -36190 0 0 {name=X_46317_ }
C {devices/lab_pin.sym} 126780 -36070 0 0 {name=p125607 lab=_65673_/A }
C {devices/lab_pin.sym} 126860 -36070 0 1 {name=p125608 lab=_65206_/A }
C {sky130_stdcells/buf_2.sym} 126820 -36070 0 0 {name=X_65151_ }
C {devices/lab_pin.sym} 126740 -35970 0 0 {name=p125609 lab=_77143_/B }
C {devices/lab_pin.sym} 126740 -35930 0 0 {name=p125610 lab=_81916_/Q }
C {devices/lab_pin.sym} 126740 -35890 0 0 {name=p125611 lab=_77136_/Y }
C {devices/lab_pin.sym} 126900 -35930 0 1 {name=p125612 lab=_77138_/B }
C {sky130_stdcells/a21oi_4.sym} 126820 -35930 0 0 {name=X_77137_ }
C {devices/lab_pin.sym} 126740 -35830 0 0 {name=p125613 lab=_43518_/X }
C {devices/lab_pin.sym} 126740 -35790 0 0 {name=p125614 lab=_43523_/X }
C {devices/lab_pin.sym} 126740 -35750 0 0 {name=p125615 lab=_40395_/X }
C {devices/lab_pin.sym} 126740 -35710 0 0 {name=p125616 lab=_87374_/Q }
C {devices/lab_pin.sym} 126740 -35670 0 0 {name=p125617 lab=_43528_/X }
C {devices/lab_pin.sym} 126900 -35750 0 1 {name=p125618 lab=_43529_/Y }
C {sky130_stdcells/o32ai_4.sym} 126820 -35750 0 0 {name=X_43529_ }
C {devices/lab_pin.sym} 126780 -35590 0 0 {name=p125619 lab=_59950_/C }
C {devices/lab_pin.sym} 126860 -35590 0 1 {name=p125620 lab=_62363_/X }
C {sky130_stdcells/buf_2.sym} 126820 -35590 0 0 {name=X_62363_ }
C {devices/lab_pin.sym} 126760 -35490 0 0 {name=p125621 lab=_74351_/A }
C {devices/lab_pin.sym} 126760 -35450 0 0 {name=p125622 lab=_74342_/X }
C {devices/lab_pin.sym} 126760 -35410 0 0 {name=p125623 lab=_56117_/B }
C {devices/lab_pin.sym} 126880 -35450 0 1 {name=p125624 lab=_74349_/Y }
C {sky130_stdcells/nand3_4.sym} 126820 -35450 0 0 {name=X_74349_ }
C {devices/lab_pin.sym} 126780 -35310 0 0 {name=p125625 lab=_47297_/A }
C {devices/lab_pin.sym} 126860 -35310 0 1 {name=p125626 lab=_47297_/Y }
C {sky130_stdcells/inv_2.sym} 126820 -35310 0 0 {name=X_47297_ }
C {devices/lab_pin.sym} 126760 -35200 0 0 {name=p125627 lab=_58277_/A }
C {devices/lab_pin.sym} 126760 -35160 0 0 {name=p125628 lab=_64102_/B }
C {devices/lab_pin.sym} 126880 -35180 0 1 {name=p125629 lab=_64102_/Y }
C {sky130_stdcells/nor2_4.sym} 126820 -35180 0 0 {name=X_64102_ }
C {devices/lab_pin.sym} 126780 -35050 0 0 {name=p125630 lab=_72550_/C }
C {devices/lab_pin.sym} 126860 -35050 0 1 {name=p125631 lab=_72607_/B }
C {sky130_stdcells/buf_2.sym} 126820 -35050 0 0 {name=X_61314_ }
C {devices/lab_pin.sym} 126760 -34940 0 0 {name=p125632 lab=_49007_/A }
C {devices/lab_pin.sym} 126760 -34900 0 0 {name=p125633 lab=_52338_/B }
C {devices/lab_pin.sym} 126880 -34920 0 1 {name=p125634 lab=_49036_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -34920 0 0 {name=X_49036_ }
C {devices/lab_pin.sym} 126780 -34790 0 0 {name=p125635 lab=_47002_/A }
C {devices/lab_pin.sym} 126860 -34790 0 1 {name=p125636 lab=_46249_/A }
C {sky130_stdcells/buf_2.sym} 126820 -34790 0 0 {name=X_46248_ }
C {devices/lab_pin.sym} 126760 -34680 0 0 {name=p125637 lab=_64904_/A }
C {devices/lab_pin.sym} 126760 -34640 0 0 {name=p125638 lab=_85839_/Q }
C {devices/lab_pin.sym} 126880 -34660 0 1 {name=p125639 lab=_65082_/X }
C {sky130_stdcells/and2_4.sym} 126820 -34660 0 0 {name=X_65082_ }
C {devices/lab_pin.sym} 126760 -34540 0 0 {name=p125640 lab=_77068_/A }
C {devices/lab_pin.sym} 126760 -34500 0 0 {name=p125641 lab=_77068_/B }
C {devices/lab_pin.sym} 126880 -34520 0 1 {name=p125642 lab=_77068_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -34520 0 0 {name=X_77068_ }
C {devices/lab_pin.sym} 126780 -34390 0 0 {name=p125643 lab=_62609_/D }
C {devices/lab_pin.sym} 126860 -34390 0 1 {name=p125644 lab=_62632_/C }
C {sky130_stdcells/buf_2.sym} 126820 -34390 0 0 {name=X_62294_ }
C {devices/lab_pin.sym} 126760 -34300 0 0 {name=p125645 lab=_63585_/B }
C {devices/lab_pin.sym} 126760 -34260 0 0 {name=p125646 lab=_64095_/B }
C {devices/lab_pin.sym} 126760 -34220 0 0 {name=p125647 lab=_64050_/C }
C {devices/lab_pin.sym} 126760 -34180 0 0 {name=p125648 lab=_64033_/D }
C {devices/lab_pin.sym} 126880 -34240 0 1 {name=p125649 lab=_64033_/Y }
C {sky130_stdcells/nand4_4.sym} 126820 -34240 0 0 {name=X_64033_ }
C {devices/lab_pin.sym} 126760 -34100 0 0 {name=p125650 lab=_69001_/A }
C {devices/lab_pin.sym} 126760 -34060 0 0 {name=p125651 lab=_68910_/B }
C {devices/lab_pin.sym} 126880 -34080 0 1 {name=p125652 lab=_68910_/Y }
C {sky130_stdcells/nor2_4.sym} 126820 -34080 0 0 {name=X_68910_ }
C {devices/lab_pin.sym} 126760 -33960 0 0 {name=p125653 lab=_76009_/Y }
C {devices/lab_pin.sym} 126760 -33920 0 0 {name=p125654 lab=_76019_/B }
C {devices/lab_pin.sym} 126880 -33940 0 1 {name=p125655 lab=_76023_/A }
C {sky130_stdcells/nand2_4.sym} 126820 -33940 0 0 {name=X_76019_ }
C {devices/lab_pin.sym} 126760 -33830 0 0 {name=p125656 lab=_61262_/A }
C {devices/lab_pin.sym} 126760 -33790 0 0 {name=p125657 lab=_61250_/B }
C {devices/lab_pin.sym} 126760 -33750 0 0 {name=p125658 lab=_75901_/A }
C {devices/lab_pin.sym} 126880 -33790 0 1 {name=p125659 lab=_61245_/Y }
C {sky130_stdcells/nor3_4.sym} 126820 -33790 0 0 {name=X_61245_ }
C {devices/lab_pin.sym} 126780 -33650 0 0 {name=p125660 lab=_46178_/X }
C {devices/lab_pin.sym} 126860 -33650 0 1 {name=p125661 lab=_46179_/X }
C {sky130_stdcells/buf_2.sym} 126820 -33650 0 0 {name=X_46179_ }
C {devices/lab_pin.sym} 126760 -33540 0 0 {name=p125662 lab=_69887_/X }
C {devices/lab_pin.sym} 126760 -33500 0 0 {name=p125663 lab=_69889_/X }
C {devices/lab_pin.sym} 126880 -33520 0 1 {name=p125664 lab=_69890_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -33520 0 0 {name=X_69890_ }
C {devices/lab_pin.sym} 126760 -33400 0 0 {name=p125665 lab=_57804_/A }
C {devices/lab_pin.sym} 126760 -33360 0 0 {name=p125666 lab=_42509_/Y }
C {devices/lab_pin.sym} 126880 -33380 0 1 {name=p125667 lab=_68841_/Y }
C {sky130_stdcells/nor2_4.sym} 126820 -33380 0 0 {name=X_68841_ }
C {devices/lab_pin.sym} 126760 -33260 0 0 {name=p125668 lab=_61202_/B }
C {devices/lab_pin.sym} 126760 -33220 0 0 {name=p125669 lab=_61176_/B }
C {devices/lab_pin.sym} 126880 -33240 0 1 {name=p125670 lab=_61176_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -33240 0 0 {name=X_61176_ }
C {devices/lab_pin.sym} 126760 -33120 0 0 {name=p125671 lab=_59943_/A }
C {devices/lab_pin.sym} 126760 -33080 0 0 {name=p125672 lab=_59973_/A }
C {devices/lab_pin.sym} 126880 -33100 0 1 {name=p125673 lab=_62269_/A }
C {sky130_stdcells/and2_4.sym} 126820 -33100 0 0 {name=X_60127_ }
C {devices/lab_pin.sym} 126760 -33000 0 0 {name=p125674 lab=_49925_/X }
C {devices/lab_pin.sym} 126760 -32960 0 0 {name=p125675 lab=_49915_/X }
C {devices/lab_pin.sym} 126760 -32920 0 0 {name=p125676 lab=_49953_/C }
C {devices/lab_pin.sym} 126760 -32880 0 0 {name=p125677 lab=_53151_/D }
C {devices/lab_pin.sym} 126880 -32940 0 1 {name=p125678 lab=_49938_/X }
C {sky130_stdcells/and4_4.sym} 126820 -32940 0 0 {name=X_49938_ }
C {devices/lab_pin.sym} 126740 -32820 0 0 {name=p125679 lab=_87491_/Q }
C {devices/lab_pin.sym} 126740 -32780 0 0 {name=p125680 lab=_68472_/A }
C {devices/lab_pin.sym} 126740 -32740 0 0 {name=p125681 lab=_68545_/X }
C {devices/lab_pin.sym} 126740 -32700 0 0 {name=p125682 lab=_68771_/X }
C {devices/lab_pin.sym} 126900 -32760 0 1 {name=p125683 lab=_68772_/X }
C {sky130_stdcells/a211o_4.sym} 126820 -32760 0 0 {name=X_68772_ }
C {devices/lab_pin.sym} 126780 -32610 0 0 {name=p125684 lab=_65984_/A }
C {devices/lab_pin.sym} 126860 -32610 0 1 {name=p125685 lab=_66062_/B }
C {sky130_stdcells/buf_2.sym} 126820 -32610 0 0 {name=X_65984_ }
C {devices/lab_pin.sym} 126780 -32490 0 0 {name=p125686 lab=_68644_/A }
C {devices/lab_pin.sym} 126860 -32490 0 1 {name=p125687 lab=_67790_/A }
C {sky130_stdcells/buf_2.sym} 126820 -32490 0 0 {name=X_67723_ }
C {devices/lab_pin.sym} 126760 -32380 0 0 {name=p125688 lab=_79703_/Y }
C {devices/lab_pin.sym} 126760 -32340 0 0 {name=p125689 lab=_79708_/Y }
C {devices/lab_pin.sym} 126880 -32360 0 1 {name=p125690 lab=_79709_/X }
C {sky130_stdcells/xor2_4.sym} 126820 -32360 0 0 {name=X_79709_ }
C {devices/lab_pin.sym} 126760 -32240 0 0 {name=p125691 lab=_64877_/X }
C {devices/lab_pin.sym} 126760 -32200 0 0 {name=p125692 lab=_86453_/Q }
C {devices/lab_pin.sym} 126880 -32220 0 1 {name=p125693 lab=_64935_/X }
C {sky130_stdcells/and2_4.sym} 126820 -32220 0 0 {name=X_64935_ }
C {devices/lab_pin.sym} 126760 -32100 0 0 {name=p125694 lab=_60528_/A }
C {devices/lab_pin.sym} 126760 -32060 0 0 {name=p125695 lab=_60058_/B }
C {devices/lab_pin.sym} 126880 -32080 0 1 {name=p125696 lab=_60058_/Y }
C {sky130_stdcells/nor2_4.sym} 126820 -32080 0 0 {name=X_60058_ }
C {devices/lab_pin.sym} 126740 -31970 0 0 {name=p125697 lab=_58116_/B }
C {devices/lab_pin.sym} 126740 -31930 0 0 {name=p125698 lab=_49853_/X }
C {devices/lab_pin.sym} 126740 -31890 0 0 {name=p125699 lab=_49868_/Y }
C {devices/lab_pin.sym} 126900 -31930 0 1 {name=p125700 lab=_49869_/Y }
C {sky130_stdcells/o21ai_4.sym} 126820 -31930 0 0 {name=X_49869_ }
C {devices/lab_pin.sym} 126730 -31790 0 0 {name=p125701 lab=_80931_/CLK }
C {devices/lab_pin.sym} 126730 -31770 0 0 {name=p125702 lab=_75748_/X }
C {devices/lab_pin.sym} 126910 -31790 0 1 {name=p125703 lab=_80937_/D }
C {sky130_stdcells/dfxtp_4.sym} 126820 -31780 0 0 {name=X_80981_ }
C {devices/lab_pin.sym} 126780 -31650 0 0 {name=p125704 lab=_51900_/A }
C {devices/lab_pin.sym} 126860 -31650 0 1 {name=p125705 lab=_51900_/X }
C {sky130_stdcells/buf_2.sym} 126820 -31650 0 0 {name=X_51900_ }
C {devices/lab_pin.sym} 126730 -31530 0 0 {name=p125706 lab=_82624_/CLK }
C {devices/lab_pin.sym} 126730 -31510 0 0 {name=p125707 lab=_82720_/D }
C {devices/lab_pin.sym} 126910 -31530 0 1 {name=p125708 lab=_82720_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -31520 0 0 {name=X_82720_ }
C {devices/lab_pin.sym} 126760 -31400 0 0 {name=p125709 lab=_67582_/A }
C {devices/lab_pin.sym} 126760 -31360 0 0 {name=p125710 lab=_67654_/B }
C {devices/lab_pin.sym} 126880 -31380 0 1 {name=p125711 lab=_67654_/X }
C {sky130_stdcells/and2_4.sym} 126820 -31380 0 0 {name=X_67654_ }
C {devices/lab_pin.sym} 126740 -31270 0 0 {name=p125712 lab=_52877_/Y }
C {devices/lab_pin.sym} 126740 -31230 0 0 {name=p125713 lab=_52865_/X }
C {devices/lab_pin.sym} 126740 -31190 0 0 {name=p125714 lab=_52879_/X }
C {devices/lab_pin.sym} 126900 -31230 0 1 {name=p125715 lab=_52880_/Y }
C {sky130_stdcells/a21oi_4.sym} 126820 -31230 0 0 {name=X_52880_ }
C {devices/lab_pin.sym} 126740 -31120 0 0 {name=p125716 lab=_64809_/X }
C {devices/lab_pin.sym} 126740 -31080 0 0 {name=p125717 lab=_86744_/Q }
C {devices/lab_pin.sym} 126740 -31040 0 0 {name=p125718 lab=_64864_/X }
C {devices/lab_pin.sym} 126740 -31000 0 0 {name=p125719 lab=_64865_/X }
C {devices/lab_pin.sym} 126900 -31060 0 1 {name=p125720 lab=_64866_/X }
C {sky130_stdcells/a211o_4.sym} 126820 -31060 0 0 {name=X_64866_ }
C {devices/lab_pin.sym} 126780 -30910 0 0 {name=p125721 lab=_68389_/A }
C {devices/lab_pin.sym} 126860 -30910 0 1 {name=p125722 lab=_66606_/A }
C {sky130_stdcells/buf_2.sym} 126820 -30910 0 0 {name=X_66605_ }
C {devices/lab_pin.sym} 126740 -30810 0 0 {name=p125723 lab=_85938_/Q }
C {devices/lab_pin.sym} 126740 -30770 0 0 {name=p125724 lab=_51817_/X }
C {devices/lab_pin.sym} 126740 -30730 0 0 {name=p125725 lab=_51830_/Y }
C {devices/lab_pin.sym} 126900 -30770 0 1 {name=p125726 lab=_51831_/Y }
C {sky130_stdcells/o21ai_4.sym} 126820 -30770 0 0 {name=X_51831_ }
C {devices/lab_pin.sym} 126760 -30650 0 0 {name=p125727 lab=_63800_/A }
C {devices/lab_pin.sym} 126760 -30610 0 0 {name=p125728 lab=_63800_/B }
C {devices/lab_pin.sym} 126760 -30570 0 0 {name=p125729 lab=_80206_/B }
C {devices/lab_pin.sym} 126880 -30610 0 1 {name=p125730 lab=_63817_/Y }
C {sky130_stdcells/nor3_4.sym} 126820 -30610 0 0 {name=X_63817_ }
C {devices/lab_pin.sym} 126730 -30470 0 0 {name=p125731 lab=_84003_/CLK }
C {devices/lab_pin.sym} 126730 -30450 0 0 {name=p125732 lab=_84003_/Q }
C {devices/lab_pin.sym} 126910 -30470 0 1 {name=p125733 lab=_82651_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -30460 0 0 {name=X_82651_ }
C {devices/lab_pin.sym} 126780 -30330 0 0 {name=p125734 lab=_67466_/X }
C {devices/lab_pin.sym} 126860 -30330 0 1 {name=p125735 lab=_67585_/X }
C {sky130_stdcells/buf_2.sym} 126820 -30330 0 0 {name=X_67585_ }
C {devices/lab_pin.sym} 126780 -30210 0 0 {name=p125736 lab=_64797_/A }
C {devices/lab_pin.sym} 126860 -30210 0 1 {name=p125737 lab=_64797_/X }
C {sky130_stdcells/buf_2.sym} 126820 -30210 0 0 {name=X_64797_ }
C {devices/lab_pin.sym} 126730 -30090 0 0 {name=p125738 lab=_81794_/CLK }
C {devices/lab_pin.sym} 126730 -30070 0 0 {name=p125739 lab=_81602_/D }
C {devices/lab_pin.sym} 126910 -30090 0 1 {name=p125740 lab=_81602_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -30080 0 0 {name=X_81602_ }
C {devices/lab_pin.sym} 126760 -29960 0 0 {name=p125741 lab=_69320_/X }
C {devices/lab_pin.sym} 126760 -29920 0 0 {name=p125742 lab=_69323_/X }
C {devices/lab_pin.sym} 126880 -29940 0 1 {name=p125743 lab=_69324_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -29940 0 0 {name=X_69324_ }
C {devices/lab_pin.sym} 126740 -29830 0 0 {name=p125744 lab=_54547_/Y }
C {devices/lab_pin.sym} 126740 -29790 0 0 {name=p125745 lab=_54530_/X }
C {devices/lab_pin.sym} 126740 -29750 0 0 {name=p125746 lab=_54549_/X }
C {devices/lab_pin.sym} 126900 -29790 0 1 {name=p125747 lab=_85422_/D }
C {sky130_stdcells/a21oi_4.sym} 126820 -29790 0 0 {name=X_54550_ }
C {devices/lab_pin.sym} 126740 -29680 0 0 {name=p125748 lab=_87955_/Q }
C {devices/lab_pin.sym} 126740 -29640 0 0 {name=p125749 lab=_66529_/X }
C {devices/lab_pin.sym} 126740 -29600 0 0 {name=p125750 lab=_66531_/X }
C {devices/lab_pin.sym} 126740 -29560 0 0 {name=p125751 lab=_66535_/X }
C {devices/lab_pin.sym} 126900 -29620 0 1 {name=p125752 lab=_66536_/X }
C {sky130_stdcells/a211o_4.sym} 126820 -29620 0 0 {name=X_66536_ }
C {devices/lab_pin.sym} 126730 -29470 0 0 {name=p125753 lab=_83275_/CLK }
C {devices/lab_pin.sym} 126730 -29450 0 0 {name=p125754 lab=_85370_/D }
C {devices/lab_pin.sym} 126910 -29470 0 1 {name=p125755 lab=_85370_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -29460 0 0 {name=X_85370_ }
C {devices/lab_pin.sym} 126740 -29350 0 0 {name=p125756 lab=_51759_/Y }
C {devices/lab_pin.sym} 126740 -29310 0 0 {name=p125757 lab=_51391_/X }
C {devices/lab_pin.sym} 126740 -29270 0 0 {name=p125758 lab=_51761_/X }
C {devices/lab_pin.sym} 126900 -29310 0 1 {name=p125759 lab=_51762_/Y }
C {sky130_stdcells/a21oi_4.sym} 126820 -29310 0 0 {name=X_51762_ }
C {devices/lab_pin.sym} 126780 -29170 0 0 {name=p125760 lab=_60930_/A }
C {devices/lab_pin.sym} 126860 -29170 0 1 {name=p125761 lab=_63749_/A }
C {sky130_stdcells/buf_2.sym} 126820 -29170 0 0 {name=X_63748_ }
C {devices/lab_pin.sym} 126730 -29050 0 0 {name=p125762 lab=_82711_/CLK }
C {devices/lab_pin.sym} 126730 -29030 0 0 {name=p125763 lab=_82614_/Q }
C {devices/lab_pin.sym} 126910 -29050 0 1 {name=p125764 lab=_78228_/A }
C {sky130_stdcells/dfxtp_4.sym} 126820 -29040 0 0 {name=X_82582_ }
C {devices/lab_pin.sym} 126760 -28920 0 0 {name=p125765 lab=_53478_/A }
C {devices/lab_pin.sym} 126760 -28880 0 0 {name=p125766 lab=_53501_/B }
C {devices/lab_pin.sym} 126880 -28900 0 1 {name=p125767 lab=_53501_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -28900 0 0 {name=X_53501_ }
C {devices/lab_pin.sym} 126730 -28770 0 0 {name=p125768 lab=_84321_/CLK }
C {devices/lab_pin.sym} 126730 -28750 0 0 {name=p125769 lab=_63470_/Y }
C {devices/lab_pin.sym} 126910 -28770 0 1 {name=p125770 lab=_84321_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -28760 0 0 {name=X_84321_ }
C {devices/lab_pin.sym} 126740 -28650 0 0 {name=p125771 lab=_86148_/Q }
C {devices/lab_pin.sym} 126740 -28610 0 0 {name=p125772 lab=_50706_/X }
C {devices/lab_pin.sym} 126740 -28570 0 0 {name=p125773 lab=_50712_/Y }
C {devices/lab_pin.sym} 126900 -28610 0 1 {name=p125774 lab=_50713_/Y }
C {sky130_stdcells/o21ai_4.sym} 126820 -28610 0 0 {name=X_50713_ }
C {devices/lab_pin.sym} 126730 -28470 0 0 {name=p125775 lab=_81703_/CLK }
C {devices/lab_pin.sym} 126730 -28450 0 0 {name=p125776 lab=_81545_/Q }
C {devices/lab_pin.sym} 126910 -28470 0 1 {name=p125777 lab=_81533_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -28460 0 0 {name=X_81533_ }
C {devices/lab_pin.sym} 126760 -28340 0 0 {name=p125778 lab=_69255_/A }
C {devices/lab_pin.sym} 126760 -28300 0 0 {name=p125779 lab=_69254_/X }
C {devices/lab_pin.sym} 126880 -28320 0 1 {name=p125780 lab=_69255_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -28320 0 0 {name=X_69255_ }
C {devices/lab_pin.sym} 126780 -28190 0 0 {name=p125781 lab=_54481_/A }
C {devices/lab_pin.sym} 126860 -28190 0 1 {name=p125782 lab=_54483_/A }
C {sky130_stdcells/buf_2.sym} 126820 -28190 0 0 {name=X_54481_ }
C {devices/lab_pin.sym} 126740 -28090 0 0 {name=p125783 lab=_60110_/X }
C {devices/lab_pin.sym} 126740 -28050 0 0 {name=p125784 lab=_65126_/Y }
C {devices/lab_pin.sym} 126740 -28010 0 0 {name=p125785 lab=_66466_/Y }
C {devices/lab_pin.sym} 126900 -28050 0 1 {name=p125786 lab=_66467_/Y }
C {sky130_stdcells/o21ai_4.sym} 126820 -28050 0 0 {name=X_66467_ }
C {devices/lab_pin.sym} 126780 -27910 0 0 {name=p125787 lab=_51639_/A }
C {devices/lab_pin.sym} 126860 -27910 0 1 {name=p125788 lab=_51693_/X }
C {sky130_stdcells/buf_2.sym} 126820 -27910 0 0 {name=X_51693_ }
C {devices/lab_pin.sym} 126780 -27790 0 0 {name=p125789 lab=_63578_/A }
C {devices/lab_pin.sym} 126860 -27790 0 1 {name=p125790 lab=_63679_/X }
C {sky130_stdcells/buf_2.sym} 126820 -27790 0 0 {name=X_63679_ }
C {devices/lab_pin.sym} 126740 -27690 0 0 {name=p125791 lab=_56060_/X }
C {devices/lab_pin.sym} 126740 -27650 0 0 {name=p125792 lab=_56210_/X }
C {devices/lab_pin.sym} 126740 -27610 0 0 {name=p125793 lab=_56219_/Y }
C {devices/lab_pin.sym} 126900 -27650 0 1 {name=p125794 lab=_85271_/D }
C {sky130_stdcells/o21ai_4.sym} 126820 -27650 0 0 {name=X_56220_ }
C {devices/lab_pin.sym} 126740 -27530 0 0 {name=p125795 lab=_82052_/D }
C {devices/lab_pin.sym} 126740 -27490 0 0 {name=p125796 lab=_68200_/X }
C {devices/lab_pin.sym} 126740 -27450 0 0 {name=p125797 lab=_68205_/X }
C {devices/lab_pin.sym} 126900 -27490 0 1 {name=p125798 lab=_68206_/X }
C {sky130_stdcells/a21bo_4.sym} 126820 -27490 0 0 {name=X_68206_ }
C {devices/lab_pin.sym} 126730 -27350 0 0 {name=p125799 lab=_87068_/CLK }
C {devices/lab_pin.sym} 126730 -27330 0 0 {name=p125800 lab=_44601_/Y }
C {devices/lab_pin.sym} 126910 -27350 0 1 {name=p125801 lab=_87040_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -27340 0 0 {name=X_87040_ }
C {devices/lab_pin.sym} 126780 -27210 0 0 {name=p125802 lab=_47832_/X }
C {devices/lab_pin.sym} 126860 -27210 0 1 {name=p125803 lab=_54194_/A }
C {sky130_stdcells/buf_2.sym} 126820 -27210 0 0 {name=X_53432_ }
C {devices/lab_pin.sym} 126740 -27120 0 0 {name=p125804 lab=_65342_/X }
C {devices/lab_pin.sym} 126740 -27080 0 0 {name=p125805 lab=_86722_/Q }
C {devices/lab_pin.sym} 126740 -27040 0 0 {name=p125806 lab=_65391_/X }
C {devices/lab_pin.sym} 126740 -27000 0 0 {name=p125807 lab=_65417_/X }
C {devices/lab_pin.sym} 126900 -27060 0 1 {name=p125808 lab=_65418_/X }
C {sky130_stdcells/a211o_4.sym} 126820 -27060 0 0 {name=X_65418_ }
C {devices/lab_pin.sym} 126730 -26910 0 0 {name=p125809 lab=_83766_/CLK }
C {devices/lab_pin.sym} 126730 -26890 0 0 {name=p125810 lab=_64372_/X }
C {devices/lab_pin.sym} 126910 -26910 0 1 {name=p125811 lab=_79742_/B }
C {sky130_stdcells/dfxtp_4.sym} 126820 -26900 0 0 {name=X_84252_ }
C {devices/lab_pin.sym} 126780 -26770 0 0 {name=p125812 lab=_50577_/A }
C {devices/lab_pin.sym} 126860 -26770 0 1 {name=p125813 lab=_50644_/X }
C {sky130_stdcells/buf_2.sym} 126820 -26770 0 0 {name=X_50644_ }
C {devices/lab_pin.sym} 126730 -26650 0 0 {name=p125814 lab=_81431_/CLK }
C {devices/lab_pin.sym} 126730 -26630 0 0 {name=p125815 lab=_81464_/D }
C {devices/lab_pin.sym} 126910 -26650 0 1 {name=p125816 lab=_81464_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -26640 0 0 {name=X_81464_ }
C {devices/lab_pin.sym} 126760 -26520 0 0 {name=p125817 lab=_69181_/X }
C {devices/lab_pin.sym} 126760 -26480 0 0 {name=p125818 lab=_69186_/B }
C {devices/lab_pin.sym} 126880 -26500 0 1 {name=p125819 lab=_69186_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -26500 0 0 {name=X_69186_ }
C {devices/lab_pin.sym} 126760 -26390 0 0 {name=p125820 lab=_66010_/X }
C {devices/lab_pin.sym} 126760 -26350 0 0 {name=p125821 lab=_66397_/X }
C {devices/lab_pin.sym} 126760 -26310 0 0 {name=p125822 lab=_66013_/X }
C {devices/lab_pin.sym} 126880 -26350 0 1 {name=p125823 lab=_66398_/Y }
C {sky130_stdcells/nand3_4.sym} 126820 -26350 0 0 {name=X_66398_ }
C {devices/lab_pin.sym} 126730 -26210 0 0 {name=p125824 lab=_83843_/CLK }
C {devices/lab_pin.sym} 126730 -26190 0 0 {name=p125825 lab=_83203_/D }
C {devices/lab_pin.sym} 126910 -26210 0 1 {name=p125826 lab=_83203_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -26200 0 0 {name=X_83203_ }
C {devices/lab_pin.sym} 126740 -26090 0 0 {name=p125827 lab=_56142_/X }
C {devices/lab_pin.sym} 126740 -26050 0 0 {name=p125828 lab=_56148_/X }
C {devices/lab_pin.sym} 126740 -26010 0 0 {name=p125829 lab=_56150_/Y }
C {devices/lab_pin.sym} 126900 -26050 0 1 {name=p125830 lab=_56151_/Y }
C {sky130_stdcells/o21ai_4.sym} 126820 -26050 0 0 {name=X_56151_ }
C {devices/lab_pin.sym} 126760 -25920 0 0 {name=p125831 lab=_80411_/Y }
C {devices/lab_pin.sym} 126760 -25880 0 0 {name=p125832 lab=_80414_/Y }
C {devices/lab_pin.sym} 126880 -25900 0 1 {name=p125833 lab=_80425_/B }
C {sky130_stdcells/xor2_4.sym} 126820 -25900 0 0 {name=X_80415_ }
C {devices/lab_pin.sym} 126740 -25790 0 0 {name=p125834 lab=_66866_/X }
C {devices/lab_pin.sym} 126740 -25750 0 0 {name=p125835 lab=_66870_/X }
C {devices/lab_pin.sym} 126740 -25710 0 0 {name=p125836 lab=_68133_/X }
C {devices/lab_pin.sym} 126900 -25750 0 1 {name=p125837 lab=_68137_/Y }
C {sky130_stdcells/a21oi_4.sym} 126820 -25750 0 0 {name=X_68137_ }
C {devices/lab_pin.sym} 126740 -25630 0 0 {name=p125838 lab=_53361_/Y }
C {devices/lab_pin.sym} 126740 -25590 0 0 {name=p125839 lab=_53355_/X }
C {devices/lab_pin.sym} 126740 -25550 0 0 {name=p125840 lab=_53362_/X }
C {devices/lab_pin.sym} 126900 -25590 0 1 {name=p125841 lab=_85648_/D }
C {sky130_stdcells/a21oi_4.sym} 126820 -25590 0 0 {name=X_53363_ }
C {devices/lab_pin.sym} 126740 -25470 0 0 {name=p125842 lab=_65346_/Y }
C {devices/lab_pin.sym} 126740 -25430 0 0 {name=p125843 lab=_65347_/X }
C {devices/lab_pin.sym} 126740 -25390 0 0 {name=p125844 lab=_65348_/X }
C {devices/lab_pin.sym} 126900 -25430 0 1 {name=p125845 lab=_84205_/D }
C {sky130_stdcells/a21o_4.sym} 126820 -25430 0 0 {name=X_65349_ }
C {devices/lab_pin.sym} 126730 -25290 0 0 {name=p125846 lab=_84194_/CLK }
C {devices/lab_pin.sym} 126730 -25270 0 0 {name=p125847 lab=_84183_/D }
C {devices/lab_pin.sym} 126910 -25290 0 1 {name=p125848 lab=_65713_/C }
C {sky130_stdcells/dfxtp_4.sym} 126820 -25280 0 0 {name=X_84183_ }
C {devices/lab_pin.sym} 126760 -25160 0 0 {name=p125849 lab=_50575_/A }
C {devices/lab_pin.sym} 126760 -25120 0 0 {name=p125850 lab=_48912_/B }
C {devices/lab_pin.sym} 126880 -25140 0 1 {name=p125851 lab=_50575_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -25140 0 0 {name=X_50575_ }
C {devices/lab_pin.sym} 126730 -25010 0 0 {name=p125852 lab=_83932_/CLK }
C {devices/lab_pin.sym} 126730 -24990 0 0 {name=p125853 lab=_83931_/Q }
C {devices/lab_pin.sym} 126910 -25010 0 1 {name=p125854 lab=_81395_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -25000 0 0 {name=X_81395_ }
C {devices/lab_pin.sym} 126780 -24870 0 0 {name=p125855 lab=_55102_/A }
C {devices/lab_pin.sym} 126860 -24870 0 1 {name=p125856 lab=_55102_/X }
C {sky130_stdcells/buf_2.sym} 126820 -24870 0 0 {name=X_55102_ }
C {devices/lab_pin.sym} 126780 -24750 0 0 {name=p125857 lab=_52262_/A }
C {devices/lab_pin.sym} 126860 -24750 0 1 {name=p125858 lab=_52314_/X }
C {sky130_stdcells/buf_2.sym} 126820 -24750 0 0 {name=X_52314_ }
C {devices/lab_pin.sym} 126730 -24630 0 0 {name=p125859 lab=_84980_/CLK }
C {devices/lab_pin.sym} 126730 -24610 0 0 {name=p125860 lab=_73841_/Y }
C {devices/lab_pin.sym} 126910 -24630 0 1 {name=p125861 lab=_83134_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -24620 0 0 {name=X_83134_ }
C {devices/lab_pin.sym} 126760 -24510 0 0 {name=p125862 lab=_80343_/X }
C {devices/lab_pin.sym} 126760 -24470 0 0 {name=p125863 lab=_80344_/X }
C {devices/lab_pin.sym} 126760 -24430 0 0 {name=p125864 lab=_80360_/B }
C {devices/lab_pin.sym} 126880 -24470 0 1 {name=p125865 lab=_80350_/B }
C {sky130_stdcells/nand3_4.sym} 126820 -24470 0 0 {name=X_80346_ }
C {devices/lab_pin.sym} 126780 -24330 0 0 {name=p125866 lab=_56142_/A }
C {devices/lab_pin.sym} 126860 -24330 0 1 {name=p125867 lab=_56082_/X }
C {sky130_stdcells/buf_2.sym} 126820 -24330 0 0 {name=X_56082_ }
C {devices/lab_pin.sym} 126740 -24240 0 0 {name=p125868 lab=_87956_/Q }
C {devices/lab_pin.sym} 126740 -24200 0 0 {name=p125869 lab=_68066_/X }
C {devices/lab_pin.sym} 126740 -24160 0 0 {name=p125870 lab=_67997_/X }
C {devices/lab_pin.sym} 126740 -24120 0 0 {name=p125871 lab=_68067_/X }
C {devices/lab_pin.sym} 126900 -24180 0 1 {name=p125872 lab=_68068_/X }
C {sky130_stdcells/a211o_4.sym} 126820 -24180 0 0 {name=X_68068_ }
C {devices/lab_pin.sym} 126740 -24050 0 0 {name=p125873 lab=_53291_/Y }
C {devices/lab_pin.sym} 126740 -24010 0 0 {name=p125874 lab=_53272_/X }
C {devices/lab_pin.sym} 126740 -23970 0 0 {name=p125875 lab=_53293_/X }
C {devices/lab_pin.sym} 126900 -24010 0 1 {name=p125876 lab=_53294_/Y }
C {sky130_stdcells/a21oi_4.sym} 126820 -24010 0 0 {name=X_53294_ }
C {devices/lab_pin.sym} 126760 -23880 0 0 {name=p125877 lab=_55037_/A }
C {devices/lab_pin.sym} 126760 -23840 0 0 {name=p125878 lab=_54867_/B }
C {devices/lab_pin.sym} 126880 -23860 0 1 {name=p125879 lab=_55033_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -23860 0 0 {name=X_55033_ }
C {devices/lab_pin.sym} 126780 -23730 0 0 {name=p125880 lab=_59909_/Y }
C {devices/lab_pin.sym} 126860 -23730 0 1 {name=p125881 lab=_59910_/X }
C {sky130_stdcells/buf_2.sym} 126820 -23730 0 0 {name=X_59910_ }
C {devices/lab_pin.sym} 126760 -23620 0 0 {name=p125882 lab=_66972_/X }
C {devices/lab_pin.sym} 126760 -23580 0 0 {name=p125883 lab=_87616_/Q }
C {devices/lab_pin.sym} 126880 -23600 0 1 {name=p125884 lab=_67019_/X }
C {sky130_stdcells/and2_4.sym} 126820 -23600 0 0 {name=X_67019_ }
C {devices/lab_pin.sym} 126760 -23480 0 0 {name=p125885 lab=_52250_/A }
C {devices/lab_pin.sym} 126760 -23440 0 0 {name=p125886 lab=_48684_/B }
C {devices/lab_pin.sym} 126880 -23460 0 1 {name=p125887 lab=_52245_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -23460 0 0 {name=X_52245_ }
C {devices/lab_pin.sym} 126730 -23330 0 0 {name=p125888 lab=_85581_/CLK }
C {devices/lab_pin.sym} 126730 -23310 0 0 {name=p125889 lab=_74446_/Y }
C {devices/lab_pin.sym} 126910 -23330 0 1 {name=p125890 lab=_83065_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -23320 0 0 {name=X_83065_ }
C {devices/lab_pin.sym} 126730 -23190 0 0 {name=p125891 lab=_88387_/CLK }
C {devices/lab_pin.sym} 126730 -23170 0 0 {name=p125892 lab=_87942_/D }
C {devices/lab_pin.sym} 126910 -23190 0 1 {name=p125893 lab=_87942_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -23180 0 0 {name=X_87942_ }
C {devices/lab_pin.sym} 126760 -23060 0 0 {name=p125894 lab=_80276_/Y }
C {devices/lab_pin.sym} 126760 -23020 0 0 {name=p125895 lab=_80277_/B }
C {devices/lab_pin.sym} 126880 -23040 0 1 {name=p125896 lab=_80280_/B }
C {sky130_stdcells/nand2_4.sym} 126820 -23040 0 0 {name=X_80277_ }
C {devices/lab_pin.sym} 126740 -22930 0 0 {name=p125897 lab=_69739_/X }
C {devices/lab_pin.sym} 126740 -22890 0 0 {name=p125898 lab=_69741_/X }
C {devices/lab_pin.sym} 126740 -22850 0 0 {name=p125899 lab=_70001_/X }
C {devices/lab_pin.sym} 126900 -22890 0 1 {name=p125900 lab=_70030_/Y }
C {sky130_stdcells/a21oi_4.sym} 126820 -22890 0 0 {name=X_70030_ }
C {devices/lab_pin.sym} 126730 -22750 0 0 {name=p125901 lab=_82604_/CLK }
C {devices/lab_pin.sym} 126730 -22730 0 0 {name=p125902 lab=_82016_/D }
C {devices/lab_pin.sym} 126910 -22750 0 1 {name=p125903 lab=_77222_/A }
C {sky130_stdcells/dfxtp_4.sym} 126820 -22740 0 0 {name=X_82016_ }
C {devices/lab_pin.sym} 126780 -22610 0 0 {name=p125904 lab=_59825_/B }
C {devices/lab_pin.sym} 126860 -22610 0 1 {name=p125905 lab=_59841_/X }
C {sky130_stdcells/buf_2.sym} 126820 -22610 0 0 {name=X_59841_ }
C {devices/lab_pin.sym} 126740 -22510 0 0 {name=p125906 lab=_52174_/Y }
C {devices/lab_pin.sym} 126740 -22470 0 0 {name=p125907 lab=_52170_/X }
C {devices/lab_pin.sym} 126740 -22430 0 0 {name=p125908 lab=_52175_/X }
C {devices/lab_pin.sym} 126900 -22470 0 1 {name=p125909 lab=_85874_/D }
C {sky130_stdcells/a21oi_4.sym} 126820 -22470 0 0 {name=X_52176_ }
C {devices/lab_pin.sym} 126730 -22330 0 0 {name=p125910 lab=_88387_/CLK }
C {devices/lab_pin.sym} 126730 -22310 0 0 {name=p125911 lab=_42421_/Y }
C {devices/lab_pin.sym} 126910 -22330 0 1 {name=p125912 lab=_87873_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -22320 0 0 {name=X_87873_ }
C {devices/lab_pin.sym} 126780 -22190 0 0 {name=p125913 lab=_50991_/A }
C {devices/lab_pin.sym} 126860 -22190 0 1 {name=p125914 lab=_51128_/A }
C {sky130_stdcells/buf_2.sym} 126820 -22190 0 0 {name=X_51127_ }
C {devices/lab_pin.sym} 126730 -22070 0 0 {name=p125915 lab=_86824_/CLK }
C {devices/lab_pin.sym} 126730 -22050 0 0 {name=p125916 lab=_86824_/D }
C {devices/lab_pin.sym} 126910 -22070 0 1 {name=p125917 lab=_86824_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -22060 0 0 {name=X_86824_ }
C {devices/lab_pin.sym} 126760 -21950 0 0 {name=p125918 lab=_59772_/A }
C {devices/lab_pin.sym} 126760 -21910 0 0 {name=p125919 lab=_59771_/X }
C {devices/lab_pin.sym} 126760 -21870 0 0 {name=p125920 lab=_80517_/A }
C {devices/lab_pin.sym} 126880 -21910 0 1 {name=p125921 lab=_59772_/Y }
C {sky130_stdcells/nor3_4.sym} 126820 -21910 0 0 {name=X_59772_ }
C {devices/lab_pin.sym} 126780 -21770 0 0 {name=p125922 lab=_56682_/X }
C {devices/lab_pin.sym} 126860 -21770 0 1 {name=p125923 lab=_57149_/C }
C {sky130_stdcells/buf_2.sym} 126820 -21770 0 0 {name=X_56984_ }
C {devices/lab_pin.sym} 126780 -21650 0 0 {name=p125924 lab=clkbuf_9_30_0_CLK/X }
C {devices/lab_pin.sym} 126860 -21650 0 1 {name=p125925 lab=_85005_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 126820 -21650 0 0 {name=Xclkbuf_10_60_0_CLK }
C {devices/lab_pin.sym} 126740 -21570 0 0 {name=p125926 lab=_58631_/X }
C {devices/lab_pin.sym} 126740 -21530 0 0 {name=p125927 lab=_58720_/Y }
C {devices/lab_pin.sym} 126740 -21490 0 0 {name=p125928 lab=_58722_/Y }
C {devices/lab_pin.sym} 126740 -21450 0 0 {name=p125929 lab=_58650_/X }
C {devices/lab_pin.sym} 126740 -21410 0 0 {name=p125930 lab=_58636_/X }
C {devices/lab_pin.sym} 126900 -21490 0 1 {name=p125931 lab=_58723_/X }
C {sky130_stdcells/o32a_4.sym} 126820 -21490 0 0 {name=X_58723_ }
C {devices/lab_pin.sym} 126760 -21340 0 0 {name=p125932 lab=_51058_/A }
C {devices/lab_pin.sym} 126760 -21300 0 0 {name=p125933 lab=_52748_/B }
C {devices/lab_pin.sym} 126880 -21320 0 1 {name=p125934 lab=_51058_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -21320 0 0 {name=X_51058_ }
C {devices/lab_pin.sym} 126740 -21220 0 0 {name=p125935 lab=_83035_/Q }
C {devices/lab_pin.sym} 126740 -21180 0 0 {name=p125936 lab=_55619_/A }
C {devices/lab_pin.sym} 126740 -21140 0 0 {name=p125937 lab=_44102_/A }
C {devices/lab_pin.sym} 126740 -21100 0 0 {name=p125938 lab=_55934_/X }
C {devices/lab_pin.sym} 126900 -21160 0 1 {name=p125939 lab=_55936_/B }
C {sky130_stdcells/a211o_4.sym} 126820 -21160 0 0 {name=X_55935_ }
C {devices/lab_pin.sym} 126730 -21010 0 0 {name=p125940 lab=_84407_/CLK }
C {devices/lab_pin.sym} 126730 -20990 0 0 {name=p125941 lab=_46232_/Y }
C {devices/lab_pin.sym} 126910 -21010 0 1 {name=p125942 lab=_86755_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -21000 0 0 {name=X_86755_ }
C {devices/lab_pin.sym} 126760 -20880 0 0 {name=p125943 lab=_71957_/A }
C {devices/lab_pin.sym} 126760 -20840 0 0 {name=p125944 lab=_48931_/A }
C {devices/lab_pin.sym} 126880 -20860 0 1 {name=p125945 lab=_71981_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -20860 0 0 {name=X_71981_ }
C {devices/lab_pin.sym} 126730 -20730 0 0 {name=p125946 lab=_83967_/CLK }
C {devices/lab_pin.sym} 126730 -20710 0 0 {name=p125947 lab=_83967_/D }
C {devices/lab_pin.sym} 126910 -20730 0 1 {name=p125948 lab=_83967_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -20720 0 0 {name=X_83967_ }
C {devices/lab_pin.sym} 126780 -20590 0 0 {name=p125949 lab=_49930_/X }
C {devices/lab_pin.sym} 126860 -20590 0 1 {name=p125950 lab=_50025_/C }
C {sky130_stdcells/buf_2.sym} 126820 -20590 0 0 {name=X_50009_ }
C {devices/lab_pin.sym} 126780 -20470 0 0 {name=p125951 lab=_42962_/A }
C {devices/lab_pin.sym} 126860 -20470 0 1 {name=p125952 lab=_42900_/X }
C {sky130_stdcells/buf_2.sym} 126820 -20470 0 0 {name=X_42900_ }
C {devices/lab_pin.sym} 126780 -20350 0 0 {name=p125953 lab=_73367_/A }
C {devices/lab_pin.sym} 126860 -20350 0 1 {name=p125954 lab=_73720_/X }
C {sky130_stdcells/buf_2.sym} 126820 -20350 0 0 {name=X_73720_ }
C {devices/lab_pin.sym} 126730 -20230 0 0 {name=p125955 lab=_85704_/CLK }
C {devices/lab_pin.sym} 126730 -20210 0 0 {name=p125956 lab=_53053_/Y }
C {devices/lab_pin.sym} 126910 -20230 0 1 {name=p125957 lab=_85706_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -20220 0 0 {name=X_85706_ }
C {devices/lab_pin.sym} 126780 -20090 0 0 {name=p125958 lab=clkbuf_6_52_0_CLK/X }
C {devices/lab_pin.sym} 126860 -20090 0 1 {name=p125959 lab=clkbuf_8_211_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 126820 -20090 0 0 {name=Xclkbuf_7_105_0_CLK }
C {devices/lab_pin.sym} 126780 -19970 0 0 {name=p125960 lab=clkbuf_9_146_0_CLK/X }
C {devices/lab_pin.sym} 126860 -19970 0 1 {name=p125961 lab=_83464_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 126820 -19970 0 0 {name=Xclkbuf_10_293_0_CLK }
C {devices/lab_pin.sym} 126780 -19850 0 0 {name=p125962 lab=_71115_/C }
C {devices/lab_pin.sym} 126860 -19850 0 1 {name=p125963 lab=_70959_/B }
C {sky130_stdcells/buf_2.sym} 126820 -19850 0 0 {name=X_70932_ }
C {devices/lab_pin.sym} 126740 -19750 0 0 {name=p125964 lab=_58641_/X }
C {devices/lab_pin.sym} 126740 -19710 0 0 {name=p125965 lab=_85946_/Q }
C {devices/lab_pin.sym} 126740 -19670 0 0 {name=p125966 lab=_58109_/X }
C {devices/lab_pin.sym} 126900 -19710 0 1 {name=p125967 lab=_58654_/X }
C {sky130_stdcells/o21a_4.sym} 126820 -19710 0 0 {name=X_58654_ }
C {devices/lab_pin.sym} 126730 -19570 0 0 {name=p125968 lab=_81198_/CLK }
C {devices/lab_pin.sym} 126730 -19550 0 0 {name=p125969 lab=_78160_/X }
C {devices/lab_pin.sym} 126910 -19570 0 1 {name=p125970 lab=_82918_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -19560 0 0 {name=X_82918_ }
C {devices/lab_pin.sym} 126780 -19430 0 0 {name=p125971 lab=_43869_/X }
C {devices/lab_pin.sym} 126860 -19430 0 1 {name=p125972 lab=_43880_/X }
C {sky130_stdcells/buf_2.sym} 126820 -19430 0 0 {name=X_43880_ }
C {devices/lab_pin.sym} 126740 -19340 0 0 {name=p125973 lab=_85268_/Q }
C {devices/lab_pin.sym} 126740 -19300 0 0 {name=p125974 lab=_55505_/X }
C {devices/lab_pin.sym} 126740 -19260 0 0 {name=p125975 lab=_55506_/X }
C {devices/lab_pin.sym} 126740 -19220 0 0 {name=p125976 lab=_55865_/X }
C {devices/lab_pin.sym} 126900 -19280 0 1 {name=p125977 lab=_55866_/X }
C {sky130_stdcells/a211o_4.sym} 126820 -19280 0 0 {name=X_55866_ }
C {devices/lab_pin.sym} 126730 -19130 0 0 {name=p125978 lab=_86686_/CLK }
C {devices/lab_pin.sym} 126730 -19110 0 0 {name=p125979 lab=_86686_/D }
C {devices/lab_pin.sym} 126910 -19130 0 1 {name=p125980 lab=_59030_/A }
C {sky130_stdcells/dfxtp_4.sym} 126820 -19120 0 0 {name=X_86686_ }
C {devices/lab_pin.sym} 126730 -18990 0 0 {name=p125981 lab=_82299_/CLK }
C {devices/lab_pin.sym} 126730 -18970 0 0 {name=p125982 lab=_69775_/X }
C {devices/lab_pin.sym} 126910 -18990 0 1 {name=p125983 lab=_83898_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -18980 0 0 {name=X_83898_ }
C {devices/lab_pin.sym} 126760 -18860 0 0 {name=p125984 lab=_57630_/A }
C {devices/lab_pin.sym} 126760 -18820 0 0 {name=p125985 lab=_57605_/B }
C {devices/lab_pin.sym} 126880 -18840 0 1 {name=p125986 lab=_57605_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -18840 0 0 {name=X_57605_ }
C {devices/lab_pin.sym} 126780 -18710 0 0 {name=p125987 lab=_42680_/A }
C {devices/lab_pin.sym} 126860 -18710 0 1 {name=p125988 lab=_42832_/A }
C {sky130_stdcells/buf_2.sym} 126820 -18710 0 0 {name=X_42831_ }
C {devices/lab_pin.sym} 126740 -18610 0 0 {name=p125989 lab=_54815_/Y }
C {devices/lab_pin.sym} 126740 -18570 0 0 {name=p125990 lab=_54802_/X }
C {devices/lab_pin.sym} 126740 -18530 0 0 {name=p125991 lab=_54816_/X }
C {devices/lab_pin.sym} 126900 -18570 0 1 {name=p125992 lab=_85373_/D }
C {sky130_stdcells/a21oi_4.sym} 126820 -18570 0 0 {name=X_54817_ }
C {devices/lab_pin.sym} 126740 -18460 0 0 {name=p125993 lab=_68465_/B }
C {devices/lab_pin.sym} 126740 -18420 0 0 {name=p125994 lab=_73250_/X }
C {devices/lab_pin.sym} 126740 -18380 0 0 {name=p125995 lab=_73344_/X }
C {devices/lab_pin.sym} 126740 -18340 0 0 {name=p125996 lab=_73650_/Y }
C {devices/lab_pin.sym} 126900 -18400 0 1 {name=p125997 lab=_73651_/X }
C {sky130_stdcells/a211o_4.sym} 126820 -18400 0 0 {name=X_73651_ }
C {devices/lab_pin.sym} 126730 -18250 0 0 {name=p125998 lab=_85635_/CLK }
C {devices/lab_pin.sym} 126730 -18230 0 0 {name=p125999 lab=_85637_/D }
C {devices/lab_pin.sym} 126910 -18250 0 1 {name=p126000 lab=_85637_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -18240 0 0 {name=X_85637_ }
C {devices/lab_pin.sym} 126760 -18140 0 0 {name=p126001 lab=_70863_/A }
C {devices/lab_pin.sym} 126760 -18100 0 0 {name=p126002 lab=_71088_/C }
C {devices/lab_pin.sym} 126760 -18060 0 0 {name=p126003 lab=_70863_/C }
C {devices/lab_pin.sym} 126760 -18020 0 0 {name=p126004 lab=_70869_/D }
C {devices/lab_pin.sym} 126880 -18080 0 1 {name=p126005 lab=_70863_/Y }
C {sky130_stdcells/nand4_4.sym} 126820 -18080 0 0 {name=X_70863_ }
C {devices/lab_pin.sym} 126780 -17930 0 0 {name=p126006 lab=_58696_/A }
C {devices/lab_pin.sym} 126860 -17930 0 1 {name=p126007 lab=_58585_/X }
C {sky130_stdcells/buf_2.sym} 126820 -17930 0 0 {name=X_58585_ }
C {devices/lab_pin.sym} 126730 -17810 0 0 {name=p126008 lab=_82740_/CLK }
C {devices/lab_pin.sym} 126730 -17790 0 0 {name=p126009 lab=_82849_/D }
C {devices/lab_pin.sym} 126910 -17810 0 1 {name=p126010 lab=_82849_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -17800 0 0 {name=X_82849_ }
C {devices/lab_pin.sym} 126780 -17670 0 0 {name=p126011 lab=clkbuf_9_37_0_CLK/X }
C {devices/lab_pin.sym} 126860 -17670 0 1 {name=p126012 lab=_86882_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 126820 -17670 0 0 {name=Xclkbuf_10_75_0_CLK }
C {devices/lab_pin.sym} 126760 -17560 0 0 {name=p126013 lab=_55761_/A }
C {devices/lab_pin.sym} 126760 -17520 0 0 {name=p126014 lab=_56124_/C }
C {devices/lab_pin.sym} 126880 -17540 0 1 {name=p126015 lab=_55797_/X }
C {sky130_stdcells/and2_4.sym} 126820 -17540 0 0 {name=X_55797_ }
C {devices/lab_pin.sym} 126760 -17420 0 0 {name=p126016 lab=_72602_/A }
C {devices/lab_pin.sym} 126760 -17380 0 0 {name=p126017 lab=_72575_/A }
C {devices/lab_pin.sym} 126880 -17400 0 1 {name=p126018 lab=_72602_/X }
C {sky130_stdcells/and2_4.sym} 126820 -17400 0 0 {name=X_72602_ }
C {devices/lab_pin.sym} 126740 -17300 0 0 {name=p126019 lab=_55520_/B }
C {devices/lab_pin.sym} 126740 -17260 0 0 {name=p126020 lab=_45516_/X }
C {devices/lab_pin.sym} 126740 -17220 0 0 {name=p126021 lab=_45548_/X }
C {devices/lab_pin.sym} 126740 -17180 0 0 {name=p126022 lab=_45549_/Y }
C {devices/lab_pin.sym} 126900 -17240 0 1 {name=p126023 lab=_45550_/X }
C {sky130_stdcells/a211o_4.sym} 126820 -17240 0 0 {name=X_45550_ }
C {devices/lab_pin.sym} 126740 -17110 0 0 {name=p126024 lab=_57534_/Y }
C {devices/lab_pin.sym} 126740 -17070 0 0 {name=p126025 lab=_57515_/X }
C {devices/lab_pin.sym} 126740 -17030 0 0 {name=p126026 lab=_57535_/Y }
C {devices/lab_pin.sym} 126900 -17070 0 1 {name=p126027 lab=_84984_/D }
C {sky130_stdcells/a21boi_4.sym} 126820 -17070 0 0 {name=X_57536_ }
C {devices/lab_pin.sym} 126740 -16950 0 0 {name=p126028 lab=_76369_/B }
C {devices/lab_pin.sym} 126740 -16910 0 0 {name=p126029 lab=_76368_/Y }
C {devices/lab_pin.sym} 126740 -16870 0 0 {name=p126030 lab=_76369_/A }
C {devices/lab_pin.sym} 126900 -16910 0 1 {name=p126031 lab=_76370_/Y }
C {sky130_stdcells/o21ai_4.sym} 126820 -16910 0 0 {name=X_76370_ }
C {devices/lab_pin.sym} 126780 -16770 0 0 {name=p126032 lab=clkbuf_8_221_0_CLK/A }
C {devices/lab_pin.sym} 126860 -16770 0 1 {name=p126033 lab=clkbuf_9_443_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 126820 -16770 0 0 {name=Xclkbuf_8_221_0_CLK }
C {devices/lab_pin.sym} 126730 -16650 0 0 {name=p126034 lab=_82538_/CLK }
C {devices/lab_pin.sym} 126730 -16630 0 0 {name=p126035 lab=_88356_/D }
C {devices/lab_pin.sym} 126910 -16650 0 1 {name=p126036 lab=_68750_/B }
C {sky130_stdcells/dfxtp_4.sym} 126820 -16640 0 0 {name=X_88356_ }
C {devices/lab_pin.sym} 126760 -16540 0 0 {name=p126037 lab=_54748_/A }
C {devices/lab_pin.sym} 126760 -16500 0 0 {name=p126038 lab=_54755_/B }
C {devices/lab_pin.sym} 126760 -16460 0 0 {name=p126039 lab=_54748_/C }
C {devices/lab_pin.sym} 126760 -16420 0 0 {name=p126040 lab=_54748_/D }
C {devices/lab_pin.sym} 126880 -16480 0 1 {name=p126041 lab=_54748_/X }
C {sky130_stdcells/and4_4.sym} 126820 -16480 0 0 {name=X_54748_ }
C {devices/lab_pin.sym} 126780 -16330 0 0 {name=p126042 lab=_42762_/A }
C {devices/lab_pin.sym} 126860 -16330 0 1 {name=p126043 lab=_42762_/Y }
C {sky130_stdcells/inv_2.sym} 126820 -16330 0 0 {name=X_42762_ }
C {devices/lab_pin.sym} 126760 -16220 0 0 {name=p126044 lab=_73582_/A }
C {devices/lab_pin.sym} 126760 -16180 0 0 {name=p126045 lab=_73581_/Y }
C {devices/lab_pin.sym} 126880 -16200 0 1 {name=p126046 lab=_73582_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -16200 0 0 {name=X_73582_ }
C {devices/lab_pin.sym} 126730 -16070 0 0 {name=p126047 lab=_83307_/CLK }
C {devices/lab_pin.sym} 126730 -16050 0 0 {name=p126048 lab=_53790_/Y }
C {devices/lab_pin.sym} 126910 -16070 0 1 {name=p126049 lab=_85568_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -16060 0 0 {name=X_85568_ }
C {devices/lab_pin.sym} 126780 -15930 0 0 {name=p126050 lab=_70772_/A }
C {devices/lab_pin.sym} 126860 -15930 0 1 {name=p126051 lab=_70794_/X }
C {sky130_stdcells/buf_2.sym} 126820 -15930 0 0 {name=X_70794_ }
C {devices/lab_pin.sym} 126740 -15840 0 0 {name=p126052 lab=_41249_/Y }
C {devices/lab_pin.sym} 126740 -15800 0 0 {name=p126053 lab=_44474_/X }
C {devices/lab_pin.sym} 126740 -15760 0 0 {name=p126054 lab=_87078_/Q }
C {devices/lab_pin.sym} 126740 -15720 0 0 {name=p126055 lab=_44475_/X }
C {devices/lab_pin.sym} 126900 -15780 0 1 {name=p126056 lab=_87078_/D }
C {sky130_stdcells/a2bb2o_4.sym} 126820 -15780 0 0 {name=X_44501_ }
C {devices/lab_pin.sym} 126780 -15630 0 0 {name=p126057 lab=_75320_/Y }
C {devices/lab_pin.sym} 126860 -15630 0 1 {name=p126058 lab=_75321_/Y }
C {sky130_stdcells/inv_2.sym} 126820 -15630 0 0 {name=X_75321_ }
C {devices/lab_pin.sym} 126730 -15510 0 0 {name=p126059 lab=_83158_/CLK }
C {devices/lab_pin.sym} 126730 -15490 0 0 {name=p126060 lab=_87307_/D }
C {devices/lab_pin.sym} 126910 -15510 0 1 {name=p126061 lab=_87307_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -15500 0 0 {name=X_87307_ }
C {devices/lab_pin.sym} 126760 -15380 0 0 {name=p126062 lab=_82897_/Q }
C {devices/lab_pin.sym} 126760 -15340 0 0 {name=p126063 lab=_41660_/X }
C {devices/lab_pin.sym} 126880 -15360 0 1 {name=p126064 lab=_41713_/X }
C {sky130_stdcells/or2_4.sym} 126820 -15360 0 0 {name=X_41713_ }
C {devices/lab_pin.sym} 126760 -15250 0 0 {name=p126065 lab=_72533_/A }
C {devices/lab_pin.sym} 126760 -15210 0 0 {name=p126066 lab=_72527_/Y }
C {devices/lab_pin.sym} 126760 -15170 0 0 {name=p126067 lab=_72532_/X }
C {devices/lab_pin.sym} 126880 -15210 0 1 {name=p126068 lab=_83239_/D }
C {sky130_stdcells/nand3_4.sym} 126820 -15210 0 0 {name=X_72533_ }
C {devices/lab_pin.sym} 126730 -15070 0 0 {name=p126069 lab=_84508_/CLK }
C {devices/lab_pin.sym} 126730 -15050 0 0 {name=p126070 lab=_84519_/D }
C {devices/lab_pin.sym} 126910 -15070 0 1 {name=p126071 lab=_61132_/C }
C {sky130_stdcells/dfxtp_4.sym} 126820 -15060 0 0 {name=X_84519_ }
C {devices/lab_pin.sym} 126740 -14950 0 0 {name=p126072 lab=_45479_/Y }
C {devices/lab_pin.sym} 126740 -14910 0 0 {name=p126073 lab=_45480_/Y }
C {devices/lab_pin.sym} 126740 -14870 0 0 {name=p126074 lab=_44939_/B }
C {devices/lab_pin.sym} 126900 -14910 0 1 {name=p126075 lab=_45481_/X }
C {sky130_stdcells/o21a_4.sym} 126820 -14910 0 0 {name=X_45481_ }
C {devices/lab_pin.sym} 126780 -14770 0 0 {name=p126076 lab=_57466_/Y }
C {devices/lab_pin.sym} 126860 -14770 0 1 {name=p126077 lab=_84999_/D }
C {sky130_stdcells/inv_2.sym} 126820 -14770 0 0 {name=X_57467_ }
C {devices/lab_pin.sym} 126740 -14680 0 0 {name=p126078 lab=_41093_/X }
C {devices/lab_pin.sym} 126740 -14640 0 0 {name=p126079 lab=_42679_/X }
C {devices/lab_pin.sym} 126740 -14600 0 0 {name=p126080 lab=_69521_/B }
C {devices/lab_pin.sym} 126740 -14560 0 0 {name=p126081 lab=_42681_/X }
C {devices/lab_pin.sym} 126900 -14620 0 1 {name=p126082 lab=_42693_/X }
C {sky130_stdcells/a2bb2o_4.sym} 126820 -14620 0 0 {name=X_42693_ }
C {devices/lab_pin.sym} 126730 -14470 0 0 {name=p126083 lab=_87022_/CLK }
C {devices/lab_pin.sym} 126730 -14450 0 0 {name=p126084 lab=_88287_/D }
C {devices/lab_pin.sym} 126910 -14470 0 1 {name=p126085 lab=_69415_/B }
C {sky130_stdcells/dfxtp_4.sym} 126820 -14460 0 0 {name=X_88287_ }
C {devices/lab_pin.sym} 126740 -14350 0 0 {name=p126086 lab=_85398_/Q }
C {devices/lab_pin.sym} 126740 -14310 0 0 {name=p126087 lab=_54676_/X }
C {devices/lab_pin.sym} 126740 -14270 0 0 {name=p126088 lab=_54678_/Y }
C {devices/lab_pin.sym} 126900 -14310 0 1 {name=p126089 lab=_54679_/Y }
C {sky130_stdcells/o21ai_4.sym} 126820 -14310 0 0 {name=X_54679_ }
C {devices/lab_pin.sym} 126730 -14170 0 0 {name=p126090 lab=_85499_/CLK }
C {devices/lab_pin.sym} 126730 -14150 0 0 {name=p126091 lab=_85499_/D }
C {devices/lab_pin.sym} 126910 -14170 0 1 {name=p126092 lab=_85499_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -14160 0 0 {name=X_85499_ }
C {devices/lab_pin.sym} 126780 -14030 0 0 {name=p126093 lab=_83393_/Q }
C {devices/lab_pin.sym} 126860 -14030 0 1 {name=p126094 lab=_47221_/A }
C {sky130_stdcells/inv_2.sym} 126820 -14030 0 0 {name=X_47220_ }
C {devices/lab_pin.sym} 126740 -13930 0 0 {name=p126095 lab=_59160_/X }
C {devices/lab_pin.sym} 126740 -13890 0 0 {name=p126096 lab=_85648_/Q }
C {devices/lab_pin.sym} 126740 -13850 0 0 {name=p126097 lab=_59205_/X }
C {devices/lab_pin.sym} 126900 -13890 0 1 {name=p126098 lab=_59206_/X }
C {sky130_stdcells/o21a_4.sym} 126820 -13890 0 0 {name=X_59206_ }
C {devices/lab_pin.sym} 126780 -13750 0 0 {name=p126099 lab=_77907_/Y }
C {devices/lab_pin.sym} 126860 -13750 0 1 {name=p126100 lab=_81942_/D }
C {sky130_stdcells/inv_2.sym} 126820 -13750 0 0 {name=X_78040_ }
C {devices/lab_pin.sym} 126780 -13630 0 0 {name=p126101 lab=_44454_/A }
C {devices/lab_pin.sym} 126860 -13630 0 1 {name=p126102 lab=_44432_/X }
C {sky130_stdcells/buf_2.sym} 126820 -13630 0 0 {name=X_44432_ }
C {devices/lab_pin.sym} 126760 -13530 0 0 {name=p126103 lab=_56418_/A }
C {devices/lab_pin.sym} 126760 -13490 0 0 {name=p126104 lab=_56418_/B }
C {devices/lab_pin.sym} 126760 -13450 0 0 {name=p126105 lab=_85201_/Q }
C {devices/lab_pin.sym} 126880 -13490 0 1 {name=p126106 lab=_56418_/Y }
C {sky130_stdcells/nand3_4.sym} 126820 -13490 0 0 {name=X_56418_ }
C {devices/lab_pin.sym} 126760 -13360 0 0 {name=p126107 lab=_75239_/A }
C {devices/lab_pin.sym} 126760 -13320 0 0 {name=p126108 lab=_80986_/Q }
C {devices/lab_pin.sym} 126880 -13340 0 1 {name=p126109 lab=_75252_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -13340 0 0 {name=X_75252_ }
C {devices/lab_pin.sym} 126740 -13240 0 0 {name=p126110 lab=_41643_/X }
C {devices/lab_pin.sym} 126740 -13200 0 0 {name=p126111 lab=_41638_/X }
C {devices/lab_pin.sym} 126740 -13160 0 0 {name=p126112 lab=_67385_/B }
C {devices/lab_pin.sym} 126740 -13120 0 0 {name=p126113 lab=_41639_/X }
C {devices/lab_pin.sym} 126900 -13180 0 1 {name=p126114 lab=_41644_/X }
C {sky130_stdcells/a2bb2o_4.sym} 126820 -13180 0 0 {name=X_41644_ }
C {devices/lab_pin.sym} 126730 -13030 0 0 {name=p126115 lab=_88012_/CLK }
C {devices/lab_pin.sym} 126730 -13010 0 0 {name=p126116 lab=_43844_/X }
C {devices/lab_pin.sym} 126910 -13030 0 1 {name=p126117 lab=_87238_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -13020 0 0 {name=X_87238_ }
C {devices/lab_pin.sym} 126740 -12920 0 0 {name=p126118 lab=_79549_/B }
C {devices/lab_pin.sym} 126740 -12880 0 0 {name=p126119 lab=_72358_/X }
C {devices/lab_pin.sym} 126740 -12840 0 0 {name=p126120 lab=_72460_/X }
C {devices/lab_pin.sym} 126740 -12800 0 0 {name=p126121 lab=_72463_/X }
C {devices/lab_pin.sym} 126900 -12860 0 1 {name=p126122 lab=_83252_/D }
C {sky130_stdcells/a22oi_4.sym} 126820 -12860 0 0 {name=X_72464_ }
C {devices/lab_pin.sym} 126740 -12730 0 0 {name=p126123 lab=_56613_/X }
C {devices/lab_pin.sym} 126740 -12690 0 0 {name=p126124 lab=_57391_/Y }
C {devices/lab_pin.sym} 126740 -12650 0 0 {name=p126125 lab=_57397_/Y }
C {devices/lab_pin.sym} 126900 -12690 0 1 {name=p126126 lab=_85017_/D }
C {sky130_stdcells/a21oi_4.sym} 126820 -12690 0 0 {name=X_57398_ }
C {devices/lab_pin.sym} 126740 -12570 0 0 {name=p126127 lab=_70129_/B }
C {devices/lab_pin.sym} 126740 -12530 0 0 {name=p126128 lab=_74139_/X }
C {devices/lab_pin.sym} 126740 -12490 0 0 {name=p126129 lab=_74202_/Y }
C {devices/lab_pin.sym} 126900 -12530 0 1 {name=p126130 lab=_74203_/X }
C {sky130_stdcells/a21o_4.sym} 126820 -12530 0 0 {name=X_74203_ }
C {devices/lab_pin.sym} 126780 -12390 0 0 {name=p126131 lab=clkbuf_8_237_0_CLK/A }
C {devices/lab_pin.sym} 126860 -12390 0 1 {name=p126132 lab=clkbuf_8_236_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 126820 -12390 0 0 {name=Xclkbuf_8_236_0_CLK }
C {devices/lab_pin.sym} 126740 -12290 0 0 {name=p126133 lab=_59121_/X }
C {devices/lab_pin.sym} 126740 -12250 0 0 {name=p126134 lab=_85430_/Q }
C {devices/lab_pin.sym} 126740 -12210 0 0 {name=p126135 lab=_59136_/X }
C {devices/lab_pin.sym} 126900 -12250 0 1 {name=p126136 lab=_59137_/Y }
C {sky130_stdcells/o21ai_4.sym} 126820 -12250 0 0 {name=X_59137_ }
C {devices/lab_pin.sym} 126740 -12130 0 0 {name=p126137 lab=_86665_/Q }
C {devices/lab_pin.sym} 126740 -12090 0 0 {name=p126138 lab=_47145_/X }
C {devices/lab_pin.sym} 126740 -12050 0 0 {name=p126139 lab=_47150_/Y }
C {devices/lab_pin.sym} 126900 -12090 0 1 {name=p126140 lab=_47151_/Y }
C {sky130_stdcells/o21ai_4.sym} 126820 -12090 0 0 {name=X_47151_ }
C {devices/lab_pin.sym} 126780 -11950 0 0 {name=p126141 lab=_71342_/B }
C {devices/lab_pin.sym} 126860 -11950 0 1 {name=p126142 lab=_71450_/C }
C {sky130_stdcells/buf_2.sym} 126820 -11950 0 0 {name=X_71415_ }
C {devices/lab_pin.sym} 126780 -11830 0 0 {name=p126143 lab=_46298_/A }
C {devices/lab_pin.sym} 126860 -11830 0 1 {name=p126144 lab=_44363_/X }
C {sky130_stdcells/buf_2.sym} 126820 -11830 0 0 {name=X_44363_ }
C {devices/lab_pin.sym} 126740 -11730 0 0 {name=p126145 lab=_56134_/X }
C {devices/lab_pin.sym} 126740 -11690 0 0 {name=p126146 lab=_56337_/X }
C {devices/lab_pin.sym} 126740 -11650 0 0 {name=p126147 lab=_56348_/Y }
C {devices/lab_pin.sym} 126900 -11690 0 1 {name=p126148 lab=_85226_/D }
C {sky130_stdcells/o21ai_4.sym} 126820 -11690 0 0 {name=X_56349_ }
C {devices/lab_pin.sym} 126780 -11550 0 0 {name=p126149 lab=clkbuf_9_115_0_CLK/X }
C {devices/lab_pin.sym} 126860 -11550 0 1 {name=p126150 lab=_84441_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 126820 -11550 0 0 {name=Xclkbuf_10_231_0_CLK }
C {devices/lab_pin.sym} 126760 -11440 0 0 {name=p126151 lab=_80777_/Q }
C {devices/lab_pin.sym} 126760 -11400 0 0 {name=p126152 lab=_81033_/D }
C {devices/lab_pin.sym} 126880 -11420 0 1 {name=p126153 lab=_75183_/X }
C {sky130_stdcells/xor2_4.sym} 126820 -11420 0 0 {name=X_75183_ }
C {devices/lab_pin.sym} 126730 -11290 0 0 {name=p126154 lab=_87169_/CLK }
C {devices/lab_pin.sym} 126730 -11270 0 0 {name=p126155 lab=_87169_/D }
C {devices/lab_pin.sym} 126910 -11290 0 1 {name=p126156 lab=_87169_/Q }
C {sky130_stdcells/dfxtp_4.sym} 126820 -11280 0 0 {name=X_87169_ }
C {devices/lab_pin.sym} 126740 -11190 0 0 {name=p126157 lab=_41540_/X }
C {devices/lab_pin.sym} 126740 -11150 0 0 {name=p126158 lab=_41541_/X }
C {devices/lab_pin.sym} 126740 -11110 0 0 {name=p126159 lab=_41574_/X }
C {devices/lab_pin.sym} 126740 -11070 0 0 {name=p126160 lab=_67100_/B }
C {devices/lab_pin.sym} 126740 -11030 0 0 {name=p126161 lab=_41537_/X }
C {devices/lab_pin.sym} 126900 -11110 0 1 {name=p126162 lab=_41576_/A }
C {sky130_stdcells/o32ai_4.sym} 126820 -11110 0 0 {name=X_41575_ }
C {devices/lab_pin.sym} 126740 -10970 0 0 {name=p126163 lab=_57712_/X }
C {devices/lab_pin.sym} 126740 -10930 0 0 {name=p126164 lab=_85322_/Q }
C {devices/lab_pin.sym} 126740 -10890 0 0 {name=p126165 lab=_72324_/X }
C {devices/lab_pin.sym} 126900 -10930 0 1 {name=p126166 lab=_72395_/X }
C {sky130_stdcells/o21a_4.sym} 126820 -10930 0 0 {name=X_72395_ }
C {devices/lab_pin.sym} 126780 -10790 0 0 {name=p126167 lab=_45955_/X }
C {devices/lab_pin.sym} 126860 -10790 0 1 {name=p126168 lab=_58981_/A }
C {sky130_stdcells/buf_2.sym} 126820 -10790 0 0 {name=X_46102_ }
C {devices/lab_pin.sym} 126780 -10670 0 0 {name=p126169 lab=clkbuf_9_430_0_CLK/X }
C {devices/lab_pin.sym} 126860 -10670 0 1 {name=p126170 lab=_85815_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 126820 -10670 0 0 {name=Xclkbuf_10_861_0_CLK }
C {devices/lab_pin.sym} 126780 -10550 0 0 {name=p126171 lab=_43314_/A }
C {devices/lab_pin.sym} 126860 -10550 0 1 {name=p126172 lab=_87486_/D }
C {sky130_stdcells/inv_2.sym} 126820 -10550 0 0 {name=X_43314_ }
C {devices/lab_pin.sym} 126760 -10440 0 0 {name=p126173 lab=_74134_/A }
C {devices/lab_pin.sym} 126760 -10400 0 0 {name=p126174 lab=_74133_/X }
C {devices/lab_pin.sym} 126880 -10420 0 1 {name=p126175 lab=_74135_/B }
C {sky130_stdcells/nand2_4.sym} 126820 -10420 0 0 {name=X_74134_ }
C {devices/lab_pin.sym} 126760 -10300 0 0 {name=p126176 lab=_82310_/Q }
C {devices/lab_pin.sym} 126760 -10260 0 0 {name=p126177 lab=_40467_/B }
C {devices/lab_pin.sym} 126880 -10280 0 1 {name=p126178 lab=_40526_/X }
C {sky130_stdcells/or2_4.sym} 126820 -10280 0 0 {name=X_40526_ }
C {devices/lab_pin.sym} 126780 -10150 0 0 {name=p126179 lab=_46941_/A }
C {devices/lab_pin.sym} 126860 -10150 0 1 {name=p126180 lab=_47082_/X }
C {sky130_stdcells/buf_2.sym} 126820 -10150 0 0 {name=X_47082_ }
C {devices/lab_pin.sym} 126760 -10040 0 0 {name=p126181 lab=_59068_/A }
C {devices/lab_pin.sym} 126760 -10000 0 0 {name=p126182 lab=_59068_/B }
C {devices/lab_pin.sym} 126880 -10020 0 1 {name=p126183 lab=_59068_/Y }
C {sky130_stdcells/nor2_4.sym} 126820 -10020 0 0 {name=X_59068_ }
C {devices/lab_pin.sym} 126780 -9890 0 0 {name=p126184 lab=_71418_/B }
C {devices/lab_pin.sym} 126860 -9890 0 1 {name=p126185 lab=_71504_/C }
C {sky130_stdcells/buf_2.sym} 126820 -9890 0 0 {name=X_71346_ }
C {devices/lab_pin.sym} 126740 -9800 0 0 {name=p126186 lab=_44216_/X }
C {devices/lab_pin.sym} 126740 -9760 0 0 {name=p126187 lab=_44217_/X }
C {devices/lab_pin.sym} 126740 -9720 0 0 {name=p126188 lab=_45950_/A }
C {devices/lab_pin.sym} 126740 -9680 0 0 {name=p126189 lab=_44268_/A }
C {devices/lab_pin.sym} 126900 -9740 0 1 {name=p126190 lab=_44294_/X }
C {sky130_stdcells/a211o_4.sym} 126820 -9740 0 0 {name=X_44294_ }
C {devices/lab_pin.sym} 126740 -9610 0 0 {name=p126191 lab=_79980_/A }
C {devices/lab_pin.sym} 126740 -9570 0 0 {name=p126192 lab=_79963_/Y }
C {devices/lab_pin.sym} 126740 -9530 0 0 {name=p126193 lab=_79980_/B }
C {devices/lab_pin.sym} 126900 -9570 0 1 {name=p126194 lab=_79991_/Y }
C {sky130_stdcells/a21boi_4.sym} 126820 -9570 0 0 {name=X_79991_ }
C {devices/lab_pin.sym} 126780 -9430 0 0 {name=p126195 lab=clkbuf_9_6_0_CLK/X }
C {devices/lab_pin.sym} 126860 -9430 0 1 {name=p126196 lab=_85184_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 126820 -9430 0 0 {name=Xclkbuf_10_13_0_CLK }
C {devices/lab_pin.sym} 126740 -9350 0 0 {name=p126197 lab=_46013_/X }
C {devices/lab_pin.sym} 126740 -9310 0 0 {name=p126198 lab=_46032_/X }
C {devices/lab_pin.sym} 126740 -9270 0 0 {name=p126199 lab=_41472_/X }
C {devices/lab_pin.sym} 126740 -9230 0 0 {name=p126200 lab=_86803_/Q }
C {devices/lab_pin.sym} 126740 -9190 0 0 {name=p126201 lab=_46014_/X }
C {devices/lab_pin.sym} 126900 -9270 0 1 {name=p126202 lab=_46034_/A }
C {sky130_stdcells/o32ai_4.sym} 126820 -9270 0 0 {name=X_46033_ }
C {devices/lab_pin.sym} 126740 -9130 0 0 {name=p126203 lab=_58017_/X }
C {devices/lab_pin.sym} 126740 -9090 0 0 {name=p126204 lab=_85388_/Q }
C {devices/lab_pin.sym} 126740 -9050 0 0 {name=p126205 lab=_58018_/X }
C {devices/lab_pin.sym} 126900 -9090 0 1 {name=p126206 lab=_58019_/Y }
C {sky130_stdcells/o21ai_4.sym} 126820 -9090 0 0 {name=X_58019_ }
C {devices/lab_pin.sym} 126780 -8950 0 0 {name=p126207 lab=clkbuf_8_176_0_CLK/X }
C {devices/lab_pin.sym} 126860 -8950 0 1 {name=p126208 lab=clkbuf_9_352_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 126820 -8950 0 0 {name=Xclkbuf_9_352_0_CLK }
C {devices/lab_pin.sym} 126740 -8870 0 0 {name=p126209 lab=_43241_/X }
C {devices/lab_pin.sym} 126740 -8830 0 0 {name=p126210 lab=_43244_/X }
C {devices/lab_pin.sym} 126740 -8790 0 0 {name=p126211 lab=_41045_/X }
C {devices/lab_pin.sym} 126740 -8750 0 0 {name=p126212 lab=_87520_/Q }
C {devices/lab_pin.sym} 126740 -8710 0 0 {name=p126213 lab=_43232_/X }
C {devices/lab_pin.sym} 126900 -8790 0 1 {name=p126214 lab=_43246_/A }
C {sky130_stdcells/o32ai_4.sym} 126820 -8790 0 0 {name=X_43245_ }
C {devices/lab_pin.sym} 126760 -8640 0 0 {name=p126215 lab=_74065_/A }
C {devices/lab_pin.sym} 126760 -8600 0 0 {name=p126216 lab=_74065_/B }
C {devices/lab_pin.sym} 126880 -8620 0 1 {name=p126217 lab=_74066_/B }
C {sky130_stdcells/nand2_4.sym} 126820 -8620 0 0 {name=X_74065_ }
C {devices/lab_pin.sym} 126760 -8500 0 0 {name=p126218 lab=_78942_/A }
C {devices/lab_pin.sym} 126760 -8460 0 0 {name=p126219 lab=_78953_/A }
C {devices/lab_pin.sym} 126880 -8480 0 1 {name=p126220 lab=_78946_/A }
C {sky130_stdcells/xor2_4.sym} 126820 -8480 0 0 {name=X_78942_ }
C {devices/lab_pin.sym} 126760 -8360 0 0 {name=p126221 lab=_82322_/Q }
C {devices/lab_pin.sym} 126760 -8320 0 0 {name=p126222 lab=_40907_/B }
C {devices/lab_pin.sym} 126880 -8340 0 1 {name=p126223 lab=_40457_/X }
C {sky130_stdcells/or2_4.sym} 126820 -8340 0 0 {name=X_40457_ }
C {devices/lab_pin.sym} 126740 -8230 0 0 {name=p126224 lab=_53200_/B }
C {devices/lab_pin.sym} 126740 -8190 0 0 {name=p126225 lab=_71265_/X }
C {devices/lab_pin.sym} 126740 -8150 0 0 {name=p126226 lab=_71276_/Y }
C {devices/lab_pin.sym} 126900 -8190 0 1 {name=p126227 lab=_83550_/D }
C {sky130_stdcells/o21ai_4.sym} 126820 -8190 0 0 {name=X_71277_ }
C {devices/lab_pin.sym} 126760 -8060 0 0 {name=p126228 lab=_61030_/A }
C {devices/lab_pin.sym} 126760 -8020 0 0 {name=p126229 lab=_60966_/A }
C {devices/lab_pin.sym} 126880 -8040 0 1 {name=p126230 lab=_61030_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -8040 0 0 {name=X_61030_ }
C {devices/lab_pin.sym} 126760 -7920 0 0 {name=p126231 lab=_72816_/X }
C {devices/lab_pin.sym} 126760 -7880 0 0 {name=p126232 lab=_73016_/B }
C {devices/lab_pin.sym} 126880 -7900 0 1 {name=p126233 lab=_73016_/X }
C {sky130_stdcells/and2_4.sym} 126820 -7900 0 0 {name=X_73016_ }
C {devices/lab_pin.sym} 126780 -7770 0 0 {name=p126234 lab=clkbuf_9_123_0_CLK/X }
C {devices/lab_pin.sym} 126860 -7770 0 1 {name=p126235 lab=_84564_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 126820 -7770 0 0 {name=Xclkbuf_10_246_0_CLK }
C {devices/lab_pin.sym} 126740 -7670 0 0 {name=p126236 lab=_70224_/X }
C {devices/lab_pin.sym} 126740 -7630 0 0 {name=p126237 lab=_83830_/Q }
C {devices/lab_pin.sym} 126740 -7590 0 0 {name=p126238 lab=_70227_/X }
C {devices/lab_pin.sym} 126900 -7630 0 1 {name=p126239 lab=_83830_/D }
C {sky130_stdcells/a21o_4.sym} 126820 -7630 0 0 {name=X_70228_ }
C {devices/lab_pin.sym} 126780 -7490 0 0 {name=p126240 lab=_43175_/X }
C {devices/lab_pin.sym} 126860 -7490 0 1 {name=p126241 lab=_53900_/A }
C {sky130_stdcells/buf_2.sym} 126820 -7490 0 0 {name=X_43176_ }
C {devices/lab_pin.sym} 126760 -7380 0 0 {name=p126242 lab=_78866_/A }
C {devices/lab_pin.sym} 126760 -7340 0 0 {name=p126243 lab=_78868_/A }
C {devices/lab_pin.sym} 126880 -7360 0 1 {name=p126244 lab=_78873_/Y }
C {sky130_stdcells/nor2_4.sym} 126820 -7360 0 0 {name=X_78873_ }
C {devices/lab_pin.sym} 126740 -7260 0 0 {name=p126245 lab=_40387_/X }
C {devices/lab_pin.sym} 126740 -7220 0 0 {name=p126246 lab=_40342_/X }
C {devices/lab_pin.sym} 126740 -7180 0 0 {name=p126247 lab=_88400_/Q }
C {devices/lab_pin.sym} 126740 -7140 0 0 {name=p126248 lab=_40355_/X }
C {devices/lab_pin.sym} 126900 -7200 0 1 {name=p126249 lab=_40388_/X }
C {sky130_stdcells/a2bb2o_4.sym} 126820 -7200 0 0 {name=X_40388_ }
C {devices/lab_pin.sym} 126780 -7050 0 0 {name=p126250 lab=clkbuf_9_438_0_CLK/X }
C {devices/lab_pin.sym} 126860 -7050 0 1 {name=p126251 lab=_86436_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 126820 -7050 0 0 {name=Xclkbuf_10_876_0_CLK }
C {devices/lab_pin.sym} 126740 -6960 0 0 {name=p126252 lab=_41093_/X }
C {devices/lab_pin.sym} 126740 -6920 0 0 {name=p126253 lab=_42125_/X }
C {devices/lab_pin.sym} 126740 -6880 0 0 {name=p126254 lab=_88023_/Q }
C {devices/lab_pin.sym} 126740 -6840 0 0 {name=p126255 lab=_42126_/X }
C {devices/lab_pin.sym} 126900 -6900 0 1 {name=p126256 lab=_42127_/X }
C {sky130_stdcells/a2bb2o_4.sym} 126820 -6900 0 0 {name=X_42127_ }
C {devices/lab_pin.sym} 126760 -6760 0 0 {name=p126257 lab=_82156_/Q }
C {devices/lab_pin.sym} 126760 -6720 0 0 {name=p126258 lab=_77824_/B }
C {devices/lab_pin.sym} 126880 -6740 0 1 {name=p126259 lab=_82124_/D }
C {sky130_stdcells/xor2_4.sym} 126820 -6740 0 0 {name=X_77824_ }
C {devices/lab_pin.sym} 126780 -6610 0 0 {name=p126260 lab=clkbuf_9_14_0_CLK/X }
C {devices/lab_pin.sym} 126860 -6610 0 1 {name=p126261 lab=_85156_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 126820 -6610 0 0 {name=Xclkbuf_10_28_0_CLK }
C {devices/lab_pin.sym} 126780 -6490 0 0 {name=p126262 lab=_70127_/X }
C {devices/lab_pin.sym} 126860 -6490 0 1 {name=p126263 lab=_70348_/A }
C {sky130_stdcells/buf_2.sym} 126820 -6490 0 0 {name=X_70159_ }
C {devices/lab_pin.sym} 126760 -6380 0 0 {name=p126264 lab=_47981_/X }
C {devices/lab_pin.sym} 126760 -6340 0 0 {name=p126265 lab=_47984_/B }
C {devices/lab_pin.sym} 126880 -6360 0 1 {name=p126266 lab=_47984_/X }
C {sky130_stdcells/and2_4.sym} 126820 -6360 0 0 {name=X_47984_ }
C {devices/lab_pin.sym} 126780 -6230 0 0 {name=p126267 lab=clkbuf_9_367_0_CLK/A }
C {devices/lab_pin.sym} 126860 -6230 0 1 {name=p126268 lab=clkbuf_9_367_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 126820 -6230 0 0 {name=Xclkbuf_9_367_0_CLK }
C {devices/lab_pin.sym} 126780 -6110 0 0 {name=p126269 lab=_49641_/A }
C {devices/lab_pin.sym} 126860 -6110 0 1 {name=p126270 lab=_49724_/B }
C {sky130_stdcells/buf_2.sym} 126820 -6110 0 0 {name=X_49723_ }
C {devices/lab_pin.sym} 126740 -6010 0 0 {name=p126271 lab=_46931_/Y }
C {devices/lab_pin.sym} 126740 -5970 0 0 {name=p126272 lab=_46891_/X }
C {devices/lab_pin.sym} 126740 -5930 0 0 {name=p126273 lab=_46934_/X }
C {devices/lab_pin.sym} 126900 -5970 0 1 {name=p126274 lab=_46935_/Y }
C {sky130_stdcells/a21oi_4.sym} 126820 -5970 0 0 {name=X_46935_ }
C {devices/lab_pin.sym} 126740 -5870 0 0 {name=p126275 lab=_42035_/X }
C {devices/lab_pin.sym} 126740 -5830 0 0 {name=p126276 lab=_42049_/X }
C {devices/lab_pin.sym} 126740 -5790 0 0 {name=p126277 lab=_40921_/X }
C {devices/lab_pin.sym} 126740 -5750 0 0 {name=p126278 lab=_42057_/Y }
C {devices/lab_pin.sym} 126740 -5710 0 0 {name=p126279 lab=_42037_/X }
C {devices/lab_pin.sym} 126900 -5790 0 1 {name=p126280 lab=_88054_/D }
C {sky130_stdcells/o32ai_4.sym} 126820 -5790 0 0 {name=X_42058_ }
C {devices/lab_pin.sym} 126780 -5630 0 0 {name=p126281 lab=_82053_/Q }
C {devices/lab_pin.sym} 126860 -5630 0 1 {name=p126282 lab=_77764_/B }
C {sky130_stdcells/inv_2.sym} 126820 -5630 0 0 {name=X_77755_ }
C {devices/lab_pin.sym} 126740 -5530 0 0 {name=p126283 lab=_74963_/B }
C {devices/lab_pin.sym} 126740 -5490 0 0 {name=p126284 lab=_74971_/A }
C {devices/lab_pin.sym} 126740 -5450 0 0 {name=p126285 lab=_74966_/Y }
C {devices/lab_pin.sym} 126900 -5490 0 1 {name=p126286 lab=_74968_/B }
C {sky130_stdcells/a21boi_4.sym} 126820 -5490 0 0 {name=X_74967_ }
C {devices/lab_pin.sym} 126760 -5370 0 0 {name=p126287 lab=_62927_/A }
C {devices/lab_pin.sym} 126760 -5330 0 0 {name=p126288 lab=_62664_/B }
C {devices/lab_pin.sym} 126760 -5290 0 0 {name=p126289 lab=_62174_/X }
C {devices/lab_pin.sym} 126880 -5330 0 1 {name=p126290 lab=_62981_/Y }
C {sky130_stdcells/nand3_4.sym} 126820 -5330 0 0 {name=X_62981_ }
C {devices/lab_pin.sym} 126740 -5220 0 0 {name=p126291 lab=_64714_/X }
C {devices/lab_pin.sym} 126740 -5180 0 0 {name=p126292 lab=_86173_/Q }
C {devices/lab_pin.sym} 126740 -5140 0 0 {name=p126293 lab=_64716_/X }
C {devices/lab_pin.sym} 126740 -5100 0 0 {name=p126294 lab=_64719_/X }
C {devices/lab_pin.sym} 126900 -5160 0 1 {name=p126295 lab=_64720_/X }
C {sky130_stdcells/a211o_4.sym} 126820 -5160 0 0 {name=X_64720_ }
C {devices/lab_pin.sym} 126780 -5010 0 0 {name=p126296 lab=_41009_/A }
C {devices/lab_pin.sym} 126860 -5010 0 1 {name=p126297 lab=_41009_/X }
C {sky130_stdcells/buf_2.sym} 126820 -5010 0 0 {name=X_41009_ }
C {devices/lab_pin.sym} 126760 -4900 0 0 {name=p126298 lab=_76706_/A }
C {devices/lab_pin.sym} 126760 -4860 0 0 {name=p126299 lab=_81448_/D }
C {devices/lab_pin.sym} 126880 -4880 0 1 {name=p126300 lab=_81544_/D }
C {sky130_stdcells/xor2_4.sym} 126820 -4880 0 0 {name=X_76706_ }
C {devices/lab_pin.sym} 126760 -4760 0 0 {name=p126301 lab=_49638_/A }
C {devices/lab_pin.sym} 126760 -4720 0 0 {name=p126302 lab=_52869_/B }
C {devices/lab_pin.sym} 126880 -4740 0 1 {name=p126303 lab=_49654_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -4740 0 0 {name=X_49654_ }
C {devices/lab_pin.sym} 126740 -4650 0 0 {name=p126304 lab=_57672_/X }
C {devices/lab_pin.sym} 126740 -4610 0 0 {name=p126305 lab=_61902_/X }
C {devices/lab_pin.sym} 126740 -4570 0 0 {name=p126306 lab=_61916_/X }
C {devices/lab_pin.sym} 126740 -4530 0 0 {name=p126307 lab=_61870_/X }
C {devices/lab_pin.sym} 126740 -4500 0 0 {name=p126308 lab=_61931_/X }
C {devices/lab_pin.sym} 126900 -4570 0 1 {name=p126309 lab=_61932_/X }
C {sky130_stdcells/a41o_4.sym} 126820 -4570 0 0 {name=X_61932_ }
C {devices/lab_pin.sym} 126760 -4420 0 0 {name=p126310 lab=_42499_/A }
C {devices/lab_pin.sym} 126760 -4380 0 0 {name=p126311 lab=_72829_/X }
C {devices/lab_pin.sym} 126880 -4400 0 1 {name=p126312 lab=_73918_/Y }
C {sky130_stdcells/nor2_4.sym} 126820 -4400 0 0 {name=X_73918_ }
C {devices/lab_pin.sym} 126780 -4270 0 0 {name=p126313 lab=_82951_/Q }
C {devices/lab_pin.sym} 126860 -4270 0 1 {name=p126314 lab=_46866_/Y }
C {sky130_stdcells/inv_2.sym} 126820 -4270 0 0 {name=X_46866_ }
C {devices/lab_pin.sym} 126780 -4150 0 0 {name=p126315 lab=_77688_/A }
C {devices/lab_pin.sym} 126860 -4150 0 1 {name=p126316 lab=_77686_/Y }
C {sky130_stdcells/inv_2.sym} 126820 -4150 0 0 {name=X_77686_ }
C {devices/lab_pin.sym} 126760 -4040 0 0 {name=p126317 lab=_74872_/Y }
C {devices/lab_pin.sym} 126760 -4000 0 0 {name=p126318 lab=_74897_/X }
C {devices/lab_pin.sym} 126880 -4020 0 1 {name=p126319 lab=_74904_/A }
C {sky130_stdcells/nand2_4.sym} 126820 -4020 0 0 {name=X_74898_ }
C {devices/lab_pin.sym} 126740 -3910 0 0 {name=p126320 lab=_86507_/Q }
C {devices/lab_pin.sym} 126740 -3870 0 0 {name=p126321 lab=_48536_/X }
C {devices/lab_pin.sym} 126740 -3830 0 0 {name=p126322 lab=_48604_/Y }
C {devices/lab_pin.sym} 126900 -3870 0 1 {name=p126323 lab=_48605_/Y }
C {sky130_stdcells/o21ai_4.sym} 126820 -3870 0 0 {name=X_48605_ }
C {devices/lab_pin.sym} 126740 -3750 0 0 {name=p126324 lab=_79415_/A }
C {devices/lab_pin.sym} 126740 -3710 0 0 {name=p126325 lab=_79414_/X }
C {devices/lab_pin.sym} 126740 -3670 0 0 {name=p126326 lab=_79424_/Y }
C {devices/lab_pin.sym} 126900 -3710 0 1 {name=p126327 lab=_79429_/A }
C {sky130_stdcells/a21boi_4.sym} 126820 -3710 0 0 {name=X_79425_ }
C {devices/lab_pin.sym} 126760 -3580 0 0 {name=p126328 lab=_74694_/B }
C {devices/lab_pin.sym} 126760 -3540 0 0 {name=p126329 lab=_45832_/B }
C {devices/lab_pin.sym} 126880 -3560 0 1 {name=p126330 lab=_45817_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -3560 0 0 {name=X_45817_ }
C {devices/lab_pin.sym} 126760 -3440 0 0 {name=p126331 lab=_64676_/A }
C {devices/lab_pin.sym} 126760 -3400 0 0 {name=p126332 lab=_85855_/Q }
C {devices/lab_pin.sym} 126880 -3420 0 1 {name=p126333 lab=_64651_/X }
C {sky130_stdcells/and2_4.sym} 126820 -3420 0 0 {name=X_64651_ }
C {devices/lab_pin.sym} 126760 -3300 0 0 {name=p126334 lab=_81537_/D }
C {devices/lab_pin.sym} 126760 -3260 0 0 {name=p126335 lab=_76637_/B }
C {devices/lab_pin.sym} 126880 -3280 0 1 {name=p126336 lab=_76637_/X }
C {sky130_stdcells/xor2_4.sym} 126820 -3280 0 0 {name=X_76637_ }
C {devices/lab_pin.sym} 126760 -3160 0 0 {name=p126337 lab=_49580_/X }
C {devices/lab_pin.sym} 126760 -3120 0 0 {name=p126338 lab=_52799_/B }
C {devices/lab_pin.sym} 126880 -3140 0 1 {name=p126339 lab=_49585_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -3140 0 0 {name=X_49585_ }
C {devices/lab_pin.sym} 126760 -3040 0 0 {name=p126340 lab=_61863_/A }
C {devices/lab_pin.sym} 126760 -3000 0 0 {name=p126341 lab=_61857_/Y }
C {devices/lab_pin.sym} 126760 -2960 0 0 {name=p126342 lab=_61860_/Y }
C {devices/lab_pin.sym} 126760 -2920 0 0 {name=p126343 lab=_61862_/Y }
C {devices/lab_pin.sym} 126880 -2980 0 1 {name=p126344 lab=_61863_/Y }
C {sky130_stdcells/nand4_4.sym} 126820 -2980 0 0 {name=X_61863_ }
C {devices/lab_pin.sym} 126740 -2850 0 0 {name=p126345 lab=_86995_/Q }
C {devices/lab_pin.sym} 126740 -2810 0 0 {name=p126346 lab=_73776_/X }
C {devices/lab_pin.sym} 126740 -2770 0 0 {name=p126347 lab=_73848_/X }
C {devices/lab_pin.sym} 126900 -2810 0 1 {name=p126348 lab=_73866_/C }
C {sky130_stdcells/o21ai_4.sym} 126820 -2810 0 0 {name=X_73849_ }
C {devices/lab_pin.sym} 126740 -2690 0 0 {name=p126349 lab=_58807_/A }
C {devices/lab_pin.sym} 126740 -2650 0 0 {name=p126350 lab=_46767_/X }
C {devices/lab_pin.sym} 126740 -2610 0 0 {name=p126351 lab=_46796_/Y }
C {devices/lab_pin.sym} 126900 -2650 0 1 {name=p126352 lab=_46797_/Y }
C {sky130_stdcells/o21ai_4.sym} 126820 -2650 0 0 {name=X_46797_ }
C {devices/lab_pin.sym} 126760 -2540 0 0 {name=p126353 lab=_58446_/A }
C {devices/lab_pin.sym} 126760 -2500 0 0 {name=p126354 lab=_63600_/X }
C {devices/lab_pin.sym} 126760 -2460 0 0 {name=p126355 lab=_63575_/C }
C {devices/lab_pin.sym} 126760 -2420 0 0 {name=p126356 lab=_63661_/D }
C {devices/lab_pin.sym} 126880 -2480 0 1 {name=p126357 lab=_63602_/Y }
C {sky130_stdcells/nand4_4.sym} 126820 -2480 0 0 {name=X_63602_ }
C {devices/lab_pin.sym} 126740 -2370 0 0 {name=p126358 lab=_60707_/X }
C {devices/lab_pin.sym} 126740 -2330 0 0 {name=p126359 lab=_60812_/Y }
C {devices/lab_pin.sym} 126740 -2290 0 0 {name=p126360 lab=_60748_/X }
C {devices/lab_pin.sym} 126740 -2250 0 0 {name=p126361 lab=_60732_/Y }
C {devices/lab_pin.sym} 126740 -2220 0 0 {name=p126362 lab=_60813_/Y }
C {devices/lab_pin.sym} 126900 -2290 0 1 {name=p126363 lab=_84560_/D }
C {sky130_stdcells/a41oi_4.sym} 126820 -2290 0 0 {name=X_60814_ }
C {devices/lab_pin.sym} 126780 -2130 0 0 {name=p126364 lab=_48612_/A }
C {devices/lab_pin.sym} 126860 -2130 0 1 {name=p126365 lab=_48536_/X }
C {sky130_stdcells/buf_2.sym} 126820 -2130 0 0 {name=X_48536_ }
C {devices/lab_pin.sym} 126760 -2020 0 0 {name=p126366 lab=_67320_/A }
C {devices/lab_pin.sym} 126760 -1980 0 0 {name=p126367 lab=_87218_/Q }
C {devices/lab_pin.sym} 126880 -2000 0 1 {name=p126368 lab=_67370_/X }
C {sky130_stdcells/and2_4.sym} 126820 -2000 0 0 {name=X_67370_ }
C {devices/lab_pin.sym} 126740 -1900 0 0 {name=p126369 lab=_79346_/A }
C {devices/lab_pin.sym} 126740 -1860 0 0 {name=p126370 lab=_79346_/B }
C {devices/lab_pin.sym} 126740 -1820 0 0 {name=p126371 lab=_79341_/Y }
C {devices/lab_pin.sym} 126740 -1780 0 0 {name=p126372 lab=_79344_/Y }
C {devices/lab_pin.sym} 126900 -1840 0 1 {name=p126373 lab=_79356_/X }
C {sky130_stdcells/o22a_4.sym} 126820 -1840 0 0 {name=X_79356_ }
C {devices/lab_pin.sym} 126780 -1690 0 0 {name=p126374 lab=_45668_/A }
C {devices/lab_pin.sym} 126860 -1690 0 1 {name=p126375 lab=_45748_/X }
C {sky130_stdcells/buf_2.sym} 126820 -1690 0 0 {name=X_45748_ }
C {devices/lab_pin.sym} 126760 -1580 0 0 {name=p126376 lab=_64582_/A }
C {devices/lab_pin.sym} 126760 -1540 0 0 {name=p126377 lab=_64582_/B }
C {devices/lab_pin.sym} 126880 -1560 0 1 {name=p126378 lab=_64582_/Y }
C {sky130_stdcells/nand2_4.sym} 126820 -1560 0 0 {name=X_64582_ }
C {devices/lab_pin.sym} 126740 -1450 0 0 {name=p126379 lab=_76566_/Y }
C {devices/lab_pin.sym} 126740 -1410 0 0 {name=p126380 lab=_76567_/Y }
C {devices/lab_pin.sym} 126740 -1370 0 0 {name=p126381 lab=_81373_/Q }
C {devices/lab_pin.sym} 126900 -1410 0 1 {name=p126382 lab=_76568_/Y }
C {sky130_stdcells/a21oi_4.sym} 126820 -1410 0 0 {name=X_76568_ }
C {devices/lab_pin.sym} 126760 -1300 0 0 {name=p126383 lab=_61376_/X }
C {devices/lab_pin.sym} 126760 -1260 0 0 {name=p126384 lab=_61794_/B }
C {devices/lab_pin.sym} 126760 -1220 0 0 {name=p126385 lab=_59810_/A }
C {devices/lab_pin.sym} 126760 -1180 0 0 {name=p126386 lab=_61776_/D }
C {devices/lab_pin.sym} 126880 -1240 0 1 {name=p126387 lab=_61794_/Y }
C {sky130_stdcells/nand4_4.sym} 126820 -1240 0 0 {name=X_61794_ }
C {devices/lab_pin.sym} 126780 -1090 0 0 {name=p126388 lab=clkbuf_9_407_0_CLK/X }
C {devices/lab_pin.sym} 126860 -1090 0 1 {name=p126389 lab=_82557_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 126820 -1090 0 0 {name=Xclkbuf_10_814_0_CLK }
C {devices/lab_pin.sym} 126760 -980 0 0 {name=p126390 lab=_66267_/X }
C {devices/lab_pin.sym} 126760 -940 0 0 {name=p126391 lab=_74232_/B }
C {devices/lab_pin.sym} 126880 -960 0 1 {name=p126392 lab=_66321_/X }
C {sky130_stdcells/and2_4.sym} 126820 -960 0 0 {name=X_66321_ }
C {devices/lab_pin.sym} 126760 -840 0 0 {name=p126393 lab=_78309_/A }
C {devices/lab_pin.sym} 126760 -800 0 0 {name=p126394 lab=_78309_/C }
C {devices/lab_pin.sym} 126880 -820 0 1 {name=p126395 lab=_78307_/X }
C {sky130_stdcells/and2_4.sym} 126820 -820 0 0 {name=X_78307_ }
C {devices/lab_pin.sym} 126760 -720 0 0 {name=p126396 lab=_63496_/A }
C {devices/lab_pin.sym} 126760 -680 0 0 {name=p126397 lab=_58528_/A }
C {devices/lab_pin.sym} 126760 -640 0 0 {name=p126398 lab=_63520_/C }
C {devices/lab_pin.sym} 126760 -600 0 0 {name=p126399 lab=_63546_/D }
C {devices/lab_pin.sym} 126880 -660 0 1 {name=p126400 lab=_63533_/X }
C {sky130_stdcells/and4_4.sym} 126820 -660 0 0 {name=X_63533_ }
C {devices/lab_pin.sym} 127680 -42170 0 0 {name=p126401 lab=_75519_/A }
C {devices/lab_pin.sym} 127680 -42130 0 0 {name=p126402 lab=_75516_/Y }
C {devices/lab_pin.sym} 127680 -42090 0 0 {name=p126403 lab=_75519_/C }
C {devices/lab_pin.sym} 127800 -42130 0 1 {name=p126404 lab=_75519_/X }
C {sky130_stdcells/or3_4.sym} 127740 -42130 0 0 {name=X_75519_ }
C {devices/lab_pin.sym} 127700 -41990 0 0 {name=p126405 lab=_83583_/Q }
C {devices/lab_pin.sym} 127780 -41990 0 1 {name=p126406 lab=_74414_/B }
C {sky130_stdcells/inv_2.sym} 127740 -41990 0 0 {name=X_48467_ }
C {devices/lab_pin.sym} 127660 -41910 0 0 {name=p126407 lab=_60671_/C }
C {devices/lab_pin.sym} 127660 -41870 0 0 {name=p126408 lab=_60737_/Y }
C {devices/lab_pin.sym} 127660 -41830 0 0 {name=p126409 lab=_60743_/X }
C {devices/lab_pin.sym} 127660 -41790 0 0 {name=p126410 lab=_60694_/Y }
C {devices/lab_pin.sym} 127660 -41760 0 0 {name=p126411 lab=_60744_/Y }
C {devices/lab_pin.sym} 127820 -41830 0 1 {name=p126412 lab=_84577_/D }
C {sky130_stdcells/a41oi_4.sym} 127740 -41830 0 0 {name=X_60745_ }
C {devices/lab_pin.sym} 127680 -41680 0 0 {name=p126413 lab=_84796_/Q }
C {devices/lab_pin.sym} 127680 -41640 0 0 {name=p126414 lab=_84116_/Q }
C {devices/lab_pin.sym} 127800 -41660 0 1 {name=p126415 lab=_79287_/X }
C {sky130_stdcells/xor2_4.sym} 127740 -41660 0 0 {name=X_79287_ }
C {devices/lab_pin.sym} 127660 -41550 0 0 {name=p126416 lab=_45674_/X }
C {devices/lab_pin.sym} 127660 -41510 0 0 {name=p126417 lab=_45677_/Y }
C {devices/lab_pin.sym} 127660 -41470 0 0 {name=p126418 lab=_45678_/X }
C {devices/lab_pin.sym} 127820 -41510 0 1 {name=p126419 lab=_45679_/X }
C {sky130_stdcells/a21o_4.sym} 127740 -41510 0 0 {name=X_45679_ }
C {devices/lab_pin.sym} 127680 -41380 0 0 {name=p126420 lab=_76497_/X }
C {devices/lab_pin.sym} 127680 -41340 0 0 {name=p126421 lab=_76498_/Y }
C {devices/lab_pin.sym} 127800 -41360 0 1 {name=p126422 lab=_76499_/X }
C {sky130_stdcells/xor2_4.sym} 127740 -41360 0 0 {name=X_76499_ }
C {devices/lab_pin.sym} 127700 -41230 0 0 {name=p126423 lab=clkbuf_8_152_0_CLK/X }
C {devices/lab_pin.sym} 127780 -41230 0 1 {name=p126424 lab=clkbuf_9_305_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 127740 -41230 0 0 {name=Xclkbuf_9_305_0_CLK }
C {devices/lab_pin.sym} 127660 -41140 0 0 {name=p126425 lab=_68929_/X }
C {devices/lab_pin.sym} 127660 -41100 0 0 {name=p126426 lab=_69029_/Y }
C {devices/lab_pin.sym} 127660 -41060 0 0 {name=p126427 lab=_68824_/X }
C {devices/lab_pin.sym} 127660 -41020 0 0 {name=p126428 lab=_69039_/Y }
C {devices/lab_pin.sym} 127820 -41080 0 1 {name=p126429 lab=_69040_/X }
C {sky130_stdcells/a211o_4.sym} 127740 -41080 0 0 {name=X_69040_ }
C {devices/lab_pin.sym} 127680 -40960 0 0 {name=p126430 lab=_47418_/A }
C {devices/lab_pin.sym} 127680 -40920 0 0 {name=p126431 lab=_47415_/X }
C {devices/lab_pin.sym} 127680 -40880 0 0 {name=p126432 lab=_47377_/X }
C {devices/lab_pin.sym} 127680 -40840 0 0 {name=p126433 lab=_53036_/D }
C {devices/lab_pin.sym} 127800 -40900 0 1 {name=p126434 lab=_47418_/X }
C {sky130_stdcells/and4_4.sym} 127740 -40900 0 0 {name=X_47418_ }
C {devices/lab_pin.sym} 127680 -40760 0 0 {name=p126435 lab=_66237_/X }
C {devices/lab_pin.sym} 127680 -40720 0 0 {name=p126436 lab=_74129_/B }
C {devices/lab_pin.sym} 127800 -40740 0 1 {name=p126437 lab=_66252_/X }
C {sky130_stdcells/and2_4.sym} 127740 -40740 0 0 {name=X_66252_ }
C {devices/lab_pin.sym} 127680 -40620 0 0 {name=p126438 lab=_78234_/Y }
C {devices/lab_pin.sym} 127680 -40580 0 0 {name=p126439 lab=_78237_/X }
C {devices/lab_pin.sym} 127800 -40600 0 1 {name=p126440 lab=_78239_/B }
C {sky130_stdcells/nand2_4.sym} 127740 -40600 0 0 {name=X_78238_ }
C {devices/lab_pin.sym} 127660 -40500 0 0 {name=p126441 lab=_61427_/B }
C {devices/lab_pin.sym} 127660 -40460 0 0 {name=p126442 lab=_63426_/X }
C {devices/lab_pin.sym} 127660 -40420 0 0 {name=p126443 lab=_63462_/X }
C {devices/lab_pin.sym} 127660 -40380 0 0 {name=p126444 lab=_63463_/X }
C {devices/lab_pin.sym} 127820 -40440 0 1 {name=p126445 lab=_63464_/X }
C {sky130_stdcells/a211o_4.sym} 127740 -40440 0 0 {name=X_63464_ }
C {devices/lab_pin.sym} 127700 -40290 0 0 {name=p126446 lab=_60632_/A }
C {devices/lab_pin.sym} 127780 -40290 0 1 {name=p126447 lab=_60677_/A }
C {sky130_stdcells/inv_2.sym} 127740 -40290 0 0 {name=X_60676_ }
C {devices/lab_pin.sym} 127660 -40190 0 0 {name=p126448 lab=_48393_/Y }
C {devices/lab_pin.sym} 127660 -40150 0 0 {name=p126449 lab=_48383_/X }
C {devices/lab_pin.sym} 127660 -40110 0 0 {name=p126450 lab=_48397_/X }
C {devices/lab_pin.sym} 127820 -40150 0 1 {name=p126451 lab=_86526_/D }
C {sky130_stdcells/a21oi_4.sym} 127740 -40150 0 0 {name=X_48398_ }
C {devices/lab_pin.sym} 127680 -40020 0 0 {name=p126452 lab=_65227_/A }
C {devices/lab_pin.sym} 127680 -39980 0 0 {name=p126453 lab=_86250_/Q }
C {devices/lab_pin.sym} 127800 -40000 0 1 {name=p126454 lab=_65203_/X }
C {sky130_stdcells/and2_4.sym} 127740 -40000 0 0 {name=X_65203_ }
C {devices/lab_pin.sym} 127700 -39870 0 0 {name=p126455 lab=_62269_/A }
C {devices/lab_pin.sym} 127780 -39870 0 1 {name=p126456 lab=_62415_/X }
C {sky130_stdcells/buf_2.sym} 127740 -39870 0 0 {name=X_62415_ }
C {devices/lab_pin.sym} 127680 -39780 0 0 {name=p126457 lab=_47380_/A }
C {devices/lab_pin.sym} 127680 -39740 0 0 {name=p126458 lab=_47349_/B }
C {devices/lab_pin.sym} 127680 -39700 0 0 {name=p126459 lab=_47370_/C }
C {devices/lab_pin.sym} 127680 -39660 0 0 {name=p126460 lab=_52997_/D }
C {devices/lab_pin.sym} 127800 -39720 0 1 {name=p126461 lab=_47349_/X }
C {sky130_stdcells/and4_4.sym} 127740 -39720 0 0 {name=X_47349_ }
C {devices/lab_pin.sym} 127680 -39580 0 0 {name=p126462 lab=_66054_/X }
C {devices/lab_pin.sym} 127680 -39540 0 0 {name=p126463 lab=_66183_/B }
C {devices/lab_pin.sym} 127800 -39560 0 1 {name=p126464 lab=_66183_/X }
C {sky130_stdcells/and2_4.sym} 127740 -39560 0 0 {name=X_66183_ }
C {devices/lab_pin.sym} 127680 -39440 0 0 {name=p126465 lab=_78177_/A }
C {devices/lab_pin.sym} 127680 -39400 0 0 {name=p126466 lab=_78177_/B }
C {devices/lab_pin.sym} 127800 -39420 0 1 {name=p126467 lab=_78172_/A }
C {sky130_stdcells/xor2_4.sym} 127740 -39420 0 0 {name=X_78169_ }
C {devices/lab_pin.sym} 127700 -39290 0 0 {name=p126468 lab=_63458_/A }
C {devices/lab_pin.sym} 127780 -39290 0 1 {name=p126469 lab=_63410_/C }
C {sky130_stdcells/buf_2.sym} 127740 -39290 0 0 {name=X_63395_ }
C {devices/lab_pin.sym} 127700 -39170 0 0 {name=p126470 lab=clkbuf_9_414_0_CLK/X }
C {devices/lab_pin.sym} 127780 -39170 0 1 {name=p126471 lab=_86582_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 127740 -39170 0 0 {name=Xclkbuf_10_829_0_CLK }
C {devices/lab_pin.sym} 127660 -39070 0 0 {name=p126472 lab=_80184_/Y }
C {devices/lab_pin.sym} 127660 -39030 0 0 {name=p126473 lab=_80187_/Y }
C {devices/lab_pin.sym} 127660 -38990 0 0 {name=p126474 lab=_80199_/X }
C {devices/lab_pin.sym} 127820 -39030 0 1 {name=p126475 lab=_80200_/X }
C {sky130_stdcells/a21o_4.sym} 127740 -39030 0 0 {name=X_80200_ }
C {devices/lab_pin.sym} 127660 -38910 0 0 {name=p126476 lab=_65131_/X }
C {devices/lab_pin.sym} 127660 -38870 0 0 {name=p126477 lab=_65133_/X }
C {devices/lab_pin.sym} 127660 -38830 0 0 {name=p126478 lab=_64959_/X }
C {devices/lab_pin.sym} 127820 -38870 0 1 {name=p126479 lab=_65134_/X }
C {sky130_stdcells/a21o_4.sym} 127740 -38870 0 0 {name=X_65134_ }
C {devices/lab_pin.sym} 127680 -38750 0 0 {name=p126480 lab=_50360_/A }
C {devices/lab_pin.sym} 127680 -38710 0 0 {name=p126481 lab=_50331_/B }
C {devices/lab_pin.sym} 127680 -38670 0 0 {name=p126482 lab=_50338_/X }
C {devices/lab_pin.sym} 127800 -38710 0 1 {name=p126483 lab=_50360_/X }
C {sky130_stdcells/and3_4.sym} 127740 -38710 0 0 {name=X_50360_ }
C {devices/lab_pin.sym} 127680 -38600 0 0 {name=p126484 lab=_62288_/X }
C {devices/lab_pin.sym} 127680 -38560 0 0 {name=p126485 lab=_62285_/X }
C {devices/lab_pin.sym} 127680 -38520 0 0 {name=p126486 lab=_64320_/B }
C {devices/lab_pin.sym} 127680 -38480 0 0 {name=p126487 lab=_62609_/D }
C {devices/lab_pin.sym} 127800 -38540 0 1 {name=p126488 lab=_62346_/X }
C {sky130_stdcells/and4_4.sym} 127740 -38540 0 0 {name=X_62346_ }
C {devices/lab_pin.sym} 127650 -38390 0 0 {name=p126489 lab=_81197_/CLK }
C {devices/lab_pin.sym} 127650 -38370 0 0 {name=p126490 lab=_75036_/X }
C {devices/lab_pin.sym} 127830 -38390 0 1 {name=p126491 lab=_81180_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -38380 0 0 {name=X_81180_ }
C {devices/lab_pin.sym} 127680 -38260 0 0 {name=p126492 lab=_49019_/A }
C {devices/lab_pin.sym} 127680 -38220 0 0 {name=p126493 lab=_49009_/B }
C {devices/lab_pin.sym} 127800 -38240 0 1 {name=p126494 lab=_49019_/Y }
C {sky130_stdcells/nor2_4.sym} 127740 -38240 0 0 {name=X_49019_ }
C {devices/lab_pin.sym} 127660 -38130 0 0 {name=p126495 lab=_80125_/A }
C {devices/lab_pin.sym} 127660 -38090 0 0 {name=p126496 lab=_80124_/X }
C {devices/lab_pin.sym} 127660 -38050 0 0 {name=p126497 lab=_80130_/Y }
C {devices/lab_pin.sym} 127820 -38090 0 1 {name=p126498 lab=_80131_/Y }
C {sky130_stdcells/a21boi_4.sym} 127740 -38090 0 0 {name=X_80131_ }
C {devices/lab_pin.sym} 127700 -37950 0 0 {name=p126499 lab=_64809_/A }
C {devices/lab_pin.sym} 127780 -37950 0 1 {name=p126500 lab=_65065_/X }
C {sky130_stdcells/buf_2.sym} 127740 -37950 0 0 {name=X_65065_ }
C {devices/lab_pin.sym} 127660 -37850 0 0 {name=p126501 lab=_81957_/D }
C {devices/lab_pin.sym} 127660 -37810 0 0 {name=p126502 lab=_69894_/X }
C {devices/lab_pin.sym} 127660 -37770 0 0 {name=p126503 lab=_69941_/X }
C {devices/lab_pin.sym} 127820 -37810 0 1 {name=p126504 lab=_83885_/D }
C {sky130_stdcells/a21bo_4.sym} 127740 -37810 0 0 {name=X_69942_ }
C {devices/lab_pin.sym} 127680 -37680 0 0 {name=p126505 lab=_50279_/X }
C {devices/lab_pin.sym} 127680 -37640 0 0 {name=p126506 lab=_53516_/B }
C {devices/lab_pin.sym} 127800 -37660 0 1 {name=p126507 lab=_50291_/Y }
C {sky130_stdcells/nand2_4.sym} 127740 -37660 0 0 {name=X_50291_ }
C {devices/lab_pin.sym} 127700 -37530 0 0 {name=p126508 lab=_62276_/X }
C {devices/lab_pin.sym} 127780 -37530 0 1 {name=p126509 lab=_62623_/C }
C {sky130_stdcells/buf_2.sym} 127740 -37530 0 0 {name=X_62277_ }
C {devices/lab_pin.sym} 127660 -37430 0 0 {name=p126510 lab=_52028_/Y }
C {devices/lab_pin.sym} 127660 -37390 0 0 {name=p126511 lab=_52022_/X }
C {devices/lab_pin.sym} 127660 -37350 0 0 {name=p126512 lab=_52029_/Y }
C {devices/lab_pin.sym} 127820 -37390 0 1 {name=p126513 lab=_52030_/Y }
C {sky130_stdcells/a21boi_4.sym} 127740 -37390 0 0 {name=X_52030_ }
C {devices/lab_pin.sym} 127680 -37280 0 0 {name=p126514 lab=_83248_/Q }
C {devices/lab_pin.sym} 127680 -37240 0 0 {name=p126515 lab=_64046_/B }
C {devices/lab_pin.sym} 127680 -37200 0 0 {name=p126516 lab=_64046_/C }
C {devices/lab_pin.sym} 127680 -37160 0 0 {name=p126517 lab=_64016_/D }
C {devices/lab_pin.sym} 127800 -37220 0 1 {name=p126518 lab=_64017_/D }
C {sky130_stdcells/nand4_4.sym} 127740 -37220 0 0 {name=X_64016_ }
C {devices/lab_pin.sym} 127680 -37080 0 0 {name=p126519 lab=_80058_/X }
C {devices/lab_pin.sym} 127680 -37040 0 0 {name=p126520 lab=_80074_/B }
C {devices/lab_pin.sym} 127800 -37060 0 1 {name=p126521 lab=_80073_/A }
C {sky130_stdcells/xor2_4.sym} 127740 -37060 0 0 {name=X_80062_ }
C {devices/lab_pin.sym} 127680 -36950 0 0 {name=p126522 lab=_61234_/A }
C {devices/lab_pin.sym} 127680 -36910 0 0 {name=p126523 lab=_61250_/B }
C {devices/lab_pin.sym} 127680 -36870 0 0 {name=p126524 lab=_84503_/Q }
C {devices/lab_pin.sym} 127800 -36910 0 1 {name=p126525 lab=_61228_/Y }
C {sky130_stdcells/nor3_4.sym} 127740 -36910 0 0 {name=X_61228_ }
C {devices/lab_pin.sym} 127700 -36770 0 0 {name=p126526 lab=_87292_/Q }
C {devices/lab_pin.sym} 127780 -36770 0 1 {name=p126527 lab=_69873_/Y }
C {sky130_stdcells/inv_2.sym} 127740 -36770 0 0 {name=X_69873_ }
C {devices/lab_pin.sym} 127700 -36650 0 0 {name=p126528 lab=clkbuf_4_2_1_CLK/X }
C {devices/lab_pin.sym} 127780 -36650 0 1 {name=p126529 lab=clkbuf_5_5_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 127740 -36650 0 0 {name=Xclkbuf_5_5_0_CLK }
C {devices/lab_pin.sym} 127700 -36530 0 0 {name=p126530 lab=_68649_/A }
C {devices/lab_pin.sym} 127780 -36530 0 1 {name=p126531 lab=_68824_/X }
C {sky130_stdcells/buf_2.sym} 127740 -36530 0 0 {name=X_68824_ }
C {devices/lab_pin.sym} 127700 -36410 0 0 {name=p126532 lab=_61082_/X }
C {devices/lab_pin.sym} 127780 -36410 0 1 {name=p126533 lab=_64456_/C }
C {sky130_stdcells/buf_2.sym} 127740 -36410 0 0 {name=X_61159_ }
C {devices/lab_pin.sym} 127650 -36290 0 0 {name=p126534 lab=_84892_/CLK }
C {devices/lab_pin.sym} 127650 -36270 0 0 {name=p126535 lab=_84870_/D }
C {devices/lab_pin.sym} 127830 -36290 0 1 {name=p126536 lab=_84870_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -36280 0 0 {name=X_84870_ }
C {devices/lab_pin.sym} 127650 -36150 0 0 {name=p126537 lab=_83819_/CLK }
C {devices/lab_pin.sym} 127650 -36130 0 0 {name=p126538 lab=_70257_/X }
C {devices/lab_pin.sym} 127830 -36150 0 1 {name=p126539 lab=_74771_/A }
C {sky130_stdcells/dfxtp_4.sym} 127740 -36140 0 0 {name=X_83821_ }
C {devices/lab_pin.sym} 127680 -36020 0 0 {name=p126540 lab=_68779_/A }
C {devices/lab_pin.sym} 127680 -35980 0 0 {name=p126541 lab=_68755_/B }
C {devices/lab_pin.sym} 127800 -36000 0 1 {name=p126542 lab=_68755_/X }
C {sky130_stdcells/and2_4.sym} 127740 -36000 0 0 {name=X_68755_ }
C {devices/lab_pin.sym} 127660 -35890 0 0 {name=p126543 lab=_85529_/Q }
C {devices/lab_pin.sym} 127660 -35850 0 0 {name=p126544 lab=_53955_/X }
C {devices/lab_pin.sym} 127660 -35810 0 0 {name=p126545 lab=_53980_/Y }
C {devices/lab_pin.sym} 127820 -35850 0 1 {name=p126546 lab=_53981_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -35850 0 0 {name=X_53981_ }
C {devices/lab_pin.sym} 127680 -35730 0 0 {name=p126547 lab=_65962_/X }
C {devices/lab_pin.sym} 127680 -35690 0 0 {name=p126548 lab=_65967_/B }
C {devices/lab_pin.sym} 127680 -35650 0 0 {name=p126549 lab=_65966_/X }
C {devices/lab_pin.sym} 127800 -35690 0 1 {name=p126550 lab=_65967_/Y }
C {sky130_stdcells/nand3_4.sym} 127740 -35690 0 0 {name=X_65967_ }
C {devices/lab_pin.sym} 127700 -35550 0 0 {name=p126551 lab=_55276_/A }
C {devices/lab_pin.sym} 127780 -35550 0 1 {name=p126552 lab=_55794_/A }
C {sky130_stdcells/buf_2.sym} 127740 -35550 0 0 {name=X_55720_ }
C {devices/lab_pin.sym} 127650 -35430 0 0 {name=p126553 lab=_86570_/CLK }
C {devices/lab_pin.sym} 127650 -35410 0 0 {name=p126554 lab=_86540_/D }
C {devices/lab_pin.sym} 127830 -35430 0 1 {name=p126555 lab=_66214_/B }
C {sky130_stdcells/dfxtp_4.sym} 127740 -35420 0 0 {name=X_86540_ }
C {devices/lab_pin.sym} 127700 -35290 0 0 {name=p126556 lab=_67466_/X }
C {devices/lab_pin.sym} 127780 -35290 0 1 {name=p126557 lab=_67706_/X }
C {sky130_stdcells/buf_2.sym} 127740 -35290 0 0 {name=X_67706_ }
C {devices/lab_pin.sym} 127660 -35190 0 0 {name=p126558 lab=_85728_/Q }
C {devices/lab_pin.sym} 127660 -35150 0 0 {name=p126559 lab=_52929_/X }
C {devices/lab_pin.sym} 127660 -35110 0 0 {name=p126560 lab=_52931_/Y }
C {devices/lab_pin.sym} 127820 -35150 0 1 {name=p126561 lab=_52932_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -35150 0 0 {name=X_52932_ }
C {devices/lab_pin.sym} 127700 -35010 0 0 {name=p126562 lab=_44175_/A }
C {devices/lab_pin.sym} 127780 -35010 0 1 {name=p126563 lab=_65669_/A }
C {sky130_stdcells/buf_2.sym} 127740 -35010 0 0 {name=X_64918_ }
C {devices/lab_pin.sym} 127650 -34890 0 0 {name=p126564 lab=_84280_/CLK }
C {devices/lab_pin.sym} 127650 -34870 0 0 {name=p126565 lab=_70546_/X }
C {devices/lab_pin.sym} 127830 -34890 0 1 {name=p126566 lab=_83752_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -34880 0 0 {name=X_83752_ }
C {devices/lab_pin.sym} 127680 -34760 0 0 {name=p126567 lab=_68735_/A }
C {devices/lab_pin.sym} 127680 -34720 0 0 {name=p126568 lab=_68686_/B }
C {devices/lab_pin.sym} 127800 -34740 0 1 {name=p126569 lab=_68686_/X }
C {sky130_stdcells/and2_4.sym} 127740 -34740 0 0 {name=X_68686_ }
C {devices/lab_pin.sym} 127650 -34610 0 0 {name=p126570 lab=_81990_/CLK }
C {devices/lab_pin.sym} 127650 -34590 0 0 {name=p126571 lab=_75597_/X }
C {devices/lab_pin.sym} 127830 -34610 0 1 {name=p126572 lab=_75393_/B }
C {sky130_stdcells/dfxtp_4.sym} 127740 -34600 0 0 {name=X_80964_ }
C {devices/lab_pin.sym} 127680 -34490 0 0 {name=p126573 lab=_65894_/X }
C {devices/lab_pin.sym} 127680 -34450 0 0 {name=p126574 lab=_65868_/B }
C {devices/lab_pin.sym} 127680 -34410 0 0 {name=p126575 lab=_65897_/X }
C {devices/lab_pin.sym} 127800 -34450 0 1 {name=p126576 lab=_65898_/Y }
C {sky130_stdcells/nand3_4.sym} 127740 -34450 0 0 {name=X_65898_ }
C {devices/lab_pin.sym} 127650 -34310 0 0 {name=p126577 lab=_82610_/CLK }
C {devices/lab_pin.sym} 127650 -34290 0 0 {name=p126578 lab=_82703_/D }
C {devices/lab_pin.sym} 127830 -34310 0 1 {name=p126579 lab=_82659_/D }
C {sky130_stdcells/dfxtp_4.sym} 127740 -34300 0 0 {name=X_82703_ }
C {devices/lab_pin.sym} 127700 -34170 0 0 {name=p126580 lab=_74539_/A }
C {devices/lab_pin.sym} 127780 -34170 0 1 {name=p126581 lab=_56171_/A }
C {sky130_stdcells/buf_2.sym} 127740 -34170 0 0 {name=X_55651_ }
C {devices/lab_pin.sym} 127700 -34050 0 0 {name=p126582 lab=_68129_/A }
C {devices/lab_pin.sym} 127780 -34050 0 1 {name=p126583 lab=_67637_/X }
C {sky130_stdcells/buf_2.sym} 127740 -34050 0 0 {name=X_67637_ }
C {devices/lab_pin.sym} 127650 -33930 0 0 {name=p126584 lab=_86471_/CLK }
C {devices/lab_pin.sym} 127650 -33910 0 0 {name=p126585 lab=_48850_/Y }
C {devices/lab_pin.sym} 127830 -33930 0 1 {name=p126586 lab=_86471_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -33920 0 0 {name=X_86471_ }
C {devices/lab_pin.sym} 127680 -33800 0 0 {name=p126587 lab=_52850_/A }
C {devices/lab_pin.sym} 127680 -33760 0 0 {name=p126588 lab=_52863_/B }
C {devices/lab_pin.sym} 127800 -33780 0 1 {name=p126589 lab=_52863_/Y }
C {sky130_stdcells/nand2_4.sym} 127740 -33780 0 0 {name=X_52863_ }
C {devices/lab_pin.sym} 127660 -33680 0 0 {name=p126590 lab=_64846_/X }
C {devices/lab_pin.sym} 127660 -33640 0 0 {name=p126591 lab=_85560_/Q }
C {devices/lab_pin.sym} 127660 -33600 0 0 {name=p126592 lab=_64642_/X }
C {devices/lab_pin.sym} 127660 -33560 0 0 {name=p126593 lab=_64848_/X }
C {devices/lab_pin.sym} 127820 -33620 0 1 {name=p126594 lab=_64849_/X }
C {sky130_stdcells/a211o_4.sym} 127740 -33620 0 0 {name=X_64849_ }
C {devices/lab_pin.sym} 127650 -33470 0 0 {name=p126595 lab=_85786_/CLK }
C {devices/lab_pin.sym} 127650 -33450 0 0 {name=p126596 lab=_70850_/Y }
C {devices/lab_pin.sym} 127830 -33470 0 1 {name=p126597 lab=_83683_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -33460 0 0 {name=X_83683_ }
C {devices/lab_pin.sym} 127650 -33330 0 0 {name=p126598 lab=_83967_/CLK }
C {devices/lab_pin.sym} 127650 -33310 0 0 {name=p126599 lab=_80895_/D }
C {devices/lab_pin.sym} 127830 -33330 0 1 {name=p126600 lab=_80895_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -33320 0 0 {name=X_80895_ }
C {devices/lab_pin.sym} 127650 -33190 0 0 {name=p126601 lab=_87888_/CLK }
C {devices/lab_pin.sym} 127650 -33170 0 0 {name=p126602 lab=_41466_/X }
C {devices/lab_pin.sym} 127830 -33190 0 1 {name=p126603 lab=_88210_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -33180 0 0 {name=X_88210_ }
C {devices/lab_pin.sym} 127700 -33050 0 0 {name=p126604 lab=_54521_/A }
C {devices/lab_pin.sym} 127780 -33050 0 1 {name=p126605 lab=_54607_/B }
C {sky130_stdcells/buf_2.sym} 127740 -33050 0 0 {name=X_54602_ }
C {devices/lab_pin.sym} 127650 -32930 0 0 {name=p126606 lab=_85648_/CLK }
C {devices/lab_pin.sym} 127650 -32910 0 0 {name=p126607 lab=_85422_/D }
C {devices/lab_pin.sym} 127830 -32930 0 1 {name=p126608 lab=_85422_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -32920 0 0 {name=X_85422_ }
C {devices/lab_pin.sym} 127700 -32790 0 0 {name=p126609 lab=_51814_/A }
C {devices/lab_pin.sym} 127780 -32790 0 1 {name=p126610 lab=_51815_/B }
C {sky130_stdcells/buf_2.sym} 127740 -32790 0 0 {name=X_51814_ }
C {devices/lab_pin.sym} 127650 -32670 0 0 {name=p126611 lab=_87926_/CLK }
C {devices/lab_pin.sym} 127650 -32650 0 0 {name=p126612 lab=_83986_/Q }
C {devices/lab_pin.sym} 127830 -32670 0 1 {name=p126613 lab=_78870_/A }
C {sky130_stdcells/dfxtp_4.sym} 127740 -32660 0 0 {name=X_82634_ }
C {devices/lab_pin.sym} 127680 -32540 0 0 {name=p126614 lab=_58370_/A }
C {devices/lab_pin.sym} 127680 -32500 0 0 {name=p126615 lab=_58369_/X }
C {devices/lab_pin.sym} 127800 -32520 0 1 {name=p126616 lab=_58370_/Y }
C {sky130_stdcells/nand2_4.sym} 127740 -32520 0 0 {name=X_58370_ }
C {devices/lab_pin.sym} 127680 -32400 0 0 {name=p126617 lab=_55572_/X }
C {devices/lab_pin.sym} 127680 -32360 0 0 {name=p126618 lab=_45455_/Y }
C {devices/lab_pin.sym} 127800 -32380 0 1 {name=p126619 lab=_55582_/Y }
C {sky130_stdcells/nor2_4.sym} 127740 -32380 0 0 {name=X_55582_ }
C {devices/lab_pin.sym} 127700 -32250 0 0 {name=p126620 lab=_67806_/A }
C {devices/lab_pin.sym} 127780 -32250 0 1 {name=p126621 lab=_67568_/X }
C {sky130_stdcells/buf_2.sym} 127740 -32250 0 0 {name=X_67568_ }
C {devices/lab_pin.sym} 127680 -32140 0 0 {name=p126622 lab=_52803_/A }
C {devices/lab_pin.sym} 127680 -32100 0 0 {name=p126623 lab=_52794_/B }
C {devices/lab_pin.sym} 127800 -32120 0 1 {name=p126624 lab=_52794_/Y }
C {sky130_stdcells/nand2_4.sym} 127740 -32120 0 0 {name=X_52794_ }
C {devices/lab_pin.sym} 127660 -32010 0 0 {name=p126625 lab=_45909_/A }
C {devices/lab_pin.sym} 127660 -31970 0 0 {name=p126626 lab=_45738_/Y }
C {devices/lab_pin.sym} 127660 -31930 0 0 {name=p126627 lab=_57320_/X }
C {devices/lab_pin.sym} 127820 -31970 0 1 {name=p126628 lab=_57321_/X }
C {sky130_stdcells/o21a_4.sym} 127740 -31970 0 0 {name=X_57321_ }
C {devices/lab_pin.sym} 127660 -31850 0 0 {name=p126629 lab=_69303_/X }
C {devices/lab_pin.sym} 127660 -31810 0 0 {name=p126630 lab=_69306_/X }
C {devices/lab_pin.sym} 127660 -31770 0 0 {name=p126631 lab=_69116_/X }
C {devices/lab_pin.sym} 127820 -31810 0 1 {name=p126632 lab=_69307_/X }
C {sky130_stdcells/a21o_4.sym} 127740 -31810 0 0 {name=X_69307_ }
C {devices/lab_pin.sym} 127650 -31670 0 0 {name=p126633 lab=_87373_/CLK }
C {devices/lab_pin.sym} 127650 -31650 0 0 {name=p126634 lab=_41810_/X }
C {devices/lab_pin.sym} 127830 -31670 0 1 {name=p126635 lab=_88141_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -31660 0 0 {name=X_88141_ }
C {devices/lab_pin.sym} 127680 -31540 0 0 {name=p126636 lab=_54518_/A }
C {devices/lab_pin.sym} 127680 -31500 0 0 {name=p126637 lab=_53360_/B }
C {devices/lab_pin.sym} 127800 -31520 0 1 {name=p126638 lab=_54533_/Y }
C {sky130_stdcells/nand2_4.sym} 127740 -31520 0 0 {name=X_54533_ }
C {devices/lab_pin.sym} 127660 -31410 0 0 {name=p126639 lab=_66517_/Y }
C {devices/lab_pin.sym} 127660 -31370 0 0 {name=p126640 lab=_66518_/Y }
C {devices/lab_pin.sym} 127660 -31330 0 0 {name=p126641 lab=_60529_/A }
C {devices/lab_pin.sym} 127820 -31370 0 1 {name=p126642 lab=_66519_/X }
C {sky130_stdcells/a21o_4.sym} 127740 -31370 0 0 {name=X_66519_ }
C {devices/lab_pin.sym} 127650 -31230 0 0 {name=p126643 lab=_86600_/CLK }
C {devices/lab_pin.sym} 127650 -31210 0 0 {name=p126644 lab=_54923_/Y }
C {devices/lab_pin.sym} 127830 -31230 0 1 {name=p126645 lab=_85353_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -31220 0 0 {name=X_85353_ }
C {sky130_stdcells/decap_3.sym} 127740 -31060 0 0 {name=XPHY_12 }
C {devices/lab_pin.sym} 127660 -30930 0 0 {name=p126646 lab=_85953_/Q }
C {devices/lab_pin.sym} 127660 -30890 0 0 {name=p126647 lab=_51387_/X }
C {devices/lab_pin.sym} 127660 -30850 0 0 {name=p126648 lab=_51744_/Y }
C {devices/lab_pin.sym} 127820 -30890 0 1 {name=p126649 lab=_51745_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -30890 0 0 {name=X_51745_ }
C {devices/lab_pin.sym} 127650 -30750 0 0 {name=p126650 lab=_82942_/CLK }
C {devices/lab_pin.sym} 127650 -30730 0 0 {name=p126651 lab=_82565_/D }
C {devices/lab_pin.sym} 127830 -30750 0 1 {name=p126652 lab=_82565_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -30740 0 0 {name=X_82565_ }
C {sky130_stdcells/decap_3.sym} 127740 -30580 0 0 {name=XPHY_23 }
C {devices/lab_pin.sym} 127700 -30430 0 0 {name=p126653 lab=_67144_/A }
C {devices/lab_pin.sym} 127780 -30430 0 1 {name=p126654 lab=_67572_/A }
C {sky130_stdcells/buf_2.sym} 127740 -30430 0 0 {name=X_67499_ }
C {sky130_stdcells/decap_3.sym} 127740 -30280 0 0 {name=XPHY_34 }
C {sky130_stdcells/decap_3.sym} 127740 -30100 0 0 {name=XPHY_45 }
C {devices/lab_pin.sym} 127650 -29950 0 0 {name=p126655 lab=_84358_/CLK }
C {devices/lab_pin.sym} 127650 -29930 0 0 {name=p126656 lab=_63664_/Y }
C {devices/lab_pin.sym} 127830 -29950 0 1 {name=p126657 lab=_80357_/B }
C {sky130_stdcells/dfxtp_4.sym} 127740 -29940 0 0 {name=X_84304_ }
C {devices/lab_pin.sym} 127660 -29840 0 0 {name=p126658 lab=_57243_/X }
C {devices/lab_pin.sym} 127660 -29800 0 0 {name=p126659 lab=_56607_/X }
C {devices/lab_pin.sym} 127660 -29760 0 0 {name=p126660 lab=_45504_/A }
C {devices/lab_pin.sym} 127660 -29720 0 0 {name=p126661 lab=_57245_/X }
C {devices/lab_pin.sym} 127820 -29780 0 1 {name=p126662 lab=_85050_/D }
C {sky130_stdcells/a2bb2o_4.sym} 127740 -29780 0 0 {name=X_57252_ }
C {devices/lab_pin.sym} 127650 -29630 0 0 {name=p126663 lab=_81755_/CLK }
C {devices/lab_pin.sym} 127650 -29610 0 0 {name=p126664 lab=_81560_/Q }
C {devices/lab_pin.sym} 127830 -29630 0 1 {name=p126665 lab=_81516_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -29620 0 0 {name=X_81516_ }
C {devices/lab_pin.sym} 127660 -29510 0 0 {name=p126666 lab=_69235_/X }
C {devices/lab_pin.sym} 127660 -29470 0 0 {name=p126667 lab=_69237_/X }
C {devices/lab_pin.sym} 127660 -29430 0 0 {name=p126668 lab=_69138_/X }
C {devices/lab_pin.sym} 127820 -29470 0 1 {name=p126669 lab=_69238_/X }
C {sky130_stdcells/a21o_4.sym} 127740 -29470 0 0 {name=X_69238_ }
C {sky130_stdcells/decap_3.sym} 127740 -29300 0 0 {name=XPHY_56 }
C {devices/lab_pin.sym} 127650 -29150 0 0 {name=p126670 lab=_87821_/CLK }
C {devices/lab_pin.sym} 127650 -29130 0 0 {name=p126671 lab=_42012_/Y }
C {devices/lab_pin.sym} 127830 -29150 0 1 {name=p126672 lab=_88072_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -29140 0 0 {name=X_88072_ }
C {devices/lab_pin.sym} 127680 -29020 0 0 {name=p126673 lab=_54478_/A }
C {devices/lab_pin.sym} 127680 -28980 0 0 {name=p126674 lab=_54464_/B }
C {devices/lab_pin.sym} 127800 -29000 0 1 {name=p126675 lab=_54464_/Y }
C {sky130_stdcells/nand2_4.sym} 127740 -29000 0 0 {name=X_54464_ }
C {devices/lab_pin.sym} 127650 -28870 0 0 {name=p126676 lab=_83013_/CLK }
C {devices/lab_pin.sym} 127650 -28850 0 0 {name=p126677 lab=_85284_/D }
C {devices/lab_pin.sym} 127830 -28870 0 1 {name=p126678 lab=_56165_/C }
C {sky130_stdcells/dfxtp_4.sym} 127740 -28860 0 0 {name=X_85284_ }
C {sky130_stdcells/decap_3.sym} 127740 -28700 0 0 {name=XPHY_67 }
C {devices/lab_pin.sym} 127700 -28550 0 0 {name=p126679 lab=_50222_/X }
C {devices/lab_pin.sym} 127780 -28550 0 1 {name=p126680 lab=_51697_/A }
C {sky130_stdcells/buf_2.sym} 127740 -28550 0 0 {name=X_51676_ }
C {devices/lab_pin.sym} 127650 -28430 0 0 {name=p126681 lab=_82671_/CLK }
C {devices/lab_pin.sym} 127650 -28410 0 0 {name=p126682 lab=_82496_/D }
C {devices/lab_pin.sym} 127830 -28430 0 1 {name=p126683 lab=_82496_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -28420 0 0 {name=X_82496_ }
C {sky130_stdcells/decap_3.sym} 127740 -28260 0 0 {name=XPHY_78 }
C {sky130_stdcells/decap_3.sym} 127740 -28080 0 0 {name=XPHY_89 }
C {devices/lab_pin.sym} 127680 -27950 0 0 {name=p126684 lab=_56200_/X }
C {devices/lab_pin.sym} 127680 -27910 0 0 {name=p126685 lab=_56192_/B }
C {devices/lab_pin.sym} 127680 -27870 0 0 {name=p126686 lab=_56203_/C }
C {devices/lab_pin.sym} 127800 -27910 0 1 {name=p126687 lab=_56203_/Y }
C {sky130_stdcells/nand3_4.sym} 127740 -27910 0 0 {name=X_56203_ }
C {devices/lab_pin.sym} 127650 -27770 0 0 {name=p126688 lab=_88301_/CLK }
C {devices/lab_pin.sym} 127650 -27750 0 0 {name=p126689 lab=_87023_/D }
C {devices/lab_pin.sym} 127830 -27770 0 1 {name=p126690 lab=_87023_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -27760 0 0 {name=X_87023_ }
C {devices/lab_pin.sym} 127660 -27650 0 0 {name=p126691 lab=_53413_/Y }
C {devices/lab_pin.sym} 127660 -27610 0 0 {name=p126692 lab=_53408_/X }
C {devices/lab_pin.sym} 127660 -27570 0 0 {name=p126693 lab=_53414_/X }
C {devices/lab_pin.sym} 127820 -27610 0 1 {name=p126694 lab=_53415_/Y }
C {sky130_stdcells/a21oi_4.sym} 127740 -27610 0 0 {name=X_53415_ }
C {devices/lab_pin.sym} 127650 -27470 0 0 {name=p126695 lab=_82786_/CLK }
C {devices/lab_pin.sym} 127650 -27450 0 0 {name=p126696 lab=_84235_/D }
C {devices/lab_pin.sym} 127830 -27470 0 1 {name=p126697 lab=_64542_/A }
C {sky130_stdcells/dfxtp_4.sym} 127740 -27460 0 0 {name=X_84235_ }
C {devices/lab_pin.sym} 127700 -27330 0 0 {name=p126698 lab=_50596_/A }
C {devices/lab_pin.sym} 127780 -27330 0 1 {name=p126699 lab=_50627_/X }
C {sky130_stdcells/buf_2.sym} 127740 -27330 0 0 {name=X_50627_ }
C {devices/lab_pin.sym} 127650 -27210 0 0 {name=p126700 lab=_81575_/CLK }
C {devices/lab_pin.sym} 127650 -27190 0 0 {name=p126701 lab=_81447_/D }
C {devices/lab_pin.sym} 127830 -27210 0 1 {name=p126702 lab=_81447_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -27200 0 0 {name=X_81447_ }
C {devices/lab_pin.sym} 127680 -27080 0 0 {name=p126703 lab=_56816_/Y }
C {devices/lab_pin.sym} 127680 -27040 0 0 {name=p126704 lab=_57182_/X }
C {devices/lab_pin.sym} 127800 -27060 0 1 {name=p126705 lab=_57183_/X }
C {sky130_stdcells/xor2_4.sym} 127740 -27060 0 0 {name=X_57183_ }
C {devices/lab_pin.sym} 127680 -26940 0 0 {name=p126706 lab=_69073_/A }
C {devices/lab_pin.sym} 127680 -26900 0 0 {name=p126707 lab=_88305_/Q }
C {devices/lab_pin.sym} 127800 -26920 0 1 {name=p126708 lab=_69169_/X }
C {sky130_stdcells/and2_4.sym} 127740 -26920 0 0 {name=X_69169_ }
C {devices/lab_pin.sym} 127680 -26820 0 0 {name=p126709 lab=_54395_/A }
C {devices/lab_pin.sym} 127680 -26780 0 0 {name=p126710 lab=_54395_/B }
C {devices/lab_pin.sym} 127680 -26740 0 0 {name=p126711 lab=_54395_/C }
C {devices/lab_pin.sym} 127680 -26700 0 0 {name=p126712 lab=_54395_/D }
C {devices/lab_pin.sym} 127800 -26760 0 1 {name=p126713 lab=_54395_/X }
C {sky130_stdcells/and4_4.sym} 127740 -26760 0 0 {name=X_54395_ }
C {devices/lab_pin.sym} 127660 -26630 0 0 {name=p126714 lab=_48561_/B }
C {devices/lab_pin.sym} 127660 -26590 0 0 {name=p126715 lab=_71190_/X }
C {devices/lab_pin.sym} 127660 -26550 0 0 {name=p126716 lab=_71199_/Y }
C {devices/lab_pin.sym} 127820 -26590 0 1 {name=p126717 lab=_71200_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -26590 0 0 {name=X_71200_ }
C {devices/lab_pin.sym} 127700 -26450 0 0 {name=p126718 lab=_56134_/A }
C {devices/lab_pin.sym} 127780 -26450 0 1 {name=p126719 lab=_56134_/X }
C {sky130_stdcells/buf_2.sym} 127740 -26450 0 0 {name=X_56134_ }
C {devices/lab_pin.sym} 127660 -26350 0 0 {name=p126720 lab=_41261_/X }
C {devices/lab_pin.sym} 127660 -26310 0 0 {name=p126721 lab=_41703_/B }
C {devices/lab_pin.sym} 127660 -26270 0 0 {name=p126722 lab=_41359_/X }
C {devices/lab_pin.sym} 127820 -26310 0 1 {name=p126723 lab=_41360_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -26310 0 0 {name=X_41360_ }
C {devices/lab_pin.sym} 127660 -26190 0 0 {name=p126724 lab=_85650_/Q }
C {devices/lab_pin.sym} 127660 -26150 0 0 {name=p126725 lab=_53324_/X }
C {devices/lab_pin.sym} 127660 -26110 0 0 {name=p126726 lab=_53345_/Y }
C {devices/lab_pin.sym} 127820 -26150 0 1 {name=p126727 lab=_53346_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -26150 0 0 {name=X_53346_ }
C {devices/lab_pin.sym} 127700 -26010 0 0 {name=p126728 lab=_57711_/X }
C {devices/lab_pin.sym} 127780 -26010 0 1 {name=p126729 lab=_72180_/X }
C {sky130_stdcells/buf_2.sym} 127740 -26010 0 0 {name=X_72180_ }
C {devices/lab_pin.sym} 127650 -25890 0 0 {name=p126730 lab=_84166_/CLK }
C {devices/lab_pin.sym} 127650 -25870 0 0 {name=p126731 lab=_84166_/D }
C {devices/lab_pin.sym} 127830 -25890 0 1 {name=p126732 lab=_84166_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -25880 0 0 {name=X_84166_ }
C {devices/lab_pin.sym} 127680 -25760 0 0 {name=p126733 lab=_50541_/A }
C {devices/lab_pin.sym} 127680 -25720 0 0 {name=p126734 lab=_48878_/B }
C {devices/lab_pin.sym} 127800 -25740 0 1 {name=p126735 lab=_50558_/Y }
C {sky130_stdcells/nand2_4.sym} 127740 -25740 0 0 {name=X_50558_ }
C {devices/lab_pin.sym} 127650 -25610 0 0 {name=p126736 lab=_83914_/CLK }
C {devices/lab_pin.sym} 127650 -25590 0 0 {name=p126737 lab=_83914_/Q }
C {devices/lab_pin.sym} 127830 -25610 0 1 {name=p126738 lab=_76792_/B }
C {sky130_stdcells/dfxtp_4.sym} 127740 -25600 0 0 {name=X_81378_ }
C {devices/lab_pin.sym} 127700 -25470 0 0 {name=p126739 lab=clkbuf_7_83_0_CLK/A }
C {devices/lab_pin.sym} 127780 -25470 0 1 {name=p126740 lab=clkbuf_7_82_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 127740 -25470 0 0 {name=Xclkbuf_7_82_0_CLK }
C {devices/lab_pin.sym} 127680 -25370 0 0 {name=p126741 lab=_71129_/A }
C {devices/lab_pin.sym} 127680 -25330 0 0 {name=p126742 lab=_71064_/B }
C {devices/lab_pin.sym} 127680 -25290 0 0 {name=p126743 lab=_70914_/D }
C {devices/lab_pin.sym} 127800 -25330 0 1 {name=p126744 lab=_71131_/Y }
C {sky130_stdcells/nand3_4.sym} 127740 -25330 0 0 {name=X_71131_ }
C {devices/lab_pin.sym} 127650 -25190 0 0 {name=p126745 lab=_86213_/CLK }
C {devices/lab_pin.sym} 127650 -25170 0 0 {name=p126746 lab=_83117_/D }
C {devices/lab_pin.sym} 127830 -25190 0 1 {name=p126747 lab=_70130_/A }
C {sky130_stdcells/dfxtp_4.sym} 127740 -25180 0 0 {name=X_83117_ }
C {devices/lab_pin.sym} 127680 -25060 0 0 {name=p126748 lab=_80324_/Y }
C {devices/lab_pin.sym} 127680 -25020 0 0 {name=p126749 lab=_80328_/Y }
C {devices/lab_pin.sym} 127800 -25040 0 1 {name=p126750 lab=_80329_/Y }
C {sky130_stdcells/nand2_4.sym} 127740 -25040 0 0 {name=X_80329_ }
C {devices/lab_pin.sym} 127700 -24910 0 0 {name=p126751 lab=_45765_/A }
C {devices/lab_pin.sym} 127780 -24910 0 1 {name=p126752 lab=_56086_/B }
C {sky130_stdcells/buf_2.sym} 127740 -24910 0 0 {name=X_56065_ }
C {devices/lab_pin.sym} 127700 -24790 0 0 {name=p126753 lab=_41186_/A }
C {devices/lab_pin.sym} 127780 -24790 0 1 {name=p126754 lab=_41292_/B }
C {sky130_stdcells/buf_2.sym} 127740 -24790 0 0 {name=X_41291_ }
C {devices/lab_pin.sym} 127660 -24690 0 0 {name=p126755 lab=_85663_/Q }
C {devices/lab_pin.sym} 127660 -24650 0 0 {name=p126756 lab=_53268_/X }
C {devices/lab_pin.sym} 127660 -24610 0 0 {name=p126757 lab=_53276_/Y }
C {devices/lab_pin.sym} 127820 -24650 0 1 {name=p126758 lab=_53277_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -24650 0 0 {name=X_53277_ }
C {devices/lab_pin.sym} 127650 -24510 0 0 {name=p126759 lab=_80928_/CLK }
C {devices/lab_pin.sym} 127650 -24490 0 0 {name=p126760 lab=_84097_/D }
C {devices/lab_pin.sym} 127830 -24510 0 1 {name=p126761 lab=_80921_/D }
C {sky130_stdcells/dfxtp_4.sym} 127740 -24500 0 0 {name=X_84097_ }
C {devices/lab_pin.sym} 127680 -24380 0 0 {name=p126762 lab=_50465_/X }
C {devices/lab_pin.sym} 127680 -24340 0 0 {name=p126763 lab=_48811_/B }
C {devices/lab_pin.sym} 127800 -24360 0 1 {name=p126764 lab=_50489_/Y }
C {sky130_stdcells/nand2_4.sym} 127740 -24360 0 0 {name=X_50489_ }
C {devices/lab_pin.sym} 127700 -24230 0 0 {name=p126765 lab=_43030_/A }
C {devices/lab_pin.sym} 127780 -24230 0 1 {name=p126766 lab=_43189_/A }
C {sky130_stdcells/buf_2.sym} 127740 -24230 0 0 {name=X_43030_ }
C {devices/lab_pin.sym} 127660 -24130 0 0 {name=p126767 lab=_85334_/Q }
C {devices/lab_pin.sym} 127660 -24090 0 0 {name=p126768 lab=_54994_/X }
C {devices/lab_pin.sym} 127660 -24050 0 0 {name=p126769 lab=_55015_/Y }
C {devices/lab_pin.sym} 127820 -24090 0 1 {name=p126770 lab=_55016_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -24090 0 0 {name=X_55016_ }
C {devices/lab_pin.sym} 127680 -23970 0 0 {name=p126771 lab=_48845_/A }
C {devices/lab_pin.sym} 127680 -23930 0 0 {name=p126772 lab=_52248_/B }
C {devices/lab_pin.sym} 127680 -23890 0 0 {name=p126773 lab=_52223_/C }
C {devices/lab_pin.sym} 127800 -23930 0 1 {name=p126774 lab=_52228_/X }
C {sky130_stdcells/and3_4.sym} 127740 -23930 0 0 {name=X_52228_ }
C {devices/lab_pin.sym} 127680 -23810 0 0 {name=p126775 lab=_71058_/A }
C {devices/lab_pin.sym} 127680 -23770 0 0 {name=p126776 lab=_70952_/B }
C {devices/lab_pin.sym} 127680 -23730 0 0 {name=p126777 lab=_71066_/C }
C {devices/lab_pin.sym} 127800 -23770 0 1 {name=p126778 lab=_71062_/Y }
C {sky130_stdcells/nand3_4.sym} 127740 -23770 0 0 {name=X_71062_ }
C {devices/lab_pin.sym} 127650 -23630 0 0 {name=p126779 lab=_87926_/CLK }
C {devices/lab_pin.sym} 127650 -23610 0 0 {name=p126780 lab=_87925_/D }
C {devices/lab_pin.sym} 127830 -23630 0 1 {name=p126781 lab=_87925_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -23620 0 0 {name=X_87925_ }
C {devices/lab_pin.sym} 127650 -23490 0 0 {name=p126782 lab=_83049_/CLK }
C {devices/lab_pin.sym} 127650 -23470 0 0 {name=p126783 lab=_74521_/Y }
C {devices/lab_pin.sym} 127830 -23490 0 1 {name=p126784 lab=_83048_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -23480 0 0 {name=X_83048_ }
C {devices/lab_pin.sym} 127660 -23370 0 0 {name=p126785 lab=_69679_/X }
C {devices/lab_pin.sym} 127660 -23330 0 0 {name=p126786 lab=_69681_/X }
C {devices/lab_pin.sym} 127660 -23290 0 0 {name=p126787 lab=_70001_/X }
C {devices/lab_pin.sym} 127820 -23330 0 1 {name=p126788 lab=_70013_/Y }
C {sky130_stdcells/a21oi_4.sym} 127740 -23330 0 0 {name=X_70013_ }
C {devices/lab_pin.sym} 127680 -23210 0 0 {name=p126789 lab=_59588_/Y }
C {devices/lab_pin.sym} 127680 -23170 0 0 {name=p126790 lab=_59824_/B }
C {devices/lab_pin.sym} 127680 -23130 0 0 {name=p126791 lab=_59823_/X }
C {devices/lab_pin.sym} 127800 -23170 0 1 {name=p126792 lab=_59825_/B }
C {sky130_stdcells/nand3_4.sym} 127740 -23170 0 0 {name=X_59824_ }
C {devices/lab_pin.sym} 127660 -23050 0 0 {name=p126793 lab=_85877_/Q }
C {devices/lab_pin.sym} 127660 -23010 0 0 {name=p126794 lab=_52152_/X }
C {devices/lab_pin.sym} 127660 -22970 0 0 {name=p126795 lab=_52158_/Y }
C {devices/lab_pin.sym} 127820 -23010 0 1 {name=p126796 lab=_52159_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -23010 0 0 {name=X_52159_ }
C {devices/lab_pin.sym} 127680 -22880 0 0 {name=p126797 lab=_75862_/Y }
C {devices/lab_pin.sym} 127680 -22840 0 0 {name=p126798 lab=_75875_/B }
C {devices/lab_pin.sym} 127800 -22860 0 1 {name=p126799 lab=_75870_/Y }
C {sky130_stdcells/nand2_4.sym} 127740 -22860 0 0 {name=X_75870_ }
C {devices/lab_pin.sym} 127650 -22730 0 0 {name=p126800 lab=_87068_/CLK }
C {devices/lab_pin.sym} 127650 -22710 0 0 {name=p126801 lab=_42464_/Y }
C {devices/lab_pin.sym} 127830 -22730 0 1 {name=p126802 lab=_87856_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -22720 0 0 {name=X_87856_ }
C {devices/lab_pin.sym} 127700 -22590 0 0 {name=p126803 lab=clkbuf_7_96_0_CLK/A }
C {devices/lab_pin.sym} 127780 -22590 0 1 {name=p126804 lab=clkbuf_7_97_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 127740 -22590 0 0 {name=Xclkbuf_7_97_0_CLK }
C {devices/lab_pin.sym} 127680 -22480 0 0 {name=p126805 lab=_74829_/A }
C {devices/lab_pin.sym} 127680 -22440 0 0 {name=p126806 lab=_46111_/B }
C {devices/lab_pin.sym} 127800 -22460 0 1 {name=p126807 lab=_74822_/A }
C {sky130_stdcells/nand2_4.sym} 127740 -22460 0 0 {name=X_74821_ }
C {devices/lab_pin.sym} 127650 -22330 0 0 {name=p126808 lab=_86807_/CLK }
C {devices/lab_pin.sym} 127650 -22310 0 0 {name=p126809 lab=_46026_/X }
C {devices/lab_pin.sym} 127830 -22330 0 1 {name=p126810 lab=_86807_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -22320 0 0 {name=X_86807_ }
C {devices/lab_pin.sym} 127700 -22190 0 0 {name=p126811 lab=_59755_/A }
C {devices/lab_pin.sym} 127780 -22190 0 1 {name=p126812 lab=_59756_/A }
C {sky130_stdcells/buf_2.sym} 127740 -22190 0 0 {name=X_59755_ }
C {devices/lab_pin.sym} 127660 -22090 0 0 {name=p126813 lab=_56206_/C }
C {devices/lab_pin.sym} 127660 -22050 0 0 {name=p126814 lab=_44911_/X }
C {devices/lab_pin.sym} 127660 -22010 0 0 {name=p126815 lab=_44980_/X }
C {devices/lab_pin.sym} 127820 -22050 0 1 {name=p126816 lab=_44981_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -22050 0 0 {name=X_44981_ }
C {devices/lab_pin.sym} 127660 -21940 0 0 {name=p126817 lab=_56966_/X }
C {devices/lab_pin.sym} 127660 -21900 0 0 {name=p126818 lab=_56639_/X }
C {devices/lab_pin.sym} 127660 -21860 0 0 {name=p126819 lab=_45597_/A }
C {devices/lab_pin.sym} 127660 -21820 0 0 {name=p126820 lab=_56989_/A }
C {devices/lab_pin.sym} 127820 -21880 0 1 {name=p126821 lab=_85108_/D }
C {sky130_stdcells/a2bb2o_4.sym} 127740 -21880 0 0 {name=X_56967_ }
C {devices/lab_pin.sym} 127650 -21730 0 0 {name=p126822 lab=_87544_/CLK }
C {devices/lab_pin.sym} 127650 -21710 0 0 {name=p126823 lab=_42650_/Y }
C {devices/lab_pin.sym} 127830 -21730 0 1 {name=p126824 lab=_87787_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -21720 0 0 {name=X_87787_ }
C {devices/lab_pin.sym} 127650 -21590 0 0 {name=p126825 lab=_83335_/CLK }
C {devices/lab_pin.sym} 127650 -21570 0 0 {name=p126826 lab=_84999_/D }
C {devices/lab_pin.sym} 127830 -21590 0 1 {name=p126827 lab=_84999_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -21580 0 0 {name=X_84999_ }
C {devices/lab_pin.sym} 127700 -21450 0 0 {name=p126828 lab=_46720_/A }
C {devices/lab_pin.sym} 127780 -21450 0 1 {name=p126829 lab=_46733_/A }
C {sky130_stdcells/buf_2.sym} 127740 -21450 0 0 {name=X_46720_ }
C {devices/lab_pin.sym} 127700 -21330 0 0 {name=p126830 lab=_58928_/A }
C {devices/lab_pin.sym} 127780 -21330 0 1 {name=p126831 lab=_58706_/X }
C {sky130_stdcells/buf_2.sym} 127740 -21330 0 0 {name=X_58706_ }
C {devices/lab_pin.sym} 127680 -21230 0 0 {name=p126832 lab=_77540_/A }
C {devices/lab_pin.sym} 127680 -21190 0 0 {name=p126833 lab=_77540_/B }
C {devices/lab_pin.sym} 127680 -21150 0 0 {name=p126834 lab=_77540_/C }
C {devices/lab_pin.sym} 127800 -21190 0 1 {name=p126835 lab=_77561_/C }
C {sky130_stdcells/or3_4.sym} 127740 -21190 0 0 {name=X_77540_ }
C {devices/lab_pin.sym} 127700 -21050 0 0 {name=p126836 lab=_43932_/A }
C {devices/lab_pin.sym} 127780 -21050 0 1 {name=p126837 lab=_43932_/Y }
C {sky130_stdcells/inv_2.sym} 127740 -21050 0 0 {name=X_43932_ }
C {devices/lab_pin.sym} 127700 -20930 0 0 {name=p126838 lab=_55918_/A }
C {devices/lab_pin.sym} 127780 -20930 0 1 {name=p126839 lab=_55928_/C }
C {sky130_stdcells/buf_2.sym} 127740 -20930 0 0 {name=X_55918_ }
C {devices/lab_pin.sym} 127680 -20840 0 0 {name=p126840 lab=_74752_/A }
C {devices/lab_pin.sym} 127680 -20800 0 0 {name=p126841 lab=_74745_/Y }
C {devices/lab_pin.sym} 127680 -20760 0 0 {name=p126842 lab=_74748_/Y }
C {devices/lab_pin.sym} 127680 -20720 0 0 {name=p126843 lab=_74751_/Y }
C {devices/lab_pin.sym} 127800 -20780 0 1 {name=p126844 lab=_74758_/B }
C {sky130_stdcells/and4_4.sym} 127740 -20780 0 0 {name=X_74752_ }
C {devices/lab_pin.sym} 127650 -20630 0 0 {name=p126845 lab=_86246_/CLK }
C {devices/lab_pin.sym} 127650 -20610 0 0 {name=p126846 lab=_46429_/Y }
C {devices/lab_pin.sym} 127830 -20630 0 1 {name=p126847 lab=_86738_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -20620 0 0 {name=X_86738_ }
C {devices/lab_pin.sym} 127700 -20490 0 0 {name=p126848 lab=_71964_/A }
C {devices/lab_pin.sym} 127780 -20490 0 1 {name=p126849 lab=_71964_/X }
C {sky130_stdcells/buf_2.sym} 127740 -20490 0 0 {name=X_71964_ }
C {devices/lab_pin.sym} 127660 -20390 0 0 {name=p126850 lab=_59637_/A }
C {devices/lab_pin.sym} 127660 -20350 0 0 {name=p126851 lab=_59806_/A }
C {devices/lab_pin.sym} 127660 -20310 0 0 {name=p126852 lab=_59699_/A }
C {devices/lab_pin.sym} 127820 -20350 0 1 {name=p126853 lab=_59686_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -20350 0 0 {name=X_59686_ }
C {devices/lab_pin.sym} 127680 -20220 0 0 {name=p126854 lab=_56898_/A }
C {devices/lab_pin.sym} 127680 -20180 0 0 {name=p126855 lab=_59498_/A }
C {devices/lab_pin.sym} 127800 -20200 0 1 {name=p126856 lab=_56898_/Y }
C {sky130_stdcells/nor2_4.sym} 127740 -20200 0 0 {name=X_56898_ }
C {devices/lab_pin.sym} 127700 -20070 0 0 {name=p126857 lab=clkbuf_7_21_0_CLK/A }
C {devices/lab_pin.sym} 127780 -20070 0 1 {name=p126858 lab=clkbuf_8_41_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 127740 -20070 0 0 {name=Xclkbuf_7_20_0_CLK }
C {devices/lab_pin.sym} 127660 -19970 0 0 {name=p126859 lab=_73700_/X }
C {devices/lab_pin.sym} 127660 -19930 0 0 {name=p126860 lab=_73702_/X }
C {devices/lab_pin.sym} 127660 -19890 0 0 {name=p126861 lab=_73679_/X }
C {devices/lab_pin.sym} 127820 -19930 0 1 {name=p126862 lab=_73719_/B }
C {sky130_stdcells/a21o_4.sym} 127740 -19930 0 0 {name=X_73703_ }
C {devices/lab_pin.sym} 127660 -19810 0 0 {name=p126863 lab=_51016_/B }
C {devices/lab_pin.sym} 127660 -19770 0 0 {name=p126864 lab=_70909_/X }
C {devices/lab_pin.sym} 127660 -19730 0 0 {name=p126865 lab=_70914_/Y }
C {devices/lab_pin.sym} 127820 -19770 0 1 {name=p126866 lab=_70915_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -19770 0 0 {name=X_70915_ }
C {devices/lab_pin.sym} 127680 -19640 0 0 {name=p126867 lab=_46651_/A }
C {devices/lab_pin.sym} 127680 -19600 0 0 {name=p126868 lab=_51770_/B }
C {devices/lab_pin.sym} 127800 -19620 0 1 {name=p126869 lab=_46651_/Y }
C {sky130_stdcells/nand2_4.sym} 127740 -19620 0 0 {name=X_46651_ }
C {devices/lab_pin.sym} 127660 -19530 0 0 {name=p126870 lab=_58631_/X }
C {devices/lab_pin.sym} 127660 -19490 0 0 {name=p126871 lab=_58633_/Y }
C {devices/lab_pin.sym} 127660 -19450 0 0 {name=p126872 lab=_58634_/Y }
C {devices/lab_pin.sym} 127660 -19410 0 0 {name=p126873 lab=_58007_/X }
C {devices/lab_pin.sym} 127660 -19370 0 0 {name=p126874 lab=_58636_/X }
C {devices/lab_pin.sym} 127820 -19450 0 1 {name=p126875 lab=_58637_/X }
C {sky130_stdcells/o32a_4.sym} 127740 -19450 0 0 {name=X_58637_ }
C {devices/lab_pin.sym} 127680 -19300 0 0 {name=p126876 lab=_77471_/A }
C {devices/lab_pin.sym} 127680 -19260 0 0 {name=p126877 lab=_77471_/B }
C {devices/lab_pin.sym} 127800 -19280 0 1 {name=p126878 lab=_77472_/A }
C {sky130_stdcells/nand2_4.sym} 127740 -19280 0 0 {name=X_77471_ }
C {devices/lab_pin.sym} 127660 -19180 0 0 {name=p126879 lab=_85202_/Q }
C {devices/lab_pin.sym} 127660 -19140 0 0 {name=p126880 lab=_55462_/X }
C {devices/lab_pin.sym} 127660 -19100 0 0 {name=p126881 lab=_55512_/X }
C {devices/lab_pin.sym} 127660 -19060 0 0 {name=p126882 lab=_55848_/X }
C {devices/lab_pin.sym} 127820 -19120 0 1 {name=p126883 lab=_55849_/X }
C {sky130_stdcells/a211o_4.sym} 127740 -19120 0 0 {name=X_55849_ }
C {devices/lab_pin.sym} 127700 -18970 0 0 {name=p126884 lab=_43776_/A }
C {devices/lab_pin.sym} 127780 -18970 0 1 {name=p126885 lab=_43863_/X }
C {sky130_stdcells/buf_2.sym} 127740 -18970 0 0 {name=X_43863_ }
C {devices/lab_pin.sym} 127700 -18850 0 0 {name=p126886 lab=clkbuf_7_80_0_CLK/X }
C {devices/lab_pin.sym} 127780 -18850 0 1 {name=p126887 lab=clkbuf_8_160_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 127740 -18850 0 0 {name=Xclkbuf_8_160_0_CLK }
C {devices/lab_pin.sym} 127660 -18750 0 0 {name=p126888 lab=_74675_/X }
C {devices/lab_pin.sym} 127660 -18710 0 0 {name=p126889 lab=_56820_/A }
C {devices/lab_pin.sym} 127660 -18670 0 0 {name=p126890 lab=_74682_/Y }
C {devices/lab_pin.sym} 127820 -18710 0 1 {name=p126891 lab=_74684_/A }
C {sky130_stdcells/o21ai_4.sym} 127740 -18710 0 0 {name=X_74683_ }
C {devices/lab_pin.sym} 127650 -18570 0 0 {name=p126892 lab=_86351_/CLK }
C {devices/lab_pin.sym} 127650 -18550 0 0 {name=p126893 lab=_86669_/D }
C {devices/lab_pin.sym} 127830 -18570 0 1 {name=p126894 lab=_59245_/A }
C {sky130_stdcells/dfxtp_4.sym} 127740 -18560 0 0 {name=X_86669_ }
C {devices/lab_pin.sym} 127700 -18430 0 0 {name=p126895 lab=_71894_/Y }
C {devices/lab_pin.sym} 127780 -18430 0 1 {name=p126896 lab=_71898_/D }
C {sky130_stdcells/buf_2.sym} 127740 -18430 0 0 {name=X_71895_ }
C {devices/lab_pin.sym} 127680 -18320 0 0 {name=p126897 lab=_79208_/Y }
C {devices/lab_pin.sym} 127680 -18280 0 0 {name=p126898 lab=_79209_/Y }
C {devices/lab_pin.sym} 127800 -18300 0 1 {name=p126899 lab=_82821_/D }
C {sky130_stdcells/xor2_4.sym} 127740 -18300 0 0 {name=X_79210_ }
C {devices/lab_pin.sym} 127700 -18170 0 0 {name=p126900 lab=_45678_/A }
C {devices/lab_pin.sym} 127780 -18170 0 1 {name=p126901 lab=_45602_/X }
C {sky130_stdcells/buf_2.sym} 127740 -18170 0 0 {name=X_45602_ }
C {devices/lab_pin.sym} 127660 -18070 0 0 {name=p126902 lab=_76387_/B }
C {devices/lab_pin.sym} 127660 -18030 0 0 {name=p126903 lab=_76420_/X }
C {devices/lab_pin.sym} 127660 -17990 0 0 {name=p126904 lab=_76421_/Y }
C {devices/lab_pin.sym} 127820 -18030 0 1 {name=p126905 lab=_76422_/Y }
C {sky130_stdcells/a21oi_4.sym} 127740 -18030 0 0 {name=X_76422_ }
C {devices/lab_pin.sym} 127660 -17920 0 0 {name=p126906 lab=_41433_/X }
C {devices/lab_pin.sym} 127660 -17880 0 0 {name=p126907 lab=_42802_/X }
C {devices/lab_pin.sym} 127660 -17840 0 0 {name=p126908 lab=_67972_/B }
C {devices/lab_pin.sym} 127660 -17800 0 0 {name=p126909 lab=_42803_/X }
C {devices/lab_pin.sym} 127820 -17860 0 1 {name=p126910 lab=_42814_/X }
C {sky130_stdcells/a2bb2o_4.sym} 127740 -17860 0 0 {name=X_42814_ }
C {devices/lab_pin.sym} 127680 -17740 0 0 {name=p126911 lab=_49374_/A }
C {devices/lab_pin.sym} 127680 -17700 0 0 {name=p126912 lab=_49369_/X }
C {devices/lab_pin.sym} 127680 -17660 0 0 {name=p126913 lab=_49380_/C }
C {devices/lab_pin.sym} 127680 -17620 0 0 {name=p126914 lab=_51756_/D }
C {devices/lab_pin.sym} 127800 -17680 0 1 {name=p126915 lab=_49370_/X }
C {sky130_stdcells/and4_4.sym} 127740 -17680 0 0 {name=X_49370_ }
C {devices/lab_pin.sym} 127660 -17550 0 0 {name=p126916 lab=_88368_/Q }
C {devices/lab_pin.sym} 127660 -17510 0 0 {name=p126917 lab=_73633_/X }
C {devices/lab_pin.sym} 127660 -17470 0 0 {name=p126918 lab=_73028_/X }
C {devices/lab_pin.sym} 127820 -17510 0 1 {name=p126919 lab=_73634_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -17510 0 0 {name=X_73634_ }
C {devices/lab_pin.sym} 127700 -17370 0 0 {name=p126920 lab=_51384_/B }
C {devices/lab_pin.sym} 127780 -17370 0 1 {name=p126921 lab=_52565_/B }
C {sky130_stdcells/buf_2.sym} 127740 -17370 0 0 {name=X_46582_ }
C {devices/lab_pin.sym} 127680 -17280 0 0 {name=p126922 lab=_70873_/A }
C {devices/lab_pin.sym} 127680 -17240 0 0 {name=p126923 lab=_70846_/B }
C {devices/lab_pin.sym} 127680 -17200 0 0 {name=p126924 lab=_70849_/C }
C {devices/lab_pin.sym} 127680 -17160 0 0 {name=p126925 lab=_70860_/D }
C {devices/lab_pin.sym} 127800 -17220 0 1 {name=p126926 lab=_70846_/Y }
C {sky130_stdcells/nand4_4.sym} 127740 -17220 0 0 {name=X_70846_ }
C {devices/lab_pin.sym} 127700 -17070 0 0 {name=p126927 lab=_58679_/A }
C {devices/lab_pin.sym} 127780 -17070 0 1 {name=p126928 lab=_58568_/X }
C {sky130_stdcells/buf_2.sym} 127740 -17070 0 0 {name=X_58568_ }
C {devices/lab_pin.sym} 127660 -16990 0 0 {name=p126929 lab=_43790_/X }
C {devices/lab_pin.sym} 127660 -16950 0 0 {name=p126930 lab=_43781_/X }
C {devices/lab_pin.sym} 127660 -16910 0 0 {name=p126931 lab=_41045_/X }
C {devices/lab_pin.sym} 127660 -16870 0 0 {name=p126932 lab=_69397_/B }
C {devices/lab_pin.sym} 127660 -16830 0 0 {name=p126933 lab=_43791_/X }
C {devices/lab_pin.sym} 127820 -16910 0 1 {name=p126934 lab=_43795_/A }
C {sky130_stdcells/o32ai_4.sym} 127740 -16910 0 0 {name=X_43794_ }
C {devices/lab_pin.sym} 127700 -16750 0 0 {name=p126935 lab=_48934_/A }
C {devices/lab_pin.sym} 127780 -16750 0 1 {name=p126936 lab=_49247_/A }
C {sky130_stdcells/buf_2.sym} 127740 -16750 0 0 {name=X_48321_ }
C {devices/lab_pin.sym} 127680 -16640 0 0 {name=p126937 lab=_79141_/A }
C {devices/lab_pin.sym} 127680 -16600 0 0 {name=p126938 lab=_79141_/B }
C {devices/lab_pin.sym} 127800 -16620 0 1 {name=p126939 lab=_79141_/X }
C {sky130_stdcells/xor2_4.sym} 127740 -16620 0 0 {name=X_79141_ }
C {devices/lab_pin.sym} 127700 -16490 0 0 {name=p126940 lab=_85080_/Q }
C {devices/lab_pin.sym} 127780 -16490 0 1 {name=p126941 lab=_45533_/Y }
C {sky130_stdcells/inv_2.sym} 127740 -16490 0 0 {name=X_45533_ }
C {devices/lab_pin.sym} 127660 -16390 0 0 {name=p126942 lab=_84987_/Q }
C {devices/lab_pin.sym} 127660 -16350 0 0 {name=p126943 lab=_57493_/X }
C {devices/lab_pin.sym} 127660 -16310 0 0 {name=p126944 lab=_57518_/Y }
C {devices/lab_pin.sym} 127820 -16350 0 1 {name=p126945 lab=_57519_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -16350 0 0 {name=X_57519_ }
C {devices/lab_pin.sym} 127680 -16230 0 0 {name=p126946 lab=_76348_/X }
C {devices/lab_pin.sym} 127680 -16190 0 0 {name=p126947 lab=_76353_/B }
C {devices/lab_pin.sym} 127680 -16150 0 0 {name=p126948 lab=_76349_/Y }
C {devices/lab_pin.sym} 127800 -16190 0 1 {name=p126949 lab=_76353_/Y }
C {sky130_stdcells/nand3_4.sym} 127740 -16190 0 0 {name=X_76353_ }
C {devices/lab_pin.sym} 127650 -16050 0 0 {name=p126950 lab=_88337_/CLK }
C {devices/lab_pin.sym} 127650 -16030 0 0 {name=p126951 lab=_88339_/D }
C {devices/lab_pin.sym} 127830 -16050 0 1 {name=p126952 lab=_88339_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -16040 0 0 {name=X_88339_ }
C {devices/lab_pin.sym} 127700 -15910 0 0 {name=p126953 lab=_42745_/A }
C {devices/lab_pin.sym} 127780 -15910 0 1 {name=p126954 lab=_42745_/X }
C {sky130_stdcells/buf_2.sym} 127740 -15910 0 0 {name=X_42745_ }
C {devices/lab_pin.sym} 127660 -15810 0 0 {name=p126955 lab=_73562_/X }
C {devices/lab_pin.sym} 127660 -15770 0 0 {name=p126956 lab=_73564_/X }
C {devices/lab_pin.sym} 127660 -15730 0 0 {name=p126957 lab=_73383_/X }
C {devices/lab_pin.sym} 127820 -15770 0 1 {name=p126958 lab=_73570_/A }
C {sky130_stdcells/a21o_4.sym} 127740 -15770 0 0 {name=X_73565_ }
C {devices/lab_pin.sym} 127700 -15630 0 0 {name=p126959 lab=_70382_/A }
C {devices/lab_pin.sym} 127780 -15630 0 1 {name=p126960 lab=_70778_/A }
C {sky130_stdcells/buf_2.sym} 127740 -15630 0 0 {name=X_70777_ }
C {devices/lab_pin.sym} 127660 -15530 0 0 {name=p126961 lab=_58448_/X }
C {devices/lab_pin.sym} 127660 -15490 0 0 {name=p126962 lab=_83410_/Q }
C {devices/lab_pin.sym} 127660 -15450 0 0 {name=p126963 lab=_58498_/Y }
C {devices/lab_pin.sym} 127820 -15490 0 1 {name=p126964 lab=_84834_/D }
C {sky130_stdcells/o21a_4.sym} 127740 -15490 0 0 {name=X_58499_ }
C {devices/lab_pin.sym} 127700 -15350 0 0 {name=p126965 lab=clkbuf_7_35_0_CLK/A }
C {devices/lab_pin.sym} 127780 -15350 0 1 {name=p126966 lab=clkbuf_8_71_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 127740 -15350 0 0 {name=Xclkbuf_7_35_0_CLK }
C {devices/lab_pin.sym} 127700 -15230 0 0 {name=p126967 lab=_75304_/A }
C {devices/lab_pin.sym} 127780 -15230 0 1 {name=p126968 lab=_75304_/Y }
C {sky130_stdcells/inv_2.sym} 127740 -15230 0 0 {name=X_75304_ }
C {devices/lab_pin.sym} 127680 -15130 0 0 {name=p126969 lab=_60526_/A }
C {devices/lab_pin.sym} 127680 -15090 0 0 {name=p126970 lab=_60526_/B }
C {devices/lab_pin.sym} 127680 -15050 0 0 {name=p126971 lab=_79145_/A }
C {devices/lab_pin.sym} 127800 -15090 0 1 {name=p126972 lab=_60530_/Y }
C {sky130_stdcells/nor3_4.sym} 127740 -15090 0 0 {name=X_60530_ }
C {devices/lab_pin.sym} 127680 -14960 0 0 {name=p126973 lab=_48229_/A }
C {devices/lab_pin.sym} 127680 -14920 0 0 {name=p126974 lab=_50300_/B }
C {devices/lab_pin.sym} 127800 -14940 0 1 {name=p126975 lab=_48252_/Y }
C {sky130_stdcells/nand2_4.sym} 127740 -14940 0 0 {name=X_48252_ }
C {devices/lab_pin.sym} 127680 -14830 0 0 {name=p126976 lab=_72516_/A }
C {devices/lab_pin.sym} 127680 -14790 0 0 {name=p126977 lab=_72516_/B }
C {devices/lab_pin.sym} 127680 -14750 0 0 {name=p126978 lab=_72516_/C }
C {devices/lab_pin.sym} 127800 -14790 0 1 {name=p126979 lab=_72517_/B }
C {sky130_stdcells/nand3_4.sym} 127740 -14790 0 0 {name=X_72516_ }
C {devices/lab_pin.sym} 127700 -14650 0 0 {name=p126980 lab=clkbuf_7_87_0_CLK/X }
C {devices/lab_pin.sym} 127780 -14650 0 1 {name=p126981 lab=clkbuf_9_351_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 127740 -14650 0 0 {name=Xclkbuf_8_175_0_CLK }
C {devices/lab_pin.sym} 127700 -14530 0 0 {name=p126982 lab=_82655_/Q }
C {devices/lab_pin.sym} 127780 -14530 0 1 {name=p126983 lab=_79074_/A }
C {sky130_stdcells/inv_2.sym} 127740 -14530 0 0 {name=X_79072_ }
C {devices/lab_pin.sym} 127700 -14410 0 0 {name=p126984 lab=_44895_/X }
C {devices/lab_pin.sym} 127780 -14410 0 1 {name=p126985 lab=_45464_/X }
C {sky130_stdcells/buf_2.sym} 127740 -14410 0 0 {name=X_45464_ }
C {devices/lab_pin.sym} 127680 -14300 0 0 {name=p126986 lab=_76293_/A }
C {devices/lab_pin.sym} 127680 -14260 0 0 {name=p126987 lab=_76283_/Y }
C {devices/lab_pin.sym} 127800 -14280 0 1 {name=p126988 lab=_76284_/X }
C {sky130_stdcells/or2_4.sym} 127740 -14280 0 0 {name=X_76284_ }
C {devices/lab_pin.sym} 127700 -14150 0 0 {name=p126989 lab=clkbuf_9_85_0_CLK/X }
C {devices/lab_pin.sym} 127780 -14150 0 1 {name=p126990 lab=_81587_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 127740 -14150 0 0 {name=Xclkbuf_10_170_0_CLK }
C {devices/lab_pin.sym} 127660 -14060 0 0 {name=p126991 lab=_41050_/X }
C {devices/lab_pin.sym} 127660 -14020 0 0 {name=p126992 lab=_42652_/X }
C {devices/lab_pin.sym} 127660 -13980 0 0 {name=p126993 lab=_69409_/B }
C {devices/lab_pin.sym} 127660 -13940 0 0 {name=p126994 lab=_42653_/X }
C {devices/lab_pin.sym} 127820 -14000 0 1 {name=p126995 lab=_87775_/D }
C {sky130_stdcells/a2bb2o_4.sym} 127740 -14000 0 0 {name=X_42676_ }
C {devices/lab_pin.sym} 127660 -13880 0 0 {name=p126996 lab=_73378_/X }
C {devices/lab_pin.sym} 127660 -13840 0 0 {name=p126997 lab=_86180_/Q }
C {devices/lab_pin.sym} 127660 -13800 0 0 {name=p126998 lab=_73446_/X }
C {devices/lab_pin.sym} 127660 -13760 0 0 {name=p126999 lab=_73495_/X }
C {devices/lab_pin.sym} 127820 -13820 0 1 {name=p127000 lab=_73496_/X }
C {sky130_stdcells/a211o_4.sym} 127740 -13820 0 0 {name=X_73496_ }
C {devices/lab_pin.sym} 127660 -13690 0 0 {name=p127001 lab=_47197_/Y }
C {devices/lab_pin.sym} 127660 -13650 0 0 {name=p127002 lab=_47177_/X }
C {devices/lab_pin.sym} 127660 -13610 0 0 {name=p127003 lab=_47202_/X }
C {devices/lab_pin.sym} 127820 -13650 0 1 {name=p127004 lab=_47203_/Y }
C {sky130_stdcells/a21oi_4.sym} 127740 -13650 0 0 {name=X_47203_ }
C {devices/lab_pin.sym} 127680 -13520 0 0 {name=p127005 lab=_78020_/Y }
C {devices/lab_pin.sym} 127680 -13480 0 0 {name=p127006 lab=_78022_/Y }
C {devices/lab_pin.sym} 127800 -13500 0 1 {name=p127007 lab=_82144_/D }
C {sky130_stdcells/nor2_4.sym} 127740 -13500 0 0 {name=X_78023_ }
C {devices/lab_pin.sym} 127660 -13410 0 0 {name=p127008 lab=_44404_/X }
C {devices/lab_pin.sym} 127660 -13370 0 0 {name=p127009 lab=_44405_/X }
C {devices/lab_pin.sym} 127660 -13330 0 0 {name=p127010 lab=_41536_/X }
C {devices/lab_pin.sym} 127660 -13290 0 0 {name=p127011 lab=_87120_/Q }
C {devices/lab_pin.sym} 127660 -13250 0 0 {name=p127012 lab=_44406_/X }
C {devices/lab_pin.sym} 127820 -13330 0 1 {name=p127013 lab=_44415_/Y }
C {sky130_stdcells/o32ai_4.sym} 127740 -13330 0 0 {name=X_44415_ }
C {devices/lab_pin.sym} 127680 -13180 0 0 {name=p127014 lab=_75242_/A }
C {devices/lab_pin.sym} 127680 -13140 0 0 {name=p127015 lab=_75234_/Y }
C {devices/lab_pin.sym} 127800 -13160 0 1 {name=p127016 lab=_81037_/D }
C {sky130_stdcells/xnor2_4.sym} 127740 -13160 0 0 {name=X_75235_ }
C {devices/lab_pin.sym} 127660 -13060 0 0 {name=p127017 lab=_41626_/X }
C {devices/lab_pin.sym} 127660 -13020 0 0 {name=p127018 lab=_41581_/X }
C {devices/lab_pin.sym} 127660 -12980 0 0 {name=p127019 lab=_67324_/B }
C {devices/lab_pin.sym} 127660 -12940 0 0 {name=p127020 lab=_41582_/X }
C {devices/lab_pin.sym} 127820 -13000 0 1 {name=p127021 lab=_41627_/X }
C {sky130_stdcells/a2bb2o_4.sym} 127740 -13000 0 0 {name=X_41627_ }
C {devices/lab_pin.sym} 127700 -12850 0 0 {name=p127022 lab=_47861_/B }
C {devices/lab_pin.sym} 127780 -12850 0 1 {name=p127023 lab=_50234_/B }
C {sky130_stdcells/buf_2.sym} 127740 -12850 0 0 {name=X_48183_ }
C {devices/lab_pin.sym} 127660 -12760 0 0 {name=p127024 lab=_79154_/A }
C {devices/lab_pin.sym} 127660 -12720 0 0 {name=p127025 lab=_60246_/X }
C {devices/lab_pin.sym} 127660 -12680 0 0 {name=p127026 lab=_60571_/B }
C {devices/lab_pin.sym} 127660 -12640 0 0 {name=p127027 lab=_60445_/Y }
C {devices/lab_pin.sym} 127820 -12700 0 1 {name=p127028 lab=_84614_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 127740 -12700 0 0 {name=X_60461_ }
C {devices/lab_pin.sym} 127680 -12560 0 0 {name=p127029 lab=_72447_/A }
C {devices/lab_pin.sym} 127680 -12520 0 0 {name=p127030 lab=_72476_/B }
C {devices/lab_pin.sym} 127800 -12540 0 1 {name=p127031 lab=_72447_/Y }
C {sky130_stdcells/nor2_4.sym} 127740 -12540 0 0 {name=X_72447_ }
C {devices/lab_pin.sym} 127700 -12410 0 0 {name=p127032 lab=_80671_/Q }
C {devices/lab_pin.sym} 127780 -12410 0 1 {name=p127033 lab=_45395_/X }
C {sky130_stdcells/buf_2.sym} 127740 -12410 0 0 {name=X_45395_ }
C {devices/lab_pin.sym} 127700 -12290 0 0 {name=p127034 lab=_62572_/A }
C {devices/lab_pin.sym} 127780 -12290 0 1 {name=p127035 lab=_62212_/A }
C {sky130_stdcells/buf_2.sym} 127740 -12290 0 0 {name=X_62200_ }
C {devices/lab_pin.sym} 127660 -12190 0 0 {name=p127036 lab=_47126_/Y }
C {devices/lab_pin.sym} 127660 -12150 0 0 {name=p127037 lab=_47128_/X }
C {devices/lab_pin.sym} 127660 -12110 0 0 {name=p127038 lab=_47133_/X }
C {devices/lab_pin.sym} 127820 -12150 0 1 {name=p127039 lab=_47134_/Y }
C {sky130_stdcells/a21oi_4.sym} 127740 -12150 0 0 {name=X_47134_ }
C {devices/lab_pin.sym} 127700 -12010 0 0 {name=p127040 lab=_40509_/X }
C {devices/lab_pin.sym} 127780 -12010 0 1 {name=p127041 lab=_44346_/X }
C {sky130_stdcells/buf_2.sym} 127740 -12010 0 0 {name=X_44346_ }
C {devices/lab_pin.sym} 127680 -11920 0 0 {name=p127042 lab=_63144_/X }
C {devices/lab_pin.sym} 127680 -11880 0 0 {name=p127043 lab=_84826_/Q }
C {devices/lab_pin.sym} 127680 -11840 0 0 {name=p127044 lab=_63146_/C }
C {devices/lab_pin.sym} 127680 -11800 0 0 {name=p127045 lab=_63135_/D }
C {devices/lab_pin.sym} 127800 -11860 0 1 {name=p127046 lab=_63180_/X }
C {sky130_stdcells/and4_4.sym} 127740 -11860 0 0 {name=X_63180_ }
C {devices/lab_pin.sym} 127700 -11710 0 0 {name=p127047 lab=clkbuf_9_291_0_CLK/A }
C {devices/lab_pin.sym} 127780 -11710 0 1 {name=p127048 lab=clkbuf_9_291_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 127740 -11710 0 0 {name=Xclkbuf_9_291_0_CLK }
C {devices/lab_pin.sym} 127660 -11610 0 0 {name=p127049 lab=_75164_/Y }
C {devices/lab_pin.sym} 127660 -11570 0 0 {name=p127050 lab=_75135_/Y }
C {devices/lab_pin.sym} 127660 -11530 0 0 {name=p127051 lab=_75165_/X }
C {devices/lab_pin.sym} 127820 -11570 0 1 {name=p127052 lab=_75167_/B }
C {sky130_stdcells/o21ai_4.sym} 127740 -11570 0 0 {name=X_75166_ }
C {devices/lab_pin.sym} 127680 -11440 0 0 {name=p127053 lab=_81166_/Q }
C {devices/lab_pin.sym} 127680 -11400 0 0 {name=p127054 lab=_41584_/B }
C {devices/lab_pin.sym} 127800 -11420 0 1 {name=p127055 lab=_41558_/X }
C {sky130_stdcells/or2_4.sym} 127740 -11420 0 0 {name=X_41558_ }
C {devices/lab_pin.sym} 127680 -11320 0 0 {name=p127056 lab=_60392_/A }
C {devices/lab_pin.sym} 127680 -11280 0 0 {name=p127057 lab=_60392_/B }
C {devices/lab_pin.sym} 127680 -11240 0 0 {name=p127058 lab=_60392_/C }
C {devices/lab_pin.sym} 127680 -11200 0 0 {name=p127059 lab=_60512_/A }
C {devices/lab_pin.sym} 127800 -11260 0 1 {name=p127060 lab=_60501_/A }
C {sky130_stdcells/and4_4.sym} 127740 -11260 0 0 {name=X_60392_ }
C {devices/lab_pin.sym} 127680 -11120 0 0 {name=p127061 lab=_72378_/A }
C {devices/lab_pin.sym} 127680 -11080 0 0 {name=p127062 lab=_72401_/B }
C {devices/lab_pin.sym} 127800 -11100 0 1 {name=p127063 lab=_72378_/Y }
C {sky130_stdcells/nor2_4.sym} 127740 -11100 0 0 {name=X_72378_ }
C {devices/lab_pin.sym} 127680 -11000 0 0 {name=p127064 lab=_59794_/X }
C {devices/lab_pin.sym} 127680 -10960 0 0 {name=p127065 lab=_62088_/B }
C {devices/lab_pin.sym} 127680 -10920 0 0 {name=p127066 lab=_62131_/C }
C {devices/lab_pin.sym} 127680 -10880 0 0 {name=p127067 lab=_62131_/D }
C {devices/lab_pin.sym} 127800 -10940 0 1 {name=p127068 lab=_62131_/Y }
C {sky130_stdcells/nand4_4.sym} 127740 -10940 0 0 {name=X_62131_ }
C {devices/lab_pin.sym} 127680 -10800 0 0 {name=p127069 lab=_74117_/A }
C {devices/lab_pin.sym} 127680 -10760 0 0 {name=p127070 lab=_74116_/Y }
C {devices/lab_pin.sym} 127800 -10780 0 1 {name=p127071 lab=_74117_/Y }
C {sky130_stdcells/nor2_4.sym} 127740 -10780 0 0 {name=X_74117_ }
C {devices/lab_pin.sym} 127700 -10650 0 0 {name=p127072 lab=_40353_/Y }
C {devices/lab_pin.sym} 127780 -10650 0 1 {name=p127073 lab=_40509_/X }
C {sky130_stdcells/buf_2.sym} 127740 -10650 0 0 {name=X_40509_ }
C {devices/lab_pin.sym} 127700 -10530 0 0 {name=p127074 lab=_82386_/Q }
C {devices/lab_pin.sym} 127780 -10530 0 1 {name=p127075 lab=_54526_/D }
C {sky130_stdcells/inv_2.sym} 127740 -10530 0 0 {name=X_47065_ }
C {devices/lab_pin.sym} 127680 -10430 0 0 {name=p127076 lab=_71335_/A }
C {devices/lab_pin.sym} 127680 -10390 0 0 {name=p127077 lab=_71335_/B }
C {devices/lab_pin.sym} 127680 -10350 0 0 {name=p127078 lab=_71302_/X }
C {devices/lab_pin.sym} 127800 -10390 0 1 {name=p127079 lab=_71329_/Y }
C {sky130_stdcells/nand3_4.sym} 127740 -10390 0 0 {name=X_71329_ }
C {devices/lab_pin.sym} 127700 -10250 0 0 {name=p127080 lab=clkbuf_9_92_0_CLK/X }
C {devices/lab_pin.sym} 127780 -10250 0 1 {name=p127081 lab=_80720_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 127740 -10250 0 0 {name=Xclkbuf_10_185_0_CLK }
C {devices/lab_pin.sym} 127700 -10130 0 0 {name=p127082 lab=_57331_/B }
C {devices/lab_pin.sym} 127780 -10130 0 1 {name=p127083 lab=_44277_/X }
C {sky130_stdcells/buf_2.sym} 127740 -10130 0 0 {name=X_44277_ }
C {devices/lab_pin.sym} 127680 -10020 0 0 {name=p127084 lab=_60136_/C }
C {devices/lab_pin.sym} 127680 -9980 0 0 {name=p127085 lab=_84271_/Q }
C {devices/lab_pin.sym} 127800 -10000 0 1 {name=p127086 lab=_79974_/Y }
C {sky130_stdcells/xnor2_4.sym} 127740 -10000 0 0 {name=X_79974_ }
C {devices/lab_pin.sym} 127680 -9880 0 0 {name=p127087 lab=_80676_/Q }
C {devices/lab_pin.sym} 127680 -9840 0 0 {name=p127088 lab=_80932_/D }
C {devices/lab_pin.sym} 127800 -9860 0 1 {name=p127089 lab=_75099_/A }
C {sky130_stdcells/nand2_4.sym} 127740 -9860 0 0 {name=X_75097_ }
C {devices/lab_pin.sym} 127700 -9730 0 0 {name=p127090 lab=_41336_/X }
C {devices/lab_pin.sym} 127780 -9730 0 1 {name=p127091 lab=_41489_/X }
C {sky130_stdcells/buf_2.sym} 127740 -9730 0 0 {name=X_41489_ }
C {devices/lab_pin.sym} 127700 -9610 0 0 {name=p127092 lab=_46016_/A }
C {devices/lab_pin.sym} 127780 -9610 0 1 {name=p127093 lab=_46016_/Y }
C {sky130_stdcells/inv_2.sym} 127740 -9610 0 0 {name=X_46016_ }
C {devices/lab_pin.sym} 127700 -9490 0 0 {name=p127094 lab=_43227_/Y }
C {devices/lab_pin.sym} 127780 -9490 0 1 {name=p127095 lab=_87528_/D }
C {sky130_stdcells/inv_2.sym} 127740 -9490 0 0 {name=X_43228_ }
C {devices/lab_pin.sym} 127700 -9370 0 0 {name=p127096 lab=_61747_/X }
C {devices/lab_pin.sym} 127780 -9370 0 1 {name=p127097 lab=_62065_/B }
C {sky130_stdcells/buf_2.sym} 127740 -9370 0 0 {name=X_62062_ }
C {devices/lab_pin.sym} 127680 -9270 0 0 {name=p127098 lab=_74046_/X }
C {devices/lab_pin.sym} 127680 -9230 0 0 {name=p127099 lab=_74048_/B }
C {devices/lab_pin.sym} 127680 -9190 0 0 {name=p127100 lab=_74048_/C }
C {devices/lab_pin.sym} 127800 -9230 0 1 {name=p127101 lab=_74048_/Y }
C {sky130_stdcells/nand3_4.sym} 127740 -9230 0 0 {name=X_74048_ }
C {devices/lab_pin.sym} 127660 -9110 0 0 {name=p127102 lab=_78918_/Y }
C {devices/lab_pin.sym} 127660 -9070 0 0 {name=p127103 lab=_78919_/A }
C {devices/lab_pin.sym} 127660 -9030 0 0 {name=p127104 lab=_78924_/Y }
C {devices/lab_pin.sym} 127820 -9070 0 1 {name=p127105 lab=_78925_/Y }
C {sky130_stdcells/a21oi_4.sym} 127740 -9070 0 0 {name=X_78925_ }
C {devices/lab_pin.sym} 127680 -8940 0 0 {name=p127106 lab=_61202_/A }
C {devices/lab_pin.sym} 127680 -8900 0 0 {name=p127107 lab=_60908_/X }
C {devices/lab_pin.sym} 127800 -8920 0 1 {name=p127108 lab=_61013_/Y }
C {sky130_stdcells/nor2_4.sym} 127740 -8920 0 0 {name=X_61013_ }
C {devices/lab_pin.sym} 127700 -8790 0 0 {name=p127109 lab=clkbuf_7_56_0_CLK/X }
C {devices/lab_pin.sym} 127780 -8790 0 1 {name=p127110 lab=clkbuf_8_113_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 127740 -8790 0 0 {name=Xclkbuf_8_113_0_CLK }
C {devices/lab_pin.sym} 127660 -8700 0 0 {name=p127111 lab=_88391_/Q }
C {devices/lab_pin.sym} 127660 -8660 0 0 {name=p127112 lab=_66868_/X }
C {devices/lab_pin.sym} 127660 -8620 0 0 {name=p127113 lab=_66801_/X }
C {devices/lab_pin.sym} 127660 -8580 0 0 {name=p127114 lab=_66869_/X }
C {devices/lab_pin.sym} 127820 -8640 0 1 {name=p127115 lab=_66870_/X }
C {sky130_stdcells/a211o_4.sym} 127740 -8640 0 0 {name=X_66870_ }
C {devices/lab_pin.sym} 127660 -8530 0 0 {name=p127116 lab=_43146_/X }
C {devices/lab_pin.sym} 127660 -8490 0 0 {name=p127117 lab=_43149_/X }
C {devices/lab_pin.sym} 127660 -8450 0 0 {name=p127118 lab=_40861_/X }
C {devices/lab_pin.sym} 127660 -8410 0 0 {name=p127119 lab=_73228_/A }
C {devices/lab_pin.sym} 127660 -8370 0 0 {name=p127120 lab=_43154_/X }
C {devices/lab_pin.sym} 127820 -8450 0 1 {name=p127121 lab=_43160_/A }
C {sky130_stdcells/o32ai_4.sym} 127740 -8450 0 0 {name=X_43159_ }
C {devices/lab_pin.sym} 127700 -8290 0 0 {name=p127122 lab=_78856_/A }
C {devices/lab_pin.sym} 127780 -8290 0 1 {name=p127123 lab=_78856_/Y }
C {sky130_stdcells/inv_2.sym} 127740 -8290 0 0 {name=X_78856_ }
C {devices/lab_pin.sym} 127680 -8180 0 0 {name=p127124 lab=_65704_/A }
C {devices/lab_pin.sym} 127680 -8140 0 0 {name=p127125 lab=_86471_/Q }
C {devices/lab_pin.sym} 127800 -8160 0 1 {name=p127126 lab=_65821_/X }
C {sky130_stdcells/and2_4.sym} 127740 -8160 0 0 {name=X_65821_ }
C {devices/lab_pin.sym} 127680 -8040 0 0 {name=p127127 lab=_82267_/Q }
C {devices/lab_pin.sym} 127680 -8000 0 0 {name=p127128 lab=_81979_/Q }
C {devices/lab_pin.sym} 127800 -8020 0 1 {name=p127129 lab=_77807_/Y }
C {sky130_stdcells/xnor2_4.sym} 127740 -8020 0 0 {name=X_77807_ }
C {devices/lab_pin.sym} 127700 -7890 0 0 {name=p127130 lab=_83772_/Q }
C {devices/lab_pin.sym} 127780 -7890 0 1 {name=p127131 lab=_47967_/Y }
C {sky130_stdcells/inv_2.sym} 127740 -7890 0 0 {name=X_47967_ }
C {devices/lab_pin.sym} 127680 -7780 0 0 {name=p127132 lab=_78782_/Y }
C {devices/lab_pin.sym} 127680 -7740 0 0 {name=p127133 lab=_78786_/X }
C {devices/lab_pin.sym} 127800 -7760 0 1 {name=p127134 lab=_78795_/A }
C {sky130_stdcells/nand2_4.sym} 127740 -7760 0 0 {name=X_78787_ }
C {devices/lab_pin.sym} 127680 -7640 0 0 {name=p127135 lab=_76005_/B }
C {devices/lab_pin.sym} 127680 -7600 0 0 {name=p127136 lab=_76005_/C }
C {devices/lab_pin.sym} 127800 -7620 0 1 {name=p127137 lab=_75999_/Y }
C {sky130_stdcells/nand2_4.sym} 127740 -7620 0 0 {name=X_75999_ }
C {devices/lab_pin.sym} 127700 -7490 0 0 {name=p127138 lab=_49787_/A }
C {devices/lab_pin.sym} 127780 -7490 0 1 {name=p127139 lab=_49706_/X }
C {sky130_stdcells/buf_2.sym} 127740 -7490 0 0 {name=X_49706_ }
C {devices/lab_pin.sym} 127700 -7370 0 0 {name=p127140 lab=_66180_/A }
C {devices/lab_pin.sym} 127780 -7370 0 1 {name=p127141 lab=_68540_/X }
C {sky130_stdcells/buf_2.sym} 127740 -7370 0 0 {name=X_68540_ }
C {devices/lab_pin.sym} 127680 -7280 0 0 {name=p127142 lab=_46915_/X }
C {devices/lab_pin.sym} 127680 -7240 0 0 {name=p127143 lab=_46896_/B }
C {devices/lab_pin.sym} 127680 -7200 0 0 {name=p127144 lab=_46926_/C }
C {devices/lab_pin.sym} 127680 -7160 0 0 {name=p127145 lab=_52746_/D }
C {devices/lab_pin.sym} 127800 -7220 0 1 {name=p127146 lab=_46918_/X }
C {sky130_stdcells/and4_4.sym} 127740 -7220 0 0 {name=X_46918_ }
C {devices/lab_pin.sym} 127660 -7090 0 0 {name=p127147 lab=_65749_/X }
C {devices/lab_pin.sym} 127660 -7050 0 0 {name=p127148 lab=_65751_/X }
C {devices/lab_pin.sym} 127660 -7010 0 0 {name=p127149 lab=_65614_/X }
C {devices/lab_pin.sym} 127820 -7050 0 1 {name=p127150 lab=_65752_/X }
C {sky130_stdcells/a21o_4.sym} 127740 -7050 0 0 {name=X_65752_ }
C {devices/lab_pin.sym} 127700 -6910 0 0 {name=p127151 lab=_82051_/Q }
C {devices/lab_pin.sym} 127780 -6910 0 1 {name=p127152 lab=_77738_/Y }
C {sky130_stdcells/inv_2.sym} 127740 -6910 0 0 {name=X_77738_ }
C {devices/lab_pin.sym} 127660 -6830 0 0 {name=p127153 lab=_58201_/X }
C {devices/lab_pin.sym} 127660 -6790 0 0 {name=p127154 lab=_62924_/C }
C {devices/lab_pin.sym} 127660 -6750 0 0 {name=p127155 lab=_62827_/X }
C {devices/lab_pin.sym} 127660 -6710 0 0 {name=p127156 lab=_62818_/X }
C {devices/lab_pin.sym} 127660 -6680 0 0 {name=p127157 lab=_62963_/X }
C {devices/lab_pin.sym} 127820 -6750 0 1 {name=p127158 lab=_62964_/Y }
C {sky130_stdcells/a41oi_4.sym} 127740 -6750 0 0 {name=X_62964_ }
C {devices/lab_pin.sym} 127700 -6590 0 0 {name=p127159 lab=_47841_/A }
C {devices/lab_pin.sym} 127780 -6590 0 1 {name=p127160 lab=_47912_/A }
C {sky130_stdcells/buf_2.sym} 127740 -6590 0 0 {name=X_47898_ }
C {devices/lab_pin.sym} 127700 -6470 0 0 {name=p127161 lab=_65607_/A }
C {devices/lab_pin.sym} 127780 -6470 0 1 {name=p127162 lab=_64712_/B }
C {sky130_stdcells/buf_2.sym} 127740 -6470 0 0 {name=X_64703_ }
C {devices/lab_pin.sym} 127700 -6350 0 0 {name=p127163 lab=clkbuf_7_64_0_CLK/X }
C {devices/lab_pin.sym} 127780 -6350 0 1 {name=p127164 lab=clkbuf_8_128_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 127740 -6350 0 0 {name=Xclkbuf_8_128_0_CLK }
C {devices/lab_pin.sym} 127680 -6260 0 0 {name=p127165 lab=_61915_/A }
C {devices/lab_pin.sym} 127680 -6220 0 0 {name=p127166 lab=_61915_/B }
C {devices/lab_pin.sym} 127680 -6180 0 0 {name=p127167 lab=_58520_/A }
C {devices/lab_pin.sym} 127680 -6140 0 0 {name=p127168 lab=_61915_/D }
C {devices/lab_pin.sym} 127800 -6200 0 1 {name=p127169 lab=_61915_/X }
C {sky130_stdcells/and4_4.sym} 127740 -6200 0 0 {name=X_61915_ }
C {devices/lab_pin.sym} 127660 -6070 0 0 {name=p127170 lab=_49635_/Y }
C {devices/lab_pin.sym} 127660 -6030 0 0 {name=p127171 lab=_49623_/X }
C {devices/lab_pin.sym} 127660 -5990 0 0 {name=p127172 lab=_49636_/X }
C {devices/lab_pin.sym} 127820 -6030 0 1 {name=p127173 lab=_49637_/Y }
C {sky130_stdcells/a21oi_4.sym} 127740 -6030 0 0 {name=X_49637_ }
C {devices/lab_pin.sym} 127700 -5890 0 0 {name=p127174 lab=clkbuf_9_61_0_CLK/X }
C {devices/lab_pin.sym} 127780 -5890 0 1 {name=p127175 lab=_84671_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 127740 -5890 0 0 {name=Xclkbuf_10_123_0_CLK }
C {devices/lab_pin.sym} 127660 -5790 0 0 {name=p127176 lab=_68466_/X }
C {devices/lab_pin.sym} 127660 -5750 0 0 {name=p127177 lab=_68469_/X }
C {devices/lab_pin.sym} 127660 -5710 0 0 {name=p127178 lab=_68470_/X }
C {devices/lab_pin.sym} 127820 -5750 0 1 {name=p127179 lab=_68471_/X }
C {sky130_stdcells/a21o_4.sym} 127740 -5750 0 0 {name=X_68471_ }
C {devices/lab_pin.sym} 127660 -5630 0 0 {name=p127180 lab=_46843_/Y }
C {devices/lab_pin.sym} 127660 -5590 0 0 {name=p127181 lab=_46844_/X }
C {devices/lab_pin.sym} 127660 -5550 0 0 {name=p127182 lab=_46848_/X }
C {devices/lab_pin.sym} 127820 -5590 0 1 {name=p127183 lab=_86697_/D }
C {sky130_stdcells/a21oi_4.sym} 127740 -5590 0 0 {name=X_46849_ }
C {devices/lab_pin.sym} 127680 -5470 0 0 {name=p127184 lab=_65634_/A }
C {devices/lab_pin.sym} 127680 -5430 0 0 {name=p127185 lab=_65802_/B }
C {devices/lab_pin.sym} 127680 -5390 0 0 {name=p127186 lab=_65683_/C }
C {devices/lab_pin.sym} 127800 -5430 0 1 {name=p127187 lab=_65683_/Y }
C {sky130_stdcells/nor3_4.sym} 127740 -5430 0 0 {name=X_65683_ }
C {devices/lab_pin.sym} 127660 -5310 0 0 {name=p127188 lab=_77596_/B }
C {devices/lab_pin.sym} 127660 -5270 0 0 {name=p127189 lab=_77663_/X }
C {devices/lab_pin.sym} 127660 -5230 0 0 {name=p127190 lab=_77668_/Y }
C {devices/lab_pin.sym} 127820 -5270 0 1 {name=p127191 lab=_77695_/B }
C {sky130_stdcells/a21oi_4.sym} 127740 -5270 0 0 {name=X_77669_ }
C {devices/lab_pin.sym} 127660 -5150 0 0 {name=p127192 lab=_62892_/X }
C {devices/lab_pin.sym} 127660 -5110 0 0 {name=p127193 lab=_62893_/X }
C {devices/lab_pin.sym} 127660 -5070 0 0 {name=p127194 lab=_62894_/Y }
C {devices/lab_pin.sym} 127820 -5110 0 1 {name=p127195 lab=_62895_/Y }
C {sky130_stdcells/a21oi_4.sym} 127740 -5110 0 0 {name=X_62895_ }
C {devices/lab_pin.sym} 127700 -4970 0 0 {name=p127196 lab=clkbuf_9_376_0_CLK/X }
C {devices/lab_pin.sym} 127780 -4970 0 1 {name=p127197 lab=_87273_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 127740 -4970 0 0 {name=Xclkbuf_10_753_0_CLK }
C {devices/lab_pin.sym} 127680 -4860 0 0 {name=p127198 lab=_79392_/X }
C {devices/lab_pin.sym} 127680 -4820 0 0 {name=p127199 lab=_79396_/B }
C {devices/lab_pin.sym} 127800 -4840 0 1 {name=p127200 lab=_79408_/X }
C {sky130_stdcells/or2_4.sym} 127740 -4840 0 0 {name=X_79408_ }
C {devices/lab_pin.sym} 127660 -4740 0 0 {name=p127201 lab=_87164_/Q }
C {devices/lab_pin.sym} 127660 -4700 0 0 {name=p127202 lab=_67348_/X }
C {devices/lab_pin.sym} 127660 -4660 0 0 {name=p127203 lab=_67398_/X }
C {devices/lab_pin.sym} 127660 -4620 0 0 {name=p127204 lab=_67421_/X }
C {devices/lab_pin.sym} 127820 -4680 0 1 {name=p127205 lab=_67422_/X }
C {sky130_stdcells/a211o_4.sym} 127740 -4680 0 0 {name=X_67422_ }
C {devices/lab_pin.sym} 127660 -4550 0 0 {name=p127206 lab=_64561_/X }
C {devices/lab_pin.sym} 127660 -4510 0 0 {name=p127207 lab=_64623_/Y }
C {devices/lab_pin.sym} 127660 -4470 0 0 {name=p127208 lab=_64633_/Y }
C {devices/lab_pin.sym} 127820 -4510 0 1 {name=p127209 lab=_64634_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -4510 0 0 {name=X_64634_ }
C {devices/lab_pin.sym} 127660 -4390 0 0 {name=p127210 lab=_86363_/Q }
C {devices/lab_pin.sym} 127660 -4350 0 0 {name=p127211 lab=_49551_/X }
C {devices/lab_pin.sym} 127660 -4310 0 0 {name=p127212 lab=_49567_/Y }
C {devices/lab_pin.sym} 127820 -4350 0 1 {name=p127213 lab=_49568_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -4350 0 0 {name=X_49568_ }
C {devices/lab_pin.sym} 127680 -4240 0 0 {name=p127214 lab=_61844_/X }
C {devices/lab_pin.sym} 127680 -4200 0 0 {name=p127215 lab=_61846_/B }
C {devices/lab_pin.sym} 127680 -4160 0 0 {name=p127216 lab=_61846_/C }
C {devices/lab_pin.sym} 127680 -4120 0 0 {name=p127217 lab=_61846_/D }
C {devices/lab_pin.sym} 127800 -4180 0 1 {name=p127218 lab=_61846_/Y }
C {sky130_stdcells/nand4_4.sym} 127740 -4180 0 0 {name=X_61846_ }
C {devices/lab_pin.sym} 127650 -4030 0 0 {name=p127219 lab=_80681_/CLK }
C {devices/lab_pin.sym} 127650 -4010 0 0 {name=p127220 lab=_80680_/D }
C {devices/lab_pin.sym} 127830 -4030 0 1 {name=p127221 lab=_80680_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -4020 0 0 {name=X_80680_ }
C {devices/lab_pin.sym} 127700 -3890 0 0 {name=p127222 lab=_48461_/A }
C {devices/lab_pin.sym} 127780 -3890 0 1 {name=p127223 lab=_48565_/B }
C {sky130_stdcells/buf_2.sym} 127740 -3890 0 0 {name=X_48519_ }
C {devices/lab_pin.sym} 127700 -3770 0 0 {name=p127224 lab=clkbuf_9_245_0_CLK/A }
C {devices/lab_pin.sym} 127780 -3770 0 1 {name=p127225 lab=clkbuf_9_244_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 127740 -3770 0 0 {name=Xclkbuf_9_244_0_CLK }
C {devices/lab_pin.sym} 127660 -3670 0 0 {name=p127226 lab=_81505_/D }
C {devices/lab_pin.sym} 127660 -3630 0 0 {name=p127227 lab=_67331_/X }
C {devices/lab_pin.sym} 127660 -3590 0 0 {name=p127228 lab=_67352_/X }
C {devices/lab_pin.sym} 127820 -3630 0 1 {name=p127229 lab=_67353_/X }
C {sky130_stdcells/a21bo_4.sym} 127740 -3630 0 0 {name=X_67353_ }
C {devices/lab_pin.sym} 127680 -3500 0 0 {name=p127230 lab=_79333_/Y }
C {devices/lab_pin.sym} 127680 -3460 0 0 {name=p127231 lab=_79339_/B }
C {devices/lab_pin.sym} 127800 -3480 0 1 {name=p127232 lab=_82832_/D }
C {sky130_stdcells/xor2_4.sym} 127740 -3480 0 0 {name=X_79339_ }
C {devices/lab_pin.sym} 127700 -3350 0 0 {name=p127233 lab=_64565_/A }
C {devices/lab_pin.sym} 127780 -3350 0 1 {name=p127234 lab=_64766_/A }
C {sky130_stdcells/buf_2.sym} 127740 -3350 0 0 {name=X_64565_ }
C {devices/lab_pin.sym} 127700 -3230 0 0 {name=p127235 lab=_61777_/A }
C {devices/lab_pin.sym} 127780 -3230 0 1 {name=p127236 lab=_61795_/C }
C {sky130_stdcells/buf_2.sym} 127740 -3230 0 0 {name=X_61777_ }
C {devices/lab_pin.sym} 127660 -3130 0 0 {name=p127237 lab=_86376_/Q }
C {devices/lab_pin.sym} 127660 -3090 0 0 {name=p127238 lab=_49496_/X }
C {devices/lab_pin.sym} 127660 -3050 0 0 {name=p127239 lab=_49498_/Y }
C {devices/lab_pin.sym} 127820 -3090 0 1 {name=p127240 lab=_49499_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -3090 0 0 {name=X_49499_ }
C {devices/lab_pin.sym} 127680 -2970 0 0 {name=p127241 lab=_65838_/X }
C {devices/lab_pin.sym} 127680 -2930 0 0 {name=p127242 lab=_66276_/B }
C {devices/lab_pin.sym} 127680 -2890 0 0 {name=p127243 lab=_65840_/X }
C {devices/lab_pin.sym} 127800 -2930 0 1 {name=p127244 lab=_66304_/Y }
C {sky130_stdcells/nand3_4.sym} 127740 -2930 0 0 {name=X_66304_ }
C {devices/lab_pin.sym} 127660 -2810 0 0 {name=p127245 lab=_85993_/Q }
C {devices/lab_pin.sym} 127660 -2770 0 0 {name=p127246 lab=_51511_/X }
C {devices/lab_pin.sym} 127660 -2730 0 0 {name=p127247 lab=_51529_/Y }
C {devices/lab_pin.sym} 127820 -2770 0 1 {name=p127248 lab=_51530_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -2770 0 0 {name=X_51530_ }
C {devices/lab_pin.sym} 127700 -2630 0 0 {name=p127249 lab=_63516_/A }
C {devices/lab_pin.sym} 127780 -2630 0 1 {name=p127250 lab=_63516_/X }
C {sky130_stdcells/buf_2.sym} 127740 -2630 0 0 {name=X_63516_ }
C {devices/lab_pin.sym} 127700 -2510 0 0 {name=p127251 lab=clkbuf_9_69_0_CLK/X }
C {devices/lab_pin.sym} 127780 -2510 0 1 {name=p127252 lab=_81361_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 127740 -2510 0 0 {name=Xclkbuf_10_138_0_CLK }
C {devices/lab_pin.sym} 127650 -2390 0 0 {name=p127253 lab=_82369_/CLK }
C {devices/lab_pin.sym} 127650 -2370 0 0 {name=p127254 lab=_82350_/D }
C {devices/lab_pin.sym} 127830 -2390 0 1 {name=p127255 lab=_82350_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -2380 0 0 {name=X_82350_ }
C {devices/lab_pin.sym} 127660 -2280 0 0 {name=p127256 lab=_84580_/Q }
C {devices/lab_pin.sym} 127660 -2240 0 0 {name=p127257 lab=_60719_/X }
C {devices/lab_pin.sym} 127660 -2200 0 0 {name=p127258 lab=_60671_/Y }
C {devices/lab_pin.sym} 127660 -2160 0 0 {name=p127259 lab=_60727_/Y }
C {devices/lab_pin.sym} 127820 -2220 0 1 {name=p127260 lab=_60728_/X }
C {sky130_stdcells/o22a_4.sym} 127740 -2220 0 0 {name=X_60728_ }
C {devices/lab_pin.sym} 127700 -2070 0 0 {name=p127261 lab=_67046_/A }
C {devices/lab_pin.sym} 127780 -2070 0 1 {name=p127262 lab=_67284_/X }
C {sky130_stdcells/buf_2.sym} 127740 -2070 0 0 {name=X_67284_ }
C {devices/lab_pin.sym} 127680 -1970 0 0 {name=p127263 lab=_64515_/A }
C {devices/lab_pin.sym} 127680 -1930 0 0 {name=p127264 lab=_59427_/A }
C {devices/lab_pin.sym} 127680 -1890 0 0 {name=p127265 lab=_64515_/C }
C {devices/lab_pin.sym} 127800 -1930 0 1 {name=p127266 lab=_64496_/Y }
C {sky130_stdcells/nand3_4.sym} 127740 -1930 0 0 {name=X_64496_ }
C {devices/lab_pin.sym} 127700 -1790 0 0 {name=p127267 lab=clkbuf_9_384_0_CLK/X }
C {devices/lab_pin.sym} 127780 -1790 0 1 {name=p127268 lab=_82531_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 127740 -1790 0 0 {name=Xclkbuf_10_768_0_CLK }
C {devices/lab_pin.sym} 127650 -1670 0 0 {name=p127269 lab=_81689_/CLK }
C {devices/lab_pin.sym} 127650 -1650 0 0 {name=p127270 lab=_76989_/X }
C {devices/lab_pin.sym} 127830 -1670 0 1 {name=p127271 lab=_81301_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -1660 0 0 {name=X_81301_ }
C {devices/lab_pin.sym} 127680 -1540 0 0 {name=p127272 lab=_68934_/X }
C {devices/lab_pin.sym} 127680 -1500 0 0 {name=p127273 lab=_69023_/B }
C {devices/lab_pin.sym} 127800 -1520 0 1 {name=p127274 lab=_69023_/Y }
C {sky130_stdcells/nor2_4.sym} 127740 -1520 0 0 {name=X_69023_ }
C {devices/lab_pin.sym} 127660 -1420 0 0 {name=p127275 lab=_66125_/X }
C {devices/lab_pin.sym} 127660 -1380 0 0 {name=p127276 lab=_86218_/Q }
C {devices/lab_pin.sym} 127660 -1340 0 0 {name=p127277 lab=_66180_/X }
C {devices/lab_pin.sym} 127660 -1300 0 0 {name=p127278 lab=_66234_/X }
C {devices/lab_pin.sym} 127820 -1360 0 1 {name=p127279 lab=_66235_/X }
C {sky130_stdcells/a211o_4.sym} 127740 -1360 0 0 {name=X_66235_ }
C {devices/lab_pin.sym} 127660 -1230 0 0 {name=p127280 lab=_86006_/Q }
C {devices/lab_pin.sym} 127660 -1190 0 0 {name=p127281 lab=_51458_/X }
C {devices/lab_pin.sym} 127660 -1150 0 0 {name=p127282 lab=_51460_/Y }
C {devices/lab_pin.sym} 127820 -1190 0 1 {name=p127283 lab=_51461_/Y }
C {sky130_stdcells/o21ai_4.sym} 127740 -1190 0 0 {name=X_51461_ }
C {devices/lab_pin.sym} 127660 -1070 0 0 {name=p127284 lab=_63445_/Y }
C {devices/lab_pin.sym} 127660 -1030 0 0 {name=p127285 lab=_63391_/X }
C {devices/lab_pin.sym} 127660 -990 0 0 {name=p127286 lab=_63446_/Y }
C {devices/lab_pin.sym} 127820 -1030 0 1 {name=p127287 lab=_84323_/D }
C {sky130_stdcells/a21oi_4.sym} 127740 -1030 0 0 {name=X_63447_ }
C {devices/lab_pin.sym} 127650 -890 0 0 {name=p127288 lab=_82288_/CLK }
C {devices/lab_pin.sym} 127650 -870 0 0 {name=p127289 lab=_82281_/D }
C {devices/lab_pin.sym} 127830 -890 0 1 {name=p127290 lab=_82281_/Q }
C {sky130_stdcells/dfxtp_4.sym} 127740 -880 0 0 {name=X_82281_ }
C {devices/lab_pin.sym} 127700 -750 0 0 {name=p127291 lab=_60659_/A }
C {devices/lab_pin.sym} 127780 -750 0 1 {name=p127292 lab=_60660_/A }
C {sky130_stdcells/buf_2.sym} 127740 -750 0 0 {name=X_60659_ }
C {devices/lab_pin.sym} 128600 -42160 0 0 {name=p127293 lab=_53219_/A }
C {devices/lab_pin.sym} 128600 -42120 0 0 {name=p127294 lab=_53200_/B }
C {devices/lab_pin.sym} 128720 -42140 0 1 {name=p127295 lab=_53200_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -42140 0 0 {name=X_53200_ }
C {devices/lab_pin.sym} 128620 -42010 0 0 {name=p127296 lab=clkbuf_9_259_0_CLK/A }
C {devices/lab_pin.sym} 128700 -42010 0 1 {name=p127297 lab=clkbuf_9_259_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 128660 -42010 0 0 {name=Xclkbuf_9_259_0_CLK }
C {devices/lab_pin.sym} 128570 -41890 0 0 {name=p127298 lab=_84020_/CLK }
C {devices/lab_pin.sym} 128570 -41870 0 0 {name=p127299 lab=_68176_/X }
C {devices/lab_pin.sym} 128750 -41890 0 1 {name=p127300 lab=_82060_/D }
C {sky130_stdcells/dfxtp_4.sym} 128660 -41880 0 0 {name=X_84020_ }
C {devices/lab_pin.sym} 128600 -41770 0 0 {name=p127301 lab=_53636_/A }
C {devices/lab_pin.sym} 128600 -41730 0 0 {name=p127302 lab=_50430_/B }
C {devices/lab_pin.sym} 128600 -41690 0 0 {name=p127303 lab=_50435_/C }
C {devices/lab_pin.sym} 128720 -41730 0 1 {name=p127304 lab=_50412_/X }
C {sky130_stdcells/and3_4.sym} 128660 -41730 0 0 {name=X_50412_ }
C {devices/lab_pin.sym} 128570 -41590 0 0 {name=p127305 lab=_81233_/CLK }
C {devices/lab_pin.sym} 128570 -41570 0 0 {name=p127306 lab=_81040_/Q }
C {devices/lab_pin.sym} 128750 -41590 0 1 {name=p127307 lab=_81232_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -41580 0 0 {name=X_81232_ }
C {devices/lab_pin.sym} 128580 -41470 0 0 {name=p127308 lab=_85489_/Q }
C {devices/lab_pin.sym} 128580 -41430 0 0 {name=p127309 lab=_54167_/X }
C {devices/lab_pin.sym} 128580 -41390 0 0 {name=p127310 lab=_54179_/Y }
C {devices/lab_pin.sym} 128740 -41430 0 1 {name=p127311 lab=_54180_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -41430 0 0 {name=X_54180_ }
C {devices/lab_pin.sym} 128600 -41300 0 0 {name=p127312 lab=_57694_/X }
C {devices/lab_pin.sym} 128600 -41260 0 0 {name=p127313 lab=_66166_/B }
C {devices/lab_pin.sym} 128720 -41280 0 1 {name=p127314 lab=_66166_/X }
C {sky130_stdcells/and2_4.sym} 128660 -41280 0 0 {name=X_66166_ }
C {devices/lab_pin.sym} 128600 -41160 0 0 {name=p127315 lab=_47857_/X }
C {devices/lab_pin.sym} 128600 -41120 0 0 {name=p127316 lab=_46591_/A }
C {devices/lab_pin.sym} 128720 -41140 0 1 {name=p127317 lab=_51392_/X }
C {sky130_stdcells/and2_4.sym} 128660 -41140 0 0 {name=X_51392_ }
C {devices/lab_pin.sym} 128620 -41010 0 0 {name=p127318 lab=_63632_/A }
C {devices/lab_pin.sym} 128700 -41010 0 1 {name=p127319 lab=_63443_/A }
C {sky130_stdcells/buf_2.sym} 128660 -41010 0 0 {name=X_63378_ }
C {devices/lab_pin.sym} 128600 -40900 0 0 {name=p127320 lab=_53121_/X }
C {devices/lab_pin.sym} 128600 -40860 0 0 {name=p127321 lab=_53131_/B }
C {devices/lab_pin.sym} 128720 -40880 0 1 {name=p127322 lab=_53131_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -40880 0 0 {name=X_53131_ }
C {devices/lab_pin.sym} 128620 -40750 0 0 {name=p127323 lab=_65117_/A }
C {devices/lab_pin.sym} 128700 -40750 0 1 {name=p127324 lab=_65118_/A }
C {sky130_stdcells/buf_2.sym} 128660 -40750 0 0 {name=X_65117_ }
C {devices/lab_pin.sym} 128600 -40640 0 0 {name=p127325 lab=_50356_/A }
C {devices/lab_pin.sym} 128600 -40600 0 0 {name=p127326 lab=_48297_/X }
C {devices/lab_pin.sym} 128720 -40620 0 1 {name=p127327 lab=_50343_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -40620 0 0 {name=X_50343_ }
C {devices/lab_pin.sym} 128580 -40510 0 0 {name=p127328 lab=_62326_/Y }
C {devices/lab_pin.sym} 128580 -40470 0 0 {name=p127329 lab=_62327_/X }
C {devices/lab_pin.sym} 128580 -40430 0 0 {name=p127330 lab=_62328_/Y }
C {devices/lab_pin.sym} 128740 -40470 0 1 {name=p127331 lab=_84418_/D }
C {sky130_stdcells/a21oi_4.sym} 128660 -40470 0 0 {name=X_62329_ }
C {devices/lab_pin.sym} 128570 -40330 0 0 {name=p127332 lab=_81125_/CLK }
C {devices/lab_pin.sym} 128570 -40310 0 0 {name=p127333 lab=_74911_/B }
C {devices/lab_pin.sym} 128750 -40330 0 1 {name=p127334 lab=_41572_/A }
C {sky130_stdcells/dfxtp_4.sym} 128660 -40320 0 0 {name=X_81163_ }
C {devices/lab_pin.sym} 128600 -40200 0 0 {name=p127335 lab=_66054_/X }
C {devices/lab_pin.sym} 128600 -40160 0 0 {name=p127336 lab=_66097_/B }
C {devices/lab_pin.sym} 128720 -40180 0 1 {name=p127337 lab=_66097_/X }
C {sky130_stdcells/and2_4.sym} 128660 -40180 0 0 {name=X_66097_ }
C {devices/lab_pin.sym} 128620 -40050 0 0 {name=p127338 lab=_80114_/A }
C {devices/lab_pin.sym} 128700 -40050 0 1 {name=p127339 lab=_80114_/Y }
C {sky130_stdcells/inv_2.sym} 128660 -40050 0 0 {name=X_80114_ }
C {devices/lab_pin.sym} 128620 -39930 0 0 {name=p127340 lab=_53062_/A }
C {devices/lab_pin.sym} 128700 -39930 0 1 {name=p127341 lab=_53074_/C }
C {sky130_stdcells/buf_2.sym} 128660 -39930 0 0 {name=X_53062_ }
C {devices/lab_pin.sym} 128580 -39830 0 0 {name=p127342 lab=_65043_/Y }
C {devices/lab_pin.sym} 128580 -39790 0 0 {name=p127343 lab=_64939_/X }
C {devices/lab_pin.sym} 128580 -39750 0 0 {name=p127344 lab=_65047_/Y }
C {devices/lab_pin.sym} 128740 -39790 0 1 {name=p127345 lab=_65048_/X }
C {sky130_stdcells/a21o_4.sym} 128660 -39790 0 0 {name=X_65048_ }
C {devices/lab_pin.sym} 128620 -39650 0 0 {name=p127346 lab=_69655_/A }
C {devices/lab_pin.sym} 128700 -39650 0 1 {name=p127347 lab=_69925_/X }
C {sky130_stdcells/buf_2.sym} 128660 -39650 0 0 {name=X_69925_ }
C {devices/lab_pin.sym} 128620 -39530 0 0 {name=p127348 lab=_50227_/A }
C {devices/lab_pin.sym} 128700 -39530 0 1 {name=p127349 lab=_50274_/X }
C {sky130_stdcells/buf_2.sym} 128660 -39530 0 0 {name=X_50274_ }
C {devices/lab_pin.sym} 128570 -39410 0 0 {name=p127350 lab=_84787_/CLK }
C {devices/lab_pin.sym} 128570 -39390 0 0 {name=p127351 lab=_51652_/Y }
C {devices/lab_pin.sym} 128750 -39410 0 1 {name=p127352 lab=_85971_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -39400 0 0 {name=X_85971_ }
C {devices/lab_pin.sym} 128570 -39270 0 0 {name=p127353 lab=_81094_/CLK }
C {devices/lab_pin.sym} 128570 -39250 0 0 {name=p127354 lab=_81094_/D }
C {devices/lab_pin.sym} 128750 -39270 0 1 {name=p127355 lab=_81094_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -39260 0 0 {name=X_81094_ }
C {devices/lab_pin.sym} 128620 -39130 0 0 {name=p127356 lab=_52152_/A }
C {devices/lab_pin.sym} 128700 -39130 0 1 {name=p127357 lab=_52013_/X }
C {sky130_stdcells/buf_2.sym} 128660 -39130 0 0 {name=X_52013_ }
C {devices/lab_pin.sym} 128570 -39010 0 0 {name=p127358 lab=_87644_/CLK }
C {devices/lab_pin.sym} 128570 -38990 0 0 {name=p127359 lab=_42804_/X }
C {devices/lab_pin.sym} 128750 -39010 0 1 {name=p127360 lab=_87710_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -39000 0 0 {name=X_87710_ }
C {devices/lab_pin.sym} 128570 -38870 0 0 {name=p127361 lab=_84922_/CLK }
C {devices/lab_pin.sym} 128570 -38850 0 0 {name=p127362 lab=_84922_/D }
C {devices/lab_pin.sym} 128750 -38870 0 1 {name=p127363 lab=_84922_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -38860 0 0 {name=X_84922_ }
C {devices/lab_pin.sym} 128600 -38740 0 0 {name=p127364 lab=_80052_/B }
C {devices/lab_pin.sym} 128600 -38700 0 0 {name=p127365 lab=_80045_/B }
C {devices/lab_pin.sym} 128720 -38720 0 1 {name=p127366 lab=_80045_/X }
C {sky130_stdcells/xor2_4.sym} 128660 -38720 0 0 {name=X_80045_ }
C {devices/lab_pin.sym} 128600 -38600 0 0 {name=p127367 lab=_57971_/A }
C {devices/lab_pin.sym} 128600 -38560 0 0 {name=p127368 lab=_57870_/B }
C {devices/lab_pin.sym} 128720 -38580 0 1 {name=p127369 lab=_57870_/Y }
C {sky130_stdcells/nor2_4.sym} 128660 -38580 0 0 {name=X_57870_ }
C {devices/lab_pin.sym} 128580 -38470 0 0 {name=p127370 lab=_69429_/X }
C {devices/lab_pin.sym} 128580 -38430 0 0 {name=p127371 lab=_69432_/X }
C {devices/lab_pin.sym} 128580 -38390 0 0 {name=p127372 lab=_69816_/X }
C {devices/lab_pin.sym} 128740 -38430 0 1 {name=p127373 lab=_69856_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -38430 0 0 {name=X_69856_ }
C {devices/lab_pin.sym} 128620 -38290 0 0 {name=p127374 lab=clkbuf_9_353_0_CLK/X }
C {devices/lab_pin.sym} 128700 -38290 0 1 {name=p127375 lab=_86796_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 128660 -38290 0 0 {name=Xclkbuf_10_706_0_CLK }
C {devices/lab_pin.sym} 128620 -38170 0 0 {name=p127376 lab=_56816_/A }
C {devices/lab_pin.sym} 128700 -38170 0 1 {name=p127377 lab=_56821_/X }
C {sky130_stdcells/buf_2.sym} 128660 -38170 0 0 {name=X_56821_ }
C {devices/lab_pin.sym} 128580 -38070 0 0 {name=p127378 lab=_68803_/X }
C {devices/lab_pin.sym} 128580 -38030 0 0 {name=p127379 lab=_68805_/X }
C {devices/lab_pin.sym} 128580 -37990 0 0 {name=p127380 lab=_68806_/X }
C {devices/lab_pin.sym} 128740 -38030 0 1 {name=p127381 lab=_68807_/X }
C {sky130_stdcells/a21o_4.sym} 128660 -38030 0 0 {name=X_68807_ }
C {devices/lab_pin.sym} 128570 -37890 0 0 {name=p127382 lab=_87195_/CLK }
C {devices/lab_pin.sym} 128570 -37870 0 0 {name=p127383 lab=_87641_/D }
C {devices/lab_pin.sym} 128750 -37890 0 1 {name=p127384 lab=_87641_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -37880 0 0 {name=X_87641_ }
C {devices/lab_pin.sym} 128570 -37750 0 0 {name=p127385 lab=_84732_/CLK }
C {devices/lab_pin.sym} 128570 -37730 0 0 {name=p127386 lab=_58419_/X }
C {devices/lab_pin.sym} 128750 -37750 0 1 {name=p127387 lab=_84853_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -37740 0 0 {name=X_84853_ }
C {devices/lab_pin.sym} 128580 -37640 0 0 {name=p127388 lab=_69746_/X }
C {devices/lab_pin.sym} 128580 -37600 0 0 {name=p127389 lab=_69785_/Y }
C {devices/lab_pin.sym} 128580 -37560 0 0 {name=p127390 lab=_69733_/X }
C {devices/lab_pin.sym} 128580 -37520 0 0 {name=p127391 lab=_69786_/Y }
C {devices/lab_pin.sym} 128740 -37580 0 1 {name=p127392 lab=_69787_/X }
C {sky130_stdcells/a211o_4.sym} 128660 -37580 0 0 {name=X_69787_ }
C {devices/lab_pin.sym} 128600 -37440 0 0 {name=p127393 lab=_66902_/X }
C {devices/lab_pin.sym} 128600 -37400 0 0 {name=p127394 lab=_86820_/Q }
C {devices/lab_pin.sym} 128720 -37420 0 1 {name=p127395 lab=_66999_/X }
C {sky130_stdcells/and2_4.sym} 128660 -37420 0 0 {name=X_66999_ }
C {devices/lab_pin.sym} 128620 -37290 0 0 {name=p127396 lab=_60593_/A }
C {devices/lab_pin.sym} 128700 -37290 0 1 {name=p127397 lab=_59540_/Y }
C {sky130_stdcells/inv_2.sym} 128660 -37290 0 0 {name=X_59540_ }
C {devices/lab_pin.sym} 128570 -37170 0 0 {name=p127398 lab=_83813_/CLK }
C {devices/lab_pin.sym} 128570 -37150 0 0 {name=p127399 lab=_83804_/D }
C {devices/lab_pin.sym} 128750 -37170 0 1 {name=p127400 lab=_83804_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -37160 0 0 {name=X_83804_ }
C {devices/lab_pin.sym} 128600 -37040 0 0 {name=p127401 lab=_56752_/A }
C {devices/lab_pin.sym} 128600 -37000 0 0 {name=p127402 lab=_56798_/B }
C {devices/lab_pin.sym} 128720 -37020 0 1 {name=p127403 lab=_56765_/A }
C {sky130_stdcells/nand2_4.sym} 128660 -37020 0 0 {name=X_56752_ }
C {devices/lab_pin.sym} 128580 -36910 0 0 {name=p127404 lab=_68734_/X }
C {devices/lab_pin.sym} 128580 -36870 0 0 {name=p127405 lab=_68736_/X }
C {devices/lab_pin.sym} 128580 -36830 0 0 {name=p127406 lab=_68737_/X }
C {devices/lab_pin.sym} 128740 -36870 0 1 {name=p127407 lab=_68738_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -36870 0 0 {name=X_68738_ }
C {devices/lab_pin.sym} 128570 -36730 0 0 {name=p127408 lab=_88326_/CLK }
C {devices/lab_pin.sym} 128570 -36710 0 0 {name=p127409 lab=_87572_/D }
C {devices/lab_pin.sym} 128750 -36730 0 1 {name=p127410 lab=_74266_/A }
C {sky130_stdcells/dfxtp_4.sym} 128660 -36720 0 0 {name=X_87572_ }
C {devices/lab_pin.sym} 128600 -36610 0 0 {name=p127411 lab=_53964_/A }
C {devices/lab_pin.sym} 128600 -36570 0 0 {name=p127412 lab=_53964_/B }
C {devices/lab_pin.sym} 128600 -36530 0 0 {name=p127413 lab=_53888_/C }
C {devices/lab_pin.sym} 128720 -36570 0 1 {name=p127414 lab=_53964_/X }
C {sky130_stdcells/and3_4.sym} 128660 -36570 0 0 {name=X_53964_ }
C {devices/lab_pin.sym} 128570 -36430 0 0 {name=p127415 lab=_84823_/CLK }
C {devices/lab_pin.sym} 128570 -36410 0 0 {name=p127416 lab=_84784_/D }
C {devices/lab_pin.sym} 128750 -36430 0 1 {name=p127417 lab=_84784_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -36420 0 0 {name=X_84784_ }
C {devices/lab_pin.sym} 128570 -36290 0 0 {name=p127418 lab=_81996_/CLK }
C {devices/lab_pin.sym} 128570 -36270 0 0 {name=p127419 lab=_81996_/D }
C {devices/lab_pin.sym} 128750 -36290 0 1 {name=p127420 lab=_77066_/A }
C {sky130_stdcells/dfxtp_4.sym} 128660 -36280 0 0 {name=X_81996_ }
C {devices/lab_pin.sym} 128580 -36180 0 0 {name=p127421 lab=_85254_/Q }
C {devices/lab_pin.sym} 128580 -36140 0 0 {name=p127422 lab=_55174_/X }
C {devices/lab_pin.sym} 128580 -36100 0 0 {name=p127423 lab=_44044_/X }
C {devices/lab_pin.sym} 128580 -36060 0 0 {name=p127424 lab=_55702_/X }
C {devices/lab_pin.sym} 128740 -36120 0 1 {name=p127425 lab=_55703_/X }
C {sky130_stdcells/a211o_4.sym} 128660 -36120 0 0 {name=X_55703_ }
C {devices/lab_pin.sym} 128570 -35970 0 0 {name=p127426 lab=_86523_/CLK }
C {devices/lab_pin.sym} 128570 -35950 0 0 {name=p127427 lab=_48432_/Y }
C {devices/lab_pin.sym} 128750 -35970 0 1 {name=p127428 lab=_65525_/B }
C {sky130_stdcells/dfxtp_4.sym} 128660 -35960 0 0 {name=X_86523_ }
C {devices/lab_pin.sym} 128580 -35850 0 0 {name=p127429 lab=_85731_/Q }
C {devices/lab_pin.sym} 128580 -35810 0 0 {name=p127430 lab=_52902_/X }
C {devices/lab_pin.sym} 128580 -35770 0 0 {name=p127431 lab=_52914_/Y }
C {devices/lab_pin.sym} 128740 -35810 0 1 {name=p127432 lab=_52915_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -35810 0 0 {name=X_52915_ }
C {devices/lab_pin.sym} 128570 -35670 0 0 {name=p127433 lab=_83736_/CLK }
C {devices/lab_pin.sym} 128570 -35650 0 0 {name=p127434 lab=_83735_/D }
C {devices/lab_pin.sym} 128750 -35670 0 1 {name=p127435 lab=_83735_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -35660 0 0 {name=X_83735_ }
C {devices/lab_pin.sym} 128600 -35540 0 0 {name=p127436 lab=_59471_/A }
C {devices/lab_pin.sym} 128600 -35500 0 0 {name=p127437 lab=_59478_/B }
C {devices/lab_pin.sym} 128720 -35520 0 1 {name=p127438 lab=_59471_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -35520 0 0 {name=X_59471_ }
C {devices/lab_pin.sym} 128620 -35390 0 0 {name=p127439 lab=_56682_/X }
C {devices/lab_pin.sym} 128700 -35390 0 1 {name=p127440 lab=_56739_/A }
C {sky130_stdcells/buf_2.sym} 128660 -35390 0 0 {name=X_56683_ }
C {devices/lab_pin.sym} 128570 -35270 0 0 {name=p127441 lab=_80740_/CLK }
C {devices/lab_pin.sym} 128570 -35250 0 0 {name=p127442 lab=_80991_/Q }
C {devices/lab_pin.sym} 128750 -35270 0 1 {name=p127443 lab=_74969_/A }
C {sky130_stdcells/dfxtp_4.sym} 128660 -35260 0 0 {name=X_80947_ }
C {devices/lab_pin.sym} 128600 -35140 0 0 {name=p127444 lab=_68669_/A }
C {devices/lab_pin.sym} 128600 -35100 0 0 {name=p127445 lab=_68669_/B }
C {devices/lab_pin.sym} 128720 -35120 0 1 {name=p127446 lab=_68669_/Y }
C {sky130_stdcells/nor2_4.sym} 128660 -35120 0 0 {name=X_68669_ }
C {devices/lab_pin.sym} 128620 -34990 0 0 {name=p127447 lab=_53661_/A }
C {devices/lab_pin.sym} 128700 -34990 0 1 {name=p127448 lab=_53921_/A }
C {sky130_stdcells/buf_2.sym} 128660 -34990 0 0 {name=X_53895_ }
C {devices/lab_pin.sym} 128600 -34890 0 0 {name=p127449 lab=_70700_/A }
C {devices/lab_pin.sym} 128600 -34850 0 0 {name=p127450 lab=_70700_/B }
C {devices/lab_pin.sym} 128600 -34810 0 0 {name=p127451 lab=_71115_/C }
C {devices/lab_pin.sym} 128720 -34850 0 1 {name=p127452 lab=_70701_/A }
C {sky130_stdcells/nor3_4.sym} 128660 -34850 0 0 {name=X_70700_ }
C {devices/lab_pin.sym} 128580 -34730 0 0 {name=p127453 lab=_58406_/X }
C {devices/lab_pin.sym} 128580 -34690 0 0 {name=p127454 lab=_83364_/Q }
C {devices/lab_pin.sym} 128580 -34650 0 0 {name=p127455 lab=_58421_/Y }
C {devices/lab_pin.sym} 128740 -34690 0 1 {name=p127456 lab=_84852_/D }
C {sky130_stdcells/o21a_4.sym} 128660 -34690 0 0 {name=X_58422_ }
C {devices/lab_pin.sym} 128620 -34550 0 0 {name=p127457 lab=_55634_/A }
C {devices/lab_pin.sym} 128700 -34550 0 1 {name=p127458 lab=_56564_/C }
C {sky130_stdcells/buf_2.sym} 128660 -34550 0 0 {name=X_55634_ }
C {devices/lab_pin.sym} 128570 -34430 0 0 {name=p127459 lab=_85555_/CLK }
C {devices/lab_pin.sym} 128570 -34410 0 0 {name=p127460 lab=_49000_/Y }
C {devices/lab_pin.sym} 128750 -34430 0 1 {name=p127461 lab=_86454_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -34420 0 0 {name=X_86454_ }
C {devices/lab_pin.sym} 128580 -34310 0 0 {name=p127462 lab=_40857_/X }
C {devices/lab_pin.sym} 128580 -34270 0 0 {name=p127463 lab=_41034_/A }
C {devices/lab_pin.sym} 128580 -34230 0 0 {name=p127464 lab=_40859_/X }
C {devices/lab_pin.sym} 128740 -34270 0 1 {name=p127465 lab=_40861_/A }
C {sky130_stdcells/o21a_4.sym} 128660 -34270 0 0 {name=X_40860_ }
C {devices/lab_pin.sym} 128600 -34160 0 0 {name=p127466 lab=_52853_/A }
C {devices/lab_pin.sym} 128600 -34120 0 0 {name=p127467 lab=_52831_/B }
C {devices/lab_pin.sym} 128600 -34080 0 0 {name=p127468 lab=_52853_/C }
C {devices/lab_pin.sym} 128600 -34040 0 0 {name=p127469 lab=_52846_/D }
C {devices/lab_pin.sym} 128720 -34100 0 1 {name=p127470 lab=_52846_/X }
C {sky130_stdcells/and4_4.sym} 128660 -34100 0 0 {name=X_52846_ }
C {devices/lab_pin.sym} 128600 -33970 0 0 {name=p127471 lab=_71680_/A }
C {devices/lab_pin.sym} 128600 -33930 0 0 {name=p127472 lab=_71671_/X }
C {devices/lab_pin.sym} 128600 -33890 0 0 {name=p127473 lab=_71680_/C }
C {devices/lab_pin.sym} 128720 -33930 0 1 {name=p127474 lab=_71680_/Y }
C {sky130_stdcells/nand3_4.sym} 128660 -33930 0 0 {name=X_71680_ }
C {devices/lab_pin.sym} 128570 -33790 0 0 {name=p127475 lab=_83666_/CLK }
C {devices/lab_pin.sym} 128570 -33770 0 0 {name=p127476 lab=_83666_/D }
C {devices/lab_pin.sym} 128750 -33790 0 1 {name=p127477 lab=_83666_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -33780 0 0 {name=X_83666_ }
C {devices/lab_pin.sym} 128570 -33650 0 0 {name=p127478 lab=_80754_/CLK }
C {devices/lab_pin.sym} 128570 -33630 0 0 {name=p127479 lab=_75686_/B }
C {devices/lab_pin.sym} 128750 -33650 0 1 {name=p127480 lab=_80878_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -33640 0 0 {name=X_80878_ }
C {devices/lab_pin.sym} 128570 -33510 0 0 {name=p127481 lab=_85499_/CLK }
C {devices/lab_pin.sym} 128570 -33490 0 0 {name=p127482 lab=_85405_/D }
C {devices/lab_pin.sym} 128750 -33510 0 1 {name=p127483 lab=_85405_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -33500 0 0 {name=X_85405_ }
C {devices/lab_pin.sym} 128620 -33370 0 0 {name=p127484 lab=_70630_/X }
C {devices/lab_pin.sym} 128700 -33370 0 1 {name=p127485 lab=_70631_/X }
C {sky130_stdcells/buf_2.sym} 128660 -33370 0 0 {name=X_70631_ }
C {devices/lab_pin.sym} 128580 -33270 0 0 {name=p127486 lab=_58341_/X }
C {devices/lab_pin.sym} 128580 -33230 0 0 {name=p127487 lab=_58350_/Y }
C {devices/lab_pin.sym} 128580 -33190 0 0 {name=p127488 lab=_58352_/Y }
C {devices/lab_pin.sym} 128740 -33230 0 1 {name=p127489 lab=_58353_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -33230 0 0 {name=X_58353_ }
C {devices/lab_pin.sym} 128570 -33090 0 0 {name=p127490 lab=_82617_/CLK }
C {devices/lab_pin.sym} 128570 -33070 0 0 {name=p127491 lab=_79019_/B }
C {devices/lab_pin.sym} 128750 -33090 0 1 {name=p127492 lab=_82617_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -33080 0 0 {name=X_82617_ }
C {devices/lab_pin.sym} 128600 -32960 0 0 {name=p127493 lab=_55843_/A }
C {devices/lab_pin.sym} 128600 -32920 0 0 {name=p127494 lab=_85146_/Q }
C {devices/lab_pin.sym} 128720 -32940 0 1 {name=p127495 lab=_55565_/X }
C {sky130_stdcells/and2_4.sym} 128660 -32940 0 0 {name=X_55565_ }
C {devices/lab_pin.sym} 128570 -32810 0 0 {name=p127496 lab=_83673_/CLK }
C {devices/lab_pin.sym} 128570 -32790 0 0 {name=p127497 lab=_86385_/D }
C {devices/lab_pin.sym} 128750 -32810 0 1 {name=p127498 lab=_86385_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -32800 0 0 {name=X_86385_ }
C {devices/lab_pin.sym} 128580 -32690 0 0 {name=p127499 lab=_40628_/X }
C {devices/lab_pin.sym} 128580 -32650 0 0 {name=p127500 lab=_82876_/Q }
C {devices/lab_pin.sym} 128580 -32610 0 0 {name=p127501 lab=_40790_/X }
C {devices/lab_pin.sym} 128740 -32650 0 1 {name=p127502 lab=_40792_/A }
C {sky130_stdcells/o21ai_4.sym} 128660 -32650 0 0 {name=X_40791_ }
C {devices/lab_pin.sym} 128600 -32520 0 0 {name=p127503 lab=_52773_/A }
C {devices/lab_pin.sym} 128600 -32480 0 0 {name=p127504 lab=_52777_/B }
C {devices/lab_pin.sym} 128720 -32500 0 1 {name=p127505 lab=_52777_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -32500 0 0 {name=X_52777_ }
C {devices/lab_pin.sym} 128570 -32370 0 0 {name=p127506 lab=_86149_/CLK }
C {devices/lab_pin.sym} 128570 -32350 0 0 {name=p127507 lab=_83597_/D }
C {devices/lab_pin.sym} 128750 -32370 0 1 {name=p127508 lab=_83597_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -32360 0 0 {name=X_83597_ }
C {devices/lab_pin.sym} 128600 -32240 0 0 {name=p127509 lab=_57303_/Y }
C {devices/lab_pin.sym} 128600 -32200 0 0 {name=p127510 lab=_57010_/Y }
C {devices/lab_pin.sym} 128720 -32220 0 1 {name=p127511 lab=_57304_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -32220 0 0 {name=X_57304_ }
C {devices/lab_pin.sym} 128570 -32090 0 0 {name=p127512 lab=_87675_/CLK }
C {devices/lab_pin.sym} 128570 -32070 0 0 {name=p127513 lab=_41849_/X }
C {devices/lab_pin.sym} 128750 -32090 0 1 {name=p127514 lab=_67136_/B }
C {sky130_stdcells/dfxtp_4.sym} 128660 -32080 0 0 {name=X_88124_ }
C {devices/lab_pin.sym} 128620 -31950 0 0 {name=p127515 lab=_74184_/A }
C {devices/lab_pin.sym} 128700 -31950 0 1 {name=p127516 lab=_69023_/B }
C {sky130_stdcells/inv_2.sym} 128660 -31950 0 0 {name=X_42530_ }
C {devices/lab_pin.sym} 128600 -31860 0 0 {name=p127517 lab=_54509_/A }
C {devices/lab_pin.sym} 128600 -31820 0 0 {name=p127518 lab=_54503_/B }
C {devices/lab_pin.sym} 128600 -31780 0 0 {name=p127519 lab=_54509_/C }
C {devices/lab_pin.sym} 128600 -31740 0 0 {name=p127520 lab=_47047_/A }
C {devices/lab_pin.sym} 128720 -31800 0 1 {name=p127521 lab=_54516_/X }
C {sky130_stdcells/and4_4.sym} 128660 -31800 0 0 {name=X_54516_ }
C {devices/lab_pin.sym} 128570 -31650 0 0 {name=p127522 lab=_85334_/CLK }
C {devices/lab_pin.sym} 128570 -31630 0 0 {name=p127523 lab=_55010_/Y }
C {devices/lab_pin.sym} 128750 -31650 0 1 {name=p127524 lab=_85336_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -31640 0 0 {name=X_85336_ }
C {devices/lab_pin.sym} 128580 -31530 0 0 {name=p127525 lab=_44577_/Y }
C {devices/lab_pin.sym} 128580 -31490 0 0 {name=p127526 lab=_73006_/X }
C {devices/lab_pin.sym} 128580 -31450 0 0 {name=p127527 lab=_73349_/Y }
C {devices/lab_pin.sym} 128740 -31490 0 1 {name=p127528 lab=_73365_/C }
C {sky130_stdcells/a21o_4.sym} 128660 -31490 0 0 {name=X_73350_ }
C {devices/lab_pin.sym} 128600 -31360 0 0 {name=p127529 lab=_51737_/A }
C {devices/lab_pin.sym} 128600 -31320 0 0 {name=p127530 lab=_51728_/B }
C {devices/lab_pin.sym} 128720 -31340 0 1 {name=p127531 lab=_51728_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -31340 0 0 {name=X_51728_ }
C {devices/lab_pin.sym} 128620 -31210 0 0 {name=p127532 lab=_71570_/A }
C {devices/lab_pin.sym} 128700 -31210 0 1 {name=p127533 lab=_71863_/A }
C {sky130_stdcells/buf_2.sym} 128660 -31210 0 0 {name=X_70562_ }
C {devices/lab_pin.sym} 128620 -31090 0 0 {name=p127534 lab=_84888_/Q }
C {devices/lab_pin.sym} 128700 -31090 0 1 {name=p127535 lab=_63655_/B }
C {sky130_stdcells/buf_2.sym} 128660 -31090 0 0 {name=X_58284_ }
C {devices/lab_pin.sym} 128570 -30970 0 0 {name=p127536 lab=_82541_/CLK }
C {devices/lab_pin.sym} 128570 -30950 0 0 {name=p127537 lab=_83868_/Q }
C {devices/lab_pin.sym} 128750 -30970 0 1 {name=p127538 lab=_79123_/B }
C {sky130_stdcells/dfxtp_4.sym} 128660 -30960 0 0 {name=X_82548_ }
C {devices/lab_pin.sym} 128580 -30860 0 0 {name=p127539 lab=_45585_/A }
C {devices/lab_pin.sym} 128580 -30820 0 0 {name=p127540 lab=_55454_/X }
C {devices/lab_pin.sym} 128580 -30780 0 0 {name=p127541 lab=_55457_/X }
C {devices/lab_pin.sym} 128580 -30740 0 0 {name=p127542 lab=_55495_/Y }
C {devices/lab_pin.sym} 128740 -30800 0 1 {name=p127543 lab=_55496_/X }
C {sky130_stdcells/a211o_4.sym} 128660 -30800 0 0 {name=X_55496_ }
C {devices/lab_pin.sym} 128600 -30660 0 0 {name=p127544 lab=_72347_/A }
C {devices/lab_pin.sym} 128600 -30620 0 0 {name=p127545 lab=_72301_/B }
C {devices/lab_pin.sym} 128720 -30640 0 1 {name=p127546 lab=_72301_/Y }
C {sky130_stdcells/nor2_4.sym} 128660 -30640 0 0 {name=X_72301_ }
C {devices/lab_pin.sym} 128580 -30550 0 0 {name=p127547 lab=_45886_/X }
C {devices/lab_pin.sym} 128580 -30510 0 0 {name=p127548 lab=_45882_/A }
C {devices/lab_pin.sym} 128580 -30470 0 0 {name=p127549 lab=_45898_/X }
C {devices/lab_pin.sym} 128580 -30430 0 0 {name=p127550 lab=_56183_/X }
C {devices/lab_pin.sym} 128580 -30400 0 0 {name=p127551 lab=_44038_/X }
C {devices/lab_pin.sym} 128740 -30470 0 1 {name=p127552 lab=_57235_/Y }
C {sky130_stdcells/a41oi_4.sym} 128660 -30470 0 0 {name=X_57235_ }
C {devices/lab_pin.sym} 128570 -30310 0 0 {name=p127553 lab=_88056_/CLK }
C {devices/lab_pin.sym} 128570 -30290 0 0 {name=p127554 lab=_42056_/Y }
C {devices/lab_pin.sym} 128750 -30310 0 1 {name=p127555 lab=_73462_/A }
C {sky130_stdcells/dfxtp_4.sym} 128660 -30300 0 0 {name=X_88055_ }
C {devices/lab_pin.sym} 128620 -30170 0 0 {name=p127556 lab=_87856_/Q }
C {devices/lab_pin.sym} 128700 -30170 0 1 {name=p127557 lab=_68440_/B }
C {sky130_stdcells/inv_2.sym} 128660 -30170 0 0 {name=X_42461_ }
C {devices/lab_pin.sym} 128580 -30070 0 0 {name=p127558 lab=_85440_/Q }
C {devices/lab_pin.sym} 128580 -30030 0 0 {name=p127559 lab=_54431_/X }
C {devices/lab_pin.sym} 128580 -29990 0 0 {name=p127560 lab=_54446_/Y }
C {devices/lab_pin.sym} 128740 -30030 0 1 {name=p127561 lab=_54447_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -30030 0 0 {name=X_54447_ }
C {devices/lab_pin.sym} 128580 -29910 0 0 {name=p127562 lab=_87051_/Q }
C {devices/lab_pin.sym} 128580 -29870 0 0 {name=p127563 lab=_73129_/X }
C {devices/lab_pin.sym} 128580 -29830 0 0 {name=p127564 lab=_73280_/X }
C {devices/lab_pin.sym} 128740 -29870 0 1 {name=p127565 lab=_73281_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -29870 0 0 {name=X_73281_ }
C {devices/lab_pin.sym} 128570 -29730 0 0 {name=p127566 lab=_85168_/CLK }
C {devices/lab_pin.sym} 128570 -29710 0 0 {name=p127567 lab=_56230_/Y }
C {devices/lab_pin.sym} 128750 -29730 0 1 {name=p127568 lab=_85267_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -29720 0 0 {name=X_85267_ }
C {devices/lab_pin.sym} 128580 -29610 0 0 {name=p127569 lab=_51654_/Y }
C {devices/lab_pin.sym} 128580 -29570 0 0 {name=p127570 lab=_51639_/X }
C {devices/lab_pin.sym} 128580 -29530 0 0 {name=p127571 lab=_51658_/X }
C {devices/lab_pin.sym} 128740 -29570 0 1 {name=p127572 lab=_51659_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -29570 0 0 {name=X_51659_ }
C {devices/lab_pin.sym} 128620 -29430 0 0 {name=p127573 lab=_70907_/B }
C {devices/lab_pin.sym} 128700 -29430 0 1 {name=p127574 lab=_70696_/B }
C {sky130_stdcells/buf_2.sym} 128660 -29430 0 0 {name=X_70493_ }
C {devices/lab_pin.sym} 128570 -29310 0 0 {name=p127575 lab=_82855_/CLK }
C {devices/lab_pin.sym} 128570 -29290 0 0 {name=p127576 lab=_82479_/D }
C {devices/lab_pin.sym} 128750 -29310 0 1 {name=p127577 lab=_78108_/B }
C {sky130_stdcells/dfxtp_4.sym} 128660 -29300 0 0 {name=X_82479_ }
C {devices/lab_pin.sym} 128580 -29190 0 0 {name=p127578 lab=_44167_/Y }
C {devices/lab_pin.sym} 128580 -29150 0 0 {name=p127579 lab=_44186_/X }
C {devices/lab_pin.sym} 128580 -29110 0 0 {name=p127580 lab=_44220_/B }
C {devices/lab_pin.sym} 128740 -29150 0 1 {name=p127581 lab=_44200_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -29150 0 0 {name=X_44200_ }
C {devices/lab_pin.sym} 128600 -29030 0 0 {name=p127582 lab=_75008_/X }
C {devices/lab_pin.sym} 128600 -28990 0 0 {name=p127583 lab=_80768_/Q }
C {devices/lab_pin.sym} 128600 -28950 0 0 {name=p127584 lab=_75020_/C }
C {devices/lab_pin.sym} 128720 -28990 0 1 {name=p127585 lab=_75020_/Y }
C {sky130_stdcells/nand3_4.sym} 128660 -28990 0 0 {name=X_75020_ }
C {devices/lab_pin.sym} 128620 -28850 0 0 {name=p127586 lab=_41411_/X }
C {devices/lab_pin.sym} 128700 -28850 0 1 {name=p127587 lab=_41412_/X }
C {sky130_stdcells/buf_2.sym} 128660 -28850 0 0 {name=X_41412_ }
C {devices/lab_pin.sym} 128570 -28730 0 0 {name=p127588 lab=_86984_/CLK }
C {devices/lab_pin.sym} 128570 -28710 0 0 {name=p127589 lab=_44672_/Y }
C {devices/lab_pin.sym} 128750 -28730 0 1 {name=p127590 lab=_87006_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -28720 0 0 {name=X_87006_ }
C {devices/lab_pin.sym} 128600 -28600 0 0 {name=p127591 lab=_72220_/A }
C {devices/lab_pin.sym} 128600 -28560 0 0 {name=p127592 lab=_72232_/B }
C {devices/lab_pin.sym} 128720 -28580 0 1 {name=p127593 lab=_72232_/Y }
C {sky130_stdcells/nor2_4.sym} 128660 -28580 0 0 {name=X_72232_ }
C {devices/lab_pin.sym} 128570 -28450 0 0 {name=p127594 lab=_84220_/CLK }
C {devices/lab_pin.sym} 128570 -28430 0 0 {name=p127595 lab=_84218_/D }
C {devices/lab_pin.sym} 128750 -28450 0 1 {name=p127596 lab=_84218_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -28440 0 0 {name=X_84218_ }
C {devices/lab_pin.sym} 128580 -28330 0 0 {name=p127597 lab=_55826_/B }
C {devices/lab_pin.sym} 128580 -28290 0 0 {name=p127598 lab=_45120_/X }
C {devices/lab_pin.sym} 128580 -28250 0 0 {name=p127599 lab=_45153_/X }
C {devices/lab_pin.sym} 128740 -28290 0 1 {name=p127600 lab=_45180_/X }
C {sky130_stdcells/o21a_4.sym} 128660 -28290 0 0 {name=X_45180_ }
C {devices/lab_pin.sym} 128580 -28170 0 0 {name=p127601 lab=_57162_/Y }
C {devices/lab_pin.sym} 128580 -28130 0 0 {name=p127602 lab=_57165_/X }
C {devices/lab_pin.sym} 128580 -28090 0 0 {name=p127603 lab=_57192_/A }
C {devices/lab_pin.sym} 128740 -28130 0 1 {name=p127604 lab=_57166_/X }
C {sky130_stdcells/a21o_4.sym} 128660 -28130 0 0 {name=X_57166_ }
C {devices/lab_pin.sym} 128620 -27990 0 0 {name=p127605 lab=_42392_/A }
C {devices/lab_pin.sym} 128700 -27990 0 1 {name=p127606 lab=_87886_/D }
C {sky130_stdcells/inv_2.sym} 128660 -27990 0 0 {name=X_42392_ }
C {devices/lab_pin.sym} 128600 -27880 0 0 {name=p127607 lab=_54378_/A }
C {devices/lab_pin.sym} 128600 -27840 0 0 {name=p127608 lab=_52686_/B }
C {devices/lab_pin.sym} 128720 -27860 0 1 {name=p127609 lab=_54378_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -27860 0 0 {name=X_54378_ }
C {devices/lab_pin.sym} 128570 -27730 0 0 {name=p127610 lab=_85198_/CLK }
C {devices/lab_pin.sym} 128570 -27710 0 0 {name=p127611 lab=_85198_/D }
C {devices/lab_pin.sym} 128750 -27730 0 1 {name=p127612 lab=_85198_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -27720 0 0 {name=X_85198_ }
C {devices/lab_pin.sym} 128620 -27590 0 0 {name=p127613 lab=_44131_/A }
C {devices/lab_pin.sym} 128700 -27590 0 1 {name=p127614 lab=_72784_/A }
C {sky130_stdcells/inv_2.sym} 128660 -27590 0 0 {name=X_44131_ }
C {devices/lab_pin.sym} 128600 -27490 0 0 {name=p127615 lab=_56117_/A }
C {devices/lab_pin.sym} 128600 -27450 0 0 {name=p127616 lab=_56117_/B }
C {devices/lab_pin.sym} 128600 -27410 0 0 {name=p127617 lab=_56117_/C }
C {devices/lab_pin.sym} 128720 -27450 0 1 {name=p127618 lab=_56118_/A }
C {sky130_stdcells/and3_4.sym} 128660 -27450 0 0 {name=X_56117_ }
C {devices/lab_pin.sym} 128620 -27310 0 0 {name=p127619 lab=_41343_/A }
C {devices/lab_pin.sym} 128700 -27310 0 1 {name=p127620 lab=_41343_/Y }
C {sky130_stdcells/inv_2.sym} 128660 -27310 0 0 {name=X_41343_ }
C {devices/lab_pin.sym} 128620 -27190 0 0 {name=p127621 lab=_53302_/A }
C {devices/lab_pin.sym} 128700 -27190 0 1 {name=p127622 lab=_53330_/C }
C {sky130_stdcells/buf_2.sym} 128660 -27190 0 0 {name=X_53329_ }
C {devices/lab_pin.sym} 128580 -27110 0 0 {name=p127623 lab=_59237_/X }
C {devices/lab_pin.sym} 128580 -27070 0 0 {name=p127624 lab=_72160_/Y }
C {devices/lab_pin.sym} 128580 -27030 0 0 {name=p127625 lab=_72162_/Y }
C {devices/lab_pin.sym} 128580 -26990 0 0 {name=p127626 lab=_59301_/X }
C {devices/lab_pin.sym} 128580 -26950 0 0 {name=p127627 lab=_59241_/X }
C {devices/lab_pin.sym} 128740 -27030 0 1 {name=p127628 lab=_72163_/X }
C {sky130_stdcells/o32a_4.sym} 128660 -27030 0 0 {name=X_72163_ }
C {devices/lab_pin.sym} 128570 -26870 0 0 {name=p127629 lab=_82746_/CLK }
C {devices/lab_pin.sym} 128570 -26850 0 0 {name=p127630 lab=_84149_/D }
C {devices/lab_pin.sym} 128750 -26870 0 1 {name=p127631 lab=_80419_/B }
C {sky130_stdcells/dfxtp_4.sym} 128660 -26860 0 0 {name=X_84149_ }
C {devices/lab_pin.sym} 128620 -26730 0 0 {name=p127632 lab=_57096_/Y }
C {devices/lab_pin.sym} 128700 -26730 0 1 {name=p127633 lab=_57097_/X }
C {sky130_stdcells/buf_2.sym} 128660 -26730 0 0 {name=X_57097_ }
C {devices/lab_pin.sym} 128580 -26630 0 0 {name=p127634 lab=_50169_/B }
C {devices/lab_pin.sym} 128580 -26590 0 0 {name=p127635 lab=_71095_/A }
C {devices/lab_pin.sym} 128580 -26550 0 0 {name=p127636 lab=_71113_/Y }
C {devices/lab_pin.sym} 128740 -26590 0 1 {name=p127637 lab=_71114_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -26590 0 0 {name=X_71114_ }
C {devices/lab_pin.sym} 128620 -26450 0 0 {name=p127638 lab=_44061_/X }
C {devices/lab_pin.sym} 128700 -26450 0 1 {name=p127639 lab=_55470_/A }
C {sky130_stdcells/buf_2.sym} 128660 -26450 0 0 {name=X_44062_ }
C {devices/lab_pin.sym} 128580 -26370 0 0 {name=p127640 lab=_55928_/A }
C {devices/lab_pin.sym} 128580 -26330 0 0 {name=p127641 lab=_74310_/C }
C {devices/lab_pin.sym} 128580 -26290 0 0 {name=p127642 lab=_55928_/C }
C {devices/lab_pin.sym} 128580 -26250 0 0 {name=p127643 lab=_56045_/Y }
C {devices/lab_pin.sym} 128580 -26210 0 0 {name=p127644 lab=_56047_/Y }
C {devices/lab_pin.sym} 128740 -26290 0 1 {name=p127645 lab=_56048_/Y }
C {sky130_stdcells/a32oi_4.sym} 128660 -26290 0 0 {name=X_56048_ }
C {devices/lab_pin.sym} 128620 -26130 0 0 {name=p127646 lab=_41013_/A }
C {devices/lab_pin.sym} 128700 -26130 0 1 {name=p127647 lab=_41275_/B }
C {sky130_stdcells/buf_2.sym} 128660 -26130 0 0 {name=X_41274_ }
C {devices/lab_pin.sym} 128600 -26020 0 0 {name=p127648 lab=_72075_/A }
C {devices/lab_pin.sym} 128600 -25980 0 0 {name=p127649 lab=_53919_/B }
C {devices/lab_pin.sym} 128720 -26000 0 1 {name=p127650 lab=_72094_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -26000 0 0 {name=X_72094_ }
C {devices/lab_pin.sym} 128600 -25880 0 0 {name=p127651 lab=_76971_/A }
C {devices/lab_pin.sym} 128600 -25840 0 0 {name=p127652 lab=_84395_/Q }
C {devices/lab_pin.sym} 128720 -25860 0 1 {name=p127653 lab=_76971_/X }
C {sky130_stdcells/xor2_4.sym} 128660 -25860 0 0 {name=X_76971_ }
C {devices/lab_pin.sym} 128620 -25730 0 0 {name=p127654 lab=_43175_/C }
C {devices/lab_pin.sym} 128700 -25730 0 1 {name=p127655 lab=_43013_/X }
C {sky130_stdcells/buf_2.sym} 128660 -25730 0 0 {name=X_43013_ }
C {devices/lab_pin.sym} 128600 -25620 0 0 {name=p127656 lab=_78710_/A }
C {devices/lab_pin.sym} 128600 -25580 0 0 {name=p127657 lab=_82685_/D }
C {devices/lab_pin.sym} 128720 -25600 0 1 {name=p127658 lab=_78713_/B }
C {sky130_stdcells/nor2_4.sym} 128660 -25600 0 0 {name=X_78710_ }
C {devices/lab_pin.sym} 128600 -25500 0 0 {name=p127659 lab=_70828_/A }
C {devices/lab_pin.sym} 128600 -25460 0 0 {name=p127660 lab=_70959_/B }
C {devices/lab_pin.sym} 128600 -25420 0 0 {name=p127661 lab=_70959_/C }
C {devices/lab_pin.sym} 128600 -25380 0 0 {name=p127662 lab=_71115_/B }
C {devices/lab_pin.sym} 128720 -25440 0 1 {name=p127663 lab=_71046_/A }
C {sky130_stdcells/and4_4.sym} 128660 -25440 0 0 {name=X_71045_ }
C {devices/lab_pin.sym} 128600 -25300 0 0 {name=p127664 lab=_84520_/Q }
C {devices/lab_pin.sym} 128600 -25260 0 0 {name=p127665 lab=_84392_/Q }
C {devices/lab_pin.sym} 128720 -25280 0 1 {name=p127666 lab=_75922_/X }
C {sky130_stdcells/xor2_4.sym} 128660 -25280 0 0 {name=X_75922_ }
C {devices/lab_pin.sym} 128570 -25150 0 0 {name=p127667 lab=_87898_/CLK }
C {devices/lab_pin.sym} 128570 -25130 0 0 {name=p127668 lab=_87908_/D }
C {devices/lab_pin.sym} 128750 -25150 0 1 {name=p127669 lab=_87908_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -25140 0 0 {name=X_87908_ }
C {devices/lab_pin.sym} 128600 -25030 0 0 {name=p127670 lab=_48702_/A }
C {devices/lab_pin.sym} 128600 -24990 0 0 {name=p127671 lab=_48859_/B }
C {devices/lab_pin.sym} 128600 -24950 0 0 {name=p127672 lab=_48854_/C }
C {devices/lab_pin.sym} 128720 -24990 0 1 {name=p127673 lab=_48870_/X }
C {sky130_stdcells/and3_4.sym} 128660 -24990 0 0 {name=X_48870_ }
C {devices/lab_pin.sym} 128600 -24860 0 0 {name=p127674 lab=_84215_/Q }
C {devices/lab_pin.sym} 128600 -24820 0 0 {name=p127675 lab=_83263_/Q }
C {devices/lab_pin.sym} 128720 -24840 0 1 {name=p127676 lab=_79692_/A }
C {sky130_stdcells/xor2_4.sym} 128660 -24840 0 0 {name=X_79690_ }
C {devices/lab_pin.sym} 128620 -24710 0 0 {name=p127677 lab=_81218_/Q }
C {devices/lab_pin.sym} 128700 -24710 0 1 {name=p127678 lab=_47822_/A }
C {sky130_stdcells/inv_2.sym} 128660 -24710 0 0 {name=X_47821_ }
C {devices/lab_pin.sym} 128620 -24590 0 0 {name=p127679 lab=_59807_/A }
C {devices/lab_pin.sym} 128700 -24590 0 1 {name=p127680 lab=_59840_/A }
C {sky130_stdcells/buf_2.sym} 128660 -24590 0 0 {name=X_59807_ }
C {devices/lab_pin.sym} 128580 -24490 0 0 {name=p127681 lab=_78640_/A }
C {devices/lab_pin.sym} 128580 -24450 0 0 {name=p127682 lab=_78640_/C }
C {devices/lab_pin.sym} 128580 -24410 0 0 {name=p127683 lab=_78621_/A }
C {devices/lab_pin.sym} 128740 -24450 0 1 {name=p127684 lab=_78641_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -24450 0 0 {name=X_78641_ }
C {devices/lab_pin.sym} 128600 -24320 0 0 {name=p127685 lab=_75831_/A }
C {devices/lab_pin.sym} 128600 -24280 0 0 {name=p127686 lab=_75841_/A }
C {devices/lab_pin.sym} 128720 -24300 0 1 {name=p127687 lab=_75853_/X }
C {sky130_stdcells/and2_4.sym} 128660 -24300 0 0 {name=X_75853_ }
C {devices/lab_pin.sym} 128570 -24170 0 0 {name=p127688 lab=_87850_/CLK }
C {devices/lab_pin.sym} 128570 -24150 0 0 {name=p127689 lab=_42512_/Y }
C {devices/lab_pin.sym} 128750 -24170 0 1 {name=p127690 lab=_87839_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -24160 0 0 {name=X_87839_ }
C {devices/lab_pin.sym} 128580 -24050 0 0 {name=p127691 lab=_57983_/X }
C {devices/lab_pin.sym} 128580 -24010 0 0 {name=p127692 lab=_85389_/Q }
C {devices/lab_pin.sym} 128580 -23970 0 0 {name=p127693 lab=_57998_/X }
C {devices/lab_pin.sym} 128740 -24010 0 1 {name=p127694 lab=_57999_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -24010 0 0 {name=X_57999_ }
C {devices/lab_pin.sym} 128600 -23900 0 0 {name=p127695 lab=_74804_/A }
C {devices/lab_pin.sym} 128600 -23860 0 0 {name=p127696 lab=_74804_/B }
C {devices/lab_pin.sym} 128600 -23820 0 0 {name=p127697 lab=_74804_/C }
C {devices/lab_pin.sym} 128600 -23780 0 0 {name=p127698 lab=_74804_/D }
C {devices/lab_pin.sym} 128720 -23840 0 1 {name=p127699 lab=_74804_/X }
C {sky130_stdcells/and4_4.sym} 128660 -23840 0 0 {name=X_74804_ }
C {devices/lab_pin.sym} 128620 -23690 0 0 {name=p127700 lab=clkbuf_9_505_0_CLK/X }
C {devices/lab_pin.sym} 128700 -23690 0 1 {name=p127701 lab=_83310_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 128660 -23690 0 0 {name=Xclkbuf_10_1010_0_CLK }
C {devices/lab_pin.sym} 128620 -23570 0 0 {name=p127702 lab=_47752_/A }
C {devices/lab_pin.sym} 128700 -23570 0 1 {name=p127703 lab=_53227_/B }
C {sky130_stdcells/buf_2.sym} 128660 -23570 0 0 {name=X_47752_ }
C {devices/lab_pin.sym} 128580 -23490 0 0 {name=p127704 lab=_59727_/X }
C {devices/lab_pin.sym} 128580 -23450 0 0 {name=p127705 lab=_59728_/Y }
C {devices/lab_pin.sym} 128580 -23410 0 0 {name=p127706 lab=_59686_/Y }
