C {sky130_stdcells/o21ai_4.sym} 84500 -5650 0 0 {name=X_71174_ }
C {devices/lab_pin.sym} 84440 -5540 0 0 {name=p84261 lab=_70125_/A }
C {devices/lab_pin.sym} 84440 -5500 0 0 {name=p84262 lab=_70122_/Y }
C {devices/lab_pin.sym} 84440 -5460 0 0 {name=p84263 lab=_70125_/C }
C {devices/lab_pin.sym} 84440 -5420 0 0 {name=p84264 lab=_70125_/D }
C {devices/lab_pin.sym} 84560 -5480 0 1 {name=p84265 lab=_70125_/Y }
C {sky130_stdcells/nand4_4.sym} 84500 -5480 0 0 {name=X_70125_ }
C {devices/lab_pin.sym} 84460 -5330 0 0 {name=p84266 lab=_83774_/Q }
C {devices/lab_pin.sym} 84540 -5330 0 1 {name=p84267 lab=_53514_/B }
C {sky130_stdcells/inv_2.sym} 84500 -5330 0 0 {name=X_47950_ }
C {devices/lab_pin.sym} 84420 -5250 0 0 {name=p84268 lab=_43072_/X }
C {devices/lab_pin.sym} 84420 -5210 0 0 {name=p84269 lab=_43050_/X }
C {devices/lab_pin.sym} 84420 -5170 0 0 {name=p84270 lab=_40682_/X }
C {devices/lab_pin.sym} 84420 -5130 0 0 {name=p84271 lab=_87586_/Q }
C {devices/lab_pin.sym} 84420 -5090 0 0 {name=p84272 lab=_43061_/X }
C {devices/lab_pin.sym} 84580 -5170 0 1 {name=p84273 lab=_43073_/Y }
C {sky130_stdcells/o32ai_4.sym} 84500 -5170 0 0 {name=X_43073_ }
C {devices/lab_pin.sym} 84440 -5020 0 0 {name=p84274 lab=_55054_/A }
C {devices/lab_pin.sym} 84440 -4980 0 0 {name=p84275 lab=_54894_/B }
C {devices/lab_pin.sym} 84560 -5000 0 1 {name=p84276 lab=_55059_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -5000 0 0 {name=X_55059_ }
C {devices/lab_pin.sym} 84460 -4870 0 0 {name=p84277 lab=_59935_/X }
C {devices/lab_pin.sym} 84540 -4870 0 1 {name=p84278 lab=_59936_/X }
C {sky130_stdcells/buf_2.sym} 84500 -4870 0 0 {name=X_59936_ }
C {devices/lab_pin.sym} 84440 -4780 0 0 {name=p84279 lab=_78770_/A }
C {devices/lab_pin.sym} 84440 -4740 0 0 {name=p84280 lab=_78770_/B }
C {devices/lab_pin.sym} 84440 -4700 0 0 {name=p84281 lab=_78737_/Y }
C {devices/lab_pin.sym} 84440 -4660 0 0 {name=p84282 lab=_78770_/D }
C {devices/lab_pin.sym} 84560 -4720 0 1 {name=p84283 lab=_78771_/A }
C {sky130_stdcells/and4_4.sym} 84500 -4720 0 0 {name=X_78770_ }
C {devices/lab_pin.sym} 84440 -4580 0 0 {name=p84284 lab=_81514_/Q }
C {devices/lab_pin.sym} 84440 -4540 0 0 {name=p84285 lab=_75982_/B }
C {devices/lab_pin.sym} 84560 -4560 0 1 {name=p84286 lab=_75982_/X }
C {sky130_stdcells/xor2_4.sym} 84500 -4560 0 0 {name=X_75982_ }
C {devices/lab_pin.sym} 84410 -4430 0 0 {name=p84287 lab=_87210_/CLK }
C {devices/lab_pin.sym} 84410 -4410 0 0 {name=p84288 lab=_87968_/D }
C {devices/lab_pin.sym} 84590 -4430 0 1 {name=p84289 lab=_87968_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -4420 0 0 {name=X_87968_ }
C {devices/lab_pin.sym} 84420 -4310 0 0 {name=p84290 lab=_58953_/A }
C {devices/lab_pin.sym} 84420 -4270 0 0 {name=p84291 lab=_46859_/X }
C {devices/lab_pin.sym} 84420 -4230 0 0 {name=p84292 lab=_46900_/Y }
C {devices/lab_pin.sym} 84580 -4270 0 1 {name=p84293 lab=_46901_/Y }
C {sky130_stdcells/o21ai_4.sym} 84500 -4270 0 0 {name=X_46901_ }
C {devices/lab_pin.sym} 84460 -4130 0 0 {name=p84294 lab=_42024_/A }
C {devices/lab_pin.sym} 84540 -4130 0 1 {name=p84295 lab=_42024_/X }
C {sky130_stdcells/buf_2.sym} 84500 -4130 0 0 {name=X_42024_ }
C {devices/lab_pin.sym} 84460 -4010 0 0 {name=p84296 lab=_77721_/A }
C {devices/lab_pin.sym} 84540 -4010 0 1 {name=p84297 lab=_77722_/B }
C {sky130_stdcells/inv_2.sym} 84500 -4010 0 0 {name=X_77721_ }
C {devices/lab_pin.sym} 84460 -3890 0 0 {name=p84298 lab=clkbuf_9_165_0_CLK/X }
C {devices/lab_pin.sym} 84540 -3890 0 1 {name=p84299 lab=_86005_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 84500 -3890 0 0 {name=Xclkbuf_10_331_0_CLK }
C {devices/lab_pin.sym} 84440 -3780 0 0 {name=p84300 lab=_74930_/Y }
C {devices/lab_pin.sym} 84440 -3740 0 0 {name=p84301 lab=_74932_/X }
C {devices/lab_pin.sym} 84560 -3760 0 1 {name=p84302 lab=_74933_/Y }
C {sky130_stdcells/nand2_4.sym} 84500 -3760 0 0 {name=X_74933_ }
C {devices/lab_pin.sym} 84460 -3630 0 0 {name=p84303 lab=_70056_/A }
C {devices/lab_pin.sym} 84540 -3630 0 1 {name=p84304 lab=_70056_/X }
C {sky130_stdcells/buf_2.sym} 84500 -3630 0 0 {name=X_70056_ }
C {devices/lab_pin.sym} 84410 -3510 0 0 {name=p84305 lab=_87141_/CLK }
C {devices/lab_pin.sym} 84410 -3490 0 0 {name=p84306 lab=_86919_/D }
C {devices/lab_pin.sym} 84590 -3510 0 1 {name=p84307 lab=_67915_/B }
C {sky130_stdcells/dfxtp_4.sym} 84500 -3500 0 0 {name=X_86919_ }
C {devices/lab_pin.sym} 84460 -3370 0 0 {name=p84308 lab=_47880_/Y }
C {devices/lab_pin.sym} 84540 -3370 0 1 {name=p84309 lab=_51954_/B }
C {sky130_stdcells/buf_2.sym} 84500 -3370 0 0 {name=X_47881_ }
C {devices/lab_pin.sym} 84460 -3250 0 0 {name=p84310 lab=_57757_/A }
C {devices/lab_pin.sym} 84540 -3250 0 1 {name=p84311 lab=_63130_/A }
C {sky130_stdcells/buf_2.sym} 84500 -3250 0 0 {name=X_59867_ }
C {devices/lab_pin.sym} 84410 -3130 0 0 {name=p84312 lab=_87898_/CLK }
C {devices/lab_pin.sym} 84410 -3110 0 0 {name=p84313 lab=_87899_/D }
C {devices/lab_pin.sym} 84590 -3130 0 1 {name=p84314 lab=_87899_/Q }
C {sky130_stdcells/dfxtp_4.sym} 84500 -3120 0 0 {name=X_87899_ }
C {devices/lab_pin.sym} 84460 -2990 0 0 {name=p84315 lab=clkbuf_9_480_0_CLK/X }
C {devices/lab_pin.sym} 84540 -2990 0 1 {name=p84316 lab=_86558_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 84500 -2990 0 0 {name=Xclkbuf_10_961_0_CLK }
C {devices/lab_pin.sym} 84420 -2890 0 0 {name=p84317 lab=_49618_/Y }
C {devices/lab_pin.sym} 84420 -2850 0 0 {name=p84318 lab=_49596_/X }
C {devices/lab_pin.sym} 84420 -2810 0 0 {name=p84319 lab=_49619_/X }
C {devices/lab_pin.sym} 84580 -2850 0 1 {name=p84320 lab=_86354_/D }
C {sky130_stdcells/a21oi_4.sym} 84500 -2850 0 0 {name=X_49620_ }
C {devices/lab_pin.sym} 84460 -2710 0 0 {name=p84321 lab=_83666_/Q }
C {devices/lab_pin.sym} 84540 -2710 0 1 {name=p84322 lab=_52700_/B }
C {sky130_stdcells/inv_2.sym} 84500 -2710 0 0 {name=X_46832_ }
C {devices/lab_pin.sym} 84440 -2600 0 0 {name=p84323 lab=_58699_/A }
C {devices/lab_pin.sym} 84440 -2560 0 0 {name=p84324 lab=_86381_/Q }
C {devices/lab_pin.sym} 84560 -2580 0 1 {name=p84325 lab=_58818_/Y }
C {sky130_stdcells/nor2_4.sym} 84500 -2580 0 0 {name=X_58818_ }
C {devices/lab_pin.sym} 84440 -2460 0 0 {name=p84326 lab=_77652_/A }
C {devices/lab_pin.sym} 84440 -2420 0 0 {name=p84327 lab=_82110_/D }
C {devices/lab_pin.sym} 84560 -2440 0 1 {name=p84328 lab=_77652_/Y }
C {sky130_stdcells/nor2_4.sym} 84500 -2440 0 0 {name=X_77652_ }
C {devices/lab_pin.sym} 84440 -2320 0 0 {name=p84329 lab=_81125_/D }
C {devices/lab_pin.sym} 84440 -2280 0 0 {name=p84330 lab=_74870_/B }
C {devices/lab_pin.sym} 84560 -2300 0 1 {name=p84331 lab=_74867_/A }
C {sky130_stdcells/xnor2_4.sym} 84500 -2300 0 0 {name=X_74864_ }
C {devices/lab_pin.sym} 84420 -2210 0 0 {name=p84332 lab=_59754_/C }
C {devices/lab_pin.sym} 84420 -2170 0 0 {name=p84333 lab=_59634_/A }
C {devices/lab_pin.sym} 84420 -2130 0 0 {name=p84334 lab=_59634_/B }
C {devices/lab_pin.sym} 84420 -2090 0 0 {name=p84335 lab=_59662_/B }
C {devices/lab_pin.sym} 84420 -2060 0 0 {name=p84336 lab=_59691_/X }
C {devices/lab_pin.sym} 84580 -2130 0 1 {name=p84337 lab=_59798_/Y }
C {sky130_stdcells/a41oi_4.sym} 84500 -2130 0 0 {name=X_59798_ }
C {devices/lab_pin.sym} 84440 -1980 0 0 {name=p84338 lab=_76614_/B }
C {devices/lab_pin.sym} 84440 -1940 0 0 {name=p84339 lab=_76602_/Y }
C {devices/lab_pin.sym} 84560 -1960 0 1 {name=p84340 lab=_76603_/X }
C {sky130_stdcells/and2_4.sym} 84500 -1960 0 0 {name=X_76603_ }
C {devices/lab_pin.sym} 84460 -1830 0 0 {name=p84341 lab=clkbuf_8_226_0_CLK/X }
C {devices/lab_pin.sym} 84540 -1830 0 1 {name=p84342 lab=clkbuf_9_452_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 84500 -1830 0 0 {name=Xclkbuf_9_452_0_CLK }
C {devices/lab_pin.sym} 84460 -1710 0 0 {name=p84343 lab=_49496_/A }
C {devices/lab_pin.sym} 84540 -1710 0 1 {name=p84344 lab=_49551_/X }
C {sky130_stdcells/buf_2.sym} 84500 -1710 0 0 {name=X_49551_ }
C {devices/lab_pin.sym} 84440 -1610 0 0 {name=p84345 lab=_73813_/X }
C {devices/lab_pin.sym} 84440 -1570 0 0 {name=p84346 lab=_73815_/B }
C {devices/lab_pin.sym} 84440 -1530 0 0 {name=p84347 lab=_73815_/C }
C {devices/lab_pin.sym} 84560 -1570 0 1 {name=p84348 lab=_73815_/Y }
C {sky130_stdcells/nand3_4.sym} 84500 -1570 0 0 {name=X_73815_ }
C {devices/lab_pin.sym} 84460 -1430 0 0 {name=p84349 lab=_54353_/D }
C {devices/lab_pin.sym} 84540 -1430 0 1 {name=p84350 lab=_52661_/D }
C {sky130_stdcells/buf_2.sym} 84500 -1430 0 0 {name=X_46763_ }
C {devices/lab_pin.sym} 84460 -1310 0 0 {name=p84351 lab=_58749_/A }
C {devices/lab_pin.sym} 84540 -1310 0 1 {name=p84352 lab=_58763_/A }
C {sky130_stdcells/buf_2.sym} 84500 -1310 0 0 {name=X_58749_ }
C {devices/lab_pin.sym} 84460 -1190 0 0 {name=p84353 lab=_77583_/A }
C {devices/lab_pin.sym} 84540 -1190 0 1 {name=p84354 lab=_77584_/C }
C {sky130_stdcells/inv_2.sym} 84500 -1190 0 0 {name=X_77583_ }
C {devices/lab_pin.sym} 84440 -1080 0 0 {name=p84355 lab=_80667_/Q }
C {devices/lab_pin.sym} 84440 -1040 0 0 {name=p84356 lab=_43975_/B }
C {devices/lab_pin.sym} 84560 -1060 0 1 {name=p84357 lab=_43975_/Y }
C {sky130_stdcells/nor2_4.sym} 84500 -1060 0 0 {name=X_43975_ }
C {devices/lab_pin.sym} 84440 -960 0 0 {name=p84358 lab=_74795_/A }
C {devices/lab_pin.sym} 84440 -920 0 0 {name=p84359 lab=_74804_/C }
C {devices/lab_pin.sym} 84440 -880 0 0 {name=p84360 lab=_74744_/X }
C {devices/lab_pin.sym} 84440 -840 0 0 {name=p84361 lab=_74769_/D }
C {devices/lab_pin.sym} 84560 -900 0 1 {name=p84362 lab=_74798_/B }
C {sky130_stdcells/nand4_4.sym} 84500 -900 0 0 {name=X_74795_ }
C {devices/lab_pin.sym} 84460 -750 0 0 {name=p84363 lab=clkbuf_9_173_0_CLK/X }
C {devices/lab_pin.sym} 84540 -750 0 1 {name=p84364 lab=_86353_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 84500 -750 0 0 {name=Xclkbuf_10_346_0_CLK }
C {devices/lab_pin.sym} 85340 -42170 0 0 {name=p84365 lab=_48494_/Y }
C {devices/lab_pin.sym} 85340 -42130 0 0 {name=p84366 lab=_48459_/X }
C {devices/lab_pin.sym} 85340 -42090 0 0 {name=p84367 lab=_48501_/X }
C {devices/lab_pin.sym} 85500 -42130 0 1 {name=p84368 lab=_86517_/D }
C {sky130_stdcells/a21oi_4.sym} 85420 -42130 0 0 {name=X_48502_ }
C {devices/lab_pin.sym} 85360 -42000 0 0 {name=p84369 lab=_79320_/X }
C {devices/lab_pin.sym} 85360 -41960 0 0 {name=p84370 lab=_79322_/B }
C {devices/lab_pin.sym} 85480 -41980 0 1 {name=p84371 lab=_79322_/Y }
C {sky130_stdcells/xnor2_4.sym} 85420 -41980 0 0 {name=X_79322_ }
C {devices/lab_pin.sym} 85380 -41850 0 0 {name=p84372 lab=_45714_/A }
C {devices/lab_pin.sym} 85460 -41850 0 1 {name=p84373 lab=_45714_/X }
C {sky130_stdcells/buf_2.sym} 85420 -41850 0 0 {name=X_45714_ }
C {devices/lab_pin.sym} 85380 -41730 0 0 {name=p84374 lab=_76533_/Y }
C {devices/lab_pin.sym} 85460 -41730 0 1 {name=p84375 lab=_76534_/Y }
C {sky130_stdcells/inv_2.sym} 85420 -41730 0 0 {name=X_76534_ }
C {devices/lab_pin.sym} 85340 -41640 0 0 {name=p84376 lab=_41731_/X }
C {devices/lab_pin.sym} 85340 -41600 0 0 {name=p84377 lab=_42920_/X }
C {devices/lab_pin.sym} 85340 -41560 0 0 {name=p84378 lab=_87648_/Q }
C {devices/lab_pin.sym} 85340 -41520 0 0 {name=p84379 lab=_42922_/X }
C {devices/lab_pin.sym} 85500 -41580 0 1 {name=p84380 lab=_87648_/D }
C {sky130_stdcells/a2bb2o_4.sym} 85420 -41580 0 0 {name=X_42926_ }
C {devices/lab_pin.sym} 85380 -41430 0 0 {name=p84381 lab=_61842_/A }
C {devices/lab_pin.sym} 85460 -41430 0 1 {name=p84382 lab=_61795_/B }
C {sky130_stdcells/buf_2.sym} 85420 -41430 0 0 {name=X_61760_ }
C {devices/lab_pin.sym} 85340 -41330 0 0 {name=p84383 lab=_86379_/Q }
C {devices/lab_pin.sym} 85340 -41290 0 0 {name=p84384 lab=_49470_/X }
C {devices/lab_pin.sym} 85340 -41250 0 0 {name=p84385 lab=_49481_/Y }
C {devices/lab_pin.sym} 85500 -41290 0 1 {name=p84386 lab=_49482_/Y }
C {sky130_stdcells/o21ai_4.sym} 85420 -41290 0 0 {name=X_49482_ }
C {devices/lab_pin.sym} 85340 -41170 0 0 {name=p84387 lab=_73727_/X }
C {devices/lab_pin.sym} 85340 -41130 0 0 {name=p84388 lab=_73730_/X }
C {devices/lab_pin.sym} 85340 -41090 0 0 {name=p84389 lab=_73745_/X }
C {devices/lab_pin.sym} 85500 -41130 0 1 {name=p84390 lab=_73746_/X }
C {sky130_stdcells/a21o_4.sym} 85420 -41130 0 0 {name=X_73746_ }
C {devices/lab_pin.sym} 85340 -41010 0 0 {name=p84391 lab=_49241_/B }
C {devices/lab_pin.sym} 85340 -40970 0 0 {name=p84392 lab=_70936_/X }
C {devices/lab_pin.sym} 85340 -40930 0 0 {name=p84393 lab=_70957_/Y }
C {devices/lab_pin.sym} 85500 -40970 0 1 {name=p84394 lab=_70958_/Y }
C {sky130_stdcells/o21ai_4.sym} 85420 -40970 0 0 {name=X_70958_ }
C {devices/lab_pin.sym} 85360 -40840 0 0 {name=p84395 lab=_46712_/A }
C {devices/lab_pin.sym} 85360 -40800 0 0 {name=p84396 lab=_51791_/B }
C {devices/lab_pin.sym} 85480 -40820 0 1 {name=p84397 lab=_46694_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -40820 0 0 {name=X_46694_ }
C {devices/lab_pin.sym} 85380 -40690 0 0 {name=p84398 lab=clkbuf_9_488_0_CLK/X }
C {devices/lab_pin.sym} 85460 -40690 0 1 {name=p84399 lab=_86155_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 85420 -40690 0 0 {name=Xclkbuf_10_976_0_CLK }
C {devices/lab_pin.sym} 85380 -40570 0 0 {name=p84400 lab=_60711_/A }
C {devices/lab_pin.sym} 85460 -40570 0 1 {name=p84401 lab=_60711_/X }
C {sky130_stdcells/buf_2.sym} 85420 -40570 0 0 {name=X_60711_ }
C {devices/lab_pin.sym} 85380 -40450 0 0 {name=p84402 lab=_83586_/Q }
C {devices/lab_pin.sym} 85460 -40450 0 1 {name=p84403 lab=_53651_/B }
C {sky130_stdcells/inv_2.sym} 85420 -40450 0 0 {name=X_48433_ }
C {devices/lab_pin.sym} 85340 -40350 0 0 {name=p84404 lab=_79225_/Y }
C {devices/lab_pin.sym} 85340 -40310 0 0 {name=p84405 lab=_79251_/Y }
C {devices/lab_pin.sym} 85340 -40270 0 0 {name=p84406 lab=_79252_/Y }
C {devices/lab_pin.sym} 85500 -40310 0 1 {name=p84407 lab=_79253_/Y }
C {sky130_stdcells/a21oi_4.sym} 85420 -40310 0 0 {name=X_79253_ }
C {devices/lab_pin.sym} 85360 -40180 0 0 {name=p84408 lab=_57137_/A }
C {devices/lab_pin.sym} 85360 -40140 0 0 {name=p84409 lab=_45801_/A }
C {devices/lab_pin.sym} 85480 -40160 0 1 {name=p84410 lab=_45645_/Y }
C {sky130_stdcells/nor2_4.sym} 85420 -40160 0 0 {name=X_45645_ }
C {devices/lab_pin.sym} 85360 -40040 0 0 {name=p84411 lab=_76440_/X }
C {devices/lab_pin.sym} 85360 -40000 0 0 {name=p84412 lab=_76437_/X }
C {devices/lab_pin.sym} 85480 -40020 0 1 {name=p84413 lab=_76482_/C }
C {sky130_stdcells/nand2_4.sym} 85420 -40020 0 0 {name=X_76465_ }
C {devices/lab_pin.sym} 85380 -39890 0 0 {name=p84414 lab=_42856_/Y }
C {devices/lab_pin.sym} 85460 -39890 0 1 {name=p84415 lab=_87684_/D }
C {sky130_stdcells/inv_2.sym} 85420 -39890 0 0 {name=X_42857_ }
C {devices/lab_pin.sym} 85340 -39790 0 0 {name=p84416 lab=_61689_/X }
C {devices/lab_pin.sym} 85340 -39750 0 0 {name=p84417 lab=_61645_/X }
C {devices/lab_pin.sym} 85340 -39710 0 0 {name=p84418 lab=_61690_/Y }
C {devices/lab_pin.sym} 85500 -39750 0 1 {name=p84419 lab=_84459_/D }
C {sky130_stdcells/a21oi_4.sym} 85420 -39750 0 0 {name=X_61691_ }
C {devices/lab_pin.sym} 85360 -39620 0 0 {name=p84420 lab=_73677_/A }
C {devices/lab_pin.sym} 85360 -39580 0 0 {name=p84421 lab=_73599_/B }
C {devices/lab_pin.sym} 85480 -39600 0 1 {name=p84422 lab=_73677_/Y }
C {sky130_stdcells/nor2_4.sym} 85420 -39600 0 0 {name=X_73677_ }
C {devices/lab_pin.sym} 85340 -39490 0 0 {name=p84423 lab=_50971_/B }
C {devices/lab_pin.sym} 85340 -39450 0 0 {name=p84424 lab=_70885_/X }
C {devices/lab_pin.sym} 85340 -39410 0 0 {name=p84425 lab=_70888_/Y }
C {devices/lab_pin.sym} 85500 -39450 0 1 {name=p84426 lab=_70889_/Y }
C {sky130_stdcells/o21ai_4.sym} 85420 -39450 0 0 {name=X_70889_ }
C {devices/lab_pin.sym} 85380 -39310 0 0 {name=p84427 lab=clkbuf_9_467_0_CLK/A }
C {devices/lab_pin.sym} 85460 -39310 0 1 {name=p84428 lab=clkbuf_9_467_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 85420 -39310 0 0 {name=Xclkbuf_9_467_0_CLK }
C {devices/lab_pin.sym} 85360 -39200 0 0 {name=p84429 lab=_78204_/A }
C {devices/lab_pin.sym} 85360 -39160 0 0 {name=p84430 lab=_78204_/B }
C {devices/lab_pin.sym} 85480 -39180 0 1 {name=p84431 lab=_78205_/B }
C {sky130_stdcells/and2_4.sym} 85420 -39180 0 0 {name=X_78204_ }
C {devices/lab_pin.sym} 85360 -39080 0 0 {name=p84432 lab=_64272_/A }
C {devices/lab_pin.sym} 85360 -39040 0 0 {name=p84433 lab=_63465_/B }
C {devices/lab_pin.sym} 85360 -39000 0 0 {name=p84434 lab=_63418_/C }
C {devices/lab_pin.sym} 85360 -38960 0 0 {name=p84435 lab=_63465_/D }
C {devices/lab_pin.sym} 85480 -39020 0 1 {name=p84436 lab=_63430_/Y }
C {sky130_stdcells/nand4_4.sym} 85420 -39020 0 0 {name=X_63430_ }
C {devices/lab_pin.sym} 85380 -38870 0 0 {name=p84437 lab=_75416_/A }
C {devices/lab_pin.sym} 85460 -38870 0 1 {name=p84438 lab=_75416_/Y }
C {sky130_stdcells/inv_2.sym} 85420 -38870 0 0 {name=X_75416_ }
C {devices/lab_pin.sym} 85340 -38790 0 0 {name=p84439 lab=_41802_/X }
C {devices/lab_pin.sym} 85340 -38750 0 0 {name=p84440 lab=_41803_/X }
C {devices/lab_pin.sym} 85340 -38710 0 0 {name=p84441 lab=_40395_/X }
C {devices/lab_pin.sym} 85340 -38670 0 0 {name=p84442 lab=_66704_/B }
C {devices/lab_pin.sym} 85340 -38630 0 0 {name=p84443 lab=_41792_/X }
C {devices/lab_pin.sym} 85500 -38710 0 1 {name=p84444 lab=_41808_/Y }
C {sky130_stdcells/o32ai_4.sym} 85420 -38710 0 0 {name=X_41808_ }
C {devices/lab_pin.sym} 85380 -38550 0 0 {name=p84445 lab=_46485_/X }
C {devices/lab_pin.sym} 85460 -38550 0 1 {name=p84446 lab=_48364_/X }
C {sky130_stdcells/buf_2.sym} 85420 -38550 0 0 {name=X_48364_ }
C {devices/lab_pin.sym} 85360 -38450 0 0 {name=p84447 lab=_60642_/A }
C {devices/lab_pin.sym} 85360 -38410 0 0 {name=p84448 lab=_60638_/Y }
C {devices/lab_pin.sym} 85360 -38370 0 0 {name=p84449 lab=_60642_/C }
C {devices/lab_pin.sym} 85480 -38410 0 1 {name=p84450 lab=_60662_/A }
C {sky130_stdcells/nand3_4.sym} 85420 -38410 0 0 {name=X_60642_ }
C {devices/lab_pin.sym} 85380 -38270 0 0 {name=p84451 lab=_79160_/B }
C {devices/lab_pin.sym} 85460 -38270 0 1 {name=p84452 lab=_79158_/A }
C {sky130_stdcells/inv_2.sym} 85420 -38270 0 0 {name=X_72628_ }
C {devices/lab_pin.sym} 85360 -38160 0 0 {name=p84453 lab=_79184_/A }
C {devices/lab_pin.sym} 85360 -38120 0 0 {name=p84454 lab=_79184_/B }
C {devices/lab_pin.sym} 85480 -38140 0 1 {name=p84455 lab=_79185_/C }
C {sky130_stdcells/nand2_4.sym} 85420 -38140 0 0 {name=X_79184_ }
C {devices/lab_pin.sym} 85340 -38030 0 0 {name=p84456 lab=_55529_/B }
C {devices/lab_pin.sym} 85340 -37990 0 0 {name=p84457 lab=_45464_/X }
C {devices/lab_pin.sym} 85340 -37950 0 0 {name=p84458 lab=_44964_/X }
C {devices/lab_pin.sym} 85500 -37990 0 1 {name=p84459 lab=_45576_/Y }
C {sky130_stdcells/o21ai_4.sym} 85420 -37990 0 0 {name=X_45576_ }
C {devices/lab_pin.sym} 85340 -37870 0 0 {name=p84460 lab=_76392_/Y }
C {devices/lab_pin.sym} 85340 -37830 0 0 {name=p84461 lab=_76394_/Y }
C {devices/lab_pin.sym} 85340 -37790 0 0 {name=p84462 lab=_76395_/Y }
C {devices/lab_pin.sym} 85500 -37830 0 1 {name=p84463 lab=_76396_/X }
C {sky130_stdcells/o21a_4.sym} 85420 -37830 0 0 {name=X_76396_ }
C {devices/lab_pin.sym} 85380 -37690 0 0 {name=p84464 lab=_42822_/A }
C {devices/lab_pin.sym} 85460 -37690 0 1 {name=p84465 lab=_42788_/X }
C {sky130_stdcells/buf_2.sym} 85420 -37690 0 0 {name=X_42788_ }
C {devices/lab_pin.sym} 85360 -37580 0 0 {name=p84466 lab=_47287_/X }
C {devices/lab_pin.sym} 85360 -37540 0 0 {name=p84467 lab=_52979_/B }
C {devices/lab_pin.sym} 85480 -37560 0 1 {name=p84468 lab=_47315_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -37560 0 0 {name=X_47315_ }
C {devices/lab_pin.sym} 85340 -37450 0 0 {name=p84469 lab=_82569_/Q }
C {devices/lab_pin.sym} 85340 -37410 0 0 {name=p84470 lab=_78124_/B }
C {devices/lab_pin.sym} 85340 -37370 0 0 {name=p84471 lab=_78134_/Y }
C {devices/lab_pin.sym} 85500 -37410 0 1 {name=p84472 lab=_78135_/Y }
C {sky130_stdcells/a21oi_4.sym} 85420 -37410 0 0 {name=X_78135_ }
C {devices/lab_pin.sym} 85340 -37310 0 0 {name=p84473 lab=_44512_/X }
C {devices/lab_pin.sym} 85340 -37270 0 0 {name=p84474 lab=_44513_/X }
C {devices/lab_pin.sym} 85340 -37230 0 0 {name=p84475 lab=_40792_/X }
C {devices/lab_pin.sym} 85340 -37190 0 0 {name=p84476 lab=_44526_/Y }
C {devices/lab_pin.sym} 85340 -37150 0 0 {name=p84477 lab=_44516_/X }
C {devices/lab_pin.sym} 85500 -37230 0 1 {name=p84478 lab=_87066_/D }
C {sky130_stdcells/o32ai_4.sym} 85420 -37230 0 0 {name=X_44527_ }
C {devices/lab_pin.sym} 85340 -37110 0 0 {name=p84479 lab=_61315_/A }
C {devices/lab_pin.sym} 85340 -37070 0 0 {name=p84480 lab=_60654_/X }
C {devices/lab_pin.sym} 85340 -37030 0 0 {name=p84481 lab=_60667_/Y }
C {devices/lab_pin.sym} 85340 -36990 0 0 {name=p84482 lab=_60758_/X }
C {devices/lab_pin.sym} 85340 -36950 0 0 {name=p84483 lab=_59477_/A }
C {devices/lab_pin.sym} 85500 -37030 0 1 {name=p84484 lab=_63361_/X }
C {sky130_stdcells/a32o_4.sym} 85420 -37030 0 0 {name=X_63361_ }
C {devices/lab_pin.sym} 85340 -36890 0 0 {name=p84485 lab=_75330_/Y }
C {devices/lab_pin.sym} 85340 -36850 0 0 {name=p84486 lab=_75331_/Y }
C {devices/lab_pin.sym} 85340 -36810 0 0 {name=p84487 lab=_75333_/A }
C {devices/lab_pin.sym} 85500 -36850 0 1 {name=p84488 lab=_75347_/X }
C {sky130_stdcells/o21a_4.sym} 85420 -36850 0 0 {name=X_75347_ }
C {devices/lab_pin.sym} 85360 -36720 0 0 {name=p84489 lab=_82892_/Q }
C {devices/lab_pin.sym} 85360 -36680 0 0 {name=p84490 lab=_41718_/X }
C {devices/lab_pin.sym} 85480 -36700 0 1 {name=p84491 lab=_41739_/X }
C {sky130_stdcells/or2_4.sym} 85420 -36700 0 0 {name=X_41739_ }
C {devices/lab_pin.sym} 85360 -36580 0 0 {name=p84492 lab=_48319_/A }
C {devices/lab_pin.sym} 85360 -36540 0 0 {name=p84493 lab=_50341_/B }
C {devices/lab_pin.sym} 85480 -36560 0 1 {name=p84494 lab=_48295_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -36560 0 0 {name=X_48295_ }
C {devices/lab_pin.sym} 85380 -36430 0 0 {name=p84495 lab=_59831_/X }
C {devices/lab_pin.sym} 85460 -36430 0 1 {name=p84496 lab=_60610_/A }
C {sky130_stdcells/buf_2.sym} 85420 -36430 0 0 {name=X_60573_ }
C {devices/lab_pin.sym} 85340 -36350 0 0 {name=p84497 lab=_60312_/Y }
C {devices/lab_pin.sym} 85340 -36310 0 0 {name=p84498 lab=_72579_/A }
C {devices/lab_pin.sym} 85340 -36270 0 0 {name=p84499 lab=_72556_/Y }
C {devices/lab_pin.sym} 85340 -36230 0 0 {name=p84500 lab=_72557_/Y }
C {devices/lab_pin.sym} 85340 -36190 0 0 {name=p84501 lab=_72558_/X }
C {devices/lab_pin.sym} 85500 -36270 0 1 {name=p84502 lab=_72559_/Y }
C {sky130_stdcells/o41ai_4.sym} 85420 -36270 0 0 {name=X_72559_ }
C {devices/lab_pin.sym} 85360 -36120 0 0 {name=p84503 lab=_64924_/A }
C {devices/lab_pin.sym} 85360 -36080 0 0 {name=p84504 lab=_65100_/B }
C {devices/lab_pin.sym} 85480 -36100 0 1 {name=p84505 lab=_65100_/X }
C {sky130_stdcells/and2_4.sym} 85420 -36100 0 0 {name=X_65100_ }
C {devices/lab_pin.sym} 85360 -35990 0 0 {name=p84506 lab=_62267_/A }
C {devices/lab_pin.sym} 85360 -35950 0 0 {name=p84507 lab=_62267_/B }
C {devices/lab_pin.sym} 85360 -35910 0 0 {name=p84508 lab=_76995_/B }
C {devices/lab_pin.sym} 85480 -35950 0 1 {name=p84509 lab=_62312_/Y }
C {sky130_stdcells/nor3_4.sym} 85420 -35950 0 0 {name=X_62312_ }
C {devices/lab_pin.sym} 85380 -35810 0 0 {name=p84510 lab=_47198_/X }
C {devices/lab_pin.sym} 85460 -35810 0 1 {name=p84511 lab=_47246_/X }
C {sky130_stdcells/buf_2.sym} 85420 -35810 0 0 {name=X_47246_ }
C {devices/lab_pin.sym} 85340 -35710 0 0 {name=p84512 lab=_66077_/Y }
C {devices/lab_pin.sym} 85340 -35670 0 0 {name=p84513 lab=_66065_/X }
C {devices/lab_pin.sym} 85340 -35630 0 0 {name=p84514 lab=_66079_/X }
C {devices/lab_pin.sym} 85500 -35670 0 1 {name=p84515 lab=_84158_/D }
C {sky130_stdcells/a21o_4.sym} 85420 -35670 0 0 {name=X_66080_ }
C {devices/lab_pin.sym} 85360 -35540 0 0 {name=p84516 lab=_78066_/A }
C {devices/lab_pin.sym} 85360 -35500 0 0 {name=p84517 lab=_78066_/B }
C {devices/lab_pin.sym} 85480 -35520 0 1 {name=p84518 lab=_78066_/X }
C {sky130_stdcells/xor2_4.sym} 85420 -35520 0 0 {name=X_78066_ }
C {devices/lab_pin.sym} 85340 -35420 0 0 {name=p84519 lab=_41129_/Y }
C {devices/lab_pin.sym} 85340 -35380 0 0 {name=p84520 lab=_44453_/X }
C {devices/lab_pin.sym} 85340 -35340 0 0 {name=p84521 lab=_87100_/Q }
C {devices/lab_pin.sym} 85340 -35300 0 0 {name=p84522 lab=_44454_/X }
C {devices/lab_pin.sym} 85500 -35360 0 1 {name=p84523 lab=_87100_/D }
C {sky130_stdcells/a2bb2o_4.sym} 85420 -35360 0 0 {name=X_44458_ }
C {devices/lab_pin.sym} 85360 -35240 0 0 {name=p84524 lab=_63216_/X }
C {devices/lab_pin.sym} 85360 -35200 0 0 {name=p84525 lab=_63292_/B }
C {devices/lab_pin.sym} 85360 -35160 0 0 {name=p84526 lab=_63333_/C }
C {devices/lab_pin.sym} 85360 -35120 0 0 {name=p84527 lab=_63240_/X }
C {devices/lab_pin.sym} 85480 -35180 0 1 {name=p84528 lab=_63292_/X }
C {sky130_stdcells/and4_4.sym} 85420 -35180 0 0 {name=X_63292_ }
C {devices/lab_pin.sym} 85380 -35030 0 0 {name=p84529 lab=_75303_/B }
C {devices/lab_pin.sym} 85460 -35030 0 1 {name=p84530 lab=_75284_/A }
C {sky130_stdcells/inv_2.sym} 85420 -35030 0 0 {name=X_75278_ }
C {devices/lab_pin.sym} 85360 -34920 0 0 {name=p84531 lab=_65031_/A }
C {devices/lab_pin.sym} 85360 -34880 0 0 {name=p84532 lab=_65031_/B }
C {devices/lab_pin.sym} 85480 -34900 0 1 {name=p84533 lab=_65031_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -34900 0 0 {name=X_65031_ }
C {devices/lab_pin.sym} 85360 -34780 0 0 {name=p84534 lab=_77017_/A }
C {devices/lab_pin.sym} 85360 -34740 0 0 {name=p84535 lab=_77017_/B }
C {devices/lab_pin.sym} 85480 -34760 0 1 {name=p84536 lab=_82365_/D }
C {sky130_stdcells/xnor2_4.sym} 85420 -34760 0 0 {name=X_77017_ }
C {devices/lab_pin.sym} 85380 -34630 0 0 {name=p84537 lab=_43408_/Y }
C {devices/lab_pin.sym} 85460 -34630 0 1 {name=p84538 lab=_43409_/Y }
C {sky130_stdcells/inv_2.sym} 85420 -34630 0 0 {name=X_43409_ }
C {devices/lab_pin.sym} 85380 -34510 0 0 {name=p84539 lab=_62218_/A }
C {devices/lab_pin.sym} 85460 -34510 0 1 {name=p84540 lab=_62244_/C }
C {sky130_stdcells/buf_2.sym} 85420 -34510 0 0 {name=X_62243_ }
C {devices/lab_pin.sym} 85340 -34410 0 0 {name=p84541 lab=_88342_/Q }
C {devices/lab_pin.sym} 85340 -34370 0 0 {name=p84542 lab=_72865_/X }
C {devices/lab_pin.sym} 85340 -34330 0 0 {name=p84543 lab=_72982_/X }
C {devices/lab_pin.sym} 85500 -34370 0 1 {name=p84544 lab=_74229_/Y }
C {sky130_stdcells/o21ai_4.sym} 85420 -34370 0 0 {name=X_74229_ }
C {devices/lab_pin.sym} 85380 -34230 0 0 {name=p84545 lab=_47128_/A }
C {devices/lab_pin.sym} 85460 -34230 0 1 {name=p84546 lab=_47177_/X }
C {sky130_stdcells/buf_2.sym} 85420 -34230 0 0 {name=X_47177_ }
C {devices/lab_pin.sym} 85340 -34140 0 0 {name=p84547 lab=_41465_/X }
C {devices/lab_pin.sym} 85340 -34100 0 0 {name=p84548 lab=_44377_/X }
C {devices/lab_pin.sym} 85340 -34060 0 0 {name=p84549 lab=_87134_/Q }
C {devices/lab_pin.sym} 85340 -34020 0 0 {name=p84550 lab=_44379_/X }
C {devices/lab_pin.sym} 85500 -34080 0 1 {name=p84551 lab=_87134_/D }
C {sky130_stdcells/a2bb2o_4.sym} 85420 -34080 0 0 {name=X_44389_ }
C {devices/lab_pin.sym} 85380 -33930 0 0 {name=p84552 lab=clkbuf_9_457_0_CLK/X }
C {devices/lab_pin.sym} 85460 -33930 0 1 {name=p84553 lab=_83139_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 85420 -33930 0 0 {name=Xclkbuf_10_914_0_CLK }
C {devices/lab_pin.sym} 85360 -33840 0 0 {name=p84554 lab=_46128_/A }
C {devices/lab_pin.sym} 85360 -33800 0 0 {name=p84555 lab=_46204_/D }
C {devices/lab_pin.sym} 85360 -33760 0 0 {name=p84556 lab=_46143_/A }
C {devices/lab_pin.sym} 85360 -33720 0 0 {name=p84557 lab=_46128_/D }
C {devices/lab_pin.sym} 85480 -33780 0 1 {name=p84558 lab=_46133_/A }
C {sky130_stdcells/and4_4.sym} 85420 -33780 0 0 {name=X_46128_ }
C {devices/lab_pin.sym} 85380 -33630 0 0 {name=p84559 lab=_58990_/A }
C {devices/lab_pin.sym} 85460 -33630 0 1 {name=p84560 lab=_62174_/X }
C {sky130_stdcells/buf_2.sym} 85420 -33630 0 0 {name=X_62174_ }
C {devices/lab_pin.sym} 85380 -33510 0 0 {name=p84561 lab=clkbuf_9_1_0_CLK/X }
C {devices/lab_pin.sym} 85460 -33510 0 1 {name=p84562 lab=_85241_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 85420 -33510 0 0 {name=Xclkbuf_10_3_0_CLK }
C {devices/lab_pin.sym} 85380 -33390 0 0 {name=p84563 lab=clkbuf_5_30_0_CLK/A }
C {devices/lab_pin.sym} 85460 -33390 0 1 {name=p84564 lab=clkbuf_6_63_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 85420 -33390 0 0 {name=Xclkbuf_5_31_0_CLK }
C {devices/lab_pin.sym} 85380 -33270 0 0 {name=p84565 lab=clkbuf_8_202_0_CLK/X }
C {devices/lab_pin.sym} 85460 -33270 0 1 {name=p84566 lab=clkbuf_9_405_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 85420 -33270 0 0 {name=Xclkbuf_9_405_0_CLK }
C {devices/lab_pin.sym} 85360 -33170 0 0 {name=p84567 lab=_61125_/A }
C {devices/lab_pin.sym} 85360 -33130 0 0 {name=p84568 lab=_64203_/B }
C {devices/lab_pin.sym} 85360 -33090 0 0 {name=p84569 lab=_64525_/B }
C {devices/lab_pin.sym} 85480 -33130 0 1 {name=p84570 lab=_61188_/B }
C {sky130_stdcells/nand3_4.sym} 85420 -33130 0 0 {name=X_61125_ }
C {devices/lab_pin.sym} 85340 -33020 0 0 {name=p84571 lab=_41552_/A }
C {devices/lab_pin.sym} 85340 -32980 0 0 {name=p84572 lab=_46043_/X }
C {devices/lab_pin.sym} 85340 -32940 0 0 {name=p84573 lab=_66985_/B }
C {devices/lab_pin.sym} 85340 -32900 0 0 {name=p84574 lab=_46044_/X }
C {devices/lab_pin.sym} 85500 -32960 0 1 {name=p84575 lab=_86789_/D }
C {sky130_stdcells/a2bb2o_4.sym} 85420 -32960 0 0 {name=X_46059_ }
C {devices/lab_pin.sym} 85360 -32820 0 0 {name=p84576 lab=_69770_/A }
C {devices/lab_pin.sym} 85360 -32780 0 0 {name=p84577 lab=_88324_/Q }
C {devices/lab_pin.sym} 85480 -32800 0 1 {name=p84578 lab=_69770_/X }
C {sky130_stdcells/and2_4.sym} 85420 -32800 0 0 {name=X_69770_ }
C {devices/lab_pin.sym} 85360 -32680 0 0 {name=p84579 lab=_67057_/A }
C {devices/lab_pin.sym} 85360 -32640 0 0 {name=p84580 lab=_66982_/B }
C {devices/lab_pin.sym} 85480 -32660 0 1 {name=p84581 lab=_66982_/X }
C {sky130_stdcells/and2_4.sym} 85420 -32660 0 0 {name=X_66982_ }
C {devices/lab_pin.sym} 85360 -32540 0 0 {name=p84582 lab=_78968_/A }
C {devices/lab_pin.sym} 85360 -32500 0 0 {name=p84583 lab=_78967_/Y }
C {devices/lab_pin.sym} 85480 -32520 0 1 {name=p84584 lab=_78969_/A }
C {sky130_stdcells/xor2_4.sym} 85420 -32520 0 0 {name=X_78968_ }
C {devices/lab_pin.sym} 85380 -32390 0 0 {name=p84585 lab=_68721_/A }
C {devices/lab_pin.sym} 85460 -32390 0 1 {name=p84586 lab=_69956_/A }
C {sky130_stdcells/buf_2.sym} 85420 -32390 0 0 {name=X_68721_ }
C {devices/lab_pin.sym} 85340 -32300 0 0 {name=p84587 lab=_65845_/X }
C {devices/lab_pin.sym} 85340 -32260 0 0 {name=p84588 lab=_86239_/Q }
C {devices/lab_pin.sym} 85340 -32220 0 0 {name=p84589 lab=_65904_/X }
C {devices/lab_pin.sym} 85340 -32180 0 0 {name=p84590 lab=_65932_/X }
C {devices/lab_pin.sym} 85500 -32240 0 1 {name=p84591 lab=_65933_/X }
C {sky130_stdcells/a211o_4.sym} 85420 -32240 0 0 {name=X_65933_ }
C {devices/lab_pin.sym} 85340 -32130 0 0 {name=p84592 lab=_60961_/X }
C {devices/lab_pin.sym} 85340 -32090 0 0 {name=p84593 lab=_60908_/X }
C {devices/lab_pin.sym} 85340 -32050 0 0 {name=p84594 lab=_63738_/B }
C {devices/lab_pin.sym} 85340 -32010 0 0 {name=p84595 lab=_60995_/Y }
C {devices/lab_pin.sym} 85340 -31970 0 0 {name=p84596 lab=_61055_/X }
C {devices/lab_pin.sym} 85500 -32050 0 1 {name=p84597 lab=_61056_/X }
C {sky130_stdcells/o41a_4.sym} 85420 -32050 0 0 {name=X_61056_ }
C {devices/lab_pin.sym} 85360 -31900 0 0 {name=p84598 lab=_82247_/Q }
C {devices/lab_pin.sym} 85360 -31860 0 0 {name=p84599 lab=_77919_/B }
C {devices/lab_pin.sym} 85480 -31880 0 1 {name=p84600 lab=_77919_/Y }
C {sky130_stdcells/xnor2_4.sym} 85420 -31880 0 0 {name=X_77919_ }
C {devices/lab_pin.sym} 85380 -31750 0 0 {name=p84601 lab=clkbuf_9_464_0_CLK/X }
C {devices/lab_pin.sym} 85460 -31750 0 1 {name=p84602 lab=_88108_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 85420 -31750 0 0 {name=Xclkbuf_10_929_0_CLK }
C {devices/lab_pin.sym} 85360 -31640 0 0 {name=p84603 lab=_78894_/Y }
C {devices/lab_pin.sym} 85360 -31600 0 0 {name=p84604 lab=_78898_/Y }
C {devices/lab_pin.sym} 85480 -31620 0 1 {name=p84605 lab=_78899_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -31620 0 0 {name=X_78899_ }
C {devices/lab_pin.sym} 85380 -31490 0 0 {name=p84606 lab=_60007_/A }
C {devices/lab_pin.sym} 85460 -31490 0 1 {name=p84607 lab=_84675_/D }
C {sky130_stdcells/inv_2.sym} 85420 -31490 0 0 {name=X_60007_ }
C {devices/lab_pin.sym} 85360 -31400 0 0 {name=p84608 lab=_49830_/A }
C {devices/lab_pin.sym} 85360 -31360 0 0 {name=p84609 lab=_49830_/B }
C {devices/lab_pin.sym} 85360 -31320 0 0 {name=p84610 lab=_49795_/X }
C {devices/lab_pin.sym} 85360 -31280 0 0 {name=p84611 lab=_53031_/D }
C {devices/lab_pin.sym} 85480 -31340 0 1 {name=p84612 lab=_49818_/X }
C {sky130_stdcells/and4_4.sym} 85420 -31340 0 0 {name=X_49818_ }
C {devices/lab_pin.sym} 85330 -31190 0 0 {name=p84613 lab=_81059_/CLK }
C {devices/lab_pin.sym} 85330 -31170 0 0 {name=p84614 lab=_75079_/B }
C {devices/lab_pin.sym} 85510 -31190 0 1 {name=p84615 lab=_80930_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -31180 0 0 {name=X_80930_ }
C {devices/lab_pin.sym} 85360 -31060 0 0 {name=p84616 lab=_68599_/A }
C {devices/lab_pin.sym} 85360 -31020 0 0 {name=p84617 lab=_87752_/Q }
C {devices/lab_pin.sym} 85480 -31040 0 1 {name=p84618 lab=_68652_/X }
C {sky130_stdcells/and2_4.sym} 85420 -31040 0 0 {name=X_68652_ }
C {devices/lab_pin.sym} 85380 -30910 0 0 {name=p84619 lab=_64683_/A }
C {devices/lab_pin.sym} 85460 -30910 0 1 {name=p84620 lab=_65868_/B }
C {sky130_stdcells/buf_2.sym} 85420 -30910 0 0 {name=X_65864_ }
C {devices/lab_pin.sym} 85360 -30800 0 0 {name=p84621 lab=_67675_/A }
C {devices/lab_pin.sym} 85360 -30760 0 0 {name=p84622 lab=_87656_/Q }
C {devices/lab_pin.sym} 85480 -30780 0 1 {name=p84623 lab=_67603_/X }
C {sky130_stdcells/and2_4.sym} 85420 -30780 0 0 {name=X_67603_ }
C {devices/lab_pin.sym} 85360 -30670 0 0 {name=p84624 lab=_64637_/X }
C {devices/lab_pin.sym} 85360 -30630 0 0 {name=p84625 lab=_64913_/B }
C {devices/lab_pin.sym} 85360 -30590 0 0 {name=p84626 lab=_84226_/Q }
C {devices/lab_pin.sym} 85480 -30630 0 1 {name=p84627 lab=_64815_/X }
C {sky130_stdcells/and3_4.sym} 85420 -30630 0 0 {name=X_64815_ }
C {devices/lab_pin.sym} 85340 -30510 0 0 {name=p84628 lab=_57832_/B }
C {devices/lab_pin.sym} 85340 -30470 0 0 {name=p84629 lab=_49742_/X }
C {devices/lab_pin.sym} 85340 -30430 0 0 {name=p84630 lab=_49748_/Y }
C {devices/lab_pin.sym} 85500 -30470 0 1 {name=p84631 lab=_49749_/Y }
C {sky130_stdcells/o21ai_4.sym} 85420 -30470 0 0 {name=X_49749_ }
C {devices/lab_pin.sym} 85340 -30350 0 0 {name=p84632 lab=_68579_/X }
C {devices/lab_pin.sym} 85340 -30310 0 0 {name=p84633 lab=_68582_/X }
C {devices/lab_pin.sym} 85340 -30270 0 0 {name=p84634 lab=_68512_/X }
C {devices/lab_pin.sym} 85500 -30310 0 1 {name=p84635 lab=_68583_/Y }
C {sky130_stdcells/a21oi_4.sym} 85420 -30310 0 0 {name=X_68583_ }
C {devices/lab_pin.sym} 85330 -30170 0 0 {name=p84636 lab=_80740_/CLK }
C {devices/lab_pin.sym} 85330 -30150 0 0 {name=p84637 lab=_80893_/Q }
C {devices/lab_pin.sym} 85510 -30170 0 1 {name=p84638 lab=_75040_/B }
C {sky130_stdcells/dfxtp_4.sym} 85420 -30160 0 0 {name=X_80861_ }
C {devices/lab_pin.sym} 85340 -30060 0 0 {name=p84639 lab=_65717_/X }
C {devices/lab_pin.sym} 85340 -30020 0 0 {name=p84640 lab=_85577_/Q }
C {devices/lab_pin.sym} 85340 -29980 0 0 {name=p84641 lab=_65718_/X }
C {devices/lab_pin.sym} 85340 -29940 0 0 {name=p84642 lab=_65794_/X }
C {devices/lab_pin.sym} 85500 -30000 0 1 {name=p84643 lab=_65795_/X }
C {sky130_stdcells/a211o_4.sym} 85420 -30000 0 0 {name=X_65795_ }
C {devices/lab_pin.sym} 85330 -29850 0 0 {name=p84644 lab=_82924_/CLK }
C {devices/lab_pin.sym} 85330 -29830 0 0 {name=p84645 lab=_78862_/B }
C {devices/lab_pin.sym} 85510 -29850 0 1 {name=p84646 lab=_82568_/D }
C {sky130_stdcells/dfxtp_4.sym} 85420 -29840 0 0 {name=X_82600_ }
C {devices/lab_pin.sym} 85360 -29720 0 0 {name=p84647 lab=_67460_/A }
C {devices/lab_pin.sym} 85360 -29680 0 0 {name=p84648 lab=_87659_/Q }
C {devices/lab_pin.sym} 85480 -29700 0 1 {name=p84649 lab=_67534_/X }
C {sky130_stdcells/and2_4.sym} 85420 -29700 0 0 {name=X_67534_ }
C {devices/lab_pin.sym} 85360 -29580 0 0 {name=p84650 lab=_52744_/A }
C {devices/lab_pin.sym} 85360 -29540 0 0 {name=p84651 lab=_52760_/B }
C {devices/lab_pin.sym} 85480 -29560 0 1 {name=p84652 lab=_52760_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -29560 0 0 {name=X_52760_ }
C {devices/lab_pin.sym} 85340 -29460 0 0 {name=p84653 lab=_64678_/X }
C {devices/lab_pin.sym} 85340 -29420 0 0 {name=p84654 lab=_85532_/Q }
C {devices/lab_pin.sym} 85340 -29380 0 0 {name=p84655 lab=_64679_/X }
C {devices/lab_pin.sym} 85340 -29340 0 0 {name=p84656 lab=_64745_/X }
C {devices/lab_pin.sym} 85500 -29400 0 1 {name=p84657 lab=_64746_/X }
C {sky130_stdcells/a211o_4.sym} 85420 -29400 0 0 {name=X_64746_ }
C {devices/lab_pin.sym} 85330 -29250 0 0 {name=p84658 lab=_83068_/CLK }
C {devices/lab_pin.sym} 85330 -29230 0 0 {name=p84659 lab=_71182_/Y }
C {devices/lab_pin.sym} 85510 -29250 0 1 {name=p84660 lab=_48503_/A }
C {sky130_stdcells/dfxtp_4.sym} 85420 -29240 0 0 {name=X_83580_ }
C {devices/lab_pin.sym} 85330 -29110 0 0 {name=p84661 lab=_80792_/CLK }
C {devices/lab_pin.sym} 85330 -29090 0 0 {name=p84662 lab=_75781_/Y }
C {devices/lab_pin.sym} 85510 -29110 0 1 {name=p84663 lab=_75408_/A }
C {sky130_stdcells/dfxtp_4.sym} 85420 -29100 0 0 {name=X_80792_ }
C {devices/lab_pin.sym} 85380 -28970 0 0 {name=p84664 lab=clkbuf_6_5_0_CLK/A }
C {devices/lab_pin.sym} 85460 -28970 0 1 {name=p84665 lab=clkbuf_6_5_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 85420 -28970 0 0 {name=Xclkbuf_6_5_0_CLK }
C {devices/lab_pin.sym} 85340 -28890 0 0 {name=p84666 lab=_61947_/X }
C {devices/lab_pin.sym} 85340 -28850 0 0 {name=p84667 lab=_61950_/X }
C {devices/lab_pin.sym} 85340 -28810 0 0 {name=p84668 lab=_61957_/Y }
C {devices/lab_pin.sym} 85340 -28770 0 0 {name=p84669 lab=_84739_/Q }
C {devices/lab_pin.sym} 85340 -28730 0 0 {name=p84670 lab=_61895_/X }
C {devices/lab_pin.sym} 85500 -28810 0 1 {name=p84671 lab=_61958_/Y }
C {sky130_stdcells/o32ai_4.sym} 85420 -28810 0 0 {name=X_61958_ }
C {devices/lab_pin.sym} 85340 -28670 0 0 {name=p84672 lab=_51708_/Y }
C {devices/lab_pin.sym} 85340 -28630 0 0 {name=p84673 lab=_51693_/X }
C {devices/lab_pin.sym} 85340 -28590 0 0 {name=p84674 lab=_51710_/X }
C {devices/lab_pin.sym} 85500 -28630 0 1 {name=p84675 lab=_85960_/D }
C {sky130_stdcells/a21oi_4.sym} 85420 -28630 0 0 {name=X_51711_ }
C {devices/lab_pin.sym} 85330 -28490 0 0 {name=p84676 lab=_82531_/CLK }
C {devices/lab_pin.sym} 85330 -28470 0 0 {name=p84677 lab=_82531_/D }
C {devices/lab_pin.sym} 85510 -28490 0 1 {name=p84678 lab=_78960_/B }
C {sky130_stdcells/dfxtp_4.sym} 85420 -28480 0 0 {name=X_82531_ }
C {devices/lab_pin.sym} 85380 -28350 0 0 {name=p84679 lab=_60909_/A }
C {devices/lab_pin.sym} 85460 -28350 0 1 {name=p84680 lab=_60909_/X }
C {sky130_stdcells/buf_2.sym} 85420 -28350 0 0 {name=X_60909_ }
C {devices/lab_pin.sym} 85340 -28250 0 0 {name=p84681 lab=_67461_/X }
C {devices/lab_pin.sym} 85340 -28210 0 0 {name=p84682 lab=_67464_/X }
C {devices/lab_pin.sym} 85340 -28170 0 0 {name=p84683 lab=_67442_/X }
C {devices/lab_pin.sym} 85500 -28210 0 1 {name=p84684 lab=_67465_/X }
C {sky130_stdcells/a21o_4.sym} 85420 -28210 0 0 {name=X_67465_ }
C {devices/lab_pin.sym} 85340 -28090 0 0 {name=p84685 lab=_52687_/Y }
C {devices/lab_pin.sym} 85340 -28050 0 0 {name=p84686 lab=_52673_/X }
C {devices/lab_pin.sym} 85340 -28010 0 0 {name=p84687 lab=_52690_/X }
C {devices/lab_pin.sym} 85500 -28050 0 1 {name=p84688 lab=_52691_/Y }
C {sky130_stdcells/a21oi_4.sym} 85420 -28050 0 0 {name=X_52691_ }
C {devices/lab_pin.sym} 85340 -27940 0 0 {name=p84689 lab=_64650_/X }
C {devices/lab_pin.sym} 85340 -27900 0 0 {name=p84690 lab=_86174_/Q }
C {devices/lab_pin.sym} 85340 -27860 0 0 {name=p84691 lab=_64583_/X }
C {devices/lab_pin.sym} 85340 -27820 0 0 {name=p84692 lab=_64676_/X }
C {devices/lab_pin.sym} 85500 -27880 0 1 {name=p84693 lab=_64677_/X }
C {sky130_stdcells/a211o_4.sym} 85420 -27880 0 0 {name=X_64677_ }
C {devices/lab_pin.sym} 85360 -27760 0 0 {name=p84694 lab=_61448_/X }
C {devices/lab_pin.sym} 85360 -27720 0 0 {name=p84695 lab=_61874_/B }
C {devices/lab_pin.sym} 85360 -27680 0 0 {name=p84696 lab=_61907_/C }
C {devices/lab_pin.sym} 85360 -27640 0 0 {name=p84697 lab=_61874_/D }
C {devices/lab_pin.sym} 85480 -27700 0 1 {name=p84698 lab=_61889_/Y }
C {sky130_stdcells/nand4_4.sym} 85420 -27700 0 0 {name=X_61889_ }
C {devices/lab_pin.sym} 85340 -27580 0 0 {name=p84699 lab=_88046_/Q }
C {devices/lab_pin.sym} 85340 -27540 0 0 {name=p84700 lab=_69162_/X }
C {devices/lab_pin.sym} 85340 -27500 0 0 {name=p84701 lab=_69202_/X }
C {devices/lab_pin.sym} 85340 -27460 0 0 {name=p84702 lab=_69203_/X }
C {devices/lab_pin.sym} 85500 -27520 0 1 {name=p84703 lab=_69204_/X }
C {sky130_stdcells/a211o_4.sym} 85420 -27520 0 0 {name=X_69204_ }
C {devices/lab_pin.sym} 85340 -27390 0 0 {name=p84704 lab=_54426_/Y }
C {devices/lab_pin.sym} 85340 -27350 0 0 {name=p84705 lab=_54422_/X }
C {devices/lab_pin.sym} 85340 -27310 0 0 {name=p84706 lab=_54429_/X }
C {devices/lab_pin.sym} 85500 -27350 0 1 {name=p84707 lab=_85444_/D }
C {sky130_stdcells/a21oi_4.sym} 85420 -27350 0 0 {name=X_54430_ }
C {devices/lab_pin.sym} 85340 -27230 0 0 {name=p84708 lab=_66413_/Y }
C {devices/lab_pin.sym} 85340 -27190 0 0 {name=p84709 lab=_66414_/X }
C {devices/lab_pin.sym} 85340 -27150 0 0 {name=p84710 lab=_66415_/X }
C {devices/lab_pin.sym} 85500 -27190 0 1 {name=p84711 lab=_66416_/X }
C {sky130_stdcells/a21o_4.sym} 85420 -27190 0 0 {name=X_66416_ }
C {devices/lab_pin.sym} 85330 -27050 0 0 {name=p84712 lab=_85250_/CLK }
C {devices/lab_pin.sym} 85330 -27030 0 0 {name=p84713 lab=_56281_/Y }
C {devices/lab_pin.sym} 85510 -27050 0 1 {name=p84714 lab=_56280_/C }
C {sky130_stdcells/dfxtp_4.sym} 85420 -27040 0 0 {name=X_85250_ }
C {devices/lab_pin.sym} 85340 -26930 0 0 {name=p84715 lab=_51638_/Y }
C {devices/lab_pin.sym} 85340 -26890 0 0 {name=p84716 lab=_51639_/X }
C {devices/lab_pin.sym} 85340 -26850 0 0 {name=p84717 lab=_51641_/X }
C {devices/lab_pin.sym} 85500 -26890 0 1 {name=p84718 lab=_85973_/D }
C {sky130_stdcells/a21oi_4.sym} 85420 -26890 0 0 {name=X_51642_ }
C {devices/lab_pin.sym} 85340 -26780 0 0 {name=p84719 lab=_58396_/Y }
C {devices/lab_pin.sym} 85340 -26740 0 0 {name=p84720 lab=_63626_/X }
C {devices/lab_pin.sym} 85340 -26700 0 0 {name=p84721 lab=_61597_/A }
C {devices/lab_pin.sym} 85340 -26660 0 0 {name=p84722 lab=_63627_/X }
C {devices/lab_pin.sym} 85500 -26720 0 1 {name=p84723 lab=_63628_/X }
C {sky130_stdcells/a2bb2o_4.sym} 85420 -26720 0 0 {name=X_63628_ }
C {devices/lab_pin.sym} 85330 -26570 0 0 {name=p84724 lab=_82462_/CLK }
C {devices/lab_pin.sym} 85330 -26550 0 0 {name=p84725 lab=_82462_/D }
C {devices/lab_pin.sym} 85510 -26570 0 1 {name=p84726 lab=_82462_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -26560 0 0 {name=X_82462_ }
C {devices/lab_pin.sym} 85340 -26460 0 0 {name=p84727 lab=_87473_/Q }
C {devices/lab_pin.sym} 85340 -26420 0 0 {name=p84728 lab=_67394_/X }
C {devices/lab_pin.sym} 85340 -26380 0 0 {name=p84729 lab=_67344_/X }
C {devices/lab_pin.sym} 85340 -26340 0 0 {name=p84730 lab=_67395_/X }
C {devices/lab_pin.sym} 85500 -26400 0 1 {name=p84731 lab=_67396_/X }
C {sky130_stdcells/a211o_4.sym} 85420 -26400 0 0 {name=X_67396_ }
C {devices/lab_pin.sym} 85330 -26250 0 0 {name=p84732 lab=_85315_/CLK }
C {devices/lab_pin.sym} 85330 -26230 0 0 {name=p84733 lab=_84201_/D }
C {devices/lab_pin.sym} 85510 -26250 0 1 {name=p84734 lab=_84201_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -26240 0 0 {name=X_84201_ }
C {devices/lab_pin.sym} 85330 -26110 0 0 {name=p84735 lab=_82053_/CLK }
C {devices/lab_pin.sym} 85330 -26090 0 0 {name=p84736 lab=_81445_/Q }
C {devices/lab_pin.sym} 85510 -26110 0 1 {name=p84737 lab=_75940_/B }
C {sky130_stdcells/dfxtp_4.sym} 85420 -26100 0 0 {name=X_81413_ }
C {devices/lab_pin.sym} 85340 -26000 0 0 {name=p84738 lab=_88051_/Q }
C {devices/lab_pin.sym} 85340 -25960 0 0 {name=p84739 lab=_69121_/X }
C {devices/lab_pin.sym} 85340 -25920 0 0 {name=p84740 lab=_69051_/X }
C {devices/lab_pin.sym} 85340 -25880 0 0 {name=p84741 lab=_69134_/X }
C {devices/lab_pin.sym} 85500 -25940 0 1 {name=p84742 lab=_69135_/X }
C {sky130_stdcells/a211o_4.sym} 85420 -25940 0 0 {name=X_69135_ }
C {devices/lab_pin.sym} 85340 -25810 0 0 {name=p84743 lab=_85456_/Q }
C {devices/lab_pin.sym} 85340 -25770 0 0 {name=p84744 lab=_54349_/X }
C {devices/lab_pin.sym} 85340 -25730 0 0 {name=p84745 lab=_54360_/Y }
C {devices/lab_pin.sym} 85500 -25770 0 1 {name=p84746 lab=_54361_/Y }
C {sky130_stdcells/o21ai_4.sym} 85420 -25770 0 0 {name=X_54361_ }
C {devices/lab_pin.sym} 85360 -25640 0 0 {name=p84747 lab=_66267_/X }
C {devices/lab_pin.sym} 85360 -25600 0 0 {name=p84748 lab=_85890_/Q }
C {devices/lab_pin.sym} 85480 -25620 0 1 {name=p84749 lab=_66347_/X }
C {sky130_stdcells/and2_4.sym} 85420 -25620 0 0 {name=X_66347_ }
C {devices/lab_pin.sym} 85330 -25490 0 0 {name=p84750 lab=_85180_/CLK }
C {devices/lab_pin.sym} 85330 -25470 0 0 {name=p84751 lab=_85181_/D }
C {devices/lab_pin.sym} 85510 -25490 0 1 {name=p84752 lab=_55949_/B }
C {sky130_stdcells/dfxtp_4.sym} 85420 -25480 0 0 {name=X_85181_ }
C {devices/lab_pin.sym} 85340 -25370 0 0 {name=p84753 lab=_85985_/Q }
C {devices/lab_pin.sym} 85340 -25330 0 0 {name=p84754 lab=_51566_/X }
C {devices/lab_pin.sym} 85340 -25290 0 0 {name=p84755 lab=_51572_/Y }
C {devices/lab_pin.sym} 85500 -25330 0 1 {name=p84756 lab=_51573_/Y }
C {sky130_stdcells/o21ai_4.sym} 85420 -25330 0 0 {name=X_51573_ }
C {devices/lab_pin.sym} 85380 -25190 0 0 {name=p84757 lab=_63372_/A }
C {devices/lab_pin.sym} 85460 -25190 0 1 {name=p84758 lab=_63559_/X }
C {sky130_stdcells/buf_2.sym} 85420 -25190 0 0 {name=X_63559_ }
C {devices/lab_pin.sym} 85330 -25070 0 0 {name=p84759 lab=_86104_/CLK }
C {devices/lab_pin.sym} 85330 -25050 0 0 {name=p84760 lab=_82393_/D }
C {devices/lab_pin.sym} 85510 -25070 0 1 {name=p84761 lab=_82393_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -25060 0 0 {name=X_82393_ }
C {devices/lab_pin.sym} 85360 -24950 0 0 {name=p84762 lab=_56100_/A }
C {devices/lab_pin.sym} 85360 -24910 0 0 {name=p84763 lab=_56115_/B }
C {devices/lab_pin.sym} 85360 -24870 0 0 {name=p84764 lab=_85296_/Q }
C {devices/lab_pin.sym} 85480 -24910 0 1 {name=p84765 lab=_56100_/Y }
C {sky130_stdcells/nand3_4.sym} 85420 -24910 0 0 {name=X_56100_ }
C {devices/lab_pin.sym} 85360 -24800 0 0 {name=p84766 lab=_53330_/A }
C {devices/lab_pin.sym} 85360 -24760 0 0 {name=p84767 lab=_53293_/B }
C {devices/lab_pin.sym} 85360 -24720 0 0 {name=p84768 lab=_53302_/X }
C {devices/lab_pin.sym} 85360 -24680 0 0 {name=p84769 lab=_52797_/D }
C {devices/lab_pin.sym} 85480 -24740 0 1 {name=p84770 lab=_53312_/X }
C {sky130_stdcells/and4_4.sym} 85420 -24740 0 0 {name=X_53312_ }
C {devices/lab_pin.sym} 85330 -24590 0 0 {name=p84771 lab=_82975_/CLK }
C {devices/lab_pin.sym} 85330 -24570 0 0 {name=p84772 lab=_84132_/D }
C {devices/lab_pin.sym} 85510 -24590 0 1 {name=p84773 lab=_79455_/B }
C {sky130_stdcells/dfxtp_4.sym} 85420 -24580 0 0 {name=X_84132_ }
C {devices/lab_pin.sym} 85380 -24450 0 0 {name=p84774 lab=_51010_/A }
C {devices/lab_pin.sym} 85460 -24450 0 1 {name=p84775 lab=_50551_/A }
C {sky130_stdcells/buf_2.sym} 85420 -24450 0 0 {name=X_50524_ }
C {devices/lab_pin.sym} 85340 -24350 0 0 {name=p84776 lab=_56976_/X }
C {devices/lab_pin.sym} 85340 -24310 0 0 {name=p84777 lab=_57318_/D }
C {devices/lab_pin.sym} 85340 -24270 0 0 {name=p84778 lab=_46178_/X }
C {devices/lab_pin.sym} 85500 -24310 0 1 {name=p84779 lab=_57080_/X }
C {sky130_stdcells/o21a_4.sym} 85420 -24310 0 0 {name=X_57080_ }
C {devices/lab_pin.sym} 85330 -24170 0 0 {name=p84780 lab=_81344_/CLK }
C {devices/lab_pin.sym} 85330 -24150 0 0 {name=p84781 lab=_76629_/Y }
C {devices/lab_pin.sym} 85510 -24170 0 1 {name=p84782 lab=_81720_/D }
C {sky130_stdcells/dfxtp_4.sym} 85420 -24160 0 0 {name=X_81344_ }
C {devices/lab_pin.sym} 85380 -24030 0 0 {name=p84783 lab=_69065_/X }
C {devices/lab_pin.sym} 85460 -24030 0 1 {name=p84784 lab=_69066_/X }
C {sky130_stdcells/buf_2.sym} 85420 -24030 0 0 {name=X_69066_ }
C {devices/lab_pin.sym} 85360 -23940 0 0 {name=p84785 lab=_54312_/A }
C {devices/lab_pin.sym} 85360 -23900 0 0 {name=p84786 lab=_54298_/B }
C {devices/lab_pin.sym} 85360 -23860 0 0 {name=p84787 lab=_54312_/C }
C {devices/lab_pin.sym} 85360 -23820 0 0 {name=p84788 lab=_46658_/A }
C {devices/lab_pin.sym} 85480 -23880 0 1 {name=p84789 lab=_54292_/X }
C {sky130_stdcells/and4_4.sym} 85420 -23880 0 0 {name=X_54292_ }
C {devices/lab_pin.sym} 85380 -23730 0 0 {name=p84790 lab=_66065_/A }
C {devices/lab_pin.sym} 85460 -23730 0 1 {name=p84791 lab=_66278_/X }
C {sky130_stdcells/buf_2.sym} 85420 -23730 0 0 {name=X_66278_ }
C {devices/lab_pin.sym} 85380 -23610 0 0 {name=p84792 lab=_56030_/X }
C {devices/lab_pin.sym} 85460 -23610 0 1 {name=p84793 lab=_56031_/X }
C {sky130_stdcells/buf_2.sym} 85420 -23610 0 0 {name=X_56031_ }
C {devices/lab_pin.sym} 85340 -23510 0 0 {name=p84794 lab=_81477_/D }
C {devices/lab_pin.sym} 85340 -23470 0 0 {name=p84795 lab=_67925_/X }
C {devices/lab_pin.sym} 85340 -23430 0 0 {name=p84796 lab=_68016_/X }
C {devices/lab_pin.sym} 85500 -23470 0 1 {name=p84797 lab=_84045_/D }
C {sky130_stdcells/a21bo_4.sym} 85420 -23470 0 0 {name=X_68017_ }
C {devices/lab_pin.sym} 85380 -23330 0 0 {name=p84798 lab=_53190_/A }
C {devices/lab_pin.sym} 85460 -23330 0 1 {name=p84799 lab=_53243_/X }
C {sky130_stdcells/buf_2.sym} 85420 -23330 0 0 {name=X_53243_ }
C {devices/lab_pin.sym} 85340 -23230 0 0 {name=p84800 lab=_65226_/X }
C {devices/lab_pin.sym} 85340 -23190 0 0 {name=p84801 lab=_65228_/X }
C {devices/lab_pin.sym} 85340 -23150 0 0 {name=p84802 lab=_65122_/X }
C {devices/lab_pin.sym} 85500 -23190 0 1 {name=p84803 lab=_65233_/A }
C {sky130_stdcells/a21o_4.sym} 85420 -23190 0 0 {name=X_65229_ }
C {devices/lab_pin.sym} 85330 -23050 0 0 {name=p84804 lab=_82648_/CLK }
C {devices/lab_pin.sym} 85330 -23030 0 0 {name=p84805 lab=_67590_/X }
C {devices/lab_pin.sym} 85510 -23050 0 1 {name=p84806 lab=_84063_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -23040 0 0 {name=X_84063_ }
C {devices/lab_pin.sym} 85380 -22910 0 0 {name=p84807 lab=_50491_/A }
C {devices/lab_pin.sym} 85460 -22910 0 1 {name=p84808 lab=_50455_/X }
C {sky130_stdcells/buf_2.sym} 85420 -22910 0 0 {name=X_50455_ }
C {devices/lab_pin.sym} 85330 -22790 0 0 {name=p84809 lab=_81275_/CLK }
C {devices/lab_pin.sym} 85330 -22770 0 0 {name=p84810 lab=_81275_/D }
C {devices/lab_pin.sym} 85510 -22790 0 1 {name=p84811 lab=_76522_/A }
C {sky130_stdcells/dfxtp_4.sym} 85420 -22780 0 0 {name=X_81275_ }
C {devices/lab_pin.sym} 85330 -22650 0 0 {name=p84812 lab=_86869_/CLK }
C {devices/lab_pin.sym} 85330 -22630 0 0 {name=p84813 lab=_83014_/D }
C {devices/lab_pin.sym} 85510 -22650 0 1 {name=p84814 lab=_83014_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -22640 0 0 {name=X_83014_ }
C {devices/lab_pin.sym} 85380 -22510 0 0 {name=p84815 lab=_80226_/A }
C {devices/lab_pin.sym} 85460 -22510 0 1 {name=p84816 lab=_80226_/Y }
C {sky130_stdcells/inv_2.sym} 85420 -22510 0 0 {name=X_80226_ }
C {devices/lab_pin.sym} 85360 -22400 0 0 {name=p84817 lab=_53187_/A }
C {devices/lab_pin.sym} 85360 -22360 0 0 {name=p84818 lab=_53174_/B }
C {devices/lab_pin.sym} 85480 -22380 0 1 {name=p84819 lab=_53174_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -22380 0 0 {name=X_53174_ }
C {devices/lab_pin.sym} 85340 -22270 0 0 {name=p84820 lab=_50384_/Y }
C {devices/lab_pin.sym} 85340 -22230 0 0 {name=p84821 lab=_50380_/X }
C {devices/lab_pin.sym} 85340 -22190 0 0 {name=p84822 lab=_50385_/Y }
C {devices/lab_pin.sym} 85500 -22230 0 1 {name=p84823 lab=_86211_/D }
C {sky130_stdcells/a21boi_4.sym} 85420 -22230 0 0 {name=X_50386_ }
C {devices/lab_pin.sym} 85380 -22090 0 0 {name=p84824 lab=_52152_/A }
C {devices/lab_pin.sym} 85460 -22090 0 1 {name=p84825 lab=_52125_/X }
C {sky130_stdcells/buf_2.sym} 85420 -22090 0 0 {name=X_52125_ }
C {devices/lab_pin.sym} 85330 -21970 0 0 {name=p84826 lab=_87821_/CLK }
C {devices/lab_pin.sym} 85330 -21950 0 0 {name=p84827 lab=_87822_/D }
C {devices/lab_pin.sym} 85510 -21970 0 1 {name=p84828 lab=_42555_/A }
C {sky130_stdcells/dfxtp_4.sym} 85420 -21960 0 0 {name=X_87822_ }
C {devices/lab_pin.sym} 85360 -21840 0 0 {name=p84829 lab=_80157_/A }
C {devices/lab_pin.sym} 85360 -21800 0 0 {name=p84830 lab=_80135_/X }
C {devices/lab_pin.sym} 85480 -21820 0 1 {name=p84831 lab=_80157_/X }
C {sky130_stdcells/and2_4.sym} 85420 -21820 0 0 {name=X_80157_ }
C {devices/lab_pin.sym} 85380 -21690 0 0 {name=p84832 lab=_57837_/A }
C {devices/lab_pin.sym} 85460 -21690 0 1 {name=p84833 lab=_58858_/A }
C {sky130_stdcells/buf_2.sym} 85420 -21690 0 0 {name=X_57982_ }
C {devices/lab_pin.sym} 85340 -21600 0 0 {name=p84834 lab=_87540_/Q }
C {devices/lab_pin.sym} 85340 -21560 0 0 {name=p84835 lab=_66529_/X }
C {devices/lab_pin.sym} 85340 -21520 0 0 {name=p84836 lab=_68436_/X }
C {devices/lab_pin.sym} 85340 -21480 0 0 {name=p84837 lab=_69967_/X }
C {devices/lab_pin.sym} 85500 -21540 0 1 {name=p84838 lab=_69968_/X }
C {sky130_stdcells/a211o_4.sym} 85420 -21540 0 0 {name=X_69968_ }
C {devices/lab_pin.sym} 85380 -21390 0 0 {name=p84839 lab=_59721_/A }
C {devices/lab_pin.sym} 85460 -21390 0 1 {name=p84840 lab=_59721_/X }
C {sky130_stdcells/buf_2.sym} 85420 -21390 0 0 {name=X_59721_ }
C {devices/lab_pin.sym} 85380 -21270 0 0 {name=p84841 lab=_72909_/A }
C {devices/lab_pin.sym} 85460 -21270 0 1 {name=p84842 lab=_56933_/X }
C {sky130_stdcells/buf_2.sym} 85420 -21270 0 0 {name=X_56933_ }
C {devices/lab_pin.sym} 85360 -21160 0 0 {name=p84843 lab=_52070_/A }
C {devices/lab_pin.sym} 85360 -21120 0 0 {name=p84844 lab=_48310_/B }
C {devices/lab_pin.sym} 85480 -21140 0 1 {name=p84845 lab=_52056_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -21140 0 0 {name=X_52056_ }
C {devices/lab_pin.sym} 85340 -21040 0 0 {name=p84846 lab=_87997_/Q }
C {devices/lab_pin.sym} 85340 -21000 0 0 {name=p84847 lab=_68895_/X }
C {devices/lab_pin.sym} 85340 -20960 0 0 {name=p84848 lab=_68916_/X }
C {devices/lab_pin.sym} 85340 -20920 0 0 {name=p84849 lab=_68918_/X }
C {devices/lab_pin.sym} 85500 -20980 0 1 {name=p84850 lab=_68919_/X }
C {sky130_stdcells/a211o_4.sym} 85420 -20980 0 0 {name=X_68919_ }
C {devices/lab_pin.sym} 85330 -20830 0 0 {name=p84851 lab=_87757_/CLK }
C {devices/lab_pin.sym} 85330 -20810 0 0 {name=p84852 lab=_87753_/D }
C {devices/lab_pin.sym} 85510 -20830 0 1 {name=p84853 lab=_68624_/B }
C {sky130_stdcells/dfxtp_4.sym} 85420 -20820 0 0 {name=X_87753_ }
C {devices/lab_pin.sym} 85330 -20690 0 0 {name=p84854 lab=_85895_/CLK }
C {devices/lab_pin.sym} 85330 -20670 0 0 {name=p84855 lab=_84965_/D }
C {devices/lab_pin.sym} 85510 -20690 0 1 {name=p84856 lab=_84965_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -20680 0 0 {name=X_84965_ }
C {devices/lab_pin.sym} 85360 -20560 0 0 {name=p84857 lab=_80081_/X }
C {devices/lab_pin.sym} 85360 -20520 0 0 {name=p84858 lab=_80088_/B }
C {devices/lab_pin.sym} 85480 -20540 0 1 {name=p84859 lab=_80088_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -20540 0 0 {name=X_80088_ }
C {devices/lab_pin.sym} 85340 -20430 0 0 {name=p84860 lab=_69896_/X }
C {devices/lab_pin.sym} 85340 -20390 0 0 {name=p84861 lab=_69898_/X }
C {devices/lab_pin.sym} 85340 -20350 0 0 {name=p84862 lab=_69624_/X }
C {devices/lab_pin.sym} 85500 -20390 0 1 {name=p84863 lab=_69902_/A }
C {sky130_stdcells/a21o_4.sym} 85420 -20390 0 0 {name=X_69899_ }
C {devices/lab_pin.sym} 85340 -20270 0 0 {name=p84864 lab=_51004_/Y }
C {devices/lab_pin.sym} 85340 -20230 0 0 {name=p84865 lab=_50983_/X }
C {devices/lab_pin.sym} 85340 -20190 0 0 {name=p84866 lab=_51006_/X }
C {devices/lab_pin.sym} 85500 -20230 0 1 {name=p84867 lab=_86091_/D }
C {sky130_stdcells/a21oi_4.sym} 85420 -20230 0 0 {name=X_51007_ }
C {devices/lab_pin.sym} 85330 -20090 0 0 {name=p84868 lab=_86384_/CLK }
C {devices/lab_pin.sym} 85330 -20070 0 0 {name=p84869 lab=_86704_/D }
C {devices/lab_pin.sym} 85510 -20090 0 1 {name=p84870 lab=_86704_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -20080 0 0 {name=X_86704_ }
C {devices/lab_pin.sym} 85360 -19970 0 0 {name=p84871 lab=_71570_/X }
C {devices/lab_pin.sym} 85360 -19930 0 0 {name=p84872 lab=_71930_/B }
C {devices/lab_pin.sym} 85360 -19890 0 0 {name=p84873 lab=_71377_/B }
C {devices/lab_pin.sym} 85480 -19930 0 1 {name=p84874 lab=_71930_/Y }
C {sky130_stdcells/nor3_4.sym} 85420 -19930 0 0 {name=X_71930_ }
C {devices/lab_pin.sym} 85330 -19790 0 0 {name=p84875 lab=_83918_/CLK }
C {devices/lab_pin.sym} 85330 -19770 0 0 {name=p84876 lab=_83916_/D }
C {devices/lab_pin.sym} 85510 -19790 0 1 {name=p84877 lab=_81380_/D }
C {sky130_stdcells/dfxtp_4.sym} 85420 -19780 0 0 {name=X_83916_ }
C {devices/lab_pin.sym} 85340 -19680 0 0 {name=p84878 lab=_80625_/A }
C {devices/lab_pin.sym} 85340 -19640 0 0 {name=p84879 lab=_59509_/X }
C {devices/lab_pin.sym} 85340 -19600 0 0 {name=p84880 lab=_59632_/X }
C {devices/lab_pin.sym} 85340 -19560 0 0 {name=p84881 lab=_59713_/A }
C {devices/lab_pin.sym} 85500 -19620 0 1 {name=p84882 lab=_59652_/X }
C {sky130_stdcells/o22a_4.sym} 85420 -19620 0 0 {name=X_59652_ }
C {devices/lab_pin.sym} 85340 -19500 0 0 {name=p84883 lab=_56857_/X }
C {devices/lab_pin.sym} 85340 -19460 0 0 {name=p84884 lab=_56862_/Y }
C {devices/lab_pin.sym} 85340 -19420 0 0 {name=p84885 lab=_56863_/X }
C {devices/lab_pin.sym} 85340 -19380 0 0 {name=p84886 lab=_56756_/X }
C {devices/lab_pin.sym} 85500 -19440 0 1 {name=p84887 lab=_56864_/X }
C {sky130_stdcells/a211o_4.sym} 85420 -19440 0 0 {name=X_56864_ }
C {devices/lab_pin.sym} 85330 -19290 0 0 {name=p84888 lab=_87684_/CLK }
C {devices/lab_pin.sym} 85330 -19270 0 0 {name=p84889 lab=_87684_/D }
C {devices/lab_pin.sym} 85510 -19290 0 1 {name=p84890 lab=_66927_/B }
C {sky130_stdcells/dfxtp_4.sym} 85420 -19280 0 0 {name=X_87684_ }
C {devices/lab_pin.sym} 85330 -19150 0 0 {name=p84891 lab=_84344_/CLK }
C {devices/lab_pin.sym} 85330 -19130 0 0 {name=p84892 lab=_58257_/X }
C {devices/lab_pin.sym} 85510 -19150 0 1 {name=p84893 lab=_58254_/A }
C {sky130_stdcells/dfxtp_4.sym} 85420 -19140 0 0 {name=X_84896_ }
C {devices/lab_pin.sym} 85380 -19010 0 0 {name=p84894 lab=_58603_/A }
C {devices/lab_pin.sym} 85460 -19010 0 1 {name=p84895 lab=_58603_/X }
C {sky130_stdcells/buf_2.sym} 85420 -19010 0 0 {name=X_58603_ }
C {devices/lab_pin.sym} 85340 -18920 0 0 {name=p84896 lab=_85198_/Q }
C {devices/lab_pin.sym} 85340 -18880 0 0 {name=p84897 lab=_55342_/X }
C {devices/lab_pin.sym} 85340 -18840 0 0 {name=p84898 lab=_55457_/X }
C {devices/lab_pin.sym} 85340 -18800 0 0 {name=p84899 lab=_55814_/X }
C {devices/lab_pin.sym} 85500 -18860 0 1 {name=p84900 lab=_55815_/X }
C {sky130_stdcells/a211o_4.sym} 85420 -18860 0 0 {name=X_55815_ }
C {devices/lab_pin.sym} 85330 -18710 0 0 {name=p84901 lab=_85993_/CLK }
C {devices/lab_pin.sym} 85330 -18690 0 0 {name=p84902 lab=_86635_/D }
C {devices/lab_pin.sym} 85510 -18710 0 1 {name=p84903 lab=_86635_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -18700 0 0 {name=X_86635_ }
C {devices/lab_pin.sym} 85360 -18600 0 0 {name=p84904 lab=_70558_/X }
C {devices/lab_pin.sym} 85360 -18560 0 0 {name=p84905 lab=_71857_/B }
C {devices/lab_pin.sym} 85360 -18520 0 0 {name=p84906 lab=_71851_/X }
C {devices/lab_pin.sym} 85360 -18480 0 0 {name=p84907 lab=_71857_/D }
C {devices/lab_pin.sym} 85480 -18540 0 1 {name=p84908 lab=_71861_/Y }
C {sky130_stdcells/nor4_4.sym} 85420 -18540 0 0 {name=X_71861_ }
C {devices/lab_pin.sym} 85380 -18390 0 0 {name=p84909 lab=_61071_/C }
C {devices/lab_pin.sym} 85460 -18390 0 1 {name=p84910 lab=_59615_/A }
C {sky130_stdcells/buf_2.sym} 85420 -18390 0 0 {name=X_59583_ }
C {devices/lab_pin.sym} 85330 -18270 0 0 {name=p84911 lab=_83843_/CLK }
C {devices/lab_pin.sym} 85330 -18250 0 0 {name=p84912 lab=_83847_/D }
C {devices/lab_pin.sym} 85510 -18270 0 1 {name=p84913 lab=_83847_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -18260 0 0 {name=X_83847_ }
C {devices/lab_pin.sym} 85360 -18140 0 0 {name=p84914 lab=_83324_/Q }
C {devices/lab_pin.sym} 85360 -18100 0 0 {name=p84915 lab=_56794_/Y }
C {devices/lab_pin.sym} 85480 -18120 0 1 {name=p84916 lab=_56796_/B }
C {sky130_stdcells/xor2_4.sym} 85420 -18120 0 0 {name=X_56795_ }
C {devices/lab_pin.sym} 85340 -18020 0 0 {name=p84917 lab=_68418_/B }
C {devices/lab_pin.sym} 85340 -17980 0 0 {name=p84918 lab=_73597_/X }
C {devices/lab_pin.sym} 85340 -17940 0 0 {name=p84919 lab=_73464_/X }
C {devices/lab_pin.sym} 85340 -17900 0 0 {name=p84920 lab=_73599_/Y }
C {devices/lab_pin.sym} 85500 -17960 0 1 {name=p84921 lab=_73600_/X }
C {sky130_stdcells/a211o_4.sym} 85420 -17960 0 0 {name=X_73600_ }
C {devices/lab_pin.sym} 85360 -17830 0 0 {name=p84922 lab=_70810_/A }
C {devices/lab_pin.sym} 85360 -17790 0 0 {name=p84923 lab=_70945_/B }
C {devices/lab_pin.sym} 85360 -17750 0 0 {name=p84924 lab=_70810_/C }
C {devices/lab_pin.sym} 85480 -17790 0 1 {name=p84925 lab=_70812_/Y }
C {sky130_stdcells/nand3_4.sym} 85420 -17790 0 0 {name=X_70812_ }
C {devices/lab_pin.sym} 85340 -17670 0 0 {name=p84926 lab=_58517_/X }
C {devices/lab_pin.sym} 85340 -17630 0 0 {name=p84927 lab=_58530_/Y }
C {devices/lab_pin.sym} 85340 -17590 0 0 {name=p84928 lab=_58533_/Y }
C {devices/lab_pin.sym} 85500 -17630 0 1 {name=p84929 lab=_84826_/D }
C {sky130_stdcells/a21oi_4.sym} 85420 -17630 0 0 {name=X_58534_ }
C {devices/lab_pin.sym} 85380 -17490 0 0 {name=p84930 lab=_43760_/A }
C {devices/lab_pin.sym} 85460 -17490 0 1 {name=p84931 lab=_43760_/X }
C {sky130_stdcells/buf_2.sym} 85420 -17490 0 0 {name=X_43760_ }
C {devices/lab_pin.sym} 85360 -17380 0 0 {name=p84932 lab=_56127_/B }
C {devices/lab_pin.sym} 85360 -17340 0 0 {name=p84933 lab=_56127_/C }
C {devices/lab_pin.sym} 85480 -17360 0 1 {name=p84934 lab=_56117_/A }
C {sky130_stdcells/nor2_4.sym} 85420 -17360 0 0 {name=X_55746_ }
C {devices/lab_pin.sym} 85330 -17230 0 0 {name=p84935 lab=_85895_/CLK }
C {devices/lab_pin.sym} 85330 -17210 0 0 {name=p84936 lab=_48121_/Y }
C {devices/lab_pin.sym} 85510 -17230 0 1 {name=p84937 lab=_66298_/B }
C {sky130_stdcells/dfxtp_4.sym} 85420 -17220 0 0 {name=X_86566_ }
C {devices/lab_pin.sym} 85340 -17120 0 0 {name=p84938 lab=_74575_/X }
C {devices/lab_pin.sym} 85340 -17080 0 0 {name=p84939 lab=_74569_/X }
C {devices/lab_pin.sym} 85340 -17040 0 0 {name=p84940 lab=_56079_/A }
C {devices/lab_pin.sym} 85340 -17000 0 0 {name=p84941 lab=_74570_/X }
C {devices/lab_pin.sym} 85500 -17060 0 1 {name=p84942 lab=_74580_/X }
C {sky130_stdcells/a211o_4.sym} 85420 -17060 0 0 {name=X_74580_ }
C {devices/lab_pin.sym} 85380 -16910 0 0 {name=p84943 lab=_40972_/A }
C {devices/lab_pin.sym} 85460 -16910 0 1 {name=p84944 lab=_40972_/X }
C {sky130_stdcells/buf_2.sym} 85420 -16910 0 0 {name=X_40972_ }
C {devices/lab_pin.sym} 85380 -16790 0 0 {name=p84945 lab=_52903_/X }
C {devices/lab_pin.sym} 85460 -16790 0 1 {name=p84946 lab=_52979_/A }
C {sky130_stdcells/buf_2.sym} 85420 -16790 0 0 {name=X_52958_ }
C {devices/lab_pin.sym} 85360 -16690 0 0 {name=p84947 lab=_71235_/A }
C {devices/lab_pin.sym} 85360 -16650 0 0 {name=p84948 lab=_71302_/X }
C {devices/lab_pin.sym} 85360 -16610 0 0 {name=p84949 lab=_71785_/X }
C {devices/lab_pin.sym} 85480 -16650 0 1 {name=p84950 lab=_71792_/Y }
C {sky130_stdcells/nand3_4.sym} 85420 -16650 0 0 {name=X_71792_ }
C {devices/lab_pin.sym} 85330 -16510 0 0 {name=p84951 lab=_85953_/CLK }
C {devices/lab_pin.sym} 85330 -16490 0 0 {name=p84952 lab=_83778_/D }
C {devices/lab_pin.sym} 85510 -16510 0 1 {name=p84953 lab=_83778_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -16500 0 0 {name=X_83778_ }
C {devices/lab_pin.sym} 85330 -16370 0 0 {name=p84954 lab=_87333_/CLK }
C {devices/lab_pin.sym} 85330 -16350 0 0 {name=p84955 lab=_88305_/D }
C {devices/lab_pin.sym} 85510 -16370 0 1 {name=p84956 lab=_88305_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -16360 0 0 {name=X_88305_ }
C {devices/lab_pin.sym} 85380 -16230 0 0 {name=p84957 lab=_42681_/A }
C {devices/lab_pin.sym} 85460 -16230 0 1 {name=p84958 lab=_42711_/X }
C {sky130_stdcells/buf_2.sym} 85420 -16230 0 0 {name=X_42711_ }
C {devices/lab_pin.sym} 85340 -16140 0 0 {name=p84959 lab=_43203_/Y }
C {devices/lab_pin.sym} 85340 -16100 0 0 {name=p84960 lab=_73529_/X }
C {devices/lab_pin.sym} 85340 -16060 0 0 {name=p84961 lab=_73464_/X }
C {devices/lab_pin.sym} 85340 -16020 0 0 {name=p84962 lab=_73530_/Y }
C {devices/lab_pin.sym} 85500 -16080 0 1 {name=p84963 lab=_73531_/X }
C {sky130_stdcells/a211o_4.sym} 85420 -16080 0 0 {name=X_73531_ }
C {devices/lab_pin.sym} 85330 -15930 0 0 {name=p84964 lab=_85516_/CLK }
C {devices/lab_pin.sym} 85330 -15910 0 0 {name=p84965 lab=_54044_/Y }
C {devices/lab_pin.sym} 85510 -15930 0 1 {name=p84966 lab=_85517_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -15920 0 0 {name=X_85517_ }
C {devices/lab_pin.sym} 85360 -15820 0 0 {name=p84967 lab=_51887_/A }
C {devices/lab_pin.sym} 85360 -15780 0 0 {name=p84968 lab=_51898_/B }
C {devices/lab_pin.sym} 85360 -15740 0 0 {name=p84969 lab=_51893_/C }
C {devices/lab_pin.sym} 85360 -15700 0 0 {name=p84970 lab=_52735_/D }
C {devices/lab_pin.sym} 85480 -15760 0 1 {name=p84971 lab=_51909_/X }
C {sky130_stdcells/and4_4.sym} 85420 -15760 0 0 {name=X_51909_ }
C {devices/lab_pin.sym} 85340 -15630 0 0 {name=p84972 lab=_53105_/B }
C {devices/lab_pin.sym} 85340 -15590 0 0 {name=p84973 lab=_70738_/X }
C {devices/lab_pin.sym} 85340 -15550 0 0 {name=p84974 lab=_70742_/Y }
C {devices/lab_pin.sym} 85500 -15590 0 1 {name=p84975 lab=_83712_/D }
C {sky130_stdcells/o21ai_4.sym} 85420 -15590 0 0 {name=X_70743_ }
C {devices/lab_pin.sym} 85360 -15460 0 0 {name=p84976 lab=_58465_/A }
C {devices/lab_pin.sym} 85360 -15420 0 0 {name=p84977 lab=_58474_/B }
C {devices/lab_pin.sym} 85480 -15440 0 1 {name=p84978 lab=_58465_/Y }
C {sky130_stdcells/nor2_4.sym} 85420 -15440 0 0 {name=X_58465_ }
C {devices/lab_pin.sym} 85330 -15310 0 0 {name=p84979 lab=_84111_/CLK }
C {devices/lab_pin.sym} 85330 -15290 0 0 {name=p84980 lab=_66490_/C }
C {devices/lab_pin.sym} 85510 -15310 0 1 {name=p84981 lab=_78869_/A }
C {sky130_stdcells/dfxtp_4.sym} 85420 -15300 0 0 {name=X_82729_ }
C {devices/lab_pin.sym} 85340 -15200 0 0 {name=p84982 lab=_40810_/X }
C {devices/lab_pin.sym} 85340 -15160 0 0 {name=p84983 lab=_43685_/X }
C {devices/lab_pin.sym} 85340 -15120 0 0 {name=p84984 lab=_87306_/Q }
C {devices/lab_pin.sym} 85340 -15080 0 0 {name=p84985 lab=_43686_/X }
C {devices/lab_pin.sym} 85500 -15140 0 1 {name=p84986 lab=_87306_/D }
C {sky130_stdcells/a2bb2o_4.sym} 85420 -15140 0 0 {name=X_43691_ }
C {devices/lab_pin.sym} 85380 -14990 0 0 {name=p84987 lab=_83321_/Q }
C {devices/lab_pin.sym} 85460 -14990 0 1 {name=p84988 lab=_55681_/A }
C {sky130_stdcells/inv_2.sym} 85420 -14990 0 0 {name=X_55677_ }
C {devices/lab_pin.sym} 85330 -14870 0 0 {name=p84989 lab=_85888_/CLK }
C {devices/lab_pin.sym} 85330 -14850 0 0 {name=p84990 lab=_48716_/Y }
C {devices/lab_pin.sym} 85510 -14870 0 1 {name=p84991 lab=_65425_/B }
C {sky130_stdcells/dfxtp_4.sym} 85420 -14860 0 0 {name=X_86497_ }
C {devices/lab_pin.sym} 85360 -14740 0 0 {name=p84992 lab=_52885_/A }
C {devices/lab_pin.sym} 85360 -14700 0 0 {name=p84993 lab=_52889_/B }
C {devices/lab_pin.sym} 85480 -14720 0 1 {name=p84994 lab=_52889_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -14720 0 0 {name=X_52889_ }
C {devices/lab_pin.sym} 85340 -14610 0 0 {name=p84995 lab=_55622_/B }
C {devices/lab_pin.sym} 85340 -14570 0 0 {name=p84996 lab=_44935_/X }
C {devices/lab_pin.sym} 85340 -14530 0 0 {name=p84997 lab=_45429_/X }
C {devices/lab_pin.sym} 85500 -14570 0 1 {name=p84998 lab=_45430_/X }
C {sky130_stdcells/o21a_4.sym} 85420 -14570 0 0 {name=X_45430_ }
C {devices/lab_pin.sym} 85360 -14450 0 0 {name=p84999 lab=_57416_/A }
C {devices/lab_pin.sym} 85360 -14410 0 0 {name=p85000 lab=_57400_/X }
C {devices/lab_pin.sym} 85360 -14370 0 0 {name=p85001 lab=_57416_/C }
C {devices/lab_pin.sym} 85480 -14410 0 1 {name=p85002 lab=_57416_/Y }
C {sky130_stdcells/nand3_4.sym} 85420 -14410 0 0 {name=X_57416_ }
C {devices/lab_pin.sym} 85380 -14270 0 0 {name=p85003 lab=_76245_/Y }
C {devices/lab_pin.sym} 85460 -14270 0 1 {name=p85004 lab=_76250_/Y }
C {sky130_stdcells/inv_2.sym} 85420 -14270 0 0 {name=X_76250_ }
C {devices/lab_pin.sym} 85330 -14150 0 0 {name=p85005 lab=_88220_/CLK }
C {devices/lab_pin.sym} 85330 -14130 0 0 {name=p85006 lab=_41323_/Y }
C {devices/lab_pin.sym} 85510 -14150 0 1 {name=p85007 lab=_88236_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -14140 0 0 {name=X_88236_ }
C {devices/lab_pin.sym} 85380 -14010 0 0 {name=p85008 lab=_42641_/Y }
C {devices/lab_pin.sym} 85460 -14010 0 1 {name=p85009 lab=_87791_/D }
C {sky130_stdcells/inv_2.sym} 85420 -14010 0 0 {name=X_42642_ }
C {devices/lab_pin.sym} 85340 -13910 0 0 {name=p85010 lab=_85407_/Q }
C {devices/lab_pin.sym} 85340 -13870 0 0 {name=p85011 lab=_54621_/X }
C {devices/lab_pin.sym} 85340 -13830 0 0 {name=p85012 lab=_54627_/Y }
C {devices/lab_pin.sym} 85500 -13870 0 1 {name=p85013 lab=_54628_/Y }
C {sky130_stdcells/o21ai_4.sym} 85420 -13870 0 0 {name=X_54628_ }
C {devices/lab_pin.sym} 85360 -13740 0 0 {name=p85014 lab=_73462_/A }
C {devices/lab_pin.sym} 85360 -13700 0 0 {name=p85015 lab=_73198_/B }
C {devices/lab_pin.sym} 85480 -13720 0 1 {name=p85016 lab=_73462_/Y }
C {sky130_stdcells/nor2_4.sym} 85420 -13720 0 0 {name=X_73462_ }
C {devices/lab_pin.sym} 85330 -13590 0 0 {name=p85017 lab=_85770_/CLK }
C {devices/lab_pin.sym} 85330 -13570 0 0 {name=p85018 lab=_85448_/D }
C {devices/lab_pin.sym} 85510 -13590 0 1 {name=p85019 lab=_85448_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -13580 0 0 {name=X_85448_ }
C {devices/lab_pin.sym} 85340 -13470 0 0 {name=p85020 lab=_70664_/X }
C {devices/lab_pin.sym} 85340 -13430 0 0 {name=p85021 lab=_47458_/A }
C {devices/lab_pin.sym} 85340 -13390 0 0 {name=p85022 lab=_70673_/Y }
C {devices/lab_pin.sym} 85500 -13430 0 1 {name=p85023 lab=_70674_/X }
C {sky130_stdcells/a21o_4.sym} 85420 -13430 0 0 {name=X_70674_ }
C {devices/lab_pin.sym} 85380 -13290 0 0 {name=p85024 lab=_84859_/Q }
C {devices/lab_pin.sym} 85460 -13290 0 1 {name=p85025 lab=_58396_/Y }
C {sky130_stdcells/inv_2.sym} 85420 -13290 0 0 {name=X_58396_ }
C {devices/lab_pin.sym} 85360 -13180 0 0 {name=p85026 lab=_75201_/A }
C {devices/lab_pin.sym} 85360 -13140 0 0 {name=p85027 lab=_75201_/B }
C {devices/lab_pin.sym} 85480 -13160 0 1 {name=p85028 lab=_75201_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -13160 0 0 {name=X_75201_ }
C {devices/lab_pin.sym} 85380 -13030 0 0 {name=p85029 lab=_59325_/A }
C {devices/lab_pin.sym} 85460 -13030 0 1 {name=p85030 lab=_72413_/X }
C {sky130_stdcells/buf_2.sym} 85420 -13030 0 0 {name=X_72413_ }
C {devices/lab_pin.sym} 85380 -12910 0 0 {name=p85031 lab=_45678_/A }
C {devices/lab_pin.sym} 85460 -12910 0 1 {name=p85032 lab=_45361_/X }
C {sky130_stdcells/buf_2.sym} 85420 -12910 0 0 {name=X_45361_ }
C {devices/lab_pin.sym} 85360 -12810 0 0 {name=p85033 lab=_57289_/B }
C {devices/lab_pin.sym} 85360 -12770 0 0 {name=p85034 lab=_56848_/X }
C {devices/lab_pin.sym} 85360 -12730 0 0 {name=p85035 lab=_56850_/X }
C {devices/lab_pin.sym} 85480 -12770 0 1 {name=p85036 lab=_57347_/Y }
C {sky130_stdcells/nor3_4.sym} 85420 -12770 0 0 {name=X_57347_ }
C {devices/lab_pin.sym} 85330 -12630 0 0 {name=p85037 lab=_86934_/CLK }
C {devices/lab_pin.sym} 85330 -12610 0 0 {name=p85038 lab=_88167_/D }
C {devices/lab_pin.sym} 85510 -12630 0 1 {name=p85039 lab=_67634_/B }
C {sky130_stdcells/dfxtp_4.sym} 85420 -12620 0 0 {name=X_88167_ }
C {devices/lab_pin.sym} 85380 -12490 0 0 {name=p85040 lab=_76181_/A }
C {devices/lab_pin.sym} 85460 -12490 0 1 {name=p85041 lab=_76182_/B }
C {sky130_stdcells/inv_2.sym} 85420 -12490 0 0 {name=X_76181_ }
C {devices/lab_pin.sym} 85380 -12370 0 0 {name=p85042 lab=_42610_/A }
C {devices/lab_pin.sym} 85460 -12370 0 1 {name=p85043 lab=_42573_/X }
C {sky130_stdcells/buf_2.sym} 85420 -12370 0 0 {name=X_42573_ }
C {devices/lab_pin.sym} 85360 -12280 0 0 {name=p85044 lab=_54538_/A }
C {devices/lab_pin.sym} 85360 -12240 0 0 {name=p85045 lab=_54559_/B }
C {devices/lab_pin.sym} 85360 -12200 0 0 {name=p85046 lab=_54538_/C }
C {devices/lab_pin.sym} 85360 -12160 0 0 {name=p85047 lab=_54559_/D }
C {devices/lab_pin.sym} 85480 -12220 0 1 {name=p85048 lab=_54559_/X }
C {sky130_stdcells/and4_4.sym} 85420 -12220 0 0 {name=X_54559_ }
C {devices/lab_pin.sym} 85380 -12070 0 0 {name=p85049 lab=_73343_/X }
C {devices/lab_pin.sym} 85460 -12070 0 1 {name=p85050 lab=_73393_/X }
C {sky130_stdcells/buf_2.sym} 85420 -12070 0 0 {name=X_73393_ }
C {devices/lab_pin.sym} 85330 -11950 0 0 {name=p85051 lab=_85379_/CLK }
C {devices/lab_pin.sym} 85330 -11930 0 0 {name=p85052 lab=_85379_/D }
C {devices/lab_pin.sym} 85510 -11950 0 1 {name=p85053 lab=_85379_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -11940 0 0 {name=X_85379_ }
C {devices/lab_pin.sym} 85360 -11820 0 0 {name=p85054 lab=_47109_/A }
C {devices/lab_pin.sym} 85360 -11780 0 0 {name=p85055 lab=_52855_/B }
C {devices/lab_pin.sym} 85480 -11800 0 1 {name=p85056 lab=_47100_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -11800 0 0 {name=X_47100_ }
C {devices/lab_pin.sym} 85360 -11700 0 0 {name=p85057 lab=_44139_/X }
C {devices/lab_pin.sym} 85360 -11660 0 0 {name=p85058 lab=_44141_/X }
C {devices/lab_pin.sym} 85360 -11620 0 0 {name=p85059 lab=_44142_/X }
C {devices/lab_pin.sym} 85360 -11580 0 0 {name=p85060 lab=_44300_/Y }
C {devices/lab_pin.sym} 85480 -11640 0 1 {name=p85061 lab=_44312_/Y }
C {sky130_stdcells/nand4_4.sym} 85420 -11640 0 0 {name=X_44312_ }
C {devices/lab_pin.sym} 85380 -11490 0 0 {name=p85062 lab=_75131_/Y }
C {devices/lab_pin.sym} 85460 -11490 0 1 {name=p85063 lab=_75133_/B }
C {sky130_stdcells/inv_2.sym} 85420 -11490 0 0 {name=X_75132_ }
C {devices/lab_pin.sym} 85330 -11370 0 0 {name=p85064 lab=_87686_/CLK }
C {devices/lab_pin.sym} 85330 -11350 0 0 {name=p85065 lab=_87118_/D }
C {devices/lab_pin.sym} 85510 -11370 0 1 {name=p85066 lab=_87118_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -11360 0 0 {name=X_87118_ }
C {devices/lab_pin.sym} 85340 -11250 0 0 {name=p85067 lab=_41481_/X }
C {devices/lab_pin.sym} 85340 -11210 0 0 {name=p85068 lab=_82324_/Q }
C {devices/lab_pin.sym} 85340 -11170 0 0 {name=p85069 lab=_41523_/X }
C {devices/lab_pin.sym} 85500 -11210 0 1 {name=p85070 lab=_41524_/Y }
C {sky130_stdcells/o21ai_4.sym} 85420 -11210 0 0 {name=X_41524_ }
C {devices/lab_pin.sym} 85340 -11090 0 0 {name=p85071 lab=_48074_/Y }
C {devices/lab_pin.sym} 85340 -11050 0 0 {name=p85072 lab=_48055_/X }
C {devices/lab_pin.sym} 85340 -11010 0 0 {name=p85073 lab=_48079_/X }
C {devices/lab_pin.sym} 85500 -11050 0 1 {name=p85074 lab=_86570_/D }
C {sky130_stdcells/a21oi_4.sym} 85420 -11050 0 0 {name=X_48080_ }
C {devices/lab_pin.sym} 85380 -10910 0 0 {name=p85075 lab=_72201_/A }
C {devices/lab_pin.sym} 85460 -10910 0 1 {name=p85076 lab=_72344_/X }
C {sky130_stdcells/buf_2.sym} 85420 -10910 0 0 {name=X_72344_ }
C {devices/lab_pin.sym} 85340 -10810 0 0 {name=p85077 lab=_45289_/X }
C {devices/lab_pin.sym} 85340 -10770 0 0 {name=p85078 lab=_45291_/Y }
C {devices/lab_pin.sym} 85340 -10730 0 0 {name=p85079 lab=_45275_/X }
C {devices/lab_pin.sym} 85500 -10770 0 1 {name=p85080 lab=_45292_/Y }
C {sky130_stdcells/a21oi_4.sym} 85420 -10770 0 0 {name=X_45292_ }
C {devices/lab_pin.sym} 85340 -10650 0 0 {name=p85081 lab=_57276_/X }
C {devices/lab_pin.sym} 85340 -10610 0 0 {name=p85082 lab=_57277_/Y }
C {devices/lab_pin.sym} 85340 -10570 0 0 {name=p85083 lab=_57322_/B }
C {devices/lab_pin.sym} 85500 -10610 0 1 {name=p85084 lab=_57278_/Y }
C {sky130_stdcells/a21oi_4.sym} 85420 -10610 0 0 {name=X_57278_ }
C {devices/lab_pin.sym} 85330 -10470 0 0 {name=p85085 lab=_88097_/CLK }
C {devices/lab_pin.sym} 85330 -10450 0 0 {name=p85086 lab=_41944_/Y }
C {devices/lab_pin.sym} 85510 -10470 0 1 {name=p85087 lab=_73963_/A }
C {sky130_stdcells/dfxtp_4.sym} 85420 -10460 0 0 {name=X_88098_ }
C {devices/lab_pin.sym} 85380 -10330 0 0 {name=p85088 lab=_47031_/A }
C {devices/lab_pin.sym} 85460 -10330 0 1 {name=p85089 lab=_53332_/B }
C {sky130_stdcells/inv_2.sym} 85420 -10330 0 0 {name=X_47031_ }
C {devices/lab_pin.sym} 85340 -10240 0 0 {name=p85090 lab=_84776_/Q }
C {devices/lab_pin.sym} 85340 -10200 0 0 {name=p85091 lab=_58956_/X }
C {devices/lab_pin.sym} 85340 -10160 0 0 {name=p85092 lab=_59009_/X }
C {devices/lab_pin.sym} 85340 -10120 0 0 {name=p85093 lab=_59016_/X }
C {devices/lab_pin.sym} 85500 -10180 0 1 {name=p85094 lab=_84776_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 85420 -10180 0 0 {name=X_59017_ }
C {devices/lab_pin.sym} 85360 -10050 0 0 {name=p85095 lab=_56233_/A }
C {devices/lab_pin.sym} 85360 -10010 0 0 {name=p85096 lab=_56229_/B }
C {devices/lab_pin.sym} 85360 -9970 0 0 {name=p85097 lab=_85267_/Q }
C {devices/lab_pin.sym} 85480 -10010 0 1 {name=p85098 lab=_56229_/Y }
C {sky130_stdcells/nand3_4.sym} 85420 -10010 0 0 {name=X_56229_ }
C {devices/lab_pin.sym} 85340 -9890 0 0 {name=p85099 lab=_44241_/Y }
C {devices/lab_pin.sym} 85340 -9850 0 0 {name=p85100 lab=_44242_/Y }
C {devices/lab_pin.sym} 85340 -9810 0 0 {name=p85101 lab=_44256_/A }
C {devices/lab_pin.sym} 85500 -9850 0 1 {name=p85102 lab=_87178_/D }
C {sky130_stdcells/a21oi_4.sym} 85420 -9850 0 0 {name=X_44243_ }
C {devices/lab_pin.sym} 85360 -9720 0 0 {name=p85103 lab=_75062_/A }
C {devices/lab_pin.sym} 85360 -9680 0 0 {name=p85104 lab=_75062_/B }
C {devices/lab_pin.sym} 85480 -9700 0 1 {name=p85105 lab=_75063_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -9700 0 0 {name=X_75063_ }
C {devices/lab_pin.sym} 85380 -9570 0 0 {name=p85106 lab=_79939_/Y }
C {devices/lab_pin.sym} 85460 -9570 0 1 {name=p85107 lab=_79940_/Y }
C {sky130_stdcells/inv_2.sym} 85420 -9570 0 0 {name=X_79940_ }
C {devices/lab_pin.sym} 85330 -9450 0 0 {name=p85108 lab=_88326_/CLK }
C {devices/lab_pin.sym} 85330 -9430 0 0 {name=p85109 lab=_44576_/Y }
C {devices/lab_pin.sym} 85510 -9450 0 1 {name=p85110 lab=_87049_/Q }
C {sky130_stdcells/dfxtp_4.sym} 85420 -9440 0 0 {name=X_87049_ }
C {devices/lab_pin.sym} 85380 -9310 0 0 {name=p85111 lab=_41486_/A }
C {devices/lab_pin.sym} 85460 -9310 0 1 {name=p85112 lab=_41455_/X }
C {sky130_stdcells/buf_2.sym} 85420 -9310 0 0 {name=X_41455_ }
C {devices/lab_pin.sym} 85340 -9230 0 0 {name=p85113 lab=_72270_/X }
C {devices/lab_pin.sym} 85340 -9190 0 0 {name=p85114 lab=_72272_/Y }
C {devices/lab_pin.sym} 85340 -9150 0 0 {name=p85115 lab=_72273_/Y }
C {devices/lab_pin.sym} 85340 -9110 0 0 {name=p85116 lab=_72189_/X }
C {devices/lab_pin.sym} 85340 -9070 0 0 {name=p85117 lab=_72274_/X }
C {devices/lab_pin.sym} 85500 -9150 0 1 {name=p85118 lab=_72275_/X }
C {sky130_stdcells/o32a_4.sym} 85420 -9150 0 0 {name=X_72275_ }
C {devices/lab_pin.sym} 85360 -9000 0 0 {name=p85119 lab=_74038_/A }
C {devices/lab_pin.sym} 85360 -8960 0 0 {name=p85120 lab=_85902_/Q }
C {devices/lab_pin.sym} 85480 -8980 0 1 {name=p85121 lab=_74014_/X }
C {sky130_stdcells/and2_4.sym} 85420 -8980 0 0 {name=X_74014_ }
C {devices/lab_pin.sym} 85360 -8860 0 0 {name=p85122 lab=_82329_/Q }
C {devices/lab_pin.sym} 85360 -8820 0 0 {name=p85123 lab=_40385_/B }
C {devices/lab_pin.sym} 85480 -8840 0 1 {name=p85124 lab=_40406_/X }
C {sky130_stdcells/or2_4.sym} 85420 -8840 0 0 {name=X_40406_ }
C {devices/lab_pin.sym} 85360 -8730 0 0 {name=p85125 lab=_71232_/A }
C {devices/lab_pin.sym} 85360 -8690 0 0 {name=p85126 lab=_71226_/B }
C {devices/lab_pin.sym} 85360 -8650 0 0 {name=p85127 lab=_71232_/C }
C {devices/lab_pin.sym} 85480 -8690 0 1 {name=p85128 lab=_71226_/Y }
C {sky130_stdcells/nand3_4.sym} 85420 -8690 0 0 {name=X_71226_ }
C {devices/lab_pin.sym} 85380 -8550 0 0 {name=p85129 lab=_44174_/A }
C {devices/lab_pin.sym} 85460 -8550 0 1 {name=p85130 lab=_44175_/A }
C {sky130_stdcells/buf_2.sym} 85420 -8550 0 0 {name=X_44174_ }
C {devices/lab_pin.sym} 85360 -8440 0 0 {name=p85131 lab=_81024_/D }
C {devices/lab_pin.sym} 85360 -8400 0 0 {name=p85132 lab=_83280_/Q }
C {devices/lab_pin.sym} 85480 -8420 0 1 {name=p85133 lab=_79871_/X }
C {sky130_stdcells/xor2_4.sym} 85420 -8420 0 0 {name=X_79871_ }
C {devices/lab_pin.sym} 85340 -8310 0 0 {name=p85134 lab=_41373_/X }
C {devices/lab_pin.sym} 85340 -8270 0 0 {name=p85135 lab=_41729_/A }
C {devices/lab_pin.sym} 85340 -8230 0 0 {name=p85136 lab=_41385_/X }
C {devices/lab_pin.sym} 85500 -8270 0 1 {name=p85137 lab=_41387_/A }
C {sky130_stdcells/o21a_4.sym} 85420 -8270 0 0 {name=X_41386_ }
C {devices/lab_pin.sym} 85380 -8130 0 0 {name=p85138 lab=_44530_/A }
C {devices/lab_pin.sym} 85460 -8130 0 1 {name=p85139 lab=_43125_/X }
C {sky130_stdcells/buf_2.sym} 85420 -8130 0 0 {name=X_43125_ }
C {devices/lab_pin.sym} 85340 -8030 0 0 {name=p85140 lab=_78810_/Y }
C {devices/lab_pin.sym} 85340 -7990 0 0 {name=p85141 lab=_78818_/Y }
C {devices/lab_pin.sym} 85340 -7950 0 0 {name=p85142 lab=_78816_/Y }
C {devices/lab_pin.sym} 85500 -7990 0 1 {name=p85143 lab=_78830_/A }
C {sky130_stdcells/a21oi_4.sym} 85420 -7990 0 0 {name=X_78822_ }
C {devices/lab_pin.sym} 85360 -7870 0 0 {name=p85144 lab=_40343_/A }
C {devices/lab_pin.sym} 85360 -7830 0 0 {name=p85145 lab=_40591_/B }
C {devices/lab_pin.sym} 85360 -7790 0 0 {name=p85146 lab=_43175_/B }
C {devices/lab_pin.sym} 85480 -7830 0 1 {name=p85147 lab=_40337_/X }
C {sky130_stdcells/and3_4.sym} 85420 -7830 0 0 {name=X_40337_ }
C {devices/lab_pin.sym} 85360 -7720 0 0 {name=p85148 lab=_71183_/A }
C {devices/lab_pin.sym} 85360 -7680 0 0 {name=p85149 lab=_71155_/B }
C {devices/lab_pin.sym} 85360 -7640 0 0 {name=p85150 lab=_71160_/C }
C {devices/lab_pin.sym} 85360 -7600 0 0 {name=p85151 lab=_71160_/D }
C {devices/lab_pin.sym} 85480 -7660 0 1 {name=p85152 lab=_71157_/Y }
C {sky130_stdcells/nand4_4.sym} 85420 -7660 0 0 {name=X_71157_ }
C {devices/lab_pin.sym} 85380 -7510 0 0 {name=p85153 lab=clkbuf_9_135_0_CLK/X }
C {devices/lab_pin.sym} 85460 -7510 0 1 {name=p85154 lab=_83438_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 85420 -7510 0 0 {name=Xclkbuf_10_270_0_CLK }
C {devices/lab_pin.sym} 85380 -7390 0 0 {name=p85155 lab=_72007_/B }
C {devices/lab_pin.sym} 85460 -7390 0 1 {name=p85156 lab=_48982_/X }
C {sky130_stdcells/buf_2.sym} 85420 -7390 0 0 {name=X_48982_ }
C {devices/lab_pin.sym} 85380 -7270 0 0 {name=p85157 lab=_83127_/Q }
C {devices/lab_pin.sym} 85460 -7270 0 1 {name=p85158 lab=_70108_/Y }
C {sky130_stdcells/inv_2.sym} 85420 -7270 0 0 {name=X_70108_ }
C {devices/lab_pin.sym} 85340 -7170 0 0 {name=p85159 lab=_66037_/B }
C {devices/lab_pin.sym} 85340 -7130 0 0 {name=p85160 lab=_47897_/X }
C {devices/lab_pin.sym} 85340 -7090 0 0 {name=p85161 lab=_47932_/Y }
C {devices/lab_pin.sym} 85500 -7130 0 1 {name=p85162 lab=_47933_/Y }
C {sky130_stdcells/o21ai_4.sym} 85420 -7130 0 0 {name=X_47933_ }
C {devices/lab_pin.sym} 85380 -6990 0 0 {name=p85163 lab=_59918_/Y }
C {devices/lab_pin.sym} 85460 -6990 0 1 {name=p85164 lab=_62475_/A }
C {sky130_stdcells/buf_2.sym} 85420 -6990 0 0 {name=X_59919_ }
C {devices/lab_pin.sym} 85340 -6910 0 0 {name=p85165 lab=_43053_/X }
C {devices/lab_pin.sym} 85340 -6870 0 0 {name=p85166 lab=_43054_/X }
C {devices/lab_pin.sym} 85340 -6830 0 0 {name=p85167 lab=_40646_/X }
C {devices/lab_pin.sym} 85340 -6790 0 0 {name=p85168 lab=_43055_/Y }
C {devices/lab_pin.sym} 85340 -6750 0 0 {name=p85169 lab=_43034_/X }
C {devices/lab_pin.sym} 85500 -6830 0 1 {name=p85170 lab=_43056_/Y }
C {sky130_stdcells/o32ai_4.sym} 85420 -6830 0 0 {name=X_43056_ }
C {devices/lab_pin.sym} 85360 -6690 0 0 {name=p85171 lab=_78749_/Y }
C {devices/lab_pin.sym} 85360 -6650 0 0 {name=p85172 lab=_78753_/B }
C {devices/lab_pin.sym} 85360 -6610 0 0 {name=p85173 lab=_78753_/C }
C {devices/lab_pin.sym} 85480 -6650 0 1 {name=p85174 lab=_78758_/A }
C {sky130_stdcells/or3_4.sym} 85420 -6650 0 0 {name=X_78753_ }
C {devices/lab_pin.sym} 85360 -6530 0 0 {name=p85175 lab=_71088_/A }
C {devices/lab_pin.sym} 85360 -6490 0 0 {name=p85176 lab=_71064_/B }
C {devices/lab_pin.sym} 85360 -6450 0 0 {name=p85177 lab=_71088_/C }
C {devices/lab_pin.sym} 85480 -6490 0 1 {name=p85178 lab=_71088_/Y }
C {sky130_stdcells/nand3_4.sym} 85420 -6490 0 0 {name=X_71088_ }
C {devices/lab_pin.sym} 85380 -6350 0 0 {name=p85179 lab=_75964_/X }
C {devices/lab_pin.sym} 85460 -6350 0 1 {name=p85180 lab=_81736_/D }
C {sky130_stdcells/buf_2.sym} 85420 -6350 0 0 {name=X_75965_ }
C {devices/lab_pin.sym} 85380 -6230 0 0 {name=p85181 lab=clkbuf_9_26_0_CLK/X }
C {devices/lab_pin.sym} 85460 -6230 0 1 {name=p85182 lab=_85031_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 85420 -6230 0 0 {name=Xclkbuf_10_52_0_CLK }
C {devices/lab_pin.sym} 85380 -6110 0 0 {name=p85183 lab=_42025_/A }
C {devices/lab_pin.sym} 85460 -6110 0 1 {name=p85184 lab=_42007_/X }
C {sky130_stdcells/buf_2.sym} 85420 -6110 0 0 {name=X_42007_ }
C {devices/lab_pin.sym} 85340 -6010 0 0 {name=p85185 lab=_77695_/A }
C {devices/lab_pin.sym} 85340 -5970 0 0 {name=p85186 lab=_77695_/B }
C {devices/lab_pin.sym} 85340 -5930 0 0 {name=p85187 lab=_77703_/B }
C {devices/lab_pin.sym} 85500 -5970 0 1 {name=p85188 lab=_77704_/Y }
C {sky130_stdcells/o21ai_4.sym} 85420 -5970 0 0 {name=X_77704_ }
C {devices/lab_pin.sym} 85360 -5850 0 0 {name=p85189 lab=_62930_/A }
C {devices/lab_pin.sym} 85360 -5810 0 0 {name=p85190 lab=_62930_/B }
C {devices/lab_pin.sym} 85360 -5770 0 0 {name=p85191 lab=_84369_/Q }
C {devices/lab_pin.sym} 85480 -5810 0 1 {name=p85192 lab=_62930_/Y }
C {sky130_stdcells/nor3_4.sym} 85420 -5810 0 0 {name=X_62930_ }
C {devices/lab_pin.sym} 85380 -5670 0 0 {name=p85193 lab=clkbuf_9_391_0_CLK/A }
C {devices/lab_pin.sym} 85460 -5670 0 1 {name=p85194 lab=clkbuf_9_391_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 85420 -5670 0 0 {name=Xclkbuf_9_391_0_CLK }
C {devices/lab_pin.sym} 85360 -5560 0 0 {name=p85195 lab=_81131_/D }
C {devices/lab_pin.sym} 85360 -5520 0 0 {name=p85196 lab=_74916_/B }
C {devices/lab_pin.sym} 85480 -5540 0 1 {name=p85197 lab=_74916_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -5540 0 0 {name=X_74916_ }
C {devices/lab_pin.sym} 85340 -5430 0 0 {name=p85198 lab=_83866_/Q }
C {devices/lab_pin.sym} 85340 -5390 0 0 {name=p85199 lab=_70029_/X }
C {devices/lab_pin.sym} 85340 -5350 0 0 {name=p85200 lab=_70038_/X }
C {devices/lab_pin.sym} 85500 -5390 0 1 {name=p85201 lab=_83866_/D }
C {sky130_stdcells/a21bo_4.sym} 85420 -5390 0 0 {name=X_70039_ }
C {devices/lab_pin.sym} 85380 -5250 0 0 {name=p85202 lab=_47863_/Y }
C {devices/lab_pin.sym} 85460 -5250 0 1 {name=p85203 lab=_51947_/B }
C {sky130_stdcells/buf_2.sym} 85420 -5250 0 0 {name=X_47864_ }
C {devices/lab_pin.sym} 85360 -5140 0 0 {name=p85204 lab=_78684_/A }
C {devices/lab_pin.sym} 85360 -5100 0 0 {name=p85205 lab=_78684_/B }
C {devices/lab_pin.sym} 85480 -5120 0 1 {name=p85206 lab=_78684_/X }
C {sky130_stdcells/and2_4.sym} 85420 -5120 0 0 {name=X_78684_ }
C {devices/lab_pin.sym} 85360 -5000 0 0 {name=p85207 lab=_61265_/C }
C {devices/lab_pin.sym} 85360 -4960 0 0 {name=p85208 lab=_84366_/Q }
C {devices/lab_pin.sym} 85480 -4980 0 1 {name=p85209 lab=_75896_/X }
C {sky130_stdcells/xor2_4.sym} 85420 -4980 0 0 {name=X_75896_ }
C {devices/lab_pin.sym} 85360 -4880 0 0 {name=p85210 lab=_49610_/A }
C {devices/lab_pin.sym} 85360 -4840 0 0 {name=p85211 lab=_49592_/B }
C {devices/lab_pin.sym} 85360 -4800 0 0 {name=p85212 lab=_49615_/C }
C {devices/lab_pin.sym} 85360 -4760 0 0 {name=p85213 lab=_52818_/D }
C {devices/lab_pin.sym} 85480 -4820 0 1 {name=p85214 lab=_49603_/X }
C {sky130_stdcells/and4_4.sym} 85420 -4820 0 0 {name=X_49603_ }
C {devices/lab_pin.sym} 85380 -4670 0 0 {name=p85215 lab=_83668_/Q }
C {devices/lab_pin.sym} 85460 -4670 0 1 {name=p85216 lab=_52692_/B }
C {sky130_stdcells/inv_2.sym} 85420 -4670 0 0 {name=X_46815_ }
C {devices/lab_pin.sym} 85380 -4550 0 0 {name=p85217 lab=clkbuf_9_142_0_CLK/X }
C {devices/lab_pin.sym} 85460 -4550 0 1 {name=p85218 lab=_83745_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 85420 -4550 0 0 {name=Xclkbuf_10_285_0_CLK }
C {devices/lab_pin.sym} 85340 -4450 0 0 {name=p85219 lab=_77614_/A }
C {devices/lab_pin.sym} 85340 -4410 0 0 {name=p85220 lab=_77614_/B }
C {devices/lab_pin.sym} 85340 -4370 0 0 {name=p85221 lab=_77612_/Y }
C {devices/lab_pin.sym} 85500 -4410 0 1 {name=p85222 lab=_77635_/X }
C {sky130_stdcells/o21a_4.sym} 85420 -4410 0 0 {name=X_77635_ }
C {devices/lab_pin.sym} 85380 -4270 0 0 {name=p85223 lab=_62667_/X }
C {devices/lab_pin.sym} 85460 -4270 0 1 {name=p85224 lab=_62911_/C }
C {sky130_stdcells/buf_2.sym} 85420 -4270 0 0 {name=X_62861_ }
C {devices/lab_pin.sym} 85380 -4150 0 0 {name=p85225 lab=_74846_/Y }
C {devices/lab_pin.sym} 85460 -4150 0 1 {name=p85226 lab=_80653_/D }
C {sky130_stdcells/inv_2.sym} 85420 -4150 0 0 {name=X_74847_ }
C {devices/lab_pin.sym} 85360 -4060 0 0 {name=p85227 lab=_47804_/A }
C {devices/lab_pin.sym} 85360 -4020 0 0 {name=p85228 lab=_49364_/B }
C {devices/lab_pin.sym} 85360 -3980 0 0 {name=p85229 lab=_47777_/C }
C {devices/lab_pin.sym} 85360 -3940 0 0 {name=p85230 lab=_53249_/D }
C {devices/lab_pin.sym} 85480 -4000 0 1 {name=p85231 lab=_47795_/X }
C {sky130_stdcells/and4_4.sym} 85420 -4000 0 0 {name=X_47795_ }
C {devices/lab_pin.sym} 85380 -3850 0 0 {name=p85232 lab=_64600_/A }
C {devices/lab_pin.sym} 85460 -3850 0 1 {name=p85233 lab=_64600_/X }
C {sky130_stdcells/buf_2.sym} 85420 -3850 0 0 {name=X_64600_ }
C {devices/lab_pin.sym} 85340 -3750 0 0 {name=p85234 lab=_49531_/Y }
C {devices/lab_pin.sym} 85340 -3710 0 0 {name=p85235 lab=_49514_/X }
C {devices/lab_pin.sym} 85340 -3670 0 0 {name=p85236 lab=_49533_/X }
C {devices/lab_pin.sym} 85500 -3710 0 1 {name=p85237 lab=_86370_/D }
C {sky130_stdcells/a21oi_4.sym} 85420 -3710 0 0 {name=X_49534_ }
C {devices/lab_pin.sym} 85380 -3570 0 0 {name=p85238 lab=_61747_/X }
C {devices/lab_pin.sym} 85460 -3570 0 1 {name=p85239 lab=_61846_/D }
C {sky130_stdcells/buf_2.sym} 85420 -3570 0 0 {name=X_61812_ }
C {devices/lab_pin.sym} 85340 -3470 0 0 {name=p85240 lab=_46742_/Y }
C {devices/lab_pin.sym} 85340 -3430 0 0 {name=p85241 lab=_46704_/X }
C {devices/lab_pin.sym} 85340 -3390 0 0 {name=p85242 lab=_46745_/X }
C {devices/lab_pin.sym} 85500 -3430 0 1 {name=p85243 lab=_86708_/D }
C {sky130_stdcells/a21oi_4.sym} 85420 -3430 0 0 {name=X_46746_ }
C {devices/lab_pin.sym} 85360 -3300 0 0 {name=p85244 lab=_65387_/A }
C {devices/lab_pin.sym} 85360 -3260 0 0 {name=p85245 lab=_73042_/B }
C {devices/lab_pin.sym} 85480 -3280 0 1 {name=p85246 lab=_65580_/X }
C {sky130_stdcells/and2_4.sym} 85420 -3280 0 0 {name=X_65580_ }
C {devices/lab_pin.sym} 85380 -3150 0 0 {name=p85247 lab=clkbuf_9_33_0_CLK/X }
C {devices/lab_pin.sym} 85460 -3150 0 1 {name=p85248 lab=_86887_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 85420 -3150 0 0 {name=Xclkbuf_10_67_0_CLK }
C {devices/lab_pin.sym} 85380 -3030 0 0 {name=p85249 lab=_82233_/Q }
C {devices/lab_pin.sym} 85460 -3030 0 1 {name=p85250 lab=_77570_/A }
C {sky130_stdcells/inv_2.sym} 85420 -3030 0 0 {name=X_77566_ }
C {devices/lab_pin.sym} 85340 -2940 0 0 {name=p85251 lab=_44104_/A }
C {devices/lab_pin.sym} 85340 -2900 0 0 {name=p85252 lab=_43954_/X }
C {devices/lab_pin.sym} 85340 -2860 0 0 {name=p85253 lab=_43955_/Y }
C {devices/lab_pin.sym} 85340 -2820 0 0 {name=p85254 lab=_43957_/X }
C {devices/lab_pin.sym} 85500 -2880 0 1 {name=p85255 lab=_43959_/B }
C {sky130_stdcells/a211o_4.sym} 85420 -2880 0 0 {name=X_43958_ }
C {devices/lab_pin.sym} 85380 -2730 0 0 {name=p85256 lab=_62791_/X }
C {devices/lab_pin.sym} 85460 -2730 0 1 {name=p85257 lab=_62792_/X }
C {sky130_stdcells/buf_2.sym} 85420 -2730 0 0 {name=X_62792_ }
C {devices/lab_pin.sym} 85360 -2640 0 0 {name=p85258 lab=_74804_/A }
C {devices/lab_pin.sym} 85360 -2600 0 0 {name=p85259 lab=_74778_/B }
C {devices/lab_pin.sym} 85360 -2560 0 0 {name=p85260 lab=_74804_/C }
C {devices/lab_pin.sym} 85360 -2520 0 0 {name=p85261 lab=_74804_/D }
C {devices/lab_pin.sym} 85480 -2580 0 1 {name=p85262 lab=_74778_/X }
C {sky130_stdcells/and4_4.sym} 85420 -2580 0 0 {name=X_74778_ }
C {devices/lab_pin.sym} 85340 -2450 0 0 {name=p85263 lab=_79297_/A }
C {devices/lab_pin.sym} 85340 -2410 0 0 {name=p85264 lab=_79296_/Y }
C {devices/lab_pin.sym} 85340 -2370 0 0 {name=p85265 lab=_79304_/X }
C {devices/lab_pin.sym} 85500 -2410 0 1 {name=p85266 lab=_79306_/B }
C {sky130_stdcells/o21ai_4.sym} 85420 -2410 0 0 {name=X_79305_ }
C {devices/lab_pin.sym} 85380 -2270 0 0 {name=p85267 lab=_79554_/B }
C {devices/lab_pin.sym} 85460 -2270 0 1 {name=p85268 lab=_79552_/A }
C {sky130_stdcells/inv_2.sym} 85420 -2270 0 0 {name=X_64531_ }
C {devices/lab_pin.sym} 85380 -2150 0 0 {name=p85269 lab=clkbuf_8_213_0_CLK/A }
C {devices/lab_pin.sym} 85460 -2150 0 1 {name=p85270 lab=clkbuf_9_427_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 85420 -2150 0 0 {name=Xclkbuf_8_213_0_CLK }
C {devices/lab_pin.sym} 85360 -2040 0 0 {name=p85271 lab=_76517_/A }
C {devices/lab_pin.sym} 85360 -2000 0 0 {name=p85272 lab=_76516_/Y }
C {devices/lab_pin.sym} 85480 -2020 0 1 {name=p85273 lab=_76518_/B }
C {sky130_stdcells/xor2_4.sym} 85420 -2020 0 0 {name=X_76517_ }
C {devices/lab_pin.sym} 85340 -1930 0 0 {name=p85274 lab=_42895_/X }
C {devices/lab_pin.sym} 85340 -1890 0 0 {name=p85275 lab=_42896_/X }
C {devices/lab_pin.sym} 85340 -1850 0 0 {name=p85276 lab=_41688_/X }
C {devices/lab_pin.sym} 85340 -1810 0 0 {name=p85277 lab=_87657_/Q }
C {devices/lab_pin.sym} 85340 -1770 0 0 {name=p85278 lab=_42905_/X }
C {devices/lab_pin.sym} 85500 -1850 0 1 {name=p85279 lab=_42909_/Y }
C {sky130_stdcells/o32ai_4.sym} 85420 -1850 0 0 {name=X_42909_ }
C {devices/lab_pin.sym} 85340 -1710 0 0 {name=p85280 lab=_58804_/B }
C {devices/lab_pin.sym} 85340 -1670 0 0 {name=p85281 lab=_49443_/X }
C {devices/lab_pin.sym} 85340 -1630 0 0 {name=p85282 lab=_49464_/Y }
C {devices/lab_pin.sym} 85500 -1670 0 1 {name=p85283 lab=_49465_/Y }
C {sky130_stdcells/o21ai_4.sym} 85420 -1670 0 0 {name=X_49465_ }
C {devices/lab_pin.sym} 85360 -1560 0 0 {name=p85284 lab=_61329_/B }
C {devices/lab_pin.sym} 85360 -1520 0 0 {name=p85285 lab=_62149_/B }
C {devices/lab_pin.sym} 85360 -1480 0 0 {name=p85286 lab=_61761_/C }
C {devices/lab_pin.sym} 85360 -1440 0 0 {name=p85287 lab=_62130_/D }
C {devices/lab_pin.sym} 85480 -1500 0 1 {name=p85288 lab=_61743_/Y }
C {sky130_stdcells/nand4_4.sym} 85420 -1500 0 0 {name=X_61743_ }
C {devices/lab_pin.sym} 85340 -1370 0 0 {name=p85289 lab=_88364_/Q }
C {devices/lab_pin.sym} 85340 -1330 0 0 {name=p85290 lab=_73633_/X }
C {devices/lab_pin.sym} 85340 -1290 0 0 {name=p85291 lab=_73704_/X }
C {devices/lab_pin.sym} 85500 -1330 0 1 {name=p85292 lab=_73729_/Y }
C {sky130_stdcells/o21ai_4.sym} 85420 -1330 0 0 {name=X_73729_ }
C {devices/lab_pin.sym} 85360 -1200 0 0 {name=p85293 lab=_46712_/A }
C {devices/lab_pin.sym} 85360 -1160 0 0 {name=p85294 lab=_51779_/B }
C {devices/lab_pin.sym} 85480 -1180 0 1 {name=p85295 lab=_46677_/Y }
C {sky130_stdcells/nand2_4.sym} 85420 -1180 0 0 {name=X_46677_ }
C {devices/lab_pin.sym} 85380 -1050 0 0 {name=p85296 lab=_77497_/A }
C {devices/lab_pin.sym} 85460 -1050 0 1 {name=p85297 lab=_77502_/A }
C {sky130_stdcells/inv_2.sym} 85420 -1050 0 0 {name=X_77497_ }
C {devices/lab_pin.sym} 85340 -960 0 0 {name=p85298 lab=_41312_/X }
C {devices/lab_pin.sym} 85340 -920 0 0 {name=p85299 lab=_43886_/X }
C {devices/lab_pin.sym} 85340 -880 0 0 {name=p85300 lab=_67453_/B }
C {devices/lab_pin.sym} 85340 -840 0 0 {name=p85301 lab=_43887_/X }
C {devices/lab_pin.sym} 85500 -900 0 1 {name=p85302 lab=_87214_/D }
C {sky130_stdcells/a2bb2o_4.sym} 85420 -900 0 0 {name=X_43889_ }
C {devices/lab_pin.sym} 85380 -750 0 0 {name=p85303 lab=_48416_/A }
C {devices/lab_pin.sym} 85460 -750 0 1 {name=p85304 lab=_52123_/B }
C {sky130_stdcells/buf_2.sym} 85420 -750 0 0 {name=X_48416_ }
C {devices/lab_pin.sym} 86280 -42160 0 0 {name=p85305 lab=_67250_/A }
C {devices/lab_pin.sym} 86280 -42120 0 0 {name=p85306 lab=_86778_/Q }
C {devices/lab_pin.sym} 86400 -42140 0 1 {name=p85307 lab=_67250_/X }
C {sky130_stdcells/and2_4.sym} 86340 -42140 0 0 {name=X_67250_ }
C {devices/lab_pin.sym} 86300 -42010 0 0 {name=p85308 lab=_79236_/A }
C {devices/lab_pin.sym} 86380 -42010 0 1 {name=p85309 lab=_79236_/Y }
C {sky130_stdcells/inv_2.sym} 86340 -42010 0 0 {name=X_79236_ }
C {devices/lab_pin.sym} 86300 -41890 0 0 {name=p85310 lab=_45281_/A }
C {devices/lab_pin.sym} 86380 -41890 0 1 {name=p85311 lab=_45801_/A }
C {sky130_stdcells/buf_2.sym} 86340 -41890 0 0 {name=X_45628_ }
C {devices/lab_pin.sym} 86280 -41790 0 0 {name=p85312 lab=_64490_/A }
C {devices/lab_pin.sym} 86280 -41750 0 0 {name=p85313 lab=_64490_/B }
C {devices/lab_pin.sym} 86280 -41710 0 0 {name=p85314 lab=_79658_/B }
C {devices/lab_pin.sym} 86400 -41750 0 1 {name=p85315 lab=_64462_/Y }
C {sky130_stdcells/nor3_4.sym} 86340 -41750 0 0 {name=X_64462_ }
C {devices/lab_pin.sym} 86280 -41620 0 0 {name=p85316 lab=_76441_/X }
C {devices/lab_pin.sym} 86280 -41580 0 0 {name=p85317 lab=_76448_/B }
C {devices/lab_pin.sym} 86400 -41600 0 1 {name=p85318 lab=_76449_/B }
C {sky130_stdcells/xor2_4.sym} 86340 -41600 0 0 {name=X_76448_ }
C {devices/lab_pin.sym} 86300 -41470 0 0 {name=p85319 lab=_49451_/A }
C {devices/lab_pin.sym} 86380 -41470 0 1 {name=p85320 lab=_49420_/B }
C {sky130_stdcells/buf_2.sym} 86340 -41470 0 0 {name=X_49396_ }
C {devices/lab_pin.sym} 86300 -41350 0 0 {name=p85321 lab=_84732_/Q }
C {devices/lab_pin.sym} 86380 -41350 0 1 {name=p85322 lab=_61675_/B }
C {sky130_stdcells/buf_2.sym} 86340 -41350 0 0 {name=X_61674_ }
C {devices/lab_pin.sym} 86280 -41240 0 0 {name=p85323 lab=_66011_/X }
C {devices/lab_pin.sym} 86280 -41200 0 0 {name=p85324 lab=_86541_/Q }
C {devices/lab_pin.sym} 86400 -41220 0 1 {name=p85325 lab=_66201_/X }
C {sky130_stdcells/and2_4.sym} 86340 -41220 0 0 {name=X_66201_ }
C {devices/lab_pin.sym} 86300 -41090 0 0 {name=p85326 lab=_63413_/A }
C {devices/lab_pin.sym} 86380 -41090 0 1 {name=p85327 lab=_63463_/C }
C {sky130_stdcells/buf_2.sym} 86340 -41090 0 0 {name=X_63413_ }
C {devices/lab_pin.sym} 86300 -40970 0 0 {name=p85328 lab=_48148_/B }
C {devices/lab_pin.sym} 86380 -40970 0 1 {name=p85329 lab=_50385_/B }
C {sky130_stdcells/buf_2.sym} 86340 -40970 0 0 {name=X_48347_ }
C {devices/lab_pin.sym} 86300 -40850 0 0 {name=p85330 lab=_60624_/X }
C {devices/lab_pin.sym} 86380 -40850 0 1 {name=p85331 lab=_60694_/C }
C {sky130_stdcells/buf_2.sym} 86340 -40850 0 0 {name=X_60625_ }
C {devices/lab_pin.sym} 86260 -40750 0 0 {name=p85332 lab=_67178_/X }
C {devices/lab_pin.sym} 86260 -40710 0 0 {name=p85333 lab=_67180_/X }
C {devices/lab_pin.sym} 86260 -40670 0 0 {name=p85334 lab=_67085_/X }
C {devices/lab_pin.sym} 86420 -40710 0 1 {name=p85335 lab=_67181_/X }
C {sky130_stdcells/a21o_4.sym} 86340 -40710 0 0 {name=X_67181_ }
C {devices/lab_pin.sym} 86280 -40580 0 0 {name=p85336 lab=_79165_/Y }
C {devices/lab_pin.sym} 86280 -40540 0 0 {name=p85337 lab=_79173_/A }
C {devices/lab_pin.sym} 86400 -40560 0 1 {name=p85338 lab=_79171_/A }
C {sky130_stdcells/nand2_4.sym} 86340 -40560 0 0 {name=X_79167_ }
C {devices/lab_pin.sym} 86300 -40430 0 0 {name=p85339 lab=_45272_/A }
C {devices/lab_pin.sym} 86380 -40430 0 1 {name=p85340 lab=_45654_/B }
C {sky130_stdcells/buf_2.sym} 86340 -40430 0 0 {name=X_45559_ }
C {devices/lab_pin.sym} 86280 -40330 0 0 {name=p85341 lab=_64344_/X }
C {devices/lab_pin.sym} 86280 -40290 0 0 {name=p85342 lab=_64379_/B }
C {devices/lab_pin.sym} 86280 -40250 0 0 {name=p85343 lab=_84826_/Q }
C {devices/lab_pin.sym} 86400 -40290 0 1 {name=p85344 lab=_64393_/X }
C {sky130_stdcells/and3_4.sym} 86340 -40290 0 0 {name=X_64393_ }
C {devices/lab_pin.sym} 86280 -40160 0 0 {name=p85345 lab=_76377_/Y }
C {devices/lab_pin.sym} 86280 -40120 0 0 {name=p85346 lab=_76379_/B }
C {devices/lab_pin.sym} 86400 -40140 0 1 {name=p85347 lab=_76379_/X }
C {sky130_stdcells/xor2_4.sym} 86340 -40140 0 0 {name=X_76379_ }
C {devices/lab_pin.sym} 86300 -40010 0 0 {name=p85348 lab=clkbuf_8_229_0_CLK/A }
C {devices/lab_pin.sym} 86380 -40010 0 1 {name=p85349 lab=clkbuf_8_228_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 86340 -40010 0 0 {name=Xclkbuf_8_228_0_CLK }
C {devices/lab_pin.sym} 86280 -39900 0 0 {name=p85350 lab=_66226_/A }
C {devices/lab_pin.sym} 86280 -39860 0 0 {name=p85351 lab=_86546_/Q }
C {devices/lab_pin.sym} 86400 -39880 0 1 {name=p85352 lab=_66132_/X }
C {sky130_stdcells/and2_4.sym} 86340 -39880 0 0 {name=X_66132_ }
C {devices/lab_pin.sym} 86300 -39750 0 0 {name=p85353 lab=_78130_/C }
C {devices/lab_pin.sym} 86380 -39750 0 1 {name=p85354 lab=_78120_/B }
C {sky130_stdcells/inv_2.sym} 86340 -39750 0 0 {name=X_78118_ }
C {devices/lab_pin.sym} 86280 -39660 0 0 {name=p85355 lab=_63344_/A }
C {devices/lab_pin.sym} 86280 -39620 0 0 {name=p85356 lab=_63344_/B }
C {devices/lab_pin.sym} 86280 -39580 0 0 {name=p85357 lab=_60588_/X }
C {devices/lab_pin.sym} 86280 -39540 0 0 {name=p85358 lab=_63344_/D }
C {devices/lab_pin.sym} 86400 -39600 0 1 {name=p85359 lab=_63344_/X }
C {sky130_stdcells/or4_4.sym} 86340 -39600 0 0 {name=X_63344_ }
C {devices/lab_pin.sym} 86300 -39450 0 0 {name=p85360 lab=clkbuf_9_111_0_CLK/X }
C {devices/lab_pin.sym} 86380 -39450 0 1 {name=p85361 lab=_84603_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 86340 -39450 0 0 {name=Xclkbuf_10_223_0_CLK }
C {devices/lab_pin.sym} 86260 -39350 0 0 {name=p85362 lab=_48272_/Y }
C {devices/lab_pin.sym} 86260 -39310 0 0 {name=p85363 lab=_48273_/X }
C {devices/lab_pin.sym} 86260 -39270 0 0 {name=p85364 lab=_48277_/Y }
C {devices/lab_pin.sym} 86420 -39310 0 1 {name=p85365 lab=_48278_/Y }
C {sky130_stdcells/a21boi_4.sym} 86340 -39310 0 0 {name=X_48278_ }
C {devices/lab_pin.sym} 86280 -39180 0 0 {name=p85366 lab=_60555_/Y }
C {devices/lab_pin.sym} 86280 -39140 0 0 {name=p85367 lab=_60556_/B }
C {devices/lab_pin.sym} 86400 -39160 0 1 {name=p85368 lab=_60556_/Y }
C {sky130_stdcells/nand2_4.sym} 86340 -39160 0 0 {name=X_60556_ }
C {devices/lab_pin.sym} 86280 -39050 0 0 {name=p85369 lab=_79095_/X }
C {devices/lab_pin.sym} 86280 -39010 0 0 {name=p85370 lab=_82752_/Q }
C {devices/lab_pin.sym} 86280 -38970 0 0 {name=p85371 lab=_79109_/A }
C {devices/lab_pin.sym} 86400 -39010 0 1 {name=p85372 lab=_79099_/A }
C {sky130_stdcells/nand3_4.sym} 86340 -39010 0 0 {name=X_79098_ }
C {devices/lab_pin.sym} 86300 -38870 0 0 {name=p85373 lab=clkbuf_9_426_0_CLK/X }
C {devices/lab_pin.sym} 86380 -38870 0 1 {name=p85374 lab=_82774_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 86340 -38870 0 0 {name=Xclkbuf_10_853_0_CLK }
C {devices/lab_pin.sym} 86260 -38770 0 0 {name=p85375 lab=_47223_/Y }
C {devices/lab_pin.sym} 86260 -38730 0 0 {name=p85376 lab=_47224_/X }
C {devices/lab_pin.sym} 86260 -38690 0 0 {name=p85377 lab=_47228_/X }
C {devices/lab_pin.sym} 86420 -38730 0 1 {name=p85378 lab=_86657_/D }
C {sky130_stdcells/a21oi_4.sym} 86340 -38730 0 0 {name=X_47229_ }
C {devices/lab_pin.sym} 86260 -38610 0 0 {name=p85379 lab=_66020_/X }
C {devices/lab_pin.sym} 86260 -38570 0 0 {name=p85380 lab=_66061_/Y }
C {devices/lab_pin.sym} 86260 -38530 0 0 {name=p85381 lab=_66062_/Y }
C {devices/lab_pin.sym} 86420 -38570 0 1 {name=p85382 lab=_66063_/Y }
C {sky130_stdcells/o21ai_4.sym} 86340 -38570 0 0 {name=X_66063_ }
C {devices/lab_pin.sym} 86280 -38440 0 0 {name=p85383 lab=_78049_/A }
C {devices/lab_pin.sym} 86280 -38400 0 0 {name=p85384 lab=_78049_/B }
C {devices/lab_pin.sym} 86400 -38420 0 1 {name=p85385 lab=_78049_/X }
C {sky130_stdcells/xor2_4.sym} 86340 -38420 0 0 {name=X_78049_ }
C {devices/lab_pin.sym} 86260 -38330 0 0 {name=p85386 lab=_63248_/X }
C {devices/lab_pin.sym} 86260 -38290 0 0 {name=p85387 lab=_63270_/Y }
C {devices/lab_pin.sym} 86260 -38250 0 0 {name=p85388 lab=_63271_/X }
C {devices/lab_pin.sym} 86260 -38210 0 0 {name=p85389 lab=_63272_/Y }
C {devices/lab_pin.sym} 86260 -38180 0 0 {name=p85390 lab=_63274_/Y }
C {devices/lab_pin.sym} 86420 -38250 0 1 {name=p85391 lab=_63275_/X }
C {sky130_stdcells/a41o_4.sym} 86340 -38250 0 0 {name=X_63275_ }
C {devices/lab_pin.sym} 86260 -38120 0 0 {name=p85392 lab=_79152_/A }
C {devices/lab_pin.sym} 86260 -38080 0 0 {name=p85393 lab=_60246_/X }
C {devices/lab_pin.sym} 86260 -38040 0 0 {name=p85394 lab=_60481_/X }
C {devices/lab_pin.sym} 86260 -38000 0 0 {name=p85395 lab=_60486_/Y }
C {devices/lab_pin.sym} 86420 -38060 0 1 {name=p85396 lab=_84612_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 86340 -38060 0 0 {name=X_60487_ }
C {devices/lab_pin.sym} 86260 -37930 0 0 {name=p85397 lab=_65011_/X }
C {devices/lab_pin.sym} 86260 -37890 0 0 {name=p85398 lab=_65013_/X }
C {devices/lab_pin.sym} 86260 -37850 0 0 {name=p85399 lab=_64989_/X }
C {devices/lab_pin.sym} 86420 -37890 0 1 {name=p85400 lab=_65014_/X }
C {sky130_stdcells/a21o_4.sym} 86340 -37890 0 0 {name=X_65014_ }
C {devices/lab_pin.sym} 86300 -37750 0 0 {name=p85401 lab=clkbuf_9_345_0_CLK/A }
C {devices/lab_pin.sym} 86380 -37750 0 1 {name=p85402 lab=clkbuf_9_344_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 86340 -37750 0 0 {name=Xclkbuf_9_344_0_CLK }
C {devices/lab_pin.sym} 86280 -37640 0 0 {name=p85403 lab=_50240_/A }
C {devices/lab_pin.sym} 86280 -37600 0 0 {name=p85404 lab=_51947_/B }
C {devices/lab_pin.sym} 86400 -37620 0 1 {name=p85405 lab=_50240_/Y }
C {sky130_stdcells/nand2_4.sym} 86340 -37620 0 0 {name=X_50240_ }
C {devices/lab_pin.sym} 86280 -37520 0 0 {name=p85406 lab=_61338_/A }
C {devices/lab_pin.sym} 86280 -37480 0 0 {name=p85407 lab=_62631_/B }
C {devices/lab_pin.sym} 86280 -37440 0 0 {name=p85408 lab=_62631_/C }
C {devices/lab_pin.sym} 86280 -37400 0 0 {name=p85409 lab=_62225_/X }
C {devices/lab_pin.sym} 86400 -37460 0 1 {name=p85410 lab=_62234_/B }
C {sky130_stdcells/nand4_4.sym} 86340 -37460 0 0 {name=X_62226_ }
C {devices/lab_pin.sym} 86250 -37310 0 0 {name=p85411 lab=_82084_/CLK }
C {devices/lab_pin.sym} 86250 -37290 0 0 {name=p85412 lab=_81092_/Q }
C {devices/lab_pin.sym} 86430 -37310 0 1 {name=p85413 lab=_75100_/A }
C {sky130_stdcells/dfxtp_4.sym} 86340 -37300 0 0 {name=X_81060_ }
C {devices/lab_pin.sym} 86280 -37200 0 0 {name=p85414 lab=_79988_/A }
C {devices/lab_pin.sym} 86280 -37160 0 0 {name=p85415 lab=_80011_/B }
C {devices/lab_pin.sym} 86280 -37120 0 0 {name=p85416 lab=_79988_/B }
C {devices/lab_pin.sym} 86280 -37080 0 0 {name=p85417 lab=_80011_/D }
C {devices/lab_pin.sym} 86400 -37140 0 1 {name=p85418 lab=_80011_/Y }
C {sky130_stdcells/nand4_4.sym} 86340 -37140 0 0 {name=X_80011_ }
C {devices/lab_pin.sym} 86300 -36990 0 0 {name=p85419 lab=clkbuf_9_119_0_CLK/X }
C {devices/lab_pin.sym} 86380 -36990 0 1 {name=p85420 lab=_80679_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 86340 -36990 0 0 {name=Xclkbuf_10_238_0_CLK }
C {devices/lab_pin.sym} 86260 -36900 0 0 {name=p85421 lab=_73247_/A }
C {devices/lab_pin.sym} 86260 -36860 0 0 {name=p85422 lab=_44299_/A }
C {devices/lab_pin.sym} 86260 -36820 0 0 {name=p85423 lab=_68933_/X }
C {devices/lab_pin.sym} 86260 -36780 0 0 {name=p85424 lab=_69821_/Y }
C {devices/lab_pin.sym} 86420 -36840 0 1 {name=p85425 lab=_69822_/X }
C {sky130_stdcells/a211o_4.sym} 86340 -36840 0 0 {name=X_69822_ }
C {devices/lab_pin.sym} 86280 -36700 0 0 {name=p85426 lab=_50131_/A }
C {devices/lab_pin.sym} 86280 -36660 0 0 {name=p85427 lab=_53902_/B }
C {devices/lab_pin.sym} 86400 -36680 0 1 {name=p85428 lab=_50171_/X }
C {sky130_stdcells/and2_4.sym} 86340 -36680 0 0 {name=X_50171_ }
C {devices/lab_pin.sym} 86280 -36580 0 0 {name=p85429 lab=_62065_/B }
C {devices/lab_pin.sym} 86280 -36540 0 0 {name=p85430 lab=_62063_/X }
C {devices/lab_pin.sym} 86280 -36500 0 0 {name=p85431 lab=_63694_/B }
C {devices/lab_pin.sym} 86280 -36460 0 0 {name=p85432 lab=_62183_/D }
C {devices/lab_pin.sym} 86400 -36520 0 1 {name=p85433 lab=_62157_/X }
C {sky130_stdcells/and4_4.sym} 86340 -36520 0 0 {name=X_62157_ }
C {devices/lab_pin.sym} 86300 -36370 0 0 {name=p85434 lab=clkbuf_9_434_0_CLK/X }
C {devices/lab_pin.sym} 86380 -36370 0 1 {name=p85435 lab=_86404_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 86340 -36370 0 0 {name=Xclkbuf_10_868_0_CLK }
C {devices/lab_pin.sym} 86260 -36270 0 0 {name=p85436 lab=_61122_/B }
C {devices/lab_pin.sym} 86260 -36230 0 0 {name=p85437 lab=_61122_/C }
C {devices/lab_pin.sym} 86260 -36190 0 0 {name=p85438 lab=_61082_/X }
C {devices/lab_pin.sym} 86420 -36230 0 1 {name=p85439 lab=_61108_/Y }
C {sky130_stdcells/a21boi_4.sym} 86340 -36230 0 0 {name=X_61108_ }
C {devices/lab_pin.sym} 86260 -36120 0 0 {name=p85440 lab=_73126_/A }
C {devices/lab_pin.sym} 86260 -36080 0 0 {name=p85441 lab=_69751_/X }
C {devices/lab_pin.sym} 86260 -36040 0 0 {name=p85442 lab=_68070_/X }
C {devices/lab_pin.sym} 86260 -36000 0 0 {name=p85443 lab=_69752_/Y }
C {devices/lab_pin.sym} 86420 -36060 0 1 {name=p85444 lab=_69753_/X }
C {sky130_stdcells/a211o_4.sym} 86340 -36060 0 0 {name=X_69753_ }
C {devices/lab_pin.sym} 86260 -35930 0 0 {name=p85445 lab=_66960_/X }
C {devices/lab_pin.sym} 86260 -35890 0 0 {name=p85446 lab=_66963_/X }
C {devices/lab_pin.sym} 86260 -35850 0 0 {name=p85447 lab=_66964_/X }
C {devices/lab_pin.sym} 86420 -35890 0 1 {name=p85448 lab=_66965_/X }
C {sky130_stdcells/a21o_4.sym} 86340 -35890 0 0 {name=X_66965_ }
C {devices/lab_pin.sym} 86280 -35780 0 0 {name=p85449 lab=_59794_/X }
C {devices/lab_pin.sym} 86280 -35740 0 0 {name=p85450 lab=_62088_/B }
C {devices/lab_pin.sym} 86280 -35700 0 0 {name=p85451 lab=_62086_/Y }
C {devices/lab_pin.sym} 86280 -35660 0 0 {name=p85452 lab=_62087_/Y }
C {devices/lab_pin.sym} 86400 -35720 0 1 {name=p85453 lab=_62088_/Y }
C {sky130_stdcells/nand4_4.sym} 86340 -35720 0 0 {name=X_62088_ }
C {devices/lab_pin.sym} 86300 -35570 0 0 {name=p85454 lab=clkbuf_8_179_0_CLK/X }
C {devices/lab_pin.sym} 86380 -35570 0 1 {name=p85455 lab=clkbuf_9_359_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 86340 -35570 0 0 {name=Xclkbuf_9_359_0_CLK }
C {devices/lab_pin.sym} 86280 -35460 0 0 {name=p85456 lab=_68604_/A }
C {devices/lab_pin.sym} 86280 -35420 0 0 {name=p85457 lab=_87238_/Q }
C {devices/lab_pin.sym} 86400 -35440 0 1 {name=p85458 lab=_68704_/X }
C {sky130_stdcells/and2_4.sym} 86340 -35440 0 0 {name=X_68704_ }
C {devices/lab_pin.sym} 86280 -35320 0 0 {name=p85459 lab=_53949_/A }
C {devices/lab_pin.sym} 86280 -35280 0 0 {name=p85460 lab=_50714_/B }
C {devices/lab_pin.sym} 86400 -35300 0 1 {name=p85461 lab=_53930_/Y }
C {sky130_stdcells/nand2_4.sym} 86340 -35300 0 0 {name=X_53930_ }
C {devices/lab_pin.sym} 86280 -35190 0 0 {name=p85462 lab=_65916_/A }
C {devices/lab_pin.sym} 86280 -35150 0 0 {name=p85463 lab=_65916_/B }
C {devices/lab_pin.sym} 86280 -35110 0 0 {name=p85464 lab=_65916_/C }
C {devices/lab_pin.sym} 86400 -35150 0 1 {name=p85465 lab=_65916_/X }
C {sky130_stdcells/and3_4.sym} 86340 -35150 0 0 {name=X_65916_ }
C {devices/lab_pin.sym} 86260 -35050 0 0 {name=p85466 lab=_60950_/Y }
C {devices/lab_pin.sym} 86260 -35010 0 0 {name=p85467 lab=_60940_/Y }
C {devices/lab_pin.sym} 86260 -34970 0 0 {name=p85468 lab=_60902_/Y }
C {devices/lab_pin.sym} 86260 -34930 0 0 {name=p85469 lab=_76980_/A }
C {devices/lab_pin.sym} 86260 -34890 0 0 {name=p85470 lab=_61020_/X }
C {devices/lab_pin.sym} 86420 -34970 0 1 {name=p85471 lab=_84532_/D }
C {sky130_stdcells/o32a_4.sym} 86340 -34970 0 0 {name=X_61039_ }
C {devices/lab_pin.sym} 86250 -34810 0 0 {name=p85472 lab=_85718_/CLK }
C {devices/lab_pin.sym} 86250 -34790 0 0 {name=p85473 lab=_59338_/Y }
C {devices/lab_pin.sym} 86430 -34810 0 1 {name=p85474 lab=_84750_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -34800 0 0 {name=X_84750_ }
C {devices/lab_pin.sym} 86250 -34670 0 0 {name=p85475 lab=_82299_/CLK }
C {devices/lab_pin.sym} 86250 -34650 0 0 {name=p85476 lab=_81962_/D }
C {devices/lab_pin.sym} 86430 -34670 0 1 {name=p85477 lab=_81962_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -34660 0 0 {name=X_81962_ }
C {devices/lab_pin.sym} 86260 -34550 0 0 {name=p85478 lab=_83905_/Q }
C {devices/lab_pin.sym} 86260 -34510 0 0 {name=p85479 lab=_69632_/X }
C {devices/lab_pin.sym} 86260 -34470 0 0 {name=p85480 lab=_69683_/X }
C {devices/lab_pin.sym} 86420 -34510 0 1 {name=p85481 lab=_83905_/D }
C {sky130_stdcells/a21bo_4.sym} 86340 -34510 0 0 {name=X_69684_ }
C {devices/lab_pin.sym} 86260 -34390 0 0 {name=p85482 lab=_80916_/D }
C {devices/lab_pin.sym} 86260 -34350 0 0 {name=p85483 lab=_66850_/X }
C {devices/lab_pin.sym} 86260 -34310 0 0 {name=p85484 lab=_66895_/X }
C {devices/lab_pin.sym} 86420 -34350 0 1 {name=p85485 lab=_84092_/D }
C {sky130_stdcells/a21bo_4.sym} 86340 -34350 0 0 {name=X_66896_ }
C {devices/lab_pin.sym} 86250 -34210 0 0 {name=p85486 lab=_83699_/CLK }
C {devices/lab_pin.sym} 86250 -34190 0 0 {name=p85487 lab=_70785_/Y }
C {devices/lab_pin.sym} 86430 -34210 0 1 {name=p85488 lab=_83701_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -34200 0 0 {name=X_83701_ }
C {devices/lab_pin.sym} 86250 -34070 0 0 {name=p85489 lab=_83918_/CLK }
C {devices/lab_pin.sym} 86250 -34050 0 0 {name=p85490 lab=_80913_/D }
C {devices/lab_pin.sym} 86430 -34070 0 1 {name=p85491 lab=_80913_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -34060 0 0 {name=X_80913_ }
C {devices/lab_pin.sym} 86260 -33950 0 0 {name=p85492 lab=_83967_/Q }
C {devices/lab_pin.sym} 86260 -33910 0 0 {name=p85493 lab=_68586_/X }
C {devices/lab_pin.sym} 86260 -33870 0 0 {name=p85494 lab=_68634_/X }
C {devices/lab_pin.sym} 86420 -33910 0 1 {name=p85495 lab=_83967_/D }
C {sky130_stdcells/a21bo_4.sym} 86340 -33910 0 0 {name=X_68635_ }
C {devices/lab_pin.sym} 86260 -33790 0 0 {name=p85496 lab=_85553_/Q }
C {devices/lab_pin.sym} 86260 -33750 0 0 {name=p85497 lab=_53846_/X }
C {devices/lab_pin.sym} 86260 -33710 0 0 {name=p85498 lab=_53860_/Y }
C {devices/lab_pin.sym} 86420 -33750 0 1 {name=p85499 lab=_53861_/Y }
C {sky130_stdcells/o21ai_4.sym} 86340 -33750 0 0 {name=X_53861_ }
C {devices/lab_pin.sym} 86260 -33640 0 0 {name=p85500 lab=_65845_/X }
C {devices/lab_pin.sym} 86260 -33600 0 0 {name=p85501 lab=_86181_/Q }
C {devices/lab_pin.sym} 86260 -33560 0 0 {name=p85502 lab=_65790_/X }
C {devices/lab_pin.sym} 86260 -33520 0 0 {name=p85503 lab=_65846_/X }
C {devices/lab_pin.sym} 86420 -33580 0 1 {name=p85504 lab=_65847_/X }
C {sky130_stdcells/a211o_4.sym} 86340 -33580 0 0 {name=X_65847_ }
C {devices/lab_pin.sym} 86250 -33430 0 0 {name=p85505 lab=_84498_/CLK }
C {devices/lab_pin.sym} 86250 -33410 0 0 {name=p85506 lab=_59956_/X }
C {devices/lab_pin.sym} 86430 -33430 0 1 {name=p85507 lab=_84681_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -33420 0 0 {name=X_84681_ }
C {devices/lab_pin.sym} 86250 -33290 0 0 {name=p85508 lab=_82009_/CLK }
C {devices/lab_pin.sym} 86250 -33270 0 0 {name=p85509 lab=_81893_/D }
C {devices/lab_pin.sym} 86430 -33290 0 1 {name=p85510 lab=_77194_/B }
C {sky130_stdcells/dfxtp_4.sym} 86340 -33280 0 0 {name=X_81893_ }
C {devices/lab_pin.sym} 86260 -33180 0 0 {name=p85511 lab=_45448_/A }
C {devices/lab_pin.sym} 86260 -33140 0 0 {name=p85512 lab=_55617_/A }
C {devices/lab_pin.sym} 86260 -33100 0 0 {name=p85513 lab=_55533_/X }
C {devices/lab_pin.sym} 86260 -33060 0 0 {name=p85514 lab=_55599_/X }
C {devices/lab_pin.sym} 86420 -33120 0 1 {name=p85515 lab=_55601_/B }
C {sky130_stdcells/a211o_4.sym} 86340 -33120 0 0 {name=X_55600_ }
C {devices/lab_pin.sym} 86250 -32970 0 0 {name=p85516 lab=_86422_/CLK }
C {devices/lab_pin.sym} 86250 -32950 0 0 {name=p85517 lab=_49274_/Y }
C {devices/lab_pin.sym} 86430 -32970 0 1 {name=p85518 lab=_86420_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -32960 0 0 {name=X_86420_ }
C {devices/lab_pin.sym} 86260 -32850 0 0 {name=p85519 lab=_52808_/Y }
C {devices/lab_pin.sym} 86260 -32810 0 0 {name=p85520 lab=_52809_/X }
C {devices/lab_pin.sym} 86260 -32770 0 0 {name=p85521 lab=_52811_/X }
C {devices/lab_pin.sym} 86420 -32810 0 1 {name=p85522 lab=_52812_/Y }
C {sky130_stdcells/a21oi_4.sym} 86340 -32810 0 0 {name=X_52812_ }
C {devices/lab_pin.sym} 86250 -32670 0 0 {name=p85523 lab=_83275_/CLK }
C {devices/lab_pin.sym} 86250 -32650 0 0 {name=p85524 lab=_83632_/D }
C {devices/lab_pin.sym} 86430 -32670 0 1 {name=p85525 lab=_47609_/A }
C {sky130_stdcells/dfxtp_4.sym} 86340 -32660 0 0 {name=X_83632_ }
C {devices/lab_pin.sym} 86280 -32540 0 0 {name=p85526 lab=_55504_/Y }
C {devices/lab_pin.sym} 86280 -32500 0 0 {name=p85527 lab=_56580_/B }
C {devices/lab_pin.sym} 86400 -32520 0 1 {name=p85528 lab=_56618_/B }
C {sky130_stdcells/nand2_4.sym} 86340 -32520 0 0 {name=X_56580_ }
C {devices/lab_pin.sym} 86250 -32390 0 0 {name=p85529 lab=_80754_/CLK }
C {devices/lab_pin.sym} 86250 -32370 0 0 {name=p85530 lab=_80876_/Q }
C {devices/lab_pin.sym} 86430 -32390 0 1 {name=p85531 lab=_74912_/B }
C {sky130_stdcells/dfxtp_4.sym} 86340 -32380 0 0 {name=X_80844_ }
C {devices/lab_pin.sym} 86260 -32280 0 0 {name=p85532 lab=_87595_/Q }
C {devices/lab_pin.sym} 86260 -32240 0 0 {name=p85533 lab=_68066_/X }
C {devices/lab_pin.sym} 86260 -32200 0 0 {name=p85534 lab=_68517_/X }
C {devices/lab_pin.sym} 86260 -32160 0 0 {name=p85535 lab=_68565_/X }
C {devices/lab_pin.sym} 86420 -32220 0 1 {name=p85536 lab=_68566_/X }
C {sky130_stdcells/a211o_4.sym} 86340 -32220 0 0 {name=X_68566_ }
C {devices/lab_pin.sym} 86260 -32090 0 0 {name=p85537 lab=_85567_/Q }
C {devices/lab_pin.sym} 86260 -32050 0 0 {name=p85538 lab=_53722_/X }
C {devices/lab_pin.sym} 86260 -32010 0 0 {name=p85539 lab=_53791_/Y }
C {devices/lab_pin.sym} 86420 -32050 0 1 {name=p85540 lab=_53792_/Y }
C {sky130_stdcells/o21ai_4.sym} 86340 -32050 0 0 {name=X_53792_ }
C {devices/lab_pin.sym} 86260 -31940 0 0 {name=p85541 lab=_65623_/X }
C {devices/lab_pin.sym} 86260 -31900 0 0 {name=p85542 lab=_86186_/Q }
C {devices/lab_pin.sym} 86260 -31860 0 0 {name=p85543 lab=_65517_/X }
C {devices/lab_pin.sym} 86260 -31820 0 0 {name=p85544 lab=_65777_/X }
C {devices/lab_pin.sym} 86420 -31880 0 1 {name=p85545 lab=_65778_/X }
C {sky130_stdcells/a211o_4.sym} 86340 -31880 0 0 {name=X_65778_ }
C {devices/lab_pin.sym} 86300 -31730 0 0 {name=p85546 lab=_55505_/X }
C {devices/lab_pin.sym} 86380 -31730 0 1 {name=p85547 lab=_55531_/X }
C {sky130_stdcells/buf_2.sym} 86340 -31730 0 0 {name=X_55531_ }
C {devices/lab_pin.sym} 86280 -31620 0 0 {name=p85548 lab=_67517_/A }
C {devices/lab_pin.sym} 86280 -31580 0 0 {name=p85549 lab=_88236_/Q }
C {devices/lab_pin.sym} 86400 -31600 0 1 {name=p85550 lab=_67517_/X }
C {sky130_stdcells/and2_4.sym} 86340 -31600 0 0 {name=X_67517_ }
C {devices/lab_pin.sym} 86250 -31470 0 0 {name=p85551 lab=_86351_/CLK }
C {devices/lab_pin.sym} 86250 -31450 0 0 {name=p85552 lab=_49637_/Y }
C {devices/lab_pin.sym} 86430 -31470 0 1 {name=p85553 lab=_86351_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -31460 0 0 {name=X_86351_ }
C {devices/lab_pin.sym} 86260 -31350 0 0 {name=p85554 lab=_52740_/Y }
C {devices/lab_pin.sym} 86260 -31310 0 0 {name=p85555 lab=_52728_/X }
C {devices/lab_pin.sym} 86260 -31270 0 0 {name=p85556 lab=_52742_/X }
C {devices/lab_pin.sym} 86420 -31310 0 1 {name=p85557 lab=_85763_/D }
C {sky130_stdcells/a21oi_4.sym} 86340 -31310 0 0 {name=X_52743_ }
C {devices/lab_pin.sym} 86300 -31170 0 0 {name=p85558 lab=_64729_/A }
C {devices/lab_pin.sym} 86380 -31170 0 1 {name=p85559 lab=_64729_/X }
C {sky130_stdcells/buf_2.sym} 86340 -31170 0 0 {name=X_64729_ }
C {devices/lab_pin.sym} 86250 -31050 0 0 {name=p85560 lab=_83623_/CLK }
C {devices/lab_pin.sym} 86250 -31030 0 0 {name=p85561 lab=_71233_/Y }
C {devices/lab_pin.sym} 86430 -31050 0 1 {name=p85562 lab=_48693_/A }
C {sky130_stdcells/dfxtp_4.sym} 86340 -31040 0 0 {name=X_83563_ }
C {devices/lab_pin.sym} 86250 -30910 0 0 {name=p85563 lab=_81059_/CLK }
C {devices/lab_pin.sym} 86250 -30890 0 0 {name=p85564 lab=_80775_/D }
C {devices/lab_pin.sym} 86430 -30910 0 1 {name=p85565 lab=_80775_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -30900 0 0 {name=X_80775_ }
C {devices/lab_pin.sym} 86260 -30790 0 0 {name=p85566 lab=_68492_/X }
C {devices/lab_pin.sym} 86260 -30750 0 0 {name=p85567 lab=_68496_/X }
C {devices/lab_pin.sym} 86260 -30710 0 0 {name=p85568 lab=_68390_/X }
C {devices/lab_pin.sym} 86420 -30750 0 1 {name=p85569 lab=_68497_/X }
C {sky130_stdcells/a21o_4.sym} 86340 -30750 0 0 {name=X_68497_ }
C {devices/lab_pin.sym} 86300 -30610 0 0 {name=p85570 lab=clkbuf_9_403_0_CLK/X }
C {devices/lab_pin.sym} 86380 -30610 0 1 {name=p85571 lab=_82570_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 86340 -30610 0 0 {name=Xclkbuf_10_806_0_CLK }
C {devices/lab_pin.sym} 86250 -30490 0 0 {name=p85572 lab=_85270_/CLK }
C {devices/lab_pin.sym} 86250 -30470 0 0 {name=p85573 lab=_85302_/D }
C {devices/lab_pin.sym} 86430 -30490 0 1 {name=p85574 lab=_55889_/B }
C {sky130_stdcells/dfxtp_4.sym} 86340 -30480 0 0 {name=X_85302_ }
C {devices/lab_pin.sym} 86300 -30350 0 0 {name=p85575 lab=_61985_/A }
C {devices/lab_pin.sym} 86380 -30350 0 1 {name=p85576 lab=_58251_/A }
C {sky130_stdcells/inv_2.sym} 86340 -30350 0 0 {name=X_58250_ }
C {devices/lab_pin.sym} 86250 -30230 0 0 {name=p85577 lab=_82610_/CLK }
C {devices/lab_pin.sym} 86250 -30210 0 0 {name=p85578 lab=_79115_/Y }
C {devices/lab_pin.sym} 86430 -30230 0 1 {name=p85579 lab=_82514_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -30220 0 0 {name=X_82514_ }
C {devices/lab_pin.sym} 86300 -30090 0 0 {name=p85580 lab=_55453_/X }
C {devices/lab_pin.sym} 86380 -30090 0 1 {name=p85581 lab=_55462_/X }
C {sky130_stdcells/buf_2.sym} 86340 -30090 0 0 {name=X_55462_ }
C {devices/lab_pin.sym} 86250 -29970 0 0 {name=p85582 lab=_86282_/CLK }
C {devices/lab_pin.sym} 86250 -29950 0 0 {name=p85583 lab=_86282_/D }
C {devices/lab_pin.sym} 86430 -29970 0 1 {name=p85584 lab=_72400_/B }
C {sky130_stdcells/dfxtp_4.sym} 86340 -29960 0 0 {name=X_86282_ }
C {devices/lab_pin.sym} 86260 -29850 0 0 {name=p85585 lab=_84069_/Q }
C {devices/lab_pin.sym} 86260 -29810 0 0 {name=p85586 lab=_67331_/X }
C {devices/lab_pin.sym} 86260 -29770 0 0 {name=p85587 lab=_67447_/X }
C {devices/lab_pin.sym} 86420 -29810 0 1 {name=p85588 lab=_67448_/X }
C {sky130_stdcells/a21bo_4.sym} 86340 -29810 0 0 {name=X_67448_ }
C {devices/lab_pin.sym} 86300 -29670 0 0 {name=p85589 lab=_52648_/A }
C {devices/lab_pin.sym} 86380 -29670 0 1 {name=p85590 lab=_52674_/X }
C {sky130_stdcells/buf_2.sym} 86340 -29670 0 0 {name=X_52674_ }
C {devices/lab_pin.sym} 86250 -29550 0 0 {name=p85591 lab=_83495_/CLK }
C {devices/lab_pin.sym} 86250 -29530 0 0 {name=p85592 lab=_71453_/X }
C {devices/lab_pin.sym} 86430 -29550 0 1 {name=p85593 lab=_83494_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -29540 0 0 {name=X_83494_ }
C {devices/lab_pin.sym} 86280 -29420 0 0 {name=p85594 lab=_57050_/A }
C {devices/lab_pin.sym} 86280 -29380 0 0 {name=p85595 lab=_44239_/A }
C {devices/lab_pin.sym} 86400 -29400 0 1 {name=p85596 lab=_57201_/Y }
C {sky130_stdcells/nand2_4.sym} 86340 -29400 0 0 {name=X_57201_ }
C {devices/lab_pin.sym} 86250 -29270 0 0 {name=p85597 lab=_87253_/CLK }
C {devices/lab_pin.sym} 86250 -29250 0 0 {name=p85598 lab=_42129_/X }
C {devices/lab_pin.sym} 86430 -29270 0 1 {name=p85599 lab=_88021_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -29260 0 0 {name=X_88021_ }
C {devices/lab_pin.sym} 86280 -29160 0 0 {name=p85600 lab=_54399_/X }
C {devices/lab_pin.sym} 86280 -29120 0 0 {name=p85601 lab=_54417_/B }
C {devices/lab_pin.sym} 86280 -29080 0 0 {name=p85602 lab=_54402_/C }
C {devices/lab_pin.sym} 86280 -29040 0 0 {name=p85603 lab=_46866_/Y }
C {devices/lab_pin.sym} 86400 -29100 0 1 {name=p85604 lab=_54413_/X }
C {sky130_stdcells/and4_4.sym} 86340 -29100 0 0 {name=X_54413_ }
C {devices/lab_pin.sym} 86250 -28950 0 0 {name=p85605 lab=_85167_/CLK }
C {devices/lab_pin.sym} 86250 -28930 0 0 {name=p85606 lab=_85233_/D }
C {devices/lab_pin.sym} 86430 -28950 0 1 {name=p85607 lab=_85233_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -28940 0 0 {name=X_85233_ }
C {devices/lab_pin.sym} 86280 -28840 0 0 {name=p85608 lab=_51619_/A }
C {devices/lab_pin.sym} 86280 -28800 0 0 {name=p85609 lab=_51619_/B }
C {devices/lab_pin.sym} 86280 -28760 0 0 {name=p85610 lab=_51608_/X }
C {devices/lab_pin.sym} 86280 -28720 0 0 {name=p85611 lab=_53151_/D }
C {devices/lab_pin.sym} 86400 -28780 0 1 {name=p85612 lab=_51625_/X }
C {sky130_stdcells/and4_4.sym} 86340 -28780 0 0 {name=X_51625_ }
C {devices/lab_pin.sym} 86300 -28630 0 0 {name=p85613 lab=_83377_/Q }
C {devices/lab_pin.sym} 86380 -28630 0 1 {name=p85614 lab=_58181_/Y }
C {sky130_stdcells/inv_2.sym} 86340 -28630 0 0 {name=X_58181_ }
C {devices/lab_pin.sym} 86250 -28510 0 0 {name=p85615 lab=_82820_/CLK }
C {devices/lab_pin.sym} 86250 -28490 0 0 {name=p85616 lab=_79137_/X }
C {devices/lab_pin.sym} 86430 -28510 0 1 {name=p85617 lab=_82445_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -28500 0 0 {name=X_82445_ }
C {devices/lab_pin.sym} 86280 -28400 0 0 {name=p85618 lab=_55443_/A }
C {devices/lab_pin.sym} 86280 -28360 0 0 {name=p85619 lab=_55393_/B }
C {devices/lab_pin.sym} 86280 -28320 0 0 {name=p85620 lab=_55443_/C }
C {devices/lab_pin.sym} 86280 -28280 0 0 {name=p85621 lab=_55443_/D }
C {devices/lab_pin.sym} 86400 -28340 0 1 {name=p85622 lab=_55394_/B }
C {sky130_stdcells/nand4_4.sym} 86340 -28340 0 0 {name=X_55393_ }
C {devices/lab_pin.sym} 86260 -28220 0 0 {name=p85623 lab=_87921_/Q }
C {devices/lab_pin.sym} 86260 -28180 0 0 {name=p85624 lab=_67355_/X }
C {devices/lab_pin.sym} 86260 -28140 0 0 {name=p85625 lab=_67284_/X }
C {devices/lab_pin.sym} 86260 -28100 0 0 {name=p85626 lab=_67378_/X }
C {devices/lab_pin.sym} 86420 -28160 0 1 {name=p85627 lab=_67379_/X }
C {sky130_stdcells/a211o_4.sym} 86340 -28160 0 0 {name=X_67379_ }
C {devices/lab_pin.sym} 86260 -28050 0 0 {name=p85628 lab=_56739_/X }
C {devices/lab_pin.sym} 86260 -28010 0 0 {name=p85629 lab=_57133_/A }
C {devices/lab_pin.sym} 86260 -27970 0 0 {name=p85630 lab=_57155_/D }
C {devices/lab_pin.sym} 86260 -27930 0 0 {name=p85631 lab=_57170_/B }
C {devices/lab_pin.sym} 86260 -27900 0 0 {name=p85632 lab=_83329_/Q }
C {devices/lab_pin.sym} 86420 -27970 0 1 {name=p85633 lab=_57132_/Y }
C {sky130_stdcells/a41oi_4.sym} 86340 -27970 0 0 {name=X_57132_ }
C {devices/lab_pin.sym} 86280 -27820 0 0 {name=p85634 lab=_69073_/A }
C {devices/lab_pin.sym} 86280 -27780 0 0 {name=p85635 lab=_88340_/Q }
C {devices/lab_pin.sym} 86400 -27800 0 1 {name=p85636 lab=_69118_/X }
C {sky130_stdcells/and2_4.sym} 86340 -27800 0 0 {name=X_69118_ }
C {devices/lab_pin.sym} 86300 -27670 0 0 {name=p85637 lab=_54344_/A }
C {devices/lab_pin.sym} 86380 -27670 0 1 {name=p85638 lab=_54399_/A }
C {sky130_stdcells/buf_2.sym} 86340 -27670 0 0 {name=X_54344_ }
C {devices/lab_pin.sym} 86250 -27550 0 0 {name=p85639 lab=_80671_/CLK }
C {devices/lab_pin.sym} 86250 -27530 0 0 {name=p85640 lab=_85164_/D }
C {devices/lab_pin.sym} 86430 -27550 0 1 {name=p85641 lab=_85164_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -27540 0 0 {name=X_85164_ }
C {devices/lab_pin.sym} 86260 -27430 0 0 {name=p85642 lab=_85988_/Q }
C {devices/lab_pin.sym} 86260 -27390 0 0 {name=p85643 lab=_51539_/X }
C {devices/lab_pin.sym} 86260 -27350 0 0 {name=p85644 lab=_51555_/Y }
C {devices/lab_pin.sym} 86420 -27390 0 1 {name=p85645 lab=_51556_/Y }
C {sky130_stdcells/o21ai_4.sym} 86340 -27390 0 0 {name=X_51556_ }
C {devices/lab_pin.sym} 86260 -27270 0 0 {name=p85646 lab=_51378_/B }
C {devices/lab_pin.sym} 86260 -27230 0 0 {name=p85647 lab=_70364_/X }
C {devices/lab_pin.sym} 86260 -27190 0 0 {name=p85648 lab=_70389_/Y }
C {devices/lab_pin.sym} 86420 -27230 0 1 {name=p85649 lab=_70390_/Y }
C {sky130_stdcells/o21ai_4.sym} 86340 -27230 0 0 {name=X_70390_ }
C {devices/lab_pin.sym} 86250 -27090 0 0 {name=p85650 lab=_86054_/CLK }
C {devices/lab_pin.sym} 86250 -27070 0 0 {name=p85651 lab=_82184_/Q }
C {devices/lab_pin.sym} 86430 -27090 0 1 {name=p85652 lab=_82376_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -27080 0 0 {name=X_82376_ }
C {devices/lab_pin.sym} 86250 -26950 0 0 {name=p85653 lab=_84115_/CLK }
C {devices/lab_pin.sym} 86250 -26930 0 0 {name=p85654 lab=_66480_/X }
C {devices/lab_pin.sym} 86430 -26950 0 1 {name=p85655 lab=_84115_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -26940 0 0 {name=X_84115_ }
C {devices/lab_pin.sym} 86300 -26810 0 0 {name=p85656 lab=_50534_/A }
C {devices/lab_pin.sym} 86380 -26810 0 1 {name=p85657 lab=_50513_/A }
C {sky130_stdcells/buf_2.sym} 86340 -26810 0 0 {name=X_50507_ }
C {devices/lab_pin.sym} 86250 -26690 0 0 {name=p85658 lab=_81333_/CLK }
C {devices/lab_pin.sym} 86250 -26670 0 0 {name=p85659 lab=_76343_/X }
C {devices/lab_pin.sym} 86430 -26690 0 1 {name=p85660 lab=_75957_/A }
C {sky130_stdcells/dfxtp_4.sym} 86340 -26680 0 0 {name=X_81327_ }
C {devices/lab_pin.sym} 86260 -26570 0 0 {name=p85661 lab=_58517_/A }
C {devices/lab_pin.sym} 86260 -26530 0 0 {name=p85662 lab=_45808_/Y }
C {devices/lab_pin.sym} 86260 -26490 0 0 {name=p85663 lab=_57062_/Y }
C {devices/lab_pin.sym} 86420 -26530 0 1 {name=p85664 lab=_57063_/Y }
C {sky130_stdcells/o21ai_4.sym} 86340 -26530 0 0 {name=X_57063_ }
C {devices/lab_pin.sym} 86260 -26420 0 0 {name=p85665 lab=_87075_/Q }
C {devices/lab_pin.sym} 86260 -26380 0 0 {name=p85666 lab=_68818_/X }
C {devices/lab_pin.sym} 86260 -26340 0 0 {name=p85667 lab=_68819_/X }
C {devices/lab_pin.sym} 86260 -26300 0 0 {name=p85668 lab=_69048_/X }
C {devices/lab_pin.sym} 86420 -26360 0 1 {name=p85669 lab=_69049_/X }
C {sky130_stdcells/a211o_4.sym} 86340 -26360 0 0 {name=X_69049_ }
C {devices/lab_pin.sym} 86280 -26240 0 0 {name=p85670 lab=_54286_/A }
C {devices/lab_pin.sym} 86280 -26200 0 0 {name=p85671 lab=_54298_/B }
C {devices/lab_pin.sym} 86280 -26160 0 0 {name=p85672 lab=_54286_/C }
C {devices/lab_pin.sym} 86280 -26120 0 0 {name=p85673 lab=_54275_/D }
C {devices/lab_pin.sym} 86400 -26180 0 1 {name=p85674 lab=_54275_/X }
C {sky130_stdcells/and4_4.sym} 86340 -26180 0 0 {name=X_54275_ }
C {devices/lab_pin.sym} 86250 -26030 0 0 {name=p85675 lab=_85128_/CLK }
C {devices/lab_pin.sym} 86250 -26010 0 0 {name=p85676 lab=_57060_/X }
C {devices/lab_pin.sym} 86430 -26030 0 1 {name=p85677 lab=_57058_/B }
C {sky130_stdcells/dfxtp_4.sym} 86340 -26020 0 0 {name=X_85095_ }
C {devices/lab_pin.sym} 86280 -25900 0 0 {name=p85678 lab=_51491_/A }
C {devices/lab_pin.sym} 86280 -25860 0 0 {name=p85679 lab=_53012_/B }
C {devices/lab_pin.sym} 86400 -25880 0 1 {name=p85680 lab=_51487_/Y }
C {sky130_stdcells/nand2_4.sym} 86340 -25880 0 0 {name=X_51487_ }
C {devices/lab_pin.sym} 86280 -25780 0 0 {name=p85681 lab=_56013_/Y }
C {devices/lab_pin.sym} 86280 -25740 0 0 {name=p85682 lab=_74297_/C }
C {devices/lab_pin.sym} 86280 -25700 0 0 {name=p85683 lab=_56003_/B }
C {devices/lab_pin.sym} 86280 -25660 0 0 {name=p85684 lab=_55966_/X }
C {devices/lab_pin.sym} 86400 -25720 0 1 {name=p85685 lab=_56015_/B }
C {sky130_stdcells/nand4_4.sym} 86340 -25720 0 0 {name=X_56014_ }
C {devices/lab_pin.sym} 86300 -25570 0 0 {name=p85686 lab=_40637_/A }
C {devices/lab_pin.sym} 86380 -25570 0 1 {name=p85687 lab=_41490_/A }
C {sky130_stdcells/buf_2.sym} 86340 -25570 0 0 {name=X_41240_ }
C {devices/lab_pin.sym} 86300 -25450 0 0 {name=p85688 lab=_53199_/A }
C {devices/lab_pin.sym} 86380 -25450 0 1 {name=p85689 lab=_53246_/A }
C {sky130_stdcells/buf_2.sym} 86340 -25450 0 0 {name=X_53226_ }
C {devices/lab_pin.sym} 86280 -25350 0 0 {name=p85690 lab=_49089_/A }
C {devices/lab_pin.sym} 86280 -25310 0 0 {name=p85691 lab=_72043_/X }
C {devices/lab_pin.sym} 86280 -25270 0 0 {name=p85692 lab=_72048_/X }
C {devices/lab_pin.sym} 86400 -25310 0 1 {name=p85693 lab=_72060_/X }
C {sky130_stdcells/and3_4.sym} 86340 -25310 0 0 {name=X_72060_ }
C {devices/lab_pin.sym} 86250 -25170 0 0 {name=p85694 lab=_88116_/CLK }
C {devices/lab_pin.sym} 86250 -25150 0 0 {name=p85695 lab=_67996_/X }
C {devices/lab_pin.sym} 86430 -25170 0 1 {name=p85696 lab=_81478_/D }
C {sky130_stdcells/dfxtp_4.sym} 86340 -25160 0 0 {name=X_84046_ }
C {devices/lab_pin.sym} 86300 -25030 0 0 {name=p85697 lab=_50655_/A }
C {devices/lab_pin.sym} 86380 -25030 0 1 {name=p85698 lab=_50534_/A }
C {sky130_stdcells/buf_2.sym} 86340 -25030 0 0 {name=X_50438_ }
C {devices/lab_pin.sym} 86250 -24910 0 0 {name=p85699 lab=_81275_/CLK }
C {devices/lab_pin.sym} 86250 -24890 0 0 {name=p85700 lab=_81258_/D }
C {devices/lab_pin.sym} 86430 -24910 0 1 {name=p85701 lab=_81258_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -24900 0 0 {name=X_81258_ }
C {devices/lab_pin.sym} 86280 -24800 0 0 {name=p85702 lab=_70886_/A }
C {devices/lab_pin.sym} 86280 -24760 0 0 {name=p85703 lab=_71010_/X }
C {devices/lab_pin.sym} 86280 -24720 0 0 {name=p85704 lab=_70735_/X }
C {devices/lab_pin.sym} 86280 -24680 0 0 {name=p85705 lab=_70758_/C }
C {devices/lab_pin.sym} 86400 -24740 0 1 {name=p85706 lab=_71012_/B }
C {sky130_stdcells/nand4_4.sym} 86340 -24740 0 0 {name=X_71011_ }
C {devices/lab_pin.sym} 86280 -24600 0 0 {name=p85707 lab=_80209_/A }
C {devices/lab_pin.sym} 86280 -24560 0 0 {name=p85708 lab=_80209_/B }
C {devices/lab_pin.sym} 86400 -24580 0 1 {name=p85709 lab=_80209_/X }
C {sky130_stdcells/or2_4.sym} 86340 -24580 0 0 {name=X_80209_ }
C {devices/lab_pin.sym} 86300 -24450 0 0 {name=p85710 lab=_41013_/A }
C {devices/lab_pin.sym} 86380 -24450 0 1 {name=p85711 lab=_41223_/B }
C {sky130_stdcells/buf_2.sym} 86340 -24450 0 0 {name=X_41171_ }
C {devices/lab_pin.sym} 86280 -24340 0 0 {name=p85712 lab=_53147_/X }
C {devices/lab_pin.sym} 86280 -24300 0 0 {name=p85713 lab=_53157_/B }
C {devices/lab_pin.sym} 86400 -24320 0 1 {name=p85714 lab=_53157_/Y }
C {sky130_stdcells/nand2_4.sym} 86340 -24320 0 0 {name=X_53157_ }
C {devices/lab_pin.sym} 86260 -24210 0 0 {name=p85715 lab=_50366_/Y }
C {devices/lab_pin.sym} 86260 -24170 0 0 {name=p85716 lab=_50351_/X }
C {devices/lab_pin.sym} 86260 -24130 0 0 {name=p85717 lab=_50368_/Y }
C {devices/lab_pin.sym} 86420 -24170 0 1 {name=p85718 lab=_50369_/Y }
C {sky130_stdcells/a21boi_4.sym} 86340 -24170 0 0 {name=X_50369_ }
C {devices/lab_pin.sym} 86250 -24030 0 0 {name=p85719 lab=_81190_/CLK }
C {devices/lab_pin.sym} 86250 -24010 0 0 {name=p85720 lab=_81189_/D }
C {devices/lab_pin.sym} 86430 -24030 0 1 {name=p85721 lab=_81189_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -24020 0 0 {name=X_81189_ }
C {devices/lab_pin.sym} 86300 -23890 0 0 {name=p85722 lab=_52203_/A }
C {devices/lab_pin.sym} 86380 -23890 0 1 {name=p85723 lab=_52108_/X }
C {sky130_stdcells/buf_2.sym} 86340 -23890 0 0 {name=X_52108_ }
C {devices/lab_pin.sym} 86250 -23770 0 0 {name=p85724 lab=_87553_/CLK }
C {devices/lab_pin.sym} 86250 -23750 0 0 {name=p85725 lab=_42603_/Y }
C {devices/lab_pin.sym} 86430 -23770 0 1 {name=p85726 lab=_69859_/A }
C {sky130_stdcells/dfxtp_4.sym} 86340 -23760 0 0 {name=X_87805_ }
C {devices/lab_pin.sym} 86300 -23630 0 0 {name=p85727 lab=_57965_/A }
C {devices/lab_pin.sym} 86380 -23630 0 1 {name=p85728 lab=_58813_/A }
C {sky130_stdcells/buf_2.sym} 86340 -23630 0 0 {name=X_57965_ }
C {devices/lab_pin.sym} 86300 -23510 0 0 {name=p85729 lab=_53221_/A }
C {devices/lab_pin.sym} 86380 -23510 0 1 {name=p85730 lab=_53195_/A }
C {sky130_stdcells/buf_2.sym} 86340 -23510 0 0 {name=X_53088_ }
C {devices/lab_pin.sym} 86250 -23390 0 0 {name=p85731 lab=_85709_/CLK }
C {devices/lab_pin.sym} 86250 -23370 0 0 {name=p85732 lab=_85997_/D }
C {devices/lab_pin.sym} 86430 -23390 0 1 {name=p85733 lab=_85997_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -23380 0 0 {name=X_85997_ }
C {devices/lab_pin.sym} 86260 -23270 0 0 {name=p85734 lab=_59649_/A }
C {devices/lab_pin.sym} 86260 -23230 0 0 {name=p85735 lab=_59628_/A }
C {devices/lab_pin.sym} 86260 -23190 0 0 {name=p85736 lab=_59648_/A }
C {devices/lab_pin.sym} 86420 -23230 0 1 {name=p85737 lab=_59790_/B }
C {sky130_stdcells/a21o_4.sym} 86340 -23230 0 0 {name=X_59704_ }
C {devices/lab_pin.sym} 86260 -23110 0 0 {name=p85738 lab=_56381_/C }
C {devices/lab_pin.sym} 86260 -23070 0 0 {name=p85739 lab=_44880_/X }
C {devices/lab_pin.sym} 86260 -23030 0 0 {name=p85740 lab=_44929_/X }
C {devices/lab_pin.sym} 86420 -23070 0 1 {name=p85741 lab=_44930_/Y }
C {sky130_stdcells/o21ai_4.sym} 86340 -23070 0 0 {name=X_44930_ }
C {devices/lab_pin.sym} 86280 -22950 0 0 {name=p85742 lab=_52039_/A }
C {devices/lab_pin.sym} 86280 -22910 0 0 {name=p85743 lab=_52098_/B }
C {devices/lab_pin.sym} 86280 -22870 0 0 {name=p85744 lab=_52033_/X }
C {devices/lab_pin.sym} 86400 -22910 0 1 {name=p85745 lab=_52039_/X }
C {sky130_stdcells/and3_4.sym} 86340 -22910 0 0 {name=X_52039_ }
C {devices/lab_pin.sym} 86280 -22780 0 0 {name=p85746 lab=_56910_/X }
C {devices/lab_pin.sym} 86280 -22740 0 0 {name=p85747 lab=_56915_/Y }
C {devices/lab_pin.sym} 86400 -22760 0 1 {name=p85748 lab=_56917_/A }
C {sky130_stdcells/nand2_4.sym} 86340 -22760 0 0 {name=X_56916_ }
C {devices/lab_pin.sym} 86280 -22640 0 0 {name=p85749 lab=_81094_/Q }
C {devices/lab_pin.sym} 86280 -22600 0 0 {name=p85750 lab=_75750_/B }
C {devices/lab_pin.sym} 86400 -22620 0 1 {name=p85751 lab=_75750_/Y }
C {sky130_stdcells/xnor2_4.sym} 86340 -22620 0 0 {name=X_75750_ }
C {devices/lab_pin.sym} 86250 -22490 0 0 {name=p85752 lab=_87993_/CLK }
C {devices/lab_pin.sym} 86250 -22470 0 0 {name=p85753 lab=_87736_/D }
C {devices/lab_pin.sym} 86430 -22490 0 1 {name=p85754 lab=_69031_/B }
C {sky130_stdcells/dfxtp_4.sym} 86340 -22480 0 0 {name=X_87736_ }
C {devices/lab_pin.sym} 86260 -22370 0 0 {name=p85755 lab=_72958_/X }
C {devices/lab_pin.sym} 86260 -22330 0 0 {name=p85756 lab=_72961_/X }
C {devices/lab_pin.sym} 86260 -22290 0 0 {name=p85757 lab=_72812_/X }
C {devices/lab_pin.sym} 86420 -22330 0 1 {name=p85758 lab=_72966_/A }
C {sky130_stdcells/a21o_4.sym} 86340 -22330 0 0 {name=X_72962_ }
C {devices/lab_pin.sym} 86250 -22190 0 0 {name=p85759 lab=_85404_/CLK }
C {devices/lab_pin.sym} 86250 -22170 0 0 {name=p85760 lab=_84948_/D }
C {devices/lab_pin.sym} 86430 -22190 0 1 {name=p85761 lab=_84948_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -22180 0 0 {name=X_84948_ }
C {devices/lab_pin.sym} 86300 -22050 0 0 {name=p85762 lab=_57896_/A }
C {devices/lab_pin.sym} 86380 -22050 0 1 {name=p85763 lab=_57896_/X }
C {sky130_stdcells/buf_2.sym} 86340 -22050 0 0 {name=X_57896_ }
C {devices/lab_pin.sym} 86260 -21950 0 0 {name=p85764 lab=_74630_/X }
C {devices/lab_pin.sym} 86260 -21910 0 0 {name=p85765 lab=_56903_/X }
C {devices/lab_pin.sym} 86260 -21870 0 0 {name=p85766 lab=_74700_/Y }
C {devices/lab_pin.sym} 86420 -21910 0 1 {name=p85767 lab=_82980_/D }
C {sky130_stdcells/o21a_4.sym} 86340 -21910 0 0 {name=X_74701_ }
C {devices/lab_pin.sym} 86300 -21770 0 0 {name=p85768 lab=_70554_/A }
C {devices/lab_pin.sym} 86380 -21770 0 1 {name=p85769 lab=_71930_/B }
C {sky130_stdcells/buf_2.sym} 86340 -21770 0 0 {name=X_71913_ }
C {devices/lab_pin.sym} 86300 -21650 0 0 {name=p85770 lab=_59624_/X }
C {devices/lab_pin.sym} 86380 -21650 0 1 {name=p85771 lab=_59635_/Y }
C {sky130_stdcells/inv_2.sym} 86340 -21650 0 0 {name=X_59635_ }
C {devices/lab_pin.sym} 86260 -21560 0 0 {name=p85772 lab=_41777_/Y }
C {devices/lab_pin.sym} 86260 -21520 0 0 {name=p85773 lab=_44848_/X }
C {devices/lab_pin.sym} 86260 -21480 0 0 {name=p85774 lab=_86915_/Q }
C {devices/lab_pin.sym} 86260 -21440 0 0 {name=p85775 lab=_44849_/X }
C {devices/lab_pin.sym} 86420 -21500 0 1 {name=p85776 lab=_44861_/X }
C {sky130_stdcells/a2bb2o_4.sym} 86340 -21500 0 0 {name=X_44861_ }
C {devices/lab_pin.sym} 86300 -21350 0 0 {name=p85777 lab=_56846_/Y }
C {devices/lab_pin.sym} 86380 -21350 0 1 {name=p85778 lab=_57050_/A }
C {sky130_stdcells/buf_2.sym} 86340 -21350 0 0 {name=X_56847_ }
C {devices/lab_pin.sym} 86250 -21230 0 0 {name=p85779 lab=_87671_/CLK }
C {devices/lab_pin.sym} 86250 -21210 0 0 {name=p85780 lab=_42890_/Y }
C {devices/lab_pin.sym} 86430 -21230 0 1 {name=p85781 lab=_87667_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -21220 0 0 {name=X_87667_ }
C {devices/lab_pin.sym} 86300 -21090 0 0 {name=p85782 lab=_75669_/Y }
C {devices/lab_pin.sym} 86380 -21090 0 1 {name=p85783 lab=_80781_/D }
C {sky130_stdcells/inv_2.sym} 86340 -21090 0 0 {name=X_75681_ }
C {devices/lab_pin.sym} 86260 -21000 0 0 {name=p85784 lab=_41994_/Y }
C {devices/lab_pin.sym} 86260 -20960 0 0 {name=p85785 lab=_72888_/X }
C {devices/lab_pin.sym} 86260 -20920 0 0 {name=p85786 lab=_72890_/X }
C {devices/lab_pin.sym} 86260 -20880 0 0 {name=p85787 lab=_72892_/Y }
C {devices/lab_pin.sym} 86420 -20940 0 1 {name=p85788 lab=_72893_/X }
C {sky130_stdcells/a211o_4.sym} 86340 -20940 0 0 {name=X_72893_ }
C {devices/lab_pin.sym} 86250 -20790 0 0 {name=p85789 lab=_84849_/CLK }
C {devices/lab_pin.sym} 86250 -20770 0 0 {name=p85790 lab=_84879_/D }
C {devices/lab_pin.sym} 86430 -20790 0 1 {name=p85791 lab=_58319_/A }
C {sky130_stdcells/dfxtp_4.sym} 86340 -20780 0 0 {name=X_84879_ }
C {devices/lab_pin.sym} 86280 -20660 0 0 {name=p85792 lab=_46505_/A }
C {devices/lab_pin.sym} 86280 -20620 0 0 {name=p85793 lab=_46600_/B }
C {devices/lab_pin.sym} 86400 -20640 0 1 {name=p85794 lab=_46600_/Y }
C {sky130_stdcells/nand2_4.sym} 86340 -20640 0 0 {name=X_46600_ }
C {devices/lab_pin.sym} 86280 -20520 0 0 {name=p85795 lab=_77416_/X }
C {devices/lab_pin.sym} 86280 -20480 0 0 {name=p85796 lab=_77419_/Y }
C {devices/lab_pin.sym} 86400 -20500 0 1 {name=p85797 lab=_82191_/D }
C {sky130_stdcells/xor2_4.sym} 86340 -20500 0 0 {name=X_77420_ }
C {devices/lab_pin.sym} 86260 -20410 0 0 {name=p85798 lab=_43810_/X }
C {devices/lab_pin.sym} 86260 -20370 0 0 {name=p85799 lab=_43797_/X }
C {devices/lab_pin.sym} 86260 -20330 0 0 {name=p85800 lab=_41087_/X }
C {devices/lab_pin.sym} 86260 -20290 0 0 {name=p85801 lab=_69509_/B }
C {devices/lab_pin.sym} 86260 -20250 0 0 {name=p85802 lab=_43811_/X }
C {devices/lab_pin.sym} 86420 -20330 0 1 {name=p85803 lab=_43813_/A }
C {sky130_stdcells/o32ai_4.sym} 86340 -20330 0 0 {name=X_43812_ }
C {devices/lab_pin.sym} 86300 -20170 0 0 {name=p85804 lab=_74675_/A }
C {devices/lab_pin.sym} 86380 -20170 0 1 {name=p85805 lab=_74691_/A }
C {sky130_stdcells/buf_2.sym} 86340 -20170 0 0 {name=X_74632_ }
C {devices/lab_pin.sym} 86250 -20050 0 0 {name=p85806 lab=_85981_/CLK }
C {devices/lab_pin.sym} 86250 -20030 0 0 {name=p85807 lab=_86618_/D }
C {devices/lab_pin.sym} 86430 -20050 0 1 {name=p85808 lab=_86618_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -20040 0 0 {name=X_86618_ }
C {devices/lab_pin.sym} 86260 -19930 0 0 {name=p85809 lab=_47575_/Y }
C {devices/lab_pin.sym} 86260 -19890 0 0 {name=p85810 lab=_47555_/X }
C {devices/lab_pin.sym} 86260 -19850 0 0 {name=p85811 lab=_47579_/X }
C {devices/lab_pin.sym} 86420 -19890 0 1 {name=p85812 lab=_47580_/Y }
C {sky130_stdcells/a21oi_4.sym} 86340 -19890 0 0 {name=X_47580_ }
C {devices/lab_pin.sym} 86260 -19770 0 0 {name=p85813 lab=_71824_/Y }
C {devices/lab_pin.sym} 86260 -19730 0 0 {name=p85814 lab=_83354_/Q }
C {devices/lab_pin.sym} 86260 -19690 0 0 {name=p85815 lab=_71843_/X }
C {devices/lab_pin.sym} 86420 -19730 0 1 {name=p85816 lab=_71844_/X }
C {sky130_stdcells/a21o_4.sym} 86340 -19730 0 0 {name=X_71844_ }
C {devices/lab_pin.sym} 86280 -19620 0 0 {name=p85817 lab=_59751_/A }
C {devices/lab_pin.sym} 86280 -19580 0 0 {name=p85818 lab=_60122_/A }
C {devices/lab_pin.sym} 86280 -19540 0 0 {name=p85819 lab=_59752_/A }
C {devices/lab_pin.sym} 86280 -19500 0 0 {name=p85820 lab=_60122_/C }
C {devices/lab_pin.sym} 86400 -19560 0 1 {name=p85821 lab=_60380_/B }
C {sky130_stdcells/and4_4.sym} 86340 -19560 0 0 {name=X_59566_ }
C {devices/lab_pin.sym} 86300 -19410 0 0 {name=p85822 lab=_44791_/Y }
C {devices/lab_pin.sym} 86380 -19410 0 1 {name=p85823 lab=_86953_/D }
C {sky130_stdcells/inv_2.sym} 86340 -19410 0 0 {name=X_44792_ }
C {devices/lab_pin.sym} 86260 -19310 0 0 {name=p85824 lab=_72765_/A }
C {devices/lab_pin.sym} 86260 -19270 0 0 {name=p85825 lab=_56776_/X }
C {devices/lab_pin.sym} 86260 -19230 0 0 {name=p85826 lab=_56777_/Y }
C {devices/lab_pin.sym} 86420 -19270 0 1 {name=p85827 lab=_56778_/Y }
C {sky130_stdcells/a21boi_4.sym} 86340 -19270 0 0 {name=X_56778_ }
C {devices/lab_pin.sym} 86250 -19130 0 0 {name=p85828 lab=_88111_/CLK }
C {devices/lab_pin.sym} 86250 -19110 0 0 {name=p85829 lab=_87598_/D }
C {devices/lab_pin.sym} 86430 -19130 0 1 {name=p85830 lab=_73677_/A }
C {sky130_stdcells/dfxtp_4.sym} 86340 -19120 0 0 {name=X_87598_ }
C {devices/lab_pin.sym} 86280 -19000 0 0 {name=p85831 lab=_46531_/A }
C {devices/lab_pin.sym} 86280 -18960 0 0 {name=p85832 lab=_50850_/B }
C {devices/lab_pin.sym} 86400 -18980 0 1 {name=p85833 lab=_46531_/Y }
C {sky130_stdcells/nand2_4.sym} 86340 -18980 0 0 {name=X_46531_ }
C {devices/lab_pin.sym} 86300 -18850 0 0 {name=p85834 lab=_58517_/A }
C {devices/lab_pin.sym} 86380 -18850 0 1 {name=p85835 lab=_58517_/X }
C {sky130_stdcells/buf_2.sym} 86340 -18850 0 0 {name=X_58517_ }
C {devices/lab_pin.sym} 86280 -18740 0 0 {name=p85836 lab=_77371_/C }
C {devices/lab_pin.sym} 86280 -18700 0 0 {name=p85837 lab=_77351_/B }
C {devices/lab_pin.sym} 86400 -18720 0 1 {name=p85838 lab=_82186_/D }
C {sky130_stdcells/xnor2_4.sym} 86340 -18720 0 0 {name=X_77351_ }
C {devices/lab_pin.sym} 86260 -18610 0 0 {name=p85839 lab=_55711_/X }
C {devices/lab_pin.sym} 86260 -18570 0 0 {name=p85840 lab=_85285_/Q }
C {devices/lab_pin.sym} 86260 -18530 0 0 {name=p85841 lab=_55172_/A }
C {devices/lab_pin.sym} 86420 -18570 0 1 {name=p85842 lab=_55729_/Y }
C {sky130_stdcells/a21oi_4.sym} 86340 -18570 0 0 {name=X_55729_ }
C {devices/lab_pin.sym} 86300 -18430 0 0 {name=p85843 lab=_43743_/A }
C {devices/lab_pin.sym} 86380 -18430 0 1 {name=p85844 lab=_87288_/D }
C {sky130_stdcells/inv_2.sym} 86340 -18430 0 0 {name=X_43743_ }
C {devices/lab_pin.sym} 86260 -18330 0 0 {name=p85845 lab=_45020_/A }
C {devices/lab_pin.sym} 86260 -18290 0 0 {name=p85846 lab=_74551_/X }
C {devices/lab_pin.sym} 86260 -18250 0 0 {name=p85847 lab=_74562_/X }
C {devices/lab_pin.sym} 86420 -18290 0 1 {name=p85848 lab=_74563_/Y }
C {sky130_stdcells/o21ai_4.sym} 86340 -18290 0 0 {name=X_74563_ }
C {devices/lab_pin.sym} 86250 -18150 0 0 {name=p85849 lab=_86549_/CLK }
C {devices/lab_pin.sym} 86250 -18130 0 0 {name=p85850 lab=_86549_/D }
C {devices/lab_pin.sym} 86430 -18150 0 1 {name=p85851 lab=_66087_/B }
C {sky130_stdcells/dfxtp_4.sym} 86340 -18140 0 0 {name=X_86549_ }
C {devices/lab_pin.sym} 86300 -18010 0 0 {name=p85852 lab=_40954_/Y }
C {devices/lab_pin.sym} 86380 -18010 0 1 {name=p85853 lab=_40955_/X }
C {sky130_stdcells/buf_2.sym} 86340 -18010 0 0 {name=X_40955_ }
C {devices/lab_pin.sym} 86280 -17910 0 0 {name=p85854 lab=_71779_/A }
C {devices/lab_pin.sym} 86280 -17870 0 0 {name=p85855 lab=_71333_/C }
C {devices/lab_pin.sym} 86280 -17830 0 0 {name=p85856 lab=_70986_/A }
C {devices/lab_pin.sym} 86400 -17870 0 1 {name=p85857 lab=_71775_/X }
C {sky130_stdcells/and3_4.sym} 86340 -17870 0 0 {name=X_71775_ }
C {devices/lab_pin.sym} 86300 -17730 0 0 {name=p85858 lab=_83428_/Q }
C {devices/lab_pin.sym} 86380 -17730 0 1 {name=p85859 lab=_59497_/Y }
C {sky130_stdcells/inv_2.sym} 86340 -17730 0 0 {name=X_59497_ }
C {devices/lab_pin.sym} 86280 -17620 0 0 {name=p85860 lab=_76301_/A }
C {devices/lab_pin.sym} 86280 -17580 0 0 {name=p85861 lab=_81561_/Q }
C {devices/lab_pin.sym} 86400 -17600 0 1 {name=p85862 lab=_76302_/Y }
C {sky130_stdcells/nand2_4.sym} 86340 -17600 0 0 {name=X_76302_ }
C {devices/lab_pin.sym} 86260 -17490 0 0 {name=p85863 lab=_49246_/Y }
C {devices/lab_pin.sym} 86260 -17450 0 0 {name=p85864 lab=_49247_/X }
C {devices/lab_pin.sym} 86260 -17410 0 0 {name=p85865 lab=_49249_/Y }
C {devices/lab_pin.sym} 86420 -17450 0 1 {name=p85866 lab=_86425_/D }
C {sky130_stdcells/a21boi_4.sym} 86340 -17450 0 0 {name=X_49250_ }
C {devices/lab_pin.sym} 86280 -17320 0 0 {name=p85867 lab=_73353_/A }
C {devices/lab_pin.sym} 86280 -17280 0 0 {name=p85868 lab=_85859_/Q }
C {devices/lab_pin.sym} 86400 -17300 0 1 {name=p85869 lab=_73514_/X }
C {sky130_stdcells/and2_4.sym} 86340 -17300 0 0 {name=X_73514_ }
C {devices/lab_pin.sym} 86280 -17180 0 0 {name=p85870 lab=_46408_/A }
C {devices/lab_pin.sym} 86280 -17140 0 0 {name=p85871 lab=_50816_/B }
C {devices/lab_pin.sym} 86400 -17160 0 1 {name=p85872 lab=_46462_/Y }
C {sky130_stdcells/nand2_4.sym} 86340 -17160 0 0 {name=X_46462_ }
C {devices/lab_pin.sym} 86300 -17030 0 0 {name=p85873 lab=_70848_/A }
C {devices/lab_pin.sym} 86380 -17030 0 1 {name=p85874 lab=_70779_/B }
C {sky130_stdcells/buf_2.sym} 86340 -17030 0 0 {name=X_70726_ }
C {devices/lab_pin.sym} 86300 -16910 0 0 {name=p85875 lab=_58423_/A }
C {devices/lab_pin.sym} 86380 -16910 0 1 {name=p85876 lab=_58448_/X }
C {sky130_stdcells/buf_2.sym} 86340 -16910 0 0 {name=X_58448_ }
C {devices/lab_pin.sym} 86260 -16810 0 0 {name=p85877 lab=_77264_/Y }
C {devices/lab_pin.sym} 86260 -16770 0 0 {name=p85878 lab=_82213_/Q }
C {devices/lab_pin.sym} 86260 -16730 0 0 {name=p85879 lab=_77265_/Y }
C {devices/lab_pin.sym} 86420 -16770 0 1 {name=p85880 lab=_77282_/Y }
C {sky130_stdcells/a21boi_4.sym} 86340 -16770 0 0 {name=X_77282_ }
C {devices/lab_pin.sym} 86260 -16660 0 0 {name=p85881 lab=_40753_/X }
C {devices/lab_pin.sym} 86260 -16620 0 0 {name=p85882 lab=_43671_/X }
C {devices/lab_pin.sym} 86260 -16580 0 0 {name=p85883 lab=_87317_/Q }
C {devices/lab_pin.sym} 86260 -16540 0 0 {name=p85884 lab=_43673_/X }
C {devices/lab_pin.sym} 86420 -16600 0 1 {name=p85885 lab=_87317_/D }
C {sky130_stdcells/a2bb2o_4.sym} 86340 -16600 0 0 {name=X_43674_ }
C {devices/lab_pin.sym} 86260 -16470 0 0 {name=p85886 lab=_74491_/Y }
C {devices/lab_pin.sym} 86260 -16430 0 0 {name=p85887 lab=_74492_/X }
C {devices/lab_pin.sym} 86260 -16390 0 0 {name=p85888 lab=_74493_/X }
C {devices/lab_pin.sym} 86420 -16430 0 1 {name=p85889 lab=_83055_/D }
C {sky130_stdcells/a21oi_4.sym} 86340 -16430 0 0 {name=X_74494_ }
C {devices/lab_pin.sym} 86260 -16330 0 0 {name=p85890 lab=_40870_/X }
C {devices/lab_pin.sym} 86260 -16290 0 0 {name=p85891 lab=_40871_/X }
C {devices/lab_pin.sym} 86260 -16250 0 0 {name=p85892 lab=_40885_/X }
C {devices/lab_pin.sym} 86260 -16210 0 0 {name=p85893 lab=_69865_/B }
C {devices/lab_pin.sym} 86260 -16170 0 0 {name=p85894 lab=_40867_/X }
C {devices/lab_pin.sym} 86420 -16250 0 1 {name=p85895 lab=_40887_/A }
C {sky130_stdcells/o32ai_4.sym} 86340 -16250 0 0 {name=X_40886_ }
C {devices/lab_pin.sym} 86280 -16110 0 0 {name=p85896 lab=_47886_/X }
C {devices/lab_pin.sym} 86280 -16070 0 0 {name=p85897 lab=_48201_/B }
C {devices/lab_pin.sym} 86280 -16030 0 0 {name=p85898 lab=_48195_/X }
C {devices/lab_pin.sym} 86400 -16070 0 1 {name=p85899 lab=_48201_/X }
C {sky130_stdcells/and3_4.sym} 86340 -16070 0 0 {name=X_48201_ }
C {devices/lab_pin.sym} 86280 -15940 0 0 {name=p85900 lab=_79021_/A }
C {devices/lab_pin.sym} 86280 -15900 0 0 {name=p85901 lab=_79021_/B }
C {devices/lab_pin.sym} 86400 -15920 0 1 {name=p85902 lab=_79027_/A }
C {sky130_stdcells/xor2_4.sym} 86340 -15920 0 0 {name=X_79021_ }
C {devices/lab_pin.sym} 86280 -15800 0 0 {name=p85903 lab=_45413_/A }
C {devices/lab_pin.sym} 86280 -15760 0 0 {name=p85904 lab=_45397_/X }
C {devices/lab_pin.sym} 86400 -15780 0 1 {name=p85905 lab=_45413_/Y }
C {sky130_stdcells/nor2_4.sym} 86340 -15780 0 0 {name=X_45413_ }
C {devices/lab_pin.sym} 86280 -15670 0 0 {name=p85906 lab=_76232_/Y }
C {devices/lab_pin.sym} 86280 -15630 0 0 {name=p85907 lab=_81640_/Q }
C {devices/lab_pin.sym} 86280 -15590 0 0 {name=p85908 lab=_76233_/C }
C {devices/lab_pin.sym} 86400 -15630 0 1 {name=p85909 lab=_76233_/Y }
C {sky130_stdcells/nand3_4.sym} 86340 -15630 0 0 {name=X_76233_ }
C {devices/lab_pin.sym} 86250 -15490 0 0 {name=p85910 lab=_87141_/CLK }
C {devices/lab_pin.sym} 86250 -15470 0 0 {name=p85911 lab=_88219_/D }
C {devices/lab_pin.sym} 86430 -15490 0 1 {name=p85912 lab=_67909_/B }
C {sky130_stdcells/dfxtp_4.sym} 86340 -15480 0 0 {name=X_88219_ }
C {devices/lab_pin.sym} 86260 -15390 0 0 {name=p85913 lab=_49210_/B }
C {devices/lab_pin.sym} 86260 -15350 0 0 {name=p85914 lab=_50731_/A }
C {devices/lab_pin.sym} 86260 -15310 0 0 {name=p85915 lab=_40929_/X }
C {devices/lab_pin.sym} 86260 -15270 0 0 {name=p85916 lab=_69969_/B }
C {devices/lab_pin.sym} 86260 -15230 0 0 {name=p85917 lab=_42612_/X }
C {devices/lab_pin.sym} 86420 -15310 0 1 {name=p85918 lab=_42625_/Y }
C {sky130_stdcells/o32ai_4.sym} 86340 -15310 0 0 {name=X_42625_ }
C {devices/lab_pin.sym} 86300 -15150 0 0 {name=p85919 lab=_49181_/A }
C {devices/lab_pin.sym} 86380 -15150 0 1 {name=p85920 lab=_50714_/B }
C {sky130_stdcells/buf_2.sym} 86340 -15150 0 0 {name=X_49181_ }
C {devices/lab_pin.sym} 86280 -15040 0 0 {name=p85921 lab=_73442_/X }
C {devices/lab_pin.sym} 86280 -15000 0 0 {name=p85922 lab=_73444_/Y }
C {devices/lab_pin.sym} 86400 -15020 0 1 {name=p85923 lab=_73445_/Y }
C {sky130_stdcells/nand2_4.sym} 86340 -15020 0 0 {name=X_73445_ }
C {devices/lab_pin.sym} 86260 -14910 0 0 {name=p85924 lab=_46388_/Y }
C {devices/lab_pin.sym} 86260 -14870 0 0 {name=p85925 lab=_46346_/X }
C {devices/lab_pin.sym} 86260 -14830 0 0 {name=p85926 lab=_46392_/Y }
C {devices/lab_pin.sym} 86420 -14870 0 1 {name=p85927 lab=_46393_/Y }
C {sky130_stdcells/a21boi_4.sym} 86340 -14870 0 0 {name=X_46393_ }
C {devices/lab_pin.sym} 86260 -14750 0 0 {name=p85928 lab=_53046_/B }
C {devices/lab_pin.sym} 86260 -14710 0 0 {name=p85929 lab=_70631_/X }
C {devices/lab_pin.sym} 86260 -14670 0 0 {name=p85930 lab=_70656_/Y }
C {devices/lab_pin.sym} 86420 -14710 0 1 {name=p85931 lab=_83731_/D }
C {sky130_stdcells/o21ai_4.sym} 86340 -14710 0 0 {name=X_70657_ }
C {devices/lab_pin.sym} 86300 -14570 0 0 {name=p85932 lab=_84864_/Q }
C {devices/lab_pin.sym} 86380 -14570 0 1 {name=p85933 lab=_58380_/A }
C {sky130_stdcells/inv_2.sym} 86340 -14570 0 0 {name=X_58379_ }
C {devices/lab_pin.sym} 86280 -14460 0 0 {name=p85934 lab=_48142_/A }
C {devices/lab_pin.sym} 86280 -14420 0 0 {name=p85935 lab=_50378_/B }
C {devices/lab_pin.sym} 86400 -14440 0 1 {name=p85936 lab=_48132_/Y }
C {sky130_stdcells/nand2_4.sym} 86340 -14440 0 0 {name=X_48132_ }
C {sky130_stdcells/decap_3.sym} 86340 -14280 0 0 {name=XPHY_80 }
C {devices/lab_pin.sym} 86280 -14150 0 0 {name=p85937 lab=_60472_/A }
C {devices/lab_pin.sym} 86280 -14110 0 0 {name=p85938 lab=_60410_/B }
C {devices/lab_pin.sym} 86280 -14070 0 0 {name=p85939 lab=_60482_/A }
C {devices/lab_pin.sym} 86400 -14110 0 1 {name=p85940 lab=_63118_/A }
C {sky130_stdcells/nand3_4.sym} 86340 -14110 0 0 {name=X_60410_ }
C {devices/lab_pin.sym} 86260 -13990 0 0 {name=p85941 lab=_56165_/C }
C {devices/lab_pin.sym} 86260 -13950 0 0 {name=p85942 lab=_45343_/X }
C {devices/lab_pin.sym} 86260 -13910 0 0 {name=p85943 lab=_45303_/X }
C {devices/lab_pin.sym} 86420 -13950 0 1 {name=p85944 lab=_45344_/X }
C {sky130_stdcells/o21a_4.sym} 86340 -13950 0 0 {name=X_45344_ }
C {sky130_stdcells/decap_3.sym} 86340 -13780 0 0 {name=XPHY_91 }
C {devices/lab_pin.sym} 86280 -13640 0 0 {name=p85945 lab=_76155_/A }
C {devices/lab_pin.sym} 86280 -13600 0 0 {name=p85946 lab=_76155_/B }
C {devices/lab_pin.sym} 86400 -13620 0 1 {name=p85947 lab=_76164_/Y }
C {sky130_stdcells/nand2_4.sym} 86340 -13620 0 0 {name=X_76164_ }
C {devices/lab_pin.sym} 86300 -13490 0 0 {name=p85948 lab=_42556_/A }
C {devices/lab_pin.sym} 86380 -13490 0 1 {name=p85949 lab=_42556_/X }
C {sky130_stdcells/buf_2.sym} 86340 -13490 0 0 {name=X_42556_ }
C {devices/lab_pin.sym} 86260 -13390 0 0 {name=p85950 lab=_73373_/X }
C {devices/lab_pin.sym} 86260 -13350 0 0 {name=p85951 lab=_73375_/X }
C {devices/lab_pin.sym} 86260 -13310 0 0 {name=p85952 lab=_72737_/A }
C {devices/lab_pin.sym} 86420 -13350 0 1 {name=p85953 lab=_73376_/X }
C {sky130_stdcells/a21o_4.sym} 86340 -13350 0 0 {name=X_73376_ }
C {devices/lab_pin.sym} 86280 -13240 0 0 {name=p85954 lab=_61390_/A }
C {devices/lab_pin.sym} 86280 -13200 0 0 {name=p85955 lab=_61367_/B }
C {devices/lab_pin.sym} 86280 -13160 0 0 {name=p85956 lab=_61367_/C }
C {devices/lab_pin.sym} 86280 -13120 0 0 {name=p85957 lab=_61390_/D }
C {devices/lab_pin.sym} 86400 -13180 0 1 {name=p85958 lab=_61390_/Y }
C {sky130_stdcells/nand4_4.sym} 86340 -13180 0 0 {name=X_61390_ }
C {devices/lab_pin.sym} 86300 -13030 0 0 {name=p85959 lab=_70588_/A }
C {devices/lab_pin.sym} 86380 -13030 0 1 {name=p85960 lab=_70613_/B }
C {sky130_stdcells/buf_2.sym} 86340 -13030 0 0 {name=X_70588_ }
C {devices/lab_pin.sym} 86300 -12910 0 0 {name=p85961 lab=_75115_/A }
C {devices/lab_pin.sym} 86380 -12910 0 1 {name=p85962 lab=_75117_/A }
C {sky130_stdcells/inv_2.sym} 86340 -12910 0 0 {name=X_75115_ }
C {devices/lab_pin.sym} 86300 -12790 0 0 {name=p85963 lab=_41506_/Y }
C {devices/lab_pin.sym} 86380 -12790 0 1 {name=p85964 lab=_41507_/X }
C {sky130_stdcells/buf_2.sym} 86340 -12790 0 0 {name=X_41507_ }
C {devices/lab_pin.sym} 86260 -12690 0 0 {name=p85965 lab=_74083_/B }
C {devices/lab_pin.sym} 86260 -12650 0 0 {name=p85966 lab=_48049_/X }
C {devices/lab_pin.sym} 86260 -12610 0 0 {name=p85967 lab=_48062_/Y }
C {devices/lab_pin.sym} 86420 -12650 0 1 {name=p85968 lab=_48063_/Y }
C {sky130_stdcells/o21ai_4.sym} 86340 -12650 0 0 {name=X_48063_ }
C {devices/lab_pin.sym} 86300 -12510 0 0 {name=p85969 lab=_60341_/A }
C {devices/lab_pin.sym} 86380 -12510 0 1 {name=p85970 lab=_60341_/X }
C {sky130_stdcells/buf_2.sym} 86340 -12510 0 0 {name=X_60341_ }
C {devices/lab_pin.sym} 86300 -12390 0 0 {name=p85971 lab=_59085_/A }
C {devices/lab_pin.sym} 86380 -12390 0 1 {name=p85972 lab=_72327_/X }
C {sky130_stdcells/buf_2.sym} 86340 -12390 0 0 {name=X_72327_ }
C {devices/lab_pin.sym} 86300 -12270 0 0 {name=p85973 lab=_45714_/A }
C {devices/lab_pin.sym} 86380 -12270 0 1 {name=p85974 lab=_45275_/X }
C {sky130_stdcells/buf_2.sym} 86340 -12270 0 0 {name=X_45275_ }
C {devices/lab_pin.sym} 86280 -12170 0 0 {name=p85975 lab=_76082_/A }
C {devices/lab_pin.sym} 86280 -12130 0 0 {name=p85976 lab=_76096_/A }
C {devices/lab_pin.sym} 86280 -12090 0 0 {name=p85977 lab=_76097_/B }
C {devices/lab_pin.sym} 86400 -12130 0 1 {name=p85978 lab=_76095_/X }
C {sky130_stdcells/and3_4.sym} 86340 -12130 0 0 {name=X_76095_ }
C {devices/lab_pin.sym} 86300 -11990 0 0 {name=p85979 lab=_73820_/A }
C {devices/lab_pin.sym} 86380 -11990 0 1 {name=p85980 lab=_68641_/B }
C {sky130_stdcells/inv_2.sym} 86340 -11990 0 0 {name=X_42487_ }
C {devices/lab_pin.sym} 86300 -11870 0 0 {name=p85981 lab=clkbuf_7_74_0_CLK/A }
C {devices/lab_pin.sym} 86380 -11870 0 1 {name=p85982 lab=clkbuf_7_74_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 86340 -11870 0 0 {name=Xclkbuf_7_74_0_CLK }
C {devices/lab_pin.sym} 86260 -11770 0 0 {name=p85983 lab=_47009_/Y }
C {devices/lab_pin.sym} 86260 -11730 0 0 {name=p85984 lab=_46987_/X }
C {devices/lab_pin.sym} 86260 -11690 0 0 {name=p85985 lab=_47013_/X }
C {devices/lab_pin.sym} 86420 -11730 0 1 {name=p85986 lab=_86680_/D }
C {sky130_stdcells/a21oi_4.sym} 86340 -11730 0 0 {name=X_47014_ }
C {devices/lab_pin.sym} 86280 -11610 0 0 {name=p85987 lab=_44006_/X }
C {devices/lab_pin.sym} 86280 -11570 0 0 {name=p85988 lab=_44164_/X }
C {devices/lab_pin.sym} 86280 -11530 0 0 {name=p85989 lab=_44225_/Y }
C {devices/lab_pin.sym} 86400 -11570 0 1 {name=p85990 lab=_44226_/Y }
C {sky130_stdcells/nand3_4.sym} 86340 -11570 0 0 {name=X_44226_ }
C {devices/lab_pin.sym} 86300 -11430 0 0 {name=p85991 lab=_63060_/A }
C {devices/lab_pin.sym} 86380 -11430 0 1 {name=p85992 lab=_63060_/X }
C {sky130_stdcells/buf_2.sym} 86340 -11430 0 0 {name=X_63060_ }
C {devices/lab_pin.sym} 86280 -11320 0 0 {name=p85993 lab=_81150_/D }
C {devices/lab_pin.sym} 86280 -11280 0 0 {name=p85994 lab=_75046_/B }
C {devices/lab_pin.sym} 86400 -11300 0 1 {name=p85995 lab=_75046_/X }
C {sky130_stdcells/xor2_4.sym} 86340 -11300 0 0 {name=X_75046_ }
C {devices/lab_pin.sym} 86280 -11180 0 0 {name=p85996 lab=_60145_/Y }
C {devices/lab_pin.sym} 86280 -11140 0 0 {name=p85997 lab=_79921_/A }
C {devices/lab_pin.sym} 86400 -11160 0 1 {name=p85998 lab=_79924_/C }
C {sky130_stdcells/nand2_4.sym} 86340 -11160 0 0 {name=X_79923_ }
C {devices/lab_pin.sym} 86260 -11060 0 0 {name=p85999 lab=_41437_/X }
C {devices/lab_pin.sym} 86260 -11020 0 0 {name=p86000 lab=_41418_/X }
C {devices/lab_pin.sym} 86260 -10980 0 0 {name=p86001 lab=_88215_/Q }
C {devices/lab_pin.sym} 86260 -10940 0 0 {name=p86002 lab=_41419_/X }
C {devices/lab_pin.sym} 86420 -11000 0 1 {name=p86003 lab=_88215_/D }
C {sky130_stdcells/a2bb2o_4.sym} 86340 -11000 0 0 {name=X_41438_ }
C {devices/lab_pin.sym} 86300 -10850 0 0 {name=p86004 lab=_60271_/X }
C {devices/lab_pin.sym} 86380 -10850 0 1 {name=p86005 lab=_60273_/A }
C {sky130_stdcells/buf_2.sym} 86340 -10850 0 0 {name=X_60272_ }
C {devices/lab_pin.sym} 86300 -10730 0 0 {name=p86006 lab=_72123_/A }
C {devices/lab_pin.sym} 86380 -10730 0 1 {name=p86007 lab=_72258_/X }
C {sky130_stdcells/buf_2.sym} 86340 -10730 0 0 {name=X_72258_ }
C {devices/lab_pin.sym} 86300 -10610 0 0 {name=p86008 lab=_59823_/X }
C {devices/lab_pin.sym} 86380 -10610 0 1 {name=p86009 lab=_62011_/X }
C {sky130_stdcells/buf_2.sym} 86340 -10610 0 0 {name=X_62011_ }
C {devices/lab_pin.sym} 86300 -10490 0 0 {name=p86010 lab=_70400_/A }
C {devices/lab_pin.sym} 86380 -10490 0 1 {name=p86011 lab=_71232_/B }
C {sky130_stdcells/buf_2.sym} 86340 -10490 0 0 {name=X_71209_ }
C {devices/lab_pin.sym} 86260 -10390 0 0 {name=p86012 lab=_66180_/A }
C {devices/lab_pin.sym} 86260 -10350 0 0 {name=p86013 lab=_57776_/A }
C {devices/lab_pin.sym} 86260 -10310 0 0 {name=p86014 lab=_44152_/A }
C {devices/lab_pin.sym} 86420 -10350 0 1 {name=p86015 lab=_44157_/Y }
C {sky130_stdcells/a21oi_4.sym} 86340 -10350 0 0 {name=X_44157_ }
C {devices/lab_pin.sym} 86280 -10220 0 0 {name=p86016 lab=_79835_/X }
C {devices/lab_pin.sym} 86280 -10180 0 0 {name=p86017 lab=_79854_/B }
C {devices/lab_pin.sym} 86400 -10200 0 1 {name=p86018 lab=_79856_/B }
C {sky130_stdcells/or2_4.sym} 86340 -10200 0 0 {name=X_79854_ }
C {devices/lab_pin.sym} 86280 -10080 0 0 {name=p86019 lab=_41369_/A }
C {devices/lab_pin.sym} 86280 -10040 0 0 {name=p86020 lab=_41325_/X }
C {devices/lab_pin.sym} 86400 -10060 0 1 {name=p86021 lab=_41369_/X }
C {sky130_stdcells/or2_4.sym} 86340 -10060 0 0 {name=X_41369_ }
C {devices/lab_pin.sym} 86300 -9930 0 0 {name=p86022 lab=_58766_/A }
C {devices/lab_pin.sym} 86380 -9930 0 1 {name=p86023 lab=_72189_/X }
C {sky130_stdcells/buf_2.sym} 86340 -9930 0 0 {name=X_72189_ }
C {devices/lab_pin.sym} 86300 -9810 0 0 {name=p86024 lab=_43127_/A }
C {devices/lab_pin.sym} 86380 -9810 0 1 {name=p86025 lab=_43108_/X }
C {sky130_stdcells/buf_2.sym} 86340 -9810 0 0 {name=X_43108_ }
C {devices/lab_pin.sym} 86280 -9700 0 0 {name=p86026 lab=_82722_/Q }
C {devices/lab_pin.sym} 86280 -9660 0 0 {name=p86027 lab=_78805_/B }
C {devices/lab_pin.sym} 86400 -9680 0 1 {name=p86028 lab=_78805_/X }
C {sky130_stdcells/xor2_4.sym} 86340 -9680 0 0 {name=X_78805_ }
C {devices/lab_pin.sym} 86260 -9570 0 0 {name=p86029 lab=_86457_/Q }
C {devices/lab_pin.sym} 86260 -9530 0 0 {name=p86030 lab=_48952_/X }
C {devices/lab_pin.sym} 86260 -9490 0 0 {name=p86031 lab=_48964_/Y }
C {devices/lab_pin.sym} 86420 -9530 0 1 {name=p86032 lab=_48965_/Y }
C {sky130_stdcells/o21ai_4.sym} 86340 -9530 0 0 {name=X_48965_ }
C {devices/lab_pin.sym} 86280 -9410 0 0 {name=p86033 lab=_44088_/A }
C {devices/lab_pin.sym} 86280 -9370 0 0 {name=p86034 lab=_43987_/A }
C {devices/lab_pin.sym} 86280 -9330 0 0 {name=p86035 lab=_44313_/B }
C {devices/lab_pin.sym} 86400 -9370 0 1 {name=p86036 lab=_44090_/A }
C {sky130_stdcells/nand3_4.sym} 86340 -9370 0 0 {name=X_44088_ }
C {devices/lab_pin.sym} 86300 -9230 0 0 {name=p86037 lab=clkbuf_7_89_0_CLK/A }
C {devices/lab_pin.sym} 86380 -9230 0 1 {name=p86038 lab=clkbuf_7_89_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 86340 -9230 0 0 {name=Xclkbuf_7_89_0_CLK }
C {devices/lab_pin.sym} 86280 -9120 0 0 {name=p86039 lab=_79794_/A }
C {devices/lab_pin.sym} 86280 -9080 0 0 {name=p86040 lab=_79794_/B }
C {devices/lab_pin.sym} 86400 -9100 0 1 {name=p86041 lab=_79785_/Y }
C {sky130_stdcells/xnor2_4.sym} 86340 -9100 0 0 {name=X_79785_ }
C {devices/lab_pin.sym} 86280 -8980 0 0 {name=p86042 lab=_60947_/C }
C {devices/lab_pin.sym} 86280 -8940 0 0 {name=p86043 lab=_84421_/Q }
C {devices/lab_pin.sym} 86400 -8960 0 1 {name=p86044 lab=_76997_/X }
C {sky130_stdcells/xor2_4.sym} 86340 -8960 0 0 {name=X_76997_ }
C {devices/lab_pin.sym} 86260 -8850 0 0 {name=p86045 lab=_47867_/X }
C {devices/lab_pin.sym} 86260 -8810 0 0 {name=p86046 lab=_46337_/A }
C {devices/lab_pin.sym} 86260 -8770 0 0 {name=p86047 lab=_47915_/Y }
C {devices/lab_pin.sym} 86420 -8810 0 1 {name=p86048 lab=_47917_/A }
C {sky130_stdcells/o21ai_4.sym} 86340 -8810 0 0 {name=X_47916_ }
C {devices/lab_pin.sym} 86260 -8710 0 0 {name=p86049 lab=_43038_/X }
C {devices/lab_pin.sym} 86260 -8670 0 0 {name=p86050 lab=_43017_/X }
C {devices/lab_pin.sym} 86260 -8630 0 0 {name=p86051 lab=_40610_/X }
C {devices/lab_pin.sym} 86260 -8590 0 0 {name=p86052 lab=_73677_/A }
C {devices/lab_pin.sym} 86260 -8550 0 0 {name=p86053 lab=_43025_/X }
C {devices/lab_pin.sym} 86420 -8630 0 1 {name=p86054 lab=_43040_/A }
C {sky130_stdcells/o32ai_4.sym} 86340 -8630 0 0 {name=X_43039_ }
C {devices/lab_pin.sym} 86260 -8490 0 0 {name=p86055 lab=_66746_/X }
C {devices/lab_pin.sym} 86260 -8450 0 0 {name=p86056 lab=_66749_/X }
C {devices/lab_pin.sym} 86260 -8410 0 0 {name=p86057 lab=_66726_/X }
C {devices/lab_pin.sym} 86420 -8450 0 1 {name=p86058 lab=_66750_/X }
C {sky130_stdcells/a21o_4.sym} 86340 -8450 0 0 {name=X_66750_ }
C {devices/lab_pin.sym} 86260 -8330 0 0 {name=p86059 lab=_78732_/X }
C {devices/lab_pin.sym} 86260 -8290 0 0 {name=p86060 lab=_78733_/Y }
C {devices/lab_pin.sym} 86260 -8250 0 0 {name=p86061 lab=_78735_/Y }
C {devices/lab_pin.sym} 86420 -8290 0 1 {name=p86062 lab=_78770_/A }
C {sky130_stdcells/a21o_4.sym} 86340 -8290 0 0 {name=X_78736_ }
C {devices/lab_pin.sym} 86280 -8180 0 0 {name=p86063 lab=_64081_/C }
C {devices/lab_pin.sym} 86280 -8140 0 0 {name=p86064 lab=_64180_/C }
C {devices/lab_pin.sym} 86280 -8100 0 0 {name=p86065 lab=_60889_/X }
C {devices/lab_pin.sym} 86280 -8060 0 0 {name=p86066 lab=_84955_/Q }
C {devices/lab_pin.sym} 86400 -8120 0 1 {name=p86067 lab=_63962_/X }
C {sky130_stdcells/and4_4.sym} 86340 -8120 0 0 {name=X_63962_ }
C {devices/lab_pin.sym} 86260 -7990 0 0 {name=p86068 lab=_75946_/Y }
C {devices/lab_pin.sym} 86260 -7950 0 0 {name=p86069 lab=_75942_/Y }
C {devices/lab_pin.sym} 86260 -7910 0 0 {name=p86070 lab=_75947_/Y }
C {devices/lab_pin.sym} 86420 -7950 0 1 {name=p86071 lab=_75948_/Y }
C {sky130_stdcells/o21ai_4.sym} 86340 -7950 0 0 {name=X_75948_ }
C {devices/lab_pin.sym} 86300 -7810 0 0 {name=p86072 lab=_48612_/A }
C {devices/lab_pin.sym} 86380 -7810 0 1 {name=p86073 lab=_48896_/X }
C {sky130_stdcells/buf_2.sym} 86340 -7810 0 0 {name=X_48896_ }
C {devices/lab_pin.sym} 86300 -7690 0 0 {name=p86074 lab=_65400_/A }
C {devices/lab_pin.sym} 86380 -7690 0 1 {name=p86075 lab=_65701_/X }
C {sky130_stdcells/buf_2.sym} 86340 -7690 0 0 {name=X_65701_ }
C {devices/lab_pin.sym} 86280 -7590 0 0 {name=p86076 lab=_62930_/A }
C {devices/lab_pin.sym} 86280 -7550 0 0 {name=p86077 lab=_62930_/B }
C {devices/lab_pin.sym} 86280 -7510 0 0 {name=p86078 lab=_84371_/Q }
C {devices/lab_pin.sym} 86400 -7550 0 1 {name=p86079 lab=_62913_/Y }
C {sky130_stdcells/nor3_4.sym} 86340 -7550 0 0 {name=X_62913_ }
C {devices/lab_pin.sym} 86300 -7410 0 0 {name=p86080 lab=_48144_/A }
C {devices/lab_pin.sym} 86380 -7410 0 1 {name=p86081 lab=_51282_/A }
C {sky130_stdcells/buf_2.sym} 86340 -7410 0 0 {name=X_47847_ }
C {devices/lab_pin.sym} 86260 -7310 0 0 {name=p86082 lab=_66677_/X }
C {devices/lab_pin.sym} 86260 -7270 0 0 {name=p86083 lab=_66680_/X }
C {devices/lab_pin.sym} 86260 -7230 0 0 {name=p86084 lab=_66606_/X }
C {devices/lab_pin.sym} 86420 -7270 0 1 {name=p86085 lab=_66681_/X }
C {sky130_stdcells/a21o_4.sym} 86340 -7270 0 0 {name=X_66681_ }
C {devices/lab_pin.sym} 86260 -7150 0 0 {name=p86086 lab=_78663_/X }
C {devices/lab_pin.sym} 86260 -7110 0 0 {name=p86087 lab=_78664_/Y }
C {devices/lab_pin.sym} 86260 -7070 0 0 {name=p86088 lab=_78666_/Y }
C {devices/lab_pin.sym} 86420 -7110 0 1 {name=p86089 lab=_78667_/X }
C {sky130_stdcells/a21o_4.sym} 86340 -7110 0 0 {name=X_78667_ }
C {devices/lab_pin.sym} 86300 -6970 0 0 {name=p86090 lab=_63972_/A }
C {devices/lab_pin.sym} 86380 -6970 0 1 {name=p86091 lab=_63894_/C }
C {sky130_stdcells/buf_2.sym} 86340 -6970 0 0 {name=X_63893_ }
C {devices/lab_pin.sym} 86280 -6870 0 0 {name=p86092 lab=_75876_/A }
C {devices/lab_pin.sym} 86280 -6830 0 0 {name=p86093 lab=_81025_/Q }
C {devices/lab_pin.sym} 86280 -6790 0 0 {name=p86094 lab=_75876_/B }
C {devices/lab_pin.sym} 86400 -6830 0 1 {name=p86095 lab=_75880_/B }
C {sky130_stdcells/nand3_4.sym} 86340 -6830 0 0 {name=X_75879_ }
C {devices/lab_pin.sym} 86300 -6690 0 0 {name=p86096 lab=clkbuf_6_6_0_CLK/X }
C {devices/lab_pin.sym} 86380 -6690 0 1 {name=p86097 lab=clkbuf_8_25_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 86340 -6690 0 0 {name=Xclkbuf_7_12_0_CLK }
C {devices/lab_pin.sym} 86260 -6590 0 0 {name=p86098 lab=_68417_/X }
C {devices/lab_pin.sym} 86260 -6550 0 0 {name=p86099 lab=_68419_/X }
C {devices/lab_pin.sym} 86260 -6510 0 0 {name=p86100 lab=_68390_/X }
C {devices/lab_pin.sym} 86420 -6550 0 1 {name=p86101 lab=_68420_/X }
C {sky130_stdcells/a21o_4.sym} 86340 -6550 0 0 {name=X_68420_ }
C {devices/lab_pin.sym} 86260 -6430 0 0 {name=p86102 lab=_65516_/X }
C {devices/lab_pin.sym} 86260 -6390 0 0 {name=p86103 lab=_64953_/Y }
C {devices/lab_pin.sym} 86260 -6350 0 0 {name=p86104 lab=_65631_/Y }
C {devices/lab_pin.sym} 86420 -6390 0 1 {name=p86105 lab=_65632_/Y }
C {sky130_stdcells/o21ai_4.sym} 86340 -6390 0 0 {name=X_65632_ }
C {devices/lab_pin.sym} 86260 -6270 0 0 {name=p86106 lab=_77614_/X }
C {devices/lab_pin.sym} 86260 -6230 0 0 {name=p86107 lab=_77619_/C }
C {devices/lab_pin.sym} 86260 -6190 0 0 {name=p86108 lab=_77619_/B }
C {devices/lab_pin.sym} 86420 -6230 0 1 {name=p86109 lab=_77664_/C }
C {sky130_stdcells/a21o_4.sym} 86340 -6230 0 0 {name=X_77618_ }
C {devices/lab_pin.sym} 86280 -6110 0 0 {name=p86110 lab=_62869_/A }
C {devices/lab_pin.sym} 86280 -6070 0 0 {name=p86111 lab=_62812_/B }
C {devices/lab_pin.sym} 86280 -6030 0 0 {name=p86112 lab=_63561_/B }
C {devices/lab_pin.sym} 86400 -6070 0 1 {name=p86113 lab=_62844_/Y }
C {sky130_stdcells/nand3_4.sym} 86340 -6070 0 0 {name=X_62844_ }
C {devices/lab_pin.sym} 86300 -5930 0 0 {name=p86114 lab=clkbuf_7_76_0_CLK/X }
C {devices/lab_pin.sym} 86380 -5930 0 1 {name=p86115 lab=clkbuf_8_152_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 86340 -5930 0 0 {name=Xclkbuf_8_152_0_CLK }
C {devices/lab_pin.sym} 86260 -5830 0 0 {name=p86116 lab=_47774_/Y }
C {devices/lab_pin.sym} 86260 -5790 0 0 {name=p86117 lab=_47745_/X }
C {devices/lab_pin.sym} 86260 -5750 0 0 {name=p86118 lab=_47777_/X }
C {devices/lab_pin.sym} 86420 -5790 0 1 {name=p86119 lab=_86599_/D }
C {sky130_stdcells/a21oi_4.sym} 86340 -5790 0 0 {name=X_47778_ }
C {devices/lab_pin.sym} 86280 -5660 0 0 {name=p86120 lab=_78596_/Y }
C {devices/lab_pin.sym} 86280 -5620 0 0 {name=p86121 lab=_78597_/X }
C {devices/lab_pin.sym} 86400 -5640 0 1 {name=p86122 lab=_78623_/A }
C {sky130_stdcells/xor2_4.sym} 86340 -5640 0 0 {name=X_78598_ }
C {devices/lab_pin.sym} 86260 -5530 0 0 {name=p86123 lab=_49513_/Y }
C {devices/lab_pin.sym} 86260 -5490 0 0 {name=p86124 lab=_49514_/X }
C {devices/lab_pin.sym} 86260 -5450 0 0 {name=p86125 lab=_49516_/X }
C {devices/lab_pin.sym} 86420 -5490 0 1 {name=p86126 lab=_86373_/D }
C {sky130_stdcells/a21oi_4.sym} 86340 -5490 0 0 {name=X_49517_ }
C {devices/lab_pin.sym} 86260 -5380 0 0 {name=p86127 lab=_87507_/Q }
C {devices/lab_pin.sym} 86260 -5340 0 0 {name=p86128 lab=_68472_/A }
C {devices/lab_pin.sym} 86260 -5300 0 0 {name=p86129 lab=_68348_/X }
C {devices/lab_pin.sym} 86260 -5260 0 0 {name=p86130 lab=_68350_/X }
C {devices/lab_pin.sym} 86420 -5320 0 1 {name=p86131 lab=_68351_/X }
C {sky130_stdcells/a211o_4.sym} 86340 -5320 0 0 {name=X_68351_ }
C {devices/lab_pin.sym} 86280 -5200 0 0 {name=p86132 lab=_46737_/A }
C {devices/lab_pin.sym} 86280 -5160 0 0 {name=p86133 lab=_46717_/B }
C {devices/lab_pin.sym} 86280 -5120 0 0 {name=p86134 lab=_46717_/C }
C {devices/lab_pin.sym} 86280 -5080 0 0 {name=p86135 lab=_46728_/X }
C {devices/lab_pin.sym} 86400 -5140 0 1 {name=p86136 lab=_46729_/X }
C {sky130_stdcells/and4_4.sym} 86340 -5140 0 0 {name=X_46729_ }
C {devices/lab_pin.sym} 86300 -4990 0 0 {name=p86137 lab=_65158_/A }
C {devices/lab_pin.sym} 86380 -4990 0 1 {name=p86138 lab=_65779_/A }
C {sky130_stdcells/buf_2.sym} 86340 -4990 0 0 {name=X_65563_ }
C {devices/lab_pin.sym} 86300 -4870 0 0 {name=p86139 lab=_77549_/A }
C {devices/lab_pin.sym} 86380 -4870 0 1 {name=p86140 lab=_77553_/A }
C {sky130_stdcells/inv_2.sym} 86340 -4870 0 0 {name=X_77549_ }
C {devices/lab_pin.sym} 86280 -4780 0 0 {name=p86141 lab=_61448_/X }
C {devices/lab_pin.sym} 86280 -4740 0 0 {name=p86142 lab=_62743_/B }
C {devices/lab_pin.sym} 86280 -4700 0 0 {name=p86143 lab=_62742_/X }
C {devices/lab_pin.sym} 86280 -4660 0 0 {name=p86144 lab=_62729_/D }
C {devices/lab_pin.sym} 86400 -4720 0 1 {name=p86145 lab=_62775_/Y }
C {sky130_stdcells/nand4_4.sym} 86340 -4720 0 0 {name=X_62775_ }
C {devices/lab_pin.sym} 86260 -4590 0 0 {name=p86146 lab=_67298_/X }
C {devices/lab_pin.sym} 86260 -4550 0 0 {name=p86147 lab=_67301_/X }
C {devices/lab_pin.sym} 86260 -4510 0 0 {name=p86148 lab=_67255_/X }
C {devices/lab_pin.sym} 86420 -4550 0 1 {name=p86149 lab=_67302_/Y }
C {sky130_stdcells/a21oi_4.sym} 86340 -4550 0 0 {name=X_67302_ }
C {devices/lab_pin.sym} 86280 -4430 0 0 {name=p86150 lab=_64474_/A }
C {devices/lab_pin.sym} 86280 -4390 0 0 {name=p86151 lab=_64306_/A }
C {devices/lab_pin.sym} 86280 -4350 0 0 {name=p86152 lab=_84886_/Q }
C {devices/lab_pin.sym} 86400 -4390 0 1 {name=p86153 lab=_64514_/X }
C {sky130_stdcells/and3_4.sym} 86340 -4390 0 0 {name=X_64514_ }
C {devices/lab_pin.sym} 86260 -4270 0 0 {name=p86154 lab=_49446_/Y }
C {devices/lab_pin.sym} 86260 -4230 0 0 {name=p86155 lab=_49434_/X }
C {devices/lab_pin.sym} 86260 -4190 0 0 {name=p86156 lab=_49447_/X }
C {devices/lab_pin.sym} 86420 -4230 0 1 {name=p86157 lab=_86386_/D }
C {sky130_stdcells/a21oi_4.sym} 86340 -4230 0 0 {name=X_49448_ }
C {devices/lab_pin.sym} 86280 -4120 0 0 {name=p86158 lab=_61770_/A }
C {devices/lab_pin.sym} 86280 -4080 0 0 {name=p86159 lab=_61770_/B }
C {devices/lab_pin.sym} 86280 -4040 0 0 {name=p86160 lab=_63369_/B }
C {devices/lab_pin.sym} 86280 -4000 0 0 {name=p86161 lab=_61770_/D }
C {devices/lab_pin.sym} 86400 -4060 0 1 {name=p86162 lab=_61726_/X }
C {sky130_stdcells/and4_4.sym} 86340 -4060 0 0 {name=X_61726_ }
C {devices/lab_pin.sym} 86280 -3920 0 0 {name=p86163 lab=_80560_/A }
C {devices/lab_pin.sym} 86280 -3880 0 0 {name=p86164 lab=_80560_/B }
C {devices/lab_pin.sym} 86400 -3900 0 1 {name=p86165 lab=_80561_/B }
C {sky130_stdcells/xnor2_4.sym} 86340 -3900 0 0 {name=X_80560_ }
C {devices/lab_pin.sym} 86260 -3790 0 0 {name=p86166 lab=_83993_/Q }
C {devices/lab_pin.sym} 86260 -3750 0 0 {name=p86167 lab=_68279_/X }
C {devices/lab_pin.sym} 86260 -3710 0 0 {name=p86168 lab=_68281_/X }
C {devices/lab_pin.sym} 86420 -3750 0 1 {name=p86169 lab=_83993_/D }
C {sky130_stdcells/a21bo_4.sym} 86340 -3750 0 0 {name=X_68282_ }
C {devices/lab_pin.sym} 86280 -3620 0 0 {name=p86170 lab=_65491_/X }
C {devices/lab_pin.sym} 86280 -3580 0 0 {name=p86171 lab=_65494_/B }
C {devices/lab_pin.sym} 86400 -3600 0 1 {name=p86172 lab=_65494_/Y }
C {sky130_stdcells/nand2_4.sym} 86340 -3600 0 0 {name=X_65494_ }
C {devices/lab_pin.sym} 86300 -3470 0 0 {name=p86173 lab=clkbuf_7_26_0_CLK/A }
C {devices/lab_pin.sym} 86380 -3470 0 1 {name=p86174 lab=clkbuf_8_55_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 86340 -3470 0 0 {name=Xclkbuf_7_27_0_CLK }
C {devices/lab_pin.sym} 86260 -3370 0 0 {name=p86175 lab=_67229_/X }
C {devices/lab_pin.sym} 86260 -3330 0 0 {name=p86176 lab=_67232_/X }
C {devices/lab_pin.sym} 86260 -3290 0 0 {name=p86177 lab=_67015_/X }
C {devices/lab_pin.sym} 86420 -3330 0 1 {name=p86178 lab=_67233_/Y }
C {sky130_stdcells/a21oi_4.sym} 86340 -3330 0 0 {name=X_67233_ }
C {devices/lab_pin.sym} 86300 -3190 0 0 {name=p86179 lab=clkbuf_7_83_0_CLK/X }
C {devices/lab_pin.sym} 86380 -3190 0 1 {name=p86180 lab=clkbuf_9_335_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 86340 -3190 0 0 {name=Xclkbuf_8_167_0_CLK }
C {devices/lab_pin.sym} 86300 -3070 0 0 {name=p86181 lab=_79202_/Y }
C {devices/lab_pin.sym} 86380 -3070 0 1 {name=p86182 lab=_79219_/Y }
C {sky130_stdcells/inv_2.sym} 86340 -3070 0 0 {name=X_79219_ }
C {devices/lab_pin.sym} 86280 -2960 0 0 {name=p86183 lab=_58452_/A }
C {devices/lab_pin.sym} 86280 -2920 0 0 {name=p86184 lab=_64511_/B }
C {devices/lab_pin.sym} 86400 -2940 0 1 {name=p86185 lab=_64445_/Y }
C {sky130_stdcells/nor2_4.sym} 86340 -2940 0 0 {name=X_64445_ }
C {devices/lab_pin.sym} 86300 -2810 0 0 {name=p86186 lab=clkbuf_9_81_0_CLK/X }
C {devices/lab_pin.sym} 86380 -2810 0 1 {name=p86187 lab=_81697_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 86340 -2810 0 0 {name=Xclkbuf_10_162_0_CLK }
C {devices/lab_pin.sym} 86300 -2690 0 0 {name=p86188 lab=_61657_/A }
C {devices/lab_pin.sym} 86380 -2690 0 1 {name=p86189 lab=_61657_/Y }
C {sky130_stdcells/inv_2.sym} 86340 -2690 0 0 {name=X_61657_ }
C {devices/lab_pin.sym} 86300 -2570 0 0 {name=p86190 lab=_49379_/A }
C {devices/lab_pin.sym} 86380 -2570 0 1 {name=p86191 lab=_49397_/A }
C {sky130_stdcells/buf_2.sym} 86340 -2570 0 0 {name=X_49379_ }
C {devices/lab_pin.sym} 86260 -2470 0 0 {name=p86192 lab=_80478_/X }
C {devices/lab_pin.sym} 86260 -2430 0 0 {name=p86193 lab=_80489_/X }
C {devices/lab_pin.sym} 86260 -2390 0 0 {name=p86194 lab=_80490_/X }
C {devices/lab_pin.sym} 86420 -2430 0 1 {name=p86195 lab=_80491_/Y }
C {sky130_stdcells/a21oi_4.sym} 86340 -2430 0 0 {name=X_80491_ }
C {devices/lab_pin.sym} 86300 -2290 0 0 {name=p86196 lab=_51218_/X }
C {devices/lab_pin.sym} 86380 -2290 0 1 {name=p86197 lab=_51410_/X }
C {sky130_stdcells/buf_2.sym} 86340 -2290 0 0 {name=X_51410_ }
C {devices/lab_pin.sym} 86250 -2170 0 0 {name=p86198 lab=_82515_/CLK }
C {devices/lab_pin.sym} 86250 -2150 0 0 {name=p86199 lab=_82262_/Q }
C {devices/lab_pin.sym} 86430 -2170 0 1 {name=p86200 lab=_77517_/A }
C {sky130_stdcells/dfxtp_4.sym} 86340 -2160 0 0 {name=X_82230_ }
C {devices/lab_pin.sym} 86300 -2030 0 0 {name=p86201 lab=clkbuf_9_396_0_CLK/X }
C {devices/lab_pin.sym} 86380 -2030 0 1 {name=p86202 lab=_82503_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 86340 -2030 0 0 {name=Xclkbuf_10_792_0_CLK }
C {devices/lab_pin.sym} 86300 -1910 0 0 {name=p86203 lab=_60608_/A }
C {devices/lab_pin.sym} 86380 -1910 0 1 {name=p86204 lab=_60608_/X }
C {sky130_stdcells/buf_2.sym} 86340 -1910 0 0 {name=X_60608_ }
C {devices/lab_pin.sym} 86260 -1820 0 0 {name=p86205 lab=_67141_/X }
C {devices/lab_pin.sym} 86260 -1780 0 0 {name=p86206 lab=_67151_/Y }
C {devices/lab_pin.sym} 86260 -1740 0 0 {name=p86207 lab=_67152_/X }
C {devices/lab_pin.sym} 86260 -1700 0 0 {name=p86208 lab=_67163_/Y }
C {devices/lab_pin.sym} 86420 -1760 0 1 {name=p86209 lab=_67164_/X }
C {sky130_stdcells/a211o_4.sym} 86340 -1760 0 0 {name=X_67164_ }
C {devices/lab_pin.sym} 86300 -1610 0 0 {name=p86210 lab=_52496_/A }
C {devices/lab_pin.sym} 86380 -1610 0 1 {name=p86211 lab=_52390_/X }
C {sky130_stdcells/buf_2.sym} 86340 -1610 0 0 {name=X_52390_ }
C {devices/lab_pin.sym} 86280 -1520 0 0 {name=p86212 lab=_64363_/A }
C {devices/lab_pin.sym} 86280 -1480 0 0 {name=p86213 lab=_64363_/B }
C {devices/lab_pin.sym} 86280 -1440 0 0 {name=p86214 lab=_84955_/Q }
C {devices/lab_pin.sym} 86280 -1400 0 0 {name=p86215 lab=_61145_/X }
C {devices/lab_pin.sym} 86400 -1460 0 1 {name=p86216 lab=_64376_/X }
C {sky130_stdcells/and4_4.sym} 86340 -1460 0 0 {name=X_64376_ }
C {devices/lab_pin.sym} 86260 -1330 0 0 {name=p86217 lab=_59829_/X }
C {devices/lab_pin.sym} 86260 -1290 0 0 {name=p86218 lab=_61586_/Y }
C {devices/lab_pin.sym} 86260 -1250 0 0 {name=p86219 lab=_61587_/X }
C {devices/lab_pin.sym} 86420 -1290 0 1 {name=p86220 lab=_61588_/X }
C {sky130_stdcells/o21a_4.sym} 86340 -1290 0 0 {name=X_61588_ }
C {devices/lab_pin.sym} 86260 -1180 0 0 {name=p86221 lab=_64971_/X }
C {devices/lab_pin.sym} 86260 -1140 0 0 {name=p86222 lab=_85619_/Q }
C {devices/lab_pin.sym} 86260 -1100 0 0 {name=p86223 lab=_44261_/X }
C {devices/lab_pin.sym} 86260 -1060 0 0 {name=p86224 lab=_66114_/X }
C {devices/lab_pin.sym} 86420 -1120 0 1 {name=p86225 lab=_66115_/X }
C {sky130_stdcells/a211o_4.sym} 86340 -1120 0 0 {name=X_66115_ }
C {devices/lab_pin.sym} 86300 -970 0 0 {name=p86226 lab=_51842_/A }
C {devices/lab_pin.sym} 86380 -970 0 1 {name=p86227 lab=_53671_/A }
C {sky130_stdcells/buf_2.sym} 86340 -970 0 0 {name=X_51341_ }
C {devices/lab_pin.sym} 86260 -870 0 0 {name=p86228 lab=_63325_/Y }
C {devices/lab_pin.sym} 86260 -830 0 0 {name=p86229 lab=_63326_/X }
C {devices/lab_pin.sym} 86260 -790 0 0 {name=p86230 lab=_63317_/X }
C {devices/lab_pin.sym} 86420 -830 0 1 {name=p86231 lab=_63327_/X }
C {sky130_stdcells/a21o_4.sym} 86340 -830 0 0 {name=X_63327_ }
C {devices/lab_pin.sym} 86250 -690 0 0 {name=p86232 lab=_84220_/CLK }
C {devices/lab_pin.sym} 86250 -670 0 0 {name=p86233 lab=_84153_/Q }
C {devices/lab_pin.sym} 86430 -690 0 1 {name=p86234 lab=_82161_/Q }
C {sky130_stdcells/dfxtp_4.sym} 86340 -680 0 0 {name=X_82161_ }
C {devices/lab_pin.sym} 87220 -42150 0 0 {name=p86235 lab=clkbuf_9_283_0_CLK/A }
C {devices/lab_pin.sym} 87300 -42150 0 1 {name=p86236 lab=clkbuf_9_283_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 87260 -42150 0 0 {name=Xclkbuf_9_283_0_CLK }
C {devices/lab_pin.sym} 87220 -42030 0 0 {name=p86237 lab=_60459_/B }
C {devices/lab_pin.sym} 87300 -42030 0 1 {name=p86238 lab=_60541_/B }
C {sky130_stdcells/buf_2.sym} 87260 -42030 0 0 {name=X_60539_ }
C {devices/lab_pin.sym} 87200 -41920 0 0 {name=p86239 lab=_67095_/A }
C {devices/lab_pin.sym} 87200 -41880 0 0 {name=p86240 lab=_67095_/B }
C {devices/lab_pin.sym} 87320 -41900 0 1 {name=p86241 lab=_67095_/X }
C {sky130_stdcells/and2_4.sym} 87260 -41900 0 0 {name=X_67095_ }
C {devices/lab_pin.sym} 87170 -41770 0 0 {name=p86242 lab=_80696_/CLK }
C {devices/lab_pin.sym} 87170 -41750 0 0 {name=p86243 lab=_79793_/X }
C {devices/lab_pin.sym} 87350 -41770 0 1 {name=p86244 lab=_81112_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -41760 0 0 {name=X_81112_ }
C {devices/lab_pin.sym} 87220 -41630 0 0 {name=p86245 lab=_53982_/A }
C {devices/lab_pin.sym} 87300 -41630 0 1 {name=p86246 lab=_54060_/X }
C {sky130_stdcells/buf_2.sym} 87260 -41630 0 0 {name=X_54060_ }
C {devices/lab_pin.sym} 87220 -41510 0 0 {name=p86247 lab=_66046_/A }
C {devices/lab_pin.sym} 87300 -41510 0 1 {name=p86248 lab=_66164_/A }
C {sky130_stdcells/buf_2.sym} 87260 -41510 0 0 {name=X_66046_ }
C {devices/lab_pin.sym} 87220 -41390 0 0 {name=p86249 lab=clkbuf_9_88_0_CLK/X }
C {devices/lab_pin.sym} 87300 -41390 0 1 {name=p86250 lab=_80721_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 87260 -41390 0 0 {name=Xclkbuf_10_177_0_CLK }
C {devices/lab_pin.sym} 87200 -41280 0 0 {name=p86251 lab=_51280_/A }
C {devices/lab_pin.sym} 87200 -41240 0 0 {name=p86252 lab=_49241_/B }
C {devices/lab_pin.sym} 87320 -41260 0 1 {name=p86253 lab=_51272_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -41260 0 0 {name=X_51272_ }
C {devices/lab_pin.sym} 87220 -41130 0 0 {name=p86254 lab=_64314_/A }
C {devices/lab_pin.sym} 87300 -41130 0 1 {name=p86255 lab=_63258_/X }
C {sky130_stdcells/buf_2.sym} 87260 -41130 0 0 {name=X_63258_ }
C {devices/lab_pin.sym} 87170 -41010 0 0 {name=p86256 lab=_82103_/CLK }
C {devices/lab_pin.sym} 87170 -40990 0 0 {name=p86257 lab=_77376_/B }
C {devices/lab_pin.sym} 87350 -41010 0 1 {name=p86258 lab=_82092_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -41000 0 0 {name=X_82092_ }
C {devices/lab_pin.sym} 87220 -40870 0 0 {name=p86259 lab=_52903_/X }
C {devices/lab_pin.sym} 87300 -40870 0 1 {name=p86260 lab=_53025_/A }
C {sky130_stdcells/buf_2.sym} 87260 -40870 0 0 {name=X_53011_ }
C {devices/lab_pin.sym} 87220 -40750 0 0 {name=p86261 lab=_50222_/X }
C {devices/lab_pin.sym} 87300 -40750 0 1 {name=p86262 lab=_51737_/A }
C {sky130_stdcells/buf_2.sym} 87260 -40750 0 0 {name=X_50223_ }
C {devices/lab_pin.sym} 87170 -40630 0 0 {name=p86263 lab=_85920_/CLK }
C {devices/lab_pin.sym} 87170 -40610 0 0 {name=p86264 lab=_85920_/D }
C {devices/lab_pin.sym} 87350 -40630 0 1 {name=p86265 lab=_73583_/B }
C {sky130_stdcells/dfxtp_4.sym} 87260 -40620 0 0 {name=X_85920_ }
C {devices/lab_pin.sym} 87170 -40490 0 0 {name=p86266 lab=_80719_/CLK }
C {devices/lab_pin.sym} 87170 -40470 0 0 {name=p86267 lab=_75328_/X }
C {devices/lab_pin.sym} 87350 -40490 0 1 {name=p86268 lab=_81043_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -40480 0 0 {name=X_81043_ }
C {devices/lab_pin.sym} 87220 -40350 0 0 {name=p86269 lab=_62522_/B }
C {devices/lab_pin.sym} 87300 -40350 0 1 {name=p86270 lab=_62560_/C }
C {sky130_stdcells/buf_2.sym} 87260 -40350 0 0 {name=X_62209_ }
C {devices/lab_pin.sym} 87220 -40230 0 0 {name=p86271 lab=_64314_/A }
C {devices/lab_pin.sym} 87300 -40230 0 1 {name=p86272 lab=_63189_/X }
C {sky130_stdcells/buf_2.sym} 87260 -40230 0 0 {name=X_63189_ }
C {devices/lab_pin.sym} 87220 -40110 0 0 {name=p86273 lab=clkbuf_9_299_0_CLK/A }
C {devices/lab_pin.sym} 87300 -40110 0 1 {name=p86274 lab=clkbuf_9_298_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 87260 -40110 0 0 {name=Xclkbuf_9_298_0_CLK }
C {devices/lab_pin.sym} 87200 -40000 0 0 {name=p86275 lab=_69791_/A }
C {devices/lab_pin.sym} 87200 -39960 0 0 {name=p86276 lab=_69804_/Y }
C {devices/lab_pin.sym} 87320 -39980 0 1 {name=p86277 lab=_69805_/Y }
C {sky130_stdcells/nor2_4.sym} 87260 -39980 0 0 {name=X_69805_ }
C {devices/lab_pin.sym} 87180 -39870 0 0 {name=p86278 lab=_86253_/Q }
C {devices/lab_pin.sym} 87180 -39830 0 0 {name=p86279 lab=_50137_/X }
C {devices/lab_pin.sym} 87180 -39790 0 0 {name=p86280 lab=_50153_/Y }
C {devices/lab_pin.sym} 87340 -39830 0 1 {name=p86281 lab=_50154_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -39830 0 0 {name=X_50154_ }
C {devices/lab_pin.sym} 87220 -39690 0 0 {name=p86282 lab=clkbuf_7_52_0_CLK/X }
C {devices/lab_pin.sym} 87300 -39690 0 1 {name=p86283 lab=clkbuf_9_210_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 87260 -39690 0 0 {name=Xclkbuf_8_105_0_CLK }
C {devices/lab_pin.sym} 87170 -39570 0 0 {name=p86284 lab=_83310_/CLK }
C {devices/lab_pin.sym} 87170 -39550 0 0 {name=p86285 lab=_52296_/Y }
C {devices/lab_pin.sym} 87350 -39570 0 1 {name=p86286 lab=_85851_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -39560 0 0 {name=X_85851_ }
C {devices/lab_pin.sym} 87220 -39430 0 0 {name=p86287 lab=clkbuf_9_50_0_CLK/X }
C {devices/lab_pin.sym} 87300 -39430 0 1 {name=p86288 lab=_86878_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 87260 -39430 0 0 {name=Xclkbuf_10_100_0_CLK }
C {devices/lab_pin.sym} 87220 -39310 0 0 {name=p86289 lab=_67997_/A }
C {devices/lab_pin.sym} 87300 -39310 0 1 {name=p86290 lab=_67997_/X }
C {sky130_stdcells/buf_2.sym} 87260 -39310 0 0 {name=X_67997_ }
C {devices/lab_pin.sym} 87170 -39190 0 0 {name=p86291 lab=_84802_/CLK }
C {devices/lab_pin.sym} 87170 -39170 0 0 {name=p86292 lab=_84802_/D }
C {devices/lab_pin.sym} 87350 -39190 0 1 {name=p86293 lab=_84802_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -39180 0 0 {name=X_84802_ }
C {devices/lab_pin.sym} 87220 -39050 0 0 {name=p86294 lab=clkbuf_9_365_0_CLK/X }
C {devices/lab_pin.sym} 87300 -39050 0 1 {name=p86295 lab=_87766_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 87260 -39050 0 0 {name=Xclkbuf_10_730_0_CLK }
C {devices/lab_pin.sym} 87180 -38950 0 0 {name=p86296 lab=_57726_/X }
C {devices/lab_pin.sym} 87180 -38910 0 0 {name=p86297 lab=_86014_/Q }
C {devices/lab_pin.sym} 87180 -38870 0 0 {name=p86298 lab=_57749_/X }
C {devices/lab_pin.sym} 87340 -38910 0 1 {name=p86299 lab=_57750_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -38910 0 0 {name=X_57750_ }
C {devices/lab_pin.sym} 87180 -38800 0 0 {name=p86300 lab=_73106_/A }
C {devices/lab_pin.sym} 87180 -38760 0 0 {name=p86301 lab=_69645_/X }
C {devices/lab_pin.sym} 87180 -38720 0 0 {name=p86302 lab=_69478_/X }
C {devices/lab_pin.sym} 87180 -38680 0 0 {name=p86303 lab=_69735_/Y }
C {devices/lab_pin.sym} 87340 -38740 0 1 {name=p86304 lab=_69736_/X }
C {sky130_stdcells/a211o_4.sym} 87260 -38740 0 0 {name=X_69736_ }
C {devices/lab_pin.sym} 87180 -38610 0 0 {name=p86305 lab=_86267_/Q }
C {devices/lab_pin.sym} 87180 -38570 0 0 {name=p86306 lab=_50061_/X }
C {devices/lab_pin.sym} 87180 -38530 0 0 {name=p86307 lab=_50084_/Y }
C {devices/lab_pin.sym} 87340 -38570 0 1 {name=p86308 lab=_50085_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -38570 0 0 {name=X_50085_ }
C {devices/lab_pin.sym} 87180 -38450 0 0 {name=p86309 lab=_85344_/Q }
C {devices/lab_pin.sym} 87180 -38410 0 0 {name=p86310 lab=_54249_/X }
C {devices/lab_pin.sym} 87180 -38370 0 0 {name=p86311 lab=_54961_/Y }
C {devices/lab_pin.sym} 87340 -38410 0 1 {name=p86312 lab=_54962_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -38410 0 0 {name=X_54962_ }
C {devices/lab_pin.sym} 87200 -38280 0 0 {name=p86313 lab=_66851_/X }
C {devices/lab_pin.sym} 87200 -38240 0 0 {name=p86314 lab=_66948_/B }
C {devices/lab_pin.sym} 87320 -38260 0 1 {name=p86315 lab=_66948_/X }
C {sky130_stdcells/and2_4.sym} 87260 -38260 0 0 {name=X_66948_ }
C {devices/lab_pin.sym} 87170 -38130 0 0 {name=p86316 lab=_82956_/CLK }
C {devices/lab_pin.sym} 87170 -38110 0 0 {name=p86317 lab=_52640_/Y }
C {devices/lab_pin.sym} 87350 -38130 0 1 {name=p86318 lab=_85782_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -38120 0 0 {name=X_85782_ }
C {devices/lab_pin.sym} 87170 -37990 0 0 {name=p86319 lab=_82993_/CLK }
C {devices/lab_pin.sym} 87170 -37970 0 0 {name=p86320 lab=_74659_/Y }
C {devices/lab_pin.sym} 87350 -37990 0 1 {name=p86321 lab=_82994_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -37980 0 0 {name=X_82994_ }
C {devices/lab_pin.sym} 87180 -37890 0 0 {name=p86322 lab=_56700_/Y }
C {devices/lab_pin.sym} 87180 -37850 0 0 {name=p86323 lab=_83327_/Q }
C {devices/lab_pin.sym} 87180 -37810 0 0 {name=p86324 lab=_56682_/X }
C {devices/lab_pin.sym} 87180 -37770 0 0 {name=p86325 lab=_56674_/X }
C {devices/lab_pin.sym} 87180 -37740 0 0 {name=p86326 lab=_57270_/A }
C {devices/lab_pin.sym} 87340 -37810 0 1 {name=p86327 lab=_56702_/A }
C {sky130_stdcells/a41o_4.sym} 87260 -37810 0 0 {name=X_56701_ }
C {devices/lab_pin.sym} 87170 -37650 0 0 {name=p86328 lab=_87525_/CLK }
C {devices/lab_pin.sym} 87170 -37630 0 0 {name=p86329 lab=_87521_/D }
C {devices/lab_pin.sym} 87350 -37650 0 1 {name=p86330 lab=_87521_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -37640 0 0 {name=X_87521_ }
C {devices/lab_pin.sym} 87180 -37530 0 0 {name=p86331 lab=_85543_/Q }
C {devices/lab_pin.sym} 87180 -37490 0 0 {name=p86332 lab=_53896_/X }
C {devices/lab_pin.sym} 87180 -37450 0 0 {name=p86333 lab=_53912_/Y }
C {devices/lab_pin.sym} 87340 -37490 0 1 {name=p86334 lab=_53913_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -37490 0 0 {name=X_53913_ }
C {devices/lab_pin.sym} 87170 -37350 0 0 {name=p86335 lab=_84903_/CLK }
C {devices/lab_pin.sym} 87170 -37330 0 0 {name=p86336 lab=_59438_/Y }
C {devices/lab_pin.sym} 87350 -37350 0 1 {name=p86337 lab=_64526_/B }
C {sky130_stdcells/dfxtp_4.sym} 87260 -37340 0 0 {name=X_84733_ }
C {devices/lab_pin.sym} 87220 -37210 0 0 {name=p86338 lab=clkbuf_9_220_0_CLK/A }
C {devices/lab_pin.sym} 87300 -37210 0 1 {name=p86339 lab=clkbuf_9_221_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 87260 -37210 0 0 {name=Xclkbuf_9_221_0_CLK }
C {devices/lab_pin.sym} 87180 -37110 0 0 {name=p86340 lab=_57677_/X }
C {devices/lab_pin.sym} 87180 -37070 0 0 {name=p86341 lab=_57678_/Y }
C {devices/lab_pin.sym} 87180 -37030 0 0 {name=p86342 lab=_57680_/Y }
C {devices/lab_pin.sym} 87340 -37070 0 1 {name=p86343 lab=_84955_/D }
C {sky130_stdcells/a21oi_4.sym} 87260 -37070 0 0 {name=X_57681_ }
C {devices/lab_pin.sym} 87170 -36930 0 0 {name=p86344 lab=_82133_/CLK }
C {devices/lab_pin.sym} 87170 -36910 0 0 {name=p86345 lab=_77946_/Y }
C {devices/lab_pin.sym} 87350 -36930 0 1 {name=p86346 lab=_81945_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -36920 0 0 {name=X_81945_ }
C {devices/lab_pin.sym} 87180 -36820 0 0 {name=p86347 lab=_87064_/Q }
C {devices/lab_pin.sym} 87180 -36780 0 0 {name=p86348 lab=_69664_/X }
C {devices/lab_pin.sym} 87180 -36740 0 0 {name=p86349 lab=_69665_/X }
C {devices/lab_pin.sym} 87180 -36700 0 0 {name=p86350 lab=_69666_/X }
C {devices/lab_pin.sym} 87340 -36760 0 1 {name=p86351 lab=_69668_/B }
C {sky130_stdcells/a211o_4.sym} 87260 -36760 0 0 {name=X_69667_ }
C {devices/lab_pin.sym} 87220 -36610 0 0 {name=p86352 lab=_54919_/A }
C {devices/lab_pin.sym} 87300 -36610 0 1 {name=p86353 lab=_54893_/X }
C {sky130_stdcells/buf_2.sym} 87260 -36610 0 0 {name=X_54893_ }
C {devices/lab_pin.sym} 87220 -36490 0 0 {name=p86354 lab=_66879_/A }
C {devices/lab_pin.sym} 87300 -36490 0 1 {name=p86355 lab=_66879_/X }
C {sky130_stdcells/buf_2.sym} 87260 -36490 0 0 {name=X_66879_ }
C {devices/lab_pin.sym} 87220 -36370 0 0 {name=p86356 lab=_59398_/A }
C {devices/lab_pin.sym} 87300 -36370 0 1 {name=p86357 lab=_59424_/B }
C {sky130_stdcells/buf_2.sym} 87260 -36370 0 0 {name=X_59420_ }
C {devices/lab_pin.sym} 87200 -36270 0 0 {name=p86358 lab=_56650_/B }
C {devices/lab_pin.sym} 87200 -36230 0 0 {name=p86359 lab=_55467_/X }
C {devices/lab_pin.sym} 87200 -36190 0 0 {name=p86360 lab=_55646_/X }
C {devices/lab_pin.sym} 87320 -36230 0 1 {name=p86361 lab=_56632_/Y }
C {sky130_stdcells/nand3_4.sym} 87260 -36230 0 0 {name=X_56632_ }
C {devices/lab_pin.sym} 87200 -36100 0 0 {name=p86362 lab=_57804_/A }
C {devices/lab_pin.sym} 87200 -36060 0 0 {name=p86363 lab=_68618_/B }
C {devices/lab_pin.sym} 87320 -36080 0 1 {name=p86364 lab=_68618_/Y }
C {sky130_stdcells/nor2_4.sym} 87260 -36080 0 0 {name=X_68618_ }
C {devices/lab_pin.sym} 87170 -35950 0 0 {name=p86365 lab=_87446_/CLK }
C {devices/lab_pin.sym} 87170 -35930 0 0 {name=p86366 lab=_87452_/D }
C {devices/lab_pin.sym} 87350 -35950 0 1 {name=p86367 lab=_87452_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -35940 0 0 {name=X_87452_ }
C {devices/lab_pin.sym} 87220 -35810 0 0 {name=p86368 lab=clkbuf_9_57_0_CLK/X }
C {devices/lab_pin.sym} 87300 -35810 0 1 {name=p86369 lab=_84426_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 87260 -35810 0 0 {name=Xclkbuf_10_115_0_CLK }
C {devices/lab_pin.sym} 87200 -35700 0 0 {name=p86370 lab=_53844_/A }
C {devices/lab_pin.sym} 87200 -35660 0 0 {name=p86371 lab=_53844_/B }
C {devices/lab_pin.sym} 87320 -35680 0 1 {name=p86372 lab=_53844_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -35680 0 0 {name=X_53844_ }
C {devices/lab_pin.sym} 87170 -35550 0 0 {name=p86373 lab=_84671_/CLK }
C {devices/lab_pin.sym} 87170 -35530 0 0 {name=p86374 lab=_84664_/D }
C {devices/lab_pin.sym} 87350 -35550 0 1 {name=p86375 lab=_60089_/C }
C {sky130_stdcells/dfxtp_4.sym} 87260 -35540 0 0 {name=X_84664_ }
C {devices/lab_pin.sym} 87170 -35410 0 0 {name=p86376 lab=_81839_/CLK }
C {devices/lab_pin.sym} 87170 -35390 0 0 {name=p86377 lab=_78067_/X }
C {devices/lab_pin.sym} 87350 -35410 0 1 {name=p86378 lab=_81876_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -35400 0 0 {name=X_81876_ }
C {devices/lab_pin.sym} 87180 -35300 0 0 {name=p86379 lab=_87069_/Q }
C {devices/lab_pin.sym} 87180 -35260 0 0 {name=p86380 lab=_66550_/X }
C {devices/lab_pin.sym} 87180 -35220 0 0 {name=p86381 lab=_66552_/X }
C {devices/lab_pin.sym} 87180 -35180 0 0 {name=p86382 lab=_69597_/X }
C {devices/lab_pin.sym} 87340 -35240 0 1 {name=p86383 lab=_69598_/X }
C {sky130_stdcells/a211o_4.sym} 87260 -35240 0 0 {name=X_69598_ }
C {devices/lab_pin.sym} 87220 -35090 0 0 {name=p86384 lab=clkbuf_9_372_0_CLK/X }
C {devices/lab_pin.sym} 87300 -35090 0 1 {name=p86385 lab=_87993_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 87260 -35090 0 0 {name=Xclkbuf_10_745_0_CLK }
C {devices/lab_pin.sym} 87170 -34970 0 0 {name=p86386 lab=_86404_/CLK }
C {devices/lab_pin.sym} 87170 -34950 0 0 {name=p86387 lab=_86403_/D }
C {devices/lab_pin.sym} 87350 -34970 0 1 {name=p86388 lab=_65381_/B }
C {sky130_stdcells/dfxtp_4.sym} 87260 -34960 0 0 {name=X_86403_ }
C {devices/lab_pin.sym} 87170 -34830 0 0 {name=p86389 lab=_85562_/CLK }
C {devices/lab_pin.sym} 87170 -34810 0 0 {name=p86390 lab=_71079_/Y }
C {devices/lab_pin.sym} 87350 -34830 0 1 {name=p86391 lab=_83615_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -34820 0 0 {name=X_83615_ }
C {devices/lab_pin.sym} 87220 -34690 0 0 {name=p86392 lab=_72201_/A }
C {devices/lab_pin.sym} 87300 -34690 0 1 {name=p86393 lab=_59351_/X }
C {sky130_stdcells/buf_2.sym} 87260 -34690 0 0 {name=X_59351_ }
C {devices/lab_pin.sym} 87220 -34570 0 0 {name=p86394 lab=_56774_/C }
C {devices/lab_pin.sym} 87300 -34570 0 1 {name=p86395 lab=_56798_/B }
C {sky130_stdcells/buf_2.sym} 87260 -34570 0 0 {name=X_56563_ }
C {devices/lab_pin.sym} 87170 -34450 0 0 {name=p86396 lab=_81065_/CLK }
C {devices/lab_pin.sym} 87170 -34430 0 0 {name=p86397 lab=_80827_/D }
C {devices/lab_pin.sym} 87350 -34450 0 1 {name=p86398 lab=_75650_/B }
C {sky130_stdcells/dfxtp_4.sym} 87260 -34440 0 0 {name=X_80827_ }
C {devices/lab_pin.sym} 87200 -34320 0 0 {name=p86399 lab=_65381_/A }
C {devices/lab_pin.sym} 87200 -34280 0 0 {name=p86400 lab=_68549_/B }
C {devices/lab_pin.sym} 87320 -34300 0 1 {name=p86401 lab=_68549_/X }
C {sky130_stdcells/and2_4.sym} 87260 -34300 0 0 {name=X_68549_ }
C {devices/lab_pin.sym} 87170 -34170 0 0 {name=p86402 lab=_87189_/CLK }
C {devices/lab_pin.sym} 87170 -34150 0 0 {name=p86403 lab=_43512_/X }
C {devices/lab_pin.sym} 87350 -34170 0 1 {name=p86404 lab=_87383_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -34160 0 0 {name=X_87383_ }
C {devices/lab_pin.sym} 87180 -34050 0 0 {name=p86405 lab=_53771_/Y }
C {devices/lab_pin.sym} 87180 -34010 0 0 {name=p86406 lab=_53773_/X }
C {devices/lab_pin.sym} 87180 -33970 0 0 {name=p86407 lab=_53774_/X }
C {devices/lab_pin.sym} 87340 -34010 0 1 {name=p86408 lab=_53775_/Y }
C {sky130_stdcells/a21oi_4.sym} 87260 -34010 0 0 {name=X_53775_ }
C {devices/lab_pin.sym} 87170 -33870 0 0 {name=p86409 lab=_84469_/CLK }
C {devices/lab_pin.sym} 87170 -33850 0 0 {name=p86410 lab=_60582_/Y }
C {devices/lab_pin.sym} 87350 -33870 0 1 {name=p86411 lab=_79135_/A }
C {sky130_stdcells/dfxtp_4.sym} 87260 -33860 0 0 {name=X_84595_ }
C {devices/lab_pin.sym} 87200 -33740 0 0 {name=p86412 lab=_50971_/A }
C {devices/lab_pin.sym} 87200 -33700 0 0 {name=p86413 lab=_50987_/B }
C {devices/lab_pin.sym} 87320 -33720 0 1 {name=p86414 lab=_50987_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -33720 0 0 {name=X_50987_ }
C {devices/lab_pin.sym} 87180 -33610 0 0 {name=p86415 lab=_58282_/X }
C {devices/lab_pin.sym} 87180 -33570 0 0 {name=p86416 lab=_58298_/Y }
C {devices/lab_pin.sym} 87180 -33530 0 0 {name=p86417 lab=_58301_/Y }
C {devices/lab_pin.sym} 87340 -33570 0 1 {name=p86418 lab=_84884_/D }
C {sky130_stdcells/a21oi_4.sym} 87260 -33570 0 0 {name=X_58302_ }
C {devices/lab_pin.sym} 87220 -33430 0 0 {name=p86419 lab=clkbuf_8_118_0_CLK/X }
C {devices/lab_pin.sym} 87300 -33430 0 1 {name=p86420 lab=clkbuf_9_236_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 87260 -33430 0 0 {name=Xclkbuf_9_236_0_CLK }
C {devices/lab_pin.sym} 87200 -33320 0 0 {name=p86421 lab=_55507_/X }
C {devices/lab_pin.sym} 87200 -33280 0 0 {name=p86422 lab=_55514_/B }
C {devices/lab_pin.sym} 87320 -33300 0 1 {name=p86423 lab=_55514_/Y }
C {sky130_stdcells/nor2_4.sym} 87260 -33300 0 0 {name=X_55514_ }
C {devices/lab_pin.sym} 87170 -33170 0 0 {name=p86424 lab=_86655_/CLK }
C {devices/lab_pin.sym} 87170 -33150 0 0 {name=p86425 lab=_86334_/D }
C {devices/lab_pin.sym} 87350 -33170 0 1 {name=p86426 lab=_86334_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -33160 0 0 {name=X_86334_ }
C {devices/lab_pin.sym} 87180 -33060 0 0 {name=p86427 lab=_40739_/X }
C {devices/lab_pin.sym} 87180 -33020 0 0 {name=p86428 lab=_40719_/X }
C {devices/lab_pin.sym} 87180 -32980 0 0 {name=p86429 lab=_88344_/Q }
C {devices/lab_pin.sym} 87180 -32940 0 0 {name=p86430 lab=_40720_/X }
C {devices/lab_pin.sym} 87340 -33000 0 1 {name=p86431 lab=_40740_/X }
C {sky130_stdcells/a2bb2o_4.sym} 87260 -33000 0 0 {name=X_40740_ }
C {devices/lab_pin.sym} 87200 -32860 0 0 {name=p86432 lab=_52718_/A }
C {devices/lab_pin.sym} 87200 -32820 0 0 {name=p86433 lab=_52726_/B }
C {devices/lab_pin.sym} 87320 -32840 0 1 {name=p86434 lab=_52726_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -32840 0 0 {name=X_52726_ }
C {devices/lab_pin.sym} 87200 -32720 0 0 {name=p86435 lab=_86666_/Q }
C {devices/lab_pin.sym} 87200 -32680 0 0 {name=p86436 lab=_59282_/B }
C {devices/lab_pin.sym} 87320 -32700 0 1 {name=p86437 lab=_59282_/Y }
C {sky130_stdcells/nor2_4.sym} 87260 -32700 0 0 {name=X_59282_ }
C {devices/lab_pin.sym} 87180 -32590 0 0 {name=p86438 lab=_71557_/X }
C {devices/lab_pin.sym} 87180 -32550 0 0 {name=p86439 lab=_83457_/Q }
C {devices/lab_pin.sym} 87180 -32510 0 0 {name=p86440 lab=_71559_/Y }
C {devices/lab_pin.sym} 87340 -32550 0 1 {name=p86441 lab=_83457_/D }
C {sky130_stdcells/a21o_4.sym} 87260 -32550 0 0 {name=X_71560_ }
C {devices/lab_pin.sym} 87170 -32410 0 0 {name=p86442 lab=_85354_/CLK }
C {devices/lab_pin.sym} 87170 -32390 0 0 {name=p86443 lab=_71286_/Y }
C {devices/lab_pin.sym} 87350 -32410 0 1 {name=p86444 lab=_83546_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -32400 0 0 {name=X_83546_ }
C {devices/lab_pin.sym} 87200 -32290 0 0 {name=p86445 lab=_56487_/X }
C {devices/lab_pin.sym} 87200 -32250 0 0 {name=p86446 lab=_56484_/X }
C {devices/lab_pin.sym} 87200 -32210 0 0 {name=p86447 lab=_56494_/C }
C {devices/lab_pin.sym} 87320 -32250 0 1 {name=p86448 lab=_56494_/Y }
C {sky130_stdcells/nand3_4.sym} 87260 -32250 0 0 {name=X_56494_ }
C {devices/lab_pin.sym} 87170 -32110 0 0 {name=p86449 lab=_81134_/CLK }
C {devices/lab_pin.sym} 87170 -32090 0 0 {name=p86450 lab=_80758_/D }
C {devices/lab_pin.sym} 87350 -32110 0 1 {name=p86451 lab=_81134_/D }
C {sky130_stdcells/dfxtp_4.sym} 87260 -32100 0 0 {name=X_80758_ }
C {devices/lab_pin.sym} 87200 -31990 0 0 {name=p86452 lab=_70511_/A }
C {devices/lab_pin.sym} 87200 -31950 0 0 {name=p86453 lab=_70374_/X }
C {devices/lab_pin.sym} 87200 -31910 0 0 {name=p86454 lab=_70508_/X }
C {devices/lab_pin.sym} 87320 -31950 0 1 {name=p86455 lab=_70511_/Y }
C {sky130_stdcells/nand3_4.sym} 87260 -31950 0 0 {name=X_70511_ }
C {devices/lab_pin.sym} 87220 -31810 0 0 {name=p86456 lab=_83397_/Q }
C {devices/lab_pin.sym} 87300 -31810 0 1 {name=p86457 lab=_58233_/Y }
C {sky130_stdcells/inv_2.sym} 87260 -31810 0 0 {name=X_58233_ }
C {devices/lab_pin.sym} 87200 -31720 0 0 {name=p86458 lab=_55445_/A }
C {devices/lab_pin.sym} 87200 -31680 0 0 {name=p86459 lab=_55445_/B }
C {devices/lab_pin.sym} 87200 -31640 0 0 {name=p86460 lab=_55445_/C }
C {devices/lab_pin.sym} 87200 -31600 0 0 {name=p86461 lab=_55445_/D }
C {devices/lab_pin.sym} 87320 -31660 0 1 {name=p86462 lab=_55446_/A }
C {sky130_stdcells/and4_4.sym} 87260 -31660 0 0 {name=X_55445_ }
C {devices/lab_pin.sym} 87170 -31510 0 0 {name=p86463 lab=_85562_/CLK }
C {devices/lab_pin.sym} 87170 -31490 0 0 {name=p86464 lab=_86265_/D }
C {devices/lab_pin.sym} 87350 -31510 0 1 {name=p86465 lab=_86265_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -31500 0 0 {name=X_86265_ }
C {sky130_stdcells/decap_3.sym} 87260 -31340 0 0 {name=XPHY_601 }
C {devices/lab_pin.sym} 87200 -31200 0 0 {name=p86466 lab=_40671_/A }
C {devices/lab_pin.sym} 87200 -31160 0 0 {name=p86467 lab=_40588_/B }
C {devices/lab_pin.sym} 87320 -31180 0 1 {name=p86468 lab=_40671_/X }
C {sky130_stdcells/or2_4.sym} 87260 -31180 0 0 {name=X_40671_ }
C {devices/lab_pin.sym} 87220 -31050 0 0 {name=p86469 lab=_52657_/A }
C {devices/lab_pin.sym} 87300 -31050 0 1 {name=p86470 lab=_52657_/X }
C {sky130_stdcells/buf_2.sym} 87260 -31050 0 0 {name=X_52657_ }
C {devices/lab_pin.sym} 87220 -30930 0 0 {name=p86471 lab=_71483_/B }
C {devices/lab_pin.sym} 87300 -30930 0 1 {name=p86472 lab=_71496_/C }
C {sky130_stdcells/buf_2.sym} 87260 -30930 0 0 {name=X_71491_ }
C {devices/lab_pin.sym} 87170 -30810 0 0 {name=p86473 lab=_83414_/CLK }
C {devices/lab_pin.sym} 87170 -30790 0 0 {name=p86474 lab=_83477_/D }
C {devices/lab_pin.sym} 87350 -30810 0 1 {name=p86475 lab=_83477_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -30800 0 0 {name=X_83477_ }
C {sky130_stdcells/decap_3.sym} 87260 -30640 0 0 {name=XPHY_612 }
C {devices/lab_pin.sym} 87170 -30490 0 0 {name=p86476 lab=_81074_/CLK }
C {devices/lab_pin.sym} 87170 -30470 0 0 {name=p86477 lab=_80721_/Q }
C {devices/lab_pin.sym} 87350 -30490 0 1 {name=p86478 lab=_75288_/A }
C {sky130_stdcells/dfxtp_4.sym} 87260 -30480 0 0 {name=X_80689_ }
C {sky130_stdcells/decap_3.sym} 87260 -30320 0 0 {name=XPHY_623 }
C {devices/lab_pin.sym} 87170 -30170 0 0 {name=p86479 lab=_87249_/CLK }
C {devices/lab_pin.sym} 87170 -30150 0 0 {name=p86480 lab=_88004_/D }
C {devices/lab_pin.sym} 87350 -30170 0 1 {name=p86481 lab=_88004_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -30160 0 0 {name=X_88004_ }
C {devices/lab_pin.sym} 87220 -30030 0 0 {name=p86482 lab=_42397_/A }
C {devices/lab_pin.sym} 87300 -30030 0 1 {name=p86483 lab=_42410_/X }
C {sky130_stdcells/buf_2.sym} 87260 -30030 0 0 {name=X_42410_ }
C {sky130_stdcells/decap_3.sym} 87260 -29880 0 0 {name=XPHY_634 }
C {devices/lab_pin.sym} 87180 -29750 0 0 {name=p86484 lab=_73226_/X }
C {devices/lab_pin.sym} 87180 -29710 0 0 {name=p86485 lab=_73229_/X }
C {devices/lab_pin.sym} 87180 -29670 0 0 {name=p86486 lab=_73200_/X }
C {devices/lab_pin.sym} 87340 -29710 0 1 {name=p86487 lab=_73230_/X }
C {sky130_stdcells/a21o_4.sym} 87260 -29710 0 0 {name=X_73230_ }
C {devices/lab_pin.sym} 87170 -29570 0 0 {name=p86488 lab=_85184_/CLK }
C {devices/lab_pin.sym} 87170 -29550 0 0 {name=p86489 lab=_56380_/Y }
C {devices/lab_pin.sym} 87350 -29570 0 1 {name=p86490 lab=_56379_/C }
C {sky130_stdcells/dfxtp_4.sym} 87260 -29560 0 0 {name=X_85216_ }
C {devices/lab_pin.sym} 87220 -29430 0 0 {name=p86491 lab=_51608_/A }
C {devices/lab_pin.sym} 87300 -29430 0 1 {name=p86492 lab=_51608_/X }
C {sky130_stdcells/buf_2.sym} 87260 -29430 0 0 {name=X_51608_ }
C {devices/lab_pin.sym} 87200 -29330 0 0 {name=p86493 lab=_70442_/A }
C {devices/lab_pin.sym} 87200 -29290 0 0 {name=p86494 lab=_70949_/B }
C {devices/lab_pin.sym} 87200 -29250 0 0 {name=p86495 lab=_71194_/C }
C {devices/lab_pin.sym} 87320 -29290 0 1 {name=p86496 lab=_70442_/Y }
C {sky130_stdcells/nand3_4.sym} 87260 -29290 0 0 {name=X_70442_ }
C {devices/lab_pin.sym} 87170 -29150 0 0 {name=p86497 lab=_82692_/CLK }
C {devices/lab_pin.sym} 87170 -29130 0 0 {name=p86498 lab=_82428_/D }
C {devices/lab_pin.sym} 87350 -29150 0 1 {name=p86499 lab=_78691_/A }
C {sky130_stdcells/dfxtp_4.sym} 87260 -29140 0 0 {name=X_82428_ }
C {devices/lab_pin.sym} 87200 -29020 0 0 {name=p86500 lab=_64257_/A }
C {devices/lab_pin.sym} 87200 -28980 0 0 {name=p86501 lab=_58160_/B }
C {devices/lab_pin.sym} 87320 -29000 0 1 {name=p86502 lab=_58164_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -29000 0 0 {name=X_58164_ }
C {sky130_stdcells/decap_3.sym} 87260 -28840 0 0 {name=XPHY_645 }
C {devices/lab_pin.sym} 87180 -28730 0 0 {name=p86503 lab=_43367_/X }
C {devices/lab_pin.sym} 87180 -28690 0 0 {name=p86504 lab=_43375_/X }
C {devices/lab_pin.sym} 87180 -28650 0 0 {name=p86505 lab=_41442_/X }
C {devices/lab_pin.sym} 87180 -28610 0 0 {name=p86506 lab=_87446_/Q }
C {devices/lab_pin.sym} 87180 -28570 0 0 {name=p86507 lab=_43378_/X }
C {devices/lab_pin.sym} 87340 -28650 0 1 {name=p86508 lab=_43390_/Y }
C {sky130_stdcells/o32ai_4.sym} 87260 -28650 0 0 {name=X_43390_ }
C {devices/lab_pin.sym} 87220 -28490 0 0 {name=p86509 lab=_55375_/Y }
C {devices/lab_pin.sym} 87300 -28490 0 1 {name=p86510 lab=_55383_/A }
C {sky130_stdcells/inv_2.sym} 87260 -28490 0 0 {name=X_55376_ }
C {devices/lab_pin.sym} 87170 -28370 0 0 {name=p86511 lab=_86196_/CLK }
C {devices/lab_pin.sym} 87170 -28350 0 0 {name=p86512 lab=_50463_/Y }
C {devices/lab_pin.sym} 87350 -28370 0 1 {name=p86513 lab=_86196_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -28360 0 0 {name=X_86196_ }
C {sky130_stdcells/decap_3.sym} 87260 -28200 0 0 {name=XPHY_656 }
C {devices/lab_pin.sym} 87200 -28080 0 0 {name=p86514 lab=_52588_/A }
C {devices/lab_pin.sym} 87200 -28040 0 0 {name=p86515 lab=_52594_/B }
C {devices/lab_pin.sym} 87200 -28000 0 0 {name=p86516 lab=_51919_/C }
C {devices/lab_pin.sym} 87200 -27960 0 0 {name=p86517 lab=_51761_/D }
C {devices/lab_pin.sym} 87320 -28020 0 1 {name=p86518 lab=_52588_/X }
C {sky130_stdcells/and4_4.sym} 87260 -28020 0 0 {name=X_52588_ }
C {sky130_stdcells/decap_3.sym} 87260 -27840 0 0 {name=XPHY_667 }
C {sky130_stdcells/decap_3.sym} 87260 -27660 0 0 {name=XPHY_678 }
C {devices/lab_pin.sym} 87180 -27540 0 0 {name=p86519 lab=_57109_/X }
C {devices/lab_pin.sym} 87180 -27500 0 0 {name=p86520 lab=_56619_/X }
C {devices/lab_pin.sym} 87180 -27460 0 0 {name=p86521 lab=_85080_/Q }
C {devices/lab_pin.sym} 87180 -27420 0 0 {name=p86522 lab=_57110_/X }
C {devices/lab_pin.sym} 87340 -27480 0 1 {name=p86523 lab=_85080_/D }
C {sky130_stdcells/a2bb2o_4.sym} 87260 -27480 0 0 {name=X_57115_ }
C {devices/lab_pin.sym} 87180 -27360 0 0 {name=p86524 lab=_41693_/X }
C {devices/lab_pin.sym} 87180 -27320 0 0 {name=p86525 lab=_42325_/X }
C {devices/lab_pin.sym} 87180 -27280 0 0 {name=p86526 lab=_87912_/Q }
C {devices/lab_pin.sym} 87180 -27240 0 0 {name=p86527 lab=_42326_/X }
C {devices/lab_pin.sym} 87340 -27300 0 1 {name=p86528 lab=_42341_/X }
C {sky130_stdcells/a2bb2o_4.sym} 87260 -27300 0 0 {name=X_42341_ }
C {devices/lab_pin.sym} 87200 -27160 0 0 {name=p86529 lab=_54332_/A }
C {devices/lab_pin.sym} 87200 -27120 0 0 {name=p86530 lab=_52637_/B }
C {devices/lab_pin.sym} 87320 -27140 0 1 {name=p86531 lab=_54327_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -27140 0 0 {name=X_54327_ }
C {sky130_stdcells/decap_3.sym} 87260 -26980 0 0 {name=XPHY_689 }
C {devices/lab_pin.sym} 87180 -26860 0 0 {name=p86532 lab=_72908_/X }
C {devices/lab_pin.sym} 87180 -26820 0 0 {name=p86533 lab=_85586_/Q }
C {devices/lab_pin.sym} 87180 -26780 0 0 {name=p86534 lab=_72909_/X }
C {devices/lab_pin.sym} 87180 -26740 0 0 {name=p86535 lab=_73160_/X }
C {devices/lab_pin.sym} 87340 -26800 0 1 {name=p86536 lab=_73161_/X }
C {sky130_stdcells/a211o_4.sym} 87260 -26800 0 0 {name=X_73161_ }
C {devices/lab_pin.sym} 87170 -26650 0 0 {name=p86537 lab=_85057_/CLK }
C {devices/lab_pin.sym} 87170 -26630 0 0 {name=p86538 lab=_56605_/Y }
C {devices/lab_pin.sym} 87350 -26650 0 1 {name=p86539 lab=_56604_/B }
C {sky130_stdcells/dfxtp_4.sym} 87260 -26640 0 0 {name=X_85147_ }
C {devices/lab_pin.sym} 87220 -26510 0 0 {name=p86540 lab=_51539_/A }
C {devices/lab_pin.sym} 87300 -26510 0 1 {name=p86541 lab=_51539_/X }
C {sky130_stdcells/buf_2.sym} 87260 -26510 0 0 {name=X_51539_ }
C {devices/lab_pin.sym} 87220 -26390 0 0 {name=p86542 lab=_58599_/A }
C {devices/lab_pin.sym} 87300 -26390 0 1 {name=p86543 lab=_58095_/X }
C {sky130_stdcells/buf_2.sym} 87260 -26390 0 0 {name=X_58095_ }
C {devices/lab_pin.sym} 87220 -26270 0 0 {name=p86544 lab=DATA_TO_HASH[6] }
C {devices/lab_pin.sym} 87300 -26270 0 1 {name=p86545 lab=_70809_/A }
C {sky130_stdcells/buf_2.sym} 87260 -26270 0 0 {name=X_70373_ }
C {devices/lab_pin.sym} 87170 -26150 0 0 {name=p86546 lab=_82349_/CLK }
C {devices/lab_pin.sym} 87170 -26130 0 0 {name=p86547 lab=_77208_/X }
C {devices/lab_pin.sym} 87350 -26150 0 1 {name=p86548 lab=_82359_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -26140 0 0 {name=X_82359_ }
C {devices/lab_pin.sym} 87220 -26010 0 0 {name=p86549 lab=_74453_/A }
C {devices/lab_pin.sym} 87300 -26010 0 1 {name=p86550 lab=_72113_/B }
C {sky130_stdcells/buf_2.sym} 87260 -26010 0 0 {name=X_72112_ }
C {devices/lab_pin.sym} 87220 -25890 0 0 {name=p86551 lab=_45284_/A }
C {devices/lab_pin.sym} 87300 -25890 0 1 {name=p86552 lab=_45060_/X }
C {sky130_stdcells/buf_2.sym} 87260 -25890 0 0 {name=X_45060_ }
C {devices/lab_pin.sym} 87200 -25790 0 0 {name=p86553 lab=_56848_/X }
C {devices/lab_pin.sym} 87200 -25750 0 0 {name=p86554 lab=_56850_/X }
C {devices/lab_pin.sym} 87200 -25710 0 0 {name=p86555 lab=_56976_/X }
C {devices/lab_pin.sym} 87320 -25750 0 1 {name=p86556 lab=_57046_/Y }
C {sky130_stdcells/nor3_4.sym} 87260 -25750 0 0 {name=X_57046_ }
C {devices/lab_pin.sym} 87220 -25610 0 0 {name=p86557 lab=_42259_/A }
C {devices/lab_pin.sym} 87300 -25610 0 1 {name=p86558 lab=_42272_/X }
C {sky130_stdcells/buf_2.sym} 87260 -25610 0 0 {name=X_42272_ }
C {devices/lab_pin.sym} 87180 -25510 0 0 {name=p86559 lab=_85475_/Q }
C {devices/lab_pin.sym} 87180 -25470 0 0 {name=p86560 lab=_54249_/X }
C {devices/lab_pin.sym} 87180 -25430 0 0 {name=p86561 lab=_54257_/Y }
C {devices/lab_pin.sym} 87340 -25470 0 1 {name=p86562 lab=_54258_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -25470 0 0 {name=X_54258_ }
C {devices/lab_pin.sym} 87220 -25330 0 0 {name=p86563 lab=_73092_/A }
C {devices/lab_pin.sym} 87300 -25330 0 1 {name=p86564 lab=_73092_/X }
C {sky130_stdcells/buf_2.sym} 87260 -25330 0 0 {name=X_73092_ }
C {devices/lab_pin.sym} 87170 -25210 0 0 {name=p86565 lab=_85083_/CLK }
C {devices/lab_pin.sym} 87170 -25190 0 0 {name=p86566 lab=_85078_/D }
C {devices/lab_pin.sym} 87350 -25210 0 1 {name=p86567 lab=_85078_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -25200 0 0 {name=X_85078_ }
C {devices/lab_pin.sym} 87220 -25070 0 0 {name=p86568 lab=_44152_/A }
C {devices/lab_pin.sym} 87300 -25070 0 1 {name=p86569 lab=_44024_/A }
C {sky130_stdcells/inv_2.sym} 87260 -25070 0 0 {name=X_44011_ }
C {devices/lab_pin.sym} 87200 -24960 0 0 {name=p86570 lab=_41223_/A }
C {devices/lab_pin.sym} 87200 -24920 0 0 {name=p86571 lab=_41223_/B }
C {devices/lab_pin.sym} 87320 -24940 0 1 {name=p86572 lab=_41223_/X }
C {sky130_stdcells/or2_4.sym} 87260 -24940 0 0 {name=X_41223_ }
C {devices/lab_pin.sym} 87200 -24820 0 0 {name=p86573 lab=_53219_/A }
C {devices/lab_pin.sym} 87200 -24780 0 0 {name=p86574 lab=_53209_/B }
C {devices/lab_pin.sym} 87320 -24800 0 1 {name=p86575 lab=_53209_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -24800 0 0 {name=X_53209_ }
C {devices/lab_pin.sym} 87220 -24670 0 0 {name=p86576 lab=_74453_/A }
C {devices/lab_pin.sym} 87300 -24670 0 1 {name=p86577 lab=_72043_/X }
C {sky130_stdcells/buf_2.sym} 87260 -24670 0 0 {name=X_72043_ }
C {devices/lab_pin.sym} 87200 -24560 0 0 {name=p86578 lab=_76906_/Y }
C {devices/lab_pin.sym} 87200 -24520 0 0 {name=p86579 lab=_76934_/A }
C {devices/lab_pin.sym} 87320 -24540 0 1 {name=p86580 lab=_76920_/Y }
C {sky130_stdcells/nor2_4.sym} 87260 -24540 0 0 {name=X_76920_ }
C {devices/lab_pin.sym} 87170 -24410 0 0 {name=p86581 lab=_81160_/CLK }
C {devices/lab_pin.sym} 87170 -24390 0 0 {name=p86582 lab=_84029_/D }
C {devices/lab_pin.sym} 87350 -24410 0 1 {name=p86583 lab=_82069_/D }
C {sky130_stdcells/dfxtp_4.sym} 87260 -24400 0 0 {name=X_84029_ }
C {devices/lab_pin.sym} 87180 -24290 0 0 {name=p86584 lab=_85487_/Q }
C {devices/lab_pin.sym} 87180 -24250 0 0 {name=p86585 lab=_54167_/X }
C {devices/lab_pin.sym} 87180 -24210 0 0 {name=p86586 lab=_54188_/Y }
C {devices/lab_pin.sym} 87340 -24250 0 1 {name=p86587 lab=_54189_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -24250 0 0 {name=X_54189_ }
C {devices/lab_pin.sym} 87180 -24140 0 0 {name=p86588 lab=_41151_/X }
C {devices/lab_pin.sym} 87180 -24100 0 0 {name=p86589 lab=_41152_/X }
C {devices/lab_pin.sym} 87180 -24060 0 0 {name=p86590 lab=_68549_/B }
C {devices/lab_pin.sym} 87180 -24020 0 0 {name=p86591 lab=_41153_/X }
C {devices/lab_pin.sym} 87340 -24080 0 1 {name=p86592 lab=_41154_/X }
C {sky130_stdcells/a2bb2o_4.sym} 87260 -24080 0 0 {name=X_41154_ }
C {devices/lab_pin.sym} 87180 -23960 0 0 {name=p86593 lab=_76829_/A }
C {devices/lab_pin.sym} 87180 -23920 0 0 {name=p86594 lab=_76828_/Y }
C {devices/lab_pin.sym} 87180 -23880 0 0 {name=p86595 lab=_76841_/A }
C {devices/lab_pin.sym} 87180 -23840 0 0 {name=p86596 lab=_76840_/Y }
C {devices/lab_pin.sym} 87340 -23900 0 1 {name=p86597 lab=_76851_/X }
C {sky130_stdcells/o22a_4.sym} 87260 -23900 0 0 {name=X_76851_ }
C {devices/lab_pin.sym} 87200 -23760 0 0 {name=p86598 lab=_58997_/A }
C {devices/lab_pin.sym} 87200 -23720 0 0 {name=p86599 lab=_58898_/B }
C {devices/lab_pin.sym} 87320 -23740 0 1 {name=p86600 lab=_58997_/Y }
C {sky130_stdcells/nor2_4.sym} 87260 -23740 0 0 {name=X_58997_ }
C {devices/lab_pin.sym} 87200 -23620 0 0 {name=p86601 lab=_75796_/Y }
C {devices/lab_pin.sym} 87200 -23580 0 0 {name=p86602 lab=_75802_/B }
C {devices/lab_pin.sym} 87320 -23600 0 1 {name=p86603 lab=_75803_/C }
C {sky130_stdcells/nand2_4.sym} 87260 -23600 0 0 {name=X_75802_ }
C {devices/lab_pin.sym} 87200 -23480 0 0 {name=p86604 lab=_48737_/A }
C {devices/lab_pin.sym} 87200 -23440 0 0 {name=p86605 lab=_52137_/B }
C {devices/lab_pin.sym} 87320 -23460 0 1 {name=p86606 lab=_48750_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -23460 0 0 {name=X_48750_ }
C {devices/lab_pin.sym} 87200 -23340 0 0 {name=p86607 lab=_65348_/C }
C {devices/lab_pin.sym} 87200 -23300 0 0 {name=p86608 lab=_83253_/Q }
C {devices/lab_pin.sym} 87320 -23320 0 1 {name=p86609 lab=_79571_/A }
C {sky130_stdcells/nor2_4.sym} 87260 -23320 0 0 {name=X_79570_ }
C {devices/lab_pin.sym} 87220 -23190 0 0 {name=p86610 lab=_51337_/A }
C {devices/lab_pin.sym} 87300 -23190 0 1 {name=p86611 lab=_45962_/X }
C {sky130_stdcells/buf_2.sym} 87260 -23190 0 0 {name=X_45962_ }
C {devices/lab_pin.sym} 87200 -23080 0 0 {name=p86612 lab=_41085_/A }
C {devices/lab_pin.sym} 87200 -23040 0 0 {name=p86613 lab=_41079_/X }
C {devices/lab_pin.sym} 87320 -23060 0 1 {name=p86614 lab=_41085_/X }
C {sky130_stdcells/or2_4.sym} 87260 -23060 0 0 {name=X_41085_ }
C {devices/lab_pin.sym} 87220 -22930 0 0 {name=p86615 lab=_58126_/A }
C {devices/lab_pin.sym} 87300 -22930 0 1 {name=p86616 lab=_57948_/X }
C {sky130_stdcells/buf_2.sym} 87260 -22930 0 0 {name=X_57948_ }
C {devices/lab_pin.sym} 87200 -22820 0 0 {name=p86617 lab=_76774_/X }
C {devices/lab_pin.sym} 87200 -22780 0 0 {name=p86618 lab=_76781_/Y }
C {devices/lab_pin.sym} 87320 -22800 0 1 {name=p86619 lab=_76783_/B }
C {sky130_stdcells/xor2_4.sym} 87260 -22800 0 0 {name=X_76782_ }
C {devices/lab_pin.sym} 87180 -22700 0 0 {name=p86620 lab=_72894_/X }
C {devices/lab_pin.sym} 87180 -22660 0 0 {name=p86621 lab=_86223_/Q }
C {devices/lab_pin.sym} 87180 -22620 0 0 {name=p86622 lab=_45896_/X }
C {devices/lab_pin.sym} 87180 -22580 0 0 {name=p86623 lab=_73993_/X }
C {devices/lab_pin.sym} 87340 -22640 0 1 {name=p86624 lab=_73994_/X }
C {sky130_stdcells/a211o_4.sym} 87260 -22640 0 0 {name=X_73994_ }
C {devices/lab_pin.sym} 87220 -22490 0 0 {name=p86625 lab=_47701_/A }
C {devices/lab_pin.sym} 87300 -22490 0 1 {name=p86626 lab=_53196_/D }
C {sky130_stdcells/buf_2.sym} 87260 -22490 0 0 {name=X_47701_ }
C {devices/lab_pin.sym} 87180 -22390 0 0 {name=p86627 lab=_78501_/Y }
C {devices/lab_pin.sym} 87180 -22350 0 0 {name=p86628 lab=_78505_/B }
C {devices/lab_pin.sym} 87180 -22310 0 0 {name=p86629 lab=_78503_/Y }
C {devices/lab_pin.sym} 87340 -22350 0 1 {name=p86630 lab=_78521_/X }
C {sky130_stdcells/o21a_4.sym} 87260 -22350 0 0 {name=X_78521_ }
C {devices/lab_pin.sym} 87180 -22230 0 0 {name=p86631 lab=_56196_/C }
C {devices/lab_pin.sym} 87180 -22190 0 0 {name=p86632 lab=_44911_/X }
C {devices/lab_pin.sym} 87180 -22150 0 0 {name=p86633 lab=_44912_/X }
C {devices/lab_pin.sym} 87340 -22190 0 1 {name=p86634 lab=_44913_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -22190 0 0 {name=X_44913_ }
C {devices/lab_pin.sym} 87200 -22060 0 0 {name=p86635 lab=_81092_/Q }
C {devices/lab_pin.sym} 87200 -22020 0 0 {name=p86636 lab=_75733_/B }
C {devices/lab_pin.sym} 87320 -22040 0 1 {name=p86637 lab=_75733_/Y }
C {sky130_stdcells/xnor2_4.sym} 87260 -22040 0 0 {name=X_75733_ }
C {devices/lab_pin.sym} 87170 -21910 0 0 {name=p86638 lab=_88232_/CLK }
C {devices/lab_pin.sym} 87170 -21890 0 0 {name=p86639 lab=_42786_/X }
C {devices/lab_pin.sym} 87350 -21910 0 1 {name=p86640 lab=_67613_/B }
C {sky130_stdcells/dfxtp_4.sym} 87260 -21900 0 0 {name=X_87719_ }
C {devices/lab_pin.sym} 87180 -21790 0 0 {name=p86641 lab=_48674_/Y }
C {devices/lab_pin.sym} 87180 -21750 0 0 {name=p86642 lab=_48651_/X }
C {devices/lab_pin.sym} 87180 -21710 0 0 {name=p86643 lab=_48680_/X }
C {devices/lab_pin.sym} 87340 -21750 0 1 {name=p86644 lab=_48681_/Y }
C {sky130_stdcells/a21oi_4.sym} 87260 -21750 0 0 {name=X_48681_ }
C {devices/lab_pin.sym} 87200 -21620 0 0 {name=p86645 lab=_72945_/A }
C {devices/lab_pin.sym} 87200 -21580 0 0 {name=p86646 lab=_73000_/B }
C {devices/lab_pin.sym} 87320 -21600 0 1 {name=p86647 lab=_72945_/Y }
C {sky130_stdcells/nor2_4.sym} 87260 -21600 0 0 {name=X_72945_ }
C {devices/lab_pin.sym} 87200 -21490 0 0 {name=p86648 lab=_41869_/A }
C {devices/lab_pin.sym} 87200 -21450 0 0 {name=p86649 lab=_45893_/B }
C {devices/lab_pin.sym} 87200 -21410 0 0 {name=p86650 lab=_45893_/C }
C {devices/lab_pin.sym} 87320 -21450 0 1 {name=p86651 lab=_45893_/Y }
C {sky130_stdcells/nor3_4.sym} 87260 -21450 0 0 {name=X_45893_ }
C {devices/lab_pin.sym} 87180 -21330 0 0 {name=p86652 lab=_57852_/X }
C {devices/lab_pin.sym} 87180 -21290 0 0 {name=p86653 lab=_85719_/Q }
C {devices/lab_pin.sym} 87180 -21250 0 0 {name=p86654 lab=_57878_/X }
C {devices/lab_pin.sym} 87340 -21290 0 1 {name=p86655 lab=_57879_/X }
C {sky130_stdcells/o21a_4.sym} 87260 -21290 0 0 {name=X_57879_ }
C {devices/lab_pin.sym} 87220 -21150 0 0 {name=p86656 lab=_47632_/A }
C {devices/lab_pin.sym} 87300 -21150 0 1 {name=p86657 lab=_53157_/B }
C {sky130_stdcells/buf_2.sym} 87260 -21150 0 0 {name=X_47632_ }
C {devices/lab_pin.sym} 87220 -21030 0 0 {name=p86658 lab=_59905_/B }
C {devices/lab_pin.sym} 87300 -21030 0 1 {name=p86659 lab=_61294_/D }
C {sky130_stdcells/inv_2.sym} 87260 -21030 0 0 {name=X_59618_ }
C {devices/lab_pin.sym} 87180 -20930 0 0 {name=p86660 lab=_78429_/Y }
C {devices/lab_pin.sym} 87180 -20890 0 0 {name=p86661 lab=_78450_/Y }
C {devices/lab_pin.sym} 87180 -20850 0 0 {name=p86662 lab=_78451_/Y }
C {devices/lab_pin.sym} 87340 -20890 0 1 {name=p86663 lab=_78453_/B }
C {sky130_stdcells/a21oi_4.sym} 87260 -20890 0 0 {name=X_78452_ }
C {devices/lab_pin.sym} 87220 -20750 0 0 {name=p86664 lab=_46001_/A }
C {devices/lab_pin.sym} 87300 -20750 0 1 {name=p86665 lab=_44844_/X }
C {sky130_stdcells/buf_2.sym} 87260 -20750 0 0 {name=X_44844_ }
C {devices/lab_pin.sym} 87180 -20650 0 0 {name=p86666 lab=_75649_/A }
C {devices/lab_pin.sym} 87180 -20610 0 0 {name=p86667 lab=_75661_/Y }
C {devices/lab_pin.sym} 87180 -20570 0 0 {name=p86668 lab=_75663_/X }
C {devices/lab_pin.sym} 87340 -20610 0 1 {name=p86669 lab=_75665_/B }
C {sky130_stdcells/o21ai_4.sym} 87260 -20610 0 0 {name=X_75664_ }
C {devices/lab_pin.sym} 87220 -20470 0 0 {name=p86670 lab=_44131_/A }
C {devices/lab_pin.sym} 87300 -20470 0 1 {name=p86671 lab=_72877_/A }
C {sky130_stdcells/buf_2.sym} 87260 -20470 0 0 {name=X_72876_ }
C {devices/lab_pin.sym} 87200 -20380 0 0 {name=p86672 lab=_64191_/B }
C {devices/lab_pin.sym} 87200 -20340 0 0 {name=p86673 lab=_60997_/A }
C {devices/lab_pin.sym} 87200 -20300 0 0 {name=p86674 lab=_60888_/Y }
C {devices/lab_pin.sym} 87200 -20260 0 0 {name=p86675 lab=_60889_/X }
C {devices/lab_pin.sym} 87320 -20320 0 1 {name=p86676 lab=_60890_/X }
C {sky130_stdcells/and4_4.sym} 87260 -20320 0 0 {name=X_60890_ }
C {devices/lab_pin.sym} 87200 -20180 0 0 {name=p86677 lab=_77434_/B }
C {devices/lab_pin.sym} 87200 -20140 0 0 {name=p86678 lab=_77403_/B }
C {devices/lab_pin.sym} 87320 -20160 0 1 {name=p86679 lab=_82190_/D }
C {sky130_stdcells/xnor2_4.sym} 87260 -20160 0 0 {name=X_77403_ }
C {devices/lab_pin.sym} 87180 -20060 0 0 {name=p86680 lab=_74605_/X }
C {devices/lab_pin.sym} 87180 -20020 0 0 {name=p86681 lab=_74613_/X }
C {devices/lab_pin.sym} 87180 -19980 0 0 {name=p86682 lab=_56148_/A }
C {devices/lab_pin.sym} 87180 -19940 0 0 {name=p86683 lab=_74614_/X }
C {devices/lab_pin.sym} 87340 -20000 0 1 {name=p86684 lab=_74615_/X }
C {sky130_stdcells/a211o_4.sym} 87260 -20000 0 0 {name=X_74615_ }
C {devices/lab_pin.sym} 87200 -19860 0 0 {name=p86685 lab=_47553_/A }
C {devices/lab_pin.sym} 87200 -19820 0 0 {name=p86686 lab=_53122_/B }
C {devices/lab_pin.sym} 87320 -19840 0 1 {name=p86687 lab=_47563_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -19840 0 0 {name=X_47563_ }
C {devices/lab_pin.sym} 87200 -19740 0 0 {name=p86688 lab=_71827_/A }
C {devices/lab_pin.sym} 87200 -19700 0 0 {name=p86689 lab=_71716_/B }
C {devices/lab_pin.sym} 87200 -19660 0 0 {name=p86690 lab=_70763_/A }
C {devices/lab_pin.sym} 87200 -19620 0 0 {name=p86691 lab=_71826_/X }
C {devices/lab_pin.sym} 87320 -19680 0 1 {name=p86692 lab=_71827_/X }
C {sky130_stdcells/and4_4.sym} 87260 -19680 0 0 {name=X_71827_ }
C {devices/lab_pin.sym} 87220 -19530 0 0 {name=p86693 lab=_59609_/D }
C {devices/lab_pin.sym} 87300 -19530 0 1 {name=p86694 lab=_59581_/C }
C {sky130_stdcells/buf_2.sym} 87260 -19530 0 0 {name=X_59549_ }
C {devices/lab_pin.sym} 87200 -19420 0 0 {name=p86695 lab=_78383_/A }
C {devices/lab_pin.sym} 87200 -19380 0 0 {name=p86696 lab=_82759_/D }
C {devices/lab_pin.sym} 87320 -19400 0 1 {name=p86697 lab=_82471_/D }
C {sky130_stdcells/xor2_4.sym} 87260 -19400 0 0 {name=X_78383_ }
C {devices/lab_pin.sym} 87220 -19270 0 0 {name=p86698 lab=_44650_/A }
C {devices/lab_pin.sym} 87300 -19270 0 1 {name=p86699 lab=_44775_/X }
C {sky130_stdcells/buf_2.sym} 87260 -19270 0 0 {name=X_44775_ }
C {devices/lab_pin.sym} 87200 -19160 0 0 {name=p86700 lab=_75595_/A }
C {devices/lab_pin.sym} 87200 -19120 0 0 {name=p86701 lab=_75594_/Y }
C {devices/lab_pin.sym} 87320 -19140 0 1 {name=p86702 lab=_75596_/B }
C {sky130_stdcells/nand2_4.sym} 87260 -19140 0 0 {name=X_75595_ }
C {devices/lab_pin.sym} 87180 -19050 0 0 {name=p86703 lab=_41982_/X }
C {devices/lab_pin.sym} 87180 -19010 0 0 {name=p86704 lab=_41975_/X }
C {devices/lab_pin.sym} 87180 -18970 0 0 {name=p86705 lab=_40776_/X }
C {devices/lab_pin.sym} 87180 -18930 0 0 {name=p86706 lab=_41986_/Y }
C {devices/lab_pin.sym} 87180 -18890 0 0 {name=p86707 lab=_41984_/X }
C {devices/lab_pin.sym} 87340 -18970 0 1 {name=p86708 lab=_41987_/Y }
C {sky130_stdcells/o32ai_4.sym} 87260 -18970 0 0 {name=X_41987_ }
C {devices/lab_pin.sym} 87200 -18820 0 0 {name=p86709 lab=_49302_/A }
C {devices/lab_pin.sym} 87200 -18780 0 0 {name=p86710 lab=_51328_/B }
C {devices/lab_pin.sym} 87320 -18800 0 1 {name=p86711 lab=_49302_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -18800 0 0 {name=X_49302_ }
C {devices/lab_pin.sym} 87200 -18680 0 0 {name=p86712 lab=_82922_/Q }
C {devices/lab_pin.sym} 87200 -18640 0 0 {name=p86713 lab=_46459_/B }
C {devices/lab_pin.sym} 87320 -18660 0 1 {name=p86714 lab=_46514_/X }
C {sky130_stdcells/or2_4.sym} 87260 -18660 0 0 {name=X_46514_ }
C {devices/lab_pin.sym} 87200 -18540 0 0 {name=p86715 lab=_77334_/A }
C {devices/lab_pin.sym} 87200 -18500 0 0 {name=p86716 lab=_77334_/B }
C {devices/lab_pin.sym} 87320 -18520 0 1 {name=p86717 lab=_77334_/Y }
C {sky130_stdcells/nor2_4.sym} 87260 -18520 0 0 {name=X_77334_ }
C {devices/lab_pin.sym} 87220 -18390 0 0 {name=p86718 lab=_43726_/A }
C {devices/lab_pin.sym} 87300 -18390 0 1 {name=p86719 lab=_43726_/Y }
C {sky130_stdcells/inv_2.sym} 87260 -18390 0 0 {name=X_43726_ }
C {devices/lab_pin.sym} 87200 -18300 0 0 {name=p86720 lab=_61618_/X }
C {devices/lab_pin.sym} 87200 -18260 0 0 {name=p86721 lab=_62560_/B }
C {devices/lab_pin.sym} 87200 -18220 0 0 {name=p86722 lab=_62560_/C }
C {devices/lab_pin.sym} 87200 -18180 0 0 {name=p86723 lab=_62560_/D }
C {devices/lab_pin.sym} 87320 -18240 0 1 {name=p86724 lab=_62560_/Y }
C {sky130_stdcells/nand4_4.sym} 87260 -18240 0 0 {name=X_62560_ }
C {devices/lab_pin.sym} 87180 -18110 0 0 {name=p86725 lab=_56016_/A }
C {devices/lab_pin.sym} 87180 -18070 0 0 {name=p86726 lab=_74538_/Y }
C {devices/lab_pin.sym} 87180 -18030 0 0 {name=p86727 lab=_74545_/Y }
C {devices/lab_pin.sym} 87340 -18070 0 1 {name=p86728 lab=_74546_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -18070 0 0 {name=X_74546_ }
C {devices/lab_pin.sym} 87180 -17950 0 0 {name=p86729 lab=_40504_/X }
C {devices/lab_pin.sym} 87180 -17910 0 0 {name=p86730 lab=_82304_/Q }
C {devices/lab_pin.sym} 87180 -17870 0 0 {name=p86731 lab=_40937_/X }
C {devices/lab_pin.sym} 87340 -17910 0 1 {name=p86732 lab=_40938_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -17910 0 0 {name=X_40938_ }
C {devices/lab_pin.sym} 87220 -17770 0 0 {name=p86733 lab=_47494_/A }
C {devices/lab_pin.sym} 87300 -17770 0 1 {name=p86734 lab=_53078_/D }
C {sky130_stdcells/buf_2.sym} 87260 -17770 0 0 {name=X_47494_ }
C {devices/lab_pin.sym} 87200 -17680 0 0 {name=p86735 lab=_71041_/X }
C {devices/lab_pin.sym} 87200 -17640 0 0 {name=p86736 lab=_70635_/A }
C {devices/lab_pin.sym} 87200 -17600 0 0 {name=p86737 lab=_71755_/X }
C {devices/lab_pin.sym} 87200 -17560 0 0 {name=p86738 lab=_71753_/D }
C {devices/lab_pin.sym} 87320 -17620 0 1 {name=p86739 lab=_71758_/Y }
C {sky130_stdcells/nand4_4.sym} 87260 -17620 0 0 {name=X_71758_ }
C {devices/lab_pin.sym} 87200 -17490 0 0 {name=p86740 lab=_61482_/A }
C {devices/lab_pin.sym} 87200 -17450 0 0 {name=p86741 lab=_61510_/X }
C {devices/lab_pin.sym} 87200 -17410 0 0 {name=p86742 lab=_61482_/C }
C {devices/lab_pin.sym} 87320 -17450 0 1 {name=p86743 lab=_61511_/Y }
C {sky130_stdcells/nand3_4.sym} 87260 -17450 0 0 {name=X_61511_ }
C {devices/lab_pin.sym} 87180 -17330 0 0 {name=p86744 lab=_64749_/B }
C {devices/lab_pin.sym} 87180 -17290 0 0 {name=p86745 lab=_49204_/X }
C {devices/lab_pin.sym} 87180 -17250 0 0 {name=p86746 lab=_49232_/Y }
C {devices/lab_pin.sym} 87340 -17290 0 1 {name=p86747 lab=_49233_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -17290 0 0 {name=X_49233_ }
C {devices/lab_pin.sym} 87180 -17170 0 0 {name=p86748 lab=_52748_/B }
C {devices/lab_pin.sym} 87180 -17130 0 0 {name=p86749 lab=_70699_/X }
C {devices/lab_pin.sym} 87180 -17090 0 0 {name=p86750 lab=_70708_/Y }
C {devices/lab_pin.sym} 87340 -17130 0 1 {name=p86751 lab=_70709_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -17130 0 0 {name=X_70709_ }
C {devices/lab_pin.sym} 87220 -16990 0 0 {name=p86752 lab=_72083_/A }
C {devices/lab_pin.sym} 87300 -16990 0 1 {name=p86753 lab=_46445_/X }
C {sky130_stdcells/buf_2.sym} 87260 -16990 0 0 {name=X_46445_ }
C {devices/lab_pin.sym} 87200 -16880 0 0 {name=p86754 lab=_77265_/A }
C {devices/lab_pin.sym} 87200 -16840 0 0 {name=p86755 lab=_77265_/B }
C {devices/lab_pin.sym} 87320 -16860 0 1 {name=p86756 lab=_77265_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -16860 0 0 {name=X_77265_ }
C {devices/lab_pin.sym} 87220 -16730 0 0 {name=p86757 lab=_43607_/A }
C {devices/lab_pin.sym} 87300 -16730 0 1 {name=p86758 lab=_43657_/X }
C {sky130_stdcells/buf_2.sym} 87260 -16730 0 0 {name=X_43657_ }
C {devices/lab_pin.sym} 87200 -16630 0 0 {name=p86759 lab=_62533_/A }
C {devices/lab_pin.sym} 87200 -16590 0 0 {name=p86760 lab=_58483_/A }
C {devices/lab_pin.sym} 87200 -16550 0 0 {name=p86761 lab=_62491_/C }
C {devices/lab_pin.sym} 87320 -16590 0 1 {name=p86762 lab=_62493_/C }
C {sky130_stdcells/nand3_4.sym} 87260 -16590 0 0 {name=X_62491_ }
C {devices/lab_pin.sym} 87180 -16470 0 0 {name=p86763 lab=_83058_/Q }
C {devices/lab_pin.sym} 87180 -16430 0 0 {name=p86764 lab=_74474_/X }
C {devices/lab_pin.sym} 87180 -16390 0 0 {name=p86765 lab=_74476_/Y }
C {devices/lab_pin.sym} 87340 -16430 0 1 {name=p86766 lab=_74477_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -16430 0 0 {name=X_74477_ }
C {devices/lab_pin.sym} 87220 -16290 0 0 {name=p86767 lab=_40869_/A }
C {devices/lab_pin.sym} 87300 -16290 0 1 {name=p86768 lab=_40869_/Y }
C {sky130_stdcells/inv_2.sym} 87260 -16290 0 0 {name=X_40869_ }
C {devices/lab_pin.sym} 87180 -16190 0 0 {name=p86769 lab=_71682_/Y }
C {devices/lab_pin.sym} 87180 -16150 0 0 {name=p86770 lab=_83410_/Q }
C {devices/lab_pin.sym} 87180 -16110 0 0 {name=p86771 lab=_71688_/Y }
C {devices/lab_pin.sym} 87340 -16150 0 1 {name=p86772 lab=_83410_/D }
C {sky130_stdcells/a21o_4.sym} 87260 -16150 0 0 {name=X_71689_ }
C {devices/lab_pin.sym} 87200 -16020 0 0 {name=p86773 lab=_79002_/Y }
C {devices/lab_pin.sym} 87200 -15980 0 0 {name=p86774 lab=_79003_/Y }
C {devices/lab_pin.sym} 87320 -16000 0 1 {name=p86775 lab=_79022_/A }
C {sky130_stdcells/xor2_4.sym} 87260 -16000 0 0 {name=X_79004_ }
C {devices/lab_pin.sym} 87180 -15910 0 0 {name=p86776 lab=_64222_/X }
C {devices/lab_pin.sym} 87180 -15870 0 0 {name=p86777 lab=_64223_/X }
C {devices/lab_pin.sym} 87180 -15830 0 0 {name=p86778 lab=_64225_/X }
C {devices/lab_pin.sym} 87180 -15790 0 0 {name=p86779 lab=_64228_/Y }
C {devices/lab_pin.sym} 87180 -15750 0 0 {name=p86780 lab=_64229_/X }
C {devices/lab_pin.sym} 87340 -15830 0 1 {name=p86781 lab=_64230_/X }
C {sky130_stdcells/o41a_4.sym} 87260 -15830 0 0 {name=X_64230_ }
C {devices/lab_pin.sym} 87200 -15680 0 0 {name=p86782 lab=_81255_/Q }
C {devices/lab_pin.sym} 87200 -15640 0 0 {name=p86783 lab=_81511_/D }
C {devices/lab_pin.sym} 87320 -15660 0 1 {name=p86784 lab=_76216_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -15660 0 0 {name=X_76216_ }
C {devices/lab_pin.sym} 87220 -15530 0 0 {name=p86785 lab=_73394_/A }
C {devices/lab_pin.sym} 87300 -15530 0 1 {name=p86786 lab=_69897_/B }
C {sky130_stdcells/inv_2.sym} 87260 -15530 0 0 {name=X_42608_ }
C {devices/lab_pin.sym} 87200 -15420 0 0 {name=p86787 lab=_49080_/A }
C {devices/lab_pin.sym} 87200 -15380 0 0 {name=p86788 lab=_53919_/B }
C {devices/lab_pin.sym} 87320 -15400 0 1 {name=p86789 lab=_49164_/X }
C {sky130_stdcells/and2_4.sym} 87260 -15400 0 0 {name=X_49164_ }
C {devices/lab_pin.sym} 87200 -15300 0 0 {name=p86790 lab=_59392_/A }
C {devices/lab_pin.sym} 87200 -15260 0 0 {name=p86791 lab=_61452_/B }
C {devices/lab_pin.sym} 87200 -15220 0 0 {name=p86792 lab=_61452_/C }
C {devices/lab_pin.sym} 87200 -15180 0 0 {name=p86793 lab=_61452_/D }
C {devices/lab_pin.sym} 87320 -15240 0 1 {name=p86794 lab=_61442_/Y }
C {sky130_stdcells/nand4_4.sym} 87260 -15240 0 0 {name=X_61442_ }
C {devices/lab_pin.sym} 87180 -15110 0 0 {name=p86795 lab=_73425_/X }
C {devices/lab_pin.sym} 87180 -15070 0 0 {name=p86796 lab=_73427_/X }
C {devices/lab_pin.sym} 87180 -15030 0 0 {name=p86797 lab=_72949_/X }
C {devices/lab_pin.sym} 87340 -15070 0 1 {name=p86798 lab=_73428_/X }
C {sky130_stdcells/a21o_4.sym} 87260 -15070 0 0 {name=X_73428_ }
C {devices/lab_pin.sym} 87220 -14930 0 0 {name=p86799 lab=_83646_/Q }
C {devices/lab_pin.sym} 87300 -14930 0 1 {name=p86800 lab=_46376_/Y }
C {sky130_stdcells/inv_2.sym} 87260 -14930 0 0 {name=X_46376_ }
C {devices/lab_pin.sym} 87200 -14820 0 0 {name=p86801 lab=_82012_/Q }
C {devices/lab_pin.sym} 87200 -14780 0 0 {name=p86802 lab=_82300_/D }
C {devices/lab_pin.sym} 87320 -14800 0 1 {name=p86803 lab=_77196_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -14800 0 0 {name=X_77196_ }
C {devices/lab_pin.sym} 87200 -14700 0 0 {name=p86804 lab=_42447_/A }
C {devices/lab_pin.sym} 87200 -14660 0 0 {name=p86805 lab=_41869_/B }
C {devices/lab_pin.sym} 87200 -14620 0 0 {name=p86806 lab=_42447_/B }
C {devices/lab_pin.sym} 87200 -14580 0 0 {name=p86807 lab=_42447_/D }
C {devices/lab_pin.sym} 87320 -14640 0 1 {name=p86808 lab=_43588_/X }
C {sky130_stdcells/and4_4.sym} 87260 -14640 0 0 {name=X_43588_ }
C {devices/lab_pin.sym} 87220 -14490 0 0 {name=p86809 lab=_53593_/B }
C {devices/lab_pin.sym} 87300 -14490 0 1 {name=p86810 lab=_50370_/B }
C {sky130_stdcells/buf_2.sym} 87260 -14490 0 0 {name=X_48115_ }
C {devices/lab_pin.sym} 87180 -14390 0 0 {name=p86811 lab=_55732_/B }
C {devices/lab_pin.sym} 87180 -14350 0 0 {name=p86812 lab=_45284_/X }
C {devices/lab_pin.sym} 87180 -14310 0 0 {name=p86813 lab=_45265_/X }
C {devices/lab_pin.sym} 87340 -14350 0 1 {name=p86814 lab=_45327_/X }
C {sky130_stdcells/o21a_4.sym} 87260 -14350 0 0 {name=X_45327_ }
C {devices/lab_pin.sym} 87200 -14240 0 0 {name=p86815 lab=_61665_/B }
C {devices/lab_pin.sym} 87200 -14200 0 0 {name=p86816 lab=_64161_/B }
C {devices/lab_pin.sym} 87200 -14160 0 0 {name=p86817 lab=_64172_/C }
C {devices/lab_pin.sym} 87200 -14120 0 0 {name=p86818 lab=_64161_/D }
C {devices/lab_pin.sym} 87320 -14180 0 1 {name=p86819 lab=_64161_/Y }
C {sky130_stdcells/nand4_4.sym} 87260 -14180 0 0 {name=X_64161_ }
C {devices/lab_pin.sym} 87220 -14030 0 0 {name=p86820 lab=_76149_/C }
C {devices/lab_pin.sym} 87300 -14030 0 1 {name=p86821 lab=_76147_/Y }
C {sky130_stdcells/inv_2.sym} 87260 -14030 0 0 {name=X_76147_ }
C {devices/lab_pin.sym} 87180 -13950 0 0 {name=p86822 lab=_42536_/X }
C {devices/lab_pin.sym} 87180 -13910 0 0 {name=p86823 lab=_42527_/X }
C {devices/lab_pin.sym} 87180 -13870 0 0 {name=p86824 lab=_40753_/X }
C {devices/lab_pin.sym} 87180 -13830 0 0 {name=p86825 lab=_69089_/B }
C {devices/lab_pin.sym} 87180 -13790 0 0 {name=p86826 lab=_42538_/X }
C {devices/lab_pin.sym} 87340 -13870 0 1 {name=p86827 lab=_87829_/D }
C {sky130_stdcells/o32ai_4.sym} 87260 -13870 0 0 {name=X_42539_ }
C {devices/lab_pin.sym} 87220 -13710 0 0 {name=p86828 lab=_61290_/X }
C {devices/lab_pin.sym} 87300 -13710 0 1 {name=p86829 lab=_61374_/A }
C {sky130_stdcells/buf_2.sym} 87260 -13710 0 0 {name=X_61373_ }
C {devices/lab_pin.sym} 87200 -13600 0 0 {name=p86830 lab=_49056_/A }
C {devices/lab_pin.sym} 87200 -13560 0 0 {name=p86831 lab=_52367_/B }
C {devices/lab_pin.sym} 87320 -13580 0 1 {name=p86832 lab=_49095_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -13580 0 0 {name=X_49095_ }
C {devices/lab_pin.sym} 87220 -13450 0 0 {name=p86833 lab=_73359_/A }
C {devices/lab_pin.sym} 87300 -13450 0 1 {name=p86834 lab=_73359_/X }
C {sky130_stdcells/buf_2.sym} 87260 -13450 0 0 {name=X_73359_ }
C {devices/lab_pin.sym} 87220 -13330 0 0 {name=p86835 lab=_63053_/A }
C {devices/lab_pin.sym} 87300 -13330 0 1 {name=p86836 lab=_63113_/B }
C {sky130_stdcells/buf_2.sym} 87260 -13330 0 0 {name=X_63112_ }
C {devices/lab_pin.sym} 87220 -13210 0 0 {name=p86837 lab=_48046_/A }
C {devices/lab_pin.sym} 87300 -13210 0 1 {name=p86838 lab=_52039_/A }
C {sky130_stdcells/buf_2.sym} 87260 -13210 0 0 {name=X_48046_ }
C {devices/lab_pin.sym} 87200 -13110 0 0 {name=p86839 lab=_60324_/A }
C {devices/lab_pin.sym} 87200 -13070 0 0 {name=p86840 lab=_60324_/B }
C {devices/lab_pin.sym} 87200 -13030 0 0 {name=p86841 lab=_60324_/C }
C {devices/lab_pin.sym} 87320 -13070 0 1 {name=p86842 lab=_60367_/D }
C {sky130_stdcells/nand3_4.sym} 87260 -13070 0 0 {name=X_60324_ }
C {devices/lab_pin.sym} 87200 -12940 0 0 {name=p86843 lab=_45257_/Y }
C {devices/lab_pin.sym} 87200 -12900 0 0 {name=p86844 lab=_45199_/B }
C {devices/lab_pin.sym} 87320 -12920 0 1 {name=p86845 lab=_45258_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -12920 0 0 {name=X_45258_ }
C {devices/lab_pin.sym} 87200 -12820 0 0 {name=p86846 lab=_64466_/B }
C {devices/lab_pin.sym} 87200 -12780 0 0 {name=p86847 lab=_64145_/B }
C {devices/lab_pin.sym} 87200 -12740 0 0 {name=p86848 lab=_64029_/C }
C {devices/lab_pin.sym} 87200 -12700 0 0 {name=p86849 lab=_64029_/D }
C {devices/lab_pin.sym} 87320 -12760 0 1 {name=p86850 lab=_64094_/C }
C {sky130_stdcells/nand4_4.sym} 87260 -12760 0 0 {name=X_64092_ }
C {devices/lab_pin.sym} 87200 -12620 0 0 {name=p86851 lab=_81719_/D }
C {devices/lab_pin.sym} 87200 -12580 0 0 {name=p86852 lab=_76070_/B }
C {devices/lab_pin.sym} 87320 -12600 0 1 {name=p86853 lab=_76078_/Y }
C {sky130_stdcells/nor2_4.sym} 87260 -12600 0 0 {name=X_76078_ }
C {devices/lab_pin.sym} 87220 -12470 0 0 {name=p86854 lab=_44153_/X }
C {devices/lab_pin.sym} 87300 -12470 0 1 {name=p86855 lab=_45950_/A }
C {sky130_stdcells/buf_2.sym} 87260 -12470 0 0 {name=X_44209_ }
C {devices/lab_pin.sym} 87180 -12380 0 0 {name=p86856 lab=_87143_/Q }
C {devices/lab_pin.sym} 87180 -12340 0 0 {name=p86857 lab=_67825_/X }
C {devices/lab_pin.sym} 87180 -12300 0 0 {name=p86858 lab=_67872_/X }
C {devices/lab_pin.sym} 87180 -12260 0 0 {name=p86859 lab=_67919_/X }
C {devices/lab_pin.sym} 87340 -12320 0 1 {name=p86860 lab=_67920_/X }
C {sky130_stdcells/a211o_4.sym} 87260 -12320 0 0 {name=X_67920_ }
C {devices/lab_pin.sym} 87220 -12170 0 0 {name=p86861 lab=_60489_/X }
C {devices/lab_pin.sym} 87300 -12170 0 1 {name=p86862 lab=_63081_/C }
C {sky130_stdcells/buf_2.sym} 87260 -12170 0 0 {name=X_63043_ }
C {devices/lab_pin.sym} 87200 -12060 0 0 {name=p86863 lab=_75042_/A }
C {devices/lab_pin.sym} 87200 -12020 0 0 {name=p86864 lab=_75042_/B }
C {devices/lab_pin.sym} 87320 -12040 0 1 {name=p86865 lab=_75047_/A }
C {sky130_stdcells/xor2_4.sym} 87260 -12040 0 0 {name=X_75029_ }
C {devices/lab_pin.sym} 87220 -11910 0 0 {name=p86866 lab=_79908_/B }
C {devices/lab_pin.sym} 87300 -11910 0 1 {name=p86867 lab=_79906_/Y }
C {sky130_stdcells/inv_2.sym} 87260 -11910 0 0 {name=X_79906_ }
C {devices/lab_pin.sym} 87200 -11810 0 0 {name=p86868 lab=_60255_/A }
C {devices/lab_pin.sym} 87200 -11770 0 0 {name=p86869 lab=_60255_/B }
C {devices/lab_pin.sym} 87200 -11730 0 0 {name=p86870 lab=_60324_/B }
C {devices/lab_pin.sym} 87320 -11770 0 1 {name=p86871 lab=_60325_/C }
C {sky130_stdcells/nand3_4.sym} 87260 -11770 0 0 {name=X_60255_ }
C {devices/lab_pin.sym} 87220 -11630 0 0 {name=p86872 lab=_45265_/A }
C {devices/lab_pin.sym} 87300 -11630 0 1 {name=p86873 lab=_45189_/X }
C {sky130_stdcells/buf_2.sym} 87260 -11630 0 0 {name=X_45189_ }
C {devices/lab_pin.sym} 87180 -11540 0 0 {name=p86874 lab=_67782_/X }
C {devices/lab_pin.sym} 87180 -11500 0 0 {name=p86875 lab=_67842_/Y }
C {devices/lab_pin.sym} 87180 -11460 0 0 {name=p86876 lab=_67747_/X }
C {devices/lab_pin.sym} 87180 -11420 0 0 {name=p86877 lab=_67850_/Y }
C {devices/lab_pin.sym} 87340 -11480 0 1 {name=p86878 lab=_67851_/X }
C {sky130_stdcells/a211o_4.sym} 87260 -11480 0 0 {name=X_67851_ }
C {devices/lab_pin.sym} 87200 -11340 0 0 {name=p86879 lab=_79837_/A }
C {devices/lab_pin.sym} 87200 -11300 0 0 {name=p86880 lab=_79837_/B }
C {devices/lab_pin.sym} 87320 -11320 0 1 {name=p86881 lab=_79838_/B }
C {sky130_stdcells/xor2_4.sym} 87260 -11320 0 0 {name=X_79837_ }
C {devices/lab_pin.sym} 87200 -11200 0 0 {name=p86882 lab=_60185_/X }
C {devices/lab_pin.sym} 87200 -11160 0 0 {name=p86883 lab=_60166_/X }
C {devices/lab_pin.sym} 87320 -11180 0 1 {name=p86884 lab=_60187_/A }
C {sky130_stdcells/and2_4.sym} 87260 -11180 0 0 {name=X_60186_ }
C {devices/lab_pin.sym} 87200 -11060 0 0 {name=p86885 lab=_50001_/A }
C {devices/lab_pin.sym} 87200 -11020 0 0 {name=p86886 lab=_53209_/B }
C {devices/lab_pin.sym} 87320 -11040 0 1 {name=p86887 lab=_49997_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -11040 0 0 {name=X_49997_ }
C {devices/lab_pin.sym} 87200 -10920 0 0 {name=p86888 lab=_66728_/A }
C {devices/lab_pin.sym} 87200 -10880 0 0 {name=p86889 lab=_66802_/B }
C {devices/lab_pin.sym} 87320 -10900 0 1 {name=p86890 lab=_66802_/X }
C {sky130_stdcells/and2_4.sym} 87260 -10900 0 0 {name=X_66802_ }
C {devices/lab_pin.sym} 87180 -10790 0 0 {name=p86891 lab=_48946_/X }
C {devices/lab_pin.sym} 87180 -10750 0 0 {name=p86892 lab=_48426_/Y }
C {devices/lab_pin.sym} 87180 -10710 0 0 {name=p86893 lab=_48947_/Y }
C {devices/lab_pin.sym} 87340 -10750 0 1 {name=p86894 lab=_52295_/B }
C {sky130_stdcells/a21o_4.sym} 87260 -10750 0 0 {name=X_48948_ }
C {devices/lab_pin.sym} 87220 -10610 0 0 {name=p86895 lab=_67495_/X }
C {devices/lab_pin.sym} 87300 -10610 0 1 {name=p86896 lab=_67782_/X }
C {sky130_stdcells/buf_2.sym} 87260 -10610 0 0 {name=X_67782_ }
C {devices/lab_pin.sym} 87180 -10520 0 0 {name=p86897 lab=_79740_/X }
C {devices/lab_pin.sym} 87180 -10480 0 0 {name=p86898 lab=_79743_/Y }
C {devices/lab_pin.sym} 87180 -10440 0 0 {name=p86899 lab=_79757_/A }
C {devices/lab_pin.sym} 87180 -10400 0 0 {name=p86900 lab=_79756_/Y }
C {devices/lab_pin.sym} 87340 -10460 0 1 {name=p86901 lab=_79768_/X }
C {sky130_stdcells/o22a_4.sym} 87260 -10460 0 0 {name=X_79768_ }
C {devices/lab_pin.sym} 87200 -10330 0 0 {name=p86902 lab=_64990_/X }
C {devices/lab_pin.sym} 87200 -10290 0 0 {name=p86903 lab=_64888_/B }
C {devices/lab_pin.sym} 87200 -10250 0 0 {name=p86904 lab=_64993_/X }
C {devices/lab_pin.sym} 87320 -10290 0 1 {name=p86905 lab=_64994_/Y }
C {sky130_stdcells/nand3_4.sym} 87260 -10290 0 0 {name=X_64994_ }
C {devices/lab_pin.sym} 87200 -10160 0 0 {name=p86906 lab=_69605_/A }
C {devices/lab_pin.sym} 87200 -10120 0 0 {name=p86907 lab=_69521_/B }
C {devices/lab_pin.sym} 87320 -10140 0 1 {name=p86908 lab=_69521_/X }
C {sky130_stdcells/and2_4.sym} 87260 -10140 0 0 {name=X_69521_ }
C {devices/lab_pin.sym} 87220 -10010 0 0 {name=p86909 lab=clkbuf_9_501_0_CLK/X }
C {devices/lab_pin.sym} 87300 -10010 0 1 {name=p86910 lab=_86203_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 87260 -10010 0 0 {name=Xclkbuf_10_1002_0_CLK }
C {devices/lab_pin.sym} 87220 -9890 0 0 {name=p86911 lab=_59816_/A }
C {devices/lab_pin.sym} 87300 -9890 0 1 {name=p86912 lab=_66971_/A }
C {sky130_stdcells/buf_2.sym} 87260 -9890 0 0 {name=X_66733_ }
C {devices/lab_pin.sym} 87200 -9780 0 0 {name=p86913 lab=_78717_/X }
C {devices/lab_pin.sym} 87200 -9740 0 0 {name=p86914 lab=_78718_/Y }
C {devices/lab_pin.sym} 87320 -9760 0 1 {name=p86915 lab=_78720_/A }
C {sky130_stdcells/and2_4.sym} 87260 -9760 0 0 {name=X_78719_ }
C {devices/lab_pin.sym} 87180 -9650 0 0 {name=p86916 lab=_63943_/X }
C {devices/lab_pin.sym} 87180 -9610 0 0 {name=p86917 lab=_63913_/X }
C {devices/lab_pin.sym} 87180 -9570 0 0 {name=p86918 lab=_63944_/Y }
C {devices/lab_pin.sym} 87340 -9610 0 1 {name=p86919 lab=_84285_/D }
C {sky130_stdcells/a21oi_4.sym} 87260 -9610 0 0 {name=X_63945_ }
C {devices/lab_pin.sym} 87180 -9490 0 0 {name=p86920 lab=_86465_/Q }
C {devices/lab_pin.sym} 87180 -9450 0 0 {name=p86921 lab=_48669_/X }
C {devices/lab_pin.sym} 87180 -9410 0 0 {name=p86922 lab=_48878_/Y }
C {devices/lab_pin.sym} 87340 -9450 0 1 {name=p86923 lab=_48879_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -9450 0 0 {name=X_48879_ }
C {devices/lab_pin.sym} 87200 -9320 0 0 {name=p86924 lab=_84216_/Q }
C {devices/lab_pin.sym} 87200 -9280 0 0 {name=p86925 lab=_72323_/A }
C {devices/lab_pin.sym} 87320 -9300 0 1 {name=p86926 lab=_79699_/X }
C {sky130_stdcells/xor2_4.sym} 87260 -9300 0 0 {name=X_79699_ }
C {devices/lab_pin.sym} 87220 -9170 0 0 {name=p86927 lab=_50819_/X }
C {devices/lab_pin.sym} 87300 -9170 0 1 {name=p86928 lab=_50910_/X }
C {sky130_stdcells/buf_2.sym} 87260 -9170 0 0 {name=X_50910_ }
C {devices/lab_pin.sym} 87170 -9050 0 0 {name=p86929 lab=_80928_/CLK }
C {devices/lab_pin.sym} 87170 -9030 0 0 {name=p86930 lab=_75925_/B }
C {devices/lab_pin.sym} 87350 -9050 0 1 {name=p86931 lab=_41452_/A }
C {sky130_stdcells/dfxtp_4.sym} 87260 -9040 0 0 {name=X_81730_ }
C {devices/lab_pin.sym} 87200 -8920 0 0 {name=p86932 lab=_69286_/A }
C {devices/lab_pin.sym} 87200 -8880 0 0 {name=p86933 lab=_69452_/B }
C {devices/lab_pin.sym} 87320 -8900 0 1 {name=p86934 lab=_69452_/X }
C {sky130_stdcells/and2_4.sym} 87260 -8900 0 0 {name=X_69452_ }
C {devices/lab_pin.sym} 87220 -8770 0 0 {name=p86935 lab=_68614_/A }
C {devices/lab_pin.sym} 87300 -8770 0 1 {name=p86936 lab=_66664_/X }
C {sky130_stdcells/buf_2.sym} 87260 -8770 0 0 {name=X_66664_ }
C {devices/lab_pin.sym} 87180 -8670 0 0 {name=p86937 lab=_85927_/Q }
C {devices/lab_pin.sym} 87180 -8630 0 0 {name=p86938 lab=_51873_/X }
C {devices/lab_pin.sym} 87180 -8590 0 0 {name=p86939 lab=_51889_/Y }
C {devices/lab_pin.sym} 87340 -8630 0 1 {name=p86940 lab=_51890_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -8630 0 0 {name=X_51890_ }
C {devices/lab_pin.sym} 87200 -8520 0 0 {name=p86941 lab=_61861_/X }
C {devices/lab_pin.sym} 87200 -8480 0 0 {name=p86942 lab=_63876_/B }
C {devices/lab_pin.sym} 87200 -8440 0 0 {name=p86943 lab=_63860_/C }
C {devices/lab_pin.sym} 87200 -8400 0 0 {name=p86944 lab=_63860_/D }
C {devices/lab_pin.sym} 87320 -8460 0 1 {name=p86945 lab=_63876_/Y }
C {sky130_stdcells/nand4_4.sym} 87260 -8460 0 0 {name=X_63876_ }
C {devices/lab_pin.sym} 87200 -8320 0 0 {name=p86946 lab=_68403_/A }
C {devices/lab_pin.sym} 87200 -8280 0 0 {name=p86947 lab=_68403_/B }
C {devices/lab_pin.sym} 87320 -8300 0 1 {name=p86948 lab=_68403_/X }
C {sky130_stdcells/and2_4.sym} 87260 -8300 0 0 {name=X_68403_ }
C {devices/lab_pin.sym} 87180 -8190 0 0 {name=p86949 lab=_65610_/X }
C {devices/lab_pin.sym} 87180 -8150 0 0 {name=p86950 lab=_65613_/X }
C {devices/lab_pin.sym} 87180 -8110 0 0 {name=p86951 lab=_65614_/X }
C {devices/lab_pin.sym} 87340 -8150 0 1 {name=p86952 lab=_65615_/X }
C {sky130_stdcells/a21o_4.sym} 87260 -8150 0 0 {name=X_65615_ }
C {devices/lab_pin.sym} 87180 -8030 0 0 {name=p86953 lab=_50837_/Y }
C {devices/lab_pin.sym} 87180 -7990 0 0 {name=p86954 lab=_50839_/X }
C {devices/lab_pin.sym} 87180 -7950 0 0 {name=p86955 lab=_50840_/X }
C {devices/lab_pin.sym} 87340 -7990 0 1 {name=p86956 lab=_86123_/D }
C {sky130_stdcells/a21oi_4.sym} 87260 -7990 0 0 {name=X_50841_ }
C {devices/lab_pin.sym} 87220 -7850 0 0 {name=p86957 lab=_60288_/C }
C {devices/lab_pin.sym} 87300 -7850 0 1 {name=p86958 lab=_62827_/X }
C {sky130_stdcells/buf_2.sym} 87260 -7850 0 0 {name=X_62827_ }
C {devices/lab_pin.sym} 87170 -7730 0 0 {name=p86959 lab=_81680_/CLK }
C {devices/lab_pin.sym} 87170 -7710 0 0 {name=p86960 lab=_81693_/Q }
C {devices/lab_pin.sym} 87350 -7730 0 1 {name=p86961 lab=_81661_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -7720 0 0 {name=X_81661_ }
C {devices/lab_pin.sym} 87200 -7600 0 0 {name=p86962 lab=_69383_/A }
C {devices/lab_pin.sym} 87200 -7560 0 0 {name=p86963 lab=_87265_/Q }
C {devices/lab_pin.sym} 87320 -7580 0 1 {name=p86964 lab=_69383_/X }
C {sky130_stdcells/and2_4.sym} 87260 -7580 0 0 {name=X_69383_ }
C {devices/lab_pin.sym} 87200 -7460 0 0 {name=p86965 lab=_69853_/A }
C {devices/lab_pin.sym} 87200 -7420 0 0 {name=p86966 lab=_88210_/Q }
C {devices/lab_pin.sym} 87320 -7440 0 1 {name=p86967 lab=_66595_/X }
C {sky130_stdcells/and2_4.sym} 87260 -7440 0 0 {name=X_66595_ }
C {devices/lab_pin.sym} 87220 -7310 0 0 {name=p86968 lab=clkbuf_9_508_0_CLK/X }
C {devices/lab_pin.sym} 87300 -7310 0 1 {name=p86969 lab=_86193_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 87260 -7310 0 0 {name=Xclkbuf_10_1017_0_CLK }
C {devices/lab_pin.sym} 87170 -7190 0 0 {name=p86970 lab=_84939_/CLK }
C {devices/lab_pin.sym} 87170 -7170 0 0 {name=p86971 lab=_83400_/D }
C {devices/lab_pin.sym} 87350 -7190 0 1 {name=p86972 lab=_83400_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -7180 0 0 {name=X_83400_ }
C {devices/lab_pin.sym} 87180 -7070 0 0 {name=p86973 lab=_80606_/A }
C {devices/lab_pin.sym} 87180 -7030 0 0 {name=p86974 lab=_80606_/B }
C {devices/lab_pin.sym} 87180 -6990 0 0 {name=p86975 lab=_80611_/Y }
C {devices/lab_pin.sym} 87340 -7030 0 1 {name=p86976 lab=_80623_/A }
C {sky130_stdcells/a21boi_4.sym} 87260 -7030 0 0 {name=X_80612_ }
C {devices/lab_pin.sym} 87180 -6910 0 0 {name=p86977 lab=_82628_/D }
C {devices/lab_pin.sym} 87180 -6870 0 0 {name=p86978 lab=_68318_/X }
C {devices/lab_pin.sym} 87180 -6830 0 0 {name=p86979 lab=_68333_/X }
C {devices/lab_pin.sym} 87340 -6870 0 1 {name=p86980 lab=_83980_/D }
C {sky130_stdcells/a21bo_4.sym} 87260 -6870 0 0 {name=X_68334_ }
C {devices/lab_pin.sym} 87220 -6730 0 0 {name=p86981 lab=_50724_/A }
C {devices/lab_pin.sym} 87300 -6730 0 1 {name=p86982 lab=_53620_/B }
C {sky130_stdcells/buf_2.sym} 87260 -6730 0 0 {name=X_53560_ }
C {devices/lab_pin.sym} 87200 -6630 0 0 {name=p86983 lab=_65559_/A }
C {devices/lab_pin.sym} 87200 -6590 0 0 {name=p86984 lab=_65546_/B }
C {devices/lab_pin.sym} 87200 -6550 0 0 {name=p86985 lab=_65546_/C }
C {devices/lab_pin.sym} 87320 -6590 0 1 {name=p86986 lab=_65546_/X }
C {sky130_stdcells/and3_4.sym} 87260 -6590 0 0 {name=X_65546_ }
C {devices/lab_pin.sym} 87170 -6450 0 0 {name=p86987 lab=_84375_/CLK }
C {devices/lab_pin.sym} 87170 -6430 0 0 {name=p86988 lab=_62817_/Y }
C {devices/lab_pin.sym} 87350 -6450 0 1 {name=p86989 lab=_62816_/C }
C {sky130_stdcells/dfxtp_4.sym} 87260 -6440 0 0 {name=X_84380_ }
C {devices/lab_pin.sym} 87180 -6330 0 0 {name=p86990 lab=_86136_/Q }
C {devices/lab_pin.sym} 87180 -6290 0 0 {name=p86991 lab=_50742_/X }
C {devices/lab_pin.sym} 87180 -6250 0 0 {name=p86992 lab=_50771_/Y }
C {devices/lab_pin.sym} 87340 -6290 0 1 {name=p86993 lab=_50772_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -6290 0 0 {name=X_50772_ }
C {devices/lab_pin.sym} 87180 -6170 0 0 {name=p86994 lab=_62756_/X }
C {devices/lab_pin.sym} 87180 -6130 0 0 {name=p86995 lab=_62721_/X }
C {devices/lab_pin.sym} 87180 -6090 0 0 {name=p86996 lab=_62757_/Y }
C {devices/lab_pin.sym} 87340 -6130 0 1 {name=p86997 lab=_62758_/Y }
C {sky130_stdcells/a21oi_4.sym} 87260 -6130 0 0 {name=X_62758_ }
C {devices/lab_pin.sym} 87170 -5990 0 0 {name=p86998 lab=_81428_/CLK }
C {devices/lab_pin.sym} 87170 -5970 0 0 {name=p86999 lab=_84192_/Q }
C {devices/lab_pin.sym} 87350 -5990 0 1 {name=p87000 lab=_76855_/A }
C {sky130_stdcells/dfxtp_4.sym} 87260 -5980 0 0 {name=X_81592_ }
C {devices/lab_pin.sym} 87200 -5860 0 0 {name=p87001 lab=_52501_/X }
C {devices/lab_pin.sym} 87200 -5820 0 0 {name=p87002 lab=_46455_/Y }
C {devices/lab_pin.sym} 87320 -5840 0 1 {name=p87003 lab=_52511_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -5840 0 0 {name=X_52511_ }
C {devices/lab_pin.sym} 87170 -5710 0 0 {name=p87004 lab=_83337_/CLK }
C {devices/lab_pin.sym} 87170 -5690 0 0 {name=p87005 lab=_83331_/D }
C {devices/lab_pin.sym} 87350 -5710 0 1 {name=p87006 lab=_83331_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -5700 0 0 {name=X_83331_ }
C {devices/lab_pin.sym} 87220 -5570 0 0 {name=p87007 lab=_61708_/X }
C {devices/lab_pin.sym} 87300 -5570 0 1 {name=p87008 lab=_62187_/C }
C {sky130_stdcells/buf_2.sym} 87260 -5570 0 0 {name=X_61709_ }
C {devices/lab_pin.sym} 87180 -5470 0 0 {name=p87009 lab=_80529_/Y }
C {devices/lab_pin.sym} 87180 -5430 0 0 {name=p87010 lab=_80534_/Y }
C {devices/lab_pin.sym} 87180 -5390 0 0 {name=p87011 lab=_80542_/X }
C {devices/lab_pin.sym} 87340 -5430 0 1 {name=p87012 lab=_80544_/B }
C {sky130_stdcells/o21ai_4.sym} 87260 -5430 0 0 {name=X_80543_ }
C {devices/lab_pin.sym} 87180 -5320 0 0 {name=p87013 lab=_68246_/X }
C {devices/lab_pin.sym} 87180 -5280 0 0 {name=p87014 lab=_67623_/Y }
C {devices/lab_pin.sym} 87180 -5240 0 0 {name=p87015 lab=_68247_/X }
C {devices/lab_pin.sym} 87180 -5200 0 0 {name=p87016 lab=_68264_/Y }
C {devices/lab_pin.sym} 87340 -5260 0 1 {name=p87017 lab=_68265_/X }
C {sky130_stdcells/a211o_4.sym} 87260 -5260 0 0 {name=X_68265_ }
C {devices/lab_pin.sym} 87180 -5130 0 0 {name=p87018 lab=_85626_/Q }
C {devices/lab_pin.sym} 87180 -5090 0 0 {name=p87019 lab=_53466_/X }
C {devices/lab_pin.sym} 87180 -5050 0 0 {name=p87020 lab=_53490_/Y }
C {devices/lab_pin.sym} 87340 -5090 0 1 {name=p87021 lab=_53491_/Y }
C {sky130_stdcells/o21ai_4.sym} 87260 -5090 0 0 {name=X_53491_ }
C {devices/lab_pin.sym} 87200 -4960 0 0 {name=p87022 lab=_65473_/X }
C {devices/lab_pin.sym} 87200 -4920 0 0 {name=p87023 lab=_65477_/B }
C {devices/lab_pin.sym} 87320 -4940 0 1 {name=p87024 lab=_65477_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -4940 0 0 {name=X_65477_ }
C {devices/lab_pin.sym} 87220 -4810 0 0 {name=p87025 lab=_60217_/A }
C {devices/lab_pin.sym} 87300 -4810 0 1 {name=p87026 lab=_62689_/X }
C {sky130_stdcells/buf_2.sym} 87260 -4810 0 0 {name=X_62689_ }
C {devices/lab_pin.sym} 87180 -4720 0 0 {name=p87027 lab=_85092_/Q }
C {devices/lab_pin.sym} 87180 -4680 0 0 {name=p87028 lab=_55142_/A }
C {devices/lab_pin.sym} 87180 -4640 0 0 {name=p87029 lab=_55133_/X }
C {devices/lab_pin.sym} 87180 -4600 0 0 {name=p87030 lab=_55229_/X }
C {devices/lab_pin.sym} 87340 -4660 0 1 {name=p87031 lab=_55230_/X }
C {sky130_stdcells/a211o_4.sym} 87260 -4660 0 0 {name=X_55230_ }
C {devices/lab_pin.sym} 87180 -4540 0 0 {name=p87032 lab=_87352_/Q }
C {devices/lab_pin.sym} 87180 -4500 0 0 {name=p87033 lab=_67121_/X }
C {devices/lab_pin.sym} 87180 -4460 0 0 {name=p87034 lab=_67122_/X }
C {devices/lab_pin.sym} 87180 -4420 0 0 {name=p87035 lab=_67215_/X }
C {devices/lab_pin.sym} 87340 -4480 0 1 {name=p87036 lab=_67216_/X }
C {sky130_stdcells/a211o_4.sym} 87260 -4480 0 0 {name=X_67216_ }
C {devices/lab_pin.sym} 87170 -4330 0 0 {name=p87037 lab=_83690_/CLK }
C {devices/lab_pin.sym} 87170 -4310 0 0 {name=p87038 lab=_86050_/D }
C {devices/lab_pin.sym} 87350 -4330 0 1 {name=p87039 lab=_86050_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -4320 0 0 {name=X_86050_ }
C {devices/lab_pin.sym} 87200 -4200 0 0 {name=p87040 lab=_52436_/A }
C {devices/lab_pin.sym} 87200 -4160 0 0 {name=p87041 lab=_53959_/B }
C {devices/lab_pin.sym} 87320 -4180 0 1 {name=p87042 lab=_52442_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -4180 0 0 {name=X_52442_ }
C {devices/lab_pin.sym} 87180 -4070 0 0 {name=p87043 lab=_79691_/B }
C {devices/lab_pin.sym} 87180 -4030 0 0 {name=p87044 lab=_64373_/X }
C {devices/lab_pin.sym} 87180 -3990 0 0 {name=p87045 lab=_64427_/X }
C {devices/lab_pin.sym} 87340 -4030 0 1 {name=p87046 lab=_84247_/D }
C {sky130_stdcells/a21o_4.sym} 87260 -4030 0 0 {name=X_64428_ }
C {devices/lab_pin.sym} 87170 -3890 0 0 {name=p87047 lab=_86289_/CLK }
C {devices/lab_pin.sym} 87170 -3870 0 0 {name=p87048 lab=_83262_/D }
C {devices/lab_pin.sym} 87350 -3890 0 1 {name=p87049 lab=_83262_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -3880 0 0 {name=X_83262_ }
C {devices/lab_pin.sym} 87200 -3760 0 0 {name=p87050 lab=_84763_/Q }
C {devices/lab_pin.sym} 87200 -3720 0 0 {name=p87051 lab=_80481_/B }
C {devices/lab_pin.sym} 87320 -3740 0 1 {name=p87052 lab=_80476_/A }
C {sky130_stdcells/xor2_4.sym} 87260 -3740 0 0 {name=X_80474_ }
C {devices/lab_pin.sym} 87220 -3610 0 0 {name=p87053 lab=_68097_/A }
C {devices/lab_pin.sym} 87300 -3610 0 1 {name=p87054 lab=_68196_/X }
C {sky130_stdcells/buf_2.sym} 87260 -3610 0 0 {name=X_68196_ }
C {devices/lab_pin.sym} 87170 -3490 0 0 {name=p87055 lab=_83335_/CLK }
C {devices/lab_pin.sym} 87170 -3470 0 0 {name=p87056 lab=_85001_/D }
C {devices/lab_pin.sym} 87350 -3490 0 1 {name=p87057 lab=_85001_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -3480 0 0 {name=X_85001_ }
C {devices/lab_pin.sym} 87170 -3350 0 0 {name=p87058 lab=_82220_/CLK }
C {devices/lab_pin.sym} 87170 -3330 0 0 {name=p87059 lab=_82245_/Q }
C {devices/lab_pin.sym} 87350 -3350 0 1 {name=p87060 lab=_82213_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -3340 0 0 {name=X_82213_ }
C {devices/lab_pin.sym} 87200 -3230 0 0 {name=p87061 lab=_55156_/X }
C {devices/lab_pin.sym} 87200 -3190 0 0 {name=p87062 lab=_83746_/Q }
C {devices/lab_pin.sym} 87200 -3150 0 0 {name=p87063 lab=_55160_/X }
C {devices/lab_pin.sym} 87320 -3190 0 1 {name=p87064 lab=_55296_/B }
C {sky130_stdcells/nand3_4.sym} 87260 -3190 0 0 {name=X_55161_ }
C {devices/lab_pin.sym} 87220 -3050 0 0 {name=p87065 lab=_67025_/X }
C {devices/lab_pin.sym} 87300 -3050 0 1 {name=p87066 lab=_67147_/X }
C {sky130_stdcells/buf_2.sym} 87260 -3050 0 0 {name=X_67147_ }
C {devices/lab_pin.sym} 87220 -2930 0 0 {name=p87067 lab=_52271_/A }
C {devices/lab_pin.sym} 87300 -2930 0 1 {name=p87068 lab=_52373_/X }
C {sky130_stdcells/buf_2.sym} 87260 -2930 0 0 {name=X_52373_ }
C {devices/lab_pin.sym} 87180 -2830 0 0 {name=p87069 lab=_79755_/B }
C {devices/lab_pin.sym} 87180 -2790 0 0 {name=p87070 lab=_64314_/X }
C {devices/lab_pin.sym} 87180 -2750 0 0 {name=p87071 lab=_64358_/X }
C {devices/lab_pin.sym} 87340 -2790 0 1 {name=p87072 lab=_64359_/X }
C {sky130_stdcells/a21o_4.sym} 87260 -2790 0 0 {name=X_64359_ }
C {devices/lab_pin.sym} 87170 -2650 0 0 {name=p87073 lab=_83191_/CLK }
C {devices/lab_pin.sym} 87170 -2630 0 0 {name=p87074 lab=_83193_/D }
C {devices/lab_pin.sym} 87350 -2650 0 1 {name=p87075 lab=_70219_/C }
C {sky130_stdcells/dfxtp_4.sym} 87260 -2640 0 0 {name=X_83193_ }
C {devices/lab_pin.sym} 87180 -2530 0 0 {name=p87076 lab=_54107_/Y }
C {devices/lab_pin.sym} 87180 -2490 0 0 {name=p87077 lab=_53437_/X }
C {devices/lab_pin.sym} 87180 -2450 0 0 {name=p87078 lab=_54111_/X }
C {devices/lab_pin.sym} 87340 -2490 0 1 {name=p87079 lab=_54112_/Y }
C {sky130_stdcells/a21oi_4.sym} 87260 -2490 0 0 {name=X_54112_ }
C {devices/lab_pin.sym} 87200 -2360 0 0 {name=p87080 lab=_51310_/X }
C {devices/lab_pin.sym} 87200 -2320 0 0 {name=p87081 lab=_51324_/B }
C {devices/lab_pin.sym} 87320 -2340 0 1 {name=p87082 lab=_51324_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -2340 0 0 {name=X_51324_ }
C {devices/lab_pin.sym} 87170 -2210 0 0 {name=p87083 lab=_82575_/CLK }
C {devices/lab_pin.sym} 87170 -2190 0 0 {name=p87084 lab=_82144_/D }
C {devices/lab_pin.sym} 87350 -2210 0 1 {name=p87085 lab=_77488_/B }
C {sky130_stdcells/dfxtp_4.sym} 87260 -2200 0 0 {name=X_82144_ }
C {devices/lab_pin.sym} 87180 -2090 0 0 {name=p87086 lab=_55090_/Y }
C {devices/lab_pin.sym} 87180 -2050 0 0 {name=p87087 lab=_55076_/X }
C {devices/lab_pin.sym} 87180 -2010 0 0 {name=p87088 lab=_55091_/X }
C {devices/lab_pin.sym} 87340 -2050 0 1 {name=p87089 lab=_85320_/D }
C {sky130_stdcells/a21oi_4.sym} 87260 -2050 0 0 {name=X_55092_ }
C {devices/lab_pin.sym} 87200 -1920 0 0 {name=p87090 lab=_67078_/A }
C {devices/lab_pin.sym} 87200 -1880 0 0 {name=p87091 lab=_67078_/B }
C {devices/lab_pin.sym} 87320 -1900 0 1 {name=p87092 lab=_67078_/Y }
C {sky130_stdcells/nand2_4.sym} 87260 -1900 0 0 {name=X_67078_ }
C {devices/lab_pin.sym} 87200 -1780 0 0 {name=p87093 lab=_58920_/A }
C {devices/lab_pin.sym} 87200 -1740 0 0 {name=p87094 lab=_58920_/B }
C {devices/lab_pin.sym} 87320 -1760 0 1 {name=p87095 lab=_58920_/Y }
C {sky130_stdcells/nor2_4.sym} 87260 -1760 0 0 {name=X_58920_ }
C {devices/lab_pin.sym} 87200 -1650 0 0 {name=p87096 lab=_54043_/A }
C {devices/lab_pin.sym} 87200 -1610 0 0 {name=p87097 lab=_54043_/B }
C {devices/lab_pin.sym} 87200 -1570 0 0 {name=p87098 lab=_53969_/C }
C {devices/lab_pin.sym} 87320 -1610 0 1 {name=p87099 lab=_54043_/X }
C {sky130_stdcells/and3_4.sym} 87260 -1610 0 0 {name=X_54043_ }
C {devices/lab_pin.sym} 87180 -1500 0 0 {name=p87100 lab=_65824_/X }
C {devices/lab_pin.sym} 87180 -1460 0 0 {name=p87101 lab=_84985_/Q }
C {devices/lab_pin.sym} 87180 -1420 0 0 {name=p87102 lab=_66027_/X }
C {devices/lab_pin.sym} 87180 -1380 0 0 {name=p87103 lab=_66028_/X }
C {devices/lab_pin.sym} 87340 -1440 0 1 {name=p87104 lab=_66029_/X }
C {sky130_stdcells/a211o_4.sym} 87260 -1440 0 0 {name=X_66029_ }
C {devices/lab_pin.sym} 87220 -1290 0 0 {name=p87105 lab=_48853_/A }
C {devices/lab_pin.sym} 87300 -1290 0 1 {name=p87106 lab=_51330_/C }
C {sky130_stdcells/buf_2.sym} 87260 -1290 0 0 {name=X_51255_ }
C {devices/lab_pin.sym} 87170 -1170 0 0 {name=p87107 lab=_88220_/CLK }
C {devices/lab_pin.sym} 87170 -1150 0 0 {name=p87108 lab=_86952_/D }
C {devices/lab_pin.sym} 87350 -1170 0 1 {name=p87109 lab=_86952_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -1160 0 0 {name=X_86952_ }
C {devices/lab_pin.sym} 87170 -1030 0 0 {name=p87110 lab=_81160_/CLK }
C {devices/lab_pin.sym} 87170 -1010 0 0 {name=p87111 lab=_84035_/Q }
C {devices/lab_pin.sym} 87350 -1030 0 1 {name=p87112 lab=_77952_/A }
C {sky130_stdcells/dfxtp_4.sym} 87260 -1020 0 0 {name=X_82075_ }
C {devices/lab_pin.sym} 87180 -910 0 0 {name=p87113 lab=_50204_/Y }
C {devices/lab_pin.sym} 87180 -870 0 0 {name=p87114 lab=_50191_/X }
C {devices/lab_pin.sym} 87180 -830 0 0 {name=p87115 lab=_50205_/X }
C {devices/lab_pin.sym} 87340 -870 0 1 {name=p87116 lab=_50206_/Y }
C {sky130_stdcells/a21oi_4.sym} 87260 -870 0 0 {name=X_50206_ }
C {devices/lab_pin.sym} 87170 -730 0 0 {name=p87117 lab=_85317_/CLK }
C {devices/lab_pin.sym} 87170 -710 0 0 {name=p87118 lab=_81026_/D }
C {devices/lab_pin.sym} 87350 -730 0 1 {name=p87119 lab=_81026_/Q }
C {sky130_stdcells/dfxtp_4.sym} 87260 -720 0 0 {name=X_81026_ }
C {devices/lab_pin.sym} 88090 -42150 0 0 {name=p87120 lab=_86576_/CLK }
C {devices/lab_pin.sym} 88090 -42130 0 0 {name=p87121 lab=_52030_/Y }
C {devices/lab_pin.sym} 88270 -42150 0 1 {name=p87122 lab=_66166_/B }
C {sky130_stdcells/dfxtp_4.sym} 88180 -42140 0 0 {name=X_85903_ }
C {devices/lab_pin.sym} 88120 -42020 0 0 {name=p87123 lab=_58763_/A }
C {devices/lab_pin.sym} 88120 -41980 0 0 {name=p87124 lab=_86379_/Q }
C {devices/lab_pin.sym} 88240 -42000 0 1 {name=p87125 lab=_58851_/Y }
C {sky130_stdcells/nor2_4.sym} 88180 -42000 0 0 {name=X_58851_ }
C {devices/lab_pin.sym} 88100 -41890 0 0 {name=p87126 lab=_86058_/Q }
C {devices/lab_pin.sym} 88100 -41850 0 0 {name=p87127 lab=_51183_/X }
C {devices/lab_pin.sym} 88100 -41810 0 0 {name=p87128 lab=_51185_/Y }
C {devices/lab_pin.sym} 88260 -41850 0 1 {name=p87129 lab=_51186_/Y }
C {sky130_stdcells/o21ai_4.sym} 88180 -41850 0 0 {name=X_51186_ }
C {devices/lab_pin.sym} 88090 -41710 0 0 {name=p87130 lab=_86869_/CLK }
C {devices/lab_pin.sym} 88090 -41690 0 0 {name=p87131 lab=_45336_/Y }
C {devices/lab_pin.sym} 88270 -41710 0 1 {name=p87132 lab=_64524_/B }
C {sky130_stdcells/dfxtp_4.sym} 88180 -41700 0 0 {name=X_86883_ }
C {devices/lab_pin.sym} 88140 -41570 0 0 {name=p87133 lab=_44147_/A }
C {devices/lab_pin.sym} 88220 -41570 0 1 {name=p87134 lab=_57803_/A }
C {sky130_stdcells/buf_2.sym} 88180 -41570 0 0 {name=X_57802_ }
C {devices/lab_pin.sym} 88140 -41450 0 0 {name=p87135 lab=_50113_/A }
C {devices/lab_pin.sym} 88220 -41450 0 1 {name=p87136 lab=_50137_/X }
C {sky130_stdcells/buf_2.sym} 88180 -41450 0 0 {name=X_50137_ }
C {devices/lab_pin.sym} 88090 -41330 0 0 {name=p87137 lab=_86155_/CLK }
C {devices/lab_pin.sym} 88090 -41310 0 0 {name=p87138 lab=_85834_/D }
C {devices/lab_pin.sym} 88270 -41330 0 1 {name=p87139 lab=_85834_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -41320 0 0 {name=X_85834_ }
C {devices/lab_pin.sym} 88100 -41210 0 0 {name=p87140 lab=_58730_/X }
C {devices/lab_pin.sym} 88100 -41170 0 0 {name=p87141 lab=_85936_/Q }
C {devices/lab_pin.sym} 88100 -41130 0 0 {name=p87142 lab=_58679_/X }
C {devices/lab_pin.sym} 88260 -41170 0 1 {name=p87143 lab=_58782_/X }
C {sky130_stdcells/o21a_4.sym} 88180 -41170 0 0 {name=X_58782_ }
C {devices/lab_pin.sym} 88140 -41030 0 0 {name=p87144 lab=clkbuf_8_80_0_CLK/X }
C {devices/lab_pin.sym} 88220 -41030 0 1 {name=p87145 lab=clkbuf_9_160_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 88180 -41030 0 0 {name=Xclkbuf_9_160_0_CLK }
C {devices/lab_pin.sym} 88140 -40910 0 0 {name=p87146 lab=_55828_/X }
C {devices/lab_pin.sym} 88220 -40910 0 1 {name=p87147 lab=_55994_/X }
C {sky130_stdcells/buf_2.sym} 88180 -40910 0 0 {name=X_55994_ }
C {devices/lab_pin.sym} 88140 -40790 0 0 {name=p87148 lab=_59286_/A }
C {devices/lab_pin.sym} 88220 -40790 0 1 {name=p87149 lab=_57833_/B }
C {sky130_stdcells/buf_2.sym} 88180 -40790 0 0 {name=X_57733_ }
C {devices/lab_pin.sym} 88120 -40680 0 0 {name=p87150 lab=_68587_/X }
C {devices/lab_pin.sym} 88120 -40640 0 0 {name=p87151 lab=_69719_/B }
C {devices/lab_pin.sym} 88240 -40660 0 1 {name=p87152 lab=_69719_/Y }
C {sky130_stdcells/nor2_4.sym} 88180 -40660 0 0 {name=X_69719_ }
C {devices/lab_pin.sym} 88140 -40530 0 0 {name=p87153 lab=_50092_/A }
C {devices/lab_pin.sym} 88220 -40530 0 1 {name=p87154 lab=_50068_/X }
C {sky130_stdcells/buf_2.sym} 88180 -40530 0 0 {name=X_50068_ }
C {devices/lab_pin.sym} 88100 -40430 0 0 {name=p87155 lab=_85348_/Q }
C {devices/lab_pin.sym} 88100 -40390 0 0 {name=p87156 lab=_53449_/X }
C {devices/lab_pin.sym} 88100 -40350 0 0 {name=p87157 lab=_54944_/Y }
C {devices/lab_pin.sym} 88260 -40390 0 1 {name=p87158 lab=_54945_/Y }
C {sky130_stdcells/o21ai_4.sym} 88180 -40390 0 0 {name=X_54945_ }
C {devices/lab_pin.sym} 88090 -40250 0 0 {name=p87159 lab=_85767_/CLK }
C {devices/lab_pin.sym} 88090 -40230 0 0 {name=p87160 lab=_52731_/Y }
C {devices/lab_pin.sym} 88270 -40250 0 1 {name=p87161 lab=_85765_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -40240 0 0 {name=X_85765_ }
C {devices/lab_pin.sym} 88100 -40130 0 0 {name=p87162 lab=_51320_/B }
C {devices/lab_pin.sym} 88100 -40090 0 0 {name=p87163 lab=_70983_/X }
C {devices/lab_pin.sym} 88100 -40050 0 0 {name=p87164 lab=_70990_/Y }
C {devices/lab_pin.sym} 88260 -40090 0 1 {name=p87165 lab=_83640_/D }
C {sky130_stdcells/o21ai_4.sym} 88180 -40090 0 0 {name=X_70991_ }
C {devices/lab_pin.sym} 88090 -39950 0 0 {name=p87166 lab=_83783_/CLK }
C {devices/lab_pin.sym} 88090 -39930 0 0 {name=p87167 lab=_82785_/Q }
C {devices/lab_pin.sym} 88270 -39950 0 1 {name=p87168 lab=_82977_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -39940 0 0 {name=X_82977_ }
C {devices/lab_pin.sym} 88090 -39810 0 0 {name=p87169 lab=_87766_/CLK }
C {devices/lab_pin.sym} 88090 -39790 0 0 {name=p87170 lab=_43276_/X }
C {devices/lab_pin.sym} 88270 -39810 0 1 {name=p87171 lab=_87504_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -39800 0 0 {name=X_87504_ }
C {devices/lab_pin.sym} 88140 -39670 0 0 {name=p87172 lab=clkbuf_9_342_0_CLK/X }
C {devices/lab_pin.sym} 88220 -39670 0 1 {name=p87173 lab=_87644_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 88180 -39670 0 0 {name=Xclkbuf_10_684_0_CLK }
C {devices/lab_pin.sym} 88140 -39550 0 0 {name=p87174 lab=_41909_/Y }
C {devices/lab_pin.sym} 88220 -39550 0 1 {name=p87175 lab=_41911_/A }
C {sky130_stdcells/buf_2.sym} 88180 -39550 0 0 {name=X_41910_ }
C {devices/lab_pin.sym} 88140 -39430 0 0 {name=p87176 lab=_73163_/A }
C {devices/lab_pin.sym} 88220 -39430 0 1 {name=p87177 lab=_72730_/X }
C {sky130_stdcells/buf_2.sym} 88180 -39430 0 0 {name=X_72730_ }
C {devices/lab_pin.sym} 88090 -39310 0 0 {name=p87178 lab=_84716_/CLK }
C {devices/lab_pin.sym} 88090 -39290 0 0 {name=p87179 lab=_84716_/D }
C {devices/lab_pin.sym} 88270 -39310 0 1 {name=p87180 lab=_64276_/C }
C {sky130_stdcells/dfxtp_4.sym} 88180 -39300 0 0 {name=X_84716_ }
C {devices/lab_pin.sym} 88140 -39170 0 0 {name=p87181 lab=_57664_/A }
C {devices/lab_pin.sym} 88220 -39170 0 1 {name=p87182 lab=_57664_/X }
C {sky130_stdcells/buf_2.sym} 88180 -39170 0 0 {name=X_57664_ }
C {devices/lab_pin.sym} 88090 -39050 0 0 {name=p87183 lab=_81928_/CLK }
C {devices/lab_pin.sym} 88090 -39030 0 0 {name=p87184 lab=_81928_/D }
C {devices/lab_pin.sym} 88270 -39050 0 1 {name=p87185 lab=_81928_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -39040 0 0 {name=X_81928_ }
C {devices/lab_pin.sym} 88140 -38910 0 0 {name=p87186 lab=_42889_/Y }
C {devices/lab_pin.sym} 88220 -38910 0 1 {name=p87187 lab=_42890_/Y }
C {sky130_stdcells/inv_2.sym} 88180 -38910 0 0 {name=X_42890_ }
C {devices/lab_pin.sym} 88120 -38800 0 0 {name=p87188 lab=_54885_/A }
C {devices/lab_pin.sym} 88120 -38760 0 0 {name=p87189 lab=_47679_/A }
C {devices/lab_pin.sym} 88240 -38780 0 1 {name=p87190 lab=_54876_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -38780 0 0 {name=X_54876_ }
C {devices/lab_pin.sym} 88090 -38650 0 0 {name=p87191 lab=_85697_/CLK }
C {devices/lab_pin.sym} 88090 -38630 0 0 {name=p87192 lab=_85696_/D }
C {devices/lab_pin.sym} 88270 -38650 0 1 {name=p87193 lab=_85696_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -38640 0 0 {name=X_85696_ }
C {devices/lab_pin.sym} 88120 -38520 0 0 {name=p87194 lab=_59403_/A }
C {devices/lab_pin.sym} 88120 -38480 0 0 {name=p87195 lab=_59399_/B }
C {devices/lab_pin.sym} 88240 -38500 0 1 {name=p87196 lab=_59403_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -38500 0 0 {name=X_59403_ }
C {devices/lab_pin.sym} 88100 -38390 0 0 {name=p87197 lab=_56613_/X }
C {devices/lab_pin.sym} 88100 -38350 0 0 {name=p87198 lab=_56553_/Y }
C {devices/lab_pin.sym} 88100 -38310 0 0 {name=p87199 lab=_56614_/Y }
C {devices/lab_pin.sym} 88260 -38350 0 1 {name=p87200 lab=_85145_/D }
C {sky130_stdcells/a21oi_4.sym} 88180 -38350 0 0 {name=X_56615_ }
C {devices/lab_pin.sym} 88090 -38210 0 0 {name=p87201 lab=_87484_/CLK }
C {devices/lab_pin.sym} 88090 -38190 0 0 {name=p87202 lab=_87435_/D }
C {devices/lab_pin.sym} 88270 -38210 0 1 {name=p87203 lab=_87435_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -38200 0 0 {name=X_87435_ }
C {devices/lab_pin.sym} 88140 -38070 0 0 {name=p87204 lab=_42465_/A }
C {devices/lab_pin.sym} 88220 -38070 0 1 {name=p87205 lab=_41841_/X }
C {sky130_stdcells/buf_2.sym} 88180 -38070 0 0 {name=X_41841_ }
C {devices/lab_pin.sym} 88140 -37950 0 0 {name=p87206 lab=clkbuf_8_87_0_CLK/X }
C {devices/lab_pin.sym} 88220 -37950 0 1 {name=p87207 lab=clkbuf_9_175_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 88180 -37950 0 0 {name=Xclkbuf_9_175_0_CLK }
C {devices/lab_pin.sym} 88120 -37840 0 0 {name=p87208 lab=_53786_/A }
C {devices/lab_pin.sym} 88120 -37800 0 0 {name=p87209 lab=_48973_/A }
C {devices/lab_pin.sym} 88240 -37820 0 1 {name=p87210 lab=_53827_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -37820 0 0 {name=X_53827_ }
C {devices/lab_pin.sym} 88140 -37690 0 0 {name=p87211 lab=_72688_/A }
C {devices/lab_pin.sym} 88220 -37690 0 1 {name=p87212 lab=_72668_/B }
C {sky130_stdcells/buf_2.sym} 88180 -37690 0 0 {name=X_72661_ }
C {devices/lab_pin.sym} 88090 -37570 0 0 {name=p87213 lab=_84645_/CLK }
C {devices/lab_pin.sym} 88090 -37550 0 0 {name=p87214 lab=_60245_/Y }
C {devices/lab_pin.sym} 88270 -37570 0 1 {name=p87215 lab=_79863_/A }
C {sky130_stdcells/dfxtp_4.sym} 88180 -37560 0 0 {name=X_84647_ }
C {devices/lab_pin.sym} 88120 -37440 0 0 {name=p87216 lab=_57552_/X }
C {devices/lab_pin.sym} 88120 -37400 0 0 {name=p87217 lab=_48051_/Y }
C {devices/lab_pin.sym} 88240 -37420 0 1 {name=p87218 lab=_57595_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -37420 0 0 {name=X_57595_ }
C {devices/lab_pin.sym} 88090 -37290 0 0 {name=p87219 lab=_81859_/CLK }
C {devices/lab_pin.sym} 88090 -37270 0 0 {name=p87220 lab=_81859_/D }
C {devices/lab_pin.sym} 88270 -37290 0 1 {name=p87221 lab=_81827_/D }
C {sky130_stdcells/dfxtp_4.sym} 88180 -37280 0 0 {name=X_81859_ }
C {devices/lab_pin.sym} 88140 -37150 0 0 {name=p87222 lab=_71964_/A }
C {devices/lab_pin.sym} 88220 -37150 0 1 {name=p87223 lab=_74421_/C }
C {sky130_stdcells/buf_2.sym} 88180 -37150 0 0 {name=X_74400_ }
C {devices/lab_pin.sym} 88140 -37030 0 0 {name=p87224 lab=_59037_/A }
C {devices/lab_pin.sym} 88220 -37030 0 1 {name=p87225 lab=_59334_/X }
C {sky130_stdcells/buf_2.sym} 88180 -37030 0 0 {name=X_59334_ }
C {devices/lab_pin.sym} 88120 -36940 0 0 {name=p87226 lab=_71857_/A }
C {devices/lab_pin.sym} 88120 -36900 0 0 {name=p87227 lab=_70573_/B }
C {devices/lab_pin.sym} 88120 -36860 0 0 {name=p87228 lab=_71614_/C }
C {devices/lab_pin.sym} 88120 -36820 0 0 {name=p87229 lab=_71606_/X }
C {devices/lab_pin.sym} 88240 -36880 0 1 {name=p87230 lab=_71612_/Y }
C {sky130_stdcells/nor4_4.sym} 88180 -36880 0 0 {name=X_71612_ }
C {devices/lab_pin.sym} 88120 -36740 0 0 {name=p87231 lab=_56546_/A }
C {devices/lab_pin.sym} 88120 -36700 0 0 {name=p87232 lab=_56545_/Y }
C {devices/lab_pin.sym} 88240 -36720 0 1 {name=p87233 lab=_85154_/D }
C {sky130_stdcells/nand2_4.sym} 88180 -36720 0 0 {name=X_56546_ }
C {devices/lab_pin.sym} 88140 -36590 0 0 {name=p87234 lab=_44560_/A }
C {devices/lab_pin.sym} 88220 -36590 0 1 {name=p87235 lab=_87055_/D }
C {sky130_stdcells/inv_2.sym} 88180 -36590 0 0 {name=X_44560_ }
C {devices/lab_pin.sym} 88120 -36480 0 0 {name=p87236 lab=_75375_/Y }
C {devices/lab_pin.sym} 88120 -36440 0 0 {name=p87237 lab=_75377_/Y }
C {devices/lab_pin.sym} 88240 -36460 0 1 {name=p87238 lab=_75380_/Y }
C {sky130_stdcells/nor2_4.sym} 88180 -36460 0 0 {name=X_75380_ }
C {devices/lab_pin.sym} 88090 -36330 0 0 {name=p87239 lab=_86824_/CLK }
C {devices/lab_pin.sym} 88090 -36310 0 0 {name=p87240 lab=_43548_/Y }
C {devices/lab_pin.sym} 88270 -36330 0 1 {name=p87241 lab=_87366_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -36320 0 0 {name=X_87366_ }
C {devices/lab_pin.sym} 88100 -36210 0 0 {name=p87242 lab=_40402_/A }
C {devices/lab_pin.sym} 88100 -36170 0 0 {name=p87243 lab=_81734_/Q }
C {devices/lab_pin.sym} 88100 -36130 0 0 {name=p87244 lab=_41771_/X }
C {devices/lab_pin.sym} 88260 -36170 0 1 {name=p87245 lab=_41772_/X }
C {sky130_stdcells/o21a_4.sym} 88180 -36170 0 0 {name=X_41772_ }
C {devices/lab_pin.sym} 88140 -36030 0 0 {name=p87246 lab=_53733_/A }
C {devices/lab_pin.sym} 88220 -36030 0 1 {name=p87247 lab=_53774_/B }
C {sky130_stdcells/buf_2.sym} 88180 -36030 0 0 {name=X_53758_ }
C {devices/lab_pin.sym} 88090 -35910 0 0 {name=p87248 lab=_84458_/CLK }
C {devices/lab_pin.sym} 88090 -35890 0 0 {name=p87249 lab=_60734_/Y }
C {devices/lab_pin.sym} 88270 -35910 0 1 {name=p87250 lab=_84578_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -35900 0 0 {name=X_84578_ }
C {devices/lab_pin.sym} 88120 -35790 0 0 {name=p87251 lab=_72592_/A }
C {devices/lab_pin.sym} 88120 -35750 0 0 {name=p87252 lab=_61414_/A }
C {devices/lab_pin.sym} 88120 -35710 0 0 {name=p87253 lab=_79330_/B }
C {devices/lab_pin.sym} 88240 -35750 0 1 {name=p87254 lab=_72592_/Y }
C {sky130_stdcells/nor3_4.sym} 88180 -35750 0 0 {name=X_72592_ }
C {devices/lab_pin.sym} 88140 -35610 0 0 {name=p87255 lab=clkbuf_9_349_0_CLK/X }
C {devices/lab_pin.sym} 88220 -35610 0 1 {name=p87256 lab=_87952_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 88180 -35610 0 0 {name=Xclkbuf_10_699_0_CLK }
C {devices/lab_pin.sym} 88140 -35490 0 0 {name=p87257 lab=_43511_/A }
C {devices/lab_pin.sym} 88220 -35490 0 1 {name=p87258 lab=_43511_/Y }
C {sky130_stdcells/inv_2.sym} 88180 -35490 0 0 {name=X_43511_ }
C {devices/lab_pin.sym} 88090 -35370 0 0 {name=p87259 lab=_86317_/CLK }
C {devices/lab_pin.sym} 88090 -35350 0 0 {name=p87260 lab=_86317_/D }
C {devices/lab_pin.sym} 88270 -35370 0 1 {name=p87261 lab=_86317_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -35360 0 0 {name=X_86317_ }
C {devices/lab_pin.sym} 88100 -35250 0 0 {name=p87262 lab=_70315_/C }
C {devices/lab_pin.sym} 88100 -35210 0 0 {name=p87263 lab=_74327_/X }
C {devices/lab_pin.sym} 88100 -35170 0 0 {name=p87264 lab=_74330_/Y }
C {devices/lab_pin.sym} 88260 -35210 0 1 {name=p87265 lab=_83096_/D }
C {sky130_stdcells/a21bo_4.sym} 88180 -35210 0 0 {name=X_74331_ }
C {devices/lab_pin.sym} 88100 -35090 0 0 {name=p87266 lab=_40698_/X }
C {devices/lab_pin.sym} 88100 -35050 0 0 {name=p87267 lab=_82857_/Q }
C {devices/lab_pin.sym} 88100 -35010 0 0 {name=p87268 lab=_40722_/X }
C {devices/lab_pin.sym} 88260 -35050 0 1 {name=p87269 lab=_40723_/X }
C {sky130_stdcells/o21a_4.sym} 88180 -35050 0 0 {name=X_40723_ }
C {devices/lab_pin.sym} 88120 -34940 0 0 {name=p87270 lab=_52704_/A }
C {devices/lab_pin.sym} 88120 -34900 0 0 {name=p87271 lab=_52694_/B }
C {devices/lab_pin.sym} 88120 -34860 0 0 {name=p87272 lab=_52708_/X }
C {devices/lab_pin.sym} 88120 -34820 0 0 {name=p87273 lab=_52709_/D }
C {devices/lab_pin.sym} 88240 -34880 0 1 {name=p87274 lab=_52709_/X }
C {sky130_stdcells/and4_4.sym} 88180 -34880 0 0 {name=X_52709_ }
C {devices/lab_pin.sym} 88100 -34750 0 0 {name=p87275 lab=_59177_/X }
C {devices/lab_pin.sym} 88100 -34710 0 0 {name=p87276 lab=_86060_/Q }
C {devices/lab_pin.sym} 88100 -34670 0 0 {name=p87277 lab=_59264_/X }
C {devices/lab_pin.sym} 88260 -34710 0 1 {name=p87278 lab=_59265_/Y }
C {sky130_stdcells/o21ai_4.sym} 88180 -34710 0 0 {name=X_59265_ }
C {devices/lab_pin.sym} 88090 -34570 0 0 {name=p87279 lab=_83526_/CLK }
C {devices/lab_pin.sym} 88090 -34550 0 0 {name=p87280 lab=_83529_/D }
C {devices/lab_pin.sym} 88270 -34570 0 1 {name=p87281 lab=_83529_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -34560 0 0 {name=X_83529_ }
C {devices/lab_pin.sym} 88100 -34450 0 0 {name=p87282 lab=_71531_/X }
C {devices/lab_pin.sym} 88100 -34410 0 0 {name=p87283 lab=_59457_/B }
C {devices/lab_pin.sym} 88100 -34370 0 0 {name=p87284 lab=_71542_/Y }
C {devices/lab_pin.sym} 88260 -34410 0 1 {name=p87285 lab=_83463_/D }
C {sky130_stdcells/a21o_4.sym} 88180 -34410 0 0 {name=X_71543_ }
C {devices/lab_pin.sym} 88100 -34310 0 0 {name=p87286 lab=_44481_/X }
C {devices/lab_pin.sym} 88100 -34270 0 0 {name=p87287 lab=_44482_/X }
C {devices/lab_pin.sym} 88100 -34230 0 0 {name=p87288 lab=_41224_/X }
C {devices/lab_pin.sym} 88100 -34190 0 0 {name=p87289 lab=_87082_/Q }
C {devices/lab_pin.sym} 88100 -34150 0 0 {name=p87290 lab=_44484_/X }
C {devices/lab_pin.sym} 88260 -34230 0 1 {name=p87291 lab=_44491_/Y }
C {sky130_stdcells/o32ai_4.sym} 88180 -34230 0 0 {name=X_44491_ }
C {devices/lab_pin.sym} 88120 -34090 0 0 {name=p87292 lab=_56474_/X }
C {devices/lab_pin.sym} 88120 -34050 0 0 {name=p87293 lab=_56472_/B }
C {devices/lab_pin.sym} 88120 -34010 0 0 {name=p87294 lab=_55949_/B }
C {devices/lab_pin.sym} 88240 -34050 0 1 {name=p87295 lab=_56477_/Y }
C {sky130_stdcells/nand3_4.sym} 88180 -34050 0 0 {name=X_56477_ }
C {devices/lab_pin.sym} 88090 -33910 0 0 {name=p87296 lab=_87814_/CLK }
C {devices/lab_pin.sym} 88090 -33890 0 0 {name=p87297 lab=_43720_/Y }
C {devices/lab_pin.sym} 88270 -33910 0 1 {name=p87298 lab=_43717_/A }
C {sky130_stdcells/dfxtp_4.sym} 88180 -33900 0 0 {name=X_87297_ }
C {devices/lab_pin.sym} 88120 -33780 0 0 {name=p87299 lab=_53713_/A }
C {devices/lab_pin.sym} 88120 -33740 0 0 {name=p87300 lab=_48514_/A }
C {devices/lab_pin.sym} 88240 -33760 0 1 {name=p87301 lab=_53689_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -33760 0 0 {name=X_53689_ }
C {devices/lab_pin.sym} 88120 -33650 0 0 {name=p87302 lab=_45893_/B }
C {devices/lab_pin.sym} 88120 -33610 0 0 {name=p87303 lab=_42447_/D }
C {devices/lab_pin.sym} 88120 -33570 0 0 {name=p87304 lab=_45893_/C }
C {devices/lab_pin.sym} 88240 -33610 0 1 {name=p87305 lab=_46230_/X }
C {sky130_stdcells/or3_4.sym} 88180 -33610 0 0 {name=X_46230_ }
C {devices/lab_pin.sym} 88140 -33470 0 0 {name=p87306 lab=_84905_/Q }
C {devices/lab_pin.sym} 88220 -33470 0 1 {name=p87307 lab=_63355_/A }
C {sky130_stdcells/inv_2.sym} 88180 -33470 0 0 {name=X_58216_ }
C {sky130_stdcells/decap_3.sym} 88180 -33320 0 0 {name=XPHY_420 }
C {devices/lab_pin.sym} 88120 -33180 0 0 {name=p87308 lab=_77050_/A }
C {devices/lab_pin.sym} 88120 -33140 0 0 {name=p87309 lab=_81906_/Q }
C {devices/lab_pin.sym} 88240 -33160 0 1 {name=p87310 lab=_77067_/A }
C {sky130_stdcells/xor2_4.sym} 88180 -33160 0 0 {name=X_77050_ }
C {devices/lab_pin.sym} 88100 -33060 0 0 {name=p87311 lab=_41592_/X }
C {devices/lab_pin.sym} 88100 -33020 0 0 {name=p87312 lab=_43431_/X }
C {devices/lab_pin.sym} 88100 -32980 0 0 {name=p87313 lab=_87418_/Q }
C {devices/lab_pin.sym} 88100 -32940 0 0 {name=p87314 lab=_43432_/X }
C {devices/lab_pin.sym} 88260 -33000 0 1 {name=p87315 lab=_43442_/X }
C {sky130_stdcells/a2bb2o_4.sym} 88180 -33000 0 0 {name=X_43442_ }
C {devices/lab_pin.sym} 88120 -32880 0 0 {name=p87316 lab=_55421_/Y }
C {devices/lab_pin.sym} 88120 -32840 0 0 {name=p87317 lab=_55423_/Y }
C {devices/lab_pin.sym} 88120 -32800 0 0 {name=p87318 lab=_55428_/C }
C {devices/lab_pin.sym} 88120 -32760 0 0 {name=p87319 lab=_55427_/Y }
C {devices/lab_pin.sym} 88240 -32820 0 1 {name=p87320 lab=_55429_/A }
C {sky130_stdcells/nand4_4.sym} 88180 -32820 0 0 {name=X_55428_ }
C {devices/lab_pin.sym} 88100 -32690 0 0 {name=p87321 lab=_74260_/X }
C {devices/lab_pin.sym} 88100 -32650 0 0 {name=p87322 lab=_74261_/Y }
C {devices/lab_pin.sym} 88100 -32610 0 0 {name=p87323 lab=_73982_/X }
C {devices/lab_pin.sym} 88260 -32650 0 1 {name=p87324 lab=_74262_/X }
C {sky130_stdcells/a21o_4.sym} 88180 -32650 0 0 {name=X_74262_ }
C {devices/lab_pin.sym} 88090 -32510 0 0 {name=p87325 lab=_86154_/CLK }
C {devices/lab_pin.sym} 88090 -32490 0 0 {name=p87326 lab=_50180_/Y }
C {devices/lab_pin.sym} 88270 -32510 0 1 {name=p87327 lab=_65249_/B }
C {sky130_stdcells/dfxtp_4.sym} 88180 -32500 0 0 {name=X_86248_ }
C {sky130_stdcells/decap_3.sym} 88180 -32340 0 0 {name=XPHY_431 }
C {devices/lab_pin.sym} 88120 -32200 0 0 {name=p87328 lab=_40654_/A }
C {devices/lab_pin.sym} 88120 -32160 0 0 {name=p87329 lab=_40654_/B }
C {devices/lab_pin.sym} 88240 -32180 0 1 {name=p87330 lab=_40654_/X }
C {sky130_stdcells/or2_4.sym} 88180 -32180 0 0 {name=X_40654_ }
C {devices/lab_pin.sym} 88140 -32050 0 0 {name=p87331 lab=_58810_/A }
C {devices/lab_pin.sym} 88220 -32050 0 1 {name=p87332 lab=_59196_/X }
C {sky130_stdcells/buf_2.sym} 88180 -32050 0 0 {name=X_59196_ }
C {devices/lab_pin.sym} 88100 -31950 0 0 {name=p87333 lab=_71464_/X }
C {devices/lab_pin.sym} 88100 -31910 0 0 {name=p87334 lab=_83486_/Q }
C {devices/lab_pin.sym} 88100 -31870 0 0 {name=p87335 lab=_71473_/X }
C {devices/lab_pin.sym} 88260 -31910 0 1 {name=p87336 lab=_83486_/D }
C {sky130_stdcells/a21o_4.sym} 88180 -31910 0 0 {name=X_71474_ }
C {sky130_stdcells/decap_3.sym} 88180 -31740 0 0 {name=XPHY_442 }
C {sky130_stdcells/decap_3.sym} 88180 -31560 0 0 {name=XPHY_453 }
C {devices/lab_pin.sym} 88100 -31430 0 0 {name=p87337 lab=_75994_/Y }
C {devices/lab_pin.sym} 88100 -31390 0 0 {name=p87338 lab=_76005_/A }
C {devices/lab_pin.sym} 88100 -31350 0 0 {name=p87339 lab=_76000_/Y }
C {devices/lab_pin.sym} 88260 -31390 0 1 {name=p87340 lab=_76001_/Y }
C {sky130_stdcells/a21boi_4.sym} 88180 -31390 0 0 {name=X_76001_ }
C {devices/lab_pin.sym} 88100 -31270 0 0 {name=p87341 lab=_73208_/X }
C {devices/lab_pin.sym} 88100 -31230 0 0 {name=p87342 lab=_73212_/X }
C {devices/lab_pin.sym} 88100 -31190 0 0 {name=p87343 lab=_73067_/X }
C {devices/lab_pin.sym} 88260 -31230 0 1 {name=p87344 lab=_73217_/A }
C {sky130_stdcells/a21o_4.sym} 88180 -31230 0 0 {name=X_73213_ }
C {sky130_stdcells/decap_3.sym} 88180 -31060 0 0 {name=XPHY_464 }
C {devices/lab_pin.sym} 88140 -30910 0 0 {name=p87345 lab=_70424_/X }
C {devices/lab_pin.sym} 88220 -30910 0 1 {name=p87346 lab=_70426_/A }
C {sky130_stdcells/buf_2.sym} 88180 -30910 0 0 {name=X_70425_ }
C {devices/lab_pin.sym} 88120 -30800 0 0 {name=p87347 lab=_46099_/X }
C {devices/lab_pin.sym} 88120 -30760 0 0 {name=p87348 lab=_74846_/B }
C {devices/lab_pin.sym} 88240 -30780 0 1 {name=p87349 lab=_46162_/D }
C {sky130_stdcells/nor2_4.sym} 88180 -30780 0 0 {name=X_46161_ }
C {devices/lab_pin.sym} 88140 -30650 0 0 {name=p87350 lab=clkbuf_9_311_0_CLK/X }
C {devices/lab_pin.sym} 88220 -30650 0 1 {name=p87351 lab=_82335_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 88180 -30650 0 0 {name=Xclkbuf_10_622_0_CLK }
C {devices/lab_pin.sym} 88120 -30540 0 0 {name=p87352 lab=_58147_/A }
C {devices/lab_pin.sym} 88120 -30500 0 0 {name=p87353 lab=_57666_/B }
C {devices/lab_pin.sym} 88240 -30520 0 1 {name=p87354 lab=_58147_/Y }
C {sky130_stdcells/nor2_4.sym} 88180 -30520 0 0 {name=X_58147_ }
C {sky130_stdcells/decap_3.sym} 88180 -30360 0 0 {name=XPHY_475 }
C {devices/lab_pin.sym} 88100 -30240 0 0 {name=p87355 lab=_41393_/X }
C {devices/lab_pin.sym} 88100 -30200 0 0 {name=p87356 lab=_43371_/X }
C {devices/lab_pin.sym} 88100 -30160 0 0 {name=p87357 lab=_87455_/Q }
C {devices/lab_pin.sym} 88100 -30120 0 0 {name=p87358 lab=_43372_/X }
C {devices/lab_pin.sym} 88260 -30180 0 1 {name=p87359 lab=_87455_/D }
C {sky130_stdcells/a2bb2o_4.sym} 88180 -30180 0 0 {name=X_43373_ }
C {devices/lab_pin.sym} 88120 -30040 0 0 {name=p87360 lab=_55352_/A }
C {devices/lab_pin.sym} 88120 -30000 0 0 {name=p87361 lab=_55352_/C }
C {devices/lab_pin.sym} 88240 -30020 0 1 {name=p87362 lab=_55360_/A }
C {sky130_stdcells/and2_4.sym} 88180 -30020 0 0 {name=X_55359_ }
C {devices/lab_pin.sym} 88090 -29890 0 0 {name=p87363 lab=_86500_/CLK }
C {devices/lab_pin.sym} 88090 -29870 0 0 {name=p87364 lab=_50553_/Y }
C {devices/lab_pin.sym} 88270 -29890 0 1 {name=p87365 lab=_86179_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -29880 0 0 {name=X_86179_ }
C {devices/lab_pin.sym} 88100 -29780 0 0 {name=p87366 lab=_45931_/X }
C {devices/lab_pin.sym} 88100 -29740 0 0 {name=p87367 lab=_86214_/Q }
C {devices/lab_pin.sym} 88100 -29700 0 0 {name=p87368 lab=_74103_/X }
C {devices/lab_pin.sym} 88100 -29660 0 0 {name=p87369 lab=_74192_/X }
C {devices/lab_pin.sym} 88260 -29720 0 1 {name=p87370 lab=_74193_/X }
C {sky130_stdcells/a211o_4.sym} 88180 -29720 0 0 {name=X_74193_ }
C {sky130_stdcells/decap_3.sym} 88180 -29540 0 0 {name=XPHY_486 }
C {devices/lab_pin.sym} 88140 -29390 0 0 {name=p87371 lab=_40585_/A }
C {devices/lab_pin.sym} 88220 -29390 0 1 {name=p87372 lab=_40585_/X }
C {sky130_stdcells/buf_2.sym} 88180 -29390 0 0 {name=X_40585_ }
C {sky130_stdcells/decap_3.sym} 88180 -29240 0 0 {name=XPHY_497 }
C {devices/lab_pin.sym} 88100 -29110 0 0 {name=p87373 lab=_45105_/X }
C {devices/lab_pin.sym} 88100 -29070 0 0 {name=p87374 lab=_45109_/Y }
C {devices/lab_pin.sym} 88100 -29030 0 0 {name=p87375 lab=_45111_/Y }
C {devices/lab_pin.sym} 88260 -29070 0 1 {name=p87376 lab=_45112_/Y }
C {sky130_stdcells/a21oi_4.sym} 88180 -29070 0 0 {name=X_45112_ }
C {devices/lab_pin.sym} 88100 -28960 0 0 {name=p87377 lab=_41643_/X }
C {devices/lab_pin.sym} 88100 -28920 0 0 {name=p87378 lab=_42303_/X }
C {devices/lab_pin.sym} 88100 -28880 0 0 {name=p87379 lab=_87921_/Q }
C {devices/lab_pin.sym} 88100 -28840 0 0 {name=p87380 lab=_42305_/X }
C {devices/lab_pin.sym} 88260 -28900 0 1 {name=p87381 lab=_87921_/D }
C {sky130_stdcells/a2bb2o_4.sym} 88180 -28900 0 0 {name=X_42324_ }
C {devices/lab_pin.sym} 88100 -28770 0 0 {name=p87382 lab=_73142_/X }
C {devices/lab_pin.sym} 88100 -28730 0 0 {name=p87383 lab=_73143_/Y }
C {devices/lab_pin.sym} 88100 -28690 0 0 {name=p87384 lab=_72970_/X }
C {devices/lab_pin.sym} 88260 -28730 0 1 {name=p87385 lab=_73144_/Y }
C {sky130_stdcells/a21oi_4.sym} 88180 -28730 0 0 {name=X_73144_ }
C {devices/lab_pin.sym} 88140 -28590 0 0 {name=p87386 lab=_80656_/Q }
C {devices/lab_pin.sym} 88220 -28590 0 1 {name=p87387 lab=_46092_/X }
C {sky130_stdcells/buf_2.sym} 88180 -28590 0 0 {name=X_46092_ }
C {devices/lab_pin.sym} 88100 -28500 0 0 {name=p87388 lab=_84927_/Q }
C {devices/lab_pin.sym} 88100 -28460 0 0 {name=p87389 lab=_58025_/X }
C {devices/lab_pin.sym} 88100 -28420 0 0 {name=p87390 lab=_58072_/X }
C {devices/lab_pin.sym} 88100 -28380 0 0 {name=p87391 lab=_58077_/X }
C {devices/lab_pin.sym} 88260 -28440 0 1 {name=p87392 lab=_84927_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 88180 -28440 0 0 {name=X_58078_ }
C {devices/lab_pin.sym} 88140 -28290 0 0 {name=p87393 lab=HASH_ADDR[2] }
C {devices/lab_pin.sym} 88220 -28290 0 1 {name=p87394 lab=_70356_/Y }
C {sky130_stdcells/inv_2.sym} 88180 -28290 0 0 {name=X_70356_ }
C {devices/lab_pin.sym} 88140 -28170 0 0 {name=p87395 lab=clkbuf_8_56_0_CLK/X }
C {devices/lab_pin.sym} 88220 -28170 0 1 {name=p87396 lab=clkbuf_9_113_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 88180 -28170 0 0 {name=Xclkbuf_9_113_0_CLK }
C {devices/lab_pin.sym} 88140 -28050 0 0 {name=p87397 lab=clkbuf_8_20_0_CLK/X }
C {devices/lab_pin.sym} 88220 -28050 0 1 {name=p87398 lab=clkbuf_9_40_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 88180 -28050 0 0 {name=Xclkbuf_9_40_0_CLK }
C {devices/lab_pin.sym} 88120 -27960 0 0 {name=p87399 lab=_49904_/A }
C {devices/lab_pin.sym} 88120 -27920 0 0 {name=p87400 lab=_49915_/X }
C {devices/lab_pin.sym} 88120 -27880 0 0 {name=p87401 lab=_49904_/C }
C {devices/lab_pin.sym} 88120 -27840 0 0 {name=p87402 lab=_53133_/D }
C {devices/lab_pin.sym} 88240 -27900 0 1 {name=p87403 lab=_49920_/X }
C {sky130_stdcells/and4_4.sym} 88180 -27900 0 0 {name=X_49920_ }
C {devices/lab_pin.sym} 88100 -27770 0 0 {name=p87404 lab=_45039_/Y }
C {devices/lab_pin.sym} 88100 -27730 0 0 {name=p87405 lab=_45042_/Y }
C {devices/lab_pin.sym} 88100 -27690 0 0 {name=p87406 lab=_44986_/X }
C {devices/lab_pin.sym} 88260 -27730 0 1 {name=p87407 lab=_45043_/X }
C {sky130_stdcells/a21o_4.sym} 88180 -27730 0 0 {name=X_45043_ }
C {devices/lab_pin.sym} 88120 -27610 0 0 {name=p87408 lab=_57029_/A }
C {devices/lab_pin.sym} 88120 -27570 0 0 {name=p87409 lab=_57043_/B }
C {devices/lab_pin.sym} 88120 -27530 0 0 {name=p87410 lab=_56812_/X }
C {devices/lab_pin.sym} 88240 -27570 0 1 {name=p87411 lab=_57029_/Y }
C {sky130_stdcells/nand3_4.sym} 88180 -27570 0 0 {name=X_57029_ }
C {devices/lab_pin.sym} 88100 -27460 0 0 {name=p87412 lab=_41447_/X }
C {devices/lab_pin.sym} 88100 -27420 0 0 {name=p87413 lab=_42248_/X }
C {devices/lab_pin.sym} 88100 -27380 0 0 {name=p87414 lab=_87957_/Q }
C {devices/lab_pin.sym} 88100 -27340 0 0 {name=p87415 lab=_42249_/X }
C {devices/lab_pin.sym} 88260 -27400 0 1 {name=p87416 lab=_87957_/D }
C {sky130_stdcells/a2bb2o_4.sym} 88180 -27400 0 0 {name=X_42255_ }
C {devices/lab_pin.sym} 88120 -27270 0 0 {name=p87417 lab=_73073_/X }
C {devices/lab_pin.sym} 88120 -27230 0 0 {name=p87418 lab=_73058_/X }
C {devices/lab_pin.sym} 88120 -27190 0 0 {name=p87419 lab=_73075_/C }
C {devices/lab_pin.sym} 88240 -27230 0 1 {name=p87420 lab=_73075_/Y }
C {sky130_stdcells/nand3_4.sym} 88180 -27230 0 0 {name=X_73075_ }
C {devices/lab_pin.sym} 88140 -27090 0 0 {name=p87421 lab=_77952_/A }
C {devices/lab_pin.sym} 88220 -27090 0 1 {name=p87422 lab=_77954_/A }
C {sky130_stdcells/inv_2.sym} 88180 -27090 0 0 {name=X_77952_ }
C {devices/lab_pin.sym} 88120 -27000 0 0 {name=p87423 lab=_70292_/A }
C {devices/lab_pin.sym} 88120 -26960 0 0 {name=p87424 lab=_70292_/B }
C {devices/lab_pin.sym} 88120 -26920 0 0 {name=p87425 lab=_83106_/Q }
C {devices/lab_pin.sym} 88120 -26880 0 0 {name=p87426 lab=_70292_/D }
C {devices/lab_pin.sym} 88240 -26940 0 1 {name=p87427 lab=_70287_/X }
C {sky130_stdcells/and4_4.sym} 88180 -26940 0 0 {name=X_70287_ }
C {devices/lab_pin.sym} 88140 -26790 0 0 {name=p87428 lab=clkbuf_9_318_0_CLK/X }
C {devices/lab_pin.sym} 88220 -26790 0 1 {name=p87429 lab=_82008_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 88180 -26790 0 0 {name=Xclkbuf_10_637_0_CLK }
C {devices/lab_pin.sym} 88140 -26670 0 0 {name=p87430 lab=_40946_/A }
C {devices/lab_pin.sym} 88220 -26670 0 1 {name=p87431 lab=_41206_/X }
C {sky130_stdcells/buf_2.sym} 88180 -26670 0 0 {name=X_41206_ }
C {devices/lab_pin.sym} 88100 -26570 0 0 {name=p87432 lab=_72023_/Y }
C {devices/lab_pin.sym} 88100 -26530 0 0 {name=p87433 lab=_72009_/X }
C {devices/lab_pin.sym} 88100 -26490 0 0 {name=p87434 lab=_72025_/Y }
C {devices/lab_pin.sym} 88260 -26530 0 1 {name=p87435 lab=_72026_/Y }
C {sky130_stdcells/a21boi_4.sym} 88180 -26530 0 0 {name=X_72026_ }
C {devices/lab_pin.sym} 88100 -26410 0 0 {name=p87436 lab=_76904_/A }
C {devices/lab_pin.sym} 88100 -26370 0 0 {name=p87437 lab=_76902_/B }
C {devices/lab_pin.sym} 88100 -26330 0 0 {name=p87438 lab=_81597_/Q }
C {devices/lab_pin.sym} 88260 -26370 0 1 {name=p87439 lab=_76905_/A }
C {sky130_stdcells/a21o_4.sym} 88180 -26370 0 0 {name=X_76903_ }
C {devices/lab_pin.sym} 88100 -26270 0 0 {name=p87440 lab=_64689_/A }
C {devices/lab_pin.sym} 88100 -26230 0 0 {name=p87441 lab=_72604_/B }
C {devices/lab_pin.sym} 88100 -26190 0 0 {name=p87442 lab=_80153_/A }
C {devices/lab_pin.sym} 88100 -26150 0 0 {name=p87443 lab=_60038_/Y }
C {devices/lab_pin.sym} 88100 -26110 0 0 {name=p87444 lab=_60049_/A }
C {devices/lab_pin.sym} 88260 -26190 0 1 {name=p87445 lab=_60041_/A }
C {sky130_stdcells/o32ai_4.sym} 88180 -26190 0 0 {name=X_60040_ }
C {devices/lab_pin.sym} 88120 -26060 0 0 {name=p87446 lab=_49851_/A }
C {devices/lab_pin.sym} 88120 -26020 0 0 {name=p87447 lab=_49851_/B }
C {devices/lab_pin.sym} 88120 -25980 0 0 {name=p87448 lab=_49862_/C }
C {devices/lab_pin.sym} 88120 -25940 0 0 {name=p87449 lab=_53063_/D }
C {devices/lab_pin.sym} 88240 -26000 0 1 {name=p87450 lab=_49851_/X }
C {sky130_stdcells/and4_4.sym} 88180 -26000 0 0 {name=X_49851_ }
C {devices/lab_pin.sym} 88100 -25880 0 0 {name=p87451 lab=_41268_/X }
C {devices/lab_pin.sym} 88100 -25840 0 0 {name=p87452 lab=_42183_/X }
C {devices/lab_pin.sym} 88100 -25800 0 0 {name=p87453 lab=_87991_/Q }
C {devices/lab_pin.sym} 88100 -25760 0 0 {name=p87454 lab=_42184_/X }
C {devices/lab_pin.sym} 88260 -25820 0 1 {name=p87455 lab=_87991_/D }
C {sky130_stdcells/a2bb2o_4.sym} 88180 -25820 0 0 {name=X_42186_ }
C {devices/lab_pin.sym} 88120 -25680 0 0 {name=p87456 lab=_82243_/Q }
C {devices/lab_pin.sym} 88120 -25640 0 0 {name=p87457 lab=_77883_/B }
C {devices/lab_pin.sym} 88240 -25660 0 1 {name=p87458 lab=_77883_/Y }
C {sky130_stdcells/xnor2_4.sym} 88180 -25660 0 0 {name=X_77883_ }
C {devices/lab_pin.sym} 88100 -25550 0 0 {name=p87459 lab=_48800_/Y }
C {devices/lab_pin.sym} 88100 -25510 0 0 {name=p87460 lab=_48785_/X }
C {devices/lab_pin.sym} 88100 -25470 0 0 {name=p87461 lab=_48801_/X }
C {devices/lab_pin.sym} 88260 -25510 0 1 {name=p87462 lab=_48802_/Y }
C {sky130_stdcells/a21oi_4.sym} 88180 -25510 0 0 {name=X_48802_ }
C {devices/lab_pin.sym} 88140 -25370 0 0 {name=p87463 lab=clkbuf_8_64_0_CLK/X }
C {devices/lab_pin.sym} 88220 -25370 0 1 {name=p87464 lab=clkbuf_9_128_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 88180 -25370 0 0 {name=Xclkbuf_9_128_0_CLK }
C {devices/lab_pin.sym} 88100 -25270 0 0 {name=p87465 lab=_79611_/A }
C {devices/lab_pin.sym} 88100 -25230 0 0 {name=p87466 lab=_79594_/Y }
C {devices/lab_pin.sym} 88100 -25190 0 0 {name=p87467 lab=_79611_/B }
C {devices/lab_pin.sym} 88260 -25230 0 1 {name=p87468 lab=_79622_/Y }
C {sky130_stdcells/a21boi_4.sym} 88180 -25230 0 0 {name=X_79622_ }
C {devices/lab_pin.sym} 88120 -25100 0 0 {name=p87469 lab=_81724_/Q }
C {devices/lab_pin.sym} 88120 -25060 0 0 {name=p87470 lab=_41079_/X }
C {devices/lab_pin.sym} 88240 -25080 0 1 {name=p87471 lab=_41137_/X }
C {sky130_stdcells/or2_4.sym} 88180 -25080 0 0 {name=X_41137_ }
C {devices/lab_pin.sym} 88100 -24980 0 0 {name=p87472 lab=_76822_/A }
C {devices/lab_pin.sym} 88100 -24940 0 0 {name=p87473 lab=_76821_/Y }
C {devices/lab_pin.sym} 88100 -24900 0 0 {name=p87474 lab=_76810_/A }
C {devices/lab_pin.sym} 88100 -24860 0 0 {name=p87475 lab=_81364_/D }
C {devices/lab_pin.sym} 88260 -24920 0 1 {name=p87476 lab=_76834_/X }
C {sky130_stdcells/a2bb2o_4.sym} 88180 -24920 0 0 {name=X_76834_ }
C {devices/lab_pin.sym} 88100 -24790 0 0 {name=p87477 lab=_57918_/B }
C {devices/lab_pin.sym} 88100 -24750 0 0 {name=p87478 lab=_49768_/X }
C {devices/lab_pin.sym} 88100 -24710 0 0 {name=p87479 lab=_49781_/Y }
C {devices/lab_pin.sym} 88260 -24750 0 1 {name=p87480 lab=_49782_/Y }
C {sky130_stdcells/o21ai_4.sym} 88180 -24750 0 0 {name=X_49782_ }
C {devices/lab_pin.sym} 88140 -24610 0 0 {name=p87481 lab=clkbuf_9_55_0_CLK/A }
C {devices/lab_pin.sym} 88220 -24610 0 1 {name=p87482 lab=clkbuf_9_55_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 88180 -24610 0 0 {name=Xclkbuf_9_55_0_CLK }
C {devices/lab_pin.sym} 88140 -24490 0 0 {name=p87483 lab=_53309_/B }
C {devices/lab_pin.sym} 88220 -24490 0 1 {name=p87484 lab=_52794_/B }
C {sky130_stdcells/buf_2.sym} 88180 -24490 0 0 {name=X_46994_ }
C {devices/lab_pin.sym} 88100 -24390 0 0 {name=p87485 lab=_65489_/B }
C {devices/lab_pin.sym} 88100 -24350 0 0 {name=p87486 lab=_48730_/X }
C {devices/lab_pin.sym} 88100 -24310 0 0 {name=p87487 lab=_48732_/Y }
C {devices/lab_pin.sym} 88260 -24350 0 1 {name=p87488 lab=_48733_/Y }
C {sky130_stdcells/o21ai_4.sym} 88180 -24350 0 0 {name=X_48733_ }
C {devices/lab_pin.sym} 88140 -24210 0 0 {name=p87489 lab=_79553_/A }
C {devices/lab_pin.sym} 88220 -24210 0 1 {name=p87490 lab=_79554_/A }
C {sky130_stdcells/inv_2.sym} 88180 -24210 0 0 {name=X_79553_ }
C {devices/lab_pin.sym} 88140 -24090 0 0 {name=p87491 lab=_60150_/A }
C {devices/lab_pin.sym} 88220 -24090 0 1 {name=p87492 lab=_66517_/B }
C {sky130_stdcells/buf_2.sym} 88180 -24090 0 0 {name=X_45945_ }
C {devices/lab_pin.sym} 88120 -23980 0 0 {name=p87493 lab=_40937_/A }
C {devices/lab_pin.sym} 88120 -23940 0 0 {name=p87494 lab=_41068_/B }
C {devices/lab_pin.sym} 88240 -23960 0 1 {name=p87495 lab=_41068_/X }
C {sky130_stdcells/or2_4.sym} 88180 -23960 0 0 {name=X_41068_ }
C {devices/lab_pin.sym} 88140 -23830 0 0 {name=p87496 lab=_81487_/Q }
C {devices/lab_pin.sym} 88220 -23830 0 1 {name=p87497 lab=_76765_/Y }
C {sky130_stdcells/inv_2.sym} 88180 -23830 0 0 {name=X_76765_ }
C {devices/lab_pin.sym} 88120 -23740 0 0 {name=p87498 lab=_61962_/X }
C {devices/lab_pin.sym} 88120 -23700 0 0 {name=p87499 lab=_61945_/X }
C {devices/lab_pin.sym} 88120 -23660 0 0 {name=p87500 lab=_58474_/A }
C {devices/lab_pin.sym} 88120 -23620 0 0 {name=p87501 lab=_61947_/D }
C {devices/lab_pin.sym} 88240 -23680 0 1 {name=p87502 lab=_61991_/X }
C {sky130_stdcells/and4_4.sym} 88180 -23680 0 0 {name=X_61991_ }
C {devices/lab_pin.sym} 88100 -23560 0 0 {name=p87503 lab=_73907_/X }
C {devices/lab_pin.sym} 88100 -23520 0 0 {name=p87504 lab=_84976_/Q }
C {devices/lab_pin.sym} 88100 -23480 0 0 {name=p87505 lab=_73859_/X }
C {devices/lab_pin.sym} 88100 -23440 0 0 {name=p87506 lab=_73976_/X }
C {devices/lab_pin.sym} 88260 -23500 0 1 {name=p87507 lab=_73977_/X }
C {sky130_stdcells/a211o_4.sym} 88180 -23500 0 0 {name=X_73977_ }
C {devices/lab_pin.sym} 88140 -23350 0 0 {name=p87508 lab=_78503_/Y }
C {devices/lab_pin.sym} 88220 -23350 0 1 {name=p87509 lab=_78505_/C }
C {sky130_stdcells/inv_2.sym} 88180 -23350 0 0 {name=X_78504_ }
C {devices/lab_pin.sym} 88120 -23260 0 0 {name=p87510 lab=_84721_/Q }
C {devices/lab_pin.sym} 88120 -23220 0 0 {name=p87511 lab=_64191_/B }
C {devices/lab_pin.sym} 88120 -23180 0 0 {name=p87512 lab=_63731_/D }
C {devices/lab_pin.sym} 88120 -23140 0 0 {name=p87513 lab=_64190_/D }
C {devices/lab_pin.sym} 88240 -23200 0 1 {name=p87514 lab=_63730_/Y }
C {sky130_stdcells/nand4_4.sym} 88180 -23200 0 0 {name=X_63730_ }
C {devices/lab_pin.sym} 88120 -23060 0 0 {name=p87515 lab=_75696_/X }
C {devices/lab_pin.sym} 88120 -23020 0 0 {name=p87516 lab=_75711_/A }
C {devices/lab_pin.sym} 88240 -23040 0 1 {name=p87517 lab=_75716_/X }
C {sky130_stdcells/and2_4.sym} 88180 -23040 0 0 {name=X_75716_ }
C {devices/lab_pin.sym} 88120 -22920 0 0 {name=p87518 lab=_48664_/A }
C {devices/lab_pin.sym} 88120 -22880 0 0 {name=p87519 lab=_48632_/B }
C {devices/lab_pin.sym} 88240 -22900 0 1 {name=p87520 lab=_48664_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -22900 0 0 {name=X_48664_ }
C {devices/lab_pin.sym} 88140 -22770 0 0 {name=p87521 lab=_61003_/A }
C {devices/lab_pin.sym} 88220 -22770 0 1 {name=p87522 lab=_64067_/A }
C {sky130_stdcells/buf_2.sym} 88180 -22770 0 0 {name=X_60942_ }
C {devices/lab_pin.sym} 88100 -22670 0 0 {name=p87523 lab=_44531_/Y }
C {devices/lab_pin.sym} 88100 -22630 0 0 {name=p87524 lab=_72775_/X }
C {devices/lab_pin.sym} 88100 -22590 0 0 {name=p87525 lab=_72927_/Y }
C {devices/lab_pin.sym} 88260 -22630 0 1 {name=p87526 lab=_72928_/X }
C {sky130_stdcells/a21o_4.sym} 88180 -22630 0 0 {name=X_72928_ }
C {devices/lab_pin.sym} 88120 -22500 0 0 {name=p87527 lab=_79484_/A }
C {devices/lab_pin.sym} 88120 -22460 0 0 {name=p87528 lab=_79484_/B }
C {devices/lab_pin.sym} 88240 -22480 0 1 {name=p87529 lab=_79486_/B }
C {sky130_stdcells/or2_4.sym} 88180 -22480 0 0 {name=X_79484_ }
C {devices/lab_pin.sym} 88120 -22360 0 0 {name=p87530 lab=_45876_/A }
C {devices/lab_pin.sym} 88120 -22320 0 0 {name=p87531 lab=_45876_/B }
C {devices/lab_pin.sym} 88240 -22340 0 1 {name=p87532 lab=_45876_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -22340 0 0 {name=X_45876_ }
C {devices/lab_pin.sym} 88120 -22220 0 0 {name=p87533 lab=_81688_/Q }
C {devices/lab_pin.sym} 88120 -22180 0 0 {name=p87534 lab=_76696_/B }
C {devices/lab_pin.sym} 88240 -22200 0 1 {name=p87535 lab=_76696_/X }
C {sky130_stdcells/xor2_4.sym} 88180 -22200 0 0 {name=X_76696_ }
C {devices/lab_pin.sym} 88140 -22070 0 0 {name=p87536 lab=_81240_/Q }
C {devices/lab_pin.sym} 88220 -22070 0 1 {name=p87537 lab=_47616_/A }
C {sky130_stdcells/inv_2.sym} 88180 -22070 0 0 {name=X_47615_ }
C {devices/lab_pin.sym} 88120 -21960 0 0 {name=p87538 lab=_78417_/A }
C {devices/lab_pin.sym} 88120 -21920 0 0 {name=p87539 lab=_82710_/Q }
C {devices/lab_pin.sym} 88240 -21940 0 1 {name=p87540 lab=_78435_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -21940 0 0 {name=X_78435_ }
C {devices/lab_pin.sym} 88100 -21850 0 0 {name=p87541 lab=_44807_/X }
C {devices/lab_pin.sym} 88100 -21810 0 0 {name=p87542 lab=_44821_/X }
C {devices/lab_pin.sym} 88100 -21770 0 0 {name=p87543 lab=_41687_/X }
C {devices/lab_pin.sym} 88100 -21730 0 0 {name=p87544 lab=_86933_/Q }
C {devices/lab_pin.sym} 88100 -21690 0 0 {name=p87545 lab=_44808_/X }
C {devices/lab_pin.sym} 88260 -21770 0 1 {name=p87546 lab=_44827_/Y }
C {sky130_stdcells/o32ai_4.sym} 88180 -21770 0 0 {name=X_44827_ }
C {devices/lab_pin.sym} 88120 -21640 0 0 {name=p87547 lab=_58348_/A }
C {devices/lab_pin.sym} 88120 -21600 0 0 {name=p87548 lab=_63600_/X }
C {devices/lab_pin.sym} 88120 -21560 0 0 {name=p87549 lab=_63661_/C }
C {devices/lab_pin.sym} 88120 -21520 0 0 {name=p87550 lab=_63661_/D }
C {devices/lab_pin.sym} 88240 -21580 0 1 {name=p87551 lab=_63661_/Y }
C {sky130_stdcells/nand4_4.sym} 88180 -21580 0 0 {name=X_63661_ }
C {devices/lab_pin.sym} 88120 -21440 0 0 {name=p87552 lab=_75659_/A }
C {devices/lab_pin.sym} 88120 -21400 0 0 {name=p87553 lab=_75660_/A }
C {devices/lab_pin.sym} 88240 -21420 0 1 {name=p87554 lab=_75648_/B }
C {sky130_stdcells/xor2_4.sym} 88180 -21420 0 0 {name=X_75647_ }
C {devices/lab_pin.sym} 88140 -21290 0 0 {name=p87555 lab=_61003_/A }
C {devices/lab_pin.sym} 88220 -21290 0 1 {name=p87556 lab=_64172_/B }
C {sky130_stdcells/buf_2.sym} 88180 -21290 0 0 {name=X_60873_ }
C {devices/lab_pin.sym} 88100 -21190 0 0 {name=p87557 lab=_73310_/B }
C {devices/lab_pin.sym} 88100 -21150 0 0 {name=p87558 lab=_48548_/X }
C {devices/lab_pin.sym} 88100 -21110 0 0 {name=p87559 lab=_48594_/Y }
C {devices/lab_pin.sym} 88260 -21150 0 1 {name=p87560 lab=_48595_/Y }
C {sky130_stdcells/o21ai_4.sym} 88180 -21150 0 0 {name=X_48595_ }
C {devices/lab_pin.sym} 88120 -21020 0 0 {name=p87561 lab=_72859_/A }
C {devices/lab_pin.sym} 88120 -20980 0 0 {name=p87562 lab=_74095_/B }
C {devices/lab_pin.sym} 88240 -21000 0 1 {name=p87563 lab=_72859_/Y }
C {sky130_stdcells/nor2_4.sym} 88180 -21000 0 0 {name=X_72859_ }
C {devices/lab_pin.sym} 88140 -20870 0 0 {name=p87564 lab=_65400_/A }
C {devices/lab_pin.sym} 88220 -20870 0 1 {name=p87565 lab=_65400_/X }
C {sky130_stdcells/buf_2.sym} 88180 -20870 0 0 {name=X_65400_ }
C {devices/lab_pin.sym} 88120 -20770 0 0 {name=p87566 lab=_62632_/A }
C {devices/lab_pin.sym} 88120 -20730 0 0 {name=p87567 lab=_63694_/B }
C {devices/lab_pin.sym} 88120 -20690 0 0 {name=p87568 lab=_62632_/C }
C {devices/lab_pin.sym} 88240 -20730 0 1 {name=p87569 lab=_62612_/Y }
C {sky130_stdcells/nand3_4.sym} 88180 -20730 0 0 {name=X_62612_ }
C {devices/lab_pin.sym} 88100 -20610 0 0 {name=p87570 lab=_86623_/Q }
C {devices/lab_pin.sym} 88100 -20570 0 0 {name=p87571 lab=_47524_/X }
C {devices/lab_pin.sym} 88100 -20530 0 0 {name=p87572 lab=_47545_/Y }
C {devices/lab_pin.sym} 88260 -20570 0 1 {name=p87573 lab=_47546_/Y }
C {sky130_stdcells/o21ai_4.sym} 88180 -20570 0 0 {name=X_47546_ }
C {devices/lab_pin.sym} 88100 -20450 0 0 {name=p87574 lab=_66376_/Y }
C {devices/lab_pin.sym} 88100 -20410 0 0 {name=p87575 lab=_66377_/X }
C {devices/lab_pin.sym} 88100 -20370 0 0 {name=p87576 lab=_66379_/X }
C {devices/lab_pin.sym} 88260 -20410 0 1 {name=p87577 lab=_84134_/D }
C {sky130_stdcells/a21o_4.sym} 88180 -20410 0 0 {name=X_66380_ }
C {devices/lab_pin.sym} 88120 -20280 0 0 {name=p87578 lab=_78363_/Y }
C {devices/lab_pin.sym} 88120 -20240 0 0 {name=p87579 lab=_78365_/Y }
C {devices/lab_pin.sym} 88240 -20260 0 1 {name=p87580 lab=_78369_/A }
C {sky130_stdcells/nor2_4.sym} 88180 -20260 0 0 {name=X_78366_ }
C {devices/lab_pin.sym} 88100 -20160 0 0 {name=p87581 lab=_41311_/Y }
C {devices/lab_pin.sym} 88100 -20120 0 0 {name=p87582 lab=_44754_/X }
C {devices/lab_pin.sym} 88100 -20080 0 0 {name=p87583 lab=_86970_/Q }
C {devices/lab_pin.sym} 88100 -20040 0 0 {name=p87584 lab=_44755_/X }
C {devices/lab_pin.sym} 88260 -20100 0 1 {name=p87585 lab=_86970_/D }
C {sky130_stdcells/a2bb2o_4.sym} 88180 -20100 0 0 {name=X_44758_ }
C {devices/lab_pin.sym} 88120 -19970 0 0 {name=p87586 lab=_63615_/A }
C {devices/lab_pin.sym} 88120 -19930 0 0 {name=p87587 lab=_63615_/B }
C {devices/lab_pin.sym} 88120 -19890 0 0 {name=p87588 lab=_84311_/Q }
C {devices/lab_pin.sym} 88240 -19930 0 1 {name=p87589 lab=_63592_/Y }
C {sky130_stdcells/nor3_4.sym} 88180 -19930 0 0 {name=X_63592_ }
C {devices/lab_pin.sym} 88120 -19800 0 0 {name=p87590 lab=_75577_/Y }
C {devices/lab_pin.sym} 88120 -19760 0 0 {name=p87591 lab=_81107_/Q }
C {devices/lab_pin.sym} 88240 -19780 0 1 {name=p87592 lab=_75888_/A }
C {sky130_stdcells/nand2_4.sym} 88180 -19780 0 0 {name=X_75578_ }
C {devices/lab_pin.sym} 88120 -19660 0 0 {name=p87593 lab=_65408_/A }
C {devices/lab_pin.sym} 88120 -19620 0 0 {name=p87594 lab=_86437_/Q }
C {devices/lab_pin.sym} 88240 -19640 0 1 {name=p87595 lab=_65331_/X }
C {sky130_stdcells/and2_4.sym} 88180 -19640 0 0 {name=X_65331_ }
C {devices/lab_pin.sym} 88140 -19510 0 0 {name=p87596 lab=_77317_/A }
C {devices/lab_pin.sym} 88220 -19510 0 1 {name=p87597 lab=_77317_/X }
C {sky130_stdcells/buf_2.sym} 88180 -19510 0 0 {name=X_77317_ }
C {devices/lab_pin.sym} 88100 -19420 0 0 {name=p87598 lab=_40845_/X }
C {devices/lab_pin.sym} 88100 -19380 0 0 {name=p87599 lab=_43695_/X }
C {devices/lab_pin.sym} 88100 -19340 0 0 {name=p87600 lab=_73149_/A }
C {devices/lab_pin.sym} 88100 -19300 0 0 {name=p87601 lab=_43696_/X }
C {devices/lab_pin.sym} 88260 -19360 0 1 {name=p87602 lab=_43709_/X }
C {sky130_stdcells/a2bb2o_4.sym} 88180 -19360 0 0 {name=X_43709_ }
C {devices/lab_pin.sym} 88120 -19240 0 0 {name=p87603 lab=_62556_/A }
C {devices/lab_pin.sym} 88120 -19200 0 0 {name=p87604 lab=_61611_/A }
C {devices/lab_pin.sym} 88120 -19160 0 0 {name=p87605 lab=_59977_/A }
C {devices/lab_pin.sym} 88120 -19120 0 0 {name=p87606 lab=_62548_/D }
C {devices/lab_pin.sym} 88240 -19180 0 1 {name=p87607 lab=_62543_/X }
C {sky130_stdcells/and4_4.sym} 88180 -19180 0 0 {name=X_62543_ }
C {devices/lab_pin.sym} 88120 -19060 0 0 {name=p87608 lab=_74529_/A }
C {devices/lab_pin.sym} 88120 -19020 0 0 {name=p87609 lab=_74531_/B }
C {devices/lab_pin.sym} 88120 -18980 0 0 {name=p87610 lab=_74531_/C }
C {devices/lab_pin.sym} 88120 -18940 0 0 {name=p87611 lab=_74531_/D }
C {devices/lab_pin.sym} 88240 -19000 0 1 {name=p87612 lab=_74529_/Y }
C {sky130_stdcells/nand4_4.sym} 88180 -19000 0 0 {name=X_74529_ }
C {devices/lab_pin.sym} 88140 -18850 0 0 {name=p87613 lab=_47003_/A }
C {devices/lab_pin.sym} 88220 -18850 0 1 {name=p87614 lab=_47619_/A }
C {sky130_stdcells/buf_2.sym} 88180 -18850 0 0 {name=X_47477_ }
C {devices/lab_pin.sym} 88100 -18750 0 0 {name=p87615 lab=_78295_/Y }
C {devices/lab_pin.sym} 88100 -18710 0 0 {name=p87616 lab=_78291_/Y }
C {devices/lab_pin.sym} 88100 -18670 0 0 {name=p87617 lab=_78296_/Y }
C {devices/lab_pin.sym} 88260 -18710 0 1 {name=p87618 lab=_78298_/B }
C {sky130_stdcells/o21ai_4.sym} 88180 -18710 0 0 {name=X_78297_ }
C {devices/lab_pin.sym} 88140 -18570 0 0 {name=p87619 lab=_44533_/A }
C {devices/lab_pin.sym} 88220 -18570 0 1 {name=p87620 lab=_44689_/X }
C {sky130_stdcells/buf_2.sym} 88180 -18570 0 0 {name=X_44689_ }
C {devices/lab_pin.sym} 88120 -18460 0 0 {name=p87621 lab=_49220_/A }
C {devices/lab_pin.sym} 88120 -18420 0 0 {name=p87622 lab=_53949_/B }
C {devices/lab_pin.sym} 88240 -18440 0 1 {name=p87623 lab=_49216_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -18440 0 0 {name=X_49216_ }
C {devices/lab_pin.sym} 88140 -18310 0 0 {name=p87624 lab=_68479_/A }
C {devices/lab_pin.sym} 88220 -18310 0 1 {name=p87625 lab=_68403_/A }
C {sky130_stdcells/buf_2.sym} 88180 -18310 0 0 {name=X_68050_ }
C {devices/lab_pin.sym} 88120 -18210 0 0 {name=p87626 lab=_50802_/A }
C {devices/lab_pin.sym} 88120 -18170 0 0 {name=p87627 lab=_46428_/B }
C {devices/lab_pin.sym} 88120 -18130 0 0 {name=p87628 lab=_46428_/C }
C {devices/lab_pin.sym} 88240 -18170 0 1 {name=p87629 lab=_46428_/X }
C {sky130_stdcells/and3_4.sym} 88180 -18170 0 0 {name=X_46428_ }
C {devices/lab_pin.sym} 88100 -18050 0 0 {name=p87630 lab=_65259_/X }
C {devices/lab_pin.sym} 88100 -18010 0 0 {name=p87631 lab=_65261_/X }
C {devices/lab_pin.sym} 88100 -17970 0 0 {name=p87632 lab=_65161_/X }
C {devices/lab_pin.sym} 88260 -18010 0 1 {name=p87633 lab=_65262_/X }
C {sky130_stdcells/a21o_4.sym} 88180 -18010 0 0 {name=X_65262_ }
C {devices/lab_pin.sym} 88120 -17880 0 0 {name=p87634 lab=_81923_/Q }
C {devices/lab_pin.sym} 88120 -17840 0 0 {name=p87635 lab=_82179_/D }
C {devices/lab_pin.sym} 88240 -17860 0 1 {name=p87636 lab=_81891_/D }
C {sky130_stdcells/xor2_4.sym} 88180 -17860 0 0 {name=X_77248_ }
C {devices/lab_pin.sym} 88120 -17750 0 0 {name=p87637 lab=_62533_/A }
C {devices/lab_pin.sym} 88120 -17710 0 0 {name=p87638 lab=_58478_/A }
C {devices/lab_pin.sym} 88120 -17670 0 0 {name=p87639 lab=_62491_/C }
C {devices/lab_pin.sym} 88240 -17710 0 1 {name=p87640 lab=_62477_/C }
C {sky130_stdcells/nand3_4.sym} 88180 -17710 0 0 {name=X_62474_ }
C {devices/lab_pin.sym} 88100 -17590 0 0 {name=p87641 lab=_66996_/X }
C {devices/lab_pin.sym} 88100 -17550 0 0 {name=p87642 lab=_67000_/X }
C {devices/lab_pin.sym} 88100 -17510 0 0 {name=p87643 lab=_66905_/X }
C {devices/lab_pin.sym} 88260 -17550 0 1 {name=p87644 lab=_67001_/X }
C {sky130_stdcells/a21o_4.sym} 88180 -17550 0 0 {name=X_67001_ }
C {devices/lab_pin.sym} 88140 -17410 0 0 {name=p87645 lab=_64457_/C }
C {devices/lab_pin.sym} 88220 -17410 0 1 {name=p87646 lab=_64213_/X }
C {sky130_stdcells/buf_2.sym} 88180 -17410 0 0 {name=X_64213_ }
C {devices/lab_pin.sym} 88140 -17290 0 0 {name=p87647 lab=_46349_/A }
C {devices/lab_pin.sym} 88220 -17290 0 1 {name=p87648 lab=_49161_/B }
C {sky130_stdcells/buf_2.sym} 88180 -17290 0 0 {name=X_49147_ }
C {devices/lab_pin.sym} 88120 -17190 0 0 {name=p87649 lab=_61434_/A }
C {devices/lab_pin.sym} 88120 -17150 0 0 {name=p87650 lab=_61434_/B }
C {devices/lab_pin.sym} 88120 -17110 0 0 {name=p87651 lab=_79150_/B }
C {devices/lab_pin.sym} 88240 -17150 0 1 {name=p87652 lab=_61425_/Y }
C {sky130_stdcells/nor3_4.sym} 88180 -17150 0 0 {name=X_61425_ }
C {devices/lab_pin.sym} 88120 -17020 0 0 {name=p87653 lab=_82936_/Q }
C {devices/lab_pin.sym} 88120 -16980 0 0 {name=p87654 lab=_46380_/B }
C {devices/lab_pin.sym} 88240 -17000 0 1 {name=p87655 lab=_46359_/X }
C {sky130_stdcells/or2_4.sym} 88180 -17000 0 0 {name=X_46359_ }
C {devices/lab_pin.sym} 88120 -16880 0 0 {name=p87656 lab=_65181_/Y }
C {devices/lab_pin.sym} 88120 -16840 0 0 {name=p87657 lab=_65192_/Y }
C {devices/lab_pin.sym} 88240 -16860 0 1 {name=p87658 lab=_65193_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -16860 0 0 {name=X_65193_ }
C {devices/lab_pin.sym} 88120 -16740 0 0 {name=p87659 lab=_82011_/Q }
C {devices/lab_pin.sym} 88120 -16700 0 0 {name=p87660 lab=_82299_/D }
C {devices/lab_pin.sym} 88240 -16720 0 1 {name=p87661 lab=_77184_/A }
C {sky130_stdcells/xor2_4.sym} 88180 -16720 0 0 {name=X_77179_ }
C {devices/lab_pin.sym} 88120 -16620 0 0 {name=p87662 lab=_63672_/B }
C {devices/lab_pin.sym} 88120 -16580 0 0 {name=p87663 lab=_64190_/B }
C {devices/lab_pin.sym} 88120 -16540 0 0 {name=p87664 lab=_64178_/C }
C {devices/lab_pin.sym} 88120 -16500 0 0 {name=p87665 lab=_64091_/D }
C {devices/lab_pin.sym} 88240 -16560 0 1 {name=p87666 lab=_64144_/Y }
C {sky130_stdcells/nand4_4.sym} 88180 -16560 0 0 {name=X_64144_ }
C {devices/lab_pin.sym} 88100 -16430 0 0 {name=p87667 lab=_49018_/X }
C {devices/lab_pin.sym} 88100 -16390 0 0 {name=p87668 lab=_48576_/A }
C {devices/lab_pin.sym} 88100 -16350 0 0 {name=p87669 lab=_49077_/Y }
C {devices/lab_pin.sym} 88260 -16390 0 1 {name=p87670 lab=_49079_/A }
C {sky130_stdcells/a21o_4.sym} 88180 -16390 0 0 {name=X_49078_ }
C {devices/lab_pin.sym} 88140 -16250 0 0 {name=p87671 lab=_84855_/Q }
C {devices/lab_pin.sym} 88220 -16250 0 1 {name=p87672 lab=_61356_/X }
C {sky130_stdcells/buf_2.sym} 88180 -16250 0 0 {name=X_61356_ }
C {devices/lab_pin.sym} 88100 -16150 0 0 {name=p87673 lab=_80173_/Y }
C {devices/lab_pin.sym} 88100 -16110 0 0 {name=p87674 lab=_80176_/Y }
C {devices/lab_pin.sym} 88100 -16070 0 0 {name=p87675 lab=_80189_/Y }
C {devices/lab_pin.sym} 88260 -16110 0 1 {name=p87676 lab=_80190_/X }
C {sky130_stdcells/o21a_4.sym} 88180 -16110 0 0 {name=X_80190_ }
C {devices/lab_pin.sym} 88100 -15990 0 0 {name=p87677 lab=_48025_/Y }
C {devices/lab_pin.sym} 88100 -15950 0 0 {name=p87678 lab=_48007_/X }
C {devices/lab_pin.sym} 88100 -15910 0 0 {name=p87679 lab=_48028_/X }
C {devices/lab_pin.sym} 88260 -15950 0 1 {name=p87680 lab=_48029_/Y }
C {sky130_stdcells/a21oi_4.sym} 88180 -15950 0 0 {name=X_48029_ }
C {devices/lab_pin.sym} 88100 -15850 0 0 {name=p87681 lab=_60305_/Y }
C {devices/lab_pin.sym} 88100 -15810 0 0 {name=p87682 lab=_60306_/Y }
C {devices/lab_pin.sym} 88100 -15770 0 0 {name=p87683 lab=_60286_/X }
C {devices/lab_pin.sym} 88100 -15730 0 0 {name=p87684 lab=_79764_/A }
C {devices/lab_pin.sym} 88100 -15690 0 0 {name=p87685 lab=_59814_/X }
C {devices/lab_pin.sym} 88260 -15770 0 1 {name=p87686 lab=_60307_/X }
C {sky130_stdcells/o32a_4.sym} 88180 -15770 0 0 {name=X_60307_ }
C {devices/lab_pin.sym} 88100 -15640 0 0 {name=p87687 lab=_68929_/X }
C {devices/lab_pin.sym} 88100 -15600 0 0 {name=p87688 lab=_68940_/Y }
C {devices/lab_pin.sym} 88100 -15560 0 0 {name=p87689 lab=_68824_/X }
C {devices/lab_pin.sym} 88100 -15520 0 0 {name=p87690 lab=_68951_/Y }
C {devices/lab_pin.sym} 88260 -15580 0 1 {name=p87691 lab=_68952_/X }
C {sky130_stdcells/a211o_4.sym} 88180 -15580 0 0 {name=X_68952_ }
C {devices/lab_pin.sym} 88100 -15450 0 0 {name=p87692 lab=_64072_/X }
C {devices/lab_pin.sym} 88100 -15410 0 0 {name=p87693 lab=_64073_/X }
C {devices/lab_pin.sym} 88100 -15370 0 0 {name=p87694 lab=_64074_/Y }
C {devices/lab_pin.sym} 88260 -15410 0 1 {name=p87695 lab=_64075_/Y }
C {sky130_stdcells/a21oi_4.sym} 88180 -15410 0 0 {name=X_64075_ }
C {devices/lab_pin.sym} 88120 -15300 0 0 {name=p87696 lab=_61287_/A }
C {devices/lab_pin.sym} 88120 -15260 0 0 {name=p87697 lab=_61284_/Y }
C {devices/lab_pin.sym} 88120 -15220 0 0 {name=p87698 lab=_72621_/B }
C {devices/lab_pin.sym} 88120 -15180 0 0 {name=p87699 lab=_61287_/D }
C {devices/lab_pin.sym} 88240 -15240 0 1 {name=p87700 lab=_61306_/A }
C {sky130_stdcells/nand4_4.sym} 88180 -15240 0 0 {name=X_61287_ }
C {devices/lab_pin.sym} 88140 -15090 0 0 {name=p87701 lab=_51013_/A }
C {devices/lab_pin.sym} 88220 -15090 0 1 {name=p87702 lab=_51045_/B }
C {sky130_stdcells/buf_2.sym} 88180 -15090 0 0 {name=X_51040_ }
C {devices/lab_pin.sym} 88120 -14980 0 0 {name=p87703 lab=_67955_/A }
C {devices/lab_pin.sym} 88120 -14940 0 0 {name=p87704 lab=_87195_/Q }
C {devices/lab_pin.sym} 88240 -14960 0 1 {name=p87705 lab=_67903_/X }
C {sky130_stdcells/and2_4.sym} 88180 -14960 0 0 {name=X_67903_ }
C {devices/lab_pin.sym} 88120 -14860 0 0 {name=p87706 lab=_60562_/B }
C {devices/lab_pin.sym} 88120 -14820 0 0 {name=p87707 lab=_64235_/B }
C {devices/lab_pin.sym} 88120 -14780 0 0 {name=p87708 lab=_63347_/C }
C {devices/lab_pin.sym} 88120 -14740 0 0 {name=p87709 lab=_60541_/B }
C {devices/lab_pin.sym} 88240 -14800 0 1 {name=p87710 lab=_63026_/X }
C {sky130_stdcells/and4_4.sym} 88180 -14800 0 0 {name=X_63026_ }
C {devices/lab_pin.sym} 88100 -14680 0 0 {name=p87711 lab=_60233_/Y }
C {devices/lab_pin.sym} 88100 -14640 0 0 {name=p87712 lab=_60324_/A }
C {devices/lab_pin.sym} 88100 -14600 0 0 {name=p87713 lab=_60259_/B }
C {devices/lab_pin.sym} 88100 -14560 0 0 {name=p87714 lab=_60350_/A }
C {devices/lab_pin.sym} 88260 -14620 0 1 {name=p87715 lab=_60238_/Y }
C {sky130_stdcells/a22oi_4.sym} 88180 -14620 0 0 {name=X_60238_ }
C {devices/lab_pin.sym} 88140 -14470 0 0 {name=p87716 lab=_68377_/A }
C {devices/lab_pin.sym} 88220 -14470 0 1 {name=p87717 lab=_68883_/X }
C {sky130_stdcells/buf_2.sym} 88180 -14470 0 0 {name=X_68883_ }
C {devices/lab_pin.sym} 88090 -14350 0 0 {name=p87718 lab=_82284_/CLK }
C {devices/lab_pin.sym} 88090 -14330 0 0 {name=p87719 lab=_78211_/B }
C {devices/lab_pin.sym} 88270 -14350 0 1 {name=p87720 lab=_82900_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -14340 0 0 {name=X_82900_ }
C {devices/lab_pin.sym} 88140 -14210 0 0 {name=p87721 lab=_68640_/A }
C {devices/lab_pin.sym} 88220 -14210 0 1 {name=p87722 lab=_67834_/X }
C {sky130_stdcells/buf_2.sym} 88180 -14210 0 0 {name=X_67834_ }
C {devices/lab_pin.sym} 88140 -14090 0 0 {name=p87723 lab=_60239_/A }
C {devices/lab_pin.sym} 88220 -14090 0 1 {name=p87724 lab=_60170_/A }
C {sky130_stdcells/inv_2.sym} 88180 -14090 0 0 {name=X_60169_ }
C {devices/lab_pin.sym} 88090 -13970 0 0 {name=p87725 lab=_82557_/CLK }
C {devices/lab_pin.sym} 88090 -13950 0 0 {name=p87726 lab=_69983_/X }
C {devices/lab_pin.sym} 88270 -13970 0 1 {name=p87727 lab=_82560_/D }
C {sky130_stdcells/dfxtp_4.sym} 88180 -13960 0 0 {name=X_83880_ }
C {devices/lab_pin.sym} 88090 -13830 0 0 {name=p87728 lab=_84119_/CLK }
C {devices/lab_pin.sym} 88090 -13810 0 0 {name=p87729 lab=_82831_/D }
C {devices/lab_pin.sym} 88270 -13830 0 1 {name=p87730 lab=_82831_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -13820 0 0 {name=X_82831_ }
C {devices/lab_pin.sym} 88100 -13720 0 0 {name=p87731 lab=_87457_/Q }
C {devices/lab_pin.sym} 88100 -13680 0 0 {name=p87732 lab=_67717_/X }
C {devices/lab_pin.sym} 88100 -13640 0 0 {name=p87733 lab=_67718_/X }
C {devices/lab_pin.sym} 88100 -13600 0 0 {name=p87734 lab=_67764_/X }
C {devices/lab_pin.sym} 88260 -13660 0 1 {name=p87735 lab=_67765_/X }
C {sky130_stdcells/a211o_4.sym} 88180 -13660 0 0 {name=X_67765_ }
C {devices/lab_pin.sym} 88120 -13520 0 0 {name=p87736 lab=_52999_/A }
C {devices/lab_pin.sym} 88120 -13480 0 0 {name=p87737 lab=_52991_/B }
C {devices/lab_pin.sym} 88240 -13500 0 1 {name=p87738 lab=_52991_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -13500 0 0 {name=X_52991_ }
C {devices/lab_pin.sym} 88100 -13400 0 0 {name=p87739 lab=_44149_/X }
C {devices/lab_pin.sym} 88100 -13360 0 0 {name=p87740 lab=_85523_/Q }
C {devices/lab_pin.sym} 88100 -13320 0 0 {name=p87741 lab=_64571_/X }
C {devices/lab_pin.sym} 88100 -13280 0 0 {name=p87742 lab=_64976_/X }
C {devices/lab_pin.sym} 88260 -13340 0 1 {name=p87743 lab=_64977_/X }
C {sky130_stdcells/a211o_4.sym} 88180 -13340 0 0 {name=X_64977_ }
C {devices/lab_pin.sym} 88140 -13190 0 0 {name=p87744 lab=_69696_/A }
C {devices/lab_pin.sym} 88220 -13190 0 1 {name=p87745 lab=_69504_/X }
C {sky130_stdcells/buf_2.sym} 88180 -13190 0 0 {name=X_69504_ }
C {devices/lab_pin.sym} 88140 -13070 0 0 {name=p87746 lab=_54321_/A }
C {devices/lab_pin.sym} 88220 -13070 0 1 {name=p87747 lab=_54758_/A }
C {sky130_stdcells/buf_2.sym} 88180 -13070 0 0 {name=X_54730_ }
C {devices/lab_pin.sym} 88140 -12950 0 0 {name=p87748 lab=_64706_/A }
C {devices/lab_pin.sym} 88220 -12950 0 1 {name=p87749 lab=_66717_/A }
C {sky130_stdcells/buf_2.sym} 88180 -12950 0 0 {name=X_66716_ }
C {devices/lab_pin.sym} 88090 -12830 0 0 {name=p87750 lab=_85535_/CLK }
C {devices/lab_pin.sym} 88090 -12810 0 0 {name=p87751 lab=_85550_/D }
C {devices/lab_pin.sym} 88270 -12830 0 1 {name=p87752 lab=_85550_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -12820 0 0 {name=X_85550_ }
C {devices/lab_pin.sym} 88100 -12710 0 0 {name=p87753 lab=_51940_/Y }
C {devices/lab_pin.sym} 88100 -12670 0 0 {name=p87754 lab=_51934_/X }
C {devices/lab_pin.sym} 88100 -12630 0 0 {name=p87755 lab=_51941_/Y }
C {devices/lab_pin.sym} 88260 -12670 0 1 {name=p87756 lab=_51942_/Y }
C {sky130_stdcells/a21boi_4.sym} 88180 -12670 0 0 {name=X_51942_ }
C {devices/lab_pin.sym} 88140 -12530 0 0 {name=p87757 lab=_63644_/A }
C {devices/lab_pin.sym} 88220 -12530 0 1 {name=p87758 lab=_63960_/A }
C {sky130_stdcells/buf_2.sym} 88180 -12530 0 0 {name=X_63928_ }
C {devices/lab_pin.sym} 88090 -12410 0 0 {name=p87759 lab=_82768_/CLK }
C {devices/lab_pin.sym} 88090 -12390 0 0 {name=p87760 lab=_82762_/D }
C {devices/lab_pin.sym} 88270 -12410 0 1 {name=p87761 lab=_82954_/D }
C {sky130_stdcells/dfxtp_4.sym} 88180 -12400 0 0 {name=X_82762_ }
C {devices/lab_pin.sym} 88120 -12280 0 0 {name=p87762 lab=_67696_/A }
C {devices/lab_pin.sym} 88120 -12240 0 0 {name=p87763 lab=_88164_/Q }
C {devices/lab_pin.sym} 88240 -12260 0 1 {name=p87764 lab=_67696_/X }
C {sky130_stdcells/and2_4.sym} 88180 -12260 0 0 {name=X_67696_ }
C {devices/lab_pin.sym} 88090 -12130 0 0 {name=p87765 lab=_84501_/CLK }
C {devices/lab_pin.sym} 88090 -12110 0 0 {name=p87766 lab=_84501_/D }
C {devices/lab_pin.sym} 88270 -12130 0 1 {name=p87767 lab=_75903_/A }
C {sky130_stdcells/dfxtp_4.sym} 88180 -12120 0 0 {name=X_84501_ }
C {devices/lab_pin.sym} 88090 -11990 0 0 {name=p87768 lab=_81749_/CLK }
C {devices/lab_pin.sym} 88090 -11970 0 0 {name=p87769 lab=_81713_/D }
C {devices/lab_pin.sym} 88270 -11990 0 1 {name=p87770 lab=_81713_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -11980 0 0 {name=X_81713_ }
C {devices/lab_pin.sym} 88100 -11870 0 0 {name=p87771 lab=_68900_/X }
C {devices/lab_pin.sym} 88100 -11830 0 0 {name=p87772 lab=_68903_/X }
C {devices/lab_pin.sym} 88100 -11790 0 0 {name=p87773 lab=_69418_/X }
C {devices/lab_pin.sym} 88260 -11830 0 1 {name=p87774 lab=_69435_/Y }
C {sky130_stdcells/a21oi_4.sym} 88180 -11830 0 0 {name=X_69435_ }
C {devices/lab_pin.sym} 88100 -11710 0 0 {name=p87775 lab=_85401_/Q }
C {devices/lab_pin.sym} 88100 -11670 0 0 {name=p87776 lab=_54648_/X }
C {devices/lab_pin.sym} 88100 -11630 0 0 {name=p87777 lab=_54660_/Y }
C {devices/lab_pin.sym} 88260 -11670 0 1 {name=p87778 lab=_54661_/Y }
C {sky130_stdcells/o21ai_4.sym} 88180 -11670 0 0 {name=X_54661_ }
C {devices/lab_pin.sym} 88140 -11530 0 0 {name=p87779 lab=_66647_/A }
C {devices/lab_pin.sym} 88220 -11530 0 1 {name=p87780 lab=_66669_/A }
C {sky130_stdcells/buf_2.sym} 88180 -11530 0 0 {name=X_66647_ }
C {devices/lab_pin.sym} 88090 -11410 0 0 {name=p87781 lab=_84926_/CLK }
C {devices/lab_pin.sym} 88090 -11390 0 0 {name=p87782 lab=_85481_/D }
C {devices/lab_pin.sym} 88270 -11410 0 1 {name=p87783 lab=_85481_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -11400 0 0 {name=X_85481_ }
C {devices/lab_pin.sym} 88140 -11270 0 0 {name=p87784 lab=_51900_/A }
C {devices/lab_pin.sym} 88220 -11270 0 1 {name=p87785 lab=_51873_/X }
C {sky130_stdcells/buf_2.sym} 88180 -11270 0 0 {name=X_51873_ }
C {devices/lab_pin.sym} 88120 -11180 0 0 {name=p87786 lab=_63853_/Y }
C {devices/lab_pin.sym} 88120 -11140 0 0 {name=p87787 lab=_63859_/B }
C {devices/lab_pin.sym} 88120 -11100 0 0 {name=p87788 lab=_63857_/Y }
C {devices/lab_pin.sym} 88120 -11060 0 0 {name=p87789 lab=_63859_/D }
C {devices/lab_pin.sym} 88240 -11120 0 1 {name=p87790 lab=_63859_/X }
C {sky130_stdcells/and4_4.sym} 88180 -11120 0 0 {name=X_63859_ }
C {devices/lab_pin.sym} 88090 -10970 0 0 {name=p87791 lab=_82923_/CLK }
C {devices/lab_pin.sym} 88090 -10950 0 0 {name=p87792 lab=_78838_/X }
C {devices/lab_pin.sym} 88270 -10970 0 1 {name=p87793 lab=_82681_/D }
C {sky130_stdcells/dfxtp_4.sym} 88180 -10960 0 0 {name=X_82693_ }
C {devices/lab_pin.sym} 88100 -10850 0 0 {name=p87794 lab=_56372_/X }
C {devices/lab_pin.sym} 88100 -10810 0 0 {name=p87795 lab=_56050_/X }
C {devices/lab_pin.sym} 88100 -10770 0 0 {name=p87796 lab=_56399_/Y }
C {devices/lab_pin.sym} 88260 -10810 0 1 {name=p87797 lab=_85209_/D }
C {sky130_stdcells/o21ai_4.sym} 88180 -10810 0 0 {name=X_56400_ }
C {devices/lab_pin.sym} 88090 -10670 0 0 {name=p87798 lab=_87141_/CLK }
C {devices/lab_pin.sym} 88090 -10650 0 0 {name=p87799 lab=_43881_/X }
C {devices/lab_pin.sym} 88270 -10670 0 1 {name=p87800 lab=_69125_/B }
C {sky130_stdcells/dfxtp_4.sym} 88180 -10660 0 0 {name=X_87220_ }
C {devices/lab_pin.sym} 88120 -10540 0 0 {name=p87801 lab=_53611_/X }
C {devices/lab_pin.sym} 88120 -10500 0 0 {name=p87802 lab=_48153_/A }
C {devices/lab_pin.sym} 88240 -10520 0 1 {name=p87803 lab=_53612_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -10520 0 0 {name=X_53612_ }
C {devices/lab_pin.sym} 88090 -10390 0 0 {name=p87804 lab=_84430_/CLK }
C {devices/lab_pin.sym} 88090 -10370 0 0 {name=p87805 lab=_84432_/D }
C {devices/lab_pin.sym} 88270 -10390 0 1 {name=p87806 lab=_62122_/C }
C {sky130_stdcells/dfxtp_4.sym} 88180 -10380 0 0 {name=X_84432_ }
C {devices/lab_pin.sym} 88140 -10250 0 0 {name=p87807 lab=_50724_/A }
C {devices/lab_pin.sym} 88220 -10250 0 1 {name=p87808 lab=_50825_/B }
C {sky130_stdcells/buf_2.sym} 88180 -10250 0 0 {name=X_50824_ }
C {devices/lab_pin.sym} 88140 -10130 0 0 {name=p87809 lab=_57379_/Y }
C {devices/lab_pin.sym} 88220 -10130 0 1 {name=p87810 lab=_57380_/X }
C {sky130_stdcells/buf_2.sym} 88180 -10130 0 0 {name=X_57380_ }
C {devices/lab_pin.sym} 88090 -10010 0 0 {name=p87811 lab=_81620_/CLK }
C {devices/lab_pin.sym} 88090 -9990 0 0 {name=p87812 lab=_81676_/Q }
C {devices/lab_pin.sym} 88270 -10010 0 1 {name=p87813 lab=_81644_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -10000 0 0 {name=X_81644_ }
C {devices/lab_pin.sym} 88100 -9890 0 0 {name=p87814 lab=_81393_/D }
C {devices/lab_pin.sym} 88100 -9850 0 0 {name=p87815 lab=_69299_/X }
C {devices/lab_pin.sym} 88100 -9810 0 0 {name=p87816 lab=_69365_/X }
C {devices/lab_pin.sym} 88260 -9850 0 1 {name=p87817 lab=_83929_/D }
C {sky130_stdcells/a21bo_4.sym} 88180 -9850 0 0 {name=X_69366_ }
C {devices/lab_pin.sym} 88100 -9730 0 0 {name=p87818 lab=_54588_/Y }
C {devices/lab_pin.sym} 88100 -9690 0 0 {name=p87819 lab=_54584_/X }
C {devices/lab_pin.sym} 88100 -9650 0 0 {name=p87820 lab=_54591_/X }
C {devices/lab_pin.sym} 88260 -9690 0 1 {name=p87821 lab=_85414_/D }
C {sky130_stdcells/a21oi_4.sym} 88180 -9690 0 0 {name=X_54592_ }
C {devices/lab_pin.sym} 88100 -9580 0 0 {name=p87822 lab=_87379_/Q }
C {devices/lab_pin.sym} 88100 -9540 0 0 {name=p87823 lab=_66571_/X }
C {devices/lab_pin.sym} 88100 -9500 0 0 {name=p87824 lab=_66574_/X }
C {devices/lab_pin.sym} 88100 -9460 0 0 {name=p87825 lab=_66577_/X }
C {devices/lab_pin.sym} 88260 -9520 0 1 {name=p87826 lab=_66578_/X }
C {sky130_stdcells/a211o_4.sym} 88180 -9520 0 0 {name=X_66578_ }
C {devices/lab_pin.sym} 88100 -9390 0 0 {name=p87827 lab=_56368_/A }
C {devices/lab_pin.sym} 88100 -9350 0 0 {name=p87828 lab=_56094_/X }
C {devices/lab_pin.sym} 88100 -9310 0 0 {name=p87829 lab=_56330_/Y }
C {devices/lab_pin.sym} 88260 -9350 0 1 {name=p87830 lab=_85233_/D }
C {sky130_stdcells/o21ai_4.sym} 88180 -9350 0 0 {name=X_56331_ }
C {devices/lab_pin.sym} 88100 -9230 0 0 {name=p87831 lab=_82632_/D }
C {devices/lab_pin.sym} 88100 -9190 0 0 {name=p87832 lab=_68299_/X }
C {devices/lab_pin.sym} 88100 -9150 0 0 {name=p87833 lab=_68316_/X }
C {devices/lab_pin.sym} 88260 -9190 0 1 {name=p87834 lab=_83984_/D }
C {sky130_stdcells/a21bo_4.sym} 88180 -9190 0 0 {name=X_68317_ }
C {devices/lab_pin.sym} 88090 -9050 0 0 {name=p87835 lab=_87150_/CLK }
C {devices/lab_pin.sym} 88090 -9030 0 0 {name=p87836 lab=_87151_/D }
C {devices/lab_pin.sym} 88270 -9050 0 1 {name=p87837 lab=_87151_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -9040 0 0 {name=X_87151_ }
C {devices/lab_pin.sym} 88100 -8930 0 0 {name=p87838 lab=_85616_/Q }
C {devices/lab_pin.sym} 88100 -8890 0 0 {name=p87839 lab=_53540_/X }
C {devices/lab_pin.sym} 88100 -8850 0 0 {name=p87840 lab=_53542_/Y }
C {devices/lab_pin.sym} 88260 -8890 0 1 {name=p87841 lab=_53543_/Y }
C {sky130_stdcells/o21ai_4.sym} 88180 -8890 0 0 {name=X_53543_ }
C {devices/lab_pin.sym} 88140 -8750 0 0 {name=p87842 lab=_65529_/A }
C {devices/lab_pin.sym} 88220 -8750 0 1 {name=p87843 lab=_65529_/X }
C {sky130_stdcells/buf_2.sym} 88180 -8750 0 0 {name=X_65529_ }
C {devices/lab_pin.sym} 88090 -8630 0 0 {name=p87844 lab=_84559_/CLK }
C {devices/lab_pin.sym} 88090 -8610 0 0 {name=p87845 lab=_62989_/Y }
C {devices/lab_pin.sym} 88270 -8630 0 1 {name=p87846 lab=_62988_/C }
C {sky130_stdcells/dfxtp_4.sym} 88180 -8620 0 0 {name=X_84363_ }
C {devices/lab_pin.sym} 88120 -8510 0 0 {name=p87847 lab=_50755_/A }
C {devices/lab_pin.sym} 88120 -8470 0 0 {name=p87848 lab=_50751_/B }
C {devices/lab_pin.sym} 88120 -8430 0 0 {name=p87849 lab=_50751_/C }
C {devices/lab_pin.sym} 88240 -8470 0 1 {name=p87850 lab=_50755_/X }
C {sky130_stdcells/and3_4.sym} 88180 -8470 0 0 {name=X_50755_ }
C {devices/lab_pin.sym} 88090 -8330 0 0 {name=p87851 lab=_81575_/CLK }
C {devices/lab_pin.sym} 88090 -8310 0 0 {name=p87852 lab=_84175_/Q }
C {devices/lab_pin.sym} 88270 -8330 0 1 {name=p87853 lab=_76695_/A }
C {sky130_stdcells/dfxtp_4.sym} 88180 -8320 0 0 {name=X_81575_ }
C {devices/lab_pin.sym} 88100 -8220 0 0 {name=p87854 lab=_69216_/X }
C {devices/lab_pin.sym} 88100 -8180 0 0 {name=p87855 lab=_69293_/Y }
C {devices/lab_pin.sym} 88100 -8140 0 0 {name=p87856 lab=_69231_/X }
C {devices/lab_pin.sym} 88100 -8100 0 0 {name=p87857 lab=_69296_/Y }
C {devices/lab_pin.sym} 88260 -8160 0 1 {name=p87858 lab=_69297_/X }
C {sky130_stdcells/a211o_4.sym} 88180 -8160 0 0 {name=X_69297_ }
C {devices/lab_pin.sym} 88090 -8010 0 0 {name=p87859 lab=_82956_/CLK }
C {devices/lab_pin.sym} 88090 -7990 0 0 {name=p87860 lab=_50949_/Y }
C {devices/lab_pin.sym} 88270 -8010 0 1 {name=p87861 lab=_86102_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -8000 0 0 {name=X_86102_ }
C {devices/lab_pin.sym} 88100 -7890 0 0 {name=p87862 lab=_59033_/X }
C {devices/lab_pin.sym} 88100 -7850 0 0 {name=p87863 lab=_85437_/Q }
C {devices/lab_pin.sym} 88100 -7810 0 0 {name=p87864 lab=_59049_/X }
C {devices/lab_pin.sym} 88260 -7850 0 1 {name=p87865 lab=_59050_/Y }
C {sky130_stdcells/o21ai_4.sym} 88180 -7850 0 0 {name=X_59050_ }
C {devices/lab_pin.sym} 88090 -7710 0 0 {name=p87866 lab=_83325_/CLK }
C {devices/lab_pin.sym} 88090 -7690 0 0 {name=p87867 lab=_71956_/X }
C {devices/lab_pin.sym} 88270 -7710 0 1 {name=p87868 lab=_83314_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -7700 0 0 {name=X_83314_ }
C {devices/lab_pin.sym} 88120 -7580 0 0 {name=p87869 lab=_80526_/A }
C {devices/lab_pin.sym} 88120 -7540 0 0 {name=p87870 lab=_80526_/B }
C {devices/lab_pin.sym} 88240 -7560 0 1 {name=p87871 lab=_80536_/B }
C {sky130_stdcells/xor2_4.sym} 88180 -7560 0 0 {name=X_80526_ }
C {devices/lab_pin.sym} 88100 -7450 0 0 {name=p87872 lab=_56148_/X }
C {devices/lab_pin.sym} 88100 -7410 0 0 {name=p87873 lab=_56255_/X }
C {devices/lab_pin.sym} 88100 -7370 0 0 {name=p87874 lab=_56261_/Y }
C {devices/lab_pin.sym} 88260 -7410 0 1 {name=p87875 lab=_85255_/D }
C {sky130_stdcells/o21ai_4.sym} 88180 -7410 0 0 {name=X_56262_ }
C {devices/lab_pin.sym} 88100 -7290 0 0 {name=p87876 lab=_67538_/X }
C {devices/lab_pin.sym} 88100 -7250 0 0 {name=p87877 lab=_67541_/X }
C {devices/lab_pin.sym} 88100 -7210 0 0 {name=p87878 lab=_68216_/X }
C {devices/lab_pin.sym} 88260 -7250 0 1 {name=p87879 lab=_68248_/Y }
C {sky130_stdcells/a21oi_4.sym} 88180 -7250 0 0 {name=X_68248_ }
C {devices/lab_pin.sym} 88090 -7110 0 0 {name=p87880 lab=_87083_/CLK }
C {devices/lab_pin.sym} 88090 -7090 0 0 {name=p87881 lab=_87082_/D }
C {devices/lab_pin.sym} 88270 -7110 0 1 {name=p87882 lab=_87082_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -7100 0 0 {name=X_87082_ }
C {devices/lab_pin.sym} 88120 -6990 0 0 {name=p87883 lab=_48196_/A }
C {devices/lab_pin.sym} 88120 -6950 0 0 {name=p87884 lab=_53474_/B }
C {devices/lab_pin.sym} 88120 -6910 0 0 {name=p87885 lab=_51352_/C }
C {devices/lab_pin.sym} 88240 -6950 0 1 {name=p87886 lab=_53474_/X }
C {sky130_stdcells/and3_4.sym} 88180 -6950 0 0 {name=X_53474_ }
C {devices/lab_pin.sym} 88090 -6810 0 0 {name=p87887 lab=_84671_/CLK }
C {devices/lab_pin.sym} 88090 -6790 0 0 {name=p87888 lab=_63801_/Y }
C {devices/lab_pin.sym} 88270 -6810 0 1 {name=p87889 lab=_63800_/C }
C {sky130_stdcells/dfxtp_4.sym} 88180 -6800 0 0 {name=X_84294_ }
C {devices/lab_pin.sym} 88120 -6680 0 0 {name=p87890 lab=_50682_/A }
C {devices/lab_pin.sym} 88120 -6640 0 0 {name=p87891 lab=_49125_/X }
C {devices/lab_pin.sym} 88240 -6660 0 1 {name=p87892 lab=_50686_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -6660 0 0 {name=X_50686_ }
C {devices/lab_pin.sym} 88100 -6550 0 0 {name=p87893 lab=_57926_/X }
C {devices/lab_pin.sym} 88100 -6510 0 0 {name=p87894 lab=_85997_/Q }
C {devices/lab_pin.sym} 88100 -6470 0 0 {name=p87895 lab=_58000_/X }
C {devices/lab_pin.sym} 88260 -6510 0 1 {name=p87896 lab=_58001_/Y }
C {sky130_stdcells/o21ai_4.sym} 88180 -6510 0 0 {name=X_58001_ }
C {devices/lab_pin.sym} 88120 -6380 0 0 {name=p87897 lab=_55149_/A }
C {devices/lab_pin.sym} 88120 -6340 0 0 {name=p87898 lab=_84994_/Q }
C {devices/lab_pin.sym} 88240 -6360 0 1 {name=p87899 lab=_55213_/X }
C {sky130_stdcells/and2_4.sym} 88180 -6360 0 0 {name=X_55213_ }
C {devices/lab_pin.sym} 88090 -6230 0 0 {name=p87900 lab=_86040_/CLK }
C {devices/lab_pin.sym} 88090 -6210 0 0 {name=p87901 lab=_51319_/Y }
C {devices/lab_pin.sym} 88270 -6230 0 1 {name=p87902 lab=_65025_/B }
C {sky130_stdcells/dfxtp_4.sym} 88180 -6220 0 0 {name=X_86033_ }
C {devices/lab_pin.sym} 88100 -6110 0 0 {name=p87903 lab=_85825_/Q }
C {devices/lab_pin.sym} 88100 -6070 0 0 {name=p87904 lab=_52422_/X }
C {devices/lab_pin.sym} 88100 -6030 0 0 {name=p87905 lab=_52424_/Y }
C {devices/lab_pin.sym} 88260 -6070 0 1 {name=p87906 lab=_52425_/Y }
C {sky130_stdcells/o21ai_4.sym} 88180 -6070 0 0 {name=X_52425_ }
C {devices/lab_pin.sym} 88090 -5930 0 0 {name=p87907 lab=_84892_/CLK }
C {devices/lab_pin.sym} 88090 -5910 0 0 {name=p87908 lab=_72495_/X }
C {devices/lab_pin.sym} 88270 -5930 0 1 {name=p87909 lab=_83245_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -5920 0 0 {name=X_83245_ }
C {devices/lab_pin.sym} 88100 -5810 0 0 {name=p87910 lab=_56188_/X }
C {devices/lab_pin.sym} 88100 -5770 0 0 {name=p87911 lab=_55987_/X }
C {devices/lab_pin.sym} 88100 -5730 0 0 {name=p87912 lab=_56192_/Y }
C {devices/lab_pin.sym} 88260 -5770 0 1 {name=p87913 lab=_85281_/D }
C {sky130_stdcells/o21ai_4.sym} 88180 -5770 0 0 {name=X_56193_ }
C {devices/lab_pin.sym} 88120 -5640 0 0 {name=p87914 lab=_80457_/A }
C {devices/lab_pin.sym} 88120 -5600 0 0 {name=p87915 lab=_80456_/Y }
C {devices/lab_pin.sym} 88240 -5620 0 1 {name=p87916 lab=_80457_/X }
C {sky130_stdcells/xor2_4.sym} 88180 -5620 0 0 {name=X_80457_ }
C {devices/lab_pin.sym} 88100 -5510 0 0 {name=p87917 lab=_82059_/D }
C {devices/lab_pin.sym} 88100 -5470 0 0 {name=p87918 lab=_68160_/X }
C {devices/lab_pin.sym} 88100 -5430 0 0 {name=p87919 lab=_68178_/X }
C {devices/lab_pin.sym} 88260 -5470 0 1 {name=p87920 lab=_68179_/X }
C {sky130_stdcells/a21bo_4.sym} 88180 -5470 0 0 {name=X_68179_ }
C {devices/lab_pin.sym} 88120 -5360 0 0 {name=p87921 lab=_70214_/A }
C {devices/lab_pin.sym} 88120 -5320 0 0 {name=p87922 lab=_70214_/B }
C {devices/lab_pin.sym} 88120 -5280 0 0 {name=p87923 lab=_70210_/C }
C {devices/lab_pin.sym} 88120 -5240 0 0 {name=p87924 lab=_70204_/X }
C {devices/lab_pin.sym} 88240 -5300 0 1 {name=p87925 lab=_70210_/X }
C {sky130_stdcells/and4_4.sym} 88180 -5300 0 0 {name=X_70210_ }
C {devices/lab_pin.sym} 88140 -5150 0 0 {name=p87926 lab=_85131_/Q }
C {devices/lab_pin.sym} 88220 -5150 0 1 {name=p87927 lab=_55145_/B }
C {sky130_stdcells/inv_2.sym} 88180 -5150 0 0 {name=X_55144_ }
C {devices/lab_pin.sym} 88100 -5050 0 0 {name=p87928 lab=_52354_/Y }
C {devices/lab_pin.sym} 88100 -5010 0 0 {name=p87929 lab=_52340_/X }
C {devices/lab_pin.sym} 88100 -4970 0 0 {name=p87930 lab=_52355_/X }
C {devices/lab_pin.sym} 88260 -5010 0 1 {name=p87931 lab=_85839_/D }
C {sky130_stdcells/a21oi_4.sym} 88180 -5010 0 0 {name=X_52356_ }
C {devices/lab_pin.sym} 88100 -4890 0 0 {name=p87932 lab=_41061_/A }
C {devices/lab_pin.sym} 88100 -4850 0 0 {name=p87933 lab=_82335_/Q }
C {devices/lab_pin.sym} 88100 -4810 0 0 {name=p87934 lab=_40369_/X }
C {devices/lab_pin.sym} 88260 -4850 0 1 {name=p87935 lab=_40370_/X }
C {sky130_stdcells/o21a_4.sym} 88180 -4850 0 0 {name=X_40370_ }
C {devices/lab_pin.sym} 88140 -4710 0 0 {name=p87936 lab=_71190_/A }
C {devices/lab_pin.sym} 88220 -4710 0 1 {name=p87937 lab=_71190_/X }
C {sky130_stdcells/buf_2.sym} 88180 -4710 0 0 {name=X_71190_ }
C {devices/lab_pin.sym} 88090 -4590 0 0 {name=p87938 lab=_83508_/CLK }
C {devices/lab_pin.sym} 88090 -4570 0 0 {name=p87939 lab=_72793_/X }
C {devices/lab_pin.sym} 88270 -4590 0 1 {name=p87940 lab=_83176_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -4580 0 0 {name=X_83176_ }
C {devices/lab_pin.sym} 88120 -4460 0 0 {name=p87941 lab=_84754_/Q }
C {devices/lab_pin.sym} 88120 -4420 0 0 {name=p87942 lab=_66247_/C }
C {devices/lab_pin.sym} 88240 -4440 0 1 {name=p87943 lab=_80388_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -4440 0 0 {name=X_80388_ }
C {devices/lab_pin.sym} 88120 -4320 0 0 {name=p87944 lab=_51306_/X }
C {devices/lab_pin.sym} 88120 -4280 0 0 {name=p87945 lab=_46416_/A }
C {devices/lab_pin.sym} 88240 -4300 0 1 {name=p87946 lab=_51307_/X }
C {sky130_stdcells/and2_4.sym} 88180 -4300 0 0 {name=X_51307_ }
C {devices/lab_pin.sym} 88100 -4200 0 0 {name=p87947 lab=_83517_/Q }
C {devices/lab_pin.sym} 88100 -4160 0 0 {name=p87948 lab=_83165_/Q }
C {devices/lab_pin.sym} 88100 -4120 0 0 {name=p87949 lab=_83501_/Q }
C {devices/lab_pin.sym} 88100 -4080 0 0 {name=p87950 lab=_83149_/Q }
C {devices/lab_pin.sym} 88260 -4140 0 1 {name=p87951 lab=_70144_/B }
C {sky130_stdcells/a22oi_4.sym} 88180 -4140 0 0 {name=X_70141_ }
C {devices/lab_pin.sym} 88090 -3990 0 0 {name=p87952 lab=_83905_/CLK }
C {devices/lab_pin.sym} 88090 -3970 0 0 {name=p87953 lab=_77850_/X }
C {devices/lab_pin.sym} 88270 -3990 0 1 {name=p87954 lab=_82083_/D }
C {sky130_stdcells/dfxtp_4.sym} 88180 -3980 0 0 {name=X_82127_ }
C {devices/lab_pin.sym} 88100 -3870 0 0 {name=p87955 lab=_85323_/Q }
C {devices/lab_pin.sym} 88100 -3830 0 0 {name=p87956 lab=_55072_/X }
C {devices/lab_pin.sym} 88100 -3790 0 0 {name=p87957 lab=_55074_/Y }
C {devices/lab_pin.sym} 88260 -3830 0 1 {name=p87958 lab=_55075_/Y }
C {sky130_stdcells/o21ai_4.sym} 88180 -3830 0 0 {name=X_55075_ }
C {devices/lab_pin.sym} 88140 -3690 0 0 {name=p87959 lab=_59831_/X }
C {devices/lab_pin.sym} 88220 -3690 0 1 {name=p87960 lab=_60513_/A }
C {sky130_stdcells/buf_2.sym} 88180 -3690 0 0 {name=X_59952_ }
C {devices/lab_pin.sym} 88120 -3580 0 0 {name=p87961 lab=_52293_/A }
C {devices/lab_pin.sym} 88120 -3540 0 0 {name=p87962 lab=_52287_/B }
C {devices/lab_pin.sym} 88240 -3560 0 1 {name=p87963 lab=_52287_/Y }
C {sky130_stdcells/nand2_4.sym} 88180 -3560 0 0 {name=X_52287_ }
C {devices/lab_pin.sym} 88090 -3430 0 0 {name=p87964 lab=_87472_/CLK }
C {devices/lab_pin.sym} 88090 -3410 0 0 {name=p87965 lab=_87984_/D }
C {devices/lab_pin.sym} 88270 -3430 0 1 {name=p87966 lab=_87984_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -3420 0 0 {name=X_87984_ }
C {devices/lab_pin.sym} 88140 -3290 0 0 {name=p87967 lab=_42040_/A }
C {devices/lab_pin.sym} 88220 -3290 0 1 {name=p87968 lab=_42040_/Y }
C {sky130_stdcells/inv_2.sym} 88180 -3290 0 0 {name=X_42040_ }
C {devices/lab_pin.sym} 88140 -3170 0 0 {name=p87969 lab=_57965_/A }
C {devices/lab_pin.sym} 88220 -3170 0 1 {name=p87970 lab=_58904_/A }
C {sky130_stdcells/buf_2.sym} 88180 -3170 0 0 {name=X_58903_ }
C {devices/lab_pin.sym} 88120 -3070 0 0 {name=p87971 lab=_46449_/A }
C {devices/lab_pin.sym} 88120 -3030 0 0 {name=p87972 lab=_53964_/B }
C {devices/lab_pin.sym} 88120 -2990 0 0 {name=p87973 lab=_53969_/C }
C {devices/lab_pin.sym} 88240 -3030 0 1 {name=p87974 lab=_54026_/X }
C {sky130_stdcells/and3_4.sym} 88180 -3030 0 0 {name=X_54026_ }
C {devices/lab_pin.sym} 88120 -2910 0 0 {name=p87975 lab=_53944_/A }
C {devices/lab_pin.sym} 88120 -2870 0 0 {name=p87976 lab=_51238_/B }
C {devices/lab_pin.sym} 88120 -2830 0 0 {name=p87977 lab=_53944_/C }
C {devices/lab_pin.sym} 88240 -2870 0 1 {name=p87978 lab=_51238_/Y }
C {sky130_stdcells/nor3_4.sym} 88180 -2870 0 0 {name=X_51238_ }
C {devices/lab_pin.sym} 88100 -2760 0 0 {name=p87979 lab=_70040_/X }
C {devices/lab_pin.sym} 88100 -2720 0 0 {name=p87980 lab=_69890_/Y }
C {devices/lab_pin.sym} 88100 -2680 0 0 {name=p87981 lab=_70056_/X }
C {devices/lab_pin.sym} 88100 -2640 0 0 {name=p87982 lab=_70071_/Y }
C {devices/lab_pin.sym} 88260 -2700 0 1 {name=p87983 lab=_70072_/X }
C {sky130_stdcells/a211o_4.sym} 88180 -2700 0 0 {name=X_70072_ }
C {devices/lab_pin.sym} 88090 -2550 0 0 {name=p87984 lab=_86935_/CLK }
C {devices/lab_pin.sym} 88090 -2530 0 0 {name=p87985 lab=_86935_/D }
C {devices/lab_pin.sym} 88270 -2550 0 1 {name=p87986 lab=_67536_/B }
C {sky130_stdcells/dfxtp_4.sym} 88180 -2540 0 0 {name=X_86935_ }
C {devices/lab_pin.sym} 88090 -2410 0 0 {name=p87987 lab=_84020_/CLK }
C {devices/lab_pin.sym} 88090 -2390 0 0 {name=p87988 lab=_84018_/Q }
C {devices/lab_pin.sym} 88270 -2410 0 1 {name=p87989 lab=_82058_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -2400 0 0 {name=X_82058_ }
C {devices/lab_pin.sym} 88120 -2300 0 0 {name=p87990 lab=_59905_/B }
C {devices/lab_pin.sym} 88120 -2260 0 0 {name=p87991 lab=_59882_/X }
C {devices/lab_pin.sym} 88120 -2220 0 0 {name=p87992 lab=_59570_/A }
C {devices/lab_pin.sym} 88120 -2180 0 0 {name=p87993 lab=_60626_/A }
C {devices/lab_pin.sym} 88240 -2240 0 1 {name=p87994 lab=_59883_/Y }
C {sky130_stdcells/nor4_4.sym} 88180 -2240 0 0 {name=X_59883_ }
C {devices/lab_pin.sym} 88100 -2110 0 0 {name=p87995 lab=_86993_/Q }
C {devices/lab_pin.sym} 88100 -2070 0 0 {name=p87996 lab=_73776_/X }
C {devices/lab_pin.sym} 88100 -2030 0 0 {name=p87997 lab=_73899_/X }
C {devices/lab_pin.sym} 88260 -2070 0 1 {name=p87998 lab=_73913_/C }
C {sky130_stdcells/o21ai_4.sym} 88180 -2070 0 0 {name=X_73900_ }
C {devices/lab_pin.sym} 88090 -1930 0 0 {name=p87999 lab=_84223_/CLK }
C {devices/lab_pin.sym} 88090 -1910 0 0 {name=p88000 lab=_84217_/Q }
C {devices/lab_pin.sym} 88270 -1930 0 1 {name=p88001 lab=_81009_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -1920 0 0 {name=X_81009_ }
C {devices/lab_pin.sym} 88140 -1790 0 0 {name=p88002 lab=_58834_/A }
C {devices/lab_pin.sym} 88220 -1790 0 1 {name=p88003 lab=_59033_/A }
C {sky130_stdcells/buf_2.sym} 88180 -1790 0 0 {name=X_58834_ }
C {devices/lab_pin.sym} 88140 -1670 0 0 {name=p88004 lab=_51033_/A }
C {devices/lab_pin.sym} 88220 -1670 0 1 {name=p88005 lab=_51170_/A }
C {sky130_stdcells/buf_2.sym} 88180 -1670 0 0 {name=X_51169_ }
C {devices/lab_pin.sym} 88120 -1570 0 0 {name=p88006 lab=_74872_/Y }
C {devices/lab_pin.sym} 88120 -1530 0 0 {name=p88007 lab=_74897_/A }
C {devices/lab_pin.sym} 88120 -1490 0 0 {name=p88008 lab=_74897_/B }
C {devices/lab_pin.sym} 88240 -1530 0 1 {name=p88009 lab=_74887_/A }
C {sky130_stdcells/nand3_4.sym} 88180 -1530 0 0 {name=X_74880_ }
C {devices/lab_pin.sym} 88090 -1390 0 0 {name=p88010 lab=_86770_/CLK }
C {devices/lab_pin.sym} 88090 -1370 0 0 {name=p88011 lab=_86866_/D }
C {devices/lab_pin.sym} 88270 -1390 0 1 {name=p88012 lab=_63158_/B }
C {sky130_stdcells/dfxtp_4.sym} 88180 -1380 0 0 {name=X_86866_ }
C {devices/lab_pin.sym} 88090 -1250 0 0 {name=p88013 lab=_85529_/CLK }
C {devices/lab_pin.sym} 88090 -1230 0 0 {name=p88014 lab=_52465_/Y }
C {devices/lab_pin.sym} 88270 -1250 0 1 {name=p88015 lab=_85817_/Q }
C {sky130_stdcells/dfxtp_4.sym} 88180 -1240 0 0 {name=X_85817_ }
C {devices/lab_pin.sym} 88100 -1140 0 0 {name=p88016 lab=_73735_/X }
C {devices/lab_pin.sym} 88100 -1100 0 0 {name=p88017 lab=_85622_/Q }
C {devices/lab_pin.sym} 88100 -1060 0 0 {name=p88018 lab=_73782_/X }
C {devices/lab_pin.sym} 88100 -1020 0 0 {name=p88019 lab=_73830_/X }
C {devices/lab_pin.sym} 88260 -1080 0 1 {name=p88020 lab=_73831_/X }
C {sky130_stdcells/a211o_4.sym} 88180 -1080 0 0 {name=X_73831_ }
C {devices/lab_pin.sym} 88140 -930 0 0 {name=p88021 lab=_44315_/A }
C {devices/lab_pin.sym} 88220 -930 0 1 {name=p88022 lab=_58766_/A }
C {sky130_stdcells/buf_2.sym} 88180 -930 0 0 {name=X_58765_ }
C {devices/lab_pin.sym} 88100 -830 0 0 {name=p88023 lab=_87187_/Q }
C {devices/lab_pin.sym} 88100 -790 0 0 {name=p88024 lab=_43954_/X }
C {devices/lab_pin.sym} 88100 -750 0 0 {name=p88025 lab=_80669_/Q }
C {devices/lab_pin.sym} 88260 -790 0 1 {name=p88026 lab=_43991_/Y }
C {sky130_stdcells/o21ai_4.sym} 88180 -790 0 0 {name=X_43991_ }
C {devices/lab_pin.sym} 88100 -680 0 0 {name=p88027 lab=_56196_/C }
C {devices/lab_pin.sym} 88100 -640 0 0 {name=p88028 lab=_55690_/A }
C {devices/lab_pin.sym} 88100 -600 0 0 {name=p88029 lab=_44052_/X }
C {devices/lab_pin.sym} 88100 -560 0 0 {name=p88030 lab=_55976_/X }
C {devices/lab_pin.sym} 88260 -620 0 1 {name=p88031 lab=_55977_/X }
C {sky130_stdcells/a211o_4.sym} 88180 -620 0 0 {name=X_55977_ }
C {devices/lab_pin.sym} 89010 -42150 0 0 {name=p88032 lab=_87487_/CLK }
C {devices/lab_pin.sym} 89010 -42130 0 0 {name=p88033 lab=_86797_/D }
C {devices/lab_pin.sym} 89190 -42150 0 1 {name=p88034 lab=_66785_/B }
C {sky130_stdcells/dfxtp_4.sym} 89100 -42140 0 0 {name=X_86797_ }
C {devices/lab_pin.sym} 89060 -42010 0 0 {name=p88035 lab=_62057_/D }
C {devices/lab_pin.sym} 89140 -42010 0 1 {name=p88036 lab=_61582_/A }
C {sky130_stdcells/buf_2.sym} 89100 -42010 0 0 {name=X_45730_ }
C {devices/lab_pin.sym} 89060 -41890 0 0 {name=p88037 lab=_57716_/A }
C {devices/lab_pin.sym} 89140 -41890 0 1 {name=p88038 lab=_58882_/A }
C {sky130_stdcells/buf_2.sym} 89100 -41890 0 0 {name=X_57716_ }
C {devices/lab_pin.sym} 89060 -41770 0 0 {name=p88039 lab=_81661_/Q }
C {devices/lab_pin.sym} 89140 -41770 0 1 {name=p88040 lab=_76550_/Y }
C {sky130_stdcells/inv_2.sym} 89100 -41770 0 0 {name=X_76550_ }
C {devices/lab_pin.sym} 89020 -41680 0 0 {name=p88041 lab=_41778_/X }
C {devices/lab_pin.sym} 89020 -41640 0 0 {name=p88042 lab=_42930_/X }
C {devices/lab_pin.sym} 89020 -41600 0 0 {name=p88043 lab=_87639_/Q }
C {devices/lab_pin.sym} 89020 -41560 0 0 {name=p88044 lab=_42931_/X }
C {devices/lab_pin.sym} 89180 -41620 0 1 {name=p88045 lab=_87639_/D }
C {sky130_stdcells/a2bb2o_4.sym} 89100 -41620 0 0 {name=X_42942_ }
C {devices/lab_pin.sym} 89040 -41500 0 0 {name=p88046 lab=_54932_/A }
C {devices/lab_pin.sym} 89040 -41460 0 0 {name=p88047 lab=_54942_/B }
C {devices/lab_pin.sym} 89040 -41420 0 0 {name=p88048 lab=_54932_/C }
C {devices/lab_pin.sym} 89040 -41380 0 0 {name=p88049 lab=_53234_/D }
C {devices/lab_pin.sym} 89160 -41440 0 1 {name=p88050 lab=_54928_/X }
C {sky130_stdcells/and4_4.sym} 89100 -41440 0 0 {name=X_54928_ }
C {devices/lab_pin.sym} 89040 -41300 0 0 {name=p88051 lab=_73742_/A }
C {devices/lab_pin.sym} 89040 -41260 0 0 {name=p88052 lab=_66028_/B }
C {devices/lab_pin.sym} 89160 -41280 0 1 {name=p88053 lab=_73762_/X }
C {sky130_stdcells/and2_4.sym} 89100 -41280 0 0 {name=X_73762_ }
C {devices/lab_pin.sym} 89010 -41150 0 0 {name=p88054 lab=_85748_/CLK }
C {devices/lab_pin.sym} 89010 -41130 0 0 {name=p88055 lab=_52828_/Y }
C {devices/lab_pin.sym} 89190 -41150 0 1 {name=p88056 lab=_85748_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -41140 0 0 {name=X_85748_ }
C {devices/lab_pin.sym} 89040 -41030 0 0 {name=p88057 lab=_70976_/A }
C {devices/lab_pin.sym} 89040 -40990 0 0 {name=p88058 lab=_70952_/B }
C {devices/lab_pin.sym} 89040 -40950 0 0 {name=p88059 lab=_70969_/C }
C {devices/lab_pin.sym} 89160 -40990 0 1 {name=p88060 lab=_70974_/Y }
C {sky130_stdcells/nand3_4.sym} 89100 -40990 0 0 {name=X_70974_ }
C {devices/lab_pin.sym} 89060 -40850 0 0 {name=p88061 lab=_58696_/A }
C {devices/lab_pin.sym} 89140 -40850 0 1 {name=p88062 lab=_58696_/X }
C {sky130_stdcells/buf_2.sym} 89100 -40850 0 0 {name=X_58696_ }
C {devices/lab_pin.sym} 89060 -40730 0 0 {name=p88063 lab=_75500_/X }
C {devices/lab_pin.sym} 89140 -40730 0 1 {name=p88064 lab=_75503_/B }
C {sky130_stdcells/inv_2.sym} 89100 -40730 0 0 {name=X_75501_ }
C {devices/lab_pin.sym} 89020 -40630 0 0 {name=p88065 lab=_83181_/Q }
C {devices/lab_pin.sym} 89020 -40590 0 0 {name=p88066 lab=_72709_/X }
C {devices/lab_pin.sym} 89020 -40550 0 0 {name=p88067 lab=_72712_/X }
C {devices/lab_pin.sym} 89180 -40590 0 1 {name=p88068 lab=_72713_/X }
C {sky130_stdcells/a21o_4.sym} 89100 -40590 0 0 {name=X_72713_ }
C {devices/lab_pin.sym} 89020 -40480 0 0 {name=p88069 lab=_45659_/Y }
C {devices/lab_pin.sym} 89020 -40440 0 0 {name=p88070 lab=_45596_/X }
C {devices/lab_pin.sym} 89020 -40400 0 0 {name=p88071 lab=_45644_/X }
C {devices/lab_pin.sym} 89020 -40360 0 0 {name=p88072 lab=_45660_/Y }
C {devices/lab_pin.sym} 89180 -40420 0 1 {name=p88073 lab=_45661_/X }
C {sky130_stdcells/a211o_4.sym} 89100 -40420 0 0 {name=X_45661_ }
C {devices/lab_pin.sym} 89020 -40290 0 0 {name=p88074 lab=_84962_/Q }
C {devices/lab_pin.sym} 89020 -40250 0 0 {name=p88075 lab=_57635_/X }
C {devices/lab_pin.sym} 89020 -40210 0 0 {name=p88076 lab=_57646_/Y }
C {devices/lab_pin.sym} 89180 -40250 0 1 {name=p88077 lab=_57647_/Y }
C {sky130_stdcells/o21ai_4.sym} 89100 -40250 0 0 {name=X_57647_ }
C {devices/lab_pin.sym} 89060 -40110 0 0 {name=p88078 lab=_76481_/A }
C {devices/lab_pin.sym} 89140 -40110 0 1 {name=p88079 lab=_76485_/A }
C {sky130_stdcells/inv_2.sym} 89100 -40110 0 0 {name=X_76481_ }
C {devices/lab_pin.sym} 89020 -40020 0 0 {name=p88080 lab=_41592_/X }
C {devices/lab_pin.sym} 89020 -39980 0 0 {name=p88081 lab=_42866_/X }
C {devices/lab_pin.sym} 89020 -39940 0 0 {name=p88082 lab=_87674_/Q }
C {devices/lab_pin.sym} 89020 -39900 0 0 {name=p88083 lab=_42867_/X }
C {devices/lab_pin.sym} 89180 -39960 0 1 {name=p88084 lab=_42873_/X }
C {sky130_stdcells/a2bb2o_4.sym} 89100 -39960 0 0 {name=X_42873_ }
C {devices/lab_pin.sym} 89040 -39820 0 0 {name=p88085 lab=_54850_/A }
C {devices/lab_pin.sym} 89040 -39780 0 0 {name=p88086 lab=_54859_/B }
C {devices/lab_pin.sym} 89160 -39800 0 1 {name=p88087 lab=_54859_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -39800 0 0 {name=X_54859_ }
C {devices/lab_pin.sym} 89010 -39670 0 0 {name=p88088 lab=_85679_/CLK }
C {devices/lab_pin.sym} 89010 -39650 0 0 {name=p88089 lab=_85679_/D }
C {devices/lab_pin.sym} 89190 -39670 0 1 {name=p88090 lab=_85679_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -39660 0 0 {name=X_85679_ }
C {devices/lab_pin.sym} 89020 -39550 0 0 {name=p88091 lab=_73694_/B }
C {devices/lab_pin.sym} 89020 -39510 0 0 {name=p88092 lab=_73694_/C }
C {devices/lab_pin.sym} 89020 -39470 0 0 {name=p88093 lab=_73692_/X }
C {devices/lab_pin.sym} 89180 -39510 0 1 {name=p88094 lab=_73693_/X }
C {sky130_stdcells/a21o_4.sym} 89100 -39510 0 0 {name=X_73693_ }
C {devices/lab_pin.sym} 89040 -39400 0 0 {name=p88095 lab=_47418_/A }
C {devices/lab_pin.sym} 89040 -39360 0 0 {name=p88096 lab=_47408_/B }
C {devices/lab_pin.sym} 89040 -39320 0 0 {name=p88097 lab=_47377_/X }
C {devices/lab_pin.sym} 89040 -39280 0 0 {name=p88098 lab=_53023_/D }
C {devices/lab_pin.sym} 89160 -39340 0 1 {name=p88099 lab=_47400_/X }
C {sky130_stdcells/and4_4.sym} 89100 -39340 0 0 {name=X_47400_ }
C {devices/lab_pin.sym} 89040 -39210 0 0 {name=p88100 lab=_78220_/A }
C {devices/lab_pin.sym} 89040 -39170 0 0 {name=p88101 lab=_78220_/B }
C {devices/lab_pin.sym} 89040 -39130 0 0 {name=p88102 lab=_78220_/C }
C {devices/lab_pin.sym} 89160 -39170 0 1 {name=p88103 lab=_78221_/B }
C {sky130_stdcells/and3_4.sym} 89100 -39170 0 0 {name=X_78220_ }
C {devices/lab_pin.sym} 89020 -39060 0 0 {name=p88104 lab=_40968_/A }
C {devices/lab_pin.sym} 89020 -39020 0 0 {name=p88105 lab=_44602_/X }
C {devices/lab_pin.sym} 89020 -38980 0 0 {name=p88106 lab=_87033_/Q }
C {devices/lab_pin.sym} 89020 -38940 0 0 {name=p88107 lab=_44603_/X }
C {devices/lab_pin.sym} 89180 -39000 0 1 {name=p88108 lab=_44612_/X }
C {sky130_stdcells/a2bb2o_4.sym} 89100 -39000 0 0 {name=X_44612_ }
C {devices/lab_pin.sym} 89010 -38850 0 0 {name=p88109 lab=_82317_/CLK }
C {devices/lab_pin.sym} 89010 -38830 0 0 {name=p88110 lab=_43442_/X }
C {devices/lab_pin.sym} 89190 -38850 0 1 {name=p88111 lab=_87418_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -38840 0 0 {name=X_87418_ }
C {devices/lab_pin.sym} 89040 -38730 0 0 {name=p88112 lab=_75427_/X }
C {devices/lab_pin.sym} 89040 -38690 0 0 {name=p88113 lab=_75430_/Y }
C {devices/lab_pin.sym} 89040 -38650 0 0 {name=p88114 lab=_75432_/C }
C {devices/lab_pin.sym} 89160 -38690 0 1 {name=p88115 lab=_75432_/Y }
C {sky130_stdcells/nand3_4.sym} 89100 -38690 0 0 {name=X_75432_ }
C {devices/lab_pin.sym} 89060 -38550 0 0 {name=p88116 lab=_41802_/A }
C {devices/lab_pin.sym} 89140 -38550 0 1 {name=p88117 lab=_41824_/X }
C {sky130_stdcells/buf_2.sym} 89100 -38550 0 0 {name=X_41824_ }
C {devices/lab_pin.sym} 89060 -38430 0 0 {name=p88118 lab=_74373_/B }
C {devices/lab_pin.sym} 89140 -38430 0 1 {name=p88119 lab=_48380_/X }
C {sky130_stdcells/buf_2.sym} 89100 -38430 0 0 {name=X_48380_ }
C {devices/lab_pin.sym} 89020 -38330 0 0 {name=p88120 lab=_70183_/C }
C {devices/lab_pin.sym} 89020 -38290 0 0 {name=p88121 lab=_72631_/X }
C {devices/lab_pin.sym} 89020 -38250 0 0 {name=p88122 lab=_72643_/Y }
C {devices/lab_pin.sym} 89180 -38290 0 1 {name=p88123 lab=_83205_/D }
C {sky130_stdcells/a21bo_4.sym} 89100 -38290 0 0 {name=X_72644_ }
C {devices/lab_pin.sym} 89060 -38150 0 0 {name=p88124 lab=_63147_/B }
C {devices/lab_pin.sym} 89140 -38150 0 1 {name=p88125 lab=_61483_/A }
C {sky130_stdcells/buf_2.sym} 89100 -38150 0 0 {name=X_45592_ }
C {devices/lab_pin.sym} 89040 -38040 0 0 {name=p88126 lab=_57552_/X }
C {devices/lab_pin.sym} 89040 -38000 0 0 {name=p88127 lab=_48022_/Y }
C {devices/lab_pin.sym} 89160 -38020 0 1 {name=p88128 lab=_57578_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -38020 0 0 {name=X_57578_ }
C {devices/lab_pin.sym} 89010 -37890 0 0 {name=p88129 lab=_88398_/CLK }
C {devices/lab_pin.sym} 89010 -37870 0 0 {name=p88130 lab=_40397_/Y }
C {devices/lab_pin.sym} 89190 -37890 0 1 {name=p88131 lab=_88398_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -37880 0 0 {name=X_88398_ }
C {devices/lab_pin.sym} 89020 -37770 0 0 {name=p88132 lab=_47326_/Y }
C {devices/lab_pin.sym} 89020 -37730 0 0 {name=p88133 lab=_47317_/X }
C {devices/lab_pin.sym} 89020 -37690 0 0 {name=p88134 lab=_47330_/X }
C {devices/lab_pin.sym} 89180 -37730 0 1 {name=p88135 lab=_86646_/D }
C {sky130_stdcells/a21oi_4.sym} 89100 -37730 0 0 {name=X_47331_ }
C {devices/lab_pin.sym} 89040 -37600 0 0 {name=p88136 lab=_86663_/Q }
C {devices/lab_pin.sym} 89040 -37560 0 0 {name=p88137 lab=_59306_/B }
C {devices/lab_pin.sym} 89160 -37580 0 1 {name=p88138 lab=_59317_/Y }
C {sky130_stdcells/nor2_4.sym} 89100 -37580 0 0 {name=X_59317_ }
C {devices/lab_pin.sym} 89040 -37460 0 0 {name=p88139 lab=_78147_/Y }
C {devices/lab_pin.sym} 89040 -37420 0 0 {name=p88140 lab=_78150_/X }
C {devices/lab_pin.sym} 89160 -37440 0 1 {name=p88141 lab=_78151_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -37440 0 0 {name=X_78151_ }
C {devices/lab_pin.sym} 89060 -37310 0 0 {name=p88142 lab=_44543_/A }
C {devices/lab_pin.sym} 89140 -37310 0 1 {name=p88143 lab=_44543_/Y }
C {sky130_stdcells/inv_2.sym} 89100 -37310 0 0 {name=X_44543_ }
C {devices/lab_pin.sym} 89040 -37210 0 0 {name=p88144 lab=_56533_/A }
C {devices/lab_pin.sym} 89040 -37170 0 0 {name=p88145 lab=_56533_/B }
C {devices/lab_pin.sym} 89040 -37130 0 0 {name=p88146 lab=_85161_/Q }
C {devices/lab_pin.sym} 89160 -37170 0 1 {name=p88147 lab=_56529_/Y }
C {sky130_stdcells/nand3_4.sym} 89100 -37170 0 0 {name=X_56529_ }
C {devices/lab_pin.sym} 89040 -37040 0 0 {name=p88148 lab=_75359_/X }
C {devices/lab_pin.sym} 89040 -37000 0 0 {name=p88149 lab=_75362_/X }
C {devices/lab_pin.sym} 89160 -37020 0 1 {name=p88150 lab=_75370_/A }
C {sky130_stdcells/xor2_4.sym} 89100 -37020 0 0 {name=X_75363_ }
C {devices/lab_pin.sym} 89040 -36900 0 0 {name=p88151 lab=_40414_/X }
C {devices/lab_pin.sym} 89040 -36860 0 0 {name=p88152 lab=_41414_/A }
C {devices/lab_pin.sym} 89160 -36880 0 1 {name=p88153 lab=_41755_/X }
C {sky130_stdcells/or2_4.sym} 89100 -36880 0 0 {name=X_41755_ }
C {devices/lab_pin.sym} 89010 -36750 0 0 {name=p88154 lab=_86807_/CLK }
C {devices/lab_pin.sym} 89010 -36730 0 0 {name=p88155 lab=_43579_/X }
C {devices/lab_pin.sym} 89190 -36750 0 1 {name=p88156 lab=_87349_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -36740 0 0 {name=X_87349_ }
C {devices/lab_pin.sym} 89040 -36620 0 0 {name=p88157 lab=_72575_/A }
C {devices/lab_pin.sym} 89040 -36580 0 0 {name=p88158 lab=_72516_/A }
C {devices/lab_pin.sym} 89160 -36600 0 1 {name=p88159 lab=_72576_/A }
C {sky130_stdcells/nor2_4.sym} 89100 -36600 0 0 {name=X_72575_ }
C {devices/lab_pin.sym} 89040 -36480 0 0 {name=p88160 lab=_77112_/A }
C {devices/lab_pin.sym} 89040 -36440 0 0 {name=p88161 lab=_77113_/A }
C {devices/lab_pin.sym} 89160 -36460 0 1 {name=p88162 lab=_77103_/B }
C {sky130_stdcells/xor2_4.sym} 89100 -36460 0 0 {name=X_77102_ }
C {devices/lab_pin.sym} 89060 -36330 0 0 {name=p88163 lab=_72686_/A }
C {devices/lab_pin.sym} 89140 -36330 0 1 {name=p88164 lab=_74314_/X }
C {sky130_stdcells/buf_2.sym} 89100 -36330 0 0 {name=X_74314_ }
C {devices/lab_pin.sym} 89020 -36230 0 0 {name=p88165 lab=_40698_/X }
C {devices/lab_pin.sym} 89020 -36190 0 0 {name=p88166 lab=_82860_/Q }
C {devices/lab_pin.sym} 89020 -36150 0 0 {name=p88167 lab=_40705_/X }
C {devices/lab_pin.sym} 89180 -36190 0 1 {name=p88168 lab=_40707_/A }
C {sky130_stdcells/o21a_4.sym} 89100 -36190 0 0 {name=X_40706_ }
C {devices/lab_pin.sym} 89020 -36070 0 0 {name=p88169 lab=_57792_/A }
C {devices/lab_pin.sym} 89020 -36030 0 0 {name=p88170 lab=_47240_/X }
C {devices/lab_pin.sym} 89020 -35990 0 0 {name=p88171 lab=_47261_/Y }
C {devices/lab_pin.sym} 89180 -36030 0 1 {name=p88172 lab=_47262_/Y }
C {sky130_stdcells/o21ai_4.sym} 89100 -36030 0 0 {name=X_47262_ }
C {devices/lab_pin.sym} 89020 -35910 0 0 {name=p88173 lab=_53259_/B }
C {devices/lab_pin.sym} 89020 -35870 0 0 {name=p88174 lab=_71512_/A }
C {devices/lab_pin.sym} 89020 -35830 0 0 {name=p88175 lab=_71525_/Y }
C {devices/lab_pin.sym} 89180 -35870 0 1 {name=p88176 lab=_83466_/D }
C {sky130_stdcells/o21ai_4.sym} 89100 -35870 0 0 {name=X_71526_ }
C {devices/lab_pin.sym} 89020 -35750 0 0 {name=p88177 lab=_59121_/X }
C {devices/lab_pin.sym} 89020 -35710 0 0 {name=p88178 lab=_85421_/Q }
C {devices/lab_pin.sym} 89020 -35670 0 0 {name=p88179 lab=_59247_/X }
C {devices/lab_pin.sym} 89180 -35710 0 1 {name=p88180 lab=_59248_/Y }
C {sky130_stdcells/o21ai_4.sym} 89100 -35710 0 0 {name=X_59248_ }
C {devices/lab_pin.sym} 89040 -35580 0 0 {name=p88181 lab=_78082_/A }
C {devices/lab_pin.sym} 89040 -35540 0 0 {name=p88182 lab=_78082_/B }
C {devices/lab_pin.sym} 89160 -35560 0 1 {name=p88183 lab=_82939_/D }
C {sky130_stdcells/xor2_4.sym} 89100 -35560 0 0 {name=X_78082_ }
C {devices/lab_pin.sym} 89060 -35430 0 0 {name=p88184 lab=clkbuf_9_280_0_CLK/X }
C {devices/lab_pin.sym} 89140 -35430 0 1 {name=p88185 lab=_81475_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 89100 -35430 0 0 {name=Xclkbuf_10_561_0_CLK }
C {devices/lab_pin.sym} 89060 -35310 0 0 {name=p88186 lab=_44602_/A }
C {devices/lab_pin.sym} 89140 -35310 0 1 {name=p88187 lab=_44474_/X }
C {sky130_stdcells/buf_2.sym} 89100 -35310 0 0 {name=X_44474_ }
C {devices/lab_pin.sym} 89040 -35200 0 0 {name=p88188 lab=_75294_/A }
C {devices/lab_pin.sym} 89040 -35160 0 0 {name=p88189 lab=_75293_/X }
C {devices/lab_pin.sym} 89160 -35180 0 1 {name=p88190 lab=_75294_/Y }
C {sky130_stdcells/xnor2_4.sym} 89100 -35180 0 0 {name=X_75294_ }
C {devices/lab_pin.sym} 89060 -35050 0 0 {name=p88191 lab=clkbuf_6_53_0_CLK/A }
C {devices/lab_pin.sym} 89140 -35050 0 1 {name=p88192 lab=clkbuf_6_52_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 89100 -35050 0 0 {name=Xclkbuf_6_52_0_CLK }
C {devices/lab_pin.sym} 89040 -34940 0 0 {name=p88193 lab=_41604_/A }
C {devices/lab_pin.sym} 89040 -34900 0 0 {name=p88194 lab=_41686_/B }
C {devices/lab_pin.sym} 89160 -34920 0 1 {name=p88195 lab=_41686_/X }
C {sky130_stdcells/or2_4.sym} 89100 -34920 0 0 {name=X_41686_ }
C {devices/lab_pin.sym} 89060 -34790 0 0 {name=p88196 lab=_48186_/A }
C {devices/lab_pin.sym} 89140 -34790 0 1 {name=p88197 lab=_49002_/A }
C {sky130_stdcells/buf_2.sym} 89100 -34790 0 0 {name=X_49001_ }
C {devices/lab_pin.sym} 89060 -34670 0 0 {name=p88198 lab=_59325_/A }
C {devices/lab_pin.sym} 89140 -34670 0 1 {name=p88199 lab=_46213_/X }
C {sky130_stdcells/buf_2.sym} 89100 -34670 0 0 {name=X_46213_ }
C {sky130_stdcells/decap_3.sym} 89100 -34520 0 0 {name=XPHY_250 }
C {devices/lab_pin.sym} 89040 -34380 0 0 {name=p88200 lab=_82087_/Q }
C {devices/lab_pin.sym} 89040 -34340 0 0 {name=p88201 lab=_77033_/B }
C {devices/lab_pin.sym} 89160 -34360 0 1 {name=p88202 lab=_82368_/D }
C {sky130_stdcells/xor2_4.sym} 89100 -34360 0 0 {name=X_77033_ }
C {devices/lab_pin.sym} 89060 -34230 0 0 {name=p88203 lab=_43166_/A }
C {devices/lab_pin.sym} 89140 -34230 0 1 {name=p88204 lab=_43425_/X }
C {sky130_stdcells/buf_2.sym} 89100 -34230 0 0 {name=X_43425_ }
C {devices/lab_pin.sym} 89020 -34140 0 0 {name=p88205 lab=_41976_/Y }
C {devices/lab_pin.sym} 89020 -34100 0 0 {name=p88206 lab=_56182_/X }
C {devices/lab_pin.sym} 89020 -34060 0 0 {name=p88207 lab=_73962_/X }
C {devices/lab_pin.sym} 89020 -34020 0 0 {name=p88208 lab=_74244_/Y }
C {devices/lab_pin.sym} 89180 -34080 0 1 {name=p88209 lab=_74245_/X }
C {sky130_stdcells/a211o_4.sym} 89100 -34080 0 0 {name=X_74245_ }
C {sky130_stdcells/decap_3.sym} 89100 -33900 0 0 {name=XPHY_261 }
C {devices/lab_pin.sym} 89060 -33750 0 0 {name=p88210 lab=_40637_/A }
C {devices/lab_pin.sym} 89140 -33750 0 1 {name=p88211 lab=_40836_/A }
C {sky130_stdcells/buf_2.sym} 89100 -33750 0 0 {name=X_40637_ }
C {devices/lab_pin.sym} 89060 -33630 0 0 {name=p88212 lab=_47147_/A }
C {devices/lab_pin.sym} 89140 -33630 0 1 {name=p88213 lab=_47196_/A }
C {sky130_stdcells/buf_2.sym} 89100 -33630 0 0 {name=X_47193_ }
C {devices/lab_pin.sym} 89020 -33530 0 0 {name=p88214 lab=_59177_/X }
C {devices/lab_pin.sym} 89020 -33490 0 0 {name=p88215 lab=_86067_/Q }
C {devices/lab_pin.sym} 89020 -33450 0 0 {name=p88216 lab=_59178_/X }
C {devices/lab_pin.sym} 89180 -33490 0 1 {name=p88217 lab=_59179_/Y }
C {sky130_stdcells/o21ai_4.sym} 89100 -33490 0 0 {name=X_59179_ }
C {devices/lab_pin.sym} 89020 -33370 0 0 {name=p88218 lab=_71445_/X }
C {devices/lab_pin.sym} 89020 -33330 0 0 {name=p88219 lab=_83492_/Q }
C {devices/lab_pin.sym} 89020 -33290 0 0 {name=p88220 lab=_71456_/Y }
C {devices/lab_pin.sym} 89180 -33330 0 1 {name=p88221 lab=_71457_/X }
C {sky130_stdcells/a21o_4.sym} 89100 -33330 0 0 {name=X_71457_ }
C {sky130_stdcells/decap_3.sym} 89100 -33160 0 0 {name=XPHY_272 }
C {sky130_stdcells/decap_3.sym} 89100 -32980 0 0 {name=XPHY_283 }
C {sky130_stdcells/decap_3.sym} 89100 -32800 0 0 {name=XPHY_294 }
C {devices/lab_pin.sym} 89040 -32670 0 0 {name=p88222 lab=_61107_/A }
C {devices/lab_pin.sym} 89040 -32630 0 0 {name=p88223 lab=_61083_/C }
C {devices/lab_pin.sym} 89040 -32590 0 0 {name=p88224 lab=_64234_/B }
C {devices/lab_pin.sym} 89160 -32630 0 1 {name=p88225 lab=_64457_/B }
C {sky130_stdcells/nand3_4.sym} 89100 -32630 0 0 {name=X_61210_ }
C {devices/lab_pin.sym} 89020 -32520 0 0 {name=p88226 lab=_46138_/A }
C {devices/lab_pin.sym} 89020 -32480 0 0 {name=p88227 lab=_46119_/A }
C {devices/lab_pin.sym} 89020 -32440 0 0 {name=p88228 lab=_46143_/Y }
C {devices/lab_pin.sym} 89020 -32400 0 0 {name=p88229 lab=_46134_/A }
C {devices/lab_pin.sym} 89180 -32460 0 1 {name=p88230 lab=_46144_/X }
C {sky130_stdcells/a211o_4.sym} 89100 -32460 0 0 {name=X_46144_ }
C {devices/lab_pin.sym} 89020 -32330 0 0 {name=p88231 lab=_51394_/B }
C {devices/lab_pin.sym} 89020 -32290 0 0 {name=p88232 lab=_70364_/A }
C {devices/lab_pin.sym} 89020 -32250 0 0 {name=p88233 lab=_70407_/Y }
C {devices/lab_pin.sym} 89180 -32290 0 1 {name=p88234 lab=_83778_/D }
C {sky130_stdcells/o21ai_4.sym} 89100 -32290 0 0 {name=X_70408_ }
C {devices/lab_pin.sym} 89060 -32150 0 0 {name=p88235 lab=_43287_/A }
C {devices/lab_pin.sym} 89140 -32150 0 1 {name=p88236 lab=_43356_/X }
C {sky130_stdcells/buf_2.sym} 89100 -32150 0 0 {name=X_43356_ }
C {devices/lab_pin.sym} 89020 -32050 0 0 {name=p88237 lab=_74173_/X }
C {devices/lab_pin.sym} 89020 -32010 0 0 {name=p88238 lab=_74175_/X }
C {devices/lab_pin.sym} 89020 -31970 0 0 {name=p88239 lab=_74085_/X }
C {devices/lab_pin.sym} 89180 -32010 0 1 {name=p88240 lab=_74176_/X }
C {sky130_stdcells/a21o_4.sym} 89100 -32010 0 0 {name=X_74176_ }
C {devices/lab_pin.sym} 89020 -31910 0 0 {name=p88241 lab=_62183_/X }
C {devices/lab_pin.sym} 89020 -31870 0 0 {name=p88242 lab=_62188_/Y }
C {devices/lab_pin.sym} 89020 -31830 0 0 {name=p88243 lab=_62189_/X }
C {devices/lab_pin.sym} 89020 -31790 0 0 {name=p88244 lab=_58374_/A }
C {devices/lab_pin.sym} 89020 -31750 0 0 {name=p88245 lab=_61782_/A }
C {devices/lab_pin.sym} 89180 -31830 0 1 {name=p88246 lab=_62190_/Y }
C {sky130_stdcells/o32ai_4.sym} 89100 -31830 0 0 {name=X_62190_ }
C {devices/lab_pin.sym} 89060 -31670 0 0 {name=p88247 lab=_40568_/A }
C {devices/lab_pin.sym} 89140 -31670 0 1 {name=p88248 lab=_40568_/X }
C {sky130_stdcells/buf_2.sym} 89100 -31670 0 0 {name=X_40568_ }
C {devices/lab_pin.sym} 89060 -31550 0 0 {name=p88249 lab=_71458_/C }
C {devices/lab_pin.sym} 89140 -31550 0 1 {name=p88250 lab=_71399_/C }
C {sky130_stdcells/buf_2.sym} 89100 -31550 0 0 {name=X_71388_ }
C {devices/lab_pin.sym} 89060 -31430 0 0 {name=p88251 lab=_42204_/X }
C {devices/lab_pin.sym} 89140 -31430 0 1 {name=p88252 lab=_42307_/X }
C {sky130_stdcells/buf_2.sym} 89100 -31430 0 0 {name=X_42307_ }
C {devices/lab_pin.sym} 89060 -31310 0 0 {name=p88253 lab=clkbuf_9_288_0_CLK/X }
C {devices/lab_pin.sym} 89140 -31310 0 1 {name=p88254 lab=_80849_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 89100 -31310 0 0 {name=Xclkbuf_10_576_0_CLK }
C {devices/lab_pin.sym} 89060 -31190 0 0 {name=p88255 lab=_61083_/B }
C {devices/lab_pin.sym} 89140 -31190 0 1 {name=p88256 lab=_61179_/A }
C {sky130_stdcells/inv_2.sym} 89100 -31190 0 0 {name=X_61141_ }
C {devices/lab_pin.sym} 89020 -31100 0 0 {name=p88257 lab=_69752_/B }
C {devices/lab_pin.sym} 89020 -31060 0 0 {name=p88258 lab=_57377_/X }
C {devices/lab_pin.sym} 89020 -31020 0 0 {name=p88259 lab=_73055_/X }
C {devices/lab_pin.sym} 89020 -30980 0 0 {name=p88260 lab=_73126_/Y }
C {devices/lab_pin.sym} 89180 -31040 0 1 {name=p88261 lab=_73127_/X }
C {sky130_stdcells/a211o_4.sym} 89100 -31040 0 0 {name=X_73127_ }
C {devices/lab_pin.sym} 89060 -30890 0 0 {name=p88262 lab=_46075_/A }
C {devices/lab_pin.sym} 89140 -30890 0 1 {name=p88263 lab=_46075_/Y }
C {sky130_stdcells/inv_2.sym} 89100 -30890 0 0 {name=X_46075_ }
C {devices/lab_pin.sym} 89020 -30790 0 0 {name=p88264 lab=_70337_/X }
C {devices/lab_pin.sym} 89020 -30750 0 0 {name=p88265 lab=_74795_/A }
C {devices/lab_pin.sym} 89020 -30710 0 0 {name=p88266 lab=_70338_/X }
C {devices/lab_pin.sym} 89180 -30750 0 1 {name=p88267 lab=_83792_/D }
C {sky130_stdcells/a21o_4.sym} 89100 -30750 0 0 {name=X_70339_ }
C {devices/lab_pin.sym} 89060 -30610 0 0 {name=p88268 lab=_43287_/A }
C {devices/lab_pin.sym} 89140 -30610 0 1 {name=p88269 lab=_43287_/X }
C {sky130_stdcells/buf_2.sym} 89100 -30610 0 0 {name=X_43287_ }
C {devices/lab_pin.sym} 89040 -30500 0 0 {name=p88270 lab=_82822_/Q }
C {devices/lab_pin.sym} 89040 -30460 0 0 {name=p88271 lab=_82534_/Q }
C {devices/lab_pin.sym} 89160 -30480 0 1 {name=p88272 lab=_78998_/B }
C {sky130_stdcells/xnor2_4.sym} 89100 -30480 0 0 {name=X_78984_ }
C {devices/lab_pin.sym} 89040 -30360 0 0 {name=p88273 lab=_82315_/Q }
C {devices/lab_pin.sym} 89040 -30320 0 0 {name=p88274 lab=_40471_/X }
C {devices/lab_pin.sym} 89160 -30340 0 1 {name=p88275 lab=_40499_/X }
C {sky130_stdcells/or2_4.sym} 89100 -30340 0 0 {name=X_40499_ }
C {devices/lab_pin.sym} 89060 -30210 0 0 {name=p88276 lab=_49794_/X }
C {devices/lab_pin.sym} 89140 -30210 0 1 {name=p88277 lab=_49904_/C }
C {sky130_stdcells/buf_2.sym} 89100 -30210 0 0 {name=X_49903_ }
C {devices/lab_pin.sym} 89020 -30110 0 0 {name=p88278 lab=_85273_/Q }
C {devices/lab_pin.sym} 89020 -30070 0 0 {name=p88279 lab=_44998_/X }
C {devices/lab_pin.sym} 89020 -30030 0 0 {name=p88280 lab=_45025_/X }
C {devices/lab_pin.sym} 89180 -30070 0 1 {name=p88281 lab=_45026_/Y }
C {sky130_stdcells/o21ai_4.sym} 89100 -30070 0 0 {name=X_45026_ }
C {devices/lab_pin.sym} 89020 -29970 0 0 {name=p88282 lab=_42231_/X }
C {devices/lab_pin.sym} 89020 -29930 0 0 {name=p88283 lab=_42226_/X }
C {devices/lab_pin.sym} 89020 -29890 0 0 {name=p88284 lab=_41403_/X }
C {devices/lab_pin.sym} 89020 -29850 0 0 {name=p88285 lab=_87965_/Q }
C {devices/lab_pin.sym} 89020 -29810 0 0 {name=p88286 lab=_42228_/X }
C {devices/lab_pin.sym} 89180 -29890 0 1 {name=p88287 lab=_42239_/A }
C {sky130_stdcells/o32ai_4.sym} 89100 -29890 0 0 {name=X_42238_ }
C {devices/lab_pin.sym} 89060 -29730 0 0 {name=p88288 lab=_61071_/X }
C {devices/lab_pin.sym} 89140 -29730 0 1 {name=p88289 lab=_61122_/C }
C {sky130_stdcells/buf_2.sym} 89100 -29730 0 0 {name=X_61072_ }
C {devices/lab_pin.sym} 89060 -29610 0 0 {name=p88290 lab=_82073_/Q }
C {devices/lab_pin.sym} 89140 -29610 0 1 {name=p88291 lab=_77935_/Y }
C {sky130_stdcells/inv_2.sym} 89100 -29610 0 0 {name=X_77935_ }
C {devices/lab_pin.sym} 89020 -29510 0 0 {name=p88292 lab=_73054_/X }
C {devices/lab_pin.sym} 89020 -29470 0 0 {name=p88293 lab=_73057_/X }
C {devices/lab_pin.sym} 89020 -29430 0 0 {name=p88294 lab=_72951_/X }
C {devices/lab_pin.sym} 89180 -29470 0 1 {name=p88295 lab=_73058_/X }
C {sky130_stdcells/a21o_4.sym} 89100 -29470 0 0 {name=X_73058_ }
C {devices/lab_pin.sym} 89020 -29360 0 0 {name=p88296 lab=_64704_/X }
C {devices/lab_pin.sym} 89020 -29320 0 0 {name=p88297 lab=_86742_/Q }
C {devices/lab_pin.sym} 89020 -29280 0 0 {name=p88298 lab=_64707_/X }
C {devices/lab_pin.sym} 89020 -29240 0 0 {name=p88299 lab=_64899_/X }
C {devices/lab_pin.sym} 89180 -29300 0 1 {name=p88300 lab=_64900_/X }
C {sky130_stdcells/a211o_4.sym} 89100 -29300 0 0 {name=X_64900_ }
C {devices/lab_pin.sym} 89060 -29150 0 0 {name=p88301 lab=_59935_/A }
C {devices/lab_pin.sym} 89140 -29150 0 1 {name=p88302 lab=_62218_/A }
C {sky130_stdcells/buf_2.sym} 89100 -29150 0 0 {name=X_60023_ }
C {devices/lab_pin.sym} 89060 -29030 0 0 {name=p88303 lab=_72009_/A }
C {devices/lab_pin.sym} 89140 -29030 0 1 {name=p88304 lab=_72009_/X }
C {sky130_stdcells/buf_2.sym} 89100 -29030 0 0 {name=X_72009_ }
C {devices/lab_pin.sym} 89060 -28910 0 0 {name=p88305 lab=_49861_/A }
C {devices/lab_pin.sym} 89140 -28910 0 1 {name=p88306 lab=_49851_/B }
C {sky130_stdcells/buf_2.sym} 89100 -28910 0 0 {name=X_49834_ }
C {devices/lab_pin.sym} 89060 -28790 0 0 {name=p88307 lab=_42077_/A }
C {devices/lab_pin.sym} 89140 -28790 0 1 {name=p88308 lab=_42169_/X }
C {sky130_stdcells/buf_2.sym} 89100 -28790 0 0 {name=X_42169_ }
C {devices/lab_pin.sym} 89060 -28670 0 0 {name=p88309 lab=_65880_/A }
C {devices/lab_pin.sym} 89140 -28670 0 1 {name=p88310 lab=_65880_/X }
C {sky130_stdcells/buf_2.sym} 89100 -28670 0 0 {name=X_65880_ }
C {devices/lab_pin.sym} 89060 -28550 0 0 {name=p88311 lab=_77852_/Y }
C {devices/lab_pin.sym} 89140 -28550 0 1 {name=p88312 lab=_77866_/Y }
C {sky130_stdcells/inv_2.sym} 89100 -28550 0 0 {name=X_77866_ }
C {devices/lab_pin.sym} 89040 -28440 0 0 {name=p88313 lab=_79605_/A }
C {devices/lab_pin.sym} 89040 -28400 0 0 {name=p88314 lab=_79605_/B }
C {devices/lab_pin.sym} 89160 -28420 0 1 {name=p88315 lab=_79607_/A }
C {sky130_stdcells/xnor2_4.sym} 89100 -28420 0 0 {name=X_79605_ }
C {devices/lab_pin.sym} 89020 -28320 0 0 {name=p88316 lab=_64828_/X }
C {devices/lab_pin.sym} 89020 -28280 0 0 {name=p88317 lab=_85561_/Q }
C {devices/lab_pin.sym} 89020 -28240 0 0 {name=p88318 lab=_64829_/X }
C {devices/lab_pin.sym} 89020 -28200 0 0 {name=p88319 lab=_64830_/X }
C {devices/lab_pin.sym} 89180 -28260 0 1 {name=p88320 lab=_64831_/X }
C {sky130_stdcells/a211o_4.sym} 89100 -28260 0 0 {name=X_64831_ }
C {devices/lab_pin.sym} 89020 -28130 0 0 {name=p88321 lab=_76801_/B }
C {devices/lab_pin.sym} 89020 -28090 0 0 {name=p88322 lab=_76814_/X }
C {devices/lab_pin.sym} 89020 -28050 0 0 {name=p88323 lab=_76816_/Y }
C {devices/lab_pin.sym} 89180 -28090 0 1 {name=p88324 lab=_76818_/B }
C {sky130_stdcells/a21oi_4.sym} 89100 -28090 0 0 {name=X_76817_ }
C {devices/lab_pin.sym} 89060 -27950 0 0 {name=p88325 lab=_49657_/A }
C {devices/lab_pin.sym} 89140 -27950 0 1 {name=p88326 lab=_49789_/C }
C {sky130_stdcells/buf_2.sym} 89100 -27950 0 0 {name=X_49765_ }
C {devices/lab_pin.sym} 89040 -27840 0 0 {name=p88327 lab=_46959_/A }
C {devices/lab_pin.sym} 89040 -27800 0 0 {name=p88328 lab=_52781_/B }
C {devices/lab_pin.sym} 89160 -27820 0 1 {name=p88329 lab=_46977_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -27820 0 0 {name=X_46977_ }
C {devices/lab_pin.sym} 89040 -27700 0 0 {name=p88330 lab=_77763_/Y }
C {devices/lab_pin.sym} 89040 -27660 0 0 {name=p88331 lab=_77773_/A }
C {devices/lab_pin.sym} 89160 -27680 0 1 {name=p88332 lab=_77798_/B }
C {sky130_stdcells/nor2_4.sym} 89100 -27680 0 0 {name=X_77797_ }
C {devices/lab_pin.sym} 89020 -27570 0 0 {name=p88333 lab=_48714_/Y }
C {devices/lab_pin.sym} 89020 -27530 0 0 {name=p88334 lab=_48156_/X }
C {devices/lab_pin.sym} 89020 -27490 0 0 {name=p88335 lab=_48715_/X }
C {devices/lab_pin.sym} 89180 -27530 0 1 {name=p88336 lab=_48716_/Y }
C {sky130_stdcells/a21oi_4.sym} 89100 -27530 0 0 {name=X_48716_ }
C {devices/lab_pin.sym} 89060 -27390 0 0 {name=p88337 lab=_68342_/A }
C {devices/lab_pin.sym} 89140 -27390 0 1 {name=p88338 lab=_67550_/X }
C {sky130_stdcells/buf_2.sym} 89100 -27390 0 0 {name=X_67550_ }
C {devices/lab_pin.sym} 89040 -27280 0 0 {name=p88339 lab=_79534_/Y }
C {devices/lab_pin.sym} 89040 -27240 0 0 {name=p88340 lab=_79542_/A }
C {devices/lab_pin.sym} 89160 -27260 0 1 {name=p88341 lab=_79536_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -27260 0 0 {name=X_79536_ }
C {devices/lab_pin.sym} 89040 -27140 0 0 {name=p88342 lab=_43990_/Y }
C {devices/lab_pin.sym} 89040 -27100 0 0 {name=p88343 lab=_45927_/X }
C {devices/lab_pin.sym} 89160 -27120 0 1 {name=p88344 lab=_45928_/X }
C {sky130_stdcells/or2_4.sym} 89100 -27120 0 0 {name=X_45928_ }
C {devices/lab_pin.sym} 89040 -27000 0 0 {name=p88345 lab=_64751_/Y }
C {devices/lab_pin.sym} 89040 -26960 0 0 {name=p88346 lab=_64761_/Y }
C {devices/lab_pin.sym} 89160 -26980 0 1 {name=p88347 lab=_64762_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -26980 0 0 {name=X_64762_ }
C {devices/lab_pin.sym} 89040 -26860 0 0 {name=p88348 lab=_76746_/Y }
C {devices/lab_pin.sym} 89040 -26820 0 0 {name=p88349 lab=_76747_/Y }
C {devices/lab_pin.sym} 89160 -26840 0 1 {name=p88350 lab=_76757_/B }
C {sky130_stdcells/xor2_4.sym} 89100 -26840 0 0 {name=X_76748_ }
C {devices/lab_pin.sym} 89020 -26750 0 0 {name=p88351 lab=_61963_/X }
C {devices/lab_pin.sym} 89020 -26710 0 0 {name=p88352 lab=_61965_/X }
C {devices/lab_pin.sym} 89020 -26670 0 0 {name=p88353 lab=_61972_/Y }
C {devices/lab_pin.sym} 89020 -26630 0 0 {name=p88354 lab=_84738_/Q }
C {devices/lab_pin.sym} 89020 -26590 0 0 {name=p88355 lab=_61973_/X }
C {devices/lab_pin.sym} 89180 -26670 0 1 {name=p88356 lab=_61974_/Y }
C {sky130_stdcells/o32ai_4.sym} 89100 -26670 0 0 {name=X_61974_ }
C {devices/lab_pin.sym} 89060 -26510 0 0 {name=p88357 lab=_49641_/A }
C {devices/lab_pin.sym} 89140 -26510 0 1 {name=p88358 lab=_49697_/B }
C {sky130_stdcells/buf_2.sym} 89100 -26510 0 0 {name=X_49696_ }
C {devices/lab_pin.sym} 89040 -26410 0 0 {name=p88359 lab=_66501_/A }
C {devices/lab_pin.sym} 89040 -26370 0 0 {name=p88360 lab=_66501_/B }
C {devices/lab_pin.sym} 89040 -26330 0 0 {name=p88361 lab=_84111_/Q }
C {devices/lab_pin.sym} 89160 -26370 0 1 {name=p88362 lab=_66501_/X }
C {sky130_stdcells/and3_4.sym} 89100 -26370 0 0 {name=X_66501_ }
C {devices/lab_pin.sym} 89040 -26260 0 0 {name=p88363 lab=_63713_/A }
C {devices/lab_pin.sym} 89040 -26220 0 0 {name=p88364 lab=_60642_/A }
C {devices/lab_pin.sym} 89040 -26180 0 0 {name=p88365 lab=_60638_/Y }
C {devices/lab_pin.sym} 89040 -26140 0 0 {name=p88366 lab=_60642_/C }
C {devices/lab_pin.sym} 89160 -26200 0 1 {name=p88367 lab=_63713_/Y }
C {sky130_stdcells/nand4_4.sym} 89100 -26200 0 0 {name=X_63713_ }
C {devices/lab_pin.sym} 89060 -26050 0 0 {name=p88368 lab=clkbuf_9_257_0_CLK/X }
C {devices/lab_pin.sym} 89140 -26050 0 1 {name=p88369 lab=_81333_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 89100 -26050 0 0 {name=Xclkbuf_10_514_0_CLK }
C {devices/lab_pin.sym} 89060 -25930 0 0 {name=p88370 lab=_83567_/Q }
C {devices/lab_pin.sym} 89140 -25930 0 1 {name=p88371 lab=_48647_/Y }
C {sky130_stdcells/inv_2.sym} 89100 -25930 0 0 {name=X_48647_ }
C {devices/lab_pin.sym} 89020 -25850 0 0 {name=p88372 lab=_60905_/Y }
C {devices/lab_pin.sym} 89020 -25810 0 0 {name=p88373 lab=_60913_/Y }
C {devices/lab_pin.sym} 89020 -25770 0 0 {name=p88374 lab=_60988_/A }
C {devices/lab_pin.sym} 89020 -25730 0 0 {name=p88375 lab=_60923_/Y }
C {devices/lab_pin.sym} 89020 -25700 0 0 {name=p88376 lab=_60924_/Y }
C {devices/lab_pin.sym} 89180 -25770 0 1 {name=p88377 lab=_84551_/D }
C {sky130_stdcells/a41oi_4.sym} 89100 -25770 0 0 {name=X_60925_ }
C {devices/lab_pin.sym} 89060 -25610 0 0 {name=p88378 lab=_67126_/X }
C {devices/lab_pin.sym} 89140 -25610 0 1 {name=p88379 lab=_67575_/A }
C {sky130_stdcells/buf_2.sym} 89100 -25610 0 0 {name=X_67481_ }
C {devices/lab_pin.sym} 89040 -25500 0 0 {name=p88380 lab=_79467_/A }
C {devices/lab_pin.sym} 89040 -25460 0 0 {name=p88381 lab=_79467_/B }
C {devices/lab_pin.sym} 89160 -25480 0 1 {name=p88382 lab=_79468_/B }
C {sky130_stdcells/xor2_4.sym} 89100 -25480 0 0 {name=X_79467_ }
C {devices/lab_pin.sym} 89020 -25370 0 0 {name=p88383 lab=_45855_/X }
C {devices/lab_pin.sym} 89020 -25330 0 0 {name=p88384 lab=_45858_/X }
C {devices/lab_pin.sym} 89020 -25290 0 0 {name=p88385 lab=_44898_/X }
C {devices/lab_pin.sym} 89180 -25330 0 1 {name=p88386 lab=_45859_/X }
C {sky130_stdcells/a21o_4.sym} 89100 -25330 0 0 {name=X_45859_ }
C {devices/lab_pin.sym} 89060 -25190 0 0 {name=p88387 lab=_64601_/A }
C {devices/lab_pin.sym} 89140 -25190 0 1 {name=p88388 lab=_64694_/A }
C {sky130_stdcells/buf_2.sym} 89100 -25190 0 0 {name=X_64693_ }
C {devices/lab_pin.sym} 89060 -25070 0 0 {name=p88389 lab=_76672_/Y }
C {devices/lab_pin.sym} 89140 -25070 0 1 {name=p88390 lab=_76679_/Y }
C {sky130_stdcells/inv_2.sym} 89100 -25070 0 0 {name=X_76679_ }
C {devices/lab_pin.sym} 89040 -24960 0 0 {name=p88391 lab=_69179_/A }
C {devices/lab_pin.sym} 89040 -24920 0 0 {name=p88392 lab=_87277_/Q }
C {devices/lab_pin.sym} 89160 -24940 0 1 {name=p88393 lab=_69220_/X }
C {sky130_stdcells/and2_4.sym} 89100 -24940 0 0 {name=X_69220_ }
C {devices/lab_pin.sym} 89020 -24830 0 0 {name=p88394 lab=_66411_/X }
C {devices/lab_pin.sym} 89020 -24790 0 0 {name=p88395 lab=_66103_/Y }
C {devices/lab_pin.sym} 89020 -24750 0 0 {name=p88396 lab=_66431_/Y }
C {devices/lab_pin.sym} 89180 -24790 0 1 {name=p88397 lab=_66432_/Y }
C {sky130_stdcells/o21ai_4.sym} 89100 -24790 0 0 {name=X_66432_ }
C {devices/lab_pin.sym} 89040 -24660 0 0 {name=p88398 lab=_78418_/A }
C {devices/lab_pin.sym} 89040 -24620 0 0 {name=p88399 lab=_78418_/B }
C {devices/lab_pin.sym} 89160 -24640 0 1 {name=p88400 lab=_78423_/A }
C {sky130_stdcells/or2_4.sym} 89100 -24640 0 0 {name=X_78418_ }
C {devices/lab_pin.sym} 89060 -24510 0 0 {name=p88401 lab=_63644_/A }
C {devices/lab_pin.sym} 89140 -24510 0 1 {name=p88402 lab=_63670_/A }
C {sky130_stdcells/buf_2.sym} 89100 -24510 0 0 {name=X_63644_ }
C {devices/lab_pin.sym} 89060 -24390 0 0 {name=p88403 lab=_48578_/A }
C {devices/lab_pin.sym} 89140 -24390 0 1 {name=p88404 lab=_52199_/A }
C {sky130_stdcells/buf_2.sym} 89100 -24390 0 0 {name=X_48578_ }
C {devices/lab_pin.sym} 89060 -24270 0 0 {name=p88405 lab=_60855_/X }
C {devices/lab_pin.sym} 89140 -24270 0 1 {name=p88406 lab=_60865_/B }
C {sky130_stdcells/buf_2.sym} 89100 -24270 0 0 {name=X_60856_ }
C {devices/lab_pin.sym} 89020 -24180 0 0 {name=p88407 lab=_79374_/A }
C {devices/lab_pin.sym} 89020 -24140 0 0 {name=p88408 lab=_79373_/Y }
C {devices/lab_pin.sym} 89020 -24100 0 0 {name=p88409 lab=_79387_/A }
C {devices/lab_pin.sym} 89020 -24060 0 0 {name=p88410 lab=_79386_/Y }
C {devices/lab_pin.sym} 89180 -24120 0 1 {name=p88411 lab=_79398_/X }
C {sky130_stdcells/o22a_4.sym} 89100 -24120 0 0 {name=X_79398_ }
C {devices/lab_pin.sym} 89020 -24000 0 0 {name=p88412 lab=_87538_/Q }
C {devices/lab_pin.sym} 89020 -23960 0 0 {name=p88413 lab=_68958_/X }
C {devices/lab_pin.sym} 89020 -23920 0 0 {name=p88414 lab=_69113_/X }
C {devices/lab_pin.sym} 89020 -23880 0 0 {name=p88415 lab=_69150_/X }
C {devices/lab_pin.sym} 89180 -23940 0 1 {name=p88416 lab=_69151_/X }
C {sky130_stdcells/a211o_4.sym} 89100 -23940 0 0 {name=X_69151_ }
C {devices/lab_pin.sym} 89020 -23810 0 0 {name=p88417 lab=_86625_/Q }
C {devices/lab_pin.sym} 89020 -23770 0 0 {name=p88418 lab=_47524_/X }
C {devices/lab_pin.sym} 89020 -23730 0 0 {name=p88419 lab=_47528_/Y }
C {devices/lab_pin.sym} 89180 -23770 0 1 {name=p88420 lab=_47529_/Y }
C {sky130_stdcells/o21ai_4.sym} 89100 -23770 0 0 {name=X_47529_ }
C {devices/lab_pin.sym} 89060 -23630 0 0 {name=p88421 lab=_66003_/A }
C {devices/lab_pin.sym} 89140 -23630 0 1 {name=p88422 lab=_66415_/B }
C {sky130_stdcells/buf_2.sym} 89100 -23630 0 0 {name=X_66363_ }
C {devices/lab_pin.sym} 89020 -23530 0 0 {name=p88423 lab=_78345_/X }
C {devices/lab_pin.sym} 89020 -23490 0 0 {name=p88424 lab=_78346_/Y }
C {devices/lab_pin.sym} 89020 -23450 0 0 {name=p88425 lab=_78350_/A }
C {devices/lab_pin.sym} 89180 -23490 0 1 {name=p88426 lab=_78353_/C }
C {sky130_stdcells/a21o_4.sym} 89100 -23490 0 0 {name=X_78349_ }
C {devices/lab_pin.sym} 89040 -23380 0 0 {name=p88427 lab=_58438_/A }
C {devices/lab_pin.sym} 89040 -23340 0 0 {name=p88428 lab=_63541_/B }
C {devices/lab_pin.sym} 89040 -23300 0 0 {name=p88429 lab=_63575_/C }
C {devices/lab_pin.sym} 89040 -23260 0 0 {name=p88430 lab=_63541_/D }
C {devices/lab_pin.sym} 89160 -23320 0 1 {name=p88431 lab=_63575_/Y }
C {sky130_stdcells/nand4_4.sym} 89100 -23320 0 0 {name=X_63575_ }
C {devices/lab_pin.sym} 89020 -23210 0 0 {name=p88432 lab=_60778_/Y }
C {devices/lab_pin.sym} 89020 -23170 0 0 {name=p88433 lab=_60782_/Y }
C {devices/lab_pin.sym} 89020 -23130 0 0 {name=p88434 lab=_60708_/Y }
C {devices/lab_pin.sym} 89020 -23090 0 0 {name=p88435 lab=_60785_/Y }
C {devices/lab_pin.sym} 89020 -23060 0 0 {name=p88436 lab=_60786_/Y }
C {devices/lab_pin.sym} 89180 -23130 0 1 {name=p88437 lab=_60787_/Y }
C {sky130_stdcells/a41oi_4.sym} 89100 -23130 0 0 {name=X_60787_ }
C {devices/lab_pin.sym} 89020 -22990 0 0 {name=p88438 lab=_66655_/X }
C {devices/lab_pin.sym} 89020 -22950 0 0 {name=p88439 lab=_66657_/X }
C {devices/lab_pin.sym} 89020 -22910 0 0 {name=p88440 lab=_68062_/X }
C {devices/lab_pin.sym} 89180 -22950 0 1 {name=p88441 lab=_68102_/Y }
C {sky130_stdcells/a21oi_4.sym} 89100 -22950 0 0 {name=X_68102_ }
C {devices/lab_pin.sym} 89020 -22840 0 0 {name=p88442 lab=_64691_/X }
C {devices/lab_pin.sym} 89020 -22800 0 0 {name=p88443 lab=_86150_/Q }
C {devices/lab_pin.sym} 89020 -22760 0 0 {name=p88444 lab=_64972_/X }
C {devices/lab_pin.sym} 89020 -22720 0 0 {name=p88445 lab=_65313_/X }
C {devices/lab_pin.sym} 89180 -22780 0 1 {name=p88446 lab=_65314_/X }
C {sky130_stdcells/a211o_4.sym} 89100 -22780 0 0 {name=X_65314_ }
C {devices/lab_pin.sym} 89060 -22630 0 0 {name=p88447 lab=clkbuf_9_264_0_CLK/X }
C {devices/lab_pin.sym} 89140 -22630 0 1 {name=p88448 lab=_81351_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 89100 -22630 0 0 {name=Xclkbuf_10_529_0_CLK }
C {devices/lab_pin.sym} 89020 -22530 0 0 {name=p88449 lab=_50536_/Y }
C {devices/lab_pin.sym} 89020 -22490 0 0 {name=p88450 lab=_50525_/X }
C {devices/lab_pin.sym} 89020 -22450 0 0 {name=p88451 lab=_50539_/X }
C {devices/lab_pin.sym} 89180 -22490 0 1 {name=p88452 lab=_86182_/D }
C {sky130_stdcells/a21oi_4.sym} 89100 -22490 0 0 {name=X_50540_ }
C {devices/lab_pin.sym} 89020 -22390 0 0 {name=p88453 lab=_62516_/X }
C {devices/lab_pin.sym} 89020 -22350 0 0 {name=p88454 lab=_62521_/Y }
C {devices/lab_pin.sym} 89020 -22310 0 0 {name=p88455 lab=_62525_/X }
C {devices/lab_pin.sym} 89020 -22270 0 0 {name=p88456 lab=_58457_/A }
C {devices/lab_pin.sym} 89020 -22230 0 0 {name=p88457 lab=_62511_/X }
C {devices/lab_pin.sym} 89180 -22310 0 1 {name=p88458 lab=_62526_/Y }
C {sky130_stdcells/o32ai_4.sym} 89100 -22310 0 0 {name=X_62526_ }
C {devices/lab_pin.sym} 89010 -22150 0 0 {name=p88459 lab=_81361_/CLK }
C {devices/lab_pin.sym} 89010 -22130 0 0 {name=p88460 lab=_81360_/D }
C {devices/lab_pin.sym} 89190 -22150 0 1 {name=p88461 lab=_81360_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -22140 0 0 {name=X_81360_ }
C {devices/lab_pin.sym} 89020 -22040 0 0 {name=p88462 lab=_87074_/Q }
C {devices/lab_pin.sym} 89020 -22000 0 0 {name=p88463 lab=_69058_/X }
C {devices/lab_pin.sym} 89020 -21960 0 0 {name=p88464 lab=_68993_/X }
C {devices/lab_pin.sym} 89020 -21920 0 0 {name=p88465 lab=_69081_/X }
C {devices/lab_pin.sym} 89180 -21980 0 1 {name=p88466 lab=_69082_/X }
C {sky130_stdcells/a211o_4.sym} 89100 -21980 0 0 {name=X_69082_ }
C {devices/lab_pin.sym} 89060 -21830 0 0 {name=p88467 lab=_66366_/A }
C {devices/lab_pin.sym} 89140 -21830 0 1 {name=p88468 lab=_66294_/X }
C {sky130_stdcells/buf_2.sym} 89100 -21830 0 0 {name=X_66294_ }
C {devices/lab_pin.sym} 89060 -21710 0 0 {name=p88469 lab=_68429_/A }
C {devices/lab_pin.sym} 89140 -21710 0 1 {name=p88470 lab=_68033_/X }
C {sky130_stdcells/buf_2.sym} 89100 -21710 0 0 {name=X_68033_ }
C {devices/lab_pin.sym} 89040 -21600 0 0 {name=p88471 lab=_80308_/Y }
C {devices/lab_pin.sym} 89040 -21560 0 0 {name=p88472 lab=_80310_/Y }
C {devices/lab_pin.sym} 89160 -21580 0 1 {name=p88473 lab=_80315_/A }
C {sky130_stdcells/nand2_4.sym} 89100 -21580 0 0 {name=X_80311_ }
C {devices/lab_pin.sym} 89040 -21470 0 0 {name=p88474 lab=_65268_/A }
C {devices/lab_pin.sym} 89040 -21430 0 0 {name=p88475 lab=_65268_/B }
C {devices/lab_pin.sym} 89040 -21390 0 0 {name=p88476 lab=_84209_/Q }
C {devices/lab_pin.sym} 89160 -21430 0 1 {name=p88477 lab=_65245_/X }
C {sky130_stdcells/and3_4.sym} 89100 -21430 0 0 {name=X_65245_ }
C {devices/lab_pin.sym} 89040 -21300 0 0 {name=p88478 lab=_50481_/A }
C {devices/lab_pin.sym} 89040 -21260 0 0 {name=p88479 lab=_48788_/B }
C {devices/lab_pin.sym} 89160 -21280 0 1 {name=p88480 lab=_50471_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -21280 0 0 {name=X_50471_ }
C {devices/lab_pin.sym} 89040 -21180 0 0 {name=p88481 lab=_62415_/X }
C {devices/lab_pin.sym} 89040 -21140 0 0 {name=p88482 lab=_83248_/Q }
C {devices/lab_pin.sym} 89040 -21100 0 0 {name=p88483 lab=_62618_/D }
C {devices/lab_pin.sym} 89040 -21060 0 0 {name=p88484 lab=_62194_/D }
C {devices/lab_pin.sym} 89160 -21120 0 1 {name=p88485 lab=_62457_/X }
C {sky130_stdcells/and4_4.sym} 89100 -21120 0 0 {name=X_62457_ }
C {devices/lab_pin.sym} 89010 -20970 0 0 {name=p88486 lab=_81631_/CLK }
C {devices/lab_pin.sym} 89010 -20950 0 0 {name=p88487 lab=_76979_/X }
C {devices/lab_pin.sym} 89190 -20970 0 1 {name=p88488 lab=_81259_/D }
C {sky130_stdcells/dfxtp_4.sym} 89100 -20960 0 0 {name=X_81291_ }
C {devices/lab_pin.sym} 89040 -20840 0 0 {name=p88489 lab=_52210_/A }
C {devices/lab_pin.sym} 89040 -20800 0 0 {name=p88490 lab=_50508_/B }
C {devices/lab_pin.sym} 89160 -20820 0 1 {name=p88491 lab=_52210_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -20820 0 0 {name=X_52210_ }
C {devices/lab_pin.sym} 89010 -20690 0 0 {name=p88492 lab=_85269_/CLK }
C {devices/lab_pin.sym} 89010 -20670 0 0 {name=p88493 lab=_83030_/D }
C {devices/lab_pin.sym} 89190 -20690 0 1 {name=p88494 lab=_45081_/A }
C {sky130_stdcells/dfxtp_4.sym} 89100 -20680 0 0 {name=X_83030_ }
C {devices/lab_pin.sym} 89060 -20550 0 0 {name=p88495 lab=_61317_/X }
C {devices/lab_pin.sym} 89140 -20550 0 1 {name=p88496 lab=_61452_/C }
C {sky130_stdcells/buf_2.sym} 89100 -20550 0 0 {name=X_61408_ }
C {devices/lab_pin.sym} 89040 -20440 0 0 {name=p88497 lab=_80242_/A }
C {devices/lab_pin.sym} 89040 -20400 0 0 {name=p88498 lab=_80241_/X }
C {devices/lab_pin.sym} 89160 -20420 0 1 {name=p88499 lab=_80242_/Y }
C {sky130_stdcells/xnor2_4.sym} 89100 -20420 0 0 {name=X_80242_ }
C {devices/lab_pin.sym} 89060 -20290 0 0 {name=p88500 lab=_53190_/A }
C {devices/lab_pin.sym} 89140 -20290 0 1 {name=p88501 lab=_53211_/A }
C {sky130_stdcells/buf_2.sym} 89100 -20290 0 0 {name=X_53190_ }
C {devices/lab_pin.sym} 89020 -20200 0 0 {name=p88502 lab=_65035_/X }
C {devices/lab_pin.sym} 89020 -20160 0 0 {name=p88503 lab=_85515_/Q }
C {devices/lab_pin.sym} 89020 -20120 0 0 {name=p88504 lab=_65036_/X }
C {devices/lab_pin.sym} 89020 -20080 0 0 {name=p88505 lab=_65175_/X }
C {devices/lab_pin.sym} 89180 -20140 0 1 {name=p88506 lab=_65176_/X }
C {sky130_stdcells/a211o_4.sym} 89100 -20140 0 0 {name=X_65176_ }
C {devices/lab_pin.sym} 89040 -20020 0 0 {name=p88507 lab=_61481_/X }
C {devices/lab_pin.sym} 89040 -19980 0 0 {name=p88508 lab=_62420_/B }
C {devices/lab_pin.sym} 89040 -19940 0 0 {name=p88509 lab=_62420_/C }
C {devices/lab_pin.sym} 89040 -19900 0 0 {name=p88510 lab=_62334_/D }
C {devices/lab_pin.sym} 89160 -19960 0 1 {name=p88511 lab=_62389_/D }
C {sky130_stdcells/nand4_4.sym} 89100 -19960 0 0 {name=X_62388_ }
C {devices/lab_pin.sym} 89040 -19830 0 0 {name=p88512 lab=_48752_/A }
C {devices/lab_pin.sym} 89040 -19790 0 0 {name=p88513 lab=_52140_/X }
C {devices/lab_pin.sym} 89040 -19750 0 0 {name=p88514 lab=_52156_/C }
C {devices/lab_pin.sym} 89160 -19790 0 1 {name=p88515 lab=_52141_/X }
C {sky130_stdcells/and3_4.sym} 89100 -19790 0 0 {name=X_52141_ }
C {devices/lab_pin.sym} 89040 -19670 0 0 {name=p88516 lab=_64162_/A }
C {devices/lab_pin.sym} 89040 -19630 0 0 {name=p88517 lab=_58348_/A }
C {devices/lab_pin.sym} 89040 -19590 0 0 {name=p88518 lab=_64173_/C }
C {devices/lab_pin.sym} 89160 -19630 0 1 {name=p88519 lab=_64127_/X }
C {sky130_stdcells/and3_4.sym} 89100 -19630 0 0 {name=X_64127_ }
C {devices/lab_pin.sym} 89060 -19490 0 0 {name=p88520 lab=_72507_/A }
C {devices/lab_pin.sym} 89140 -19490 0 1 {name=p88521 lab=_61340_/A }
C {sky130_stdcells/buf_2.sym} 89100 -19490 0 0 {name=X_61339_ }
C {devices/lab_pin.sym} 89020 -19390 0 0 {name=p88522 lab=_80167_/A }
C {devices/lab_pin.sym} 89020 -19350 0 0 {name=p88523 lab=_80166_/X }
C {devices/lab_pin.sym} 89020 -19310 0 0 {name=p88524 lab=_80172_/Y }
C {devices/lab_pin.sym} 89180 -19350 0 1 {name=p88525 lab=_80173_/Y }
C {sky130_stdcells/a21boi_4.sym} 89100 -19350 0 0 {name=X_80173_ }
C {devices/lab_pin.sym} 89060 -19210 0 0 {name=p88526 lab=_70012_/A }
C {devices/lab_pin.sym} 89140 -19210 0 1 {name=p88527 lab=_69984_/X }
C {sky130_stdcells/buf_2.sym} 89100 -19210 0 0 {name=X_69984_ }
C {devices/lab_pin.sym} 89040 -19100 0 0 {name=p88528 lab=_52083_/A }
C {devices/lab_pin.sym} 89040 -19060 0 0 {name=p88529 lab=_50372_/B }
C {devices/lab_pin.sym} 89160 -19080 0 1 {name=p88530 lab=_52072_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -19080 0 0 {name=X_52072_ }
C {devices/lab_pin.sym} 89040 -18980 0 0 {name=p88531 lab=_63241_/B }
C {devices/lab_pin.sym} 89040 -18940 0 0 {name=p88532 lab=_64118_/B }
C {devices/lab_pin.sym} 89040 -18900 0 0 {name=p88533 lab=_64155_/C }
C {devices/lab_pin.sym} 89040 -18860 0 0 {name=p88534 lab=_64142_/D }
C {devices/lab_pin.sym} 89160 -18920 0 1 {name=p88535 lab=_64058_/Y }
C {sky130_stdcells/nand4_4.sym} 89100 -18920 0 0 {name=X_64058_ }
C {devices/lab_pin.sym} 89040 -18780 0 0 {name=p88536 lab=_68934_/X }
C {devices/lab_pin.sym} 89040 -18740 0 0 {name=p88537 lab=_42518_/Y }
C {devices/lab_pin.sym} 89160 -18760 0 1 {name=p88538 lab=_68935_/Y }
C {sky130_stdcells/nor2_4.sym} 89100 -18760 0 0 {name=X_68935_ }
C {devices/lab_pin.sym} 89010 -18630 0 0 {name=p88539 lab=_84981_/CLK }
C {devices/lab_pin.sym} 89010 -18610 0 0 {name=p88540 lab=_84981_/D }
C {devices/lab_pin.sym} 89190 -18630 0 1 {name=p88541 lab=_84981_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -18620 0 0 {name=X_84981_ }
C {devices/lab_pin.sym} 89040 -18500 0 0 {name=p88542 lab=_55949_/A }
C {devices/lab_pin.sym} 89040 -18460 0 0 {name=p88543 lab=_55900_/B }
C {devices/lab_pin.sym} 89160 -18480 0 1 {name=p88544 lab=_55900_/X }
C {sky130_stdcells/and2_4.sym} 89100 -18480 0 0 {name=X_55900_ }
C {devices/lab_pin.sym} 89020 -18370 0 0 {name=p88545 lab=_86088_/Q }
C {devices/lab_pin.sym} 89020 -18330 0 0 {name=p88546 lab=_51020_/X }
C {devices/lab_pin.sym} 89020 -18290 0 0 {name=p88547 lab=_51022_/Y }
C {devices/lab_pin.sym} 89180 -18330 0 1 {name=p88548 lab=_51023_/Y }
C {sky130_stdcells/o21ai_4.sym} 89100 -18330 0 0 {name=X_51023_ }
C {devices/lab_pin.sym} 89060 -18190 0 0 {name=p88549 lab=_60447_/B }
C {devices/lab_pin.sym} 89140 -18190 0 1 {name=p88550 lab=_63010_/A }
C {sky130_stdcells/buf_2.sym} 89100 -18190 0 0 {name=X_63009_ }
C {devices/lab_pin.sym} 89010 -18070 0 0 {name=p88551 lab=_86400_/CLK }
C {devices/lab_pin.sym} 89010 -18050 0 0 {name=p88552 lab=_86720_/D }
C {devices/lab_pin.sym} 89190 -18070 0 1 {name=p88553 lab=_58577_/A }
C {sky130_stdcells/dfxtp_4.sym} 89100 -18060 0 0 {name=X_86720_ }
C {devices/lab_pin.sym} 89010 -17930 0 0 {name=p88554 lab=_83932_/CLK }
C {devices/lab_pin.sym} 89010 -17910 0 0 {name=p88555 lab=_83932_/D }
C {devices/lab_pin.sym} 89190 -17930 0 1 {name=p88556 lab=_81396_/D }
C {sky130_stdcells/dfxtp_4.sym} 89100 -17920 0 0 {name=X_83932_ }
C {devices/lab_pin.sym} 89040 -17810 0 0 {name=p88557 lab=_56878_/Y }
C {devices/lab_pin.sym} 89040 -17770 0 0 {name=p88558 lab=_56880_/B }
C {devices/lab_pin.sym} 89040 -17730 0 0 {name=p88559 lab=_44134_/X }
C {devices/lab_pin.sym} 89160 -17770 0 1 {name=p88560 lab=_56880_/X }
C {sky130_stdcells/or3_4.sym} 89100 -17770 0 0 {name=X_56880_ }
C {devices/lab_pin.sym} 89020 -17660 0 0 {name=p88561 lab=_86987_/Q }
C {devices/lab_pin.sym} 89020 -17620 0 0 {name=p88562 lab=_68864_/X }
C {devices/lab_pin.sym} 89020 -17580 0 0 {name=p88563 lab=_68421_/X }
C {devices/lab_pin.sym} 89020 -17540 0 0 {name=p88564 lab=_68865_/X }
C {devices/lab_pin.sym} 89180 -17600 0 1 {name=p88565 lab=_68866_/X }
C {sky130_stdcells/a211o_4.sym} 89100 -17600 0 0 {name=X_68866_ }
C {devices/lab_pin.sym} 89040 -17460 0 0 {name=p88566 lab=_55836_/A }
C {devices/lab_pin.sym} 89040 -17420 0 0 {name=p88567 lab=_85233_/Q }
C {devices/lab_pin.sym} 89160 -17440 0 1 {name=p88568 lab=_55831_/X }
C {sky130_stdcells/and2_4.sym} 89100 -17440 0 0 {name=X_55831_ }
C {devices/lab_pin.sym} 89060 -17310 0 0 {name=p88569 lab=_68479_/A }
C {devices/lab_pin.sym} 89140 -17310 0 1 {name=p88570 lab=_67817_/X }
C {sky130_stdcells/buf_2.sym} 89100 -17310 0 0 {name=X_67817_ }
C {devices/lab_pin.sym} 89010 -17190 0 0 {name=p88571 lab=_86651_/CLK }
C {devices/lab_pin.sym} 89010 -17170 0 0 {name=p88572 lab=_86651_/D }
C {devices/lab_pin.sym} 89190 -17190 0 1 {name=p88573 lab=_86651_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -17180 0 0 {name=X_86651_ }
C {devices/lab_pin.sym} 89010 -17050 0 0 {name=p88574 lab=_82553_/CLK }
C {devices/lab_pin.sym} 89010 -17030 0 0 {name=p88575 lab=_70051_/X }
C {devices/lab_pin.sym} 89190 -17050 0 1 {name=p88576 lab=_82543_/D }
C {sky130_stdcells/dfxtp_4.sym} 89100 -17040 0 0 {name=X_83863_ }
C {devices/lab_pin.sym} 89020 -16940 0 0 {name=p88577 lab=_87086_/Q }
C {devices/lab_pin.sym} 89020 -16900 0 0 {name=p88578 lab=_68353_/X }
C {devices/lab_pin.sym} 89020 -16860 0 0 {name=p88579 lab=_68354_/X }
C {devices/lab_pin.sym} 89020 -16820 0 0 {name=p88580 lab=_68796_/X }
C {devices/lab_pin.sym} 89180 -16880 0 1 {name=p88581 lab=_68798_/B }
C {sky130_stdcells/a211o_4.sym} 89100 -16880 0 0 {name=X_68797_ }
C {devices/lab_pin.sym} 89010 -16730 0 0 {name=p88582 lab=_86210_/CLK }
C {devices/lab_pin.sym} 89010 -16710 0 0 {name=p88583 lab=_85602_/D }
C {devices/lab_pin.sym} 89190 -16730 0 1 {name=p88584 lab=_85602_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -16720 0 0 {name=X_85602_ }
C {devices/lab_pin.sym} 89060 -16590 0 0 {name=p88585 lab=_84821_/Q }
C {devices/lab_pin.sym} 89140 -16590 0 1 {name=p88586 lab=_58551_/A }
C {sky130_stdcells/inv_2.sym} 89100 -16590 0 0 {name=X_58550_ }
C {devices/lab_pin.sym} 89010 -16470 0 0 {name=p88587 lab=_81019_/CLK }
C {devices/lab_pin.sym} 89010 -16450 0 0 {name=p88588 lab=_82814_/D }
C {devices/lab_pin.sym} 89190 -16470 0 1 {name=p88589 lab=_78728_/A }
C {sky130_stdcells/dfxtp_4.sym} 89100 -16460 0 0 {name=X_82814_ }
C {devices/lab_pin.sym} 89060 -16330 0 0 {name=p88590 lab=_67270_/X }
C {devices/lab_pin.sym} 89140 -16330 0 1 {name=p88591 lab=_67748_/X }
C {sky130_stdcells/buf_2.sym} 89100 -16330 0 0 {name=X_67748_ }
C {devices/lab_pin.sym} 89020 -16240 0 0 {name=p88592 lab=_83015_/Q }
C {devices/lab_pin.sym} 89020 -16200 0 0 {name=p88593 lab=_44059_/X }
C {devices/lab_pin.sym} 89020 -16160 0 0 {name=p88594 lab=_55172_/X }
C {devices/lab_pin.sym} 89020 -16120 0 0 {name=p88595 lab=_55761_/X }
C {devices/lab_pin.sym} 89180 -16180 0 1 {name=p88596 lab=_55762_/X }
C {sky130_stdcells/a211o_4.sym} 89100 -16180 0 0 {name=X_55762_ }
C {devices/lab_pin.sym} 89010 -16030 0 0 {name=p88597 lab=_86582_/CLK }
C {devices/lab_pin.sym} 89010 -16010 0 0 {name=p88598 lab=_86582_/D }
C {devices/lab_pin.sym} 89190 -16030 0 1 {name=p88599 lab=_73830_/B }
C {sky130_stdcells/dfxtp_4.sym} 89100 -16020 0 0 {name=X_86582_ }
C {devices/lab_pin.sym} 89020 -15910 0 0 {name=p88600 lab=_85720_/Q }
C {devices/lab_pin.sym} 89020 -15870 0 0 {name=p88601 lab=_52957_/X }
C {devices/lab_pin.sym} 89020 -15830 0 0 {name=p88602 lab=_52973_/Y }
C {devices/lab_pin.sym} 89180 -15870 0 1 {name=p88603 lab=_52974_/Y }
C {sky130_stdcells/o21ai_4.sym} 89100 -15870 0 0 {name=X_52974_ }
C {devices/lab_pin.sym} 89010 -15730 0 0 {name=p88604 lab=_81620_/CLK }
C {devices/lab_pin.sym} 89010 -15710 0 0 {name=p88605 lab=_83794_/D }
C {devices/lab_pin.sym} 89190 -15730 0 1 {name=p88606 lab=_83794_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -15720 0 0 {name=X_83794_ }
C {devices/lab_pin.sym} 89040 -15600 0 0 {name=p88607 lab=_57497_/A }
C {devices/lab_pin.sym} 89040 -15560 0 0 {name=p88608 lab=_50234_/B }
C {devices/lab_pin.sym} 89160 -15580 0 1 {name=p88609 lab=_57501_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -15580 0 0 {name=X_57501_ }
C {devices/lab_pin.sym} 89010 -15450 0 0 {name=p88610 lab=_88062_/CLK }
C {devices/lab_pin.sym} 89010 -15430 0 0 {name=p88611 lab=_40863_/Y }
C {devices/lab_pin.sym} 89190 -15450 0 1 {name=p88612 lab=_88321_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -15440 0 0 {name=X_88321_ }
C {devices/lab_pin.sym} 89020 -15330 0 0 {name=p88613 lab=_54710_/Y }
C {devices/lab_pin.sym} 89020 -15290 0 0 {name=p88614 lab=_54694_/X }
C {devices/lab_pin.sym} 89020 -15250 0 0 {name=p88615 lab=_54712_/X }
C {devices/lab_pin.sym} 89180 -15290 0 1 {name=p88616 lab=_85392_/D }
C {sky130_stdcells/a21oi_4.sym} 89100 -15290 0 0 {name=X_54713_ }
C {devices/lab_pin.sym} 89010 -15150 0 0 {name=p88617 lab=_86246_/CLK }
C {devices/lab_pin.sym} 89010 -15130 0 0 {name=p88618 lab=_85533_/D }
C {devices/lab_pin.sym} 89190 -15150 0 1 {name=p88619 lab=_85533_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -15140 0 0 {name=X_85533_ }
C {devices/lab_pin.sym} 89020 -15030 0 0 {name=p88620 lab=_73561_/B }
C {devices/lab_pin.sym} 89020 -14990 0 0 {name=p88621 lab=_42612_/X }
C {devices/lab_pin.sym} 89020 -14950 0 0 {name=p88622 lab=_51924_/X }
C {devices/lab_pin.sym} 89180 -14990 0 1 {name=p88623 lab=_51926_/A }
C {sky130_stdcells/o21ai_4.sym} 89100 -14990 0 0 {name=X_51925_ }
C {devices/lab_pin.sym} 89060 -14850 0 0 {name=p88624 lab=_84838_/Q }
C {devices/lab_pin.sym} 89140 -14850 0 1 {name=p88625 lab=_58483_/A }
C {sky130_stdcells/buf_2.sym} 89100 -14850 0 0 {name=X_58481_ }
C {devices/lab_pin.sym} 89010 -14730 0 0 {name=p88626 lab=_84175_/CLK }
C {devices/lab_pin.sym} 89010 -14710 0 0 {name=p88627 lab=_84129_/Q }
C {devices/lab_pin.sym} 89190 -14730 0 1 {name=p88628 lab=_82745_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -14720 0 0 {name=X_82745_ }
C {devices/lab_pin.sym} 89020 -14620 0 0 {name=p88629 lab=_56192_/C }
C {devices/lab_pin.sym} 89020 -14580 0 0 {name=p88630 lab=_55690_/X }
C {devices/lab_pin.sym} 89020 -14540 0 0 {name=p88631 lab=_44052_/X }
C {devices/lab_pin.sym} 89020 -14500 0 0 {name=p88632 lab=_55692_/X }
C {devices/lab_pin.sym} 89180 -14560 0 1 {name=p88633 lab=_55693_/X }
C {sky130_stdcells/a211o_4.sym} 89100 -14560 0 0 {name=X_55693_ }
C {devices/lab_pin.sym} 89040 -14420 0 0 {name=p88634 lab=_67678_/X }
C {devices/lab_pin.sym} 89040 -14380 0 0 {name=p88635 lab=_67679_/B }
C {devices/lab_pin.sym} 89160 -14400 0 1 {name=p88636 lab=_67679_/X }
C {sky130_stdcells/and2_4.sym} 89100 -14400 0 0 {name=X_67679_ }
C {devices/lab_pin.sym} 89040 -14280 0 0 {name=p88637 lab=_57465_/A }
C {devices/lab_pin.sym} 89040 -14240 0 0 {name=p88638 lab=_57007_/X }
C {devices/lab_pin.sym} 89160 -14260 0 1 {name=p88639 lab=_57432_/Y }
C {sky130_stdcells/nor2_4.sym} 89100 -14260 0 0 {name=X_57432_ }
C {devices/lab_pin.sym} 89060 -14130 0 0 {name=p88640 lab=_69575_/A }
C {devices/lab_pin.sym} 89140 -14130 0 1 {name=p88641 lab=_69418_/X }
C {sky130_stdcells/buf_2.sym} 89100 -14130 0 0 {name=X_69418_ }
C {devices/lab_pin.sym} 89010 -14010 0 0 {name=p88642 lab=_87073_/CLK }
C {devices/lab_pin.sym} 89010 -13990 0 0 {name=p88643 lab=_88252_/D }
C {devices/lab_pin.sym} 89190 -14010 0 1 {name=p88644 lab=_88252_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -14000 0 0 {name=X_88252_ }
C {devices/lab_pin.sym} 89060 -13870 0 0 {name=p88645 lab=_54537_/A }
C {devices/lab_pin.sym} 89140 -13870 0 1 {name=p88646 lab=_54644_/X }
C {sky130_stdcells/buf_2.sym} 89100 -13870 0 0 {name=X_54644_ }
C {devices/lab_pin.sym} 89010 -13750 0 0 {name=p88647 lab=_82768_/CLK }
C {devices/lab_pin.sym} 89010 -13730 0 0 {name=p88648 lab=_85464_/D }
C {devices/lab_pin.sym} 89190 -13750 0 1 {name=p88649 lab=_85464_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -13740 0 0 {name=X_85464_ }
C {devices/lab_pin.sym} 89020 -13630 0 0 {name=p88650 lab=_51854_/Y }
C {devices/lab_pin.sym} 89020 -13590 0 0 {name=p88651 lab=_51850_/X }
C {devices/lab_pin.sym} 89020 -13550 0 0 {name=p88652 lab=_51855_/X }
C {devices/lab_pin.sym} 89180 -13590 0 1 {name=p88653 lab=_51856_/Y }
C {sky130_stdcells/a21oi_4.sym} 89100 -13590 0 0 {name=X_51856_ }
C {devices/lab_pin.sym} 89020 -13470 0 0 {name=p88654 lab=_70664_/A }
C {devices/lab_pin.sym} 89020 -13430 0 0 {name=p88655 lab=_47505_/A }
C {devices/lab_pin.sym} 89020 -13390 0 0 {name=p88656 lab=_70689_/Y }
C {devices/lab_pin.sym} 89180 -13430 0 1 {name=p88657 lab=_83723_/D }
C {sky130_stdcells/a21o_4.sym} 89100 -13430 0 0 {name=X_70690_ }
C {devices/lab_pin.sym} 89010 -13290 0 0 {name=p88658 lab=_81198_/CLK }
C {devices/lab_pin.sym} 89010 -13270 0 0 {name=p88659 lab=_82720_/Q }
C {devices/lab_pin.sym} 89190 -13290 0 1 {name=p88660 lab=_82676_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -13280 0 0 {name=X_82676_ }
C {devices/lab_pin.sym} 89010 -13150 0 0 {name=p88661 lab=_87394_/CLK }
C {devices/lab_pin.sym} 89010 -13130 0 0 {name=p88662 lab=_87203_/D }
C {devices/lab_pin.sym} 89190 -13150 0 1 {name=p88663 lab=_67729_/B }
C {sky130_stdcells/dfxtp_4.sym} 89100 -13140 0 0 {name=X_87203_ }
C {devices/lab_pin.sym} 89010 -13010 0 0 {name=p88664 lab=_84421_/CLK }
C {devices/lab_pin.sym} 89010 -12990 0 0 {name=p88665 lab=_84415_/D }
C {devices/lab_pin.sym} 89190 -13010 0 1 {name=p88666 lab=_84415_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -13000 0 0 {name=X_84415_ }
C {devices/lab_pin.sym} 89020 -12890 0 0 {name=p88667 lab=_86129_/Q }
C {devices/lab_pin.sym} 89020 -12850 0 0 {name=p88668 lab=_50804_/X }
C {devices/lab_pin.sym} 89020 -12810 0 0 {name=p88669 lab=_50806_/Y }
C {devices/lab_pin.sym} 89180 -12850 0 1 {name=p88670 lab=_50807_/Y }
C {sky130_stdcells/o21ai_4.sym} 89100 -12850 0 0 {name=X_50807_ }
C {devices/lab_pin.sym} 89010 -12710 0 0 {name=p88671 lab=_81627_/CLK }
C {devices/lab_pin.sym} 89010 -12690 0 0 {name=p88672 lab=_81627_/D }
C {devices/lab_pin.sym} 89190 -12710 0 1 {name=p88673 lab=_81819_/D }
C {sky130_stdcells/dfxtp_4.sym} 89100 -12700 0 0 {name=X_81627_ }
C {devices/lab_pin.sym} 89060 -12570 0 0 {name=p88674 lab=_56688_/X }
C {devices/lab_pin.sym} 89140 -12570 0 1 {name=p88675 lab=_73191_/B }
