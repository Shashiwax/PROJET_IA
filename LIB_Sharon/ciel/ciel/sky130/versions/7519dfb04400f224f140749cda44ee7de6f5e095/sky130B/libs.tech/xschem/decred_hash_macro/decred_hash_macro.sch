C {sky130_stdcells/a2bb2oi_4.sym} 67020 -17900 0 0 {name=X_72150_ }
C {devices/lab_pin.sym} 66930 -17750 0 0 {name=p66586 lab=_82177_/CLK }
C {devices/lab_pin.sym} 66930 -17730 0 0 {name=p66587 lab=_84136_/D }
C {devices/lab_pin.sym} 67110 -17750 0 1 {name=p66588 lab=_84136_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -17740 0 0 {name=X_84136_ }
C {devices/lab_pin.sym} 66960 -17620 0 0 {name=p66589 lab=_50513_/A }
C {devices/lab_pin.sym} 66960 -17580 0 0 {name=p66590 lab=_48847_/B }
C {devices/lab_pin.sym} 67080 -17600 0 1 {name=p66591 lab=_50528_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -17600 0 0 {name=X_50528_ }
C {devices/lab_pin.sym} 66960 -17480 0 0 {name=p66592 lab=_57084_/A }
C {devices/lab_pin.sym} 66960 -17440 0 0 {name=p66593 lab=_57084_/B }
C {devices/lab_pin.sym} 67080 -17460 0 1 {name=p66594 lab=_57084_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -17460 0 0 {name=X_57084_ }
C {devices/lab_pin.sym} 66930 -17330 0 0 {name=p66595 lab=_84105_/CLK }
C {devices/lab_pin.sym} 66930 -17310 0 0 {name=p66596 lab=_76968_/Y }
C {devices/lab_pin.sym} 67110 -17330 0 1 {name=p66597 lab=_81348_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -17320 0 0 {name=X_81348_ }
C {devices/lab_pin.sym} 66960 -17200 0 0 {name=p66598 lab=_54314_/A }
C {devices/lab_pin.sym} 66960 -17160 0 0 {name=p66599 lab=_46662_/A }
C {devices/lab_pin.sym} 67080 -17180 0 1 {name=p66600 lab=_54296_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -17180 0 0 {name=X_54296_ }
C {devices/lab_pin.sym} 66980 -17050 0 0 {name=p66601 lab=_71071_/A }
C {devices/lab_pin.sym} 67060 -17050 0 1 {name=p66602 lab=_71101_/X }
C {sky130_stdcells/buf_2.sym} 67020 -17050 0 0 {name=X_71101_ }
C {devices/lab_pin.sym} 66980 -16930 0 0 {name=p66603 lab=_56035_/A }
C {devices/lab_pin.sym} 67060 -16930 0 1 {name=p66604 lab=_56035_/X }
C {sky130_stdcells/buf_2.sym} 67020 -16930 0 0 {name=X_56035_ }
C {devices/lab_pin.sym} 66980 -16810 0 0 {name=p66605 lab=_41061_/A }
C {devices/lab_pin.sym} 67060 -16810 0 1 {name=p66606 lab=_41261_/X }
C {sky130_stdcells/buf_2.sym} 67020 -16810 0 0 {name=X_41261_ }
C {devices/lab_pin.sym} 66940 -16710 0 0 {name=p66607 lab=_85669_/Q }
C {devices/lab_pin.sym} 66940 -16670 0 0 {name=p66608 lab=_53225_/X }
C {devices/lab_pin.sym} 66940 -16630 0 0 {name=p66609 lab=_53246_/Y }
C {devices/lab_pin.sym} 67100 -16670 0 1 {name=p66610 lab=_53247_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -16670 0 0 {name=X_53247_ }
C {devices/lab_pin.sym} 66960 -16540 0 0 {name=p66611 lab=_72053_/A }
C {devices/lab_pin.sym} 66960 -16500 0 0 {name=p66612 lab=_49135_/A }
C {devices/lab_pin.sym} 67080 -16520 0 1 {name=p66613 lab=_72081_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -16520 0 0 {name=X_72081_ }
C {devices/lab_pin.sym} 66930 -16390 0 0 {name=p66614 lab=_82648_/CLK }
C {devices/lab_pin.sym} 66930 -16370 0 0 {name=p66615 lab=_84067_/D }
C {devices/lab_pin.sym} 67110 -16390 0 1 {name=p66616 lab=_81499_/D }
C {sky130_stdcells/dfxtp_4.sym} 67020 -16380 0 0 {name=X_84067_ }
C {devices/lab_pin.sym} 66940 -16270 0 0 {name=p66617 lab=_86196_/Q }
C {devices/lab_pin.sym} 66940 -16230 0 0 {name=p66618 lab=_50437_/X }
C {devices/lab_pin.sym} 66940 -16190 0 0 {name=p66619 lab=_50458_/Y }
C {devices/lab_pin.sym} 67100 -16230 0 1 {name=p66620 lab=_50459_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -16230 0 0 {name=X_50459_ }
C {devices/lab_pin.sym} 66930 -16090 0 0 {name=p66621 lab=_81279_/CLK }
C {devices/lab_pin.sym} 66930 -16070 0 0 {name=p66622 lab=_81311_/Q }
C {devices/lab_pin.sym} 67110 -16090 0 1 {name=p66623 lab=_76595_/A }
C {sky130_stdcells/dfxtp_4.sym} 67020 -16080 0 0 {name=X_81279_ }
C {devices/lab_pin.sym} 66940 -15990 0 0 {name=p66624 lab=_42984_/X }
C {devices/lab_pin.sym} 66940 -15950 0 0 {name=p66625 lab=_42985_/X }
C {devices/lab_pin.sym} 66940 -15910 0 0 {name=p66626 lab=_40515_/X }
C {devices/lab_pin.sym} 66940 -15870 0 0 {name=p66627 lab=_67142_/B }
C {devices/lab_pin.sym} 66940 -15830 0 0 {name=p66628 lab=_42463_/A }
C {devices/lab_pin.sym} 67100 -15910 0 1 {name=p66629 lab=_43001_/A }
C {sky130_stdcells/o32ai_4.sym} 67020 -15910 0 0 {name=X_43000_ }
C {devices/lab_pin.sym} 66980 -15750 0 0 {name=p66630 lab=_70997_/A }
C {devices/lab_pin.sym} 67060 -15750 0 1 {name=p66631 lab=_71178_/A }
C {sky130_stdcells/buf_2.sym} 67020 -15750 0 0 {name=X_71032_ }
C {devices/lab_pin.sym} 66930 -15630 0 0 {name=p66632 lab=_80670_/CLK }
C {devices/lab_pin.sym} 66930 -15610 0 0 {name=p66633 lab=_83018_/D }
C {devices/lab_pin.sym} 67110 -15630 0 1 {name=p66634 lab=_45257_/A }
C {sky130_stdcells/dfxtp_4.sym} 67020 -15620 0 0 {name=X_83018_ }
C {devices/lab_pin.sym} 66940 -15510 0 0 {name=p66635 lab=_53175_/Y }
C {devices/lab_pin.sym} 66940 -15470 0 0 {name=p66636 lab=_53163_/X }
C {devices/lab_pin.sym} 66940 -15430 0 0 {name=p66637 lab=_53177_/X }
C {devices/lab_pin.sym} 67100 -15470 0 1 {name=p66638 lab=_85683_/D }
C {sky130_stdcells/a21oi_4.sym} 67020 -15470 0 0 {name=X_53178_ }
C {devices/lab_pin.sym} 66940 -15350 0 0 {name=p66639 lab=_41042_/X }
C {devices/lab_pin.sym} 66940 -15310 0 0 {name=p66640 lab=_81714_/Q }
C {devices/lab_pin.sym} 66940 -15270 0 0 {name=p66641 lab=_41191_/X }
C {devices/lab_pin.sym} 67100 -15310 0 1 {name=p66642 lab=_41192_/X }
C {sky130_stdcells/o21a_4.sym} 67020 -15310 0 0 {name=X_41192_ }
C {devices/lab_pin.sym} 66980 -15170 0 0 {name=p66643 lab=clkbuf_9_198_0_CLK/X }
C {devices/lab_pin.sym} 67060 -15170 0 1 {name=p66644 lab=_84481_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67020 -15170 0 0 {name=Xclkbuf_10_396_0_CLK }
C {devices/lab_pin.sym} 66940 -15070 0 0 {name=p66645 lab=_65519_/B }
C {devices/lab_pin.sym} 66940 -15030 0 0 {name=p66646 lab=_52125_/X }
C {devices/lab_pin.sym} 66940 -14990 0 0 {name=p66647 lab=_52128_/Y }
C {devices/lab_pin.sym} 67100 -15030 0 1 {name=p66648 lab=_52129_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -15030 0 0 {name=X_52129_ }
C {devices/lab_pin.sym} 66960 -14900 0 0 {name=p66649 lab=_75838_/Y }
C {devices/lab_pin.sym} 66960 -14860 0 0 {name=p66650 lab=_75840_/B }
C {devices/lab_pin.sym} 67080 -14880 0 1 {name=p66651 lab=_75841_/A }
C {sky130_stdcells/xor2_4.sym} 67020 -14880 0 0 {name=X_75840_ }
C {devices/lab_pin.sym} 66930 -14750 0 0 {name=p66652 lab=_87826_/CLK }
C {devices/lab_pin.sym} 66930 -14730 0 0 {name=p66653 lab=_87826_/D }
C {devices/lab_pin.sym} 67110 -14750 0 1 {name=p66654 lab=_72769_/A }
C {sky130_stdcells/dfxtp_4.sym} 67020 -14740 0 0 {name=X_87826_ }
C {devices/lab_pin.sym} 66940 -14630 0 0 {name=p66655 lab=_57947_/X }
C {devices/lab_pin.sym} 66940 -14590 0 0 {name=p66656 lab=_85710_/Q }
C {devices/lab_pin.sym} 66940 -14550 0 0 {name=p66657 lab=_57948_/X }
C {devices/lab_pin.sym} 67100 -14590 0 1 {name=p66658 lab=_57986_/X }
C {sky130_stdcells/o21a_4.sym} 67020 -14590 0 0 {name=X_57986_ }
C {devices/lab_pin.sym} 66940 -14480 0 0 {name=p66659 lab=_80559_/A }
C {devices/lab_pin.sym} 66940 -14440 0 0 {name=p66660 lab=_59339_/X }
C {devices/lab_pin.sym} 66940 -14400 0 0 {name=p66661 lab=_59710_/Y }
C {devices/lab_pin.sym} 66940 -14360 0 0 {name=p66662 lab=_59724_/Y }
C {devices/lab_pin.sym} 67100 -14420 0 1 {name=p66663 lab=_84707_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 67020 -14420 0 0 {name=X_59725_ }
C {devices/lab_pin.sym} 66980 -14270 0 0 {name=p66664 lab=_45819_/A }
C {devices/lab_pin.sym} 67060 -14270 0 1 {name=p66665 lab=_45590_/B }
C {sky130_stdcells/buf_2.sym} 67020 -14270 0 0 {name=X_44951_ }
C {devices/lab_pin.sym} 66980 -14150 0 0 {name=p66666 lab=_72978_/A }
C {devices/lab_pin.sym} 67060 -14150 0 1 {name=p66667 lab=_72771_/A }
C {sky130_stdcells/buf_2.sym} 67020 -14150 0 0 {name=X_56937_ }
C {devices/lab_pin.sym} 66980 -14030 0 0 {name=p66668 lab=_75771_/A }
C {devices/lab_pin.sym} 67060 -14030 0 1 {name=p66669 lab=_75771_/Y }
C {sky130_stdcells/inv_2.sym} 67020 -14030 0 0 {name=X_75771_ }
C {devices/lab_pin.sym} 66930 -13910 0 0 {name=p66670 lab=_87757_/CLK }
C {devices/lab_pin.sym} 66930 -13890 0 0 {name=p66671 lab=_87757_/D }
C {devices/lab_pin.sym} 67110 -13910 0 1 {name=p66672 lab=_68528_/B }
C {sky130_stdcells/dfxtp_4.sym} 67020 -13900 0 0 {name=X_87757_ }
C {devices/lab_pin.sym} 66940 -13790 0 0 {name=p66673 lab=_72977_/X }
C {devices/lab_pin.sym} 66940 -13750 0 0 {name=p66674 lab=_72981_/X }
C {devices/lab_pin.sym} 66940 -13710 0 0 {name=p66675 lab=_72982_/X }
C {devices/lab_pin.sym} 67100 -13750 0 1 {name=p66676 lab=_72983_/X }
C {sky130_stdcells/a21o_4.sym} 67020 -13750 0 0 {name=X_72983_ }
C {devices/lab_pin.sym} 66930 -13610 0 0 {name=p66677 lab=_86535_/CLK }
C {devices/lab_pin.sym} 66930 -13590 0 0 {name=p66678 lab=_57614_/Y }
C {devices/lab_pin.sym} 67110 -13610 0 1 {name=p66679 lab=_84969_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -13600 0 0 {name=X_84969_ }
C {devices/lab_pin.sym} 66940 -13490 0 0 {name=p66680 lab=_77509_/B }
C {devices/lab_pin.sym} 66940 -13450 0 0 {name=p66681 lab=_77508_/Y }
C {devices/lab_pin.sym} 66940 -13410 0 0 {name=p66682 lab=_77505_/Y }
C {devices/lab_pin.sym} 67100 -13450 0 1 {name=p66683 lab=_77510_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -13450 0 0 {name=X_77510_ }
C {devices/lab_pin.sym} 66980 -13310 0 0 {name=p66684 lab=_43854_/A }
C {devices/lab_pin.sym} 67060 -13310 0 1 {name=p66685 lab=_43902_/X }
C {sky130_stdcells/buf_2.sym} 67020 -13310 0 0 {name=X_43902_ }
C {devices/lab_pin.sym} 66960 -13220 0 0 {name=p66686 lab=_74722_/A }
C {devices/lab_pin.sym} 66960 -13180 0 0 {name=p66687 lab=_74775_/A }
C {devices/lab_pin.sym} 66960 -13140 0 0 {name=p66688 lab=_71867_/B }
C {devices/lab_pin.sym} 66960 -13100 0 0 {name=p66689 lab=_70662_/X }
C {devices/lab_pin.sym} 67080 -13160 0 1 {name=p66690 lab=_74722_/Y }
C {sky130_stdcells/nand4_4.sym} 67020 -13160 0 0 {name=X_74722_ }
C {devices/lab_pin.sym} 66930 -13010 0 0 {name=p66691 lab=_86711_/CLK }
C {devices/lab_pin.sym} 66930 -12990 0 0 {name=p66692 lab=_86708_/D }
C {devices/lab_pin.sym} 67110 -13010 0 1 {name=p66693 lab=_58727_/A }
C {sky130_stdcells/dfxtp_4.sym} 67020 -13000 0 0 {name=X_86708_ }
C {devices/lab_pin.sym} 66960 -12880 0 0 {name=p66694 lab=_47696_/A }
C {devices/lab_pin.sym} 66960 -12840 0 0 {name=p66695 lab=_53179_/B }
C {devices/lab_pin.sym} 67080 -12860 0 1 {name=p66696 lab=_47670_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -12860 0 0 {name=X_47670_ }
C {devices/lab_pin.sym} 66940 -12750 0 0 {name=p66697 lab=_56808_/Y }
C {devices/lab_pin.sym} 66940 -12710 0 0 {name=p66698 lab=_71917_/X }
C {devices/lab_pin.sym} 66940 -12670 0 0 {name=p66699 lab=_71933_/Y }
C {devices/lab_pin.sym} 67100 -12710 0 1 {name=p66700 lab=_83323_/D }
C {sky130_stdcells/o21ai_4.sym} 67020 -12710 0 0 {name=X_71934_ }
C {devices/lab_pin.sym} 66980 -12570 0 0 {name=p66701 lab=_59775_/A }
C {devices/lab_pin.sym} 67060 -12570 0 1 {name=p66702 lab=_60414_/B }
C {sky130_stdcells/buf_2.sym} 67020 -12570 0 0 {name=X_59656_ }
C {devices/lab_pin.sym} 66980 -12450 0 0 {name=p66703 lab=_78489_/Y }
C {devices/lab_pin.sym} 67060 -12450 0 1 {name=p66704 lab=_78490_/Y }
C {sky130_stdcells/inv_2.sym} 67020 -12450 0 0 {name=X_78490_ }
C {devices/lab_pin.sym} 66980 -12330 0 0 {name=p66705 lab=_45281_/A }
C {devices/lab_pin.sym} 67060 -12330 0 1 {name=p66706 lab=_44882_/X }
C {sky130_stdcells/buf_2.sym} 67020 -12330 0 0 {name=X_44882_ }
C {devices/lab_pin.sym} 66960 -12220 0 0 {name=p66707 lab=_56868_/A }
C {devices/lab_pin.sym} 66960 -12180 0 0 {name=p66708 lab=_56868_/B }
C {devices/lab_pin.sym} 67080 -12200 0 1 {name=p66709 lab=_56868_/X }
C {sky130_stdcells/and2_4.sym} 67020 -12200 0 0 {name=X_56868_ }
C {devices/lab_pin.sym} 66930 -12070 0 0 {name=p66710 lab=_87126_/CLK }
C {devices/lab_pin.sym} 66930 -12050 0 0 {name=p66711 lab=_87688_/D }
C {devices/lab_pin.sym} 67110 -12070 0 1 {name=p66712 lab=_66828_/B }
C {sky130_stdcells/dfxtp_4.sym} 67020 -12060 0 0 {name=X_87688_ }
C {devices/lab_pin.sym} 66940 -11950 0 0 {name=p66713 lab=_46609_/Y }
C {devices/lab_pin.sym} 66940 -11910 0 0 {name=p66714 lab=_46598_/X }
C {devices/lab_pin.sym} 66940 -11870 0 0 {name=p66715 lab=_46620_/X }
C {devices/lab_pin.sym} 67100 -11910 0 1 {name=p66716 lab=_46621_/Y }
C {sky130_stdcells/a21oi_4.sym} 67020 -11910 0 0 {name=X_46621_ }
C {devices/lab_pin.sym} 66940 -11790 0 0 {name=p66717 lab=_58591_/X }
C {devices/lab_pin.sym} 66940 -11750 0 0 {name=p66718 lab=_85470_/Q }
C {devices/lab_pin.sym} 66940 -11710 0 0 {name=p66719 lab=_58606_/X }
C {devices/lab_pin.sym} 67100 -11750 0 1 {name=p66720 lab=_58607_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -11750 0 0 {name=X_58607_ }
C {devices/lab_pin.sym} 66960 -11620 0 0 {name=p66721 lab=_77441_/A }
C {devices/lab_pin.sym} 66960 -11580 0 0 {name=p66722 lab=_82192_/D }
C {devices/lab_pin.sym} 67080 -11600 0 1 {name=p66723 lab=_77441_/X }
C {sky130_stdcells/xor2_4.sym} 67020 -11600 0 0 {name=X_77441_ }
C {devices/lab_pin.sym} 66980 -11470 0 0 {name=p66724 lab=_43802_/A }
C {devices/lab_pin.sym} 67060 -11470 0 1 {name=p66725 lab=_43833_/X }
C {sky130_stdcells/buf_2.sym} 67020 -11470 0 0 {name=X_43833_ }
C {devices/lab_pin.sym} 66960 -11360 0 0 {name=p66726 lab=_55816_/X }
C {devices/lab_pin.sym} 66960 -11320 0 0 {name=p66727 lab=_55818_/X }
C {devices/lab_pin.sym} 67080 -11340 0 1 {name=p66728 lab=_55819_/X }
C {sky130_stdcells/and2_4.sym} 67020 -11340 0 0 {name=X_55819_ }
C {devices/lab_pin.sym} 66930 -11210 0 0 {name=p66729 lab=_86640_/CLK }
C {devices/lab_pin.sym} 66930 -11190 0 0 {name=p66730 lab=_86639_/D }
C {devices/lab_pin.sym} 67110 -11210 0 1 {name=p66731 lab=_86639_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67020 -11200 0 0 {name=X_86639_ }
C {devices/lab_pin.sym} 66940 -11100 0 0 {name=p66732 lab=_74638_/X }
C {devices/lab_pin.sym} 66940 -11060 0 0 {name=p66733 lab=_56633_/X }
C {devices/lab_pin.sym} 66940 -11020 0 0 {name=p66734 lab=_82997_/Q }
C {devices/lab_pin.sym} 66940 -10980 0 0 {name=p66735 lab=_74645_/X }
C {devices/lab_pin.sym} 67100 -11040 0 1 {name=p66736 lab=_74653_/X }
C {sky130_stdcells/a2bb2o_4.sym} 67020 -11040 0 0 {name=X_74653_ }
C {devices/lab_pin.sym} 66960 -10920 0 0 {name=p66737 lab=_71865_/A }
C {devices/lab_pin.sym} 66960 -10880 0 0 {name=p66738 lab=_71867_/B }
C {devices/lab_pin.sym} 66960 -10840 0 0 {name=p66739 lab=_70884_/B }
C {devices/lab_pin.sym} 66960 -10800 0 0 {name=p66740 lab=_71711_/A }
C {devices/lab_pin.sym} 67080 -10860 0 1 {name=p66741 lab=_71865_/Y }
C {sky130_stdcells/nor4_4.sym} 67020 -10860 0 0 {name=X_71865_ }
C {devices/lab_pin.sym} 66980 -10710 0 0 {name=p66742 lab=_59586_/X }
C {devices/lab_pin.sym} 67060 -10710 0 1 {name=p66743 lab=_59634_/B }
C {sky130_stdcells/buf_2.sym} 67020 -10710 0 0 {name=X_59587_ }
C {devices/lab_pin.sym} 66940 -10610 0 0 {name=p66744 lab=_44163_/B }
C {devices/lab_pin.sym} 66940 -10570 0 0 {name=p66745 lab=_56792_/X }
C {devices/lab_pin.sym} 66940 -10530 0 0 {name=p66746 lab=_56798_/Y }
C {devices/lab_pin.sym} 67100 -10570 0 1 {name=p66747 lab=_56799_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -10570 0 0 {name=X_56799_ }
C {devices/lab_pin.sym} 66980 -10430 0 0 {name=p66748 lab=clkbuf_9_441_0_CLK/A }
C {devices/lab_pin.sym} 67060 -10430 0 1 {name=p66749 lab=clkbuf_9_440_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 67020 -10430 0 0 {name=Xclkbuf_9_440_0_CLK }
C {devices/lab_pin.sym} 66960 -10320 0 0 {name=p66750 lab=_49352_/A }
C {devices/lab_pin.sym} 66960 -10280 0 0 {name=p66751 lab=_50862_/B }
C {devices/lab_pin.sym} 67080 -10300 0 1 {name=p66752 lab=_49340_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -10300 0 0 {name=X_49340_ }
C {devices/lab_pin.sym} 66940 -10190 0 0 {name=p66753 lab=_87005_/Q }
C {devices/lab_pin.sym} 66940 -10150 0 0 {name=p66754 lab=_56550_/X }
C {devices/lab_pin.sym} 66940 -10110 0 0 {name=p66755 lab=_73603_/X }
C {devices/lab_pin.sym} 67100 -10150 0 1 {name=p66756 lab=_73604_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -10150 0 0 {name=X_73604_ }
C {devices/lab_pin.sym} 66960 -10020 0 0 {name=p66757 lab=_46531_/A }
C {devices/lab_pin.sym} 66960 -9980 0 0 {name=p66758 lab=_54071_/B }
C {devices/lab_pin.sym} 67080 -10000 0 1 {name=p66759 lab=_46552_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -10000 0 0 {name=X_46552_ }
C {devices/lab_pin.sym} 66960 -9890 0 0 {name=p66760 lab=_70810_/A }
C {devices/lab_pin.sym} 66960 -9850 0 0 {name=p66761 lab=_70949_/B }
C {devices/lab_pin.sym} 66960 -9810 0 0 {name=p66762 lab=_70810_/C }
C {devices/lab_pin.sym} 67080 -9850 0 1 {name=p66763 lab=_70816_/Y }
C {sky130_stdcells/nand3_4.sym} 67020 -9850 0 0 {name=X_70816_ }
C {devices/lab_pin.sym} 66980 -9710 0 0 {name=p66764 lab=_58423_/A }
C {devices/lab_pin.sym} 67060 -9710 0 1 {name=p66765 lab=_58538_/X }
C {sky130_stdcells/buf_2.sym} 67020 -9710 0 0 {name=X_58538_ }
C {devices/lab_pin.sym} 66940 -9610 0 0 {name=p66766 lab=_77361_/A }
C {devices/lab_pin.sym} 66940 -9570 0 0 {name=p66767 lab=_77345_/B }
C {devices/lab_pin.sym} 66940 -9530 0 0 {name=p66768 lab=_77371_/A }
C {devices/lab_pin.sym} 67100 -9570 0 1 {name=p66769 lab=_77372_/Y }
C {sky130_stdcells/a21oi_4.sym} 67020 -9570 0 0 {name=X_77372_ }
C {devices/lab_pin.sym} 66940 -9460 0 0 {name=p66770 lab=_40968_/X }
C {devices/lab_pin.sym} 66940 -9420 0 0 {name=p66771 lab=_43752_/X }
C {devices/lab_pin.sym} 66940 -9380 0 0 {name=p66772 lab=_87277_/Q }
C {devices/lab_pin.sym} 66940 -9340 0 0 {name=p66773 lab=_43753_/X }
C {devices/lab_pin.sym} 67100 -9400 0 1 {name=p66774 lab=_43764_/X }
C {sky130_stdcells/a2bb2o_4.sym} 67020 -9400 0 0 {name=X_43764_ }
C {devices/lab_pin.sym} 66980 -9250 0 0 {name=p66775 lab=_74600_/A }
C {devices/lab_pin.sym} 67060 -9250 0 1 {name=p66776 lab=_74584_/X }
C {sky130_stdcells/buf_2.sym} 67020 -9250 0 0 {name=X_74584_ }
C {devices/lab_pin.sym} 66940 -9150 0 0 {name=p66777 lab=_40512_/X }
C {devices/lab_pin.sym} 66940 -9110 0 0 {name=p66778 lab=_81721_/Q }
C {devices/lab_pin.sym} 66940 -9070 0 0 {name=p66779 lab=_40975_/X }
C {devices/lab_pin.sym} 67100 -9110 0 1 {name=p66780 lab=_40976_/X }
C {sky130_stdcells/o21a_4.sym} 67020 -9110 0 0 {name=X_40976_ }
C {devices/lab_pin.sym} 66960 -8990 0 0 {name=p66781 lab=_70804_/A }
C {devices/lab_pin.sym} 66960 -8950 0 0 {name=p66782 lab=_71333_/C }
C {devices/lab_pin.sym} 66960 -8910 0 0 {name=p66783 lab=_71716_/B }
C {devices/lab_pin.sym} 67080 -8950 0 1 {name=p66784 lab=_71796_/Y }
C {sky130_stdcells/nand3_4.sym} 67020 -8950 0 0 {name=X_71796_ }
C {devices/lab_pin.sym} 66980 -8810 0 0 {name=p66785 lab=clkbuf_9_167_0_CLK/X }
C {devices/lab_pin.sym} 67060 -8810 0 1 {name=p66786 lab=_85718_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67020 -8810 0 0 {name=Xclkbuf_10_334_0_CLK }
C {devices/lab_pin.sym} 66980 -8690 0 0 {name=p66787 lab=_82753_/Q }
C {devices/lab_pin.sym} 67060 -8690 0 1 {name=p66788 lab=_79112_/B }
C {sky130_stdcells/inv_2.sym} 67020 -8690 0 0 {name=X_79111_ }
C {devices/lab_pin.sym} 66980 -8570 0 0 {name=p66789 lab=_85018_/Q }
C {devices/lab_pin.sym} 67060 -8570 0 1 {name=p66790 lab=_55555_/B }
C {sky130_stdcells/inv_2.sym} 67020 -8570 0 0 {name=X_45503_ }
C {devices/lab_pin.sym} 66940 -8470 0 0 {name=p66791 lab=_76309_/X }
C {devices/lab_pin.sym} 66940 -8430 0 0 {name=p66792 lab=_76321_/Y }
C {devices/lab_pin.sym} 66940 -8390 0 0 {name=p66793 lab=_76322_/Y }
C {devices/lab_pin.sym} 67100 -8430 0 1 {name=p66794 lab=_76323_/X }
C {sky130_stdcells/a21o_4.sym} 67020 -8430 0 0 {name=X_76323_ }
C {devices/lab_pin.sym} 66930 -8290 0 0 {name=p66795 lab=_87068_/CLK }
C {devices/lab_pin.sym} 66930 -8270 0 0 {name=p66796 lab=_40926_/X }
C {devices/lab_pin.sym} 67110 -8290 0 1 {name=p66797 lab=_69961_/B }
C {sky130_stdcells/dfxtp_4.sym} 67020 -8280 0 0 {name=X_88309_ }
C {devices/lab_pin.sym} 66940 -8180 0 0 {name=p66798 lab=_41161_/X }
C {devices/lab_pin.sym} 66940 -8140 0 0 {name=p66799 lab=_42710_/X }
C {devices/lab_pin.sym} 66940 -8100 0 0 {name=p66800 lab=_87754_/Q }
C {devices/lab_pin.sym} 66940 -8060 0 0 {name=p66801 lab=_42711_/X }
C {devices/lab_pin.sym} 67100 -8120 0 1 {name=p66802 lab=_42715_/X }
C {sky130_stdcells/a2bb2o_4.sym} 67020 -8120 0 0 {name=X_42715_ }
C {devices/lab_pin.sym} 66980 -7970 0 0 {name=p66803 lab=_49247_/A }
C {devices/lab_pin.sym} 67060 -7970 0 1 {name=p66804 lab=_49271_/X }
C {sky130_stdcells/buf_2.sym} 67020 -7970 0 0 {name=X_49271_ }
C {devices/lab_pin.sym} 66960 -7860 0 0 {name=p66805 lab=_73535_/A }
C {devices/lab_pin.sym} 66960 -7820 0 0 {name=p66806 lab=_65890_/B }
C {devices/lab_pin.sym} 67080 -7840 0 1 {name=p66807 lab=_73535_/X }
C {sky130_stdcells/and2_4.sym} 67020 -7840 0 0 {name=X_73535_ }
C {devices/lab_pin.sym} 66960 -7720 0 0 {name=p66808 lab=_70753_/A }
C {devices/lab_pin.sym} 66960 -7680 0 0 {name=p66809 lab=_70717_/A }
C {devices/lab_pin.sym} 67080 -7700 0 1 {name=p66810 lab=_70747_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -7700 0 0 {name=X_70747_ }
C {devices/lab_pin.sym} 66940 -7590 0 0 {name=p66811 lab=_46423_/X }
C {devices/lab_pin.sym} 66940 -7550 0 0 {name=p66812 lab=_81197_/Q }
C {devices/lab_pin.sym} 66940 -7510 0 0 {name=p66813 lab=_46482_/Y }
C {devices/lab_pin.sym} 67100 -7550 0 1 {name=p66814 lab=_54043_/A }
C {sky130_stdcells/o21ai_4.sym} 67020 -7550 0 0 {name=X_46483_ }
C {devices/lab_pin.sym} 66980 -7410 0 0 {name=p66815 lab=_84841_/Q }
C {devices/lab_pin.sym} 67060 -7410 0 1 {name=p66816 lab=_63557_/B }
C {sky130_stdcells/buf_2.sym} 67020 -7410 0 0 {name=X_58469_ }
C {devices/lab_pin.sym} 66980 -7290 0 0 {name=p66817 lab=clkbuf_9_482_0_CLK/X }
C {devices/lab_pin.sym} 67060 -7290 0 1 {name=p66818 lab=_85826_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67020 -7290 0 0 {name=Xclkbuf_10_964_0_CLK }
C {devices/lab_pin.sym} 66980 -7170 0 0 {name=p66819 lab=_43685_/A }
C {devices/lab_pin.sym} 67060 -7170 0 1 {name=p66820 lab=_43695_/X }
C {sky130_stdcells/buf_2.sym} 67020 -7170 0 0 {name=X_43695_ }
C {devices/lab_pin.sym} 66960 -7060 0 0 {name=p66821 lab=_48184_/A }
C {devices/lab_pin.sym} 66960 -7020 0 0 {name=p66822 lab=_50275_/B }
C {devices/lab_pin.sym} 67080 -7040 0 1 {name=p66823 lab=_48222_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -7040 0 0 {name=X_48222_ }
C {devices/lab_pin.sym} 66980 -6910 0 0 {name=p66824 lab=_60440_/A }
C {devices/lab_pin.sym} 67060 -6910 0 1 {name=p66825 lab=_60500_/Y }
C {sky130_stdcells/inv_2.sym} 67020 -6910 0 0 {name=X_60500_ }
C {devices/lab_pin.sym} 66980 -6790 0 0 {name=p66826 lab=_79042_/A }
C {devices/lab_pin.sym} 67060 -6790 0 1 {name=p66827 lab=_79044_/B }
C {sky130_stdcells/inv_2.sym} 67020 -6790 0 0 {name=X_79042_ }
C {devices/lab_pin.sym} 66980 -6670 0 0 {name=p66828 lab=_45668_/A }
C {devices/lab_pin.sym} 67060 -6670 0 1 {name=p66829 lab=_45434_/X }
C {sky130_stdcells/buf_2.sym} 67020 -6670 0 0 {name=X_45434_ }
C {devices/lab_pin.sym} 66960 -6570 0 0 {name=p66830 lab=_76254_/A }
C {devices/lab_pin.sym} 66960 -6530 0 0 {name=p66831 lab=_76254_/B }
C {devices/lab_pin.sym} 66960 -6490 0 0 {name=p66832 lab=_76252_/Y }
C {devices/lab_pin.sym} 67080 -6530 0 1 {name=p66833 lab=_76255_/A }
C {sky130_stdcells/nand3_4.sym} 67020 -6530 0 0 {name=X_76254_ }
C {devices/lab_pin.sym} 66980 -6390 0 0 {name=p66834 lab=_42645_/Y }
C {devices/lab_pin.sym} 67060 -6390 0 1 {name=p66835 lab=_42646_/Y }
C {sky130_stdcells/inv_2.sym} 67020 -6390 0 0 {name=X_42646_ }
C {devices/lab_pin.sym} 66980 -6270 0 0 {name=p66836 lab=_61355_/A }
C {devices/lab_pin.sym} 67060 -6270 0 1 {name=p66837 lab=_61482_/A }
C {sky130_stdcells/buf_2.sym} 67020 -6270 0 0 {name=X_61480_ }
C {devices/lab_pin.sym} 66940 -6180 0 0 {name=p66838 lab=_69932_/B }
C {devices/lab_pin.sym} 66940 -6140 0 0 {name=p66839 lab=_73250_/X }
C {devices/lab_pin.sym} 66940 -6100 0 0 {name=p66840 lab=_73464_/X }
C {devices/lab_pin.sym} 66940 -6060 0 0 {name=p66841 lab=_73465_/Y }
C {devices/lab_pin.sym} 67100 -6120 0 1 {name=p66842 lab=_73466_/X }
C {sky130_stdcells/a211o_4.sym} 67020 -6120 0 0 {name=X_73466_ }
C {devices/lab_pin.sym} 66980 -5970 0 0 {name=p66843 lab=_70552_/Y }
C {devices/lab_pin.sym} 67060 -5970 0 1 {name=p66844 lab=_70679_/A }
C {sky130_stdcells/buf_2.sym} 67020 -5970 0 0 {name=X_70678_ }
C {devices/lab_pin.sym} 66980 -5850 0 0 {name=p66845 lab=clkbuf_9_455_0_CLK/A }
C {devices/lab_pin.sym} 67060 -5850 0 1 {name=p66846 lab=clkbuf_9_455_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 67020 -5850 0 0 {name=Xclkbuf_9_455_0_CLK }
C {devices/lab_pin.sym} 66980 -5730 0 0 {name=p66847 lab=_75205_/A }
C {devices/lab_pin.sym} 67060 -5730 0 1 {name=p66848 lab=_75205_/Y }
C {sky130_stdcells/inv_2.sym} 67020 -5730 0 0 {name=X_75205_ }
C {devices/lab_pin.sym} 66980 -5610 0 0 {name=p66849 lab=_48153_/A }
C {devices/lab_pin.sym} 67060 -5610 0 1 {name=p66850 lab=_50389_/B }
C {sky130_stdcells/buf_2.sym} 67020 -5610 0 0 {name=X_48153_ }
C {devices/lab_pin.sym} 66980 -5490 0 0 {name=p66851 lab=_60430_/Y }
C {devices/lab_pin.sym} 67060 -5490 0 1 {name=p66852 lab=_60438_/A }
C {sky130_stdcells/buf_2.sym} 67020 -5490 0 0 {name=X_60431_ }
C {devices/lab_pin.sym} 66980 -5370 0 0 {name=p66853 lab=_72417_/A }
C {devices/lab_pin.sym} 67060 -5370 0 1 {name=p66854 lab=_72417_/X }
C {sky130_stdcells/buf_2.sym} 67020 -5370 0 0 {name=X_72417_ }
C {devices/lab_pin.sym} 66960 -5260 0 0 {name=p66855 lab=_45365_/A }
C {devices/lab_pin.sym} 66960 -5220 0 0 {name=p66856 lab=_45381_/B }
C {devices/lab_pin.sym} 67080 -5240 0 1 {name=p66857 lab=_45365_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -5240 0 0 {name=X_45365_ }
C {devices/lab_pin.sym} 66960 -5120 0 0 {name=p66858 lab=_76187_/A }
C {devices/lab_pin.sym} 66960 -5080 0 0 {name=p66859 lab=_81553_/Q }
C {devices/lab_pin.sym} 67080 -5100 0 1 {name=p66860 lab=_76186_/A }
C {sky130_stdcells/nor2_4.sym} 67020 -5100 0 0 {name=X_76185_ }
C {devices/lab_pin.sym} 66940 -5010 0 0 {name=p66861 lab=_42573_/X }
C {devices/lab_pin.sym} 66940 -4970 0 0 {name=p66862 lab=_42574_/X }
C {devices/lab_pin.sym} 66940 -4930 0 0 {name=p66863 lab=_40831_/X }
C {devices/lab_pin.sym} 66940 -4890 0 0 {name=p66864 lab=_69734_/A }
C {devices/lab_pin.sym} 66940 -4850 0 0 {name=p66865 lab=_42540_/X }
C {devices/lab_pin.sym} 67100 -4930 0 1 {name=p66866 lab=_42578_/A }
C {sky130_stdcells/o32ai_4.sym} 67020 -4930 0 0 {name=X_42577_ }
C {devices/lab_pin.sym} 66940 -4800 0 0 {name=p66867 lab=_43190_/Y }
C {devices/lab_pin.sym} 66940 -4760 0 0 {name=p66868 lab=_73298_/X }
C {devices/lab_pin.sym} 66940 -4720 0 0 {name=p66869 lab=_73251_/X }
C {devices/lab_pin.sym} 66940 -4680 0 0 {name=p66870 lab=_73396_/Y }
C {devices/lab_pin.sym} 67100 -4740 0 1 {name=p66871 lab=_73397_/X }
C {sky130_stdcells/a211o_4.sym} 67020 -4740 0 0 {name=X_73397_ }
C {devices/lab_pin.sym} 66980 -4590 0 0 {name=p66872 lab=clkbuf_9_174_0_CLK/X }
C {devices/lab_pin.sym} 67060 -4590 0 1 {name=p66873 lab=_85745_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67020 -4590 0 0 {name=Xclkbuf_10_349_0_CLK }
C {devices/lab_pin.sym} 66980 -4470 0 0 {name=p66874 lab=_47103_/Y }
C {devices/lab_pin.sym} 67060 -4470 0 1 {name=p66875 lab=_52857_/D }
C {sky130_stdcells/buf_2.sym} 67020 -4470 0 0 {name=X_47104_ }
C {devices/lab_pin.sym} 66940 -4390 0 0 {name=p66876 lab=_58631_/A }
C {devices/lab_pin.sym} 66940 -4350 0 0 {name=p66877 lab=_44031_/X }
C {devices/lab_pin.sym} 66940 -4310 0 0 {name=p66878 lab=_57811_/A }
C {devices/lab_pin.sym} 66940 -4270 0 0 {name=p66879 lab=_58007_/A }
C {devices/lab_pin.sym} 66940 -4240 0 0 {name=p66880 lab=_44253_/X }
C {devices/lab_pin.sym} 67100 -4310 0 1 {name=p66881 lab=_44316_/X }
C {sky130_stdcells/a41o_4.sym} 67020 -4310 0 0 {name=X_44316_ }
C {devices/lab_pin.sym} 66960 -4160 0 0 {name=p66882 lab=_75133_/Y }
C {devices/lab_pin.sym} 66960 -4120 0 0 {name=p66883 lab=_75135_/Y }
C {devices/lab_pin.sym} 67080 -4140 0 1 {name=p66884 lab=_81030_/D }
C {sky130_stdcells/xnor2_4.sym} 67020 -4140 0 0 {name=X_75136_ }
C {devices/lab_pin.sym} 66960 -4040 0 0 {name=p66885 lab=_63150_/A }
C {devices/lab_pin.sym} 66960 -4000 0 0 {name=p66886 lab=_63113_/B }
C {devices/lab_pin.sym} 66960 -3960 0 0 {name=p66887 lab=_63103_/C }
C {devices/lab_pin.sym} 66960 -3920 0 0 {name=p66888 lab=_63149_/X }
C {devices/lab_pin.sym} 67080 -3980 0 1 {name=p66889 lab=_63150_/X }
C {sky130_stdcells/or4_4.sym} 67020 -3980 0 0 {name=X_63150_ }
C {devices/lab_pin.sym} 66940 -3850 0 0 {name=p66890 lab=_41261_/X }
C {devices/lab_pin.sym} 66940 -3810 0 0 {name=p66891 lab=_81171_/Q }
C {devices/lab_pin.sym} 66940 -3770 0 0 {name=p66892 lab=_41527_/X }
C {devices/lab_pin.sym} 67100 -3810 0 1 {name=p66893 lab=_41529_/A }
C {sky130_stdcells/o21ai_4.sym} 67020 -3810 0 0 {name=X_41528_ }
C {devices/lab_pin.sym} 66980 -3670 0 0 {name=p66894 lab=clkbuf_9_489_0_CLK/X }
C {devices/lab_pin.sym} 67060 -3670 0 1 {name=p66895 lab=_85554_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67020 -3670 0 0 {name=Xclkbuf_10_979_0_CLK }
C {devices/lab_pin.sym} 66940 -3570 0 0 {name=p66896 lab=_74129_/B }
C {devices/lab_pin.sym} 66940 -3530 0 0 {name=p66897 lab=_48049_/X }
C {devices/lab_pin.sym} 66940 -3490 0 0 {name=p66898 lab=_48083_/Y }
C {devices/lab_pin.sym} 67100 -3530 0 1 {name=p66899 lab=_48084_/Y }
C {sky130_stdcells/o21ai_4.sym} 67020 -3530 0 0 {name=X_48084_ }
C {devices/lab_pin.sym} 66980 -3390 0 0 {name=p66900 lab=_60362_/A }
C {devices/lab_pin.sym} 67060 -3390 0 1 {name=p66901 lab=_62678_/A }
C {sky130_stdcells/buf_2.sym} 67020 -3390 0 0 {name=X_60362_ }
C {devices/lab_pin.sym} 66960 -3280 0 0 {name=p66902 lab=_86606_/Q }
C {devices/lab_pin.sym} 66960 -3240 0 0 {name=p66903 lab=_72348_/B }
C {devices/lab_pin.sym} 67080 -3260 0 1 {name=p66904 lab=_72348_/Y }
C {sky130_stdcells/nor2_4.sym} 67020 -3260 0 0 {name=X_72348_ }
C {devices/lab_pin.sym} 66940 -3150 0 0 {name=p66905 lab=_45288_/X }
C {devices/lab_pin.sym} 66940 -3110 0 0 {name=p66906 lab=_45292_/Y }
C {devices/lab_pin.sym} 66940 -3070 0 0 {name=p66907 lab=_45295_/Y }
C {devices/lab_pin.sym} 67100 -3110 0 1 {name=p66908 lab=_45296_/Y }
C {sky130_stdcells/a21oi_4.sym} 67020 -3110 0 0 {name=X_45296_ }
C {devices/lab_pin.sym} 66980 -2970 0 0 {name=p66909 lab=_62033_/A }
C {devices/lab_pin.sym} 67060 -2970 0 1 {name=p66910 lab=_62101_/X }
C {sky130_stdcells/buf_2.sym} 67020 -2970 0 0 {name=X_62101_ }
C {devices/lab_pin.sym} 66980 -2850 0 0 {name=p66911 lab=_47081_/A }
C {devices/lab_pin.sym} 67060 -2850 0 1 {name=p66912 lab=_47035_/X }
C {sky130_stdcells/buf_2.sym} 67020 -2850 0 0 {name=X_47035_ }
C {devices/lab_pin.sym} 66980 -2730 0 0 {name=p66913 lab=_44247_/A }
C {devices/lab_pin.sym} 67060 -2730 0 1 {name=p66914 lab=_58602_/A }
C {sky130_stdcells/buf_2.sym} 67020 -2730 0 0 {name=X_44247_ }
C {devices/lab_pin.sym} 66960 -2640 0 0 {name=p66915 lab=_63081_/A }
C {devices/lab_pin.sym} 66960 -2600 0 0 {name=p66916 lab=_63081_/B }
C {devices/lab_pin.sym} 66960 -2560 0 0 {name=p66917 lab=_63081_/C }
C {devices/lab_pin.sym} 66960 -2520 0 0 {name=p66918 lab=_63033_/D }
C {devices/lab_pin.sym} 67080 -2580 0 1 {name=p66919 lab=_63081_/X }
C {sky130_stdcells/or4_4.sym} 67020 -2580 0 0 {name=X_63081_ }
C {devices/lab_pin.sym} 66960 -2440 0 0 {name=p66920 lab=_75067_/A }
C {devices/lab_pin.sym} 66960 -2400 0 0 {name=p66921 lab=_75067_/B }
C {devices/lab_pin.sym} 67080 -2420 0 1 {name=p66922 lab=_75067_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -2420 0 0 {name=X_75067_ }
C {devices/lab_pin.sym} 66960 -2310 0 0 {name=p66923 lab=_79944_/A }
C {devices/lab_pin.sym} 66960 -2270 0 0 {name=p66924 lab=_79945_/B }
C {devices/lab_pin.sym} 66960 -2230 0 0 {name=p66925 lab=_79945_/A }
C {devices/lab_pin.sym} 67080 -2270 0 1 {name=p66926 lab=_79944_/Y }
C {sky130_stdcells/nand3_4.sym} 67020 -2270 0 0 {name=X_79944_ }
C {devices/lab_pin.sym} 66960 -2140 0 0 {name=p66927 lab=_81185_/Q }
C {devices/lab_pin.sym} 66960 -2100 0 0 {name=p66928 lab=_41459_/B }
C {devices/lab_pin.sym} 67080 -2120 0 1 {name=p66929 lab=_41459_/X }
C {sky130_stdcells/or2_4.sym} 67020 -2120 0 0 {name=X_41459_ }
C {devices/lab_pin.sym} 66980 -1990 0 0 {name=p66930 lab=_60105_/X }
C {devices/lab_pin.sym} 67060 -1990 0 1 {name=p66931 lab=_60317_/A }
C {sky130_stdcells/buf_2.sym} 67020 -1990 0 0 {name=X_60293_ }
C {devices/lab_pin.sym} 66940 -1910 0 0 {name=p66932 lab=_72137_/X }
C {devices/lab_pin.sym} 66940 -1870 0 0 {name=p66933 lab=_72277_/Y }
C {devices/lab_pin.sym} 66940 -1830 0 0 {name=p66934 lab=_72278_/Y }
C {devices/lab_pin.sym} 66940 -1790 0 0 {name=p66935 lab=_72194_/X }
C {devices/lab_pin.sym} 66940 -1750 0 0 {name=p66936 lab=_72141_/X }
C {devices/lab_pin.sym} 67100 -1830 0 1 {name=p66937 lab=_72279_/X }
C {sky130_stdcells/o32a_4.sym} 67020 -1830 0 0 {name=X_72279_ }
C {devices/lab_pin.sym} 66980 -1670 0 0 {name=p66938 lab=_61348_/A }
C {devices/lab_pin.sym} 67060 -1670 0 1 {name=p66939 lab=_62033_/A }
C {sky130_stdcells/buf_2.sym} 67020 -1670 0 0 {name=X_62032_ }
C {devices/lab_pin.sym} 66940 -1580 0 0 {name=p66940 lab=_74016_/X }
C {devices/lab_pin.sym} 66940 -1540 0 0 {name=p66941 lab=_85614_/Q }
C {devices/lab_pin.sym} 66940 -1500 0 0 {name=p66942 lab=_73903_/X }
C {devices/lab_pin.sym} 66940 -1460 0 0 {name=p66943 lab=_74017_/X }
C {devices/lab_pin.sym} 67100 -1520 0 1 {name=p66944 lab=_74018_/X }
C {sky130_stdcells/a211o_4.sym} 67020 -1520 0 0 {name=X_74018_ }
C {devices/lab_pin.sym} 66980 -1370 0 0 {name=p66945 lab=_44146_/A }
C {devices/lab_pin.sym} 67060 -1370 0 1 {name=p66946 lab=_45924_/A }
C {sky130_stdcells/buf_2.sym} 67020 -1370 0 0 {name=X_44178_ }
C {devices/lab_pin.sym} 66960 -1260 0 0 {name=p66947 lab=_79875_/A }
C {devices/lab_pin.sym} 66960 -1220 0 0 {name=p66948 lab=_79875_/B }
C {devices/lab_pin.sym} 67080 -1240 0 1 {name=p66949 lab=_79875_/Y }
C {sky130_stdcells/nand2_4.sym} 67020 -1240 0 0 {name=X_79875_ }
C {devices/lab_pin.sym} 66980 -1110 0 0 {name=p66950 lab=clkbuf_9_451_0_CLK/X }
C {devices/lab_pin.sym} 67060 -1110 0 1 {name=p66951 lab=_82538_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67020 -1110 0 0 {name=Xclkbuf_10_902_0_CLK }
C {devices/lab_pin.sym} 66980 -990 0 0 {name=p66952 lab=_43129_/A }
C {devices/lab_pin.sym} 67060 -990 0 1 {name=p66953 lab=_43129_/X }
C {sky130_stdcells/buf_2.sym} 67020 -990 0 0 {name=X_43129_ }
C {devices/lab_pin.sym} 66980 -870 0 0 {name=p66954 lab=_68721_/A }
C {devices/lab_pin.sym} 67060 -870 0 1 {name=p66955 lab=_66840_/X }
C {sky130_stdcells/buf_2.sym} 67020 -870 0 0 {name=X_66840_ }
C {devices/lab_pin.sym} 66980 -750 0 0 {name=p66956 lab=_82628_/Q }
C {devices/lab_pin.sym} 67060 -750 0 1 {name=p66957 lab=_78828_/B }
C {sky130_stdcells/inv_2.sym} 67020 -750 0 0 {name=X_78826_ }
C {devices/lab_pin.sym} 67880 -42160 0 0 {name=p66958 lab=_48986_/A }
C {devices/lab_pin.sym} 67880 -42120 0 0 {name=p66959 lab=_49009_/B }
C {devices/lab_pin.sym} 68000 -42140 0 1 {name=p66960 lab=_48986_/Y }
C {sky130_stdcells/nor2_4.sym} 67940 -42140 0 0 {name=X_48986_ }
C {devices/lab_pin.sym} 67880 -42020 0 0 {name=p66961 lab=_47946_/A }
C {devices/lab_pin.sym} 67880 -41980 0 0 {name=p66962 lab=_47937_/B }
C {devices/lab_pin.sym} 68000 -42000 0 1 {name=p66963 lab=_47937_/X }
C {sky130_stdcells/and2_4.sym} 67940 -42000 0 0 {name=X_47937_ }
C {devices/lab_pin.sym} 67880 -41880 0 0 {name=p66964 lab=_66771_/A }
C {devices/lab_pin.sym} 67880 -41840 0 0 {name=p66965 lab=_66770_/X }
C {devices/lab_pin.sym} 68000 -41860 0 1 {name=p66966 lab=_66771_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -41860 0 0 {name=X_66771_ }
C {devices/lab_pin.sym} 67860 -41750 0 0 {name=p66967 lab=_78758_/A }
C {devices/lab_pin.sym} 67860 -41710 0 0 {name=p66968 lab=_78758_/C }
C {devices/lab_pin.sym} 67860 -41670 0 0 {name=p66969 lab=_78756_/Y }
C {devices/lab_pin.sym} 68020 -41710 0 1 {name=p66970 lab=_78770_/B }
C {sky130_stdcells/a21o_4.sym} 67940 -41710 0 0 {name=X_78757_ }
C {devices/lab_pin.sym} 67900 -41570 0 0 {name=p66971 lab=_60906_/X }
C {devices/lab_pin.sym} 67980 -41570 0 1 {name=p66972 lab=_64046_/C }
C {sky130_stdcells/buf_2.sym} 67940 -41570 0 0 {name=X_63983_ }
C {devices/lab_pin.sym} 67880 -41460 0 0 {name=p66973 lab=_75964_/A }
C {devices/lab_pin.sym} 67880 -41420 0 0 {name=p66974 lab=_75969_/B }
C {devices/lab_pin.sym} 68000 -41440 0 1 {name=p66975 lab=_75969_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -41440 0 0 {name=X_75969_ }
C {devices/lab_pin.sym} 67880 -41320 0 0 {name=p66976 lab=_68409_/A }
C {devices/lab_pin.sym} 67880 -41280 0 0 {name=p66977 lab=_88270_/Q }
C {devices/lab_pin.sym} 68000 -41300 0 1 {name=p66978 lab=_68510_/X }
C {sky130_stdcells/and2_4.sym} 67940 -41300 0 0 {name=X_68510_ }
C {devices/lab_pin.sym} 67900 -41170 0 0 {name=p66979 lab=_64683_/A }
C {devices/lab_pin.sym} 67980 -41170 0 1 {name=p66980 lab=_65725_/B }
C {sky130_stdcells/buf_2.sym} 67940 -41170 0 0 {name=X_65722_ }
C {devices/lab_pin.sym} 67880 -41060 0 0 {name=p66981 lab=_81952_/Q }
C {devices/lab_pin.sym} 67880 -41020 0 0 {name=p66982 lab=_77707_/A }
C {devices/lab_pin.sym} 68000 -41040 0 1 {name=p66983 lab=_77708_/Y }
C {sky130_stdcells/xnor2_4.sym} 67940 -41040 0 0 {name=X_77708_ }
C {devices/lab_pin.sym} 67860 -40950 0 0 {name=p66984 lab=_58187_/X }
C {devices/lab_pin.sym} 67860 -40910 0 0 {name=p66985 lab=_62808_/X }
C {devices/lab_pin.sym} 67860 -40870 0 0 {name=p66986 lab=_62827_/X }
C {devices/lab_pin.sym} 67860 -40830 0 0 {name=p66987 lab=_62818_/X }
C {devices/lab_pin.sym} 67860 -40800 0 0 {name=p66988 lab=_62933_/X }
C {devices/lab_pin.sym} 68020 -40870 0 1 {name=p66989 lab=_62934_/Y }
C {sky130_stdcells/a41oi_4.sym} 67940 -40870 0 0 {name=X_62934_ }
C {devices/lab_pin.sym} 67900 -40710 0 0 {name=p66990 lab=clkbuf_9_458_0_CLK/X }
C {devices/lab_pin.sym} 67980 -40710 0 1 {name=p66991 lab=_86549_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67940 -40710 0 0 {name=Xclkbuf_10_917_0_CLK }
C {devices/lab_pin.sym} 67860 -40610 0 0 {name=p66992 lab=_81384_/D }
C {devices/lab_pin.sym} 67860 -40570 0 0 {name=p66993 lab=_69439_/X }
C {devices/lab_pin.sym} 67860 -40530 0 0 {name=p66994 lab=_69489_/X }
C {devices/lab_pin.sym} 68020 -40570 0 1 {name=p66995 lab=_83920_/D }
C {sky130_stdcells/a21bo_4.sym} 67940 -40570 0 0 {name=X_69490_ }
C {devices/lab_pin.sym} 67900 -40430 0 0 {name=p66996 lab=_82366_/Q }
C {devices/lab_pin.sym} 67980 -40430 0 1 {name=p66997 lab=_47869_/A }
C {sky130_stdcells/inv_2.sym} 67940 -40430 0 0 {name=X_47868_ }
C {devices/lab_pin.sym} 67880 -40320 0 0 {name=p66998 lab=_82523_/Q }
C {devices/lab_pin.sym} 67880 -40280 0 0 {name=p66999 lab=_82779_/D }
C {devices/lab_pin.sym} 68000 -40300 0 1 {name=p67000 lab=_82491_/D }
C {sky130_stdcells/xor2_4.sym} 67940 -40300 0 0 {name=X_78688_ }
C {devices/lab_pin.sym} 67900 -40170 0 0 {name=p67001 lab=_49580_/A }
C {devices/lab_pin.sym} 67980 -40170 0 1 {name=p67002 lab=_49607_/X }
C {sky130_stdcells/buf_2.sym} 67940 -40170 0 0 {name=X_49607_ }
C {devices/lab_pin.sym} 67900 -40050 0 0 {name=p67003 lab=clkbuf_9_3_0_CLK/X }
C {devices/lab_pin.sym} 67980 -40050 0 1 {name=p67004 lab=_85177_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67940 -40050 0 0 {name=Xclkbuf_10_6_0_CLK }
C {devices/lab_pin.sym} 67860 -39960 0 0 {name=p67005 lab=_88112_/Q }
C {devices/lab_pin.sym} 67860 -39920 0 0 {name=p67006 lab=_68069_/X }
C {devices/lab_pin.sym} 67860 -39880 0 0 {name=p67007 lab=_68439_/X }
C {devices/lab_pin.sym} 67860 -39840 0 0 {name=p67008 lab=_68440_/Y }
C {devices/lab_pin.sym} 68020 -39900 0 1 {name=p67009 lab=_68441_/X }
C {sky130_stdcells/a211o_4.sym} 67940 -39900 0 0 {name=X_68441_ }
C {devices/lab_pin.sym} 67900 -39750 0 0 {name=p67010 lab=_46915_/A }
C {devices/lab_pin.sym} 67980 -39750 0 1 {name=p67011 lab=_46830_/A }
C {sky130_stdcells/buf_2.sym} 67940 -39750 0 0 {name=X_46819_ }
C {devices/lab_pin.sym} 67880 -39650 0 0 {name=p67012 lab=_65014_/X }
C {devices/lab_pin.sym} 67880 -39610 0 0 {name=p67013 lab=_65653_/B }
C {devices/lab_pin.sym} 67880 -39570 0 0 {name=p67014 lab=_65017_/X }
C {devices/lab_pin.sym} 68000 -39610 0 1 {name=p67015 lab=_65664_/A }
C {sky130_stdcells/nand3_4.sym} 67940 -39610 0 0 {name=X_65653_ }
C {devices/lab_pin.sym} 67880 -39490 0 0 {name=p67016 lab=_77633_/X }
C {devices/lab_pin.sym} 67880 -39450 0 0 {name=p67017 lab=_77636_/Y }
C {devices/lab_pin.sym} 67880 -39410 0 0 {name=p67018 lab=_77634_/Y }
C {devices/lab_pin.sym} 68000 -39450 0 1 {name=p67019 lab=_77639_/Y }
C {sky130_stdcells/nand3_4.sym} 67940 -39450 0 0 {name=X_77639_ }
C {devices/lab_pin.sym} 67860 -39330 0 0 {name=p67020 lab=_62863_/X }
C {devices/lab_pin.sym} 67860 -39290 0 0 {name=p67021 lab=_62838_/X }
C {devices/lab_pin.sym} 67860 -39250 0 0 {name=p67022 lab=_62864_/Y }
C {devices/lab_pin.sym} 68020 -39290 0 1 {name=p67023 lab=_84376_/D }
C {sky130_stdcells/a21oi_4.sym} 67940 -39290 0 0 {name=X_62865_ }
C {devices/lab_pin.sym} 67900 -39150 0 0 {name=p67024 lab=clkbuf_9_409_0_CLK/A }
C {devices/lab_pin.sym} 67980 -39150 0 1 {name=p67025 lab=clkbuf_9_408_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 67940 -39150 0 0 {name=Xclkbuf_9_408_0_CLK }
C {devices/lab_pin.sym} 67880 -39040 0 0 {name=p67026 lab=_47799_/A }
C {devices/lab_pin.sym} 67880 -39000 0 0 {name=p67027 lab=_51728_/B }
C {devices/lab_pin.sym} 68000 -39020 0 1 {name=p67028 lab=_47799_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -39020 0 0 {name=X_47799_ }
C {devices/lab_pin.sym} 67860 -38920 0 0 {name=p67029 lab=_64599_/X }
C {devices/lab_pin.sym} 67860 -38880 0 0 {name=p67030 lab=_83313_/Q }
C {devices/lab_pin.sym} 67860 -38840 0 0 {name=p67031 lab=_64600_/X }
C {devices/lab_pin.sym} 67860 -38800 0 0 {name=p67032 lab=_64603_/X }
C {devices/lab_pin.sym} 68020 -38860 0 1 {name=p67033 lab=_64604_/X }
C {sky130_stdcells/a211o_4.sym} 67940 -38860 0 0 {name=X_64604_ }
C {devices/lab_pin.sym} 67860 -38730 0 0 {name=p67034 lab=_49536_/Y }
C {devices/lab_pin.sym} 67860 -38690 0 0 {name=p67035 lab=_49514_/X }
C {devices/lab_pin.sym} 67860 -38650 0 0 {name=p67036 lab=_49537_/X }
C {devices/lab_pin.sym} 68020 -38690 0 1 {name=p67037 lab=_49538_/Y }
C {sky130_stdcells/a21oi_4.sym} 67940 -38690 0 0 {name=X_49538_ }
C {devices/lab_pin.sym} 67860 -38590 0 0 {name=p67038 lab=_61805_/X }
C {devices/lab_pin.sym} 67860 -38550 0 0 {name=p67039 lab=_61807_/X }
C {devices/lab_pin.sym} 67860 -38510 0 0 {name=p67040 lab=_61814_/Y }
C {devices/lab_pin.sym} 67860 -38470 0 0 {name=p67041 lab=_58166_/A }
C {devices/lab_pin.sym} 67860 -38430 0 0 {name=p67042 lab=_61815_/X }
C {devices/lab_pin.sym} 68020 -38510 0 1 {name=p67043 lab=_61816_/Y }
C {sky130_stdcells/o32ai_4.sym} 67940 -38510 0 0 {name=X_61816_ }
C {devices/lab_pin.sym} 67900 -38340 0 0 {name=p67044 lab=_74811_/X }
C {devices/lab_pin.sym} 67900 -38300 0 0 {name=p67045 lab=_74714_/Y }
C {devices/lab_pin.sym} 67980 -38340 0 1 {name=p67046 lab=DATA_FROM_HASH[7] }
C {sky130_stdcells/ebufn_2.sym} 67940 -38340 0 0 {name=X_80650_ }
C {devices/lab_pin.sym} 67860 -38240 0 0 {name=p67047 lab=_87007_/Q }
C {devices/lab_pin.sym} 67860 -38200 0 0 {name=p67048 lab=_68059_/X }
C {devices/lab_pin.sym} 67860 -38160 0 0 {name=p67049 lab=_68370_/X }
C {devices/lab_pin.sym} 67860 -38120 0 0 {name=p67050 lab=_68371_/X }
C {devices/lab_pin.sym} 68020 -38180 0 1 {name=p67051 lab=_68372_/X }
C {sky130_stdcells/a211o_4.sym} 67940 -38180 0 0 {name=X_68372_ }
C {devices/lab_pin.sym} 67880 -38040 0 0 {name=p67052 lab=_65769_/A }
C {devices/lab_pin.sym} 67880 -38000 0 0 {name=p67053 lab=_65584_/B }
C {devices/lab_pin.sym} 68000 -38020 0 1 {name=p67054 lab=_65584_/X }
C {sky130_stdcells/and2_4.sym} 67940 -38020 0 0 {name=X_65584_ }
C {devices/lab_pin.sym} 67900 -37890 0 0 {name=p67055 lab=_60179_/A }
C {devices/lab_pin.sym} 67980 -37890 0 1 {name=p67056 lab=_62819_/C }
C {sky130_stdcells/buf_2.sym} 67940 -37890 0 0 {name=X_62796_ }
C {devices/lab_pin.sym} 67860 -37790 0 0 {name=p67057 lab=_67318_/X }
C {devices/lab_pin.sym} 67860 -37750 0 0 {name=p67058 lab=_67321_/X }
C {devices/lab_pin.sym} 67860 -37710 0 0 {name=p67059 lab=_67322_/X }
C {devices/lab_pin.sym} 68020 -37750 0 1 {name=p67060 lab=_67323_/X }
C {sky130_stdcells/a21o_4.sym} 67940 -37750 0 0 {name=X_67323_ }
C {devices/lab_pin.sym} 67880 -37620 0 0 {name=p67061 lab=_84798_/Q }
C {devices/lab_pin.sym} 67880 -37580 0 0 {name=p67062 lab=_84118_/Q }
C {devices/lab_pin.sym} 68000 -37600 0 1 {name=p67063 lab=_79309_/X }
C {sky130_stdcells/xor2_4.sym} 67940 -37600 0 0 {name=X_79309_ }
C {devices/lab_pin.sym} 67880 -37490 0 0 {name=p67064 lab=_64545_/A }
C {devices/lab_pin.sym} 67880 -37450 0 0 {name=p67065 lab=_64535_/B }
C {devices/lab_pin.sym} 67880 -37410 0 0 {name=p67066 lab=_64545_/C }
C {devices/lab_pin.sym} 68000 -37450 0 1 {name=p67067 lab=_64535_/X }
C {sky130_stdcells/and3_4.sym} 67940 -37450 0 0 {name=X_64535_ }
C {devices/lab_pin.sym} 67900 -37310 0 0 {name=p67068 lab=_49002_/A }
C {devices/lab_pin.sym} 67980 -37310 0 1 {name=p67069 lab=_49496_/A }
C {sky130_stdcells/buf_2.sym} 67940 -37310 0 0 {name=X_49469_ }
C {devices/lab_pin.sym} 67900 -37190 0 0 {name=p67070 lab=_59721_/A }
C {devices/lab_pin.sym} 67980 -37190 0 1 {name=p67071 lab=_61747_/X }
C {sky130_stdcells/buf_2.sym} 67940 -37190 0 0 {name=X_61747_ }
C {devices/lab_pin.sym} 67880 -37080 0 0 {name=p67072 lab=_80596_/A }
C {devices/lab_pin.sym} 67880 -37040 0 0 {name=p67073 lab=_80596_/B }
C {devices/lab_pin.sym} 68000 -37060 0 1 {name=p67074 lab=_80581_/X }
C {sky130_stdcells/xor2_4.sym} 67940 -37060 0 0 {name=X_80581_ }
C {devices/lab_pin.sym} 67860 -36950 0 0 {name=p67075 lab=_51497_/Y }
C {devices/lab_pin.sym} 67860 -36910 0 0 {name=p67076 lab=_51477_/X }
C {devices/lab_pin.sym} 67860 -36870 0 0 {name=p67077 lab=_51499_/X }
C {devices/lab_pin.sym} 68020 -36910 0 1 {name=p67078 lab=_85999_/D }
C {sky130_stdcells/a21oi_4.sym} 67940 -36910 0 0 {name=X_51500_ }
C {devices/lab_pin.sym} 67850 -36770 0 0 {name=p67079 lab=_82327_/CLK }
C {devices/lab_pin.sym} 67850 -36750 0 0 {name=p67080 lab=_77103_/B }
C {devices/lab_pin.sym} 68030 -36770 0 1 {name=p67081 lab=_82320_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -36760 0 0 {name=X_82320_ }
C {devices/lab_pin.sym} 67860 -36660 0 0 {name=p67082 lab=_87107_/Q }
C {devices/lab_pin.sym} 67860 -36620 0 0 {name=p67083 lab=_67230_/X }
C {devices/lab_pin.sym} 67860 -36580 0 0 {name=p67084 lab=_67160_/X }
C {devices/lab_pin.sym} 67860 -36540 0 0 {name=p67085 lab=_67253_/X }
C {devices/lab_pin.sym} 68020 -36600 0 1 {name=p67086 lab=_67254_/X }
C {sky130_stdcells/a211o_4.sym} 67940 -36600 0 0 {name=X_67254_ }
C {devices/lab_pin.sym} 67880 -36460 0 0 {name=p67087 lab=_52476_/A }
C {devices/lab_pin.sym} 67880 -36420 0 0 {name=p67088 lab=_52480_/B }
C {devices/lab_pin.sym} 68000 -36440 0 1 {name=p67089 lab=_52480_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -36440 0 0 {name=X_52480_ }
C {devices/lab_pin.sym} 67880 -36330 0 0 {name=p67090 lab=_64494_/A }
C {devices/lab_pin.sym} 67880 -36290 0 0 {name=p67091 lab=_64466_/B }
C {devices/lab_pin.sym} 67880 -36250 0 0 {name=p67092 lab=_64207_/A }
C {devices/lab_pin.sym} 68000 -36290 0 1 {name=p67093 lab=_64466_/X }
C {sky130_stdcells/and3_4.sym} 67940 -36290 0 0 {name=X_64466_ }
C {devices/lab_pin.sym} 67900 -36150 0 0 {name=p67094 lab=_61678_/A }
C {devices/lab_pin.sym} 67980 -36150 0 1 {name=p67095 lab=_61678_/Y }
C {sky130_stdcells/inv_2.sym} 67940 -36150 0 0 {name=X_61678_ }
C {devices/lab_pin.sym} 67900 -36030 0 0 {name=p67096 lab=_66065_/A }
C {devices/lab_pin.sym} 67980 -36030 0 1 {name=p67097 lab=_66205_/X }
C {sky130_stdcells/buf_2.sym} 67940 -36030 0 0 {name=X_66205_ }
C {devices/lab_pin.sym} 67880 -35920 0 0 {name=p67098 lab=_51430_/X }
C {devices/lab_pin.sym} 67880 -35880 0 0 {name=p67099 lab=_52959_/B }
C {devices/lab_pin.sym} 68000 -35900 0 1 {name=p67100 lab=_51431_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -35900 0 0 {name=X_51431_ }
C {devices/lab_pin.sym} 67900 -35770 0 0 {name=p67101 lab=_63417_/A }
C {devices/lab_pin.sym} 67980 -35770 0 1 {name=p67102 lab=_63465_/D }
C {sky130_stdcells/buf_2.sym} 67940 -35770 0 0 {name=X_63417_ }
C {devices/lab_pin.sym} 67850 -35650 0 0 {name=p67103 lab=_82251_/CLK }
C {devices/lab_pin.sym} 67850 -35630 0 0 {name=p67104 lab=_82251_/D }
C {devices/lab_pin.sym} 68030 -35650 0 1 {name=p67105 lab=_82251_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -35640 0 0 {name=X_82251_ }
C {devices/lab_pin.sym} 67900 -35510 0 0 {name=p67106 lab=_60628_/Y }
C {devices/lab_pin.sym} 67980 -35510 0 1 {name=p67107 lab=_60629_/Y }
C {sky130_stdcells/inv_2.sym} 67940 -35510 0 0 {name=X_60629_ }
C {devices/lab_pin.sym} 67860 -35410 0 0 {name=p67108 lab=_67181_/X }
C {devices/lab_pin.sym} 67860 -35370 0 0 {name=p67109 lab=_67184_/X }
C {devices/lab_pin.sym} 67860 -35330 0 0 {name=p67110 lab=_67113_/X }
C {devices/lab_pin.sym} 68020 -35370 0 1 {name=p67111 lab=_67185_/Y }
C {sky130_stdcells/a21oi_4.sym} 67940 -35370 0 0 {name=X_67185_ }
C {devices/lab_pin.sym} 67860 -35250 0 0 {name=p67112 lab=_64389_/Y }
C {devices/lab_pin.sym} 67860 -35210 0 0 {name=p67113 lab=_64396_/X }
C {devices/lab_pin.sym} 67860 -35170 0 0 {name=p67114 lab=_64386_/X }
C {devices/lab_pin.sym} 68020 -35210 0 1 {name=p67115 lab=_64397_/X }
C {sky130_stdcells/o21a_4.sym} 67940 -35210 0 0 {name=X_64397_ }
C {devices/lab_pin.sym} 67850 -35070 0 0 {name=p67116 lab=_81198_/CLK }
C {devices/lab_pin.sym} 67850 -35050 0 0 {name=p67117 lab=_75014_/X }
C {devices/lab_pin.sym} 68030 -35070 0 1 {name=p67118 lab=_49039_/A }
C {sky130_stdcells/dfxtp_4.sym} 67940 -35060 0 0 {name=X_81202_ }
C {devices/lab_pin.sym} 67860 -34950 0 0 {name=p67119 lab=_85495_/Q }
C {devices/lab_pin.sym} 67860 -34910 0 0 {name=p67120 lab=_54140_/X }
C {devices/lab_pin.sym} 67860 -34870 0 0 {name=p67121 lab=_54149_/Y }
C {devices/lab_pin.sym} 68020 -34910 0 1 {name=p67122 lab=_54150_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -34910 0 0 {name=X_54150_ }
C {devices/lab_pin.sym} 67900 -34770 0 0 {name=p67123 lab=clkbuf_6_9_0_CLK/A }
C {devices/lab_pin.sym} 67980 -34770 0 1 {name=p67124 lab=clkbuf_6_8_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 67940 -34770 0 0 {name=Xclkbuf_6_8_0_CLK }
C {devices/lab_pin.sym} 67860 -34670 0 0 {name=p67125 lab=_66020_/X }
C {devices/lab_pin.sym} 67860 -34630 0 0 {name=p67126 lab=_66134_/Y }
C {devices/lab_pin.sym} 67860 -34590 0 0 {name=p67127 lab=_66135_/Y }
C {devices/lab_pin.sym} 68020 -34630 0 1 {name=p67128 lab=_66136_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -34630 0 0 {name=X_66136_ }
C {devices/lab_pin.sym} 67900 -34490 0 0 {name=p67129 lab=_51259_/A }
C {devices/lab_pin.sym} 67980 -34490 0 1 {name=p67130 lab=_51362_/X }
C {sky130_stdcells/buf_2.sym} 67940 -34490 0 0 {name=X_51362_ }
C {devices/lab_pin.sym} 67880 -34380 0 0 {name=p67131 lab=_63348_/A }
C {devices/lab_pin.sym} 67880 -34340 0 0 {name=p67132 lab=_63250_/X }
C {devices/lab_pin.sym} 68000 -34360 0 1 {name=p67133 lab=_63348_/Y }
C {sky130_stdcells/nor2_4.sym} 67940 -34360 0 0 {name=X_63348_ }
C {devices/lab_pin.sym} 67850 -34230 0 0 {name=p67134 lab=_86655_/CLK }
C {devices/lab_pin.sym} 67850 -34210 0 0 {name=p67135 lab=_82182_/D }
C {devices/lab_pin.sym} 68030 -34230 0 1 {name=p67136 lab=_82374_/D }
C {sky130_stdcells/dfxtp_4.sym} 67940 -34220 0 0 {name=X_82182_ }
C {devices/lab_pin.sym} 67880 -34100 0 0 {name=p67137 lab=_53115_/A }
C {devices/lab_pin.sym} 67880 -34060 0 0 {name=p67138 lab=_53101_/B }
C {devices/lab_pin.sym} 68000 -34080 0 1 {name=p67139 lab=_53101_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -34080 0 0 {name=X_53101_ }
C {devices/lab_pin.sym} 67900 -33950 0 0 {name=p67140 lab=_50491_/A }
C {devices/lab_pin.sym} 67980 -33950 0 1 {name=p67141 lab=_50313_/X }
C {sky130_stdcells/buf_2.sym} 67940 -33950 0 0 {name=X_50313_ }
C {devices/lab_pin.sym} 67850 -33830 0 0 {name=p67142 lab=_81130_/CLK }
C {devices/lab_pin.sym} 67850 -33810 0 0 {name=p67143 lab=_80757_/Q }
C {devices/lab_pin.sym} 68030 -33830 0 1 {name=p67144 lab=_40700_/A }
C {sky130_stdcells/dfxtp_4.sym} 67940 -33820 0 0 {name=X_81133_ }
C {devices/lab_pin.sym} 67880 -33700 0 0 {name=p67145 lab=_54068_/X }
C {devices/lab_pin.sym} 67880 -33660 0 0 {name=p67146 lab=_52563_/B }
C {devices/lab_pin.sym} 68000 -33680 0 1 {name=p67147 lab=_54081_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -33680 0 0 {name=X_54081_ }
C {devices/lab_pin.sym} 67860 -33570 0 0 {name=p67148 lab=_66063_/Y }
C {devices/lab_pin.sym} 67860 -33530 0 0 {name=p67149 lab=_66065_/X }
C {devices/lab_pin.sym} 67860 -33490 0 0 {name=p67150 lab=_66066_/X }
C {devices/lab_pin.sym} 68020 -33530 0 1 {name=p67151 lab=_66067_/X }
C {sky130_stdcells/a21o_4.sym} 67940 -33530 0 0 {name=X_66067_ }
C {devices/lab_pin.sym} 67860 -33410 0 0 {name=p67152 lab=_86038_/Q }
C {devices/lab_pin.sym} 67860 -33370 0 0 {name=p67153 lab=_51285_/X }
C {devices/lab_pin.sym} 67860 -33330 0 0 {name=p67154 lab=_51292_/Y }
C {devices/lab_pin.sym} 68020 -33370 0 1 {name=p67155 lab=_51293_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -33370 0 0 {name=X_51293_ }
C {devices/lab_pin.sym} 67860 -33260 0 0 {name=p67156 lab=_58279_/Y }
C {devices/lab_pin.sym} 67860 -33220 0 0 {name=p67157 lab=_63250_/X }
C {devices/lab_pin.sym} 67860 -33180 0 0 {name=p67158 lab=_59423_/Y }
C {devices/lab_pin.sym} 67860 -33140 0 0 {name=p67159 lab=_60493_/X }
C {devices/lab_pin.sym} 68020 -33200 0 1 {name=p67160 lab=_63279_/X }
C {sky130_stdcells/o22a_4.sym} 67940 -33200 0 0 {name=X_63279_ }
C {devices/lab_pin.sym} 67850 -33050 0 0 {name=p67161 lab=_86989_/CLK }
C {devices/lab_pin.sym} 67850 -33030 0 0 {name=p67162 lab=_86990_/D }
C {devices/lab_pin.sym} 68030 -33050 0 1 {name=p67163 lab=_86990_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -33040 0 0 {name=X_86990_ }
C {devices/lab_pin.sym} 67860 -32930 0 0 {name=p67164 lab=_53026_/Y }
C {devices/lab_pin.sym} 67860 -32890 0 0 {name=p67165 lab=_53028_/X }
C {devices/lab_pin.sym} 67860 -32850 0 0 {name=p67166 lab=_53031_/X }
C {devices/lab_pin.sym} 68020 -32890 0 1 {name=p67167 lab=_53032_/Y }
C {sky130_stdcells/a21oi_4.sym} 67940 -32890 0 0 {name=X_53032_ }
C {devices/lab_pin.sym} 67880 -32770 0 0 {name=p67168 lab=_65014_/X }
C {devices/lab_pin.sym} 67880 -32730 0 0 {name=p67169 lab=_64888_/B }
C {devices/lab_pin.sym} 67880 -32690 0 0 {name=p67170 lab=_65017_/X }
C {devices/lab_pin.sym} 68000 -32730 0 1 {name=p67171 lab=_65018_/Y }
C {sky130_stdcells/nand3_4.sym} 67940 -32730 0 0 {name=X_65018_ }
C {devices/lab_pin.sym} 67900 -32590 0 0 {name=p67172 lab=_53874_/A }
C {devices/lab_pin.sym} 67980 -32590 0 1 {name=p67173 lab=_74509_/C }
C {sky130_stdcells/buf_2.sym} 67940 -32590 0 0 {name=X_50244_ }
C {devices/lab_pin.sym} 67850 -32470 0 0 {name=p67174 lab=_82768_/CLK }
C {devices/lab_pin.sym} 67850 -32450 0 0 {name=p67175 lab=_51816_/Y }
C {devices/lab_pin.sym} 68030 -32470 0 1 {name=p67176 lab=_85941_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -32460 0 0 {name=X_85941_ }
C {devices/lab_pin.sym} 67850 -32330 0 0 {name=p67177 lab=_80681_/CLK }
C {devices/lab_pin.sym} 67850 -32310 0 0 {name=p67178 lab=_81096_/Q }
C {devices/lab_pin.sym} 68030 -32330 0 1 {name=p67179 lab=_75157_/B }
C {sky130_stdcells/dfxtp_4.sym} 67940 -32320 0 0 {name=X_81064_ }
C {devices/lab_pin.sym} 67880 -32200 0 0 {name=p67180 lab=_84930_/Q }
C {devices/lab_pin.sym} 67880 -32160 0 0 {name=p67181 lab=_84178_/Q }
C {devices/lab_pin.sym} 68000 -32180 0 1 {name=p67182 lab=_80015_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -32180 0 0 {name=X_80015_ }
C {devices/lab_pin.sym} 67860 -32070 0 0 {name=p67183 lab=_57838_/X }
C {devices/lab_pin.sym} 67860 -32030 0 0 {name=p67184 lab=_86010_/Q }
C {devices/lab_pin.sym} 67860 -31990 0 0 {name=p67185 lab=_57839_/X }
C {devices/lab_pin.sym} 68020 -32030 0 1 {name=p67186 lab=_57840_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -32030 0 0 {name=X_57840_ }
C {devices/lab_pin.sym} 67880 -31900 0 0 {name=p67187 lab=_69865_/A }
C {devices/lab_pin.sym} 67880 -31860 0 0 {name=p67188 lab=_69826_/B }
C {devices/lab_pin.sym} 68000 -31880 0 1 {name=p67189 lab=_69826_/X }
C {sky130_stdcells/and2_4.sym} 67940 -31880 0 0 {name=X_69826_ }
C {devices/lab_pin.sym} 67880 -31760 0 0 {name=p67190 lab=_50131_/A }
C {devices/lab_pin.sym} 67880 -31720 0 0 {name=p67191 lab=_72079_/B }
C {devices/lab_pin.sym} 68000 -31740 0 1 {name=p67192 lab=_50175_/X }
C {sky130_stdcells/and2_4.sym} 67940 -31740 0 0 {name=X_50175_ }
C {devices/lab_pin.sym} 67850 -31610 0 0 {name=p67193 lab=_83562_/CLK }
C {devices/lab_pin.sym} 67850 -31590 0 0 {name=p67194 lab=_85872_/D }
C {devices/lab_pin.sym} 68030 -31610 0 1 {name=p67195 lab=_85872_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -31600 0 0 {name=X_85872_ }
C {devices/lab_pin.sym} 67850 -31470 0 0 {name=p67196 lab=_82888_/CLK }
C {devices/lab_pin.sym} 67850 -31450 0 0 {name=p67197 lab=_43001_/Y }
C {devices/lab_pin.sym} 68030 -31470 0 1 {name=p67198 lab=_67142_/B }
C {sky130_stdcells/dfxtp_4.sym} 67940 -31460 0 0 {name=X_87611_ }
C {devices/lab_pin.sym} 67850 -31330 0 0 {name=p67199 lab=_84823_/CLK }
C {devices/lab_pin.sym} 67850 -31310 0 0 {name=p67200 lab=_58545_/X }
C {devices/lab_pin.sym} 68030 -31330 0 1 {name=p67201 lab=_58543_/A }
C {sky130_stdcells/dfxtp_4.sym} 67940 -31320 0 0 {name=X_84823_ }
C {devices/lab_pin.sym} 67900 -31190 0 0 {name=p67202 lab=_58796_/A }
C {devices/lab_pin.sym} 67980 -31190 0 1 {name=p67203 lab=_72476_/B }
C {sky130_stdcells/buf_2.sym} 67940 -31190 0 0 {name=X_57771_ }
C {devices/lab_pin.sym} 67860 -31100 0 0 {name=p67204 lab=_87057_/Q }
C {devices/lab_pin.sym} 67860 -31060 0 0 {name=p67205 lab=_69664_/X }
C {devices/lab_pin.sym} 67860 -31020 0 0 {name=p67206 lab=_69665_/X }
C {devices/lab_pin.sym} 67860 -30980 0 0 {name=p67207 lab=_69756_/X }
C {devices/lab_pin.sym} 68020 -31040 0 1 {name=p67208 lab=_69758_/B }
C {sky130_stdcells/a211o_4.sym} 67940 -31040 0 0 {name=X_69757_ }
C {devices/lab_pin.sym} 67880 -30920 0 0 {name=p67209 lab=_54964_/A }
C {devices/lab_pin.sym} 67880 -30880 0 0 {name=p67210 lab=_54978_/X }
C {devices/lab_pin.sym} 67880 -30840 0 0 {name=p67211 lab=_54974_/C }
C {devices/lab_pin.sym} 67880 -30800 0 0 {name=p67212 lab=_47567_/A }
C {devices/lab_pin.sym} 68000 -30860 0 1 {name=p67213 lab=_54983_/X }
C {sky130_stdcells/and4_4.sym} 67940 -30860 0 0 {name=X_54983_ }
C {devices/lab_pin.sym} 67860 -30740 0 0 {name=p67214 lab=_66947_/X }
C {devices/lab_pin.sym} 67860 -30700 0 0 {name=p67215 lab=_66958_/Y }
C {devices/lab_pin.sym} 67860 -30660 0 0 {name=p67216 lab=_66910_/X }
C {devices/lab_pin.sym} 67860 -30620 0 0 {name=p67217 lab=_66968_/Y }
C {devices/lab_pin.sym} 68020 -30680 0 1 {name=p67218 lab=_66969_/X }
C {sky130_stdcells/a211o_4.sym} 67940 -30680 0 0 {name=X_66969_ }
C {devices/lab_pin.sym} 67900 -30530 0 0 {name=p67219 lab=_57754_/X }
C {devices/lab_pin.sym} 67980 -30530 0 1 {name=p67220 lab=_69814_/A }
C {sky130_stdcells/buf_2.sym} 67940 -30530 0 0 {name=X_59510_ }
C {devices/lab_pin.sym} 67880 -30420 0 0 {name=p67221 lab=_56684_/C }
C {devices/lab_pin.sym} 67880 -30380 0 0 {name=p67222 lab=_56721_/Y }
C {devices/lab_pin.sym} 68000 -30400 0 1 {name=p67223 lab=_56723_/B }
C {sky130_stdcells/xor2_4.sym} 67940 -30400 0 0 {name=X_56722_ }
C {devices/lab_pin.sym} 67880 -30280 0 0 {name=p67224 lab=_68735_/A }
C {devices/lab_pin.sym} 67880 -30240 0 0 {name=p67225 lab=_68708_/B }
C {devices/lab_pin.sym} 68000 -30260 0 1 {name=p67226 lab=_68708_/X }
C {sky130_stdcells/and2_4.sym} 67940 -30260 0 0 {name=X_68708_ }
C {devices/lab_pin.sym} 67850 -30130 0 0 {name=p67227 lab=_87542_/CLK }
C {devices/lab_pin.sym} 67850 -30110 0 0 {name=p67228 lab=_87542_/D }
C {devices/lab_pin.sym} 68030 -30130 0 1 {name=p67229 lab=_43199_/A }
C {sky130_stdcells/dfxtp_4.sym} 67940 -30120 0 0 {name=X_87542_ }
C {devices/lab_pin.sym} 67880 -30000 0 0 {name=p67230 lab=_53949_/A }
C {devices/lab_pin.sym} 67880 -29960 0 0 {name=p67231 lab=_50719_/B }
C {devices/lab_pin.sym} 68000 -29980 0 1 {name=p67232 lab=_53934_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -29980 0 0 {name=X_53934_ }
C {devices/lab_pin.sym} 67850 -29850 0 0 {name=p67233 lab=_84757_/CLK }
C {devices/lab_pin.sym} 67850 -29830 0 0 {name=p67234 lab=_84754_/D }
C {devices/lab_pin.sym} 68030 -29850 0 1 {name=p67235 lab=_84754_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -29840 0 0 {name=X_84754_ }
C {devices/lab_pin.sym} 67850 -29710 0 0 {name=p67236 lab=_82299_/CLK }
C {devices/lab_pin.sym} 67850 -29690 0 0 {name=p67237 lab=_81966_/D }
C {devices/lab_pin.sym} 68030 -29710 0 1 {name=p67238 lab=_81966_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -29700 0 0 {name=X_81966_ }
C {devices/lab_pin.sym} 67860 -29600 0 0 {name=p67239 lab=_88074_/Q }
C {devices/lab_pin.sym} 67860 -29560 0 0 {name=p67240 lab=_69607_/X }
C {devices/lab_pin.sym} 67860 -29520 0 0 {name=p67241 lab=_68617_/X }
C {devices/lab_pin.sym} 67860 -29480 0 0 {name=p67242 lab=_69687_/Y }
C {devices/lab_pin.sym} 68020 -29540 0 1 {name=p67243 lab=_69688_/X }
C {sky130_stdcells/a211o_4.sym} 67940 -29540 0 0 {name=X_69688_ }
C {devices/lab_pin.sym} 67860 -29410 0 0 {name=p67244 lab=_59417_/X }
C {devices/lab_pin.sym} 67860 -29370 0 0 {name=p67245 lab=_83340_/Q }
C {devices/lab_pin.sym} 67860 -29330 0 0 {name=p67246 lab=_59440_/Y }
C {devices/lab_pin.sym} 68020 -29370 0 1 {name=p67247 lab=_59441_/X }
C {sky130_stdcells/o21a_4.sym} 67940 -29370 0 0 {name=X_59441_ }
C {devices/lab_pin.sym} 67850 -29230 0 0 {name=p67248 lab=_85428_/CLK }
C {devices/lab_pin.sym} 67850 -29210 0 0 {name=p67249 lab=_70767_/Y }
C {devices/lab_pin.sym} 68030 -29230 0 1 {name=p67250 lab=_47069_/A }
C {sky130_stdcells/dfxtp_4.sym} 67940 -29220 0 0 {name=X_83705_ }
C {devices/lab_pin.sym} 67880 -29100 0 0 {name=p67251 lab=_56808_/A }
C {devices/lab_pin.sym} 67880 -29060 0 0 {name=p67252 lab=_83322_/Q }
C {devices/lab_pin.sym} 68000 -29080 0 1 {name=p67253 lab=_56653_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -29080 0 0 {name=X_56653_ }
C {devices/lab_pin.sym} 67850 -28950 0 0 {name=p67254 lab=_81507_/CLK }
C {devices/lab_pin.sym} 67850 -28930 0 0 {name=p67255 lab=_80917_/D }
C {devices/lab_pin.sym} 68030 -28950 0 1 {name=p67256 lab=_80917_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -28940 0 0 {name=X_80917_ }
C {devices/lab_pin.sym} 67860 -28840 0 0 {name=p67257 lab=_43057_/A }
C {devices/lab_pin.sym} 67860 -28800 0 0 {name=p67258 lab=_68636_/X }
C {devices/lab_pin.sym} 67860 -28760 0 0 {name=p67259 lab=_68517_/X }
C {devices/lab_pin.sym} 67860 -28720 0 0 {name=p67260 lab=_68638_/X }
C {devices/lab_pin.sym} 68020 -28780 0 1 {name=p67261 lab=_68639_/X }
C {sky130_stdcells/a211o_4.sym} 67940 -28780 0 0 {name=X_68639_ }
C {devices/lab_pin.sym} 67850 -28630 0 0 {name=p67262 lab=_87473_/CLK }
C {devices/lab_pin.sym} 67850 -28610 0 0 {name=p67263 lab=_87473_/D }
C {devices/lab_pin.sym} 68030 -28630 0 1 {name=p67264 lab=_87473_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -28620 0 0 {name=X_87473_ }
C {devices/lab_pin.sym} 67880 -28500 0 0 {name=p67265 lab=_53786_/A }
C {devices/lab_pin.sym} 67880 -28460 0 0 {name=p67266 lab=_49055_/A }
C {devices/lab_pin.sym} 68000 -28480 0 1 {name=p67267 lab=_53865_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -28480 0 0 {name=X_53865_ }
C {devices/lab_pin.sym} 67850 -28350 0 0 {name=p67268 lab=_84713_/CLK }
C {devices/lab_pin.sym} 67850 -28330 0 0 {name=p67269 lab=_59865_/Y }
C {devices/lab_pin.sym} 68030 -28350 0 1 {name=p67270 lab=_80308_/B }
C {sky130_stdcells/dfxtp_4.sym} 67940 -28340 0 0 {name=X_84685_ }
C {devices/lab_pin.sym} 67850 -28210 0 0 {name=p67271 lab=_82047_/CLK }
C {devices/lab_pin.sym} 67850 -28190 0 0 {name=p67272 lab=_77337_/X }
C {devices/lab_pin.sym} 68030 -28210 0 1 {name=p67273 lab=_82305_/D }
C {sky130_stdcells/dfxtp_4.sym} 67940 -28200 0 0 {name=X_81897_ }
C {devices/lab_pin.sym} 67900 -28070 0 0 {name=p67274 lab=_55603_/X }
C {devices/lab_pin.sym} 67980 -28070 0 1 {name=p67275 lab=_56564_/A }
C {sky130_stdcells/buf_2.sym} 67940 -28070 0 0 {name=X_55604_ }
C {devices/lab_pin.sym} 67850 -27950 0 0 {name=p67276 lab=_86424_/CLK }
C {devices/lab_pin.sym} 67850 -27930 0 0 {name=p67277 lab=_49254_/Y }
C {devices/lab_pin.sym} 68030 -27950 0 1 {name=p67278 lab=_86424_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -27940 0 0 {name=X_86424_ }
C {devices/lab_pin.sym} 67900 -27810 0 0 {name=p67279 lab=_53221_/A }
C {devices/lab_pin.sym} 67980 -27810 0 1 {name=p67280 lab=_52845_/A }
C {sky130_stdcells/buf_2.sym} 67940 -27810 0 0 {name=X_52816_ }
C {devices/lab_pin.sym} 67860 -27710 0 0 {name=p67281 lab=_40324_/X }
C {devices/lab_pin.sym} 67860 -27670 0 0 {name=p67282 lab=_82868_/Q }
C {devices/lab_pin.sym} 67860 -27630 0 0 {name=p67283 lab=_40829_/X }
C {devices/lab_pin.sym} 68020 -27670 0 1 {name=p67284 lab=_40831_/A }
C {sky130_stdcells/o21a_4.sym} 67940 -27670 0 0 {name=X_40830_ }
C {devices/lab_pin.sym} 67880 -27550 0 0 {name=p67285 lab=_71650_/A }
C {devices/lab_pin.sym} 67880 -27510 0 0 {name=p67286 lab=_71217_/B }
C {devices/lab_pin.sym} 67880 -27470 0 0 {name=p67287 lab=_71644_/C }
C {devices/lab_pin.sym} 68000 -27510 0 1 {name=p67288 lab=_71650_/Y }
C {sky130_stdcells/nand3_4.sym} 67940 -27510 0 0 {name=X_71650_ }
C {devices/lab_pin.sym} 67850 -27370 0 0 {name=p67289 lab=_86424_/CLK }
C {devices/lab_pin.sym} 67850 -27350 0 0 {name=p67290 lab=_83636_/D }
C {devices/lab_pin.sym} 68030 -27370 0 1 {name=p67291 lab=_83636_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -27360 0 0 {name=X_83636_ }
C {devices/lab_pin.sym} 67880 -27240 0 0 {name=p67292 lab=_59238_/X }
C {devices/lab_pin.sym} 67880 -27200 0 0 {name=p67293 lab=_59372_/B }
C {devices/lab_pin.sym} 68000 -27220 0 1 {name=p67294 lab=_59372_/Y }
C {sky130_stdcells/nor2_4.sym} 67940 -27220 0 0 {name=X_59372_ }
C {devices/lab_pin.sym} 67900 -27090 0 0 {name=p67295 lab=_56583_/X }
C {devices/lab_pin.sym} 67980 -27090 0 1 {name=p67296 lab=_56584_/X }
C {sky130_stdcells/buf_2.sym} 67940 -27090 0 0 {name=X_56584_ }
C {devices/lab_pin.sym} 67850 -26970 0 0 {name=p67297 lab=_80849_/CLK }
C {devices/lab_pin.sym} 67850 -26950 0 0 {name=p67298 lab=_80880_/Q }
C {devices/lab_pin.sym} 68030 -26970 0 1 {name=p67299 lab=_74960_/C }
C {sky130_stdcells/dfxtp_4.sym} 67940 -26960 0 0 {name=X_80848_ }
C {devices/lab_pin.sym} 67880 -26840 0 0 {name=p67300 lab=_53791_/A }
C {devices/lab_pin.sym} 67880 -26800 0 0 {name=p67301 lab=_71972_/B }
C {devices/lab_pin.sym} 68000 -26820 0 1 {name=p67302 lab=_53796_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -26820 0 0 {name=X_53796_ }
C {devices/lab_pin.sym} 67900 -26690 0 0 {name=p67303 lab=DATA_TO_HASH[5] }
C {devices/lab_pin.sym} 67980 -26690 0 1 {name=p67304 lab=_70771_/A }
C {sky130_stdcells/buf_2.sym} 67940 -26690 0 0 {name=X_70601_ }
C {devices/lab_pin.sym} 67880 -26580 0 0 {name=p67305 lab=_58322_/Y }
C {devices/lab_pin.sym} 67880 -26540 0 0 {name=p67306 lab=_58326_/B }
C {devices/lab_pin.sym} 68000 -26560 0 1 {name=p67307 lab=_58323_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -26560 0 0 {name=X_58323_ }
C {devices/lab_pin.sym} 67860 -26460 0 0 {name=p67308 lab=_45558_/A }
C {devices/lab_pin.sym} 67860 -26420 0 0 {name=p67309 lab=_55531_/X }
C {devices/lab_pin.sym} 67860 -26380 0 0 {name=p67310 lab=_55533_/X }
C {devices/lab_pin.sym} 67860 -26340 0 0 {name=p67311 lab=_55534_/X }
C {devices/lab_pin.sym} 68020 -26400 0 1 {name=p67312 lab=_55536_/D }
C {sky130_stdcells/a211o_4.sym} 67940 -26400 0 0 {name=X_55535_ }
C {devices/lab_pin.sym} 67850 -26250 0 0 {name=p67313 lab=_85428_/CLK }
C {devices/lab_pin.sym} 67850 -26230 0 0 {name=p67314 lab=_49616_/Y }
C {devices/lab_pin.sym} 68030 -26250 0 1 {name=p67315 lab=_86355_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -26240 0 0 {name=X_86355_ }
C {devices/lab_pin.sym} 67900 -26110 0 0 {name=p67316 lab=clkbuf_2_0_1_CLK/A }
C {devices/lab_pin.sym} 67980 -26110 0 1 {name=p67317 lab=clkbuf_2_0_2_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 67940 -26110 0 0 {name=Xclkbuf_2_0_1_CLK }
C {devices/lab_pin.sym} 67860 -26010 0 0 {name=p67318 lab=_40698_/X }
C {devices/lab_pin.sym} 67860 -25970 0 0 {name=p67319 lab=_40927_/A }
C {devices/lab_pin.sym} 67860 -25930 0 0 {name=p67320 lab=_40760_/X }
C {devices/lab_pin.sym} 68020 -25970 0 1 {name=p67321 lab=_40762_/A }
C {sky130_stdcells/o21a_4.sym} 67940 -25970 0 0 {name=X_40761_ }
C {devices/lab_pin.sym} 67860 -25850 0 0 {name=p67322 lab=_52745_/Y }
C {devices/lab_pin.sym} 67860 -25810 0 0 {name=p67323 lab=_52728_/X }
C {devices/lab_pin.sym} 67860 -25770 0 0 {name=p67324 lab=_52746_/X }
C {devices/lab_pin.sym} 68020 -25810 0 1 {name=p67325 lab=_52747_/Y }
C {sky130_stdcells/a21oi_4.sym} 67940 -25810 0 0 {name=X_52747_ }
C {devices/lab_pin.sym} 67900 -25670 0 0 {name=p67326 lab=_71581_/A }
C {devices/lab_pin.sym} 67980 -25670 0 1 {name=p67327 lab=_71581_/X }
C {sky130_stdcells/buf_2.sym} 67940 -25670 0 0 {name=X_71581_ }
C {devices/lab_pin.sym} 67850 -25550 0 0 {name=p67328 lab=_86500_/CLK }
C {devices/lab_pin.sym} 67850 -25530 0 0 {name=p67329 lab=_71224_/Y }
C {devices/lab_pin.sym} 68030 -25550 0 1 {name=p67330 lab=_83567_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -25540 0 0 {name=X_83567_ }
C {devices/lab_pin.sym} 67850 -25410 0 0 {name=p67331 lab=_80754_/CLK }
C {devices/lab_pin.sym} 67850 -25390 0 0 {name=p67332 lab=_75661_/Y }
C {devices/lab_pin.sym} 68030 -25410 0 1 {name=p67333 lab=_80779_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -25400 0 0 {name=X_80779_ }
C {devices/lab_pin.sym} 67860 -25310 0 0 {name=p67334 lab=_42486_/X }
C {devices/lab_pin.sym} 67860 -25270 0 0 {name=p67335 lab=_42472_/X }
C {devices/lab_pin.sym} 67860 -25230 0 0 {name=p67336 lab=_40673_/X }
C {devices/lab_pin.sym} 67860 -25190 0 0 {name=p67337 lab=_68746_/B }
C {devices/lab_pin.sym} 67860 -25150 0 0 {name=p67338 lab=_42489_/X }
C {devices/lab_pin.sym} 68020 -25230 0 1 {name=p67339 lab=_87844_/D }
C {sky130_stdcells/o32ai_4.sym} 67940 -25230 0 0 {name=X_42500_ }
C {devices/lab_pin.sym} 67880 -25080 0 0 {name=p67340 lab=_73320_/A }
C {devices/lab_pin.sym} 67880 -25040 0 0 {name=p67341 lab=_73438_/B }
C {devices/lab_pin.sym} 68000 -25060 0 1 {name=p67342 lab=_73320_/Y }
C {sky130_stdcells/nor2_4.sym} 67940 -25060 0 0 {name=X_73320_ }
C {devices/lab_pin.sym} 67850 -24930 0 0 {name=p67343 lab=_85180_/CLK }
C {devices/lab_pin.sym} 67850 -24910 0 0 {name=p67344 lab=_56042_/Y }
C {devices/lab_pin.sym} 68030 -24930 0 1 {name=p67345 lab=_56041_/C }
C {sky130_stdcells/dfxtp_4.sym} 67940 -24920 0 0 {name=X_85306_ }
C {devices/lab_pin.sym} 67900 -24790 0 0 {name=p67346 lab=_70531_/Y }
C {devices/lab_pin.sym} 67980 -24790 0 1 {name=p67347 lab=_70532_/Y }
C {sky130_stdcells/inv_2.sym} 67940 -24790 0 0 {name=X_70532_ }
C {devices/lab_pin.sym} 67900 -24670 0 0 {name=p67348 lab=_58254_/A }
C {devices/lab_pin.sym} 67980 -24670 0 1 {name=p67349 lab=_58254_/Y }
C {sky130_stdcells/inv_2.sym} 67940 -24670 0 0 {name=X_58254_ }
C {devices/lab_pin.sym} 67850 -24550 0 0 {name=p67350 lab=_82518_/CLK }
C {devices/lab_pin.sym} 67850 -24530 0 0 {name=p67351 lab=_79117_/Y }
C {devices/lab_pin.sym} 68030 -24550 0 1 {name=p67352 lab=_82518_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -24540 0 0 {name=X_82518_ }
C {devices/lab_pin.sym} 67880 -24420 0 0 {name=p67353 lab=_55461_/X }
C {devices/lab_pin.sym} 67880 -24380 0 0 {name=p67354 lab=_55465_/X }
C {devices/lab_pin.sym} 68000 -24400 0 1 {name=p67355 lab=_55466_/X }
C {sky130_stdcells/and2_4.sym} 67940 -24400 0 0 {name=X_55466_ }
C {devices/lab_pin.sym} 67860 -24310 0 0 {name=p67356 lab=_43472_/X }
C {devices/lab_pin.sym} 67860 -24270 0 0 {name=p67357 lab=_43475_/X }
C {devices/lab_pin.sym} 67860 -24230 0 0 {name=p67358 lab=_41688_/X }
C {devices/lab_pin.sym} 67860 -24190 0 0 {name=p67359 lab=_87401_/Q }
C {devices/lab_pin.sym} 67860 -24150 0 0 {name=p67360 lab=_43479_/X }
C {devices/lab_pin.sym} 68020 -24230 0 1 {name=p67361 lab=_43480_/Y }
C {sky130_stdcells/o32ai_4.sym} 67940 -24230 0 0 {name=X_43480_ }
C {devices/lab_pin.sym} 67850 -24070 0 0 {name=p67362 lab=_86610_/CLK }
C {devices/lab_pin.sym} 67850 -24050 0 0 {name=p67363 lab=_86286_/D }
C {devices/lab_pin.sym} 68030 -24070 0 1 {name=p67364 lab=_72347_/B }
C {sky130_stdcells/dfxtp_4.sym} 67940 -24060 0 0 {name=X_86286_ }
C {devices/lab_pin.sym} 67860 -23950 0 0 {name=p67365 lab=_85774_/Q }
C {devices/lab_pin.sym} 67860 -23910 0 0 {name=p67366 lab=_52656_/X }
C {devices/lab_pin.sym} 67860 -23870 0 0 {name=p67367 lab=_52677_/Y }
C {devices/lab_pin.sym} 68020 -23910 0 1 {name=p67368 lab=_52678_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -23910 0 0 {name=X_52678_ }
C {devices/lab_pin.sym} 67860 -23810 0 0 {name=p67369 lab=_40687_/X }
C {devices/lab_pin.sym} 67860 -23770 0 0 {name=p67370 lab=_40688_/X }
C {devices/lab_pin.sym} 67860 -23730 0 0 {name=p67371 lab=_40691_/X }
C {devices/lab_pin.sym} 67860 -23690 0 0 {name=p67372 lab=_88353_/Q }
C {devices/lab_pin.sym} 67860 -23650 0 0 {name=p67373 lab=_40683_/X }
C {devices/lab_pin.sym} 68020 -23730 0 1 {name=p67374 lab=_40692_/Y }
C {sky130_stdcells/o32ai_4.sym} 67940 -23730 0 0 {name=X_40692_ }
C {devices/lab_pin.sym} 67850 -23570 0 0 {name=p67375 lab=_83498_/CLK }
C {devices/lab_pin.sym} 67850 -23550 0 0 {name=p67376 lab=_71440_/X }
C {devices/lab_pin.sym} 68030 -23570 0 1 {name=p67377 lab=_83498_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -23560 0 0 {name=X_83498_ }
C {devices/lab_pin.sym} 67880 -23440 0 0 {name=p67378 lab=_57179_/A }
C {devices/lab_pin.sym} 67880 -23400 0 0 {name=p67379 lab=_85063_/Q }
C {devices/lab_pin.sym} 68000 -23420 0 1 {name=p67380 lab=_57205_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -23420 0 0 {name=X_57205_ }
C {devices/lab_pin.sym} 67850 -23290 0 0 {name=p67381 lab=_87776_/CLK }
C {devices/lab_pin.sym} 67850 -23270 0 0 {name=p67382 lab=_88025_/D }
C {devices/lab_pin.sym} 68030 -23290 0 1 {name=p67383 lab=_88025_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -23280 0 0 {name=X_88025_ }
C {devices/lab_pin.sym} 67880 -23180 0 0 {name=p67384 lab=_54399_/X }
C {devices/lab_pin.sym} 67880 -23140 0 0 {name=p67385 lab=_54417_/B }
C {devices/lab_pin.sym} 67880 -23100 0 0 {name=p67386 lab=_54402_/C }
C {devices/lab_pin.sym} 67880 -23060 0 0 {name=p67387 lab=_54417_/D }
C {devices/lab_pin.sym} 68000 -23120 0 1 {name=p67388 lab=_54417_/X }
C {sky130_stdcells/and4_4.sym} 67940 -23120 0 0 {name=X_54417_ }
C {devices/lab_pin.sym} 67860 -23010 0 0 {name=p67389 lab=_42417_/X }
C {devices/lab_pin.sym} 67860 -22970 0 0 {name=p67390 lab=_42430_/X }
C {devices/lab_pin.sym} 67860 -22930 0 0 {name=p67391 lab=_40515_/X }
C {devices/lab_pin.sym} 67860 -22890 0 0 {name=p67392 lab=_87867_/Q }
C {devices/lab_pin.sym} 67860 -22850 0 0 {name=p67393 lab=_41967_/A }
C {devices/lab_pin.sym} 68020 -22930 0 1 {name=p67394 lab=_42432_/A }
C {sky130_stdcells/o32ai_4.sym} 67940 -22930 0 0 {name=X_42431_ }
C {devices/lab_pin.sym} 67900 -22770 0 0 {name=p67395 lab=_56934_/X }
C {devices/lab_pin.sym} 67980 -22770 0 1 {name=p67396 lab=_73251_/X }
C {sky130_stdcells/buf_2.sym} 67940 -22770 0 0 {name=X_73251_ }
C {devices/lab_pin.sym} 67850 -22650 0 0 {name=p67397 lab=_86900_/CLK }
C {devices/lab_pin.sym} 67850 -22630 0 0 {name=p67398 lab=_85237_/D }
C {devices/lab_pin.sym} 68030 -22650 0 1 {name=p67399 lab=_55874_/B }
C {sky130_stdcells/dfxtp_4.sym} 67940 -22640 0 0 {name=X_85237_ }
C {devices/lab_pin.sym} 67900 -22510 0 0 {name=p67400 lab=_51629_/A }
C {devices/lab_pin.sym} 67980 -22510 0 1 {name=p67401 lab=_51629_/X }
C {sky130_stdcells/buf_2.sym} 67940 -22510 0 0 {name=X_51629_ }
C {devices/lab_pin.sym} 67900 -22390 0 0 {name=p67402 lab=DATA_TO_HASH[7] }
C {devices/lab_pin.sym} 67980 -22390 0 1 {name=p67403 lab=_71672_/C }
C {sky130_stdcells/buf_2.sym} 67940 -22390 0 0 {name=X_70463_ }
C {devices/lab_pin.sym} 67860 -22290 0 0 {name=p67404 lab=_57677_/X }
C {devices/lab_pin.sym} 67860 -22250 0 0 {name=p67405 lab=_58181_/Y }
C {devices/lab_pin.sym} 67860 -22210 0 0 {name=p67406 lab=_58184_/Y }
C {devices/lab_pin.sym} 68020 -22250 0 1 {name=p67407 lab=_58185_/Y }
C {sky130_stdcells/a21oi_4.sym} 67940 -22250 0 0 {name=X_58185_ }
C {devices/lab_pin.sym} 67850 -22110 0 0 {name=p67408 lab=_82452_/CLK }
C {devices/lab_pin.sym} 67850 -22090 0 0 {name=p67409 lab=_79141_/X }
C {devices/lab_pin.sym} 68030 -22110 0 1 {name=p67410 lab=_82449_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -22100 0 0 {name=X_82449_ }
C {devices/lab_pin.sym} 67900 -21970 0 0 {name=p67411 lab=_55164_/X }
C {devices/lab_pin.sym} 67980 -21970 0 1 {name=p67412 lab=_55397_/Y }
C {sky130_stdcells/inv_2.sym} 67940 -21970 0 0 {name=X_55397_ }
C {devices/lab_pin.sym} 67860 -21870 0 0 {name=p67413 lab=_72198_/Y }
C {devices/lab_pin.sym} 67860 -21830 0 0 {name=p67414 lab=_72200_/Y }
C {devices/lab_pin.sym} 67860 -21790 0 0 {name=p67415 lab=_72201_/X }
C {devices/lab_pin.sym} 68020 -21830 0 1 {name=p67416 lab=_72202_/X }
C {sky130_stdcells/a21o_4.sym} 67940 -21830 0 0 {name=X_72202_ }
C {devices/lab_pin.sym} 67860 -21710 0 0 {name=p67417 lab=_55833_/B }
C {devices/lab_pin.sym} 67860 -21670 0 0 {name=p67418 lab=_45134_/X }
C {devices/lab_pin.sym} 67860 -21630 0 0 {name=p67419 lab=_45116_/X }
C {devices/lab_pin.sym} 68020 -21670 0 1 {name=p67420 lab=_45150_/X }
C {sky130_stdcells/o21a_4.sym} 67940 -21670 0 0 {name=X_45150_ }
C {devices/lab_pin.sym} 67860 -21550 0 0 {name=p67421 lab=_57132_/Y }
C {devices/lab_pin.sym} 67860 -21510 0 0 {name=p67422 lab=_57135_/Y }
C {devices/lab_pin.sym} 67860 -21470 0 0 {name=p67423 lab=_46178_/X }
C {devices/lab_pin.sym} 68020 -21510 0 1 {name=p67424 lab=_57136_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -21510 0 0 {name=X_57136_ }
C {devices/lab_pin.sym} 67860 -21400 0 0 {name=p67425 lab=_41745_/X }
C {devices/lab_pin.sym} 67860 -21360 0 0 {name=p67426 lab=_42356_/X }
C {devices/lab_pin.sym} 67860 -21320 0 0 {name=p67427 lab=_87901_/Q }
C {devices/lab_pin.sym} 67860 -21280 0 0 {name=p67428 lab=_42357_/X }
C {devices/lab_pin.sym} 68020 -21340 0 1 {name=p67429 lab=_87901_/D }
C {sky130_stdcells/a2bb2o_4.sym} 67940 -21340 0 0 {name=X_42362_ }
C {devices/lab_pin.sym} 67860 -21210 0 0 {name=p67430 lab=_54342_/Y }
C {devices/lab_pin.sym} 67860 -21170 0 0 {name=p67431 lab=_54338_/X }
C {devices/lab_pin.sym} 67860 -21130 0 0 {name=p67432 lab=_54347_/X }
C {devices/lab_pin.sym} 68020 -21170 0 1 {name=p67433 lab=_54348_/Y }
C {sky130_stdcells/a21oi_4.sym} 67940 -21170 0 0 {name=X_54348_ }
C {devices/lab_pin.sym} 67860 -21060 0 0 {name=p67434 lab=_72988_/X }
C {devices/lab_pin.sym} 67860 -21020 0 0 {name=p67435 lab=_86193_/Q }
C {devices/lab_pin.sym} 67860 -20980 0 0 {name=p67436 lab=_72985_/X }
C {devices/lab_pin.sym} 67860 -20940 0 0 {name=p67437 lab=_73181_/X }
C {devices/lab_pin.sym} 68020 -21000 0 1 {name=p67438 lab=_73182_/X }
C {sky130_stdcells/a211o_4.sym} 67940 -21000 0 0 {name=X_73182_ }
C {devices/lab_pin.sym} 67850 -20850 0 0 {name=p67439 lab=_85168_/CLK }
C {devices/lab_pin.sym} 67850 -20830 0 0 {name=p67440 lab=_85168_/D }
C {devices/lab_pin.sym} 68030 -20850 0 1 {name=p67441 lab=_56510_/C }
C {sky130_stdcells/dfxtp_4.sym} 67940 -20840 0 0 {name=X_85168_ }
C {devices/lab_pin.sym} 67900 -20710 0 0 {name=p67442 lab=_70819_/A }
C {devices/lab_pin.sym} 67980 -20710 0 1 {name=p67443 lab=_70786_/A }
C {sky130_stdcells/buf_2.sym} 67940 -20710 0 0 {name=X_70394_ }
C {devices/lab_pin.sym} 67900 -20590 0 0 {name=p67444 lab=_44101_/A }
C {devices/lab_pin.sym} 67980 -20590 0 1 {name=p67445 lab=_44102_/A }
C {sky130_stdcells/buf_2.sym} 67940 -20590 0 0 {name=X_44101_ }
C {devices/lab_pin.sym} 67860 -20500 0 0 {name=p67446 lab=_41312_/X }
C {devices/lab_pin.sym} 67860 -20460 0 0 {name=p67447 lab=_41307_/X }
C {devices/lab_pin.sym} 67860 -20420 0 0 {name=p67448 lab=_67456_/B }
C {devices/lab_pin.sym} 67860 -20380 0 0 {name=p67449 lab=_41308_/X }
C {devices/lab_pin.sym} 68020 -20440 0 1 {name=p67450 lab=_88238_/D }
C {sky130_stdcells/a2bb2o_4.sym} 67940 -20440 0 0 {name=X_41313_ }
C {devices/lab_pin.sym} 67860 -20310 0 0 {name=p67451 lab=_72123_/X }
C {devices/lab_pin.sym} 67860 -20270 0 0 {name=p67452 lab=_85696_/Q }
C {devices/lab_pin.sym} 67860 -20230 0 0 {name=p67453 lab=_59334_/X }
C {devices/lab_pin.sym} 68020 -20270 0 1 {name=p67454 lab=_72133_/X }
C {sky130_stdcells/o21a_4.sym} 67940 -20270 0 0 {name=X_72133_ }
C {devices/lab_pin.sym} 67850 -20130 0 0 {name=p67455 lab=_84119_/CLK }
C {devices/lab_pin.sym} 67850 -20110 0 0 {name=p67456 lab=_84119_/D }
C {devices/lab_pin.sym} 68030 -20130 0 1 {name=p67457 lab=_82735_/D }
C {sky130_stdcells/dfxtp_4.sym} 67940 -20120 0 0 {name=X_84119_ }
C {devices/lab_pin.sym} 67900 -19990 0 0 {name=p67458 lab=_45081_/A }
C {devices/lab_pin.sym} 67980 -19990 0 1 {name=p67459 lab=_45082_/A }
C {sky130_stdcells/inv_2.sym} 67940 -19990 0 0 {name=X_45081_ }
C {devices/lab_pin.sym} 67860 -19900 0 0 {name=p67460 lab=_56893_/Y }
C {devices/lab_pin.sym} 67860 -19860 0 0 {name=p67461 lab=_57289_/B }
C {devices/lab_pin.sym} 67860 -19820 0 0 {name=p67462 lab=_56866_/A }
C {devices/lab_pin.sym} 67860 -19780 0 0 {name=p67463 lab=_56860_/X }
C {devices/lab_pin.sym} 68020 -19840 0 1 {name=p67464 lab=_57067_/Y }
C {sky130_stdcells/a22oi_4.sym} 67940 -19840 0 0 {name=X_57067_ }
C {devices/lab_pin.sym} 67860 -19720 0 0 {name=p67465 lab=_41560_/X }
C {devices/lab_pin.sym} 67860 -19680 0 0 {name=p67466 lab=_42290_/X }
C {devices/lab_pin.sym} 67860 -19640 0 0 {name=p67467 lab=_87936_/Q }
C {devices/lab_pin.sym} 67860 -19600 0 0 {name=p67468 lab=_42291_/X }
C {devices/lab_pin.sym} 68020 -19660 0 1 {name=p67469 lab=_87936_/D }
C {sky130_stdcells/a2bb2o_4.sym} 67940 -19660 0 0 {name=X_42293_ }
C {devices/lab_pin.sym} 67880 -19540 0 0 {name=p67470 lab=_54286_/A }
C {devices/lab_pin.sym} 67880 -19500 0 0 {name=p67471 lab=_54298_/B }
C {devices/lab_pin.sym} 67880 -19460 0 0 {name=p67472 lab=_54286_/C }
C {devices/lab_pin.sym} 67880 -19420 0 0 {name=p67473 lab=_46638_/A }
C {devices/lab_pin.sym} 68000 -19480 0 1 {name=p67474 lab=_54279_/X }
C {sky130_stdcells/and4_4.sym} 67940 -19480 0 0 {name=X_54279_ }
C {devices/lab_pin.sym} 67860 -19350 0 0 {name=p67475 lab=_77971_/X }
C {devices/lab_pin.sym} 67860 -19310 0 0 {name=p67476 lab=_77977_/A }
C {devices/lab_pin.sym} 67860 -19270 0 0 {name=p67477 lab=_77975_/Y }
C {devices/lab_pin.sym} 68020 -19310 0 1 {name=p67478 lab=_77990_/Y }
C {sky130_stdcells/a21oi_4.sym} 67940 -19310 0 0 {name=X_77990_ }
C {devices/lab_pin.sym} 67850 -19170 0 0 {name=p67479 lab=_85096_/CLK }
C {devices/lab_pin.sym} 67850 -19150 0 0 {name=p67480 lab=_57031_/Y }
C {devices/lab_pin.sym} 68030 -19170 0 1 {name=p67481 lab=_57027_/A }
C {sky130_stdcells/dfxtp_4.sym} 67940 -19160 0 0 {name=X_85099_ }
C {devices/lab_pin.sym} 67900 -19030 0 0 {name=p67482 lab=_58834_/A }
C {devices/lab_pin.sym} 67980 -19030 0 1 {name=p67483 lab=_57811_/A }
C {sky130_stdcells/buf_2.sym} 67940 -19030 0 0 {name=X_44032_ }
C {devices/lab_pin.sym} 67860 -18930 0 0 {name=p67484 lab=_55688_/X }
C {devices/lab_pin.sym} 67860 -18890 0 0 {name=p67485 lab=_56016_/X }
C {devices/lab_pin.sym} 67860 -18850 0 0 {name=p67486 lab=_56017_/Y }
C {devices/lab_pin.sym} 68020 -18890 0 1 {name=p67487 lab=_56018_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -18890 0 0 {name=X_56018_ }
C {devices/lab_pin.sym} 67860 -18770 0 0 {name=p67488 lab=_41242_/X }
C {devices/lab_pin.sym} 67860 -18730 0 0 {name=p67489 lab=_40722_/A }
C {devices/lab_pin.sym} 67860 -18690 0 0 {name=p67490 lab=_41243_/X }
C {devices/lab_pin.sym} 68020 -18730 0 1 {name=p67491 lab=_41244_/X }
C {sky130_stdcells/o21a_4.sym} 67940 -18730 0 0 {name=X_41244_ }
C {devices/lab_pin.sym} 67860 -18610 0 0 {name=p67492 lab=_76939_/X }
C {devices/lab_pin.sym} 67860 -18570 0 0 {name=p67493 lab=_76953_/A }
C {devices/lab_pin.sym} 67860 -18530 0 0 {name=p67494 lab=_76942_/B }
C {devices/lab_pin.sym} 68020 -18570 0 1 {name=p67495 lab=_76941_/Y }
C {sky130_stdcells/a21oi_4.sym} 67940 -18570 0 0 {name=X_76941_ }
C {devices/lab_pin.sym} 67880 -18450 0 0 {name=p67496 lab=_49099_/A }
C {devices/lab_pin.sym} 67880 -18410 0 0 {name=p67497 lab=_72043_/X }
C {devices/lab_pin.sym} 67880 -18370 0 0 {name=p67498 lab=_72048_/X }
C {devices/lab_pin.sym} 68000 -18410 0 1 {name=p67499 lab=_72064_/X }
C {sky130_stdcells/and3_4.sym} 67940 -18410 0 0 {name=X_72064_ }
C {devices/lab_pin.sym} 67900 -18270 0 0 {name=p67500 lab=_71263_/D }
C {devices/lab_pin.sym} 67980 -18270 0 1 {name=p67501 lab=_71016_/A }
C {sky130_stdcells/buf_2.sym} 67940 -18270 0 0 {name=X_71015_ }
C {devices/lab_pin.sym} 67900 -18150 0 0 {name=p67502 lab=_48840_/A }
C {devices/lab_pin.sym} 67980 -18150 0 1 {name=p67503 lab=_48840_/X }
C {sky130_stdcells/buf_2.sym} 67940 -18150 0 0 {name=X_48840_ }
C {devices/lab_pin.sym} 67880 -18040 0 0 {name=p67504 lab=_79660_/A }
C {devices/lab_pin.sym} 67880 -18000 0 0 {name=p67505 lab=_79659_/Y }
C {devices/lab_pin.sym} 68000 -18020 0 1 {name=p67506 lab=_79660_/X }
C {sky130_stdcells/xor2_4.sym} 67940 -18020 0 0 {name=X_79660_ }
C {devices/lab_pin.sym} 67860 -17930 0 0 {name=p67507 lab=_41112_/X }
C {devices/lab_pin.sym} 67860 -17890 0 0 {name=p67508 lab=_41113_/X }
C {devices/lab_pin.sym} 67860 -17850 0 0 {name=p67509 lab=_41174_/X }
C {devices/lab_pin.sym} 67860 -17810 0 0 {name=p67510 lab=_68686_/B }
C {devices/lab_pin.sym} 67860 -17770 0 0 {name=p67511 lab=_41088_/X }
C {devices/lab_pin.sym} 68020 -17850 0 1 {name=p67512 lab=_41176_/A }
C {sky130_stdcells/o32ai_4.sym} 67940 -17850 0 0 {name=X_41175_ }
C {devices/lab_pin.sym} 67880 -17700 0 0 {name=p67513 lab=_76872_/A }
C {devices/lab_pin.sym} 67880 -17660 0 0 {name=p67514 lab=_81466_/D }
C {devices/lab_pin.sym} 68000 -17680 0 1 {name=p67515 lab=_81562_/D }
C {sky130_stdcells/xor2_4.sym} 67940 -17680 0 0 {name=X_76872_ }
C {devices/lab_pin.sym} 67880 -17560 0 0 {name=p67516 lab=_78611_/A }
C {devices/lab_pin.sym} 67880 -17520 0 0 {name=p67517 lab=_82679_/D }
C {devices/lab_pin.sym} 68000 -17540 0 1 {name=p67518 lab=_78616_/A }
C {sky130_stdcells/nor2_4.sym} 67940 -17540 0 0 {name=X_78611_ }
C {devices/lab_pin.sym} 67880 -17430 0 0 {name=p67519 lab=_75811_/A }
C {devices/lab_pin.sym} 67880 -17390 0 0 {name=p67520 lab=_75815_/Y }
C {devices/lab_pin.sym} 67880 -17350 0 0 {name=p67521 lab=_75823_/C }
C {devices/lab_pin.sym} 68000 -17390 0 1 {name=p67522 lab=_75824_/B }
C {sky130_stdcells/nand3_4.sym} 67940 -17390 0 0 {name=X_75823_ }
C {devices/lab_pin.sym} 67850 -17250 0 0 {name=p67523 lab=_87553_/CLK }
C {devices/lab_pin.sym} 67850 -17230 0 0 {name=p67524 lab=_87809_/D }
C {devices/lab_pin.sym} 68030 -17250 0 1 {name=p67525 lab=_69804_/A }
C {sky130_stdcells/dfxtp_4.sym} 67940 -17240 0 0 {name=X_87809_ }
C {devices/lab_pin.sym} 67880 -17130 0 0 {name=p67526 lab=_52156_/A }
C {devices/lab_pin.sym} 67880 -17090 0 0 {name=p67527 lab=_48770_/X }
C {devices/lab_pin.sym} 67880 -17050 0 0 {name=p67528 lab=_48786_/C }
C {devices/lab_pin.sym} 68000 -17090 0 1 {name=p67529 lab=_48771_/X }
C {sky130_stdcells/and3_4.sym} 67940 -17090 0 0 {name=X_48771_ }
C {devices/lab_pin.sym} 67860 -16970 0 0 {name=p67530 lab=_79569_/Y }
C {devices/lab_pin.sym} 67860 -16930 0 0 {name=p67531 lab=_79573_/B }
C {devices/lab_pin.sym} 67860 -16890 0 0 {name=p67532 lab=_79590_/Y }
C {devices/lab_pin.sym} 68020 -16930 0 1 {name=p67533 lab=_79591_/Y }
C {sky130_stdcells/a21oi_4.sym} 67940 -16930 0 0 {name=X_79591_ }
C {devices/lab_pin.sym} 67860 -16830 0 0 {name=p67534 lab=_45980_/X }
C {devices/lab_pin.sym} 67860 -16790 0 0 {name=p67535 lab=_44865_/X }
C {devices/lab_pin.sym} 67860 -16750 0 0 {name=p67536 lab=_40425_/X }
C {devices/lab_pin.sym} 67860 -16710 0 0 {name=p67537 lab=_66810_/B }
C {devices/lab_pin.sym} 67860 -16670 0 0 {name=p67538 lab=_45982_/X }
C {devices/lab_pin.sym} 68020 -16750 0 1 {name=p67539 lab=_45984_/A }
C {sky130_stdcells/o32ai_4.sym} 67940 -16750 0 0 {name=X_45983_ }
C {devices/lab_pin.sym} 67860 -16610 0 0 {name=p67540 lab=_57964_/Y }
C {devices/lab_pin.sym} 67860 -16570 0 0 {name=p67541 lab=_57968_/Y }
C {devices/lab_pin.sym} 67860 -16530 0 0 {name=p67542 lab=_57909_/X }
C {devices/lab_pin.sym} 68020 -16570 0 1 {name=p67543 lab=_57969_/X }
C {sky130_stdcells/a21o_4.sym} 67940 -16570 0 0 {name=X_57969_ }
C {devices/lab_pin.sym} 67900 -16430 0 0 {name=p67544 lab=_47722_/A }
C {devices/lab_pin.sym} 67980 -16430 0 1 {name=p67545 lab=_53207_/D }
C {sky130_stdcells/buf_2.sym} 67940 -16430 0 0 {name=X_47722_ }
C {devices/lab_pin.sym} 67900 -16310 0 0 {name=p67546 lab=_59544_/A }
C {devices/lab_pin.sym} 67980 -16310 0 1 {name=p67547 lab=_59741_/A }
C {sky130_stdcells/buf_2.sym} 67940 -16310 0 0 {name=X_59708_ }
C {devices/lab_pin.sym} 67860 -16210 0 0 {name=p67548 lab=_78540_/X }
C {devices/lab_pin.sym} 67860 -16170 0 0 {name=p67549 lab=_78510_/Y }
C {devices/lab_pin.sym} 67860 -16130 0 0 {name=p67550 lab=_78541_/Y }
C {devices/lab_pin.sym} 68020 -16170 0 1 {name=p67551 lab=_78542_/X }
C {sky130_stdcells/a21o_4.sym} 67940 -16170 0 0 {name=X_78542_ }
C {devices/lab_pin.sym} 67900 -16030 0 0 {name=p67552 lab=_80670_/Q }
C {devices/lab_pin.sym} 67980 -16030 0 1 {name=p67553 lab=_45705_/A }
C {sky130_stdcells/buf_2.sym} 67940 -16030 0 0 {name=X_44934_ }
C {devices/lab_pin.sym} 67900 -15910 0 0 {name=p67554 lab=_75743_/Y }
C {devices/lab_pin.sym} 67980 -15910 0 1 {name=p67555 lab=_75754_/Y }
C {sky130_stdcells/inv_2.sym} 67940 -15910 0 0 {name=X_75754_ }
C {devices/lab_pin.sym} 67900 -15790 0 0 {name=p67556 lab=clkbuf_9_20_0_CLK/X }
C {devices/lab_pin.sym} 67980 -15790 0 1 {name=p67557 lab=_82998_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67940 -15790 0 0 {name=Xclkbuf_10_40_0_CLK }
C {devices/lab_pin.sym} 67860 -15690 0 0 {name=p67558 lab=_60908_/X }
C {devices/lab_pin.sym} 67860 -15650 0 0 {name=p67559 lab=_61012_/C }
C {devices/lab_pin.sym} 67860 -15610 0 0 {name=p67560 lab=_59691_/X }
C {devices/lab_pin.sym} 68020 -15650 0 1 {name=p67561 lab=_60980_/Y }
C {sky130_stdcells/a21oi_4.sym} 67940 -15650 0 0 {name=X_60980_ }
C {devices/lab_pin.sym} 67880 -15520 0 0 {name=p67562 lab=_72966_/A }
C {devices/lab_pin.sym} 67880 -15480 0 0 {name=p67563 lab=_72965_/X }
C {devices/lab_pin.sym} 68000 -15500 0 1 {name=p67564 lab=_72967_/B }
C {sky130_stdcells/nand2_4.sym} 67940 -15500 0 0 {name=X_72966_ }
C {devices/lab_pin.sym} 67880 -15380 0 0 {name=p67565 lab=_74673_/A }
C {devices/lab_pin.sym} 67880 -15340 0 0 {name=p67566 lab=_45876_/A }
C {devices/lab_pin.sym} 68000 -15360 0 1 {name=p67567 lab=_74705_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -15360 0 0 {name=X_74705_ }
C {devices/lab_pin.sym} 67900 -15230 0 0 {name=p67568 lab=_47653_/A }
C {devices/lab_pin.sym} 67980 -15230 0 1 {name=p67569 lab=_55031_/D }
C {sky130_stdcells/inv_2.sym} 67940 -15230 0 0 {name=X_47653_ }
C {devices/lab_pin.sym} 67900 -15110 0 0 {name=p67570 lab=_71916_/Y }
C {devices/lab_pin.sym} 67980 -15110 0 1 {name=p67571 lab=_71917_/X }
C {sky130_stdcells/buf_2.sym} 67940 -15110 0 0 {name=X_71917_ }
C {devices/lab_pin.sym} 67900 -14990 0 0 {name=p67572 lab=_59639_/A }
C {devices/lab_pin.sym} 67980 -14990 0 1 {name=p67573 lab=_60403_/A }
C {sky130_stdcells/buf_2.sym} 67940 -14990 0 0 {name=X_59639_ }
C {devices/lab_pin.sym} 67880 -14880 0 0 {name=p67574 lab=_78473_/A }
C {devices/lab_pin.sym} 67880 -14840 0 0 {name=p67575 lab=_78472_/X }
C {devices/lab_pin.sym} 68000 -14860 0 1 {name=p67576 lab=_78473_/X }
C {sky130_stdcells/xor2_4.sym} 67940 -14860 0 0 {name=X_78473_ }
C {devices/lab_pin.sym} 67900 -14730 0 0 {name=p67577 lab=_46001_/A }
C {devices/lab_pin.sym} 67980 -14730 0 1 {name=p67578 lab=_44865_/X }
C {sky130_stdcells/buf_2.sym} 67940 -14730 0 0 {name=X_44865_ }
C {devices/lab_pin.sym} 67880 -14620 0 0 {name=p67579 lab=_75685_/A }
C {devices/lab_pin.sym} 67880 -14580 0 0 {name=p67580 lab=_75684_/Y }
C {devices/lab_pin.sym} 68000 -14600 0 1 {name=p67581 lab=_75686_/B }
C {sky130_stdcells/xor2_4.sym} 67940 -14600 0 0 {name=X_75685_ }
C {devices/lab_pin.sym} 67860 -14500 0 0 {name=p67582 lab=_43126_/Y }
C {devices/lab_pin.sym} 67860 -14460 0 0 {name=p67583 lab=_72895_/X }
C {devices/lab_pin.sym} 67860 -14420 0 0 {name=p67584 lab=_72858_/X }
C {devices/lab_pin.sym} 67860 -14380 0 0 {name=p67585 lab=_72896_/Y }
C {devices/lab_pin.sym} 68020 -14440 0 1 {name=p67586 lab=_72897_/X }
C {sky130_stdcells/a211o_4.sym} 67940 -14440 0 0 {name=X_72897_ }
C {devices/lab_pin.sym} 67900 -14290 0 0 {name=p67587 lab=clkbuf_9_136_0_CLK/X }
C {devices/lab_pin.sym} 67980 -14290 0 1 {name=p67588 lab=_84951_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67940 -14290 0 0 {name=Xclkbuf_10_273_0_CLK }
C {devices/lab_pin.sym} 67880 -14190 0 0 {name=p67589 lab=_51396_/A }
C {devices/lab_pin.sym} 67880 -14150 0 0 {name=p67590 lab=_46487_/B }
C {devices/lab_pin.sym} 67880 -14110 0 0 {name=p67591 lab=_46603_/X }
C {devices/lab_pin.sym} 68000 -14150 0 1 {name=p67592 lab=_46604_/X }
C {sky130_stdcells/and3_4.sym} 67940 -14150 0 0 {name=X_46604_ }
C {devices/lab_pin.sym} 67880 -14020 0 0 {name=p67593 lab=_77423_/A }
C {devices/lab_pin.sym} 67880 -13980 0 0 {name=p67594 lab=_82096_/D }
C {devices/lab_pin.sym} 68000 -14000 0 1 {name=p67595 lab=_77424_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -14000 0 0 {name=X_77424_ }
C {devices/lab_pin.sym} 67860 -13900 0 0 {name=p67596 lab=_41104_/X }
C {devices/lab_pin.sym} 67860 -13860 0 0 {name=p67597 lab=_43801_/X }
C {devices/lab_pin.sym} 67860 -13820 0 0 {name=p67598 lab=_69544_/B }
C {devices/lab_pin.sym} 67860 -13780 0 0 {name=p67599 lab=_43802_/X }
C {devices/lab_pin.sym} 68020 -13840 0 1 {name=p67600 lab=_87253_/D }
C {sky130_stdcells/a2bb2o_4.sym} 67940 -13840 0 0 {name=X_43816_ }
C {devices/lab_pin.sym} 67860 -13720 0 0 {name=p67601 lab=_45952_/X }
C {devices/lab_pin.sym} 67860 -13680 0 0 {name=p67602 lab=_56577_/Y }
C {devices/lab_pin.sym} 67860 -13640 0 0 {name=p67603 lab=_45448_/A }
C {devices/lab_pin.sym} 67860 -13600 0 0 {name=p67604 lab=_74633_/X }
C {devices/lab_pin.sym} 68020 -13660 0 1 {name=p67605 lab=_83006_/D }
C {sky130_stdcells/a2bb2o_4.sym} 67940 -13660 0 0 {name=X_74636_ }
C {devices/lab_pin.sym} 67900 -13510 0 0 {name=p67606 lab=_62949_/B }
C {devices/lab_pin.sym} 67980 -13510 0 1 {name=p67607 lab=_62650_/X }
C {sky130_stdcells/buf_2.sym} 67940 -13510 0 0 {name=X_62650_ }
C {devices/lab_pin.sym} 67860 -13410 0 0 {name=p67608 lab=_72193_/A }
C {devices/lab_pin.sym} 67860 -13370 0 0 {name=p67609 lab=_47570_/X }
C {devices/lab_pin.sym} 67860 -13330 0 0 {name=p67610 lab=_47583_/Y }
C {devices/lab_pin.sym} 68020 -13370 0 1 {name=p67611 lab=_47584_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -13370 0 0 {name=X_47584_ }
C {devices/lab_pin.sym} 67900 -13230 0 0 {name=p67612 lab=_71847_/Y }
C {devices/lab_pin.sym} 67980 -13230 0 1 {name=p67613 lab=_71848_/X }
C {sky130_stdcells/buf_2.sym} 67940 -13230 0 0 {name=X_71848_ }
C {devices/lab_pin.sym} 67860 -13150 0 0 {name=p67614 lab=_44512_/A }
C {devices/lab_pin.sym} 67860 -13110 0 0 {name=p67615 lab=_41887_/A }
C {devices/lab_pin.sym} 67860 -13070 0 0 {name=p67616 lab=_41423_/X }
C {devices/lab_pin.sym} 67860 -13030 0 0 {name=p67617 lab=_86950_/Q }
C {devices/lab_pin.sym} 67860 -12990 0 0 {name=p67618 lab=_44516_/A }
C {devices/lab_pin.sym} 68020 -13070 0 1 {name=p67619 lab=_44797_/A }
C {sky130_stdcells/o32ai_4.sym} 67940 -13070 0 0 {name=X_44796_ }
C {devices/lab_pin.sym} 67860 -12930 0 0 {name=p67620 lab=_49321_/Y }
C {devices/lab_pin.sym} 67860 -12890 0 0 {name=p67621 lab=_49271_/X }
C {devices/lab_pin.sym} 67860 -12850 0 0 {name=p67622 lab=_49322_/Y }
C {devices/lab_pin.sym} 68020 -12890 0 1 {name=p67623 lab=_86410_/D }
C {sky130_stdcells/a21boi_4.sym} 67940 -12890 0 0 {name=X_49323_ }
C {devices/lab_pin.sym} 67900 -12750 0 0 {name=p67624 lab=_61600_/Y }
C {devices/lab_pin.sym} 67980 -12750 0 1 {name=p67625 lab=_61601_/Y }
C {sky130_stdcells/inv_2.sym} 67940 -12750 0 0 {name=X_61601_ }
C {devices/lab_pin.sym} 67880 -12640 0 0 {name=p67626 lab=_46434_/A }
C {devices/lab_pin.sym} 67880 -12600 0 0 {name=p67627 lab=_50852_/B }
C {devices/lab_pin.sym} 68000 -12620 0 1 {name=p67628 lab=_46535_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -12620 0 0 {name=X_46535_ }
C {devices/lab_pin.sym} 67900 -12490 0 0 {name=p67629 lab=clkbuf_9_27_0_CLK/X }
C {devices/lab_pin.sym} 67980 -12490 0 1 {name=p67630 lab=_85096_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67940 -12490 0 0 {name=Xclkbuf_10_55_0_CLK }
C {devices/lab_pin.sym} 67880 -12380 0 0 {name=p67631 lab=_77354_/B }
C {devices/lab_pin.sym} 67880 -12340 0 0 {name=p67632 lab=_77354_/A }
C {devices/lab_pin.sym} 68000 -12360 0 1 {name=p67633 lab=_77360_/C }
C {sky130_stdcells/nand2_4.sym} 67940 -12360 0 0 {name=X_77355_ }
C {devices/lab_pin.sym} 67860 -12260 0 0 {name=p67634 lab=_40921_/X }
C {devices/lab_pin.sym} 67860 -12220 0 0 {name=p67635 lab=_43736_/X }
C {devices/lab_pin.sym} 67860 -12180 0 0 {name=p67636 lab=_73487_/A }
C {devices/lab_pin.sym} 67860 -12140 0 0 {name=p67637 lab=_43737_/X }
C {devices/lab_pin.sym} 68020 -12200 0 1 {name=p67638 lab=_43747_/X }
C {sky130_stdcells/a2bb2o_4.sym} 67940 -12200 0 0 {name=X_43747_ }
C {devices/lab_pin.sym} 67880 -12070 0 0 {name=p67639 lab=_62579_/Y }
C {devices/lab_pin.sym} 67880 -12030 0 0 {name=p67640 lab=_62561_/B }
C {devices/lab_pin.sym} 67880 -11990 0 0 {name=p67641 lab=_62580_/Y }
C {devices/lab_pin.sym} 68000 -12030 0 1 {name=p67642 lab=_62581_/Y }
C {sky130_stdcells/nand3_4.sym} 67940 -12030 0 0 {name=X_62581_ }
C {devices/lab_pin.sym} 67860 -11910 0 0 {name=p67643 lab=_45046_/Y }
C {devices/lab_pin.sym} 67860 -11870 0 0 {name=p67644 lab=_74551_/X }
C {devices/lab_pin.sym} 67860 -11830 0 0 {name=p67645 lab=_74566_/X }
C {devices/lab_pin.sym} 68020 -11870 0 1 {name=p67646 lab=_74567_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -11870 0 0 {name=X_74567_ }
C {devices/lab_pin.sym} 67900 -11730 0 0 {name=p67647 lab=_40959_/A }
C {devices/lab_pin.sym} 67980 -11730 0 1 {name=p67648 lab=_40959_/X }
C {sky130_stdcells/buf_2.sym} 67940 -11730 0 0 {name=X_40959_ }
C {devices/lab_pin.sym} 67880 -11630 0 0 {name=p67649 lab=_71779_/A }
C {devices/lab_pin.sym} 67880 -11590 0 0 {name=p67650 lab=_71779_/B }
C {devices/lab_pin.sym} 67880 -11550 0 0 {name=p67651 lab=_70986_/A }
C {devices/lab_pin.sym} 68000 -11590 0 1 {name=p67652 lab=_71779_/X }
C {sky130_stdcells/and3_4.sym} 67940 -11590 0 0 {name=X_71779_ }
C {devices/lab_pin.sym} 67900 -11450 0 0 {name=p67653 lab=clkbuf_9_395_0_CLK/A }
C {devices/lab_pin.sym} 67980 -11450 0 1 {name=p67654 lab=clkbuf_9_394_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 67940 -11450 0 0 {name=Xclkbuf_9_394_0_CLK }
C {devices/lab_pin.sym} 67880 -11350 0 0 {name=p67655 lab=_64319_/X }
C {devices/lab_pin.sym} 67880 -11310 0 0 {name=p67656 lab=_64320_/B }
C {devices/lab_pin.sym} 67880 -11270 0 0 {name=p67657 lab=_64274_/X }
C {devices/lab_pin.sym} 68000 -11310 0 1 {name=p67658 lab=_64320_/X }
C {sky130_stdcells/and3_4.sym} 67940 -11310 0 0 {name=X_64320_ }
C {devices/lab_pin.sym} 67900 -11170 0 0 {name=p67659 lab=clkbuf_8_201_0_CLK/A }
C {devices/lab_pin.sym} 67980 -11170 0 1 {name=p67660 lab=clkbuf_9_402_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 67940 -11170 0 0 {name=Xclkbuf_8_201_0_CLK }
C {devices/lab_pin.sym} 67880 -11060 0 0 {name=p67661 lab=_76306_/A }
C {devices/lab_pin.sym} 67880 -11020 0 0 {name=p67662 lab=_76305_/Y }
C {devices/lab_pin.sym} 68000 -11040 0 1 {name=p67663 lab=_76306_/X }
C {sky130_stdcells/and2_4.sym} 67940 -11040 0 0 {name=X_76306_ }
C {devices/lab_pin.sym} 67860 -10930 0 0 {name=p67664 lab=_49252_/Y }
C {devices/lab_pin.sym} 67860 -10890 0 0 {name=p67665 lab=_49247_/X }
C {devices/lab_pin.sym} 67860 -10850 0 0 {name=p67666 lab=_49253_/Y }
C {devices/lab_pin.sym} 68020 -10890 0 1 {name=p67667 lab=_49254_/Y }
C {sky130_stdcells/a21boi_4.sym} 67940 -10890 0 0 {name=X_49254_ }
C {devices/lab_pin.sym} 67900 -10750 0 0 {name=p67668 lab=_61532_/A }
C {devices/lab_pin.sym} 67980 -10750 0 1 {name=p67669 lab=_61532_/Y }
C {sky130_stdcells/inv_2.sym} 67940 -10750 0 0 {name=X_61532_ }
C {devices/lab_pin.sym} 67860 -10650 0 0 {name=p67670 lab=_73515_/X }
C {devices/lab_pin.sym} 67860 -10610 0 0 {name=p67671 lab=_73517_/X }
C {devices/lab_pin.sym} 67860 -10570 0 0 {name=p67672 lab=_72949_/X }
C {devices/lab_pin.sym} 68020 -10610 0 1 {name=p67673 lab=_73521_/A }
C {sky130_stdcells/a21o_4.sym} 67940 -10610 0 0 {name=X_73518_ }
C {devices/lab_pin.sym} 67880 -10480 0 0 {name=p67674 lab=_46421_/A }
C {devices/lab_pin.sym} 67880 -10440 0 0 {name=p67675 lab=_51328_/B }
C {devices/lab_pin.sym} 68000 -10460 0 1 {name=p67676 lab=_46466_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -10460 0 0 {name=X_46466_ }
C {devices/lab_pin.sym} 67900 -10330 0 0 {name=p67677 lab=_77286_/A }
C {devices/lab_pin.sym} 67980 -10330 0 1 {name=p67678 lab=_77286_/Y }
C {sky130_stdcells/inv_2.sym} 67940 -10330 0 0 {name=X_77286_ }
C {devices/lab_pin.sym} 67860 -10240 0 0 {name=p67679 lab=_40767_/X }
C {devices/lab_pin.sym} 67860 -10200 0 0 {name=p67680 lab=_43671_/X }
C {devices/lab_pin.sym} 67860 -10160 0 0 {name=p67681 lab=_87315_/Q }
C {devices/lab_pin.sym} 67860 -10120 0 0 {name=p67682 lab=_43673_/X }
C {devices/lab_pin.sym} 68020 -10180 0 1 {name=p67683 lab=_43678_/X }
C {sky130_stdcells/a2bb2o_4.sym} 67940 -10180 0 0 {name=X_43678_ }
C {devices/lab_pin.sym} 67860 -10050 0 0 {name=p67684 lab=_74496_/Y }
C {devices/lab_pin.sym} 67860 -10010 0 0 {name=p67685 lab=_74492_/X }
C {devices/lab_pin.sym} 67860 -9970 0 0 {name=p67686 lab=_74497_/X }
C {devices/lab_pin.sym} 68020 -10010 0 1 {name=p67687 lab=_83054_/D }
C {sky130_stdcells/a21oi_4.sym} 67940 -10010 0 0 {name=X_74498_ }
C {devices/lab_pin.sym} 67900 -9870 0 0 {name=p67688 lab=clkbuf_9_144_0_CLK/X }
C {devices/lab_pin.sym} 67980 -9870 0 1 {name=p67689 lab=_84903_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67940 -9870 0 0 {name=Xclkbuf_10_288_0_CLK }
C {devices/lab_pin.sym} 67880 -9760 0 0 {name=p67690 lab=_48204_/X }
C {devices/lab_pin.sym} 67880 -9720 0 0 {name=p67691 lab=_50260_/B }
C {devices/lab_pin.sym} 68000 -9740 0 1 {name=p67692 lab=_48205_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -9740 0 0 {name=X_48205_ }
C {devices/lab_pin.sym} 67860 -9630 0 0 {name=p67693 lab=_79012_/A }
C {devices/lab_pin.sym} 67860 -9590 0 0 {name=p67694 lab=_79023_/Y }
C {devices/lab_pin.sym} 67860 -9550 0 0 {name=p67695 lab=_79024_/X }
C {devices/lab_pin.sym} 68020 -9590 0 1 {name=p67696 lab=_79025_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -9590 0 0 {name=X_79025_ }
C {devices/lab_pin.sym} 67860 -9470 0 0 {name=p67697 lab=_85152_/Q }
C {devices/lab_pin.sym} 67860 -9430 0 0 {name=p67698 lab=_45876_/B }
C {devices/lab_pin.sym} 67860 -9390 0 0 {name=p67699 lab=_44919_/X }
C {devices/lab_pin.sym} 68020 -9430 0 1 {name=p67700 lab=_45417_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -9430 0 0 {name=X_45417_ }
C {devices/lab_pin.sym} 67880 -9310 0 0 {name=p67701 lab=_76231_/Y }
C {devices/lab_pin.sym} 67880 -9270 0 0 {name=p67702 lab=_76233_/Y }
C {devices/lab_pin.sym} 67880 -9230 0 0 {name=p67703 lab=_76235_/Y }
C {devices/lab_pin.sym} 68000 -9270 0 1 {name=p67704 lab=_76237_/Y }
C {sky130_stdcells/nand3_4.sym} 67940 -9270 0 0 {name=X_76237_ }
C {devices/lab_pin.sym} 67860 -9150 0 0 {name=p67705 lab=_59460_/A }
C {devices/lab_pin.sym} 67860 -9110 0 0 {name=p67706 lab=_64249_/X }
C {devices/lab_pin.sym} 67860 -9070 0 0 {name=p67707 lab=_64250_/Y }
C {devices/lab_pin.sym} 68020 -9110 0 1 {name=p67708 lab=_64251_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -9110 0 0 {name=X_64251_ }
C {devices/lab_pin.sym} 67900 -8970 0 0 {name=p67709 lab=_42743_/A }
C {devices/lab_pin.sym} 67980 -8970 0 1 {name=p67710 lab=_52754_/A }
C {sky130_stdcells/buf_2.sym} 67940 -8970 0 0 {name=X_42629_ }
C {devices/lab_pin.sym} 67900 -8850 0 0 {name=p67711 lab=_53932_/B }
C {devices/lab_pin.sym} 67980 -8850 0 1 {name=p67712 lab=_50716_/B }
C {sky130_stdcells/buf_2.sym} 67940 -8850 0 0 {name=X_49185_ }
C {devices/lab_pin.sym} 67880 -8750 0 0 {name=p67713 lab=_61429_/A }
C {devices/lab_pin.sym} 67880 -8710 0 0 {name=p67714 lab=_61461_/X }
C {devices/lab_pin.sym} 67880 -8670 0 0 {name=p67715 lab=_61482_/C }
C {devices/lab_pin.sym} 68000 -8710 0 1 {name=p67716 lab=_61463_/Y }
C {sky130_stdcells/nand3_4.sym} 67940 -8710 0 0 {name=X_61463_ }
C {devices/lab_pin.sym} 67900 -8570 0 0 {name=p67717 lab=_72908_/A }
C {devices/lab_pin.sym} 67980 -8570 0 1 {name=p67718 lab=_73449_/X }
C {sky130_stdcells/buf_2.sym} 67940 -8570 0 0 {name=X_73449_ }
C {devices/lab_pin.sym} 67860 -8470 0 0 {name=p67719 lab=_86740_/Q }
C {devices/lab_pin.sym} 67860 -8430 0 0 {name=p67720 lab=_46364_/X }
C {devices/lab_pin.sym} 67860 -8390 0 0 {name=p67721 lab=_46396_/Y }
C {devices/lab_pin.sym} 68020 -8430 0 1 {name=p67722 lab=_46397_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -8430 0 0 {name=X_46397_ }
C {devices/lab_pin.sym} 67880 -8320 0 0 {name=p67723 lab=_63154_/X }
C {devices/lab_pin.sym} 67880 -8280 0 0 {name=p67724 lab=_64411_/B }
C {devices/lab_pin.sym} 67880 -8240 0 0 {name=p67725 lab=_63165_/X }
C {devices/lab_pin.sym} 67880 -8200 0 0 {name=p67726 lab=_63192_/D }
C {devices/lab_pin.sym} 68000 -8260 0 1 {name=p67727 lab=_63202_/X }
C {sky130_stdcells/and4_4.sym} 67940 -8260 0 0 {name=X_63202_ }
C {devices/lab_pin.sym} 67880 -8120 0 0 {name=p67728 lab=_48136_/A }
C {devices/lab_pin.sym} 67880 -8080 0 0 {name=p67729 lab=_48136_/B }
C {devices/lab_pin.sym} 68000 -8100 0 1 {name=p67730 lab=_48136_/X }
C {sky130_stdcells/or2_4.sym} 67940 -8100 0 0 {name=X_48136_ }
C {devices/lab_pin.sym} 67880 -7980 0 0 {name=p67731 lab=_60413_/X }
C {devices/lab_pin.sym} 67880 -7940 0 0 {name=p67732 lab=_60414_/B }
C {devices/lab_pin.sym} 68000 -7960 0 1 {name=p67733 lab=_60414_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -7960 0 0 {name=X_60414_ }
C {devices/lab_pin.sym} 67900 -7830 0 0 {name=p67734 lab=_45714_/A }
C {devices/lab_pin.sym} 67980 -7830 0 1 {name=p67735 lab=_45348_/X }
C {sky130_stdcells/buf_2.sym} 67940 -7830 0 0 {name=X_45348_ }
C {devices/lab_pin.sym} 67880 -7740 0 0 {name=p67736 lab=_62174_/X }
C {devices/lab_pin.sym} 67880 -7700 0 0 {name=p67737 lab=_64182_/B }
C {devices/lab_pin.sym} 67880 -7660 0 0 {name=p67738 lab=_64182_/C }
C {devices/lab_pin.sym} 67880 -7620 0 0 {name=p67739 lab=_64182_/D }
C {devices/lab_pin.sym} 68000 -7680 0 1 {name=p67740 lab=_64182_/Y }
C {sky130_stdcells/nand4_4.sym} 67940 -7680 0 0 {name=X_64182_ }
C {devices/lab_pin.sym} 67880 -7540 0 0 {name=p67741 lab=_76166_/X }
C {devices/lab_pin.sym} 67880 -7500 0 0 {name=p67742 lab=_76168_/B }
C {devices/lab_pin.sym} 68000 -7520 0 1 {name=p67743 lab=_76169_/A }
C {sky130_stdcells/and2_4.sym} 67940 -7520 0 0 {name=X_76168_ }
C {devices/lab_pin.sym} 67900 -7390 0 0 {name=p67744 lab=_61394_/A }
C {devices/lab_pin.sym} 67980 -7390 0 1 {name=p67745 lab=_61394_/X }
C {sky130_stdcells/buf_2.sym} 67940 -7390 0 0 {name=X_61394_ }
C {devices/lab_pin.sym} 67900 -7270 0 0 {name=p67746 lab=clkbuf_8_217_0_CLK/A }
C {devices/lab_pin.sym} 67980 -7270 0 1 {name=p67747 lab=clkbuf_8_216_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 67940 -7270 0 0 {name=Xclkbuf_8_216_0_CLK }
C {devices/lab_pin.sym} 67900 -7150 0 0 {name=p67748 lab=clkbuf_9_105_0_CLK/X }
C {devices/lab_pin.sym} 67980 -7150 0 1 {name=p67749 lab=_84493_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67940 -7150 0 0 {name=Xclkbuf_10_211_0_CLK }
C {devices/lab_pin.sym} 67880 -7060 0 0 {name=p67750 lab=_63097_/A }
C {devices/lab_pin.sym} 67880 -7020 0 0 {name=p67751 lab=_64343_/B }
C {devices/lab_pin.sym} 67880 -6980 0 0 {name=p67752 lab=_63108_/C }
C {devices/lab_pin.sym} 67880 -6940 0 0 {name=p67753 lab=_63121_/D }
C {devices/lab_pin.sym} 68000 -7000 0 1 {name=p67754 lab=_63133_/X }
C {sky130_stdcells/and4_4.sym} 67940 -7000 0 0 {name=X_63133_ }
C {devices/lab_pin.sym} 67860 -6870 0 0 {name=p67755 lab=_75116_/X }
C {devices/lab_pin.sym} 67860 -6830 0 0 {name=p67756 lab=_75120_/B }
C {devices/lab_pin.sym} 67860 -6790 0 0 {name=p67757 lab=_75120_/A }
C {devices/lab_pin.sym} 68020 -6830 0 1 {name=p67758 lab=_75119_/X }
C {sky130_stdcells/a21o_4.sym} 67940 -6830 0 0 {name=X_75119_ }
C {devices/lab_pin.sym} 67900 -6690 0 0 {name=p67759 lab=_60105_/X }
C {devices/lab_pin.sym} 67980 -6690 0 1 {name=p67760 lab=_60477_/A }
C {sky130_stdcells/buf_2.sym} 67940 -6690 0 0 {name=X_60345_ }
C {devices/lab_pin.sym} 67900 -6570 0 0 {name=p67761 lab=_48067_/A }
C {devices/lab_pin.sym} 67980 -6570 0 1 {name=p67762 lab=_52050_/A }
C {sky130_stdcells/buf_2.sym} 67940 -6570 0 0 {name=X_48067_ }
C {devices/lab_pin.sym} 67860 -6470 0 0 {name=p67763 lab=_45277_/X }
C {devices/lab_pin.sym} 67860 -6430 0 0 {name=p67764 lab=_61617_/B }
C {devices/lab_pin.sym} 67860 -6390 0 0 {name=p67765 lab=_45219_/X }
C {devices/lab_pin.sym} 68020 -6430 0 1 {name=p67766 lab=_45279_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -6430 0 0 {name=X_45279_ }
C {devices/lab_pin.sym} 67880 -6300 0 0 {name=p67767 lab=_69648_/A }
C {devices/lab_pin.sym} 67880 -6260 0 0 {name=p67768 lab=_42525_/Y }
C {devices/lab_pin.sym} 68000 -6280 0 1 {name=p67769 lab=_68990_/Y }
C {sky130_stdcells/nor2_4.sym} 67940 -6280 0 0 {name=X_68990_ }
C {devices/lab_pin.sym} 67880 -6160 0 0 {name=p67770 lab=_76099_/A }
C {devices/lab_pin.sym} 67880 -6120 0 0 {name=p67771 lab=_76099_/B }
C {devices/lab_pin.sym} 68000 -6140 0 1 {name=p67772 lab=_76100_/B }
C {sky130_stdcells/xnor2_4.sym} 67940 -6140 0 0 {name=X_76099_ }
C {devices/lab_pin.sym} 67900 -6010 0 0 {name=p67773 lab=clkbuf_9_420_0_CLK/X }
C {devices/lab_pin.sym} 67980 -6010 0 1 {name=p67774 lab=_82746_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67940 -6010 0 0 {name=Xclkbuf_10_841_0_CLK }
C {devices/lab_pin.sym} 67860 -5910 0 0 {name=p67775 lab=_59118_/A }
C {devices/lab_pin.sym} 67860 -5870 0 0 {name=p67776 lab=_47004_/X }
C {devices/lab_pin.sym} 67860 -5830 0 0 {name=p67777 lab=_47017_/Y }
C {devices/lab_pin.sym} 68020 -5870 0 1 {name=p67778 lab=_47018_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -5870 0 0 {name=X_47018_ }
C {devices/lab_pin.sym} 67860 -5750 0 0 {name=p67779 lab=_67937_/X }
C {devices/lab_pin.sym} 67860 -5710 0 0 {name=p67780 lab=_67940_/X }
C {devices/lab_pin.sym} 67860 -5670 0 0 {name=p67781 lab=_67917_/X }
C {devices/lab_pin.sym} 68020 -5710 0 1 {name=p67782 lab=_67941_/X }
C {sky130_stdcells/a21o_4.sym} 67940 -5710 0 0 {name=X_67941_ }
C {devices/lab_pin.sym} 67880 -5600 0 0 {name=p67783 lab=_63039_/A }
C {devices/lab_pin.sym} 67880 -5560 0 0 {name=p67784 lab=_64276_/C }
C {devices/lab_pin.sym} 67880 -5520 0 0 {name=p67785 lab=_63028_/X }
C {devices/lab_pin.sym} 67880 -5480 0 0 {name=p67786 lab=_63014_/D }
C {devices/lab_pin.sym} 68000 -5540 0 1 {name=p67787 lab=_63064_/X }
C {sky130_stdcells/and4_4.sym} 67940 -5540 0 0 {name=X_63064_ }
C {devices/lab_pin.sym} 67880 -5400 0 0 {name=p67788 lab=_79927_/A }
C {devices/lab_pin.sym} 67880 -5360 0 0 {name=p67789 lab=_79927_/B }
C {devices/lab_pin.sym} 68000 -5380 0 1 {name=p67790 lab=_79928_/B }
C {sky130_stdcells/nand2_4.sym} 67940 -5380 0 0 {name=X_79927_ }
C {devices/lab_pin.sym} 67860 -5280 0 0 {name=p67791 lab=_60331_/D }
C {devices/lab_pin.sym} 67860 -5240 0 0 {name=p67792 lab=_60273_/X }
C {devices/lab_pin.sym} 67860 -5200 0 0 {name=p67793 lab=_60275_/X }
C {devices/lab_pin.sym} 67860 -5160 0 0 {name=p67794 lab=_60344_/B }
C {devices/lab_pin.sym} 68020 -5220 0 1 {name=p67795 lab=_60276_/Y }
C {sky130_stdcells/a22oi_4.sym} 67940 -5220 0 0 {name=X_60276_ }
C {devices/lab_pin.sym} 67900 -5070 0 0 {name=p67796 lab=clkbuf_8_166_0_CLK/X }
C {devices/lab_pin.sym} 67980 -5070 0 1 {name=p67797 lab=clkbuf_9_332_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 67940 -5070 0 0 {name=Xclkbuf_9_332_0_CLK }
C {devices/lab_pin.sym} 67880 -4980 0 0 {name=p67798 lab=_61957_/A }
C {devices/lab_pin.sym} 67880 -4940 0 0 {name=p67799 lab=_62015_/B }
C {devices/lab_pin.sym} 67880 -4900 0 0 {name=p67800 lab=_62012_/Y }
C {devices/lab_pin.sym} 67880 -4860 0 0 {name=p67801 lab=_62015_/D }
C {devices/lab_pin.sym} 68000 -4920 0 1 {name=p67802 lab=_62015_/Y }
C {sky130_stdcells/nand4_4.sym} 67940 -4920 0 0 {name=X_62015_ }
C {devices/lab_pin.sym} 67900 -4770 0 0 {name=p67803 lab=_68370_/A }
C {devices/lab_pin.sym} 67980 -4770 0 1 {name=p67804 lab=_67872_/X }
C {sky130_stdcells/buf_2.sym} 67940 -4770 0 0 {name=X_67872_ }
C {devices/lab_pin.sym} 67860 -4670 0 0 {name=p67805 lab=_79812_/Y }
C {devices/lab_pin.sym} 67860 -4630 0 0 {name=p67806 lab=_79852_/X }
C {devices/lab_pin.sym} 67860 -4590 0 0 {name=p67807 lab=_79857_/Y }
C {devices/lab_pin.sym} 68020 -4630 0 1 {name=p67808 lab=_79858_/Y }
C {sky130_stdcells/a21oi_4.sym} 67940 -4630 0 0 {name=X_79858_ }
C {devices/lab_pin.sym} 67900 -4490 0 0 {name=p67809 lab=clkbuf_9_113_0_CLK/X }
C {devices/lab_pin.sym} 67980 -4490 0 1 {name=p67810 lab=_81111_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67940 -4490 0 0 {name=Xclkbuf_10_226_0_CLK }
C {devices/lab_pin.sym} 67900 -4370 0 0 {name=p67811 lab=_69611_/A }
C {devices/lab_pin.sym} 67980 -4370 0 1 {name=p67812 lab=_69611_/X }
C {sky130_stdcells/buf_2.sym} 67940 -4370 0 0 {name=X_69611_ }
C {devices/lab_pin.sym} 67880 -4260 0 0 {name=p67813 lab=_66823_/A }
C {devices/lab_pin.sym} 67880 -4220 0 0 {name=p67814 lab=_88201_/Q }
C {devices/lab_pin.sym} 68000 -4240 0 1 {name=p67815 lab=_66823_/X }
C {sky130_stdcells/and2_4.sym} 67940 -4240 0 0 {name=X_66823_ }
C {devices/lab_pin.sym} 67880 -4120 0 0 {name=p67816 lab=_78809_/A }
C {devices/lab_pin.sym} 67880 -4080 0 0 {name=p67817 lab=_82546_/Q }
C {devices/lab_pin.sym} 68000 -4100 0 1 {name=p67818 lab=_78809_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -4100 0 0 {name=X_78809_ }
C {devices/lab_pin.sym} 67900 -3970 0 0 {name=p67819 lab=_48969_/A }
C {devices/lab_pin.sym} 67980 -3970 0 1 {name=p67820 lab=_71998_/B }
C {sky130_stdcells/buf_2.sym} 67940 -3970 0 0 {name=X_48969_ }
C {devices/lab_pin.sym} 67900 -3850 0 0 {name=p67821 lab=clkbuf_9_428_0_CLK/X }
C {devices/lab_pin.sym} 67980 -3850 0 1 {name=p67822 lab=_85800_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 67940 -3850 0 0 {name=Xclkbuf_10_856_0_CLK }
C {devices/lab_pin.sym} 67880 -3740 0 0 {name=p67823 lab=_79790_/B }
C {devices/lab_pin.sym} 67880 -3700 0 0 {name=p67824 lab=_79776_/Y }
C {devices/lab_pin.sym} 68000 -3720 0 1 {name=p67825 lab=_79789_/X }
C {sky130_stdcells/or2_4.sym} 67940 -3720 0 0 {name=X_79789_ }
C {devices/lab_pin.sym} 67850 -3590 0 0 {name=p67826 lab=_81275_/CLK }
C {devices/lab_pin.sym} 67850 -3570 0 0 {name=p67827 lab=_81628_/Q }
C {devices/lab_pin.sym} 68030 -3590 0 1 {name=p67828 lab=_81820_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -3580 0 0 {name=X_81820_ }
C {devices/lab_pin.sym} 67880 -3460 0 0 {name=p67829 lab=_69956_/A }
C {devices/lab_pin.sym} 67880 -3420 0 0 {name=p67830 lab=_69542_/B }
C {devices/lab_pin.sym} 68000 -3440 0 1 {name=p67831 lab=_69542_/X }
C {sky130_stdcells/and2_4.sym} 67940 -3440 0 0 {name=X_69542_ }
C {devices/lab_pin.sym} 67860 -3330 0 0 {name=p67832 lab=_66750_/X }
C {devices/lab_pin.sym} 67860 -3290 0 0 {name=p67833 lab=_66753_/X }
C {devices/lab_pin.sym} 67860 -3250 0 0 {name=p67834 lab=_66658_/X }
C {devices/lab_pin.sym} 68020 -3290 0 1 {name=p67835 lab=_66754_/Y }
C {sky130_stdcells/a21oi_4.sym} 67940 -3290 0 0 {name=X_66754_ }
C {devices/lab_pin.sym} 67860 -3170 0 0 {name=p67836 lab=_73780_/B }
C {devices/lab_pin.sym} 67860 -3130 0 0 {name=p67837 lab=_51960_/X }
C {devices/lab_pin.sym} 67860 -3090 0 0 {name=p67838 lab=_51979_/Y }
C {devices/lab_pin.sym} 68020 -3130 0 1 {name=p67839 lab=_51980_/Y }
C {sky130_stdcells/o21ai_4.sym} 67940 -3130 0 0 {name=X_51980_ }
C {devices/lab_pin.sym} 67880 -3020 0 0 {name=p67840 lab=_58528_/A }
C {devices/lab_pin.sym} 67880 -2980 0 0 {name=p67841 lab=_64191_/B }
C {devices/lab_pin.sym} 67880 -2940 0 0 {name=p67842 lab=_60889_/X }
C {devices/lab_pin.sym} 67880 -2900 0 0 {name=p67843 lab=_64191_/D }
C {devices/lab_pin.sym} 68000 -2960 0 1 {name=p67844 lab=_63966_/Y }
C {sky130_stdcells/nand4_4.sym} 67940 -2960 0 0 {name=X_63966_ }
C {devices/lab_pin.sym} 67900 -2810 0 0 {name=p67845 lab=clkbuf_9_347_0_CLK/A }
C {devices/lab_pin.sym} 67980 -2810 0 1 {name=p67846 lab=clkbuf_9_347_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 67940 -2810 0 0 {name=Xclkbuf_9_347_0_CLK }
C {devices/lab_pin.sym} 67860 -2720 0 0 {name=p67847 lab=_65638_/X }
C {devices/lab_pin.sym} 67860 -2680 0 0 {name=p67848 lab=_85583_/Q }
C {devices/lab_pin.sym} 67860 -2640 0 0 {name=p67849 lab=_65669_/X }
C {devices/lab_pin.sym} 67860 -2600 0 0 {name=p67850 lab=_65704_/X }
C {devices/lab_pin.sym} 68020 -2660 0 1 {name=p67851 lab=_65705_/X }
C {sky130_stdcells/a211o_4.sym} 67940 -2660 0 0 {name=X_65705_ }
C {devices/lab_pin.sym} 67860 -2530 0 0 {name=p67852 lab=_50927_/Y }
C {devices/lab_pin.sym} 67860 -2490 0 0 {name=p67853 lab=_50928_/X }
C {devices/lab_pin.sym} 67860 -2450 0 0 {name=p67854 lab=_50930_/X }
C {devices/lab_pin.sym} 68020 -2490 0 1 {name=p67855 lab=_86105_/D }
C {sky130_stdcells/a21oi_4.sym} 67940 -2490 0 0 {name=X_50931_ }
C {devices/lab_pin.sym} 67900 -2350 0 0 {name=p67856 lab=_62081_/B }
C {devices/lab_pin.sym} 67980 -2350 0 1 {name=p67857 lab=_64473_/A }
C {sky130_stdcells/inv_2.sym} 67940 -2350 0 0 {name=X_62917_ }
C {devices/lab_pin.sym} 67850 -2230 0 0 {name=p67858 lab=_81756_/CLK }
C {devices/lab_pin.sym} 67850 -2210 0 0 {name=p67859 lab=_76074_/B }
C {devices/lab_pin.sym} 68030 -2230 0 1 {name=p67860 lab=_41686_/B }
C {sky130_stdcells/dfxtp_4.sym} 67940 -2220 0 0 {name=X_81751_ }
C {devices/lab_pin.sym} 67860 -2120 0 0 {name=p67861 lab=_87015_/Q }
C {devices/lab_pin.sym} 67860 -2080 0 0 {name=p67862 lab=_69414_/X }
C {devices/lab_pin.sym} 67860 -2040 0 0 {name=p67863 lab=_69430_/X }
C {devices/lab_pin.sym} 67860 -2000 0 0 {name=p67864 lab=_69472_/X }
C {devices/lab_pin.sym} 68020 -2060 0 1 {name=p67865 lab=_69473_/X }
C {sky130_stdcells/a211o_4.sym} 67940 -2060 0 0 {name=X_69473_ }
C {devices/lab_pin.sym} 67860 -1930 0 0 {name=p67866 lab=_66681_/X }
C {devices/lab_pin.sym} 67860 -1890 0 0 {name=p67867 lab=_66684_/X }
C {devices/lab_pin.sym} 67860 -1850 0 0 {name=p67868 lab=_66411_/A }
C {devices/lab_pin.sym} 68020 -1890 0 1 {name=p67869 lab=_66685_/Y }
C {sky130_stdcells/a21oi_4.sym} 67940 -1890 0 0 {name=X_66685_ }
C {devices/lab_pin.sym} 67880 -1770 0 0 {name=p67870 lab=_63848_/X }
C {devices/lab_pin.sym} 67880 -1730 0 0 {name=p67871 lab=_63849_/X }
C {devices/lab_pin.sym} 67880 -1690 0 0 {name=p67872 lab=_63897_/C }
C {devices/lab_pin.sym} 68000 -1730 0 1 {name=p67873 lab=_63897_/Y }
C {sky130_stdcells/nor3_4.sym} 67940 -1730 0 0 {name=X_63897_ }
C {devices/lab_pin.sym} 67850 -1590 0 0 {name=p67874 lab=_82211_/CLK }
C {devices/lab_pin.sym} 67850 -1570 0 0 {name=p67875 lab=_80702_/D }
C {devices/lab_pin.sym} 68030 -1590 0 1 {name=p67876 lab=_80702_/Q }
C {sky130_stdcells/dfxtp_4.sym} 67940 -1580 0 0 {name=X_80702_ }
C {devices/lab_pin.sym} 67860 -1470 0 0 {name=p67877 lab=_68420_/X }
C {devices/lab_pin.sym} 67860 -1430 0 0 {name=p67878 lab=_68423_/X }
C {devices/lab_pin.sym} 67860 -1390 0 0 {name=p67879 lab=_68400_/X }
C {devices/lab_pin.sym} 68020 -1430 0 1 {name=p67880 lab=_68424_/Y }
C {sky130_stdcells/a21oi_4.sym} 67940 -1430 0 0 {name=X_68424_ }
C {devices/lab_pin.sym} 67860 -1310 0 0 {name=p67881 lab=_53648_/Y }
C {devices/lab_pin.sym} 67860 -1270 0 0 {name=p67882 lab=_53619_/X }
C {devices/lab_pin.sym} 67860 -1230 0 0 {name=p67883 lab=_53649_/X }
C {devices/lab_pin.sym} 68020 -1270 0 1 {name=p67884 lab=_85595_/D }
C {sky130_stdcells/a21oi_4.sym} 67940 -1270 0 0 {name=X_53650_ }
C {devices/lab_pin.sym} 67880 -1140 0 0 {name=p67885 lab=_65667_/A }
C {devices/lab_pin.sym} 67880 -1100 0 0 {name=p67886 lab=_85875_/Q }
C {devices/lab_pin.sym} 68000 -1120 0 1 {name=p67887 lab=_65636_/X }
C {sky130_stdcells/and2_4.sym} 67940 -1120 0 0 {name=X_65636_ }
C {devices/lab_pin.sym} 67850 -990 0 0 {name=p67888 lab=_82452_/CLK }
C {devices/lab_pin.sym} 67850 -970 0 0 {name=p67889 lab=_61567_/Y }
C {devices/lab_pin.sym} 68030 -990 0 1 {name=p67890 lab=_79138_/B }
C {sky130_stdcells/dfxtp_4.sym} 67940 -980 0 0 {name=X_84470_ }
C {devices/lab_pin.sym} 67880 -860 0 0 {name=p67891 lab=_50857_/X }
C {devices/lab_pin.sym} 67880 -820 0 0 {name=p67892 lab=_50862_/B }
C {devices/lab_pin.sym} 68000 -840 0 1 {name=p67893 lab=_50862_/Y }
C {sky130_stdcells/nand2_4.sym} 67940 -840 0 0 {name=X_50862_ }
C {devices/lab_pin.sym} 67880 -740 0 0 {name=p67894 lab=_62847_/X }
C {devices/lab_pin.sym} 67880 -700 0 0 {name=p67895 lab=_63198_/A }
C {devices/lab_pin.sym} 67880 -660 0 0 {name=p67896 lab=_62848_/C }
C {devices/lab_pin.sym} 67880 -620 0 0 {name=p67897 lab=_62880_/D }
C {devices/lab_pin.sym} 68000 -680 0 1 {name=p67898 lab=_62848_/X }
C {sky130_stdcells/and4_4.sym} 67940 -680 0 0 {name=X_62848_ }
C {devices/lab_pin.sym} 68770 -42150 0 0 {name=p67899 lab=_81682_/CLK }
C {devices/lab_pin.sym} 68770 -42130 0 0 {name=p67900 lab=_80098_/X }
C {devices/lab_pin.sym} 68950 -42150 0 1 {name=p67901 lab=_81682_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -42140 0 0 {name=X_81682_ }
C {devices/lab_pin.sym} 68820 -42010 0 0 {name=p67902 lab=_52515_/X }
C {devices/lab_pin.sym} 68900 -42010 0 1 {name=p67903 lab=_52601_/X }
C {sky130_stdcells/buf_2.sym} 68860 -42010 0 0 {name=X_52601_ }
C {devices/lab_pin.sym} 68770 -41890 0 0 {name=p67904 lab=_83421_/CLK }
C {devices/lab_pin.sym} 68770 -41870 0 0 {name=p67905 lab=_83421_/D }
C {devices/lab_pin.sym} 68950 -41890 0 1 {name=p67906 lab=_83421_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -41880 0 0 {name=X_83421_ }
C {devices/lab_pin.sym} 68800 -41770 0 0 {name=p67907 lab=_80624_/A }
C {devices/lab_pin.sym} 68800 -41730 0 0 {name=p67908 lab=_80623_/X }
C {devices/lab_pin.sym} 68800 -41690 0 0 {name=p67909 lab=_80633_/C }
C {devices/lab_pin.sym} 68920 -41730 0 1 {name=p67910 lab=_80633_/Y }
C {sky130_stdcells/nand3_4.sym} 68860 -41730 0 0 {name=X_80633_ }
C {devices/lab_pin.sym} 68800 -41600 0 0 {name=p67911 lab=_65381_/A }
C {devices/lab_pin.sym} 68800 -41560 0 0 {name=p67912 lab=_88275_/Q }
C {devices/lab_pin.sym} 68920 -41580 0 1 {name=p67913 lab=_68355_/X }
C {sky130_stdcells/and2_4.sym} 68860 -41580 0 0 {name=X_68355_ }
C {devices/lab_pin.sym} 68800 -41460 0 0 {name=p67914 lab=_53622_/A }
C {devices/lab_pin.sym} 68800 -41420 0 0 {name=p67915 lab=_57617_/B }
C {devices/lab_pin.sym} 68920 -41440 0 1 {name=p67916 lab=_53581_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -41440 0 0 {name=X_53581_ }
C {devices/lab_pin.sym} 68780 -41330 0 0 {name=p67917 lab=_65562_/X }
C {devices/lab_pin.sym} 68780 -41290 0 0 {name=p67918 lab=_65565_/X }
C {devices/lab_pin.sym} 68780 -41250 0 0 {name=p67919 lab=_65566_/X }
C {devices/lab_pin.sym} 68940 -41290 0 1 {name=p67920 lab=_66044_/A }
C {sky130_stdcells/a21o_4.sym} 68860 -41290 0 0 {name=X_65567_ }
C {devices/lab_pin.sym} 68800 -41160 0 0 {name=p67921 lab=_50787_/X }
C {devices/lab_pin.sym} 68800 -41120 0 0 {name=p67922 lab=_46407_/X }
C {devices/lab_pin.sym} 68920 -41140 0 1 {name=p67923 lab=_50793_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -41140 0 0 {name=X_50793_ }
C {devices/lab_pin.sym} 68820 -41010 0 0 {name=p67924 lab=_62893_/A }
C {devices/lab_pin.sym} 68900 -41010 0 1 {name=p67925 lab=_62779_/X }
C {sky130_stdcells/buf_2.sym} 68860 -41010 0 0 {name=X_62779_ }
C {devices/lab_pin.sym} 68800 -40900 0 0 {name=p67926 lab=_44059_/X }
C {devices/lab_pin.sym} 68800 -40860 0 0 {name=p67927 lab=_55320_/B }
C {devices/lab_pin.sym} 68920 -40880 0 1 {name=p67928 lab=_55320_/Y }
C {sky130_stdcells/nor2_4.sym} 68860 -40880 0 0 {name=X_55320_ }
C {devices/lab_pin.sym} 68800 -40760 0 0 {name=p67929 lab=_67259_/A }
C {devices/lab_pin.sym} 68800 -40720 0 0 {name=p67930 lab=_87604_/Q }
C {devices/lab_pin.sym} 68920 -40740 0 1 {name=p67931 lab=_67306_/X }
C {sky130_stdcells/and2_4.sym} 68860 -40740 0 0 {name=X_67306_ }
C {devices/lab_pin.sym} 68770 -40610 0 0 {name=p67932 lab=_86139_/CLK }
C {devices/lab_pin.sym} 68770 -40590 0 0 {name=p67933 lab=_50756_/Y }
C {devices/lab_pin.sym} 68950 -40610 0 1 {name=p67934 lab=_86140_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -40600 0 0 {name=X_86140_ }
C {devices/lab_pin.sym} 68820 -40470 0 0 {name=p67935 lab=_52496_/A }
C {devices/lab_pin.sym} 68900 -40470 0 1 {name=p67936 lab=_52532_/X }
C {sky130_stdcells/buf_2.sym} 68860 -40470 0 0 {name=X_52532_ }
C {devices/lab_pin.sym} 68780 -40370 0 0 {name=p67937 lab=_64511_/Y }
C {devices/lab_pin.sym} 68780 -40330 0 0 {name=p67938 lab=_64517_/X }
C {devices/lab_pin.sym} 68780 -40290 0 0 {name=p67939 lab=_64442_/X }
C {devices/lab_pin.sym} 68940 -40330 0 1 {name=p67940 lab=_64518_/X }
C {sky130_stdcells/o21a_4.sym} 68860 -40330 0 0 {name=X_64518_ }
C {devices/lab_pin.sym} 68770 -40190 0 0 {name=p67941 lab=_83480_/CLK }
C {devices/lab_pin.sym} 68770 -40170 0 0 {name=p67942 lab=_83352_/D }
C {devices/lab_pin.sym} 68950 -40190 0 1 {name=p67943 lab=_83352_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -40180 0 0 {name=X_83352_ }
C {devices/lab_pin.sym} 68800 -40060 0 0 {name=p67944 lab=_80561_/X }
C {devices/lab_pin.sym} 68800 -40020 0 0 {name=p67945 lab=_80564_/B }
C {devices/lab_pin.sym} 68920 -40040 0 1 {name=p67946 lab=_82267_/D }
C {sky130_stdcells/xnor2_4.sym} 68860 -40040 0 0 {name=X_80564_ }
C {sky130_stdcells/decap_3.sym} 68860 -39880 0 0 {name=XPHY_107 }
C {devices/lab_pin.sym} 68780 -39750 0 0 {name=p67947 lab=_82640_/D }
C {devices/lab_pin.sym} 68780 -39710 0 0 {name=p67948 lab=_68279_/X }
C {devices/lab_pin.sym} 68780 -39670 0 0 {name=p67949 lab=_68285_/X }
C {devices/lab_pin.sym} 68940 -39710 0 1 {name=p67950 lab=_83992_/D }
C {sky130_stdcells/a21bo_4.sym} 68860 -39710 0 0 {name=X_68286_ }
C {devices/lab_pin.sym} 68800 -39590 0 0 {name=p67951 lab=_65397_/A }
C {devices/lab_pin.sym} 68800 -39550 0 0 {name=p67952 lab=_65397_/B }
C {devices/lab_pin.sym} 68800 -39510 0 0 {name=p67953 lab=_65498_/C }
C {devices/lab_pin.sym} 68920 -39550 0 1 {name=p67954 lab=_65498_/Y }
C {sky130_stdcells/nor3_4.sym} 68860 -39550 0 0 {name=X_65498_ }
C {sky130_stdcells/decap_3.sym} 68860 -39380 0 0 {name=XPHY_118 }
C {sky130_stdcells/decap_3.sym} 68860 -39200 0 0 {name=XPHY_129 }
C {devices/lab_pin.sym} 68770 -39050 0 0 {name=p67955 lab=_82349_/CLK }
C {devices/lab_pin.sym} 68770 -39030 0 0 {name=p67956 lab=_77217_/B }
C {devices/lab_pin.sym} 68950 -39050 0 1 {name=p67957 lab=_82303_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -39040 0 0 {name=X_82303_ }
C {devices/lab_pin.sym} 68820 -38910 0 0 {name=p67958 lab=_55224_/A }
C {devices/lab_pin.sym} 68900 -38910 0 1 {name=p67959 lab=_55252_/A }
C {sky130_stdcells/buf_2.sym} 68860 -38910 0 0 {name=X_55251_ }
C {devices/lab_pin.sym} 68800 -38800 0 0 {name=p67960 lab=_67259_/A }
C {devices/lab_pin.sym} 68800 -38760 0 0 {name=p67961 lab=_87607_/Q }
C {devices/lab_pin.sym} 68920 -38780 0 1 {name=p67962 lab=_67237_/X }
C {sky130_stdcells/and2_4.sym} 68860 -38780 0 0 {name=X_67237_ }
C {devices/lab_pin.sym} 68770 -38650 0 0 {name=p67963 lab=_85751_/CLK }
C {devices/lab_pin.sym} 68770 -38630 0 0 {name=p67964 lab=_51116_/Y }
C {devices/lab_pin.sym} 68950 -38650 0 1 {name=p67965 lab=_86071_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -38640 0 0 {name=X_86071_ }
C {devices/lab_pin.sym} 68820 -38510 0 0 {name=p67966 lab=_52431_/A }
C {devices/lab_pin.sym} 68900 -38510 0 1 {name=p67967 lab=_52468_/A }
C {sky130_stdcells/buf_2.sym} 68860 -38510 0 0 {name=X_52463_ }
C {devices/lab_pin.sym} 68800 -38410 0 0 {name=p67968 lab=_64515_/A }
C {devices/lab_pin.sym} 68800 -38370 0 0 {name=p67969 lab=_84861_/Q }
C {devices/lab_pin.sym} 68800 -38330 0 0 {name=p67970 lab=_64515_/C }
C {devices/lab_pin.sym} 68920 -38370 0 1 {name=p67971 lab=_64449_/Y }
C {sky130_stdcells/nand3_4.sym} 68860 -38370 0 0 {name=X_64449_ }
C {devices/lab_pin.sym} 68770 -38230 0 0 {name=p67972 lab=_85826_/CLK }
C {devices/lab_pin.sym} 68770 -38210 0 0 {name=p67973 lab=_83283_/D }
C {devices/lab_pin.sym} 68950 -38230 0 1 {name=p67974 lab=_83283_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -38220 0 0 {name=X_83283_ }
C {devices/lab_pin.sym} 68780 -38110 0 0 {name=p67975 lab=_59159_/Y }
C {devices/lab_pin.sym} 68780 -38070 0 0 {name=p67976 lab=_66109_/C }
C {devices/lab_pin.sym} 68780 -38030 0 0 {name=p67977 lab=_80494_/Y }
C {devices/lab_pin.sym} 68940 -38070 0 1 {name=p67978 lab=_80495_/X }
C {sky130_stdcells/o21a_4.sym} 68860 -38070 0 0 {name=X_80495_ }
C {devices/lab_pin.sym} 68780 -37950 0 0 {name=p67979 lab=_85485_/Q }
C {devices/lab_pin.sym} 68780 -37910 0 0 {name=p67980 lab=_54193_/X }
C {devices/lab_pin.sym} 68780 -37870 0 0 {name=p67981 lab=_54201_/Y }
C {devices/lab_pin.sym} 68940 -37910 0 1 {name=p67982 lab=_54202_/Y }
C {sky130_stdcells/o21ai_4.sym} 68860 -37910 0 0 {name=X_54202_ }
C {devices/lab_pin.sym} 68770 -37770 0 0 {name=p67983 lab=_83008_/CLK }
C {devices/lab_pin.sym} 68770 -37750 0 0 {name=p67984 lab=_57388_/X }
C {devices/lab_pin.sym} 68950 -37770 0 1 {name=p67985 lab=_85022_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -37760 0 0 {name=X_85022_ }
C {devices/lab_pin.sym} 68780 -37650 0 0 {name=p67986 lab=_86014_/Q }
C {devices/lab_pin.sym} 68780 -37610 0 0 {name=p67987 lab=_51402_/X }
C {devices/lab_pin.sym} 68780 -37570 0 0 {name=p67988 lab=_51413_/Y }
C {devices/lab_pin.sym} 68940 -37610 0 1 {name=p67989 lab=_51414_/Y }
C {sky130_stdcells/o21ai_4.sym} 68860 -37610 0 0 {name=X_51414_ }
C {devices/lab_pin.sym} 68770 -37470 0 0 {name=p67990 lab=_82234_/CLK }
C {devices/lab_pin.sym} 68770 -37450 0 0 {name=p67991 lab=_82266_/Q }
C {devices/lab_pin.sym} 68950 -37470 0 1 {name=p67992 lab=_77580_/A }
C {sky130_stdcells/dfxtp_4.sym} 68860 -37460 0 0 {name=X_82234_ }
C {devices/lab_pin.sym} 68820 -37330 0 0 {name=p67993 lab=_55129_/A }
C {devices/lab_pin.sym} 68900 -37330 0 1 {name=p67994 lab=_55245_/A }
C {sky130_stdcells/buf_2.sym} 68860 -37330 0 0 {name=X_55182_ }
C {devices/lab_pin.sym} 68800 -37220 0 0 {name=p67995 lab=_67095_/A }
C {devices/lab_pin.sym} 68800 -37180 0 0 {name=p67996 lab=_87674_/Q }
C {devices/lab_pin.sym} 68920 -37200 0 1 {name=p67997 lab=_67168_/X }
C {sky130_stdcells/and2_4.sym} 68860 -37200 0 0 {name=X_67168_ }
C {devices/lab_pin.sym} 68780 -37090 0 0 {name=p67998 lab=_65282_/B }
C {devices/lab_pin.sym} 68780 -37050 0 0 {name=p67999 lab=_52372_/X }
C {devices/lab_pin.sym} 68780 -37010 0 0 {name=p68000 lab=_52393_/Y }
C {devices/lab_pin.sym} 68940 -37050 0 1 {name=p68001 lab=_52394_/Y }
C {sky130_stdcells/o21ai_4.sym} 68860 -37050 0 0 {name=X_52394_ }
C {devices/lab_pin.sym} 68780 -36930 0 0 {name=p68002 lab=_54131_/Y }
C {devices/lab_pin.sym} 68780 -36890 0 0 {name=p68003 lab=_54117_/X }
C {devices/lab_pin.sym} 68780 -36850 0 0 {name=p68004 lab=_54132_/X }
C {devices/lab_pin.sym} 68940 -36890 0 1 {name=p68005 lab=_85498_/D }
C {sky130_stdcells/a21oi_4.sym} 68860 -36890 0 0 {name=X_54133_ }
C {devices/lab_pin.sym} 68800 -36760 0 0 {name=p68006 lab=_64710_/A }
C {devices/lab_pin.sym} 68800 -36720 0 0 {name=p68007 lab=_66119_/B }
C {devices/lab_pin.sym} 68920 -36740 0 1 {name=p68008 lab=_66119_/X }
C {sky130_stdcells/and2_4.sym} 68860 -36740 0 0 {name=X_66119_ }
C {devices/lab_pin.sym} 68800 -36620 0 0 {name=p68009 lab=_51350_/A }
C {devices/lab_pin.sym} 68800 -36580 0 0 {name=p68010 lab=_50832_/B }
C {devices/lab_pin.sym} 68920 -36600 0 1 {name=p68011 lab=_51345_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -36600 0 0 {name=X_51345_ }
C {devices/lab_pin.sym} 68770 -36470 0 0 {name=p68012 lab=_83556_/CLK }
C {devices/lab_pin.sym} 68770 -36450 0 0 {name=p68013 lab=_84157_/Q }
C {devices/lab_pin.sym} 68950 -36470 0 1 {name=p68014 lab=_82165_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -36460 0 0 {name=X_82165_ }
C {devices/lab_pin.sym} 68820 -36330 0 0 {name=p68015 lab=clkbuf_9_404_0_CLK/X }
C {devices/lab_pin.sym} 68900 -36330 0 1 {name=p68016 lab=_82349_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 68860 -36330 0 0 {name=Xclkbuf_10_809_0_CLK }
C {devices/lab_pin.sym} 68780 -36230 0 0 {name=p68017 lab=_59976_/A }
C {devices/lab_pin.sym} 68780 -36190 0 0 {name=p68018 lab=_62515_/C }
C {devices/lab_pin.sym} 68780 -36150 0 0 {name=p68019 lab=_62515_/A }
C {devices/lab_pin.sym} 68940 -36190 0 1 {name=p68020 lab=_59990_/X }
C {sky130_stdcells/o21a_4.sym} 68860 -36190 0 0 {name=X_59990_ }
C {devices/lab_pin.sym} 68780 -36070 0 0 {name=p68021 lab=_67096_/X }
C {devices/lab_pin.sym} 68780 -36030 0 0 {name=p68022 lab=_67098_/X }
C {devices/lab_pin.sym} 68780 -35990 0 0 {name=p68023 lab=_67026_/X }
C {devices/lab_pin.sym} 68940 -36030 0 1 {name=p68024 lab=_67099_/X }
C {sky130_stdcells/a21o_4.sym} 68860 -36030 0 0 {name=X_67099_ }
C {devices/lab_pin.sym} 68770 -35890 0 0 {name=p68025 lab=_81084_/CLK }
C {devices/lab_pin.sym} 68770 -35870 0 0 {name=p68026 lab=_79833_/X }
C {devices/lab_pin.sym} 68950 -35890 0 1 {name=p68027 lab=_75657_/A }
C {sky130_stdcells/dfxtp_4.sym} 68860 -35880 0 0 {name=X_81116_ }
C {devices/lab_pin.sym} 68800 -35760 0 0 {name=p68028 lab=_58941_/A }
C {devices/lab_pin.sym} 68800 -35720 0 0 {name=p68029 lab=_86372_/Q }
C {devices/lab_pin.sym} 68920 -35740 0 1 {name=p68030 lab=_58941_/Y }
C {sky130_stdcells/nor2_4.sym} 68860 -35740 0 0 {name=X_58941_ }
C {devices/lab_pin.sym} 68780 -35630 0 0 {name=p68031 lab=_85512_/Q }
C {devices/lab_pin.sym} 68780 -35590 0 0 {name=p68032 lab=_54018_/X }
C {devices/lab_pin.sym} 68780 -35550 0 0 {name=p68033 lab=_54063_/Y }
C {devices/lab_pin.sym} 68940 -35590 0 1 {name=p68034 lab=_54064_/Y }
C {sky130_stdcells/o21ai_4.sym} 68860 -35590 0 0 {name=X_54064_ }
C {devices/lab_pin.sym} 68800 -35460 0 0 {name=p68035 lab=_51280_/A }
C {devices/lab_pin.sym} 68800 -35420 0 0 {name=p68036 lab=_49245_/B }
C {devices/lab_pin.sym} 68920 -35440 0 1 {name=p68037 lab=_51276_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -35440 0 0 {name=X_51276_ }
C {devices/lab_pin.sym} 68770 -35310 0 0 {name=p68038 lab=_82906_/CLK }
C {devices/lab_pin.sym} 68770 -35290 0 0 {name=p68039 lab=_86973_/D }
C {devices/lab_pin.sym} 68950 -35310 0 1 {name=p68040 lab=_86973_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -35300 0 0 {name=X_86973_ }
C {devices/lab_pin.sym} 68770 -35170 0 0 {name=p68041 lab=_82860_/CLK }
C {devices/lab_pin.sym} 68770 -35150 0 0 {name=p68042 lab=_82096_/D }
C {devices/lab_pin.sym} 68950 -35170 0 1 {name=p68043 lab=_82096_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -35160 0 0 {name=X_82096_ }
C {devices/lab_pin.sym} 68800 -35060 0 0 {name=p68044 lab=_53019_/A }
C {devices/lab_pin.sym} 68800 -35020 0 0 {name=p68045 lab=_53036_/B }
C {devices/lab_pin.sym} 68800 -34980 0 0 {name=p68046 lab=_53019_/C }
C {devices/lab_pin.sym} 68800 -34940 0 0 {name=p68047 lab=_53015_/D }
C {devices/lab_pin.sym} 68920 -35000 0 1 {name=p68048 lab=_53015_/X }
C {sky130_stdcells/and4_4.sym} 68860 -35000 0 0 {name=X_53015_ }
C {devices/lab_pin.sym} 68820 -34850 0 0 {name=p68049 lab=_50227_/A }
C {devices/lab_pin.sym} 68900 -34850 0 1 {name=p68050 lab=_50227_/X }
C {sky130_stdcells/buf_2.sym} 68860 -34850 0 0 {name=X_50227_ }
C {devices/lab_pin.sym} 68770 -34730 0 0 {name=p68051 lab=_85444_/CLK }
C {devices/lab_pin.sym} 68770 -34710 0 0 {name=p68052 lab=_51910_/Y }
C {devices/lab_pin.sym} 68950 -34730 0 1 {name=p68053 lab=_85924_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -34720 0 0 {name=X_85924_ }
C {devices/lab_pin.sym} 68770 -34590 0 0 {name=p68054 lab=_80697_/CLK }
C {devices/lab_pin.sym} 68770 -34570 0 0 {name=p68055 lab=_75390_/X }
C {devices/lab_pin.sym} 68950 -34590 0 1 {name=p68056 lab=_81047_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -34580 0 0 {name=X_81047_ }
C {devices/lab_pin.sym} 68800 -34460 0 0 {name=p68057 lab=_58872_/A }
C {devices/lab_pin.sym} 68800 -34420 0 0 {name=p68058 lab=_86377_/Q }
C {devices/lab_pin.sym} 68920 -34440 0 1 {name=p68059 lab=_58872_/Y }
C {sky130_stdcells/nor2_4.sym} 68860 -34440 0 0 {name=X_58872_ }
C {devices/lab_pin.sym} 68780 -34350 0 0 {name=p68060 lab=_57801_/X }
C {devices/lab_pin.sym} 68780 -34310 0 0 {name=p68061 lab=_57820_/Y }
C {devices/lab_pin.sym} 68780 -34270 0 0 {name=p68062 lab=_57821_/Y }
C {devices/lab_pin.sym} 68780 -34230 0 0 {name=p68063 lab=_57822_/X }
C {devices/lab_pin.sym} 68780 -34190 0 0 {name=p68064 lab=_57809_/X }
C {devices/lab_pin.sym} 68940 -34270 0 1 {name=p68065 lab=_57823_/X }
C {sky130_stdcells/o32a_4.sym} 68860 -34270 0 0 {name=X_57823_ }
C {devices/lab_pin.sym} 68780 -34140 0 0 {name=p68066 lab=_73228_/A }
C {devices/lab_pin.sym} 68780 -34100 0 0 {name=p68067 lab=_69751_/X }
C {devices/lab_pin.sym} 68780 -34060 0 0 {name=p68068 lab=_69779_/X }
C {devices/lab_pin.sym} 68780 -34020 0 0 {name=p68069 lab=_69808_/Y }
C {devices/lab_pin.sym} 68940 -34080 0 1 {name=p68070 lab=_69809_/X }
C {sky130_stdcells/a211o_4.sym} 68860 -34080 0 0 {name=X_69809_ }
C {devices/lab_pin.sym} 68800 -33940 0 0 {name=p68071 lab=_50153_/A }
C {devices/lab_pin.sym} 68800 -33900 0 0 {name=p68072 lab=_52367_/B }
C {devices/lab_pin.sym} 68920 -33920 0 1 {name=p68073 lab=_50158_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -33920 0 0 {name=X_50158_ }
C {devices/lab_pin.sym} 68770 -33790 0 0 {name=p68074 lab=_85566_/CLK }
C {devices/lab_pin.sym} 68770 -33770 0 0 {name=p68075 lab=_85855_/D }
C {devices/lab_pin.sym} 68950 -33790 0 1 {name=p68076 lab=_85855_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -33780 0 0 {name=X_85855_ }
C {devices/lab_pin.sym} 68800 -33660 0 0 {name=p68077 lab=_74373_/B }
C {devices/lab_pin.sym} 68800 -33620 0 0 {name=p68078 lab=_72820_/B }
C {devices/lab_pin.sym} 68920 -33640 0 1 {name=p68079 lab=_72820_/X }
C {sky130_stdcells/xor2_4.sym} 68860 -33640 0 0 {name=X_72820_ }
C {devices/lab_pin.sym} 68770 -33510 0 0 {name=p68080 lab=_84807_/CLK }
C {devices/lab_pin.sym} 68770 -33490 0 0 {name=p68081 lab=_58710_/Y }
C {devices/lab_pin.sym} 68950 -33510 0 1 {name=p68082 lab=_84806_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -33500 0 0 {name=X_84806_ }
C {devices/lab_pin.sym} 68820 -33370 0 0 {name=p68083 lab=_57687_/A }
C {devices/lab_pin.sym} 68900 -33370 0 1 {name=p68084 lab=_57754_/X }
C {sky130_stdcells/buf_2.sym} 68860 -33370 0 0 {name=X_57754_ }
C {devices/lab_pin.sym} 68820 -33250 0 0 {name=p68085 lab=_42979_/Y }
C {devices/lab_pin.sym} 68900 -33250 0 1 {name=p68086 lab=_87621_/D }
C {sky130_stdcells/inv_2.sym} 68860 -33250 0 0 {name=X_42980_ }
C {devices/lab_pin.sym} 68820 -33130 0 0 {name=p68087 lab=_50064_/A }
C {devices/lab_pin.sym} 68900 -33130 0 1 {name=p68088 lab=_50103_/A }
C {sky130_stdcells/buf_2.sym} 68860 -33130 0 0 {name=X_50089_ }
C {devices/lab_pin.sym} 68820 -33010 0 0 {name=p68089 lab=_48755_/A }
C {devices/lab_pin.sym} 68900 -33010 0 1 {name=p68090 lab=_55072_/A }
C {sky130_stdcells/buf_2.sym} 68860 -33010 0 0 {name=X_54966_ }
C {devices/lab_pin.sym} 68770 -32890 0 0 {name=p68091 lab=_85786_/CLK }
C {devices/lab_pin.sym} 68770 -32870 0 0 {name=p68092 lab=_52615_/Y }
C {devices/lab_pin.sym} 68950 -32890 0 1 {name=p68093 lab=_85786_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -32880 0 0 {name=X_85786_ }
C {devices/lab_pin.sym} 68770 -32750 0 0 {name=p68094 lab=_82998_/CLK }
C {devices/lab_pin.sym} 68770 -32730 0 0 {name=p68095 lab=_82998_/D }
C {devices/lab_pin.sym} 68950 -32750 0 1 {name=p68096 lab=_45575_/A }
C {sky130_stdcells/dfxtp_4.sym} 68860 -32740 0 0 {name=X_82998_ }
C {devices/lab_pin.sym} 68800 -32620 0 0 {name=p68097 lab=_56704_/X }
C {devices/lab_pin.sym} 68800 -32580 0 0 {name=p68098 lab=_56705_/B }
C {devices/lab_pin.sym} 68920 -32600 0 1 {name=p68099 lab=_56705_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -32600 0 0 {name=X_56705_ }
C {devices/lab_pin.sym} 68770 -32470 0 0 {name=p68100 lab=_87525_/CLK }
C {devices/lab_pin.sym} 68770 -32450 0 0 {name=p68101 lab=_87525_/D }
C {devices/lab_pin.sym} 68950 -32470 0 1 {name=p68102 lab=_87525_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -32460 0 0 {name=X_87525_ }
C {devices/lab_pin.sym} 68800 -32340 0 0 {name=p68103 lab=_53898_/A }
C {devices/lab_pin.sym} 68800 -32300 0 0 {name=p68104 lab=_53917_/B }
C {devices/lab_pin.sym} 68920 -32320 0 1 {name=p68105 lab=_53917_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -32320 0 0 {name=X_53917_ }
C {devices/lab_pin.sym} 68820 -32190 0 0 {name=p68106 lab=_42059_/A }
C {devices/lab_pin.sym} 68900 -32190 0 1 {name=p68107 lab=_42013_/A }
C {sky130_stdcells/buf_2.sym} 68860 -32190 0 0 {name=X_41931_ }
C {devices/lab_pin.sym} 68820 -32070 0 0 {name=p68108 lab=_73352_/A }
C {devices/lab_pin.sym} 68900 -32070 0 1 {name=p68109 lab=_73535_/A }
C {sky130_stdcells/buf_2.sym} 68860 -32070 0 0 {name=X_72751_ }
C {devices/lab_pin.sym} 68770 -31950 0 0 {name=p68110 lab=_83402_/CLK }
C {devices/lab_pin.sym} 68770 -31930 0 0 {name=p68111 lab=_84737_/D }
C {devices/lab_pin.sym} 68950 -31950 0 1 {name=p68112 lab=_59423_/A }
C {sky130_stdcells/dfxtp_4.sym} 68860 -31940 0 0 {name=X_84737_ }
C {devices/lab_pin.sym} 68770 -31810 0 0 {name=p68113 lab=_82124_/CLK }
C {devices/lab_pin.sym} 68770 -31790 0 0 {name=p68114 lab=_78043_/Y }
C {devices/lab_pin.sym} 68950 -31810 0 1 {name=p68115 lab=_81949_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -31800 0 0 {name=X_81949_ }
C {devices/lab_pin.sym} 68780 -31690 0 0 {name=p68116 lab=_57677_/X }
C {devices/lab_pin.sym} 68780 -31650 0 0 {name=p68117 lab=_57682_/Y }
C {devices/lab_pin.sym} 68780 -31610 0 0 {name=p68118 lab=_57684_/Y }
C {devices/lab_pin.sym} 68940 -31650 0 1 {name=p68119 lab=_84954_/D }
C {sky130_stdcells/a21oi_4.sym} 68860 -31650 0 0 {name=X_57685_ }
C {devices/lab_pin.sym} 68780 -31530 0 0 {name=p68120 lab=_54895_/Y }
C {devices/lab_pin.sym} 68780 -31490 0 0 {name=p68121 lab=_54882_/X }
C {devices/lab_pin.sym} 68780 -31450 0 0 {name=p68122 lab=_54896_/X }
C {devices/lab_pin.sym} 68940 -31490 0 1 {name=p68123 lab=_85358_/D }
C {sky130_stdcells/a21oi_4.sym} 68860 -31490 0 0 {name=X_54897_ }
C {devices/lab_pin.sym} 68800 -31370 0 0 {name=p68124 lab=_71338_/A }
C {devices/lab_pin.sym} 68800 -31330 0 0 {name=p68125 lab=_71685_/X }
C {devices/lab_pin.sym} 68800 -31290 0 0 {name=p68126 lab=_71815_/B }
C {devices/lab_pin.sym} 68920 -31330 0 1 {name=p68127 lab=_71702_/Y }
C {sky130_stdcells/nand3_4.sym} 68860 -31330 0 0 {name=X_71702_ }
C {devices/lab_pin.sym} 68800 -31200 0 0 {name=p68128 lab=_59423_/Y }
C {devices/lab_pin.sym} 68800 -31160 0 0 {name=p68129 lab=_59424_/B }
C {devices/lab_pin.sym} 68920 -31180 0 1 {name=p68130 lab=_59424_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -31180 0 0 {name=X_59424_ }
C {devices/lab_pin.sym} 68820 -31050 0 0 {name=p68131 lab=_44650_/A }
C {devices/lab_pin.sym} 68900 -31050 0 1 {name=p68132 lab=_44650_/X }
C {sky130_stdcells/buf_2.sym} 68860 -31050 0 0 {name=X_44650_ }
C {devices/lab_pin.sym} 68820 -30930 0 0 {name=p68133 lab=_56567_/Y }
C {devices/lab_pin.sym} 68900 -30930 0 1 {name=p68134 lab=_56636_/X }
C {sky130_stdcells/buf_2.sym} 68860 -30930 0 0 {name=X_56636_ }
C {devices/lab_pin.sym} 68780 -30830 0 0 {name=p68135 lab=_75438_/Y }
C {devices/lab_pin.sym} 68780 -30790 0 0 {name=p68136 lab=_75466_/X }
C {devices/lab_pin.sym} 68780 -30750 0 0 {name=p68137 lab=_75508_/B }
C {devices/lab_pin.sym} 68940 -30790 0 1 {name=p68138 lab=_75470_/Y }
C {sky130_stdcells/a21boi_4.sym} 68860 -30790 0 0 {name=X_75470_ }
C {devices/lab_pin.sym} 68820 -30650 0 0 {name=p68139 lab=_43012_/B }
C {devices/lab_pin.sym} 68900 -30650 0 1 {name=p68140 lab=_41862_/Y }
C {sky130_stdcells/inv_2.sym} 68860 -30650 0 0 {name=X_41862_ }
C {devices/lab_pin.sym} 68770 -30530 0 0 {name=p68141 lab=_87210_/CLK }
C {devices/lab_pin.sym} 68770 -30510 0 0 {name=p68142 lab=_87456_/D }
C {devices/lab_pin.sym} 68950 -30530 0 1 {name=p68143 lab=_87456_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -30520 0 0 {name=X_87456_ }
C {devices/lab_pin.sym} 68800 -30400 0 0 {name=p68144 lab=_53848_/A }
C {devices/lab_pin.sym} 68800 -30360 0 0 {name=p68145 lab=_53848_/B }
C {devices/lab_pin.sym} 68920 -30380 0 1 {name=p68146 lab=_53848_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -30380 0 0 {name=X_53848_ }
C {devices/lab_pin.sym} 68780 -30270 0 0 {name=p68147 lab=_70225_/C }
C {devices/lab_pin.sym} 68780 -30230 0 0 {name=p68148 lab=_72672_/X }
C {devices/lab_pin.sym} 68780 -30190 0 0 {name=p68149 lab=_72681_/Y }
C {devices/lab_pin.sym} 68940 -30230 0 1 {name=p68150 lab=_72682_/X }
C {sky130_stdcells/a21bo_4.sym} 68860 -30230 0 0 {name=X_72682_ }
C {devices/lab_pin.sym} 68770 -30090 0 0 {name=p68151 lab=_84668_/CLK }
C {devices/lab_pin.sym} 68770 -30070 0 0 {name=p68152 lab=_84668_/D }
C {devices/lab_pin.sym} 68950 -30090 0 1 {name=p68153 lab=_60064_/C }
C {sky130_stdcells/dfxtp_4.sym} 68860 -30080 0 0 {name=X_84668_ }
C {devices/lab_pin.sym} 68820 -29950 0 0 {name=p68154 lab=_43600_/X }
C {devices/lab_pin.sym} 68900 -29950 0 1 {name=p68155 lab=_43601_/Y }
C {sky130_stdcells/inv_2.sym} 68860 -29950 0 0 {name=X_43601_ }
C {devices/lab_pin.sym} 68800 -29850 0 0 {name=p68156 lab=_48487_/A }
C {devices/lab_pin.sym} 68800 -29810 0 0 {name=p68157 lab=_74420_/X }
C {devices/lab_pin.sym} 68800 -29770 0 0 {name=p68158 lab=_74421_/C }
C {devices/lab_pin.sym} 68920 -29810 0 1 {name=p68159 lab=_74421_/X }
C {sky130_stdcells/and3_4.sym} 68860 -29810 0 0 {name=X_74421_ }
C {devices/lab_pin.sym} 68770 -29670 0 0 {name=p68160 lab=_86119_/CLK }
C {devices/lab_pin.sym} 68770 -29650 0 0 {name=p68161 lab=_86407_/D }
C {devices/lab_pin.sym} 68950 -29670 0 1 {name=p68162 lab=_65279_/B }
C {sky130_stdcells/dfxtp_4.sym} 68860 -29660 0 0 {name=X_86407_ }
C {devices/lab_pin.sym} 68780 -29550 0 0 {name=p68163 lab=_40783_/X }
C {devices/lab_pin.sym} 68780 -29510 0 0 {name=p68164 lab=_82295_/Q }
C {devices/lab_pin.sym} 68780 -29470 0 0 {name=p68165 lab=_40812_/X }
C {devices/lab_pin.sym} 68940 -29510 0 1 {name=p68166 lab=_40814_/A }
C {sky130_stdcells/o21a_4.sym} 68860 -29510 0 0 {name=X_40813_ }
C {devices/lab_pin.sym} 68780 -29390 0 0 {name=p68167 lab=_59292_/X }
C {devices/lab_pin.sym} 68780 -29350 0 0 {name=p68168 lab=_85636_/Q }
C {devices/lab_pin.sym} 68780 -29310 0 0 {name=p68169 lab=_59205_/X }
C {devices/lab_pin.sym} 68940 -29350 0 1 {name=p68170 lab=_59355_/X }
C {sky130_stdcells/o21a_4.sym} 68860 -29350 0 0 {name=X_59355_ }
C {devices/lab_pin.sym} 68780 -29230 0 0 {name=p68171 lab=_59480_/Y }
C {devices/lab_pin.sym} 68780 -29190 0 0 {name=p68172 lab=_71628_/X }
C {devices/lab_pin.sym} 68780 -29150 0 0 {name=p68173 lab=_71632_/Y }
C {devices/lab_pin.sym} 68940 -29190 0 1 {name=p68174 lab=_71633_/Y }
C {sky130_stdcells/o21ai_4.sym} 68860 -29190 0 0 {name=X_71633_ }
C {devices/lab_pin.sym} 68770 -29050 0 0 {name=p68175 lab=_85566_/CLK }
C {devices/lab_pin.sym} 68770 -29030 0 0 {name=p68176 lab=_71065_/Y }
C {devices/lab_pin.sym} 68950 -29050 0 1 {name=p68177 lab=_83619_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -29040 0 0 {name=X_83619_ }
C {devices/lab_pin.sym} 68820 -28910 0 0 {name=p68178 lab=_44134_/X }
C {devices/lab_pin.sym} 68900 -28910 0 1 {name=p68179 lab=_56567_/Y }
C {sky130_stdcells/inv_2.sym} 68860 -28910 0 0 {name=X_56567_ }
C {devices/lab_pin.sym} 68820 -28790 0 0 {name=p68180 lab=_87046_/Q }
C {devices/lab_pin.sym} 68900 -28790 0 1 {name=p68181 lab=_44581_/Y }
C {sky130_stdcells/inv_2.sym} 68860 -28790 0 0 {name=X_44581_ }
C {devices/lab_pin.sym} 68770 -28670 0 0 {name=p68182 lab=_87141_/CLK }
C {devices/lab_pin.sym} 68770 -28650 0 0 {name=p68183 lab=_43505_/Y }
C {devices/lab_pin.sym} 68950 -28670 0 1 {name=p68184 lab=_87387_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -28660 0 0 {name=X_87387_ }
C {devices/lab_pin.sym} 68780 -28550 0 0 {name=p68185 lab=_53777_/Y }
C {devices/lab_pin.sym} 68780 -28510 0 0 {name=p68186 lab=_53696_/X }
C {devices/lab_pin.sym} 68780 -28470 0 0 {name=p68187 lab=_53778_/Y }
C {devices/lab_pin.sym} 68940 -28510 0 1 {name=p68188 lab=_85570_/D }
C {sky130_stdcells/a21boi_4.sym} 68860 -28510 0 0 {name=X_53779_ }
C {devices/lab_pin.sym} 68780 -28410 0 0 {name=p68189 lab=_41753_/X }
C {devices/lab_pin.sym} 68780 -28370 0 0 {name=p68190 lab=_41754_/X }
C {devices/lab_pin.sym} 68780 -28330 0 0 {name=p68191 lab=_41791_/X }
C {devices/lab_pin.sym} 68780 -28290 0 0 {name=p68192 lab=_88148_/Q }
C {devices/lab_pin.sym} 68780 -28250 0 0 {name=p68193 lab=_41792_/X }
C {devices/lab_pin.sym} 68940 -28330 0 1 {name=p68194 lab=_41793_/Y }
C {sky130_stdcells/o32ai_4.sym} 68860 -28330 0 0 {name=X_41793_ }
C {devices/lab_pin.sym} 68770 -28170 0 0 {name=p68195 lab=_84606_/CLK }
C {devices/lab_pin.sym} 68770 -28150 0 0 {name=p68196 lab=_84599_/D }
C {devices/lab_pin.sym} 68950 -28170 0 1 {name=p68197 lab=_79139_/A }
C {sky130_stdcells/dfxtp_4.sym} 68860 -28160 0 0 {name=X_84599_ }
C {devices/lab_pin.sym} 68780 -28050 0 0 {name=p68198 lab=_46301_/X }
C {devices/lab_pin.sym} 68780 -28010 0 0 {name=p68199 lab=_82940_/Q }
C {devices/lab_pin.sym} 68780 -27970 0 0 {name=p68200 lab=_46319_/Y }
C {devices/lab_pin.sym} 68940 -28010 0 1 {name=p68201 lab=_53969_/A }
C {sky130_stdcells/o21ai_4.sym} 68860 -28010 0 0 {name=X_46320_ }
C {devices/lab_pin.sym} 68780 -27890 0 0 {name=p68202 lab=_58282_/X }
C {devices/lab_pin.sym} 68780 -27850 0 0 {name=p68203 lab=_58303_/Y }
C {devices/lab_pin.sym} 68780 -27810 0 0 {name=p68204 lab=_58305_/Y }
C {devices/lab_pin.sym} 68940 -27850 0 1 {name=p68205 lab=_58306_/Y }
C {sky130_stdcells/a21oi_4.sym} 68860 -27850 0 0 {name=X_58306_ }
C {devices/lab_pin.sym} 68800 -27720 0 0 {name=p68206 lab=_77149_/A }
C {devices/lab_pin.sym} 68800 -27680 0 0 {name=p68207 lab=_81918_/Q }
C {devices/lab_pin.sym} 68920 -27700 0 1 {name=p68208 lab=_77154_/A }
C {sky130_stdcells/xor2_4.sym} 68860 -27700 0 0 {name=X_77140_ }
C {devices/lab_pin.sym} 68780 -27590 0 0 {name=p68209 lab=_55509_/X }
C {devices/lab_pin.sym} 68780 -27550 0 0 {name=p68210 lab=_55515_/X }
C {devices/lab_pin.sym} 68780 -27510 0 0 {name=p68211 lab=_55517_/X }
C {devices/lab_pin.sym} 68940 -27550 0 1 {name=p68212 lab=_55536_/A }
C {sky130_stdcells/a21o_4.sym} 68860 -27550 0 0 {name=X_55518_ }
C {devices/lab_pin.sym} 68820 -27410 0 0 {name=p68213 lab=_53443_/A }
C {devices/lab_pin.sym} 68900 -27410 0 1 {name=p68214 lab=_43532_/X }
C {sky130_stdcells/buf_2.sym} 68860 -27410 0 0 {name=X_43532_ }
C {devices/lab_pin.sym} 68780 -27310 0 0 {name=p68215 lab=_83087_/Q }
C {devices/lab_pin.sym} 68780 -27270 0 0 {name=p68216 lab=_74340_/X }
C {devices/lab_pin.sym} 68780 -27230 0 0 {name=p68217 lab=_74351_/Y }
C {devices/lab_pin.sym} 68940 -27270 0 1 {name=p68218 lab=_74352_/X }
C {sky130_stdcells/a21bo_4.sym} 68860 -27270 0 0 {name=X_74352_ }
C {sky130_stdcells/decap_3.sym} 68860 -27100 0 0 {name=XPHY_9 }
C {devices/lab_pin.sym} 68770 -26950 0 0 {name=p68219 lab=_86340_/CLK }
C {devices/lab_pin.sym} 68770 -26930 0 0 {name=p68220 lab=_86338_/D }
C {devices/lab_pin.sym} 68950 -26950 0 1 {name=p68221 lab=_59376_/B }
C {sky130_stdcells/dfxtp_4.sym} 68860 -26940 0 0 {name=X_86338_ }
C {devices/lab_pin.sym} 68820 -26810 0 0 {name=p68222 lab=_40832_/A }
C {devices/lab_pin.sym} 68900 -26810 0 1 {name=p68223 lab=_40744_/X }
C {sky130_stdcells/buf_2.sym} 68860 -26810 0 0 {name=X_40744_ }
C {devices/lab_pin.sym} 68820 -26690 0 0 {name=p68224 lab=_59286_/A }
C {devices/lab_pin.sym} 68900 -26690 0 1 {name=p68225 lab=_59286_/X }
C {sky130_stdcells/buf_2.sym} 68860 -26690 0 0 {name=X_59286_ }
C {devices/lab_pin.sym} 68780 -26590 0 0 {name=p68226 lab=_71557_/X }
C {devices/lab_pin.sym} 68780 -26550 0 0 {name=p68227 lab=_83455_/Q }
C {devices/lab_pin.sym} 68780 -26510 0 0 {name=p68228 lab=_71563_/Y }
C {devices/lab_pin.sym} 68940 -26550 0 1 {name=p68229 lab=_71564_/X }
C {sky130_stdcells/a21o_4.sym} 68860 -26550 0 0 {name=X_71564_ }
C {devices/lab_pin.sym} 68780 -26430 0 0 {name=p68230 lab=_56070_/X }
C {devices/lab_pin.sym} 68780 -26390 0 0 {name=p68231 lab=_56483_/X }
C {devices/lab_pin.sym} 68780 -26350 0 0 {name=p68232 lab=_56497_/Y }
C {devices/lab_pin.sym} 68940 -26390 0 1 {name=p68233 lab=_85173_/D }
C {sky130_stdcells/o21ai_4.sym} 68860 -26390 0 0 {name=X_56498_ }
C {devices/lab_pin.sym} 68780 -26270 0 0 {name=p68234 lab=_44573_/Y }
C {devices/lab_pin.sym} 68780 -26230 0 0 {name=p68235 lab=_73006_/X }
C {devices/lab_pin.sym} 68780 -26190 0 0 {name=p68236 lab=_73302_/Y }
C {devices/lab_pin.sym} 68940 -26230 0 1 {name=p68237 lab=_73303_/X }
C {sky130_stdcells/a21o_4.sym} 68860 -26230 0 0 {name=X_73303_ }
C {devices/lab_pin.sym} 68820 -26090 0 0 {name=p68238 lab=_47002_/A }
C {devices/lab_pin.sym} 68900 -26090 0 1 {name=p68239 lab=_57563_/A }
C {sky130_stdcells/buf_2.sym} 68860 -26090 0 0 {name=X_46251_ }
C {sky130_stdcells/decap_3.sym} 68860 -25940 0 0 {name=XPHY_630 }
C {devices/lab_pin.sym} 68780 -25810 0 0 {name=p68240 lab=_57659_/Y }
C {devices/lab_pin.sym} 68780 -25770 0 0 {name=p68241 lab=_70501_/X }
C {devices/lab_pin.sym} 68780 -25730 0 0 {name=p68242 lab=_70514_/Y }
C {devices/lab_pin.sym} 68940 -25770 0 1 {name=p68243 lab=_83759_/D }
C {sky130_stdcells/o21ai_4.sym} 68860 -25770 0 0 {name=X_70515_ }
C {devices/lab_pin.sym} 68820 -25630 0 0 {name=p68244 lab=_84900_/Q }
C {devices/lab_pin.sym} 68900 -25630 0 1 {name=p68245 lab=_58237_/X }
C {sky130_stdcells/buf_2.sym} 68860 -25630 0 0 {name=X_58237_ }
C {devices/lab_pin.sym} 68780 -25530 0 0 {name=p68246 lab=_77062_/Y }
C {devices/lab_pin.sym} 68780 -25490 0 0 {name=p68247 lab=_77069_/Y }
C {devices/lab_pin.sym} 68780 -25450 0 0 {name=p68248 lab=_77070_/Y }
C {devices/lab_pin.sym} 68940 -25490 0 1 {name=p68249 lab=_77072_/B }
C {sky130_stdcells/o21a_4.sym} 68860 -25490 0 0 {name=X_77071_ }
C {devices/lab_pin.sym} 68780 -25380 0 0 {name=p68250 lab=_41643_/X }
C {devices/lab_pin.sym} 68780 -25340 0 0 {name=p68251 lab=_43446_/X }
C {devices/lab_pin.sym} 68780 -25300 0 0 {name=p68252 lab=_87409_/Q }
C {devices/lab_pin.sym} 68780 -25260 0 0 {name=p68253 lab=_43447_/X }
C {devices/lab_pin.sym} 68940 -25320 0 1 {name=p68254 lab=_87409_/D }
C {sky130_stdcells/a2bb2o_4.sym} 68860 -25320 0 0 {name=X_43463_ }
C {devices/lab_pin.sym} 68780 -25190 0 0 {name=p68255 lab=_55445_/A }
C {devices/lab_pin.sym} 68780 -25150 0 0 {name=p68256 lab=_55354_/Y }
C {devices/lab_pin.sym} 68780 -25110 0 0 {name=p68257 lab=_55445_/C }
C {devices/lab_pin.sym} 68940 -25150 0 1 {name=p68258 lab=_55449_/Y }
C {sky130_stdcells/a21boi_4.sym} 68860 -25150 0 0 {name=X_55449_ }
C {devices/lab_pin.sym} 68780 -25030 0 0 {name=p68259 lab=_70134_/C }
C {devices/lab_pin.sym} 68780 -24990 0 0 {name=p68260 lab=_74003_/B }
C {devices/lab_pin.sym} 68780 -24950 0 0 {name=p68261 lab=_74282_/X }
C {devices/lab_pin.sym} 68940 -24990 0 1 {name=p68262 lab=_83114_/D }
C {sky130_stdcells/o21ai_4.sym} 68860 -24990 0 0 {name=X_74283_ }
C {devices/lab_pin.sym} 68770 -24850 0 0 {name=p68263 lab=_85562_/CLK }
C {devices/lab_pin.sym} 68770 -24830 0 0 {name=p68264 lab=_86269_/D }
C {devices/lab_pin.sym} 68950 -24850 0 1 {name=p68265 lab=_86269_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -24840 0 0 {name=X_86269_ }
C {sky130_stdcells/decap_3.sym} 68860 -24680 0 0 {name=XPHY_641 }
C {devices/lab_pin.sym} 68820 -24530 0 0 {name=p68266 lab=_40736_/A }
C {devices/lab_pin.sym} 68900 -24530 0 1 {name=p68267 lab=_40710_/B }
C {sky130_stdcells/buf_2.sym} 68860 -24530 0 0 {name=X_40675_ }
C {devices/lab_pin.sym} 68780 -24430 0 0 {name=p68268 lab=_71487_/X }
C {devices/lab_pin.sym} 68780 -24390 0 0 {name=p68269 lab=_83479_/Q }
C {devices/lab_pin.sym} 68780 -24350 0 0 {name=p68270 lab=_71494_/X }
C {devices/lab_pin.sym} 68940 -24390 0 1 {name=p68271 lab=_83479_/D }
C {sky130_stdcells/a21o_4.sym} 68860 -24390 0 0 {name=X_71495_ }
C {sky130_stdcells/decap_3.sym} 68860 -24220 0 0 {name=XPHY_652 }
C {sky130_stdcells/decap_3.sym} 68860 -24040 0 0 {name=XPHY_663 }
C {devices/lab_pin.sym} 68820 -23890 0 0 {name=p68272 lab=_45350_/A }
C {devices/lab_pin.sym} 68900 -23890 0 1 {name=p68273 lab=_45202_/X }
C {sky130_stdcells/buf_2.sym} 68860 -23890 0 0 {name=X_45202_ }
C {devices/lab_pin.sym} 68780 -23790 0 0 {name=p68274 lab=_76013_/Y }
C {devices/lab_pin.sym} 68780 -23750 0 0 {name=p68275 lab=_76020_/Y }
C {devices/lab_pin.sym} 68780 -23710 0 0 {name=p68276 lab=_76021_/Y }
C {devices/lab_pin.sym} 68940 -23750 0 1 {name=p68277 lab=_76023_/B }
C {sky130_stdcells/o21a_4.sym} 68860 -23750 0 0 {name=X_76022_ }
C {devices/lab_pin.sym} 68820 -23610 0 0 {name=p68278 lab=_42373_/X }
C {devices/lab_pin.sym} 68900 -23610 0 1 {name=p68279 lab=_42414_/X }
C {sky130_stdcells/buf_2.sym} 68860 -23610 0 0 {name=X_42414_ }
C {devices/lab_pin.sym} 68770 -23490 0 0 {name=p68280 lab=_88006_/CLK }
C {devices/lab_pin.sym} 68770 -23470 0 0 {name=p68281 lab=_42153_/X }
C {devices/lab_pin.sym} 68950 -23490 0 1 {name=p68282 lab=_88008_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -23480 0 0 {name=X_88008_ }
C {sky130_stdcells/decap_3.sym} 68860 -23320 0 0 {name=XPHY_674 }
C {devices/lab_pin.sym} 68780 -23200 0 0 {name=p68283 lab=_73062_/X }
C {devices/lab_pin.sym} 68780 -23160 0 0 {name=p68284 lab=_86191_/Q }
C {devices/lab_pin.sym} 68780 -23120 0 0 {name=p68285 lab=_73205_/X }
C {devices/lab_pin.sym} 68780 -23080 0 0 {name=p68286 lab=_73233_/X }
C {devices/lab_pin.sym} 68940 -23140 0 1 {name=p68287 lab=_73234_/X }
C {sky130_stdcells/a211o_4.sym} 68860 -23140 0 0 {name=X_73234_ }
C {devices/lab_pin.sym} 68780 -23010 0 0 {name=p68288 lab=_47969_/B }
C {devices/lab_pin.sym} 68780 -22970 0 0 {name=p68289 lab=_70421_/Y }
C {devices/lab_pin.sym} 68780 -22930 0 0 {name=p68290 lab=_70445_/Y }
C {devices/lab_pin.sym} 68940 -22970 0 1 {name=p68291 lab=_70446_/Y }
C {sky130_stdcells/o21ai_4.sym} 68860 -22970 0 0 {name=X_70446_ }
C {devices/lab_pin.sym} 68780 -22860 0 0 {name=p68292 lab=_44905_/X }
C {devices/lab_pin.sym} 68780 -22820 0 0 {name=p68293 lab=_46162_/D }
C {devices/lab_pin.sym} 68780 -22780 0 0 {name=p68294 lab=_57657_/B }
C {devices/lab_pin.sym} 68780 -22740 0 0 {name=p68295 lab=_46181_/Y }
C {devices/lab_pin.sym} 68940 -22800 0 1 {name=p68296 lab=_86765_/D }
C {sky130_stdcells/a211o_4.sym} 68860 -22800 0 0 {name=X_46182_ }
C {devices/lab_pin.sym} 68800 -22660 0 0 {name=p68297 lab=_64272_/A }
C {devices/lab_pin.sym} 68800 -22620 0 0 {name=p68298 lab=_58160_/B }
C {devices/lab_pin.sym} 68920 -22640 0 1 {name=p68299 lab=_58168_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -22640 0 0 {name=X_58168_ }
C {sky130_stdcells/decap_3.sym} 68860 -22480 0 0 {name=XPHY_685 }
C {devices/lab_pin.sym} 68780 -22360 0 0 {name=p68300 lab=_41461_/X }
C {devices/lab_pin.sym} 68780 -22320 0 0 {name=p68301 lab=_43386_/X }
C {devices/lab_pin.sym} 68780 -22280 0 0 {name=p68302 lab=_87443_/Q }
C {devices/lab_pin.sym} 68780 -22240 0 0 {name=p68303 lab=_43388_/X }
C {devices/lab_pin.sym} 68940 -22300 0 1 {name=p68304 lab=_87443_/D }
C {sky130_stdcells/a2bb2o_4.sym} 68860 -22300 0 0 {name=X_43394_ }
C {sky130_stdcells/decap_3.sym} 68860 -22120 0 0 {name=XPHY_696 }
C {devices/lab_pin.sym} 68780 -21990 0 0 {name=p68305 lab=_56233_/C }
C {devices/lab_pin.sym} 68780 -21950 0 0 {name=p68306 lab=_45073_/X }
C {devices/lab_pin.sym} 68780 -21910 0 0 {name=p68307 lab=_45132_/X }
C {devices/lab_pin.sym} 68940 -21950 0 1 {name=p68308 lab=_45133_/Y }
C {sky130_stdcells/o21ai_4.sym} 68860 -21950 0 0 {name=X_45133_ }
C {devices/lab_pin.sym} 68780 -21840 0 0 {name=p68309 lab=_57109_/X }
C {devices/lab_pin.sym} 68780 -21800 0 0 {name=p68310 lab=_56634_/X }
C {devices/lab_pin.sym} 68780 -21760 0 0 {name=p68311 lab=_85077_/Q }
C {devices/lab_pin.sym} 68780 -21720 0 0 {name=p68312 lab=_57110_/X }
C {devices/lab_pin.sym} 68940 -21780 0 1 {name=p68313 lab=_85077_/D }
C {sky130_stdcells/a2bb2o_4.sym} 68860 -21780 0 0 {name=X_57119_ }
C {devices/lab_pin.sym} 68780 -21660 0 0 {name=p68314 lab=_41701_/X }
C {devices/lab_pin.sym} 68780 -21620 0 0 {name=p68315 lab=_42342_/X }
C {devices/lab_pin.sym} 68780 -21580 0 0 {name=p68316 lab=_87910_/Q }
C {devices/lab_pin.sym} 68780 -21540 0 0 {name=p68317 lab=_42343_/X }
C {devices/lab_pin.sym} 68940 -21600 0 1 {name=p68318 lab=_87910_/D }
C {sky130_stdcells/a2bb2o_4.sym} 68860 -21600 0 0 {name=X_42345_ }
C {devices/lab_pin.sym} 68820 -21450 0 0 {name=p68319 lab=_73165_/A }
C {devices/lab_pin.sym} 68900 -21450 0 1 {name=p68320 lab=_73386_/A }
C {sky130_stdcells/buf_2.sym} 68860 -21450 0 0 {name=X_73165_ }
C {devices/lab_pin.sym} 68780 -21370 0 0 {name=p68321 lab=_58079_/X }
C {devices/lab_pin.sym} 68780 -21330 0 0 {name=p68322 lab=_58096_/Y }
C {devices/lab_pin.sym} 68780 -21290 0 0 {name=p68323 lab=_58097_/Y }
C {devices/lab_pin.sym} 68780 -21250 0 0 {name=p68324 lab=_58098_/X }
C {devices/lab_pin.sym} 68780 -21210 0 0 {name=p68325 lab=_58083_/X }
C {devices/lab_pin.sym} 68940 -21290 0 1 {name=p68326 lab=_58099_/X }
C {sky130_stdcells/o32a_4.sym} 68860 -21290 0 0 {name=X_58099_ }
C {devices/lab_pin.sym} 68820 -21130 0 0 {name=p68327 lab=DATA_TO_HASH[5] }
C {devices/lab_pin.sym} 68900 -21130 0 1 {name=p68328 lab=_71054_/A }
C {sky130_stdcells/buf_2.sym} 68860 -21130 0 0 {name=X_70377_ }
C {devices/lab_pin.sym} 68820 -21010 0 0 {name=p68329 lab=_83246_/CLK }
C {devices/lab_pin.sym} 68900 -21010 0 1 {name=p68330 lab=_84897_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 68860 -21010 0 0 {name=Xclkbuf_opt_1_CLK }
C {devices/lab_pin.sym} 68800 -20910 0 0 {name=p68331 lab=_60513_/A }
C {devices/lab_pin.sym} 68800 -20870 0 0 {name=p68332 lab=_61587_/B }
C {devices/lab_pin.sym} 68800 -20830 0 0 {name=p68333 lab=_79998_/A }
C {devices/lab_pin.sym} 68920 -20870 0 1 {name=p68334 lab=_60130_/X }
C {sky130_stdcells/or3_4.sym} 68860 -20870 0 0 {name=X_60130_ }
C {devices/lab_pin.sym} 68800 -20740 0 0 {name=p68335 lab=_59326_/X }
C {devices/lab_pin.sym} 68800 -20700 0 0 {name=p68336 lab=_72116_/B }
C {devices/lab_pin.sym} 68920 -20720 0 1 {name=p68337 lab=_72116_/Y }
C {sky130_stdcells/nor2_4.sym} 68860 -20720 0 0 {name=X_72116_ }
C {devices/lab_pin.sym} 68780 -20610 0 0 {name=p68338 lab=_86295_/Q }
C {devices/lab_pin.sym} 68780 -20570 0 0 {name=p68339 lab=_49934_/X }
C {devices/lab_pin.sym} 68780 -20530 0 0 {name=p68340 lab=_49940_/Y }
C {devices/lab_pin.sym} 68940 -20570 0 1 {name=p68341 lab=_49941_/Y }
C {sky130_stdcells/o21ai_4.sym} 68860 -20570 0 0 {name=X_49941_ }
C {devices/lab_pin.sym} 68780 -20450 0 0 {name=p68342 lab=_45058_/Y }
C {devices/lab_pin.sym} 68780 -20410 0 0 {name=p68343 lab=_45062_/Y }
C {devices/lab_pin.sym} 68780 -20370 0 0 {name=p68344 lab=_45063_/X }
C {devices/lab_pin.sym} 68940 -20410 0 1 {name=p68345 lab=_45064_/X }
C {sky130_stdcells/a21o_4.sym} 68860 -20410 0 0 {name=X_45064_ }
C {devices/lab_pin.sym} 68820 -20270 0 0 {name=p68346 lab=_42276_/A }
C {devices/lab_pin.sym} 68900 -20270 0 1 {name=p68347 lab=_42276_/X }
C {sky130_stdcells/buf_2.sym} 68860 -20270 0 0 {name=X_42276_ }
C {devices/lab_pin.sym} 68820 -20150 0 0 {name=p68348 lab=clkbuf_7_63_0_CLK/A }
C {devices/lab_pin.sym} 68900 -20150 0 1 {name=p68349 lab=clkbuf_7_62_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 68860 -20150 0 0 {name=Xclkbuf_7_62_0_CLK }
C {devices/lab_pin.sym} 68800 -20040 0 0 {name=p68350 lab=_73239_/A }
C {devices/lab_pin.sym} 68800 -20000 0 0 {name=p68351 lab=_73096_/B }
C {devices/lab_pin.sym} 68920 -20020 0 1 {name=p68352 lab=_73096_/X }
C {sky130_stdcells/and2_4.sym} 68860 -20020 0 0 {name=X_73096_ }
C {devices/lab_pin.sym} 68820 -19890 0 0 {name=p68353 lab=_82077_/Q }
C {devices/lab_pin.sym} 68900 -19890 0 1 {name=p68354 lab=_77975_/A }
C {sky130_stdcells/inv_2.sym} 68860 -19890 0 0 {name=X_77973_ }
C {devices/lab_pin.sym} 68820 -19770 0 0 {name=p68355 lab=_45920_/A }
C {devices/lab_pin.sym} 68900 -19770 0 1 {name=p68356 lab=_68617_/A }
C {sky130_stdcells/buf_2.sym} 68860 -19770 0 0 {name=X_44015_ }
C {devices/lab_pin.sym} 68800 -19660 0 0 {name=p68357 lab=_84217_/Q }
C {devices/lab_pin.sym} 68800 -19620 0 0 {name=p68358 lab=_72313_/A }
C {devices/lab_pin.sym} 68920 -19640 0 1 {name=p68359 lab=_79712_/X }
C {sky130_stdcells/xor2_4.sym} 68860 -19640 0 0 {name=X_79712_ }
C {devices/lab_pin.sym} 68820 -19510 0 0 {name=p68360 lab=_41227_/A }
C {devices/lab_pin.sym} 68900 -19510 0 1 {name=p68361 lab=_41227_/Y }
C {sky130_stdcells/inv_2.sym} 68860 -19510 0 0 {name=X_41227_ }
C {devices/lab_pin.sym} 68780 -19410 0 0 {name=p68362 lab=_59968_/A }
C {devices/lab_pin.sym} 68780 -19370 0 0 {name=p68363 lab=_59968_/B }
C {devices/lab_pin.sym} 68780 -19330 0 0 {name=p68364 lab=_59802_/X }
C {devices/lab_pin.sym} 68940 -19370 0 1 {name=p68365 lab=_60061_/Y }
C {sky130_stdcells/a21oi_4.sym} 68860 -19370 0 0 {name=X_60061_ }
C {devices/lab_pin.sym} 68780 -19250 0 0 {name=p68366 lab=_83295_/Q }
C {devices/lab_pin.sym} 68780 -19210 0 0 {name=p68367 lab=_72001_/X }
C {devices/lab_pin.sym} 68780 -19170 0 0 {name=p68368 lab=_72046_/Y }
C {devices/lab_pin.sym} 68940 -19210 0 1 {name=p68369 lab=_72047_/Y }
C {sky130_stdcells/o21ai_4.sym} 68860 -19210 0 0 {name=X_72047_ }
C {devices/lab_pin.sym} 68820 -19070 0 0 {name=p68370 lab=_76924_/A }
C {devices/lab_pin.sym} 68900 -19070 0 1 {name=p68371 lab=_81471_/D }
C {sky130_stdcells/inv_2.sym} 68860 -19070 0 0 {name=X_76924_ }
C {devices/lab_pin.sym} 68800 -18980 0 0 {name=p68372 lab=_49893_/A }
C {devices/lab_pin.sym} 68800 -18940 0 0 {name=p68373 lab=_49884_/B }
C {devices/lab_pin.sym} 68800 -18900 0 0 {name=p68374 lab=_49862_/C }
C {devices/lab_pin.sym} 68800 -18860 0 0 {name=p68375 lab=_53084_/D }
C {devices/lab_pin.sym} 68920 -18920 0 1 {name=p68376 lab=_49872_/X }
C {sky130_stdcells/and4_4.sym} 68860 -18920 0 0 {name=X_49872_ }
C {devices/lab_pin.sym} 68800 -18780 0 0 {name=p68377 lab=_50069_/A }
C {devices/lab_pin.sym} 68800 -18740 0 0 {name=p68378 lab=_48823_/B }
C {devices/lab_pin.sym} 68920 -18760 0 1 {name=p68379 lab=_48823_/X }
C {sky130_stdcells/and2_4.sym} 68860 -18760 0 0 {name=X_48823_ }
C {devices/lab_pin.sym} 68780 -18650 0 0 {name=p68380 lab=_79619_/A }
C {devices/lab_pin.sym} 68780 -18610 0 0 {name=p68381 lab=_79642_/D }
C {devices/lab_pin.sym} 68780 -18570 0 0 {name=p68382 lab=_79642_/B }
C {devices/lab_pin.sym} 68940 -18610 0 1 {name=p68383 lab=_79643_/X }
C {sky130_stdcells/a21bo_4.sym} 68860 -18610 0 0 {name=X_79643_ }
C {devices/lab_pin.sym} 68780 -18500 0 0 {name=p68384 lab=_41157_/X }
C {devices/lab_pin.sym} 68780 -18460 0 0 {name=p68385 lab=_41152_/X }
C {devices/lab_pin.sym} 68780 -18420 0 0 {name=p68386 lab=_88267_/Q }
C {devices/lab_pin.sym} 68780 -18380 0 0 {name=p68387 lab=_41153_/X }
C {devices/lab_pin.sym} 68940 -18440 0 1 {name=p68388 lab=_88267_/D }
C {sky130_stdcells/a2bb2o_4.sym} 68860 -18440 0 0 {name=X_41158_ }
C {devices/lab_pin.sym} 68800 -18300 0 0 {name=p68389 lab=_76855_/A }
C {devices/lab_pin.sym} 68800 -18260 0 0 {name=p68390 lab=_81464_/D }
C {devices/lab_pin.sym} 68920 -18280 0 1 {name=p68391 lab=_81560_/D }
C {sky130_stdcells/xor2_4.sym} 68860 -18280 0 0 {name=X_76855_ }
C {devices/lab_pin.sym} 68800 -18180 0 0 {name=p68392 lab=_63424_/B }
C {devices/lab_pin.sym} 68800 -18140 0 0 {name=p68393 lab=_63820_/B }
C {devices/lab_pin.sym} 68800 -18100 0 0 {name=p68394 lab=_63753_/C }
C {devices/lab_pin.sym} 68800 -18060 0 0 {name=p68395 lab=_63820_/D }
C {devices/lab_pin.sym} 68920 -18120 0 1 {name=p68396 lab=_63823_/B }
C {sky130_stdcells/nand4_4.sym} 68860 -18120 0 0 {name=X_63820_ }
C {devices/lab_pin.sym} 68800 -17980 0 0 {name=p68397 lab=_81100_/Q }
C {devices/lab_pin.sym} 68800 -17940 0 0 {name=p68398 lab=_75806_/B }
C {devices/lab_pin.sym} 68920 -17960 0 1 {name=p68399 lab=_80796_/D }
C {sky130_stdcells/xor2_4.sym} 68860 -17960 0 0 {name=X_75806_ }
C {devices/lab_pin.sym} 68820 -17830 0 0 {name=p68400 lab=_48781_/A }
C {devices/lab_pin.sym} 68900 -17830 0 1 {name=p68401 lab=_48754_/X }
C {sky130_stdcells/buf_2.sym} 68860 -17830 0 0 {name=X_48754_ }
C {devices/lab_pin.sym} 68820 -17710 0 0 {name=p68402 lab=clkbuf_7_77_0_CLK/A }
C {devices/lab_pin.sym} 68900 -17710 0 1 {name=p68403 lab=clkbuf_7_77_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 68860 -17710 0 0 {name=Xclkbuf_7_77_0_CLK }
C {devices/lab_pin.sym} 68780 -17610 0 0 {name=p68404 lab=_79573_/B }
C {devices/lab_pin.sym} 68780 -17570 0 0 {name=p68405 lab=_79572_/Y }
C {devices/lab_pin.sym} 68780 -17530 0 0 {name=p68406 lab=_79569_/Y }
C {devices/lab_pin.sym} 68940 -17570 0 1 {name=p68407 lab=_79576_/A }
C {sky130_stdcells/a21o_4.sym} 68860 -17570 0 0 {name=X_79574_ }
C {devices/lab_pin.sym} 68780 -17460 0 0 {name=p68408 lab=_40330_/Y }
C {devices/lab_pin.sym} 68780 -17420 0 0 {name=p68409 lab=_45963_/X }
C {devices/lab_pin.sym} 68780 -17380 0 0 {name=p68410 lab=_66602_/B }
C {devices/lab_pin.sym} 68780 -17340 0 0 {name=p68411 lab=_45964_/X }
C {devices/lab_pin.sym} 68940 -17400 0 1 {name=p68412 lab=_45966_/X }
C {sky130_stdcells/a2bb2o_4.sym} 68860 -17400 0 0 {name=X_45966_ }
C {devices/lab_pin.sym} 68780 -17290 0 0 {name=p68413 lab=_41040_/X }
C {devices/lab_pin.sym} 68780 -17250 0 0 {name=p68414 lab=_41041_/X }
C {devices/lab_pin.sym} 68780 -17210 0 0 {name=p68415 lab=_41087_/X }
C {devices/lab_pin.sym} 68780 -17170 0 0 {name=p68416 lab=_69513_/B }
C {devices/lab_pin.sym} 68780 -17130 0 0 {name=p68417 lab=_41088_/X }
C {devices/lab_pin.sym} 68940 -17210 0 1 {name=p68418 lab=_41090_/A }
C {sky130_stdcells/o32ai_4.sym} 68860 -17210 0 0 {name=X_41089_ }
C {devices/lab_pin.sym} 68800 -17060 0 0 {name=p68419 lab=_76784_/Y }
C {devices/lab_pin.sym} 68800 -17020 0 0 {name=p68420 lab=_76785_/Y }
C {devices/lab_pin.sym} 68920 -17040 0 1 {name=p68421 lab=_76786_/X }
C {sky130_stdcells/xor2_4.sym} 68860 -17040 0 0 {name=X_76786_ }
C {devices/lab_pin.sym} 68800 -16920 0 0 {name=p68422 lab=_72758_/X }
C {devices/lab_pin.sym} 68800 -16880 0 0 {name=p68423 lab=_66171_/B }
C {devices/lab_pin.sym} 68920 -16900 0 1 {name=p68424 lab=_73998_/X }
C {sky130_stdcells/and2_4.sym} 68860 -16900 0 0 {name=X_73998_ }
C {devices/lab_pin.sym} 68820 -16770 0 0 {name=p68425 lab=_54894_/B }
C {devices/lab_pin.sym} 68900 -16770 0 1 {name=p68426 lab=_53200_/B }
C {sky130_stdcells/buf_2.sym} 68860 -16770 0 0 {name=X_47705_ }
C {devices/lab_pin.sym} 68820 -16650 0 0 {name=p68427 lab=_78525_/A }
C {devices/lab_pin.sym} 68900 -16650 0 1 {name=p68428 lab=_78526_/C }
C {sky130_stdcells/inv_2.sym} 68860 -16650 0 0 {name=X_78525_ }
C {devices/lab_pin.sym} 68800 -16540 0 0 {name=p68429 lab=_44917_/A }
C {devices/lab_pin.sym} 68800 -16500 0 0 {name=p68430 lab=_44894_/B }
C {devices/lab_pin.sym} 68920 -16520 0 1 {name=p68431 lab=_44917_/Y }
C {sky130_stdcells/nor2_4.sym} 68860 -16520 0 0 {name=X_44917_ }
C {devices/lab_pin.sym} 68780 -16420 0 0 {name=p68432 lab=_75715_/A }
C {devices/lab_pin.sym} 68780 -16380 0 0 {name=p68433 lab=_75714_/Y }
C {devices/lab_pin.sym} 68780 -16340 0 0 {name=p68434 lab=_75727_/A }
C {devices/lab_pin.sym} 68780 -16300 0 0 {name=p68435 lab=_75726_/Y }
C {devices/lab_pin.sym} 68940 -16360 0 1 {name=p68436 lab=_75737_/X }
C {sky130_stdcells/o22a_4.sym} 68860 -16360 0 0 {name=X_75737_ }
C {devices/lab_pin.sym} 68820 -16210 0 0 {name=p68437 lab=_60928_/X }
C {devices/lab_pin.sym} 68900 -16210 0 1 {name=p68438 lab=_63751_/X }
C {sky130_stdcells/buf_2.sym} 68860 -16210 0 0 {name=X_63751_ }
C {devices/lab_pin.sym} 68780 -16110 0 0 {name=p68439 lab=_86500_/Q }
C {devices/lab_pin.sym} 68780 -16070 0 0 {name=p68440 lab=_48669_/X }
C {devices/lab_pin.sym} 68780 -16030 0 0 {name=p68441 lab=_48684_/Y }
C {devices/lab_pin.sym} 68940 -16070 0 1 {name=p68442 lab=_48685_/Y }
C {sky130_stdcells/o21ai_4.sym} 68860 -16070 0 0 {name=X_48685_ }
C {devices/lab_pin.sym} 68820 -15930 0 0 {name=p68443 lab=_60962_/Y }
C {devices/lab_pin.sym} 68900 -15930 0 1 {name=p68444 lab=_60963_/X }
C {sky130_stdcells/buf_2.sym} 68860 -15930 0 0 {name=X_60963_ }
C {devices/lab_pin.sym} 68820 -15810 0 0 {name=p68445 lab=_72877_/A }
C {devices/lab_pin.sym} 68900 -15810 0 1 {name=p68446 lab=_72949_/X }
C {sky130_stdcells/buf_2.sym} 68860 -15810 0 0 {name=X_72949_ }
C {devices/lab_pin.sym} 68820 -15690 0 0 {name=p68447 lab=_45896_/X }
C {devices/lab_pin.sym} 68900 -15690 0 1 {name=p68448 lab=_45897_/X }
C {sky130_stdcells/buf_2.sym} 68860 -15690 0 0 {name=X_45897_ }
C {devices/lab_pin.sym} 68800 -15590 0 0 {name=p68449 lab=_62678_/A }
C {devices/lab_pin.sym} 68800 -15550 0 0 {name=p68450 lab=_62727_/B }
C {devices/lab_pin.sym} 68800 -15510 0 0 {name=p68451 lab=_61796_/X }
C {devices/lab_pin.sym} 68920 -15550 0 1 {name=p68452 lab=_62702_/Y }
C {sky130_stdcells/nand3_4.sym} 68860 -15550 0 0 {name=X_62702_ }
C {devices/lab_pin.sym} 68820 -15410 0 0 {name=p68453 lab=_47636_/A }
C {devices/lab_pin.sym} 68900 -15410 0 1 {name=p68454 lab=_53159_/D }
C {sky130_stdcells/buf_2.sym} 68860 -15410 0 0 {name=X_47636_ }
C {devices/lab_pin.sym} 68780 -15310 0 0 {name=p68455 lab=_66467_/Y }
C {devices/lab_pin.sym} 68780 -15270 0 0 {name=p68456 lab=_66449_/X }
C {devices/lab_pin.sym} 68780 -15230 0 0 {name=p68457 lab=_66469_/X }
C {devices/lab_pin.sym} 68940 -15270 0 1 {name=p68458 lab=_84117_/D }
C {sky130_stdcells/a21o_4.sym} 68860 -15270 0 0 {name=X_66470_ }
C {devices/lab_pin.sym} 68780 -15150 0 0 {name=p68459 lab=_78447_/B }
C {devices/lab_pin.sym} 68780 -15110 0 0 {name=p68460 lab=_82796_/Q }
C {devices/lab_pin.sym} 68780 -15070 0 0 {name=p68461 lab=_78455_/Y }
C {devices/lab_pin.sym} 68940 -15110 0 1 {name=p68462 lab=_78465_/A }
C {sky130_stdcells/a21boi_4.sym} 68860 -15110 0 0 {name=X_78456_ }
C {devices/lab_pin.sym} 68820 -14970 0 0 {name=p68463 lab=_43927_/X }
C {devices/lab_pin.sym} 68900 -14970 0 1 {name=p68464 lab=_44848_/X }
C {sky130_stdcells/buf_2.sym} 68860 -14970 0 0 {name=X_44848_ }
C {devices/lab_pin.sym} 68800 -14880 0 0 {name=p68465 lab=_63655_/A }
C {devices/lab_pin.sym} 68800 -14840 0 0 {name=p68466 lab=_58296_/A }
C {devices/lab_pin.sym} 68800 -14800 0 0 {name=p68467 lab=_63672_/C }
C {devices/lab_pin.sym} 68800 -14760 0 0 {name=p68468 lab=_60682_/A }
C {devices/lab_pin.sym} 68920 -14820 0 1 {name=p68469 lab=_63682_/X }
C {sky130_stdcells/and4_4.sym} 68860 -14820 0 0 {name=X_63682_ }
C {devices/lab_pin.sym} 68820 -14670 0 0 {name=p68470 lab=_80909_/Q }
C {devices/lab_pin.sym} 68900 -14670 0 1 {name=p68471 lab=_75670_/A }
C {sky130_stdcells/inv_2.sym} 68860 -14670 0 0 {name=X_75668_ }
C {devices/lab_pin.sym} 68800 -14560 0 0 {name=p68472 lab=_60865_/C }
C {devices/lab_pin.sym} 68800 -14520 0 0 {name=p68473 lab=_64180_/C }
C {devices/lab_pin.sym} 68920 -14540 0 1 {name=p68474 lab=_60894_/X }
C {sky130_stdcells/and2_4.sym} 68860 -14540 0 0 {name=X_60894_ }
C {devices/lab_pin.sym} 68800 -14430 0 0 {name=p68475 lab=_65268_/A }
C {devices/lab_pin.sym} 68800 -14390 0 0 {name=p68476 lab=_65294_/B }
C {devices/lab_pin.sym} 68800 -14350 0 0 {name=p68477 lab=_65421_/C }
C {devices/lab_pin.sym} 68920 -14390 0 1 {name=p68478 lab=_65421_/X }
C {sky130_stdcells/and3_4.sym} 68860 -14390 0 0 {name=X_65421_ }
C {devices/lab_pin.sym} 68780 -14270 0 0 {name=p68479 lab=_77394_/A }
C {devices/lab_pin.sym} 68780 -14230 0 0 {name=p68480 lab=_77405_/Y }
C {devices/lab_pin.sym} 68780 -14190 0 0 {name=p68481 lab=_77406_/Y }
C {devices/lab_pin.sym} 68940 -14230 0 1 {name=p68482 lab=_77416_/A }
C {sky130_stdcells/o21a_4.sym} 68860 -14230 0 0 {name=X_77407_ }
C {devices/lab_pin.sym} 68820 -14090 0 0 {name=p68483 lab=clkbuf_7_70_0_CLK/X }
C {devices/lab_pin.sym} 68900 -14090 0 1 {name=p68484 lab=clkbuf_9_281_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 68860 -14090 0 0 {name=Xclkbuf_8_140_0_CLK }
C {devices/lab_pin.sym} 68800 -14000 0 0 {name=p68485 lab=_61694_/B }
C {devices/lab_pin.sym} 68800 -13960 0 0 {name=p68486 lab=_62309_/B }
C {devices/lab_pin.sym} 68800 -13920 0 0 {name=p68487 lab=_62309_/C }
C {devices/lab_pin.sym} 68800 -13880 0 0 {name=p68488 lab=_62225_/X }
C {devices/lab_pin.sym} 68920 -13940 0 1 {name=p68489 lab=_62633_/Y }
C {sky130_stdcells/nand4_4.sym} 68860 -13940 0 0 {name=X_62633_ }
C {devices/lab_pin.sym} 68780 -13820 0 0 {name=p68490 lab=_58253_/A }
C {devices/lab_pin.sym} 68780 -13780 0 0 {name=p68491 lab=_74613_/X }
C {devices/lab_pin.sym} 68780 -13740 0 0 {name=p68492 lab=_56159_/A }
C {devices/lab_pin.sym} 68780 -13700 0 0 {name=p68493 lab=_74614_/X }
C {devices/lab_pin.sym} 68940 -13760 0 1 {name=p68494 lab=_74619_/X }
C {sky130_stdcells/a211o_4.sym} 68860 -13760 0 0 {name=X_74619_ }
C {devices/lab_pin.sym} 68820 -13610 0 0 {name=p68495 lab=_47567_/A }
C {devices/lab_pin.sym} 68900 -13610 0 1 {name=p68496 lab=_53125_/D }
C {sky130_stdcells/buf_2.sym} 68860 -13610 0 0 {name=X_47567_ }
C {devices/lab_pin.sym} 68820 -13490 0 0 {name=p68497 lab=_82792_/Q }
C {devices/lab_pin.sym} 68900 -13490 0 1 {name=p68498 lab=_78387_/Y }
C {sky130_stdcells/inv_2.sym} 68860 -13490 0 0 {name=X_78387_ }
C {devices/lab_pin.sym} 68780 -13400 0 0 {name=p68499 lab=_41370_/Y }
C {devices/lab_pin.sym} 68780 -13360 0 0 {name=p68500 lab=_44774_/X }
C {devices/lab_pin.sym} 68780 -13320 0 0 {name=p68501 lab=_86959_/Q }
C {devices/lab_pin.sym} 68780 -13280 0 0 {name=p68502 lab=_44775_/X }
C {devices/lab_pin.sym} 68940 -13340 0 1 {name=p68503 lab=_86959_/D }
C {sky130_stdcells/a2bb2o_4.sym} 68860 -13340 0 0 {name=X_44779_ }
C {devices/lab_pin.sym} 68800 -13200 0 0 {name=p68504 lab=_81109_/Q }
C {devices/lab_pin.sym} 68800 -13160 0 0 {name=p68505 lab=_75599_/B }
C {devices/lab_pin.sym} 68920 -13180 0 1 {name=p68506 lab=_75891_/A }
C {sky130_stdcells/xnor2_4.sym} 68860 -13180 0 0 {name=X_75599_ }
C {devices/lab_pin.sym} 68800 -13060 0 0 {name=p68507 lab=_49302_/A }
C {devices/lab_pin.sym} 68800 -13020 0 0 {name=p68508 lab=_50827_/B }
C {devices/lab_pin.sym} 68920 -13040 0 1 {name=p68509 lab=_49306_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -13040 0 0 {name=X_49306_ }
C {devices/lab_pin.sym} 68820 -12910 0 0 {name=p68510 lab=_68120_/A }
C {devices/lab_pin.sym} 68900 -12910 0 1 {name=p68511 lab=_68140_/X }
C {sky130_stdcells/buf_2.sym} 68860 -12910 0 0 {name=X_68140_ }
C {devices/lab_pin.sym} 68780 -12810 0 0 {name=p68512 lab=_46513_/Y }
C {devices/lab_pin.sym} 68780 -12770 0 0 {name=p68513 lab=_46399_/X }
C {devices/lab_pin.sym} 68780 -12730 0 0 {name=p68514 lab=_46517_/Y }
C {devices/lab_pin.sym} 68940 -12770 0 1 {name=p68515 lab=_86730_/D }
C {sky130_stdcells/a21boi_4.sym} 68860 -12770 0 0 {name=X_46518_ }
C {devices/lab_pin.sym} 68800 -12640 0 0 {name=p68516 lab=_65401_/A }
C {devices/lab_pin.sym} 68800 -12600 0 0 {name=p68517 lab=_85828_/Q }
C {devices/lab_pin.sym} 68920 -12620 0 1 {name=p68518 lab=_65352_/X }
C {sky130_stdcells/and2_4.sym} 68860 -12620 0 0 {name=X_65352_ }
C {devices/lab_pin.sym} 68800 -12500 0 0 {name=p68519 lab=_77338_/A }
C {devices/lab_pin.sym} 68800 -12460 0 0 {name=p68520 lab=_77338_/B }
C {devices/lab_pin.sym} 68920 -12480 0 1 {name=p68521 lab=_77339_/B }
C {sky130_stdcells/xor2_4.sym} 68860 -12480 0 0 {name=X_77338_ }
C {devices/lab_pin.sym} 68780 -12370 0 0 {name=p68522 lab=_62562_/Y }
C {devices/lab_pin.sym} 68780 -12330 0 0 {name=p68523 lab=_62540_/X }
C {devices/lab_pin.sym} 68780 -12290 0 0 {name=p68524 lab=_62563_/Y }
C {devices/lab_pin.sym} 68940 -12330 0 1 {name=p68525 lab=_84401_/D }
C {sky130_stdcells/a21oi_4.sym} 68860 -12330 0 0 {name=X_62564_ }
C {devices/lab_pin.sym} 68820 -12190 0 0 {name=p68526 lab=_54772_/B }
C {devices/lab_pin.sym} 68900 -12190 0 1 {name=p68527 lab=_53080_/B }
C {sky130_stdcells/buf_2.sym} 68860 -12190 0 0 {name=X_47498_ }
C {devices/lab_pin.sym} 68820 -12070 0 0 {name=p68528 lab=_64303_/A }
C {devices/lab_pin.sym} 68900 -12070 0 1 {name=p68529 lab=_64303_/X }
C {sky130_stdcells/buf_2.sym} 68860 -12070 0 0 {name=X_64303_ }
C {devices/lab_pin.sym} 68800 -11960 0 0 {name=p68530 lab=_49241_/A }
C {devices/lab_pin.sym} 68800 -11920 0 0 {name=p68531 lab=_50757_/B }
C {devices/lab_pin.sym} 68920 -11940 0 1 {name=p68532 lab=_49237_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -11940 0 0 {name=X_49237_ }
C {devices/lab_pin.sym} 68820 -11810 0 0 {name=p68533 lab=_61514_/Y }
C {devices/lab_pin.sym} 68900 -11810 0 1 {name=p68534 lab=_61515_/Y }
C {sky130_stdcells/inv_2.sym} 68860 -11810 0 0 {name=X_61515_ }
C {devices/lab_pin.sym} 68800 -11700 0 0 {name=p68535 lab=_68044_/A }
C {devices/lab_pin.sym} 68800 -11660 0 0 {name=p68536 lab=_68071_/B }
C {devices/lab_pin.sym} 68920 -11680 0 1 {name=p68537 lab=_68071_/X }
C {sky130_stdcells/and2_4.sym} 68860 -11680 0 0 {name=X_68071_ }
C {devices/lab_pin.sym} 68820 -11550 0 0 {name=p68538 lab=_46449_/A }
C {devices/lab_pin.sym} 68900 -11550 0 1 {name=p68539 lab=_50812_/A }
C {sky130_stdcells/buf_2.sym} 68860 -11550 0 0 {name=X_46449_ }
C {devices/lab_pin.sym} 68780 -11460 0 0 {name=p68540 lab=_65172_/X }
C {devices/lab_pin.sym} 68780 -11420 0 0 {name=p68541 lab=_86151_/Q }
C {devices/lab_pin.sym} 68780 -11380 0 0 {name=p68542 lab=_65256_/X }
C {devices/lab_pin.sym} 68780 -11340 0 0 {name=p68543 lab=_65282_/X }
C {devices/lab_pin.sym} 68940 -11400 0 1 {name=p68544 lab=_65283_/X }
C {sky130_stdcells/a211o_4.sym} 68860 -11400 0 0 {name=X_65283_ }
C {devices/lab_pin.sym} 68820 -11250 0 0 {name=p68545 lab=clkbuf_6_7_0_CLK/X }
C {devices/lab_pin.sym} 68900 -11250 0 1 {name=p68546 lab=clkbuf_8_31_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 68860 -11250 0 0 {name=Xclkbuf_7_15_0_CLK }
C {devices/lab_pin.sym} 68820 -11130 0 0 {name=p68547 lab=_77268_/X }
C {devices/lab_pin.sym} 68900 -11130 0 1 {name=p68548 lab=_77269_/Y }
C {sky130_stdcells/inv_2.sym} 68860 -11130 0 0 {name=X_77269_ }
C {devices/lab_pin.sym} 68800 -11040 0 0 {name=p68549 lab=_62570_/A }
C {devices/lab_pin.sym} 68800 -11000 0 0 {name=p68550 lab=_62027_/X }
C {devices/lab_pin.sym} 68800 -10960 0 0 {name=p68551 lab=_62479_/C }
C {devices/lab_pin.sym} 68800 -10920 0 0 {name=p68552 lab=_62463_/X }
C {devices/lab_pin.sym} 68920 -10980 0 1 {name=p68553 lab=_62495_/X }
C {sky130_stdcells/and4_4.sym} 68860 -10980 0 0 {name=X_62495_ }
C {devices/lab_pin.sym} 68820 -10830 0 0 {name=p68554 lab=clkbuf_7_77_0_CLK/X }
C {devices/lab_pin.sym} 68900 -10830 0 1 {name=p68555 lab=clkbuf_9_311_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 68860 -10830 0 0 {name=Xclkbuf_8_155_0_CLK }
C {devices/lab_pin.sym} 68820 -10710 0 0 {name=p68556 lab=_67144_/A }
C {devices/lab_pin.sym} 68900 -10710 0 1 {name=p68557 lab=_67023_/A }
C {sky130_stdcells/buf_2.sym} 68860 -10710 0 0 {name=X_67022_ }
C {devices/lab_pin.sym} 68780 -10610 0 0 {name=p68558 lab=_78997_/A }
C {devices/lab_pin.sym} 68780 -10570 0 0 {name=p68559 lab=_78997_/B }
C {devices/lab_pin.sym} 68780 -10530 0 0 {name=p68560 lab=_79007_/X }
C {devices/lab_pin.sym} 68940 -10570 0 1 {name=p68561 lab=_79008_/Y }
C {sky130_stdcells/a21oi_4.sym} 68860 -10570 0 0 {name=X_79008_ }
C {devices/lab_pin.sym} 68800 -10460 0 0 {name=p68562 lab=_64234_/A }
C {devices/lab_pin.sym} 68800 -10420 0 0 {name=p68563 lab=_64234_/B }
C {devices/lab_pin.sym} 68800 -10380 0 0 {name=p68564 lab=_58225_/A }
C {devices/lab_pin.sym} 68800 -10340 0 0 {name=p68565 lab=_64221_/X }
C {devices/lab_pin.sym} 68920 -10400 0 1 {name=p68566 lab=_64234_/X }
C {sky130_stdcells/and4_4.sym} 68860 -10400 0 0 {name=X_64234_ }
C {devices/lab_pin.sym} 68820 -10250 0 0 {name=p68567 lab=clkbuf_9_75_0_CLK/X }
C {devices/lab_pin.sym} 68900 -10250 0 1 {name=p68568 lab=_81632_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 68860 -10250 0 0 {name=Xclkbuf_10_150_0_CLK }
C {devices/lab_pin.sym} 68780 -10150 0 0 {name=p68569 lab=_61444_/X }
C {devices/lab_pin.sym} 68780 -10110 0 0 {name=p68570 lab=_61394_/X }
C {devices/lab_pin.sym} 68780 -10070 0 0 {name=p68571 lab=_61445_/Y }
C {devices/lab_pin.sym} 68940 -10110 0 1 {name=p68572 lab=_61446_/Y }
C {sky130_stdcells/a21oi_4.sym} 68860 -10110 0 0 {name=X_61446_ }
C {devices/lab_pin.sym} 68800 -9980 0 0 {name=p68573 lab=_49156_/X }
C {devices/lab_pin.sym} 68800 -9940 0 0 {name=p68574 lab=_50708_/B }
C {devices/lab_pin.sym} 68920 -9960 0 1 {name=p68575 lab=_49168_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -9960 0 0 {name=X_49168_ }
C {devices/lab_pin.sym} 68800 -9850 0 0 {name=p68576 lab=_80275_/Y }
C {devices/lab_pin.sym} 68800 -9810 0 0 {name=p68577 lab=_80280_/B }
C {devices/lab_pin.sym} 68800 -9770 0 0 {name=p68578 lab=_80280_/C }
C {devices/lab_pin.sym} 68920 -9810 0 1 {name=p68579 lab=_80280_/Y }
C {sky130_stdcells/nand3_4.sym} 68860 -9810 0 0 {name=X_80280_ }
C {devices/lab_pin.sym} 68820 -9670 0 0 {name=p68580 lab=clkbuf_9_390_0_CLK/X }
C {devices/lab_pin.sym} 68900 -9670 0 1 {name=p68581 lab=_82580_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 68860 -9670 0 0 {name=Xclkbuf_10_780_0_CLK }
C {devices/lab_pin.sym} 68780 -9570 0 0 {name=p68582 lab=_48075_/X }
C {devices/lab_pin.sym} 68780 -9530 0 0 {name=p68583 lab=_82918_/Q }
C {devices/lab_pin.sym} 68780 -9490 0 0 {name=p68584 lab=_48118_/X }
C {devices/lab_pin.sym} 68940 -9530 0 1 {name=p68585 lab=_48329_/A }
C {sky130_stdcells/o21ai_4.sym} 68860 -9530 0 0 {name=X_48119_ }
C {devices/lab_pin.sym} 68780 -9410 0 0 {name=p68586 lab=_64163_/X }
C {devices/lab_pin.sym} 68780 -9370 0 0 {name=p68587 lab=_64129_/X }
C {devices/lab_pin.sym} 68780 -9330 0 0 {name=p68588 lab=_64164_/Y }
C {devices/lab_pin.sym} 68940 -9370 0 1 {name=p68589 lab=_64165_/Y }
C {sky130_stdcells/a21oi_4.sym} 68860 -9370 0 0 {name=X_64165_ }
C {devices/lab_pin.sym} 68820 -9230 0 0 {name=p68590 lab=_49099_/A }
C {devices/lab_pin.sym} 68900 -9230 0 1 {name=p68591 lab=_52370_/A }
C {sky130_stdcells/buf_2.sym} 68860 -9230 0 0 {name=X_49099_ }
C {devices/lab_pin.sym} 68800 -9130 0 0 {name=p68592 lab=_61377_/A }
C {devices/lab_pin.sym} 68800 -9090 0 0 {name=p68593 lab=_61376_/X }
C {devices/lab_pin.sym} 68800 -9050 0 0 {name=p68594 lab=_61377_/C }
C {devices/lab_pin.sym} 68920 -9090 0 1 {name=p68595 lab=_61377_/Y }
C {sky130_stdcells/nand3_4.sym} 68860 -9090 0 0 {name=X_61377_ }
C {devices/lab_pin.sym} 68800 -8960 0 0 {name=p68596 lab=_51130_/A }
C {devices/lab_pin.sym} 68800 -8920 0 0 {name=p68597 lab=_51130_/B }
C {devices/lab_pin.sym} 68920 -8940 0 1 {name=p68598 lab=_51130_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -8940 0 0 {name=X_51130_ }
C {devices/lab_pin.sym} 68820 -8810 0 0 {name=p68599 lab=clkbuf_9_271_0_CLK/A }
C {devices/lab_pin.sym} 68900 -8810 0 1 {name=p68600 lab=clkbuf_9_271_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 68860 -8810 0 0 {name=Xclkbuf_9_271_0_CLK }
C {devices/lab_pin.sym} 68780 -8710 0 0 {name=p68601 lab=_79414_/A }
C {devices/lab_pin.sym} 68780 -8670 0 0 {name=p68602 lab=_63072_/X }
C {devices/lab_pin.sym} 68780 -8630 0 0 {name=p68603 lab=_63115_/Y }
C {devices/lab_pin.sym} 68940 -8670 0 1 {name=p68604 lab=_84352_/D }
C {sky130_stdcells/a21o_4.sym} 68860 -8670 0 0 {name=X_63116_ }
C {devices/lab_pin.sym} 68780 -8570 0 0 {name=p68605 lab=_60235_/A }
C {devices/lab_pin.sym} 68780 -8530 0 0 {name=p68606 lab=_60327_/X }
C {devices/lab_pin.sym} 68780 -8490 0 0 {name=p68607 lab=_60198_/A }
C {devices/lab_pin.sym} 68780 -8450 0 0 {name=p68608 lab=_79691_/A }
C {devices/lab_pin.sym} 68780 -8410 0 0 {name=p68609 lab=_59814_/X }
C {devices/lab_pin.sym} 68940 -8490 0 1 {name=p68610 lab=_60328_/X }
C {sky130_stdcells/o32a_4.sym} 68860 -8490 0 0 {name=X_60328_ }
C {devices/lab_pin.sym} 68780 -8360 0 0 {name=p68611 lab=_68907_/X }
C {devices/lab_pin.sym} 68780 -8320 0 0 {name=p68612 lab=_68882_/X }
C {devices/lab_pin.sym} 68780 -8280 0 0 {name=p68613 lab=_68964_/Y }
C {devices/lab_pin.sym} 68780 -8240 0 0 {name=p68614 lab=_68972_/Y }
C {devices/lab_pin.sym} 68940 -8300 0 1 {name=p68615 lab=_68973_/X }
C {sky130_stdcells/a211o_4.sym} 68860 -8300 0 0 {name=X_68973_ }
C {devices/lab_pin.sym} 68800 -8180 0 0 {name=p68616 lab=_61593_/B }
C {devices/lab_pin.sym} 68800 -8140 0 0 {name=p68617 lab=_64161_/B }
C {devices/lab_pin.sym} 68800 -8100 0 0 {name=p68618 lab=_64150_/C }
C {devices/lab_pin.sym} 68800 -8060 0 0 {name=p68619 lab=_64161_/D }
C {devices/lab_pin.sym} 68920 -8120 0 1 {name=p68620 lab=_64096_/Y }
C {sky130_stdcells/nand4_4.sym} 68860 -8120 0 0 {name=X_64096_ }
C {devices/lab_pin.sym} 68820 -7970 0 0 {name=p68621 lab=clkbuf_9_82_0_CLK/X }
C {devices/lab_pin.sym} 68900 -7970 0 1 {name=p68622 lab=_81288_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 68860 -7970 0 0 {name=Xclkbuf_10_165_0_CLK }
C {devices/lab_pin.sym} 68800 -7880 0 0 {name=p68623 lab=_51056_/A }
C {devices/lab_pin.sym} 68800 -7840 0 0 {name=p68624 lab=_51045_/B }
C {devices/lab_pin.sym} 68800 -7800 0 0 {name=p68625 lab=_51071_/C }
C {devices/lab_pin.sym} 68800 -7760 0 0 {name=p68626 lab=_52750_/D }
C {devices/lab_pin.sym} 68920 -7820 0 1 {name=p68627 lab=_51061_/X }
C {sky130_stdcells/and4_4.sym} 68860 -7820 0 0 {name=X_51061_ }
C {devices/lab_pin.sym} 68820 -7670 0 0 {name=p68628 lab=_68461_/A }
C {devices/lab_pin.sym} 68900 -7670 0 1 {name=p68629 lab=_68120_/A }
C {sky130_stdcells/buf_2.sym} 68860 -7670 0 0 {name=X_67924_ }
C {devices/lab_pin.sym} 68780 -7590 0 0 {name=p68630 lab=_58418_/A }
C {devices/lab_pin.sym} 68780 -7550 0 0 {name=p68631 lab=_63010_/X }
C {devices/lab_pin.sym} 68780 -7510 0 0 {name=p68632 lab=_60523_/X }
C {devices/lab_pin.sym} 68780 -7470 0 0 {name=p68633 lab=_59463_/Y }
C {devices/lab_pin.sym} 68780 -7430 0 0 {name=p68634 lab=_60412_/X }
C {devices/lab_pin.sym} 68940 -7510 0 1 {name=p68635 lab=_63047_/Y }
C {sky130_stdcells/o32ai_4.sym} 68860 -7510 0 0 {name=X_63047_ }
C {devices/lab_pin.sym} 68800 -7360 0 0 {name=p68636 lab=_60259_/A }
C {devices/lab_pin.sym} 68800 -7320 0 0 {name=p68637 lab=_60259_/B }
C {devices/lab_pin.sym} 68920 -7340 0 1 {name=p68638 lab=_60259_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -7340 0 0 {name=X_60259_ }
C {devices/lab_pin.sym} 68770 -7210 0 0 {name=p68639 lab=_80931_/CLK }
C {devices/lab_pin.sym} 68770 -7190 0 0 {name=p68640 lab=_83970_/D }
C {devices/lab_pin.sym} 68950 -7210 0 1 {name=p68641 lab=_80826_/D }
C {sky130_stdcells/dfxtp_4.sym} 68860 -7200 0 0 {name=X_83970_ }
C {devices/lab_pin.sym} 68820 -7070 0 0 {name=p68642 lab=clkbuf_9_397_0_CLK/X }
C {devices/lab_pin.sym} 68900 -7070 0 1 {name=p68643 lab=_82671_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 68860 -7070 0 0 {name=Xclkbuf_10_795_0_CLK }
C {devices/lab_pin.sym} 68820 -6950 0 0 {name=p68644 lab=_48169_/X }
C {devices/lab_pin.sym} 68900 -6950 0 1 {name=p68645 lab=_50012_/X }
C {sky130_stdcells/buf_2.sym} 68860 -6950 0 0 {name=X_50012_ }
C {devices/lab_pin.sym} 68770 -6830 0 0 {name=p68646 lab=_82923_/CLK }
C {devices/lab_pin.sym} 68770 -6810 0 0 {name=p68647 lab=_78182_/X }
C {devices/lab_pin.sym} 68950 -6830 0 1 {name=p68648 lab=_46528_/A }
C {sky130_stdcells/dfxtp_4.sym} 68860 -6820 0 0 {name=X_82921_ }
C {devices/lab_pin.sym} 68820 -6690 0 0 {name=p68649 lab=_66554_/X }
C {devices/lab_pin.sym} 68900 -6690 0 1 {name=p68650 lab=_67955_/A }
C {sky130_stdcells/buf_2.sym} 68860 -6690 0 0 {name=X_67855_ }
C {devices/lab_pin.sym} 68820 -6570 0 0 {name=p68651 lab=clkbuf_9_286_0_CLK/A }
C {devices/lab_pin.sym} 68900 -6570 0 1 {name=p68652 lab=clkbuf_9_286_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 68860 -6570 0 0 {name=Xclkbuf_9_286_0_CLK }
C {devices/lab_pin.sym} 68820 -6450 0 0 {name=p68653 lab=_54900_/A }
C {devices/lab_pin.sym} 68900 -6450 0 1 {name=p68654 lab=_54843_/B }
C {sky130_stdcells/buf_2.sym} 68860 -6450 0 0 {name=X_54820_ }
C {devices/lab_pin.sym} 68780 -6350 0 0 {name=p68655 lab=_84096_/Q }
C {devices/lab_pin.sym} 68780 -6310 0 0 {name=p68656 lab=_66734_/X }
C {devices/lab_pin.sym} 68780 -6270 0 0 {name=p68657 lab=_66805_/X }
C {devices/lab_pin.sym} 68940 -6310 0 1 {name=p68658 lab=_66806_/X }
C {sky130_stdcells/a21bo_4.sym} 68860 -6310 0 0 {name=X_66806_ }
C {devices/lab_pin.sym} 68770 -6170 0 0 {name=p68659 lab=_85643_/CLK }
C {devices/lab_pin.sym} 68770 -6150 0 0 {name=p68660 lab=_85640_/D }
C {devices/lab_pin.sym} 68950 -6170 0 1 {name=p68661 lab=_85640_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -6160 0 0 {name=X_85640_ }
C {devices/lab_pin.sym} 68770 -6030 0 0 {name=p68662 lab=_82596_/CLK }
C {devices/lab_pin.sym} 68770 -6010 0 0 {name=p68663 lab=_78088_/B }
C {devices/lab_pin.sym} 68950 -6030 0 1 {name=p68664 lab=_82852_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -6020 0 0 {name=X_82852_ }
C {devices/lab_pin.sym} 68780 -5920 0 0 {name=p68665 lab=_87392_/Q }
C {devices/lab_pin.sym} 68780 -5880 0 0 {name=p68666 lab=_67717_/X }
C {devices/lab_pin.sym} 68780 -5840 0 0 {name=p68667 lab=_67718_/X }
C {devices/lab_pin.sym} 68780 -5800 0 0 {name=p68668 lab=_67785_/X }
C {devices/lab_pin.sym} 68940 -5860 0 1 {name=p68669 lab=_67786_/X }
C {sky130_stdcells/a211o_4.sym} 68860 -5860 0 0 {name=X_67786_ }
C {devices/lab_pin.sym} 68780 -5730 0 0 {name=p68670 lab=_64995_/Y }
C {devices/lab_pin.sym} 68780 -5690 0 0 {name=p68671 lab=_64939_/X }
C {devices/lab_pin.sym} 68780 -5650 0 0 {name=p68672 lab=_64997_/Y }
C {devices/lab_pin.sym} 68940 -5690 0 1 {name=p68673 lab=_84219_/D }
C {sky130_stdcells/a21o_4.sym} 68860 -5690 0 0 {name=X_64998_ }
C {devices/lab_pin.sym} 68770 -5550 0 0 {name=p68674 lab=_81632_/CLK }
C {devices/lab_pin.sym} 68770 -5530 0 0 {name=p68675 lab=_81803_/D }
C {devices/lab_pin.sym} 68950 -5550 0 1 {name=p68676 lab=_81803_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -5540 0 0 {name=X_81803_ }
C {devices/lab_pin.sym} 68780 -5430 0 0 {name=p68677 lab=_69522_/X }
C {devices/lab_pin.sym} 68780 -5390 0 0 {name=p68678 lab=_69524_/X }
C {devices/lab_pin.sym} 68780 -5350 0 0 {name=p68679 lab=_69385_/X }
C {devices/lab_pin.sym} 68940 -5390 0 1 {name=p68680 lab=_69525_/X }
C {sky130_stdcells/a21o_4.sym} 68860 -5390 0 0 {name=X_69525_ }
C {devices/lab_pin.sym} 68780 -5270 0 0 {name=p68681 lab=_85384_/Q }
C {devices/lab_pin.sym} 68780 -5230 0 0 {name=p68682 lab=_54729_/X }
C {devices/lab_pin.sym} 68780 -5190 0 0 {name=p68683 lab=_54750_/Y }
C {devices/lab_pin.sym} 68940 -5230 0 1 {name=p68684 lab=_54751_/Y }
C {sky130_stdcells/o21ai_4.sym} 68860 -5230 0 0 {name=X_54751_ }
C {devices/lab_pin.sym} 68780 -5120 0 0 {name=p68685 lab=_87884_/Q }
C {devices/lab_pin.sym} 68780 -5080 0 0 {name=p68686 lab=_66639_/X }
C {devices/lab_pin.sym} 68780 -5040 0 0 {name=p68687 lab=_66688_/X }
C {devices/lab_pin.sym} 68780 -5000 0 0 {name=p68688 lab=_66736_/X }
C {devices/lab_pin.sym} 68940 -5060 0 1 {name=p68689 lab=_66737_/X }
C {sky130_stdcells/a211o_4.sym} 68860 -5060 0 0 {name=X_66737_ }
C {devices/lab_pin.sym} 68770 -4910 0 0 {name=p68690 lab=_85571_/CLK }
C {devices/lab_pin.sym} 68770 -4890 0 0 {name=p68691 lab=_53775_/Y }
C {devices/lab_pin.sym} 68950 -4910 0 1 {name=p68692 lab=_85571_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -4900 0 0 {name=X_85571_ }
C {devices/lab_pin.sym} 68780 -4790 0 0 {name=p68693 lab=_65972_/B }
C {devices/lab_pin.sym} 68780 -4750 0 0 {name=p68694 lab=_51960_/X }
C {devices/lab_pin.sym} 68780 -4710 0 0 {name=p68695 lab=_51962_/Y }
C {devices/lab_pin.sym} 68940 -4750 0 1 {name=p68696 lab=_51963_/Y }
C {sky130_stdcells/o21ai_4.sym} 68860 -4750 0 0 {name=X_51963_ }
C {devices/lab_pin.sym} 68800 -4640 0 0 {name=p68697 lab=_63520_/B }
C {devices/lab_pin.sym} 68800 -4600 0 0 {name=p68698 lab=_63934_/X }
C {devices/lab_pin.sym} 68800 -4560 0 0 {name=p68699 lab=_63949_/C }
C {devices/lab_pin.sym} 68800 -4520 0 0 {name=p68700 lab=_64027_/D }
C {devices/lab_pin.sym} 68920 -4580 0 1 {name=p68701 lab=_63949_/Y }
C {sky130_stdcells/nand4_4.sym} 68860 -4580 0 0 {name=X_63949_ }
C {devices/lab_pin.sym} 68770 -4430 0 0 {name=p68702 lab=_82975_/CLK }
C {devices/lab_pin.sym} 68770 -4410 0 0 {name=p68703 lab=_78762_/X }
C {devices/lab_pin.sym} 68950 -4430 0 1 {name=p68704 lab=_82783_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -4420 0 0 {name=X_82783_ }
C {devices/lab_pin.sym} 68770 -4290 0 0 {name=p68705 lab=_83158_/CLK }
C {devices/lab_pin.sym} 68770 -4270 0 0 {name=p68706 lab=_87310_/D }
C {devices/lab_pin.sym} 68950 -4290 0 1 {name=p68707 lab=_87310_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -4280 0 0 {name=X_87310_ }
C {devices/lab_pin.sym} 68820 -4150 0 0 {name=p68708 lab=_53763_/A }
C {devices/lab_pin.sym} 68900 -4150 0 1 {name=p68709 lab=_53734_/C }
C {sky130_stdcells/buf_2.sym} 68860 -4150 0 0 {name=X_53702_ }
C {devices/lab_pin.sym} 68770 -4030 0 0 {name=p68710 lab=_84292_/CLK }
C {devices/lab_pin.sym} 68770 -4010 0 0 {name=p68711 lab=_61065_/X }
C {devices/lab_pin.sym} 68950 -4030 0 1 {name=p68712 lab=_84522_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -4020 0 0 {name=X_84522_ }
C {devices/lab_pin.sym} 68800 -3920 0 0 {name=p68713 lab=_50908_/A }
C {devices/lab_pin.sym} 68800 -3880 0 0 {name=p68714 lab=_50919_/B }
C {devices/lab_pin.sym} 68800 -3840 0 0 {name=p68715 lab=_50897_/X }
C {devices/lab_pin.sym} 68800 -3800 0 0 {name=p68716 lab=_51777_/D }
C {devices/lab_pin.sym} 68920 -3860 0 1 {name=p68717 lab=_50914_/X }
C {sky130_stdcells/and4_4.sym} 68860 -3860 0 0 {name=X_50914_ }
C {devices/lab_pin.sym} 68800 -3730 0 0 {name=p68718 lab=_56885_/A }
C {devices/lab_pin.sym} 68800 -3690 0 0 {name=p68719 lab=_57470_/B }
C {devices/lab_pin.sym} 68800 -3650 0 0 {name=p68720 lab=_56884_/Y }
C {devices/lab_pin.sym} 68920 -3690 0 1 {name=p68721 lab=_57470_/Y }
C {sky130_stdcells/nand3_4.sym} 68860 -3690 0 0 {name=X_57470_ }
C {devices/lab_pin.sym} 68770 -3550 0 0 {name=p68722 lab=_82067_/CLK }
C {devices/lab_pin.sym} 68770 -3530 0 0 {name=p68723 lab=_81734_/D }
C {devices/lab_pin.sym} 68950 -3550 0 1 {name=p68724 lab=_81734_/Q }
C {sky130_stdcells/dfxtp_4.sym} 68860 -3540 0 0 {name=X_81734_ }
C {devices/lab_pin.sym} 68780 -3430 0 0 {name=p68725 lab=_69453_/X }
C {devices/lab_pin.sym} 68780 -3390 0 0 {name=p68726 lab=_69455_/X }
C {devices/lab_pin.sym} 68780 -3350 0 0 {name=p68727 lab=_69399_/X }
C {devices/lab_pin.sym} 68940 -3390 0 1 {name=p68728 lab=_69461_/A }
C {sky130_stdcells/a21o_4.sym} 68860 -3390 0 0 {name=X_69456_ }
C {devices/lab_pin.sym} 68770 -3250 0 0 {name=p68729 lab=_87022_/CLK }
C {devices/lab_pin.sym} 68770 -3230 0 0 {name=p68730 lab=_88290_/D }
C {devices/lab_pin.sym} 68950 -3250 0 1 {name=p68731 lab=_69376_/B }
C {sky130_stdcells/dfxtp_4.sym} 68860 -3240 0 0 {name=X_88290_ }
C {devices/lab_pin.sym} 68800 -3120 0 0 {name=p68732 lab=_54682_/A }
C {devices/lab_pin.sym} 68800 -3080 0 0 {name=p68733 lab=_47334_/Y }
C {devices/lab_pin.sym} 68920 -3100 0 1 {name=p68734 lab=_54682_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -3100 0 0 {name=X_54682_ }
C {devices/lab_pin.sym} 68780 -2990 0 0 {name=p68735 lab=_66663_/X }
C {devices/lab_pin.sym} 68780 -2950 0 0 {name=p68736 lab=_66666_/X }
C {devices/lab_pin.sym} 68780 -2910 0 0 {name=p68737 lab=_66667_/X }
C {devices/lab_pin.sym} 68940 -2950 0 1 {name=p68738 lab=_66668_/X }
C {sky130_stdcells/a21o_4.sym} 68860 -2950 0 0 {name=X_66668_ }
C {devices/lab_pin.sym} 68780 -2830 0 0 {name=p68739 lab=_51890_/Y }
C {devices/lab_pin.sym} 68780 -2790 0 0 {name=p68740 lab=_51877_/X }
C {devices/lab_pin.sym} 68780 -2750 0 0 {name=p68741 lab=_51893_/X }
C {devices/lab_pin.sym} 68940 -2790 0 1 {name=p68742 lab=_85927_/D }
C {sky130_stdcells/a21oi_4.sym} 68860 -2790 0 0 {name=X_51894_ }
C {devices/lab_pin.sym} 68820 -2650 0 0 {name=p68743 lab=clkbuf_7_54_0_CLK/X }
C {devices/lab_pin.sym} 68900 -2650 0 1 {name=p68744 lab=clkbuf_9_217_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 68860 -2650 0 0 {name=Xclkbuf_8_108_0_CLK }
C {devices/lab_pin.sym} 68780 -2550 0 0 {name=p68745 lab=_56099_/X }
C {devices/lab_pin.sym} 68780 -2510 0 0 {name=p68746 lab=_56409_/X }
C {devices/lab_pin.sym} 68780 -2470 0 0 {name=p68747 lab=_56420_/Y }
C {devices/lab_pin.sym} 68940 -2510 0 1 {name=p68748 lab=_85200_/D }
C {sky130_stdcells/o21ai_4.sym} 68860 -2510 0 0 {name=X_56421_ }
C {devices/lab_pin.sym} 68820 -2370 0 0 {name=p68749 lab=clkbuf_9_51_0_CLK/X }
C {devices/lab_pin.sym} 68900 -2370 0 1 {name=p68750 lab=_84529_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 68860 -2370 0 0 {name=Xclkbuf_10_103_0_CLK }
C {devices/lab_pin.sym} 68780 -2270 0 0 {name=p68751 lab=_68404_/X }
C {devices/lab_pin.sym} 68780 -2230 0 0 {name=p68752 lab=_68406_/X }
C {devices/lab_pin.sym} 68780 -2190 0 0 {name=p68753 lab=_68033_/X }
C {devices/lab_pin.sym} 68940 -2230 0 1 {name=p68754 lab=_68407_/X }
C {sky130_stdcells/a21o_4.sym} 68860 -2230 0 0 {name=X_68407_ }
C {devices/lab_pin.sym} 68770 -2090 0 0 {name=p68755 lab=_88012_/CLK }
C {devices/lab_pin.sym} 68770 -2070 0 0 {name=p68756 lab=_87241_/D }
C {devices/lab_pin.sym} 68950 -2090 0 1 {name=p68757 lab=_68627_/B }
C {sky130_stdcells/dfxtp_4.sym} 68860 -2080 0 0 {name=X_87241_ }
C {devices/lab_pin.sym} 68800 -1960 0 0 {name=p68758 lab=_53656_/A }
C {devices/lab_pin.sym} 68800 -1920 0 0 {name=p68759 lab=_48391_/A }
C {devices/lab_pin.sym} 68920 -1940 0 1 {name=p68760 lab=_53633_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -1940 0 0 {name=X_53633_ }
C {devices/lab_pin.sym} 68800 -1820 0 0 {name=p68761 lab=_65608_/Y }
C {devices/lab_pin.sym} 68800 -1780 0 0 {name=p68762 lab=_65619_/B }
C {devices/lab_pin.sym} 68920 -1800 0 1 {name=p68763 lab=_65619_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -1800 0 0 {name=X_65619_ }
C {devices/lab_pin.sym} 68770 -1670 0 0 {name=p68764 lab=_84454_/CLK }
C {devices/lab_pin.sym} 68770 -1650 0 0 {name=p68765 lab=_61803_/Y }
C {devices/lab_pin.sym} 68950 -1670 0 1 {name=p68766 lab=_78076_/B }
C {sky130_stdcells/dfxtp_4.sym} 68860 -1660 0 0 {name=X_84453_ }
C {devices/lab_pin.sym} 68800 -1540 0 0 {name=p68767 lab=_50845_/A }
C {devices/lab_pin.sym} 68800 -1500 0 0 {name=p68768 lab=_49322_/B }
C {devices/lab_pin.sym} 68920 -1520 0 1 {name=p68769 lab=_50845_/Y }
C {sky130_stdcells/nand2_4.sym} 68860 -1520 0 0 {name=X_50845_ }
C {devices/lab_pin.sym} 68770 -1390 0 0 {name=p68770 lab=_81682_/CLK }
C {devices/lab_pin.sym} 68770 -1370 0 0 {name=p68771 lab=_81697_/Q }
C {devices/lab_pin.sym} 68950 -1390 0 1 {name=p68772 lab=_76635_/A }
C {sky130_stdcells/dfxtp_4.sym} 68860 -1380 0 0 {name=X_81665_ }
C {devices/lab_pin.sym} 68800 -1260 0 0 {name=p68773 lab=_69612_/A }
C {devices/lab_pin.sym} 68800 -1220 0 0 {name=p68774 lab=_88289_/Q }
C {devices/lab_pin.sym} 68920 -1240 0 1 {name=p68775 lab=_69387_/X }
C {sky130_stdcells/and2_4.sym} 68860 -1240 0 0 {name=X_69387_ }
C {devices/lab_pin.sym} 68780 -1140 0 0 {name=p68776 lab=_87890_/Q }
C {devices/lab_pin.sym} 68780 -1100 0 0 {name=p68777 lab=_66562_/X }
C {devices/lab_pin.sym} 68780 -1060 0 0 {name=p68778 lab=_66564_/X }
C {devices/lab_pin.sym} 68780 -1020 0 0 {name=p68779 lab=_66598_/X }
C {devices/lab_pin.sym} 68940 -1080 0 1 {name=p68780 lab=_66599_/X }
C {sky130_stdcells/a211o_4.sym} 68860 -1080 0 0 {name=X_66599_ }
C {devices/lab_pin.sym} 68820 -930 0 0 {name=p68781 lab=clkbuf_9_366_0_CLK/X }
C {devices/lab_pin.sym} 68900 -930 0 1 {name=p68782 lab=_87333_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 68860 -930 0 0 {name=Xclkbuf_10_733_0_CLK }
C {devices/lab_pin.sym} 68820 -810 0 0 {name=p68783 lab=_59053_/A }
C {devices/lab_pin.sym} 68900 -810 0 1 {name=p68784 lab=_59140_/X }
C {sky130_stdcells/buf_2.sym} 68860 -810 0 0 {name=X_59140_ }
C {devices/lab_pin.sym} 68770 -690 0 0 {name=p68785 lab=_83372_/CLK }
C {devices/lab_pin.sym} 68770 -670 0 0 {name=p68786 lab=_83404_/D }
C {devices/lab_pin.sym} 68950 -690 0 1 {name=p68787 lab=_58298_/A }
C {sky130_stdcells/dfxtp_4.sym} 68860 -680 0 0 {name=X_83404_ }
C {devices/lab_pin.sym} 69720 -42160 0 0 {name=p68788 lab=_80623_/A }
C {devices/lab_pin.sym} 69720 -42120 0 0 {name=p68789 lab=_80615_/Y }
C {devices/lab_pin.sym} 69840 -42140 0 1 {name=p68790 lab=_80622_/B }
C {sky130_stdcells/xor2_4.sym} 69780 -42140 0 0 {name=X_80616_ }
C {devices/lab_pin.sym} 69720 -42030 0 0 {name=p68791 lab=_56358_/A }
C {devices/lab_pin.sym} 69720 -41990 0 0 {name=p68792 lab=_56358_/B }
C {devices/lab_pin.sym} 69720 -41950 0 0 {name=p68793 lab=_55764_/B }
C {devices/lab_pin.sym} 69840 -41990 0 1 {name=p68794 lab=_56352_/Y }
C {sky130_stdcells/nand3_4.sym} 69780 -41990 0 0 {name=X_56352_ }
C {devices/lab_pin.sym} 69740 -41850 0 0 {name=p68795 lab=_68338_/A }
C {devices/lab_pin.sym} 69820 -41850 0 1 {name=p68796 lab=_68338_/X }
C {sky130_stdcells/buf_2.sym} 69780 -41850 0 0 {name=X_68338_ }
C {devices/lab_pin.sym} 69690 -41730 0 0 {name=p68797 lab=_87174_/CLK }
C {devices/lab_pin.sym} 69690 -41710 0 0 {name=p68798 lab=_44295_/Y }
C {devices/lab_pin.sym} 69870 -41730 0 1 {name=p68799 lab=_44293_/B }
C {sky130_stdcells/dfxtp_4.sym} 69780 -41720 0 0 {name=X_87172_ }
C {devices/lab_pin.sym} 69700 -41610 0 0 {name=p68800 lab=_85612_/Q }
C {devices/lab_pin.sym} 69700 -41570 0 0 {name=p68801 lab=_53540_/X }
C {devices/lab_pin.sym} 69700 -41530 0 0 {name=p68802 lab=_53563_/Y }
C {devices/lab_pin.sym} 69860 -41570 0 1 {name=p68803 lab=_53564_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -41570 0 0 {name=X_53564_ }
C {devices/lab_pin.sym} 69690 -41430 0 0 {name=p68804 lab=_84518_/CLK }
C {devices/lab_pin.sym} 69690 -41410 0 0 {name=p68805 lab=_62767_/Y }
C {devices/lab_pin.sym} 69870 -41430 0 1 {name=p68806 lab=_62766_/C }
C {sky130_stdcells/dfxtp_4.sym} 69780 -41420 0 0 {name=X_84384_ }
C {devices/lab_pin.sym} 69740 -41290 0 0 {name=p68807 lab=_50505_/A }
C {devices/lab_pin.sym} 69820 -41290 0 1 {name=p68808 lab=_50777_/A }
C {sky130_stdcells/buf_2.sym} 69780 -41290 0 0 {name=X_50776_ }
C {devices/lab_pin.sym} 69690 -41170 0 0 {name=p68809 lab=_81433_/CLK }
C {devices/lab_pin.sym} 69690 -41150 0 0 {name=p68810 lab=_84196_/Q }
C {devices/lab_pin.sym} 69870 -41170 0 1 {name=p68811 lab=_81596_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -41160 0 0 {name=X_81596_ }
C {devices/lab_pin.sym} 69740 -41030 0 0 {name=p68812 lab=clkbuf_8_112_0_CLK/X }
C {devices/lab_pin.sym} 69820 -41030 0 1 {name=p68813 lab=clkbuf_9_224_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 69780 -41030 0 0 {name=Xclkbuf_9_224_0_CLK }
C {devices/lab_pin.sym} 69720 -40920 0 0 {name=p68814 lab=_55317_/A }
C {devices/lab_pin.sym} 69720 -40880 0 0 {name=p68815 lab=_57419_/A }
C {devices/lab_pin.sym} 69840 -40900 0 1 {name=p68816 lab=_55303_/X }
C {sky130_stdcells/and2_4.sym} 69780 -40900 0 0 {name=X_55303_ }
C {devices/lab_pin.sym} 69690 -40770 0 0 {name=p68817 lab=_86029_/CLK }
C {devices/lab_pin.sym} 69690 -40750 0 0 {name=p68818 lab=_86123_/D }
C {devices/lab_pin.sym} 69870 -40770 0 1 {name=p68819 lab=_86123_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -40760 0 0 {name=X_86123_ }
C {devices/lab_pin.sym} 69740 -40630 0 0 {name=p68820 lab=_52515_/A }
C {devices/lab_pin.sym} 69820 -40630 0 1 {name=p68821 lab=_52515_/X }
C {sky130_stdcells/buf_2.sym} 69780 -40630 0 0 {name=X_52515_ }
C {devices/lab_pin.sym} 69700 -40530 0 0 {name=p68822 lab=_59048_/X }
C {devices/lab_pin.sym} 69700 -40490 0 0 {name=p68823 lab=_85659_/Q }
C {devices/lab_pin.sym} 69700 -40450 0 0 {name=p68824 lab=_59070_/X }
C {devices/lab_pin.sym} 69860 -40490 0 1 {name=p68825 lab=_59071_/X }
C {sky130_stdcells/o21a_4.sym} 69780 -40490 0 0 {name=X_59071_ }
C {devices/lab_pin.sym} 69690 -40350 0 0 {name=p68826 lab=_83335_/CLK }
C {devices/lab_pin.sym} 69690 -40330 0 0 {name=p68827 lab=_71901_/Y }
C {devices/lab_pin.sym} 69870 -40350 0 1 {name=p68828 lab=_83335_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -40340 0 0 {name=X_83335_ }
C {devices/lab_pin.sym} 69740 -40210 0 0 {name=p68829 lab=_56282_/Y }
C {devices/lab_pin.sym} 69820 -40210 0 1 {name=p68830 lab=_56350_/A }
C {sky130_stdcells/buf_2.sym} 69780 -40210 0 0 {name=X_56283_ }
C {devices/lab_pin.sym} 69720 -40100 0 0 {name=p68831 lab=_84770_/Q }
C {devices/lab_pin.sym} 69720 -40060 0 0 {name=p68832 lab=_84162_/Q }
C {devices/lab_pin.sym} 69840 -40080 0 1 {name=p68833 lab=_80547_/X }
C {sky130_stdcells/xor2_4.sym} 69780 -40080 0 0 {name=X_80547_ }
C {devices/lab_pin.sym} 69700 -39970 0 0 {name=p68834 lab=_67656_/X }
C {devices/lab_pin.sym} 69700 -39930 0 0 {name=p68835 lab=_67660_/X }
C {devices/lab_pin.sym} 69700 -39890 0 0 {name=p68836 lab=_68260_/X }
C {devices/lab_pin.sym} 69860 -39930 0 1 {name=p68837 lab=_68269_/Y }
C {sky130_stdcells/a21oi_4.sym} 69780 -39930 0 0 {name=X_68269_ }
C {devices/lab_pin.sym} 69720 -39800 0 0 {name=p68838 lab=_53478_/A }
C {devices/lab_pin.sym} 69720 -39760 0 0 {name=p68839 lab=_73765_/A }
C {devices/lab_pin.sym} 69840 -39780 0 1 {name=p68840 lab=_53495_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -39780 0 0 {name=X_53495_ }
C {devices/lab_pin.sym} 69740 -39650 0 0 {name=p68841 lab=clkbuf_9_59_0_CLK/X }
C {devices/lab_pin.sym} 69820 -39650 0 1 {name=p68842 lab=_84392_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 69780 -39650 0 0 {name=Xclkbuf_10_118_0_CLK }
C {devices/lab_pin.sym} 69700 -39550 0 0 {name=p68843 lab=_57939_/X }
C {devices/lab_pin.sym} 69700 -39510 0 0 {name=p68844 lab=_85996_/Q }
C {devices/lab_pin.sym} 69700 -39470 0 0 {name=p68845 lab=_58021_/X }
C {devices/lab_pin.sym} 69860 -39510 0 1 {name=p68846 lab=_58022_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -39510 0 0 {name=X_58022_ }
C {devices/lab_pin.sym} 69700 -39390 0 0 {name=p68847 lab=_70289_/X }
C {devices/lab_pin.sym} 69700 -39350 0 0 {name=p68848 lab=_74783_/A }
C {devices/lab_pin.sym} 69700 -39310 0 0 {name=p68849 lab=_70299_/X }
C {devices/lab_pin.sym} 69860 -39350 0 1 {name=p68850 lab=_70300_/X }
C {sky130_stdcells/a21o_4.sym} 69780 -39350 0 0 {name=X_70300_ }
C {devices/lab_pin.sym} 69740 -39210 0 0 {name=p68851 lab=_55129_/A }
C {devices/lab_pin.sym} 69820 -39210 0 1 {name=p68852 lab=_55235_/A }
C {sky130_stdcells/buf_2.sym} 69780 -39210 0 0 {name=X_55234_ }
C {devices/lab_pin.sym} 69690 -39090 0 0 {name=p68853 lab=_86054_/CLK }
C {devices/lab_pin.sym} 69690 -39070 0 0 {name=p68854 lab=_51208_/Y }
C {devices/lab_pin.sym} 69870 -39090 0 1 {name=p68855 lab=_86054_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -39080 0 0 {name=X_86054_ }
C {devices/lab_pin.sym} 69700 -38990 0 0 {name=p68856 lab=_40437_/X }
C {devices/lab_pin.sym} 69700 -38950 0 0 {name=p68857 lab=_40443_/X }
C {devices/lab_pin.sym} 69700 -38910 0 0 {name=p68858 lab=_40459_/X }
C {devices/lab_pin.sym} 69700 -38870 0 0 {name=p68859 lab=_88388_/Q }
C {devices/lab_pin.sym} 69700 -38830 0 0 {name=p68860 lab=_40447_/X }
C {devices/lab_pin.sym} 69860 -38910 0 1 {name=p68861 lab=_40461_/A }
C {sky130_stdcells/o32ai_4.sym} 69780 -38910 0 0 {name=X_40460_ }
C {devices/lab_pin.sym} 69720 -38770 0 0 {name=p68862 lab=_51256_/A }
C {devices/lab_pin.sym} 69720 -38730 0 0 {name=p68863 lab=_52446_/B }
C {devices/lab_pin.sym} 69720 -38690 0 0 {name=p68864 lab=_52369_/X }
C {devices/lab_pin.sym} 69840 -38730 0 1 {name=p68865 lab=_52446_/X }
C {sky130_stdcells/and3_4.sym} 69780 -38730 0 0 {name=X_52446_ }
C {devices/lab_pin.sym} 69690 -38590 0 0 {name=p68866 lab=_86289_/CLK }
C {devices/lab_pin.sym} 69690 -38570 0 0 {name=p68867 lab=_72312_/Y }
C {devices/lab_pin.sym} 69870 -38590 0 1 {name=p68868 lab=_83266_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -38580 0 0 {name=X_83266_ }
C {devices/lab_pin.sym} 69700 -38470 0 0 {name=p68869 lab=_53205_/B }
C {devices/lab_pin.sym} 69700 -38430 0 0 {name=p68870 lab=_71265_/X }
C {devices/lab_pin.sym} 69700 -38390 0 0 {name=p68871 lab=_71279_/Y }
C {devices/lab_pin.sym} 69860 -38430 0 1 {name=p68872 lab=_71280_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -38430 0 0 {name=X_71280_ }
C {devices/lab_pin.sym} 69720 -38300 0 0 {name=p68873 lab=_80478_/A }
C {devices/lab_pin.sym} 69720 -38260 0 0 {name=p68874 lab=_80478_/B }
C {devices/lab_pin.sym} 69840 -38280 0 1 {name=p68875 lab=_80478_/X }
C {sky130_stdcells/or2_4.sym} 69780 -38280 0 0 {name=X_80478_ }
C {devices/lab_pin.sym} 69740 -38150 0 0 {name=p68876 lab=clkbuf_9_374_0_CLK/X }
C {devices/lab_pin.sym} 69820 -38150 0 1 {name=p68877 lab=_88001_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 69780 -38150 0 0 {name=Xclkbuf_10_748_0_CLK }
C {devices/lab_pin.sym} 69690 -38030 0 0 {name=p68878 lab=_85005_/CLK }
C {devices/lab_pin.sym} 69690 -38010 0 0 {name=p68879 lab=_57434_/Y }
C {devices/lab_pin.sym} 69870 -38030 0 1 {name=p68880 lab=_57430_/A }
C {sky130_stdcells/dfxtp_4.sym} 69780 -38020 0 0 {name=X_85005_ }
C {devices/lab_pin.sym} 69740 -37890 0 0 {name=p68881 lab=_70231_/A }
C {devices/lab_pin.sym} 69820 -37890 0 1 {name=p68882 lab=_70239_/A }
C {sky130_stdcells/buf_2.sym} 69780 -37890 0 0 {name=X_70231_ }
C {devices/lab_pin.sym} 69690 -37770 0 0 {name=p68883 lab=_83905_/CLK }
C {devices/lab_pin.sym} 69690 -37750 0 0 {name=p68884 lab=_82249_/Q }
C {devices/lab_pin.sym} 69870 -37770 0 1 {name=p68885 lab=_82217_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -37760 0 0 {name=X_82217_ }
C {devices/lab_pin.sym} 69740 -37630 0 0 {name=p68886 lab=_55134_/X }
C {devices/lab_pin.sym} 69820 -37630 0 1 {name=p68887 lab=_55165_/X }
C {sky130_stdcells/buf_2.sym} 69780 -37630 0 0 {name=X_55165_ }
C {devices/lab_pin.sym} 69740 -37510 0 0 {name=p68888 lab=_40390_/Y }
C {devices/lab_pin.sym} 69820 -37510 0 1 {name=p68889 lab=_40391_/X }
C {sky130_stdcells/buf_2.sym} 69780 -37510 0 0 {name=X_40391_ }
C {devices/lab_pin.sym} 69720 -37410 0 0 {name=p68890 lab=_50677_/A }
C {devices/lab_pin.sym} 69720 -37370 0 0 {name=p68891 lab=_52446_/B }
C {devices/lab_pin.sym} 69720 -37330 0 0 {name=p68892 lab=_52369_/X }
C {devices/lab_pin.sym} 69840 -37370 0 1 {name=p68893 lab=_52377_/X }
C {sky130_stdcells/and3_4.sym} 69780 -37370 0 0 {name=X_52377_ }
C {devices/lab_pin.sym} 69690 -37230 0 0 {name=p68894 lab=_85013_/CLK }
C {devices/lab_pin.sym} 69690 -37210 0 0 {name=p68895 lab=_83197_/D }
C {devices/lab_pin.sym} 69870 -37230 0 1 {name=p68896 lab=_83197_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -37220 0 0 {name=X_83197_ }
C {devices/lab_pin.sym} 69740 -37090 0 0 {name=p68897 lab=clkbuf_9_239_0_CLK/A }
C {devices/lab_pin.sym} 69820 -37090 0 1 {name=p68898 lab=clkbuf_9_239_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 69780 -37090 0 0 {name=Xclkbuf_9_239_0_CLK }
C {devices/lab_pin.sym} 69700 -37000 0 0 {name=p68899 lab=_41108_/X }
C {devices/lab_pin.sym} 69700 -36960 0 0 {name=p68900 lab=_42125_/X }
C {devices/lab_pin.sym} 69700 -36920 0 0 {name=p68901 lab=_88020_/Q }
C {devices/lab_pin.sym} 69700 -36880 0 0 {name=p68902 lab=_42126_/X }
C {devices/lab_pin.sym} 69860 -36940 0 1 {name=p68903 lab=_88020_/D }
C {sky130_stdcells/a2bb2o_4.sym} 69780 -36940 0 0 {name=X_42130_ }
C {devices/lab_pin.sym} 69700 -36810 0 0 {name=p68904 lab=_85501_/Q }
C {devices/lab_pin.sym} 69700 -36770 0 0 {name=p68905 lab=_54113_/X }
C {devices/lab_pin.sym} 69700 -36730 0 0 {name=p68906 lab=_54115_/Y }
C {devices/lab_pin.sym} 69860 -36770 0 1 {name=p68907 lab=_54116_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -36770 0 0 {name=X_54116_ }
C {devices/lab_pin.sym} 69720 -36640 0 0 {name=p68908 lab=_51310_/X }
C {devices/lab_pin.sym} 69720 -36600 0 0 {name=p68909 lab=_51328_/B }
C {devices/lab_pin.sym} 69840 -36620 0 1 {name=p68910 lab=_51328_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -36620 0 0 {name=X_51328_ }
C {devices/lab_pin.sym} 69740 -36490 0 0 {name=p68911 lab=_70348_/B }
C {devices/lab_pin.sym} 69820 -36490 0 1 {name=p68912 lab=_70162_/X }
C {sky130_stdcells/buf_2.sym} 69780 -36490 0 0 {name=X_70162_ }
C {devices/lab_pin.sym} 69690 -36370 0 0 {name=p68913 lab=_84231_/CLK }
C {devices/lab_pin.sym} 69690 -36350 0 0 {name=p68914 lab=_84140_/Q }
C {devices/lab_pin.sym} 69870 -36370 0 1 {name=p68915 lab=_82148_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -36360 0 0 {name=X_82148_ }
C {devices/lab_pin.sym} 69720 -36260 0 0 {name=p68916 lab=_55112_/A }
C {devices/lab_pin.sym} 69720 -36220 0 0 {name=p68917 lab=_55104_/B }
C {devices/lab_pin.sym} 69720 -36180 0 0 {name=p68918 lab=_55083_/C }
C {devices/lab_pin.sym} 69720 -36140 0 0 {name=p68919 lab=_47776_/A }
C {devices/lab_pin.sym} 69840 -36200 0 1 {name=p68920 lab=_55096_/X }
C {sky130_stdcells/and4_4.sym} 69780 -36200 0 0 {name=X_55096_ }
C {devices/lab_pin.sym} 69740 -36050 0 0 {name=p68921 lab=_59973_/A }
C {devices/lab_pin.sym} 69820 -36050 0 1 {name=p68922 lab=_59977_/B }
C {sky130_stdcells/buf_2.sym} 69780 -36050 0 0 {name=X_59973_ }
C {devices/lab_pin.sym} 69740 -35930 0 0 {name=p68923 lab=_88053_/Q }
C {devices/lab_pin.sym} 69820 -35930 0 1 {name=p68924 lab=_42061_/Y }
C {sky130_stdcells/inv_2.sym} 69780 -35930 0 0 {name=X_42061_ }
C {devices/lab_pin.sym} 69700 -35850 0 0 {name=p68925 lab=_58918_/X }
C {devices/lab_pin.sym} 69700 -35810 0 0 {name=p68926 lab=_58920_/Y }
C {devices/lab_pin.sym} 69700 -35770 0 0 {name=p68927 lab=_58921_/Y }
C {devices/lab_pin.sym} 69700 -35730 0 0 {name=p68928 lab=_58874_/X }
C {devices/lab_pin.sym} 69700 -35690 0 0 {name=p68929 lab=_58923_/X }
C {devices/lab_pin.sym} 69860 -35770 0 1 {name=p68930 lab=_58924_/X }
C {sky130_stdcells/o32a_4.sym} 69780 -35770 0 0 {name=X_58924_ }
C {devices/lab_pin.sym} 69720 -35630 0 0 {name=p68931 lab=_54047_/A }
C {devices/lab_pin.sym} 69720 -35590 0 0 {name=p68932 lab=_54043_/B }
C {devices/lab_pin.sym} 69720 -35550 0 0 {name=p68933 lab=_51749_/X }
C {devices/lab_pin.sym} 69840 -35590 0 1 {name=p68934 lab=_54047_/X }
C {sky130_stdcells/and3_4.sym} 69780 -35590 0 0 {name=X_54047_ }
C {devices/lab_pin.sym} 69740 -35450 0 0 {name=p68935 lab=_51259_/A }
C {devices/lab_pin.sym} 69820 -35450 0 1 {name=p68936 lab=_51259_/X }
C {sky130_stdcells/buf_2.sym} 69780 -35450 0 0 {name=X_51259_ }
C {devices/lab_pin.sym} 69720 -35340 0 0 {name=p68937 lab=_81140_/D }
C {devices/lab_pin.sym} 69720 -35300 0 0 {name=p68938 lab=_74989_/C }
C {devices/lab_pin.sym} 69840 -35320 0 1 {name=p68939 lab=_74987_/A }
C {sky130_stdcells/xor2_4.sym} 69780 -35320 0 0 {name=X_74970_ }
C {devices/lab_pin.sym} 69700 -35220 0 0 {name=p68940 lab=_70011_/X }
C {devices/lab_pin.sym} 69700 -35180 0 0 {name=p68941 lab=_69094_/Y }
C {devices/lab_pin.sym} 69700 -35140 0 0 {name=p68942 lab=_70081_/X }
C {devices/lab_pin.sym} 69700 -35100 0 0 {name=p68943 lab=_70092_/Y }
C {devices/lab_pin.sym} 69860 -35160 0 1 {name=p68944 lab=_70093_/X }
C {sky130_stdcells/a211o_4.sym} 69780 -35160 0 0 {name=X_70093_ }
C {devices/lab_pin.sym} 69690 -35010 0 0 {name=p68945 lab=_88224_/CLK }
C {devices/lab_pin.sym} 69690 -34990 0 0 {name=p68946 lab=_86956_/D }
C {devices/lab_pin.sym} 69870 -35010 0 1 {name=p68947 lab=_86956_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -35000 0 0 {name=X_86956_ }
C {devices/lab_pin.sym} 69690 -34870 0 0 {name=p68948 lab=_81169_/CLK }
C {devices/lab_pin.sym} 69690 -34850 0 0 {name=p68949 lab=_82079_/D }
C {devices/lab_pin.sym} 69870 -34870 0 1 {name=p68950 lab=_82079_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -34860 0 0 {name=X_82079_ }
C {devices/lab_pin.sym} 69740 -34730 0 0 {name=p68951 lab=_40321_/A }
C {devices/lab_pin.sym} 69820 -34730 0 1 {name=p68952 lab=_41013_/A }
C {sky130_stdcells/buf_2.sym} 69780 -34730 0 0 {name=X_41012_ }
C {devices/lab_pin.sym} 69720 -34620 0 0 {name=p68953 lab=_73921_/A }
C {devices/lab_pin.sym} 69720 -34580 0 0 {name=p68954 lab=_56181_/X }
C {devices/lab_pin.sym} 69840 -34600 0 1 {name=p68955 lab=_73921_/Y }
C {sky130_stdcells/nor2_4.sym} 69780 -34600 0 0 {name=X_73921_ }
C {devices/lab_pin.sym} 69690 -34470 0 0 {name=p68956 lab=_86549_/CLK }
C {devices/lab_pin.sym} 69690 -34450 0 0 {name=p68957 lab=_85907_/D }
C {devices/lab_pin.sym} 69870 -34470 0 1 {name=p68958 lab=_73901_/B }
C {sky130_stdcells/dfxtp_4.sym} 69780 -34460 0 0 {name=X_85907_ }
C {devices/lab_pin.sym} 69700 -34360 0 0 {name=p68959 lab=_58843_/Y }
C {devices/lab_pin.sym} 69700 -34320 0 0 {name=p68960 lab=_58739_/X }
C {devices/lab_pin.sym} 69700 -34280 0 0 {name=p68961 lab=_58850_/X }
C {devices/lab_pin.sym} 69700 -34240 0 0 {name=p68962 lab=_58854_/X }
C {devices/lab_pin.sym} 69860 -34300 0 1 {name=p68963 lab=_84795_/D }
C {sky130_stdcells/a22oi_4.sym} 69780 -34300 0 0 {name=X_58855_ }
C {devices/lab_pin.sym} 69690 -34150 0 0 {name=p68964 lab=_86887_/CLK }
C {devices/lab_pin.sym} 69690 -34130 0 0 {name=p68965 lab=_45280_/Y }
C {devices/lab_pin.sym} 69870 -34150 0 1 {name=p68966 lab=_62557_/A }
C {sky130_stdcells/dfxtp_4.sym} 69780 -34140 0 0 {name=X_86887_ }
C {devices/lab_pin.sym} 69740 -34010 0 0 {name=p68967 lab=_58080_/A }
C {devices/lab_pin.sym} 69820 -34010 0 1 {name=p68968 lab=_57806_/X }
C {sky130_stdcells/buf_2.sym} 69780 -34010 0 0 {name=X_57806_ }
C {devices/lab_pin.sym} 69740 -33890 0 0 {name=p68969 lab=_63314_/B }
C {devices/lab_pin.sym} 69820 -33890 0 1 {name=p68970 lab=_61655_/A }
C {sky130_stdcells/buf_2.sym} 69780 -33890 0 0 {name=X_45820_ }
C {devices/lab_pin.sym} 69720 -33790 0 0 {name=p68971 lab=_76640_/A }
C {devices/lab_pin.sym} 69720 -33750 0 0 {name=p68972 lab=_76640_/B }
C {devices/lab_pin.sym} 69720 -33710 0 0 {name=p68973 lab=_76637_/X }
C {devices/lab_pin.sym} 69840 -33750 0 1 {name=p68974 lab=_76640_/Y }
C {sky130_stdcells/nand3_4.sym} 69780 -33750 0 0 {name=X_76640_ }
C {devices/lab_pin.sym} 69720 -33620 0 0 {name=p68975 lab=_73949_/A }
C {devices/lab_pin.sym} 69720 -33580 0 0 {name=p68976 lab=_66082_/B }
C {devices/lab_pin.sym} 69840 -33600 0 1 {name=p68977 lab=_73852_/X }
C {sky130_stdcells/and2_4.sym} 69780 -33600 0 0 {name=X_73852_ }
C {devices/lab_pin.sym} 69690 -33470 0 0 {name=p68978 lab=_85536_/CLK }
C {devices/lab_pin.sym} 69690 -33450 0 0 {name=p68979 lab=_85838_/D }
C {devices/lab_pin.sym} 69870 -33470 0 1 {name=p68980 lab=_65094_/B }
C {sky130_stdcells/dfxtp_4.sym} 69780 -33460 0 0 {name=X_85838_ }
C {devices/lab_pin.sym} 69740 -33330 0 0 {name=p68981 lab=_64836_/A }
C {devices/lab_pin.sym} 69820 -33330 0 1 {name=p68982 lab=_59061_/A }
C {sky130_stdcells/buf_2.sym} 69780 -33330 0 0 {name=X_58786_ }
C {devices/lab_pin.sym} 69740 -33210 0 0 {name=p68983 lab=_55891_/X }
C {devices/lab_pin.sym} 69820 -33210 0 1 {name=p68984 lab=_74312_/C }
C {sky130_stdcells/buf_2.sym} 69780 -33210 0 0 {name=X_55998_ }
C {devices/lab_pin.sym} 69740 -33090 0 0 {name=p68985 lab=_72732_/B }
C {devices/lab_pin.sym} 69820 -33090 0 1 {name=p68986 lab=_72803_/X }
C {sky130_stdcells/buf_2.sym} 69780 -33090 0 0 {name=X_72803_ }
C {devices/lab_pin.sym} 69700 -32990 0 0 {name=p68987 lab=_45742_/X }
C {devices/lab_pin.sym} 69700 -32950 0 0 {name=p68988 lab=_45747_/Y }
C {devices/lab_pin.sym} 69700 -32910 0 0 {name=p68989 lab=_45750_/Y }
C {devices/lab_pin.sym} 69860 -32950 0 1 {name=p68990 lab=_45751_/Y }
C {sky130_stdcells/a21oi_4.sym} 69780 -32950 0 0 {name=X_45751_ }
C {devices/lab_pin.sym} 69700 -32830 0 0 {name=p68991 lab=_57705_/X }
C {devices/lab_pin.sym} 69700 -32790 0 0 {name=p68992 lab=_85503_/Q }
C {devices/lab_pin.sym} 69700 -32750 0 0 {name=p68993 lab=_57736_/X }
C {devices/lab_pin.sym} 69860 -32790 0 1 {name=p68994 lab=_57737_/X }
C {sky130_stdcells/o21a_4.sym} 69780 -32790 0 0 {name=X_57737_ }
C {devices/lab_pin.sym} 69720 -32660 0 0 {name=p68995 lab=_76568_/Y }
C {devices/lab_pin.sym} 69720 -32620 0 0 {name=p68996 lab=_76571_/B }
C {devices/lab_pin.sym} 69840 -32640 0 1 {name=p68997 lab=_81341_/D }
C {sky130_stdcells/nor2_4.sym} 69780 -32640 0 0 {name=X_76571_ }
C {devices/lab_pin.sym} 69740 -32510 0 0 {name=p68998 lab=_42951_/A }
C {devices/lab_pin.sym} 69820 -32510 0 1 {name=p68999 lab=_42963_/X }
C {sky130_stdcells/buf_2.sym} 69780 -32510 0 0 {name=X_42963_ }
C {devices/lab_pin.sym} 69700 -32410 0 0 {name=p69000 lab=_85347_/Q }
C {devices/lab_pin.sym} 69700 -32370 0 0 {name=p69001 lab=_53449_/X }
C {devices/lab_pin.sym} 69700 -32330 0 0 {name=p69002 lab=_54948_/Y }
C {devices/lab_pin.sym} 69860 -32370 0 1 {name=p69003 lab=_54949_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -32370 0 0 {name=X_54949_ }
C {devices/lab_pin.sym} 69720 -32240 0 0 {name=p69004 lab=_73711_/A }
C {devices/lab_pin.sym} 69720 -32200 0 0 {name=p69005 lab=_66037_/B }
C {devices/lab_pin.sym} 69840 -32220 0 1 {name=p69006 lab=_73783_/X }
C {sky130_stdcells/and2_4.sym} 69780 -32220 0 0 {name=X_73783_ }
C {devices/lab_pin.sym} 69690 -32090 0 0 {name=p69007 lab=_85770_/CLK }
C {devices/lab_pin.sym} 69690 -32070 0 0 {name=p69008 lab=_52710_/Y }
C {devices/lab_pin.sym} 69870 -32090 0 1 {name=p69009 lab=_85769_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -32080 0 0 {name=X_85769_ }
C {devices/lab_pin.sym} 69720 -31970 0 0 {name=p69010 lab=_70990_/A }
C {devices/lab_pin.sym} 69720 -31930 0 0 {name=p69011 lab=_71080_/B }
C {devices/lab_pin.sym} 69720 -31890 0 0 {name=p69012 lab=_70990_/C }
C {devices/lab_pin.sym} 69840 -31930 0 1 {name=p69013 lab=_70995_/Y }
C {sky130_stdcells/nand3_4.sym} 69780 -31930 0 0 {name=X_70995_ }
C {devices/lab_pin.sym} 69740 -31790 0 0 {name=p69014 lab=_78309_/Y }
C {devices/lab_pin.sym} 69820 -31790 0 1 {name=p69015 lab=_78310_/Y }
C {sky130_stdcells/inv_2.sym} 69780 -31790 0 0 {name=X_78310_ }
C {devices/lab_pin.sym} 69740 -31670 0 0 {name=p69016 lab=_44702_/A }
C {devices/lab_pin.sym} 69820 -31670 0 1 {name=p69017 lab=_44702_/Y }
C {sky130_stdcells/inv_2.sym} 69780 -31670 0 0 {name=X_44702_ }
C {devices/lab_pin.sym} 69740 -31550 0 0 {name=p69018 lab=_75522_/A }
C {devices/lab_pin.sym} 69820 -31550 0 1 {name=p69019 lab=_75524_/B }
C {sky130_stdcells/inv_2.sym} 69780 -31550 0 0 {name=X_75522_ }
C {devices/lab_pin.sym} 69690 -31430 0 0 {name=p69020 lab=_87253_/CLK }
C {devices/lab_pin.sym} 69690 -31410 0 0 {name=p69021 lab=_43268_/X }
C {devices/lab_pin.sym} 69870 -31430 0 1 {name=p69022 lab=_87508_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -31420 0 0 {name=X_87508_ }
C {devices/lab_pin.sym} 69740 -31290 0 0 {name=p69023 lab=_41914_/A }
C {devices/lab_pin.sym} 69820 -31290 0 1 {name=p69024 lab=_41914_/Y }
C {sky130_stdcells/inv_2.sym} 69780 -31290 0 0 {name=X_41914_ }
C {devices/lab_pin.sym} 69700 -31190 0 0 {name=p69025 lab=_65584_/B }
C {devices/lab_pin.sym} 69700 -31150 0 0 {name=p69026 lab=_48419_/X }
C {devices/lab_pin.sym} 69700 -31110 0 0 {name=p69027 lab=_48469_/Y }
C {devices/lab_pin.sym} 69860 -31150 0 1 {name=p69028 lab=_48470_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -31150 0 0 {name=X_48470_ }
C {devices/lab_pin.sym} 69740 -31010 0 0 {name=p69029 lab=_44131_/A }
C {devices/lab_pin.sym} 69820 -31010 0 1 {name=p69030 lab=_73262_/A }
C {sky130_stdcells/buf_2.sym} 69780 -31010 0 0 {name=X_72734_ }
C {devices/lab_pin.sym} 69720 -30900 0 0 {name=p69031 lab=_79286_/X }
C {devices/lab_pin.sym} 69720 -30860 0 0 {name=p69032 lab=_79304_/B }
C {devices/lab_pin.sym} 69840 -30880 0 1 {name=p69033 lab=_79291_/A }
C {sky130_stdcells/xor2_4.sym} 69780 -30880 0 0 {name=X_79290_ }
C {devices/lab_pin.sym} 69740 -30750 0 0 {name=p69034 lab=_57668_/A }
C {devices/lab_pin.sym} 69820 -30750 0 1 {name=p69035 lab=_57668_/Y }
C {sky130_stdcells/inv_2.sym} 69780 -30750 0 0 {name=X_57668_ }
C {devices/lab_pin.sym} 69720 -30640 0 0 {name=p69036 lab=_74667_/B }
C {devices/lab_pin.sym} 69720 -30600 0 0 {name=p69037 lab=_45654_/B }
C {devices/lab_pin.sym} 69840 -30620 0 1 {name=p69038 lab=_45682_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -30620 0 0 {name=X_45682_ }
C {devices/lab_pin.sym} 69700 -30520 0 0 {name=p69039 lab=_41651_/X }
C {devices/lab_pin.sym} 69700 -30480 0 0 {name=p69040 lab=_42886_/X }
C {devices/lab_pin.sym} 69700 -30440 0 0 {name=p69041 lab=_87663_/Q }
C {devices/lab_pin.sym} 69700 -30400 0 0 {name=p69042 lab=_42887_/X }
C {devices/lab_pin.sym} 69860 -30460 0 1 {name=p69043 lab=_87663_/D }
C {sky130_stdcells/a2bb2o_4.sym} 69780 -30460 0 0 {name=X_42894_ }
C {devices/lab_pin.sym} 69740 -30310 0 0 {name=p69044 lab=_47420_/Y }
C {devices/lab_pin.sym} 69820 -30310 0 1 {name=p69045 lab=_53041_/B }
C {sky130_stdcells/buf_2.sym} 69780 -30310 0 0 {name=X_47421_ }
C {devices/lab_pin.sym} 69720 -30200 0 0 {name=p69046 lab=_59407_/A }
C {devices/lab_pin.sym} 69720 -30160 0 0 {name=p69047 lab=_59399_/B }
C {devices/lab_pin.sym} 69840 -30180 0 1 {name=p69048 lab=_59407_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -30180 0 0 {name=X_59407_ }
C {devices/lab_pin.sym} 69720 -30060 0 0 {name=p69049 lab=_78241_/A }
C {devices/lab_pin.sym} 69720 -30020 0 0 {name=p69050 lab=_78241_/B }
C {devices/lab_pin.sym} 69840 -30040 0 1 {name=p69051 lab=_78241_/X }
C {sky130_stdcells/or2_4.sym} 69780 -30040 0 0 {name=X_78241_ }
C {devices/lab_pin.sym} 69740 -29910 0 0 {name=p69052 lab=_44633_/A }
C {devices/lab_pin.sym} 69820 -29910 0 1 {name=p69053 lab=_44633_/Y }
C {sky130_stdcells/inv_2.sym} 69780 -29910 0 0 {name=X_44633_ }
C {devices/lab_pin.sym} 69740 -29790 0 0 {name=p69054 lab=_56619_/A }
C {devices/lab_pin.sym} 69820 -29790 0 1 {name=p69055 lab=_56619_/X }
C {sky130_stdcells/buf_2.sym} 69780 -29790 0 0 {name=X_56619_ }
C {devices/lab_pin.sym} 69740 -29670 0 0 {name=p69056 lab=_81084_/Q }
C {devices/lab_pin.sym} 69820 -29670 0 1 {name=p69057 lab=_75457_/A }
C {sky130_stdcells/inv_2.sym} 69780 -29670 0 0 {name=X_75453_ }
C {devices/lab_pin.sym} 69690 -29550 0 0 {name=p69058 lab=_87484_/CLK }
C {devices/lab_pin.sym} 69690 -29530 0 0 {name=p69059 lab=_43402_/X }
C {devices/lab_pin.sym} 69870 -29550 0 1 {name=p69060 lab=_87439_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -29540 0 0 {name=X_87439_ }
C {devices/lab_pin.sym} 69700 -29450 0 0 {name=p69061 lab=_41839_/X }
C {devices/lab_pin.sym} 69700 -29410 0 0 {name=p69062 lab=_41841_/X }
C {devices/lab_pin.sym} 69700 -29370 0 0 {name=p69063 lab=_40501_/X }
C {devices/lab_pin.sym} 69700 -29330 0 0 {name=p69064 lab=_88125_/Q }
C {devices/lab_pin.sym} 69700 -29290 0 0 {name=p69065 lab=_41835_/X }
C {devices/lab_pin.sym} 69860 -29370 0 1 {name=p69066 lab=_41846_/A }
C {sky130_stdcells/o32ai_4.sym} 69780 -29370 0 0 {name=X_41845_ }
C {devices/lab_pin.sym} 69700 -29230 0 0 {name=p69067 lab=_70205_/C }
C {devices/lab_pin.sym} 69700 -29190 0 0 {name=p69068 lab=_72658_/X }
C {devices/lab_pin.sym} 69700 -29150 0 0 {name=p69069 lab=_72664_/Y }
C {devices/lab_pin.sym} 69860 -29190 0 1 {name=p69070 lab=_83198_/D }
C {sky130_stdcells/a21bo_4.sym} 69780 -29190 0 0 {name=X_72665_ }
C {devices/lab_pin.sym} 69720 -29060 0 0 {name=p69071 lab=_57564_/X }
C {devices/lab_pin.sym} 69720 -29020 0 0 {name=p69072 lab=_53567_/B }
C {devices/lab_pin.sym} 69840 -29040 0 1 {name=p69073 lab=_57599_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -29040 0 0 {name=X_57599_ }
C {devices/lab_pin.sym} 69700 -28930 0 0 {name=p69074 lab=_83073_/Q }
C {devices/lab_pin.sym} 69700 -28890 0 0 {name=p69075 lab=_74377_/X }
C {devices/lab_pin.sym} 69700 -28850 0 0 {name=p69076 lab=_74403_/Y }
C {devices/lab_pin.sym} 69860 -28890 0 1 {name=p69077 lab=_74404_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -28890 0 0 {name=X_74404_ }
C {devices/lab_pin.sym} 69740 -28750 0 0 {name=p69078 lab=_47352_/A }
C {devices/lab_pin.sym} 69820 -28750 0 1 {name=p69079 lab=_52999_/B }
C {sky130_stdcells/buf_2.sym} 69780 -28750 0 0 {name=X_47352_ }
C {devices/lab_pin.sym} 69700 -28660 0 0 {name=p69080 lab=_84750_/Q }
C {devices/lab_pin.sym} 69700 -28620 0 0 {name=p69081 lab=_59268_/X }
C {devices/lab_pin.sym} 69700 -28580 0 0 {name=p69082 lab=_59330_/X }
C {devices/lab_pin.sym} 69700 -28540 0 0 {name=p69083 lab=_59337_/X }
C {devices/lab_pin.sym} 69860 -28600 0 1 {name=p69084 lab=_59338_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 69780 -28600 0 0 {name=X_59338_ }
C {devices/lab_pin.sym} 69720 -28480 0 0 {name=p69085 lab=_70558_/X }
C {devices/lab_pin.sym} 69720 -28440 0 0 {name=p69086 lab=_70667_/A }
C {devices/lab_pin.sym} 69720 -28400 0 0 {name=p69087 lab=_71614_/C }
C {devices/lab_pin.sym} 69720 -28360 0 0 {name=p69088 lab=_71606_/X }
C {devices/lab_pin.sym} 69840 -28420 0 1 {name=p69089 lab=_71616_/Y }
C {sky130_stdcells/nor4_4.sym} 69780 -28420 0 0 {name=X_71616_ }
C {devices/lab_pin.sym} 69720 -28280 0 0 {name=p69090 lab=_78172_/A }
C {devices/lab_pin.sym} 69720 -28240 0 0 {name=p69091 lab=_78171_/Y }
C {devices/lab_pin.sym} 69840 -28260 0 1 {name=p69092 lab=_78173_/B }
C {sky130_stdcells/xnor2_4.sym} 69780 -28260 0 0 {name=X_78172_ }
C {devices/lab_pin.sym} 69740 -28130 0 0 {name=p69093 lab=_44564_/A }
C {devices/lab_pin.sym} 69820 -28130 0 1 {name=p69094 lab=_44564_/Y }
C {sky130_stdcells/inv_2.sym} 69780 -28130 0 0 {name=X_44564_ }
C {devices/lab_pin.sym} 69700 -28030 0 0 {name=p69095 lab=_75383_/B }
C {devices/lab_pin.sym} 69700 -27990 0 0 {name=p69096 lab=_75383_/C }
C {devices/lab_pin.sym} 69700 -27950 0 0 {name=p69097 lab=_75383_/A }
C {devices/lab_pin.sym} 69860 -27990 0 1 {name=p69098 lab=_75384_/X }
C {sky130_stdcells/o21a_4.sym} 69780 -27990 0 0 {name=X_75384_ }
C {devices/lab_pin.sym} 69720 -27860 0 0 {name=p69099 lab=_82885_/Q }
C {devices/lab_pin.sym} 69720 -27820 0 0 {name=p69100 lab=_46240_/A }
C {devices/lab_pin.sym} 69840 -27840 0 1 {name=p69101 lab=_41776_/X }
C {sky130_stdcells/or2_4.sym} 69780 -27840 0 0 {name=X_41776_ }
C {devices/lab_pin.sym} 69700 -27730 0 0 {name=p69102 lab=_79321_/B }
C {devices/lab_pin.sym} 69700 -27690 0 0 {name=p69103 lab=_60349_/X }
C {devices/lab_pin.sym} 69700 -27650 0 0 {name=p69104 lab=_72595_/X }
C {devices/lab_pin.sym} 69860 -27690 0 1 {name=p69105 lab=_72596_/X }
C {sky130_stdcells/o21a_4.sym} 69780 -27690 0 0 {name=X_72596_ }
C {devices/lab_pin.sym} 69720 -27560 0 0 {name=p69106 lab=_40842_/X }
C {devices/lab_pin.sym} 69720 -27520 0 0 {name=p69107 lab=_48924_/A }
C {devices/lab_pin.sym} 69840 -27540 0 1 {name=p69108 lab=_46303_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -27540 0 0 {name=X_46303_ }
C {devices/lab_pin.sym} 69720 -27420 0 0 {name=p69109 lab=_82099_/Q }
C {devices/lab_pin.sym} 69720 -27380 0 0 {name=p69110 lab=_77123_/B }
C {devices/lab_pin.sym} 69840 -27400 0 1 {name=p69111 lab=_77123_/X }
C {sky130_stdcells/xor2_4.sym} 69780 -27400 0 0 {name=X_77123_ }
C {devices/lab_pin.sym} 69700 -27300 0 0 {name=p69112 lab=_41782_/X }
C {devices/lab_pin.sym} 69700 -27260 0 0 {name=p69113 lab=_43513_/X }
C {devices/lab_pin.sym} 69700 -27220 0 0 {name=p69114 lab=_87382_/Q }
C {devices/lab_pin.sym} 69700 -27180 0 0 {name=p69115 lab=_43514_/X }
C {devices/lab_pin.sym} 69860 -27240 0 1 {name=p69116 lab=_87382_/D }
C {sky130_stdcells/a2bb2o_4.sym} 69780 -27240 0 0 {name=X_43515_ }
C {devices/lab_pin.sym} 69700 -27110 0 0 {name=p69117 lab=_70321_/C }
C {devices/lab_pin.sym} 69700 -27070 0 0 {name=p69118 lab=_74327_/X }
C {devices/lab_pin.sym} 69700 -27030 0 0 {name=p69119 lab=_74334_/Y }
C {devices/lab_pin.sym} 69860 -27070 0 1 {name=p69120 lab=_74335_/X }
C {sky130_stdcells/a21bo_4.sym} 69780 -27070 0 0 {name=X_74335_ }
C {devices/lab_pin.sym} 69720 -26940 0 0 {name=p69121 lab=_40727_/A }
C {devices/lab_pin.sym} 69720 -26900 0 0 {name=p69122 lab=_40710_/B }
C {devices/lab_pin.sym} 69840 -26920 0 1 {name=p69123 lab=_40727_/X }
C {sky130_stdcells/or2_4.sym} 69780 -26920 0 0 {name=X_40727_ }
C {devices/lab_pin.sym} 69720 -26800 0 0 {name=p69124 lab=_59256_/A }
C {devices/lab_pin.sym} 69720 -26760 0 0 {name=p69125 lab=_86347_/Q }
C {devices/lab_pin.sym} 69840 -26780 0 1 {name=p69126 lab=_59269_/Y }
C {sky130_stdcells/nor2_4.sym} 69780 -26780 0 0 {name=X_59269_ }
C {devices/lab_pin.sym} 69740 -26650 0 0 {name=p69127 lab=_47283_/A }
C {devices/lab_pin.sym} 69820 -26650 0 1 {name=p69128 lab=_52963_/D }
C {sky130_stdcells/buf_2.sym} 69780 -26650 0 0 {name=X_47283_ }
C {devices/lab_pin.sym} 69700 -26550 0 0 {name=p69129 lab=_71531_/X }
C {devices/lab_pin.sym} 69700 -26510 0 0 {name=p69130 lab=_83461_/Q }
C {devices/lab_pin.sym} 69700 -26470 0 0 {name=p69131 lab=_71546_/Y }
C {devices/lab_pin.sym} 69860 -26510 0 1 {name=p69132 lab=_83461_/D }
C {sky130_stdcells/a21o_4.sym} 69780 -26510 0 0 {name=X_71547_ }
C {devices/lab_pin.sym} 69740 -26370 0 0 {name=p69133 lab=_44495_/A }
C {devices/lab_pin.sym} 69820 -26370 0 1 {name=p69134 lab=_87080_/D }
C {sky130_stdcells/inv_2.sym} 69780 -26370 0 0 {name=X_44495_ }
C {devices/lab_pin.sym} 69740 -26250 0 0 {name=p69135 lab=_61355_/A }
C {devices/lab_pin.sym} 69820 -26250 0 1 {name=p69136 lab=_61305_/A }
C {sky130_stdcells/buf_2.sym} 69780 -26250 0 0 {name=X_61300_ }
C {devices/lab_pin.sym} 69720 -26140 0 0 {name=p69137 lab=_49022_/A }
C {devices/lab_pin.sym} 69720 -26100 0 0 {name=p69138 lab=_72025_/B }
C {devices/lab_pin.sym} 69840 -26120 0 1 {name=p69139 lab=_49022_/X }
C {sky130_stdcells/and2_4.sym} 69780 -26120 0 0 {name=X_49022_ }
C {devices/lab_pin.sym} 69740 -25990 0 0 {name=p69140 lab=_46233_/Y }
C {devices/lab_pin.sym} 69820 -25990 0 1 {name=p69141 lab=_46234_/Y }
C {sky130_stdcells/inv_2.sym} 69780 -25990 0 0 {name=X_46234_ }
C {sky130_stdcells/decap_3.sym} 69780 -25840 0 0 {name=XPHY_460 }
C {devices/lab_pin.sym} 69720 -25700 0 0 {name=p69142 lab=_77054_/A }
C {devices/lab_pin.sym} 69720 -25660 0 0 {name=p69143 lab=_82281_/D }
C {devices/lab_pin.sym} 69840 -25680 0 1 {name=p69144 lab=_77055_/B }
C {sky130_stdcells/nor2_4.sym} 69780 -25680 0 0 {name=X_77054_ }
C {devices/lab_pin.sym} 69740 -25550 0 0 {name=p69145 lab=_43513_/A }
C {devices/lab_pin.sym} 69820 -25550 0 1 {name=p69146 lab=_43446_/X }
C {sky130_stdcells/buf_2.sym} 69780 -25550 0 0 {name=X_43446_ }
C {devices/lab_pin.sym} 69720 -25460 0 0 {name=p69147 lab=_62597_/B }
C {devices/lab_pin.sym} 69720 -25420 0 0 {name=p69148 lab=_61796_/X }
C {devices/lab_pin.sym} 69720 -25380 0 0 {name=p69149 lab=_62237_/X }
C {devices/lab_pin.sym} 69720 -25340 0 0 {name=p69150 lab=_62280_/D }
C {devices/lab_pin.sym} 69840 -25400 0 1 {name=p69151 lab=_62280_/X }
C {sky130_stdcells/and4_4.sym} 69780 -25400 0 0 {name=X_62280_ }
C {devices/lab_pin.sym} 69720 -25260 0 0 {name=p69152 lab=_74266_/A }
C {devices/lab_pin.sym} 69720 -25220 0 0 {name=p69153 lab=_72853_/X }
C {devices/lab_pin.sym} 69840 -25240 0 1 {name=p69154 lab=_74266_/Y }
C {sky130_stdcells/nor2_4.sym} 69780 -25240 0 0 {name=X_74266_ }
C {sky130_stdcells/decap_3.sym} 69780 -25080 0 0 {name=XPHY_471 }
C {devices/lab_pin.sym} 69740 -24930 0 0 {name=p69155 lab=_40657_/Y }
C {devices/lab_pin.sym} 69820 -24930 0 1 {name=p69156 lab=_40658_/Y }
C {sky130_stdcells/inv_2.sym} 69780 -24930 0 0 {name=X_40658_ }
C {devices/lab_pin.sym} 69740 -24810 0 0 {name=p69157 lab=_71429_/A }
C {devices/lab_pin.sym} 69820 -24810 0 1 {name=p69158 lab=_71716_/D }
C {sky130_stdcells/buf_2.sym} 69780 -24810 0 0 {name=X_71478_ }
C {sky130_stdcells/decap_3.sym} 69780 -24660 0 0 {name=XPHY_482 }
C {sky130_stdcells/decap_3.sym} 69780 -24480 0 0 {name=XPHY_493 }
C {devices/lab_pin.sym} 69720 -24350 0 0 {name=p69159 lab=_76005_/A }
C {devices/lab_pin.sym} 69720 -24310 0 0 {name=p69160 lab=_76005_/B }
C {devices/lab_pin.sym} 69720 -24270 0 0 {name=p69161 lab=_76005_/C }
C {devices/lab_pin.sym} 69840 -24310 0 1 {name=p69162 lab=_76006_/B }
C {sky130_stdcells/and3_4.sym} 69780 -24310 0 0 {name=X_76005_ }
C {devices/lab_pin.sym} 69740 -24170 0 0 {name=p69163 lab=_61196_/A }
C {devices/lab_pin.sym} 69820 -24170 0 1 {name=p69164 lab=_64223_/A }
C {sky130_stdcells/buf_2.sym} 69780 -24170 0 0 {name=X_61231_ }
C {devices/lab_pin.sym} 69720 -24060 0 0 {name=p69165 lab=_73217_/A }
C {devices/lab_pin.sym} 69720 -24020 0 0 {name=p69166 lab=_73216_/X }
C {devices/lab_pin.sym} 69840 -24040 0 1 {name=p69167 lab=_73217_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -24040 0 0 {name=X_73217_ }
C {devices/lab_pin.sym} 69700 -23930 0 0 {name=p69168 lab=_46166_/A }
C {devices/lab_pin.sym} 69700 -23890 0 0 {name=p69169 lab=_46170_/C }
C {devices/lab_pin.sym} 69700 -23850 0 0 {name=p69170 lab=_46169_/C }
C {devices/lab_pin.sym} 69860 -23890 0 1 {name=p69171 lab=_46167_/B }
C {sky130_stdcells/a21boi_4.sym} 69780 -23890 0 0 {name=X_46165_ }
C {devices/lab_pin.sym} 69740 -23750 0 0 {name=p69172 lab=_71145_/A }
C {devices/lab_pin.sym} 69820 -23750 0 1 {name=p69173 lab=_71196_/A }
C {sky130_stdcells/buf_2.sym} 69780 -23750 0 0 {name=X_70429_ }
C {devices/lab_pin.sym} 69740 -23630 0 0 {name=p69174 lab=_43376_/Y }
C {devices/lab_pin.sym} 69820 -23630 0 1 {name=p69175 lab=_43377_/Y }
C {sky130_stdcells/inv_2.sym} 69780 -23630 0 0 {name=X_43377_ }
C {devices/lab_pin.sym} 69720 -23520 0 0 {name=p69176 lab=_74237_/A }
C {devices/lab_pin.sym} 69720 -23480 0 0 {name=p69177 lab=_66301_/B }
C {devices/lab_pin.sym} 69840 -23500 0 1 {name=p69178 lab=_74197_/X }
C {sky130_stdcells/and2_4.sym} 69780 -23500 0 0 {name=X_74197_ }
C {devices/lab_pin.sym} 69700 -23390 0 0 {name=p69179 lab=_40585_/X }
C {devices/lab_pin.sym} 69700 -23350 0 0 {name=p69180 lab=_82878_/Q }
C {devices/lab_pin.sym} 69700 -23310 0 0 {name=p69181 lab=_40588_/X }
C {devices/lab_pin.sym} 69860 -23350 0 1 {name=p69182 lab=_40590_/A }
C {sky130_stdcells/o21ai_4.sym} 69780 -23350 0 0 {name=X_40589_ }
C {devices/lab_pin.sym} 69740 -23210 0 0 {name=p69183 lab=_45265_/A }
C {devices/lab_pin.sym} 69820 -23210 0 1 {name=p69184 lab=_45116_/X }
C {sky130_stdcells/buf_2.sym} 69780 -23210 0 0 {name=X_45116_ }
C {devices/lab_pin.sym} 69700 -23120 0 0 {name=p69185 lab=_41651_/X }
C {devices/lab_pin.sym} 69700 -23080 0 0 {name=p69186 lab=_42325_/X }
C {devices/lab_pin.sym} 69700 -23040 0 0 {name=p69187 lab=_87919_/Q }
C {devices/lab_pin.sym} 69700 -23000 0 0 {name=p69188 lab=_42326_/X }
C {devices/lab_pin.sym} 69860 -23060 0 1 {name=p69189 lab=_87919_/D }
C {sky130_stdcells/a2bb2o_4.sym} 69780 -23060 0 0 {name=X_42328_ }
C {devices/lab_pin.sym} 69700 -22930 0 0 {name=p69190 lab=_61107_/X }
C {devices/lab_pin.sym} 69700 -22890 0 0 {name=p69191 lab=_61254_/C }
C {devices/lab_pin.sym} 69700 -22850 0 0 {name=p69192 lab=_61131_/Y }
C {devices/lab_pin.sym} 69860 -22890 0 1 {name=p69193 lab=_61162_/X }
C {sky130_stdcells/o21a_4.sym} 69780 -22890 0 0 {name=X_61162_ }
C {devices/lab_pin.sym} 69700 -22780 0 0 {name=p69194 lab=_42020_/Y }
C {devices/lab_pin.sym} 69700 -22740 0 0 {name=p69195 lab=_72888_/X }
C {devices/lab_pin.sym} 69700 -22700 0 0 {name=p69196 lab=_72890_/X }
C {devices/lab_pin.sym} 69700 -22660 0 0 {name=p69197 lab=_73147_/Y }
C {devices/lab_pin.sym} 69860 -22720 0 1 {name=p69198 lab=_73148_/X }
C {sky130_stdcells/a211o_4.sym} 69780 -22720 0 0 {name=X_73148_ }
C {devices/lab_pin.sym} 69720 -22600 0 0 {name=p69199 lab=_46162_/A }
C {devices/lab_pin.sym} 69720 -22560 0 0 {name=p69200 lab=_46090_/Y }
C {devices/lab_pin.sym} 69720 -22520 0 0 {name=p69201 lab=_46091_/Y }
C {devices/lab_pin.sym} 69720 -22480 0 0 {name=p69202 lab=_46096_/D }
C {devices/lab_pin.sym} 69840 -22540 0 1 {name=p69203 lab=_46097_/A }
C {sky130_stdcells/and4_4.sym} 69780 -22540 0 0 {name=X_46096_ }
C {devices/lab_pin.sym} 69700 -22430 0 0 {name=p69204 lab=_60058_/B }
C {devices/lab_pin.sym} 69700 -22390 0 0 {name=p69205 lab=_59913_/X }
C {devices/lab_pin.sym} 69700 -22350 0 0 {name=p69206 lab=_60027_/X }
C {devices/lab_pin.sym} 69700 -22310 0 0 {name=p69207 lab=_60110_/X }
C {devices/lab_pin.sym} 69700 -22270 0 0 {name=p69208 lab=_64638_/B }
C {devices/lab_pin.sym} 69860 -22350 0 1 {name=p69209 lab=_60113_/Y }
C {sky130_stdcells/a32oi_4.sym} 69780 -22350 0 0 {name=X_60113_ }
C {devices/lab_pin.sym} 69740 -22190 0 0 {name=p69210 lab=_49924_/A }
C {devices/lab_pin.sym} 69820 -22190 0 1 {name=p69211 lab=_49924_/X }
C {sky130_stdcells/buf_2.sym} 69780 -22190 0 0 {name=X_49924_ }
C {devices/lab_pin.sym} 69740 -22070 0 0 {name=p69212 lab=_44968_/X }
C {devices/lab_pin.sym} 69820 -22070 0 1 {name=p69213 lab=_45067_/B }
C {sky130_stdcells/buf_2.sym} 69780 -22070 0 0 {name=X_45047_ }
C {devices/lab_pin.sym} 69740 -21950 0 0 {name=p69214 lab=_42259_/A }
C {devices/lab_pin.sym} 69820 -21950 0 1 {name=p69215 lab=_42259_/X }
C {sky130_stdcells/buf_2.sym} 69780 -21950 0 0 {name=X_42259_ }
C {devices/lab_pin.sym} 69720 -21850 0 0 {name=p69216 lab=_65970_/A }
C {devices/lab_pin.sym} 69720 -21810 0 0 {name=p69217 lab=_65970_/B }
C {devices/lab_pin.sym} 69720 -21770 0 0 {name=p69218 lab=_65970_/C }
C {devices/lab_pin.sym} 69840 -21810 0 1 {name=p69219 lab=_65970_/X }
C {sky130_stdcells/and3_4.sym} 69780 -21810 0 0 {name=X_65970_ }
C {devices/lab_pin.sym} 69740 -21670 0 0 {name=p69220 lab=_64243_/A }
C {devices/lab_pin.sym} 69820 -21670 0 1 {name=p69221 lab=_61107_/A }
C {sky130_stdcells/inv_2.sym} 69780 -21670 0 0 {name=X_61093_ }
C {devices/lab_pin.sym} 69740 -21550 0 0 {name=p69222 lab=_73193_/A }
C {devices/lab_pin.sym} 69820 -21550 0 1 {name=p69223 lab=_73079_/X }
C {sky130_stdcells/buf_2.sym} 69780 -21550 0 0 {name=X_73079_ }
C {devices/lab_pin.sym} 69700 -21450 0 0 {name=p69224 lab=_77961_/B }
C {devices/lab_pin.sym} 69700 -21410 0 0 {name=p69225 lab=_77944_/B }
C {devices/lab_pin.sym} 69700 -21370 0 0 {name=p69226 lab=_77955_/X }
C {devices/lab_pin.sym} 69860 -21410 0 1 {name=p69227 lab=_77956_/Y }
C {sky130_stdcells/a21oi_4.sym} 69780 -21410 0 0 {name=X_77956_ }
C {devices/lab_pin.sym} 69700 -21300 0 0 {name=p69228 lab=_64846_/X }
C {devices/lab_pin.sym} 69700 -21260 0 0 {name=p69229 lab=_85525_/Q }
C {devices/lab_pin.sym} 69700 -21220 0 0 {name=p69230 lab=_64919_/X }
C {devices/lab_pin.sym} 69700 -21180 0 0 {name=p69231 lab=_64920_/X }
C {devices/lab_pin.sym} 69860 -21240 0 1 {name=p69232 lab=_64921_/X }
C {sky130_stdcells/a211o_4.sym} 69780 -21240 0 0 {name=X_64921_ }
C {devices/lab_pin.sym} 69740 -21090 0 0 {name=p69233 lab=_60044_/A }
C {devices/lab_pin.sym} 69820 -21090 0 1 {name=p69234 lab=_60044_/Y }
C {sky130_stdcells/inv_2.sym} 69780 -21090 0 0 {name=X_60044_ }
C {devices/lab_pin.sym} 69720 -20980 0 0 {name=p69235 lab=_76907_/A }
C {devices/lab_pin.sym} 69720 -20940 0 0 {name=p69236 lab=_76907_/B }
C {devices/lab_pin.sym} 69840 -20960 0 1 {name=p69237 lab=_76934_/A }
C {sky130_stdcells/xnor2_4.sym} 69780 -20960 0 0 {name=X_76907_ }
C {devices/lab_pin.sym} 69720 -20840 0 0 {name=p69238 lab=_49864_/A }
C {devices/lab_pin.sym} 69720 -20800 0 0 {name=p69239 lab=_53067_/B }
C {devices/lab_pin.sym} 69840 -20820 0 1 {name=p69240 lab=_49855_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -20820 0 0 {name=X_49855_ }
C {devices/lab_pin.sym} 69720 -20700 0 0 {name=p69241 lab=_77887_/A }
C {devices/lab_pin.sym} 69720 -20660 0 0 {name=p69242 lab=_77886_/Y }
C {devices/lab_pin.sym} 69840 -20680 0 1 {name=p69243 lab=_77888_/B }
C {sky130_stdcells/xnor2_4.sym} 69780 -20680 0 0 {name=X_77887_ }
C {devices/lab_pin.sym} 69700 -20570 0 0 {name=p69244 lab=_48804_/Y }
C {devices/lab_pin.sym} 69700 -20530 0 0 {name=p69245 lab=_48785_/X }
C {devices/lab_pin.sym} 69700 -20490 0 0 {name=p69246 lab=_48805_/X }
C {devices/lab_pin.sym} 69860 -20530 0 1 {name=p69247 lab=_86479_/D }
C {sky130_stdcells/a21oi_4.sym} 69780 -20530 0 0 {name=X_48806_ }
C {devices/lab_pin.sym} 69700 -20410 0 0 {name=p69248 lab=_84061_/Q }
C {devices/lab_pin.sym} 69700 -20370 0 0 {name=p69249 lab=_67568_/X }
C {devices/lab_pin.sym} 69700 -20330 0 0 {name=p69250 lab=_67639_/X }
C {devices/lab_pin.sym} 69860 -20370 0 1 {name=p69251 lab=_84061_/D }
C {sky130_stdcells/a21bo_4.sym} 69780 -20370 0 0 {name=X_67640_ }
C {devices/lab_pin.sym} 69700 -20250 0 0 {name=p69252 lab=_79614_/X }
C {devices/lab_pin.sym} 69700 -20210 0 0 {name=p69253 lab=_79615_/X }
C {devices/lab_pin.sym} 69700 -20170 0 0 {name=p69254 lab=_79625_/Y }
C {devices/lab_pin.sym} 69860 -20210 0 1 {name=p69255 lab=_79626_/Y }
C {sky130_stdcells/a21boi_4.sym} 69780 -20210 0 0 {name=X_79626_ }
C {devices/lab_pin.sym} 69700 -20090 0 0 {name=p69256 lab=_64845_/X }
C {devices/lab_pin.sym} 69700 -20050 0 0 {name=p69257 lab=_64849_/X }
C {devices/lab_pin.sym} 69700 -20010 0 0 {name=p69258 lab=_64851_/X }
C {devices/lab_pin.sym} 69860 -20050 0 1 {name=p69259 lab=_64855_/A }
C {sky130_stdcells/a21o_4.sym} 69780 -20050 0 0 {name=X_64852_ }
C {devices/lab_pin.sym} 69740 -19910 0 0 {name=p69260 lab=clkbuf_3_6_1_CLK/X }
C {devices/lab_pin.sym} 69820 -19910 0 1 {name=p69261 lab=clkbuf_4_12_1_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 69780 -19910 0 0 {name=Xclkbuf_4_12_0_CLK }
C {devices/lab_pin.sym} 69720 -19800 0 0 {name=p69262 lab=_81590_/Q }
C {devices/lab_pin.sym} 69720 -19760 0 0 {name=p69263 lab=_76838_/B }
C {devices/lab_pin.sym} 69840 -19780 0 1 {name=p69264 lab=_81558_/D }
C {sky130_stdcells/xor2_4.sym} 69780 -19780 0 0 {name=X_76838_ }
C {devices/lab_pin.sym} 69700 -19670 0 0 {name=p69265 lab=_86323_/Q }
C {devices/lab_pin.sym} 69700 -19630 0 0 {name=p69266 lab=_49768_/X }
C {devices/lab_pin.sym} 69700 -19590 0 0 {name=p69267 lab=_49785_/Y }
C {devices/lab_pin.sym} 69860 -19630 0 1 {name=p69268 lab=_49786_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -19630 0 0 {name=X_49786_ }
C {devices/lab_pin.sym} 69740 -19490 0 0 {name=p69269 lab=_82393_/Q }
C {devices/lab_pin.sym} 69820 -19490 0 1 {name=p69270 lab=_46999_/A }
C {sky130_stdcells/inv_2.sym} 69780 -19490 0 0 {name=X_46998_ }
C {devices/lab_pin.sym} 69720 -19400 0 0 {name=p69271 lab=_61378_/A }
C {devices/lab_pin.sym} 69720 -19360 0 0 {name=p69272 lab=_63772_/B }
C {devices/lab_pin.sym} 69720 -19320 0 0 {name=p69273 lab=_63803_/C }
C {devices/lab_pin.sym} 69720 -19280 0 0 {name=p69274 lab=_63787_/D }
C {devices/lab_pin.sym} 69840 -19340 0 1 {name=p69275 lab=_63809_/A }
C {sky130_stdcells/nand4_4.sym} 69780 -19340 0 0 {name=X_63803_ }
C {devices/lab_pin.sym} 69720 -19200 0 0 {name=p69276 lab=_48737_/A }
C {devices/lab_pin.sym} 69720 -19160 0 0 {name=p69277 lab=_52121_/B }
C {devices/lab_pin.sym} 69840 -19180 0 1 {name=p69278 lab=_48737_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -19180 0 0 {name=X_48737_ }
C {devices/lab_pin.sym} 69700 -19080 0 0 {name=p69279 lab=_87913_/Q }
C {devices/lab_pin.sym} 69700 -19040 0 0 {name=p69280 lab=_67473_/X }
C {devices/lab_pin.sym} 69700 -19000 0 0 {name=p69281 lab=_67524_/X }
C {devices/lab_pin.sym} 69700 -18960 0 0 {name=p69282 lab=_67570_/X }
C {devices/lab_pin.sym} 69860 -19020 0 1 {name=p69283 lab=_67571_/X }
C {sky130_stdcells/a211o_4.sym} 69780 -19020 0 0 {name=X_67571_ }
C {devices/lab_pin.sym} 69720 -18890 0 0 {name=p69284 lab=_79557_/A }
C {devices/lab_pin.sym} 69720 -18850 0 0 {name=p69285 lab=_79549_/Y }
C {devices/lab_pin.sym} 69720 -18810 0 0 {name=p69286 lab=_79550_/Y }
C {devices/lab_pin.sym} 69840 -18850 0 1 {name=p69287 lab=_79558_/B }
C {sky130_stdcells/nand3_4.sym} 69780 -18850 0 0 {name=X_79557_ }
C {devices/lab_pin.sym} 69740 -18710 0 0 {name=p69288 lab=_45918_/Y }
C {devices/lab_pin.sym} 69820 -18710 0 1 {name=p69289 lab=_45950_/B }
C {sky130_stdcells/inv_2.sym} 69780 -18710 0 0 {name=X_45949_ }
C {devices/lab_pin.sym} 69740 -18590 0 0 {name=p69290 lab=_64608_/A }
C {devices/lab_pin.sym} 69820 -18590 0 1 {name=p69291 lab=_64867_/B }
C {sky130_stdcells/buf_2.sym} 69780 -18590 0 0 {name=X_64783_ }
C {devices/lab_pin.sym} 69700 -18490 0 0 {name=p69292 lab=_76762_/Y }
C {devices/lab_pin.sym} 69700 -18450 0 0 {name=p69293 lab=_76763_/A }
C {devices/lab_pin.sym} 69700 -18410 0 0 {name=p69294 lab=_76768_/Y }
C {devices/lab_pin.sym} 69860 -18450 0 1 {name=p69295 lab=_76769_/Y }
C {sky130_stdcells/a21oi_4.sym} 69780 -18450 0 0 {name=X_76769_ }
C {devices/lab_pin.sym} 69740 -18310 0 0 {name=p69296 lab=_59692_/Y }
C {devices/lab_pin.sym} 69820 -18310 0 1 {name=p69297 lab=_61995_/X }
C {sky130_stdcells/buf_2.sym} 69780 -18310 0 0 {name=X_61995_ }
C {devices/lab_pin.sym} 69700 -18220 0 0 {name=p69298 lab=_87027_/Q }
C {devices/lab_pin.sym} 69700 -18180 0 0 {name=p69299 lab=_69153_/X }
C {devices/lab_pin.sym} 69700 -18140 0 0 {name=p69300 lab=_69168_/X }
C {devices/lab_pin.sym} 69700 -18100 0 0 {name=p69301 lab=_69309_/X }
C {devices/lab_pin.sym} 69860 -18160 0 1 {name=p69302 lab=_69310_/X }
C {sky130_stdcells/a211o_4.sym} 69780 -18160 0 0 {name=X_69310_ }
C {devices/lab_pin.sym} 69700 -18030 0 0 {name=p69303 lab=_60371_/X }
C {devices/lab_pin.sym} 69700 -17990 0 0 {name=p69304 lab=_66355_/Y }
C {devices/lab_pin.sym} 69700 -17950 0 0 {name=p69305 lab=_66521_/Y }
C {devices/lab_pin.sym} 69860 -17990 0 1 {name=p69306 lab=_66522_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -17990 0 0 {name=X_66522_ }
C {devices/lab_pin.sym} 69740 -17850 0 0 {name=p69307 lab=_78508_/A }
C {devices/lab_pin.sym} 69820 -17850 0 1 {name=p69308 lab=_78508_/Y }
C {sky130_stdcells/inv_2.sym} 69780 -17850 0 0 {name=X_78508_ }
C {devices/lab_pin.sym} 69720 -17740 0 0 {name=p69309 lab=_63734_/A }
C {devices/lab_pin.sym} 69720 -17700 0 0 {name=p69310 lab=_63733_/X }
C {devices/lab_pin.sym} 69840 -17720 0 1 {name=p69311 lab=_63735_/A }
C {sky130_stdcells/nand2_4.sym} 69780 -17720 0 0 {name=X_63734_ }
C {devices/lab_pin.sym} 69740 -17590 0 0 {name=p69312 lab=_72543_/A }
C {devices/lab_pin.sym} 69820 -17590 0 1 {name=p69313 lab=_60946_/X }
C {sky130_stdcells/buf_2.sym} 69780 -17590 0 0 {name=X_60946_ }
C {devices/lab_pin.sym} 69700 -17490 0 0 {name=p69314 lab=_48662_/Y }
C {devices/lab_pin.sym} 69700 -17450 0 0 {name=p69315 lab=_48651_/X }
C {devices/lab_pin.sym} 69700 -17410 0 0 {name=p69316 lab=_48667_/X }
C {devices/lab_pin.sym} 69860 -17450 0 1 {name=p69317 lab=_48668_/Y }
C {sky130_stdcells/a21oi_4.sym} 69780 -17450 0 0 {name=X_48668_ }
C {devices/lab_pin.sym} 69700 -17330 0 0 {name=p69318 lab=_79442_/Y }
C {devices/lab_pin.sym} 69700 -17290 0 0 {name=p69319 lab=_79482_/X }
C {devices/lab_pin.sym} 69700 -17250 0 0 {name=p69320 lab=_79487_/Y }
C {devices/lab_pin.sym} 69860 -17290 0 1 {name=p69321 lab=_79488_/Y }
C {sky130_stdcells/a21oi_4.sym} 69780 -17290 0 0 {name=X_79488_ }
C {devices/lab_pin.sym} 69700 -17180 0 0 {name=p69322 lab=_87032_/Q }
C {devices/lab_pin.sym} 69700 -17140 0 0 {name=p69323 lab=_69239_/X }
C {devices/lab_pin.sym} 69700 -17100 0 0 {name=p69324 lab=_69103_/X }
C {devices/lab_pin.sym} 69700 -17060 0 0 {name=p69325 lab=_69240_/X }
C {devices/lab_pin.sym} 69860 -17120 0 1 {name=p69326 lab=_69241_/X }
C {sky130_stdcells/a211o_4.sym} 69780 -17120 0 0 {name=X_69241_ }
C {devices/lab_pin.sym} 69740 -16970 0 0 {name=p69327 lab=_47619_/A }
C {devices/lab_pin.sym} 69820 -16970 0 1 {name=p69328 lab=_47619_/X }
C {sky130_stdcells/buf_2.sym} 69780 -16970 0 0 {name=X_47619_ }
C {devices/lab_pin.sym} 69720 -16870 0 0 {name=p69329 lab=_66453_/A }
C {devices/lab_pin.sym} 69720 -16830 0 0 {name=p69330 lab=_65833_/B }
C {devices/lab_pin.sym} 69720 -16790 0 0 {name=p69331 lab=_66160_/X }
C {devices/lab_pin.sym} 69840 -16830 0 1 {name=p69332 lab=_66453_/Y }
C {sky130_stdcells/nand3_4.sym} 69780 -16830 0 0 {name=X_66453_ }
C {devices/lab_pin.sym} 69720 -16710 0 0 {name=p69333 lab=_78438_/Y }
C {devices/lab_pin.sym} 69720 -16670 0 0 {name=p69334 lab=_78439_/B }
C {devices/lab_pin.sym} 69720 -16630 0 0 {name=p69335 lab=_78439_/C }
C {devices/lab_pin.sym} 69840 -16670 0 1 {name=p69336 lab=_78439_/Y }
C {sky130_stdcells/nand3_4.sym} 69780 -16670 0 0 {name=X_78439_ }
C {devices/lab_pin.sym} 69720 -16540 0 0 {name=p69337 lab=_59430_/Y }
C {devices/lab_pin.sym} 69720 -16500 0 0 {name=p69338 lab=_63648_/B }
C {devices/lab_pin.sym} 69840 -16520 0 1 {name=p69339 lab=_63665_/Y }
C {sky130_stdcells/nor2_4.sym} 69780 -16520 0 0 {name=X_63665_ }
C {devices/lab_pin.sym} 69740 -16390 0 0 {name=p69340 lab=_48823_/B }
C {devices/lab_pin.sym} 69820 -16390 0 1 {name=p69341 lab=_50503_/B }
C {sky130_stdcells/buf_2.sym} 69780 -16390 0 0 {name=X_48599_ }
C {devices/lab_pin.sym} 69740 -16270 0 0 {name=p69342 lab=_60857_/X }
C {devices/lab_pin.sym} 69820 -16270 0 1 {name=p69343 lab=_60879_/B }
C {sky130_stdcells/buf_2.sym} 69780 -16270 0 0 {name=X_60877_ }
C {devices/lab_pin.sym} 69700 -16180 0 0 {name=p69344 lab=_65272_/X }
C {devices/lab_pin.sym} 69700 -16140 0 0 {name=p69345 lab=_85538_/Q }
C {devices/lab_pin.sym} 69700 -16100 0 0 {name=p69346 lab=_65326_/X }
C {devices/lab_pin.sym} 69700 -16060 0 0 {name=p69347 lab=_65403_/X }
C {devices/lab_pin.sym} 69860 -16120 0 1 {name=p69348 lab=_65404_/X }
C {sky130_stdcells/a211o_4.sym} 69780 -16120 0 0 {name=X_65404_ }
C {devices/lab_pin.sym} 69720 -15980 0 0 {name=p69349 lab=_50624_/A }
C {devices/lab_pin.sym} 69720 -15940 0 0 {name=p69350 lab=_72025_/B }
C {devices/lab_pin.sym} 69840 -15960 0 1 {name=p69351 lab=_50630_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -15960 0 0 {name=X_50630_ }
C {devices/lab_pin.sym} 69720 -15850 0 0 {name=p69352 lab=_62653_/A }
C {devices/lab_pin.sym} 69720 -15810 0 0 {name=p69353 lab=_62653_/B }
C {devices/lab_pin.sym} 69720 -15770 0 0 {name=p69354 lab=_62616_/C }
C {devices/lab_pin.sym} 69840 -15810 0 1 {name=p69355 lab=_62616_/Y }
C {sky130_stdcells/nor3_4.sym} 69780 -15810 0 0 {name=X_62616_ }
C {devices/lab_pin.sym} 69690 -15670 0 0 {name=p69356 lab=_81344_/CLK }
C {devices/lab_pin.sym} 69690 -15650 0 0 {name=p69357 lab=_81450_/D }
C {devices/lab_pin.sym} 69870 -15670 0 1 {name=p69358 lab=_81418_/D }
C {sky130_stdcells/dfxtp_4.sym} 69780 -15660 0 0 {name=X_81450_ }
C {devices/lab_pin.sym} 69700 -15550 0 0 {name=p69359 lab=_69167_/X }
C {devices/lab_pin.sym} 69700 -15510 0 0 {name=p69360 lab=_69170_/X }
C {devices/lab_pin.sym} 69700 -15470 0 0 {name=p69361 lab=_69171_/X }
C {devices/lab_pin.sym} 69860 -15510 0 1 {name=p69362 lab=_69172_/Y }
C {sky130_stdcells/a21oi_4.sym} 69780 -15510 0 0 {name=X_69172_ }
C {devices/lab_pin.sym} 69700 -15390 0 0 {name=p69363 lab=_84133_/Q }
C {devices/lab_pin.sym} 69700 -15350 0 0 {name=p69364 lab=_65296_/X }
C {devices/lab_pin.sym} 69700 -15310 0 0 {name=p69365 lab=_66383_/Y }
C {devices/lab_pin.sym} 69860 -15350 0 1 {name=p69366 lab=_84133_/D }
C {sky130_stdcells/a21o_4.sym} 69780 -15350 0 0 {name=X_66384_ }
C {devices/lab_pin.sym} 69700 -15240 0 0 {name=p69367 lab=_58385_/Y }
C {devices/lab_pin.sym} 69700 -15200 0 0 {name=p69368 lab=_63558_/X }
C {devices/lab_pin.sym} 69700 -15160 0 0 {name=p69369 lab=_61561_/A }
C {devices/lab_pin.sym} 69700 -15120 0 0 {name=p69370 lab=_63559_/X }
C {devices/lab_pin.sym} 69860 -15180 0 1 {name=p69371 lab=_63596_/X }
C {sky130_stdcells/a2bb2o_4.sym} 69780 -15180 0 0 {name=X_63596_ }
C {devices/lab_pin.sym} 69740 -15030 0 0 {name=p69372 lab=clkbuf_9_502_0_CLK/X }
C {devices/lab_pin.sym} 69820 -15030 0 1 {name=p69373 lab=_83068_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 69780 -15030 0 0 {name=Xclkbuf_10_1005_0_CLK }
C {devices/lab_pin.sym} 69720 -14920 0 0 {name=p69374 lab=_80401_/A }
C {devices/lab_pin.sym} 69720 -14880 0 0 {name=p69375 lab=_80400_/X }
C {devices/lab_pin.sym} 69840 -14900 0 1 {name=p69376 lab=_80416_/B }
C {sky130_stdcells/xnor2_4.sym} 69780 -14900 0 0 {name=X_80401_ }
C {devices/lab_pin.sym} 69700 -14800 0 0 {name=p69377 lab=_68121_/X }
C {devices/lab_pin.sym} 69700 -14760 0 0 {name=p69378 lab=_66771_/Y }
C {devices/lab_pin.sym} 69700 -14720 0 0 {name=p69379 lab=_68110_/X }
C {devices/lab_pin.sym} 69700 -14680 0 0 {name=p69380 lab=_68122_/Y }
C {devices/lab_pin.sym} 69860 -14740 0 1 {name=p69381 lab=_68123_/X }
C {sky130_stdcells/a211o_4.sym} 69780 -14740 0 0 {name=X_68123_ }
C {devices/lab_pin.sym} 69720 -14600 0 0 {name=p69382 lab=_65258_/A }
C {devices/lab_pin.sym} 69720 -14560 0 0 {name=p69383 lab=_65335_/B }
C {devices/lab_pin.sym} 69840 -14580 0 1 {name=p69384 lab=_65335_/X }
C {sky130_stdcells/and2_4.sym} 69780 -14580 0 0 {name=X_65335_ }
C {devices/lab_pin.sym} 69720 -14470 0 0 {name=p69385 lab=_48885_/A }
C {devices/lab_pin.sym} 69720 -14430 0 0 {name=p69386 lab=_50560_/X }
C {devices/lab_pin.sym} 69720 -14390 0 0 {name=p69387 lab=_50552_/C }
C {devices/lab_pin.sym} 69840 -14430 0 1 {name=p69388 lab=_50561_/X }
C {sky130_stdcells/and3_4.sym} 69780 -14430 0 0 {name=X_50561_ }
C {devices/lab_pin.sym} 69690 -14290 0 0 {name=p69389 lab=_84087_/CLK }
C {devices/lab_pin.sym} 69690 -14270 0 0 {name=p69390 lab=_81381_/D }
C {devices/lab_pin.sym} 69870 -14290 0 1 {name=p69391 lab=_76821_/B }
C {sky130_stdcells/dfxtp_4.sym} 69780 -14280 0 0 {name=X_81381_ }
C {devices/lab_pin.sym} 69740 -14150 0 0 {name=p69392 lab=_62237_/X }
C {devices/lab_pin.sym} 69820 -14150 0 1 {name=p69393 lab=_62548_/C }
C {sky130_stdcells/buf_2.sym} 69780 -14150 0 0 {name=X_62547_ }
C {devices/lab_pin.sym} 69700 -14050 0 0 {name=p69394 lab=_85850_/Q }
C {devices/lab_pin.sym} 69700 -14010 0 0 {name=p69395 lab=_52297_/X }
C {devices/lab_pin.sym} 69700 -13970 0 0 {name=p69396 lab=_52299_/Y }
C {devices/lab_pin.sym} 69860 -14010 0 1 {name=p69397 lab=_52300_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -14010 0 0 {name=X_52300_ }
C {devices/lab_pin.sym} 69690 -13870 0 0 {name=p69398 lab=_86213_/CLK }
C {devices/lab_pin.sym} 69690 -13850 0 0 {name=p69399 lab=_83120_/D }
C {devices/lab_pin.sym} 69870 -13870 0 1 {name=p69400 lab=_83120_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -13860 0 0 {name=X_83120_ }
C {devices/lab_pin.sym} 69740 -13730 0 0 {name=p69401 lab=_80314_/Y }
C {devices/lab_pin.sym} 69820 -13730 0 1 {name=p69402 lab=_80332_/Y }
C {sky130_stdcells/inv_2.sym} 69780 -13730 0 0 {name=X_80332_ }
C {devices/lab_pin.sym} 69720 -13620 0 0 {name=p69403 lab=_68405_/A }
C {devices/lab_pin.sym} 69720 -13580 0 0 {name=p69404 lab=_68054_/B }
C {devices/lab_pin.sym} 69840 -13600 0 1 {name=p69405 lab=_68054_/X }
C {sky130_stdcells/and2_4.sym} 69780 -13600 0 0 {name=X_68054_ }
C {devices/lab_pin.sym} 69720 -13480 0 0 {name=p69406 lab=_53276_/A }
C {devices/lab_pin.sym} 69720 -13440 0 0 {name=p69407 lab=_54460_/B }
C {devices/lab_pin.sym} 69840 -13460 0 1 {name=p69408 lab=_53280_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -13460 0 0 {name=X_53280_ }
C {devices/lab_pin.sym} 69720 -13350 0 0 {name=p69409 lab=_65262_/X }
C {devices/lab_pin.sym} 69720 -13310 0 0 {name=p69410 lab=_65111_/B }
C {devices/lab_pin.sym} 69720 -13270 0 0 {name=p69411 lab=_65265_/X }
C {devices/lab_pin.sym} 69840 -13310 0 1 {name=p69412 lab=_65266_/Y }
C {sky130_stdcells/nand3_4.sym} 69780 -13310 0 0 {name=X_65266_ }
C {devices/lab_pin.sym} 69720 -13190 0 0 {name=p69413 lab=_52199_/A }
C {devices/lab_pin.sym} 69720 -13150 0 0 {name=p69414 lab=_50492_/B }
C {devices/lab_pin.sym} 69720 -13110 0 0 {name=p69415 lab=_50497_/C }
C {devices/lab_pin.sym} 69840 -13150 0 1 {name=p69416 lab=_50492_/X }
C {sky130_stdcells/and3_4.sym} 69780 -13150 0 0 {name=X_50492_ }
C {devices/lab_pin.sym} 69740 -13010 0 0 {name=p69417 lab=_62478_/A }
C {devices/lab_pin.sym} 69820 -13010 0 1 {name=p69418 lab=_62478_/X }
C {sky130_stdcells/buf_2.sym} 69780 -13010 0 0 {name=X_62478_ }
C {devices/lab_pin.sym} 69720 -12900 0 0 {name=p69419 lab=_67001_/X }
C {devices/lab_pin.sym} 69720 -12860 0 0 {name=p69420 lab=_67004_/X }
C {devices/lab_pin.sym} 69840 -12880 0 1 {name=p69421 lab=_67005_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -12880 0 0 {name=X_67005_ }
C {devices/lab_pin.sym} 69700 -12770 0 0 {name=p69422 lab=_85863_/Q }
C {devices/lab_pin.sym} 69700 -12730 0 0 {name=p69423 lab=_52214_/X }
C {devices/lab_pin.sym} 69700 -12690 0 0 {name=p69424 lab=_52230_/Y }
C {devices/lab_pin.sym} 69860 -12730 0 1 {name=p69425 lab=_52231_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -12730 0 0 {name=X_52231_ }
C {devices/lab_pin.sym} 69740 -12590 0 0 {name=p69426 lab=_64440_/A }
C {devices/lab_pin.sym} 69820 -12590 0 1 {name=p69427 lab=_64315_/A }
C {sky130_stdcells/buf_2.sym} 69780 -12590 0 0 {name=X_64217_ }
C {devices/lab_pin.sym} 69690 -12470 0 0 {name=p69428 lab=_83310_/CLK }
C {devices/lab_pin.sym} 69690 -12450 0 0 {name=p69429 lab=_74510_/Y }
C {devices/lab_pin.sym} 69870 -12470 0 1 {name=p69430 lab=_83051_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -12460 0 0 {name=X_83051_ }
C {devices/lab_pin.sym} 69720 -12350 0 0 {name=p69431 lab=_61429_/A }
C {devices/lab_pin.sym} 69720 -12310 0 0 {name=p69432 lab=_61428_/X }
C {devices/lab_pin.sym} 69720 -12270 0 0 {name=p69433 lab=_61429_/C }
C {devices/lab_pin.sym} 69840 -12310 0 1 {name=p69434 lab=_61429_/Y }
C {sky130_stdcells/nand3_4.sym} 69780 -12310 0 0 {name=X_61429_ }
C {devices/lab_pin.sym} 69720 -12180 0 0 {name=p69435 lab=_79900_/X }
C {devices/lab_pin.sym} 69720 -12140 0 0 {name=p69436 lab=_80263_/B }
C {devices/lab_pin.sym} 69840 -12160 0 1 {name=p69437 lab=_80264_/B }
C {sky130_stdcells/nand2_4.sym} 69780 -12160 0 0 {name=X_80263_ }
C {devices/lab_pin.sym} 69700 -12050 0 0 {name=p69438 lab=_65193_/Y }
C {devices/lab_pin.sym} 69700 -12010 0 0 {name=p69439 lab=_65195_/X }
C {devices/lab_pin.sym} 69700 -11970 0 0 {name=p69440 lab=_65196_/X }
C {devices/lab_pin.sym} 69860 -12010 0 1 {name=p69441 lab=_84211_/D }
C {sky130_stdcells/a21o_4.sym} 69780 -12010 0 0 {name=X_65197_ }
C {devices/lab_pin.sym} 69690 -11870 0 0 {name=p69442 lab=_82005_/CLK }
C {devices/lab_pin.sym} 69690 -11850 0 0 {name=p69443 lab=_82034_/Q }
C {devices/lab_pin.sym} 69870 -11870 0 1 {name=p69444 lab=_77111_/A }
C {sky130_stdcells/dfxtp_4.sym} 69780 -11860 0 0 {name=X_82002_ }
C {devices/lab_pin.sym} 69700 -11750 0 0 {name=p69445 lab=_52159_/Y }
C {devices/lab_pin.sym} 69700 -11710 0 0 {name=p69446 lab=_52145_/X }
C {devices/lab_pin.sym} 69700 -11670 0 0 {name=p69447 lab=_52161_/X }
C {devices/lab_pin.sym} 69860 -11710 0 1 {name=p69448 lab=_85877_/D }
C {sky130_stdcells/a21oi_4.sym} 69780 -11710 0 0 {name=X_52162_ }
C {devices/lab_pin.sym} 69740 -11570 0 0 {name=p69449 lab=_60982_/A }
C {devices/lab_pin.sym} 69820 -11570 0 1 {name=p69450 lab=_64182_/B }
C {sky130_stdcells/buf_2.sym} 69780 -11570 0 0 {name=X_64148_ }
C {devices/lab_pin.sym} 69720 -11460 0 0 {name=p69451 lab=_84948_/Q }
C {devices/lab_pin.sym} 69720 -11420 0 0 {name=p69452 lab=_84196_/Q }
C {devices/lab_pin.sym} 69840 -11440 0 1 {name=p69453 lab=_80196_/A }
C {sky130_stdcells/xor2_4.sym} 69780 -11440 0 0 {name=X_80194_ }
C {devices/lab_pin.sym} 69700 -11330 0 0 {name=p69454 lab=_86071_/Q }
C {devices/lab_pin.sym} 69700 -11290 0 0 {name=p69455 lab=_51101_/X }
C {devices/lab_pin.sym} 69700 -11250 0 0 {name=p69456 lab=_51112_/Y }
C {devices/lab_pin.sym} 69860 -11290 0 1 {name=p69457 lab=_51113_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -11290 0 0 {name=X_51113_ }
C {devices/lab_pin.sym} 69690 -11150 0 0 {name=p69458 lab=_86814_/CLK }
C {devices/lab_pin.sym} 69690 -11130 0 0 {name=p69459 lab=_46021_/Y }
C {devices/lab_pin.sym} 69870 -11150 0 1 {name=p69460 lab=_86810_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -11140 0 0 {name=X_86810_ }
C {devices/lab_pin.sym} 69720 -11030 0 0 {name=p69461 lab=_52093_/A }
C {devices/lab_pin.sym} 69720 -10990 0 0 {name=p69462 lab=_52098_/B }
C {devices/lab_pin.sym} 69720 -10950 0 0 {name=p69463 lab=_52033_/X }
C {devices/lab_pin.sym} 69840 -10990 0 1 {name=p69464 lab=_52093_/X }
C {sky130_stdcells/and3_4.sym} 69780 -10990 0 0 {name=X_52093_ }
C {devices/lab_pin.sym} 69700 -10870 0 0 {name=p69465 lab=_56877_/X }
C {devices/lab_pin.sym} 69700 -10830 0 0 {name=p69466 lab=_56922_/X }
C {devices/lab_pin.sym} 69700 -10790 0 0 {name=p69467 lab=_56893_/B }
C {devices/lab_pin.sym} 69860 -10830 0 1 {name=p69468 lab=_56971_/C }
C {sky130_stdcells/o21ai_4.sym} 69780 -10830 0 0 {name=X_56970_ }
C {devices/lab_pin.sym} 69700 -10710 0 0 {name=p69469 lab=_58268_/A }
C {devices/lab_pin.sym} 69700 -10670 0 0 {name=p69470 lab=_60866_/A }
C {devices/lab_pin.sym} 69700 -10630 0 0 {name=p69471 lab=_64078_/X }
C {devices/lab_pin.sym} 69860 -10670 0 1 {name=p69472 lab=_64079_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -10670 0 0 {name=X_64079_ }
C {devices/lab_pin.sym} 69720 -10540 0 0 {name=p69473 lab=_68669_/A }
C {devices/lab_pin.sym} 69720 -10500 0 0 {name=p69474 lab=_68956_/B }
C {devices/lab_pin.sym} 69840 -10520 0 1 {name=p69475 lab=_68956_/Y }
C {sky130_stdcells/nor2_4.sym} 69780 -10520 0 0 {name=X_68956_ }
C {devices/lab_pin.sym} 69690 -10390 0 0 {name=p69476 lab=_87790_/CLK }
C {devices/lab_pin.sym} 69690 -10370 0 0 {name=p69477 lab=_87790_/D }
C {devices/lab_pin.sym} 69870 -10390 0 1 {name=p69478 lab=_69203_/B }
C {sky130_stdcells/dfxtp_4.sym} 69780 -10380 0 0 {name=X_87790_ }
C {devices/lab_pin.sym} 69700 -10270 0 0 {name=p69479 lab=_86084_/Q }
C {devices/lab_pin.sym} 69700 -10230 0 0 {name=p69480 lab=_51020_/X }
C {devices/lab_pin.sym} 69700 -10190 0 0 {name=p69481 lab=_51043_/Y }
C {devices/lab_pin.sym} 69860 -10230 0 1 {name=p69482 lab=_51044_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -10230 0 0 {name=X_51044_ }
C {devices/lab_pin.sym} 69720 -10100 0 0 {name=p69483 lab=_55903_/A }
C {devices/lab_pin.sym} 69720 -10060 0 0 {name=p69484 lab=_85178_/Q }
C {devices/lab_pin.sym} 69840 -10080 0 1 {name=p69485 lab=_55921_/X }
C {sky130_stdcells/and2_4.sym} 69780 -10080 0 0 {name=X_55921_ }
C {devices/lab_pin.sym} 69740 -9950 0 0 {name=p69486 lab=_64706_/A }
C {devices/lab_pin.sym} 69820 -9950 0 1 {name=p69487 lab=_69797_/A }
C {sky130_stdcells/buf_2.sym} 69780 -9950 0 0 {name=X_67907_ }
C {devices/lab_pin.sym} 69690 -9830 0 0 {name=p69488 lab=_85527_/CLK }
C {devices/lab_pin.sym} 69690 -9810 0 0 {name=p69489 lab=_46393_/Y }
C {devices/lab_pin.sym} 69870 -9830 0 1 {name=p69490 lab=_86741_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -9820 0 0 {name=X_86741_ }
C {devices/lab_pin.sym} 69690 -9690 0 0 {name=p69491 lab=_83957_/CLK }
C {devices/lab_pin.sym} 69690 -9670 0 0 {name=p69492 lab=_83953_/D }
C {devices/lab_pin.sym} 69870 -9690 0 1 {name=p69493 lab=_80809_/D }
C {sky130_stdcells/dfxtp_4.sym} 69780 -9680 0 0 {name=X_83953_ }
C {devices/lab_pin.sym} 69700 -9580 0 0 {name=p69494 lab=_74051_/A }
C {devices/lab_pin.sym} 69700 -9540 0 0 {name=p69495 lab=_68883_/X }
C {devices/lab_pin.sym} 69700 -9500 0 0 {name=p69496 lab=_68884_/X }
C {devices/lab_pin.sym} 69700 -9460 0 0 {name=p69497 lab=_68886_/Y }
C {devices/lab_pin.sym} 69860 -9520 0 1 {name=p69498 lab=_68887_/X }
C {sky130_stdcells/a211o_4.sym} 69780 -9520 0 0 {name=X_68887_ }
C {devices/lab_pin.sym} 69740 -9370 0 0 {name=p69499 lab=_64656_/A }
C {devices/lab_pin.sym} 69820 -9370 0 1 {name=p69500 lab=_58641_/A }
C {sky130_stdcells/buf_2.sym} 69780 -9370 0 0 {name=X_58640_ }
C {devices/lab_pin.sym} 69690 -9250 0 0 {name=p69501 lab=_87922_/CLK }
C {devices/lab_pin.sym} 69690 -9230 0 0 {name=p69502 lab=_78240_/B }
C {devices/lab_pin.sym} 69870 -9250 0 1 {name=p69503 lab=_41679_/A }
C {sky130_stdcells/dfxtp_4.sym} 69780 -9240 0 0 {name=X_82904_ }
C {devices/lab_pin.sym} 69700 -9140 0 0 {name=p69504 lab=_83026_/Q }
C {devices/lab_pin.sym} 69700 -9100 0 0 {name=p69505 lab=_55507_/X }
C {devices/lab_pin.sym} 69700 -9060 0 0 {name=p69506 lab=_44097_/X }
C {devices/lab_pin.sym} 69700 -9020 0 0 {name=p69507 lab=_55851_/X }
C {devices/lab_pin.sym} 69860 -9080 0 1 {name=p69508 lab=_55853_/B }
C {sky130_stdcells/a211o_4.sym} 69780 -9080 0 0 {name=X_55852_ }
C {devices/lab_pin.sym} 69700 -8950 0 0 {name=p69509 lab=_67833_/X }
C {devices/lab_pin.sym} 69700 -8910 0 0 {name=p69510 lab=_67837_/X }
C {devices/lab_pin.sym} 69700 -8870 0 0 {name=p69511 lab=_67742_/X }
C {devices/lab_pin.sym} 69860 -8910 0 1 {name=p69512 lab=_67842_/A }
C {sky130_stdcells/a21o_4.sym} 69780 -8910 0 0 {name=X_67838_ }
C {devices/lab_pin.sym} 69690 -8770 0 0 {name=p69513 lab=_86353_/CLK }
C {devices/lab_pin.sym} 69690 -8750 0 0 {name=p69514 lab=_86672_/D }
C {devices/lab_pin.sym} 69870 -8770 0 1 {name=p69515 lab=_86672_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -8760 0 0 {name=X_86672_ }
C {devices/lab_pin.sym} 69690 -8630 0 0 {name=p69516 lab=_82301_/CLK }
C {devices/lab_pin.sym} 69690 -8610 0 0 {name=p69517 lab=_83884_/D }
C {devices/lab_pin.sym} 69870 -8630 0 1 {name=p69518 lab=_81956_/D }
C {sky130_stdcells/dfxtp_4.sym} 69780 -8620 0 0 {name=X_83884_ }
C {devices/lab_pin.sym} 69720 -8520 0 0 {name=p69519 lab=_54798_/A }
C {devices/lab_pin.sym} 69720 -8480 0 0 {name=p69520 lab=_54816_/B }
C {devices/lab_pin.sym} 69720 -8440 0 0 {name=p69521 lab=_54798_/C }
C {devices/lab_pin.sym} 69720 -8400 0 0 {name=p69522 lab=_53113_/D }
C {devices/lab_pin.sym} 69840 -8460 0 1 {name=p69523 lab=_54803_/X }
C {sky130_stdcells/and4_4.sym} 69780 -8460 0 0 {name=X_54803_ }
C {devices/lab_pin.sym} 69690 -8310 0 0 {name=p69524 lab=_86235_/CLK }
C {devices/lab_pin.sym} 69690 -8290 0 0 {name=p69525 lab=_53513_/Y }
C {devices/lab_pin.sym} 69870 -8310 0 1 {name=p69526 lab=_85623_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -8300 0 0 {name=X_85623_ }
C {devices/lab_pin.sym} 69740 -8170 0 0 {name=p69527 lab=_58813_/A }
C {devices/lab_pin.sym} 69820 -8170 0 1 {name=p69528 lab=_58571_/X }
C {sky130_stdcells/buf_2.sym} 69780 -8170 0 0 {name=X_58571_ }
C {devices/lab_pin.sym} 69690 -8050 0 0 {name=p69529 lab=_83167_/CLK }
C {devices/lab_pin.sym} 69690 -8030 0 0 {name=p69530 lab=_82835_/D }
C {devices/lab_pin.sym} 69870 -8050 0 1 {name=p69531 lab=_82835_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -8040 0 0 {name=X_82835_ }
C {devices/lab_pin.sym} 69720 -7920 0 0 {name=p69532 lab=_55711_/X }
C {devices/lab_pin.sym} 69720 -7880 0 0 {name=p69533 lab=_55783_/B }
C {devices/lab_pin.sym} 69840 -7900 0 1 {name=p69534 lab=_55783_/X }
C {sky130_stdcells/and2_4.sym} 69780 -7900 0 0 {name=X_55783_ }
C {devices/lab_pin.sym} 69720 -7780 0 0 {name=p69535 lab=_67766_/X }
C {devices/lab_pin.sym} 69720 -7740 0 0 {name=p69536 lab=_67768_/X }
C {devices/lab_pin.sym} 69840 -7760 0 1 {name=p69537 lab=_67769_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -7760 0 0 {name=X_67769_ }
C {devices/lab_pin.sym} 69720 -7640 0 0 {name=p69538 lab=_52999_/A }
C {devices/lab_pin.sym} 69720 -7600 0 0 {name=p69539 lab=_52995_/B }
C {devices/lab_pin.sym} 69840 -7620 0 1 {name=p69540 lab=_52995_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -7620 0 0 {name=X_52995_ }
C {devices/lab_pin.sym} 69700 -7510 0 0 {name=p69541 lab=_57519_/Y }
C {devices/lab_pin.sym} 69700 -7470 0 0 {name=p69542 lab=_57515_/X }
C {devices/lab_pin.sym} 69700 -7430 0 0 {name=p69543 lab=_57521_/Y }
C {devices/lab_pin.sym} 69860 -7470 0 1 {name=p69544 lab=_57522_/Y }
C {sky130_stdcells/a21boi_4.sym} 69780 -7470 0 0 {name=X_57522_ }
C {devices/lab_pin.sym} 69700 -7360 0 0 {name=p69545 lab=_88024_/Q }
C {devices/lab_pin.sym} 69700 -7320 0 0 {name=p69546 lab=_69506_/X }
C {devices/lab_pin.sym} 69700 -7280 0 0 {name=p69547 lab=_69393_/X }
C {devices/lab_pin.sym} 69700 -7240 0 0 {name=p69548 lab=_69507_/X }
C {devices/lab_pin.sym} 69860 -7300 0 1 {name=p69549 lab=_69508_/X }
C {sky130_stdcells/a211o_4.sym} 69780 -7300 0 0 {name=X_69508_ }
C {devices/lab_pin.sym} 69690 -7150 0 0 {name=p69550 lab=_88345_/CLK }
C {devices/lab_pin.sym} 69690 -7130 0 0 {name=p69551 lab=_40750_/X }
C {devices/lab_pin.sym} 69870 -7150 0 1 {name=p69552 lab=_88342_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -7140 0 0 {name=X_88342_ }
C {devices/lab_pin.sym} 69720 -7040 0 0 {name=p69553 lab=_54748_/A }
C {devices/lab_pin.sym} 69720 -7000 0 0 {name=p69554 lab=_54734_/B }
C {devices/lab_pin.sym} 69720 -6960 0 0 {name=p69555 lab=_54748_/C }
C {devices/lab_pin.sym} 69720 -6920 0 0 {name=p69556 lab=_47426_/A }
C {devices/lab_pin.sym} 69840 -6980 0 1 {name=p69557 lab=_54734_/X }
C {sky130_stdcells/and4_4.sym} 69780 -6980 0 0 {name=X_54734_ }
C {devices/lab_pin.sym} 69690 -6830 0 0 {name=p69558 lab=_85554_/CLK }
C {devices/lab_pin.sym} 69690 -6810 0 0 {name=p69559 lab=_85554_/D }
C {devices/lab_pin.sym} 69870 -6830 0 1 {name=p69560 lab=_85554_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -6820 0 0 {name=X_85554_ }
C {devices/lab_pin.sym} 69740 -6690 0 0 {name=p69561 lab=_51922_/X }
C {devices/lab_pin.sym} 69820 -6690 0 1 {name=p69562 lab=_51947_/A }
C {sky130_stdcells/buf_2.sym} 69780 -6690 0 0 {name=X_51946_ }
C {devices/lab_pin.sym} 69690 -6570 0 0 {name=p69563 lab=_82769_/CLK }
C {devices/lab_pin.sym} 69690 -6550 0 0 {name=p69564 lab=_82766_/D }
C {devices/lab_pin.sym} 69870 -6570 0 1 {name=p69565 lab=_82766_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -6560 0 0 {name=X_82766_ }
C {devices/lab_pin.sym} 69700 -6450 0 0 {name=p69566 lab=_52855_/B }
C {devices/lab_pin.sym} 69700 -6410 0 0 {name=p69567 lab=_70761_/X }
C {devices/lab_pin.sym} 69700 -6370 0 0 {name=p69568 lab=_70779_/Y }
C {devices/lab_pin.sym} 69860 -6410 0 1 {name=p69569 lab=_83702_/D }
C {sky130_stdcells/o21ai_4.sym} 69780 -6410 0 0 {name=X_70780_ }
C {devices/lab_pin.sym} 69740 -6270 0 0 {name=p69570 lab=clkbuf_9_336_0_CLK/X }
C {devices/lab_pin.sym} 69820 -6270 0 1 {name=p69571 lab=_87149_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 69780 -6270 0 0 {name=Xclkbuf_10_672_0_CLK }
C {devices/lab_pin.sym} 69690 -6150 0 0 {name=p69572 lab=_84501_/CLK }
C {devices/lab_pin.sym} 69690 -6130 0 0 {name=p69573 lab=_84505_/D }
C {devices/lab_pin.sym} 69870 -6150 0 1 {name=p69574 lab=_84505_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -6140 0 0 {name=X_84505_ }
C {devices/lab_pin.sym} 69720 -6020 0 0 {name=p69575 lab=_85001_/Q }
C {devices/lab_pin.sym} 69720 -5980 0 0 {name=p69576 lab=_57463_/B }
C {devices/lab_pin.sym} 69840 -6000 0 1 {name=p69577 lab=_57453_/X }
C {sky130_stdcells/or2_4.sym} 69780 -6000 0 0 {name=X_57453_ }
C {devices/lab_pin.sym} 69690 -5870 0 0 {name=p69578 lab=_81514_/CLK }
C {devices/lab_pin.sym} 69690 -5850 0 0 {name=p69579 lab=_81717_/D }
C {devices/lab_pin.sym} 69870 -5870 0 1 {name=p69580 lab=_41002_/B }
C {sky130_stdcells/dfxtp_4.sym} 69780 -5860 0 0 {name=X_81717_ }
C {devices/lab_pin.sym} 69740 -5730 0 0 {name=p69581 lab=_69696_/A }
C {devices/lab_pin.sym} 69820 -5730 0 1 {name=p69582 lab=_69439_/X }
C {sky130_stdcells/buf_2.sym} 69780 -5730 0 0 {name=X_69439_ }
C {devices/lab_pin.sym} 69690 -5610 0 0 {name=p69583 lab=_88288_/CLK }
C {devices/lab_pin.sym} 69690 -5590 0 0 {name=p69584 lab=_41127_/Y }
C {devices/lab_pin.sym} 69870 -5610 0 1 {name=p69585 lab=_88273_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -5600 0 0 {name=X_88273_ }
C {devices/lab_pin.sym} 69700 -5490 0 0 {name=p69586 lab=_85400_/Q }
C {devices/lab_pin.sym} 69700 -5450 0 0 {name=p69587 lab=_54648_/X }
C {devices/lab_pin.sym} 69700 -5410 0 0 {name=p69588 lab=_54664_/Y }
C {devices/lab_pin.sym} 69860 -5450 0 1 {name=p69589 lab=_54665_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -5450 0 0 {name=X_54665_ }
C {devices/lab_pin.sym} 69690 -5310 0 0 {name=p69590 lab=_85485_/CLK }
C {devices/lab_pin.sym} 69690 -5290 0 0 {name=p69591 lab=_85485_/D }
C {devices/lab_pin.sym} 69870 -5310 0 1 {name=p69592 lab=_85485_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -5300 0 0 {name=X_85485_ }
C {devices/lab_pin.sym} 69740 -5170 0 0 {name=p69593 lab=_51823_/A }
C {devices/lab_pin.sym} 69820 -5170 0 1 {name=p69594 lab=_51877_/X }
C {sky130_stdcells/buf_2.sym} 69780 -5170 0 0 {name=X_51877_ }
C {devices/lab_pin.sym} 69690 -5050 0 0 {name=p69595 lab=_82933_/CLK }
C {devices/lab_pin.sym} 69690 -5030 0 0 {name=p69596 lab=_78869_/X }
C {devices/lab_pin.sym} 69870 -5050 0 1 {name=p69597 lab=_82685_/D }
C {sky130_stdcells/dfxtp_4.sym} 69780 -5040 0 0 {name=X_82697_ }
C {devices/lab_pin.sym} 69700 -4930 0 0 {name=p69598 lab=_56060_/X }
C {devices/lab_pin.sym} 69700 -4890 0 0 {name=p69599 lab=_56394_/X }
C {devices/lab_pin.sym} 69700 -4850 0 0 {name=p69600 lab=_56403_/Y }
C {devices/lab_pin.sym} 69860 -4890 0 1 {name=p69601 lab=_85207_/D }
C {sky130_stdcells/o21ai_4.sym} 69780 -4890 0 0 {name=X_56404_ }
C {devices/lab_pin.sym} 69740 -4750 0 0 {name=p69602 lab=clkbuf_8_81_0_CLK/X }
C {devices/lab_pin.sym} 69820 -4750 0 1 {name=p69603 lab=clkbuf_9_163_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 69780 -4750 0 0 {name=Xclkbuf_9_163_0_CLK }
C {devices/lab_pin.sym} 69700 -4650 0 0 {name=p69604 lab=_41628_/X }
C {devices/lab_pin.sym} 69700 -4610 0 0 {name=p69605 lab=_41286_/A }
C {devices/lab_pin.sym} 69700 -4570 0 0 {name=p69606 lab=_41629_/X }
C {devices/lab_pin.sym} 69860 -4610 0 1 {name=p69607 lab=_41630_/X }
C {sky130_stdcells/o21a_4.sym} 69780 -4610 0 0 {name=X_41630_ }
C {devices/lab_pin.sym} 69690 -4470 0 0 {name=p69608 lab=_87225_/CLK }
C {devices/lab_pin.sym} 69690 -4450 0 0 {name=p69609 lab=_43873_/X }
C {devices/lab_pin.sym} 69870 -4470 0 1 {name=p69610 lab=_69033_/B }
C {sky130_stdcells/dfxtp_4.sym} 69780 -4460 0 0 {name=X_87224_ }
C {devices/lab_pin.sym} 69720 -4340 0 0 {name=p69611 lab=_53622_/A }
C {devices/lab_pin.sym} 69720 -4300 0 0 {name=p69612 lab=_48357_/Y }
C {devices/lab_pin.sym} 69840 -4320 0 1 {name=p69613 lab=_53616_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -4320 0 0 {name=X_53616_ }
C {devices/lab_pin.sym} 69700 -4210 0 0 {name=p69614 lab=_72419_/X }
C {devices/lab_pin.sym} 69700 -4170 0 0 {name=p69615 lab=_85349_/Q }
C {devices/lab_pin.sym} 69700 -4130 0 0 {name=p69616 lab=_72449_/X }
C {devices/lab_pin.sym} 69860 -4170 0 1 {name=p69617 lab=_72450_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -4170 0 0 {name=X_72450_ }
C {devices/lab_pin.sym} 69690 -4030 0 0 {name=p69618 lab=_84438_/CLK }
C {devices/lab_pin.sym} 69690 -4010 0 0 {name=p69619 lab=_62069_/Y }
C {devices/lab_pin.sym} 69870 -4030 0 1 {name=p69620 lab=_78059_/B }
C {sky130_stdcells/dfxtp_4.sym} 69780 -4020 0 0 {name=X_84436_ }
C {devices/lab_pin.sym} 69700 -3910 0 0 {name=p69621 lab=_86125_/Q }
C {devices/lab_pin.sym} 69700 -3870 0 0 {name=p69622 lab=_50820_/X }
C {devices/lab_pin.sym} 69700 -3830 0 0 {name=p69623 lab=_50827_/Y }
C {devices/lab_pin.sym} 69860 -3870 0 1 {name=p69624 lab=_50828_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -3870 0 0 {name=X_50828_ }
C {devices/lab_pin.sym} 69740 -3730 0 0 {name=p69625 lab=_57484_/A }
C {devices/lab_pin.sym} 69820 -3730 0 1 {name=p69626 lab=_57384_/X }
C {sky130_stdcells/buf_2.sym} 69780 -3730 0 0 {name=X_57384_ }
C {devices/lab_pin.sym} 69690 -3610 0 0 {name=p69627 lab=_81265_/CLK }
C {devices/lab_pin.sym} 69690 -3590 0 0 {name=p69628 lab=_81680_/Q }
C {devices/lab_pin.sym} 69870 -3610 0 1 {name=p69629 lab=_81648_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -3600 0 0 {name=X_81648_ }
C {devices/lab_pin.sym} 69740 -3470 0 0 {name=p69630 lab=clkbuf_8_45_0_CLK/X }
C {devices/lab_pin.sym} 69820 -3470 0 1 {name=p69631 lab=clkbuf_9_90_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 69780 -3470 0 0 {name=Xclkbuf_9_90_0_CLK }
C {devices/lab_pin.sym} 69720 -3360 0 0 {name=p69632 lab=_54600_/A }
C {devices/lab_pin.sym} 69720 -3320 0 0 {name=p69633 lab=_47184_/A }
C {devices/lab_pin.sym} 69840 -3340 0 1 {name=p69634 lab=_54596_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -3340 0 0 {name=X_54596_ }
C {devices/lab_pin.sym} 69700 -3230 0 0 {name=p69635 lab=_59121_/X }
C {devices/lab_pin.sym} 69700 -3190 0 0 {name=p69636 lab=_85431_/Q }
C {devices/lab_pin.sym} 69700 -3150 0 0 {name=p69637 lab=_59122_/X }
C {devices/lab_pin.sym} 69860 -3190 0 1 {name=p69638 lab=_59123_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -3190 0 0 {name=X_59123_ }
C {devices/lab_pin.sym} 69720 -3070 0 0 {name=p69639 lab=_70673_/A }
C {devices/lab_pin.sym} 69720 -3030 0 0 {name=p69640 lab=_71404_/B }
C {devices/lab_pin.sym} 69720 -2990 0 0 {name=p69641 lab=_71399_/C }
C {devices/lab_pin.sym} 69840 -3030 0 1 {name=p69642 lab=_71401_/Y }
C {sky130_stdcells/nor3_4.sym} 69780 -3030 0 0 {name=X_71401_ }
C {devices/lab_pin.sym} 69720 -2910 0 0 {name=p69643 lab=_56345_/A }
C {devices/lab_pin.sym} 69720 -2870 0 0 {name=p69644 lab=_56335_/B }
C {devices/lab_pin.sym} 69720 -2830 0 0 {name=p69645 lab=_55821_/B }
C {devices/lab_pin.sym} 69840 -2870 0 1 {name=p69646 lab=_56335_/Y }
C {sky130_stdcells/nand3_4.sym} 69780 -2870 0 0 {name=X_56335_ }
C {devices/lab_pin.sym} 69690 -2730 0 0 {name=p69647 lab=_86932_/CLK }
C {devices/lab_pin.sym} 69690 -2710 0 0 {name=p69648 lab=_87155_/D }
C {devices/lab_pin.sym} 69870 -2730 0 1 {name=p69649 lab=_87155_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -2720 0 0 {name=X_87155_ }
C {devices/lab_pin.sym} 69700 -2620 0 0 {name=p69650 lab=_41560_/X }
C {devices/lab_pin.sym} 69700 -2580 0 0 {name=p69651 lab=_41530_/X }
C {devices/lab_pin.sym} 69700 -2540 0 0 {name=p69652 lab=_67041_/B }
C {devices/lab_pin.sym} 69700 -2500 0 0 {name=p69653 lab=_41531_/X }
C {devices/lab_pin.sym} 69860 -2560 0 1 {name=p69654 lab=_88192_/D }
C {sky130_stdcells/a2bb2o_4.sym} 69780 -2560 0 0 {name=X_41561_ }
C {devices/lab_pin.sym} 69700 -2430 0 0 {name=p69655 lab=_53543_/Y }
C {devices/lab_pin.sym} 69700 -2390 0 0 {name=p69656 lab=_53524_/X }
C {devices/lab_pin.sym} 69700 -2350 0 0 {name=p69657 lab=_53546_/Y }
C {devices/lab_pin.sym} 69860 -2390 0 1 {name=p69658 lab=_85616_/D }
C {sky130_stdcells/a21boi_4.sym} 69780 -2390 0 0 {name=X_53547_ }
C {devices/lab_pin.sym} 69740 -2250 0 0 {name=p69659 lab=_72381_/A }
C {devices/lab_pin.sym} 69820 -2250 0 1 {name=p69660 lab=_72381_/X }
C {sky130_stdcells/buf_2.sym} 69780 -2250 0 0 {name=X_72381_ }
C {devices/lab_pin.sym} 69690 -2130 0 0 {name=p69661 lab=_84562_/CLK }
C {devices/lab_pin.sym} 69690 -2110 0 0 {name=p69662 lab=_62954_/Y }
C {devices/lab_pin.sym} 69870 -2130 0 1 {name=p69663 lab=_84367_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -2120 0 0 {name=X_84367_ }
C {devices/lab_pin.sym} 69720 -2000 0 0 {name=p69664 lab=_50740_/A }
C {devices/lab_pin.sym} 69720 -1960 0 0 {name=p69665 lab=_52454_/B }
C {devices/lab_pin.sym} 69840 -1980 0 1 {name=p69666 lab=_50759_/Y }
C {sky130_stdcells/nand2_4.sym} 69780 -1980 0 0 {name=X_50759_ }
C {devices/lab_pin.sym} 69690 -1850 0 0 {name=p69667 lab=_81352_/CLK }
C {devices/lab_pin.sym} 69690 -1830 0 0 {name=p69668 lab=_84179_/Q }
C {devices/lab_pin.sym} 69870 -1850 0 1 {name=p69669 lab=_76733_/A }
C {sky130_stdcells/dfxtp_4.sym} 69780 -1840 0 0 {name=X_81579_ }
C {devices/lab_pin.sym} 69740 -1710 0 0 {name=p69670 lab=clkbuf_9_343_0_CLK/X }
C {devices/lab_pin.sym} 69820 -1710 0 1 {name=p69671 lab=_87446_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 69780 -1710 0 0 {name=Xclkbuf_10_687_0_CLK }
C {devices/lab_pin.sym} 69740 -1590 0 0 {name=p69672 lab=_43287_/A }
C {devices/lab_pin.sym} 69820 -1590 0 1 {name=p69673 lab=_43300_/X }
C {sky130_stdcells/buf_2.sym} 69780 -1590 0 0 {name=X_43300_ }
C {devices/lab_pin.sym} 69690 -1470 0 0 {name=p69674 lab=_85786_/CLK }
C {devices/lab_pin.sym} 69690 -1450 0 0 {name=p69675 lab=_86106_/D }
C {devices/lab_pin.sym} 69870 -1470 0 1 {name=p69676 lab=_86106_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -1460 0 0 {name=X_86106_ }
C {devices/lab_pin.sym} 69700 -1350 0 0 {name=p69677 lab=_88347_/Q }
C {devices/lab_pin.sym} 69700 -1310 0 0 {name=p69678 lab=_73026_/X }
C {devices/lab_pin.sym} 69700 -1270 0 0 {name=p69679 lab=_73028_/X }
C {devices/lab_pin.sym} 69860 -1310 0 1 {name=p69680 lab=_74120_/Y }
C {sky130_stdcells/o21ai_4.sym} 69780 -1310 0 0 {name=X_74120_ }
C {devices/lab_pin.sym} 69740 -1170 0 0 {name=p69681 lab=_40783_/A }
C {devices/lab_pin.sym} 69820 -1170 0 1 {name=p69682 lab=_40512_/X }
C {sky130_stdcells/buf_2.sym} 69780 -1170 0 0 {name=X_40512_ }
C {devices/lab_pin.sym} 69700 -1070 0 0 {name=p69683 lab=_59050_/Y }
C {devices/lab_pin.sym} 69700 -1030 0 0 {name=p69684 lab=_59052_/Y }
C {devices/lab_pin.sym} 69700 -990 0 0 {name=p69685 lab=_59053_/X }
C {devices/lab_pin.sym} 69860 -1030 0 1 {name=p69686 lab=_59054_/X }
C {sky130_stdcells/a21o_4.sym} 69780 -1030 0 0 {name=X_59054_ }
C {devices/lab_pin.sym} 69700 -910 0 0 {name=p69687 lab=_48335_/B }
C {devices/lab_pin.sym} 69700 -870 0 0 {name=p69688 lab=_71320_/X }
C {devices/lab_pin.sym} 69700 -830 0 0 {name=p69689 lab=_71331_/Y }
C {devices/lab_pin.sym} 69860 -870 0 1 {name=p69690 lab=_83533_/D }
C {sky130_stdcells/o21ai_4.sym} 69780 -870 0 0 {name=X_71332_ }
C {devices/lab_pin.sym} 69690 -730 0 0 {name=p69691 lab=_83316_/CLK }
C {devices/lab_pin.sym} 69690 -710 0 0 {name=p69692 lab=_83318_/D }
C {devices/lab_pin.sym} 69870 -730 0 1 {name=p69693 lab=_83318_/Q }
C {sky130_stdcells/dfxtp_4.sym} 69780 -720 0 0 {name=X_83318_ }
C {devices/lab_pin.sym} 70640 -42170 0 0 {name=p69694 lab=_44268_/A }
C {devices/lab_pin.sym} 70640 -42130 0 0 {name=p69695 lab=_87174_/Q }
C {devices/lab_pin.sym} 70640 -42090 0 0 {name=p69696 lab=_44242_/C }
C {devices/lab_pin.sym} 70760 -42130 0 1 {name=p69697 lab=_44280_/Y }
C {sky130_stdcells/nand3_4.sym} 70700 -42130 0 0 {name=X_44280_ }
C {devices/lab_pin.sym} 70620 -42010 0 0 {name=p69698 lab=_56159_/X }
C {devices/lab_pin.sym} 70620 -41970 0 0 {name=p69699 lab=_56255_/X }
C {devices/lab_pin.sym} 70620 -41930 0 0 {name=p69700 lab=_56265_/Y }
C {devices/lab_pin.sym} 70780 -41970 0 1 {name=p69701 lab=_85253_/D }
C {sky130_stdcells/o21ai_4.sym} 70700 -41970 0 0 {name=X_56266_ }
C {devices/lab_pin.sym} 70620 -41850 0 0 {name=p69702 lab=_41421_/X }
C {devices/lab_pin.sym} 70620 -41810 0 0 {name=p69703 lab=_82331_/Q }
C {devices/lab_pin.sym} 70620 -41770 0 0 {name=p69704 lab=_41491_/X }
C {devices/lab_pin.sym} 70780 -41810 0 1 {name=p69705 lab=_41492_/X }
C {sky130_stdcells/o21a_4.sym} 70700 -41810 0 0 {name=X_41492_ }
C {devices/lab_pin.sym} 70610 -41670 0 0 {name=p69706 lab=_87086_/CLK }
C {devices/lab_pin.sym} 70610 -41650 0 0 {name=p69707 lab=_44480_/X }
C {devices/lab_pin.sym} 70790 -41670 0 1 {name=p69708 lab=_87086_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -41660 0 0 {name=X_87086_ }
C {devices/lab_pin.sym} 70640 -41540 0 0 {name=p69709 lab=_53478_/A }
C {devices/lab_pin.sym} 70640 -41500 0 0 {name=p69710 lab=_47880_/Y }
C {devices/lab_pin.sym} 70760 -41520 0 1 {name=p69711 lab=_53478_/Y }
C {sky130_stdcells/nand2_4.sym} 70700 -41520 0 0 {name=X_53478_ }
C {devices/lab_pin.sym} 70610 -41390 0 0 {name=p69712 lab=_84299_/CLK }
C {devices/lab_pin.sym} 70610 -41370 0 0 {name=p69713 lab=_63719_/Y }
C {devices/lab_pin.sym} 70790 -41390 0 1 {name=p69714 lab=_80268_/B }
C {sky130_stdcells/dfxtp_4.sym} 70700 -41380 0 0 {name=X_84298_ }
C {devices/lab_pin.sym} 70660 -41250 0 0 {name=p69715 lab=clkbuf_8_89_0_CLK/X }
C {devices/lab_pin.sym} 70740 -41250 0 1 {name=p69716 lab=clkbuf_9_178_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 70700 -41250 0 0 {name=Xclkbuf_9_178_0_CLK }
C {devices/lab_pin.sym} 70640 -41140 0 0 {name=p69717 lab=_57991_/A }
C {devices/lab_pin.sym} 70640 -41100 0 0 {name=p69718 lab=_86317_/Q }
C {devices/lab_pin.sym} 70760 -41120 0 1 {name=p69719 lab=_58005_/Y }
C {sky130_stdcells/nor2_4.sym} 70700 -41120 0 0 {name=X_58005_ }
C {devices/lab_pin.sym} 70660 -40990 0 0 {name=p69720 lab=_43231_/A }
C {devices/lab_pin.sym} 70740 -40990 0 1 {name=p69721 lab=_43231_/Y }
C {sky130_stdcells/inv_2.sym} 70700 -40990 0 0 {name=X_43231_ }
C {devices/lab_pin.sym} 70620 -40900 0 0 {name=p69722 lab=_45875_/A }
C {devices/lab_pin.sym} 70620 -40860 0 0 {name=p69723 lab=_55152_/X }
C {devices/lab_pin.sym} 70620 -40820 0 0 {name=p69724 lab=_55158_/A }
C {devices/lab_pin.sym} 70620 -40780 0 0 {name=p69725 lab=_55216_/X }
C {devices/lab_pin.sym} 70780 -40840 0 1 {name=p69726 lab=_72718_/D }
C {sky130_stdcells/a211o_4.sym} 70700 -40840 0 0 {name=X_55217_ }
C {devices/lab_pin.sym} 70640 -40700 0 0 {name=p69727 lab=_74051_/A }
C {devices/lab_pin.sym} 70640 -40660 0 0 {name=p69728 lab=_73869_/X }
C {devices/lab_pin.sym} 70760 -40680 0 1 {name=p69729 lab=_74051_/Y }
C {sky130_stdcells/nor2_4.sym} 70700 -40680 0 0 {name=X_74051_ }
C {devices/lab_pin.sym} 70610 -40550 0 0 {name=p69730 lab=_85527_/CLK }
C {devices/lab_pin.sym} 70610 -40530 0 0 {name=p69731 lab=_51299_/Y }
C {devices/lab_pin.sym} 70790 -40550 0 1 {name=p69732 lab=_64920_/B }
C {sky130_stdcells/dfxtp_4.sym} 70700 -40540 0 0 {name=X_86037_ }
C {devices/lab_pin.sym} 70620 -40430 0 0 {name=p69733 lab=_85824_/Q }
C {devices/lab_pin.sym} 70620 -40390 0 0 {name=p69734 lab=_52184_/X }
C {devices/lab_pin.sym} 70620 -40350 0 0 {name=p69735 lab=_52428_/Y }
C {devices/lab_pin.sym} 70780 -40390 0 1 {name=p69736 lab=_52429_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -40390 0 0 {name=X_52429_ }
C {devices/lab_pin.sym} 70660 -40250 0 0 {name=p69737 lab=_40363_/X }
C {devices/lab_pin.sym} 70740 -40250 0 1 {name=p69738 lab=_40443_/X }
C {sky130_stdcells/buf_2.sym} 70700 -40250 0 0 {name=X_40443_ }
C {devices/lab_pin.sym} 70640 -40160 0 0 {name=p69739 lab=_70630_/B }
C {devices/lab_pin.sym} 70640 -40120 0 0 {name=p69740 lab=_74515_/C }
C {devices/lab_pin.sym} 70640 -40080 0 0 {name=p69741 lab=_71735_/C }
C {devices/lab_pin.sym} 70640 -40040 0 0 {name=p69742 lab=_71263_/D }
C {devices/lab_pin.sym} 70760 -40100 0 1 {name=p69743 lab=_71264_/A }
C {sky130_stdcells/and4_4.sym} 70700 -40100 0 0 {name=X_71263_ }
C {devices/lab_pin.sym} 70610 -39950 0 0 {name=p69744 lab=_83248_/CLK }
C {devices/lab_pin.sym} 70610 -39930 0 0 {name=p69745 lab=_83249_/D }
C {devices/lab_pin.sym} 70790 -39950 0 1 {name=p69746 lab=_61980_/A }
C {sky130_stdcells/dfxtp_4.sym} 70700 -39940 0 0 {name=X_83249_ }
C {devices/lab_pin.sym} 70620 -39830 0 0 {name=p69747 lab=_56005_/X }
C {devices/lab_pin.sym} 70620 -39790 0 0 {name=p69748 lab=_56195_/X }
C {devices/lab_pin.sym} 70620 -39750 0 0 {name=p69749 lab=_56196_/Y }
C {devices/lab_pin.sym} 70780 -39790 0 1 {name=p69750 lab=_56197_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -39790 0 0 {name=X_56197_ }
C {devices/lab_pin.sym} 70660 -39650 0 0 {name=p69751 lab=_72771_/A }
C {devices/lab_pin.sym} 70740 -39650 0 1 {name=p69752 lab=_73003_/B }
C {sky130_stdcells/buf_2.sym} 70700 -39650 0 0 {name=X_73002_ }
C {devices/lab_pin.sym} 70660 -39530 0 0 {name=p69753 lab=clkbuf_9_305_0_CLK/X }
C {devices/lab_pin.sym} 70740 -39530 0 1 {name=p69754 lab=_81160_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 70700 -39530 0 0 {name=Xclkbuf_10_610_0_CLK }
C {devices/lab_pin.sym} 70640 -39440 0 0 {name=p69755 lab=_70214_/A }
C {devices/lab_pin.sym} 70640 -39400 0 0 {name=p69756 lab=_70214_/B }
C {devices/lab_pin.sym} 70640 -39360 0 0 {name=p69757 lab=_83194_/Q }
C {devices/lab_pin.sym} 70640 -39320 0 0 {name=p69758 lab=_70204_/X }
C {devices/lab_pin.sym} 70760 -39380 0 1 {name=p69759 lab=_70214_/X }
C {sky130_stdcells/and4_4.sym} 70700 -39380 0 0 {name=X_70214_ }
C {devices/lab_pin.sym} 70660 -39230 0 0 {name=p69760 lab=_43162_/A }
C {devices/lab_pin.sym} 70740 -39230 0 1 {name=p69761 lab=_43162_/X }
C {sky130_stdcells/buf_2.sym} 70700 -39230 0 0 {name=X_43162_ }
C {devices/lab_pin.sym} 70660 -39110 0 0 {name=p69762 lab=_55147_/X }
C {devices/lab_pin.sym} 70740 -39110 0 1 {name=p69763 lab=_55423_/B }
C {sky130_stdcells/buf_2.sym} 70700 -39110 0 0 {name=X_55148_ }
C {devices/lab_pin.sym} 70660 -38990 0 0 {name=p69764 lab=_44532_/A }
C {devices/lab_pin.sym} 70740 -38990 0 1 {name=p69765 lab=_44736_/A }
C {sky130_stdcells/buf_2.sym} 70700 -38990 0 0 {name=X_40374_ }
C {devices/lab_pin.sym} 70640 -38890 0 0 {name=p69766 lab=_71197_/A }
C {devices/lab_pin.sym} 70640 -38850 0 0 {name=p69767 lab=_71217_/B }
C {devices/lab_pin.sym} 70640 -38810 0 0 {name=p69768 lab=_71194_/C }
C {devices/lab_pin.sym} 70760 -38850 0 1 {name=p69769 lab=_71194_/Y }
C {sky130_stdcells/nand3_4.sym} 70700 -38850 0 0 {name=X_71194_ }
C {devices/lab_pin.sym} 70620 -38740 0 0 {name=p69770 lab=_41059_/X }
C {devices/lab_pin.sym} 70620 -38700 0 0 {name=p69771 lab=_42103_/X }
C {devices/lab_pin.sym} 70620 -38660 0 0 {name=p69772 lab=_88029_/Q }
C {devices/lab_pin.sym} 70620 -38620 0 0 {name=p69773 lab=_42104_/X }
C {devices/lab_pin.sym} 70780 -38680 0 1 {name=p69774 lab=_42113_/X }
C {sky130_stdcells/a2bb2o_4.sym} 70700 -38680 0 0 {name=X_42113_ }
C {devices/lab_pin.sym} 70620 -38550 0 0 {name=p69775 lab=_77817_/A }
C {devices/lab_pin.sym} 70620 -38510 0 0 {name=p69776 lab=_77795_/X }
C {devices/lab_pin.sym} 70620 -38470 0 0 {name=p69777 lab=_77809_/Y }
C {devices/lab_pin.sym} 70780 -38510 0 1 {name=p69778 lab=_77811_/B }
C {sky130_stdcells/a21oi_4.sym} 70700 -38510 0 0 {name=X_77810_ }
C {devices/lab_pin.sym} 70660 -38370 0 0 {name=p69779 lab=clkbuf_8_50_0_CLK/X }
C {devices/lab_pin.sym} 70740 -38370 0 1 {name=p69780 lab=clkbuf_9_101_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 70700 -38370 0 0 {name=Xclkbuf_9_101_0_CLK }
C {devices/lab_pin.sym} 70620 -38280 0 0 {name=p69781 lab=_83511_/Q }
C {devices/lab_pin.sym} 70620 -38240 0 0 {name=p69782 lab=_83159_/Q }
C {devices/lab_pin.sym} 70620 -38200 0 0 {name=p69783 lab=_83508_/Q }
C {devices/lab_pin.sym} 70620 -38160 0 0 {name=p69784 lab=_83156_/Q }
C {devices/lab_pin.sym} 70780 -38220 0 1 {name=p69785 lab=_70149_/A }
C {sky130_stdcells/a22oi_4.sym} 70700 -38220 0 0 {name=X_70145_ }
C {devices/lab_pin.sym} 70620 -38090 0 0 {name=p69786 lab=_66097_/B }
C {devices/lab_pin.sym} 70620 -38050 0 0 {name=p69787 lab=_47948_/X }
C {devices/lab_pin.sym} 70620 -38010 0 0 {name=p69788 lab=_47969_/Y }
C {devices/lab_pin.sym} 70780 -38050 0 1 {name=p69789 lab=_47970_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -38050 0 0 {name=X_47970_ }
C {devices/lab_pin.sym} 70620 -37930 0 0 {name=p69790 lab=_55075_/Y }
C {devices/lab_pin.sym} 70620 -37890 0 0 {name=p69791 lab=_55076_/X }
C {devices/lab_pin.sym} 70620 -37850 0 0 {name=p69792 lab=_55078_/X }
C {devices/lab_pin.sym} 70780 -37890 0 1 {name=p69793 lab=_85323_/D }
C {sky130_stdcells/a21oi_4.sym} 70700 -37890 0 0 {name=X_55079_ }
C {devices/lab_pin.sym} 70620 -37790 0 0 {name=p69794 lab=_59875_/X }
C {devices/lab_pin.sym} 70620 -37750 0 0 {name=p69795 lab=_59922_/X }
C {devices/lab_pin.sym} 70620 -37710 0 0 {name=p69796 lab=_59931_/X }
C {devices/lab_pin.sym} 70620 -37670 0 0 {name=p69797 lab=_59951_/Y }
C {devices/lab_pin.sym} 70620 -37630 0 0 {name=p69798 lab=_59955_/X }
C {devices/lab_pin.sym} 70780 -37710 0 1 {name=p69799 lab=_59956_/X }
C {sky130_stdcells/o41a_4.sym} 70700 -37710 0 0 {name=X_59956_ }
C {devices/lab_pin.sym} 70660 -37550 0 0 {name=p69800 lab=_43092_/Y }
C {devices/lab_pin.sym} 70740 -37550 0 1 {name=p69801 lab=_87579_/D }
C {sky130_stdcells/inv_2.sym} 70700 -37550 0 0 {name=X_43093_ }
C {devices/lab_pin.sym} 70620 -37450 0 0 {name=p69802 lab=_78777_/B }
C {devices/lab_pin.sym} 70620 -37410 0 0 {name=p69803 lab=_82816_/Q }
C {devices/lab_pin.sym} 70620 -37370 0 0 {name=p69804 lab=_78789_/Y }
C {devices/lab_pin.sym} 70780 -37410 0 1 {name=p69805 lab=_78791_/B }
C {sky130_stdcells/a21oi_4.sym} 70700 -37410 0 0 {name=X_78790_ }
C {devices/lab_pin.sym} 70610 -37270 0 0 {name=p69806 lab=_87749_/CLK }
C {devices/lab_pin.sym} 70610 -37250 0 0 {name=p69807 lab=_87988_/D }
C {devices/lab_pin.sym} 70790 -37270 0 1 {name=p69808 lab=_87988_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -37260 0 0 {name=X_87988_ }
C {devices/lab_pin.sym} 70620 -37150 0 0 {name=p69809 lab=_58902_/Y }
C {devices/lab_pin.sym} 70620 -37110 0 0 {name=p69810 lab=_58906_/Y }
C {devices/lab_pin.sym} 70620 -37070 0 0 {name=p69811 lab=_58883_/X }
C {devices/lab_pin.sym} 70780 -37110 0 1 {name=p69812 lab=_58907_/X }
C {sky130_stdcells/a21o_4.sym} 70700 -37110 0 0 {name=X_58907_ }
C {devices/lab_pin.sym} 70660 -36970 0 0 {name=p69813 lab=_54442_/B }
C {devices/lab_pin.sym} 70740 -36970 0 1 {name=p69814 lab=_52748_/B }
C {sky130_stdcells/buf_2.sym} 70700 -36970 0 0 {name=X_46921_ }
C {devices/lab_pin.sym} 70660 -36850 0 0 {name=p69815 lab=_42025_/A }
C {devices/lab_pin.sym} 70740 -36850 0 1 {name=p69816 lab=_42044_/X }
C {sky130_stdcells/buf_2.sym} 70700 -36850 0 0 {name=X_42044_ }
C {devices/lab_pin.sym} 70640 -36750 0 0 {name=p69817 lab=_78045_/A }
C {devices/lab_pin.sym} 70640 -36710 0 0 {name=p69818 lab=_78045_/B }
C {devices/lab_pin.sym} 70640 -36670 0 0 {name=p69819 lab=_77738_/Y }
C {devices/lab_pin.sym} 70760 -36710 0 1 {name=p69820 lab=_77741_/Y }
C {sky130_stdcells/nand3_4.sym} 70700 -36710 0 0 {name=X_77741_ }
C {devices/lab_pin.sym} 70620 -36590 0 0 {name=p69821 lab=_74947_/A }
C {devices/lab_pin.sym} 70620 -36550 0 0 {name=p69822 lab=_74946_/X }
C {devices/lab_pin.sym} 70620 -36510 0 0 {name=p69823 lab=_74958_/A }
C {devices/lab_pin.sym} 70780 -36550 0 1 {name=p69824 lab=_74953_/Y }
C {sky130_stdcells/a21boi_4.sym} 70700 -36550 0 0 {name=X_74953_ }
C {devices/lab_pin.sym} 70610 -36410 0 0 {name=p69825 lab=_86941_/CLK }
C {devices/lab_pin.sym} 70610 -36390 0 0 {name=p69826 lab=_86939_/D }
C {devices/lab_pin.sym} 70790 -36410 0 1 {name=p69827 lab=_67429_/B }
C {sky130_stdcells/dfxtp_4.sym} 70700 -36400 0 0 {name=X_86939_ }
C {devices/lab_pin.sym} 70620 -36290 0 0 {name=p69828 lab=_82536_/D }
C {devices/lab_pin.sym} 70620 -36250 0 0 {name=p69829 lab=_70067_/X }
C {devices/lab_pin.sym} 70620 -36210 0 0 {name=p69830 lab=_70075_/X }
C {devices/lab_pin.sym} 70780 -36250 0 1 {name=p69831 lab=_83856_/D }
C {sky130_stdcells/a21bo_4.sym} 70700 -36250 0 0 {name=X_70076_ }
C {devices/lab_pin.sym} 70640 -36120 0 0 {name=p69832 lab=_59885_/Y }
C {devices/lab_pin.sym} 70640 -36080 0 0 {name=p69833 lab=_61277_/C }
C {devices/lab_pin.sym} 70760 -36100 0 1 {name=p69834 lab=_59887_/Y }
C {sky130_stdcells/nor2_4.sym} 70700 -36100 0 0 {name=X_59887_ }
C {devices/lab_pin.sym} 70660 -35970 0 0 {name=p69835 lab=clkbuf_9_312_0_CLK/X }
C {devices/lab_pin.sym} 70740 -35970 0 1 {name=p69836 lab=_81994_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 70700 -35970 0 0 {name=Xclkbuf_10_625_0_CLK }
C {devices/lab_pin.sym} 70660 -35850 0 0 {name=p69837 lab=_49504_/A }
C {devices/lab_pin.sym} 70740 -35850 0 1 {name=p69838 lab=_49641_/A }
C {sky130_stdcells/buf_2.sym} 70700 -35850 0 0 {name=X_49640_ }
C {devices/lab_pin.sym} 70640 -35740 0 0 {name=p69839 lab=_73829_/X }
C {devices/lab_pin.sym} 70640 -35700 0 0 {name=p69840 lab=_73904_/B }
C {devices/lab_pin.sym} 70760 -35720 0 1 {name=p69841 lab=_73904_/X }
C {sky130_stdcells/and2_4.sym} 70700 -35720 0 0 {name=X_73904_ }
C {devices/lab_pin.sym} 70640 -35600 0 0 {name=p69842 lab=_46817_/A }
C {devices/lab_pin.sym} 70640 -35560 0 0 {name=p69843 lab=_51022_/B }
C {devices/lab_pin.sym} 70760 -35580 0 1 {name=p69844 lab=_46852_/Y }
C {sky130_stdcells/nand2_4.sym} 70700 -35580 0 0 {name=X_46852_ }
C {devices/lab_pin.sym} 70660 -35450 0 0 {name=p69845 lab=_58928_/A }
C {devices/lab_pin.sym} 70740 -35450 0 1 {name=p69846 lab=_58838_/X }
C {sky130_stdcells/buf_2.sym} 70700 -35450 0 0 {name=X_58838_ }
C {devices/lab_pin.sym} 70660 -35330 0 0 {name=p69847 lab=_82239_/Q }
C {devices/lab_pin.sym} 70740 -35330 0 1 {name=p69848 lab=_77676_/A }
C {sky130_stdcells/inv_2.sym} 70700 -35330 0 0 {name=X_77672_ }
C {devices/lab_pin.sym} 70640 -35220 0 0 {name=p69849 lab=_81128_/D }
C {devices/lab_pin.sym} 70640 -35180 0 0 {name=p69850 lab=_80840_/Q }
C {devices/lab_pin.sym} 70760 -35200 0 1 {name=p69851 lab=_74899_/A }
C {sky130_stdcells/xor2_4.sym} 70700 -35200 0 0 {name=X_74884_ }
C {devices/lab_pin.sym} 70660 -35070 0 0 {name=p69852 lab=clkbuf_8_58_0_CLK/X }
C {devices/lab_pin.sym} 70740 -35070 0 1 {name=p69853 lab=clkbuf_9_116_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 70700 -35070 0 0 {name=Xclkbuf_9_116_0_CLK }
C {devices/lab_pin.sym} 70640 -34960 0 0 {name=p69854 lab=_84807_/Q }
C {devices/lab_pin.sym} 70640 -34920 0 0 {name=p69855 lab=_66420_/C }
C {devices/lab_pin.sym} 70760 -34940 0 1 {name=p69856 lab=_79411_/Y }
C {sky130_stdcells/nand2_4.sym} 70700 -34940 0 0 {name=X_79411_ }
C {devices/lab_pin.sym} 70660 -34810 0 0 {name=p69857 lab=_45714_/A }
C {devices/lab_pin.sym} 70740 -34810 0 1 {name=p69858 lab=_45803_/X }
C {sky130_stdcells/buf_2.sym} 70700 -34810 0 0 {name=X_45803_ }
C {devices/lab_pin.sym} 70660 -34690 0 0 {name=p69859 lab=_76623_/A }
C {devices/lab_pin.sym} 70740 -34690 0 1 {name=p69860 lab=_76624_/C }
C {sky130_stdcells/inv_2.sym} 70700 -34690 0 0 {name=X_76623_ }
C {devices/lab_pin.sym} 70660 -34570 0 0 {name=p69861 lab=_49571_/A }
C {devices/lab_pin.sym} 70740 -34570 0 1 {name=p69862 lab=_49571_/X }
C {sky130_stdcells/buf_2.sym} 70700 -34570 0 0 {name=X_49571_ }
C {devices/lab_pin.sym} 70640 -34460 0 0 {name=p69863 lab=_73835_/A }
C {devices/lab_pin.sym} 70640 -34420 0 0 {name=p69864 lab=_73835_/B }
C {devices/lab_pin.sym} 70760 -34440 0 1 {name=p69865 lab=_73836_/B }
C {sky130_stdcells/nand2_4.sym} 70700 -34440 0 0 {name=X_73835_ }
C {devices/lab_pin.sym} 70660 -34310 0 0 {name=p69866 lab=clkbuf_9_43_0_CLK/A }
C {devices/lab_pin.sym} 70740 -34310 0 1 {name=p69867 lab=clkbuf_9_43_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 70700 -34310 0 0 {name=Xclkbuf_9_43_0_CLK }
C {devices/lab_pin.sym} 70660 -34190 0 0 {name=p69868 lab=_54362_/D }
C {devices/lab_pin.sym} 70740 -34190 0 1 {name=p69869 lab=_46783_/X }
C {sky130_stdcells/buf_2.sym} 70700 -34190 0 0 {name=X_46783_ }
C {devices/lab_pin.sym} 70660 -34070 0 0 {name=p69870 lab=_84801_/Q }
C {devices/lab_pin.sym} 70740 -34070 0 1 {name=p69871 lab=_58769_/Y }
C {sky130_stdcells/inv_2.sym} 70700 -34070 0 0 {name=X_58769_ }
C {devices/lab_pin.sym} 70660 -33950 0 0 {name=p69872 lab=_43995_/A }
C {devices/lab_pin.sym} 70740 -33950 0 1 {name=p69873 lab=_59563_/A }
C {sky130_stdcells/buf_2.sym} 70700 -33950 0 0 {name=X_43995_ }
C {devices/lab_pin.sym} 70620 -33860 0 0 {name=p69874 lab=_84565_/Q }
C {devices/lab_pin.sym} 70620 -33820 0 0 {name=p69875 lab=_60719_/X }
C {devices/lab_pin.sym} 70620 -33780 0 0 {name=p69876 lab=_60796_/Y }
C {devices/lab_pin.sym} 70620 -33740 0 0 {name=p69877 lab=_60799_/X }
C {devices/lab_pin.sym} 70780 -33800 0 1 {name=p69878 lab=_84565_/D }
C {sky130_stdcells/o22a_4.sym} 70700 -33800 0 0 {name=X_60800_ }
C {devices/lab_pin.sym} 70660 -33650 0 0 {name=p69879 lab=_48522_/A }
C {devices/lab_pin.sym} 70740 -33650 0 1 {name=p69880 lab=_50469_/A }
C {sky130_stdcells/buf_2.sym} 70700 -33650 0 0 {name=X_48522_ }
C {devices/lab_pin.sym} 70640 -33540 0 0 {name=p69881 lab=_84801_/Q }
C {devices/lab_pin.sym} 70640 -33500 0 0 {name=p69882 lab=_84121_/Q }
C {devices/lab_pin.sym} 70760 -33520 0 1 {name=p69883 lab=_79342_/X }
C {sky130_stdcells/xor2_4.sym} 70700 -33520 0 0 {name=X_79342_ }
C {devices/lab_pin.sym} 70660 -33390 0 0 {name=p69884 lab=_45734_/A }
C {devices/lab_pin.sym} 70740 -33390 0 1 {name=p69885 lab=_45734_/X }
C {sky130_stdcells/buf_2.sym} 70700 -33390 0 0 {name=X_45734_ }
C {devices/lab_pin.sym} 70640 -33290 0 0 {name=p69886 lab=_76550_/Y }
C {devices/lab_pin.sym} 70640 -33250 0 0 {name=p69887 lab=_76554_/B }
C {devices/lab_pin.sym} 70640 -33210 0 0 {name=p69888 lab=_76554_/C }
C {devices/lab_pin.sym} 70760 -33250 0 1 {name=p69889 lab=_76554_/X }
C {sky130_stdcells/or3_4.sym} 70700 -33250 0 0 {name=X_76554_ }
C {devices/lab_pin.sym} 70620 -33150 0 0 {name=p69890 lab=_42944_/X }
C {devices/lab_pin.sym} 70620 -33110 0 0 {name=p69891 lab=_42945_/X }
C {devices/lab_pin.sym} 70620 -33070 0 0 {name=p69892 lab=_41786_/X }
C {devices/lab_pin.sym} 70620 -33030 0 0 {name=p69893 lab=_68051_/B }
C {devices/lab_pin.sym} 70620 -32990 0 0 {name=p69894 lab=_42934_/X }
C {devices/lab_pin.sym} 70780 -33070 0 1 {name=p69895 lab=_42946_/Y }
C {sky130_stdcells/o32ai_4.sym} 70700 -33070 0 0 {name=X_42946_ }
C {devices/lab_pin.sym} 70660 -32910 0 0 {name=p69896 lab=_84726_/Q }
C {devices/lab_pin.sym} 70740 -32910 0 1 {name=p69897 lab=_61780_/X }
C {sky130_stdcells/buf_2.sym} 70700 -32910 0 0 {name=X_61780_ }
C {devices/lab_pin.sym} 70620 -32810 0 0 {name=p69898 lab=_73767_/B }
C {devices/lab_pin.sym} 70620 -32770 0 0 {name=p69899 lab=_73767_/C }
C {devices/lab_pin.sym} 70620 -32730 0 0 {name=p69900 lab=_73765_/X }
C {devices/lab_pin.sym} 70780 -32770 0 1 {name=p69901 lab=_73766_/X }
C {sky130_stdcells/a21o_4.sym} 70700 -32770 0 0 {name=X_73766_ }
C {devices/lab_pin.sym} 70660 -32630 0 0 {name=p69902 lab=_71170_/A }
C {devices/lab_pin.sym} 70740 -32630 0 1 {name=p69903 lab=_70979_/C }
C {sky130_stdcells/buf_2.sym} 70700 -32630 0 0 {name=X_70978_ }
C {devices/lab_pin.sym} 70660 -32510 0 0 {name=p69904 lab=clkbuf_2_0_2_CLK/X }
C {devices/lab_pin.sym} 70740 -32510 0 1 {name=p69905 lab=clkbuf_3_1_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 70700 -32510 0 0 {name=Xclkbuf_3_1_0_CLK }
C {devices/lab_pin.sym} 70660 -32390 0 0 {name=p69906 lab=_75504_/X }
C {devices/lab_pin.sym} 70740 -32390 0 1 {name=p69907 lab=_75505_/Y }
C {sky130_stdcells/inv_2.sym} 70700 -32390 0 0 {name=X_75505_ }
C {devices/lab_pin.sym} 70620 -32290 0 0 {name=p69908 lab=_48447_/Y }
C {devices/lab_pin.sym} 70620 -32250 0 0 {name=p69909 lab=_48383_/X }
C {devices/lab_pin.sym} 70620 -32210 0 0 {name=p69910 lab=_48452_/X }
C {devices/lab_pin.sym} 70780 -32250 0 1 {name=p69911 lab=_48453_/Y }
C {sky130_stdcells/a21oi_4.sym} 70700 -32250 0 0 {name=X_48453_ }
C {devices/lab_pin.sym} 70660 -32110 0 0 {name=p69912 lab=_60731_/A }
C {devices/lab_pin.sym} 70740 -32110 0 1 {name=p69913 lab=_63410_/A }
C {sky130_stdcells/buf_2.sym} 70700 -32110 0 0 {name=X_60731_ }
C {devices/lab_pin.sym} 70620 -32010 0 0 {name=p69914 lab=_70260_/C }
C {devices/lab_pin.sym} 70620 -31970 0 0 {name=p69915 lab=_72702_/X }
C {devices/lab_pin.sym} 70620 -31930 0 0 {name=p69916 lab=_72716_/Y }
C {devices/lab_pin.sym} 70780 -31970 0 1 {name=p69917 lab=_83179_/D }
C {sky130_stdcells/a21bo_4.sym} 70700 -31970 0 0 {name=X_72717_ }
C {devices/lab_pin.sym} 70620 -31850 0 0 {name=p69918 lab=_79247_/X }
C {devices/lab_pin.sym} 70620 -31810 0 0 {name=p69919 lab=_79271_/Y }
C {devices/lab_pin.sym} 70620 -31770 0 0 {name=p69920 lab=_79270_/X }
C {devices/lab_pin.sym} 70780 -31810 0 1 {name=p69921 lab=_79273_/X }
C {sky130_stdcells/a21bo_4.sym} 70700 -31810 0 0 {name=X_79273_ }
C {devices/lab_pin.sym} 70620 -31690 0 0 {name=p69922 lab=_56705_/B }
C {devices/lab_pin.sym} 70620 -31650 0 0 {name=p69923 lab=_45507_/X }
C {devices/lab_pin.sym} 70620 -31610 0 0 {name=p69924 lab=_45429_/X }
C {devices/lab_pin.sym} 70780 -31650 0 1 {name=p69925 lab=_45665_/X }
C {sky130_stdcells/o21a_4.sym} 70700 -31650 0 0 {name=X_45665_ }
C {devices/lab_pin.sym} 70640 -31520 0 0 {name=p69926 lab=_76485_/A }
C {devices/lab_pin.sym} 70640 -31480 0 0 {name=p69927 lab=_76484_/Y }
C {devices/lab_pin.sym} 70760 -31500 0 1 {name=p69928 lab=_76485_/X }
C {sky130_stdcells/xor2_4.sym} 70700 -31500 0 0 {name=X_76485_ }
C {devices/lab_pin.sym} 70660 -31370 0 0 {name=p69929 lab=_42877_/A }
C {devices/lab_pin.sym} 70740 -31370 0 1 {name=p69930 lab=_87673_/D }
C {sky130_stdcells/inv_2.sym} 70700 -31370 0 0 {name=X_42877_ }
C {devices/lab_pin.sym} 70660 -31250 0 0 {name=p69931 lab=_73939_/A }
C {devices/lab_pin.sym} 70740 -31250 0 1 {name=p69932 lab=_73697_/X }
C {sky130_stdcells/buf_2.sym} 70700 -31250 0 0 {name=X_73697_ }
C {devices/lab_pin.sym} 70640 -31140 0 0 {name=p69933 lab=_47404_/A }
C {devices/lab_pin.sym} 70640 -31100 0 0 {name=p69934 lab=_53025_/B }
C {devices/lab_pin.sym} 70760 -31120 0 1 {name=p69935 lab=_47404_/Y }
C {sky130_stdcells/nand2_4.sym} 70700 -31120 0 0 {name=X_47404_ }
C {devices/lab_pin.sym} 70640 -31000 0 0 {name=p69936 lab=_78221_/Y }
C {devices/lab_pin.sym} 70640 -30960 0 0 {name=p69937 lab=_78223_/X }
C {devices/lab_pin.sym} 70760 -30980 0 1 {name=p69938 lab=_78234_/A }
C {sky130_stdcells/nand2_4.sym} 70700 -30980 0 0 {name=X_78224_ }
C {devices/lab_pin.sym} 70660 -30850 0 0 {name=p69939 lab=_44616_/A }
C {devices/lab_pin.sym} 70740 -30850 0 1 {name=p69940 lab=_87031_/D }
C {sky130_stdcells/inv_2.sym} 70700 -30850 0 0 {name=X_44616_ }
C {devices/lab_pin.sym} 70660 -30730 0 0 {name=p69941 lab=clkbuf_9_59_0_CLK/A }
C {devices/lab_pin.sym} 70740 -30730 0 1 {name=p69942 lab=clkbuf_9_58_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 70700 -30730 0 0 {name=Xclkbuf_9_58_0_CLK }
C {devices/lab_pin.sym} 70640 -30620 0 0 {name=p69943 lab=_63427_/A }
C {devices/lab_pin.sym} 70640 -30580 0 0 {name=p69944 lab=_61844_/X }
C {devices/lab_pin.sym} 70760 -30600 0 1 {name=p69945 lab=_63450_/X }
C {sky130_stdcells/and2_4.sym} 70700 -30600 0 0 {name=X_63450_ }
C {devices/lab_pin.sym} 70660 -30470 0 0 {name=p69946 lab=_75436_/A }
C {devices/lab_pin.sym} 70740 -30470 0 1 {name=p69947 lab=_75436_/Y }
C {sky130_stdcells/inv_2.sym} 70700 -30470 0 0 {name=X_75436_ }
C {devices/lab_pin.sym} 70620 -30390 0 0 {name=p69948 lab=_41824_/X }
C {devices/lab_pin.sym} 70620 -30350 0 0 {name=p69949 lab=_41825_/X }
C {devices/lab_pin.sym} 70620 -30310 0 0 {name=p69950 lab=_40452_/X }
C {devices/lab_pin.sym} 70620 -30270 0 0 {name=p69951 lab=_66920_/B }
C {devices/lab_pin.sym} 70620 -30230 0 0 {name=p69952 lab=_41821_/X }
C {devices/lab_pin.sym} 70780 -30310 0 1 {name=p69953 lab=_41829_/A }
C {sky130_stdcells/o32ai_4.sym} 70700 -30310 0 0 {name=X_41828_ }
C {devices/lab_pin.sym} 70660 -30150 0 0 {name=p69954 lab=_48384_/A }
C {devices/lab_pin.sym} 70740 -30150 0 1 {name=p69955 lab=_48384_/Y }
C {sky130_stdcells/inv_2.sym} 70700 -30150 0 0 {name=X_48384_ }
C {devices/lab_pin.sym} 70640 -30050 0 0 {name=p69956 lab=_72656_/A }
C {devices/lab_pin.sym} 70640 -30010 0 0 {name=p69957 lab=_72656_/B }
C {devices/lab_pin.sym} 70640 -29970 0 0 {name=p69958 lab=_72648_/C }
C {devices/lab_pin.sym} 70760 -30010 0 1 {name=p69959 lab=_72648_/Y }
C {sky130_stdcells/nand3_4.sym} 70700 -30010 0 0 {name=X_72648_ }
C {devices/lab_pin.sym} 70660 -29870 0 0 {name=p69960 lab=_60662_/A }
C {devices/lab_pin.sym} 70740 -29870 0 1 {name=p69961 lab=_60720_/A }
C {sky130_stdcells/inv_2.sym} 70700 -29870 0 0 {name=X_60662_ }
C {devices/lab_pin.sym} 70660 -29750 0 0 {name=p69962 lab=_45596_/A }
C {devices/lab_pin.sym} 70740 -29750 0 1 {name=p69963 lab=_45596_/X }
C {sky130_stdcells/buf_2.sym} 70700 -29750 0 0 {name=X_45596_ }
C {devices/lab_pin.sym} 70640 -29660 0 0 {name=p69964 lab=_61492_/A }
C {devices/lab_pin.sym} 70640 -29620 0 0 {name=p69965 lab=_62332_/B }
C {devices/lab_pin.sym} 70640 -29580 0 0 {name=p69966 lab=_62386_/C }
C {devices/lab_pin.sym} 70640 -29540 0 0 {name=p69967 lab=_62431_/D }
C {devices/lab_pin.sym} 70760 -29600 0 1 {name=p69968 lab=_62401_/Y }
C {sky130_stdcells/nand4_4.sym} 70700 -29600 0 0 {name=X_62401_ }
C {devices/lab_pin.sym} 70660 -29450 0 0 {name=p69969 lab=_47334_/Y }
C {devices/lab_pin.sym} 70740 -29450 0 1 {name=p69970 lab=_52991_/B }
C {sky130_stdcells/buf_2.sym} 70700 -29450 0 0 {name=X_47335_ }
C {devices/lab_pin.sym} 70640 -29340 0 0 {name=p69971 lab=_78154_/A }
C {devices/lab_pin.sym} 70640 -29300 0 0 {name=p69972 lab=_78154_/B }
C {devices/lab_pin.sym} 70760 -29320 0 1 {name=p69973 lab=_78162_/C }
C {sky130_stdcells/nand2_4.sym} 70700 -29320 0 0 {name=X_78155_ }
C {devices/lab_pin.sym} 70660 -29190 0 0 {name=p69974 lab=_44547_/A }
C {devices/lab_pin.sym} 70740 -29190 0 1 {name=p69975 lab=_44547_/X }
C {sky130_stdcells/buf_2.sym} 70700 -29190 0 0 {name=X_44547_ }
C {devices/lab_pin.sym} 70620 -29110 0 0 {name=p69976 lab=_63368_/X }
C {devices/lab_pin.sym} 70620 -29070 0 0 {name=p69977 lab=_63369_/X }
C {devices/lab_pin.sym} 70620 -29030 0 0 {name=p69978 lab=_63373_/X }
C {devices/lab_pin.sym} 70620 -28990 0 0 {name=p69979 lab=_63377_/X }
C {devices/lab_pin.sym} 70620 -28950 0 0 {name=p69980 lab=_63380_/Y }
C {devices/lab_pin.sym} 70780 -29030 0 1 {name=p69981 lab=_63381_/Y }
C {sky130_stdcells/o41ai_4.sym} 70700 -29030 0 0 {name=X_63381_ }
C {devices/lab_pin.sym} 70620 -28890 0 0 {name=p69982 lab=_75347_/X }
C {devices/lab_pin.sym} 70620 -28850 0 0 {name=p69983 lab=_75366_/Y }
C {devices/lab_pin.sym} 70620 -28810 0 0 {name=p69984 lab=_75339_/Y }
C {devices/lab_pin.sym} 70780 -28850 0 1 {name=p69985 lab=_75367_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -28850 0 0 {name=X_75367_ }
C {devices/lab_pin.sym} 70660 -28710 0 0 {name=p69986 lab=_41759_/A }
C {devices/lab_pin.sym} 70740 -28710 0 1 {name=p69987 lab=_41759_/Y }
C {sky130_stdcells/inv_2.sym} 70700 -28710 0 0 {name=X_41759_ }
C {devices/lab_pin.sym} 70640 -28600 0 0 {name=p69988 lab=_60593_/A }
C {devices/lab_pin.sym} 70640 -28560 0 0 {name=p69989 lab=_60593_/B }
C {devices/lab_pin.sym} 70760 -28580 0 1 {name=p69990 lab=_60594_/A }
C {sky130_stdcells/nor2_4.sym} 70700 -28580 0 0 {name=X_60593_ }
C {devices/lab_pin.sym} 70640 -28460 0 0 {name=p69991 lab=_72579_/A }
C {devices/lab_pin.sym} 70640 -28420 0 0 {name=p69992 lab=_72579_/B }
C {devices/lab_pin.sym} 70760 -28440 0 1 {name=p69993 lab=_72579_/Y }
C {sky130_stdcells/nand2_4.sym} 70700 -28440 0 0 {name=X_72579_ }
C {devices/lab_pin.sym} 70640 -28320 0 0 {name=p69994 lab=_65227_/A }
C {devices/lab_pin.sym} 70640 -28280 0 0 {name=p69995 lab=_65120_/B }
C {devices/lab_pin.sym} 70760 -28300 0 1 {name=p69996 lab=_65120_/X }
C {sky130_stdcells/and2_4.sym} 70700 -28300 0 0 {name=X_65120_ }
C {devices/lab_pin.sym} 70640 -28180 0 0 {name=p69997 lab=_77106_/A }
C {devices/lab_pin.sym} 70640 -28140 0 0 {name=p69998 lab=_77112_/C }
C {devices/lab_pin.sym} 70760 -28160 0 1 {name=p69999 lab=_77109_/A }
C {sky130_stdcells/nand2_4.sym} 70700 -28160 0 0 {name=X_77106_ }
C {devices/lab_pin.sym} 70640 -28060 0 0 {name=p70000 lab=_61430_/A }
C {devices/lab_pin.sym} 70640 -28020 0 0 {name=p70001 lab=_62332_/B }
C {devices/lab_pin.sym} 70640 -27980 0 0 {name=p70002 lab=_62631_/C }
C {devices/lab_pin.sym} 70640 -27940 0 0 {name=p70003 lab=_62332_/D }
C {devices/lab_pin.sym} 70760 -28000 0 1 {name=p70004 lab=_62335_/B }
C {sky130_stdcells/nand4_4.sym} 70700 -28000 0 0 {name=X_62332_ }
C {devices/lab_pin.sym} 70620 -27870 0 0 {name=p70005 lab=_70301_/C }
C {devices/lab_pin.sym} 70620 -27830 0 0 {name=p70006 lab=_74314_/X }
C {devices/lab_pin.sym} 70620 -27790 0 0 {name=p70007 lab=_74317_/Y }
C {devices/lab_pin.sym} 70780 -27830 0 1 {name=p70008 lab=_74318_/X }
C {sky130_stdcells/a21bo_4.sym} 70700 -27830 0 0 {name=X_74318_ }
C {devices/lab_pin.sym} 70620 -27710 0 0 {name=p70009 lab=_47262_/Y }
C {devices/lab_pin.sym} 70620 -27670 0 0 {name=p70010 lab=_47224_/X }
C {devices/lab_pin.sym} 70620 -27630 0 0 {name=p70011 lab=_47265_/X }
C {devices/lab_pin.sym} 70780 -27670 0 1 {name=p70012 lab=_47266_/Y }
C {sky130_stdcells/a21oi_4.sym} 70700 -27670 0 0 {name=X_47266_ }
C {devices/lab_pin.sym} 70640 -27540 0 0 {name=p70013 lab=_82659_/Q }
C {devices/lab_pin.sym} 70640 -27500 0 0 {name=p70014 lab=_78085_/Y }
C {devices/lab_pin.sym} 70760 -27520 0 1 {name=p70015 lab=_78086_/X }
C {sky130_stdcells/xor2_4.sym} 70700 -27520 0 0 {name=X_78086_ }
C {devices/lab_pin.sym} 70660 -27390 0 0 {name=p70016 lab=_44478_/A }
C {devices/lab_pin.sym} 70740 -27390 0 1 {name=p70017 lab=_87088_/D }
C {sky130_stdcells/inv_2.sym} 70700 -27390 0 0 {name=X_44478_ }
C {devices/lab_pin.sym} 70620 -27290 0 0 {name=p70018 lab=_75287_/Y }
C {devices/lab_pin.sym} 70620 -27250 0 0 {name=p70019 lab=_75288_/Y }
C {devices/lab_pin.sym} 70620 -27210 0 0 {name=p70020 lab=_75289_/Y }
C {devices/lab_pin.sym} 70780 -27250 0 1 {name=p70021 lab=_75298_/X }
C {sky130_stdcells/o21a_4.sym} 70700 -27250 0 0 {name=X_75298_ }
C {devices/lab_pin.sym} 70660 -27110 0 0 {name=p70022 lab=_49005_/A }
C {devices/lab_pin.sym} 70740 -27110 0 1 {name=p70023 lab=_53841_/B }
C {sky130_stdcells/inv_2.sym} 70700 -27110 0 0 {name=X_49005_ }
C {devices/lab_pin.sym} 70640 -27000 0 0 {name=p70024 lab=_65836_/A }
C {devices/lab_pin.sym} 70640 -26960 0 0 {name=p70025 lab=_65051_/B }
C {devices/lab_pin.sym} 70760 -26980 0 1 {name=p70026 lab=_65051_/X }
C {sky130_stdcells/and2_4.sym} 70700 -26980 0 0 {name=X_65051_ }
C {devices/lab_pin.sym} 70640 -26870 0 0 {name=p70027 lab=_46222_/A }
C {devices/lab_pin.sym} 70640 -26830 0 0 {name=p70028 lab=_46217_/B }
C {devices/lab_pin.sym} 70640 -26790 0 0 {name=p70029 lab=_46217_/C }
C {devices/lab_pin.sym} 70760 -26830 0 1 {name=p70030 lab=_46217_/Y }
C {sky130_stdcells/nand3_4.sym} 70700 -26830 0 0 {name=X_46217_ }
C {devices/lab_pin.sym} 70620 -26710 0 0 {name=p70031 lab=_77030_/Y }
C {devices/lab_pin.sym} 70620 -26670 0 0 {name=p70032 lab=_77035_/Y }
C {devices/lab_pin.sym} 70620 -26630 0 0 {name=p70033 lab=_77036_/Y }
C {devices/lab_pin.sym} 70780 -26670 0 1 {name=p70034 lab=_77041_/C }
C {sky130_stdcells/a21o_4.sym} 70700 -26670 0 0 {name=X_77037_ }
C {sky130_stdcells/decap_3.sym} 70700 -26500 0 0 {name=XPHY_290 }
C {devices/lab_pin.sym} 70620 -26380 0 0 {name=p70035 lab=_41552_/X }
C {devices/lab_pin.sym} 70620 -26340 0 0 {name=p70036 lab=_43412_/X }
C {devices/lab_pin.sym} 70620 -26300 0 0 {name=p70037 lab=_87426_/Q }
C {devices/lab_pin.sym} 70620 -26260 0 0 {name=p70038 lab=_43413_/X }
C {devices/lab_pin.sym} 70780 -26320 0 1 {name=p70039 lab=_43429_/X }
C {sky130_stdcells/a2bb2o_4.sym} 70700 -26320 0 0 {name=X_43429_ }
C {devices/lab_pin.sym} 70640 -26200 0 0 {name=p70040 lab=_62212_/A }
C {devices/lab_pin.sym} 70640 -26160 0 0 {name=p70041 lab=_62260_/Y }
C {devices/lab_pin.sym} 70640 -26120 0 0 {name=p70042 lab=_62261_/Y }
C {devices/lab_pin.sym} 70640 -26080 0 0 {name=p70043 lab=_62262_/Y }
C {devices/lab_pin.sym} 70760 -26140 0 1 {name=p70044 lab=_62263_/Y }
C {sky130_stdcells/nand4_4.sym} 70700 -26140 0 0 {name=X_62263_ }
C {devices/lab_pin.sym} 70620 -26010 0 0 {name=p70045 lab=_88341_/Q }
C {devices/lab_pin.sym} 70620 -25970 0 0 {name=p70046 lab=_73801_/X }
C {devices/lab_pin.sym} 70620 -25930 0 0 {name=p70047 lab=_73087_/X }
C {devices/lab_pin.sym} 70780 -25970 0 1 {name=p70048 lab=_74249_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -25970 0 0 {name=X_74249_ }
C {devices/lab_pin.sym} 70620 -25850 0 0 {name=p70049 lab=_59361_/A }
C {devices/lab_pin.sym} 70620 -25810 0 0 {name=p70050 lab=_47192_/X }
C {devices/lab_pin.sym} 70620 -25770 0 0 {name=p70051 lab=_47196_/Y }
C {devices/lab_pin.sym} 70780 -25810 0 1 {name=p70052 lab=_47197_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -25810 0 0 {name=X_47197_ }
C {devices/lab_pin.sym} 70640 -25700 0 0 {name=p70053 lab=_63561_/B }
C {devices/lab_pin.sym} 70640 -25660 0 0 {name=p70054 lab=_63955_/X }
C {devices/lab_pin.sym} 70640 -25620 0 0 {name=p70055 lab=_64050_/C }
C {devices/lab_pin.sym} 70640 -25580 0 0 {name=p70056 lab=_64033_/D }
C {devices/lab_pin.sym} 70760 -25640 0 1 {name=p70057 lab=_64002_/Y }
C {sky130_stdcells/nand4_4.sym} 70700 -25640 0 0 {name=X_64002_ }
C {devices/lab_pin.sym} 70660 -25490 0 0 {name=p70058 lab=_61188_/C }
C {devices/lab_pin.sym} 70740 -25490 0 1 {name=p70059 lab=_61214_/Y }
C {sky130_stdcells/inv_2.sym} 70700 -25490 0 0 {name=X_61214_ }
C {devices/lab_pin.sym} 70660 -25370 0 0 {name=p70060 lab=_44274_/D }
C {devices/lab_pin.sym} 70740 -25370 0 1 {name=p70061 lab=_44307_/D }
C {sky130_stdcells/buf_2.sym} 70700 -25370 0 0 {name=Xpsn_inst_psn_buff_17 }
C {devices/lab_pin.sym} 70660 -25250 0 0 {name=p70062 lab=_49520_/A }
C {devices/lab_pin.sym} 70740 -25250 0 1 {name=p70063 lab=_49380_/C }
C {sky130_stdcells/buf_2.sym} 70700 -25250 0 0 {name=X_46148_ }
C {devices/lab_pin.sym} 70660 -25130 0 0 {name=p70064 lab=_50212_/A }
C {devices/lab_pin.sym} 70740 -25130 0 1 {name=p70065 lab=_50218_/A }
C {sky130_stdcells/buf_2.sym} 70700 -25130 0 0 {name=Xpsn_inst_psn_buff_28 }
C {devices/lab_pin.sym} 70640 -25040 0 0 {name=p70066 lab=_62194_/A }
C {devices/lab_pin.sym} 70640 -25000 0 0 {name=p70067 lab=_84905_/Q }
C {devices/lab_pin.sym} 70640 -24960 0 0 {name=p70068 lab=_62618_/D }
C {devices/lab_pin.sym} 70640 -24920 0 0 {name=p70069 lab=_62194_/D }
C {devices/lab_pin.sym} 70760 -24980 0 1 {name=p70070 lab=_62194_/X }
C {sky130_stdcells/and4_4.sym} 70700 -24980 0 0 {name=X_62194_ }
C {devices/lab_pin.sym} 70620 -24850 0 0 {name=p70071 lab=_68807_/X }
C {devices/lab_pin.sym} 70620 -24810 0 0 {name=p70072 lab=_68809_/X }
C {devices/lab_pin.sym} 70620 -24770 0 0 {name=p70073 lab=_68737_/X }
C {devices/lab_pin.sym} 70780 -24810 0 1 {name=p70074 lab=_68810_/Y }
C {sky130_stdcells/a21oi_4.sym} 70700 -24810 0 0 {name=X_68810_ }
C {devices/lab_pin.sym} 70660 -24670 0 0 {name=p70075 lab=_64221_/A }
C {devices/lab_pin.sym} 70740 -24670 0 1 {name=p70076 lab=_61145_/X }
C {sky130_stdcells/buf_2.sym} 70700 -24670 0 0 {name=X_61145_ }
C {devices/lab_pin.sym} 70620 -24590 0 0 {name=p70077 lab=_46067_/X }
C {devices/lab_pin.sym} 70620 -24550 0 0 {name=p70078 lab=_43046_/A }
C {devices/lab_pin.sym} 70620 -24510 0 0 {name=p70079 lab=_41615_/X }
C {devices/lab_pin.sym} 70620 -24470 0 0 {name=p70080 lab=_86777_/Q }
C {devices/lab_pin.sym} 70620 -24430 0 0 {name=p70081 lab=_46068_/X }
C {devices/lab_pin.sym} 70780 -24510 0 1 {name=p70082 lab=_46080_/A }
C {sky130_stdcells/o32ai_4.sym} 70700 -24510 0 0 {name=X_46079_ }
C {devices/lab_pin.sym} 70660 -24350 0 0 {name=p70083 lab=_69790_/A }
C {devices/lab_pin.sym} 70740 -24350 0 1 {name=p70084 lab=_69790_/Y }
C {sky130_stdcells/inv_2.sym} 70700 -24350 0 0 {name=X_69790_ }
C {devices/lab_pin.sym} 70660 -24230 0 0 {name=p70085 lab=_78978_/B }
C {devices/lab_pin.sym} 70740 -24230 0 1 {name=p70086 lab=_82517_/D }
C {sky130_stdcells/inv_2.sym} 70700 -24230 0 0 {name=X_78988_ }
C {devices/lab_pin.sym} 70660 -24110 0 0 {name=p70087 lab=_49854_/A }
C {devices/lab_pin.sym} 70740 -24110 0 1 {name=p70088 lab=_49928_/A }
C {sky130_stdcells/buf_2.sym} 70700 -24110 0 0 {name=X_49907_ }
C {devices/lab_pin.sym} 70660 -23990 0 0 {name=p70089 lab=_69779_/A }
C {devices/lab_pin.sym} 70740 -23990 0 1 {name=p70090 lab=_68741_/X }
C {sky130_stdcells/buf_2.sym} 70700 -23990 0 0 {name=X_68741_ }
C {devices/lab_pin.sym} 70640 -23890 0 0 {name=p70091 lab=_65949_/X }
C {devices/lab_pin.sym} 70640 -23850 0 0 {name=p70092 lab=_65868_/B }
C {devices/lab_pin.sym} 70640 -23810 0 0 {name=p70093 lab=_65952_/X }
C {devices/lab_pin.sym} 70760 -23850 0 1 {name=p70094 lab=_65953_/Y }
C {sky130_stdcells/nand3_4.sym} 70700 -23850 0 0 {name=X_65953_ }
C {devices/lab_pin.sym} 70640 -23720 0 0 {name=p70095 lab=_61075_/X }
C {devices/lab_pin.sym} 70640 -23680 0 0 {name=p70096 lab=_60631_/D }
C {devices/lab_pin.sym} 70760 -23700 0 1 {name=p70097 lab=_61144_/A }
C {sky130_stdcells/and2_4.sym} 70700 -23700 0 0 {name=X_61076_ }
C {devices/lab_pin.sym} 70640 -23580 0 0 {name=p70098 lab=_77933_/A }
C {devices/lab_pin.sym} 70640 -23540 0 0 {name=p70099 lab=_77933_/B }
C {devices/lab_pin.sym} 70760 -23560 0 1 {name=p70100 lab=_77939_/Y }
C {sky130_stdcells/nor2_4.sym} 70700 -23560 0 0 {name=X_77939_ }
C {devices/lab_pin.sym} 70640 -23440 0 0 {name=p70101 lab=_64904_/A }
C {devices/lab_pin.sym} 70640 -23400 0 0 {name=p70102 lab=_64904_/B }
C {devices/lab_pin.sym} 70760 -23420 0 1 {name=p70103 lab=_64904_/X }
C {sky130_stdcells/and2_4.sym} 70700 -23420 0 0 {name=X_64904_ }
C {devices/lab_pin.sym} 70660 -23290 0 0 {name=p70104 lab=_60027_/A }
C {devices/lab_pin.sym} 70740 -23290 0 1 {name=p70105 lab=_60027_/X }
C {sky130_stdcells/buf_2.sym} 70700 -23290 0 0 {name=X_60027_ }
C {devices/lab_pin.sym} 70620 -23190 0 0 {name=p70106 lab=_58038_/B }
C {devices/lab_pin.sym} 70620 -23150 0 0 {name=p70107 lab=_49825_/X }
C {devices/lab_pin.sym} 70620 -23110 0 0 {name=p70108 lab=_49837_/Y }
C {devices/lab_pin.sym} 70780 -23150 0 1 {name=p70109 lab=_49838_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -23150 0 0 {name=X_49838_ }
C {devices/lab_pin.sym} 70610 -23010 0 0 {name=p70110 lab=_81996_/CLK }
C {devices/lab_pin.sym} 70610 -22990 0 0 {name=p70111 lab=_80950_/D }
C {devices/lab_pin.sym} 70790 -23010 0 1 {name=p70112 lab=_74993_/A }
C {sky130_stdcells/dfxtp_4.sym} 70700 -23000 0 0 {name=X_80950_ }
C {devices/lab_pin.sym} 70640 -22880 0 0 {name=p70113 lab=_68746_/A }
C {devices/lab_pin.sym} 70640 -22840 0 0 {name=p70114 lab=_68672_/B }
C {devices/lab_pin.sym} 70760 -22860 0 1 {name=p70115 lab=_68672_/Y }
C {sky130_stdcells/nor2_4.sym} 70700 -22860 0 0 {name=X_68672_ }
C {devices/lab_pin.sym} 70640 -22740 0 0 {name=p70116 lab=_65884_/A }
C {devices/lab_pin.sym} 70640 -22700 0 0 {name=p70117 lab=_65884_/B }
C {devices/lab_pin.sym} 70760 -22720 0 1 {name=p70118 lab=_65884_/Y }
C {sky130_stdcells/nand2_4.sym} 70700 -22720 0 0 {name=X_65884_ }
C {devices/lab_pin.sym} 70640 -22600 0 0 {name=p70119 lab=_67623_/A }
C {devices/lab_pin.sym} 70640 -22560 0 0 {name=p70120 lab=_67623_/B }
C {devices/lab_pin.sym} 70760 -22580 0 1 {name=p70121 lab=_67623_/Y }
C {sky130_stdcells/nand2_4.sym} 70700 -22580 0 0 {name=X_67623_ }
C {devices/lab_pin.sym} 70640 -22460 0 0 {name=p70122 lab=_79609_/A }
C {devices/lab_pin.sym} 70640 -22420 0 0 {name=p70123 lab=_79609_/B }
C {devices/lab_pin.sym} 70760 -22440 0 1 {name=p70124 lab=_79610_/A }
C {sky130_stdcells/nand2_4.sym} 70700 -22440 0 0 {name=X_79609_ }
C {devices/lab_pin.sym} 70660 -22310 0 0 {name=p70125 lab=_64598_/X }
C {devices/lab_pin.sym} 70740 -22310 0 1 {name=p70126 lab=_64835_/X }
C {sky130_stdcells/buf_2.sym} 70700 -22310 0 0 {name=X_64835_ }
C {devices/lab_pin.sym} 70660 -22190 0 0 {name=p70127 lab=_49688_/X }
C {devices/lab_pin.sym} 70740 -22190 0 1 {name=p70128 lab=_49769_/X }
C {sky130_stdcells/buf_2.sym} 70700 -22190 0 0 {name=X_49769_ }
C {devices/lab_pin.sym} 70610 -22070 0 0 {name=p70129 lab=_80849_/CLK }
C {devices/lab_pin.sym} 70610 -22050 0 0 {name=p70130 lab=_75712_/B }
C {devices/lab_pin.sym} 70790 -22070 0 1 {name=p70131 lab=_80881_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -22060 0 0 {name=X_80881_ }
C {devices/lab_pin.sym} 70640 -21940 0 0 {name=p70132 lab=_51796_/A }
C {devices/lab_pin.sym} 70640 -21900 0 0 {name=p70133 lab=_51800_/B }
C {devices/lab_pin.sym} 70760 -21920 0 1 {name=p70134 lab=_51800_/Y }
C {sky130_stdcells/nand2_4.sym} 70700 -21920 0 0 {name=X_51800_ }
C {devices/lab_pin.sym} 70610 -21790 0 0 {name=p70135 lab=_82589_/CLK }
C {devices/lab_pin.sym} 70610 -21770 0 0 {name=p70136 lab=_79047_/B }
C {devices/lab_pin.sym} 70790 -21790 0 1 {name=p70137 lab=_82620_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -21780 0 0 {name=X_82620_ }
C {devices/lab_pin.sym} 70620 -21680 0 0 {name=p70138 lab=_86966_/Q }
C {devices/lab_pin.sym} 70620 -21640 0 0 {name=p70139 lab=_67551_/X }
C {devices/lab_pin.sym} 70620 -21600 0 0 {name=p70140 lab=_67552_/X }
C {devices/lab_pin.sym} 70620 -21560 0 0 {name=p70141 lab=_67553_/X }
C {devices/lab_pin.sym} 70780 -21620 0 1 {name=p70142 lab=_67555_/B }
C {sky130_stdcells/a211o_4.sym} 70700 -21620 0 0 {name=X_67554_ }
C {devices/lab_pin.sym} 70620 -21490 0 0 {name=p70143 lab=_52778_/Y }
C {devices/lab_pin.sym} 70620 -21450 0 0 {name=p70144 lab=_52755_/X }
C {devices/lab_pin.sym} 70620 -21410 0 0 {name=p70145 lab=_52779_/X }
C {devices/lab_pin.sym} 70780 -21450 0 1 {name=p70146 lab=_52780_/Y }
C {sky130_stdcells/a21oi_4.sym} 70700 -21450 0 0 {name=X_52780_ }
C {devices/lab_pin.sym} 70660 -21310 0 0 {name=p70147 lab=_64766_/A }
C {devices/lab_pin.sym} 70740 -21310 0 1 {name=p70148 lab=_64766_/X }
C {sky130_stdcells/buf_2.sym} 70700 -21310 0 0 {name=X_64766_ }
C {devices/lab_pin.sym} 70620 -21210 0 0 {name=p70149 lab=_61974_/Y }
C {devices/lab_pin.sym} 70620 -21170 0 0 {name=p70150 lab=_61959_/X }
C {devices/lab_pin.sym} 70620 -21130 0 0 {name=p70151 lab=_61977_/Y }
C {devices/lab_pin.sym} 70780 -21170 0 1 {name=p70152 lab=_84442_/D }
C {sky130_stdcells/a21oi_4.sym} 70700 -21170 0 0 {name=X_61978_ }
C {devices/lab_pin.sym} 70640 -21050 0 0 {name=p70153 lab=_64867_/B }
C {devices/lab_pin.sym} 70640 -21010 0 0 {name=p70154 lab=_66501_/B }
C {devices/lab_pin.sym} 70640 -20970 0 0 {name=p70155 lab=_84110_/Q }
C {devices/lab_pin.sym} 70760 -21010 0 1 {name=p70156 lab=_66505_/X }
C {sky130_stdcells/and3_4.sym} 70700 -21010 0 0 {name=X_66505_ }
C {devices/lab_pin.sym} 70620 -20890 0 0 {name=p70157 lab=_51729_/Y }
C {devices/lab_pin.sym} 70620 -20850 0 0 {name=p70158 lab=_51719_/X }
C {devices/lab_pin.sym} 70620 -20810 0 0 {name=p70159 lab=_51730_/X }
C {devices/lab_pin.sym} 70780 -20850 0 1 {name=p70160 lab=_85956_/D }
C {sky130_stdcells/a21oi_4.sym} 70700 -20850 0 0 {name=X_51731_ }
C {devices/lab_pin.sym} 70620 -20750 0 0 {name=p70161 lab=_63712_/Y }
C {devices/lab_pin.sym} 70620 -20710 0 0 {name=p70162 lab=_63715_/X }
C {devices/lab_pin.sym} 70620 -20670 0 0 {name=p70163 lab=_63716_/X }
C {devices/lab_pin.sym} 70620 -20630 0 0 {name=p70164 lab=_84866_/Q }
C {devices/lab_pin.sym} 70620 -20590 0 0 {name=p70165 lab=_63363_/A }
C {devices/lab_pin.sym} 70780 -20670 0 1 {name=p70166 lab=_63717_/Y }
C {sky130_stdcells/o32ai_4.sym} 70700 -20670 0 0 {name=X_63717_ }
C {devices/lab_pin.sym} 70610 -20510 0 0 {name=p70167 lab=_82553_/CLK }
C {devices/lab_pin.sym} 70610 -20490 0 0 {name=p70168 lab=_83871_/Q }
C {devices/lab_pin.sym} 70790 -20510 0 1 {name=p70169 lab=_82551_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -20500 0 0 {name=X_82551_ }
C {devices/lab_pin.sym} 70660 -20370 0 0 {name=p70170 lab=_60928_/X }
C {devices/lab_pin.sym} 70740 -20370 0 1 {name=p70171 lab=_60930_/C }
C {sky130_stdcells/buf_2.sym} 70700 -20370 0 0 {name=X_60929_ }
C {devices/lab_pin.sym} 70640 -20260 0 0 {name=p70172 lab=_67460_/A }
C {devices/lab_pin.sym} 70640 -20220 0 0 {name=p70173 lab=_87725_/Q }
C {devices/lab_pin.sym} 70760 -20240 0 1 {name=p70174 lab=_67485_/X }
C {sky130_stdcells/and2_4.sym} 70700 -20240 0 0 {name=X_67485_ }
C {devices/lab_pin.sym} 70660 -20110 0 0 {name=p70175 lab=_64642_/A }
C {devices/lab_pin.sym} 70740 -20110 0 1 {name=p70176 lab=_64697_/X }
C {sky130_stdcells/buf_2.sym} 70700 -20110 0 0 {name=X_64697_ }
C {devices/lab_pin.sym} 70610 -19990 0 0 {name=p70177 lab=_81461_/CLK }
C {devices/lab_pin.sym} 70610 -19970 0 0 {name=p70178 lab=_81502_/D }
C {devices/lab_pin.sym} 70790 -19990 0 1 {name=p70179 lab=_76906_/A }
C {sky130_stdcells/dfxtp_4.sym} 70700 -19980 0 0 {name=X_81502_ }
C {devices/lab_pin.sym} 70640 -19860 0 0 {name=p70180 lab=_69253_/A }
C {devices/lab_pin.sym} 70640 -19820 0 0 {name=p70181 lab=_69224_/B }
C {devices/lab_pin.sym} 70760 -19840 0 1 {name=p70182 lab=_69224_/X }
C {sky130_stdcells/and2_4.sym} 70700 -19840 0 0 {name=X_69224_ }
C {devices/lab_pin.sym} 70620 -19730 0 0 {name=p70183 lab=_54447_/Y }
C {devices/lab_pin.sym} 70620 -19690 0 0 {name=p70184 lab=_54448_/X }
C {devices/lab_pin.sym} 70620 -19650 0 0 {name=p70185 lab=_54449_/X }
C {devices/lab_pin.sym} 70780 -19690 0 1 {name=p70186 lab=_85440_/D }
C {sky130_stdcells/a21oi_4.sym} 70700 -19690 0 0 {name=X_54450_ }
C {devices/lab_pin.sym} 70640 -19570 0 0 {name=p70187 lab=_66116_/X }
C {devices/lab_pin.sym} 70640 -19530 0 0 {name=p70188 lab=_66517_/B }
C {devices/lab_pin.sym} 70640 -19490 0 0 {name=p70189 lab=_66120_/X }
C {devices/lab_pin.sym} 70760 -19530 0 1 {name=p70190 lab=_66436_/Y }
C {sky130_stdcells/nand3_4.sym} 70700 -19530 0 0 {name=X_66436_ }
C {devices/lab_pin.sym} 70610 -19390 0 0 {name=p70191 lab=_85270_/CLK }
C {devices/lab_pin.sym} 70610 -19370 0 0 {name=p70192 lab=_85270_/D }
C {devices/lab_pin.sym} 70790 -19390 0 1 {name=p70193 lab=_56221_/C }
C {sky130_stdcells/dfxtp_4.sym} 70700 -19380 0 0 {name=X_85270_ }
C {devices/lab_pin.sym} 70660 -19250 0 0 {name=p70194 lab=_51608_/A }
C {devices/lab_pin.sym} 70740 -19250 0 1 {name=p70195 lab=_51684_/C }
C {sky130_stdcells/buf_2.sym} 70700 -19250 0 0 {name=X_51662_ }
C {devices/lab_pin.sym} 70640 -19140 0 0 {name=p70196 lab=_59423_/Y }
C {devices/lab_pin.sym} 70640 -19100 0 0 {name=p70197 lab=_63648_/B }
C {devices/lab_pin.sym} 70760 -19120 0 1 {name=p70198 lab=_63648_/Y }
C {sky130_stdcells/nor2_4.sym} 70700 -19120 0 0 {name=X_63648_ }
C {devices/lab_pin.sym} 70610 -18990 0 0 {name=p70199 lab=_82610_/CLK }
C {devices/lab_pin.sym} 70610 -18970 0 0 {name=p70200 lab=_82482_/D }
C {devices/lab_pin.sym} 70790 -18990 0 1 {name=p70201 lab=_82858_/D }
C {sky130_stdcells/dfxtp_4.sym} 70700 -18980 0 0 {name=X_82482_ }
C {devices/lab_pin.sym} 70660 -18850 0 0 {name=p70202 lab=_53347_/A }
C {devices/lab_pin.sym} 70740 -18850 0 1 {name=p70203 lab=_53402_/B }
C {sky130_stdcells/buf_2.sym} 70700 -18850 0 0 {name=X_53401_ }
C {devices/lab_pin.sym} 70610 -18730 0 0 {name=p70204 lab=_81224_/CLK }
C {devices/lab_pin.sym} 70610 -18710 0 0 {name=p70205 lab=_84221_/D }
C {devices/lab_pin.sym} 70790 -18730 0 1 {name=p70206 lab=_84221_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -18720 0 0 {name=X_84221_ }
C {devices/lab_pin.sym} 70620 -18610 0 0 {name=p70207 lab=_86167_/Q }
C {devices/lab_pin.sym} 70620 -18570 0 0 {name=p70208 lab=_50594_/X }
C {devices/lab_pin.sym} 70620 -18530 0 0 {name=p70209 lab=_50612_/Y }
C {devices/lab_pin.sym} 70780 -18570 0 1 {name=p70210 lab=_50613_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -18570 0 0 {name=X_50613_ }
C {devices/lab_pin.sym} 70610 -18430 0 0 {name=p70211 lab=_81433_/CLK }
C {devices/lab_pin.sym} 70610 -18410 0 0 {name=p70212 lab=_81465_/Q }
C {devices/lab_pin.sym} 70790 -18430 0 1 {name=p70213 lab=_76085_/B }
C {sky130_stdcells/dfxtp_4.sym} 70700 -18420 0 0 {name=X_81433_ }
C {devices/lab_pin.sym} 70620 -18320 0 0 {name=p70214 lab=_87038_/Q }
C {devices/lab_pin.sym} 70620 -18280 0 0 {name=p70215 lab=_69153_/X }
C {devices/lab_pin.sym} 70620 -18240 0 0 {name=p70216 lab=_68891_/X }
C {devices/lab_pin.sym} 70620 -18200 0 0 {name=p70217 lab=_69154_/X }
C {devices/lab_pin.sym} 70780 -18260 0 1 {name=p70218 lab=_69155_/X }
C {sky130_stdcells/a211o_4.sym} 70700 -18260 0 0 {name=X_69155_ }
C {devices/lab_pin.sym} 70620 -18130 0 0 {name=p70219 lab=_54379_/Y }
C {devices/lab_pin.sym} 70620 -18090 0 0 {name=p70220 lab=_54366_/X }
C {devices/lab_pin.sym} 70620 -18050 0 0 {name=p70221 lab=_54380_/X }
C {devices/lab_pin.sym} 70780 -18090 0 1 {name=p70222 lab=_85453_/D }
C {sky130_stdcells/a21oi_4.sym} 70700 -18090 0 0 {name=X_54381_ }
C {devices/lab_pin.sym} 70640 -17970 0 0 {name=p70223 lab=_65923_/X }
C {devices/lab_pin.sym} 70640 -17930 0 0 {name=p70224 lab=_66367_/B }
C {devices/lab_pin.sym} 70640 -17890 0 0 {name=p70225 lab=_65927_/C }
C {devices/lab_pin.sym} 70760 -17930 0 1 {name=p70226 lab=_66367_/Y }
C {sky130_stdcells/nand3_4.sym} 70700 -17930 0 0 {name=X_66367_ }
C {devices/lab_pin.sym} 70620 -17810 0 0 {name=p70227 lab=_51591_/Y }
C {devices/lab_pin.sym} 70620 -17770 0 0 {name=p70228 lab=_51585_/X }
C {devices/lab_pin.sym} 70620 -17730 0 0 {name=p70229 lab=_51592_/X }
C {devices/lab_pin.sym} 70780 -17770 0 1 {name=p70230 lab=_51593_/Y }
C {sky130_stdcells/a21oi_4.sym} 70700 -17770 0 0 {name=X_51593_ }
C {devices/lab_pin.sym} 70640 -17650 0 0 {name=p70231 lab=_63554_/A }
C {devices/lab_pin.sym} 70640 -17610 0 0 {name=p70232 lab=_63554_/B }
C {devices/lab_pin.sym} 70640 -17570 0 0 {name=p70233 lab=_80442_/B }
C {devices/lab_pin.sym} 70760 -17610 0 1 {name=p70234 lab=_63579_/Y }
C {sky130_stdcells/nor3_4.sym} 70700 -17610 0 0 {name=X_63579_ }
C {devices/lab_pin.sym} 70640 -17480 0 0 {name=p70235 lab=_55801_/D }
C {devices/lab_pin.sym} 70640 -17440 0 0 {name=p70236 lab=_56120_/B }
C {devices/lab_pin.sym} 70760 -17460 0 1 {name=p70237 lab=_56121_/A }
C {sky130_stdcells/xor2_4.sym} 70700 -17460 0 0 {name=X_56120_ }
C {devices/lab_pin.sym} 70660 -17330 0 0 {name=p70238 lab=_68106_/A }
C {devices/lab_pin.sym} 70740 -17330 0 1 {name=p70239 lab=_68106_/X }
C {sky130_stdcells/buf_2.sym} 70700 -17330 0 0 {name=X_68106_ }
C {devices/lab_pin.sym} 70640 -17220 0 0 {name=p70240 lab=_53332_/A }
C {devices/lab_pin.sym} 70640 -17180 0 0 {name=p70241 lab=_53332_/B }
C {devices/lab_pin.sym} 70760 -17200 0 1 {name=p70242 lab=_53332_/Y }
C {sky130_stdcells/nand2_4.sym} 70700 -17200 0 0 {name=X_53332_ }
C {devices/lab_pin.sym} 70660 -17070 0 0 {name=p70243 lab=_72296_/A }
C {devices/lab_pin.sym} 70740 -17070 0 1 {name=p70244 lab=_66423_/B }
C {sky130_stdcells/buf_2.sym} 70700 -17070 0 0 {name=X_65318_ }
C {devices/lab_pin.sym} 70610 -16950 0 0 {name=p70245 lab=_81224_/CLK }
C {devices/lab_pin.sym} 70610 -16930 0 0 {name=p70246 lab=_66165_/X }
C {devices/lab_pin.sym} 70790 -16950 0 1 {name=p70247 lab=_84152_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -16940 0 0 {name=X_84152_ }
C {devices/lab_pin.sym} 70620 -16830 0 0 {name=p70248 lab=_50542_/Y }
C {devices/lab_pin.sym} 70620 -16790 0 0 {name=p70249 lab=_50525_/X }
C {devices/lab_pin.sym} 70620 -16750 0 0 {name=p70250 lab=_50543_/X }
C {devices/lab_pin.sym} 70780 -16790 0 1 {name=p70251 lab=_86181_/D }
C {sky130_stdcells/a21oi_4.sym} 70700 -16790 0 0 {name=X_50544_ }
C {devices/lab_pin.sym} 70610 -16650 0 0 {name=p70252 lab=_81461_/CLK }
C {devices/lab_pin.sym} 70610 -16630 0 0 {name=p70253 lab=_81364_/D }
C {devices/lab_pin.sym} 70790 -16650 0 1 {name=p70254 lab=_76424_/A }
C {sky130_stdcells/dfxtp_4.sym} 70700 -16640 0 0 {name=X_81364_ }
C {devices/lab_pin.sym} 70640 -16520 0 0 {name=p70255 lab=_69086_/A }
C {devices/lab_pin.sym} 70640 -16480 0 0 {name=p70256 lab=_87317_/Q }
C {devices/lab_pin.sym} 70760 -16500 0 1 {name=p70257 lab=_69086_/X }
C {sky130_stdcells/and2_4.sym} 70700 -16500 0 0 {name=X_69086_ }
C {devices/lab_pin.sym} 70640 -16380 0 0 {name=p70258 lab=_66237_/X }
C {devices/lab_pin.sym} 70640 -16340 0 0 {name=p70259 lab=_66298_/B }
C {devices/lab_pin.sym} 70760 -16360 0 1 {name=p70260 lab=_66298_/X }
C {sky130_stdcells/and2_4.sym} 70700 -16360 0 0 {name=X_66298_ }
C {devices/lab_pin.sym} 70610 -16230 0 0 {name=p70261 lab=_83095_/CLK }
C {devices/lab_pin.sym} 70610 -16210 0 0 {name=p70262 lab=_74311_/X }
C {devices/lab_pin.sym} 70790 -16230 0 1 {name=p70263 lab=_83103_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -16220 0 0 {name=X_83103_ }
C {devices/lab_pin.sym} 70640 -16110 0 0 {name=p70264 lab=_80315_/A }
C {devices/lab_pin.sym} 70640 -16070 0 0 {name=p70265 lab=_80313_/Y }
C {devices/lab_pin.sym} 70640 -16030 0 0 {name=p70266 lab=_80314_/Y }
C {devices/lab_pin.sym} 70760 -16070 0 1 {name=p70267 lab=_80317_/B }
C {sky130_stdcells/nand3_4.sym} 70700 -16070 0 0 {name=X_80315_ }
C {devices/lab_pin.sym} 70660 -15930 0 0 {name=p70268 lab=_56104_/A }
C {devices/lab_pin.sym} 70740 -15930 0 1 {name=p70269 lab=_56052_/A }
C {sky130_stdcells/buf_2.sym} 70700 -15930 0 0 {name=X_56051_ }
C {devices/lab_pin.sym} 70620 -15830 0 0 {name=p70270 lab=_68034_/X }
C {devices/lab_pin.sym} 70620 -15790 0 0 {name=p70271 lab=_68036_/X }
C {devices/lab_pin.sym} 70620 -15750 0 0 {name=p70272 lab=_67897_/X }
C {devices/lab_pin.sym} 70780 -15790 0 1 {name=p70273 lab=_68037_/Y }
C {sky130_stdcells/a21oi_4.sym} 70700 -15790 0 0 {name=X_68037_ }
C {devices/lab_pin.sym} 70640 -15660 0 0 {name=p70274 lab=_51902_/A }
C {devices/lab_pin.sym} 70640 -15620 0 0 {name=p70275 lab=_54442_/B }
C {devices/lab_pin.sym} 70760 -15640 0 1 {name=p70276 lab=_53263_/Y }
C {sky130_stdcells/nand2_4.sym} 70700 -15640 0 0 {name=X_53263_ }
C {devices/lab_pin.sym} 70640 -15520 0 0 {name=p70277 lab=_65227_/A }
C {devices/lab_pin.sym} 70640 -15480 0 0 {name=p70278 lab=_65249_/B }
C {devices/lab_pin.sym} 70760 -15500 0 1 {name=p70279 lab=_65249_/X }
C {sky130_stdcells/and2_4.sym} 70700 -15500 0 0 {name=X_65249_ }
C {devices/lab_pin.sym} 70610 -15370 0 0 {name=p70280 lab=_84105_/CLK }
C {devices/lab_pin.sym} 70610 -15350 0 0 {name=p70281 lab=_67116_/X }
C {devices/lab_pin.sym} 70790 -15370 0 1 {name=p70282 lab=_80907_/D }
C {sky130_stdcells/dfxtp_4.sym} 70700 -15360 0 0 {name=X_84083_ }
C {devices/lab_pin.sym} 70640 -15250 0 0 {name=p70283 lab=_48533_/A }
C {devices/lab_pin.sym} 70640 -15210 0 0 {name=p70284 lab=_50475_/B }
C {devices/lab_pin.sym} 70640 -15170 0 0 {name=p70285 lab=_50257_/X }
C {devices/lab_pin.sym} 70760 -15210 0 1 {name=p70286 lab=_50475_/Y }
C {sky130_stdcells/nand3_4.sym} 70700 -15210 0 0 {name=X_50475_ }
C {devices/lab_pin.sym} 70610 -15070 0 0 {name=p70287 lab=_81615_/CLK }
C {devices/lab_pin.sym} 70610 -15050 0 0 {name=p70288 lab=_76983_/X }
C {devices/lab_pin.sym} 70790 -15070 0 1 {name=p70289 lab=_81295_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -15060 0 0 {name=X_81295_ }
C {devices/lab_pin.sym} 70640 -14940 0 0 {name=p70290 lab=_55011_/A }
C {devices/lab_pin.sym} 70640 -14900 0 0 {name=p70291 lab=_47598_/A }
C {devices/lab_pin.sym} 70760 -14920 0 1 {name=p70292 lab=_55002_/Y }
C {sky130_stdcells/nand2_4.sym} 70700 -14920 0 0 {name=X_55002_ }
C {devices/lab_pin.sym} 70660 -14790 0 0 {name=p70293 lab=_52214_/A }
C {devices/lab_pin.sym} 70740 -14790 0 1 {name=p70294 lab=_52214_/X }
C {sky130_stdcells/buf_2.sym} 70700 -14790 0 0 {name=X_52214_ }
C {devices/lab_pin.sym} 70610 -14670 0 0 {name=p70295 lab=_85180_/CLK }
C {devices/lab_pin.sym} 70610 -14650 0 0 {name=p70296 lab=_74563_/Y }
C {devices/lab_pin.sym} 70790 -14670 0 1 {name=p70297 lab=_83034_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -14660 0 0 {name=X_83034_ }
C {devices/lab_pin.sym} 70610 -14530 0 0 {name=p70298 lab=_86930_/CLK }
C {devices/lab_pin.sym} 70610 -14510 0 0 {name=p70299 lab=_87911_/D }
C {devices/lab_pin.sym} 70790 -14530 0 1 {name=p70300 lab=_87911_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -14520 0 0 {name=X_87911_ }
C {devices/lab_pin.sym} 70620 -14410 0 0 {name=p70301 lab=_80230_/Y }
C {devices/lab_pin.sym} 70620 -14370 0 0 {name=p70302 lab=_80233_/Y }
C {devices/lab_pin.sym} 70620 -14330 0 0 {name=p70303 lab=_80245_/X }
C {devices/lab_pin.sym} 70780 -14370 0 1 {name=p70304 lab=_80246_/X }
C {sky130_stdcells/a21o_4.sym} 70700 -14370 0 0 {name=X_80246_ }
C {devices/lab_pin.sym} 70620 -14250 0 0 {name=p70305 lab=_85679_/Q }
C {devices/lab_pin.sym} 70620 -14210 0 0 {name=p70306 lab=_53172_/X }
C {devices/lab_pin.sym} 70620 -14170 0 0 {name=p70307 lab=_53193_/Y }
C {devices/lab_pin.sym} 70780 -14210 0 1 {name=p70308 lab=_53194_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -14210 0 0 {name=X_53194_ }
C {devices/lab_pin.sym} 70660 -14070 0 0 {name=p70309 lab=_86499_/CLK }
C {devices/lab_pin.sym} 70740 -14070 0 1 {name=p70310 lab=_86470_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 70700 -14070 0 0 {name=Xclkbuf_opt_24_CLK }
C {devices/lab_pin.sym} 70640 -13960 0 0 {name=p70311 lab=_59810_/A }
C {devices/lab_pin.sym} 70640 -13920 0 0 {name=p70312 lab=_59743_/B }
C {devices/lab_pin.sym} 70760 -13940 0 1 {name=p70313 lab=_59810_/Y }
C {sky130_stdcells/nor2_4.sym} 70700 -13940 0 0 {name=X_59810_ }
C {devices/lab_pin.sym} 70660 -13810 0 0 {name=p70314 lab=_52203_/A }
C {devices/lab_pin.sym} 70740 -13810 0 1 {name=p70315 lab=_52145_/X }
C {sky130_stdcells/buf_2.sym} 70700 -13810 0 0 {name=X_52145_ }
C {devices/lab_pin.sym} 70610 -13690 0 0 {name=p70316 lab=_88097_/CLK }
C {devices/lab_pin.sym} 70610 -13670 0 0 {name=p70317 lab=_87842_/D }
C {devices/lab_pin.sym} 70790 -13690 0 1 {name=p70318 lab=_68801_/A }
C {sky130_stdcells/dfxtp_4.sym} 70700 -13680 0 0 {name=X_87842_ }
C {devices/lab_pin.sym} 70640 -13560 0 0 {name=p70319 lab=_80173_/Y }
C {devices/lab_pin.sym} 70640 -13520 0 0 {name=p70320 lab=_80176_/Y }
C {devices/lab_pin.sym} 70760 -13540 0 1 {name=p70321 lab=_80198_/A }
C {sky130_stdcells/xor2_4.sym} 70700 -13540 0 0 {name=X_80177_ }
C {devices/lab_pin.sym} 70660 -13410 0 0 {name=p70322 lab=_69988_/A }
C {devices/lab_pin.sym} 70740 -13410 0 1 {name=p70323 lab=_69988_/X }
C {sky130_stdcells/buf_2.sym} 70700 -13410 0 0 {name=X_69988_ }
C {devices/lab_pin.sym} 70640 -13310 0 0 {name=p70324 lab=_59741_/A }
C {devices/lab_pin.sym} 70640 -13270 0 0 {name=p70325 lab=_62669_/D }
C {devices/lab_pin.sym} 70640 -13230 0 0 {name=p70326 lab=_59741_/C }
C {devices/lab_pin.sym} 70760 -13270 0 1 {name=p70327 lab=_59742_/A }
C {sky130_stdcells/and3_4.sym} 70700 -13270 0 0 {name=X_59741_ }
C {devices/lab_pin.sym} 70660 -13130 0 0 {name=p70328 lab=_52185_/A }
C {devices/lab_pin.sym} 70740 -13130 0 1 {name=p70329 lab=_52121_/A }
C {sky130_stdcells/buf_2.sym} 70700 -13130 0 0 {name=X_52076_ }
C {devices/lab_pin.sym} 70660 -13010 0 0 {name=p70330 lab=_56953_/A }
C {devices/lab_pin.sym} 70740 -13010 0 1 {name=p70331 lab=_56953_/X }
C {sky130_stdcells/buf_2.sym} 70700 -13010 0 0 {name=X_56953_ }
C {devices/lab_pin.sym} 70620 -12920 0 0 {name=p70332 lab=_44727_/A }
C {devices/lab_pin.sym} 70620 -12880 0 0 {name=p70333 lab=_68818_/X }
C {devices/lab_pin.sym} 70620 -12840 0 0 {name=p70334 lab=_68819_/X }
C {devices/lab_pin.sym} 70620 -12800 0 0 {name=p70335 lab=_68938_/X }
C {devices/lab_pin.sym} 70780 -12860 0 1 {name=p70336 lab=_68940_/B }
C {sky130_stdcells/a211o_4.sym} 70700 -12860 0 0 {name=X_68939_ }
C {devices/lab_pin.sym} 70610 -12710 0 0 {name=p70337 lab=_87767_/CLK }
C {devices/lab_pin.sym} 70610 -12690 0 0 {name=p70338 lab=_87773_/D }
C {devices/lab_pin.sym} 70790 -12710 0 1 {name=p70339 lab=_87773_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -12700 0 0 {name=X_87773_ }
C {devices/lab_pin.sym} 70610 -12570 0 0 {name=p70340 lab=_85915_/CLK }
C {devices/lab_pin.sym} 70610 -12550 0 0 {name=p70341 lab=_84985_/D }
C {devices/lab_pin.sym} 70790 -12570 0 1 {name=p70342 lab=_84985_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -12560 0 0 {name=X_84985_ }
C {devices/lab_pin.sym} 70620 -12450 0 0 {name=p70343 lab=_86087_/Q }
C {devices/lab_pin.sym} 70620 -12410 0 0 {name=p70344 lab=_51020_/X }
C {devices/lab_pin.sym} 70620 -12370 0 0 {name=p70345 lab=_51026_/Y }
C {devices/lab_pin.sym} 70780 -12410 0 1 {name=p70346 lab=_51027_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -12410 0 0 {name=X_51027_ }
C {devices/lab_pin.sym} 70620 -12300 0 0 {name=p70347 lab=_85273_/Q }
C {devices/lab_pin.sym} 70620 -12260 0 0 {name=p70348 lab=_44106_/C }
C {devices/lab_pin.sym} 70620 -12220 0 0 {name=p70349 lab=_44051_/A }
C {devices/lab_pin.sym} 70620 -12180 0 0 {name=p70350 lab=_55903_/X }
C {devices/lab_pin.sym} 70780 -12240 0 1 {name=p70351 lab=_55904_/X }
C {sky130_stdcells/a211o_4.sym} 70700 -12240 0 0 {name=X_55904_ }
C {devices/lab_pin.sym} 70610 -12090 0 0 {name=p70352 lab=_86404_/CLK }
C {devices/lab_pin.sym} 70610 -12070 0 0 {name=p70353 lab=_46584_/Y }
C {devices/lab_pin.sym} 70790 -12090 0 1 {name=p70354 lab=_86724_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -12080 0 0 {name=X_86724_ }
C {devices/lab_pin.sym} 70620 -11970 0 0 {name=p70355 lab=_55663_/Y }
C {devices/lab_pin.sym} 70620 -11930 0 0 {name=p70356 lab=_71939_/X }
C {devices/lab_pin.sym} 70620 -11890 0 0 {name=p70357 lab=_71949_/Y }
C {devices/lab_pin.sym} 70780 -11930 0 1 {name=p70358 lab=_71950_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -11930 0 0 {name=X_71950_ }
C {devices/lab_pin.sym} 70660 -11790 0 0 {name=p70359 lab=_57701_/A }
C {devices/lab_pin.sym} 70740 -11790 0 1 {name=p70360 lab=_59770_/A }
C {sky130_stdcells/buf_2.sym} 70700 -11790 0 0 {name=X_59672_ }
C {devices/lab_pin.sym} 70610 -11670 0 0 {name=p70361 lab=_81346_/CLK }
C {devices/lab_pin.sym} 70610 -11650 0 0 {name=p70362 lab=_83936_/D }
C {devices/lab_pin.sym} 70790 -11670 0 1 {name=p70363 lab=_81400_/D }
C {sky130_stdcells/dfxtp_4.sym} 70700 -11660 0 0 {name=X_83936_ }
C {devices/lab_pin.sym} 70640 -11550 0 0 {name=p70364 lab=_56691_/A }
C {devices/lab_pin.sym} 70640 -11510 0 0 {name=p70365 lab=_56884_/B }
C {devices/lab_pin.sym} 70640 -11470 0 0 {name=p70366 lab=_56884_/C }
C {devices/lab_pin.sym} 70760 -11510 0 1 {name=p70367 lab=_56884_/Y }
C {sky130_stdcells/nand3_4.sym} 70700 -11510 0 0 {name=X_56884_ }
C {devices/lab_pin.sym} 70640 -11400 0 0 {name=p70368 lab=_70873_/A }
C {devices/lab_pin.sym} 70640 -11360 0 0 {name=p70369 lab=_70903_/B }
C {devices/lab_pin.sym} 70640 -11320 0 0 {name=p70370 lab=_70899_/C }
C {devices/lab_pin.sym} 70640 -11280 0 0 {name=p70371 lab=_70899_/D }
C {devices/lab_pin.sym} 70760 -11340 0 1 {name=p70372 lab=_70901_/Y }
C {sky130_stdcells/nand4_4.sym} 70700 -11340 0 0 {name=X_70901_ }
C {devices/lab_pin.sym} 70660 -11190 0 0 {name=p70373 lab=_58623_/A }
C {devices/lab_pin.sym} 70740 -11190 0 1 {name=p70374 lab=_58623_/Y }
C {sky130_stdcells/inv_2.sym} 70700 -11190 0 0 {name=X_58623_ }
C {devices/lab_pin.sym} 70620 -11090 0 0 {name=p70375 lab=_55832_/X }
C {devices/lab_pin.sym} 70620 -11050 0 0 {name=p70376 lab=_55834_/X }
C {devices/lab_pin.sym} 70620 -11010 0 0 {name=p70377 lab=_44113_/X }
C {devices/lab_pin.sym} 70780 -11050 0 1 {name=p70378 lab=_56088_/A }
C {sky130_stdcells/a21o_4.sym} 70700 -11050 0 0 {name=X_55835_ }
C {devices/lab_pin.sym} 70610 -10910 0 0 {name=p70379 lab=_86655_/CLK }
C {devices/lab_pin.sym} 70610 -10890 0 0 {name=p70380 lab=_86655_/D }
C {devices/lab_pin.sym} 70790 -10910 0 1 {name=p70381 lab=_57734_/A }
C {sky130_stdcells/dfxtp_4.sym} 70700 -10900 0 0 {name=X_86655_ }
C {devices/lab_pin.sym} 70640 -10800 0 0 {name=p70382 lab=_70552_/Y }
C {devices/lab_pin.sym} 70640 -10760 0 0 {name=p70383 lab=_71883_/B }
C {devices/lab_pin.sym} 70640 -10720 0 0 {name=p70384 lab=_71873_/X }
C {devices/lab_pin.sym} 70640 -10680 0 0 {name=p70385 lab=_71883_/D }
C {devices/lab_pin.sym} 70760 -10740 0 1 {name=p70386 lab=_71881_/Y }
C {sky130_stdcells/nor4_4.sym} 70700 -10740 0 0 {name=X_71881_ }
C {devices/lab_pin.sym} 70610 -10590 0 0 {name=p70387 lab=_82541_/CLK }
C {devices/lab_pin.sym} 70610 -10570 0 0 {name=p70388 lab=_70036_/X }
C {devices/lab_pin.sym} 70790 -10590 0 1 {name=p70389 lab=_82547_/D }
C {sky130_stdcells/dfxtp_4.sym} 70700 -10580 0 0 {name=X_83867_ }
C {devices/lab_pin.sym} 70660 -10450 0 0 {name=p70390 lab=_42799_/Y }
C {devices/lab_pin.sym} 70740 -10450 0 1 {name=p70391 lab=_87712_/D }
C {sky130_stdcells/inv_2.sym} 70700 -10450 0 0 {name=X_42800_ }
C {devices/lab_pin.sym} 70610 -10330 0 0 {name=p70392 lab=_86534_/CLK }
C {devices/lab_pin.sym} 70610 -10310 0 0 {name=p70393 lab=_85606_/D }
C {devices/lab_pin.sym} 70790 -10330 0 1 {name=p70394 lab=_85606_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -10320 0 0 {name=X_85606_ }
C {devices/lab_pin.sym} 70620 -10210 0 0 {name=p70395 lab=_73601_/X }
C {devices/lab_pin.sym} 70620 -10170 0 0 {name=p70396 lab=_73604_/Y }
C {devices/lab_pin.sym} 70620 -10130 0 0 {name=p70397 lab=_73619_/X }
C {devices/lab_pin.sym} 70780 -10170 0 1 {name=p70398 lab=_73620_/X }
C {sky130_stdcells/a21o_4.sym} 70700 -10170 0 0 {name=X_73620_ }
C {devices/lab_pin.sym} 70660 -10030 0 0 {name=p70399 lab=_70832_/A }
C {devices/lab_pin.sym} 70740 -10030 0 1 {name=p70400 lab=_71066_/C }
C {sky130_stdcells/buf_2.sym} 70700 -10030 0 0 {name=X_70832_ }
C {devices/lab_pin.sym} 70640 -9920 0 0 {name=p70401 lab=_58554_/A }
C {devices/lab_pin.sym} 70640 -9880 0 0 {name=p70402 lab=_58557_/B }
C {devices/lab_pin.sym} 70760 -9900 0 1 {name=p70403 lab=_58554_/Y }
C {sky130_stdcells/nand2_4.sym} 70700 -9900 0 0 {name=X_58554_ }
C {devices/lab_pin.sym} 70610 -9770 0 0 {name=p70404 lab=_82828_/CLK }
C {devices/lab_pin.sym} 70610 -9750 0 0 {name=p70405 lab=_82818_/D }
C {devices/lab_pin.sym} 70790 -9770 0 1 {name=p70406 lab=_82818_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -9760 0 0 {name=X_82818_ }
C {devices/lab_pin.sym} 70660 -9630 0 0 {name=p70407 lab=_43779_/Y }
C {devices/lab_pin.sym} 70740 -9630 0 1 {name=p70408 lab=_43780_/Y }
C {sky130_stdcells/inv_2.sym} 70700 -9630 0 0 {name=X_43780_ }
C {devices/lab_pin.sym} 70640 -9520 0 0 {name=p70409 lab=_55741_/A }
C {devices/lab_pin.sym} 70640 -9480 0 0 {name=p70410 lab=_85161_/Q }
C {devices/lab_pin.sym} 70760 -9500 0 1 {name=p70411 lab=_55766_/X }
C {sky130_stdcells/and2_4.sym} 70700 -9500 0 0 {name=X_55766_ }
C {devices/lab_pin.sym} 70610 -9370 0 0 {name=p70412 lab=_86554_/CLK }
C {devices/lab_pin.sym} 70610 -9350 0 0 {name=p70413 lab=_47921_/Y }
C {devices/lab_pin.sym} 70790 -9370 0 1 {name=p70414 lab=_66008_/B }
C {sky130_stdcells/dfxtp_4.sym} 70700 -9360 0 0 {name=X_86586_ }
C {devices/lab_pin.sym} 70640 -9240 0 0 {name=p70415 lab=_82294_/Q }
C {devices/lab_pin.sym} 70640 -9200 0 0 {name=p70416 lab=_40970_/B }
C {devices/lab_pin.sym} 70760 -9220 0 1 {name=p70417 lab=_40992_/X }
C {sky130_stdcells/or2_4.sym} 70700 -9220 0 0 {name=X_40992_ }
C {devices/lab_pin.sym} 70620 -9110 0 0 {name=p70418 lab=_52974_/Y }
C {devices/lab_pin.sym} 70620 -9070 0 0 {name=p70419 lab=_52975_/X }
C {devices/lab_pin.sym} 70620 -9030 0 0 {name=p70420 lab=_52977_/X }
C {devices/lab_pin.sym} 70780 -9070 0 1 {name=p70421 lab=_85720_/D }
C {sky130_stdcells/a21oi_4.sym} 70700 -9070 0 0 {name=X_52978_ }
C {devices/lab_pin.sym} 70610 -8930 0 0 {name=p70422 lab=_83819_/CLK }
C {devices/lab_pin.sym} 70610 -8910 0 0 {name=p70423 lab=_83798_/D }
C {devices/lab_pin.sym} 70790 -8930 0 1 {name=p70424 lab=_74782_/B }
C {sky130_stdcells/dfxtp_4.sym} 70700 -8920 0 0 {name=X_83798_ }
C {devices/lab_pin.sym} 70660 -8790 0 0 {name=p70425 lab=_47363_/A }
C {devices/lab_pin.sym} 70740 -8790 0 1 {name=p70426 lab=_71978_/A }
C {sky130_stdcells/buf_2.sym} 70700 -8790 0 0 {name=X_57505_ }
C {devices/lab_pin.sym} 70620 -8700 0 0 {name=p70427 lab=_41203_/X }
C {devices/lab_pin.sym} 70620 -8660 0 0 {name=p70428 lab=_42717_/X }
C {devices/lab_pin.sym} 70620 -8620 0 0 {name=p70429 lab=_68790_/B }
C {devices/lab_pin.sym} 70620 -8580 0 0 {name=p70430 lab=_42718_/X }
C {devices/lab_pin.sym} 70780 -8640 0 1 {name=p70431 lab=_87746_/D }
C {sky130_stdcells/a2bb2o_4.sym} 70700 -8640 0 0 {name=X_42731_ }
C {devices/lab_pin.sym} 70610 -8490 0 0 {name=p70432 lab=_88060_/CLK }
C {devices/lab_pin.sym} 70610 -8470 0 0 {name=p70433 lab=_88325_/D }
C {devices/lab_pin.sym} 70790 -8490 0 1 {name=p70434 lab=_69756_/B }
C {sky130_stdcells/dfxtp_4.sym} 70700 -8480 0 0 {name=X_88325_ }
C {devices/lab_pin.sym} 70620 -8370 0 0 {name=p70435 lab=_54715_/Y }
C {devices/lab_pin.sym} 70620 -8330 0 0 {name=p70436 lab=_54694_/X }
C {devices/lab_pin.sym} 70620 -8290 0 0 {name=p70437 lab=_54716_/X }
C {devices/lab_pin.sym} 70780 -8330 0 1 {name=p70438 lab=_54717_/Y }
C {sky130_stdcells/a21oi_4.sym} 70700 -8330 0 0 {name=X_54717_ }
C {devices/lab_pin.sym} 70660 -8190 0 0 {name=p70439 lab=_72889_/X }
C {devices/lab_pin.sym} 70740 -8190 0 1 {name=p70440 lab=_73551_/X }
C {sky130_stdcells/buf_2.sym} 70700 -8190 0 0 {name=X_73551_ }
C {devices/lab_pin.sym} 70610 -8070 0 0 {name=p70441 lab=_86145_/CLK }
C {devices/lab_pin.sym} 70610 -8050 0 0 {name=p70442 lab=_85537_/D }
C {devices/lab_pin.sym} 70790 -8070 0 1 {name=p70443 lab=_85537_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -8060 0 0 {name=X_85537_ }
C {devices/lab_pin.sym} 70660 -7930 0 0 {name=p70444 lab=_51928_/X }
C {devices/lab_pin.sym} 70740 -7930 0 1 {name=p70445 lab=_51929_/X }
C {sky130_stdcells/buf_2.sym} 70700 -7930 0 0 {name=X_51929_ }
C {devices/lab_pin.sym} 70660 -7810 0 0 {name=p70446 lab=_70763_/A }
C {devices/lab_pin.sym} 70740 -7810 0 1 {name=p70447 lab=_70860_/A }
C {sky130_stdcells/buf_2.sym} 70700 -7810 0 0 {name=X_70763_ }
C {devices/lab_pin.sym} 70610 -7690 0 0 {name=p70448 lab=_82748_/CLK }
C {devices/lab_pin.sym} 70610 -7670 0 0 {name=p70449 lab=_84133_/Q }
C {devices/lab_pin.sym} 70790 -7690 0 1 {name=p70450 lab=_82749_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -7680 0 0 {name=X_82749_ }
C {devices/lab_pin.sym} 70660 -7550 0 0 {name=p70451 lab=_83413_/Q }
C {devices/lab_pin.sym} 70740 -7550 0 1 {name=p70452 lab=_58485_/Y }
C {sky130_stdcells/inv_2.sym} 70700 -7550 0 0 {name=X_58485_ }
C {devices/lab_pin.sym} 70620 -7450 0 0 {name=p70453 lab=_55693_/X }
C {devices/lab_pin.sym} 70620 -7410 0 0 {name=p70454 lab=_55696_/X }
C {devices/lab_pin.sym} 70620 -7370 0 0 {name=p70455 lab=_55615_/X }
C {devices/lab_pin.sym} 70780 -7410 0 1 {name=p70456 lab=_55700_/A }
C {sky130_stdcells/a21o_4.sym} 70700 -7410 0 0 {name=X_55697_ }
C {devices/lab_pin.sym} 70660 -7270 0 0 {name=p70457 lab=_72502_/A }
C {devices/lab_pin.sym} 70740 -7270 0 1 {name=p70458 lab=_72516_/C }
C {sky130_stdcells/buf_2.sym} 70700 -7270 0 0 {name=X_72502_ }
C {devices/lab_pin.sym} 70620 -7170 0 0 {name=p70459 lab=_45448_/Y }
C {devices/lab_pin.sym} 70620 -7130 0 0 {name=p70460 lab=_45449_/Y }
C {devices/lab_pin.sym} 70620 -7090 0 0 {name=p70461 lab=_44901_/X }
C {devices/lab_pin.sym} 70780 -7130 0 1 {name=p70462 lab=_45450_/X }
C {sky130_stdcells/o21a_4.sym} 70700 -7130 0 0 {name=X_45450_ }
C {devices/lab_pin.sym} 70620 -7010 0 0 {name=p70463 lab=_57275_/X }
C {devices/lab_pin.sym} 70620 -6970 0 0 {name=p70464 lab=_57170_/A }
C {devices/lab_pin.sym} 70620 -6930 0 0 {name=p70465 lab=_57435_/X }
C {devices/lab_pin.sym} 70780 -6970 0 1 {name=p70466 lab=_57436_/X }
C {sky130_stdcells/o21a_4.sym} 70700 -6970 0 0 {name=X_57436_ }
C {devices/lab_pin.sym} 70620 -6850 0 0 {name=p70467 lab=_76237_/Y }
C {devices/lab_pin.sym} 70620 -6810 0 0 {name=p70468 lab=_76253_/Y }
C {devices/lab_pin.sym} 70620 -6770 0 0 {name=p70469 lab=_76255_/A }
C {devices/lab_pin.sym} 70780 -6810 0 1 {name=p70470 lab=_76270_/X }
C {sky130_stdcells/o21a_4.sym} 70700 -6810 0 0 {name=X_76270_ }
C {devices/lab_pin.sym} 70610 -6670 0 0 {name=p70471 lab=_87757_/CLK }
C {devices/lab_pin.sym} 70610 -6650 0 0 {name=p70472 lab=_41216_/Y }
C {devices/lab_pin.sym} 70790 -6670 0 1 {name=p70473 lab=_88256_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -6660 0 0 {name=X_88256_ }
C {devices/lab_pin.sym} 70660 -6530 0 0 {name=p70474 lab=_42661_/Y }
C {devices/lab_pin.sym} 70740 -6530 0 1 {name=p70475 lab=_42662_/Y }
C {sky130_stdcells/inv_2.sym} 70700 -6530 0 0 {name=X_42662_ }
C {devices/lab_pin.sym} 70660 -6410 0 0 {name=p70476 lab=_54729_/A }
C {devices/lab_pin.sym} 70740 -6410 0 1 {name=p70477 lab=_54648_/X }
C {sky130_stdcells/buf_2.sym} 70700 -6410 0 0 {name=X_54648_ }
C {devices/lab_pin.sym} 70620 -6310 0 0 {name=p70478 lab=_73480_/X }
C {devices/lab_pin.sym} 70620 -6270 0 0 {name=p70479 lab=_73481_/Y }
C {devices/lab_pin.sym} 70620 -6230 0 0 {name=p70480 lab=_73367_/X }
C {devices/lab_pin.sym} 70780 -6270 0 1 {name=p70481 lab=_73482_/Y }
C {sky130_stdcells/a21oi_4.sym} 70700 -6270 0 0 {name=X_73482_ }
C {devices/lab_pin.sym} 70610 -6130 0 0 {name=p70482 lab=_82206_/CLK }
C {devices/lab_pin.sym} 70610 -6110 0 0 {name=p70483 lab=_54299_/Y }
C {devices/lab_pin.sym} 70790 -6130 0 1 {name=p70484 lab=_85468_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -6120 0 0 {name=X_85468_ }
C {devices/lab_pin.sym} 70640 -6020 0 0 {name=p70485 lab=_70694_/A }
C {devices/lab_pin.sym} 70640 -5980 0 0 {name=p70486 lab=_70412_/X }
C {devices/lab_pin.sym} 70640 -5940 0 0 {name=p70487 lab=_70933_/B }
C {devices/lab_pin.sym} 70640 -5900 0 0 {name=p70488 lab=_70627_/A }
C {devices/lab_pin.sym} 70760 -5960 0 1 {name=p70489 lab=_70695_/A }
C {sky130_stdcells/nand4_4.sym} 70700 -5960 0 0 {name=X_70694_ }
C {devices/lab_pin.sym} 70620 -5840 0 0 {name=p70490 lab=_41503_/X }
C {devices/lab_pin.sym} 70620 -5800 0 0 {name=p70491 lab=_44394_/X }
C {devices/lab_pin.sym} 70620 -5760 0 0 {name=p70492 lab=_87127_/Q }
C {devices/lab_pin.sym} 70620 -5720 0 0 {name=p70493 lab=_44395_/X }
C {devices/lab_pin.sym} 70780 -5780 0 1 {name=p70494 lab=_87127_/D }
C {sky130_stdcells/a2bb2o_4.sym} 70700 -5780 0 0 {name=X_44401_ }
C {devices/lab_pin.sym} 70640 -5640 0 0 {name=p70495 lab=_80780_/Q }
C {devices/lab_pin.sym} 70640 -5600 0 0 {name=p70496 lab=_81036_/D }
C {devices/lab_pin.sym} 70760 -5620 0 1 {name=p70497 lab=_80748_/D }
C {sky130_stdcells/xor2_4.sym} 70700 -5620 0 0 {name=X_75221_ }
C {devices/lab_pin.sym} 70660 -5490 0 0 {name=p70498 lab=_41825_/A }
C {devices/lab_pin.sym} 70740 -5490 0 1 {name=p70499 lab=_41613_/X }
C {sky130_stdcells/buf_2.sym} 70700 -5490 0 0 {name=X_41613_ }
C {devices/lab_pin.sym} 70610 -5370 0 0 {name=p70500 lab=_87149_/CLK }
C {devices/lab_pin.sym} 70610 -5350 0 0 {name=p70501 lab=_87207_/D }
C {devices/lab_pin.sym} 70790 -5370 0 1 {name=p70502 lab=_67616_/B }
C {sky130_stdcells/dfxtp_4.sym} 70700 -5360 0 0 {name=X_87207_ }
C {devices/lab_pin.sym} 70620 -5250 0 0 {name=p70503 lab=_72352_/X }
C {devices/lab_pin.sym} 70620 -5210 0 0 {name=p70504 lab=_85959_/Q }
C {devices/lab_pin.sym} 70620 -5170 0 0 {name=p70505 lab=_72432_/X }
C {devices/lab_pin.sym} 70780 -5210 0 1 {name=p70506 lab=_72433_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -5210 0 0 {name=X_72433_ }
C {devices/lab_pin.sym} 70610 -5070 0 0 {name=p70507 lab=_84538_/CLK }
C {devices/lab_pin.sym} 70610 -5050 0 0 {name=p70508 lab=_84419_/D }
C {devices/lab_pin.sym} 70790 -5070 0 1 {name=p70509 lab=_76995_/B }
C {sky130_stdcells/dfxtp_4.sym} 70700 -5060 0 0 {name=X_84419_ }
C {devices/lab_pin.sym} 70640 -4940 0 0 {name=p70510 lab=_45381_/A }
C {devices/lab_pin.sym} 70640 -4900 0 0 {name=p70511 lab=_45381_/B }
C {devices/lab_pin.sym} 70760 -4920 0 1 {name=p70512 lab=_45381_/Y }
C {sky130_stdcells/nand2_4.sym} 70700 -4920 0 0 {name=X_45381_ }
C {devices/lab_pin.sym} 70620 -4810 0 0 {name=p70513 lab=_57244_/X }
C {devices/lab_pin.sym} 70620 -4770 0 0 {name=p70514 lab=_56917_/A }
C {devices/lab_pin.sym} 70620 -4730 0 0 {name=p70515 lab=_57366_/Y }
C {devices/lab_pin.sym} 70780 -4770 0 1 {name=p70516 lab=_57368_/A }
C {sky130_stdcells/o21ai_4.sym} 70700 -4770 0 0 {name=X_57367_ }
C {devices/lab_pin.sym} 70610 -4630 0 0 {name=p70517 lab=_87110_/CLK }
C {devices/lab_pin.sym} 70610 -4610 0 0 {name=p70518 lab=_88187_/D }
C {devices/lab_pin.sym} 70790 -4630 0 1 {name=p70519 lab=_67161_/B }
C {sky130_stdcells/dfxtp_4.sym} 70700 -4620 0 0 {name=X_88187_ }
C {devices/lab_pin.sym} 70620 -4510 0 0 {name=p70520 lab=_85416_/Q }
C {devices/lab_pin.sym} 70620 -4470 0 0 {name=p70521 lab=_54567_/X }
C {devices/lab_pin.sym} 70620 -4430 0 0 {name=p70522 lab=_54578_/Y }
C {devices/lab_pin.sym} 70780 -4470 0 1 {name=p70523 lab=_54579_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -4470 0 0 {name=X_54579_ }
C {devices/lab_pin.sym} 70620 -4370 0 0 {name=p70524 lab=_42590_/X }
C {devices/lab_pin.sym} 70620 -4330 0 0 {name=p70525 lab=_42592_/X }
C {devices/lab_pin.sym} 70620 -4290 0 0 {name=p70526 lab=_40861_/X }
C {devices/lab_pin.sym} 70620 -4250 0 0 {name=p70527 lab=_69804_/A }
C {devices/lab_pin.sym} 70620 -4210 0 0 {name=p70528 lab=_42580_/X }
C {devices/lab_pin.sym} 70780 -4290 0 1 {name=p70529 lab=_42593_/Y }
C {sky130_stdcells/o32ai_4.sym} 70700 -4290 0 0 {name=X_42593_ }
C {devices/lab_pin.sym} 70610 -4130 0 0 {name=p70530 lab=_85492_/CLK }
C {devices/lab_pin.sym} 70610 -4110 0 0 {name=p70531 lab=_85399_/D }
C {devices/lab_pin.sym} 70790 -4130 0 1 {name=p70532 lab=_85399_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -4120 0 0 {name=X_85399_ }
C {devices/lab_pin.sym} 70660 -3990 0 0 {name=p70533 lab=_54559_/D }
C {devices/lab_pin.sym} 70740 -3990 0 1 {name=p70534 lab=_52867_/D }
C {sky130_stdcells/buf_2.sym} 70700 -3990 0 0 {name=X_47120_ }
C {devices/lab_pin.sym} 70660 -3870 0 0 {name=p70535 lab=_58847_/A }
C {devices/lab_pin.sym} 70740 -3870 0 1 {name=p70536 lab=_59106_/X }
C {sky130_stdcells/buf_2.sym} 70700 -3870 0 0 {name=X_59106_ }
C {devices/lab_pin.sym} 70660 -3750 0 0 {name=p70537 lab=_44736_/A }
C {devices/lab_pin.sym} 70740 -3750 0 1 {name=p70538 lab=_44332_/X }
C {sky130_stdcells/buf_2.sym} 70700 -3750 0 0 {name=X_44332_ }
C {devices/lab_pin.sym} 70620 -3650 0 0 {name=p70539 lab=_56064_/X }
C {devices/lab_pin.sym} 70620 -3610 0 0 {name=p70540 lab=_56305_/X }
C {devices/lab_pin.sym} 70620 -3570 0 0 {name=p70541 lab=_56317_/Y }
C {devices/lab_pin.sym} 70780 -3610 0 1 {name=p70542 lab=_85238_/D }
C {sky130_stdcells/o21ai_4.sym} 70700 -3610 0 0 {name=X_56318_ }
C {devices/lab_pin.sym} 70640 -3480 0 0 {name=p70543 lab=_80680_/Q }
C {devices/lab_pin.sym} 70640 -3440 0 0 {name=p70544 lab=_75151_/B }
C {devices/lab_pin.sym} 70760 -3460 0 1 {name=p70545 lab=_75153_/A }
C {sky130_stdcells/nand2_4.sym} 70700 -3460 0 0 {name=X_75152_ }
C {devices/lab_pin.sym} 70610 -3330 0 0 {name=p70546 lab=_87382_/CLK }
C {devices/lab_pin.sym} 70610 -3310 0 0 {name=p70547 lab=_87138_/D }
C {devices/lab_pin.sym} 70790 -3330 0 1 {name=p70548 lab=_87138_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -3320 0 0 {name=X_87138_ }
C {devices/lab_pin.sym} 70620 -3210 0 0 {name=p70549 lab=_41344_/X }
C {devices/lab_pin.sym} 70620 -3170 0 0 {name=p70550 lab=_81169_/Q }
C {devices/lab_pin.sym} 70620 -3130 0 0 {name=p70551 lab=_41543_/X }
C {devices/lab_pin.sym} 70780 -3170 0 1 {name=p70552 lab=_41544_/X }
C {sky130_stdcells/o21a_4.sym} 70700 -3170 0 0 {name=X_41544_ }
C {devices/lab_pin.sym} 70620 -3050 0 0 {name=p70553 lab=_72327_/X }
C {devices/lab_pin.sym} 70620 -3010 0 0 {name=p70554 lab=_85965_/Q }
C {devices/lab_pin.sym} 70620 -2970 0 0 {name=p70555 lab=_72363_/X }
C {devices/lab_pin.sym} 70780 -3010 0 1 {name=p70556 lab=_72364_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -3010 0 0 {name=X_72364_ }
C {devices/lab_pin.sym} 70640 -2890 0 0 {name=p70557 lab=_57049_/A }
C {devices/lab_pin.sym} 70640 -2850 0 0 {name=p70558 lab=_85038_/Q }
C {devices/lab_pin.sym} 70640 -2810 0 0 {name=p70559 lab=_57326_/C }
C {devices/lab_pin.sym} 70760 -2850 0 1 {name=p70560 lab=_57298_/Y }
C {sky130_stdcells/nor3_4.sym} 70700 -2850 0 0 {name=X_57298_ }
C {devices/lab_pin.sym} 70660 -2710 0 0 {name=p70561 lab=_72905_/A }
C {devices/lab_pin.sym} 70740 -2710 0 1 {name=p70562 lab=_74103_/X }
C {sky130_stdcells/buf_2.sym} 70700 -2710 0 0 {name=X_74103_ }
C {devices/lab_pin.sym} 70660 -2590 0 0 {name=p70563 lab=_46909_/X }
C {devices/lab_pin.sym} 70740 -2590 0 1 {name=p70564 lab=_47063_/A }
C {sky130_stdcells/buf_2.sym} 70700 -2590 0 0 {name=X_47051_ }
C {devices/lab_pin.sym} 70660 -2470 0 0 {name=p70565 lab=_59037_/A }
C {devices/lab_pin.sym} 70740 -2470 0 1 {name=p70566 lab=_59037_/X }
C {sky130_stdcells/buf_2.sym} 70700 -2470 0 0 {name=X_59037_ }
C {devices/lab_pin.sym} 70620 -2370 0 0 {name=p70567 lab=_52047_/B }
C {devices/lab_pin.sym} 70620 -2330 0 0 {name=p70568 lab=_71289_/Y }
C {devices/lab_pin.sym} 70620 -2290 0 0 {name=p70569 lab=_71314_/Y }
C {devices/lab_pin.sym} 70780 -2330 0 1 {name=p70570 lab=_71315_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -2330 0 0 {name=X_71315_ }
C {devices/lab_pin.sym} 70660 -2190 0 0 {name=p70571 lab=_64725_/A }
C {devices/lab_pin.sym} 70740 -2190 0 1 {name=p70572 lab=_44263_/X }
C {sky130_stdcells/buf_2.sym} 70700 -2190 0 0 {name=X_44263_ }
C {devices/lab_pin.sym} 70660 -2070 0 0 {name=p70573 lab=clkbuf_6_41_0_CLK/A }
C {devices/lab_pin.sym} 70740 -2070 0 1 {name=p70574 lab=clkbuf_7_81_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 70700 -2070 0 0 {name=Xclkbuf_6_40_0_CLK }
C {devices/lab_pin.sym} 70620 -1970 0 0 {name=p70575 lab=_56121_/X }
C {devices/lab_pin.sym} 70620 -1930 0 0 {name=p70576 lab=_56242_/X }
C {devices/lab_pin.sym} 70620 -1890 0 0 {name=p70577 lab=_56248_/Y }
C {devices/lab_pin.sym} 70780 -1930 0 1 {name=p70578 lab=_56249_/Y }
C {sky130_stdcells/o21ai_4.sym} 70700 -1930 0 0 {name=X_56249_ }
C {devices/lab_pin.sym} 70640 -1800 0 0 {name=p70579 lab=_80675_/Q }
C {devices/lab_pin.sym} 70640 -1760 0 0 {name=p70580 lab=_75082_/B }
C {devices/lab_pin.sym} 70760 -1780 0 1 {name=p70581 lab=_75102_/B }
C {sky130_stdcells/nand2_4.sym} 70700 -1780 0 0 {name=X_75083_ }
C {devices/lab_pin.sym} 70620 -1670 0 0 {name=p70582 lab=_79942_/A }
C {devices/lab_pin.sym} 70620 -1630 0 0 {name=p70583 lab=_79940_/Y }
C {devices/lab_pin.sym} 70620 -1590 0 0 {name=p70584 lab=_79959_/Y }
C {devices/lab_pin.sym} 70780 -1630 0 1 {name=p70585 lab=_79960_/Y }
C {sky130_stdcells/a21oi_4.sym} 70700 -1630 0 0 {name=X_79960_ }
C {devices/lab_pin.sym} 70620 -1530 0 0 {name=p70586 lab=_41399_/X }
C {devices/lab_pin.sym} 70620 -1490 0 0 {name=p70587 lab=_41400_/X }
C {devices/lab_pin.sym} 70620 -1450 0 0 {name=p70588 lab=_41473_/X }
C {devices/lab_pin.sym} 70620 -1410 0 0 {name=p70589 lab=_66656_/B }
C {devices/lab_pin.sym} 70620 -1370 0 0 {name=p70590 lab=_41474_/X }
C {devices/lab_pin.sym} 70780 -1450 0 1 {name=p70591 lab=_41476_/A }
C {sky130_stdcells/o32ai_4.sym} 70700 -1450 0 0 {name=X_41475_ }
C {devices/lab_pin.sym} 70610 -1290 0 0 {name=p70592 lab=_88337_/CLK }
C {devices/lab_pin.sym} 70610 -1270 0 0 {name=p70593 lab=_44521_/Y }
C {devices/lab_pin.sym} 70790 -1290 0 1 {name=p70594 lab=_87069_/Q }
C {sky130_stdcells/dfxtp_4.sym} 70700 -1280 0 0 {name=X_87069_ }
C {devices/lab_pin.sym} 70640 -1160 0 0 {name=p70595 lab=_72295_/A }
C {devices/lab_pin.sym} 70640 -1120 0 0 {name=p70596 lab=_72332_/B }
C {devices/lab_pin.sym} 70760 -1140 0 1 {name=p70597 lab=_72295_/Y }
C {sky130_stdcells/nor2_4.sym} 70700 -1140 0 0 {name=X_72295_ }
C {devices/lab_pin.sym} 70620 -1050 0 0 {name=p70598 lab=_45994_/X }
C {devices/lab_pin.sym} 70620 -1010 0 0 {name=p70599 lab=_46001_/X }
C {devices/lab_pin.sym} 70620 -970 0 0 {name=p70600 lab=_40479_/X }
C {devices/lab_pin.sym} 70620 -930 0 0 {name=p70601 lab=_86820_/Q }
C {devices/lab_pin.sym} 70620 -890 0 0 {name=p70602 lab=_45995_/X }
C {devices/lab_pin.sym} 70780 -970 0 1 {name=p70603 lab=_46002_/Y }
C {sky130_stdcells/o32ai_4.sym} 70700 -970 0 0 {name=X_46002_ }
C {devices/lab_pin.sym} 70660 -810 0 0 {name=p70604 lab=_43214_/A }
C {devices/lab_pin.sym} 70740 -810 0 1 {name=p70605 lab=_87535_/D }
C {sky130_stdcells/inv_2.sym} 70700 -810 0 0 {name=X_43214_ }
C {devices/lab_pin.sym} 70620 -720 0 0 {name=p70606 lab=_68861_/B }
C {devices/lab_pin.sym} 70620 -680 0 0 {name=p70607 lab=_73872_/X }
C {devices/lab_pin.sym} 70620 -640 0 0 {name=p70608 lab=_73894_/X }
C {devices/lab_pin.sym} 70620 -600 0 0 {name=p70609 lab=_74033_/Y }
C {devices/lab_pin.sym} 70780 -660 0 1 {name=p70610 lab=_74034_/X }
C {sky130_stdcells/a211o_4.sym} 70700 -660 0 0 {name=X_74034_ }
C {devices/lab_pin.sym} 71560 -42160 0 0 {name=p70611 lab=_82814_/D }
C {devices/lab_pin.sym} 71560 -42120 0 0 {name=p70612 lab=_82558_/Q }
C {devices/lab_pin.sym} 71680 -42140 0 1 {name=p70613 lab=_78912_/B }
C {sky130_stdcells/xnor2_4.sym} 71620 -42140 0 0 {name=X_78911_ }
C {devices/lab_pin.sym} 71580 -42010 0 0 {name=p70614 lab=_40425_/X }
C {devices/lab_pin.sym} 71660 -42010 0 1 {name=p70615 lab=_40426_/X }
C {sky130_stdcells/buf_2.sym} 71620 -42010 0 0 {name=X_40426_ }
C {devices/lab_pin.sym} 71560 -41910 0 0 {name=p70616 lab=_71252_/A }
C {devices/lab_pin.sym} 71560 -41870 0 0 {name=p70617 lab=_71246_/B }
C {devices/lab_pin.sym} 71560 -41830 0 0 {name=p70618 lab=_71248_/C }
C {devices/lab_pin.sym} 71680 -41870 0 1 {name=p70619 lab=_71246_/Y }
C {sky130_stdcells/nand3_4.sym} 71620 -41870 0 0 {name=X_71246_ }
C {devices/lab_pin.sym} 71580 -41730 0 0 {name=p70620 lab=_73948_/A }
C {devices/lab_pin.sym} 71660 -41730 0 1 {name=p70621 lab=_44194_/X }
C {sky130_stdcells/buf_2.sym} 71620 -41730 0 0 {name=X_44194_ }
C {devices/lab_pin.sym} 71560 -41630 0 0 {name=p70622 lab=_79882_/A }
C {devices/lab_pin.sym} 71560 -41590 0 0 {name=p70623 lab=_79881_/X }
C {devices/lab_pin.sym} 71560 -41550 0 0 {name=p70624 lab=_79889_/A }
C {devices/lab_pin.sym} 71680 -41590 0 1 {name=p70625 lab=_79891_/Y }
C {sky130_stdcells/nand3_4.sym} 71620 -41590 0 0 {name=X_79891_ }
C {devices/lab_pin.sym} 71580 -41450 0 0 {name=p70626 lab=_84518_/CLK }
C {devices/lab_pin.sym} 71660 -41450 0 1 {name=p70627 lab=_84640_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 71620 -41450 0 0 {name=Xclkbuf_opt_15_CLK }
C {devices/lab_pin.sym} 71580 -41330 0 0 {name=p70628 lab=_43145_/A }
C {devices/lab_pin.sym} 71660 -41330 0 1 {name=p70629 lab=_43145_/Y }
C {sky130_stdcells/inv_2.sym} 71620 -41330 0 0 {name=X_43145_ }
C {devices/lab_pin.sym} 71560 -41220 0 0 {name=p70630 lab=_78841_/B }
C {devices/lab_pin.sym} 71560 -41180 0 0 {name=p70631 lab=_78833_/Y }
C {devices/lab_pin.sym} 71680 -41200 0 1 {name=p70632 lab=_78842_/Y }
C {sky130_stdcells/nor2_4.sym} 71620 -41200 0 0 {name=X_78842_ }
C {devices/lab_pin.sym} 71580 -41070 0 0 {name=p70633 lab=_40344_/A }
C {devices/lab_pin.sym} 71660 -41070 0 1 {name=p70634 lab=_40435_/A }
C {sky130_stdcells/inv_2.sym} 71620 -41070 0 0 {name=X_40357_ }
C {devices/lab_pin.sym} 71580 -40950 0 0 {name=p70635 lab=_71145_/A }
C {devices/lab_pin.sym} 71660 -40950 0 1 {name=p70636 lab=_71185_/B }
C {sky130_stdcells/buf_2.sym} 71620 -40950 0 0 {name=X_71177_ }
C {devices/lab_pin.sym} 71580 -40830 0 0 {name=p70637 lab=clkbuf_9_282_0_CLK/X }
C {devices/lab_pin.sym} 71660 -40830 0 1 {name=p70638 lab=_84074_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 71620 -40830 0 0 {name=Xclkbuf_10_564_0_CLK }
C {devices/lab_pin.sym} 71580 -40710 0 0 {name=p70639 lab=clkbuf_6_55_0_CLK/A }
C {devices/lab_pin.sym} 71660 -40710 0 1 {name=p70640 lab=clkbuf_6_55_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 71620 -40710 0 0 {name=Xclkbuf_6_55_0_CLK }
C {devices/lab_pin.sym} 71560 -40620 0 0 {name=p70641 lab=_70128_/A }
C {devices/lab_pin.sym} 71560 -40580 0 0 {name=p70642 lab=_83122_/Q }
C {devices/lab_pin.sym} 71560 -40540 0 0 {name=p70643 lab=_70128_/C }
C {devices/lab_pin.sym} 71560 -40500 0 0 {name=p70644 lab=_83120_/Q }
C {devices/lab_pin.sym} 71680 -40560 0 1 {name=p70645 lab=_70131_/A }
C {sky130_stdcells/nor4_4.sym} 71620 -40560 0 0 {name=X_70128_ }
C {devices/lab_pin.sym} 71540 -40430 0 0 {name=p70646 lab=_73830_/B }
C {devices/lab_pin.sym} 71540 -40390 0 0 {name=p70647 lab=_47948_/X }
C {devices/lab_pin.sym} 71540 -40350 0 0 {name=p70648 lab=_47952_/Y }
C {devices/lab_pin.sym} 71700 -40390 0 1 {name=p70649 lab=_47953_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -40390 0 0 {name=X_47953_ }
C {devices/lab_pin.sym} 71540 -40290 0 0 {name=p70650 lab=_43072_/X }
C {devices/lab_pin.sym} 71540 -40250 0 0 {name=p70651 lab=_43075_/X }
C {devices/lab_pin.sym} 71540 -40210 0 0 {name=p70652 lab=_40691_/X }
C {devices/lab_pin.sym} 71540 -40170 0 0 {name=p70653 lab=_73989_/A }
C {devices/lab_pin.sym} 71540 -40130 0 0 {name=p70654 lab=_43061_/X }
C {devices/lab_pin.sym} 71700 -40210 0 1 {name=p70655 lab=_43076_/Y }
C {sky130_stdcells/o32ai_4.sym} 71620 -40210 0 0 {name=X_43076_ }
C {devices/lab_pin.sym} 71580 -40050 0 0 {name=p70656 lab=_59918_/Y }
C {devices/lab_pin.sym} 71660 -40050 0 1 {name=p70657 lab=_62463_/A }
C {sky130_stdcells/buf_2.sym} 71620 -40050 0 0 {name=X_59939_ }
C {devices/lab_pin.sym} 71540 -39950 0 0 {name=p70658 lab=_78737_/Y }
C {devices/lab_pin.sym} 71540 -39910 0 0 {name=p70659 lab=_78770_/D }
C {devices/lab_pin.sym} 71540 -39870 0 0 {name=p70660 lab=_78770_/B }
C {devices/lab_pin.sym} 71700 -39910 0 1 {name=p70661 lab=_78773_/X }
C {sky130_stdcells/a21bo_4.sym} 71620 -39910 0 0 {name=X_78773_ }
C {devices/lab_pin.sym} 71540 -39790 0 0 {name=p70662 lab=_75980_/Y }
C {devices/lab_pin.sym} 71540 -39750 0 0 {name=p70663 lab=_75981_/A }
C {devices/lab_pin.sym} 71540 -39710 0 0 {name=p70664 lab=_75984_/Y }
C {devices/lab_pin.sym} 71700 -39750 0 1 {name=p70665 lab=_75986_/B }
C {sky130_stdcells/a21boi_4.sym} 71620 -39750 0 0 {name=X_75985_ }
C {devices/lab_pin.sym} 71580 -39610 0 0 {name=p70666 lab=_82947_/Q }
C {devices/lab_pin.sym} 71660 -39610 0 1 {name=p70667 lab=_54435_/D }
C {sky130_stdcells/inv_2.sym} 71620 -39610 0 0 {name=X_46904_ }
C {devices/lab_pin.sym} 71580 -39490 0 0 {name=p70668 lab=_42027_/A }
C {devices/lab_pin.sym} 71660 -39490 0 1 {name=p70669 lab=_42027_/Y }
C {sky130_stdcells/inv_2.sym} 71620 -39490 0 0 {name=X_42027_ }
C {devices/lab_pin.sym} 71560 -39380 0 0 {name=p70670 lab=_77724_/A }
C {devices/lab_pin.sym} 71560 -39340 0 0 {name=p70671 lab=_77724_/B }
C {devices/lab_pin.sym} 71680 -39360 0 1 {name=p70672 lab=_81921_/D }
C {sky130_stdcells/nand2_4.sym} 71620 -39360 0 0 {name=X_77724_ }
C {devices/lab_pin.sym} 71540 -39270 0 0 {name=p70673 lab=_62945_/Y }
C {devices/lab_pin.sym} 71540 -39230 0 0 {name=p70674 lab=_62946_/X }
C {devices/lab_pin.sym} 71540 -39190 0 0 {name=p70675 lab=_62949_/Y }
C {devices/lab_pin.sym} 71540 -39150 0 0 {name=p70676 lab=_58352_/A }
C {devices/lab_pin.sym} 71540 -39110 0 0 {name=p70677 lab=_62650_/X }
C {devices/lab_pin.sym} 71700 -39190 0 1 {name=p70678 lab=_62950_/Y }
C {sky130_stdcells/o32ai_4.sym} 71620 -39190 0 0 {name=X_62950_ }
C {devices/lab_pin.sym} 71560 -39040 0 0 {name=p70679 lab=_81135_/D }
C {devices/lab_pin.sym} 71560 -39000 0 0 {name=p70680 lab=_74945_/B }
C {devices/lab_pin.sym} 71680 -39020 0 1 {name=p70681 lab=_74942_/B }
C {sky130_stdcells/xor2_4.sym} 71620 -39020 0 0 {name=X_74936_ }
C {devices/lab_pin.sym} 71540 -38910 0 0 {name=p70682 lab=_82541_/D }
C {devices/lab_pin.sym} 71540 -38870 0 0 {name=p70683 lab=_70048_/X }
C {devices/lab_pin.sym} 71540 -38830 0 0 {name=p70684 lab=_70058_/X }
C {devices/lab_pin.sym} 71700 -38870 0 1 {name=p70685 lab=_70059_/X }
C {sky130_stdcells/a21bo_4.sym} 71620 -38870 0 0 {name=X_70059_ }
C {devices/lab_pin.sym} 71560 -38740 0 0 {name=p70686 lab=_47943_/A }
C {devices/lab_pin.sym} 71560 -38700 0 0 {name=p70687 lab=_82941_/Q }
C {devices/lab_pin.sym} 71680 -38720 0 1 {name=p70688 lab=_47884_/X }
C {sky130_stdcells/or2_4.sym} 71620 -38720 0 0 {name=X_47884_ }
C {devices/lab_pin.sym} 71560 -38620 0 0 {name=p70689 lab=_61915_/A }
C {devices/lab_pin.sym} 71560 -38580 0 0 {name=p70690 lab=_61915_/B }
C {devices/lab_pin.sym} 71560 -38540 0 0 {name=p70691 lab=_63496_/B }
C {devices/lab_pin.sym} 71560 -38500 0 0 {name=p70692 lab=_61915_/D }
C {devices/lab_pin.sym} 71680 -38560 0 1 {name=p70693 lab=_61901_/X }
C {sky130_stdcells/and4_4.sym} 71620 -38560 0 0 {name=X_61901_ }
C {devices/lab_pin.sym} 71580 -38410 0 0 {name=p70694 lab=_49570_/A }
C {devices/lab_pin.sym} 71660 -38410 0 1 {name=p70695 lab=_49623_/X }
C {sky130_stdcells/buf_2.sym} 71620 -38410 0 0 {name=X_49623_ }
C {devices/lab_pin.sym} 71540 -38310 0 0 {name=p70696 lab=_58867_/A }
C {devices/lab_pin.sym} 71540 -38270 0 0 {name=p70697 lab=_46813_/X }
C {devices/lab_pin.sym} 71540 -38230 0 0 {name=p70698 lab=_46834_/Y }
C {devices/lab_pin.sym} 71700 -38270 0 1 {name=p70699 lab=_46835_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -38270 0 0 {name=X_46835_ }
C {devices/lab_pin.sym} 71560 -38150 0 0 {name=p70700 lab=_77655_/A }
C {devices/lab_pin.sym} 71560 -38110 0 0 {name=p70701 lab=_77652_/Y }
C {devices/lab_pin.sym} 71560 -38070 0 0 {name=p70702 lab=_77654_/Y }
C {devices/lab_pin.sym} 71680 -38110 0 1 {name=p70703 lab=_77660_/A }
C {sky130_stdcells/or3_4.sym} 71620 -38110 0 0 {name=X_77655_ }
C {devices/lab_pin.sym} 71540 -38010 0 0 {name=p70704 lab=_62877_/X }
C {devices/lab_pin.sym} 71540 -37970 0 0 {name=p70705 lab=_62831_/X }
C {devices/lab_pin.sym} 71540 -37930 0 0 {name=p70706 lab=_62878_/Y }
C {devices/lab_pin.sym} 71540 -37890 0 0 {name=p70707 lab=_62879_/Y }
C {devices/lab_pin.sym} 71540 -37860 0 0 {name=p70708 lab=_62880_/X }
C {devices/lab_pin.sym} 71700 -37930 0 1 {name=p70709 lab=_62881_/X }
C {sky130_stdcells/a41o_4.sym} 71620 -37930 0 0 {name=X_62881_ }
C {devices/lab_pin.sym} 71560 -37780 0 0 {name=p70710 lab=_74867_/A }
C {devices/lab_pin.sym} 71560 -37740 0 0 {name=p70711 lab=_74866_/Y }
C {devices/lab_pin.sym} 71680 -37760 0 1 {name=p70712 lab=_74868_/B }
C {sky130_stdcells/xor2_4.sym} 71620 -37760 0 0 {name=X_74867_ }
C {devices/lab_pin.sym} 71580 -37630 0 0 {name=p70713 lab=clkbuf_9_289_0_CLK/X }
C {devices/lab_pin.sym} 71660 -37630 0 1 {name=p70714 lab=_80804_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 71620 -37630 0 0 {name=Xclkbuf_10_579_0_CLK }
C {devices/lab_pin.sym} 71540 -37530 0 0 {name=p70715 lab=_64612_/X }
C {devices/lab_pin.sym} 71540 -37490 0 0 {name=p70716 lab=_64618_/X }
C {devices/lab_pin.sym} 71540 -37450 0 0 {name=p70717 lab=_64619_/X }
C {devices/lab_pin.sym} 71700 -37490 0 1 {name=p70718 lab=_64623_/A }
C {sky130_stdcells/a21o_4.sym} 71620 -37490 0 0 {name=X_64620_ }
C {devices/lab_pin.sym} 71560 -37360 0 0 {name=p70719 lab=_76604_/Y }
C {devices/lab_pin.sym} 71560 -37320 0 0 {name=p70720 lab=_76605_/X }
C {devices/lab_pin.sym} 71680 -37340 0 1 {name=p70721 lab=_81631_/D }
C {sky130_stdcells/xor2_4.sym} 71620 -37340 0 0 {name=X_76606_ }
C {devices/lab_pin.sym} 71560 -37220 0 0 {name=p70722 lab=_49558_/A }
C {devices/lab_pin.sym} 71560 -37180 0 0 {name=p70723 lab=_52768_/B }
C {devices/lab_pin.sym} 71680 -37200 0 1 {name=p70724 lab=_49554_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -37200 0 0 {name=X_49554_ }
C {devices/lab_pin.sym} 71560 -37100 0 0 {name=p70725 lab=_61831_/X }
C {devices/lab_pin.sym} 71560 -37060 0 0 {name=p70726 lab=_61765_/B }
C {devices/lab_pin.sym} 71560 -37020 0 0 {name=p70727 lab=_61846_/C }
C {devices/lab_pin.sym} 71560 -36980 0 0 {name=p70728 lab=_61846_/D }
C {devices/lab_pin.sym} 71680 -37040 0 1 {name=p70729 lab=_61832_/Y }
C {sky130_stdcells/nand4_4.sym} 71620 -37040 0 0 {name=X_61832_ }
C {devices/lab_pin.sym} 71580 -36890 0 0 {name=p70730 lab=_73939_/A }
C {devices/lab_pin.sym} 71660 -36890 0 1 {name=p70731 lab=_73818_/X }
C {sky130_stdcells/buf_2.sym} 71620 -36890 0 0 {name=X_73818_ }
C {devices/lab_pin.sym} 71580 -36770 0 0 {name=p70732 lab=_72052_/A }
C {devices/lab_pin.sym} 71660 -36770 0 1 {name=p70733 lab=_46767_/A }
C {sky130_stdcells/buf_2.sym} 71620 -36770 0 0 {name=X_46766_ }
C {devices/lab_pin.sym} 71540 -36670 0 0 {name=p70734 lab=_77570_/A }
C {devices/lab_pin.sym} 71540 -36630 0 0 {name=p70735 lab=_77567_/Y }
C {devices/lab_pin.sym} 71540 -36590 0 0 {name=p70736 lab=_77568_/Y }
C {devices/lab_pin.sym} 71700 -36630 0 1 {name=p70737 lab=_77586_/X }
C {sky130_stdcells/o21a_4.sym} 71620 -36630 0 0 {name=X_77586_ }
C {devices/lab_pin.sym} 71580 -36490 0 0 {name=p70738 lab=_44160_/B }
C {devices/lab_pin.sym} 71660 -36490 0 1 {name=p70739 lab=_43978_/Y }
C {sky130_stdcells/inv_2.sym} 71620 -36490 0 0 {name=X_43978_ }
C {devices/lab_pin.sym} 71560 -36400 0 0 {name=p70740 lab=_74794_/Y }
C {devices/lab_pin.sym} 71560 -36360 0 0 {name=p70741 lab=_74798_/B }
C {devices/lab_pin.sym} 71560 -36320 0 0 {name=p70742 lab=_74796_/Y }
C {devices/lab_pin.sym} 71560 -36280 0 0 {name=p70743 lab=_74798_/D }
C {devices/lab_pin.sym} 71680 -36340 0 1 {name=p70744 lab=_74798_/X }
C {sky130_stdcells/and4_4.sym} 71620 -36340 0 0 {name=X_74798_ }
C {devices/lab_pin.sym} 71560 -36200 0 0 {name=p70745 lab=_48515_/A }
C {devices/lab_pin.sym} 71560 -36160 0 0 {name=p70746 lab=_52163_/B }
C {devices/lab_pin.sym} 71680 -36180 0 1 {name=p70747 lab=_48505_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -36180 0 0 {name=X_48505_ }
C {devices/lab_pin.sym} 71540 -36070 0 0 {name=p70748 lab=_79316_/Y }
C {devices/lab_pin.sym} 71540 -36030 0 0 {name=p70749 lab=_79334_/B }
C {devices/lab_pin.sym} 71540 -35990 0 0 {name=p70750 lab=_79324_/X }
C {devices/lab_pin.sym} 71700 -36030 0 1 {name=p70751 lab=_79325_/Y }
C {sky130_stdcells/a21boi_4.sym} 71620 -36030 0 0 {name=X_79325_ }
C {devices/lab_pin.sym} 71540 -35910 0 0 {name=p70752 lab=_45668_/X }
C {devices/lab_pin.sym} 71540 -35870 0 0 {name=p70753 lab=_61572_/A }
C {devices/lab_pin.sym} 71540 -35830 0 0 {name=p70754 lab=_45685_/X }
C {devices/lab_pin.sym} 71700 -35870 0 1 {name=p70755 lab=_45717_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -35870 0 0 {name=X_45717_ }
C {devices/lab_pin.sym} 71540 -35750 0 0 {name=p70756 lab=_64542_/Y }
C {devices/lab_pin.sym} 71540 -35710 0 0 {name=p70757 lab=_64532_/X }
C {devices/lab_pin.sym} 71540 -35670 0 0 {name=p70758 lab=_64550_/Y }
C {devices/lab_pin.sym} 71700 -35710 0 1 {name=p70759 lab=_84235_/D }
C {sky130_stdcells/o21ai_4.sym} 71620 -35710 0 0 {name=X_64551_ }
C {devices/lab_pin.sym} 71540 -35590 0 0 {name=p70760 lab=_76520_/Y }
C {devices/lab_pin.sym} 71540 -35550 0 0 {name=p70761 lab=_76521_/Y }
C {devices/lab_pin.sym} 71540 -35510 0 0 {name=p70762 lab=_76522_/Y }
C {devices/lab_pin.sym} 71700 -35550 0 1 {name=p70763 lab=_76537_/X }
C {sky130_stdcells/o21a_4.sym} 71620 -35550 0 0 {name=X_76537_ }
C {devices/lab_pin.sym} 71540 -35440 0 0 {name=p70764 lab=_41741_/X }
C {devices/lab_pin.sym} 71540 -35400 0 0 {name=p70765 lab=_42920_/X }
C {devices/lab_pin.sym} 71540 -35360 0 0 {name=p70766 lab=_67832_/B }
C {devices/lab_pin.sym} 71540 -35320 0 0 {name=p70767 lab=_42922_/X }
C {devices/lab_pin.sym} 71700 -35380 0 1 {name=p70768 lab=_87646_/D }
C {sky130_stdcells/a2bb2o_4.sym} 71620 -35380 0 0 {name=X_42929_ }
C {devices/lab_pin.sym} 71560 -35240 0 0 {name=p70769 lab=_49481_/A }
C {devices/lab_pin.sym} 71560 -35200 0 0 {name=p70770 lab=_51008_/B }
C {devices/lab_pin.sym} 71680 -35220 0 1 {name=p70771 lab=_49485_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -35220 0 0 {name=X_49485_ }
C {devices/lab_pin.sym} 71580 -35090 0 0 {name=p70772 lab=_61711_/X }
C {devices/lab_pin.sym} 71660 -35090 0 1 {name=p70773 lab=_61856_/A }
C {sky130_stdcells/buf_2.sym} 71620 -35090 0 0 {name=X_61763_ }
C {devices/lab_pin.sym} 71540 -34990 0 0 {name=p70774 lab=_70107_/B }
C {devices/lab_pin.sym} 71540 -34950 0 0 {name=p70775 lab=_73697_/X }
C {devices/lab_pin.sym} 71540 -34910 0 0 {name=p70776 lab=_73748_/X }
C {devices/lab_pin.sym} 71700 -34950 0 1 {name=p70777 lab=_73749_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -34950 0 0 {name=X_73749_ }
C {devices/lab_pin.sym} 71580 -34810 0 0 {name=p70778 lab=_54312_/D }
C {devices/lab_pin.sym} 71660 -34810 0 1 {name=p70779 lab=_52622_/D }
C {sky130_stdcells/buf_2.sym} 71620 -34810 0 0 {name=X_46697_ }
C {devices/lab_pin.sym} 71580 -34690 0 0 {name=p70780 lab=clkbuf_9_251_0_CLK/X }
C {devices/lab_pin.sym} 71660 -34690 0 1 {name=p70781 lab=_86100_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 71620 -34690 0 0 {name=Xclkbuf_10_502_0_CLK }
C {devices/lab_pin.sym} 71560 -34590 0 0 {name=p70782 lab=_63512_/A }
C {devices/lab_pin.sym} 71560 -34550 0 0 {name=p70783 lab=_57664_/A }
C {devices/lab_pin.sym} 71560 -34510 0 0 {name=p70784 lab=_63476_/C }
C {devices/lab_pin.sym} 71680 -34550 0 1 {name=p70785 lab=_63502_/X }
C {sky130_stdcells/and3_4.sym} 71620 -34550 0 0 {name=X_63502_ }
C {devices/lab_pin.sym} 71540 -34430 0 0 {name=p70786 lab=_86522_/Q }
C {devices/lab_pin.sym} 71540 -34390 0 0 {name=p70787 lab=_48419_/X }
C {devices/lab_pin.sym} 71540 -34350 0 0 {name=p70788 lab=_48435_/Y }
C {devices/lab_pin.sym} 71700 -34390 0 1 {name=p70789 lab=_48436_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -34390 0 0 {name=X_48436_ }
C {devices/lab_pin.sym} 71560 -34270 0 0 {name=p70790 lab=_60714_/A }
C {devices/lab_pin.sym} 71560 -34230 0 0 {name=p70791 lab=_63417_/A }
C {devices/lab_pin.sym} 71560 -34190 0 0 {name=p70792 lab=_60725_/A }
C {devices/lab_pin.sym} 71680 -34230 0 1 {name=p70793 lab=_60714_/Y }
C {sky130_stdcells/nand3_4.sym} 71620 -34230 0 0 {name=X_60714_ }
C {devices/lab_pin.sym} 71580 -34090 0 0 {name=p70794 lab=_66673_/X }
C {devices/lab_pin.sym} 71660 -34090 0 1 {name=p70795 lab=_67270_/X }
C {sky130_stdcells/buf_2.sym} 71620 -34090 0 0 {name=X_67270_ }
C {devices/lab_pin.sym} 71540 -33990 0 0 {name=p70796 lab=_79244_/X }
C {devices/lab_pin.sym} 71540 -33950 0 0 {name=p70797 lab=_79246_/B }
C {devices/lab_pin.sym} 71540 -33910 0 0 {name=p70798 lab=_79255_/Y }
C {devices/lab_pin.sym} 71700 -33950 0 1 {name=p70799 lab=_79256_/Y }
C {sky130_stdcells/a21boi_4.sym} 71620 -33950 0 0 {name=X_79256_ }
C {devices/lab_pin.sym} 71560 -33820 0 0 {name=p70800 lab=_57409_/A }
C {devices/lab_pin.sym} 71560 -33780 0 0 {name=p70801 lab=_45354_/X }
C {devices/lab_pin.sym} 71680 -33800 0 1 {name=p70802 lab=_45648_/Y }
C {sky130_stdcells/nor2_4.sym} 71620 -33800 0 0 {name=X_45648_ }
C {devices/lab_pin.sym} 71540 -33690 0 0 {name=p70803 lab=_64480_/Y }
C {devices/lab_pin.sym} 71540 -33650 0 0 {name=p70804 lab=_64186_/X }
C {devices/lab_pin.sym} 71540 -33610 0 0 {name=p70805 lab=_64481_/Y }
C {devices/lab_pin.sym} 71700 -33650 0 1 {name=p70806 lab=_64482_/Y }
C {sky130_stdcells/a21oi_4.sym} 71620 -33650 0 0 {name=X_64482_ }
C {devices/lab_pin.sym} 71560 -33520 0 0 {name=p70807 lab=_76464_/Y }
C {devices/lab_pin.sym} 71560 -33480 0 0 {name=p70808 lab=_76468_/B }
C {devices/lab_pin.sym} 71680 -33500 0 1 {name=p70809 lab=_76469_/B }
C {sky130_stdcells/xor2_4.sym} 71620 -33500 0 0 {name=X_76468_ }
C {devices/lab_pin.sym} 71560 -33390 0 0 {name=p70810 lab=_61292_/A }
C {devices/lab_pin.sym} 71560 -33350 0 0 {name=p70811 lab=_61694_/B }
C {devices/lab_pin.sym} 71560 -33310 0 0 {name=p70812 lab=_61675_/C }
C {devices/lab_pin.sym} 71680 -33350 0 1 {name=p70813 lab=_61694_/Y }
C {sky130_stdcells/nand3_4.sym} 71620 -33350 0 0 {name=X_61694_ }
C {devices/lab_pin.sym} 71540 -33240 0 0 {name=p70814 lab=_66125_/X }
C {devices/lab_pin.sym} 71540 -33200 0 0 {name=p70815 lab=_86219_/Q }
C {devices/lab_pin.sym} 71540 -33160 0 0 {name=p70816 lab=_66180_/X }
C {devices/lab_pin.sym} 71540 -33120 0 0 {name=p70817 lab=_66220_/X }
C {devices/lab_pin.sym} 71700 -33180 0 1 {name=p70818 lab=_66221_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -33180 0 0 {name=X_66221_ }
C {devices/lab_pin.sym} 71560 -33040 0 0 {name=p70819 lab=_78198_/A }
C {devices/lab_pin.sym} 71560 -33000 0 0 {name=p70820 lab=_82491_/Q }
C {devices/lab_pin.sym} 71680 -33020 0 1 {name=p70821 lab=_78207_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -33020 0 0 {name=X_78207_ }
C {devices/lab_pin.sym} 71540 -32910 0 0 {name=p70822 lab=_63431_/Y }
C {devices/lab_pin.sym} 71540 -32870 0 0 {name=p70823 lab=_63391_/X }
C {devices/lab_pin.sym} 71540 -32830 0 0 {name=p70824 lab=_63432_/Y }
C {devices/lab_pin.sym} 71700 -32870 0 1 {name=p70825 lab=_63433_/Y }
C {sky130_stdcells/a21oi_4.sym} 71620 -32870 0 0 {name=X_63433_ }
C {devices/lab_pin.sym} 71560 -32740 0 0 {name=p70826 lab=_75435_/B }
C {devices/lab_pin.sym} 71560 -32700 0 0 {name=p70827 lab=_75435_/D }
C {devices/lab_pin.sym} 71680 -32720 0 1 {name=p70828 lab=_75419_/X }
C {sky130_stdcells/and2_4.sym} 71620 -32720 0 0 {name=X_75419_ }
C {devices/lab_pin.sym} 71580 -32590 0 0 {name=p70829 lab=_83592_/Q }
C {devices/lab_pin.sym} 71660 -32590 0 1 {name=p70830 lab=_48367_/Y }
C {sky130_stdcells/inv_2.sym} 71620 -32590 0 0 {name=X_48367_ }
C {devices/lab_pin.sym} 71580 -32470 0 0 {name=p70831 lab=_60644_/X }
C {devices/lab_pin.sym} 71660 -32470 0 1 {name=p70832 lab=_60687_/A }
C {sky130_stdcells/buf_2.sym} 71620 -32470 0 0 {name=X_60645_ }
C {devices/lab_pin.sym} 71560 -32370 0 0 {name=p70833 lab=_79186_/Y }
C {devices/lab_pin.sym} 71560 -32330 0 0 {name=p70834 lab=_79180_/Y }
C {devices/lab_pin.sym} 71560 -32290 0 0 {name=p70835 lab=_79181_/Y }
C {devices/lab_pin.sym} 71680 -32330 0 1 {name=p70836 lab=_79188_/B }
C {sky130_stdcells/nand3_4.sym} 71620 -32330 0 0 {name=X_79187_ }
C {devices/lab_pin.sym} 71540 -32210 0 0 {name=p70837 lab=_45511_/X }
C {devices/lab_pin.sym} 71540 -32170 0 0 {name=p70838 lab=_61468_/A }
C {devices/lab_pin.sym} 71540 -32130 0 0 {name=p70839 lab=_45530_/X }
C {devices/lab_pin.sym} 71700 -32170 0 1 {name=p70840 lab=_45579_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -32170 0 0 {name=X_45579_ }
C {devices/lab_pin.sym} 71580 -32030 0 0 {name=p70841 lab=_76399_/A }
C {devices/lab_pin.sym} 71660 -32030 0 1 {name=p70842 lab=_76400_/C }
C {sky130_stdcells/inv_2.sym} 71620 -32030 0 0 {name=X_76399_ }
C {devices/lab_pin.sym} 71580 -31910 0 0 {name=p70843 lab=_47130_/A }
C {devices/lab_pin.sym} 71660 -31910 0 1 {name=p70844 lab=_47349_/B }
C {sky130_stdcells/buf_2.sym} 71620 -31910 0 0 {name=X_47318_ }
C {devices/lab_pin.sym} 71540 -31810 0 0 {name=p70845 lab=_66149_/Y }
C {devices/lab_pin.sym} 71540 -31770 0 0 {name=p70846 lab=_66137_/X }
C {devices/lab_pin.sym} 71540 -31730 0 0 {name=p70847 lab=_66151_/X }
C {devices/lab_pin.sym} 71700 -31770 0 1 {name=p70848 lab=_66152_/X }
C {sky130_stdcells/a21o_4.sym} 71620 -31770 0 0 {name=X_66152_ }
C {devices/lab_pin.sym} 71560 -31640 0 0 {name=p70849 lab=_78129_/X }
C {devices/lab_pin.sym} 71560 -31600 0 0 {name=p70850 lab=_78137_/Y }
C {devices/lab_pin.sym} 71680 -31620 0 1 {name=p70851 lab=_78139_/B }
C {sky130_stdcells/xor2_4.sym} 71620 -31620 0 0 {name=X_78138_ }
C {devices/lab_pin.sym} 71540 -31530 0 0 {name=p70852 lab=_63354_/Y }
C {devices/lab_pin.sym} 71540 -31490 0 0 {name=p70853 lab=_63360_/X }
C {devices/lab_pin.sym} 71540 -31450 0 0 {name=p70854 lab=_63361_/X }
C {devices/lab_pin.sym} 71540 -31410 0 0 {name=p70855 lab=_58147_/A }
C {devices/lab_pin.sym} 71540 -31370 0 0 {name=p70856 lab=_63363_/X }
C {devices/lab_pin.sym} 71700 -31450 0 1 {name=p70857 lab=_63364_/Y }
C {sky130_stdcells/o32ai_4.sym} 71620 -31450 0 0 {name=X_63364_ }
C {devices/lab_pin.sym} 71580 -31290 0 0 {name=p70858 lab=_58094_/A }
C {devices/lab_pin.sym} 71660 -31290 0 1 {name=p70859 lab=_72250_/A }
C {sky130_stdcells/buf_2.sym} 71620 -31290 0 0 {name=X_60576_ }
C {devices/lab_pin.sym} 71560 -31180 0 0 {name=p70860 lab=_48275_/X }
C {devices/lab_pin.sym} 71560 -31140 0 0 {name=p70861 lab=_48297_/X }
C {devices/lab_pin.sym} 71680 -31160 0 1 {name=p70862 lab=_48298_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -31160 0 0 {name=X_48298_ }
C {devices/lab_pin.sym} 71580 -31030 0 0 {name=p70863 lab=clkbuf_9_258_0_CLK/X }
C {devices/lab_pin.sym} 71660 -31030 0 1 {name=p70864 lab=_81473_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 71620 -31030 0 0 {name=Xclkbuf_10_517_0_CLK }
C {devices/lab_pin.sym} 71560 -30920 0 0 {name=p70865 lab=_64929_/A }
C {devices/lab_pin.sym} 71560 -30880 0 0 {name=p70866 lab=_65103_/B }
C {devices/lab_pin.sym} 71680 -30900 0 1 {name=p70867 lab=_65103_/X }
C {sky130_stdcells/and2_4.sym} 71620 -30900 0 0 {name=X_65103_ }
C {devices/lab_pin.sym} 71560 -30800 0 0 {name=p70868 lab=_62304_/A }
C {devices/lab_pin.sym} 71560 -30760 0 0 {name=p70869 lab=_58248_/A }
C {devices/lab_pin.sym} 71560 -30720 0 0 {name=p70870 lab=_62315_/C }
C {devices/lab_pin.sym} 71560 -30680 0 0 {name=p70871 lab=_62286_/X }
C {devices/lab_pin.sym} 71680 -30740 0 1 {name=p70872 lab=_62315_/X }
C {sky130_stdcells/and4_4.sym} 71620 -30740 0 0 {name=X_62315_ }
C {devices/lab_pin.sym} 71560 -30620 0 0 {name=p70873 lab=_47246_/X }
C {devices/lab_pin.sym} 71560 -30580 0 0 {name=p70874 lab=_47228_/B }
C {devices/lab_pin.sym} 71560 -30540 0 0 {name=p70875 lab=_47234_/X }
C {devices/lab_pin.sym} 71560 -30500 0 0 {name=p70876 lab=_52938_/D }
C {devices/lab_pin.sym} 71680 -30560 0 1 {name=p70877 lab=_47249_/X }
C {sky130_stdcells/and4_4.sym} 71620 -30560 0 0 {name=X_47249_ }
C {devices/lab_pin.sym} 71540 -30440 0 0 {name=p70878 lab=_64598_/X }
C {devices/lab_pin.sym} 71540 -30400 0 0 {name=p70879 lab=_86229_/Q }
C {devices/lab_pin.sym} 71540 -30360 0 0 {name=p70880 lab=_65761_/X }
C {devices/lab_pin.sym} 71540 -30320 0 0 {name=p70881 lab=_66082_/X }
C {devices/lab_pin.sym} 71700 -30380 0 1 {name=p70882 lab=_66083_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -30380 0 0 {name=X_66083_ }
C {devices/lab_pin.sym} 71560 -30240 0 0 {name=p70883 lab=_60755_/C }
C {devices/lab_pin.sym} 71560 -30200 0 0 {name=p70884 lab=_78069_/B }
C {devices/lab_pin.sym} 71680 -30220 0 1 {name=p70885 lab=_78069_/X }
C {sky130_stdcells/xor2_4.sym} 71620 -30220 0 0 {name=X_78069_ }
C {devices/lab_pin.sym} 71560 -30120 0 0 {name=p70886 lab=_63295_/A }
C {devices/lab_pin.sym} 71560 -30080 0 0 {name=p70887 lab=_63316_/B }
C {devices/lab_pin.sym} 71560 -30040 0 0 {name=p70888 lab=_63295_/C }
C {devices/lab_pin.sym} 71560 -30000 0 0 {name=p70889 lab=_63344_/D }
C {devices/lab_pin.sym} 71680 -30060 0 1 {name=p70890 lab=_63295_/X }
C {sky130_stdcells/or4_4.sym} 71620 -30060 0 0 {name=X_63295_ }
C {devices/lab_pin.sym} 71540 -29930 0 0 {name=p70891 lab=_80092_/A }
C {devices/lab_pin.sym} 71540 -29890 0 0 {name=p70892 lab=_80091_/X }
C {devices/lab_pin.sym} 71540 -29850 0 0 {name=p70893 lab=_80099_/Y }
C {devices/lab_pin.sym} 71700 -29890 0 1 {name=p70894 lab=_80117_/B }
C {sky130_stdcells/a21boi_4.sym} 71620 -29890 0 0 {name=X_80100_ }
C {devices/lab_pin.sym} 71580 -29750 0 0 {name=p70895 lab=_65034_/A }
C {devices/lab_pin.sym} 71660 -29750 0 1 {name=p70896 lab=_65859_/A }
C {sky130_stdcells/buf_2.sym} 71620 -29750 0 0 {name=X_65034_ }
C {devices/lab_pin.sym} 71560 -29640 0 0 {name=p70897 lab=_69865_/A }
C {devices/lab_pin.sym} 71560 -29600 0 0 {name=p70898 lab=_88313_/Q }
C {devices/lab_pin.sym} 71680 -29620 0 1 {name=p70899 lab=_69911_/X }
C {sky130_stdcells/and2_4.sym} 71620 -29620 0 0 {name=X_69911_ }
C {devices/lab_pin.sym} 71560 -29500 0 0 {name=p70900 lab=_50251_/X }
C {devices/lab_pin.sym} 71560 -29460 0 0 {name=p70901 lab=_50260_/B }
C {devices/lab_pin.sym} 71680 -29480 0 1 {name=p70902 lab=_50260_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -29480 0 0 {name=X_50260_ }
C {devices/lab_pin.sym} 71540 -29370 0 0 {name=p70903 lab=_59931_/X }
C {devices/lab_pin.sym} 71540 -29330 0 0 {name=p70904 lab=_61762_/X }
C {devices/lab_pin.sym} 71540 -29290 0 0 {name=p70905 lab=_62245_/X }
C {devices/lab_pin.sym} 71700 -29330 0 1 {name=p70906 lab=_62246_/X }
C {sky130_stdcells/a21o_4.sym} 71620 -29330 0 0 {name=X_62246_ }
C {devices/lab_pin.sym} 71530 -29190 0 0 {name=p70907 lab=_80696_/CLK }
C {devices/lab_pin.sym} 71530 -29170 0 0 {name=p70908 lab=_81112_/Q }
C {devices/lab_pin.sym} 71710 -29190 0 1 {name=p70909 lab=_75392_/A }
C {sky130_stdcells/dfxtp_4.sym} 71620 -29180 0 0 {name=X_81080_ }
C {devices/lab_pin.sym} 71560 -29060 0 0 {name=p70910 lab=_80023_/A }
C {devices/lab_pin.sym} 71560 -29020 0 0 {name=p70911 lab=_80008_/X }
C {devices/lab_pin.sym} 71680 -29040 0 1 {name=p70912 lab=_80031_/X }
C {sky130_stdcells/and2_4.sym} 71620 -29040 0 0 {name=X_80031_ }
C {devices/lab_pin.sym} 71560 -28920 0 0 {name=p70913 lab=_69900_/A }
C {devices/lab_pin.sym} 71560 -28880 0 0 {name=p70914 lab=_69842_/B }
C {devices/lab_pin.sym} 71680 -28900 0 1 {name=p70915 lab=_69842_/X }
C {sky130_stdcells/and2_4.sym} 71620 -28900 0 0 {name=X_69842_ }
C {devices/lab_pin.sym} 71580 -28770 0 0 {name=p70916 lab=_51263_/A }
C {devices/lab_pin.sym} 71660 -28770 0 1 {name=p70917 lab=_50191_/X }
C {sky130_stdcells/buf_2.sym} 71620 -28770 0 0 {name=X_50191_ }
C {devices/lab_pin.sym} 71540 -28690 0 0 {name=p70918 lab=_62169_/X }
C {devices/lab_pin.sym} 71540 -28650 0 0 {name=p70919 lab=_62171_/X }
C {devices/lab_pin.sym} 71540 -28610 0 0 {name=p70920 lab=_62176_/Y }
C {devices/lab_pin.sym} 71540 -28570 0 0 {name=p70921 lab=_84867_/Q }
C {devices/lab_pin.sym} 71540 -28530 0 0 {name=p70922 lab=_61782_/A }
C {devices/lab_pin.sym} 71700 -28610 0 1 {name=p70923 lab=_62177_/Y }
C {sky130_stdcells/o32ai_4.sym} 71620 -28610 0 0 {name=X_62177_ }
C {devices/lab_pin.sym} 71580 -28450 0 0 {name=p70924 lab=_61128_/A }
C {devices/lab_pin.sym} 71660 -28450 0 1 {name=p70925 lab=_64303_/A }
C {sky130_stdcells/buf_2.sym} 71620 -28450 0 0 {name=X_61128_ }
C {devices/lab_pin.sym} 71540 -28350 0 0 {name=p70926 lab=_69347_/X }
C {devices/lab_pin.sym} 71540 -28310 0 0 {name=p70927 lab=_69349_/X }
C {devices/lab_pin.sym} 71540 -28270 0 0 {name=p70928 lab=_69728_/X }
C {devices/lab_pin.sym} 71700 -28310 0 1 {name=p70929 lab=_69773_/Y }
C {sky130_stdcells/a21oi_4.sym} 71620 -28310 0 0 {name=X_69773_ }
C {devices/lab_pin.sym} 71560 -28180 0 0 {name=p70930 lab=_66961_/X }
C {devices/lab_pin.sym} 71560 -28140 0 0 {name=p70931 lab=_66985_/B }
C {devices/lab_pin.sym} 71680 -28160 0 1 {name=p70932 lab=_66985_/X }
C {sky130_stdcells/and2_4.sym} 71620 -28160 0 0 {name=X_66985_ }
C {devices/lab_pin.sym} 71540 -28060 0 0 {name=p70933 lab=_87089_/Q }
C {devices/lab_pin.sym} 71540 -28020 0 0 {name=p70934 lab=_68353_/X }
C {devices/lab_pin.sym} 71540 -27980 0 0 {name=p70935 lab=_68354_/X }
C {devices/lab_pin.sym} 71540 -27940 0 0 {name=p70936 lab=_68723_/X }
C {devices/lab_pin.sym} 71700 -28000 0 1 {name=p70937 lab=_68724_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -28000 0 0 {name=X_68724_ }
C {devices/lab_pin.sym} 71540 -27870 0 0 {name=p70938 lab=_53947_/Y }
C {devices/lab_pin.sym} 71540 -27830 0 0 {name=p70939 lab=_53948_/X }
C {devices/lab_pin.sym} 71540 -27790 0 0 {name=p70940 lab=_53949_/Y }
C {devices/lab_pin.sym} 71700 -27830 0 1 {name=p70941 lab=_53950_/Y }
C {sky130_stdcells/a21boi_4.sym} 71620 -27830 0 0 {name=X_53950_ }
C {devices/lab_pin.sym} 71540 -27720 0 0 {name=p70942 lab=_65859_/X }
C {devices/lab_pin.sym} 71540 -27680 0 0 {name=p70943 lab=_85631_/Q }
C {devices/lab_pin.sym} 71540 -27640 0 0 {name=p70944 lab=_65860_/X }
C {devices/lab_pin.sym} 71540 -27600 0 0 {name=p70945 lab=_65935_/X }
C {devices/lab_pin.sym} 71700 -27660 0 1 {name=p70946 lab=_65936_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -27660 0 0 {name=X_65936_ }
C {devices/lab_pin.sym} 71540 -27540 0 0 {name=p70947 lab=_60994_/A }
C {devices/lab_pin.sym} 71540 -27500 0 0 {name=p70948 lab=_60998_/X }
C {devices/lab_pin.sym} 71540 -27460 0 0 {name=p70949 lab=_59846_/X }
C {devices/lab_pin.sym} 71540 -27420 0 0 {name=p70950 lab=_60992_/X }
C {devices/lab_pin.sym} 71700 -27480 0 1 {name=p70951 lab=_61059_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -27480 0 0 {name=X_61059_ }
C {devices/lab_pin.sym} 71530 -27330 0 0 {name=p70952 lab=_85375_/CLK }
C {devices/lab_pin.sym} 71530 -27310 0 0 {name=p70953 lab=_59092_/Y }
C {devices/lab_pin.sym} 71710 -27330 0 1 {name=p70954 lab=_84770_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -27320 0 0 {name=X_84770_ }
C {devices/lab_pin.sym} 71530 -27190 0 0 {name=p70955 lab=_83906_/CLK }
C {devices/lab_pin.sym} 71530 -27170 0 0 {name=p70956 lab=_83910_/Q }
C {devices/lab_pin.sym} 71710 -27190 0 1 {name=p70957 lab=_77833_/B }
C {sky130_stdcells/dfxtp_4.sym} 71620 -27180 0 0 {name=X_81982_ }
C {devices/lab_pin.sym} 71540 -27070 0 0 {name=p70958 lab=_52898_/Y }
C {devices/lab_pin.sym} 71540 -27030 0 0 {name=p70959 lab=_52892_/X }
C {devices/lab_pin.sym} 71540 -26990 0 0 {name=p70960 lab=_52900_/X }
C {devices/lab_pin.sym} 71700 -27030 0 1 {name=p70961 lab=_52901_/Y }
C {sky130_stdcells/a21oi_4.sym} 71620 -27030 0 0 {name=X_52901_ }
C {devices/lab_pin.sym} 71530 -26890 0 0 {name=p70962 lab=_83721_/CLK }
C {devices/lab_pin.sym} 71530 -26870 0 0 {name=p70963 lab=_70709_/Y }
C {devices/lab_pin.sym} 71710 -26890 0 1 {name=p70964 lab=_46920_/A }
C {sky130_stdcells/dfxtp_4.sym} 71620 -26880 0 0 {name=X_83721_ }
C {devices/lab_pin.sym} 71540 -26780 0 0 {name=p70965 lab=_87496_/Q }
C {devices/lab_pin.sym} 71540 -26740 0 0 {name=p70966 lab=_68626_/X }
C {devices/lab_pin.sym} 71540 -26700 0 0 {name=p70967 lab=_68601_/X }
C {devices/lab_pin.sym} 71540 -26660 0 0 {name=p70968 lab=_68654_/X }
C {devices/lab_pin.sym} 71700 -26720 0 1 {name=p70969 lab=_68655_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -26720 0 0 {name=X_68655_ }
C {devices/lab_pin.sym} 71530 -26570 0 0 {name=p70970 lab=_81061_/CLK }
C {devices/lab_pin.sym} 71530 -26550 0 0 {name=p70971 lab=_75109_/B }
C {devices/lab_pin.sym} 71710 -26570 0 1 {name=p70972 lab=_80933_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -26560 0 0 {name=X_80933_ }
C {devices/lab_pin.sym} 71560 -26440 0 0 {name=p70973 lab=_53871_/X }
C {devices/lab_pin.sym} 71560 -26400 0 0 {name=p70974 lab=_49083_/A }
C {devices/lab_pin.sym} 71680 -26420 0 1 {name=p70975 lab=_53881_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -26420 0 0 {name=X_53881_ }
C {devices/lab_pin.sym} 71540 -26320 0 0 {name=p70976 lab=_65811_/X }
C {devices/lab_pin.sym} 71540 -26280 0 0 {name=p70977 lab=_83052_/Q }
C {devices/lab_pin.sym} 71540 -26240 0 0 {name=p70978 lab=_65865_/X }
C {devices/lab_pin.sym} 71540 -26200 0 0 {name=p70979 lab=_65866_/X }
C {devices/lab_pin.sym} 71700 -26260 0 1 {name=p70980 lab=_65867_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -26260 0 0 {name=X_65867_ }
C {devices/lab_pin.sym} 71580 -26110 0 0 {name=p70981 lab=_55620_/A }
C {devices/lab_pin.sym} 71660 -26110 0 1 {name=p70982 lab=_55947_/A }
C {sky130_stdcells/buf_2.sym} 71620 -26110 0 0 {name=X_55620_ }
C {devices/lab_pin.sym} 71540 -26020 0 0 {name=p70983 lab=_87400_/Q }
C {devices/lab_pin.sym} 71540 -25980 0 0 {name=p70984 lab=_67512_/X }
C {devices/lab_pin.sym} 71540 -25940 0 0 {name=p70985 lab=_67581_/X }
C {devices/lab_pin.sym} 71540 -25900 0 0 {name=p70986 lab=_67605_/X }
C {devices/lab_pin.sym} 71700 -25960 0 1 {name=p70987 lab=_67606_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -25960 0 0 {name=X_67606_ }
C {devices/lab_pin.sym} 71530 -25810 0 0 {name=p70988 lab=_83594_/CLK }
C {devices/lab_pin.sym} 71530 -25790 0 0 {name=p70989 lab=_86440_/D }
C {devices/lab_pin.sym} 71710 -25810 0 1 {name=p70990 lab=_65253_/B }
C {sky130_stdcells/dfxtp_4.sym} 71620 -25800 0 0 {name=X_86440_ }
C {devices/lab_pin.sym} 71540 -25690 0 0 {name=p70991 lab=_52830_/Y }
C {devices/lab_pin.sym} 71540 -25650 0 0 {name=p70992 lab=_52809_/X }
C {devices/lab_pin.sym} 71540 -25610 0 0 {name=p70993 lab=_52831_/X }
C {devices/lab_pin.sym} 71700 -25650 0 1 {name=p70994 lab=_52832_/Y }
C {sky130_stdcells/a21oi_4.sym} 71620 -25650 0 0 {name=X_52832_ }
C {devices/lab_pin.sym} 71560 -25520 0 0 {name=p70995 lab=_64778_/A }
C {devices/lab_pin.sym} 71560 -25480 0 0 {name=p70996 lab=_85817_/Q }
