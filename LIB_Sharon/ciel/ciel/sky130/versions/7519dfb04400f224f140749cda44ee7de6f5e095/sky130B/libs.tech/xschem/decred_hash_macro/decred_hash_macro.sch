C {devices/lab_pin.sym} 162610 -2470 0 0 {name=p162181 lab=_84452_/CLK }
C {devices/lab_pin.sym} 162610 -2450 0 0 {name=p162182 lab=_84442_/D }
C {devices/lab_pin.sym} 162790 -2470 0 1 {name=p162183 lab=_78065_/B }
C {sky130_stdcells/dfxtp_4.sym} 162700 -2460 0 0 {name=X_84442_ }
C {devices/lab_pin.sym} 162640 -2350 0 0 {name=p162184 lab=_52528_/A }
C {devices/lab_pin.sym} 162640 -2310 0 0 {name=p162185 lab=_50825_/B }
C {devices/lab_pin.sym} 162640 -2270 0 0 {name=p162186 lab=_50830_/C }
C {devices/lab_pin.sym} 162760 -2310 0 1 {name=p162187 lab=_50834_/X }
C {sky130_stdcells/and3_4.sym} 162700 -2310 0 0 {name=X_50834_ }
C {devices/lab_pin.sym} 162620 -2200 0 0 {name=p162188 lab=_57384_/X }
C {devices/lab_pin.sym} 162620 -2160 0 0 {name=p162189 lab=_56589_/X }
C {devices/lab_pin.sym} 162620 -2120 0 0 {name=p162190 lab=_85020_/Q }
C {devices/lab_pin.sym} 162620 -2080 0 0 {name=p162191 lab=_57385_/X }
C {devices/lab_pin.sym} 162780 -2140 0 1 {name=p162192 lab=_85020_/D }
C {sky130_stdcells/a2bb2o_4.sym} 162700 -2140 0 0 {name=X_57390_ }
C {devices/lab_pin.sym} 162610 -1990 0 0 {name=p162193 lab=_81682_/CLK }
C {devices/lab_pin.sym} 162610 -1970 0 0 {name=p162194 lab=_81686_/Q }
C {devices/lab_pin.sym} 162790 -1990 0 1 {name=p162195 lab=_76438_/A }
C {sky130_stdcells/dfxtp_4.sym} 162700 -1980 0 0 {name=X_81654_ }
C {devices/lab_pin.sym} 162640 -1860 0 0 {name=p162196 lab=_69612_/A }
C {devices/lab_pin.sym} 162640 -1820 0 0 {name=p162197 lab=_69376_/B }
C {devices/lab_pin.sym} 162760 -1840 0 1 {name=p162198 lab=_69376_/X }
C {sky130_stdcells/and2_4.sym} 162700 -1840 0 0 {name=X_69376_ }
C {devices/lab_pin.sym} 162640 -1720 0 0 {name=p162199 lab=_69633_/A }
C {devices/lab_pin.sym} 162640 -1680 0 0 {name=p162200 lab=_87698_/Q }
C {devices/lab_pin.sym} 162760 -1700 0 1 {name=p162201 lab=_66588_/X }
C {sky130_stdcells/and2_4.sym} 162700 -1700 0 0 {name=X_66588_ }
C {devices/lab_pin.sym} 162640 -1590 0 0 {name=p162202 lab=_56345_/A }
C {devices/lab_pin.sym} 162640 -1550 0 0 {name=p162203 lab=_56345_/B }
C {devices/lab_pin.sym} 162640 -1510 0 0 {name=p162204 lab=_56341_/C }
C {devices/lab_pin.sym} 162760 -1550 0 1 {name=p162205 lab=_56341_/Y }
C {sky130_stdcells/nand3_4.sym} 162700 -1550 0 0 {name=X_56341_ }
C {devices/lab_pin.sym} 162640 -1420 0 0 {name=p162206 lab=_80605_/A }
C {devices/lab_pin.sym} 162640 -1380 0 0 {name=p162207 lab=_63392_/C }
C {devices/lab_pin.sym} 162760 -1400 0 1 {name=p162208 lab=_80606_/B }
C {sky130_stdcells/xor2_4.sym} 162700 -1400 0 0 {name=X_80605_ }
C {devices/lab_pin.sym} 162660 -1270 0 0 {name=p162209 lab=_68737_/A }
C {devices/lab_pin.sym} 162740 -1270 0 1 {name=p162210 lab=_68327_/X }
C {sky130_stdcells/buf_2.sym} 162700 -1270 0 0 {name=X_68327_ }
C {devices/lab_pin.sym} 162610 -1150 0 0 {name=p162211 lab=_87472_/CLK }
C {devices/lab_pin.sym} 162610 -1130 0 0 {name=p162212 lab=_44335_/X }
C {devices/lab_pin.sym} 162790 -1150 0 1 {name=p162213 lab=_87161_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -1140 0 0 {name=X_87161_ }
C {devices/lab_pin.sym} 162620 -1030 0 0 {name=p162214 lab=_85614_/Q }
C {devices/lab_pin.sym} 162620 -990 0 0 {name=p162215 lab=_53466_/X }
C {devices/lab_pin.sym} 162620 -950 0 0 {name=p162216 lab=_53552_/Y }
C {devices/lab_pin.sym} 162780 -990 0 1 {name=p162217 lab=_53553_/Y }
C {sky130_stdcells/o21ai_4.sym} 162700 -990 0 0 {name=X_53553_ }
C {devices/lab_pin.sym} 162620 -870 0 0 {name=p162218 lab=_65536_/X }
C {devices/lab_pin.sym} 162620 -830 0 0 {name=p162219 lab=_65538_/X }
C {devices/lab_pin.sym} 162620 -790 0 0 {name=p162220 lab=_65457_/X }
C {devices/lab_pin.sym} 162780 -830 0 1 {name=p162221 lab=_65543_/A }
C {sky130_stdcells/a21o_4.sym} 162700 -830 0 0 {name=X_65539_ }
C {devices/lab_pin.sym} 162610 -690 0 0 {name=p162222 lab=_84449_/CLK }
C {devices/lab_pin.sym} 162610 -670 0 0 {name=p162223 lab=_62895_/Y }
C {devices/lab_pin.sym} 162790 -690 0 1 {name=p162224 lab=_84373_/Q }
C {sky130_stdcells/dfxtp_4.sym} 162700 -680 0 0 {name=X_84373_ }
C {devices/lab_pin.sym} 163540 -42170 0 0 {name=p162225 lab=_50762_/Y }
C {devices/lab_pin.sym} 163540 -42130 0 0 {name=p162226 lab=_50735_/X }
C {devices/lab_pin.sym} 163540 -42090 0 0 {name=p162227 lab=_50764_/Y }
C {devices/lab_pin.sym} 163700 -42130 0 1 {name=p162228 lab=_86138_/D }
C {sky130_stdcells/a21boi_4.sym} 163620 -42130 0 0 {name=X_50765_ }
C {devices/lab_pin.sym} 163530 -41990 0 0 {name=p162229 lab=_81582_/CLK }
C {devices/lab_pin.sym} 163530 -41970 0 0 {name=p162230 lab=_65682_/A }
C {devices/lab_pin.sym} 163710 -41990 0 1 {name=p162231 lab=_76790_/A }
C {sky130_stdcells/dfxtp_4.sym} 163620 -41980 0 0 {name=X_81585_ }
C {devices/lab_pin.sym} 163580 -41850 0 0 {name=p162232 lab=clkbuf_9_357_0_CLK/X }
C {devices/lab_pin.sym} 163660 -41850 0 1 {name=p162233 lab=_87073_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 163620 -41850 0 0 {name=Xclkbuf_10_715_0_CLK }
C {devices/lab_pin.sym} 163530 -41730 0 0 {name=p162234 lab=_83685_/CLK }
C {devices/lab_pin.sym} 163530 -41710 0 0 {name=p162235 lab=_50892_/Y }
C {devices/lab_pin.sym} 163710 -41730 0 1 {name=p162236 lab=_86112_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -41720 0 0 {name=X_86112_ }
C {devices/lab_pin.sym} 163560 -41600 0 0 {name=p162237 lab=_52487_/X }
C {devices/lab_pin.sym} 163560 -41560 0 0 {name=p162238 lab=_50808_/B }
C {devices/lab_pin.sym} 163680 -41580 0 1 {name=p162239 lab=_52504_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -41580 0 0 {name=X_52504_ }
C {devices/lab_pin.sym} 163540 -41470 0 0 {name=p162240 lab=_59033_/X }
C {devices/lab_pin.sym} 163540 -41430 0 0 {name=p162241 lab=_85436_/Q }
C {devices/lab_pin.sym} 163540 -41390 0 0 {name=p162242 lab=_59059_/X }
C {devices/lab_pin.sym} 163700 -41430 0 1 {name=p162243 lab=_59060_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -41430 0 0 {name=X_59060_ }
C {devices/lab_pin.sym} 163530 -41290 0 0 {name=p162244 lab=_83333_/CLK }
C {devices/lab_pin.sym} 163530 -41270 0 0 {name=p162245 lab=_71931_/X }
C {devices/lab_pin.sym} 163710 -41290 0 1 {name=p162246 lab=_83324_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -41280 0 0 {name=X_83324_ }
C {devices/lab_pin.sym} 163580 -41150 0 0 {name=p162247 lab=_72806_/A }
C {devices/lab_pin.sym} 163660 -41150 0 1 {name=p162248 lab=_73359_/A }
C {sky130_stdcells/buf_2.sym} 163620 -41150 0 0 {name=X_56272_ }
C {devices/lab_pin.sym} 163560 -41040 0 0 {name=p162249 lab=_80525_/X }
C {devices/lab_pin.sym} 163560 -41000 0 0 {name=p162250 lab=_80536_/B }
C {devices/lab_pin.sym} 163680 -41020 0 1 {name=p162251 lab=_80536_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -41020 0 0 {name=X_80536_ }
C {devices/lab_pin.sym} 163580 -40890 0 0 {name=p162252 lab=_68461_/A }
C {devices/lab_pin.sym} 163660 -40890 0 1 {name=p162253 lab=_68338_/A }
C {sky130_stdcells/buf_2.sym} 163620 -40890 0 0 {name=X_68258_ }
C {devices/lab_pin.sym} 163530 -40770 0 0 {name=p162254 lab=_88268_/CLK }
C {devices/lab_pin.sym} 163530 -40750 0 0 {name=p162255 lab=_44470_/X }
C {devices/lab_pin.sym} 163710 -40770 0 1 {name=p162256 lab=_87092_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -40760 0 0 {name=X_87092_ }
C {devices/lab_pin.sym} 163560 -40640 0 0 {name=p162257 lab=_53458_/A }
C {devices/lab_pin.sym} 163560 -40600 0 0 {name=p162258 lab=_48207_/X }
C {devices/lab_pin.sym} 163680 -40620 0 1 {name=p162259 lab=_53484_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -40620 0 0 {name=X_53484_ }
C {devices/lab_pin.sym} 163540 -40510 0 0 {name=p162260 lab=_50691_/Y }
C {devices/lab_pin.sym} 163540 -40470 0 0 {name=p162261 lab=_50644_/X }
C {devices/lab_pin.sym} 163540 -40430 0 0 {name=p162262 lab=_50695_/Y }
C {devices/lab_pin.sym} 163700 -40470 0 1 {name=p162263 lab=_50696_/Y }
C {sky130_stdcells/a21boi_4.sym} 163620 -40470 0 0 {name=X_50696_ }
C {devices/lab_pin.sym} 163580 -40330 0 0 {name=p162264 lab=clkbuf_9_206_0_CLK/A }
C {devices/lab_pin.sym} 163660 -40330 0 1 {name=p162265 lab=clkbuf_9_206_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 163620 -40330 0 0 {name=Xclkbuf_9_206_0_CLK }
C {devices/lab_pin.sym} 163580 -40210 0 0 {name=p162266 lab=_58080_/A }
C {devices/lab_pin.sym} 163660 -40210 0 1 {name=p162267 lab=_58070_/A }
C {sky130_stdcells/buf_2.sym} 163620 -40210 0 0 {name=X_58011_ }
C {devices/lab_pin.sym} 163540 -40110 0 0 {name=p162268 lab=_55220_/X }
C {devices/lab_pin.sym} 163540 -40070 0 0 {name=p162269 lab=_55222_/X }
C {devices/lab_pin.sym} 163540 -40030 0 0 {name=p162270 lab=_55138_/A }
C {devices/lab_pin.sym} 163700 -40070 0 1 {name=p162271 lab=_55227_/A }
C {sky130_stdcells/a21o_4.sym} 163620 -40070 0 0 {name=X_55223_ }
C {devices/lab_pin.sym} 163540 -39960 0 0 {name=p162272 lab=_67166_/X }
C {devices/lab_pin.sym} 163540 -39920 0 0 {name=p162273 lab=_67197_/Y }
C {devices/lab_pin.sym} 163540 -39880 0 0 {name=p162274 lab=_67152_/X }
C {devices/lab_pin.sym} 163540 -39840 0 0 {name=p162275 lab=_67208_/Y }
C {devices/lab_pin.sym} 163700 -39900 0 1 {name=p162276 lab=_67209_/X }
C {sky130_stdcells/a211o_4.sym} 163620 -39900 0 0 {name=X_67209_ }
C {devices/lab_pin.sym} 163530 -39750 0 0 {name=p162277 lab=_85822_/CLK }
C {devices/lab_pin.sym} 163530 -39730 0 0 {name=p162278 lab=_51271_/Y }
C {devices/lab_pin.sym} 163710 -39750 0 1 {name=p162279 lab=_64780_/B }
C {sky130_stdcells/dfxtp_4.sym} 163620 -39740 0 0 {name=X_86043_ }
C {devices/lab_pin.sym} 163540 -39630 0 0 {name=p162280 lab=_85823_/Q }
C {devices/lab_pin.sym} 163540 -39590 0 0 {name=p162281 lab=_52184_/X }
C {devices/lab_pin.sym} 163540 -39550 0 0 {name=p162282 lab=_52434_/Y }
C {devices/lab_pin.sym} 163700 -39590 0 1 {name=p162283 lab=_52435_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -39590 0 0 {name=X_52435_ }
C {devices/lab_pin.sym} 163530 -39450 0 0 {name=p162284 lab=_85959_/CLK }
C {devices/lab_pin.sym} 163530 -39430 0 0 {name=p162285 lab=_83255_/D }
C {devices/lab_pin.sym} 163710 -39450 0 1 {name=p162286 lab=_83255_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -39440 0 0 {name=X_83255_ }
C {devices/lab_pin.sym} 163560 -39320 0 0 {name=p162287 lab=_80467_/A }
C {devices/lab_pin.sym} 163560 -39280 0 0 {name=p162288 lab=_80457_/X }
C {devices/lab_pin.sym} 163680 -39300 0 1 {name=p162289 lab=_80467_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -39300 0 0 {name=X_80467_ }
C {devices/lab_pin.sym} 163580 -39170 0 0 {name=p162290 lab=_68168_/A }
C {devices/lab_pin.sym} 163660 -39170 0 1 {name=p162291 lab=_68189_/X }
C {sky130_stdcells/buf_2.sym} 163620 -39170 0 0 {name=X_68189_ }
C {devices/lab_pin.sym} 163540 -39070 0 0 {name=p162292 lab=_70209_/X }
C {devices/lab_pin.sym} 163540 -39030 0 0 {name=p162293 lab=_83833_/Q }
C {devices/lab_pin.sym} 163540 -38990 0 0 {name=p162294 lab=_70219_/X }
C {devices/lab_pin.sym} 163700 -39030 0 1 {name=p162295 lab=_83833_/D }
C {sky130_stdcells/a21o_4.sym} 163620 -39030 0 0 {name=X_70220_ }
C {devices/lab_pin.sym} 163530 -38890 0 0 {name=p162296 lab=_82206_/CLK }
C {devices/lab_pin.sym} 163530 -38870 0 0 {name=p162297 lab=_82206_/D }
C {devices/lab_pin.sym} 163710 -38890 0 1 {name=p162298 lab=_82206_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -38880 0 0 {name=X_82206_ }
C {devices/lab_pin.sym} 163560 -38760 0 0 {name=p162299 lab=_55224_/A }
C {devices/lab_pin.sym} 163560 -38720 0 0 {name=p162300 lab=_57448_/A }
C {devices/lab_pin.sym} 163680 -38740 0 1 {name=p162301 lab=_55154_/X }
C {sky130_stdcells/and2_4.sym} 163620 -38740 0 0 {name=X_55154_ }
C {devices/lab_pin.sym} 163580 -38610 0 0 {name=p162302 lab=_40380_/A }
C {devices/lab_pin.sym} 163660 -38610 0 1 {name=p162303 lab=_40380_/X }
C {sky130_stdcells/buf_2.sym} 163620 -38610 0 0 {name=X_40380_ }
C {devices/lab_pin.sym} 163540 -38510 0 0 {name=p162304 lab=_52363_/Y }
C {devices/lab_pin.sym} 163540 -38470 0 0 {name=p162305 lab=_52364_/X }
C {devices/lab_pin.sym} 163540 -38430 0 0 {name=p162306 lab=_52365_/X }
C {devices/lab_pin.sym} 163700 -38470 0 1 {name=p162307 lab=_52366_/Y }
C {sky130_stdcells/a21oi_4.sym} 163620 -38470 0 0 {name=X_52366_ }
C {devices/lab_pin.sym} 163530 -38330 0 0 {name=p162308 lab=_83187_/CLK }
C {devices/lab_pin.sym} 163530 -38310 0 0 {name=p162309 lab=_83186_/D }
C {devices/lab_pin.sym} 163710 -38330 0 1 {name=p162310 lab=_70239_/C }
C {sky130_stdcells/dfxtp_4.sym} 163620 -38320 0 0 {name=X_83186_ }
C {devices/lab_pin.sym} 163540 -38210 0 0 {name=p162311 lab=_80390_/X }
C {devices/lab_pin.sym} 163540 -38170 0 0 {name=p162312 lab=_80391_/X }
C {devices/lab_pin.sym} 163540 -38130 0 0 {name=p162313 lab=_80397_/Y }
C {devices/lab_pin.sym} 163700 -38170 0 1 {name=p162314 lab=_80416_/A }
C {sky130_stdcells/a21boi_4.sym} 163620 -38170 0 0 {name=X_80398_ }
C {devices/lab_pin.sym} 163540 -38050 0 0 {name=p162315 lab=_54103_/Y }
C {devices/lab_pin.sym} 163540 -38010 0 0 {name=p162316 lab=_53437_/X }
C {devices/lab_pin.sym} 163540 -37970 0 0 {name=p162317 lab=_54104_/X }
C {devices/lab_pin.sym} 163700 -38010 0 1 {name=p162318 lab=_85503_/D }
C {sky130_stdcells/a21oi_4.sym} 163620 -38010 0 0 {name=X_54105_ }
C {devices/lab_pin.sym} 163540 -37890 0 0 {name=p162319 lab=_65025_/B }
C {devices/lab_pin.sym} 163540 -37850 0 0 {name=p162320 lab=_51309_/X }
C {devices/lab_pin.sym} 163540 -37810 0 0 {name=p162321 lab=_51316_/Y }
C {devices/lab_pin.sym} 163700 -37850 0 1 {name=p162322 lab=_51317_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -37850 0 0 {name=X_51317_ }
C {devices/lab_pin.sym} 163560 -37720 0 0 {name=p162323 lab=_83507_/Q }
C {devices/lab_pin.sym} 163560 -37680 0 0 {name=p162324 lab=_83155_/Q }
C {devices/lab_pin.sym} 163680 -37700 0 1 {name=p162325 lab=_70151_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -37700 0 0 {name=X_70151_ }
C {devices/lab_pin.sym} 163530 -37570 0 0 {name=p162326 lab=_82139_/CLK }
C {devices/lab_pin.sym} 163530 -37550 0 0 {name=p162327 lab=_77942_/X }
C {devices/lab_pin.sym} 163710 -37570 0 1 {name=p162328 lab=_82093_/D }
C {sky130_stdcells/dfxtp_4.sym} 163620 -37560 0 0 {name=X_82137_ }
C {devices/lab_pin.sym} 163560 -37440 0 0 {name=p162329 lab=_55093_/A }
C {devices/lab_pin.sym} 163560 -37400 0 0 {name=p162330 lab=_47752_/A }
C {devices/lab_pin.sym} 163680 -37420 0 1 {name=p162331 lab=_55085_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -37420 0 0 {name=X_55085_ }
C {devices/lab_pin.sym} 163560 -37300 0 0 {name=p162332 lab=_59962_/A }
C {devices/lab_pin.sym} 163560 -37260 0 0 {name=p162333 lab=_64386_/A }
C {devices/lab_pin.sym} 163680 -37280 0 1 {name=p162334 lab=_59962_/X }
C {sky130_stdcells/and2_4.sym} 163620 -37280 0 0 {name=X_59962_ }
C {devices/lab_pin.sym} 163580 -37150 0 0 {name=p162335 lab=_52214_/A }
C {devices/lab_pin.sym} 163660 -37150 0 1 {name=p162336 lab=_52297_/X }
C {sky130_stdcells/buf_2.sym} 163620 -37150 0 0 {name=X_52297_ }
C {devices/lab_pin.sym} 163530 -37030 0 0 {name=p162337 lab=_87235_/CLK }
C {devices/lab_pin.sym} 163530 -37010 0 0 {name=p162338 lab=_42181_/X }
C {devices/lab_pin.sym} 163710 -37030 0 1 {name=p162339 lab=_87994_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -37020 0 0 {name=X_87994_ }
C {devices/lab_pin.sym} 163580 -36890 0 0 {name=p162340 lab=_88057_/Q }
C {devices/lab_pin.sym} 163660 -36890 0 1 {name=p162341 lab=_42050_/Y }
C {sky130_stdcells/inv_2.sym} 163620 -36890 0 0 {name=X_42050_ }
C {devices/lab_pin.sym} 163540 -36790 0 0 {name=p162342 lab=_58835_/X }
C {devices/lab_pin.sym} 163540 -36750 0 0 {name=p162343 lab=_85446_/Q }
C {devices/lab_pin.sym} 163540 -36710 0 0 {name=p162344 lab=_58912_/X }
C {devices/lab_pin.sym} 163700 -36750 0 1 {name=p162345 lab=_58913_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -36750 0 0 {name=X_58913_ }
C {devices/lab_pin.sym} 163580 -36610 0 0 {name=p162346 lab=_54295_/A }
C {devices/lab_pin.sym} 163660 -36610 0 1 {name=p162347 lab=_54037_/A }
C {sky130_stdcells/buf_2.sym} 163620 -36610 0 0 {name=X_54036_ }
C {devices/lab_pin.sym} 163540 -36510 0 0 {name=p162348 lab=_51245_/Y }
C {devices/lab_pin.sym} 163540 -36470 0 0 {name=p162349 lab=_51237_/X }
C {devices/lab_pin.sym} 163540 -36430 0 0 {name=p162350 lab=_51247_/X }
C {devices/lab_pin.sym} 163700 -36470 0 1 {name=p162351 lab=_51248_/Y }
C {sky130_stdcells/a21oi_4.sym} 163620 -36470 0 0 {name=X_51248_ }
C {devices/lab_pin.sym} 163540 -36350 0 0 {name=p162352 lab=_69922_/X }
C {devices/lab_pin.sym} 163540 -36310 0 0 {name=p162353 lab=_69924_/X }
C {devices/lab_pin.sym} 163540 -36270 0 0 {name=p162354 lab=_68400_/X }
C {devices/lab_pin.sym} 163700 -36310 0 1 {name=p162355 lab=_70082_/Y }
C {sky130_stdcells/a21oi_4.sym} 163620 -36310 0 0 {name=X_70082_ }
C {devices/lab_pin.sym} 163530 -36170 0 0 {name=p162356 lab=_88398_/CLK }
C {devices/lab_pin.sym} 163530 -36150 0 0 {name=p162357 lab=_86945_/D }
C {devices/lab_pin.sym} 163710 -36170 0 1 {name=p162358 lab=_86945_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -36160 0 0 {name=X_86945_ }
C {devices/lab_pin.sym} 163530 -36030 0 0 {name=p162359 lab=_81160_/CLK }
C {devices/lab_pin.sym} 163530 -36010 0 0 {name=p162360 lab=_84028_/Q }
C {devices/lab_pin.sym} 163710 -36030 0 1 {name=p162361 lab=_82068_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -36020 0 0 {name=X_82068_ }
C {devices/lab_pin.sym} 163560 -35910 0 0 {name=p162362 lab=_59622_/A }
C {devices/lab_pin.sym} 163560 -35870 0 0 {name=p162363 lab=_59570_/A }
C {devices/lab_pin.sym} 163560 -35830 0 0 {name=p162364 lab=_59893_/C }
C {devices/lab_pin.sym} 163680 -35870 0 1 {name=p162365 lab=_60165_/A }
C {sky130_stdcells/nor3_4.sym} 163620 -35870 0 0 {name=X_59893_ }
C {devices/lab_pin.sym} 163580 -35730 0 0 {name=p162366 lab=_40413_/X }
C {devices/lab_pin.sym} 163660 -35730 0 1 {name=p162367 lab=_41007_/A }
C {sky130_stdcells/buf_2.sym} 163620 -35730 0 0 {name=X_41001_ }
C {devices/lab_pin.sym} 163560 -35620 0 0 {name=p162368 lab=_73910_/A }
C {devices/lab_pin.sym} 163560 -35580 0 0 {name=p162369 lab=_73910_/B }
C {devices/lab_pin.sym} 163680 -35600 0 1 {name=p162370 lab=_73911_/B }
C {sky130_stdcells/nand2_4.sym} 163620 -35600 0 0 {name=X_73910_ }
C {devices/lab_pin.sym} 163530 -35470 0 0 {name=p162371 lab=_81019_/CLK }
C {devices/lab_pin.sym} 163530 -35450 0 0 {name=p162372 lab=_84227_/Q }
C {devices/lab_pin.sym} 163710 -35470 0 1 {name=p162373 lab=_81019_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -35460 0 0 {name=X_81019_ }
C {devices/lab_pin.sym} 163540 -35350 0 0 {name=p162374 lab=_58756_/X }
C {devices/lab_pin.sym} 163540 -35310 0 0 {name=p162375 lab=_85931_/Q }
C {devices/lab_pin.sym} 163540 -35270 0 0 {name=p162376 lab=_58793_/X }
C {devices/lab_pin.sym} 163700 -35310 0 1 {name=p162377 lab=_58844_/X }
C {sky130_stdcells/o21a_4.sym} 163620 -35310 0 0 {name=X_58844_ }
C {devices/lab_pin.sym} 163580 -35170 0 0 {name=p162378 lab=clkbuf_4_7_0_CLK/A }
C {devices/lab_pin.sym} 163660 -35170 0 1 {name=p162379 lab=clkbuf_4_6_1_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 163620 -35170 0 0 {name=Xclkbuf_4_6_0_CLK }
C {devices/lab_pin.sym} 163560 -35060 0 0 {name=p162380 lab=_51167_/A }
C {devices/lab_pin.sym} 163560 -35020 0 0 {name=p162381 lab=_52869_/B }
C {devices/lab_pin.sym} 163680 -35040 0 1 {name=p162382 lab=_51179_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -35040 0 0 {name=X_51179_ }
C {devices/lab_pin.sym} 163530 -34910 0 0 {name=p162383 lab=_86878_/CLK }
C {devices/lab_pin.sym} 163530 -34890 0 0 {name=p162384 lab=_45454_/Y }
C {devices/lab_pin.sym} 163710 -34910 0 1 {name=p162385 lab=_63041_/B }
C {sky130_stdcells/dfxtp_4.sym} 163620 -34900 0 0 {name=X_86876_ }
C {devices/lab_pin.sym} 163560 -34780 0 0 {name=p162386 lab=_80936_/Q }
C {devices/lab_pin.sym} 163560 -34740 0 0 {name=p162387 lab=_74890_/B }
C {devices/lab_pin.sym} 163680 -34760 0 1 {name=p162388 lab=_74890_/X }
C {sky130_stdcells/xor2_4.sym} 163620 -34760 0 0 {name=X_74890_ }
C {devices/lab_pin.sym} 163540 -34650 0 0 {name=p162389 lab=_70099_/Y }
C {devices/lab_pin.sym} 163540 -34610 0 0 {name=p162390 lab=_73818_/X }
C {devices/lab_pin.sym} 163540 -34570 0 0 {name=p162391 lab=_73840_/X }
C {devices/lab_pin.sym} 163700 -34610 0 1 {name=p162392 lab=_73841_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -34610 0 0 {name=X_73841_ }
C {devices/lab_pin.sym} 163530 -34470 0 0 {name=p162393 lab=_86749_/CLK }
C {devices/lab_pin.sym} 163530 -34450 0 0 {name=p162394 lab=_85827_/D }
C {devices/lab_pin.sym} 163710 -34470 0 1 {name=p162395 lab=_65384_/B }
C {sky130_stdcells/dfxtp_4.sym} 163620 -34460 0 0 {name=X_85827_ }
C {devices/lab_pin.sym} 163560 -34340 0 0 {name=p162396 lab=_58763_/A }
C {devices/lab_pin.sym} 163560 -34300 0 0 {name=p162397 lab=_86385_/Q }
C {devices/lab_pin.sym} 163680 -34320 0 1 {name=p162398 lab=_58775_/Y }
C {sky130_stdcells/nor2_4.sym} 163620 -34320 0 0 {name=X_58775_ }
C {devices/lab_pin.sym} 163580 -34190 0 0 {name=p162399 lab=_55986_/X }
C {devices/lab_pin.sym} 163660 -34190 0 1 {name=p162400 lab=_55987_/X }
C {sky130_stdcells/buf_2.sym} 163620 -34190 0 0 {name=X_55987_ }
C {devices/lab_pin.sym} 163560 -34080 0 0 {name=p162401 lab=_85003_/Q }
C {devices/lab_pin.sym} 163560 -34040 0 0 {name=p162402 lab=_45740_/B }
C {devices/lab_pin.sym} 163680 -34060 0 1 {name=p162403 lab=_45740_/Y }
C {sky130_stdcells/nor2_4.sym} 163620 -34060 0 0 {name=X_45740_ }
C {devices/lab_pin.sym} 163580 -33930 0 0 {name=p162404 lab=_57708_/X }
C {devices/lab_pin.sym} 163660 -33930 0 1 {name=p162405 lab=_57726_/X }
C {sky130_stdcells/buf_2.sym} 163620 -33930 0 0 {name=X_57726_ }
C {devices/lab_pin.sym} 163560 -33830 0 0 {name=p162406 lab=_76554_/X }
C {devices/lab_pin.sym} 163560 -33790 0 0 {name=p162407 lab=_76560_/B }
C {devices/lab_pin.sym} 163560 -33750 0 0 {name=p162408 lab=_76555_/Y }
C {devices/lab_pin.sym} 163680 -33790 0 1 {name=p162409 lab=_76560_/Y }
C {sky130_stdcells/nand3_4.sym} 163620 -33790 0 0 {name=X_76560_ }
C {devices/lab_pin.sym} 163540 -33670 0 0 {name=p162410 lab=_54935_/Y }
C {devices/lab_pin.sym} 163540 -33630 0 0 {name=p162411 lab=_54936_/X }
C {devices/lab_pin.sym} 163540 -33590 0 0 {name=p162412 lab=_54937_/X }
C {devices/lab_pin.sym} 163700 -33630 0 1 {name=p162413 lab=_54938_/Y }
C {sky130_stdcells/a21oi_4.sym} 163620 -33630 0 0 {name=X_54938_ }
C {devices/lab_pin.sym} 163540 -33520 0 0 {name=p162414 lab=_41797_/X }
C {devices/lab_pin.sym} 163540 -33480 0 0 {name=p162415 lab=_42950_/X }
C {devices/lab_pin.sym} 163540 -33440 0 0 {name=p162416 lab=_66567_/B }
C {devices/lab_pin.sym} 163540 -33400 0 0 {name=p162417 lab=_42951_/X }
C {devices/lab_pin.sym} 163700 -33460 0 1 {name=p162418 lab=_87635_/D }
C {sky130_stdcells/a2bb2o_4.sym} 163620 -33460 0 0 {name=X_42952_ }
C {devices/lab_pin.sym} 163580 -33310 0 0 {name=p162419 lab=_56934_/X }
C {devices/lab_pin.sym} 163660 -33310 0 1 {name=p162420 lab=_73772_/X }
C {sky130_stdcells/buf_2.sym} 163620 -33310 0 0 {name=X_73772_ }
C {devices/lab_pin.sym} 163530 -33190 0 0 {name=p162421 lab=_85761_/CLK }
C {devices/lab_pin.sym} 163530 -33170 0 0 {name=p162422 lab=_52772_/Y }
C {devices/lab_pin.sym} 163710 -33190 0 1 {name=p162423 lab=_85758_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -33180 0 0 {name=X_85758_ }
C {devices/lab_pin.sym} 163580 -33050 0 0 {name=p162424 lab=_70984_/A }
C {devices/lab_pin.sym} 163660 -33050 0 1 {name=p162425 lab=_71073_/B }
C {sky130_stdcells/buf_2.sym} 163620 -33050 0 0 {name=X_70984_ }
C {devices/lab_pin.sym} 163580 -32930 0 0 {name=p162426 lab=_75510_/X }
C {devices/lab_pin.sym} 163660 -32930 0 1 {name=p162427 lab=_75511_/Y }
C {sky130_stdcells/inv_2.sym} 163620 -32930 0 0 {name=X_75511_ }
C {devices/lab_pin.sym} 163580 -32810 0 0 {name=p162428 lab=_41902_/X }
C {devices/lab_pin.sym} 163660 -32810 0 1 {name=p162429 lab=_50638_/A }
C {sky130_stdcells/buf_2.sym} 163620 -32810 0 0 {name=X_41903_ }
C {devices/lab_pin.sym} 163580 -32690 0 0 {name=p162430 lab=_72722_/X }
C {devices/lab_pin.sym} 163660 -32690 0 1 {name=p162431 lab=_72723_/X }
C {sky130_stdcells/buf_2.sym} 163620 -32690 0 0 {name=X_72723_ }
C {devices/lab_pin.sym} 163530 -32570 0 0 {name=p162432 lab=_84329_/CLK }
C {devices/lab_pin.sym} 163530 -32550 0 0 {name=p162433 lab=_59712_/Y }
C {devices/lab_pin.sym} 163710 -32570 0 1 {name=p162434 lab=_80579_/A }
C {sky130_stdcells/dfxtp_4.sym} 163620 -32560 0 0 {name=X_84709_ }
C {devices/lab_pin.sym} 163540 -32450 0 0 {name=p162435 lab=_45664_/X }
C {devices/lab_pin.sym} 163540 -32410 0 0 {name=p162436 lab=_45667_/X }
C {devices/lab_pin.sym} 163540 -32370 0 0 {name=p162437 lab=_45670_/Y }
C {devices/lab_pin.sym} 163700 -32410 0 1 {name=p162438 lab=_45671_/Y }
C {sky130_stdcells/a21oi_4.sym} 163620 -32410 0 0 {name=X_45671_ }
C {devices/lab_pin.sym} 163560 -32280 0 0 {name=p162439 lab=_57656_/X }
C {devices/lab_pin.sym} 163560 -32240 0 0 {name=p162440 lab=_57657_/B }
C {devices/lab_pin.sym} 163680 -32260 0 1 {name=p162441 lab=_57657_/Y }
C {sky130_stdcells/nor2_4.sym} 163620 -32260 0 0 {name=X_57657_ }
C {devices/lab_pin.sym} 163560 -32150 0 0 {name=p162442 lab=_76487_/Y }
C {devices/lab_pin.sym} 163560 -32110 0 0 {name=p162443 lab=_76491_/B }
C {devices/lab_pin.sym} 163560 -32070 0 0 {name=p162444 lab=_76491_/C }
C {devices/lab_pin.sym} 163680 -32110 0 1 {name=p162445 lab=_76491_/X }
C {sky130_stdcells/or3_4.sym} 163620 -32110 0 0 {name=X_76491_ }
C {devices/lab_pin.sym} 163580 -31970 0 0 {name=p162446 lab=_42883_/A }
C {devices/lab_pin.sym} 163660 -31970 0 1 {name=p162447 lab=_42883_/Y }
C {sky130_stdcells/inv_2.sym} 163620 -31970 0 0 {name=X_42883_ }
C {devices/lab_pin.sym} 163560 -31880 0 0 {name=p162448 lab=_54883_/A }
C {devices/lab_pin.sym} 163560 -31840 0 0 {name=p162449 lab=_54857_/B }
C {devices/lab_pin.sym} 163560 -31800 0 0 {name=p162450 lab=_54883_/C }
C {devices/lab_pin.sym} 163560 -31760 0 0 {name=p162451 lab=_53177_/D }
C {devices/lab_pin.sym} 163680 -31820 0 1 {name=p162452 lab=_54869_/X }
C {sky130_stdcells/and4_4.sym} 163620 -31820 0 0 {name=X_54869_ }
C {devices/lab_pin.sym} 163530 -31670 0 0 {name=p162453 lab=_85688_/CLK }
C {devices/lab_pin.sym} 163530 -31650 0 0 {name=p162454 lab=_53145_/Y }
C {devices/lab_pin.sym} 163710 -31670 0 1 {name=p162455 lab=_85689_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -31660 0 0 {name=X_85689_ }
C {devices/lab_pin.sym} 163580 -31530 0 0 {name=p162456 lab=_47410_/A }
C {devices/lab_pin.sym} 163660 -31530 0 1 {name=p162457 lab=_47411_/A }
C {sky130_stdcells/inv_2.sym} 163620 -31530 0 0 {name=X_47410_ }
C {devices/lab_pin.sym} 163560 -31420 0 0 {name=p162458 lab=_78230_/A }
C {devices/lab_pin.sym} 163560 -31380 0 0 {name=p162459 lab=_78229_/Y }
C {devices/lab_pin.sym} 163680 -31400 0 1 {name=p162460 lab=_78231_/B }
C {sky130_stdcells/xnor2_4.sym} 163620 -31400 0 0 {name=X_78230_ }
C {devices/lab_pin.sym} 163580 -31270 0 0 {name=p162461 lab=_44679_/A }
C {devices/lab_pin.sym} 163660 -31270 0 1 {name=p162462 lab=_44622_/X }
C {sky130_stdcells/buf_2.sym} 163620 -31270 0 0 {name=X_44622_ }
C {devices/lab_pin.sym} 163540 -31180 0 0 {name=p162463 lab=_56587_/X }
C {devices/lab_pin.sym} 163540 -31140 0 0 {name=p162464 lab=_56607_/X }
C {devices/lab_pin.sym} 163540 -31100 0 0 {name=p162465 lab=_85146_/Q }
C {devices/lab_pin.sym} 163540 -31060 0 0 {name=p162466 lab=_56590_/X }
C {devices/lab_pin.sym} 163700 -31120 0 1 {name=p162467 lab=_85146_/D }
C {sky130_stdcells/a2bb2o_4.sym} 163620 -31120 0 0 {name=X_56608_ }
C {devices/lab_pin.sym} 163580 -30970 0 0 {name=p162468 lab=_81083_/Q }
C {devices/lab_pin.sym} 163660 -30970 0 1 {name=p162469 lab=_75442_/Y }
C {sky130_stdcells/inv_2.sym} 163620 -30970 0 0 {name=X_75442_ }
C {devices/lab_pin.sym} 163580 -30850 0 0 {name=p162470 lab=_41834_/A }
C {devices/lab_pin.sym} 163660 -30850 0 1 {name=p162471 lab=_88130_/D }
C {sky130_stdcells/inv_2.sym} 163620 -30850 0 0 {name=X_41834_ }
C {devices/lab_pin.sym} 163530 -30730 0 0 {name=p162472 lab=_87684_/CLK }
C {devices/lab_pin.sym} 163530 -30710 0 0 {name=p162473 lab=_87428_/D }
C {devices/lab_pin.sym} 163710 -30730 0 1 {name=p162474 lab=_87428_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -30720 0 0 {name=X_87428_ }
C {devices/lab_pin.sym} 163580 -30590 0 0 {name=p162475 lab=_83590_/Q }
C {devices/lab_pin.sym} 163660 -30590 0 1 {name=p162476 lab=_48391_/A }
C {sky130_stdcells/inv_2.sym} 163620 -30590 0 0 {name=X_48390_ }
C {devices/lab_pin.sym} 163560 -30490 0 0 {name=p162477 lab=_72656_/A }
C {devices/lab_pin.sym} 163560 -30450 0 0 {name=p162478 lab=_72656_/B }
C {devices/lab_pin.sym} 163560 -30410 0 0 {name=p162479 lab=_72654_/C }
C {devices/lab_pin.sym} 163680 -30450 0 1 {name=p162480 lab=_72654_/Y }
C {sky130_stdcells/nand3_4.sym} 163620 -30450 0 0 {name=X_72654_ }
C {devices/lab_pin.sym} 163560 -30330 0 0 {name=p162481 lab=_48036_/A }
C {devices/lab_pin.sym} 163560 -30290 0 0 {name=p162482 lab=_57619_/B }
C {devices/lab_pin.sym} 163560 -30250 0 0 {name=p162483 lab=_71960_/C }
C {devices/lab_pin.sym} 163680 -30290 0 1 {name=p162484 lab=_57588_/X }
C {sky130_stdcells/and3_4.sym} 163620 -30290 0 0 {name=X_57588_ }
C {devices/lab_pin.sym} 163560 -30180 0 0 {name=p162485 lab=_47380_/A }
C {devices/lab_pin.sym} 163560 -30140 0 0 {name=p162486 lab=_47349_/B }
C {devices/lab_pin.sym} 163560 -30100 0 0 {name=p162487 lab=_47370_/C }
C {devices/lab_pin.sym} 163560 -30060 0 0 {name=p162488 lab=_52993_/D }
C {devices/lab_pin.sym} 163680 -30120 0 1 {name=p162489 lab=_47341_/X }
C {sky130_stdcells/and4_4.sym} 163620 -30120 0 0 {name=X_47341_ }
C {devices/lab_pin.sym} 163560 -29980 0 0 {name=p162490 lab=_59326_/X }
C {devices/lab_pin.sym} 163560 -29940 0 0 {name=p162491 lab=_59327_/B }
C {devices/lab_pin.sym} 163680 -29960 0 1 {name=p162492 lab=_59327_/Y }
C {sky130_stdcells/nor2_4.sym} 163620 -29960 0 0 {name=X_59327_ }
C {devices/lab_pin.sym} 163580 -29830 0 0 {name=p162493 lab=_71602_/C }
C {devices/lab_pin.sym} 163660 -29830 0 1 {name=p162494 lab=_71690_/A }
C {sky130_stdcells/buf_2.sym} 163620 -29830 0 0 {name=X_71605_ }
C {devices/lab_pin.sym} 163560 -29720 0 0 {name=p162495 lab=_78161_/A }
C {devices/lab_pin.sym} 163560 -29680 0 0 {name=p162496 lab=_82862_/D }
C {devices/lab_pin.sym} 163680 -29700 0 1 {name=p162497 lab=_78167_/A }
C {sky130_stdcells/xor2_4.sym} 163620 -29700 0 0 {name=X_78161_ }
C {devices/lab_pin.sym} 163540 -29590 0 0 {name=p162498 lab=_56159_/X }
C {devices/lab_pin.sym} 163540 -29550 0 0 {name=p162499 lab=_56528_/X }
C {devices/lab_pin.sym} 163540 -29510 0 0 {name=p162500 lab=_56538_/Y }
C {devices/lab_pin.sym} 163700 -29550 0 1 {name=p162501 lab=_85157_/D }
C {sky130_stdcells/o21ai_4.sym} 163620 -29550 0 0 {name=X_56539_ }
C {devices/lab_pin.sym} 163580 -29410 0 0 {name=p162502 lab=_44552_/Y }
C {devices/lab_pin.sym} 163660 -29410 0 1 {name=p162503 lab=_44553_/Y }
C {sky130_stdcells/inv_2.sym} 163620 -29410 0 0 {name=X_44553_ }
C {devices/lab_pin.sym} 163560 -29300 0 0 {name=p162504 lab=_80694_/Q }
C {devices/lab_pin.sym} 163560 -29260 0 0 {name=p162505 lab=_80950_/D }
C {devices/lab_pin.sym} 163680 -29280 0 1 {name=p162506 lab=_75373_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -29280 0 0 {name=X_75373_ }
C {devices/lab_pin.sym} 163530 -29150 0 0 {name=p162507 lab=_86784_/CLK }
C {devices/lab_pin.sym} 163530 -29130 0 0 {name=p162508 lab=_43565_/Y }
C {devices/lab_pin.sym} 163710 -29150 0 1 {name=p162509 lab=_87359_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -29140 0 0 {name=X_87359_ }
C {devices/lab_pin.sym} 163580 -29010 0 0 {name=p162510 lab=_40736_/A }
C {devices/lab_pin.sym} 163660 -29010 0 1 {name=p162511 lab=_46240_/A }
C {sky130_stdcells/buf_2.sym} 163620 -29010 0 0 {name=X_41765_ }
C {devices/lab_pin.sym} 163580 -28890 0 0 {name=p162512 lab=_72585_/A }
C {devices/lab_pin.sym} 163660 -28890 0 1 {name=p162513 lab=_72585_/Y }
C {sky130_stdcells/inv_2.sym} 163620 -28890 0 0 {name=X_72585_ }
C {devices/lab_pin.sym} 163560 -28790 0 0 {name=p162514 lab=_77112_/A }
C {devices/lab_pin.sym} 163560 -28750 0 0 {name=p162515 lab=_77106_/A }
C {devices/lab_pin.sym} 163560 -28710 0 0 {name=p162516 lab=_77112_/C }
C {devices/lab_pin.sym} 163680 -28750 0 1 {name=p162517 lab=_77113_/B }
C {sky130_stdcells/and3_4.sym} 163620 -28750 0 0 {name=X_77112_ }
C {devices/lab_pin.sym} 163540 -28650 0 0 {name=p162518 lab=_43495_/X }
C {devices/lab_pin.sym} 163540 -28610 0 0 {name=p162519 lab=_43503_/X }
C {devices/lab_pin.sym} 163540 -28570 0 0 {name=p162520 lab=_41757_/X }
C {devices/lab_pin.sym} 163540 -28530 0 0 {name=p162521 lab=_87387_/Q }
C {devices/lab_pin.sym} 163540 -28490 0 0 {name=p162522 lab=_43479_/X }
C {devices/lab_pin.sym} 163700 -28570 0 1 {name=p162523 lab=_43505_/A }
C {sky130_stdcells/o32ai_4.sym} 163620 -28570 0 0 {name=X_43504_ }
C {devices/lab_pin.sym} 163540 -28430 0 0 {name=p162524 lab=_83098_/Q }
C {devices/lab_pin.sym} 163540 -28390 0 0 {name=p162525 lab=_74314_/X }
C {devices/lab_pin.sym} 163540 -28350 0 0 {name=p162526 lab=_74323_/Y }
C {devices/lab_pin.sym} 163700 -28390 0 1 {name=p162527 lab=_83098_/D }
C {sky130_stdcells/a21bo_4.sym} 163620 -28390 0 0 {name=X_74324_ }
C {devices/lab_pin.sym} 163580 -28250 0 0 {name=p162528 lab=_40716_/A }
C {devices/lab_pin.sym} 163660 -28250 0 1 {name=p162529 lab=_40716_/X }
C {sky130_stdcells/buf_2.sym} 163620 -28250 0 0 {name=X_40716_ }
C {devices/lab_pin.sym} 163580 -28130 0 0 {name=p162530 lab=_47130_/A }
C {devices/lab_pin.sym} 163660 -28130 0 1 {name=p162531 lab=_47311_/B }
C {sky130_stdcells/buf_2.sym} 163620 -28130 0 0 {name=X_47272_ }
C {devices/lab_pin.sym} 163580 -28010 0 0 {name=p162532 lab=_58923_/A }
C {devices/lab_pin.sym} 163660 -28010 0 1 {name=p162533 lab=_59258_/X }
C {sky130_stdcells/buf_2.sym} 163620 -28010 0 0 {name=X_59258_ }
C {devices/lab_pin.sym} 163580 -27890 0 0 {name=p162534 lab=_71536_/A }
C {devices/lab_pin.sym} 163660 -27890 0 1 {name=p162535 lab=_71546_/C }
C {sky130_stdcells/buf_2.sym} 163620 -27890 0 0 {name=X_71536_ }
C {devices/lab_pin.sym} 163560 -27780 0 0 {name=p162536 lab=_82563_/Q }
C {devices/lab_pin.sym} 163560 -27740 0 0 {name=p162537 lab=_78091_/B }
C {devices/lab_pin.sym} 163680 -27760 0 1 {name=p162538 lab=_78092_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -27760 0 0 {name=X_78092_ }
C {devices/lab_pin.sym} 163580 -27630 0 0 {name=p162539 lab=_44549_/A }
C {devices/lab_pin.sym} 163660 -27630 0 1 {name=p162540 lab=_44484_/X }
C {sky130_stdcells/buf_2.sym} 163620 -27630 0 0 {name=X_44484_ }
C {devices/lab_pin.sym} 163540 -27530 0 0 {name=p162541 lab=_41659_/X }
C {devices/lab_pin.sym} 163540 -27490 0 0 {name=p162542 lab=_41350_/A }
C {devices/lab_pin.sym} 163540 -27450 0 0 {name=p162543 lab=_41695_/X }
C {devices/lab_pin.sym} 163700 -27490 0 1 {name=p162544 lab=_41697_/A }
C {sky130_stdcells/o21ai_4.sym} 163620 -27490 0 0 {name=X_41696_ }
C {devices/lab_pin.sym} 163580 -27350 0 0 {name=p162545 lab=_52328_/B }
C {devices/lab_pin.sym} 163660 -27350 0 1 {name=p162546 lab=_53844_/B }
C {sky130_stdcells/buf_2.sym} 163620 -27350 0 0 {name=X_49011_ }
C {devices/lab_pin.sym} 163580 -27230 0 0 {name=p162547 lab=_58547_/A }
C {devices/lab_pin.sym} 163660 -27230 0 1 {name=p162548 lab=_58151_/A }
C {sky130_stdcells/buf_2.sym} 163620 -27230 0 0 {name=X_46223_ }
C {devices/lab_pin.sym} 163580 -27110 0 0 {name=p162549 lab=_83371_/Q }
C {devices/lab_pin.sym} 163660 -27110 0 1 {name=p162550 lab=_58209_/Y }
C {sky130_stdcells/inv_2.sym} 163620 -27110 0 0 {name=X_58209_ }
C {sky130_stdcells/decap_3.sym} 163620 -26960 0 0 {name=XPHY_350 }
C {devices/lab_pin.sym} 163580 -26810 0 0 {name=p162551 lab=_77042_/X }
C {devices/lab_pin.sym} 163660 -26810 0 1 {name=p162552 lab=_77044_/B }
C {sky130_stdcells/buf_2.sym} 163620 -26810 0 0 {name=X_77043_ }
C {devices/lab_pin.sym} 163540 -26730 0 0 {name=p162553 lab=_43422_/X }
C {devices/lab_pin.sym} 163540 -26690 0 0 {name=p162554 lab=_43426_/X }
C {devices/lab_pin.sym} 163540 -26650 0 0 {name=p162555 lab=_41565_/X }
C {devices/lab_pin.sym} 163540 -26610 0 0 {name=p162556 lab=_87423_/Q }
C {devices/lab_pin.sym} 163540 -26570 0 0 {name=p162557 lab=_43434_/X }
C {devices/lab_pin.sym} 163700 -26650 0 1 {name=p162558 lab=_43435_/Y }
C {sky130_stdcells/o32ai_4.sym} 163620 -26650 0 0 {name=X_43435_ }
C {devices/lab_pin.sym} 163540 -26510 0 0 {name=p162559 lab=_74252_/X }
C {devices/lab_pin.sym} 163540 -26470 0 0 {name=p162560 lab=_74254_/X }
C {devices/lab_pin.sym} 163540 -26430 0 0 {name=p162561 lab=_74019_/X }
C {devices/lab_pin.sym} 163700 -26470 0 1 {name=p162562 lab=_74258_/A }
C {sky130_stdcells/a21o_4.sym} 163620 -26470 0 0 {name=X_74255_ }
C {sky130_stdcells/decap_3.sym} 163620 -26300 0 0 {name=XPHY_361 }
C {devices/lab_pin.sym} 163540 -26180 0 0 {name=p162563 lab=_40646_/X }
C {devices/lab_pin.sym} 163540 -26140 0 0 {name=p162564 lab=_40596_/X }
C {devices/lab_pin.sym} 163540 -26100 0 0 {name=p162565 lab=_88361_/Q }
C {devices/lab_pin.sym} 163540 -26060 0 0 {name=p162566 lab=_40599_/X }
C {devices/lab_pin.sym} 163700 -26120 0 1 {name=p162567 lab=_88361_/D }
C {sky130_stdcells/a2bb2o_4.sym} 163620 -26120 0 0 {name=X_40647_ }
C {devices/lab_pin.sym} 163560 -25980 0 0 {name=p162568 lab=_59189_/A }
C {devices/lab_pin.sym} 163560 -25940 0 0 {name=p162569 lab=_59189_/B }
C {devices/lab_pin.sym} 163680 -25960 0 1 {name=p162570 lab=_59189_/Y }
C {sky130_stdcells/nor2_4.sym} 163620 -25960 0 0 {name=X_59189_ }
C {devices/lab_pin.sym} 163540 -25850 0 0 {name=p162571 lab=_71464_/X }
C {devices/lab_pin.sym} 163540 -25810 0 0 {name=p162572 lab=_83489_/Q }
C {devices/lab_pin.sym} 163540 -25770 0 0 {name=p162573 lab=_71466_/X }
C {devices/lab_pin.sym} 163700 -25810 0 1 {name=p162574 lab=_83489_/D }
C {sky130_stdcells/a21o_4.sym} 163620 -25810 0 0 {name=X_71467_ }
C {sky130_stdcells/decap_3.sym} 163620 -25640 0 0 {name=XPHY_372 }
C {sky130_stdcells/decap_3.sym} 163620 -25460 0 0 {name=XPHY_383 }
C {devices/lab_pin.sym} 163560 -25320 0 0 {name=p162575 lab=_61198_/X }
C {devices/lab_pin.sym} 163560 -25280 0 0 {name=p162576 lab=_61095_/X }
C {devices/lab_pin.sym} 163680 -25300 0 1 {name=p162577 lab=_61220_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -25300 0 0 {name=X_61220_ }
C {devices/lab_pin.sym} 163580 -25170 0 0 {name=p162578 lab=_73352_/A }
C {devices/lab_pin.sym} 163660 -25170 0 1 {name=p162579 lab=_73206_/X }
C {sky130_stdcells/buf_2.sym} 163620 -25170 0 0 {name=X_73206_ }
C {sky130_stdcells/decap_3.sym} 163620 -25020 0 0 {name=XPHY_394 }
C {devices/lab_pin.sym} 163580 -24870 0 0 {name=p162580 lab=HASH_ADDR[2] }
C {devices/lab_pin.sym} 163660 -24870 0 1 {name=p162581 lab=_70495_/A }
C {sky130_stdcells/buf_2.sym} 163620 -24870 0 0 {name=X_70418_ }
C {devices/lab_pin.sym} 163580 -24750 0 0 {name=p162582 lab=_45955_/X }
C {devices/lab_pin.sym} 163660 -24750 0 1 {name=p162583 lab=_46155_/A }
C {sky130_stdcells/buf_2.sym} 163620 -24750 0 0 {name=X_46154_ }
C {devices/lab_pin.sym} 163580 -24630 0 0 {name=p162584 lab=_43366_/A }
C {devices/lab_pin.sym} 163660 -24630 0 1 {name=p162585 lab=_43366_/Y }
C {sky130_stdcells/inv_2.sym} 163620 -24630 0 0 {name=X_43366_ }
C {devices/lab_pin.sym} 163560 -24520 0 0 {name=p162586 lab=_74186_/A }
C {devices/lab_pin.sym} 163560 -24480 0 0 {name=p162587 lab=_74073_/X }
C {devices/lab_pin.sym} 163680 -24500 0 1 {name=p162588 lab=_74186_/Y }
C {sky130_stdcells/nor2_4.sym} 163620 -24500 0 0 {name=X_74186_ }
C {devices/lab_pin.sym} 163580 -24370 0 0 {name=p162589 lab=_40784_/A }
C {devices/lab_pin.sym} 163660 -24370 0 1 {name=p162590 lab=_40654_/B }
C {sky130_stdcells/buf_2.sym} 163620 -24370 0 0 {name=X_40578_ }
C {devices/lab_pin.sym} 163580 -24250 0 0 {name=p162591 lab=_71189_/B }
C {devices/lab_pin.sym} 163660 -24250 0 1 {name=p162592 lab=_71404_/B }
C {sky130_stdcells/buf_2.sym} 163620 -24250 0 0 {name=X_71398_ }
C {devices/lab_pin.sym} 163540 -24150 0 0 {name=p162593 lab=_45101_/Y }
C {devices/lab_pin.sym} 163540 -24110 0 0 {name=p162594 lab=_45104_/Y }
C {devices/lab_pin.sym} 163540 -24070 0 0 {name=p162595 lab=_45063_/X }
C {devices/lab_pin.sym} 163700 -24110 0 1 {name=p162596 lab=_45105_/X }
C {sky130_stdcells/a21o_4.sym} 163620 -24110 0 0 {name=X_45105_ }
C {devices/lab_pin.sym} 163540 -24000 0 0 {name=p162597 lab=_41626_/X }
C {devices/lab_pin.sym} 163540 -23960 0 0 {name=p162598 lab=_42303_/X }
C {devices/lab_pin.sym} 163540 -23920 0 0 {name=p162599 lab=_87924_/Q }
C {devices/lab_pin.sym} 163540 -23880 0 0 {name=p162600 lab=_42305_/X }
C {devices/lab_pin.sym} 163700 -23940 0 1 {name=p162601 lab=_42317_/X }
C {sky130_stdcells/a2bb2o_4.sym} 163620 -23940 0 0 {name=X_42317_ }
C {devices/lab_pin.sym} 163560 -23800 0 0 {name=p162602 lab=_61108_/Y }
C {devices/lab_pin.sym} 163560 -23760 0 0 {name=p162603 lab=_61140_/X }
C {devices/lab_pin.sym} 163680 -23780 0 1 {name=p162604 lab=_61151_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -23780 0 0 {name=X_61151_ }
C {devices/lab_pin.sym} 163540 -23670 0 0 {name=p162605 lab=_73133_/X }
C {devices/lab_pin.sym} 163540 -23630 0 0 {name=p162606 lab=_73136_/X }
C {devices/lab_pin.sym} 163540 -23590 0 0 {name=p162607 lab=_73067_/X }
C {devices/lab_pin.sym} 163700 -23630 0 1 {name=p162608 lab=_73137_/X }
C {sky130_stdcells/a21o_4.sym} 163620 -23630 0 0 {name=X_73137_ }
C {devices/lab_pin.sym} 163580 -23490 0 0 {name=p162609 lab=_46085_/A }
C {devices/lab_pin.sym} 163660 -23490 0 1 {name=p162610 lab=_46089_/A }
C {sky130_stdcells/inv_2.sym} 163620 -23490 0 0 {name=X_46085_ }
C {devices/lab_pin.sym} 163540 -23390 0 0 {name=p162611 lab=_70209_/A }
C {devices/lab_pin.sym} 163540 -23350 0 0 {name=p162612 lab=_74745_/A }
C {devices/lab_pin.sym} 163540 -23310 0 0 {name=p162613 lab=_70348_/X }
C {devices/lab_pin.sym} 163700 -23350 0 1 {name=p162614 lab=_70349_/X }
C {sky130_stdcells/a21o_4.sym} 163620 -23350 0 0 {name=X_70349_ }
C {devices/lab_pin.sym} 163540 -23250 0 0 {name=p162615 lab=_43296_/X }
C {devices/lab_pin.sym} 163540 -23210 0 0 {name=p162616 lab=_43269_/X }
C {devices/lab_pin.sym} 163540 -23170 0 0 {name=p162617 lab=_41193_/X }
C {devices/lab_pin.sym} 163540 -23130 0 0 {name=p162618 lab=_87492_/Q }
C {devices/lab_pin.sym} 163540 -23090 0 0 {name=p162619 lab=_43273_/X }
C {devices/lab_pin.sym} 163700 -23170 0 1 {name=p162620 lab=_43298_/A }
C {sky130_stdcells/o32ai_4.sym} 163620 -23170 0 0 {name=X_43297_ }
C {devices/lab_pin.sym} 163560 -23020 0 0 {name=p162621 lab=_78994_/A }
C {devices/lab_pin.sym} 163560 -22980 0 0 {name=p162622 lab=_78994_/B }
C {devices/lab_pin.sym} 163680 -23000 0 1 {name=p162623 lab=_82710_/D }
C {sky130_stdcells/xor2_4.sym} 163620 -23000 0 0 {name=X_78994_ }
C {devices/lab_pin.sym} 163580 -22870 0 0 {name=p162624 lab=_60102_/A }
C {devices/lab_pin.sym} 163660 -22870 0 1 {name=p162625 lab=_60102_/Y }
C {sky130_stdcells/inv_2.sym} 163620 -22870 0 0 {name=X_60102_ }
C {devices/lab_pin.sym} 163540 -22770 0 0 {name=p162626 lab=_72187_/B }
C {devices/lab_pin.sym} 163540 -22730 0 0 {name=p162627 lab=_49906_/X }
C {devices/lab_pin.sym} 163540 -22690 0 0 {name=p162628 lab=_49912_/Y }
C {devices/lab_pin.sym} 163700 -22730 0 1 {name=p162629 lab=_49913_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -22730 0 0 {name=X_49913_ }
C {devices/lab_pin.sym} 163540 -22610 0 0 {name=p162630 lab=_44975_/X }
C {devices/lab_pin.sym} 163540 -22570 0 0 {name=p162631 lab=_61427_/B }
C {devices/lab_pin.sym} 163540 -22530 0 0 {name=p162632 lab=_44995_/X }
C {devices/lab_pin.sym} 163700 -22570 0 1 {name=p162633 lab=_45036_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -22570 0 0 {name=X_45036_ }
C {devices/lab_pin.sym} 163580 -22430 0 0 {name=p162634 lab=_42258_/A }
C {devices/lab_pin.sym} 163660 -22430 0 1 {name=p162635 lab=_42248_/X }
C {sky130_stdcells/buf_2.sym} 163620 -22430 0 0 {name=X_42248_ }
C {devices/lab_pin.sym} 163580 -22310 0 0 {name=p162636 lab=_61122_/A }
C {devices/lab_pin.sym} 163660 -22310 0 1 {name=p162637 lab=_61082_/X }
C {sky130_stdcells/buf_2.sym} 163620 -22310 0 0 {name=X_61082_ }
C {devices/lab_pin.sym} 163540 -22210 0 0 {name=p162638 lab=_73064_/X }
C {devices/lab_pin.sym} 163540 -22170 0 0 {name=p162639 lab=_73066_/X }
C {devices/lab_pin.sym} 163540 -22130 0 0 {name=p162640 lab=_73067_/X }
C {devices/lab_pin.sym} 163700 -22170 0 1 {name=p162641 lab=_73068_/X }
C {sky130_stdcells/a21o_4.sym} 163620 -22170 0 0 {name=X_73068_ }
C {devices/lab_pin.sym} 163560 -22040 0 0 {name=p162642 lab=_77928_/A }
C {devices/lab_pin.sym} 163560 -22000 0 0 {name=p162643 lab=_77941_/A }
C {devices/lab_pin.sym} 163680 -22020 0 1 {name=p162644 lab=_77945_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -22020 0 0 {name=X_77945_ }
C {devices/lab_pin.sym} 163540 -21920 0 0 {name=p162645 lab=_64809_/X }
C {devices/lab_pin.sym} 163540 -21880 0 0 {name=p162646 lab=_83302_/Q }
C {devices/lab_pin.sym} 163540 -21840 0 0 {name=p162647 lab=_64864_/X }
C {devices/lab_pin.sym} 163540 -21800 0 0 {name=p162648 lab=_64909_/X }
C {devices/lab_pin.sym} 163700 -21860 0 1 {name=p162649 lab=_64910_/X }
C {sky130_stdcells/a211o_4.sym} 163620 -21860 0 0 {name=X_64910_ }
C {devices/lab_pin.sym} 163540 -21730 0 0 {name=p162650 lab=_83301_/Q }
C {devices/lab_pin.sym} 163540 -21690 0 0 {name=p162651 lab=_72016_/X }
C {devices/lab_pin.sym} 163540 -21650 0 0 {name=p162652 lab=_72018_/Y }
C {devices/lab_pin.sym} 163700 -21690 0 1 {name=p162653 lab=_72019_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -21690 0 0 {name=X_72019_ }
C {devices/lab_pin.sym} 163540 -21590 0 0 {name=p162654 lab=_60028_/Y }
C {devices/lab_pin.sym} 163540 -21550 0 0 {name=p162655 lab=_59974_/Y }
C {devices/lab_pin.sym} 163540 -21510 0 0 {name=p162656 lab=_60030_/Y }
C {devices/lab_pin.sym} 163540 -21470 0 0 {name=p162657 lab=_60031_/X }
C {devices/lab_pin.sym} 163540 -21440 0 0 {name=p162658 lab=_60032_/Y }
C {devices/lab_pin.sym} 163700 -21510 0 1 {name=p162659 lab=_84673_/D }
C {sky130_stdcells/a41oi_4.sym} 163620 -21510 0 0 {name=X_60033_ }
C {devices/lab_pin.sym} 163580 -21350 0 0 {name=p162660 lab=_49924_/A }
C {devices/lab_pin.sym} 163660 -21350 0 1 {name=p162661 lab=_49844_/X }
C {sky130_stdcells/buf_2.sym} 163620 -21350 0 0 {name=X_49844_ }
C {devices/lab_pin.sym} 163540 -21270 0 0 {name=p162662 lab=_42173_/X }
C {devices/lab_pin.sym} 163540 -21230 0 0 {name=p162663 lab=_42169_/X }
C {devices/lab_pin.sym} 163540 -21190 0 0 {name=p162664 lab=_41245_/X }
C {devices/lab_pin.sym} 163540 -21150 0 0 {name=p162665 lab=_87995_/Q }
C {devices/lab_pin.sym} 163540 -21110 0 0 {name=p162666 lab=_42170_/X }
C {devices/lab_pin.sym} 163700 -21190 0 1 {name=p162667 lab=_42180_/A }
C {sky130_stdcells/o32ai_4.sym} 163620 -21190 0 0 {name=X_42179_ }
C {devices/lab_pin.sym} 163560 -21040 0 0 {name=p162668 lab=_65804_/A }
C {devices/lab_pin.sym} 163560 -21000 0 0 {name=p162669 lab=_65890_/B }
C {devices/lab_pin.sym} 163680 -21020 0 1 {name=p162670 lab=_65890_/X }
C {sky130_stdcells/and2_4.sym} 163620 -21020 0 0 {name=X_65890_ }
C {devices/lab_pin.sym} 163580 -20890 0 0 {name=p162671 lab=_77864_/Y }
C {devices/lab_pin.sym} 163660 -20890 0 1 {name=p162672 lab=_77876_/Y }
C {sky130_stdcells/inv_2.sym} 163620 -20890 0 0 {name=X_77876_ }
C {devices/lab_pin.sym} 163560 -20780 0 0 {name=p162673 lab=_79615_/A }
C {devices/lab_pin.sym} 163560 -20740 0 0 {name=p162674 lab=_84240_/Q }
C {devices/lab_pin.sym} 163680 -20760 0 1 {name=p162675 lab=_79615_/X }
C {sky130_stdcells/xor2_4.sym} 163620 -20760 0 0 {name=X_79615_ }
C {devices/lab_pin.sym} 163580 -20630 0 0 {name=p162676 lab=_84225_/Q }
C {devices/lab_pin.sym} 163660 -20630 0 1 {name=p162677 lab=_64841_/Y }
C {sky130_stdcells/inv_2.sym} 163620 -20630 0 0 {name=X_64841_ }
C {devices/lab_pin.sym} 163580 -20510 0 0 {name=p162678 lab=_81494_/Q }
C {devices/lab_pin.sym} 163660 -20510 0 1 {name=p162679 lab=_76829_/A }
C {sky130_stdcells/inv_2.sym} 163620 -20510 0 0 {name=X_76827_ }
C {devices/lab_pin.sym} 163540 -20410 0 0 {name=p162680 lab=_57897_/B }
C {devices/lab_pin.sym} 163540 -20370 0 0 {name=p162681 lab=_49768_/X }
C {devices/lab_pin.sym} 163540 -20330 0 0 {name=p162682 lab=_49774_/Y }
C {devices/lab_pin.sym} 163700 -20370 0 1 {name=p162683 lab=_49775_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -20370 0 0 {name=X_49775_ }
C {devices/lab_pin.sym} 163580 -20230 0 0 {name=p162684 lab=_47081_/A }
C {devices/lab_pin.sym} 163660 -20230 0 1 {name=p162685 lab=_46987_/X }
C {sky130_stdcells/buf_2.sym} 163620 -20230 0 0 {name=X_46987_ }
C {devices/lab_pin.sym} 163540 -20130 0 0 {name=p162686 lab=_72840_/B }
C {devices/lab_pin.sym} 163540 -20090 0 0 {name=p162687 lab=_48150_/X }
C {devices/lab_pin.sym} 163540 -20050 0 0 {name=p162688 lab=_48725_/Y }
C {devices/lab_pin.sym} 163700 -20090 0 1 {name=p162689 lab=_48726_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -20090 0 0 {name=X_48726_ }
C {devices/lab_pin.sym} 163540 -19980 0 0 {name=p162690 lab=_87402_/Q }
C {devices/lab_pin.sym} 163540 -19940 0 0 {name=p162691 lab=_67512_/X }
C {devices/lab_pin.sym} 163540 -19900 0 0 {name=p162692 lab=_67462_/X }
C {devices/lab_pin.sym} 163540 -19860 0 0 {name=p162693 lab=_67559_/X }
C {devices/lab_pin.sym} 163700 -19920 0 1 {name=p162694 lab=_67560_/X }
C {sky130_stdcells/a211o_4.sym} 163620 -19920 0 0 {name=X_67560_ }
C {devices/lab_pin.sym} 163560 -19780 0 0 {name=p162695 lab=_79546_/A }
C {devices/lab_pin.sym} 163560 -19740 0 0 {name=p162696 lab=_79545_/Y }
C {devices/lab_pin.sym} 163680 -19760 0 1 {name=p162697 lab=_79546_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -19760 0 0 {name=X_79546_ }
C {devices/lab_pin.sym} 163560 -19640 0 0 {name=p162698 lab=_45938_/A }
C {devices/lab_pin.sym} 163560 -19600 0 0 {name=p162699 lab=_45927_/X }
C {devices/lab_pin.sym} 163680 -19620 0 1 {name=p162700 lab=_45938_/X }
C {sky130_stdcells/or2_4.sym} 163620 -19620 0 0 {name=X_45938_ }
C {devices/lab_pin.sym} 163580 -19490 0 0 {name=p162701 lab=_64772_/A }
C {devices/lab_pin.sym} 163660 -19490 0 1 {name=p162702 lab=_64772_/X }
C {sky130_stdcells/buf_2.sym} 163620 -19490 0 0 {name=X_64772_ }
C {devices/lab_pin.sym} 163560 -19380 0 0 {name=p162703 lab=_76743_/Y }
C {devices/lab_pin.sym} 163560 -19340 0 0 {name=p162704 lab=_76758_/B }
C {devices/lab_pin.sym} 163680 -19360 0 1 {name=p162705 lab=_76758_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -19360 0 0 {name=X_76758_ }
C {devices/lab_pin.sym} 163560 -19260 0 0 {name=p162706 lab=_61521_/B }
C {devices/lab_pin.sym} 163560 -19220 0 0 {name=p162707 lab=_61953_/B }
C {devices/lab_pin.sym} 163560 -19180 0 0 {name=p162708 lab=_61953_/C }
C {devices/lab_pin.sym} 163560 -19140 0 0 {name=p162709 lab=_61937_/X }
C {devices/lab_pin.sym} 163680 -19200 0 1 {name=p162710 lab=_61984_/Y }
C {sky130_stdcells/nand4_4.sym} 163620 -19200 0 0 {name=X_61984_ }
C {devices/lab_pin.sym} 163560 -19070 0 0 {name=p162711 lab=_65366_/X }
C {devices/lab_pin.sym} 163560 -19030 0 0 {name=p162712 lab=_66521_/B }
C {devices/lab_pin.sym} 163560 -18990 0 0 {name=p162713 lab=_65368_/X }
C {devices/lab_pin.sym} 163680 -19030 0 1 {name=p162714 lab=_66511_/Y }
C {sky130_stdcells/nand3_4.sym} 163620 -19030 0 0 {name=X_66511_ }
C {devices/lab_pin.sym} 163560 -18900 0 0 {name=p162715 lab=_75696_/A }
C {devices/lab_pin.sym} 163560 -18860 0 0 {name=p162716 lab=_75695_/Y }
C {devices/lab_pin.sym} 163680 -18880 0 1 {name=p162717 lab=_75709_/Y }
C {sky130_stdcells/nor2_4.sym} 163620 -18880 0 0 {name=X_75709_ }
C {devices/lab_pin.sym} 163580 -18750 0 0 {name=p162718 lab=_60915_/A }
C {devices/lab_pin.sym} 163660 -18750 0 1 {name=p162719 lab=_63724_/A }
C {sky130_stdcells/buf_2.sym} 163620 -18750 0 0 {name=X_63723_ }
C {devices/lab_pin.sym} 163560 -18650 0 0 {name=p162720 lab=_48849_/A }
C {devices/lab_pin.sym} 163560 -18610 0 0 {name=p162721 lab=_48657_/B }
C {devices/lab_pin.sym} 163560 -18570 0 0 {name=p162722 lab=_48657_/C }
C {devices/lab_pin.sym} 163680 -18610 0 1 {name=p162723 lab=_48657_/X }
C {sky130_stdcells/and3_4.sym} 163620 -18610 0 0 {name=X_48657_ }
C {devices/lab_pin.sym} 163560 -18500 0 0 {name=p162724 lab=_60865_/B }
C {devices/lab_pin.sym} 163560 -18460 0 0 {name=p162725 lab=_60934_/X }
C {devices/lab_pin.sym} 163560 -18420 0 0 {name=p162726 lab=_60865_/C }
C {devices/lab_pin.sym} 163560 -18380 0 0 {name=p162727 lab=_60888_/Y }
C {devices/lab_pin.sym} 163680 -18440 0 1 {name=p162728 lab=_60935_/X }
C {sky130_stdcells/and4_4.sym} 163620 -18440 0 0 {name=X_60935_ }
C {devices/lab_pin.sym} 163540 -18320 0 0 {name=p162729 lab=_86969_/Q }
C {devices/lab_pin.sym} 163540 -18280 0 0 {name=p162730 lab=_67467_/X }
C {devices/lab_pin.sym} 163540 -18240 0 0 {name=p162731 lab=_67398_/X }
C {devices/lab_pin.sym} 163540 -18200 0 0 {name=p162732 lab=_67490_/X }
C {devices/lab_pin.sym} 163700 -18260 0 1 {name=p162733 lab=_67491_/X }
C {sky130_stdcells/a211o_4.sym} 163620 -18260 0 0 {name=X_67491_ }
C {devices/lab_pin.sym} 163560 -18120 0 0 {name=p162734 lab=_79475_/X }
C {devices/lab_pin.sym} 163560 -18080 0 0 {name=p162735 lab=_79476_/X }
C {devices/lab_pin.sym} 163680 -18100 0 1 {name=p162736 lab=_79496_/B }
C {sky130_stdcells/xnor2_4.sym} 163620 -18100 0 0 {name=X_79477_ }
C {devices/lab_pin.sym} 163540 -18000 0 0 {name=p162737 lab=_57084_/B }
C {devices/lab_pin.sym} 163540 -17960 0 0 {name=p162738 lab=_45734_/X }
C {devices/lab_pin.sym} 163540 -17920 0 0 {name=p162739 lab=_45571_/X }
C {devices/lab_pin.sym} 163540 -17880 0 0 {name=p162740 lab=_45868_/Y }
C {devices/lab_pin.sym} 163700 -17940 0 1 {name=p162741 lab=_45869_/X }
C {sky130_stdcells/a211o_4.sym} 163620 -17940 0 0 {name=X_45869_ }
C {devices/lab_pin.sym} 163560 -17800 0 0 {name=p162742 lab=_76689_/A }
C {devices/lab_pin.sym} 163560 -17760 0 0 {name=p162743 lab=_81446_/D }
C {devices/lab_pin.sym} 163680 -17780 0 1 {name=p162744 lab=_76689_/X }
C {sky130_stdcells/xor2_4.sym} 163620 -17780 0 0 {name=X_76689_ }
C {devices/lab_pin.sym} 163580 -17650 0 0 {name=p162745 lab=_69065_/X }
C {devices/lab_pin.sym} 163660 -17650 0 1 {name=p162746 lab=_69230_/X }
C {sky130_stdcells/buf_2.sym} 163620 -17650 0 0 {name=X_69230_ }
C {devices/lab_pin.sym} 163540 -17550 0 0 {name=p162747 lab=_47600_/Y }
C {devices/lab_pin.sym} 163540 -17510 0 0 {name=p162748 lab=_47602_/X }
C {devices/lab_pin.sym} 163540 -17470 0 0 {name=p162749 lab=_47607_/X }
C {devices/lab_pin.sym} 163700 -17510 0 1 {name=p162750 lab=_86617_/D }
C {sky130_stdcells/a21oi_4.sym} 163620 -17510 0 0 {name=X_47608_ }
C {devices/lab_pin.sym} 163540 -17390 0 0 {name=p162751 lab=_66411_/X }
C {devices/lab_pin.sym} 163540 -17350 0 0 {name=p162752 lab=_66134_/Y }
C {devices/lab_pin.sym} 163540 -17310 0 0 {name=p162753 lab=_66441_/Y }
C {devices/lab_pin.sym} 163700 -17350 0 1 {name=p162754 lab=_66442_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -17350 0 0 {name=X_66442_ }
C {devices/lab_pin.sym} 163540 -17230 0 0 {name=p162755 lab=_78398_/X }
C {devices/lab_pin.sym} 163540 -17190 0 0 {name=p162756 lab=_78426_/Y }
C {devices/lab_pin.sym} 163540 -17150 0 0 {name=p162757 lab=_78427_/X }
C {devices/lab_pin.sym} 163700 -17190 0 1 {name=p162758 lab=_78428_/X }
C {sky130_stdcells/o21a_4.sym} 163620 -17190 0 0 {name=X_78428_ }
C {devices/lab_pin.sym} 163540 -17070 0 0 {name=p162759 lab=_63652_/Y }
C {devices/lab_pin.sym} 163540 -17030 0 0 {name=p162760 lab=_63635_/X }
C {devices/lab_pin.sym} 163540 -16990 0 0 {name=p162761 lab=_63653_/Y }
C {devices/lab_pin.sym} 163700 -17030 0 1 {name=p162762 lab=_84305_/D }
C {sky130_stdcells/a21oi_4.sym} 163620 -17030 0 0 {name=X_63654_ }
C {devices/lab_pin.sym} 163580 -16890 0 0 {name=p162763 lab=_60866_/A }
C {devices/lab_pin.sym} 163660 -16890 0 1 {name=p162764 lab=_64102_/B }
C {sky130_stdcells/buf_2.sym} 163620 -16890 0 0 {name=X_60866_ }
C {devices/lab_pin.sym} 163540 -16790 0 0 {name=p162765 lab=_48563_/X }
C {devices/lab_pin.sym} 163540 -16750 0 0 {name=p162766 lab=_82349_/Q }
C {devices/lab_pin.sym} 163540 -16710 0 0 {name=p162767 lab=_48587_/Y }
C {devices/lab_pin.sym} 163700 -16750 0 1 {name=p162768 lab=_48589_/A }
C {sky130_stdcells/o21ai_4.sym} 163620 -16750 0 0 {name=X_48588_ }
C {devices/lab_pin.sym} 163580 -16610 0 0 {name=p162769 lab=_62672_/A }
C {devices/lab_pin.sym} 163660 -16610 0 1 {name=p162770 lab=_62653_/B }
C {sky130_stdcells/buf_2.sym} 163620 -16610 0 0 {name=X_62605_ }
C {devices/lab_pin.sym} 163580 -16490 0 0 {name=p162771 lab=_69065_/X }
C {devices/lab_pin.sym} 163660 -16490 0 1 {name=p162772 lab=_69161_/X }
C {sky130_stdcells/buf_2.sym} 163620 -16490 0 0 {name=X_69161_ }
C {devices/lab_pin.sym} 163580 -16370 0 0 {name=p162773 lab=_47539_/A }
C {devices/lab_pin.sym} 163660 -16370 0 1 {name=p162774 lab=_47540_/A }
C {sky130_stdcells/inv_2.sym} 163620 -16370 0 0 {name=X_47539_ }
C {devices/lab_pin.sym} 163560 -16270 0 0 {name=p162775 lab=_66318_/X }
C {devices/lab_pin.sym} 163560 -16230 0 0 {name=p162776 lab=_66415_/B }
C {devices/lab_pin.sym} 163560 -16190 0 0 {name=p162777 lab=_84135_/Q }
C {devices/lab_pin.sym} 163680 -16230 0 1 {name=p162778 lab=_66373_/X }
C {sky130_stdcells/and3_4.sym} 163620 -16230 0 0 {name=X_66373_ }
C {devices/lab_pin.sym} 163540 -16110 0 0 {name=p162779 lab=_78360_/A }
C {devices/lab_pin.sym} 163540 -16070 0 0 {name=p162780 lab=_78376_/B }
C {devices/lab_pin.sym} 163540 -16030 0 0 {name=p162781 lab=_78360_/B }
C {devices/lab_pin.sym} 163700 -16070 0 1 {name=p162782 lab=_78359_/X }
C {sky130_stdcells/a21o_4.sym} 163620 -16070 0 0 {name=X_78359_ }
C {devices/lab_pin.sym} 163560 -15940 0 0 {name=p162783 lab=_63657_/A }
C {devices/lab_pin.sym} 163560 -15900 0 0 {name=p162784 lab=_63585_/B }
C {devices/lab_pin.sym} 163680 -15920 0 1 {name=p162785 lab=_63585_/X }
C {sky130_stdcells/and2_4.sym} 163620 -15920 0 0 {name=X_63585_ }
C {devices/lab_pin.sym} 163580 -15790 0 0 {name=p162786 lab=_60738_/Y }
C {devices/lab_pin.sym} 163660 -15790 0 1 {name=p162787 lab=_63375_/A }
C {sky130_stdcells/inv_2.sym} 163620 -15790 0 0 {name=X_60797_ }
C {devices/lab_pin.sym} 163540 -15700 0 0 {name=p162788 lab=_68088_/X }
C {devices/lab_pin.sym} 163540 -15660 0 0 {name=p162789 lab=_66696_/Y }
C {devices/lab_pin.sym} 163540 -15620 0 0 {name=p162790 lab=_68110_/X }
C {devices/lab_pin.sym} 163540 -15580 0 0 {name=p162791 lab=_68111_/Y }
C {devices/lab_pin.sym} 163700 -15640 0 1 {name=p162792 lab=_68112_/X }
C {sky130_stdcells/a211o_4.sym} 163620 -15640 0 0 {name=X_68112_ }
C {devices/lab_pin.sym} 163560 -15500 0 0 {name=p162793 lab=_65225_/A }
C {devices/lab_pin.sym} 163560 -15460 0 0 {name=p162794 lab=_65324_/B }
C {devices/lab_pin.sym} 163680 -15480 0 1 {name=p162795 lab=_65324_/X }
C {sky130_stdcells/and2_4.sym} 163620 -15480 0 0 {name=X_65324_ }
C {devices/lab_pin.sym} 163540 -15370 0 0 {name=p162796 lab=_86179_/Q }
C {devices/lab_pin.sym} 163540 -15330 0 0 {name=p162797 lab=_50533_/X }
C {devices/lab_pin.sym} 163540 -15290 0 0 {name=p162798 lab=_50549_/Y }
C {devices/lab_pin.sym} 163700 -15330 0 1 {name=p162799 lab=_50550_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -15330 0 0 {name=X_50550_ }
C {devices/lab_pin.sym} 163560 -15220 0 0 {name=p162800 lab=_62622_/A }
C {devices/lab_pin.sym} 163560 -15180 0 0 {name=p162801 lab=_62536_/B }
C {devices/lab_pin.sym} 163560 -15140 0 0 {name=p162802 lab=_62536_/C }
C {devices/lab_pin.sym} 163560 -15100 0 0 {name=p162803 lab=_62536_/D }
C {devices/lab_pin.sym} 163680 -15160 0 1 {name=p162804 lab=_62536_/Y }
C {sky130_stdcells/nand4_4.sym} 163620 -15160 0 0 {name=X_62536_ }
C {devices/lab_pin.sym} 163530 -15010 0 0 {name=p162805 lab=_81352_/CLK }
C {devices/lab_pin.sym} 163530 -14990 0 0 {name=p162806 lab=_81370_/D }
C {devices/lab_pin.sym} 163710 -15010 0 1 {name=p162807 lab=_76518_/A }
C {sky130_stdcells/dfxtp_4.sym} 163620 -15000 0 0 {name=X_81370_ }
C {devices/lab_pin.sym} 163560 -14880 0 0 {name=p162808 lab=_69092_/A }
C {devices/lab_pin.sym} 163560 -14840 0 0 {name=p162809 lab=_88341_/Q }
C {devices/lab_pin.sym} 163680 -14860 0 1 {name=p162810 lab=_69092_/X }
C {sky130_stdcells/and2_4.sym} 163620 -14860 0 0 {name=X_69092_ }
C {devices/lab_pin.sym} 163580 -14730 0 0 {name=p162811 lab=_46241_/X }
C {devices/lab_pin.sym} 163660 -14730 0 1 {name=p162812 lab=_53944_/C }
C {sky130_stdcells/buf_2.sym} 163620 -14730 0 0 {name=X_49209_ }
C {devices/lab_pin.sym} 163540 -14630 0 0 {name=p162813 lab=_80304_/A }
C {devices/lab_pin.sym} 163540 -14590 0 0 {name=p162814 lab=_80303_/B }
C {devices/lab_pin.sym} 163540 -14550 0 0 {name=p162815 lab=_80300_/Y }
C {devices/lab_pin.sym} 163700 -14590 0 1 {name=p162816 lab=_80322_/B }
C {sky130_stdcells/a21oi_4.sym} 163620 -14590 0 0 {name=X_80321_ }
C {devices/lab_pin.sym} 163540 -14480 0 0 {name=p162817 lab=_87957_/Q }
C {devices/lab_pin.sym} 163540 -14440 0 0 {name=p162818 lab=_67950_/X }
C {devices/lab_pin.sym} 163540 -14400 0 0 {name=p162819 lab=_67997_/X }
C {devices/lab_pin.sym} 163540 -14360 0 0 {name=p162820 lab=_68042_/X }
C {devices/lab_pin.sym} 163700 -14420 0 1 {name=p162821 lab=_68043_/X }
C {sky130_stdcells/a211o_4.sym} 163620 -14420 0 0 {name=X_68043_ }
C {devices/lab_pin.sym} 163560 -14280 0 0 {name=p162822 lab=_65255_/A }
C {devices/lab_pin.sym} 163560 -14240 0 0 {name=p162823 lab=_65254_/X }
C {devices/lab_pin.sym} 163680 -14260 0 1 {name=p162824 lab=_65255_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -14260 0 0 {name=X_65255_ }
C {devices/lab_pin.sym} 163560 -14140 0 0 {name=p162825 lab=_50481_/A }
C {devices/lab_pin.sym} 163560 -14100 0 0 {name=p162826 lab=_48551_/X }
C {devices/lab_pin.sym} 163680 -14120 0 1 {name=p162827 lab=_50481_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -14120 0 0 {name=X_50481_ }
C {devices/lab_pin.sym} 163580 -13990 0 0 {name=p162828 lab=_62395_/X }
C {devices/lab_pin.sym} 163660 -13990 0 1 {name=p162829 lab=_62467_/X }
C {sky130_stdcells/buf_2.sym} 163620 -13990 0 0 {name=X_62467_ }
C {devices/lab_pin.sym} 163560 -13880 0 0 {name=p162830 lab=_52220_/A }
C {devices/lab_pin.sym} 163560 -13840 0 0 {name=p162831 lab=_48628_/B }
C {devices/lab_pin.sym} 163680 -13860 0 1 {name=p162832 lab=_52220_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -13860 0 0 {name=X_52220_ }
C {devices/lab_pin.sym} 163580 -13730 0 0 {name=p162833 lab=_64274_/A }
C {devices/lab_pin.sym} 163660 -13730 0 1 {name=p162834 lab=_64207_/A }
C {sky130_stdcells/buf_2.sym} 163620 -13730 0 0 {name=X_64206_ }
C {devices/lab_pin.sym} 163530 -13610 0 0 {name=p162835 lab=_85311_/CLK }
C {devices/lab_pin.sym} 163530 -13590 0 0 {name=p162836 lab=_83040_/D }
C {devices/lab_pin.sym} 163710 -13610 0 1 {name=p162837 lab=_44917_/A }
C {sky130_stdcells/dfxtp_4.sym} 163620 -13600 0 0 {name=X_83040_ }
C {devices/lab_pin.sym} 163560 -13480 0 0 {name=p162838 lab=_84681_/Q }
C {devices/lab_pin.sym} 163560 -13440 0 0 {name=p162839 lab=_63745_/C }
C {devices/lab_pin.sym} 163680 -13460 0 1 {name=p162840 lab=_80257_/A }
C {sky130_stdcells/xor2_4.sym} 163620 -13460 0 0 {name=X_80252_ }
C {devices/lab_pin.sym} 163580 -13330 0 0 {name=p162841 lab=_61355_/A }
C {devices/lab_pin.sym} 163660 -13330 0 1 {name=p162842 lab=_61429_/A }
C {sky130_stdcells/buf_2.sym} 163620 -13330 0 0 {name=X_61418_ }
C {devices/lab_pin.sym} 163560 -13220 0 0 {name=p162843 lab=_65012_/A }
C {devices/lab_pin.sym} 163560 -13180 0 0 {name=p162844 lab=_86251_/Q }
C {devices/lab_pin.sym} 163680 -13200 0 1 {name=p162845 lab=_65186_/X }
C {sky130_stdcells/and2_4.sym} 163620 -13200 0 0 {name=X_65186_ }
C {devices/lab_pin.sym} 163540 -13090 0 0 {name=p162846 lab=_62394_/Y }
C {devices/lab_pin.sym} 163540 -13050 0 0 {name=p162847 lab=_62396_/X }
C {devices/lab_pin.sym} 163540 -13010 0 0 {name=p162848 lab=_62397_/Y }
C {devices/lab_pin.sym} 163700 -13050 0 1 {name=p162849 lab=_84413_/D }
C {sky130_stdcells/a21oi_4.sym} 163620 -13050 0 0 {name=X_62398_ }
C {devices/lab_pin.sym} 163580 -12910 0 0 {name=p162850 lab=clkbuf_8_96_0_CLK/X }
C {devices/lab_pin.sym} 163660 -12910 0 1 {name=p162851 lab=clkbuf_9_192_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 163620 -12910 0 0 {name=Xclkbuf_9_192_0_CLK }
C {devices/lab_pin.sym} 163540 -12810 0 0 {name=p162852 lab=_52149_/Y }
C {devices/lab_pin.sym} 163540 -12770 0 0 {name=p162853 lab=_52145_/X }
C {devices/lab_pin.sym} 163540 -12730 0 0 {name=p162854 lab=_52150_/X }
C {devices/lab_pin.sym} 163700 -12770 0 1 {name=p162855 lab=_85879_/D }
C {sky130_stdcells/a21oi_4.sym} 163620 -12770 0 0 {name=X_52151_ }
C {devices/lab_pin.sym} 163540 -12670 0 0 {name=p162856 lab=_64077_/Y }
C {devices/lab_pin.sym} 163540 -12630 0 0 {name=p162857 lab=_64132_/Y }
C {devices/lab_pin.sym} 163540 -12590 0 0 {name=p162858 lab=_64133_/X }
C {devices/lab_pin.sym} 163540 -12550 0 0 {name=p162859 lab=_64135_/X }
C {devices/lab_pin.sym} 163540 -12510 0 0 {name=p162860 lab=_64136_/X }
C {devices/lab_pin.sym} 163700 -12590 0 1 {name=p162861 lab=_64137_/Y }
C {sky130_stdcells/o41ai_4.sym} 163620 -12590 0 0 {name=X_64137_ }
C {devices/lab_pin.sym} 163580 -12430 0 0 {name=p162862 lab=_61394_/A }
C {devices/lab_pin.sym} 163660 -12430 0 1 {name=p162863 lab=_61349_/X }
C {sky130_stdcells/buf_2.sym} 163620 -12430 0 0 {name=X_61349_ }
C {devices/lab_pin.sym} 163560 -12320 0 0 {name=p162864 lab=_84946_/Q }
C {devices/lab_pin.sym} 163560 -12280 0 0 {name=p162865 lab=_65546_/C }
C {devices/lab_pin.sym} 163680 -12300 0 1 {name=p162866 lab=_80183_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -12300 0 0 {name=X_80183_ }
C {devices/lab_pin.sym} 163580 -12170 0 0 {name=p162867 lab=_60150_/A }
C {devices/lab_pin.sym} 163660 -12170 0 1 {name=p162868 lab=_69994_/X }
C {sky130_stdcells/buf_2.sym} 163620 -12170 0 0 {name=X_69994_ }
C {devices/lab_pin.sym} 163580 -12050 0 0 {name=p162869 lab=_51129_/A }
C {devices/lab_pin.sym} 163660 -12050 0 1 {name=p162870 lab=_51112_/A }
C {sky130_stdcells/buf_2.sym} 163620 -12050 0 0 {name=X_51102_ }
C {devices/lab_pin.sym} 163540 -11950 0 0 {name=p162871 lab=_74232_/B }
C {devices/lab_pin.sym} 163540 -11910 0 0 {name=p162872 lab=_52075_/X }
C {devices/lab_pin.sym} 163540 -11870 0 0 {name=p162873 lab=_52081_/Y }
C {devices/lab_pin.sym} 163700 -11910 0 1 {name=p162874 lab=_52082_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -11910 0 0 {name=X_52082_ }
C {devices/lab_pin.sym} 163540 -11800 0 0 {name=p162875 lab=_87484_/Q }
C {devices/lab_pin.sym} 163540 -11760 0 0 {name=p162876 lab=_68870_/X }
C {devices/lab_pin.sym} 163540 -11720 0 0 {name=p162877 lab=_68871_/X }
C {devices/lab_pin.sym} 163540 -11680 0 0 {name=p162878 lab=_68944_/X }
C {devices/lab_pin.sym} 163700 -11740 0 1 {name=p162879 lab=_68945_/X }
C {sky130_stdcells/a211o_4.sym} 163620 -11740 0 0 {name=X_68945_ }
C {devices/lab_pin.sym} 163580 -11590 0 0 {name=p162880 lab=_63721_/C }
C {devices/lab_pin.sym} 163660 -11590 0 1 {name=p162881 lab=_64161_/D }
C {sky130_stdcells/buf_2.sym} 163620 -11590 0 0 {name=X_64068_ }
C {devices/lab_pin.sym} 163530 -11470 0 0 {name=p162882 lab=_84991_/CLK }
C {devices/lab_pin.sym} 163530 -11450 0 0 {name=p162883 lab=_84991_/D }
C {devices/lab_pin.sym} 163710 -11470 0 1 {name=p162884 lab=_84991_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -11460 0 0 {name=X_84991_ }
C {devices/lab_pin.sym} 163580 -11330 0 0 {name=p162885 lab=_51033_/A }
C {devices/lab_pin.sym} 163660 -11330 0 1 {name=p162886 lab=_51141_/A }
C {sky130_stdcells/buf_2.sym} 163620 -11330 0 0 {name=X_51033_ }
C {devices/lab_pin.sym} 163560 -11220 0 0 {name=p162887 lab=_55908_/A }
C {devices/lab_pin.sym} 163560 -11180 0 0 {name=p162888 lab=_85176_/Q }
C {devices/lab_pin.sym} 163680 -11200 0 1 {name=p162889 lab=_55910_/X }
C {sky130_stdcells/and2_4.sym} 163620 -11200 0 0 {name=X_55910_ }
C {devices/lab_pin.sym} 163530 -11070 0 0 {name=p162890 lab=_85514_/CLK }
C {devices/lab_pin.sym} 163530 -11050 0 0 {name=p162891 lab=_86730_/D }
C {devices/lab_pin.sym} 163710 -11070 0 1 {name=p162892 lab=_86730_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -11060 0 0 {name=X_86730_ }
C {devices/lab_pin.sym} 163580 -10930 0 0 {name=p162893 lab=_63018_/X }
C {devices/lab_pin.sym} 163660 -10930 0 1 {name=p162894 lab=_63020_/A }
C {sky130_stdcells/buf_2.sym} 163620 -10930 0 0 {name=X_63019_ }
C {devices/lab_pin.sym} 163530 -10810 0 0 {name=p162895 lab=_81351_/CLK }
C {devices/lab_pin.sym} 163530 -10790 0 0 {name=p162896 lab=_69189_/X }
C {devices/lab_pin.sym} 163710 -10810 0 1 {name=p162897 lab=_83942_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -10800 0 0 {name=X_83942_ }
C {devices/lab_pin.sym} 163540 -10690 0 0 {name=p162898 lab=_56889_/X }
C {devices/lab_pin.sym} 163540 -10650 0 0 {name=p162899 lab=_55662_/Y }
C {devices/lab_pin.sym} 163540 -10610 0 0 {name=p162900 lab=_56777_/B }
C {devices/lab_pin.sym} 163700 -10650 0 1 {name=p162901 lab=_56890_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -10650 0 0 {name=X_56890_ }
C {devices/lab_pin.sym} 163560 -10520 0 0 {name=p162902 lab=_68785_/A }
C {devices/lab_pin.sym} 163560 -10480 0 0 {name=p162903 lab=_88255_/Q }
C {devices/lab_pin.sym} 163680 -10500 0 1 {name=p162904 lab=_68876_/X }
C {sky130_stdcells/and2_4.sym} 163620 -10500 0 0 {name=X_68876_ }
C {devices/lab_pin.sym} 163560 -10380 0 0 {name=p162905 lab=_55843_/A }
C {devices/lab_pin.sym} 163560 -10340 0 0 {name=p162906 lab=_85297_/Q }
C {devices/lab_pin.sym} 163680 -10360 0 1 {name=p162907 lab=_55841_/X }
C {sky130_stdcells/and2_4.sym} 163620 -10360 0 0 {name=X_55841_ }
C {devices/lab_pin.sym} 163540 -10260 0 0 {name=p162908 lab=_87147_/Q }
C {devices/lab_pin.sym} 163540 -10220 0 0 {name=p162909 lab=_67825_/X }
C {devices/lab_pin.sym} 163540 -10180 0 0 {name=p162910 lab=_67755_/X }
C {devices/lab_pin.sym} 163540 -10140 0 0 {name=p162911 lab=_67826_/X }
C {devices/lab_pin.sym} 163700 -10200 0 1 {name=p162912 lab=_67827_/X }
C {sky130_stdcells/a211o_4.sym} 163620 -10200 0 0 {name=X_67827_ }
C {devices/lab_pin.sym} 163530 -10050 0 0 {name=p162913 lab=_86665_/CLK }
C {devices/lab_pin.sym} 163530 -10030 0 0 {name=p162914 lab=_47191_/Y }
C {devices/lab_pin.sym} 163710 -10050 0 1 {name=p162915 lab=_86661_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -10040 0 0 {name=X_86661_ }
C {devices/lab_pin.sym} 163530 -9910 0 0 {name=p162916 lab=_82553_/CLK }
C {devices/lab_pin.sym} 163530 -9890 0 0 {name=p162917 lab=_83873_/D }
C {devices/lab_pin.sym} 163710 -9910 0 1 {name=p162918 lab=_82553_/D }
C {sky130_stdcells/dfxtp_4.sym} 163620 -9900 0 0 {name=X_83873_ }
C {devices/lab_pin.sym} 163530 -9770 0 0 {name=p162919 lab=_86834_/CLK }
C {devices/lab_pin.sym} 163530 -9750 0 0 {name=p162920 lab=_40388_/X }
C {devices/lab_pin.sym} 163710 -9770 0 1 {name=p162921 lab=_88400_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -9760 0 0 {name=X_88400_ }
C {devices/lab_pin.sym} 163530 -9630 0 0 {name=p162922 lab=_86570_/CLK }
C {devices/lab_pin.sym} 163530 -9610 0 0 {name=p162923 lab=_53566_/Y }
C {devices/lab_pin.sym} 163710 -9630 0 1 {name=p162924 lab=_85612_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -9620 0 0 {name=X_85612_ }
C {devices/lab_pin.sym} 163580 -9490 0 0 {name=p162925 lab=_84818_/Q }
C {devices/lab_pin.sym} 163660 -9490 0 1 {name=p162926 lab=_58562_/A }
C {sky130_stdcells/inv_2.sym} 163620 -9490 0 0 {name=X_58560_ }
C {devices/lab_pin.sym} 163530 -9370 0 0 {name=p162927 lab=_82463_/CLK }
C {devices/lab_pin.sym} 163530 -9350 0 0 {name=p162928 lab=_82824_/D }
C {devices/lab_pin.sym} 163710 -9370 0 1 {name=p162929 lab=_82824_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -9360 0 0 {name=X_82824_ }
C {devices/lab_pin.sym} 163580 -9230 0 0 {name=p162930 lab=_55772_/A }
C {devices/lab_pin.sym} 163660 -9230 0 1 {name=p162931 lab=_55773_/D }
C {sky130_stdcells/buf_2.sym} 163620 -9230 0 0 {name=X_55772_ }
C {devices/lab_pin.sym} 163540 -9130 0 0 {name=p162932 lab=_67754_/X }
C {devices/lab_pin.sym} 163540 -9090 0 0 {name=p162933 lab=_67757_/X }
C {devices/lab_pin.sym} 163540 -9050 0 0 {name=p162934 lab=_67709_/X }
C {devices/lab_pin.sym} 163700 -9090 0 1 {name=p162935 lab=_67758_/Y }
C {sky130_stdcells/a21oi_4.sym} 163620 -9090 0 0 {name=X_67758_ }
C {devices/lab_pin.sym} 163530 -8950 0 0 {name=p162936 lab=_86592_/CLK }
C {devices/lab_pin.sym} 163530 -8930 0 0 {name=p162937 lab=_86592_/D }
C {devices/lab_pin.sym} 163710 -8950 0 1 {name=p162938 lab=_65921_/B }
C {sky130_stdcells/dfxtp_4.sym} 163620 -8940 0 0 {name=X_86592_ }
C {devices/lab_pin.sym} 163580 -8810 0 0 {name=p162939 lab=_53065_/A }
C {devices/lab_pin.sym} 163660 -8810 0 1 {name=p162940 lab=_52984_/X }
C {sky130_stdcells/buf_2.sym} 163620 -8810 0 0 {name=X_52984_ }
C {devices/lab_pin.sym} 163560 -8710 0 0 {name=p162941 lab=_47886_/X }
C {devices/lab_pin.sym} 163560 -8670 0 0 {name=p162942 lab=_46620_/A }
C {devices/lab_pin.sym} 163560 -8630 0 0 {name=p162943 lab=_53697_/B }
C {devices/lab_pin.sym} 163680 -8670 0 1 {name=p162944 lab=_57511_/Y }
C {sky130_stdcells/nand3_4.sym} 163620 -8670 0 0 {name=X_57511_ }
C {devices/lab_pin.sym} 163580 -8530 0 0 {name=p162945 lab=clkbuf_8_65_0_CLK/X }
C {devices/lab_pin.sym} 163660 -8530 0 1 {name=p162946 lab=clkbuf_9_130_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 163620 -8530 0 0 {name=Xclkbuf_9_130_0_CLK }
C {devices/lab_pin.sym} 163530 -8410 0 0 {name=p162947 lab=_84970_/CLK }
C {devices/lab_pin.sym} 163530 -8390 0 0 {name=p162948 lab=_40807_/X }
C {devices/lab_pin.sym} 163710 -8410 0 1 {name=p162949 lab=_88331_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -8400 0 0 {name=X_88331_ }
C {devices/lab_pin.sym} 163560 -8280 0 0 {name=p162950 lab=_54718_/A }
C {devices/lab_pin.sym} 163560 -8240 0 0 {name=p162951 lab=_47411_/A }
C {devices/lab_pin.sym} 163680 -8260 0 1 {name=p162952 lab=_54723_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -8260 0 0 {name=X_54723_ }
C {devices/lab_pin.sym} 163540 -8150 0 0 {name=p162953 lab=_84100_/Q }
C {devices/lab_pin.sym} 163540 -8110 0 0 {name=p162954 lab=_66614_/X }
C {devices/lab_pin.sym} 163540 -8070 0 0 {name=p162955 lab=_66708_/X }
C {devices/lab_pin.sym} 163700 -8110 0 1 {name=p162956 lab=_66709_/X }
C {sky130_stdcells/a21bo_4.sym} 163620 -8110 0 0 {name=X_66709_ }
C {devices/lab_pin.sym} 163530 -7970 0 0 {name=p162957 lab=_85542_/CLK }
C {devices/lab_pin.sym} 163530 -7950 0 0 {name=p162958 lab=_85543_/D }
C {devices/lab_pin.sym} 163710 -7970 0 1 {name=p162959 lab=_85543_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -7960 0 0 {name=X_85543_ }
C {devices/lab_pin.sym} 163580 -7830 0 0 {name=p162960 lab=_52274_/A }
C {devices/lab_pin.sym} 163660 -7830 0 1 {name=p162961 lab=_52407_/A }
C {sky130_stdcells/buf_2.sym} 163620 -7830 0 0 {name=X_51935_ }
C {devices/lab_pin.sym} 163540 -7730 0 0 {name=p162962 lab=_58448_/X }
C {devices/lab_pin.sym} 163540 -7690 0 0 {name=p162963 lab=_83412_/Q }
C {devices/lab_pin.sym} 163540 -7650 0 0 {name=p162964 lab=_58490_/Y }
C {devices/lab_pin.sym} 163700 -7690 0 1 {name=p162965 lab=_84836_/D }
C {sky130_stdcells/o21a_4.sym} 163620 -7690 0 0 {name=X_58491_ }
C {devices/lab_pin.sym} 163530 -7550 0 0 {name=p162966 lab=_82965_/CLK }
C {devices/lab_pin.sym} 163530 -7530 0 0 {name=p162967 lab=_82755_/D }
C {devices/lab_pin.sym} 163710 -7550 0 1 {name=p162968 lab=_82755_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -7540 0 0 {name=X_82755_ }
C {devices/lab_pin.sym} 163580 -7410 0 0 {name=p162969 lab=_66565_/A }
C {devices/lab_pin.sym} 163660 -7410 0 1 {name=p162970 lab=_68637_/A }
C {sky130_stdcells/buf_2.sym} 163620 -7410 0 0 {name=X_67689_ }
C {devices/lab_pin.sym} 163580 -7290 0 0 {name=p162971 lab=_44037_/X }
C {devices/lab_pin.sym} 163660 -7290 0 1 {name=p162972 lab=_57463_/B }
C {sky130_stdcells/buf_2.sym} 163620 -7290 0 0 {name=X_57442_ }
C {devices/lab_pin.sym} 163530 -7170 0 0 {name=p162973 lab=_81514_/CLK }
C {devices/lab_pin.sym} 163530 -7150 0 0 {name=p162974 lab=_81706_/D }
C {devices/lab_pin.sym} 163710 -7170 0 1 {name=p162975 lab=_41062_/B }
C {sky130_stdcells/dfxtp_4.sym} 163620 -7160 0 0 {name=X_81706_ }
C {devices/lab_pin.sym} 163540 -7060 0 0 {name=p162976 lab=_87518_/Q }
C {devices/lab_pin.sym} 163540 -7020 0 0 {name=p162977 lab=_69205_/X }
C {devices/lab_pin.sym} 163540 -6980 0 0 {name=p162978 lab=_69343_/X }
C {devices/lab_pin.sym} 163540 -6940 0 0 {name=p162979 lab=_69427_/X }
C {devices/lab_pin.sym} 163700 -7000 0 1 {name=p162980 lab=_69428_/X }
C {sky130_stdcells/a211o_4.sym} 163620 -7000 0 0 {name=X_69428_ }
C {devices/lab_pin.sym} 163530 -6850 0 0 {name=p162981 lab=_87103_/CLK }
C {devices/lab_pin.sym} 163530 -6830 0 0 {name=p162982 lab=_41183_/X }
C {devices/lab_pin.sym} 163710 -6850 0 1 {name=p162983 lab=_68708_/B }
C {sky130_stdcells/dfxtp_4.sym} 163620 -6840 0 0 {name=X_88262_ }
C {devices/lab_pin.sym} 163560 -6720 0 0 {name=p162984 lab=_54649_/X }
C {devices/lab_pin.sym} 163560 -6680 0 0 {name=p162985 lab=_54130_/B }
C {devices/lab_pin.sym} 163680 -6700 0 1 {name=p162986 lab=_54654_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -6700 0 0 {name=X_54654_ }
C {devices/lab_pin.sym} 163530 -6570 0 0 {name=p162987 lab=_83711_/CLK }
C {devices/lab_pin.sym} 163530 -6550 0 0 {name=p162988 lab=_54265_/Y }
C {devices/lab_pin.sym} 163710 -6570 0 1 {name=p162989 lab=_85474_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -6560 0 0 {name=X_85474_ }
C {devices/lab_pin.sym} 163540 -6450 0 0 {name=p162990 lab=_51863_/Y }
C {devices/lab_pin.sym} 163540 -6410 0 0 {name=p162991 lab=_51850_/X }
C {devices/lab_pin.sym} 163540 -6370 0 0 {name=p162992 lab=_51865_/X }
C {devices/lab_pin.sym} 163700 -6410 0 1 {name=p162993 lab=_51866_/Y }
C {sky130_stdcells/a21oi_4.sym} 163620 -6410 0 0 {name=X_51866_ }
C {devices/lab_pin.sym} 163530 -6270 0 0 {name=p162994 lab=_82933_/CLK }
C {devices/lab_pin.sym} 163530 -6250 0 0 {name=p162995 lab=_82686_/D }
C {devices/lab_pin.sym} 163710 -6270 0 1 {name=p162996 lab=_82686_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -6260 0 0 {name=X_82686_ }
C {devices/lab_pin.sym} 163580 -6130 0 0 {name=p162997 lab=clkbuf_9_327_0_CLK/X }
C {devices/lab_pin.sym} 163660 -6130 0 1 {name=p162998 lab=_88164_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 163620 -6130 0 0 {name=Xclkbuf_10_654_0_CLK }
C {devices/lab_pin.sym} 163530 -6010 0 0 {name=p162999 lab=_87446_/CLK }
C {devices/lab_pin.sym} 163530 -5990 0 0 {name=p163000 lab=_43891_/Y }
C {devices/lab_pin.sym} 163710 -6010 0 1 {name=p163001 lab=_87213_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -6000 0 0 {name=X_87213_ }
C {devices/lab_pin.sym} 163540 -5890 0 0 {name=p163002 lab=_53602_/Y }
C {devices/lab_pin.sym} 163540 -5850 0 0 {name=p163003 lab=_53603_/X }
C {devices/lab_pin.sym} 163540 -5810 0 0 {name=p163004 lab=_53604_/Y }
C {devices/lab_pin.sym} 163700 -5850 0 1 {name=p163005 lab=_85604_/D }
C {sky130_stdcells/a21boi_4.sym} 163620 -5850 0 0 {name=X_53605_ }
C {devices/lab_pin.sym} 163530 -5710 0 0 {name=p163006 lab=_84426_/CLK }
C {devices/lab_pin.sym} 163530 -5690 0 0 {name=p163007 lab=_84425_/D }
C {devices/lab_pin.sym} 163710 -5710 0 1 {name=p163008 lab=_84425_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -5700 0 0 {name=X_84425_ }
C {devices/lab_pin.sym} 163540 -5590 0 0 {name=p163009 lab=_50815_/Y }
C {devices/lab_pin.sym} 163540 -5550 0 0 {name=p163010 lab=_50792_/X }
C {devices/lab_pin.sym} 163540 -5510 0 0 {name=p163011 lab=_50816_/Y }
C {devices/lab_pin.sym} 163700 -5550 0 1 {name=p163012 lab=_50817_/Y }
C {sky130_stdcells/a21boi_4.sym} 163620 -5550 0 0 {name=X_50817_ }
C {devices/lab_pin.sym} 163580 -5410 0 0 {name=p163013 lab=_44124_/A }
C {devices/lab_pin.sym} 163660 -5410 0 1 {name=p163014 lab=_72910_/A }
C {sky130_stdcells/buf_2.sym} 163620 -5410 0 0 {name=X_57373_ }
C {devices/lab_pin.sym} 163530 -5290 0 0 {name=p163015 lab=_81684_/CLK }
C {devices/lab_pin.sym} 163530 -5270 0 0 {name=p163016 lab=_81637_/D }
C {devices/lab_pin.sym} 163710 -5290 0 1 {name=p163017 lab=_76189_/B }
C {sky130_stdcells/dfxtp_4.sym} 163620 -5280 0 0 {name=X_81637_ }
C {devices/lab_pin.sym} 163540 -5180 0 0 {name=p163018 lab=_87523_/Q }
C {devices/lab_pin.sym} 163540 -5140 0 0 {name=p163019 lab=_69356_/X }
C {devices/lab_pin.sym} 163540 -5100 0 0 {name=p163020 lab=_69124_/X }
C {devices/lab_pin.sym} 163540 -5060 0 0 {name=p163021 lab=_69358_/X }
C {devices/lab_pin.sym} 163700 -5120 0 1 {name=p163022 lab=_69359_/X }
C {sky130_stdcells/a211o_4.sym} 163620 -5120 0 0 {name=X_69359_ }
C {devices/lab_pin.sym} 163530 -4970 0 0 {name=p163023 lab=_87116_/CLK }
C {devices/lab_pin.sym} 163530 -4950 0 0 {name=p163024 lab=_88193_/D }
C {devices/lab_pin.sym} 163710 -4970 0 1 {name=p163025 lab=_67011_/B }
C {sky130_stdcells/dfxtp_4.sym} 163620 -4960 0 0 {name=X_88193_ }
C {devices/lab_pin.sym} 163560 -4860 0 0 {name=p163026 lab=_54565_/A }
C {devices/lab_pin.sym} 163560 -4820 0 0 {name=p163027 lab=_54585_/B }
C {devices/lab_pin.sym} 163560 -4780 0 0 {name=p163028 lab=_54565_/C }
C {devices/lab_pin.sym} 163560 -4740 0 0 {name=p163029 lab=_47169_/Y }
C {devices/lab_pin.sym} 163680 -4800 0 1 {name=p163030 lab=_54585_/X }
C {sky130_stdcells/and4_4.sym} 163620 -4800 0 0 {name=X_54585_ }
C {devices/lab_pin.sym} 163540 -4670 0 0 {name=p163031 lab=_85944_/Q }
C {devices/lab_pin.sym} 163540 -4630 0 0 {name=p163032 lab=_51789_/X }
C {devices/lab_pin.sym} 163540 -4590 0 0 {name=p163033 lab=_51796_/Y }
C {devices/lab_pin.sym} 163700 -4630 0 1 {name=p163034 lab=_51797_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -4630 0 0 {name=X_51797_ }
C {devices/lab_pin.sym} 163580 -4490 0 0 {name=p163035 lab=clkbuf_8_72_0_CLK/X }
C {devices/lab_pin.sym} 163660 -4490 0 1 {name=p163036 lab=clkbuf_9_145_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 163620 -4490 0 0 {name=Xclkbuf_9_145_0_CLK }
C {devices/lab_pin.sym} 163560 -4380 0 0 {name=p163037 lab=_86680_/Q }
C {devices/lab_pin.sym} 163560 -4340 0 0 {name=p163038 lab=_59189_/B }
C {devices/lab_pin.sym} 163680 -4360 0 1 {name=p163039 lab=_59112_/Y }
C {sky130_stdcells/nor2_4.sym} 163620 -4360 0 0 {name=X_59112_ }
C {devices/lab_pin.sym} 163540 -4250 0 0 {name=p163040 lab=_56074_/X }
C {devices/lab_pin.sym} 163540 -4210 0 0 {name=p163041 lab=_56321_/X }
C {devices/lab_pin.sym} 163540 -4170 0 0 {name=p163042 lab=_56323_/Y }
C {devices/lab_pin.sym} 163700 -4210 0 1 {name=p163043 lab=_85236_/D }
C {sky130_stdcells/o21ai_4.sym} 163620 -4210 0 0 {name=X_56324_ }
C {devices/lab_pin.sym} 163530 -4070 0 0 {name=p163044 lab=_87144_/CLK }
C {devices/lab_pin.sym} 163530 -4050 0 0 {name=p163045 lab=_87144_/D }
C {devices/lab_pin.sym} 163710 -4070 0 1 {name=p163046 lab=_87144_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -4060 0 0 {name=X_87144_ }
C {devices/lab_pin.sym} 163560 -3940 0 0 {name=p163047 lab=_81168_/Q }
C {devices/lab_pin.sym} 163560 -3900 0 0 {name=p163048 lab=_41584_/B }
C {devices/lab_pin.sym} 163680 -3920 0 1 {name=p163049 lab=_41550_/X }
C {sky130_stdcells/or2_4.sym} 163620 -3920 0 0 {name=X_41550_ }
C {devices/lab_pin.sym} 163540 -3810 0 0 {name=p163050 lab=_85617_/Q }
C {devices/lab_pin.sym} 163540 -3770 0 0 {name=p163051 lab=_53466_/X }
C {devices/lab_pin.sym} 163540 -3730 0 0 {name=p163052 lab=_53535_/Y }
C {devices/lab_pin.sym} 163700 -3770 0 1 {name=p163053 lab=_53536_/Y }
C {sky130_stdcells/o21ai_4.sym} 163620 -3770 0 0 {name=X_53536_ }
C {devices/lab_pin.sym} 163580 -3630 0 0 {name=p163054 lab=clkbuf_9_72_0_CLK/A }
C {devices/lab_pin.sym} 163660 -3630 0 1 {name=p163055 lab=clkbuf_9_72_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 163620 -3630 0 0 {name=Xclkbuf_9_72_0_CLK }
C {devices/lab_pin.sym} 163540 -3540 0 0 {name=p163056 lab=_72357_/Y }
C {devices/lab_pin.sym} 163540 -3500 0 0 {name=p163057 lab=_72358_/X }
C {devices/lab_pin.sym} 163540 -3460 0 0 {name=p163058 lab=_72365_/X }
C {devices/lab_pin.sym} 163540 -3420 0 0 {name=p163059 lab=_72369_/X }
C {devices/lab_pin.sym} 163700 -3480 0 1 {name=p163060 lab=_83261_/D }
C {sky130_stdcells/a22oi_4.sym} 163620 -3480 0 0 {name=X_72370_ }
C {devices/lab_pin.sym} 163530 -3330 0 0 {name=p163061 lab=_84308_/CLK }
C {devices/lab_pin.sym} 163530 -3310 0 0 {name=p163062 lab=_84356_/D }
C {devices/lab_pin.sym} 163710 -3330 0 1 {name=p163063 lab=_79456_/A }
C {sky130_stdcells/dfxtp_4.sym} 163620 -3320 0 0 {name=X_84356_ }
C {devices/lab_pin.sym} 163560 -3200 0 0 {name=p163064 lab=_50799_/A }
C {devices/lab_pin.sym} 163560 -3160 0 0 {name=p163065 lab=_46295_/X }
C {devices/lab_pin.sym} 163680 -3180 0 1 {name=p163066 lab=_50748_/Y }
C {sky130_stdcells/nand2_4.sym} 163620 -3180 0 0 {name=X_50748_ }
C {devices/lab_pin.sym} 163530 -3050 0 0 {name=p163067 lab=_81473_/CLK }
C {devices/lab_pin.sym} 163530 -3030 0 0 {name=p163068 lab=_81568_/D }
C {devices/lab_pin.sym} 163710 -3050 0 1 {name=p163069 lab=_81568_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -3040 0 0 {name=X_81568_ }
C {devices/lab_pin.sym} 163580 -2910 0 0 {name=p163070 lab=_40500_/X }
C {devices/lab_pin.sym} 163660 -2910 0 1 {name=p163071 lab=_40501_/X }
C {sky130_stdcells/buf_2.sym} 163620 -2910 0 0 {name=X_40501_ }
C {devices/lab_pin.sym} 163580 -2790 0 0 {name=p163072 lab=_59043_/A }
C {devices/lab_pin.sym} 163660 -2790 0 1 {name=p163073 lab=_59043_/X }
C {sky130_stdcells/buf_2.sym} 163620 -2790 0 0 {name=X_59043_ }
C {devices/lab_pin.sym} 163560 -2690 0 0 {name=p163074 lab=_71323_/A }
C {devices/lab_pin.sym} 163560 -2650 0 0 {name=p163075 lab=_71314_/B }
C {devices/lab_pin.sym} 163560 -2610 0 0 {name=p163076 lab=_71672_/C }
C {devices/lab_pin.sym} 163680 -2650 0 1 {name=p163077 lab=_71321_/Y }
C {sky130_stdcells/nand3_4.sym} 163620 -2650 0 0 {name=X_71321_ }
C {devices/lab_pin.sym} 163530 -2510 0 0 {name=p163078 lab=_83307_/CLK }
C {devices/lab_pin.sym} 163530 -2490 0 0 {name=p163079 lab=_71990_/Y }
C {devices/lab_pin.sym} 163710 -2510 0 1 {name=p163080 lab=_83307_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -2500 0 0 {name=X_83307_ }
C {devices/lab_pin.sym} 163560 -2380 0 0 {name=p163081 lab=_80531_/A }
C {devices/lab_pin.sym} 163560 -2340 0 0 {name=p163082 lab=_80531_/B }
C {devices/lab_pin.sym} 163680 -2360 0 1 {name=p163083 lab=_80530_/A }
C {sky130_stdcells/xor2_4.sym} 163620 -2360 0 0 {name=X_80519_ }
C {devices/lab_pin.sym} 163580 -2230 0 0 {name=p163084 lab=_56255_/A }
C {devices/lab_pin.sym} 163660 -2230 0 1 {name=p163085 lab=_56255_/X }
C {sky130_stdcells/buf_2.sym} 163620 -2230 0 0 {name=X_56255_ }
C {devices/lab_pin.sym} 163530 -2110 0 0 {name=p163086 lab=_88247_/CLK }
C {devices/lab_pin.sym} 163530 -2090 0 0 {name=p163087 lab=_44506_/X }
C {devices/lab_pin.sym} 163710 -2110 0 1 {name=p163088 lab=_87075_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -2100 0 0 {name=X_87075_ }
C {devices/lab_pin.sym} 163580 -1970 0 0 {name=p163089 lab=_41411_/X }
C {devices/lab_pin.sym} 163660 -1970 0 1 {name=p163090 lab=_41481_/X }
C {sky130_stdcells/buf_2.sym} 163620 -1970 0 0 {name=X_41481_ }
C {devices/lab_pin.sym} 163580 -1850 0 0 {name=p163091 lab=_54067_/A }
C {devices/lab_pin.sym} 163660 -1850 0 1 {name=p163092 lab=_53468_/A }
C {sky130_stdcells/buf_2.sym} 163620 -1850 0 0 {name=X_53467_ }
C {devices/lab_pin.sym} 163530 -1730 0 0 {name=p163093 lab=_84287_/CLK }
C {devices/lab_pin.sym} 163530 -1710 0 0 {name=p163094 lab=_84287_/D }
C {devices/lab_pin.sym} 163710 -1730 0 1 {name=p163095 lab=_63914_/C }
C {sky130_stdcells/dfxtp_4.sym} 163620 -1720 0 0 {name=X_84287_ }
C {devices/lab_pin.sym} 163580 -1590 0 0 {name=p163096 lab=clkbuf_9_334_0_CLK/X }
C {devices/lab_pin.sym} 163660 -1590 0 1 {name=p163097 lab=_88387_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 163620 -1590 0 0 {name=Xclkbuf_10_669_0_CLK }
C {devices/lab_pin.sym} 163580 -1470 0 0 {name=p163098 lab=_50655_/A }
C {devices/lab_pin.sym} 163660 -1470 0 1 {name=p163099 lab=_50742_/A }
C {sky130_stdcells/buf_2.sym} 163620 -1470 0 0 {name=X_50679_ }
C {devices/lab_pin.sym} 163530 -1350 0 0 {name=p163100 lab=_84064_/CLK }
C {devices/lab_pin.sym} 163530 -1330 0 0 {name=p163101 lab=_81499_/D }
C {devices/lab_pin.sym} 163710 -1350 0 1 {name=p163102 lab=_76873_/A }
C {sky130_stdcells/dfxtp_4.sym} 163620 -1340 0 0 {name=X_81499_ }
C {devices/lab_pin.sym} 163540 -1250 0 0 {name=p163103 lab=_43196_/X }
C {devices/lab_pin.sym} 163540 -1210 0 0 {name=p163104 lab=_43207_/X }
C {devices/lab_pin.sym} 163540 -1170 0 0 {name=p163105 lab=_40972_/X }
C {devices/lab_pin.sym} 163540 -1130 0 0 {name=p163106 lab=_87532_/Q }
C {devices/lab_pin.sym} 163540 -1090 0 0 {name=p163107 lab=_43212_/X }
C {devices/lab_pin.sym} 163700 -1170 0 1 {name=p163108 lab=_43221_/A }
C {sky130_stdcells/o32ai_4.sym} 163620 -1170 0 0 {name=X_43220_ }
C {devices/lab_pin.sym} 163540 -1030 0 0 {name=p163109 lab=_55203_/X }
C {devices/lab_pin.sym} 163540 -990 0 0 {name=p163110 lab=_55205_/X }
C {devices/lab_pin.sym} 163540 -950 0 0 {name=p163111 lab=_44109_/X }
C {devices/lab_pin.sym} 163700 -990 0 1 {name=p163112 lab=_72712_/C }
C {sky130_stdcells/a21o_4.sym} 163620 -990 0 0 {name=X_55206_ }
C {devices/lab_pin.sym} 163530 -850 0 0 {name=p163113 lab=_86122_/CLK }
C {devices/lab_pin.sym} 163530 -830 0 0 {name=p163114 lab=_51357_/Y }
C {devices/lab_pin.sym} 163710 -850 0 1 {name=p163115 lab=_86026_/Q }
C {sky130_stdcells/dfxtp_4.sym} 163620 -840 0 0 {name=X_86026_ }
C {devices/lab_pin.sym} 163560 -720 0 0 {name=p163116 lab=_73972_/X }
C {devices/lab_pin.sym} 163560 -680 0 0 {name=p163117 lab=_66198_/B }
C {devices/lab_pin.sym} 163680 -700 0 1 {name=p163118 lab=_74040_/X }
C {sky130_stdcells/and2_4.sym} 163620 -700 0 0 {name=X_74040_ }
C {devices/lab_pin.sym} 164500 -42150 0 0 {name=p163119 lab=_40431_/X }
C {devices/lab_pin.sym} 164580 -42150 0 1 {name=p163120 lab=_40432_/X }
C {sky130_stdcells/buf_2.sym} 164540 -42150 0 0 {name=X_40432_ }
C {devices/lab_pin.sym} 164480 -42040 0 0 {name=p163121 lab=_52400_/X }
C {devices/lab_pin.sym} 164480 -42000 0 0 {name=p163122 lab=_50721_/B }
C {devices/lab_pin.sym} 164600 -42020 0 1 {name=p163123 lab=_52418_/Y }
C {sky130_stdcells/nand2_4.sym} 164540 -42020 0 0 {name=X_52418_ }
C {devices/lab_pin.sym} 164480 -41910 0 0 {name=p163124 lab=_71252_/A }
C {devices/lab_pin.sym} 164480 -41870 0 0 {name=p163125 lab=_71228_/B }
C {devices/lab_pin.sym} 164480 -41830 0 0 {name=p163126 lab=_71248_/C }
C {devices/lab_pin.sym} 164600 -41870 0 1 {name=p163127 lab=_71252_/Y }
C {sky130_stdcells/nand3_4.sym} 164540 -41870 0 0 {name=X_71252_ }
C {devices/lab_pin.sym} 164450 -41730 0 0 {name=p163128 lab=_83238_/CLK }
C {devices/lab_pin.sym} 164450 -41710 0 0 {name=p163129 lab=_83238_/D }
C {devices/lab_pin.sym} 164630 -41730 0 1 {name=p163130 lab=_79476_/B }
C {sky130_stdcells/dfxtp_4.sym} 164540 -41720 0 0 {name=X_83238_ }
C {devices/lab_pin.sym} 164480 -41620 0 0 {name=p163131 lab=_56183_/X }
C {devices/lab_pin.sym} 164480 -41580 0 0 {name=p163132 lab=_56460_/B }
C {devices/lab_pin.sym} 164480 -41540 0 0 {name=p163133 lab=_56278_/A }
C {devices/lab_pin.sym} 164480 -41500 0 0 {name=p163134 lab=_56460_/D }
C {devices/lab_pin.sym} 164600 -41560 0 1 {name=p163135 lab=_56186_/Y }
C {sky130_stdcells/nand4_4.sym} 164540 -41560 0 0 {name=X_56186_ }
C {devices/lab_pin.sym} 164460 -41430 0 0 {name=p163136 lab=_53396_/Y }
C {devices/lab_pin.sym} 164460 -41390 0 0 {name=p163137 lab=_53382_/X }
C {devices/lab_pin.sym} 164460 -41350 0 0 {name=p163138 lab=_53397_/X }
C {devices/lab_pin.sym} 164620 -41390 0 1 {name=p163139 lab=_85641_/D }
C {sky130_stdcells/a21oi_4.sym} 164540 -41390 0 0 {name=X_53398_ }
C {devices/lab_pin.sym} 164500 -41250 0 0 {name=p163140 lab=clkbuf_2_3_1_CLK/X }
C {devices/lab_pin.sym} 164580 -41250 0 1 {name=p163141 lab=clkbuf_3_6_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 164540 -41250 0 0 {name=Xclkbuf_2_3_2_CLK }
C {devices/lab_pin.sym} 164500 -41130 0 0 {name=p163142 lab=_70232_/A }
C {devices/lab_pin.sym} 164580 -41130 0 1 {name=p163143 lab=_70214_/B }
C {sky130_stdcells/buf_2.sym} 164540 -41130 0 0 {name=X_70203_ }
C {devices/lab_pin.sym} 164500 -41010 0 0 {name=p163144 lab=clkbuf_9_87_0_CLK/A }
C {devices/lab_pin.sym} 164580 -41010 0 1 {name=p163145 lab=clkbuf_9_87_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 164540 -41010 0 0 {name=Xclkbuf_9_87_0_CLK }
C {devices/lab_pin.sym} 164500 -40890 0 0 {name=p163146 lab=_43151_/A }
C {devices/lab_pin.sym} 164580 -40890 0 1 {name=p163147 lab=_43151_/Y }
C {sky130_stdcells/inv_2.sym} 164540 -40890 0 0 {name=X_43151_ }
C {devices/lab_pin.sym} 164500 -40770 0 0 {name=p163148 lab=_80666_/Q }
C {devices/lab_pin.sym} 164580 -40770 0 1 {name=p163149 lab=_55138_/A }
C {sky130_stdcells/buf_2.sym} 164540 -40770 0 0 {name=X_55137_ }
C {devices/lab_pin.sym} 164500 -40650 0 0 {name=p163150 lab=_40362_/X }
C {devices/lab_pin.sym} 164580 -40650 0 1 {name=p163151 lab=_40363_/X }
C {sky130_stdcells/buf_2.sym} 164540 -40650 0 0 {name=X_40363_ }
C {devices/lab_pin.sym} 164480 -40540 0 0 {name=p163152 lab=_52349_/A }
C {devices/lab_pin.sym} 164480 -40500 0 0 {name=p163153 lab=_50649_/B }
C {devices/lab_pin.sym} 164600 -40520 0 1 {name=p163154 lab=_52349_/Y }
C {sky130_stdcells/nand2_4.sym} 164540 -40520 0 0 {name=X_52349_ }
C {devices/lab_pin.sym} 164480 -40420 0 0 {name=p163155 lab=_71183_/A }
C {devices/lab_pin.sym} 164480 -40380 0 0 {name=p163156 lab=_71185_/B }
C {devices/lab_pin.sym} 164480 -40340 0 0 {name=p163157 lab=_70966_/A }
C {devices/lab_pin.sym} 164480 -40300 0 0 {name=p163158 lab=_74518_/D }
C {devices/lab_pin.sym} 164600 -40360 0 1 {name=p163159 lab=_71183_/Y }
C {sky130_stdcells/nand4_4.sym} 164540 -40360 0 0 {name=X_71183_ }
C {devices/lab_pin.sym} 164450 -40210 0 0 {name=p163160 lab=_83507_/CLK }
C {devices/lab_pin.sym} 164450 -40190 0 0 {name=p163161 lab=_72999_/X }
C {devices/lab_pin.sym} 164630 -40210 0 1 {name=p163162 lab=_83169_/Q }
C {sky130_stdcells/dfxtp_4.sym} 164540 -40200 0 0 {name=X_83169_ }
C {devices/lab_pin.sym} 164460 -40100 0 0 {name=p163163 lab=_41028_/X }
C {devices/lab_pin.sym} 164460 -40060 0 0 {name=p163164 lab=_42072_/X }
C {devices/lab_pin.sym} 164460 -40020 0 0 {name=p163165 lab=_88035_/Q }
C {devices/lab_pin.sym} 164460 -39980 0 0 {name=p163166 lab=_42073_/X }
C {devices/lab_pin.sym} 164620 -40040 0 1 {name=p163167 lab=_42102_/X }
C {sky130_stdcells/a2bb2o_4.sym} 164540 -40040 0 0 {name=X_42102_ }
C {devices/lab_pin.sym} 164480 -39920 0 0 {name=p163168 lab=_70131_/X }
C {devices/lab_pin.sym} 164480 -39880 0 0 {name=p163169 lab=_70134_/B }
C {devices/lab_pin.sym} 164480 -39840 0 0 {name=p163170 lab=_70134_/C }
C {devices/lab_pin.sym} 164480 -39800 0 0 {name=p163171 lab=_86754_/Q }
C {devices/lab_pin.sym} 164600 -39860 0 1 {name=p163172 lab=_70134_/X }
C {sky130_stdcells/and4_4.sym} 164540 -39860 0 0 {name=X_70134_ }
C {devices/lab_pin.sym} 164500 -39710 0 0 {name=p163173 lab=_43081_/Y }
C {devices/lab_pin.sym} 164580 -39710 0 1 {name=p163174 lab=_43082_/Y }
C {sky130_stdcells/inv_2.sym} 164540 -39710 0 0 {name=X_43082_ }
C {devices/lab_pin.sym} 164460 -39610 0 0 {name=p163175 lab=_85324_/Q }
C {devices/lab_pin.sym} 164460 -39570 0 0 {name=p163176 lab=_55046_/X }
C {devices/lab_pin.sym} 164460 -39530 0 0 {name=p163177 lab=_55067_/Y }
C {devices/lab_pin.sym} 164620 -39570 0 1 {name=p163178 lab=_55068_/Y }
C {sky130_stdcells/o21ai_4.sym} 164540 -39570 0 0 {name=X_55068_ }
C {devices/lab_pin.sym} 164480 -39450 0 0 {name=p163179 lab=_62504_/A }
C {devices/lab_pin.sym} 164480 -39410 0 0 {name=p163180 lab=_62534_/A }
C {devices/lab_pin.sym} 164480 -39370 0 0 {name=p163181 lab=_62532_/A }
C {devices/lab_pin.sym} 164600 -39410 0 1 {name=p163182 lab=_59945_/Y }
C {sky130_stdcells/nand3_4.sym} 164540 -39410 0 0 {name=X_59945_ }
C {devices/lab_pin.sym} 164480 -39280 0 0 {name=p163183 lab=_81707_/D }
C {devices/lab_pin.sym} 164480 -39240 0 0 {name=p163184 lab=_75991_/B }
C {devices/lab_pin.sym} 164600 -39260 0 1 {name=p163185 lab=_75991_/Y }
C {sky130_stdcells/nor2_4.sym} 164540 -39260 0 0 {name=X_75991_ }
C {devices/lab_pin.sym} 164450 -39130 0 0 {name=p163186 lab=_88158_/CLK }
C {devices/lab_pin.sym} 164450 -39110 0 0 {name=p163187 lab=_42215_/Y }
C {devices/lab_pin.sym} 164630 -39130 0 1 {name=p163188 lab=_87977_/Q }
C {sky130_stdcells/dfxtp_4.sym} 164540 -39120 0 0 {name=X_87977_ }
C {devices/lab_pin.sym} 164500 -38990 0 0 {name=p163189 lab=_46909_/X }
C {devices/lab_pin.sym} 164580 -38990 0 1 {name=p163190 lab=_46948_/A }
C {sky130_stdcells/buf_2.sym} 164540 -38990 0 0 {name=X_46910_ }
C {devices/lab_pin.sym} 164460 -38910 0 0 {name=p163191 lab=_42028_/X }
C {devices/lab_pin.sym} 164460 -38870 0 0 {name=p163192 lab=_42024_/X }
C {devices/lab_pin.sym} 164460 -38830 0 0 {name=p163193 lab=_40874_/X }
C {devices/lab_pin.sym} 164460 -38790 0 0 {name=p163194 lab=_73273_/A }
C {devices/lab_pin.sym} 164460 -38750 0 0 {name=p163195 lab=_42025_/X }
C {devices/lab_pin.sym} 164620 -38830 0 1 {name=p163196 lab=_42034_/A }
C {sky130_stdcells/o32ai_4.sym} 164540 -38830 0 0 {name=X_42033_ }
C {devices/lab_pin.sym} 164500 -38670 0 0 {name=p163197 lab=_53990_/A }
C {devices/lab_pin.sym} 164580 -38670 0 1 {name=p163198 lab=_54020_/A }
C {sky130_stdcells/buf_2.sym} 164540 -38670 0 0 {name=X_54019_ }
C {devices/lab_pin.sym} 164480 -38560 0 0 {name=p163199 lab=_77730_/A }
C {devices/lab_pin.sym} 164480 -38520 0 0 {name=p163200 lab=_82258_/Q }
C {devices/lab_pin.sym} 164600 -38540 0 1 {name=p163201 lab=_77730_/Y }
C {sky130_stdcells/nand2_4.sym} 164540 -38540 0 0 {name=X_77730_ }
C {devices/lab_pin.sym} 164500 -38410 0 0 {name=p163202 lab=clkbuf_8_5_0_CLK/X }
C {devices/lab_pin.sym} 164580 -38410 0 1 {name=p163203 lab=clkbuf_9_10_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 164540 -38410 0 0 {name=Xclkbuf_9_10_0_CLK }
C {devices/lab_pin.sym} 164480 -38300 0 0 {name=p163204 lab=_74942_/A }
C {devices/lab_pin.sym} 164480 -38260 0 0 {name=p163205 lab=_74942_/B }
C {devices/lab_pin.sym} 164600 -38280 0 1 {name=p163206 lab=_74943_/B }
C {sky130_stdcells/and2_4.sym} 164540 -38280 0 0 {name=X_74942_ }
C {devices/lab_pin.sym} 164480 -38170 0 0 {name=p163207 lab=_70063_/X }
C {devices/lab_pin.sym} 164480 -38130 0 0 {name=p163208 lab=_70064_/X }
C {devices/lab_pin.sym} 164480 -38090 0 0 {name=p163209 lab=_70021_/C }
C {devices/lab_pin.sym} 164600 -38130 0 1 {name=p163210 lab=_70065_/Y }
C {sky130_stdcells/nand3_4.sym} 164540 -38130 0 0 {name=X_70065_ }
C {devices/lab_pin.sym} 164450 -37990 0 0 {name=p163211 lab=_87144_/CLK }
C {devices/lab_pin.sym} 164450 -37970 0 0 {name=p163212 lab=_86928_/D }
C {devices/lab_pin.sym} 164630 -37990 0 1 {name=p163213 lab=_67693_/B }
C {sky130_stdcells/dfxtp_4.sym} 164540 -37980 0 0 {name=X_86928_ }
C {devices/lab_pin.sym} 164500 -37850 0 0 {name=p163214 lab=_73692_/A }
C {devices/lab_pin.sym} 164580 -37850 0 1 {name=p163215 lab=_50260_/B }
C {sky130_stdcells/buf_2.sym} 164540 -37850 0 0 {name=X_47890_ }
C {devices/lab_pin.sym} 164480 -37750 0 0 {name=p163216 lab=_59571_/B }
C {devices/lab_pin.sym} 164480 -37710 0 0 {name=p163217 lab=_59876_/B }
C {devices/lab_pin.sym} 164480 -37670 0 0 {name=p163218 lab=_59543_/A }
C {devices/lab_pin.sym} 164600 -37710 0 1 {name=p163219 lab=_59876_/X }
C {sky130_stdcells/and3_4.sym} 164540 -37710 0 0 {name=X_59876_ }
C {devices/lab_pin.sym} 164500 -37570 0 0 {name=p163220 lab=_52706_/B }
C {devices/lab_pin.sym} 164580 -37570 0 1 {name=p163221 lab=_51016_/B }
C {sky130_stdcells/buf_2.sym} 164540 -37570 0 0 {name=X_46841_ }
C {devices/lab_pin.sym} 164500 -37450 0 0 {name=p163222 lab=_58827_/A }
C {devices/lab_pin.sym} 164580 -37450 0 1 {name=p163223 lab=_58918_/A }
C {sky130_stdcells/buf_2.sym} 164540 -37450 0 0 {name=X_58827_ }
C {devices/lab_pin.sym} 164480 -37340 0 0 {name=p163224 lab=_77693_/A }
C {devices/lab_pin.sym} 164480 -37300 0 0 {name=p163225 lab=_77693_/C }
C {devices/lab_pin.sym} 164600 -37320 0 1 {name=p163226 lab=_77661_/X }
C {sky130_stdcells/and2_4.sym} 164540 -37320 0 0 {name=X_77661_ }
C {devices/lab_pin.sym} 164480 -37200 0 0 {name=p163227 lab=_74897_/A }
C {devices/lab_pin.sym} 164480 -37160 0 0 {name=p163228 lab=_74872_/Y }
C {devices/lab_pin.sym} 164600 -37180 0 1 {name=p163229 lab=_74874_/B }
C {sky130_stdcells/xor2_4.sym} 164540 -37180 0 0 {name=X_74873_ }
C {devices/lab_pin.sym} 164450 -37050 0 0 {name=p163230 lab=_80672_/CLK }
C {devices/lab_pin.sym} 164450 -37030 0 0 {name=p163231 lab=_45718_/Y }
C {devices/lab_pin.sym} 164630 -37050 0 1 {name=p163232 lab=_63241_/B }
C {sky130_stdcells/dfxtp_4.sym} 164540 -37040 0 0 {name=X_86859_ }
C {devices/lab_pin.sym} 164500 -36910 0 0 {name=p163233 lab=clkbuf_9_303_0_CLK/X }
C {devices/lab_pin.sym} 164580 -36910 0 1 {name=p163234 lab=_82104_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 164540 -36910 0 0 {name=Xclkbuf_10_607_0_CLK }
C {devices/lab_pin.sym} 164460 -36810 0 0 {name=p163235 lab=_79397_/Y }
C {devices/lab_pin.sym} 164460 -36770 0 0 {name=p163236 lab=_79381_/B }
C {devices/lab_pin.sym} 164460 -36730 0 0 {name=p163237 lab=_79399_/X }
C {devices/lab_pin.sym} 164620 -36770 0 1 {name=p163238 lab=_79401_/B }
C {sky130_stdcells/o21ai_4.sym} 164540 -36770 0 0 {name=X_79400_ }
C {devices/lab_pin.sym} 164500 -36630 0 0 {name=p163239 lab=_76611_/Y }
C {devices/lab_pin.sym} 164580 -36630 0 1 {name=p163240 lab=_76613_/B }
C {sky130_stdcells/inv_2.sym} 164540 -36630 0 0 {name=X_76612_ }
C {devices/lab_pin.sym} 164500 -36510 0 0 {name=p163241 lab=_49614_/A }
C {devices/lab_pin.sym} 164580 -36510 0 1 {name=p163242 lab=_49561_/B }
C {sky130_stdcells/buf_2.sym} 164540 -36510 0 0 {name=X_49560_ }
C {devices/lab_pin.sym} 164460 -36410 0 0 {name=p163243 lab=_73821_/X }
C {devices/lab_pin.sym} 164460 -36370 0 0 {name=p163244 lab=_73823_/X }
C {devices/lab_pin.sym} 164460 -36330 0 0 {name=p163245 lab=_73799_/X }
C {devices/lab_pin.sym} 164620 -36370 0 1 {name=p163246 lab=_73838_/B }
C {sky130_stdcells/a21o_4.sym} 164540 -36370 0 0 {name=X_73824_ }
C {devices/lab_pin.sym} 164460 -36250 0 0 {name=p163247 lab=_58776_/A }
C {devices/lab_pin.sym} 164460 -36210 0 0 {name=p163248 lab=_46767_/X }
C {devices/lab_pin.sym} 164460 -36170 0 0 {name=p163249 lab=_46771_/Y }
C {devices/lab_pin.sym} 164620 -36210 0 1 {name=p163250 lab=_46772_/Y }
C {sky130_stdcells/o21ai_4.sym} 164540 -36210 0 0 {name=X_46772_ }
C {devices/lab_pin.sym} 164460 -36090 0 0 {name=p163251 lab=_58740_/X }
C {devices/lab_pin.sym} 164460 -36050 0 0 {name=p163252 lab=_85458_/Q }
C {devices/lab_pin.sym} 164460 -36010 0 0 {name=p163253 lab=_58757_/X }
C {devices/lab_pin.sym} 164620 -36050 0 1 {name=p163254 lab=_58758_/Y }
C {sky130_stdcells/o21ai_4.sym} 164540 -36050 0 0 {name=X_58758_ }
C {devices/lab_pin.sym} 164480 -35940 0 0 {name=p163255 lab=_77559_/A }
C {devices/lab_pin.sym} 164480 -35900 0 0 {name=p163256 lab=_77576_/A }
C {devices/lab_pin.sym} 164480 -35860 0 0 {name=p163257 lab=_77559_/B }
C {devices/lab_pin.sym} 164480 -35820 0 0 {name=p163258 lab=_77576_/B }
C {devices/lab_pin.sym} 164600 -35880 0 1 {name=p163259 lab=_77592_/X }
C {sky130_stdcells/and4_4.sym} 164540 -35880 0 0 {name=X_77592_ }
C {devices/lab_pin.sym} 164480 -35740 0 0 {name=p163260 lab=_44232_/B }
C {devices/lab_pin.sym} 164480 -35700 0 0 {name=p163261 lab=_43987_/B }
C {devices/lab_pin.sym} 164600 -35720 0 1 {name=p163262 lab=_43984_/Y }
C {sky130_stdcells/nor2_4.sym} 164540 -35720 0 0 {name=X_43984_ }
C {devices/lab_pin.sym} 164480 -35610 0 0 {name=p163263 lab=_52166_/A }
C {devices/lab_pin.sym} 164480 -35570 0 0 {name=p163264 lab=_48500_/X }
C {devices/lab_pin.sym} 164480 -35530 0 0 {name=p163265 lab=_48533_/C }
C {devices/lab_pin.sym} 164600 -35570 0 1 {name=p163266 lab=_48511_/X }
C {sky130_stdcells/and3_4.sym} 164540 -35570 0 0 {name=X_48511_ }
C {devices/lab_pin.sym} 164480 -35440 0 0 {name=p163267 lab=_79331_/A }
C {devices/lab_pin.sym} 164480 -35400 0 0 {name=p163268 lab=_79331_/B }
C {devices/lab_pin.sym} 164600 -35420 0 1 {name=p163269 lab=_79346_/B }
C {sky130_stdcells/xnor2_4.sym} 164540 -35420 0 0 {name=X_79331_ }
C {devices/lab_pin.sym} 164500 -35290 0 0 {name=p163270 lab=clkbuf_9_25_0_CLK/A }
C {devices/lab_pin.sym} 164580 -35290 0 1 {name=p163271 lab=clkbuf_9_25_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 164540 -35290 0 0 {name=Xclkbuf_9_25_0_CLK }
C {devices/lab_pin.sym} 164460 -35190 0 0 {name=p163272 lab=_85004_/Q }
C {devices/lab_pin.sym} 164460 -35150 0 0 {name=p163273 lab=_45705_/X }
C {devices/lab_pin.sym} 164460 -35110 0 0 {name=p163274 lab=_45691_/X }
C {devices/lab_pin.sym} 164620 -35150 0 1 {name=p163275 lab=_45723_/X }
C {sky130_stdcells/o21a_4.sym} 164540 -35150 0 0 {name=X_45723_ }
C {devices/lab_pin.sym} 164500 -35010 0 0 {name=p163276 lab=_57708_/X }
C {devices/lab_pin.sym} 164580 -35010 0 1 {name=p163277 lab=_57709_/X }
C {sky130_stdcells/buf_2.sym} 164540 -35010 0 0 {name=X_57709_ }
C {devices/lab_pin.sym} 164480 -34900 0 0 {name=p163278 lab=_76584_/A }
C {devices/lab_pin.sym} 164480 -34860 0 0 {name=p163279 lab=_76517_/A }
C {devices/lab_pin.sym} 164600 -34880 0 1 {name=p163280 lab=_76543_/X }
C {sky130_stdcells/and2_4.sym} 164540 -34880 0 0 {name=X_76543_ }
C {devices/lab_pin.sym} 164460 -34790 0 0 {name=p163281 lab=_42916_/X }
C {devices/lab_pin.sym} 164460 -34750 0 0 {name=p163282 lab=_42917_/X }
C {devices/lab_pin.sym} 164460 -34710 0 0 {name=p163283 lab=_41757_/X }
C {devices/lab_pin.sym} 164460 -34670 0 0 {name=p163284 lab=_67912_/B }
C {devices/lab_pin.sym} 164460 -34630 0 0 {name=p163285 lab=_42934_/X }
C {devices/lab_pin.sym} 164620 -34710 0 1 {name=p163286 lab=_42936_/A }
C {sky130_stdcells/o32ai_4.sym} 164540 -34710 0 0 {name=X_42935_ }
C {devices/lab_pin.sym} 164480 -34560 0 0 {name=p163287 lab=_49481_/A }
C {devices/lab_pin.sym} 164480 -34520 0 0 {name=p163288 lab=_51016_/B }
C {devices/lab_pin.sym} 164600 -34540 0 1 {name=p163289 lab=_49491_/Y }
C {sky130_stdcells/nand2_4.sym} 164540 -34540 0 0 {name=X_49491_ }
C {devices/lab_pin.sym} 164460 -34430 0 0 {name=p163290 lab=_88363_/Q }
C {devices/lab_pin.sym} 164460 -34390 0 0 {name=p163291 lab=_73633_/X }
C {devices/lab_pin.sym} 164460 -34350 0 0 {name=p163292 lab=_73704_/X }
C {devices/lab_pin.sym} 164620 -34390 0 1 {name=p163293 lab=_73755_/Y }
C {sky130_stdcells/o21ai_4.sym} 164540 -34390 0 0 {name=X_73755_ }
C {devices/lab_pin.sym} 164480 -34270 0 0 {name=p163294 lab=_70969_/A }
C {devices/lab_pin.sym} 164480 -34230 0 0 {name=p163295 lab=_70945_/B }
C {devices/lab_pin.sym} 164480 -34190 0 0 {name=p163296 lab=_70969_/C }
C {devices/lab_pin.sym} 164600 -34230 0 1 {name=p163297 lab=_70967_/Y }
C {sky130_stdcells/nand3_4.sym} 164540 -34230 0 0 {name=X_70967_ }
C {devices/lab_pin.sym} 164460 -34130 0 0 {name=p163298 lab=_58585_/X }
C {devices/lab_pin.sym} 164460 -34090 0 0 {name=p163299 lab=_58687_/Y }
C {devices/lab_pin.sym} 164460 -34050 0 0 {name=p163300 lab=_58688_/Y }
C {devices/lab_pin.sym} 164460 -34010 0 0 {name=p163301 lab=_58603_/X }
C {devices/lab_pin.sym} 164460 -33970 0 0 {name=p163302 lab=_58589_/X }
C {devices/lab_pin.sym} 164620 -34050 0 1 {name=p163303 lab=_58689_/X }
C {sky130_stdcells/o32a_4.sym} 164540 -34050 0 0 {name=X_58689_ }
C {devices/lab_pin.sym} 164500 -33890 0 0 {name=p163304 lab=_60720_/A }
C {devices/lab_pin.sym} 164580 -33890 0 1 {name=p163305 lab=_63413_/A }
C {sky130_stdcells/buf_2.sym} 164540 -33890 0 0 {name=X_60720_ }
C {devices/lab_pin.sym} 164480 -33790 0 0 {name=p163306 lab=_52135_/A }
C {devices/lab_pin.sym} 164480 -33750 0 0 {name=p163307 lab=_48489_/B }
C {devices/lab_pin.sym} 164480 -33710 0 0 {name=p163308 lab=_48476_/C }
C {devices/lab_pin.sym} 164600 -33750 0 1 {name=p163309 lab=_48442_/X }
C {sky130_stdcells/and3_4.sym} 164540 -33750 0 0 {name=X_48442_ }
C {devices/lab_pin.sym} 164480 -33630 0 0 {name=p163310 lab=_72714_/A }
C {devices/lab_pin.sym} 164480 -33590 0 0 {name=p163311 lab=_72714_/B }
C {devices/lab_pin.sym} 164480 -33550 0 0 {name=p163312 lab=_56868_/X }
C {devices/lab_pin.sym} 164600 -33590 0 1 {name=p163313 lab=_72706_/Y }
C {sky130_stdcells/nand3_4.sym} 164540 -33590 0 0 {name=X_72706_ }
C {devices/lab_pin.sym} 164460 -33470 0 0 {name=p163314 lab=_79250_/Y }
C {devices/lab_pin.sym} 164460 -33430 0 0 {name=p163315 lab=_79253_/Y }
C {devices/lab_pin.sym} 164460 -33390 0 0 {name=p163316 lab=_79247_/X }
C {devices/lab_pin.sym} 164620 -33430 0 1 {name=p163317 lab=_79263_/B }
C {sky130_stdcells/o21ai_4.sym} 164540 -33430 0 0 {name=X_79262_ }
C {devices/lab_pin.sym} 164480 -33300 0 0 {name=p163318 lab=_45654_/A }
C {devices/lab_pin.sym} 164480 -33260 0 0 {name=p163319 lab=_45654_/B }
C {devices/lab_pin.sym} 164600 -33280 0 1 {name=p163320 lab=_45654_/Y }
C {sky130_stdcells/nand2_4.sym} 164540 -33280 0 0 {name=X_45654_ }
C {devices/lab_pin.sym} 164480 -33170 0 0 {name=p163321 lab=_76474_/A }
C {devices/lab_pin.sym} 164480 -33130 0 0 {name=p163322 lab=_76471_/Y }
C {devices/lab_pin.sym} 164480 -33090 0 0 {name=p163323 lab=_76473_/Y }
C {devices/lab_pin.sym} 164600 -33130 0 1 {name=p163324 lab=_76474_/X }
C {sky130_stdcells/or3_4.sym} 164540 -33130 0 0 {name=X_76474_ }
C {devices/lab_pin.sym} 164500 -32990 0 0 {name=p163325 lab=_42820_/X }
C {devices/lab_pin.sym} 164580 -32990 0 1 {name=p163326 lab=_42866_/X }
C {sky130_stdcells/buf_2.sym} 164540 -32990 0 0 {name=X_42866_ }
C {devices/lab_pin.sym} 164480 -32880 0 0 {name=p163327 lab=_73638_/A }
C {devices/lab_pin.sym} 164480 -32840 0 0 {name=p163328 lab=_65977_/B }
C {devices/lab_pin.sym} 164600 -32860 0 1 {name=p163329 lab=_73686_/X }
C {sky130_stdcells/and2_4.sym} 164540 -32860 0 0 {name=X_73686_ }
C {devices/lab_pin.sym} 164460 -32750 0 0 {name=p163330 lab=_50987_/B }
C {devices/lab_pin.sym} 164460 -32710 0 0 {name=p163331 lab=_70885_/X }
C {devices/lab_pin.sym} 164460 -32670 0 0 {name=p163332 lab=_70897_/Y }
C {devices/lab_pin.sym} 164620 -32710 0 1 {name=p163333 lab=_70898_/Y }
C {sky130_stdcells/o21ai_4.sym} 164540 -32710 0 0 {name=X_70898_ }
C {devices/lab_pin.sym} 164480 -32580 0 0 {name=p163334 lab=_78213_/A }
C {devices/lab_pin.sym} 164480 -32540 0 0 {name=p163335 lab=_78213_/B }
C {devices/lab_pin.sym} 164600 -32560 0 1 {name=p163336 lab=_78220_/C }
C {sky130_stdcells/nand2_4.sym} 164540 -32560 0 0 {name=X_78213_ }
C {devices/lab_pin.sym} 164460 -32460 0 0 {name=p163337 lab=_40938_/Y }
C {devices/lab_pin.sym} 164460 -32420 0 0 {name=p163338 lab=_44602_/X }
C {devices/lab_pin.sym} 164460 -32380 0 0 {name=p163339 lab=_87038_/Q }
C {devices/lab_pin.sym} 164460 -32340 0 0 {name=p163340 lab=_44603_/X }
C {devices/lab_pin.sym} 164620 -32400 0 1 {name=p163341 lab=_44605_/X }
C {sky130_stdcells/a2bb2o_4.sym} 164540 -32400 0 0 {name=X_44605_ }
C {devices/lab_pin.sym} 164480 -32260 0 0 {name=p163342 lab=_75424_/A }
C {devices/lab_pin.sym} 164480 -32220 0 0 {name=p163343 lab=_75424_/B }
C {devices/lab_pin.sym} 164600 -32240 0 1 {name=p163344 lab=_75426_/A }
C {sky130_stdcells/nand2_4.sym} 164540 -32240 0 0 {name=X_75425_ }
C {devices/lab_pin.sym} 164460 -32150 0 0 {name=p163345 lab=_41802_/X }
C {devices/lab_pin.sym} 164460 -32110 0 0 {name=p163346 lab=_41803_/X }
C {devices/lab_pin.sym} 164460 -32070 0 0 {name=p163347 lab=_40426_/X }
C {devices/lab_pin.sym} 164460 -32030 0 0 {name=p163348 lab=_88137_/Q }
C {devices/lab_pin.sym} 164460 -31990 0 0 {name=p163349 lab=_41792_/X }
C {devices/lab_pin.sym} 164620 -32070 0 1 {name=p163350 lab=_41818_/A }
C {sky130_stdcells/o32ai_4.sym} 164540 -32070 0 0 {name=X_41817_ }
C {devices/lab_pin.sym} 164500 -31910 0 0 {name=p163351 lab=_48373_/A }
C {devices/lab_pin.sym} 164580 -31910 0 1 {name=p163352 lab=_48891_/B }
C {sky130_stdcells/inv_2.sym} 164540 -31910 0 0 {name=X_48373_ }
C {devices/lab_pin.sym} 164500 -31790 0 0 {name=p163353 lab=_60687_/A }
C {devices/lab_pin.sym} 164580 -31790 0 1 {name=p163354 lab=_60652_/A }
C {sky130_stdcells/inv_2.sym} 164540 -31790 0 0 {name=X_60651_ }
C {devices/lab_pin.sym} 164480 -31690 0 0 {name=p163355 lab=_72633_/X }
C {devices/lab_pin.sym} 164480 -31650 0 0 {name=p163356 lab=_72643_/B }
C {devices/lab_pin.sym} 164480 -31610 0 0 {name=p163357 lab=_56564_/C }
C {devices/lab_pin.sym} 164600 -31650 0 1 {name=p163358 lab=_72637_/Y }
C {sky130_stdcells/nand3_4.sym} 164540 -31650 0 0 {name=X_72637_ }
C {devices/lab_pin.sym} 164480 -31520 0 0 {name=p163359 lab=_79178_/Y }
C {devices/lab_pin.sym} 164480 -31480 0 0 {name=p163360 lab=_79193_/B }
C {devices/lab_pin.sym} 164600 -31500 0 1 {name=p163361 lab=_82820_/D }
C {sky130_stdcells/xnor2_4.sym} 164540 -31500 0 0 {name=X_79193_ }
C {devices/lab_pin.sym} 164480 -31380 0 0 {name=p163362 lab=_45585_/A }
C {devices/lab_pin.sym} 164480 -31340 0 0 {name=p163363 lab=_45617_/B }
C {devices/lab_pin.sym} 164600 -31360 0 1 {name=p163364 lab=_45585_/Y }
C {sky130_stdcells/nor2_4.sym} 164540 -31360 0 0 {name=X_45585_ }
C {devices/lab_pin.sym} 164460 -31270 0 0 {name=p163365 lab=_42795_/X }
C {devices/lab_pin.sym} 164460 -31230 0 0 {name=p163366 lab=_42796_/X }
C {devices/lab_pin.sym} 164460 -31190 0 0 {name=p163367 lab=_41382_/X }
C {devices/lab_pin.sym} 164460 -31150 0 0 {name=p163368 lab=_87713_/Q }
C {devices/lab_pin.sym} 164460 -31110 0 0 {name=p163369 lab=_42781_/X }
C {devices/lab_pin.sym} 164620 -31190 0 1 {name=p163370 lab=_42797_/Y }
C {sky130_stdcells/o32ai_4.sym} 164540 -31190 0 0 {name=X_42797_ }
C {devices/lab_pin.sym} 164500 -31030 0 0 {name=p163371 lab=_47324_/A }
C {devices/lab_pin.sym} 164580 -31030 0 1 {name=p163372 lab=_52986_/B }
C {sky130_stdcells/buf_2.sym} 164540 -31030 0 0 {name=X_47324_ }
C {devices/lab_pin.sym} 164480 -30920 0 0 {name=p163373 lab=_82667_/Q }
C {devices/lab_pin.sym} 164480 -30880 0 0 {name=p163374 lab=_78144_/B }
C {devices/lab_pin.sym} 164600 -30900 0 1 {name=p163375 lab=_78144_/X }
C {sky130_stdcells/xor2_4.sym} 164540 -30900 0 0 {name=X_78144_ }
C {devices/lab_pin.sym} 164460 -30810 0 0 {name=p163376 lab=_44529_/X }
C {devices/lab_pin.sym} 164460 -30770 0 0 {name=p163377 lab=_44530_/X }
C {devices/lab_pin.sym} 164460 -30730 0 0 {name=p163378 lab=_40802_/X }
C {devices/lab_pin.sym} 164460 -30690 0 0 {name=p163379 lab=_44535_/Y }
C {devices/lab_pin.sym} 164460 -30650 0 0 {name=p163380 lab=_44533_/X }
C {devices/lab_pin.sym} 164620 -30730 0 1 {name=p163381 lab=_44536_/Y }
C {sky130_stdcells/o32ai_4.sym} 164540 -30730 0 0 {name=X_44536_ }
C {devices/lab_pin.sym} 164500 -30570 0 0 {name=p163382 lab=_63370_/A }
C {devices/lab_pin.sym} 164580 -30570 0 1 {name=p163383 lab=_63370_/X }
C {sky130_stdcells/buf_2.sym} 164540 -30570 0 0 {name=X_63370_ }
C {devices/lab_pin.sym} 164460 -30470 0 0 {name=p163384 lab=_75364_/A }
C {devices/lab_pin.sym} 164460 -30430 0 0 {name=p163385 lab=_75345_/B }
C {devices/lab_pin.sym} 164460 -30390 0 0 {name=p163386 lab=_75339_/Y }
C {devices/lab_pin.sym} 164620 -30430 0 1 {name=p163387 lab=_75357_/B }
C {sky130_stdcells/o21ai_4.sym} 164540 -30430 0 0 {name=X_75356_ }
C {devices/lab_pin.sym} 164460 -30310 0 0 {name=p163388 lab=_41717_/X }
C {devices/lab_pin.sym} 164460 -30270 0 0 {name=p163389 lab=_41406_/A }
C {devices/lab_pin.sym} 164460 -30230 0 0 {name=p163390 lab=_41747_/X }
C {devices/lab_pin.sym} 164620 -30270 0 1 {name=p163391 lab=_41748_/Y }
C {sky130_stdcells/o21ai_4.sym} 164540 -30270 0 0 {name=X_41748_ }
C {devices/lab_pin.sym} 164460 -30170 0 0 {name=p163392 lab=_60481_/X }
C {devices/lab_pin.sym} 164460 -30130 0 0 {name=p163393 lab=_60524_/Y }
C {devices/lab_pin.sym} 164460 -30090 0 0 {name=p163394 lab=_60556_/B }
C {devices/lab_pin.sym} 164460 -30050 0 0 {name=p163395 lab=_60491_/X }
C {devices/lab_pin.sym} 164460 -30020 0 0 {name=p163396 lab=_60581_/Y }
C {devices/lab_pin.sym} 164620 -30090 0 1 {name=p163397 lab=_60582_/Y }
C {sky130_stdcells/a41oi_4.sym} 164540 -30090 0 0 {name=X_60582_ }
C {devices/lab_pin.sym} 164460 -29970 0 0 {name=p163398 lab=_60053_/X }
C {devices/lab_pin.sym} 164460 -29930 0 0 {name=p163399 lab=_72537_/Y }
C {devices/lab_pin.sym} 164460 -29890 0 0 {name=p163400 lab=_72528_/Y }
C {devices/lab_pin.sym} 164460 -29850 0 0 {name=p163401 lab=_72517_/B }
C {devices/lab_pin.sym} 164460 -29820 0 0 {name=p163402 lab=_72567_/Y }
C {devices/lab_pin.sym} 164620 -29890 0 1 {name=p163403 lab=_72568_/Y }
C {sky130_stdcells/a41oi_4.sym} 164540 -29890 0 0 {name=X_72568_ }
C {devices/lab_pin.sym} 164480 -29760 0 0 {name=p163404 lab=_61419_/X }
C {devices/lab_pin.sym} 164480 -29720 0 0 {name=p163405 lab=_59898_/A }
C {devices/lab_pin.sym} 164480 -29680 0 0 {name=p163406 lab=_62233_/C }
C {devices/lab_pin.sym} 164480 -29640 0 0 {name=p163407 lab=_62334_/D }
C {devices/lab_pin.sym} 164600 -29700 0 1 {name=p163408 lab=_62321_/Y }
C {sky130_stdcells/nand4_4.sym} 164540 -29700 0 0 {name=X_62321_ }
C {devices/lab_pin.sym} 164460 -29570 0 0 {name=p163409 lab=_83105_/Q }
C {devices/lab_pin.sym} 164460 -29530 0 0 {name=p163410 lab=_74301_/X }
C {devices/lab_pin.sym} 164460 -29490 0 0 {name=p163411 lab=_74306_/Y }
C {devices/lab_pin.sym} 164620 -29530 0 1 {name=p163412 lab=_74307_/X }
C {sky130_stdcells/a21bo_4.sym} 164540 -29530 0 0 {name=X_74307_ }
C {devices/lab_pin.sym} 164480 -29400 0 0 {name=p163413 lab=_71521_/A }
C {devices/lab_pin.sym} 164480 -29360 0 0 {name=p163414 lab=_70719_/A }
C {devices/lab_pin.sym} 164600 -29380 0 1 {name=p163415 lab=_71519_/Y }
C {sky130_stdcells/nand2_4.sym} 164540 -29380 0 0 {name=X_71519_ }
C {devices/lab_pin.sym} 164500 -29250 0 0 {name=p163416 lab=_81822_/Q }
C {devices/lab_pin.sym} 164580 -29250 0 1 {name=p163417 lab=_54634_/D }
C {sky130_stdcells/inv_2.sym} 164540 -29250 0 0 {name=X_47255_ }
C {devices/lab_pin.sym} 164480 -29140 0 0 {name=p163418 lab=_84580_/Q }
C {devices/lab_pin.sym} 164480 -29100 0 0 {name=p163419 lab=_78075_/B }
C {devices/lab_pin.sym} 164600 -29120 0 1 {name=p163420 lab=_78075_/X }
C {sky130_stdcells/xor2_4.sym} 164540 -29120 0 0 {name=X_78075_ }
C {devices/lab_pin.sym} 164460 -29020 0 0 {name=p163421 lab=_41157_/A }
C {devices/lab_pin.sym} 164460 -28980 0 0 {name=p163422 lab=_44464_/X }
C {devices/lab_pin.sym} 164460 -28940 0 0 {name=p163423 lab=_87095_/Q }
C {devices/lab_pin.sym} 164460 -28900 0 0 {name=p163424 lab=_44466_/X }
C {devices/lab_pin.sym} 164620 -28960 0 1 {name=p163425 lab=_87095_/D }
C {sky130_stdcells/a2bb2o_4.sym} 164540 -28960 0 0 {name=X_44467_ }
C {devices/lab_pin.sym} 164500 -28810 0 0 {name=p163426 lab=_75287_/A }
C {devices/lab_pin.sym} 164580 -28810 0 1 {name=p163427 lab=_75287_/Y }
C {sky130_stdcells/inv_2.sym} 164540 -28810 0 0 {name=X_75287_ }
C {devices/lab_pin.sym} 164480 -28700 0 0 {name=p163428 lab=_41679_/A }
C {devices/lab_pin.sym} 164480 -28660 0 0 {name=p163429 lab=_41660_/X }
C {devices/lab_pin.sym} 164600 -28680 0 1 {name=p163430 lab=_41679_/X }
C {sky130_stdcells/or2_4.sym} 164540 -28680 0 0 {name=X_41679_ }
C {devices/lab_pin.sym} 164460 -28570 0 0 {name=p163431 lab=_46150_/B }
C {devices/lab_pin.sym} 164460 -28530 0 0 {name=p163432 lab=_83379_/Q }
C {devices/lab_pin.sym} 164460 -28490 0 0 {name=p163433 lab=_72498_/Y }
C {devices/lab_pin.sym} 164620 -28530 0 1 {name=p163434 lab=_83243_/D }
C {sky130_stdcells/o21a_4.sym} 164540 -28530 0 0 {name=X_72499_ }
C {devices/lab_pin.sym} 164480 -28410 0 0 {name=p163435 lab=_46097_/A }
C {devices/lab_pin.sym} 164480 -28370 0 0 {name=p163436 lab=_46104_/Y }
C {devices/lab_pin.sym} 164480 -28330 0 0 {name=p163437 lab=_46101_/A }
C {devices/lab_pin.sym} 164600 -28370 0 1 {name=p163438 lab=_46222_/A }
C {sky130_stdcells/nand3_4.sym} 164540 -28370 0 0 {name=X_46206_ }
C {devices/lab_pin.sym} 164480 -28240 0 0 {name=p163439 lab=_65005_/X }
C {devices/lab_pin.sym} 164480 -28200 0 0 {name=p163440 lab=_86449_/Q }
C {devices/lab_pin.sym} 164600 -28220 0 1 {name=p163441 lab=_65040_/X }
C {sky130_stdcells/and2_4.sym} 164540 -28220 0 0 {name=X_65040_ }
C {sky130_stdcells/decap_3.sym} 164540 -28060 0 0 {name=XPHY_180 }
C {devices/lab_pin.sym} 164460 -27930 0 0 {name=p163442 lab=_77024_/Y }
C {devices/lab_pin.sym} 164460 -27890 0 0 {name=p163443 lab=_77020_/Y }
C {devices/lab_pin.sym} 164460 -27850 0 0 {name=p163444 lab=_77025_/Y }
C {devices/lab_pin.sym} 164620 -27890 0 1 {name=p163445 lab=_77026_/Y }
C {sky130_stdcells/o21ai_4.sym} 164540 -27890 0 0 {name=X_77026_ }
C {devices/lab_pin.sym} 164500 -27750 0 0 {name=p163446 lab=_43418_/A }
C {devices/lab_pin.sym} 164580 -27750 0 1 {name=p163447 lab=_43418_/Y }
C {sky130_stdcells/inv_2.sym} 164540 -27750 0 0 {name=X_43418_ }
C {devices/lab_pin.sym} 164460 -27670 0 0 {name=p163448 lab=_62244_/X }
C {devices/lab_pin.sym} 164460 -27630 0 0 {name=p163449 lab=_62246_/X }
C {devices/lab_pin.sym} 164460 -27590 0 0 {name=p163450 lab=_62251_/Y }
C {devices/lab_pin.sym} 164460 -27550 0 0 {name=p163451 lab=_58154_/A }
C {devices/lab_pin.sym} 164460 -27510 0 0 {name=p163452 lab=_62214_/X }
C {devices/lab_pin.sym} 164620 -27590 0 1 {name=p163453 lab=_62252_/Y }
C {sky130_stdcells/o32ai_4.sym} 164540 -27590 0 0 {name=X_62252_ }
C {devices/lab_pin.sym} 164460 -27460 0 0 {name=p163454 lab=_74155_/X }
C {devices/lab_pin.sym} 164460 -27420 0 0 {name=p163455 lab=_84964_/Q }
C {devices/lab_pin.sym} 164460 -27380 0 0 {name=p163456 lab=_72992_/X }
C {devices/lab_pin.sym} 164460 -27340 0 0 {name=p163457 lab=_74237_/X }
C {devices/lab_pin.sym} 164620 -27400 0 1 {name=p163458 lab=_74239_/B }
C {sky130_stdcells/a211o_4.sym} 164540 -27400 0 0 {name=X_74238_ }
C {sky130_stdcells/decap_3.sym} 164540 -27220 0 0 {name=XPHY_191 }
C {devices/lab_pin.sym} 164460 -27090 0 0 {name=p163459 lab=_86661_/Q }
C {devices/lab_pin.sym} 164460 -27050 0 0 {name=p163460 lab=_47145_/X }
C {devices/lab_pin.sym} 164460 -27010 0 0 {name=p163461 lab=_47185_/Y }
C {devices/lab_pin.sym} 164620 -27050 0 1 {name=p163462 lab=_47186_/Y }
C {sky130_stdcells/o21ai_4.sym} 164540 -27050 0 0 {name=X_47186_ }
C {devices/lab_pin.sym} 164500 -26910 0 0 {name=p163463 lab=_44398_/A }
C {devices/lab_pin.sym} 164580 -26910 0 1 {name=p163464 lab=_44398_/Y }
C {sky130_stdcells/inv_2.sym} 164540 -26910 0 0 {name=X_44398_ }
C {devices/lab_pin.sym} 164480 -26810 0 0 {name=p163465 lab=_61234_/A }
C {devices/lab_pin.sym} 164480 -26770 0 0 {name=p163466 lab=_61165_/B }
C {devices/lab_pin.sym} 164480 -26730 0 0 {name=p163467 lab=_61203_/C }
C {devices/lab_pin.sym} 164600 -26770 0 1 {name=p163468 lab=_61203_/Y }
C {sky130_stdcells/nor3_4.sym} 164540 -26770 0 0 {name=X_61203_ }
C {devices/lab_pin.sym} 164500 -26630 0 0 {name=p163469 lab=_57665_/A }
C {devices/lab_pin.sym} 164580 -26630 0 1 {name=p163470 lab=_57657_/B }
C {sky130_stdcells/buf_2.sym} 164540 -26630 0 0 {name=X_46137_ }
C {devices/lab_pin.sym} 164500 -26510 0 0 {name=p163471 lab=_43349_/A }
C {devices/lab_pin.sym} 164580 -26510 0 1 {name=p163472 lab=_87466_/D }
C {sky130_stdcells/inv_2.sym} 164540 -26510 0 0 {name=X_43349_ }
C {devices/lab_pin.sym} 164480 -26420 0 0 {name=p163473 lab=_62183_/A }
C {devices/lab_pin.sym} 164480 -26380 0 0 {name=p163474 lab=_61692_/B }
C {devices/lab_pin.sym} 164480 -26340 0 0 {name=p163475 lab=_59754_/C }
C {devices/lab_pin.sym} 164480 -26300 0 0 {name=p163476 lab=_62183_/D }
C {devices/lab_pin.sym} 164600 -26360 0 1 {name=p163477 lab=_62183_/X }
C {sky130_stdcells/and4_4.sym} 164540 -26360 0 0 {name=X_62183_ }
C {devices/lab_pin.sym} 164460 -26230 0 0 {name=p163478 lab=_69004_/B }
C {devices/lab_pin.sym} 164460 -26190 0 0 {name=p163479 lab=_73153_/X }
C {devices/lab_pin.sym} 164460 -26150 0 0 {name=p163480 lab=_72982_/X }
C {devices/lab_pin.sym} 164620 -26190 0 1 {name=p163481 lab=_74169_/Y }
C {sky130_stdcells/o21ai_4.sym} 164540 -26190 0 0 {name=X_74169_ }
C {devices/lab_pin.sym} 164500 -26050 0 0 {name=p163482 lab=_64421_/A }
C {devices/lab_pin.sym} 164580 -26050 0 1 {name=p163483 lab=_64225_/B }
C {sky130_stdcells/buf_2.sym} 164540 -26050 0 0 {name=X_61134_ }
C {devices/lab_pin.sym} 164500 -25930 0 0 {name=p163484 lab=_45981_/X }
C {devices/lab_pin.sym} 164580 -25930 0 1 {name=p163485 lab=_46068_/X }
C {sky130_stdcells/buf_2.sym} 164540 -25930 0 0 {name=X_46068_ }
C {devices/lab_pin.sym} 164460 -25830 0 0 {name=p163486 lab=_66987_/X }
C {devices/lab_pin.sym} 164460 -25790 0 0 {name=p163487 lab=_66990_/X }
C {devices/lab_pin.sym} 164460 -25750 0 0 {name=p163488 lab=_66658_/X }
C {devices/lab_pin.sym} 164620 -25790 0 1 {name=p163489 lab=_66991_/Y }
C {sky130_stdcells/a21oi_4.sym} 164540 -25790 0 0 {name=X_66991_ }
C {devices/lab_pin.sym} 164480 -25660 0 0 {name=p163490 lab=_82821_/Q }
C {devices/lab_pin.sym} 164480 -25620 0 0 {name=p163491 lab=_82533_/Q }
C {devices/lab_pin.sym} 164600 -25640 0 1 {name=p163492 lab=_78978_/B }
C {sky130_stdcells/xnor2_4.sym} 164540 -25640 0 0 {name=X_78977_ }
C {devices/lab_pin.sym} 164500 -25510 0 0 {name=p163493 lab=_83034_/Q }
C {devices/lab_pin.sym} 164580 -25510 0 1 {name=p163494 lab=_45020_/A }
C {sky130_stdcells/inv_2.sym} 164540 -25510 0 0 {name=X_45019_ }
C {devices/lab_pin.sym} 164500 -25390 0 0 {name=p163495 lab=_66572_/X }
C {devices/lab_pin.sym} 164580 -25390 0 1 {name=p163496 lab=_69371_/A }
C {sky130_stdcells/buf_2.sym} 164540 -25390 0 0 {name=X_68730_ }
C {devices/lab_pin.sym} 164460 -25290 0 0 {name=p163497 lab=_65903_/X }
C {devices/lab_pin.sym} 164460 -25250 0 0 {name=p163498 lab=_65461_/Y }
C {devices/lab_pin.sym} 164460 -25210 0 0 {name=p163499 lab=_65941_/Y }
C {devices/lab_pin.sym} 164620 -25250 0 1 {name=p163500 lab=_65942_/Y }
C {sky130_stdcells/o21ai_4.sym} 164540 -25250 0 0 {name=X_65942_ }
C {devices/lab_pin.sym} 164460 -25150 0 0 {name=p163501 lab=_60070_/Y }
C {devices/lab_pin.sym} 164460 -25110 0 0 {name=p163502 lab=_61063_/Y }
C {devices/lab_pin.sym} 164460 -25070 0 0 {name=p163503 lab=_60908_/X }
C {devices/lab_pin.sym} 164460 -25030 0 0 {name=p163504 lab=_60989_/X }
C {devices/lab_pin.sym} 164460 -24990 0 0 {name=p163505 lab=_61064_/X }
C {devices/lab_pin.sym} 164620 -25070 0 1 {name=p163506 lab=_61065_/X }
C {sky130_stdcells/o41a_4.sym} 164540 -25070 0 0 {name=X_61065_ }
C {devices/lab_pin.sym} 164500 -24910 0 0 {name=p163507 lab=_77928_/A }
C {devices/lab_pin.sym} 164580 -24910 0 1 {name=p163508 lab=_77933_/A }
C {sky130_stdcells/inv_2.sym} 164540 -24910 0 0 {name=X_77928_ }
C {devices/lab_pin.sym} 164480 -24800 0 0 {name=p163509 lab=_59929_/C }
C {devices/lab_pin.sym} 164480 -24760 0 0 {name=p163510 lab=_59927_/Y }
C {devices/lab_pin.sym} 164600 -24780 0 1 {name=p163511 lab=_62336_/A }
C {sky130_stdcells/and2_4.sym} 164540 -24780 0 0 {name=X_60016_ }
C {devices/lab_pin.sym} 164500 -24650 0 0 {name=p163512 lab=_49854_/A }
C {devices/lab_pin.sym} 164580 -24650 0 1 {name=p163513 lab=_49827_/X }
C {sky130_stdcells/buf_2.sym} 164540 -24650 0 0 {name=X_49827_ }
C {devices/lab_pin.sym} 164500 -24530 0 0 {name=p163514 lab=_68660_/X }
C {devices/lab_pin.sym} 164580 -24530 0 1 {name=p163515 lab=_68661_/X }
C {sky130_stdcells/buf_2.sym} 164540 -24530 0 0 {name=X_68661_ }
C {devices/lab_pin.sym} 164460 -24430 0 0 {name=p163516 lab=_65869_/Y }
C {devices/lab_pin.sym} 164460 -24390 0 0 {name=p163517 lab=_65830_/X }
C {devices/lab_pin.sym} 164460 -24350 0 0 {name=p163518 lab=_65872_/Y }
C {devices/lab_pin.sym} 164620 -24390 0 1 {name=p163519 lab=_84172_/D }
C {sky130_stdcells/a21o_4.sym} 164540 -24390 0 0 {name=X_65873_ }
C {devices/lab_pin.sym} 164460 -24270 0 0 {name=p163520 lab=_82063_/Q }
C {devices/lab_pin.sym} 164460 -24230 0 0 {name=p163521 lab=_77856_/Y }
C {devices/lab_pin.sym} 164460 -24190 0 0 {name=p163522 lab=_77858_/X }
C {devices/lab_pin.sym} 164620 -24230 0 1 {name=p163523 lab=_77860_/B }
C {sky130_stdcells/o21ai_4.sym} 164540 -24230 0 0 {name=X_77859_ }
C {devices/lab_pin.sym} 164460 -24110 0 0 {name=p163524 lab=_81494_/D }
C {devices/lab_pin.sym} 164460 -24070 0 0 {name=p163525 lab=_67568_/X }
C {devices/lab_pin.sym} 164460 -24030 0 0 {name=p163526 lab=_67611_/X }
C {devices/lab_pin.sym} 164620 -24070 0 1 {name=p163527 lab=_84062_/D }
C {sky130_stdcells/a21bo_4.sym} 164540 -24070 0 0 {name=X_67612_ }
C {devices/lab_pin.sym} 164460 -23960 0 0 {name=p163528 lab=_64809_/X }
C {devices/lab_pin.sym} 164460 -23920 0 0 {name=p163529 lab=_86745_/Q }
C {devices/lab_pin.sym} 164460 -23880 0 0 {name=p163530 lab=_64733_/X }
C {devices/lab_pin.sym} 164460 -23840 0 0 {name=p163531 lab=_64823_/X }
C {devices/lab_pin.sym} 164620 -23900 0 1 {name=p163532 lab=_64824_/X }
C {sky130_stdcells/a211o_4.sym} 164540 -23900 0 0 {name=X_64824_ }
C {devices/lab_pin.sym} 164460 -23770 0 0 {name=p163533 lab=_57857_/B }
C {devices/lab_pin.sym} 164460 -23730 0 0 {name=p163534 lab=_49742_/X }
C {devices/lab_pin.sym} 164460 -23690 0 0 {name=p163535 lab=_49757_/Y }
C {devices/lab_pin.sym} 164620 -23730 0 1 {name=p163536 lab=_49758_/Y }
C {sky130_stdcells/o21ai_4.sym} 164540 -23730 0 0 {name=X_49758_ }
C {devices/lab_pin.sym} 164450 -23590 0 0 {name=p163537 lab=_80746_/CLK }
C {devices/lab_pin.sym} 164450 -23570 0 0 {name=p163538 lab=_75611_/B }
C {devices/lab_pin.sym} 164630 -23590 0 1 {name=p163539 lab=_80870_/Q }
C {sky130_stdcells/dfxtp_4.sym} 164540 -23580 0 0 {name=X_80870_ }
C {devices/lab_pin.sym} 164480 -23460 0 0 {name=p163540 lab=_69661_/A }
C {devices/lab_pin.sym} 164480 -23420 0 0 {name=p163541 lab=_43620_/Y }
C {devices/lab_pin.sym} 164600 -23440 0 1 {name=p163542 lab=_68592_/Y }
C {sky130_stdcells/nor2_4.sym} 164540 -23440 0 0 {name=X_68592_ }
C {devices/ipin.sym} 290 -330 0 0 {name=p163543 lab=CLK }
C {devices/opin.sym} 520 -340 0 0 {name=p163544 lab=DATA_AVAILABLE }
C {devices/opin.sym} 520 -290 0 0 {name=p163545 lab=DATA_FROM_HASH[0:7] }
C {devices/ipin.sym} 290 -310 0 0 {name=p163546 lab=DATA_TO_HASH[0:7] }
C {devices/ipin.sym} 290 -250 0 0 {name=p163547 lab=HASH_ADDR[0:5] }
C {devices/ipin.sym} 290 -230 0 0 {name=p163548 lab=HASH_EN }
C {devices/ipin.sym} 290 -210 0 0 {name=p163549 lab=MACRO_RD_SELECT }
C {devices/ipin.sym} 290 -190 0 0 {name=p163550 lab=MACRO_WR_SELECT }
C {devices/opin.sym} 520 -200 0 0 {name=p163551 lab=THREAD_COUNT[0:3] }
C {devices/title.sym} 160 -40 0 0 {name=l1 author="Stefan Schippers"}
