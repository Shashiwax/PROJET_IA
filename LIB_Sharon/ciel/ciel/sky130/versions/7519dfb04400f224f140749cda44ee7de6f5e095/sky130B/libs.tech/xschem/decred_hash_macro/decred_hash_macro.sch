v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/lab_pin.sym} 700 -42170 0 0 {name=p0 lab=_46423_/X }
C {devices/lab_pin.sym} 700 -42130 0 0 {name=p1 lab=_82338_/Q }
C {devices/lab_pin.sym} 700 -42090 0 0 {name=p2 lab=_48708_/X }
C {devices/lab_pin.sym} 860 -42130 0 1 {name=p3 lab=_48874_/B }
C {sky130_stdcells/o21ai_4.sym} 780 -42130 0 0 {name=X_48709_ }
C {devices/lab_pin.sym} 700 -42020 0 0 {name=p4 lab=_67522_/X }
C {devices/lab_pin.sym} 700 -41980 0 0 {name=p5 lab=_67532_/Y }
C {devices/lab_pin.sym} 700 -41940 0 0 {name=p6 lab=_67507_/X }
C {devices/lab_pin.sym} 700 -41900 0 0 {name=p7 lab=_67542_/Y }
C {devices/lab_pin.sym} 860 -41960 0 1 {name=p8 lab=_67543_/X }
C {sky130_stdcells/a211o_4.sym} 780 -41960 0 0 {name=X_67543_ }
C {devices/lab_pin.sym} 720 -41820 0 0 {name=p9 lab=_79528_/Y }
C {devices/lab_pin.sym} 720 -41780 0 0 {name=p10 lab=_79529_/B }
C {devices/lab_pin.sym} 840 -41800 0 1 {name=p11 lab=_79529_/Y }
C {sky130_stdcells/nand2_4.sym} 780 -41800 0 0 {name=X_79529_ }
C {devices/lab_pin.sym} 720 -41680 0 0 {name=p12 lab=_64883_/A }
C {devices/lab_pin.sym} 720 -41640 0 0 {name=p13 lab=_64755_/B }
C {devices/lab_pin.sym} 840 -41660 0 1 {name=p14 lab=_64755_/X }
C {sky130_stdcells/and2_4.sym} 780 -41660 0 0 {name=X_64755_ }
C {devices/lab_pin.sym} 720 -41560 0 0 {name=p15 lab=_61510_/X }
C {devices/lab_pin.sym} 720 -41520 0 0 {name=p16 lab=_61933_/X }
C {devices/lab_pin.sym} 720 -41480 0 0 {name=p17 lab=_61967_/C }
C {devices/lab_pin.sym} 720 -41440 0 0 {name=p18 lab=_61952_/D }
C {devices/lab_pin.sym} 840 -41500 0 1 {name=p19 lab=_61967_/Y }
C {sky130_stdcells/nand4_4.sym} 780 -41500 0 0 {name=X_61967_ }
C {devices/lab_pin.sym} 740 -41350 0 0 {name=p20 lab=_49688_/X }
C {devices/lab_pin.sym} 820 -41350 0 1 {name=p21 lab=_49699_/A }
C {sky130_stdcells/buf_2.sym} 780 -41350 0 0 {name=X_49689_ }
C {devices/lab_pin.sym} 740 -41230 0 0 {name=p22 lab=_52688_/A }
C {devices/lab_pin.sym} 820 -41230 0 1 {name=p23 lab=_52605_/A }
C {sky130_stdcells/buf_2.sym} 780 -41230 0 0 {name=X_51720_ }
C {devices/lab_pin.sym} 720 -41130 0 0 {name=p24 lab=_63697_/A }
C {devices/lab_pin.sym} 720 -41090 0 0 {name=p25 lab=_64544_/C }
C {devices/lab_pin.sym} 720 -41050 0 0 {name=p26 lab=_63458_/A }
C {devices/lab_pin.sym} 840 -41090 0 1 {name=p27 lab=_63706_/X }
C {sky130_stdcells/and3_4.sym} 780 -41090 0 0 {name=X_63706_ }
C {devices/lab_pin.sym} 690 -40950 0 0 {name=p28 lab=_82553_/CLK }
C {devices/lab_pin.sym} 690 -40930 0 0 {name=p29 lab=_82540_/D }
C {devices/lab_pin.sym} 870 -40950 0 1 {name=p30 lab=_82540_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -40940 0 0 {name=X_82540_ }
C {devices/lab_pin.sym} 740 -40810 0 0 {name=p31 lab=_64172_/C }
C {devices/lab_pin.sym} 820 -40810 0 1 {name=p32 lab=_60918_/X }
C {sky130_stdcells/buf_2.sym} 780 -40810 0 0 {name=X_60918_ }
C {devices/lab_pin.sym} 720 -40700 0 0 {name=p33 lab=_67497_/A }
C {devices/lab_pin.sym} 720 -40660 0 0 {name=p34 lab=_87661_/Q }
C {devices/lab_pin.sym} 840 -40680 0 1 {name=p35 lab=_67474_/X }
C {sky130_stdcells/and2_4.sym} 780 -40680 0 0 {name=X_67474_ }
C {devices/lab_pin.sym} 720 -40570 0 0 {name=p36 lab=_64682_/X }
C {devices/lab_pin.sym} 720 -40530 0 0 {name=p37 lab=_64937_/B }
C {devices/lab_pin.sym} 720 -40490 0 0 {name=p38 lab=_64685_/X }
C {devices/lab_pin.sym} 840 -40530 0 1 {name=p39 lab=_64686_/Y }
C {sky130_stdcells/nand3_4.sym} 780 -40530 0 0 {name=X_64686_ }
C {devices/lab_pin.sym} 740 -40390 0 0 {name=p40 lab=_61820_/A }
C {devices/lab_pin.sym} 820 -40390 0 1 {name=p41 lab=_61960_/B }
C {sky130_stdcells/buf_2.sym} 780 -40390 0 0 {name=X_61898_ }
C {devices/lab_pin.sym} 700 -40290 0 0 {name=p42 lab=_68507_/X }
C {devices/lab_pin.sym} 700 -40250 0 0 {name=p43 lab=_68511_/X }
C {devices/lab_pin.sym} 700 -40210 0 0 {name=p44 lab=_69212_/X }
C {devices/lab_pin.sym} 860 -40250 0 1 {name=p45 lab=_69213_/Y }
C {sky130_stdcells/a21oi_4.sym} 780 -40250 0 0 {name=X_69213_ }
C {devices/lab_pin.sym} 700 -40130 0 0 {name=p46 lab=_84126_/Q }
C {devices/lab_pin.sym} 700 -40090 0 0 {name=p47 lab=_65296_/X }
C {devices/lab_pin.sym} 700 -40050 0 0 {name=p48 lab=_66424_/Y }
C {devices/lab_pin.sym} 860 -40090 0 1 {name=p49 lab=_66425_/X }
C {sky130_stdcells/a21o_4.sym} 780 -40090 0 0 {name=X_66425_ }
C {devices/lab_pin.sym} 720 -39980 0 0 {name=p50 lab=_51629_/X }
C {devices/lab_pin.sym} 720 -39940 0 0 {name=p51 lab=_51651_/B }
C {devices/lab_pin.sym} 720 -39900 0 0 {name=p52 lab=_51651_/C }
C {devices/lab_pin.sym} 720 -39860 0 0 {name=p53 lab=_53177_/D }
C {devices/lab_pin.sym} 840 -39920 0 1 {name=p54 lab=_51651_/X }
C {sky130_stdcells/and4_4.sym} 780 -39920 0 0 {name=X_51651_ }
C {devices/lab_pin.sym} 700 -39790 0 0 {name=p55 lab=_63634_/Y }
C {devices/lab_pin.sym} 700 -39750 0 0 {name=p56 lab=_63635_/X }
C {devices/lab_pin.sym} 700 -39710 0 0 {name=p57 lab=_63636_/Y }
C {devices/lab_pin.sym} 860 -39750 0 1 {name=p58 lab=_63637_/Y }
C {sky130_stdcells/a21oi_4.sym} 780 -39750 0 0 {name=X_63637_ }
C {devices/lab_pin.sym} 690 -39610 0 0 {name=p59 lab=_82589_/CLK }
C {devices/lab_pin.sym} 690 -39590 0 0 {name=p60 lab=_82471_/D }
C {devices/lab_pin.sym} 870 -39610 0 1 {name=p61 lab=_78296_/B }
C {sky130_stdcells/dfxtp_4.sym} 780 -39600 0 0 {name=X_82471_ }
C {devices/lab_pin.sym} 720 -39480 0 0 {name=p62 lab=_60844_/X }
C {devices/lab_pin.sym} 720 -39440 0 0 {name=p63 lab=_60857_/D }
C {devices/lab_pin.sym} 840 -39460 0 1 {name=p64 lab=_60909_/A }
C {sky130_stdcells/and2_4.sym} 780 -39460 0 0 {name=X_60849_ }
C {devices/lab_pin.sym} 690 -39330 0 0 {name=p65 lab=_84210_/CLK }
C {devices/lab_pin.sym} 690 -39310 0 0 {name=p66 lab=_84210_/D }
C {devices/lab_pin.sym} 870 -39330 0 1 {name=p67 lab=_84210_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -39320 0 0 {name=X_84210_ }
C {devices/lab_pin.sym} 700 -39210 0 0 {name=p68 lab=_50598_/Y }
C {devices/lab_pin.sym} 700 -39170 0 0 {name=p69 lab=_50577_/X }
C {devices/lab_pin.sym} 700 -39130 0 0 {name=p70 lab=_50601_/Y }
C {devices/lab_pin.sym} 860 -39170 0 1 {name=p71 lab=_86170_/D }
C {sky130_stdcells/a21boi_4.sym} 780 -39170 0 0 {name=X_50602_ }
C {devices/lab_pin.sym} 690 -39030 0 0 {name=p72 lab=_81333_/CLK }
C {devices/lab_pin.sym} 690 -39010 0 0 {name=p73 lab=_81454_/Q }
C {devices/lab_pin.sym} 870 -39030 0 1 {name=p74 lab=_76013_/B }
C {sky130_stdcells/dfxtp_4.sym} 780 -39020 0 0 {name=X_81422_ }
C {devices/lab_pin.sym} 700 -38920 0 0 {name=p75 lab=_68929_/X }
C {devices/lab_pin.sym} 700 -38880 0 0 {name=p76 lab=_68357_/Y }
C {devices/lab_pin.sym} 700 -38840 0 0 {name=p77 lab=_69095_/X }
C {devices/lab_pin.sym} 700 -38800 0 0 {name=p78 lab=_69143_/Y }
C {devices/lab_pin.sym} 860 -38860 0 1 {name=p79 lab=_69144_/X }
C {sky130_stdcells/a211o_4.sym} 780 -38860 0 0 {name=X_69144_ }
C {devices/lab_pin.sym} 700 -38730 0 0 {name=p80 lab=_85454_/Q }
C {devices/lab_pin.sym} 700 -38690 0 0 {name=p81 lab=_54349_/X }
C {devices/lab_pin.sym} 700 -38650 0 0 {name=p82 lab=_54369_/Y }
C {devices/lab_pin.sym} 860 -38690 0 1 {name=p83 lab=_54370_/Y }
C {sky130_stdcells/o21ai_4.sym} 780 -38690 0 0 {name=X_54370_ }
C {devices/lab_pin.sym} 740 -38550 0 0 {name=p84 lab=_66104_/A }
C {devices/lab_pin.sym} 820 -38550 0 1 {name=p85 lab=_66367_/B }
C {sky130_stdcells/buf_2.sym} 780 -38550 0 0 {name=X_66356_ }
C {devices/lab_pin.sym} 690 -38430 0 0 {name=p86 lab=_85190_/CLK }
C {devices/lab_pin.sym} 690 -38410 0 0 {name=p87 lab=_56447_/Y }
C {devices/lab_pin.sym} 870 -38430 0 1 {name=p88 lab=_85190_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -38420 0 0 {name=X_85190_ }
C {devices/lab_pin.sym} 720 -38300 0 0 {name=p89 lab=_51590_/A }
C {devices/lab_pin.sym} 720 -38260 0 0 {name=p90 lab=_53109_/B }
C {devices/lab_pin.sym} 840 -38280 0 1 {name=p91 lab=_51582_/Y }
C {sky130_stdcells/nand2_4.sym} 780 -38280 0 0 {name=X_51582_ }
C {devices/lab_pin.sym} 700 -38170 0 0 {name=p92 lab=_63566_/Y }
C {devices/lab_pin.sym} 700 -38130 0 0 {name=p93 lab=_63516_/X }
C {devices/lab_pin.sym} 700 -38090 0 0 {name=p94 lab=_63567_/Y }
C {devices/lab_pin.sym} 860 -38130 0 1 {name=p95 lab=_84313_/D }
C {sky130_stdcells/a21oi_4.sym} 780 -38130 0 0 {name=X_63568_ }
C {devices/lab_pin.sym} 740 -37990 0 0 {name=p96 lab=_53347_/A }
C {devices/lab_pin.sym} 820 -37990 0 1 {name=p97 lab=_53330_/B }
C {sky130_stdcells/buf_2.sym} 780 -37990 0 0 {name=X_53321_ }
C {devices/lab_pin.sym} 740 -37870 0 0 {name=p98 lab=_65307_/A }
C {devices/lab_pin.sym} 820 -37870 0 1 {name=p99 lab=_65833_/B }
C {sky130_stdcells/buf_2.sym} 780 -37870 0 0 {name=X_65307_ }
C {devices/lab_pin.sym} 690 -37750 0 0 {name=p100 lab=_84175_/CLK }
C {devices/lab_pin.sym} 690 -37730 0 0 {name=p101 lab=_84141_/D }
C {devices/lab_pin.sym} 870 -37750 0 1 {name=p102 lab=_66319_/C }
C {sky130_stdcells/dfxtp_4.sym} 780 -37740 0 0 {name=X_84141_ }
C {devices/lab_pin.sym} 740 -37610 0 0 {name=p103 lab=_50506_/A }
C {devices/lab_pin.sym} 820 -37610 0 1 {name=p104 lab=_50533_/X }
C {sky130_stdcells/buf_2.sym} 780 -37610 0 0 {name=X_50533_ }
C {devices/lab_pin.sym} 720 -37500 0 0 {name=p105 lab=_59951_/B }
C {devices/lab_pin.sym} 720 -37460 0 0 {name=p106 lab=_62198_/Y }
C {devices/lab_pin.sym} 840 -37480 0 1 {name=p107 lab=_62520_/A }
C {sky130_stdcells/and2_4.sym} 780 -37480 0 0 {name=X_62519_ }
C {devices/lab_pin.sym} 690 -37350 0 0 {name=p108 lab=_81351_/CLK }
C {devices/lab_pin.sym} 690 -37330 0 0 {name=p109 lab=_76707_/X }
C {devices/lab_pin.sym} 870 -37350 0 1 {name=p110 lab=_81353_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -37340 0 0 {name=X_81353_ }
C {devices/lab_pin.sym} 700 -37230 0 0 {name=p111 lab=_69071_/X }
C {devices/lab_pin.sym} 700 -37190 0 0 {name=p112 lab=_69074_/X }
C {devices/lab_pin.sym} 700 -37150 0 0 {name=p113 lab=_60014_/X }
C {devices/lab_pin.sym} 860 -37190 0 1 {name=p114 lab=_69075_/Y }
C {sky130_stdcells/a21oi_4.sym} 780 -37190 0 0 {name=X_69075_ }
C {devices/lab_pin.sym} 700 -37070 0 0 {name=p115 lab=_66284_/X }
C {devices/lab_pin.sym} 700 -37030 0 0 {name=p116 lab=_66286_/X }
C {devices/lab_pin.sym} 700 -36990 0 0 {name=p117 lab=_65937_/X }
C {devices/lab_pin.sym} 860 -37030 0 1 {name=p118 lab=_66287_/X }
C {sky130_stdcells/a21o_4.sym} 780 -37030 0 0 {name=X_66287_ }
C {devices/lab_pin.sym} 700 -36920 0 0 {name=p119 lab=_58546_/Y }
C {devices/lab_pin.sym} 700 -36880 0 0 {name=p120 lab=_63497_/X }
C {devices/lab_pin.sym} 700 -36840 0 0 {name=p121 lab=_61468_/A }
C {devices/lab_pin.sym} 700 -36800 0 0 {name=p122 lab=_63498_/X }
C {devices/lab_pin.sym} 860 -36860 0 1 {name=p123 lab=_63499_/X }
C {sky130_stdcells/a2bb2o_4.sym} 780 -36860 0 0 {name=X_63499_ }
C {devices/lab_pin.sym} 740 -36710 0 0 {name=p124 lab=_56039_/Y }
C {devices/lab_pin.sym} 820 -36710 0 1 {name=p125 lab=_56040_/X }
C {sky130_stdcells/buf_2.sym} 780 -36710 0 0 {name=X_56040_ }
C {devices/lab_pin.sym} 720 -36600 0 0 {name=p126 lab=_80304_/A }
C {devices/lab_pin.sym} 720 -36560 0 0 {name=p127 lab=_80304_/B }
C {devices/lab_pin.sym} 840 -36580 0 1 {name=p128 lab=_82244_/D }
C {sky130_stdcells/xnor2_4.sym} 780 -36580 0 0 {name=X_80304_ }
C {devices/lab_pin.sym} 700 -36480 0 0 {name=p129 lab=_87138_/Q }
C {devices/lab_pin.sym} 700 -36440 0 0 {name=p130 lab=_68023_/X }
C {devices/lab_pin.sym} 700 -36400 0 0 {name=p131 lab=_68024_/X }
C {devices/lab_pin.sym} 700 -36360 0 0 {name=p132 lab=_68025_/X }
C {devices/lab_pin.sym} 860 -36420 0 1 {name=p133 lab=_68027_/B }
C {sky130_stdcells/a211o_4.sym} 780 -36420 0 0 {name=X_68026_ }
C {devices/lab_pin.sym} 700 -36290 0 0 {name=p134 lab=_85668_/Q }
C {devices/lab_pin.sym} 700 -36250 0 0 {name=p135 lab=_51929_/X }
C {devices/lab_pin.sym} 700 -36210 0 0 {name=p136 lab=_53251_/Y }
C {devices/lab_pin.sym} 860 -36250 0 1 {name=p137 lab=_53252_/Y }
C {sky130_stdcells/o21ai_4.sym} 780 -36250 0 0 {name=X_53252_ }
C {devices/lab_pin.sym} 700 -36130 0 0 {name=p138 lab=_65235_/X }
C {devices/lab_pin.sym} 700 -36090 0 0 {name=p139 lab=_65237_/X }
C {devices/lab_pin.sym} 700 -36050 0 0 {name=p140 lab=_65161_/X }
C {devices/lab_pin.sym} 860 -36090 0 1 {name=p141 lab=_65238_/X }
C {sky130_stdcells/a21o_4.sym} 780 -36090 0 0 {name=X_65238_ }
C {devices/lab_pin.sym} 690 -35950 0 0 {name=p142 lab=_81322_/CLK }
C {devices/lab_pin.sym} 690 -35930 0 0 {name=p143 lab=_84072_/D }
C {devices/lab_pin.sym} 870 -35950 0 1 {name=p144 lab=_81504_/D }
C {sky130_stdcells/dfxtp_4.sym} 780 -35940 0 0 {name=X_84072_ }
C {devices/lab_pin.sym} 740 -35810 0 0 {name=p145 lab=_50464_/A }
C {devices/lab_pin.sym} 820 -35810 0 1 {name=p146 lab=_50464_/X }
C {sky130_stdcells/buf_2.sym} 780 -35810 0 0 {name=X_50464_ }
C {devices/lab_pin.sym} 690 -35690 0 0 {name=p147 lab=_81284_/CLK }
C {devices/lab_pin.sym} 690 -35670 0 0 {name=p148 lab=_76972_/X }
C {devices/lab_pin.sym} 870 -35690 0 1 {name=p149 lab=_81284_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -35680 0 0 {name=X_81284_ }
C {devices/lab_pin.sym} 740 -35550 0 0 {name=p150 lab=_52203_/A }
C {devices/lab_pin.sym} 820 -35550 0 1 {name=p151 lab=_52203_/X }
C {sky130_stdcells/buf_2.sym} 780 -35550 0 0 {name=X_52203_ }
C {devices/lab_pin.sym} 690 -35430 0 0 {name=p152 lab=_83022_/CLK }
C {devices/lab_pin.sym} 690 -35410 0 0 {name=p153 lab=_74593_/Y }
C {devices/lab_pin.sym} 870 -35430 0 1 {name=p154 lab=_45181_/A }
C {sky130_stdcells/dfxtp_4.sym} 780 -35420 0 0 {name=X_83023_ }
C {devices/lab_pin.sym} 690 -35290 0 0 {name=p155 lab=_87195_/CLK }
C {devices/lab_pin.sym} 690 -35270 0 0 {name=p156 lab=_87900_/D }
C {devices/lab_pin.sym} 870 -35290 0 1 {name=p157 lab=_87900_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -35280 0 0 {name=X_87900_ }
C {devices/lab_pin.sym} 720 -35160 0 0 {name=p158 lab=_80213_/X }
C {devices/lab_pin.sym} 720 -35120 0 0 {name=p159 lab=_80216_/Y }
C {devices/lab_pin.sym} 840 -35140 0 1 {name=p160 lab=_80235_/X }
C {sky130_stdcells/or2_4.sym} 780 -35140 0 0 {name=X_80235_ }
C {devices/lab_pin.sym} 720 -35020 0 0 {name=p161 lab=_53187_/A }
C {devices/lab_pin.sym} 720 -34980 0 0 {name=p162 lab=_53183_/B }
C {devices/lab_pin.sym} 840 -35000 0 1 {name=p163 lab=_53183_/Y }
C {sky130_stdcells/nand2_4.sym} 780 -35000 0 0 {name=X_53183_ }
C {devices/lab_pin.sym} 740 -34870 0 0 {name=p164 lab=_84212_/Q }
C {devices/lab_pin.sym} 820 -34870 0 1 {name=p165 lab=_65170_/C }
C {sky130_stdcells/inv_2.sym} 780 -34870 0 0 {name=X_65169_ }
C {devices/lab_pin.sym} 740 -34750 0 0 {name=p166 lab=_50491_/A }
C {devices/lab_pin.sym} 820 -34750 0 1 {name=p167 lab=_50395_/X }
C {sky130_stdcells/buf_2.sym} 780 -34750 0 0 {name=X_50395_ }
C {devices/lab_pin.sym} 740 -34630 0 0 {name=p168 lab=_51956_/X }
C {devices/lab_pin.sym} 820 -34630 0 1 {name=p169 lab=_52156_/C }
C {sky130_stdcells/buf_2.sym} 780 -34630 0 0 {name=X_52134_ }
C {devices/lab_pin.sym} 690 -34510 0 0 {name=p170 lab=_88326_/CLK }
C {devices/lab_pin.sym} 690 -34490 0 0 {name=p171 lab=_87831_/D }
C {devices/lab_pin.sym} 870 -34510 0 1 {name=p172 lab=_69052_/A }
C {sky130_stdcells/dfxtp_4.sym} 780 -34500 0 0 {name=X_87831_ }
C {devices/lab_pin.sym} 720 -34380 0 0 {name=p173 lab=_60032_/C }
C {devices/lab_pin.sym} 720 -34340 0 0 {name=p174 lab=_84289_/Q }
C {devices/lab_pin.sym} 840 -34360 0 1 {name=p175 lab=_80166_/X }
C {sky130_stdcells/xor2_4.sym} 780 -34360 0 0 {name=X_80166_ }
C {devices/lab_pin.sym} 720 -34240 0 0 {name=p176 lab=_57991_/A }
C {devices/lab_pin.sym} 720 -34200 0 0 {name=p177 lab=_57991_/B }
C {devices/lab_pin.sym} 840 -34220 0 1 {name=p178 lab=_57991_/Y }
C {sky130_stdcells/nor2_4.sym} 780 -34220 0 0 {name=X_57991_ }
C {devices/lab_pin.sym} 700 -34110 0 0 {name=p179 lab=_83882_/Q }
C {devices/lab_pin.sym} 700 -34070 0 0 {name=p180 lab=_69955_/X }
C {devices/lab_pin.sym} 700 -34030 0 0 {name=p181 lab=_69976_/X }
C {devices/lab_pin.sym} 860 -34070 0 1 {name=p182 lab=_83882_/D }
C {sky130_stdcells/a21bo_4.sym} 780 -34070 0 0 {name=X_69977_ }
C {devices/lab_pin.sym} 740 -33930 0 0 {name=p183 lab=_59730_/A }
C {devices/lab_pin.sym} 820 -33930 0 1 {name=p184 lab=_59754_/A }
C {sky130_stdcells/buf_2.sym} 780 -33930 0 0 {name=X_59730_ }
C {devices/lab_pin.sym} 700 -33830 0 0 {name=p185 lab=_66283_/B }
C {devices/lab_pin.sym} 700 -33790 0 0 {name=p186 lab=_52041_/X }
C {devices/lab_pin.sym} 700 -33750 0 0 {name=p187 lab=_52064_/Y }
C {devices/lab_pin.sym} 860 -33790 0 1 {name=p188 lab=_52065_/Y }
C {sky130_stdcells/o21ai_4.sym} 780 -33790 0 0 {name=X_52065_ }
C {devices/lab_pin.sym} 700 -33690 0 0 {name=p189 lab=_56561_/X }
C {devices/lab_pin.sym} 700 -33650 0 0 {name=p190 lab=_56930_/X }
C {devices/lab_pin.sym} 700 -33610 0 0 {name=p191 lab=_56931_/X }
C {devices/lab_pin.sym} 700 -33570 0 0 {name=p192 lab=_85121_/Q }
C {devices/lab_pin.sym} 700 -33530 0 0 {name=p193 lab=_57084_/A }
C {devices/lab_pin.sym} 860 -33610 0 1 {name=p194 lab=_56942_/X }
C {sky130_stdcells/a32o_4.sym} 780 -33610 0 0 {name=X_56942_ }
C {devices/lab_pin.sym} 700 -33470 0 0 {name=p195 lab=_83955_/Q }
C {devices/lab_pin.sym} 700 -33430 0 0 {name=p196 lab=_68838_/X }
C {devices/lab_pin.sym} 700 -33390 0 0 {name=p197 lab=_68927_/X }
C {devices/lab_pin.sym} 860 -33430 0 1 {name=p198 lab=_68928_/X }
C {sky130_stdcells/a21bo_4.sym} 780 -33430 0 0 {name=X_68928_ }
C {devices/lab_pin.sym} 690 -33290 0 0 {name=p199 lab=_87260_/CLK }
C {devices/lab_pin.sym} 690 -33270 0 0 {name=p200 lab=_42703_/X }
C {devices/lab_pin.sym} 870 -33290 0 1 {name=p201 lab=_68403_/B }
C {sky130_stdcells/dfxtp_4.sym} 780 -33280 0 0 {name=X_87762_ }
C {devices/lab_pin.sym} 690 -33150 0 0 {name=p202 lab=_86541_/CLK }
C {devices/lab_pin.sym} 690 -33130 0 0 {name=p203 lab=_84974_/D }
C {devices/lab_pin.sym} 870 -33150 0 1 {name=p204 lab=_84974_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -33140 0 0 {name=X_84974_ }
C {devices/lab_pin.sym} 700 -33030 0 0 {name=p205 lab=_80094_/Y }
C {devices/lab_pin.sym} 700 -32990 0 0 {name=p206 lab=_80077_/Y }
C {devices/lab_pin.sym} 700 -32950 0 0 {name=p207 lab=_80096_/X }
C {devices/lab_pin.sym} 860 -32990 0 1 {name=p208 lab=_80098_/B }
C {sky130_stdcells/o21ai_4.sym} 780 -32990 0 0 {name=X_80097_ }
C {devices/lab_pin.sym} 720 -32860 0 0 {name=p209 lab=_51003_/A }
C {devices/lab_pin.sym} 720 -32820 0 0 {name=p210 lab=_51016_/B }
C {devices/lab_pin.sym} 840 -32840 0 1 {name=p211 lab=_51016_/Y }
C {sky130_stdcells/nand2_4.sym} 780 -32840 0 0 {name=X_51016_ }
C {devices/lab_pin.sym} 690 -32710 0 0 {name=p212 lab=_86713_/CLK }
C {devices/lab_pin.sym} 690 -32690 0 0 {name=p213 lab=_86713_/D }
C {devices/lab_pin.sym} 870 -32710 0 1 {name=p214 lab=_58672_/A }
C {sky130_stdcells/dfxtp_4.sym} 780 -32700 0 0 {name=X_86713_ }
C {devices/lab_pin.sym} 690 -32570 0 0 {name=p215 lab=_81473_/CLK }
C {devices/lab_pin.sym} 690 -32550 0 0 {name=p216 lab=_83925_/D }
C {devices/lab_pin.sym} 870 -32570 0 1 {name=p217 lab=_83925_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -32560 0 0 {name=X_83925_ }
C {devices/lab_pin.sym} 720 -32460 0 0 {name=p218 lab=_59661_/A }
C {devices/lab_pin.sym} 720 -32420 0 0 {name=p219 lab=_59662_/C }
C {devices/lab_pin.sym} 720 -32380 0 0 {name=p220 lab=_59805_/A }
C {devices/lab_pin.sym} 720 -32340 0 0 {name=p221 lab=_59661_/D }
C {devices/lab_pin.sym} 840 -32400 0 1 {name=p222 lab=_59679_/A }
C {sky130_stdcells/and4_4.sym} 780 -32400 0 0 {name=X_59661_ }
C {devices/lab_pin.sym} 740 -32250 0 0 {name=p223 lab=_56872_/Y }
C {devices/lab_pin.sym} 820 -32250 0 1 {name=p224 lab=_56873_/X }
C {sky130_stdcells/buf_2.sym} 780 -32250 0 0 {name=X_56873_ }
C {devices/lab_pin.sym} 720 -32140 0 0 {name=p225 lab=_68669_/A }
C {devices/lab_pin.sym} 720 -32100 0 0 {name=p226 lab=_68859_/B }
C {devices/lab_pin.sym} 840 -32120 0 1 {name=p227 lab=_68859_/Y }
C {sky130_stdcells/nor2_4.sym} 780 -32120 0 0 {name=X_68859_ }
C {devices/lab_pin.sym} 690 -31990 0 0 {name=p228 lab=_87126_/CLK }
C {devices/lab_pin.sym} 690 -31970 0 0 {name=p229 lab=_87693_/D }
C {devices/lab_pin.sym} 870 -31990 0 1 {name=p230 lab=_66710_/B }
C {sky130_stdcells/dfxtp_4.sym} 780 -31980 0 0 {name=X_87693_ }
C {devices/lab_pin.sym} 700 -31880 0 0 {name=p231 lab=_84814_/Q }
C {devices/lab_pin.sym} 700 -31840 0 0 {name=p232 lab=_58599_/X }
C {devices/lab_pin.sym} 700 -31800 0 0 {name=p233 lab=_58604_/X }
C {devices/lab_pin.sym} 700 -31760 0 0 {name=p234 lab=_58611_/X }
C {devices/lab_pin.sym} 860 -31820 0 1 {name=p235 lab=_84814_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 780 -31820 0 0 {name=X_58612_ }
C {devices/lab_pin.sym} 700 -31700 0 0 {name=p236 lab=_56424_/C }
C {devices/lab_pin.sym} 700 -31660 0 0 {name=p237 lab=_55454_/X }
C {devices/lab_pin.sym} 700 -31620 0 0 {name=p238 lab=_55457_/X }
C {devices/lab_pin.sym} 700 -31580 0 0 {name=p239 lab=_55823_/X }
C {devices/lab_pin.sym} 860 -31640 0 1 {name=p240 lab=_55824_/X }
C {sky130_stdcells/a211o_4.sym} 780 -31640 0 0 {name=X_55824_ }
C {devices/lab_pin.sym} 690 -31490 0 0 {name=p241 lab=_86005_/CLK }
C {devices/lab_pin.sym} 690 -31470 0 0 {name=p242 lab=_86644_/D }
C {devices/lab_pin.sym} 870 -31490 0 1 {name=p243 lab=_57919_/A }
C {sky130_stdcells/dfxtp_4.sym} 780 -31480 0 0 {name=X_86644_ }
C {devices/lab_pin.sym} 740 -31350 0 0 {name=p244 lab=_71870_/A }
C {devices/lab_pin.sym} 820 -31350 0 1 {name=p245 lab=_71870_/Y }
C {sky130_stdcells/inv_2.sym} 780 -31350 0 0 {name=X_71870_ }
C {devices/lab_pin.sym} 700 -31270 0 0 {name=p246 lab=_59539_/A }
C {devices/lab_pin.sym} 700 -31230 0 0 {name=p247 lab=_59598_/A }
C {devices/lab_pin.sym} 700 -31190 0 0 {name=p248 lab=_44003_/X }
C {devices/lab_pin.sym} 700 -31150 0 0 {name=p249 lab=_59564_/A }
C {devices/lab_pin.sym} 700 -31120 0 0 {name=p250 lab=_59579_/A }
C {devices/lab_pin.sym} 860 -31190 0 1 {name=p251 lab=_60392_/B }
C {sky130_stdcells/a41oi_4.sym} 780 -31190 0 0 {name=X_59592_ }
C {devices/lab_pin.sym} 690 -31030 0 0 {name=p252 lab=_82596_/CLK }
C {devices/lab_pin.sym} 690 -31010 0 0 {name=p253 lab=_83856_/D }
C {devices/lab_pin.sym} 870 -31030 0 1 {name=p254 lab=_82536_/D }
C {sky130_stdcells/dfxtp_4.sym} 780 -31020 0 0 {name=X_83856_ }
C {devices/lab_pin.sym} 700 -30910 0 0 {name=p255 lab=_47195_/X }
C {devices/lab_pin.sym} 700 -30870 0 0 {name=p256 lab=_70802_/A }
C {devices/lab_pin.sym} 700 -30830 0 0 {name=p257 lab=_70820_/Y }
C {devices/lab_pin.sym} 860 -30870 0 1 {name=p258 lab=_83692_/D }
C {sky130_stdcells/o21ai_4.sym} 780 -30870 0 0 {name=X_70821_ }
C {devices/lab_pin.sym} 740 -30730 0 0 {name=p259 lab=_58543_/A }
C {devices/lab_pin.sym} 820 -30730 0 1 {name=p260 lab=_58543_/Y }
C {sky130_stdcells/inv_2.sym} 780 -30730 0 0 {name=X_58543_ }
C {devices/lab_pin.sym} 690 -30610 0 0 {name=p261 lab=_82740_/CLK }
C {devices/lab_pin.sym} 690 -30590 0 0 {name=p262 lab=_82839_/Q }
C {devices/lab_pin.sym} 870 -30610 0 1 {name=p263 lab=_78617_/B }
C {sky130_stdcells/dfxtp_4.sym} 780 -30600 0 0 {name=X_82807_ }
C {devices/lab_pin.sym} 700 -30490 0 0 {name=p264 lab=_55752_/Y }
C {devices/lab_pin.sym} 700 -30450 0 0 {name=p265 lab=_44095_/X }
C {devices/lab_pin.sym} 700 -30410 0 0 {name=p266 lab=_55754_/X }
C {devices/lab_pin.sym} 860 -30450 0 1 {name=p267 lab=_56117_/B }
C {sky130_stdcells/a21boi_4.sym} 780 -30450 0 0 {name=X_55755_ }
C {devices/lab_pin.sym} 690 -30310 0 0 {name=p268 lab=_86576_/CLK }
C {devices/lab_pin.sym} 690 -30290 0 0 {name=p269 lab=_48029_/Y }
C {devices/lab_pin.sym} 870 -30310 0 1 {name=p270 lab=_66168_/B }
C {sky130_stdcells/dfxtp_4.sym} 780 -30300 0 0 {name=X_86575_ }
C {devices/lab_pin.sym} 700 -30190 0 0 {name=p271 lab=_40931_/X }
C {devices/lab_pin.sym} 700 -30150 0 0 {name=p272 lab=_81720_/Q }
C {devices/lab_pin.sym} 700 -30110 0 0 {name=p273 lab=_40980_/X }
C {devices/lab_pin.sym} 860 -30150 0 1 {name=p274 lab=_40982_/A }
C {sky130_stdcells/o21ai_4.sym} 780 -30150 0 0 {name=X_40981_ }
C {devices/lab_pin.sym} 720 -30040 0 0 {name=p275 lab=_52947_/X }
C {devices/lab_pin.sym} 720 -30000 0 0 {name=p276 lab=_52982_/B }
C {devices/lab_pin.sym} 720 -29960 0 0 {name=p277 lab=_52977_/C }
C {devices/lab_pin.sym} 720 -29920 0 0 {name=p278 lab=_52967_/D }
C {devices/lab_pin.sym} 840 -29980 0 1 {name=p279 lab=_52967_/X }
C {sky130_stdcells/and4_4.sym} 780 -29980 0 0 {name=X_52967_ }
C {devices/lab_pin.sym} 690 -29830 0 0 {name=p280 lab=_83787_/CLK }
C {devices/lab_pin.sym} 690 -29810 0 0 {name=p281 lab=_70349_/X }
C {devices/lab_pin.sym} 870 -29830 0 1 {name=p282 lab=_74745_/A }
C {sky130_stdcells/dfxtp_4.sym} 780 -29820 0 0 {name=X_83787_ }
C {devices/lab_pin.sym} 690 -29690 0 0 {name=p283 lab=_80776_/CLK }
C {devices/lab_pin.sym} 690 -29670 0 0 {name=p284 lab=_65294_/C }
C {devices/lab_pin.sym} 870 -29690 0 1 {name=p285 lab=_75617_/A }
C {sky130_stdcells/dfxtp_4.sym} 780 -29680 0 0 {name=X_80999_ }
C {devices/lab_pin.sym} 740 -29550 0 0 {name=p286 lab=clkbuf_9_296_0_CLK/X }
C {devices/lab_pin.sym} 820 -29550 0 1 {name=p287 lab=_82084_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 780 -29550 0 0 {name=Xclkbuf_10_593_0_CLK }
C {devices/lab_pin.sym} 690 -29430 0 0 {name=p288 lab=_88085_/CLK }
C {devices/lab_pin.sym} 690 -29410 0 0 {name=p289 lab=_40900_/X }
C {devices/lab_pin.sym} 870 -29430 0 1 {name=p290 lab=_88314_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -29420 0 0 {name=X_88314_ }
C {devices/lab_pin.sym} 740 -29290 0 0 {name=p291 lab=_42465_/A }
C {devices/lab_pin.sym} 820 -29290 0 1 {name=p292 lab=_42720_/X }
C {sky130_stdcells/buf_2.sym} 780 -29290 0 0 {name=X_42720_ }
C {devices/lab_pin.sym} 700 -29190 0 0 {name=p293 lab=_85393_/Q }
C {devices/lab_pin.sym} 700 -29150 0 0 {name=p294 lab=_54703_/X }
C {devices/lab_pin.sym} 700 -29110 0 0 {name=p295 lab=_54705_/Y }
C {devices/lab_pin.sym} 860 -29150 0 1 {name=p296 lab=_54706_/Y }
C {sky130_stdcells/o21ai_4.sym} 780 -29150 0 0 {name=X_54706_ }
C {devices/lab_pin.sym} 690 -29010 0 0 {name=p297 lab=_85815_/CLK }
C {devices/lab_pin.sym} 690 -28990 0 0 {name=p298 lab=_53999_/Y }
C {devices/lab_pin.sym} 870 -29010 0 1 {name=p299 lab=_85526_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -29000 0 0 {name=X_85526_ }
C {devices/lab_pin.sym} 720 -28880 0 0 {name=p300 lab=_73476_/A }
C {devices/lab_pin.sym} 720 -28840 0 0 {name=p301 lab=_86498_/Q }
C {devices/lab_pin.sym} 840 -28860 0 1 {name=p302 lab=_73540_/X }
C {sky130_stdcells/and2_4.sym} 780 -28860 0 0 {name=X_73540_ }
C {devices/lab_pin.sym} 740 -28730 0 0 {name=p303 lab=_52626_/A }
C {devices/lab_pin.sym} 820 -28730 0 1 {name=p304 lab=_51919_/C }
C {sky130_stdcells/buf_2.sym} 780 -28730 0 0 {name=X_51918_ }
C {devices/lab_pin.sym} 700 -28630 0 0 {name=p305 lab=_53127_/B }
C {devices/lab_pin.sym} 700 -28590 0 0 {name=p306 lab=_70740_/A }
C {devices/lab_pin.sym} 700 -28550 0 0 {name=p307 lab=_70751_/Y }
C {devices/lab_pin.sym} 860 -28590 0 1 {name=p308 lab=_83708_/D }
C {sky130_stdcells/o21ai_4.sym} 780 -28590 0 0 {name=X_70752_ }
C {devices/lab_pin.sym} 690 -28450 0 0 {name=p309 lab=_82152_/CLK }
C {devices/lab_pin.sym} 690 -28430 0 0 {name=p310 lab=_84122_/Q }
C {devices/lab_pin.sym} 870 -28450 0 1 {name=p311 lab=_82738_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -28440 0 0 {name=X_82738_ }
C {devices/lab_pin.sym} 720 -28320 0 0 {name=p312 lab=_58474_/A }
C {devices/lab_pin.sym} 720 -28280 0 0 {name=p313 lab=_58474_/B }
C {devices/lab_pin.sym} 840 -28300 0 1 {name=p314 lab=_58474_/Y }
C {sky130_stdcells/nor2_4.sym} 780 -28300 0 0 {name=X_58474_ }
C {devices/lab_pin.sym} 720 -28200 0 0 {name=p315 lab=_73024_/B }
C {devices/lab_pin.sym} 720 -28160 0 0 {name=p316 lab=_56171_/A }
C {devices/lab_pin.sym} 720 -28120 0 0 {name=p317 lab=_55686_/C }
C {devices/lab_pin.sym} 720 -28080 0 0 {name=p318 lab=_56171_/C }
C {devices/lab_pin.sym} 840 -28140 0 1 {name=p319 lab=_55686_/Y }
C {sky130_stdcells/nand4_4.sym} 780 -28140 0 0 {name=X_55686_ }
C {devices/lab_pin.sym} 700 -28010 0 0 {name=p320 lab=_85734_/Q }
C {devices/lab_pin.sym} 700 -27970 0 0 {name=p321 lab=_52874_/X }
C {devices/lab_pin.sym} 700 -27930 0 0 {name=p322 lab=_52897_/Y }
C {devices/lab_pin.sym} 860 -27970 0 1 {name=p323 lab=_52898_/Y }
C {sky130_stdcells/o21ai_4.sym} 780 -27970 0 0 {name=X_52898_ }
C {devices/lab_pin.sym} 720 -27840 0 0 {name=p324 lab=_55317_/B }
C {devices/lab_pin.sym} 720 -27800 0 0 {name=p325 lab=_57413_/X }
C {devices/lab_pin.sym} 840 -27820 0 1 {name=p326 lab=_57425_/X }
C {sky130_stdcells/or2_4.sym} 780 -27820 0 0 {name=X_57425_ }
C {devices/lab_pin.sym} 690 -27690 0 0 {name=p327 lab=_88245_/CLK }
C {devices/lab_pin.sym} 690 -27670 0 0 {name=p328 lab=_41279_/Y }
C {devices/lab_pin.sym} 870 -27690 0 1 {name=p329 lab=_69104_/B }
C {sky130_stdcells/dfxtp_4.sym} 780 -27680 0 0 {name=X_88245_ }
C {devices/lab_pin.sym} 740 -27550 0 0 {name=p330 lab=_52754_/A }
C {devices/lab_pin.sym} 820 -27550 0 1 {name=p331 lab=_42651_/X }
C {sky130_stdcells/buf_2.sym} 780 -27550 0 0 {name=X_42651_ }
C {devices/lab_pin.sym} 700 -27450 0 0 {name=p332 lab=_85405_/Q }
C {devices/lab_pin.sym} 700 -27410 0 0 {name=p333 lab=_54621_/X }
C {devices/lab_pin.sym} 700 -27370 0 0 {name=p334 lab=_54636_/Y }
C {devices/lab_pin.sym} 860 -27410 0 1 {name=p335 lab=_54637_/Y }
C {sky130_stdcells/o21ai_4.sym} 780 -27410 0 0 {name=X_54637_ }
C {devices/lab_pin.sym} 700 -27300 0 0 {name=p336 lab=_72721_/X }
C {devices/lab_pin.sym} 700 -27260 0 0 {name=p337 lab=_86181_/Q }
C {devices/lab_pin.sym} 700 -27220 0 0 {name=p338 lab=_73351_/X }
C {devices/lab_pin.sym} 700 -27180 0 0 {name=p339 lab=_73470_/X }
C {devices/lab_pin.sym} 860 -27240 0 1 {name=p340 lab=_73471_/X }
C {sky130_stdcells/a211o_4.sym} 780 -27240 0 0 {name=X_73471_ }
C {devices/lab_pin.sym} 690 -27090 0 0 {name=p341 lab=_85459_/CLK }
C {devices/lab_pin.sym} 690 -27070 0 0 {name=p342 lab=_85457_/D }
C {devices/lab_pin.sym} 870 -27090 0 1 {name=p343 lab=_85457_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -27080 0 0 {name=X_85457_ }
C {devices/lab_pin.sym} 700 -26970 0 0 {name=p344 lab=_85935_/Q }
C {devices/lab_pin.sym} 700 -26930 0 0 {name=p345 lab=_51846_/X }
C {devices/lab_pin.sym} 700 -26890 0 0 {name=p346 lab=_51848_/Y }
C {devices/lab_pin.sym} 860 -26930 0 1 {name=p347 lab=_51849_/Y }
C {sky130_stdcells/o21ai_4.sym} 780 -26930 0 0 {name=X_51849_ }
C {devices/lab_pin.sym} 700 -26810 0 0 {name=p348 lab=_70664_/X }
C {devices/lab_pin.sym} 700 -26770 0 0 {name=p349 lab=_47489_/A }
C {devices/lab_pin.sym} 700 -26730 0 0 {name=p350 lab=_70682_/Y }
C {devices/lab_pin.sym} 860 -26770 0 1 {name=p351 lab=_83725_/D }
C {sky130_stdcells/a21o_4.sym} 780 -26770 0 0 {name=X_70683_ }
C {devices/lab_pin.sym} 690 -26630 0 0 {name=p352 lab=_82675_/CLK }
C {devices/lab_pin.sym} 690 -26610 0 0 {name=p353 lab=_82669_/D }
C {devices/lab_pin.sym} 870 -26630 0 1 {name=p354 lab=_82669_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -26620 0 0 {name=X_82669_ }
C {devices/lab_pin.sym} 720 -26500 0 0 {name=p355 lab=_75217_/B }
C {devices/lab_pin.sym} 720 -26460 0 0 {name=p356 lab=_75210_/B }
C {devices/lab_pin.sym} 840 -26480 0 1 {name=p357 lab=_81035_/D }
C {sky130_stdcells/xor2_4.sym} 780 -26480 0 0 {name=X_75210_ }
C {devices/lab_pin.sym} 700 -26380 0 0 {name=p358 lab=_41601_/X }
C {devices/lab_pin.sym} 700 -26340 0 0 {name=p359 lab=_41581_/X }
C {devices/lab_pin.sym} 700 -26300 0 0 {name=p360 lab=_67231_/B }
C {devices/lab_pin.sym} 700 -26260 0 0 {name=p361 lab=_41582_/X }
C {devices/lab_pin.sym} 860 -26320 0 1 {name=p362 lab=_88184_/D }
C {sky130_stdcells/a2bb2o_4.sym} 780 -26320 0 0 {name=X_41602_ }
C {devices/lab_pin.sym} 740 -26170 0 0 {name=p363 lab=_58126_/A }
C {devices/lab_pin.sym} 820 -26170 0 1 {name=p364 lab=_72422_/X }
C {sky130_stdcells/buf_2.sym} 780 -26170 0 0 {name=X_72422_ }
C {devices/lab_pin.sym} 690 -26050 0 0 {name=p365 lab=_84408_/CLK }
C {devices/lab_pin.sym} 690 -26030 0 0 {name=p366 lab=_62469_/Y }
C {devices/lab_pin.sym} 870 -26050 0 1 {name=p367 lab=_76984_/B }
C {sky130_stdcells/dfxtp_4.sym} 780 -26040 0 0 {name=X_84408_ }
C {devices/lab_pin.sym} 740 -25910 0 0 {name=p368 lab=_45452_/A }
C {devices/lab_pin.sym} 820 -25910 0 1 {name=p369 lab=_45370_/X }
C {sky130_stdcells/buf_2.sym} 780 -25910 0 0 {name=X_45370_ }
C {devices/lab_pin.sym} 700 -25810 0 0 {name=p370 lab=_57238_/X }
C {devices/lab_pin.sym} 700 -25770 0 0 {name=p371 lab=_57354_/Y }
C {devices/lab_pin.sym} 700 -25730 0 0 {name=p372 lab=_57355_/Y }
C {devices/lab_pin.sym} 860 -25770 0 1 {name=p373 lab=_85030_/D }
C {sky130_stdcells/o21ai_4.sym} 780 -25770 0 0 {name=X_57356_ }
C {devices/lab_pin.sym} 690 -25630 0 0 {name=p374 lab=_87473_/CLK }
C {devices/lab_pin.sym} 690 -25610 0 0 {name=p375 lab=_88176_/D }
C {devices/lab_pin.sym} 870 -25630 0 1 {name=p376 lab=_67421_/B }
C {sky130_stdcells/dfxtp_4.sym} 780 -25620 0 0 {name=X_88176_ }
C {devices/lab_pin.sym} 700 -25510 0 0 {name=p377 lab=_76176_/Y }
C {devices/lab_pin.sym} 700 -25470 0 0 {name=p378 lab=_76171_/Y }
C {devices/lab_pin.sym} 700 -25430 0 0 {name=p379 lab=_76175_/A }
C {devices/lab_pin.sym} 860 -25470 0 1 {name=p380 lab=_76190_/X }
C {sky130_stdcells/o21a_4.sym} 780 -25470 0 0 {name=X_76190_ }
C {devices/lab_pin.sym} 740 -25330 0 0 {name=p381 lab=_42581_/Y }
C {devices/lab_pin.sym} 820 -25330 0 1 {name=p382 lab=_87813_/D }
C {sky130_stdcells/inv_2.sym} 780 -25330 0 0 {name=X_42582_ }
C {devices/lab_pin.sym} 740 -25210 0 0 {name=p383 lab=_54486_/A }
C {devices/lab_pin.sym} 820 -25210 0 1 {name=p384 lab=_54578_/A }
C {sky130_stdcells/buf_2.sym} 780 -25210 0 0 {name=X_54568_ }
C {devices/lab_pin.sym} 690 -25090 0 0 {name=p385 lab=_85484_/CLK }
C {devices/lab_pin.sym} 690 -25070 0 0 {name=p386 lab=_54735_/Y }
C {devices/lab_pin.sym} 870 -25090 0 1 {name=p387 lab=_85388_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -25080 0 0 {name=X_85388_ }
C {devices/lab_pin.sym} 700 -24990 0 0 {name=p388 lab=_41839_/X }
C {devices/lab_pin.sym} 700 -24950 0 0 {name=p389 lab=_40488_/X }
C {devices/lab_pin.sym} 700 -24910 0 0 {name=p390 lab=_41631_/X }
C {devices/lab_pin.sym} 700 -24870 0 0 {name=p391 lab=_87167_/Q }
C {devices/lab_pin.sym} 700 -24830 0 0 {name=p392 lab=_40492_/X }
C {devices/lab_pin.sym} 860 -24910 0 1 {name=p393 lab=_44321_/Y }
C {sky130_stdcells/o32ai_4.sym} 780 -24910 0 0 {name=X_44321_ }
C {devices/lab_pin.sym} 700 -24770 0 0 {name=p394 lab=_56040_/X }
C {devices/lab_pin.sym} 700 -24730 0 0 {name=p395 lab=_56305_/X }
C {devices/lab_pin.sym} 700 -24690 0 0 {name=p396 lab=_56306_/Y }
C {devices/lab_pin.sym} 860 -24730 0 1 {name=p397 lab=_85242_/D }
C {sky130_stdcells/o21ai_4.sym} 780 -24730 0 0 {name=X_56307_ }
C {devices/lab_pin.sym} 690 -24590 0 0 {name=p398 lab=_87126_/CLK }
C {devices/lab_pin.sym} 690 -24570 0 0 {name=p399 lab=_87127_/D }
C {devices/lab_pin.sym} 870 -24590 0 1 {name=p400 lab=_87127_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -24580 0 0 {name=X_87127_ }
C {devices/lab_pin.sym} 700 -24470 0 0 {name=p401 lab=_75142_/A }
C {devices/lab_pin.sym} 700 -24430 0 0 {name=p402 lab=_75140_/Y }
C {devices/lab_pin.sym} 700 -24390 0 0 {name=p403 lab=_81063_/Q }
C {devices/lab_pin.sym} 860 -24430 0 1 {name=p404 lab=_75141_/X }
C {sky130_stdcells/a21o_4.sym} 780 -24430 0 0 {name=X_75141_ }
C {devices/lab_pin.sym} 740 -24290 0 0 {name=p405 lab=_40380_/A }
C {devices/lab_pin.sym} 820 -24290 0 1 {name=p406 lab=_41533_/X }
C {sky130_stdcells/buf_2.sym} 780 -24290 0 0 {name=X_41533_ }
C {devices/lab_pin.sym} 700 -24190 0 0 {name=p407 lab=_85621_/Q }
C {devices/lab_pin.sym} 700 -24150 0 0 {name=p408 lab=_53506_/X }
C {devices/lab_pin.sym} 700 -24110 0 0 {name=p409 lab=_53518_/Y }
C {devices/lab_pin.sym} 860 -24150 0 1 {name=p410 lab=_53519_/Y }
C {sky130_stdcells/o21ai_4.sym} 780 -24150 0 0 {name=X_53519_ }
C {devices/lab_pin.sym} 700 -24030 0 0 {name=p411 lab=_72258_/X }
C {devices/lab_pin.sym} 700 -23990 0 0 {name=p412 lab=_85678_/Q }
C {devices/lab_pin.sym} 700 -23950 0 0 {name=p413 lab=_72308_/X }
C {devices/lab_pin.sym} 860 -23990 0 1 {name=p414 lab=_72353_/X }
C {sky130_stdcells/o21a_4.sym} 780 -23990 0 0 {name=X_72353_ }
C {devices/lab_pin.sym} 690 -23850 0 0 {name=p415 lab=_84263_/CLK }
C {devices/lab_pin.sym} 690 -23830 0 0 {name=p416 lab=_84339_/D }
C {devices/lab_pin.sym} 870 -23850 0 1 {name=p417 lab=_84339_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -23840 0 0 {name=X_84339_ }
C {devices/lab_pin.sym} 740 -23710 0 0 {name=p418 lab=_57286_/X }
C {devices/lab_pin.sym} 820 -23710 0 1 {name=p419 lab=_85040_/D }
C {sky130_stdcells/inv_2.sym} 780 -23710 0 0 {name=X_57287_ }
C {devices/lab_pin.sym} 700 -23610 0 0 {name=p420 lab=_54497_/Y }
C {devices/lab_pin.sym} 700 -23570 0 0 {name=p421 lab=_54475_/X }
C {devices/lab_pin.sym} 700 -23530 0 0 {name=p422 lab=_54498_/X }
C {devices/lab_pin.sym} 860 -23570 0 1 {name=p423 lab=_54499_/Y }
C {sky130_stdcells/a21oi_4.sym} 780 -23570 0 0 {name=X_54499_ }
C {devices/lab_pin.sym} 700 -23450 0 0 {name=p424 lab=_47034_/Y }
C {devices/lab_pin.sym} 700 -23410 0 0 {name=p425 lab=_47035_/X }
C {devices/lab_pin.sym} 700 -23370 0 0 {name=p426 lab=_47039_/X }
C {devices/lab_pin.sym} 860 -23410 0 1 {name=p427 lab=_86677_/D }
C {sky130_stdcells/a21oi_4.sym} 780 -23410 0 0 {name=X_47040_ }
C {devices/lab_pin.sym} 700 -23300 0 0 {name=p428 lab=_84775_/Q }
C {devices/lab_pin.sym} 700 -23260 0 0 {name=p429 lab=_58956_/X }
C {devices/lab_pin.sym} 700 -23220 0 0 {name=p430 lab=_59020_/X }
C {devices/lab_pin.sym} 700 -23180 0 0 {name=p431 lab=_59025_/X }
C {devices/lab_pin.sym} 860 -23240 0 1 {name=p432 lab=_84775_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 780 -23240 0 0 {name=X_59026_ }
C {devices/lab_pin.sym} 700 -23110 0 0 {name=p433 lab=_50328_/B }
C {devices/lab_pin.sym} 700 -23070 0 0 {name=p434 lab=_71290_/X }
C {devices/lab_pin.sym} 700 -23030 0 0 {name=p435 lab=_71303_/Y }
C {devices/lab_pin.sym} 860 -23070 0 1 {name=p436 lab=_83542_/D }
C {sky130_stdcells/o21ai_4.sym} 780 -23070 0 0 {name=X_71304_ }
C {devices/lab_pin.sym} 740 -22930 0 0 {name=p437 lab=_58020_/A }
C {devices/lab_pin.sym} 820 -22930 0 1 {name=p438 lab=_44252_/X }
C {sky130_stdcells/buf_2.sym} 780 -22930 0 0 {name=X_44252_ }
C {devices/lab_pin.sym} 700 -22830 0 0 {name=p439 lab=_56099_/X }
C {devices/lab_pin.sym} 700 -22790 0 0 {name=p440 lab=_56225_/X }
C {devices/lab_pin.sym} 700 -22750 0 0 {name=p441 lab=_56237_/Y }
C {devices/lab_pin.sym} 860 -22790 0 1 {name=p442 lab=_85264_/D }
C {sky130_stdcells/o21ai_4.sym} 780 -22790 0 0 {name=X_56238_ }
C {devices/lab_pin.sym} 720 -22660 0 0 {name=p443 lab=_75069_/Y }
C {devices/lab_pin.sym} 720 -22620 0 0 {name=p444 lab=_75071_/Y }
C {devices/lab_pin.sym} 840 -22640 0 1 {name=p445 lab=_75072_/Y }
C {sky130_stdcells/nand2_4.sym} 780 -22640 0 0 {name=X_75072_ }
C {devices/lab_pin.sym} 690 -22510 0 0 {name=p446 lab=_88060_/CLK }
C {devices/lab_pin.sym} 690 -22490 0 0 {name=p447 lab=_87058_/D }
C {devices/lab_pin.sym} 870 -22510 0 1 {name=p448 lab=_73104_/A }
C {sky130_stdcells/dfxtp_4.sym} 780 -22500 0 0 {name=X_87058_ }
C {devices/lab_pin.sym} 700 -22390 0 0 {name=p449 lab=_41449_/X }
C {devices/lab_pin.sym} 700 -22350 0 0 {name=p450 lab=_82336_/Q }
C {devices/lab_pin.sym} 700 -22310 0 0 {name=p451 lab=_41463_/X }
C {devices/lab_pin.sym} 860 -22350 0 1 {name=p452 lab=_41464_/Y }
C {sky130_stdcells/o21ai_4.sym} 780 -22350 0 0 {name=X_41464_ }
C {devices/lab_pin.sym} 700 -22230 0 0 {name=p453 lab=_72281_/Y }
C {devices/lab_pin.sym} 700 -22190 0 0 {name=p454 lab=_72283_/Y }
C {devices/lab_pin.sym} 700 -22150 0 0 {name=p455 lab=_72201_/X }
C {devices/lab_pin.sym} 860 -22190 0 1 {name=p456 lab=_72284_/X }
C {sky130_stdcells/a21o_4.sym} 780 -22190 0 0 {name=X_72284_ }
C {devices/lab_pin.sym} 740 -22050 0 0 {name=p457 lab=clkbuf_9_265_0_CLK/X }
C {devices/lab_pin.sym} 820 -22050 0 1 {name=p458 lab=_81346_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 780 -22050 0 0 {name=Xclkbuf_10_531_0_CLK }
C {devices/lab_pin.sym} 740 -21930 0 0 {name=p459 lab=_87540_/Q }
C {devices/lab_pin.sym} 820 -21930 0 1 {name=p460 lab=_43203_/Y }
C {sky130_stdcells/inv_2.sym} 780 -21930 0 0 {name=X_43203_ }
C {devices/lab_pin.sym} 720 -21820 0 0 {name=p461 lab=_74022_/X }
C {devices/lab_pin.sym} 720 -21780 0 0 {name=p462 lab=_86542_/Q }
C {devices/lab_pin.sym} 840 -21800 0 1 {name=p463 lab=_74023_/X }
C {sky130_stdcells/and2_4.sym} 780 -21800 0 0 {name=X_74023_ }
C {devices/lab_pin.sym} 720 -21680 0 0 {name=p464 lab=_78900_/A }
C {devices/lab_pin.sym} 720 -21640 0 0 {name=p465 lab=_78899_/Y }
C {devices/lab_pin.sym} 840 -21660 0 1 {name=p466 lab=_78901_/B }
C {sky130_stdcells/xor2_4.sym} 780 -21660 0 0 {name=X_78900_ }
C {devices/lab_pin.sym} 740 -21530 0 0 {name=p467 lab=clkbuf_6_23_0_CLK/A }
C {devices/lab_pin.sym} 820 -21530 0 1 {name=p468 lab=clkbuf_6_22_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 780 -21530 0 0 {name=Xclkbuf_6_22_0_CLK }
C {devices/lab_pin.sym} 690 -21410 0 0 {name=p469 lab=_86008_/CLK }
C {devices/lab_pin.sym} 690 -21390 0 0 {name=p470 lab=_86009_/D }
C {devices/lab_pin.sym} 870 -21410 0 1 {name=p471 lab=_86009_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -21400 0 0 {name=X_86009_ }
C {devices/lab_pin.sym} 740 -21270 0 0 {name=p472 lab=_40414_/X }
C {devices/lab_pin.sym} 820 -21270 0 1 {name=p473 lab=_40416_/A }
C {sky130_stdcells/buf_2.sym} 780 -21270 0 0 {name=X_40415_ }
C {devices/lab_pin.sym} 720 -21170 0 0 {name=p474 lab=_71235_/A }
C {devices/lab_pin.sym} 720 -21130 0 0 {name=p475 lab=_71091_/B }
C {devices/lab_pin.sym} 720 -21090 0 0 {name=p476 lab=_71232_/C }
C {devices/lab_pin.sym} 840 -21130 0 1 {name=p477 lab=_71235_/Y }
C {sky130_stdcells/nand3_4.sym} 780 -21130 0 0 {name=X_71235_ }
C {devices/lab_pin.sym} 740 -20990 0 0 {name=p478 lab=_44036_/Y }
C {devices/lab_pin.sym} 820 -20990 0 1 {name=p479 lab=_44184_/A }
C {sky130_stdcells/buf_2.sym} 780 -20990 0 0 {name=X_44183_ }
C {devices/lab_pin.sym} 720 -20890 0 0 {name=p480 lab=_56169_/A }
C {devices/lab_pin.sym} 720 -20850 0 0 {name=p481 lab=_56150_/B }
C {devices/lab_pin.sym} 720 -20810 0 0 {name=p482 lab=_85283_/Q }
C {devices/lab_pin.sym} 840 -20850 0 1 {name=p483 lab=_56169_/Y }
C {sky130_stdcells/nand3_4.sym} 780 -20850 0 0 {name=X_56169_ }
C {devices/lab_pin.sym} 720 -20720 0 0 {name=p484 lab=_79878_/Y }
C {devices/lab_pin.sym} 720 -20680 0 0 {name=p485 lab=_79874_/X }
C {devices/lab_pin.sym} 840 -20700 0 1 {name=p486 lab=_79882_/A }
C {sky130_stdcells/nand2_4.sym} 780 -20700 0 0 {name=X_79880_ }
C {devices/lab_pin.sym} 720 -20580 0 0 {name=p487 lab=_81740_/Q }
C {devices/lab_pin.sym} 720 -20540 0 0 {name=p488 lab=_41325_/X }
C {devices/lab_pin.sym} 840 -20560 0 1 {name=p489 lab=_41395_/X }
C {sky130_stdcells/or2_4.sym} 780 -20560 0 0 {name=X_41395_ }
C {devices/lab_pin.sym} 700 -20470 0 0 {name=p490 lab=_43046_/X }
C {devices/lab_pin.sym} 700 -20430 0 0 {name=p491 lab=_43125_/X }
C {devices/lab_pin.sym} 700 -20390 0 0 {name=p492 lab=_40802_/X }
C {devices/lab_pin.sym} 700 -20350 0 0 {name=p493 lab=_43133_/Y }
C {devices/lab_pin.sym} 700 -20310 0 0 {name=p494 lab=_43127_/X }
C {devices/lab_pin.sym} 860 -20390 0 1 {name=p495 lab=_87564_/D }
C {sky130_stdcells/o32ai_4.sym} 780 -20390 0 0 {name=X_43134_ }
C {devices/lab_pin.sym} 720 -20240 0 0 {name=p496 lab=_78831_/A }
C {devices/lab_pin.sym} 720 -20200 0 0 {name=p497 lab=_78831_/B }
C {devices/lab_pin.sym} 840 -20220 0 1 {name=p498 lab=_78831_/X }
C {sky130_stdcells/xor2_4.sym} 780 -20220 0 0 {name=X_78831_ }
C {devices/lab_pin.sym} 700 -20110 0 0 {name=p499 lab=_40326_/A }
C {devices/lab_pin.sym} 700 -20070 0 0 {name=p500 lab=_86757_/Q }
C {devices/lab_pin.sym} 700 -20030 0 0 {name=p501 lab=_43175_/B }
C {devices/lab_pin.sym} 860 -20070 0 1 {name=p502 lab=_40361_/A }
C {sky130_stdcells/o21a_4.sym} 780 -20070 0 0 {name=X_40346_ }
C {devices/lab_pin.sym} 740 -19930 0 0 {name=p503 lab=_71170_/A }
C {devices/lab_pin.sym} 820 -19930 0 1 {name=p504 lab=_74531_/B }
C {sky130_stdcells/buf_2.sym} 780 -19930 0 0 {name=X_71166_ }
C {devices/lab_pin.sym} 740 -19810 0 0 {name=p505 lab=_83614_/Q }
C {devices/lab_pin.sym} 820 -19810 0 1 {name=p506 lab=_72012_/B }
C {sky130_stdcells/inv_2.sym} 780 -19810 0 0 {name=X_48991_ }
C {devices/lab_pin.sym} 720 -19720 0 0 {name=p507 lab=_70117_/A }
C {devices/lab_pin.sym} 720 -19680 0 0 {name=p508 lab=_70114_/Y }
C {devices/lab_pin.sym} 720 -19640 0 0 {name=p509 lab=_70117_/C }
C {devices/lab_pin.sym} 720 -19600 0 0 {name=p510 lab=_70117_/D }
C {devices/lab_pin.sym} 840 -19660 0 1 {name=p511 lab=_70118_/D }
C {sky130_stdcells/nand4_4.sym} 780 -19660 0 0 {name=X_70117_ }
C {devices/lab_pin.sym} 700 -19530 0 0 {name=p512 lab=_66055_/B }
C {devices/lab_pin.sym} 700 -19490 0 0 {name=p513 lab=_47897_/X }
C {devices/lab_pin.sym} 700 -19450 0 0 {name=p514 lab=_47941_/Y }
C {devices/lab_pin.sym} 860 -19490 0 1 {name=p515 lab=_47942_/Y }
C {sky130_stdcells/o21ai_4.sym} 780 -19490 0 0 {name=X_47942_ }
C {devices/lab_pin.sym} 740 -19350 0 0 {name=p516 lab=_59927_/Y }
C {devices/lab_pin.sym} 820 -19350 0 1 {name=p517 lab=_59985_/A }
C {sky130_stdcells/buf_2.sym} 780 -19350 0 0 {name=X_59928_ }
C {devices/lab_pin.sym} 740 -19230 0 0 {name=p518 lab=_43065_/A }
C {devices/lab_pin.sym} 820 -19230 0 1 {name=p519 lab=_43065_/Y }
C {sky130_stdcells/inv_2.sym} 780 -19230 0 0 {name=X_43065_ }
C {devices/lab_pin.sym} 720 -19120 0 0 {name=p520 lab=_78762_/A }
C {devices/lab_pin.sym} 720 -19080 0 0 {name=p521 lab=_78761_/X }
C {devices/lab_pin.sym} 840 -19100 0 1 {name=p522 lab=_78762_/X }
C {sky130_stdcells/xor2_4.sym} 780 -19100 0 0 {name=X_78762_ }
C {devices/lab_pin.sym} 720 -18990 0 0 {name=p523 lab=_71088_/A }
C {devices/lab_pin.sym} 720 -18950 0 0 {name=p524 lab=_71073_/B }
C {devices/lab_pin.sym} 720 -18910 0 0 {name=p525 lab=_71099_/C }
C {devices/lab_pin.sym} 840 -18950 0 1 {name=p526 lab=_71097_/Y }
C {sky130_stdcells/nand3_4.sym} 780 -18950 0 0 {name=X_71097_ }
C {devices/lab_pin.sym} 720 -18820 0 0 {name=p527 lab=_75948_/Y }
C {devices/lab_pin.sym} 720 -18780 0 0 {name=p528 lab=_75974_/B }
C {devices/lab_pin.sym} 840 -18800 0 1 {name=p529 lab=_75980_/A }
C {sky130_stdcells/nand2_4.sym} 780 -18800 0 0 {name=X_75974_ }
C {devices/lab_pin.sym} 740 -18670 0 0 {name=p530 lab=clkbuf_9_273_0_CLK/X }
C {devices/lab_pin.sym} 820 -18670 0 1 {name=p531 lab=_82642_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 780 -18670 0 0 {name=Xclkbuf_10_546_0_CLK }
C {devices/lab_pin.sym} 740 -18550 0 0 {name=p532 lab=clkbuf_6_37_0_CLK/A }
C {devices/lab_pin.sym} 820 -18550 0 1 {name=p533 lab=clkbuf_7_74_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 780 -18550 0 0 {name=Xclkbuf_6_37_0_CLK }
C {devices/lab_pin.sym} 700 -18470 0 0 {name=p534 lab=_42013_/X }
C {devices/lab_pin.sym} 700 -18430 0 0 {name=p535 lab=_42006_/X }
C {devices/lab_pin.sym} 700 -18390 0 0 {name=p536 lab=_40831_/X }
C {devices/lab_pin.sym} 700 -18350 0 0 {name=p537 lab=_73106_/A }
C {devices/lab_pin.sym} 700 -18310 0 0 {name=p538 lab=_42007_/X }
C {devices/lab_pin.sym} 860 -18390 0 1 {name=p539 lab=_42017_/A }
C {sky130_stdcells/o32ai_4.sym} 780 -18390 0 0 {name=X_42016_ }
C {devices/lab_pin.sym} 700 -18250 0 0 {name=p540 lab=_77698_/Y }
C {devices/lab_pin.sym} 700 -18210 0 0 {name=p541 lab=_77711_/Y }
C {devices/lab_pin.sym} 700 -18170 0 0 {name=p542 lab=_77712_/Y }
C {devices/lab_pin.sym} 860 -18210 0 1 {name=p543 lab=_77713_/Y }
C {sky130_stdcells/o21ai_4.sym} 780 -18210 0 0 {name=X_77713_ }
C {devices/lab_pin.sym} 700 -18090 0 0 {name=p544 lab=_74930_/A }
C {devices/lab_pin.sym} 700 -18050 0 0 {name=p545 lab=_74912_/X }
C {devices/lab_pin.sym} 700 -18010 0 0 {name=p546 lab=_74924_/Y }
C {devices/lab_pin.sym} 860 -18050 0 1 {name=p547 lab=_74925_/Y }
C {sky130_stdcells/a21boi_4.sym} 780 -18050 0 0 {name=X_74925_ }
C {devices/lab_pin.sym} 740 -17910 0 0 {name=p548 lab=_70048_/A }
C {devices/lab_pin.sym} 820 -17910 0 1 {name=p549 lab=_70048_/X }
C {sky130_stdcells/buf_2.sym} 780 -17910 0 0 {name=X_70048_ }
C {devices/lab_pin.sym} 740 -17790 0 0 {name=p550 lab=_52139_/A }
C {devices/lab_pin.sym} 820 -17790 0 1 {name=p551 lab=_52309_/A }
C {sky130_stdcells/buf_2.sym} 780 -17790 0 0 {name=X_47873_ }
C {devices/lab_pin.sym} 740 -17670 0 0 {name=p552 lab=_59689_/A }
C {devices/lab_pin.sym} 820 -17670 0 1 {name=p553 lab=_59859_/Y }
C {sky130_stdcells/inv_2.sym} 780 -17670 0 0 {name=X_59859_ }
C {devices/lab_pin.sym} 720 -17570 0 0 {name=p554 lab=_78689_/Y }
C {devices/lab_pin.sym} 720 -17530 0 0 {name=p555 lab=_78690_/Y }
C {devices/lab_pin.sym} 720 -17490 0 0 {name=p556 lab=_78693_/C }
C {devices/lab_pin.sym} 840 -17530 0 1 {name=p557 lab=_78693_/X }
C {sky130_stdcells/or3_4.sym} 780 -17530 0 0 {name=X_78693_ }
C {devices/lab_pin.sym} 720 -17400 0 0 {name=p558 lab=_49607_/X }
C {devices/lab_pin.sym} 720 -17360 0 0 {name=p559 lab=_52829_/B }
C {devices/lab_pin.sym} 840 -17380 0 1 {name=p560 lab=_49612_/Y }
C {sky130_stdcells/nand2_4.sym} 780 -17380 0 0 {name=X_49612_ }
C {devices/lab_pin.sym} 740 -17250 0 0 {name=p561 lab=_46824_/A }
C {devices/lab_pin.sym} 820 -17250 0 1 {name=p562 lab=_52696_/B }
C {sky130_stdcells/inv_2.sym} 780 -17250 0 0 {name=X_46824_ }
C {devices/lab_pin.sym} 740 -17130 0 0 {name=p563 lab=_77643_/B }
C {devices/lab_pin.sym} 820 -17130 0 1 {name=p564 lab=_77644_/Y }
C {sky130_stdcells/inv_2.sym} 780 -17130 0 0 {name=X_77644_ }
C {devices/lab_pin.sym} 720 -17040 0 0 {name=p565 lab=_61549_/X }
C {devices/lab_pin.sym} 720 -17000 0 0 {name=p566 lab=_62858_/X }
C {devices/lab_pin.sym} 720 -16960 0 0 {name=p567 lab=_62859_/X }
C {devices/lab_pin.sym} 720 -16920 0 0 {name=p568 lab=_62889_/D }
C {devices/lab_pin.sym} 840 -16980 0 1 {name=p569 lab=_62870_/Y }
C {sky130_stdcells/nand4_4.sym} 780 -16980 0 0 {name=X_62870_ }
C {devices/lab_pin.sym} 740 -16830 0 0 {name=p570 lab=_74855_/Y }
C {devices/lab_pin.sym} 820 -16830 0 1 {name=p571 lab=_74856_/Y }
C {sky130_stdcells/inv_2.sym} 780 -16830 0 0 {name=X_74856_ }
C {devices/lab_pin.sym} 720 -16730 0 0 {name=p572 lab=_61865_/A }
C {devices/lab_pin.sym} 720 -16690 0 0 {name=p573 lab=_61865_/B }
C {devices/lab_pin.sym} 720 -16650 0 0 {name=p574 lab=_78075_/B }
C {devices/lab_pin.sym} 840 -16690 0 1 {name=p575 lab=_61821_/Y }
C {sky130_stdcells/nor3_4.sym} 780 -16690 0 0 {name=X_61821_ }
C {devices/lab_pin.sym} 740 -16550 0 0 {name=p576 lab=_49571_/A }
C {devices/lab_pin.sym} 820 -16550 0 1 {name=p577 lab=_49561_/A }
C {sky130_stdcells/buf_2.sym} 780 -16550 0 0 {name=X_49543_ }
C {devices/lab_pin.sym} 720 -16440 0 0 {name=p578 lab=_73711_/A }
C {devices/lab_pin.sym} 720 -16400 0 0 {name=p579 lab=_66055_/B }
C {devices/lab_pin.sym} 840 -16420 0 1 {name=p580 lab=_73807_/X }
C {sky130_stdcells/and2_4.sym} 780 -16420 0 0 {name=X_73807_ }
C {devices/lab_pin.sym} 720 -16320 0 0 {name=p581 lab=_46737_/A }
C {devices/lab_pin.sym} 720 -16280 0 0 {name=p582 lab=_46784_/B }
C {devices/lab_pin.sym} 720 -16240 0 0 {name=p583 lab=_46717_/C }
C {devices/lab_pin.sym} 720 -16200 0 0 {name=p584 lab=_52654_/D }
C {devices/lab_pin.sym} 840 -16260 0 1 {name=p585 lab=_46755_/X }
C {sky130_stdcells/and4_4.sym} 780 -16260 0 0 {name=X_46755_ }
C {devices/lab_pin.sym} 720 -16130 0 0 {name=p586 lab=_77575_/A }
C {devices/lab_pin.sym} 720 -16090 0 0 {name=p587 lab=_77575_/B }
C {devices/lab_pin.sym} 720 -16050 0 0 {name=p588 lab=_77571_/Y }
C {devices/lab_pin.sym} 840 -16090 0 1 {name=p589 lab=_77576_/B }
C {sky130_stdcells/nand3_4.sym} 780 -16090 0 0 {name=X_77575_ }
C {devices/lab_pin.sym} 720 -15960 0 0 {name=p590 lab=_43957_/A }
C {devices/lab_pin.sym} 720 -15920 0 0 {name=p591 lab=_87186_/Q }
C {devices/lab_pin.sym} 840 -15940 0 1 {name=p592 lab=_43967_/X }
C {sky130_stdcells/and2_4.sym} 780 -15940 0 0 {name=X_43967_ }
C {devices/lab_pin.sym} 700 -15830 0 0 {name=p593 lab=_70317_/Y }
C {devices/lab_pin.sym} 700 -15790 0 0 {name=p594 lab=_71012_/B }
C {devices/lab_pin.sym} 700 -15750 0 0 {name=p595 lab=_74786_/Y }
C {devices/lab_pin.sym} 860 -15790 0 1 {name=p596 lab=_74787_/Y }
C {sky130_stdcells/o21ai_4.sym} 780 -15790 0 0 {name=X_74787_ }
C {devices/lab_pin.sym} 700 -15670 0 0 {name=p597 lab=_71997_/Y }
C {devices/lab_pin.sym} 700 -15630 0 0 {name=p598 lab=_71969_/X }
C {devices/lab_pin.sym} 700 -15590 0 0 {name=p599 lab=_71998_/Y }
C {devices/lab_pin.sym} 860 -15630 0 1 {name=p600 lab=_83305_/D }
C {sky130_stdcells/a21boi_4.sym} 780 -15630 0 0 {name=X_71999_ }
C {devices/lab_pin.sym} 700 -15520 0 0 {name=p601 lab=_79286_/X }
C {devices/lab_pin.sym} 700 -15480 0 0 {name=p602 lab=_79304_/B }
C {devices/lab_pin.sym} 700 -15440 0 0 {name=p603 lab=_79303_/A }
C {devices/lab_pin.sym} 700 -15400 0 0 {name=p604 lab=_79302_/Y }
C {devices/lab_pin.sym} 860 -15460 0 1 {name=p605 lab=_79314_/X }
C {sky130_stdcells/o22a_4.sym} 780 -15460 0 0 {name=X_79314_ }
C {devices/lab_pin.sym} 700 -15330 0 0 {name=p606 lab=_57430_/A }
C {devices/lab_pin.sym} 700 -15290 0 0 {name=p607 lab=_45705_/X }
C {devices/lab_pin.sym} 700 -15250 0 0 {name=p608 lab=_45691_/X }
C {devices/lab_pin.sym} 860 -15290 0 1 {name=p609 lab=_45706_/X }
C {sky130_stdcells/o21a_4.sym} 780 -15290 0 0 {name=X_45706_ }
C {devices/lab_pin.sym} 700 -15170 0 0 {name=p610 lab=_64533_/Y }
C {devices/lab_pin.sym} 700 -15130 0 0 {name=p611 lab=_64539_/X }
C {devices/lab_pin.sym} 700 -15090 0 0 {name=p612 lab=_60074_/X }
C {devices/lab_pin.sym} 860 -15130 0 1 {name=p613 lab=_64540_/Y }
C {sky130_stdcells/o21ai_4.sym} 780 -15130 0 0 {name=X_64540_ }
C {devices/lab_pin.sym} 720 -15000 0 0 {name=p614 lab=_76524_/X }
C {devices/lab_pin.sym} 720 -14960 0 0 {name=p615 lab=_76525_/Y }
C {devices/lab_pin.sym} 840 -14980 0 1 {name=p616 lab=_76526_/X }
C {sky130_stdcells/and2_4.sym} 780 -14980 0 0 {name=X_76526_ }
C {devices/lab_pin.sym} 700 -14890 0 0 {name=p617 lab=_42916_/X }
C {devices/lab_pin.sym} 700 -14850 0 0 {name=p618 lab=_42917_/X }
C {devices/lab_pin.sym} 700 -14810 0 0 {name=p619 lab=_41710_/X }
C {devices/lab_pin.sym} 700 -14770 0 0 {name=p620 lab=_67691_/B }
C {devices/lab_pin.sym} 700 -14730 0 0 {name=p621 lab=_42905_/X }
C {devices/lab_pin.sym} 860 -14810 0 1 {name=p622 lab=_42919_/A }
C {sky130_stdcells/o32ai_4.sym} 780 -14810 0 0 {name=X_42918_ }
C {devices/lab_pin.sym} 720 -14680 0 0 {name=p623 lab=_49467_/A }
C {devices/lab_pin.sym} 720 -14640 0 0 {name=p624 lab=_49456_/B }
C {devices/lab_pin.sym} 720 -14600 0 0 {name=p625 lab=_49467_/C }
C {devices/lab_pin.sym} 720 -14560 0 0 {name=p626 lab=_46810_/X }
C {devices/lab_pin.sym} 840 -14620 0 1 {name=p627 lab=_49474_/X }
C {sky130_stdcells/and4_4.sym} 780 -14620 0 0 {name=X_49474_ }
C {devices/lab_pin.sym} 720 -14490 0 0 {name=p628 lab=_61752_/A }
C {devices/lab_pin.sym} 720 -14450 0 0 {name=p629 lab=_61723_/X }
C {devices/lab_pin.sym} 720 -14410 0 0 {name=p630 lab=_78079_/B }
C {devices/lab_pin.sym} 840 -14450 0 1 {name=p631 lab=_61752_/Y }
C {sky130_stdcells/nor3_4.sym} 780 -14450 0 0 {name=X_61752_ }
C {devices/lab_pin.sym} 740 -14310 0 0 {name=p632 lab=_73262_/A }
C {devices/lab_pin.sym} 820 -14310 0 1 {name=p633 lab=_73738_/X }
C {sky130_stdcells/buf_2.sym} 780 -14310 0 0 {name=X_73738_ }
C {devices/lab_pin.sym} 720 -14200 0 0 {name=p634 lab=_46712_/A }
C {devices/lab_pin.sym} 720 -14160 0 0 {name=p635 lab=_46685_/X }
C {devices/lab_pin.sym} 840 -14180 0 1 {name=p636 lab=_46686_/Y }
C {sky130_stdcells/nand2_4.sym} 780 -14180 0 0 {name=X_46686_ }
C {devices/lab_pin.sym} 700 -14090 0 0 {name=p637 lab=_43895_/X }
C {devices/lab_pin.sym} 700 -14050 0 0 {name=p638 lab=_43876_/X }
C {devices/lab_pin.sym} 700 -14010 0 0 {name=p639 lab=_41332_/X }
C {devices/lab_pin.sym} 700 -13970 0 0 {name=p640 lab=_87210_/Q }
C {devices/lab_pin.sym} 700 -13930 0 0 {name=p641 lab=_43897_/X }
C {devices/lab_pin.sym} 860 -14010 0 1 {name=p642 lab=_43898_/Y }
C {sky130_stdcells/o32ai_4.sym} 780 -14010 0 0 {name=X_43898_ }
C {devices/lab_pin.sym} 700 -13870 0 0 {name=p643 lab=_65525_/B }
C {devices/lab_pin.sym} 700 -13830 0 0 {name=p644 lab=_48419_/X }
C {devices/lab_pin.sym} 700 -13790 0 0 {name=p645 lab=_48424_/Y }
C {devices/lab_pin.sym} 860 -13830 0 1 {name=p646 lab=_48425_/Y }
C {sky130_stdcells/o21ai_4.sym} 780 -13830 0 0 {name=X_48425_ }
C {devices/lab_pin.sym} 720 -13700 0 0 {name=p647 lab=_60724_/B }
C {devices/lab_pin.sym} 720 -13660 0 0 {name=p648 lab=_60702_/Y }
C {devices/lab_pin.sym} 840 -13680 0 1 {name=p649 lab=_60703_/Y }
C {sky130_stdcells/nor2_4.sym} 780 -13680 0 0 {name=X_60703_ }
C {devices/lab_pin.sym} 720 -13560 0 0 {name=p650 lab=_79245_/A }
C {devices/lab_pin.sym} 720 -13520 0 0 {name=p651 lab=_79245_/B }
C {devices/lab_pin.sym} 840 -13540 0 1 {name=p652 lab=_79246_/B }
C {sky130_stdcells/xor2_4.sym} 780 -13540 0 0 {name=X_79245_ }
C {devices/lab_pin.sym} 740 -13410 0 0 {name=p653 lab=_82994_/Q }
C {devices/lab_pin.sym} 820 -13410 0 1 {name=p654 lab=_45638_/A }
C {sky130_stdcells/inv_2.sym} 780 -13410 0 0 {name=X_45637_ }
C {devices/lab_pin.sym} 700 -13310 0 0 {name=p655 lab=_64464_/Y }
C {devices/lab_pin.sym} 700 -13270 0 0 {name=p656 lab=_64470_/X }
C {devices/lab_pin.sym} 700 -13230 0 0 {name=p657 lab=_64442_/X }
C {devices/lab_pin.sym} 860 -13270 0 1 {name=p658 lab=_64471_/X }
C {sky130_stdcells/o21a_4.sym} 780 -13270 0 0 {name=X_64471_ }
C {devices/lab_pin.sym} 740 -13130 0 0 {name=p659 lab=_76456_/Y }
C {devices/lab_pin.sym} 820 -13130 0 1 {name=p660 lab=_76457_/Y }
C {sky130_stdcells/inv_2.sym} 780 -13130 0 0 {name=X_76457_ }
C {devices/lab_pin.sym} 740 -13010 0 0 {name=p661 lab=_42945_/A }
C {devices/lab_pin.sym} 820 -13010 0 1 {name=p662 lab=_42849_/X }
C {sky130_stdcells/buf_2.sym} 780 -13010 0 0 {name=X_42849_ }
C {devices/lab_pin.sym} 740 -12890 0 0 {name=p663 lab=_59443_/A }
C {devices/lab_pin.sym} 820 -12890 0 1 {name=p664 lab=_61683_/X }
C {sky130_stdcells/buf_2.sym} 780 -12890 0 0 {name=X_61683_ }
C {devices/lab_pin.sym} 720 -12780 0 0 {name=p665 lab=_47880_/Y }
C {devices/lab_pin.sym} 720 -12740 0 0 {name=p666 lab=_73668_/Y }
C {devices/lab_pin.sym} 840 -12760 0 1 {name=p667 lab=_73669_/X }
C {sky130_stdcells/xor2_4.sym} 780 -12760 0 0 {name=X_73669_ }
C {devices/lab_pin.sym} 700 -12660 0 0 {name=p668 lab=_64598_/X }
C {devices/lab_pin.sym} 700 -12620 0 0 {name=p669 lab=_86220_/Q }
C {devices/lab_pin.sym} 700 -12580 0 0 {name=p670 lab=_65761_/X }
C {devices/lab_pin.sym} 700 -12540 0 0 {name=p671 lab=_66209_/X }
C {devices/lab_pin.sym} 860 -12600 0 1 {name=p672 lab=_66210_/X }
C {sky130_stdcells/a211o_4.sym} 780 -12600 0 0 {name=X_66210_ }
C {devices/lab_pin.sym} 740 -12450 0 0 {name=p673 lab=_60731_/A }
C {devices/lab_pin.sym} 820 -12450 0 1 {name=p674 lab=_63484_/A }
C {sky130_stdcells/buf_2.sym} 780 -12450 0 0 {name=X_63422_ }
C {devices/lab_pin.sym} 720 -12340 0 0 {name=p675 lab=_75408_/A }
C {devices/lab_pin.sym} 720 -12300 0 0 {name=p676 lab=_75407_/X }
C {devices/lab_pin.sym} 840 -12320 0 1 {name=p677 lab=_80760_/D }
C {sky130_stdcells/xor2_4.sym} 780 -12320 0 0 {name=X_75408_ }
C {devices/lab_pin.sym} 700 -12210 0 0 {name=p678 lab=_48353_/Y }
C {devices/lab_pin.sym} 700 -12170 0 0 {name=p679 lab=_48302_/X }
C {devices/lab_pin.sym} 700 -12130 0 0 {name=p680 lab=_48355_/X }
C {devices/lab_pin.sym} 860 -12170 0 1 {name=p681 lab=_86530_/D }
C {sky130_stdcells/a21oi_4.sym} 780 -12170 0 0 {name=X_48356_ }
C {devices/lab_pin.sym} 740 -12030 0 0 {name=p682 lab=_60659_/A }
C {devices/lab_pin.sym} 820 -12030 0 1 {name=p683 lab=_60725_/A }
C {sky130_stdcells/buf_2.sym} 780 -12030 0 0 {name=X_60634_ }
C {devices/lab_pin.sym} 720 -11920 0 0 {name=p684 lab=_67241_/A }
C {devices/lab_pin.sym} 720 -11880 0 0 {name=p685 lab=_86780_/Q }
C {devices/lab_pin.sym} 840 -11900 0 1 {name=p686 lab=_67190_/X }
C {sky130_stdcells/and2_4.sym} 780 -11900 0 0 {name=X_67190_ }
C {devices/lab_pin.sym} 720 -11780 0 0 {name=p687 lab=_79176_/A }
C {devices/lab_pin.sym} 720 -11740 0 0 {name=p688 lab=_79175_/Y }
C {devices/lab_pin.sym} 840 -11760 0 1 {name=p689 lab=_79176_/Y }
C {sky130_stdcells/nand2_4.sym} 780 -11760 0 0 {name=X_79176_ }
C {devices/lab_pin.sym} 700 -11660 0 0 {name=p690 lab=_55514_/B }
C {devices/lab_pin.sym} 700 -11620 0 0 {name=p691 lab=_45516_/X }
C {devices/lab_pin.sym} 700 -11580 0 0 {name=p692 lab=_45396_/X }
C {devices/lab_pin.sym} 700 -11540 0 0 {name=p693 lab=_45567_/Y }
C {devices/lab_pin.sym} 860 -11600 0 1 {name=p694 lab=_45568_/X }
C {sky130_stdcells/a211o_4.sym} 780 -11600 0 0 {name=X_45568_ }
C {devices/lab_pin.sym} 720 -11460 0 0 {name=p695 lab=_81362_/Q }
C {devices/lab_pin.sym} 720 -11420 0 0 {name=p696 lab=_81618_/D }
C {devices/lab_pin.sym} 840 -11440 0 1 {name=p697 lab=_76388_/X }
C {sky130_stdcells/xor2_4.sym} 780 -11440 0 0 {name=X_76388_ }
C {devices/lab_pin.sym} 720 -11320 0 0 {name=p698 lab=_47287_/X }
C {devices/lab_pin.sym} 720 -11280 0 0 {name=p699 lab=_52973_/B }
C {devices/lab_pin.sym} 840 -11300 0 1 {name=p700 lab=_47307_/Y }
C {sky130_stdcells/nand2_4.sym} 780 -11300 0 0 {name=X_47307_ }
C {devices/lab_pin.sym} 720 -11180 0 0 {name=p701 lab=_65932_/A }
C {devices/lab_pin.sym} 720 -11140 0 0 {name=p702 lab=_66141_/B }
C {devices/lab_pin.sym} 840 -11160 0 1 {name=p703 lab=_66141_/X }
C {sky130_stdcells/and2_4.sym} 780 -11160 0 0 {name=X_66141_ }
C {devices/lab_pin.sym} 720 -11040 0 0 {name=p704 lab=_78130_/D }
C {devices/lab_pin.sym} 720 -11000 0 0 {name=p705 lab=_78126_/Y }
C {devices/lab_pin.sym} 840 -11020 0 1 {name=p706 lab=_78128_/B }
C {sky130_stdcells/xor2_4.sym} 780 -11020 0 0 {name=X_78127_ }
C {devices/lab_pin.sym} 700 -10930 0 0 {name=p707 lab=_44512_/X }
C {devices/lab_pin.sym} 700 -10890 0 0 {name=p708 lab=_44513_/X }
C {devices/lab_pin.sym} 700 -10850 0 0 {name=p709 lab=_40770_/Y }
C {devices/lab_pin.sym} 700 -10810 0 0 {name=p710 lab=_44518_/Y }
C {devices/lab_pin.sym} 700 -10770 0 0 {name=p711 lab=_44516_/X }
C {devices/lab_pin.sym} 860 -10850 0 1 {name=p712 lab=_87070_/D }
C {sky130_stdcells/o32ai_4.sym} 780 -10850 0 0 {name=X_44519_ }
C {devices/lab_pin.sym} 700 -10710 0 0 {name=p713 lab=_63351_/Y }
C {devices/lab_pin.sym} 700 -10670 0 0 {name=p714 lab=_63284_/X }
C {devices/lab_pin.sym} 700 -10630 0 0 {name=p715 lab=_63352_/Y }
C {devices/lab_pin.sym} 860 -10670 0 1 {name=p716 lab=_63353_/Y }
C {sky130_stdcells/a21oi_4.sym} 780 -10670 0 0 {name=X_63353_ }
C {devices/lab_pin.sym} 720 -10550 0 0 {name=p717 lab=_75334_/X }
C {devices/lab_pin.sym} 720 -10510 0 0 {name=p718 lab=_75337_/Y }
C {devices/lab_pin.sym} 720 -10470 0 0 {name=p719 lab=_75339_/C }
C {devices/lab_pin.sym} 840 -10510 0 1 {name=p720 lab=_75339_/Y }
C {sky130_stdcells/nand3_4.sym} 780 -10510 0 0 {name=X_75339_ }
C {devices/lab_pin.sym} 720 -10390 0 0 {name=p721 lab=_48287_/A }
C {devices/lab_pin.sym} 720 -10350 0 0 {name=p722 lab=_48286_/X }
C {devices/lab_pin.sym} 720 -10310 0 0 {name=p723 lab=_48287_/C }
C {devices/lab_pin.sym} 840 -10350 0 1 {name=p724 lab=_48287_/X }
C {sky130_stdcells/and3_4.sym} 780 -10350 0 0 {name=X_48287_ }
C {devices/lab_pin.sym} 740 -10210 0 0 {name=p725 lab=_60564_/X }
C {devices/lab_pin.sym} 820 -10210 0 1 {name=p726 lab=_84599_/D }
C {sky130_stdcells/inv_2.sym} 780 -10210 0 0 {name=X_60565_ }
C {devices/lab_pin.sym} 700 -10110 0 0 {name=p727 lab=_45492_/X }
C {devices/lab_pin.sym} 700 -10070 0 0 {name=p728 lab=_45496_/Y }
C {devices/lab_pin.sym} 700 -10030 0 0 {name=p729 lab=_45498_/Y }
C {devices/lab_pin.sym} 860 -10070 0 1 {name=p730 lab=_45499_/Y }
C {sky130_stdcells/a21oi_4.sym} 780 -10070 0 0 {name=X_45499_ }
C {devices/lab_pin.sym} 720 -9960 0 0 {name=p731 lab=_62304_/A }
C {devices/lab_pin.sym} 720 -9920 0 0 {name=p732 lab=_58241_/X }
C {devices/lab_pin.sym} 720 -9880 0 0 {name=p733 lab=_62244_/C }
C {devices/lab_pin.sym} 720 -9840 0 0 {name=p734 lab=_62286_/X }
C {devices/lab_pin.sym} 840 -9900 0 1 {name=p735 lab=_62304_/X }
C {sky130_stdcells/and4_4.sym} 780 -9900 0 0 {name=X_62304_ }
C {devices/lab_pin.sym} 700 -9770 0 0 {name=p736 lab=_47233_/Y }
C {devices/lab_pin.sym} 700 -9730 0 0 {name=p737 lab=_47224_/X }
C {devices/lab_pin.sym} 700 -9690 0 0 {name=p738 lab=_47237_/X }
C {devices/lab_pin.sym} 860 -9730 0 1 {name=p739 lab=_47238_/Y }
C {sky130_stdcells/a21oi_4.sym} 780 -9730 0 0 {name=X_47238_ }
C {devices/lab_pin.sym} 700 -9620 0 0 {name=p740 lab=_65300_/X }
C {devices/lab_pin.sym} 700 -9580 0 0 {name=p741 lab=_85622_/Q }
C {devices/lab_pin.sym} 700 -9540 0 0 {name=p742 lab=_65301_/X }
C {devices/lab_pin.sym} 700 -9500 0 0 {name=p743 lab=_66071_/X }
C {devices/lab_pin.sym} 860 -9560 0 1 {name=p744 lab=_66072_/X }
C {sky130_stdcells/a211o_4.sym} 780 -9560 0 0 {name=X_66072_ }
C {devices/lab_pin.sym} 720 -9420 0 0 {name=p745 lab=_84563_/Q }
C {devices/lab_pin.sym} 720 -9380 0 0 {name=p746 lab=_78058_/B }
C {devices/lab_pin.sym} 840 -9400 0 1 {name=p747 lab=_78058_/X }
C {sky130_stdcells/xor2_4.sym} 780 -9400 0 0 {name=X_78058_ }
C {devices/lab_pin.sym} 740 -9270 0 0 {name=p748 lab=_63516_/A }
C {devices/lab_pin.sym} 820 -9270 0 1 {name=p749 lab=_63284_/X }
C {sky130_stdcells/buf_2.sym} 780 -9270 0 0 {name=X_63284_ }
C {devices/lab_pin.sym} 740 -9150 0 0 {name=p750 lab=_60105_/X }
C {devices/lab_pin.sym} 820 -9150 0 1 {name=p751 lab=_60526_/A }
C {sky130_stdcells/buf_2.sym} 780 -9150 0 0 {name=X_60496_ }
C {devices/lab_pin.sym} 720 -9040 0 0 {name=p752 lab=_69900_/A }
C {devices/lab_pin.sym} 720 -9000 0 0 {name=p753 lab=_88314_/Q }
C {devices/lab_pin.sym} 840 -9020 0 1 {name=p754 lab=_69900_/X }
C {sky130_stdcells/and2_4.sym} 780 -9020 0 0 {name=X_69900_ }
C {devices/lab_pin.sym} 720 -8900 0 0 {name=p755 lab=_64946_/A }
C {devices/lab_pin.sym} 720 -8860 0 0 {name=p756 lab=_85809_/Q }
C {devices/lab_pin.sym} 840 -8880 0 1 {name=p757 lab=_65023_/X }
C {sky130_stdcells/and2_4.sym} 780 -8880 0 0 {name=X_65023_ }
C {devices/lab_pin.sym} 720 -8760 0 0 {name=p758 lab=_77009_/A }
C {devices/lab_pin.sym} 720 -8720 0 0 {name=p759 lab=_82276_/D }
C {devices/lab_pin.sym} 840 -8740 0 1 {name=p760 lab=_77010_/A }
C {sky130_stdcells/nand2_4.sym} 780 -8740 0 0 {name=X_77009_ }
C {devices/lab_pin.sym} 740 -8610 0 0 {name=p761 lab=_62193_/A }
C {devices/lab_pin.sym} 820 -8610 0 1 {name=p762 lab=_62628_/C }
C {sky130_stdcells/buf_2.sym} 780 -8610 0 0 {name=X_62235_ }
C {devices/lab_pin.sym} 740 -8490 0 0 {name=p763 lab=_82375_/Q }
C {devices/lab_pin.sym} 820 -8490 0 1 {name=p764 lab=_47169_/Y }
C {sky130_stdcells/inv_2.sym} 780 -8490 0 0 {name=X_47169_ }
C {devices/lab_pin.sym} 720 -8380 0 0 {name=p765 lab=_80016_/Y }
C {devices/lab_pin.sym} 720 -8340 0 0 {name=p766 lab=_80019_/Y }
C {devices/lab_pin.sym} 840 -8360 0 1 {name=p767 lab=_80023_/A }
C {sky130_stdcells/xor2_4.sym} 780 -8360 0 0 {name=X_80020_ }
C {devices/lab_pin.sym} 740 -8230 0 0 {name=p768 lab=_69988_/A }
C {devices/lab_pin.sym} 820 -8230 0 1 {name=p769 lab=_69831_/X }
C {sky130_stdcells/buf_2.sym} 780 -8230 0 0 {name=X_69831_ }
C {devices/lab_pin.sym} 700 -8130 0 0 {name=p770 lab=_50178_/Y }
C {devices/lab_pin.sym} 700 -8090 0 0 {name=p771 lab=_50166_/X }
C {devices/lab_pin.sym} 700 -8050 0 0 {name=p772 lab=_50179_/X }
C {devices/lab_pin.sym} 860 -8090 0 1 {name=p773 lab=_50180_/Y }
C {sky130_stdcells/a21oi_4.sym} 780 -8090 0 0 {name=X_50180_ }
C {devices/lab_pin.sym} 740 -7950 0 0 {name=p774 lab=_62033_/A }
C {devices/lab_pin.sym} 820 -7950 0 1 {name=p775 lab=_62166_/X }
C {sky130_stdcells/buf_2.sym} 780 -7950 0 0 {name=X_62166_ }
C {devices/lab_pin.sym} 740 -7830 0 0 {name=p776 lab=_64546_/A }
C {devices/lab_pin.sym} 820 -7830 0 1 {name=p777 lab=_61117_/X }
C {sky130_stdcells/buf_2.sym} 780 -7830 0 0 {name=X_61117_ }
C {devices/lab_pin.sym} 740 -7710 0 0 {name=p778 lab=_70009_/A }
C {devices/lab_pin.sym} 820 -7710 0 1 {name=p779 lab=_69988_/A }
C {sky130_stdcells/buf_2.sym} 780 -7710 0 0 {name=X_69762_ }
C {devices/lab_pin.sym} 700 -7620 0 0 {name=p780 lab=_87874_/Q }
C {devices/lab_pin.sym} 700 -7580 0 0 {name=p781 lab=_66875_/X }
C {devices/lab_pin.sym} 700 -7540 0 0 {name=p782 lab=_66926_/X }
C {devices/lab_pin.sym} 700 -7500 0 0 {name=p783 lab=_66973_/X }
C {devices/lab_pin.sym} 860 -7560 0 1 {name=p784 lab=_66974_/X }
C {sky130_stdcells/a211o_4.sym} 780 -7560 0 0 {name=X_66974_ }
C {devices/lab_pin.sym} 740 -7410 0 0 {name=p785 lab=_58279_/A }
C {devices/lab_pin.sym} 820 -7410 0 1 {name=p786 lab=_62097_/X }
C {sky130_stdcells/buf_2.sym} 780 -7410 0 0 {name=X_62097_ }
C {devices/lab_pin.sym} 740 -7290 0 0 {name=p787 lab=_68586_/A }
C {devices/lab_pin.sym} 820 -7290 0 1 {name=p788 lab=_68713_/X }
C {sky130_stdcells/buf_2.sym} 780 -7290 0 0 {name=X_68713_ }
C {devices/lab_pin.sym} 720 -7180 0 0 {name=p789 lab=_65896_/A }
C {devices/lab_pin.sym} 720 -7140 0 0 {name=p790 lab=_73588_/B }
C {devices/lab_pin.sym} 840 -7160 0 1 {name=p791 lab=_65925_/X }
C {sky130_stdcells/and2_4.sym} 780 -7160 0 0 {name=X_65925_ }
C {devices/lab_pin.sym} 740 -7030 0 0 {name=p792 lab=clkbuf_8_5_0_CLK/A }
C {devices/lab_pin.sym} 820 -7030 0 1 {name=p793 lab=clkbuf_8_5_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 780 -7030 0 0 {name=Xclkbuf_8_5_0_CLK }
C {devices/lab_pin.sym} 700 -6950 0 0 {name=p794 lab=_60953_/X }
C {devices/lab_pin.sym} 700 -6910 0 0 {name=p795 lab=_61044_/X }
C {devices/lab_pin.sym} 700 -6870 0 0 {name=p796 lab=_61016_/Y }
C {devices/lab_pin.sym} 700 -6830 0 0 {name=p797 lab=_60952_/X }
C {devices/lab_pin.sym} 700 -6790 0 0 {name=p798 lab=_61047_/X }
C {devices/lab_pin.sym} 860 -6870 0 1 {name=p799 lab=_84529_/D }
C {sky130_stdcells/o41a_4.sym} 780 -6870 0 0 {name=X_61048_ }
C {devices/lab_pin.sym} 690 -6710 0 0 {name=p800 lab=_82116_/CLK }
C {devices/lab_pin.sym} 690 -6690 0 0 {name=p801 lab=_81971_/D }
C {devices/lab_pin.sym} 870 -6710 0 1 {name=p802 lab=_77737_/B }
C {sky130_stdcells/dfxtp_4.sym} 780 -6700 0 0 {name=X_81971_ }
C {devices/lab_pin.sym} 700 -6590 0 0 {name=p803 lab=_69689_/X }
C {devices/lab_pin.sym} 700 -6550 0 0 {name=p804 lab=_69692_/X }
C {devices/lab_pin.sym} 700 -6510 0 0 {name=p805 lab=_69655_/X }
C {devices/lab_pin.sym} 860 -6550 0 1 {name=p806 lab=_69693_/Y }
C {sky130_stdcells/a21oi_4.sym} 780 -6550 0 0 {name=X_69693_ }
C {devices/lab_pin.sym} 690 -6410 0 0 {name=p807 lab=_83711_/CLK }
C {devices/lab_pin.sym} 690 -6390 0 0 {name=p808 lab=_70748_/Y }
C {devices/lab_pin.sym} 870 -6410 0 1 {name=p809 lab=_83710_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -6400 0 0 {name=X_83710_ }
C {devices/lab_pin.sym} 690 -6270 0 0 {name=p810 lab=_80928_/CLK }
C {devices/lab_pin.sym} 690 -6250 0 0 {name=p811 lab=_84098_/Q }
C {devices/lab_pin.sym} 870 -6270 0 1 {name=p812 lab=_75787_/A }
C {sky130_stdcells/dfxtp_4.sym} 780 -6260 0 0 {name=X_80922_ }
C {devices/lab_pin.sym} 740 -6130 0 0 {name=p813 lab=_68644_/A }
C {devices/lab_pin.sym} 820 -6130 0 1 {name=p814 lab=_69092_/A }
C {sky130_stdcells/buf_2.sym} 780 -6130 0 0 {name=X_68644_ }
C {devices/lab_pin.sym} 740 -6010 0 0 {name=p815 lab=_53661_/A }
C {devices/lab_pin.sym} 820 -6010 0 1 {name=p816 lab=_54295_/A }
C {sky130_stdcells/buf_2.sym} 780 -6010 0 0 {name=X_53870_ }
C {devices/lab_pin.sym} 700 -5910 0 0 {name=p817 lab=_65854_/Y }
C {devices/lab_pin.sym} 700 -5870 0 0 {name=p818 lab=_65830_/X }
C {devices/lab_pin.sym} 700 -5830 0 0 {name=p819 lab=_65855_/X }
C {devices/lab_pin.sym} 860 -5870 0 1 {name=p820 lab=_84173_/D }
C {sky130_stdcells/a21o_4.sym} 780 -5870 0 0 {name=X_65856_ }
C {devices/lab_pin.sym} 690 -5730 0 0 {name=p821 lab=_84358_/CLK }
C {devices/lab_pin.sym} 690 -5710 0 0 {name=p822 lab=_59844_/Y }
C {devices/lab_pin.sym} 870 -5730 0 1 {name=p823 lab=_80379_/A }
C {sky130_stdcells/dfxtp_4.sym} 780 -5720 0 0 {name=X_84690_ }
C {devices/lab_pin.sym} 740 -5590 0 0 {name=p824 lab=_52821_/A }
C {devices/lab_pin.sym} 820 -5590 0 1 {name=p825 lab=_52821_/X }
C {sky130_stdcells/buf_2.sym} 780 -5590 0 0 {name=X_52821_ }
C {devices/lab_pin.sym} 740 -5470 0 0 {name=p826 lab=_64807_/A }
C {devices/lab_pin.sym} 820 -5470 0 1 {name=p827 lab=_64807_/X }
C {sky130_stdcells/buf_2.sym} 780 -5470 0 0 {name=X_64807_ }
C {devices/lab_pin.sym} 690 -5350 0 0 {name=p828 lab=_86422_/CLK }
C {devices/lab_pin.sym} 690 -5330 0 0 {name=p829 lab=_70988_/Y }
C {devices/lab_pin.sym} 870 -5350 0 1 {name=p830 lab=_83641_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -5340 0 0 {name=X_83641_ }
C {devices/lab_pin.sym} 690 -5210 0 0 {name=p831 lab=_80854_/CLK }
C {devices/lab_pin.sym} 690 -5190 0 0 {name=p832 lab=_80885_/Q }
C {devices/lab_pin.sym} 870 -5210 0 1 {name=p833 lab=_74980_/B }
C {sky130_stdcells/dfxtp_4.sym} 780 -5200 0 0 {name=X_80853_ }
C {devices/lab_pin.sym} 720 -5080 0 0 {name=p834 lab=_68553_/A }
C {devices/lab_pin.sym} 720 -5040 0 0 {name=p835 lab=_87755_/Q }
C {devices/lab_pin.sym} 840 -5060 0 1 {name=p836 lab=_68575_/X }
C {sky130_stdcells/and2_4.sym} 780 -5060 0 0 {name=X_68575_ }
C {devices/lab_pin.sym} 720 -4950 0 0 {name=p837 lab=_65855_/A }
C {devices/lab_pin.sym} 720 -4910 0 0 {name=p838 lab=_65775_/B }
C {devices/lab_pin.sym} 720 -4870 0 0 {name=p839 lab=_84178_/Q }
C {devices/lab_pin.sym} 840 -4910 0 1 {name=p840 lab=_65787_/X }
C {sky130_stdcells/and3_4.sym} 780 -4910 0 0 {name=X_65787_ }
C {devices/lab_pin.sym} 740 -4770 0 0 {name=p841 lab=_63060_/A }
C {devices/lab_pin.sym} 820 -4770 0 1 {name=p842 lab=_62999_/X }
C {sky130_stdcells/buf_2.sym} 780 -4770 0 0 {name=X_62999_ }
C {devices/lab_pin.sym} 700 -4680 0 0 {name=p843 lab=_85048_/Q }
C {devices/lab_pin.sym} 700 -4640 0 0 {name=p844 lab=_55510_/X }
C {devices/lab_pin.sym} 700 -4600 0 0 {name=p845 lab=_55512_/X }
C {devices/lab_pin.sym} 700 -4560 0 0 {name=p846 lab=_55539_/Y }
C {devices/lab_pin.sym} 860 -4620 0 1 {name=p847 lab=_55540_/X }
C {sky130_stdcells/a211o_4.sym} 780 -4620 0 0 {name=X_55540_ }
C {devices/lab_pin.sym} 700 -4500 0 0 {name=p848 lab=_87979_/Q }
C {devices/lab_pin.sym} 700 -4460 0 0 {name=p849 lab=_67473_/X }
C {devices/lab_pin.sym} 700 -4420 0 0 {name=p850 lab=_67524_/X }
C {devices/lab_pin.sym} 700 -4380 0 0 {name=p851 lab=_67525_/X }
C {devices/lab_pin.sym} 860 -4440 0 1 {name=p852 lab=_67526_/X }
C {sky130_stdcells/a211o_4.sym} 780 -4440 0 0 {name=X_67526_ }
C {devices/lab_pin.sym} 690 -4290 0 0 {name=p853 lab=_86361_/CLK }
C {devices/lab_pin.sym} 690 -4270 0 0 {name=p854 lab=_86360_/D }
C {devices/lab_pin.sym} 870 -4290 0 1 {name=p855 lab=_86360_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -4280 0 0 {name=X_86360_ }
C {devices/lab_pin.sym} 720 -4160 0 0 {name=p856 lab=_52744_/A }
C {devices/lab_pin.sym} 720 -4120 0 0 {name=p857 lab=_52752_/B }
C {devices/lab_pin.sym} 840 -4140 0 1 {name=p858 lab=_52752_/Y }
C {sky130_stdcells/nand2_4.sym} 780 -4140 0 0 {name=X_52752_ }
C {devices/lab_pin.sym} 740 -4010 0 0 {name=p859 lab=_64738_/A }
C {devices/lab_pin.sym} 820 -4010 0 1 {name=p860 lab=_64739_/A }
C {sky130_stdcells/buf_2.sym} 780 -4010 0 0 {name=X_64738_ }
C {devices/lab_pin.sym} 690 -3890 0 0 {name=p861 lab=_83572_/CLK }
C {devices/lab_pin.sym} 690 -3870 0 0 {name=p862 lab=_71208_/Y }
C {devices/lab_pin.sym} 870 -3890 0 1 {name=p863 lab=_83572_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -3880 0 0 {name=X_83572_ }
C {devices/lab_pin.sym} 690 -3750 0 0 {name=p864 lab=_80784_/CLK }
C {devices/lab_pin.sym} 690 -3730 0 0 {name=p865 lab=_75719_/Y }
C {devices/lab_pin.sym} 870 -3750 0 1 {name=p866 lab=_80784_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -3740 0 0 {name=X_80784_ }
C {devices/lab_pin.sym} 690 -3610 0 0 {name=p867 lab=_85311_/CLK }
C {devices/lab_pin.sym} 690 -3590 0 0 {name=p868 lab=_56018_/Y }
C {devices/lab_pin.sym} 870 -3610 0 1 {name=p869 lab=_85311_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -3600 0 0 {name=X_85311_ }
C {devices/lab_pin.sym} 720 -3480 0 0 {name=p870 lab=_51717_/A }
C {devices/lab_pin.sym} 720 -3440 0 0 {name=p871 lab=_53227_/B }
C {devices/lab_pin.sym} 840 -3460 0 1 {name=p872 lab=_51703_/Y }
C {sky130_stdcells/nand2_4.sym} 780 -3460 0 0 {name=X_51703_ }
C {devices/lab_pin.sym} 690 -3330 0 0 {name=p873 lab=_82491_/CLK }
C {devices/lab_pin.sym} 690 -3310 0 0 {name=p874 lab=_79119_/Y }
C {devices/lab_pin.sym} 870 -3330 0 1 {name=p875 lab=_82523_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -3320 0 0 {name=X_82523_ }
C {devices/lab_pin.sym} 700 -3220 0 0 {name=p876 lab=_85107_/Q }
C {devices/lab_pin.sym} 700 -3180 0 0 {name=p877 lab=_55468_/X }
C {devices/lab_pin.sym} 700 -3140 0 0 {name=p878 lab=_55469_/X }
C {devices/lab_pin.sym} 700 -3100 0 0 {name=p879 lab=_55470_/Y }
C {devices/lab_pin.sym} 860 -3160 0 1 {name=p880 lab=_55471_/X }
C {sky130_stdcells/a211o_4.sym} 780 -3160 0 0 {name=X_55471_ }
C {devices/lab_pin.sym} 700 -3040 0 0 {name=p881 lab=_86970_/Q }
C {devices/lab_pin.sym} 700 -3000 0 0 {name=p882 lab=_67432_/X }
C {devices/lab_pin.sym} 700 -2960 0 0 {name=p883 lab=_67433_/X }
C {devices/lab_pin.sym} 700 -2920 0 0 {name=p884 lab=_67456_/X }
C {devices/lab_pin.sym} 860 -2980 0 1 {name=p885 lab=_67457_/X }
C {sky130_stdcells/a211o_4.sym} 780 -2980 0 0 {name=X_67457_ }
C {devices/lab_pin.sym} 690 -2830 0 0 {name=p886 lab=_86611_/CLK }
C {devices/lab_pin.sym} 690 -2810 0 0 {name=p887 lab=_86291_/D }
C {devices/lab_pin.sym} 870 -2830 0 1 {name=p888 lab=_72294_/B }
C {sky130_stdcells/dfxtp_4.sym} 780 -2820 0 0 {name=X_86291_ }
C {devices/lab_pin.sym} 740 -2690 0 0 {name=p889 lab=_52515_/A }
C {devices/lab_pin.sym} 820 -2690 0 1 {name=p890 lab=_52684_/A }
C {sky130_stdcells/buf_2.sym} 780 -2690 0 0 {name=X_52683_ }
C {devices/lab_pin.sym} 700 -2600 0 0 {name=p891 lab=_64666_/X }
C {devices/lab_pin.sym} 700 -2560 0 0 {name=p892 lab=_86142_/Q }
C {devices/lab_pin.sym} 700 -2520 0 0 {name=p893 lab=_64566_/X }
C {devices/lab_pin.sym} 700 -2480 0 0 {name=p894 lab=_64668_/X }
C {devices/lab_pin.sym} 860 -2540 0 1 {name=p895 lab=_64669_/X }
C {sky130_stdcells/a211o_4.sym} 780 -2540 0 0 {name=X_64669_ }
C {devices/lab_pin.sym} 720 -2410 0 0 {name=p896 lab=_57049_/A }
C {devices/lab_pin.sym} 720 -2370 0 0 {name=p897 lab=_57210_/B }
C {devices/lab_pin.sym} 720 -2330 0 0 {name=p898 lab=_57086_/X }
C {devices/lab_pin.sym} 840 -2370 0 1 {name=p899 lab=_57210_/Y }
C {sky130_stdcells/nor3_4.sym} 780 -2370 0 0 {name=X_57210_ }
C {devices/lab_pin.sym} 690 -2230 0 0 {name=p900 lab=_88036_/CLK }
C {devices/lab_pin.sym} 690 -2210 0 0 {name=p901 lab=_42112_/Y }
C {devices/lab_pin.sym} 870 -2230 0 1 {name=p902 lab=_88030_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -2220 0 0 {name=X_88030_ }
C {devices/lab_pin.sym} 740 -2090 0 0 {name=p903 lab=_54475_/A }
C {devices/lab_pin.sym} 820 -2090 0 1 {name=p904 lab=_54422_/X }
C {sky130_stdcells/buf_2.sym} 780 -2090 0 0 {name=X_54422_ }
C {devices/lab_pin.sym} 700 -1990 0 0 {name=p905 lab=_66405_/Y }
C {devices/lab_pin.sym} 700 -1950 0 0 {name=p906 lab=_66377_/X }
C {devices/lab_pin.sym} 700 -1910 0 0 {name=p907 lab=_66407_/Y }
C {devices/lab_pin.sym} 860 -1950 0 1 {name=p908 lab=_84129_/D }
C {sky130_stdcells/a21o_4.sym} 780 -1950 0 0 {name=X_66408_ }
C {devices/lab_pin.sym} 690 -1810 0 0 {name=p909 lab=_85241_/CLK }
C {devices/lab_pin.sym} 690 -1790 0 0 {name=p910 lab=_85242_/D }
C {devices/lab_pin.sym} 870 -1810 0 1 {name=p911 lab=_56306_/C }
C {sky130_stdcells/dfxtp_4.sym} 780 -1800 0 0 {name=X_85242_ }
C {devices/lab_pin.sym} 740 -1670 0 0 {name=p912 lab=_51608_/A }
C {devices/lab_pin.sym} 820 -1670 0 1 {name=p913 lab=_51651_/C }
C {sky130_stdcells/buf_2.sym} 780 -1670 0 0 {name=X_51634_ }
C {devices/lab_pin.sym} 740 -1550 0 0 {name=p914 lab=_44282_/X }
C {devices/lab_pin.sym} 820 -1550 0 1 {name=p915 lab=_58341_/A }
C {sky130_stdcells/buf_2.sym} 780 -1550 0 0 {name=X_58190_ }
C {devices/lab_pin.sym} 690 -1430 0 0 {name=p916 lab=_82248_/CLK }
C {devices/lab_pin.sym} 690 -1410 0 0 {name=p917 lab=_79146_/X }
C {devices/lab_pin.sym} 870 -1430 0 1 {name=p918 lab=_82454_/Q }
C {sky130_stdcells/dfxtp_4.sym} 780 -1420 0 0 {name=X_82454_ }
C {devices/lab_pin.sym} 740 -1290 0 0 {name=p919 lab=_57754_/X }
C {devices/lab_pin.sym} 820 -1290 0 1 {name=p920 lab=_67388_/X }
C {sky130_stdcells/buf_2.sym} 780 -1290 0 0 {name=X_67388_ }
C {devices/lab_pin.sym} 740 -1170 0 0 {name=p921 lab=_57141_/A }
C {devices/lab_pin.sym} 820 -1170 0 1 {name=p922 lab=_57141_/X }
C {sky130_stdcells/buf_2.sym} 780 -1170 0 0 {name=X_57141_ }
C {devices/lab_pin.sym} 690 -1050 0 0 {name=p923 lab=_83940_/CLK }
C {devices/lab_pin.sym} 690 -1030 0 0 {name=p924 lab=_81405_/D }
C {devices/lab_pin.sym} 870 -1050 0 1 {name=p925 lab=_76747_/B }
C {sky130_stdcells/dfxtp_4.sym} 780 -1040 0 0 {name=X_81405_ }
C {devices/lab_pin.sym} 700 -930 0 0 {name=p926 lab=_69123_/X }
C {devices/lab_pin.sym} 700 -890 0 0 {name=p927 lab=_69126_/X }
C {devices/lab_pin.sym} 700 -850 0 0 {name=p928 lab=_69035_/X }
C {devices/lab_pin.sym} 860 -890 0 1 {name=p929 lab=_69127_/X }
C {sky130_stdcells/a21o_4.sym} 780 -890 0 0 {name=X_69127_ }
C {devices/lab_pin.sym} 720 -780 0 0 {name=p930 lab=_54362_/A }
C {devices/lab_pin.sym} 720 -740 0 0 {name=p931 lab=_54353_/B }
C {devices/lab_pin.sym} 720 -700 0 0 {name=p932 lab=_54362_/C }
C {devices/lab_pin.sym} 720 -660 0 0 {name=p933 lab=_54353_/D }
C {devices/lab_pin.sym} 840 -720 0 1 {name=p934 lab=_54353_/X }
C {sky130_stdcells/and4_4.sym} 780 -720 0 0 {name=X_54353_ }
C {devices/lab_pin.sym} 1640 -42160 0 0 {name=p935 lab=_64710_/A }
C {devices/lab_pin.sym} 1640 -42120 0 0 {name=p936 lab=_86531_/Q }
C {devices/lab_pin.sym} 1760 -42140 0 1 {name=p937 lab=_66339_/X }
C {sky130_stdcells/and2_4.sym} 1700 -42140 0 0 {name=X_66339_ }
C {devices/lab_pin.sym} 1610 -42010 0 0 {name=p938 lab=_86900_/CLK }
C {devices/lab_pin.sym} 1610 -41990 0 0 {name=p939 lab=_85173_/D }
C {devices/lab_pin.sym} 1790 -42010 0 1 {name=p940 lab=_55876_/B }
C {sky130_stdcells/dfxtp_4.sym} 1700 -42000 0 0 {name=X_85173_ }
C {devices/lab_pin.sym} 1660 -41870 0 0 {name=p941 lab=_50991_/A }
C {devices/lab_pin.sym} 1740 -41870 0 1 {name=p942 lab=_51621_/A }
C {sky130_stdcells/buf_2.sym} 1700 -41870 0 0 {name=X_51565_ }
C {devices/lab_pin.sym} 1610 -41750 0 0 {name=p943 lab=_84757_/CLK }
C {devices/lab_pin.sym} 1610 -41730 0 0 {name=p944 lab=_82193_/Q }
C {devices/lab_pin.sym} 1790 -41750 0 1 {name=p945 lab=_82385_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -41740 0 0 {name=X_82385_ }
C {devices/lab_pin.sym} 1620 -41630 0 0 {name=p946 lab=_53299_/Y }
C {devices/lab_pin.sym} 1620 -41590 0 0 {name=p947 lab=_53301_/X }
C {devices/lab_pin.sym} 1620 -41550 0 0 {name=p948 lab=_53303_/X }
C {devices/lab_pin.sym} 1780 -41590 0 1 {name=p949 lab=_53304_/Y }
C {sky130_stdcells/a21oi_4.sym} 1700 -41590 0 0 {name=X_53304_ }
C {devices/lab_pin.sym} 1610 -41450 0 0 {name=p950 lab=_84161_/CLK }
C {devices/lab_pin.sym} 1610 -41430 0 0 {name=p951 lab=_84124_/D }
C {devices/lab_pin.sym} 1790 -41450 0 1 {name=p952 lab=_66433_/C }
C {sky130_stdcells/dfxtp_4.sym} 1700 -41440 0 0 {name=X_84124_ }
C {devices/lab_pin.sym} 1620 -41330 0 0 {name=p953 lab=_50514_/Y }
C {devices/lab_pin.sym} 1620 -41290 0 0 {name=p954 lab=_50491_/X }
C {devices/lab_pin.sym} 1620 -41250 0 0 {name=p955 lab=_50515_/X }
C {devices/lab_pin.sym} 1780 -41290 0 1 {name=p956 lab=_50516_/Y }
C {sky130_stdcells/a21oi_4.sym} 1700 -41290 0 0 {name=X_50516_ }
C {devices/lab_pin.sym} 1610 -41150 0 0 {name=p957 lab=_81333_/CLK }
C {devices/lab_pin.sym} 1610 -41130 0 0 {name=p958 lab=_81336_/D }
C {devices/lab_pin.sym} 1790 -41150 0 1 {name=p959 lab=_81712_/D }
C {sky130_stdcells/dfxtp_4.sym} 1700 -41140 0 0 {name=X_81336_ }
C {devices/lab_pin.sym} 1620 -41030 0 0 {name=p960 lab=_57070_/X }
C {devices/lab_pin.sym} 1620 -40990 0 0 {name=p961 lab=_57071_/Y }
C {devices/lab_pin.sym} 1620 -40950 0 0 {name=p962 lab=_56953_/X }
C {devices/lab_pin.sym} 1780 -40990 0 1 {name=p963 lab=_57072_/Y }
C {sky130_stdcells/a21oi_4.sym} 1700 -40990 0 0 {name=X_57072_ }
C {devices/lab_pin.sym} 1660 -40850 0 0 {name=p964 lab=_69485_/A }
C {devices/lab_pin.sym} 1740 -40850 0 1 {name=p965 lab=_69058_/X }
C {sky130_stdcells/buf_2.sym} 1700 -40850 0 0 {name=X_69058_ }
C {devices/lab_pin.sym} 1660 -40730 0 0 {name=p966 lab=_54284_/A }
C {devices/lab_pin.sym} 1740 -40730 0 1 {name=p967 lab=_54366_/A }
C {sky130_stdcells/buf_2.sym} 1700 -40730 0 0 {name=X_54284_ }
C {devices/lab_pin.sym} 1640 -40620 0 0 {name=p968 lab=_51491_/A }
C {devices/lab_pin.sym} 1640 -40580 0 0 {name=p969 lab=_53021_/B }
C {devices/lab_pin.sym} 1760 -40600 0 1 {name=p970 lab=_51496_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -40600 0 0 {name=X_51496_ }
C {devices/lab_pin.sym} 1640 -40490 0 0 {name=p971 lab=_56023_/A }
C {devices/lab_pin.sym} 1640 -40450 0 0 {name=p972 lab=_56017_/B }
C {devices/lab_pin.sym} 1640 -40410 0 0 {name=p973 lab=_55963_/B }
C {devices/lab_pin.sym} 1760 -40450 0 1 {name=p974 lab=_56023_/Y }
C {sky130_stdcells/nand3_4.sym} 1700 -40450 0 0 {name=X_56023_ }
C {devices/lab_pin.sym} 1640 -40320 0 0 {name=p975 lab=_67914_/X }
C {devices/lab_pin.sym} 1640 -40280 0 0 {name=p976 lab=_86915_/Q }
C {devices/lab_pin.sym} 1760 -40300 0 1 {name=p977 lab=_68009_/X }
C {sky130_stdcells/and2_4.sym} 1700 -40300 0 0 {name=X_68009_ }
C {devices/lab_pin.sym} 1620 -40190 0 0 {name=p978 lab=_53233_/Y }
C {devices/lab_pin.sym} 1620 -40150 0 0 {name=p979 lab=_53215_/X }
C {devices/lab_pin.sym} 1620 -40110 0 0 {name=p980 lab=_53234_/X }
C {devices/lab_pin.sym} 1780 -40150 0 1 {name=p981 lab=_53235_/Y }
C {sky130_stdcells/a21oi_4.sym} 1700 -40150 0 0 {name=X_53235_ }
C {devices/lab_pin.sym} 1610 -40010 0 0 {name=p982 lab=_81492_/CLK }
C {devices/lab_pin.sym} 1610 -39990 0 0 {name=p983 lab=_84055_/D }
C {devices/lab_pin.sym} 1790 -40010 0 1 {name=p984 lab=_84055_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -40000 0 0 {name=X_84055_ }
C {devices/lab_pin.sym} 1640 -39890 0 0 {name=p985 lab=_50447_/A }
C {devices/lab_pin.sym} 1640 -39850 0 0 {name=p986 lab=_50456_/B }
C {devices/lab_pin.sym} 1640 -39810 0 0 {name=p987 lab=_50462_/C }
C {devices/lab_pin.sym} 1760 -39850 0 1 {name=p988 lab=_50447_/X }
C {sky130_stdcells/and3_4.sym} 1700 -39850 0 0 {name=X_50447_ }
C {devices/lab_pin.sym} 1610 -39710 0 0 {name=p989 lab=_81631_/CLK }
C {devices/lab_pin.sym} 1610 -39690 0 0 {name=p990 lab=_81267_/D }
C {devices/lab_pin.sym} 1790 -39710 0 1 {name=p991 lab=_76393_/A }
C {sky130_stdcells/dfxtp_4.sym} 1700 -39700 0 0 {name=X_81267_ }
C {devices/lab_pin.sym} 1660 -39570 0 0 {name=p992 lab=_70768_/A }
C {devices/lab_pin.sym} 1740 -39570 0 1 {name=p993 lab=_71171_/A }
C {sky130_stdcells/buf_2.sym} 1700 -39570 0 0 {name=X_71020_ }
C {devices/lab_pin.sym} 1610 -39450 0 0 {name=p994 lab=_83008_/CLK }
C {devices/lab_pin.sym} 1610 -39430 0 0 {name=p995 lab=_83006_/D }
C {devices/lab_pin.sym} 1790 -39450 0 1 {name=p996 lab=_45448_/A }
C {sky130_stdcells/dfxtp_4.sym} 1700 -39440 0 0 {name=X_83006_ }
C {devices/lab_pin.sym} 1660 -39310 0 0 {name=p997 lab=_80244_/A }
C {devices/lab_pin.sym} 1740 -39310 0 1 {name=p998 lab=_80228_/A }
C {sky130_stdcells/inv_2.sym} 1700 -39310 0 0 {name=X_80218_ }
C {devices/lab_pin.sym} 1620 -39210 0 0 {name=p999 lab=_53162_/Y }
C {devices/lab_pin.sym} 1620 -39170 0 0 {name=p1000 lab=_53163_/X }
C {devices/lab_pin.sym} 1620 -39130 0 0 {name=p1001 lab=_53165_/X }
C {devices/lab_pin.sym} 1780 -39170 0 1 {name=p1002 lab=_53166_/Y }
C {sky130_stdcells/a21oi_4.sym} 1700 -39170 0 0 {name=X_53166_ }
C {devices/lab_pin.sym} 1660 -39030 0 0 {name=p1003 lab=_40717_/X }
C {devices/lab_pin.sym} 1740 -39030 0 1 {name=p1004 lab=_41181_/A }
C {sky130_stdcells/buf_2.sym} 1700 -39030 0 0 {name=X_41180_ }
C {devices/lab_pin.sym} 1640 -38920 0 0 {name=p1005 lab=_50383_/A }
C {devices/lab_pin.sym} 1640 -38880 0 0 {name=p1006 lab=_50378_/B }
C {devices/lab_pin.sym} 1760 -38900 0 1 {name=p1007 lab=_50378_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -38900 0 0 {name=X_50378_ }
C {devices/lab_pin.sym} 1610 -38770 0 0 {name=p1008 lab=_81198_/CLK }
C {devices/lab_pin.sym} 1610 -38750 0 0 {name=p1009 lab=_81198_/D }
C {devices/lab_pin.sym} 1790 -38770 0 1 {name=p1010 lab=_49077_/A }
C {sky130_stdcells/dfxtp_4.sym} 1700 -38760 0 0 {name=X_81198_ }
C {devices/lab_pin.sym} 1660 -38630 0 0 {name=p1011 lab=_52462_/A }
C {devices/lab_pin.sym} 1740 -38630 0 1 {name=p1012 lab=_52117_/X }
C {sky130_stdcells/buf_2.sym} 1700 -38630 0 0 {name=X_52117_ }
C {devices/lab_pin.sym} 1610 -38510 0 0 {name=p1013 lab=_87814_/CLK }
C {devices/lab_pin.sym} 1610 -38490 0 0 {name=p1014 lab=_87814_/D }
C {devices/lab_pin.sym} 1790 -38510 0 1 {name=p1015 lab=_69734_/A }
C {sky130_stdcells/dfxtp_4.sym} 1700 -38500 0 0 {name=X_87814_ }
C {devices/lab_pin.sym} 1640 -38380 0 0 {name=p1016 lab=_80157_/A }
C {devices/lab_pin.sym} 1640 -38340 0 0 {name=p1017 lab=_80149_/B }
C {devices/lab_pin.sym} 1760 -38360 0 1 {name=p1018 lab=_81687_/D }
C {sky130_stdcells/xnor2_4.sym} 1700 -38360 0 0 {name=X_80149_ }
C {devices/lab_pin.sym} 1660 -38230 0 0 {name=p1019 lab=_53097_/A }
C {devices/lab_pin.sym} 1740 -38230 0 1 {name=p1020 lab=_53097_/X }
C {sky130_stdcells/buf_2.sym} 1700 -38230 0 0 {name=X_53097_ }
C {devices/lab_pin.sym} 1620 -38130 0 0 {name=p1021 lab=_57903_/X }
C {devices/lab_pin.sym} 1620 -38090 0 0 {name=p1022 lab=_85487_/Q }
C {devices/lab_pin.sym} 1620 -38050 0 0 {name=p1023 lab=_57962_/X }
C {devices/lab_pin.sym} 1780 -38090 0 1 {name=p1024 lab=_57974_/X }
C {sky130_stdcells/o21a_4.sym} 1700 -38090 0 0 {name=X_57974_ }
C {devices/lab_pin.sym} 1660 -37950 0 0 {name=p1025 lab=_59713_/A }
C {devices/lab_pin.sym} 1740 -37950 0 1 {name=p1026 lab=_59713_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -37950 0 0 {name=X_59713_ }
C {devices/lab_pin.sym} 1620 -37850 0 0 {name=p1027 lab=_85899_/Q }
C {devices/lab_pin.sym} 1620 -37810 0 0 {name=p1028 lab=_52013_/X }
C {devices/lab_pin.sym} 1620 -37770 0 0 {name=p1029 lab=_52047_/Y }
C {devices/lab_pin.sym} 1780 -37810 0 1 {name=p1030 lab=_52048_/Y }
C {sky130_stdcells/o21ai_4.sym} 1700 -37810 0 0 {name=X_52048_ }
C {devices/lab_pin.sym} 1620 -37690 0 0 {name=p1031 lab=_55218_/Y }
C {devices/lab_pin.sym} 1620 -37650 0 0 {name=p1032 lab=_56924_/X }
C {devices/lab_pin.sym} 1620 -37610 0 0 {name=p1033 lab=_56649_/X }
C {devices/lab_pin.sym} 1780 -37650 0 1 {name=p1034 lab=_56927_/A }
C {sky130_stdcells/a21o_4.sym} 1700 -37650 0 0 {name=X_56925_ }
C {devices/lab_pin.sym} 1610 -37510 0 0 {name=p1035 lab=_87748_/CLK }
C {devices/lab_pin.sym} 1610 -37490 0 0 {name=p1036 lab=_87745_/D }
C {devices/lab_pin.sym} 1790 -37510 0 1 {name=p1037 lab=_87745_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -37500 0 0 {name=X_87745_ }
C {devices/lab_pin.sym} 1620 -37390 0 0 {name=p1038 lab=_72968_/X }
C {devices/lab_pin.sym} 1620 -37350 0 0 {name=p1039 lab=_72969_/Y }
C {devices/lab_pin.sym} 1620 -37310 0 0 {name=p1040 lab=_72970_/X }
C {devices/lab_pin.sym} 1780 -37350 0 1 {name=p1041 lab=_72971_/Y }
C {sky130_stdcells/a21oi_4.sym} 1700 -37350 0 0 {name=X_72971_ }
C {devices/lab_pin.sym} 1610 -37210 0 0 {name=p1042 lab=_84869_/CLK }
C {devices/lab_pin.sym} 1610 -37190 0 0 {name=p1043 lab=_57671_/Y }
C {devices/lab_pin.sym} 1790 -37210 0 1 {name=p1044 lab=_84957_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -37200 0 0 {name=X_84957_ }
C {devices/lab_pin.sym} 1660 -37070 0 0 {name=p1045 lab=_74711_/A }
C {devices/lab_pin.sym} 1740 -37070 0 1 {name=p1046 lab=_74710_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -37070 0 0 {name=X_74710_ }
C {devices/lab_pin.sym} 1620 -36970 0 0 {name=p1047 lab=_71920_/Y }
C {devices/lab_pin.sym} 1620 -36930 0 0 {name=p1048 lab=_57270_/X }
C {devices/lab_pin.sym} 1620 -36890 0 0 {name=p1049 lab=_71921_/Y }
C {devices/lab_pin.sym} 1780 -36930 0 1 {name=p1050 lab=_83328_/D }
C {sky130_stdcells/a21o_4.sym} 1700 -36930 0 0 {name=X_71922_ }
C {devices/lab_pin.sym} 1660 -36790 0 0 {name=p1051 lab=_59797_/B }
C {devices/lab_pin.sym} 1740 -36790 0 1 {name=p1052 lab=_59651_/B }
C {sky130_stdcells/inv_2.sym} 1700 -36790 0 0 {name=X_59644_ }
C {devices/lab_pin.sym} 1610 -36670 0 0 {name=p1053 lab=_83905_/CLK }
C {devices/lab_pin.sym} 1610 -36650 0 0 {name=p1054 lab=_83908_/D }
C {devices/lab_pin.sym} 1790 -36670 0 1 {name=p1055 lab=_81980_/D }
C {sky130_stdcells/dfxtp_4.sym} 1700 -36660 0 0 {name=X_83908_ }
C {devices/lab_pin.sym} 1660 -36530 0 0 {name=p1056 lab=_45612_/A }
C {devices/lab_pin.sym} 1740 -36530 0 1 {name=p1057 lab=_45297_/A }
C {sky130_stdcells/buf_2.sym} 1700 -36530 0 0 {name=X_44870_ }
C {devices/lab_pin.sym} 1660 -36410 0 0 {name=p1058 lab=_83335_/Q }
C {devices/lab_pin.sym} 1740 -36410 0 1 {name=p1059 lab=_56856_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -36410 0 0 {name=X_56856_ }
C {devices/lab_pin.sym} 1640 -36300 0 0 {name=p1060 lab=_75678_/A }
C {devices/lab_pin.sym} 1640 -36260 0 0 {name=p1061 lab=_75677_/Y }
C {devices/lab_pin.sym} 1760 -36280 0 1 {name=p1062 lab=_75690_/Y }
C {sky130_stdcells/nor2_4.sym} 1700 -36280 0 0 {name=X_75690_ }
C {devices/lab_pin.sym} 1610 -36150 0 0 {name=p1063 lab=_87675_/CLK }
C {devices/lab_pin.sym} 1610 -36130 0 0 {name=p1064 lab=_42871_/X }
C {devices/lab_pin.sym} 1790 -36150 0 1 {name=p1065 lab=_67118_/B }
C {sky130_stdcells/dfxtp_4.sym} 1700 -36140 0 0 {name=X_87676_ }
C {devices/lab_pin.sym} 1610 -36010 0 0 {name=p1066 lab=_84888_/CLK }
C {devices/lab_pin.sym} 1610 -35990 0 0 {name=p1067 lab=_84888_/D }
C {devices/lab_pin.sym} 1790 -36010 0 1 {name=p1068 lab=_84888_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -36000 0 0 {name=X_84888_ }
C {devices/lab_pin.sym} 1660 -35870 0 0 {name=p1069 lab=_43821_/A }
C {devices/lab_pin.sym} 1740 -35870 0 1 {name=p1070 lab=_43821_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -35870 0 0 {name=X_43821_ }
C {devices/lab_pin.sym} 1620 -35770 0 0 {name=p1071 lab=_55804_/X }
C {devices/lab_pin.sym} 1620 -35730 0 0 {name=p1072 lab=_55806_/X }
C {devices/lab_pin.sym} 1620 -35690 0 0 {name=p1073 lab=_44111_/X }
C {devices/lab_pin.sym} 1780 -35730 0 1 {name=p1074 lab=_55807_/X }
C {sky130_stdcells/a21o_4.sym} 1700 -35730 0 0 {name=X_55807_ }
C {devices/lab_pin.sym} 1610 -35590 0 0 {name=p1075 lab=_86627_/CLK }
C {devices/lab_pin.sym} 1610 -35570 0 0 {name=p1076 lab=_86627_/D }
C {devices/lab_pin.sym} 1790 -35590 0 1 {name=p1077 lab=_58132_/A }
C {sky130_stdcells/dfxtp_4.sym} 1700 -35580 0 0 {name=X_86627_ }
C {devices/lab_pin.sym} 1660 -35450 0 0 {name=p1078 lab=_74685_/C }
C {devices/lab_pin.sym} 1740 -35450 0 1 {name=p1079 lab=_74641_/X }
C {sky130_stdcells/buf_2.sym} 1700 -35450 0 0 {name=X_74641_ }
C {devices/lab_pin.sym} 1640 -35360 0 0 {name=p1080 lab=_70534_/Y }
C {devices/lab_pin.sym} 1640 -35320 0 0 {name=p1081 lab=_71857_/B }
C {devices/lab_pin.sym} 1640 -35280 0 0 {name=p1082 lab=_71851_/X }
C {devices/lab_pin.sym} 1640 -35240 0 0 {name=p1083 lab=_71857_/D }
C {devices/lab_pin.sym} 1760 -35300 0 1 {name=p1084 lab=_71853_/Y }
C {sky130_stdcells/nor4_4.sym} 1700 -35300 0 0 {name=X_71853_ }
C {devices/lab_pin.sym} 1640 -35170 0 0 {name=p1085 lab=_60639_/A }
C {devices/lab_pin.sym} 1640 -35130 0 0 {name=p1086 lab=_60620_/B }
C {devices/lab_pin.sym} 1640 -35090 0 0 {name=p1087 lab=_60620_/C }
C {devices/lab_pin.sym} 1760 -35130 0 1 {name=p1088 lab=_59575_/Y }
C {sky130_stdcells/nand3_4.sym} 1700 -35130 0 0 {name=X_59575_ }
C {devices/lab_pin.sym} 1610 -34990 0 0 {name=p1089 lab=_83835_/CLK }
C {devices/lab_pin.sym} 1610 -34970 0 0 {name=p1090 lab=_70201_/X }
C {devices/lab_pin.sym} 1790 -34990 0 1 {name=p1091 lab=_74789_/C }
C {sky130_stdcells/dfxtp_4.sym} 1700 -34980 0 0 {name=X_83839_ }
C {devices/lab_pin.sym} 1660 -34850 0 0 {name=p1092 lab=_56755_/X }
C {devices/lab_pin.sym} 1740 -34850 0 1 {name=p1093 lab=_56787_/X }
C {sky130_stdcells/buf_2.sym} 1700 -34850 0 0 {name=X_56787_ }
C {devices/lab_pin.sym} 1620 -34750 0 0 {name=p1094 lab=_53996_/Y }
C {devices/lab_pin.sym} 1620 -34710 0 0 {name=p1095 lab=_53982_/X }
C {devices/lab_pin.sym} 1620 -34670 0 0 {name=p1096 lab=_53998_/Y }
C {devices/lab_pin.sym} 1780 -34710 0 1 {name=p1097 lab=_53999_/Y }
C {sky130_stdcells/a21boi_4.sym} 1700 -34710 0 0 {name=X_53999_ }
C {devices/lab_pin.sym} 1640 -34580 0 0 {name=p1098 lab=_46531_/A }
C {devices/lab_pin.sym} 1640 -34540 0 0 {name=p1099 lab=_50854_/B }
C {devices/lab_pin.sym} 1760 -34560 0 1 {name=p1100 lab=_46540_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -34560 0 0 {name=X_46540_ }
C {devices/lab_pin.sym} 1660 -34430 0 0 {name=p1101 lab=_70804_/A }
C {devices/lab_pin.sym} 1740 -34430 0 1 {name=p1102 lab=_70810_/A }
C {sky130_stdcells/buf_2.sym} 1700 -34430 0 0 {name=X_70804_ }
C {devices/lab_pin.sym} 1660 -34310 0 0 {name=p1103 lab=_58526_/A }
C {devices/lab_pin.sym} 1740 -34310 0 1 {name=p1104 lab=_58526_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -34310 0 0 {name=X_58526_ }
C {devices/lab_pin.sym} 1640 -34210 0 0 {name=p1105 lab=_77360_/A }
C {devices/lab_pin.sym} 1640 -34170 0 0 {name=p1106 lab=_77354_/X }
C {devices/lab_pin.sym} 1640 -34130 0 0 {name=p1107 lab=_77360_/C }
C {devices/lab_pin.sym} 1760 -34170 0 1 {name=p1108 lab=_77361_/A }
C {sky130_stdcells/nand3_4.sym} 1700 -34170 0 0 {name=X_77360_ }
C {devices/lab_pin.sym} 1660 -34030 0 0 {name=p1109 lab=_43752_/A }
C {devices/lab_pin.sym} 1740 -34030 0 1 {name=p1110 lab=_43752_/X }
C {sky130_stdcells/buf_2.sym} 1700 -34030 0 0 {name=X_43752_ }
C {devices/lab_pin.sym} 1640 -33920 0 0 {name=p1111 lab=_55235_/A }
C {devices/lab_pin.sym} 1640 -33880 0 0 {name=p1112 lab=_55738_/B }
C {devices/lab_pin.sym} 1760 -33900 0 1 {name=p1113 lab=_55738_/X }
C {sky130_stdcells/and2_4.sym} 1700 -33900 0 0 {name=X_55738_ }
C {devices/lab_pin.sym} 1620 -33790 0 0 {name=p1114 lab=_45067_/A }
C {devices/lab_pin.sym} 1620 -33750 0 0 {name=p1115 lab=_74568_/X }
C {devices/lab_pin.sym} 1620 -33710 0 0 {name=p1116 lab=_74571_/X }
C {devices/lab_pin.sym} 1780 -33750 0 1 {name=p1117 lab=_83031_/D }
C {sky130_stdcells/o21ai_4.sym} 1700 -33750 0 0 {name=X_74572_ }
C {devices/lab_pin.sym} 1610 -33610 0 0 {name=p1118 lab=_86558_/CLK }
C {devices/lab_pin.sym} 1610 -33590 0 0 {name=p1119 lab=_48197_/Y }
C {devices/lab_pin.sym} 1790 -33610 0 1 {name=p1120 lab=_86558_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -33600 0 0 {name=X_86558_ }
C {devices/lab_pin.sym} 1660 -33470 0 0 {name=p1121 lab=_40964_/A }
C {devices/lab_pin.sym} 1740 -33470 0 1 {name=p1122 lab=_40964_/X }
C {sky130_stdcells/buf_2.sym} 1700 -33470 0 0 {name=X_40964_ }
C {devices/lab_pin.sym} 1660 -33350 0 0 {name=p1123 lab=_71783_/Y }
C {devices/lab_pin.sym} 1740 -33350 0 1 {name=p1124 lab=_71784_/X }
C {sky130_stdcells/buf_2.sym} 1700 -33350 0 0 {name=X_71784_ }
C {devices/lab_pin.sym} 1640 -33240 0 0 {name=p1125 lab=_76311_/A }
C {devices/lab_pin.sym} 1640 -33200 0 0 {name=p1126 lab=_76310_/Y }
C {devices/lab_pin.sym} 1760 -33220 0 1 {name=p1127 lab=_76312_/B }
C {sky130_stdcells/xnor2_4.sym} 1700 -33220 0 0 {name=X_76311_ }
C {devices/lab_pin.sym} 1620 -33120 0 0 {name=p1128 lab=_41121_/X }
C {devices/lab_pin.sym} 1620 -33080 0 0 {name=p1129 lab=_42695_/X }
C {devices/lab_pin.sym} 1620 -33040 0 0 {name=p1130 lab=_68403_/B }
C {devices/lab_pin.sym} 1620 -33000 0 0 {name=p1131 lab=_42696_/X }
C {devices/lab_pin.sym} 1780 -33060 0 1 {name=p1132 lab=_42703_/X }
C {sky130_stdcells/a2bb2o_4.sym} 1700 -33060 0 0 {name=X_42703_ }
C {devices/lab_pin.sym} 1620 -32930 0 0 {name=p1133 lab=_73524_/B }
C {devices/lab_pin.sym} 1620 -32890 0 0 {name=p1134 lab=_73524_/C }
C {devices/lab_pin.sym} 1620 -32850 0 0 {name=p1135 lab=_73522_/X }
C {devices/lab_pin.sym} 1780 -32890 0 1 {name=p1136 lab=_73523_/X }
C {sky130_stdcells/a21o_4.sym} 1700 -32890 0 0 {name=X_73523_ }
C {devices/lab_pin.sym} 1610 -32750 0 0 {name=p1137 lab=_86733_/CLK }
C {devices/lab_pin.sym} 1610 -32730 0 0 {name=p1138 lab=_54080_/Y }
C {devices/lab_pin.sym} 1790 -32750 0 1 {name=p1139 lab=_85509_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -32740 0 0 {name=X_85509_ }
C {devices/lab_pin.sym} 1660 -32610 0 0 {name=p1140 lab=_46471_/A }
C {devices/lab_pin.sym} 1740 -32610 0 1 {name=p1141 lab=_51330_/A }
C {sky130_stdcells/buf_2.sym} 1700 -32610 0 0 {name=X_46471_ }
C {devices/lab_pin.sym} 1660 -32490 0 0 {name=p1142 lab=_71263_/D }
C {devices/lab_pin.sym} 1740 -32490 0 1 {name=p1143 lab=_70735_/X }
C {sky130_stdcells/buf_2.sym} 1700 -32490 0 0 {name=X_70735_ }
C {devices/lab_pin.sym} 1640 -32380 0 0 {name=p1144 lab=_58457_/A }
C {devices/lab_pin.sym} 1640 -32340 0 0 {name=p1145 lab=_58474_/B }
C {devices/lab_pin.sym} 1760 -32360 0 1 {name=p1146 lab=_58457_/Y }
C {sky130_stdcells/nor2_4.sym} 1700 -32360 0 0 {name=X_58457_ }
C {devices/lab_pin.sym} 1640 -32240 0 0 {name=p1147 lab=_81926_/Q }
C {devices/lab_pin.sym} 1640 -32200 0 0 {name=p1148 lab=_82182_/D }
C {devices/lab_pin.sym} 1760 -32220 0 1 {name=p1149 lab=_77291_/X }
C {sky130_stdcells/xor2_4.sym} 1700 -32220 0 0 {name=X_77291_ }
C {devices/lab_pin.sym} 1620 -32120 0 0 {name=p1150 lab=_40787_/A }
C {devices/lab_pin.sym} 1620 -32080 0 0 {name=p1151 lab=_43659_/X }
C {devices/lab_pin.sym} 1620 -32040 0 0 {name=p1152 lab=_69622_/B }
C {devices/lab_pin.sym} 1620 -32000 0 0 {name=p1153 lab=_43661_/X }
C {devices/lab_pin.sym} 1780 -32060 0 1 {name=p1154 lab=_43683_/X }
C {sky130_stdcells/a2bb2o_4.sym} 1700 -32060 0 0 {name=X_43683_ }
C {devices/lab_pin.sym} 1640 -31920 0 0 {name=p1155 lab=_55669_/A }
C {devices/lab_pin.sym} 1640 -31880 0 0 {name=p1156 lab=_55289_/X }
C {devices/lab_pin.sym} 1760 -31900 0 1 {name=p1157 lab=_55670_/B }
C {sky130_stdcells/and2_4.sym} 1700 -31900 0 0 {name=X_55669_ }
C {devices/lab_pin.sym} 1610 -31770 0 0 {name=p1158 lab=_85879_/CLK }
C {devices/lab_pin.sym} 1610 -31750 0 0 {name=p1159 lab=_48753_/Y }
C {devices/lab_pin.sym} 1790 -31770 0 1 {name=p1160 lab=_65551_/B }
C {sky130_stdcells/dfxtp_4.sym} 1700 -31760 0 0 {name=X_86489_ }
C {devices/lab_pin.sym} 1620 -31670 0 0 {name=p1161 lab=_40870_/X }
C {devices/lab_pin.sym} 1620 -31630 0 0 {name=p1162 lab=_40871_/X }
C {devices/lab_pin.sym} 1620 -31590 0 0 {name=p1163 lab=_40894_/X }
C {devices/lab_pin.sym} 1620 -31550 0 0 {name=p1164 lab=_69888_/B }
C {devices/lab_pin.sym} 1620 -31510 0 0 {name=p1165 lab=_40867_/X }
C {devices/lab_pin.sym} 1780 -31590 0 1 {name=p1166 lab=_40895_/Y }
C {sky130_stdcells/o32ai_4.sym} 1700 -31590 0 0 {name=X_40895_ }
C {devices/lab_pin.sym} 1640 -31440 0 0 {name=p1167 lab=_48204_/X }
C {devices/lab_pin.sym} 1640 -31400 0 0 {name=p1168 lab=_50264_/B }
C {devices/lab_pin.sym} 1760 -31420 0 1 {name=p1169 lab=_48210_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -31420 0 0 {name=X_48210_ }
C {devices/lab_pin.sym} 1640 -31300 0 0 {name=p1170 lab=_82827_/Q }
C {devices/lab_pin.sym} 1640 -31260 0 0 {name=p1171 lab=_82539_/Q }
C {devices/lab_pin.sym} 1760 -31280 0 1 {name=p1172 lab=_79031_/B }
C {sky130_stdcells/xnor2_4.sym} 1700 -31280 0 0 {name=X_79030_ }
C {devices/lab_pin.sym} 1660 -31150 0 0 {name=p1173 lab=_45422_/A }
C {devices/lab_pin.sym} 1740 -31150 0 1 {name=p1174 lab=_45422_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -31150 0 0 {name=X_45422_ }
C {devices/lab_pin.sym} 1660 -31030 0 0 {name=p1175 lab=_57470_/B }
C {devices/lab_pin.sym} 1740 -31030 0 1 {name=p1176 lab=_57408_/X }
C {sky130_stdcells/buf_2.sym} 1700 -31030 0 0 {name=X_57408_ }
C {devices/lab_pin.sym} 1610 -30910 0 0 {name=p1177 lab=_88232_/CLK }
C {devices/lab_pin.sym} 1610 -30890 0 0 {name=p1178 lab=_88228_/D }
C {devices/lab_pin.sym} 1790 -30910 0 1 {name=p1179 lab=_67707_/B }
C {sky130_stdcells/dfxtp_4.sym} 1700 -30900 0 0 {name=X_88228_ }
C {devices/lab_pin.sym} 1620 -30790 0 0 {name=p1180 lab=_76240_/Y }
C {devices/lab_pin.sym} 1620 -30750 0 0 {name=p1181 lab=_76211_/Y }
C {devices/lab_pin.sym} 1620 -30710 0 0 {name=p1182 lab=_76241_/X }
C {devices/lab_pin.sym} 1780 -30750 0 1 {name=p1183 lab=_76242_/Y }
C {sky130_stdcells/o21ai_4.sym} 1700 -30750 0 0 {name=X_76242_ }
C {devices/lab_pin.sym} 1660 -30610 0 0 {name=p1184 lab=_42634_/A }
C {devices/lab_pin.sym} 1740 -30610 0 1 {name=p1185 lab=_42634_/X }
C {sky130_stdcells/buf_2.sym} 1700 -30610 0 0 {name=X_42634_ }
C {devices/lab_pin.sym} 1640 -30500 0 0 {name=p1186 lab=_49190_/A }
C {devices/lab_pin.sym} 1640 -30460 0 0 {name=p1187 lab=_49161_/B }
C {devices/lab_pin.sym} 1760 -30480 0 1 {name=p1188 lab=_49190_/Y }
C {sky130_stdcells/nor2_4.sym} 1700 -30480 0 0 {name=X_49190_ }
C {devices/lab_pin.sym} 1620 -30370 0 0 {name=p1189 lab=_73448_/X }
C {devices/lab_pin.sym} 1620 -30330 0 0 {name=p1190 lab=_73453_/X }
C {devices/lab_pin.sym} 1620 -30290 0 0 {name=p1191 lab=_73383_/X }
C {devices/lab_pin.sym} 1780 -30330 0 1 {name=p1192 lab=_73457_/A }
C {sky130_stdcells/a21o_4.sym} 1700 -30330 0 0 {name=X_73454_ }
C {devices/lab_pin.sym} 1660 -30190 0 0 {name=p1193 lab=_70410_/Y }
C {devices/lab_pin.sym} 1740 -30190 0 1 {name=p1194 lab=_70667_/A }
C {sky130_stdcells/buf_2.sym} 1700 -30190 0 0 {name=X_70666_ }
C {devices/lab_pin.sym} 1660 -30070 0 0 {name=p1195 lab=_58328_/A }
C {devices/lab_pin.sym} 1740 -30070 0 1 {name=p1196 lab=_58388_/X }
C {sky130_stdcells/buf_2.sym} 1700 -30070 0 0 {name=X_58388_ }
C {devices/lab_pin.sym} 1660 -29950 0 0 {name=p1197 lab=_48141_/A }
C {devices/lab_pin.sym} 1740 -29950 0 1 {name=p1198 lab=_50383_/B }
C {sky130_stdcells/buf_2.sym} 1700 -29950 0 0 {name=X_48141_ }
C {devices/lab_pin.sym} 1640 -29840 0 0 {name=p1199 lab=_72405_/A }
C {devices/lab_pin.sym} 1640 -29800 0 0 {name=p1200 lab=_72428_/B }
C {devices/lab_pin.sym} 1760 -29820 0 1 {name=p1201 lab=_72405_/Y }
C {sky130_stdcells/nor2_4.sym} 1700 -29820 0 0 {name=X_72405_ }
C {devices/lab_pin.sym} 1620 -29710 0 0 {name=p1202 lab=_45342_/X }
C {devices/lab_pin.sym} 1620 -29670 0 0 {name=p1203 lab=_45349_/Y }
C {devices/lab_pin.sym} 1620 -29630 0 0 {name=p1204 lab=_45352_/Y }
C {devices/lab_pin.sym} 1780 -29670 0 1 {name=p1205 lab=_45353_/Y }
C {sky130_stdcells/a21oi_4.sym} 1700 -29670 0 0 {name=X_45353_ }
C {devices/lab_pin.sym} 1620 -29550 0 0 {name=p1206 lab=_57338_/Y }
C {devices/lab_pin.sym} 1620 -29510 0 0 {name=p1207 lab=_57290_/A }
C {devices/lab_pin.sym} 1620 -29470 0 0 {name=p1208 lab=_44039_/X }
C {devices/lab_pin.sym} 1780 -29510 0 1 {name=p1209 lab=_57339_/X }
C {sky130_stdcells/o21a_4.sym} 1700 -29510 0 0 {name=X_57339_ }
C {devices/lab_pin.sym} 1640 -29380 0 0 {name=p1210 lab=_76171_/A }
C {devices/lab_pin.sym} 1640 -29340 0 0 {name=p1211 lab=_76171_/B }
C {devices/lab_pin.sym} 1760 -29360 0 1 {name=p1212 lab=_76175_/A }
C {sky130_stdcells/nand2_4.sym} 1700 -29360 0 0 {name=X_76173_ }
C {devices/lab_pin.sym} 1610 -29230 0 0 {name=p1213 lab=_88164_/CLK }
C {devices/lab_pin.sym} 1610 -29210 0 0 {name=p1214 lab=_88159_/D }
C {devices/lab_pin.sym} 1790 -29230 0 1 {name=p1215 lab=_67826_/B }
C {sky130_stdcells/dfxtp_4.sym} 1700 -29220 0 0 {name=X_88159_ }
C {devices/lab_pin.sym} 1620 -29130 0 0 {name=p1216 lab=_42554_/X }
C {devices/lab_pin.sym} 1620 -29090 0 0 {name=p1217 lab=_42547_/X }
C {devices/lab_pin.sym} 1620 -29050 0 0 {name=p1218 lab=_40810_/X }
C {devices/lab_pin.sym} 1620 -29010 0 0 {name=p1219 lab=_42564_/Y }
C {devices/lab_pin.sym} 1620 -28970 0 0 {name=p1220 lab=_42556_/X }
C {devices/lab_pin.sym} 1780 -29050 0 1 {name=p1221 lab=_42565_/Y }
C {sky130_stdcells/o32ai_4.sym} 1700 -29050 0 0 {name=X_42565_ }
C {devices/lab_pin.sym} 1660 -28890 0 0 {name=p1222 lab=_72880_/A }
C {devices/lab_pin.sym} 1740 -28890 0 1 {name=p1223 lab=_73385_/X }
C {sky130_stdcells/buf_2.sym} 1700 -28890 0 0 {name=X_73385_ }
C {devices/lab_pin.sym} 1660 -28770 0 0 {name=p1224 lab=DATA_TO_HASH[6] }
C {devices/lab_pin.sym} 1740 -28770 0 1 {name=p1225 lab=_70768_/A }
C {sky130_stdcells/buf_2.sym} 1700 -28770 0 0 {name=X_70597_ }
C {devices/lab_pin.sym} 1640 -28670 0 0 {name=p1226 lab=_44313_/A }
C {devices/lab_pin.sym} 1640 -28630 0 0 {name=p1227 lab=_43987_/A }
C {devices/lab_pin.sym} 1640 -28590 0 0 {name=p1228 lab=_46228_/A }
C {devices/lab_pin.sym} 1760 -28630 0 1 {name=p1229 lab=_44304_/Y }
C {sky130_stdcells/nand3_4.sym} 1700 -28630 0 0 {name=X_44304_ }
C {devices/lab_pin.sym} 1640 -28500 0 0 {name=p1230 lab=_80678_/Q }
C {devices/lab_pin.sym} 1640 -28460 0 0 {name=p1231 lab=_75124_/B }
C {devices/lab_pin.sym} 1760 -28480 0 1 {name=p1232 lab=_75124_/X }
C {sky130_stdcells/or2_4.sym} 1700 -28480 0 0 {name=X_75124_ }
C {devices/lab_pin.sym} 1660 -28350 0 0 {name=p1233 lab=clkbuf_9_235_0_CLK/X }
C {devices/lab_pin.sym} 1740 -28350 0 1 {name=p1234 lab=_85447_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 1700 -28350 0 0 {name=Xclkbuf_10_470_0_CLK }
C {devices/lab_pin.sym} 1620 -28270 0 0 {name=p1235 lab=_41489_/X }
C {devices/lab_pin.sym} 1620 -28230 0 0 {name=p1236 lab=_41490_/X }
C {devices/lab_pin.sym} 1620 -28190 0 0 {name=p1237 lab=_41515_/X }
C {devices/lab_pin.sym} 1620 -28150 0 0 {name=p1238 lab=_88200_/Q }
C {devices/lab_pin.sym} 1620 -28110 0 0 {name=p1239 lab=_41474_/X }
C {devices/lab_pin.sym} 1780 -28190 0 1 {name=p1240 lab=_41517_/A }
C {sky130_stdcells/o32ai_4.sym} 1700 -28190 0 0 {name=X_41516_ }
C {devices/lab_pin.sym} 1640 -28040 0 0 {name=p1241 lab=_72336_/A }
C {devices/lab_pin.sym} 1640 -28000 0 0 {name=p1242 lab=_72348_/B }
C {devices/lab_pin.sym} 1760 -28020 0 1 {name=p1243 lab=_72336_/Y }
C {sky130_stdcells/nor2_4.sym} 1700 -28020 0 0 {name=X_72336_ }
C {devices/lab_pin.sym} 1660 -27890 0 0 {name=p1244 lab=_57605_/B }
C {devices/lab_pin.sym} 1740 -27890 0 1 {name=p1245 lab=_48073_/B }
C {sky130_stdcells/buf_2.sym} 1700 -27890 0 0 {name=X_48072_ }
C {devices/lab_pin.sym} 1660 -27770 0 0 {name=p1246 lab=_60350_/A }
C {devices/lab_pin.sym} 1740 -27770 0 1 {name=p1247 lab=_60350_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -27770 0 0 {name=X_60350_ }
C {devices/lab_pin.sym} 1660 -27650 0 0 {name=p1248 lab=_45284_/A }
C {devices/lab_pin.sym} 1740 -27650 0 1 {name=p1249 lab=_45284_/X }
C {sky130_stdcells/buf_2.sym} 1700 -27650 0 0 {name=X_45284_ }
C {devices/lab_pin.sym} 1660 -27530 0 0 {name=p1250 lab=_42574_/A }
C {devices/lab_pin.sym} 1740 -27530 0 1 {name=p1251 lab=_42496_/X }
C {sky130_stdcells/buf_2.sym} 1700 -27530 0 0 {name=X_42496_ }
C {devices/lab_pin.sym} 1660 -27410 0 0 {name=p1252 lab=_83046_/Q }
C {devices/lab_pin.sym} 1740 -27410 0 1 {name=p1253 lab=_47023_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -27410 0 0 {name=X_47023_ }
C {devices/lab_pin.sym} 1620 -27330 0 0 {name=p1254 lab=_58918_/X }
C {devices/lab_pin.sym} 1620 -27290 0 0 {name=p1255 lab=_59006_/Y }
C {devices/lab_pin.sym} 1620 -27250 0 0 {name=p1256 lab=_59008_/Y }
C {devices/lab_pin.sym} 1620 -27210 0 0 {name=p1257 lab=_58959_/X }
C {devices/lab_pin.sym} 1620 -27170 0 0 {name=p1258 lab=_58923_/X }
C {devices/lab_pin.sym} 1780 -27250 0 1 {name=p1259 lab=_59009_/X }
C {sky130_stdcells/o32a_4.sym} 1700 -27250 0 0 {name=X_59009_ }
C {devices/lab_pin.sym} 1660 -27090 0 0 {name=p1260 lab=_72881_/A }
C {devices/lab_pin.sym} 1740 -27090 0 1 {name=p1261 lab=_44235_/X }
C {sky130_stdcells/buf_2.sym} 1700 -27090 0 0 {name=X_44235_ }
C {devices/lab_pin.sym} 1640 -26980 0 0 {name=p1262 lab=_75062_/A }
C {devices/lab_pin.sym} 1640 -26940 0 0 {name=p1263 lab=_75062_/B }
C {devices/lab_pin.sym} 1760 -26960 0 1 {name=p1264 lab=_75055_/Y }
C {sky130_stdcells/xnor2_4.sym} 1700 -26960 0 0 {name=X_75055_ }
C {devices/lab_pin.sym} 1640 -26840 0 0 {name=p1265 lab=_79932_/A }
C {devices/lab_pin.sym} 1640 -26800 0 0 {name=p1266 lab=_79932_/B }
C {devices/lab_pin.sym} 1760 -26820 0 1 {name=p1267 lab=_79932_/Y }
C {sky130_stdcells/xnor2_4.sym} 1700 -26820 0 0 {name=X_79932_ }
C {devices/lab_pin.sym} 1660 -26690 0 0 {name=p1268 lab=_41446_/Y }
C {devices/lab_pin.sym} 1740 -26690 0 1 {name=p1269 lab=_41447_/X }
C {sky130_stdcells/buf_2.sym} 1700 -26690 0 0 {name=X_41447_ }
C {devices/lab_pin.sym} 1660 -26570 0 0 {name=p1270 lab=_60281_/A }
C {devices/lab_pin.sym} 1740 -26570 0 1 {name=p1271 lab=_60284_/A }
C {sky130_stdcells/inv_2.sym} 1700 -26570 0 0 {name=X_60281_ }
C {devices/lab_pin.sym} 1620 -26470 0 0 {name=p1272 lab=_72240_/X }
C {devices/lab_pin.sym} 1620 -26430 0 0 {name=p1273 lab=_85685_/Q }
C {devices/lab_pin.sym} 1620 -26390 0 0 {name=p1274 lab=_72241_/X }
C {devices/lab_pin.sym} 1780 -26430 0 1 {name=p1275 lab=_72267_/X }
C {sky130_stdcells/o21a_4.sym} 1700 -26430 0 0 {name=X_72267_ }
C {devices/lab_pin.sym} 1660 -26290 0 0 {name=p1276 lab=_61787_/X }
C {devices/lab_pin.sym} 1740 -26290 0 1 {name=p1277 lab=_62020_/X }
C {sky130_stdcells/buf_2.sym} 1700 -26290 0 0 {name=X_62020_ }
C {devices/lab_pin.sym} 1620 -26200 0 0 {name=p1278 lab=_41947_/Y }
C {devices/lab_pin.sym} 1620 -26160 0 0 {name=p1279 lab=_56182_/X }
C {devices/lab_pin.sym} 1620 -26120 0 0 {name=p1280 lab=_73962_/X }
C {devices/lab_pin.sym} 1620 -26080 0 0 {name=p1281 lab=_74005_/Y }
C {devices/lab_pin.sym} 1780 -26140 0 1 {name=p1282 lab=_74006_/X }
C {sky130_stdcells/a211o_4.sym} 1700 -26140 0 0 {name=X_74006_ }
C {devices/lab_pin.sym} 1620 -26010 0 0 {name=p1283 lab=_48628_/B }
C {devices/lab_pin.sym} 1620 -25970 0 0 {name=p1284 lab=_71216_/X }
C {devices/lab_pin.sym} 1620 -25930 0 0 {name=p1285 lab=_71217_/Y }
C {devices/lab_pin.sym} 1780 -25970 0 1 {name=p1286 lab=_71218_/Y }
C {sky130_stdcells/o21ai_4.sym} 1700 -25970 0 0 {name=X_71218_ }
C {devices/lab_pin.sym} 1640 -25860 0 0 {name=p1287 lab=_64619_/A }
C {devices/lab_pin.sym} 1640 -25820 0 0 {name=p1288 lab=_57736_/A }
C {devices/lab_pin.sym} 1640 -25780 0 0 {name=p1289 lab=_58834_/A }
C {devices/lab_pin.sym} 1640 -25740 0 0 {name=p1290 lab=_44265_/D }
C {devices/lab_pin.sym} 1760 -25800 0 1 {name=p1291 lab=_44166_/Y }
C {sky130_stdcells/nor4_4.sym} 1700 -25800 0 0 {name=X_44166_ }
C {devices/lab_pin.sym} 1640 -25660 0 0 {name=p1292 lab=_79863_/A }
C {devices/lab_pin.sym} 1640 -25620 0 0 {name=p1293 lab=_79863_/B }
C {devices/lab_pin.sym} 1760 -25640 0 1 {name=p1294 lab=_79864_/B }
C {sky130_stdcells/xor2_4.sym} 1700 -25640 0 0 {name=X_79863_ }
C {devices/lab_pin.sym} 1660 -25510 0 0 {name=p1295 lab=_41378_/A }
C {devices/lab_pin.sym} 1740 -25510 0 1 {name=p1296 lab=_41378_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -25510 0 0 {name=X_41378_ }
C {devices/lab_pin.sym} 1620 -25410 0 0 {name=p1297 lab=_72143_/X }
C {devices/lab_pin.sym} 1620 -25370 0 0 {name=p1298 lab=_85371_/Q }
C {devices/lab_pin.sym} 1620 -25330 0 0 {name=p1299 lab=_72197_/X }
C {devices/lab_pin.sym} 1780 -25370 0 1 {name=p1300 lab=_72198_/Y }
C {sky130_stdcells/o21ai_4.sym} 1700 -25370 0 0 {name=X_72198_ }
C {devices/lab_pin.sym} 1660 -25230 0 0 {name=p1301 lab=clkbuf_9_242_0_CLK/X }
C {devices/lab_pin.sym} 1740 -25230 0 1 {name=p1302 lab=_84797_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 1700 -25230 0 0 {name=Xclkbuf_10_485_0_CLK }
C {devices/lab_pin.sym} 1660 -25110 0 0 {name=p1303 lab=_87569_/Q }
C {devices/lab_pin.sym} 1740 -25110 0 1 {name=p1304 lab=_43117_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -25110 0 0 {name=X_43117_ }
C {devices/lab_pin.sym} 1640 -25000 0 0 {name=p1305 lab=_78814_/A }
C {devices/lab_pin.sym} 1640 -24960 0 0 {name=p1306 lab=_82547_/Q }
C {devices/lab_pin.sym} 1760 -24980 0 1 {name=p1307 lab=_79122_/B }
C {sky130_stdcells/nand2_4.sym} 1700 -24980 0 0 {name=X_78814_ }
C {devices/lab_pin.sym} 1640 -24860 0 0 {name=p1308 lab=_40402_/A }
C {devices/lab_pin.sym} 1640 -24820 0 0 {name=p1309 lab=_81184_/Q }
C {devices/lab_pin.sym} 1760 -24840 0 1 {name=p1310 lab=_40329_/X }
C {sky130_stdcells/or2_4.sym} 1700 -24840 0 0 {name=X_40329_ }
C {devices/lab_pin.sym} 1660 -24710 0 0 {name=p1311 lab=_70611_/X }
C {devices/lab_pin.sym} 1740 -24710 0 1 {name=p1312 lab=_71160_/D }
C {sky130_stdcells/buf_2.sym} 1700 -24710 0 0 {name=X_71149_ }
C {devices/lab_pin.sym} 1640 -24600 0 0 {name=p1313 lab=_48964_/A }
C {devices/lab_pin.sym} 1640 -24560 0 0 {name=p1314 lab=_52307_/B }
C {devices/lab_pin.sym} 1760 -24580 0 1 {name=p1315 lab=_48974_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -24580 0 0 {name=X_48974_ }
C {devices/lab_pin.sym} 1660 -24450 0 0 {name=p1316 lab=_44096_/X }
C {devices/lab_pin.sym} 1740 -24450 0 1 {name=p1317 lab=_44097_/X }
C {sky130_stdcells/buf_2.sym} 1700 -24450 0 0 {name=X_44097_ }
C {devices/lab_pin.sym} 1640 -24340 0 0 {name=p1318 lab=_79794_/A }
C {devices/lab_pin.sym} 1640 -24300 0 0 {name=p1319 lab=_79794_/B }
C {devices/lab_pin.sym} 1760 -24320 0 1 {name=p1320 lab=_79794_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -24320 0 0 {name=X_79794_ }
C {devices/lab_pin.sym} 1620 -24210 0 0 {name=p1321 lab=_66024_/B }
C {devices/lab_pin.sym} 1620 -24170 0 0 {name=p1322 lab=_47897_/X }
C {devices/lab_pin.sym} 1620 -24130 0 0 {name=p1323 lab=_47924_/Y }
C {devices/lab_pin.sym} 1780 -24170 0 1 {name=p1324 lab=_47925_/Y }
C {sky130_stdcells/o21ai_4.sym} 1700 -24170 0 0 {name=X_47925_ }
C {devices/lab_pin.sym} 1660 -24030 0 0 {name=p1325 lab=_87595_/Q }
C {devices/lab_pin.sym} 1740 -24030 0 1 {name=p1326 lab=_43048_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -24030 0 0 {name=X_43048_ }
C {devices/lab_pin.sym} 1660 -23910 0 0 {name=p1327 lab=_78745_/A }
C {devices/lab_pin.sym} 1740 -23910 0 1 {name=p1328 lab=_78745_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -23910 0 0 {name=X_78745_ }
C {devices/lab_pin.sym} 1640 -23820 0 0 {name=p1329 lab=_61954_/X }
C {devices/lab_pin.sym} 1640 -23780 0 0 {name=p1330 lab=_63955_/X }
C {devices/lab_pin.sym} 1640 -23740 0 0 {name=p1331 lab=_63905_/C }
C {devices/lab_pin.sym} 1640 -23700 0 0 {name=p1332 lab=_64033_/D }
C {devices/lab_pin.sym} 1760 -23760 0 1 {name=p1333 lab=_63971_/Y }
C {sky130_stdcells/nand4_4.sym} 1700 -23760 0 0 {name=X_63971_ }
C {devices/lab_pin.sym} 1640 -23620 0 0 {name=p1334 lab=_75957_/A }
C {devices/lab_pin.sym} 1640 -23580 0 0 {name=p1335 lab=_75957_/B }
C {devices/lab_pin.sym} 1760 -23600 0 1 {name=p1336 lab=_75957_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -23600 0 0 {name=X_75957_ }
C {devices/lab_pin.sym} 1640 -23480 0 0 {name=p1337 lab=_65710_/A }
C {devices/lab_pin.sym} 1640 -23440 0 0 {name=p1338 lab=_65710_/B }
C {devices/lab_pin.sym} 1760 -23460 0 1 {name=p1339 lab=_65710_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -23460 0 0 {name=X_65710_ }
C {devices/lab_pin.sym} 1620 -23350 0 0 {name=p1340 lab=_62920_/X }
C {devices/lab_pin.sym} 1620 -23310 0 0 {name=p1341 lab=_62893_/X }
C {devices/lab_pin.sym} 1620 -23270 0 0 {name=p1342 lab=_62921_/Y }
C {devices/lab_pin.sym} 1780 -23310 0 1 {name=p1343 lab=_84370_/D }
C {sky130_stdcells/a21oi_4.sym} 1700 -23310 0 0 {name=X_62922_ }
C {devices/lab_pin.sym} 1640 -23180 0 0 {name=p1344 lab=_81130_/D }
C {devices/lab_pin.sym} 1640 -23140 0 0 {name=p1345 lab=_80842_/Q }
C {devices/lab_pin.sym} 1760 -23160 0 1 {name=p1346 lab=_74908_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -23160 0 0 {name=X_74908_ }
C {devices/lab_pin.sym} 1620 -23050 0 0 {name=p1347 lab=_65935_/B }
C {devices/lab_pin.sym} 1620 -23010 0 0 {name=p1348 lab=_47840_/X }
C {devices/lab_pin.sym} 1620 -22970 0 0 {name=p1349 lab=_47855_/Y }
C {devices/lab_pin.sym} 1780 -23010 0 1 {name=p1350 lab=_47856_/Y }
C {sky130_stdcells/o21ai_4.sym} 1700 -23010 0 0 {name=X_47856_ }
C {devices/lab_pin.sym} 1620 -22900 0 0 {name=p1351 lab=_87950_/Q }
C {devices/lab_pin.sym} 1620 -22860 0 0 {name=p1352 lab=_66639_/X }
C {devices/lab_pin.sym} 1620 -22820 0 0 {name=p1353 lab=_66688_/X }
C {devices/lab_pin.sym} 1620 -22780 0 0 {name=p1354 lab=_66689_/X }
C {devices/lab_pin.sym} 1780 -22840 0 1 {name=p1355 lab=_66690_/X }
C {sky130_stdcells/a211o_4.sym} 1700 -22840 0 0 {name=X_66690_ }
C {devices/lab_pin.sym} 1640 -22700 0 0 {name=p1356 lab=_82522_/Q }
C {devices/lab_pin.sym} 1640 -22660 0 0 {name=p1357 lab=_82778_/D }
C {devices/lab_pin.sym} 1760 -22680 0 1 {name=p1358 lab=_78676_/X }
C {sky130_stdcells/xor2_4.sym} 1700 -22680 0 0 {name=X_78676_ }
C {devices/lab_pin.sym} 1640 -22560 0 0 {name=p1359 lab=_75888_/A }
C {devices/lab_pin.sym} 1640 -22520 0 0 {name=p1360 lab=_75580_/Y }
C {devices/lab_pin.sym} 1760 -22540 0 1 {name=p1361 lab=_75888_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -22540 0 0 {name=X_75888_ }
C {devices/lab_pin.sym} 1620 -22430 0 0 {name=p1362 lab=_86701_/Q }
C {devices/lab_pin.sym} 1620 -22390 0 0 {name=p1363 lab=_46767_/X }
C {devices/lab_pin.sym} 1620 -22350 0 0 {name=p1364 lab=_46806_/Y }
C {devices/lab_pin.sym} 1780 -22390 0 1 {name=p1365 lab=_46807_/Y }
C {sky130_stdcells/o21ai_4.sym} 1700 -22390 0 0 {name=X_46807_ }
C {devices/lab_pin.sym} 1620 -22280 0 0 {name=p1366 lab=_65638_/X }
C {devices/lab_pin.sym} 1620 -22240 0 0 {name=p1367 lab=_85587_/Q }
C {devices/lab_pin.sym} 1620 -22200 0 0 {name=p1368 lab=_65470_/X }
C {devices/lab_pin.sym} 1620 -22160 0 0 {name=p1369 lab=_65640_/X }
C {devices/lab_pin.sym} 1780 -22220 0 1 {name=p1370 lab=_65641_/X }
C {sky130_stdcells/a211o_4.sym} 1700 -22220 0 0 {name=X_65641_ }
C {devices/lab_pin.sym} 1640 -22080 0 0 {name=p1371 lab=_77627_/A }
C {devices/lab_pin.sym} 1640 -22040 0 0 {name=p1372 lab=_77626_/Y }
C {devices/lab_pin.sym} 1760 -22060 0 1 {name=p1373 lab=_82204_/D }
C {sky130_stdcells/xor2_4.sym} 1700 -22060 0 0 {name=X_77627_ }
C {devices/lab_pin.sym} 1640 -21950 0 0 {name=p1374 lab=_62894_/A }
C {devices/lab_pin.sym} 1640 -21910 0 0 {name=p1375 lab=_62852_/X }
C {devices/lab_pin.sym} 1640 -21870 0 0 {name=p1376 lab=_75907_/B }
C {devices/lab_pin.sym} 1760 -21910 0 1 {name=p1377 lab=_62853_/Y }
C {sky130_stdcells/nor3_4.sym} 1700 -21910 0 0 {name=X_62853_ }
C {devices/lab_pin.sym} 1640 -21780 0 0 {name=p1378 lab=_74844_/A }
C {devices/lab_pin.sym} 1640 -21740 0 0 {name=p1379 lab=_46121_/A }
C {devices/lab_pin.sym} 1760 -21760 0 1 {name=p1380 lab=_74839_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -21760 0 0 {name=X_74839_ }
C {devices/lab_pin.sym} 1660 -21630 0 0 {name=p1381 lab=_47787_/A }
C {devices/lab_pin.sym} 1740 -21630 0 1 {name=p1382 lab=_47788_/A }
C {sky130_stdcells/inv_2.sym} 1700 -21630 0 0 {name=X_47787_ }
C {devices/lab_pin.sym} 1620 -21530 0 0 {name=p1383 lab=_56303_/C }
C {devices/lab_pin.sym} 1620 -21490 0 0 {name=p1384 lab=_44979_/X }
C {devices/lab_pin.sym} 1620 -21450 0 0 {name=p1385 lab=_44926_/X }
C {devices/lab_pin.sym} 1780 -21490 0 1 {name=p1386 lab=_44999_/X }
C {sky130_stdcells/o21a_4.sym} 1700 -21490 0 0 {name=X_44999_ }
C {devices/lab_pin.sym} 1640 -21360 0 0 {name=p1387 lab=_49546_/A }
C {devices/lab_pin.sym} 1640 -21320 0 0 {name=p1388 lab=_46899_/X }
C {devices/lab_pin.sym} 1760 -21340 0 1 {name=p1389 lab=_49526_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -21340 0 0 {name=X_49526_ }
C {devices/lab_pin.sym} 1660 -21210 0 0 {name=p1390 lab=_59721_/X }
C {devices/lab_pin.sym} 1740 -21210 0 1 {name=p1391 lab=_61823_/A }
C {sky130_stdcells/buf_2.sym} 1700 -21210 0 0 {name=X_61804_ }
C {devices/lab_pin.sym} 1660 -21090 0 0 {name=p1392 lab=_65117_/A }
C {devices/lab_pin.sym} 1740 -21090 0 1 {name=p1393 lab=_68360_/X }
C {sky130_stdcells/buf_2.sym} 1700 -21090 0 0 {name=X_68360_ }
C {devices/lab_pin.sym} 1620 -20990 0 0 {name=p1394 lab=_46734_/Y }
C {devices/lab_pin.sym} 1620 -20950 0 0 {name=p1395 lab=_46704_/X }
C {devices/lab_pin.sym} 1620 -20910 0 0 {name=p1396 lab=_46737_/X }
C {devices/lab_pin.sym} 1780 -20950 0 1 {name=p1397 lab=_86709_/D }
C {sky130_stdcells/a21oi_4.sym} 1700 -20950 0 0 {name=X_46738_ }
C {devices/lab_pin.sym} 1620 -20830 0 0 {name=p1398 lab=_65516_/X }
C {devices/lab_pin.sym} 1620 -20790 0 0 {name=p1399 lab=_64855_/Y }
C {devices/lab_pin.sym} 1620 -20750 0 0 {name=p1400 lab=_65571_/Y }
C {devices/lab_pin.sym} 1780 -20790 0 1 {name=p1401 lab=_65572_/Y }
C {sky130_stdcells/o21ai_4.sym} 1700 -20790 0 0 {name=X_65572_ }
C {devices/lab_pin.sym} 1640 -20670 0 0 {name=p1402 lab=_77553_/X }
C {devices/lab_pin.sym} 1640 -20630 0 0 {name=p1403 lab=_77556_/Y }
C {devices/lab_pin.sym} 1640 -20590 0 0 {name=p1404 lab=_77558_/C }
C {devices/lab_pin.sym} 1760 -20630 0 1 {name=p1405 lab=_77559_/B }
C {sky130_stdcells/nand3_4.sym} 1700 -20630 0 0 {name=X_77558_ }
C {devices/lab_pin.sym} 1620 -20530 0 0 {name=p1406 lab=_57664_/X }
C {devices/lab_pin.sym} 1620 -20490 0 0 {name=p1407 lab=_62749_/X }
C {devices/lab_pin.sym} 1620 -20450 0 0 {name=p1408 lab=_62768_/X }
C {devices/lab_pin.sym} 1620 -20410 0 0 {name=p1409 lab=_62759_/X }
C {devices/lab_pin.sym} 1620 -20380 0 0 {name=p1410 lab=_62783_/X }
C {devices/lab_pin.sym} 1780 -20450 0 1 {name=p1411 lab=_62784_/Y }
C {sky130_stdcells/a41oi_4.sym} 1700 -20450 0 0 {name=X_62784_ }
C {devices/lab_pin.sym} 1660 -20290 0 0 {name=p1412 lab=_66953_/X }
C {devices/lab_pin.sym} 1740 -20290 0 1 {name=p1413 lab=_67311_/X }
C {sky130_stdcells/buf_2.sym} 1700 -20290 0 0 {name=X_67311_ }
C {devices/lab_pin.sym} 1660 -20170 0 0 {name=p1414 lab=clkbuf_9_211_0_CLK/X }
C {devices/lab_pin.sym} 1740 -20170 0 1 {name=p1415 lab=_82462_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 1700 -20170 0 0 {name=Xclkbuf_10_423_0_CLK }
C {devices/lab_pin.sym} 1640 -20080 0 0 {name=p1416 lab=_64234_/A }
C {devices/lab_pin.sym} 1640 -20040 0 0 {name=p1417 lab=_64523_/B }
C {devices/lab_pin.sym} 1640 -20000 0 0 {name=p1418 lab=_58201_/A }
C {devices/lab_pin.sym} 1640 -19960 0 0 {name=p1419 lab=_64523_/D }
C {devices/lab_pin.sym} 1760 -20020 0 1 {name=p1420 lab=_64523_/X }
C {sky130_stdcells/and4_4.sym} 1700 -20020 0 0 {name=X_64523_ }
C {devices/lab_pin.sym} 1620 -19890 0 0 {name=p1421 lab=_76510_/A }
C {devices/lab_pin.sym} 1620 -19850 0 0 {name=p1422 lab=_76510_/C }
C {devices/lab_pin.sym} 1620 -19810 0 0 {name=p1423 lab=_76510_/B }
C {devices/lab_pin.sym} 1780 -19850 0 1 {name=p1424 lab=_76509_/X }
C {sky130_stdcells/a21o_4.sym} 1700 -19850 0 0 {name=X_76509_ }
C {devices/lab_pin.sym} 1620 -19730 0 0 {name=p1425 lab=_49455_/Y }
C {devices/lab_pin.sym} 1620 -19690 0 0 {name=p1426 lab=_49434_/X }
C {devices/lab_pin.sym} 1620 -19650 0 0 {name=p1427 lab=_49456_/X }
C {devices/lab_pin.sym} 1780 -19690 0 1 {name=p1428 lab=_86384_/D }
C {sky130_stdcells/a21oi_4.sym} 1700 -19690 0 0 {name=X_49457_ }
C {devices/lab_pin.sym} 1660 -19550 0 0 {name=p1429 lab=_61704_/Y }
C {devices/lab_pin.sym} 1740 -19550 0 1 {name=p1430 lab=_61736_/A }
C {sky130_stdcells/buf_2.sym} 1700 -19550 0 0 {name=X_61735_ }
C {devices/lab_pin.sym} 1620 -19450 0 0 {name=p1431 lab=_67800_/X }
C {devices/lab_pin.sym} 1620 -19410 0 0 {name=p1432 lab=_67802_/X }
C {devices/lab_pin.sym} 1620 -19370 0 0 {name=p1433 lab=_68283_/X }
C {devices/lab_pin.sym} 1780 -19410 0 1 {name=p1434 lab=_68291_/Y }
C {sky130_stdcells/a21oi_4.sym} 1700 -19410 0 0 {name=X_68291_ }
C {devices/lab_pin.sym} 1660 -19270 0 0 {name=p1435 lab=_54298_/D }
C {devices/lab_pin.sym} 1740 -19270 0 1 {name=p1436 lab=_51777_/D }
C {sky130_stdcells/buf_2.sym} 1700 -19270 0 0 {name=X_46669_ }
C {devices/lab_pin.sym} 1660 -19150 0 0 {name=p1437 lab=_77488_/Y }
C {devices/lab_pin.sym} 1740 -19150 0 1 {name=p1438 lab=_77489_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -19150 0 0 {name=X_77489_ }
C {devices/lab_pin.sym} 1660 -19030 0 0 {name=p1439 lab=clkbuf_4_15_0_CLK/X }
C {devices/lab_pin.sym} 1740 -19030 0 1 {name=p1440 lab=clkbuf_5_30_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 1700 -19030 0 0 {name=Xclkbuf_4_15_1_CLK }
C {devices/lab_pin.sym} 1640 -18920 0 0 {name=p1441 lab=_48557_/A }
C {devices/lab_pin.sym} 1640 -18880 0 0 {name=p1442 lab=_52119_/B }
C {devices/lab_pin.sym} 1760 -18900 0 1 {name=p1443 lab=_48408_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -18900 0 0 {name=X_48408_ }
C {devices/lab_pin.sym} 1620 -18800 0 0 {name=p1444 lab=_87351_/Q }
C {devices/lab_pin.sym} 1620 -18760 0 0 {name=p1445 lab=_67239_/X }
C {devices/lab_pin.sym} 1620 -18720 0 0 {name=p1446 lab=_67240_/X }
C {devices/lab_pin.sym} 1620 -18680 0 0 {name=p1447 lab=_67241_/X }
C {devices/lab_pin.sym} 1780 -18740 0 1 {name=p1448 lab=_67242_/X }
C {sky130_stdcells/a211o_4.sym} 1700 -18740 0 0 {name=X_67242_ }
C {devices/lab_pin.sym} 1640 -18600 0 0 {name=p1449 lab=_84791_/Q }
C {devices/lab_pin.sym} 1640 -18560 0 0 {name=p1450 lab=_84111_/Q }
C {devices/lab_pin.sym} 1760 -18580 0 1 {name=p1451 lab=_79230_/A }
C {sky130_stdcells/or2_4.sym} 1700 -18580 0 0 {name=X_79228_ }
C {devices/lab_pin.sym} 1640 -18460 0 0 {name=p1452 lab=_64454_/A }
C {devices/lab_pin.sym} 1640 -18420 0 0 {name=p1453 lab=_64454_/B }
C {devices/lab_pin.sym} 1760 -18440 0 1 {name=p1454 lab=_64454_/Y }
C {sky130_stdcells/nor2_4.sym} 1700 -18440 0 0 {name=X_64454_ }
C {devices/lab_pin.sym} 1660 -18310 0 0 {name=p1455 lab=_49415_/A }
C {devices/lab_pin.sym} 1740 -18310 0 1 {name=p1456 lab=_49388_/X }
C {sky130_stdcells/buf_2.sym} 1700 -18310 0 0 {name=X_49388_ }
C {devices/lab_pin.sym} 1640 -18220 0 0 {name=p1457 lab=_61666_/A }
C {devices/lab_pin.sym} 1640 -18180 0 0 {name=p1458 lab=_61653_/X }
C {devices/lab_pin.sym} 1640 -18140 0 0 {name=p1459 lab=_61654_/X }
C {devices/lab_pin.sym} 1640 -18100 0 0 {name=p1460 lab=_61639_/X }
C {devices/lab_pin.sym} 1760 -18160 0 1 {name=p1461 lab=_61666_/Y }
C {sky130_stdcells/nand4_4.sym} 1700 -18160 0 0 {name=X_61666_ }
C {devices/lab_pin.sym} 1660 -18010 0 0 {name=p1462 lab=_62851_/A }
C {devices/lab_pin.sym} 1740 -18010 0 1 {name=p1463 lab=_63468_/A }
C {sky130_stdcells/buf_2.sym} 1700 -18010 0 0 {name=X_63405_ }
C {devices/lab_pin.sym} 1660 -17890 0 0 {name=p1464 lab=_61078_/B }
C {devices/lab_pin.sym} 1740 -17890 0 1 {name=p1465 lab=_61075_/B }
C {sky130_stdcells/buf_2.sym} 1700 -17890 0 0 {name=X_60617_ }
C {devices/lab_pin.sym} 1620 -17790 0 0 {name=p1466 lab=_48336_/Y }
C {devices/lab_pin.sym} 1620 -17750 0 0 {name=p1467 lab=_48322_/X }
C {devices/lab_pin.sym} 1620 -17710 0 0 {name=p1468 lab=_48338_/Y }
C {devices/lab_pin.sym} 1780 -17750 0 1 {name=p1469 lab=_48339_/Y }
C {sky130_stdcells/a21boi_4.sym} 1700 -17750 0 0 {name=X_48339_ }
C {devices/lab_pin.sym} 1640 -17620 0 0 {name=p1470 lab=_67149_/A }
C {devices/lab_pin.sym} 1640 -17580 0 0 {name=p1471 lab=_88186_/Q }
C {devices/lab_pin.sym} 1760 -17600 0 1 {name=p1472 lab=_67173_/X }
C {sky130_stdcells/and2_4.sym} 1700 -17600 0 0 {name=X_67173_ }
C {devices/lab_pin.sym} 1660 -17470 0 0 {name=p1473 lab=_79158_/B }
C {devices/lab_pin.sym} 1740 -17470 0 1 {name=p1474 lab=_79159_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -17470 0 0 {name=X_79159_ }
C {devices/lab_pin.sym} 1620 -17390 0 0 {name=p1475 lab=_64376_/X }
C {devices/lab_pin.sym} 1620 -17350 0 0 {name=p1476 lab=_64378_/X }
C {devices/lab_pin.sym} 1620 -17310 0 0 {name=p1477 lab=_64379_/X }
C {devices/lab_pin.sym} 1620 -17270 0 0 {name=p1478 lab=_64383_/Y }
C {devices/lab_pin.sym} 1620 -17230 0 0 {name=p1479 lab=_64384_/X }
C {devices/lab_pin.sym} 1780 -17310 0 1 {name=p1480 lab=_64385_/X }
C {sky130_stdcells/o41a_4.sym} 1700 -17310 0 0 {name=X_64385_ }
C {devices/lab_pin.sym} 1640 -17180 0 0 {name=p1481 lab=_61597_/A }
C {devices/lab_pin.sym} 1640 -17140 0 0 {name=p1482 lab=_61611_/B }
C {devices/lab_pin.sym} 1640 -17100 0 0 {name=p1483 lab=_61611_/C }
C {devices/lab_pin.sym} 1640 -17060 0 0 {name=p1484 lab=_61572_/D }
C {devices/lab_pin.sym} 1760 -17120 0 1 {name=p1485 lab=_61597_/Y }
C {sky130_stdcells/nand4_4.sym} 1700 -17120 0 0 {name=X_61597_ }
C {devices/lab_pin.sym} 1660 -16970 0 0 {name=p1486 lab=clkbuf_9_219_0_CLK/X }
C {devices/lab_pin.sym} 1740 -16970 0 1 {name=p1487 lab=_81227_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 1700 -16970 0 0 {name=Xclkbuf_10_438_0_CLK }
C {devices/lab_pin.sym} 1620 -16870 0 0 {name=p1488 lab=_66122_/Y }
C {devices/lab_pin.sym} 1620 -16830 0 0 {name=p1489 lab=_66065_/X }
C {devices/lab_pin.sym} 1620 -16790 0 0 {name=p1490 lab=_66123_/X }
C {devices/lab_pin.sym} 1780 -16830 0 1 {name=p1491 lab=_84155_/D }
C {sky130_stdcells/a21o_4.sym} 1700 -16830 0 0 {name=X_66124_ }
C {devices/lab_pin.sym} 1640 -16700 0 0 {name=p1492 lab=_51350_/A }
C {devices/lab_pin.sym} 1640 -16660 0 0 {name=p1493 lab=_51350_/B }
C {devices/lab_pin.sym} 1760 -16680 0 1 {name=p1494 lab=_51350_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -16680 0 0 {name=X_51350_ }
C {devices/lab_pin.sym} 1620 -16570 0 0 {name=p1495 lab=_63334_/Y }
C {devices/lab_pin.sym} 1620 -16530 0 0 {name=p1496 lab=_63335_/X }
C {devices/lab_pin.sym} 1620 -16490 0 0 {name=p1497 lab=_63317_/X }
C {devices/lab_pin.sym} 1780 -16530 0 1 {name=p1498 lab=_63336_/X }
C {sky130_stdcells/a21o_4.sym} 1700 -16530 0 0 {name=X_63336_ }
C {devices/lab_pin.sym} 1610 -16390 0 0 {name=p1499 lab=_84166_/CLK }
C {devices/lab_pin.sym} 1610 -16370 0 0 {name=p1500 lab=_84162_/Q }
C {devices/lab_pin.sym} 1790 -16390 0 1 {name=p1501 lab=_82170_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -16380 0 0 {name=X_82170_ }
C {devices/lab_pin.sym} 1620 -16290 0 0 {name=p1502 lab=_60413_/X }
C {devices/lab_pin.sym} 1620 -16250 0 0 {name=p1503 lab=_60455_/Y }
C {devices/lab_pin.sym} 1620 -16210 0 0 {name=p1504 lab=_60571_/B }
C {devices/lab_pin.sym} 1620 -16170 0 0 {name=p1505 lab=_60546_/Y }
C {devices/lab_pin.sym} 1620 -16140 0 0 {name=p1506 lab=_60547_/Y }
C {devices/lab_pin.sym} 1780 -16210 0 1 {name=p1507 lab=_60548_/Y }
C {sky130_stdcells/a41oi_4.sym} 1700 -16210 0 0 {name=X_60548_ }
C {devices/lab_pin.sym} 1620 -16070 0 0 {name=p1508 lab=_50298_/Y }
C {devices/lab_pin.sym} 1620 -16030 0 0 {name=p1509 lab=_50299_/X }
C {devices/lab_pin.sym} 1620 -15990 0 0 {name=p1510 lab=_50300_/Y }
C {devices/lab_pin.sym} 1780 -16030 0 1 {name=p1511 lab=_50301_/Y }
C {sky130_stdcells/a21boi_4.sym} 1700 -16030 0 0 {name=X_50301_ }
C {devices/lab_pin.sym} 1610 -15890 0 0 {name=p1512 lab=_81121_/CLK }
C {devices/lab_pin.sym} 1610 -15870 0 0 {name=p1513 lab=_79892_/Y }
C {devices/lab_pin.sym} 1790 -15890 0 1 {name=p1514 lab=_81121_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -15880 0 0 {name=X_81121_ }
C {devices/lab_pin.sym} 1640 -15760 0 0 {name=p1515 lab=_66054_/X }
C {devices/lab_pin.sym} 1640 -15720 0 0 {name=p1516 lab=_66055_/B }
C {devices/lab_pin.sym} 1760 -15740 0 1 {name=p1517 lab=_66055_/X }
C {sky130_stdcells/and2_4.sym} 1700 -15740 0 0 {name=X_66055_ }
C {devices/lab_pin.sym} 1620 -15630 0 0 {name=p1518 lab=_64860_/B }
C {devices/lab_pin.sym} 1620 -15590 0 0 {name=p1519 lab=_51259_/X }
C {devices/lab_pin.sym} 1620 -15550 0 0 {name=p1520 lab=_51280_/Y }
C {devices/lab_pin.sym} 1780 -15590 0 1 {name=p1521 lab=_51281_/Y }
C {sky130_stdcells/o21ai_4.sym} 1700 -15590 0 0 {name=X_51281_ }
C {devices/lab_pin.sym} 1640 -15480 0 0 {name=p1522 lab=_58459_/Y }
C {devices/lab_pin.sym} 1640 -15440 0 0 {name=p1523 lab=_63316_/B }
C {devices/lab_pin.sym} 1640 -15400 0 0 {name=p1524 lab=_63295_/C }
C {devices/lab_pin.sym} 1640 -15360 0 0 {name=p1525 lab=_63267_/D }
C {devices/lab_pin.sym} 1760 -15420 0 1 {name=p1526 lab=_63267_/X }
C {sky130_stdcells/or4_4.sym} 1700 -15420 0 0 {name=X_63267_ }
C {devices/lab_pin.sym} 1640 -15290 0 0 {name=p1527 lab=_60572_/A }
C {devices/lab_pin.sym} 1640 -15250 0 0 {name=p1528 lab=_60572_/B }
C {devices/lab_pin.sym} 1640 -15210 0 0 {name=p1529 lab=_60572_/C }
C {devices/lab_pin.sym} 1760 -15250 0 1 {name=p1530 lab=_60479_/Y }
C {sky130_stdcells/nand3_4.sym} 1700 -15250 0 0 {name=X_60479_ }
C {devices/lab_pin.sym} 1620 -15130 0 0 {name=p1531 lab=_53018_/Y }
C {devices/lab_pin.sym} 1620 -15090 0 0 {name=p1532 lab=_53001_/X }
C {devices/lab_pin.sym} 1620 -15050 0 0 {name=p1533 lab=_53019_/X }
C {devices/lab_pin.sym} 1780 -15090 0 1 {name=p1534 lab=_53020_/Y }
C {sky130_stdcells/a21oi_4.sym} 1700 -15090 0 0 {name=X_53020_ }
C {devices/lab_pin.sym} 1640 -14960 0 0 {name=p1535 lab=_65005_/X }
C {devices/lab_pin.sym} 1640 -14920 0 0 {name=p1536 lab=_86418_/Q }
C {devices/lab_pin.sym} 1760 -14940 0 1 {name=p1537 lab=_65006_/X }
C {sky130_stdcells/and2_4.sym} 1700 -14940 0 0 {name=X_65006_ }
C {devices/lab_pin.sym} 1640 -14820 0 0 {name=p1538 lab=_51737_/A }
C {devices/lab_pin.sym} 1640 -14780 0 0 {name=p1539 lab=_50232_/B }
C {devices/lab_pin.sym} 1760 -14800 0 1 {name=p1540 lab=_50232_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -14800 0 0 {name=X_50232_ }
C {devices/lab_pin.sym} 1660 -14670 0 0 {name=p1541 lab=_62218_/A }
C {devices/lab_pin.sym} 1740 -14670 0 1 {name=p1542 lab=_62618_/C }
C {sky130_stdcells/buf_2.sym} 1700 -14670 0 0 {name=X_62218_ }
C {devices/lab_pin.sym} 1610 -14550 0 0 {name=p1543 lab=_84276_/CLK }
C {devices/lab_pin.sym} 1610 -14530 0 0 {name=p1544 lab=_81052_/D }
C {devices/lab_pin.sym} 1790 -14550 0 1 {name=p1545 lab=_81052_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -14540 0 0 {name=X_81052_ }
C {devices/lab_pin.sym} 1640 -14440 0 0 {name=p1546 lab=_63198_/A }
C {devices/lab_pin.sym} 1640 -14400 0 0 {name=p1547 lab=_63170_/X }
C {devices/lab_pin.sym} 1640 -14360 0 0 {name=p1548 lab=_63161_/C }
C {devices/lab_pin.sym} 1640 -14320 0 0 {name=p1549 lab=_63149_/X }
C {devices/lab_pin.sym} 1760 -14380 0 1 {name=p1550 lab=_63198_/X }
C {sky130_stdcells/or4_4.sym} 1700 -14380 0 0 {name=X_63198_ }
C {devices/lab_pin.sym} 1640 -14240 0 0 {name=p1551 lab=_79997_/X }
C {devices/lab_pin.sym} 1640 -14200 0 0 {name=p1552 lab=_80003_/B }
C {devices/lab_pin.sym} 1760 -14220 0 1 {name=p1553 lab=_80003_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -14220 0 0 {name=X_80003_ }
C {devices/lab_pin.sym} 1660 -14090 0 0 {name=p1554 lab=_69814_/A }
C {devices/lab_pin.sym} 1740 -14090 0 1 {name=p1555 lab=_70012_/A }
C {sky130_stdcells/buf_2.sym} 1700 -14090 0 0 {name=X_69814_ }
C {devices/lab_pin.sym} 1660 -13970 0 0 {name=p1556 lab=_50064_/A }
C {devices/lab_pin.sym} 1740 -13970 0 1 {name=p1557 lab=_50169_/A }
C {sky130_stdcells/buf_2.sym} 1700 -13970 0 0 {name=X_50163_ }
C {devices/lab_pin.sym} 1640 -13880 0 0 {name=p1558 lab=_61665_/B }
C {devices/lab_pin.sym} 1640 -13840 0 0 {name=p1559 lab=_62149_/B }
C {devices/lab_pin.sym} 1640 -13800 0 0 {name=p1560 lab=_62149_/C }
C {devices/lab_pin.sym} 1640 -13760 0 0 {name=p1561 lab=_61749_/B }
C {devices/lab_pin.sym} 1760 -13820 0 1 {name=p1562 lab=_62153_/B }
C {sky130_stdcells/nand4_4.sym} 1700 -13820 0 0 {name=X_62149_ }
C {devices/lab_pin.sym} 1610 -13670 0 0 {name=p1563 lab=_85859_/CLK }
C {devices/lab_pin.sym} 1610 -13650 0 0 {name=p1564 lab=_85860_/D }
C {devices/lab_pin.sym} 1790 -13670 0 1 {name=p1565 lab=_85860_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -13660 0 0 {name=X_85860_ }
C {devices/lab_pin.sym} 1610 -13530 0 0 {name=p1566 lab=_85955_/CLK }
C {devices/lab_pin.sym} 1610 -13510 0 0 {name=p1567 lab=_84811_/D }
C {devices/lab_pin.sym} 1790 -13530 0 1 {name=p1568 lab=_84811_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -13520 0 0 {name=X_84811_ }
C {devices/lab_pin.sym} 1620 -13410 0 0 {name=p1569 lab=_83900_/Q }
C {devices/lab_pin.sym} 1620 -13370 0 0 {name=p1570 lab=_69696_/X }
C {devices/lab_pin.sym} 1620 -13330 0 0 {name=p1571 lab=_69744_/X }
C {devices/lab_pin.sym} 1780 -13370 0 1 {name=p1572 lab=_83900_/D }
C {sky130_stdcells/a21bo_4.sym} 1700 -13370 0 0 {name=X_69745_ }
C {devices/lab_pin.sym} 1620 -13250 0 0 {name=p1573 lab=_50091_/Y }
C {devices/lab_pin.sym} 1620 -13210 0 0 {name=p1574 lab=_50092_/X }
C {devices/lab_pin.sym} 1620 -13170 0 0 {name=p1575 lab=_50093_/X }
C {devices/lab_pin.sym} 1780 -13210 0 1 {name=p1576 lab=_50094_/Y }
C {sky130_stdcells/a21oi_4.sym} 1700 -13210 0 0 {name=X_50094_ }
C {devices/lab_pin.sym} 1660 -13070 0 0 {name=p1577 lab=_54253_/A }
C {devices/lab_pin.sym} 1740 -13070 0 1 {name=p1578 lab=_54971_/X }
C {sky130_stdcells/buf_2.sym} 1700 -13070 0 0 {name=X_54971_ }
C {devices/lab_pin.sym} 1620 -12980 0 0 {name=p1579 lab=_88387_/Q }
C {devices/lab_pin.sym} 1620 -12940 0 0 {name=p1580 lab=_66954_/X }
C {devices/lab_pin.sym} 1620 -12900 0 0 {name=p1581 lab=_66955_/X }
C {devices/lab_pin.sym} 1620 -12860 0 0 {name=p1582 lab=_66956_/X }
C {devices/lab_pin.sym} 1780 -12920 0 1 {name=p1583 lab=_66957_/X }
C {sky130_stdcells/a211o_4.sym} 1700 -12920 0 0 {name=X_66957_ }
C {devices/lab_pin.sym} 1610 -12770 0 0 {name=p1584 lab=_83685_/CLK }
C {devices/lab_pin.sym} 1610 -12750 0 0 {name=p1585 lab=_52589_/Y }
C {devices/lab_pin.sym} 1790 -12770 0 1 {name=p1586 lab=_85791_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -12760 0 0 {name=X_85791_ }
C {devices/lab_pin.sym} 1660 -12630 0 0 {name=p1587 lab=_56661_/C }
C {devices/lab_pin.sym} 1740 -12630 0 1 {name=p1588 lab=_56721_/D }
C {sky130_stdcells/buf_2.sym} 1700 -12630 0 0 {name=X_56710_ }
C {devices/lab_pin.sym} 1610 -12510 0 0 {name=p1589 lab=_87533_/CLK }
C {devices/lab_pin.sym} 1610 -12490 0 0 {name=p1590 lab=_43224_/X }
C {devices/lab_pin.sym} 1790 -12510 0 1 {name=p1591 lab=_87530_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -12500 0 0 {name=X_87530_ }
C {devices/lab_pin.sym} 1660 -12370 0 0 {name=p1592 lab=_53956_/A }
C {devices/lab_pin.sym} 1740 -12370 0 1 {name=p1593 lab=_53951_/A }
C {sky130_stdcells/buf_2.sym} 1700 -12370 0 0 {name=X_53922_ }
C {devices/lab_pin.sym} 1640 -12260 0 0 {name=p1594 lab=_65807_/A }
C {devices/lab_pin.sym} 1640 -12220 0 0 {name=p1595 lab=_65908_/B }
C {devices/lab_pin.sym} 1760 -12240 0 1 {name=p1596 lab=_65908_/X }
C {sky130_stdcells/and2_4.sym} 1700 -12240 0 0 {name=X_65908_ }
C {devices/lab_pin.sym} 1610 -12110 0 0 {name=p1597 lab=_83766_/CLK }
C {devices/lab_pin.sym} 1610 -12090 0 0 {name=p1598 lab=_84742_/D }
C {devices/lab_pin.sym} 1790 -12110 0 1 {name=p1599 lab=_84742_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -12100 0 0 {name=X_84742_ }
C {devices/lab_pin.sym} 1660 -11970 0 0 {name=p1600 lab=_58094_/A }
C {devices/lab_pin.sym} 1740 -11970 0 1 {name=p1601 lab=_57896_/A }
C {sky130_stdcells/buf_2.sym} 1700 -11970 0 0 {name=X_57690_ }
C {devices/lab_pin.sym} 1610 -11850 0 0 {name=p1602 lab=_81954_/CLK }
C {devices/lab_pin.sym} 1610 -11830 0 0 {name=p1603 lab=_83882_/Q }
C {devices/lab_pin.sym} 1790 -11850 0 1 {name=p1604 lab=_77872_/B }
C {sky130_stdcells/dfxtp_4.sym} 1700 -11840 0 0 {name=X_81954_ }
C {devices/lab_pin.sym} 1640 -11720 0 0 {name=p1605 lab=_69687_/A }
C {devices/lab_pin.sym} 1640 -11680 0 0 {name=p1606 lab=_69676_/B }
C {devices/lab_pin.sym} 1760 -11700 0 1 {name=p1607 lab=_69676_/Y }
C {sky130_stdcells/nor2_4.sym} 1700 -11700 0 0 {name=X_69676_ }
C {devices/lab_pin.sym} 1620 -11600 0 0 {name=p1608 lab=_87878_/Q }
C {devices/lab_pin.sym} 1620 -11560 0 0 {name=p1609 lab=_66816_/X }
C {devices/lab_pin.sym} 1620 -11520 0 0 {name=p1610 lab=_66794_/X }
C {devices/lab_pin.sym} 1620 -11480 0 0 {name=p1611 lab=_66887_/X }
C {devices/lab_pin.sym} 1780 -11540 0 1 {name=p1612 lab=_66888_/X }
C {sky130_stdcells/a211o_4.sym} 1700 -11540 0 0 {name=X_66888_ }
C {devices/lab_pin.sym} 1620 -11420 0 0 {name=p1613 lab=_56636_/X }
C {devices/lab_pin.sym} 1620 -11380 0 0 {name=p1614 lab=_56639_/X }
C {devices/lab_pin.sym} 1620 -11340 0 0 {name=p1615 lab=_85140_/Q }
C {devices/lab_pin.sym} 1620 -11300 0 0 {name=p1616 lab=_56753_/A }
C {devices/lab_pin.sym} 1780 -11360 0 1 {name=p1617 lab=_56641_/X }
C {sky130_stdcells/a2bb2o_4.sym} 1700 -11360 0 0 {name=X_56641_ }
C {devices/lab_pin.sym} 1610 -11210 0 0 {name=p1618 lab=_83932_/CLK }
C {devices/lab_pin.sym} 1610 -11190 0 0 {name=p1619 lab=_84081_/Q }
C {devices/lab_pin.sym} 1790 -11210 0 1 {name=p1620 lab=_75630_/A }
C {sky130_stdcells/dfxtp_4.sym} 1700 -11200 0 0 {name=X_80905_ }
C {devices/lab_pin.sym} 1640 -11080 0 0 {name=p1621 lab=_68604_/A }
C {devices/lab_pin.sym} 1640 -11040 0 0 {name=p1622 lab=_68627_/B }
C {devices/lab_pin.sym} 1760 -11060 0 1 {name=p1623 lab=_68627_/X }
C {sky130_stdcells/and2_4.sym} 1700 -11060 0 0 {name=X_68627_ }
C {devices/lab_pin.sym} 1610 -10930 0 0 {name=p1624 lab=_87149_/CLK }
C {devices/lab_pin.sym} 1610 -10910 0 0 {name=p1625 lab=_87461_/D }
C {devices/lab_pin.sym} 1790 -10930 0 1 {name=p1626 lab=_87461_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -10920 0 0 {name=X_87461_ }
C {devices/lab_pin.sym} 1620 -10810 0 0 {name=p1627 lab=_85555_/Q }
C {devices/lab_pin.sym} 1620 -10770 0 0 {name=p1628 lab=_53846_/X }
C {devices/lab_pin.sym} 1620 -10730 0 0 {name=p1629 lab=_53852_/Y }
C {devices/lab_pin.sym} 1780 -10770 0 1 {name=p1630 lab=_53853_/Y }
C {sky130_stdcells/o21ai_4.sym} 1700 -10770 0 0 {name=X_53853_ }
C {devices/lab_pin.sym} 1640 -10640 0 0 {name=p1631 lab=_65319_/A }
C {devices/lab_pin.sym} 1640 -10600 0 0 {name=p1632 lab=_86502_/Q }
C {devices/lab_pin.sym} 1760 -10620 0 1 {name=p1633 lab=_65839_/X }
C {sky130_stdcells/and2_4.sym} 1700 -10620 0 0 {name=X_65839_ }
C {devices/lab_pin.sym} 1610 -10490 0 0 {name=p1634 lab=_84671_/CLK }
C {devices/lab_pin.sym} 1610 -10470 0 0 {name=p1635 lab=_84673_/D }
C {devices/lab_pin.sym} 1790 -10490 0 1 {name=p1636 lab=_60032_/C }
C {sky130_stdcells/dfxtp_4.sym} 1700 -10480 0 0 {name=X_84673_ }
C {devices/lab_pin.sym} 1610 -10350 0 0 {name=p1637 lab=_81839_/CLK }
C {devices/lab_pin.sym} 1610 -10330 0 0 {name=p1638 lab=_78076_/X }
C {devices/lab_pin.sym} 1790 -10350 0 1 {name=p1639 lab=_81885_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -10340 0 0 {name=X_81885_ }
C {devices/lab_pin.sym} 1610 -10210 0 0 {name=p1640 lab=_86414_/CLK }
C {devices/lab_pin.sym} 1610 -10190 0 0 {name=p1641 lab=_49313_/Y }
C {devices/lab_pin.sym} 1790 -10210 0 1 {name=p1642 lab=_65152_/B }
C {sky130_stdcells/dfxtp_4.sym} 1700 -10200 0 0 {name=X_86412_ }
C {devices/lab_pin.sym} 1620 -10090 0 0 {name=p1643 lab=_85751_/Q }
C {devices/lab_pin.sym} 1620 -10050 0 0 {name=p1644 lab=_52792_/X }
C {devices/lab_pin.sym} 1620 -10010 0 0 {name=p1645 lab=_52803_/Y }
C {devices/lab_pin.sym} 1780 -10050 0 1 {name=p1646 lab=_52804_/Y }
C {sky130_stdcells/o21ai_4.sym} 1700 -10050 0 0 {name=X_52804_ }
C {devices/lab_pin.sym} 1640 -9920 0 0 {name=p1647 lab=_59238_/X }
C {devices/lab_pin.sym} 1640 -9880 0 0 {name=p1648 lab=_59360_/B }
C {devices/lab_pin.sym} 1760 -9900 0 1 {name=p1649 lab=_59360_/Y }
C {sky130_stdcells/nor2_4.sym} 1700 -9900 0 0 {name=X_59360_ }
C {devices/lab_pin.sym} 1610 -9770 0 0 {name=p1650 lab=_83310_/CLK }
C {devices/lab_pin.sym} 1610 -9750 0 0 {name=p1651 lab=_71053_/Y }
C {devices/lab_pin.sym} 1790 -9770 0 1 {name=p1652 lab=_83624_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -9760 0 0 {name=X_83624_ }
C {devices/lab_pin.sym} 1660 -9630 0 0 {name=p1653 lab=_56552_/Y }
C {devices/lab_pin.sym} 1740 -9630 0 1 {name=p1654 lab=_56572_/X }
C {sky130_stdcells/buf_2.sym} 1700 -9630 0 0 {name=X_56572_ }
C {devices/lab_pin.sym} 1610 -9510 0 0 {name=p1655 lab=_81125_/CLK }
C {devices/lab_pin.sym} 1610 -9490 0 0 {name=p1656 lab=_80868_/Q }
C {devices/lab_pin.sym} 1790 -9510 0 1 {name=p1657 lab=_74854_/B }
C {sky130_stdcells/dfxtp_4.sym} 1700 -9500 0 0 {name=X_80836_ }
C {devices/lab_pin.sym} 1660 -9370 0 0 {name=p1658 lab=_68429_/A }
C {devices/lab_pin.sym} 1740 -9370 0 1 {name=p1659 lab=_68558_/X }
C {sky130_stdcells/buf_2.sym} 1700 -9370 0 0 {name=X_68558_ }
C {devices/lab_pin.sym} 1610 -9250 0 0 {name=p1660 lab=_87646_/CLK }
C {devices/lab_pin.sym} 1610 -9230 0 0 {name=p1661 lab=_87392_/D }
C {devices/lab_pin.sym} 1790 -9250 0 1 {name=p1662 lab=_87392_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -9240 0 0 {name=X_87392_ }
C {devices/lab_pin.sym} 1660 -9110 0 0 {name=p1663 lab=_53729_/A }
C {devices/lab_pin.sym} 1740 -9110 0 1 {name=p1664 lab=_53784_/X }
C {sky130_stdcells/buf_2.sym} 1700 -9110 0 0 {name=X_53784_ }
C {devices/lab_pin.sym} 1640 -9020 0 0 {name=p1665 lab=_50973_/X }
C {devices/lab_pin.sym} 1640 -8980 0 0 {name=p1666 lab=_50985_/B }
C {devices/lab_pin.sym} 1640 -8940 0 0 {name=p1667 lab=_50985_/C }
C {devices/lab_pin.sym} 1640 -8900 0 0 {name=p1668 lab=_46810_/X }
C {devices/lab_pin.sym} 1760 -8960 0 1 {name=p1669 lab=_50996_/X }
C {sky130_stdcells/and4_4.sym} 1700 -8960 0 0 {name=X_50996_ }
C {devices/lab_pin.sym} 1660 -8810 0 0 {name=p1670 lab=_84881_/Q }
C {devices/lab_pin.sym} 1740 -8810 0 1 {name=p1671 lab=_58314_/A }
C {sky130_stdcells/inv_2.sym} 1700 -8810 0 0 {name=X_58311_ }
C {devices/lab_pin.sym} 1660 -8690 0 0 {name=p1672 lab=clkbuf_8_51_0_CLK/A }
C {devices/lab_pin.sym} 1740 -8690 0 1 {name=p1673 lab=clkbuf_8_50_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 1700 -8690 0 0 {name=Xclkbuf_8_50_0_CLK }
C {devices/lab_pin.sym} 1660 -8570 0 0 {name=p1674 lab=_55458_/X }
C {devices/lab_pin.sym} 1740 -8570 0 1 {name=p1675 lab=_55523_/X }
C {sky130_stdcells/buf_2.sym} 1700 -8570 0 0 {name=X_55523_ }
C {devices/lab_pin.sym} 1610 -8450 0 0 {name=p1676 lab=_82381_/CLK }
C {devices/lab_pin.sym} 1610 -8430 0 0 {name=p1677 lab=_86343_/D }
C {devices/lab_pin.sym} 1790 -8450 0 1 {name=p1678 lab=_86343_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -8440 0 0 {name=X_86343_ }
C {devices/lab_pin.sym} 1640 -8320 0 0 {name=p1679 lab=_67460_/A }
C {devices/lab_pin.sym} 1640 -8280 0 0 {name=p1680 lab=_87724_/Q }
C {devices/lab_pin.sym} 1760 -8300 0 1 {name=p1681 lab=_67509_/X }
C {sky130_stdcells/and2_4.sym} 1700 -8300 0 0 {name=X_67509_ }
C {devices/lab_pin.sym} 1640 -8200 0 0 {name=p1682 lab=_52729_/X }
C {devices/lab_pin.sym} 1640 -8160 0 0 {name=p1683 lab=_52724_/B }
C {devices/lab_pin.sym} 1640 -8120 0 0 {name=p1684 lab=_52746_/C }
C {devices/lab_pin.sym} 1640 -8080 0 0 {name=p1685 lab=_52735_/D }
C {devices/lab_pin.sym} 1760 -8140 0 1 {name=p1686 lab=_52735_/X }
C {sky130_stdcells/and4_4.sym} 1700 -8140 0 0 {name=X_52735_ }
C {devices/lab_pin.sym} 1660 -7990 0 0 {name=p1687 lab=_84753_/Q }
C {devices/lab_pin.sym} 1740 -7990 0 1 {name=p1688 lab=_59291_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -7990 0 0 {name=X_59291_ }
C {devices/lab_pin.sym} 1610 -7870 0 0 {name=p1689 lab=_83556_/CLK }
C {devices/lab_pin.sym} 1610 -7850 0 0 {name=p1690 lab=_83555_/D }
C {devices/lab_pin.sym} 1790 -7870 0 1 {name=p1691 lab=_47899_/A }
C {sky130_stdcells/dfxtp_4.sym} 1700 -7860 0 0 {name=X_83555_ }
C {devices/lab_pin.sym} 1610 -7730 0 0 {name=p1692 lab=_80740_/CLK }
C {devices/lab_pin.sym} 1610 -7710 0 0 {name=p1693 lab=_75535_/Y }
C {devices/lab_pin.sym} 1790 -7730 0 1 {name=p1694 lab=_81143_/D }
C {sky130_stdcells/dfxtp_4.sym} 1700 -7720 0 0 {name=X_80767_ }
C {devices/lab_pin.sym} 1620 -7610 0 0 {name=p1695 lab=_83973_/Q }
C {devices/lab_pin.sym} 1620 -7570 0 0 {name=p1696 lab=_68462_/X }
C {devices/lab_pin.sym} 1620 -7530 0 0 {name=p1697 lab=_68488_/X }
C {devices/lab_pin.sym} 1780 -7570 0 1 {name=p1698 lab=_83973_/D }
C {sky130_stdcells/a21bo_4.sym} 1700 -7570 0 0 {name=X_68489_ }
C {devices/lab_pin.sym} 1660 -7430 0 0 {name=p1699 lab=_70504_/A }
C {devices/lab_pin.sym} 1740 -7430 0 1 {name=p1700 lab=_70526_/A }
C {sky130_stdcells/buf_2.sym} 1700 -7430 0 0 {name=X_70520_ }
C {devices/lab_pin.sym} 1660 -7310 0 0 {name=p1701 lab=_44184_/X }
C {devices/lab_pin.sym} 1740 -7310 0 1 {name=p1702 lab=_58510_/A }
C {sky130_stdcells/buf_2.sym} 1700 -7310 0 0 {name=X_58242_ }
C {devices/lab_pin.sym} 1610 -7190 0 0 {name=p1703 lab=_82498_/CLK }
C {devices/lab_pin.sym} 1610 -7170 0 0 {name=p1704 lab=_82506_/D }
C {devices/lab_pin.sym} 1790 -7190 0 1 {name=p1705 lab=_82506_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -7180 0 0 {name=X_82506_ }
C {devices/lab_pin.sym} 1660 -7050 0 0 {name=p1706 lab=_55342_/X }
C {devices/lab_pin.sym} 1740 -7050 0 1 {name=p1707 lab=_55454_/X }
C {sky130_stdcells/buf_2.sym} 1700 -7050 0 0 {name=X_55454_ }
C {devices/lab_pin.sym} 1610 -6930 0 0 {name=p1708 lab=_85955_/CLK }
C {devices/lab_pin.sym} 1610 -6910 0 0 {name=p1709 lab=_86274_/D }
C {devices/lab_pin.sym} 1790 -6930 0 1 {name=p1710 lab=_72475_/B }
C {sky130_stdcells/dfxtp_4.sym} 1700 -6920 0 0 {name=X_86274_ }
C {devices/lab_pin.sym} 1620 -6810 0 0 {name=p1711 lab=_52664_/Y }
C {devices/lab_pin.sym} 1620 -6770 0 0 {name=p1712 lab=_52647_/X }
C {devices/lab_pin.sym} 1620 -6730 0 0 {name=p1713 lab=_52665_/X }
C {devices/lab_pin.sym} 1780 -6770 0 1 {name=p1714 lab=_52666_/Y }
C {sky130_stdcells/a21oi_4.sym} 1700 -6770 0 0 {name=X_52666_ }
C {devices/lab_pin.sym} 1640 -6640 0 0 {name=p1715 lab=_40829_/A }
C {devices/lab_pin.sym} 1640 -6600 0 0 {name=p1716 lab=_82864_/Q }
C {devices/lab_pin.sym} 1760 -6620 0 1 {name=p1717 lab=_40680_/X }
C {sky130_stdcells/or2_4.sym} 1700 -6620 0 0 {name=X_40680_ }
C {devices/lab_pin.sym} 1610 -6490 0 0 {name=p1718 lab=_83482_/CLK }
C {devices/lab_pin.sym} 1610 -6470 0 0 {name=p1719 lab=_83486_/D }
C {devices/lab_pin.sym} 1790 -6490 0 1 {name=p1720 lab=_83486_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -6480 0 0 {name=X_83486_ }
C {sky130_stdcells/decap_3.sym} 1700 -6320 0 0 {name=XPHY_702 }
C {devices/lab_pin.sym} 1610 -6170 0 0 {name=p1721 lab=_81048_/CLK }
C {devices/lab_pin.sym} 1610 -6150 0 0 {name=p1722 lab=_80730_/Q }
C {devices/lab_pin.sym} 1790 -6170 0 1 {name=p1723 lab=_75424_/A }
C {sky130_stdcells/dfxtp_4.sym} 1700 -6160 0 0 {name=X_80698_ }
C {sky130_stdcells/decap_3.sym} 1700 -6000 0 0 {name=XPHY_713 }
C {devices/lab_pin.sym} 1610 -5850 0 0 {name=p1724 lab=_87766_/CLK }
C {devices/lab_pin.sym} 1610 -5830 0 0 {name=p1725 lab=_42145_/X }
C {devices/lab_pin.sym} 1790 -5850 0 1 {name=p1726 lab=_88013_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -5840 0 0 {name=X_88013_ }
C {devices/lab_pin.sym} 1660 -5710 0 0 {name=p1727 lab=_54322_/A }
C {devices/lab_pin.sym} 1740 -5710 0 1 {name=p1728 lab=_54425_/A }
C {sky130_stdcells/buf_2.sym} 1700 -5710 0 0 {name=X_54405_ }
C {devices/lab_pin.sym} 1610 -5590 0 0 {name=p1729 lab=_85192_/CLK }
C {devices/lab_pin.sym} 1610 -5570 0 0 {name=p1730 lab=_56353_/Y }
C {devices/lab_pin.sym} 1790 -5590 0 1 {name=p1731 lab=_55764_/B }
C {sky130_stdcells/dfxtp_4.sym} 1700 -5580 0 0 {name=X_85225_ }
C {devices/lab_pin.sym} 1640 -5460 0 0 {name=p1732 lab=_51617_/A }
C {devices/lab_pin.sym} 1640 -5420 0 0 {name=p1733 lab=_53141_/B }
C {devices/lab_pin.sym} 1760 -5440 0 1 {name=p1734 lab=_51617_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -5440 0 0 {name=X_51617_ }
C {devices/lab_pin.sym} 1620 -5330 0 0 {name=p1735 lab=_50306_/B }
C {devices/lab_pin.sym} 1620 -5290 0 0 {name=p1736 lab=_70421_/Y }
C {devices/lab_pin.sym} 1620 -5250 0 0 {name=p1737 lab=_70450_/Y }
C {devices/lab_pin.sym} 1780 -5290 0 1 {name=p1738 lab=_70451_/Y }
C {sky130_stdcells/o21ai_4.sym} 1700 -5290 0 0 {name=X_70451_ }
C {devices/lab_pin.sym} 1660 -5150 0 0 {name=p1739 lab=_63081_/A }
C {devices/lab_pin.sym} 1740 -5150 0 1 {name=p1740 lab=_64282_/A }
C {sky130_stdcells/buf_2.sym} 1700 -5150 0 0 {name=X_58173_ }
C {devices/lab_pin.sym} 1610 -5030 0 0 {name=p1741 lab=_82443_/CLK }
C {devices/lab_pin.sym} 1610 -5010 0 0 {name=p1742 lab=_82437_/D }
C {devices/lab_pin.sym} 1790 -5030 0 1 {name=p1743 lab=_82437_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -5020 0 0 {name=X_82437_ }
C {devices/lab_pin.sym} 1620 -4910 0 0 {name=p1744 lab=_55384_/Y }
C {devices/lab_pin.sym} 1620 -4870 0 0 {name=p1745 lab=_55375_/Y }
C {devices/lab_pin.sym} 1620 -4830 0 0 {name=p1746 lab=_55382_/A }
C {devices/lab_pin.sym} 1780 -4870 0 1 {name=p1747 lab=_56719_/B }
C {sky130_stdcells/o21ai_4.sym} 1700 -4870 0 0 {name=X_55385_ }
C {devices/lab_pin.sym} 1620 -4750 0 0 {name=p1748 lab=_85789_/Q }
C {devices/lab_pin.sym} 1620 -4710 0 0 {name=p1749 lab=_52575_/X }
C {devices/lab_pin.sym} 1620 -4670 0 0 {name=p1750 lab=_52596_/Y }
C {devices/lab_pin.sym} 1780 -4710 0 1 {name=p1751 lab=_52597_/Y }
C {sky130_stdcells/o21ai_4.sym} 1700 -4710 0 0 {name=X_52597_ }
C {devices/lab_pin.sym} 1660 -4570 0 0 {name=p1752 lab=clkbuf_8_65_0_CLK/A }
C {devices/lab_pin.sym} 1740 -4570 0 1 {name=p1753 lab=clkbuf_8_65_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 1700 -4570 0 0 {name=Xclkbuf_8_65_0_CLK }
C {devices/lab_pin.sym} 1620 -4480 0 0 {name=p1754 lab=_56972_/Y }
C {devices/lab_pin.sym} 1620 -4440 0 0 {name=p1755 lab=_56664_/Y }
C {devices/lab_pin.sym} 1620 -4400 0 0 {name=p1756 lab=_57221_/A }
C {devices/lab_pin.sym} 1620 -4360 0 0 {name=p1757 lab=_57123_/Y }
C {devices/lab_pin.sym} 1780 -4420 0 1 {name=p1758 lab=_57124_/X }
C {sky130_stdcells/a211o_4.sym} 1700 -4420 0 0 {name=X_57124_ }
C {devices/lab_pin.sym} 1660 -4270 0 0 {name=p1759 lab=_42417_/A }
C {devices/lab_pin.sym} 1740 -4270 0 1 {name=p1760 lab=_42350_/X }
C {sky130_stdcells/buf_2.sym} 1700 -4270 0 0 {name=X_42350_ }
C {devices/lab_pin.sym} 1640 -4160 0 0 {name=p1761 lab=_54332_/A }
C {devices/lab_pin.sym} 1640 -4120 0 0 {name=p1762 lab=_52645_/B }
C {devices/lab_pin.sym} 1760 -4140 0 1 {name=p1763 lab=_54336_/Y }
C {sky130_stdcells/nand2_4.sym} 1700 -4140 0 0 {name=X_54336_ }
C {devices/lab_pin.sym} 1640 -4020 0 0 {name=p1764 lab=_73156_/Y }
C {devices/lab_pin.sym} 1640 -3980 0 0 {name=p1765 lab=_73169_/X }
C {devices/lab_pin.sym} 1760 -4000 0 1 {name=p1766 lab=_73170_/Y }
C {sky130_stdcells/xnor2_4.sym} 1700 -4000 0 0 {name=X_73170_ }
C {devices/lab_pin.sym} 1610 -3870 0 0 {name=p1767 lab=_85156_/CLK }
C {devices/lab_pin.sym} 1610 -3850 0 0 {name=p1768 lab=_56541_/Y }
C {devices/lab_pin.sym} 1790 -3870 0 1 {name=p1769 lab=_55724_/B }
C {sky130_stdcells/dfxtp_4.sym} 1700 -3860 0 0 {name=X_85156_ }
C {devices/lab_pin.sym} 1640 -3760 0 0 {name=p1770 lab=_51553_/A }
C {devices/lab_pin.sym} 1640 -3720 0 0 {name=p1771 lab=_51553_/B }
C {devices/lab_pin.sym} 1640 -3680 0 0 {name=p1772 lab=_51533_/C }
C {devices/lab_pin.sym} 1640 -3640 0 0 {name=p1773 lab=_53074_/D }
C {devices/lab_pin.sym} 1760 -3700 0 1 {name=p1774 lab=_51548_/X }
C {sky130_stdcells/and4_4.sym} 1700 -3700 0 0 {name=X_51548_ }
C {devices/lab_pin.sym} 1660 -3550 0 0 {name=p1775 lab=_70382_/A }
C {devices/lab_pin.sym} 1740 -3550 0 1 {name=p1776 lab=_70994_/A }
C {sky130_stdcells/buf_2.sym} 1700 -3550 0 0 {name=X_70382_ }
C {devices/lab_pin.sym} 1610 -3430 0 0 {name=p1777 lab=_82368_/CLK }
C {devices/lab_pin.sym} 1610 -3410 0 0 {name=p1778 lab=_82368_/D }
C {devices/lab_pin.sym} 1790 -3430 0 1 {name=p1779 lab=_82368_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -3420 0 0 {name=X_82368_ }
C {devices/lab_pin.sym} 1620 -3310 0 0 {name=p1780 lab=_41290_/X }
C {devices/lab_pin.sym} 1620 -3270 0 0 {name=p1781 lab=_82910_/Q }
C {devices/lab_pin.sym} 1620 -3230 0 0 {name=p1782 lab=_41300_/X }
C {devices/lab_pin.sym} 1780 -3270 0 1 {name=p1783 lab=_41301_/Y }
C {sky130_stdcells/o21ai_4.sym} 1700 -3270 0 0 {name=X_41301_ }
C {devices/lab_pin.sym} 1620 -3150 0 0 {name=p1784 lab=_59346_/X }
C {devices/lab_pin.sym} 1620 -3110 0 0 {name=p1785 lab=_85345_/Q }
C {devices/lab_pin.sym} 1620 -3070 0 0 {name=p1786 lab=_72120_/X }
C {devices/lab_pin.sym} 1780 -3110 0 1 {name=p1787 lab=_72121_/X }
C {sky130_stdcells/o21a_4.sym} 1700 -3110 0 0 {name=X_72121_ }
C {devices/lab_pin.sym} 1610 -2970 0 0 {name=p1788 lab=_82425_/CLK }
C {devices/lab_pin.sym} 1610 -2950 0 0 {name=p1789 lab=_84107_/D }
C {devices/lab_pin.sym} 1790 -2970 0 1 {name=p1790 lab=_82723_/D }
C {sky130_stdcells/dfxtp_4.sym} 1700 -2960 0 0 {name=X_84107_ }
C {devices/lab_pin.sym} 1640 -2850 0 0 {name=p1791 lab=_57055_/A }
C {devices/lab_pin.sym} 1640 -2810 0 0 {name=p1792 lab=_56849_/X }
C {devices/lab_pin.sym} 1640 -2770 0 0 {name=p1793 lab=_56985_/D }
C {devices/lab_pin.sym} 1760 -2810 0 1 {name=p1794 lab=_57055_/Y }
C {sky130_stdcells/nor3_4.sym} 1700 -2810 0 0 {name=X_57055_ }
C {devices/lab_pin.sym} 1610 -2670 0 0 {name=p1795 lab=_84079_/CLK }
C {devices/lab_pin.sym} 1610 -2650 0 0 {name=p1796 lab=_76226_/X }
C {devices/lab_pin.sym} 1790 -2670 0 1 {name=p1797 lab=_81727_/D }
C {sky130_stdcells/dfxtp_4.sym} 1700 -2660 0 0 {name=X_81319_ }
C {devices/lab_pin.sym} 1660 -2530 0 0 {name=p1798 lab=_54295_/A }
C {devices/lab_pin.sym} 1740 -2530 0 1 {name=p1799 lab=_54288_/A }
C {sky130_stdcells/buf_2.sym} 1700 -2530 0 0 {name=X_54267_ }
C {devices/lab_pin.sym} 1660 -2410 0 0 {name=p1800 lab=_42281_/A }
C {devices/lab_pin.sym} 1740 -2410 0 1 {name=p1801 lab=_42281_/Y }
C {sky130_stdcells/inv_2.sym} 1700 -2410 0 0 {name=X_42281_ }
C {devices/lab_pin.sym} 1610 -2290 0 0 {name=p1802 lab=_85152_/CLK }
C {devices/lab_pin.sym} 1610 -2270 0 0 {name=p1803 lab=_57101_/X }
C {devices/lab_pin.sym} 1790 -2290 0 1 {name=p1804 lab=_45422_/A }
C {sky130_stdcells/dfxtp_4.sym} 1700 -2280 0 0 {name=X_85087_ }
C {devices/lab_pin.sym} 1640 -2180 0 0 {name=p1805 lab=_51473_/A }
C {devices/lab_pin.sym} 1640 -2140 0 0 {name=p1806 lab=_51494_/B }
C {devices/lab_pin.sym} 1640 -2100 0 0 {name=p1807 lab=_51494_/C }
C {devices/lab_pin.sym} 1640 -2060 0 0 {name=p1808 lab=_53003_/D }
C {devices/lab_pin.sym} 1760 -2120 0 1 {name=p1809 lab=_51479_/X }
C {sky130_stdcells/and4_4.sym} 1700 -2120 0 0 {name=X_51479_ }
C {devices/lab_pin.sym} 1610 -1970 0 0 {name=p1810 lab=_82299_/CLK }
C {devices/lab_pin.sym} 1610 -1950 0 0 {name=p1811 lab=_82299_/D }
C {devices/lab_pin.sym} 1790 -1970 0 1 {name=p1812 lab=_82299_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1700 -1960 0 0 {name=X_82299_ }
C {devices/lab_pin.sym} 1660 -1830 0 0 {name=p1813 lab=_44020_/A }
C {devices/lab_pin.sym} 1740 -1830 0 1 {name=p1814 lab=_64717_/A }
C {sky130_stdcells/buf_2.sym} 1700 -1830 0 0 {name=X_44020_ }
C {devices/lab_pin.sym} 1660 -1710 0 0 {name=p1815 lab=_45765_/A }
C {devices/lab_pin.sym} 1740 -1710 0 1 {name=p1816 lab=_56017_/B }
C {sky130_stdcells/buf_2.sym} 1700 -1710 0 0 {name=X_56006_ }
C {devices/lab_pin.sym} 1640 -1600 0 0 {name=p1817 lab=_41062_/B }
C {devices/lab_pin.sym} 1640 -1560 0 0 {name=p1818 lab=_41223_/B }
C {devices/lab_pin.sym} 1760 -1580 0 1 {name=p1819 lab=_41232_/X }
C {sky130_stdcells/or2_4.sym} 1700 -1580 0 0 {name=X_41232_ }
C {devices/lab_pin.sym} 1620 -1470 0 0 {name=p1820 lab=_53214_/Y }
C {devices/lab_pin.sym} 1620 -1430 0 0 {name=p1821 lab=_53215_/X }
C {devices/lab_pin.sym} 1620 -1390 0 0 {name=p1822 lab=_53217_/X }
C {devices/lab_pin.sym} 1780 -1430 0 1 {name=p1823 lab=_53218_/Y }
C {sky130_stdcells/a21oi_4.sym} 1700 -1430 0 0 {name=X_53218_ }
C {devices/lab_pin.sym} 1660 -1290 0 0 {name=p1824 lab=_72052_/A }
C {devices/lab_pin.sym} 1740 -1290 0 1 {name=p1825 lab=_72053_/A }
C {sky130_stdcells/buf_2.sym} 1700 -1290 0 0 {name=X_72052_ }
C {devices/lab_pin.sym} 1610 -1170 0 0 {name=p1826 lab=_81160_/CLK }
C {devices/lab_pin.sym} 1610 -1150 0 0 {name=p1827 lab=_84038_/D }
C {devices/lab_pin.sym} 1790 -1170 0 1 {name=p1828 lab=_82078_/D }
C {sky130_stdcells/dfxtp_4.sym} 1700 -1160 0 0 {name=X_84038_ }
C {devices/lab_pin.sym} 1660 -1030 0 0 {name=p1829 lab=_54254_/A }
C {devices/lab_pin.sym} 1740 -1030 0 1 {name=p1830 lab=_54209_/C }
C {sky130_stdcells/buf_2.sym} 1700 -1030 0 0 {name=X_54198_ }
C {devices/lab_pin.sym} 1660 -910 0 0 {name=p1831 lab=_71003_/A }
C {devices/lab_pin.sym} 1740 -910 0 1 {name=p1832 lab=_71071_/A }
C {sky130_stdcells/buf_2.sym} 1700 -910 0 0 {name=X_71003_ }
C {devices/lab_pin.sym} 1640 -800 0 0 {name=p1833 lab=_40984_/B }
C {devices/lab_pin.sym} 1640 -760 0 0 {name=p1834 lab=_41145_/B }
C {devices/lab_pin.sym} 1760 -780 0 1 {name=p1835 lab=_41163_/X }
C {sky130_stdcells/or2_4.sym} 1700 -780 0 0 {name=X_41163_ }
C {devices/lab_pin.sym} 2540 -42170 0 0 {name=p1836 lab=_85688_/Q }
C {devices/lab_pin.sym} 2540 -42130 0 0 {name=p1837 lab=_53146_/X }
C {devices/lab_pin.sym} 2540 -42090 0 0 {name=p1838 lab=_53148_/Y }
C {devices/lab_pin.sym} 2700 -42130 0 1 {name=p1839 lab=_53149_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -42130 0 0 {name=X_53149_ }
C {devices/lab_pin.sym} 2560 -42000 0 0 {name=p1840 lab=_76854_/A }
C {devices/lab_pin.sym} 2560 -41960 0 0 {name=p1841 lab=_76854_/B }
C {devices/lab_pin.sym} 2680 -41980 0 1 {name=p1842 lab=_76860_/Y }
C {sky130_stdcells/nor2_4.sym} 2620 -41980 0 0 {name=X_76860_ }
C {devices/lab_pin.sym} 2560 -41860 0 0 {name=p1843 lab=_75811_/A }
C {devices/lab_pin.sym} 2560 -41820 0 0 {name=p1844 lab=_75810_/Y }
C {devices/lab_pin.sym} 2680 -41840 0 1 {name=p1845 lab=_75811_/X }
C {sky130_stdcells/and2_4.sym} 2620 -41840 0 0 {name=X_75811_ }
C {devices/lab_pin.sym} 2540 -41750 0 0 {name=p1846 lab=_44857_/X }
C {devices/lab_pin.sym} 2540 -41710 0 0 {name=p1847 lab=_44865_/X }
C {devices/lab_pin.sym} 2540 -41670 0 0 {name=p1848 lab=_40394_/X }
C {devices/lab_pin.sym} 2540 -41630 0 0 {name=p1849 lab=_66700_/B }
C {devices/lab_pin.sym} 2540 -41590 0 0 {name=p1850 lab=_44858_/X }
C {devices/lab_pin.sym} 2700 -41670 0 1 {name=p1851 lab=_45971_/Y }
C {sky130_stdcells/o32ai_4.sym} 2620 -41670 0 0 {name=X_45971_ }
C {devices/lab_pin.sym} 2540 -41540 0 0 {name=p1852 lab=_41093_/X }
C {devices/lab_pin.sym} 2540 -41500 0 0 {name=p1853 lab=_41065_/X }
C {devices/lab_pin.sym} 2540 -41460 0 0 {name=p1854 lab=_69526_/B }
C {devices/lab_pin.sym} 2540 -41420 0 0 {name=p1855 lab=_41066_/X }
C {devices/lab_pin.sym} 2700 -41480 0 1 {name=p1856 lab=_41094_/X }
C {sky130_stdcells/a2bb2o_4.sym} 2620 -41480 0 0 {name=X_41094_ }
C {devices/lab_pin.sym} 2540 -41360 0 0 {name=p1857 lab=_57944_/Y }
C {devices/lab_pin.sym} 2540 -41320 0 0 {name=p1858 lab=_57758_/X }
C {devices/lab_pin.sym} 2540 -41280 0 0 {name=p1859 lab=_57951_/X }
C {devices/lab_pin.sym} 2540 -41240 0 0 {name=p1860 lab=_57956_/X }
C {devices/lab_pin.sym} 2700 -41300 0 1 {name=p1861 lab=_84937_/D }
C {sky130_stdcells/a22oi_4.sym} 2620 -41300 0 0 {name=X_57957_ }
C {devices/lab_pin.sym} 2580 -41150 0 0 {name=p1862 lab=_81490_/Q }
C {devices/lab_pin.sym} 2660 -41150 0 1 {name=p1863 lab=_76806_/A }
C {sky130_stdcells/inv_2.sym} 2620 -41150 0 0 {name=X_76791_ }
C {devices/lab_pin.sym} 2530 -41030 0 0 {name=p1864 lab=_85990_/CLK }
C {devices/lab_pin.sym} 2530 -41010 0 0 {name=p1865 lab=_85989_/D }
C {devices/lab_pin.sym} 2710 -41030 0 1 {name=p1866 lab=_85989_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -41020 0 0 {name=X_85989_ }
C {devices/lab_pin.sym} 2580 -40890 0 0 {name=p1867 lab=_47710_/A }
C {devices/lab_pin.sym} 2660 -40890 0 1 {name=p1868 lab=_53203_/D }
C {sky130_stdcells/buf_2.sym} 2620 -40890 0 0 {name=X_47710_ }
C {devices/lab_pin.sym} 2540 -40790 0 0 {name=p1869 lab=_78519_/A }
C {devices/lab_pin.sym} 2540 -40750 0 0 {name=p1870 lab=_78519_/B }
C {devices/lab_pin.sym} 2540 -40710 0 0 {name=p1871 lab=_78510_/Y }
C {devices/lab_pin.sym} 2700 -40750 0 1 {name=p1872 lab=_78530_/X }
C {sky130_stdcells/o21a_4.sym} 2620 -40750 0 0 {name=X_78530_ }
C {devices/lab_pin.sym} 2580 -40610 0 0 {name=p1873 lab=_64223_/B }
C {devices/lab_pin.sym} 2660 -40610 0 1 {name=p1874 lab=_61329_/B }
C {sky130_stdcells/buf_2.sym} 2620 -40610 0 0 {name=X_44922_ }
C {devices/lab_pin.sym} 2560 -40500 0 0 {name=p1875 lab=_56908_/A }
C {devices/lab_pin.sym} 2560 -40460 0 0 {name=p1876 lab=_56907_/X }
C {devices/lab_pin.sym} 2680 -40480 0 1 {name=p1877 lab=_56908_/X }
C {sky130_stdcells/xor2_4.sym} 2620 -40480 0 0 {name=X_56908_ }
C {devices/lab_pin.sym} 2530 -40350 0 0 {name=p1878 lab=_87472_/CLK }
C {devices/lab_pin.sym} 2530 -40330 0 0 {name=p1879 lab=_87728_/D }
C {devices/lab_pin.sym} 2710 -40350 0 1 {name=p1880 lab=_67406_/B }
C {sky130_stdcells/dfxtp_4.sym} 2620 -40340 0 0 {name=X_87728_ }
C {devices/lab_pin.sym} 2580 -40210 0 0 {name=p1881 lab=_80917_/Q }
C {devices/lab_pin.sym} 2660 -40210 0 1 {name=p1882 lab=_75742_/Y }
C {sky130_stdcells/inv_2.sym} 2620 -40210 0 0 {name=X_75742_ }
C {devices/lab_pin.sym} 2580 -40090 0 0 {name=p1883 lab=_48635_/A }
C {devices/lab_pin.sym} 2660 -40090 0 1 {name=p1884 lab=_48894_/B }
C {sky130_stdcells/buf_2.sym} 2620 -40090 0 0 {name=X_48690_ }
C {devices/lab_pin.sym} 2540 -39990 0 0 {name=p1885 lab=_44535_/Y }
C {devices/lab_pin.sym} 2540 -39950 0 0 {name=p1886 lab=_72775_/X }
C {devices/lab_pin.sym} 2540 -39910 0 0 {name=p1887 lab=_72953_/Y }
C {devices/lab_pin.sym} 2700 -39950 0 1 {name=p1888 lab=_72969_/C }
C {sky130_stdcells/a21o_4.sym} 2620 -39950 0 0 {name=X_72954_ }
C {devices/lab_pin.sym} 2540 -39830 0 0 {name=p1889 lab=_72476_/B }
C {devices/lab_pin.sym} 2540 -39790 0 0 {name=p1890 lab=_86006_/Q }
C {devices/lab_pin.sym} 2540 -39750 0 0 {name=p1891 lab=_57887_/X }
C {devices/lab_pin.sym} 2700 -39790 0 1 {name=p1892 lab=_57888_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -39790 0 0 {name=X_57888_ }
C {devices/lab_pin.sym} 2560 -39660 0 0 {name=p1893 lab=_47649_/A }
C {devices/lab_pin.sym} 2560 -39620 0 0 {name=p1894 lab=_53161_/B }
C {devices/lab_pin.sym} 2680 -39640 0 1 {name=p1895 lab=_47641_/Y }
C {sky130_stdcells/nand2_4.sym} 2620 -39640 0 0 {name=X_47641_ }
C {devices/lab_pin.sym} 2560 -39540 0 0 {name=p1896 lab=_74527_/A }
C {devices/lab_pin.sym} 2560 -39500 0 0 {name=p1897 lab=_71893_/X }
C {devices/lab_pin.sym} 2560 -39460 0 0 {name=p1898 lab=_71902_/X }
C {devices/lab_pin.sym} 2560 -39420 0 0 {name=p1899 lab=_71898_/D }
C {devices/lab_pin.sym} 2680 -39480 0 1 {name=p1900 lab=_71905_/Y }
C {sky130_stdcells/nand4_4.sym} 2620 -39480 0 0 {name=X_71905_ }
C {devices/lab_pin.sym} 2580 -39330 0 0 {name=p1901 lab=_61755_/A }
C {devices/lab_pin.sym} 2660 -39330 0 1 {name=p1902 lab=_59628_/A }
C {sky130_stdcells/buf_2.sym} 2620 -39330 0 0 {name=X_59627_ }
C {devices/lab_pin.sym} 2560 -39230 0 0 {name=p1903 lab=_78461_/A }
C {devices/lab_pin.sym} 2560 -39190 0 0 {name=p1904 lab=_78458_/Y }
C {devices/lab_pin.sym} 2560 -39150 0 0 {name=p1905 lab=_78460_/Y }
C {devices/lab_pin.sym} 2680 -39190 0 1 {name=p1906 lab=_78463_/A }
C {sky130_stdcells/or3_4.sym} 2620 -39190 0 0 {name=X_78461_ }
C {devices/lab_pin.sym} 2580 -39050 0 0 {name=p1907 lab=_44852_/Y }
C {devices/lab_pin.sym} 2660 -39050 0 1 {name=p1908 lab=_86919_/D }
C {sky130_stdcells/inv_2.sym} 2620 -39050 0 0 {name=X_44853_ }
C {devices/lab_pin.sym} 2580 -38930 0 0 {name=p1909 lab=_56838_/Y }
C {devices/lab_pin.sym} 2660 -38930 0 1 {name=p1910 lab=_56839_/Y }
C {sky130_stdcells/inv_2.sym} 2620 -38930 0 0 {name=X_56839_ }
C {devices/lab_pin.sym} 2540 -38830 0 0 {name=p1911 lab=_75656_/A }
C {devices/lab_pin.sym} 2540 -38790 0 0 {name=p1912 lab=_80780_/D }
C {devices/lab_pin.sym} 2540 -38750 0 0 {name=p1913 lab=_75672_/Y }
C {devices/lab_pin.sym} 2700 -38790 0 1 {name=p1914 lab=_75673_/Y }
C {sky130_stdcells/a21oi_4.sym} 2620 -38790 0 0 {name=X_75673_ }
C {devices/lab_pin.sym} 2530 -38650 0 0 {name=p1915 lab=_87653_/CLK }
C {devices/lab_pin.sym} 2530 -38630 0 0 {name=p1916 lab=_87659_/D }
C {devices/lab_pin.sym} 2710 -38650 0 1 {name=p1917 lab=_87659_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -38640 0 0 {name=X_87659_ }
C {devices/lab_pin.sym} 2560 -38520 0 0 {name=p1918 lab=_72869_/Y }
C {devices/lab_pin.sym} 2560 -38480 0 0 {name=p1919 lab=_72884_/X }
C {devices/lab_pin.sym} 2680 -38500 0 1 {name=p1920 lab=_72885_/Y }
C {sky130_stdcells/xnor2_4.sym} 2620 -38500 0 0 {name=X_72885_ }
C {devices/lab_pin.sym} 2560 -38390 0 0 {name=p1921 lab=_77412_/A }
C {devices/lab_pin.sym} 2560 -38350 0 0 {name=p1922 lab=_77412_/B }
C {devices/lab_pin.sym} 2560 -38310 0 0 {name=p1923 lab=_77412_/C }
C {devices/lab_pin.sym} 2680 -38350 0 1 {name=p1924 lab=_77412_/X }
C {sky130_stdcells/or3_4.sym} 2620 -38350 0 0 {name=X_77412_ }
C {devices/lab_pin.sym} 2540 -38240 0 0 {name=p1925 lab=_41070_/X }
C {devices/lab_pin.sym} 2540 -38200 0 0 {name=p1926 lab=_43801_/X }
C {devices/lab_pin.sym} 2540 -38160 0 0 {name=p1927 lab=_69469_/B }
C {devices/lab_pin.sym} 2540 -38120 0 0 {name=p1928 lab=_43802_/X }
C {devices/lab_pin.sym} 2700 -38180 0 1 {name=p1929 lab=_87259_/D }
C {sky130_stdcells/a2bb2o_4.sym} 2620 -38180 0 0 {name=X_43804_ }
C {devices/lab_pin.sym} 2540 -38050 0 0 {name=p1930 lab=_45365_/A }
C {devices/lab_pin.sym} 2540 -38010 0 0 {name=p1931 lab=_74612_/X }
C {devices/lab_pin.sym} 2540 -37970 0 0 {name=p1932 lab=_74623_/X }
C {devices/lab_pin.sym} 2700 -38010 0 1 {name=p1933 lab=_74624_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -38010 0 0 {name=X_74624_ }
C {devices/lab_pin.sym} 2580 -37870 0 0 {name=p1934 lab=_83708_/Q }
C {devices/lab_pin.sym} 2660 -37870 0 1 {name=p1935 lab=_47572_/Y }
C {sky130_stdcells/inv_2.sym} 2620 -37870 0 0 {name=X_47572_ }
C {devices/lab_pin.sym} 2540 -37770 0 0 {name=p1936 lab=_71825_/X }
C {devices/lab_pin.sym} 2540 -37730 0 0 {name=p1937 lab=_58548_/B }
C {devices/lab_pin.sym} 2540 -37690 0 0 {name=p1938 lab=_71835_/X }
C {devices/lab_pin.sym} 2700 -37730 0 1 {name=p1939 lab=_83358_/D }
C {sky130_stdcells/a21o_4.sym} 2620 -37730 0 0 {name=X_71836_ }
C {devices/lab_pin.sym} 2560 -37610 0 0 {name=p1940 lab=_43959_/A }
C {devices/lab_pin.sym} 2560 -37570 0 0 {name=p1941 lab=_44008_/A }
C {devices/lab_pin.sym} 2560 -37530 0 0 {name=p1942 lab=_43959_/B }
C {devices/lab_pin.sym} 2680 -37570 0 1 {name=p1943 lab=_59558_/Y }
C {sky130_stdcells/nand3_4.sym} 2620 -37570 0 0 {name=X_59558_ }
C {devices/lab_pin.sym} 2540 -37450 0 0 {name=p1944 lab=_78391_/Y }
C {devices/lab_pin.sym} 2540 -37410 0 0 {name=p1945 lab=_78371_/Y }
C {devices/lab_pin.sym} 2540 -37370 0 0 {name=p1946 lab=_78375_/C }
C {devices/lab_pin.sym} 2700 -37410 0 1 {name=p1947 lab=_78394_/C }
C {sky130_stdcells/o21ai_4.sym} 2620 -37410 0 0 {name=X_78392_ }
C {devices/lab_pin.sym} 2540 -37310 0 0 {name=p1948 lab=_44766_/X }
C {devices/lab_pin.sym} 2540 -37270 0 0 {name=p1949 lab=_44767_/X }
C {devices/lab_pin.sym} 2540 -37230 0 0 {name=p1950 lab=_41387_/A }
C {devices/lab_pin.sym} 2540 -37190 0 0 {name=p1951 lab=_86956_/Q }
C {devices/lab_pin.sym} 2540 -37150 0 0 {name=p1952 lab=_44768_/X }
C {devices/lab_pin.sym} 2700 -37230 0 1 {name=p1953 lab=_44784_/Y }
C {sky130_stdcells/o32ai_4.sym} 2620 -37230 0 0 {name=X_44784_ }
C {devices/lab_pin.sym} 2580 -37070 0 0 {name=p1954 lab=_41996_/A }
C {devices/lab_pin.sym} 2660 -37070 0 1 {name=p1955 lab=_41996_/Y }
C {sky130_stdcells/inv_2.sym} 2620 -37070 0 0 {name=X_41996_ }
C {devices/lab_pin.sym} 2580 -36950 0 0 {name=p1956 lab=clkbuf_7_9_0_CLK/X }
C {devices/lab_pin.sym} 2660 -36950 0 1 {name=p1957 lab=clkbuf_9_37_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 2620 -36950 0 0 {name=Xclkbuf_8_18_0_CLK }
C {devices/lab_pin.sym} 2540 -36850 0 0 {name=p1958 lab=_65152_/B }
C {devices/lab_pin.sym} 2540 -36810 0 0 {name=p1959 lab=_49300_/X }
C {devices/lab_pin.sym} 2540 -36770 0 0 {name=p1960 lab=_49310_/Y }
C {devices/lab_pin.sym} 2700 -36810 0 1 {name=p1961 lab=_49311_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -36810 0 0 {name=X_49311_ }
C {devices/lab_pin.sym} 2580 -36670 0 0 {name=p1962 lab=_46399_/A }
C {devices/lab_pin.sym} 2660 -36670 0 1 {name=p1963 lab=_46523_/X }
C {sky130_stdcells/buf_2.sym} 2620 -36670 0 0 {name=X_46523_ }
C {devices/lab_pin.sym} 2580 -36550 0 0 {name=p1964 lab=_64335_/C }
C {devices/lab_pin.sym} 2660 -36550 0 1 {name=p1965 lab=_58511_/A }
C {sky130_stdcells/buf_2.sym} 2620 -36550 0 0 {name=X_58509_ }
C {devices/lab_pin.sym} 2540 -36450 0 0 {name=p1966 lab=_77339_/X }
C {devices/lab_pin.sym} 2540 -36410 0 0 {name=p1967 lab=_77340_/Y }
C {devices/lab_pin.sym} 2540 -36370 0 0 {name=p1968 lab=_77342_/Y }
C {devices/lab_pin.sym} 2700 -36410 0 1 {name=p1969 lab=_77345_/A }
C {sky130_stdcells/a21o_4.sym} 2620 -36410 0 0 {name=X_77343_ }
C {devices/lab_pin.sym} 2540 -36300 0 0 {name=p1970 lab=_40899_/X }
C {devices/lab_pin.sym} 2540 -36260 0 0 {name=p1971 lab=_43695_/X }
C {devices/lab_pin.sym} 2540 -36220 0 0 {name=p1972 lab=_87290_/Q }
C {devices/lab_pin.sym} 2540 -36180 0 0 {name=p1973 lab=_43696_/X }
C {devices/lab_pin.sym} 2700 -36240 0 1 {name=p1974 lab=_43735_/X }
C {sky130_stdcells/a2bb2o_4.sym} 2620 -36240 0 0 {name=X_43735_ }
C {devices/lab_pin.sym} 2540 -36120 0 0 {name=p1975 lab=_46155_/X }
C {devices/lab_pin.sym} 2540 -36080 0 0 {name=p1976 lab=_74553_/X }
C {devices/lab_pin.sym} 2540 -36040 0 0 {name=p1977 lab=_56025_/X }
C {devices/lab_pin.sym} 2540 -36000 0 0 {name=p1978 lab=_74554_/X }
C {devices/lab_pin.sym} 2700 -36060 0 1 {name=p1979 lab=_74555_/X }
C {sky130_stdcells/a211o_4.sym} 2620 -36060 0 0 {name=X_74555_ }
C {devices/lab_pin.sym} 2580 -35910 0 0 {name=p1980 lab=_40947_/A }
C {devices/lab_pin.sym} 2660 -35910 0 1 {name=p1981 lab=_40970_/B }
C {sky130_stdcells/buf_2.sym} 2620 -35910 0 0 {name=X_40947_ }
C {devices/lab_pin.sym} 2540 -35810 0 0 {name=p1982 lab=_71762_/X }
C {devices/lab_pin.sym} 2540 -35770 0 0 {name=p1983 lab=_83384_/Q }
C {devices/lab_pin.sym} 2540 -35730 0 0 {name=p1984 lab=_71766_/X }
C {devices/lab_pin.sym} 2700 -35770 0 1 {name=p1985 lab=_71767_/X }
C {sky130_stdcells/a21o_4.sym} 2620 -35770 0 0 {name=X_71767_ }
C {devices/lab_pin.sym} 2580 -35630 0 0 {name=p1986 lab=_64248_/C }
C {devices/lab_pin.sym} 2660 -35630 0 1 {name=p1987 lab=_63396_/B }
C {sky130_stdcells/buf_2.sym} 2620 -35630 0 0 {name=X_59489_ }
C {devices/lab_pin.sym} 2540 -35530 0 0 {name=p1988 lab=_64798_/B }
C {devices/lab_pin.sym} 2540 -35490 0 0 {name=p1989 lab=_49222_/X }
C {devices/lab_pin.sym} 2540 -35450 0 0 {name=p1990 lab=_49241_/Y }
C {devices/lab_pin.sym} 2700 -35490 0 1 {name=p1991 lab=_49242_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -35490 0 0 {name=X_49242_ }
C {devices/lab_pin.sym} 2580 -35350 0 0 {name=p1992 lab=_72561_/C }
C {devices/lab_pin.sym} 2660 -35350 0 1 {name=p1993 lab=_61538_/C }
C {sky130_stdcells/buf_2.sym} 2620 -35350 0 0 {name=X_61520_ }
C {devices/lab_pin.sym} 2540 -35250 0 0 {name=p1994 lab=_83148_/Q }
C {devices/lab_pin.sym} 2540 -35210 0 0 {name=p1995 lab=_73437_/X }
C {devices/lab_pin.sym} 2540 -35170 0 0 {name=p1996 lab=_73505_/Y }
C {devices/lab_pin.sym} 2700 -35210 0 1 {name=p1997 lab=_73506_/X }
C {sky130_stdcells/a21o_4.sym} 2620 -35210 0 0 {name=X_73506_ }
C {devices/lab_pin.sym} 2540 -35090 0 0 {name=p1998 lab=_52768_/B }
C {devices/lab_pin.sym} 2540 -35050 0 0 {name=p1999 lab=_70699_/X }
C {devices/lab_pin.sym} 2540 -35010 0 0 {name=p2000 lab=_70717_/Y }
C {devices/lab_pin.sym} 2700 -35050 0 1 {name=p2001 lab=_70718_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -35050 0 0 {name=X_70718_ }
C {devices/lab_pin.sym} 2540 -34930 0 0 {name=p2002 lab=_46444_/Y }
C {devices/lab_pin.sym} 2540 -34890 0 0 {name=p2003 lab=_46445_/X }
C {devices/lab_pin.sym} 2540 -34850 0 0 {name=p2004 lab=_46453_/X }
C {devices/lab_pin.sym} 2700 -34890 0 1 {name=p2005 lab=_46454_/Y }
C {sky130_stdcells/a21oi_4.sym} 2620 -34890 0 0 {name=X_46454_ }
C {devices/lab_pin.sym} 2560 -34770 0 0 {name=p2006 lab=_77272_/Y }
C {devices/lab_pin.sym} 2560 -34730 0 0 {name=p2007 lab=_77274_/B }
C {devices/lab_pin.sym} 2560 -34690 0 0 {name=p2008 lab=_77270_/X }
C {devices/lab_pin.sym} 2680 -34730 0 1 {name=p2009 lab=_77274_/Y }
C {sky130_stdcells/nand3_4.sym} 2620 -34730 0 0 {name=X_77274_ }
C {devices/lab_pin.sym} 2540 -34620 0 0 {name=p2010 lab=_40739_/X }
C {devices/lab_pin.sym} 2540 -34580 0 0 {name=p2011 lab=_43656_/X }
C {devices/lab_pin.sym} 2540 -34540 0 0 {name=p2012 lab=_74186_/A }
C {devices/lab_pin.sym} 2540 -34500 0 0 {name=p2013 lab=_43657_/X }
C {devices/lab_pin.sym} 2700 -34560 0 1 {name=p2014 lab=_87320_/D }
C {sky130_stdcells/a2bb2o_4.sym} 2620 -34560 0 0 {name=X_43666_ }
C {devices/lab_pin.sym} 2540 -34430 0 0 {name=p2015 lab=_83056_/Q }
C {devices/lab_pin.sym} 2540 -34390 0 0 {name=p2016 lab=_74474_/X }
C {devices/lab_pin.sym} 2540 -34350 0 0 {name=p2017 lab=_74485_/Y }
C {devices/lab_pin.sym} 2700 -34390 0 1 {name=p2018 lab=_74486_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -34390 0 0 {name=X_74486_ }
C {devices/lab_pin.sym} 2580 -34250 0 0 {name=p2019 lab=_40878_/A }
C {devices/lab_pin.sym} 2660 -34250 0 1 {name=p2020 lab=_46469_/B }
C {sky130_stdcells/buf_2.sym} 2620 -34250 0 0 {name=X_40878_ }
C {devices/lab_pin.sym} 2560 -34150 0 0 {name=p2021 lab=_71698_/A }
C {devices/lab_pin.sym} 2560 -34110 0 0 {name=p2022 lab=_71690_/A }
C {devices/lab_pin.sym} 2560 -34070 0 0 {name=p2023 lab=_71874_/D }
C {devices/lab_pin.sym} 2680 -34110 0 1 {name=p2024 lab=_71698_/Y }
C {sky130_stdcells/nor3_4.sym} 2620 -34110 0 0 {name=X_71698_ }
C {devices/lab_pin.sym} 2560 -33980 0 0 {name=p2025 lab=_82825_/Q }
C {devices/lab_pin.sym} 2560 -33940 0 0 {name=p2026 lab=_82537_/Q }
C {devices/lab_pin.sym} 2680 -33960 0 1 {name=p2027 lab=_79014_/B }
C {sky130_stdcells/xnor2_4.sym} 2620 -33960 0 0 {name=X_79013_ }
C {devices/lab_pin.sym} 2580 -33830 0 0 {name=p2028 lab=_61714_/A }
C {devices/lab_pin.sym} 2660 -33830 0 1 {name=p2029 lab=_61315_/A }
C {sky130_stdcells/buf_2.sym} 2620 -33830 0 0 {name=X_45405_ }
C {devices/lab_pin.sym} 2560 -33720 0 0 {name=p2030 lab=_76223_/Y }
C {devices/lab_pin.sym} 2560 -33680 0 0 {name=p2031 lab=_76225_/B }
C {devices/lab_pin.sym} 2680 -33700 0 1 {name=p2032 lab=_81607_/D }
C {sky130_stdcells/xor2_4.sym} 2620 -33700 0 0 {name=X_76225_ }
C {devices/lab_pin.sym} 2580 -33570 0 0 {name=p2033 lab=_42616_/Y }
C {devices/lab_pin.sym} 2660 -33570 0 1 {name=p2034 lab=_87800_/D }
C {sky130_stdcells/inv_2.sym} 2620 -33570 0 0 {name=X_42617_ }
C {devices/lab_pin.sym} 2560 -33460 0 0 {name=p2035 lab=_49173_/A }
C {devices/lab_pin.sym} 2560 -33420 0 0 {name=p2036 lab=_50710_/B }
C {devices/lab_pin.sym} 2680 -33440 0 1 {name=p2037 lab=_49173_/X }
C {sky130_stdcells/and2_4.sym} 2620 -33440 0 0 {name=X_49173_ }
C {devices/lab_pin.sym} 2560 -33340 0 0 {name=p2038 lab=_61451_/A }
C {devices/lab_pin.sym} 2560 -33300 0 0 {name=p2039 lab=_61404_/X }
C {devices/lab_pin.sym} 2560 -33260 0 0 {name=p2040 lab=_61406_/C }
C {devices/lab_pin.sym} 2560 -33220 0 0 {name=p2041 lab=_61451_/D }
C {devices/lab_pin.sym} 2680 -33280 0 1 {name=p2042 lab=_61451_/Y }
C {sky130_stdcells/nand4_4.sym} 2620 -33280 0 0 {name=X_61451_ }
C {devices/lab_pin.sym} 2580 -33130 0 0 {name=p2043 lab=_73193_/A }
C {devices/lab_pin.sym} 2660 -33130 0 1 {name=p2044 lab=_73437_/X }
C {sky130_stdcells/buf_2.sym} 2620 -33130 0 0 {name=X_73437_ }
C {devices/lab_pin.sym} 2580 -33010 0 0 {name=p2045 lab=_46385_/A }
C {devices/lab_pin.sym} 2660 -33010 0 1 {name=p2046 lab=_52480_/B }
C {sky130_stdcells/inv_2.sym} 2620 -33010 0 0 {name=X_46385_ }
C {devices/lab_pin.sym} 2560 -32920 0 0 {name=p2047 lab=_70719_/A }
C {devices/lab_pin.sym} 2560 -32880 0 0 {name=p2048 lab=_70639_/B }
C {devices/lab_pin.sym} 2560 -32840 0 0 {name=p2049 lab=_70642_/X }
C {devices/lab_pin.sym} 2560 -32800 0 0 {name=p2050 lab=_70638_/X }
C {devices/lab_pin.sym} 2680 -32860 0 1 {name=p2051 lab=_70649_/Y }
C {sky130_stdcells/nand4_4.sym} 2620 -32860 0 0 {name=X_70649_ }
C {devices/lab_pin.sym} 2540 -32740 0 0 {name=p2052 lab=_40573_/A }
C {devices/lab_pin.sym} 2540 -32700 0 0 {name=p2053 lab=_43586_/X }
C {devices/lab_pin.sym} 2540 -32660 0 0 {name=p2054 lab=_68387_/B }
C {devices/lab_pin.sym} 2540 -32620 0 0 {name=p2055 lab=_43593_/X }
C {devices/lab_pin.sym} 2700 -32680 0 1 {name=p2056 lab=_43598_/A }
C {sky130_stdcells/a2bb2o_4.sym} 2620 -32680 0 0 {name=X_43597_ }
C {devices/lab_pin.sym} 2560 -32540 0 0 {name=p2057 lab=_48142_/A }
C {devices/lab_pin.sym} 2560 -32500 0 0 {name=p2058 lab=_48335_/B }
C {devices/lab_pin.sym} 2680 -32520 0 1 {name=p2059 lab=_48124_/Y }
C {sky130_stdcells/nand2_4.sym} 2620 -32520 0 0 {name=X_48124_ }
C {devices/lab_pin.sym} 2580 -32390 0 0 {name=p2060 lab=_60402_/A }
C {devices/lab_pin.sym} 2660 -32390 0 1 {name=p2061 lab=_60403_/B }
C {sky130_stdcells/buf_2.sym} 2620 -32390 0 0 {name=X_60402_ }
C {devices/lab_pin.sym} 2540 -32290 0 0 {name=p2062 lab=_45329_/X }
C {devices/lab_pin.sym} 2540 -32250 0 0 {name=p2063 lab=_45333_/Y }
C {devices/lab_pin.sym} 2540 -32210 0 0 {name=p2064 lab=_45335_/Y }
C {devices/lab_pin.sym} 2700 -32250 0 1 {name=p2065 lab=_45336_/Y }
C {sky130_stdcells/a21oi_4.sym} 2620 -32250 0 0 {name=X_45336_ }
C {devices/lab_pin.sym} 2560 -32140 0 0 {name=p2066 lab=_64166_/Y }
C {devices/lab_pin.sym} 2560 -32100 0 0 {name=p2067 lab=_64167_/Y }
C {devices/lab_pin.sym} 2560 -32060 0 0 {name=p2068 lab=_64168_/Y }
C {devices/lab_pin.sym} 2560 -32020 0 0 {name=p2069 lab=_64169_/Y }
C {devices/lab_pin.sym} 2680 -32080 0 1 {name=p2070 lab=_64170_/X }
C {sky130_stdcells/and4_4.sym} 2620 -32080 0 0 {name=X_64170_ }
C {devices/lab_pin.sym} 2560 -31940 0 0 {name=p2071 lab=_81634_/Q }
C {devices/lab_pin.sym} 2560 -31900 0 0 {name=p2072 lab=_76155_/X }
C {devices/lab_pin.sym} 2680 -31920 0 1 {name=p2073 lab=_81602_/D }
C {sky130_stdcells/xor2_4.sym} 2620 -31920 0 0 {name=X_76156_ }
C {devices/lab_pin.sym} 2580 -31790 0 0 {name=p2074 lab=_42548_/A }
C {devices/lab_pin.sym} 2660 -31790 0 1 {name=p2075 lab=_42548_/Y }
C {sky130_stdcells/inv_2.sym} 2620 -31790 0 0 {name=X_42548_ }
C {devices/lab_pin.sym} 2580 -31670 0 0 {name=p2076 lab=clkbuf_3_4_0_CLK/X }
C {devices/lab_pin.sym} 2660 -31670 0 1 {name=p2077 lab=clkbuf_4_9_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 2620 -31670 0 0 {name=Xclkbuf_3_4_1_CLK }
C {devices/lab_pin.sym} 2580 -31550 0 0 {name=p2078 lab=_61381_/Y }
C {devices/lab_pin.sym} 2660 -31550 0 1 {name=p2079 lab=_61382_/Y }
C {sky130_stdcells/inv_2.sym} 2620 -31550 0 0 {name=X_61382_ }
C {devices/lab_pin.sym} 2540 -31450 0 0 {name=p2080 lab=_73364_/X }
C {devices/lab_pin.sym} 2540 -31410 0 0 {name=p2081 lab=_73365_/Y }
C {devices/lab_pin.sym} 2540 -31370 0 0 {name=p2082 lab=_73367_/X }
C {devices/lab_pin.sym} 2700 -31410 0 1 {name=p2083 lab=_73368_/Y }
C {sky130_stdcells/a21oi_4.sym} 2620 -31410 0 0 {name=X_73368_ }
C {devices/lab_pin.sym} 2560 -31300 0 0 {name=p2084 lab=_63097_/A }
C {devices/lab_pin.sym} 2560 -31260 0 0 {name=p2085 lab=_64334_/B }
C {devices/lab_pin.sym} 2560 -31220 0 0 {name=p2086 lab=_63108_/C }
C {devices/lab_pin.sym} 2560 -31180 0 0 {name=p2087 lab=_63121_/D }
C {devices/lab_pin.sym} 2680 -31240 0 1 {name=p2088 lab=_63121_/X }
C {sky130_stdcells/and4_4.sym} 2620 -31240 0 0 {name=X_63121_ }
C {devices/lab_pin.sym} 2560 -31100 0 0 {name=p2089 lab=_75107_/A }
C {devices/lab_pin.sym} 2560 -31060 0 0 {name=p2090 lab=_75107_/B }
C {devices/lab_pin.sym} 2680 -31080 0 1 {name=p2091 lab=_75107_/Y }
C {sky130_stdcells/xnor2_4.sym} 2620 -31080 0 0 {name=X_75107_ }
C {devices/lab_pin.sym} 2540 -30990 0 0 {name=p2092 lab=_60256_/X }
C {devices/lab_pin.sym} 2540 -30950 0 0 {name=p2093 lab=_60285_/A }
C {devices/lab_pin.sym} 2540 -30910 0 0 {name=p2094 lab=_60330_/Y }
C {devices/lab_pin.sym} 2540 -30870 0 0 {name=p2095 lab=_60331_/Y }
C {devices/lab_pin.sym} 2540 -30840 0 0 {name=p2096 lab=_60332_/Y }
C {devices/lab_pin.sym} 2700 -30910 0 1 {name=p2097 lab=_60333_/Y }
C {sky130_stdcells/a41oi_4.sym} 2620 -30910 0 0 {name=X_60333_ }
C {devices/lab_pin.sym} 2560 -30760 0 0 {name=p2098 lab=_72366_/A }
C {devices/lab_pin.sym} 2560 -30720 0 0 {name=p2099 lab=_86289_/Q }
C {devices/lab_pin.sym} 2680 -30740 0 1 {name=p2100 lab=_72319_/Y }
C {sky130_stdcells/nor2_4.sym} 2620 -30740 0 0 {name=X_72319_ }
C {devices/lab_pin.sym} 2580 -30610 0 0 {name=p2101 lab=_48734_/A }
C {devices/lab_pin.sym} 2660 -30610 0 1 {name=p2102 lab=_48055_/X }
C {sky130_stdcells/buf_2.sym} 2620 -30610 0 0 {name=X_48055_ }
C {devices/lab_pin.sym} 2540 -30510 0 0 {name=p2103 lab=_85193_/Q }
C {devices/lab_pin.sym} 2540 -30470 0 0 {name=p2104 lab=_45252_/X }
C {devices/lab_pin.sym} 2540 -30430 0 0 {name=p2105 lab=_45266_/X }
C {devices/lab_pin.sym} 2700 -30470 0 1 {name=p2106 lab=_45267_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -30470 0 0 {name=X_45267_ }
C {devices/lab_pin.sym} 2540 -30350 0 0 {name=p2107 lab=_76077_/Y }
C {devices/lab_pin.sym} 2540 -30310 0 0 {name=p2108 lab=_76080_/X }
C {devices/lab_pin.sym} 2540 -30270 0 0 {name=p2109 lab=_76082_/A }
C {devices/lab_pin.sym} 2700 -30310 0 1 {name=p2110 lab=_76087_/Y }
C {sky130_stdcells/a21boi_4.sym} 2620 -30310 0 0 {name=X_76087_ }
C {devices/lab_pin.sym} 2540 -30210 0 0 {name=p2111 lab=_42460_/X }
C {devices/lab_pin.sym} 2540 -30170 0 0 {name=p2112 lab=_40632_/Y }
C {devices/lab_pin.sym} 2540 -30130 0 0 {name=p2113 lab=_42477_/X }
C {devices/lab_pin.sym} 2540 -30090 0 0 {name=p2114 lab=_68567_/B }
C {devices/lab_pin.sym} 2540 -30050 0 0 {name=p2115 lab=_42463_/X }
C {devices/lab_pin.sym} 2700 -30130 0 1 {name=p2116 lab=_42479_/Y }
C {sky130_stdcells/o32ai_4.sym} 2620 -30130 0 0 {name=X_42479_ }
C {devices/lab_pin.sym} 2560 -29980 0 0 {name=p2117 lab=_73299_/A }
C {devices/lab_pin.sym} 2560 -29940 0 0 {name=p2118 lab=_73003_/B }
C {devices/lab_pin.sym} 2680 -29960 0 1 {name=p2119 lab=_73299_/Y }
C {sky130_stdcells/nor2_4.sym} 2620 -29960 0 0 {name=X_73299_ }
C {devices/lab_pin.sym} 2580 -29830 0 0 {name=p2120 lab=_83048_/Q }
C {devices/lab_pin.sym} 2660 -29830 0 1 {name=p2121 lab=_47006_/Y }
C {sky130_stdcells/inv_2.sym} 2620 -29830 0 0 {name=X_47006_ }
C {devices/lab_pin.sym} 2540 -29730 0 0 {name=p2122 lab=_44216_/X }
C {devices/lab_pin.sym} 2540 -29690 0 0 {name=p2123 lab=_44217_/X }
C {devices/lab_pin.sym} 2540 -29650 0 0 {name=p2124 lab=_44153_/X }
C {devices/lab_pin.sym} 2700 -29690 0 1 {name=p2125 lab=_44218_/X }
C {sky130_stdcells/a21o_4.sym} 2620 -29690 0 0 {name=X_44218_ }
C {devices/lab_pin.sym} 2560 -29560 0 0 {name=p2126 lab=_79915_/A }
C {devices/lab_pin.sym} 2560 -29520 0 0 {name=p2127 lab=_79915_/B }
C {devices/lab_pin.sym} 2680 -29540 0 1 {name=p2128 lab=_80262_/B }
C {sky130_stdcells/nand2_4.sym} 2620 -29540 0 0 {name=X_79915_ }
C {devices/lab_pin.sym} 2540 -29450 0 0 {name=p2129 lab=_63047_/Y }
C {devices/lab_pin.sym} 2540 -29410 0 0 {name=p2130 lab=_63049_/X }
C {devices/lab_pin.sym} 2540 -29370 0 0 {name=p2131 lab=_63050_/X }
C {devices/lab_pin.sym} 2540 -29330 0 0 {name=p2132 lab=_63051_/X }
C {devices/lab_pin.sym} 2540 -29290 0 0 {name=p2133 lab=_63020_/X }
C {devices/lab_pin.sym} 2700 -29370 0 1 {name=p2134 lab=_63052_/Y }
C {sky130_stdcells/o41ai_4.sym} 2620 -29370 0 0 {name=X_63052_ }
C {devices/lab_pin.sym} 2560 -29220 0 0 {name=p2135 lab=_81149_/D }
C {devices/lab_pin.sym} 2560 -29180 0 0 {name=p2136 lab=_75040_/B }
C {devices/lab_pin.sym} 2680 -29200 0 1 {name=p2137 lab=_75038_/X }
C {sky130_stdcells/or2_4.sym} 2620 -29200 0 0 {name=X_75038_ }
C {devices/lab_pin.sym} 2580 -29070 0 0 {name=p2138 lab=_60207_/Y }
C {devices/lab_pin.sym} 2660 -29070 0 1 {name=p2139 lab=_60264_/Y }
C {sky130_stdcells/inv_2.sym} 2620 -29070 0 0 {name=X_60264_ }
C {devices/lab_pin.sym} 2580 -28950 0 0 {name=p2140 lab=_45272_/A }
C {devices/lab_pin.sym} 2660 -28950 0 1 {name=p2141 lab=_45199_/B }
C {sky130_stdcells/buf_2.sym} 2620 -28950 0 0 {name=X_45198_ }
C {devices/lab_pin.sym} 2540 -28850 0 0 {name=p2142 lab=_62001_/Y }
C {devices/lab_pin.sym} 2540 -28810 0 0 {name=p2143 lab=_61959_/X }
C {devices/lab_pin.sym} 2540 -28770 0 0 {name=p2144 lab=_62002_/Y }
C {devices/lab_pin.sym} 2700 -28810 0 1 {name=p2145 lab=_84440_/D }
C {sky130_stdcells/a21oi_4.sym} 2620 -28810 0 0 {name=X_62003_ }
C {devices/lab_pin.sym} 2580 -28670 0 0 {name=p2146 lab=_44149_/A }
C {devices/lab_pin.sym} 2660 -28670 0 1 {name=p2147 lab=_44149_/X }
C {sky130_stdcells/buf_2.sym} 2620 -28670 0 0 {name=X_44149_ }
C {devices/lab_pin.sym} 2560 -28560 0 0 {name=p2148 lab=_67909_/A }
C {devices/lab_pin.sym} 2560 -28520 0 0 {name=p2149 lab=_67860_/B }
C {devices/lab_pin.sym} 2680 -28540 0 1 {name=p2150 lab=_67860_/X }
C {sky130_stdcells/and2_4.sym} 2620 -28540 0 0 {name=X_67860_ }
C {devices/lab_pin.sym} 2560 -28420 0 0 {name=p2151 lab=_79846_/A }
C {devices/lab_pin.sym} 2560 -28380 0 0 {name=p2152 lab=_79846_/B }
C {devices/lab_pin.sym} 2680 -28400 0 1 {name=p2153 lab=_79860_/B }
C {sky130_stdcells/xor2_4.sym} 2620 -28400 0 0 {name=X_79846_ }
C {devices/lab_pin.sym} 2580 -28270 0 0 {name=p2154 lab=_60179_/A }
C {devices/lab_pin.sym} 2660 -28270 0 1 {name=p2155 lab=_62737_/A }
C {sky130_stdcells/buf_2.sym} 2620 -28270 0 0 {name=X_60195_ }
C {devices/lab_pin.sym} 2540 -28180 0 0 {name=p2156 lab=_87369_/Q }
C {devices/lab_pin.sym} 2540 -28140 0 0 {name=p2157 lab=_66762_/X }
C {devices/lab_pin.sym} 2540 -28100 0 0 {name=p2158 lab=_66764_/X }
C {devices/lab_pin.sym} 2540 -28060 0 0 {name=p2159 lab=_66810_/X }
C {devices/lab_pin.sym} 2700 -28120 0 1 {name=p2160 lab=_66811_/X }
C {sky130_stdcells/a211o_4.sym} 2620 -28120 0 0 {name=X_66811_ }
C {devices/lab_pin.sym} 2540 -27990 0 0 {name=p2161 lab=_86458_/Q }
C {devices/lab_pin.sym} 2540 -27950 0 0 {name=p2162 lab=_48952_/X }
C {devices/lab_pin.sym} 2540 -27910 0 0 {name=p2163 lab=_48956_/Y }
C {devices/lab_pin.sym} 2700 -27950 0 1 {name=p2164 lab=_48957_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -27950 0 0 {name=X_48957_ }
C {devices/lab_pin.sym} 2540 -27840 0 0 {name=p2165 lab=_87148_/Q }
C {devices/lab_pin.sym} 2540 -27800 0 0 {name=p2166 lab=_67788_/X }
C {devices/lab_pin.sym} 2540 -27760 0 0 {name=p2167 lab=_67789_/X }
C {devices/lab_pin.sym} 2540 -27720 0 0 {name=p2168 lab=_67790_/X }
C {devices/lab_pin.sym} 2700 -27780 0 1 {name=p2169 lab=_67791_/X }
C {sky130_stdcells/a211o_4.sym} 2620 -27780 0 0 {name=X_67791_ }
C {devices/lab_pin.sym} 2560 -27640 0 0 {name=p2170 lab=_79790_/B }
C {devices/lab_pin.sym} 2560 -27600 0 0 {name=p2171 lab=_79776_/Y }
C {devices/lab_pin.sym} 2680 -27620 0 1 {name=p2172 lab=_79777_/X }
C {sky130_stdcells/xor2_4.sym} 2620 -27620 0 0 {name=X_79777_ }
C {devices/lab_pin.sym} 2560 -27500 0 0 {name=p2173 lab=_76989_/A }
C {devices/lab_pin.sym} 2560 -27460 0 0 {name=p2174 lab=_62397_/C }
C {devices/lab_pin.sym} 2680 -27480 0 1 {name=p2175 lab=_76989_/X }
C {sky130_stdcells/xor2_4.sym} 2620 -27480 0 0 {name=X_76989_ }
C {devices/lab_pin.sym} 2540 -27370 0 0 {name=p2176 lab=_81381_/D }
C {devices/lab_pin.sym} 2540 -27330 0 0 {name=p2177 lab=_69504_/X }
C {devices/lab_pin.sym} 2540 -27290 0 0 {name=p2178 lab=_69529_/X }
C {devices/lab_pin.sym} 2700 -27330 0 1 {name=p2179 lab=_83917_/D }
C {sky130_stdcells/a21bo_4.sym} 2620 -27330 0 0 {name=X_69530_ }
C {devices/lab_pin.sym} 2560 -27200 0 0 {name=p2180 lab=_47887_/A }
C {devices/lab_pin.sym} 2560 -27160 0 0 {name=p2181 lab=_48212_/A }
C {devices/lab_pin.sym} 2680 -27180 0 1 {name=p2182 lab=_47908_/X }
C {sky130_stdcells/and2_4.sym} 2620 -27180 0 0 {name=X_47908_ }
C {devices/lab_pin.sym} 2540 -27080 0 0 {name=p2183 lab=_88396_/Q }
C {devices/lab_pin.sym} 2540 -27040 0 0 {name=p2184 lab=_66715_/X }
C {devices/lab_pin.sym} 2540 -27000 0 0 {name=p2185 lab=_66717_/X }
C {devices/lab_pin.sym} 2540 -26960 0 0 {name=p2186 lab=_66741_/X }
C {devices/lab_pin.sym} 2700 -27020 0 1 {name=p2187 lab=_66742_/X }
C {sky130_stdcells/a211o_4.sym} 2620 -27020 0 0 {name=X_66742_ }
C {devices/lab_pin.sym} 2580 -26870 0 0 {name=p2188 lab=_78728_/A }
C {devices/lab_pin.sym} 2660 -26870 0 1 {name=p2189 lab=_78732_/A }
C {sky130_stdcells/inv_2.sym} 2620 -26870 0 0 {name=X_78728_ }
C {devices/lab_pin.sym} 2560 -26780 0 0 {name=p2190 lab=_63947_/Y }
C {devices/lab_pin.sym} 2560 -26740 0 0 {name=p2191 lab=_63949_/Y }
C {devices/lab_pin.sym} 2560 -26700 0 0 {name=p2192 lab=_63951_/Y }
C {devices/lab_pin.sym} 2560 -26660 0 0 {name=p2193 lab=_63954_/D }
C {devices/lab_pin.sym} 2680 -26720 0 1 {name=p2194 lab=_63954_/X }
C {sky130_stdcells/and4_4.sym} 2620 -26720 0 0 {name=X_63954_ }
C {devices/lab_pin.sym} 2580 -26570 0 0 {name=p2195 lab=_48887_/Y }
C {devices/lab_pin.sym} 2660 -26570 0 1 {name=p2196 lab=_48889_/B }
C {sky130_stdcells/buf_2.sym} 2620 -26570 0 0 {name=X_48888_ }
C {devices/lab_pin.sym} 2560 -26480 0 0 {name=p2197 lab=_58495_/A }
C {devices/lab_pin.sym} 2560 -26440 0 0 {name=p2198 lab=_62658_/A }
C {devices/lab_pin.sym} 2560 -26400 0 0 {name=p2199 lab=_60197_/C }
C {devices/lab_pin.sym} 2560 -26360 0 0 {name=p2200 lab=_60202_/A }
C {devices/lab_pin.sym} 2680 -26420 0 1 {name=p2201 lab=_62905_/Y }
C {sky130_stdcells/nand4_4.sym} 2620 -26420 0 0 {name=X_62905_ }
C {devices/lab_pin.sym} 2560 -26280 0 0 {name=p2202 lab=_69461_/A }
C {devices/lab_pin.sym} 2560 -26240 0 0 {name=p2203 lab=_69461_/B }
C {devices/lab_pin.sym} 2680 -26260 0 1 {name=p2204 lab=_69461_/Y }
C {sky130_stdcells/nand2_4.sym} 2620 -26260 0 0 {name=X_69461_ }
C {devices/lab_pin.sym} 2580 -26130 0 0 {name=p2205 lab=_47838_/X }
C {devices/lab_pin.sym} 2660 -26130 0 1 {name=p2206 lab=_47840_/A }
C {sky130_stdcells/buf_2.sym} 2620 -26130 0 0 {name=X_47839_ }
C {devices/lab_pin.sym} 2580 -26010 0 0 {name=p2207 lab=_45920_/A }
C {devices/lab_pin.sym} 2660 -26010 0 1 {name=p2208 lab=_66673_/X }
C {sky130_stdcells/buf_2.sym} 2620 -26010 0 0 {name=X_66673_ }
C {devices/lab_pin.sym} 2580 -25890 0 0 {name=p2209 lab=_82810_/Q }
C {devices/lab_pin.sym} 2660 -25890 0 1 {name=p2210 lab=_78663_/A }
C {sky130_stdcells/inv_2.sym} 2620 -25890 0 0 {name=X_78659_ }
C {devices/lab_pin.sym} 2560 -25800 0 0 {name=p2211 lab=_61437_/B }
C {devices/lab_pin.sym} 2560 -25760 0 0 {name=p2212 lab=_63920_/B }
C {devices/lab_pin.sym} 2560 -25720 0 0 {name=p2213 lab=_63840_/C }
C {devices/lab_pin.sym} 2560 -25680 0 0 {name=p2214 lab=_63920_/D }
C {devices/lab_pin.sym} 2680 -25740 0 1 {name=p2215 lab=_63885_/Y }
C {sky130_stdcells/nand4_4.sym} 2620 -25740 0 0 {name=X_63885_ }
C {devices/lab_pin.sym} 2540 -25620 0 0 {name=p2216 lab=_68376_/X }
C {devices/lab_pin.sym} 2540 -25580 0 0 {name=p2217 lab=_66524_/B }
C {devices/lab_pin.sym} 2540 -25540 0 0 {name=p2218 lab=_68401_/Y }
C {devices/lab_pin.sym} 2540 -25500 0 0 {name=p2219 lab=_68411_/Y }
C {devices/lab_pin.sym} 2700 -25560 0 1 {name=p2220 lab=_68412_/X }
C {sky130_stdcells/a211o_4.sym} 2620 -25560 0 0 {name=X_68412_ }
C {devices/lab_pin.sym} 2580 -25410 0 0 {name=p2221 lab=clkbuf_9_181_0_CLK/X }
C {devices/lab_pin.sym} 2660 -25410 0 1 {name=p2222 lab=_84926_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 2620 -25410 0 0 {name=Xclkbuf_10_362_0_CLK }
C {devices/lab_pin.sym} 2560 -25300 0 0 {name=p2223 lab=_65777_/A }
C {devices/lab_pin.sym} 2560 -25260 0 0 {name=p2224 lab=_85876_/Q }
C {devices/lab_pin.sym} 2680 -25280 0 1 {name=p2225 lab=_65624_/X }
C {sky130_stdcells/and2_4.sym} 2620 -25280 0 0 {name=X_65624_ }
C {devices/lab_pin.sym} 2560 -25160 0 0 {name=p2226 lab=_50845_/A }
C {devices/lab_pin.sym} 2560 -25120 0 0 {name=p2227 lab=_50850_/B }
C {devices/lab_pin.sym} 2680 -25140 0 1 {name=p2228 lab=_50850_/Y }
C {sky130_stdcells/nand2_4.sym} 2620 -25140 0 0 {name=X_50850_ }
C {devices/lab_pin.sym} 2560 -25040 0 0 {name=p2229 lab=_62789_/A }
C {devices/lab_pin.sym} 2560 -25000 0 0 {name=p2230 lab=_59419_/A }
C {devices/lab_pin.sym} 2560 -24960 0 0 {name=p2231 lab=_62848_/C }
C {devices/lab_pin.sym} 2560 -24920 0 0 {name=p2232 lab=_62880_/D }
C {devices/lab_pin.sym} 2680 -24980 0 1 {name=p2233 lab=_62836_/X }
C {sky130_stdcells/and4_4.sym} 2620 -24980 0 0 {name=X_62836_ }
C {devices/lab_pin.sym} 2540 -24850 0 0 {name=p2234 lab=_81391_/D }
C {devices/lab_pin.sym} 2540 -24810 0 0 {name=p2235 lab=_69367_/X }
C {devices/lab_pin.sym} 2540 -24770 0 0 {name=p2236 lab=_69391_/X }
C {devices/lab_pin.sym} 2700 -24810 0 1 {name=p2237 lab=_83927_/D }
C {sky130_stdcells/a21bo_4.sym} 2620 -24810 0 0 {name=X_69392_ }
C {devices/lab_pin.sym} 2530 -24670 0 0 {name=p2238 lab=_81582_/CLK }
C {devices/lab_pin.sym} 2530 -24650 0 0 {name=p2239 lab=_79967_/Y }
C {devices/lab_pin.sym} 2710 -24670 0 1 {name=p2240 lab=_81670_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -24660 0 0 {name=X_81670_ }
C {devices/lab_pin.sym} 2580 -24530 0 0 {name=p2241 lab=clkbuf_9_496_0_CLK/X }
C {devices/lab_pin.sym} 2660 -24530 0 1 {name=p2242 lab=_86210_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 2620 -24530 0 0 {name=Xclkbuf_10_992_0_CLK }
C {devices/lab_pin.sym} 2540 -24430 0 0 {name=p2243 lab=_86374_/Q }
C {devices/lab_pin.sym} 2540 -24390 0 0 {name=p2244 lab=_49496_/X }
C {devices/lab_pin.sym} 2540 -24350 0 0 {name=p2245 lab=_49508_/Y }
C {devices/lab_pin.sym} 2700 -24390 0 1 {name=p2246 lab=_49509_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -24390 0 0 {name=X_49509_ }
C {devices/lab_pin.sym} 2560 -24260 0 0 {name=p2247 lab=_80622_/B }
C {devices/lab_pin.sym} 2560 -24220 0 0 {name=p2248 lab=_80622_/A }
C {devices/lab_pin.sym} 2680 -24240 0 1 {name=p2249 lab=_82272_/D }
C {sky130_stdcells/xor2_4.sym} 2620 -24240 0 0 {name=X_80621_ }
C {devices/lab_pin.sym} 2560 -24120 0 0 {name=p2250 lab=_64898_/A }
C {devices/lab_pin.sym} 2560 -24080 0 0 {name=p2251 lab=_68343_/B }
C {devices/lab_pin.sym} 2680 -24100 0 1 {name=p2252 lab=_68343_/X }
C {sky130_stdcells/and2_4.sym} 2620 -24100 0 0 {name=X_68343_ }
C {devices/lab_pin.sym} 2540 -24000 0 0 {name=p2253 lab=_65524_/X }
C {devices/lab_pin.sym} 2540 -23960 0 0 {name=p2254 lab=_83073_/Q }
C {devices/lab_pin.sym} 2540 -23920 0 0 {name=p2255 lab=_65391_/X }
C {devices/lab_pin.sym} 2540 -23880 0 0 {name=p2256 lab=_65554_/X }
C {devices/lab_pin.sym} 2700 -23940 0 1 {name=p2257 lab=_65556_/C }
C {sky130_stdcells/a211o_4.sym} 2620 -23940 0 0 {name=X_65555_ }
C {devices/lab_pin.sym} 2560 -23800 0 0 {name=p2258 lab=_50777_/A }
C {devices/lab_pin.sym} 2560 -23760 0 0 {name=p2259 lab=_50781_/B }
C {devices/lab_pin.sym} 2680 -23780 0 1 {name=p2260 lab=_50781_/Y }
C {sky130_stdcells/nand2_4.sym} 2620 -23780 0 0 {name=X_50781_ }
C {devices/lab_pin.sym} 2540 -23670 0 0 {name=p2261 lab=_62765_/X }
C {devices/lab_pin.sym} 2540 -23630 0 0 {name=p2262 lab=_62721_/X }
C {devices/lab_pin.sym} 2540 -23590 0 0 {name=p2263 lab=_62766_/Y }
C {devices/lab_pin.sym} 2700 -23630 0 1 {name=p2264 lab=_62767_/Y }
C {sky130_stdcells/a21oi_4.sym} 2620 -23630 0 0 {name=X_62767_ }
C {devices/lab_pin.sym} 2580 -23490 0 0 {name=p2265 lab=clkbuf_9_483_0_CLK/A }
C {devices/lab_pin.sym} 2660 -23490 0 1 {name=p2266 lab=clkbuf_9_483_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 2620 -23490 0 0 {name=Xclkbuf_9_483_0_CLK }
C {devices/lab_pin.sym} 2560 -23390 0 0 {name=p2267 lab=_51330_/A }
C {devices/lab_pin.sym} 2560 -23350 0 0 {name=p2268 lab=_52509_/B }
C {devices/lab_pin.sym} 2560 -23310 0 0 {name=p2269 lab=_52498_/C }
C {devices/lab_pin.sym} 2680 -23350 0 1 {name=p2270 lab=_52520_/X }
C {sky130_stdcells/and3_4.sym} 2620 -23350 0 0 {name=X_52520_ }
C {devices/lab_pin.sym} 2540 -23230 0 0 {name=p2271 lab=_58976_/A }
C {devices/lab_pin.sym} 2540 -23190 0 0 {name=p2272 lab=_61085_/X }
C {devices/lab_pin.sym} 2540 -23150 0 0 {name=p2273 lab=_64505_/Y }
C {devices/lab_pin.sym} 2700 -23190 0 1 {name=p2274 lab=_64506_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -23190 0 0 {name=X_64506_ }
C {devices/lab_pin.sym} 2530 -23050 0 0 {name=p2275 lab=_83362_/CLK }
C {devices/lab_pin.sym} 2530 -23030 0 0 {name=p2276 lab=_71886_/X }
C {devices/lab_pin.sym} 2710 -23050 0 1 {name=p2277 lab=_83340_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -23040 0 0 {name=X_83340_ }
C {devices/lab_pin.sym} 2580 -22910 0 0 {name=p2278 lab=_61704_/Y }
C {devices/lab_pin.sym} 2660 -22910 0 1 {name=p2279 lab=_61719_/A }
C {sky130_stdcells/buf_2.sym} 2620 -22910 0 0 {name=X_61718_ }
C {devices/lab_pin.sym} 2540 -22820 0 0 {name=p2280 lab=_80542_/A }
C {devices/lab_pin.sym} 2540 -22780 0 0 {name=p2281 lab=_80527_/Y }
C {devices/lab_pin.sym} 2540 -22740 0 0 {name=p2282 lab=_80537_/X }
C {devices/lab_pin.sym} 2540 -22700 0 0 {name=p2283 lab=_80541_/B }
C {devices/lab_pin.sym} 2700 -22760 0 1 {name=p2284 lab=_80552_/X }
C {sky130_stdcells/o22a_4.sym} 2620 -22760 0 0 {name=X_80552_ }
C {devices/lab_pin.sym} 2540 -22640 0 0 {name=p2285 lab=_68272_/X }
C {devices/lab_pin.sym} 2540 -22600 0 0 {name=p2286 lab=_67674_/Y }
C {devices/lab_pin.sym} 2540 -22560 0 0 {name=p2287 lab=_68268_/X }
C {devices/lab_pin.sym} 2540 -22520 0 0 {name=p2288 lab=_68273_/Y }
C {devices/lab_pin.sym} 2700 -22580 0 1 {name=p2289 lab=_68274_/X }
C {sky130_stdcells/a211o_4.sym} 2620 -22580 0 0 {name=X_68274_ }
C {devices/lab_pin.sym} 2580 -22430 0 0 {name=p2290 lab=_65486_/A }
C {devices/lab_pin.sym} 2660 -22430 0 1 {name=p2291 lab=_65667_/A }
C {sky130_stdcells/buf_2.sym} 2620 -22430 0 0 {name=X_65486_ }
C {devices/lab_pin.sym} 2540 -22330 0 0 {name=p2292 lab=_62696_/X }
C {devices/lab_pin.sym} 2540 -22290 0 0 {name=p2293 lab=_62652_/X }
C {devices/lab_pin.sym} 2540 -22250 0 0 {name=p2294 lab=_62697_/Y }
C {devices/lab_pin.sym} 2700 -22290 0 1 {name=p2295 lab=_62698_/Y }
C {sky130_stdcells/a21oi_4.sym} 2620 -22290 0 0 {name=X_62698_ }
C {devices/lab_pin.sym} 2580 -22150 0 0 {name=p2296 lab=clkbuf_9_188_0_CLK/X }
C {devices/lab_pin.sym} 2660 -22150 0 1 {name=p2297 lab=_83716_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 2620 -22150 0 0 {name=Xclkbuf_10_377_0_CLK }
C {devices/lab_pin.sym} 2580 -22030 0 0 {name=p2298 lab=_66572_/X }
C {devices/lab_pin.sym} 2660 -22030 0 1 {name=p2299 lab=_67226_/A }
C {sky130_stdcells/buf_2.sym} 2620 -22030 0 0 {name=X_67225_ }
C {devices/lab_pin.sym} 2540 -21930 0 0 {name=p2300 lab=_52449_/Y }
C {devices/lab_pin.sym} 2540 -21890 0 0 {name=p2301 lab=_52415_/X }
C {devices/lab_pin.sym} 2540 -21850 0 0 {name=p2302 lab=_52450_/X }
C {devices/lab_pin.sym} 2700 -21890 0 1 {name=p2303 lab=_52451_/Y }
C {sky130_stdcells/a21oi_4.sym} 2620 -21890 0 0 {name=X_52451_ }
C {devices/lab_pin.sym} 2580 -21750 0 0 {name=p2304 lab=_61101_/A }
C {devices/lab_pin.sym} 2660 -21750 0 1 {name=p2305 lab=_64515_/C }
C {sky130_stdcells/buf_2.sym} 2620 -21750 0 0 {name=X_64437_ }
C {devices/lab_pin.sym} 2530 -21630 0 0 {name=p2306 lab=_83627_/CLK }
C {devices/lab_pin.sym} 2530 -21610 0 0 {name=p2307 lab=_72249_/Y }
C {devices/lab_pin.sym} 2710 -21630 0 1 {name=p2308 lab=_72236_/A }
C {sky130_stdcells/dfxtp_4.sym} 2620 -21620 0 0 {name=X_83271_ }
C {devices/lab_pin.sym} 2560 -21510 0 0 {name=p2309 lab=_61636_/A }
C {devices/lab_pin.sym} 2560 -21470 0 0 {name=p2310 lab=_61649_/B }
C {devices/lab_pin.sym} 2560 -21430 0 0 {name=p2311 lab=_61682_/C }
C {devices/lab_pin.sym} 2680 -21470 0 1 {name=p2312 lab=_61649_/Y }
C {sky130_stdcells/nand3_4.sym} 2620 -21470 0 0 {name=X_61649_ }
C {devices/lab_pin.sym} 2560 -21340 0 0 {name=p2313 lab=_59159_/A }
C {devices/lab_pin.sym} 2560 -21300 0 0 {name=p2314 lab=_84156_/Q }
C {devices/lab_pin.sym} 2680 -21320 0 1 {name=p2315 lab=_80494_/A }
C {sky130_stdcells/xor2_4.sym} 2620 -21320 0 0 {name=X_80483_ }
C {devices/lab_pin.sym} 2530 -21190 0 0 {name=p2316 lab=_85041_/CLK }
C {devices/lab_pin.sym} 2530 -21170 0 0 {name=p2317 lab=_57407_/X }
C {devices/lab_pin.sym} 2710 -21190 0 1 {name=p2318 lab=_55483_/A }
C {sky130_stdcells/dfxtp_4.sym} 2620 -21180 0 0 {name=X_85010_ }
C {devices/lab_pin.sym} 2580 -21050 0 0 {name=p2319 lab=_51128_/A }
C {devices/lab_pin.sym} 2660 -21050 0 1 {name=p2320 lab=_51402_/X }
C {sky130_stdcells/buf_2.sym} 2620 -21050 0 0 {name=X_51402_ }
C {devices/lab_pin.sym} 2530 -20930 0 0 {name=p2321 lab=_81883_/CLK }
C {devices/lab_pin.sym} 2530 -20910 0 0 {name=p2322 lab=_82254_/Q }
C {devices/lab_pin.sym} 2710 -20930 0 1 {name=p2323 lab=_77392_/A }
C {sky130_stdcells/dfxtp_4.sym} 2620 -20920 0 0 {name=X_82222_ }
C {devices/lab_pin.sym} 2540 -20820 0 0 {name=p2324 lab=_85036_/Q }
C {devices/lab_pin.sym} 2540 -20780 0 0 {name=p2325 lab=_55157_/X }
C {devices/lab_pin.sym} 2540 -20740 0 0 {name=p2326 lab=_55168_/X }
C {devices/lab_pin.sym} 2540 -20700 0 0 {name=p2327 lab=_55169_/X }
C {devices/lab_pin.sym} 2700 -20760 0 1 {name=p2328 lab=_55170_/X }
C {sky130_stdcells/a211o_4.sym} 2620 -20760 0 0 {name=X_55170_ }
C {devices/lab_pin.sym} 2580 -20610 0 0 {name=p2329 lab=_66915_/A }
C {devices/lab_pin.sym} 2660 -20610 0 1 {name=p2330 lab=_67156_/X }
C {sky130_stdcells/buf_2.sym} 2620 -20610 0 0 {name=X_67156_ }
C {devices/lab_pin.sym} 2540 -20510 0 0 {name=p2331 lab=_52380_/Y }
C {devices/lab_pin.sym} 2540 -20470 0 0 {name=p2332 lab=_52364_/X }
C {devices/lab_pin.sym} 2540 -20430 0 0 {name=p2333 lab=_52381_/X }
C {devices/lab_pin.sym} 2700 -20470 0 1 {name=p2334 lab=_85834_/D }
C {sky130_stdcells/a21oi_4.sym} 2620 -20470 0 0 {name=X_52382_ }
C {devices/lab_pin.sym} 2560 -20350 0 0 {name=p2335 lab=_64336_/A }
C {devices/lab_pin.sym} 2560 -20310 0 0 {name=p2336 lab=_84820_/Q }
C {devices/lab_pin.sym} 2560 -20270 0 0 {name=p2337 lab=_64323_/X }
C {devices/lab_pin.sym} 2680 -20310 0 1 {name=p2338 lab=_64368_/Y }
C {sky130_stdcells/nand3_4.sym} 2620 -20310 0 0 {name=X_64368_ }
C {devices/lab_pin.sym} 2580 -20170 0 0 {name=p2339 lab=clkbuf_9_499_0_CLK/A }
C {devices/lab_pin.sym} 2660 -20170 0 1 {name=p2340 lab=clkbuf_9_498_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 2620 -20170 0 0 {name=Xclkbuf_9_498_0_CLK }
C {devices/lab_pin.sym} 2560 -20060 0 0 {name=p2341 lab=_54134_/A }
C {devices/lab_pin.sym} 2560 -20020 0 0 {name=p2342 lab=_54121_/B }
C {devices/lab_pin.sym} 2680 -20040 0 1 {name=p2343 lab=_54121_/Y }
C {sky130_stdcells/nand2_4.sym} 2620 -20040 0 0 {name=X_54121_ }
C {devices/lab_pin.sym} 2580 -19910 0 0 {name=p2344 lab=_65045_/A }
C {devices/lab_pin.sym} 2660 -19910 0 1 {name=p2345 lab=_66164_/B }
C {sky130_stdcells/buf_2.sym} 2620 -19910 0 0 {name=X_66107_ }
C {devices/lab_pin.sym} 2580 -19790 0 0 {name=p2346 lab=_50063_/A }
C {devices/lab_pin.sym} 2660 -19790 0 1 {name=p2347 lab=_51790_/A }
C {sky130_stdcells/buf_2.sym} 2620 -19790 0 0 {name=X_51333_ }
C {devices/lab_pin.sym} 2540 -19690 0 0 {name=p2348 lab=_79212_/A }
C {devices/lab_pin.sym} 2540 -19650 0 0 {name=p2349 lab=_63310_/X }
C {devices/lab_pin.sym} 2540 -19610 0 0 {name=p2350 lab=_63318_/X }
C {devices/lab_pin.sym} 2700 -19650 0 1 {name=p2351 lab=_63319_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -19650 0 0 {name=X_63319_ }
C {devices/lab_pin.sym} 2530 -19510 0 0 {name=p2352 lab=_84175_/CLK }
C {devices/lab_pin.sym} 2530 -19490 0 0 {name=p2353 lab=_84145_/Q }
C {devices/lab_pin.sym} 2710 -19510 0 1 {name=p2354 lab=_82153_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -19500 0 0 {name=X_82153_ }
C {devices/lab_pin.sym} 2580 -19370 0 0 {name=p2355 lab=clkbuf_9_150_0_CLK/X }
C {devices/lab_pin.sym} 2660 -19370 0 1 {name=p2356 lab=_84308_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 2620 -19370 0 0 {name=Xclkbuf_10_300_0_CLK }
C {devices/lab_pin.sym} 2560 -19260 0 0 {name=p2357 lab=_67087_/A }
C {devices/lab_pin.sym} 2560 -19220 0 0 {name=p2358 lab=_67087_/B }
C {devices/lab_pin.sym} 2680 -19240 0 1 {name=p2359 lab=_67087_/X }
C {sky130_stdcells/and2_4.sym} 2620 -19240 0 0 {name=X_67087_ }
C {devices/lab_pin.sym} 2540 -19130 0 0 {name=p2360 lab=_64292_/Y }
C {devices/lab_pin.sym} 2540 -19090 0 0 {name=p2361 lab=_64298_/X }
C {devices/lab_pin.sym} 2540 -19050 0 0 {name=p2362 lab=_64269_/X }
C {devices/lab_pin.sym} 2700 -19090 0 1 {name=p2363 lab=_64299_/X }
C {sky130_stdcells/o21a_4.sym} 2620 -19090 0 0 {name=X_64299_ }
C {devices/lab_pin.sym} 2580 -18950 0 0 {name=p2364 lab=clkbuf_9_465_0_CLK/X }
C {devices/lab_pin.sym} 2660 -18950 0 1 {name=p2365 lab=_87288_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 2620 -18950 0 0 {name=Xclkbuf_10_930_0_CLK }
C {devices/lab_pin.sym} 2530 -18830 0 0 {name=p2366 lab=_81104_/CLK }
C {devices/lab_pin.sym} 2530 -18810 0 0 {name=p2367 lab=_79709_/X }
C {devices/lab_pin.sym} 2710 -18830 0 1 {name=p2368 lab=_81104_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -18820 0 0 {name=X_81104_ }
C {devices/lab_pin.sym} 2560 -18710 0 0 {name=p2369 lab=_46507_/A }
C {devices/lab_pin.sym} 2560 -18670 0 0 {name=p2370 lab=_54043_/B }
C {devices/lab_pin.sym} 2560 -18630 0 0 {name=p2371 lab=_51749_/X }
C {devices/lab_pin.sym} 2680 -18670 0 1 {name=p2372 lab=_54052_/X }
C {sky130_stdcells/and3_4.sym} 2620 -18670 0 0 {name=X_54052_ }
C {devices/lab_pin.sym} 2540 -18560 0 0 {name=p2373 lab=_65876_/X }
C {devices/lab_pin.sym} 2540 -18520 0 0 {name=p2374 lab=_85624_/Q }
C {devices/lab_pin.sym} 2540 -18480 0 0 {name=p2375 lab=_65976_/X }
C {devices/lab_pin.sym} 2540 -18440 0 0 {name=p2376 lab=_66037_/X }
C {devices/lab_pin.sym} 2700 -18500 0 1 {name=p2377 lab=_66038_/X }
C {sky130_stdcells/a211o_4.sym} 2620 -18500 0 0 {name=X_66038_ }
C {devices/lab_pin.sym} 2580 -18350 0 0 {name=p2378 lab=_52139_/A }
C {devices/lab_pin.sym} 2660 -18350 0 1 {name=p2379 lab=_51265_/A }
C {sky130_stdcells/buf_2.sym} 2620 -18350 0 0 {name=X_51264_ }
C {devices/lab_pin.sym} 2530 -18230 0 0 {name=p2380 lab=_88232_/CLK }
C {devices/lab_pin.sym} 2530 -18210 0 0 {name=p2381 lab=_44777_/X }
C {devices/lab_pin.sym} 2710 -18230 0 1 {name=p2382 lab=_86961_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -18220 0 0 {name=X_86961_ }
C {devices/lab_pin.sym} 2530 -18090 0 0 {name=p2383 lab=_82084_/CLK }
C {devices/lab_pin.sym} 2530 -18070 0 0 {name=p2384 lab=_82084_/D }
C {devices/lab_pin.sym} 2710 -18090 0 1 {name=p2385 lab=_77017_/A }
C {sky130_stdcells/dfxtp_4.sym} 2620 -18080 0 0 {name=X_82084_ }
C {devices/lab_pin.sym} 2560 -17980 0 0 {name=p2386 lab=_53019_/A }
C {devices/lab_pin.sym} 2560 -17940 0 0 {name=p2387 lab=_52997_/B }
C {devices/lab_pin.sym} 2560 -17900 0 0 {name=p2388 lab=_52997_/C }
C {devices/lab_pin.sym} 2560 -17860 0 0 {name=p2389 lab=_53003_/D }
C {devices/lab_pin.sym} 2680 -17920 0 1 {name=p2390 lab=_53003_/X }
C {sky130_stdcells/and4_4.sym} 2620 -17920 0 0 {name=X_53003_ }
C {devices/lab_pin.sym} 2580 -17770 0 0 {name=p2391 lab=clkbuf_8_210_0_CLK/X }
C {devices/lab_pin.sym} 2660 -17770 0 1 {name=p2392 lab=clkbuf_9_421_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 2620 -17770 0 0 {name=Xclkbuf_9_421_0_CLK }
C {devices/lab_pin.sym} 2540 -17670 0 0 {name=p2393 lab=_42373_/X }
C {devices/lab_pin.sym} 2540 -17630 0 0 {name=p2394 lab=_57491_/C }
C {devices/lab_pin.sym} 2540 -17590 0 0 {name=p2395 lab=_50214_/Y }
C {devices/lab_pin.sym} 2700 -17630 0 1 {name=p2396 lab=_50215_/X }
C {sky130_stdcells/o21a_4.sym} 2620 -17630 0 0 {name=X_50215_ }
C {devices/lab_pin.sym} 2530 -17490 0 0 {name=p2397 lab=_86587_/CLK }
C {devices/lab_pin.sym} 2530 -17470 0 0 {name=p2398 lab=_51984_/Y }
C {devices/lab_pin.sym} 2710 -17490 0 1 {name=p2399 lab=_73780_/B }
C {sky130_stdcells/dfxtp_4.sym} 2620 -17480 0 0 {name=X_85912_ }
C {devices/lab_pin.sym} 2530 -17350 0 0 {name=p2400 lab=_81061_/CLK }
C {devices/lab_pin.sym} 2530 -17330 0 0 {name=p2401 lab=_81035_/D }
C {devices/lab_pin.sym} 2710 -17350 0 1 {name=p2402 lab=_81035_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -17340 0 0 {name=X_81035_ }
C {devices/lab_pin.sym} 2540 -17230 0 0 {name=p2403 lab=_58858_/X }
C {devices/lab_pin.sym} 2540 -17190 0 0 {name=p2404 lab=_85450_/Q }
C {devices/lab_pin.sym} 2540 -17150 0 0 {name=p2405 lab=_58859_/X }
C {devices/lab_pin.sym} 2700 -17190 0 1 {name=p2406 lab=_58860_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -17190 0 0 {name=X_58860_ }
C {devices/lab_pin.sym} 2540 -17070 0 0 {name=p2407 lab=_86056_/Q }
C {devices/lab_pin.sym} 2540 -17030 0 0 {name=p2408 lab=_51183_/X }
C {devices/lab_pin.sym} 2540 -16990 0 0 {name=p2409 lab=_51194_/Y }
C {devices/lab_pin.sym} 2700 -17030 0 1 {name=p2410 lab=_51195_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -17030 0 0 {name=X_51195_ }
C {devices/lab_pin.sym} 2530 -16890 0 0 {name=p2411 lab=_86861_/CLK }
C {devices/lab_pin.sym} 2530 -16870 0 0 {name=p2412 lab=_45205_/Y }
C {devices/lab_pin.sym} 2710 -16890 0 1 {name=p2413 lab=_64434_/B }
C {sky130_stdcells/dfxtp_4.sym} 2620 -16880 0 0 {name=X_86892_ }
C {devices/lab_pin.sym} 2580 -16750 0 0 {name=p2414 lab=clkbuf_9_157_0_CLK/X }
C {devices/lab_pin.sym} 2660 -16750 0 1 {name=p2415 lab=_83476_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 2620 -16750 0 0 {name=Xclkbuf_10_315_0_CLK }
C {devices/lab_pin.sym} 2580 -16630 0 0 {name=p2416 lab=_57811_/A }
C {devices/lab_pin.sym} 2660 -16630 0 1 {name=p2417 lab=_57811_/X }
C {sky130_stdcells/buf_2.sym} 2620 -16630 0 0 {name=X_57811_ }
C {devices/lab_pin.sym} 2580 -16510 0 0 {name=p2418 lab=_48853_/A }
C {devices/lab_pin.sym} 2660 -16510 0 1 {name=p2419 lab=_50147_/C }
C {sky130_stdcells/buf_2.sym} 2620 -16510 0 0 {name=X_50146_ }
C {devices/lab_pin.sym} 2530 -16390 0 0 {name=p2420 lab=_85555_/CLK }
C {devices/lab_pin.sym} 2530 -16370 0 0 {name=p2421 lab=_52337_/Y }
C {devices/lab_pin.sym} 2710 -16390 0 1 {name=p2422 lab=_85843_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -16380 0 0 {name=X_85843_ }
C {devices/lab_pin.sym} 2540 -16280 0 0 {name=p2423 lab=_84800_/Q }
C {devices/lab_pin.sym} 2540 -16240 0 0 {name=p2424 lab=_58725_/X }
C {devices/lab_pin.sym} 2540 -16200 0 0 {name=p2425 lab=_58781_/X }
C {devices/lab_pin.sym} 2540 -16160 0 0 {name=p2426 lab=_58790_/X }
C {devices/lab_pin.sym} 2700 -16220 0 1 {name=p2427 lab=_84800_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 2620 -16220 0 0 {name=X_58791_ }
C {devices/lab_pin.sym} 2540 -16100 0 0 {name=p2428 lab=_87384_/Q }
C {devices/lab_pin.sym} 2540 -16060 0 0 {name=p2429 lab=_67987_/X }
C {devices/lab_pin.sym} 2540 -16020 0 0 {name=p2430 lab=_67938_/X }
C {devices/lab_pin.sym} 2540 -15980 0 0 {name=p2431 lab=_67988_/X }
C {devices/lab_pin.sym} 2700 -16040 0 1 {name=p2432 lab=_67989_/X }
C {sky130_stdcells/a211o_4.sym} 2620 -16040 0 0 {name=X_67989_ }
C {devices/lab_pin.sym} 2580 -15890 0 0 {name=p2433 lab=clkbuf_9_472_0_CLK/X }
C {devices/lab_pin.sym} 2660 -15890 0 1 {name=p2434 lab=_87063_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 2620 -15890 0 0 {name=Xclkbuf_10_945_0_CLK }
C {devices/lab_pin.sym} 2540 -15790 0 0 {name=p2435 lab=_57738_/Y }
C {devices/lab_pin.sym} 2540 -15750 0 0 {name=p2436 lab=_57741_/Y }
C {devices/lab_pin.sym} 2540 -15710 0 0 {name=p2437 lab=_57718_/X }
C {devices/lab_pin.sym} 2700 -15750 0 1 {name=p2438 lab=_57742_/X }
C {sky130_stdcells/a21o_4.sym} 2620 -15750 0 0 {name=X_57742_ }
C {devices/lab_pin.sym} 2580 -15610 0 0 {name=p2439 lab=_69575_/A }
C {devices/lab_pin.sym} 2660 -15610 0 1 {name=p2440 lab=_69728_/X }
C {sky130_stdcells/buf_2.sym} 2620 -15610 0 0 {name=X_69728_ }
C {devices/lab_pin.sym} 2580 -15490 0 0 {name=p2441 lab=_48833_/A }
C {devices/lab_pin.sym} 2660 -15490 0 1 {name=p2442 lab=_50082_/B }
C {sky130_stdcells/buf_2.sym} 2620 -15490 0 0 {name=X_50077_ }
C {devices/lab_pin.sym} 2540 -15390 0 0 {name=p2443 lab=_85346_/Q }
C {devices/lab_pin.sym} 2540 -15350 0 0 {name=p2444 lab=_53449_/X }
C {devices/lab_pin.sym} 2540 -15310 0 0 {name=p2445 lab=_54953_/Y }
C {devices/lab_pin.sym} 2700 -15350 0 1 {name=p2446 lab=_54954_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -15350 0 0 {name=X_54954_ }
C {devices/lab_pin.sym} 2530 -15210 0 0 {name=p2447 lab=_85778_/CLK }
C {devices/lab_pin.sym} 2530 -15190 0 0 {name=p2448 lab=_52682_/Y }
C {devices/lab_pin.sym} 2710 -15210 0 1 {name=p2449 lab=_85774_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -15200 0 0 {name=X_85774_ }
C {devices/lab_pin.sym} 2530 -15070 0 0 {name=p2450 lab=_82987_/CLK }
C {devices/lab_pin.sym} 2530 -15050 0 0 {name=p2451 lab=_74684_/Y }
C {devices/lab_pin.sym} 2710 -15070 0 1 {name=p2452 lab=_82986_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -15060 0 0 {name=X_82986_ }
C {devices/lab_pin.sym} 2580 -14930 0 0 {name=p2453 lab=clkbuf_8_218_0_CLK/X }
C {devices/lab_pin.sym} 2660 -14930 0 1 {name=p2454 lab=clkbuf_9_436_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 2620 -14930 0 0 {name=Xclkbuf_9_436_0_CLK }
C {devices/lab_pin.sym} 2530 -14810 0 0 {name=p2455 lab=_87520_/CLK }
C {devices/lab_pin.sym} 2530 -14790 0 0 {name=p2456 lab=_87513_/D }
C {devices/lab_pin.sym} 2710 -14810 0 1 {name=p2457 lab=_87513_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -14800 0 0 {name=X_87513_ }
C {devices/lab_pin.sym} 2540 -14690 0 0 {name=p2458 lab=_85545_/Q }
C {devices/lab_pin.sym} 2540 -14650 0 0 {name=p2459 lab=_53896_/X }
C {devices/lab_pin.sym} 2540 -14610 0 0 {name=p2460 lab=_53904_/Y }
C {devices/lab_pin.sym} 2700 -14650 0 1 {name=p2461 lab=_53905_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -14650 0 0 {name=X_53905_ }
C {devices/lab_pin.sym} 2530 -14510 0 0 {name=p2462 lab=_83464_/CLK }
C {devices/lab_pin.sym} 2530 -14490 0 0 {name=p2463 lab=_84725_/D }
C {devices/lab_pin.sym} 2710 -14510 0 1 {name=p2464 lab=_59463_/A }
C {sky130_stdcells/dfxtp_4.sym} 2620 -14500 0 0 {name=X_84725_ }
C {devices/lab_pin.sym} 2530 -14370 0 0 {name=p2465 lab=_81989_/CLK }
C {devices/lab_pin.sym} 2530 -14350 0 0 {name=p2466 lab=_77876_/Y }
C {devices/lab_pin.sym} 2710 -14370 0 1 {name=p2467 lab=_77453_/A }
C {sky130_stdcells/dfxtp_4.sym} 2620 -14360 0 0 {name=X_81937_ }
C {devices/lab_pin.sym} 2580 -14230 0 0 {name=p2468 lab=_57673_/A }
C {devices/lab_pin.sym} 2660 -14230 0 1 {name=p2469 lab=_58230_/A }
C {sky130_stdcells/buf_2.sym} 2620 -14230 0 0 {name=X_57673_ }
C {devices/lab_pin.sym} 2560 -14120 0 0 {name=p2470 lab=_69086_/A }
C {devices/lab_pin.sym} 2560 -14080 0 0 {name=p2471 lab=_72947_/A }
C {devices/lab_pin.sym} 2680 -14100 0 1 {name=p2472 lab=_69659_/X }
C {sky130_stdcells/and2_4.sym} 2620 -14100 0 0 {name=X_69659_ }
C {devices/lab_pin.sym} 2560 -13980 0 0 {name=p2473 lab=_54885_/A }
C {devices/lab_pin.sym} 2560 -13940 0 0 {name=p2474 lab=_54885_/B }
C {devices/lab_pin.sym} 2680 -13960 0 1 {name=p2475 lab=_54885_/Y }
C {sky130_stdcells/nand2_4.sym} 2620 -13960 0 0 {name=X_54885_ }
C {devices/lab_pin.sym} 2540 -13850 0 0 {name=p2476 lab=_59394_/X }
C {devices/lab_pin.sym} 2540 -13810 0 0 {name=p2477 lab=_83484_/Q }
C {devices/lab_pin.sym} 2540 -13770 0 0 {name=p2478 lab=_59411_/Y }
C {devices/lab_pin.sym} 2700 -13810 0 1 {name=p2479 lab=_84740_/D }
C {sky130_stdcells/o21a_4.sym} 2620 -13810 0 0 {name=X_59412_ }
C {devices/lab_pin.sym} 2540 -13690 0 0 {name=p2480 lab=_56629_/B }
C {devices/lab_pin.sym} 2540 -13650 0 0 {name=p2481 lab=_72664_/C }
C {devices/lab_pin.sym} 2540 -13610 0 0 {name=p2482 lab=_72662_/C }
C {devices/lab_pin.sym} 2700 -13650 0 1 {name=p2483 lab=_56624_/Y }
C {sky130_stdcells/a21oi_4.sym} 2620 -13650 0 0 {name=X_56624_ }
C {devices/lab_pin.sym} 2530 -13510 0 0 {name=p2484 lab=_88201_/CLK }
C {devices/lab_pin.sym} 2530 -13490 0 0 {name=p2485 lab=_87444_/D }
C {devices/lab_pin.sym} 2710 -13510 0 1 {name=p2486 lab=_87444_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -13500 0 0 {name=X_87444_ }
C {devices/lab_pin.sym} 2540 -13410 0 0 {name=p2487 lab=_41839_/X }
C {devices/lab_pin.sym} 2540 -13370 0 0 {name=p2488 lab=_41841_/X }
C {devices/lab_pin.sym} 2540 -13330 0 0 {name=p2489 lab=_40515_/X }
C {devices/lab_pin.sym} 2540 -13290 0 0 {name=p2490 lab=_88123_/Q }
C {devices/lab_pin.sym} 2540 -13250 0 0 {name=p2491 lab=_41835_/X }
C {devices/lab_pin.sym} 2700 -13330 0 1 {name=p2492 lab=_41851_/A }
C {sky130_stdcells/o32ai_4.sym} 2620 -13330 0 0 {name=X_41850_ }
C {devices/lab_pin.sym} 2560 -13180 0 0 {name=p2493 lab=_53819_/A }
C {devices/lab_pin.sym} 2560 -13140 0 0 {name=p2494 lab=_72012_/B }
C {devices/lab_pin.sym} 2680 -13160 0 1 {name=p2495 lab=_53836_/Y }
C {sky130_stdcells/nand2_4.sym} 2620 -13160 0 0 {name=X_53836_ }
C {devices/lab_pin.sym} 2560 -13050 0 0 {name=p2496 lab=_72668_/A }
C {devices/lab_pin.sym} 2560 -13010 0 0 {name=p2497 lab=_72668_/B }
C {devices/lab_pin.sym} 2560 -12970 0 0 {name=p2498 lab=_55646_/X }
C {devices/lab_pin.sym} 2680 -13010 0 1 {name=p2499 lab=_72670_/Y }
C {sky130_stdcells/nand3_4.sym} 2620 -13010 0 0 {name=X_72670_ }
C {devices/lab_pin.sym} 2530 -12870 0 0 {name=p2500 lab=_84672_/CLK }
C {devices/lab_pin.sym} 2530 -12850 0 0 {name=p2501 lab=_84656_/D }
C {devices/lab_pin.sym} 2710 -12870 0 1 {name=p2502 lab=_84656_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -12860 0 0 {name=X_84656_ }
C {devices/lab_pin.sym} 2530 -12730 0 0 {name=p2503 lab=_84441_/CLK }
C {devices/lab_pin.sym} 2530 -12710 0 0 {name=p2504 lab=_78059_/X }
C {devices/lab_pin.sym} 2710 -12730 0 1 {name=p2505 lab=_81868_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -12720 0 0 {name=X_81868_ }
C {devices/lab_pin.sym} 2540 -12610 0 0 {name=p2506 lab=_40628_/X }
C {devices/lab_pin.sym} 2540 -12570 0 0 {name=p2507 lab=_82874_/Q }
C {devices/lab_pin.sym} 2540 -12530 0 0 {name=p2508 lab=_40800_/X }
C {devices/lab_pin.sym} 2700 -12570 0 1 {name=p2509 lab=_40802_/A }
C {sky130_stdcells/o21ai_4.sym} 2620 -12570 0 0 {name=X_40801_ }
C {devices/lab_pin.sym} 2540 -12470 0 0 {name=p2510 lab=_59325_/X }
C {devices/lab_pin.sym} 2540 -12430 0 0 {name=p2511 lab=_59340_/Y }
C {devices/lab_pin.sym} 2540 -12390 0 0 {name=p2512 lab=_59341_/Y }
C {devices/lab_pin.sym} 2540 -12350 0 0 {name=p2513 lab=_59342_/X }
C {devices/lab_pin.sym} 2540 -12310 0 0 {name=p2514 lab=_59329_/X }
C {devices/lab_pin.sym} 2700 -12390 0 1 {name=p2515 lab=_59343_/X }
C {sky130_stdcells/o32a_4.sym} 2620 -12390 0 0 {name=X_59343_ }
C {devices/lab_pin.sym} 2540 -12250 0 0 {name=p2516 lab=_71603_/Y }
C {devices/lab_pin.sym} 2540 -12210 0 0 {name=p2517 lab=_83435_/Q }
C {devices/lab_pin.sym} 2540 -12170 0 0 {name=p2518 lab=_71620_/Y }
C {devices/lab_pin.sym} 2700 -12210 0 1 {name=p2519 lab=_83435_/D }
C {sky130_stdcells/a21o_4.sym} 2620 -12210 0 0 {name=X_71621_ }
C {devices/lab_pin.sym} 2530 -12070 0 0 {name=p2520 lab=_85837_/CLK }
C {devices/lab_pin.sym} 2530 -12050 0 0 {name=p2521 lab=_83607_/D }
C {devices/lab_pin.sym} 2710 -12070 0 1 {name=p2522 lab=_83607_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -12060 0 0 {name=X_83607_ }
C {devices/lab_pin.sym} 2560 -11950 0 0 {name=p2523 lab=_55504_/Y }
C {devices/lab_pin.sym} 2560 -11910 0 0 {name=p2524 lab=_56580_/B }
C {devices/lab_pin.sym} 2560 -11870 0 0 {name=p2525 lab=_55552_/X }
C {devices/lab_pin.sym} 2680 -11910 0 1 {name=p2526 lab=_56556_/A }
C {sky130_stdcells/nand3_4.sym} 2620 -11910 0 0 {name=X_56555_ }
C {devices/lab_pin.sym} 2530 -11770 0 0 {name=p2527 lab=_80991_/CLK }
C {devices/lab_pin.sym} 2530 -11750 0 0 {name=p2528 lab=_83963_/Q }
C {devices/lab_pin.sym} 2710 -11770 0 1 {name=p2529 lab=_80819_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -11760 0 0 {name=X_80819_ }
C {devices/lab_pin.sym} 2530 -11630 0 0 {name=p2530 lab=_86834_/CLK }
C {devices/lab_pin.sym} 2530 -11610 0 0 {name=p2531 lab=_87375_/D }
C {devices/lab_pin.sym} 2710 -11630 0 1 {name=p2532 lab=_87375_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -11620 0 0 {name=X_87375_ }
C {devices/lab_pin.sym} 2540 -11510 0 0 {name=p2533 lab=_85572_/Q }
C {devices/lab_pin.sym} 2540 -11470 0 0 {name=p2534 lab=_53754_/X }
C {devices/lab_pin.sym} 2540 -11430 0 0 {name=p2535 lab=_53766_/Y }
C {devices/lab_pin.sym} 2700 -11470 0 1 {name=p2536 lab=_53767_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -11470 0 0 {name=X_53767_ }
C {devices/lab_pin.sym} 2540 -11350 0 0 {name=p2537 lab=_40621_/X }
C {devices/lab_pin.sym} 2540 -11310 0 0 {name=p2538 lab=_41440_/A }
C {devices/lab_pin.sym} 2540 -11270 0 0 {name=p2539 lab=_41780_/X }
C {devices/lab_pin.sym} 2700 -11310 0 1 {name=p2540 lab=_41781_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -11310 0 0 {name=X_41781_ }
C {devices/lab_pin.sym} 2530 -11170 0 0 {name=p2541 lab=_84333_/CLK }
C {devices/lab_pin.sym} 2530 -11150 0 0 {name=p2542 lab=_60611_/X }
C {devices/lab_pin.sym} 2710 -11170 0 1 {name=p2543 lab=_79127_/A }
C {sky130_stdcells/dfxtp_4.sym} 2620 -11160 0 0 {name=X_84587_ }
C {devices/lab_pin.sym} 2560 -11060 0 0 {name=p2544 lab=_50973_/X }
C {devices/lab_pin.sym} 2560 -11020 0 0 {name=p2545 lab=_50963_/B }
C {devices/lab_pin.sym} 2560 -10980 0 0 {name=p2546 lab=_50985_/C }
C {devices/lab_pin.sym} 2560 -10940 0 0 {name=p2547 lab=_46783_/X }
C {devices/lab_pin.sym} 2680 -11000 0 1 {name=p2548 lab=_50979_/X }
C {sky130_stdcells/and4_4.sym} 2620 -11000 0 0 {name=X_50979_ }
C {devices/lab_pin.sym} 2530 -10850 0 0 {name=p2549 lab=_81801_/CLK }
C {devices/lab_pin.sym} 2530 -10830 0 0 {name=p2550 lab=_81607_/Q }
C {devices/lab_pin.sym} 2710 -10850 0 1 {name=p2551 lab=_47473_/A }
C {sky130_stdcells/dfxtp_4.sym} 2620 -10840 0 0 {name=X_81799_ }
C {devices/lab_pin.sym} 2580 -10710 0 0 {name=p2552 lab=_43519_/Y }
C {devices/lab_pin.sym} 2660 -10710 0 1 {name=p2553 lab=_43520_/Y }
C {sky130_stdcells/inv_2.sym} 2620 -10710 0 0 {name=X_43520_ }
C {devices/lab_pin.sym} 2580 -10590 0 0 {name=p2554 lab=_55469_/X }
C {devices/lab_pin.sym} 2660 -10590 0 1 {name=p2555 lab=_55506_/X }
C {sky130_stdcells/buf_2.sym} 2620 -10590 0 0 {name=X_55506_ }
C {devices/lab_pin.sym} 2580 -10470 0 0 {name=p2556 lab=_72943_/A }
C {devices/lab_pin.sym} 2660 -10470 0 1 {name=p2557 lab=_74340_/X }
C {sky130_stdcells/buf_2.sym} 2620 -10470 0 0 {name=X_74340_ }
C {devices/lab_pin.sym} 2530 -10350 0 0 {name=p2558 lab=_86322_/CLK }
C {devices/lab_pin.sym} 2530 -10330 0 0 {name=p2559 lab=_49773_/Y }
C {devices/lab_pin.sym} 2710 -10350 0 1 {name=p2560 lab=_57891_/B }
C {sky130_stdcells/dfxtp_4.sym} 2620 -10340 0 0 {name=X_86326_ }
C {devices/lab_pin.sym} 2560 -10220 0 0 {name=p2561 lab=_40732_/A }
C {devices/lab_pin.sym} 2560 -10180 0 0 {name=p2562 lab=_40710_/B }
C {devices/lab_pin.sym} 2680 -10200 0 1 {name=p2563 lab=_40732_/X }
C {sky130_stdcells/or2_4.sym} 2620 -10200 0 0 {name=X_40732_ }
C {devices/lab_pin.sym} 2560 -10080 0 0 {name=p2564 lab=_52718_/A }
C {devices/lab_pin.sym} 2560 -10040 0 0 {name=p2565 lab=_52718_/B }
C {devices/lab_pin.sym} 2680 -10060 0 1 {name=p2566 lab=_52718_/Y }
C {sky130_stdcells/nand2_4.sym} 2620 -10060 0 0 {name=X_52718_ }
C {devices/lab_pin.sym} 2540 -9950 0 0 {name=p2567 lab=_59273_/X }
C {devices/lab_pin.sym} 2540 -9910 0 0 {name=p2568 lab=_85643_/Q }
C {devices/lab_pin.sym} 2540 -9870 0 0 {name=p2569 lab=_59196_/X }
C {devices/lab_pin.sym} 2700 -9910 0 1 {name=p2570 lab=_59274_/X }
C {sky130_stdcells/o21a_4.sym} 2620 -9910 0 0 {name=X_59274_ }
C {devices/lab_pin.sym} 2580 -9770 0 0 {name=p2571 lab=_71585_/A }
C {devices/lab_pin.sym} 2660 -9770 0 1 {name=p2572 lab=_71553_/B }
C {sky130_stdcells/buf_2.sym} 2620 -9770 0 0 {name=X_71552_ }
C {devices/lab_pin.sym} 2530 -9650 0 0 {name=p2573 lab=_86570_/CLK }
C {devices/lab_pin.sym} 2530 -9630 0 0 {name=p2574 lab=_83538_/D }
C {devices/lab_pin.sym} 2710 -9650 0 1 {name=p2575 lab=_83538_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -9640 0 0 {name=X_83538_ }
C {devices/lab_pin.sym} 2540 -9530 0 0 {name=p2576 lab=_56040_/X }
C {devices/lab_pin.sym} 2540 -9490 0 0 {name=p2577 lab=_56483_/X }
C {devices/lab_pin.sym} 2540 -9450 0 0 {name=p2578 lab=_56485_/Y }
C {devices/lab_pin.sym} 2700 -9490 0 1 {name=p2579 lab=_56486_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -9490 0 0 {name=X_56486_ }
C {devices/lab_pin.sym} 2540 -9370 0 0 {name=p2580 lab=_53695_/Y }
C {devices/lab_pin.sym} 2540 -9330 0 0 {name=p2581 lab=_53696_/X }
C {devices/lab_pin.sym} 2540 -9290 0 0 {name=p2582 lab=_53697_/Y }
C {devices/lab_pin.sym} 2700 -9330 0 1 {name=p2583 lab=_53698_/Y }
C {sky130_stdcells/a21boi_4.sym} 2620 -9330 0 0 {name=X_53698_ }
C {sky130_stdcells/decap_3.sym} 2620 -9160 0 0 {name=XPHY_510 }
C {devices/lab_pin.sym} 2580 -9010 0 0 {name=p2584 lab=_70502_/Y }
C {devices/lab_pin.sym} 2660 -9010 0 1 {name=p2585 lab=_70504_/A }
C {sky130_stdcells/buf_2.sym} 2620 -9010 0 0 {name=X_70503_ }
C {devices/lab_pin.sym} 2580 -8890 0 0 {name=p2586 lab=_58225_/A }
C {devices/lab_pin.sym} 2660 -8890 0 1 {name=p2587 lab=_58225_/X }
C {sky130_stdcells/buf_2.sym} 2620 -8890 0 0 {name=X_58225_ }
C {devices/lab_pin.sym} 2580 -8770 0 0 {name=p2588 lab=_43450_/Y }
C {devices/lab_pin.sym} 2660 -8770 0 1 {name=p2589 lab=_87415_/D }
C {sky130_stdcells/inv_2.sym} 2620 -8770 0 0 {name=X_43451_ }
C {devices/lab_pin.sym} 2580 -8650 0 0 {name=p2590 lab=_55436_/Y }
C {devices/lab_pin.sym} 2660 -8650 0 1 {name=p2591 lab=_55438_/B }
C {sky130_stdcells/inv_2.sym} 2620 -8650 0 0 {name=X_55437_ }
C {devices/lab_pin.sym} 2560 -8540 0 0 {name=p2592 lab=_74038_/A }
C {devices/lab_pin.sym} 2560 -8500 0 0 {name=p2593 lab=_85890_/Q }
C {devices/lab_pin.sym} 2680 -8520 0 1 {name=p2594 lab=_74271_/X }
C {sky130_stdcells/and2_4.sym} 2620 -8520 0 0 {name=X_74271_ }
C {devices/lab_pin.sym} 2530 -8390 0 0 {name=p2595 lab=_85557_/CLK }
C {devices/lab_pin.sym} 2530 -8370 0 0 {name=p2596 lab=_86257_/D }
C {devices/lab_pin.sym} 2710 -8390 0 1 {name=p2597 lab=_65037_/B }
C {sky130_stdcells/dfxtp_4.sym} 2620 -8380 0 0 {name=X_86257_ }
C {sky130_stdcells/decap_3.sym} 2620 -8220 0 0 {name=XPHY_521 }
C {devices/lab_pin.sym} 2580 -8070 0 0 {name=p2598 lab=_40663_/A }
C {devices/lab_pin.sym} 2660 -8070 0 1 {name=p2599 lab=_40663_/Y }
C {sky130_stdcells/inv_2.sym} 2620 -8070 0 0 {name=X_40663_ }
C {devices/lab_pin.sym} 2560 -7980 0 0 {name=p2600 lab=_52648_/X }
C {devices/lab_pin.sym} 2560 -7940 0 0 {name=p2601 lab=_52654_/B }
C {devices/lab_pin.sym} 2560 -7900 0 0 {name=p2602 lab=_52643_/C }
C {devices/lab_pin.sym} 2560 -7860 0 0 {name=p2603 lab=_46744_/X }
C {devices/lab_pin.sym} 2680 -7920 0 1 {name=p2604 lab=_52649_/X }
C {sky130_stdcells/and4_4.sym} 2620 -7920 0 0 {name=X_52649_ }
C {devices/lab_pin.sym} 2560 -7800 0 0 {name=p2605 lab=_71827_/A }
C {devices/lab_pin.sym} 2560 -7760 0 0 {name=p2606 lab=_71483_/B }
C {devices/lab_pin.sym} 2560 -7720 0 0 {name=p2607 lab=_71439_/C }
C {devices/lab_pin.sym} 2560 -7680 0 0 {name=p2608 lab=_71716_/D }
C {devices/lab_pin.sym} 2680 -7740 0 1 {name=p2609 lab=_71483_/X }
C {sky130_stdcells/and4_4.sym} 2620 -7740 0 0 {name=X_71483_ }
C {devices/lab_pin.sym} 2530 -7590 0 0 {name=p2610 lab=_85959_/CLK }
C {devices/lab_pin.sym} 2530 -7570 0 0 {name=p2611 lab=_83469_/D }
C {devices/lab_pin.sym} 2710 -7590 0 1 {name=p2612 lab=_47787_/A }
C {sky130_stdcells/dfxtp_4.sym} 2620 -7580 0 0 {name=X_83469_ }
C {sky130_stdcells/decap_3.sym} 2620 -7420 0 0 {name=XPHY_532 }
C {sky130_stdcells/decap_3.sym} 2620 -7240 0 0 {name=XPHY_543 }
C {devices/lab_pin.sym} 2560 -7100 0 0 {name=p2613 lab=_76010_/A }
C {devices/lab_pin.sym} 2560 -7060 0 0 {name=p2614 lab=_76009_/Y }
C {devices/lab_pin.sym} 2680 -7080 0 1 {name=p2615 lab=_81742_/D }
C {sky130_stdcells/xor2_4.sym} 2620 -7080 0 0 {name=X_76010_ }
C {devices/lab_pin.sym} 2540 -6990 0 0 {name=p2616 lab=_42401_/X }
C {devices/lab_pin.sym} 2540 -6950 0 0 {name=p2617 lab=_42397_/X }
C {devices/lab_pin.sym} 2540 -6910 0 0 {name=p2618 lab=_40432_/X }
C {devices/lab_pin.sym} 2540 -6870 0 0 {name=p2619 lab=_87880_/Q }
C {devices/lab_pin.sym} 2540 -6830 0 0 {name=p2620 lab=_42398_/X }
C {devices/lab_pin.sym} 2700 -6910 0 1 {name=p2621 lab=_42403_/A }
C {sky130_stdcells/o32ai_4.sym} 2620 -6910 0 0 {name=X_42402_ }
C {sky130_stdcells/decap_3.sym} 2620 -6720 0 0 {name=XPHY_554 }
C {devices/lab_pin.sym} 2540 -6590 0 0 {name=p2622 lab=_73219_/X }
C {devices/lab_pin.sym} 2540 -6550 0 0 {name=p2623 lab=_73220_/Y }
C {devices/lab_pin.sym} 2540 -6510 0 0 {name=p2624 lab=_73221_/X }
C {devices/lab_pin.sym} 2700 -6550 0 1 {name=p2625 lab=_73222_/Y }
C {sky130_stdcells/a21oi_4.sym} 2620 -6550 0 0 {name=X_73222_ }
C {devices/lab_pin.sym} 2530 -6410 0 0 {name=p2626 lab=_85269_/CLK }
C {devices/lab_pin.sym} 2530 -6390 0 0 {name=p2627 lab=_85208_/D }
C {devices/lab_pin.sym} 2710 -6410 0 1 {name=p2628 lab=_85208_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -6400 0 0 {name=X_85208_ }
C {devices/lab_pin.sym} 2540 -6290 0 0 {name=p2629 lab=_47932_/B }
C {devices/lab_pin.sym} 2540 -6250 0 0 {name=p2630 lab=_70422_/X }
C {devices/lab_pin.sym} 2540 -6210 0 0 {name=p2631 lab=_70433_/Y }
C {devices/lab_pin.sym} 2700 -6250 0 1 {name=p2632 lab=_83776_/D }
C {sky130_stdcells/o21ai_4.sym} 2620 -6250 0 0 {name=X_70434_ }
C {devices/lab_pin.sym} 2560 -6130 0 0 {name=p2633 lab=_46166_/A }
C {devices/lab_pin.sym} 2560 -6090 0 0 {name=p2634 lab=_45898_/X }
C {devices/lab_pin.sym} 2560 -6050 0 0 {name=p2635 lab=_46170_/C }
C {devices/lab_pin.sym} 2680 -6090 0 1 {name=p2636 lab=_46170_/Y }
C {sky130_stdcells/nand3_4.sym} 2620 -6090 0 0 {name=X_46170_ }
C {devices/lab_pin.sym} 2560 -5960 0 0 {name=p2637 lab=_63389_/A }
C {devices/lab_pin.sym} 2560 -5920 0 0 {name=p2638 lab=_58160_/B }
C {devices/lab_pin.sym} 2680 -5940 0 1 {name=p2639 lab=_58156_/Y }
C {sky130_stdcells/nand2_4.sym} 2620 -5940 0 0 {name=X_58156_ }
C {sky130_stdcells/decap_3.sym} 2620 -5780 0 0 {name=XPHY_565 }
C {devices/lab_pin.sym} 2540 -5670 0 0 {name=p2640 lab=_43367_/X }
C {devices/lab_pin.sym} 2540 -5630 0 0 {name=p2641 lab=_43375_/X }
C {devices/lab_pin.sym} 2540 -5590 0 0 {name=p2642 lab=_41424_/X }
C {devices/lab_pin.sym} 2540 -5550 0 0 {name=p2643 lab=_87450_/Q }
C {devices/lab_pin.sym} 2540 -5510 0 0 {name=p2644 lab=_43378_/X }
C {devices/lab_pin.sym} 2700 -5590 0 1 {name=p2645 lab=_43382_/Y }
C {sky130_stdcells/o32ai_4.sym} 2620 -5590 0 0 {name=X_43382_ }
C {devices/lab_pin.sym} 2580 -5430 0 0 {name=p2646 lab=_55360_/X }
C {devices/lab_pin.sym} 2660 -5430 0 1 {name=p2647 lab=_55368_/Y }
C {sky130_stdcells/inv_2.sym} 2620 -5430 0 0 {name=X_55368_ }
C {devices/lab_pin.sym} 2530 -5310 0 0 {name=p2648 lab=_83307_/CLK }
C {devices/lab_pin.sym} 2530 -5290 0 0 {name=p2649 lab=_86188_/D }
C {devices/lab_pin.sym} 2710 -5310 0 1 {name=p2650 lab=_86188_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -5300 0 0 {name=X_86188_ }
C {sky130_stdcells/decap_3.sym} 2620 -5140 0 0 {name=XPHY_576 }
C {devices/lab_pin.sym} 2580 -4990 0 0 {name=p2651 lab=_48192_/A }
C {devices/lab_pin.sym} 2660 -4990 0 1 {name=p2652 lab=_49569_/A }
C {sky130_stdcells/buf_2.sym} 2620 -4990 0 0 {name=X_40594_ }
C {sky130_stdcells/decap_3.sym} 2620 -4840 0 0 {name=XPHY_587 }
C {sky130_stdcells/decap_3.sym} 2620 -4660 0 0 {name=XPHY_598 }
C {devices/lab_pin.sym} 2540 -4530 0 0 {name=p2653 lab=_56080_/C }
C {devices/lab_pin.sym} 2540 -4490 0 0 {name=p2654 lab=_45120_/X }
C {devices/lab_pin.sym} 2540 -4450 0 0 {name=p2655 lab=_45079_/X }
C {devices/lab_pin.sym} 2700 -4490 0 1 {name=p2656 lab=_45121_/X }
C {sky130_stdcells/o21a_4.sym} 2620 -4490 0 0 {name=X_45121_ }
C {devices/lab_pin.sym} 2560 -4370 0 0 {name=p2657 lab=_56960_/X }
C {devices/lab_pin.sym} 2560 -4330 0 0 {name=p2658 lab=_85083_/Q }
C {devices/lab_pin.sym} 2560 -4290 0 0 {name=p2659 lab=_57087_/X }
C {devices/lab_pin.sym} 2680 -4330 0 1 {name=p2660 lab=_57107_/Y }
C {sky130_stdcells/nor3_4.sym} 2620 -4330 0 0 {name=X_57107_ }
C {devices/lab_pin.sym} 2540 -4220 0 0 {name=p2661 lab=_41663_/X }
C {devices/lab_pin.sym} 2540 -4180 0 0 {name=p2662 lab=_42325_/X }
C {devices/lab_pin.sym} 2540 -4140 0 0 {name=p2663 lab=_87917_/Q }
C {devices/lab_pin.sym} 2540 -4100 0 0 {name=p2664 lab=_42326_/X }
C {devices/lab_pin.sym} 2700 -4160 0 1 {name=p2665 lab=_87917_/D }
C {sky130_stdcells/a2bb2o_4.sym} 2620 -4160 0 0 {name=X_42333_ }
C {devices/lab_pin.sym} 2540 -4030 0 0 {name=p2666 lab=_54315_/Y }
C {devices/lab_pin.sym} 2540 -3990 0 0 {name=p2667 lab=_54311_/X }
C {devices/lab_pin.sym} 2540 -3950 0 0 {name=p2668 lab=_54318_/X }
C {devices/lab_pin.sym} 2700 -3990 0 1 {name=p2669 lab=_85464_/D }
C {sky130_stdcells/a21oi_4.sym} 2620 -3990 0 0 {name=X_54319_ }
C {devices/lab_pin.sym} 2530 -3850 0 0 {name=p2670 lab=_85138_/CLK }
C {devices/lab_pin.sym} 2530 -3830 0 0 {name=p2671 lab=_85139_/D }
C {devices/lab_pin.sym} 2710 -3850 0 1 {name=p2672 lab=_85139_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2620 -3840 0 0 {name=X_85139_ }
C {devices/lab_pin.sym} 2580 -3710 0 0 {name=p2673 lab=_73152_/X }
C {devices/lab_pin.sym} 2660 -3710 0 1 {name=p2674 lab=_73153_/X }
C {sky130_stdcells/buf_2.sym} 2620 -3710 0 0 {name=X_73153_ }
C {devices/lab_pin.sym} 2580 -3590 0 0 {name=p2675 lab=_71003_/A }
C {devices/lab_pin.sym} 2660 -3590 0 1 {name=p2676 lab=_71129_/A }
C {sky130_stdcells/buf_2.sym} 2620 -3590 0 0 {name=X_70365_ }
C {devices/lab_pin.sym} 2540 -3490 0 0 {name=p2677 lab=_58085_/X }
C {devices/lab_pin.sym} 2540 -3450 0 0 {name=p2678 lab=_85382_/Q }
C {devices/lab_pin.sym} 2540 -3410 0 0 {name=p2679 lab=_58086_/X }
C {devices/lab_pin.sym} 2700 -3450 0 1 {name=p2680 lab=_58087_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -3450 0 0 {name=X_58087_ }
C {devices/lab_pin.sym} 2540 -3330 0 0 {name=p2681 lab=_55288_/Y }
C {devices/lab_pin.sym} 2540 -3290 0 0 {name=p2682 lab=_55292_/X }
C {devices/lab_pin.sym} 2540 -3250 0 0 {name=p2683 lab=_55298_/X }
C {devices/lab_pin.sym} 2700 -3290 0 1 {name=p2684 lab=_55299_/Y }
C {sky130_stdcells/a21boi_4.sym} 2620 -3290 0 0 {name=X_55299_ }
C {devices/lab_pin.sym} 2540 -3170 0 0 {name=p2685 lab=_72102_/Y }
C {devices/lab_pin.sym} 2540 -3130 0 0 {name=p2686 lab=_72083_/X }
C {devices/lab_pin.sym} 2540 -3090 0 0 {name=p2687 lab=_72103_/Y }
C {devices/lab_pin.sym} 2700 -3130 0 1 {name=p2688 lab=_72104_/Y }
C {sky130_stdcells/a21boi_4.sym} 2620 -3130 0 0 {name=X_72104_ }
C {devices/lab_pin.sym} 2580 -2990 0 0 {name=p2689 lab=_45350_/A }
C {devices/lab_pin.sym} 2660 -2990 0 1 {name=p2690 lab=_45052_/X }
C {sky130_stdcells/buf_2.sym} 2620 -2990 0 0 {name=X_45052_ }
C {devices/lab_pin.sym} 2560 -2880 0 0 {name=p2691 lab=_56732_/X }
C {devices/lab_pin.sym} 2560 -2840 0 0 {name=p2692 lab=_57038_/B }
C {devices/lab_pin.sym} 2680 -2860 0 1 {name=p2693 lab=_57038_/X }
C {sky130_stdcells/xor2_4.sym} 2620 -2860 0 0 {name=X_57038_ }
C {devices/lab_pin.sym} 2540 -2760 0 0 {name=p2694 lab=_41479_/X }
C {devices/lab_pin.sym} 2540 -2720 0 0 {name=p2695 lab=_42258_/X }
C {devices/lab_pin.sym} 2540 -2680 0 0 {name=p2696 lab=_87951_/Q }
C {devices/lab_pin.sym} 2540 -2640 0 0 {name=p2697 lab=_42259_/X }
C {devices/lab_pin.sym} 2700 -2700 0 1 {name=p2698 lab=_42264_/X }
C {sky130_stdcells/a2bb2o_4.sym} 2620 -2700 0 0 {name=X_42264_ }
C {devices/lab_pin.sym} 2560 -2570 0 0 {name=p2699 lab=_77960_/C }
C {devices/lab_pin.sym} 2560 -2530 0 0 {name=p2700 lab=_77961_/B }
C {devices/lab_pin.sym} 2560 -2490 0 0 {name=p2701 lab=_77944_/B }
C {devices/lab_pin.sym} 2680 -2530 0 1 {name=p2702 lab=_77961_/Y }
C {sky130_stdcells/nand3_4.sym} 2620 -2530 0 0 {name=X_77961_ }
C {devices/lab_pin.sym} 2540 -2420 0 0 {name=p2703 lab=_69722_/B }
C {devices/lab_pin.sym} 2540 -2380 0 0 {name=p2704 lab=_57377_/X }
C {devices/lab_pin.sym} 2540 -2340 0 0 {name=p2705 lab=_73055_/X }
C {devices/lab_pin.sym} 2540 -2300 0 0 {name=p2706 lab=_73083_/Y }
C {devices/lab_pin.sym} 2700 -2360 0 1 {name=p2707 lab=_73084_/X }
C {sky130_stdcells/a211o_4.sym} 2620 -2360 0 0 {name=X_73084_ }
C {devices/lab_pin.sym} 2580 -2210 0 0 {name=p2708 lab=_70246_/A }
C {devices/lab_pin.sym} 2660 -2210 0 1 {name=p2709 lab=_70296_/X }
C {sky130_stdcells/buf_2.sym} 2620 -2210 0 0 {name=X_70296_ }
C {devices/lab_pin.sym} 2580 -2090 0 0 {name=p2710 lab=clkbuf_4_7_1_CLK/X }
C {devices/lab_pin.sym} 2660 -2090 0 1 {name=p2711 lab=clkbuf_6_31_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 2620 -2090 0 0 {name=Xclkbuf_5_15_0_CLK }
C {devices/lab_pin.sym} 2580 -1970 0 0 {name=p2712 lab=_44003_/A }
C {devices/lab_pin.sym} 2660 -1970 0 1 {name=p2713 lab=_44003_/X }
C {sky130_stdcells/buf_2.sym} 2620 -1970 0 0 {name=X_44003_ }
C {devices/lab_pin.sym} 2560 -1860 0 0 {name=p2714 lab=_79700_/A }
C {devices/lab_pin.sym} 2560 -1820 0 0 {name=p2715 lab=_79700_/B }
C {devices/lab_pin.sym} 2680 -1840 0 1 {name=p2716 lab=_79710_/B }
C {sky130_stdcells/xor2_4.sym} 2620 -1840 0 0 {name=X_79700_ }
C {devices/lab_pin.sym} 2540 -1750 0 0 {name=p2717 lab=_41205_/X }
C {devices/lab_pin.sym} 2540 -1710 0 0 {name=p2718 lab=_41206_/X }
C {devices/lab_pin.sym} 2540 -1670 0 0 {name=p2719 lab=_41214_/X }
C {devices/lab_pin.sym} 2540 -1630 0 0 {name=p2720 lab=_88256_/Q }
C {devices/lab_pin.sym} 2540 -1590 0 0 {name=p2721 lab=_41194_/X }
C {devices/lab_pin.sym} 2700 -1670 0 1 {name=p2722 lab=_41216_/A }
C {sky130_stdcells/o32ai_4.sym} 2620 -1670 0 0 {name=X_41215_ }
C {devices/lab_pin.sym} 2540 -1530 0 0 {name=p2723 lab=_72032_/Y }
C {devices/lab_pin.sym} 2540 -1490 0 0 {name=p2724 lab=_72033_/X }
C {devices/lab_pin.sym} 2540 -1450 0 0 {name=p2725 lab=_72034_/Y }
C {devices/lab_pin.sym} 2700 -1490 0 1 {name=p2726 lab=_72035_/Y }
C {sky130_stdcells/a21boi_4.sym} 2620 -1490 0 0 {name=X_72035_ }
C {devices/lab_pin.sym} 2540 -1390 0 0 {name=p2727 lab=_76899_/B }
C {devices/lab_pin.sym} 2540 -1350 0 0 {name=p2728 lab=_76899_/A }
C {devices/lab_pin.sym} 2540 -1310 0 0 {name=p2729 lab=_76888_/C }
C {devices/lab_pin.sym} 2540 -1270 0 0 {name=p2730 lab=_76888_/B }
C {devices/lab_pin.sym} 2540 -1230 0 0 {name=p2731 lab=_76911_/Y }
C {devices/lab_pin.sym} 2700 -1310 0 1 {name=p2732 lab=_76912_/X }
C {sky130_stdcells/o41a_4.sym} 2620 -1310 0 0 {name=X_76912_ }
C {devices/lab_pin.sym} 2540 -1170 0 0 {name=p2733 lab=_58081_/B }
C {devices/lab_pin.sym} 2540 -1130 0 0 {name=p2734 lab=_49853_/X }
C {devices/lab_pin.sym} 2540 -1090 0 0 {name=p2735 lab=_49859_/Y }
C {devices/lab_pin.sym} 2700 -1130 0 1 {name=p2736 lab=_49860_/Y }
C {sky130_stdcells/o21ai_4.sym} 2620 -1130 0 0 {name=X_49860_ }
C {devices/lab_pin.sym} 2540 -1020 0 0 {name=p2737 lab=_41298_/X }
C {devices/lab_pin.sym} 2540 -980 0 0 {name=p2738 lab=_42192_/X }
C {devices/lab_pin.sym} 2540 -940 0 0 {name=p2739 lab=_87985_/Q }
C {devices/lab_pin.sym} 2540 -900 0 0 {name=p2740 lab=_42193_/X }
C {devices/lab_pin.sym} 2700 -960 0 1 {name=p2741 lab=_87985_/D }
C {sky130_stdcells/a2bb2o_4.sym} 2620 -960 0 0 {name=X_42195_ }
C {devices/lab_pin.sym} 2580 -810 0 0 {name=p2742 lab=_77892_/A }
C {devices/lab_pin.sym} 2660 -810 0 1 {name=p2743 lab=_77902_/A }
C {sky130_stdcells/inv_2.sym} 2620 -810 0 0 {name=X_77892_ }
C {devices/lab_pin.sym} 2560 -700 0 0 {name=p2744 lab=_48831_/A }
C {devices/lab_pin.sym} 2560 -660 0 0 {name=p2745 lab=_48811_/B }
C {devices/lab_pin.sym} 2680 -680 0 1 {name=p2746 lab=_48811_/Y }
C {sky130_stdcells/nand2_4.sym} 2620 -680 0 0 {name=X_48811_ }
C {devices/lab_pin.sym} 3480 -42160 0 0 {name=p2747 lab=_79627_/Y }
C {devices/lab_pin.sym} 3480 -42120 0 0 {name=p2748 lab=_79630_/X }
C {devices/lab_pin.sym} 3600 -42140 0 1 {name=p2749 lab=_79633_/A }
C {sky130_stdcells/xor2_4.sym} 3540 -42140 0 0 {name=X_79631_ }
C {devices/lab_pin.sym} 3460 -42030 0 0 {name=p2750 lab=_41143_/X }
C {devices/lab_pin.sym} 3460 -41990 0 0 {name=p2751 lab=_40615_/A }
C {devices/lab_pin.sym} 3460 -41950 0 0 {name=p2752 lab=_41145_/X }
C {devices/lab_pin.sym} 3620 -41990 0 1 {name=p2753 lab=_41147_/A }
C {sky130_stdcells/o21ai_4.sym} 3540 -41990 0 0 {name=X_41146_ }
C {devices/lab_pin.sym} 3460 -41870 0 0 {name=p2754 lab=_76837_/B }
C {devices/lab_pin.sym} 3460 -41830 0 0 {name=p2755 lab=_76837_/A }
C {devices/lab_pin.sym} 3460 -41790 0 0 {name=p2756 lab=_76842_/Y }
C {devices/lab_pin.sym} 3620 -41830 0 1 {name=p2757 lab=_76843_/Y }
C {sky130_stdcells/a21oi_4.sym} 3540 -41830 0 0 {name=X_76843_ }
C {devices/lab_pin.sym} 3480 -41700 0 0 {name=p2758 lab=_49769_/X }
C {devices/lab_pin.sym} 3480 -41660 0 0 {name=p2759 lab=_53005_/B }
C {devices/lab_pin.sym} 3600 -41680 0 1 {name=p2760 lab=_49791_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -41680 0 0 {name=X_49791_ }
C {devices/lab_pin.sym} 3460 -41570 0 0 {name=p2761 lab=_58982_/X }
C {devices/lab_pin.sym} 3460 -41530 0 0 {name=p2762 lab=_83436_/Q }
C {devices/lab_pin.sym} 3460 -41490 0 0 {name=p2763 lab=_58988_/Y }
C {devices/lab_pin.sym} 3620 -41530 0 1 {name=p2764 lab=_84780_/D }
C {sky130_stdcells/o21a_4.sym} 3540 -41530 0 0 {name=X_58989_ }
C {devices/lab_pin.sym} 3460 -41410 0 0 {name=p2765 lab=_65521_/B }
C {devices/lab_pin.sym} 3460 -41370 0 0 {name=p2766 lab=_48730_/X }
C {devices/lab_pin.sym} 3460 -41330 0 0 {name=p2767 lab=_48741_/Y }
C {devices/lab_pin.sym} 3620 -41370 0 1 {name=p2768 lab=_48742_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -41370 0 0 {name=X_48742_ }
C {devices/lab_pin.sym} 3480 -41240 0 0 {name=p2769 lab=_79560_/Y }
C {devices/lab_pin.sym} 3480 -41200 0 0 {name=p2770 lab=_79561_/Y }
C {devices/lab_pin.sym} 3600 -41220 0 1 {name=p2771 lab=_79563_/B }
C {sky130_stdcells/nand2_4.sym} 3540 -41220 0 0 {name=X_79562_ }
C {devices/lab_pin.sym} 3500 -41090 0 0 {name=p2772 lab=_45883_/B }
C {devices/lab_pin.sym} 3580 -41090 0 1 {name=p2773 lab=_45954_/X }
C {sky130_stdcells/buf_2.sym} 3540 -41090 0 0 {name=X_45954_ }
C {devices/lab_pin.sym} 3460 -41010 0 0 {name=p2774 lab=_41040_/X }
C {devices/lab_pin.sym} 3460 -40970 0 0 {name=p2775 lab=_41041_/X }
C {devices/lab_pin.sym} 3460 -40930 0 0 {name=p2776 lab=_41076_/X }
C {devices/lab_pin.sym} 3460 -40890 0 0 {name=p2777 lab=_69486_/B }
C {devices/lab_pin.sym} 3460 -40850 0 0 {name=p2778 lab=_41037_/X }
C {devices/lab_pin.sym} 3620 -40930 0 1 {name=p2779 lab=_41078_/A }
C {sky130_stdcells/o32ai_4.sym} 3540 -40930 0 0 {name=X_41077_ }
C {devices/lab_pin.sym} 3480 -40780 0 0 {name=p2780 lab=_76772_/Y }
C {devices/lab_pin.sym} 3480 -40740 0 0 {name=p2781 lab=_76773_/Y }
C {devices/lab_pin.sym} 3600 -40760 0 1 {name=p2782 lab=_76774_/X }
C {sky130_stdcells/xor2_4.sym} 3540 -40760 0 0 {name=X_76774_ }
C {devices/lab_pin.sym} 3460 -40650 0 0 {name=p2783 lab=_88353_/Q }
C {devices/lab_pin.sym} 3460 -40610 0 0 {name=p2784 lab=_56939_/X }
C {devices/lab_pin.sym} 3460 -40570 0 0 {name=p2785 lab=_72741_/X }
C {devices/lab_pin.sym} 3620 -40610 0 1 {name=p2786 lab=_73986_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -40610 0 0 {name=X_73986_ }
C {devices/lab_pin.sym} 3480 -40480 0 0 {name=p2787 lab=_78499_/A }
C {devices/lab_pin.sym} 3480 -40440 0 0 {name=p2788 lab=_78482_/A }
C {devices/lab_pin.sym} 3600 -40460 0 1 {name=p2789 lab=_78513_/Y }
C {sky130_stdcells/nor2_4.sym} 3540 -40460 0 0 {name=X_78513_ }
C {devices/lab_pin.sym} 3500 -40330 0 0 {name=p2790 lab=_44975_/A }
C {devices/lab_pin.sym} 3580 -40330 0 1 {name=p2791 lab=_44905_/X }
C {sky130_stdcells/buf_2.sym} 3540 -40330 0 0 {name=X_44905_ }
C {devices/lab_pin.sym} 3500 -40210 0 0 {name=p2792 lab=_80915_/Q }
C {devices/lab_pin.sym} 3580 -40210 0 1 {name=p2793 lab=_75727_/A }
C {sky130_stdcells/inv_2.sym} 3540 -40210 0 0 {name=X_75725_ }
C {devices/lab_pin.sym} 3480 -40100 0 0 {name=p2794 lab=_48695_/A }
C {devices/lab_pin.sym} 3480 -40060 0 0 {name=p2795 lab=_48673_/B }
C {devices/lab_pin.sym} 3600 -40080 0 1 {name=p2796 lab=_48673_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -40080 0 0 {name=X_48673_ }
C {devices/lab_pin.sym} 3480 -39960 0 0 {name=p2797 lab=_72934_/X }
C {devices/lab_pin.sym} 3480 -39920 0 0 {name=p2798 lab=_72936_/X }
C {devices/lab_pin.sym} 3600 -39940 0 1 {name=p2799 lab=_72938_/B }
C {sky130_stdcells/nand2_4.sym} 3540 -39940 0 0 {name=X_72937_ }
C {devices/lab_pin.sym} 3500 -39810 0 0 {name=p2800 lab=_60905_/Y }
C {devices/lab_pin.sym} 3580 -39810 0 1 {name=p2801 lab=_60951_/Y }
C {sky130_stdcells/inv_2.sym} 3540 -39810 0 0 {name=X_60951_ }
C {devices/lab_pin.sym} 3480 -39700 0 0 {name=p2802 lab=_79493_/A }
C {devices/lab_pin.sym} 3480 -39660 0 0 {name=p2803 lab=_79493_/B }
C {devices/lab_pin.sym} 3600 -39680 0 1 {name=p2804 lab=_79494_/B }
C {sky130_stdcells/xor2_4.sym} 3540 -39680 0 0 {name=X_79493_ }
C {devices/lab_pin.sym} 3500 -39550 0 0 {name=p2805 lab=_73614_/A }
C {devices/lab_pin.sym} 3580 -39550 0 1 {name=p2806 lab=_45885_/X }
C {sky130_stdcells/buf_2.sym} 3540 -39550 0 0 {name=X_45885_ }
C {devices/lab_pin.sym} 3480 -39440 0 0 {name=p2807 lab=_47649_/A }
C {devices/lab_pin.sym} 3480 -39400 0 0 {name=p2808 lab=_53153_/B }
C {devices/lab_pin.sym} 3600 -39420 0 1 {name=p2809 lab=_47624_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -39420 0 0 {name=X_47624_ }
C {devices/lab_pin.sym} 3480 -39300 0 0 {name=p2810 lab=_82507_/Q }
C {devices/lab_pin.sym} 3480 -39260 0 0 {name=p2811 lab=_82763_/D }
C {devices/lab_pin.sym} 3600 -39280 0 1 {name=p2812 lab=_78444_/X }
C {sky130_stdcells/xor2_4.sym} 3540 -39280 0 0 {name=X_78444_ }
C {devices/lab_pin.sym} 3460 -39190 0 0 {name=p2813 lab=_44832_/X }
C {devices/lab_pin.sym} 3460 -39150 0 0 {name=p2814 lab=_44821_/X }
C {devices/lab_pin.sym} 3460 -39110 0 0 {name=p2815 lab=_41709_/X }
C {devices/lab_pin.sym} 3460 -39070 0 0 {name=p2816 lab=_67693_/B }
C {devices/lab_pin.sym} 3460 -39030 0 0 {name=p2817 lab=_44833_/X }
C {devices/lab_pin.sym} 3620 -39110 0 1 {name=p2818 lab=_44837_/A }
C {sky130_stdcells/o32ai_4.sym} 3540 -39110 0 0 {name=X_44836_ }
C {devices/lab_pin.sym} 3480 -38970 0 0 {name=p2819 lab=_63670_/A }
C {devices/lab_pin.sym} 3480 -38930 0 0 {name=p2820 lab=_63670_/B }
C {devices/lab_pin.sym} 3480 -38890 0 0 {name=p2821 lab=_80347_/B }
C {devices/lab_pin.sym} 3600 -38930 0 1 {name=p2822 lab=_63670_/Y }
C {sky130_stdcells/nor3_4.sym} 3540 -38930 0 0 {name=X_63670_ }
C {devices/lab_pin.sym} 3500 -38790 0 0 {name=p2823 lab=_75656_/A }
C {devices/lab_pin.sym} 3580 -38790 0 1 {name=p2824 lab=_75658_/A }
C {sky130_stdcells/inv_2.sym} 3540 -38790 0 0 {name=X_75656_ }
C {devices/lab_pin.sym} 3500 -38670 0 0 {name=p2825 lab=_60997_/A }
C {devices/lab_pin.sym} 3580 -38670 0 1 {name=p2826 lab=_60882_/X }
C {sky130_stdcells/buf_2.sym} 3540 -38670 0 0 {name=X_60882_ }
C {devices/lab_pin.sym} 3460 -38570 0 0 {name=p2827 lab=_87067_/Q }
C {devices/lab_pin.sym} 3460 -38530 0 0 {name=p2828 lab=_73370_/B }
C {devices/lab_pin.sym} 3460 -38490 0 0 {name=p2829 lab=_72867_/X }
C {devices/lab_pin.sym} 3620 -38530 0 1 {name=p2830 lab=_72868_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -38530 0 0 {name=X_72868_ }
C {devices/lab_pin.sym} 3480 -38420 0 0 {name=p2831 lab=_61683_/X }
C {devices/lab_pin.sym} 3480 -38380 0 0 {name=p2832 lab=_62515_/A }
C {devices/lab_pin.sym} 3480 -38340 0 0 {name=p2833 lab=_62534_/X }
C {devices/lab_pin.sym} 3480 -38300 0 0 {name=p2834 lab=_62621_/D }
C {devices/lab_pin.sym} 3600 -38360 0 1 {name=p2835 lab=_62621_/Y }
C {sky130_stdcells/nand4_4.sym} 3540 -38360 0 0 {name=X_62621_ }
C {devices/lab_pin.sym} 3460 -38230 0 0 {name=p2836 lab=_45257_/Y }
C {devices/lab_pin.sym} 3460 -38190 0 0 {name=p2837 lab=_74598_/X }
C {devices/lab_pin.sym} 3460 -38150 0 0 {name=p2838 lab=_74606_/X }
C {devices/lab_pin.sym} 3620 -38190 0 1 {name=p2839 lab=_83018_/D }
C {sky130_stdcells/o21ai_4.sym} 3540 -38190 0 0 {name=X_74607_ }
C {devices/lab_pin.sym} 3500 -38050 0 0 {name=p2840 lab=_47414_/A }
C {devices/lab_pin.sym} 3580 -38050 0 1 {name=p2841 lab=_47555_/X }
C {sky130_stdcells/buf_2.sym} 3540 -38050 0 0 {name=X_47555_ }
C {devices/lab_pin.sym} 3480 -37950 0 0 {name=p2842 lab=_71813_/A }
C {devices/lab_pin.sym} 3480 -37910 0 0 {name=p2843 lab=_71777_/B }
C {devices/lab_pin.sym} 3480 -37870 0 0 {name=p2844 lab=_71049_/A }
C {devices/lab_pin.sym} 3600 -37910 0 1 {name=p2845 lab=_71819_/X }
C {sky130_stdcells/and3_4.sym} 3540 -37910 0 0 {name=X_71819_ }
C {devices/lab_pin.sym} 3480 -37790 0 0 {name=p2846 lab=_78375_/A }
C {devices/lab_pin.sym} 3480 -37750 0 0 {name=p2847 lab=_78375_/B }
C {devices/lab_pin.sym} 3480 -37710 0 0 {name=p2848 lab=_78375_/C }
C {devices/lab_pin.sym} 3600 -37750 0 1 {name=p2849 lab=_78375_/Y }
C {sky130_stdcells/nand3_4.sym} 3540 -37750 0 0 {name=X_78375_ }
C {devices/lab_pin.sym} 3500 -37610 0 0 {name=p2850 lab=_41936_/A }
C {devices/lab_pin.sym} 3580 -37610 0 1 {name=p2851 lab=_44767_/X }
C {sky130_stdcells/buf_2.sym} 3540 -37610 0 0 {name=X_44767_ }
C {devices/lab_pin.sym} 3480 -37500 0 0 {name=p2852 lab=_80995_/Q }
C {devices/lab_pin.sym} 3480 -37460 0 0 {name=p2853 lab=_75587_/B }
C {devices/lab_pin.sym} 3600 -37480 0 1 {name=p2854 lab=_75587_/X }
C {sky130_stdcells/xor2_4.sym} 3540 -37480 0 0 {name=X_75587_ }
C {devices/lab_pin.sym} 3500 -37350 0 0 {name=p2855 lab=_41978_/Y }
C {devices/lab_pin.sym} 3580 -37350 0 1 {name=p2856 lab=_88084_/D }
C {sky130_stdcells/inv_2.sym} 3540 -37350 0 0 {name=X_41979_ }
C {devices/lab_pin.sym} 3500 -37230 0 0 {name=p2857 lab=_72798_/X }
C {devices/lab_pin.sym} 3580 -37230 0 1 {name=p2858 lab=_72799_/X }
C {sky130_stdcells/buf_2.sym} 3540 -37230 0 0 {name=X_72799_ }
C {devices/lab_pin.sym} 3460 -37130 0 0 {name=p2859 lab=_46493_/X }
C {devices/lab_pin.sym} 3460 -37090 0 0 {name=p2860 lab=_82923_/Q }
C {devices/lab_pin.sym} 3460 -37050 0 0 {name=p2861 lab=_46505_/Y }
C {devices/lab_pin.sym} 3620 -37090 0 1 {name=p2862 lab=_46507_/A }
C {sky130_stdcells/o21ai_4.sym} 3540 -37090 0 0 {name=X_46506_ }
C {devices/lab_pin.sym} 3500 -36950 0 0 {name=p2863 lab=_65984_/A }
C {devices/lab_pin.sym} 3580 -36950 0 1 {name=p2864 lab=_65340_/X }
C {sky130_stdcells/buf_2.sym} 3540 -36950 0 0 {name=X_65340_ }
C {devices/lab_pin.sym} 3500 -36830 0 0 {name=p2865 lab=_82217_/Q }
C {devices/lab_pin.sym} 3580 -36830 0 1 {name=p2866 lab=_77326_/Y }
C {sky130_stdcells/inv_2.sym} 3540 -36830 0 0 {name=X_77326_ }
C {devices/lab_pin.sym} 3500 -36710 0 0 {name=p2867 lab=_43606_/A }
C {devices/lab_pin.sym} 3580 -36710 0 1 {name=p2868 lab=_43718_/X }
C {sky130_stdcells/buf_2.sym} 3540 -36710 0 0 {name=X_43718_ }
C {devices/lab_pin.sym} 3500 -36590 0 0 {name=p2869 lab=_62851_/A }
C {devices/lab_pin.sym} 3580 -36590 0 1 {name=p2870 lab=_62672_/A }
C {sky130_stdcells/buf_2.sym} 3540 -36590 0 0 {name=X_62552_ }
C {devices/lab_pin.sym} 3460 -36490 0 0 {name=p2871 lab=_45909_/A }
C {devices/lab_pin.sym} 3460 -36450 0 0 {name=p2872 lab=_45933_/Y }
C {devices/lab_pin.sym} 3460 -36410 0 0 {name=p2873 lab=_74537_/Y }
C {devices/lab_pin.sym} 3620 -36450 0 1 {name=p2874 lab=_74538_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -36450 0 0 {name=X_74538_ }
C {devices/lab_pin.sym} 3500 -36310 0 0 {name=p2875 lab=_47486_/A }
C {devices/lab_pin.sym} 3580 -36310 0 1 {name=p2876 lab=_53074_/D }
C {sky130_stdcells/buf_2.sym} 3540 -36310 0 0 {name=X_47486_ }
C {devices/lab_pin.sym} 3460 -36230 0 0 {name=p2877 lab=_44686_/X }
C {devices/lab_pin.sym} 3460 -36190 0 0 {name=p2878 lab=_44687_/X }
C {devices/lab_pin.sym} 3460 -36150 0 0 {name=p2879 lab=_40649_/Y }
C {devices/lab_pin.sym} 3460 -36110 0 0 {name=p2880 lab=_44697_/Y }
C {devices/lab_pin.sym} 3460 -36070 0 0 {name=p2881 lab=_44689_/X }
C {devices/lab_pin.sym} 3620 -36150 0 1 {name=p2882 lab=_44698_/Y }
C {sky130_stdcells/o32ai_4.sym} 3540 -36150 0 0 {name=X_44698_ }
C {devices/lab_pin.sym} 3460 -36010 0 0 {name=p2883 lab=_86430_/Q }
C {devices/lab_pin.sym} 3460 -35970 0 0 {name=p2884 lab=_49222_/X }
C {devices/lab_pin.sym} 3460 -35930 0 0 {name=p2885 lab=_49224_/Y }
C {devices/lab_pin.sym} 3620 -35970 0 1 {name=p2886 lab=_49225_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -35970 0 0 {name=X_49225_ }
C {devices/lab_pin.sym} 3500 -35830 0 0 {name=p2887 lab=_61380_/A }
C {devices/lab_pin.sym} 3580 -35830 0 1 {name=p2888 lab=_61514_/D }
C {sky130_stdcells/buf_2.sym} 3540 -35830 0 0 {name=X_61503_ }
C {devices/lab_pin.sym} 3460 -35730 0 0 {name=p2889 lab=_46403_/X }
C {devices/lab_pin.sym} 3460 -35690 0 0 {name=p2890 lab=_49049_/A }
C {devices/lab_pin.sym} 3460 -35650 0 0 {name=p2891 lab=_46436_/X }
C {devices/lab_pin.sym} 3620 -35690 0 1 {name=p2892 lab=_46438_/A }
C {sky130_stdcells/o21ai_4.sym} 3540 -35690 0 0 {name=X_46437_ }
C {devices/lab_pin.sym} 3460 -35580 0 0 {name=p2893 lab=_65199_/X }
C {devices/lab_pin.sym} 3460 -35540 0 0 {name=p2894 lab=_86119_/Q }
C {devices/lab_pin.sym} 3460 -35500 0 0 {name=p2895 lab=_65224_/X }
C {devices/lab_pin.sym} 3460 -35460 0 0 {name=p2896 lab=_65270_/X }
C {devices/lab_pin.sym} 3620 -35520 0 1 {name=p2897 lab=_65271_/X }
C {sky130_stdcells/a211o_4.sym} 3540 -35520 0 0 {name=X_65271_ }
C {devices/lab_pin.sym} 3460 -35390 0 0 {name=p2898 lab=_77252_/Y }
C {devices/lab_pin.sym} 3460 -35350 0 0 {name=p2899 lab=_77255_/Y }
C {devices/lab_pin.sym} 3460 -35310 0 0 {name=p2900 lab=_77258_/A }
C {devices/lab_pin.sym} 3620 -35350 0 1 {name=p2901 lab=_77260_/A }
C {sky130_stdcells/a21oi_4.sym} 3540 -35350 0 0 {name=X_77257_ }
C {devices/lab_pin.sym} 3460 -35240 0 0 {name=p2902 lab=_40702_/A }
C {devices/lab_pin.sym} 3460 -35200 0 0 {name=p2903 lab=_43634_/X }
C {devices/lab_pin.sym} 3460 -35160 0 0 {name=p2904 lab=_68861_/B }
C {devices/lab_pin.sym} 3460 -35120 0 0 {name=p2905 lab=_43636_/X }
C {devices/lab_pin.sym} 3620 -35180 0 1 {name=p2906 lab=_43649_/X }
C {sky130_stdcells/a2bb2o_4.sym} 3540 -35180 0 0 {name=X_43649_ }
C {devices/lab_pin.sym} 3500 -35030 0 0 {name=p2907 lab=_62671_/A }
C {devices/lab_pin.sym} 3580 -35030 0 1 {name=p2908 lab=_62483_/X }
C {sky130_stdcells/buf_2.sym} 3540 -35030 0 0 {name=X_62483_ }
C {devices/lab_pin.sym} 3460 -34930 0 0 {name=p2909 lab=_74467_/Y }
C {devices/lab_pin.sym} 3460 -34890 0 0 {name=p2910 lab=_46300_/X }
C {devices/lab_pin.sym} 3460 -34850 0 0 {name=p2911 lab=_74468_/Y }
C {devices/lab_pin.sym} 3620 -34890 0 1 {name=p2912 lab=_83060_/D }
C {sky130_stdcells/a21boi_4.sym} 3540 -34890 0 0 {name=X_74469_ }
C {devices/lab_pin.sym} 3460 -34770 0 0 {name=p2913 lab=_67007_/X }
C {devices/lab_pin.sym} 3460 -34730 0 0 {name=p2914 lab=_67009_/X }
C {devices/lab_pin.sym} 3460 -34690 0 0 {name=p2915 lab=_66964_/X }
C {devices/lab_pin.sym} 3620 -34730 0 1 {name=p2916 lab=_67010_/X }
C {sky130_stdcells/a21o_4.sym} 3540 -34730 0 0 {name=X_67010_ }
C {devices/lab_pin.sym} 3480 -34620 0 0 {name=p2917 lab=_64234_/A }
C {devices/lab_pin.sym} 3480 -34580 0 0 {name=p2918 lab=_64234_/B }
C {devices/lab_pin.sym} 3480 -34540 0 0 {name=p2919 lab=_63376_/B }
C {devices/lab_pin.sym} 3480 -34500 0 0 {name=p2920 lab=_64221_/X }
C {devices/lab_pin.sym} 3600 -34560 0 1 {name=p2921 lab=_64222_/X }
C {sky130_stdcells/and4_4.sym} 3540 -34560 0 0 {name=X_64222_ }
C {devices/lab_pin.sym} 3500 -34410 0 0 {name=p2922 lab=_76207_/Y }
C {devices/lab_pin.sym} 3580 -34410 0 1 {name=p2923 lab=_76208_/Y }
C {sky130_stdcells/inv_2.sym} 3540 -34410 0 0 {name=X_76208_ }
C {devices/lab_pin.sym} 3480 -34310 0 0 {name=p2924 lab=_61434_/A }
C {devices/lab_pin.sym} 3480 -34270 0 0 {name=p2925 lab=_61434_/B }
C {devices/lab_pin.sym} 3480 -34230 0 0 {name=p2926 lab=_61434_/C }
C {devices/lab_pin.sym} 3600 -34270 0 1 {name=p2927 lab=_61434_/Y }
C {sky130_stdcells/nor3_4.sym} 3540 -34270 0 0 {name=X_61434_ }
C {devices/lab_pin.sym} 3500 -34130 0 0 {name=p2928 lab=_49205_/A }
C {devices/lab_pin.sym} 3580 -34130 0 1 {name=p2929 lab=_49156_/X }
C {sky130_stdcells/buf_2.sym} 3540 -34130 0 0 {name=X_49156_ }
C {devices/lab_pin.sym} 3500 -34010 0 0 {name=p2930 lab=_46367_/Y }
C {devices/lab_pin.sym} 3580 -34010 0 1 {name=p2931 lab=_50777_/B }
C {sky130_stdcells/buf_2.sym} 3540 -34010 0 0 {name=X_46368_ }
C {devices/lab_pin.sym} 3460 -33910 0 0 {name=p2932 lab=_77171_/A }
C {devices/lab_pin.sym} 3460 -33870 0 0 {name=p2933 lab=_77186_/Y }
C {devices/lab_pin.sym} 3460 -33830 0 0 {name=p2934 lab=_77187_/Y }
C {devices/lab_pin.sym} 3620 -33870 0 1 {name=p2935 lab=_77188_/X }
C {sky130_stdcells/a21o_4.sym} 3540 -33870 0 0 {name=X_77188_ }
C {devices/lab_pin.sym} 3480 -33740 0 0 {name=p2936 lab=_48142_/A }
C {devices/lab_pin.sym} 3480 -33700 0 0 {name=p2937 lab=_50365_/B }
C {devices/lab_pin.sym} 3600 -33720 0 1 {name=p2938 lab=_48107_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -33720 0 0 {name=X_48107_ }
C {devices/lab_pin.sym} 3480 -33600 0 0 {name=p2939 lab=_45319_/A }
C {devices/lab_pin.sym} 3480 -33560 0 0 {name=p2940 lab=_45272_/X }
C {devices/lab_pin.sym} 3600 -33580 0 1 {name=p2941 lab=_45319_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -33580 0 0 {name=X_45319_ }
C {devices/lab_pin.sym} 3480 -33470 0 0 {name=p2942 lab=_64187_/A }
C {devices/lab_pin.sym} 3480 -33430 0 0 {name=p2943 lab=_64187_/B }
C {devices/lab_pin.sym} 3480 -33390 0 0 {name=p2944 lab=_79950_/B }
C {devices/lab_pin.sym} 3600 -33430 0 1 {name=p2945 lab=_64153_/Y }
C {sky130_stdcells/nor3_4.sym} 3540 -33430 0 0 {name=X_64153_ }
C {devices/lab_pin.sym} 3480 -33300 0 0 {name=p2946 lab=_81727_/D }
C {devices/lab_pin.sym} 3480 -33260 0 0 {name=p2947 lab=_76139_/B }
C {devices/lab_pin.sym} 3600 -33280 0 1 {name=p2948 lab=_76139_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -33280 0 0 {name=X_76139_ }
C {devices/lab_pin.sym} 3480 -33160 0 0 {name=p2949 lab=_48976_/A }
C {devices/lab_pin.sym} 3480 -33120 0 0 {name=p2950 lab=_48586_/Y }
C {devices/lab_pin.sym} 3600 -33140 0 1 {name=p2951 lab=_49087_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -33140 0 0 {name=X_49087_ }
C {devices/lab_pin.sym} 3500 -33010 0 0 {name=p2952 lab=_84854_/Q }
C {devices/lab_pin.sym} 3580 -33010 0 1 {name=p2953 lab=_61365_/X }
C {sky130_stdcells/buf_2.sym} 3540 -33010 0 0 {name=X_61365_ }
C {devices/lab_pin.sym} 3500 -32890 0 0 {name=p2954 lab=_46653_/A }
C {devices/lab_pin.sym} 3580 -32890 0 1 {name=p2955 lab=_72083_/A }
C {sky130_stdcells/buf_2.sym} 3540 -32890 0 0 {name=X_46299_ }
C {devices/lab_pin.sym} 3460 -32790 0 0 {name=p2956 lab=_63101_/Y }
C {devices/lab_pin.sym} 3460 -32750 0 0 {name=p2957 lab=_63103_/X }
C {devices/lab_pin.sym} 3460 -32710 0 0 {name=p2958 lab=_63056_/X }
C {devices/lab_pin.sym} 3620 -32750 0 1 {name=p2959 lab=_63104_/Y }
C {sky130_stdcells/a21oi_4.sym} 3540 -32750 0 0 {name=X_63104_ }
C {devices/lab_pin.sym} 3460 -32630 0 0 {name=p2960 lab=_48033_/Y }
C {devices/lab_pin.sym} 3460 -32590 0 0 {name=p2961 lab=_48007_/X }
C {devices/lab_pin.sym} 3460 -32550 0 0 {name=p2962 lab=_48037_/X }
C {devices/lab_pin.sym} 3620 -32590 0 1 {name=p2963 lab=_86574_/D }
C {sky130_stdcells/a21oi_4.sym} 3540 -32590 0 0 {name=X_48038_ }
C {devices/lab_pin.sym} 3500 -32450 0 0 {name=p2964 lab=_60315_/X }
C {devices/lab_pin.sym} 3580 -32450 0 1 {name=p2965 lab=_60316_/Y }
C {sky130_stdcells/inv_2.sym} 3540 -32450 0 0 {name=X_60316_ }
C {devices/lab_pin.sym} 3460 -32370 0 0 {name=p2966 lab=_64077_/Y }
C {devices/lab_pin.sym} 3460 -32330 0 0 {name=p2967 lab=_64079_/Y }
C {devices/lab_pin.sym} 3460 -32290 0 0 {name=p2968 lab=_64083_/X }
C {devices/lab_pin.sym} 3460 -32250 0 0 {name=p2969 lab=_58457_/A }
C {devices/lab_pin.sym} 3460 -32210 0 0 {name=p2970 lab=_63736_/X }
C {devices/lab_pin.sym} 3620 -32290 0 1 {name=p2971 lab=_64084_/Y }
C {sky130_stdcells/o32ai_4.sym} 3540 -32290 0 0 {name=X_64084_ }
C {devices/lab_pin.sym} 3460 -32150 0 0 {name=p2972 lab=_68957_/X }
C {devices/lab_pin.sym} 3460 -32110 0 0 {name=p2973 lab=_68960_/X }
C {devices/lab_pin.sym} 3460 -32070 0 0 {name=p2974 lab=_68748_/X }
C {devices/lab_pin.sym} 3620 -32110 0 1 {name=p2975 lab=_68961_/X }
C {sky130_stdcells/a21o_4.sym} 3540 -32110 0 0 {name=X_68961_ }
C {devices/lab_pin.sym} 3500 -31970 0 0 {name=p2976 lab=_61302_/A }
C {devices/lab_pin.sym} 3580 -31970 0 1 {name=p2977 lab=_72515_/D }
C {sky130_stdcells/buf_2.sym} 3540 -31970 0 0 {name=X_61296_ }
C {devices/lab_pin.sym} 3480 -31860 0 0 {name=p2978 lab=_67817_/X }
C {devices/lab_pin.sym} 3480 -31820 0 0 {name=p2979 lab=_67912_/B }
C {devices/lab_pin.sym} 3600 -31840 0 1 {name=p2980 lab=_67912_/X }
C {sky130_stdcells/and2_4.sym} 3540 -31840 0 0 {name=X_67912_ }
C {devices/lab_pin.sym} 3460 -31730 0 0 {name=p2981 lab=_79493_/A }
C {devices/lab_pin.sym} 3460 -31690 0 0 {name=p2982 lab=_63008_/X }
C {devices/lab_pin.sym} 3460 -31650 0 0 {name=p2983 lab=_63034_/Y }
C {devices/lab_pin.sym} 3620 -31690 0 1 {name=p2984 lab=_63035_/X }
C {sky130_stdcells/a21o_4.sym} 3540 -31690 0 0 {name=X_63035_ }
C {devices/lab_pin.sym} 3460 -31590 0 0 {name=p2985 lab=_60221_/A }
C {devices/lab_pin.sym} 3460 -31550 0 0 {name=p2986 lab=_60324_/B }
C {devices/lab_pin.sym} 3460 -31510 0 0 {name=p2987 lab=_60324_/C }
C {devices/lab_pin.sym} 3460 -31470 0 0 {name=p2988 lab=_60218_/A }
C {devices/lab_pin.sym} 3460 -31440 0 0 {name=p2989 lab=_60528_/A }
C {devices/lab_pin.sym} 3620 -31510 0 1 {name=p2990 lab=_60247_/Y }
C {sky130_stdcells/a41oi_4.sym} 3540 -31510 0 0 {name=X_60247_ }
C {devices/lab_pin.sym} 3480 -31360 0 0 {name=p2991 lab=_68750_/A }
C {devices/lab_pin.sym} 3480 -31320 0 0 {name=p2992 lab=_68892_/B }
C {devices/lab_pin.sym} 3600 -31340 0 1 {name=p2993 lab=_68892_/X }
C {sky130_stdcells/and2_4.sym} 3540 -31340 0 0 {name=X_68892_ }
C {devices/lab_pin.sym} 3460 -31230 0 0 {name=p2994 lab=_49998_/Y }
C {devices/lab_pin.sym} 3460 -31190 0 0 {name=p2995 lab=_49977_/X }
C {devices/lab_pin.sym} 3460 -31150 0 0 {name=p2996 lab=_49999_/X }
C {devices/lab_pin.sym} 3620 -31190 0 1 {name=p2997 lab=_86284_/D }
C {sky130_stdcells/a21oi_4.sym} 3540 -31190 0 0 {name=X_50000_ }
C {devices/lab_pin.sym} 3480 -31060 0 0 {name=p2998 lab=_67817_/X }
C {devices/lab_pin.sym} 3480 -31020 0 0 {name=p2999 lab=_87710_/Q }
C {devices/lab_pin.sym} 3600 -31040 0 1 {name=p3000 lab=_67843_/X }
C {sky130_stdcells/and2_4.sym} 3540 -31040 0 0 {name=X_67843_ }
C {devices/lab_pin.sym} 3480 -30920 0 0 {name=p3001 lab=_79829_/A }
C {devices/lab_pin.sym} 3480 -30880 0 0 {name=p3002 lab=_79829_/B }
C {devices/lab_pin.sym} 3600 -30900 0 1 {name=p3003 lab=_79852_/B }
C {sky130_stdcells/and2_4.sym} 3540 -30900 0 0 {name=X_79829_ }
C {devices/lab_pin.sym} 3500 -30770 0 0 {name=p3004 lab=_60177_/X }
C {devices/lab_pin.sym} 3580 -30770 0 1 {name=p3005 lab=_60179_/A }
C {sky130_stdcells/buf_2.sym} 3540 -30770 0 0 {name=X_60178_ }
C {devices/lab_pin.sym} 3460 -30670 0 0 {name=p3006 lab=_72347_/B }
C {devices/lab_pin.sym} 3460 -30630 0 0 {name=p3007 lab=_49986_/X }
C {devices/lab_pin.sym} 3460 -30590 0 0 {name=p3008 lab=_49988_/Y }
C {devices/lab_pin.sym} 3620 -30630 0 1 {name=p3009 lab=_49989_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -30630 0 0 {name=X_49989_ }
C {devices/lab_pin.sym} 3450 -30490 0 0 {name=p3010 lab=_82740_/CLK }
C {devices/lab_pin.sym} 3450 -30470 0 0 {name=p3011 lab=_82840_/D }
C {devices/lab_pin.sym} 3630 -30490 0 1 {name=p3012 lab=_82840_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -30480 0 0 {name=X_82840_ }
C {devices/lab_pin.sym} 3460 -30380 0 0 {name=p3013 lab=_87393_/Q }
C {devices/lab_pin.sym} 3460 -30340 0 0 {name=p3014 lab=_67751_/X }
C {devices/lab_pin.sym} 3460 -30300 0 0 {name=p3015 lab=_67702_/X }
C {devices/lab_pin.sym} 3460 -30260 0 0 {name=p3016 lab=_67773_/X }
C {devices/lab_pin.sym} 3620 -30320 0 1 {name=p3017 lab=_67774_/X }
C {sky130_stdcells/a211o_4.sym} 3540 -30320 0 0 {name=X_67774_ }
C {devices/lab_pin.sym} 3500 -30170 0 0 {name=p3018 lab=_64725_/A }
C {devices/lab_pin.sym} 3580 -30170 0 1 {name=p3019 lab=_65012_/A }
C {sky130_stdcells/buf_2.sym} 3540 -30170 0 0 {name=X_64986_ }
C {devices/lab_pin.sym} 3480 -30060 0 0 {name=p3020 lab=_69586_/A }
C {devices/lab_pin.sym} 3480 -30020 0 0 {name=p3021 lab=_69513_/B }
C {devices/lab_pin.sym} 3600 -30040 0 1 {name=p3022 lab=_69513_/X }
C {sky130_stdcells/and2_4.sym} 3540 -30040 0 0 {name=X_69513_ }
C {devices/lab_pin.sym} 3460 -29940 0 0 {name=p3023 lab=_87373_/Q }
C {devices/lab_pin.sym} 3460 -29900 0 0 {name=p3024 lab=_66678_/X }
C {devices/lab_pin.sym} 3460 -29860 0 0 {name=p3025 lab=_66629_/X }
C {devices/lab_pin.sym} 3460 -29820 0 0 {name=p3026 lab=_66724_/X }
C {devices/lab_pin.sym} 3620 -29880 0 1 {name=p3027 lab=_66725_/X }
C {sky130_stdcells/a211o_4.sym} 3540 -29880 0 0 {name=X_66725_ }
C {devices/lab_pin.sym} 3500 -29730 0 0 {name=p3028 lab=clkbuf_6_56_0_CLK/X }
C {devices/lab_pin.sym} 3580 -29730 0 1 {name=p3029 lab=clkbuf_8_227_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 3540 -29730 0 0 {name=Xclkbuf_7_113_0_CLK }
C {devices/lab_pin.sym} 3500 -29610 0 0 {name=p3030 lab=_52486_/A }
C {devices/lab_pin.sym} 3580 -29610 0 1 {name=p3031 lab=_51951_/X }
C {sky130_stdcells/buf_2.sym} 3540 -29610 0 0 {name=X_51951_ }
C {devices/lab_pin.sym} 3480 -29520 0 0 {name=p3032 lab=_64353_/B }
C {devices/lab_pin.sym} 3480 -29480 0 0 {name=p3033 lab=_63920_/B }
C {devices/lab_pin.sym} 3480 -29440 0 0 {name=p3034 lab=_63951_/C }
C {devices/lab_pin.sym} 3480 -29400 0 0 {name=p3035 lab=_64015_/D }
C {devices/lab_pin.sym} 3600 -29460 0 1 {name=p3036 lab=_63937_/Y }
C {sky130_stdcells/nand4_4.sym} 3540 -29460 0 0 {name=X_63937_ }
C {devices/lab_pin.sym} 3450 -29310 0 0 {name=p3037 lab=_82774_/CLK }
C {devices/lab_pin.sym} 3450 -29290 0 0 {name=p3038 lab=_82771_/D }
C {devices/lab_pin.sym} 3630 -29310 0 1 {name=p3039 lab=_82771_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -29300 0 0 {name=X_82771_ }
C {devices/lab_pin.sym} 3450 -29170 0 0 {name=p3040 lab=_84503_/CLK }
C {devices/lab_pin.sym} 3450 -29150 0 0 {name=p3041 lab=_84510_/D }
C {devices/lab_pin.sym} 3630 -29170 0 1 {name=p3042 lab=_61192_/C }
C {sky130_stdcells/dfxtp_4.sym} 3540 -29160 0 0 {name=X_84510_ }
C {devices/lab_pin.sym} 3500 -29030 0 0 {name=p3043 lab=_50957_/A }
C {devices/lab_pin.sym} 3580 -29030 0 1 {name=p3044 lab=_50902_/X }
C {sky130_stdcells/buf_2.sym} 3540 -29030 0 0 {name=X_50902_ }
C {devices/lab_pin.sym} 3450 -28910 0 0 {name=p3045 lab=_84020_/CLK }
C {devices/lab_pin.sym} 3450 -28890 0 0 {name=p3046 lab=_81722_/D }
C {devices/lab_pin.sym} 3630 -28910 0 1 {name=p3047 lab=_41149_/A }
C {sky130_stdcells/dfxtp_4.sym} 3540 -28900 0 0 {name=X_81722_ }
C {devices/lab_pin.sym} 3460 -28800 0 0 {name=p3048 lab=_87517_/Q }
C {devices/lab_pin.sym} 3460 -28760 0 0 {name=p3049 lab=_69442_/X }
C {devices/lab_pin.sym} 3460 -28720 0 0 {name=p3050 lab=_69396_/X }
C {devices/lab_pin.sym} 3460 -28680 0 0 {name=p3051 lab=_69443_/X }
C {devices/lab_pin.sym} 3620 -28740 0 1 {name=p3052 lab=_69444_/X }
C {sky130_stdcells/a211o_4.sym} 3540 -28740 0 0 {name=X_69444_ }
C {devices/lab_pin.sym} 3460 -28610 0 0 {name=p3053 lab=_85399_/Q }
C {devices/lab_pin.sym} 3460 -28570 0 0 {name=p3054 lab=_54648_/X }
C {devices/lab_pin.sym} 3460 -28530 0 0 {name=p3055 lab=_54669_/Y }
C {devices/lab_pin.sym} 3620 -28570 0 1 {name=p3056 lab=_54670_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -28570 0 0 {name=X_54670_ }
C {devices/lab_pin.sym} 3480 -28440 0 0 {name=p3057 lab=_66683_/A }
C {devices/lab_pin.sym} 3480 -28400 0 0 {name=p3058 lab=_66656_/B }
C {devices/lab_pin.sym} 3600 -28420 0 1 {name=p3059 lab=_66656_/X }
C {sky130_stdcells/and2_4.sym} 3540 -28420 0 0 {name=X_66656_ }
C {devices/lab_pin.sym} 3450 -28290 0 0 {name=p3060 lab=_83736_/CLK }
C {devices/lab_pin.sym} 3450 -28270 0 0 {name=p3061 lab=_54178_/Y }
C {devices/lab_pin.sym} 3630 -28290 0 1 {name=p3062 lab=_85490_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -28280 0 0 {name=X_85490_ }
C {devices/lab_pin.sym} 3480 -28180 0 0 {name=p3063 lab=_51870_/A }
C {devices/lab_pin.sym} 3480 -28140 0 0 {name=p3064 lab=_51870_/B }
C {devices/lab_pin.sym} 3480 -28100 0 0 {name=p3065 lab=_51870_/C }
C {devices/lab_pin.sym} 3480 -28060 0 0 {name=p3066 lab=_52709_/D }
C {devices/lab_pin.sym} 3600 -28120 0 1 {name=p3067 lab=_51882_/X }
C {sky130_stdcells/and4_4.sym} 3540 -28120 0 0 {name=X_51882_ }
C {devices/lab_pin.sym} 3500 -27970 0 0 {name=p3068 lab=_63751_/X }
C {devices/lab_pin.sym} 3580 -27970 0 1 {name=p3069 lab=_63900_/D }
C {sky130_stdcells/buf_2.sym} 3540 -27970 0 0 {name=X_63868_ }
C {devices/lab_pin.sym} 3500 -27850 0 0 {name=p3070 lab=clkbuf_9_41_0_CLK/X }
C {devices/lab_pin.sym} 3580 -27850 0 1 {name=p3071 lab=_86757_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 3540 -27850 0 0 {name=Xclkbuf_10_83_0_CLK }
C {devices/lab_pin.sym} 3460 -27750 0 0 {name=p3072 lab=_53617_/Y }
C {devices/lab_pin.sym} 3460 -27710 0 0 {name=p3073 lab=_53619_/X }
C {devices/lab_pin.sym} 3460 -27670 0 0 {name=p3074 lab=_53620_/X }
C {devices/lab_pin.sym} 3620 -27710 0 1 {name=p3075 lab=_53621_/Y }
C {sky130_stdcells/a21oi_4.sym} 3540 -27710 0 0 {name=X_53621_ }
C {devices/lab_pin.sym} 3500 -27570 0 0 {name=p3076 lab=_65607_/A }
C {devices/lab_pin.sym} 3580 -27570 0 1 {name=p3077 lab=_65653_/B }
C {sky130_stdcells/buf_2.sym} 3540 -27570 0 0 {name=X_65607_ }
C {devices/lab_pin.sym} 3450 -27450 0 0 {name=p3078 lab=_84441_/CLK }
C {devices/lab_pin.sym} 3450 -27430 0 0 {name=p3079 lab=_61990_/Y }
C {devices/lab_pin.sym} 3630 -27450 0 1 {name=p3080 lab=_78064_/B }
C {sky130_stdcells/dfxtp_4.sym} 3540 -27440 0 0 {name=X_84441_ }
C {devices/lab_pin.sym} 3460 -27330 0 0 {name=p3081 lab=_86124_/Q }
C {devices/lab_pin.sym} 3460 -27290 0 0 {name=p3082 lab=_50820_/X }
C {devices/lab_pin.sym} 3460 -27250 0 0 {name=p3083 lab=_50832_/Y }
C {devices/lab_pin.sym} 3620 -27290 0 1 {name=p3084 lab=_50833_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -27290 0 0 {name=X_50833_ }
C {devices/lab_pin.sym} 3480 -27180 0 0 {name=p3085 lab=_62819_/A }
C {devices/lab_pin.sym} 3480 -27140 0 0 {name=p3086 lab=_64379_/C }
C {devices/lab_pin.sym} 3480 -27100 0 0 {name=p3087 lab=_62819_/C }
C {devices/lab_pin.sym} 3480 -27060 0 0 {name=p3088 lab=_62782_/X }
C {devices/lab_pin.sym} 3600 -27120 0 1 {name=p3089 lab=_62819_/X }
C {sky130_stdcells/and4_4.sym} 3540 -27120 0 0 {name=X_62819_ }
C {devices/lab_pin.sym} 3450 -26970 0 0 {name=p3090 lab=_81682_/CLK }
C {devices/lab_pin.sym} 3450 -26950 0 0 {name=p3091 lab=_81685_/Q }
C {devices/lab_pin.sym} 3630 -26970 0 1 {name=p3092 lab=_76426_/A }
C {sky130_stdcells/dfxtp_4.sym} 3540 -26960 0 0 {name=X_81653_ }
C {devices/lab_pin.sym} 3500 -26830 0 0 {name=p3093 lab=_69651_/A }
C {devices/lab_pin.sym} 3580 -26830 0 1 {name=p3094 lab=_69612_/A }
C {sky130_stdcells/buf_2.sym} 3540 -26830 0 0 {name=X_69375_ }
C {devices/lab_pin.sym} 3460 -26730 0 0 {name=p3095 lab=_84105_/Q }
C {devices/lab_pin.sym} 3460 -26690 0 0 {name=p3096 lab=_59803_/X }
C {devices/lab_pin.sym} 3460 -26650 0 0 {name=p3097 lab=_66586_/X }
C {devices/lab_pin.sym} 3620 -26690 0 1 {name=p3098 lab=_84105_/D }
C {sky130_stdcells/a21bo_4.sym} 3540 -26690 0 0 {name=X_66587_ }
C {devices/lab_pin.sym} 3460 -26590 0 0 {name=p3099 lab=_63794_/X }
C {devices/lab_pin.sym} 3460 -26550 0 0 {name=p3100 lab=_63736_/X }
C {devices/lab_pin.sym} 3460 -26510 0 0 {name=p3101 lab=_63796_/Y }
C {devices/lab_pin.sym} 3460 -26470 0 0 {name=p3102 lab=_63797_/Y }
C {devices/lab_pin.sym} 3460 -26440 0 0 {name=p3103 lab=_63798_/X }
C {devices/lab_pin.sym} 3620 -26510 0 1 {name=p3104 lab=_63799_/X }
C {sky130_stdcells/a41o_4.sym} 3540 -26510 0 0 {name=X_63799_ }
C {devices/lab_pin.sym} 3480 -26360 0 0 {name=p3105 lab=_84775_/Q }
C {devices/lab_pin.sym} 3480 -26320 0 0 {name=p3106 lab=_84167_/Q }
C {devices/lab_pin.sym} 3600 -26340 0 1 {name=p3107 lab=_80606_/A }
C {sky130_stdcells/xor2_4.sym} 3540 -26340 0 0 {name=X_80604_ }
C {devices/lab_pin.sym} 3460 -26230 0 0 {name=p3108 lab=_56109_/X }
C {devices/lab_pin.sym} 3460 -26190 0 0 {name=p3109 lab=_56337_/X }
C {devices/lab_pin.sym} 3460 -26150 0 0 {name=p3110 lab=_56339_/Y }
C {devices/lab_pin.sym} 3620 -26190 0 1 {name=p3111 lab=_85230_/D }
C {sky130_stdcells/o21ai_4.sym} 3540 -26190 0 0 {name=X_56340_ }
C {devices/lab_pin.sym} 3500 -26050 0 0 {name=p3112 lab=_68447_/A }
C {devices/lab_pin.sym} 3580 -26050 0 1 {name=p3113 lab=_68326_/X }
C {sky130_stdcells/buf_2.sym} 3540 -26050 0 0 {name=X_68326_ }
C {devices/lab_pin.sym} 3450 -25930 0 0 {name=p3114 lab=_86935_/CLK }
C {devices/lab_pin.sym} 3450 -25910 0 0 {name=p3115 lab=_87160_/D }
C {devices/lab_pin.sym} 3630 -25930 0 1 {name=p3116 lab=_87160_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -25920 0 0 {name=X_87160_ }
C {devices/lab_pin.sym} 3480 -25800 0 0 {name=p3117 lab=_53468_/A }
C {devices/lab_pin.sym} 3480 -25760 0 0 {name=p3118 lab=_53552_/B }
C {devices/lab_pin.sym} 3600 -25780 0 1 {name=p3119 lab=_53552_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -25780 0 0 {name=X_53552_ }
C {devices/lab_pin.sym} 3460 -25680 0 0 {name=p3120 lab=_65453_/X }
C {devices/lab_pin.sym} 3460 -25640 0 0 {name=p3121 lab=_85594_/Q }
C {devices/lab_pin.sym} 3460 -25600 0 0 {name=p3122 lab=_65470_/X }
C {devices/lab_pin.sym} 3460 -25560 0 0 {name=p3123 lab=_65537_/X }
C {devices/lab_pin.sym} 3620 -25620 0 1 {name=p3124 lab=_65538_/X }
C {sky130_stdcells/a211o_4.sym} 3540 -25620 0 0 {name=X_65538_ }
C {devices/lab_pin.sym} 3450 -25470 0 0 {name=p3125 lab=_84449_/CLK }
C {devices/lab_pin.sym} 3450 -25450 0 0 {name=p3126 lab=_84372_/D }
C {devices/lab_pin.sym} 3630 -25470 0 1 {name=p3127 lab=_84372_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -25460 0 0 {name=X_84372_ }
C {devices/lab_pin.sym} 3480 -25340 0 0 {name=p3128 lab=_50764_/A }
C {devices/lab_pin.sym} 3480 -25300 0 0 {name=p3129 lab=_53978_/B }
C {devices/lab_pin.sym} 3600 -25320 0 1 {name=p3130 lab=_50764_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -25320 0 0 {name=X_50764_ }
C {devices/lab_pin.sym} 3450 -25190 0 0 {name=p3131 lab=_83914_/CLK }
C {devices/lab_pin.sym} 3450 -25170 0 0 {name=p3132 lab=_65698_/C }
C {devices/lab_pin.sym} 3630 -25190 0 1 {name=p3133 lab=_81584_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -25180 0 0 {name=X_81584_ }
C {devices/lab_pin.sym} 3450 -25050 0 0 {name=p3134 lab=_83685_/CLK }
C {devices/lab_pin.sym} 3450 -25030 0 0 {name=p3135 lab=_50899_/Y }
C {devices/lab_pin.sym} 3630 -25050 0 1 {name=p3136 lab=_86111_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -25040 0 0 {name=X_86111_ }
C {devices/lab_pin.sym} 3460 -24930 0 0 {name=p3137 lab=_85809_/Q }
C {devices/lab_pin.sym} 3460 -24890 0 0 {name=p3138 lab=_52500_/X }
C {devices/lab_pin.sym} 3460 -24850 0 0 {name=p3139 lab=_52502_/Y }
C {devices/lab_pin.sym} 3620 -24890 0 1 {name=p3140 lab=_52503_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -24890 0 0 {name=X_52503_ }
C {devices/lab_pin.sym} 3450 -24750 0 0 {name=p3141 lab=_83322_/CLK }
C {devices/lab_pin.sym} 3450 -24730 0 0 {name=p3142 lab=_83323_/D }
C {devices/lab_pin.sym} 3630 -24750 0 1 {name=p3143 lab=_56808_/A }
C {sky130_stdcells/dfxtp_4.sym} 3540 -24740 0 0 {name=X_83323_ }
C {devices/lab_pin.sym} 3460 -24630 0 0 {name=p3144 lab=_56168_/X }
C {devices/lab_pin.sym} 3460 -24590 0 0 {name=p3145 lab=_56188_/X }
C {devices/lab_pin.sym} 3460 -24550 0 0 {name=p3146 lab=_56270_/Y }
C {devices/lab_pin.sym} 3620 -24590 0 1 {name=p3147 lab=_56271_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -24590 0 0 {name=X_56271_ }
C {devices/lab_pin.sym} 3480 -24460 0 0 {name=p3148 lab=_80529_/Y }
C {devices/lab_pin.sym} 3480 -24420 0 0 {name=p3149 lab=_80534_/Y }
C {devices/lab_pin.sym} 3600 -24440 0 1 {name=p3150 lab=_82264_/D }
C {sky130_stdcells/xor2_4.sym} 3540 -24440 0 0 {name=X_80535_ }
C {devices/lab_pin.sym} 3460 -24330 0 0 {name=p3151 lab=_83999_/Q }
C {devices/lab_pin.sym} 3460 -24290 0 0 {name=p3152 lab=_68238_/X }
C {devices/lab_pin.sym} 3460 -24250 0 0 {name=p3153 lab=_68256_/X }
C {devices/lab_pin.sym} 3620 -24290 0 1 {name=p3154 lab=_83999_/D }
C {sky130_stdcells/a21bo_4.sym} 3540 -24290 0 0 {name=X_68257_ }
C {devices/lab_pin.sym} 3450 -24150 0 0 {name=p3155 lab=_88263_/CLK }
C {devices/lab_pin.sym} 3450 -24130 0 0 {name=p3156 lab=_87091_/D }
C {devices/lab_pin.sym} 3630 -24150 0 1 {name=p3157 lab=_87091_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -24140 0 0 {name=X_87091_ }
C {devices/lab_pin.sym} 3500 -24010 0 0 {name=p3158 lab=clkbuf_9_49_0_CLK/X }
C {devices/lab_pin.sym} 3580 -24010 0 1 {name=p3159 lab=_85067_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 3540 -24010 0 0 {name=Xclkbuf_10_98_0_CLK }
C {devices/lab_pin.sym} 3460 -23910 0 0 {name=p3160 lab=_85628_/Q }
C {devices/lab_pin.sym} 3460 -23870 0 0 {name=p3161 lab=_53476_/X }
C {devices/lab_pin.sym} 3460 -23830 0 0 {name=p3162 lab=_53482_/Y }
C {devices/lab_pin.sym} 3620 -23870 0 1 {name=p3163 lab=_53483_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -23870 0 0 {name=X_53483_ }
C {devices/lab_pin.sym} 3460 -23760 0 0 {name=p3164 lab=_65350_/X }
C {devices/lab_pin.sym} 3460 -23720 0 0 {name=p3165 lab=_86206_/Q }
C {devices/lab_pin.sym} 3460 -23680 0 0 {name=p3166 lab=_65400_/X }
C {devices/lab_pin.sym} 3460 -23640 0 0 {name=p3167 lab=_65468_/X }
C {devices/lab_pin.sym} 3620 -23700 0 1 {name=p3168 lab=_65469_/X }
C {sky130_stdcells/a211o_4.sym} 3540 -23700 0 0 {name=X_65469_ }
C {devices/lab_pin.sym} 3480 -23560 0 0 {name=p3169 lab=_50695_/A }
C {devices/lab_pin.sym} 3480 -23520 0 0 {name=p3170 lab=_53910_/A }
C {devices/lab_pin.sym} 3600 -23540 0 1 {name=p3171 lab=_50695_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -23540 0 0 {name=X_50695_ }
C {devices/lab_pin.sym} 3500 -23410 0 0 {name=p3172 lab=_58696_/A }
C {devices/lab_pin.sym} 3580 -23410 0 1 {name=p3173 lab=_58010_/X }
C {sky130_stdcells/buf_2.sym} 3540 -23410 0 0 {name=X_58010_ }
C {devices/lab_pin.sym} 3460 -23310 0 0 {name=p3174 lab=_67205_/X }
C {devices/lab_pin.sym} 3460 -23270 0 0 {name=p3175 lab=_67207_/X }
C {devices/lab_pin.sym} 3460 -23230 0 0 {name=p3176 lab=_67113_/X }
C {devices/lab_pin.sym} 3620 -23270 0 1 {name=p3177 lab=_67208_/Y }
C {sky130_stdcells/a21oi_4.sym} 3540 -23270 0 0 {name=X_67208_ }
C {devices/lab_pin.sym} 3460 -23160 0 0 {name=p3178 lab=_85091_/Q }
C {devices/lab_pin.sym} 3460 -23120 0 0 {name=p3179 lab=_55152_/A }
C {devices/lab_pin.sym} 3460 -23080 0 0 {name=p3180 lab=_55133_/X }
C {devices/lab_pin.sym} 3460 -23040 0 0 {name=p3181 lab=_55221_/Y }
C {devices/lab_pin.sym} 3620 -23100 0 1 {name=p3182 lab=_55222_/X }
C {sky130_stdcells/a211o_4.sym} 3540 -23100 0 0 {name=X_55222_ }
C {devices/lab_pin.sym} 3450 -22950 0 0 {name=p3183 lab=_85818_/CLK }
C {devices/lab_pin.sym} 3450 -22930 0 0 {name=p3184 lab=_51275_/Y }
C {devices/lab_pin.sym} 3630 -22950 0 1 {name=p3185 lab=_64794_/B }
C {sky130_stdcells/dfxtp_4.sym} 3540 -22940 0 0 {name=X_86042_ }
C {devices/lab_pin.sym} 3500 -22810 0 0 {name=p3186 lab=clkbuf_8_245_0_CLK/A }
C {devices/lab_pin.sym} 3580 -22810 0 1 {name=p3187 lab=clkbuf_9_489_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 3540 -22810 0 0 {name=Xclkbuf_8_244_0_CLK }
C {devices/lab_pin.sym} 3480 -22700 0 0 {name=p3188 lab=_52185_/X }
C {devices/lab_pin.sym} 3480 -22660 0 0 {name=p3189 lab=_53951_/B }
C {devices/lab_pin.sym} 3600 -22680 0 1 {name=p3190 lab=_52434_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -22680 0 0 {name=X_52434_ }
C {devices/lab_pin.sym} 3450 -22550 0 0 {name=p3191 lab=_85957_/CLK }
C {devices/lab_pin.sym} 3450 -22530 0 0 {name=p3192 lab=_72444_/Y }
C {devices/lab_pin.sym} 3630 -22550 0 1 {name=p3193 lab=_83254_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -22540 0 0 {name=X_83254_ }
C {devices/lab_pin.sym} 3480 -22420 0 0 {name=p3194 lab=_80478_/A }
C {devices/lab_pin.sym} 3480 -22380 0 0 {name=p3195 lab=_80478_/B }
C {devices/lab_pin.sym} 3600 -22400 0 1 {name=p3196 lab=_80471_/A }
C {sky130_stdcells/xor2_4.sym} 3540 -22400 0 0 {name=X_80466_ }
C {devices/lab_pin.sym} 3500 -22270 0 0 {name=p3197 lab=_68376_/A }
C {devices/lab_pin.sym} 3580 -22270 0 1 {name=p3198 lab=_68188_/X }
C {sky130_stdcells/buf_2.sym} 3540 -22270 0 0 {name=X_68188_ }
C {devices/lab_pin.sym} 3450 -22150 0 0 {name=p3199 lab=_82206_/CLK }
C {devices/lab_pin.sym} 3450 -22130 0 0 {name=p3200 lab=_77643_/X }
C {devices/lab_pin.sym} 3630 -22150 0 1 {name=p3201 lab=_82205_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -22140 0 0 {name=X_82205_ }
C {devices/lab_pin.sym} 3500 -22010 0 0 {name=p3202 lab=_80665_/Q }
C {devices/lab_pin.sym} 3580 -22010 0 1 {name=p3203 lab=_55168_/A }
C {sky130_stdcells/buf_2.sym} 3540 -22010 0 0 {name=X_55153_ }
C {devices/lab_pin.sym} 3460 -21920 0 0 {name=p3204 lab=_66899_/X }
C {devices/lab_pin.sym} 3460 -21880 0 0 {name=p3205 lab=_67130_/Y }
C {devices/lab_pin.sym} 3460 -21840 0 0 {name=p3206 lab=_67031_/X }
C {devices/lab_pin.sym} 3460 -21800 0 0 {name=p3207 lab=_67138_/Y }
C {devices/lab_pin.sym} 3620 -21860 0 1 {name=p3208 lab=_67139_/X }
C {sky130_stdcells/a211o_4.sym} 3540 -21860 0 0 {name=X_67139_ }
C {devices/lab_pin.sym} 3480 -21730 0 0 {name=p3209 lab=_52365_/A }
C {devices/lab_pin.sym} 3480 -21690 0 0 {name=p3210 lab=_52310_/B }
C {devices/lab_pin.sym} 3480 -21650 0 0 {name=p3211 lab=_52291_/C }
C {devices/lab_pin.sym} 3600 -21690 0 1 {name=p3212 lab=_52365_/X }
C {sky130_stdcells/and3_4.sym} 3540 -21690 0 0 {name=X_52365_ }
C {devices/lab_pin.sym} 3450 -21550 0 0 {name=p3213 lab=_81627_/CLK }
C {devices/lab_pin.sym} 3450 -21530 0 0 {name=p3214 lab=_83185_/D }
C {devices/lab_pin.sym} 3630 -21550 0 1 {name=p3215 lab=_70241_/C }
C {sky130_stdcells/dfxtp_4.sym} 3540 -21540 0 0 {name=X_83185_ }
C {devices/lab_pin.sym} 3480 -21420 0 0 {name=p3216 lab=_84755_/Q }
C {devices/lab_pin.sym} 3480 -21380 0 0 {name=p3217 lab=_80397_/B }
C {devices/lab_pin.sym} 3600 -21400 0 1 {name=p3218 lab=_80397_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -21400 0 0 {name=X_80397_ }
C {devices/lab_pin.sym} 3500 -21270 0 0 {name=p3219 lab=clkbuf_9_10_0_CLK/X }
C {devices/lab_pin.sym} 3580 -21270 0 1 {name=p3220 lab=_85192_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 3540 -21270 0 0 {name=Xclkbuf_10_21_0_CLK }
C {devices/lab_pin.sym} 3480 -21180 0 0 {name=p3221 lab=_54123_/A }
C {devices/lab_pin.sym} 3480 -21140 0 0 {name=p3222 lab=_53428_/X }
C {devices/lab_pin.sym} 3480 -21100 0 0 {name=p3223 lab=_54111_/C }
C {devices/lab_pin.sym} 3480 -21060 0 0 {name=p3224 lab=_52938_/D }
C {devices/lab_pin.sym} 3600 -21120 0 1 {name=p3225 lab=_54104_/X }
C {sky130_stdcells/and4_4.sym} 3540 -21120 0 0 {name=X_54104_ }
C {devices/lab_pin.sym} 3480 -20980 0 0 {name=p3226 lab=_51310_/X }
C {devices/lab_pin.sym} 3480 -20940 0 0 {name=p3227 lab=_51316_/B }
C {devices/lab_pin.sym} 3600 -20960 0 1 {name=p3228 lab=_51316_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -20960 0 0 {name=X_51316_ }
C {devices/lab_pin.sym} 3460 -20860 0 0 {name=p3229 lab=_83524_/Q }
C {devices/lab_pin.sym} 3460 -20820 0 0 {name=p3230 lab=_83172_/Q }
C {devices/lab_pin.sym} 3460 -20780 0 0 {name=p3231 lab=_83519_/Q }
C {devices/lab_pin.sym} 3460 -20740 0 0 {name=p3232 lab=_83167_/Q }
C {devices/lab_pin.sym} 3620 -20800 0 1 {name=p3233 lab=_70150_/Y }
C {sky130_stdcells/a22oi_4.sym} 3540 -20800 0 0 {name=X_70150_ }
C {devices/lab_pin.sym} 3450 -20650 0 0 {name=p3234 lab=_81970_/CLK }
C {devices/lab_pin.sym} 3450 -20630 0 0 {name=p3235 lab=_82136_/D }
C {devices/lab_pin.sym} 3630 -20650 0 1 {name=p3236 lab=_77376_/B }
C {sky130_stdcells/dfxtp_4.sym} 3540 -20640 0 0 {name=X_82136_ }
C {devices/lab_pin.sym} 3500 -20510 0 0 {name=p3237 lab=clkbuf_8_180_0_CLK/X }
C {devices/lab_pin.sym} 3580 -20510 0 1 {name=p3238 lab=clkbuf_9_360_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 3540 -20510 0 0 {name=Xclkbuf_9_360_0_CLK }
C {devices/lab_pin.sym} 3460 -20410 0 0 {name=p3239 lab=_55081_/Y }
C {devices/lab_pin.sym} 3460 -20370 0 0 {name=p3240 lab=_55076_/X }
C {devices/lab_pin.sym} 3460 -20330 0 0 {name=p3241 lab=_55083_/X }
C {devices/lab_pin.sym} 3620 -20370 0 1 {name=p3242 lab=_85322_/D }
C {sky130_stdcells/a21oi_4.sym} 3540 -20370 0 0 {name=X_55084_ }
C {devices/lab_pin.sym} 3500 -20230 0 0 {name=p3243 lab=_59961_/A }
C {devices/lab_pin.sym} 3580 -20230 0 1 {name=p3244 lab=_64386_/A }
C {sky130_stdcells/buf_2.sym} 3540 -20230 0 0 {name=X_59961_ }
C {devices/lab_pin.sym} 3460 -20130 0 0 {name=p3245 lab=_52294_/Y }
C {devices/lab_pin.sym} 3460 -20090 0 0 {name=p3246 lab=_52289_/X }
C {devices/lab_pin.sym} 3460 -20050 0 0 {name=p3247 lab=_52295_/X }
C {devices/lab_pin.sym} 3620 -20090 0 1 {name=p3248 lab=_52296_/Y }
C {sky130_stdcells/a21oi_4.sym} 3540 -20090 0 0 {name=X_52296_ }
C {devices/lab_pin.sym} 3450 -19950 0 0 {name=p3249 lab=_87993_/CLK }
C {devices/lab_pin.sym} 3450 -19930 0 0 {name=p3250 lab=_87993_/D }
C {devices/lab_pin.sym} 3630 -19950 0 1 {name=p3251 lab=_87993_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -19940 0 0 {name=X_87993_ }
C {devices/lab_pin.sym} 3460 -19830 0 0 {name=p3252 lab=_58877_/X }
C {devices/lab_pin.sym} 3460 -19790 0 0 {name=p3253 lab=_85926_/Q }
C {devices/lab_pin.sym} 3460 -19750 0 0 {name=p3254 lab=_58900_/X }
C {devices/lab_pin.sym} 3620 -19790 0 1 {name=p3255 lab=_58912_/X }
C {sky130_stdcells/o21a_4.sym} 3540 -19790 0 0 {name=X_58912_ }
C {devices/lab_pin.sym} 3500 -19650 0 0 {name=p3256 lab=_54320_/A }
C {devices/lab_pin.sym} 3580 -19650 0 1 {name=p3257 lab=_54035_/X }
C {sky130_stdcells/buf_2.sym} 3540 -19650 0 0 {name=X_54035_ }
C {devices/lab_pin.sym} 3500 -19530 0 0 {name=p3258 lab=clkbuf_9_127_0_CLK/X }
C {devices/lab_pin.sym} 3580 -19530 0 1 {name=p3259 lab=_81094_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 3540 -19530 0 0 {name=Xclkbuf_10_254_0_CLK }
C {devices/lab_pin.sym} 3480 -19420 0 0 {name=p3260 lab=_51278_/A }
C {devices/lab_pin.sym} 3480 -19380 0 0 {name=p3261 lab=_46276_/A }
C {devices/lab_pin.sym} 3600 -19400 0 1 {name=p3262 lab=_51247_/X }
C {sky130_stdcells/and2_4.sym} 3540 -19400 0 0 {name=X_51247_ }
C {devices/lab_pin.sym} 3500 -19270 0 0 {name=p3263 lab=_70056_/A }
C {devices/lab_pin.sym} 3580 -19270 0 1 {name=p3264 lab=_70081_/X }
C {sky130_stdcells/buf_2.sym} 3540 -19270 0 0 {name=X_70081_ }
C {devices/lab_pin.sym} 3450 -19150 0 0 {name=p3265 lab=_88398_/CLK }
C {devices/lab_pin.sym} 3450 -19130 0 0 {name=p3266 lab=_86944_/D }
C {devices/lab_pin.sym} 3630 -19150 0 1 {name=p3267 lab=_86944_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -19140 0 0 {name=X_86944_ }
C {devices/lab_pin.sym} 3450 -19010 0 0 {name=p3268 lab=_82067_/CLK }
C {devices/lab_pin.sym} 3450 -18990 0 0 {name=p3269 lab=_82067_/D }
C {devices/lab_pin.sym} 3630 -19010 0 1 {name=p3270 lab=_82067_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -19000 0 0 {name=X_82067_ }
C {devices/lab_pin.sym} 3480 -18880 0 0 {name=p3271 lab=_60593_/B }
C {devices/lab_pin.sym} 3480 -18840 0 0 {name=p3272 lab=_61066_/B }
C {devices/lab_pin.sym} 3600 -18860 0 1 {name=p3273 lab=_59892_/Y }
C {sky130_stdcells/nor2_4.sym} 3540 -18860 0 0 {name=X_59892_ }
C {devices/lab_pin.sym} 3500 -18730 0 0 {name=p3274 lab=_40946_/A }
C {devices/lab_pin.sym} 3580 -18730 0 1 {name=p3275 lab=_41000_/X }
C {sky130_stdcells/buf_2.sym} 3540 -18730 0 0 {name=X_41000_ }
C {devices/lab_pin.sym} 3500 -18610 0 0 {name=p3276 lab=clkbuf_9_442_0_CLK/X }
C {devices/lab_pin.sym} 3580 -18610 0 1 {name=p3277 lab=_86040_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 3540 -18610 0 0 {name=Xclkbuf_10_884_0_CLK }
C {devices/lab_pin.sym} 3450 -18490 0 0 {name=p3278 lab=_82152_/CLK }
C {devices/lab_pin.sym} 3450 -18470 0 0 {name=p3279 lab=_84226_/Q }
C {devices/lab_pin.sym} 3630 -18490 0 1 {name=p3280 lab=_81018_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -18480 0 0 {name=X_81018_ }
C {devices/lab_pin.sym} 3500 -18350 0 0 {name=p3281 lab=_84795_/Q }
C {devices/lab_pin.sym} 3580 -18350 0 1 {name=p3282 lab=_58843_/Y }
C {sky130_stdcells/inv_2.sym} 3540 -18350 0 0 {name=X_58843_ }
C {devices/lab_pin.sym} 3460 -18250 0 0 {name=p3283 lab=_51174_/Y }
C {devices/lab_pin.sym} 3460 -18210 0 0 {name=p3284 lab=_51175_/X }
C {devices/lab_pin.sym} 3460 -18170 0 0 {name=p3285 lab=_51177_/X }
C {devices/lab_pin.sym} 3620 -18210 0 1 {name=p3286 lab=_86060_/D }
C {sky130_stdcells/a21oi_4.sym} 3540 -18210 0 0 {name=X_51178_ }
C {devices/lab_pin.sym} 3500 -18070 0 0 {name=p3287 lab=clkbuf_9_18_0_CLK/X }
C {devices/lab_pin.sym} 3580 -18070 0 1 {name=p3288 lab=_85144_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 3540 -18070 0 0 {name=Xclkbuf_10_36_0_CLK }
C {devices/lab_pin.sym} 3450 -17950 0 0 {name=p3289 lab=_86873_/CLK }
C {devices/lab_pin.sym} 3450 -17930 0 0 {name=p3290 lab=_86875_/D }
C {devices/lab_pin.sym} 3630 -17950 0 1 {name=p3291 lab=_63051_/B }
C {sky130_stdcells/dfxtp_4.sym} 3540 -17940 0 0 {name=X_86875_ }
C {devices/lab_pin.sym} 3500 -17810 0 0 {name=p3292 lab=clkbuf_9_375_0_CLK/A }
C {devices/lab_pin.sym} 3580 -17810 0 1 {name=p3293 lab=clkbuf_9_375_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 3540 -17810 0 0 {name=Xclkbuf_9_375_0_CLK }
C {devices/lab_pin.sym} 3460 -17710 0 0 {name=p3294 lab=_65012_/B }
C {devices/lab_pin.sym} 3460 -17670 0 0 {name=p3295 lab=_50113_/X }
C {devices/lab_pin.sym} 3460 -17630 0 0 {name=p3296 lab=_50128_/Y }
C {devices/lab_pin.sym} 3620 -17670 0 1 {name=p3297 lab=_50129_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -17670 0 0 {name=X_50129_ }
C {devices/lab_pin.sym} 3460 -17550 0 0 {name=p3298 lab=_73837_/X }
C {devices/lab_pin.sym} 3460 -17510 0 0 {name=p3299 lab=_73838_/Y }
C {devices/lab_pin.sym} 3460 -17470 0 0 {name=p3300 lab=_73839_/X }
C {devices/lab_pin.sym} 3620 -17510 0 1 {name=p3301 lab=_73840_/X }
C {sky130_stdcells/a21o_4.sym} 3540 -17510 0 0 {name=X_73840_ }
C {devices/lab_pin.sym} 3450 -17370 0 0 {name=p3302 lab=_85826_/CLK }
C {devices/lab_pin.sym} 3450 -17350 0 0 {name=p3303 lab=_85826_/D }
C {devices/lab_pin.sym} 3630 -17370 0 1 {name=p3304 lab=_85826_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -17360 0 0 {name=X_85826_ }
C {devices/lab_pin.sym} 3460 -17250 0 0 {name=p3305 lab=_58771_/Y }
C {devices/lab_pin.sym} 3460 -17210 0 0 {name=p3306 lab=_58773_/Y }
C {devices/lab_pin.sym} 3460 -17170 0 0 {name=p3307 lab=_58761_/X }
C {devices/lab_pin.sym} 3620 -17210 0 1 {name=p3308 lab=_58774_/X }
C {sky130_stdcells/a21o_4.sym} 3540 -17210 0 0 {name=X_58774_ }
C {devices/lab_pin.sym} 3480 -17080 0 0 {name=p3309 lab=_74284_/C }
C {devices/lab_pin.sym} 3480 -17040 0 0 {name=p3310 lab=_55985_/Y }
C {devices/lab_pin.sym} 3600 -17060 0 1 {name=p3311 lab=_55986_/X }
C {sky130_stdcells/xor2_4.sym} 3540 -17060 0 0 {name=X_55986_ }
C {devices/lab_pin.sym} 3500 -16930 0 0 {name=p3312 lab=clkbuf_9_134_0_CLK/X }
C {devices/lab_pin.sym} 3580 -16930 0 1 {name=p3313 lab=_83766_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 3540 -16930 0 0 {name=Xclkbuf_10_269_0_CLK }
C {devices/lab_pin.sym} 3460 -16830 0 0 {name=p3314 lab=_46224_/X }
C {devices/lab_pin.sym} 3460 -16790 0 0 {name=p3315 lab=_85408_/Q }
C {devices/lab_pin.sym} 3460 -16750 0 0 {name=p3316 lab=_57724_/X }
C {devices/lab_pin.sym} 3620 -16790 0 1 {name=p3317 lab=_57725_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -16790 0 0 {name=X_57725_ }
C {devices/lab_pin.sym} 3500 -16650 0 0 {name=p3318 lab=_42951_/A }
C {devices/lab_pin.sym} 3580 -16650 0 1 {name=p3319 lab=_42951_/X }
C {sky130_stdcells/buf_2.sym} 3540 -16650 0 0 {name=X_42951_ }
C {devices/lab_pin.sym} 3480 -16560 0 0 {name=p3320 lab=_54932_/A }
C {devices/lab_pin.sym} 3480 -16520 0 0 {name=p3321 lab=_54942_/B }
C {devices/lab_pin.sym} 3480 -16480 0 0 {name=p3322 lab=_54932_/C }
C {devices/lab_pin.sym} 3480 -16440 0 0 {name=p3323 lab=_53244_/D }
C {devices/lab_pin.sym} 3600 -16500 0 1 {name=p3324 lab=_54937_/X }
C {sky130_stdcells/and4_4.sym} 3540 -16500 0 0 {name=X_54937_ }
C {devices/lab_pin.sym} 3460 -16380 0 0 {name=p3325 lab=_68588_/Y }
C {devices/lab_pin.sym} 3460 -16340 0 0 {name=p3326 lab=_73674_/X }
C {devices/lab_pin.sym} 3460 -16300 0 0 {name=p3327 lab=_73698_/X }
C {devices/lab_pin.sym} 3460 -16260 0 0 {name=p3328 lab=_73770_/Y }
C {devices/lab_pin.sym} 3620 -16320 0 1 {name=p3329 lab=_73771_/X }
C {sky130_stdcells/a211o_4.sym} 3540 -16320 0 0 {name=X_73771_ }
C {devices/lab_pin.sym} 3450 -16170 0 0 {name=p3330 lab=_85757_/CLK }
C {devices/lab_pin.sym} 3450 -16150 0 0 {name=p3331 lab=_52776_/Y }
C {devices/lab_pin.sym} 3630 -16170 0 1 {name=p3332 lab=_85757_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -16160 0 0 {name=X_85757_ }
C {devices/lab_pin.sym} 3500 -16030 0 0 {name=p3333 lab=_70983_/A }
C {devices/lab_pin.sym} 3580 -16030 0 1 {name=p3334 lab=_70983_/X }
C {sky130_stdcells/buf_2.sym} 3540 -16030 0 0 {name=X_70983_ }
C {devices/lab_pin.sym} 3450 -15910 0 0 {name=p3335 lab=_82206_/CLK }
C {devices/lab_pin.sym} 3450 -15890 0 0 {name=p3336 lab=_82777_/Q }
C {devices/lab_pin.sym} 3630 -15910 0 1 {name=p3337 lab=_46696_/A }
C {sky130_stdcells/dfxtp_4.sym} 3540 -15900 0 0 {name=X_82969_ }
C {devices/lab_pin.sym} 3500 -15770 0 0 {name=p3338 lab=clkbuf_9_449_0_CLK/X }
C {devices/lab_pin.sym} 3580 -15770 0 1 {name=p3339 lab=_86982_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 3540 -15770 0 0 {name=Xclkbuf_10_899_0_CLK }
C {devices/lab_pin.sym} 3480 -15670 0 0 {name=p3340 lab=_75510_/A }
C {devices/lab_pin.sym} 3480 -15630 0 0 {name=p3341 lab=_75482_/Y }
C {devices/lab_pin.sym} 3480 -15590 0 0 {name=p3342 lab=_75509_/Y }
C {devices/lab_pin.sym} 3600 -15630 0 1 {name=p3343 lab=_75510_/X }
C {sky130_stdcells/and3_4.sym} 3540 -15630 0 0 {name=X_75510_ }
C {devices/lab_pin.sym} 3480 -15510 0 0 {name=p3344 lab=_41902_/A }
C {devices/lab_pin.sym} 3480 -15470 0 0 {name=p3345 lab=_40591_/B }
C {devices/lab_pin.sym} 3480 -15430 0 0 {name=p3346 lab=_46616_/A }
C {devices/lab_pin.sym} 3600 -15470 0 1 {name=p3347 lab=_41902_/X }
C {sky130_stdcells/and3_4.sym} 3540 -15470 0 0 {name=X_41902_ }
C {devices/lab_pin.sym} 3500 -15330 0 0 {name=p3348 lab=_72721_/X }
C {devices/lab_pin.sym} 3580 -15330 0 1 {name=p3349 lab=_72722_/X }
C {sky130_stdcells/buf_2.sym} 3540 -15330 0 0 {name=X_72722_ }
C {devices/lab_pin.sym} 3450 -15210 0 0 {name=p3350 lab=_84355_/CLK }
C {devices/lab_pin.sym} 3450 -15190 0 0 {name=p3351 lab=_59719_/Y }
C {devices/lab_pin.sym} 3630 -15210 0 1 {name=p3352 lab=_80568_/A }
C {sky130_stdcells/dfxtp_4.sym} 3540 -15200 0 0 {name=X_84708_ }
C {devices/lab_pin.sym} 3500 -15070 0 0 {name=p3353 lab=_84960_/Q }
C {devices/lab_pin.sym} 3580 -15070 0 1 {name=p3354 lab=_57656_/X }
C {sky130_stdcells/buf_2.sym} 3540 -15070 0 0 {name=X_57656_ }
C {devices/lab_pin.sym} 3460 -14970 0 0 {name=p3355 lab=_45668_/X }
C {devices/lab_pin.sym} 3460 -14930 0 0 {name=p3356 lab=_61542_/A }
C {devices/lab_pin.sym} 3460 -14890 0 0 {name=p3357 lab=_45608_/X }
C {devices/lab_pin.sym} 3620 -14930 0 1 {name=p3358 lab=_45670_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -14930 0 0 {name=X_45670_ }
C {devices/lab_pin.sym} 3500 -14790 0 0 {name=p3359 lab=_76489_/Y }
C {devices/lab_pin.sym} 3580 -14790 0 1 {name=p3360 lab=_76491_/C }
C {sky130_stdcells/inv_2.sym} 3540 -14790 0 0 {name=X_76490_ }
C {devices/lab_pin.sym} 3460 -14690 0 0 {name=p3361 lab=_85363_/Q }
C {devices/lab_pin.sym} 3460 -14650 0 0 {name=p3362 lab=_54865_/X }
C {devices/lab_pin.sym} 3460 -14610 0 0 {name=p3363 lab=_54867_/Y }
C {devices/lab_pin.sym} 3620 -14650 0 1 {name=p3364 lab=_54868_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -14650 0 0 {name=X_54868_ }
C {devices/lab_pin.sym} 3460 -14550 0 0 {name=p3365 lab=_42874_/X }
C {devices/lab_pin.sym} 3460 -14510 0 0 {name=p3366 lab=_42875_/X }
C {devices/lab_pin.sym} 3460 -14470 0 0 {name=p3367 lab=_41616_/X }
C {devices/lab_pin.sym} 3460 -14430 0 0 {name=p3368 lab=_87670_/Q }
C {devices/lab_pin.sym} 3460 -14390 0 0 {name=p3369 lab=_42881_/X }
C {devices/lab_pin.sym} 3620 -14470 0 1 {name=p3370 lab=_42883_/A }
C {sky130_stdcells/o32ai_4.sym} 3540 -14470 0 0 {name=X_42882_ }
C {devices/lab_pin.sym} 3450 -14310 0 0 {name=p3371 lab=_85688_/CLK }
C {devices/lab_pin.sym} 3450 -14290 0 0 {name=p3372 lab=_53152_/Y }
C {devices/lab_pin.sym} 3630 -14310 0 1 {name=p3373 lab=_85688_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -14300 0 0 {name=X_85688_ }
C {devices/lab_pin.sym} 3500 -14170 0 0 {name=p3374 lab=_56607_/A }
C {devices/lab_pin.sym} 3580 -14170 0 1 {name=p3375 lab=_56607_/X }
C {sky130_stdcells/buf_2.sym} 3540 -14170 0 0 {name=X_56607_ }
C {devices/lab_pin.sym} 3460 -14080 0 0 {name=p3376 lab=_40985_/Y }
C {devices/lab_pin.sym} 3460 -14040 0 0 {name=p3377 lab=_44618_/X }
C {devices/lab_pin.sym} 3460 -14000 0 0 {name=p3378 lab=_87029_/Q }
C {devices/lab_pin.sym} 3460 -13960 0 0 {name=p3379 lab=_44619_/X }
C {devices/lab_pin.sym} 3620 -14020 0 1 {name=p3380 lab=_87029_/D }
C {sky130_stdcells/a2bb2o_4.sym} 3540 -14020 0 0 {name=X_44621_ }
C {devices/lab_pin.sym} 3460 -13890 0 0 {name=p3381 lab=_75423_/Y }
C {devices/lab_pin.sym} 3460 -13850 0 0 {name=p3382 lab=_75427_/B }
C {devices/lab_pin.sym} 3460 -13810 0 0 {name=p3383 lab=_75426_/A }
C {devices/lab_pin.sym} 3620 -13850 0 1 {name=p3384 lab=_75441_/X }
C {sky130_stdcells/o21a_4.sym} 3540 -13850 0 0 {name=X_75441_ }
C {devices/lab_pin.sym} 3450 -13710 0 0 {name=p3385 lab=_87686_/CLK }
C {devices/lab_pin.sym} 3450 -13690 0 0 {name=p3386 lab=_43428_/Y }
C {devices/lab_pin.sym} 3630 -13710 0 1 {name=p3387 lab=_87427_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -13700 0 0 {name=X_87427_ }
C {devices/lab_pin.sym} 3460 -13610 0 0 {name=p3388 lab=_41824_/X }
C {devices/lab_pin.sym} 3460 -13570 0 0 {name=p3389 lab=_41825_/X }
C {devices/lab_pin.sym} 3460 -13530 0 0 {name=p3390 lab=_40474_/X }
C {devices/lab_pin.sym} 3460 -13490 0 0 {name=p3391 lab=_66978_/B }
C {devices/lab_pin.sym} 3460 -13450 0 0 {name=p3392 lab=_41821_/X }
C {devices/lab_pin.sym} 3620 -13530 0 1 {name=p3393 lab=_41834_/A }
C {sky130_stdcells/o32ai_4.sym} 3540 -13530 0 0 {name=X_41833_ }
C {devices/lab_pin.sym} 3480 -13380 0 0 {name=p3394 lab=_53819_/A }
C {devices/lab_pin.sym} 3480 -13340 0 0 {name=p3395 lab=_53819_/B }
C {devices/lab_pin.sym} 3600 -13360 0 1 {name=p3396 lab=_53819_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -13360 0 0 {name=X_53819_ }
C {devices/lab_pin.sym} 3460 -13250 0 0 {name=p3397 lab=_70193_/A }
C {devices/lab_pin.sym} 3460 -13210 0 0 {name=p3398 lab=_72645_/X }
C {devices/lab_pin.sym} 3460 -13170 0 0 {name=p3399 lab=_72652_/Y }
C {devices/lab_pin.sym} 3620 -13210 0 1 {name=p3400 lab=_83202_/D }
C {sky130_stdcells/a21bo_4.sym} 3540 -13210 0 0 {name=X_72653_ }
C {devices/lab_pin.sym} 3450 -13070 0 0 {name=p3401 lab=_83216_/CLK }
C {devices/lab_pin.sym} 3450 -13050 0 0 {name=p3402 lab=_60301_/X }
C {devices/lab_pin.sym} 3630 -13070 0 1 {name=p3403 lab=_79775_/A }
C {sky130_stdcells/dfxtp_4.sym} 3540 -13060 0 0 {name=X_84639_ }
C {devices/lab_pin.sym} 3500 -12930 0 0 {name=p3404 lab=_71964_/A }
C {devices/lab_pin.sym} 3580 -12930 0 1 {name=p3405 lab=_71960_/C }
C {sky130_stdcells/buf_2.sym} 3540 -12930 0 0 {name=X_57587_ }
C {devices/lab_pin.sym} 3460 -12830 0 0 {name=p3406 lab=_54797_/Y }
C {devices/lab_pin.sym} 3460 -12790 0 0 {name=p3407 lab=_54774_/X }
C {devices/lab_pin.sym} 3460 -12750 0 0 {name=p3408 lab=_54798_/X }
C {devices/lab_pin.sym} 3620 -12790 0 1 {name=p3409 lab=_54799_/Y }
C {sky130_stdcells/a21oi_4.sym} 3540 -12790 0 0 {name=X_54799_ }
C {devices/lab_pin.sym} 3500 -12650 0 0 {name=p3410 lab=clkbuf_9_411_0_CLK/X }
C {devices/lab_pin.sym} 3580 -12650 0 1 {name=p3411 lab=_82931_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 3540 -12650 0 0 {name=Xclkbuf_10_822_0_CLK }
C {devices/lab_pin.sym} 3500 -12530 0 0 {name=p3412 lab=_54685_/D }
C {devices/lab_pin.sym} 3580 -12530 0 1 {name=p3413 lab=_52993_/D }
C {sky130_stdcells/buf_2.sym} 3540 -12530 0 0 {name=X_47340_ }
C {devices/lab_pin.sym} 3500 -12410 0 0 {name=p3414 lab=_59255_/A }
C {devices/lab_pin.sym} 3580 -12410 0 1 {name=p3415 lab=_59326_/X }
C {sky130_stdcells/buf_2.sym} 3540 -12410 0 0 {name=X_59326_ }
C {devices/lab_pin.sym} 3500 -12290 0 0 {name=p3416 lab=_71603_/Y }
C {devices/lab_pin.sym} 3580 -12290 0 1 {name=p3417 lab=_71604_/X }
C {sky130_stdcells/buf_2.sym} 3540 -12290 0 0 {name=X_71604_ }
C {devices/lab_pin.sym} 3480 -12180 0 0 {name=p3418 lab=_82669_/Q }
C {devices/lab_pin.sym} 3480 -12140 0 0 {name=p3419 lab=_78160_/B }
C {devices/lab_pin.sym} 3600 -12160 0 1 {name=p3420 lab=_78160_/X }
C {sky130_stdcells/xor2_4.sym} 3540 -12160 0 0 {name=X_78160_ }
C {devices/lab_pin.sym} 3460 -12070 0 0 {name=p3421 lab=_44547_/X }
C {devices/lab_pin.sym} 3460 -12030 0 0 {name=p3422 lab=_44548_/X }
C {devices/lab_pin.sym} 3460 -11990 0 0 {name=p3423 lab=_40839_/X }
C {devices/lab_pin.sym} 3460 -11950 0 0 {name=p3424 lab=_87057_/Q }
C {devices/lab_pin.sym} 3460 -11910 0 0 {name=p3425 lab=_44549_/X }
C {devices/lab_pin.sym} 3620 -11990 0 1 {name=p3426 lab=_44552_/Y }
C {sky130_stdcells/o32ai_4.sym} 3540 -11990 0 0 {name=X_44552_ }
C {devices/lab_pin.sym} 3480 -11850 0 0 {name=p3427 lab=_56538_/A }
C {devices/lab_pin.sym} 3480 -11810 0 0 {name=p3428 lab=_56535_/X }
C {devices/lab_pin.sym} 3480 -11770 0 0 {name=p3429 lab=_55732_/B }
C {devices/lab_pin.sym} 3600 -11810 0 1 {name=p3430 lab=_56538_/Y }
C {sky130_stdcells/nand3_4.sym} 3540 -11810 0 0 {name=X_56538_ }
C {devices/lab_pin.sym} 3480 -11680 0 0 {name=p3431 lab=_80694_/Q }
C {devices/lab_pin.sym} 3480 -11640 0 0 {name=p3432 lab=_80950_/D }
C {devices/lab_pin.sym} 3600 -11660 0 1 {name=p3433 lab=_75372_/Y }
C {sky130_stdcells/nor2_4.sym} 3540 -11660 0 0 {name=X_75372_ }
C {devices/lab_pin.sym} 3500 -11530 0 0 {name=p3434 lab=_41764_/A }
C {devices/lab_pin.sym} 3580 -11530 0 1 {name=p3435 lab=_41764_/Y }
C {sky130_stdcells/inv_2.sym} 3540 -11530 0 0 {name=X_41764_ }
C {devices/lab_pin.sym} 3450 -11410 0 0 {name=p3436 lab=_86784_/CLK }
C {devices/lab_pin.sym} 3450 -11390 0 0 {name=p3437 lab=_87358_/D }
C {devices/lab_pin.sym} 3630 -11410 0 1 {name=p3438 lab=_87358_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -11400 0 0 {name=X_87358_ }
C {devices/lab_pin.sym} 3480 -11290 0 0 {name=p3439 lab=_72584_/A }
C {devices/lab_pin.sym} 3480 -11250 0 0 {name=p3440 lab=_72530_/A }
C {devices/lab_pin.sym} 3480 -11210 0 0 {name=p3441 lab=_72584_/C }
C {devices/lab_pin.sym} 3600 -11250 0 1 {name=p3442 lab=_72585_/A }
C {sky130_stdcells/nand3_4.sym} 3540 -11250 0 0 {name=X_72584_ }
C {devices/lab_pin.sym} 3480 -11120 0 0 {name=p3443 lab=_77111_/A }
C {devices/lab_pin.sym} 3480 -11080 0 0 {name=p3444 lab=_82290_/D }
C {devices/lab_pin.sym} 3600 -11100 0 1 {name=p3445 lab=_77111_/X }
C {sky130_stdcells/xor2_4.sym} 3540 -11100 0 0 {name=X_77111_ }
C {devices/lab_pin.sym} 3500 -10970 0 0 {name=p3446 lab=_43425_/X }
C {devices/lab_pin.sym} 3580 -10970 0 1 {name=p3447 lab=_43503_/X }
C {sky130_stdcells/buf_2.sym} 3540 -10970 0 0 {name=X_43503_ }
C {devices/lab_pin.sym} 3480 -10870 0 0 {name=p3448 lab=_74325_/A }
C {devices/lab_pin.sym} 3480 -10830 0 0 {name=p3449 lab=_74325_/B }
C {devices/lab_pin.sym} 3480 -10790 0 0 {name=p3450 lab=_55854_/X }
C {devices/lab_pin.sym} 3600 -10830 0 1 {name=p3451 lab=_74323_/Y }
C {sky130_stdcells/nand3_4.sym} 3540 -10830 0 0 {name=X_74323_ }
C {devices/lab_pin.sym} 3500 -10690 0 0 {name=p3452 lab=clkbuf_9_313_0_CLK/A }
C {devices/lab_pin.sym} 3580 -10690 0 1 {name=p3453 lab=clkbuf_9_313_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 3540 -10690 0 0 {name=Xclkbuf_9_313_0_CLK }
C {devices/lab_pin.sym} 3450 -10570 0 0 {name=p3454 lab=_86627_/CLK }
C {devices/lab_pin.sym} 3450 -10550 0 0 {name=p3455 lab=_49867_/Y }
C {devices/lab_pin.sym} 3630 -10570 0 1 {name=p3456 lab=_58096_/B }
C {sky130_stdcells/dfxtp_4.sym} 3540 -10560 0 0 {name=X_86309_ }
C {devices/lab_pin.sym} 3460 -10450 0 0 {name=p3457 lab=_40621_/X }
C {devices/lab_pin.sym} 3460 -10410 0 0 {name=p3458 lab=_40888_/A }
C {devices/lab_pin.sym} 3460 -10370 0 0 {name=p3459 lab=_40714_/X }
C {devices/lab_pin.sym} 3620 -10410 0 1 {name=p3460 lab=_40716_/A }
C {sky130_stdcells/o21ai_4.sym} 3540 -10410 0 0 {name=X_40715_ }
C {devices/lab_pin.sym} 3480 -10280 0 0 {name=p3461 lab=_86668_/Q }
C {devices/lab_pin.sym} 3480 -10240 0 0 {name=p3462 lab=_59282_/B }
C {devices/lab_pin.sym} 3600 -10260 0 1 {name=p3463 lab=_59257_/Y }
C {sky130_stdcells/nor2_4.sym} 3540 -10260 0 0 {name=X_59257_ }
C {devices/lab_pin.sym} 3500 -10130 0 0 {name=p3464 lab=_47128_/A }
C {devices/lab_pin.sym} 3580 -10130 0 1 {name=p3465 lab=_47271_/X }
C {sky130_stdcells/buf_2.sym} 3540 -10130 0 0 {name=X_47271_ }
C {devices/lab_pin.sym} 3500 -10010 0 0 {name=p3466 lab=_71137_/B }
C {devices/lab_pin.sym} 3580 -10010 0 1 {name=p3467 lab=_71536_/A }
C {sky130_stdcells/buf_2.sym} 3540 -10010 0 0 {name=X_71535_ }
C {devices/lab_pin.sym} 3480 -9900 0 0 {name=p3468 lab=_82563_/Q }
C {devices/lab_pin.sym} 3480 -9860 0 0 {name=p3469 lab=_78091_/B }
C {devices/lab_pin.sym} 3600 -9880 0 1 {name=p3470 lab=_78091_/Y }
C {sky130_stdcells/nor2_4.sym} 3540 -9880 0 0 {name=X_78091_ }
C {devices/lab_pin.sym} 3500 -9750 0 0 {name=p3471 lab=_44624_/A }
C {devices/lab_pin.sym} 3580 -9750 0 1 {name=p3472 lab=_44549_/A }
C {sky130_stdcells/buf_2.sym} 3540 -9750 0 0 {name=X_44483_ }
C {devices/lab_pin.sym} 3480 -9650 0 0 {name=p3473 lab=_56545_/A }
C {devices/lab_pin.sym} 3480 -9610 0 0 {name=p3474 lab=_56454_/B }
C {devices/lab_pin.sym} 3480 -9570 0 0 {name=p3475 lab=_56469_/C }
C {devices/lab_pin.sym} 3600 -9610 0 1 {name=p3476 lab=_56469_/Y }
C {sky130_stdcells/nand3_4.sym} 3540 -9610 0 0 {name=X_56469_ }
C {devices/lab_pin.sym} 3450 -9470 0 0 {name=p3477 lab=_87824_/CLK }
C {devices/lab_pin.sym} 3450 -9450 0 0 {name=p3478 lab=_43738_/X }
C {devices/lab_pin.sym} 3630 -9470 0 1 {name=p3479 lab=_87289_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3540 -9460 0 0 {name=X_87289_ }
C {devices/lab_pin.sym} 3480 -9340 0 0 {name=p3480 lab=_82901_/Q }
C {devices/lab_pin.sym} 3480 -9300 0 0 {name=p3481 lab=_41660_/X }
C {devices/lab_pin.sym} 3600 -9320 0 1 {name=p3482 lab=_41695_/X }
C {sky130_stdcells/or2_4.sym} 3540 -9320 0 0 {name=X_41695_ }
C {devices/lab_pin.sym} 3460 -9210 0 0 {name=p3483 lab=_48946_/X }
C {devices/lab_pin.sym} 3460 -9170 0 0 {name=p3484 lab=_48495_/Y }
C {devices/lab_pin.sym} 3460 -9130 0 0 {name=p3485 lab=_49009_/Y }
C {devices/lab_pin.sym} 3620 -9170 0 1 {name=p3486 lab=_52328_/B }
C {sky130_stdcells/a21o_4.sym} 3540 -9170 0 0 {name=X_49010_ }
C {devices/lab_pin.sym} 3480 -9050 0 0 {name=p3487 lab=_46222_/A }
C {devices/lab_pin.sym} 3480 -9010 0 0 {name=p3488 lab=_46222_/B }
C {devices/lab_pin.sym} 3480 -8970 0 0 {name=p3489 lab=_46221_/Y }
C {devices/lab_pin.sym} 3600 -9010 0 1 {name=p3490 lab=_46222_/Y }
C {sky130_stdcells/nand3_4.sym} 3540 -9010 0 0 {name=X_46222_ }
C {devices/lab_pin.sym} 3500 -8870 0 0 {name=p3491 lab=clkbuf_9_103_0_CLK/X }
C {devices/lab_pin.sym} 3580 -8870 0 1 {name=p3492 lab=_80728_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 3540 -8870 0 0 {name=Xclkbuf_10_207_0_CLK }
C {sky130_stdcells/decap_3.sym} 3540 -8720 0 0 {name=XPHY_340 }
C {devices/lab_pin.sym} 3460 -8590 0 0 {name=p3493 lab=_58191_/X }
C {devices/lab_pin.sym} 3460 -8550 0 0 {name=p3494 lab=_58204_/Y }
C {devices/lab_pin.sym} 3460 -8510 0 0 {name=p3495 lab=_58207_/Y }
C {devices/lab_pin.sym} 3620 -8550 0 1 {name=p3496 lab=_84908_/D }
C {sky130_stdcells/a21oi_4.sym} 3540 -8550 0 0 {name=X_58208_ }
C {devices/lab_pin.sym} 3480 -8420 0 0 {name=p3497 lab=_77047_/A }
C {devices/lab_pin.sym} 3480 -8380 0 0 {name=p3498 lab=_77041_/Y }
C {devices/lab_pin.sym} 3600 -8400 0 1 {name=p3499 lab=_77042_/X }
C {sky130_stdcells/and2_4.sym} 3540 -8400 0 0 {name=X_77042_ }
C {devices/lab_pin.sym} 3500 -8270 0 0 {name=p3500 lab=_43329_/X }
C {devices/lab_pin.sym} 3580 -8270 0 1 {name=p3501 lab=_43434_/X }
C {sky130_stdcells/buf_2.sym} 3540 -8270 0 0 {name=X_43434_ }
C {devices/lab_pin.sym} 3460 -8180 0 0 {name=p3502 lab=_74016_/X }
C {devices/lab_pin.sym} 3460 -8140 0 0 {name=p3503 lab=_85603_/Q }
C {devices/lab_pin.sym} 3460 -8100 0 0 {name=p3504 lab=_56933_/X }
C {devices/lab_pin.sym} 3460 -8060 0 0 {name=p3505 lab=_74253_/X }
C {devices/lab_pin.sym} 3620 -8120 0 1 {name=p3506 lab=_74254_/X }
C {sky130_stdcells/a211o_4.sym} 3540 -8120 0 0 {name=X_74254_ }
C {sky130_stdcells/decap_3.sym} 3540 -7940 0 0 {name=XPHY_351 }
C {devices/lab_pin.sym} 3500 -7790 0 0 {name=p3507 lab=_40645_/Y }
C {devices/lab_pin.sym} 3580 -7790 0 1 {name=p3508 lab=_40646_/X }
C {sky130_stdcells/buf_2.sym} 3540 -7790 0 0 {name=X_40646_ }
C {devices/lab_pin.sym} 3480 -7680 0 0 {name=p3509 lab=_59154_/A }
C {devices/lab_pin.sym} 3480 -7640 0 0 {name=p3510 lab=_86354_/Q }
C {devices/lab_pin.sym} 3600 -7660 0 1 {name=p3511 lab=_59188_/Y }
C {sky130_stdcells/nor2_4.sym} 3540 -7660 0 0 {name=X_59188_ }
C {devices/lab_pin.sym} 3480 -7560 0 0 {name=p3512 lab=_70880_/B }
C {devices/lab_pin.sym} 3480 -7520 0 0 {name=p3513 lab=_71435_/B }
C {devices/lab_pin.sym} 3480 -7480 0 0 {name=p3514 lab=_70763_/A }
C {devices/lab_pin.sym} 3480 -7440 0 0 {name=p3515 lab=_71476_/D }
C {devices/lab_pin.sym} 3600 -7500 0 1 {name=p3516 lab=_71466_/X }
C {sky130_stdcells/and4_4.sym} 3540 -7500 0 0 {name=X_71466_ }
C {sky130_stdcells/decap_3.sym} 3540 -7320 0 0 {name=XPHY_362 }
C {devices/lab_pin.sym} 3500 -7170 0 0 {name=p3517 lab=clkbuf_9_418_0_CLK/X }
C {devices/lab_pin.sym} 3580 -7170 0 1 {name=p3518 lab=_85955_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 3540 -7170 0 0 {name=Xclkbuf_10_837_0_CLK }
C {sky130_stdcells/decap_3.sym} 3540 -7020 0 0 {name=XPHY_373 }
C {sky130_stdcells/decap_3.sym} 3540 -6840 0 0 {name=XPHY_384 }
C {devices/lab_pin.sym} 3500 -6690 0 0 {name=p3519 lab=_73351_/A }
C {devices/lab_pin.sym} 3580 -6690 0 1 {name=p3520 lab=_73205_/X }
C {sky130_stdcells/buf_2.sym} 3540 -6690 0 0 {name=X_73205_ }
C {devices/lab_pin.sym} 3460 -6590 0 0 {name=p3521 lab=_46120_/A }
C {devices/lab_pin.sym} 3460 -6550 0 0 {name=p3522 lab=_46120_/B }
C {devices/lab_pin.sym} 3460 -6510 0 0 {name=p3523 lab=_46170_/C }
C {devices/lab_pin.sym} 3620 -6550 0 1 {name=p3524 lab=_46158_/A }
C {sky130_stdcells/a21o_4.sym} 3540 -6550 0 0 {name=X_46153_ }
C {devices/lab_pin.sym} 3460 -6430 0 0 {name=p3525 lab=_58085_/X }
C {devices/lab_pin.sym} 3460 -6390 0 0 {name=p3526 lab=_85378_/Q }
C {devices/lab_pin.sym} 3460 -6350 0 0 {name=p3527 lab=_58138_/X }
C {devices/lab_pin.sym} 3620 -6390 0 1 {name=p3528 lab=_58139_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -6390 0 0 {name=X_58139_ }
C {devices/lab_pin.sym} 3500 -6250 0 0 {name=p3529 lab=_70416_/Y }
C {devices/lab_pin.sym} 3580 -6250 0 1 {name=p3530 lab=_71162_/B }
C {sky130_stdcells/buf_2.sym} 3540 -6250 0 0 {name=X_70417_ }
C {sky130_stdcells/decap_3.sym} 3540 -6100 0 0 {name=XPHY_395 }
C {devices/lab_pin.sym} 3460 -5990 0 0 {name=p3531 lab=_43347_/X }
C {devices/lab_pin.sym} 3460 -5950 0 0 {name=p3532 lab=_43350_/X }
C {devices/lab_pin.sym} 3460 -5910 0 0 {name=p3533 lab=_41382_/X }
C {devices/lab_pin.sym} 3460 -5870 0 0 {name=p3534 lab=_87457_/Q }
C {devices/lab_pin.sym} 3460 -5830 0 0 {name=p3535 lab=_43353_/X }
C {devices/lab_pin.sym} 3620 -5910 0 1 {name=p3536 lab=_43366_/A }
C {sky130_stdcells/o32ai_4.sym} 3540 -5910 0 0 {name=X_43365_ }
C {devices/lab_pin.sym} 3460 -5780 0 0 {name=p3537 lab=_41969_/Y }
C {devices/lab_pin.sym} 3460 -5740 0 0 {name=p3538 lab=_73930_/X }
C {devices/lab_pin.sym} 3460 -5700 0 0 {name=p3539 lab=_73031_/X }
C {devices/lab_pin.sym} 3460 -5660 0 0 {name=p3540 lab=_74184_/Y }
C {devices/lab_pin.sym} 3620 -5720 0 1 {name=p3541 lab=_74185_/X }
C {sky130_stdcells/a211o_4.sym} 3540 -5720 0 0 {name=X_74185_ }
C {devices/lab_pin.sym} 3500 -5570 0 0 {name=p3542 lab=_49048_/A }
C {devices/lab_pin.sym} 3580 -5570 0 1 {name=p3543 lab=_40577_/X }
C {sky130_stdcells/buf_2.sym} 3540 -5570 0 0 {name=X_40577_ }
C {devices/lab_pin.sym} 3500 -5450 0 0 {name=p3544 lab=_71396_/Y }
C {devices/lab_pin.sym} 3580 -5450 0 1 {name=p3545 lab=_71397_/X }
C {sky130_stdcells/buf_2.sym} 3540 -5450 0 0 {name=X_71397_ }
C {devices/lab_pin.sym} 3500 -5330 0 0 {name=p3546 lab=clkbuf_9_329_0_CLK/A }
C {devices/lab_pin.sym} 3580 -5330 0 1 {name=p3547 lab=clkbuf_9_328_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 3540 -5330 0 0 {name=Xclkbuf_9_328_0_CLK }
C {devices/lab_pin.sym} 3460 -5230 0 0 {name=p3548 lab=_85204_/Q }
C {devices/lab_pin.sym} 3460 -5190 0 0 {name=p3549 lab=_45102_/X }
C {devices/lab_pin.sym} 3460 -5150 0 0 {name=p3550 lab=_45103_/X }
C {devices/lab_pin.sym} 3620 -5190 0 1 {name=p3551 lab=_45104_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -5190 0 0 {name=X_45104_ }
C {devices/lab_pin.sym} 3500 -5050 0 0 {name=p3552 lab=_42316_/A }
C {devices/lab_pin.sym} 3580 -5050 0 1 {name=p3553 lab=_87925_/D }
C {sky130_stdcells/inv_2.sym} 3540 -5050 0 0 {name=X_42316_ }
C {devices/lab_pin.sym} 3500 -4930 0 0 {name=p3554 lab=_64523_/D }
C {devices/lab_pin.sym} 3580 -4930 0 1 {name=p3555 lab=_61176_/B }
C {sky130_stdcells/buf_2.sym} 3540 -4930 0 0 {name=X_61150_ }
C {devices/lab_pin.sym} 3460 -4840 0 0 {name=p3556 lab=_72959_/X }
C {devices/lab_pin.sym} 3460 -4800 0 0 {name=p3557 lab=_85587_/Q }
C {devices/lab_pin.sym} 3460 -4760 0 0 {name=p3558 lab=_73092_/X }
C {devices/lab_pin.sym} 3460 -4720 0 0 {name=p3559 lab=_73135_/X }
C {devices/lab_pin.sym} 3620 -4780 0 1 {name=p3560 lab=_73136_/X }
C {sky130_stdcells/a211o_4.sym} 3540 -4780 0 0 {name=X_73136_ }
C {devices/lab_pin.sym} 3480 -4660 0 0 {name=p3561 lab=_70348_/A }
C {devices/lab_pin.sym} 3480 -4620 0 0 {name=p3562 lab=_70348_/B }
C {devices/lab_pin.sym} 3480 -4580 0 0 {name=p3563 lab=_83083_/Q }
C {devices/lab_pin.sym} 3480 -4540 0 0 {name=p3564 lab=_70348_/D }
C {devices/lab_pin.sym} 3600 -4600 0 1 {name=p3565 lab=_70348_/X }
C {sky130_stdcells/and4_4.sym} 3540 -4600 0 0 {name=X_70348_ }
C {devices/lab_pin.sym} 3480 -4480 0 0 {name=p3566 lab=_46111_/B }
C {devices/lab_pin.sym} 3480 -4440 0 0 {name=p3567 lab=_46141_/A }
C {devices/lab_pin.sym} 3480 -4400 0 0 {name=p3568 lab=_46115_/A }
C {devices/lab_pin.sym} 3480 -4360 0 0 {name=p3569 lab=_46114_/A }
C {devices/lab_pin.sym} 3600 -4420 0 1 {name=p3570 lab=_46162_/A }
C {sky130_stdcells/nor4_4.sym} 3540 -4420 0 0 {name=X_46084_ }
C {devices/lab_pin.sym} 3500 -4270 0 0 {name=p3571 lab=_43296_/A }
C {devices/lab_pin.sym} 3580 -4270 0 1 {name=p3572 lab=_43296_/X }
C {sky130_stdcells/buf_2.sym} 3540 -4270 0 0 {name=X_43296_ }
C {devices/lab_pin.sym} 3480 -4160 0 0 {name=p3573 lab=_78993_/A }
C {devices/lab_pin.sym} 3480 -4120 0 0 {name=p3574 lab=_78993_/B }
C {devices/lab_pin.sym} 3600 -4140 0 1 {name=p3575 lab=_78994_/B }
C {sky130_stdcells/xor2_4.sym} 3540 -4140 0 0 {name=X_78993_ }
C {devices/lab_pin.sym} 3460 -4030 0 0 {name=p3576 lab=_60091_/B }
C {devices/lab_pin.sym} 3460 -3990 0 0 {name=p3577 lab=_60100_/Y }
C {devices/lab_pin.sym} 3460 -3950 0 0 {name=p3578 lab=_59951_/C }
C {devices/lab_pin.sym} 3620 -3990 0 1 {name=p3579 lab=_60102_/A }
C {sky130_stdcells/o21ai_4.sym} 3540 -3990 0 0 {name=X_60101_ }
C {devices/lab_pin.sym} 3480 -3860 0 0 {name=p3580 lab=_49928_/A }
C {devices/lab_pin.sym} 3480 -3820 0 0 {name=p3581 lab=_53127_/B }
C {devices/lab_pin.sym} 3600 -3840 0 1 {name=p3582 lab=_49912_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -3840 0 0 {name=X_49912_ }
C {devices/lab_pin.sym} 3500 -3710 0 0 {name=p3583 lab=_64305_/B }
C {devices/lab_pin.sym} 3580 -3710 0 1 {name=p3584 lab=_61427_/B }
C {sky130_stdcells/buf_2.sym} 3540 -3710 0 0 {name=X_45035_ }
C {devices/lab_pin.sym} 3460 -3620 0 0 {name=p3585 lab=_41429_/X }
C {devices/lab_pin.sym} 3460 -3580 0 0 {name=p3586 lab=_42222_/X }
C {devices/lab_pin.sym} 3460 -3540 0 0 {name=p3587 lab=_87961_/Q }
C {devices/lab_pin.sym} 3460 -3500 0 0 {name=p3588 lab=_42224_/X }
C {devices/lab_pin.sym} 3620 -3560 0 1 {name=p3589 lab=_87961_/D }
C {sky130_stdcells/a2bb2o_4.sym} 3540 -3560 0 0 {name=X_42247_ }
C {devices/lab_pin.sym} 3500 -3410 0 0 {name=p3590 lab=_61081_/A }
C {devices/lab_pin.sym} 3580 -3410 0 1 {name=p3591 lab=_61122_/A }
C {sky130_stdcells/buf_2.sym} 3540 -3410 0 0 {name=X_61081_ }
C {devices/lab_pin.sym} 3500 -3290 0 0 {name=p3592 lab=_73067_/A }
C {devices/lab_pin.sym} 3580 -3290 0 1 {name=p3593 lab=_73067_/X }
C {sky130_stdcells/buf_2.sym} 3540 -3290 0 0 {name=X_73067_ }
C {devices/lab_pin.sym} 3480 -3180 0 0 {name=p3594 lab=_77961_/B }
C {devices/lab_pin.sym} 3480 -3140 0 0 {name=p3595 lab=_77944_/B }
C {devices/lab_pin.sym} 3600 -3160 0 1 {name=p3596 lab=_77950_/A }
C {sky130_stdcells/xor2_4.sym} 3540 -3160 0 0 {name=X_77944_ }
C {devices/lab_pin.sym} 3500 -3030 0 0 {name=p3597 lab=_83812_/Q }
C {devices/lab_pin.sym} 3580 -3030 0 1 {name=p3598 lab=_74762_/A }
C {sky130_stdcells/inv_2.sym} 3540 -3030 0 0 {name=X_70279_ }
C {devices/lab_pin.sym} 3480 -2930 0 0 {name=p3599 lab=_60064_/A }
C {devices/lab_pin.sym} 3480 -2890 0 0 {name=p3600 lab=_59873_/B }
C {devices/lab_pin.sym} 3480 -2850 0 0 {name=p3601 lab=_60032_/C }
C {devices/lab_pin.sym} 3600 -2890 0 1 {name=p3602 lab=_60032_/Y }
C {sky130_stdcells/nor3_4.sym} 3540 -2890 0 0 {name=X_60032_ }
C {devices/lab_pin.sym} 3480 -2760 0 0 {name=p3603 lab=_72017_/X }
C {devices/lab_pin.sym} 3480 -2720 0 0 {name=p3604 lab=_53841_/B }
C {devices/lab_pin.sym} 3600 -2740 0 1 {name=p3605 lab=_72018_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -2740 0 0 {name=X_72018_ }
C {devices/lab_pin.sym} 3500 -2610 0 0 {name=p3606 lab=_49569_/A }
C {devices/lab_pin.sym} 3580 -2610 0 1 {name=p3607 lab=_49924_/A }
C {sky130_stdcells/buf_2.sym} 3540 -2610 0 0 {name=X_49843_ }
C {devices/lab_pin.sym} 3500 -2490 0 0 {name=p3608 lab=_42178_/A }
C {devices/lab_pin.sym} 3580 -2490 0 1 {name=p3609 lab=_42178_/Y }
C {sky130_stdcells/inv_2.sym} 3540 -2490 0 0 {name=X_42178_ }
C {devices/lab_pin.sym} 3480 -2380 0 0 {name=p3610 lab=_77875_/A }
C {devices/lab_pin.sym} 3480 -2340 0 0 {name=p3611 lab=_77874_/X }
C {devices/lab_pin.sym} 3600 -2360 0 1 {name=p3612 lab=_77879_/A }
C {sky130_stdcells/nand2_4.sym} 3540 -2360 0 0 {name=X_77875_ }
C {devices/lab_pin.sym} 3480 -2240 0 0 {name=p3613 lab=_65268_/C }
C {devices/lab_pin.sym} 3480 -2200 0 0 {name=p3614 lab=_83256_/Q }
C {devices/lab_pin.sym} 3600 -2220 0 1 {name=p3615 lab=_79614_/X }
C {sky130_stdcells/xor2_4.sym} 3540 -2220 0 0 {name=X_79614_ }
C {devices/lab_pin.sym} 3460 -2110 0 0 {name=p3616 lab=_41100_/X }
C {devices/lab_pin.sym} 3460 -2070 0 0 {name=p3617 lab=_40588_/A }
C {devices/lab_pin.sym} 3460 -2030 0 0 {name=p3618 lab=_41128_/X }
C {devices/lab_pin.sym} 3620 -2070 0 1 {name=p3619 lab=_41129_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -2070 0 0 {name=X_41129_ }
C {devices/lab_pin.sym} 3500 -1930 0 0 {name=p3620 lab=_64508_/A }
C {devices/lab_pin.sym} 3580 -1930 0 1 {name=p3621 lab=_64870_/B }
C {sky130_stdcells/buf_2.sym} 3540 -1930 0 0 {name=X_64840_ }
C {devices/lab_pin.sym} 3480 -1820 0 0 {name=p3622 lab=_81589_/Q }
C {devices/lab_pin.sym} 3480 -1780 0 0 {name=p3623 lab=_76826_/B }
C {devices/lab_pin.sym} 3600 -1800 0 1 {name=p3624 lab=_76826_/X }
C {sky130_stdcells/xor2_4.sym} 3540 -1800 0 0 {name=X_76826_ }
C {devices/lab_pin.sym} 3480 -1680 0 0 {name=p3625 lab=_49769_/X }
C {devices/lab_pin.sym} 3480 -1640 0 0 {name=p3626 lab=_52991_/B }
C {devices/lab_pin.sym} 3600 -1660 0 1 {name=p3627 lab=_49774_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -1660 0 0 {name=X_49774_ }
C {devices/lab_pin.sym} 3460 -1550 0 0 {name=p3628 lab=_59090_/A }
C {devices/lab_pin.sym} 3460 -1510 0 0 {name=p3629 lab=_46955_/X }
C {devices/lab_pin.sym} 3460 -1470 0 0 {name=p3630 lab=_46985_/Y }
C {devices/lab_pin.sym} 3620 -1510 0 1 {name=p3631 lab=_46986_/Y }
C {sky130_stdcells/o21ai_4.sym} 3540 -1510 0 0 {name=X_46986_ }
C {devices/lab_pin.sym} 3480 -1380 0 0 {name=p3632 lab=_48725_/A }
C {devices/lab_pin.sym} 3480 -1340 0 0 {name=p3633 lab=_48391_/X }
C {devices/lab_pin.sym} 3600 -1360 0 1 {name=p3634 lab=_48725_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -1360 0 0 {name=X_48725_ }
C {devices/lab_pin.sym} 3480 -1240 0 0 {name=p3635 lab=_79543_/Y }
C {devices/lab_pin.sym} 3480 -1200 0 0 {name=p3636 lab=_79545_/B }
C {devices/lab_pin.sym} 3600 -1220 0 1 {name=p3637 lab=_79545_/Y }
C {sky130_stdcells/nand2_4.sym} 3540 -1220 0 0 {name=X_79545_ }
C {devices/lab_pin.sym} 3480 -1120 0 0 {name=p3638 lab=_44164_/X }
C {devices/lab_pin.sym} 3480 -1080 0 0 {name=p3639 lab=_44140_/X }
C {devices/lab_pin.sym} 3480 -1040 0 0 {name=p3640 lab=_44004_/Y }
C {devices/lab_pin.sym} 3480 -1000 0 0 {name=p3641 lab=_45918_/Y }
C {devices/lab_pin.sym} 3600 -1060 0 1 {name=p3642 lab=_45937_/Y }
C {sky130_stdcells/nand4_4.sym} 3540 -1060 0 0 {name=X_45937_ }
C {devices/lab_pin.sym} 3460 -930 0 0 {name=p3643 lab=_64768_/X }
C {devices/lab_pin.sym} 3460 -890 0 0 {name=p3644 lab=_64770_/X }
C {devices/lab_pin.sym} 3460 -850 0 0 {name=p3645 lab=_64619_/X }
C {devices/lab_pin.sym} 3620 -890 0 1 {name=p3646 lab=_64775_/A }
C {sky130_stdcells/a21o_4.sym} 3540 -890 0 0 {name=X_64771_ }
C {devices/lab_pin.sym} 3480 -760 0 0 {name=p3647 lab=_76744_/A }
C {devices/lab_pin.sym} 3480 -720 0 0 {name=p3648 lab=_76757_/B }
C {devices/lab_pin.sym} 3600 -740 0 1 {name=p3649 lab=_76758_/B }
C {sky130_stdcells/and2_4.sym} 3540 -740 0 0 {name=X_76757_ }
C {devices/lab_pin.sym} 4400 -42180 0 0 {name=p3650 lab=_61522_/X }
C {devices/lab_pin.sym} 4400 -42140 0 0 {name=p3651 lab=_61933_/X }
C {devices/lab_pin.sym} 4400 -42100 0 0 {name=p3652 lab=_61967_/C }
C {devices/lab_pin.sym} 4400 -42060 0 0 {name=p3653 lab=_61952_/D }
C {devices/lab_pin.sym} 4520 -42120 0 1 {name=p3654 lab=_61983_/Y }
C {sky130_stdcells/nand4_4.sym} 4460 -42120 0 0 {name=X_61983_ }
C {devices/lab_pin.sym} 4380 -41990 0 0 {name=p3655 lab=_86990_/Q }
C {devices/lab_pin.sym} 4380 -41950 0 0 {name=p3656 lab=_73776_/X }
C {devices/lab_pin.sym} 4380 -41910 0 0 {name=p3657 lab=_73968_/X }
C {devices/lab_pin.sym} 4540 -41950 0 1 {name=p3658 lab=_73981_/C }
C {sky130_stdcells/o21ai_4.sym} 4460 -41950 0 0 {name=X_73969_ }
C {devices/lab_pin.sym} 4380 -41830 0 0 {name=p3659 lab=_66508_/Y }
C {devices/lab_pin.sym} 4380 -41790 0 0 {name=p3660 lab=_59756_/X }
C {devices/lab_pin.sym} 4380 -41750 0 0 {name=p3661 lab=_66509_/X }
C {devices/lab_pin.sym} 4540 -41790 0 1 {name=p3662 lab=_84109_/D }
C {sky130_stdcells/a21o_4.sym} 4460 -41790 0 0 {name=X_66510_ }
C {devices/lab_pin.sym} 4420 -41650 0 0 {name=p3663 lab=_61003_/A }
C {devices/lab_pin.sym} 4500 -41650 0 1 {name=p3664 lab=_64192_/B }
C {sky130_stdcells/buf_2.sym} 4460 -41650 0 0 {name=X_63722_ }
C {devices/lab_pin.sym} 4400 -41540 0 0 {name=p3665 lab=_75708_/A }
C {devices/lab_pin.sym} 4400 -41500 0 0 {name=p3666 lab=_75707_/Y }
C {devices/lab_pin.sym} 4520 -41520 0 1 {name=p3667 lab=_75711_/A }
C {sky130_stdcells/xor2_4.sym} 4460 -41520 0 0 {name=X_75708_ }
C {devices/lab_pin.sym} 4420 -41390 0 0 {name=p3668 lab=_60934_/A }
C {devices/lab_pin.sym} 4500 -41390 0 1 {name=p3669 lab=_60934_/X }
C {sky130_stdcells/buf_2.sym} 4460 -41390 0 0 {name=X_60934_ }
C {devices/lab_pin.sym} 4420 -41270 0 0 {name=p3670 lab=_48656_/A }
C {devices/lab_pin.sym} 4500 -41270 0 1 {name=p3671 lab=_48849_/A }
C {sky130_stdcells/buf_2.sym} 4460 -41270 0 0 {name=X_48656_ }
C {devices/lab_pin.sym} 4400 -41160 0 0 {name=p3672 lab=_67517_/A }
C {devices/lab_pin.sym} 4400 -41120 0 0 {name=p3673 lab=_88237_/Q }
C {devices/lab_pin.sym} 4520 -41140 0 1 {name=p3674 lab=_67490_/X }
C {sky130_stdcells/and2_4.sym} 4460 -41140 0 0 {name=X_67490_ }
C {devices/lab_pin.sym} 4400 -41020 0 0 {name=p3675 lab=_79476_/A }
C {devices/lab_pin.sym} 4400 -40980 0 0 {name=p3676 lab=_79476_/B }
C {devices/lab_pin.sym} 4520 -41000 0 1 {name=p3677 lab=_79476_/X }
C {sky130_stdcells/xor2_4.sym} 4460 -41000 0 0 {name=X_79476_ }
C {devices/lab_pin.sym} 4400 -40880 0 0 {name=p3678 lab=_55211_/B }
C {devices/lab_pin.sym} 4400 -40840 0 0 {name=p3679 lab=_45736_/B }
C {devices/lab_pin.sym} 4520 -40860 0 1 {name=p3680 lab=_45868_/Y }
C {sky130_stdcells/nor2_4.sym} 4460 -40860 0 0 {name=X_45868_ }
C {devices/lab_pin.sym} 4400 -40740 0 0 {name=p3681 lab=_76688_/A }
C {devices/lab_pin.sym} 4400 -40700 0 0 {name=p3682 lab=_76687_/Y }
C {devices/lab_pin.sym} 4520 -40720 0 1 {name=p3683 lab=_81446_/D }
C {sky130_stdcells/xor2_4.sym} 4460 -40720 0 0 {name=X_76688_ }
C {devices/lab_pin.sym} 4400 -40620 0 0 {name=p3684 lab=_47595_/A }
C {devices/lab_pin.sym} 4400 -40580 0 0 {name=p3685 lab=_47645_/B }
C {devices/lab_pin.sym} 4400 -40540 0 0 {name=p3686 lab=_47595_/C }
C {devices/lab_pin.sym} 4400 -40500 0 0 {name=p3687 lab=_53144_/D }
C {devices/lab_pin.sym} 4520 -40560 0 1 {name=p3688 lab=_47607_/X }
C {sky130_stdcells/and4_4.sym} 4460 -40560 0 0 {name=X_47607_ }
C {devices/lab_pin.sym} 4400 -40430 0 0 {name=p3689 lab=_65004_/X }
C {devices/lab_pin.sym} 4400 -40390 0 0 {name=p3690 lab=_66476_/B }
C {devices/lab_pin.sym} 4400 -40350 0 0 {name=p3691 lab=_65007_/X }
C {devices/lab_pin.sym} 4520 -40390 0 1 {name=p3692 lab=_66441_/Y }
C {sky130_stdcells/nand3_4.sym} 4460 -40390 0 0 {name=X_66441_ }
C {devices/lab_pin.sym} 4380 -40270 0 0 {name=p3693 lab=_78426_/B }
C {devices/lab_pin.sym} 4380 -40230 0 0 {name=p3694 lab=_78413_/A }
C {devices/lab_pin.sym} 4380 -40190 0 0 {name=p3695 lab=_78412_/A }
C {devices/lab_pin.sym} 4540 -40230 0 1 {name=p3696 lab=_78427_/X }
C {sky130_stdcells/o21a_4.sym} 4460 -40230 0 0 {name=X_78427_ }
C {devices/lab_pin.sym} 4380 -40120 0 0 {name=p3697 lab=_41662_/Y }
C {devices/lab_pin.sym} 4380 -40080 0 0 {name=p3698 lab=_44817_/X }
C {devices/lab_pin.sym} 4380 -40040 0 0 {name=p3699 lab=_86937_/Q }
C {devices/lab_pin.sym} 4380 -40000 0 0 {name=p3700 lab=_44818_/X }
C {devices/lab_pin.sym} 4540 -40060 0 1 {name=p3701 lab=_86937_/D }
C {sky130_stdcells/a2bb2o_4.sym} 4460 -40060 0 0 {name=X_44819_ }
C {devices/lab_pin.sym} 4400 -39930 0 0 {name=p3702 lab=_63670_/A }
C {devices/lab_pin.sym} 4400 -39890 0 0 {name=p3703 lab=_63670_/B }
C {devices/lab_pin.sym} 4400 -39850 0 0 {name=p3704 lab=_80371_/B }
C {devices/lab_pin.sym} 4520 -39890 0 1 {name=p3705 lab=_63653_/Y }
C {sky130_stdcells/nor3_4.sym} 4460 -39890 0 0 {name=X_63653_ }
C {devices/lab_pin.sym} 4400 -39760 0 0 {name=p3706 lab=_75632_/A }
C {devices/lab_pin.sym} 4400 -39720 0 0 {name=p3707 lab=_75639_/B }
C {devices/lab_pin.sym} 4520 -39740 0 1 {name=p3708 lab=_75641_/A }
C {sky130_stdcells/nor2_4.sym} 4460 -39740 0 0 {name=X_75639_ }
C {devices/lab_pin.sym} 4400 -39620 0 0 {name=p3709 lab=_48586_/Y }
C {devices/lab_pin.sym} 4400 -39580 0 0 {name=p3710 lab=_48565_/B }
C {devices/lab_pin.sym} 4520 -39600 0 1 {name=p3711 lab=_48587_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -39600 0 0 {name=X_48587_ }
C {devices/lab_pin.sym} 4400 -39500 0 0 {name=p3712 lab=_60997_/A }
C {devices/lab_pin.sym} 4400 -39460 0 0 {name=p3713 lab=_60865_/B }
C {devices/lab_pin.sym} 4400 -39420 0 0 {name=p3714 lab=_60865_/C }
C {devices/lab_pin.sym} 4400 -39380 0 0 {name=p3715 lab=_60864_/X }
C {devices/lab_pin.sym} 4520 -39440 0 1 {name=p3716 lab=_60866_/A }
C {sky130_stdcells/nand4_4.sym} 4460 -39440 0 0 {name=X_60865_ }
C {devices/lab_pin.sym} 4380 -39310 0 0 {name=p3717 lab=_55281_/A }
C {devices/lab_pin.sym} 4380 -39270 0 0 {name=p3718 lab=_45798_/X }
C {devices/lab_pin.sym} 4380 -39230 0 0 {name=p3719 lab=_45743_/X }
C {devices/lab_pin.sym} 4540 -39270 0 1 {name=p3720 lab=_45799_/X }
C {sky130_stdcells/o21a_4.sym} 4460 -39270 0 0 {name=X_45799_ }
C {devices/lab_pin.sym} 4420 -39130 0 0 {name=p3721 lab=_62671_/A }
C {devices/lab_pin.sym} 4500 -39130 0 1 {name=p3722 lab=_62653_/A }
C {sky130_stdcells/buf_2.sym} 4460 -39130 0 0 {name=X_62604_ }
C {devices/lab_pin.sym} 4380 -39030 0 0 {name=p3723 lab=_83944_/Q }
C {devices/lab_pin.sym} 4380 -38990 0 0 {name=p3724 lab=_69066_/X }
C {devices/lab_pin.sym} 4380 -38950 0 0 {name=p3725 lab=_69159_/X }
C {devices/lab_pin.sym} 4540 -38990 0 1 {name=p3726 lab=_83944_/D }
C {sky130_stdcells/a21bo_4.sym} 4460 -38990 0 0 {name=X_69160_ }
C {devices/lab_pin.sym} 4380 -38870 0 0 {name=p3727 lab=_72129_/A }
C {devices/lab_pin.sym} 4380 -38830 0 0 {name=p3728 lab=_47524_/X }
C {devices/lab_pin.sym} 4380 -38790 0 0 {name=p3729 lab=_47537_/Y }
C {devices/lab_pin.sym} 4540 -38830 0 1 {name=p3730 lab=_47538_/Y }
C {sky130_stdcells/o21ai_4.sym} 4460 -38830 0 0 {name=X_47538_ }
C {devices/lab_pin.sym} 4380 -38710 0 0 {name=p3731 lab=_66366_/X }
C {devices/lab_pin.sym} 4380 -38670 0 0 {name=p3732 lab=_64649_/Y }
C {devices/lab_pin.sym} 4380 -38630 0 0 {name=p3733 lab=_66371_/Y }
C {devices/lab_pin.sym} 4540 -38670 0 1 {name=p3734 lab=_66372_/Y }
C {sky130_stdcells/o21ai_4.sym} 4460 -38670 0 0 {name=X_66372_ }
C {devices/lab_pin.sym} 4400 -38540 0 0 {name=p3735 lab=_78358_/A }
C {devices/lab_pin.sym} 4400 -38500 0 0 {name=p3736 lab=_78358_/B }
C {devices/lab_pin.sym} 4520 -38520 0 1 {name=p3737 lab=_78376_/B }
C {sky130_stdcells/nand2_4.sym} 4460 -38520 0 0 {name=X_78358_ }
C {devices/lab_pin.sym} 4420 -38390 0 0 {name=p3738 lab=_63398_/A }
C {devices/lab_pin.sym} 4500 -38390 0 1 {name=p3739 lab=_63657_/A }
C {sky130_stdcells/buf_2.sym} 4460 -38390 0 0 {name=X_63584_ }
C {devices/lab_pin.sym} 4400 -38290 0 0 {name=p3740 lab=_60727_/A }
C {devices/lab_pin.sym} 4400 -38250 0 0 {name=p3741 lab=_60794_/Y }
C {devices/lab_pin.sym} 4400 -38210 0 0 {name=p3742 lab=_60795_/X }
C {devices/lab_pin.sym} 4520 -38250 0 1 {name=p3743 lab=_60796_/Y }
C {sky130_stdcells/nand3_4.sym} 4460 -38250 0 0 {name=X_60796_ }
C {devices/lab_pin.sym} 4380 -38130 0 0 {name=p3744 lab=_66702_/X }
C {devices/lab_pin.sym} 4380 -38090 0 0 {name=p3745 lab=_66705_/X }
C {devices/lab_pin.sym} 4380 -38050 0 0 {name=p3746 lab=_68106_/X }
C {devices/lab_pin.sym} 4540 -38090 0 1 {name=p3747 lab=_68111_/Y }
C {sky130_stdcells/a21oi_4.sym} 4460 -38090 0 0 {name=X_68111_ }
C {devices/lab_pin.sym} 4380 -37970 0 0 {name=p3748 lab=_84206_/Q }
C {devices/lab_pin.sym} 4380 -37930 0 0 {name=p3749 lab=_65296_/X }
C {devices/lab_pin.sym} 4380 -37890 0 0 {name=p3750 lab=_65322_/Y }
C {devices/lab_pin.sym} 4540 -37930 0 1 {name=p3751 lab=_84206_/D }
C {sky130_stdcells/a21o_4.sym} 4460 -37930 0 0 {name=X_65323_ }
C {devices/lab_pin.sym} 4380 -37810 0 0 {name=p3752 lab=_77310_/A }
C {devices/lab_pin.sym} 4380 -37770 0 0 {name=p3753 lab=_77307_/Y }
C {devices/lab_pin.sym} 4380 -37730 0 0 {name=p3754 lab=_77308_/Y }
C {devices/lab_pin.sym} 4540 -37770 0 1 {name=p3755 lab=_77315_/A }
C {sky130_stdcells/o21ai_4.sym} 4460 -37770 0 0 {name=X_77309_ }
C {devices/lab_pin.sym} 4400 -37660 0 0 {name=p3756 lab=_61593_/B }
C {devices/lab_pin.sym} 4400 -37620 0 0 {name=p3757 lab=_62504_/X }
C {devices/lab_pin.sym} 4400 -37580 0 0 {name=p3758 lab=_62534_/X }
C {devices/lab_pin.sym} 4400 -37540 0 0 {name=p3759 lab=_62475_/X }
C {devices/lab_pin.sym} 4520 -37600 0 1 {name=p3760 lab=_62536_/D }
C {sky130_stdcells/nand4_4.sym} 4460 -37600 0 0 {name=X_62535_ }
C {devices/lab_pin.sym} 4380 -37470 0 0 {name=p3761 lab=_69087_/X }
C {devices/lab_pin.sym} 4380 -37430 0 0 {name=p3762 lab=_69090_/X }
C {devices/lab_pin.sym} 4380 -37390 0 0 {name=p3763 lab=_68697_/X }
C {devices/lab_pin.sym} 4540 -37430 0 1 {name=p3764 lab=_69091_/X }
C {sky130_stdcells/a21o_4.sym} 4460 -37430 0 0 {name=X_69091_ }
C {devices/lab_pin.sym} 4420 -37290 0 0 {name=p3765 lab=_47469_/A }
C {devices/lab_pin.sym} 4500 -37290 0 1 {name=p3766 lab=_53067_/B }
C {sky130_stdcells/buf_2.sym} 4460 -37290 0 0 {name=X_47469_ }
C {devices/lab_pin.sym} 4400 -37180 0 0 {name=p3767 lab=_82590_/Q }
C {devices/lab_pin.sym} 4400 -37140 0 0 {name=p3768 lab=_78290_/B }
C {devices/lab_pin.sym} 4520 -37160 0 1 {name=p3769 lab=_78289_/X }
C {sky130_stdcells/or2_4.sym} 4460 -37160 0 0 {name=X_78289_ }
C {devices/lab_pin.sym} 4380 -37050 0 0 {name=p3770 lab=_64580_/B }
C {devices/lab_pin.sym} 4380 -37010 0 0 {name=p3771 lab=_49204_/X }
C {devices/lab_pin.sym} 4380 -36970 0 0 {name=p3772 lab=_49207_/Y }
C {devices/lab_pin.sym} 4540 -37010 0 1 {name=p3773 lab=_49208_/Y }
C {sky130_stdcells/o21ai_4.sym} 4460 -37010 0 0 {name=X_49208_ }
C {devices/lab_pin.sym} 4400 -36880 0 0 {name=p3774 lab=_80320_/A }
C {devices/lab_pin.sym} 4400 -36840 0 0 {name=p3775 lab=_80320_/B }
C {devices/lab_pin.sym} 4520 -36860 0 1 {name=p3776 lab=_80320_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -36860 0 0 {name=X_80320_ }
C {devices/lab_pin.sym} 4400 -36740 0 0 {name=p3777 lab=_68437_/A }
C {devices/lab_pin.sym} 4400 -36700 0 0 {name=p3778 lab=_87701_/Q }
C {devices/lab_pin.sym} 4520 -36720 0 1 {name=p3779 lab=_68042_/X }
C {sky130_stdcells/and2_4.sym} 4460 -36720 0 0 {name=X_68042_ }
C {devices/lab_pin.sym} 4380 -36620 0 0 {name=p3780 lab=_65252_/X }
C {devices/lab_pin.sym} 4380 -36580 0 0 {name=p3781 lab=_83288_/Q }
C {devices/lab_pin.sym} 4380 -36540 0 0 {name=p3782 lab=_65230_/X }
C {devices/lab_pin.sym} 4380 -36500 0 0 {name=p3783 lab=_65253_/X }
C {devices/lab_pin.sym} 4540 -36560 0 1 {name=p3784 lab=_65254_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -36560 0 0 {name=X_65254_ }
C {devices/lab_pin.sym} 4380 -36430 0 0 {name=p3785 lab=_50478_/Y }
C {devices/lab_pin.sym} 4380 -36390 0 0 {name=p3786 lab=_50455_/X }
C {devices/lab_pin.sym} 4380 -36350 0 0 {name=p3787 lab=_50479_/X }
C {devices/lab_pin.sym} 4540 -36390 0 1 {name=p3788 lab=_86193_/D }
C {sky130_stdcells/a21oi_4.sym} 4460 -36390 0 0 {name=X_50480_ }
C {devices/lab_pin.sym} 4380 -36290 0 0 {name=p3789 lab=_62457_/X }
C {devices/lab_pin.sym} 4380 -36250 0 0 {name=p3790 lab=_62461_/Y }
C {devices/lab_pin.sym} 4380 -36210 0 0 {name=p3791 lab=_62465_/X }
C {devices/lab_pin.sym} 4380 -36170 0 0 {name=p3792 lab=_84848_/Q }
C {devices/lab_pin.sym} 4380 -36130 0 0 {name=p3793 lab=_62440_/X }
C {devices/lab_pin.sym} 4540 -36210 0 1 {name=p3794 lab=_62466_/Y }
C {sky130_stdcells/o32ai_4.sym} 4460 -36210 0 0 {name=X_62466_ }
C {devices/lab_pin.sym} 4420 -36050 0 0 {name=p3795 lab=_64267_/A }
C {devices/lab_pin.sym} 4500 -36050 0 1 {name=p3796 lab=_64457_/C }
C {sky130_stdcells/buf_2.sym} 4460 -36050 0 0 {name=X_64205_ }
C {devices/lab_pin.sym} 4400 -35940 0 0 {name=p3797 lab=_49048_/A }
C {devices/lab_pin.sym} 4400 -35900 0 0 {name=p3798 lab=_49139_/B }
C {devices/lab_pin.sym} 4520 -35920 0 1 {name=p3799 lab=_50693_/A }
C {sky130_stdcells/nor2_4.sym} 4460 -35920 0 0 {name=X_49139_ }
C {devices/lab_pin.sym} 4400 -35810 0 0 {name=p3800 lab=_61375_/A }
C {devices/lab_pin.sym} 4400 -35770 0 0 {name=p3801 lab=_61417_/B }
C {devices/lab_pin.sym} 4400 -35730 0 0 {name=p3802 lab=_61398_/C }
C {devices/lab_pin.sym} 4520 -35770 0 1 {name=p3803 lab=_61417_/Y }
C {sky130_stdcells/nand3_4.sym} 4460 -35770 0 0 {name=X_61417_ }
C {devices/lab_pin.sym} 4400 -35640 0 0 {name=p3804 lab=_80251_/A }
C {devices/lab_pin.sym} 4400 -35600 0 0 {name=p3805 lab=_80250_/X }
C {devices/lab_pin.sym} 4520 -35620 0 1 {name=p3806 lab=_80259_/A }
C {sky130_stdcells/nand2_4.sym} 4460 -35620 0 0 {name=X_80251_ }
C {devices/lab_pin.sym} 4380 -35520 0 0 {name=p3807 lab=_65009_/X }
C {devices/lab_pin.sym} 4380 -35480 0 0 {name=p3808 lab=_86155_/Q }
C {devices/lab_pin.sym} 4380 -35440 0 0 {name=p3809 lab=_65182_/X }
C {devices/lab_pin.sym} 4380 -35400 0 0 {name=p3810 lab=_65184_/X }
C {devices/lab_pin.sym} 4540 -35460 0 1 {name=p3811 lab=_65185_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -35460 0 0 {name=X_65185_ }
C {devices/lab_pin.sym} 4400 -35330 0 0 {name=p3812 lab=_62342_/A }
C {devices/lab_pin.sym} 4400 -35290 0 0 {name=p3813 lab=_62341_/X }
C {devices/lab_pin.sym} 4400 -35250 0 0 {name=p3814 lab=_62397_/C }
C {devices/lab_pin.sym} 4520 -35290 0 1 {name=p3815 lab=_62397_/Y }
C {sky130_stdcells/nor3_4.sym} 4460 -35290 0 0 {name=X_62397_ }
C {devices/lab_pin.sym} 4420 -35150 0 0 {name=p3816 lab=clkbuf_7_91_0_CLK/A }
C {devices/lab_pin.sym} 4500 -35150 0 1 {name=p3817 lab=clkbuf_7_90_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 4460 -35150 0 0 {name=Xclkbuf_7_90_0_CLK }
C {devices/lab_pin.sym} 4400 -35050 0 0 {name=p3818 lab=_50447_/A }
C {devices/lab_pin.sym} 4400 -35010 0 0 {name=p3819 lab=_52140_/X }
C {devices/lab_pin.sym} 4400 -34970 0 0 {name=p3820 lab=_52156_/C }
C {devices/lab_pin.sym} 4520 -35010 0 1 {name=p3821 lab=_52150_/X }
C {sky130_stdcells/and3_4.sym} 4460 -35010 0 0 {name=X_52150_ }
C {devices/lab_pin.sym} 4400 -34880 0 0 {name=p3822 lab=_84871_/Q }
C {devices/lab_pin.sym} 4400 -34840 0 0 {name=p3823 lab=_64136_/B }
C {devices/lab_pin.sym} 4520 -34860 0 1 {name=p3824 lab=_64136_/X }
C {sky130_stdcells/or2_4.sym} 4460 -34860 0 0 {name=X_64136_ }
C {devices/lab_pin.sym} 4420 -34730 0 0 {name=p3825 lab=_61348_/A }
C {devices/lab_pin.sym} 4500 -34730 0 1 {name=p3826 lab=_61394_/A }
C {sky130_stdcells/buf_2.sym} 4460 -34730 0 0 {name=X_61348_ }
C {devices/lab_pin.sym} 4400 -34620 0 0 {name=p3827 lab=_80198_/A }
C {devices/lab_pin.sym} 4400 -34580 0 0 {name=p3828 lab=_80189_/A }
C {devices/lab_pin.sym} 4520 -34600 0 1 {name=p3829 lab=_80182_/X }
C {sky130_stdcells/xor2_4.sym} 4460 -34600 0 0 {name=X_80182_ }
C {devices/lab_pin.sym} 4380 -34490 0 0 {name=p3830 lab=_68471_/X }
C {devices/lab_pin.sym} 4380 -34450 0 0 {name=p3831 lab=_68476_/X }
C {devices/lab_pin.sym} 4380 -34410 0 0 {name=p3832 lab=_69992_/X }
C {devices/lab_pin.sym} 4540 -34450 0 1 {name=p3833 lab=_69993_/X }
C {sky130_stdcells/a21o_4.sym} 4460 -34450 0 0 {name=X_69993_ }
C {devices/lab_pin.sym} 4420 -34310 0 0 {name=p3834 lab=_51101_/A }
C {devices/lab_pin.sym} 4500 -34310 0 1 {name=p3835 lab=_51101_/X }
C {sky130_stdcells/buf_2.sym} 4460 -34310 0 0 {name=X_51101_ }
C {devices/lab_pin.sym} 4400 -34200 0 0 {name=p3836 lab=_52121_/A }
C {devices/lab_pin.sym} 4400 -34160 0 0 {name=p3837 lab=_50378_/B }
C {devices/lab_pin.sym} 4520 -34180 0 1 {name=p3838 lab=_52081_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -34180 0 0 {name=X_52081_ }
C {devices/lab_pin.sym} 4400 -34060 0 0 {name=p3839 lab=_69011_/A }
C {devices/lab_pin.sym} 4400 -34020 0 0 {name=p3840 lab=_68944_/B }
C {devices/lab_pin.sym} 4520 -34040 0 1 {name=p3841 lab=_68944_/X }
C {sky130_stdcells/and2_4.sym} 4460 -34040 0 0 {name=X_68944_ }
C {devices/lab_pin.sym} 4420 -33910 0 0 {name=p3842 lab=_64067_/A }
C {devices/lab_pin.sym} 4500 -33910 0 1 {name=p3843 lab=_64161_/B }
C {sky130_stdcells/buf_2.sym} 4460 -33910 0 0 {name=X_64067_ }
C {devices/lab_pin.sym} 4420 -33790 0 0 {name=p3844 lab=_61312_/A }
C {devices/lab_pin.sym} 4500 -33790 0 1 {name=p3845 lab=_72502_/A }
C {sky130_stdcells/inv_2.sym} 4460 -33790 0 0 {name=X_61279_ }
C {devices/lab_pin.sym} 4370 -33670 0 0 {name=p3846 lab=_86558_/CLK }
C {devices/lab_pin.sym} 4370 -33650 0 0 {name=p3847 lab=_57508_/Y }
C {devices/lab_pin.sym} 4550 -33670 0 1 {name=p3848 lab=_84990_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -33660 0 0 {name=X_84990_ }
C {devices/lab_pin.sym} 4380 -33550 0 0 {name=p3849 lab=_86086_/Q }
C {devices/lab_pin.sym} 4380 -33510 0 0 {name=p3850 lab=_51020_/X }
C {devices/lab_pin.sym} 4380 -33470 0 0 {name=p3851 lab=_51031_/Y }
C {devices/lab_pin.sym} 4540 -33510 0 1 {name=p3852 lab=_51032_/Y }
C {sky130_stdcells/o21ai_4.sym} 4460 -33510 0 0 {name=X_51032_ }
C {devices/lab_pin.sym} 4380 -33400 0 0 {name=p3853 lab=_60472_/A }
C {devices/lab_pin.sym} 4380 -33360 0 0 {name=p3854 lab=_60443_/A }
C {devices/lab_pin.sym} 4380 -33320 0 0 {name=p3855 lab=_63001_/A }
C {devices/lab_pin.sym} 4380 -33280 0 0 {name=p3856 lab=_60404_/Y }
C {devices/lab_pin.sym} 4540 -33340 0 1 {name=p3857 lab=_63018_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -33340 0 0 {name=X_63018_ }
C {devices/lab_pin.sym} 4370 -33190 0 0 {name=p3858 lab=_83940_/CLK }
C {devices/lab_pin.sym} 4370 -33170 0 0 {name=p3859 lab=_83941_/D }
C {devices/lab_pin.sym} 4550 -33190 0 1 {name=p3860 lab=_81405_/D }
C {sky130_stdcells/dfxtp_4.sym} 4460 -33180 0 0 {name=X_83941_ }
C {devices/lab_pin.sym} 4420 -33050 0 0 {name=p3861 lab=_68993_/A }
C {devices/lab_pin.sym} 4500 -33050 0 1 {name=p3862 lab=_68875_/X }
C {sky130_stdcells/buf_2.sym} 4460 -33050 0 0 {name=X_68875_ }
C {devices/lab_pin.sym} 4380 -32950 0 0 {name=p3863 lab=_55837_/X }
C {devices/lab_pin.sym} 4380 -32910 0 0 {name=p3864 lab=_55839_/X }
C {devices/lab_pin.sym} 4380 -32870 0 0 {name=p3865 lab=_55516_/X }
C {devices/lab_pin.sym} 4540 -32910 0 1 {name=p3866 lab=_55845_/B }
C {sky130_stdcells/a21o_4.sym} 4460 -32910 0 0 {name=X_55840_ }
C {devices/lab_pin.sym} 4400 -32780 0 0 {name=p3867 lab=_67873_/A }
C {devices/lab_pin.sym} 4400 -32740 0 0 {name=p3868 lab=_67826_/B }
C {devices/lab_pin.sym} 4520 -32760 0 1 {name=p3869 lab=_67826_/X }
C {sky130_stdcells/and2_4.sym} 4460 -32760 0 0 {name=X_67826_ }
C {devices/lab_pin.sym} 4370 -32630 0 0 {name=p3870 lab=_84746_/CLK }
C {devices/lab_pin.sym} 4370 -32610 0 0 {name=p3871 lab=_47203_/Y }
C {devices/lab_pin.sym} 4550 -32630 0 1 {name=p3872 lab=_59361_/A }
C {sky130_stdcells/dfxtp_4.sym} 4460 -32620 0 0 {name=X_86660_ }
C {devices/lab_pin.sym} 4370 -32490 0 0 {name=p3873 lab=_83133_/CLK }
C {devices/lab_pin.sym} 4370 -32470 0 0 {name=p3874 lab=_83872_/D }
C {devices/lab_pin.sym} 4550 -32490 0 1 {name=p3875 lab=_82552_/D }
C {sky130_stdcells/dfxtp_4.sym} 4460 -32480 0 0 {name=X_83872_ }
C {devices/lab_pin.sym} 4370 -32350 0 0 {name=p3876 lab=_85601_/CLK }
C {devices/lab_pin.sym} 4370 -32330 0 0 {name=p3877 lab=_85611_/D }
C {devices/lab_pin.sym} 4550 -32350 0 1 {name=p3878 lab=_85611_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -32340 0 0 {name=X_85611_ }
C {devices/lab_pin.sym} 4370 -32210 0 0 {name=p3879 lab=_82248_/CLK }
C {devices/lab_pin.sym} 4370 -32190 0 0 {name=p3880 lab=_82823_/D }
C {devices/lab_pin.sym} 4550 -32210 0 1 {name=p3881 lab=_82823_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -32200 0 0 {name=X_82823_ }
C {devices/lab_pin.sym} 4400 -32080 0 0 {name=p3882 lab=_55768_/X }
C {devices/lab_pin.sym} 4400 -32040 0 0 {name=p3883 lab=_55771_/B }
C {devices/lab_pin.sym} 4520 -32060 0 1 {name=p3884 lab=_55772_/A }
C {sky130_stdcells/and2_4.sym} 4460 -32060 0 0 {name=X_55771_ }
C {devices/lab_pin.sym} 4380 -31960 0 0 {name=p3885 lab=_86958_/Q }
C {devices/lab_pin.sym} 4380 -31920 0 0 {name=p3886 lab=_67706_/X }
C {devices/lab_pin.sym} 4380 -31880 0 0 {name=p3887 lab=_67755_/X }
C {devices/lab_pin.sym} 4380 -31840 0 0 {name=p3888 lab=_67756_/X }
C {devices/lab_pin.sym} 4540 -31900 0 1 {name=p3889 lab=_67757_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -31900 0 0 {name=X_67757_ }
C {devices/lab_pin.sym} 4370 -31750 0 0 {name=p3890 lab=_86592_/CLK }
C {devices/lab_pin.sym} 4370 -31730 0 0 {name=p3891 lab=_47862_/Y }
C {devices/lab_pin.sym} 4550 -31750 0 1 {name=p3892 lab=_65935_/B }
C {sky130_stdcells/dfxtp_4.sym} 4460 -31740 0 0 {name=X_86591_ }
C {devices/lab_pin.sym} 4380 -31630 0 0 {name=p3893 lab=_52980_/Y }
C {devices/lab_pin.sym} 4380 -31590 0 0 {name=p3894 lab=_52975_/X }
C {devices/lab_pin.sym} 4380 -31550 0 0 {name=p3895 lab=_52982_/X }
C {devices/lab_pin.sym} 4540 -31590 0 1 {name=p3896 lab=_52983_/Y }
C {sky130_stdcells/a21oi_4.sym} 4460 -31590 0 0 {name=X_52983_ }
C {devices/lab_pin.sym} 4400 -31470 0 0 {name=p3897 lab=_65196_/A }
C {devices/lab_pin.sym} 4400 -31430 0 0 {name=p3898 lab=_64913_/B }
C {devices/lab_pin.sym} 4400 -31390 0 0 {name=p3899 lab=_84220_/Q }
C {devices/lab_pin.sym} 4520 -31430 0 1 {name=p3900 lab=_64969_/X }
C {sky130_stdcells/and3_4.sym} 4460 -31430 0 0 {name=X_64969_ }
C {devices/lab_pin.sym} 4380 -31310 0 0 {name=p3901 lab=_84989_/Q }
C {devices/lab_pin.sym} 4380 -31270 0 0 {name=p3902 lab=_57493_/X }
C {devices/lab_pin.sym} 4380 -31230 0 0 {name=p3903 lab=_57509_/Y }
C {devices/lab_pin.sym} 4540 -31270 0 1 {name=p3904 lab=_57510_/Y }
C {sky130_stdcells/o21ai_4.sym} 4460 -31270 0 0 {name=X_57510_ }
C {devices/lab_pin.sym} 4370 -31130 0 0 {name=p3905 lab=_84970_/CLK }
C {devices/lab_pin.sym} 4370 -31110 0 0 {name=p3906 lab=_40811_/X }
C {devices/lab_pin.sym} 4550 -31130 0 1 {name=p3907 lab=_88330_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -31120 0 0 {name=X_88330_ }
C {devices/lab_pin.sym} 4380 -31010 0 0 {name=p3908 lab=_54719_/Y }
C {devices/lab_pin.sym} 4380 -30970 0 0 {name=p3909 lab=_54720_/X }
C {devices/lab_pin.sym} 4380 -30930 0 0 {name=p3910 lab=_54721_/X }
C {devices/lab_pin.sym} 4540 -30970 0 1 {name=p3911 lab=_54722_/Y }
C {sky130_stdcells/a21oi_4.sym} 4460 -30970 0 0 {name=X_54722_ }
C {devices/lab_pin.sym} 4380 -30860 0 0 {name=p3912 lab=_66526_/X }
C {devices/lab_pin.sym} 4380 -30820 0 0 {name=p3913 lab=_66696_/Y }
C {devices/lab_pin.sym} 4380 -30780 0 0 {name=p3914 lab=_66672_/X }
C {devices/lab_pin.sym} 4380 -30740 0 0 {name=p3915 lab=_66707_/Y }
C {devices/lab_pin.sym} 4540 -30800 0 1 {name=p3916 lab=_66708_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -30800 0 0 {name=X_66708_ }
C {devices/lab_pin.sym} 4370 -30650 0 0 {name=p3917 lab=_85542_/CLK }
C {devices/lab_pin.sym} 4370 -30630 0 0 {name=p3918 lab=_53920_/Y }
C {devices/lab_pin.sym} 4550 -30650 0 1 {name=p3919 lab=_85542_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -30640 0 0 {name=X_85542_ }
C {devices/lab_pin.sym} 4420 -30510 0 0 {name=p3920 lab=_51934_/A }
C {devices/lab_pin.sym} 4500 -30510 0 1 {name=p3921 lab=_51934_/X }
C {sky130_stdcells/buf_2.sym} 4460 -30510 0 0 {name=X_51934_ }
C {devices/lab_pin.sym} 4370 -30390 0 0 {name=p3922 lab=_82965_/CLK }
C {devices/lab_pin.sym} 4370 -30370 0 0 {name=p3923 lab=_82754_/D }
C {devices/lab_pin.sym} 4550 -30390 0 1 {name=p3924 lab=_82946_/D }
C {sky130_stdcells/dfxtp_4.sym} 4460 -30380 0 0 {name=X_82754_ }
C {devices/lab_pin.sym} 4400 -30260 0 0 {name=p3925 lab=_58490_/A }
C {devices/lab_pin.sym} 4400 -30220 0 0 {name=p3926 lab=_58498_/B }
C {devices/lab_pin.sym} 4520 -30240 0 1 {name=p3927 lab=_58490_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -30240 0 0 {name=X_58490_ }
C {devices/lab_pin.sym} 4420 -30110 0 0 {name=p3928 lab=_67806_/A }
C {devices/lab_pin.sym} 4500 -30110 0 1 {name=p3929 lab=_67688_/X }
C {sky130_stdcells/buf_2.sym} 4460 -30110 0 0 {name=X_67688_ }
C {devices/lab_pin.sym} 4370 -29990 0 0 {name=p3930 lab=_81703_/CLK }
C {devices/lab_pin.sym} 4370 -29970 0 0 {name=p3931 lab=_75976_/A }
C {devices/lab_pin.sym} 4550 -29990 0 1 {name=p3932 lab=_41068_/B }
C {sky130_stdcells/dfxtp_4.sym} 4460 -29980 0 0 {name=X_81705_ }
C {devices/lab_pin.sym} 4420 -29850 0 0 {name=p3933 lab=_58425_/A }
C {devices/lab_pin.sym} 4500 -29850 0 1 {name=p3934 lab=_57441_/X }
C {sky130_stdcells/buf_2.sym} 4460 -29850 0 0 {name=X_57441_ }
C {devices/lab_pin.sym} 4400 -29740 0 0 {name=p3935 lab=_69305_/A }
C {devices/lab_pin.sym} 4400 -29700 0 0 {name=p3936 lab=_69427_/B }
C {devices/lab_pin.sym} 4520 -29720 0 1 {name=p3937 lab=_69427_/X }
C {sky130_stdcells/and2_4.sym} 4460 -29720 0 0 {name=X_69427_ }
C {devices/lab_pin.sym} 4370 -29590 0 0 {name=p3938 lab=_87103_/CLK }
C {devices/lab_pin.sym} 4370 -29570 0 0 {name=p3939 lab=_88261_/D }
C {devices/lab_pin.sym} 4550 -29590 0 1 {name=p3940 lab=_68723_/B }
C {sky130_stdcells/dfxtp_4.sym} 4460 -29580 0 0 {name=X_88261_ }
C {devices/lab_pin.sym} 4380 -29470 0 0 {name=p3941 lab=_54651_/Y }
C {devices/lab_pin.sym} 4380 -29430 0 0 {name=p3942 lab=_54638_/X }
C {devices/lab_pin.sym} 4380 -29390 0 0 {name=p3943 lab=_54652_/X }
C {devices/lab_pin.sym} 4540 -29430 0 1 {name=p3944 lab=_54653_/Y }
C {sky130_stdcells/a21oi_4.sym} 4460 -29430 0 0 {name=X_54653_ }
C {devices/lab_pin.sym} 4420 -29290 0 0 {name=p3945 lab=_69315_/A }
C {devices/lab_pin.sym} 4500 -29290 0 1 {name=p3946 lab=_66639_/X }
C {sky130_stdcells/buf_2.sym} 4460 -29290 0 0 {name=X_66639_ }
C {devices/lab_pin.sym} 4370 -29170 0 0 {name=p3947 lab=_85471_/CLK }
C {devices/lab_pin.sym} 4370 -29150 0 0 {name=p3948 lab=_54271_/Y }
C {devices/lab_pin.sym} 4550 -29170 0 1 {name=p3949 lab=_85473_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -29160 0 0 {name=X_85473_ }
C {devices/lab_pin.sym} 4400 -29060 0 0 {name=p3950 lab=_51870_/A }
C {devices/lab_pin.sym} 4400 -29020 0 0 {name=p3951 lab=_51851_/B }
C {devices/lab_pin.sym} 4400 -28980 0 0 {name=p3952 lab=_51870_/C }
C {devices/lab_pin.sym} 4400 -28940 0 0 {name=p3953 lab=_52694_/D }
C {devices/lab_pin.sym} 4520 -29000 0 1 {name=p3954 lab=_51865_/X }
C {sky130_stdcells/and4_4.sym} 4460 -29000 0 0 {name=X_51865_ }
C {devices/lab_pin.sym} 4370 -28850 0 0 {name=p3955 lab=_82933_/CLK }
C {devices/lab_pin.sym} 4370 -28830 0 0 {name=p3956 lab=_82685_/D }
C {devices/lab_pin.sym} 4550 -28850 0 1 {name=p3957 lab=_78278_/A }
C {sky130_stdcells/dfxtp_4.sym} 4460 -28840 0 0 {name=X_82685_ }
C {devices/lab_pin.sym} 4370 -28710 0 0 {name=p3958 lab=_87446_/CLK }
C {devices/lab_pin.sym} 4370 -28690 0 0 {name=p3959 lab=_87212_/D }
C {devices/lab_pin.sym} 4550 -28710 0 1 {name=p3960 lab=_87212_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -28700 0 0 {name=X_87212_ }
C {devices/lab_pin.sym} 4400 -28580 0 0 {name=p3961 lab=_53604_/A }
C {devices/lab_pin.sym} 4400 -28540 0 0 {name=p3962 lab=_50381_/B }
C {devices/lab_pin.sym} 4520 -28560 0 1 {name=p3963 lab=_53604_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -28560 0 0 {name=X_53604_ }
C {devices/lab_pin.sym} 4370 -28430 0 0 {name=p3964 lab=_84424_/CLK }
C {devices/lab_pin.sym} 4370 -28410 0 0 {name=p3965 lab=_84424_/D }
C {devices/lab_pin.sym} 4550 -28430 0 1 {name=p3966 lab=_84424_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -28420 0 0 {name=X_84424_ }
C {devices/lab_pin.sym} 4400 -28300 0 0 {name=p3967 lab=_50787_/X }
C {devices/lab_pin.sym} 4400 -28260 0 0 {name=p3968 lab=_50816_/B }
C {devices/lab_pin.sym} 4520 -28280 0 1 {name=p3969 lab=_50816_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -28280 0 0 {name=X_50816_ }
C {devices/lab_pin.sym} 4420 -28150 0 0 {name=p3970 lab=_57440_/A }
C {devices/lab_pin.sym} 4500 -28150 0 1 {name=p3971 lab=_57372_/X }
C {sky130_stdcells/buf_2.sym} 4460 -28150 0 0 {name=X_57372_ }
C {devices/lab_pin.sym} 4370 -28030 0 0 {name=p3972 lab=_81684_/CLK }
C {devices/lab_pin.sym} 4370 -28010 0 0 {name=p3973 lab=_81668_/Q }
C {devices/lab_pin.sym} 4550 -28030 0 1 {name=p3974 lab=_76176_/A }
C {sky130_stdcells/dfxtp_4.sym} 4460 -28020 0 0 {name=X_81636_ }
C {devices/lab_pin.sym} 4400 -27900 0 0 {name=p3975 lab=_69383_/A }
C {devices/lab_pin.sym} 4400 -27860 0 0 {name=p3976 lab=_69358_/B }
C {devices/lab_pin.sym} 4520 -27880 0 1 {name=p3977 lab=_69358_/X }
C {sky130_stdcells/and2_4.sym} 4460 -27880 0 0 {name=X_69358_ }
C {devices/lab_pin.sym} 4370 -27750 0 0 {name=p3978 lab=_87116_/CLK }
C {devices/lab_pin.sym} 4370 -27730 0 0 {name=p3979 lab=_88192_/D }
C {devices/lab_pin.sym} 4550 -27750 0 1 {name=p3980 lab=_67041_/B }
C {sky130_stdcells/dfxtp_4.sym} 4460 -27740 0 0 {name=X_88192_ }
C {devices/lab_pin.sym} 4420 -27610 0 0 {name=p3981 lab=_54558_/A }
C {devices/lab_pin.sym} 4500 -27610 0 1 {name=p3982 lab=_54584_/X }
C {sky130_stdcells/buf_2.sym} 4460 -27610 0 0 {name=X_54584_ }
C {devices/lab_pin.sym} 4400 -27500 0 0 {name=p3983 lab=_51796_/A }
C {devices/lab_pin.sym} 4400 -27460 0 0 {name=p3984 lab=_46701_/X }
C {devices/lab_pin.sym} 4520 -27480 0 1 {name=p3985 lab=_51796_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -27480 0 0 {name=X_51796_ }
C {devices/lab_pin.sym} 4420 -27350 0 0 {name=p3986 lab=clkbuf_7_42_0_CLK/A }
C {devices/lab_pin.sym} 4500 -27350 0 1 {name=p3987 lab=clkbuf_8_87_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 4460 -27350 0 0 {name=Xclkbuf_7_43_0_CLK }
C {devices/lab_pin.sym} 4420 -27230 0 0 {name=p3988 lab=_58721_/A }
C {devices/lab_pin.sym} 4500 -27230 0 1 {name=p3989 lab=_59189_/B }
C {sky130_stdcells/buf_2.sym} 4460 -27230 0 0 {name=X_59111_ }
C {devices/lab_pin.sym} 4380 -27130 0 0 {name=p3990 lab=_67893_/X }
C {devices/lab_pin.sym} 4380 -27090 0 0 {name=p3991 lab=_67896_/X }
C {devices/lab_pin.sym} 4380 -27050 0 0 {name=p3992 lab=_68283_/X }
C {devices/lab_pin.sym} 4540 -27090 0 1 {name=p3993 lab=_68309_/Y }
C {sky130_stdcells/a21oi_4.sym} 4460 -27090 0 0 {name=X_68309_ }
C {devices/lab_pin.sym} 4400 -26970 0 0 {name=p3994 lab=_56332_/A }
C {devices/lab_pin.sym} 4400 -26930 0 0 {name=p3995 lab=_56312_/X }
C {devices/lab_pin.sym} 4400 -26890 0 0 {name=p3996 lab=_55865_/B }
C {devices/lab_pin.sym} 4520 -26930 0 1 {name=p3997 lab=_56323_/Y }
C {sky130_stdcells/nand3_4.sym} 4460 -26930 0 0 {name=X_56323_ }
C {devices/lab_pin.sym} 4370 -26790 0 0 {name=p3998 lab=_88220_/CLK }
C {devices/lab_pin.sym} 4370 -26770 0 0 {name=p3999 lab=_87143_/D }
C {devices/lab_pin.sym} 4550 -26790 0 1 {name=p4000 lab=_87143_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -26780 0 0 {name=X_87143_ }
C {devices/lab_pin.sym} 4400 -26660 0 0 {name=p4001 lab=_53468_/A }
C {devices/lab_pin.sym} 4400 -26620 0 0 {name=p4002 lab=_53535_/B }
C {devices/lab_pin.sym} 4520 -26640 0 1 {name=p4003 lab=_53535_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -26640 0 0 {name=X_53535_ }
C {devices/lab_pin.sym} 4370 -26510 0 0 {name=p4004 lab=_84355_/CLK }
C {devices/lab_pin.sym} 4370 -26490 0 0 {name=p4005 lab=_84355_/D }
C {devices/lab_pin.sym} 4550 -26510 0 1 {name=p4006 lab=_79447_/A }
C {sky130_stdcells/dfxtp_4.sym} 4460 -26500 0 0 {name=X_84355_ }
C {devices/lab_pin.sym} 4420 -26370 0 0 {name=p4007 lab=clkbuf_7_91_0_CLK/X }
C {devices/lab_pin.sym} 4500 -26370 0 1 {name=p4008 lab=clkbuf_9_367_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 4460 -26370 0 0 {name=Xclkbuf_8_183_0_CLK }
C {devices/lab_pin.sym} 4380 -26270 0 0 {name=p4009 lab=_50745_/Y }
C {devices/lab_pin.sym} 4380 -26230 0 0 {name=p4010 lab=_50735_/X }
C {devices/lab_pin.sym} 4380 -26190 0 0 {name=p4011 lab=_50746_/Y }
C {devices/lab_pin.sym} 4540 -26230 0 1 {name=p4012 lab=_86142_/D }
C {sky130_stdcells/a21boi_4.sym} 4460 -26230 0 0 {name=X_50747_ }
C {devices/lab_pin.sym} 4370 -26090 0 0 {name=p4013 lab=_83926_/CLK }
C {devices/lab_pin.sym} 4370 -26070 0 0 {name=p4014 lab=_81567_/D }
C {devices/lab_pin.sym} 4550 -26090 0 1 {name=p4015 lab=_81567_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -26080 0 0 {name=X_81567_ }
C {devices/lab_pin.sym} 4380 -25980 0 0 {name=p4016 lab=_87528_/Q }
C {devices/lab_pin.sym} 4380 -25940 0 0 {name=p4017 lab=_69261_/X }
C {devices/lab_pin.sym} 4380 -25900 0 0 {name=p4018 lab=_69248_/X }
C {devices/lab_pin.sym} 4380 -25860 0 0 {name=p4019 lab=_69288_/X }
C {devices/lab_pin.sym} 4540 -25920 0 1 {name=p4020 lab=_69289_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -25920 0 0 {name=X_69289_ }
C {devices/lab_pin.sym} 4380 -25790 0 0 {name=p4021 lab=_40456_/X }
C {devices/lab_pin.sym} 4380 -25750 0 0 {name=p4022 lab=_41572_/A }
C {devices/lab_pin.sym} 4380 -25710 0 0 {name=p4023 lab=_40499_/X }
C {devices/lab_pin.sym} 4540 -25750 0 1 {name=p4024 lab=_40500_/X }
C {sky130_stdcells/o21a_4.sym} 4460 -25750 0 0 {name=X_40500_ }
C {devices/lab_pin.sym} 4420 -25610 0 0 {name=p4025 lab=_71320_/A }
C {devices/lab_pin.sym} 4500 -25610 0 1 {name=p4026 lab=_71320_/X }
C {sky130_stdcells/buf_2.sym} 4460 -25610 0 0 {name=X_71320_ }
C {devices/lab_pin.sym} 4420 -25490 0 0 {name=p4027 lab=_58094_/A }
C {devices/lab_pin.sym} 4500 -25490 0 1 {name=p4028 lab=_59043_/A }
C {sky130_stdcells/buf_2.sym} 4460 -25490 0 0 {name=X_59042_ }
C {devices/lab_pin.sym} 4370 -25370 0 0 {name=p4029 lab=_83306_/CLK }
C {devices/lab_pin.sym} 4370 -25350 0 0 {name=p4030 lab=_71995_/Y }
C {devices/lab_pin.sym} 4550 -25370 0 1 {name=p4031 lab=_83306_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -25360 0 0 {name=X_83306_ }
C {devices/lab_pin.sym} 4380 -25250 0 0 {name=p4032 lab=_56134_/X }
C {devices/lab_pin.sym} 4380 -25210 0 0 {name=p4033 lab=_56242_/X }
C {devices/lab_pin.sym} 4380 -25170 0 0 {name=p4034 lab=_56253_/Y }
C {devices/lab_pin.sym} 4540 -25210 0 1 {name=p4035 lab=_56254_/Y }
C {sky130_stdcells/o21ai_4.sym} 4460 -25210 0 0 {name=X_56254_ }
C {devices/lab_pin.sym} 4400 -25080 0 0 {name=p4036 lab=_80518_/A }
C {devices/lab_pin.sym} 4400 -25040 0 0 {name=p4037 lab=_80518_/B }
C {devices/lab_pin.sym} 4520 -25060 0 1 {name=p4038 lab=_80531_/B }
C {sky130_stdcells/xnor2_4.sym} 4460 -25060 0 0 {name=X_80518_ }
C {devices/lab_pin.sym} 4380 -24960 0 0 {name=p4039 lab=_41479_/X }
C {devices/lab_pin.sym} 4380 -24920 0 0 {name=p4040 lab=_41455_/X }
C {devices/lab_pin.sym} 4380 -24880 0 0 {name=p4041 lab=_88207_/Q }
C {devices/lab_pin.sym} 4380 -24840 0 0 {name=p4042 lab=_41457_/X }
C {devices/lab_pin.sym} 4540 -24900 0 1 {name=p4043 lab=_41480_/X }
C {sky130_stdcells/a2bb2o_4.sym} 4460 -24900 0 0 {name=X_41480_ }
C {devices/lab_pin.sym} 4370 -24750 0 0 {name=p4044 lab=_87077_/CLK }
C {devices/lab_pin.sym} 4370 -24730 0 0 {name=p4045 lab=_87074_/D }
C {devices/lab_pin.sym} 4550 -24750 0 1 {name=p4046 lab=_87074_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -24740 0 0 {name=X_87074_ }
C {devices/lab_pin.sym} 4420 -24610 0 0 {name=p4047 lab=_53687_/A }
C {devices/lab_pin.sym} 4500 -24610 0 1 {name=p4048 lab=_53466_/X }
C {sky130_stdcells/buf_2.sym} 4460 -24610 0 0 {name=X_53466_ }
C {devices/lab_pin.sym} 4370 -24490 0 0 {name=p4049 lab=_84668_/CLK }
C {devices/lab_pin.sym} 4370 -24470 0 0 {name=p4050 lab=_84286_/D }
C {devices/lab_pin.sym} 4550 -24490 0 1 {name=p4051 lab=_80133_/B }
C {sky130_stdcells/dfxtp_4.sym} 4460 -24480 0 0 {name=X_84286_ }
C {devices/lab_pin.sym} 4380 -24370 0 0 {name=p4052 lab=_50675_/Y }
C {devices/lab_pin.sym} 4380 -24330 0 0 {name=p4053 lab=_50676_/X }
C {devices/lab_pin.sym} 4380 -24290 0 0 {name=p4054 lab=_50677_/X }
C {devices/lab_pin.sym} 4540 -24330 0 1 {name=p4055 lab=_86155_/D }
C {sky130_stdcells/a21oi_4.sym} 4460 -24330 0 0 {name=X_50678_ }
C {devices/lab_pin.sym} 4370 -24190 0 0 {name=p4056 lab=_81749_/CLK }
C {devices/lab_pin.sym} 4370 -24170 0 0 {name=p4057 lab=_81498_/D }
C {devices/lab_pin.sym} 4550 -24190 0 1 {name=p4058 lab=_81498_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -24180 0 0 {name=X_81498_ }
C {devices/lab_pin.sym} 4380 -24080 0 0 {name=p4059 lab=_85029_/Q }
C {devices/lab_pin.sym} 4380 -24040 0 0 {name=p4060 lab=_55157_/X }
C {devices/lab_pin.sym} 4380 -24000 0 0 {name=p4061 lab=_55168_/X }
C {devices/lab_pin.sym} 4380 -23960 0 0 {name=p4062 lab=_55204_/Y }
C {devices/lab_pin.sym} 4540 -24020 0 1 {name=p4063 lab=_55205_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -24020 0 0 {name=X_55205_ }
C {devices/lab_pin.sym} 4370 -23870 0 0 {name=p4064 lab=_86122_/CLK }
C {devices/lab_pin.sym} 4370 -23850 0 0 {name=p4065 lab=_86025_/D }
C {devices/lab_pin.sym} 4550 -23870 0 1 {name=p4066 lab=_86025_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -23860 0 0 {name=X_86025_ }
C {devices/lab_pin.sym} 4380 -23750 0 0 {name=p4067 lab=_52414_/Y }
C {devices/lab_pin.sym} 4380 -23710 0 0 {name=p4068 lab=_52415_/X }
C {devices/lab_pin.sym} 4380 -23670 0 0 {name=p4069 lab=_52416_/X }
C {devices/lab_pin.sym} 4540 -23710 0 1 {name=p4070 lab=_85827_/D }
C {sky130_stdcells/a21oi_4.sym} 4460 -23710 0 0 {name=X_52417_ }
C {devices/lab_pin.sym} 4380 -23590 0 0 {name=p4071 lab=_40429_/X }
C {devices/lab_pin.sym} 4380 -23550 0 0 {name=p4072 lab=_82326_/Q }
C {devices/lab_pin.sym} 4380 -23510 0 0 {name=p4073 lab=_40430_/X }
C {devices/lab_pin.sym} 4540 -23550 0 1 {name=p4074 lab=_40431_/X }
C {sky130_stdcells/o21a_4.sym} 4460 -23550 0 0 {name=X_40431_ }
C {devices/lab_pin.sym} 4380 -23430 0 0 {name=p4075 lab=_51947_/B }
C {devices/lab_pin.sym} 4380 -23390 0 0 {name=p4076 lab=_71239_/X }
C {devices/lab_pin.sym} 4380 -23350 0 0 {name=p4077 lab=_71250_/Y }
C {devices/lab_pin.sym} 4540 -23390 0 1 {name=p4078 lab=_83558_/D }
C {sky130_stdcells/o21ai_4.sym} 4460 -23390 0 0 {name=X_71251_ }
C {devices/lab_pin.sym} 4370 -23250 0 0 {name=p4079 lab=_84350_/CLK }
C {devices/lab_pin.sym} 4370 -23230 0 0 {name=p4080 lab=_83237_/D }
C {devices/lab_pin.sym} 4550 -23250 0 1 {name=p4081 lab=_79467_/B }
C {sky130_stdcells/dfxtp_4.sym} 4460 -23240 0 0 {name=X_83237_ }
C {devices/lab_pin.sym} 4380 -23130 0 0 {name=p4082 lab=_80436_/X }
C {devices/lab_pin.sym} 4380 -23090 0 0 {name=p4083 lab=_80447_/X }
C {devices/lab_pin.sym} 4380 -23050 0 0 {name=p4084 lab=_80448_/X }
C {devices/lab_pin.sym} 4540 -23090 0 1 {name=p4085 lab=_80449_/Y }
C {sky130_stdcells/a21oi_4.sym} 4460 -23090 0 0 {name=X_80449_ }
C {devices/lab_pin.sym} 4420 -22950 0 0 {name=p4086 lab=_55684_/X }
C {devices/lab_pin.sym} 4500 -22950 0 1 {name=p4087 lab=_56460_/D }
C {sky130_stdcells/buf_2.sym} 4460 -22950 0 0 {name=X_56185_ }
C {devices/lab_pin.sym} 4420 -22830 0 0 {name=p4088 lab=clkbuf_7_58_0_CLK/A }
C {devices/lab_pin.sym} 4500 -22830 0 1 {name=p4089 lab=clkbuf_7_58_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 4460 -22830 0 0 {name=Xclkbuf_7_58_0_CLK }
C {devices/lab_pin.sym} 4400 -22740 0 0 {name=p4090 lab=_53397_/A }
C {devices/lab_pin.sym} 4400 -22700 0 0 {name=p4091 lab=_53388_/B }
C {devices/lab_pin.sym} 4400 -22660 0 0 {name=p4092 lab=_53388_/C }
C {devices/lab_pin.sym} 4400 -22620 0 0 {name=p4093 lab=_51192_/D }
C {devices/lab_pin.sym} 4520 -22680 0 1 {name=p4094 lab=_53397_/X }
C {sky130_stdcells/and4_4.sym} 4460 -22680 0 0 {name=X_53397_ }
C {devices/lab_pin.sym} 4420 -22530 0 0 {name=p4095 lab=_70231_/A }
C {devices/lab_pin.sym} 4500 -22530 0 1 {name=p4096 lab=_70214_/A }
C {sky130_stdcells/buf_2.sym} 4460 -22530 0 0 {name=X_70202_ }
C {devices/lab_pin.sym} 4380 -22450 0 0 {name=p4097 lab=_43146_/X }
C {devices/lab_pin.sym} 4380 -22410 0 0 {name=p4098 lab=_43149_/X }
C {devices/lab_pin.sym} 4380 -22370 0 0 {name=p4099 lab=_40839_/X }
C {devices/lab_pin.sym} 4380 -22330 0 0 {name=p4100 lab=_73126_/A }
C {devices/lab_pin.sym} 4380 -22290 0 0 {name=p4101 lab=_43121_/X }
C {devices/lab_pin.sym} 4540 -22370 0 1 {name=p4102 lab=_43151_/A }
C {sky130_stdcells/o32ai_4.sym} 4460 -22370 0 0 {name=X_43150_ }
C {devices/lab_pin.sym} 4420 -22210 0 0 {name=p4103 lab=clkbuf_7_99_0_CLK/X }
C {devices/lab_pin.sym} 4500 -22210 0 1 {name=p4104 lab=clkbuf_8_198_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 4460 -22210 0 0 {name=Xclkbuf_8_198_0_CLK }
C {devices/lab_pin.sym} 4380 -22120 0 0 {name=p4105 lab=_57027_/A }
C {devices/lab_pin.sym} 4380 -22080 0 0 {name=p4106 lab=_55126_/X }
C {devices/lab_pin.sym} 4380 -22040 0 0 {name=p4107 lab=_55134_/X }
C {devices/lab_pin.sym} 4380 -22000 0 0 {name=p4108 lab=_55135_/X }
C {devices/lab_pin.sym} 4540 -22060 0 1 {name=p4109 lab=_55136_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -22060 0 0 {name=X_55136_ }
C {devices/lab_pin.sym} 4420 -21910 0 0 {name=p4110 lab=_42081_/A }
C {devices/lab_pin.sym} 4500 -21910 0 1 {name=p4111 lab=_40362_/X }
C {sky130_stdcells/buf_2.sym} 4460 -21910 0 0 {name=X_40362_ }
C {devices/lab_pin.sym} 4420 -21790 0 0 {name=p4112 lab=_52271_/A }
C {devices/lab_pin.sym} 4500 -21790 0 1 {name=p4113 lab=_52349_/A }
C {sky130_stdcells/buf_2.sym} 4460 -21790 0 0 {name=X_52348_ }
C {devices/lab_pin.sym} 4420 -21670 0 0 {name=p4114 lab=clkbuf_9_96_0_CLK/X }
C {devices/lab_pin.sym} 4500 -21670 0 1 {name=p4115 lab=_84280_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 4460 -21670 0 0 {name=Xclkbuf_10_193_0_CLK }
C {devices/lab_pin.sym} 4380 -21570 0 0 {name=p4116 lab=_52163_/B }
C {devices/lab_pin.sym} 4380 -21530 0 0 {name=p4117 lab=_71164_/Y }
C {devices/lab_pin.sym} 4380 -21490 0 0 {name=p4118 lab=_71181_/Y }
C {devices/lab_pin.sym} 4540 -21530 0 1 {name=p4119 lab=_71182_/Y }
C {sky130_stdcells/o21ai_4.sym} 4460 -21530 0 0 {name=X_71182_ }
C {devices/lab_pin.sym} 4370 -21390 0 0 {name=p4120 lab=_83167_/CLK }
C {devices/lab_pin.sym} 4370 -21370 0 0 {name=p4121 lab=_73023_/X }
C {devices/lab_pin.sym} 4550 -21390 0 1 {name=p4122 lab=_83168_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -21380 0 0 {name=X_83168_ }
C {devices/lab_pin.sym} 4420 -21250 0 0 {name=p4123 lab=_42101_/A }
C {devices/lab_pin.sym} 4500 -21250 0 1 {name=p4124 lab=_42101_/Y }
C {sky130_stdcells/inv_2.sym} 4460 -21250 0 0 {name=X_42101_ }
C {devices/lab_pin.sym} 4420 -21130 0 0 {name=p4125 lab=_70133_/A }
C {devices/lab_pin.sym} 4500 -21130 0 1 {name=p4126 lab=_70134_/C }
C {sky130_stdcells/inv_2.sym} 4460 -21130 0 0 {name=X_70133_ }
C {devices/lab_pin.sym} 4370 -21010 0 0 {name=p4127 lab=_82145_/CLK }
C {devices/lab_pin.sym} 4370 -20990 0 0 {name=p4128 lab=_82119_/D }
C {devices/lab_pin.sym} 4550 -21010 0 1 {name=p4129 lab=_82107_/D }
C {sky130_stdcells/dfxtp_4.sym} 4460 -21000 0 0 {name=X_82119_ }
C {devices/lab_pin.sym} 4380 -20910 0 0 {name=p4130 lab=_43072_/X }
C {devices/lab_pin.sym} 4380 -20870 0 0 {name=p4131 lab=_43075_/X }
C {devices/lab_pin.sym} 4380 -20830 0 0 {name=p4132 lab=_40702_/X }
C {devices/lab_pin.sym} 4380 -20790 0 0 {name=p4133 lab=_74033_/A }
C {devices/lab_pin.sym} 4380 -20750 0 0 {name=p4134 lab=_43080_/X }
C {devices/lab_pin.sym} 4540 -20830 0 1 {name=p4135 lab=_43081_/Y }
C {sky130_stdcells/o32ai_4.sym} 4460 -20830 0 0 {name=X_43081_ }
C {devices/lab_pin.sym} 4400 -20680 0 0 {name=p4136 lab=_55054_/A }
C {devices/lab_pin.sym} 4400 -20640 0 0 {name=p4137 lab=_54903_/B }
C {devices/lab_pin.sym} 4520 -20660 0 1 {name=p4138 lab=_55067_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -20660 0 0 {name=X_55067_ }
C {devices/lab_pin.sym} 4420 -20530 0 0 {name=p4139 lab=_59943_/X }
C {devices/lab_pin.sym} 4500 -20530 0 1 {name=p4140 lab=_62532_/A }
C {sky130_stdcells/buf_2.sym} 4460 -20530 0 0 {name=X_59944_ }
C {devices/lab_pin.sym} 4420 -20410 0 0 {name=p4141 lab=_52274_/A }
C {devices/lab_pin.sym} 4500 -20410 0 1 {name=p4142 lab=_52319_/A }
C {sky130_stdcells/buf_2.sym} 4460 -20410 0 0 {name=X_52279_ }
C {devices/lab_pin.sym} 4400 -20300 0 0 {name=p4143 lab=_75980_/Y }
C {devices/lab_pin.sym} 4400 -20260 0 0 {name=p4144 lab=_75990_/B }
C {devices/lab_pin.sym} 4520 -20280 0 1 {name=p4145 lab=_75990_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -20280 0 0 {name=X_75990_ }
C {devices/lab_pin.sym} 4370 -20150 0 0 {name=p4146 lab=_88158_/CLK }
C {devices/lab_pin.sym} 4370 -20130 0 0 {name=p4147 lab=_42217_/Y }
C {devices/lab_pin.sym} 4550 -20150 0 1 {name=p4148 lab=_87976_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -20140 0 0 {name=X_87976_ }
C {devices/lab_pin.sym} 4370 -20010 0 0 {name=p4149 lab=_83095_/CLK }
C {devices/lab_pin.sym} 4370 -19990 0 0 {name=p4150 lab=_83099_/D }
C {devices/lab_pin.sym} 4550 -20010 0 1 {name=p4151 lab=_70306_/C }
C {sky130_stdcells/dfxtp_4.sym} 4460 -20000 0 0 {name=X_83099_ }
C {devices/lab_pin.sym} 4420 -19870 0 0 {name=p4152 lab=_53921_/A }
C {devices/lab_pin.sym} 4500 -19870 0 1 {name=p4153 lab=_54018_/X }
C {sky130_stdcells/buf_2.sym} 4460 -19870 0 0 {name=X_54018_ }
C {devices/lab_pin.sym} 4420 -19750 0 0 {name=p4154 lab=_42031_/Y }
C {devices/lab_pin.sym} 4500 -19750 0 1 {name=p4155 lab=_88064_/D }
C {sky130_stdcells/inv_2.sym} 4460 -19750 0 0 {name=X_42032_ }
C {devices/lab_pin.sym} 4400 -19640 0 0 {name=p4156 lab=_81136_/D }
C {devices/lab_pin.sym} 4400 -19600 0 0 {name=p4157 lab=_74960_/C }
C {devices/lab_pin.sym} 4520 -19620 0 1 {name=p4158 lab=_74958_/A }
C {sky130_stdcells/xor2_4.sym} 4460 -19620 0 0 {name=X_74941_ }
C {devices/lab_pin.sym} 4380 -19510 0 0 {name=p4159 lab=_69864_/X }
C {devices/lab_pin.sym} 4380 -19470 0 0 {name=p4160 lab=_69866_/X }
C {devices/lab_pin.sym} 4380 -19430 0 0 {name=p4161 lab=_69994_/X }
C {devices/lab_pin.sym} 4540 -19470 0 1 {name=p4162 lab=_70064_/X }
C {sky130_stdcells/a21o_4.sym} 4460 -19470 0 0 {name=X_70064_ }
C {devices/lab_pin.sym} 4370 -19330 0 0 {name=p4163 lab=_87652_/CLK }
C {devices/lab_pin.sym} 4370 -19310 0 0 {name=p4164 lab=_44840_/X }
C {devices/lab_pin.sym} 4550 -19330 0 1 {name=p4165 lab=_67719_/B }
C {sky130_stdcells/dfxtp_4.sym} 4460 -19320 0 0 {name=X_86927_ }
C {devices/lab_pin.sym} 4420 -19190 0 0 {name=p4166 lab=clkbuf_7_60_0_CLK/X }
C {devices/lab_pin.sym} 4500 -19190 0 1 {name=p4167 lab=clkbuf_9_243_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 4460 -19190 0 0 {name=Xclkbuf_8_121_0_CLK }
C {devices/lab_pin.sym} 4420 -19070 0 0 {name=p4168 lab=_59875_/A }
C {devices/lab_pin.sym} 4500 -19070 0 1 {name=p4169 lab=_59875_/X }
C {sky130_stdcells/buf_2.sym} 4460 -19070 0 0 {name=X_59875_ }
C {devices/lab_pin.sym} 4420 -18950 0 0 {name=p4170 lab=_46840_/A }
C {devices/lab_pin.sym} 4500 -18950 0 1 {name=p4171 lab=_52706_/B }
C {sky130_stdcells/inv_2.sym} 4460 -18950 0 0 {name=X_46840_ }
C {devices/lab_pin.sym} 4380 -18860 0 0 {name=p4172 lab=_84797_/Q }
C {devices/lab_pin.sym} 4380 -18820 0 0 {name=p4173 lab=_58725_/X }
C {devices/lab_pin.sym} 4380 -18780 0 0 {name=p4174 lab=_58820_/X }
C {devices/lab_pin.sym} 4380 -18740 0 0 {name=p4175 lab=_58825_/X }
C {devices/lab_pin.sym} 4540 -18800 0 1 {name=p4176 lab=_84797_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 4460 -18800 0 0 {name=X_58826_ }
C {devices/lab_pin.sym} 4400 -18670 0 0 {name=p4177 lab=_77660_/A }
C {devices/lab_pin.sym} 4400 -18630 0 0 {name=p4178 lab=_77658_/Y }
C {devices/lab_pin.sym} 4400 -18590 0 0 {name=p4179 lab=_77656_/Y }
C {devices/lab_pin.sym} 4520 -18630 0 1 {name=p4180 lab=_77693_/C }
C {sky130_stdcells/nand3_4.sym} 4460 -18630 0 0 {name=X_77660_ }
C {devices/lab_pin.sym} 4380 -18510 0 0 {name=p4181 lab=_74870_/Y }
C {devices/lab_pin.sym} 4380 -18470 0 0 {name=p4182 lab=_74866_/Y }
C {devices/lab_pin.sym} 4380 -18430 0 0 {name=p4183 lab=_74871_/Y }
C {devices/lab_pin.sym} 4540 -18470 0 1 {name=p4184 lab=_74872_/Y }
C {sky130_stdcells/o21ai_4.sym} 4460 -18470 0 0 {name=X_74872_ }
C {devices/lab_pin.sym} 4370 -18330 0 0 {name=p4185 lab=_84534_/CLK }
C {devices/lab_pin.sym} 4370 -18310 0 0 {name=p4186 lab=_45732_/Y }
C {devices/lab_pin.sym} 4550 -18330 0 1 {name=p4187 lab=_62057_/D }
C {sky130_stdcells/dfxtp_4.sym} 4460 -18320 0 0 {name=X_86858_ }
C {devices/lab_pin.sym} 4400 -18210 0 0 {name=p4188 lab=_76611_/A }
C {devices/lab_pin.sym} 4400 -18170 0 0 {name=p4189 lab=_81375_/Q }
C {devices/lab_pin.sym} 4400 -18130 0 0 {name=p4190 lab=_76609_/Y }
C {devices/lab_pin.sym} 4520 -18170 0 1 {name=p4191 lab=_76611_/Y }
C {sky130_stdcells/nand3_4.sym} 4460 -18170 0 0 {name=X_76611_ }
C {devices/lab_pin.sym} 4380 -18060 0 0 {name=p4192 lab=_43057_/Y }
C {devices/lab_pin.sym} 4380 -18020 0 0 {name=p4193 lab=_72900_/X }
C {devices/lab_pin.sym} 4380 -17980 0 0 {name=p4194 lab=_73772_/X }
C {devices/lab_pin.sym} 4380 -17940 0 0 {name=p4195 lab=_73822_/Y }
C {devices/lab_pin.sym} 4540 -18000 0 1 {name=p4196 lab=_73823_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -18000 0 0 {name=X_73823_ }
C {devices/lab_pin.sym} 4370 -17850 0 0 {name=p4197 lab=_86422_/CLK }
C {devices/lab_pin.sym} 4370 -17830 0 0 {name=p4198 lab=_85809_/D }
C {devices/lab_pin.sym} 4550 -17850 0 1 {name=p4199 lab=_85809_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4460 -17840 0 0 {name=X_85809_ }
C {devices/lab_pin.sym} 4380 -17730 0 0 {name=p4200 lab=_58756_/X }
C {devices/lab_pin.sym} 4380 -17690 0 0 {name=p4201 lab=_85938_/Q }
C {devices/lab_pin.sym} 4380 -17650 0 0 {name=p4202 lab=_58664_/X }
C {devices/lab_pin.sym} 4540 -17690 0 1 {name=p4203 lab=_58757_/X }
C {sky130_stdcells/o21a_4.sym} 4460 -17690 0 0 {name=X_58757_ }
C {devices/lab_pin.sym} 4400 -17560 0 0 {name=p4204 lab=_46806_/A }
C {devices/lab_pin.sym} 4400 -17520 0 0 {name=p4205 lab=_50971_/B }
C {devices/lab_pin.sym} 4520 -17540 0 1 {name=p4206 lab=_46771_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -17540 0 0 {name=X_46771_ }
C {devices/lab_pin.sym} 4420 -17410 0 0 {name=p4207 lab=_77591_/A }
C {devices/lab_pin.sym} 4500 -17410 0 1 {name=p4208 lab=_77596_/A }
C {sky130_stdcells/buf_2.sym} 4460 -17410 0 0 {name=X_77591_ }
C {devices/lab_pin.sym} 4420 -17290 0 0 {name=p4209 lab=_43983_/A }
C {devices/lab_pin.sym} 4500 -17290 0 1 {name=p4210 lab=_44186_/A }
C {sky130_stdcells/inv_2.sym} 4460 -17290 0 0 {name=X_43983_ }
C {devices/lab_pin.sym} 4400 -17180 0 0 {name=p4211 lab=_55691_/A }
C {devices/lab_pin.sym} 4400 -17140 0 0 {name=p4212 lab=_85183_/Q }
C {devices/lab_pin.sym} 4520 -17160 0 1 {name=p4213 lab=_55969_/X }
C {sky130_stdcells/and2_4.sym} 4460 -17160 0 0 {name=X_55969_ }
C {devices/lab_pin.sym} 4370 -17030 0 0 {name=p4214 lab=_86814_/CLK }
C {devices/lab_pin.sym} 4370 -17010 0 0 {name=p4215 lab=_86789_/D }
C {devices/lab_pin.sym} 4550 -17030 0 1 {name=p4216 lab=_66985_/B }
C {sky130_stdcells/dfxtp_4.sym} 4460 -17020 0 0 {name=X_86789_ }
C {devices/lab_pin.sym} 4420 -16890 0 0 {name=p4217 lab=_74431_/A }
C {devices/lab_pin.sym} 4500 -16890 0 1 {name=p4218 lab=_52166_/A }
C {sky130_stdcells/buf_2.sym} 4460 -16890 0 0 {name=X_48510_ }
C {devices/lab_pin.sym} 4400 -16780 0 0 {name=p4219 lab=_79330_/A }
C {devices/lab_pin.sym} 4400 -16740 0 0 {name=p4220 lab=_79330_/B }
C {devices/lab_pin.sym} 4520 -16760 0 1 {name=p4221 lab=_79331_/B }
C {sky130_stdcells/xor2_4.sym} 4460 -16760 0 0 {name=X_79330_ }
C {devices/lab_pin.sym} 4380 -16660 0 0 {name=p4222 lab=_45719_/Y }
C {devices/lab_pin.sym} 4380 -16620 0 0 {name=p4223 lab=_45627_/X }
C {devices/lab_pin.sym} 4380 -16580 0 0 {name=p4224 lab=_45720_/X }
C {devices/lab_pin.sym} 4380 -16540 0 0 {name=p4225 lab=_45721_/Y }
C {devices/lab_pin.sym} 4540 -16600 0 1 {name=p4226 lab=_45722_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -16600 0 0 {name=X_45722_ }
C {devices/lab_pin.sym} 4420 -16450 0 0 {name=p4227 lab=_57837_/A }
C {devices/lab_pin.sym} 4500 -16450 0 1 {name=p4228 lab=_57708_/X }
C {sky130_stdcells/buf_2.sym} 4460 -16450 0 0 {name=X_57708_ }
C {devices/lab_pin.sym} 4420 -16330 0 0 {name=p4229 lab=_76584_/C }
C {devices/lab_pin.sym} 4500 -16330 0 1 {name=p4230 lab=_76548_/A }
C {sky130_stdcells/inv_2.sym} 4460 -16330 0 0 {name=X_76542_ }
C {devices/lab_pin.sym} 4420 -16210 0 0 {name=p4231 lab=clkbuf_7_68_0_CLK/X }
C {devices/lab_pin.sym} 4500 -16210 0 1 {name=p4232 lab=clkbuf_8_136_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 4460 -16210 0 0 {name=Xclkbuf_8_136_0_CLK }
C {devices/lab_pin.sym} 4420 -16090 0 0 {name=p4233 lab=_42835_/X }
C {devices/lab_pin.sym} 4500 -16090 0 1 {name=p4234 lab=_42934_/X }
C {sky130_stdcells/buf_2.sym} 4460 -16090 0 0 {name=X_42934_ }
C {devices/lab_pin.sym} 4380 -15990 0 0 {name=p4235 lab=_49486_/Y }
C {devices/lab_pin.sym} 4380 -15950 0 0 {name=p4236 lab=_49487_/X }
C {devices/lab_pin.sym} 4380 -15910 0 0 {name=p4237 lab=_49489_/X }
C {devices/lab_pin.sym} 4540 -15950 0 1 {name=p4238 lab=_49490_/Y }
C {sky130_stdcells/a21oi_4.sym} 4460 -15950 0 0 {name=X_49490_ }
C {devices/lab_pin.sym} 4380 -15830 0 0 {name=p4239 lab=_73751_/X }
C {devices/lab_pin.sym} 4380 -15790 0 0 {name=p4240 lab=_73753_/X }
C {devices/lab_pin.sym} 4380 -15750 0 0 {name=p4241 lab=_73679_/X }
C {devices/lab_pin.sym} 4540 -15790 0 1 {name=p4242 lab=_73767_/B }
C {sky130_stdcells/a21o_4.sym} 4460 -15790 0 0 {name=X_73754_ }
C {devices/lab_pin.sym} 4420 -15650 0 0 {name=p4243 lab=clkbuf_9_65_0_CLK/X }
C {devices/lab_pin.sym} 4500 -15650 0 1 {name=p4244 lab=_81808_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 4460 -15650 0 0 {name=Xclkbuf_10_131_0_CLK }
C {devices/lab_pin.sym} 4420 -15530 0 0 {name=p4245 lab=_70966_/A }
C {devices/lab_pin.sym} 4500 -15530 0 1 {name=p4246 lab=_70969_/C }
C {sky130_stdcells/buf_2.sym} 4460 -15530 0 0 {name=X_70966_ }
C {devices/lab_pin.sym} 4400 -15420 0 0 {name=p4247 lab=_58688_/A }
C {devices/lab_pin.sym} 4400 -15380 0 0 {name=p4248 lab=_58688_/B }
C {devices/lab_pin.sym} 4520 -15400 0 1 {name=p4249 lab=_58688_/Y }
C {sky130_stdcells/nor2_4.sym} 4460 -15400 0 0 {name=X_58688_ }
C {devices/lab_pin.sym} 4420 -15270 0 0 {name=p4250 lab=_46485_/X }
C {devices/lab_pin.sym} 4500 -15270 0 1 {name=p4251 lab=_48489_/B }
C {sky130_stdcells/buf_2.sym} 4460 -15270 0 0 {name=X_48441_ }
C {devices/lab_pin.sym} 4420 -15150 0 0 {name=p4252 lab=_72688_/A }
C {devices/lab_pin.sym} 4500 -15150 0 1 {name=p4253 lab=_72714_/B }
C {sky130_stdcells/buf_2.sym} 4460 -15150 0 0 {name=X_72705_ }
C {devices/lab_pin.sym} 4420 -15030 0 0 {name=p4254 lab=clkbuf_9_380_0_CLK/X }
C {devices/lab_pin.sym} 4500 -15030 0 1 {name=p4255 lab=_88036_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 4460 -15030 0 0 {name=Xclkbuf_10_761_0_CLK }
C {devices/lab_pin.sym} 4400 -14920 0 0 {name=p4256 lab=_79257_/Y }
C {devices/lab_pin.sym} 4400 -14880 0 0 {name=p4257 lab=_79270_/B }
C {devices/lab_pin.sym} 4520 -14900 0 1 {name=p4258 lab=_79263_/A }
C {sky130_stdcells/xor2_4.sym} 4460 -14900 0 0 {name=X_79261_ }
C {devices/lab_pin.sym} 4420 -14770 0 0 {name=p4259 lab=_82993_/Q }
C {devices/lab_pin.sym} 4500 -14770 0 1 {name=p4260 lab=_45654_/A }
C {sky130_stdcells/inv_2.sym} 4460 -14770 0 0 {name=X_45653_ }
C {devices/lab_pin.sym} 4420 -14650 0 0 {name=p4261 lab=_71993_/A }
C {devices/lab_pin.sym} 4500 -14650 0 1 {name=p4262 lab=_71970_/A }
C {sky130_stdcells/buf_2.sym} 4460 -14650 0 0 {name=X_57639_ }
C {devices/lab_pin.sym} 4420 -14530 0 0 {name=p4263 lab=_76473_/A }
C {devices/lab_pin.sym} 4500 -14530 0 1 {name=p4264 lab=_76473_/Y }
C {sky130_stdcells/inv_2.sym} 4460 -14530 0 0 {name=X_76473_ }
C {devices/lab_pin.sym} 4420 -14410 0 0 {name=p4265 lab=_42865_/A }
C {devices/lab_pin.sym} 4500 -14410 0 1 {name=p4266 lab=_42865_/Y }
C {sky130_stdcells/inv_2.sym} 4460 -14410 0 0 {name=X_42865_ }
C {devices/lab_pin.sym} 4380 -14320 0 0 {name=p4267 lab=_73605_/X }
C {devices/lab_pin.sym} 4380 -14280 0 0 {name=p4268 lab=_86236_/Q }
C {devices/lab_pin.sym} 4380 -14240 0 0 {name=p4269 lab=_73683_/X }
C {devices/lab_pin.sym} 4380 -14200 0 0 {name=p4270 lab=_73684_/X }
C {devices/lab_pin.sym} 4540 -14260 0 1 {name=p4271 lab=_73685_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -14260 0 0 {name=X_73685_ }
C {devices/lab_pin.sym} 4400 -14140 0 0 {name=p4272 lab=_70869_/A }
C {devices/lab_pin.sym} 4400 -14100 0 0 {name=p4273 lab=_70903_/B }
C {devices/lab_pin.sym} 4400 -14060 0 0 {name=p4274 lab=_70899_/C }
C {devices/lab_pin.sym} 4400 -14020 0 0 {name=p4275 lab=_70899_/D }
C {devices/lab_pin.sym} 4520 -14080 0 1 {name=p4276 lab=_70897_/Y }
C {sky130_stdcells/nand4_4.sym} 4460 -14080 0 0 {name=X_70897_ }
C {devices/lab_pin.sym} 4400 -13940 0 0 {name=p4277 lab=_78213_/A }
C {devices/lab_pin.sym} 4400 -13900 0 0 {name=p4278 lab=_78213_/B }
C {devices/lab_pin.sym} 4520 -13920 0 1 {name=p4279 lab=_78220_/B }
C {sky130_stdcells/or2_4.sym} 4460 -13920 0 0 {name=X_78212_ }
C {devices/lab_pin.sym} 4380 -13820 0 0 {name=p4280 lab=_40935_/A }
C {devices/lab_pin.sym} 4380 -13780 0 0 {name=p4281 lab=_44602_/X }
C {devices/lab_pin.sym} 4380 -13740 0 0 {name=p4282 lab=_87039_/Q }
C {devices/lab_pin.sym} 4380 -13700 0 0 {name=p4283 lab=_44603_/X }
C {devices/lab_pin.sym} 4540 -13760 0 1 {name=p4284 lab=_44604_/X }
C {sky130_stdcells/a2bb2o_4.sym} 4460 -13760 0 0 {name=X_44604_ }
C {devices/lab_pin.sym} 4400 -13620 0 0 {name=p4285 lab=_75424_/A }
C {devices/lab_pin.sym} 4400 -13580 0 0 {name=p4286 lab=_75424_/B }
C {devices/lab_pin.sym} 4520 -13600 0 1 {name=p4287 lab=_75427_/B }
C {sky130_stdcells/nor2_4.sym} 4460 -13600 0 0 {name=X_75424_ }
C {devices/lab_pin.sym} 4380 -13500 0 0 {name=p4288 lab=_40418_/X }
C {devices/lab_pin.sym} 4380 -13460 0 0 {name=p4289 lab=_41813_/X }
C {devices/lab_pin.sym} 4380 -13420 0 0 {name=p4290 lab=_66802_/B }
C {devices/lab_pin.sym} 4380 -13380 0 0 {name=p4291 lab=_41814_/X }
C {devices/lab_pin.sym} 4540 -13440 0 1 {name=p4292 lab=_88138_/D }
C {sky130_stdcells/a2bb2o_4.sym} 4460 -13440 0 0 {name=X_41816_ }
C {devices/lab_pin.sym} 4420 -13290 0 0 {name=p4293 lab=_60712_/B }
C {devices/lab_pin.sym} 4500 -13290 0 1 {name=p4294 lab=_60694_/B }
C {sky130_stdcells/buf_2.sym} 4460 -13290 0 0 {name=X_60650_ }
C {devices/lab_pin.sym} 4420 -13170 0 0 {name=p4295 lab=clkbuf_9_253_0_CLK/A }
C {devices/lab_pin.sym} 4500 -13170 0 1 {name=p4296 lab=clkbuf_9_252_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 4460 -13170 0 0 {name=Xclkbuf_9_252_0_CLK }
C {devices/lab_pin.sym} 4420 -13050 0 0 {name=p4297 lab=_48471_/A }
C {devices/lab_pin.sym} 4500 -13050 0 1 {name=p4298 lab=_48372_/X }
C {sky130_stdcells/buf_2.sym} 4460 -13050 0 0 {name=X_48372_ }
C {devices/lab_pin.sym} 4380 -12950 0 0 {name=p4299 lab=_70165_/A }
C {devices/lab_pin.sym} 4380 -12910 0 0 {name=p4300 lab=_72631_/X }
C {devices/lab_pin.sym} 4380 -12870 0 0 {name=p4301 lab=_72635_/Y }
C {devices/lab_pin.sym} 4540 -12910 0 1 {name=p4302 lab=_72636_/X }
C {sky130_stdcells/a21bo_4.sym} 4460 -12910 0 0 {name=X_72636_ }
C {devices/lab_pin.sym} 4400 -12780 0 0 {name=p4303 lab=_79190_/Y }
C {devices/lab_pin.sym} 4400 -12740 0 0 {name=p4304 lab=_79192_/B }
C {devices/lab_pin.sym} 4520 -12760 0 1 {name=p4305 lab=_79193_/B }
C {sky130_stdcells/nand2_4.sym} 4460 -12760 0 0 {name=X_79192_ }
C {devices/lab_pin.sym} 4420 -12630 0 0 {name=p4306 lab=_45584_/A }
C {devices/lab_pin.sym} 4500 -12630 0 1 {name=p4307 lab=_45584_/Y }
C {sky130_stdcells/inv_2.sym} 4460 -12630 0 0 {name=X_45584_ }
C {devices/lab_pin.sym} 4420 -12510 0 0 {name=p4308 lab=_42723_/A }
C {devices/lab_pin.sym} 4500 -12510 0 1 {name=p4309 lab=_42796_/X }
C {sky130_stdcells/buf_2.sym} 4460 -12510 0 0 {name=X_42796_ }
C {devices/lab_pin.sym} 4420 -12390 0 0 {name=p4310 lab=_47323_/A }
C {devices/lab_pin.sym} 4500 -12390 0 1 {name=p4311 lab=_47324_/A }
C {sky130_stdcells/inv_2.sym} 4460 -12390 0 0 {name=X_47323_ }
C {devices/lab_pin.sym} 4380 -12290 0 0 {name=p4312 lab=_59273_/X }
C {devices/lab_pin.sym} 4380 -12250 0 0 {name=p4313 lab=_85640_/Q }
C {devices/lab_pin.sym} 4380 -12210 0 0 {name=p4314 lab=_59308_/X }
C {devices/lab_pin.sym} 4540 -12250 0 1 {name=p4315 lab=_59309_/X }
C {sky130_stdcells/o21a_4.sym} 4460 -12250 0 0 {name=X_59309_ }
C {devices/lab_pin.sym} 4400 -12120 0 0 {name=p4316 lab=_78143_/A }
C {devices/lab_pin.sym} 4400 -12080 0 0 {name=p4317 lab=_78143_/B }
C {devices/lab_pin.sym} 4520 -12100 0 1 {name=p4318 lab=_78144_/B }
C {sky130_stdcells/xnor2_4.sym} 4460 -12100 0 0 {name=X_78143_ }
C {devices/lab_pin.sym} 4420 -11970 0 0 {name=p4319 lab=clkbuf_9_73_0_CLK/X }
C {devices/lab_pin.sym} 4500 -11970 0 1 {name=p4320 lab=_83187_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 4460 -11970 0 0 {name=Xclkbuf_10_146_0_CLK }
C {devices/lab_pin.sym} 4420 -11850 0 0 {name=p4321 lab=_87064_/Q }
C {devices/lab_pin.sym} 4500 -11850 0 1 {name=p4322 lab=_44535_/Y }
C {sky130_stdcells/inv_2.sym} 4460 -11850 0 0 {name=X_44535_ }
C {devices/lab_pin.sym} 4400 -11740 0 0 {name=p4323 lab=_75347_/X }
C {devices/lab_pin.sym} 4400 -11700 0 0 {name=p4324 lab=_75354_/X }
C {devices/lab_pin.sym} 4520 -11720 0 1 {name=p4325 lab=_75355_/X }
C {sky130_stdcells/xor2_4.sym} 4460 -11720 0 0 {name=X_75355_ }
C {devices/lab_pin.sym} 4400 -11600 0 0 {name=p4326 lab=_41747_/A }
C {devices/lab_pin.sym} 4400 -11560 0 0 {name=p4327 lab=_41718_/X }
C {devices/lab_pin.sym} 4520 -11580 0 1 {name=p4328 lab=_41747_/X }
C {sky130_stdcells/or2_4.sym} 4460 -11580 0 0 {name=X_41747_ }
C {devices/lab_pin.sym} 4400 -11470 0 0 {name=p4329 lab=_60612_/A }
C {devices/lab_pin.sym} 4400 -11430 0 0 {name=p4330 lab=_60612_/B }
C {devices/lab_pin.sym} 4400 -11390 0 0 {name=p4331 lab=_79135_/A }
C {devices/lab_pin.sym} 4520 -11430 0 1 {name=p4332 lab=_60581_/Y }
C {sky130_stdcells/nor3_4.sym} 4460 -11430 0 0 {name=X_60581_ }
C {devices/lab_pin.sym} 4400 -11310 0 0 {name=p4333 lab=_72573_/A }
C {devices/lab_pin.sym} 4400 -11270 0 0 {name=p4334 lab=_72573_/B }
C {devices/lab_pin.sym} 4400 -11230 0 0 {name=p4335 lab=_79414_/B }
C {devices/lab_pin.sym} 4520 -11270 0 1 {name=p4336 lab=_72567_/Y }
C {sky130_stdcells/nor3_4.sym} 4460 -11270 0 0 {name=X_72567_ }
C {devices/lab_pin.sym} 4420 -11130 0 0 {name=p4337 lab=clkbuf_9_388_0_CLK/X }
C {devices/lab_pin.sym} 4500 -11130 0 1 {name=p4338 lab=_82145_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 4460 -11130 0 0 {name=Xclkbuf_10_776_0_CLK }
C {devices/lab_pin.sym} 4420 -11010 0 0 {name=p4339 lab=_62471_/A }
C {devices/lab_pin.sym} 4500 -11010 0 1 {name=p4340 lab=_62334_/D }
C {sky130_stdcells/buf_2.sym} 4460 -11010 0 0 {name=X_62320_ }
C {devices/lab_pin.sym} 4400 -10910 0 0 {name=p4341 lab=_74302_/X }
C {devices/lab_pin.sym} 4400 -10870 0 0 {name=p4342 lab=_74310_/B }
C {devices/lab_pin.sym} 4400 -10830 0 0 {name=p4343 lab=_74306_/C }
C {devices/lab_pin.sym} 4520 -10870 0 1 {name=p4344 lab=_74306_/Y }
C {sky130_stdcells/nand3_4.sym} 4460 -10870 0 0 {name=X_74306_ }
C {devices/lab_pin.sym} 4380 -10750 0 0 {name=p4345 lab=_86654_/Q }
C {devices/lab_pin.sym} 4380 -10710 0 0 {name=p4346 lab=_47240_/X }
C {devices/lab_pin.sym} 4380 -10670 0 0 {name=p4347 lab=_47253_/Y }
C {devices/lab_pin.sym} 4540 -10710 0 1 {name=p4348 lab=_47254_/Y }
C {sky130_stdcells/o21ai_4.sym} 4460 -10710 0 0 {name=X_47254_ }
C {devices/lab_pin.sym} 4380 -10590 0 0 {name=p4349 lab=_53240_/B }
C {devices/lab_pin.sym} 4380 -10550 0 0 {name=p4350 lab=_71508_/X }
C {devices/lab_pin.sym} 4380 -10510 0 0 {name=p4351 lab=_71517_/Y }
C {devices/lab_pin.sym} 4540 -10550 0 1 {name=p4352 lab=_83470_/D }
C {sky130_stdcells/o21ai_4.sym} 4460 -10550 0 0 {name=X_71518_ }
C {devices/lab_pin.sym} 4400 -10420 0 0 {name=p4353 lab=_78074_/A }
C {devices/lab_pin.sym} 4400 -10380 0 0 {name=p4354 lab=_78074_/B }
C {devices/lab_pin.sym} 4520 -10400 0 1 {name=p4355 lab=_78074_/X }
C {sky130_stdcells/xor2_4.sym} 4460 -10400 0 0 {name=X_78074_ }
C {devices/lab_pin.sym} 4420 -10270 0 0 {name=p4356 lab=_44603_/A }
C {devices/lab_pin.sym} 4500 -10270 0 1 {name=p4357 lab=_44466_/X }
C {sky130_stdcells/buf_2.sym} 4460 -10270 0 0 {name=X_44466_ }
C {devices/lab_pin.sym} 4380 -10170 0 0 {name=p4358 lab=_75267_/Y }
C {devices/lab_pin.sym} 4380 -10130 0 0 {name=p4359 lab=_75268_/Y }
C {devices/lab_pin.sym} 4380 -10090 0 0 {name=p4360 lab=_75269_/Y }
C {devices/lab_pin.sym} 4540 -10130 0 1 {name=p4361 lab=_75294_/A }
C {sky130_stdcells/o21a_4.sym} 4460 -10130 0 0 {name=X_75286_ }
C {devices/lab_pin.sym} 4420 -9990 0 0 {name=p4362 lab=_41678_/A }
C {devices/lab_pin.sym} 4500 -9990 0 1 {name=p4363 lab=_41678_/Y }
C {sky130_stdcells/inv_2.sym} 4460 -9990 0 0 {name=X_41678_ }
C {devices/lab_pin.sym} 4400 -9880 0 0 {name=p4364 lab=_63630_/A }
C {devices/lab_pin.sym} 4400 -9840 0 0 {name=p4365 lab=_72498_/B }
C {devices/lab_pin.sym} 4520 -9860 0 1 {name=p4366 lab=_72498_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -9860 0 0 {name=X_72498_ }
C {devices/lab_pin.sym} 4380 -9750 0 0 {name=p4367 lab=_46120_/A }
C {devices/lab_pin.sym} 4380 -9710 0 0 {name=p4368 lab=_72527_/B }
C {devices/lab_pin.sym} 4380 -9670 0 0 {name=p4369 lab=_46204_/Y }
C {devices/lab_pin.sym} 4540 -9710 0 1 {name=p4370 lab=_46205_/Y }
C {sky130_stdcells/a21oi_4.sym} 4460 -9710 0 0 {name=X_46205_ }
C {devices/lab_pin.sym} 4420 -9570 0 0 {name=p4371 lab=clkbuf_9_267_0_CLK/A }
C {devices/lab_pin.sym} 4500 -9570 0 1 {name=p4372 lab=clkbuf_9_267_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 4460 -9570 0 0 {name=Xclkbuf_9_267_0_CLK }
C {sky130_stdcells/decap_3.sym} 4460 -9420 0 0 {name=XPHY_170 }
C {devices/lab_pin.sym} 4400 -9280 0 0 {name=p4373 lab=_77018_/A }
C {devices/lab_pin.sym} 4400 -9240 0 0 {name=p4374 lab=_82277_/D }
C {devices/lab_pin.sym} 4520 -9260 0 1 {name=p4375 lab=_77025_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -9260 0 0 {name=X_77025_ }
C {devices/lab_pin.sym} 4380 -9170 0 0 {name=p4376 lab=_43399_/X }
C {devices/lab_pin.sym} 4380 -9130 0 0 {name=p4377 lab=_43404_/X }
C {devices/lab_pin.sym} 4380 -9090 0 0 {name=p4378 lab=_41520_/X }
C {devices/lab_pin.sym} 4380 -9050 0 0 {name=p4379 lab=_87431_/Q }
C {devices/lab_pin.sym} 4380 -9010 0 0 {name=p4380 lab=_43407_/X }
C {devices/lab_pin.sym} 4540 -9090 0 1 {name=p4381 lab=_43418_/A }
C {sky130_stdcells/o32ai_4.sym} 4460 -9090 0 0 {name=X_43417_ }
C {devices/lab_pin.sym} 4400 -8940 0 0 {name=p4382 lab=_74237_/A }
C {devices/lab_pin.sym} 4400 -8900 0 0 {name=p4383 lab=_66326_/B }
C {devices/lab_pin.sym} 4520 -8920 0 1 {name=p4384 lab=_74237_/X }
C {sky130_stdcells/and2_4.sym} 4460 -8920 0 0 {name=X_74237_ }
C {devices/lab_pin.sym} 4400 -8820 0 0 {name=p4385 lab=_62212_/A }
C {devices/lab_pin.sym} 4400 -8780 0 0 {name=p4386 lab=_62251_/B }
C {devices/lab_pin.sym} 4400 -8740 0 0 {name=p4387 lab=_62251_/C }
C {devices/lab_pin.sym} 4400 -8700 0 0 {name=p4388 lab=_62251_/D }
C {devices/lab_pin.sym} 4520 -8760 0 1 {name=p4389 lab=_62251_/Y }
C {sky130_stdcells/nand4_4.sym} 4460 -8760 0 0 {name=X_62251_ }
C {sky130_stdcells/decap_3.sym} 4460 -8580 0 0 {name=XPHY_181 }
C {devices/lab_pin.sym} 4420 -8430 0 0 {name=p4390 lab=_40629_/A }
C {devices/lab_pin.sym} 4500 -8430 0 1 {name=p4391 lab=_48631_/A }
C {sky130_stdcells/buf_2.sym} 4460 -8430 0 0 {name=X_40629_ }
C {devices/lab_pin.sym} 4400 -8320 0 0 {name=p4392 lab=_47150_/A }
C {devices/lab_pin.sym} 4400 -8280 0 0 {name=p4393 lab=_47184_/X }
C {devices/lab_pin.sym} 4520 -8300 0 1 {name=p4394 lab=_47185_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -8300 0 0 {name=X_47185_ }
C {devices/lab_pin.sym} 4380 -8190 0 0 {name=p4395 lab=_71445_/X }
C {devices/lab_pin.sym} 4380 -8150 0 0 {name=p4396 lab=_58151_/B }
C {devices/lab_pin.sym} 4380 -8110 0 0 {name=p4397 lab=_71448_/Y }
C {devices/lab_pin.sym} 4540 -8150 0 1 {name=p4398 lab=_83496_/D }
C {sky130_stdcells/a21o_4.sym} 4460 -8150 0 0 {name=X_71449_ }
C {devices/lab_pin.sym} 4380 -8050 0 0 {name=p4399 lab=_44381_/X }
C {devices/lab_pin.sym} 4380 -8010 0 0 {name=p4400 lab=_44382_/X }
C {devices/lab_pin.sym} 4380 -7970 0 0 {name=p4401 lab=_41493_/X }
C {devices/lab_pin.sym} 4380 -7930 0 0 {name=p4402 lab=_87129_/Q }
C {devices/lab_pin.sym} 4380 -7890 0 0 {name=p4403 lab=_44383_/X }
C {devices/lab_pin.sym} 4540 -7970 0 1 {name=p4404 lab=_44398_/A }
C {sky130_stdcells/o32ai_4.sym} 4460 -7970 0 0 {name=X_44397_ }
C {sky130_stdcells/decap_3.sym} 4460 -7780 0 0 {name=XPHY_192 }
C {devices/lab_pin.sym} 4400 -7640 0 0 {name=p4405 lab=_61202_/A }
C {devices/lab_pin.sym} 4400 -7600 0 0 {name=p4406 lab=_61202_/B }
C {devices/lab_pin.sym} 4520 -7620 0 1 {name=p4407 lab=_61202_/Y }
C {sky130_stdcells/nor2_4.sym} 4460 -7620 0 0 {name=X_61202_ }
C {devices/lab_pin.sym} 4420 -7490 0 0 {name=p4408 lab=_44184_/X }
C {devices/lab_pin.sym} 4500 -7490 0 1 {name=p4409 lab=_57665_/A }
C {sky130_stdcells/buf_2.sym} 4460 -7490 0 0 {name=X_46136_ }
C {devices/lab_pin.sym} 4380 -7410 0 0 {name=p4410 lab=_43347_/X }
C {devices/lab_pin.sym} 4380 -7370 0 0 {name=p4411 lab=_43319_/X }
C {devices/lab_pin.sym} 4380 -7330 0 0 {name=p4412 lab=_41332_/X }
C {devices/lab_pin.sym} 4380 -7290 0 0 {name=p4413 lab=_87466_/Q }
C {devices/lab_pin.sym} 4380 -7250 0 0 {name=p4414 lab=_43330_/X }
C {devices/lab_pin.sym} 4540 -7330 0 1 {name=p4415 lab=_43349_/A }
C {sky130_stdcells/o32ai_4.sym} 4460 -7330 0 0 {name=X_43348_ }
C {devices/lab_pin.sym} 4380 -7190 0 0 {name=p4416 lab=_62177_/Y }
C {devices/lab_pin.sym} 4380 -7150 0 0 {name=p4417 lab=_62166_/X }
C {devices/lab_pin.sym} 4380 -7110 0 0 {name=p4418 lab=_62181_/Y }
C {devices/lab_pin.sym} 4540 -7150 0 1 {name=p4419 lab=_84427_/D }
C {sky130_stdcells/a21oi_4.sym} 4460 -7150 0 0 {name=X_62182_ }
C {devices/lab_pin.sym} 4380 -7030 0 0 {name=p4420 lab=_74165_/X }
C {devices/lab_pin.sym} 4380 -6990 0 0 {name=p4421 lab=_74167_/X }
C {devices/lab_pin.sym} 4380 -6950 0 0 {name=p4422 lab=_73602_/X }
C {devices/lab_pin.sym} 4540 -6990 0 1 {name=p4423 lab=_74168_/X }
C {sky130_stdcells/a21o_4.sym} 4460 -6990 0 0 {name=X_74168_ }
C {devices/lab_pin.sym} 4380 -6890 0 0 {name=p4424 lab=_61110_/Y }
C {devices/lab_pin.sym} 4380 -6850 0 0 {name=p4425 lab=_61118_/X }
C {devices/lab_pin.sym} 4380 -6810 0 0 {name=p4426 lab=_61254_/B }
C {devices/lab_pin.sym} 4380 -6770 0 0 {name=p4427 lab=_61131_/Y }
C {devices/lab_pin.sym} 4380 -6740 0 0 {name=p4428 lab=_61132_/Y }
C {devices/lab_pin.sym} 4540 -6810 0 1 {name=p4429 lab=_84519_/D }
C {sky130_stdcells/a41oi_4.sym} 4460 -6810 0 0 {name=X_61133_ }
C {devices/lab_pin.sym} 4400 -6660 0 0 {name=p4430 lab=_73116_/X }
C {devices/lab_pin.sym} 4400 -6620 0 0 {name=p4431 lab=_73118_/X }
C {devices/lab_pin.sym} 4520 -6640 0 1 {name=p4432 lab=_73120_/B }
C {sky130_stdcells/nand2_4.sym} 4460 -6640 0 0 {name=X_73119_ }
C {devices/lab_pin.sym} 4420 -6510 0 0 {name=p4433 lab=_40556_/A }
C {devices/lab_pin.sym} 4500 -6510 0 1 {name=p4434 lab=_46067_/X }
C {sky130_stdcells/buf_2.sym} 4460 -6510 0 0 {name=X_46067_ }
C {devices/lab_pin.sym} 4380 -6420 0 0 {name=p4435 lab=_41134_/X }
C {devices/lab_pin.sym} 4380 -6380 0 0 {name=p4436 lab=_43277_/X }
C {devices/lab_pin.sym} 4380 -6340 0 0 {name=p4437 lab=_87503_/Q }
C {devices/lab_pin.sym} 4380 -6300 0 0 {name=p4438 lab=_43278_/X }
C {devices/lab_pin.sym} 4540 -6360 0 1 {name=p4439 lab=_87503_/D }
C {sky130_stdcells/a2bb2o_4.sym} 4460 -6360 0 0 {name=X_43279_ }
C {devices/lab_pin.sym} 4380 -6240 0 0 {name=p4440 lab=_87118_/Q }
C {devices/lab_pin.sym} 4380 -6200 0 0 {name=p4441 lab=_66988_/X }
C {devices/lab_pin.sym} 4380 -6160 0 0 {name=p4442 lab=_66919_/X }
C {devices/lab_pin.sym} 4380 -6120 0 0 {name=p4443 lab=_66989_/X }
C {devices/lab_pin.sym} 4540 -6180 0 1 {name=p4444 lab=_66990_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -6180 0 0 {name=X_66990_ }
C {devices/lab_pin.sym} 4420 -6030 0 0 {name=p4445 lab=_82645_/Q }
C {devices/lab_pin.sym} 4500 -6030 0 1 {name=p4446 lab=_78976_/Y }
C {sky130_stdcells/inv_2.sym} 4460 -6030 0 0 {name=X_78976_ }
C {devices/lab_pin.sym} 4380 -5930 0 0 {name=p4447 lab=_74096_/X }
C {devices/lab_pin.sym} 4380 -5890 0 0 {name=p4448 lab=_74098_/X }
C {devices/lab_pin.sym} 4380 -5850 0 0 {name=p4449 lab=_73489_/X }
C {devices/lab_pin.sym} 4540 -5890 0 1 {name=p4450 lab=_74102_/A }
C {sky130_stdcells/a21o_4.sym} 4460 -5890 0 0 {name=X_74099_ }
C {devices/lab_pin.sym} 4380 -5770 0 0 {name=p4451 lab=_56041_/C }
C {devices/lab_pin.sym} 4380 -5730 0 0 {name=p4452 lab=_44963_/X }
C {devices/lab_pin.sym} 4380 -5690 0 0 {name=p4453 lab=_45004_/X }
C {devices/lab_pin.sym} 4540 -5730 0 1 {name=p4454 lab=_45018_/X }
C {sky130_stdcells/o21a_4.sym} 4460 -5730 0 0 {name=X_45018_ }
C {devices/lab_pin.sym} 4400 -5610 0 0 {name=p4455 lab=_65938_/X }
C {devices/lab_pin.sym} 4400 -5570 0 0 {name=p4456 lab=_65868_/B }
C {devices/lab_pin.sym} 4400 -5530 0 0 {name=p4457 lab=_65940_/X }
C {devices/lab_pin.sym} 4520 -5570 0 1 {name=p4458 lab=_65941_/Y }
C {sky130_stdcells/nand3_4.sym} 4460 -5570 0 0 {name=X_65941_ }
C {devices/lab_pin.sym} 4400 -5450 0 0 {name=p4459 lab=_61055_/A }
C {devices/lab_pin.sym} 4400 -5410 0 0 {name=p4460 lab=_59771_/X }
C {devices/lab_pin.sym} 4400 -5370 0 0 {name=p4461 lab=_84522_/Q }
C {devices/lab_pin.sym} 4520 -5410 0 1 {name=p4462 lab=_61064_/X }
C {sky130_stdcells/or3_4.sym} 4460 -5410 0 0 {name=X_61064_ }
C {devices/lab_pin.sym} 4400 -5280 0 0 {name=p4463 lab=_77925_/Y }
C {devices/lab_pin.sym} 4400 -5240 0 0 {name=p4464 lab=_77927_/B }
C {devices/lab_pin.sym} 4520 -5260 0 1 {name=p4465 lab=_77928_/A }
C {sky130_stdcells/xor2_4.sym} 4460 -5260 0 0 {name=X_77927_ }
C {devices/lab_pin.sym} 4420 -5130 0 0 {name=p4466 lab=clkbuf_9_357_0_CLK/X }
C {devices/lab_pin.sym} 4500 -5130 0 1 {name=p4467 lab=_86824_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 4460 -5130 0 0 {name=Xclkbuf_10_714_0_CLK }
C {devices/lab_pin.sym} 4380 -5050 0 0 {name=p4468 lab=_60011_/X }
C {devices/lab_pin.sym} 4380 -5010 0 0 {name=p4469 lab=_59995_/X }
C {devices/lab_pin.sym} 4380 -4970 0 0 {name=p4470 lab=_62548_/D }
C {devices/lab_pin.sym} 4380 -4930 0 0 {name=p4471 lab=_60014_/X }
C {devices/lab_pin.sym} 4380 -4890 0 0 {name=p4472 lab=_46199_/X }
C {devices/lab_pin.sym} 4540 -4970 0 1 {name=p4473 lab=_60015_/Y }
C {sky130_stdcells/a32oi_4.sym} 4460 -4970 0 0 {name=X_60015_ }
C {devices/lab_pin.sym} 4420 -4810 0 0 {name=p4474 lab=_49416_/A }
C {devices/lab_pin.sym} 4500 -4810 0 1 {name=p4475 lab=_49854_/A }
C {sky130_stdcells/buf_2.sym} 4460 -4810 0 0 {name=X_49826_ }
C {devices/lab_pin.sym} 4420 -4690 0 0 {name=p4476 lab=_69654_/A }
C {devices/lab_pin.sym} 4500 -4690 0 1 {name=p4477 lab=_68660_/X }
C {sky130_stdcells/buf_2.sym} 4460 -4690 0 0 {name=X_68660_ }
C {devices/lab_pin.sym} 4400 -4590 0 0 {name=p4478 lab=_65888_/A }
C {devices/lab_pin.sym} 4400 -4550 0 0 {name=p4479 lab=_65888_/B }
C {devices/lab_pin.sym} 4400 -4510 0 0 {name=p4480 lab=_65872_/C }
C {devices/lab_pin.sym} 4520 -4550 0 1 {name=p4481 lab=_65872_/Y }
C {sky130_stdcells/nor3_4.sym} 4460 -4550 0 0 {name=X_65872_ }
C {devices/lab_pin.sym} 4380 -4440 0 0 {name=p4482 lab=_77844_/Y }
C {devices/lab_pin.sym} 4380 -4400 0 0 {name=p4483 lab=_77845_/Y }
C {devices/lab_pin.sym} 4380 -4360 0 0 {name=p4484 lab=_77832_/A }
C {devices/lab_pin.sym} 4380 -4320 0 0 {name=p4485 lab=_81934_/D }
C {devices/lab_pin.sym} 4540 -4380 0 1 {name=p4486 lab=_77858_/X }
C {sky130_stdcells/a2bb2o_4.sym} 4460 -4380 0 0 {name=X_77858_ }
C {devices/lab_pin.sym} 4380 -4260 0 0 {name=p4487 lab=_67522_/X }
C {devices/lab_pin.sym} 4380 -4220 0 0 {name=p4488 lab=_67602_/Y }
C {devices/lab_pin.sym} 4380 -4180 0 0 {name=p4489 lab=_67507_/X }
C {devices/lab_pin.sym} 4380 -4140 0 0 {name=p4490 lab=_67610_/Y }
C {devices/lab_pin.sym} 4540 -4200 0 1 {name=p4491 lab=_67611_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -4200 0 0 {name=X_67611_ }
C {devices/lab_pin.sym} 4420 -4050 0 0 {name=p4492 lab=clkbuf_8_102_0_CLK/X }
C {devices/lab_pin.sym} 4500 -4050 0 1 {name=p4493 lab=clkbuf_9_205_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 4460 -4050 0 0 {name=Xclkbuf_9_205_0_CLK }
C {devices/lab_pin.sym} 4400 -3940 0 0 {name=p4494 lab=_64810_/A }
C {devices/lab_pin.sym} 4400 -3900 0 0 {name=p4495 lab=_86425_/Q }
C {devices/lab_pin.sym} 4520 -3920 0 1 {name=p4496 lab=_64823_/X }
C {sky130_stdcells/and2_4.sym} 4460 -3920 0 0 {name=X_64823_ }
C {devices/lab_pin.sym} 4400 -3800 0 0 {name=p4497 lab=_76809_/A }
C {devices/lab_pin.sym} 4400 -3760 0 0 {name=p4498 lab=_76809_/B }
C {devices/lab_pin.sym} 4520 -3780 0 1 {name=p4499 lab=_76809_/X }
C {sky130_stdcells/xor2_4.sym} 4460 -3780 0 0 {name=X_76809_ }
C {devices/lab_pin.sym} 4400 -3660 0 0 {name=p4500 lab=_49757_/A }
C {devices/lab_pin.sym} 4400 -3620 0 0 {name=p4501 lab=_52973_/B }
C {devices/lab_pin.sym} 4520 -3640 0 1 {name=p4502 lab=_49757_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -3640 0 0 {name=X_49757_ }
C {devices/lab_pin.sym} 4420 -3510 0 0 {name=p4503 lab=_44148_/A }
C {devices/lab_pin.sym} 4500 -3510 0 1 {name=p4504 lab=_69661_/A }
C {sky130_stdcells/buf_2.sym} 4460 -3510 0 0 {name=X_68591_ }
C {devices/lab_pin.sym} 4400 -3400 0 0 {name=p4505 lab=_46959_/A }
C {devices/lab_pin.sym} 4400 -3360 0 0 {name=p4506 lab=_52777_/B }
C {devices/lab_pin.sym} 4520 -3380 0 1 {name=p4507 lab=_46969_/Y }
C {sky130_stdcells/nand2_4.sym} 4460 -3380 0 0 {name=X_46969_ }
C {devices/lab_pin.sym} 4420 -3250 0 0 {name=p4508 lab=_77788_/X }
C {devices/lab_pin.sym} 4500 -3250 0 1 {name=p4509 lab=_77789_/Y }
C {sky130_stdcells/inv_2.sym} 4460 -3250 0 0 {name=X_77789_ }
C {devices/lab_pin.sym} 4400 -3140 0 0 {name=p4510 lab=_81762_/Q }
C {devices/lab_pin.sym} 4400 -3100 0 0 {name=p4511 lab=_48959_/B }
C {devices/lab_pin.sym} 4520 -3120 0 1 {name=p4512 lab=_48708_/X }
C {sky130_stdcells/or2_4.sym} 4460 -3120 0 0 {name=X_48708_ }
C {devices/lab_pin.sym} 4380 -3010 0 0 {name=p4513 lab=_67538_/X }
C {devices/lab_pin.sym} 4380 -2970 0 0 {name=p4514 lab=_67541_/X }
C {devices/lab_pin.sym} 4380 -2930 0 0 {name=p4515 lab=_67423_/X }
C {devices/lab_pin.sym} 4540 -2970 0 1 {name=p4516 lab=_67542_/Y }
C {sky130_stdcells/a21oi_4.sym} 4460 -2970 0 0 {name=X_67542_ }
C {devices/lab_pin.sym} 4420 -2830 0 0 {name=p4517 lab=_60374_/C }
C {devices/lab_pin.sym} 4500 -2830 0 1 {name=p4518 lab=_79528_/Y }
C {sky130_stdcells/inv_2.sym} 4460 -2830 0 0 {name=X_79528_ }
C {devices/lab_pin.sym} 4380 -2740 0 0 {name=p4519 lab=_64752_/X }
C {devices/lab_pin.sym} 4380 -2700 0 0 {name=p4520 lab=_86172_/Q }
C {devices/lab_pin.sym} 4380 -2660 0 0 {name=p4521 lab=_64716_/X }
C {devices/lab_pin.sym} 4380 -2620 0 0 {name=p4522 lab=_64753_/X }
C {devices/lab_pin.sym} 4540 -2680 0 1 {name=p4523 lab=_64754_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -2680 0 0 {name=X_64754_ }
C {devices/lab_pin.sym} 4420 -2530 0 0 {name=p4524 lab=_49416_/A }
C {devices/lab_pin.sym} 4500 -2530 0 1 {name=p4525 lab=_49688_/X }
C {sky130_stdcells/buf_2.sym} 4460 -2530 0 0 {name=X_49688_ }
C {devices/lab_pin.sym} 4420 -2410 0 0 {name=p4526 lab=_61966_/A }
C {devices/lab_pin.sym} 4500 -2410 0 1 {name=p4527 lab=_61967_/C }
C {sky130_stdcells/buf_2.sym} 4460 -2410 0 0 {name=X_61966_ }
C {devices/lab_pin.sym} 4420 -2290 0 0 {name=p4528 lab=clkbuf_9_364_0_CLK/X }
C {devices/lab_pin.sym} 4500 -2290 0 1 {name=p4529 lab=_87026_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 4460 -2290 0 0 {name=Xclkbuf_10_729_0_CLK }
C {devices/lab_pin.sym} 4400 -2180 0 0 {name=p4530 lab=_63696_/A }
C {devices/lab_pin.sym} 4400 -2140 0 0 {name=p4531 lab=_62174_/X }
C {devices/lab_pin.sym} 4520 -2160 0 1 {name=p4532 lab=_63705_/X }
C {sky130_stdcells/and2_4.sym} 4460 -2160 0 0 {name=X_63705_ }
C {devices/lab_pin.sym} 4420 -2030 0 0 {name=p4533 lab=_48639_/A }
C {devices/lab_pin.sym} 4500 -2030 0 1 {name=p4534 lab=_48843_/B }
C {sky130_stdcells/buf_2.sym} 4460 -2030 0 0 {name=X_48639_ }
C {devices/lab_pin.sym} 4420 -1910 0 0 {name=p4535 lab=_64189_/C }
C {devices/lab_pin.sym} 4500 -1910 0 1 {name=p4536 lab=_64172_/C }
C {sky130_stdcells/buf_2.sym} 4460 -1910 0 0 {name=X_60917_ }
C {devices/lab_pin.sym} 4420 -1790 0 0 {name=p4537 lab=_67354_/X }
C {devices/lab_pin.sym} 4500 -1790 0 1 {name=p4538 lab=_67473_/X }
C {sky130_stdcells/buf_2.sym} 4460 -1790 0 0 {name=X_67473_ }
C {devices/lab_pin.sym} 4400 -1680 0 0 {name=p4539 lab=_79459_/A }
C {devices/lab_pin.sym} 4400 -1640 0 0 {name=p4540 lab=_79459_/B }
C {devices/lab_pin.sym} 4520 -1660 0 1 {name=p4541 lab=_79482_/B }
C {sky130_stdcells/and2_4.sym} 4460 -1660 0 0 {name=X_79459_ }
C {devices/lab_pin.sym} 4380 -1560 0 0 {name=p4542 lab=_64657_/X }
C {devices/lab_pin.sym} 4380 -1520 0 0 {name=p4543 lab=_83310_/Q }
C {devices/lab_pin.sym} 4380 -1480 0 0 {name=p4544 lab=_64600_/X }
C {devices/lab_pin.sym} 4380 -1440 0 0 {name=p4545 lab=_64684_/X }
C {devices/lab_pin.sym} 4540 -1500 0 1 {name=p4546 lab=_64685_/X }
C {sky130_stdcells/a211o_4.sym} 4460 -1500 0 0 {name=X_64685_ }
C {devices/lab_pin.sym} 4420 -1350 0 0 {name=p4547 lab=_61722_/A }
C {devices/lab_pin.sym} 4500 -1350 0 1 {name=p4548 lab=_61960_/A }
C {sky130_stdcells/buf_2.sym} 4460 -1350 0 0 {name=X_61897_ }
C {devices/lab_pin.sym} 4420 -1230 0 0 {name=p4549 lab=_68737_/A }
C {devices/lab_pin.sym} 4500 -1230 0 1 {name=p4550 lab=_69212_/X }
C {sky130_stdcells/buf_2.sym} 4460 -1230 0 0 {name=X_69212_ }
C {devices/lab_pin.sym} 4380 -1130 0 0 {name=p4551 lab=_66422_/Y }
