C {devices/lab_pin.sym} 133220 -36490 0 0 {name=p132030 lab=clkbuf_9_351_0_CLK/A }
C {devices/lab_pin.sym} 133300 -36490 0 1 {name=p132031 lab=clkbuf_9_351_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 133260 -36490 0 0 {name=Xclkbuf_9_351_0_CLK }
C {devices/lab_pin.sym} 133170 -36370 0 0 {name=p132032 lab=_85404_/CLK }
C {devices/lab_pin.sym} 133170 -36350 0 0 {name=p132033 lab=_54646_/Y }
C {devices/lab_pin.sym} 133350 -36370 0 1 {name=p132034 lab=_85404_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -36360 0 0 {name=X_85404_ }
C {devices/lab_pin.sym} 133200 -36260 0 0 {name=p132035 lab=_71735_/A }
C {devices/lab_pin.sym} 133200 -36220 0 0 {name=p132036 lab=_70630_/B }
C {devices/lab_pin.sym} 133200 -36180 0 0 {name=p132037 lab=_71115_/D }
C {devices/lab_pin.sym} 133200 -36140 0 0 {name=p132038 lab=_71735_/C }
C {devices/lab_pin.sym} 133320 -36200 0 1 {name=p132039 lab=_70630_/X }
C {sky130_stdcells/and4_4.sym} 133260 -36200 0 0 {name=X_70630_ }
C {devices/lab_pin.sym} 133200 -36060 0 0 {name=p132040 lab=_58352_/A }
C {devices/lab_pin.sym} 133200 -36020 0 0 {name=p132041 lab=_58344_/B }
C {devices/lab_pin.sym} 133320 -36040 0 1 {name=p132042 lab=_58352_/Y }
C {sky130_stdcells/nor2_4.sym} 133260 -36040 0 0 {name=X_58352_ }
C {devices/lab_pin.sym} 133170 -35910 0 0 {name=p132043 lab=_82503_/CLK }
C {devices/lab_pin.sym} 133170 -35890 0 0 {name=p132044 lab=_79011_/B }
C {devices/lab_pin.sym} 133350 -35910 0 1 {name=p132045 lab=_82616_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -35900 0 0 {name=X_82616_ }
C {devices/lab_pin.sym} 133220 -35770 0 0 {name=p132046 lab=_55836_/A }
C {devices/lab_pin.sym} 133300 -35770 0 1 {name=p132047 lab=_55843_/A }
C {sky130_stdcells/buf_2.sym} 133260 -35770 0 0 {name=X_55564_ }
C {devices/lab_pin.sym} 133170 -35650 0 0 {name=p132048 lab=_86384_/CLK }
C {devices/lab_pin.sym} 133170 -35630 0 0 {name=p132049 lab=_86384_/D }
C {devices/lab_pin.sym} 133350 -35650 0 1 {name=p132050 lab=_86384_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -35640 0 0 {name=X_86384_ }
C {devices/lab_pin.sym} 133200 -35520 0 0 {name=p132051 lab=_40817_/A }
C {devices/lab_pin.sym} 133200 -35480 0 0 {name=p132052 lab=_40790_/B }
C {devices/lab_pin.sym} 133320 -35500 0 1 {name=p132053 lab=_40790_/X }
C {sky130_stdcells/or2_4.sym} 133260 -35500 0 0 {name=X_40790_ }
C {devices/lab_pin.sym} 133180 -35390 0 0 {name=p132054 lab=_52774_/Y }
C {devices/lab_pin.sym} 133180 -35350 0 0 {name=p132055 lab=_52755_/X }
C {devices/lab_pin.sym} 133180 -35310 0 0 {name=p132056 lab=_52775_/X }
C {devices/lab_pin.sym} 133340 -35350 0 1 {name=p132057 lab=_52776_/Y }
C {sky130_stdcells/a21oi_4.sym} 133260 -35350 0 0 {name=X_52776_ }
C {devices/lab_pin.sym} 133170 -35210 0 0 {name=p132058 lab=_86149_/CLK }
C {devices/lab_pin.sym} 133170 -35190 0 0 {name=p132059 lab=_83596_/D }
C {devices/lab_pin.sym} 133350 -35210 0 1 {name=p132060 lab=_49175_/A }
C {sky130_stdcells/dfxtp_4.sym} 133260 -35200 0 0 {name=X_83596_ }
C {devices/lab_pin.sym} 133220 -35070 0 0 {name=p132061 lab=clkbuf_9_122_0_CLK/X }
C {devices/lab_pin.sym} 133300 -35070 0 1 {name=p132062 lab=_84590_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 133260 -35070 0 0 {name=Xclkbuf_10_245_0_CLK }
C {devices/lab_pin.sym} 133200 -34970 0 0 {name=p132063 lab=_57268_/X }
C {devices/lab_pin.sym} 133200 -34930 0 0 {name=p132064 lab=_56783_/X }
C {devices/lab_pin.sym} 133200 -34890 0 0 {name=p132065 lab=_56785_/D }
C {devices/lab_pin.sym} 133320 -34930 0 1 {name=p132066 lab=_57303_/Y }
C {sky130_stdcells/nand3_4.sym} 133260 -34930 0 0 {name=X_57303_ }
C {devices/lab_pin.sym} 133170 -34790 0 0 {name=p132067 lab=_87417_/CLK }
C {devices/lab_pin.sym} 133170 -34770 0 0 {name=p132068 lab=_41851_/Y }
C {devices/lab_pin.sym} 133350 -34790 0 1 {name=p132069 lab=_88123_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -34780 0 0 {name=X_88123_ }
C {devices/lab_pin.sym} 133180 -34670 0 0 {name=p132070 lab=_85428_/Q }
C {devices/lab_pin.sym} 133180 -34630 0 0 {name=p132071 lab=_54512_/X }
C {devices/lab_pin.sym} 133180 -34590 0 0 {name=p132072 lab=_54514_/Y }
C {devices/lab_pin.sym} 133340 -34630 0 1 {name=p132073 lab=_54515_/Y }
C {sky130_stdcells/o21ai_4.sym} 133260 -34630 0 0 {name=X_54515_ }
C {devices/lab_pin.sym} 133170 -34490 0 0 {name=p132074 lab=_85335_/CLK }
C {devices/lab_pin.sym} 133170 -34470 0 0 {name=p132075 lab=_55014_/Y }
C {devices/lab_pin.sym} 133350 -34490 0 1 {name=p132076 lab=_85335_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -34480 0 0 {name=X_85335_ }
C {devices/lab_pin.sym} 133180 -34370 0 0 {name=p132077 lab=_51725_/Y }
C {devices/lab_pin.sym} 133180 -34330 0 0 {name=p132078 lab=_51719_/X }
C {devices/lab_pin.sym} 133180 -34290 0 0 {name=p132079 lab=_51726_/X }
C {devices/lab_pin.sym} 133340 -34330 0 1 {name=p132080 lab=_85957_/D }
C {sky130_stdcells/a21oi_4.sym} 133260 -34330 0 0 {name=X_51727_ }
C {devices/lab_pin.sym} 133220 -34190 0 0 {name=p132081 lab=clkbuf_9_437_0_CLK/X }
C {devices/lab_pin.sym} 133300 -34190 0 1 {name=p132082 lab=_86237_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 133260 -34190 0 0 {name=Xclkbuf_10_875_0_CLK }
C {devices/lab_pin.sym} 133220 -34070 0 0 {name=p132083 lab=DATA_TO_HASH[2] }
C {devices/lab_pin.sym} 133300 -34070 0 1 {name=p132084 lab=_71570_/A }
C {sky130_stdcells/inv_2.sym} 133260 -34070 0 0 {name=X_70561_ }
C {devices/lab_pin.sym} 133220 -33950 0 0 {name=p132085 lab=_58283_/A }
C {devices/lab_pin.sym} 133300 -33950 0 1 {name=p132086 lab=_58283_/Y }
C {sky130_stdcells/inv_2.sym} 133260 -33950 0 0 {name=X_58283_ }
C {devices/lab_pin.sym} 133170 -33830 0 0 {name=p132087 lab=_82541_/CLK }
C {devices/lab_pin.sym} 133170 -33810 0 0 {name=p132088 lab=_82547_/D }
C {devices/lab_pin.sym} 133350 -33830 0 1 {name=p132089 lab=_82547_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -33820 0 0 {name=X_82547_ }
C {devices/lab_pin.sym} 133200 -33700 0 0 {name=p132090 lab=_44061_/X }
C {devices/lab_pin.sym} 133200 -33660 0 0 {name=p132091 lab=_45584_/Y }
C {devices/lab_pin.sym} 133320 -33680 0 1 {name=p132092 lab=_55495_/Y }
C {sky130_stdcells/nor2_4.sym} 133260 -33680 0 0 {name=X_55495_ }
C {devices/lab_pin.sym} 133220 -33550 0 0 {name=p132093 lab=clkbuf_9_13_0_CLK/X }
C {devices/lab_pin.sym} 133300 -33550 0 1 {name=p132094 lab=_82993_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 133260 -33550 0 0 {name=Xclkbuf_10_27_0_CLK }
C {devices/lab_pin.sym} 133220 -33430 0 0 {name=p132095 lab=_59255_/A }
C {devices/lab_pin.sym} 133300 -33430 0 1 {name=p132096 lab=_72347_/A }
C {sky130_stdcells/buf_2.sym} 133260 -33430 0 0 {name=X_72300_ }
C {devices/lab_pin.sym} 133220 -33310 0 0 {name=p132097 lab=_57326_/C }
C {devices/lab_pin.sym} 133300 -33310 0 1 {name=p132098 lab=_57322_/B }
C {sky130_stdcells/buf_2.sym} 133260 -33310 0 0 {name=X_57234_ }
C {devices/lab_pin.sym} 133170 -33190 0 0 {name=p132099 lab=_87542_/CLK }
C {devices/lab_pin.sym} 133170 -33170 0 0 {name=p132100 lab=_88054_/D }
C {devices/lab_pin.sym} 133350 -33190 0 1 {name=p132101 lab=_42057_/A }
C {sky130_stdcells/dfxtp_4.sym} 133260 -33180 0 0 {name=X_88054_ }
C {devices/lab_pin.sym} 133220 -33050 0 0 {name=p132102 lab=_41841_/X }
C {devices/lab_pin.sym} 133300 -33050 0 1 {name=p132103 lab=_42460_/X }
C {sky130_stdcells/buf_2.sym} 133260 -33050 0 0 {name=X_42460_ }
C {devices/lab_pin.sym} 133200 -32940 0 0 {name=p132104 lab=_54446_/A }
C {devices/lab_pin.sym} 133200 -32900 0 0 {name=p132105 lab=_54446_/B }
C {devices/lab_pin.sym} 133320 -32920 0 1 {name=p132106 lab=_54446_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -32920 0 0 {name=X_54446_ }
C {devices/lab_pin.sym} 133180 -32810 0 0 {name=p132107 lab=_69842_/B }
C {devices/lab_pin.sym} 133180 -32770 0 0 {name=p132108 lab=_73279_/X }
C {devices/lab_pin.sym} 133180 -32730 0 0 {name=p132109 lab=_73202_/X }
C {devices/lab_pin.sym} 133340 -32770 0 1 {name=p132110 lab=_73280_/X }
C {sky130_stdcells/o21a_4.sym} 133260 -32770 0 0 {name=X_73280_ }
C {devices/lab_pin.sym} 133170 -32630 0 0 {name=p132111 lab=_85167_/CLK }
C {devices/lab_pin.sym} 133170 -32610 0 0 {name=p132112 lab=_56234_/Y }
C {devices/lab_pin.sym} 133350 -32630 0 1 {name=p132113 lab=_56233_/C }
C {sky130_stdcells/dfxtp_4.sym} 133260 -32620 0 0 {name=X_85266_ }
C {devices/lab_pin.sym} 133200 -32520 0 0 {name=p132114 lab=_51657_/X }
C {devices/lab_pin.sym} 133200 -32480 0 0 {name=p132115 lab=_51651_/B }
C {devices/lab_pin.sym} 133200 -32440 0 0 {name=p132116 lab=_51651_/C }
C {devices/lab_pin.sym} 133200 -32400 0 0 {name=p132117 lab=_53181_/D }
C {devices/lab_pin.sym} 133320 -32460 0 1 {name=p132118 lab=_51658_/X }
C {sky130_stdcells/and4_4.sym} 133260 -32460 0 0 {name=X_51658_ }
C {devices/lab_pin.sym} 133220 -32310 0 0 {name=p132119 lab=clkbuf_9_367_0_CLK/A }
C {devices/lab_pin.sym} 133300 -32310 0 1 {name=p132120 lab=clkbuf_9_366_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 133260 -32310 0 0 {name=Xclkbuf_9_366_0_CLK }
C {devices/lab_pin.sym} 133220 -32190 0 0 {name=p132121 lab=_70491_/Y }
C {devices/lab_pin.sym} 133300 -32190 0 1 {name=p132122 lab=_71136_/A }
C {sky130_stdcells/buf_2.sym} 133260 -32190 0 0 {name=X_70492_ }
C {devices/lab_pin.sym} 133170 -32070 0 0 {name=p132123 lab=_82563_/CLK }
C {devices/lab_pin.sym} 133170 -32050 0 0 {name=p132124 lab=_78483_/X }
C {devices/lab_pin.sym} 133350 -32070 0 1 {name=p132125 lab=_78102_/B }
C {sky130_stdcells/dfxtp_4.sym} 133260 -32060 0 0 {name=X_82478_ }
C {devices/lab_pin.sym} 133220 -31930 0 0 {name=p132126 lab=_47867_/A }
C {devices/lab_pin.sym} 133300 -31930 0 1 {name=p132127 lab=_41411_/X }
C {sky130_stdcells/buf_2.sym} 133260 -31930 0 0 {name=X_41411_ }
C {devices/lab_pin.sym} 133170 -31810 0 0 {name=p132128 lab=_86984_/CLK }
C {devices/lab_pin.sym} 133170 -31790 0 0 {name=p132129 lab=_44674_/Y }
C {devices/lab_pin.sym} 133350 -31810 0 1 {name=p132130 lab=_87005_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -31800 0 0 {name=X_87005_ }
C {devices/lab_pin.sym} 133180 -31690 0 0 {name=p132131 lab=_72227_/Y }
C {devices/lab_pin.sym} 133180 -31650 0 0 {name=p132132 lab=_72230_/Y }
C {devices/lab_pin.sym} 133180 -31610 0 0 {name=p132133 lab=_72185_/X }
C {devices/lab_pin.sym} 133340 -31650 0 1 {name=p132134 lab=_72231_/X }
C {sky130_stdcells/a21o_4.sym} 133260 -31650 0 0 {name=X_72231_ }
C {devices/lab_pin.sym} 133170 -31510 0 0 {name=p132135 lab=_81227_/CLK }
C {devices/lab_pin.sym} 133170 -31490 0 0 {name=p132136 lab=_65048_/X }
C {devices/lab_pin.sym} 133350 -31510 0 1 {name=p132137 lab=_84217_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -31500 0 0 {name=X_84217_ }
C {devices/lab_pin.sym} 133220 -31370 0 0 {name=p132138 lab=_50551_/A }
C {devices/lab_pin.sym} 133300 -31370 0 1 {name=p132139 lab=_50609_/X }
C {sky130_stdcells/buf_2.sym} 133260 -31370 0 0 {name=X_50609_ }
C {devices/lab_pin.sym} 133180 -31280 0 0 {name=p132140 lab=_57010_/Y }
C {devices/lab_pin.sym} 133180 -31240 0 0 {name=p132141 lab=_57163_/Y }
C {devices/lab_pin.sym} 133180 -31200 0 0 {name=p132142 lab=_57164_/X }
C {devices/lab_pin.sym} 133180 -31160 0 0 {name=p132143 lab=_57126_/A }
C {devices/lab_pin.sym} 133340 -31220 0 1 {name=p132144 lab=_57165_/X }
C {sky130_stdcells/a211o_4.sym} 133260 -31220 0 0 {name=X_57165_ }
C {devices/lab_pin.sym} 133170 -31070 0 0 {name=p132145 lab=_84049_/CLK }
C {devices/lab_pin.sym} 133170 -31050 0 0 {name=p132146 lab=_81461_/Q }
C {devices/lab_pin.sym} 133350 -31070 0 1 {name=p132147 lab=_76056_/B }
C {sky130_stdcells/dfxtp_4.sym} 133260 -31060 0 0 {name=X_81429_ }
C {devices/lab_pin.sym} 133220 -30930 0 0 {name=p132148 lab=_54322_/A }
C {devices/lab_pin.sym} 133300 -30930 0 1 {name=p132149 lab=_54378_/A }
C {sky130_stdcells/buf_2.sym} 133260 -30930 0 0 {name=X_54377_ }
C {devices/lab_pin.sym} 133180 -30850 0 0 {name=p132150 lab=_42378_/X }
C {devices/lab_pin.sym} 133180 -30810 0 0 {name=p132151 lab=_42369_/X }
C {devices/lab_pin.sym} 133180 -30770 0 0 {name=p132152 lab=_40395_/X }
C {devices/lab_pin.sym} 133180 -30730 0 0 {name=p132153 lab=_87886_/Q }
C {devices/lab_pin.sym} 133180 -30690 0 0 {name=p132154 lab=_42370_/X }
C {devices/lab_pin.sym} 133340 -30770 0 1 {name=p132155 lab=_42392_/A }
C {sky130_stdcells/o32ai_4.sym} 133260 -30770 0 0 {name=X_42391_ }
C {devices/lab_pin.sym} 133170 -30610 0 0 {name=p132156 lab=_85257_/CLK }
C {devices/lab_pin.sym} 133170 -30590 0 0 {name=p132157 lab=_56430_/Y }
C {devices/lab_pin.sym} 133350 -30610 0 1 {name=p132158 lab=_85197_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -30600 0 0 {name=X_85197_ }
C {devices/lab_pin.sym} 133180 -30490 0 0 {name=p132159 lab=_51583_/Y }
C {devices/lab_pin.sym} 133180 -30450 0 0 {name=p132160 lab=_51585_/X }
C {devices/lab_pin.sym} 133180 -30410 0 0 {name=p132161 lab=_51588_/X }
C {devices/lab_pin.sym} 133340 -30450 0 1 {name=p132162 lab=_85983_/D }
C {sky130_stdcells/a21oi_4.sym} 133260 -30450 0 0 {name=X_51589_ }
C {devices/lab_pin.sym} 133220 -30310 0 0 {name=p132163 lab=_73284_/A }
C {devices/lab_pin.sym} 133300 -30310 0 1 {name=p132164 lab=_44130_/X }
C {sky130_stdcells/buf_2.sym} 133260 -30310 0 0 {name=X_44130_ }
C {devices/lab_pin.sym} 133180 -30210 0 0 {name=p132165 lab=_56112_/X }
C {devices/lab_pin.sym} 133180 -30170 0 0 {name=p132166 lab=_56114_/X }
C {devices/lab_pin.sym} 133180 -30130 0 0 {name=p132167 lab=_56115_/Y }
C {devices/lab_pin.sym} 133340 -30170 0 1 {name=p132168 lab=_85293_/D }
C {sky130_stdcells/o21ai_4.sym} 133260 -30170 0 0 {name=X_56116_ }
C {devices/lab_pin.sym} 133220 -30030 0 0 {name=p132169 lab=_53355_/A }
C {devices/lab_pin.sym} 133300 -30030 0 1 {name=p132170 lab=_53328_/X }
C {sky130_stdcells/buf_2.sym} 133260 -30030 0 0 {name=X_53328_ }
C {devices/lab_pin.sym} 133180 -29950 0 0 {name=p132171 lab=_41337_/X }
C {devices/lab_pin.sym} 133180 -29910 0 0 {name=p132172 lab=_41338_/X }
C {devices/lab_pin.sym} 133180 -29870 0 0 {name=p132173 lab=_41341_/X }
C {devices/lab_pin.sym} 133180 -29830 0 0 {name=p132174 lab=_88233_/Q }
C {devices/lab_pin.sym} 133180 -29790 0 0 {name=p132175 lab=_41333_/X }
C {devices/lab_pin.sym} 133340 -29870 0 1 {name=p132176 lab=_41343_/A }
C {sky130_stdcells/o32ai_4.sym} 133260 -29870 0 0 {name=X_41342_ }
C {devices/lab_pin.sym} 133200 -29720 0 0 {name=p132177 lab=_72162_/A }
C {devices/lab_pin.sym} 133200 -29680 0 0 {name=p132178 lab=_72162_/B }
C {devices/lab_pin.sym} 133320 -29700 0 1 {name=p132179 lab=_72162_/Y }
C {sky130_stdcells/nor2_4.sym} 133260 -29700 0 0 {name=X_72162_ }
C {devices/lab_pin.sym} 133170 -29570 0 0 {name=p132180 lab=_82746_/CLK }
C {devices/lab_pin.sym} 133170 -29550 0 0 {name=p132181 lab=_66219_/X }
C {devices/lab_pin.sym} 133350 -29570 0 1 {name=p132182 lab=_84148_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -29560 0 0 {name=X_84148_ }
C {devices/lab_pin.sym} 133220 -29430 0 0 {name=p132183 lab=_44236_/X }
C {devices/lab_pin.sym} 133300 -29430 0 1 {name=p132184 lab=_57096_/Y }
C {sky130_stdcells/inv_2.sym} 133260 -29430 0 0 {name=X_57096_ }
C {devices/lab_pin.sym} 133200 -29330 0 0 {name=p132185 lab=_71112_/X }
C {devices/lab_pin.sym} 133200 -29290 0 0 {name=p132186 lab=_71091_/B }
C {devices/lab_pin.sym} 133200 -29250 0 0 {name=p132187 lab=_70890_/D }
C {devices/lab_pin.sym} 133320 -29290 0 1 {name=p132188 lab=_71113_/Y }
C {sky130_stdcells/nand3_4.sym} 133260 -29290 0 0 {name=X_71113_ }
C {devices/lab_pin.sym} 133220 -29150 0 0 {name=p132189 lab=_44060_/X }
C {devices/lab_pin.sym} 133300 -29150 0 1 {name=p132190 lab=_44061_/X }
C {sky130_stdcells/buf_2.sym} 133260 -29150 0 0 {name=X_44061_ }
C {devices/lab_pin.sym} 133220 -29030 0 0 {name=p132191 lab=_74306_/C }
C {devices/lab_pin.sym} 133300 -29030 0 1 {name=p132192 lab=_56047_/Y }
C {sky130_stdcells/inv_2.sym} 133260 -29030 0 0 {name=X_56047_ }
C {devices/lab_pin.sym} 133180 -28940 0 0 {name=p132193 lab=_41272_/X }
C {devices/lab_pin.sym} 133180 -28900 0 0 {name=p132194 lab=_41251_/X }
C {devices/lab_pin.sym} 133180 -28860 0 0 {name=p132195 lab=_88246_/Q }
C {devices/lab_pin.sym} 133180 -28820 0 0 {name=p132196 lab=_41253_/X }
C {devices/lab_pin.sym} 133340 -28880 0 1 {name=p132197 lab=_41273_/X }
C {sky130_stdcells/a2bb2o_4.sym} 133260 -28880 0 0 {name=X_41273_ }
C {devices/lab_pin.sym} 133200 -28740 0 0 {name=p132198 lab=_53259_/A }
C {devices/lab_pin.sym} 133200 -28700 0 0 {name=p132199 lab=_53259_/B }
C {devices/lab_pin.sym} 133320 -28720 0 1 {name=p132200 lab=_53259_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -28720 0 0 {name=X_53259_ }
C {devices/lab_pin.sym} 133180 -28610 0 0 {name=p132201 lab=_83286_/Q }
C {devices/lab_pin.sym} 133180 -28570 0 0 {name=p132202 lab=_72090_/X }
C {devices/lab_pin.sym} 133180 -28530 0 0 {name=p132203 lab=_72092_/Y }
C {devices/lab_pin.sym} 133340 -28570 0 1 {name=p132204 lab=_72093_/Y }
C {sky130_stdcells/o21ai_4.sym} 133260 -28570 0 0 {name=X_72093_ }
C {devices/lab_pin.sym} 133200 -28440 0 0 {name=p132205 lab=_84522_/Q }
C {devices/lab_pin.sym} 133200 -28400 0 0 {name=p132206 lab=_62636_/C }
C {devices/lab_pin.sym} 133320 -28420 0 1 {name=p132207 lab=_76970_/X }
C {sky130_stdcells/xor2_4.sym} 133260 -28420 0 0 {name=X_76970_ }
C {devices/lab_pin.sym} 133170 -28290 0 0 {name=p132208 lab=_84079_/CLK }
C {devices/lab_pin.sym} 133170 -28270 0 0 {name=p132209 lab=_67210_/X }
C {devices/lab_pin.sym} 133350 -28290 0 1 {name=p132210 lab=_80903_/D }
C {sky130_stdcells/dfxtp_4.sym} 133260 -28280 0 0 {name=X_84079_ }
C {devices/lab_pin.sym} 133200 -28160 0 0 {name=p132211 lab=_41863_/A }
C {devices/lab_pin.sym} 133200 -28120 0 0 {name=p132212 lab=_43012_/B }
C {devices/lab_pin.sym} 133320 -28140 0 1 {name=p132213 lab=_43175_/C }
C {sky130_stdcells/nor2_4.sym} 133260 -28140 0 0 {name=X_43012_ }
C {devices/lab_pin.sym} 133180 -28030 0 0 {name=p132214 lab=_53179_/B }
C {devices/lab_pin.sym} 133180 -27990 0 0 {name=p132215 lab=_71013_/A }
C {devices/lab_pin.sym} 133180 -27950 0 0 {name=p132216 lab=_71043_/Y }
C {devices/lab_pin.sym} 133340 -27990 0 1 {name=p132217 lab=_71044_/Y }
C {sky130_stdcells/o21ai_4.sym} 133260 -27990 0 0 {name=X_71044_ }
C {devices/lab_pin.sym} 133200 -27860 0 0 {name=p132218 lab=_61132_/C }
C {devices/lab_pin.sym} 133200 -27820 0 0 {name=p132219 lab=_84391_/Q }
C {devices/lab_pin.sym} 133320 -27840 0 1 {name=p132220 lab=_80735_/D }
C {sky130_stdcells/xor2_4.sym} 133260 -27840 0 0 {name=X_75921_ }
C {devices/lab_pin.sym} 133170 -27710 0 0 {name=p132221 lab=_87394_/CLK }
C {devices/lab_pin.sym} 133170 -27690 0 0 {name=p132222 lab=_87907_/D }
C {devices/lab_pin.sym} 133350 -27710 0 1 {name=p132223 lab=_87907_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -27700 0 0 {name=X_87907_ }
C {devices/lab_pin.sym} 133220 -27570 0 0 {name=p132224 lab=clkbuf_9_406_0_CLK/X }
C {devices/lab_pin.sym} 133300 -27570 0 1 {name=p132225 lab=_82855_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 133260 -27570 0 0 {name=Xclkbuf_10_813_0_CLK }
C {devices/lab_pin.sym} 133180 -27470 0 0 {name=p132226 lab=_72476_/A }
C {devices/lab_pin.sym} 133180 -27430 0 0 {name=p132227 lab=_47806_/X }
C {devices/lab_pin.sym} 133180 -27390 0 0 {name=p132228 lab=_47819_/Y }
C {devices/lab_pin.sym} 133340 -27430 0 1 {name=p132229 lab=_47820_/Y }
C {sky130_stdcells/o21ai_4.sym} 133260 -27430 0 0 {name=X_47820_ }
C {devices/lab_pin.sym} 133200 -27310 0 0 {name=p132230 lab=_59806_/A }
C {devices/lab_pin.sym} 133200 -27270 0 0 {name=p132231 lab=_59721_/A }
C {devices/lab_pin.sym} 133200 -27230 0 0 {name=p132232 lab=_59722_/A }
C {devices/lab_pin.sym} 133320 -27270 0 1 {name=p132233 lab=_59807_/A }
C {sky130_stdcells/and3_4.sym} 133260 -27270 0 0 {name=X_59806_ }
C {devices/lab_pin.sym} 133200 -27160 0 0 {name=p132234 lab=_78640_/A }
C {devices/lab_pin.sym} 133200 -27120 0 0 {name=p132235 lab=_78640_/B }
C {devices/lab_pin.sym} 133200 -27080 0 0 {name=p132236 lab=_78640_/C }
C {devices/lab_pin.sym} 133200 -27040 0 0 {name=p132237 lab=_78621_/Y }
C {devices/lab_pin.sym} 133320 -27100 0 1 {name=p132238 lab=_78640_/X }
C {sky130_stdcells/and4_4.sym} 133260 -27100 0 0 {name=X_78640_ }
C {devices/lab_pin.sym} 133200 -26960 0 0 {name=p132239 lab=_75852_/A }
C {devices/lab_pin.sym} 133200 -26920 0 0 {name=p132240 lab=_75867_/A }
C {devices/lab_pin.sym} 133320 -26940 0 1 {name=p132241 lab=_75860_/A }
C {sky130_stdcells/xnor2_4.sym} 133260 -26940 0 0 {name=X_75852_ }
C {devices/lab_pin.sym} 133170 -26810 0 0 {name=p132242 lab=_87850_/CLK }
C {devices/lab_pin.sym} 133170 -26790 0 0 {name=p132243 lab=_42514_/Y }
C {devices/lab_pin.sym} 133350 -26810 0 1 {name=p132244 lab=_87838_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -26800 0 0 {name=X_87838_ }
C {devices/lab_pin.sym} 133220 -26670 0 0 {name=p132245 lab=clkbuf_8_152_0_CLK/X }
C {devices/lab_pin.sym} 133300 -26670 0 1 {name=p132246 lab=clkbuf_9_304_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 133260 -26670 0 0 {name=Xclkbuf_9_304_0_CLK }
C {devices/lab_pin.sym} 133180 -26570 0 0 {name=p132247 lab=_57997_/X }
C {devices/lab_pin.sym} 133180 -26530 0 0 {name=p132248 lab=_85485_/Q }
C {devices/lab_pin.sym} 133180 -26490 0 0 {name=p132249 lab=_57923_/X }
C {devices/lab_pin.sym} 133340 -26530 0 1 {name=p132250 lab=_57998_/X }
C {sky130_stdcells/o21a_4.sym} 133260 -26530 0 0 {name=X_57998_ }
C {devices/lab_pin.sym} 133200 -26410 0 0 {name=p132251 lab=_74741_/X }
C {devices/lab_pin.sym} 133200 -26370 0 0 {name=p132252 lab=_74798_/X }
C {devices/lab_pin.sym} 133200 -26330 0 0 {name=p132253 lab=_74802_/Y }
C {devices/lab_pin.sym} 133320 -26370 0 1 {name=p132254 lab=_74803_/Y }
C {sky130_stdcells/nand3_4.sym} 133260 -26370 0 0 {name=X_74803_ }
C {devices/lab_pin.sym} 133220 -26230 0 0 {name=p132255 lab=_47751_/A }
C {devices/lab_pin.sym} 133300 -26230 0 1 {name=p132256 lab=_47752_/A }
C {sky130_stdcells/inv_2.sym} 133260 -26230 0 0 {name=X_47751_ }
C {devices/lab_pin.sym} 133200 -26130 0 0 {name=p132257 lab=_59737_/A }
C {devices/lab_pin.sym} 133200 -26090 0 0 {name=p132258 lab=_59711_/B }
C {devices/lab_pin.sym} 133200 -26050 0 0 {name=p132259 lab=_80548_/A }
C {devices/lab_pin.sym} 133320 -26090 0 1 {name=p132260 lab=_59737_/Y }
C {sky130_stdcells/nor3_4.sym} 133260 -26090 0 0 {name=X_59737_ }
C {devices/lab_pin.sym} 133180 -25970 0 0 {name=p132261 lab=_78552_/Y }
C {devices/lab_pin.sym} 133180 -25930 0 0 {name=p132262 lab=_78554_/A }
C {devices/lab_pin.sym} 133180 -25890 0 0 {name=p132263 lab=_78551_/A }
C {devices/lab_pin.sym} 133340 -25930 0 1 {name=p132264 lab=_78572_/A }
C {sky130_stdcells/o21a_4.sym} 133260 -25930 0 0 {name=X_78571_ }
C {devices/lab_pin.sym} 133220 -25790 0 0 {name=p132265 lab=_44895_/X }
C {devices/lab_pin.sym} 133300 -25790 0 1 {name=p132266 lab=_44963_/X }
C {sky130_stdcells/buf_2.sym} 133260 -25790 0 0 {name=X_44963_ }
C {devices/lab_pin.sym} 133220 -25670 0 0 {name=p132267 lab=_44213_/X }
C {devices/lab_pin.sym} 133300 -25670 0 1 {name=p132268 lab=_56949_/X }
C {sky130_stdcells/buf_2.sym} 133260 -25670 0 0 {name=X_56949_ }
C {devices/lab_pin.sym} 133180 -25570 0 0 {name=p132269 lab=_80920_/Q }
C {devices/lab_pin.sym} 133180 -25530 0 0 {name=p132270 lab=_75781_/Y }
C {devices/lab_pin.sym} 133180 -25490 0 0 {name=p132271 lab=_75782_/Y }
C {devices/lab_pin.sym} 133340 -25530 0 1 {name=p132272 lab=_75783_/Y }
C {sky130_stdcells/a21oi_4.sym} 133260 -25530 0 0 {name=X_75783_ }
C {devices/lab_pin.sym} 133170 -25390 0 0 {name=p132273 lab=_87520_/CLK }
C {devices/lab_pin.sym} 133170 -25370 0 0 {name=p132274 lab=_87769_/D }
C {devices/lab_pin.sym} 133350 -25390 0 1 {name=p132275 lab=_87769_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -25380 0 0 {name=X_87769_ }
C {devices/lab_pin.sym} 133200 -25260 0 0 {name=p132276 lab=_72995_/A }
C {devices/lab_pin.sym} 133200 -25220 0 0 {name=p132277 lab=_72994_/X }
C {devices/lab_pin.sym} 133320 -25240 0 1 {name=p132278 lab=_72996_/B }
C {sky130_stdcells/nand2_4.sym} 133260 -25240 0 0 {name=X_72995_ }
C {devices/lab_pin.sym} 133200 -25120 0 0 {name=p132279 lab=_46712_/A }
C {devices/lab_pin.sym} 133200 -25080 0 0 {name=p132280 lab=_46701_/X }
C {devices/lab_pin.sym} 133320 -25100 0 1 {name=p132281 lab=_46702_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -25100 0 0 {name=X_46702_ }
C {devices/lab_pin.sym} 133220 -24970 0 0 {name=p132282 lab=_77521_/Y }
C {devices/lab_pin.sym} 133300 -24970 0 1 {name=p132283 lab=_77522_/Y }
C {sky130_stdcells/inv_2.sym} 133260 -24970 0 0 {name=X_77522_ }
C {devices/lab_pin.sym} 133220 -24850 0 0 {name=p132284 lab=clkbuf_9_414_0_CLK/X }
C {devices/lab_pin.sym} 133300 -24850 0 1 {name=p132285 lab=_82925_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 133260 -24850 0 0 {name=Xclkbuf_10_828_0_CLK }
C {devices/lab_pin.sym} 133180 -24770 0 0 {name=p132286 lab=_43895_/X }
C {devices/lab_pin.sym} 133180 -24730 0 0 {name=p132287 lab=_43902_/X }
C {devices/lab_pin.sym} 133180 -24690 0 0 {name=p132288 lab=_41382_/X }
C {devices/lab_pin.sym} 133180 -24650 0 0 {name=p132289 lab=_87201_/Q }
C {devices/lab_pin.sym} 133180 -24610 0 0 {name=p132290 lab=_43897_/X }
C {devices/lab_pin.sym} 133340 -24690 0 1 {name=p132291 lab=_43914_/Y }
C {sky130_stdcells/o32ai_4.sym} 133260 -24690 0 0 {name=X_43914_ }
C {devices/lab_pin.sym} 133220 -24530 0 0 {name=p132292 lab=_70669_/A }
C {devices/lab_pin.sym} 133300 -24530 0 1 {name=p132293 lab=_74734_/Y }
C {sky130_stdcells/inv_2.sym} 133260 -24530 0 0 {name=X_74734_ }
C {devices/lab_pin.sym} 133220 -24410 0 0 {name=p132294 lab=_81233_/Q }
C {devices/lab_pin.sym} 133300 -24410 0 1 {name=p132295 lab=_47682_/Y }
C {sky130_stdcells/inv_2.sym} 133260 -24410 0 0 {name=X_47682_ }
C {devices/lab_pin.sym} 133180 -24310 0 0 {name=p132296 lab=_55671_/Y }
C {devices/lab_pin.sym} 133180 -24270 0 0 {name=p132297 lab=_71939_/X }
C {devices/lab_pin.sym} 133180 -24230 0 0 {name=p132298 lab=_71945_/Y }
C {devices/lab_pin.sym} 133340 -24270 0 1 {name=p132299 lab=_83319_/D }
C {sky130_stdcells/o21ai_4.sym} 133260 -24270 0 0 {name=X_71946_ }
C {devices/lab_pin.sym} 133200 -24140 0 0 {name=p132300 lab=_59588_/Y }
C {devices/lab_pin.sym} 133200 -24100 0 0 {name=p132301 lab=_59668_/B }
C {devices/lab_pin.sym} 133320 -24120 0 1 {name=p132302 lab=_59763_/A }
C {sky130_stdcells/nand2_4.sym} 133260 -24120 0 0 {name=X_59668_ }
C {devices/lab_pin.sym} 133200 -24000 0 0 {name=p132303 lab=_74541_/C }
C {devices/lab_pin.sym} 133200 -23960 0 0 {name=p132304 lab=_44894_/B }
C {devices/lab_pin.sym} 133320 -23980 0 1 {name=p132305 lab=_44894_/Y }
C {sky130_stdcells/nor2_4.sym} 133260 -23980 0 0 {name=X_44894_ }
C {devices/lab_pin.sym} 133180 -23870 0 0 {name=p132306 lab=_49419_/Y }
C {devices/lab_pin.sym} 133180 -23830 0 0 {name=p132307 lab=_49405_/X }
C {devices/lab_pin.sym} 133180 -23790 0 0 {name=p132308 lab=_49420_/X }
C {devices/lab_pin.sym} 133340 -23830 0 1 {name=p132309 lab=_86391_/D }
C {sky130_stdcells/a21oi_4.sym} 133260 -23830 0 0 {name=X_49421_ }
C {devices/lab_pin.sym} 133220 -23690 0 0 {name=p132310 lab=_83687_/Q }
C {devices/lab_pin.sym} 133300 -23690 0 1 {name=p132311 lab=_54277_/B }
C {sky130_stdcells/inv_2.sym} 133260 -23690 0 0 {name=X_46633_ }
C {devices/lab_pin.sym} 133180 -23590 0 0 {name=p132312 lab=_58571_/X }
C {devices/lab_pin.sym} 133180 -23550 0 0 {name=p132313 lab=_85789_/Q }
C {devices/lab_pin.sym} 133180 -23510 0 0 {name=p132314 lab=_58594_/X }
C {devices/lab_pin.sym} 133340 -23550 0 1 {name=p132315 lab=_58619_/X }
C {sky130_stdcells/o21a_4.sym} 133260 -23550 0 0 {name=X_58619_ }
C {devices/lab_pin.sym} 133200 -23420 0 0 {name=p132316 lab=_77453_/A }
C {devices/lab_pin.sym} 133200 -23380 0 0 {name=p132317 lab=_82193_/D }
C {devices/lab_pin.sym} 133320 -23400 0 1 {name=p132318 lab=_77453_/X }
C {sky130_stdcells/xor2_4.sym} 133260 -23400 0 0 {name=X_77453_ }
C {devices/lab_pin.sym} 133220 -23270 0 0 {name=p132319 lab=clkbuf_9_318_0_CLK/A }
C {devices/lab_pin.sym} 133300 -23270 0 1 {name=p132320 lab=clkbuf_9_319_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 133260 -23270 0 0 {name=Xclkbuf_9_319_0_CLK }
C {devices/lab_pin.sym} 133180 -23180 0 0 {name=p132321 lab=_41189_/X }
C {devices/lab_pin.sym} 133180 -23140 0 0 {name=p132322 lab=_43842_/X }
C {devices/lab_pin.sym} 133180 -23100 0 0 {name=p132323 lab=_68718_/B }
C {devices/lab_pin.sym} 133180 -23060 0 0 {name=p132324 lab=_43843_/X }
C {devices/lab_pin.sym} 133340 -23120 0 1 {name=p132325 lab=_87237_/D }
C {sky130_stdcells/a2bb2o_4.sym} 133260 -23120 0 0 {name=X_43845_ }
C {devices/lab_pin.sym} 133220 -22970 0 0 {name=p132326 lab=_74694_/A }
C {devices/lab_pin.sym} 133300 -22970 0 1 {name=p132327 lab=_74673_/A }
C {sky130_stdcells/buf_2.sym} 133260 -22970 0 0 {name=X_74665_ }
C {devices/lab_pin.sym} 133180 -22870 0 0 {name=p132328 lab=_71871_/X }
C {devices/lab_pin.sym} 133180 -22830 0 0 {name=p132329 lab=_83344_/Q }
C {devices/lab_pin.sym} 133180 -22790 0 0 {name=p132330 lab=_71876_/Y }
C {devices/lab_pin.sym} 133340 -22830 0 1 {name=p132331 lab=_71877_/X }
C {sky130_stdcells/a21o_4.sym} 133260 -22830 0 0 {name=X_71877_ }
C {devices/lab_pin.sym} 133200 -22700 0 0 {name=p132332 lab=_60630_/A }
C {devices/lab_pin.sym} 133200 -22660 0 0 {name=p132333 lab=_60630_/C }
C {devices/lab_pin.sym} 133320 -22680 0 1 {name=p132334 lab=_60636_/B }
C {sky130_stdcells/and2_4.sym} 133260 -22680 0 0 {name=X_59599_ }
C {devices/lab_pin.sym} 133180 -22570 0 0 {name=p132335 lab=_76368_/A }
C {devices/lab_pin.sym} 133180 -22530 0 0 {name=p132336 lab=_76369_/X }
C {devices/lab_pin.sym} 133180 -22490 0 0 {name=p132337 lab=_76379_/X }
C {devices/lab_pin.sym} 133340 -22530 0 1 {name=p132338 lab=_76404_/X }
C {sky130_stdcells/a21o_4.sym} 133260 -22530 0 0 {name=X_76404_ }
C {devices/lab_pin.sym} 133200 -22400 0 0 {name=p132339 lab=_49352_/A }
C {devices/lab_pin.sym} 133200 -22360 0 0 {name=p132340 lab=_51389_/B }
C {devices/lab_pin.sym} 133320 -22380 0 1 {name=p132341 lab=_49352_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -22380 0 0 {name=X_49352_ }
C {devices/lab_pin.sym} 133200 -22280 0 0 {name=p132342 lab=_61630_/A }
C {devices/lab_pin.sym} 133200 -22240 0 0 {name=p132343 lab=_61611_/B }
C {devices/lab_pin.sym} 133200 -22200 0 0 {name=p132344 lab=_61611_/C }
C {devices/lab_pin.sym} 133200 -22160 0 0 {name=p132345 lab=_61572_/D }
C {devices/lab_pin.sym} 133320 -22220 0 1 {name=p132346 lab=_61630_/Y }
C {sky130_stdcells/nand4_4.sym} 133260 -22220 0 0 {name=X_61630_ }
C {devices/lab_pin.sym} 133200 -22080 0 0 {name=p132347 lab=_73641_/A }
C {devices/lab_pin.sym} 133200 -22040 0 0 {name=p132348 lab=_65939_/B }
C {devices/lab_pin.sym} 133320 -22060 0 1 {name=p132349 lab=_73616_/X }
C {sky130_stdcells/and2_4.sym} 133260 -22060 0 0 {name=X_73616_ }
C {devices/lab_pin.sym} 133220 -21930 0 0 {name=p132350 lab=_54077_/B }
C {devices/lab_pin.sym} 133300 -21930 0 1 {name=p132351 lab=_51378_/B }
C {sky130_stdcells/buf_2.sym} 133260 -21930 0 0 {name=X_46564_ }
C {devices/lab_pin.sym} 133220 -21810 0 0 {name=p132352 lab=_70828_/A }
C {devices/lab_pin.sym} 133300 -21810 0 1 {name=p132353 lab=_70832_/A }
C {sky130_stdcells/buf_2.sym} 133260 -21810 0 0 {name=X_70828_ }
C {devices/lab_pin.sym} 133200 -21700 0 0 {name=p132354 lab=_77382_/X }
C {devices/lab_pin.sym} 133200 -21660 0 0 {name=p132355 lab=_77383_/Y }
C {devices/lab_pin.sym} 133320 -21680 0 1 {name=p132356 lab=_77385_/A }
C {sky130_stdcells/and2_4.sym} 133260 -21680 0 0 {name=X_77384_ }
C {devices/lab_pin.sym} 133220 -21550 0 0 {name=p132357 lab=_43776_/A }
C {devices/lab_pin.sym} 133300 -21550 0 1 {name=p132358 lab=_43776_/X }
C {sky130_stdcells/buf_2.sym} 133260 -21550 0 0 {name=X_43776_ }
C {devices/lab_pin.sym} 133180 -21460 0 0 {name=p132359 lab=_74591_/X }
C {devices/lab_pin.sym} 133180 -21420 0 0 {name=p132360 lab=_74583_/X }
C {devices/lab_pin.sym} 133180 -21380 0 0 {name=p132361 lab=_56114_/A }
C {devices/lab_pin.sym} 133180 -21340 0 0 {name=p132362 lab=_74584_/X }
C {devices/lab_pin.sym} 133340 -21400 0 1 {name=p132363 lab=_74596_/X }
C {sky130_stdcells/a211o_4.sym} 133260 -21400 0 0 {name=X_74596_ }
C {devices/lab_pin.sym} 133220 -21250 0 0 {name=p132364 lab=_40755_/A }
C {devices/lab_pin.sym} 133300 -21250 0 1 {name=p132365 lab=_40989_/A }
C {sky130_stdcells/buf_2.sym} 133260 -21250 0 0 {name=X_40988_ }
C {devices/lab_pin.sym} 133200 -21150 0 0 {name=p132366 lab=_52050_/A }
C {devices/lab_pin.sym} 133200 -21110 0 0 {name=p132367 lab=_48286_/X }
C {devices/lab_pin.sym} 133200 -21070 0 0 {name=p132368 lab=_48287_/C }
C {devices/lab_pin.sym} 133320 -21110 0 1 {name=p132369 lab=_48303_/X }
C {sky130_stdcells/and3_4.sym} 133260 -21110 0 0 {name=X_48303_ }
C {devices/lab_pin.sym} 133200 -20980 0 0 {name=p132370 lab=_82836_/Q }
C {devices/lab_pin.sym} 133200 -20940 0 0 {name=p132371 lab=_79123_/B }
C {devices/lab_pin.sym} 133320 -20960 0 1 {name=p132372 lab=_79123_/Y }
C {sky130_stdcells/xnor2_4.sym} 133260 -20960 0 0 {name=X_79123_ }
C {devices/lab_pin.sym} 133220 -20830 0 0 {name=p132373 lab=_57113_/B }
C {devices/lab_pin.sym} 133300 -20830 0 1 {name=p132374 lab=_45515_/Y }
C {sky130_stdcells/inv_2.sym} 133260 -20830 0 0 {name=X_45515_ }
C {devices/lab_pin.sym} 133220 -20710 0 0 {name=p132375 lab=clkbuf_4_2_1_CLK/X }
C {devices/lab_pin.sym} 133300 -20710 0 1 {name=p132376 lab=clkbuf_6_9_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 133260 -20710 0 0 {name=Xclkbuf_5_4_0_CLK }
C {devices/lab_pin.sym} 133180 -20610 0 0 {name=p132377 lab=_76331_/Y }
C {devices/lab_pin.sym} 133180 -20570 0 0 {name=p132378 lab=_76333_/Y }
C {devices/lab_pin.sym} 133180 -20530 0 0 {name=p132379 lab=_76330_/Y }
C {devices/lab_pin.sym} 133340 -20570 0 1 {name=p132380 lab=_76336_/B }
C {sky130_stdcells/o21ai_4.sym} 133260 -20570 0 0 {name=X_76335_ }
C {devices/lab_pin.sym} 133180 -20460 0 0 {name=p132381 lab=_41189_/X }
C {devices/lab_pin.sym} 133180 -20420 0 0 {name=p132382 lab=_42717_/X }
C {devices/lab_pin.sym} 133180 -20380 0 0 {name=p132383 lab=_87749_/Q }
C {devices/lab_pin.sym} 133180 -20340 0 0 {name=p132384 lab=_42718_/X }
C {devices/lab_pin.sym} 133340 -20400 0 1 {name=p132385 lab=_87749_/D }
C {sky130_stdcells/a2bb2o_4.sym} 133260 -20400 0 0 {name=X_42727_ }
C {devices/lab_pin.sym} 133200 -20270 0 0 {name=p132386 lab=_50802_/A }
C {devices/lab_pin.sym} 133200 -20230 0 0 {name=p132387 lab=_49283_/B }
C {devices/lab_pin.sym} 133200 -20190 0 0 {name=p132388 lab=_49234_/X }
C {devices/lab_pin.sym} 133320 -20230 0 1 {name=p132389 lab=_49283_/X }
C {sky130_stdcells/and3_4.sym} 133260 -20230 0 0 {name=X_49283_ }
C {devices/lab_pin.sym} 133180 -20110 0 0 {name=p132390 lab=_73544_/X }
C {devices/lab_pin.sym} 133180 -20070 0 0 {name=p132391 lab=_73545_/Y }
C {devices/lab_pin.sym} 133180 -20030 0 0 {name=p132392 lab=_73546_/X }
C {devices/lab_pin.sym} 133340 -20070 0 1 {name=p132393 lab=_73547_/Y }
C {sky130_stdcells/a21oi_4.sym} 133260 -20070 0 0 {name=X_73547_ }
C {devices/lab_pin.sym} 133200 -19960 0 0 {name=p132394 lab=_61561_/A }
C {devices/lab_pin.sym} 133200 -19920 0 0 {name=p132395 lab=_61542_/B }
C {devices/lab_pin.sym} 133200 -19880 0 0 {name=p132396 lab=_61542_/C }
C {devices/lab_pin.sym} 133200 -19840 0 0 {name=p132397 lab=_61512_/X }
C {devices/lab_pin.sym} 133320 -19900 0 1 {name=p132398 lab=_61561_/Y }
C {sky130_stdcells/nand4_4.sym} 133260 -19900 0 0 {name=X_61561_ }
C {devices/lab_pin.sym} 133220 -19750 0 0 {name=p132399 lab=_70764_/A }
C {devices/lab_pin.sym} 133300 -19750 0 1 {name=p132400 lab=_70760_/B }
C {sky130_stdcells/inv_2.sym} 133260 -19750 0 0 {name=X_70759_ }
C {devices/lab_pin.sym} 133200 -19640 0 0 {name=p132401 lab=_46505_/A }
C {devices/lab_pin.sym} 133200 -19600 0 0 {name=p132402 lab=_46495_/B }
C {devices/lab_pin.sym} 133320 -19620 0 1 {name=p132403 lab=_46495_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -19620 0 0 {name=X_46495_ }
C {devices/lab_pin.sym} 133200 -19510 0 0 {name=p132404 lab=_63272_/A }
C {devices/lab_pin.sym} 133200 -19470 0 0 {name=p132405 lab=_61640_/A }
C {devices/lab_pin.sym} 133200 -19430 0 0 {name=p132406 lab=_63280_/C }
C {devices/lab_pin.sym} 133320 -19470 0 1 {name=p132407 lab=_63300_/Y }
C {sky130_stdcells/nand3_4.sym} 133260 -19470 0 0 {name=X_63300_ }
C {devices/lab_pin.sym} 133200 -19350 0 0 {name=p132408 lab=_48234_/A }
C {devices/lab_pin.sym} 133200 -19310 0 0 {name=p132409 lab=_48201_/B }
C {devices/lab_pin.sym} 133200 -19270 0 0 {name=p132410 lab=_48195_/X }
C {devices/lab_pin.sym} 133320 -19310 0 1 {name=p132411 lab=_48234_/X }
C {sky130_stdcells/and3_4.sym} 133260 -19310 0 0 {name=X_48234_ }
C {devices/lab_pin.sym} 133220 -19170 0 0 {name=p132412 lab=_60512_/A }
C {devices/lab_pin.sym} 133300 -19170 0 1 {name=p132413 lab=_60512_/Y }
C {sky130_stdcells/inv_2.sym} 133260 -19170 0 0 {name=X_60512_ }
C {devices/lab_pin.sym} 133220 -19050 0 0 {name=p132414 lab=_79054_/A }
C {devices/lab_pin.sym} 133300 -19050 0 1 {name=p132415 lab=_79055_/B }
C {sky130_stdcells/inv_2.sym} 133260 -19050 0 0 {name=X_79054_ }
C {devices/lab_pin.sym} 133220 -18930 0 0 {name=p132416 lab=_45678_/A }
C {devices/lab_pin.sym} 133300 -18930 0 1 {name=p132417 lab=_45446_/X }
C {sky130_stdcells/buf_2.sym} 133260 -18930 0 0 {name=X_45446_ }
C {devices/lab_pin.sym} 133180 -18830 0 0 {name=p132418 lab=_64272_/Y }
C {devices/lab_pin.sym} 133180 -18790 0 0 {name=p132419 lab=_64279_/X }
C {devices/lab_pin.sym} 133180 -18750 0 0 {name=p132420 lab=_64269_/X }
C {devices/lab_pin.sym} 133340 -18790 0 1 {name=p132421 lab=_64280_/X }
C {sky130_stdcells/o21a_4.sym} 133260 -18790 0 0 {name=X_64280_ }
C {devices/lab_pin.sym} 133200 -18670 0 0 {name=p132422 lab=_76261_/X }
C {devices/lab_pin.sym} 133200 -18630 0 0 {name=p132423 lab=_76264_/Y }
C {devices/lab_pin.sym} 133200 -18590 0 0 {name=p132424 lab=_76262_/Y }
C {devices/lab_pin.sym} 133320 -18630 0 1 {name=p132425 lab=_76267_/B }
C {sky130_stdcells/nand3_4.sym} 133260 -18630 0 0 {name=X_76266_ }
C {devices/lab_pin.sym} 133220 -18490 0 0 {name=p132426 lab=_42580_/A }
C {devices/lab_pin.sym} 133300 -18490 0 1 {name=p132427 lab=_42658_/X }
C {sky130_stdcells/buf_2.sym} 133260 -18490 0 0 {name=X_42658_ }
C {devices/lab_pin.sym} 133200 -18400 0 0 {name=p132428 lab=_61492_/A }
C {devices/lab_pin.sym} 133200 -18360 0 0 {name=p132429 lab=_61468_/B }
C {devices/lab_pin.sym} 133200 -18320 0 0 {name=p132430 lab=_61467_/X }
C {devices/lab_pin.sym} 133200 -18280 0 0 {name=p132431 lab=_61451_/D }
C {devices/lab_pin.sym} 133320 -18340 0 1 {name=p132432 lab=_61492_/Y }
C {sky130_stdcells/nand4_4.sym} 133260 -18340 0 0 {name=X_61492_ }
C {devices/lab_pin.sym} 133200 -18200 0 0 {name=p132433 lab=_73478_/A }
C {devices/lab_pin.sym} 133200 -18160 0 0 {name=p132434 lab=_73477_/X }
C {devices/lab_pin.sym} 133320 -18180 0 1 {name=p132435 lab=_73478_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -18180 0 0 {name=X_73478_ }
C {devices/lab_pin.sym} 133200 -18060 0 0 {name=p132436 lab=_78003_/Y }
C {devices/lab_pin.sym} 133200 -18020 0 0 {name=p132437 lab=_78004_/Y }
C {devices/lab_pin.sym} 133320 -18040 0 1 {name=p132438 lab=_78007_/A }
C {sky130_stdcells/nand2_4.sym} 133260 -18040 0 0 {name=X_78005_ }
C {devices/lab_pin.sym} 133220 -17910 0 0 {name=p132439 lab=_63231_/A }
C {devices/lab_pin.sym} 133300 -17910 0 1 {name=p132440 lab=_63231_/X }
C {sky130_stdcells/buf_2.sym} 133260 -17910 0 0 {name=X_63231_ }
C {devices/lab_pin.sym} 133200 -17800 0 0 {name=p132441 lab=_75217_/A }
C {devices/lab_pin.sym} 133200 -17760 0 0 {name=p132442 lab=_75217_/B }
C {devices/lab_pin.sym} 133320 -17780 0 1 {name=p132443 lab=_75217_/Y }
C {sky130_stdcells/nor2_4.sym} 133260 -17780 0 0 {name=X_75217_ }
C {devices/lab_pin.sym} 133180 -17690 0 0 {name=p132444 lab=_41540_/X }
C {devices/lab_pin.sym} 133180 -17650 0 0 {name=p132445 lab=_41541_/X }
C {devices/lab_pin.sym} 133180 -17610 0 0 {name=p132446 lab=_41606_/X }
C {devices/lab_pin.sym} 133180 -17570 0 0 {name=p132447 lab=_88183_/Q }
C {devices/lab_pin.sym} 133180 -17530 0 0 {name=p132448 lab=_41608_/X }
C {devices/lab_pin.sym} 133340 -17610 0 1 {name=p132449 lab=_41610_/A }
C {sky130_stdcells/o32ai_4.sym} 133260 -17610 0 0 {name=X_41609_ }
C {devices/lab_pin.sym} 133180 -17470 0 0 {name=p132450 lab=_48164_/A }
C {devices/lab_pin.sym} 133180 -17430 0 0 {name=p132451 lab=_57491_/C }
C {devices/lab_pin.sym} 133180 -17390 0 0 {name=p132452 lab=_48164_/Y }
C {devices/lab_pin.sym} 133340 -17430 0 1 {name=p132453 lab=_48165_/X }
C {sky130_stdcells/o21a_4.sym} 133260 -17430 0 0 {name=X_48165_ }
C {devices/lab_pin.sym} 133220 -17290 0 0 {name=p132454 lab=_60443_/A }
C {devices/lab_pin.sym} 133300 -17290 0 1 {name=p132455 lab=_60476_/D }
C {sky130_stdcells/buf_2.sym} 133260 -17290 0 0 {name=X_60443_ }
C {devices/lab_pin.sym} 133180 -17210 0 0 {name=p132456 lab=_72413_/X }
C {devices/lab_pin.sym} 133180 -17170 0 0 {name=p132457 lab=_72427_/Y }
C {devices/lab_pin.sym} 133180 -17130 0 0 {name=p132458 lab=_72428_/Y }
C {devices/lab_pin.sym} 133180 -17090 0 0 {name=p132459 lab=_57793_/X }
C {devices/lab_pin.sym} 133180 -17050 0 0 {name=p132460 lab=_72417_/X }
C {devices/lab_pin.sym} 133340 -17130 0 1 {name=p132461 lab=_72429_/X }
C {sky130_stdcells/o32a_4.sym} 133260 -17130 0 0 {name=X_72429_ }
C {devices/lab_pin.sym} 133180 -16990 0 0 {name=p132462 lab=_45374_/Y }
C {devices/lab_pin.sym} 133180 -16950 0 0 {name=p132463 lab=_45376_/Y }
C {devices/lab_pin.sym} 133180 -16910 0 0 {name=p132464 lab=_45361_/X }
C {devices/lab_pin.sym} 133340 -16950 0 1 {name=p132465 lab=_45377_/X }
C {sky130_stdcells/a21o_4.sym} 133260 -16950 0 0 {name=X_45377_ }
C {devices/lab_pin.sym} 133200 -16820 0 0 {name=p132466 lab=_76195_/X }
C {devices/lab_pin.sym} 133200 -16780 0 0 {name=p132467 lab=_76196_/Y }
C {devices/lab_pin.sym} 133320 -16800 0 1 {name=p132468 lab=_76199_/B }
C {sky130_stdcells/nand2_4.sym} 133260 -16800 0 0 {name=X_76197_ }
C {devices/lab_pin.sym} 133220 -16670 0 0 {name=p132469 lab=_42465_/A }
C {devices/lab_pin.sym} 133300 -16670 0 1 {name=p132470 lab=_42590_/A }
C {sky130_stdcells/buf_2.sym} 133260 -16670 0 0 {name=X_42589_ }
C {devices/lab_pin.sym} 133220 -16550 0 0 {name=p132471 lab=_47116_/A }
C {devices/lab_pin.sym} 133300 -16550 0 1 {name=p132472 lab=_52863_/B }
C {sky130_stdcells/buf_2.sym} 133260 -16550 0 0 {name=X_47116_ }
C {devices/lab_pin.sym} 133180 -16460 0 0 {name=p132473 lab=_41651_/X }
C {devices/lab_pin.sym} 133180 -16420 0 0 {name=p132474 lab=_44326_/X }
C {devices/lab_pin.sym} 133180 -16380 0 0 {name=p132475 lab=_87163_/Q }
C {devices/lab_pin.sym} 133180 -16340 0 0 {name=p132476 lab=_44327_/X }
C {devices/lab_pin.sym} 133340 -16400 0 1 {name=p132477 lab=_87163_/D }
C {sky130_stdcells/a2bb2o_4.sym} 133260 -16400 0 0 {name=X_44328_ }
C {devices/lab_pin.sym} 133180 -16270 0 0 {name=p132478 lab=_75130_/Y }
C {devices/lab_pin.sym} 133180 -16230 0 0 {name=p132479 lab=_75135_/Y }
C {devices/lab_pin.sym} 133180 -16190 0 0 {name=p132480 lab=_75131_/Y }
C {devices/lab_pin.sym} 133340 -16230 0 1 {name=p132481 lab=_75148_/Y }
C {sky130_stdcells/o21ai_4.sym} 133260 -16230 0 0 {name=X_75148_ }
C {devices/lab_pin.sym} 133180 -16110 0 0 {name=p132482 lab=_63159_/Y }
C {devices/lab_pin.sym} 133180 -16070 0 0 {name=p132483 lab=_63161_/X }
C {devices/lab_pin.sym} 133180 -16030 0 0 {name=p132484 lab=_63114_/X }
C {devices/lab_pin.sym} 133340 -16070 0 1 {name=p132485 lab=_63162_/Y }
C {sky130_stdcells/a21oi_4.sym} 133260 -16070 0 0 {name=X_63162_ }
C {devices/lab_pin.sym} 133200 -15940 0 0 {name=p132486 lab=_48642_/B }
C {devices/lab_pin.sym} 133200 -15900 0 0 {name=p132487 lab=_48449_/B }
C {devices/lab_pin.sym} 133320 -15920 0 1 {name=p132488 lab=_48096_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -15920 0 0 {name=X_48096_ }
C {devices/lab_pin.sym} 133200 -15810 0 0 {name=p132489 lab=_60477_/A }
C {devices/lab_pin.sym} 133200 -15770 0 0 {name=p132490 lab=_60519_/B }
C {devices/lab_pin.sym} 133200 -15730 0 0 {name=p132491 lab=_60374_/C }
C {devices/lab_pin.sym} 133320 -15770 0 1 {name=p132492 lab=_60374_/Y }
C {sky130_stdcells/nor3_4.sym} 133260 -15770 0 0 {name=X_60374_ }
C {devices/lab_pin.sym} 133220 -15630 0 0 {name=p132493 lab=_84784_/Q }
C {devices/lab_pin.sym} 133300 -15630 0 1 {name=p132494 lab=_62113_/X }
C {sky130_stdcells/buf_2.sym} 133260 -15630 0 0 {name=X_62113_ }
C {devices/lab_pin.sym} 133220 -15510 0 0 {name=p132495 lab=_47047_/A }
C {devices/lab_pin.sym} 133300 -15510 0 1 {name=p132496 lab=_52827_/D }
C {sky130_stdcells/buf_2.sym} 133260 -15510 0 0 {name=X_47047_ }
C {devices/lab_pin.sym} 133220 -15390 0 0 {name=p132497 lab=_64850_/A }
C {devices/lab_pin.sym} 133300 -15390 0 1 {name=p132498 lab=_65880_/A }
C {sky130_stdcells/buf_2.sym} 133260 -15390 0 0 {name=X_44259_ }
C {devices/lab_pin.sym} 133180 -15300 0 0 {name=p132499 lab=_67948_/X }
C {devices/lab_pin.sym} 133180 -15260 0 0 {name=p132500 lab=_67961_/Y }
C {devices/lab_pin.sym} 133180 -15220 0 0 {name=p132501 lab=_67863_/X }
C {devices/lab_pin.sym} 133180 -15180 0 0 {name=p132502 lab=_67969_/Y }
C {devices/lab_pin.sym} 133340 -15240 0 1 {name=p132503 lab=_67970_/X }
C {sky130_stdcells/a211o_4.sym} 133260 -15240 0 0 {name=X_67970_ }
C {devices/lab_pin.sym} 133180 -15110 0 0 {name=p132504 lab=_63090_/Y }
C {devices/lab_pin.sym} 133180 -15070 0 0 {name=p132505 lab=_63092_/X }
C {devices/lab_pin.sym} 133180 -15030 0 0 {name=p132506 lab=_63056_/X }
C {devices/lab_pin.sym} 133340 -15070 0 1 {name=p132507 lab=_63093_/Y }
C {sky130_stdcells/a21oi_4.sym} 133260 -15070 0 0 {name=X_63093_ }
C {devices/lab_pin.sym} 133200 -14940 0 0 {name=p132508 lab=_79956_/A }
C {devices/lab_pin.sym} 133200 -14900 0 0 {name=p132509 lab=_79955_/Y }
C {devices/lab_pin.sym} 133320 -14920 0 1 {name=p132510 lab=_79958_/A }
C {sky130_stdcells/nand2_4.sym} 133260 -14920 0 0 {name=X_79956_ }
C {devices/lab_pin.sym} 133200 -14800 0 0 {name=p132511 lab=_75086_/A }
C {devices/lab_pin.sym} 133200 -14760 0 0 {name=p132512 lab=_75079_/B }
C {devices/lab_pin.sym} 133320 -14780 0 1 {name=p132513 lab=_75080_/B }
C {sky130_stdcells/xor2_4.sym} 133260 -14780 0 0 {name=X_75079_ }
C {devices/lab_pin.sym} 133180 -14680 0 0 {name=p132514 lab=_88389_/Q }
C {devices/lab_pin.sym} 133180 -14640 0 0 {name=p132515 lab=_66868_/X }
C {devices/lab_pin.sym} 133180 -14600 0 0 {name=p132516 lab=_66919_/X }
C {devices/lab_pin.sym} 133180 -14560 0 0 {name=p132517 lab=_66920_/X }
C {devices/lab_pin.sym} 133340 -14620 0 1 {name=p132518 lab=_66921_/X }
C {sky130_stdcells/a211o_4.sym} 133260 -14620 0 0 {name=X_66921_ }
C {devices/lab_pin.sym} 133220 -14470 0 0 {name=p132519 lab=_58264_/A }
C {devices/lab_pin.sym} 133300 -14470 0 1 {name=p132520 lab=_63610_/B }
C {sky130_stdcells/buf_2.sym} 133260 -14470 0 0 {name=X_62044_ }
C {devices/lab_pin.sym} 133180 -14370 0 0 {name=p132521 lab=_82636_/Q }
C {devices/lab_pin.sym} 133180 -14330 0 0 {name=p132522 lab=_82508_/D }
C {devices/lab_pin.sym} 133180 -14290 0 0 {name=p132523 lab=_78906_/Y }
C {devices/lab_pin.sym} 133340 -14330 0 1 {name=p132524 lab=_78907_/Y }
C {sky130_stdcells/a21oi_4.sym} 133260 -14330 0 0 {name=X_78907_ }
C {devices/lab_pin.sym} 133200 -14200 0 0 {name=p132525 lab=_79887_/A }
C {devices/lab_pin.sym} 133200 -14160 0 0 {name=p132526 lab=_79886_/Y }
C {devices/lab_pin.sym} 133320 -14180 0 1 {name=p132527 lab=_79888_/B }
C {sky130_stdcells/xor2_4.sym} 133260 -14180 0 0 {name=X_79887_ }
C {devices/lab_pin.sym} 133200 -14060 0 0 {name=p132528 lab=_69637_/X }
C {devices/lab_pin.sym} 133200 -14020 0 0 {name=p132529 lab=_69639_/X }
C {devices/lab_pin.sym} 133320 -14040 0 1 {name=p132530 lab=_69640_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -14040 0 0 {name=X_69640_ }
C {devices/lab_pin.sym} 133200 -13920 0 0 {name=p132531 lab=_66851_/X }
C {devices/lab_pin.sym} 133200 -13880 0 0 {name=p132532 lab=_66852_/B }
C {devices/lab_pin.sym} 133320 -13900 0 1 {name=p132533 lab=_66852_/X }
C {sky130_stdcells/and2_4.sym} 133260 -13900 0 0 {name=X_66852_ }
C {devices/lab_pin.sym} 133200 -13780 0 0 {name=p132534 lab=_78838_/A }
C {devices/lab_pin.sym} 133200 -13740 0 0 {name=p132535 lab=_78838_/B }
C {devices/lab_pin.sym} 133320 -13760 0 1 {name=p132536 lab=_78838_/X }
C {sky130_stdcells/xor2_4.sym} 133260 -13760 0 0 {name=X_78838_ }
C {devices/lab_pin.sym} 133220 -13630 0 0 {name=p132537 lab=_48998_/A }
C {devices/lab_pin.sym} 133300 -13630 0 1 {name=p132538 lab=_72014_/B }
C {sky130_stdcells/buf_2.sym} 133260 -13630 0 0 {name=X_48998_ }
C {devices/lab_pin.sym} 133180 -13530 0 0 {name=p132539 lab=_65800_/Y }
C {devices/lab_pin.sym} 133180 -13490 0 0 {name=p132540 lab=_65757_/X }
C {devices/lab_pin.sym} 133180 -13450 0 0 {name=p132541 lab=_65802_/Y }
C {devices/lab_pin.sym} 133340 -13490 0 1 {name=p132542 lab=_84177_/D }
C {sky130_stdcells/a21o_4.sym} 133260 -13490 0 0 {name=X_65803_ }
C {devices/lab_pin.sym} 133180 -13370 0 0 {name=p132543 lab=_69566_/X }
C {devices/lab_pin.sym} 133180 -13330 0 0 {name=p132544 lab=_69569_/X }
C {devices/lab_pin.sym} 133180 -13290 0 0 {name=p132545 lab=_69570_/X }
C {devices/lab_pin.sym} 133340 -13330 0 1 {name=p132546 lab=_69571_/X }
C {sky130_stdcells/a21o_4.sym} 133260 -13330 0 0 {name=X_69571_ }
C {devices/lab_pin.sym} 133220 -13190 0 0 {name=p132547 lab=_47841_/A }
C {devices/lab_pin.sym} 133300 -13190 0 1 {name=p132548 lab=_47988_/A }
C {sky130_stdcells/buf_2.sym} 133260 -13190 0 0 {name=X_47949_ }
C {devices/lab_pin.sym} 133180 -13100 0 0 {name=p132549 lab=_87946_/Q }
C {devices/lab_pin.sym} 133180 -13060 0 0 {name=p132550 lab=_66759_/X }
C {devices/lab_pin.sym} 133180 -13020 0 0 {name=p132551 lab=_66688_/X }
C {devices/lab_pin.sym} 133180 -12980 0 0 {name=p132552 lab=_66782_/X }
C {devices/lab_pin.sym} 133340 -13040 0 1 {name=p132553 lab=_66783_/X }
C {sky130_stdcells/a211o_4.sym} 133260 -13040 0 0 {name=X_66783_ }
C {devices/lab_pin.sym} 133200 -12900 0 0 {name=p132554 lab=_78769_/A }
C {devices/lab_pin.sym} 133200 -12860 0 0 {name=p132555 lab=_78769_/B }
C {devices/lab_pin.sym} 133320 -12880 0 1 {name=p132556 lab=_78769_/Y }
C {sky130_stdcells/nor2_4.sym} 133260 -12880 0 0 {name=X_78769_ }
C {devices/lab_pin.sym} 133200 -12770 0 0 {name=p132557 lab=_63960_/A }
C {devices/lab_pin.sym} 133200 -12730 0 0 {name=p132558 lab=_63960_/B }
C {devices/lab_pin.sym} 133200 -12690 0 0 {name=p132559 lab=_63995_/C }
C {devices/lab_pin.sym} 133320 -12730 0 1 {name=p132560 lab=_63995_/Y }
C {sky130_stdcells/nor3_4.sym} 133260 -12730 0 0 {name=X_63995_ }
C {devices/lab_pin.sym} 133170 -12590 0 0 {name=p132561 lab=_80821_/CLK }
C {devices/lab_pin.sym} 133170 -12570 0 0 {name=p132562 lab=_75867_/Y }
C {devices/lab_pin.sym} 133350 -12590 0 1 {name=p132563 lab=_80800_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -12580 0 0 {name=X_80800_ }
C {devices/lab_pin.sym} 133180 -12470 0 0 {name=p132564 lab=_68519_/X }
C {devices/lab_pin.sym} 133180 -12430 0 0 {name=p132565 lab=_68521_/X }
C {devices/lab_pin.sym} 133180 -12390 0 0 {name=p132566 lab=_68442_/X }
C {devices/lab_pin.sym} 133340 -12430 0 1 {name=p132567 lab=_68525_/A }
C {sky130_stdcells/a21o_4.sym} 133260 -12430 0 0 {name=X_68522_ }
C {devices/lab_pin.sym} 133220 -12290 0 0 {name=p132568 lab=_64829_/A }
C {devices/lab_pin.sym} 133300 -12290 0 1 {name=p132569 lab=_65734_/X }
C {sky130_stdcells/buf_2.sym} 133260 -12290 0 0 {name=X_65734_ }
C {devices/lab_pin.sym} 133180 -12190 0 0 {name=p132570 lab=_50956_/Y }
C {devices/lab_pin.sym} 133180 -12150 0 0 {name=p132571 lab=_50957_/X }
C {devices/lab_pin.sym} 133180 -12110 0 0 {name=p132572 lab=_50959_/X }
C {devices/lab_pin.sym} 133340 -12150 0 1 {name=p132573 lab=_86100_/D }
C {sky130_stdcells/a21oi_4.sym} 133260 -12150 0 0 {name=X_50960_ }
C {devices/lab_pin.sym} 133170 -12010 0 0 {name=p132574 lab=_81703_/CLK }
C {devices/lab_pin.sym} 133170 -11990 0 0 {name=p132575 lab=_76104_/X }
C {devices/lab_pin.sym} 133350 -12010 0 1 {name=p132576 lab=_81780_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -12000 0 0 {name=X_81780_ }
C {devices/lab_pin.sym} 133200 -11900 0 0 {name=p132577 lab=_62644_/X }
C {devices/lab_pin.sym} 133200 -11860 0 0 {name=p132578 lab=_58194_/A }
C {devices/lab_pin.sym} 133200 -11820 0 0 {name=p132579 lab=_60253_/A }
C {devices/lab_pin.sym} 133200 -11780 0 0 {name=p132580 lab=_60220_/A }
C {devices/lab_pin.sym} 133320 -11840 0 1 {name=p132581 lab=_62946_/X }
C {sky130_stdcells/and4_4.sym} 133260 -11840 0 0 {name=X_62946_ }
C {devices/lab_pin.sym} 133200 -11720 0 0 {name=p132582 lab=_49610_/A }
C {devices/lab_pin.sym} 133200 -11680 0 0 {name=p132583 lab=_49614_/X }
C {devices/lab_pin.sym} 133200 -11640 0 0 {name=p132584 lab=_49615_/C }
C {devices/lab_pin.sym} 133200 -11600 0 0 {name=p132585 lab=_52835_/D }
C {devices/lab_pin.sym} 133320 -11660 0 1 {name=p132586 lab=_49619_/X }
C {sky130_stdcells/and4_4.sym} 133260 -11660 0 0 {name=X_49619_ }
C {devices/lab_pin.sym} 133220 -11510 0 0 {name=p132587 lab=clkbuf_7_81_0_CLK/A }
C {devices/lab_pin.sym} 133300 -11510 0 1 {name=p132588 lab=clkbuf_7_81_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 133260 -11510 0 0 {name=Xclkbuf_7_81_0_CLK }
C {devices/lab_pin.sym} 133180 -11420 0 0 {name=p132589 lab=_87504_/Q }
C {devices/lab_pin.sym} 133180 -11380 0 0 {name=p132590 lab=_68365_/X }
C {devices/lab_pin.sym} 133180 -11340 0 0 {name=p132591 lab=_68450_/X }
C {devices/lab_pin.sym} 133180 -11300 0 0 {name=p132592 lab=_68452_/X }
C {devices/lab_pin.sym} 133340 -11360 0 1 {name=p132593 lab=_68453_/X }
C {sky130_stdcells/a211o_4.sym} 133260 -11360 0 0 {name=X_68453_ }
C {devices/lab_pin.sym} 133170 -11210 0 0 {name=p132594 lab=_81048_/CLK }
C {devices/lab_pin.sym} 133170 -11190 0 0 {name=p132595 lab=_75917_/X }
C {devices/lab_pin.sym} 133350 -11210 0 1 {name=p132596 lab=_80699_/D }
C {sky130_stdcells/dfxtp_4.sym} 133260 -11200 0 0 {name=X_80731_ }
C {devices/lab_pin.sym} 133200 -11090 0 0 {name=p132597 lab=_65621_/A }
C {devices/lab_pin.sym} 133200 -11050 0 0 {name=p132598 lab=_65559_/B }
C {devices/lab_pin.sym} 133200 -11010 0 0 {name=p132599 lab=_84186_/Q }
C {devices/lab_pin.sym} 133320 -11050 0 1 {name=p132600 lab=_65665_/X }
C {sky130_stdcells/and3_4.sym} 133260 -11050 0 0 {name=X_65665_ }
C {devices/lab_pin.sym} 133200 -10940 0 0 {name=p132601 lab=_50908_/A }
C {devices/lab_pin.sym} 133200 -10900 0 0 {name=p132602 lab=_50045_/X }
C {devices/lab_pin.sym} 133200 -10860 0 0 {name=p132603 lab=_50886_/C }
C {devices/lab_pin.sym} 133200 -10820 0 0 {name=p132604 lab=_51756_/D }
C {devices/lab_pin.sym} 133320 -10880 0 1 {name=p132605 lab=_50891_/X }
C {sky130_stdcells/and4_4.sym} 133260 -10880 0 0 {name=X_50891_ }
C {devices/lab_pin.sym} 133180 -10750 0 0 {name=p132606 lab=_63598_/A }
C {devices/lab_pin.sym} 133180 -10710 0 0 {name=p132607 lab=_62875_/X }
C {devices/lab_pin.sym} 133180 -10670 0 0 {name=p132608 lab=_62876_/Y }
C {devices/lab_pin.sym} 133340 -10710 0 1 {name=p132609 lab=_62877_/X }
C {sky130_stdcells/o21a_4.sym} 133260 -10710 0 0 {name=X_62877_ }
C {devices/lab_pin.sym} 133180 -10590 0 0 {name=p132610 lab=_84071_/Q }
C {devices/lab_pin.sym} 133180 -10550 0 0 {name=p132611 lab=_67331_/X }
C {devices/lab_pin.sym} 133180 -10510 0 0 {name=p132612 lab=_67403_/X }
C {devices/lab_pin.sym} 133340 -10550 0 1 {name=p132613 lab=_67404_/X }
C {sky130_stdcells/a21bo_4.sym} 133260 -10550 0 0 {name=X_67404_ }
C {devices/lab_pin.sym} 133220 -10410 0 0 {name=p132614 lab=_52630_/A }
C {devices/lab_pin.sym} 133300 -10410 0 1 {name=p132615 lab=_52657_/A }
C {sky130_stdcells/buf_2.sym} 133260 -10410 0 0 {name=X_52630_ }
C {devices/lab_pin.sym} 133220 -10290 0 0 {name=p132616 lab=_64616_/A }
C {devices/lab_pin.sym} 133300 -10290 0 1 {name=p132617 lab=_64769_/A }
C {sky130_stdcells/buf_2.sym} 133260 -10290 0 0 {name=X_64616_ }
C {devices/lab_pin.sym} 133170 -10170 0 0 {name=p132618 lab=_83451_/CLK }
C {devices/lab_pin.sym} 133170 -10150 0 0 {name=p132619 lab=_71578_/X }
C {devices/lab_pin.sym} 133350 -10170 0 1 {name=p132620 lab=_83450_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -10160 0 0 {name=X_83450_ }
C {devices/lab_pin.sym} 133180 -10070 0 0 {name=p132621 lab=_58241_/X }
C {devices/lab_pin.sym} 133180 -10030 0 0 {name=p132622 lab=_61824_/X }
C {devices/lab_pin.sym} 133180 -9990 0 0 {name=p132623 lab=_61756_/X }
C {devices/lab_pin.sym} 133180 -9950 0 0 {name=p132624 lab=_61790_/X }
C {devices/lab_pin.sym} 133180 -9920 0 0 {name=p132625 lab=_61827_/X }
C {devices/lab_pin.sym} 133340 -9990 0 1 {name=p132626 lab=_61828_/X }
C {sky130_stdcells/a41o_4.sym} 133260 -9990 0 0 {name=X_61828_ }
C {devices/lab_pin.sym} 133170 -9830 0 0 {name=p132627 lab=_80657_/CLK }
C {devices/lab_pin.sym} 133170 -9810 0 0 {name=p132628 lab=_74828_/Y }
C {devices/lab_pin.sym} 133350 -9830 0 1 {name=p132629 lab=_46129_/A }
C {sky130_stdcells/dfxtp_4.sym} 133260 -9820 0 0 {name=X_80662_ }
C {devices/lab_pin.sym} 133220 -9690 0 0 {name=p132630 lab=_68384_/A }
C {devices/lab_pin.sym} 133300 -9690 0 1 {name=p132631 lab=_68384_/X }
C {sky130_stdcells/buf_2.sym} 133260 -9690 0 0 {name=X_68384_ }
C {devices/lab_pin.sym} 133220 -9570 0 0 {name=p132632 lab=_65595_/X }
C {devices/lab_pin.sym} 133300 -9570 0 1 {name=p132633 lab=_65596_/X }
C {sky130_stdcells/buf_2.sym} 133260 -9570 0 0 {name=X_65596_ }
C {devices/lab_pin.sym} 133170 -9450 0 0 {name=p132634 lab=_82965_/CLK }
C {devices/lab_pin.sym} 133170 -9430 0 0 {name=p132635 lab=_82209_/Q }
C {devices/lab_pin.sym} 133350 -9450 0 1 {name=p132636 lab=_82401_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -9440 0 0 {name=X_82401_ }
C {devices/lab_pin.sym} 133200 -9320 0 0 {name=p132637 lab=_67308_/A }
C {devices/lab_pin.sym} 133200 -9280 0 0 {name=p132638 lab=_87219_/Q }
C {devices/lab_pin.sym} 133320 -9300 0 1 {name=p132639 lab=_67335_/X }
C {sky130_stdcells/and2_4.sym} 133260 -9300 0 0 {name=X_67335_ }
C {devices/lab_pin.sym} 133200 -9180 0 0 {name=p132640 lab=_52542_/X }
C {devices/lab_pin.sym} 133200 -9140 0 0 {name=p132641 lab=_54079_/B }
C {devices/lab_pin.sym} 133320 -9160 0 1 {name=p132642 lab=_52561_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -9160 0 0 {name=X_52561_ }
C {devices/lab_pin.sym} 133200 -9050 0 0 {name=p132643 lab=_64250_/A }
C {devices/lab_pin.sym} 133200 -9010 0 0 {name=p132644 lab=_59443_/A }
C {devices/lab_pin.sym} 133200 -8970 0 0 {name=p132645 lab=_61102_/X }
C {devices/lab_pin.sym} 133320 -9010 0 1 {name=p132646 lab=_64547_/Y }
C {sky130_stdcells/nand3_4.sym} 133260 -9010 0 0 {name=X_64547_ }
C {devices/lab_pin.sym} 133170 -8870 0 0 {name=p132647 lab=_83414_/CLK }
C {devices/lab_pin.sym} 133170 -8850 0 0 {name=p132648 lab=_71773_/X }
C {devices/lab_pin.sym} 133350 -8870 0 1 {name=p132649 lab=_83381_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -8860 0 0 {name=X_83381_ }
C {devices/lab_pin.sym} 133200 -8760 0 0 {name=p132650 lab=_61356_/X }
C {devices/lab_pin.sym} 133200 -8720 0 0 {name=p132651 lab=_62183_/A }
C {devices/lab_pin.sym} 133200 -8680 0 0 {name=p132652 lab=_59810_/A }
C {devices/lab_pin.sym} 133200 -8640 0 0 {name=p132653 lab=_59754_/A }
C {devices/lab_pin.sym} 133320 -8700 0 1 {name=p132654 lab=_61766_/B }
C {sky130_stdcells/nand4_4.sym} 133260 -8700 0 0 {name=X_61759_ }
C {devices/lab_pin.sym} 133200 -8560 0 0 {name=p132655 lab=_80570_/Y }
C {devices/lab_pin.sym} 133200 -8520 0 0 {name=p132656 lab=_80592_/Y }
C {devices/lab_pin.sym} 133320 -8540 0 1 {name=p132657 lab=_80593_/Y }
C {sky130_stdcells/nor2_4.sym} 133260 -8540 0 0 {name=X_80593_ }
C {sky130_stdcells/decap_3.sym} 133260 -8380 0 0 {name=XPHY_408 }
C {devices/lab_pin.sym} 133200 -8240 0 0 {name=p132658 lab=_54314_/A }
C {devices/lab_pin.sym} 133200 -8200 0 0 {name=p132659 lab=_46676_/A }
C {devices/lab_pin.sym} 133320 -8220 0 1 {name=p132660 lab=_54300_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -8220 0 0 {name=X_54300_ }
C {sky130_stdcells/decap_3.sym} 133260 -8060 0 0 {name=XPHY_419 }
C {devices/lab_pin.sym} 133170 -7910 0 0 {name=p132661 lab=_85152_/CLK }
C {devices/lab_pin.sym} 133170 -7890 0 0 {name=p132662 lab=_85120_/D }
C {devices/lab_pin.sym} 133350 -7910 0 1 {name=p132663 lab=_45409_/A }
C {sky130_stdcells/dfxtp_4.sym} 133260 -7900 0 0 {name=X_85120_ }
C {devices/lab_pin.sym} 133220 -7770 0 0 {name=p132664 lab=clkbuf_7_96_0_CLK/A }
C {devices/lab_pin.sym} 133300 -7770 0 1 {name=p132665 lab=clkbuf_7_96_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 133260 -7770 0 0 {name=Xclkbuf_7_96_0_CLK }
C {devices/lab_pin.sym} 133220 -7650 0 0 {name=p132666 lab=_51074_/A }
C {devices/lab_pin.sym} 133300 -7650 0 1 {name=p132667 lab=_51622_/A }
C {sky130_stdcells/buf_2.sym} 133260 -7650 0 0 {name=X_51512_ }
C {devices/lab_pin.sym} 133170 -7530 0 0 {name=p132668 lab=_82288_/CLK }
C {devices/lab_pin.sym} 133170 -7510 0 0 {name=p132669 lab=_77191_/B }
C {devices/lab_pin.sym} 133350 -7530 0 1 {name=p132670 lab=_82332_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -7520 0 0 {name=X_82332_ }
C {devices/lab_pin.sym} 133180 -7410 0 0 {name=p132671 lab=_55277_/X }
C {devices/lab_pin.sym} 133180 -7370 0 0 {name=p132672 lab=_55279_/X }
C {devices/lab_pin.sym} 133180 -7330 0 0 {name=p132673 lab=_55138_/X }
C {devices/lab_pin.sym} 133340 -7370 0 1 {name=p132674 lab=_56868_/A }
C {sky130_stdcells/a21o_4.sym} 133260 -7370 0 0 {name=X_55280_ }
C {devices/lab_pin.sym} 133200 -7240 0 0 {name=p132675 lab=_67266_/A }
C {devices/lab_pin.sym} 133200 -7200 0 0 {name=p132676 lab=_88118_/Q }
C {devices/lab_pin.sym} 133320 -7220 0 1 {name=p132677 lab=_67266_/X }
C {sky130_stdcells/and2_4.sym} 133260 -7220 0 0 {name=X_67266_ }
C {devices/lab_pin.sym} 133200 -7100 0 0 {name=p132678 lab=_52487_/X }
C {devices/lab_pin.sym} 133200 -7060 0 0 {name=p132679 lab=_46417_/B }
C {devices/lab_pin.sym} 133320 -7080 0 1 {name=p132680 lab=_52492_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -7080 0 0 {name=X_52492_ }
C {devices/lab_pin.sym} 133200 -6970 0 0 {name=p132681 lab=_61182_/X }
C {devices/lab_pin.sym} 133200 -6930 0 0 {name=p132682 lab=_61609_/X }
C {devices/lab_pin.sym} 133200 -6890 0 0 {name=p132683 lab=_64211_/C }
C {devices/lab_pin.sym} 133320 -6930 0 1 {name=p132684 lab=_64478_/Y }
C {sky130_stdcells/nand3_4.sym} 133260 -6930 0 0 {name=X_64478_ }
C {devices/lab_pin.sym} 133180 -6820 0 0 {name=p132685 lab=_86981_/Q }
C {devices/lab_pin.sym} 133180 -6780 0 0 {name=p132686 lab=_68472_/X }
C {devices/lab_pin.sym} 133180 -6740 0 0 {name=p132687 lab=_44246_/A }
C {devices/lab_pin.sym} 133180 -6700 0 0 {name=p132688 lab=_69004_/X }
C {devices/lab_pin.sym} 133340 -6760 0 1 {name=p132689 lab=_69005_/X }
C {sky130_stdcells/a211o_4.sym} 133260 -6760 0 0 {name=X_69005_ }
C {devices/lab_pin.sym} 133180 -6630 0 0 {name=p132690 lab=_85480_/Q }
C {devices/lab_pin.sym} 133180 -6590 0 0 {name=p132691 lab=_54220_/X }
C {devices/lab_pin.sym} 133180 -6550 0 0 {name=p132692 lab=_54230_/Y }
C {devices/lab_pin.sym} 133340 -6590 0 1 {name=p132693 lab=_54231_/Y }
C {sky130_stdcells/o21ai_4.sym} 133260 -6590 0 0 {name=X_54231_ }
C {devices/lab_pin.sym} 133200 -6460 0 0 {name=p132694 lab=_66217_/A }
C {devices/lab_pin.sym} 133200 -6420 0 0 {name=p132695 lab=_66216_/Y }
C {devices/lab_pin.sym} 133320 -6440 0 1 {name=p132696 lab=_66217_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -6440 0 0 {name=X_66217_ }
C {devices/lab_pin.sym} 133170 -6310 0 0 {name=p132697 lab=_85089_/CLK }
C {devices/lab_pin.sym} 133170 -6290 0 0 {name=p132698 lab=_85051_/D }
C {devices/lab_pin.sym} 133350 -6310 0 1 {name=p132699 lab=_85051_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -6300 0 0 {name=X_85051_ }
C {devices/lab_pin.sym} 133200 -6200 0 0 {name=p132700 lab=_51456_/A }
C {devices/lab_pin.sym} 133200 -6160 0 0 {name=p132701 lab=_51421_/X }
C {devices/lab_pin.sym} 133200 -6120 0 0 {name=p132702 lab=_51467_/C }
C {devices/lab_pin.sym} 133200 -6080 0 0 {name=p132703 lab=_52971_/D }
C {devices/lab_pin.sym} 133320 -6140 0 1 {name=p132704 lab=_51443_/X }
C {sky130_stdcells/and4_4.sym} 133260 -6140 0 0 {name=X_51443_ }
C {devices/lab_pin.sym} 133180 -6020 0 0 {name=p132705 lab=_61386_/B }
C {devices/lab_pin.sym} 133180 -5980 0 0 {name=p132706 lab=_63426_/X }
C {devices/lab_pin.sym} 133180 -5940 0 0 {name=p132707 lab=_63427_/X }
C {devices/lab_pin.sym} 133180 -5900 0 0 {name=p132708 lab=_63428_/X }
C {devices/lab_pin.sym} 133340 -5960 0 1 {name=p132709 lab=_63429_/X }
C {sky130_stdcells/a211o_4.sym} 133260 -5960 0 0 {name=X_63429_ }
C {devices/lab_pin.sym} 133170 -5810 0 0 {name=p132710 lab=_82263_/CLK }
C {devices/lab_pin.sym} 133170 -5790 0 0 {name=p132711 lab=_80522_/Y }
C {devices/lab_pin.sym} 133350 -5810 0 1 {name=p132712 lab=_82263_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -5800 0 0 {name=X_82263_ }
C {devices/lab_pin.sym} 133200 -5680 0 0 {name=p132713 lab=_67197_/A }
C {devices/lab_pin.sym} 133200 -5640 0 0 {name=p132714 lab=_67196_/X }
C {devices/lab_pin.sym} 133320 -5660 0 1 {name=p132715 lab=_67197_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -5660 0 0 {name=X_67197_ }
C {devices/lab_pin.sym} 133170 -5530 0 0 {name=p132716 lab=_81755_/CLK }
C {devices/lab_pin.sym} 133170 -5510 0 0 {name=p132717 lab=_84002_/D }
C {devices/lab_pin.sym} 133350 -5530 0 1 {name=p132718 lab=_84002_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -5520 0 0 {name=X_84002_ }
C {devices/lab_pin.sym} 133170 -5390 0 0 {name=p132719 lab=_84981_/CLK }
C {devices/lab_pin.sym} 133170 -5370 0 0 {name=p132720 lab=_74868_/X }
C {devices/lab_pin.sym} 133350 -5390 0 1 {name=p132721 lab=_48915_/A }
C {sky130_stdcells/dfxtp_4.sym} 133260 -5380 0 0 {name=X_81214_ }
C {devices/lab_pin.sym} 133200 -5260 0 0 {name=p132722 lab=_54149_/A }
C {devices/lab_pin.sym} 133200 -5220 0 0 {name=p132723 lab=_47344_/A }
C {devices/lab_pin.sym} 133320 -5240 0 1 {name=p132724 lab=_54162_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -5240 0 0 {name=X_54162_ }
C {devices/lab_pin.sym} 133200 -5130 0 0 {name=p132725 lab=_66145_/X }
C {devices/lab_pin.sym} 133200 -5090 0 0 {name=p132726 lab=_65967_/B }
C {devices/lab_pin.sym} 133200 -5050 0 0 {name=p132727 lab=_66147_/X }
C {devices/lab_pin.sym} 133320 -5090 0 1 {name=p132728 lab=_66148_/Y }
C {sky130_stdcells/nand3_4.sym} 133260 -5090 0 0 {name=X_66148_ }
C {devices/lab_pin.sym} 133200 -4960 0 0 {name=p132729 lab=_51364_/A }
C {devices/lab_pin.sym} 133200 -4920 0 0 {name=p132730 lab=_50862_/B }
C {devices/lab_pin.sym} 133320 -4940 0 1 {name=p132731 lab=_51374_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -4940 0 0 {name=X_51374_ }
C {devices/lab_pin.sym} 133170 -4810 0 0 {name=p132732 lab=_82386_/CLK }
C {devices/lab_pin.sym} 133170 -4790 0 0 {name=p132733 lab=_82194_/D }
C {devices/lab_pin.sym} 133350 -4810 0 1 {name=p132734 lab=_82194_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -4800 0 0 {name=X_82194_ }
C {devices/lab_pin.sym} 133200 -4700 0 0 {name=p132735 lab=_53133_/A }
C {devices/lab_pin.sym} 133200 -4660 0 0 {name=p132736 lab=_53113_/B }
C {devices/lab_pin.sym} 133200 -4620 0 0 {name=p132737 lab=_53107_/C }
C {devices/lab_pin.sym} 133200 -4580 0 0 {name=p132738 lab=_53113_/D }
C {devices/lab_pin.sym} 133320 -4640 0 1 {name=p132739 lab=_53113_/X }
C {sky130_stdcells/and4_4.sym} 133260 -4640 0 0 {name=X_53113_ }
C {devices/lab_pin.sym} 133180 -4510 0 0 {name=p132740 lab=_86223_/Q }
C {devices/lab_pin.sym} 133180 -4470 0 0 {name=p132741 lab=_50316_/X }
C {devices/lab_pin.sym} 133180 -4430 0 0 {name=p132742 lab=_50324_/Y }
C {devices/lab_pin.sym} 133340 -4470 0 1 {name=p132743 lab=_50325_/Y }
C {sky130_stdcells/o21ai_4.sym} 133260 -4470 0 0 {name=X_50325_ }
C {devices/lab_pin.sym} 133170 -4330 0 0 {name=p132744 lab=_81197_/CLK }
C {devices/lab_pin.sym} 133170 -4310 0 0 {name=p132745 lab=_75008_/A }
C {devices/lab_pin.sym} 133350 -4330 0 1 {name=p132746 lab=_81145_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -4320 0 0 {name=X_81145_ }
C {devices/lab_pin.sym} 133200 -4200 0 0 {name=p132747 lab=_53434_/A }
C {devices/lab_pin.sym} 133200 -4160 0 0 {name=p132748 lab=_47221_/A }
C {devices/lab_pin.sym} 133320 -4180 0 1 {name=p132749 lab=_54093_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -4180 0 0 {name=X_54093_ }
C {devices/lab_pin.sym} 133200 -4060 0 0 {name=p132750 lab=_58970_/A }
C {devices/lab_pin.sym} 133200 -4020 0 0 {name=p132751 lab=_58973_/B }
C {devices/lab_pin.sym} 133320 -4040 0 1 {name=p132752 lab=_58970_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -4040 0 0 {name=X_58970_ }
C {devices/lab_pin.sym} 133200 -3930 0 0 {name=p132753 lab=_66123_/A }
C {devices/lab_pin.sym} 133200 -3890 0 0 {name=p132754 lab=_66004_/B }
C {devices/lab_pin.sym} 133200 -3850 0 0 {name=p132755 lab=_84158_/Q }
C {devices/lab_pin.sym} 133320 -3890 0 1 {name=p132756 lab=_66079_/X }
C {sky130_stdcells/and3_4.sym} 133260 -3890 0 0 {name=X_66079_ }
C {devices/lab_pin.sym} 133180 -3780 0 0 {name=p132757 lab=_57912_/Y }
C {devices/lab_pin.sym} 133180 -3740 0 0 {name=p132758 lab=_57758_/X }
C {devices/lab_pin.sym} 133180 -3700 0 0 {name=p132759 lab=_57917_/X }
C {devices/lab_pin.sym} 133180 -3660 0 0 {name=p132760 lab=_57920_/X }
C {devices/lab_pin.sym} 133340 -3720 0 1 {name=p132761 lab=_84940_/D }
C {sky130_stdcells/a22oi_4.sym} 133260 -3720 0 0 {name=X_57921_ }
C {devices/lab_pin.sym} 133200 -3600 0 0 {name=p132762 lab=_53048_/A }
C {devices/lab_pin.sym} 133200 -3560 0 0 {name=p132763 lab=_53063_/B }
C {devices/lab_pin.sym} 133200 -3520 0 0 {name=p132764 lab=_53058_/C }
C {devices/lab_pin.sym} 133200 -3480 0 0 {name=p132765 lab=_53044_/D }
C {devices/lab_pin.sym} 133320 -3540 0 1 {name=p132766 lab=_53044_/X }
C {sky130_stdcells/and4_4.sym} 133260 -3540 0 0 {name=X_53044_ }
C {devices/lab_pin.sym} 133180 -3420 0 0 {name=p132767 lab=_87545_/Q }
C {devices/lab_pin.sym} 133180 -3380 0 0 {name=p132768 lab=_66608_/A }
C {devices/lab_pin.sym} 133180 -3340 0 0 {name=p132769 lab=_68348_/X }
C {devices/lab_pin.sym} 133180 -3300 0 0 {name=p132770 lab=_69906_/X }
C {devices/lab_pin.sym} 133340 -3360 0 1 {name=p132771 lab=_69907_/X }
C {sky130_stdcells/a211o_4.sym} 133260 -3360 0 0 {name=X_69907_ }
C {devices/lab_pin.sym} 133220 -3210 0 0 {name=p132772 lab=_50256_/A }
C {devices/lab_pin.sym} 133300 -3210 0 1 {name=p132773 lab=_50918_/A }
C {sky130_stdcells/buf_2.sym} 133260 -3210 0 0 {name=X_50256_ }
C {devices/lab_pin.sym} 133170 -3090 0 0 {name=p132774 lab=_85953_/CLK }
C {devices/lab_pin.sym} 133170 -3070 0 0 {name=p132775 lab=_51751_/Y }
C {devices/lab_pin.sym} 133350 -3090 0 1 {name=p132776 lab=_85953_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -3080 0 0 {name=X_85953_ }
C {devices/lab_pin.sym} 133170 -2950 0 0 {name=p132777 lab=_81087_/CLK }
C {devices/lab_pin.sym} 133170 -2930 0 0 {name=p132778 lab=_75889_/A }
C {devices/lab_pin.sym} 133350 -2950 0 1 {name=p132779 lab=_81076_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -2940 0 0 {name=X_81076_ }
C {devices/lab_pin.sym} 133220 -2810 0 0 {name=p132780 lab=clkbuf_7_35_0_CLK/A }
C {devices/lab_pin.sym} 133300 -2810 0 1 {name=p132781 lab=clkbuf_8_69_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 133260 -2810 0 0 {name=Xclkbuf_7_34_0_CLK }
C {devices/lab_pin.sym} 133170 -2690 0 0 {name=p132782 lab=_84903_/CLK }
C {devices/lab_pin.sym} 133170 -2670 0 0 {name=p132783 lab=_58223_/Y }
C {devices/lab_pin.sym} 133350 -2690 0 1 {name=p132784 lab=_63376_/B }
C {sky130_stdcells/dfxtp_4.sym} 133260 -2680 0 0 {name=X_84904_ }
C {devices/lab_pin.sym} 133200 -2560 0 0 {name=p132785 lab=_60107_/C }
C {devices/lab_pin.sym} 133200 -2520 0 0 {name=p132786 lab=_64088_/C }
C {devices/lab_pin.sym} 133320 -2540 0 1 {name=p132787 lab=_80027_/X }
C {sky130_stdcells/xor2_4.sym} 133260 -2540 0 0 {name=X_80027_ }
C {devices/lab_pin.sym} 133220 -2410 0 0 {name=p132788 lab=_57711_/X }
C {devices/lab_pin.sym} 133300 -2410 0 1 {name=p132789 lab=_57852_/X }
C {sky130_stdcells/buf_2.sym} 133260 -2410 0 0 {name=X_57852_ }
C {devices/lab_pin.sym} 133200 -2300 0 0 {name=p132790 lab=_69897_/A }
C {devices/lab_pin.sym} 133200 -2260 0 0 {name=p132791 lab=_69838_/B }
C {devices/lab_pin.sym} 133320 -2280 0 1 {name=p132792 lab=_69838_/Y }
C {sky130_stdcells/nor2_4.sym} 133260 -2280 0 0 {name=X_69838_ }
C {devices/lab_pin.sym} 133220 -2150 0 0 {name=p132793 lab=_51286_/A }
C {devices/lab_pin.sym} 133300 -2150 0 1 {name=p132794 lab=_50187_/X }
C {sky130_stdcells/buf_2.sym} 133260 -2150 0 0 {name=X_50187_ }
C {devices/lab_pin.sym} 133170 -2030 0 0 {name=p132795 lab=_85884_/CLK }
C {devices/lab_pin.sym} 133170 -2010 0 0 {name=p132796 lab=_85884_/D }
C {devices/lab_pin.sym} 133350 -2030 0 1 {name=p132797 lab=_65501_/B }
C {sky130_stdcells/dfxtp_4.sym} 133260 -2020 0 0 {name=X_85884_ }
C {devices/lab_pin.sym} 133220 -1890 0 0 {name=p132798 lab=clkbuf_7_87_0_CLK/X }
C {devices/lab_pin.sym} 133300 -1890 0 1 {name=p132799 lab=clkbuf_8_174_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 133260 -1890 0 0 {name=Xclkbuf_8_174_0_CLK }
C {devices/lab_pin.sym} 133220 -1770 0 0 {name=p132800 lab=_56803_/A }
C {devices/lab_pin.sym} 133300 -1770 0 1 {name=p132801 lab=_57170_/B }
C {sky130_stdcells/buf_2.sym} 133260 -1770 0 0 {name=X_56803_ }
C {devices/lab_pin.sym} 133170 -1650 0 0 {name=p132802 lab=_87883_/CLK }
C {devices/lab_pin.sym} 133170 -1630 0 0 {name=p132803 lab=_42975_/Y }
C {devices/lab_pin.sym} 133350 -1650 0 1 {name=p132804 lab=_66861_/B }
C {sky130_stdcells/dfxtp_4.sym} 133260 -1640 0 0 {name=X_87623_ }
C {devices/lab_pin.sym} 133170 -1510 0 0 {name=p132805 lab=_84835_/CLK }
C {devices/lab_pin.sym} 133170 -1490 0 0 {name=p132806 lab=_84835_/D }
C {devices/lab_pin.sym} 133350 -1510 0 1 {name=p132807 lab=_64467_/C }
C {sky130_stdcells/dfxtp_4.sym} 133260 -1500 0 0 {name=X_84835_ }
C {devices/lab_pin.sym} 133220 -1370 0 0 {name=p132808 lab=_68342_/A }
C {devices/lab_pin.sym} 133300 -1370 0 1 {name=p132809 lab=_69182_/A }
C {sky130_stdcells/buf_2.sym} 133260 -1370 0 0 {name=X_57783_ }
C {devices/lab_pin.sym} 133180 -1270 0 0 {name=p132810 lab=_69765_/X }
C {devices/lab_pin.sym} 133180 -1230 0 0 {name=p132811 lab=_69767_/X }
C {devices/lab_pin.sym} 133180 -1190 0 0 {name=p132812 lab=_69768_/X }
C {devices/lab_pin.sym} 133340 -1230 0 1 {name=p132813 lab=_69772_/A }
C {sky130_stdcells/a21o_4.sym} 133260 -1230 0 0 {name=X_69769_ }
C {devices/lab_pin.sym} 133220 -1090 0 0 {name=p132814 lab=_54250_/A }
C {devices/lab_pin.sym} 133300 -1090 0 1 {name=p132815 lab=_55011_/A }
C {sky130_stdcells/buf_2.sym} 133260 -1090 0 0 {name=X_54995_ }
C {devices/lab_pin.sym} 133220 -970 0 0 {name=p132816 lab=_71783_/Y }
C {devices/lab_pin.sym} 133300 -970 0 1 {name=p132817 lab=_71800_/Y }
C {sky130_stdcells/inv_2.sym} 133260 -970 0 0 {name=X_71800_ }
C {devices/lab_pin.sym} 133220 -850 0 0 {name=p132818 lab=_59571_/B }
C {devices/lab_pin.sym} 133300 -850 0 1 {name=p132819 lab=_59544_/A }
C {sky130_stdcells/buf_2.sym} 133260 -850 0 0 {name=X_59522_ }
C {devices/lab_pin.sym} 133220 -730 0 0 {name=p132820 lab=_56674_/X }
C {devices/lab_pin.sym} 133300 -730 0 1 {name=p132821 lab=_57149_/D }
C {sky130_stdcells/buf_2.sym} 133260 -730 0 0 {name=X_56734_ }
C {devices/lab_pin.sym} 134090 -42150 0 0 {name=p132822 lab=_88060_/CLK }
C {devices/lab_pin.sym} 134090 -42130 0 0 {name=p132823 lab=_43158_/Y }
C {devices/lab_pin.sym} 134270 -42150 0 1 {name=p132824 lab=_73198_/A }
C {sky130_stdcells/dfxtp_4.sym} 134180 -42140 0 0 {name=X_87554_ }
C {devices/lab_pin.sym} 134140 -42010 0 0 {name=p132825 lab=_42013_/A }
C {devices/lab_pin.sym} 134220 -42010 0 1 {name=p132826 lab=_41960_/X }
C {sky130_stdcells/buf_2.sym} 134180 -42010 0 0 {name=X_41960_ }
C {devices/lab_pin.sym} 134120 -41900 0 0 {name=p132827 lab=_53951_/A }
C {devices/lab_pin.sym} 134120 -41860 0 0 {name=p132828 lab=_53946_/B }
C {devices/lab_pin.sym} 134240 -41880 0 1 {name=p132829 lab=_53946_/Y }
C {sky130_stdcells/nand2_4.sym} 134180 -41880 0 0 {name=X_53946_ }
C {devices/lab_pin.sym} 134100 -41780 0 0 {name=p132830 lab=_72744_/X }
C {devices/lab_pin.sym} 134100 -41740 0 0 {name=p132831 lab=_86208_/Q }
C {devices/lab_pin.sym} 134100 -41700 0 0 {name=p132832 lab=_72746_/X }
C {devices/lab_pin.sym} 134100 -41660 0 0 {name=p132833 lab=_72779_/X }
C {devices/lab_pin.sym} 134260 -41720 0 1 {name=p132834 lab=_72780_/X }
C {sky130_stdcells/a211o_4.sym} 134180 -41720 0 0 {name=X_72780_ }
C {devices/lab_pin.sym} 134090 -41570 0 0 {name=p132835 lab=_84766_/CLK }
C {devices/lab_pin.sym} 134090 -41550 0 0 {name=p132836 lab=_59142_/Y }
C {devices/lab_pin.sym} 134270 -41570 0 1 {name=p132837 lab=_84766_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -41560 0 0 {name=X_84766_ }
C {devices/lab_pin.sym} 134090 -41430 0 0 {name=p132838 lab=_82234_/CLK }
C {devices/lab_pin.sym} 134090 -41410 0 0 {name=p132839 lab=_81978_/D }
C {devices/lab_pin.sym} 134270 -41430 0 1 {name=p132840 lab=_81978_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -41420 0 0 {name=X_81978_ }
C {devices/lab_pin.sym} 134140 -41290 0 0 {name=p132841 lab=clkbuf_9_291_0_CLK/A }
C {devices/lab_pin.sym} 134220 -41290 0 1 {name=p132842 lab=clkbuf_9_290_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 134180 -41290 0 0 {name=Xclkbuf_9_290_0_CLK }
C {devices/lab_pin.sym} 134140 -41170 0 0 {name=p132843 lab=clkbuf_6_24_0_CLK/X }
C {devices/lab_pin.sym} 134220 -41170 0 1 {name=p132844 lab=clkbuf_8_99_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 134180 -41170 0 0 {name=Xclkbuf_7_49_0_CLK }
C {devices/lab_pin.sym} 134090 -41050 0 0 {name=p132845 lab=_86505_/CLK }
C {devices/lab_pin.sym} 134090 -41030 0 0 {name=p132846 lab=_86505_/D }
C {devices/lab_pin.sym} 134270 -41050 0 1 {name=p132847 lab=_86505_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -41040 0 0 {name=X_86505_ }
C {devices/lab_pin.sym} 134140 -40910 0 0 {name=p132848 lab=_40911_/A }
C {devices/lab_pin.sym} 134220 -40910 0 1 {name=p132849 lab=_40911_/Y }
C {sky130_stdcells/inv_2.sym} 134180 -40910 0 0 {name=X_40911_ }
C {devices/lab_pin.sym} 134120 -40810 0 0 {name=p132850 lab=_71729_/A }
C {devices/lab_pin.sym} 134120 -40770 0 0 {name=p132851 lab=_71313_/X }
C {devices/lab_pin.sym} 134120 -40730 0 0 {name=p132852 lab=_71724_/X }
C {devices/lab_pin.sym} 134240 -40770 0 1 {name=p132853 lab=_71731_/Y }
C {sky130_stdcells/nand3_4.sym} 134180 -40770 0 0 {name=X_71731_ }
C {devices/lab_pin.sym} 134140 -40630 0 0 {name=p132854 lab=_84728_/Q }
C {devices/lab_pin.sym} 134220 -40630 0 1 {name=p132855 lab=_59454_/A }
C {sky130_stdcells/inv_2.sym} 134180 -40630 0 0 {name=X_59453_ }
C {devices/lab_pin.sym} 134090 -40510 0 0 {name=p132856 lab=_83721_/CLK }
C {devices/lab_pin.sym} 134090 -40490 0 0 {name=p132857 lab=_70720_/Y }
C {devices/lab_pin.sym} 134270 -40510 0 1 {name=p132858 lab=_83717_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -40500 0 0 {name=X_83717_ }
C {devices/lab_pin.sym} 134140 -40370 0 0 {name=p132859 lab=_56664_/Y }
C {devices/lab_pin.sym} 134220 -40370 0 1 {name=p132860 lab=_56665_/Y }
C {sky130_stdcells/inv_2.sym} 134180 -40370 0 0 {name=X_56665_ }
C {devices/lab_pin.sym} 134090 -40250 0 0 {name=p132861 lab=_80928_/CLK }
C {devices/lab_pin.sym} 134090 -40230 0 0 {name=p132862 lab=_84105_/Q }
C {devices/lab_pin.sym} 134270 -40250 0 1 {name=p132863 lab=_80929_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -40240 0 0 {name=X_80929_ }
C {devices/lab_pin.sym} 134090 -40110 0 0 {name=p132864 lab=_88001_/CLK }
C {devices/lab_pin.sym} 134090 -40090 0 0 {name=p132865 lab=_43315_/X }
C {devices/lab_pin.sym} 134270 -40110 0 1 {name=p132866 lab=_87485_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -40100 0 0 {name=X_87485_ }
C {devices/lab_pin.sym} 134140 -39970 0 0 {name=p132867 lab=_41967_/A }
C {devices/lab_pin.sym} 134220 -39970 0 1 {name=p132868 lab=_41891_/X }
C {sky130_stdcells/buf_2.sym} 134180 -39970 0 0 {name=X_41891_ }
C {devices/lab_pin.sym} 134120 -39860 0 0 {name=p132869 lab=_53848_/A }
C {devices/lab_pin.sym} 134120 -39820 0 0 {name=p132870 lab=_53877_/B }
C {devices/lab_pin.sym} 134240 -39840 0 1 {name=p132871 lab=_53877_/Y }
C {sky130_stdcells/nand2_4.sym} 134180 -39840 0 0 {name=X_53877_ }
C {devices/lab_pin.sym} 134140 -39710 0 0 {name=p132872 lab=clkbuf_7_94_0_CLK/X }
C {devices/lab_pin.sym} 134220 -39710 0 1 {name=p132873 lab=clkbuf_9_378_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 134180 -39710 0 0 {name=Xclkbuf_8_189_0_CLK }
C {devices/lab_pin.sym} 134090 -39590 0 0 {name=p132874 lab=_84329_/CLK }
C {devices/lab_pin.sym} 134090 -39570 0 0 {name=p132875 lab=_59804_/X }
C {devices/lab_pin.sym} 134270 -39590 0 1 {name=p132876 lab=_80455_/A }
C {sky130_stdcells/dfxtp_4.sym} 134180 -39580 0 0 {name=X_84697_ }
C {devices/lab_pin.sym} 134140 -39450 0 0 {name=p132877 lab=clkbuf_9_92_0_CLK/X }
C {devices/lab_pin.sym} 134220 -39450 0 1 {name=p132878 lab=_81282_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 134180 -39450 0 0 {name=Xclkbuf_10_184_0_CLK }
C {devices/lab_pin.sym} 134100 -39350 0 0 {name=p132879 lab=_58388_/X }
C {devices/lab_pin.sym} 134100 -39310 0 0 {name=p132880 lab=_83369_/Q }
C {devices/lab_pin.sym} 134100 -39270 0 0 {name=p132881 lab=_58403_/Y }
C {devices/lab_pin.sym} 134260 -39310 0 1 {name=p132882 lab=_84857_/D }
C {sky130_stdcells/o21a_4.sym} 134180 -39310 0 0 {name=X_58404_ }
C {devices/lab_pin.sym} 134140 -39170 0 0 {name=p132883 lab=_87334_/Q }
C {devices/lab_pin.sym} 134220 -39170 0 1 {name=p132884 lab=_68695_/B }
C {sky130_stdcells/inv_2.sym} 134180 -39170 0 0 {name=X_43630_ }
C {devices/lab_pin.sym} 134100 -39070 0 0 {name=p132885 lab=_55608_/X }
C {devices/lab_pin.sym} 134100 -39030 0 0 {name=p132886 lab=_55613_/X }
C {devices/lab_pin.sym} 134100 -38990 0 0 {name=p132887 lab=_55615_/X }
C {devices/lab_pin.sym} 134260 -39030 0 1 {name=p132888 lab=_55616_/X }
C {sky130_stdcells/a21o_4.sym} 134180 -39030 0 0 {name=X_55616_ }
C {devices/lab_pin.sym} 134100 -38910 0 0 {name=p132889 lab=_74448_/Y }
C {devices/lab_pin.sym} 134100 -38870 0 0 {name=p132890 lab=_72107_/X }
C {devices/lab_pin.sym} 134100 -38830 0 0 {name=p132891 lab=_74449_/Y }
C {devices/lab_pin.sym} 134260 -38870 0 1 {name=p132892 lab=_83064_/D }
C {sky130_stdcells/a21boi_4.sym} 134180 -38870 0 0 {name=X_74450_ }
C {devices/lab_pin.sym} 134090 -38730 0 0 {name=p132893 lab=_86436_/CLK }
C {devices/lab_pin.sym} 134090 -38710 0 0 {name=p132894 lab=_49183_/Y }
C {devices/lab_pin.sym} 134270 -38730 0 1 {name=p132895 lab=_65357_/B }
C {sky130_stdcells/dfxtp_4.sym} 134180 -38720 0 0 {name=X_86436_ }
C {devices/lab_pin.sym} 134100 -38610 0 0 {name=p132896 lab=_52824_/Y }
C {devices/lab_pin.sym} 134100 -38570 0 0 {name=p132897 lab=_52809_/X }
C {devices/lab_pin.sym} 134100 -38530 0 0 {name=p132898 lab=_52827_/X }
C {devices/lab_pin.sym} 134260 -38570 0 1 {name=p132899 lab=_52828_/Y }
C {sky130_stdcells/a21oi_4.sym} 134180 -38570 0 0 {name=X_52828_ }
C {devices/lab_pin.sym} 134140 -38430 0 0 {name=p132900 lab=_48904_/A }
C {devices/lab_pin.sym} 134220 -38430 0 1 {name=p132901 lab=_40842_/X }
C {sky130_stdcells/buf_2.sym} 134180 -38430 0 0 {name=X_40842_ }
C {devices/lab_pin.sym} 134120 -38330 0 0 {name=p132902 lab=_71660_/A }
C {devices/lab_pin.sym} 134120 -38290 0 0 {name=p132903 lab=_71256_/B }
C {devices/lab_pin.sym} 134120 -38250 0 0 {name=p132904 lab=_71660_/C }
C {devices/lab_pin.sym} 134240 -38290 0 1 {name=p132905 lab=_71662_/Y }
C {sky130_stdcells/nand3_4.sym} 134180 -38290 0 0 {name=X_71662_ }
C {devices/lab_pin.sym} 134090 -38150 0 0 {name=p132906 lab=_82774_/CLK }
C {devices/lab_pin.sym} 134090 -38130 0 0 {name=p132907 lab=_70965_/Y }
C {devices/lab_pin.sym} 134270 -38150 0 1 {name=p132908 lab=_83648_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -38140 0 0 {name=X_83648_ }
C {devices/lab_pin.sym} 134100 -38030 0 0 {name=p132909 lab=_59380_/Y }
C {devices/lab_pin.sym} 134100 -37990 0 0 {name=p132910 lab=_59383_/Y }
C {devices/lab_pin.sym} 134100 -37950 0 0 {name=p132911 lab=_59351_/X }
C {devices/lab_pin.sym} 134260 -37990 0 1 {name=p132912 lab=_59384_/X }
C {sky130_stdcells/a21o_4.sym} 134180 -37990 0 0 {name=X_59384_ }
C {devices/lab_pin.sym} 134140 -37850 0 0 {name=p132913 lab=_56596_/A }
C {devices/lab_pin.sym} 134220 -37850 0 1 {name=p132914 lab=_72652_/C }
C {sky130_stdcells/buf_2.sym} 134180 -37850 0 0 {name=X_56596_ }
C {devices/lab_pin.sym} 134120 -37740 0 0 {name=p132915 lab=_73353_/A }
C {devices/lab_pin.sym} 134120 -37700 0 0 {name=p132916 lab=_85864_/Q }
C {devices/lab_pin.sym} 134240 -37720 0 1 {name=p132917 lab=_73401_/X }
C {sky130_stdcells/and2_4.sym} 134180 -37720 0 0 {name=X_73401_ }
C {devices/lab_pin.sym} 134120 -37620 0 0 {name=p132918 lab=_70719_/A }
C {devices/lab_pin.sym} 134120 -37580 0 0 {name=p132919 lab=_70613_/B }
C {devices/lab_pin.sym} 134120 -37540 0 0 {name=p132920 lab=_70620_/C }
C {devices/lab_pin.sym} 134120 -37500 0 0 {name=p132921 lab=_70594_/X }
C {devices/lab_pin.sym} 134240 -37560 0 1 {name=p132922 lab=_70613_/Y }
C {sky130_stdcells/nand4_4.sym} 134180 -37560 0 0 {name=X_70613_ }
C {devices/lab_pin.sym} 134140 -37410 0 0 {name=p132923 lab=_58335_/A }
C {devices/lab_pin.sym} 134220 -37410 0 1 {name=p132924 lab=_58335_/Y }
C {sky130_stdcells/inv_2.sym} 134180 -37410 0 0 {name=X_58335_ }
C {devices/lab_pin.sym} 134140 -37290 0 0 {name=p132925 lab=_43217_/A }
C {devices/lab_pin.sym} 134220 -37290 0 1 {name=p132926 lab=_43561_/X }
C {sky130_stdcells/buf_2.sym} 134180 -37290 0 0 {name=X_43561_ }
C {devices/lab_pin.sym} 134120 -37180 0 0 {name=p132927 lab=_55477_/A }
C {devices/lab_pin.sym} 134120 -37140 0 0 {name=p132928 lab=_85144_/Q }
C {devices/lab_pin.sym} 134240 -37160 0 1 {name=p132929 lab=_55547_/X }
C {sky130_stdcells/and2_4.sym} 134180 -37160 0 0 {name=X_55547_ }
C {devices/lab_pin.sym} 134120 -37050 0 0 {name=p132930 lab=_74381_/A }
C {devices/lab_pin.sym} 134120 -37010 0 0 {name=p132931 lab=_72113_/B }
C {devices/lab_pin.sym} 134120 -36970 0 0 {name=p132932 lab=_74366_/C }
C {devices/lab_pin.sym} 134240 -37010 0 1 {name=p132933 lab=_74381_/X }
C {sky130_stdcells/and3_4.sym} 134180 -37010 0 0 {name=X_74381_ }
C {devices/lab_pin.sym} 134090 -36870 0 0 {name=p132934 lab=_83721_/CLK }
C {devices/lab_pin.sym} 134090 -36850 0 0 {name=p132935 lab=_86367_/D }
C {devices/lab_pin.sym} 134270 -36870 0 1 {name=p132936 lab=_86367_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -36860 0 0 {name=X_86367_ }
C {devices/lab_pin.sym} 134140 -36730 0 0 {name=p132937 lab=_40585_/A }
C {devices/lab_pin.sym} 134220 -36730 0 1 {name=p132938 lab=_40773_/X }
C {sky130_stdcells/buf_2.sym} 134180 -36730 0 0 {name=X_40773_ }
C {devices/lab_pin.sym} 134100 -36630 0 0 {name=p132939 lab=_52753_/Y }
C {devices/lab_pin.sym} 134100 -36590 0 0 {name=p132940 lab=_52755_/X }
C {devices/lab_pin.sym} 134100 -36550 0 0 {name=p132941 lab=_52758_/X }
C {devices/lab_pin.sym} 134260 -36590 0 1 {name=p132942 lab=_52759_/Y }
C {sky130_stdcells/a21oi_4.sym} 134180 -36590 0 0 {name=X_52759_ }
C {devices/lab_pin.sym} 134100 -36470 0 0 {name=p132943 lab=_71581_/X }
C {devices/lab_pin.sym} 134100 -36430 0 0 {name=p132944 lab=_83445_/Q }
C {devices/lab_pin.sym} 134100 -36390 0 0 {name=p132945 lab=_71592_/Y }
C {devices/lab_pin.sym} 134260 -36430 0 1 {name=p132946 lab=_83445_/D }
C {sky130_stdcells/a21o_4.sym} 134180 -36430 0 0 {name=X_71593_ }
C {devices/lab_pin.sym} 134090 -36290 0 0 {name=p132947 lab=_86193_/CLK }
C {devices/lab_pin.sym} 134090 -36270 0 0 {name=p132948 lab=_71184_/Y }
C {devices/lab_pin.sym} 134270 -36290 0 1 {name=p132949 lab=_83579_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -36280 0 0 {name=X_83579_ }
C {devices/lab_pin.sym} 134140 -36150 0 0 {name=p132950 lab=clkbuf_7_56_0_CLK/X }
C {devices/lab_pin.sym} 134220 -36150 0 1 {name=p132951 lab=clkbuf_8_112_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 134180 -36150 0 0 {name=Xclkbuf_8_112_0_CLK }
C {devices/lab_pin.sym} 134100 -36050 0 0 {name=p132952 lab=_85159_/Q }
C {devices/lab_pin.sym} 134100 -36010 0 0 {name=p132953 lab=_45284_/X }
C {devices/lab_pin.sym} 134100 -35970 0 0 {name=p132954 lab=_45265_/X }
C {devices/lab_pin.sym} 134260 -36010 0 1 {name=p132955 lab=_45300_/X }
C {sky130_stdcells/o21a_4.sym} 134180 -36010 0 0 {name=X_45300_ }
C {devices/lab_pin.sym} 134120 -35880 0 0 {name=p132956 lab=_76117_/Y }
C {devices/lab_pin.sym} 134120 -35840 0 0 {name=p132957 lab=_76119_/Y }
C {devices/lab_pin.sym} 134240 -35860 0 1 {name=p132958 lab=_76121_/B }
C {sky130_stdcells/xor2_4.sym} 134180 -35860 0 0 {name=X_76120_ }
C {devices/lab_pin.sym} 134140 -35730 0 0 {name=p132959 lab=_42511_/Y }
C {devices/lab_pin.sym} 134220 -35730 0 1 {name=p132960 lab=_42512_/Y }
C {sky130_stdcells/inv_2.sym} 134180 -35730 0 0 {name=X_42512_ }
C {devices/lab_pin.sym} 134090 -35610 0 0 {name=p132961 lab=_88111_/CLK }
C {devices/lab_pin.sym} 134090 -35590 0 0 {name=p132962 lab=_41917_/Y }
C {devices/lab_pin.sym} 134270 -35610 0 1 {name=p132963 lab=_88106_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -35600 0 0 {name=X_88106_ }
C {devices/lab_pin.sym} 134100 -35500 0 0 {name=p132964 lab=_72908_/X }
C {devices/lab_pin.sym} 134100 -35460 0 0 {name=p132965 lab=_85579_/Q }
C {devices/lab_pin.sym} 134100 -35420 0 0 {name=p132966 lab=_72909_/X }
C {devices/lab_pin.sym} 134100 -35380 0 0 {name=p132967 lab=_73331_/X }
C {devices/lab_pin.sym} 134260 -35440 0 1 {name=p132968 lab=_73332_/X }
C {sky130_stdcells/a211o_4.sym} 134180 -35440 0 0 {name=X_73332_ }
C {devices/lab_pin.sym} 134090 -35290 0 0 {name=p132969 lab=_85317_/CLK }
C {devices/lab_pin.sym} 134090 -35270 0 0 {name=p132970 lab=_85318_/D }
C {devices/lab_pin.sym} 134270 -35290 0 1 {name=p132971 lab=_85318_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -35280 0 0 {name=X_85318_ }
C {devices/lab_pin.sym} 134140 -35150 0 0 {name=p132972 lab=_46280_/A }
C {devices/lab_pin.sym} 134220 -35150 0 1 {name=p132973 lab=_46326_/A }
C {sky130_stdcells/buf_2.sym} 134180 -35150 0 0 {name=X_46280_ }
C {devices/lab_pin.sym} 134140 -35030 0 0 {name=p132974 lab=_70543_/Y }
C {devices/lab_pin.sym} 134220 -35030 0 1 {name=p132975 lab=_71586_/A }
C {sky130_stdcells/buf_2.sym} 134180 -35030 0 0 {name=X_70544_ }
C {devices/lab_pin.sym} 134100 -34930 0 0 {name=p132976 lab=_58253_/X }
C {devices/lab_pin.sym} 134100 -34890 0 0 {name=p132977 lab=_83445_/Q }
C {devices/lab_pin.sym} 134100 -34850 0 0 {name=p132978 lab=_58265_/Y }
C {devices/lab_pin.sym} 134260 -34890 0 1 {name=p132979 lab=_84893_/D }
C {sky130_stdcells/o21a_4.sym} 134180 -34890 0 0 {name=X_58266_ }
C {devices/lab_pin.sym} 134100 -34780 0 0 {name=p132980 lab=_82995_/Q }
C {devices/lab_pin.sym} 134100 -34740 0 0 {name=p132981 lab=_55475_/X }
C {devices/lab_pin.sym} 134100 -34700 0 0 {name=p132982 lab=_44097_/X }
C {devices/lab_pin.sym} 134100 -34660 0 0 {name=p132983 lab=_55477_/X }
C {devices/lab_pin.sym} 134260 -34720 0 1 {name=p132984 lab=_55478_/X }
C {sky130_stdcells/a211o_4.sym} 134180 -34720 0 0 {name=X_55478_ }
C {devices/lab_pin.sym} 134100 -34600 0 0 {name=p132985 lab=_41721_/X }
C {devices/lab_pin.sym} 134100 -34560 0 0 {name=p132986 lab=_43484_/X }
C {devices/lab_pin.sym} 134100 -34520 0 0 {name=p132987 lab=_87394_/Q }
C {devices/lab_pin.sym} 134100 -34480 0 0 {name=p132988 lab=_43485_/X }
C {devices/lab_pin.sym} 134260 -34540 0 1 {name=p132989 lab=_43492_/X }
C {sky130_stdcells/a2bb2o_4.sym} 134180 -34540 0 0 {name=X_43492_ }
C {devices/lab_pin.sym} 134140 -34390 0 0 {name=p132990 lab=clkbuf_9_99_0_CLK/X }
C {devices/lab_pin.sym} 134220 -34390 0 1 {name=p132991 lab=_84672_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 134180 -34390 0 0 {name=Xclkbuf_10_199_0_CLK }
C {devices/lab_pin.sym} 134090 -34270 0 0 {name=p132992 lab=_86297_/CLK }
C {devices/lab_pin.sym} 134090 -34250 0 0 {name=p132993 lab=_86298_/D }
C {devices/lab_pin.sym} 134270 -34270 0 1 {name=p132994 lab=_86298_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -34260 0 0 {name=X_86298_ }
C {devices/lab_pin.sym} 134140 -34130 0 0 {name=p132995 lab=_83020_/Q }
C {devices/lab_pin.sym} 134220 -34130 0 1 {name=p132996 lab=_45232_/A }
C {sky130_stdcells/inv_2.sym} 134180 -34130 0 0 {name=X_45231_ }
C {devices/lab_pin.sym} 134120 -34020 0 0 {name=p132997 lab=_57179_/A }
C {devices/lab_pin.sym} 134120 -33980 0 0 {name=p132998 lab=_57217_/B }
C {devices/lab_pin.sym} 134240 -34000 0 1 {name=p132999 lab=_57217_/Y }
C {sky130_stdcells/nand2_4.sym} 134180 -34000 0 0 {name=X_57217_ }
C {devices/lab_pin.sym} 134100 -33890 0 0 {name=p133000 lab=_76042_/Y }
C {devices/lab_pin.sym} 134100 -33850 0 0 {name=p133001 lab=_76049_/Y }
C {devices/lab_pin.sym} 134100 -33810 0 0 {name=p133002 lab=_76050_/Y }
C {devices/lab_pin.sym} 134260 -33850 0 1 {name=p133003 lab=_76051_/X }
C {sky130_stdcells/o21a_4.sym} 134180 -33850 0 0 {name=X_76051_ }
C {devices/lab_pin.sym} 134090 -33710 0 0 {name=p133004 lab=_88044_/CLK }
C {devices/lab_pin.sym} 134090 -33690 0 0 {name=p133005 lab=_88037_/D }
C {devices/lab_pin.sym} 134270 -33710 0 1 {name=p133006 lab=_88037_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -33700 0 0 {name=X_88037_ }
C {devices/lab_pin.sym} 134120 -33600 0 0 {name=p133007 lab=_54435_/A }
C {devices/lab_pin.sym} 134120 -33560 0 0 {name=p133008 lab=_54417_/B }
C {devices/lab_pin.sym} 134120 -33520 0 0 {name=p133009 lab=_54429_/C }
C {devices/lab_pin.sym} 134120 -33480 0 0 {name=p133010 lab=_46894_/Y }
C {devices/lab_pin.sym} 134240 -33540 0 1 {name=p133011 lab=_54429_/X }
C {sky130_stdcells/and4_4.sym} 134180 -33540 0 0 {name=X_54429_ }
C {devices/lab_pin.sym} 134100 -33420 0 0 {name=p133012 lab=_40542_/X }
C {devices/lab_pin.sym} 134100 -33380 0 0 {name=p133013 lab=_42434_/X }
C {devices/lab_pin.sym} 134100 -33340 0 0 {name=p133014 lab=_87861_/Q }
C {devices/lab_pin.sym} 134100 -33300 0 0 {name=p133015 lab=_42435_/X }
C {devices/lab_pin.sym} 134260 -33360 0 1 {name=p133016 lab=_87861_/D }
C {sky130_stdcells/a2bb2o_4.sym} 134180 -33360 0 0 {name=X_42443_ }
C {devices/lab_pin.sym} 134100 -33230 0 0 {name=p133017 lab=_73259_/X }
C {devices/lab_pin.sym} 134100 -33190 0 0 {name=p133018 lab=_73261_/X }
C {devices/lab_pin.sym} 134100 -33150 0 0 {name=p133019 lab=_73262_/X }
C {devices/lab_pin.sym} 134260 -33190 0 1 {name=p133020 lab=_73267_/A }
C {sky130_stdcells/a21o_4.sym} 134180 -33190 0 0 {name=X_73263_ }
C {devices/lab_pin.sym} 134090 -33050 0 0 {name=p133021 lab=_85249_/CLK }
C {devices/lab_pin.sym} 134090 -33030 0 0 {name=p133022 lab=_85249_/D }
C {devices/lab_pin.sym} 134270 -33050 0 1 {name=p133023 lab=_56287_/C }
C {sky130_stdcells/dfxtp_4.sym} 134180 -33040 0 0 {name=X_85249_ }
C {devices/lab_pin.sym} 134140 -32910 0 0 {name=p133024 lab=_71483_/B }
C {devices/lab_pin.sym} 134220 -32910 0 1 {name=p133025 lab=_70483_/B }
C {sky130_stdcells/buf_2.sym} 134180 -32910 0 0 {name=X_70475_ }
C {devices/lab_pin.sym} 134140 -32790 0 0 {name=p133026 lab=_84910_/Q }
C {devices/lab_pin.sym} 134220 -32790 0 1 {name=p133027 lab=_58198_/A }
C {sky130_stdcells/buf_2.sym} 134180 -32790 0 0 {name=X_58197_ }
C {devices/lab_pin.sym} 134120 -32680 0 0 {name=p133028 lab=_81143_/D }
C {devices/lab_pin.sym} 134120 -32640 0 0 {name=p133029 lab=_75003_/B }
C {devices/lab_pin.sym} 134240 -32660 0 1 {name=p133030 lab=_75002_/Y }
C {sky130_stdcells/nor2_4.sym} 134180 -32660 0 0 {name=X_75002_ }
C {devices/lab_pin.sym} 134140 -32530 0 0 {name=p133031 lab=_72214_/A }
C {devices/lab_pin.sym} 134220 -32530 0 1 {name=p133032 lab=_72214_/Y }
C {sky130_stdcells/inv_2.sym} 134180 -32530 0 0 {name=X_72214_ }
C {devices/lab_pin.sym} 134100 -32430 0 0 {name=p133033 lab=_55836_/B }
C {devices/lab_pin.sym} 134100 -32390 0 0 {name=p133034 lab=_45131_/X }
C {devices/lab_pin.sym} 134100 -32350 0 0 {name=p133035 lab=_45161_/X }
C {devices/lab_pin.sym} 134260 -32390 0 1 {name=p133036 lab=_45162_/X }
C {sky130_stdcells/o21a_4.sym} 134180 -32390 0 0 {name=X_45162_ }
C {devices/lab_pin.sym} 134140 -32250 0 0 {name=p133037 lab=_57147_/X }
C {devices/lab_pin.sym} 134220 -32250 0 1 {name=p133038 lab=_85072_/D }
C {sky130_stdcells/inv_2.sym} 134180 -32250 0 0 {name=X_57148_ }
C {devices/lab_pin.sym} 134140 -32130 0 0 {name=p133039 lab=_42373_/X }
C {devices/lab_pin.sym} 134220 -32130 0 1 {name=p133040 lab=_42374_/X }
C {sky130_stdcells/buf_2.sym} 134180 -32130 0 0 {name=X_42374_ }
C {devices/lab_pin.sym} 134140 -32010 0 0 {name=p133041 lab=_72725_/A }
C {devices/lab_pin.sym} 134220 -32010 0 1 {name=p133042 lab=_73194_/X }
C {sky130_stdcells/buf_2.sym} 134180 -32010 0 0 {name=X_73194_ }
C {devices/lab_pin.sym} 134140 -31890 0 0 {name=p133043 lab=clkbuf_7_63_0_CLK/X }
C {devices/lab_pin.sym} 134220 -31890 0 1 {name=p133044 lab=clkbuf_9_255_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 134180 -31890 0 0 {name=Xclkbuf_8_127_0_CLK }
C {devices/lab_pin.sym} 134140 -31770 0 0 {name=p133045 lab=clkbuf_9_61_0_CLK/X }
C {devices/lab_pin.sym} 134220 -31770 0 1 {name=p133046 lab=_84287_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 134180 -31770 0 0 {name=Xclkbuf_10_122_0_CLK }
C {devices/lab_pin.sym} 134140 -31650 0 0 {name=p133047 lab=_44112_/X }
C {devices/lab_pin.sym} 134220 -31650 0 1 {name=p133048 lab=_44113_/X }
C {sky130_stdcells/buf_2.sym} 134180 -31650 0 0 {name=X_44113_ }
C {devices/lab_pin.sym} 134100 -31560 0 0 {name=p133049 lab=_79782_/X }
C {devices/lab_pin.sym} 134100 -31520 0 0 {name=p133050 lab=_79785_/Y }
C {devices/lab_pin.sym} 134100 -31480 0 0 {name=p133051 lab=_79795_/X }
C {devices/lab_pin.sym} 134100 -31440 0 0 {name=p133052 lab=_79798_/Y }
C {devices/lab_pin.sym} 134260 -31500 0 1 {name=p133053 lab=_79810_/X }
C {sky130_stdcells/o22a_4.sym} 134180 -31500 0 0 {name=X_79810_ }
C {devices/lab_pin.sym} 134140 -31350 0 0 {name=p133054 lab=_41186_/A }
C {devices/lab_pin.sym} 134220 -31350 0 1 {name=p133055 lab=_41325_/X }
C {sky130_stdcells/buf_2.sym} 134180 -31350 0 0 {name=X_41325_ }
C {devices/lab_pin.sym} 134100 -31250 0 0 {name=p133056 lab=_72143_/X }
C {devices/lab_pin.sym} 134100 -31210 0 0 {name=p133057 lab=_85375_/Q }
C {devices/lab_pin.sym} 134100 -31170 0 0 {name=p133058 lab=_72144_/X }
C {devices/lab_pin.sym} 134260 -31210 0 1 {name=p133059 lab=_72145_/Y }
C {sky130_stdcells/o21ai_4.sym} 134180 -31210 0 0 {name=X_72145_ }
C {devices/lab_pin.sym} 134100 -31090 0 0 {name=p133060 lab=_49967_/Y }
C {devices/lab_pin.sym} 134100 -31050 0 0 {name=p133061 lab=_49951_/X }
C {devices/lab_pin.sym} 134100 -31010 0 0 {name=p133062 lab=_49969_/X }
C {devices/lab_pin.sym} 134260 -31050 0 1 {name=p133063 lab=_49970_/Y }
C {sky130_stdcells/a21oi_4.sym} 134180 -31050 0 0 {name=X_49970_ }
C {devices/lab_pin.sym} 134100 -30930 0 0 {name=p133064 lab=_55879_/B }
C {devices/lab_pin.sym} 134100 -30890 0 0 {name=p133065 lab=_45044_/X }
C {devices/lab_pin.sym} 134100 -30850 0 0 {name=p133066 lab=_45079_/X }
C {devices/lab_pin.sym} 134260 -30890 0 1 {name=p133067 lab=_45093_/X }
C {sky130_stdcells/o21a_4.sym} 134180 -30890 0 0 {name=X_45093_ }
C {devices/lab_pin.sym} 134140 -30750 0 0 {name=p133068 lab=_57319_/D }
C {devices/lab_pin.sym} 134220 -30750 0 1 {name=p133069 lab=_57318_/D }
C {sky130_stdcells/buf_2.sym} 134180 -30750 0 0 {name=X_57079_ }
C {devices/lab_pin.sym} 134140 -30630 0 0 {name=p133070 lab=clkbuf_9_376_0_CLK/X }
C {devices/lab_pin.sym} 134220 -30630 0 1 {name=p133071 lab=_87260_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 134180 -30630 0 0 {name=Xclkbuf_10_752_0_CLK }
C {devices/lab_pin.sym} 134140 -30510 0 0 {name=p133072 lab=_48920_/Y }
C {devices/lab_pin.sym} 134220 -30510 0 1 {name=p133073 lab=_48922_/B }
C {sky130_stdcells/buf_2.sym} 134180 -30510 0 0 {name=X_48921_ }
C {devices/lab_pin.sym} 134140 -30390 0 0 {name=p133074 lab=_44043_/X }
C {devices/lab_pin.sym} 134220 -30390 0 1 {name=p133075 lab=_44044_/X }
C {sky130_stdcells/buf_2.sym} 134180 -30390 0 0 {name=X_44044_ }
C {devices/lab_pin.sym} 134120 -30280 0 0 {name=p133076 lab=_84220_/Q }
C {devices/lab_pin.sym} 134120 -30240 0 0 {name=p133077 lab=_83268_/Q }
C {devices/lab_pin.sym} 134240 -30260 0 1 {name=p133078 lab=_79741_/X }
C {sky130_stdcells/xor2_4.sym} 134180 -30260 0 0 {name=X_79741_ }
C {devices/lab_pin.sym} 134140 -30130 0 0 {name=p133079 lab=_41186_/A }
C {devices/lab_pin.sym} 134220 -30130 0 1 {name=p133080 lab=_41280_/B }
C {sky130_stdcells/buf_2.sym} 134180 -30130 0 0 {name=X_41256_ }
C {devices/lab_pin.sym} 134100 -30050 0 0 {name=p133081 lab=_59971_/X }
C {devices/lab_pin.sym} 134100 -30010 0 0 {name=p133082 lab=_60003_/Y }
C {devices/lab_pin.sym} 134100 -29970 0 0 {name=p133083 lab=_60092_/B }
C {devices/lab_pin.sym} 134100 -29930 0 0 {name=p133084 lab=_60087_/Y }
C {devices/lab_pin.sym} 134100 -29900 0 0 {name=p133085 lab=_60089_/Y }
C {devices/lab_pin.sym} 134260 -29970 0 1 {name=p133086 lab=_84664_/D }
C {sky130_stdcells/a41oi_4.sym} 134180 -29970 0 0 {name=X_60090_ }
C {devices/lab_pin.sym} 134100 -29830 0 0 {name=p133087 lab=_72073_/Y }
C {devices/lab_pin.sym} 134100 -29790 0 0 {name=p133088 lab=_72033_/X }
C {devices/lab_pin.sym} 134100 -29750 0 0 {name=p133089 lab=_72075_/Y }
C {devices/lab_pin.sym} 134260 -29790 0 1 {name=p133090 lab=_83290_/D }
C {sky130_stdcells/a21boi_4.sym} 134180 -29790 0 0 {name=X_72076_ }
C {devices/lab_pin.sym} 134120 -29670 0 0 {name=p133091 lab=_76953_/A }
C {devices/lab_pin.sym} 134120 -29630 0 0 {name=p133092 lab=_76953_/B }
C {devices/lab_pin.sym} 134120 -29590 0 0 {name=p133093 lab=_76951_/A }
C {devices/lab_pin.sym} 134240 -29630 0 1 {name=p133094 lab=_76957_/C }
C {sky130_stdcells/nand3_4.sym} 134180 -29630 0 0 {name=X_76953_ }
C {devices/lab_pin.sym} 134140 -29490 0 0 {name=p133095 lab=clkbuf_9_243_0_CLK/A }
C {devices/lab_pin.sym} 134220 -29490 0 1 {name=p133096 lab=clkbuf_9_243_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 134180 -29490 0 0 {name=Xclkbuf_9_243_0_CLK }
C {devices/lab_pin.sym} 134120 -29400 0 0 {name=p133097 lab=_71173_/A }
C {devices/lab_pin.sym} 134120 -29360 0 0 {name=p133098 lab=_71030_/B }
C {devices/lab_pin.sym} 134120 -29320 0 0 {name=p133099 lab=_71030_/C }
C {devices/lab_pin.sym} 134120 -29280 0 0 {name=p133100 lab=_71018_/D }
C {devices/lab_pin.sym} 134240 -29340 0 1 {name=p133101 lab=_71027_/Y }
C {sky130_stdcells/nand4_4.sym} 134180 -29340 0 0 {name=X_71027_ }
C {devices/lab_pin.sym} 134120 -29200 0 0 {name=p133102 lab=_84502_/Q }
C {devices/lab_pin.sym} 134120 -29160 0 0 {name=p133103 lab=_84374_/Q }
C {devices/lab_pin.sym} 134240 -29180 0 1 {name=p133104 lab=_75904_/X }
C {sky130_stdcells/xor2_4.sym} 134180 -29180 0 0 {name=X_75904_ }
C {devices/lab_pin.sym} 134100 -29070 0 0 {name=p133105 lab=_86470_/Q }
C {devices/lab_pin.sym} 134100 -29030 0 0 {name=p133106 lab=_48836_/X }
C {devices/lab_pin.sym} 134100 -28990 0 0 {name=p133107 lab=_48851_/Y }
C {devices/lab_pin.sym} 134260 -29030 0 1 {name=p133108 lab=_48852_/Y }
C {sky130_stdcells/o21ai_4.sym} 134180 -29030 0 0 {name=X_48852_ }
C {devices/lab_pin.sym} 134120 -28900 0 0 {name=p133109 lab=_79670_/X }
C {devices/lab_pin.sym} 134120 -28860 0 0 {name=p133110 lab=_79677_/B }
C {devices/lab_pin.sym} 134240 -28880 0 1 {name=p133111 lab=_79672_/Y }
C {sky130_stdcells/xnor2_4.sym} 134180 -28880 0 0 {name=X_79672_ }
C {devices/lab_pin.sym} 134120 -28760 0 0 {name=p133112 lab=_81715_/Q }
C {devices/lab_pin.sym} 134120 -28720 0 0 {name=p133113 lab=_41197_/B }
C {devices/lab_pin.sym} 134240 -28740 0 1 {name=p133114 lab=_41187_/X }
C {sky130_stdcells/or2_4.sym} 134180 -28740 0 0 {name=X_41187_ }
C {devices/lab_pin.sym} 134120 -28620 0 0 {name=p133115 lab=_81676_/Q }
C {devices/lab_pin.sym} 134120 -28580 0 0 {name=p133116 lab=_76884_/B }
C {devices/lab_pin.sym} 134240 -28600 0 1 {name=p133117 lab=_76884_/X }
C {sky130_stdcells/xor2_4.sym} 134180 -28600 0 0 {name=X_76884_ }
C {devices/lab_pin.sym} 134140 -28470 0 0 {name=p133118 lab=clkbuf_9_68_0_CLK/X }
C {devices/lab_pin.sym} 134220 -28470 0 1 {name=p133119 lab=_81260_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 134180 -28470 0 0 {name=Xclkbuf_10_137_0_CLK }
C {devices/lab_pin.sym} 134140 -28350 0 0 {name=p133120 lab=_47803_/A }
C {devices/lab_pin.sym} 134220 -28350 0 1 {name=p133121 lab=_53253_/D }
C {sky130_stdcells/buf_2.sym} 134180 -28350 0 0 {name=X_47803_ }
C {devices/lab_pin.sym} 134120 -28240 0 0 {name=p133122 lab=_78623_/A }
C {devices/lab_pin.sym} 134120 -28200 0 0 {name=p133123 lab=_78623_/B }
C {devices/lab_pin.sym} 134240 -28220 0 1 {name=p133124 lab=_78640_/B }
C {sky130_stdcells/nand2_4.sym} 134180 -28220 0 0 {name=X_78623_ }
C {devices/lab_pin.sym} 134100 -28110 0 0 {name=p133125 lab=_75793_/B }
C {devices/lab_pin.sym} 134100 -28070 0 0 {name=p133126 lab=_75832_/X }
C {devices/lab_pin.sym} 134100 -28030 0 0 {name=p133127 lab=_75834_/X }
C {devices/lab_pin.sym} 134260 -28070 0 1 {name=p133128 lab=_75836_/B }
C {sky130_stdcells/a21boi_4.sym} 134180 -28070 0 0 {name=X_75835_ }
C {devices/lab_pin.sym} 134140 -27930 0 0 {name=p133129 lab=clkbuf_9_383_0_CLK/X }
C {devices/lab_pin.sym} 134220 -27930 0 1 {name=p133130 lab=_87544_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 134180 -27930 0 0 {name=Xclkbuf_10_767_0_CLK }
C {devices/lab_pin.sym} 134120 -27820 0 0 {name=p133131 lab=_48793_/A }
C {devices/lab_pin.sym} 134120 -27780 0 0 {name=p133132 lab=_50466_/B }
C {devices/lab_pin.sym} 134240 -27800 0 1 {name=p133133 lab=_48783_/Y }
C {sky130_stdcells/nand2_4.sym} 134180 -27800 0 0 {name=X_48783_ }
C {devices/lab_pin.sym} 134140 -27670 0 0 {name=p133134 lab=_45981_/X }
C {devices/lab_pin.sym} 134220 -27670 0 1 {name=p133135 lab=_45995_/X }
C {sky130_stdcells/buf_2.sym} 134180 -27670 0 0 {name=X_45995_ }
C {devices/lab_pin.sym} 134140 -27550 0 0 {name=p133136 lab=_62679_/X }
C {devices/lab_pin.sym} 134220 -27550 0 1 {name=p133137 lab=_62834_/B }
C {sky130_stdcells/buf_2.sym} 134180 -27550 0 0 {name=X_62800_ }
C {devices/lab_pin.sym} 134140 -27430 0 0 {name=p133138 lab=_54907_/B }
C {devices/lab_pin.sym} 134220 -27430 0 1 {name=p133139 lab=_53213_/B }
C {sky130_stdcells/buf_2.sym} 134180 -27430 0 0 {name=X_47734_ }
C {devices/lab_pin.sym} 134120 -27320 0 0 {name=p133140 lab=_78554_/A }
C {devices/lab_pin.sym} 134120 -27280 0 0 {name=p133141 lab=_78554_/B }
C {devices/lab_pin.sym} 134240 -27300 0 1 {name=p133142 lab=_78555_/A }
C {sky130_stdcells/nor2_4.sym} 134180 -27300 0 0 {name=X_78554_ }
C {devices/lab_pin.sym} 134100 -27190 0 0 {name=p133143 lab=_55960_/B }
C {devices/lab_pin.sym} 134100 -27150 0 0 {name=p133144 lab=_44882_/X }
C {devices/lab_pin.sym} 134100 -27110 0 0 {name=p133145 lab=_44884_/X }
C {devices/lab_pin.sym} 134260 -27150 0 1 {name=p133146 lab=_44946_/X }
C {sky130_stdcells/o21a_4.sym} 134180 -27150 0 0 {name=X_44946_ }
C {devices/lab_pin.sym} 134120 -27040 0 0 {name=p133147 lab=_61762_/X }
C {devices/lab_pin.sym} 134120 -27000 0 0 {name=p133148 lab=_63738_/B }
C {devices/lab_pin.sym} 134120 -26960 0 0 {name=p133149 lab=_63738_/C }
C {devices/lab_pin.sym} 134120 -26920 0 0 {name=p133150 lab=_63738_/D }
C {devices/lab_pin.sym} 134240 -26980 0 1 {name=p133151 lab=_63780_/Y }
C {sky130_stdcells/nand4_4.sym} 134180 -26980 0 0 {name=X_63780_ }
C {devices/lab_pin.sym} 134140 -26830 0 0 {name=p133152 lab=clkbuf_9_259_0_CLK/A }
C {devices/lab_pin.sym} 134220 -26830 0 1 {name=p133153 lab=clkbuf_9_258_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 134180 -26830 0 0 {name=Xclkbuf_9_258_0_CLK }
C {devices/lab_pin.sym} 134120 -26720 0 0 {name=p133154 lab=_75766_/A }
C {devices/lab_pin.sym} 134120 -26680 0 0 {name=p133155 lab=_75765_/Y }
C {devices/lab_pin.sym} 134240 -26700 0 1 {name=p133156 lab=_80887_/D }
C {sky130_stdcells/xnor2_4.sym} 134180 -26700 0 0 {name=X_75766_ }
C {devices/lab_pin.sym} 134140 -26570 0 0 {name=p133157 lab=_60910_/B }
C {devices/lab_pin.sym} 134220 -26570 0 1 {name=p133158 lab=_60992_/X }
C {sky130_stdcells/buf_2.sym} 134180 -26570 0 0 {name=X_60992_ }
C {devices/lab_pin.sym} 134140 -26450 0 0 {name=p133159 lab=_72978_/A }
C {devices/lab_pin.sym} 134220 -26450 0 1 {name=p133160 lab=_72978_/X }
C {sky130_stdcells/buf_2.sym} 134180 -26450 0 0 {name=X_72978_ }
C {devices/lab_pin.sym} 134140 -26330 0 0 {name=p133161 lab=_82229_/Q }
C {devices/lab_pin.sym} 134220 -26330 0 1 {name=p133162 lab=_77505_/Y }
C {sky130_stdcells/inv_2.sym} 134180 -26330 0 0 {name=X_77505_ }
C {devices/lab_pin.sym} 134120 -26240 0 0 {name=p133163 lab=_62731_/A }
C {devices/lab_pin.sym} 134120 -26200 0 0 {name=p133164 lab=_63081_/A }
C {devices/lab_pin.sym} 134120 -26160 0 0 {name=p133165 lab=_62704_/C }
C {devices/lab_pin.sym} 134120 -26120 0 0 {name=p133166 lab=_62717_/X }
C {devices/lab_pin.sym} 134240 -26180 0 1 {name=p133167 lab=_62731_/X }
C {sky130_stdcells/and4_4.sym} 134180 -26180 0 0 {name=X_62731_ }
C {devices/lab_pin.sym} 134140 -26030 0 0 {name=p133168 lab=_71266_/A }
C {devices/lab_pin.sym} 134220 -26030 0 1 {name=p133169 lab=_74739_/B }
C {sky130_stdcells/buf_2.sym} 134180 -26030 0 0 {name=X_74717_ }
C {devices/lab_pin.sym} 134100 -25930 0 0 {name=p133170 lab=_47660_/Y }
C {devices/lab_pin.sym} 134100 -25890 0 0 {name=p133171 lab=_47651_/X }
C {devices/lab_pin.sym} 134100 -25850 0 0 {name=p133172 lab=_47664_/X }
C {devices/lab_pin.sym} 134260 -25890 0 1 {name=p133173 lab=_86611_/D }
C {sky130_stdcells/a21oi_4.sym} 134180 -25890 0 0 {name=X_47665_ }
C {devices/lab_pin.sym} 134100 -25770 0 0 {name=p133174 lab=_57010_/Y }
C {devices/lab_pin.sym} 134100 -25730 0 0 {name=p133175 lab=_71917_/X }
C {devices/lab_pin.sym} 134100 -25690 0 0 {name=p133176 lab=_71928_/Y }
C {devices/lab_pin.sym} 134260 -25730 0 1 {name=p133177 lab=_83325_/D }
C {sky130_stdcells/o21ai_4.sym} 134180 -25730 0 0 {name=X_71929_ }
C {devices/lab_pin.sym} 134140 -25590 0 0 {name=p133178 lab=_78484_/Y }
C {devices/lab_pin.sym} 134220 -25590 0 1 {name=p133179 lab=_78485_/Y }
C {sky130_stdcells/inv_2.sym} 134180 -25590 0 0 {name=X_78485_ }
C {devices/lab_pin.sym} 134100 -25490 0 0 {name=p133180 lab=_56192_/C }
C {devices/lab_pin.sym} 134100 -25450 0 0 {name=p133181 lab=_45604_/B }
C {devices/lab_pin.sym} 134100 -25410 0 0 {name=p133182 lab=_44876_/X }
C {devices/lab_pin.sym} 134260 -25450 0 1 {name=p133183 lab=_44877_/Y }
C {sky130_stdcells/o21ai_4.sym} 134180 -25450 0 0 {name=X_44877_ }
C {devices/lab_pin.sym} 134120 -25320 0 0 {name=p133184 lab=_75685_/A }
C {devices/lab_pin.sym} 134120 -25280 0 0 {name=p133185 lab=_75692_/A }
C {devices/lab_pin.sym} 134240 -25300 0 1 {name=p133186 lab=_75697_/X }
C {sky130_stdcells/and2_4.sym} 134180 -25300 0 0 {name=X_75697_ }
C {devices/lab_pin.sym} 134100 -25190 0 0 {name=p133187 lab=_86393_/Q }
C {devices/lab_pin.sym} 134100 -25150 0 0 {name=p133188 lab=_49388_/X }
C {devices/lab_pin.sym} 134100 -25110 0 0 {name=p133189 lab=_49403_/Y }
C {devices/lab_pin.sym} 134260 -25150 0 1 {name=p133190 lab=_49404_/Y }
C {sky130_stdcells/o21ai_4.sym} 134180 -25150 0 0 {name=X_49404_ }
C {devices/lab_pin.sym} 134140 -25010 0 0 {name=p133191 lab=_46616_/A }
C {devices/lab_pin.sym} 134220 -25010 0 1 {name=p133192 lab=_46617_/A }
C {sky130_stdcells/buf_2.sym} 134180 -25010 0 0 {name=X_46616_ }
C {devices/lab_pin.sym} 134100 -24910 0 0 {name=p133193 lab=_65447_/Y }
C {devices/lab_pin.sym} 134100 -24870 0 0 {name=p133194 lab=_65448_/X }
C {devices/lab_pin.sym} 134100 -24830 0 0 {name=p133195 lab=_65449_/X }
C {devices/lab_pin.sym} 134260 -24870 0 1 {name=p133196 lab=_84200_/D }
C {sky130_stdcells/a21o_4.sym} 134180 -24870 0 0 {name=X_65450_ }
C {devices/lab_pin.sym} 134120 -24740 0 0 {name=p133197 lab=_77415_/X }
C {devices/lab_pin.sym} 134120 -24700 0 0 {name=p133198 lab=_77435_/Y }
C {devices/lab_pin.sym} 134240 -24720 0 1 {name=p133199 lab=_77436_/Y }
C {sky130_stdcells/nand2_4.sym} 134180 -24720 0 0 {name=X_77436_ }
C {devices/lab_pin.sym} 134100 -24620 0 0 {name=p133200 lab=_41134_/X }
C {devices/lab_pin.sym} 134100 -24580 0 0 {name=p133201 lab=_43817_/X }
C {devices/lab_pin.sym} 134100 -24540 0 0 {name=p133202 lab=_87247_/Q }
C {devices/lab_pin.sym} 134100 -24500 0 0 {name=p133203 lab=_43818_/X }
C {devices/lab_pin.sym} 134260 -24560 0 1 {name=p133204 lab=_43828_/X }
C {sky130_stdcells/a2bb2o_4.sym} 134180 -24560 0 0 {name=X_43828_ }
C {devices/lab_pin.sym} 134100 -24430 0 0 {name=p133205 lab=_56613_/A }
C {devices/lab_pin.sym} 134100 -24390 0 0 {name=p133206 lab=_74641_/X }
C {devices/lab_pin.sym} 134100 -24350 0 0 {name=p133207 lab=_74647_/Y }
C {devices/lab_pin.sym} 134260 -24390 0 1 {name=p133208 lab=_83001_/D }
C {sky130_stdcells/a21boi_4.sym} 134180 -24390 0 0 {name=X_74648_ }
C {devices/lab_pin.sym} 134140 -24250 0 0 {name=p133209 lab=_62646_/B }
C {devices/lab_pin.sym} 134220 -24250 0 1 {name=p133210 lab=_62664_/B }
C {sky130_stdcells/buf_2.sym} 134180 -24250 0 0 {name=X_62662_ }
C {devices/lab_pin.sym} 134100 -24150 0 0 {name=p133211 lab=_47592_/Y }
C {devices/lab_pin.sym} 134100 -24110 0 0 {name=p133212 lab=_47555_/X }
C {devices/lab_pin.sym} 134100 -24070 0 0 {name=p133213 lab=_47595_/X }
C {devices/lab_pin.sym} 134260 -24110 0 1 {name=p133214 lab=_86618_/D }
C {sky130_stdcells/a21oi_4.sym} 134180 -24110 0 0 {name=X_47596_ }
C {devices/lab_pin.sym} 134120 -23990 0 0 {name=p133215 lab=_64377_/X }
C {devices/lab_pin.sym} 134120 -23950 0 0 {name=p133216 lab=_64401_/B }
C {devices/lab_pin.sym} 134120 -23910 0 0 {name=p133217 lab=_64391_/X }
C {devices/lab_pin.sym} 134240 -23950 0 1 {name=p133218 lab=_64401_/X }
C {sky130_stdcells/and3_4.sym} 134180 -23950 0 0 {name=X_64401_ }
C {devices/lab_pin.sym} 134140 -23810 0 0 {name=p133219 lab=_48535_/A }
C {devices/lab_pin.sym} 134220 -23810 0 1 {name=p133220 lab=_49352_/A }
C {sky130_stdcells/buf_2.sym} 134180 -23810 0 0 {name=X_49335_ }
C {devices/lab_pin.sym} 134140 -23690 0 0 {name=p133221 lab=_61613_/A }
C {devices/lab_pin.sym} 134220 -23690 0 1 {name=p133222 lab=_61613_/Y }
C {sky130_stdcells/inv_2.sym} 134180 -23690 0 0 {name=X_61613_ }
C {devices/lab_pin.sym} 134120 -23580 0 0 {name=p133223 lab=_46547_/A }
C {devices/lab_pin.sym} 134120 -23540 0 0 {name=p133224 lab=_50858_/B }
C {devices/lab_pin.sym} 134240 -23560 0 1 {name=p133225 lab=_46547_/Y }
C {sky130_stdcells/nand2_4.sym} 134180 -23560 0 0 {name=X_46547_ }
C {devices/lab_pin.sym} 134120 -23440 0 0 {name=p133226 lab=_65381_/A }
C {devices/lab_pin.sym} 134120 -23400 0 0 {name=p133227 lab=_65381_/B }
C {devices/lab_pin.sym} 134240 -23420 0 1 {name=p133228 lab=_65381_/X }
C {sky130_stdcells/and2_4.sym} 134180 -23420 0 0 {name=X_65381_ }
C {devices/lab_pin.sym} 134120 -23300 0 0 {name=p133229 lab=_77376_/A }
C {devices/lab_pin.sym} 134120 -23260 0 0 {name=p133230 lab=_77376_/B }
C {devices/lab_pin.sym} 134240 -23280 0 1 {name=p133231 lab=_77367_/X }
C {sky130_stdcells/xor2_4.sym} 134180 -23280 0 0 {name=X_77367_ }
C {devices/lab_pin.sym} 134100 -23180 0 0 {name=p133232 lab=_40955_/X }
C {devices/lab_pin.sym} 134100 -23140 0 0 {name=p133233 lab=_43752_/X }
C {devices/lab_pin.sym} 134100 -23100 0 0 {name=p133234 lab=_69179_/B }
C {devices/lab_pin.sym} 134100 -23060 0 0 {name=p133235 lab=_43753_/X }
C {devices/lab_pin.sym} 134260 -23120 0 1 {name=p133236 lab=_87280_/D }
C {sky130_stdcells/a2bb2o_4.sym} 134180 -23120 0 0 {name=X_43759_ }
C {devices/lab_pin.sym} 134140 -22970 0 0 {name=p133237 lab=_62395_/X }
C {devices/lab_pin.sym} 134220 -22970 0 1 {name=p133238 lab=_62593_/X }
C {sky130_stdcells/buf_2.sym} 134180 -22970 0 0 {name=X_62593_ }
C {devices/lab_pin.sym} 134100 -22870 0 0 {name=p133239 lab=_45108_/A }
C {devices/lab_pin.sym} 134100 -22830 0 0 {name=p133240 lab=_74568_/X }
C {devices/lab_pin.sym} 134100 -22790 0 0 {name=p133241 lab=_74578_/X }
C {devices/lab_pin.sym} 134260 -22830 0 1 {name=p133242 lab=_74579_/Y }
C {sky130_stdcells/o21ai_4.sym} 134180 -22830 0 0 {name=X_74579_ }
C {devices/lab_pin.sym} 134140 -22690 0 0 {name=p133243 lab=_68057_/A }
C {devices/lab_pin.sym} 134220 -22690 0 1 {name=p133244 lab=_67120_/X }
C {sky130_stdcells/buf_2.sym} 134180 -22690 0 0 {name=X_67120_ }
C {devices/lab_pin.sym} 134120 -22580 0 0 {name=p133245 lab=_82657_/Q }
C {devices/lab_pin.sym} 134120 -22540 0 0 {name=p133246 lab=_82529_/D }
C {devices/lab_pin.sym} 134240 -22560 0 1 {name=p133247 lab=_79107_/A }
C {sky130_stdcells/xor2_4.sym} 134180 -22560 0 0 {name=X_79106_ }
C {devices/lab_pin.sym} 134120 -22460 0 0 {name=p133248 lab=_64304_/A }
C {devices/lab_pin.sym} 134120 -22420 0 0 {name=p133249 lab=_64303_/X }
C {devices/lab_pin.sym} 134120 -22380 0 0 {name=p133250 lab=_84959_/Q }
C {devices/lab_pin.sym} 134120 -22340 0 0 {name=p133251 lab=_64318_/D }
C {devices/lab_pin.sym} 134240 -22400 0 1 {name=p133252 lab=_64332_/X }
C {sky130_stdcells/and4_4.sym} 134180 -22400 0 0 {name=X_64332_ }
C {devices/lab_pin.sym} 134120 -22260 0 0 {name=p133253 lab=_76311_/A }
C {devices/lab_pin.sym} 134120 -22220 0 0 {name=p133254 lab=_76296_/A }
C {devices/lab_pin.sym} 134240 -22240 0 1 {name=p133255 lab=_76319_/A }
C {sky130_stdcells/nor2_4.sym} 134180 -22240 0 0 {name=X_76318_ }
C {devices/lab_pin.sym} 134100 -22130 0 0 {name=p133256 lab=_86421_/Q }
C {devices/lab_pin.sym} 134100 -22090 0 0 {name=p133257 lab=_49255_/X }
C {devices/lab_pin.sym} 134100 -22050 0 0 {name=p133258 lab=_49265_/Y }
C {devices/lab_pin.sym} 134260 -22090 0 1 {name=p133259 lab=_49266_/Y }
C {sky130_stdcells/o21ai_4.sym} 134180 -22090 0 0 {name=X_49266_ }
C {devices/lab_pin.sym} 134140 -21950 0 0 {name=p133260 lab=_61544_/A }
C {devices/lab_pin.sym} 134220 -21950 0 1 {name=p133261 lab=_61544_/Y }
C {sky130_stdcells/inv_2.sym} 134180 -21950 0 0 {name=X_61544_ }
C {devices/lab_pin.sym} 134140 -21830 0 0 {name=p133262 lab=clkbuf_9_352_0_CLK/X }
C {devices/lab_pin.sym} 134220 -21830 0 1 {name=p133263 lab=_86814_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 134180 -21830 0 0 {name=Xclkbuf_10_705_0_CLK }
C {devices/lab_pin.sym} 134120 -21720 0 0 {name=p133264 lab=_46491_/A }
C {devices/lab_pin.sym} 134120 -21680 0 0 {name=p133265 lab=_50827_/B }
C {devices/lab_pin.sym} 134240 -21700 0 1 {name=p133266 lab=_46478_/Y }
C {sky130_stdcells/nand2_4.sym} 134180 -21700 0 0 {name=X_46478_ }
C {devices/lab_pin.sym} 134100 -21590 0 0 {name=p133267 lab=_77295_/X }
C {devices/lab_pin.sym} 134100 -21550 0 0 {name=p133268 lab=_77296_/Y }
C {devices/lab_pin.sym} 134100 -21510 0 0 {name=p133269 lab=_77297_/Y }
C {devices/lab_pin.sym} 134260 -21550 0 1 {name=p133270 lab=_77301_/A }
C {sky130_stdcells/a21oi_4.sym} 134180 -21550 0 0 {name=X_77298_ }
C {devices/lab_pin.sym} 134120 -21430 0 0 {name=p133271 lab=_50270_/A }
C {devices/lab_pin.sym} 134120 -21390 0 0 {name=p133272 lab=_48201_/B }
C {devices/lab_pin.sym} 134120 -21350 0 0 {name=p133273 lab=_48195_/X }
C {devices/lab_pin.sym} 134240 -21390 0 1 {name=p133274 lab=_48217_/X }
C {sky130_stdcells/and3_4.sym} 134180 -21390 0 0 {name=X_48217_ }
C {devices/lab_pin.sym} 134100 -21270 0 0 {name=p133275 lab=_67048_/X }
C {devices/lab_pin.sym} 134100 -21230 0 0 {name=p133276 lab=_67050_/X }
C {devices/lab_pin.sym} 134100 -21190 0 0 {name=p133277 lab=_67026_/X }
C {devices/lab_pin.sym} 134260 -21230 0 1 {name=p133278 lab=_67051_/X }
C {sky130_stdcells/a21o_4.sym} 134180 -21230 0 0 {name=X_67051_ }
C {devices/lab_pin.sym} 134120 -21110 0 0 {name=p133279 lab=_79027_/B }
C {devices/lab_pin.sym} 134120 -21070 0 0 {name=p133280 lab=_79027_/A }
C {devices/lab_pin.sym} 134120 -21030 0 0 {name=p133281 lab=_79037_/C }
C {devices/lab_pin.sym} 134240 -21070 0 1 {name=p133282 lab=_79044_/A }
C {sky130_stdcells/nand3_4.sym} 134180 -21070 0 0 {name=X_79037_ }
C {devices/lab_pin.sym} 134140 -20930 0 0 {name=p133283 lab=_44887_/X }
C {devices/lab_pin.sym} 134220 -20930 0 1 {name=p133284 lab=_45429_/X }
C {sky130_stdcells/buf_2.sym} 134180 -20930 0 0 {name=X_45429_ }
C {devices/lab_pin.sym} 134140 -20810 0 0 {name=p133285 lab=_64263_/A }
C {devices/lab_pin.sym} 134220 -20810 0 1 {name=p133286 lab=_64287_/A }
C {sky130_stdcells/buf_2.sym} 134180 -20810 0 0 {name=X_64263_ }
C {devices/lab_pin.sym} 134100 -20710 0 0 {name=p133287 lab=_76245_/Y }
C {devices/lab_pin.sym} 134100 -20670 0 0 {name=p133288 lab=_76247_/Y }
C {devices/lab_pin.sym} 134100 -20630 0 0 {name=p133289 lab=_76248_/Y }
C {devices/lab_pin.sym} 134260 -20670 0 1 {name=p133290 lab=_76254_/A }
C {sky130_stdcells/o21ai_4.sym} 134180 -20670 0 0 {name=X_76249_ }
C {devices/lab_pin.sym} 134120 -20540 0 0 {name=p133291 lab=_49156_/X }
C {devices/lab_pin.sym} 134120 -20500 0 0 {name=p133292 lab=_50721_/B }
C {devices/lab_pin.sym} 134240 -20520 0 1 {name=p133293 lab=_49197_/Y }
C {sky130_stdcells/nand2_4.sym} 134180 -20520 0 0 {name=X_49197_ }
C {devices/lab_pin.sym} 134140 -20390 0 0 {name=p133294 lab=_72176_/A }
C {devices/lab_pin.sym} 134220 -20390 0 1 {name=p133295 lab=_61476_/A }
C {sky130_stdcells/buf_2.sym} 134180 -20390 0 0 {name=X_61475_ }
C {devices/lab_pin.sym} 134140 -20270 0 0 {name=p133296 lab=_66002_/A }
C {devices/lab_pin.sym} 134220 -20270 0 1 {name=p133297 lab=_66003_/A }
C {sky130_stdcells/buf_2.sym} 134180 -20270 0 0 {name=X_66002_ }
C {devices/lab_pin.sym} 134120 -20180 0 0 {name=p133298 lab=_63288_/A }
C {devices/lab_pin.sym} 134120 -20140 0 0 {name=p133299 lab=_64420_/B }
C {devices/lab_pin.sym} 134120 -20100 0 0 {name=p133300 lab=_63165_/X }
C {devices/lab_pin.sym} 134120 -20060 0 0 {name=p133301 lab=_63192_/D }
C {devices/lab_pin.sym} 134240 -20120 0 1 {name=p133302 lab=_63214_/X }
C {sky130_stdcells/and4_4.sym} 134180 -20120 0 0 {name=X_63214_ }
C {devices/lab_pin.sym} 134120 -19980 0 0 {name=p133303 lab=_48801_/A }
C {devices/lab_pin.sym} 134120 -19940 0 0 {name=p133304 lab=_48148_/B }
C {devices/lab_pin.sym} 134240 -19960 0 1 {name=p133305 lab=_48148_/X }
C {sky130_stdcells/and2_4.sym} 134180 -19960 0 0 {name=X_48148_ }
C {devices/lab_pin.sym} 134120 -19860 0 0 {name=p133306 lab=_60417_/A }
C {devices/lab_pin.sym} 134120 -19820 0 0 {name=p133307 lab=_60441_/B }
C {devices/lab_pin.sym} 134120 -19780 0 0 {name=p133308 lab=_60473_/B }
C {devices/lab_pin.sym} 134120 -19740 0 0 {name=p133309 lab=_60383_/A }
C {devices/lab_pin.sym} 134240 -19800 0 1 {name=p133310 lab=_60427_/A }
C {sky130_stdcells/and4_4.sym} 134180 -19800 0 0 {name=X_60426_ }
C {devices/lab_pin.sym} 134120 -19680 0 0 {name=p133311 lab=_62186_/X }
C {devices/lab_pin.sym} 134120 -19640 0 0 {name=p133312 lab=_64182_/B }
C {devices/lab_pin.sym} 134120 -19600 0 0 {name=p133313 lab=_64182_/C }
C {devices/lab_pin.sym} 134120 -19560 0 0 {name=p133314 lab=_64182_/D }
C {devices/lab_pin.sym} 134240 -19620 0 1 {name=p133315 lab=_64194_/Y }
C {sky130_stdcells/nand4_4.sym} 134180 -19620 0 0 {name=X_64194_ }
C {devices/lab_pin.sym} 134140 -19470 0 0 {name=p133316 lab=_60606_/X }
C {devices/lab_pin.sym} 134220 -19470 0 1 {name=p133317 lab=_63146_/C }
C {sky130_stdcells/buf_2.sym} 134180 -19470 0 0 {name=X_63145_ }
C {devices/lab_pin.sym} 134120 -19370 0 0 {name=p133318 lab=_60477_/A }
C {devices/lab_pin.sym} 134120 -19330 0 0 {name=p133319 lab=_60319_/X }
C {devices/lab_pin.sym} 134120 -19290 0 0 {name=p133320 lab=_79605_/A }
C {devices/lab_pin.sym} 134240 -19330 0 1 {name=p133321 lab=_60357_/Y }
C {sky130_stdcells/nor3_4.sym} 134180 -19330 0 0 {name=X_60357_ }
C {devices/lab_pin.sym} 134120 -19200 0 0 {name=p133322 lab=_47981_/X }
C {devices/lab_pin.sym} 134120 -19160 0 0 {name=p133323 lab=_48079_/B }
C {devices/lab_pin.sym} 134240 -19180 0 1 {name=p133324 lab=_48079_/X }
C {sky130_stdcells/and2_4.sym} 134180 -19180 0 0 {name=X_48079_ }
C {devices/lab_pin.sym} 134120 -19060 0 0 {name=p133325 lab=_50106_/A }
C {devices/lab_pin.sym} 134120 -19020 0 0 {name=p133326 lab=_72014_/B }
C {devices/lab_pin.sym} 134240 -19040 0 1 {name=p133327 lab=_50110_/X }
C {sky130_stdcells/and2_4.sym} 134180 -19040 0 0 {name=X_50110_ }
C {devices/lab_pin.sym} 134100 -18930 0 0 {name=p133328 lab=_51087_/Y }
C {devices/lab_pin.sym} 134100 -18890 0 0 {name=p133329 lab=_51065_/X }
C {devices/lab_pin.sym} 134100 -18850 0 0 {name=p133330 lab=_51089_/X }
C {devices/lab_pin.sym} 134260 -18890 0 1 {name=p133331 lab=_86076_/D }
C {sky130_stdcells/a21oi_4.sym} 134180 -18890 0 0 {name=X_51090_ }
C {devices/lab_pin.sym} 134140 -18750 0 0 {name=p133332 lab=_68640_/A }
C {devices/lab_pin.sym} 134220 -18750 0 1 {name=p133333 lab=_67953_/X }
C {sky130_stdcells/buf_2.sym} 134180 -18750 0 0 {name=X_67953_ }
C {devices/lab_pin.sym} 134140 -18630 0 0 {name=p133334 lab=_60458_/X }
C {devices/lab_pin.sym} 134220 -18630 0 1 {name=p133335 lab=_63077_/D }
C {sky130_stdcells/buf_2.sym} 134180 -18630 0 0 {name=X_63076_ }
C {devices/lab_pin.sym} 134120 -18520 0 0 {name=p133336 lab=_84925_/Q }
C {devices/lab_pin.sym} 134120 -18480 0 0 {name=p133337 lab=_65855_/C }
C {devices/lab_pin.sym} 134240 -18500 0 1 {name=p133338 lab=_79939_/Y }
C {sky130_stdcells/nor2_4.sym} 134180 -18500 0 0 {name=X_79939_ }
C {devices/lab_pin.sym} 134120 -18390 0 0 {name=p133339 lab=_62644_/A }
C {devices/lab_pin.sym} 134120 -18350 0 0 {name=p133340 lab=_60251_/A }
C {devices/lab_pin.sym} 134120 -18310 0 0 {name=p133341 lab=_60288_/C }
C {devices/lab_pin.sym} 134240 -18350 0 1 {name=p133342 lab=_60288_/X }
C {sky130_stdcells/and3_4.sym} 134180 -18350 0 0 {name=X_60288_ }
C {devices/lab_pin.sym} 134100 -18230 0 0 {name=p133343 lab=_50039_/Y }
C {devices/lab_pin.sym} 134100 -18190 0 0 {name=p133344 lab=_50029_/X }
C {devices/lab_pin.sym} 134100 -18150 0 0 {name=p133345 lab=_50040_/X }
C {devices/lab_pin.sym} 134260 -18190 0 1 {name=p133346 lab=_86276_/D }
C {sky130_stdcells/a21oi_4.sym} 134180 -18190 0 0 {name=X_50041_ }
C {devices/lab_pin.sym} 134100 -18080 0 0 {name=p133347 lab=_87429_/Q }
C {devices/lab_pin.sym} 134100 -18040 0 0 {name=p133348 lab=_66878_/X }
C {devices/lab_pin.sym} 134100 -18000 0 0 {name=p133349 lab=_66879_/X }
C {devices/lab_pin.sym} 134100 -17960 0 0 {name=p133350 lab=_66903_/X }
C {devices/lab_pin.sym} 134260 -18020 0 1 {name=p133351 lab=_66904_/X }
C {sky130_stdcells/a211o_4.sym} 134180 -18020 0 0 {name=X_66904_ }
C {devices/lab_pin.sym} 134140 -17870 0 0 {name=p133352 lab=_62027_/A }
C {devices/lab_pin.sym} 134220 -17870 0 1 {name=p133353 lab=_62027_/X }
C {sky130_stdcells/buf_2.sym} 134180 -17870 0 0 {name=X_62027_ }
C {devices/lab_pin.sym} 134090 -17750 0 0 {name=p133354 lab=_82774_/CLK }
C {devices/lab_pin.sym} 134090 -17730 0 0 {name=p133355 lab=_82758_/Q }
C {devices/lab_pin.sym} 134270 -17750 0 1 {name=p133356 lab=_82950_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -17740 0 0 {name=X_82950_ }
C {devices/lab_pin.sym} 134100 -17630 0 0 {name=p133357 lab=_67881_/X }
C {devices/lab_pin.sym} 134100 -17590 0 0 {name=p133358 lab=_67883_/X }
C {devices/lab_pin.sym} 134100 -17550 0 0 {name=p133359 lab=_67858_/X }
C {devices/lab_pin.sym} 134260 -17590 0 1 {name=p133360 lab=_67887_/A }
C {sky130_stdcells/a21o_4.sym} 134180 -17590 0 0 {name=X_67884_ }
C {devices/lab_pin.sym} 134090 -17450 0 0 {name=p133361 lab=_81989_/CLK }
C {devices/lab_pin.sym} 134090 -17430 0 0 {name=p133362 lab=_77390_/X }
C {devices/lab_pin.sym} 134270 -17450 0 1 {name=p133363 lab=_82277_/D }
C {sky130_stdcells/dfxtp_4.sym} 134180 -17440 0 0 {name=X_81901_ }
C {devices/lab_pin.sym} 134100 -17340 0 0 {name=p133364 lab=_72859_/A }
C {devices/lab_pin.sym} 134100 -17300 0 0 {name=p133365 lab=_68394_/A }
C {devices/lab_pin.sym} 134100 -17260 0 0 {name=p133366 lab=_68741_/X }
C {devices/lab_pin.sym} 134100 -17220 0 0 {name=p133367 lab=_69622_/Y }
C {devices/lab_pin.sym} 134260 -17280 0 1 {name=p133368 lab=_69623_/X }
C {sky130_stdcells/a211o_4.sym} 134180 -17280 0 0 {name=X_69623_ }
C {devices/lab_pin.sym} 134120 -17140 0 0 {name=p133369 lab=_66769_/A }
C {devices/lab_pin.sym} 134120 -17100 0 0 {name=p133370 lab=_88200_/Q }
C {devices/lab_pin.sym} 134240 -17120 0 1 {name=p133371 lab=_66835_/X }
C {sky130_stdcells/and2_4.sym} 134180 -17120 0 0 {name=X_66835_ }
C {devices/lab_pin.sym} 134090 -16990 0 0 {name=p133372 lab=_82368_/CLK }
C {devices/lab_pin.sym} 134090 -16970 0 0 {name=p133373 lab=_78303_/B }
C {devices/lab_pin.sym} 134270 -16990 0 1 {name=p133374 lab=_82881_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -16980 0 0 {name=X_82881_ }
C {devices/lab_pin.sym} 134140 -16850 0 0 {name=p133375 lab=_53900_/A }
C {devices/lab_pin.sym} 134220 -16850 0 1 {name=p133376 lab=_53801_/B }
C {sky130_stdcells/buf_2.sym} 134180 -16850 0 0 {name=X_53800_ }
C {devices/lab_pin.sym} 134090 -16730 0 0 {name=p133377 lab=_84620_/CLK }
C {devices/lab_pin.sym} 134090 -16710 0 0 {name=p133378 lab=_60370_/Y }
C {devices/lab_pin.sym} 134270 -16730 0 1 {name=p133379 lab=_79553_/A }
C {sky130_stdcells/dfxtp_4.sym} 134180 -16720 0 0 {name=X_84620_ }
C {devices/lab_pin.sym} 134100 -16620 0 0 {name=p133380 lab=_88020_/Q }
C {devices/lab_pin.sym} 134100 -16580 0 0 {name=p133381 lab=_69424_/X }
C {devices/lab_pin.sym} 134100 -16540 0 0 {name=p133382 lab=_69465_/X }
C {devices/lab_pin.sym} 134100 -16500 0 0 {name=p133383 lab=_69553_/X }
C {devices/lab_pin.sym} 134260 -16560 0 1 {name=p133384 lab=_69554_/X }
C {sky130_stdcells/a211o_4.sym} 134180 -16560 0 0 {name=X_69554_ }
C {devices/lab_pin.sym} 134090 -16410 0 0 {name=p133385 lab=_82084_/CLK }
C {devices/lab_pin.sym} 134090 -16390 0 0 {name=p133386 lab=_81864_/Q }
C {devices/lab_pin.sym} 134270 -16410 0 1 {name=p133387 lab=_77305_/A }
C {sky130_stdcells/dfxtp_4.sym} 134180 -16400 0 0 {name=X_81832_ }
C {devices/lab_pin.sym} 134140 -16270 0 0 {name=p133388 lab=_54672_/X }
C {devices/lab_pin.sym} 134220 -16270 0 1 {name=p133389 lab=_54798_/C }
C {sky130_stdcells/buf_2.sym} 134180 -16270 0 0 {name=X_54780_ }
C {devices/lab_pin.sym} 134100 -16180 0 0 {name=p133390 lab=_87435_/Q }
C {devices/lab_pin.sym} 134100 -16140 0 0 {name=p133391 lab=_66762_/X }
C {devices/lab_pin.sym} 134100 -16100 0 0 {name=p133392 lab=_66764_/X }
C {devices/lab_pin.sym} 134100 -16060 0 0 {name=p133393 lab=_66765_/X }
C {devices/lab_pin.sym} 134260 -16120 0 1 {name=p133394 lab=_66766_/X }
C {sky130_stdcells/a211o_4.sym} 134180 -16120 0 0 {name=X_66766_ }
C {devices/lab_pin.sym} 134120 -15980 0 0 {name=p133395 lab=_51982_/X }
C {devices/lab_pin.sym} 134120 -15940 0 0 {name=p133396 lab=_53516_/B }
C {devices/lab_pin.sym} 134240 -15960 0 1 {name=p133397 lab=_51992_/Y }
C {sky130_stdcells/nand2_4.sym} 134180 -15960 0 0 {name=X_51992_ }
C {devices/lab_pin.sym} 134140 -15830 0 0 {name=p133398 lab=_60920_/A }
C {devices/lab_pin.sym} 134220 -15830 0 1 {name=p133399 lab=_64040_/C }
C {sky130_stdcells/buf_2.sym} 134180 -15830 0 0 {name=X_63978_ }
C {devices/lab_pin.sym} 134120 -15720 0 0 {name=p133400 lab=_68452_/A }
C {devices/lab_pin.sym} 134120 -15680 0 0 {name=p133401 lab=_87246_/Q }
C {devices/lab_pin.sym} 134240 -15700 0 1 {name=p133402 lab=_68505_/X }
C {sky130_stdcells/and2_4.sym} 134180 -15700 0 0 {name=X_68505_ }
C {devices/lab_pin.sym} 134120 -15580 0 0 {name=p133403 lab=_53750_/A }
C {devices/lab_pin.sym} 134120 -15540 0 0 {name=p133404 lab=_48602_/Y }
C {devices/lab_pin.sym} 134240 -15560 0 1 {name=p133405 lab=_53731_/Y }
C {sky130_stdcells/nand2_4.sym} 134180 -15560 0 0 {name=X_53731_ }
C {devices/lab_pin.sym} 134140 -15430 0 0 {name=p133406 lab=_65859_/A }
C {devices/lab_pin.sym} 134220 -15430 0 1 {name=p133407 lab=_65717_/X }
C {sky130_stdcells/buf_2.sym} 134180 -15430 0 0 {name=X_65717_ }
C {devices/lab_pin.sym} 134090 -15310 0 0 {name=p133408 lab=_84292_/CLK }
C {devices/lab_pin.sym} 134090 -15290 0 0 {name=p133409 lab=_84551_/D }
C {devices/lab_pin.sym} 134270 -15310 0 1 {name=p133410 lab=_76999_/A }
C {sky130_stdcells/dfxtp_4.sym} 134180 -15300 0 0 {name=X_84551_ }
C {devices/lab_pin.sym} 134120 -15180 0 0 {name=p133411 lab=_50938_/X }
C {devices/lab_pin.sym} 134120 -15140 0 0 {name=p133412 lab=_51807_/B }
C {devices/lab_pin.sym} 134240 -15160 0 1 {name=p133413 lab=_50943_/Y }
C {sky130_stdcells/nand2_4.sym} 134180 -15160 0 0 {name=X_50943_ }
C {devices/lab_pin.sym} 134100 -15070 0 0 {name=p133414 lab=_62923_/Y }
C {devices/lab_pin.sym} 134100 -15030 0 0 {name=p133415 lab=_62924_/X }
C {devices/lab_pin.sym} 134100 -14990 0 0 {name=p133416 lab=_62928_/Y }
C {devices/lab_pin.sym} 134100 -14950 0 0 {name=p133417 lab=_58344_/A }
C {devices/lab_pin.sym} 134100 -14910 0 0 {name=p133418 lab=_62650_/X }
C {devices/lab_pin.sym} 134260 -14990 0 1 {name=p133419 lab=_62929_/Y }
C {sky130_stdcells/o32ai_4.sym} 134180 -14990 0 0 {name=X_62929_ }
C {devices/lab_pin.sym} 134090 -14830 0 0 {name=p133420 lab=_88116_/CLK }
C {devices/lab_pin.sym} 134090 -14810 0 0 {name=p133421 lab=_75982_/X }
C {devices/lab_pin.sym} 134270 -14830 0 1 {name=p133422 lab=_48697_/A }
C {sky130_stdcells/dfxtp_4.sym} 134180 -14820 0 0 {name=X_81763_ }
C {devices/lab_pin.sym} 134140 -14690 0 0 {name=p133423 lab=_69485_/A }
C {devices/lab_pin.sym} 134220 -14690 0 1 {name=p133424 lab=_69485_/X }
C {sky130_stdcells/buf_2.sym} 134180 -14690 0 0 {name=X_69485_ }
C {devices/lab_pin.sym} 134140 -14570 0 0 {name=p133425 lab=_69582_/A }
C {devices/lab_pin.sym} 134220 -14570 0 1 {name=p133426 lab=_66697_/X }
C {sky130_stdcells/buf_2.sym} 134180 -14570 0 0 {name=X_66697_ }
C {devices/lab_pin.sym} 134090 -14450 0 0 {name=p133427 lab=_84228_/CLK }
C {devices/lab_pin.sym} 134090 -14430 0 0 {name=p133428 lab=_83502_/D }
C {devices/lab_pin.sym} 134270 -14450 0 1 {name=p133429 lab=_83502_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -14440 0 0 {name=X_83502_ }
C {devices/lab_pin.sym} 134120 -14330 0 0 {name=p133430 lab=_56377_/X }
C {devices/lab_pin.sym} 134120 -14290 0 0 {name=p133431 lab=_56454_/B }
C {devices/lab_pin.sym} 134120 -14250 0 0 {name=p133432 lab=_56450_/C }
C {devices/lab_pin.sym} 134240 -14290 0 1 {name=p133433 lab=_56450_/Y }
C {sky130_stdcells/nand3_4.sym} 134180 -14290 0 0 {name=X_56450_ }
C {devices/lab_pin.sym} 134090 -14150 0 0 {name=p133434 lab=_80681_/CLK }
C {devices/lab_pin.sym} 134090 -14130 0 0 {name=p133435 lab=_75900_/X }
C {devices/lab_pin.sym} 134270 -14150 0 1 {name=p133436 lab=_80682_/D }
C {sky130_stdcells/dfxtp_4.sym} 134180 -14140 0 0 {name=X_80714_ }
C {devices/lab_pin.sym} 134140 -14010 0 0 {name=p133437 lab=_65976_/A }
C {devices/lab_pin.sym} 134220 -14010 0 1 {name=p133438 lab=_68436_/X }
C {sky130_stdcells/buf_2.sym} 134180 -14010 0 0 {name=X_68436_ }
C {devices/lab_pin.sym} 134090 -13890 0 0 {name=p133439 lab=_87782_/CLK }
C {devices/lab_pin.sym} 134090 -13870 0 0 {name=p133440 lab=_43783_/Y }
C {devices/lab_pin.sym} 134270 -13890 0 1 {name=p133441 lab=_69318_/B }
C {sky130_stdcells/dfxtp_4.sym} 134180 -13880 0 0 {name=X_87270_ }
C {devices/lab_pin.sym} 134140 -13750 0 0 {name=p133442 lab=_53755_/A }
C {devices/lab_pin.sym} 134220 -13750 0 1 {name=p133443 lab=_53662_/X }
C {sky130_stdcells/buf_2.sym} 134180 -13750 0 0 {name=X_53662_ }
C {devices/lab_pin.sym} 134100 -13650 0 0 {name=p133444 lab=_65533_/X }
C {devices/lab_pin.sym} 134100 -13610 0 0 {name=p133445 lab=_65646_/Y }
C {devices/lab_pin.sym} 134100 -13570 0 0 {name=p133446 lab=_65647_/Y }
C {devices/lab_pin.sym} 134260 -13610 0 1 {name=p133447 lab=_65648_/Y }
C {sky130_stdcells/o21ai_4.sym} 134180 -13610 0 0 {name=X_65648_ }
C {devices/lab_pin.sym} 134090 -13470 0 0 {name=p133448 lab=_84481_/CLK }
C {devices/lab_pin.sym} 134090 -13450 0 0 {name=p133449 lab=_61426_/Y }
C {devices/lab_pin.sym} 134270 -13470 0 1 {name=p133450 lab=_79150_/B }
C {sky130_stdcells/dfxtp_4.sym} 134180 -13460 0 0 {name=X_84482_ }
C {devices/lab_pin.sym} 134120 -13340 0 0 {name=p133451 lab=_50857_/X }
C {devices/lab_pin.sym} 134120 -13300 0 0 {name=p133452 lab=_51389_/B }
C {devices/lab_pin.sym} 134240 -13320 0 1 {name=p133453 lab=_50874_/Y }
C {sky130_stdcells/nand2_4.sym} 134180 -13320 0 0 {name=X_50874_ }
C {devices/lab_pin.sym} 134090 -13190 0 0 {name=p133454 lab=_81695_/CLK }
C {devices/lab_pin.sym} 134090 -13170 0 0 {name=p133455 lab=_80228_/X }
C {devices/lab_pin.sym} 134270 -13190 0 1 {name=p133456 lab=_76755_/A }
C {sky130_stdcells/dfxtp_4.sym} 134180 -13180 0 0 {name=X_81694_ }
C {devices/lab_pin.sym} 134100 -13070 0 0 {name=p133457 lab=_55399_/X }
C {devices/lab_pin.sym} 134100 -13030 0 0 {name=p133458 lab=_55181_/B }
C {devices/lab_pin.sym} 134100 -12990 0 0 {name=p133459 lab=_55400_/Y }
C {devices/lab_pin.sym} 134260 -13030 0 1 {name=p133460 lab=_55403_/A }
C {sky130_stdcells/a21o_4.sym} 134180 -13030 0 0 {name=X_55401_ }
C {devices/lab_pin.sym} 134090 -12890 0 0 {name=p133461 lab=_85599_/CLK }
C {devices/lab_pin.sym} 134090 -12870 0 0 {name=p133462 lab=_86221_/D }
C {devices/lab_pin.sym} 134270 -12890 0 1 {name=p133463 lab=_86221_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -12880 0 0 {name=X_86221_ }
C {devices/lab_pin.sym} 134100 -12770 0 0 {name=p133464 lab=_85786_/Q }
C {devices/lab_pin.sym} 134100 -12730 0 0 {name=p133465 lab=_52601_/X }
C {devices/lab_pin.sym} 134100 -12690 0 0 {name=p133466 lab=_52612_/Y }
C {devices/lab_pin.sym} 134260 -12730 0 1 {name=p133467 lab=_52613_/Y }
C {sky130_stdcells/o21ai_4.sym} 134180 -12730 0 0 {name=X_52613_ }
C {devices/lab_pin.sym} 134090 -12590 0 0 {name=p133468 lab=_83372_/CLK }
C {devices/lab_pin.sym} 134090 -12570 0 0 {name=p133469 lab=_71627_/X }
C {devices/lab_pin.sym} 134270 -12590 0 1 {name=p133470 lab=_83433_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -12580 0 0 {name=X_83433_ }
C {devices/lab_pin.sym} 134120 -12470 0 0 {name=p133471 lab=_56458_/A }
C {devices/lab_pin.sym} 134120 -12430 0 0 {name=p133472 lab=_56363_/B }
C {devices/lab_pin.sym} 134120 -12390 0 0 {name=p133473 lab=_56381_/C }
C {devices/lab_pin.sym} 134240 -12430 0 1 {name=p133474 lab=_56381_/Y }
C {sky130_stdcells/nand3_4.sym} 134180 -12430 0 0 {name=X_56381_ }
C {devices/lab_pin.sym} 134140 -12280 0 0 {name=p133475 lab=_74767_/X }
C {devices/lab_pin.sym} 134140 -12240 0 0 {name=p133476 lab=_74709_/Y }
C {devices/lab_pin.sym} 134220 -12280 0 1 {name=p133477 lab=DATA_FROM_HASH[2] }
C {sky130_stdcells/ebufn_2.sym} 134180 -12280 0 0 {name=X_80645_ }
C {devices/lab_pin.sym} 134120 -12160 0 0 {name=p133478 lab=_68366_/X }
C {devices/lab_pin.sym} 134120 -12120 0 0 {name=p133479 lab=_43587_/Y }
C {devices/lab_pin.sym} 134240 -12140 0 1 {name=p133480 lab=_68367_/Y }
C {sky130_stdcells/nor2_4.sym} 134180 -12140 0 0 {name=X_68367_ }
C {devices/lab_pin.sym} 134120 -12020 0 0 {name=p133481 lab=_53601_/A }
C {devices/lab_pin.sym} 134120 -11980 0 0 {name=p133482 lab=_53593_/B }
C {devices/lab_pin.sym} 134240 -12000 0 1 {name=p133483 lab=_53593_/Y }
C {sky130_stdcells/nand2_4.sym} 134180 -12000 0 0 {name=X_53593_ }
C {devices/lab_pin.sym} 134100 -11900 0 0 {name=p133484 lab=_65438_/X }
C {devices/lab_pin.sym} 134100 -11860 0 0 {name=p133485 lab=_86199_/Q }
C {devices/lab_pin.sym} 134100 -11820 0 0 {name=p133486 lab=_65576_/X }
C {devices/lab_pin.sym} 134100 -11780 0 0 {name=p133487 lab=_65578_/X }
C {devices/lab_pin.sym} 134260 -11840 0 1 {name=p133488 lab=_65579_/X }
C {sky130_stdcells/a211o_4.sym} 134180 -11840 0 0 {name=X_65579_ }
C {devices/lab_pin.sym} 134140 -11690 0 0 {name=p133489 lab=_84923_/Q }
C {devices/lab_pin.sym} 134220 -11690 0 1 {name=p133490 lab=_79903_/A }
C {sky130_stdcells/inv_2.sym} 134180 -11690 0 0 {name=X_58120_ }
C {sky130_stdcells/decap_3.sym} 134180 -11540 0 0 {name=XPHY_205 }
C {devices/lab_pin.sym} 134120 -11400 0 0 {name=p133491 lab=_55317_/A }
C {devices/lab_pin.sym} 134120 -11360 0 0 {name=p133492 lab=_57414_/A }
C {devices/lab_pin.sym} 134240 -11380 0 1 {name=p133493 lab=_55332_/X }
C {sky130_stdcells/and2_4.sym} 134180 -11380 0 0 {name=X_55332_ }
C {devices/lab_pin.sym} 134100 -11280 0 0 {name=p133494 lab=_87924_/Q }
C {devices/lab_pin.sym} 134100 -11240 0 0 {name=p133495 lab=_67293_/X }
C {devices/lab_pin.sym} 134100 -11200 0 0 {name=p133496 lab=_67271_/X }
C {devices/lab_pin.sym} 134100 -11160 0 0 {name=p133497 lab=_67317_/X }
C {devices/lab_pin.sym} 134260 -11220 0 1 {name=p133498 lab=_67318_/X }
C {sky130_stdcells/a211o_4.sym} 134180 -11220 0 0 {name=X_67318_ }
C {devices/lab_pin.sym} 134090 -11070 0 0 {name=p133499 lab=_86155_/CLK }
C {devices/lab_pin.sym} 134090 -11050 0 0 {name=p133500 lab=_50696_/Y }
C {devices/lab_pin.sym} 134270 -11070 0 1 {name=p133501 lab=_86152_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -11060 0 0 {name=X_86152_ }
C {devices/lab_pin.sym} 134100 -10950 0 0 {name=p133502 lab=_52540_/Y }
C {devices/lab_pin.sym} 134100 -10910 0 0 {name=p133503 lab=_52541_/X }
C {devices/lab_pin.sym} 134100 -10870 0 0 {name=p133504 lab=_52543_/Y }
C {devices/lab_pin.sym} 134260 -10910 0 1 {name=p133505 lab=_52544_/Y }
C {sky130_stdcells/a21boi_4.sym} 134180 -10910 0 0 {name=X_52544_ }
C {sky130_stdcells/decap_3.sym} 134180 -10740 0 0 {name=XPHY_216 }
C {devices/lab_pin.sym} 134090 -10590 0 0 {name=p133506 lab=_83362_/CLK }
C {devices/lab_pin.sym} 134090 -10570 0 0 {name=p133507 lab=_83364_/D }
C {devices/lab_pin.sym} 134270 -10590 0 1 {name=p133508 lab=_83364_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -10580 0 0 {name=X_83364_ }
C {devices/lab_pin.sym} 134120 -10460 0 0 {name=p133509 lab=_84772_/Q }
C {devices/lab_pin.sym} 134120 -10420 0 0 {name=p133510 lab=_84164_/Q }
C {devices/lab_pin.sym} 134240 -10440 0 1 {name=p133511 lab=_80576_/Y }
C {sky130_stdcells/nand2_4.sym} 134180 -10440 0 0 {name=X_80576_ }
C {sky130_stdcells/decap_3.sym} 134180 -10280 0 0 {name=XPHY_227 }
C {devices/lab_pin.sym} 134100 -10150 0 0 {name=p133512 lab=_83989_/Q }
C {devices/lab_pin.sym} 134100 -10110 0 0 {name=p133513 lab=_68279_/X }
C {devices/lab_pin.sym} 134100 -10070 0 0 {name=p133514 lab=_68297_/X }
C {devices/lab_pin.sym} 134260 -10110 0 1 {name=p133515 lab=_68298_/X }
C {sky130_stdcells/a21bo_4.sym} 134180 -10110 0 0 {name=X_68298_ }
C {sky130_stdcells/decap_3.sym} 134180 -9940 0 0 {name=XPHY_238 }
C {devices/lab_pin.sym} 134090 -9790 0 0 {name=p133516 lab=_85103_/CLK }
C {devices/lab_pin.sym} 134090 -9770 0 0 {name=p133517 lab=_85103_/D }
C {devices/lab_pin.sym} 134270 -9790 0 1 {name=p133518 lab=_45673_/A }
C {sky130_stdcells/dfxtp_4.sym} 134180 -9780 0 0 {name=X_85103_ }
C {sky130_stdcells/decap_3.sym} 134180 -9620 0 0 {name=XPHY_249 }
C {devices/lab_pin.sym} 134100 -9490 0 0 {name=p133519 lab=_57947_/X }
C {devices/lab_pin.sym} 134100 -9450 0 0 {name=p133520 lab=_85705_/Q }
C {devices/lab_pin.sym} 134100 -9410 0 0 {name=p133521 lab=_57948_/X }
C {devices/lab_pin.sym} 134260 -9450 0 1 {name=p133522 lab=_58051_/X }
C {sky130_stdcells/o21a_4.sym} 134180 -9450 0 0 {name=X_58051_ }
C {devices/lab_pin.sym} 134090 -9310 0 0 {name=p133523 lab=_81195_/CLK }
C {devices/lab_pin.sym} 134090 -9290 0 0 {name=p133524 lab=_77065_/B }
C {devices/lab_pin.sym} 134270 -9310 0 1 {name=p133525 lab=_82315_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -9300 0 0 {name=X_82315_ }
C {devices/lab_pin.sym} 134100 -9190 0 0 {name=p133526 lab=_55264_/A }
C {devices/lab_pin.sym} 134100 -9150 0 0 {name=p133527 lab=_55264_/C }
C {devices/lab_pin.sym} 134100 -9110 0 0 {name=p133528 lab=_83321_/Q }
C {devices/lab_pin.sym} 134260 -9150 0 1 {name=p133529 lab=_55263_/X }
C {sky130_stdcells/a21o_4.sym} 134180 -9150 0 0 {name=X_55263_ }
C {devices/lab_pin.sym} 134100 -9040 0 0 {name=p133530 lab=_87927_/Q }
C {devices/lab_pin.sym} 134100 -9000 0 0 {name=p133531 lab=_67176_/X }
C {devices/lab_pin.sym} 134100 -8960 0 0 {name=p133532 lab=_67153_/X }
C {devices/lab_pin.sym} 134100 -8920 0 0 {name=p133533 lab=_67248_/X }
C {devices/lab_pin.sym} 134260 -8980 0 1 {name=p133534 lab=_67249_/X }
C {sky130_stdcells/a211o_4.sym} 134180 -8980 0 0 {name=X_67249_ }
C {devices/lab_pin.sym} 134090 -8830 0 0 {name=p133535 lab=_85764_/CLK }
C {devices/lab_pin.sym} 134090 -8810 0 0 {name=p133536 lab=_51052_/Y }
C {devices/lab_pin.sym} 134270 -8830 0 1 {name=p133537 lab=_86083_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -8820 0 0 {name=X_86083_ }
C {devices/lab_pin.sym} 134100 -8710 0 0 {name=p133538 lab=_52473_/Y }
C {devices/lab_pin.sym} 134100 -8670 0 0 {name=p133539 lab=_52462_/X }
C {devices/lab_pin.sym} 134100 -8630 0 0 {name=p133540 lab=_52474_/Y }
C {devices/lab_pin.sym} 134260 -8670 0 1 {name=p133541 lab=_52475_/Y }
C {sky130_stdcells/a21boi_4.sym} 134180 -8670 0 0 {name=X_52475_ }
C {devices/lab_pin.sym} 134090 -8530 0 0 {name=p133542 lab=_85538_/CLK }
C {devices/lab_pin.sym} 134090 -8510 0 0 {name=p133543 lab=_72050_/Y }
C {devices/lab_pin.sym} 134270 -8530 0 1 {name=p133544 lab=_83295_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -8520 0 0 {name=X_83295_ }
C {devices/lab_pin.sym} 134100 -8430 0 0 {name=p133545 lab=_56758_/X }
C {devices/lab_pin.sym} 134100 -8390 0 0 {name=p133546 lab=_56730_/X }
C {devices/lab_pin.sym} 134100 -8350 0 0 {name=p133547 lab=_56740_/X }
C {devices/lab_pin.sym} 134100 -8310 0 0 {name=p133548 lab=_56994_/D }
C {devices/lab_pin.sym} 134100 -8280 0 0 {name=p133549 lab=_57003_/B }
C {devices/lab_pin.sym} 134260 -8350 0 1 {name=p133550 lab=_57004_/B }
C {sky130_stdcells/a41oi_4.sym} 134180 -8350 0 0 {name=X_57002_ }
C {devices/lab_pin.sym} 134100 -8210 0 0 {name=p133551 lab=_54212_/Y }
C {devices/lab_pin.sym} 134100 -8170 0 0 {name=p133552 lab=_54197_/X }
C {devices/lab_pin.sym} 134100 -8130 0 0 {name=p133553 lab=_54213_/X }
C {devices/lab_pin.sym} 134260 -8170 0 1 {name=p133554 lab=_85483_/D }
C {sky130_stdcells/a21oi_4.sym} 134180 -8170 0 0 {name=X_54214_ }
C {devices/lab_pin.sym} 134090 -8030 0 0 {name=p133555 lab=_85034_/CLK }
C {devices/lab_pin.sym} 134090 -8010 0 0 {name=p133556 lab=_57330_/Y }
C {devices/lab_pin.sym} 134270 -8030 0 1 {name=p133557 lab=_57326_/B }
C {sky130_stdcells/dfxtp_4.sym} 134180 -8020 0 0 {name=X_85034_ }
C {devices/lab_pin.sym} 134120 -7920 0 0 {name=p133558 lab=_51410_/X }
C {devices/lab_pin.sym} 134120 -7880 0 0 {name=p133559 lab=_51421_/X }
C {devices/lab_pin.sym} 134120 -7840 0 0 {name=p133560 lab=_51438_/C }
C {devices/lab_pin.sym} 134120 -7800 0 0 {name=p133561 lab=_52954_/D }
C {devices/lab_pin.sym} 134240 -7860 0 1 {name=p133562 lab=_51426_/X }
C {sky130_stdcells/and4_4.sym} 134180 -7860 0 0 {name=X_51426_ }
C {devices/lab_pin.sym} 134120 -7740 0 0 {name=p133563 lab=_70260_/A }
C {devices/lab_pin.sym} 134120 -7700 0 0 {name=p133564 lab=_70260_/B }
C {devices/lab_pin.sym} 134120 -7660 0 0 {name=p133565 lab=_70260_/C }
C {devices/lab_pin.sym} 134120 -7620 0 0 {name=p133566 lab=_70260_/D }
C {devices/lab_pin.sym} 134240 -7680 0 1 {name=p133567 lab=_70260_/X }
C {sky130_stdcells/and4_4.sym} 134180 -7680 0 0 {name=X_70260_ }
C {devices/lab_pin.sym} 134090 -7530 0 0 {name=p133568 lab=_82436_/CLK }
C {devices/lab_pin.sym} 134090 -7510 0 0 {name=p133569 lab=_82246_/D }
C {devices/lab_pin.sym} 134270 -7530 0 1 {name=p133570 lab=_82246_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -7520 0 0 {name=X_82246_ }
C {devices/lab_pin.sym} 134100 -7410 0 0 {name=p133571 lab=_55188_/X }
C {devices/lab_pin.sym} 134100 -7370 0 0 {name=p133572 lab=_55193_/X }
C {devices/lab_pin.sym} 134100 -7330 0 0 {name=p133573 lab=_83749_/Q }
C {devices/lab_pin.sym} 134260 -7370 0 1 {name=p133574 lab=_55196_/A }
C {sky130_stdcells/a21o_4.sym} 134180 -7370 0 0 {name=X_55194_ }
C {devices/lab_pin.sym} 134140 -7230 0 0 {name=p133575 lab=_86505_/CLK }
C {devices/lab_pin.sym} 134220 -7230 0 1 {name=p133576 lab=_86186_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 134180 -7230 0 0 {name=Xclkbuf_opt_26_CLK }
C {devices/lab_pin.sym} 134140 -7110 0 0 {name=p133577 lab=_49793_/A }
C {devices/lab_pin.sym} 134220 -7110 0 1 {name=p133578 lab=_54254_/A }
C {sky130_stdcells/buf_2.sym} 134180 -7110 0 0 {name=X_54145_ }
C {devices/lab_pin.sym} 134100 -7010 0 0 {name=p133579 lab=_51355_/Y }
C {devices/lab_pin.sym} 134100 -6970 0 0 {name=p133580 lab=_51339_/X }
C {devices/lab_pin.sym} 134100 -6930 0 0 {name=p133581 lab=_51356_/X }
C {devices/lab_pin.sym} 134260 -6970 0 1 {name=p133582 lab=_51357_/Y }
C {sky130_stdcells/a21oi_4.sym} 134180 -6970 0 0 {name=X_51357_ }
C {devices/lab_pin.sym} 134090 -6830 0 0 {name=p133583 lab=_82177_/CLK }
C {devices/lab_pin.sym} 134090 -6810 0 0 {name=p133584 lab=_65916_/C }
C {devices/lab_pin.sym} 134270 -6830 0 1 {name=p133585 lab=_82177_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -6820 0 0 {name=X_82177_ }
C {devices/lab_pin.sym} 134100 -6710 0 0 {name=p133586 lab=_70169_/X }
C {devices/lab_pin.sym} 134100 -6670 0 0 {name=p133587 lab=_83843_/Q }
C {devices/lab_pin.sym} 134100 -6630 0 0 {name=p133588 lab=_70190_/X }
C {devices/lab_pin.sym} 134260 -6670 0 1 {name=p133589 lab=_70191_/X }
C {sky130_stdcells/a21o_4.sym} 134180 -6670 0 0 {name=X_70191_ }
C {devices/lab_pin.sym} 134140 -6530 0 0 {name=p133590 lab=_40989_/A }
C {devices/lab_pin.sym} 134220 -6530 0 1 {name=p133591 lab=_41110_/X }
C {sky130_stdcells/buf_2.sym} 134180 -6530 0 0 {name=X_41110_ }
C {devices/lab_pin.sym} 134120 -6430 0 0 {name=p133592 lab=_50308_/A }
C {devices/lab_pin.sym} 134120 -6390 0 0 {name=p133593 lab=_74509_/C }
C {devices/lab_pin.sym} 134120 -6350 0 0 {name=p133594 lab=_50247_/X }
C {devices/lab_pin.sym} 134240 -6390 0 1 {name=p133595 lab=_50308_/X }
C {sky130_stdcells/and3_4.sym} 134180 -6390 0 0 {name=X_50308_ }
C {devices/lab_pin.sym} 134090 -6250 0 0 {name=p133596 lab=_81125_/CLK }
C {devices/lab_pin.sym} 134090 -6230 0 0 {name=p133597 lab=_81128_/D }
C {devices/lab_pin.sym} 134270 -6250 0 1 {name=p133598 lab=_40727_/A }
C {sky130_stdcells/dfxtp_4.sym} 134180 -6240 0 0 {name=X_81128_ }
C {devices/lab_pin.sym} 134100 -6150 0 0 {name=p133599 lab=_42083_/X }
C {devices/lab_pin.sym} 134100 -6110 0 0 {name=p133600 lab=_42077_/X }
C {devices/lab_pin.sym} 134100 -6070 0 0 {name=p133601 lab=_41004_/X }
C {devices/lab_pin.sym} 134100 -6030 0 0 {name=p133602 lab=_88039_/Q }
C {devices/lab_pin.sym} 134100 -5990 0 0 {name=p133603 lab=_42078_/X }
C {devices/lab_pin.sym} 134260 -6070 0 1 {name=p133604 lab=_42090_/Y }
C {sky130_stdcells/o32ai_4.sym} 134180 -6070 0 0 {name=X_42090_ }
C {devices/lab_pin.sym} 134120 -5920 0 0 {name=p133605 lab=_58953_/A }
C {devices/lab_pin.sym} 134120 -5880 0 0 {name=p133606 lab=_59090_/B }
C {devices/lab_pin.sym} 134240 -5900 0 1 {name=p133607 lab=_58953_/Y }
C {sky130_stdcells/nor2_4.sym} 134180 -5900 0 0 {name=X_58953_ }
C {devices/lab_pin.sym} 134100 -5790 0 0 {name=p133608 lab=_54074_/Y }
C {devices/lab_pin.sym} 134100 -5750 0 0 {name=p133609 lab=_54060_/X }
C {devices/lab_pin.sym} 134100 -5710 0 0 {name=p133610 lab=_54075_/Y }
C {devices/lab_pin.sym} 134260 -5750 0 1 {name=p133611 lab=_85510_/D }
C {sky130_stdcells/a21boi_4.sym} 134180 -5750 0 0 {name=X_54076_ }
C {devices/lab_pin.sym} 134100 -5630 0 0 {name=p133612 lab=_64874_/B }
C {devices/lab_pin.sym} 134100 -5590 0 0 {name=p133613 lab=_51285_/X }
C {devices/lab_pin.sym} 134100 -5550 0 0 {name=p133614 lab=_51287_/Y }
C {devices/lab_pin.sym} 134260 -5590 0 1 {name=p133615 lab=_51288_/Y }
C {sky130_stdcells/o21ai_4.sym} 134180 -5590 0 0 {name=X_51288_ }
C {devices/lab_pin.sym} 134090 -5450 0 0 {name=p133616 lab=_82538_/CLK }
C {devices/lab_pin.sym} 134090 -5430 0 0 {name=p133617 lab=_44726_/Y }
C {devices/lab_pin.sym} 134270 -5450 0 1 {name=p133618 lab=_44725_/A }
C {sky130_stdcells/dfxtp_4.sym} 134180 -5440 0 0 {name=X_86985_ }
C {devices/lab_pin.sym} 134140 -5310 0 0 {name=p133619 lab=_40946_/A }
C {devices/lab_pin.sym} 134220 -5310 0 1 {name=p133620 lab=_41041_/X }
C {sky130_stdcells/buf_2.sym} 134180 -5310 0 0 {name=X_41041_ }
C {devices/lab_pin.sym} 134140 -5190 0 0 {name=p133621 lab=_52754_/A }
C {devices/lab_pin.sym} 134220 -5190 0 1 {name=p133622 lab=_53111_/A }
C {sky130_stdcells/buf_2.sym} 134180 -5190 0 0 {name=X_53027_ }
C {devices/lab_pin.sym} 134100 -5090 0 0 {name=p133623 lab=_57903_/X }
C {devices/lab_pin.sym} 134100 -5050 0 0 {name=p133624 lab=_85493_/Q }
C {devices/lab_pin.sym} 134100 -5010 0 0 {name=p133625 lab=_57849_/X }
C {devices/lab_pin.sym} 134260 -5050 0 1 {name=p133626 lab=_57904_/X }
C {sky130_stdcells/o21a_4.sym} 134180 -5050 0 0 {name=X_57904_ }
C {devices/lab_pin.sym} 134140 -4910 0 0 {name=p133627 lab=_50213_/X }
C {devices/lab_pin.sym} 134220 -4910 0 1 {name=p133628 lab=_50240_/A }
C {sky130_stdcells/buf_2.sym} 134180 -4910 0 0 {name=X_50239_ }
C {devices/lab_pin.sym} 134100 -4820 0 0 {name=p133629 lab=_73850_/X }
C {devices/lab_pin.sym} 134100 -4780 0 0 {name=p133630 lab=_86225_/Q }
C {devices/lab_pin.sym} 134100 -4740 0 0 {name=p133631 lab=_73948_/X }
C {devices/lab_pin.sym} 134100 -4700 0 0 {name=p133632 lab=_73949_/X }
C {devices/lab_pin.sym} 134260 -4760 0 1 {name=p133633 lab=_73950_/X }
C {sky130_stdcells/a211o_4.sym} 134180 -4760 0 0 {name=X_73950_ }
C {devices/lab_pin.sym} 134090 -4610 0 0 {name=p133634 lab=_86096_/CLK }
C {devices/lab_pin.sym} 134090 -4590 0 0 {name=p133635 lab=_51845_/Y }
C {devices/lab_pin.sym} 134270 -4610 0 1 {name=p133636 lab=_85936_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -4600 0 0 {name=X_85936_ }
C {devices/lab_pin.sym} 134090 -4470 0 0 {name=p133637 lab=_81059_/CLK }
C {devices/lab_pin.sym} 134090 -4450 0 0 {name=p133638 lab=_81091_/Q }
C {devices/lab_pin.sym} 134270 -4470 0 1 {name=p133639 lab=_75085_/B }
C {sky130_stdcells/dfxtp_4.sym} 134180 -4460 0 0 {name=X_81059_ }
C {devices/lab_pin.sym} 134100 -4350 0 0 {name=p133640 lab=_58879_/Y }
C {devices/lab_pin.sym} 134100 -4310 0 0 {name=p133641 lab=_58881_/Y }
C {devices/lab_pin.sym} 134100 -4270 0 0 {name=p133642 lab=_58883_/X }
C {devices/lab_pin.sym} 134260 -4310 0 1 {name=p133643 lab=_58884_/X }
C {sky130_stdcells/a21o_4.sym} 134180 -4310 0 0 {name=X_58884_ }
C {devices/lab_pin.sym} 134140 -4170 0 0 {name=p133644 lab=_72739_/X }
C {devices/lab_pin.sym} 134220 -4170 0 1 {name=p133645 lab=_72901_/X }
C {sky130_stdcells/buf_2.sym} 134180 -4170 0 0 {name=X_72901_ }
C {devices/lab_pin.sym} 134100 -4070 0 0 {name=p133646 lab=_57824_/X }
C {devices/lab_pin.sym} 134100 -4030 0 0 {name=p133647 lab=_85498_/Q }
C {devices/lab_pin.sym} 134100 -3990 0 0 {name=p133648 lab=_57736_/X }
C {devices/lab_pin.sym} 134260 -4030 0 1 {name=p133649 lab=_57835_/X }
C {sky130_stdcells/o21a_4.sym} 134180 -4030 0 0 {name=X_57835_ }
C {devices/lab_pin.sym} 134100 -3920 0 0 {name=p133650 lab=_73854_/X }
C {devices/lab_pin.sym} 134100 -3880 0 0 {name=p133651 lab=_85620_/Q }
C {devices/lab_pin.sym} 134100 -3840 0 0 {name=p133652 lab=_73782_/X }
C {devices/lab_pin.sym} 134100 -3800 0 0 {name=p133653 lab=_73880_/X }
C {devices/lab_pin.sym} 134260 -3860 0 1 {name=p133654 lab=_73881_/X }
C {sky130_stdcells/a211o_4.sym} 134180 -3860 0 0 {name=X_73881_ }
C {devices/lab_pin.sym} 134090 -3710 0 0 {name=p133655 lab=_86506_/CLK }
C {devices/lab_pin.sym} 134090 -3690 0 0 {name=p133656 lab=_52213_/Y }
C {devices/lab_pin.sym} 134270 -3710 0 1 {name=p133657 lab=_85867_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -3700 0 0 {name=X_85867_ }
C {devices/lab_pin.sym} 134100 -3600 0 0 {name=p133658 lab=_41436_/Y }
C {devices/lab_pin.sym} 134100 -3560 0 0 {name=p133659 lab=_44788_/X }
C {devices/lab_pin.sym} 134100 -3520 0 0 {name=p133660 lab=_86947_/Q }
C {devices/lab_pin.sym} 134100 -3480 0 0 {name=p133661 lab=_44789_/X }
C {devices/lab_pin.sym} 134260 -3540 0 1 {name=p133662 lab=_86947_/D }
C {sky130_stdcells/a2bb2o_4.sym} 134180 -3540 0 0 {name=X_44800_ }
C {devices/lab_pin.sym} 134120 -3400 0 0 {name=p133663 lab=_75640_/A }
C {devices/lab_pin.sym} 134120 -3360 0 0 {name=p133664 lab=_75609_/Y }
C {devices/lab_pin.sym} 134240 -3380 0 1 {name=p133665 lab=_75620_/Y }
C {sky130_stdcells/nor2_4.sym} 134180 -3380 0 0 {name=X_75620_ }
C {devices/lab_pin.sym} 134090 -3250 0 0 {name=p133666 lab=_87348_/CLK }
C {devices/lab_pin.sym} 134090 -3230 0 0 {name=p133667 lab=_87606_/D }
C {devices/lab_pin.sym} 134270 -3250 0 1 {name=p133668 lab=_67259_/B }
C {sky130_stdcells/dfxtp_4.sym} 134180 -3240 0 0 {name=X_87606_ }
C {devices/lab_pin.sym} 134100 -3140 0 0 {name=p133669 lab=_43119_/Y }
C {devices/lab_pin.sym} 134100 -3100 0 0 {name=p133670 lab=_72830_/X }
C {devices/lab_pin.sym} 134100 -3060 0 0 {name=p133671 lab=_72799_/X }
C {devices/lab_pin.sym} 134100 -3020 0 0 {name=p133672 lab=_72831_/Y }
C {devices/lab_pin.sym} 134260 -3080 0 1 {name=p133673 lab=_72832_/X }
C {sky130_stdcells/a211o_4.sym} 134180 -3080 0 0 {name=X_72832_ }
C {devices/lab_pin.sym} 134090 -2930 0 0 {name=p133674 lab=_84877_/CLK }
C {devices/lab_pin.sym} 134090 -2910 0 0 {name=p133675 lab=_84818_/D }
C {devices/lab_pin.sym} 134270 -2930 0 1 {name=p133676 lab=_84818_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -2920 0 0 {name=X_84818_ }
C {devices/lab_pin.sym} 134100 -2810 0 0 {name=p133677 lab=_57199_/A }
C {devices/lab_pin.sym} 134100 -2770 0 0 {name=p133678 lab=_45354_/X }
C {devices/lab_pin.sym} 134100 -2730 0 0 {name=p133679 lab=_45395_/X }
C {devices/lab_pin.sym} 134260 -2770 0 1 {name=p133680 lab=_45780_/X }
C {sky130_stdcells/o21a_4.sym} 134180 -2770 0 0 {name=X_45780_ }
C {devices/lab_pin.sym} 134140 -2630 0 0 {name=p133681 lab=_44019_/A }
C {devices/lab_pin.sym} 134220 -2630 0 1 {name=p133682 lab=_64567_/A }
C {sky130_stdcells/buf_2.sym} 134180 -2630 0 0 {name=X_57766_ }
C {devices/lab_pin.sym} 134140 -2510 0 0 {name=p133683 lab=_54927_/A }
C {devices/lab_pin.sym} 134220 -2510 0 1 {name=p133684 lab=_54978_/X }
C {sky130_stdcells/buf_2.sym} 134180 -2510 0 0 {name=X_54978_ }
C {devices/lab_pin.sym} 134140 -2390 0 0 {name=p133685 lab=_42992_/A }
C {devices/lab_pin.sym} 134220 -2390 0 1 {name=p133686 lab=_42992_/Y }
C {sky130_stdcells/inv_2.sym} 134180 -2390 0 0 {name=X_42992_ }
C {devices/lab_pin.sym} 134090 -2270 0 0 {name=p133687 lab=_86119_/CLK }
C {devices/lab_pin.sym} 134090 -2250 0 0 {name=p133688 lab=_85798_/D }
C {devices/lab_pin.sym} 134270 -2270 0 1 {name=p133689 lab=_65298_/B }
C {sky130_stdcells/dfxtp_4.sym} 134180 -2260 0 0 {name=X_85798_ }
C {devices/lab_pin.sym} 134140 -2130 0 0 {name=p133690 lab=_64295_/C }
C {devices/lab_pin.sym} 134220 -2130 0 1 {name=p133691 lab=_63448_/B }
C {sky130_stdcells/buf_2.sym} 134180 -2130 0 0 {name=X_59505_ }
C {devices/lab_pin.sym} 134100 -2030 0 0 {name=p133692 lab=_57416_/A }
C {devices/lab_pin.sym} 134100 -1990 0 0 {name=p133693 lab=_57416_/C }
C {devices/lab_pin.sym} 134100 -1950 0 0 {name=p133694 lab=_56764_/B }
C {devices/lab_pin.sym} 134260 -1990 0 1 {name=p133695 lab=_56717_/Y }
C {sky130_stdcells/a21oi_4.sym} 134180 -1990 0 0 {name=X_56717_ }
C {devices/lab_pin.sym} 134140 -1850 0 0 {name=p133696 lab=_86982_/Q }
C {devices/lab_pin.sym} 134220 -1850 0 1 {name=p133697 lab=_44731_/Y }
C {sky130_stdcells/inv_2.sym} 134180 -1850 0 0 {name=X_44731_ }
C {devices/lab_pin.sym} 134120 -1740 0 0 {name=p133698 lab=_80800_/Q }
C {devices/lab_pin.sym} 134120 -1700 0 0 {name=p133699 lab=_75551_/B }
C {devices/lab_pin.sym} 134240 -1720 0 1 {name=p133700 lab=_80768_/D }
C {sky130_stdcells/xnor2_4.sym} 134180 -1720 0 0 {name=X_75551_ }
C {devices/lab_pin.sym} 134090 -1590 0 0 {name=p133701 lab=_87544_/CLK }
C {devices/lab_pin.sym} 134090 -1570 0 0 {name=p133702 lab=_43209_/Y }
C {devices/lab_pin.sym} 134270 -1590 0 1 {name=p133703 lab=_87537_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -1580 0 0 {name=X_87537_ }
C {devices/lab_pin.sym} 134140 -1450 0 0 {name=p133704 lab=_53929_/A }
C {devices/lab_pin.sym} 134220 -1450 0 1 {name=p133705 lab=_53949_/A }
C {sky130_stdcells/buf_2.sym} 134180 -1450 0 0 {name=X_53929_ }
C {devices/lab_pin.sym} 134100 -1370 0 0 {name=p133706 lab=_41932_/X }
C {devices/lab_pin.sym} 134100 -1330 0 0 {name=p133707 lab=_41927_/X }
C {devices/lab_pin.sym} 134100 -1290 0 0 {name=p133708 lab=_40682_/X }
C {devices/lab_pin.sym} 134100 -1250 0 0 {name=p133709 lab=_73963_/A }
C {devices/lab_pin.sym} 134100 -1210 0 0 {name=p133710 lab=_41928_/X }
C {devices/lab_pin.sym} 134260 -1290 0 1 {name=p133711 lab=_41944_/A }
C {sky130_stdcells/o32ai_4.sym} 134180 -1290 0 0 {name=X_41943_ }
C {devices/lab_pin.sym} 134100 -1150 0 0 {name=p133712 lab=_72738_/X }
C {devices/lab_pin.sym} 134100 -1110 0 0 {name=p133713 lab=_72764_/C }
C {devices/lab_pin.sym} 134100 -1070 0 0 {name=p133714 lab=_72762_/X }
C {devices/lab_pin.sym} 134260 -1110 0 1 {name=p133715 lab=_72763_/X }
C {sky130_stdcells/a21o_4.sym} 134180 -1110 0 0 {name=X_72763_ }
C {devices/lab_pin.sym} 134090 -970 0 0 {name=p133716 lab=_86665_/CLK }
C {devices/lab_pin.sym} 134090 -950 0 0 {name=p133717 lab=_84749_/D }
C {devices/lab_pin.sym} 134270 -970 0 1 {name=p133718 lab=_84749_/Q }
C {sky130_stdcells/dfxtp_4.sym} 134180 -960 0 0 {name=X_84749_ }
C {devices/lab_pin.sym} 134140 -830 0 0 {name=p133719 lab=_57696_/X }
C {devices/lab_pin.sym} 134220 -830 0 1 {name=p133720 lab=_57697_/X }
C {sky130_stdcells/buf_2.sym} 134180 -830 0 0 {name=X_57697_ }
C {devices/lab_pin.sym} 134100 -730 0 0 {name=p133721 lab=_74500_/Y }
C {devices/lab_pin.sym} 134100 -690 0 0 {name=p133722 lab=_74492_/X }
C {devices/lab_pin.sym} 134100 -650 0 0 {name=p133723 lab=_74501_/X }
C {devices/lab_pin.sym} 134260 -690 0 1 {name=p133724 lab=_74502_/Y }
C {sky130_stdcells/a21oi_4.sym} 134180 -690 0 0 {name=X_74502_ }
C {devices/lab_pin.sym} 135060 -42150 0 0 {name=p133725 lab=_83729_/Q }
C {devices/lab_pin.sym} 135140 -42150 0 1 {name=p133726 lab=_47451_/A }
C {sky130_stdcells/inv_2.sym} 135100 -42150 0 0 {name=X_47450_ }
C {devices/lab_pin.sym} 135040 -42040 0 0 {name=p133727 lab=_71823_/A }
C {devices/lab_pin.sym} 135040 -42000 0 0 {name=p133728 lab=_71713_/Y }
C {devices/lab_pin.sym} 135160 -42020 0 1 {name=p133729 lab=_71714_/Y }
C {sky130_stdcells/nor2_4.sym} 135100 -42020 0 0 {name=X_71714_ }
C {devices/lab_pin.sym} 135060 -41890 0 0 {name=p133730 lab=_64526_/B }
C {devices/lab_pin.sym} 135140 -41890 0 1 {name=p133731 lab=_59436_/Y }
C {sky130_stdcells/inv_2.sym} 135100 -41890 0 0 {name=X_59436_ }
C {devices/lab_pin.sym} 135040 -41780 0 0 {name=p133732 lab=_82684_/Q }
C {devices/lab_pin.sym} 135040 -41740 0 0 {name=p133733 lab=_78270_/B }
C {devices/lab_pin.sym} 135160 -41760 0 1 {name=p133734 lab=_78270_/X }
C {sky130_stdcells/xor2_4.sym} 135100 -41760 0 0 {name=X_78270_ }
C {devices/lab_pin.sym} 135060 -41630 0 0 {name=p133735 lab=_44662_/A }
C {devices/lab_pin.sym} 135140 -41630 0 1 {name=p133736 lab=_87012_/D }
C {sky130_stdcells/inv_2.sym} 135100 -41630 0 0 {name=X_44662_ }
C {devices/lab_pin.sym} 135020 -41530 0 0 {name=p133737 lab=_55491_/A }
C {devices/lab_pin.sym} 135020 -41490 0 0 {name=p133738 lab=_55490_/X }
C {devices/lab_pin.sym} 135020 -41450 0 0 {name=p133739 lab=_55676_/B }
C {devices/lab_pin.sym} 135180 -41490 0 1 {name=p133740 lab=_56972_/A }
C {sky130_stdcells/a21bo_4.sym} 135100 -41490 0 0 {name=X_56648_ }
C {devices/lab_pin.sym} 135040 -41370 0 0 {name=p133741 lab=_75477_/X }
C {devices/lab_pin.sym} 135040 -41330 0 0 {name=p133742 lab=_75480_/Y }
C {devices/lab_pin.sym} 135040 -41290 0 0 {name=p133743 lab=_75478_/Y }
C {devices/lab_pin.sym} 135160 -41330 0 1 {name=p133744 lab=_75482_/Y }
C {sky130_stdcells/nand3_4.sym} 135100 -41330 0 0 {name=X_75482_ }
C {devices/lab_pin.sym} 135010 -41190 0 0 {name=p133745 lab=_87708_/CLK }
C {devices/lab_pin.sym} 135010 -41170 0 0 {name=p133746 lab=_87468_/D }
C {devices/lab_pin.sym} 135190 -41190 0 1 {name=p133747 lab=_87468_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -41180 0 0 {name=X_87468_ }
C {devices/lab_pin.sym} 135060 -41050 0 0 {name=p133748 lab=_41873_/Y }
C {devices/lab_pin.sym} 135140 -41050 0 1 {name=p133749 lab=_88115_/D }
C {sky130_stdcells/inv_2.sym} 135100 -41050 0 0 {name=X_41874_ }
C {devices/lab_pin.sym} 135020 -40950 0 0 {name=p133750 lab=_70236_/C }
C {devices/lab_pin.sym} 135020 -40910 0 0 {name=p133751 lab=_72686_/X }
C {devices/lab_pin.sym} 135020 -40870 0 0 {name=p133752 lab=_72693_/Y }
C {devices/lab_pin.sym} 135180 -40910 0 1 {name=p133753 lab=_83187_/D }
C {sky130_stdcells/a21bo_4.sym} 135100 -40910 0 0 {name=X_72694_ }
C {devices/lab_pin.sym} 135060 -40770 0 0 {name=p133754 lab=_46401_/A }
C {devices/lab_pin.sym} 135140 -40770 0 1 {name=p133755 lab=_46408_/A }
C {sky130_stdcells/buf_2.sym} 135100 -40770 0 0 {name=X_46401_ }
C {devices/lab_pin.sym} 135040 -40660 0 0 {name=p133756 lab=_77219_/B }
C {devices/lab_pin.sym} 135040 -40620 0 0 {name=p133757 lab=_77219_/A }
C {devices/lab_pin.sym} 135160 -40640 0 1 {name=p133758 lab=_77223_/A }
C {sky130_stdcells/nand2_4.sym} 135100 -40640 0 0 {name=X_77221_ }
C {devices/lab_pin.sym} 135060 -40510 0 0 {name=p133759 lab=_43613_/A }
C {devices/lab_pin.sym} 135140 -40510 0 1 {name=p133760 lab=_43613_/Y }
C {sky130_stdcells/inv_2.sym} 135100 -40510 0 0 {name=X_43613_ }
C {devices/lab_pin.sym} 135040 -40400 0 0 {name=p133761 lab=_74413_/X }
C {devices/lab_pin.sym} 135040 -40360 0 0 {name=p133762 lab=_48514_/A }
C {devices/lab_pin.sym} 135160 -40380 0 1 {name=p133763 lab=_74433_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -40380 0 0 {name=X_74433_ }
C {devices/lab_pin.sym} 135010 -40250 0 0 {name=p133764 lab=_86422_/CLK }
C {devices/lab_pin.sym} 135010 -40230 0 0 {name=p133765 lab=_86419_/D }
C {devices/lab_pin.sym} 135190 -40250 0 1 {name=p133766 lab=_86419_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -40240 0 0 {name=X_86419_ }
C {devices/lab_pin.sym} 135020 -40130 0 0 {name=p133767 lab=_40783_/X }
C {devices/lab_pin.sym} 135020 -40090 0 0 {name=p133768 lab=_82293_/Q }
C {devices/lab_pin.sym} 135020 -40050 0 0 {name=p133769 lab=_40824_/X }
C {devices/lab_pin.sym} 135180 -40090 0 1 {name=p133770 lab=_40826_/A }
C {sky130_stdcells/o21a_4.sym} 135100 -40090 0 0 {name=X_40825_ }
C {devices/lab_pin.sym} 135020 -39970 0 0 {name=p133771 lab=_47375_/Y }
C {devices/lab_pin.sym} 135020 -39930 0 0 {name=p133772 lab=_47364_/X }
C {devices/lab_pin.sym} 135020 -39890 0 0 {name=p133773 lab=_47380_/X }
C {devices/lab_pin.sym} 135180 -39930 0 1 {name=p133774 lab=_47381_/Y }
C {sky130_stdcells/a21oi_4.sym} 135100 -39930 0 0 {name=X_47381_ }
C {devices/lab_pin.sym} 135020 -39810 0 0 {name=p133775 lab=_59231_/X }
C {devices/lab_pin.sym} 135020 -39770 0 0 {name=p133776 lab=_85411_/Q }
C {devices/lab_pin.sym} 135020 -39730 0 0 {name=p133777 lab=_59366_/X }
C {devices/lab_pin.sym} 135180 -39770 0 1 {name=p133778 lab=_59367_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -39770 0 0 {name=X_59367_ }
C {devices/lab_pin.sym} 135020 -39650 0 0 {name=p133779 lab=_59500_/Y }
C {devices/lab_pin.sym} 135020 -39610 0 0 {name=p133780 lab=_71628_/A }
C {devices/lab_pin.sym} 135020 -39570 0 0 {name=p133781 lab=_71644_/Y }
C {devices/lab_pin.sym} 135180 -39610 0 1 {name=p133782 lab=_71645_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -39610 0 0 {name=X_71645_ }
C {devices/lab_pin.sym} 135020 -39500 0 0 {name=p133783 lab=_56568_/X }
C {devices/lab_pin.sym} 135020 -39460 0 0 {name=p133784 lab=_56578_/X }
C {devices/lab_pin.sym} 135020 -39420 0 0 {name=p133785 lab=_55599_/B }
C {devices/lab_pin.sym} 135020 -39380 0 0 {name=p133786 lab=_56572_/X }
C {devices/lab_pin.sym} 135180 -39440 0 1 {name=p133787 lab=_85150_/D }
C {sky130_stdcells/a2bb2o_4.sym} 135100 -39440 0 0 {name=X_56579_ }
C {devices/lab_pin.sym} 135060 -39290 0 0 {name=p133788 lab=_44529_/A }
C {devices/lab_pin.sym} 135140 -39290 0 1 {name=p133789 lab=_44593_/X }
C {sky130_stdcells/buf_2.sym} 135100 -39290 0 0 {name=X_44593_ }
C {devices/lab_pin.sym} 135010 -39170 0 0 {name=p133790 lab=_86932_/CLK }
C {devices/lab_pin.sym} 135010 -39150 0 0 {name=p133791 lab=_87399_/D }
C {devices/lab_pin.sym} 135190 -39170 0 1 {name=p133792 lab=_87399_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -39160 0 0 {name=X_87399_ }
C {devices/lab_pin.sym} 135020 -39050 0 0 {name=p133793 lab=_49018_/X }
C {devices/lab_pin.sym} 135020 -39010 0 0 {name=p133794 lab=_48618_/Y }
C {devices/lab_pin.sym} 135020 -38970 0 0 {name=p133795 lab=_49119_/Y }
C {devices/lab_pin.sym} 135180 -39010 0 1 {name=p133796 lab=_49121_/A }
C {sky130_stdcells/a21o_4.sym} 135100 -39010 0 0 {name=X_49120_ }
C {devices/lab_pin.sym} 135020 -38890 0 0 {name=p133797 lab=_46327_/Y }
C {devices/lab_pin.sym} 135020 -38850 0 0 {name=p133798 lab=_46258_/X }
C {devices/lab_pin.sym} 135020 -38810 0 0 {name=p133799 lab=_46331_/Y }
C {devices/lab_pin.sym} 135180 -38850 0 1 {name=p133800 lab=_46332_/Y }
C {sky130_stdcells/a21boi_4.sym} 135100 -38850 0 0 {name=X_46332_ }
C {devices/lab_pin.sym} 135020 -38730 0 0 {name=p133801 lab=_58310_/X }
C {devices/lab_pin.sym} 135020 -38690 0 0 {name=p133802 lab=_83456_/Q }
C {devices/lab_pin.sym} 135020 -38650 0 0 {name=p133803 lab=_58317_/Y }
C {devices/lab_pin.sym} 135180 -38690 0 1 {name=p133804 lab=_84880_/D }
C {sky130_stdcells/o21a_4.sym} 135100 -38690 0 0 {name=X_58318_ }
C {devices/lab_pin.sym} 135040 -38560 0 0 {name=p133805 lab=_77152_/A }
C {devices/lab_pin.sym} 135040 -38520 0 0 {name=p133806 lab=_77152_/B }
C {devices/lab_pin.sym} 135160 -38540 0 1 {name=p133807 lab=_77152_/X }
C {sky130_stdcells/xor2_4.sym} 135100 -38540 0 0 {name=X_77152_ }
C {devices/lab_pin.sym} 135060 -38410 0 0 {name=p133808 lab=_43544_/A }
C {devices/lab_pin.sym} 135140 -38410 0 1 {name=p133809 lab=_43544_/Y }
C {sky130_stdcells/inv_2.sym} 135100 -38410 0 0 {name=X_43544_ }
C {devices/lab_pin.sym} 135020 -38310 0 0 {name=p133810 lab=_83081_/Q }
C {devices/lab_pin.sym} 135020 -38270 0 0 {name=p133811 lab=_72066_/X }
C {devices/lab_pin.sym} 135020 -38230 0 0 {name=p133812 lab=_74363_/Y }
C {devices/lab_pin.sym} 135180 -38270 0 1 {name=p133813 lab=_74364_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -38270 0 0 {name=X_74364_ }
C {devices/lab_pin.sym} 135060 -38130 0 0 {name=p133814 lab=_40756_/A }
C {devices/lab_pin.sym} 135140 -38130 0 1 {name=p133815 lab=_40756_/X }
C {sky130_stdcells/buf_2.sym} 135100 -38130 0 0 {name=X_40756_ }
C {devices/lab_pin.sym} 135020 -38030 0 0 {name=p133816 lab=_59294_/Y }
C {devices/lab_pin.sym} 135020 -37990 0 0 {name=p133817 lab=_59296_/Y }
C {devices/lab_pin.sym} 135020 -37950 0 0 {name=p133818 lab=_59297_/X }
C {devices/lab_pin.sym} 135180 -37990 0 1 {name=p133819 lab=_59298_/X }
C {sky130_stdcells/a21o_4.sym} 135100 -37990 0 0 {name=X_59298_ }
C {devices/lab_pin.sym} 135060 -37850 0 0 {name=p133820 lab=_70570_/Y }
C {devices/lab_pin.sym} 135140 -37850 0 1 {name=p133821 lab=_71576_/X }
C {sky130_stdcells/buf_2.sym} 135100 -37850 0 0 {name=X_71576_ }
C {devices/lab_pin.sym} 135040 -37740 0 0 {name=p133822 lab=_76103_/A }
C {devices/lab_pin.sym} 135040 -37700 0 0 {name=p133823 lab=_76102_/Y }
C {devices/lab_pin.sym} 135160 -37720 0 1 {name=p133824 lab=_76104_/B }
C {sky130_stdcells/xor2_4.sym} 135100 -37720 0 0 {name=X_76103_ }
C {devices/lab_pin.sym} 135020 -37610 0 0 {name=p133825 lab=_49047_/Y }
C {devices/lab_pin.sym} 135020 -37570 0 0 {name=p133826 lab=_49038_/X }
C {devices/lab_pin.sym} 135020 -37530 0 0 {name=p133827 lab=_49050_/X }
C {devices/lab_pin.sym} 135180 -37570 0 1 {name=p133828 lab=_49051_/Y }
C {sky130_stdcells/a21oi_4.sym} 135100 -37570 0 0 {name=X_49051_ }
C {devices/lab_pin.sym} 135040 -37450 0 0 {name=p133829 lab=_73313_/X }
C {devices/lab_pin.sym} 135040 -37410 0 0 {name=p133830 lab=_73301_/X }
C {devices/lab_pin.sym} 135040 -37370 0 0 {name=p133831 lab=_73303_/X }
C {devices/lab_pin.sym} 135160 -37410 0 1 {name=p133832 lab=_73315_/Y }
C {sky130_stdcells/nand3_4.sym} 135100 -37410 0 0 {name=X_73315_ }
C {devices/lab_pin.sym} 135060 -37270 0 0 {name=p133833 lab=_46526_/A }
C {devices/lab_pin.sym} 135140 -37270 0 1 {name=p133834 lab=_46349_/A }
C {sky130_stdcells/buf_2.sym} 135100 -37270 0 0 {name=X_46263_ }
C {devices/lab_pin.sym} 135020 -37170 0 0 {name=p133835 lab=_57682_/Y }
C {devices/lab_pin.sym} 135020 -37130 0 0 {name=p133836 lab=_70500_/Y }
C {devices/lab_pin.sym} 135020 -37090 0 0 {name=p133837 lab=_70526_/Y }
C {devices/lab_pin.sym} 135180 -37130 0 1 {name=p133838 lab=_70527_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -37130 0 0 {name=X_70527_ }
C {devices/lab_pin.sym} 135020 -37010 0 0 {name=p133839 lab=_58219_/X }
C {devices/lab_pin.sym} 135020 -36970 0 0 {name=p133840 lab=_58246_/Y }
C {devices/lab_pin.sym} 135020 -36930 0 0 {name=p133841 lab=_58248_/Y }
C {devices/lab_pin.sym} 135180 -36970 0 1 {name=p133842 lab=_84898_/D }
C {sky130_stdcells/a21oi_4.sym} 135100 -36970 0 0 {name=X_58249_ }
C {devices/lab_pin.sym} 135040 -36850 0 0 {name=p133843 lab=_77073_/A }
C {devices/lab_pin.sym} 135040 -36810 0 0 {name=p133844 lab=_77077_/A }
C {devices/lab_pin.sym} 135040 -36770 0 0 {name=p133845 lab=_77086_/B }
C {devices/lab_pin.sym} 135160 -36810 0 1 {name=p133846 lab=_77083_/X }
C {sky130_stdcells/and3_4.sym} 135100 -36810 0 0 {name=X_77083_ }
C {devices/lab_pin.sym} 135060 -36670 0 0 {name=p133847 lab=_43425_/X }
C {devices/lab_pin.sym} 135140 -36670 0 1 {name=p133848 lab=_43475_/X }
C {sky130_stdcells/buf_2.sym} 135100 -36670 0 0 {name=X_43475_ }
C {devices/lab_pin.sym} 135040 -36570 0 0 {name=p133849 lab=_74297_/A }
C {devices/lab_pin.sym} 135040 -36530 0 0 {name=p133850 lab=_74297_/B }
C {devices/lab_pin.sym} 135040 -36490 0 0 {name=p133851 lab=_56003_/B }
C {devices/lab_pin.sym} 135160 -36530 0 1 {name=p133852 lab=_74295_/Y }
C {sky130_stdcells/nand3_4.sym} 135100 -36530 0 0 {name=X_74295_ }
C {devices/lab_pin.sym} 135060 -36390 0 0 {name=p133853 lab=_40835_/A }
C {devices/lab_pin.sym} 135140 -36390 0 1 {name=p133854 lab=_40687_/X }
C {sky130_stdcells/buf_2.sym} 135100 -36390 0 0 {name=X_40687_ }
C {devices/lab_pin.sym} 135060 -36270 0 0 {name=p133855 lab=_83545_/Q }
C {devices/lab_pin.sym} 135140 -36270 0 1 {name=p133856 lab=_53535_/B }
C {sky130_stdcells/inv_2.sym} 135100 -36270 0 0 {name=X_48002_ }
C {devices/lab_pin.sym} 135020 -36170 0 0 {name=p133857 lab=_85293_/Q }
C {devices/lab_pin.sym} 135020 -36130 0 0 {name=p133858 lab=_45194_/X }
C {devices/lab_pin.sym} 135020 -36090 0 0 {name=p133859 lab=_45153_/X }
C {devices/lab_pin.sym} 135180 -36130 0 1 {name=p133860 lab=_45214_/X }
C {sky130_stdcells/o21a_4.sym} 135100 -36130 0 0 {name=X_45214_ }
C {devices/lab_pin.sym} 135040 -36010 0 0 {name=p133861 lab=_76024_/A }
C {devices/lab_pin.sym} 135040 -35970 0 0 {name=p133862 lab=_76028_/A }
C {devices/lab_pin.sym} 135040 -35930 0 0 {name=p133863 lab=_76028_/B }
C {devices/lab_pin.sym} 135160 -35970 0 1 {name=p133864 lab=_76034_/X }
C {sky130_stdcells/and3_4.sym} 135100 -35970 0 0 {name=X_76034_ }
C {devices/lab_pin.sym} 135020 -35870 0 0 {name=p133865 lab=_42417_/X }
C {devices/lab_pin.sym} 135020 -35830 0 0 {name=p133866 lab=_42410_/X }
C {devices/lab_pin.sym} 135020 -35790 0 0 {name=p133867 lab=_40501_/X }
C {devices/lab_pin.sym} 135020 -35750 0 0 {name=p133868 lab=_87869_/Q }
C {devices/lab_pin.sym} 135020 -35710 0 0 {name=p133869 lab=_42411_/X }
C {devices/lab_pin.sym} 135180 -35790 0 1 {name=p133870 lab=_42427_/A }
C {sky130_stdcells/o32ai_4.sym} 135100 -35790 0 0 {name=X_42426_ }
C {devices/lab_pin.sym} 135060 -35630 0 0 {name=p133871 lab=_61260_/A }
C {devices/lab_pin.sym} 135140 -35630 0 1 {name=p133872 lab=_61260_/X }
C {sky130_stdcells/buf_2.sym} 135100 -35630 0 0 {name=X_61260_ }
C {devices/lab_pin.sym} 135020 -35530 0 0 {name=p133873 lab=_83159_/Q }
C {devices/lab_pin.sym} 135020 -35490 0 0 {name=p133874 lab=_73193_/X }
C {devices/lab_pin.sym} 135020 -35450 0 0 {name=p133875 lab=_73245_/Y }
C {devices/lab_pin.sym} 135180 -35490 0 1 {name=p133876 lab=_83159_/D }
C {sky130_stdcells/a21o_4.sym} 135100 -35490 0 0 {name=X_73246_ }
C {devices/lab_pin.sym} 135060 -35350 0 0 {name=p133877 lab=_70457_/X }
C {devices/lab_pin.sym} 135140 -35350 0 1 {name=p133878 lab=_70458_/X }
C {sky130_stdcells/buf_2.sym} 135100 -35350 0 0 {name=X_70458_ }
C {devices/lab_pin.sym} 135040 -35260 0 0 {name=p133879 lab=_46143_/D }
C {devices/lab_pin.sym} 135040 -35220 0 0 {name=p133880 lab=_46222_/B }
C {devices/lab_pin.sym} 135040 -35180 0 0 {name=p133881 lab=_46128_/D }
C {devices/lab_pin.sym} 135040 -35140 0 0 {name=p133882 lab=_46133_/C }
C {devices/lab_pin.sym} 135160 -35200 0 1 {name=p133883 lab=_46195_/D }
C {sky130_stdcells/nand4_4.sym} 135100 -35200 0 0 {name=X_46194_ }
C {devices/lab_pin.sym} 135060 -35050 0 0 {name=p133884 lab=clkbuf_9_345_0_CLK/X }
C {devices/lab_pin.sym} 135140 -35050 0 1 {name=p133885 lab=_87636_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 135100 -35050 0 0 {name=Xclkbuf_10_691_0_CLK }
C {devices/lab_pin.sym} 135060 -34930 0 0 {name=p133886 lab=_85535_/CLK }
C {devices/lab_pin.sym} 135140 -34930 0 1 {name=p133887 lab=_85556_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 135100 -34930 0 0 {name=Xclkbuf_opt_17_CLK }
C {devices/lab_pin.sym} 135040 -34820 0 0 {name=p133888 lab=_60211_/A }
C {devices/lab_pin.sym} 135040 -34780 0 0 {name=p133889 lab=_60309_/D }
C {devices/lab_pin.sym} 135160 -34800 0 1 {name=p133890 lab=_60212_/A }
C {sky130_stdcells/nand2_4.sym} 135100 -34800 0 0 {name=X_60211_ }
C {devices/lab_pin.sym} 135020 -34690 0 0 {name=p133891 lab=_45127_/X }
C {devices/lab_pin.sym} 135020 -34650 0 0 {name=p133892 lab=_61509_/B }
C {devices/lab_pin.sym} 135020 -34610 0 0 {name=p133893 lab=_45144_/X }
C {devices/lab_pin.sym} 135180 -34650 0 1 {name=p133894 lab=_45145_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -34650 0 0 {name=X_45145_ }
C {devices/lab_pin.sym} 135060 -34510 0 0 {name=p133895 lab=_42304_/X }
C {devices/lab_pin.sym} 135140 -34510 0 1 {name=p133896 lab=_42357_/X }
C {sky130_stdcells/buf_2.sym} 135100 -34510 0 0 {name=X_42357_ }
C {devices/lab_pin.sym} 135060 -34390 0 0 {name=p133897 lab=_72543_/A }
C {devices/lab_pin.sym} 135140 -34390 0 1 {name=p133898 lab=_61234_/A }
C {sky130_stdcells/buf_2.sym} 135100 -34390 0 0 {name=X_61191_ }
C {devices/lab_pin.sym} 135040 -34280 0 0 {name=p133899 lab=_87555_/Q }
C {devices/lab_pin.sym} 135040 -34240 0 0 {name=p133900 lab=_72758_/X }
C {devices/lab_pin.sym} 135160 -34260 0 1 {name=p133901 lab=_73177_/Y }
C {sky130_stdcells/nor2_4.sym} 135100 -34260 0 0 {name=X_73177_ }
C {devices/lab_pin.sym} 135040 -34150 0 0 {name=p133902 lab=_70366_/X }
C {devices/lab_pin.sym} 135040 -34110 0 0 {name=p133903 lab=_74527_/A }
C {devices/lab_pin.sym} 135040 -34070 0 0 {name=p133904 lab=_70375_/C }
C {devices/lab_pin.sym} 135160 -34110 0 1 {name=p133905 lab=_70389_/Y }
C {sky130_stdcells/nand3_4.sym} 135100 -34110 0 0 {name=X_70389_ }
C {devices/lab_pin.sym} 135060 -33970 0 0 {name=p133906 lab=clkbuf_8_91_0_CLK/X }
C {devices/lab_pin.sym} 135140 -33970 0 1 {name=p133907 lab=clkbuf_9_182_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 135100 -33970 0 0 {name=Xclkbuf_9_182_0_CLK }
C {devices/lab_pin.sym} 135060 -33850 0 0 {name=p133908 lab=_41253_/A }
C {devices/lab_pin.sym} 135140 -33850 0 1 {name=p133909 lab=_41308_/X }
C {sky130_stdcells/buf_2.sym} 135100 -33850 0 0 {name=X_41308_ }
C {devices/lab_pin.sym} 135060 -33730 0 0 {name=p133910 lab=_79936_/B }
C {devices/lab_pin.sym} 135140 -33730 0 1 {name=p133911 lab=_79937_/A }
C {sky130_stdcells/inv_2.sym} 135100 -33730 0 0 {name=X_60142_ }
C {devices/lab_pin.sym} 135040 -33620 0 0 {name=p133912 lab=_59326_/X }
C {devices/lab_pin.sym} 135040 -33580 0 0 {name=p133913 lab=_72128_/B }
C {devices/lab_pin.sym} 135160 -33600 0 1 {name=p133914 lab=_72128_/Y }
C {sky130_stdcells/nor2_4.sym} 135100 -33600 0 0 {name=X_72128_ }
C {devices/lab_pin.sym} 135040 -33500 0 0 {name=p133915 lab=_49973_/A }
C {devices/lab_pin.sym} 135040 -33460 0 0 {name=p133916 lab=_49943_/B }
C {devices/lab_pin.sym} 135040 -33420 0 0 {name=p133917 lab=_49953_/C }
C {devices/lab_pin.sym} 135040 -33380 0 0 {name=p133918 lab=_53165_/D }
C {devices/lab_pin.sym} 135160 -33440 0 1 {name=p133919 lab=_49953_/X }
C {sky130_stdcells/and4_4.sym} 135100 -33440 0 0 {name=X_49953_ }
C {devices/lab_pin.sym} 135020 -33310 0 0 {name=p133920 lab=_56494_/C }
C {devices/lab_pin.sym} 135020 -33270 0 0 {name=p133921 lab=_45060_/X }
C {devices/lab_pin.sym} 135020 -33230 0 0 {name=p133922 lab=_45040_/X }
C {devices/lab_pin.sym} 135180 -33270 0 1 {name=p133923 lab=_45076_/X }
C {sky130_stdcells/o21a_4.sym} 135100 -33270 0 0 {name=X_45076_ }
C {devices/lab_pin.sym} 135020 -33160 0 0 {name=p133924 lab=_41552_/X }
C {devices/lab_pin.sym} 135020 -33120 0 0 {name=p133925 lab=_42271_/X }
C {devices/lab_pin.sym} 135020 -33080 0 0 {name=p133926 lab=_87938_/Q }
C {devices/lab_pin.sym} 135020 -33040 0 0 {name=p133927 lab=_42272_/X }
C {devices/lab_pin.sym} 135180 -33100 0 1 {name=p133928 lab=_87938_/D }
C {sky130_stdcells/a2bb2o_4.sym} 135100 -33100 0 0 {name=X_42288_ }
C {devices/lab_pin.sym} 135060 -32950 0 0 {name=p133929 lab=_82078_/Q }
C {devices/lab_pin.sym} 135140 -32950 0 1 {name=p133930 lab=_77999_/A }
C {sky130_stdcells/inv_2.sym} 135100 -32950 0 0 {name=X_77985_ }
C {devices/lab_pin.sym} 135060 -32830 0 0 {name=p133931 lab=_48904_/A }
C {devices/lab_pin.sym} 135140 -32830 0 1 {name=p133932 lab=_48976_/A }
C {sky130_stdcells/buf_2.sym} 135100 -32830 0 0 {name=X_48904_ }
C {devices/lab_pin.sym} 135060 -32710 0 0 {name=p133933 lab=_44247_/A }
C {devices/lab_pin.sym} 135140 -32710 0 1 {name=p133934 lab=_69654_/A }
C {sky130_stdcells/buf_2.sym} 135100 -32710 0 0 {name=X_44027_ }
C {devices/lab_pin.sym} 135040 -32600 0 0 {name=p133935 lab=_79720_/X }
C {devices/lab_pin.sym} 135040 -32560 0 0 {name=p133936 lab=_79724_/B }
C {devices/lab_pin.sym} 135160 -32580 0 1 {name=p133937 lab=_79724_/X }
C {sky130_stdcells/xor2_4.sym} 135100 -32580 0 0 {name=X_79724_ }
C {devices/lab_pin.sym} 135020 -32470 0 0 {name=p133938 lab=_64947_/X }
C {devices/lab_pin.sym} 135020 -32430 0 0 {name=p133939 lab=_64949_/X }
C {devices/lab_pin.sym} 135020 -32390 0 0 {name=p133940 lab=_64851_/X }
C {devices/lab_pin.sym} 135180 -32430 0 1 {name=p133941 lab=_64953_/A }
C {sky130_stdcells/a21o_4.sym} 135100 -32430 0 0 {name=X_64950_ }
C {devices/lab_pin.sym} 135060 -32290 0 0 {name=p133942 lab=_40999_/A }
C {devices/lab_pin.sym} 135140 -32290 0 1 {name=p133943 lab=_41239_/X }
C {sky130_stdcells/buf_2.sym} 135100 -32290 0 0 {name=X_41239_ }
C {devices/lab_pin.sym} 135060 -32170 0 0 {name=p133944 lab=_71978_/A }
C {devices/lab_pin.sym} 135140 -32170 0 1 {name=p133945 lab=_72059_/X }
C {sky130_stdcells/buf_2.sym} 135100 -32170 0 0 {name=X_72059_ }
C {devices/lab_pin.sym} 135020 -32070 0 0 {name=p133946 lab=_81503_/Q }
C {devices/lab_pin.sym} 135020 -32030 0 0 {name=p133947 lab=_76933_/Y }
C {devices/lab_pin.sym} 135020 -31990 0 0 {name=p133948 lab=_76935_/X }
C {devices/lab_pin.sym} 135180 -32030 0 1 {name=p133949 lab=_76936_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -32030 0 0 {name=X_76936_ }
C {devices/lab_pin.sym} 135060 -31890 0 0 {name=p133950 lab=_60072_/Y }
C {devices/lab_pin.sym} 135140 -31890 0 1 {name=p133951 lab=_60073_/Y }
C {sky130_stdcells/inv_2.sym} 135100 -31890 0 0 {name=X_60073_ }
C {devices/lab_pin.sym} 135040 -31800 0 0 {name=p133952 lab=_49893_/A }
C {devices/lab_pin.sym} 135040 -31760 0 0 {name=p133953 lab=_49884_/B }
C {devices/lab_pin.sym} 135040 -31720 0 0 {name=p133954 lab=_49893_/C }
C {devices/lab_pin.sym} 135040 -31680 0 0 {name=p133955 lab=_53099_/D }
C {devices/lab_pin.sym} 135160 -31740 0 1 {name=p133956 lab=_49884_/X }
C {sky130_stdcells/and4_4.sym} 135100 -31740 0 0 {name=X_49884_ }
C {devices/lab_pin.sym} 135040 -31620 0 0 {name=p133957 lab=_64334_/B }
C {devices/lab_pin.sym} 135040 -31580 0 0 {name=p133958 lab=_63920_/B }
C {devices/lab_pin.sym} 135040 -31540 0 0 {name=p133959 lab=_63840_/C }
C {devices/lab_pin.sym} 135040 -31500 0 0 {name=p133960 lab=_63920_/D }
C {devices/lab_pin.sym} 135160 -31560 0 1 {name=p133961 lab=_63901_/Y }
C {sky130_stdcells/nand4_4.sym} 135100 -31560 0 0 {name=X_63901_ }
C {devices/lab_pin.sym} 135020 -31430 0 0 {name=p133962 lab=_48832_/Y }
C {devices/lab_pin.sym} 135020 -31390 0 0 {name=p133963 lab=_48813_/X }
C {devices/lab_pin.sym} 135020 -31350 0 0 {name=p133964 lab=_48834_/X }
C {devices/lab_pin.sym} 135180 -31390 0 1 {name=p133965 lab=_86474_/D }
C {sky130_stdcells/a21oi_4.sym} 135100 -31390 0 0 {name=X_48835_ }
C {devices/lab_pin.sym} 135040 -31260 0 0 {name=p133966 lab=_84211_/Q }
C {devices/lab_pin.sym} 135040 -31220 0 0 {name=p133967 lab=_83259_/Q }
C {devices/lab_pin.sym} 135160 -31240 0 1 {name=p133968 lab=_79655_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -31240 0 0 {name=X_79655_ }
C {devices/lab_pin.sym} 135040 -31120 0 0 {name=p133969 lab=_64826_/A }
C {devices/lab_pin.sym} 135040 -31080 0 0 {name=p133970 lab=_85847_/Q }
C {devices/lab_pin.sym} 135160 -31100 0 1 {name=p133971 lab=_64881_/X }
C {sky130_stdcells/and2_4.sym} 135100 -31100 0 0 {name=X_64881_ }
C {devices/lab_pin.sym} 135060 -30970 0 0 {name=p133972 lab=_76857_/Y }
C {devices/lab_pin.sym} 135140 -30970 0 1 {name=p133973 lab=_76867_/Y }
C {sky130_stdcells/inv_2.sym} 135100 -30970 0 0 {name=X_76867_ }
C {devices/lab_pin.sym} 135060 -30850 0 0 {name=p133974 lab=clkbuf_8_98_0_CLK/X }
C {devices/lab_pin.sym} 135140 -30850 0 1 {name=p133975 lab=clkbuf_9_197_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 135100 -30850 0 0 {name=Xclkbuf_9_197_0_CLK }
C {devices/lab_pin.sym} 135020 -30750 0 0 {name=p133976 lab=_66617_/X }
C {devices/lab_pin.sym} 135020 -30710 0 0 {name=p133977 lab=_66619_/X }
C {devices/lab_pin.sym} 135020 -30670 0 0 {name=p133978 lab=_66547_/X }
C {devices/lab_pin.sym} 135180 -30710 0 1 {name=p133979 lab=_66620_/X }
C {sky130_stdcells/a21o_4.sym} 135100 -30710 0 0 {name=X_66620_ }
C {devices/lab_pin.sym} 135040 -30580 0 0 {name=p133980 lab=_78599_/X }
C {devices/lab_pin.sym} 135040 -30540 0 0 {name=p133981 lab=_78605_/Y }
C {devices/lab_pin.sym} 135160 -30560 0 1 {name=p133982 lab=_82774_/D }
C {sky130_stdcells/xor2_4.sym} 135100 -30560 0 0 {name=X_78606_ }
C {devices/lab_pin.sym} 135020 -30470 0 0 {name=p133983 lab=_63823_/X }
C {devices/lab_pin.sym} 135020 -30430 0 0 {name=p133984 lab=_63810_/X }
C {devices/lab_pin.sym} 135020 -30390 0 0 {name=p133985 lab=_63825_/Y }
C {devices/lab_pin.sym} 135020 -30350 0 0 {name=p133986 lab=_63828_/Y }
C {devices/lab_pin.sym} 135020 -30320 0 0 {name=p133987 lab=_63831_/X }
C {devices/lab_pin.sym} 135180 -30390 0 1 {name=p133988 lab=_63832_/X }
C {sky130_stdcells/a41o_4.sym} 135100 -30390 0 0 {name=X_63832_ }
C {devices/lab_pin.sym} 135040 -30240 0 0 {name=p133989 lab=_75818_/A }
C {devices/lab_pin.sym} 135040 -30200 0 0 {name=p133990 lab=_75817_/Y }
C {devices/lab_pin.sym} 135160 -30220 0 1 {name=p133991 lab=_75821_/A }
C {sky130_stdcells/nor2_4.sym} 135100 -30220 0 0 {name=X_75818_ }
C {devices/lab_pin.sym} 135040 -30110 0 0 {name=p133992 lab=_50447_/A }
C {devices/lab_pin.sym} 135040 -30070 0 0 {name=p133993 lab=_48766_/B }
C {devices/lab_pin.sym} 135040 -30030 0 0 {name=p133994 lab=_48786_/C }
C {devices/lab_pin.sym} 135160 -30070 0 1 {name=p133995 lab=_48766_/X }
C {sky130_stdcells/and3_4.sym} 135100 -30070 0 0 {name=X_48766_ }
C {devices/lab_pin.sym} 135040 -29940 0 0 {name=p133996 lab=_79586_/A }
C {devices/lab_pin.sym} 135040 -29900 0 0 {name=p133997 lab=_79585_/Y }
C {devices/lab_pin.sym} 135160 -29920 0 1 {name=p133998 lab=_79587_/B }
C {sky130_stdcells/nand2_4.sym} 135100 -29920 0 0 {name=X_79586_ }
C {devices/lab_pin.sym} 135020 -29820 0 0 {name=p133999 lab=_40407_/Y }
C {devices/lab_pin.sym} 135020 -29780 0 0 {name=p134000 lab=_45974_/X }
C {devices/lab_pin.sym} 135020 -29740 0 0 {name=p134001 lab=_86830_/Q }
C {devices/lab_pin.sym} 135020 -29700 0 0 {name=p134002 lab=_45976_/X }
C {devices/lab_pin.sym} 135180 -29760 0 1 {name=p134003 lab=_45978_/X }
C {sky130_stdcells/a2bb2o_4.sym} 135100 -29760 0 0 {name=X_45978_ }
C {devices/lab_pin.sym} 135020 -29640 0 0 {name=p134004 lab=_76784_/Y }
C {devices/lab_pin.sym} 135020 -29600 0 0 {name=p134005 lab=_76785_/Y }
C {devices/lab_pin.sym} 135020 -29560 0 0 {name=p134006 lab=_81488_/Q }
C {devices/lab_pin.sym} 135020 -29520 0 0 {name=p134007 lab=_81360_/D }
C {devices/lab_pin.sym} 135180 -29580 0 1 {name=p134008 lab=_76798_/X }
C {sky130_stdcells/a2bb2o_4.sym} 135100 -29580 0 0 {name=X_76798_ }
C {devices/lab_pin.sym} 135060 -29430 0 0 {name=p134009 lab=_54898_/B }
C {devices/lab_pin.sym} 135140 -29430 0 1 {name=p134010 lab=_53205_/B }
C {sky130_stdcells/buf_2.sym} 135100 -29430 0 0 {name=X_47717_ }
C {devices/lab_pin.sym} 135060 -29310 0 0 {name=p134011 lab=_64706_/A }
C {devices/lab_pin.sym} 135140 -29310 0 1 {name=p134012 lab=_69183_/A }
C {sky130_stdcells/buf_2.sym} 135100 -29310 0 0 {name=X_66551_ }
C {devices/lab_pin.sym} 135040 -29200 0 0 {name=p134013 lab=_78533_/X }
C {devices/lab_pin.sym} 135040 -29160 0 0 {name=p134014 lab=_78536_/X }
C {devices/lab_pin.sym} 135160 -29180 0 1 {name=p134015 lab=_78561_/B }
C {sky130_stdcells/xor2_4.sym} 135100 -29180 0 0 {name=X_78537_ }
C {devices/lab_pin.sym} 135020 -29070 0 0 {name=p134016 lab=_85183_/Q }
C {devices/lab_pin.sym} 135020 -29030 0 0 {name=p134017 lab=_44882_/X }
C {devices/lab_pin.sym} 135020 -28990 0 0 {name=p134018 lab=_44884_/X }
C {devices/lab_pin.sym} 135180 -29030 0 1 {name=p134019 lab=_44929_/X }
C {sky130_stdcells/o21a_4.sym} 135100 -29030 0 0 {name=X_44929_ }
C {devices/lab_pin.sym} 135060 -28890 0 0 {name=p134020 lab=_80918_/Q }
C {devices/lab_pin.sym} 135140 -28890 0 1 {name=p134021 lab=_75751_/A }
C {sky130_stdcells/inv_2.sym} 135100 -28890 0 0 {name=X_75749_ }
C {devices/lab_pin.sym} 135060 -28770 0 0 {name=p134022 lab=_63733_/X }
C {devices/lab_pin.sym} 135140 -28770 0 1 {name=p134023 lab=_64184_/C }
C {sky130_stdcells/buf_2.sym} 135100 -28770 0 0 {name=X_63763_ }
C {devices/lab_pin.sym} 135060 -28650 0 0 {name=p134024 lab=_64191_/D }
C {devices/lab_pin.sym} 135140 -28650 0 1 {name=p134025 lab=_61012_/A }
C {sky130_stdcells/buf_2.sym} 135100 -28650 0 0 {name=X_60975_ }
C {devices/lab_pin.sym} 135060 -28530 0 0 {name=p134026 lab=_48697_/A }
C {devices/lab_pin.sym} 135140 -28530 0 1 {name=p134027 lab=_48697_/Y }
C {sky130_stdcells/inv_2.sym} 135100 -28530 0 0 {name=X_48697_ }
C {devices/lab_pin.sym} 135060 -28410 0 0 {name=p134028 lab=clkbuf_8_60_0_CLK/X }
C {devices/lab_pin.sym} 135140 -28410 0 1 {name=p134029 lab=clkbuf_9_120_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 135100 -28410 0 0 {name=Xclkbuf_9_120_0_CLK }
C {devices/lab_pin.sym} 135020 -28320 0 0 {name=p134030 lab=_65438_/X }
C {devices/lab_pin.sym} 135020 -28280 0 0 {name=p134031 lab=_86204_/Q }
C {devices/lab_pin.sym} 135020 -28240 0 0 {name=p134032 lab=_65182_/X }
C {devices/lab_pin.sym} 135020 -28200 0 0 {name=p134033 lab=_65501_/X }
C {devices/lab_pin.sym} 135180 -28260 0 1 {name=p134034 lab=_65502_/X }
C {sky130_stdcells/a211o_4.sym} 135100 -28260 0 0 {name=X_65502_ }
C {devices/lab_pin.sym} 135060 -28110 0 0 {name=p134035 lab=_60362_/A }
C {devices/lab_pin.sym} 135140 -28110 0 1 {name=p134036 lab=_62727_/A }
C {sky130_stdcells/buf_2.sym} 135100 -28110 0 0 {name=X_62714_ }
C {devices/lab_pin.sym} 135020 -28010 0 0 {name=p134037 lab=_81400_/D }
C {devices/lab_pin.sym} 135020 -27970 0 0 {name=p134038 lab=_69230_/X }
C {devices/lab_pin.sym} 135020 -27930 0 0 {name=p134039 lab=_69269_/X }
C {devices/lab_pin.sym} 135180 -27970 0 1 {name=p134040 lab=_83936_/D }
C {sky130_stdcells/a21bo_4.sym} 135100 -27970 0 0 {name=X_69270_ }
C {devices/lab_pin.sym} 135060 -27830 0 0 {name=p134041 lab=_54859_/B }
C {devices/lab_pin.sym} 135140 -27830 0 1 {name=p134042 lab=_53167_/B }
C {sky130_stdcells/buf_2.sym} 135100 -27830 0 0 {name=X_47648_ }
C {devices/lab_pin.sym} 135020 -27730 0 0 {name=p134043 lab=_66475_/X }
C {devices/lab_pin.sym} 135020 -27690 0 0 {name=p134044 lab=_66244_/Y }
C {devices/lab_pin.sym} 135020 -27650 0 0 {name=p134045 lab=_66481_/Y }
C {devices/lab_pin.sym} 135180 -27690 0 1 {name=p134046 lab=_66482_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -27690 0 0 {name=X_66482_ }
C {devices/lab_pin.sym} 135040 -27560 0 0 {name=p134047 lab=_78475_/A }
C {devices/lab_pin.sym} 135040 -27520 0 0 {name=p134048 lab=_78467_/Y }
C {devices/lab_pin.sym} 135160 -27540 0 1 {name=p134049 lab=_82765_/D }
C {sky130_stdcells/xnor2_4.sym} 135100 -27540 0 0 {name=X_78468_ }
C {devices/lab_pin.sym} 135040 -27440 0 0 {name=p134050 lab=_63484_/A }
C {devices/lab_pin.sym} 135040 -27400 0 0 {name=p134051 lab=_63694_/B }
C {devices/lab_pin.sym} 135040 -27360 0 0 {name=p134052 lab=_63672_/C }
C {devices/lab_pin.sym} 135040 -27320 0 0 {name=p134053 lab=_60682_/A }
C {devices/lab_pin.sym} 135160 -27380 0 1 {name=p134054 lab=_63694_/X }
C {sky130_stdcells/and4_4.sym} 135100 -27380 0 0 {name=X_63694_ }
C {devices/lab_pin.sym} 135060 -27230 0 0 {name=p134055 lab=_68097_/A }
C {devices/lab_pin.sym} 135140 -27230 0 1 {name=p134056 lab=_68221_/X }
C {sky130_stdcells/buf_2.sym} 135100 -27230 0 0 {name=X_68221_ }
C {devices/lab_pin.sym} 135020 -27130 0 0 {name=p134057 lab=_65399_/X }
C {devices/lab_pin.sym} 135020 -27090 0 0 {name=p134058 lab=_65431_/Y }
C {devices/lab_pin.sym} 135020 -27050 0 0 {name=p134059 lab=_65432_/Y }
C {devices/lab_pin.sym} 135180 -27090 0 1 {name=p134060 lab=_65433_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -27090 0 0 {name=X_65433_ }
C {devices/lab_pin.sym} 135020 -26970 0 0 {name=p134061 lab=_77403_/B }
C {devices/lab_pin.sym} 135020 -26930 0 0 {name=p134062 lab=_77417_/X }
C {devices/lab_pin.sym} 135020 -26890 0 0 {name=p134063 lab=_77418_/X }
C {devices/lab_pin.sym} 135180 -26930 0 1 {name=p134064 lab=_77419_/Y }
C {sky130_stdcells/a21boi_4.sym} 135100 -26930 0 0 {name=X_77419_ }
C {devices/lab_pin.sym} 135060 -26790 0 0 {name=p134065 lab=_60271_/X }
C {devices/lab_pin.sym} 135140 -26790 0 1 {name=p134066 lab=_62646_/B }
C {sky130_stdcells/buf_2.sym} 135100 -26790 0 0 {name=X_62645_ }
C {devices/lab_pin.sym} 135040 -26700 0 0 {name=p134067 lab=_47595_/A }
C {devices/lab_pin.sym} 135040 -26660 0 0 {name=p134068 lab=_47595_/B }
C {devices/lab_pin.sym} 135040 -26620 0 0 {name=p134069 lab=_47595_/C }
C {devices/lab_pin.sym} 135040 -26580 0 0 {name=p134070 lab=_53129_/D }
C {devices/lab_pin.sym} 135160 -26640 0 1 {name=p134071 lab=_47579_/X }
C {sky130_stdcells/and4_4.sym} 135100 -26640 0 0 {name=X_47579_ }
C {devices/lab_pin.sym} 135060 -26490 0 0 {name=p134072 lab=clkbuf_9_322_0_CLK/X }
C {devices/lab_pin.sym} 135140 -26490 0 1 {name=p134073 lab=_86935_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 135100 -26490 0 0 {name=Xclkbuf_10_644_0_CLK }
C {devices/lab_pin.sym} 135020 -26390 0 0 {name=p134074 lab=_78397_/Y }
C {devices/lab_pin.sym} 135020 -26350 0 0 {name=p134075 lab=_78369_/B }
C {devices/lab_pin.sym} 135020 -26310 0 0 {name=p134076 lab=_78398_/X }
C {devices/lab_pin.sym} 135180 -26350 0 1 {name=p134077 lab=_78400_/B }
C {sky130_stdcells/o21ai_4.sym} 135100 -26350 0 0 {name=X_78399_ }
C {devices/lab_pin.sym} 135040 -26230 0 0 {name=p134078 lab=_52533_/A }
C {devices/lab_pin.sym} 135040 -26190 0 0 {name=p134079 lab=_49317_/X }
C {devices/lab_pin.sym} 135040 -26150 0 0 {name=p134080 lab=_49312_/C }
C {devices/lab_pin.sym} 135160 -26190 0 1 {name=p134081 lab=_49318_/X }
C {sky130_stdcells/and3_4.sym} 135100 -26190 0 0 {name=X_49318_ }
C {devices/lab_pin.sym} 135040 -26060 0 0 {name=p134082 lab=_80423_/A }
C {devices/lab_pin.sym} 135040 -26020 0 0 {name=p134083 lab=_80423_/B }
C {devices/lab_pin.sym} 135160 -26040 0 1 {name=p134084 lab=_80430_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -26040 0 0 {name=X_80430_ }
C {devices/lab_pin.sym} 135020 -25930 0 0 {name=p134085 lab=_66965_/X }
C {devices/lab_pin.sym} 135020 -25890 0 0 {name=p134086 lab=_66967_/X }
C {devices/lab_pin.sym} 135020 -25850 0 0 {name=p134087 lab=_68129_/X }
C {devices/lab_pin.sym} 135180 -25890 0 1 {name=p134088 lab=_68152_/Y }
C {sky130_stdcells/a21oi_4.sym} 135100 -25890 0 0 {name=X_68152_ }
C {devices/lab_pin.sym} 135040 -25760 0 0 {name=p134089 lab=_65285_/A }
C {devices/lab_pin.sym} 135040 -25720 0 0 {name=p134090 lab=_86020_/Q }
C {devices/lab_pin.sym} 135160 -25740 0 1 {name=p134091 lab=_65364_/X }
C {sky130_stdcells/and2_4.sym} 135100 -25740 0 0 {name=X_65364_ }
C {devices/lab_pin.sym} 135040 -25620 0 0 {name=p134092 lab=_50575_/A }
C {devices/lab_pin.sym} 135040 -25580 0 0 {name=p134093 lab=_48944_/B }
C {devices/lab_pin.sym} 135160 -25600 0 1 {name=p134094 lab=_50590_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -25600 0 0 {name=X_50590_ }
C {devices/lab_pin.sym} 135040 -25500 0 0 {name=p134095 lab=_62556_/A }
C {devices/lab_pin.sym} 135040 -25460 0 0 {name=p134096 lab=_61640_/A }
C {devices/lab_pin.sym} 135040 -25420 0 0 {name=p134097 lab=_62576_/C }
C {devices/lab_pin.sym} 135040 -25380 0 0 {name=p134098 lab=_62548_/D }
C {devices/lab_pin.sym} 135160 -25440 0 1 {name=p134099 lab=_62576_/X }
C {sky130_stdcells/and4_4.sym} 135100 -25440 0 0 {name=X_62576_ }
C {devices/lab_pin.sym} 135060 -25290 0 0 {name=p134100 lab=clkbuf_8_67_0_CLK/X }
C {devices/lab_pin.sym} 135140 -25290 0 1 {name=p134101 lab=clkbuf_9_135_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 135100 -25290 0 0 {name=Xclkbuf_9_135_0_CLK }
C {devices/lab_pin.sym} 135060 -25170 0 0 {name=p134102 lab=_66625_/A }
C {devices/lab_pin.sym} 135140 -25170 0 1 {name=p134103 lab=_67131_/A }
C {sky130_stdcells/buf_2.sym} 135100 -25170 0 0 {name=X_67103_ }
C {devices/lab_pin.sym} 135060 -25050 0 0 {name=p134104 lab=_64315_/A }
C {devices/lab_pin.sym} 135140 -25050 0 1 {name=p134105 lab=_64316_/B }
C {sky130_stdcells/buf_2.sym} 135100 -25050 0 0 {name=X_64315_ }
C {devices/lab_pin.sym} 135060 -24930 0 0 {name=p134106 lab=clkbuf_9_63_0_CLK/A }
C {devices/lab_pin.sym} 135140 -24930 0 1 {name=p134107 lab=clkbuf_9_62_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 135100 -24930 0 0 {name=Xclkbuf_9_62_0_CLK }
C {devices/lab_pin.sym} 135040 -24820 0 0 {name=p134108 lab=_49263_/A }
C {devices/lab_pin.sym} 135040 -24780 0 0 {name=p134109 lab=_53983_/B }
C {devices/lab_pin.sym} 135160 -24800 0 1 {name=p134110 lab=_49249_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -24800 0 0 {name=X_49249_ }
C {devices/lab_pin.sym} 135060 -24670 0 0 {name=p134111 lab=_61340_/A }
C {devices/lab_pin.sym} 135140 -24670 0 1 {name=p134112 lab=_61542_/C }
C {sky130_stdcells/buf_2.sym} 135100 -24670 0 0 {name=X_61527_ }
C {devices/lab_pin.sym} 135040 -24560 0 0 {name=p134113 lab=_80361_/A }
C {devices/lab_pin.sym} 135040 -24520 0 0 {name=p134114 lab=_80361_/B }
C {devices/lab_pin.sym} 135160 -24540 0 1 {name=p134115 lab=_80362_/A }
C {sky130_stdcells/and2_4.sym} 135100 -24540 0 0 {name=X_80361_ }
C {devices/lab_pin.sym} 135040 -24420 0 0 {name=p134116 lab=_68371_/A }
C {devices/lab_pin.sym} 135040 -24380 0 0 {name=p134117 lab=_88148_/Q }
C {devices/lab_pin.sym} 135160 -24400 0 1 {name=p134118 lab=_68083_/X }
C {sky130_stdcells/and2_4.sym} 135100 -24400 0 0 {name=X_68083_ }
C {devices/lab_pin.sym} 135020 -24290 0 0 {name=p134119 lab=_65292_/Y }
C {devices/lab_pin.sym} 135020 -24250 0 0 {name=p134120 lab=_65195_/X }
C {devices/lab_pin.sym} 135020 -24210 0 0 {name=p134121 lab=_65294_/X }
C {devices/lab_pin.sym} 135180 -24250 0 1 {name=p134122 lab=_84207_/D }
C {sky130_stdcells/a21o_4.sym} 135100 -24250 0 0 {name=X_65295_ }
C {devices/lab_pin.sym} 135010 -24110 0 0 {name=p134123 lab=_82349_/CLK }
C {devices/lab_pin.sym} 135010 -24090 0 0 {name=p134124 lab=_77488_/B }
C {devices/lab_pin.sym} 135190 -24110 0 1 {name=p134125 lab=_82100_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -24100 0 0 {name=X_82100_ }
C {devices/lab_pin.sym} 135020 -24000 0 0 {name=p134126 lab=_87936_/Q }
C {devices/lab_pin.sym} 135020 -23960 0 0 {name=p134127 lab=_66935_/X }
C {devices/lab_pin.sym} 135020 -23920 0 0 {name=p134128 lab=_67032_/X }
C {devices/lab_pin.sym} 135020 -23880 0 0 {name=p134129 lab=_67033_/X }
C {devices/lab_pin.sym} 135180 -23940 0 1 {name=p134130 lab=_67034_/X }
C {sky130_stdcells/a211o_4.sym} 135100 -23940 0 0 {name=X_67034_ }
C {devices/lab_pin.sym} 135020 -23810 0 0 {name=p134131 lab=_85857_/Q }
C {devices/lab_pin.sym} 135020 -23770 0 0 {name=p134132 lab=_52239_/X }
C {devices/lab_pin.sym} 135020 -23730 0 0 {name=p134133 lab=_52259_/Y }
C {devices/lab_pin.sym} 135180 -23770 0 1 {name=p134134 lab=_52260_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -23770 0 0 {name=X_52260_ }
C {devices/lab_pin.sym} 135040 -23650 0 0 {name=p134135 lab=_64223_/A }
C {devices/lab_pin.sym} 135040 -23610 0 0 {name=p134136 lab=_64246_/B }
C {devices/lab_pin.sym} 135040 -23570 0 0 {name=p134137 lab=_64223_/C }
C {devices/lab_pin.sym} 135160 -23610 0 1 {name=p134138 lab=_64246_/X }
C {sky130_stdcells/and3_4.sym} 135100 -23610 0 0 {name=X_64246_ }
C {devices/lab_pin.sym} 135010 -23470 0 0 {name=p134139 lab=_86525_/CLK }
C {devices/lab_pin.sym} 135010 -23450 0 0 {name=p134140 lab=_74372_/Y }
C {devices/lab_pin.sym} 135190 -23470 0 1 {name=p134141 lab=_83080_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -23460 0 0 {name=X_83080_ }
C {devices/lab_pin.sym} 135060 -23330 0 0 {name=p134142 lab=clkbuf_9_329_0_CLK/X }
C {devices/lab_pin.sym} 135140 -23330 0 1 {name=p134143 lab=_87421_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 135100 -23330 0 0 {name=Xclkbuf_10_659_0_CLK }
C {devices/lab_pin.sym} 135040 -23220 0 0 {name=p134144 lab=_80292_/A }
C {devices/lab_pin.sym} 135040 -23180 0 0 {name=p134145 lab=_80292_/B }
C {devices/lab_pin.sym} 135160 -23200 0 1 {name=p134146 lab=_80296_/A }
C {sky130_stdcells/nand2_4.sym} 135100 -23200 0 0 {name=X_80292_ }
C {devices/lab_pin.sym} 135060 -23070 0 0 {name=p134147 lab=_61302_/A }
C {devices/lab_pin.sym} 135140 -23070 0 1 {name=p134148 lab=_72561_/C }
C {sky130_stdcells/buf_2.sym} 135100 -23070 0 0 {name=X_61458_ }
C {devices/lab_pin.sym} 135060 -22950 0 0 {name=p134149 lab=_51211_/A }
C {devices/lab_pin.sym} 135140 -22950 0 1 {name=p134150 lab=_51212_/A }
C {sky130_stdcells/buf_2.sym} 135100 -22950 0 0 {name=X_51211_ }
C {devices/lab_pin.sym} 135010 -22830 0 0 {name=p134151 lab=_81985_/CLK }
C {devices/lab_pin.sym} 135010 -22810 0 0 {name=p134152 lab=_77850_/B }
C {devices/lab_pin.sym} 135190 -22830 0 1 {name=p134153 lab=_81999_/D }
C {sky130_stdcells/dfxtp_4.sym} 135100 -22820 0 0 {name=X_82031_ }
C {devices/lab_pin.sym} 135060 -22690 0 0 {name=p134154 lab=_60408_/X }
C {devices/lab_pin.sym} 135140 -22690 0 1 {name=p134155 lab=_60482_/A }
C {sky130_stdcells/buf_2.sym} 135100 -22690 0 0 {name=X_60409_ }
C {devices/lab_pin.sym} 135020 -22590 0 0 {name=p134156 lab=_85871_/Q }
C {devices/lab_pin.sym} 135020 -22550 0 0 {name=p134157 lab=_52178_/X }
C {devices/lab_pin.sym} 135020 -22510 0 0 {name=p134158 lab=_52190_/Y }
C {devices/lab_pin.sym} 135180 -22550 0 1 {name=p134159 lab=_52191_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -22550 0 0 {name=X_52191_ }
C {devices/lab_pin.sym} 135040 -22440 0 0 {name=p134160 lab=_61685_/A }
C {devices/lab_pin.sym} 135040 -22400 0 0 {name=p134161 lab=_64177_/B }
C {devices/lab_pin.sym} 135040 -22360 0 0 {name=p134162 lab=_64189_/D }
C {devices/lab_pin.sym} 135040 -22320 0 0 {name=p134163 lab=_64177_/D }
C {devices/lab_pin.sym} 135160 -22380 0 1 {name=p134164 lab=_64181_/A }
C {sky130_stdcells/nand4_4.sym} 135100 -22380 0 0 {name=X_64177_ }
C {devices/lab_pin.sym} 135060 -22230 0 0 {name=p134165 lab=_72550_/C }
C {devices/lab_pin.sym} 135140 -22230 0 1 {name=p134166 lab=_61390_/D }
C {sky130_stdcells/buf_2.sym} 135100 -22230 0 0 {name=X_61389_ }
C {devices/lab_pin.sym} 135060 -22110 0 0 {name=p134167 lab=clkbuf_8_38_0_CLK/X }
C {devices/lab_pin.sym} 135140 -22110 0 1 {name=p134168 lab=clkbuf_9_77_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 135100 -22110 0 0 {name=Xclkbuf_9_77_0_CLK }
C {devices/lab_pin.sym} 135040 -22020 0 0 {name=p134169 lab=_51160_/A }
C {devices/lab_pin.sym} 135040 -21980 0 0 {name=p134170 lab=_51121_/B }
C {devices/lab_pin.sym} 135040 -21940 0 0 {name=p134171 lab=_51141_/X }
C {devices/lab_pin.sym} 135040 -21900 0 0 {name=p134172 lab=_52835_/D }
C {devices/lab_pin.sym} 135160 -21960 0 1 {name=p134173 lab=_51142_/X }
C {sky130_stdcells/and4_4.sym} 135100 -21960 0 0 {name=X_51142_ }
C {devices/lab_pin.sym} 135020 -21830 0 0 {name=p134174 lab=_63126_/Y }
C {devices/lab_pin.sym} 135020 -21790 0 0 {name=p134175 lab=_63127_/X }
C {devices/lab_pin.sym} 135020 -21750 0 0 {name=p134176 lab=_63114_/X }
C {devices/lab_pin.sym} 135180 -21790 0 1 {name=p134177 lab=_63128_/Y }
C {sky130_stdcells/a21oi_4.sym} 135100 -21790 0 0 {name=X_63128_ }
C {devices/lab_pin.sym} 135020 -21680 0 0 {name=p134178 lab=_87078_/Q }
C {devices/lab_pin.sym} 135020 -21640 0 0 {name=p134179 lab=_68818_/X }
C {devices/lab_pin.sym} 135020 -21600 0 0 {name=p134180 lab=_68819_/X }
C {devices/lab_pin.sym} 135020 -21560 0 0 {name=p134181 lab=_68984_/X }
C {devices/lab_pin.sym} 135180 -21620 0 1 {name=p134182 lab=_68985_/X }
C {sky130_stdcells/a211o_4.sym} 135100 -21620 0 0 {name=X_68985_ }
C {devices/lab_pin.sym} 135060 -21470 0 0 {name=p134183 lab=_51101_/A }
C {devices/lab_pin.sym} 135140 -21470 0 1 {name=p134184 lab=_51073_/X }
C {sky130_stdcells/buf_2.sym} 135100 -21470 0 0 {name=X_51073_ }
C {devices/lab_pin.sym} 135040 -21360 0 0 {name=p134185 lab=_68028_/A }
C {devices/lab_pin.sym} 135040 -21320 0 0 {name=p134186 lab=_87706_/Q }
C {devices/lab_pin.sym} 135160 -21340 0 1 {name=p134187 lab=_67936_/X }
C {sky130_stdcells/and2_4.sym} 135100 -21340 0 0 {name=X_67936_ }
C {devices/lab_pin.sym} 135020 -21240 0 0 {name=p134188 lab=_85213_/Q }
C {devices/lab_pin.sym} 135020 -21200 0 0 {name=p134189 lab=_55641_/A }
C {devices/lab_pin.sym} 135020 -21160 0 0 {name=p134190 lab=_55610_/X }
C {devices/lab_pin.sym} 135020 -21120 0 0 {name=p134191 lab=_55949_/X }
C {devices/lab_pin.sym} 135180 -21180 0 1 {name=p134192 lab=_55950_/X }
C {sky130_stdcells/a211o_4.sym} 135100 -21180 0 0 {name=X_55950_ }
C {devices/lab_pin.sym} 135060 -21030 0 0 {name=p134193 lab=_60523_/A }
C {devices/lab_pin.sym} 135140 -21030 0 1 {name=p134194 lab=_63059_/X }
C {sky130_stdcells/buf_2.sym} 135100 -21030 0 0 {name=X_63059_ }
C {devices/lab_pin.sym} 135010 -20910 0 0 {name=p134195 lab=_86770_/CLK }
C {devices/lab_pin.sym} 135010 -20890 0 0 {name=p134196 lab=_46158_/Y }
C {devices/lab_pin.sym} 135190 -20910 0 1 {name=p134197 lab=_86770_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -20900 0 0 {name=X_86770_ }
C {devices/lab_pin.sym} 135010 -20770 0 0 {name=p134198 lab=_82629_/CLK }
C {devices/lab_pin.sym} 135010 -20750 0 0 {name=p134199 lab=_83982_/D }
C {devices/lab_pin.sym} 135190 -20770 0 1 {name=p134200 lab=_83982_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -20760 0 0 {name=X_83982_ }
C {devices/lab_pin.sym} 135020 -20650 0 0 {name=p134201 lab=_72427_/B }
C {devices/lab_pin.sym} 135020 -20610 0 0 {name=p134202 lab=_50012_/X }
C {devices/lab_pin.sym} 135020 -20570 0 0 {name=p134203 lab=_50023_/Y }
C {devices/lab_pin.sym} 135180 -20610 0 1 {name=p134204 lab=_50024_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -20610 0 0 {name=X_50024_ }
C {devices/lab_pin.sym} 135040 -20500 0 0 {name=p134205 lab=_54910_/A }
C {devices/lab_pin.sym} 135040 -20460 0 0 {name=p134206 lab=_54910_/B }
C {devices/lab_pin.sym} 135040 -20420 0 0 {name=p134207 lab=_54910_/C }
C {devices/lab_pin.sym} 135040 -20380 0 0 {name=p134208 lab=_53207_/D }
C {devices/lab_pin.sym} 135160 -20440 0 1 {name=p134209 lab=_54901_/X }
C {sky130_stdcells/and4_4.sym} 135100 -20440 0 0 {name=X_54901_ }
C {devices/lab_pin.sym} 135010 -20290 0 0 {name=p134210 lab=_84746_/CLK }
C {devices/lab_pin.sym} 135010 -20270 0 0 {name=p134211 lab=_52972_/Y }
C {devices/lab_pin.sym} 135190 -20290 0 1 {name=p134212 lab=_85721_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -20280 0 0 {name=X_85721_ }
C {devices/lab_pin.sym} 135010 -20150 0 0 {name=p134213 lab=_82933_/CLK }
C {devices/lab_pin.sym} 135010 -20130 0 0 {name=p134214 lab=_78270_/X }
C {devices/lab_pin.sym} 135190 -20150 0 1 {name=p134215 lab=_46389_/A }
C {sky130_stdcells/dfxtp_4.sym} 135100 -20140 0 0 {name=X_82933_ }
C {devices/lab_pin.sym} 135040 -20020 0 0 {name=p134216 lab=_55881_/A }
C {devices/lab_pin.sym} 135040 -19980 0 0 {name=p134217 lab=_55880_/X }
C {devices/lab_pin.sym} 135160 -20000 0 1 {name=p134218 lab=_55882_/A }
C {sky130_stdcells/and2_4.sym} 135100 -20000 0 0 {name=X_55881_ }
C {devices/lab_pin.sym} 135020 -19900 0 0 {name=p134219 lab=_87901_/Q }
C {devices/lab_pin.sym} 135020 -19860 0 0 {name=p134220 lab=_67770_/X }
C {devices/lab_pin.sym} 135020 -19820 0 0 {name=p134221 lab=_67865_/X }
C {devices/lab_pin.sym} 135020 -19780 0 0 {name=p134222 lab=_67866_/X }
C {devices/lab_pin.sym} 135180 -19840 0 1 {name=p134223 lab=_67867_/X }
C {sky130_stdcells/a211o_4.sym} 135100 -19840 0 0 {name=X_67867_ }
C {devices/lab_pin.sym} 135020 -19710 0 0 {name=p134224 lab=_57618_/Y }
C {devices/lab_pin.sym} 135020 -19670 0 0 {name=p134225 lab=_57592_/X }
C {devices/lab_pin.sym} 135020 -19630 0 0 {name=p134226 lab=_57619_/X }
C {devices/lab_pin.sym} 135180 -19670 0 1 {name=p134227 lab=_57620_/Y }
C {sky130_stdcells/a21oi_4.sym} 135100 -19670 0 0 {name=X_57620_ }
C {devices/lab_pin.sym} 135020 -19560 0 0 {name=p134228 lab=_87568_/Q }
C {devices/lab_pin.sym} 135020 -19520 0 0 {name=p134229 lab=_69368_/X }
C {devices/lab_pin.sym} 135020 -19480 0 0 {name=p134230 lab=_68552_/X }
C {devices/lab_pin.sym} 135020 -19440 0 0 {name=p134231 lab=_69605_/X }
C {devices/lab_pin.sym} 135180 -19500 0 1 {name=p134232 lab=_69606_/X }
C {sky130_stdcells/a211o_4.sym} 135100 -19500 0 0 {name=X_69606_ }
C {devices/lab_pin.sym} 135020 -19370 0 0 {name=p134233 lab=_54828_/Y }
C {devices/lab_pin.sym} 135020 -19330 0 0 {name=p134234 lab=_54830_/X }
C {devices/lab_pin.sym} 135020 -19290 0 0 {name=p134235 lab=_54831_/X }
C {devices/lab_pin.sym} 135180 -19330 0 1 {name=p134236 lab=_85370_/D }
C {sky130_stdcells/a21oi_4.sym} 135100 -19330 0 0 {name=X_54832_ }
C {devices/lab_pin.sym} 135020 -19220 0 0 {name=p134237 lab=_87945_/Q }
C {devices/lab_pin.sym} 135020 -19180 0 0 {name=p134238 lab=_66816_/X }
C {devices/lab_pin.sym} 135020 -19140 0 0 {name=p134239 lab=_66794_/X }
C {devices/lab_pin.sym} 135020 -19100 0 0 {name=p134240 lab=_66817_/X }
C {devices/lab_pin.sym} 135180 -19160 0 1 {name=p134241 lab=_66818_/X }
C {sky130_stdcells/a211o_4.sym} 135100 -19160 0 0 {name=X_66818_ }
C {devices/lab_pin.sym} 135010 -19010 0 0 {name=p134242 lab=_85651_/CLK }
C {devices/lab_pin.sym} 135010 -18990 0 0 {name=p134243 lab=_85652_/D }
C {devices/lab_pin.sym} 135190 -19010 0 1 {name=p134244 lab=_85652_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -19000 0 0 {name=X_85652_ }
C {devices/lab_pin.sym} 135010 -18870 0 0 {name=p134245 lab=_82859_/CLK }
C {devices/lab_pin.sym} 135010 -18850 0 0 {name=p134246 lab=_78174_/B }
C {devices/lab_pin.sym} 135190 -18870 0 1 {name=p134247 lab=_82864_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -18860 0 0 {name=X_82864_ }
C {devices/lab_pin.sym} 135060 -18730 0 0 {name=p134248 lab=_68389_/A }
C {devices/lab_pin.sym} 135140 -18730 0 1 {name=p134249 lab=_68429_/A }
C {sky130_stdcells/buf_2.sym} 135100 -18730 0 0 {name=X_67798_ }
C {devices/lab_pin.sym} 135010 -18610 0 0 {name=p134250 lab=_84603_/CLK }
C {devices/lab_pin.sym} 135010 -18590 0 0 {name=p134251 lab=_60544_/X }
C {devices/lab_pin.sym} 135190 -18610 0 1 {name=p134252 lab=_79143_/A }
C {sky130_stdcells/dfxtp_4.sym} 135100 -18600 0 0 {name=X_84603_ }
C {devices/lab_pin.sym} 135060 -18470 0 0 {name=p134253 lab=_46290_/A }
C {devices/lab_pin.sym} 135140 -18470 0 1 {name=p134254 lab=_72017_/A }
C {sky130_stdcells/buf_2.sym} 135100 -18470 0 0 {name=X_57551_ }
C {devices/lab_pin.sym} 135010 -18350 0 0 {name=p134255 lab=_81304_/CLK }
C {devices/lab_pin.sym} 135010 -18330 0 0 {name=p134256 lab=_81815_/D }
C {devices/lab_pin.sym} 135190 -18350 0 1 {name=p134257 lab=_81815_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -18340 0 0 {name=X_81815_ }
C {devices/lab_pin.sym} 135020 -18240 0 0 {name=p134258 lab=_87010_/Q }
C {devices/lab_pin.sym} 135020 -18200 0 0 {name=p134259 lab=_69414_/X }
C {devices/lab_pin.sym} 135020 -18160 0 0 {name=p134260 lab=_69430_/X }
C {devices/lab_pin.sym} 135020 -18120 0 0 {name=p134261 lab=_69536_/X }
C {devices/lab_pin.sym} 135180 -18180 0 1 {name=p134262 lab=_69537_/X }
C {sky130_stdcells/a211o_4.sym} 135100 -18180 0 0 {name=X_69537_ }
C {devices/lab_pin.sym} 135010 -18030 0 0 {name=p134263 lab=_87859_/CLK }
C {devices/lab_pin.sym} 135010 -18010 0 0 {name=p134264 lab=_88371_/D }
C {devices/lab_pin.sym} 135190 -18030 0 1 {name=p134265 lab=_88371_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -18020 0 0 {name=X_88371_ }
C {devices/lab_pin.sym} 135040 -17900 0 0 {name=p134266 lab=_54758_/X }
C {devices/lab_pin.sym} 135040 -17860 0 0 {name=p134267 lab=_47481_/A }
C {devices/lab_pin.sym} 135160 -17880 0 1 {name=p134268 lab=_54763_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -17880 0 0 {name=X_54763_ }
C {devices/lab_pin.sym} 135020 -17780 0 0 {name=p134269 lab=_87436_/Q }
C {devices/lab_pin.sym} 135020 -17740 0 0 {name=p134270 lab=_66678_/X }
C {devices/lab_pin.sym} 135020 -17700 0 0 {name=p134271 lab=_66747_/X }
C {devices/lab_pin.sym} 135020 -17660 0 0 {name=p134272 lab=_66748_/X }
C {devices/lab_pin.sym} 135180 -17720 0 1 {name=p134273 lab=_66749_/X }
C {sky130_stdcells/a211o_4.sym} 135100 -17720 0 0 {name=X_66749_ }
C {devices/lab_pin.sym} 135010 -17570 0 0 {name=p134274 lab=_86193_/CLK }
C {devices/lab_pin.sym} 135010 -17550 0 0 {name=p134275 lab=_53712_/Y }
C {devices/lab_pin.sym} 135190 -17570 0 1 {name=p134276 lab=_85583_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -17560 0 0 {name=X_85583_ }
C {devices/lab_pin.sym} 135040 -17440 0 0 {name=p134277 lab=_51961_/X }
C {devices/lab_pin.sym} 135040 -17400 0 0 {name=p134278 lab=_47924_/B }
C {devices/lab_pin.sym} 135160 -17420 0 1 {name=p134279 lab=_51975_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -17420 0 0 {name=X_51975_ }
C {devices/lab_pin.sym} 135010 -17290 0 0 {name=p134280 lab=_82797_/CLK }
C {devices/lab_pin.sym} 135010 -17270 0 0 {name=p134281 lab=_82827_/Q }
C {devices/lab_pin.sym} 135190 -17290 0 1 {name=p134282 lab=_78434_/B }
C {sky130_stdcells/dfxtp_4.sym} 135100 -17280 0 0 {name=X_82795_ }
C {devices/lab_pin.sym} 135060 -17150 0 0 {name=p134283 lab=clkbuf_8_7_0_CLK/X }
C {devices/lab_pin.sym} 135140 -17150 0 1 {name=p134284 lab=clkbuf_9_15_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 135100 -17150 0 0 {name=Xclkbuf_9_15_0_CLK }
C {devices/lab_pin.sym} 135020 -17050 0 0 {name=p134285 lab=_56074_/X }
C {devices/lab_pin.sym} 135020 -17010 0 0 {name=p134286 lab=_56499_/X }
C {devices/lab_pin.sym} 135020 -16970 0 0 {name=p134287 lab=_56501_/Y }
C {devices/lab_pin.sym} 135180 -17010 0 1 {name=p134288 lab=_56502_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -17010 0 0 {name=X_56502_ }
C {devices/lab_pin.sym} 135010 -16870 0 0 {name=p134289 lab=_87577_/CLK }
C {devices/lab_pin.sym} 135010 -16850 0 0 {name=p134290 lab=_87322_/D }
C {devices/lab_pin.sym} 135190 -16870 0 1 {name=p134291 lab=_74145_/A }
C {sky130_stdcells/dfxtp_4.sym} 135100 -16860 0 0 {name=X_87322_ }
C {devices/lab_pin.sym} 135020 -16750 0 0 {name=p134292 lab=_85582_/Q }
C {devices/lab_pin.sym} 135020 -16710 0 0 {name=p134293 lab=_53687_/X }
C {devices/lab_pin.sym} 135020 -16670 0 0 {name=p134294 lab=_53713_/Y }
C {devices/lab_pin.sym} 135180 -16710 0 1 {name=p134295 lab=_53714_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -16710 0 0 {name=X_53714_ }
C {devices/lab_pin.sym} 135010 -16570 0 0 {name=p134296 lab=_84534_/CLK }
C {devices/lab_pin.sym} 135010 -16550 0 0 {name=p134297 lab=_84534_/D }
C {devices/lab_pin.sym} 135190 -16570 0 1 {name=p134298 lab=_84534_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -16560 0 0 {name=X_84534_ }
C {devices/lab_pin.sym} 135040 -16440 0 0 {name=p134299 lab=_50932_/A }
C {devices/lab_pin.sym} 135040 -16400 0 0 {name=p134300 lab=_51791_/B }
C {devices/lab_pin.sym} 135160 -16420 0 1 {name=p134301 lab=_50926_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -16420 0 0 {name=X_50926_ }
C {devices/lab_pin.sym} 135040 -16310 0 0 {name=p134302 lab=_56910_/X }
C {devices/lab_pin.sym} 135040 -16270 0 0 {name=p134303 lab=_57400_/X }
C {devices/lab_pin.sym} 135040 -16230 0 0 {name=p134304 lab=_56915_/Y }
C {devices/lab_pin.sym} 135160 -16270 0 1 {name=p134305 lab=_57485_/A }
C {sky130_stdcells/nand3_4.sym} 135100 -16270 0 0 {name=X_57482_ }
C {devices/lab_pin.sym} 135060 -16130 0 0 {name=p134306 lab=_64713_/A }
C {devices/lab_pin.sym} 135140 -16130 0 1 {name=p134307 lab=_69468_/X }
C {sky130_stdcells/buf_2.sym} 135100 -16130 0 0 {name=X_69468_ }
C {devices/lab_pin.sym} 135010 -16010 0 0 {name=p134308 lab=_81746_/CLK }
C {devices/lab_pin.sym} 135010 -15990 0 0 {name=p134309 lab=_76040_/B }
C {devices/lab_pin.sym} 135190 -16010 0 1 {name=p134310 lab=_81746_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -16000 0 0 {name=X_81746_ }
C {devices/lab_pin.sym} 135060 -15870 0 0 {name=p134311 lab=_54693_/X }
C {devices/lab_pin.sym} 135140 -15870 0 1 {name=p134312 lab=_54694_/X }
C {sky130_stdcells/buf_2.sym} 135100 -15870 0 0 {name=X_54694_ }
C {devices/lab_pin.sym} 135020 -15770 0 0 {name=p134313 lab=_59219_/X }
C {devices/lab_pin.sym} 135020 -15730 0 0 {name=p134314 lab=_85743_/Q }
C {devices/lab_pin.sym} 135020 -15690 0 0 {name=p134315 lab=_59220_/X }
C {devices/lab_pin.sym} 135180 -15730 0 1 {name=p134316 lab=_59221_/X }
C {sky130_stdcells/o21a_4.sym} 135100 -15730 0 0 {name=X_59221_ }
C {devices/lab_pin.sym} 135040 -15610 0 0 {name=p134317 lab=_56431_/A }
C {devices/lab_pin.sym} 135040 -15570 0 0 {name=p134318 lab=_56433_/B }
C {devices/lab_pin.sym} 135040 -15530 0 0 {name=p134319 lab=_85195_/Q }
C {devices/lab_pin.sym} 135160 -15570 0 1 {name=p134320 lab=_56433_/Y }
C {sky130_stdcells/nand3_4.sym} 135100 -15570 0 0 {name=X_56433_ }
C {devices/lab_pin.sym} 135020 -15460 0 0 {name=p134321 lab=_73599_/A }
C {devices/lab_pin.sym} 135020 -15420 0 0 {name=p134322 lab=_68384_/X }
C {devices/lab_pin.sym} 135020 -15380 0 0 {name=p134323 lab=_68385_/X }
C {devices/lab_pin.sym} 135020 -15340 0 0 {name=p134324 lab=_68418_/Y }
C {devices/lab_pin.sym} 135180 -15400 0 1 {name=p134325 lab=_68419_/X }
C {sky130_stdcells/a211o_4.sym} 135100 -15400 0 0 {name=X_68419_ }
C {devices/lab_pin.sym} 135010 -15250 0 0 {name=p134326 lab=_87253_/CLK }
C {devices/lab_pin.sym} 135010 -15230 0 0 {name=p134327 lab=_87253_/D }
C {devices/lab_pin.sym} 135190 -15250 0 1 {name=p134328 lab=_69544_/B }
C {sky130_stdcells/dfxtp_4.sym} 135100 -15240 0 0 {name=X_87253_ }
C {devices/lab_pin.sym} 135040 -15120 0 0 {name=p134329 lab=_53778_/A }
C {devices/lab_pin.sym} 135040 -15080 0 0 {name=p134330 lab=_52123_/B }
C {devices/lab_pin.sym} 135160 -15100 0 1 {name=p134331 lab=_53645_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -15100 0 0 {name=X_53645_ }
C {devices/lab_pin.sym} 135010 -14970 0 0 {name=p134332 lab=_84469_/CLK }
C {devices/lab_pin.sym} 135010 -14950 0 0 {name=p134333 lab=_61625_/Y }
C {devices/lab_pin.sym} 135190 -14970 0 1 {name=p134334 lab=_79133_/B }
C {sky130_stdcells/dfxtp_4.sym} 135100 -14960 0 0 {name=X_84465_ }
C {devices/lab_pin.sym} 135060 -14830 0 0 {name=p134335 lab=_50505_/A }
C {devices/lab_pin.sym} 135140 -14830 0 1 {name=p134336 lab=_50857_/X }
C {sky130_stdcells/buf_2.sym} 135100 -14830 0 0 {name=X_50857_ }
C {devices/lab_pin.sym} 135010 -14710 0 0 {name=p134337 lab=_81260_/CLK }
C {devices/lab_pin.sym} 135010 -14690 0 0 {name=p134338 lab=_80045_/X }
C {devices/lab_pin.sym} 135190 -14710 0 1 {name=p134339 lab=_81677_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -14700 0 0 {name=X_81677_ }
C {devices/lab_pin.sym} 135060 -14570 0 0 {name=p134340 lab=_57716_/A }
C {devices/lab_pin.sym} 135140 -14570 0 1 {name=p134341 lab=_69399_/X }
C {sky130_stdcells/buf_2.sym} 135100 -14570 0 0 {name=X_69399_ }
C {devices/lab_pin.sym} 135010 -14450 0 0 {name=p134342 lab=_85884_/CLK }
C {devices/lab_pin.sym} 135010 -14430 0 0 {name=p134343 lab=_50422_/Y }
C {devices/lab_pin.sym} 135190 -14450 0 1 {name=p134344 lab=_86204_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -14440 0 0 {name=X_86204_ }
C {devices/lab_pin.sym} 135060 -14310 0 0 {name=p134345 lab=_40610_/A }
C {devices/lab_pin.sym} 135140 -14310 0 1 {name=p134346 lab=_40610_/X }
C {sky130_stdcells/buf_2.sym} 135100 -14310 0 0 {name=X_40610_ }
C {devices/lab_pin.sym} 135060 -14190 0 0 {name=p134347 lab=clkbuf_9_3_0_CLK/A }
C {devices/lab_pin.sym} 135140 -14190 0 1 {name=p134348 lab=clkbuf_9_3_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 135100 -14190 0 0 {name=Xclkbuf_9_3_0_CLK }
C {devices/lab_pin.sym} 135060 -14070 0 0 {name=p134349 lab=_58864_/A }
C {devices/lab_pin.sym} 135140 -14070 0 1 {name=p134350 lab=_59152_/X }
C {sky130_stdcells/buf_2.sym} 135100 -14070 0 0 {name=X_59152_ }
C {devices/lab_pin.sym} 135040 -13980 0 0 {name=p134351 lab=_71432_/A }
C {devices/lab_pin.sym} 135040 -13940 0 0 {name=p134352 lab=_71432_/B }
C {devices/lab_pin.sym} 135040 -13900 0 0 {name=p134353 lab=_70778_/A }
C {devices/lab_pin.sym} 135040 -13860 0 0 {name=p134354 lab=_71432_/D }
C {devices/lab_pin.sym} 135160 -13920 0 1 {name=p134355 lab=_71430_/X }
C {sky130_stdcells/and4_4.sym} 135100 -13920 0 0 {name=X_71430_ }
C {devices/lab_pin.sym} 135010 -13770 0 0 {name=p134356 lab=_83415_/CLK }
C {devices/lab_pin.sym} 135010 -13750 0 0 {name=p134357 lab=_83416_/D }
C {devices/lab_pin.sym} 135190 -13770 0 1 {name=p134358 lab=_83416_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -13760 0 0 {name=X_83416_ }
C {devices/lab_pin.sym} 135020 -13650 0 0 {name=p134359 lab=_56164_/X }
C {devices/lab_pin.sym} 135020 -13610 0 0 {name=p134360 lab=_56284_/X }
C {devices/lab_pin.sym} 135020 -13570 0 0 {name=p134361 lab=_56363_/Y }
C {devices/lab_pin.sym} 135180 -13610 0 1 {name=p134362 lab=_85220_/D }
C {sky130_stdcells/o21ai_4.sym} 135100 -13610 0 0 {name=X_56364_ }
C {devices/lab_pin.sym} 135020 -13490 0 0 {name=p134363 lab=_80613_/X }
C {devices/lab_pin.sym} 135020 -13450 0 0 {name=p134364 lab=_80614_/X }
C {devices/lab_pin.sym} 135020 -13410 0 0 {name=p134365 lab=_80627_/Y }
C {devices/lab_pin.sym} 135180 -13450 0 1 {name=p134366 lab=_80629_/B }
C {sky130_stdcells/a21boi_4.sym} 135100 -13450 0 0 {name=X_80628_ }
C {devices/lab_pin.sym} 135040 -13320 0 0 {name=p134367 lab=_40518_/B }
C {devices/lab_pin.sym} 135040 -13280 0 0 {name=p134368 lab=_41624_/B }
C {devices/lab_pin.sym} 135160 -13300 0 1 {name=p134369 lab=_41590_/X }
C {sky130_stdcells/or2_4.sym} 135100 -13300 0 0 {name=X_41590_ }
C {devices/lab_pin.sym} 135010 -13170 0 0 {name=p134370 lab=_83753_/CLK }
C {devices/lab_pin.sym} 135010 -13150 0 0 {name=p134371 lab=_87184_/D }
C {devices/lab_pin.sym} 135190 -13170 0 1 {name=p134372 lab=_43957_/B }
C {sky130_stdcells/dfxtp_4.sym} 135100 -13160 0 0 {name=X_87184_ }
C {devices/lab_pin.sym} 135020 -13050 0 0 {name=p134373 lab=_53573_/Y }
C {devices/lab_pin.sym} 135020 -13010 0 0 {name=p134374 lab=_53574_/X }
C {devices/lab_pin.sym} 135020 -12970 0 0 {name=p134375 lab=_53575_/Y }
C {devices/lab_pin.sym} 135180 -13010 0 1 {name=p134376 lab=_85610_/D }
C {sky130_stdcells/a21boi_4.sym} 135100 -13010 0 0 {name=X_53576_ }
C {devices/lab_pin.sym} 135010 -12870 0 0 {name=p134377 lab=_84396_/CLK }
C {devices/lab_pin.sym} 135010 -12850 0 0 {name=p134378 lab=_62617_/Y }
C {devices/lab_pin.sym} 135190 -12870 0 1 {name=p134379 lab=_62616_/C }
C {sky130_stdcells/dfxtp_4.sym} 135100 -12860 0 0 {name=X_84396_ }
C {devices/lab_pin.sym} 135040 -12740 0 0 {name=p134380 lab=_50787_/X }
C {devices/lab_pin.sym} 135040 -12700 0 0 {name=p134381 lab=_52482_/B }
C {devices/lab_pin.sym} 135160 -12720 0 1 {name=p134382 lab=_50788_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -12720 0 0 {name=X_50788_ }
C {devices/lab_pin.sym} 135020 -12610 0 0 {name=p134383 lab=_58065_/X }
C {devices/lab_pin.sym} 135020 -12570 0 0 {name=p134384 lab=_85701_/Q }
C {devices/lab_pin.sym} 135020 -12530 0 0 {name=p134385 lab=_58089_/X }
C {devices/lab_pin.sym} 135180 -12570 0 1 {name=p134386 lab=_58103_/X }
C {sky130_stdcells/o21a_4.sym} 135100 -12570 0 0 {name=X_58103_ }
C {devices/lab_pin.sym} 135020 -12460 0 0 {name=p134387 lab=_45681_/A }
C {devices/lab_pin.sym} 135020 -12420 0 0 {name=p134388 lab=_55311_/X }
C {devices/lab_pin.sym} 135020 -12380 0 0 {name=p134389 lab=_55312_/X }
C {devices/lab_pin.sym} 135020 -12340 0 0 {name=p134390 lab=_55314_/X }
C {devices/lab_pin.sym} 135180 -12400 0 1 {name=p134391 lab=_55315_/X }
C {sky130_stdcells/a211o_4.sym} 135100 -12400 0 0 {name=X_55315_ }
C {devices/lab_pin.sym} 135010 -12250 0 0 {name=p134392 lab=_85527_/CLK }
C {devices/lab_pin.sym} 135010 -12230 0 0 {name=p134393 lab=_50780_/Y }
C {devices/lab_pin.sym} 135190 -12250 0 1 {name=p134394 lab=_86135_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -12240 0 0 {name=X_86135_ }
C {devices/lab_pin.sym} 135020 -12130 0 0 {name=p134395 lab=_40463_/X }
C {devices/lab_pin.sym} 135020 -12090 0 0 {name=p134396 lab=_81155_/Q }
C {devices/lab_pin.sym} 135020 -12050 0 0 {name=p134397 lab=_40540_/X }
C {devices/lab_pin.sym} 135180 -12090 0 1 {name=p134398 lab=_40541_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -12090 0 0 {name=X_40541_ }
C {devices/lab_pin.sym} 135020 -11970 0 0 {name=p134399 lab=_65144_/B }
C {devices/lab_pin.sym} 135020 -11930 0 0 {name=p134400 lab=_52516_/X }
C {devices/lab_pin.sym} 135020 -11890 0 0 {name=p134401 lab=_52526_/Y }
C {devices/lab_pin.sym} 135180 -11930 0 1 {name=p134402 lab=_52527_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -11930 0 0 {name=X_52527_ }
C {devices/lab_pin.sym} 135020 -11810 0 0 {name=p134403 lab=_58858_/X }
C {devices/lab_pin.sym} 135020 -11770 0 0 {name=p134404 lab=_85434_/Q }
C {devices/lab_pin.sym} 135020 -11730 0 0 {name=p134405 lab=_59082_/X }
C {devices/lab_pin.sym} 135180 -11770 0 1 {name=p134406 lab=_59083_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -11770 0 0 {name=X_59083_ }
C {devices/lab_pin.sym} 135040 -11660 0 0 {name=p134407 lab=_71366_/A }
C {devices/lab_pin.sym} 135040 -11620 0 0 {name=p134408 lab=_71351_/X }
C {devices/lab_pin.sym} 135040 -11580 0 0 {name=p134409 lab=_70782_/A }
C {devices/lab_pin.sym} 135040 -11540 0 0 {name=p134410 lab=_71363_/D }
C {devices/lab_pin.sym} 135160 -11600 0 1 {name=p134411 lab=_71361_/X }
C {sky130_stdcells/and4_4.sym} 135100 -11600 0 0 {name=X_71361_ }
C {devices/lab_pin.sym} 135010 -11450 0 0 {name=p134412 lab=_83763_/CLK }
C {devices/lab_pin.sym} 135010 -11430 0 0 {name=p134413 lab=_83347_/D }
C {devices/lab_pin.sym} 135190 -11450 0 1 {name=p134414 lab=_83347_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -11440 0 0 {name=X_83347_ }
C {devices/lab_pin.sym} 135060 -11310 0 0 {name=p134415 lab=_56350_/A }
C {devices/lab_pin.sym} 135140 -11310 0 1 {name=p134416 lab=_56296_/A }
C {sky130_stdcells/buf_2.sym} 135100 -11310 0 0 {name=X_56295_ }
C {devices/lab_pin.sym} 135040 -11200 0 0 {name=p134417 lab=_80559_/A }
C {devices/lab_pin.sym} 135040 -11160 0 0 {name=p134418 lab=_80559_/B }
C {devices/lab_pin.sym} 135160 -11180 0 1 {name=p134419 lab=_80560_/B }
C {sky130_stdcells/xor2_4.sym} 135100 -11180 0 0 {name=X_80559_ }
C {devices/lab_pin.sym} 135020 -11070 0 0 {name=p134420 lab=_73101_/B }
C {devices/lab_pin.sym} 135020 -11030 0 0 {name=p134421 lab=_73101_/C }
C {devices/lab_pin.sym} 135020 -10990 0 0 {name=p134422 lab=_73099_/X }
C {devices/lab_pin.sym} 135180 -11030 0 1 {name=p134423 lab=_73100_/X }
C {sky130_stdcells/a21o_4.sym} 135100 -11030 0 0 {name=X_73100_ }
C {devices/lab_pin.sym} 135020 -10910 0 0 {name=p134424 lab=_57939_/X }
C {devices/lab_pin.sym} 135020 -10870 0 0 {name=p134425 lab=_85995_/Q }
C {devices/lab_pin.sym} 135020 -10830 0 0 {name=p134426 lab=_58033_/X }
C {devices/lab_pin.sym} 135180 -10870 0 1 {name=p134427 lab=_58034_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -10870 0 0 {name=X_58034_ }
C {devices/lab_pin.sym} 135060 -10730 0 0 {name=p134428 lab=_70249_/X }
C {devices/lab_pin.sym} 135140 -10730 0 1 {name=p134429 lab=_70328_/D }
C {sky130_stdcells/buf_2.sym} 135100 -10730 0 0 {name=X_70312_ }
C {devices/lab_pin.sym} 135060 -10610 0 0 {name=p134430 lab=_43162_/A }
C {devices/lab_pin.sym} 135140 -10610 0 1 {name=p134431 lab=_43260_/X }
C {sky130_stdcells/buf_2.sym} 135100 -10610 0 0 {name=X_43260_ }
C {devices/lab_pin.sym} 135040 -10500 0 0 {name=p134432 lab=_55276_/A }
C {devices/lab_pin.sym} 135040 -10460 0 0 {name=p134433 lab=_57199_/A }
C {devices/lab_pin.sym} 135160 -10480 0 1 {name=p134434 lab=_55246_/X }
C {sky130_stdcells/and2_4.sym} 135100 -10480 0 0 {name=X_55246_ }
C {devices/lab_pin.sym} 135010 -10350 0 0 {name=p134435 lab=_85748_/CLK }
C {devices/lab_pin.sym} 135010 -10330 0 0 {name=p134436 lab=_86066_/D }
C {devices/lab_pin.sym} 135190 -10350 0 1 {name=p134437 lab=_86066_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -10340 0 0 {name=X_86066_ }
C {devices/lab_pin.sym} 135060 -10210 0 0 {name=p134438 lab=_73378_/A }
C {devices/lab_pin.sym} 135140 -10210 0 1 {name=p134439 lab=_74080_/X }
C {sky130_stdcells/buf_2.sym} 135100 -10210 0 0 {name=X_74080_ }
C {devices/lab_pin.sym} 135040 -10100 0 0 {name=p134440 lab=_82320_/Q }
C {devices/lab_pin.sym} 135040 -10060 0 0 {name=p134441 lab=_40471_/X }
C {devices/lab_pin.sym} 135160 -10080 0 1 {name=p134442 lab=_40472_/X }
C {sky130_stdcells/or2_4.sym} 135100 -10080 0 0 {name=X_40472_ }
C {devices/lab_pin.sym} 135040 -9960 0 0 {name=p134443 lab=_52436_/A }
C {devices/lab_pin.sym} 135040 -9920 0 0 {name=p134444 lab=_53978_/B }
C {devices/lab_pin.sym} 135160 -9940 0 1 {name=p134445 lab=_52458_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -9940 0 0 {name=X_52458_ }
C {devices/lab_pin.sym} 135010 -9810 0 0 {name=p134446 lab=_83278_/CLK }
C {devices/lab_pin.sym} 135010 -9790 0 0 {name=p134447 lab=_83278_/D }
C {devices/lab_pin.sym} 135190 -9810 0 1 {name=p134448 lab=_83278_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -9800 0 0 {name=X_83278_ }
C {devices/lab_pin.sym} 135060 -9670 0 0 {name=p134449 lab=_71291_/Y }
C {devices/lab_pin.sym} 135140 -9670 0 1 {name=p134450 lab=_71308_/A }
C {sky130_stdcells/buf_2.sym} 135100 -9670 0 0 {name=X_71292_ }
C {devices/lab_pin.sym} 135020 -9580 0 0 {name=p134451 lab=_41328_/X }
C {devices/lab_pin.sym} 135020 -9540 0 0 {name=p134452 lab=_42209_/X }
C {devices/lab_pin.sym} 135020 -9500 0 0 {name=p134453 lab=_87979_/Q }
C {devices/lab_pin.sym} 135020 -9460 0 0 {name=p134454 lab=_42210_/X }
C {devices/lab_pin.sym} 135180 -9520 0 1 {name=p134455 lab=_42211_/X }
C {sky130_stdcells/a2bb2o_4.sym} 135100 -9520 0 0 {name=X_42211_ }
C {devices/lab_pin.sym} 135010 -9370 0 0 {name=p134456 lab=_85049_/CLK }
C {devices/lab_pin.sym} 135010 -9350 0 0 {name=p134457 lab=_85017_/D }
C {devices/lab_pin.sym} 135190 -9370 0 1 {name=p134458 lab=_57397_/B }
C {sky130_stdcells/dfxtp_4.sym} 135100 -9360 0 0 {name=X_85017_ }
C {devices/lab_pin.sym} 135060 -9230 0 0 {name=p134459 lab=_45896_/X }
C {devices/lab_pin.sym} 135140 -9230 0 1 {name=p134460 lab=_73031_/X }
C {sky130_stdcells/buf_2.sym} 135100 -9230 0 0 {name=X_73031_ }
C {devices/lab_pin.sym} 135020 -9130 0 0 {name=p134461 lab=_86015_/Q }
C {devices/lab_pin.sym} 135020 -9090 0 0 {name=p134462 lab=_51402_/X }
C {devices/lab_pin.sym} 135020 -9050 0 0 {name=p134463 lab=_51408_/Y }
C {devices/lab_pin.sym} 135180 -9090 0 1 {name=p134464 lab=_51409_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -9090 0 0 {name=X_51409_ }
C {devices/lab_pin.sym} 135040 -8980 0 0 {name=p134465 lab=_70239_/A }
C {devices/lab_pin.sym} 135040 -8940 0 0 {name=p134466 lab=_70239_/B }
C {devices/lab_pin.sym} 135040 -8900 0 0 {name=p134467 lab=_83184_/Q }
C {devices/lab_pin.sym} 135040 -8860 0 0 {name=p134468 lab=_70239_/D }
C {devices/lab_pin.sym} 135160 -8920 0 1 {name=p134469 lab=_70243_/X }
C {sky130_stdcells/and4_4.sym} 135100 -8920 0 0 {name=X_70243_ }
C {devices/lab_pin.sym} 135010 -8770 0 0 {name=p134470 lab=_81839_/CLK }
C {devices/lab_pin.sym} 135010 -8750 0 0 {name=p134471 lab=_82261_/Q }
C {devices/lab_pin.sym} 135190 -8770 0 1 {name=p134472 lab=_82229_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -8760 0 0 {name=X_82229_ }
C {devices/lab_pin.sym} 135020 -8670 0 0 {name=p134473 lab=_43047_/X }
C {devices/lab_pin.sym} 135020 -8630 0 0 {name=p134474 lab=_53944_/A }
C {devices/lab_pin.sym} 135020 -8590 0 0 {name=p134475 lab=_40899_/X }
C {devices/lab_pin.sym} 135020 -8550 0 0 {name=p134476 lab=_43190_/Y }
C {devices/lab_pin.sym} 135020 -8510 0 0 {name=p134477 lab=_43142_/X }
C {devices/lab_pin.sym} 135180 -8590 0 1 {name=p134478 lab=_87546_/D }
C {sky130_stdcells/o32ai_4.sym} 135100 -8590 0 0 {name=X_43191_ }
C {devices/lab_pin.sym} 135040 -8440 0 0 {name=p134479 lab=_55177_/A }
C {devices/lab_pin.sym} 135040 -8400 0 0 {name=p134480 lab=_55176_/Y }
C {devices/lab_pin.sym} 135160 -8420 0 1 {name=p134481 lab=_55177_/Y }
C {sky130_stdcells/nor2_4.sym} 135100 -8420 0 0 {name=X_55177_ }
C {devices/lab_pin.sym} 135060 -8290 0 0 {name=p134482 lab=_52618_/A }
C {devices/lab_pin.sym} 135140 -8290 0 1 {name=p134483 lab=_52496_/A }
C {sky130_stdcells/buf_2.sym} 135100 -8290 0 0 {name=X_52389_ }
C {devices/lab_pin.sym} 135060 -8170 0 0 {name=p134484 lab=_42096_/A }
C {devices/lab_pin.sym} 135140 -8170 0 1 {name=p134485 lab=_42142_/X }
C {sky130_stdcells/buf_2.sym} 135100 -8170 0 0 {name=X_42142_ }
C {devices/lab_pin.sym} 135040 -8080 0 0 {name=p134486 lab=_54127_/X }
C {devices/lab_pin.sym} 135040 -8040 0 0 {name=p134487 lab=_54123_/B }
C {devices/lab_pin.sym} 135040 -8000 0 0 {name=p134488 lab=_54118_/X }
C {devices/lab_pin.sym} 135040 -7960 0 0 {name=p134489 lab=_52963_/D }
C {devices/lab_pin.sym} 135160 -8020 0 1 {name=p134490 lab=_54128_/X }
C {sky130_stdcells/and4_4.sym} 135100 -8020 0 0 {name=X_54128_ }
C {devices/lab_pin.sym} 135060 -7870 0 0 {name=p134491 lab=_70134_/X }
C {devices/lab_pin.sym} 135140 -7870 0 1 {name=p134492 lab=_70233_/A }
C {sky130_stdcells/buf_2.sym} 135100 -7870 0 0 {name=X_70174_ }
C {devices/lab_pin.sym} 135060 -7750 0 0 {name=p134493 lab=_59985_/A }
C {devices/lab_pin.sym} 135140 -7750 0 1 {name=p134494 lab=_59985_/X }
C {sky130_stdcells/buf_2.sym} 135100 -7750 0 0 {name=X_59985_ }
C {devices/lab_pin.sym} 135060 -7630 0 0 {name=p134495 lab=_46903_/A }
C {devices/lab_pin.sym} 135140 -7630 0 1 {name=p134496 lab=_46981_/C }
C {sky130_stdcells/buf_2.sym} 135100 -7630 0 0 {name=X_46950_ }
C {devices/lab_pin.sym} 135060 -7510 0 0 {name=p134497 lab=_41912_/A }
C {devices/lab_pin.sym} 135140 -7510 0 1 {name=p134498 lab=_42073_/X }
C {sky130_stdcells/buf_2.sym} 135100 -7510 0 0 {name=X_42073_ }
C {devices/lab_pin.sym} 135020 -7410 0 0 {name=p134499 lab=_58858_/X }
C {devices/lab_pin.sym} 135020 -7370 0 0 {name=p134500 lab=_85444_/Q }
C {devices/lab_pin.sym} 135020 -7330 0 0 {name=p134501 lab=_58935_/X }
C {devices/lab_pin.sym} 135180 -7370 0 1 {name=p134502 lab=_58936_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -7370 0 0 {name=X_58936_ }
C {devices/lab_pin.sym} 135020 -7250 0 0 {name=p134503 lab=_85513_/Q }
C {devices/lab_pin.sym} 135020 -7210 0 0 {name=p134504 lab=_54018_/X }
C {devices/lab_pin.sym} 135020 -7170 0 0 {name=p134505 lab=_54058_/Y }
C {devices/lab_pin.sym} 135180 -7210 0 1 {name=p134506 lab=_54059_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -7210 0 0 {name=X_54059_ }
C {devices/lab_pin.sym} 135040 -7080 0 0 {name=p134507 lab=_77780_/B }
C {devices/lab_pin.sym} 135040 -7040 0 0 {name=p134508 lab=_81927_/D }
C {devices/lab_pin.sym} 135160 -7060 0 1 {name=p134509 lab=_77773_/A }
C {sky130_stdcells/xnor2_4.sym} 135100 -7060 0 0 {name=X_77770_ }
C {devices/lab_pin.sym} 135040 -6940 0 0 {name=p134510 lab=_81140_/D }
C {devices/lab_pin.sym} 135040 -6900 0 0 {name=p134511 lab=_74989_/C }
C {devices/lab_pin.sym} 135160 -6920 0 1 {name=p134512 lab=_74982_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -6920 0 0 {name=X_74982_ }
C {devices/lab_pin.sym} 135010 -6790 0 0 {name=p134513 lab=_87188_/CLK }
C {devices/lab_pin.sym} 135010 -6770 0 0 {name=p134514 lab=_44762_/Y }
C {devices/lab_pin.sym} 135190 -6790 0 1 {name=p134515 lab=_86968_/Q }
C {sky130_stdcells/dfxtp_4.sym} 135100 -6780 0 0 {name=X_86968_ }
C {devices/lab_pin.sym} 135020 -6680 0 0 {name=p134516 lab=_45884_/Y }
C {devices/lab_pin.sym} 135020 -6640 0 0 {name=p134517 lab=_45898_/X }
C {devices/lab_pin.sym} 135020 -6600 0 0 {name=p134518 lab=_46159_/A }
C {devices/lab_pin.sym} 135020 -6560 0 0 {name=p134519 lab=_45900_/Y }
C {devices/lab_pin.sym} 135180 -6620 0 1 {name=p134520 lab=_45901_/X }
C {sky130_stdcells/a211o_4.sym} 135100 -6620 0 0 {name=X_45901_ }
C {devices/lab_pin.sym} 135060 -6470 0 0 {name=p134521 lab=_40931_/A }
C {devices/lab_pin.sym} 135140 -6470 0 1 {name=p134522 lab=_41024_/X }
C {sky130_stdcells/buf_2.sym} 135100 -6470 0 0 {name=X_41024_ }
C {devices/lab_pin.sym} 135040 -6360 0 0 {name=p134523 lab=_76707_/X }
C {devices/lab_pin.sym} 135040 -6320 0 0 {name=p134524 lab=_76708_/A }
C {devices/lab_pin.sym} 135160 -6340 0 1 {name=p134525 lab=_76721_/X }
C {sky130_stdcells/and2_4.sym} 135100 -6340 0 0 {name=X_76721_ }
C {devices/lab_pin.sym} 135040 -6220 0 0 {name=p134526 lab=_73933_/A }
C {devices/lab_pin.sym} 135040 -6180 0 0 {name=p134527 lab=_73932_/X }
C {devices/lab_pin.sym} 135160 -6200 0 1 {name=p134528 lab=_73933_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -6200 0 0 {name=X_73933_ }
C {devices/lab_pin.sym} 135010 -6070 0 0 {name=p134529 lab=_85920_/CLK }
C {devices/lab_pin.sym} 135010 -6050 0 0 {name=p134530 lab=_51942_/Y }
C {devices/lab_pin.sym} 135190 -6070 0 1 {name=p134531 lab=_65932_/B }
C {sky130_stdcells/dfxtp_4.sym} 135100 -6060 0 0 {name=X_85919_ }
C {devices/lab_pin.sym} 135020 -5950 0 0 {name=p134532 lab=_58921_/A }
C {devices/lab_pin.sym} 135020 -5910 0 0 {name=p134533 lab=_46859_/X }
C {devices/lab_pin.sym} 135020 -5870 0 0 {name=p134534 lab=_46880_/Y }
C {devices/lab_pin.sym} 135180 -5910 0 1 {name=p134535 lab=_46881_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -5910 0 0 {name=X_46881_ }
C {devices/lab_pin.sym} 135040 -5780 0 0 {name=p134536 lab=_58867_/A }
C {devices/lab_pin.sym} 135040 -5740 0 0 {name=p134537 lab=_59090_/B }
C {devices/lab_pin.sym} 135160 -5760 0 1 {name=p134538 lab=_58867_/Y }
C {sky130_stdcells/nor2_4.sym} 135100 -5760 0 0 {name=X_58867_ }
C {devices/lab_pin.sym} 135010 -5630 0 0 {name=p134539 lab=_80664_/CLK }
C {devices/lab_pin.sym} 135010 -5610 0 0 {name=p134540 lab=_86899_/D }
C {devices/lab_pin.sym} 135190 -5630 0 1 {name=p134541 lab=_64353_/B }
C {sky130_stdcells/dfxtp_4.sym} 135100 -5620 0 0 {name=X_86899_ }
C {devices/lab_pin.sym} 135020 -5510 0 0 {name=p134542 lab=_48563_/X }
C {devices/lab_pin.sym} 135020 -5470 0 0 {name=p134543 lab=_48077_/A }
C {devices/lab_pin.sym} 135020 -5430 0 0 {name=p134544 lab=_48619_/Y }
C {devices/lab_pin.sym} 135180 -5470 0 1 {name=p134545 lab=_48621_/A }
C {sky130_stdcells/o21ai_4.sym} 135100 -5470 0 0 {name=X_48620_ }
C {devices/lab_pin.sym} 135020 -5360 0 0 {name=p134546 lab=_79416_/A }
C {devices/lab_pin.sym} 135020 -5320 0 0 {name=p134547 lab=_79416_/B }
C {devices/lab_pin.sym} 135020 -5280 0 0 {name=p134548 lab=_79429_/A }
C {devices/lab_pin.sym} 135020 -5240 0 0 {name=p134549 lab=_79428_/Y }
C {devices/lab_pin.sym} 135180 -5300 0 1 {name=p134550 lab=_79440_/X }
C {sky130_stdcells/o22a_4.sym} 135100 -5300 0 0 {name=X_79440_ }
C {devices/lab_pin.sym} 135020 -5180 0 0 {name=p134551 lab=_84948_/Q }
C {devices/lab_pin.sym} 135020 -5140 0 0 {name=p134552 lab=_57691_/X }
C {devices/lab_pin.sym} 135020 -5100 0 0 {name=p134553 lab=_57810_/X }
C {devices/lab_pin.sym} 135020 -5060 0 0 {name=p134554 lab=_57817_/X }
C {devices/lab_pin.sym} 135180 -5120 0 1 {name=p134555 lab=_84948_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 135100 -5120 0 0 {name=X_57818_ }
C {devices/lab_pin.sym} 135040 -4980 0 0 {name=p134556 lab=_45832_/A }
C {devices/lab_pin.sym} 135040 -4940 0 0 {name=p134557 lab=_45832_/B }
C {devices/lab_pin.sym} 135160 -4960 0 1 {name=p134558 lab=_45832_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -4960 0 0 {name=X_45832_ }
C {devices/lab_pin.sym} 135060 -4830 0 0 {name=p134559 lab=_81682_/Q }
C {devices/lab_pin.sym} 135140 -4830 0 1 {name=p134560 lab=_76652_/Y }
C {sky130_stdcells/inv_2.sym} 135100 -4830 0 0 {name=X_76652_ }
C {devices/lab_pin.sym} 135040 -4720 0 0 {name=p134561 lab=_73864_/A }
C {devices/lab_pin.sym} 135040 -4680 0 0 {name=p134562 lab=_73864_/B }
C {devices/lab_pin.sym} 135160 -4700 0 1 {name=p134563 lab=_73864_/X }
C {sky130_stdcells/xor2_4.sym} 135100 -4700 0 0 {name=X_73864_ }
C {devices/lab_pin.sym} 135020 -4590 0 0 {name=p134564 lab=_58796_/X }
C {devices/lab_pin.sym} 135020 -4550 0 0 {name=p134565 lab=_86095_/Q }
C {devices/lab_pin.sym} 135020 -4510 0 0 {name=p134566 lab=_58797_/X }
C {devices/lab_pin.sym} 135180 -4550 0 1 {name=p134567 lab=_58798_/Y }
C {sky130_stdcells/o21ai_4.sym} 135100 -4550 0 0 {name=X_58798_ }
C {devices/lab_pin.sym} 135040 -4420 0 0 {name=p134568 lab=_75600_/X }
C {devices/lab_pin.sym} 135040 -4380 0 0 {name=p134569 lab=_75602_/Y }
C {devices/lab_pin.sym} 135160 -4400 0 1 {name=p134570 lab=_75604_/B }
C {sky130_stdcells/xor2_4.sym} 135100 -4400 0 0 {name=X_75603_ }
C {devices/lab_pin.sym} 135060 -4270 0 0 {name=p134571 lab=_48550_/Y }
C {devices/lab_pin.sym} 135140 -4270 0 1 {name=p134572 lab=_48551_/X }
C {sky130_stdcells/buf_2.sym} 135100 -4270 0 0 {name=X_48551_ }
C {devices/lab_pin.sym} 135060 -4150 0 0 {name=p134573 lab=_73306_/A }
C {devices/lab_pin.sym} 135140 -4150 0 1 {name=p134574 lab=_73516_/A }
C {sky130_stdcells/buf_2.sym} 135100 -4150 0 0 {name=X_72815_ }
C {devices/lab_pin.sym} 135040 -4040 0 0 {name=p134575 lab=_84804_/Q }
C {devices/lab_pin.sym} 135040 -4000 0 0 {name=p134576 lab=_66433_/C }
C {devices/lab_pin.sym} 135160 -4020 0 1 {name=p134577 lab=_79373_/A }
C {sky130_stdcells/xor2_4.sym} 135100 -4020 0 0 {name=X_79371_ }
C {devices/lab_pin.sym} 135060 -3890 0 0 {name=p134578 lab=_62083_/D }
C {devices/lab_pin.sym} 135140 -3890 0 1 {name=p134579 lab=_61611_/A }
C {sky130_stdcells/buf_2.sym} 135100 -3890 0 0 {name=X_45763_ }
C {devices/lab_pin.sym} 135020 -3790 0 0 {name=p134580 lab=_57739_/X }
C {devices/lab_pin.sym} 135020 -3750 0 0 {name=p134581 lab=_85726_/Q }
C {devices/lab_pin.sym} 135020 -3710 0 0 {name=p134582 lab=_44252_/X }
C {devices/lab_pin.sym} 135180 -3750 0 1 {name=p134583 lab=_57749_/X }
C {sky130_stdcells/o21a_4.sym} 135100 -3750 0 0 {name=X_57749_ }
C {devices/lab_pin.sym} 135060 -3610 0 0 {name=p134584 lab=_76583_/A }
C {devices/lab_pin.sym} 135140 -3610 0 1 {name=p134585 lab=_76583_/Y }
C {sky130_stdcells/inv_2.sym} 135100 -3610 0 0 {name=X_76583_ }
C {devices/lab_pin.sym} 135060 -3490 0 0 {name=p134586 lab=_42975_/A }
C {devices/lab_pin.sym} 135140 -3490 0 1 {name=p134587 lab=_42975_/Y }
C {sky130_stdcells/inv_2.sym} 135100 -3490 0 0 {name=X_42975_ }
C {devices/lab_pin.sym} 135040 -3380 0 0 {name=p134588 lab=_73795_/A }
C {devices/lab_pin.sym} 135040 -3340 0 0 {name=p134589 lab=_73624_/X }
C {devices/lab_pin.sym} 135160 -3360 0 1 {name=p134590 lab=_73795_/Y }
C {sky130_stdcells/nor2_4.sym} 135100 -3360 0 0 {name=X_73795_ }
C {devices/lab_pin.sym} 135060 -3230 0 0 {name=p134591 lab=_47502_/A }
C {devices/lab_pin.sym} 135140 -3230 0 1 {name=p134592 lab=_53084_/D }
C {sky130_stdcells/buf_2.sym} 135100 -3230 0 0 {name=X_47502_ }
C {devices/lab_pin.sym} 135020 -3130 0 0 {name=p134593 lab=_78320_/Y }
C {devices/lab_pin.sym} 135020 -3090 0 0 {name=p134594 lab=_82786_/Q }
C {devices/lab_pin.sym} 135020 -3050 0 0 {name=p134595 lab=_78321_/Y }
C {devices/lab_pin.sym} 135180 -3090 0 1 {name=p134596 lab=_78324_/B }
C {sky130_stdcells/a21bo_4.sym} 135100 -3090 0 0 {name=X_78322_ }
C {devices/lab_pin.sym} 135060 -2950 0 0 {name=p134597 lab=_44714_/A }
C {devices/lab_pin.sym} 135140 -2950 0 1 {name=p134598 lab=_44714_/X }
C {sky130_stdcells/buf_2.sym} 135100 -2950 0 0 {name=X_44714_ }
C {devices/lab_pin.sym} 135060 -2830 0 0 {name=p134599 lab=_75533_/Y }
C {devices/lab_pin.sym} 135140 -2830 0 1 {name=p134600 lab=_75535_/B }
C {sky130_stdcells/inv_2.sym} 135100 -2830 0 0 {name=X_75534_ }
C {devices/lab_pin.sym} 135060 -2710 0 0 {name=p134601 lab=_41878_/A }
C {devices/lab_pin.sym} 135140 -2710 0 1 {name=p134602 lab=_42024_/A }
C {sky130_stdcells/buf_2.sym} 135100 -2710 0 0 {name=X_41926_ }
C {devices/lab_pin.sym} 135060 -2590 0 0 {name=p134603 lab=_60715_/X }
C {devices/lab_pin.sym} 135140 -2590 0 1 {name=p134604 lab=_60761_/B }
C {sky130_stdcells/buf_2.sym} 135100 -2590 0 0 {name=X_60760_ }
C {devices/lab_pin.sym} 135040 -2480 0 0 {name=p134605 lab=_48515_/A }
C {devices/lab_pin.sym} 135040 -2440 0 0 {name=p134606 lab=_48482_/B }
C {devices/lab_pin.sym} 135160 -2460 0 1 {name=p134607 lab=_48482_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -2460 0 0 {name=X_48482_ }
C {devices/lab_pin.sym} 135060 -2330 0 0 {name=p134608 lab=_73351_/A }
C {devices/lab_pin.sym} 135140 -2330 0 1 {name=p134609 lab=_72746_/X }
C {sky130_stdcells/buf_2.sym} 135100 -2330 0 0 {name=X_72746_ }
C {devices/lab_pin.sym} 135020 -2230 0 0 {name=p134610 lab=_45690_/X }
C {devices/lab_pin.sym} 135020 -2190 0 0 {name=p134611 lab=_45693_/Y }
C {devices/lab_pin.sym} 135020 -2150 0 0 {name=p134612 lab=_45678_/X }
C {devices/lab_pin.sym} 135180 -2190 0 1 {name=p134613 lab=_45694_/X }
C {sky130_stdcells/a21o_4.sym} 135100 -2190 0 0 {name=X_45694_ }
C {devices/lab_pin.sym} 135040 -2060 0 0 {name=p134614 lab=_47444_/A }
C {devices/lab_pin.sym} 135040 -2020 0 0 {name=p134615 lab=_53046_/B }
C {devices/lab_pin.sym} 135160 -2040 0 1 {name=p134616 lab=_47433_/Y }
C {sky130_stdcells/nand2_4.sym} 135100 -2040 0 0 {name=X_47433_ }
C {devices/lab_pin.sym} 135060 -1910 0 0 {name=p134617 lab=_59419_/A }
C {devices/lab_pin.sym} 135140 -1910 0 1 {name=p134618 lab=_59421_/A }
C {sky130_stdcells/buf_2.sym} 135100 -1910 0 0 {name=X_59419_ }
C {devices/lab_pin.sym} 135040 -1810 0 0 {name=p134619 lab=_78241_/X }
C {devices/lab_pin.sym} 135040 -1770 0 0 {name=p134620 lab=_78253_/B }
C {devices/lab_pin.sym} 135040 -1730 0 0 {name=p134621 lab=_82496_/Q }
C {devices/lab_pin.sym} 135160 -1770 0 1 {name=p134622 lab=_78254_/A }
C {sky130_stdcells/nand3_4.sym} 135100 -1770 0 0 {name=X_78253_ }
C {devices/lab_pin.sym} 135020 -1660 0 0 {name=p134623 lab=_41050_/A }
C {devices/lab_pin.sym} 135020 -1620 0 0 {name=p134624 lab=_44618_/X }
C {devices/lab_pin.sym} 135020 -1580 0 0 {name=p134625 lab=_87019_/Q }
C {devices/lab_pin.sym} 135020 -1540 0 0 {name=p134626 lab=_44619_/X }
C {devices/lab_pin.sym} 135180 -1600 0 1 {name=p134627 lab=_44645_/X }
C {sky130_stdcells/a2bb2o_4.sym} 135100 -1600 0 0 {name=X_44645_ }
C {devices/lab_pin.sym} 135060 -1450 0 0 {name=p134628 lab=_75506_/C }
C {devices/lab_pin.sym} 135140 -1450 0 1 {name=p134629 lab=_75465_/Y }
C {sky130_stdcells/inv_2.sym} 135100 -1450 0 0 {name=X_75465_ }
C {devices/lab_pin.sym} 135020 -1360 0 0 {name=p134630 lab=_40538_/X }
C {devices/lab_pin.sym} 135020 -1320 0 0 {name=p134631 lab=_41847_/X }
C {devices/lab_pin.sym} 135020 -1280 0 0 {name=p134632 lab=_88118_/Q }
C {devices/lab_pin.sym} 135020 -1240 0 0 {name=p134633 lab=_41848_/X }
C {devices/lab_pin.sym} 135180 -1300 0 1 {name=p134634 lab=_88118_/D }
C {sky130_stdcells/a2bb2o_4.sym} 135100 -1300 0 0 {name=X_41857_ }
C {devices/lab_pin.sym} 135060 -1150 0 0 {name=p134635 lab=_60690_/X }
C {devices/lab_pin.sym} 135140 -1150 0 1 {name=p134636 lab=_60727_/A }
C {sky130_stdcells/inv_2.sym} 135100 -1150 0 0 {name=X_60691_ }
C {devices/lab_pin.sym} 135040 -1050 0 0 {name=p134637 lab=_72683_/A }
C {devices/lab_pin.sym} 135040 -1010 0 0 {name=p134638 lab=_72683_/B }
C {devices/lab_pin.sym} 135040 -970 0 0 {name=p134639 lab=_55360_/X }
C {devices/lab_pin.sym} 135160 -1010 0 1 {name=p134640 lab=_72677_/Y }
C {sky130_stdcells/nand3_4.sym} 135100 -1010 0 0 {name=X_72677_ }
C {devices/lab_pin.sym} 135040 -890 0 0 {name=p134641 lab=_77202_/B }
C {devices/lab_pin.sym} 135040 -850 0 0 {name=p134642 lab=_82012_/Q }
C {devices/lab_pin.sym} 135040 -810 0 0 {name=p134643 lab=_82300_/D }
C {devices/lab_pin.sym} 135160 -850 0 1 {name=p134644 lab=_77204_/Y }
C {sky130_stdcells/nand3_4.sym} 135100 -850 0 0 {name=X_77204_ }
C {devices/lab_pin.sym} 135060 -710 0 0 {name=p134645 lab=_62501_/A }
C {devices/lab_pin.sym} 135140 -710 0 1 {name=p134646 lab=_62490_/C }
C {sky130_stdcells/buf_2.sym} 135100 -710 0 0 {name=X_62430_ }
C {devices/lab_pin.sym} 135960 -42170 0 0 {name=p134647 lab=_74416_/A }
C {devices/lab_pin.sym} 135960 -42130 0 0 {name=p134648 lab=_74395_/X }
C {devices/lab_pin.sym} 135960 -42090 0 0 {name=p134649 lab=_74421_/C }
C {devices/lab_pin.sym} 136080 -42130 0 1 {name=p134650 lab=_74416_/X }
C {sky130_stdcells/and3_4.sym} 136020 -42130 0 0 {name=X_74416_ }
C {devices/lab_pin.sym} 135960 -42000 0 0 {name=p134651 lab=_82872_/Q }
C {devices/lab_pin.sym} 135960 -41960 0 0 {name=p134652 lab=_40779_/B }
C {devices/lab_pin.sym} 136080 -41980 0 1 {name=p134653 lab=_40808_/X }
C {sky130_stdcells/or2_4.sym} 136020 -41980 0 0 {name=X_40808_ }
C {devices/lab_pin.sym} 135980 -41850 0 0 {name=p134654 lab=_47414_/A }
C {devices/lab_pin.sym} 136060 -41850 0 1 {name=p134655 lab=_47364_/X }
C {sky130_stdcells/buf_2.sym} 136020 -41850 0 0 {name=X_47364_ }
C {devices/lab_pin.sym} 135980 -41730 0 0 {name=p134656 lab=_71628_/A }
C {devices/lab_pin.sym} 136060 -41730 0 1 {name=p134657 lab=_71628_/X }
C {sky130_stdcells/buf_2.sym} 136020 -41730 0 0 {name=X_71628_ }
C {devices/lab_pin.sym} 135960 -41620 0 0 {name=p134658 lab=_78183_/A }
C {devices/lab_pin.sym} 135960 -41580 0 0 {name=p134659 lab=_82489_/Q }
C {devices/lab_pin.sym} 136080 -41600 0 1 {name=p134660 lab=_78191_/C }
C {sky130_stdcells/nand2_4.sym} 136020 -41600 0 0 {name=X_78184_ }
C {devices/lab_pin.sym} 135980 -41470 0 0 {name=p134661 lab=_44575_/Y }
C {devices/lab_pin.sym} 136060 -41470 0 1 {name=p134662 lab=_44576_/Y }
C {sky130_stdcells/inv_2.sym} 136020 -41470 0 0 {name=X_44576_ }
C {devices/lab_pin.sym} 135960 -41370 0 0 {name=p134663 lab=_75396_/A }
C {devices/lab_pin.sym} 135960 -41330 0 0 {name=p134664 lab=_75393_/Y }
C {devices/lab_pin.sym} 135960 -41290 0 0 {name=p134665 lab=_75396_/C }
C {devices/lab_pin.sym} 136080 -41330 0 1 {name=p134666 lab=_75401_/A }
C {sky130_stdcells/or3_4.sym} 136020 -41330 0 0 {name=X_75396_ }
C {devices/lab_pin.sym} 135980 -41190 0 0 {name=p134667 lab=_41788_/A }
C {devices/lab_pin.sym} 136060 -41190 0 1 {name=p134668 lab=_41788_/Y }
C {sky130_stdcells/inv_2.sym} 136020 -41190 0 0 {name=X_41788_ }
C {devices/lab_pin.sym} 135940 -41090 0 0 {name=p134669 lab=_49096_/Y }
C {devices/lab_pin.sym} 135940 -41050 0 0 {name=p134670 lab=_49086_/X }
C {devices/lab_pin.sym} 135940 -41010 0 0 {name=p134671 lab=_49102_/X }
C {devices/lab_pin.sym} 136100 -41050 0 1 {name=p134672 lab=_86444_/D }
C {sky130_stdcells/a21oi_4.sym} 136020 -41050 0 0 {name=X_49103_ }
C {devices/lab_pin.sym} 135960 -40920 0 0 {name=p134673 lab=_46421_/A }
C {devices/lab_pin.sym} 135960 -40880 0 0 {name=p134674 lab=_51261_/B }
C {devices/lab_pin.sym} 136080 -40900 0 1 {name=p134675 lab=_46315_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -40900 0 0 {name=X_46315_ }
C {devices/lab_pin.sym} 135960 -40780 0 0 {name=p134676 lab=_77141_/B }
C {devices/lab_pin.sym} 135960 -40740 0 0 {name=p134677 lab=_77141_/C }
C {devices/lab_pin.sym} 136080 -40760 0 1 {name=p134678 lab=_77135_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -40760 0 0 {name=X_77135_ }
C {devices/lab_pin.sym} 135940 -40660 0 0 {name=p134679 lab=_40391_/X }
C {devices/lab_pin.sym} 135940 -40620 0 0 {name=p134680 lab=_43513_/X }
C {devices/lab_pin.sym} 135940 -40580 0 0 {name=p134681 lab=_87375_/Q }
C {devices/lab_pin.sym} 135940 -40540 0 0 {name=p134682 lab=_43514_/X }
C {devices/lab_pin.sym} 136100 -40600 0 1 {name=p134683 lab=_87375_/D }
C {sky130_stdcells/a2bb2o_4.sym} 136020 -40600 0 0 {name=X_43527_ }
C {devices/lab_pin.sym} 135960 -40480 0 0 {name=p134684 lab=_61448_/X }
C {devices/lab_pin.sym} 135960 -40440 0 0 {name=p134685 lab=_62420_/B }
C {devices/lab_pin.sym} 135960 -40400 0 0 {name=p134686 lab=_62233_/C }
C {devices/lab_pin.sym} 135960 -40360 0 0 {name=p134687 lab=_62334_/D }
C {devices/lab_pin.sym} 136080 -40420 0 1 {name=p134688 lab=_62361_/Y }
C {sky130_stdcells/nand4_4.sym} 136020 -40420 0 0 {name=X_62361_ }
C {devices/lab_pin.sym} 135960 -40290 0 0 {name=p134689 lab=_74351_/A }
C {devices/lab_pin.sym} 135960 -40250 0 0 {name=p134690 lab=_74342_/X }
C {devices/lab_pin.sym} 135960 -40210 0 0 {name=p134691 lab=_55773_/D }
C {devices/lab_pin.sym} 136080 -40250 0 1 {name=p134692 lab=_74347_/Y }
C {sky130_stdcells/nand3_4.sym} 136020 -40250 0 0 {name=X_74347_ }
C {devices/lab_pin.sym} 135980 -40110 0 0 {name=p134693 lab=_40739_/A }
C {devices/lab_pin.sym} 136060 -40110 0 1 {name=p134694 lab=_40739_/X }
C {sky130_stdcells/buf_2.sym} 136020 -40110 0 0 {name=X_40739_ }
C {devices/lab_pin.sym} 135960 -40020 0 0 {name=p134695 lab=_47330_/A }
C {devices/lab_pin.sym} 135960 -39980 0 0 {name=p134696 lab=_47311_/B }
C {devices/lab_pin.sym} 135960 -39940 0 0 {name=p134697 lab=_47321_/C }
C {devices/lab_pin.sym} 135960 -39900 0 0 {name=p134698 lab=_52967_/D }
C {devices/lab_pin.sym} 136080 -39960 0 1 {name=p134699 lab=_47295_/X }
C {sky130_stdcells/and4_4.sym} 136020 -39960 0 0 {name=X_47295_ }
C {devices/lab_pin.sym} 135960 -39830 0 0 {name=p134700 lab=_70670_/A }
C {devices/lab_pin.sym} 135960 -39790 0 0 {name=p134701 lab=_71553_/B }
C {devices/lab_pin.sym} 135960 -39750 0 0 {name=p134702 lab=_71558_/X }
C {devices/lab_pin.sym} 136080 -39790 0 1 {name=p134703 lab=_71559_/Y }
C {sky130_stdcells/nor3_4.sym} 136020 -39790 0 0 {name=X_71559_ }
C {devices/lab_pin.sym} 135960 -39670 0 0 {name=p134704 lab=_64116_/A }
C {devices/lab_pin.sym} 135960 -39630 0 0 {name=p134705 lab=_64087_/X }
C {devices/lab_pin.sym} 135960 -39590 0 0 {name=p134706 lab=_64100_/C }
C {devices/lab_pin.sym} 136080 -39630 0 1 {name=p134707 lab=_64100_/Y }
C {sky130_stdcells/nor3_4.sym} 136020 -39630 0 0 {name=X_64100_ }
C {devices/lab_pin.sym} 135980 -39490 0 0 {name=p134708 lab=_83610_/Q }
C {devices/lab_pin.sym} 136060 -39490 0 1 {name=p134709 lab=_53856_/B }
C {sky130_stdcells/inv_2.sym} 136020 -39490 0 0 {name=X_49034_ }
C {devices/lab_pin.sym} 135980 -39370 0 0 {name=p134710 lab=_61312_/A }
C {devices/lab_pin.sym} 136060 -39370 0 1 {name=p134711 lab=_61313_/A }
C {sky130_stdcells/buf_2.sym} 136020 -39370 0 0 {name=X_61312_ }
C {devices/lab_pin.sym} 135940 -39270 0 0 {name=p134712 lab=_86753_/Q }
C {devices/lab_pin.sym} 135940 -39230 0 0 {name=p134713 lab=_44736_/X }
C {devices/lab_pin.sym} 135940 -39190 0 0 {name=p134714 lab=_46245_/X }
C {devices/lab_pin.sym} 136100 -39230 0 1 {name=p134715 lab=_46247_/A }
C {sky130_stdcells/o21ai_4.sym} 136020 -39230 0 0 {name=X_46246_ }
C {sky130_stdcells/decap_3.sym} 136020 -39060 0 0 {name=XPHY_580 }
C {devices/lab_pin.sym} 135940 -38940 0 0 {name=p134716 lab=_44150_/X }
C {devices/lab_pin.sym} 135940 -38900 0 0 {name=p134717 lab=_86735_/Q }
C {devices/lab_pin.sym} 135940 -38860 0 0 {name=p134718 lab=_64980_/X }
C {devices/lab_pin.sym} 135940 -38820 0 0 {name=p134719 lab=_65079_/X }
C {devices/lab_pin.sym} 136100 -38880 0 1 {name=p134720 lab=_65080_/X }
C {sky130_stdcells/a211o_4.sym} 136020 -38880 0 0 {name=X_65080_ }
C {devices/lab_pin.sym} 135960 -38740 0 0 {name=p134721 lab=_77066_/A }
C {devices/lab_pin.sym} 135960 -38700 0 0 {name=p134722 lab=_82284_/D }
C {devices/lab_pin.sym} 136080 -38720 0 1 {name=p134723 lab=_77073_/A }
C {sky130_stdcells/xor2_4.sym} 136020 -38720 0 0 {name=X_77066_ }
C {devices/lab_pin.sym} 135980 -38590 0 0 {name=p134724 lab=_43458_/A }
C {devices/lab_pin.sym} 136060 -38590 0 1 {name=p134725 lab=_43458_/Y }
C {sky130_stdcells/inv_2.sym} 136020 -38590 0 0 {name=X_43458_ }
C {devices/lab_pin.sym} 135980 -38470 0 0 {name=p134726 lab=_60084_/A }
C {devices/lab_pin.sym} 136060 -38470 0 1 {name=p134727 lab=_62631_/D }
C {sky130_stdcells/buf_2.sym} 136020 -38470 0 0 {name=X_62292_ }
C {devices/lab_pin.sym} 135960 -38360 0 0 {name=p134728 lab=_74278_/A }
C {devices/lab_pin.sym} 135960 -38320 0 0 {name=p134729 lab=_74278_/B }
C {devices/lab_pin.sym} 136080 -38340 0 1 {name=p134730 lab=_74278_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -38340 0 0 {name=X_74278_ }
C {sky130_stdcells/decap_3.sym} 136020 -38180 0 0 {name=XPHY_591 }
C {devices/lab_pin.sym} 135960 -38060 0 0 {name=p134731 lab=_64025_/Y }
C {devices/lab_pin.sym} 135960 -38020 0 0 {name=p134732 lab=_64027_/Y }
C {devices/lab_pin.sym} 135960 -37980 0 0 {name=p134733 lab=_64029_/Y }
C {devices/lab_pin.sym} 135960 -37940 0 0 {name=p134734 lab=_64030_/Y }
C {devices/lab_pin.sym} 136080 -38000 0 1 {name=p134735 lab=_64031_/X }
C {sky130_stdcells/and4_4.sym} 136020 -38000 0 0 {name=X_64031_ }
C {devices/lab_pin.sym} 135960 -37860 0 0 {name=p134736 lab=_81712_/D }
C {devices/lab_pin.sym} 135960 -37820 0 0 {name=p134737 lab=_76036_/C }
C {devices/lab_pin.sym} 136080 -37840 0 1 {name=p134738 lab=_76024_/A }
C {sky130_stdcells/xor2_4.sym} 136020 -37840 0 0 {name=X_76017_ }
C {devices/lab_pin.sym} 135980 -37710 0 0 {name=p134739 lab=_42408_/Y }
C {devices/lab_pin.sym} 136060 -37710 0 1 {name=p134740 lab=_87877_/D }
C {sky130_stdcells/inv_2.sym} 136020 -37710 0 0 {name=X_42409_ }
C {devices/lab_pin.sym} 135940 -37610 0 0 {name=p134741 lab=_61097_/X }
C {devices/lab_pin.sym} 135940 -37570 0 0 {name=p134742 lab=_64456_/C }
C {devices/lab_pin.sym} 135940 -37530 0 0 {name=p134743 lab=_61117_/X }
C {devices/lab_pin.sym} 136100 -37570 0 1 {name=p134744 lab=_61243_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -37570 0 0 {name=X_61243_ }
C {devices/lab_pin.sym} 135940 -37460 0 0 {name=p134745 lab=_69808_/B }
C {devices/lab_pin.sym} 135940 -37420 0 0 {name=p134746 lab=_57377_/X }
C {devices/lab_pin.sym} 135940 -37380 0 0 {name=p134747 lab=_73055_/X }
C {devices/lab_pin.sym} 135940 -37340 0 0 {name=p134748 lab=_73228_/Y }
C {devices/lab_pin.sym} 136100 -37400 0 1 {name=p134749 lab=_73229_/X }
C {sky130_stdcells/a211o_4.sym} 136020 -37400 0 0 {name=X_73229_ }
C {devices/lab_pin.sym} 135980 -37250 0 0 {name=p134750 lab=_66517_/B }
C {devices/lab_pin.sym} 136060 -37250 0 1 {name=p134751 lab=_72527_/A }
C {sky130_stdcells/buf_2.sym} 136020 -37250 0 0 {name=X_46177_ }
C {devices/lab_pin.sym} 135940 -37160 0 0 {name=p134752 lab=_41437_/X }
C {devices/lab_pin.sym} 135940 -37120 0 0 {name=p134753 lab=_43386_/X }
C {devices/lab_pin.sym} 135940 -37080 0 0 {name=p134754 lab=_87447_/Q }
C {devices/lab_pin.sym} 135940 -37040 0 0 {name=p134755 lab=_43388_/X }
C {devices/lab_pin.sym} 136100 -37100 0 1 {name=p134756 lab=_43389_/X }
C {sky130_stdcells/a2bb2o_4.sym} 136020 -37100 0 0 {name=X_43389_ }
C {devices/lab_pin.sym} 135980 -36950 0 0 {name=p134757 lab=_64378_/B }
C {devices/lab_pin.sym} 136060 -36950 0 1 {name=p134758 lab=_61499_/B }
C {sky130_stdcells/buf_2.sym} 136020 -36950 0 0 {name=X_45128_ }
C {devices/lab_pin.sym} 135960 -36850 0 0 {name=p134759 lab=_61165_/A }
C {devices/lab_pin.sym} 135960 -36810 0 0 {name=p134760 lab=_61165_/B }
C {devices/lab_pin.sym} 135960 -36770 0 0 {name=p134761 lab=_61174_/C }
C {devices/lab_pin.sym} 136080 -36810 0 1 {name=p134762 lab=_61174_/Y }
C {sky130_stdcells/nor3_4.sym} 136020 -36810 0 0 {name=X_61174_ }
C {devices/lab_pin.sym} 135960 -36690 0 0 {name=p134763 lab=_60125_/A }
C {devices/lab_pin.sym} 135960 -36650 0 0 {name=p134764 lab=_60214_/B }
C {devices/lab_pin.sym} 135960 -36610 0 0 {name=p134765 lab=_84658_/Q }
C {devices/lab_pin.sym} 136080 -36650 0 1 {name=p134766 lab=_60125_/Y }
C {sky130_stdcells/nor3_4.sym} 136020 -36650 0 0 {name=X_60125_ }
C {devices/lab_pin.sym} 135960 -36520 0 0 {name=p134767 lab=_49955_/A }
C {devices/lab_pin.sym} 135960 -36480 0 0 {name=p134768 lab=_53148_/B }
C {devices/lab_pin.sym} 136080 -36500 0 1 {name=p134769 lab=_49936_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -36500 0 0 {name=X_49936_ }
C {devices/lab_pin.sym} 135980 -36370 0 0 {name=p134770 lab=_80670_/Q }
C {devices/lab_pin.sym} 136060 -36370 0 1 {name=p134771 lab=_45284_/A }
C {sky130_stdcells/buf_2.sym} 136020 -36370 0 0 {name=X_45059_ }
C {devices/lab_pin.sym} 135980 -36250 0 0 {name=p134772 lab=_69178_/A }
C {devices/lab_pin.sym} 136060 -36250 0 1 {name=p134773 lab=_68770_/X }
C {sky130_stdcells/buf_2.sym} 136020 -36250 0 0 {name=X_68770_ }
C {devices/lab_pin.sym} 135940 -36160 0 0 {name=p134774 lab=_65824_/X }
C {devices/lab_pin.sym} 135940 -36120 0 0 {name=p134775 lab=_84988_/Q }
C {devices/lab_pin.sym} 135940 -36080 0 0 {name=p134776 lab=_65707_/X }
C {devices/lab_pin.sym} 135940 -36040 0 0 {name=p134777 lab=_65981_/X }
C {devices/lab_pin.sym} 136100 -36100 0 1 {name=p134778 lab=_65982_/X }
C {sky130_stdcells/a211o_4.sym} 136020 -36100 0 0 {name=X_65982_ }
C {devices/lab_pin.sym} 135960 -35960 0 0 {name=p134779 lab=_77980_/A }
C {devices/lab_pin.sym} 135960 -35920 0 0 {name=p134780 lab=_77967_/Y }
C {devices/lab_pin.sym} 136080 -35940 0 1 {name=p134781 lab=_77968_/X }
C {sky130_stdcells/and2_4.sym} 136020 -35940 0 0 {name=X_77968_ }
C {devices/lab_pin.sym} 135940 -35830 0 0 {name=p134782 lab=_67715_/X }
C {devices/lab_pin.sym} 135940 -35790 0 0 {name=p134783 lab=_67720_/X }
C {devices/lab_pin.sym} 135940 -35750 0 0 {name=p134784 lab=_67619_/X }
C {devices/lab_pin.sym} 136100 -35790 0 1 {name=p134785 lab=_67726_/A }
C {sky130_stdcells/a21o_4.sym} 136020 -35790 0 0 {name=X_67721_ }
C {devices/lab_pin.sym} 135940 -35670 0 0 {name=p134786 lab=_79694_/X }
C {devices/lab_pin.sym} 135940 -35630 0 0 {name=p134787 lab=_79705_/X }
C {devices/lab_pin.sym} 135940 -35590 0 0 {name=p134788 lab=_79706_/X }
C {devices/lab_pin.sym} 136100 -35630 0 1 {name=p134789 lab=_79707_/Y }
C {sky130_stdcells/a21oi_4.sym} 136020 -35630 0 0 {name=X_79707_ }
C {devices/lab_pin.sym} 135940 -35510 0 0 {name=p134790 lab=_64930_/X }
C {devices/lab_pin.sym} 135940 -35470 0 0 {name=p134791 lab=_64932_/X }
C {devices/lab_pin.sym} 135940 -35430 0 0 {name=p134792 lab=_64807_/X }
C {devices/lab_pin.sym} 136100 -35470 0 1 {name=p134793 lab=_64933_/X }
C {sky130_stdcells/a21o_4.sym} 136020 -35470 0 0 {name=X_64933_ }
C {devices/lab_pin.sym} 135980 -35330 0 0 {name=p134794 lab=_60056_/A }
C {devices/lab_pin.sym} 136060 -35330 0 1 {name=p134795 lab=_60059_/B }
C {sky130_stdcells/inv_2.sym} 136020 -35330 0 0 {name=X_60056_ }
C {devices/lab_pin.sym} 135980 -35210 0 0 {name=p134796 lab=_76931_/B }
C {devices/lab_pin.sym} 136060 -35210 0 1 {name=p134797 lab=_76919_/Y }
C {sky130_stdcells/inv_2.sym} 136020 -35210 0 0 {name=X_76919_ }
C {devices/lab_pin.sym} 135940 -35110 0 0 {name=p134798 lab=_49865_/Y }
C {devices/lab_pin.sym} 135940 -35070 0 0 {name=p134799 lab=_49844_/X }
C {devices/lab_pin.sym} 135940 -35030 0 0 {name=p134800 lab=_49866_/X }
C {devices/lab_pin.sym} 136100 -35070 0 1 {name=p134801 lab=_49867_/Y }
C {sky130_stdcells/a21oi_4.sym} 136020 -35070 0 0 {name=X_49867_ }
C {devices/lab_pin.sym} 135980 -34930 0 0 {name=p134802 lab=_82069_/Q }
C {devices/lab_pin.sym} 136060 -34930 0 1 {name=p134803 lab=_77899_/Y }
C {sky130_stdcells/inv_2.sym} 136020 -34930 0 0 {name=X_77899_ }
C {devices/lab_pin.sym} 135960 -34830 0 0 {name=p134804 lab=_52204_/A }
C {devices/lab_pin.sym} 135960 -34790 0 0 {name=p134805 lab=_48829_/B }
C {devices/lab_pin.sym} 135960 -34750 0 0 {name=p134806 lab=_48814_/C }
C {devices/lab_pin.sym} 136080 -34790 0 1 {name=p134807 lab=_48818_/X }
C {sky130_stdcells/and3_4.sym} 136020 -34790 0 0 {name=X_48818_ }
C {devices/lab_pin.sym} 135960 -34660 0 0 {name=p134808 lab=_79636_/X }
C {devices/lab_pin.sym} 135960 -34620 0 0 {name=p134809 lab=_79646_/B }
C {devices/lab_pin.sym} 136080 -34640 0 1 {name=p134810 lab=_79638_/Y }
C {sky130_stdcells/xnor2_4.sym} 136020 -34640 0 0 {name=X_79638_ }
C {devices/lab_pin.sym} 135960 -34520 0 0 {name=p134811 lab=_67675_/A }
C {devices/lab_pin.sym} 135960 -34480 0 0 {name=p134812 lab=_67652_/B }
C {devices/lab_pin.sym} 136080 -34500 0 1 {name=p134813 lab=_67652_/X }
C {sky130_stdcells/and2_4.sym} 136020 -34500 0 0 {name=X_67652_ }
C {devices/lab_pin.sym} 135980 -34370 0 0 {name=p134814 lab=_64991_/A }
C {devices/lab_pin.sym} 136060 -34370 0 1 {name=p134815 lab=_64864_/X }
C {sky130_stdcells/buf_2.sym} 136020 -34370 0 0 {name=X_64864_ }
C {devices/lab_pin.sym} 135980 -34250 0 0 {name=p134816 lab=_49825_/A }
C {devices/lab_pin.sym} 136060 -34250 0 1 {name=p134817 lab=_49798_/X }
C {sky130_stdcells/buf_2.sym} 136020 -34250 0 0 {name=X_49798_ }
C {devices/lab_pin.sym} 135940 -34160 0 0 {name=p134818 lab=_87378_/Q }
C {devices/lab_pin.sym} 135940 -34120 0 0 {name=p134819 lab=_66571_/X }
C {devices/lab_pin.sym} 135940 -34080 0 0 {name=p134820 lab=_66574_/X }
C {devices/lab_pin.sym} 135940 -34040 0 0 {name=p134821 lab=_66602_/X }
C {devices/lab_pin.sym} 136100 -34100 0 1 {name=p134822 lab=_66603_/X }
C {sky130_stdcells/a211o_4.sym} 136020 -34100 0 0 {name=X_66603_ }
C {devices/lab_pin.sym} 135960 -33970 0 0 {name=p134823 lab=_63765_/A }
C {devices/lab_pin.sym} 135960 -33930 0 0 {name=p134824 lab=_64257_/A }
C {devices/lab_pin.sym} 135960 -33890 0 0 {name=p134825 lab=_63765_/C }
C {devices/lab_pin.sym} 136080 -33930 0 1 {name=p134826 lab=_63815_/X }
C {sky130_stdcells/and3_4.sym} 136020 -33930 0 0 {name=X_63815_ }
C {devices/lab_pin.sym} 135940 -33810 0 0 {name=p134827 lab=_48747_/Y }
C {devices/lab_pin.sym} 135940 -33770 0 0 {name=p134828 lab=_48734_/X }
C {devices/lab_pin.sym} 135940 -33730 0 0 {name=p134829 lab=_48748_/X }
C {devices/lab_pin.sym} 136100 -33770 0 1 {name=p134830 lab=_48749_/Y }
C {sky130_stdcells/a21oi_4.sym} 136020 -33770 0 0 {name=X_48749_ }
C {devices/lab_pin.sym} 135940 -33660 0 0 {name=p134831 lab=_87465_/Q }
C {devices/lab_pin.sym} 135940 -33620 0 0 {name=p134832 lab=_67512_/X }
C {devices/lab_pin.sym} 135940 -33580 0 0 {name=p134833 lab=_67581_/X }
C {devices/lab_pin.sym} 135940 -33540 0 0 {name=p134834 lab=_67582_/X }
C {devices/lab_pin.sym} 136100 -33600 0 1 {name=p134835 lab=_67583_/X }
C {sky130_stdcells/a211o_4.sym} 136020 -33600 0 0 {name=X_67583_ }
C {devices/lab_pin.sym} 135960 -33460 0 0 {name=p134836 lab=_79569_/A }
C {devices/lab_pin.sym} 135960 -33420 0 0 {name=p134837 lab=_79569_/B }
C {devices/lab_pin.sym} 136080 -33440 0 1 {name=p134838 lab=_79569_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -33440 0 0 {name=X_79569_ }
C {devices/lab_pin.sym} 135940 -33340 0 0 {name=p134839 lab=_64615_/X }
C {devices/lab_pin.sym} 135940 -33300 0 0 {name=p134840 lab=_85530_/Q }
C {devices/lab_pin.sym} 135940 -33260 0 0 {name=p134841 lab=_64642_/X }
C {devices/lab_pin.sym} 135940 -33220 0 0 {name=p134842 lab=_64794_/X }
C {devices/lab_pin.sym} 136100 -33280 0 1 {name=p134843 lab=_64795_/X }
C {sky130_stdcells/a211o_4.sym} 136020 -33280 0 0 {name=X_64795_ }
C {devices/lab_pin.sym} 135930 -33130 0 0 {name=p134844 lab=_81473_/CLK }
C {devices/lab_pin.sym} 135930 -33110 0 0 {name=p134845 lab=_65449_/C }
C {devices/lab_pin.sym} 136110 -33130 0 1 {name=p134846 lab=_76942_/B }
C {sky130_stdcells/dfxtp_4.sym} 136020 -33120 0 0 {name=X_81600_ }
C {devices/lab_pin.sym} 135960 -33000 0 0 {name=p134847 lab=_69322_/A }
C {devices/lab_pin.sym} 135960 -32960 0 0 {name=p134848 lab=_88294_/Q }
C {devices/lab_pin.sym} 136080 -32980 0 1 {name=p134849 lab=_69322_/X }
C {sky130_stdcells/and2_4.sym} 136020 -32980 0 0 {name=X_69322_ }
C {devices/lab_pin.sym} 135980 -32850 0 0 {name=p134850 lab=_66534_/A }
C {devices/lab_pin.sym} 136060 -32850 0 1 {name=p134851 lab=_69633_/A }
C {sky130_stdcells/buf_2.sym} 136020 -32850 0 0 {name=X_66534_ }
C {devices/lab_pin.sym} 135980 -32730 0 0 {name=p134852 lab=_51814_/A }
C {devices/lab_pin.sym} 136060 -32730 0 1 {name=p134853 lab=_51782_/B }
C {sky130_stdcells/buf_2.sym} 136020 -32730 0 0 {name=X_51760_ }
C {devices/lab_pin.sym} 135940 -32630 0 0 {name=p134854 lab=_63743_/X }
C {devices/lab_pin.sym} 135940 -32590 0 0 {name=p134855 lab=_63744_/X }
C {devices/lab_pin.sym} 135940 -32550 0 0 {name=p134856 lab=_63745_/Y }
C {devices/lab_pin.sym} 136100 -32590 0 1 {name=p134857 lab=_84297_/D }
C {sky130_stdcells/a21oi_4.sym} 136020 -32590 0 0 {name=X_63746_ }
C {devices/lab_pin.sym} 135930 -32450 0 0 {name=p134858 lab=_82580_/CLK }
C {devices/lab_pin.sym} 135930 -32430 0 0 {name=p134859 lab=_82612_/Q }
C {devices/lab_pin.sym} 136110 -32450 0 1 {name=p134860 lab=_78203_/A }
C {sky130_stdcells/dfxtp_4.sym} 136020 -32440 0 0 {name=X_82580_ }
C {devices/lab_pin.sym} 135940 -32330 0 0 {name=p134861 lab=_60953_/X }
C {devices/lab_pin.sym} 135940 -32290 0 0 {name=p134862 lab=_60954_/X }
C {devices/lab_pin.sym} 135940 -32250 0 0 {name=p134863 lab=_60957_/Y }
C {devices/lab_pin.sym} 136100 -32290 0 1 {name=p134864 lab=_60958_/X }
C {sky130_stdcells/a21o_4.sym} 136020 -32290 0 0 {name=X_60958_ }
C {devices/lab_pin.sym} 135980 -32150 0 0 {name=p134865 lab=clkbuf_9_291_0_CLK/X }
C {devices/lab_pin.sym} 136060 -32150 0 1 {name=p134866 lab=_80931_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 136020 -32150 0 0 {name=Xclkbuf_10_583_0_CLK }
C {devices/lab_pin.sym} 135940 -32050 0 0 {name=p134867 lab=_50709_/Y }
C {devices/lab_pin.sym} 135940 -32010 0 0 {name=p134868 lab=_50699_/X }
C {devices/lab_pin.sym} 135940 -31970 0 0 {name=p134869 lab=_50710_/Y }
C {devices/lab_pin.sym} 136100 -32010 0 1 {name=p134870 lab=_86149_/D }
C {sky130_stdcells/a21boi_4.sym} 136020 -32010 0 0 {name=X_50711_ }
C {devices/lab_pin.sym} 135930 -31870 0 0 {name=p134871 lab=_81703_/CLK }
C {devices/lab_pin.sym} 135930 -31850 0 0 {name=p134872 lab=_76522_/B }
C {devices/lab_pin.sym} 136110 -31870 0 1 {name=p134873 lab=_81531_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -31860 0 0 {name=X_81531_ }
C {devices/lab_pin.sym} 135960 -31740 0 0 {name=p134874 lab=_69253_/A }
C {devices/lab_pin.sym} 135960 -31700 0 0 {name=p134875 lab=_88299_/Q }
C {devices/lab_pin.sym} 136080 -31720 0 1 {name=p134876 lab=_69253_/X }
C {sky130_stdcells/and2_4.sym} 136020 -31720 0 0 {name=X_69253_ }
C {devices/lab_pin.sym} 135940 -31610 0 0 {name=p134877 lab=_66463_/Y }
C {devices/lab_pin.sym} 135940 -31570 0 0 {name=p134878 lab=_66449_/X }
C {devices/lab_pin.sym} 135940 -31530 0 0 {name=p134879 lab=_66464_/X }
C {devices/lab_pin.sym} 136100 -31570 0 1 {name=p134880 lab=_84118_/D }
C {sky130_stdcells/a21o_4.sym} 136020 -31570 0 0 {name=X_66465_ }
C {devices/lab_pin.sym} 135960 -31440 0 0 {name=p134881 lab=_51697_/A }
C {devices/lab_pin.sym} 135960 -31400 0 0 {name=p134882 lab=_53213_/B }
C {devices/lab_pin.sym} 136080 -31420 0 1 {name=p134883 lab=_51691_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -31420 0 0 {name=X_51691_ }
C {devices/lab_pin.sym} 135960 -31320 0 0 {name=p134884 lab=_61656_/A }
C {devices/lab_pin.sym} 135960 -31280 0 0 {name=p134885 lab=_63600_/X }
C {devices/lab_pin.sym} 135960 -31240 0 0 {name=p134886 lab=_63661_/C }
C {devices/lab_pin.sym} 135960 -31200 0 0 {name=p134887 lab=_63661_/D }
C {devices/lab_pin.sym} 136080 -31260 0 1 {name=p134888 lab=_63677_/Y }
C {sky130_stdcells/nand4_4.sym} 136020 -31260 0 0 {name=X_63677_ }
C {devices/lab_pin.sym} 135980 -31110 0 0 {name=p134889 lab=_60879_/D }
C {devices/lab_pin.sym} 136060 -31110 0 1 {name=p134890 lab=_60889_/X }
C {sky130_stdcells/buf_2.sym} 136020 -31110 0 0 {name=X_60889_ }
C {devices/lab_pin.sym} 135940 -31010 0 0 {name=p134891 lab=_67277_/X }
C {devices/lab_pin.sym} 135940 -30970 0 0 {name=p134892 lab=_67280_/X }
C {devices/lab_pin.sym} 135940 -30930 0 0 {name=p134893 lab=_68173_/X }
C {devices/lab_pin.sym} 136100 -30970 0 1 {name=p134894 lab=_68204_/Y }
C {sky130_stdcells/a21oi_4.sym} 136020 -30970 0 0 {name=X_68204_ }
C {devices/lab_pin.sym} 135940 -30850 0 0 {name=p134895 lab=_53427_/Y }
C {devices/lab_pin.sym} 135940 -30810 0 0 {name=p134896 lab=_53408_/X }
C {devices/lab_pin.sym} 135940 -30770 0 0 {name=p134897 lab=_53429_/X }
C {devices/lab_pin.sym} 136100 -30810 0 1 {name=p134898 lab=_85635_/D }
C {sky130_stdcells/a21oi_4.sym} 136020 -30810 0 0 {name=X_53430_ }
C {devices/lab_pin.sym} 135980 -30670 0 0 {name=p134899 lab=_65782_/A }
C {devices/lab_pin.sym} 136060 -30670 0 1 {name=p134900 lab=_65416_/X }
C {sky130_stdcells/buf_2.sym} 136020 -30670 0 0 {name=X_65416_ }
C {devices/lab_pin.sym} 135930 -30550 0 0 {name=p134901 lab=_84250_/CLK }
C {devices/lab_pin.sym} 135930 -30530 0 0 {name=p134902 lab=_64398_/X }
C {devices/lab_pin.sym} 136110 -30550 0 1 {name=p134903 lab=_79722_/B }
C {sky130_stdcells/dfxtp_4.sym} 136020 -30540 0 0 {name=X_84250_ }
C {devices/lab_pin.sym} 135960 -30420 0 0 {name=p134904 lab=_50627_/X }
C {devices/lab_pin.sym} 135960 -30380 0 0 {name=p134905 lab=_50133_/B }
C {devices/lab_pin.sym} 136080 -30400 0 1 {name=p134906 lab=_50642_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -30400 0 0 {name=X_50642_ }
C {devices/lab_pin.sym} 135960 -30300 0 0 {name=p134907 lab=_62269_/X }
C {devices/lab_pin.sym} 135960 -30260 0 0 {name=p134908 lab=_84906_/Q }
C {devices/lab_pin.sym} 135960 -30220 0 0 {name=p134909 lab=_62628_/C }
C {devices/lab_pin.sym} 135960 -30180 0 0 {name=p134910 lab=_62219_/X }
C {devices/lab_pin.sym} 136080 -30240 0 1 {name=p134911 lab=_62628_/X }
C {sky130_stdcells/and4_4.sym} 136020 -30240 0 0 {name=X_62628_ }
C {devices/lab_pin.sym} 135930 -30090 0 0 {name=p134912 lab=_81482_/CLK }
C {devices/lab_pin.sym} 135930 -30070 0 0 {name=p134913 lab=_76838_/B }
C {devices/lab_pin.sym} 136110 -30090 0 1 {name=p134914 lab=_81462_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -30080 0 0 {name=X_81462_ }
C {devices/lab_pin.sym} 135960 -29960 0 0 {name=p134915 lab=_69027_/A }
C {devices/lab_pin.sym} 135960 -29920 0 0 {name=p134916 lab=_88304_/Q }
C {devices/lab_pin.sym} 136080 -29940 0 1 {name=p134917 lab=_69184_/X }
C {sky130_stdcells/and2_4.sym} 136020 -29940 0 0 {name=X_69184_ }
C {devices/lab_pin.sym} 135940 -29830 0 0 {name=p134918 lab=_66393_/Y }
C {devices/lab_pin.sym} 135940 -29790 0 0 {name=p134919 lab=_66377_/X }
C {devices/lab_pin.sym} 135940 -29750 0 0 {name=p134920 lab=_66395_/Y }
C {devices/lab_pin.sym} 136100 -29790 0 1 {name=p134921 lab=_84131_/D }
C {sky130_stdcells/a21o_4.sym} 136020 -29790 0 0 {name=X_66396_ }
C {devices/lab_pin.sym} 135930 -29650 0 0 {name=p134922 lab=_83835_/CLK }
C {devices/lab_pin.sym} 135930 -29630 0 0 {name=p134923 lab=_83201_/D }
C {devices/lab_pin.sym} 136110 -29650 0 1 {name=p134924 lab=_83201_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -29640 0 0 {name=X_83201_ }
C {devices/lab_pin.sym} 135960 -29520 0 0 {name=p134925 lab=_80413_/A }
C {devices/lab_pin.sym} 135960 -29480 0 0 {name=p134926 lab=_80413_/B }
C {devices/lab_pin.sym} 136080 -29500 0 1 {name=p134927 lab=_80413_/X }
C {sky130_stdcells/xor2_4.sym} 136020 -29500 0 0 {name=X_80413_ }
C {devices/lab_pin.sym} 135940 -29400 0 0 {name=p134928 lab=_68121_/X }
C {devices/lab_pin.sym} 135940 -29360 0 0 {name=p134929 lab=_66837_/Y }
C {devices/lab_pin.sym} 135940 -29320 0 0 {name=p134930 lab=_68128_/X }
C {devices/lab_pin.sym} 135940 -29280 0 0 {name=p134931 lab=_68134_/Y }
C {devices/lab_pin.sym} 136100 -29340 0 1 {name=p134932 lab=_68135_/X }
C {sky130_stdcells/a211o_4.sym} 136020 -29340 0 0 {name=X_68135_ }
C {devices/lab_pin.sym} 135940 -29210 0 0 {name=p134933 lab=_85648_/Q }
C {devices/lab_pin.sym} 135940 -29170 0 0 {name=p134934 lab=_53351_/X }
C {devices/lab_pin.sym} 135940 -29130 0 0 {name=p134935 lab=_53360_/Y }
C {devices/lab_pin.sym} 136100 -29170 0 1 {name=p134936 lab=_53361_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -29170 0 0 {name=X_53361_ }
C {devices/lab_pin.sym} 135980 -29030 0 0 {name=p134937 lab=_65529_/A }
C {devices/lab_pin.sym} 136060 -29030 0 1 {name=p134938 lab=_65347_/X }
C {sky130_stdcells/buf_2.sym} 136020 -29030 0 0 {name=X_65347_ }
C {devices/lab_pin.sym} 135930 -28910 0 0 {name=p134939 lab=_83508_/CLK }
C {devices/lab_pin.sym} 135930 -28890 0 0 {name=p134940 lab=_65746_/X }
C {devices/lab_pin.sym} 136110 -28910 0 1 {name=p134941 lab=_84181_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -28900 0 0 {name=X_84181_ }
C {devices/lab_pin.sym} 135960 -28780 0 0 {name=p134942 lab=_50580_/A }
C {devices/lab_pin.sym} 135960 -28740 0 0 {name=p134943 lab=_71970_/B }
C {devices/lab_pin.sym} 136080 -28760 0 1 {name=p134944 lab=_50573_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -28760 0 0 {name=X_50573_ }
C {devices/lab_pin.sym} 135930 -28630 0 0 {name=p134945 lab=_81351_/CLK }
C {devices/lab_pin.sym} 135930 -28610 0 0 {name=p134946 lab=_81393_/D }
C {devices/lab_pin.sym} 136110 -28630 0 1 {name=p134947 lab=_76949_/B }
C {sky130_stdcells/dfxtp_4.sym} 136020 -28620 0 0 {name=X_81393_ }
C {devices/lab_pin.sym} 135940 -28520 0 0 {name=p134948 lab=_60056_/A }
C {devices/lab_pin.sym} 135940 -28480 0 0 {name=p134949 lab=_62097_/X }
C {devices/lab_pin.sym} 135940 -28440 0 0 {name=p134950 lab=_59936_/X }
C {devices/lab_pin.sym} 135940 -28400 0 0 {name=p134951 lab=_58184_/A }
C {devices/lab_pin.sym} 136100 -28460 0 1 {name=p134952 lab=_62559_/Y }
C {sky130_stdcells/a22oi_4.sym} 136020 -28460 0 0 {name=X_62559_ }
C {devices/lab_pin.sym} 135980 -28310 0 0 {name=p134953 lab=clkbuf_9_299_0_CLK/X }
C {devices/lab_pin.sym} 136060 -28310 0 1 {name=p134954 lab=_83906_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 136020 -28310 0 0 {name=Xclkbuf_10_598_0_CLK }
C {devices/lab_pin.sym} 135960 -28200 0 0 {name=p134955 lab=_55118_/A }
C {devices/lab_pin.sym} 135960 -28160 0 0 {name=p134956 lab=_47780_/A }
C {devices/lab_pin.sym} 136080 -28180 0 1 {name=p134957 lab=_55100_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -28180 0 0 {name=X_55100_ }
C {devices/lab_pin.sym} 135960 -28060 0 0 {name=p134958 lab=_52299_/A }
C {devices/lab_pin.sym} 135960 -28020 0 0 {name=p134959 lab=_48982_/X }
C {devices/lab_pin.sym} 136080 -28040 0 1 {name=p134960 lab=_52312_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -28040 0 0 {name=X_52312_ }
C {devices/lab_pin.sym} 135930 -27910 0 0 {name=p134961 lab=_83133_/CLK }
C {devices/lab_pin.sym} 135930 -27890 0 0 {name=p134962 lab=_83132_/D }
C {devices/lab_pin.sym} 136110 -27910 0 1 {name=p134963 lab=_83132_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -27900 0 0 {name=X_83132_ }
C {devices/lab_pin.sym} 135960 -27790 0 0 {name=p134964 lab=_56100_/A }
C {devices/lab_pin.sym} 135960 -27750 0 0 {name=p134965 lab=_56086_/B }
C {devices/lab_pin.sym} 135960 -27710 0 0 {name=p134966 lab=_56080_/C }
C {devices/lab_pin.sym} 136080 -27750 0 1 {name=p134967 lab=_56080_/Y }
C {sky130_stdcells/nand3_4.sym} 136020 -27750 0 0 {name=X_56080_ }
C {devices/lab_pin.sym} 135960 -27620 0 0 {name=p134968 lab=_84751_/Q }
C {devices/lab_pin.sym} 135960 -27580 0 0 {name=p134969 lab=_84143_/Q }
C {devices/lab_pin.sym} 136080 -27600 0 1 {name=p134970 lab=_80344_/X }
C {sky130_stdcells/or2_4.sym} 136020 -27600 0 0 {name=X_80344_ }
C {devices/lab_pin.sym} 135980 -27470 0 0 {name=p134971 lab=_69747_/A }
C {devices/lab_pin.sym} 136060 -27470 0 1 {name=p134972 lab=_68066_/X }
C {sky130_stdcells/buf_2.sym} 136020 -27470 0 0 {name=X_68066_ }
C {devices/lab_pin.sym} 135980 -27350 0 0 {name=p134973 lab=_51843_/A }
C {devices/lab_pin.sym} 136060 -27350 0 1 {name=p134974 lab=_53293_/B }
C {sky130_stdcells/buf_2.sym} 136020 -27350 0 0 {name=X_53292_ }
C {devices/lab_pin.sym} 135940 -27250 0 0 {name=p134975 lab=_65271_/X }
C {devices/lab_pin.sym} 135940 -27210 0 0 {name=p134976 lab=_65276_/X }
C {devices/lab_pin.sym} 135940 -27170 0 0 {name=p134977 lab=_65277_/X }
C {devices/lab_pin.sym} 136100 -27210 0 1 {name=p134978 lab=_65281_/A }
C {sky130_stdcells/a21o_4.sym} 136020 -27210 0 0 {name=X_65278_ }
C {devices/lab_pin.sym} 135960 -27100 0 0 {name=p134979 lab=_55017_/X }
C {devices/lab_pin.sym} 135960 -27060 0 0 {name=p134980 lab=_55030_/X }
C {devices/lab_pin.sym} 135960 -27020 0 0 {name=p134981 lab=_55026_/C }
C {devices/lab_pin.sym} 135960 -26980 0 0 {name=p134982 lab=_55031_/D }
C {devices/lab_pin.sym} 136080 -27040 0 1 {name=p134983 lab=_55031_/X }
C {sky130_stdcells/and4_4.sym} 136020 -27040 0 0 {name=X_55031_ }
C {devices/lab_pin.sym} 135940 -26920 0 0 {name=p134984 lab=_66947_/X }
C {devices/lab_pin.sym} 135940 -26880 0 0 {name=p134985 lab=_67005_/Y }
C {devices/lab_pin.sym} 135940 -26840 0 0 {name=p134986 lab=_66910_/X }
C {devices/lab_pin.sym} 135940 -26800 0 0 {name=p134987 lab=_67016_/Y }
C {devices/lab_pin.sym} 136100 -26860 0 1 {name=p134988 lab=_67017_/X }
C {sky130_stdcells/a211o_4.sym} 136020 -26860 0 0 {name=X_67017_ }
C {devices/lab_pin.sym} 135960 -26730 0 0 {name=p134989 lab=_48680_/A }
C {devices/lab_pin.sym} 135960 -26690 0 0 {name=p134990 lab=_52248_/B }
C {devices/lab_pin.sym} 135960 -26650 0 0 {name=p134991 lab=_52223_/C }
C {devices/lab_pin.sym} 136080 -26690 0 1 {name=p134992 lab=_52243_/X }
C {sky130_stdcells/and3_4.sym} 136020 -26690 0 0 {name=X_52243_ }
C {devices/lab_pin.sym} 135980 -26550 0 0 {name=p134993 lab=_64440_/A }
C {devices/lab_pin.sym} 136060 -26550 0 1 {name=p134994 lab=_64229_/X }
C {sky130_stdcells/buf_2.sym} 136020 -26550 0 0 {name=X_64229_ }
C {devices/lab_pin.sym} 135930 -26430 0 0 {name=p134995 lab=_85581_/CLK }
C {devices/lab_pin.sym} 135930 -26410 0 0 {name=p134996 lab=_83063_/D }
C {devices/lab_pin.sym} 136110 -26430 0 1 {name=p134997 lab=_83063_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -26420 0 0 {name=X_83063_ }
C {devices/lab_pin.sym} 135930 -26290 0 0 {name=p134998 lab=_88386_/CLK }
C {devices/lab_pin.sym} 135930 -26270 0 0 {name=p134999 lab=_42285_/Y }
C {devices/lab_pin.sym} 136110 -26290 0 1 {name=p135000 lab=_87940_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -26280 0 0 {name=X_87940_ }
C {devices/lab_pin.sym} 135960 -26160 0 0 {name=p135001 lab=_80273_/Y }
C {devices/lab_pin.sym} 135960 -26120 0 0 {name=p135002 lab=_80274_/Y }
C {devices/lab_pin.sym} 136080 -26140 0 1 {name=p135003 lab=_80275_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -26140 0 0 {name=X_80275_ }
C {devices/lab_pin.sym} 135980 -26010 0 0 {name=p135004 lab=clkbuf_9_260_0_CLK/X }
C {devices/lab_pin.sym} 136060 -26010 0 1 {name=p135005 lab=_81431_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 136020 -26010 0 0 {name=Xclkbuf_10_521_0_CLK }
C {devices/lab_pin.sym} 135980 -25890 0 0 {name=p135006 lab=clkbuf_5_6_0_CLK/X }
C {devices/lab_pin.sym} 136060 -25890 0 1 {name=p135007 lab=clkbuf_6_12_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 136020 -25890 0 0 {name=Xclkbuf_6_12_0_CLK }
C {devices/lab_pin.sym} 135930 -25770 0 0 {name=p135008 lab=_82139_/CLK }
C {devices/lab_pin.sym} 135930 -25750 0 0 {name=p135009 lab=_82046_/Q }
C {devices/lab_pin.sym} 136110 -25770 0 1 {name=p135010 lab=_77200_/A }
C {sky130_stdcells/dfxtp_4.sym} 136020 -25760 0 0 {name=X_82014_ }
C {devices/lab_pin.sym} 135940 -25650 0 0 {name=p135011 lab=_85874_/Q }
C {devices/lab_pin.sym} 135940 -25610 0 0 {name=p135012 lab=_52152_/X }
C {devices/lab_pin.sym} 135940 -25570 0 0 {name=p135013 lab=_52173_/Y }
C {devices/lab_pin.sym} 136100 -25610 0 1 {name=p135014 lab=_52174_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -25610 0 0 {name=X_52174_ }
C {devices/lab_pin.sym} 135930 -25470 0 0 {name=p135015 lab=_82888_/CLK }
C {devices/lab_pin.sym} 135930 -25450 0 0 {name=p135016 lab=_87871_/D }
C {devices/lab_pin.sym} 136110 -25470 0 1 {name=p135017 lab=_87871_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -25460 0 0 {name=X_87871_ }
C {devices/lab_pin.sym} 135960 -25360 0 0 {name=p135018 lab=_51115_/A }
C {devices/lab_pin.sym} 135960 -25320 0 0 {name=p135019 lab=_51121_/B }
C {devices/lab_pin.sym} 135960 -25280 0 0 {name=p135020 lab=_51115_/C }
C {devices/lab_pin.sym} 135960 -25240 0 0 {name=p135021 lab=_52818_/D }
C {devices/lab_pin.sym} 136080 -25300 0 1 {name=p135022 lab=_51125_/X }
C {sky130_stdcells/and4_4.sym} 136020 -25300 0 0 {name=X_51125_ }
C {devices/lab_pin.sym} 135930 -25150 0 0 {name=p135023 lab=_87077_/CLK }
C {devices/lab_pin.sym} 135930 -25130 0 0 {name=p135024 lab=_45998_/X }
C {devices/lab_pin.sym} 136110 -25150 0 1 {name=p135025 lab=_86822_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -25140 0 0 {name=X_86822_ }
C {devices/lab_pin.sym} 135980 -25010 0 0 {name=p135026 lab=_59770_/A }
C {devices/lab_pin.sym} 136060 -25010 0 1 {name=p135027 lab=_65044_/A }
C {sky130_stdcells/buf_2.sym} 136020 -25010 0 0 {name=X_59770_ }
C {devices/lab_pin.sym} 135980 -24890 0 0 {name=p135028 lab=_57019_/A }
C {devices/lab_pin.sym} 136060 -24890 0 1 {name=p135029 lab=_56982_/X }
C {sky130_stdcells/buf_2.sym} 136020 -24890 0 0 {name=X_56982_ }
C {devices/lab_pin.sym} 135940 -24800 0 0 {name=p135030 lab=_87483_/Q }
C {devices/lab_pin.sym} 135940 -24760 0 0 {name=p135031 lab=_68870_/X }
C {devices/lab_pin.sym} 135940 -24720 0 0 {name=p135032 lab=_68871_/X }
C {devices/lab_pin.sym} 135940 -24680 0 0 {name=p135033 lab=_68967_/X }
C {devices/lab_pin.sym} 136100 -24740 0 1 {name=p135034 lab=_68968_/X }
C {sky130_stdcells/a211o_4.sym} 136020 -24740 0 0 {name=X_68968_ }
C {devices/lab_pin.sym} 135980 -24590 0 0 {name=p135035 lab=_58721_/A }
C {devices/lab_pin.sym} 136060 -24590 0 1 {name=p135036 lab=_58764_/B }
C {sky130_stdcells/buf_2.sym} 136020 -24590 0 0 {name=X_58721_ }
C {devices/lab_pin.sym} 135960 -24500 0 0 {name=p135037 lab=_51056_/A }
C {devices/lab_pin.sym} 135960 -24460 0 0 {name=p135038 lab=_51045_/B }
C {devices/lab_pin.sym} 135960 -24420 0 0 {name=p135039 lab=_51045_/C }
C {devices/lab_pin.sym} 135960 -24380 0 0 {name=p135040 lab=_52746_/D }
C {devices/lab_pin.sym} 136080 -24440 0 1 {name=p135041 lab=_51056_/X }
C {sky130_stdcells/and4_4.sym} 136020 -24440 0 0 {name=X_51056_ }
C {devices/lab_pin.sym} 135940 -24310 0 0 {name=p135042 lab=_55930_/X }
C {devices/lab_pin.sym} 135940 -24270 0 0 {name=p135043 lab=_55932_/X }
C {devices/lab_pin.sym} 135940 -24230 0 0 {name=p135044 lab=_55615_/A }
C {devices/lab_pin.sym} 136100 -24270 0 1 {name=p135045 lab=_55936_/A }
C {sky130_stdcells/a21o_4.sym} 136020 -24270 0 0 {name=X_55933_ }
C {devices/lab_pin.sym} 135960 -24140 0 0 {name=p135046 lab=_67992_/A }
C {devices/lab_pin.sym} 135960 -24100 0 0 {name=p135047 lab=_88155_/Q }
C {devices/lab_pin.sym} 136080 -24120 0 1 {name=p135048 lab=_67919_/X }
C {sky130_stdcells/and2_4.sym} 136020 -24120 0 0 {name=X_67919_ }
C {devices/lab_pin.sym} 135930 -23990 0 0 {name=p135049 lab=_86753_/CLK }
C {devices/lab_pin.sym} 135930 -23970 0 0 {name=p135050 lab=_46247_/Y }
C {devices/lab_pin.sym} 136110 -23990 0 1 {name=p135051 lab=_86753_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -23980 0 0 {name=X_86753_ }
C {devices/lab_pin.sym} 135930 -23850 0 0 {name=p135052 lab=_83967_/CLK }
C {devices/lab_pin.sym} 135930 -23830 0 0 {name=p135053 lab=_68690_/X }
C {devices/lab_pin.sym} 136110 -23850 0 1 {name=p135054 lab=_80821_/D }
C {sky130_stdcells/dfxtp_4.sym} 136020 -23840 0 0 {name=X_83965_ }
C {devices/lab_pin.sym} 135980 -23710 0 0 {name=p135055 lab=clkbuf_9_268_0_CLK/X }
C {devices/lab_pin.sym} 136060 -23710 0 1 {name=p135056 lab=_81412_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 136020 -23710 0 0 {name=Xclkbuf_10_536_0_CLK }
C {devices/lab_pin.sym} 135940 -23620 0 0 {name=p135057 lab=_87486_/Q }
C {devices/lab_pin.sym} 135940 -23580 0 0 {name=p135058 lab=_68870_/X }
C {devices/lab_pin.sym} 135940 -23540 0 0 {name=p135059 lab=_68871_/X }
C {devices/lab_pin.sym} 135940 -23500 0 0 {name=p135060 lab=_68898_/X }
C {devices/lab_pin.sym} 136100 -23560 0 1 {name=p135061 lab=_68899_/X }
C {sky130_stdcells/a211o_4.sym} 136020 -23560 0 0 {name=X_68899_ }
C {devices/lab_pin.sym} 135980 -23410 0 0 {name=p135062 lab=clkbuf_6_27_0_CLK/A }
C {devices/lab_pin.sym} 136060 -23410 0 1 {name=p135063 lab=clkbuf_7_55_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 136020 -23410 0 0 {name=Xclkbuf_6_27_0_CLK }
C {devices/lab_pin.sym} 135960 -23300 0 0 {name=p135064 lab=_50001_/A }
C {devices/lab_pin.sym} 135960 -23260 0 0 {name=p135065 lab=_53219_/B }
C {devices/lab_pin.sym} 136080 -23280 0 1 {name=p135066 lab=_50007_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -23280 0 0 {name=X_50007_ }
C {devices/lab_pin.sym} 135930 -23150 0 0 {name=p135067 lab=_85704_/CLK }
C {devices/lab_pin.sym} 135930 -23130 0 0 {name=p135068 lab=_85704_/D }
C {devices/lab_pin.sym} 136110 -23150 0 1 {name=p135069 lab=_85704_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -23140 0 0 {name=X_85704_ }
C {devices/lab_pin.sym} 135960 -23040 0 0 {name=p135070 lab=_70905_/A }
C {devices/lab_pin.sym} 135960 -23000 0 0 {name=p135071 lab=_70863_/C }
C {devices/lab_pin.sym} 135960 -22960 0 0 {name=p135072 lab=_70925_/X }
C {devices/lab_pin.sym} 135960 -22920 0 0 {name=p135073 lab=_70913_/A }
C {devices/lab_pin.sym} 136080 -22980 0 1 {name=p135074 lab=_70930_/Y }
C {sky130_stdcells/nand4_4.sym} 136020 -22980 0 0 {name=X_70930_ }
C {devices/lab_pin.sym} 135940 -22860 0 0 {name=p135075 lab=_58639_/Y }
C {devices/lab_pin.sym} 135940 -22820 0 0 {name=p135076 lab=_58624_/X }
C {devices/lab_pin.sym} 135940 -22780 0 0 {name=p135077 lab=_58647_/X }
C {devices/lab_pin.sym} 135940 -22740 0 0 {name=p135078 lab=_58651_/X }
C {devices/lab_pin.sym} 136100 -22800 0 1 {name=p135079 lab=_84811_/D }
C {sky130_stdcells/a22oi_4.sym} 136020 -22800 0 0 {name=X_58652_ }
C {devices/lab_pin.sym} 135930 -22650 0 0 {name=p135080 lab=_82368_/CLK }
C {devices/lab_pin.sym} 135930 -22630 0 0 {name=p135081 lab=_78144_/X }
C {devices/lab_pin.sym} 136110 -22650 0 1 {name=p135082 lab=_82916_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -22640 0 0 {name=X_82916_ }
C {devices/lab_pin.sym} 135960 -22540 0 0 {name=p135083 lab=_55830_/X }
C {devices/lab_pin.sym} 135960 -22500 0 0 {name=p135084 lab=_56083_/C }
C {devices/lab_pin.sym} 135960 -22460 0 0 {name=p135085 lab=_55854_/X }
C {devices/lab_pin.sym} 135960 -22420 0 0 {name=p135086 lab=_55863_/X }
C {devices/lab_pin.sym} 136080 -22480 0 1 {name=p135087 lab=_55864_/X }
C {sky130_stdcells/and4_4.sym} 136020 -22480 0 0 {name=X_55864_ }
C {devices/lab_pin.sym} 135930 -22330 0 0 {name=p135088 lab=_86686_/CLK }
C {devices/lab_pin.sym} 135930 -22310 0 0 {name=p135089 lab=_86684_/D }
C {devices/lab_pin.sym} 136110 -22330 0 1 {name=p135090 lab=_59057_/A }
C {sky130_stdcells/dfxtp_4.sym} 136020 -22320 0 0 {name=X_86684_ }
C {devices/lab_pin.sym} 135930 -22190 0 0 {name=p135091 lab=_82299_/CLK }
C {devices/lab_pin.sym} 135930 -22170 0 0 {name=p135092 lab=_83896_/D }
C {devices/lab_pin.sym} 136110 -22190 0 1 {name=p135093 lab=_81968_/D }
C {sky130_stdcells/dfxtp_4.sym} 136020 -22180 0 0 {name=X_83896_ }
C {devices/lab_pin.sym} 135980 -22050 0 0 {name=p135094 lab=_46542_/X }
C {devices/lab_pin.sym} 136060 -22050 0 1 {name=p135095 lab=_57603_/X }
C {sky130_stdcells/buf_2.sym} 136020 -22050 0 0 {name=X_57603_ }
C {devices/lab_pin.sym} 135940 -21950 0 0 {name=p135096 lab=_85373_/Q }
C {devices/lab_pin.sym} 135940 -21910 0 0 {name=p135097 lab=_54812_/X }
C {devices/lab_pin.sym} 135940 -21870 0 0 {name=p135098 lab=_54814_/Y }
C {devices/lab_pin.sym} 136100 -21910 0 1 {name=p135099 lab=_54815_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -21910 0 0 {name=X_54815_ }
C {devices/lab_pin.sym} 135930 -21770 0 0 {name=p135100 lab=_85635_/CLK }
C {devices/lab_pin.sym} 135930 -21750 0 0 {name=p135101 lab=_85635_/D }
C {devices/lab_pin.sym} 136110 -21770 0 1 {name=p135102 lab=_85635_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -21760 0 0 {name=X_85635_ }
C {devices/lab_pin.sym} 135940 -21650 0 0 {name=p135103 lab=_51791_/B }
C {devices/lab_pin.sym} 135940 -21610 0 0 {name=p135104 lab=_70855_/X }
C {devices/lab_pin.sym} 135940 -21570 0 0 {name=p135105 lab=_70860_/Y }
C {devices/lab_pin.sym} 136100 -21610 0 1 {name=p135106 lab=_70861_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -21610 0 0 {name=X_70861_ }
C {devices/lab_pin.sym} 135940 -21490 0 0 {name=p135107 lab=_58580_/Y }
C {devices/lab_pin.sym} 135940 -21450 0 0 {name=p135108 lab=_58582_/Y }
C {devices/lab_pin.sym} 135940 -21410 0 0 {name=p135109 lab=_58105_/X }
C {devices/lab_pin.sym} 136100 -21450 0 1 {name=p135110 lab=_58583_/X }
C {sky130_stdcells/a21o_4.sym} 136020 -21450 0 0 {name=X_58583_ }
C {devices/lab_pin.sym} 135930 -21310 0 0 {name=p135111 lab=_82152_/CLK }
C {devices/lab_pin.sym} 135930 -21290 0 0 {name=p135112 lab=_82847_/D }
C {devices/lab_pin.sym} 136110 -21310 0 1 {name=p135113 lab=_82847_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -21300 0 0 {name=X_82847_ }
C {devices/lab_pin.sym} 135940 -21200 0 0 {name=p135114 lab=_85196_/Q }
C {devices/lab_pin.sym} 135940 -21160 0 0 {name=p135115 lab=_55747_/X }
C {devices/lab_pin.sym} 135940 -21120 0 0 {name=p135116 lab=_55300_/X }
C {devices/lab_pin.sym} 135940 -21080 0 0 {name=p135117 lab=_55794_/X }
C {devices/lab_pin.sym} 136100 -21140 0 1 {name=p135118 lab=_55795_/X }
C {sky130_stdcells/a211o_4.sym} 136020 -21140 0 0 {name=X_55795_ }
C {devices/lab_pin.sym} 135940 -21010 0 0 {name=p135119 lab=_72576_/A }
C {devices/lab_pin.sym} 135940 -20970 0 0 {name=p135120 lab=_72535_/A }
C {devices/lab_pin.sym} 135940 -20930 0 0 {name=p135121 lab=_59829_/X }
C {devices/lab_pin.sym} 136100 -20970 0 1 {name=p135122 lab=_72600_/Y }
C {sky130_stdcells/a21oi_4.sym} 136020 -20970 0 0 {name=X_72600_ }
C {devices/lab_pin.sym} 135940 -20850 0 0 {name=p135123 lab=_84984_/Q }
C {devices/lab_pin.sym} 135940 -20810 0 0 {name=p135124 lab=_57527_/X }
C {devices/lab_pin.sym} 135940 -20770 0 0 {name=p135125 lab=_57533_/Y }
C {devices/lab_pin.sym} 136100 -20810 0 1 {name=p135126 lab=_57534_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -20810 0 0 {name=X_57534_ }
C {devices/lab_pin.sym} 135930 -20670 0 0 {name=p135127 lab=_86998_/CLK }
C {devices/lab_pin.sym} 135930 -20650 0 0 {name=p135128 lab=_88354_/D }
C {devices/lab_pin.sym} 136110 -20670 0 1 {name=p135129 lab=_88354_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -20660 0 0 {name=X_88354_ }
C {devices/lab_pin.sym} 135940 -20560 0 0 {name=p135130 lab=_41272_/X }
C {devices/lab_pin.sym} 135940 -20520 0 0 {name=p135131 lab=_42757_/X }
C {devices/lab_pin.sym} 135940 -20480 0 0 {name=p135132 lab=_69076_/B }
C {devices/lab_pin.sym} 135940 -20440 0 0 {name=p135133 lab=_42759_/X }
C {devices/lab_pin.sym} 136100 -20500 0 1 {name=p135134 lab=_87734_/D }
C {sky130_stdcells/a2bb2o_4.sym} 136020 -20500 0 0 {name=X_42760_ }
C {devices/lab_pin.sym} 135940 -20370 0 0 {name=p135135 lab=_85385_/Q }
C {devices/lab_pin.sym} 135940 -20330 0 0 {name=p135136 lab=_54729_/X }
C {devices/lab_pin.sym} 135940 -20290 0 0 {name=p135137 lab=_54745_/Y }
C {devices/lab_pin.sym} 136100 -20330 0 1 {name=p135138 lab=_54746_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -20330 0 0 {name=X_54746_ }
C {devices/lab_pin.sym} 135930 -20190 0 0 {name=p135139 lab=_85566_/CLK }
C {devices/lab_pin.sym} 135930 -20170 0 0 {name=p135140 lab=_53802_/Y }
C {devices/lab_pin.sym} 136110 -20190 0 1 {name=p135141 lab=_85566_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -20180 0 0 {name=X_85566_ }
C {devices/lab_pin.sym} 135940 -20070 0 0 {name=p135142 lab=_88370_/Q }
C {devices/lab_pin.sym} 135940 -20030 0 0 {name=p135143 lab=_72769_/B }
C {devices/lab_pin.sym} 135940 -19990 0 0 {name=p135144 lab=_73007_/A }
C {devices/lab_pin.sym} 136100 -20030 0 1 {name=p135145 lab=_73580_/X }
C {sky130_stdcells/o21a_4.sym} 136020 -20030 0 0 {name=X_73580_ }
C {devices/lab_pin.sym} 135960 -19910 0 0 {name=p135146 lab=_47886_/A }
C {devices/lab_pin.sym} 135960 -19870 0 0 {name=p135147 lab=_51352_/B }
C {devices/lab_pin.sym} 135960 -19830 0 0 {name=p135148 lab=_51958_/C }
C {devices/lab_pin.sym} 136080 -19870 0 1 {name=p135149 lab=_51958_/X }
C {sky130_stdcells/and3_4.sym} 136020 -19870 0 0 {name=X_51958_ }
C {devices/lab_pin.sym} 135940 -19750 0 0 {name=p135150 lab=_52869_/B }
C {devices/lab_pin.sym} 135940 -19710 0 0 {name=p135151 lab=_70761_/A }
C {devices/lab_pin.sym} 135940 -19670 0 0 {name=p135152 lab=_70791_/Y }
C {devices/lab_pin.sym} 136100 -19710 0 1 {name=p135153 lab=_70792_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -19710 0 0 {name=X_70792_ }
C {devices/lab_pin.sym} 135930 -19570 0 0 {name=p135154 lab=_82206_/CLK }
C {devices/lab_pin.sym} 135930 -19550 0 0 {name=p135155 lab=_82778_/D }
C {devices/lab_pin.sym} 136110 -19570 0 1 {name=p135156 lab=_82778_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -19560 0 0 {name=X_82778_ }
C {devices/lab_pin.sym} 135930 -19430 0 0 {name=p135157 lab=_88327_/CLK }
C {devices/lab_pin.sym} 135930 -19410 0 0 {name=p135158 lab=_87305_/D }
C {devices/lab_pin.sym} 136110 -19430 0 1 {name=p135159 lab=_87305_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -19420 0 0 {name=X_87305_ }
C {devices/lab_pin.sym} 135940 -19330 0 0 {name=p135160 lab=_41672_/X }
C {devices/lab_pin.sym} 135940 -19290 0 0 {name=p135161 lab=_41673_/X }
C {devices/lab_pin.sym} 135940 -19250 0 0 {name=p135162 lab=_41710_/X }
C {devices/lab_pin.sym} 135940 -19210 0 0 {name=p135163 lab=_88164_/Q }
C {devices/lab_pin.sym} 135940 -19170 0 0 {name=p135164 lab=_41668_/X }
C {devices/lab_pin.sym} 136100 -19250 0 1 {name=p135165 lab=_41712_/A }
C {sky130_stdcells/o32ai_4.sym} 136020 -19250 0 0 {name=X_41711_ }
C {devices/lab_pin.sym} 135930 -19090 0 0 {name=p135166 lab=_84498_/CLK }
C {devices/lab_pin.sym} 135930 -19070 0 0 {name=p135167 lab=_84517_/D }
C {devices/lab_pin.sym} 136110 -19090 0 1 {name=p135168 lab=_84517_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -19080 0 0 {name=X_84517_ }
C {devices/lab_pin.sym} 135960 -18970 0 0 {name=p135169 lab=_72597_/B }
C {devices/lab_pin.sym} 135960 -18930 0 0 {name=p135170 lab=_72535_/B }
C {devices/lab_pin.sym} 135960 -18890 0 0 {name=p135171 lab=_72597_/C }
C {devices/lab_pin.sym} 136080 -18930 0 1 {name=p135172 lab=_72531_/Y }
C {sky130_stdcells/nand3_4.sym} 136020 -18930 0 0 {name=X_72531_ }
C {devices/lab_pin.sym} 135940 -18810 0 0 {name=p135173 lab=_50907_/Y }
C {devices/lab_pin.sym} 135940 -18770 0 0 {name=p135174 lab=_50902_/X }
C {devices/lab_pin.sym} 135940 -18730 0 0 {name=p135175 lab=_50908_/X }
C {devices/lab_pin.sym} 136100 -18770 0 1 {name=p135176 lab=_86109_/D }
C {sky130_stdcells/a21oi_4.sym} 136020 -18770 0 0 {name=X_50909_ }
C {devices/lab_pin.sym} 135960 -18640 0 0 {name=p135177 lab=_57465_/A }
C {devices/lab_pin.sym} 135960 -18600 0 0 {name=p135178 lab=_56872_/Y }
C {devices/lab_pin.sym} 136080 -18620 0 1 {name=p135179 lab=_57465_/X }
C {sky130_stdcells/or2_4.sym} 136020 -18620 0 0 {name=X_57465_ }
C {devices/lab_pin.sym} 135930 -18490 0 0 {name=p135180 lab=_81346_/CLK }
C {devices/lab_pin.sym} 135930 -18470 0 0 {name=p135181 lab=_81729_/D }
C {devices/lab_pin.sym} 136110 -18490 0 1 {name=p135182 lab=_41114_/A }
C {sky130_stdcells/dfxtp_4.sym} 136020 -18480 0 0 {name=X_81729_ }
C {devices/lab_pin.sym} 135940 -18390 0 0 {name=p135183 lab=_42687_/X }
C {devices/lab_pin.sym} 135940 -18350 0 0 {name=p135184 lab=_42688_/X }
C {devices/lab_pin.sym} 135940 -18310 0 0 {name=p135185 lab=_41087_/X }
C {devices/lab_pin.sym} 135940 -18270 0 0 {name=p135186 lab=_87768_/Q }
C {devices/lab_pin.sym} 135940 -18230 0 0 {name=p135187 lab=_42673_/X }
C {devices/lab_pin.sym} 136100 -18310 0 1 {name=p135188 lab=_42692_/A }
C {sky130_stdcells/o32ai_4.sym} 136020 -18310 0 0 {name=X_42691_ }
C {devices/lab_pin.sym} 135930 -18150 0 0 {name=p135189 lab=_87011_/CLK }
C {devices/lab_pin.sym} 135930 -18130 0 0 {name=p135190 lab=_41060_/X }
C {devices/lab_pin.sym} 136110 -18150 0 1 {name=p135191 lab=_88285_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -18140 0 0 {name=X_88285_ }
C {devices/lab_pin.sym} 135980 -18010 0 0 {name=p135192 lab=_54594_/X }
C {devices/lab_pin.sym} 136060 -18010 0 1 {name=p135193 lab=_54682_/A }
C {sky130_stdcells/buf_2.sym} 136020 -18010 0 0 {name=X_54677_ }
C {devices/lab_pin.sym} 135930 -17890 0 0 {name=p135194 lab=_83745_/CLK }
C {devices/lab_pin.sym} 135930 -17870 0 0 {name=p135195 lab=_54138_/Y }
C {devices/lab_pin.sym} 136110 -17890 0 1 {name=p135196 lab=_85497_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -17880 0 0 {name=X_85497_ }
C {devices/lab_pin.sym} 135960 -17760 0 0 {name=p135197 lab=_51875_/A }
C {devices/lab_pin.sym} 135960 -17720 0 0 {name=p135198 lab=_51026_/B }
C {devices/lab_pin.sym} 136080 -17740 0 1 {name=p135199 lab=_51889_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -17740 0 0 {name=X_51889_ }
C {devices/lab_pin.sym} 135980 -17610 0 0 {name=p135200 lab=_80441_/A }
C {devices/lab_pin.sym} 136060 -17610 0 1 {name=p135201 lab=_59204_/Y }
C {sky130_stdcells/inv_2.sym} 136020 -17610 0 0 {name=X_59204_ }
C {devices/lab_pin.sym} 135980 -17490 0 0 {name=p135202 lab=_44430_/A }
C {devices/lab_pin.sym} 136060 -17490 0 1 {name=p135203 lab=_87113_/D }
C {sky130_stdcells/inv_2.sym} 136020 -17490 0 0 {name=X_44430_ }
C {devices/lab_pin.sym} 135960 -17390 0 0 {name=p135204 lab=_56418_/A }
C {devices/lab_pin.sym} 135960 -17350 0 0 {name=p135205 lab=_56418_/B }
C {devices/lab_pin.sym} 135960 -17310 0 0 {name=p135206 lab=_85202_/Q }
C {devices/lab_pin.sym} 136080 -17350 0 1 {name=p135207 lab=_56416_/Y }
C {sky130_stdcells/nand3_4.sym} 136020 -17350 0 0 {name=X_56416_ }
C {devices/lab_pin.sym} 135960 -17220 0 0 {name=p135208 lab=_80782_/Q }
C {devices/lab_pin.sym} 135960 -17180 0 0 {name=p135209 lab=_75249_/Y }
C {devices/lab_pin.sym} 136080 -17200 0 1 {name=p135210 lab=_75250_/X }
C {sky130_stdcells/xor2_4.sym} 136020 -17200 0 0 {name=X_75250_ }
C {devices/lab_pin.sym} 135940 -17090 0 0 {name=p135211 lab=_41588_/X }
C {devices/lab_pin.sym} 135940 -17050 0 0 {name=p135212 lab=_81759_/Q }
C {devices/lab_pin.sym} 135940 -17010 0 0 {name=p135213 lab=_41641_/X }
C {devices/lab_pin.sym} 136100 -17050 0 1 {name=p135214 lab=_41642_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -17050 0 0 {name=X_41642_ }
C {devices/lab_pin.sym} 135930 -16910 0 0 {name=p135215 lab=_87758_/CLK }
C {devices/lab_pin.sym} 135930 -16890 0 0 {name=p135216 lab=_87236_/D }
C {devices/lab_pin.sym} 136110 -16910 0 1 {name=p135217 lab=_87236_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -16900 0 0 {name=X_87236_ }
C {devices/lab_pin.sym} 135960 -16780 0 0 {name=p135218 lab=_53656_/A }
C {devices/lab_pin.sym} 135960 -16740 0 0 {name=p135219 lab=_74373_/B }
C {devices/lab_pin.sym} 136080 -16760 0 1 {name=p135220 lab=_53628_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -16760 0 0 {name=X_53628_ }
C {devices/lab_pin.sym} 135960 -16640 0 0 {name=p135221 lab=_86596_/Q }
C {devices/lab_pin.sym} 135960 -16600 0 0 {name=p135222 lab=_72401_/B }
C {devices/lab_pin.sym} 136080 -16620 0 1 {name=p135223 lab=_72462_/Y }
C {sky130_stdcells/nor2_4.sym} 136020 -16620 0 0 {name=X_72462_ }
C {devices/lab_pin.sym} 135930 -16490 0 0 {name=p135224 lab=_84449_/CLK }
C {devices/lab_pin.sym} 135930 -16470 0 0 {name=p135225 lab=_61883_/Y }
C {devices/lab_pin.sym} 136110 -16490 0 1 {name=p135226 lab=_78071_/B }
C {sky130_stdcells/dfxtp_4.sym} 136020 -16480 0 0 {name=X_84448_ }
C {devices/lab_pin.sym} 135940 -16380 0 0 {name=p135227 lab=_57394_/X }
C {devices/lab_pin.sym} 135940 -16340 0 0 {name=p135228 lab=_56607_/X }
C {devices/lab_pin.sym} 135940 -16300 0 0 {name=p135229 lab=_85018_/Q }
C {devices/lab_pin.sym} 135940 -16260 0 0 {name=p135230 lab=_57395_/X }
C {devices/lab_pin.sym} 136100 -16320 0 1 {name=p135231 lab=_85018_/D }
C {sky130_stdcells/a2bb2o_4.sym} 136020 -16320 0 0 {name=X_57396_ }
C {devices/lab_pin.sym} 135960 -16180 0 0 {name=p135232 lab=_74191_/Y }
C {devices/lab_pin.sym} 135960 -16140 0 0 {name=p135233 lab=_74201_/B }
C {devices/lab_pin.sym} 136080 -16160 0 1 {name=p135234 lab=_74201_/Y }
C {sky130_stdcells/xnor2_4.sym} 136020 -16160 0 0 {name=X_74201_ }
C {devices/lab_pin.sym} 135960 -16050 0 0 {name=p135235 lab=_70689_/A }
C {devices/lab_pin.sym} 135960 -16010 0 0 {name=p135236 lab=_71411_/B }
C {devices/lab_pin.sym} 135960 -15970 0 0 {name=p135237 lab=_71411_/C }
C {devices/lab_pin.sym} 136080 -16010 0 1 {name=p135238 lab=_71413_/Y }
C {sky130_stdcells/nor3_4.sym} 136020 -16010 0 0 {name=X_71413_ }
C {devices/lab_pin.sym} 135980 -15870 0 0 {name=p135239 lab=_58877_/A }
C {devices/lab_pin.sym} 136060 -15870 0 1 {name=p135240 lab=_59135_/X }
C {sky130_stdcells/buf_2.sym} 136020 -15870 0 0 {name=X_59135_ }
C {devices/lab_pin.sym} 135980 -15750 0 0 {name=p135241 lab=_44361_/A }
C {devices/lab_pin.sym} 136060 -15750 0 1 {name=p135242 lab=_44361_/Y }
C {sky130_stdcells/inv_2.sym} 136020 -15750 0 0 {name=X_44361_ }
C {devices/lab_pin.sym} 135980 -15630 0 0 {name=p135243 lab=_56347_/A }
C {devices/lab_pin.sym} 136060 -15630 0 1 {name=p135244 lab=_56358_/A }
C {sky130_stdcells/buf_2.sym} 136020 -15630 0 0 {name=X_56347_ }
C {devices/lab_pin.sym} 135930 -15510 0 0 {name=p135245 lab=_87417_/CLK }
C {devices/lab_pin.sym} 135930 -15490 0 0 {name=p135246 lab=_87167_/D }
C {devices/lab_pin.sym} 136110 -15510 0 1 {name=p135247 lab=_87167_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -15500 0 0 {name=X_87167_ }
C {devices/lab_pin.sym} 135940 -15390 0 0 {name=p135248 lab=_75167_/B }
C {devices/lab_pin.sym} 135940 -15350 0 0 {name=p135249 lab=_75162_/A }
C {devices/lab_pin.sym} 135940 -15310 0 0 {name=p135250 lab=_75162_/B }
C {devices/lab_pin.sym} 136100 -15350 0 1 {name=p135251 lab=_75181_/Y }
C {sky130_stdcells/a21boi_4.sym} 136020 -15350 0 0 {name=X_75181_ }
C {devices/lab_pin.sym} 135940 -15230 0 0 {name=p135252 lab=_41533_/X }
C {devices/lab_pin.sym} 135940 -15190 0 0 {name=p135253 lab=_82315_/Q }
C {devices/lab_pin.sym} 135940 -15150 0 0 {name=p135254 lab=_41572_/X }
C {devices/lab_pin.sym} 136100 -15190 0 1 {name=p135255 lab=_41573_/X }
C {sky130_stdcells/o21a_4.sym} 136020 -15190 0 0 {name=X_41573_ }
C {devices/lab_pin.sym} 135940 -15070 0 0 {name=p135256 lab=_85613_/Q }
C {devices/lab_pin.sym} 135940 -15030 0 0 {name=p135257 lab=_53556_/X }
C {devices/lab_pin.sym} 135940 -14990 0 0 {name=p135258 lab=_53558_/Y }
C {devices/lab_pin.sym} 136100 -15030 0 1 {name=p135259 lab=_53559_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -15030 0 0 {name=X_53559_ }
C {devices/lab_pin.sym} 135940 -14920 0 0 {name=p135260 lab=_83259_/Q }
C {devices/lab_pin.sym} 135940 -14880 0 0 {name=p135261 lab=_72381_/X }
C {devices/lab_pin.sym} 135940 -14840 0 0 {name=p135262 lab=_72385_/X }
C {devices/lab_pin.sym} 135940 -14800 0 0 {name=p135263 lab=_72392_/X }
C {devices/lab_pin.sym} 136100 -14860 0 1 {name=p135264 lab=_83259_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 136020 -14860 0 0 {name=X_72393_ }
C {devices/lab_pin.sym} 135930 -14710 0 0 {name=p135265 lab=_84375_/CLK }
C {devices/lab_pin.sym} 135930 -14690 0 0 {name=p135266 lab=_84379_/D }
C {devices/lab_pin.sym} 136110 -14710 0 1 {name=p135267 lab=_62825_/C }
C {sky130_stdcells/dfxtp_4.sym} 136020 -14700 0 0 {name=X_84379_ }
C {devices/lab_pin.sym} 135960 -14590 0 0 {name=p135268 lab=_46111_/A }
C {devices/lab_pin.sym} 135960 -14550 0 0 {name=p135269 lab=_46099_/X }
C {devices/lab_pin.sym} 135960 -14510 0 0 {name=p135270 lab=_46094_/X }
C {devices/lab_pin.sym} 136080 -14550 0 1 {name=p135271 lab=_46101_/A }
C {sky130_stdcells/nor3_4.sym} 136020 -14550 0 0 {name=X_46100_ }
C {devices/lab_pin.sym} 135980 -14410 0 0 {name=p135272 lab=_43312_/A }
C {devices/lab_pin.sym} 136060 -14410 0 1 {name=p135273 lab=_87487_/D }
C {sky130_stdcells/inv_2.sym} 136020 -14410 0 0 {name=X_43312_ }
C {devices/lab_pin.sym} 135960 -14300 0 0 {name=p135274 lab=_73588_/A }
C {devices/lab_pin.sym} 135960 -14260 0 0 {name=p135275 lab=_66256_/B }
C {devices/lab_pin.sym} 136080 -14280 0 1 {name=p135276 lab=_74132_/X }
C {sky130_stdcells/and2_4.sym} 136020 -14280 0 0 {name=X_74132_ }
C {devices/lab_pin.sym} 135930 -14150 0 0 {name=p135277 lab=_86118_/CLK }
C {devices/lab_pin.sym} 135930 -14130 0 0 {name=p135278 lab=_86118_/D }
C {devices/lab_pin.sym} 136110 -14150 0 1 {name=p135279 lab=_86118_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -14140 0 0 {name=X_86118_ }
C {devices/lab_pin.sym} 135980 -14010 0 0 {name=p135280 lab=_40523_/Y }
C {devices/lab_pin.sym} 136060 -14010 0 1 {name=p135281 lab=_40524_/X }
C {sky130_stdcells/buf_2.sym} 136020 -14010 0 0 {name=X_40524_ }
C {devices/lab_pin.sym} 135940 -13910 0 0 {name=p135282 lab=_86672_/Q }
C {devices/lab_pin.sym} 135940 -13870 0 0 {name=p135283 lab=_47050_/X }
C {devices/lab_pin.sym} 135940 -13830 0 0 {name=p135284 lab=_47079_/Y }
C {devices/lab_pin.sym} 136100 -13870 0 1 {name=p135285 lab=_47080_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -13870 0 0 {name=X_47080_ }
C {devices/lab_pin.sym} 135960 -13740 0 0 {name=p135286 lab=_59029_/A }
C {devices/lab_pin.sym} 135960 -13700 0 0 {name=p135287 lab=_86363_/Q }
C {devices/lab_pin.sym} 136080 -13720 0 1 {name=p135288 lab=_59066_/Y }
C {sky130_stdcells/nor2_4.sym} 136020 -13720 0 0 {name=X_59066_ }
C {devices/lab_pin.sym} 135980 -13590 0 0 {name=p135289 lab=_71344_/A }
C {devices/lab_pin.sym} 136060 -13590 0 1 {name=p135290 lab=_71344_/X }
C {sky130_stdcells/buf_2.sym} 136020 -13590 0 0 {name=X_71344_ }
C {devices/lab_pin.sym} 135980 -13470 0 0 {name=p135291 lab=_44292_/A }
C {devices/lab_pin.sym} 136060 -13470 0 1 {name=p135292 lab=_72498_/B }
C {sky130_stdcells/buf_2.sym} 136020 -13470 0 0 {name=X_44292_ }
C {devices/lab_pin.sym} 135980 -13350 0 0 {name=p135293 lab=_56278_/A }
C {devices/lab_pin.sym} 136060 -13350 0 1 {name=p135294 lab=_57223_/D }
C {sky130_stdcells/buf_2.sym} 136020 -13350 0 0 {name=X_56278_ }
C {devices/lab_pin.sym} 135930 -13230 0 0 {name=p135295 lab=_87011_/CLK }
C {devices/lab_pin.sym} 135930 -13210 0 0 {name=p135296 lab=_44461_/Y }
C {devices/lab_pin.sym} 136110 -13230 0 1 {name=p135297 lab=_87098_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136020 -13220 0 0 {name=X_87098_ }
C {devices/lab_pin.sym} 135940 -13120 0 0 {name=p135298 lab=_41468_/Y }
C {devices/lab_pin.sym} 135940 -13080 0 0 {name=p135299 lab=_46029_/X }
C {devices/lab_pin.sym} 135940 -13040 0 0 {name=p135300 lab=_86804_/Q }
C {devices/lab_pin.sym} 135940 -13000 0 0 {name=p135301 lab=_46030_/X }
C {devices/lab_pin.sym} 136100 -13060 0 1 {name=p135302 lab=_46031_/X }
C {sky130_stdcells/a2bb2o_4.sym} 136020 -13060 0 0 {name=X_46031_ }
C {devices/lab_pin.sym} 135980 -12910 0 0 {name=p135303 lab=_58703_/A }
C {devices/lab_pin.sym} 136060 -12910 0 1 {name=p135304 lab=_58017_/X }
C {sky130_stdcells/buf_2.sym} 136020 -12910 0 0 {name=X_58017_ }
C {devices/lab_pin.sym} 135960 -12800 0 0 {name=p135305 lab=_55129_/A }
C {devices/lab_pin.sym} 135960 -12760 0 0 {name=p135306 lab=_85060_/Q }
C {devices/lab_pin.sym} 136080 -12780 0 1 {name=p135307 lab=_55229_/X }
C {sky130_stdcells/and2_4.sym} 136020 -12780 0 0 {name=X_55229_ }
C {devices/lab_pin.sym} 135980 -12650 0 0 {name=p135308 lab=_43243_/A }
C {devices/lab_pin.sym} 136060 -12650 0 1 {name=p135309 lab=_87521_/D }
C {sky130_stdcells/inv_2.sym} 136020 -12650 0 0 {name=X_43243_ }
C {devices/lab_pin.sym} 135960 -12540 0 0 {name=p135310 lab=_74022_/X }
C {devices/lab_pin.sym} 135960 -12500 0 0 {name=p135311 lab=_66214_/B }
C {devices/lab_pin.sym} 136080 -12520 0 1 {name=p135312 lab=_74063_/X }
C {sky130_stdcells/and2_4.sym} 136020 -12520 0 0 {name=X_74063_ }
C {devices/lab_pin.sym} 135980 -12390 0 0 {name=p135313 lab=_78940_/A }
C {devices/lab_pin.sym} 136060 -12390 0 1 {name=p135314 lab=_78942_/A }
C {sky130_stdcells/inv_2.sym} 136020 -12390 0 0 {name=X_78940_ }
C {devices/lab_pin.sym} 135930 -12270 0 0 {name=p135315 lab=_85535_/CLK }
C {devices/lab_pin.sym} 135930 -12250 0 0 {name=p135316 lab=_51239_/Y }
C {devices/lab_pin.sym} 136110 -12270 0 1 {name=p135317 lab=_64572_/B }
C {sky130_stdcells/dfxtp_4.sym} 136020 -12260 0 0 {name=X_86049_ }
C {devices/lab_pin.sym} 135980 -12130 0 0 {name=p135318 lab=_47825_/A }
C {devices/lab_pin.sym} 136060 -12130 0 1 {name=p135319 lab=_40783_/A }
C {sky130_stdcells/buf_2.sym} 136020 -12130 0 0 {name=X_40455_ }
C {devices/lab_pin.sym} 135940 -12030 0 0 {name=p135320 lab=_53193_/B }
C {devices/lab_pin.sym} 135940 -11990 0 0 {name=p135321 lab=_71265_/X }
C {devices/lab_pin.sym} 135940 -11950 0 0 {name=p135322 lab=_71274_/Y }
C {devices/lab_pin.sym} 136100 -11990 0 1 {name=p135323 lab=_83551_/D }
C {sky130_stdcells/o21ai_4.sym} 136020 -11990 0 0 {name=X_71275_ }
C {devices/lab_pin.sym} 135940 -11870 0 0 {name=p135324 lab=_73011_/X }
C {devices/lab_pin.sym} 135940 -11830 0 0 {name=p135325 lab=_73013_/X }
C {devices/lab_pin.sym} 135940 -11790 0 0 {name=p135326 lab=_72812_/X }
C {devices/lab_pin.sym} 136100 -11830 0 1 {name=p135327 lab=_73018_/A }
C {sky130_stdcells/a21o_4.sym} 136020 -11830 0 0 {name=X_73014_ }
C {devices/lab_pin.sym} 135940 -11710 0 0 {name=p135328 lab=_70224_/X }
C {devices/lab_pin.sym} 135940 -11670 0 0 {name=p135329 lab=_83831_/Q }
C {devices/lab_pin.sym} 135940 -11630 0 0 {name=p135330 lab=_70225_/X }
C {devices/lab_pin.sym} 136100 -11670 0 1 {name=p135331 lab=_83831_/D }
C {sky130_stdcells/a21o_4.sym} 136020 -11670 0 0 {name=X_70226_ }
C {devices/lab_pin.sym} 135980 -11530 0 0 {name=p135332 lab=_43174_/A }
C {devices/lab_pin.sym} 136060 -11530 0 1 {name=p135333 lab=_43174_/Y }
C {sky130_stdcells/inv_2.sym} 136020 -11530 0 0 {name=X_43174_ }
C {devices/lab_pin.sym} 135960 -11420 0 0 {name=p135334 lab=_82842_/Q }
C {devices/lab_pin.sym} 135960 -11380 0 0 {name=p135335 lab=_82554_/Q }
C {devices/lab_pin.sym} 136080 -11400 0 1 {name=p135336 lab=_78896_/A }
C {sky130_stdcells/xnor2_4.sym} 136020 -11400 0 0 {name=X_78871_ }
C {devices/lab_pin.sym} 135940 -11290 0 0 {name=p135337 lab=_40381_/X }
C {devices/lab_pin.sym} 135940 -11250 0 0 {name=p135338 lab=_81182_/Q }
C {devices/lab_pin.sym} 135940 -11210 0 0 {name=p135339 lab=_40385_/X }
C {devices/lab_pin.sym} 136100 -11250 0 1 {name=p135340 lab=_40386_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -11250 0 0 {name=X_40386_ }
C {devices/lab_pin.sym} 135980 -11110 0 0 {name=p135341 lab=_51719_/A }
C {devices/lab_pin.sym} 136060 -11110 0 1 {name=p135342 lab=_42125_/X }
C {sky130_stdcells/buf_2.sym} 136020 -11110 0 0 {name=X_42125_ }
C {devices/lab_pin.sym} 135960 -11000 0 0 {name=p135343 lab=_77822_/A }
C {devices/lab_pin.sym} 135960 -10960 0 0 {name=p135344 lab=_77822_/B }
C {devices/lab_pin.sym} 136080 -10980 0 1 {name=p135345 lab=_77822_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -10980 0 0 {name=X_77822_ }
C {devices/lab_pin.sym} 135980 -10850 0 0 {name=p135346 lab=_70157_/A }
C {devices/lab_pin.sym} 136060 -10850 0 1 {name=p135347 lab=_70157_/X }
C {sky130_stdcells/buf_2.sym} 136020 -10850 0 0 {name=X_70157_ }
C {devices/lab_pin.sym} 135960 -10740 0 0 {name=p135348 lab=_47982_/A }
C {devices/lab_pin.sym} 135960 -10700 0 0 {name=p135349 lab=_47973_/B }
C {devices/lab_pin.sym} 136080 -10720 0 1 {name=p135350 lab=_47982_/X }
C {sky130_stdcells/or2_4.sym} 136020 -10720 0 0 {name=X_47982_ }
C {devices/lab_pin.sym} 135960 -10600 0 0 {name=p135351 lab=_59968_/A }
C {devices/lab_pin.sym} 135960 -10560 0 0 {name=p135352 lab=_59968_/B }
C {devices/lab_pin.sym} 136080 -10580 0 1 {name=p135353 lab=_59968_/X }
C {sky130_stdcells/and2_4.sym} 136020 -10580 0 0 {name=X_59968_ }
C {devices/lab_pin.sym} 135960 -10460 0 0 {name=p135354 lab=_49716_/X }
C {devices/lab_pin.sym} 135960 -10420 0 0 {name=p135355 lab=_52936_/B }
C {devices/lab_pin.sym} 136080 -10440 0 1 {name=p135356 lab=_49721_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -10440 0 0 {name=X_49721_ }
C {devices/lab_pin.sym} 135980 -10310 0 0 {name=p135357 lab=_54449_/D }
C {devices/lab_pin.sym} 136060 -10310 0 1 {name=p135358 lab=_52758_/D }
C {sky130_stdcells/buf_2.sym} 136020 -10310 0 0 {name=X_46933_ }
C {devices/lab_pin.sym} 135980 -10190 0 0 {name=p135359 lab=_58698_/A }
C {devices/lab_pin.sym} 136060 -10190 0 1 {name=p135360 lab=_58920_/A }
C {sky130_stdcells/buf_2.sym} 136020 -10190 0 0 {name=X_58919_ }
C {devices/lab_pin.sym} 135980 -10070 0 0 {name=p135361 lab=_42056_/A }
C {devices/lab_pin.sym} 136060 -10070 0 1 {name=p135362 lab=_42056_/Y }
C {sky130_stdcells/inv_2.sym} 136020 -10070 0 0 {name=X_42056_ }
C {devices/lab_pin.sym} 135960 -9960 0 0 {name=p135363 lab=_77745_/Y }
C {devices/lab_pin.sym} 135960 -9920 0 0 {name=p135364 lab=_77753_/B }
C {devices/lab_pin.sym} 136080 -9940 0 1 {name=p135365 lab=_77754_/B }
C {sky130_stdcells/xor2_4.sym} 136020 -9940 0 0 {name=X_77753_ }
C {devices/lab_pin.sym} 135960 -9820 0 0 {name=p135366 lab=_80763_/Q }
C {devices/lab_pin.sym} 135960 -9780 0 0 {name=p135367 lab=_74965_/B }
C {devices/lab_pin.sym} 136080 -9800 0 1 {name=p135368 lab=_74971_/B }
C {sky130_stdcells/xor2_4.sym} 136020 -9800 0 0 {name=X_74965_ }
C {devices/lab_pin.sym} 135940 -9690 0 0 {name=p135369 lab=_83853_/Q }
C {devices/lab_pin.sym} 135940 -9650 0 0 {name=p135370 lab=_70085_/X }
C {devices/lab_pin.sym} 135940 -9610 0 0 {name=p135371 lab=_70087_/X }
C {devices/lab_pin.sym} 136100 -9650 0 1 {name=p135372 lab=_70088_/X }
C {sky130_stdcells/a21bo_4.sym} 136020 -9650 0 0 {name=X_70088_ }
C {devices/lab_pin.sym} 135960 -9540 0 0 {name=p135373 lab=_43969_/A }
C {devices/lab_pin.sym} 135960 -9500 0 0 {name=p135374 lab=_59899_/B }
C {devices/lab_pin.sym} 135960 -9460 0 0 {name=p135375 lab=_43969_/B }
C {devices/lab_pin.sym} 135960 -9420 0 0 {name=p135376 lab=_59899_/D }
C {devices/lab_pin.sym} 136080 -9480 0 1 {name=p135377 lab=_59899_/X }
C {sky130_stdcells/and4_4.sym} 136020 -9480 0 0 {name=X_59899_ }
C {devices/lab_pin.sym} 135960 -9340 0 0 {name=p135378 lab=_41007_/A }
C {devices/lab_pin.sym} 135960 -9300 0 0 {name=p135379 lab=_41007_/B }
C {devices/lab_pin.sym} 136080 -9320 0 1 {name=p135380 lab=_41007_/X }
C {sky130_stdcells/or2_4.sym} 136020 -9320 0 0 {name=X_41007_ }
C {devices/lab_pin.sym} 135940 -9210 0 0 {name=p135381 lab=_76698_/Y }
C {devices/lab_pin.sym} 135940 -9170 0 0 {name=p135382 lab=_76699_/X }
C {devices/lab_pin.sym} 135940 -9130 0 0 {name=p135383 lab=_76703_/Y }
C {devices/lab_pin.sym} 136100 -9170 0 1 {name=p135384 lab=_76704_/Y }
C {sky130_stdcells/a21oi_4.sym} 136020 -9170 0 0 {name=X_76704_ }
C {devices/lab_pin.sym} 135960 -9060 0 0 {name=p135385 lab=_49651_/X }
C {devices/lab_pin.sym} 135960 -9020 0 0 {name=p135386 lab=_49642_/B }
C {devices/lab_pin.sym} 135960 -8980 0 0 {name=p135387 lab=_49629_/X }
C {devices/lab_pin.sym} 135960 -8940 0 0 {name=p135388 lab=_52867_/D }
C {devices/lab_pin.sym} 136080 -9000 0 1 {name=p135389 lab=_49652_/X }
C {sky130_stdcells/and4_4.sym} 136020 -9000 0 0 {name=X_49652_ }
C {devices/lab_pin.sym} 135980 -8850 0 0 {name=p135390 lab=_61711_/X }
C {devices/lab_pin.sym} 136060 -8850 0 1 {name=p135391 lab=_61949_/A }
C {sky130_stdcells/buf_2.sym} 136020 -8850 0 0 {name=X_61930_ }
C {devices/lab_pin.sym} 135960 -8740 0 0 {name=p135392 lab=_44705_/A }
C {devices/lab_pin.sym} 135960 -8700 0 0 {name=p135393 lab=_73916_/B }
C {devices/lab_pin.sym} 136080 -8720 0 1 {name=p135394 lab=_73916_/Y }
C {sky130_stdcells/nor2_4.sym} 136020 -8720 0 0 {name=X_73916_ }
C {devices/lab_pin.sym} 135940 -8610 0 0 {name=p135395 lab=_86695_/Q }
C {devices/lab_pin.sym} 135940 -8570 0 0 {name=p135396 lab=_46859_/X }
C {devices/lab_pin.sym} 135940 -8530 0 0 {name=p135397 lab=_46863_/Y }
C {devices/lab_pin.sym} 136100 -8570 0 1 {name=p135398 lab=_46864_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -8570 0 0 {name=X_46864_ }
C {devices/lab_pin.sym} 135940 -8450 0 0 {name=p135399 lab=_77662_/Y }
C {devices/lab_pin.sym} 135940 -8410 0 0 {name=p135400 lab=_77695_/B }
C {devices/lab_pin.sym} 135940 -8370 0 0 {name=p135401 lab=_77693_/C }
C {devices/lab_pin.sym} 136100 -8410 0 1 {name=p135402 lab=_77688_/A }
C {sky130_stdcells/o21a_4.sym} 136020 -8410 0 0 {name=X_77684_ }
C {devices/lab_pin.sym} 135960 -8280 0 0 {name=p135403 lab=_81130_/D }
C {devices/lab_pin.sym} 135960 -8240 0 0 {name=p135404 lab=_80842_/Q }
C {devices/lab_pin.sym} 136080 -8260 0 1 {name=p135405 lab=_74905_/A }
C {sky130_stdcells/xor2_4.sym} 136020 -8260 0 0 {name=X_74896_ }
C {devices/lab_pin.sym} 135980 -8130 0 0 {name=p135406 lab=_48602_/Y }
C {devices/lab_pin.sym} 136060 -8130 0 1 {name=p135407 lab=_50508_/B }
C {sky130_stdcells/buf_2.sym} 136020 -8130 0 0 {name=X_48603_ }
C {devices/lab_pin.sym} 135960 -8020 0 0 {name=p135408 lab=_79417_/Y }
C {devices/lab_pin.sym} 135960 -7980 0 0 {name=p135409 lab=_79422_/Y }
C {devices/lab_pin.sym} 136080 -8000 0 1 {name=p135410 lab=_82840_/D }
C {sky130_stdcells/xor2_4.sym} 136020 -8000 0 0 {name=X_79423_ }
C {devices/lab_pin.sym} 135940 -7890 0 0 {name=p135411 lab=_56887_/B }
C {devices/lab_pin.sym} 135940 -7850 0 0 {name=p135412 lab=_45798_/X }
C {devices/lab_pin.sym} 135940 -7810 0 0 {name=p135413 lab=_45743_/X }
C {devices/lab_pin.sym} 136100 -7850 0 1 {name=p135414 lab=_45815_/X }
C {sky130_stdcells/o21a_4.sym} 136020 -7850 0 0 {name=X_45815_ }
C {devices/lab_pin.sym} 135960 -7720 0 0 {name=p135415 lab=_76635_/A }
C {devices/lab_pin.sym} 135960 -7680 0 0 {name=p135416 lab=_76634_/Y }
C {devices/lab_pin.sym} 136080 -7700 0 1 {name=p135417 lab=_76635_/X }
C {sky130_stdcells/xor2_4.sym} 136020 -7700 0 0 {name=X_76635_ }
C {devices/lab_pin.sym} 135980 -7570 0 0 {name=p135418 lab=_84881_/Q }
C {devices/lab_pin.sym} 136060 -7570 0 1 {name=p135419 lab=_61861_/X }
C {sky130_stdcells/buf_2.sym} 136020 -7570 0 0 {name=X_61861_ }
C {devices/lab_pin.sym} 135960 -7480 0 0 {name=p135420 lab=_49571_/X }
C {devices/lab_pin.sym} 135960 -7440 0 0 {name=p135421 lab=_49561_/B }
C {devices/lab_pin.sym} 135960 -7400 0 0 {name=p135422 lab=_49577_/C }
C {devices/lab_pin.sym} 135960 -7360 0 0 {name=p135423 lab=_52797_/D }
C {devices/lab_pin.sym} 136080 -7420 0 1 {name=p135424 lab=_49583_/X }
C {sky130_stdcells/and4_4.sym} 136020 -7420 0 0 {name=X_49583_ }
C {devices/lab_pin.sym} 135940 -7290 0 0 {name=p135425 lab=_73843_/X }
C {devices/lab_pin.sym} 135940 -7250 0 0 {name=p135426 lab=_73846_/X }
C {devices/lab_pin.sym} 135940 -7210 0 0 {name=p135427 lab=_73799_/X }
C {devices/lab_pin.sym} 136100 -7250 0 1 {name=p135428 lab=_73866_/B }
C {sky130_stdcells/a21o_4.sym} 136020 -7250 0 0 {name=X_73847_ }
C {devices/lab_pin.sym} 135980 -7110 0 0 {name=p135429 lab=_52677_/B }
C {devices/lab_pin.sym} 136060 -7110 0 1 {name=p135430 lab=_50987_/B }
C {sky130_stdcells/buf_2.sym} 136020 -7110 0 0 {name=X_46795_ }
C {devices/lab_pin.sym} 135980 -6990 0 0 {name=p135431 lab=_63478_/A }
C {devices/lab_pin.sym} 136060 -6990 0 1 {name=p135432 lab=_63600_/X }
C {sky130_stdcells/buf_2.sym} 136020 -6990 0 0 {name=X_63600_ }
C {devices/lab_pin.sym} 135940 -6890 0 0 {name=p135433 lab=_60732_/C }
C {devices/lab_pin.sym} 135940 -6850 0 0 {name=p135434 lab=_60711_/X }
C {devices/lab_pin.sym} 135940 -6810 0 0 {name=p135435 lab=_60722_/A }
C {devices/lab_pin.sym} 136100 -6850 0 1 {name=p135436 lab=_60812_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -6850 0 0 {name=X_60812_ }
C {devices/lab_pin.sym} 135940 -6730 0 0 {name=p135437 lab=_48528_/Y }
C {devices/lab_pin.sym} 135940 -6690 0 0 {name=p135438 lab=_48517_/X }
C {devices/lab_pin.sym} 135940 -6650 0 0 {name=p135439 lab=_48533_/X }
C {devices/lab_pin.sym} 136100 -6690 0 1 {name=p135440 lab=_86514_/D }
C {sky130_stdcells/a21oi_4.sym} 136020 -6690 0 0 {name=X_48534_ }
C {devices/lab_pin.sym} 135960 -6560 0 0 {name=p135441 lab=_79350_/X }
C {devices/lab_pin.sym} 135960 -6520 0 0 {name=p135442 lab=_79353_/Y }
C {devices/lab_pin.sym} 136080 -6540 0 1 {name=p135443 lab=_79354_/X }
C {sky130_stdcells/xor2_4.sym} 136020 -6540 0 0 {name=X_79354_ }
C {devices/lab_pin.sym} 135960 -6420 0 0 {name=p135444 lab=_74679_/B }
C {devices/lab_pin.sym} 135960 -6380 0 0 {name=p135445 lab=_45746_/B }
C {devices/lab_pin.sym} 136080 -6400 0 1 {name=p135446 lab=_45746_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -6400 0 0 {name=X_45746_ }
C {devices/lab_pin.sym} 135960 -6280 0 0 {name=p135447 lab=_64621_/A }
C {devices/lab_pin.sym} 135960 -6240 0 0 {name=p135448 lab=_64580_/B }
C {devices/lab_pin.sym} 136080 -6260 0 1 {name=p135449 lab=_64580_/X }
C {sky130_stdcells/and2_4.sym} 136020 -6260 0 0 {name=X_64580_ }
C {devices/lab_pin.sym} 135960 -6140 0 0 {name=p135450 lab=_76566_/A }
C {devices/lab_pin.sym} 135960 -6100 0 0 {name=p135451 lab=_76584_/D }
C {devices/lab_pin.sym} 136080 -6120 0 1 {name=p135452 lab=_76566_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -6120 0 0 {name=X_76566_ }
C {devices/lab_pin.sym} 135940 -6020 0 0 {name=p135453 lab=_40391_/X }
C {devices/lab_pin.sym} 135940 -5980 0 0 {name=p135454 lab=_42950_/X }
C {devices/lab_pin.sym} 135940 -5940 0 0 {name=p135455 lab=_66676_/B }
C {devices/lab_pin.sym} 135940 -5900 0 0 {name=p135456 lab=_42951_/X }
C {devices/lab_pin.sym} 136100 -5960 0 1 {name=p135457 lab=_87631_/D }
C {sky130_stdcells/a2bb2o_4.sym} 136020 -5960 0 0 {name=X_42958_ }
C {devices/lab_pin.sym} 135940 -5850 0 0 {name=p135458 lab=_58232_/X }
C {devices/lab_pin.sym} 135940 -5810 0 0 {name=p135459 lab=_61728_/X }
C {devices/lab_pin.sym} 135940 -5770 0 0 {name=p135460 lab=_61756_/X }
C {devices/lab_pin.sym} 135940 -5730 0 0 {name=p135461 lab=_61790_/X }
C {devices/lab_pin.sym} 135940 -5700 0 0 {name=p135462 lab=_61791_/X }
C {devices/lab_pin.sym} 136100 -5770 0 1 {name=p135463 lab=_61792_/X }
C {sky130_stdcells/a41o_4.sym} 136020 -5770 0 0 {name=X_61792_ }
C {devices/lab_pin.sym} 135940 -5630 0 0 {name=p135464 lab=_68595_/B }
C {devices/lab_pin.sym} 135940 -5590 0 0 {name=p135465 lab=_73777_/X }
C {devices/lab_pin.sym} 135940 -5550 0 0 {name=p135466 lab=_73656_/X }
C {devices/lab_pin.sym} 136100 -5590 0 1 {name=p135467 lab=_73778_/X }
C {sky130_stdcells/o21a_4.sym} 136020 -5590 0 0 {name=X_73778_ }
C {devices/lab_pin.sym} 135960 -5460 0 0 {name=p135468 lab=_78305_/A }
C {devices/lab_pin.sym} 135960 -5420 0 0 {name=p135469 lab=_78304_/Y }
C {devices/lab_pin.sym} 136080 -5440 0 1 {name=p135470 lab=_78309_/A }
C {sky130_stdcells/nand2_4.sym} 136020 -5440 0 0 {name=X_78305_ }
C {devices/lab_pin.sym} 135940 -5330 0 0 {name=p135471 lab=_63527_/Y }
C {devices/lab_pin.sym} 135940 -5290 0 0 {name=p135472 lab=_63516_/X }
C {devices/lab_pin.sym} 135940 -5250 0 0 {name=p135473 lab=_63530_/Y }
C {devices/lab_pin.sym} 136100 -5290 0 1 {name=p135474 lab=_63531_/Y }
C {sky130_stdcells/a21oi_4.sym} 136020 -5290 0 0 {name=X_63531_ }
C {devices/lab_pin.sym} 135960 -5160 0 0 {name=p135475 lab=_80703_/Q }
C {devices/lab_pin.sym} 135960 -5120 0 0 {name=p135476 lab=_80959_/D }
C {devices/lab_pin.sym} 136080 -5140 0 1 {name=p135477 lab=_75517_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -5140 0 0 {name=X_75517_ }
C {devices/lab_pin.sym} 135940 -5030 0 0 {name=p135478 lab=_46450_/A }
C {devices/lab_pin.sym} 135940 -4990 0 0 {name=p135479 lab=_50256_/A }
C {devices/lab_pin.sym} 135940 -4950 0 0 {name=p135480 lab=_41909_/B1 }
C {devices/lab_pin.sym} 136100 -4990 0 1 {name=p135481 lab=_41909_/Y }
C {sky130_stdcells/a21oi_4.sym} 136020 -4990 0 0 {name=X_41909_ }
C {devices/lab_pin.sym} 135960 -4870 0 0 {name=p135482 lab=_50443_/A }
C {devices/lab_pin.sym} 135960 -4830 0 0 {name=p135483 lab=_48489_/B }
C {devices/lab_pin.sym} 135960 -4790 0 0 {name=p135484 lab=_48476_/C }
C {devices/lab_pin.sym} 136080 -4830 0 1 {name=p135485 lab=_48465_/X }
C {sky130_stdcells/and3_4.sym} 136020 -4830 0 0 {name=X_48465_ }
C {devices/lab_pin.sym} 135940 -4710 0 0 {name=p135486 lab=_60694_/B }
C {devices/lab_pin.sym} 135940 -4670 0 0 {name=p135487 lab=_60739_/X }
C {devices/lab_pin.sym} 135940 -4630 0 0 {name=p135488 lab=_63648_/B }
C {devices/lab_pin.sym} 136100 -4670 0 1 {name=p135489 lab=_60743_/X }
C {sky130_stdcells/o21a_4.sym} 136020 -4670 0 0 {name=X_60743_ }
C {devices/lab_pin.sym} 135940 -4560 0 0 {name=p135490 lab=_41980_/Y }
C {devices/lab_pin.sym} 135940 -4520 0 0 {name=p135491 lab=_72723_/X }
C {devices/lab_pin.sym} 135940 -4480 0 0 {name=p135492 lab=_72725_/X }
C {devices/lab_pin.sym} 135940 -4440 0 0 {name=p135493 lab=_72728_/Y }
C {devices/lab_pin.sym} 136100 -4500 0 1 {name=p135494 lab=_72729_/X }
C {sky130_stdcells/a211o_4.sym} 136020 -4500 0 0 {name=X_72729_ }
C {devices/lab_pin.sym} 135960 -4360 0 0 {name=p135495 lab=_79278_/X }
C {devices/lab_pin.sym} 135960 -4320 0 0 {name=p135496 lab=_79285_/B }
C {devices/lab_pin.sym} 136080 -4340 0 1 {name=p135497 lab=_79285_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -4340 0 0 {name=X_79285_ }
C {devices/lab_pin.sym} 135940 -4230 0 0 {name=p135498 lab=_85039_/Q }
C {devices/lab_pin.sym} 135940 -4190 0 0 {name=p135499 lab=_45675_/X }
C {devices/lab_pin.sym} 135940 -4150 0 0 {name=p135500 lab=_45676_/X }
C {devices/lab_pin.sym} 136100 -4190 0 1 {name=p135501 lab=_45677_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -4190 0 0 {name=X_45677_ }
C {devices/lab_pin.sym} 135960 -4060 0 0 {name=p135502 lab=_76513_/B }
C {devices/lab_pin.sym} 135960 -4020 0 0 {name=p135503 lab=_76513_/D }
C {devices/lab_pin.sym} 136080 -4040 0 1 {name=p135504 lab=_76497_/X }
C {sky130_stdcells/and2_4.sym} 136020 -4040 0 0 {name=X_76497_ }
C {devices/lab_pin.sym} 135940 -3950 0 0 {name=p135505 lab=_42874_/X }
C {devices/lab_pin.sym} 135940 -3910 0 0 {name=p135506 lab=_42875_/X }
C {devices/lab_pin.sym} 135940 -3870 0 0 {name=p135507 lab=_41631_/X }
C {devices/lab_pin.sym} 135940 -3830 0 0 {name=p135508 lab=_87667_/Q }
C {devices/lab_pin.sym} 135940 -3790 0 0 {name=p135509 lab=_42881_/X }
C {devices/lab_pin.sym} 136100 -3870 0 1 {name=p135510 lab=_42889_/Y }
C {sky130_stdcells/o32ai_4.sym} 136020 -3870 0 0 {name=X_42889_ }
C {devices/lab_pin.sym} 135980 -3710 0 0 {name=p135511 lab=_81805_/Q }
C {devices/lab_pin.sym} 136060 -3710 0 1 {name=p135512 lab=_47417_/A }
C {sky130_stdcells/inv_2.sym} 136020 -3710 0 0 {name=X_47416_ }
C {devices/lab_pin.sym} 135940 -3620 0 0 {name=p135513 lab=_66125_/X }
C {devices/lab_pin.sym} 135940 -3580 0 0 {name=p135514 lab=_86217_/Q }
C {devices/lab_pin.sym} 135940 -3540 0 0 {name=p135515 lab=_66180_/X }
C {devices/lab_pin.sym} 135940 -3500 0 0 {name=p135516 lab=_66249_/X }
C {devices/lab_pin.sym} 136100 -3560 0 1 {name=p135517 lab=_66250_/X }
C {sky130_stdcells/a211o_4.sym} 136020 -3560 0 0 {name=X_66250_ }
C {devices/lab_pin.sym} 135960 -3420 0 0 {name=p135518 lab=_82583_/Q }
C {devices/lab_pin.sym} 135960 -3380 0 0 {name=p135519 lab=_82495_/Q }
C {devices/lab_pin.sym} 136080 -3400 0 1 {name=p135520 lab=_78236_/Y }
C {sky130_stdcells/nand2_4.sym} 136020 -3400 0 0 {name=X_78236_ }
C {devices/lab_pin.sym} 135940 -3310 0 0 {name=p135521 lab=_44622_/X }
C {devices/lab_pin.sym} 135940 -3270 0 0 {name=p135522 lab=_44623_/X }
C {devices/lab_pin.sym} 135940 -3230 0 0 {name=p135523 lab=_41003_/X }
C {devices/lab_pin.sym} 135940 -3190 0 0 {name=p135524 lab=_87027_/Q }
C {devices/lab_pin.sym} 135940 -3150 0 0 {name=p135525 lab=_44625_/X }
C {devices/lab_pin.sym} 136100 -3230 0 1 {name=p135526 lab=_44628_/Y }
C {sky130_stdcells/o32ai_4.sym} 136020 -3230 0 0 {name=X_44628_ }
C {devices/lab_pin.sym} 135960 -3080 0 0 {name=p135527 lab=_63488_/A }
C {devices/lab_pin.sym} 135960 -3040 0 0 {name=p135528 lab=_61861_/X }
C {devices/lab_pin.sym} 136080 -3060 0 1 {name=p135529 lab=_63462_/X }
C {sky130_stdcells/and2_4.sym} 136020 -3060 0 0 {name=X_63462_ }
C {devices/lab_pin.sym} 135960 -2940 0 0 {name=p135530 lab=_75446_/X }
C {devices/lab_pin.sym} 135960 -2900 0 0 {name=p135531 lab=_75448_/B }
C {devices/lab_pin.sym} 136080 -2920 0 1 {name=p135532 lab=_75467_/A }
C {sky130_stdcells/and2_4.sym} 136020 -2920 0 0 {name=X_75448_ }
C {devices/lab_pin.sym} 135980 -2790 0 0 {name=p135533 lab=_74381_/A }
C {devices/lab_pin.sym} 136060 -2790 0 1 {name=p135534 lab=_53636_/A }
C {sky130_stdcells/buf_2.sym} 136020 -2790 0 0 {name=X_48396_ }
C {devices/lab_pin.sym} 135980 -2670 0 0 {name=p135535 lab=_60660_/A }
C {devices/lab_pin.sym} 136060 -2670 0 1 {name=p135536 lab=_60804_/B }
C {sky130_stdcells/buf_2.sym} 136020 -2670 0 0 {name=X_60674_ }
C {devices/lab_pin.sym} 135960 -2560 0 0 {name=p135537 lab=_65225_/A }
C {devices/lab_pin.sym} 135960 -2520 0 0 {name=p135538 lab=_85834_/Q }
C {devices/lab_pin.sym} 136080 -2540 0 1 {name=p135539 lab=_65201_/X }
C {sky130_stdcells/and2_4.sym} 136020 -2540 0 0 {name=X_65201_ }
C {devices/lab_pin.sym} 135960 -2430 0 0 {name=p135540 lab=_62411_/X }
C {devices/lab_pin.sym} 135960 -2390 0 0 {name=p135541 lab=_62412_/X }
C {devices/lab_pin.sym} 135960 -2350 0 0 {name=p135542 lab=_84412_/Q }
C {devices/lab_pin.sym} 136080 -2390 0 1 {name=p135543 lab=_62413_/Y }
C {sky130_stdcells/nor3_4.sym} 136020 -2390 0 0 {name=X_62413_ }
C {devices/lab_pin.sym} 135980 -2250 0 0 {name=p135544 lab=_81812_/Q }
C {devices/lab_pin.sym} 136060 -2250 0 1 {name=p135545 lab=_47348_/A }
C {sky130_stdcells/inv_2.sym} 136020 -2250 0 0 {name=X_47347_ }
C {devices/lab_pin.sym} 135960 -2140 0 0 {name=p135546 lab=_66181_/A }
C {devices/lab_pin.sym} 135960 -2100 0 0 {name=p135547 lab=_85902_/Q }
C {devices/lab_pin.sym} 136080 -2120 0 1 {name=p135548 lab=_66181_/X }
C {sky130_stdcells/and2_4.sym} 136020 -2120 0 0 {name=X_66181_ }
C {devices/lab_pin.sym} 135960 -2000 0 0 {name=p135549 lab=_78167_/A }
C {devices/lab_pin.sym} 135960 -1960 0 0 {name=p135550 lab=_78166_/Y }
C {devices/lab_pin.sym} 136080 -1980 0 1 {name=p135551 lab=_78168_/B }
C {sky130_stdcells/xor2_4.sym} 136020 -1980 0 0 {name=X_78167_ }
C {devices/lab_pin.sym} 135940 -1890 0 0 {name=p135552 lab=_44547_/X }
C {devices/lab_pin.sym} 135940 -1850 0 0 {name=p135553 lab=_44548_/X }
C {devices/lab_pin.sym} 135940 -1810 0 0 {name=p135554 lab=_40849_/X }
C {devices/lab_pin.sym} 135940 -1770 0 0 {name=p135555 lab=_87055_/Q }
C {devices/lab_pin.sym} 135940 -1730 0 0 {name=p135556 lab=_44549_/X }
C {devices/lab_pin.sym} 136100 -1810 0 1 {name=p135557 lab=_44560_/A }
C {sky130_stdcells/o32ai_4.sym} 136020 -1810 0 0 {name=X_44559_ }
C {devices/lab_pin.sym} 135940 -1670 0 0 {name=p135558 lab=_63390_/Y }
C {devices/lab_pin.sym} 135940 -1630 0 0 {name=p135559 lab=_63391_/X }
C {devices/lab_pin.sym} 135940 -1590 0 0 {name=p135560 lab=_63392_/Y }
C {devices/lab_pin.sym} 136100 -1630 0 1 {name=p135561 lab=_63393_/Y }
C {sky130_stdcells/a21oi_4.sym} 136020 -1630 0 0 {name=X_63393_ }
C {devices/lab_pin.sym} 135940 -1510 0 0 {name=p135562 lab=_75375_/Y }
C {devices/lab_pin.sym} 135940 -1470 0 0 {name=p135563 lab=_75377_/Y }
C {devices/lab_pin.sym} 135940 -1430 0 0 {name=p135564 lab=_75378_/Y }
C {devices/lab_pin.sym} 136100 -1470 0 1 {name=p135565 lab=_75383_/B }
C {sky130_stdcells/o21a_4.sym} 136020 -1470 0 0 {name=X_75379_ }
C {devices/lab_pin.sym} 135960 -1340 0 0 {name=p135566 lab=_65002_/A }
C {devices/lab_pin.sym} 135960 -1300 0 0 {name=p135567 lab=_86253_/Q }
C {devices/lab_pin.sym} 136080 -1320 0 1 {name=p135568 lab=_65132_/X }
C {sky130_stdcells/and2_4.sym} 136020 -1320 0 0 {name=X_65132_ }
C {devices/lab_pin.sym} 135960 -1200 0 0 {name=p135569 lab=_77118_/A }
C {devices/lab_pin.sym} 135960 -1160 0 0 {name=p135570 lab=_77118_/B }
C {devices/lab_pin.sym} 136080 -1180 0 1 {name=p135571 lab=_77118_/X }
C {sky130_stdcells/xor2_4.sym} 136020 -1180 0 0 {name=X_77118_ }
C {devices/lab_pin.sym} 135980 -1050 0 0 {name=p135572 lab=_62269_/A }
C {devices/lab_pin.sym} 136060 -1050 0 1 {name=p135573 lab=_62344_/X }
C {sky130_stdcells/buf_2.sym} 136020 -1050 0 0 {name=X_62344_ }
C {devices/lab_pin.sym} 135980 -930 0 0 {name=p135574 lab=_54125_/B }
C {devices/lab_pin.sym} 136060 -930 0 1 {name=p135575 lab=_52959_/B }
C {sky130_stdcells/buf_2.sym} 136020 -930 0 0 {name=X_47278_ }
C {devices/lab_pin.sym} 135980 -810 0 0 {name=p135576 lab=_78087_/Y }
C {devices/lab_pin.sym} 136060 -810 0 1 {name=p135577 lab=_78098_/Y }
C {sky130_stdcells/inv_2.sym} 136020 -810 0 0 {name=X_78098_ }
C {devices/lab_pin.sym} 135940 -710 0 0 {name=p135578 lab=_64951_/B }
C {devices/lab_pin.sym} 135940 -670 0 0 {name=p135579 lab=_49003_/X }
C {devices/lab_pin.sym} 135940 -630 0 0 {name=p135580 lab=_49016_/Y }
C {devices/lab_pin.sym} 136100 -670 0 1 {name=p135581 lab=_49017_/Y }
C {sky130_stdcells/o21ai_4.sym} 136020 -670 0 0 {name=X_49017_ }
C {devices/lab_pin.sym} 136860 -42190 0 0 {name=p135582 lab=_40335_/B }
C {devices/lab_pin.sym} 136860 -42150 0 0 {name=p135583 lab=_46091_/Y }
C {devices/lab_pin.sym} 136860 -42110 0 0 {name=p135584 lab=_46162_/A }
C {devices/lab_pin.sym} 136860 -42070 0 0 {name=p135585 lab=_46096_/D }
C {devices/lab_pin.sym} 136860 -42040 0 0 {name=p135586 lab=_46228_/Y }
C {devices/lab_pin.sym} 137020 -42110 0 1 {name=p135587 lab=_46229_/Y }
C {sky130_stdcells/a41oi_4.sym} 136940 -42110 0 0 {name=X_46229_ }
C {devices/lab_pin.sym} 136860 -41970 0 0 {name=p135588 lab=_69525_/X }
C {devices/lab_pin.sym} 136860 -41930 0 0 {name=p135589 lab=_69527_/X }
C {devices/lab_pin.sym} 136860 -41890 0 0 {name=p135590 lab=_69939_/X }
C {devices/lab_pin.sym} 137020 -41930 0 1 {name=p135591 lab=_69940_/Y }
C {sky130_stdcells/a21oi_4.sym} 136940 -41930 0 0 {name=X_69940_ }
C {devices/lab_pin.sym} 136860 -41810 0 0 {name=p135592 lab=_65058_/X }
C {devices/lab_pin.sym} 136860 -41770 0 0 {name=p135593 lab=_65062_/X }
C {devices/lab_pin.sym} 136860 -41730 0 0 {name=p135594 lab=_64989_/X }
C {devices/lab_pin.sym} 137020 -41770 0 1 {name=p135595 lab=_65063_/X }
C {sky130_stdcells/a21o_4.sym} 136940 -41770 0 0 {name=X_65063_ }
C {devices/lab_pin.sym} 136880 -41640 0 0 {name=p135596 lab=_82089_/Q }
C {devices/lab_pin.sym} 136880 -41600 0 0 {name=p135597 lab=_77049_/B }
C {devices/lab_pin.sym} 137000 -41620 0 1 {name=p135598 lab=_77049_/X }
C {sky130_stdcells/xor2_4.sym} 136940 -41620 0 0 {name=X_77049_ }
C {devices/lab_pin.sym} 136880 -41520 0 0 {name=p135599 lab=_62362_/A }
C {devices/lab_pin.sym} 136880 -41480 0 0 {name=p135600 lab=_62272_/Y }
C {devices/lab_pin.sym} 136880 -41440 0 0 {name=p135601 lab=_62273_/Y }
C {devices/lab_pin.sym} 136880 -41400 0 0 {name=p135602 lab=_62274_/Y }
C {devices/lab_pin.sym} 137000 -41460 0 1 {name=p135603 lab=_62275_/Y }
C {sky130_stdcells/nand4_4.sym} 136940 -41460 0 0 {name=X_62275_ }
C {devices/lab_pin.sym} 136900 -41310 0 0 {name=p135604 lab=_60879_/B }
C {devices/lab_pin.sym} 136980 -41310 0 1 {name=p135605 lab=_64029_/C }
C {sky130_stdcells/buf_2.sym} 136940 -41310 0 0 {name=X_64014_ }
C {devices/lab_pin.sym} 136900 -41190 0 0 {name=p135606 lab=_64419_/B }
C {devices/lab_pin.sym} 136980 -41190 0 1 {name=p135607 lab=_61226_/X }
C {sky130_stdcells/buf_2.sym} 136940 -41190 0 0 {name=X_61226_ }
C {devices/lab_pin.sym} 136880 -41080 0 0 {name=p135608 lab=_84663_/Q }
C {devices/lab_pin.sym} 136880 -41040 0 0 {name=p135609 lab=_64037_/C }
C {devices/lab_pin.sym} 137000 -41060 0 1 {name=p135610 lab=_80060_/X }
C {sky130_stdcells/xor2_4.sym} 136940 -41060 0 0 {name=X_80060_ }
C {devices/lab_pin.sym} 136880 -40940 0 0 {name=p135611 lab=_64615_/A }
C {devices/lab_pin.sym} 136880 -40900 0 0 {name=p135612 lab=_42604_/Y }
C {devices/lab_pin.sym} 137000 -40920 0 1 {name=p135613 lab=_69871_/Y }
C {sky130_stdcells/nor2_4.sym} 136940 -40920 0 0 {name=X_69871_ }
C {devices/lab_pin.sym} 136880 -40800 0 0 {name=p135614 lab=_68817_/X }
C {devices/lab_pin.sym} 136880 -40760 0 0 {name=p135615 lab=_68821_/X }
C {devices/lab_pin.sym} 137000 -40780 0 1 {name=p135616 lab=_68822_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -40780 0 0 {name=X_68822_ }
C {devices/lab_pin.sym} 136880 -40670 0 0 {name=p135617 lab=_61165_/A }
C {devices/lab_pin.sym} 136880 -40630 0 0 {name=p135618 lab=_61138_/B }
C {devices/lab_pin.sym} 136880 -40590 0 0 {name=p135619 lab=_84517_/Q }
C {devices/lab_pin.sym} 137000 -40630 0 1 {name=p135620 lab=_61157_/Y }
C {sky130_stdcells/nor3_4.sym} 136940 -40630 0 0 {name=X_61157_ }
C {devices/lab_pin.sym} 136860 -40530 0 0 {name=p135621 lab=_60078_/X }
C {devices/lab_pin.sym} 136860 -40490 0 0 {name=p135622 lab=_60079_/Y }
C {devices/lab_pin.sym} 136860 -40450 0 0 {name=p135623 lab=_59962_/A }
C {devices/lab_pin.sym} 136860 -40410 0 0 {name=p135624 lab=_60100_/Y }
C {devices/lab_pin.sym} 136860 -40380 0 0 {name=p135625 lab=_60107_/Y }
C {devices/lab_pin.sym} 137020 -40450 0 1 {name=p135626 lab=_60108_/Y }
C {sky130_stdcells/a41oi_4.sym} 136940 -40450 0 0 {name=X_60108_ }
C {devices/lab_pin.sym} 136860 -40310 0 0 {name=p135627 lab=_72192_/B }
C {devices/lab_pin.sym} 136860 -40270 0 0 {name=p135628 lab=_49906_/X }
C {devices/lab_pin.sym} 136860 -40230 0 0 {name=p135629 lab=_49918_/Y }
C {devices/lab_pin.sym} 137020 -40270 0 1 {name=p135630 lab=_49919_/Y }
C {sky130_stdcells/o21ai_4.sym} 136940 -40270 0 0 {name=X_49919_ }
C {devices/lab_pin.sym} 136900 -40130 0 0 {name=p135631 lab=_67816_/A }
C {devices/lab_pin.sym} 136980 -40130 0 1 {name=p135632 lab=_69233_/A }
C {sky130_stdcells/buf_2.sym} 136940 -40130 0 0 {name=X_68753_ }
C {devices/lab_pin.sym} 136880 -40020 0 0 {name=p135633 lab=_57770_/A }
C {devices/lab_pin.sym} 136880 -39980 0 0 {name=p135634 lab=_86557_/Q }
C {devices/lab_pin.sym} 137000 -40000 0 1 {name=p135635 lab=_65965_/X }
C {sky130_stdcells/and2_4.sym} 136940 -40000 0 0 {name=X_65965_ }
C {devices/lab_pin.sym} 136900 -39870 0 0 {name=p135636 lab=_65044_/A }
C {devices/lab_pin.sym} 136980 -39870 0 1 {name=p135637 lab=_61414_/A }
C {sky130_stdcells/buf_2.sym} 136940 -39870 0 0 {name=X_61088_ }
C {devices/lab_pin.sym} 136860 -39780 0 0 {name=p135638 lab=_87460_/Q }
C {devices/lab_pin.sym} 136860 -39740 0 0 {name=p135639 lab=_67628_/X }
C {devices/lab_pin.sym} 136860 -39700 0 0 {name=p135640 lab=_67702_/X }
C {devices/lab_pin.sym} 136860 -39660 0 0 {name=p135641 lab=_67703_/X }
C {devices/lab_pin.sym} 137020 -39720 0 1 {name=p135642 lab=_67704_/X }
C {sky130_stdcells/a211o_4.sym} 136940 -39720 0 0 {name=X_67704_ }
C {devices/lab_pin.sym} 136900 -39570 0 0 {name=p135643 lab=clkbuf_4_2_1_CLK/A }
C {devices/lab_pin.sym} 136980 -39570 0 1 {name=p135644 lab=clkbuf_4_2_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 136940 -39570 0 0 {name=Xclkbuf_4_2_1_CLK }
C {devices/lab_pin.sym} 136900 -39450 0 0 {name=p135645 lab=_52903_/X }
C {devices/lab_pin.sym} 136980 -39450 0 1 {name=p135646 lab=_52944_/A }
C {sky130_stdcells/buf_2.sym} 136940 -39450 0 0 {name=X_52930_ }
C {devices/lab_pin.sym} 136880 -39340 0 0 {name=p135647 lab=_64767_/A }
C {devices/lab_pin.sym} 136880 -39300 0 0 {name=p135648 lab=_85813_/Q }
C {devices/lab_pin.sym} 137000 -39320 0 1 {name=p135649 lab=_64916_/X }
C {sky130_stdcells/and2_4.sym} 136940 -39320 0 0 {name=X_64916_ }
C {devices/lab_pin.sym} 136880 -39200 0 0 {name=p135650 lab=_59974_/Y }
C {devices/lab_pin.sym} 136880 -39160 0 0 {name=p135651 lab=_59951_/D }
C {devices/lab_pin.sym} 137000 -39180 0 1 {name=p135652 lab=_60049_/A }
C {sky130_stdcells/nand2_4.sym} 136940 -39180 0 0 {name=X_60039_ }
C {devices/lab_pin.sym} 136850 -39050 0 0 {name=p135653 lab=_83753_/CLK }
C {devices/lab_pin.sym} 136850 -39030 0 0 {name=p135654 lab=_70556_/X }
C {devices/lab_pin.sym} 137030 -39050 0 1 {name=p135655 lab=_83750_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -39040 0 0 {name=X_83750_ }
C {devices/lab_pin.sym} 136850 -38910 0 0 {name=p135656 lab=_80962_/CLK }
C {devices/lab_pin.sym} 136850 -38890 0 0 {name=p135657 lab=_80962_/D }
C {devices/lab_pin.sym} 137030 -38910 0 1 {name=p135658 lab=_80950_/D }
C {sky130_stdcells/dfxtp_4.sym} 136940 -38900 0 0 {name=X_80962_ }
C {devices/lab_pin.sym} 136900 -38770 0 0 {name=p135659 lab=_69035_/A }
C {devices/lab_pin.sym} 136980 -38770 0 1 {name=p135660 lab=_68684_/X }
C {sky130_stdcells/buf_2.sym} 136940 -38770 0 0 {name=X_68684_ }
C {devices/lab_pin.sym} 136880 -38660 0 0 {name=p135661 lab=_65896_/A }
C {devices/lab_pin.sym} 136880 -38620 0 0 {name=p135662 lab=_86498_/Q }
C {devices/lab_pin.sym} 137000 -38640 0 1 {name=p135663 lab=_65896_/X }
C {sky130_stdcells/and2_4.sym} 136940 -38640 0 0 {name=X_65896_ }
C {devices/lab_pin.sym} 136850 -38510 0 0 {name=p135664 lab=_81190_/CLK }
C {devices/lab_pin.sym} 136850 -38490 0 0 {name=p135665 lab=_78909_/X }
C {devices/lab_pin.sym} 137030 -38510 0 1 {name=p135666 lab=_78793_/A }
C {sky130_stdcells/dfxtp_4.sym} 136940 -38500 0 0 {name=X_82701_ }
C {devices/lab_pin.sym} 136860 -38400 0 0 {name=p135667 lab=_87155_/Q }
C {devices/lab_pin.sym} 136860 -38360 0 0 {name=p135668 lab=_67585_/X }
C {devices/lab_pin.sym} 136860 -38320 0 0 {name=p135669 lab=_67633_/X }
C {devices/lab_pin.sym} 136860 -38280 0 0 {name=p135670 lab=_67634_/X }
C {devices/lab_pin.sym} 137020 -38340 0 1 {name=p135671 lab=_67635_/X }
C {sky130_stdcells/a211o_4.sym} 136940 -38340 0 0 {name=X_67635_ }
C {devices/lab_pin.sym} 136880 -38220 0 0 {name=p135672 lab=_52853_/A }
C {devices/lab_pin.sym} 136880 -38180 0 0 {name=p135673 lab=_52853_/B }
C {devices/lab_pin.sym} 136880 -38140 0 0 {name=p135674 lab=_52853_/C }
C {devices/lab_pin.sym} 136880 -38100 0 0 {name=p135675 lab=_52861_/D }
C {devices/lab_pin.sym} 137000 -38160 0 1 {name=p135676 lab=_52861_/X }
C {sky130_stdcells/and4_4.sym} 136940 -38160 0 0 {name=X_52861_ }
C {devices/lab_pin.sym} 136900 -38010 0 0 {name=p135677 lab=_64616_/A }
C {devices/lab_pin.sym} 136980 -38010 0 1 {name=p135678 lab=_64948_/A }
C {sky130_stdcells/buf_2.sym} 136940 -38010 0 0 {name=X_64847_ }
C {devices/lab_pin.sym} 136850 -37890 0 0 {name=p135679 lab=_83681_/CLK }
C {devices/lab_pin.sym} 136850 -37870 0 0 {name=p135680 lab=_70861_/Y }
C {devices/lab_pin.sym} 137030 -37890 0 1 {name=p135681 lab=_83681_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -37880 0 0 {name=X_83681_ }
C {devices/lab_pin.sym} 136850 -37750 0 0 {name=p135682 lab=_80991_/CLK }
C {devices/lab_pin.sym} 136850 -37730 0 0 {name=p135683 lab=_75824_/Y }
C {devices/lab_pin.sym} 137030 -37750 0 1 {name=p135684 lab=_80893_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -37740 0 0 {name=X_80893_ }
C {devices/lab_pin.sym} 136880 -37620 0 0 {name=p135685 lab=_54600_/A }
C {devices/lab_pin.sym} 136880 -37580 0 0 {name=p135686 lab=_47195_/A }
C {devices/lab_pin.sym} 137000 -37600 0 1 {name=p135687 lab=_54600_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -37600 0 0 {name=X_54600_ }
C {devices/lab_pin.sym} 136850 -37470 0 0 {name=p135688 lab=_85645_/CLK }
C {devices/lab_pin.sym} 136850 -37450 0 0 {name=p135689 lab=_54560_/Y }
C {devices/lab_pin.sym} 137030 -37470 0 1 {name=p135690 lab=_85420_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -37460 0 0 {name=X_85420_ }
C {devices/lab_pin.sym} 136880 -37340 0 0 {name=p135691 lab=_51796_/A }
C {devices/lab_pin.sym} 136880 -37300 0 0 {name=p135692 lab=_51812_/B }
C {devices/lab_pin.sym} 137000 -37320 0 1 {name=p135693 lab=_51812_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -37320 0 0 {name=X_51812_ }
C {devices/lab_pin.sym} 136850 -37190 0 0 {name=p135694 lab=_87671_/CLK }
C {devices/lab_pin.sym} 136850 -37170 0 0 {name=p135695 lab=_82632_/D }
C {devices/lab_pin.sym} 137030 -37190 0 1 {name=p135696 lab=_78865_/B }
C {sky130_stdcells/dfxtp_4.sym} 136940 -37180 0 0 {name=X_82632_ }
C {devices/lab_pin.sym} 136880 -37060 0 0 {name=p135697 lab=_55580_/A }
C {devices/lab_pin.sym} 136880 -37020 0 0 {name=p135698 lab=_55580_/B }
C {devices/lab_pin.sym} 137000 -37040 0 1 {name=p135699 lab=_55580_/X }
C {sky130_stdcells/and2_4.sym} 136940 -37040 0 0 {name=X_55580_ }
C {devices/lab_pin.sym} 136860 -36940 0 0 {name=p135700 lab=_67522_/X }
C {devices/lab_pin.sym} 136860 -36900 0 0 {name=p135701 lab=_67555_/Y }
C {devices/lab_pin.sym} 136860 -36860 0 0 {name=p135702 lab=_67507_/X }
C {devices/lab_pin.sym} 136860 -36820 0 0 {name=p135703 lab=_67565_/Y }
C {devices/lab_pin.sym} 137020 -36880 0 1 {name=p135704 lab=_67566_/X }
C {sky130_stdcells/a211o_4.sym} 136940 -36880 0 0 {name=X_67566_ }
C {devices/lab_pin.sym} 136900 -36730 0 0 {name=p135705 lab=_52684_/A }
C {devices/lab_pin.sym} 136980 -36730 0 1 {name=p135706 lab=_52792_/X }
C {sky130_stdcells/buf_2.sym} 136940 -36730 0 0 {name=X_52792_ }
C {devices/lab_pin.sym} 136880 -36620 0 0 {name=p135707 lab=_64778_/A }
C {devices/lab_pin.sym} 136880 -36580 0 0 {name=p135708 lab=_85819_/Q }
C {devices/lab_pin.sym} 137000 -36600 0 1 {name=p135709 lab=_64778_/X }
C {sky130_stdcells/and2_4.sym} 136940 -36600 0 0 {name=X_64778_ }
C {devices/lab_pin.sym} 136880 -36480 0 0 {name=p135710 lab=_69305_/A }
C {devices/lab_pin.sym} 136880 -36440 0 0 {name=p135711 lab=_87271_/Q }
C {devices/lab_pin.sym} 137000 -36460 0 1 {name=p135712 lab=_69305_/X }
C {sky130_stdcells/and2_4.sym} 136940 -36460 0 0 {name=X_69305_ }
C {devices/lab_pin.sym} 136880 -36360 0 0 {name=p135713 lab=_54509_/A }
C {devices/lab_pin.sym} 136880 -36320 0 0 {name=p135714 lab=_54526_/B }
C {devices/lab_pin.sym} 136880 -36280 0 0 {name=p135715 lab=_54509_/C }
C {devices/lab_pin.sym} 136880 -36240 0 0 {name=p135716 lab=_47074_/A }
C {devices/lab_pin.sym} 137000 -36300 0 1 {name=p135717 lab=_54531_/X }
C {sky130_stdcells/and4_4.sym} 136940 -36300 0 0 {name=X_54531_ }
C {devices/lab_pin.sym} 136880 -36170 0 0 {name=p135718 lab=_66338_/X }
C {devices/lab_pin.sym} 136880 -36130 0 0 {name=p135719 lab=_66517_/B }
C {devices/lab_pin.sym} 136880 -36090 0 0 {name=p135720 lab=_66340_/X }
C {devices/lab_pin.sym} 137000 -36130 0 1 {name=p135721 lab=_66517_/Y }
C {sky130_stdcells/nand3_4.sym} 136940 -36130 0 0 {name=X_66517_ }
C {devices/lab_pin.sym} 136850 -35990 0 0 {name=p135722 lab=_85351_/CLK }
C {devices/lab_pin.sym} 136850 -35970 0 0 {name=p135723 lab=_85351_/D }
C {devices/lab_pin.sym} 137030 -35990 0 1 {name=p135724 lab=_85351_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -35980 0 0 {name=X_85351_ }
C {devices/lab_pin.sym} 136860 -35870 0 0 {name=p135725 lab=_51738_/Y }
C {devices/lab_pin.sym} 136860 -35830 0 0 {name=p135726 lab=_51719_/X }
C {devices/lab_pin.sym} 136860 -35790 0 0 {name=p135727 lab=_51742_/X }
C {devices/lab_pin.sym} 137020 -35830 0 1 {name=p135728 lab=_51743_/Y }
C {sky130_stdcells/a21oi_4.sym} 136940 -35830 0 0 {name=X_51743_ }
C {devices/lab_pin.sym} 136900 -35690 0 0 {name=p135729 lab=_60930_/C }
C {devices/lab_pin.sym} 136980 -35690 0 1 {name=p135730 lab=_64190_/D }
C {sky130_stdcells/buf_2.sym} 136940 -35690 0 0 {name=X_63729_ }
C {devices/lab_pin.sym} 136850 -35570 0 0 {name=p135731 lab=_82563_/CLK }
C {devices/lab_pin.sym} 136850 -35550 0 0 {name=p135732 lab=_82595_/Q }
C {devices/lab_pin.sym} 137030 -35570 0 1 {name=p135733 lab=_82563_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -35560 0 0 {name=X_82563_ }
C {devices/lab_pin.sym} 136880 -35440 0 0 {name=p135734 lab=_67497_/A }
C {devices/lab_pin.sym} 136880 -35400 0 0 {name=p135735 lab=_87660_/Q }
C {devices/lab_pin.sym} 137000 -35420 0 1 {name=p135736 lab=_67497_/X }
C {sky130_stdcells/and2_4.sym} 136940 -35420 0 0 {name=X_67497_ }
C {sky130_stdcells/decap_3.sym} 136940 -35260 0 0 {name=XPHY_14 }
C {sky130_stdcells/decap_3.sym} 136940 -35080 0 0 {name=XPHY_25 }
C {devices/lab_pin.sym} 136850 -34930 0 0 {name=p135737 lab=_84358_/CLK }
C {devices/lab_pin.sym} 136850 -34910 0 0 {name=p135738 lab=_63681_/Y }
C {devices/lab_pin.sym} 137030 -34930 0 1 {name=p135739 lab=_80323_/B }
C {sky130_stdcells/dfxtp_4.sym} 136940 -34920 0 0 {name=X_84302_ }
C {devices/lab_pin.sym} 136850 -34790 0 0 {name=p135740 lab=_81514_/CLK }
C {devices/lab_pin.sym} 136850 -34770 0 0 {name=p135741 lab=_81514_/D }
C {devices/lab_pin.sym} 137030 -34790 0 1 {name=p135742 lab=_81514_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -34780 0 0 {name=X_81514_ }
C {devices/lab_pin.sym} 136880 -34670 0 0 {name=p135743 lab=_56960_/X }
C {devices/lab_pin.sym} 136880 -34630 0 0 {name=p135744 lab=_85051_/Q }
C {devices/lab_pin.sym} 136880 -34590 0 0 {name=p135745 lab=_57249_/X }
C {devices/lab_pin.sym} 137000 -34630 0 1 {name=p135746 lab=_57250_/Y }
C {sky130_stdcells/nor3_4.sym} 136940 -34630 0 0 {name=X_57250_ }
C {devices/lab_pin.sym} 136880 -34500 0 0 {name=p135747 lab=_69236_/A }
C {devices/lab_pin.sym} 136880 -34460 0 0 {name=p135748 lab=_69236_/B }
C {devices/lab_pin.sym} 137000 -34480 0 1 {name=p135749 lab=_69236_/X }
C {sky130_stdcells/and2_4.sym} 136940 -34480 0 0 {name=X_69236_ }
C {sky130_stdcells/decap_3.sym} 136940 -34320 0 0 {name=XPHY_36 }
C {devices/lab_pin.sym} 136850 -34170 0 0 {name=p135750 lab=_87814_/CLK }
C {devices/lab_pin.sym} 136850 -34150 0 0 {name=p135751 lab=_42017_/Y }
C {devices/lab_pin.sym} 137030 -34170 0 1 {name=p135752 lab=_73106_/A }
C {sky130_stdcells/dfxtp_4.sym} 136940 -34160 0 0 {name=X_88070_ }
C {devices/lab_pin.sym} 136880 -34060 0 0 {name=p135753 lab=_54453_/X }
C {devices/lab_pin.sym} 136880 -34020 0 0 {name=p135754 lab=_54440_/B }
C {devices/lab_pin.sym} 136880 -33980 0 0 {name=p135755 lab=_54471_/C }
C {devices/lab_pin.sym} 136880 -33940 0 0 {name=p135756 lab=_46952_/A }
C {devices/lab_pin.sym} 137000 -34000 0 1 {name=p135757 lab=_54462_/X }
C {sky130_stdcells/and4_4.sym} 136940 -34000 0 0 {name=X_54462_ }
C {devices/lab_pin.sym} 136860 -33870 0 0 {name=p135758 lab=_60110_/X }
C {devices/lab_pin.sym} 136860 -33830 0 0 {name=p135759 lab=_65031_/Y }
C {devices/lab_pin.sym} 136860 -33790 0 0 {name=p135760 lab=_66447_/Y }
C {devices/lab_pin.sym} 137020 -33830 0 1 {name=p135761 lab=_66448_/Y }
C {sky130_stdcells/o21ai_4.sym} 136940 -33830 0 0 {name=X_66448_ }
C {devices/lab_pin.sym} 136850 -33690 0 0 {name=p135762 lab=_82979_/CLK }
C {devices/lab_pin.sym} 136850 -33670 0 0 {name=p135763 lab=_56178_/Y }
C {devices/lab_pin.sym} 137030 -33690 0 1 {name=p135764 lab=_55741_/B }
C {sky130_stdcells/dfxtp_4.sym} 136940 -33680 0 0 {name=X_85282_ }
C {devices/lab_pin.sym} 136860 -33570 0 0 {name=p135765 lab=_51672_/Y }
C {devices/lab_pin.sym} 136860 -33530 0 0 {name=p135766 lab=_51667_/X }
C {devices/lab_pin.sym} 136860 -33490 0 0 {name=p135767 lab=_51673_/X }
C {devices/lab_pin.sym} 137020 -33530 0 1 {name=p135768 lab=_85967_/D }
C {sky130_stdcells/a21oi_4.sym} 136940 -33530 0 0 {name=X_51674_ }
C {sky130_stdcells/decap_3.sym} 136940 -33360 0 0 {name=XPHY_47 }
C {devices/lab_pin.sym} 136850 -33210 0 0 {name=p135769 lab=_82503_/CLK }
C {devices/lab_pin.sym} 136850 -33190 0 0 {name=p135770 lab=_82494_/D }
C {devices/lab_pin.sym} 137030 -33210 0 1 {name=p135771 lab=_78228_/B }
C {sky130_stdcells/dfxtp_4.sym} 136940 -33200 0 0 {name=X_82494_ }
C {sky130_stdcells/decap_3.sym} 136940 -33040 0 0 {name=XPHY_58 }
C {sky130_stdcells/decap_3.sym} 136940 -32860 0 0 {name=XPHY_69 }
C {devices/lab_pin.sym} 136880 -32730 0 0 {name=p135772 lab=_56200_/X }
C {devices/lab_pin.sym} 136880 -32690 0 0 {name=p135773 lab=_56192_/B }
C {devices/lab_pin.sym} 136880 -32650 0 0 {name=p135774 lab=_85278_/Q }
C {devices/lab_pin.sym} 137000 -32690 0 1 {name=p135775 lab=_56201_/Y }
C {sky130_stdcells/nand3_4.sym} 136940 -32690 0 0 {name=X_56201_ }
C {devices/lab_pin.sym} 136850 -32550 0 0 {name=p135776 lab=_87026_/CLK }
C {devices/lab_pin.sym} 136850 -32530 0 0 {name=p135777 lab=_87021_/D }
C {devices/lab_pin.sym} 137030 -32550 0 1 {name=p135778 lab=_87021_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -32540 0 0 {name=X_87021_ }
C {devices/lab_pin.sym} 136860 -32430 0 0 {name=p135779 lab=_85638_/Q }
C {devices/lab_pin.sym} 136860 -32390 0 0 {name=p135780 lab=_53404_/X }
C {devices/lab_pin.sym} 136860 -32350 0 0 {name=p135781 lab=_53412_/Y }
C {devices/lab_pin.sym} 137020 -32390 0 1 {name=p135782 lab=_53413_/Y }
C {sky130_stdcells/o21ai_4.sym} 136940 -32390 0 0 {name=X_53413_ }
C {devices/lab_pin.sym} 136850 -32250 0 0 {name=p135783 lab=_85346_/CLK }
C {devices/lab_pin.sym} 136850 -32230 0 0 {name=p135784 lab=_64610_/X }
C {devices/lab_pin.sym} 137030 -32250 0 1 {name=p135785 lab=_84233_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -32240 0 0 {name=X_84233_ }
C {devices/lab_pin.sym} 136860 -32130 0 0 {name=p135786 lab=_50623_/Y }
C {devices/lab_pin.sym} 136860 -32090 0 0 {name=p135787 lab=_50619_/X }
C {devices/lab_pin.sym} 136860 -32050 0 0 {name=p135788 lab=_50624_/Y }
C {devices/lab_pin.sym} 137020 -32090 0 1 {name=p135789 lab=_86165_/D }
C {sky130_stdcells/a21boi_4.sym} 136940 -32090 0 0 {name=X_50625_ }
C {devices/lab_pin.sym} 136860 -31970 0 0 {name=p135790 lab=_56814_/A }
C {devices/lab_pin.sym} 136860 -31930 0 0 {name=p135791 lab=_57153_/B }
C {devices/lab_pin.sym} 136860 -31890 0 0 {name=p135792 lab=_57180_/Y }
C {devices/lab_pin.sym} 137020 -31930 0 1 {name=p135793 lab=_85067_/D }
C {sky130_stdcells/a21o_4.sym} 136940 -31930 0 0 {name=X_57181_ }
C {devices/lab_pin.sym} 136850 -31790 0 0 {name=p135794 lab=_81412_/CLK }
C {devices/lab_pin.sym} 136850 -31770 0 0 {name=p135795 lab=_81445_/D }
C {devices/lab_pin.sym} 137030 -31790 0 1 {name=p135796 lab=_81445_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -31780 0 0 {name=X_81445_ }
C {devices/lab_pin.sym} 136860 -31670 0 0 {name=p135797 lab=_69164_/X }
C {devices/lab_pin.sym} 136860 -31630 0 0 {name=p135798 lab=_69166_/X }
C {devices/lab_pin.sym} 136860 -31590 0 0 {name=p135799 lab=_69116_/X }
C {devices/lab_pin.sym} 137020 -31630 0 1 {name=p135800 lab=_69167_/X }
C {sky130_stdcells/a21o_4.sym} 136940 -31630 0 0 {name=X_69167_ }
C {devices/lab_pin.sym} 136860 -31510 0 0 {name=p135801 lab=_85450_/Q }
C {devices/lab_pin.sym} 136860 -31470 0 0 {name=p135802 lab=_54376_/X }
C {devices/lab_pin.sym} 136860 -31430 0 0 {name=p135803 lab=_54392_/Y }
C {devices/lab_pin.sym} 137020 -31470 0 1 {name=p135804 lab=_54393_/Y }
C {sky130_stdcells/o21ai_4.sym} 136940 -31470 0 0 {name=X_54393_ }
C {devices/lab_pin.sym} 136880 -31350 0 0 {name=p135805 lab=_66433_/A }
C {devices/lab_pin.sym} 136880 -31310 0 0 {name=p135806 lab=_66415_/B }
C {devices/lab_pin.sym} 136880 -31270 0 0 {name=p135807 lab=_84134_/Q }
C {devices/lab_pin.sym} 137000 -31310 0 1 {name=p135808 lab=_66379_/X }
C {sky130_stdcells/and3_4.sym} 136940 -31310 0 0 {name=X_66379_ }
C {devices/lab_pin.sym} 136860 -31190 0 0 {name=p135809 lab=_56112_/X }
C {devices/lab_pin.sym} 136860 -31150 0 0 {name=p135810 lab=_56130_/X }
C {devices/lab_pin.sym} 136860 -31110 0 0 {name=p135811 lab=_56131_/Y }
C {devices/lab_pin.sym} 137020 -31150 0 1 {name=p135812 lab=_85291_/D }
C {sky130_stdcells/o21ai_4.sym} 136940 -31150 0 0 {name=X_56132_ }
C {devices/lab_pin.sym} 136860 -31040 0 0 {name=p135813 lab=_68097_/X }
C {devices/lab_pin.sym} 136860 -31000 0 0 {name=p135814 lab=_66743_/Y }
C {devices/lab_pin.sym} 136860 -30960 0 0 {name=p135815 lab=_68110_/X }
C {devices/lab_pin.sym} 136860 -30920 0 0 {name=p135816 lab=_68117_/Y }
C {devices/lab_pin.sym} 137020 -30980 0 1 {name=p135817 lab=_68118_/X }
C {sky130_stdcells/a211o_4.sym} 136940 -30980 0 0 {name=X_68118_ }
C {devices/lab_pin.sym} 136860 -30850 0 0 {name=p135818 lab=_53342_/Y }
C {devices/lab_pin.sym} 136860 -30810 0 0 {name=p135819 lab=_53328_/X }
C {devices/lab_pin.sym} 136860 -30770 0 0 {name=p135820 lab=_53343_/X }
C {devices/lab_pin.sym} 137020 -30810 0 1 {name=p135821 lab=_53344_/Y }
C {sky130_stdcells/a21oi_4.sym} 136940 -30810 0 0 {name=X_53344_ }
C {devices/lab_pin.sym} 136850 -30670 0 0 {name=p135822 lab=_84166_/CLK }
C {devices/lab_pin.sym} 136850 -30650 0 0 {name=p135823 lab=_65989_/X }
C {devices/lab_pin.sym} 137030 -30670 0 1 {name=p135824 lab=_84164_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -30660 0 0 {name=X_84164_ }
C {devices/lab_pin.sym} 136880 -30540 0 0 {name=p135825 lab=_50556_/A }
C {devices/lab_pin.sym} 136880 -30500 0 0 {name=p135826 lab=_50556_/B }
C {devices/lab_pin.sym} 137000 -30520 0 1 {name=p135827 lab=_50556_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -30520 0 0 {name=X_50556_ }
C {devices/lab_pin.sym} 136850 -30390 0 0 {name=p135828 lab=_81473_/CLK }
C {devices/lab_pin.sym} 136850 -30370 0 0 {name=p135829 lab=_81376_/D }
C {devices/lab_pin.sym} 137030 -30390 0 1 {name=p135830 lab=_81376_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -30380 0 0 {name=X_81376_ }
C {devices/lab_pin.sym} 136900 -30250 0 0 {name=p135831 lab=_69607_/A }
C {devices/lab_pin.sym} 136980 -30250 0 1 {name=p135832 lab=_69098_/X }
C {sky130_stdcells/buf_2.sym} 136940 -30250 0 0 {name=X_69098_ }
C {devices/lab_pin.sym} 136900 -30130 0 0 {name=p135833 lab=clkbuf_9_230_0_CLK/X }
C {devices/lab_pin.sym} 136980 -30130 0 1 {name=p135834 lab=_85974_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 136940 -30130 0 0 {name=Xclkbuf_10_460_0_CLK }
C {devices/lab_pin.sym} 136850 -30010 0 0 {name=p135835 lab=_83115_/CLK }
C {devices/lab_pin.sym} 136850 -29990 0 0 {name=p135836 lab=_83115_/D }
C {devices/lab_pin.sym} 137030 -30010 0 1 {name=p135837 lab=_83115_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -30000 0 0 {name=X_83115_ }
C {devices/lab_pin.sym} 136880 -29880 0 0 {name=p135838 lab=_84750_/Q }
C {devices/lab_pin.sym} 136880 -29840 0 0 {name=p135839 lab=_84142_/Q }
C {devices/lab_pin.sym} 137000 -29860 0 1 {name=p135840 lab=_80327_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -29860 0 0 {name=X_80327_ }
C {devices/lab_pin.sym} 136880 -29740 0 0 {name=p135841 lab=_74312_/C }
C {devices/lab_pin.sym} 136880 -29700 0 0 {name=p135842 lab=_55997_/X }
C {devices/lab_pin.sym} 137000 -29720 0 1 {name=p135843 lab=_56063_/Y }
C {sky130_stdcells/xnor2_4.sym} 136940 -29720 0 0 {name=X_56063_ }
C {devices/lab_pin.sym} 136880 -29600 0 0 {name=p135844 lab=_68049_/A }
C {devices/lab_pin.sym} 136880 -29560 0 0 {name=p135845 lab=_68049_/B }
C {devices/lab_pin.sym} 137000 -29580 0 1 {name=p135846 lab=_68049_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -29580 0 0 {name=X_68049_ }
C {devices/lab_pin.sym} 136860 -29470 0 0 {name=p135847 lab=_53271_/Y }
C {devices/lab_pin.sym} 136860 -29430 0 0 {name=p135848 lab=_53272_/X }
C {devices/lab_pin.sym} 136860 -29390 0 0 {name=p135849 lab=_53274_/X }
C {devices/lab_pin.sym} 137020 -29430 0 1 {name=p135850 lab=_85664_/D }
C {sky130_stdcells/a21oi_4.sym} 136940 -29430 0 0 {name=X_53275_ }
C {devices/lab_pin.sym} 136850 -29290 0 0 {name=p135851 lab=_80928_/CLK }
C {devices/lab_pin.sym} 136850 -29270 0 0 {name=p135852 lab=_66827_/X }
C {devices/lab_pin.sym} 137030 -29290 0 1 {name=p135853 lab=_80919_/D }
C {sky130_stdcells/dfxtp_4.sym} 136940 -29280 0 0 {name=X_84095_ }
C {devices/lab_pin.sym} 136880 -29170 0 0 {name=p135854 lab=_52194_/A }
C {devices/lab_pin.sym} 136880 -29130 0 0 {name=p135855 lab=_50492_/B }
C {devices/lab_pin.sym} 136880 -29090 0 0 {name=p135856 lab=_50497_/C }
C {devices/lab_pin.sym} 137000 -29130 0 1 {name=p135857 lab=_50487_/X }
C {sky130_stdcells/and3_4.sym} 136940 -29130 0 0 {name=X_50487_ }
C {devices/lab_pin.sym} 136860 -29010 0 0 {name=p135858 lab=_55012_/Y }
C {devices/lab_pin.sym} 136860 -28970 0 0 {name=p135859 lab=_54998_/X }
C {devices/lab_pin.sym} 136860 -28930 0 0 {name=p135860 lab=_55013_/X }
C {devices/lab_pin.sym} 137020 -28970 0 1 {name=p135861 lab=_55014_/Y }
C {sky130_stdcells/a21oi_4.sym} 136940 -28970 0 0 {name=X_55014_ }
C {devices/lab_pin.sym} 136860 -28850 0 0 {name=p135862 lab=_85864_/Q }
C {devices/lab_pin.sym} 136860 -28810 0 0 {name=p135863 lab=_52214_/X }
C {devices/lab_pin.sym} 136860 -28770 0 0 {name=p135864 lab=_52225_/Y }
C {devices/lab_pin.sym} 137020 -28810 0 1 {name=p135865 lab=_52226_/Y }
C {sky130_stdcells/o21ai_4.sym} 136940 -28810 0 0 {name=X_52226_ }
C {devices/lab_pin.sym} 136880 -28690 0 0 {name=p135866 lab=_71058_/A }
C {devices/lab_pin.sym} 136880 -28650 0 0 {name=p135867 lab=_71082_/B }
C {devices/lab_pin.sym} 136880 -28610 0 0 {name=p135868 lab=_71055_/C }
C {devices/lab_pin.sym} 137000 -28650 0 1 {name=p135869 lab=_71060_/Y }
C {sky130_stdcells/nand3_4.sym} 136940 -28650 0 0 {name=X_71060_ }
C {devices/lab_pin.sym} 136850 -28510 0 0 {name=p135870 lab=_83046_/CLK }
C {devices/lab_pin.sym} 136850 -28490 0 0 {name=p135871 lab=_74526_/Y }
C {devices/lab_pin.sym} 137030 -28510 0 1 {name=p135872 lab=_83046_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -28500 0 0 {name=X_83046_ }
C {devices/lab_pin.sym} 136850 -28370 0 0 {name=p135873 lab=_87671_/CLK }
C {devices/lab_pin.sym} 136850 -28350 0 0 {name=p135874 lab=_42322_/Y }
C {devices/lab_pin.sym} 137030 -28370 0 1 {name=p135875 lab=_87923_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -28360 0 0 {name=X_87923_ }
C {devices/lab_pin.sym} 136900 -28230 0 0 {name=p135876 lab=_80257_/Y }
C {devices/lab_pin.sym} 136980 -28230 0 1 {name=p135877 lab=_80259_/B }
C {sky130_stdcells/inv_2.sym} 136940 -28230 0 0 {name=X_80258_ }
C {devices/lab_pin.sym} 136900 -28110 0 0 {name=p135878 lab=_68823_/A }
C {devices/lab_pin.sym} 136980 -28110 0 1 {name=p135879 lab=_70011_/X }
C {sky130_stdcells/buf_2.sym} 136940 -28110 0 0 {name=X_70011_ }
C {devices/lab_pin.sym} 136900 -27990 0 0 {name=p135880 lab=_59756_/A }
C {devices/lab_pin.sym} 136980 -27990 0 1 {name=p135881 lab=_59822_/X }
C {sky130_stdcells/buf_2.sym} 136940 -27990 0 0 {name=X_59822_ }
C {devices/lab_pin.sym} 136860 -27890 0 0 {name=p135882 lab=_52155_/Y }
C {devices/lab_pin.sym} 136860 -27850 0 0 {name=p135883 lab=_52145_/X }
C {devices/lab_pin.sym} 136860 -27810 0 0 {name=p135884 lab=_52156_/X }
C {devices/lab_pin.sym} 137020 -27850 0 1 {name=p135885 lab=_52157_/Y }
C {sky130_stdcells/a21oi_4.sym} 136940 -27850 0 0 {name=X_52157_ }
C {devices/lab_pin.sym} 136850 -27710 0 0 {name=p135886 lab=_86984_/CLK }
C {devices/lab_pin.sym} 136850 -27690 0 0 {name=p135887 lab=_87854_/D }
C {devices/lab_pin.sym} 137030 -27710 0 1 {name=p135888 lab=_68490_/A }
C {sky130_stdcells/dfxtp_4.sym} 136940 -27700 0 0 {name=X_87854_ }
C {devices/lab_pin.sym} 136880 -27580 0 0 {name=p135889 lab=_80189_/A }
C {devices/lab_pin.sym} 136880 -27540 0 0 {name=p135890 lab=_80198_/A }
C {devices/lab_pin.sym} 137000 -27560 0 1 {name=p135891 lab=_80189_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -27560 0 0 {name=X_80189_ }
C {devices/lab_pin.sym} 136900 -27430 0 0 {name=p135892 lab=clkbuf_9_237_0_CLK/X }
C {devices/lab_pin.sym} 136980 -27430 0 1 {name=p135893 lab=_86381_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 136940 -27430 0 0 {name=Xclkbuf_10_475_0_CLK }
C {devices/lab_pin.sym} 136860 -27330 0 0 {name=p135894 lab=_86072_/Q }
C {devices/lab_pin.sym} 136860 -27290 0 0 {name=p135895 lab=_51101_/X }
C {devices/lab_pin.sym} 136860 -27250 0 0 {name=p135896 lab=_51107_/Y }
C {devices/lab_pin.sym} 137020 -27290 0 1 {name=p135897 lab=_51108_/Y }
C {sky130_stdcells/o21ai_4.sym} 136940 -27290 0 0 {name=X_51108_ }
C {devices/lab_pin.sym} 136850 -27150 0 0 {name=p135898 lab=_87888_/CLK }
C {devices/lab_pin.sym} 136850 -27130 0 0 {name=p135899 lab=_86805_/D }
C {devices/lab_pin.sym} 137030 -27150 0 1 {name=p135900 lab=_86805_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -27140 0 0 {name=X_86805_ }
C {devices/lab_pin.sym} 136880 -27040 0 0 {name=p135901 lab=_72584_/C }
C {devices/lab_pin.sym} 136880 -27000 0 0 {name=p135902 lab=_59753_/B }
C {devices/lab_pin.sym} 136880 -26960 0 0 {name=p135903 lab=_60312_/C }
C {devices/lab_pin.sym} 136880 -26920 0 0 {name=p135904 lab=_60312_/D }
C {devices/lab_pin.sym} 137000 -26980 0 1 {name=p135905 lab=_59753_/Y }
C {sky130_stdcells/nand4_4.sym} 136940 -26980 0 0 {name=X_59753_ }
C {devices/lab_pin.sym} 136860 -26850 0 0 {name=p135906 lab=_52086_/Y }
C {devices/lab_pin.sym} 136860 -26810 0 0 {name=p135907 lab=_52066_/X }
C {devices/lab_pin.sym} 136860 -26770 0 0 {name=p135908 lab=_52087_/Y }
C {devices/lab_pin.sym} 137020 -26810 0 1 {name=p135909 lab=_85891_/D }
C {sky130_stdcells/a21boi_4.sym} 136940 -26810 0 0 {name=X_52088_ }
C {devices/lab_pin.sym} 136860 -26700 0 0 {name=p135910 lab=_56949_/X }
C {devices/lab_pin.sym} 136860 -26660 0 0 {name=p135911 lab=_56634_/X }
C {devices/lab_pin.sym} 136860 -26620 0 0 {name=p135912 lab=_45582_/A }
C {devices/lab_pin.sym} 136860 -26580 0 0 {name=p135913 lab=_56989_/A }
C {devices/lab_pin.sym} 137020 -26640 0 1 {name=p135914 lab=_85109_/D }
C {sky130_stdcells/a2bb2o_4.sym} 136940 -26640 0 0 {name=X_56965_ }
C {devices/lab_pin.sym} 136850 -26490 0 0 {name=p135915 lab=_87789_/CLK }
C {devices/lab_pin.sym} 136850 -26470 0 0 {name=p135916 lab=_87785_/D }
C {devices/lab_pin.sym} 137030 -26490 0 1 {name=p135917 lab=_87785_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -26480 0 0 {name=X_87785_ }
C {devices/lab_pin.sym} 136850 -26350 0 0 {name=p135918 lab=_86855_/CLK }
C {devices/lab_pin.sym} 136850 -26330 0 0 {name=p135919 lab=_57478_/Y }
C {devices/lab_pin.sym} 137030 -26350 0 1 {name=p135920 lab=_57473_/B }
C {sky130_stdcells/dfxtp_4.sym} 136940 -26340 0 0 {name=X_84997_ }
C {devices/lab_pin.sym} 136860 -26230 0 0 {name=p135921 lab=_58605_/X }
C {devices/lab_pin.sym} 136860 -26190 0 0 {name=p135922 lab=_85942_/Q }
C {devices/lab_pin.sym} 136860 -26150 0 0 {name=p135923 lab=_58679_/X }
C {devices/lab_pin.sym} 137020 -26190 0 1 {name=p135924 lab=_58704_/X }
C {sky130_stdcells/o21a_4.sym} 136940 -26190 0 0 {name=X_58704_ }
C {devices/lab_pin.sym} 136860 -26080 0 0 {name=p135925 lab=_41416_/X }
C {devices/lab_pin.sym} 136860 -26040 0 0 {name=p135926 lab=_43928_/X }
C {devices/lab_pin.sym} 136860 -26000 0 0 {name=p135927 lab=_87195_/Q }
C {devices/lab_pin.sym} 136860 -25960 0 0 {name=p135928 lab=_43929_/X }
C {devices/lab_pin.sym} 137020 -26020 0 1 {name=p135929 lab=_87195_/D }
C {sky130_stdcells/a2bb2o_4.sym} 136940 -26020 0 0 {name=X_43930_ }
C {devices/lab_pin.sym} 136900 -25870 0 0 {name=p135930 lab=_51039_/A }
C {devices/lab_pin.sym} 136980 -25870 0 1 {name=p135931 lab=_51039_/X }
C {sky130_stdcells/buf_2.sym} 136940 -25870 0 0 {name=X_51039_ }
C {devices/lab_pin.sym} 136860 -25780 0 0 {name=p135932 lab=_45046_/A }
C {devices/lab_pin.sym} 136860 -25740 0 0 {name=p135933 lab=_55607_/A }
C {devices/lab_pin.sym} 136860 -25700 0 0 {name=p135934 lab=_44099_/X }
C {devices/lab_pin.sym} 136860 -25660 0 0 {name=p135935 lab=_55915_/X }
C {devices/lab_pin.sym} 137020 -25720 0 1 {name=p135936 lab=_55916_/X }
C {sky130_stdcells/a211o_4.sym} 136940 -25720 0 0 {name=X_55916_ }
C {devices/lab_pin.sym} 136900 -25570 0 0 {name=p135937 lab=_74764_/A }
C {devices/lab_pin.sym} 136980 -25570 0 1 {name=p135938 lab=_74804_/A }
C {sky130_stdcells/buf_2.sym} 136940 -25570 0 0 {name=X_74750_ }
C {devices/lab_pin.sym} 136850 -25450 0 0 {name=p135939 lab=_86736_/CLK }
C {devices/lab_pin.sym} 136850 -25430 0 0 {name=p135940 lab=_46454_/Y }
C {devices/lab_pin.sym} 137030 -25450 0 1 {name=p135941 lab=_86736_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -25440 0 0 {name=X_86736_ }
C {devices/lab_pin.sym} 136880 -25320 0 0 {name=p135942 lab=_71957_/A }
C {devices/lab_pin.sym} 136880 -25280 0 0 {name=p135943 lab=_48887_/Y }
C {devices/lab_pin.sym} 137000 -25300 0 1 {name=p135944 lab=_71962_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -25300 0 0 {name=X_71962_ }
C {devices/lab_pin.sym} 136900 -25170 0 0 {name=p135945 lab=_59642_/X }
C {devices/lab_pin.sym} 136980 -25170 0 1 {name=p135946 lab=_59684_/X }
C {sky130_stdcells/buf_2.sym} 136940 -25170 0 0 {name=X_59684_ }
C {devices/lab_pin.sym} 136850 -25050 0 0 {name=p135947 lab=_83973_/CLK }
C {devices/lab_pin.sym} 136850 -25030 0 0 {name=p135948 lab=_83948_/D }
C {devices/lab_pin.sym} 137030 -25050 0 1 {name=p135949 lab=_80804_/D }
C {sky130_stdcells/dfxtp_4.sym} 136940 -25040 0 0 {name=X_83948_ }
C {devices/lab_pin.sym} 136860 -24940 0 0 {name=p135950 lab=_46155_/X }
C {devices/lab_pin.sym} 136860 -24900 0 0 {name=p135951 lab=_55208_/B }
C {devices/lab_pin.sym} 136860 -24860 0 0 {name=p135952 lab=_56895_/X }
C {devices/lab_pin.sym} 136860 -24820 0 0 {name=p135953 lab=_44137_/A }
C {devices/lab_pin.sym} 137020 -24880 0 1 {name=p135954 lab=_56897_/B }
C {sky130_stdcells/a211o_4.sym} 136940 -24880 0 0 {name=X_56896_ }
C {devices/lab_pin.sym} 136880 -24740 0 0 {name=p135955 lab=_87341_/Q }
C {devices/lab_pin.sym} 136880 -24700 0 0 {name=p135956 lab=_73701_/B }
C {devices/lab_pin.sym} 137000 -24720 0 1 {name=p135957 lab=_73701_/Y }
C {sky130_stdcells/nor2_4.sym} 136940 -24720 0 0 {name=X_73701_ }
C {devices/lab_pin.sym} 136900 -24590 0 0 {name=p135958 lab=_70913_/A }
C {devices/lab_pin.sym} 136980 -24590 0 1 {name=p135959 lab=_70914_/D }
C {sky130_stdcells/buf_2.sym} 136940 -24590 0 0 {name=X_70913_ }
C {devices/lab_pin.sym} 136900 -24470 0 0 {name=p135960 lab=_58635_/A }
C {devices/lab_pin.sym} 136980 -24470 0 1 {name=p135961 lab=_58868_/A }
C {sky130_stdcells/buf_2.sym} 136940 -24470 0 0 {name=X_58635_ }
C {devices/lab_pin.sym} 136860 -24380 0 0 {name=p135962 lab=_41230_/X }
C {devices/lab_pin.sym} 136860 -24340 0 0 {name=p135963 lab=_43842_/X }
C {devices/lab_pin.sym} 136860 -24300 0 0 {name=p135964 lab=_68920_/B }
C {devices/lab_pin.sym} 136860 -24260 0 0 {name=p135965 lab=_43843_/X }
C {devices/lab_pin.sym} 137020 -24320 0 1 {name=p135966 lab=_43861_/X }
C {sky130_stdcells/a2bb2o_4.sym} 136940 -24320 0 0 {name=X_43861_ }
C {devices/lab_pin.sym} 136860 -24200 0 0 {name=p135967 lab=_56233_/C }
C {devices/lab_pin.sym} 136860 -24160 0 0 {name=p135968 lab=_55489_/A }
C {devices/lab_pin.sym} 136860 -24120 0 0 {name=p135969 lab=_55469_/X }
C {devices/lab_pin.sym} 136860 -24080 0 0 {name=p135970 lab=_55846_/X }
C {devices/lab_pin.sym} 137020 -24140 0 1 {name=p135971 lab=_55847_/X }
C {sky130_stdcells/a211o_4.sym} 136940 -24140 0 0 {name=X_55847_ }
C {devices/lab_pin.sym} 136850 -23990 0 0 {name=p135972 lab=_86351_/CLK }
C {devices/lab_pin.sym} 136850 -23970 0 0 {name=p135973 lab=_47134_/Y }
C {devices/lab_pin.sym} 137030 -23990 0 1 {name=p135974 lab=_59270_/A }
C {sky130_stdcells/dfxtp_4.sym} 136940 -23980 0 0 {name=X_86667_ }
C {devices/lab_pin.sym} 136900 -23850 0 0 {name=p135975 lab=_74680_/Y }
C {devices/lab_pin.sym} 136980 -23850 0 1 {name=p135976 lab=_82987_/D }
C {sky130_stdcells/inv_2.sym} 136940 -23850 0 0 {name=X_74681_ }
C {devices/lab_pin.sym} 136900 -23730 0 0 {name=p135977 lab=_70716_/A }
C {devices/lab_pin.sym} 136980 -23730 0 1 {name=p135978 lab=_71893_/X }
C {sky130_stdcells/buf_2.sym} 136940 -23730 0 0 {name=X_71893_ }
C {devices/lab_pin.sym} 136850 -23610 0 0 {name=p135979 lab=_82557_/CLK }
C {devices/lab_pin.sym} 136850 -23590 0 0 {name=p135980 lab=_69987_/X }
C {devices/lab_pin.sym} 137030 -23610 0 1 {name=p135981 lab=_82559_/D }
C {sky130_stdcells/dfxtp_4.sym} 136940 -23600 0 0 {name=X_83879_ }
C {devices/lab_pin.sym} 136880 -23480 0 0 {name=p135982 lab=_45600_/A }
C {devices/lab_pin.sym} 136880 -23440 0 0 {name=p135983 lab=_45617_/B }
C {devices/lab_pin.sym} 137000 -23460 0 1 {name=p135984 lab=_45600_/Y }
C {sky130_stdcells/nor2_4.sym} 136940 -23460 0 0 {name=X_45600_ }
C {devices/lab_pin.sym} 136880 -23350 0 0 {name=p135985 lab=_76387_/A }
C {devices/lab_pin.sym} 136880 -23310 0 0 {name=p135986 lab=_76403_/B }
C {devices/lab_pin.sym} 136880 -23270 0 0 {name=p135987 lab=_76400_/X }
C {devices/lab_pin.sym} 137000 -23310 0 1 {name=p135988 lab=_76420_/X }
C {sky130_stdcells/and3_4.sym} 136940 -23310 0 0 {name=X_76420_ }
C {devices/lab_pin.sym} 136900 -23170 0 0 {name=p135989 lab=_42812_/A }
C {devices/lab_pin.sym} 136980 -23170 0 1 {name=p135990 lab=_87706_/D }
C {sky130_stdcells/inv_2.sym} 136940 -23170 0 0 {name=X_42812_ }
C {devices/lab_pin.sym} 136900 -23050 0 0 {name=p135991 lab=_72978_/X }
C {devices/lab_pin.sym} 136980 -23050 0 1 {name=p135992 lab=_74244_/B }
C {sky130_stdcells/buf_2.sym} 136940 -23050 0 0 {name=X_73632_ }
C {devices/lab_pin.sym} 136850 -22930 0 0 {name=p135993 lab=_85630_/CLK }
C {devices/lab_pin.sym} 136850 -22910 0 0 {name=p135994 lab=_53534_/Y }
C {devices/lab_pin.sym} 137030 -22930 0 1 {name=p135995 lab=_85618_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -22920 0 0 {name=X_85618_ }
C {devices/lab_pin.sym} 136880 -22800 0 0 {name=p135996 lab=_82916_/Q }
C {devices/lab_pin.sym} 136880 -22760 0 0 {name=p135997 lab=_46579_/X }
C {devices/lab_pin.sym} 137000 -22780 0 1 {name=p135998 lab=_46580_/X }
C {sky130_stdcells/or2_4.sym} 136940 -22780 0 0 {name=X_46580_ }
C {devices/lab_pin.sym} 136880 -22680 0 0 {name=p135999 lab=_70871_/A }
C {devices/lab_pin.sym} 136880 -22640 0 0 {name=p136000 lab=_70846_/B }
C {devices/lab_pin.sym} 136880 -22600 0 0 {name=p136001 lab=_70849_/C }
C {devices/lab_pin.sym} 136880 -22560 0 0 {name=p136002 lab=_70860_/D }
C {devices/lab_pin.sym} 137000 -22620 0 1 {name=p136003 lab=_70844_/Y }
C {sky130_stdcells/nand4_4.sym} 136940 -22620 0 0 {name=X_70844_ }
C {devices/lab_pin.sym} 136880 -22480 0 0 {name=p136004 lab=_86721_/Q }
C {devices/lab_pin.sym} 136880 -22440 0 0 {name=p136005 lab=_58614_/B }
C {devices/lab_pin.sym} 137000 -22460 0 1 {name=p136006 lab=_58566_/Y }
C {sky130_stdcells/nor2_4.sym} 136940 -22460 0 0 {name=X_58566_ }
C {devices/lab_pin.sym} 136860 -22370 0 0 {name=p136007 lab=_43790_/X }
C {devices/lab_pin.sym} 136860 -22330 0 0 {name=p136008 lab=_43781_/X }
C {devices/lab_pin.sym} 136860 -22290 0 0 {name=p136009 lab=_41036_/X }
C {devices/lab_pin.sym} 136860 -22250 0 0 {name=p136010 lab=_87265_/Q }
C {devices/lab_pin.sym} 136860 -22210 0 0 {name=p136011 lab=_43791_/X }
C {devices/lab_pin.sym} 137020 -22290 0 1 {name=p136012 lab=_43792_/Y }
C {sky130_stdcells/o32ai_4.sym} 136940 -22290 0 0 {name=X_43792_ }
C {devices/lab_pin.sym} 136860 -22150 0 0 {name=p136013 lab=_55775_/X }
C {devices/lab_pin.sym} 136860 -22110 0 0 {name=p136014 lab=_55777_/X }
C {devices/lab_pin.sym} 136860 -22070 0 0 {name=p136015 lab=_44110_/X }
C {devices/lab_pin.sym} 137020 -22110 0 1 {name=p136016 lab=_55778_/X }
C {sky130_stdcells/a21o_4.sym} 136940 -22110 0 0 {name=X_55778_ }
C {devices/lab_pin.sym} 136850 -21970 0 0 {name=p136017 lab=_85959_/CLK }
C {devices/lab_pin.sym} 136850 -21950 0 0 {name=p136018 lab=_86598_/D }
C {devices/lab_pin.sym} 137030 -21970 0 1 {name=p136019 lab=_86598_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -21960 0 0 {name=X_86598_ }
C {devices/lab_pin.sym} 136860 -21850 0 0 {name=p136020 lab=_45511_/X }
C {devices/lab_pin.sym} 136860 -21810 0 0 {name=p136021 lab=_61430_/A }
C {devices/lab_pin.sym} 136860 -21770 0 0 {name=p136022 lab=_45530_/X }
C {devices/lab_pin.sym} 137020 -21810 0 1 {name=p136023 lab=_45531_/Y }
C {sky130_stdcells/o21ai_4.sym} 136940 -21810 0 0 {name=X_45531_ }
C {devices/lab_pin.sym} 136860 -21690 0 0 {name=p136024 lab=_57514_/Y }
C {devices/lab_pin.sym} 136860 -21650 0 0 {name=p136025 lab=_57515_/X }
C {devices/lab_pin.sym} 136860 -21610 0 0 {name=p136026 lab=_57516_/Y }
C {devices/lab_pin.sym} 137020 -21650 0 1 {name=p136027 lab=_84988_/D }
C {sky130_stdcells/a21boi_4.sym} 136940 -21650 0 0 {name=X_57517_ }
C {devices/lab_pin.sym} 136900 -21510 0 0 {name=p136028 lab=_76350_/X }
C {devices/lab_pin.sym} 136980 -21510 0 1 {name=p136029 lab=_76353_/B }
C {sky130_stdcells/inv_2.sym} 136940 -21510 0 0 {name=X_76351_ }
C {devices/lab_pin.sym} 136900 -21390 0 0 {name=p136030 lab=_42743_/A }
C {devices/lab_pin.sym} 136980 -21390 0 1 {name=p136031 lab=_51949_/A }
C {sky130_stdcells/buf_2.sym} 136940 -21390 0 0 {name=X_42743_ }
C {devices/lab_pin.sym} 136850 -21270 0 0 {name=p136032 lab=_88337_/CLK }
C {devices/lab_pin.sym} 136850 -21250 0 0 {name=p136033 lab=_88337_/D }
C {devices/lab_pin.sym} 137030 -21270 0 1 {name=p136034 lab=_69597_/B }
C {sky130_stdcells/dfxtp_4.sym} 136940 -21260 0 0 {name=X_88337_ }
C {devices/lab_pin.sym} 136900 -21130 0 0 {name=p136035 lab=_54729_/A }
C {devices/lab_pin.sym} 136980 -21130 0 1 {name=p136036 lab=_54729_/X }
C {sky130_stdcells/buf_2.sym} 136940 -21130 0 0 {name=X_54729_ }
C {devices/lab_pin.sym} 136880 -21020 0 0 {name=p136037 lab=_73497_/A }
C {devices/lab_pin.sym} 136880 -20980 0 0 {name=p136038 lab=_65908_/B }
C {devices/lab_pin.sym} 137000 -21000 0 1 {name=p136039 lab=_73563_/X }
C {sky130_stdcells/and2_4.sym} 136940 -21000 0 0 {name=X_73563_ }
C {devices/lab_pin.sym} 136850 -20870 0 0 {name=p136040 lab=_86256_/CLK }
C {devices/lab_pin.sym} 136850 -20850 0 0 {name=p136041 lab=_53885_/Y }
C {devices/lab_pin.sym} 137030 -20870 0 1 {name=p136042 lab=_85549_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -20860 0 0 {name=X_85549_ }
C {devices/lab_pin.sym} 136880 -20760 0 0 {name=p136043 lab=_70867_/A }
C {devices/lab_pin.sym} 136880 -20720 0 0 {name=p136044 lab=_70779_/B }
C {devices/lab_pin.sym} 136880 -20680 0 0 {name=p136045 lab=_70791_/C }
C {devices/lab_pin.sym} 136880 -20640 0 0 {name=p136046 lab=_70791_/D }
C {devices/lab_pin.sym} 137000 -20700 0 1 {name=p136047 lab=_70775_/Y }
C {sky130_stdcells/nand4_4.sym} 136940 -20700 0 0 {name=X_70775_ }
C {devices/lab_pin.sym} 136900 -20550 0 0 {name=p136048 lab=_84834_/Q }
C {devices/lab_pin.sym} 136980 -20550 0 1 {name=p136049 lab=_58498_/A }
C {sky130_stdcells/inv_2.sym} 136940 -20550 0 0 {name=X_58497_ }
C {devices/lab_pin.sym} 136900 -20430 0 0 {name=p136050 lab=clkbuf_9_206_0_CLK/X }
C {devices/lab_pin.sym} 136980 -20430 0 1 {name=p136051 lab=_85335_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 136940 -20430 0 0 {name=Xclkbuf_10_413_0_CLK }
C {devices/lab_pin.sym} 136880 -20320 0 0 {name=p136052 lab=_75298_/X }
C {devices/lab_pin.sym} 136880 -20280 0 0 {name=p136053 lab=_75301_/X }
C {devices/lab_pin.sym} 137000 -20300 0 1 {name=p136054 lab=_75309_/A }
C {sky130_stdcells/xor2_4.sym} 136940 -20300 0 0 {name=X_75302_ }
C {devices/lab_pin.sym} 136860 -20190 0 0 {name=p136055 lab=_66101_/B }
C {devices/lab_pin.sym} 136860 -20150 0 0 {name=p136056 lab=_48241_/X }
C {devices/lab_pin.sym} 136860 -20110 0 0 {name=p136057 lab=_48249_/Y }
C {devices/lab_pin.sym} 137020 -20150 0 1 {name=p136058 lab=_48250_/Y }
C {sky130_stdcells/o21ai_4.sym} 136940 -20150 0 0 {name=X_48250_ }
C {devices/lab_pin.sym} 136900 -20010 0 0 {name=p136059 lab=_72514_/A }
C {devices/lab_pin.sym} 136980 -20010 0 1 {name=p136060 lab=_72607_/C }
C {sky130_stdcells/buf_2.sym} 136940 -20010 0 0 {name=X_72514_ }
C {devices/lab_pin.sym} 136880 -19900 0 0 {name=p136061 lab=_79065_/Y }
C {devices/lab_pin.sym} 136880 -19860 0 0 {name=p136062 lab=_79070_/B }
C {devices/lab_pin.sym} 137000 -19880 0 1 {name=p136063 lab=_79071_/B }
C {sky130_stdcells/xor2_4.sym} 136940 -19880 0 0 {name=X_79070_ }
C {devices/lab_pin.sym} 136860 -19770 0 0 {name=p136064 lab=_45458_/X }
C {devices/lab_pin.sym} 136860 -19730 0 0 {name=p136065 lab=_45461_/X }
C {devices/lab_pin.sym} 136860 -19690 0 0 {name=p136066 lab=_45446_/X }
C {devices/lab_pin.sym} 137020 -19730 0 1 {name=p136067 lab=_45462_/X }
C {sky130_stdcells/a21o_4.sym} 136940 -19730 0 0 {name=X_45462_ }
C {devices/lab_pin.sym} 136880 -19600 0 0 {name=p136068 lab=_57448_/A }
C {devices/lab_pin.sym} 136880 -19560 0 0 {name=p136069 lab=_57463_/B }
C {devices/lab_pin.sym} 137000 -19580 0 1 {name=p136070 lab=_57448_/X }
C {sky130_stdcells/or2_4.sym} 136940 -19580 0 0 {name=X_57448_ }
C {devices/lab_pin.sym} 136880 -19470 0 0 {name=p136071 lab=_76282_/A }
C {devices/lab_pin.sym} 136880 -19430 0 0 {name=p136072 lab=_76276_/X }
C {devices/lab_pin.sym} 136880 -19390 0 0 {name=p136073 lab=_76282_/C }
C {devices/lab_pin.sym} 137000 -19430 0 1 {name=p136074 lab=_76283_/A }
C {sky130_stdcells/nand3_4.sym} 136940 -19430 0 0 {name=X_76282_ }
C {devices/lab_pin.sym} 136850 -19290 0 0 {name=p136075 lab=_88268_/CLK }
C {devices/lab_pin.sym} 136850 -19270 0 0 {name=p136076 lab=_41154_/X }
C {devices/lab_pin.sym} 137030 -19290 0 1 {name=p136077 lab=_68549_/B }
C {sky130_stdcells/dfxtp_4.sym} 136940 -19280 0 0 {name=X_88268_ }
C {devices/lab_pin.sym} 136860 -19190 0 0 {name=p136078 lab=_42665_/X }
C {devices/lab_pin.sym} 136860 -19150 0 0 {name=p136079 lab=_42666_/X }
C {devices/lab_pin.sym} 136860 -19110 0 0 {name=p136080 lab=_41045_/X }
C {devices/lab_pin.sym} 136860 -19070 0 0 {name=p136081 lab=_87776_/Q }
C {devices/lab_pin.sym} 136860 -19030 0 0 {name=p136082 lab=_42673_/X }
C {devices/lab_pin.sym} 137020 -19110 0 1 {name=p136083 lab=_42674_/Y }
C {sky130_stdcells/o32ai_4.sym} 136940 -19110 0 0 {name=X_42674_ }
C {devices/lab_pin.sym} 136880 -18960 0 0 {name=p136084 lab=_73494_/A }
C {devices/lab_pin.sym} 136880 -18920 0 0 {name=p136085 lab=_73493_/X }
C {devices/lab_pin.sym} 137000 -18940 0 1 {name=p136086 lab=_73494_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -18940 0 0 {name=X_73494_ }
C {devices/lab_pin.sym} 136900 -18810 0 0 {name=p136087 lab=_47201_/A }
C {devices/lab_pin.sym} 136980 -18810 0 1 {name=p136088 lab=_51220_/D }
C {sky130_stdcells/buf_2.sym} 136940 -18810 0 0 {name=X_47201_ }
C {devices/lab_pin.sym} 136880 -18710 0 0 {name=p136089 lab=_78021_/A }
C {devices/lab_pin.sym} 136880 -18670 0 0 {name=p136090 lab=_82176_/Q }
C {devices/lab_pin.sym} 136880 -18630 0 0 {name=p136091 lab=_78021_/C }
C {devices/lab_pin.sym} 137000 -18670 0 1 {name=p136092 lab=_78022_/A }
C {sky130_stdcells/nand3_4.sym} 136940 -18670 0 0 {name=X_78021_ }
C {devices/lab_pin.sym} 136900 -18530 0 0 {name=p136093 lab=_44454_/A }
C {devices/lab_pin.sym} 136980 -18530 0 1 {name=p136094 lab=_44413_/X }
C {sky130_stdcells/buf_2.sym} 136940 -18530 0 0 {name=X_44413_ }
C {devices/lab_pin.sym} 136880 -18420 0 0 {name=p136095 lab=_75212_/Y }
C {devices/lab_pin.sym} 136880 -18380 0 0 {name=p136096 lab=_75233_/B }
C {devices/lab_pin.sym} 137000 -18400 0 1 {name=p136097 lab=_75233_/X }
C {sky130_stdcells/or2_4.sym} 136940 -18400 0 0 {name=X_75233_ }
C {devices/lab_pin.sym} 136850 -18270 0 0 {name=p136098 lab=_88180_/CLK }
C {devices/lab_pin.sym} 136850 -18250 0 0 {name=p136099 lab=_87219_/D }
C {devices/lab_pin.sym} 137030 -18270 0 1 {name=p136100 lab=_87219_/Q }
C {sky130_stdcells/dfxtp_4.sym} 136940 -18260 0 0 {name=X_87219_ }
C {devices/lab_pin.sym} 136860 -18150 0 0 {name=p136101 lab=_41588_/X }
C {devices/lab_pin.sym} 136860 -18110 0 0 {name=p136102 lab=_40546_/A }
C {devices/lab_pin.sym} 136860 -18070 0 0 {name=p136103 lab=_41624_/X }
C {devices/lab_pin.sym} 137020 -18110 0 1 {name=p136104 lab=_41625_/Y }
C {sky130_stdcells/o21ai_4.sym} 136940 -18110 0 0 {name=X_41625_ }
C {devices/lab_pin.sym} 136880 -17980 0 0 {name=p136105 lab=_50048_/A }
C {devices/lab_pin.sym} 136880 -17940 0 0 {name=p136106 lab=_50232_/B }
C {devices/lab_pin.sym} 137000 -17960 0 1 {name=p136107 lab=_48181_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -17960 0 0 {name=X_48181_ }
C {devices/lab_pin.sym} 136900 -17830 0 0 {name=p136108 lab=_72381_/A }
C {devices/lab_pin.sym} 136980 -17830 0 1 {name=p136109 lab=_72445_/X }
C {sky130_stdcells/buf_2.sym} 136940 -17830 0 0 {name=X_72445_ }
C {devices/lab_pin.sym} 136900 -17710 0 0 {name=p136110 lab=_45393_/A }
C {devices/lab_pin.sym} 136980 -17710 0 1 {name=p136111 lab=_45393_/Y }
C {sky130_stdcells/inv_2.sym} 136940 -17710 0 0 {name=X_45393_ }
C {devices/lab_pin.sym} 136860 -17630 0 0 {name=p136112 lab=_45886_/X }
C {devices/lab_pin.sym} 136860 -17590 0 0 {name=p136113 lab=_45882_/A }
C {devices/lab_pin.sym} 136860 -17550 0 0 {name=p136114 lab=_45898_/X }
C {devices/lab_pin.sym} 136860 -17510 0 0 {name=p136115 lab=_73916_/B }
C {devices/lab_pin.sym} 136860 -17480 0 0 {name=p136116 lab=_44038_/X }
C {devices/lab_pin.sym} 137020 -17550 0 1 {name=p136117 lab=_57379_/Y }
C {sky130_stdcells/a41oi_4.sym} 136940 -17550 0 0 {name=X_57379_ }
C {devices/lab_pin.sym} 136850 -17390 0 0 {name=p136118 lab=_88133_/CLK }
C {devices/lab_pin.sym} 136850 -17370 0 0 {name=p136119 lab=_41522_/Y }
C {devices/lab_pin.sym} 137030 -17390 0 1 {name=p136120 lab=_66857_/B }
C {sky130_stdcells/dfxtp_4.sym} 136940 -17380 0 0 {name=X_88199_ }
C {devices/lab_pin.sym} 136900 -17250 0 0 {name=p136121 lab=_54565_/D }
C {devices/lab_pin.sym} 136980 -17250 0 1 {name=p136122 lab=_52872_/D }
C {sky130_stdcells/buf_2.sym} 136940 -17250 0 0 {name=X_47132_ }
C {devices/lab_pin.sym} 136880 -17140 0 0 {name=p136123 lab=_59118_/A }
C {devices/lab_pin.sym} 136880 -17100 0 0 {name=p136124 lab=_59068_/B }
C {devices/lab_pin.sym} 137000 -17120 0 1 {name=p136125 lab=_59118_/Y }
C {sky130_stdcells/nor2_4.sym} 136940 -17120 0 0 {name=X_59118_ }
C {devices/lab_pin.sym} 136860 -17020 0 0 {name=p136126 lab=_41697_/X }
C {devices/lab_pin.sym} 136860 -16980 0 0 {name=p136127 lab=_44326_/X }
C {devices/lab_pin.sym} 136860 -16940 0 0 {name=p136128 lab=_87155_/Q }
C {devices/lab_pin.sym} 136860 -16900 0 0 {name=p136129 lab=_44327_/X }
C {devices/lab_pin.sym} 137020 -16960 0 1 {name=p136130 lab=_87155_/D }
C {sky130_stdcells/a2bb2o_4.sym} 136940 -16960 0 0 {name=X_44344_ }
C {devices/lab_pin.sym} 136880 -16820 0 0 {name=p136131 lab=_75133_/Y }
C {devices/lab_pin.sym} 136880 -16780 0 0 {name=p136132 lab=_75147_/Y }
C {devices/lab_pin.sym} 137000 -16800 0 1 {name=p136133 lab=_75164_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -16800 0 0 {name=X_75164_ }
C {devices/lab_pin.sym} 136900 -16670 0 0 {name=p136134 lab=_41555_/Y }
C {devices/lab_pin.sym} 136980 -16670 0 1 {name=p136135 lab=_41556_/X }
C {sky130_stdcells/buf_2.sym} 136940 -16670 0 0 {name=X_41556_ }
C {devices/lab_pin.sym} 136860 -16570 0 0 {name=p136136 lab=_72373_/Y }
C {devices/lab_pin.sym} 136860 -16530 0 0 {name=p136137 lab=_72375_/Y }
C {devices/lab_pin.sym} 136860 -16490 0 0 {name=p136138 lab=_72292_/X }
C {devices/lab_pin.sym} 137020 -16530 0 1 {name=p136139 lab=_72376_/X }
C {sky130_stdcells/a21o_4.sym} 136940 -16530 0 0 {name=X_72376_ }
C {devices/lab_pin.sym} 136900 -16390 0 0 {name=p136140 lab=_60473_/C }
C {devices/lab_pin.sym} 136980 -16390 0 1 {name=p136141 lab=_60399_/B }
C {sky130_stdcells/buf_2.sym} 136940 -16390 0 0 {name=X_60390_ }
C {devices/lab_pin.sym} 136900 -16270 0 0 {name=p136142 lab=clkbuf_9_214_0_CLK/X }
C {devices/lab_pin.sym} 136980 -16270 0 1 {name=p136143 lab=_84119_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 136940 -16270 0 0 {name=Xclkbuf_10_428_0_CLK }
C {devices/lab_pin.sym} 136880 -16160 0 0 {name=p136144 lab=_57605_/B }
C {devices/lab_pin.sym} 136880 -16120 0 0 {name=p136145 lab=_74115_/B }
C {devices/lab_pin.sym} 137000 -16140 0 1 {name=p136146 lab=_74116_/B }
C {sky130_stdcells/xor2_4.sym} 136940 -16140 0 0 {name=X_74115_ }
C {devices/lab_pin.sym} 136900 -16010 0 0 {name=p136147 lab=_40506_/Y }
C {devices/lab_pin.sym} 136980 -16010 0 1 {name=p136148 lab=_40507_/X }
C {sky130_stdcells/buf_2.sym} 136940 -16010 0 0 {name=X_40507_ }
C {devices/lab_pin.sym} 136880 -15900 0 0 {name=p136149 lab=_47063_/A }
C {devices/lab_pin.sym} 136880 -15860 0 0 {name=p136150 lab=_52833_/B }
C {devices/lab_pin.sym} 137000 -15880 0 1 {name=p136151 lab=_47063_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -15880 0 0 {name=X_47063_ }
C {devices/lab_pin.sym} 136860 -15770 0 0 {name=p136152 lab=_59048_/X }
C {devices/lab_pin.sym} 136860 -15730 0 0 {name=p136153 lab=_85661_/Q }
C {devices/lab_pin.sym} 136860 -15690 0 0 {name=p136154 lab=_59010_/X }
C {devices/lab_pin.sym} 137020 -15730 0 1 {name=p136155 lab=_59049_/X }
C {sky130_stdcells/o21a_4.sym} 136940 -15730 0 0 {name=X_59049_ }
C {devices/lab_pin.sym} 136880 -15610 0 0 {name=p136156 lab=_71335_/A }
C {devices/lab_pin.sym} 136880 -15570 0 0 {name=p136157 lab=_71335_/B }
C {devices/lab_pin.sym} 136880 -15530 0 0 {name=p136158 lab=_70472_/X }
C {devices/lab_pin.sym} 137000 -15570 0 1 {name=p136159 lab=_71327_/Y }
C {sky130_stdcells/nand3_4.sym} 136940 -15570 0 0 {name=X_71327_ }
C {devices/lab_pin.sym} 136900 -15430 0 0 {name=p136160 lab=_44274_/X }
C {devices/lab_pin.sym} 136980 -15430 0 1 {name=p136161 lab=_57327_/B }
C {sky130_stdcells/buf_2.sym} 136940 -15430 0 0 {name=X_44275_ }
C {devices/lab_pin.sym} 136880 -15320 0 0 {name=p136162 lab=_84927_/Q }
C {devices/lab_pin.sym} 136880 -15280 0 0 {name=p136163 lab=_84175_/Q }
C {devices/lab_pin.sym} 137000 -15300 0 1 {name=p136164 lab=_79972_/Y }
C {sky130_stdcells/nand2_4.sym} 136940 -15300 0 0 {name=X_79972_ }
C {devices/lab_pin.sym} 136880 -15180 0 0 {name=p136165 lab=_80676_/Q }
C {devices/lab_pin.sym} 136880 -15140 0 0 {name=p136166 lab=_80932_/D }
C {devices/lab_pin.sym} 137000 -15160 0 1 {name=p136167 lab=_75096_/A }
C {sky130_stdcells/nor2_4.sym} 136940 -15160 0 0 {name=X_75095_ }
C {devices/lab_pin.sym} 136900 -15030 0 0 {name=p136168 lab=_41457_/A }
C {devices/lab_pin.sym} 136980 -15030 0 1 {name=p136169 lab=_41487_/X }
C {sky130_stdcells/buf_2.sym} 136940 -15030 0 0 {name=X_41487_ }
C {devices/lab_pin.sym} 136900 -14910 0 0 {name=p136170 lab=_45981_/X }
C {devices/lab_pin.sym} 136980 -14910 0 1 {name=p136171 lab=_46014_/X }
C {sky130_stdcells/buf_2.sym} 136940 -14910 0 0 {name=X_46014_ }
C {devices/lab_pin.sym} 136900 -14790 0 0 {name=p136172 lab=_43162_/A }
C {devices/lab_pin.sym} 136980 -14790 0 1 {name=p136173 lab=_43226_/X }
C {sky130_stdcells/buf_2.sym} 136940 -14790 0 0 {name=X_43226_ }
C {devices/lab_pin.sym} 136900 -14670 0 0 {name=p136174 lab=_59699_/A }
C {devices/lab_pin.sym} 136980 -14670 0 1 {name=p136175 lab=_62060_/X }
C {sky130_stdcells/buf_2.sym} 136940 -14670 0 0 {name=X_62060_ }
C {devices/lab_pin.sym} 136880 -14560 0 0 {name=p136176 lab=_57590_/B }
C {devices/lab_pin.sym} 136880 -14520 0 0 {name=p136177 lab=_74046_/B }
C {devices/lab_pin.sym} 137000 -14540 0 1 {name=p136178 lab=_74046_/X }
C {sky130_stdcells/xor2_4.sym} 136940 -14540 0 0 {name=X_74046_ }
C {devices/lab_pin.sym} 136880 -14420 0 0 {name=p136179 lab=_78921_/Y }
C {devices/lab_pin.sym} 136880 -14380 0 0 {name=p136180 lab=_78923_/B }
C {devices/lab_pin.sym} 137000 -14400 0 1 {name=p136181 lab=_78931_/B }
C {sky130_stdcells/xor2_4.sym} 136940 -14400 0 0 {name=X_78923_ }
C {devices/lab_pin.sym} 136880 -14280 0 0 {name=p136182 lab=_82325_/Q }
C {devices/lab_pin.sym} 136880 -14240 0 0 {name=p136183 lab=_40907_/B }
C {devices/lab_pin.sym} 137000 -14260 0 1 {name=p136184 lab=_40438_/X }
C {sky130_stdcells/or2_4.sym} 136940 -14260 0 0 {name=X_40438_ }
C {devices/lab_pin.sym} 136880 -14150 0 0 {name=p136185 lab=_71258_/A }
C {devices/lab_pin.sym} 136880 -14110 0 0 {name=p136186 lab=_71232_/B }
C {devices/lab_pin.sym} 136880 -14070 0 0 {name=p136187 lab=_71141_/B }
C {devices/lab_pin.sym} 137000 -14110 0 1 {name=p136188 lab=_71258_/Y }
C {sky130_stdcells/nand3_4.sym} 136940 -14110 0 0 {name=X_71258_ }
C {devices/lab_pin.sym} 136860 -14010 0 0 {name=p136189 lab=_60963_/X }
C {devices/lab_pin.sym} 136860 -13970 0 0 {name=p136190 lab=_61010_/Y }
C {devices/lab_pin.sym} 136860 -13930 0 0 {name=p136191 lab=_60999_/X }
C {devices/lab_pin.sym} 136860 -13890 0 0 {name=p136192 lab=_76989_/A }
C {devices/lab_pin.sym} 136860 -13850 0 0 {name=p136193 lab=_60898_/X }
C {devices/lab_pin.sym} 137020 -13930 0 1 {name=p136194 lab=_84541_/D }
C {sky130_stdcells/o32a_4.sym} 136940 -13930 0 0 {name=X_61011_ }
C {devices/lab_pin.sym} 136900 -13770 0 0 {name=p136195 lab=_70209_/A }
C {devices/lab_pin.sym} 136980 -13770 0 1 {name=p136196 lab=_70209_/X }
C {sky130_stdcells/buf_2.sym} 136940 -13770 0 0 {name=X_70209_ }
C {devices/lab_pin.sym} 136860 -13690 0 0 {name=p136197 lab=_43146_/X }
C {devices/lab_pin.sym} 136860 -13650 0 0 {name=p136198 lab=_43149_/X }
C {devices/lab_pin.sym} 136860 -13610 0 0 {name=p136199 lab=_40854_/X }
C {devices/lab_pin.sym} 136860 -13570 0 0 {name=p136200 lab=_73198_/A }
C {devices/lab_pin.sym} 136860 -13530 0 0 {name=p136201 lab=_43154_/X }
C {devices/lab_pin.sym} 137020 -13610 0 1 {name=p136202 lab=_43158_/A }
C {sky130_stdcells/o32ai_4.sym} 136940 -13610 0 0 {name=X_43157_ }
C {devices/lab_pin.sym} 136880 -13460 0 0 {name=p136203 lab=_78874_/A }
C {devices/lab_pin.sym} 136880 -13420 0 0 {name=p136204 lab=_78854_/B }
C {devices/lab_pin.sym} 137000 -13440 0 1 {name=p136205 lab=_78854_/Y }
C {sky130_stdcells/nor2_4.sym} 136940 -13440 0 0 {name=X_78854_ }
C {devices/lab_pin.sym} 136880 -13320 0 0 {name=p136206 lab=_40368_/X }
C {devices/lab_pin.sym} 136880 -13280 0 0 {name=p136207 lab=_81183_/Q }
C {devices/lab_pin.sym} 137000 -13300 0 1 {name=p136208 lab=_40369_/X }
C {sky130_stdcells/or2_4.sym} 136940 -13300 0 0 {name=X_40369_ }
C {devices/lab_pin.sym} 136880 -13180 0 0 {name=p136209 lab=_71137_/A }
C {devices/lab_pin.sym} 136880 -13140 0 0 {name=p136210 lab=_71189_/B }
C {devices/lab_pin.sym} 137000 -13160 0 1 {name=p136211 lab=_71190_/A }
C {sky130_stdcells/nor2_4.sym} 136940 -13160 0 0 {name=X_71189_ }
C {devices/lab_pin.sym} 136860 -13070 0 0 {name=p136212 lab=_42099_/X }
C {devices/lab_pin.sym} 136860 -13030 0 0 {name=p136213 lab=_42094_/X }
C {devices/lab_pin.sym} 136860 -12990 0 0 {name=p136214 lab=_41045_/X }
C {devices/lab_pin.sym} 136860 -12950 0 0 {name=p136215 lab=_88032_/Q }
C {devices/lab_pin.sym} 136860 -12910 0 0 {name=p136216 lab=_42096_/X }
C {devices/lab_pin.sym} 137020 -12990 0 1 {name=p136217 lab=_42109_/A }
C {sky130_stdcells/o32ai_4.sym} 136940 -12990 0 0 {name=X_42108_ }
C {devices/lab_pin.sym} 136880 -12840 0 0 {name=p136218 lab=_82154_/Q }
C {devices/lab_pin.sym} 136880 -12800 0 0 {name=p136219 lab=_77805_/B }
C {devices/lab_pin.sym} 137000 -12820 0 1 {name=p136220 lab=_77805_/X }
C {sky130_stdcells/xor2_4.sym} 136940 -12820 0 0 {name=X_77805_ }
C {devices/lab_pin.sym} 136880 -12700 0 0 {name=p136221 lab=_47946_/A }
C {devices/lab_pin.sym} 136880 -12660 0 0 {name=p136222 lab=_47965_/B }
C {devices/lab_pin.sym} 137000 -12680 0 1 {name=p136223 lab=_47965_/X }
C {sky130_stdcells/and2_4.sym} 136940 -12680 0 0 {name=X_47965_ }
C {devices/lab_pin.sym} 136860 -12590 0 0 {name=p136224 lab=_43085_/X }
C {devices/lab_pin.sym} 136860 -12550 0 0 {name=p136225 lab=_43086_/X }
C {devices/lab_pin.sym} 136860 -12510 0 0 {name=p136226 lab=_40712_/X }
C {devices/lab_pin.sym} 136860 -12470 0 0 {name=p136227 lab=_43087_/Y }
C {devices/lab_pin.sym} 136860 -12430 0 0 {name=p136228 lab=_43058_/X }
C {devices/lab_pin.sym} 137020 -12510 0 1 {name=p136229 lab=_43088_/Y }
C {sky130_stdcells/o32ai_4.sym} 136940 -12510 0 0 {name=X_43088_ }
C {devices/lab_pin.sym} 136880 -12360 0 0 {name=p136230 lab=_82528_/Q }
C {devices/lab_pin.sym} 136880 -12320 0 0 {name=p136231 lab=_78784_/A }
C {devices/lab_pin.sym} 137000 -12340 0 1 {name=p136232 lab=_82496_/D }
C {sky130_stdcells/xnor2_4.sym} 136940 -12340 0 0 {name=X_78785_ }
C {devices/lab_pin.sym} 136880 -12220 0 0 {name=p136233 lab=_81333_/Q }
C {devices/lab_pin.sym} 136880 -12180 0 0 {name=p136234 lab=_81421_/Q }
C {devices/lab_pin.sym} 137000 -12200 0 1 {name=p136235 lab=_76005_/B }
C {sky130_stdcells/or2_4.sym} 136940 -12200 0 0 {name=X_75997_ }
C {devices/lab_pin.sym} 136860 -12090 0 0 {name=p136236 lab=_59376_/B }
C {devices/lab_pin.sym} 136860 -12050 0 0 {name=p136237 lab=_49687_/X }
C {devices/lab_pin.sym} 136860 -12010 0 0 {name=p136238 lab=_49703_/Y }
C {devices/lab_pin.sym} 137020 -12050 0 1 {name=p136239 lab=_49704_/Y }
C {sky130_stdcells/o21ai_4.sym} 136940 -12050 0 0 {name=X_49704_ }
C {devices/lab_pin.sym} 136900 -11910 0 0 {name=p136240 lab=_82946_/Q }
C {devices/lab_pin.sym} 136980 -11910 0 1 {name=p136241 lab=_46916_/Y }
C {sky130_stdcells/inv_2.sym} 136940 -11910 0 0 {name=X_46916_ }
C {devices/lab_pin.sym} 136860 -11830 0 0 {name=p136242 lab=_42028_/X }
C {devices/lab_pin.sym} 136860 -11790 0 0 {name=p136243 lab=_42024_/X }
C {devices/lab_pin.sym} 136860 -11750 0 0 {name=p136244 lab=_40885_/X }
C {devices/lab_pin.sym} 136860 -11710 0 0 {name=p136245 lab=_73320_/A }
C {devices/lab_pin.sym} 136860 -11670 0 0 {name=p136246 lab=_42025_/X }
C {devices/lab_pin.sym} 137020 -11750 0 1 {name=p136247 lab=_42040_/A }
C {sky130_stdcells/o32ai_4.sym} 136940 -11750 0 0 {name=X_42039_ }
C {devices/lab_pin.sym} 136880 -11600 0 0 {name=p136248 lab=_65735_/A }
C {devices/lab_pin.sym} 136880 -11560 0 0 {name=p136249 lab=_86476_/Q }
C {devices/lab_pin.sym} 137000 -11580 0 1 {name=p136250 lab=_65750_/X }
C {sky130_stdcells/and2_4.sym} 136940 -11580 0 0 {name=X_65750_ }
C {devices/lab_pin.sym} 136900 -11450 0 0 {name=p136251 lab=_82259_/Q }
C {devices/lab_pin.sym} 136980 -11450 0 1 {name=p136252 lab=_77736_/Y }
C {sky130_stdcells/inv_2.sym} 136940 -11450 0 0 {name=X_77736_ }
C {devices/lab_pin.sym} 136860 -11350 0 0 {name=p136253 lab=_62960_/X }
C {devices/lab_pin.sym} 136860 -11310 0 0 {name=p136254 lab=_62942_/X }
C {devices/lab_pin.sym} 136860 -11270 0 0 {name=p136255 lab=_62961_/Y }
C {devices/lab_pin.sym} 137020 -11310 0 1 {name=p136256 lab=_84366_/D }
C {sky130_stdcells/a21oi_4.sym} 136940 -11310 0 0 {name=X_62962_ }
C {devices/lab_pin.sym} 136880 -11180 0 0 {name=p136257 lab=_74958_/A }
C {devices/lab_pin.sym} 136880 -11140 0 0 {name=p136258 lab=_74959_/A }
C {devices/lab_pin.sym} 137000 -11160 0 1 {name=p136259 lab=_74949_/B }
C {sky130_stdcells/xor2_4.sym} 136940 -11160 0 0 {name=X_74948_ }
C {devices/lab_pin.sym} 136860 -11050 0 0 {name=p136260 lab=_47892_/Y }
C {devices/lab_pin.sym} 136860 -11010 0 0 {name=p136261 lab=_47846_/X }
C {devices/lab_pin.sym} 136860 -10970 0 0 {name=p136262 lab=_47895_/X }
C {devices/lab_pin.sym} 137020 -11010 0 1 {name=p136263 lab=_47896_/Y }
C {sky130_stdcells/a21oi_4.sym} 136940 -11010 0 0 {name=X_47896_ }
C {devices/lab_pin.sym} 136900 -10870 0 0 {name=p136264 lab=_64619_/A }
C {devices/lab_pin.sym} 136980 -10870 0 1 {name=p136265 lab=_64701_/X }
C {sky130_stdcells/buf_2.sym} 136940 -10870 0 0 {name=X_64701_ }
C {devices/lab_pin.sym} 136860 -10770 0 0 {name=p136266 lab=_86351_/Q }
C {devices/lab_pin.sym} 136860 -10730 0 0 {name=p136267 lab=_49632_/X }
C {devices/lab_pin.sym} 136860 -10690 0 0 {name=p136268 lab=_49634_/Y }
C {devices/lab_pin.sym} 137020 -10730 0 1 {name=p136269 lab=_49635_/Y }
C {sky130_stdcells/o21ai_4.sym} 136940 -10730 0 0 {name=X_49635_ }
C {devices/lab_pin.sym} 136880 -10610 0 0 {name=p136270 lab=_61960_/A }
C {devices/lab_pin.sym} 136880 -10570 0 0 {name=p136271 lab=_61960_/B }
C {devices/lab_pin.sym} 136880 -10530 0 0 {name=p136272 lab=_78069_/B }
C {devices/lab_pin.sym} 137000 -10570 0 1 {name=p136273 lab=_61913_/Y }
C {sky130_stdcells/nor3_4.sym} 136940 -10570 0 0 {name=X_61913_ }
C {devices/lab_pin.sym} 136900 -10430 0 0 {name=p136274 lab=_46846_/Y }
C {devices/lab_pin.sym} 136980 -10430 0 1 {name=p136275 lab=_52709_/D }
C {sky130_stdcells/buf_2.sym} 136940 -10430 0 0 {name=X_46847_ }
C {devices/lab_pin.sym} 136900 -10310 0 0 {name=p136276 lab=_65757_/A }
C {devices/lab_pin.sym} 136980 -10310 0 1 {name=p136277 lab=_65681_/X }
C {sky130_stdcells/buf_2.sym} 136940 -10310 0 0 {name=X_65681_ }
C {devices/lab_pin.sym} 136880 -10210 0 0 {name=p136278 lab=_77665_/X }
C {devices/lab_pin.sym} 136880 -10170 0 0 {name=p136279 lab=_77639_/Y }
C {devices/lab_pin.sym} 136880 -10130 0 0 {name=p136280 lab=_77667_/C }
C {devices/lab_pin.sym} 137000 -10170 0 1 {name=p136281 lab=_77667_/X }
C {sky130_stdcells/and3_4.sym} 136940 -10170 0 0 {name=X_77667_ }
C {devices/lab_pin.sym} 136900 -10030 0 0 {name=p136282 lab=_62893_/A }
C {devices/lab_pin.sym} 136980 -10030 0 1 {name=p136283 lab=_62893_/X }
C {sky130_stdcells/buf_2.sym} 136940 -10030 0 0 {name=X_62893_ }
C {devices/lab_pin.sym} 136880 -9920 0 0 {name=p136284 lab=_74879_/A }
C {devices/lab_pin.sym} 136880 -9880 0 0 {name=p136285 lab=_74879_/B }
C {devices/lab_pin.sym} 137000 -9900 0 1 {name=p136286 lab=_81216_/D }
C {sky130_stdcells/xor2_4.sym} 136940 -9900 0 0 {name=X_74879_ }
C {devices/lab_pin.sym} 136900 -9770 0 0 {name=p136287 lab=_67062_/X }
C {devices/lab_pin.sym} 136980 -9770 0 1 {name=p136288 lab=_67517_/A }
C {sky130_stdcells/buf_2.sym} 136940 -9770 0 0 {name=X_67420_ }
C {devices/lab_pin.sym} 136880 -9660 0 0 {name=p136289 lab=_79404_/X }
C {devices/lab_pin.sym} 136880 -9620 0 0 {name=p136290 lab=_79405_/X }
C {devices/lab_pin.sym} 137000 -9640 0 1 {name=p136291 lab=_79419_/B }
C {sky130_stdcells/xnor2_4.sym} 136940 -9640 0 0 {name=X_79406_ }
C {devices/lab_pin.sym} 136860 -9540 0 0 {name=p136292 lab=_64599_/X }
C {devices/lab_pin.sym} 136860 -9500 0 0 {name=p136293 lab=_83312_/Q }
C {devices/lab_pin.sym} 136860 -9460 0 0 {name=p136294 lab=_64600_/X }
C {devices/lab_pin.sym} 136860 -9420 0 0 {name=p136295 lab=_64631_/X }
C {devices/lab_pin.sym} 137020 -9480 0 1 {name=p136296 lab=_64632_/X }
C {sky130_stdcells/a211o_4.sym} 136940 -9480 0 0 {name=X_64632_ }
C {devices/lab_pin.sym} 136860 -9350 0 0 {name=p136297 lab=_76593_/Y }
C {devices/lab_pin.sym} 136860 -9310 0 0 {name=p136298 lab=_76597_/B }
C {devices/lab_pin.sym} 136860 -9270 0 0 {name=p136299 lab=_76595_/Y }
C {devices/lab_pin.sym} 137020 -9310 0 1 {name=p136300 lab=_76618_/X }
C {sky130_stdcells/o21a_4.sym} 136940 -9310 0 0 {name=X_76618_ }
C {devices/lab_pin.sym} 136860 -9190 0 0 {name=p136301 lab=_49564_/Y }
C {devices/lab_pin.sym} 136860 -9150 0 0 {name=p136302 lab=_49541_/X }
C {devices/lab_pin.sym} 136860 -9110 0 0 {name=p136303 lab=_49565_/X }
C {devices/lab_pin.sym} 137020 -9150 0 1 {name=p136304 lab=_86364_/D }
C {sky130_stdcells/a21oi_4.sym} 136940 -9150 0 0 {name=X_49566_ }
C {devices/lab_pin.sym} 136900 -9010 0 0 {name=p136305 lab=_84722_/Q }
C {devices/lab_pin.sym} 136980 -9010 0 1 {name=p136306 lab=_61844_/X }
C {sky130_stdcells/buf_2.sym} 136940 -9010 0 0 {name=X_61844_ }
C {devices/lab_pin.sym} 136900 -8890 0 0 {name=p136307 lab=_46778_/A }
C {devices/lab_pin.sym} 136980 -8890 0 1 {name=p136308 lab=_52667_/B }
C {sky130_stdcells/inv_2.sym} 136940 -8890 0 0 {name=X_46778_ }
C {devices/lab_pin.sym} 136860 -8790 0 0 {name=p136309 lab=_77584_/A }
C {devices/lab_pin.sym} 136860 -8750 0 0 {name=p136310 lab=_77584_/B }
C {devices/lab_pin.sym} 136860 -8710 0 0 {name=p136311 lab=_77583_/A }
C {devices/lab_pin.sym} 137020 -8750 0 1 {name=p136312 lab=_77606_/A }
C {sky130_stdcells/o21a_4.sym} 136940 -8750 0 0 {name=X_77598_ }
C {devices/lab_pin.sym} 136900 -8610 0 0 {name=p136313 lab=_48651_/A }
C {devices/lab_pin.sym} 136980 -8610 0 1 {name=p136314 lab=_48517_/X }
C {sky130_stdcells/buf_2.sym} 136940 -8610 0 0 {name=X_48517_ }
C {devices/lab_pin.sym} 136860 -8510 0 0 {name=p136315 lab=_67347_/X }
C {devices/lab_pin.sym} 136860 -8470 0 0 {name=p136316 lab=_67350_/X }
C {devices/lab_pin.sym} 136860 -8430 0 0 {name=p136317 lab=_67113_/X }
C {devices/lab_pin.sym} 137020 -8470 0 1 {name=p136318 lab=_67351_/Y }
C {sky130_stdcells/a21oi_4.sym} 136940 -8470 0 0 {name=X_67351_ }
C {devices/lab_pin.sym} 136860 -8350 0 0 {name=p136319 lab=_79324_/X }
C {devices/lab_pin.sym} 136860 -8310 0 0 {name=p136320 lab=_79335_/X }
C {devices/lab_pin.sym} 136860 -8270 0 0 {name=p136321 lab=_79336_/X }
C {devices/lab_pin.sym} 137020 -8310 0 1 {name=p136322 lab=_79337_/Y }
C {sky130_stdcells/a21oi_4.sym} 136940 -8310 0 0 {name=X_79337_ }
C {devices/lab_pin.sym} 136900 -8170 0 0 {name=p136323 lab=_64665_/A }
C {devices/lab_pin.sym} 136980 -8170 0 1 {name=p136324 lab=_64696_/A }
C {sky130_stdcells/buf_2.sym} 136940 -8170 0 0 {name=X_64563_ }
C {devices/lab_pin.sym} 136860 -8070 0 0 {name=p136325 lab=_45726_/X }
C {devices/lab_pin.sym} 136860 -8030 0 0 {name=p136326 lab=_45728_/Y }
C {devices/lab_pin.sym} 136860 -7990 0 0 {name=p136327 lab=_45714_/X }
C {devices/lab_pin.sym} 137020 -8030 0 1 {name=p136328 lab=_45729_/Y }
C {sky130_stdcells/a21oi_4.sym} 136940 -8030 0 0 {name=X_45729_ }
C {devices/lab_pin.sym} 136880 -7900 0 0 {name=p136329 lab=_81372_/Q }
C {devices/lab_pin.sym} 136880 -7860 0 0 {name=p136330 lab=_76548_/X }
C {devices/lab_pin.sym} 137000 -7880 0 1 {name=p136331 lab=_81340_/D }
C {sky130_stdcells/xor2_4.sym} 136940 -7880 0 0 {name=X_76549_ }
C {devices/lab_pin.sym} 136900 -7750 0 0 {name=p136332 lab=_49444_/A }
C {devices/lab_pin.sym} 136980 -7750 0 1 {name=p136333 lab=_49502_/A }
C {sky130_stdcells/buf_2.sym} 136940 -7750 0 0 {name=X_49497_ }
C {devices/lab_pin.sym} 136900 -7630 0 0 {name=p136334 lab=_59730_/A }
C {devices/lab_pin.sym} 136980 -7630 0 1 {name=p136335 lab=_61776_/D }
C {sky130_stdcells/buf_2.sym} 136940 -7630 0 0 {name=X_61775_ }
