C {devices/lab_pin.sym} 102820 -35330 0 0 {name=p101881 lab=_42083_/X }
C {devices/lab_pin.sym} 102820 -35290 0 0 {name=p101882 lab=_42094_/X }
C {devices/lab_pin.sym} 102820 -35250 0 0 {name=p101883 lab=_41016_/X }
C {devices/lab_pin.sym} 102820 -35210 0 0 {name=p101884 lab=_88037_/Q }
C {devices/lab_pin.sym} 102820 -35170 0 0 {name=p101885 lab=_42096_/X }
C {devices/lab_pin.sym} 102980 -35250 0 1 {name=p101886 lab=_42097_/Y }
C {sky130_stdcells/o32ai_4.sym} 102900 -35250 0 0 {name=X_42097_ }
C {devices/lab_pin.sym} 102840 -35100 0 0 {name=p101887 lab=_82266_/Q }
C {devices/lab_pin.sym} 102840 -35060 0 0 {name=p101888 lab=_81978_/Q }
C {devices/lab_pin.sym} 102960 -35080 0 1 {name=p101889 lab=_77819_/A }
C {sky130_stdcells/xnor2_4.sym} 102900 -35080 0 0 {name=X_77794_ }
C {devices/lab_pin.sym} 102840 -34960 0 0 {name=p101890 lab=_48725_/A }
C {devices/lab_pin.sym} 102840 -34920 0 0 {name=p101891 lab=_48358_/X }
C {devices/lab_pin.sym} 102960 -34940 0 1 {name=p101892 lab=_48713_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -34940 0 0 {name=X_48713_ }
C {devices/lab_pin.sym} 102860 -34810 0 0 {name=p101893 lab=clkbuf_9_179_0_CLK/X }
C {devices/lab_pin.sym} 102940 -34810 0 1 {name=p101894 lab=_85709_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 102900 -34810 0 0 {name=Xclkbuf_10_358_0_CLK }
C {devices/lab_pin.sym} 102820 -34710 0 0 {name=p101895 lab=_79895_/A }
C {devices/lab_pin.sym} 102820 -34670 0 0 {name=p101896 lab=_79531_/X }
C {devices/lab_pin.sym} 102820 -34630 0 0 {name=p101897 lab=_79532_/Y }
C {devices/lab_pin.sym} 102980 -34670 0 1 {name=p101898 lab=_79547_/A }
C {sky130_stdcells/a21boi_4.sym} 102900 -34670 0 0 {name=X_79533_ }
C {devices/lab_pin.sym} 102860 -34530 0 0 {name=p101899 lab=_65034_/A }
C {devices/lab_pin.sym} 102940 -34530 0 1 {name=p101900 lab=_64656_/A }
C {sky130_stdcells/buf_2.sym} 102900 -34530 0 0 {name=X_45925_ }
C {devices/lab_pin.sym} 102840 -34420 0 0 {name=p101901 lab=_41048_/A }
C {devices/lab_pin.sym} 102840 -34380 0 0 {name=p101902 lab=_41091_/B }
C {devices/lab_pin.sym} 102960 -34400 0 1 {name=p101903 lab=_41048_/X }
C {sky130_stdcells/or2_4.sym} 102900 -34400 0 0 {name=X_41048_ }
C {devices/lab_pin.sym} 102840 -34280 0 0 {name=p101904 lab=_76745_/A }
C {devices/lab_pin.sym} 102840 -34240 0 0 {name=p101905 lab=_76745_/B }
C {devices/lab_pin.sym} 102960 -34260 0 1 {name=p101906 lab=_76745_/X }
C {sky130_stdcells/xor2_4.sym} 102900 -34260 0 0 {name=X_76745_ }
C {devices/lab_pin.sym} 102820 -34150 0 0 {name=p101907 lab=_49691_/Y }
C {devices/lab_pin.sym} 102820 -34110 0 0 {name=p101908 lab=_49677_/X }
C {devices/lab_pin.sym} 102820 -34070 0 0 {name=p101909 lab=_49692_/X }
C {devices/lab_pin.sym} 102980 -34110 0 1 {name=p101910 lab=_49693_/Y }
C {sky130_stdcells/a21oi_4.sym} 102900 -34110 0 0 {name=X_49693_ }
C {devices/lab_pin.sym} 102840 -34000 0 0 {name=p101911 lab=_61969_/X }
C {devices/lab_pin.sym} 102840 -33960 0 0 {name=p101912 lab=_61924_/B }
C {devices/lab_pin.sym} 102840 -33920 0 0 {name=p101913 lab=_61971_/C }
C {devices/lab_pin.sym} 102840 -33880 0 0 {name=p101914 lab=_61971_/D }
C {devices/lab_pin.sym} 102960 -33940 0 1 {name=p101915 lab=_61971_/Y }
C {sky130_stdcells/nand4_4.sym} 102900 -33940 0 0 {name=X_61971_ }
C {devices/lab_pin.sym} 102840 -33800 0 0 {name=p101916 lab=_53535_/B }
C {devices/lab_pin.sym} 102840 -33760 0 0 {name=p101917 lab=_73957_/B }
C {devices/lab_pin.sym} 102960 -33780 0 1 {name=p101918 lab=_73957_/X }
C {sky130_stdcells/xor2_4.sym} 102900 -33780 0 0 {name=X_73957_ }
C {devices/lab_pin.sym} 102860 -33650 0 0 {name=p101919 lab=clkbuf_9_494_0_CLK/X }
C {devices/lab_pin.sym} 102940 -33650 0 1 {name=p101920 lab=_86256_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 102900 -33650 0 0 {name=Xclkbuf_10_988_0_CLK }
C {devices/lab_pin.sym} 102840 -33550 0 0 {name=p101921 lab=_63701_/A }
C {devices/lab_pin.sym} 102840 -33510 0 0 {name=p101922 lab=_63701_/B }
C {devices/lab_pin.sym} 102840 -33470 0 0 {name=p101923 lab=_80279_/B }
C {devices/lab_pin.sym} 102960 -33510 0 1 {name=p101924 lab=_63710_/Y }
C {sky130_stdcells/nor3_4.sym} 102900 -33510 0 0 {name=X_63710_ }
C {devices/lab_pin.sym} 102860 -33370 0 0 {name=p101925 lab=_64172_/B }
C {devices/lab_pin.sym} 102940 -33370 0 1 {name=p101926 lab=_60994_/B }
C {sky130_stdcells/buf_2.sym} 102900 -33370 0 0 {name=X_60922_ }
C {devices/lab_pin.sym} 102860 -33250 0 0 {name=p101927 lab=_48644_/A }
C {devices/lab_pin.sym} 102940 -33250 0 1 {name=p101928 lab=_48845_/A }
C {sky130_stdcells/buf_2.sym} 102900 -33250 0 0 {name=X_48644_ }
C {devices/lab_pin.sym} 102860 -33130 0 0 {name=p101929 lab=_72908_/A }
C {devices/lab_pin.sym} 102940 -33130 0 1 {name=p101930 lab=_72908_/X }
C {sky130_stdcells/buf_2.sym} 102900 -33130 0 0 {name=X_72908_ }
C {devices/lab_pin.sym} 102840 -33020 0 0 {name=p101931 lab=_79455_/X }
C {devices/lab_pin.sym} 102840 -32980 0 0 {name=p101932 lab=_79457_/B }
C {devices/lab_pin.sym} 102960 -33000 0 1 {name=p101933 lab=_79464_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -33000 0 0 {name=X_79464_ }
C {devices/lab_pin.sym} 102860 -32870 0 0 {name=p101934 lab=_85027_/Q }
C {devices/lab_pin.sym} 102940 -32870 0 1 {name=p101935 lab=_45856_/Y }
C {sky130_stdcells/inv_2.sym} 102900 -32870 0 0 {name=X_45856_ }
C {devices/lab_pin.sym} 102820 -32770 0 0 {name=p101936 lab=_64687_/Y }
C {devices/lab_pin.sym} 102820 -32730 0 0 {name=p101937 lab=_64662_/X }
C {devices/lab_pin.sym} 102820 -32690 0 0 {name=p101938 lab=_64689_/Y }
C {devices/lab_pin.sym} 102980 -32730 0 1 {name=p101939 lab=_64690_/X }
C {sky130_stdcells/a21o_4.sym} 102900 -32730 0 0 {name=X_64690_ }
C {devices/lab_pin.sym} 102860 -32590 0 0 {name=p101940 lab=_81477_/Q }
C {devices/lab_pin.sym} 102940 -32590 0 1 {name=p101941 lab=_76686_/A }
C {sky130_stdcells/inv_2.sym} 102900 -32590 0 0 {name=X_76676_ }
C {devices/lab_pin.sym} 102840 -32490 0 0 {name=p101942 lab=_73886_/X }
C {devices/lab_pin.sym} 102840 -32450 0 0 {name=p101943 lab=_73888_/B }
C {devices/lab_pin.sym} 102840 -32410 0 0 {name=p101944 lab=_73888_/C }
C {devices/lab_pin.sym} 102960 -32450 0 1 {name=p101945 lab=_73888_/Y }
C {sky130_stdcells/nand3_4.sym} 102900 -32450 0 0 {name=X_73888_ }
C {devices/lab_pin.sym} 102860 -32310 0 0 {name=p101946 lab=clkbuf_9_479_0_CLK/A }
C {devices/lab_pin.sym} 102940 -32310 0 1 {name=p101947 lab=clkbuf_9_479_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 102900 -32310 0 0 {name=Xclkbuf_9_479_0_CLK }
C {devices/lab_pin.sym} 102840 -32200 0 0 {name=p101948 lab=_78413_/Y }
C {devices/lab_pin.sym} 102840 -32160 0 0 {name=p101949 lab=_78414_/Y }
C {devices/lab_pin.sym} 102960 -32180 0 1 {name=p101950 lab=_82761_/D }
C {sky130_stdcells/xnor2_4.sym} 102900 -32180 0 0 {name=X_78415_ }
C {devices/lab_pin.sym} 102860 -32050 0 0 {name=p101951 lab=_45980_/A }
C {devices/lab_pin.sym} 102940 -32050 0 1 {name=p101952 lab=_44807_/X }
C {sky130_stdcells/buf_2.sym} 102900 -32050 0 0 {name=X_44807_ }
C {devices/lab_pin.sym} 102820 -31970 0 0 {name=p101953 lab=_62083_/D }
C {devices/lab_pin.sym} 102820 -31930 0 0 {name=p101954 lab=_60780_/X }
C {devices/lab_pin.sym} 102820 -31890 0 0 {name=p101955 lab=_63358_/X }
C {devices/lab_pin.sym} 102820 -31850 0 0 {name=p101956 lab=_60767_/X }
C {devices/lab_pin.sym} 102820 -31810 0 0 {name=p101957 lab=_63640_/Y }
C {devices/lab_pin.sym} 102980 -31890 0 1 {name=p101958 lab=_63641_/X }
C {sky130_stdcells/a2111o_4.sym} 102900 -31890 0 0 {name=X_63641_ }
C {devices/lab_pin.sym} 102840 -31740 0 0 {name=p101959 lab=_75632_/A }
C {devices/lab_pin.sym} 102840 -31700 0 0 {name=p101960 lab=_75632_/B }
C {devices/lab_pin.sym} 102960 -31720 0 1 {name=p101961 lab=_75628_/B }
C {sky130_stdcells/xor2_4.sym} 102900 -31720 0 0 {name=X_75627_ }
C {devices/lab_pin.sym} 102860 -31590 0 0 {name=p101962 lab=_81774_/Q }
C {devices/lab_pin.sym} 102940 -31590 0 1 {name=p101963 lab=_48576_/A }
C {sky130_stdcells/inv_2.sym} 102900 -31590 0 0 {name=X_48575_ }
C {devices/lab_pin.sym} 102840 -31490 0 0 {name=p101964 lab=_60851_/X }
C {devices/lab_pin.sym} 102840 -31450 0 0 {name=p101965 lab=_60852_/X }
C {devices/lab_pin.sym} 102840 -31410 0 0 {name=p101966 lab=_63632_/A }
C {devices/lab_pin.sym} 102960 -31450 0 1 {name=p101967 lab=_60853_/X }
C {sky130_stdcells/and3_4.sym} 102900 -31450 0 0 {name=X_60853_ }
C {devices/lab_pin.sym} 102860 -31310 0 0 {name=p101968 lab=_73092_/A }
C {devices/lab_pin.sym} 102940 -31310 0 1 {name=p101969 lab=_72839_/X }
C {sky130_stdcells/buf_2.sym} 102900 -31310 0 0 {name=X_72839_ }
C {devices/lab_pin.sym} 102840 -31200 0 0 {name=p101970 lab=_79395_/A }
C {devices/lab_pin.sym} 102840 -31160 0 0 {name=p101971 lab=_79395_/B }
C {devices/lab_pin.sym} 102960 -31180 0 1 {name=p101972 lab=_79396_/B }
C {sky130_stdcells/xnor2_4.sym} 102900 -31180 0 0 {name=X_79395_ }
C {devices/lab_pin.sym} 102840 -31060 0 0 {name=p101973 lab=_45787_/A }
C {devices/lab_pin.sym} 102840 -31020 0 0 {name=p101974 lab=_45746_/B }
C {devices/lab_pin.sym} 102960 -31040 0 1 {name=p101975 lab=_45787_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -31040 0 0 {name=X_45787_ }
C {devices/lab_pin.sym} 102820 -30940 0 0 {name=p101976 lab=_40507_/X }
C {devices/lab_pin.sym} 102820 -30900 0 0 {name=p101977 lab=_42994_/X }
C {devices/lab_pin.sym} 102820 -30860 0 0 {name=p101978 lab=_87612_/Q }
C {devices/lab_pin.sym} 102820 -30820 0 0 {name=p101979 lab=_42995_/X }
C {devices/lab_pin.sym} 102980 -30880 0 1 {name=p101980 lab=_87612_/D }
C {sky130_stdcells/a2bb2o_4.sym} 102900 -30880 0 0 {name=X_42999_ }
C {devices/lab_pin.sym} 102860 -30730 0 0 {name=p101981 lab=_47526_/A }
C {devices/lab_pin.sym} 102940 -30730 0 1 {name=p101982 lab=_47526_/Y }
C {sky130_stdcells/inv_2.sym} 102900 -30730 0 0 {name=X_47526_ }
C {devices/lab_pin.sym} 102820 -30630 0 0 {name=p101983 lab=_66358_/Y }
C {devices/lab_pin.sym} 102820 -30590 0 0 {name=p101984 lab=_66343_/X }
C {devices/lab_pin.sym} 102820 -30550 0 0 {name=p101985 lab=_66359_/X }
C {devices/lab_pin.sym} 102980 -30590 0 1 {name=p101986 lab=_84138_/D }
C {sky130_stdcells/a21o_4.sym} 102900 -30590 0 0 {name=X_66360_ }
C {devices/lab_pin.sym} 102860 -30450 0 0 {name=p101987 lab=clkbuf_9_455_0_CLK/X }
C {devices/lab_pin.sym} 102940 -30450 0 1 {name=p101988 lab=_87595_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 102900 -30450 0 0 {name=Xclkbuf_10_911_0_CLK }
C {devices/lab_pin.sym} 102840 -30350 0 0 {name=p101989 lab=_78343_/Y }
C {devices/lab_pin.sym} 102840 -30310 0 0 {name=p101990 lab=_82789_/Q }
C {devices/lab_pin.sym} 102840 -30270 0 0 {name=p101991 lab=_78344_/Y }
C {devices/lab_pin.sym} 102960 -30310 0 1 {name=p101992 lab=_78346_/Y }
C {sky130_stdcells/nand3_4.sym} 102900 -30310 0 0 {name=X_78346_ }
C {devices/lab_pin.sym} 102860 -30170 0 0 {name=p101993 lab=_44738_/A }
C {devices/lab_pin.sym} 102940 -30170 0 1 {name=p101994 lab=_44738_/Y }
C {sky130_stdcells/inv_2.sym} 102900 -30170 0 0 {name=X_44738_ }
C {devices/lab_pin.sym} 102860 -30050 0 0 {name=p101995 lab=_60738_/Y }
C {devices/lab_pin.sym} 102940 -30050 0 1 {name=p101996 lab=_63630_/C }
C {sky130_stdcells/buf_2.sym} 102900 -30050 0 0 {name=X_63572_ }
C {devices/lab_pin.sym} 102840 -29940 0 0 {name=p101997 lab=_75558_/A }
C {devices/lab_pin.sym} 102840 -29900 0 0 {name=p101998 lab=_75557_/X }
C {devices/lab_pin.sym} 102960 -29920 0 1 {name=p101999 lab=_75559_/B }
C {sky130_stdcells/xnor2_4.sym} 102900 -29920 0 0 {name=X_75558_ }
C {devices/lab_pin.sym} 102860 -29790 0 0 {name=p102000 lab=_60652_/X }
C {devices/lab_pin.sym} 102940 -29790 0 1 {name=p102001 lab=_63384_/D }
C {sky130_stdcells/buf_2.sym} 102900 -29790 0 0 {name=X_60784_ }
C {devices/lab_pin.sym} 102860 -29670 0 0 {name=p102002 lab=clkbuf_9_0_0_CLK/X }
C {devices/lab_pin.sym} 102940 -29670 0 1 {name=p102003 lab=_85270_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 102900 -29670 0 0 {name=Xclkbuf_10_0_0_CLK }
C {devices/lab_pin.sym} 102820 -29580 0 0 {name=p102004 lab=_65308_/X }
C {devices/lab_pin.sym} 102820 -29540 0 0 {name=p102005 lab=_86726_/Q }
C {devices/lab_pin.sym} 102820 -29500 0 0 {name=p102006 lab=_65309_/X }
C {devices/lab_pin.sym} 102820 -29460 0 0 {name=p102007 lab=_65310_/X }
C {devices/lab_pin.sym} 102980 -29520 0 1 {name=p102008 lab=_65311_/X }
C {sky130_stdcells/a211o_4.sym} 102900 -29520 0 0 {name=X_65311_ }
C {devices/lab_pin.sym} 102860 -29370 0 0 {name=p102009 lab=_62463_/A }
C {devices/lab_pin.sym} 102940 -29370 0 1 {name=p102010 lab=_62623_/D }
C {sky130_stdcells/buf_2.sym} 102900 -29370 0 0 {name=X_62523_ }
C {devices/lab_pin.sym} 102840 -29270 0 0 {name=p102011 lab=_74509_/A }
C {devices/lab_pin.sym} 102840 -29230 0 0 {name=p102012 lab=_74509_/B }
C {devices/lab_pin.sym} 102840 -29190 0 0 {name=p102013 lab=_74509_/C }
C {devices/lab_pin.sym} 102960 -29230 0 1 {name=p102014 lab=_74509_/X }
C {sky130_stdcells/and3_4.sym} 102900 -29230 0 0 {name=X_74509_ }
C {devices/lab_pin.sym} 102820 -29110 0 0 {name=p102015 lab=_47453_/Y }
C {devices/lab_pin.sym} 102820 -29070 0 0 {name=p102016 lab=_47414_/X }
C {devices/lab_pin.sym} 102820 -29030 0 0 {name=p102017 lab=_47456_/X }
C {devices/lab_pin.sym} 102980 -29070 0 1 {name=p102018 lab=_47457_/Y }
C {sky130_stdcells/a21oi_4.sym} 102900 -29070 0 0 {name=X_47457_ }
C {devices/lab_pin.sym} 102860 -28930 0 0 {name=p102019 lab=clkbuf_9_402_0_CLK/A }
C {devices/lab_pin.sym} 102940 -28930 0 1 {name=p102020 lab=clkbuf_9_402_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 102900 -28930 0 0 {name=Xclkbuf_9_402_0_CLK }
C {devices/lab_pin.sym} 102820 -28830 0 0 {name=p102021 lab=_66282_/X }
C {devices/lab_pin.sym} 102820 -28790 0 0 {name=p102022 lab=_65827_/Y }
C {devices/lab_pin.sym} 102820 -28750 0 0 {name=p102023 lab=_66290_/Y }
C {devices/lab_pin.sym} 102980 -28790 0 1 {name=p102024 lab=_66291_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -28790 0 0 {name=X_66291_ }
C {devices/lab_pin.sym} 102840 -28660 0 0 {name=p102025 lab=_78274_/Y }
C {devices/lab_pin.sym} 102840 -28620 0 0 {name=p102026 lab=_78276_/Y }
C {devices/lab_pin.sym} 102960 -28640 0 1 {name=p102027 lab=_78278_/B }
C {sky130_stdcells/xor2_4.sym} 102900 -28640 0 0 {name=X_78277_ }
C {devices/lab_pin.sym} 102820 -28550 0 0 {name=p102028 lab=_44658_/X }
C {devices/lab_pin.sym} 102820 -28510 0 0 {name=p102029 lab=_44659_/X }
C {devices/lab_pin.sym} 102820 -28470 0 0 {name=p102030 lab=_40560_/X }
C {devices/lab_pin.sym} 102820 -28430 0 0 {name=p102031 lab=_87007_/Q }
C {devices/lab_pin.sym} 102820 -28390 0 0 {name=p102032 lab=_44660_/X }
C {devices/lab_pin.sym} 102980 -28470 0 1 {name=p102033 lab=_44669_/Y }
C {sky130_stdcells/o32ai_4.sym} 102900 -28470 0 0 {name=X_44669_ }
C {devices/lab_pin.sym} 102840 -28320 0 0 {name=p102034 lab=_75485_/X }
C {devices/lab_pin.sym} 102840 -28280 0 0 {name=p102035 lab=_75486_/A }
C {devices/lab_pin.sym} 102960 -28300 0 1 {name=p102036 lab=_75491_/C }
C {sky130_stdcells/nand2_4.sym} 102900 -28300 0 0 {name=X_75489_ }
C {devices/lab_pin.sym} 102860 -28170 0 0 {name=p102037 lab=_68451_/A }
C {devices/lab_pin.sym} 102940 -28170 0 1 {name=p102038 lab=_68405_/A }
C {sky130_stdcells/buf_2.sym} 102900 -28170 0 0 {name=X_68030_ }
C {devices/lab_pin.sym} 102840 -28060 0 0 {name=p102039 lab=_46408_/A }
C {devices/lab_pin.sym} 102840 -28020 0 0 {name=p102040 lab=_46407_/X }
C {devices/lab_pin.sym} 102960 -28040 0 1 {name=p102041 lab=_46408_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -28040 0 0 {name=X_46408_ }
C {devices/lab_pin.sym} 102840 -27930 0 0 {name=p102042 lab=_65238_/X }
C {devices/lab_pin.sym} 102840 -27890 0 0 {name=p102043 lab=_65111_/B }
C {devices/lab_pin.sym} 102840 -27850 0 0 {name=p102044 lab=_65241_/X }
C {devices/lab_pin.sym} 102960 -27890 0 1 {name=p102045 lab=_65242_/Y }
C {sky130_stdcells/nand3_4.sym} 102900 -27890 0 0 {name=X_65242_ }
C {devices/lab_pin.sym} 102840 -27760 0 0 {name=p102046 lab=_77230_/A }
C {devices/lab_pin.sym} 102840 -27720 0 0 {name=p102047 lab=_77230_/C }
C {devices/lab_pin.sym} 102960 -27740 0 1 {name=p102048 lab=_77228_/X }
C {sky130_stdcells/and2_4.sym} 102900 -27740 0 0 {name=X_77228_ }
C {devices/lab_pin.sym} 102820 -27650 0 0 {name=p102049 lab=_62444_/X }
C {devices/lab_pin.sym} 102820 -27610 0 0 {name=p102050 lab=_62451_/Y }
C {devices/lab_pin.sym} 102820 -27570 0 0 {name=p102051 lab=_62453_/X }
C {devices/lab_pin.sym} 102820 -27530 0 0 {name=p102052 lab=_84849_/Q }
C {devices/lab_pin.sym} 102820 -27490 0 0 {name=p102053 lab=_62440_/X }
C {devices/lab_pin.sym} 102980 -27570 0 1 {name=p102054 lab=_62454_/Y }
C {sky130_stdcells/o32ai_4.sym} 102900 -27570 0 0 {name=X_62454_ }
C {devices/lab_pin.sym} 102820 -27430 0 0 {name=p102055 lab=_86640_/Q }
C {devices/lab_pin.sym} 102820 -27390 0 0 {name=p102056 lab=_47382_/X }
C {devices/lab_pin.sym} 102820 -27350 0 0 {name=p102057 lab=_47387_/Y }
C {devices/lab_pin.sym} 102980 -27390 0 1 {name=p102058 lab=_47388_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -27390 0 0 {name=X_47388_ }
C {devices/lab_pin.sym} 102860 -27250 0 0 {name=p102059 lab=clkbuf_9_463_0_CLK/X }
C {devices/lab_pin.sym} 102940 -27250 0 1 {name=p102060 lab=_83161_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 102900 -27250 0 0 {name=Xclkbuf_10_926_0_CLK }
C {devices/lab_pin.sym} 102820 -27150 0 0 {name=p102061 lab=_86441_/Q }
C {devices/lab_pin.sym} 102820 -27110 0 0 {name=p102062 lab=_49104_/X }
C {devices/lab_pin.sym} 102820 -27070 0 0 {name=p102063 lab=_49126_/Y }
C {devices/lab_pin.sym} 102980 -27110 0 1 {name=p102064 lab=_49127_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -27110 0 0 {name=X_49127_ }
C {devices/lab_pin.sym} 102860 -26970 0 0 {name=p102065 lab=_72529_/C }
C {devices/lab_pin.sym} 102940 -26970 0 1 {name=p102066 lab=_61406_/C }
C {sky130_stdcells/buf_2.sym} 102900 -26970 0 0 {name=X_61405_ }
C {devices/lab_pin.sym} 102860 -26850 0 0 {name=p102067 lab=_46339_/A }
C {devices/lab_pin.sym} 102940 -26850 0 1 {name=p102068 lab=_53978_/B }
C {sky130_stdcells/buf_2.sym} 102900 -26850 0 0 {name=X_46339_ }
C {devices/lab_pin.sym} 102840 -26740 0 0 {name=p102069 lab=_65155_/A }
C {devices/lab_pin.sym} 102840 -26700 0 0 {name=p102070 lab=_85803_/Q }
C {devices/lab_pin.sym} 102960 -26720 0 1 {name=p102071 lab=_65173_/X }
C {sky130_stdcells/and2_4.sym} 102900 -26720 0 0 {name=X_65173_ }
C {devices/lab_pin.sym} 102840 -26600 0 0 {name=p102072 lab=_77159_/A }
C {devices/lab_pin.sym} 102840 -26560 0 0 {name=p102073 lab=_77159_/B }
C {devices/lab_pin.sym} 102960 -26580 0 1 {name=p102074 lab=_77159_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -26580 0 0 {name=X_77159_ }
C {devices/lab_pin.sym} 102840 -26480 0 0 {name=p102075 lab=_62344_/X }
C {devices/lab_pin.sym} 102840 -26440 0 0 {name=p102076 lab=_57670_/A }
C {devices/lab_pin.sym} 102840 -26400 0 0 {name=p102077 lab=_62565_/C }
C {devices/lab_pin.sym} 102840 -26360 0 0 {name=p102078 lab=_62355_/X }
C {devices/lab_pin.sym} 102960 -26420 0 1 {name=p102079 lab=_62385_/X }
C {sky130_stdcells/and4_4.sym} 102900 -26420 0 0 {name=X_62385_ }
C {devices/lab_pin.sym} 102840 -26300 0 0 {name=p102080 lab=_64118_/Y }
C {devices/lab_pin.sym} 102840 -26260 0 0 {name=p102081 lab=_64120_/Y }
C {devices/lab_pin.sym} 102840 -26220 0 0 {name=p102082 lab=_64122_/Y }
C {devices/lab_pin.sym} 102840 -26180 0 0 {name=p102083 lab=_64123_/Y }
C {devices/lab_pin.sym} 102960 -26240 0 1 {name=p102084 lab=_64124_/X }
C {sky130_stdcells/and4_4.sym} 102900 -26240 0 0 {name=X_64124_ }
C {devices/lab_pin.sym} 102860 -26090 0 0 {name=p102085 lab=clkbuf_8_208_0_CLK/X }
C {devices/lab_pin.sym} 102940 -26090 0 1 {name=p102086 lab=clkbuf_9_417_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 102900 -26090 0 0 {name=Xclkbuf_9_417_0_CLK }
C {devices/lab_pin.sym} 102840 -25980 0 0 {name=p102087 lab=_46447_/B }
C {devices/lab_pin.sym} 102840 -25940 0 0 {name=p102088 lab=_48699_/B }
C {devices/lab_pin.sym} 102960 -25960 0 1 {name=p102089 lab=_49058_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -25960 0 0 {name=X_49058_ }
C {devices/lab_pin.sym} 102860 -25830 0 0 {name=p102090 lab=_72529_/C }
C {devices/lab_pin.sym} 102940 -25830 0 1 {name=p102091 lab=_61367_/C }
C {sky130_stdcells/buf_2.sym} 102900 -25830 0 0 {name=X_61336_ }
C {devices/lab_pin.sym} 102820 -25730 0 0 {name=p102092 lab=_80156_/Y }
C {devices/lab_pin.sym} 102820 -25690 0 0 {name=p102093 lab=_80162_/B }
C {devices/lab_pin.sym} 102820 -25650 0 0 {name=p102094 lab=_80169_/X }
C {devices/lab_pin.sym} 102980 -25690 0 1 {name=p102095 lab=_80171_/B }
C {sky130_stdcells/o21ai_4.sym} 102900 -25690 0 0 {name=X_80170_ }
C {devices/lab_pin.sym} 102820 -25570 0 0 {name=p102096 lab=_68391_/X }
C {devices/lab_pin.sym} 102820 -25530 0 0 {name=p102097 lab=_68398_/X }
C {devices/lab_pin.sym} 102820 -25490 0 0 {name=p102098 lab=_69925_/X }
C {devices/lab_pin.sym} 102980 -25530 0 1 {name=p102099 lab=_69981_/Y }
C {sky130_stdcells/a21oi_4.sym} 102900 -25530 0 0 {name=X_69981_ }
C {devices/lab_pin.sym} 102840 -25400 0 0 {name=p102100 lab=_48542_/B }
C {devices/lab_pin.sym} 102840 -25360 0 0 {name=p102101 lab=_47915_/B }
C {devices/lab_pin.sym} 102960 -25380 0 1 {name=p102102 lab=_48009_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -25380 0 0 {name=X_48009_ }
C {devices/lab_pin.sym} 102840 -25270 0 0 {name=p102103 lab=_64074_/A }
C {devices/lab_pin.sym} 102840 -25230 0 0 {name=p102104 lab=_64074_/B }
C {devices/lab_pin.sym} 102840 -25190 0 0 {name=p102105 lab=_80049_/B }
C {devices/lab_pin.sym} 102960 -25230 0 1 {name=p102106 lab=_64055_/Y }
C {sky130_stdcells/nor3_4.sym} 102900 -25230 0 0 {name=X_64055_ }
C {devices/lab_pin.sym} 102820 -25120 0 0 {name=p102107 lab=_87580_/Q }
C {devices/lab_pin.sym} 102820 -25080 0 0 {name=p102108 lab=_68715_/X }
C {devices/lab_pin.sym} 102820 -25040 0 0 {name=p102109 lab=_66349_/X }
C {devices/lab_pin.sym} 102820 -25000 0 0 {name=p102110 lab=_68931_/X }
C {devices/lab_pin.sym} 102980 -25060 0 1 {name=p102111 lab=_68932_/X }
C {sky130_stdcells/a211o_4.sym} 102900 -25060 0 0 {name=X_68932_ }
C {devices/lab_pin.sym} 102820 -24930 0 0 {name=p102112 lab=_61109_/X }
C {devices/lab_pin.sym} 102820 -24890 0 0 {name=p102113 lab=_61198_/X }
C {devices/lab_pin.sym} 102820 -24850 0 0 {name=p102114 lab=_61095_/X }
C {devices/lab_pin.sym} 102980 -24890 0 1 {name=p102115 lab=_61267_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -24890 0 0 {name=X_61267_ }
C {devices/lab_pin.sym} 102860 -24750 0 0 {name=p102116 lab=_51101_/A }
C {devices/lab_pin.sym} 102940 -24750 0 1 {name=p102117 lab=_51020_/X }
C {sky130_stdcells/buf_2.sym} 102900 -24750 0 0 {name=X_51020_ }
C {devices/lab_pin.sym} 102860 -24630 0 0 {name=p102118 lab=clkbuf_6_3_0_CLK/A }
C {devices/lab_pin.sym} 102940 -24630 0 1 {name=p102119 lab=clkbuf_6_2_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 102900 -24630 0 0 {name=Xclkbuf_6_2_0_CLK }
C {devices/lab_pin.sym} 102840 -24530 0 0 {name=p102120 lab=_63285_/A }
C {devices/lab_pin.sym} 102840 -24490 0 0 {name=p102121 lab=_63285_/B }
C {devices/lab_pin.sym} 102840 -24450 0 0 {name=p102122 lab=_79513_/A }
C {devices/lab_pin.sym} 102960 -24490 0 1 {name=p102123 lab=_63006_/Y }
C {sky130_stdcells/nor3_4.sym} 102900 -24490 0 0 {name=X_63006_ }
C {devices/lab_pin.sym} 102860 -24350 0 0 {name=p102124 lab=_60218_/A }
C {devices/lab_pin.sym} 102940 -24350 0 1 {name=p102125 lab=_60344_/B }
C {sky130_stdcells/buf_2.sym} 102900 -24350 0 0 {name=X_60218_ }
C {devices/lab_pin.sym} 102820 -24250 0 0 {name=p102126 lab=_68860_/X }
C {devices/lab_pin.sym} 102820 -24210 0 0 {name=p102127 lab=_68862_/X }
C {devices/lab_pin.sym} 102820 -24170 0 0 {name=p102128 lab=_68748_/X }
C {devices/lab_pin.sym} 102980 -24210 0 1 {name=p102129 lab=_68863_/X }
C {sky130_stdcells/a21o_4.sym} 102900 -24210 0 0 {name=X_68863_ }
C {devices/lab_pin.sym} 102860 -24070 0 0 {name=p102130 lab=_64545_/A }
C {devices/lab_pin.sym} 102940 -24070 0 1 {name=p102131 lab=_61198_/X }
C {sky130_stdcells/buf_2.sym} 102900 -24070 0 0 {name=X_61198_ }
C {devices/lab_pin.sym} 102820 -23980 0 0 {name=p102132 lab=_86955_/Q }
C {devices/lab_pin.sym} 102820 -23940 0 0 {name=p102133 lab=_67788_/X }
C {devices/lab_pin.sym} 102820 -23900 0 0 {name=p102134 lab=_67789_/X }
C {devices/lab_pin.sym} 102820 -23860 0 0 {name=p102135 lab=_67813_/X }
C {devices/lab_pin.sym} 102980 -23920 0 1 {name=p102136 lab=_67814_/X }
C {sky130_stdcells/a211o_4.sym} 102900 -23920 0 0 {name=X_67814_ }
C {devices/lab_pin.sym} 102820 -23810 0 0 {name=p102137 lab=_59875_/X }
C {devices/lab_pin.sym} 102820 -23770 0 0 {name=p102138 lab=_60118_/X }
C {devices/lab_pin.sym} 102820 -23730 0 0 {name=p102139 lab=_60073_/Y }
C {devices/lab_pin.sym} 102820 -23690 0 0 {name=p102140 lab=_59951_/Y }
C {devices/lab_pin.sym} 102820 -23650 0 0 {name=p102141 lab=_60148_/Y }
C {devices/lab_pin.sym} 102980 -23730 0 1 {name=p102142 lab=_60149_/X }
C {sky130_stdcells/o41a_4.sym} 102900 -23730 0 0 {name=X_60149_ }
C {devices/lab_pin.sym} 102810 -23570 0 0 {name=p102143 lab=_82541_/CLK }
C {devices/lab_pin.sym} 102810 -23550 0 0 {name=p102144 lab=_70062_/X }
C {devices/lab_pin.sym} 102990 -23570 0 1 {name=p102145 lab=_82540_/D }
C {sky130_stdcells/dfxtp_4.sym} 102900 -23560 0 0 {name=X_83860_ }
C {devices/lab_pin.sym} 102820 -23460 0 0 {name=p102146 lab=_87490_/Q }
C {devices/lab_pin.sym} 102820 -23420 0 0 {name=p102147 lab=_68792_/X }
C {devices/lab_pin.sym} 102820 -23380 0 0 {name=p102148 lab=_68545_/X }
C {devices/lab_pin.sym} 102820 -23340 0 0 {name=p102149 lab=_68793_/X }
C {devices/lab_pin.sym} 102980 -23400 0 1 {name=p102150 lab=_68794_/X }
C {sky130_stdcells/a211o_4.sym} 102900 -23400 0 0 {name=X_68794_ }
C {devices/lab_pin.sym} 102810 -23250 0 0 {name=p102151 lab=_82692_/CLK }
C {devices/lab_pin.sym} 102810 -23230 0 0 {name=p102152 lab=_82843_/Q }
C {devices/lab_pin.sym} 102990 -23250 0 1 {name=p102153 lab=_82811_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -23240 0 0 {name=X_82811_ }
C {devices/lab_pin.sym} 102820 -23140 0 0 {name=p102154 lab=_87150_/Q }
C {devices/lab_pin.sym} 102820 -23100 0 0 {name=p102155 lab=_67670_/X }
C {devices/lab_pin.sym} 102820 -23060 0 0 {name=p102156 lab=_67671_/X }
C {devices/lab_pin.sym} 102820 -23020 0 0 {name=p102157 lab=_67744_/X }
C {devices/lab_pin.sym} 102980 -23080 0 1 {name=p102158 lab=_67745_/X }
C {sky130_stdcells/a211o_4.sym} 102900 -23080 0 0 {name=X_67745_ }
C {devices/lab_pin.sym} 102840 -22960 0 0 {name=p102159 lab=_52947_/X }
C {devices/lab_pin.sym} 102840 -22920 0 0 {name=p102160 lab=_52982_/B }
C {devices/lab_pin.sym} 102840 -22880 0 0 {name=p102161 lab=_52977_/C }
C {devices/lab_pin.sym} 102840 -22840 0 0 {name=p102162 lab=_52971_/D }
C {devices/lab_pin.sym} 102960 -22900 0 1 {name=p102163 lab=_52971_/X }
C {sky130_stdcells/and4_4.sym} 102900 -22900 0 0 {name=X_52971_ }
C {devices/lab_pin.sym} 102840 -22760 0 0 {name=p102164 lab=_65002_/A }
C {devices/lab_pin.sym} 102840 -22720 0 0 {name=p102165 lab=_86036_/Q }
C {devices/lab_pin.sym} 102960 -22740 0 1 {name=p102166 lab=_64957_/X }
C {sky130_stdcells/and2_4.sym} 102900 -22740 0 0 {name=X_64957_ }
C {devices/lab_pin.sym} 102810 -22610 0 0 {name=p102167 lab=_81631_/CLK }
C {devices/lab_pin.sym} 102810 -22590 0 0 {name=p102168 lab=_83791_/D }
C {devices/lab_pin.sym} 102990 -22610 0 1 {name=p102169 lab=_74786_/A }
C {sky130_stdcells/dfxtp_4.sym} 102900 -22600 0 0 {name=X_83791_ }
C {devices/lab_pin.sym} 102820 -22490 0 0 {name=p102170 lab=_85392_/Q }
C {devices/lab_pin.sym} 102820 -22450 0 0 {name=p102171 lab=_54703_/X }
C {devices/lab_pin.sym} 102820 -22410 0 0 {name=p102172 lab=_54709_/Y }
C {devices/lab_pin.sym} 102980 -22450 0 1 {name=p102173 lab=_54710_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -22450 0 0 {name=X_54710_ }
C {devices/lab_pin.sym} 102810 -22310 0 0 {name=p102174 lab=_85818_/CLK }
C {devices/lab_pin.sym} 102810 -22290 0 0 {name=p102175 lab=_85530_/D }
C {devices/lab_pin.sym} 102990 -22310 0 1 {name=p102176 lab=_85530_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -22300 0 0 {name=X_85530_ }
C {devices/lab_pin.sym} 102860 -22170 0 0 {name=p102177 lab=_52322_/A }
C {devices/lab_pin.sym} 102940 -22170 0 1 {name=p102178 lab=_51922_/X }
C {sky130_stdcells/buf_2.sym} 102900 -22170 0 0 {name=X_51922_ }
C {devices/lab_pin.sym} 102840 -22080 0 0 {name=p102179 lab=_61448_/X }
C {devices/lab_pin.sym} 102840 -22040 0 0 {name=p102180 lab=_63908_/B }
C {devices/lab_pin.sym} 102840 -22000 0 0 {name=p102181 lab=_63894_/C }
C {devices/lab_pin.sym} 102840 -21960 0 0 {name=p102182 lab=_63908_/D }
C {devices/lab_pin.sym} 102960 -22020 0 1 {name=p102183 lab=_63908_/Y }
C {sky130_stdcells/nand4_4.sym} 102900 -22020 0 0 {name=X_63908_ }
C {devices/lab_pin.sym} 102810 -21870 0 0 {name=p102184 lab=_82147_/CLK }
C {devices/lab_pin.sym} 102810 -21850 0 0 {name=p102185 lab=_84126_/Q }
C {devices/lab_pin.sym} 102990 -21870 0 1 {name=p102186 lab=_78994_/A }
C {sky130_stdcells/dfxtp_4.sym} 102900 -21860 0 0 {name=X_82742_ }
C {devices/lab_pin.sym} 102860 -21730 0 0 {name=p102187 lab=_55690_/A }
C {devices/lab_pin.sym} 102940 -21730 0 1 {name=p102188 lab=_55690_/X }
C {sky130_stdcells/buf_2.sym} 102900 -21730 0 0 {name=X_55690_ }
C {devices/lab_pin.sym} 102820 -21640 0 0 {name=p102189 lab=_87909_/Q }
C {devices/lab_pin.sym} 102820 -21600 0 0 {name=p102190 lab=_67651_/X }
C {devices/lab_pin.sym} 102820 -21560 0 0 {name=p102191 lab=_67625_/X }
C {devices/lab_pin.sym} 102820 -21520 0 0 {name=p102192 lab=_67675_/X }
C {devices/lab_pin.sym} 102980 -21580 0 1 {name=p102193 lab=_67676_/X }
C {sky130_stdcells/a211o_4.sym} 102900 -21580 0 0 {name=X_67676_ }
C {devices/lab_pin.sym} 102840 -21450 0 0 {name=p102194 lab=_64885_/X }
C {devices/lab_pin.sym} 102840 -21410 0 0 {name=p102195 lab=_64888_/B }
C {devices/lab_pin.sym} 102840 -21370 0 0 {name=p102196 lab=_64887_/X }
C {devices/lab_pin.sym} 102960 -21410 0 1 {name=p102197 lab=_64888_/Y }
C {sky130_stdcells/nand3_4.sym} 102900 -21410 0 0 {name=X_64888_ }
C {devices/lab_pin.sym} 102840 -21280 0 0 {name=p102198 lab=_69309_/A }
C {devices/lab_pin.sym} 102840 -21240 0 0 {name=p102199 lab=_69415_/B }
C {devices/lab_pin.sym} 102960 -21260 0 1 {name=p102200 lab=_69415_/X }
C {sky130_stdcells/and2_4.sym} 102900 -21260 0 0 {name=X_69415_ }
C {devices/lab_pin.sym} 102840 -21140 0 0 {name=p102201 lab=_54636_/A }
C {devices/lab_pin.sym} 102840 -21100 0 0 {name=p102202 lab=_54121_/B }
C {devices/lab_pin.sym} 102960 -21120 0 1 {name=p102203 lab=_54641_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -21120 0 0 {name=X_54641_ }
C {devices/lab_pin.sym} 102820 -21020 0 0 {name=p102204 lab=_87953_/Q }
C {devices/lab_pin.sym} 102820 -20980 0 0 {name=p102205 lab=_66562_/X }
C {devices/lab_pin.sym} 102820 -20940 0 0 {name=p102206 lab=_66564_/X }
C {devices/lab_pin.sym} 102820 -20900 0 0 {name=p102207 lab=_66626_/X }
C {devices/lab_pin.sym} 102980 -20960 0 1 {name=p102208 lab=_66627_/X }
C {sky130_stdcells/a211o_4.sym} 102900 -20960 0 0 {name=X_66627_ }
C {devices/lab_pin.sym} 102810 -20810 0 0 {name=p102209 lab=_82769_/CLK }
C {devices/lab_pin.sym} 102810 -20790 0 0 {name=p102210 lab=_54335_/Y }
C {devices/lab_pin.sym} 102990 -20810 0 1 {name=p102211 lab=_85461_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -20800 0 0 {name=X_85461_ }
C {devices/lab_pin.sym} 102840 -20680 0 0 {name=p102212 lab=_51853_/A }
C {devices/lab_pin.sym} 102840 -20640 0 0 {name=p102213 lab=_50987_/B }
C {devices/lab_pin.sym} 102960 -20660 0 1 {name=p102214 lab=_51853_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -20660 0 0 {name=X_51853_ }
C {devices/lab_pin.sym} 102860 -20530 0 0 {name=p102215 lab=_63724_/A }
C {devices/lab_pin.sym} 102940 -20530 0 1 {name=p102216 lab=_63840_/C }
C {sky130_stdcells/buf_2.sym} 102900 -20530 0 0 {name=X_63839_ }
C {devices/lab_pin.sym} 102810 -20410 0 0 {name=p102217 lab=_82715_/CLK }
C {devices/lab_pin.sym} 102810 -20390 0 0 {name=p102218 lab=_82673_/D }
C {devices/lab_pin.sym} 102990 -20410 0 1 {name=p102219 lab=_82673_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -20400 0 0 {name=X_82673_ }
C {devices/lab_pin.sym} 102810 -20270 0 0 {name=p102220 lab=_87708_/CLK }
C {devices/lab_pin.sym} 102810 -20250 0 0 {name=p102221 lab=_87200_/D }
C {devices/lab_pin.sym} 102990 -20270 0 1 {name=p102222 lab=_87200_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -20260 0 0 {name=X_87200_ }
C {devices/lab_pin.sym} 102810 -20130 0 0 {name=p102223 lab=_84414_/CLK }
C {devices/lab_pin.sym} 102810 -20110 0 0 {name=p102224 lab=_84412_/D }
C {devices/lab_pin.sym} 102990 -20130 0 1 {name=p102225 lab=_84412_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -20120 0 0 {name=X_84412_ }
C {devices/lab_pin.sym} 102860 -19990 0 0 {name=p102226 lab=_50742_/A }
C {devices/lab_pin.sym} 102940 -19990 0 1 {name=p102227 lab=_50804_/X }
C {sky130_stdcells/buf_2.sym} 102900 -19990 0 0 {name=X_50804_ }
C {devices/lab_pin.sym} 102820 -19890 0 0 {name=p102228 lab=_57358_/X }
C {devices/lab_pin.sym} 102820 -19850 0 0 {name=p102229 lab=_57247_/Y }
C {devices/lab_pin.sym} 102820 -19810 0 0 {name=p102230 lab=_57359_/Y }
C {devices/lab_pin.sym} 102980 -19850 0 1 {name=p102231 lab=_85029_/D }
C {sky130_stdcells/a21oi_4.sym} 102900 -19850 0 0 {name=X_57360_ }
C {devices/lab_pin.sym} 102810 -19710 0 0 {name=p102232 lab=_81696_/CLK }
C {devices/lab_pin.sym} 102810 -19690 0 0 {name=p102233 lab=_76485_/X }
C {devices/lab_pin.sym} 102990 -19710 0 1 {name=p102234 lab=_81624_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -19700 0 0 {name=X_81624_ }
C {devices/lab_pin.sym} 102860 -19570 0 0 {name=p102235 lab=_64806_/A }
C {devices/lab_pin.sym} 102940 -19570 0 1 {name=p102236 lab=_69346_/X }
C {sky130_stdcells/buf_2.sym} 102900 -19570 0 0 {name=X_69346_ }
C {devices/lab_pin.sym} 102810 -19450 0 0 {name=p102237 lab=_88180_/CLK }
C {devices/lab_pin.sym} 102810 -19430 0 0 {name=p102238 lab=_41627_/X }
C {devices/lab_pin.sym} 102990 -19450 0 1 {name=p102239 lab=_67324_/B }
C {sky130_stdcells/dfxtp_4.sym} 102900 -19440 0 0 {name=X_88180_ }
C {devices/lab_pin.sym} 102820 -19330 0 0 {name=p102240 lab=_54570_/Y }
C {devices/lab_pin.sym} 102820 -19290 0 0 {name=p102241 lab=_54558_/X }
C {devices/lab_pin.sym} 102820 -19250 0 0 {name=p102242 lab=_54571_/X }
C {devices/lab_pin.sym} 102980 -19290 0 1 {name=p102243 lab=_54572_/Y }
C {sky130_stdcells/a21oi_4.sym} 102900 -19290 0 0 {name=X_54572_ }
C {devices/lab_pin.sym} 102820 -19180 0 0 {name=p102244 lab=_87135_/Q }
C {devices/lab_pin.sym} 102820 -19140 0 0 {name=p102245 lab=_66550_/X }
C {devices/lab_pin.sym} 102820 -19100 0 0 {name=p102246 lab=_66552_/X }
C {devices/lab_pin.sym} 102820 -19060 0 0 {name=p102247 lab=_66557_/X }
C {devices/lab_pin.sym} 102980 -19120 0 1 {name=p102248 lab=_66559_/B }
C {sky130_stdcells/a211o_4.sym} 102900 -19120 0 0 {name=X_66558_ }
C {devices/lab_pin.sym} 102810 -18970 0 0 {name=p102249 lab=_85489_/CLK }
C {devices/lab_pin.sym} 102810 -18950 0 0 {name=p102250 lab=_85392_/D }
C {devices/lab_pin.sym} 102990 -18970 0 1 {name=p102251 lab=_85392_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -18960 0 0 {name=X_85392_ }
C {devices/lab_pin.sym} 102840 -18840 0 0 {name=p102252 lab=_51779_/A }
C {devices/lab_pin.sym} 102840 -18800 0 0 {name=p102253 lab=_46685_/X }
C {devices/lab_pin.sym} 102960 -18820 0 1 {name=p102254 lab=_51784_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -18820 0 0 {name=X_51784_ }
C {devices/lab_pin.sym} 102860 -18690 0 0 {name=p102255 lab=_45369_/A }
C {devices/lab_pin.sym} 102940 -18690 0 1 {name=p102256 lab=_56351_/A }
C {sky130_stdcells/buf_2.sym} 102900 -18690 0 0 {name=X_56311_ }
C {devices/lab_pin.sym} 102810 -18570 0 0 {name=p102257 lab=_87484_/CLK }
C {devices/lab_pin.sym} 102810 -18550 0 0 {name=p102258 lab=_44393_/X }
C {devices/lab_pin.sym} 102990 -18570 0 1 {name=p102259 lab=_87131_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -18560 0 0 {name=X_87131_ }
C {devices/lab_pin.sym} 102840 -18440 0 0 {name=p102260 lab=_65416_/X }
C {devices/lab_pin.sym} 102840 -18400 0 0 {name=p102261 lab=_86524_/Q }
C {devices/lab_pin.sym} 102960 -18420 0 1 {name=p102262 lab=_65509_/X }
C {sky130_stdcells/and2_4.sym} 102900 -18420 0 0 {name=X_65509_ }
C {devices/lab_pin.sym} 102820 -18310 0 0 {name=p102263 lab=_85620_/Q }
C {devices/lab_pin.sym} 102820 -18270 0 0 {name=p102264 lab=_53506_/X }
C {devices/lab_pin.sym} 102820 -18230 0 0 {name=p102265 lab=_53522_/Y }
C {devices/lab_pin.sym} 102980 -18270 0 1 {name=p102266 lab=_53523_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -18270 0 0 {name=X_53523_ }
C {devices/lab_pin.sym} 102810 -18130 0 0 {name=p102267 lab=_84849_/CLK }
C {devices/lab_pin.sym} 102810 -18110 0 0 {name=p102268 lab=_63222_/X }
C {devices/lab_pin.sym} 102990 -18130 0 1 {name=p102269 lab=_79321_/A }
C {sky130_stdcells/dfxtp_4.sym} 102900 -18120 0 0 {name=X_84343_ }
C {devices/lab_pin.sym} 102860 -17990 0 0 {name=p102270 lab=_50768_/A }
C {devices/lab_pin.sym} 102940 -17990 0 1 {name=p102271 lab=_50735_/X }
C {sky130_stdcells/buf_2.sym} 102900 -17990 0 0 {name=X_50735_ }
C {devices/lab_pin.sym} 102820 -17910 0 0 {name=p102272 lab=_56726_/X }
C {devices/lab_pin.sym} 102820 -17870 0 0 {name=p102273 lab=_57268_/X }
C {devices/lab_pin.sym} 102820 -17830 0 0 {name=p102274 lab=_56739_/X }
C {devices/lab_pin.sym} 102820 -17790 0 0 {name=p102275 lab=_56740_/X }
C {devices/lab_pin.sym} 102820 -17760 0 0 {name=p102276 lab=_56852_/A }
C {devices/lab_pin.sym} 102980 -17830 0 1 {name=p102277 lab=_57291_/Y }
C {sky130_stdcells/a41oi_4.sym} 102900 -17830 0 0 {name=X_57291_ }
C {devices/lab_pin.sym} 102810 -17670 0 0 {name=p102278 lab=_84087_/CLK }
C {devices/lab_pin.sym} 102810 -17650 0 0 {name=p102279 lab=_76809_/X }
C {devices/lab_pin.sym} 102990 -17670 0 1 {name=p102280 lab=_81511_/D }
C {sky130_stdcells/dfxtp_4.sym} 102900 -17660 0 0 {name=X_81555_ }
C {devices/lab_pin.sym} 102860 -17530 0 0 {name=p102281 lab=_69182_/A }
C {devices/lab_pin.sym} 102940 -17530 0 1 {name=p102282 lab=_69277_/X }
C {sky130_stdcells/buf_2.sym} 102900 -17530 0 0 {name=X_69277_ }
C {devices/lab_pin.sym} 102860 -17410 0 0 {name=p102283 lab=_65464_/A }
C {devices/lab_pin.sym} 102940 -17410 0 1 {name=p102284 lab=_66501_/B }
C {sky130_stdcells/buf_2.sym} 102900 -17410 0 0 {name=X_66489_ }
C {devices/lab_pin.sym} 102840 -17300 0 0 {name=p102285 lab=_59030_/A }
C {devices/lab_pin.sym} 102840 -17260 0 0 {name=p102286 lab=_59008_/B }
C {devices/lab_pin.sym} 102960 -17280 0 1 {name=p102287 lab=_59030_/Y }
C {sky130_stdcells/nor2_4.sym} 102900 -17280 0 0 {name=X_59030_ }
C {devices/lab_pin.sym} 102860 -17150 0 0 {name=p102288 lab=_56255_/A }
C {devices/lab_pin.sym} 102940 -17150 0 1 {name=p102289 lab=_56242_/X }
C {sky130_stdcells/buf_2.sym} 102900 -17150 0 0 {name=X_56242_ }
C {devices/lab_pin.sym} 102840 -17040 0 0 {name=p102290 lab=_80506_/A }
C {devices/lab_pin.sym} 102840 -17000 0 0 {name=p102291 lab=_80506_/B }
C {devices/lab_pin.sym} 102960 -17020 0 1 {name=p102292 lab=_80506_/X }
C {sky130_stdcells/xor2_4.sym} 102900 -17020 0 0 {name=X_80506_ }
C {devices/lab_pin.sym} 102860 -16890 0 0 {name=p102293 lab=_68168_/A }
C {devices/lab_pin.sym} 102940 -16890 0 1 {name=p102294 lab=_68228_/X }
C {sky130_stdcells/buf_2.sym} 102900 -16890 0 0 {name=X_68228_ }
C {devices/lab_pin.sym} 102810 -16770 0 0 {name=p102295 lab=_87063_/CLK }
C {devices/lab_pin.sym} 102810 -16750 0 0 {name=p102296 lab=_44540_/Y }
C {devices/lab_pin.sym} 102990 -16770 0 1 {name=p102297 lab=_44539_/A }
C {sky130_stdcells/dfxtp_4.sym} 102900 -16760 0 0 {name=X_87062_ }
C {devices/lab_pin.sym} 102820 -16650 0 0 {name=p102298 lab=_85632_/Q }
C {devices/lab_pin.sym} 102820 -16610 0 0 {name=p102299 lab=_53449_/X }
C {devices/lab_pin.sym} 102820 -16570 0 0 {name=p102300 lab=_53453_/Y }
C {devices/lab_pin.sym} 102980 -16610 0 1 {name=p102301 lab=_53454_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -16610 0 0 {name=X_53454_ }
C {devices/lab_pin.sym} 102810 -16470 0 0 {name=p102302 lab=_84273_/CLK }
C {devices/lab_pin.sym} 102810 -16450 0 0 {name=p102303 lab=_84274_/D }
C {devices/lab_pin.sym} 102990 -16470 0 1 {name=p102304 lab=_64108_/C }
C {sky130_stdcells/dfxtp_4.sym} 102900 -16460 0 0 {name=X_84274_ }
C {devices/lab_pin.sym} 102840 -16340 0 0 {name=p102305 lab=_50657_/A }
C {devices/lab_pin.sym} 102840 -16300 0 0 {name=p102306 lab=_50153_/B }
C {devices/lab_pin.sym} 102960 -16320 0 1 {name=p102307 lab=_50666_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -16320 0 0 {name=X_50666_ }
C {devices/lab_pin.sym} 102810 -16190 0 0 {name=p102308 lab=_81492_/CLK }
C {devices/lab_pin.sym} 102810 -16170 0 0 {name=p102309 lab=_81486_/D }
C {devices/lab_pin.sym} 102990 -16190 0 1 {name=p102310 lab=_81486_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -16180 0 0 {name=X_81486_ }
C {devices/lab_pin.sym} 102810 -16050 0 0 {name=p102311 lab=_85725_/CLK }
C {devices/lab_pin.sym} 102810 -16030 0 0 {name=p102312 lab=_51423_/Y }
C {devices/lab_pin.sym} 102990 -16050 0 1 {name=p102313 lab=_86013_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -16040 0 0 {name=X_86013_ }
C {devices/lab_pin.sym} 102840 -15920 0 0 {name=p102314 lab=_52400_/X }
C {devices/lab_pin.sym} 102840 -15880 0 0 {name=p102315 lab=_50708_/B }
C {devices/lab_pin.sym} 102960 -15900 0 1 {name=p102316 lab=_52405_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -15900 0 0 {name=X_52405_ }
C {devices/lab_pin.sym} 102810 -15770 0 0 {name=p102317 lab=_84350_/CLK }
C {devices/lab_pin.sym} 102810 -15750 0 0 {name=p102318 lab=_72591_/X }
C {devices/lab_pin.sym} 102990 -15770 0 1 {name=p102319 lab=_79343_/B }
C {sky130_stdcells/dfxtp_4.sym} 102900 -15760 0 0 {name=X_83225_ }
C {devices/lab_pin.sym} 102820 -15650 0 0 {name=p102320 lab=_80429_/B }
C {devices/lab_pin.sym} 102820 -15610 0 0 {name=p102321 lab=_80446_/B }
C {devices/lab_pin.sym} 102820 -15570 0 0 {name=p102322 lab=_80436_/X }
C {devices/lab_pin.sym} 102980 -15610 0 1 {name=p102323 lab=_80437_/Y }
C {sky130_stdcells/a21boi_4.sym} 102900 -15610 0 0 {name=X_80437_ }
C {devices/lab_pin.sym} 102860 -15470 0 0 {name=p102324 lab=_68461_/A }
C {devices/lab_pin.sym} 102940 -15470 0 1 {name=p102325 lab=_68160_/A }
C {sky130_stdcells/buf_2.sym} 102900 -15470 0 0 {name=X_68159_ }
C {devices/lab_pin.sym} 102860 -15350 0 0 {name=p102326 lab=_56167_/A }
C {devices/lab_pin.sym} 102940 -15350 0 1 {name=p102327 lab=_56173_/Y }
C {sky130_stdcells/inv_2.sym} 102900 -15350 0 0 {name=X_56173_ }
C {devices/lab_pin.sym} 102820 -15250 0 0 {name=p102328 lab=_53381_/Y }
C {devices/lab_pin.sym} 102820 -15210 0 0 {name=p102329 lab=_53382_/X }
C {devices/lab_pin.sym} 102820 -15170 0 0 {name=p102330 lab=_53384_/X }
C {devices/lab_pin.sym} 102980 -15210 0 1 {name=p102331 lab=_53385_/Y }
C {sky130_stdcells/a21oi_4.sym} 102900 -15210 0 0 {name=X_53385_ }
C {devices/lab_pin.sym} 102840 -15080 0 0 {name=p102332 lab=_50597_/A }
C {devices/lab_pin.sym} 102840 -15040 0 0 {name=p102333 lab=_48955_/X }
C {devices/lab_pin.sym} 102960 -15060 0 1 {name=p102334 lab=_50597_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -15060 0 0 {name=X_50597_ }
C {devices/lab_pin.sym} 102860 -14930 0 0 {name=p102335 lab=_73124_/B }
C {devices/lab_pin.sym} 102940 -14930 0 1 {name=p102336 lab=_73024_/B }
C {sky130_stdcells/buf_2.sym} 102900 -14930 0 0 {name=X_55124_ }
C {devices/lab_pin.sym} 102840 -14820 0 0 {name=p102337 lab=_40350_/A }
C {devices/lab_pin.sym} 102840 -14780 0 0 {name=p102338 lab=_42447_/D }
C {devices/lab_pin.sym} 102960 -14800 0 1 {name=p102339 lab=_41869_/C }
C {sky130_stdcells/nand2_4.sym} 102900 -14800 0 0 {name=X_40350_ }
C {devices/lab_pin.sym} 102840 -14680 0 0 {name=p102340 lab=_52320_/A }
C {devices/lab_pin.sym} 102840 -14640 0 0 {name=p102341 lab=_49031_/A }
C {devices/lab_pin.sym} 102960 -14660 0 1 {name=p102342 lab=_52336_/X }
C {sky130_stdcells/and2_4.sym} 102900 -14660 0 0 {name=X_52336_ }
C {devices/lab_pin.sym} 102860 -14530 0 0 {name=p102343 lab=_71170_/A }
C {devices/lab_pin.sym} 102940 -14530 0 1 {name=p102344 lab=_71181_/C }
C {sky130_stdcells/buf_2.sym} 102900 -14530 0 0 {name=X_71170_ }
C {devices/lab_pin.sym} 102810 -14410 0 0 {name=p102345 lab=_86213_/CLK }
C {devices/lab_pin.sym} 102810 -14390 0 0 {name=p102346 lab=_73317_/X }
C {devices/lab_pin.sym} 102990 -14410 0 1 {name=p102347 lab=_83156_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -14400 0 0 {name=X_83156_ }
C {devices/lab_pin.sym} 102820 -14290 0 0 {name=p102348 lab=_80358_/A }
C {devices/lab_pin.sym} 102820 -14250 0 0 {name=p102349 lab=_80357_/X }
C {devices/lab_pin.sym} 102820 -14210 0 0 {name=p102350 lab=_80367_/Y }
C {devices/lab_pin.sym} 102980 -14250 0 1 {name=p102351 lab=_80368_/Y }
C {sky130_stdcells/a21boi_4.sym} 102900 -14250 0 0 {name=X_80368_ }
C {devices/lab_pin.sym} 102860 -14110 0 0 {name=p102352 lab=_70121_/A }
C {devices/lab_pin.sym} 102940 -14110 0 1 {name=p102353 lab=_70125_/A }
C {sky130_stdcells/inv_2.sym} 102900 -14110 0 0 {name=X_70121_ }
C {devices/lab_pin.sym} 102810 -13990 0 0 {name=p102354 lab=_82349_/CLK }
C {devices/lab_pin.sym} 102810 -13970 0 0 {name=p102355 lab=_82107_/D }
C {devices/lab_pin.sym} 102990 -13990 0 1 {name=p102356 lab=_82107_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -13980 0 0 {name=X_82107_ }
C {devices/lab_pin.sym} 102820 -13870 0 0 {name=p102357 lab=_85327_/Q }
C {devices/lab_pin.sym} 102820 -13830 0 0 {name=p102358 lab=_55046_/X }
C {devices/lab_pin.sym} 102820 -13790 0 0 {name=p102359 lab=_55054_/Y }
C {devices/lab_pin.sym} 102980 -13830 0 1 {name=p102360 lab=_55055_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -13830 0 0 {name=X_55055_ }
C {devices/lab_pin.sym} 102860 -13690 0 0 {name=p102361 lab=_59929_/C }
C {devices/lab_pin.sym} 102940 -13690 0 1 {name=p102362 lab=_59935_/A }
C {sky130_stdcells/inv_2.sym} 102900 -13690 0 0 {name=X_59932_ }
C {devices/lab_pin.sym} 102840 -13590 0 0 {name=p102363 lab=_48894_/A }
C {devices/lab_pin.sym} 102840 -13550 0 0 {name=p102364 lab=_52267_/B }
C {devices/lab_pin.sym} 102840 -13510 0 0 {name=p102365 lab=_52267_/C }
C {devices/lab_pin.sym} 102960 -13550 0 1 {name=p102366 lab=_52267_/X }
C {sky130_stdcells/and3_4.sym} 102900 -13550 0 0 {name=X_52267_ }
C {devices/lab_pin.sym} 102810 -13410 0 0 {name=p102367 lab=_87446_/CLK }
C {devices/lab_pin.sym} 102810 -13390 0 0 {name=p102368 lab=_42241_/Y }
C {devices/lab_pin.sym} 102990 -13410 0 1 {name=p102369 lab=_87964_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -13400 0 0 {name=X_87964_ }
C {devices/lab_pin.sym} 102810 -13270 0 0 {name=p102370 lab=_83187_/CLK }
C {devices/lab_pin.sym} 102810 -13250 0 0 {name=p102371 lab=_74352_/X }
C {devices/lab_pin.sym} 102990 -13270 0 1 {name=p102372 lab=_83087_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -13260 0 0 {name=X_83087_ }
C {devices/lab_pin.sym} 102840 -13140 0 0 {name=p102373 lab=_80296_/Y }
C {devices/lab_pin.sym} 102840 -13100 0 0 {name=p102374 lab=_80299_/B }
C {devices/lab_pin.sym} 102960 -13120 0 1 {name=p102375 lab=_80299_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -13120 0 0 {name=X_80299_ }
C {devices/lab_pin.sym} 102860 -12990 0 0 {name=p102376 lab=_53982_/A }
C {devices/lab_pin.sym} 102940 -12990 0 1 {name=p102377 lab=_54006_/X }
C {sky130_stdcells/buf_2.sym} 102900 -12990 0 0 {name=X_54006_ }
C {devices/lab_pin.sym} 102860 -12870 0 0 {name=p102378 lab=_88068_/Q }
C {devices/lab_pin.sym} 102940 -12870 0 1 {name=p102379 lab=_42020_/Y }
C {sky130_stdcells/inv_2.sym} 102900 -12870 0 0 {name=X_42020_ }
C {devices/lab_pin.sym} 102860 -12750 0 0 {name=p102380 lab=_50946_/A }
C {devices/lab_pin.sym} 102940 -12750 0 1 {name=p102381 lab=_51218_/X }
C {sky130_stdcells/buf_2.sym} 102900 -12750 0 0 {name=X_51218_ }
C {devices/lab_pin.sym} 102820 -12650 0 0 {name=p102382 lab=_68843_/X }
C {devices/lab_pin.sym} 102820 -12610 0 0 {name=p102383 lab=_68845_/X }
C {devices/lab_pin.sym} 102820 -12570 0 0 {name=p102384 lab=_69992_/X }
C {devices/lab_pin.sym} 102980 -12610 0 1 {name=p102385 lab=_70054_/A }
C {sky130_stdcells/a21o_4.sym} 102900 -12610 0 0 {name=X_70052_ }
C {devices/lab_pin.sym} 102810 -12470 0 0 {name=p102386 lab=_86914_/CLK }
C {devices/lab_pin.sym} 102810 -12450 0 0 {name=p102387 lab=_44861_/X }
C {devices/lab_pin.sym} 102990 -12470 0 1 {name=p102388 lab=_86915_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -12460 0 0 {name=X_86915_ }
C {devices/lab_pin.sym} 102810 -12330 0 0 {name=p102389 lab=_82008_/CLK }
C {devices/lab_pin.sym} 102810 -12310 0 0 {name=p102390 lab=_82038_/D }
C {devices/lab_pin.sym} 102990 -12330 0 1 {name=p102391 lab=_82038_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -12320 0 0 {name=X_82038_ }
C {devices/lab_pin.sym} 102860 -12190 0 0 {name=p102392 lab=_59842_/A }
C {devices/lab_pin.sym} 102940 -12190 0 1 {name=p102393 lab=_59873_/A }
C {sky130_stdcells/buf_2.sym} 102900 -12190 0 0 {name=X_59863_ }
C {devices/lab_pin.sym} 102860 -12070 0 0 {name=p102394 lab=_52198_/A }
C {devices/lab_pin.sym} 102940 -12070 0 1 {name=p102395 lab=_52198_/X }
C {sky130_stdcells/buf_2.sym} 102900 -12070 0 0 {name=X_52198_ }
C {devices/lab_pin.sym} 102810 -11950 0 0 {name=p102396 lab=_87382_/CLK }
C {devices/lab_pin.sym} 102810 -11930 0 0 {name=p102397 lab=_87895_/D }
C {devices/lab_pin.sym} 102990 -11950 0 1 {name=p102398 lab=_87895_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -11940 0 0 {name=X_87895_ }
C {devices/lab_pin.sym} 102820 -11830 0 0 {name=p102399 lab=_58813_/X }
C {devices/lab_pin.sym} 102820 -11790 0 0 {name=p102400 lab=_85774_/Q }
C {devices/lab_pin.sym} 102820 -11750 0 0 {name=p102401 lab=_58706_/X }
C {devices/lab_pin.sym} 102980 -11790 0 1 {name=p102402 lab=_58814_/X }
C {sky130_stdcells/o21a_4.sym} 102900 -11790 0 0 {name=X_58814_ }
C {devices/lab_pin.sym} 102860 -11650 0 0 {name=p102403 lab=_51149_/A }
C {devices/lab_pin.sym} 102940 -11650 0 1 {name=p102404 lab=_51160_/B }
C {sky130_stdcells/buf_2.sym} 102900 -11650 0 0 {name=X_51149_ }
C {devices/lab_pin.sym} 102820 -11550 0 0 {name=p102405 lab=_74850_/Y }
C {devices/lab_pin.sym} 102820 -11510 0 0 {name=p102406 lab=_74858_/Y }
C {devices/lab_pin.sym} 102820 -11470 0 0 {name=p102407 lab=_74859_/Y }
C {devices/lab_pin.sym} 102980 -11510 0 1 {name=p102408 lab=_74860_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -11510 0 0 {name=X_74860_ }
C {devices/lab_pin.sym} 102810 -11370 0 0 {name=p102409 lab=_81117_/CLK }
C {devices/lab_pin.sym} 102810 -11350 0 0 {name=p102410 lab=_45902_/Y }
C {devices/lab_pin.sym} 102990 -11370 0 1 {name=p102411 lab=_42447_/C }
C {sky130_stdcells/dfxtp_4.sym} 102900 -11360 0 0 {name=X_86846_ }
C {devices/lab_pin.sym} 102860 -11230 0 0 {name=p102412 lab=_59794_/A }
C {devices/lab_pin.sym} 102940 -11230 0 1 {name=p102413 lab=_59794_/X }
C {sky130_stdcells/buf_2.sym} 102900 -11230 0 0 {name=X_59794_ }
C {devices/lab_pin.sym} 102820 -11140 0 0 {name=p102414 lab=_73786_/X }
C {devices/lab_pin.sym} 102820 -11100 0 0 {name=p102415 lab=_84983_/Q }
C {devices/lab_pin.sym} 102820 -11060 0 0 {name=p102416 lab=_73740_/X }
C {devices/lab_pin.sym} 102820 -11020 0 0 {name=p102417 lab=_73810_/X }
C {devices/lab_pin.sym} 102980 -11080 0 1 {name=p102418 lab=_73812_/B }
C {sky130_stdcells/a211o_4.sym} 102900 -11080 0 0 {name=X_73811_ }
C {devices/lab_pin.sym} 102820 -10950 0 0 {name=p102419 lab=_58742_/Y }
C {devices/lab_pin.sym} 102820 -10910 0 0 {name=p102420 lab=_58744_/Y }
C {devices/lab_pin.sym} 102820 -10870 0 0 {name=p102421 lab=_58646_/X }
C {devices/lab_pin.sym} 102980 -10910 0 1 {name=p102422 lab=_58745_/X }
C {sky130_stdcells/a21o_4.sym} 102900 -10910 0 0 {name=X_58745_ }
C {devices/lab_pin.sym} 102860 -10770 0 0 {name=p102423 lab=_55957_/A }
C {devices/lab_pin.sym} 102940 -10770 0 1 {name=p102424 lab=_56019_/B }
C {sky130_stdcells/buf_2.sym} 102900 -10770 0 0 {name=X_55957_ }
C {devices/lab_pin.sym} 102860 -10650 0 0 {name=p102425 lab=_43971_/A }
C {devices/lab_pin.sym} 102940 -10650 0 1 {name=p102426 lab=_43972_/B }
C {sky130_stdcells/inv_2.sym} 102900 -10650 0 0 {name=X_43971_ }
C {devices/lab_pin.sym} 102840 -10550 0 0 {name=p102427 lab=_70576_/X }
C {devices/lab_pin.sym} 102840 -10510 0 0 {name=p102428 lab=_83831_/Q }
C {devices/lab_pin.sym} 102840 -10470 0 0 {name=p102429 lab=_74764_/A }
C {devices/lab_pin.sym} 102960 -10510 0 1 {name=p102430 lab=_74791_/X }
C {sky130_stdcells/and3_4.sym} 102900 -10510 0 0 {name=X_74791_ }
C {devices/lab_pin.sym} 102810 -10370 0 0 {name=p102431 lab=_86814_/CLK }
C {devices/lab_pin.sym} 102810 -10350 0 0 {name=p102432 lab=_46080_/Y }
C {devices/lab_pin.sym} 102990 -10370 0 1 {name=p102433 lab=_86777_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -10360 0 0 {name=X_86777_ }
C {devices/lab_pin.sym} 102810 -10230 0 0 {name=p102434 lab=_81746_/CLK }
C {devices/lab_pin.sym} 102810 -10210 0 0 {name=p102435 lab=_68298_/X }
C {devices/lab_pin.sym} 102990 -10230 0 1 {name=p102436 lab=_83989_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -10220 0 0 {name=X_83989_ }
C {devices/lab_pin.sym} 102820 -10110 0 0 {name=p102437 lab=_85133_/Q }
C {devices/lab_pin.sym} 102820 -10070 0 0 {name=p102438 lab=_45709_/X }
C {devices/lab_pin.sym} 102820 -10030 0 0 {name=p102439 lab=_45651_/X }
C {devices/lab_pin.sym} 102980 -10070 0 1 {name=p102440 lab=_45710_/X }
C {sky130_stdcells/o21a_4.sym} 102900 -10070 0 0 {name=X_45710_ }
C {devices/lab_pin.sym} 102840 -9940 0 0 {name=p102441 lab=_81371_/Q }
C {devices/lab_pin.sym} 102840 -9900 0 0 {name=p102442 lab=_81627_/D }
C {devices/lab_pin.sym} 102960 -9920 0 1 {name=p102443 lab=_81339_/D }
C {sky130_stdcells/xor2_4.sym} 102900 -9920 0 0 {name=X_76530_ }
C {devices/lab_pin.sym} 102860 -9790 0 0 {name=p102444 lab=_42951_/A }
C {devices/lab_pin.sym} 102940 -9790 0 1 {name=p102445 lab=_42922_/X }
C {sky130_stdcells/buf_2.sym} 102900 -9790 0 0 {name=X_42922_ }
C {devices/lab_pin.sym} 102820 -9690 0 0 {name=p102446 lab=_85355_/Q }
C {devices/lab_pin.sym} 102820 -9650 0 0 {name=p102447 lab=_54892_/X }
C {devices/lab_pin.sym} 102820 -9610 0 0 {name=p102448 lab=_54907_/Y }
C {devices/lab_pin.sym} 102980 -9650 0 1 {name=p102449 lab=_54908_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -9650 0 0 {name=X_54908_ }
C {devices/lab_pin.sym} 102810 -9510 0 0 {name=p102450 lab=_85727_/CLK }
C {devices/lab_pin.sym} 102810 -9490 0 0 {name=p102451 lab=_85728_/D }
C {devices/lab_pin.sym} 102990 -9510 0 1 {name=p102452 lab=_85728_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -9500 0 0 {name=X_85728_ }
C {devices/lab_pin.sym} 102840 -9380 0 0 {name=p102453 lab=_73742_/A }
C {devices/lab_pin.sym} 102840 -9340 0 0 {name=p102454 lab=_86554_/Q }
C {devices/lab_pin.sym} 102960 -9360 0 1 {name=p102455 lab=_73742_/X }
C {sky130_stdcells/and2_4.sym} 102900 -9360 0 0 {name=X_73742_ }
C {devices/lab_pin.sym} 102840 -9260 0 0 {name=p102456 lab=_46717_/A }
C {devices/lab_pin.sym} 102840 -9220 0 0 {name=p102457 lab=_46682_/B }
C {devices/lab_pin.sym} 102840 -9180 0 0 {name=p102458 lab=_46682_/C }
C {devices/lab_pin.sym} 102840 -9140 0 0 {name=p102459 lab=_51787_/D }
C {devices/lab_pin.sym} 102960 -9200 0 1 {name=p102460 lab=_46690_/X }
C {sky130_stdcells/and4_4.sym} 102900 -9200 0 0 {name=X_46690_ }
C {devices/lab_pin.sym} 102840 -9070 0 0 {name=p102461 lab=_70947_/A }
C {devices/lab_pin.sym} 102840 -9030 0 0 {name=p102462 lab=_70954_/B }
C {devices/lab_pin.sym} 102840 -8990 0 0 {name=p102463 lab=_70954_/C }
C {devices/lab_pin.sym} 102960 -9030 0 1 {name=p102464 lab=_70954_/Y }
C {sky130_stdcells/nand3_4.sym} 102900 -9030 0 0 {name=X_70954_ }
C {devices/lab_pin.sym} 102860 -8890 0 0 {name=p102465 lab=_58676_/A }
C {devices/lab_pin.sym} 102940 -8890 0 1 {name=p102466 lab=_58688_/B }
C {sky130_stdcells/buf_2.sym} 102900 -8890 0 0 {name=X_58676_ }
C {devices/lab_pin.sym} 102860 -8770 0 0 {name=p102467 lab=_55534_/A }
C {devices/lab_pin.sym} 102940 -8770 0 1 {name=p102468 lab=_55903_/A }
C {sky130_stdcells/buf_2.sym} 102900 -8770 0 0 {name=X_55888_ }
C {devices/lab_pin.sym} 102820 -8670 0 0 {name=p102469 lab=_45591_/X }
C {devices/lab_pin.sym} 102820 -8630 0 0 {name=p102470 lab=_61513_/A }
C {devices/lab_pin.sym} 102820 -8590 0 0 {name=p102471 lab=_45608_/X }
C {devices/lab_pin.sym} 102980 -8630 0 1 {name=p102472 lab=_45641_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -8630 0 0 {name=X_45641_ }
C {devices/lab_pin.sym} 102860 -8490 0 0 {name=p102473 lab=_72009_/A }
C {devices/lab_pin.sym} 102940 -8490 0 1 {name=p102474 lab=_57627_/X }
C {sky130_stdcells/buf_2.sym} 102900 -8490 0 0 {name=X_57627_ }
C {devices/lab_pin.sym} 102820 -8390 0 0 {name=p102475 lab=_76454_/X }
C {devices/lab_pin.sym} 102820 -8350 0 0 {name=p102476 lab=_76457_/Y }
C {devices/lab_pin.sym} 102820 -8310 0 0 {name=p102477 lab=_76460_/X }
C {devices/lab_pin.sym} 102980 -8350 0 1 {name=p102478 lab=_76461_/X }
C {sky130_stdcells/o21a_4.sym} 102900 -8350 0 0 {name=X_76461_ }
C {devices/lab_pin.sym} 102860 -8210 0 0 {name=p102479 lab=_42832_/A }
C {devices/lab_pin.sym} 102940 -8210 0 1 {name=p102480 lab=_42853_/X }
C {sky130_stdcells/buf_2.sym} 102900 -8210 0 0 {name=X_42853_ }
C {devices/lab_pin.sym} 102860 -8090 0 0 {name=p102481 lab=_54892_/A }
C {devices/lab_pin.sym} 102940 -8090 0 1 {name=p102482 lab=_54839_/X }
C {sky130_stdcells/buf_2.sym} 102900 -8090 0 0 {name=X_54839_ }
C {devices/lab_pin.sym} 102820 -7990 0 0 {name=p102483 lab=_70125_/C }
C {devices/lab_pin.sym} 102820 -7950 0 0 {name=p102484 lab=_86754_/D }
C {devices/lab_pin.sym} 102820 -7910 0 0 {name=p102485 lab=_73672_/X }
C {devices/lab_pin.sym} 102980 -7950 0 1 {name=p102486 lab=_73673_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -7950 0 0 {name=X_73673_ }
C {devices/lab_pin.sym} 102810 -7810 0 0 {name=p102487 lab=_85433_/CLK }
C {devices/lab_pin.sym} 102810 -7790 0 0 {name=p102488 lab=_53304_/Y }
C {devices/lab_pin.sym} 102990 -7810 0 1 {name=p102489 lab=_85659_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -7800 0 0 {name=X_85659_ }
C {devices/lab_pin.sym} 102860 -7670 0 0 {name=p102490 lab=_70885_/A }
C {devices/lab_pin.sym} 102940 -7670 0 1 {name=p102491 lab=_70885_/X }
C {sky130_stdcells/buf_2.sym} 102900 -7670 0 0 {name=X_70885_ }
C {devices/lab_pin.sym} 102820 -7570 0 0 {name=p102492 lab=_78205_/A }
C {devices/lab_pin.sym} 102820 -7530 0 0 {name=p102493 lab=_78204_/A }
C {devices/lab_pin.sym} 102820 -7490 0 0 {name=p102494 lab=_78199_/Y }
C {devices/lab_pin.sym} 102980 -7530 0 1 {name=p102495 lab=_78200_/Y }
C {sky130_stdcells/a21boi_4.sym} 102900 -7530 0 0 {name=X_78200_ }
C {devices/lab_pin.sym} 102860 -7390 0 0 {name=p102496 lab=_75411_/Y }
C {devices/lab_pin.sym} 102940 -7390 0 1 {name=p102497 lab=_75413_/C }
C {sky130_stdcells/inv_2.sym} 102900 -7390 0 0 {name=X_75412_ }
C {devices/lab_pin.sym} 102820 -7310 0 0 {name=p102498 lab=_41802_/X }
C {devices/lab_pin.sym} 102820 -7270 0 0 {name=p102499 lab=_41803_/X }
C {devices/lab_pin.sym} 102820 -7230 0 0 {name=p102500 lab=_40371_/X }
C {devices/lab_pin.sym} 102820 -7190 0 0 {name=p102501 lab=_66621_/B }
C {devices/lab_pin.sym} 102820 -7150 0 0 {name=p102502 lab=_41792_/X }
C {devices/lab_pin.sym} 102980 -7230 0 1 {name=p102503 lab=_41805_/A }
C {sky130_stdcells/o32ai_4.sym} 102900 -7230 0 0 {name=X_41804_ }
C {devices/lab_pin.sym} 102820 -7090 0 0 {name=p102504 lab=_86529_/Q }
C {devices/lab_pin.sym} 102820 -7050 0 0 {name=p102505 lab=_48350_/X }
C {devices/lab_pin.sym} 102820 -7010 0 0 {name=p102506 lab=_48359_/Y }
C {devices/lab_pin.sym} 102980 -7050 0 1 {name=p102507 lab=_48360_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -7050 0 0 {name=X_48360_ }
C {devices/lab_pin.sym} 102820 -6930 0 0 {name=p102508 lab=_79183_/A }
C {devices/lab_pin.sym} 102820 -6890 0 0 {name=p102509 lab=_61349_/X }
C {devices/lab_pin.sym} 102820 -6850 0 0 {name=p102510 lab=_72577_/Y }
C {devices/lab_pin.sym} 102980 -6890 0 1 {name=p102511 lab=_83212_/D }
C {sky130_stdcells/o21ai_4.sym} 102900 -6890 0 0 {name=X_72624_ }
C {devices/lab_pin.sym} 102840 -6760 0 0 {name=p102512 lab=_79180_/A }
C {devices/lab_pin.sym} 102840 -6720 0 0 {name=p102513 lab=_66514_/C }
C {devices/lab_pin.sym} 102960 -6740 0 1 {name=p102514 lab=_79180_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -6740 0 0 {name=X_79180_ }
C {devices/lab_pin.sym} 102840 -6620 0 0 {name=p102515 lab=_45572_/A }
C {devices/lab_pin.sym} 102840 -6580 0 0 {name=p102516 lab=_45617_/B }
C {devices/lab_pin.sym} 102960 -6600 0 1 {name=p102517 lab=_45572_/Y }
C {sky130_stdcells/nor2_4.sym} 102900 -6600 0 0 {name=X_45572_ }
C {devices/lab_pin.sym} 102840 -6480 0 0 {name=p102518 lab=_57552_/X }
C {devices/lab_pin.sym} 102840 -6440 0 0 {name=p102519 lab=_47978_/A }
C {devices/lab_pin.sym} 102960 -6460 0 1 {name=p102520 lab=_57558_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -6460 0 0 {name=X_57558_ }
C {devices/lab_pin.sym} 102810 -6330 0 0 {name=p102521 lab=_87865_/CLK }
C {devices/lab_pin.sym} 102810 -6310 0 0 {name=p102522 lab=_40521_/X }
C {devices/lab_pin.sym} 102990 -6330 0 1 {name=p102523 lab=_88378_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -6320 0 0 {name=X_88378_ }
C {devices/lab_pin.sym} 102840 -6200 0 0 {name=p102524 lab=_76393_/A }
C {devices/lab_pin.sym} 102840 -6160 0 0 {name=p102525 lab=_81567_/Q }
C {devices/lab_pin.sym} 102960 -6180 0 1 {name=p102526 lab=_76392_/Y }
C {sky130_stdcells/nor2_4.sym} 102900 -6180 0 0 {name=X_76392_ }
C {devices/lab_pin.sym} 102820 -6090 0 0 {name=p102527 lab=_42774_/X }
C {devices/lab_pin.sym} 102820 -6050 0 0 {name=p102528 lab=_42775_/X }
C {devices/lab_pin.sym} 102820 -6010 0 0 {name=p102529 lab=_41347_/X }
C {devices/lab_pin.sym} 102820 -5970 0 0 {name=p102530 lab=_87720_/Q }
C {devices/lab_pin.sym} 102820 -5930 0 0 {name=p102531 lab=_42781_/X }
C {devices/lab_pin.sym} 102980 -6010 0 1 {name=p102532 lab=_42785_/A }
C {sky130_stdcells/o32ai_4.sym} 102900 -6010 0 0 {name=X_42784_ }
C {devices/lab_pin.sym} 102840 -5880 0 0 {name=p102533 lab=_47330_/A }
C {devices/lab_pin.sym} 102840 -5840 0 0 {name=p102534 lab=_47311_/B }
C {devices/lab_pin.sym} 102840 -5800 0 0 {name=p102535 lab=_47321_/C }
C {devices/lab_pin.sym} 102840 -5760 0 0 {name=p102536 lab=_52977_/D }
C {devices/lab_pin.sym} 102960 -5820 0 1 {name=p102537 lab=_47311_/X }
C {sky130_stdcells/and4_4.sym} 102900 -5820 0 0 {name=X_47311_ }
C {devices/lab_pin.sym} 102840 -5680 0 0 {name=p102538 lab=_78105_/Y }
C {devices/lab_pin.sym} 102840 -5640 0 0 {name=p102539 lab=_78131_/B }
C {devices/lab_pin.sym} 102960 -5660 0 1 {name=p102540 lab=_78131_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -5660 0 0 {name=X_78131_ }
C {devices/lab_pin.sym} 102820 -5570 0 0 {name=p102541 lab=_44512_/X }
C {devices/lab_pin.sym} 102820 -5530 0 0 {name=p102542 lab=_44513_/X }
C {devices/lab_pin.sym} 102820 -5490 0 0 {name=p102543 lab=_40780_/Y }
C {devices/lab_pin.sym} 102820 -5450 0 0 {name=p102544 lab=_44522_/Y }
C {devices/lab_pin.sym} 102820 -5410 0 0 {name=p102545 lab=_44516_/X }
C {devices/lab_pin.sym} 102980 -5490 0 1 {name=p102546 lab=_87068_/D }
C {sky130_stdcells/o32ai_4.sym} 102900 -5490 0 0 {name=X_44523_ }
C {devices/lab_pin.sym} 102860 -5330 0 0 {name=p102547 lab=_56448_/X }
C {devices/lab_pin.sym} 102940 -5330 0 1 {name=p102548 lab=_56520_/B }
C {sky130_stdcells/buf_2.sym} 102900 -5330 0 0 {name=X_56509_ }
C {devices/lab_pin.sym} 102820 -5230 0 0 {name=p102549 lab=_75326_/X }
C {devices/lab_pin.sym} 102820 -5190 0 0 {name=p102550 lab=_75322_/X }
C {devices/lab_pin.sym} 102820 -5150 0 0 {name=p102551 lab=_75323_/X }
C {devices/lab_pin.sym} 102980 -5190 0 1 {name=p102552 lab=_75343_/Y }
C {sky130_stdcells/a21oi_4.sym} 102900 -5190 0 0 {name=X_75343_ }
C {devices/lab_pin.sym} 102810 -5050 0 0 {name=p102553 lab=_87850_/CLK }
C {devices/lab_pin.sym} 102810 -5030 0 0 {name=p102554 lab=_87329_/D }
C {devices/lab_pin.sym} 102990 -5050 0 1 {name=p102555 lab=_87329_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -5040 0 0 {name=X_87329_ }
C {devices/lab_pin.sym} 102860 -4910 0 0 {name=p102556 lab=_41734_/X }
C {devices/lab_pin.sym} 102940 -4910 0 1 {name=p102557 lab=_41735_/X }
C {sky130_stdcells/buf_2.sym} 102900 -4910 0 0 {name=X_41735_ }
C {devices/lab_pin.sym} 102840 -4810 0 0 {name=p102558 lab=_52039_/A }
C {devices/lab_pin.sym} 102840 -4770 0 0 {name=p102559 lab=_48286_/X }
C {devices/lab_pin.sym} 102840 -4730 0 0 {name=p102560 lab=_48287_/C }
C {devices/lab_pin.sym} 102960 -4770 0 1 {name=p102561 lab=_48291_/X }
C {sky130_stdcells/and3_4.sym} 102900 -4770 0 0 {name=X_48291_ }
C {devices/lab_pin.sym} 102840 -4660 0 0 {name=p102562 lab=_72516_/C }
C {devices/lab_pin.sym} 102840 -4620 0 0 {name=p102563 lab=_72555_/B }
C {devices/lab_pin.sym} 102840 -4580 0 0 {name=p102564 lab=_72563_/C }
C {devices/lab_pin.sym} 102840 -4540 0 0 {name=p102565 lab=_72607_/C }
C {devices/lab_pin.sym} 102960 -4600 0 1 {name=p102566 lab=_72572_/A }
C {sky130_stdcells/nand4_4.sym} 102900 -4600 0 0 {name=X_72555_ }
C {devices/lab_pin.sym} 102840 -4460 0 0 {name=p102567 lab=_47819_/A }
C {devices/lab_pin.sym} 102840 -4420 0 0 {name=p102568 lab=_57489_/B }
C {devices/lab_pin.sym} 102960 -4440 0 1 {name=p102569 lab=_57489_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -4440 0 0 {name=X_57489_ }
C {devices/lab_pin.sym} 102860 -4310 0 0 {name=p102570 lab=_47242_/A }
C {devices/lab_pin.sym} 102940 -4310 0 1 {name=p102571 lab=_54102_/B }
C {sky130_stdcells/inv_2.sym} 102900 -4310 0 0 {name=X_47242_ }
C {devices/lab_pin.sym} 102820 -4220 0 0 {name=p102572 lab=_59216_/Y }
C {devices/lab_pin.sym} 102820 -4180 0 0 {name=p102573 lab=_59145_/X }
C {devices/lab_pin.sym} 102820 -4140 0 0 {name=p102574 lab=_59223_/X }
C {devices/lab_pin.sym} 102820 -4100 0 0 {name=p102575 lab=_59227_/X }
C {devices/lab_pin.sym} 102980 -4160 0 1 {name=p102576 lab=_84759_/D }
C {sky130_stdcells/a22oi_4.sym} 102900 -4160 0 0 {name=X_59228_ }
C {devices/lab_pin.sym} 102840 -4040 0 0 {name=p102577 lab=_70886_/A }
C {devices/lab_pin.sym} 102840 -4000 0 0 {name=p102578 lab=_71735_/C }
C {devices/lab_pin.sym} 102840 -3960 0 0 {name=p102579 lab=_71263_/D }
C {devices/lab_pin.sym} 102840 -3920 0 0 {name=p102580 lab=_70500_/B }
C {devices/lab_pin.sym} 102960 -3980 0 1 {name=p102581 lab=_71507_/B }
C {sky130_stdcells/nand4_4.sym} 102900 -3980 0 0 {name=X_71506_ }
C {devices/lab_pin.sym} 102840 -3840 0 0 {name=p102582 lab=_60789_/C }
C {devices/lab_pin.sym} 102840 -3800 0 0 {name=p102583 lab=_78062_/B }
C {devices/lab_pin.sym} 102960 -3820 0 1 {name=p102584 lab=_78062_/X }
C {sky130_stdcells/xor2_4.sym} 102900 -3820 0 0 {name=X_78062_ }
C {devices/lab_pin.sym} 102860 -3690 0 0 {name=p102585 lab=_44454_/A }
C {devices/lab_pin.sym} 102940 -3690 0 1 {name=p102586 lab=_44454_/X }
C {sky130_stdcells/buf_2.sym} 102900 -3690 0 0 {name=X_44454_ }
C {devices/lab_pin.sym} 102860 -3570 0 0 {name=p102587 lab=_75274_/A }
C {devices/lab_pin.sym} 102940 -3570 0 1 {name=p102588 lab=_75274_/Y }
C {sky130_stdcells/inv_2.sym} 102900 -3570 0 0 {name=X_75274_ }
C {devices/lab_pin.sym} 102820 -3470 0 0 {name=p102589 lab=_41628_/X }
C {devices/lab_pin.sym} 102820 -3430 0 0 {name=p102590 lab=_81754_/Q }
C {devices/lab_pin.sym} 102820 -3390 0 0 {name=p102591 lab=_41665_/X }
C {devices/lab_pin.sym} 102980 -3430 0 1 {name=p102592 lab=_41666_/X }
C {sky130_stdcells/o21a_4.sym} 102900 -3430 0 0 {name=X_41666_ }
C {devices/lab_pin.sym} 102840 -3300 0 0 {name=p102593 lab=_63562_/A }
C {devices/lab_pin.sym} 102840 -3260 0 0 {name=p102594 lab=_72488_/B }
C {devices/lab_pin.sym} 102960 -3280 0 1 {name=p102595 lab=_72486_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -3280 0 0 {name=X_72486_ }
C {devices/lab_pin.sym} 102840 -3160 0 0 {name=p102596 lab=_77013_/A }
C {devices/lab_pin.sym} 102840 -3120 0 0 {name=p102597 lab=_77013_/B }
C {devices/lab_pin.sym} 102960 -3140 0 1 {name=p102598 lab=_77013_/Y }
C {sky130_stdcells/nand2_4.sym} 102900 -3140 0 0 {name=X_77013_ }
C {devices/lab_pin.sym} 102820 -3050 0 0 {name=p102599 lab=_43399_/X }
C {devices/lab_pin.sym} 102820 -3010 0 0 {name=p102600 lab=_43404_/X }
C {devices/lab_pin.sym} 102820 -2970 0 0 {name=p102601 lab=_41493_/X }
C {devices/lab_pin.sym} 102820 -2930 0 0 {name=p102602 lab=_87437_/Q }
C {devices/lab_pin.sym} 102820 -2890 0 0 {name=p102603 lab=_43378_/X }
C {devices/lab_pin.sym} 102980 -2970 0 1 {name=p102604 lab=_43405_/Y }
C {sky130_stdcells/o32ai_4.sym} 102900 -2970 0 0 {name=X_43405_ }
C {devices/lab_pin.sym} 102820 -2840 0 0 {name=p102605 lab=_41973_/Y }
C {devices/lab_pin.sym} 102820 -2800 0 0 {name=p102606 lab=_73930_/X }
C {devices/lab_pin.sym} 102820 -2760 0 0 {name=p102607 lab=_73031_/X }
C {devices/lab_pin.sym} 102820 -2720 0 0 {name=p102608 lab=_74224_/Y }
C {devices/lab_pin.sym} 102980 -2780 0 1 {name=p102609 lab=_74225_/X }
C {sky130_stdcells/a211o_4.sym} 102900 -2780 0 0 {name=X_74225_ }
C {devices/lab_pin.sym} 102860 -2630 0 0 {name=p102610 lab=_40616_/Y }
C {devices/lab_pin.sym} 102940 -2630 0 1 {name=p102611 lab=_40617_/X }
C {sky130_stdcells/buf_2.sym} 102900 -2630 0 0 {name=X_40617_ }
C {devices/lab_pin.sym} 102860 -2510 0 0 {name=p102612 lab=_83694_/Q }
C {devices/lab_pin.sym} 102940 -2510 0 1 {name=p102613 lab=_54587_/B }
C {sky130_stdcells/inv_2.sym} 102900 -2510 0 0 {name=X_47173_ }
C {devices/lab_pin.sym} 102840 -2420 0 0 {name=p102614 lab=_71432_/A }
C {devices/lab_pin.sym} 102840 -2380 0 0 {name=p102615 lab=_71435_/B }
C {devices/lab_pin.sym} 102840 -2340 0 0 {name=p102616 lab=_70790_/A }
C {devices/lab_pin.sym} 102840 -2300 0 0 {name=p102617 lab=_71432_/D }
C {devices/lab_pin.sym} 102960 -2360 0 1 {name=p102618 lab=_71437_/X }
C {sky130_stdcells/and4_4.sym} 102900 -2360 0 0 {name=X_71437_ }
C {devices/lab_pin.sym} 102860 -2210 0 0 {name=p102619 lab=_59159_/A }
C {devices/lab_pin.sym} 102940 -2210 0 1 {name=p102620 lab=_59159_/Y }
C {sky130_stdcells/inv_2.sym} 102900 -2210 0 0 {name=X_59159_ }
C {devices/lab_pin.sym} 102860 -2090 0 0 {name=p102621 lab=_44385_/A }
C {devices/lab_pin.sym} 102940 -2090 0 1 {name=p102622 lab=_44385_/Y }
C {sky130_stdcells/inv_2.sym} 102900 -2090 0 0 {name=X_44385_ }
C {devices/lab_pin.sym} 102820 -2010 0 0 {name=p102623 lab=_41540_/X }
C {devices/lab_pin.sym} 102820 -1970 0 0 {name=p102624 lab=_41541_/X }
C {devices/lab_pin.sym} 102820 -1930 0 0 {name=p102625 lab=_41596_/X }
C {devices/lab_pin.sym} 102820 -1890 0 0 {name=p102626 lab=_88185_/Q }
C {devices/lab_pin.sym} 102820 -1850 0 0 {name=p102627 lab=_41537_/X }
C {devices/lab_pin.sym} 102980 -1930 0 1 {name=p102628 lab=_41597_/Y }
C {sky130_stdcells/o32ai_4.sym} 102900 -1930 0 0 {name=X_41597_ }
C {devices/lab_pin.sym} 102860 -1770 0 0 {name=p102629 lab=_46124_/A }
C {devices/lab_pin.sym} 102940 -1770 0 1 {name=p102630 lab=_46125_/A }
C {sky130_stdcells/inv_2.sym} 102900 -1770 0 0 {name=X_46124_ }
C {devices/lab_pin.sym} 102860 -1650 0 0 {name=p102631 lab=_43287_/A }
C {devices/lab_pin.sym} 102940 -1650 0 1 {name=p102632 lab=_43336_/X }
C {sky130_stdcells/buf_2.sym} 102900 -1650 0 0 {name=X_43336_ }
C {devices/lab_pin.sym} 102840 -1560 0 0 {name=p102633 lab=_59730_/A }
C {devices/lab_pin.sym} 102840 -1520 0 0 {name=p102634 lab=_62170_/B }
C {devices/lab_pin.sym} 102840 -1480 0 0 {name=p102635 lab=_62158_/C }
C {devices/lab_pin.sym} 102840 -1440 0 0 {name=p102636 lab=_63342_/B }
C {devices/lab_pin.sym} 102960 -1500 0 1 {name=p102637 lab=_62170_/X }
C {sky130_stdcells/and4_4.sym} 102900 -1500 0 0 {name=X_62170_ }
C {devices/lab_pin.sym} 102860 -1350 0 0 {name=p102638 lab=_73165_/A }
C {devices/lab_pin.sym} 102940 -1350 0 1 {name=p102639 lab=_74237_/A }
C {sky130_stdcells/buf_2.sym} 102900 -1350 0 0 {name=X_74156_ }
C {devices/lab_pin.sym} 102860 -1230 0 0 {name=p102640 lab=_40547_/Y }
C {devices/lab_pin.sym} 102940 -1230 0 1 {name=p102641 lab=_40548_/X }
C {sky130_stdcells/buf_2.sym} 102900 -1230 0 0 {name=X_40548_ }
C {devices/lab_pin.sym} 102860 -1110 0 0 {name=p102642 lab=_71090_/A }
C {devices/lab_pin.sym} 102940 -1110 0 1 {name=p102643 lab=_71439_/C }
C {sky130_stdcells/buf_2.sym} 102900 -1110 0 0 {name=X_71368_ }
C {devices/lab_pin.sym} 102860 -990 0 0 {name=p102644 lab=clkbuf_9_141_0_CLK/X }
C {devices/lab_pin.sym} 102940 -990 0 1 {name=p102645 lab=_83372_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 102900 -990 0 0 {name=Xclkbuf_10_282_0_CLK }
C {devices/lab_pin.sym} 102860 -870 0 0 {name=p102646 lab=_61120_/Y }
C {devices/lab_pin.sym} 102940 -870 0 1 {name=p102647 lab=_64203_/B }
C {sky130_stdcells/buf_2.sym} 102900 -870 0 0 {name=X_61121_ }
C {devices/lab_pin.sym} 102820 -780 0 0 {name=p102648 lab=_69734_/Y }
C {devices/lab_pin.sym} 102820 -740 0 0 {name=p102649 lab=_73195_/A }
C {devices/lab_pin.sym} 102820 -700 0 0 {name=p102650 lab=_72889_/X }
C {devices/lab_pin.sym} 102820 -660 0 0 {name=p102651 lab=_73106_/Y }
C {devices/lab_pin.sym} 102980 -720 0 1 {name=p102652 lab=_73107_/X }
C {sky130_stdcells/a211o_4.sym} 102900 -720 0 0 {name=X_73107_ }
C {devices/lab_pin.sym} 103740 -42190 0 0 {name=p102653 lab=_46046_/X }
C {devices/lab_pin.sym} 103740 -42150 0 0 {name=p102654 lab=_46054_/X }
C {devices/lab_pin.sym} 103740 -42110 0 0 {name=p102655 lab=_41535_/X }
C {devices/lab_pin.sym} 103740 -42070 0 0 {name=p102656 lab=_86791_/Q }
C {devices/lab_pin.sym} 103740 -42030 0 0 {name=p102657 lab=_46047_/X }
C {devices/lab_pin.sym} 103900 -42110 0 1 {name=p102658 lab=_46055_/Y }
C {sky130_stdcells/o32ai_4.sym} 103820 -42110 0 0 {name=X_46055_ }
C {devices/lab_pin.sym} 103740 -41970 0 0 {name=p102659 lab=_70317_/Y }
C {devices/lab_pin.sym} 103740 -41930 0 0 {name=p102660 lab=_70157_/A }
C {devices/lab_pin.sym} 103740 -41890 0 0 {name=p102661 lab=_70318_/Y }
C {devices/lab_pin.sym} 103900 -41930 0 1 {name=p102662 lab=_70319_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -41930 0 0 {name=X_70319_ }
C {devices/lab_pin.sym} 103740 -41820 0 0 {name=p102663 lab=_41104_/X }
C {devices/lab_pin.sym} 103740 -41780 0 0 {name=p102664 lab=_43264_/X }
C {devices/lab_pin.sym} 103740 -41740 0 0 {name=p102665 lab=_87509_/Q }
C {devices/lab_pin.sym} 103740 -41700 0 0 {name=p102666 lab=_43265_/X }
C {devices/lab_pin.sym} 103900 -41760 0 1 {name=p102667 lab=_87509_/D }
C {sky130_stdcells/a2bb2o_4.sym} 103820 -41760 0 0 {name=X_43267_ }
C {devices/lab_pin.sym} 103780 -41610 0 0 {name=p102668 lab=_72880_/A }
C {devices/lab_pin.sym} 103860 -41610 0 1 {name=p102669 lab=_74087_/X }
C {sky130_stdcells/buf_2.sym} 103820 -41610 0 0 {name=X_74087_ }
C {devices/lab_pin.sym} 103760 -41500 0 0 {name=p102670 lab=_78970_/B }
C {devices/lab_pin.sym} 103760 -41460 0 0 {name=p102671 lab=_78964_/B }
C {devices/lab_pin.sym} 103880 -41480 0 1 {name=p102672 lab=_78965_/B }
C {sky130_stdcells/xnor2_4.sym} 103820 -41480 0 0 {name=X_78964_ }
C {devices/lab_pin.sym} 103740 -41370 0 0 {name=p102673 lab=_40456_/X }
C {devices/lab_pin.sym} 103740 -41330 0 0 {name=p102674 lab=_81167_/Q }
C {devices/lab_pin.sym} 103740 -41290 0 0 {name=p102675 lab=_40478_/X }
C {devices/lab_pin.sym} 103900 -41330 0 1 {name=p102676 lab=_40479_/X }
C {sky130_stdcells/o21a_4.sym} 103820 -41330 0 0 {name=X_40479_ }
C {devices/lab_pin.sym} 103740 -41210 0 0 {name=p102677 lab=_48016_/B }
C {devices/lab_pin.sym} 103740 -41170 0 0 {name=p102678 lab=_71290_/X }
C {devices/lab_pin.sym} 103740 -41130 0 0 {name=p102679 lab=_71298_/Y }
C {devices/lab_pin.sym} 103900 -41170 0 1 {name=p102680 lab=_83544_/D }
C {sky130_stdcells/o21ai_4.sym} 103820 -41170 0 0 {name=X_71299_ }
C {devices/lab_pin.sym} 103780 -41030 0 0 {name=p102681 lab=clkbuf_9_32_0_CLK/X }
C {devices/lab_pin.sym} 103860 -41030 0 1 {name=p102682 lab=_80671_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 103820 -41030 0 0 {name=Xclkbuf_10_64_0_CLK }
C {devices/lab_pin.sym} 103780 -40910 0 0 {name=p102683 lab=_83035_/Q }
C {devices/lab_pin.sym} 103860 -40910 0 1 {name=p102684 lab=_45007_/A }
C {sky130_stdcells/inv_2.sym} 103820 -40910 0 0 {name=X_45006_ }
C {devices/lab_pin.sym} 103740 -40820 0 0 {name=p102685 lab=_41352_/X }
C {devices/lab_pin.sym} 103740 -40780 0 0 {name=p102686 lab=_42209_/X }
C {devices/lab_pin.sym} 103740 -40740 0 0 {name=p102687 lab=_87975_/Q }
C {devices/lab_pin.sym} 103740 -40700 0 0 {name=p102688 lab=_42210_/X }
C {devices/lab_pin.sym} 103900 -40760 0 1 {name=p102689 lab=_87975_/D }
C {sky130_stdcells/a2bb2o_4.sym} 103820 -40760 0 0 {name=X_42218_ }
C {devices/lab_pin.sym} 103740 -40630 0 0 {name=p102690 lab=_77910_/Y }
C {devices/lab_pin.sym} 103740 -40590 0 0 {name=p102691 lab=_77902_/B }
C {devices/lab_pin.sym} 103740 -40550 0 0 {name=p102692 lab=_77914_/Y }
C {devices/lab_pin.sym} 103900 -40590 0 1 {name=p102693 lab=_77916_/B }
C {sky130_stdcells/o21ai_4.sym} 103820 -40590 0 0 {name=X_77915_ }
C {devices/lab_pin.sym} 103780 -40450 0 0 {name=p102694 lab=_60715_/X }
C {devices/lab_pin.sym} 103860 -40450 0 1 {name=p102695 lab=_61138_/B }
C {sky130_stdcells/buf_2.sym} 103820 -40450 0 0 {name=X_61052_ }
C {devices/lab_pin.sym} 103740 -40350 0 0 {name=p102696 lab=_73034_/X }
C {devices/lab_pin.sym} 103740 -40310 0 0 {name=p102697 lab=_73037_/X }
C {devices/lab_pin.sym} 103740 -40270 0 0 {name=p102698 lab=_72737_/A }
C {devices/lab_pin.sym} 103900 -40310 0 1 {name=p102699 lab=_73038_/X }
C {sky130_stdcells/a21o_4.sym} 103820 -40310 0 0 {name=X_73038_ }
C {devices/lab_pin.sym} 103780 -40170 0 0 {name=p102700 lab=_43197_/Y }
C {devices/lab_pin.sym} 103860 -40170 0 1 {name=p102701 lab=_43198_/Y }
C {sky130_stdcells/inv_2.sym} 103820 -40170 0 0 {name=X_43198_ }
C {devices/lab_pin.sym} 103780 -40050 0 0 {name=p102702 lab=_78885_/B }
C {devices/lab_pin.sym} 103860 -40050 0 1 {name=p102703 lab=_82507_/D }
C {sky130_stdcells/inv_2.sym} 103820 -40050 0 0 {name=X_78895_ }
C {devices/lab_pin.sym} 103780 -39930 0 0 {name=p102704 lab=clkbuf_8_211_0_CLK/A }
C {devices/lab_pin.sym} 103860 -39930 0 1 {name=p102705 lab=clkbuf_8_210_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 103820 -39930 0 0 {name=Xclkbuf_8_210_0_CLK }
C {devices/lab_pin.sym} 103760 -39830 0 0 {name=p102706 lab=_59913_/X }
C {devices/lab_pin.sym} 103760 -39790 0 0 {name=p102707 lab=_60091_/B }
C {devices/lab_pin.sym} 103760 -39750 0 0 {name=p102708 lab=_60091_/C }
C {devices/lab_pin.sym} 103880 -39790 0 1 {name=p102709 lab=_60003_/Y }
C {sky130_stdcells/nand3_4.sym} 103820 -39790 0 0 {name=X_60003_ }
C {devices/lab_pin.sym} 103740 -39670 0 0 {name=p102710 lab=_57991_/B }
C {devices/lab_pin.sym} 103740 -39630 0 0 {name=p102711 lab=_49798_/X }
C {devices/lab_pin.sym} 103740 -39590 0 0 {name=p102712 lab=_49813_/Y }
C {devices/lab_pin.sym} 103900 -39630 0 1 {name=p102713 lab=_49814_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -39630 0 0 {name=X_49814_ }
C {devices/lab_pin.sym} 103780 -39490 0 0 {name=p102714 lab=_41911_/A }
C {devices/lab_pin.sym} 103860 -39490 0 1 {name=p102715 lab=_42162_/A }
C {sky130_stdcells/buf_2.sym} 103820 -39490 0 0 {name=X_42149_ }
C {devices/lab_pin.sym} 103780 -39370 0 0 {name=p102716 lab=_65718_/A }
C {devices/lab_pin.sym} 103860 -39370 0 1 {name=p102717 lab=_65860_/X }
C {sky130_stdcells/buf_2.sym} 103820 -39370 0 0 {name=X_65860_ }
C {devices/lab_pin.sym} 103780 -39250 0 0 {name=p102718 lab=clkbuf_6_54_0_CLK/X }
C {devices/lab_pin.sym} 103860 -39250 0 1 {name=p102719 lab=clkbuf_8_219_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 103820 -39250 0 0 {name=Xclkbuf_7_109_0_CLK }
C {devices/lab_pin.sym} 103780 -39130 0 0 {name=p102720 lab=clkbuf_9_148_0_CLK/X }
C {devices/lab_pin.sym} 103860 -39130 0 1 {name=p102721 lab=_84358_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 103820 -39130 0 0 {name=Xclkbuf_10_297_0_CLK }
C {devices/lab_pin.sym} 103760 -39020 0 0 {name=p102722 lab=_77844_/Y }
C {devices/lab_pin.sym} 103760 -38980 0 0 {name=p102723 lab=_77845_/Y }
C {devices/lab_pin.sym} 103880 -39000 0 1 {name=p102724 lab=_77849_/A }
C {sky130_stdcells/xor2_4.sym} 103820 -39000 0 0 {name=X_77846_ }
C {devices/lab_pin.sym} 103740 -38900 0 0 {name=p102725 lab=_64809_/X }
C {devices/lab_pin.sym} 103740 -38860 0 0 {name=p102726 lab=_83306_/Q }
C {devices/lab_pin.sym} 103740 -38820 0 0 {name=p102727 lab=_64733_/X }
C {devices/lab_pin.sym} 103740 -38780 0 0 {name=p102728 lab=_64810_/X }
C {devices/lab_pin.sym} 103900 -38840 0 1 {name=p102729 lab=_64811_/X }
C {sky130_stdcells/a211o_4.sym} 103820 -38840 0 0 {name=X_64811_ }
C {devices/lab_pin.sym} 103740 -38710 0 0 {name=p102730 lab=_57820_/B }
C {devices/lab_pin.sym} 103740 -38670 0 0 {name=p102731 lab=_49742_/X }
C {devices/lab_pin.sym} 103740 -38630 0 0 {name=p102732 lab=_49744_/Y }
C {devices/lab_pin.sym} 103900 -38670 0 1 {name=p102733 lab=_49745_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -38670 0 0 {name=X_49745_ }
C {devices/lab_pin.sym} 103780 -38530 0 0 {name=p102734 lab=_83717_/Q }
C {devices/lab_pin.sym} 103860 -38530 0 1 {name=p102735 lab=_54464_/B }
C {sky130_stdcells/inv_2.sym} 103820 -38530 0 0 {name=X_46957_ }
C {devices/lab_pin.sym} 103780 -38410 0 0 {name=p102736 lab=_65791_/A }
C {devices/lab_pin.sym} 103860 -38410 0 1 {name=p102737 lab=_65804_/A }
C {sky130_stdcells/buf_2.sym} 103820 -38410 0 0 {name=X_65791_ }
C {devices/lab_pin.sym} 103760 -38300 0 0 {name=p102738 lab=_77763_/Y }
C {devices/lab_pin.sym} 103760 -38260 0 0 {name=p102739 lab=_77766_/Y }
C {devices/lab_pin.sym} 103880 -38280 0 1 {name=p102740 lab=_77777_/Y }
C {sky130_stdcells/nor2_4.sym} 103820 -38280 0 0 {name=X_77777_ }
C {devices/lab_pin.sym} 103780 -38150 0 0 {name=p102741 lab=clkbuf_9_39_0_CLK/X }
C {devices/lab_pin.sym} 103860 -38150 0 1 {name=p102742 lab=_84420_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 103820 -38150 0 0 {name=Xclkbuf_10_79_0_CLK }
C {devices/lab_pin.sym} 103760 -38050 0 0 {name=p102743 lab=_74987_/B }
C {devices/lab_pin.sym} 103760 -38010 0 0 {name=p102744 lab=_81140_/D }
C {devices/lab_pin.sym} 103760 -37970 0 0 {name=p102745 lab=_74989_/C }
C {devices/lab_pin.sym} 103880 -38010 0 1 {name=p102746 lab=_74990_/A }
C {sky130_stdcells/nand3_4.sym} 103820 -38010 0 0 {name=X_74989_ }
C {devices/lab_pin.sym} 103740 -37890 0 0 {name=p102747 lab=_79503_/A }
C {devices/lab_pin.sym} 103740 -37850 0 0 {name=p102748 lab=_79503_/B }
C {devices/lab_pin.sym} 103740 -37810 0 0 {name=p102749 lab=_79515_/Y }
C {devices/lab_pin.sym} 103900 -37850 0 1 {name=p102750 lab=_79517_/B }
C {sky130_stdcells/a21boi_4.sym} 103820 -37850 0 0 {name=X_79516_ }
C {devices/lab_pin.sym} 103760 -37720 0 0 {name=p102751 lab=_67575_/A }
C {devices/lab_pin.sym} 103760 -37680 0 0 {name=p102752 lab=_88235_/Q }
C {devices/lab_pin.sym} 103880 -37700 0 1 {name=p102753 lab=_67530_/X }
C {sky130_stdcells/and2_4.sym} 103820 -37700 0 0 {name=X_67530_ }
C {devices/lab_pin.sym} 103780 -37570 0 0 {name=p102754 lab=_44039_/X }
C {devices/lab_pin.sym} 103860 -37570 0 1 {name=p102755 lab=_45909_/A }
C {sky130_stdcells/buf_2.sym} 103820 -37570 0 0 {name=X_45908_ }
C {devices/lab_pin.sym} 103740 -37470 0 0 {name=p102756 lab=_64737_/Y }
C {devices/lab_pin.sym} 103740 -37430 0 0 {name=p102757 lab=_64662_/X }
C {devices/lab_pin.sym} 103740 -37390 0 0 {name=p102758 lab=_64741_/Y }
C {devices/lab_pin.sym} 103900 -37430 0 1 {name=p102759 lab=_84229_/D }
C {sky130_stdcells/a21o_4.sym} 103820 -37430 0 0 {name=X_64742_ }
C {devices/lab_pin.sym} 103760 -37300 0 0 {name=p102760 lab=_76728_/A }
C {devices/lab_pin.sym} 103760 -37260 0 0 {name=p102761 lab=_76728_/B }
C {devices/lab_pin.sym} 103880 -37280 0 1 {name=p102762 lab=_76728_/Y }
C {sky130_stdcells/xnor2_4.sym} 103820 -37280 0 0 {name=X_76728_ }
C {devices/lab_pin.sym} 103740 -37170 0 0 {name=p102763 lab=_86343_/Q }
C {devices/lab_pin.sym} 103740 -37130 0 0 {name=p102764 lab=_49660_/X }
C {devices/lab_pin.sym} 103740 -37090 0 0 {name=p102765 lab=_49675_/Y }
C {devices/lab_pin.sym} 103900 -37130 0 1 {name=p102766 lab=_49676_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -37130 0 0 {name=X_49676_ }
C {devices/lab_pin.sym} 103780 -36990 0 0 {name=p102767 lab=_58335_/A }
C {devices/lab_pin.sym} 103860 -36990 0 1 {name=p102768 lab=_61954_/X }
C {sky130_stdcells/buf_2.sym} 103820 -36990 0 0 {name=X_61954_ }
C {devices/lab_pin.sym} 103780 -36870 0 0 {name=p102769 lab=clkbuf_8_225_0_CLK/A }
C {devices/lab_pin.sym} 103860 -36870 0 1 {name=p102770 lab=clkbuf_9_451_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 103820 -36870 0 0 {name=Xclkbuf_8_225_0_CLK }
C {devices/lab_pin.sym} 103760 -36760 0 0 {name=p102771 lab=_46860_/X }
C {devices/lab_pin.sym} 103760 -36720 0 0 {name=p102772 lab=_51043_/B }
C {devices/lab_pin.sym} 103880 -36740 0 1 {name=p102773 lab=_46888_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -36740 0 0 {name=X_46888_ }
C {devices/lab_pin.sym} 103780 -36610 0 0 {name=p102774 lab=clkbuf_9_110_0_CLK/X }
C {devices/lab_pin.sym} 103860 -36610 0 1 {name=p102775 lab=_84241_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 103820 -36610 0 0 {name=Xclkbuf_10_220_0_CLK }
C {devices/lab_pin.sym} 103780 -36490 0 0 {name=p102776 lab=_48627_/A }
C {devices/lab_pin.sym} 103860 -36490 0 1 {name=p102777 lab=_48628_/B }
C {sky130_stdcells/buf_2.sym} 103820 -36490 0 0 {name=X_48627_ }
C {devices/lab_pin.sym} 103740 -36410 0 0 {name=p102778 lab=_60997_/A }
C {devices/lab_pin.sym} 103740 -36370 0 0 {name=p102779 lab=_64081_/C }
C {devices/lab_pin.sym} 103740 -36330 0 0 {name=p102780 lab=_60889_/X }
C {devices/lab_pin.sym} 103740 -36290 0 0 {name=p102781 lab=_60864_/X }
C {devices/lab_pin.sym} 103740 -36260 0 0 {name=p102782 lab=_69814_/A }
C {devices/lab_pin.sym} 103900 -36330 0 1 {name=p102783 lab=_60905_/Y }
C {sky130_stdcells/a41oi_4.sym} 103820 -36330 0 0 {name=X_60905_ }
C {devices/lab_pin.sym} 103740 -36200 0 0 {name=p102784 lab=_87918_/Q }
C {devices/lab_pin.sym} 103740 -36160 0 0 {name=p102785 lab=_67414_/X }
C {devices/lab_pin.sym} 103740 -36120 0 0 {name=p102786 lab=_67391_/X }
C {devices/lab_pin.sym} 103740 -36080 0 0 {name=p102787 lab=_67460_/X }
C {devices/lab_pin.sym} 103900 -36140 0 1 {name=p102788 lab=_67461_/X }
C {sky130_stdcells/a211o_4.sym} 103820 -36140 0 0 {name=X_67461_ }
C {devices/lab_pin.sym} 103760 -36000 0 0 {name=p102789 lab=_79447_/A }
C {devices/lab_pin.sym} 103760 -35960 0 0 {name=p102790 lab=_79447_/B }
C {devices/lab_pin.sym} 103880 -35980 0 1 {name=p102791 lab=_79453_/B }
C {sky130_stdcells/xor2_4.sym} 103820 -35980 0 0 {name=X_79447_ }
C {devices/lab_pin.sym} 103780 -35850 0 0 {name=p102792 lab=clkbuf_9_425_0_CLK/X }
C {devices/lab_pin.sym} 103860 -35850 0 1 {name=p102793 lab=_85953_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 103820 -35850 0 0 {name=Xclkbuf_10_850_0_CLK }
C {devices/lab_pin.sym} 103780 -35730 0 0 {name=p102794 lab=_84996_/Q }
C {devices/lab_pin.sym} 103860 -35730 0 1 {name=p102795 lab=_55231_/B }
C {sky130_stdcells/inv_2.sym} 103820 -35730 0 0 {name=X_45839_ }
C {devices/lab_pin.sym} 103760 -35620 0 0 {name=p102796 lab=_64773_/A }
C {devices/lab_pin.sym} 103760 -35580 0 0 {name=p102797 lab=_86430_/Q }
C {devices/lab_pin.sym} 103880 -35600 0 1 {name=p102798 lab=_64673_/X }
C {sky130_stdcells/and2_4.sym} 103820 -35600 0 0 {name=X_64673_ }
C {devices/lab_pin.sym} 103780 -35470 0 0 {name=p102799 lab=_76659_/A }
C {devices/lab_pin.sym} 103860 -35470 0 1 {name=p102800 lab=_76662_/C }
C {sky130_stdcells/inv_2.sym} 103820 -35470 0 0 {name=X_76659_ }
C {devices/lab_pin.sym} 103760 -35380 0 0 {name=p102801 lab=_61915_/A }
C {devices/lab_pin.sym} 103760 -35340 0 0 {name=p102802 lab=_61915_/B }
C {devices/lab_pin.sym} 103760 -35300 0 0 {name=p102803 lab=_58511_/A }
C {devices/lab_pin.sym} 103760 -35260 0 0 {name=p102804 lab=_61915_/D }
C {devices/lab_pin.sym} 103880 -35320 0 1 {name=p102805 lab=_61885_/X }
C {sky130_stdcells/and4_4.sym} 103820 -35320 0 0 {name=X_61885_ }
C {devices/lab_pin.sym} 103740 -35200 0 0 {name=p102806 lab=_69146_/X }
C {devices/lab_pin.sym} 103740 -35160 0 0 {name=p102807 lab=_69198_/Y }
C {devices/lab_pin.sym} 103740 -35120 0 0 {name=p102808 lab=_69095_/X }
C {devices/lab_pin.sym} 103740 -35080 0 0 {name=p102809 lab=_69199_/Y }
C {devices/lab_pin.sym} 103900 -35140 0 1 {name=p102810 lab=_69200_/X }
C {sky130_stdcells/a211o_4.sym} 103820 -35140 0 0 {name=X_69200_ }
C {devices/lab_pin.sym} 103760 -35010 0 0 {name=p102811 lab=_64862_/X }
C {devices/lab_pin.sym} 103760 -34970 0 0 {name=p102812 lab=_66417_/B }
C {devices/lab_pin.sym} 103760 -34930 0 0 {name=p102813 lab=_64866_/X }
C {devices/lab_pin.sym} 103880 -34970 0 1 {name=p102814 lab=_66412_/Y }
C {sky130_stdcells/nand3_4.sym} 103820 -34970 0 0 {name=X_66412_ }
C {devices/lab_pin.sym} 103780 -34830 0 0 {name=p102815 lab=_63358_/X }
C {devices/lab_pin.sym} 103860 -34830 0 1 {name=p102816 lab=_63624_/X }
C {sky130_stdcells/buf_2.sym} 103820 -34830 0 0 {name=X_63624_ }
C {devices/lab_pin.sym} 103740 -34730 0 0 {name=p102817 lab=_48553_/Y }
C {devices/lab_pin.sym} 103740 -34690 0 0 {name=p102818 lab=_48403_/X }
C {devices/lab_pin.sym} 103740 -34650 0 0 {name=p102819 lab=_48557_/Y }
C {devices/lab_pin.sym} 103900 -34690 0 1 {name=p102820 lab=_86512_/D }
C {sky130_stdcells/a21boi_4.sym} 103820 -34690 0 0 {name=X_48558_ }
C {devices/lab_pin.sym} 103760 -34570 0 0 {name=p102821 lab=_60610_/A }
C {devices/lab_pin.sym} 103760 -34530 0 0 {name=p102822 lab=_60835_/X }
C {devices/lab_pin.sym} 103760 -34490 0 0 {name=p102823 lab=_84555_/Q }
C {devices/lab_pin.sym} 103880 -34530 0 1 {name=p102824 lab=_60836_/X }
C {sky130_stdcells/or3_4.sym} 103820 -34530 0 0 {name=X_60836_ }
C {devices/lab_pin.sym} 103760 -34400 0 0 {name=p102825 lab=_67342_/A }
C {devices/lab_pin.sym} 103760 -34360 0 0 {name=p102826 lab=_67392_/B }
C {devices/lab_pin.sym} 103880 -34380 0 1 {name=p102827 lab=_67392_/X }
C {sky130_stdcells/and2_4.sym} 103820 -34380 0 0 {name=X_67392_ }
C {devices/lab_pin.sym} 103760 -34260 0 0 {name=p102828 lab=_79364_/Y }
C {devices/lab_pin.sym} 103760 -34220 0 0 {name=p102829 lab=_79361_/X }
C {devices/lab_pin.sym} 103880 -34240 0 1 {name=p102830 lab=_79378_/X }
C {sky130_stdcells/and2_4.sym} 103820 -34240 0 0 {name=X_79378_ }
C {devices/lab_pin.sym} 103780 -34110 0 0 {name=p102831 lab=clkbuf_9_341_0_CLK/A }
C {devices/lab_pin.sym} 103860 -34110 0 1 {name=p102832 lab=clkbuf_9_341_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 103820 -34110 0 0 {name=Xclkbuf_9_341_0_CLK }
C {devices/lab_pin.sym} 103740 -34010 0 0 {name=p102833 lab=_69127_/X }
C {devices/lab_pin.sym} 103740 -33970 0 0 {name=p102834 lab=_69130_/X }
C {devices/lab_pin.sym} 103740 -33930 0 0 {name=p102835 lab=_69017_/X }
C {devices/lab_pin.sym} 103900 -33970 0 1 {name=p102836 lab=_69131_/Y }
C {sky130_stdcells/a21oi_4.sym} 103820 -33970 0 0 {name=X_69131_ }
C {devices/lab_pin.sym} 103780 -33830 0 0 {name=p102837 lab=_47414_/A }
C {devices/lab_pin.sym} 103860 -33830 0 1 {name=p102838 lab=_47509_/X }
C {sky130_stdcells/buf_2.sym} 103820 -33830 0 0 {name=X_47509_ }
C {devices/lab_pin.sym} 103780 -33710 0 0 {name=p102839 lab=_66065_/A }
C {devices/lab_pin.sym} 103860 -33710 0 1 {name=p102840 lab=_66343_/X }
C {sky130_stdcells/buf_2.sym} 103820 -33710 0 0 {name=X_66343_ }
C {devices/lab_pin.sym} 103780 -33590 0 0 {name=p102841 lab=_78329_/A }
C {devices/lab_pin.sym} 103860 -33590 0 1 {name=p102842 lab=_78329_/Y }
C {sky130_stdcells/inv_2.sym} 103820 -33590 0 0 {name=X_78329_ }
C {devices/lab_pin.sym} 103740 -33490 0 0 {name=p102843 lab=_63553_/Y }
C {devices/lab_pin.sym} 103740 -33450 0 0 {name=p102844 lab=_63516_/X }
C {devices/lab_pin.sym} 103740 -33410 0 0 {name=p102845 lab=_63554_/Y }
C {devices/lab_pin.sym} 103900 -33450 0 1 {name=p102846 lab=_63555_/Y }
C {sky130_stdcells/a21oi_4.sym} 103820 -33450 0 0 {name=X_63555_ }
C {devices/lab_pin.sym} 103780 -33310 0 0 {name=p102847 lab=clkbuf_9_117_0_CLK/X }
C {devices/lab_pin.sym} 103860 -33310 0 1 {name=p102848 lab=_80681_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 103820 -33310 0 0 {name=Xclkbuf_10_235_0_CLK }
C {devices/lab_pin.sym} 103760 -33210 0 0 {name=p102849 lab=_52156_/A }
C {devices/lab_pin.sym} 103760 -33170 0 0 {name=p102850 lab=_48489_/B }
C {devices/lab_pin.sym} 103760 -33130 0 0 {name=p102851 lab=_48533_/C }
C {devices/lab_pin.sym} 103880 -33170 0 1 {name=p102852 lab=_48489_/X }
C {sky130_stdcells/and3_4.sym} 103820 -33170 0 0 {name=X_48489_ }
C {devices/lab_pin.sym} 103780 -33030 0 0 {name=p102853 lab=_60766_/X }
C {devices/lab_pin.sym} 103860 -33030 0 1 {name=p102854 lab=_60767_/X }
C {sky130_stdcells/buf_2.sym} 103820 -33030 0 0 {name=X_60767_ }
C {devices/lab_pin.sym} 103740 -32930 0 0 {name=p102855 lab=_50518_/Y }
C {devices/lab_pin.sym} 103740 -32890 0 0 {name=p102856 lab=_50491_/X }
C {devices/lab_pin.sym} 103740 -32850 0 0 {name=p102857 lab=_50519_/X }
C {devices/lab_pin.sym} 103900 -32890 0 1 {name=p102858 lab=_50520_/Y }
C {sky130_stdcells/a21oi_4.sym} 103820 -32890 0 0 {name=X_50520_ }
C {devices/lab_pin.sym} 103760 -32780 0 0 {name=p102859 lab=_62493_/A }
C {devices/lab_pin.sym} 103760 -32740 0 0 {name=p102860 lab=_62506_/B }
C {devices/lab_pin.sym} 103760 -32700 0 0 {name=p102861 lab=_62506_/C }
C {devices/lab_pin.sym} 103760 -32660 0 0 {name=p102862 lab=_62506_/D }
C {devices/lab_pin.sym} 103880 -32720 0 1 {name=p102863 lab=_62506_/Y }
C {sky130_stdcells/nand4_4.sym} 103820 -32720 0 0 {name=X_62506_ }
C {devices/lab_pin.sym} 103780 -32570 0 0 {name=p102864 lab=clkbuf_9_432_0_CLK/X }
C {devices/lab_pin.sym} 103860 -32570 0 1 {name=p102865 lab=_83556_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 103820 -32570 0 0 {name=Xclkbuf_10_865_0_CLK }
C {devices/lab_pin.sym} 103730 -32450 0 0 {name=p102866 lab=_84049_/CLK }
C {devices/lab_pin.sym} 103730 -32430 0 0 {name=p102867 lab=_81340_/D }
C {devices/lab_pin.sym} 103910 -32450 0 1 {name=p102868 lab=_81716_/D }
C {sky130_stdcells/dfxtp_4.sym} 103820 -32440 0 0 {name=X_81340_ }
C {devices/lab_pin.sym} 103740 -32330 0 0 {name=p102869 lab=_69057_/X }
C {devices/lab_pin.sym} 103740 -32290 0 0 {name=p102870 lab=_69060_/X }
C {devices/lab_pin.sym} 103740 -32250 0 0 {name=p102871 lab=_69061_/X }
C {devices/lab_pin.sym} 103900 -32290 0 1 {name=p102872 lab=_69062_/Y }
C {sky130_stdcells/a21oi_4.sym} 103820 -32290 0 0 {name=X_69062_ }
C {devices/lab_pin.sym} 103740 -32180 0 0 {name=p102873 lab=_66225_/X }
C {devices/lab_pin.sym} 103740 -32140 0 0 {name=p102874 lab=_84968_/Q }
C {devices/lab_pin.sym} 103740 -32100 0 0 {name=p102875 lab=_66186_/X }
C {devices/lab_pin.sym} 103740 -32060 0 0 {name=p102876 lab=_66273_/X }
C {devices/lab_pin.sym} 103900 -32120 0 1 {name=p102877 lab=_66274_/X }
C {sky130_stdcells/a211o_4.sym} 103820 -32120 0 0 {name=X_66274_ }
C {devices/lab_pin.sym} 103740 -32000 0 0 {name=p102878 lab=_58543_/Y }
C {devices/lab_pin.sym} 103740 -31960 0 0 {name=p102879 lab=_63436_/X }
C {devices/lab_pin.sym} 103740 -31920 0 0 {name=p102880 lab=_61451_/A }
C {devices/lab_pin.sym} 103740 -31880 0 0 {name=p102881 lab=_63437_/X }
C {devices/lab_pin.sym} 103900 -31940 0 1 {name=p102882 lab=_63486_/X }
C {sky130_stdcells/a2bb2o_4.sym} 103820 -31940 0 0 {name=X_63486_ }
C {devices/lab_pin.sym} 103740 -31810 0 0 {name=p102883 lab=_60697_/Y }
C {devices/lab_pin.sym} 103740 -31770 0 0 {name=p102884 lab=_60646_/Y }
C {devices/lab_pin.sym} 103740 -31730 0 0 {name=p102885 lab=_59756_/A }
C {devices/lab_pin.sym} 103900 -31770 0 1 {name=p102886 lab=_60698_/X }
C {sky130_stdcells/o21a_4.sym} 103820 -31770 0 0 {name=X_60698_ }
C {devices/lab_pin.sym} 103780 -31630 0 0 {name=p102887 lab=clkbuf_9_8_0_CLK/X }
C {devices/lab_pin.sym} 103860 -31630 0 1 {name=p102888 lab=_85198_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 103820 -31630 0 0 {name=Xclkbuf_10_17_0_CLK }
C {devices/lab_pin.sym} 103760 -31520 0 0 {name=p102889 lab=_68371_/A }
C {devices/lab_pin.sym} 103760 -31480 0 0 {name=p102890 lab=_88151_/Q }
C {devices/lab_pin.sym} 103880 -31500 0 1 {name=p102891 lab=_68013_/X }
C {sky130_stdcells/and2_4.sym} 103820 -31500 0 0 {name=X_68013_ }
C {devices/lab_pin.sym} 103760 -31380 0 0 {name=p102892 lab=_65225_/A }
C {devices/lab_pin.sym} 103760 -31340 0 0 {name=p102893 lab=_65225_/B }
C {devices/lab_pin.sym} 103880 -31360 0 1 {name=p102894 lab=_65225_/X }
C {sky130_stdcells/and2_4.sym} 103820 -31360 0 0 {name=X_65225_ }
C {devices/lab_pin.sym} 103760 -31250 0 0 {name=p102895 lab=_52156_/A }
C {devices/lab_pin.sym} 103760 -31210 0 0 {name=p102896 lab=_50456_/B }
C {devices/lab_pin.sym} 103760 -31170 0 0 {name=p102897 lab=_50462_/C }
C {devices/lab_pin.sym} 103880 -31210 0 1 {name=p102898 lab=_50451_/X }
C {sky130_stdcells/and3_4.sym} 103820 -31210 0 0 {name=X_50451_ }
C {devices/lab_pin.sym} 103780 -31070 0 0 {name=p102899 lab=clkbuf_8_178_0_CLK/X }
C {devices/lab_pin.sym} 103860 -31070 0 1 {name=p102900 lab=clkbuf_9_356_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 103820 -31070 0 0 {name=Xclkbuf_9_356_0_CLK }
C {devices/lab_pin.sym} 103780 -30950 0 0 {name=p102901 lab=_62276_/X }
C {devices/lab_pin.sym} 103860 -30950 0 1 {name=p102902 lab=_62479_/C }
C {sky130_stdcells/buf_2.sym} 103820 -30950 0 0 {name=X_62437_ }
C {devices/lab_pin.sym} 103730 -30830 0 0 {name=p102903 lab=_81257_/CLK }
C {devices/lab_pin.sym} 103730 -30810 0 0 {name=p102904 lab=_81303_/Q }
C {devices/lab_pin.sym} 103910 -30830 0 1 {name=p102905 lab=_81271_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -30820 0 0 {name=X_81271_ }
C {devices/lab_pin.sym} 103730 -30690 0 0 {name=p102906 lab=_82979_/CLK }
C {devices/lab_pin.sym} 103730 -30670 0 0 {name=p102907 lab=_74626_/Y }
C {devices/lab_pin.sym} 103910 -30690 0 1 {name=p102908 lab=_45380_/A }
C {sky130_stdcells/dfxtp_4.sym} 103820 -30680 0 0 {name=X_83010_ }
C {devices/lab_pin.sym} 103740 -30590 0 0 {name=p102909 lab=_80184_/Y }
C {devices/lab_pin.sym} 103740 -30550 0 0 {name=p102910 lab=_80187_/Y }
C {devices/lab_pin.sym} 103740 -30510 0 0 {name=p102911 lab=_80199_/X }
C {devices/lab_pin.sym} 103740 -30470 0 0 {name=p102912 lab=_80197_/Y }
C {devices/lab_pin.sym} 103740 -30430 0 0 {name=p102913 lab=_80220_/B }
C {devices/lab_pin.sym} 103900 -30510 0 1 {name=p102914 lab=_80222_/X }
C {sky130_stdcells/a2111o_4.sym} 103820 -30510 0 0 {name=X_80222_ }
C {devices/lab_pin.sym} 103760 -30380 0 0 {name=p102915 lab=_53181_/A }
C {devices/lab_pin.sym} 103760 -30340 0 0 {name=p102916 lab=_53159_/B }
C {devices/lab_pin.sym} 103760 -30300 0 0 {name=p102917 lab=_53169_/X }
C {devices/lab_pin.sym} 103760 -30260 0 0 {name=p102918 lab=_53170_/D }
C {devices/lab_pin.sym} 103880 -30320 0 1 {name=p102919 lab=_53170_/X }
C {sky130_stdcells/and4_4.sym} 103820 -30320 0 0 {name=X_53170_ }
C {devices/lab_pin.sym} 103740 -30200 0 0 {name=p102920 lab=_64999_/X }
C {devices/lab_pin.sym} 103740 -30160 0 0 {name=p102921 lab=_86156_/Q }
C {devices/lab_pin.sym} 103740 -30120 0 0 {name=p102922 lab=_65127_/X }
C {devices/lab_pin.sym} 103740 -30080 0 0 {name=p102923 lab=_65155_/X }
C {devices/lab_pin.sym} 103900 -30140 0 1 {name=p102924 lab=_65156_/X }
C {sky130_stdcells/a211o_4.sym} 103820 -30140 0 0 {name=X_65156_ }
C {devices/lab_pin.sym} 103740 -30010 0 0 {name=p102925 lab=_50379_/Y }
C {devices/lab_pin.sym} 103740 -29970 0 0 {name=p102926 lab=_50380_/X }
C {devices/lab_pin.sym} 103740 -29930 0 0 {name=p102927 lab=_50381_/Y }
C {devices/lab_pin.sym} 103900 -29970 0 1 {name=p102928 lab=_50382_/Y }
C {sky130_stdcells/a21boi_4.sym} 103820 -29970 0 0 {name=X_50382_ }
C {devices/lab_pin.sym} 103740 -29870 0 0 {name=p102929 lab=_62356_/X }
C {devices/lab_pin.sym} 103740 -29830 0 0 {name=p102930 lab=_62362_/Y }
C {devices/lab_pin.sym} 103740 -29790 0 0 {name=p102931 lab=_62366_/X }
C {devices/lab_pin.sym} 103740 -29750 0 0 {name=p102932 lab=_84743_/Q }
C {devices/lab_pin.sym} 103740 -29710 0 0 {name=p102933 lab=_62367_/X }
C {devices/lab_pin.sym} 103900 -29790 0 1 {name=p102934 lab=_62368_/Y }
C {sky130_stdcells/o32ai_4.sym} 103820 -29790 0 0 {name=X_62368_ }
C {devices/lab_pin.sym} 103760 -29640 0 0 {name=p102935 lab=_52121_/A }
C {devices/lab_pin.sym} 103760 -29600 0 0 {name=p102936 lab=_52121_/B }
C {devices/lab_pin.sym} 103880 -29620 0 1 {name=p102937 lab=_52121_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -29620 0 0 {name=X_52121_ }
C {devices/lab_pin.sym} 103740 -29530 0 0 {name=p102938 lab=_64077_/Y }
C {devices/lab_pin.sym} 103740 -29490 0 0 {name=p102939 lab=_64102_/Y }
C {devices/lab_pin.sym} 103740 -29450 0 0 {name=p102940 lab=_64103_/X }
C {devices/lab_pin.sym} 103740 -29410 0 0 {name=p102941 lab=_64105_/X }
C {devices/lab_pin.sym} 103740 -29370 0 0 {name=p102942 lab=_64106_/X }
C {devices/lab_pin.sym} 103900 -29450 0 1 {name=p102943 lab=_64107_/Y }
C {sky130_stdcells/o41ai_4.sym} 103820 -29450 0 0 {name=X_64107_ }
C {devices/lab_pin.sym} 103780 -29290 0 0 {name=p102944 lab=_61281_/A }
C {devices/lab_pin.sym} 103860 -29290 0 1 {name=p102945 lab=_61319_/X }
C {sky130_stdcells/buf_2.sym} 103820 -29290 0 0 {name=X_61319_ }
C {devices/lab_pin.sym} 103760 -29180 0 0 {name=p102946 lab=_80153_/A }
C {devices/lab_pin.sym} 103760 -29140 0 0 {name=p102947 lab=_63897_/C }
C {devices/lab_pin.sym} 103880 -29160 0 1 {name=p102948 lab=_80153_/X }
C {sky130_stdcells/xor2_4.sym} 103820 -29160 0 0 {name=X_80153_ }
C {devices/lab_pin.sym} 103760 -29040 0 0 {name=p102949 lab=_65005_/X }
C {devices/lab_pin.sym} 103760 -29000 0 0 {name=p102950 lab=_65087_/B }
C {devices/lab_pin.sym} 103880 -29020 0 1 {name=p102951 lab=_65087_/X }
C {sky130_stdcells/and2_4.sym} 103820 -29020 0 0 {name=X_65087_ }
C {devices/lab_pin.sym} 103740 -28910 0 0 {name=p102952 lab=_69546_/X }
C {devices/lab_pin.sym} 103740 -28870 0 0 {name=p102953 lab=_69548_/X }
C {devices/lab_pin.sym} 103740 -28830 0 0 {name=p102954 lab=_69939_/X }
C {devices/lab_pin.sym} 103900 -28870 0 1 {name=p102955 lab=_69964_/Y }
C {sky130_stdcells/a21oi_4.sym} 103820 -28870 0 0 {name=X_69964_ }
C {devices/lab_pin.sym} 103760 -28760 0 0 {name=p102956 lab=_62634_/A }
C {devices/lab_pin.sym} 103760 -28720 0 0 {name=p102957 lab=_62293_/Y }
C {devices/lab_pin.sym} 103760 -28680 0 0 {name=p102958 lab=_62299_/C }
C {devices/lab_pin.sym} 103760 -28640 0 0 {name=p102959 lab=_62298_/Y }
C {devices/lab_pin.sym} 103880 -28700 0 1 {name=p102960 lab=_62299_/Y }
C {sky130_stdcells/nand4_4.sym} 103820 -28700 0 0 {name=X_62299_ }
C {devices/lab_pin.sym} 103760 -28560 0 0 {name=p102961 lab=_52070_/A }
C {devices/lab_pin.sym} 103760 -28520 0 0 {name=p102962 lab=_48073_/B }
C {devices/lab_pin.sym} 103880 -28540 0 1 {name=p102963 lab=_52052_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -28540 0 0 {name=X_52052_ }
C {devices/lab_pin.sym} 103740 -28430 0 0 {name=p102964 lab=_64036_/X }
C {devices/lab_pin.sym} 103740 -28390 0 0 {name=p102965 lab=_63994_/X }
C {devices/lab_pin.sym} 103740 -28350 0 0 {name=p102966 lab=_64037_/Y }
C {devices/lab_pin.sym} 103900 -28390 0 1 {name=p102967 lab=_84279_/D }
C {sky130_stdcells/a21oi_4.sym} 103820 -28390 0 0 {name=X_64038_ }
C {devices/lab_pin.sym} 103740 -28270 0 0 {name=p102968 lab=_68912_/X }
C {devices/lab_pin.sym} 103740 -28230 0 0 {name=p102969 lab=_68914_/X }
C {devices/lab_pin.sym} 103740 -28190 0 0 {name=p102970 lab=_68846_/X }
C {devices/lab_pin.sym} 103900 -28230 0 1 {name=p102971 lab=_68915_/Y }
C {sky130_stdcells/a21oi_4.sym} 103820 -28230 0 0 {name=X_68915_ }
C {devices/lab_pin.sym} 103730 -28090 0 0 {name=p102972 lab=_84960_/CLK }
C {devices/lab_pin.sym} 103730 -28070 0 0 {name=p102973 lab=_84961_/D }
C {devices/lab_pin.sym} 103910 -28090 0 1 {name=p102974 lab=_84961_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -28080 0 0 {name=X_84961_ }
C {devices/lab_pin.sym} 103760 -27960 0 0 {name=p102975 lab=_80080_/Y }
C {devices/lab_pin.sym} 103760 -27920 0 0 {name=p102976 lab=_80083_/Y }
C {devices/lab_pin.sym} 103880 -27940 0 1 {name=p102977 lab=_80084_/X }
C {sky130_stdcells/xor2_4.sym} 103820 -27940 0 0 {name=X_80084_ }
C {devices/lab_pin.sym} 103760 -27820 0 0 {name=p102978 lab=_69086_/A }
C {devices/lab_pin.sym} 103760 -27780 0 0 {name=p102979 lab=_87290_/Q }
C {devices/lab_pin.sym} 103880 -27800 0 1 {name=p102980 lab=_69895_/X }
C {sky130_stdcells/and2_4.sym} 103820 -27800 0 0 {name=X_69895_ }
C {devices/lab_pin.sym} 103760 -27680 0 0 {name=p102981 lab=_51003_/A }
C {devices/lab_pin.sym} 103760 -27640 0 0 {name=p102982 lab=_51003_/B }
C {devices/lab_pin.sym} 103880 -27660 0 1 {name=p102983 lab=_51003_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -27660 0 0 {name=X_51003_ }
C {devices/lab_pin.sym} 103730 -27530 0 0 {name=p102984 lab=_86701_/CLK }
C {devices/lab_pin.sym} 103730 -27510 0 0 {name=p102985 lab=_86700_/D }
C {devices/lab_pin.sym} 103910 -27530 0 1 {name=p102986 lab=_86700_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -27520 0 0 {name=X_86700_ }
C {devices/lab_pin.sym} 103730 -27390 0 0 {name=p102987 lab=_81975_/CLK }
C {devices/lab_pin.sym} 103730 -27370 0 0 {name=p102988 lab=_69591_/X }
C {devices/lab_pin.sym} 103910 -27390 0 1 {name=p102989 lab=_83912_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -27380 0 0 {name=X_83912_ }
C {devices/lab_pin.sym} 103780 -27250 0 0 {name=p102990 lab=clkbuf_9_401_0_CLK/X }
C {devices/lab_pin.sym} 103860 -27250 0 1 {name=p102991 lab=_82860_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 103820 -27250 0 0 {name=Xclkbuf_10_803_0_CLK }
C {devices/lab_pin.sym} 103780 -27130 0 0 {name=p102992 lab=_56859_/X }
C {devices/lab_pin.sym} 103860 -27130 0 1 {name=p102993 lab=_56860_/X }
C {sky130_stdcells/buf_2.sym} 103820 -27130 0 0 {name=X_56860_ }
C {devices/lab_pin.sym} 103780 -27010 0 0 {name=p102994 lab=_60109_/A }
C {devices/lab_pin.sym} 103860 -27010 0 1 {name=p102995 lab=_68846_/X }
C {sky130_stdcells/buf_2.sym} 103820 -27010 0 0 {name=X_68846_ }
C {devices/lab_pin.sym} 103730 -26890 0 0 {name=p102996 lab=_82888_/CLK }
C {devices/lab_pin.sym} 103730 -26870 0 0 {name=p102997 lab=_42863_/X }
C {devices/lab_pin.sym} 103910 -26890 0 1 {name=p102998 lab=_67033_/B }
C {sky130_stdcells/dfxtp_4.sym} 103820 -26880 0 0 {name=X_87680_ }
C {devices/lab_pin.sym} 103730 -26750 0 0 {name=p102999 lab=_84892_/CLK }
C {devices/lab_pin.sym} 103730 -26730 0 0 {name=p103000 lab=_84892_/D }
C {devices/lab_pin.sym} 103910 -26750 0 1 {name=p103001 lab=_84892_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -26740 0 0 {name=X_84892_ }
C {devices/lab_pin.sym} 103780 -26610 0 0 {name=p103002 lab=_55811_/A }
C {devices/lab_pin.sym} 103860 -26610 0 1 {name=p103003 lab=_55811_/X }
C {sky130_stdcells/buf_2.sym} 103820 -26610 0 0 {name=X_55811_ }
C {devices/lab_pin.sym} 103730 -26490 0 0 {name=p103004 lab=_85990_/CLK }
C {devices/lab_pin.sym} 103730 -26470 0 0 {name=p103005 lab=_86631_/D }
C {devices/lab_pin.sym} 103910 -26490 0 1 {name=p103006 lab=_86631_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -26480 0 0 {name=X_86631_ }
C {devices/lab_pin.sym} 103730 -26350 0 0 {name=p103007 lab=_83843_/CLK }
C {devices/lab_pin.sym} 103730 -26330 0 0 {name=p103008 lab=_70191_/X }
C {devices/lab_pin.sym} 103910 -26350 0 1 {name=p103009 lab=_83843_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -26340 0 0 {name=X_83843_ }
C {devices/lab_pin.sym} 103760 -26230 0 0 {name=p103010 lab=_56786_/Y }
C {devices/lab_pin.sym} 103760 -26190 0 0 {name=p103011 lab=_57673_/A }
C {devices/lab_pin.sym} 103760 -26150 0 0 {name=p103012 lab=_56790_/X }
C {devices/lab_pin.sym} 103880 -26190 0 1 {name=p103013 lab=_56791_/Y }
C {sky130_stdcells/nand3_4.sym} 103820 -26190 0 0 {name=X_56791_ }
C {devices/lab_pin.sym} 103760 -26060 0 0 {name=p103014 lab=_68774_/X }
C {devices/lab_pin.sym} 103760 -26020 0 0 {name=p103015 lab=_68776_/X }
C {devices/lab_pin.sym} 103880 -26040 0 1 {name=p103016 lab=_68777_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -26040 0 0 {name=X_68777_ }
C {devices/lab_pin.sym} 103740 -25930 0 0 {name=p103017 lab=_65986_/Y }
C {devices/lab_pin.sym} 103740 -25890 0 0 {name=p103018 lab=_65987_/X }
C {devices/lab_pin.sym} 103740 -25850 0 0 {name=p103019 lab=_65988_/X }
C {devices/lab_pin.sym} 103900 -25890 0 1 {name=p103020 lab=_65989_/X }
C {sky130_stdcells/a21o_4.sym} 103820 -25890 0 0 {name=X_65989_ }
C {devices/lab_pin.sym} 103780 -25750 0 0 {name=p103021 lab=_58530_/A }
C {devices/lab_pin.sym} 103860 -25750 0 1 {name=p103022 lab=_58530_/Y }
C {sky130_stdcells/inv_2.sym} 103820 -25750 0 0 {name=X_58530_ }
C {devices/lab_pin.sym} 103740 -25660 0 0 {name=p103023 lab=_45380_/A }
C {devices/lab_pin.sym} 103740 -25620 0 0 {name=p103024 lab=_55152_/X }
C {devices/lab_pin.sym} 103740 -25580 0 0 {name=p103025 lab=_55140_/A }
C {devices/lab_pin.sym} 103740 -25540 0 0 {name=p103026 lab=_55741_/X }
C {devices/lab_pin.sym} 103900 -25600 0 1 {name=p103027 lab=_55742_/X }
C {sky130_stdcells/a211o_4.sym} 103820 -25600 0 0 {name=X_55742_ }
C {devices/lab_pin.sym} 103740 -25480 0 0 {name=p103028 lab=_87971_/Q }
C {devices/lab_pin.sym} 103740 -25440 0 0 {name=p103029 lab=_67651_/X }
C {devices/lab_pin.sym} 103740 -25400 0 0 {name=p103030 lab=_67625_/X }
C {devices/lab_pin.sym} 103740 -25360 0 0 {name=p103031 lab=_67727_/X }
C {devices/lab_pin.sym} 103900 -25420 0 1 {name=p103032 lab=_67728_/X }
C {sky130_stdcells/a211o_4.sym} 103820 -25420 0 0 {name=X_67728_ }
C {devices/lab_pin.sym} 103730 -25270 0 0 {name=p103033 lab=_86490_/CLK }
C {devices/lab_pin.sym} 103730 -25250 0 0 {name=p103034 lab=_86562_/D }
C {devices/lab_pin.sym} 103910 -25270 0 1 {name=p103035 lab=_86562_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -25260 0 0 {name=X_86562_ }
C {devices/lab_pin.sym} 103760 -25160 0 0 {name=p103036 lab=_52947_/X }
C {devices/lab_pin.sym} 103760 -25120 0 0 {name=p103037 lab=_52954_/B }
C {devices/lab_pin.sym} 103760 -25080 0 0 {name=p103038 lab=_52977_/C }
C {devices/lab_pin.sym} 103760 -25040 0 0 {name=p103039 lab=_52954_/D }
C {devices/lab_pin.sym} 103880 -25100 0 1 {name=p103040 lab=_52954_/X }
C {sky130_stdcells/and4_4.sym} 103820 -25100 0 0 {name=X_52954_ }
C {devices/lab_pin.sym} 103730 -24950 0 0 {name=p103041 lab=_86553_/CLK }
C {devices/lab_pin.sym} 103730 -24930 0 0 {name=p103042 lab=_83774_/D }
C {devices/lab_pin.sym} 103910 -24950 0 1 {name=p103043 lab=_83774_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -24940 0 0 {name=X_83774_ }
C {devices/lab_pin.sym} 103730 -24810 0 0 {name=p103044 lab=_80818_/CLK }
C {devices/lab_pin.sym} 103730 -24790 0 0 {name=p103045 lab=_80986_/D }
C {devices/lab_pin.sym} 103910 -24810 0 1 {name=p103046 lab=_80986_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -24800 0 0 {name=X_80986_ }
C {devices/lab_pin.sym} 103730 -24670 0 0 {name=p103047 lab=_88301_/CLK }
C {devices/lab_pin.sym} 103730 -24650 0 0 {name=p103048 lab=_40969_/X }
C {devices/lab_pin.sym} 103910 -24670 0 1 {name=p103049 lab=_69224_/B }
C {sky130_stdcells/dfxtp_4.sym} 103820 -24660 0 0 {name=X_88301_ }
C {devices/lab_pin.sym} 103780 -24530 0 0 {name=p103050 lab=clkbuf_9_409_0_CLK/X }
C {devices/lab_pin.sym} 103860 -24530 0 1 {name=p103051 lab=_82924_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 103820 -24530 0 0 {name=Xclkbuf_10_818_0_CLK }
C {devices/lab_pin.sym} 103730 -24410 0 0 {name=p103052 lab=_85514_/CLK }
C {devices/lab_pin.sym} 103730 -24390 0 0 {name=p103053 lab=_54062_/Y }
C {devices/lab_pin.sym} 103910 -24410 0 1 {name=p103054 lab=_85513_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -24400 0 0 {name=X_85513_ }
C {devices/lab_pin.sym} 103760 -24300 0 0 {name=p103055 lab=_51887_/A }
C {devices/lab_pin.sym} 103760 -24260 0 0 {name=p103056 lab=_51898_/B }
C {devices/lab_pin.sym} 103760 -24220 0 0 {name=p103057 lab=_51893_/C }
C {devices/lab_pin.sym} 103760 -24180 0 0 {name=p103058 lab=_52730_/D }
C {devices/lab_pin.sym} 103880 -24240 0 1 {name=p103059 lab=_51905_/X }
C {sky130_stdcells/and4_4.sym} 103820 -24240 0 0 {name=X_51905_ }
C {devices/lab_pin.sym} 103760 -24100 0 0 {name=p103060 lab=_58461_/A }
C {devices/lab_pin.sym} 103760 -24060 0 0 {name=p103061 lab=_58498_/B }
C {devices/lab_pin.sym} 103880 -24080 0 1 {name=p103062 lab=_58461_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -24080 0 0 {name=X_58461_ }
C {devices/lab_pin.sym} 103730 -23950 0 0 {name=p103063 lab=_82923_/CLK }
C {devices/lab_pin.sym} 103730 -23930 0 0 {name=p103064 lab=_66509_/C }
C {devices/lab_pin.sym} 103910 -23950 0 1 {name=p103065 lab=_78838_/A }
C {sky130_stdcells/dfxtp_4.sym} 103820 -23940 0 0 {name=X_82725_ }
C {devices/lab_pin.sym} 103760 -23820 0 0 {name=p103066 lab=_67658_/X }
C {devices/lab_pin.sym} 103760 -23780 0 0 {name=p103067 lab=_67659_/B }
C {devices/lab_pin.sym} 103880 -23800 0 1 {name=p103068 lab=_67659_/X }
C {sky130_stdcells/and2_4.sym} 103820 -23800 0 0 {name=X_67659_ }
C {devices/lab_pin.sym} 103760 -23690 0 0 {name=p103069 lab=_55288_/B }
C {devices/lab_pin.sym} 103760 -23650 0 0 {name=p103070 lab=_55288_/A }
C {devices/lab_pin.sym} 103760 -23610 0 0 {name=p103071 lab=_55672_/X }
C {devices/lab_pin.sym} 103880 -23650 0 1 {name=p103072 lab=_55674_/A }
C {sky130_stdcells/nand3_4.sym} 103820 -23650 0 0 {name=X_55673_ }
C {devices/lab_pin.sym} 103730 -23510 0 0 {name=p103073 lab=_85596_/CLK }
C {devices/lab_pin.sym} 103730 -23490 0 0 {name=p103074 lab=_86493_/D }
C {devices/lab_pin.sym} 103910 -23510 0 1 {name=p103075 lab=_65489_/B }
C {sky130_stdcells/dfxtp_4.sym} 103820 -23500 0 0 {name=X_86493_ }
C {devices/lab_pin.sym} 103760 -23380 0 0 {name=p103076 lab=_52885_/A }
C {devices/lab_pin.sym} 103760 -23340 0 0 {name=p103077 lab=_52885_/B }
C {devices/lab_pin.sym} 103880 -23360 0 1 {name=p103078 lab=_52885_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -23360 0 0 {name=X_52885_ }
C {devices/lab_pin.sym} 103740 -23250 0 0 {name=p103079 lab=_57408_/X }
C {devices/lab_pin.sym} 103740 -23210 0 0 {name=p103080 lab=_57410_/Y }
C {devices/lab_pin.sym} 103740 -23170 0 0 {name=p103081 lab=_57411_/Y }
C {devices/lab_pin.sym} 103900 -23210 0 1 {name=p103082 lab=_57412_/X }
C {sky130_stdcells/o21a_4.sym} 103820 -23210 0 0 {name=X_57412_ }
C {devices/lab_pin.sym} 103730 -23070 0 0 {name=p103083 lab=_88232_/CLK }
C {devices/lab_pin.sym} 103730 -23050 0 0 {name=p103084 lab=_88232_/D }
C {devices/lab_pin.sym} 103910 -23070 0 1 {name=p103085 lab=_67600_/B }
C {sky130_stdcells/dfxtp_4.sym} 103820 -23060 0 0 {name=X_88232_ }
C {devices/lab_pin.sym} 103780 -22930 0 0 {name=p103086 lab=clkbuf_8_154_0_CLK/X }
C {devices/lab_pin.sym} 103860 -22930 0 1 {name=p103087 lab=clkbuf_9_309_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 103820 -22930 0 0 {name=Xclkbuf_9_309_0_CLK }
C {devices/lab_pin.sym} 103740 -22830 0 0 {name=p103088 lab=_85408_/Q }
C {devices/lab_pin.sym} 103740 -22790 0 0 {name=p103089 lab=_54621_/X }
C {devices/lab_pin.sym} 103740 -22750 0 0 {name=p103090 lab=_54623_/Y }
C {devices/lab_pin.sym} 103900 -22790 0 1 {name=p103091 lab=_54624_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -22790 0 0 {name=X_54624_ }
C {devices/lab_pin.sym} 103730 -22650 0 0 {name=p103092 lab=_85444_/CLK }
C {devices/lab_pin.sym} 103730 -22630 0 0 {name=p103093 lab=_85444_/D }
C {devices/lab_pin.sym} 103910 -22650 0 1 {name=p103094 lab=_85444_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -22640 0 0 {name=X_85444_ }
C {devices/lab_pin.sym} 103740 -22530 0 0 {name=p103095 lab=_85937_/Q }
C {devices/lab_pin.sym} 103740 -22490 0 0 {name=p103096 lab=_51817_/X }
C {devices/lab_pin.sym} 103740 -22450 0 0 {name=p103097 lab=_51835_/Y }
C {devices/lab_pin.sym} 103900 -22490 0 1 {name=p103098 lab=_51836_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -22490 0 0 {name=X_51836_ }
C {devices/lab_pin.sym} 103760 -22370 0 0 {name=p103099 lab=_70670_/A }
C {devices/lab_pin.sym} 103760 -22330 0 0 {name=p103100 lab=_70676_/B }
C {devices/lab_pin.sym} 103760 -22290 0 0 {name=p103101 lab=_70676_/C }
C {devices/lab_pin.sym} 103880 -22330 0 1 {name=p103102 lab=_70670_/Y }
C {sky130_stdcells/nor3_4.sym} 103820 -22330 0 0 {name=X_70670_ }
C {devices/lab_pin.sym} 103740 -22210 0 0 {name=p103103 lab=_58388_/X }
C {devices/lab_pin.sym} 103740 -22170 0 0 {name=p103104 lab=_83349_/Q }
C {devices/lab_pin.sym} 103740 -22130 0 0 {name=p103105 lab=_58391_/Y }
C {devices/lab_pin.sym} 103900 -22170 0 1 {name=p103106 lab=_84861_/D }
C {sky130_stdcells/o21a_4.sym} 103820 -22170 0 0 {name=X_58392_ }
C {devices/lab_pin.sym} 103730 -22030 0 0 {name=p103107 lab=_81783_/CLK }
C {devices/lab_pin.sym} 103730 -22010 0 0 {name=p103108 lab=_84008_/Q }
C {devices/lab_pin.sym} 103910 -22030 0 1 {name=p103109 lab=_79086_/A }
C {sky130_stdcells/dfxtp_4.sym} 103820 -22020 0 0 {name=X_82656_ }
C {devices/lab_pin.sym} 103740 -21920 0 0 {name=p103110 lab=_44287_/X }
C {devices/lab_pin.sym} 103740 -21880 0 0 {name=p103111 lab=_57339_/X }
C {devices/lab_pin.sym} 103740 -21840 0 0 {name=p103112 lab=_57340_/Y }
C {devices/lab_pin.sym} 103740 -21800 0 0 {name=p103113 lab=_57342_/Y }
C {devices/lab_pin.sym} 103900 -21860 0 1 {name=p103114 lab=_57344_/A }
C {sky130_stdcells/a211o_4.sym} 103820 -21860 0 0 {name=X_57343_ }
C {devices/lab_pin.sym} 103730 -21710 0 0 {name=p103115 lab=_85003_/CLK }
C {devices/lab_pin.sym} 103730 -21690 0 0 {name=p103116 lab=_81607_/D }
C {devices/lab_pin.sym} 103910 -21710 0 1 {name=p103117 lab=_81607_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -21700 0 0 {name=X_81607_ }
C {devices/lab_pin.sym} 103780 -21570 0 0 {name=p103118 lab=_68300_/X }
C {devices/lab_pin.sym} 103860 -21570 0 1 {name=p103119 lab=_69329_/X }
C {sky130_stdcells/buf_2.sym} 103820 -21570 0 0 {name=X_69329_ }
C {devices/lab_pin.sym} 103730 -21450 0 0 {name=p103120 lab=_87150_/CLK }
C {devices/lab_pin.sym} 103730 -21430 0 0 {name=p103121 lab=_41716_/X }
C {devices/lab_pin.sym} 103910 -21450 0 1 {name=p103122 lab=_67724_/B }
C {sky130_stdcells/dfxtp_4.sym} 103820 -21440 0 0 {name=X_88163_ }
C {devices/lab_pin.sym} 103760 -21320 0 0 {name=p103123 lab=_54546_/A }
C {devices/lab_pin.sym} 103760 -21280 0 0 {name=p103124 lab=_47116_/A }
C {devices/lab_pin.sym} 103880 -21300 0 1 {name=p103125 lab=_54555_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -21300 0 0 {name=X_54555_ }
C {devices/lab_pin.sym} 103730 -21170 0 0 {name=p103126 lab=_85375_/CLK }
C {devices/lab_pin.sym} 103730 -21150 0 0 {name=p103127 lab=_85375_/D }
C {devices/lab_pin.sym} 103910 -21170 0 1 {name=p103128 lab=_85375_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -21160 0 0 {name=X_85375_ }
C {devices/lab_pin.sym} 103780 -21030 0 0 {name=p103129 lab=_51793_/A }
C {devices/lab_pin.sym} 103860 -21030 0 1 {name=p103130 lab=_51767_/X }
C {sky130_stdcells/buf_2.sym} 103820 -21030 0 0 {name=X_51767_ }
C {devices/lab_pin.sym} 103730 -20910 0 0 {name=p103131 lab=_82675_/CLK }
C {devices/lab_pin.sym} 103730 -20890 0 0 {name=p103132 lab=_82619_/Q }
C {devices/lab_pin.sym} 103910 -20910 0 1 {name=p103133 lab=_78265_/A }
C {sky130_stdcells/dfxtp_4.sym} 103820 -20900 0 0 {name=X_82587_ }
C {devices/lab_pin.sym} 103730 -20770 0 0 {name=p103134 lab=_87116_/CLK }
C {devices/lab_pin.sym} 103730 -20750 0 0 {name=p103135 lab=_87114_/D }
C {devices/lab_pin.sym} 103910 -20770 0 1 {name=p103136 lab=_87114_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -20760 0 0 {name=X_87114_ }
C {devices/lab_pin.sym} 103780 -20630 0 0 {name=p103137 lab=_53448_/X }
C {devices/lab_pin.sym} 103860 -20630 0 1 {name=p103138 lab=_53506_/X }
C {sky130_stdcells/buf_2.sym} 103820 -20630 0 0 {name=X_53506_ }
C {devices/lab_pin.sym} 103780 -20510 0 0 {name=p103139 lab=_41519_/X }
C {devices/lab_pin.sym} 103860 -20510 0 1 {name=p103140 lab=_41520_/X }
C {sky130_stdcells/buf_2.sym} 103820 -20510 0 0 {name=X_41520_ }
C {devices/lab_pin.sym} 103740 -20410 0 0 {name=p103141 lab=_72339_/X }
C {devices/lab_pin.sym} 103740 -20370 0 0 {name=p103142 lab=_85327_/Q }
C {devices/lab_pin.sym} 103740 -20330 0 0 {name=p103143 lab=_72255_/X }
C {devices/lab_pin.sym} 103900 -20370 0 1 {name=p103144 lab=_72340_/X }
C {sky130_stdcells/o21a_4.sym} 103820 -20370 0 0 {name=X_72340_ }
C {devices/lab_pin.sym} 103730 -20230 0 0 {name=p103145 lab=_84355_/CLK }
C {devices/lab_pin.sym} 103730 -20210 0 0 {name=p103146 lab=_63408_/Y }
C {devices/lab_pin.sym} 103910 -20230 0 1 {name=p103147 lab=_80588_/B }
C {sky130_stdcells/dfxtp_4.sym} 103820 -20220 0 0 {name=X_84326_ }
C {devices/lab_pin.sym} 103780 -20090 0 0 {name=p103148 lab=_50718_/A }
C {devices/lab_pin.sym} 103860 -20090 0 1 {name=p103149 lab=_50740_/A }
C {sky130_stdcells/buf_2.sym} 103820 -20090 0 0 {name=X_50718_ }
C {devices/lab_pin.sym} 103730 -19970 0 0 {name=p103150 lab=_81346_/CLK }
C {devices/lab_pin.sym} 103730 -19950 0 0 {name=p103151 lab=_81538_/D }
C {devices/lab_pin.sym} 103910 -19970 0 1 {name=p103152 lab=_81526_/D }
C {sky130_stdcells/dfxtp_4.sym} 103820 -19960 0 0 {name=X_81538_ }
C {devices/lab_pin.sym} 103760 -19840 0 0 {name=p103153 lab=_57273_/Y }
C {devices/lab_pin.sym} 103760 -19800 0 0 {name=p103154 lab=_56672_/Y }
C {devices/lab_pin.sym} 103880 -19820 0 1 {name=p103155 lab=_57274_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -19820 0 0 {name=X_57274_ }
C {devices/lab_pin.sym} 103730 -19690 0 0 {name=p103156 lab=_88108_/CLK }
C {devices/lab_pin.sym} 103730 -19670 0 0 {name=p103157 lab=_41955_/Y }
C {devices/lab_pin.sym} 103910 -19690 0 1 {name=p103158 lab=_74051_/A }
C {sky130_stdcells/dfxtp_4.sym} 103820 -19680 0 0 {name=X_88094_ }
C {devices/lab_pin.sym} 103780 -19550 0 0 {name=p103159 lab=_54486_/A }
C {devices/lab_pin.sym} 103860 -19550 0 1 {name=p103160 lab=_54486_/X }
C {sky130_stdcells/buf_2.sym} 103820 -19550 0 0 {name=X_54486_ }
C {devices/lab_pin.sym} 103740 -19450 0 0 {name=p103161 lab=_85962_/Q }
C {devices/lab_pin.sym} 103740 -19410 0 0 {name=p103162 lab=_51675_/X }
C {devices/lab_pin.sym} 103740 -19370 0 0 {name=p103163 lab=_51697_/Y }
C {devices/lab_pin.sym} 103900 -19410 0 1 {name=p103164 lab=_51698_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -19410 0 0 {name=X_51698_ }
C {devices/lab_pin.sym} 103780 -19270 0 0 {name=p103165 lab=_58904_/A }
C {devices/lab_pin.sym} 103860 -19270 0 1 {name=p103166 lab=_59013_/X }
C {sky130_stdcells/buf_2.sym} 103820 -19270 0 0 {name=X_59013_ }
C {devices/lab_pin.sym} 103780 -19150 0 0 {name=p103167 lab=_56255_/A }
C {devices/lab_pin.sym} 103860 -19150 0 1 {name=p103168 lab=_56225_/X }
C {sky130_stdcells/buf_2.sym} 103820 -19150 0 0 {name=X_56225_ }
C {devices/lab_pin.sym} 103780 -19030 0 0 {name=p103169 lab=_41482_/A }
C {devices/lab_pin.sym} 103860 -19030 0 1 {name=p103170 lab=_41459_/B }
C {sky130_stdcells/buf_2.sym} 103820 -19030 0 0 {name=X_41451_ }
C {devices/lab_pin.sym} 103730 -18910 0 0 {name=p103171 lab=_87045_/CLK }
C {devices/lab_pin.sym} 103730 -18890 0 0 {name=p103172 lab=_87045_/D }
C {devices/lab_pin.sym} 103910 -18910 0 1 {name=p103173 lab=_44583_/A }
C {sky130_stdcells/dfxtp_4.sym} 103820 -18900 0 0 {name=X_87045_ }
C {devices/lab_pin.sym} 103780 -18770 0 0 {name=p103174 lab=_53436_/X }
C {devices/lab_pin.sym} 103860 -18770 0 1 {name=p103175 lab=_53437_/X }
C {sky130_stdcells/buf_2.sym} 103820 -18770 0 0 {name=X_53437_ }
C {devices/lab_pin.sym} 103780 -18650 0 0 {name=p103176 lab=_59238_/A }
C {devices/lab_pin.sym} 103860 -18650 0 1 {name=p103177 lab=_72366_/A }
C {sky130_stdcells/buf_2.sym} 103820 -18650 0 0 {name=X_72271_ }
C {devices/lab_pin.sym} 103730 -18530 0 0 {name=p103178 lab=_84314_/CLK }
C {devices/lab_pin.sym} 103730 -18510 0 0 {name=p103179 lab=_64313_/X }
C {devices/lab_pin.sym} 103910 -18530 0 1 {name=p103180 lab=_79797_/B }
C {sky130_stdcells/dfxtp_4.sym} 103820 -18520 0 0 {name=X_84257_ }
C {devices/lab_pin.sym} 103760 -18400 0 0 {name=p103181 lab=_50607_/A }
C {devices/lab_pin.sym} 103760 -18360 0 0 {name=p103182 lab=_50649_/B }
C {devices/lab_pin.sym} 103880 -18380 0 1 {name=p103183 lab=_50649_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -18380 0 0 {name=X_50649_ }
C {devices/lab_pin.sym} 103730 -18250 0 0 {name=p103184 lab=_82648_/CLK }
C {devices/lab_pin.sym} 103730 -18230 0 0 {name=p103185 lab=_76902_/Y }
C {devices/lab_pin.sym} 103910 -18250 0 1 {name=p103186 lab=_81469_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -18240 0 0 {name=X_81469_ }
C {devices/lab_pin.sym} 103740 -18130 0 0 {name=p103187 lab=_88352_/Q }
C {devices/lab_pin.sym} 103740 -18090 0 0 {name=p103188 lab=_73801_/X }
C {devices/lab_pin.sym} 103740 -18050 0 0 {name=p103189 lab=_73087_/X }
C {devices/lab_pin.sym} 103900 -18090 0 1 {name=p103190 lab=_74010_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -18090 0 0 {name=X_74010_ }
C {devices/lab_pin.sym} 103760 -17960 0 0 {name=p103191 lab=_40402_/A }
C {devices/lab_pin.sym} 103760 -17920 0 0 {name=p103192 lab=_40402_/B }
C {devices/lab_pin.sym} 103880 -17940 0 1 {name=p103193 lab=_40402_/X }
C {sky130_stdcells/or2_4.sym} 103820 -17940 0 0 {name=X_40402_ }
C {devices/lab_pin.sym} 103780 -17810 0 0 {name=p103194 lab=_71054_/A }
C {devices/lab_pin.sym} 103860 -17810 0 1 {name=p103195 lab=_71223_/B }
C {sky130_stdcells/buf_2.sym} 103820 -17810 0 0 {name=X_71222_ }
C {devices/lab_pin.sym} 103730 -17690 0 0 {name=p103196 lab=_83843_/CLK }
C {devices/lab_pin.sym} 103730 -17670 0 0 {name=p103197 lab=_83208_/D }
C {devices/lab_pin.sym} 103910 -17690 0 1 {name=p103198 lab=_70176_/C }
C {sky130_stdcells/dfxtp_4.sym} 103820 -17680 0 0 {name=X_83208_ }
C {devices/lab_pin.sym} 103780 -17550 0 0 {name=p103199 lab=_44170_/A }
C {devices/lab_pin.sym} 103860 -17550 0 1 {name=p103200 lab=_65768_/A }
C {sky130_stdcells/buf_2.sym} 103820 -17550 0 0 {name=X_44170_ }
C {devices/lab_pin.sym} 103780 -17430 0 0 {name=p103201 lab=_55745_/D }
C {devices/lab_pin.sym} 103860 -17430 0 1 {name=p103202 lab=_56167_/A }
C {sky130_stdcells/buf_2.sym} 103820 -17430 0 0 {name=X_56156_ }
C {devices/lab_pin.sym} 103740 -17330 0 0 {name=p103203 lab=_53365_/Y }
C {devices/lab_pin.sym} 103740 -17290 0 0 {name=p103204 lab=_53355_/X }
C {devices/lab_pin.sym} 103740 -17250 0 0 {name=p103205 lab=_53367_/X }
C {devices/lab_pin.sym} 103900 -17290 0 1 {name=p103206 lab=_53368_/Y }
C {sky130_stdcells/a21oi_4.sym} 103820 -17290 0 0 {name=X_53368_ }
C {devices/lab_pin.sym} 103780 -17150 0 0 {name=p103207 lab=_41381_/X }
C {devices/lab_pin.sym} 103860 -17150 0 1 {name=p103208 lab=_41382_/X }
C {sky130_stdcells/buf_2.sym} 103820 -17150 0 0 {name=X_41382_ }
C {devices/lab_pin.sym} 103730 -17030 0 0 {name=p103209 lab=_83521_/CLK }
C {devices/lab_pin.sym} 103730 -17010 0 0 {name=p103210 lab=_84188_/D }
C {devices/lab_pin.sym} 103910 -17030 0 1 {name=p103211 lab=_84188_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -17020 0 0 {name=X_84188_ }
C {devices/lab_pin.sym} 103780 -16890 0 0 {name=p103212 lab=clkbuf_4_4_1_CLK/X }
C {devices/lab_pin.sym} 103860 -16890 0 1 {name=p103213 lab=clkbuf_5_9_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 103820 -16890 0 0 {name=Xclkbuf_5_9_0_CLK }
C {devices/lab_pin.sym} 103740 -16790 0 0 {name=p103214 lab=_85317_/Q }
C {devices/lab_pin.sym} 103740 -16750 0 0 {name=p103215 lab=_55098_/X }
C {devices/lab_pin.sym} 103740 -16710 0 0 {name=p103216 lab=_55106_/Y }
C {devices/lab_pin.sym} 103900 -16750 0 1 {name=p103217 lab=_55107_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -16750 0 0 {name=X_55107_ }
C {devices/lab_pin.sym} 103780 -16610 0 0 {name=p103218 lab=_43121_/A }
C {devices/lab_pin.sym} 103860 -16610 0 1 {name=p103219 lab=_43121_/X }
C {sky130_stdcells/buf_2.sym} 103820 -16610 0 0 {name=X_43121_ }
C {devices/lab_pin.sym} 103760 -16500 0 0 {name=p103220 lab=_43012_/B }
C {devices/lab_pin.sym} 103760 -16460 0 0 {name=p103221 lab=_40332_/Y }
C {devices/lab_pin.sym} 103880 -16480 0 1 {name=p103222 lab=_40343_/A }
C {sky130_stdcells/nor2_4.sym} 103820 -16480 0 0 {name=X_40333_ }
C {devices/lab_pin.sym} 103780 -16350 0 0 {name=p103223 lab=_52319_/A }
C {devices/lab_pin.sym} 103860 -16350 0 1 {name=p103224 lab=_52320_/A }
C {sky130_stdcells/buf_2.sym} 103820 -16350 0 0 {name=X_52319_ }
C {devices/lab_pin.sym} 103740 -16250 0 0 {name=p103225 lab=_48401_/B }
C {devices/lab_pin.sym} 103740 -16210 0 0 {name=p103226 lab=_71138_/X }
C {devices/lab_pin.sym} 103740 -16170 0 0 {name=p103227 lab=_71152_/Y }
C {devices/lab_pin.sym} 103900 -16210 0 1 {name=p103228 lab=_71153_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -16210 0 0 {name=X_71153_ }
C {devices/lab_pin.sym} 103730 -16070 0 0 {name=p103229 lab=_83139_/CLK }
C {devices/lab_pin.sym} 103730 -16050 0 0 {name=p103230 lab=_73722_/Y }
C {devices/lab_pin.sym} 103910 -16070 0 1 {name=p103231 lab=_70103_/A }
C {sky130_stdcells/dfxtp_4.sym} 103820 -16060 0 0 {name=X_83139_ }
C {devices/lab_pin.sym} 103740 -15950 0 0 {name=p103232 lab=_56082_/X }
C {devices/lab_pin.sym} 103740 -15910 0 0 {name=p103233 lab=_56085_/X }
C {devices/lab_pin.sym} 103740 -15870 0 0 {name=p103234 lab=_56086_/Y }
C {devices/lab_pin.sym} 103900 -15910 0 1 {name=p103235 lab=_56087_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -15910 0 0 {name=X_56087_ }
C {devices/lab_pin.sym} 103740 -15790 0 0 {name=p103236 lab=_85659_/Q }
C {devices/lab_pin.sym} 103740 -15750 0 0 {name=p103237 lab=_53295_/X }
C {devices/lab_pin.sym} 103740 -15710 0 0 {name=p103238 lab=_53298_/Y }
C {devices/lab_pin.sym} 103900 -15750 0 1 {name=p103239 lab=_53299_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -15750 0 0 {name=X_53299_ }
C {devices/lab_pin.sym} 103780 -15610 0 0 {name=p103240 lab=_83138_/Q }
C {devices/lab_pin.sym} 103860 -15610 0 1 {name=p103241 lab=_70107_/B }
C {sky130_stdcells/inv_2.sym} 103820 -15610 0 0 {name=X_70104_ }
C {devices/lab_pin.sym} 103780 -15490 0 0 {name=p103242 lab=_43052_/A }
C {devices/lab_pin.sym} 103860 -15490 0 1 {name=p103243 lab=_87594_/D }
C {sky130_stdcells/inv_2.sym} 103820 -15490 0 0 {name=X_43052_ }
C {devices/lab_pin.sym} 103740 -15390 0 0 {name=p103244 lab=_85330_/Q }
C {devices/lab_pin.sym} 103740 -15350 0 0 {name=p103245 lab=_55020_/X }
C {devices/lab_pin.sym} 103740 -15310 0 0 {name=p103246 lab=_55037_/Y }
C {devices/lab_pin.sym} 103900 -15350 0 1 {name=p103247 lab=_55038_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -15350 0 0 {name=X_55038_ }
C {devices/lab_pin.sym} 103760 -15240 0 0 {name=p103248 lab=_59657_/A }
C {devices/lab_pin.sym} 103760 -15200 0 0 {name=p103249 lab=_61293_/B }
C {devices/lab_pin.sym} 103760 -15160 0 0 {name=p103250 lab=_59753_/B }
C {devices/lab_pin.sym} 103760 -15120 0 0 {name=p103251 lab=_60407_/C }
C {devices/lab_pin.sym} 103880 -15180 0 1 {name=p103252 lab=_59917_/A }
C {sky130_stdcells/and4_4.sym} 103820 -15180 0 0 {name=X_59915_ }
C {devices/lab_pin.sym} 103780 -15030 0 0 {name=p103253 lab=_71071_/A }
C {devices/lab_pin.sym} 103860 -15030 0 1 {name=p103254 lab=_71088_/A }
C {sky130_stdcells/buf_2.sym} 103820 -15030 0 0 {name=X_71084_ }
C {devices/lab_pin.sym} 103780 -14910 0 0 {name=p103255 lab=_75961_/A }
C {devices/lab_pin.sym} 103860 -14910 0 1 {name=p103256 lab=_75961_/Y }
C {sky130_stdcells/inv_2.sym} 103820 -14910 0 0 {name=X_75961_ }
C {devices/lab_pin.sym} 103730 -14790 0 0 {name=p103257 lab=_87950_/CLK }
C {devices/lab_pin.sym} 103730 -14770 0 0 {name=p103258 lab=_87947_/D }
C {devices/lab_pin.sym} 103910 -14790 0 1 {name=p103259 lab=_87947_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -14780 0 0 {name=X_87947_ }
C {devices/lab_pin.sym} 103740 -14690 0 0 {name=p103260 lab=_41998_/X }
C {devices/lab_pin.sym} 103740 -14650 0 0 {name=p103261 lab=_41993_/X }
C {devices/lab_pin.sym} 103740 -14610 0 0 {name=p103262 lab=_40806_/X }
C {devices/lab_pin.sym} 103740 -14570 0 0 {name=p103263 lab=_42002_/Y }
C {devices/lab_pin.sym} 103740 -14530 0 0 {name=p103264 lab=_42000_/X }
C {devices/lab_pin.sym} 103900 -14610 0 1 {name=p103265 lab=_42003_/Y }
C {sky130_stdcells/o32ai_4.sym} 103820 -14610 0 0 {name=X_42003_ }
C {devices/lab_pin.sym} 103760 -14460 0 0 {name=p103266 lab=_77698_/Y }
C {devices/lab_pin.sym} 103760 -14420 0 0 {name=p103267 lab=_77699_/X }
C {devices/lab_pin.sym} 103880 -14440 0 1 {name=p103268 lab=_77700_/X }
C {sky130_stdcells/xor2_4.sym} 103820 -14440 0 0 {name=X_77700_ }
C {devices/lab_pin.sym} 103760 -14320 0 0 {name=p103269 lab=_81132_/D }
C {devices/lab_pin.sym} 103760 -14280 0 0 {name=p103270 lab=_74912_/B }
C {devices/lab_pin.sym} 103880 -14300 0 1 {name=p103271 lab=_74912_/X }
C {sky130_stdcells/xor2_4.sym} 103820 -14300 0 0 {name=X_74912_ }
C {devices/lab_pin.sym} 103740 -14200 0 0 {name=p103272 lab=_69520_/X }
C {devices/lab_pin.sym} 103740 -14160 0 0 {name=p103273 lab=_69758_/Y }
C {devices/lab_pin.sym} 103740 -14120 0 0 {name=p103274 lab=_70033_/X }
C {devices/lab_pin.sym} 103740 -14080 0 0 {name=p103275 lab=_70034_/Y }
C {devices/lab_pin.sym} 103900 -14140 0 1 {name=p103276 lab=_70035_/X }
C {sky130_stdcells/a211o_4.sym} 103820 -14140 0 0 {name=X_70035_ }
C {devices/lab_pin.sym} 103740 -14010 0 0 {name=p103277 lab=_46578_/X }
C {devices/lab_pin.sym} 103740 -13970 0 0 {name=p103278 lab=_46274_/A }
C {devices/lab_pin.sym} 103740 -13930 0 0 {name=p103279 lab=_47859_/X }
C {devices/lab_pin.sym} 103900 -13970 0 1 {name=p103280 lab=_47861_/B }
C {sky130_stdcells/o21ai_4.sym} 103820 -13970 0 0 {name=X_47860_ }
C {devices/lab_pin.sym} 103780 -13830 0 0 {name=p103281 lab=_60781_/A }
C {devices/lab_pin.sym} 103860 -13830 0 1 {name=p103282 lab=_59846_/X }
C {sky130_stdcells/buf_2.sym} 103820 -13830 0 0 {name=X_59846_ }
C {devices/lab_pin.sym} 103760 -13720 0 0 {name=p103283 lab=_78680_/A }
C {devices/lab_pin.sym} 103760 -13680 0 0 {name=p103284 lab=_78680_/B }
C {devices/lab_pin.sym} 103880 -13700 0 1 {name=p103285 lab=_78680_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -13700 0 0 {name=X_78680_ }
C {devices/lab_pin.sym} 103760 -13580 0 0 {name=p103286 lab=_84490_/Q }
C {devices/lab_pin.sym} 103760 -13540 0 0 {name=p103287 lab=_62995_/C }
C {devices/lab_pin.sym} 103880 -13560 0 1 {name=p103288 lab=_75892_/X }
C {sky130_stdcells/xor2_4.sym} 103820 -13560 0 0 {name=X_75892_ }
C {devices/lab_pin.sym} 103730 -13430 0 0 {name=p103289 lab=_88398_/CLK }
C {devices/lab_pin.sym} 103730 -13410 0 0 {name=p103290 lab=_42407_/Y }
C {devices/lab_pin.sym} 103910 -13430 0 1 {name=p103291 lab=_87878_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -13420 0 0 {name=X_87878_ }
C {devices/lab_pin.sym} 103760 -13320 0 0 {name=p103292 lab=_46784_/A }
C {devices/lab_pin.sym} 103760 -13280 0 0 {name=p103293 lab=_46830_/B }
C {devices/lab_pin.sym} 103760 -13240 0 0 {name=p103294 lab=_46830_/C }
C {devices/lab_pin.sym} 103760 -13200 0 0 {name=p103295 lab=_46810_/X }
C {devices/lab_pin.sym} 103880 -13260 0 1 {name=p103296 lab=_46811_/X }
C {sky130_stdcells/and4_4.sym} 103820 -13260 0 0 {name=X_46811_ }
C {devices/lab_pin.sym} 103760 -13120 0 0 {name=p103297 lab=_77630_/A }
C {devices/lab_pin.sym} 103760 -13080 0 0 {name=p103298 lab=_82109_/D }
C {devices/lab_pin.sym} 103880 -13100 0 1 {name=p103299 lab=_77632_/A }
C {sky130_stdcells/nand2_4.sym} 103820 -13100 0 0 {name=X_77631_ }
C {devices/lab_pin.sym} 103730 -12970 0 0 {name=p103300 lab=_87990_/CLK }
C {devices/lab_pin.sym} 103730 -12950 0 0 {name=p103301 lab=_86829_/D }
C {devices/lab_pin.sym} 103910 -12970 0 1 {name=p103302 lab=_86829_/Q }
C {sky130_stdcells/dfxtp_4.sym} 103820 -12960 0 0 {name=X_86829_ }
C {devices/lab_pin.sym} 103760 -12850 0 0 {name=p103303 lab=_45909_/X }
C {devices/lab_pin.sym} 103760 -12810 0 0 {name=p103304 lab=_46167_/B }
C {devices/lab_pin.sym} 103760 -12770 0 0 {name=p103305 lab=_46167_/A }
C {devices/lab_pin.sym} 103880 -12810 0 1 {name=p103306 lab=_74843_/Y }
C {sky130_stdcells/nor3_4.sym} 103820 -12810 0 0 {name=X_74843_ }
C {devices/lab_pin.sym} 103780 -12670 0 0 {name=p103307 lab=_47745_/A }
C {devices/lab_pin.sym} 103860 -12670 0 1 {name=p103308 lab=_47791_/X }
C {sky130_stdcells/buf_2.sym} 103820 -12670 0 0 {name=X_47791_ }
C {devices/lab_pin.sym} 103780 -12550 0 0 {name=p103309 lab=_72176_/A }
C {devices/lab_pin.sym} 103860 -12550 0 1 {name=p103310 lab=_59837_/B }
C {sky130_stdcells/buf_2.sym} 103820 -12550 0 0 {name=X_59777_ }
C {devices/lab_pin.sym} 103760 -12440 0 0 {name=p103311 lab=_56989_/A }
C {devices/lab_pin.sym} 103760 -12400 0 0 {name=p103312 lab=_56989_/B }
C {devices/lab_pin.sym} 103880 -12420 0 1 {name=p103313 lab=_56989_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -12420 0 0 {name=X_56989_ }
C {devices/lab_pin.sym} 103760 -12300 0 0 {name=p103314 lab=_49546_/A }
C {devices/lab_pin.sym} 103760 -12260 0 0 {name=p103315 lab=_46912_/X }
C {devices/lab_pin.sym} 103880 -12280 0 1 {name=p103316 lab=_49530_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -12280 0 0 {name=X_49530_ }
C {devices/lab_pin.sym} 103740 -12170 0 0 {name=p103317 lab=_58727_/A }
C {devices/lab_pin.sym} 103740 -12130 0 0 {name=p103318 lab=_46719_/X }
C {devices/lab_pin.sym} 103740 -12090 0 0 {name=p103319 lab=_46741_/Y }
C {devices/lab_pin.sym} 103900 -12130 0 1 {name=p103320 lab=_46742_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -12130 0 0 {name=X_46742_ }
C {devices/lab_pin.sym} 103780 -11990 0 0 {name=p103321 lab=_58603_/A }
C {devices/lab_pin.sym} 103860 -11990 0 1 {name=p103322 lab=_58728_/X }
C {sky130_stdcells/buf_2.sym} 103820 -11990 0 0 {name=X_58728_ }
C {devices/lab_pin.sym} 103740 -11890 0 0 {name=p103323 lab=_77561_/A }
C {devices/lab_pin.sym} 103740 -11850 0 0 {name=p103324 lab=_77561_/C }
C {devices/lab_pin.sym} 103740 -11810 0 0 {name=p103325 lab=_77542_/A }
C {devices/lab_pin.sym} 103900 -11850 0 1 {name=p103326 lab=_77562_/Y }
C {sky130_stdcells/a21oi_4.sym} 103820 -11850 0 0 {name=X_77562_ }
C {devices/lab_pin.sym} 103780 -11710 0 0 {name=p103327 lab=_43979_/A }
C {devices/lab_pin.sym} 103860 -11710 0 1 {name=p103328 lab=_43954_/X }
C {sky130_stdcells/buf_2.sym} 103820 -11710 0 0 {name=X_43954_ }
C {devices/lab_pin.sym} 103760 -11610 0 0 {name=p103329 lab=_70586_/X }
C {devices/lab_pin.sym} 103760 -11570 0 0 {name=p103330 lab=_83829_/Q }
C {devices/lab_pin.sym} 103760 -11530 0 0 {name=p103331 lab=_74753_/X }
C {devices/lab_pin.sym} 103880 -11570 0 1 {name=p103332 lab=_74774_/X }
C {sky130_stdcells/and3_4.sym} 103820 -11570 0 0 {name=X_74774_ }
C {devices/lab_pin.sym} 103780 -11430 0 0 {name=p103333 lab=_72017_/A }
C {devices/lab_pin.sym} 103860 -11430 0 1 {name=p103334 lab=_72007_/A }
C {sky130_stdcells/buf_2.sym} 103820 -11430 0 0 {name=X_71986_ }
C {devices/lab_pin.sym} 103760 -11320 0 0 {name=p103335 lab=_79301_/A }
C {devices/lab_pin.sym} 103760 -11280 0 0 {name=p103336 lab=_83221_/Q }
C {devices/lab_pin.sym} 103880 -11300 0 1 {name=p103337 lab=_79301_/X }
C {sky130_stdcells/xor2_4.sym} 103820 -11300 0 0 {name=X_79301_ }
C {devices/lab_pin.sym} 103760 -11200 0 0 {name=p103338 lab=_76478_/X }
C {devices/lab_pin.sym} 103760 -11160 0 0 {name=p103339 lab=_76513_/B }
C {devices/lab_pin.sym} 103760 -11120 0 0 {name=p103340 lab=_76513_/C }
C {devices/lab_pin.sym} 103760 -11080 0 0 {name=p103341 lab=_76513_/D }
C {devices/lab_pin.sym} 103880 -11140 0 1 {name=p103342 lab=_76514_/A }
C {sky130_stdcells/and4_4.sym} 103820 -11140 0 0 {name=X_76513_ }
C {devices/lab_pin.sym} 103780 -10990 0 0 {name=p103343 lab=_42835_/X }
C {devices/lab_pin.sym} 103860 -10990 0 1 {name=p103344 lab=_42905_/X }
C {sky130_stdcells/buf_2.sym} 103820 -10990 0 0 {name=X_42905_ }
C {devices/lab_pin.sym} 103780 -10870 0 0 {name=p103345 lab=_49407_/A }
C {devices/lab_pin.sym} 103860 -10870 0 1 {name=p103346 lab=_49467_/A }
C {sky130_stdcells/buf_2.sym} 103820 -10870 0 0 {name=X_49461_ }
C {devices/lab_pin.sym} 103760 -10760 0 0 {name=p103347 lab=_87340_/Q }
C {devices/lab_pin.sym} 103760 -10720 0 0 {name=p103348 lab=_73701_/B }
C {devices/lab_pin.sym} 103880 -10740 0 1 {name=p103349 lab=_73725_/Y }
C {sky130_stdcells/nor2_4.sym} 103820 -10740 0 0 {name=X_73725_ }
C {devices/lab_pin.sym} 103780 -10610 0 0 {name=p103350 lab=_70936_/X }
C {devices/lab_pin.sym} 103860 -10610 0 1 {name=p103351 lab=_70937_/X }
C {sky130_stdcells/buf_2.sym} 103820 -10610 0 0 {name=X_70937_ }
C {devices/lab_pin.sym} 103780 -10490 0 0 {name=p103352 lab=_46249_/A }
C {devices/lab_pin.sym} 103860 -10490 0 1 {name=p103353 lab=_46720_/A }
C {sky130_stdcells/buf_2.sym} 103820 -10490 0 0 {name=X_46673_ }
C {devices/lab_pin.sym} 103760 -10380 0 0 {name=p103354 lab=_58659_/A }
C {devices/lab_pin.sym} 103760 -10340 0 0 {name=p103355 lab=_86394_/Q }
C {devices/lab_pin.sym} 103880 -10360 0 1 {name=p103356 lab=_58659_/Y }
C {sky130_stdcells/nor2_4.sym} 103820 -10360 0 0 {name=X_58659_ }
C {devices/lab_pin.sym} 103780 -10230 0 0 {name=p103357 lab=_77493_/A }
C {devices/lab_pin.sym} 103860 -10230 0 1 {name=p103358 lab=_77493_/Y }
C {sky130_stdcells/inv_2.sym} 103820 -10230 0 0 {name=X_77493_ }
C {devices/lab_pin.sym} 103740 -10140 0 0 {name=p103359 lab=_41302_/X }
C {devices/lab_pin.sym} 103740 -10100 0 0 {name=p103360 lab=_43879_/X }
C {devices/lab_pin.sym} 103740 -10060 0 0 {name=p103361 lab=_87216_/Q }
C {devices/lab_pin.sym} 103740 -10020 0 0 {name=p103362 lab=_43880_/X }
C {devices/lab_pin.sym} 103900 -10080 0 1 {name=p103363 lab=_87216_/D }
C {sky130_stdcells/a2bb2o_4.sym} 103820 -10080 0 0 {name=X_43885_ }
C {devices/lab_pin.sym} 103760 -9940 0 0 {name=p103364 lab=_48401_/A }
C {devices/lab_pin.sym} 103760 -9900 0 0 {name=p103365 lab=_52121_/B }
C {devices/lab_pin.sym} 103880 -9920 0 1 {name=p103366 lab=_48412_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -9920 0 0 {name=X_48412_ }
C {devices/lab_pin.sym} 103760 -9800 0 0 {name=p103367 lab=_79230_/Y }
C {devices/lab_pin.sym} 103760 -9760 0 0 {name=p103368 lab=_79232_/B }
C {devices/lab_pin.sym} 103880 -9780 0 1 {name=p103369 lab=_79233_/A }
C {sky130_stdcells/or2_4.sym} 103820 -9780 0 0 {name=X_79232_ }
C {devices/lab_pin.sym} 103780 -9650 0 0 {name=p103370 lab=clkbuf_7_70_0_CLK/A }
C {devices/lab_pin.sym} 103860 -9650 0 1 {name=p103371 lab=clkbuf_7_71_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 103820 -9650 0 0 {name=Xclkbuf_7_71_0_CLK }
C {devices/lab_pin.sym} 103740 -9550 0 0 {name=p103372 lab=_45591_/X }
C {devices/lab_pin.sym} 103740 -9510 0 0 {name=p103373 lab=_61502_/A }
C {devices/lab_pin.sym} 103740 -9470 0 0 {name=p103374 lab=_45608_/X }
C {devices/lab_pin.sym} 103900 -9510 0 1 {name=p103375 lab=_45624_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -9510 0 0 {name=X_45624_ }
C {devices/lab_pin.sym} 103780 -9370 0 0 {name=p103376 lab=_76432_/X }
C {devices/lab_pin.sym} 103860 -9370 0 1 {name=p103377 lab=_76444_/Y }
C {sky130_stdcells/inv_2.sym} 103820 -9370 0 0 {name=X_76444_ }
C {devices/lab_pin.sym} 103780 -9250 0 0 {name=p103378 lab=_42835_/X }
C {devices/lab_pin.sym} 103860 -9250 0 1 {name=p103379 lab=_42836_/X }
C {sky130_stdcells/buf_2.sym} 103820 -9250 0 0 {name=X_42836_ }
C {devices/lab_pin.sym} 103760 -9160 0 0 {name=p103380 lab=_49397_/A }
C {devices/lab_pin.sym} 103760 -9120 0 0 {name=p103381 lab=_49369_/X }
C {devices/lab_pin.sym} 103760 -9080 0 0 {name=p103382 lab=_49408_/C }
C {devices/lab_pin.sym} 103760 -9040 0 0 {name=p103383 lab=_51777_/D }
C {devices/lab_pin.sym} 103880 -9100 0 1 {name=p103384 lab=_49392_/X }
C {sky130_stdcells/and4_4.sym} 103820 -9100 0 0 {name=X_49392_ }
C {devices/lab_pin.sym} 103740 -8990 0 0 {name=p103385 lab=_61663_/Y }
C {devices/lab_pin.sym} 103740 -8950 0 0 {name=p103386 lab=_61665_/Y }
C {devices/lab_pin.sym} 103740 -8910 0 0 {name=p103387 lab=_61594_/X }
C {devices/lab_pin.sym} 103740 -8870 0 0 {name=p103388 lab=_61666_/Y }
C {devices/lab_pin.sym} 103740 -8840 0 0 {name=p103389 lab=_61669_/Y }
C {devices/lab_pin.sym} 103900 -8910 0 1 {name=p103390 lab=_61670_/X }
C {sky130_stdcells/a41o_4.sym} 103820 -8910 0 0 {name=X_61670_ }
C {devices/lab_pin.sym} 103780 -8750 0 0 {name=p103391 lab=_72861_/X }
C {devices/lab_pin.sym} 103860 -8750 0 1 {name=p103392 lab=_73656_/X }
C {sky130_stdcells/buf_2.sym} 103820 -8750 0 0 {name=X_73656_ }
C {devices/lab_pin.sym} 103740 -8650 0 0 {name=p103393 lab=_51800_/B }
C {devices/lab_pin.sym} 103740 -8610 0 0 {name=p103394 lab=_70855_/X }
C {devices/lab_pin.sym} 103740 -8570 0 0 {name=p103395 lab=_70867_/Y }
C {devices/lab_pin.sym} 103900 -8610 0 1 {name=p103396 lab=_70868_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -8610 0 0 {name=X_70868_ }
C {devices/lab_pin.sym} 103760 -8480 0 0 {name=p103397 lab=_48348_/A }
C {devices/lab_pin.sym} 103760 -8440 0 0 {name=p103398 lab=_50381_/B }
C {devices/lab_pin.sym} 103880 -8460 0 1 {name=p103399 lab=_48343_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -8460 0 0 {name=X_48343_ }
C {devices/lab_pin.sym} 103780 -8330 0 0 {name=p103400 lab=_60620_/Y }
C {devices/lab_pin.sym} 103860 -8330 0 1 {name=p103401 lab=_60622_/D }
C {sky130_stdcells/inv_2.sym} 103820 -8330 0 0 {name=X_60621_ }
C {devices/lab_pin.sym} 103760 -8230 0 0 {name=p103402 lab=_72516_/A }
C {devices/lab_pin.sym} 103760 -8190 0 0 {name=p103403 lab=_72607_/B }
C {devices/lab_pin.sym} 103760 -8150 0 0 {name=p103404 lab=_72607_/C }
C {devices/lab_pin.sym} 103880 -8190 0 1 {name=p103405 lab=_72607_/Y }
C {sky130_stdcells/nand3_4.sym} 103820 -8190 0 0 {name=X_72607_ }
C {devices/lab_pin.sym} 103760 -8060 0 0 {name=p103406 lab=_84786_/Q }
C {devices/lab_pin.sym} 103760 -8020 0 0 {name=p103407 lab=_66524_/C }
C {devices/lab_pin.sym} 103880 -8040 0 1 {name=p103408 lab=_79163_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -8040 0 0 {name=X_79163_ }
C {devices/lab_pin.sym} 103740 -7930 0 0 {name=p103409 lab=_45550_/X }
C {devices/lab_pin.sym} 103740 -7890 0 0 {name=p103410 lab=_45554_/X }
C {devices/lab_pin.sym} 103740 -7850 0 0 {name=p103411 lab=_45523_/X }
C {devices/lab_pin.sym} 103900 -7890 0 1 {name=p103412 lab=_45555_/X }
C {sky130_stdcells/a21o_4.sym} 103820 -7890 0 0 {name=X_45555_ }
C {devices/lab_pin.sym} 103760 -7760 0 0 {name=p103413 lab=_81361_/Q }
C {devices/lab_pin.sym} 103760 -7720 0 0 {name=p103414 lab=_81617_/D }
C {devices/lab_pin.sym} 103880 -7740 0 1 {name=p103415 lab=_76375_/X }
C {sky130_stdcells/xor2_4.sym} 103820 -7740 0 0 {name=X_76375_ }
C {devices/lab_pin.sym} 103780 -7610 0 0 {name=p103416 lab=_42745_/A }
C {devices/lab_pin.sym} 103860 -7610 0 1 {name=p103417 lab=_42767_/X }
C {sky130_stdcells/buf_2.sym} 103820 -7610 0 0 {name=X_42767_ }
C {devices/lab_pin.sym} 103740 -7510 0 0 {name=p103418 lab=_73584_/X }
C {devices/lab_pin.sym} 103740 -7470 0 0 {name=p103419 lab=_73586_/X }
C {devices/lab_pin.sym} 103740 -7430 0 0 {name=p103420 lab=_73383_/X }
C {devices/lab_pin.sym} 103900 -7470 0 1 {name=p103421 lab=_73590_/A }
C {sky130_stdcells/a21o_4.sym} 103820 -7470 0 0 {name=X_73587_ }
C {devices/lab_pin.sym} 103780 -7330 0 0 {name=p103422 lab=_70798_/X }
C {devices/lab_pin.sym} 103860 -7330 0 1 {name=p103423 lab=_71221_/A }
C {sky130_stdcells/buf_2.sym} 103820 -7330 0 0 {name=X_70799_ }
C {devices/lab_pin.sym} 103780 -7210 0 0 {name=p103424 lab=clkbuf_1_1_0_CLK/X }
C {devices/lab_pin.sym} 103860 -7210 0 1 {name=p103425 lab=clkbuf_1_1_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 103820 -7210 0 0 {name=Xclkbuf_1_1_1_CLK }
C {devices/lab_pin.sym} 103760 -7100 0 0 {name=p103426 lab=_82567_/Q }
C {devices/lab_pin.sym} 103760 -7060 0 0 {name=p103427 lab=_78108_/B }
C {devices/lab_pin.sym} 103880 -7080 0 1 {name=p103428 lab=_78114_/Y }
C {sky130_stdcells/nand2_4.sym} 103820 -7080 0 0 {name=X_78114_ }
C {devices/lab_pin.sym} 103740 -6980 0 0 {name=p103429 lab=_41267_/Y }
C {devices/lab_pin.sym} 103740 -6940 0 0 {name=p103430 lab=_44502_/X }
C {devices/lab_pin.sym} 103740 -6900 0 0 {name=p103431 lab=_87075_/Q }
C {devices/lab_pin.sym} 103740 -6860 0 0 {name=p103432 lab=_44503_/X }
C {devices/lab_pin.sym} 103900 -6920 0 1 {name=p103433 lab=_44506_/X }
C {sky130_stdcells/a2bb2o_4.sym} 103820 -6920 0 0 {name=X_44506_ }
C {devices/lab_pin.sym} 103740 -6790 0 0 {name=p103434 lab=_75289_/Y }
C {devices/lab_pin.sym} 103740 -6750 0 0 {name=p103435 lab=_75291_/X }
C {devices/lab_pin.sym} 103740 -6710 0 0 {name=p103436 lab=_75301_/X }
C {devices/lab_pin.sym} 103900 -6750 0 1 {name=p103437 lab=_75326_/X }
C {sky130_stdcells/a21o_4.sym} 103820 -6750 0 0 {name=X_75326_ }
C {devices/lab_pin.sym} 103760 -6640 0 0 {name=p103438 lab=_60454_/A }
C {devices/lab_pin.sym} 103760 -6600 0 0 {name=p103439 lab=_64545_/B }
C {devices/lab_pin.sym} 103760 -6560 0 0 {name=p103440 lab=_60441_/B }
C {devices/lab_pin.sym} 103760 -6520 0 0 {name=p103441 lab=_60473_/B }
C {devices/lab_pin.sym} 103880 -6580 0 1 {name=p103442 lab=_63340_/X }
C {sky130_stdcells/and4_4.sym} 103820 -6580 0 0 {name=X_63340_ }
C {devices/lab_pin.sym} 103780 -6430 0 0 {name=p103443 lab=_46317_/A }
C {devices/lab_pin.sym} 103860 -6430 0 1 {name=p103444 lab=_41718_/X }
C {sky130_stdcells/buf_2.sym} 103820 -6430 0 0 {name=X_41718_ }
C {devices/lab_pin.sym} 103780 -6310 0 0 {name=p103445 lab=_48903_/A }
C {devices/lab_pin.sym} 103860 -6310 0 1 {name=p103446 lab=_49215_/A }
C {sky130_stdcells/buf_2.sym} 103820 -6310 0 0 {name=X_48274_ }
C {devices/lab_pin.sym} 103740 -6230 0 0 {name=p103447 lab=_61278_/B }
C {devices/lab_pin.sym} 103740 -6190 0 0 {name=p103448 lab=_61281_/C }
C {devices/lab_pin.sym} 103740 -6150 0 0 {name=p103449 lab=_63733_/X }
C {devices/lab_pin.sym} 103740 -6110 0 0 {name=p103450 lab=_61260_/A }
C {devices/lab_pin.sym} 103740 -6070 0 0 {name=p103451 lab=_61319_/X }
C {devices/lab_pin.sym} 103900 -6150 0 1 {name=p103452 lab=_72539_/B }
C {sky130_stdcells/a32oi_4.sym} 103820 -6150 0 0 {name=X_72538_ }
C {devices/lab_pin.sym} 103740 -6030 0 0 {name=p103453 lab=_72527_/A }
C {devices/lab_pin.sym} 103740 -5990 0 0 {name=p103454 lab=_72527_/B }
C {devices/lab_pin.sym} 103740 -5950 0 0 {name=p103455 lab=_79141_/A }
C {devices/lab_pin.sym} 103740 -5910 0 0 {name=p103456 lab=_60551_/X }
C {devices/lab_pin.sym} 103740 -5870 0 0 {name=p103457 lab=_60595_/C }
C {devices/lab_pin.sym} 103900 -5950 0 1 {name=p103458 lab=_84601_/D }
C {sky130_stdcells/a32o_4.sym} 103820 -5950 0 0 {name=X_60552_ }
C {devices/lab_pin.sym} 103760 -5800 0 0 {name=p103459 lab=_79095_/A }
C {devices/lab_pin.sym} 103760 -5760 0 0 {name=p103460 lab=_79095_/B }
C {devices/lab_pin.sym} 103880 -5780 0 1 {name=p103461 lab=_79094_/X }
C {sky130_stdcells/xor2_4.sym} 103820 -5780 0 0 {name=X_79094_ }
C {devices/lab_pin.sym} 103760 -5660 0 0 {name=p103462 lab=_85115_/Q }
C {devices/lab_pin.sym} 103760 -5620 0 0 {name=p103463 lab=_45456_/X }
C {devices/lab_pin.sym} 103880 -5640 0 1 {name=p103464 lab=_45486_/Y }
C {sky130_stdcells/nor2_4.sym} 103820 -5640 0 0 {name=X_45486_ }
C {devices/lab_pin.sym} 103740 -5540 0 0 {name=p103465 lab=_41108_/X }
C {devices/lab_pin.sym} 103740 -5500 0 0 {name=p103466 lab=_42695_/X }
C {devices/lab_pin.sym} 103740 -5460 0 0 {name=p103467 lab=_69553_/B }
C {devices/lab_pin.sym} 103740 -5420 0 0 {name=p103468 lab=_42696_/X }
C {devices/lab_pin.sym} 103900 -5480 0 1 {name=p103469 lab=_42698_/X }
C {sky130_stdcells/a2bb2o_4.sym} 103820 -5480 0 0 {name=X_42698_ }
C {devices/lab_pin.sym} 103780 -5330 0 0 {name=p103470 lab=clkbuf_7_87_0_CLK/A }
C {devices/lab_pin.sym} 103860 -5330 0 1 {name=p103471 lab=clkbuf_7_86_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 103820 -5330 0 0 {name=Xclkbuf_7_86_0_CLK }
C {devices/lab_pin.sym} 103780 -5210 0 0 {name=p103472 lab=_47130_/A }
C {devices/lab_pin.sym} 103860 -5210 0 1 {name=p103473 lab=_47228_/B }
C {sky130_stdcells/buf_2.sym} 103820 -5210 0 0 {name=X_47225_ }
C {devices/lab_pin.sym} 103760 -5100 0 0 {name=p103474 lab=_78045_/A }
C {devices/lab_pin.sym} 103760 -5060 0 0 {name=p103475 lab=_78045_/B }
C {devices/lab_pin.sym} 103880 -5080 0 1 {name=p103476 lab=_81923_/D }
C {sky130_stdcells/nand2_4.sym} 103820 -5080 0 0 {name=X_78045_ }
C {devices/lab_pin.sym} 103780 -4950 0 0 {name=p103477 lab=_44437_/A }
C {devices/lab_pin.sym} 103860 -4950 0 1 {name=p103478 lab=_44437_/Y }
C {sky130_stdcells/inv_2.sym} 103820 -4950 0 0 {name=X_44437_ }
C {devices/lab_pin.sym} 103740 -4860 0 0 {name=p103479 lab=_58498_/A }
C {devices/lab_pin.sym} 103740 -4820 0 0 {name=p103480 lab=_63250_/X }
C {devices/lab_pin.sym} 103740 -4780 0 0 {name=p103481 lab=_58400_/A }
C {devices/lab_pin.sym} 103740 -4740 0 0 {name=p103482 lab=_60493_/X }
C {devices/lab_pin.sym} 103900 -4800 0 1 {name=p103483 lab=_63271_/X }
C {sky130_stdcells/o22a_4.sym} 103820 -4800 0 0 {name=X_63271_ }
C {devices/lab_pin.sym} 103780 -4650 0 0 {name=p103484 lab=_75256_/Y }
C {devices/lab_pin.sym} 103860 -4650 0 1 {name=p103485 lab=_75258_/C }
C {sky130_stdcells/inv_2.sym} 103820 -4650 0 0 {name=X_75257_ }
C {devices/lab_pin.sym} 103760 -4540 0 0 {name=p103486 lab=_82909_/Q }
C {devices/lab_pin.sym} 103760 -4500 0 0 {name=p103487 lab=_41624_/B }
C {devices/lab_pin.sym} 103880 -4520 0 1 {name=p103488 lab=_41649_/X }
C {sky130_stdcells/or2_4.sym} 103820 -4520 0 0 {name=X_41649_ }
C {devices/lab_pin.sym} 103780 -4390 0 0 {name=p103489 lab=_60482_/Y }
C {devices/lab_pin.sym} 103860 -4390 0 1 {name=p103490 lab=_60484_/A }
C {sky130_stdcells/buf_2.sym} 103820 -4390 0 0 {name=X_60483_ }
C {devices/lab_pin.sym} 103740 -4290 0 0 {name=p103491 lab=_57791_/X }
C {devices/lab_pin.sym} 103740 -4250 0 0 {name=p103492 lab=_85955_/Q }
C {devices/lab_pin.sym} 103740 -4210 0 0 {name=p103493 lab=_72468_/X }
C {devices/lab_pin.sym} 103900 -4250 0 1 {name=p103494 lab=_72469_/Y }
C {sky130_stdcells/o21ai_4.sym} 103820 -4250 0 0 {name=X_72469_ }
C {devices/lab_pin.sym} 103760 -4120 0 0 {name=p103495 lab=_64904_/A }
C {devices/lab_pin.sym} 103760 -4080 0 0 {name=p103496 lab=_85842_/Q }
C {devices/lab_pin.sym} 103880 -4100 0 1 {name=p103497 lab=_65010_/X }
C {sky130_stdcells/and2_4.sym} 103820 -4100 0 0 {name=X_65010_ }
C {devices/lab_pin.sym} 103780 -3970 0 0 {name=p103498 lab=_62336_/A }
C {devices/lab_pin.sym} 103860 -3970 0 1 {name=p103499 lab=_62236_/A }
C {sky130_stdcells/buf_2.sym} 103820 -3970 0 0 {name=X_62222_ }
C {devices/lab_pin.sym} 103740 -3870 0 0 {name=p103500 lab=_74205_/X }
C {devices/lab_pin.sym} 103740 -3830 0 0 {name=p103501 lab=_74207_/X }
C {devices/lab_pin.sym} 103740 -3790 0 0 {name=p103502 lab=_73602_/X }
C {devices/lab_pin.sym} 103900 -3830 0 1 {name=p103503 lab=_74208_/X }
C {sky130_stdcells/a21o_4.sym} 103820 -3830 0 0 {name=X_74208_ }
C {devices/lab_pin.sym} 103740 -3710 0 0 {name=p103504 lab=_47151_/Y }
C {devices/lab_pin.sym} 103740 -3670 0 0 {name=p103505 lab=_47128_/X }
C {devices/lab_pin.sym} 103740 -3630 0 0 {name=p103506 lab=_47155_/X }
C {devices/lab_pin.sym} 103900 -3670 0 1 {name=p103507 lab=_47156_/Y }
C {sky130_stdcells/a21oi_4.sym} 103820 -3670 0 0 {name=X_47156_ }
C {devices/lab_pin.sym} 103740 -3560 0 0 {name=p103508 lab=_41749_/X }
C {devices/lab_pin.sym} 103740 -3520 0 0 {name=p103509 lab=_44364_/X }
C {devices/lab_pin.sym} 103740 -3480 0 0 {name=p103510 lab=_87144_/Q }
C {devices/lab_pin.sym} 103740 -3440 0 0 {name=p103511 lab=_44365_/X }
C {devices/lab_pin.sym} 103900 -3500 0 1 {name=p103512 lab=_87144_/D }
C {sky130_stdcells/a2bb2o_4.sym} 103820 -3500 0 0 {name=X_44368_ }
C {devices/lab_pin.sym} 103780 -3350 0 0 {name=p103513 lab=_75188_/A }
C {devices/lab_pin.sym} 103860 -3350 0 1 {name=p103514 lab=_75190_/B }
C {sky130_stdcells/inv_2.sym} 103820 -3350 0 0 {name=X_75188_ }
C {devices/lab_pin.sym} 103760 -3240 0 0 {name=p103515 lab=_46107_/A }
C {devices/lab_pin.sym} 103760 -3200 0 0 {name=p103516 lab=_46188_/A }
C {devices/lab_pin.sym} 103880 -3220 0 1 {name=p103517 lab=_46108_/D }
C {sky130_stdcells/nor2_4.sym} 103820 -3220 0 0 {name=X_46107_ }
C {devices/lab_pin.sym} 103780 -3090 0 0 {name=p103518 lab=_43305_/A }
C {devices/lab_pin.sym} 103860 -3090 0 1 {name=p103519 lab=_43319_/X }
C {sky130_stdcells/buf_2.sym} 103820 -3090 0 0 {name=X_43319_ }
C {devices/lab_pin.sym} 103760 -3000 0 0 {name=p103520 lab=_61715_/A }
C {devices/lab_pin.sym} 103760 -2960 0 0 {name=p103521 lab=_62153_/B }
C {devices/lab_pin.sym} 103760 -2920 0 0 {name=p103522 lab=_62150_/Y }
C {devices/lab_pin.sym} 103760 -2880 0 0 {name=p103523 lab=_62152_/Y }
C {devices/lab_pin.sym} 103880 -2940 0 1 {name=p103524 lab=_62153_/Y }
C {sky130_stdcells/nand4_4.sym} 103820 -2940 0 0 {name=X_62153_ }
C {devices/lab_pin.sym} 103780 -2790 0 0 {name=p103525 lab=_74139_/A }
C {devices/lab_pin.sym} 103860 -2790 0 1 {name=p103526 lab=_74139_/X }
C {sky130_stdcells/buf_2.sym} 103820 -2790 0 0 {name=X_74139_ }
C {devices/lab_pin.sym} 103780 -2670 0 0 {name=p103527 lab=_47087_/A }
C {devices/lab_pin.sym} 103860 -2670 0 1 {name=p103528 lab=_53364_/B }
C {sky130_stdcells/inv_2.sym} 103820 -2670 0 0 {name=X_47087_ }
C {devices/lab_pin.sym} 103780 -2550 0 0 {name=p103529 lab=_44299_/A }
C {devices/lab_pin.sym} 103860 -2550 0 1 {name=p103530 lab=_59238_/A }
C {sky130_stdcells/buf_2.sym} 103820 -2550 0 0 {name=X_44299_ }
C {devices/lab_pin.sym} 103780 -2430 0 0 {name=p103531 lab=_79995_/Y }
C {devices/lab_pin.sym} 103860 -2430 0 1 {name=p103532 lab=_80000_/A }
C {sky130_stdcells/inv_2.sym} 103820 -2430 0 0 {name=X_79996_ }
C {devices/lab_pin.sym} 103740 -2350 0 0 {name=p103533 lab=_61095_/X }
C {devices/lab_pin.sym} 103740 -2310 0 0 {name=p103534 lab=_61097_/X }
C {devices/lab_pin.sym} 103740 -2270 0 0 {name=p103535 lab=_61230_/C }
C {devices/lab_pin.sym} 103740 -2230 0 0 {name=p103536 lab=_61103_/X }
C {devices/lab_pin.sym} 103740 -2200 0 0 {name=p103537 lab=_60529_/A }
C {devices/lab_pin.sym} 103900 -2270 0 1 {name=p103538 lab=_61104_/Y }
C {sky130_stdcells/a41oi_4.sym} 103820 -2270 0 0 {name=X_61104_ }
C {devices/lab_pin.sym} 103780 -2110 0 0 {name=p103539 lab=_46038_/A }
C {devices/lab_pin.sym} 103860 -2110 0 1 {name=p103540 lab=_46038_/Y }
C {sky130_stdcells/inv_2.sym} 103820 -2110 0 0 {name=X_46038_ }
C {devices/lab_pin.sym} 103780 -1990 0 0 {name=p103541 lab=_68721_/A }
C {devices/lab_pin.sym} 103860 -1990 0 1 {name=p103542 lab=_66961_/X }
C {sky130_stdcells/buf_2.sym} 103820 -1990 0 0 {name=X_66961_ }
C {devices/lab_pin.sym} 103740 -1890 0 0 {name=p103543 lab=_61716_/X }
C {devices/lab_pin.sym} 103740 -1850 0 0 {name=p103544 lab=_61607_/B }
C {devices/lab_pin.sym} 103740 -1810 0 0 {name=p103545 lab=_62083_/X }
C {devices/lab_pin.sym} 103900 -1850 0 1 {name=p103546 lab=_62084_/X }
C {sky130_stdcells/a21o_4.sym} 103820 -1850 0 0 {name=X_62084_ }
C {devices/lab_pin.sym} 103760 -1720 0 0 {name=p103547 lab=_82737_/Q }
C {devices/lab_pin.sym} 103760 -1680 0 0 {name=p103548 lab=_78947_/B }
C {devices/lab_pin.sym} 103880 -1700 0 1 {name=p103549 lab=_82705_/D }
C {sky130_stdcells/xor2_4.sym} 103820 -1700 0 0 {name=X_78947_ }
C {devices/lab_pin.sym} 103740 -1600 0 0 {name=p103550 lab=_86994_/Q }
C {devices/lab_pin.sym} 103740 -1560 0 0 {name=p103551 lab=_68570_/X }
C {devices/lab_pin.sym} 103740 -1520 0 0 {name=p103552 lab=_68571_/X }
C {devices/lab_pin.sym} 103740 -1480 0 0 {name=p103553 lab=_68699_/X }
C {devices/lab_pin.sym} 103900 -1540 0 1 {name=p103554 lab=_68700_/X }
C {sky130_stdcells/a211o_4.sym} 103820 -1540 0 0 {name=X_68700_ }
C {devices/lab_pin.sym} 103740 -1420 0 0 {name=p103555 lab=_65811_/X }
C {devices/lab_pin.sym} 103740 -1380 0 0 {name=p103556 lab=_84993_/Q }
C {devices/lab_pin.sym} 103740 -1340 0 0 {name=p103557 lab=_65865_/X }
C {devices/lab_pin.sym} 103740 -1300 0 0 {name=p103558 lab=_65911_/X }
C {devices/lab_pin.sym} 103900 -1360 0 1 {name=p103559 lab=_65912_/X }
C {sky130_stdcells/a211o_4.sym} 103820 -1360 0 0 {name=X_65912_ }
C {devices/lab_pin.sym} 103740 -1230 0 0 {name=p103560 lab=_60998_/X }
C {devices/lab_pin.sym} 103740 -1190 0 0 {name=p103561 lab=_60996_/Y }
C {devices/lab_pin.sym} 103740 -1150 0 0 {name=p103562 lab=_60880_/X }
C {devices/lab_pin.sym} 103900 -1190 0 1 {name=p103563 lab=_61035_/X }
C {sky130_stdcells/a21bo_4.sym} 103820 -1190 0 0 {name=X_61035_ }
C {devices/lab_pin.sym} 103760 -1060 0 0 {name=p103564 lab=_69680_/A }
C {devices/lab_pin.sym} 103760 -1020 0 0 {name=p103565 lab=_88331_/Q }
C {devices/lab_pin.sym} 103880 -1040 0 1 {name=p103566 lab=_69680_/X }
C {sky130_stdcells/and2_4.sym} 103820 -1040 0 0 {name=X_69680_ }
C {devices/lab_pin.sym} 103760 -920 0 0 {name=p103567 lab=_66823_/A }
C {devices/lab_pin.sym} 103760 -880 0 0 {name=p103568 lab=_66892_/B }
C {devices/lab_pin.sym} 103880 -900 0 1 {name=p103569 lab=_66892_/X }
C {sky130_stdcells/and2_4.sym} 103820 -900 0 0 {name=X_66892_ }
C {devices/lab_pin.sym} 103740 -790 0 0 {name=p103570 lab=_78876_/X }
C {devices/lab_pin.sym} 103740 -750 0 0 {name=p103571 lab=_78865_/X }
C {devices/lab_pin.sym} 103740 -710 0 0 {name=p103572 lab=_78877_/X }
C {devices/lab_pin.sym} 103900 -750 0 1 {name=p103573 lab=_78878_/X }
C {sky130_stdcells/a21o_4.sym} 103820 -750 0 0 {name=X_78878_ }
C {devices/lab_pin.sym} 104700 -42150 0 0 {name=p103574 lab=clkbuf_6_12_0_CLK/X }
C {devices/lab_pin.sym} 104780 -42150 0 1 {name=p103575 lab=clkbuf_8_49_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 104740 -42150 0 0 {name=Xclkbuf_7_24_0_CLK }
C {devices/lab_pin.sym} 104680 -42040 0 0 {name=p103576 lab=_68560_/A }
C {devices/lab_pin.sym} 104680 -42000 0 0 {name=p103577 lab=_68631_/B }
C {devices/lab_pin.sym} 104800 -42020 0 1 {name=p103578 lab=_68631_/X }
C {sky130_stdcells/and2_4.sym} 104740 -42020 0 0 {name=X_68631_ }
C {devices/lab_pin.sym} 104660 -41910 0 0 {name=p103579 lab=_65833_/Y }
C {devices/lab_pin.sym} 104660 -41870 0 0 {name=p103580 lab=_65841_/Y }
C {devices/lab_pin.sym} 104660 -41830 0 0 {name=p103581 lab=_65842_/X }
C {devices/lab_pin.sym} 104820 -41870 0 1 {name=p103582 lab=_65843_/Y }
C {sky130_stdcells/a21oi_4.sym} 104740 -41870 0 0 {name=X_65843_ }
C {devices/lab_pin.sym} 104660 -41750 0 0 {name=p103583 lab=_77822_/Y }
C {devices/lab_pin.sym} 104660 -41710 0 0 {name=p103584 lab=_77835_/A }
C {devices/lab_pin.sym} 104660 -41670 0 0 {name=p103585 lab=_77828_/Y }
C {devices/lab_pin.sym} 104820 -41710 0 1 {name=p103586 lab=_77830_/B }
C {sky130_stdcells/a21oi_4.sym} 104740 -41710 0 0 {name=X_77829_ }
C {devices/lab_pin.sym} 104660 -41590 0 0 {name=p103587 lab=_73927_/B }
C {devices/lab_pin.sym} 104660 -41550 0 0 {name=p103588 lab=_47948_/X }
C {devices/lab_pin.sym} 104660 -41510 0 0 {name=p103589 lab=_47988_/Y }
C {devices/lab_pin.sym} 104820 -41550 0 1 {name=p103590 lab=_47989_/Y }
C {sky130_stdcells/o21ai_4.sym} 104740 -41550 0 0 {name=X_47989_ }
C {devices/lab_pin.sym} 104700 -41410 0 0 {name=p103591 lab=clkbuf_7_82_0_CLK/X }
C {devices/lab_pin.sym} 104780 -41410 0 1 {name=p103592 lab=clkbuf_9_329_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 104740 -41410 0 0 {name=Xclkbuf_8_164_0_CLK }
C {devices/lab_pin.sym} 104680 -41320 0 0 {name=p103593 lab=_49708_/A }
C {devices/lab_pin.sym} 104680 -41280 0 0 {name=p103594 lab=_49724_/B }
C {devices/lab_pin.sym} 104680 -41240 0 0 {name=p103595 lab=_49724_/C }
C {devices/lab_pin.sym} 104680 -41200 0 0 {name=p103596 lab=_52942_/D }
C {devices/lab_pin.sym} 104800 -41260 0 1 {name=p103597 lab=_49728_/X }
C {sky130_stdcells/and4_4.sym} 104740 -41260 0 0 {name=X_49728_ }
C {devices/lab_pin.sym} 104650 -41110 0 0 {name=p103598 lab=_80746_/CLK }
C {devices/lab_pin.sym} 104650 -41090 0 0 {name=p103599 lab=_80872_/Q }
C {devices/lab_pin.sym} 104830 -41110 0 1 {name=p103600 lab=_80840_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -41100 0 0 {name=X_80840_ }
C {devices/lab_pin.sym} 104660 -40990 0 0 {name=p103601 lab=_68559_/X }
C {devices/lab_pin.sym} 104660 -40950 0 0 {name=p103602 lab=_68561_/X }
C {devices/lab_pin.sym} 104660 -40910 0 0 {name=p103603 lab=_68327_/X }
C {devices/lab_pin.sym} 104820 -40950 0 1 {name=p103604 lab=_68562_/Y }
C {sky130_stdcells/a21oi_4.sym} 104740 -40950 0 0 {name=X_68562_ }
C {devices/lab_pin.sym} 104700 -40810 0 0 {name=p103605 lab=_65969_/A }
C {devices/lab_pin.sym} 104780 -40810 0 1 {name=p103606 lab=_65855_/A }
C {sky130_stdcells/buf_2.sym} 104740 -40810 0 0 {name=X_65774_ }
C {devices/lab_pin.sym} 104700 -40690 0 0 {name=p103607 lab=_64328_/A }
C {devices/lab_pin.sym} 104780 -40690 0 1 {name=p103608 lab=_63516_/A }
C {sky130_stdcells/buf_2.sym} 104740 -40690 0 0 {name=X_62986_ }
C {devices/lab_pin.sym} 104680 -40580 0 0 {name=p103609 lab=_67513_/A }
C {devices/lab_pin.sym} 104680 -40540 0 0 {name=p103610 lab=_87212_/Q }
C {devices/lab_pin.sym} 104800 -40560 0 1 {name=p103611 lab=_67513_/X }
C {sky130_stdcells/and2_4.sym} 104740 -40560 0 0 {name=X_67513_ }
C {devices/lab_pin.sym} 104700 -40430 0 0 {name=p103612 lab=_64725_/A }
C {devices/lab_pin.sym} 104780 -40430 0 1 {name=p103613 lab=_64883_/A }
C {sky130_stdcells/buf_2.sym} 104740 -40430 0 0 {name=X_64725_ }
C {devices/lab_pin.sym} 104660 -40330 0 0 {name=p103614 lab=_49655_/Y }
C {devices/lab_pin.sym} 104660 -40290 0 0 {name=p103615 lab=_49650_/X }
C {devices/lab_pin.sym} 104660 -40250 0 0 {name=p103616 lab=_49658_/X }
C {devices/lab_pin.sym} 104820 -40290 0 1 {name=p103617 lab=_86347_/D }
C {sky130_stdcells/a21oi_4.sym} 104740 -40290 0 0 {name=X_49659_ }
C {devices/lab_pin.sym} 104700 -40150 0 0 {name=p103618 lab=_59823_/X }
C {devices/lab_pin.sym} 104780 -40150 0 1 {name=p103619 lab=_61937_/X }
C {sky130_stdcells/buf_2.sym} 104740 -40150 0 0 {name=X_61937_ }
C {devices/lab_pin.sym} 104650 -40030 0 0 {name=p103620 lab=_80818_/CLK }
C {devices/lab_pin.sym} 104650 -40010 0 0 {name=p103621 lab=_75888_/Y }
C {devices/lab_pin.sym} 104830 -40030 0 1 {name=p103622 lab=_80771_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -40020 0 0 {name=X_80771_ }
C {devices/lab_pin.sym} 104700 -39890 0 0 {name=p103623 lab=_68384_/A }
C {devices/lab_pin.sym} 104780 -39890 0 1 {name=p103624 lab=_68493_/X }
C {sky130_stdcells/buf_2.sym} 104740 -39890 0 0 {name=X_68493_ }
C {devices/lab_pin.sym} 104700 -39770 0 0 {name=p103625 lab=clkbuf_9_281_0_CLK/A }
C {devices/lab_pin.sym} 104780 -39770 0 1 {name=p103626 lab=clkbuf_9_280_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 104740 -39770 0 0 {name=Xclkbuf_9_280_0_CLK }
C {devices/lab_pin.sym} 104700 -39650 0 0 {name=p103627 lab=clkbuf_7_39_0_CLK/A }
C {devices/lab_pin.sym} 104780 -39650 0 1 {name=p103628 lab=clkbuf_8_79_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 104740 -39650 0 0 {name=Xclkbuf_7_39_0_CLK }
C {devices/lab_pin.sym} 104650 -39530 0 0 {name=p103629 lab=_82491_/CLK }
C {devices/lab_pin.sym} 104650 -39510 0 0 {name=p103630 lab=_82510_/D }
C {devices/lab_pin.sym} 104830 -39530 0 1 {name=p103631 lab=_82510_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -39520 0 0 {name=X_82510_ }
C {devices/lab_pin.sym} 104680 -39400 0 0 {name=p103632 lab=_67517_/A }
C {devices/lab_pin.sym} 104680 -39360 0 0 {name=p103633 lab=_67444_/B }
C {devices/lab_pin.sym} 104800 -39380 0 1 {name=p103634 lab=_67444_/X }
C {sky130_stdcells/and2_4.sym} 104740 -39380 0 0 {name=X_67444_ }
C {devices/lab_pin.sym} 104660 -39270 0 0 {name=p103635 lab=_52668_/Y }
C {devices/lab_pin.sym} 104660 -39230 0 0 {name=p103636 lab=_52647_/X }
C {devices/lab_pin.sym} 104660 -39190 0 0 {name=p103637 lab=_52669_/X }
C {devices/lab_pin.sym} 104820 -39230 0 1 {name=p103638 lab=_85776_/D }
C {sky130_stdcells/a21oi_4.sym} 104740 -39230 0 0 {name=X_52670_ }
C {devices/lab_pin.sym} 104700 -39090 0 0 {name=p103639 lab=_64656_/A }
C {devices/lab_pin.sym} 104780 -39090 0 1 {name=p103640 lab=_64809_/A }
C {sky130_stdcells/buf_2.sym} 104740 -39090 0 0 {name=X_64656_ }
C {devices/lab_pin.sym} 104700 -38970 0 0 {name=p103641 lab=clkbuf_7_89_0_CLK/X }
C {devices/lab_pin.sym} 104780 -38970 0 1 {name=p103642 lab=clkbuf_8_179_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 104740 -38970 0 0 {name=Xclkbuf_8_179_0_CLK }
C {devices/lab_pin.sym} 104650 -38850 0 0 {name=p103643 lab=_83491_/CLK }
C {devices/lab_pin.sym} 104650 -38830 0 0 {name=p103644 lab=_71461_/X }
C {devices/lab_pin.sym} 104830 -38850 0 1 {name=p103645 lab=_83490_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -38840 0 0 {name=X_83490_ }
C {devices/lab_pin.sym} 104700 -38710 0 0 {name=p103646 lab=_61787_/X }
C {devices/lab_pin.sym} 104780 -38710 0 1 {name=p103647 lab=_61915_/D }
C {sky130_stdcells/buf_2.sym} 104740 -38710 0 0 {name=X_61868_ }
C {devices/lab_pin.sym} 104700 -38590 0 0 {name=p103648 lab=clkbuf_9_87_0_CLK/X }
C {devices/lab_pin.sym} 104780 -38590 0 1 {name=p103649 lab=_83914_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 104740 -38590 0 0 {name=Xclkbuf_10_174_0_CLK }
C {devices/lab_pin.sym} 104700 -38470 0 0 {name=p103650 lab=_51621_/A }
C {devices/lab_pin.sym} 104780 -38470 0 1 {name=p103651 lab=_51621_/X }
C {sky130_stdcells/buf_2.sym} 104740 -38470 0 0 {name=X_51621_ }
C {devices/lab_pin.sym} 104680 -38380 0 0 {name=p103652 lab=_63655_/A }
C {devices/lab_pin.sym} 104680 -38340 0 0 {name=p103653 lab=_58487_/A }
C {devices/lab_pin.sym} 104680 -38300 0 0 {name=p103654 lab=_63581_/X }
C {devices/lab_pin.sym} 104680 -38260 0 0 {name=p103655 lab=_63595_/D }
C {devices/lab_pin.sym} 104800 -38320 0 1 {name=p103656 lab=_63607_/X }
C {sky130_stdcells/and4_4.sym} 104740 -38320 0 0 {name=X_63607_ }
C {devices/lab_pin.sym} 104650 -38170 0 0 {name=p103657 lab=_82820_/CLK }
C {devices/lab_pin.sym} 104650 -38150 0 0 {name=p103658 lab=_79133_/X }
C {devices/lab_pin.sym} 104830 -38170 0 1 {name=p103659 lab=_82409_/D }
C {sky130_stdcells/dfxtp_4.sym} 104740 -38160 0 0 {name=X_82441_ }
C {devices/lab_pin.sym} 104680 -38050 0 0 {name=p103660 lab=_59532_/A }
C {devices/lab_pin.sym} 104680 -38010 0 0 {name=p103661 lab=_60630_/C }
C {devices/lab_pin.sym} 104680 -37970 0 0 {name=p103662 lab=_60630_/A }
C {devices/lab_pin.sym} 104800 -38010 0 1 {name=p103663 lab=_61277_/B }
C {sky130_stdcells/nand3_4.sym} 104740 -38010 0 0 {name=X_60819_ }
C {devices/lab_pin.sym} 104660 -37890 0 0 {name=p103664 lab=_67372_/X }
C {devices/lab_pin.sym} 104660 -37850 0 0 {name=p103665 lab=_67374_/X }
C {devices/lab_pin.sym} 104660 -37810 0 0 {name=p103666 lab=_67255_/X }
C {devices/lab_pin.sym} 104820 -37850 0 1 {name=p103667 lab=_67375_/Y }
C {sky130_stdcells/a21oi_4.sym} 104740 -37850 0 0 {name=X_67375_ }
C {devices/lab_pin.sym} 104680 -37720 0 0 {name=p103668 lab=_64676_/A }
C {devices/lab_pin.sym} 104680 -37680 0 0 {name=p103669 lab=_85857_/Q }
C {devices/lab_pin.sym} 104800 -37700 0 1 {name=p103670 lab=_64587_/X }
C {sky130_stdcells/and2_4.sym} 104740 -37700 0 0 {name=X_64587_ }
C {devices/lab_pin.sym} 104680 -37600 0 0 {name=p103671 lab=_61863_/A }
C {devices/lab_pin.sym} 104680 -37560 0 0 {name=p103672 lab=_61794_/Y }
C {devices/lab_pin.sym} 104680 -37520 0 0 {name=p103673 lab=_61795_/Y }
C {devices/lab_pin.sym} 104680 -37480 0 0 {name=p103674 lab=_61798_/Y }
C {devices/lab_pin.sym} 104800 -37540 0 1 {name=p103675 lab=_61799_/Y }
C {sky130_stdcells/nand4_4.sym} 104740 -37540 0 0 {name=X_61799_ }
C {devices/lab_pin.sym} 104680 -37400 0 0 {name=p103676 lab=_69958_/A }
C {devices/lab_pin.sym} 104680 -37360 0 0 {name=p103677 lab=_69114_/B }
C {devices/lab_pin.sym} 104800 -37380 0 1 {name=p103678 lab=_69114_/Y }
C {sky130_stdcells/nor2_4.sym} 104740 -37380 0 0 {name=X_69114_ }
C {devices/lab_pin.sym} 104660 -37270 0 0 {name=p103679 lab=_54337_/Y }
C {devices/lab_pin.sym} 104660 -37230 0 0 {name=p103680 lab=_54338_/X }
C {devices/lab_pin.sym} 104660 -37190 0 0 {name=p103681 lab=_54339_/X }
C {devices/lab_pin.sym} 104820 -37230 0 1 {name=p103682 lab=_85460_/D }
C {sky130_stdcells/a21oi_4.sym} 104740 -37230 0 0 {name=X_54340_ }
C {devices/lab_pin.sym} 104680 -37100 0 0 {name=p103683 lab=_66326_/A }
C {devices/lab_pin.sym} 104680 -37060 0 0 {name=p103684 lab=_66326_/B }
C {devices/lab_pin.sym} 104800 -37080 0 1 {name=p103685 lab=_66326_/X }
C {sky130_stdcells/and2_4.sym} 104740 -37080 0 0 {name=X_66326_ }
C {devices/lab_pin.sym} 104650 -36950 0 0 {name=p103686 lab=_83016_/CLK }
C {devices/lab_pin.sym} 104650 -36930 0 0 {name=p103687 lab=_56532_/Y }
C {devices/lab_pin.sym} 104830 -36950 0 1 {name=p103688 lab=_85160_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -36940 0 0 {name=X_85160_ }
C {devices/lab_pin.sym} 104700 -36810 0 0 {name=p103689 lab=_51552_/A }
C {devices/lab_pin.sym} 104780 -36810 0 1 {name=p103690 lab=_51553_/C }
C {sky130_stdcells/buf_2.sym} 104740 -36810 0 0 {name=X_51552_ }
C {devices/lab_pin.sym} 104660 -36720 0 0 {name=p103691 lab=_61499_/B }
C {devices/lab_pin.sym} 104660 -36680 0 0 {name=p103692 lab=_63487_/X }
C {devices/lab_pin.sym} 104660 -36640 0 0 {name=p103693 lab=_63535_/X }
C {devices/lab_pin.sym} 104660 -36600 0 0 {name=p103694 lab=_63537_/X }
C {devices/lab_pin.sym} 104820 -36660 0 1 {name=p103695 lab=_63538_/X }
C {sky130_stdcells/a211o_4.sym} 104740 -36660 0 0 {name=X_63538_ }
C {devices/lab_pin.sym} 104650 -36510 0 0 {name=p103696 lab=_84951_/CLK }
C {devices/lab_pin.sym} 104650 -36490 0 0 {name=p103697 lab=_82180_/Q }
C {devices/lab_pin.sym} 104830 -36510 0 1 {name=p103698 lab=_82372_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -36500 0 0 {name=X_82372_ }
C {devices/lab_pin.sym} 104700 -36370 0 0 {name=p103699 lab=clkbuf_9_295_0_CLK/A }
C {devices/lab_pin.sym} 104780 -36370 0 1 {name=p103700 lab=clkbuf_9_295_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 104740 -36370 0 0 {name=Xclkbuf_9_295_0_CLK }
C {devices/lab_pin.sym} 104700 -36250 0 0 {name=p103701 lab=clkbuf_7_51_0_CLK/X }
C {devices/lab_pin.sym} 104780 -36250 0 1 {name=p103702 lab=clkbuf_8_102_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 104740 -36250 0 0 {name=Xclkbuf_8_102_0_CLK }
C {devices/lab_pin.sym} 104650 -36130 0 0 {name=p103703 lab=_84111_/CLK }
C {devices/lab_pin.sym} 104650 -36110 0 0 {name=p103704 lab=_66502_/X }
C {devices/lab_pin.sym} 104830 -36130 0 1 {name=p103705 lab=_84111_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -36120 0 0 {name=X_84111_ }
C {devices/lab_pin.sym} 104680 -36000 0 0 {name=p103706 lab=_50556_/A }
C {devices/lab_pin.sym} 104680 -35960 0 0 {name=p103707 lab=_50503_/B }
C {devices/lab_pin.sym} 104800 -35980 0 1 {name=p103708 lab=_50503_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -35980 0 0 {name=X_50503_ }
C {devices/lab_pin.sym} 104650 -35850 0 0 {name=p103709 lab=_81344_/CLK }
C {devices/lab_pin.sym} 104650 -35830 0 0 {name=p103710 lab=_76287_/X }
C {devices/lab_pin.sym} 104830 -35850 0 1 {name=p103711 lab=_81699_/D }
C {sky130_stdcells/dfxtp_4.sym} 104740 -35840 0 0 {name=X_81323_ }
C {devices/lab_pin.sym} 104680 -35720 0 0 {name=p103712 lab=_68770_/X }
C {devices/lab_pin.sym} 104680 -35680 0 0 {name=p103713 lab=_69045_/B }
C {devices/lab_pin.sym} 104800 -35700 0 1 {name=p103714 lab=_69045_/X }
C {sky130_stdcells/and2_4.sym} 104740 -35700 0 0 {name=X_69045_ }
C {devices/lab_pin.sym} 104660 -35590 0 0 {name=p103715 lab=_54269_/Y }
C {devices/lab_pin.sym} 104660 -35550 0 0 {name=p103716 lab=_54051_/X }
C {devices/lab_pin.sym} 104660 -35510 0 0 {name=p103717 lab=_54270_/X }
C {devices/lab_pin.sym} 104820 -35550 0 1 {name=p103718 lab=_54271_/Y }
C {sky130_stdcells/a21oi_4.sym} 104740 -35550 0 0 {name=X_54271_ }
C {devices/lab_pin.sym} 104660 -35440 0 0 {name=p103719 lab=_66225_/X }
C {devices/lab_pin.sym} 104660 -35400 0 0 {name=p103720 lab=_84969_/Q }
C {devices/lab_pin.sym} 104660 -35360 0 0 {name=p103721 lab=_66186_/X }
C {devices/lab_pin.sym} 104660 -35320 0 0 {name=p103722 lab=_66256_/X }
C {devices/lab_pin.sym} 104820 -35380 0 1 {name=p103723 lab=_66257_/X }
C {sky130_stdcells/a211o_4.sym} 104740 -35380 0 0 {name=X_66257_ }
C {devices/lab_pin.sym} 104650 -35230 0 0 {name=p103724 lab=_85100_/CLK }
C {devices/lab_pin.sym} 104650 -35210 0 0 {name=p103725 lab=_85091_/D }
C {devices/lab_pin.sym} 104830 -35230 0 1 {name=p103726 lab=_85091_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -35220 0 0 {name=X_85091_ }
C {devices/lab_pin.sym} 104700 -35090 0 0 {name=p103727 lab=clkbuf_9_94_0_CLK/X }
C {devices/lab_pin.sym} 104780 -35090 0 1 {name=p103728 lab=_81074_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 104740 -35090 0 0 {name=Xclkbuf_10_189_0_CLK }
C {devices/lab_pin.sym} 104680 -35000 0 0 {name=p103729 lab=_51473_/A }
C {devices/lab_pin.sym} 104680 -34960 0 0 {name=p103730 lab=_51494_/B }
C {devices/lab_pin.sym} 104680 -34920 0 0 {name=p103731 lab=_51494_/C }
C {devices/lab_pin.sym} 104680 -34880 0 0 {name=p103732 lab=_53008_/D }
C {devices/lab_pin.sym} 104800 -34940 0 1 {name=p103733 lab=_51483_/X }
C {sky130_stdcells/and4_4.sym} 104740 -34940 0 0 {name=X_51483_ }
C {devices/lab_pin.sym} 104680 -34810 0 0 {name=p103734 lab=_63517_/A }
C {devices/lab_pin.sym} 104680 -34770 0 0 {name=p103735 lab=_63517_/B }
C {devices/lab_pin.sym} 104680 -34730 0 0 {name=p103736 lab=_84321_/Q }
C {devices/lab_pin.sym} 104800 -34770 0 1 {name=p103737 lab=_63469_/Y }
C {sky130_stdcells/nor3_4.sym} 104740 -34770 0 0 {name=X_63469_ }
C {devices/lab_pin.sym} 104680 -34650 0 0 {name=p103738 lab=_55997_/X }
C {devices/lab_pin.sym} 104680 -34610 0 0 {name=p103739 lab=_74312_/C }
C {devices/lab_pin.sym} 104680 -34570 0 0 {name=p103740 lab=_74310_/C }
C {devices/lab_pin.sym} 104800 -34610 0 1 {name=p103741 lab=_56010_/X }
C {sky130_stdcells/and3_4.sym} 104740 -34610 0 0 {name=X_56010_ }
C {devices/lab_pin.sym} 104700 -34470 0 0 {name=p103742 lab=_53302_/A }
C {devices/lab_pin.sym} 104780 -34470 0 1 {name=p103743 lab=_53222_/X }
C {sky130_stdcells/buf_2.sym} 104740 -34470 0 0 {name=X_53222_ }
C {devices/lab_pin.sym} 104680 -34360 0 0 {name=p103744 lab=_65208_/A }
C {devices/lab_pin.sym} 104680 -34320 0 0 {name=p103745 lab=_65207_/X }
C {devices/lab_pin.sym} 104800 -34340 0 1 {name=p103746 lab=_65208_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -34340 0 0 {name=X_65208_ }
C {devices/lab_pin.sym} 104650 -34210 0 0 {name=p103747 lab=_81475_/CLK }
C {devices/lab_pin.sym} 104650 -34190 0 0 {name=p103748 lab=_84042_/D }
C {devices/lab_pin.sym} 104830 -34210 0 1 {name=p103749 lab=_81474_/D }
C {sky130_stdcells/dfxtp_4.sym} 104740 -34200 0 0 {name=X_84042_ }
C {devices/lab_pin.sym} 104700 -34070 0 0 {name=p103750 lab=_53511_/A }
C {devices/lab_pin.sym} 104780 -34070 0 1 {name=p103751 lab=_50456_/B }
C {sky130_stdcells/buf_2.sym} 104740 -34070 0 0 {name=X_50434_ }
C {devices/lab_pin.sym} 104650 -33950 0 0 {name=p103752 lab=_81671_/CLK }
C {devices/lab_pin.sym} 104650 -33930 0 0 {name=p103753 lab=_81286_/Q }
C {devices/lab_pin.sym} 104830 -33950 0 1 {name=p103754 lab=_76200_/A }
C {sky130_stdcells/dfxtp_4.sym} 104740 -33940 0 0 {name=X_81254_ }
C {devices/lab_pin.sym} 104660 -33840 0 0 {name=p103755 lab=_66040_/X }
C {devices/lab_pin.sym} 104660 -33800 0 0 {name=p103756 lab=_84974_/Q }
C {devices/lab_pin.sym} 104660 -33760 0 0 {name=p103757 lab=_66186_/X }
C {devices/lab_pin.sym} 104660 -33720 0 0 {name=p103758 lab=_66187_/X }
C {devices/lab_pin.sym} 104820 -33780 0 1 {name=p103759 lab=_66188_/X }
C {sky130_stdcells/a211o_4.sym} 104740 -33780 0 0 {name=X_66188_ }
C {devices/lab_pin.sym} 104680 -33640 0 0 {name=p103760 lab=_84949_/Q }
C {devices/lab_pin.sym} 104680 -33600 0 0 {name=p103761 lab=_84197_/Q }
C {devices/lab_pin.sym} 104800 -33620 0 1 {name=p103762 lab=_80205_/X }
C {sky130_stdcells/xor2_4.sym} 104740 -33620 0 0 {name=X_80205_ }
C {devices/lab_pin.sym} 104680 -33500 0 0 {name=p103763 lab=_53147_/X }
C {devices/lab_pin.sym} 104680 -33460 0 0 {name=p103764 lab=_53153_/B }
C {devices/lab_pin.sym} 104800 -33480 0 1 {name=p103765 lab=_53153_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -33480 0 0 {name=X_53153_ }
C {devices/lab_pin.sym} 104680 -33370 0 0 {name=p103766 lab=_65134_/X }
C {devices/lab_pin.sym} 104680 -33330 0 0 {name=p103767 lab=_64937_/B }
C {devices/lab_pin.sym} 104680 -33290 0 0 {name=p103768 lab=_65138_/X }
C {devices/lab_pin.sym} 104800 -33330 0 1 {name=p103769 lab=_65139_/Y }
C {sky130_stdcells/nand3_4.sym} 104740 -33330 0 0 {name=X_65139_ }
C {devices/lab_pin.sym} 104680 -33200 0 0 {name=p103770 lab=_50383_/A }
C {devices/lab_pin.sym} 104680 -33160 0 0 {name=p103771 lab=_50365_/B }
C {devices/lab_pin.sym} 104800 -33180 0 1 {name=p103772 lab=_50365_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -33180 0 0 {name=X_50365_ }
C {devices/lab_pin.sym} 104700 -33050 0 0 {name=p103773 lab=clkbuf_7_58_0_CLK/X }
C {devices/lab_pin.sym} 104780 -33050 0 1 {name=p103774 lab=clkbuf_9_235_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 104740 -33050 0 0 {name=Xclkbuf_8_117_0_CLK }
C {devices/lab_pin.sym} 104650 -32930 0 0 {name=p103775 lab=_86758_/CLK }
C {devices/lab_pin.sym} 104650 -32910 0 0 {name=p103776 lab=_75074_/X }
C {devices/lab_pin.sym} 104830 -32930 0 1 {name=p103777 lab=_81185_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -32920 0 0 {name=X_81185_ }
C {devices/lab_pin.sym} 104700 -32790 0 0 {name=p103778 lab=clkbuf_9_56_0_CLK/X }
C {devices/lab_pin.sym} 104780 -32790 0 1 {name=p103779 lab=_84400_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 104740 -32790 0 0 {name=Xclkbuf_10_112_0_CLK }
C {devices/lab_pin.sym} 104660 -32690 0 0 {name=p103780 lab=_52101_/Y }
C {devices/lab_pin.sym} 104660 -32650 0 0 {name=p103781 lab=_52049_/X }
C {devices/lab_pin.sym} 104660 -32610 0 0 {name=p103782 lab=_52103_/X }
C {devices/lab_pin.sym} 104820 -32650 0 1 {name=p103783 lab=_52104_/Y }
C {sky130_stdcells/a21oi_4.sym} 104740 -32650 0 0 {name=X_52104_ }
C {devices/lab_pin.sym} 104650 -32510 0 0 {name=p103784 lab=_87285_/CLK }
C {devices/lab_pin.sym} 104650 -32490 0 0 {name=p103785 lab=_42613_/Y }
C {devices/lab_pin.sym} 104830 -32510 0 1 {name=p103786 lab=_73415_/A }
C {sky130_stdcells/dfxtp_4.sym} 104740 -32500 0 0 {name=X_87801_ }
C {devices/lab_pin.sym} 104680 -32380 0 0 {name=p103787 lab=_80114_/A }
C {devices/lab_pin.sym} 104680 -32340 0 0 {name=p103788 lab=_80126_/X }
C {devices/lab_pin.sym} 104800 -32360 0 1 {name=p103789 lab=_80136_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -32360 0 0 {name=X_80136_ }
C {devices/lab_pin.sym} 104660 -32270 0 0 {name=p103790 lab=_57868_/X }
C {devices/lab_pin.sym} 104660 -32230 0 0 {name=p103791 lab=_57958_/Y }
C {devices/lab_pin.sym} 104660 -32190 0 0 {name=p103792 lab=_57960_/Y }
C {devices/lab_pin.sym} 104660 -32150 0 0 {name=p103793 lab=_57899_/X }
C {devices/lab_pin.sym} 104660 -32110 0 0 {name=p103794 lab=_57872_/X }
C {devices/lab_pin.sym} 104820 -32190 0 1 {name=p103795 lab=_57961_/X }
C {sky130_stdcells/o32a_4.sym} 104740 -32190 0 0 {name=X_57961_ }
C {devices/lab_pin.sym} 104680 -32060 0 0 {name=p103796 lab=_53107_/A }
C {devices/lab_pin.sym} 104680 -32020 0 0 {name=p103797 lab=_53069_/X }
C {devices/lab_pin.sym} 104680 -31980 0 0 {name=p103798 lab=_53074_/C }
C {devices/lab_pin.sym} 104680 -31940 0 0 {name=p103799 lab=_53084_/D }
C {devices/lab_pin.sym} 104800 -32000 0 1 {name=p103800 lab=_53084_/X }
C {sky130_stdcells/and4_4.sym} 104740 -32000 0 0 {name=X_53084_ }
C {devices/lab_pin.sym} 104700 -31850 0 0 {name=p103801 lab=clkbuf_9_371_0_CLK/X }
C {devices/lab_pin.sym} 104780 -31850 0 1 {name=p103802 lab=_88002_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 104740 -31850 0 0 {name=Xclkbuf_10_742_0_CLK }
C {devices/lab_pin.sym} 104660 -31760 0 0 {name=p103803 lab=_42057_/A }
C {devices/lab_pin.sym} 104660 -31720 0 0 {name=p103804 lab=_69837_/X }
C {devices/lab_pin.sym} 104660 -31680 0 0 {name=p103805 lab=_69088_/X }
C {devices/lab_pin.sym} 104660 -31640 0 0 {name=p103806 lab=_69946_/Y }
C {devices/lab_pin.sym} 104820 -31700 0 1 {name=p103807 lab=_69947_/X }
C {sky130_stdcells/a211o_4.sym} 104740 -31700 0 0 {name=X_69947_ }
C {devices/lab_pin.sym} 104660 -31570 0 0 {name=p103808 lab=_50294_/Y }
C {devices/lab_pin.sym} 104660 -31530 0 0 {name=p103809 lab=_50274_/X }
C {devices/lab_pin.sym} 104660 -31490 0 0 {name=p103810 lab=_50295_/Y }
C {devices/lab_pin.sym} 104820 -31530 0 1 {name=p103811 lab=_86229_/D }
C {sky130_stdcells/a21boi_4.sym} 104740 -31530 0 0 {name=X_50296_ }
C {devices/lab_pin.sym} 104650 -31390 0 0 {name=p103812 lab=_85993_/CLK }
C {devices/lab_pin.sym} 104650 -31370 0 0 {name=p103813 lab=_85993_/D }
C {devices/lab_pin.sym} 104830 -31390 0 1 {name=p103814 lab=_85993_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -31380 0 0 {name=X_85993_ }
C {devices/lab_pin.sym} 104700 -31250 0 0 {name=p103815 lab=_59797_/A }
C {devices/lab_pin.sym} 104780 -31250 0 1 {name=p103816 lab=_59700_/Y }
C {sky130_stdcells/inv_2.sym} 104740 -31250 0 0 {name=X_59700_ }
C {devices/lab_pin.sym} 104660 -31150 0 0 {name=p103817 lab=_52032_/Y }
C {devices/lab_pin.sym} 104660 -31110 0 0 {name=p103818 lab=_51987_/X }
C {devices/lab_pin.sym} 104660 -31070 0 0 {name=p103819 lab=_52034_/X }
C {devices/lab_pin.sym} 104820 -31110 0 1 {name=p103820 lab=_85902_/D }
C {sky130_stdcells/a21oi_4.sym} 104740 -31110 0 0 {name=X_52035_ }
C {devices/lab_pin.sym} 104700 -30970 0 0 {name=p103821 lab=_56912_/A }
C {devices/lab_pin.sym} 104780 -30970 0 1 {name=p103822 lab=_57272_/D }
C {sky130_stdcells/inv_2.sym} 104740 -30970 0 0 {name=X_56912_ }
C {devices/lab_pin.sym} 104650 -30850 0 0 {name=p103823 lab=_87990_/CLK }
C {devices/lab_pin.sym} 104650 -30830 0 0 {name=p103824 lab=_87732_/D }
C {devices/lab_pin.sym} 104830 -30850 0 1 {name=p103825 lab=_69122_/B }
C {sky130_stdcells/dfxtp_4.sym} 104740 -30840 0 0 {name=X_87732_ }
C {devices/lab_pin.sym} 104650 -30710 0 0 {name=p103826 lab=_85492_/CLK }
C {devices/lab_pin.sym} 104650 -30690 0 0 {name=p103827 lab=_57865_/Y }
C {devices/lab_pin.sym} 104830 -30710 0 1 {name=p103828 lab=_84944_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -30700 0 0 {name=X_84944_ }
C {devices/lab_pin.sym} 104660 -30590 0 0 {name=p103829 lab=_80059_/X }
C {devices/lab_pin.sym} 104660 -30550 0 0 {name=p103830 lab=_80060_/X }
C {devices/lab_pin.sym} 104660 -30510 0 0 {name=p103831 lab=_80066_/Y }
C {devices/lab_pin.sym} 104820 -30550 0 1 {name=p103832 lab=_80071_/A }
C {sky130_stdcells/a21boi_4.sym} 104740 -30550 0 0 {name=X_80067_ }
C {devices/lab_pin.sym} 104680 -30420 0 0 {name=p103833 lab=_86646_/Q }
C {devices/lab_pin.sym} 104680 -30380 0 0 {name=p103834 lab=_57791_/X }
C {devices/lab_pin.sym} 104800 -30400 0 1 {name=p103835 lab=_57892_/Y }
C {sky130_stdcells/nor2_4.sym} 104740 -30400 0 0 {name=X_57892_ }
C {devices/lab_pin.sym} 104700 -30270 0 0 {name=p103836 lab=clkbuf_8_116_0_CLK/X }
C {devices/lab_pin.sym} 104780 -30270 0 1 {name=p103837 lab=clkbuf_9_233_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 104740 -30270 0 0 {name=Xclkbuf_9_233_0_CLK }
C {devices/lab_pin.sym} 104660 -30180 0 0 {name=p103838 lab=_87048_/Q }
C {devices/lab_pin.sym} 104660 -30140 0 0 {name=p103839 lab=_69690_/X }
C {devices/lab_pin.sym} 104660 -30100 0 0 {name=p103840 lab=_68473_/X }
C {devices/lab_pin.sym} 104660 -30060 0 0 {name=p103841 lab=_69877_/X }
C {devices/lab_pin.sym} 104820 -30120 0 1 {name=p103842 lab=_69878_/X }
C {sky130_stdcells/a211o_4.sym} 104740 -30120 0 0 {name=X_69878_ }
C {devices/lab_pin.sym} 104680 -29990 0 0 {name=p103843 lab=_59689_/B }
C {devices/lab_pin.sym} 104680 -29950 0 0 {name=p103844 lab=_59631_/B }
C {devices/lab_pin.sym} 104680 -29910 0 0 {name=p103845 lab=_65680_/A }
C {devices/lab_pin.sym} 104800 -29950 0 1 {name=p103846 lab=_59631_/Y }
C {sky130_stdcells/nand3_4.sym} 104740 -29950 0 0 {name=X_59631_ }
C {devices/lab_pin.sym} 104680 -29820 0 0 {name=p103847 lab=_56721_/D }
C {devices/lab_pin.sym} 104680 -29780 0 0 {name=p103848 lab=_56842_/X }
C {devices/lab_pin.sym} 104800 -29800 0 1 {name=p103849 lab=_56843_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -29800 0 0 {name=X_56843_ }
C {devices/lab_pin.sym} 104680 -29680 0 0 {name=p103850 lab=_69648_/A }
C {devices/lab_pin.sym} 104680 -29640 0 0 {name=p103851 lab=_43644_/Y }
C {devices/lab_pin.sym} 104800 -29660 0 1 {name=p103852 lab=_68829_/Y }
C {sky130_stdcells/nor2_4.sym} 104740 -29660 0 0 {name=X_68829_ }
C {devices/lab_pin.sym} 104650 -29530 0 0 {name=p103853 lab=_82896_/CLK }
C {devices/lab_pin.sym} 104650 -29510 0 0 {name=p103854 lab=_87663_/D }
C {devices/lab_pin.sym} 104830 -29530 0 1 {name=p103855 lab=_87663_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -29520 0 0 {name=X_87663_ }
C {devices/lab_pin.sym} 104700 -29390 0 0 {name=p103856 lab=clkbuf_9_63_0_CLK/X }
C {devices/lab_pin.sym} 104780 -29390 0 1 {name=p103857 lab=_84518_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 104740 -29390 0 0 {name=Xclkbuf_10_127_0_CLK }
C {devices/lab_pin.sym} 104650 -29270 0 0 {name=p103858 lab=_84877_/CLK }
C {devices/lab_pin.sym} 104650 -29250 0 0 {name=p103859 lab=_84875_/D }
C {devices/lab_pin.sym} 104830 -29270 0 1 {name=p103860 lab=_58335_/A }
C {sky130_stdcells/dfxtp_4.sym} 104740 -29260 0 0 {name=X_84875_ }
C {devices/lab_pin.sym} 104650 -29130 0 0 {name=p103861 lab=_85969_/CLK }
C {devices/lab_pin.sym} 104650 -29110 0 0 {name=p103862 lab=_86614_/D }
C {devices/lab_pin.sym} 104830 -29130 0 1 {name=p103863 lab=_86614_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -29120 0 0 {name=X_86614_ }
C {devices/lab_pin.sym} 104700 -28990 0 0 {name=p103864 lab=clkbuf_9_378_0_CLK/X }
C {devices/lab_pin.sym} 104780 -28990 0 1 {name=p103865 lab=_88084_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 104740 -28990 0 0 {name=Xclkbuf_10_757_0_CLK }
C {devices/lab_pin.sym} 104660 -28890 0 0 {name=p103866 lab=_71824_/Y }
C {devices/lab_pin.sym} 104660 -28850 0 0 {name=p103867 lab=_83356_/Q }
C {devices/lab_pin.sym} 104660 -28810 0 0 {name=p103868 lab=_71839_/X }
C {devices/lab_pin.sym} 104820 -28850 0 1 {name=p103869 lab=_83356_/D }
C {sky130_stdcells/a21o_4.sym} 104740 -28850 0 0 {name=X_71840_ }
C {devices/lab_pin.sym} 104680 -28730 0 0 {name=p103870 lab=_59557_/X }
C {devices/lab_pin.sym} 104680 -28690 0 0 {name=p103871 lab=_59562_/B }
C {devices/lab_pin.sym} 104680 -28650 0 0 {name=p103872 lab=_59544_/D }
C {devices/lab_pin.sym} 104800 -28690 0 1 {name=p103873 lab=_60122_/A }
C {sky130_stdcells/nand3_4.sym} 104740 -28690 0 0 {name=X_59562_ }
C {devices/lab_pin.sym} 104650 -28550 0 0 {name=p103874 lab=_83187_/CLK }
C {devices/lab_pin.sym} 104650 -28530 0 0 {name=p103875 lab=_83826_/D }
C {devices/lab_pin.sym} 104830 -28550 0 1 {name=p103876 lab=_83826_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -28540 0 0 {name=X_83826_ }
C {devices/lab_pin.sym} 104680 -28430 0 0 {name=p103877 lab=_56774_/A }
C {devices/lab_pin.sym} 104680 -28390 0 0 {name=p103878 lab=_85133_/Q }
C {devices/lab_pin.sym} 104680 -28350 0 0 {name=p103879 lab=_56774_/C }
C {devices/lab_pin.sym} 104800 -28390 0 1 {name=p103880 lab=_56774_/Y }
C {sky130_stdcells/nor3_4.sym} 104740 -28390 0 0 {name=X_56774_ }
C {devices/lab_pin.sym} 104650 -28250 0 0 {name=p103881 lab=_88111_/CLK }
C {devices/lab_pin.sym} 104650 -28230 0 0 {name=p103882 lab=_87594_/D }
C {devices/lab_pin.sym} 104830 -28250 0 1 {name=p103883 lab=_73773_/A }
C {sky130_stdcells/dfxtp_4.sym} 104740 -28240 0 0 {name=X_87594_ }
C {devices/lab_pin.sym} 104660 -28130 0 0 {name=p103884 lab=_85528_/Q }
C {devices/lab_pin.sym} 104660 -28090 0 0 {name=p103885 lab=_53955_/X }
C {devices/lab_pin.sym} 104660 -28050 0 0 {name=p103886 lab=_53985_/Y }
C {devices/lab_pin.sym} 104820 -28090 0 1 {name=p103887 lab=_53986_/Y }
C {sky130_stdcells/o21ai_4.sym} 104740 -28090 0 0 {name=X_53986_ }
C {devices/lab_pin.sym} 104700 -27950 0 0 {name=p103888 lab=_58513_/A }
C {devices/lab_pin.sym} 104780 -27950 0 1 {name=p103889 lab=_58513_/Y }
C {sky130_stdcells/inv_2.sym} 104740 -27950 0 0 {name=X_58513_ }
C {devices/lab_pin.sym} 104660 -27860 0 0 {name=p103890 lab=_56452_/C }
C {devices/lab_pin.sym} 104660 -27820 0 0 {name=p103891 lab=_55126_/A }
C {devices/lab_pin.sym} 104660 -27780 0 0 {name=p103892 lab=_55128_/A }
C {devices/lab_pin.sym} 104660 -27740 0 0 {name=p103893 lab=_55724_/X }
C {devices/lab_pin.sym} 104820 -27800 0 1 {name=p103894 lab=_55725_/X }
C {sky130_stdcells/a211o_4.sym} 104740 -27800 0 0 {name=X_55725_ }
C {devices/lab_pin.sym} 104650 -27650 0 0 {name=p103895 lab=_86222_/CLK }
C {devices/lab_pin.sym} 104650 -27630 0 0 {name=p103896 lab=_86545_/D }
C {devices/lab_pin.sym} 104830 -27650 0 1 {name=p103897 lab=_86545_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -27640 0 0 {name=X_86545_ }
C {devices/lab_pin.sym} 104700 -27510 0 0 {name=p103898 lab=clkbuf_8_124_0_CLK/X }
C {devices/lab_pin.sym} 104780 -27510 0 1 {name=p103899 lab=clkbuf_9_248_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 104740 -27510 0 0 {name=Xclkbuf_9_248_0_CLK }
C {devices/lab_pin.sym} 104660 -27430 0 0 {name=p103900 lab=_40944_/X }
C {devices/lab_pin.sym} 104660 -27390 0 0 {name=p103901 lab=_40946_/X }
C {devices/lab_pin.sym} 104660 -27350 0 0 {name=p103902 lab=_40950_/X }
C {devices/lab_pin.sym} 104660 -27310 0 0 {name=p103903 lab=_88305_/Q }
C {devices/lab_pin.sym} 104660 -27270 0 0 {name=p103904 lab=_40916_/X }
C {devices/lab_pin.sym} 104820 -27350 0 1 {name=p103905 lab=_40952_/A }
C {sky130_stdcells/o32ai_4.sym} 104740 -27350 0 0 {name=X_40951_ }
C {devices/lab_pin.sym} 104660 -27210 0 0 {name=p103906 lab=_85727_/Q }
C {devices/lab_pin.sym} 104660 -27170 0 0 {name=p103907 lab=_52929_/X }
C {devices/lab_pin.sym} 104660 -27130 0 0 {name=p103908 lab=_52936_/Y }
C {devices/lab_pin.sym} 104820 -27170 0 1 {name=p103909 lab=_52937_/Y }
C {sky130_stdcells/o21ai_4.sym} 104740 -27170 0 0 {name=X_52937_ }
C {devices/lab_pin.sym} 104700 -27030 0 0 {name=p103910 lab=_59493_/A }
C {devices/lab_pin.sym} 104780 -27030 0 1 {name=p103911 lab=_59493_/Y }
C {sky130_stdcells/inv_2.sym} 104740 -27030 0 0 {name=X_59493_ }
C {devices/lab_pin.sym} 104660 -26930 0 0 {name=p103912 lab=_71762_/X }
C {devices/lab_pin.sym} 104660 -26890 0 0 {name=p103913 lab=_83382_/Q }
C {devices/lab_pin.sym} 104660 -26850 0 0 {name=p103914 lab=_71770_/X }
C {devices/lab_pin.sym} 104820 -26890 0 1 {name=p103915 lab=_71771_/X }
C {sky130_stdcells/a21o_4.sym} 104740 -26890 0 0 {name=X_71771_ }
C {devices/lab_pin.sym} 104650 -26750 0 0 {name=p103916 lab=_83761_/CLK }
C {devices/lab_pin.sym} 104650 -26730 0 0 {name=p103917 lab=_70519_/Y }
C {devices/lab_pin.sym} 104830 -26750 0 1 {name=p103918 lab=_57668_/A }
C {sky130_stdcells/dfxtp_4.sym} 104740 -26740 0 0 {name=X_83757_ }
C {devices/lab_pin.sym} 104650 -26610 0 0 {name=p103919 lab=_80776_/CLK }
C {devices/lab_pin.sym} 104650 -26590 0 0 {name=p103920 lab=_75635_/X }
C {devices/lab_pin.sym} 104830 -26610 0 1 {name=p103921 lab=_75475_/B }
C {sky130_stdcells/dfxtp_4.sym} 104740 -26600 0 0 {name=X_80969_ }
C {devices/lab_pin.sym} 104660 -26500 0 0 {name=p103922 lab=_43201_/Y }
C {devices/lab_pin.sym} 104660 -26460 0 0 {name=p103923 lab=_73298_/X }
C {devices/lab_pin.sym} 104660 -26420 0 0 {name=p103924 lab=_73464_/X }
C {devices/lab_pin.sym} 104660 -26380 0 0 {name=p103925 lab=_73509_/Y }
C {devices/lab_pin.sym} 104820 -26440 0 1 {name=p103926 lab=_73510_/X }
C {sky130_stdcells/a211o_4.sym} 104740 -26440 0 0 {name=X_73510_ }
C {devices/lab_pin.sym} 104680 -26320 0 0 {name=p103927 lab=_70722_/A }
C {devices/lab_pin.sym} 104680 -26280 0 0 {name=p103928 lab=_70713_/X }
C {devices/lab_pin.sym} 104680 -26240 0 0 {name=p103929 lab=_70727_/C }
C {devices/lab_pin.sym} 104680 -26200 0 0 {name=p103930 lab=_70769_/D }
C {devices/lab_pin.sym} 104800 -26260 0 1 {name=p103931 lab=_70722_/Y }
C {sky130_stdcells/nand4_4.sym} 104740 -26260 0 0 {name=X_70722_ }
C {devices/lab_pin.sym} 104700 -26110 0 0 {name=p103932 lab=_84846_/Q }
C {devices/lab_pin.sym} 104780 -26110 0 1 {name=p103933 lab=_63230_/A }
C {sky130_stdcells/inv_2.sym} 104740 -26110 0 0 {name=X_58444_ }
C {devices/lab_pin.sym} 104650 -25990 0 0 {name=p103934 lab=_82803_/CLK }
C {devices/lab_pin.sym} 104650 -25970 0 0 {name=p103935 lab=_78975_/X }
C {devices/lab_pin.sym} 104830 -25990 0 1 {name=p103936 lab=_82664_/D }
C {sky130_stdcells/dfxtp_4.sym} 104740 -25980 0 0 {name=X_82708_ }
C {devices/lab_pin.sym} 104660 -25880 0 0 {name=p103937 lab=_40749_/X }
C {devices/lab_pin.sym} 104660 -25840 0 0 {name=p103938 lab=_43656_/X }
C {devices/lab_pin.sym} 104660 -25800 0 0 {name=p103939 lab=_74226_/A }
C {devices/lab_pin.sym} 104660 -25760 0 0 {name=p103940 lab=_43657_/X }
C {devices/lab_pin.sym} 104820 -25820 0 1 {name=p103941 lab=_87318_/D }
C {sky130_stdcells/a2bb2o_4.sym} 104740 -25820 0 0 {name=X_43670_ }
C {devices/lab_pin.sym} 104700 -25670 0 0 {name=p103942 lab=_55656_/A }
C {devices/lab_pin.sym} 104780 -25670 0 1 {name=p103943 lab=_55656_/X }
C {sky130_stdcells/buf_2.sym} 104740 -25670 0 0 {name=X_55656_ }
C {devices/lab_pin.sym} 104680 -25560 0 0 {name=p103944 lab=_74490_/A }
C {devices/lab_pin.sym} 104680 -25520 0 0 {name=p103945 lab=_48647_/Y }
C {devices/lab_pin.sym} 104800 -25540 0 1 {name=p103946 lab=_74490_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -25540 0 0 {name=X_74490_ }
C {devices/lab_pin.sym} 104650 -25410 0 0 {name=p103947 lab=_86505_/CLK }
C {devices/lab_pin.sym} 104650 -25390 0 0 {name=p103948 lab=_48824_/Y }
C {devices/lab_pin.sym} 104830 -25410 0 1 {name=p103949 lab=_86476_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -25400 0 0 {name=X_86476_ }
C {devices/lab_pin.sym} 104660 -25290 0 0 {name=p103950 lab=_52864_/Y }
C {devices/lab_pin.sym} 104660 -25250 0 0 {name=p103951 lab=_52865_/X }
C {devices/lab_pin.sym} 104660 -25210 0 0 {name=p103952 lab=_52867_/X }
C {devices/lab_pin.sym} 104820 -25250 0 1 {name=p103953 lab=_52868_/Y }
C {sky130_stdcells/a21oi_4.sym} 104740 -25250 0 0 {name=X_52868_ }
C {devices/lab_pin.sym} 104660 -25140 0 0 {name=p103954 lab=_40881_/X }
C {devices/lab_pin.sym} 104660 -25100 0 0 {name=p103955 lab=_40821_/X }
C {devices/lab_pin.sym} 104660 -25060 0 0 {name=p103956 lab=_88318_/Q }
C {devices/lab_pin.sym} 104660 -25020 0 0 {name=p103957 lab=_40822_/X }
C {devices/lab_pin.sym} 104820 -25080 0 1 {name=p103958 lab=_40882_/X }
C {sky130_stdcells/a2bb2o_4.sym} 104740 -25080 0 0 {name=X_40882_ }
C {devices/lab_pin.sym} 104650 -24930 0 0 {name=p103959 lab=_83685_/CLK }
C {devices/lab_pin.sym} 104650 -24910 0 0 {name=p103960 lab=_70837_/Y }
C {devices/lab_pin.sym} 104830 -24930 0 1 {name=p103961 lab=_46624_/A }
C {sky130_stdcells/dfxtp_4.sym} 104740 -24920 0 0 {name=X_83688_ }
C {devices/lab_pin.sym} 104650 -24790 0 0 {name=p103962 lab=_88215_/CLK }
C {devices/lab_pin.sym} 104650 -24770 0 0 {name=p103963 lab=_88215_/D }
C {devices/lab_pin.sym} 104830 -24790 0 1 {name=p103964 lab=_88215_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -24780 0 0 {name=X_88215_ }
C {devices/lab_pin.sym} 104680 -24680 0 0 {name=p103965 lab=_54589_/X }
C {devices/lab_pin.sym} 104680 -24640 0 0 {name=p103966 lab=_54607_/B }
C {devices/lab_pin.sym} 104680 -24600 0 0 {name=p103967 lab=_54591_/C }
C {devices/lab_pin.sym} 104680 -24560 0 0 {name=p103968 lab=_47208_/Y }
C {devices/lab_pin.sym} 104800 -24620 0 1 {name=p103969 lab=_54607_/X }
C {sky130_stdcells/and4_4.sym} 104740 -24620 0 0 {name=X_54607_ }
C {devices/lab_pin.sym} 104660 -24510 0 0 {name=p103970 lab=_49210_/B }
C {devices/lab_pin.sym} 104660 -24470 0 0 {name=p103971 lab=_40921_/A }
C {devices/lab_pin.sym} 104660 -24430 0 0 {name=p103972 lab=_41888_/X }
C {devices/lab_pin.sym} 104660 -24390 0 0 {name=p103973 lab=_42620_/Y }
C {devices/lab_pin.sym} 104660 -24350 0 0 {name=p103974 lab=_42612_/X }
C {devices/lab_pin.sym} 104820 -24430 0 1 {name=p103975 lab=_42621_/Y }
C {sky130_stdcells/o32ai_4.sym} 104740 -24430 0 0 {name=X_42621_ }
C {devices/lab_pin.sym} 104660 -24300 0 0 {name=p103976 lab=_43741_/Y }
C {devices/lab_pin.sym} 104660 -24260 0 0 {name=p103977 lab=_73030_/X }
C {devices/lab_pin.sym} 104660 -24220 0 0 {name=p103978 lab=_72858_/X }
C {devices/lab_pin.sym} 104660 -24180 0 0 {name=p103979 lab=_73440_/Y }
C {devices/lab_pin.sym} 104820 -24240 0 1 {name=p103980 lab=_73441_/X }
C {sky130_stdcells/a211o_4.sym} 104740 -24240 0 0 {name=X_73441_ }
C {devices/lab_pin.sym} 104650 -24090 0 0 {name=p103981 lab=_85428_/CLK }
C {devices/lab_pin.sym} 104650 -24070 0 0 {name=p103982 lab=_54523_/Y }
C {devices/lab_pin.sym} 104830 -24090 0 1 {name=p103983 lab=_85427_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -24080 0 0 {name=X_85427_ }
C {devices/lab_pin.sym} 104700 -23950 0 0 {name=p103984 lab=_53269_/A }
C {devices/lab_pin.sym} 104780 -23950 0 1 {name=p103985 lab=_51820_/A }
C {sky130_stdcells/buf_2.sym} 104740 -23950 0 0 {name=X_51819_ }
C {devices/lab_pin.sym} 104680 -23860 0 0 {name=p103986 lab=_70722_/A }
C {devices/lab_pin.sym} 104680 -23820 0 0 {name=p103987 lab=_70656_/B }
C {devices/lab_pin.sym} 104680 -23780 0 0 {name=p103988 lab=_70642_/X }
C {devices/lab_pin.sym} 104680 -23740 0 0 {name=p103989 lab=_70656_/D }
C {devices/lab_pin.sym} 104800 -23800 0 1 {name=p103990 lab=_70653_/Y }
C {sky130_stdcells/nand4_4.sym} 104740 -23800 0 0 {name=X_70653_ }
C {devices/lab_pin.sym} 104650 -23650 0 0 {name=p103991 lab=_84003_/CLK }
C {devices/lab_pin.sym} 104650 -23630 0 0 {name=p103992 lab=_82639_/D }
C {devices/lab_pin.sym} 104830 -23650 0 1 {name=p103993 lab=_78921_/A }
C {sky130_stdcells/dfxtp_4.sym} 104740 -23640 0 0 {name=X_82639_ }
C {devices/lab_pin.sym} 104660 -23530 0 0 {name=p103994 lab=_58341_/X }
C {devices/lab_pin.sym} 104660 -23490 0 0 {name=p103995 lab=_58372_/Y }
C {devices/lab_pin.sym} 104660 -23450 0 0 {name=p103996 lab=_58374_/Y }
C {devices/lab_pin.sym} 104820 -23490 0 1 {name=p103997 lab=_84866_/D }
C {sky130_stdcells/a21oi_4.sym} 104740 -23490 0 0 {name=X_58375_ }
C {devices/lab_pin.sym} 104660 -23370 0 0 {name=p103998 lab=_55583_/X }
C {devices/lab_pin.sym} 104660 -23330 0 0 {name=p103999 lab=_55586_/X }
C {devices/lab_pin.sym} 104660 -23290 0 0 {name=p104000 lab=_44115_/A }
C {devices/lab_pin.sym} 104820 -23330 0 1 {name=p104001 lab=_55592_/A }
C {sky130_stdcells/a21o_4.sym} 104740 -23330 0 0 {name=X_55587_ }
C {devices/lab_pin.sym} 104680 -23200 0 0 {name=p104002 lab=_52803_/A }
C {devices/lab_pin.sym} 104680 -23160 0 0 {name=p104003 lab=_52799_/B }
C {devices/lab_pin.sym} 104800 -23180 0 1 {name=p104004 lab=_52799_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -23180 0 0 {name=X_52799_ }
C {sky130_stdcells/decap_3.sym} 104740 -23020 0 0 {name=XPHY_40 }
C {devices/lab_pin.sym} 104660 -22890 0 0 {name=p104005 lab=_55724_/B }
C {devices/lab_pin.sym} 104660 -22850 0 0 {name=p104006 lab=_45284_/X }
C {devices/lab_pin.sym} 104660 -22810 0 0 {name=p104007 lab=_45339_/X }
C {devices/lab_pin.sym} 104820 -22850 0 1 {name=p104008 lab=_45340_/X }
C {sky130_stdcells/o21a_4.sym} 104740 -22850 0 0 {name=X_45340_ }
C {sky130_stdcells/decap_3.sym} 104740 -22680 0 0 {name=XPHY_51 }
C {devices/lab_pin.sym} 104680 -22550 0 0 {name=p104009 lab=_57026_/X }
C {devices/lab_pin.sym} 104680 -22510 0 0 {name=p104010 lab=_57326_/B }
C {devices/lab_pin.sym} 104680 -22470 0 0 {name=p104011 lab=_57326_/C }
C {devices/lab_pin.sym} 104800 -22510 0 1 {name=p104012 lab=_57326_/Y }
C {sky130_stdcells/nor3_4.sym} 104740 -22510 0 0 {name=X_57326_ }
C {devices/lab_pin.sym} 104660 -22390 0 0 {name=p104013 lab=_76158_/X }
C {devices/lab_pin.sym} 104660 -22350 0 0 {name=p104014 lab=_76159_/Y }
C {devices/lab_pin.sym} 104660 -22310 0 0 {name=p104015 lab=_81635_/Q }
C {devices/lab_pin.sym} 104820 -22350 0 1 {name=p104016 lab=_76160_/X }
C {sky130_stdcells/a21o_4.sym} 104740 -22350 0 0 {name=X_76160_ }
C {devices/lab_pin.sym} 104650 -22210 0 0 {name=p104017 lab=_86834_/CLK }
C {devices/lab_pin.sym} 104650 -22190 0 0 {name=p104018 lab=_88146_/D }
C {devices/lab_pin.sym} 104830 -22210 0 1 {name=p104019 lab=_66609_/B }
C {sky130_stdcells/dfxtp_4.sym} 104740 -22200 0 0 {name=X_88146_ }
C {devices/lab_pin.sym} 104660 -22110 0 0 {name=p104020 lab=_42521_/X }
C {devices/lab_pin.sym} 104660 -22070 0 0 {name=p104021 lab=_42522_/X }
C {devices/lab_pin.sym} 104660 -22030 0 0 {name=p104022 lab=_40787_/X }
C {devices/lab_pin.sym} 104660 -21990 0 0 {name=p104023 lab=_87823_/Q }
C {devices/lab_pin.sym} 104660 -21950 0 0 {name=p104024 lab=_42540_/X }
C {devices/lab_pin.sym} 104820 -22030 0 1 {name=p104025 lab=_42553_/A }
C {sky130_stdcells/o32ai_4.sym} 104740 -22030 0 0 {name=X_42552_ }
C {devices/lab_pin.sym} 104680 -21900 0 0 {name=p104026 lab=_54538_/A }
C {devices/lab_pin.sym} 104680 -21860 0 0 {name=p104027 lab=_54526_/B }
C {devices/lab_pin.sym} 104680 -21820 0 0 {name=p104028 lab=_54538_/C }
C {devices/lab_pin.sym} 104680 -21780 0 0 {name=p104029 lab=_47084_/A }
C {devices/lab_pin.sym} 104800 -21840 0 1 {name=p104030 lab=_54538_/X }
C {sky130_stdcells/and4_4.sym} 104740 -21840 0 0 {name=X_54538_ }
C {devices/lab_pin.sym} 104680 -21700 0 0 {name=p104031 lab=_73372_/A }
C {devices/lab_pin.sym} 104680 -21660 0 0 {name=p104032 lab=_73372_/B }
C {devices/lab_pin.sym} 104800 -21680 0 1 {name=p104033 lab=_73372_/Y }
C {sky130_stdcells/nor2_4.sym} 104740 -21680 0 0 {name=X_73372_ }
C {devices/lab_pin.sym} 104650 -21550 0 0 {name=p104034 lab=_86289_/CLK }
C {devices/lab_pin.sym} 104650 -21530 0 0 {name=p104035 lab=_85358_/D }
C {devices/lab_pin.sym} 104830 -21550 0 1 {name=p104036 lab=_85358_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -21540 0 0 {name=X_85358_ }
C {sky130_stdcells/decap_3.sym} 104740 -21380 0 0 {name=XPHY_62 }
C {devices/lab_pin.sym} 104700 -21230 0 0 {name=p104037 lab=_70583_/X }
C {devices/lab_pin.sym} 104780 -21230 0 1 {name=p104038 lab=_70584_/X }
C {sky130_stdcells/buf_2.sym} 104740 -21230 0 0 {name=X_70584_ }
C {sky130_stdcells/decap_3.sym} 104740 -21080 0 0 {name=XPHY_73 }
C {sky130_stdcells/decap_3.sym} 104740 -20900 0 0 {name=XPHY_84 }
C {devices/lab_pin.sym} 104680 -20760 0 0 {name=p104039 lab=_75109_/A }
C {devices/lab_pin.sym} 104680 -20720 0 0 {name=p104040 lab=_75109_/B }
C {devices/lab_pin.sym} 104800 -20740 0 1 {name=p104041 lab=_75113_/C }
C {sky130_stdcells/nand2_4.sym} 104740 -20740 0 0 {name=X_75111_ }
C {devices/lab_pin.sym} 104700 -20610 0 0 {name=p104042 lab=_41502_/Y }
C {devices/lab_pin.sym} 104780 -20610 0 1 {name=p104043 lab=_41503_/X }
C {sky130_stdcells/buf_2.sym} 104740 -20610 0 0 {name=X_41503_ }
C {devices/lab_pin.sym} 104700 -20490 0 0 {name=p104044 lab=_72323_/A }
C {devices/lab_pin.sym} 104780 -20490 0 1 {name=p104045 lab=_72323_/Y }
C {sky130_stdcells/inv_2.sym} 104740 -20490 0 0 {name=X_72323_ }
C {sky130_stdcells/decap_3.sym} 104740 -20340 0 0 {name=XPHY_95 }
C {devices/lab_pin.sym} 104650 -20190 0 0 {name=p104046 lab=_84314_/CLK }
C {devices/lab_pin.sym} 104650 -20170 0 0 {name=p104047 lab=_63616_/Y }
C {devices/lab_pin.sym} 104830 -20190 0 1 {name=p104048 lab=_80413_/B }
C {sky130_stdcells/dfxtp_4.sym} 104740 -20180 0 0 {name=X_84309_ }
C {devices/lab_pin.sym} 104680 -20070 0 0 {name=p104049 lab=_57359_/A }
C {devices/lab_pin.sym} 104680 -20030 0 0 {name=p104050 lab=_45553_/A }
C {devices/lab_pin.sym} 104680 -19990 0 0 {name=p104051 lab=_57249_/X }
C {devices/lab_pin.sym} 104800 -20030 0 1 {name=p104052 lab=_57257_/Y }
C {sky130_stdcells/nor3_4.sym} 104740 -20030 0 0 {name=X_57257_ }
C {devices/lab_pin.sym} 104700 -19890 0 0 {name=p104053 lab=_83017_/Q }
C {devices/lab_pin.sym} 104780 -19890 0 1 {name=p104054 lab=_45273_/A }
C {sky130_stdcells/inv_2.sym} 104740 -19890 0 0 {name=X_45271_ }
C {devices/lab_pin.sym} 104680 -19780 0 0 {name=p104055 lab=_81722_/D }
C {devices/lab_pin.sym} 104680 -19740 0 0 {name=p104056 lab=_76092_/B }
C {devices/lab_pin.sym} 104800 -19760 0 1 {name=p104057 lab=_76094_/A }
C {sky130_stdcells/nor2_4.sym} 104740 -19760 0 0 {name=X_76091_ }
C {devices/lab_pin.sym} 104650 -19630 0 0 {name=p104058 lab=_88081_/CLK }
C {devices/lab_pin.sym} 104650 -19610 0 0 {name=p104059 lab=_88077_/D }
C {devices/lab_pin.sym} 104830 -19630 0 1 {name=p104060 lab=_41996_/A }
C {sky130_stdcells/dfxtp_4.sym} 104740 -19620 0 0 {name=X_88077_ }
C {devices/lab_pin.sym} 104680 -19500 0 0 {name=p104061 lab=_54478_/A }
C {devices/lab_pin.sym} 104680 -19460 0 0 {name=p104062 lab=_54469_/B }
C {devices/lab_pin.sym} 104800 -19480 0 1 {name=p104063 lab=_54469_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -19480 0 0 {name=X_54469_ }
C {devices/lab_pin.sym} 104700 -19350 0 0 {name=p104064 lab=_73795_/A }
C {devices/lab_pin.sym} 104780 -19350 0 1 {name=p104065 lab=_68618_/B }
C {sky130_stdcells/inv_2.sym} 104740 -19350 0 0 {name=X_42483_ }
C {devices/lab_pin.sym} 104650 -19230 0 0 {name=p104066 lab=_83016_/CLK }
C {devices/lab_pin.sym} 104650 -19210 0 0 {name=p104067 lab=_56141_/Y }
C {devices/lab_pin.sym} 104830 -19230 0 1 {name=p104068 lab=_85289_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -19220 0 0 {name=X_85289_ }
C {devices/lab_pin.sym} 104700 -19090 0 0 {name=p104069 lab=_46961_/X }
C {devices/lab_pin.sym} 104780 -19090 0 1 {name=p104070 lab=_47029_/A }
C {sky130_stdcells/buf_2.sym} 104740 -19090 0 0 {name=X_47010_ }
C {devices/lab_pin.sym} 104680 -18990 0 0 {name=p104071 lab=_56200_/X }
C {devices/lab_pin.sym} 104680 -18950 0 0 {name=p104072 lab=_56205_/X }
C {devices/lab_pin.sym} 104680 -18910 0 0 {name=p104073 lab=_56208_/C }
C {devices/lab_pin.sym} 104800 -18950 0 1 {name=p104074 lab=_56208_/Y }
C {sky130_stdcells/nand3_4.sym} 104740 -18950 0 0 {name=X_56208_ }
C {devices/lab_pin.sym} 104700 -18810 0 0 {name=p104075 lab=_68057_/A }
C {devices/lab_pin.sym} 104780 -18810 0 1 {name=p104076 lab=_69751_/A }
C {sky130_stdcells/buf_2.sym} 104740 -18810 0 0 {name=X_44222_ }
C {devices/lab_pin.sym} 104680 -18700 0 0 {name=p104077 lab=_75042_/A }
C {devices/lab_pin.sym} 104680 -18660 0 0 {name=p104078 lab=_75042_/B }
C {devices/lab_pin.sym} 104800 -18680 0 1 {name=p104079 lab=_75042_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -18680 0 0 {name=X_75042_ }
C {devices/lab_pin.sym} 104650 -18550 0 0 {name=p104080 lab=_87032_/CLK }
C {devices/lab_pin.sym} 104650 -18530 0 0 {name=p104081 lab=_44627_/Y }
C {devices/lab_pin.sym} 104830 -18550 0 1 {name=p104082 lab=_87028_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -18540 0 0 {name=X_87028_ }
C {devices/lab_pin.sym} 104660 -18440 0 0 {name=p104083 lab=_41433_/X }
C {devices/lab_pin.sym} 104660 -18400 0 0 {name=p104084 lab=_41418_/X }
C {devices/lab_pin.sym} 104660 -18360 0 0 {name=p104085 lab=_88216_/Q }
C {devices/lab_pin.sym} 104660 -18320 0 0 {name=p104086 lab=_41419_/X }
C {devices/lab_pin.sym} 104820 -18380 0 1 {name=p104087 lab=_41434_/X }
C {sky130_stdcells/a2bb2o_4.sym} 104740 -18380 0 0 {name=X_41434_ }
C {devices/lab_pin.sym} 104660 -18270 0 0 {name=p104088 lab=_72137_/X }
C {devices/lab_pin.sym} 104660 -18230 0 0 {name=p104089 lab=_72251_/Y }
C {devices/lab_pin.sym} 104660 -18190 0 0 {name=p104090 lab=_72253_/Y }
C {devices/lab_pin.sym} 104660 -18150 0 0 {name=p104091 lab=_72194_/X }
C {devices/lab_pin.sym} 104660 -18110 0 0 {name=p104092 lab=_72141_/X }
C {devices/lab_pin.sym} 104820 -18190 0 1 {name=p104093 lab=_72254_/X }
C {sky130_stdcells/o32a_4.sym} 104740 -18190 0 0 {name=X_72254_ }
C {devices/lab_pin.sym} 104680 -18050 0 0 {name=p104094 lab=_57188_/A }
C {devices/lab_pin.sym} 104680 -18010 0 0 {name=p104095 lab=_44239_/A }
C {devices/lab_pin.sym} 104680 -17970 0 0 {name=p104096 lab=_56818_/X }
C {devices/lab_pin.sym} 104800 -18010 0 1 {name=p104097 lab=_57188_/Y }
C {sky130_stdcells/nand3_4.sym} 104740 -18010 0 0 {name=X_57188_ }
C {devices/lab_pin.sym} 104680 -17890 0 0 {name=p104098 lab=_71197_/A }
C {devices/lab_pin.sym} 104680 -17850 0 0 {name=p104099 lab=_71228_/B }
C {devices/lab_pin.sym} 104680 -17810 0 0 {name=p104100 lab=_71197_/C }
C {devices/lab_pin.sym} 104800 -17850 0 1 {name=p104101 lab=_71205_/Y }
C {sky130_stdcells/nand3_4.sym} 104740 -17850 0 0 {name=X_71205_ }
C {devices/lab_pin.sym} 104700 -17710 0 0 {name=p104102 lab=_44265_/D }
C {devices/lab_pin.sym} 104780 -17710 0 1 {name=p104103 lab=_44153_/X }
C {sky130_stdcells/buf_2.sym} 104740 -17710 0 0 {name=X_44153_ }
C {devices/lab_pin.sym} 104700 -17590 0 0 {name=p104104 lab=_56138_/Y }
C {devices/lab_pin.sym} 104780 -17590 0 1 {name=p104105 lab=_56139_/X }
C {sky130_stdcells/buf_2.sym} 104740 -17590 0 0 {name=X_56139_ }
C {devices/lab_pin.sym} 104700 -17470 0 0 {name=p104106 lab=_79839_/X }
C {devices/lab_pin.sym} 104780 -17470 0 1 {name=p104107 lab=_79850_/Y }
C {sky130_stdcells/inv_2.sym} 104740 -17470 0 0 {name=X_79850_ }
C {devices/lab_pin.sym} 104680 -17360 0 0 {name=p104108 lab=_41358_/X }
C {devices/lab_pin.sym} 104680 -17320 0 0 {name=p104109 lab=_82898_/Q }
C {devices/lab_pin.sym} 104800 -17340 0 1 {name=p104110 lab=_41365_/X }
C {sky130_stdcells/or2_4.sym} 104740 -17340 0 0 {name=X_41365_ }
C {devices/lab_pin.sym} 104700 -17210 0 0 {name=p104111 lab=_59297_/A }
C {devices/lab_pin.sym} 104780 -17210 0 1 {name=p104112 lab=_72185_/X }
C {sky130_stdcells/buf_2.sym} 104740 -17210 0 0 {name=X_72185_ }
C {devices/lab_pin.sym} 104660 -17130 0 0 {name=p104113 lab=_43046_/X }
C {devices/lab_pin.sym} 104660 -17090 0 0 {name=p104114 lab=_43047_/X }
C {devices/lab_pin.sym} 104660 -17050 0 0 {name=p104115 lab=_40749_/X }
C {devices/lab_pin.sym} 104660 -17010 0 0 {name=p104116 lab=_43103_/Y }
C {devices/lab_pin.sym} 104660 -16970 0 0 {name=p104117 lab=_43090_/X }
C {devices/lab_pin.sym} 104820 -17050 0 1 {name=p104118 lab=_87574_/D }
C {sky130_stdcells/o32ai_4.sym} 104740 -17050 0 0 {name=X_43104_ }
C {devices/lab_pin.sym} 104680 -16900 0 0 {name=p104119 lab=_78801_/A }
C {devices/lab_pin.sym} 104680 -16860 0 0 {name=p104120 lab=_78801_/B }
C {devices/lab_pin.sym} 104800 -16880 0 1 {name=p104121 lab=_78801_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -16880 0 0 {name=X_78801_ }
C {devices/lab_pin.sym} 104680 -16780 0 0 {name=p104122 lab=_71136_/A }
C {devices/lab_pin.sym} 104680 -16740 0 0 {name=p104123 lab=_70758_/C }
C {devices/lab_pin.sym} 104680 -16700 0 0 {name=p104124 lab=_70827_/C }
C {devices/lab_pin.sym} 104680 -16660 0 0 {name=p104125 lab=_70627_/A }
C {devices/lab_pin.sym} 104800 -16720 0 1 {name=p104126 lab=_71137_/B }
C {sky130_stdcells/nand4_4.sym} 104740 -16720 0 0 {name=X_71136_ }
C {devices/lab_pin.sym} 104660 -16590 0 0 {name=p104127 lab=_48957_/Y }
C {devices/lab_pin.sym} 104660 -16550 0 0 {name=p104128 lab=_48935_/X }
C {devices/lab_pin.sym} 104660 -16510 0 0 {name=p104129 lab=_48960_/X }
C {devices/lab_pin.sym} 104820 -16550 0 1 {name=p104130 lab=_86458_/D }
C {sky130_stdcells/a21oi_4.sym} 104740 -16550 0 0 {name=X_48961_ }
C {devices/lab_pin.sym} 104680 -16420 0 0 {name=p104131 lab=_43986_/A }
C {devices/lab_pin.sym} 104680 -16380 0 0 {name=p104132 lab=_87174_/Q }
C {devices/lab_pin.sym} 104800 -16400 0 1 {name=p104133 lab=_44085_/D }
C {sky130_stdcells/nand2_4.sym} 104740 -16400 0 0 {name=X_44084_ }
C {devices/lab_pin.sym} 104680 -16280 0 0 {name=p104134 lab=_79774_/X }
C {devices/lab_pin.sym} 104680 -16240 0 0 {name=p104135 lab=_79781_/B }
C {devices/lab_pin.sym} 104800 -16260 0 1 {name=p104136 lab=_79781_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -16260 0 0 {name=X_79781_ }
C {devices/lab_pin.sym} 104680 -16140 0 0 {name=p104137 lab=_81759_/Q }
C {devices/lab_pin.sym} 104680 -16100 0 0 {name=p104138 lab=_41292_/B }
C {devices/lab_pin.sym} 104800 -16120 0 1 {name=p104139 lab=_41296_/X }
C {sky130_stdcells/or2_4.sym} 104740 -16120 0 0 {name=X_41296_ }
C {devices/lab_pin.sym} 104680 -16000 0 0 {name=p104140 lab=_84545_/Q }
C {devices/lab_pin.sym} 104680 -15960 0 0 {name=p104141 lab=_76993_/B }
C {devices/lab_pin.sym} 104800 -15980 0 1 {name=p104142 lab=_76993_/X }
C {sky130_stdcells/xor2_4.sym} 104740 -15980 0 0 {name=X_76993_ }
C {devices/lab_pin.sym} 104680 -15860 0 0 {name=p104143 lab=_47912_/A }
C {devices/lab_pin.sym} 104680 -15820 0 0 {name=p104144 lab=_50268_/B }
C {devices/lab_pin.sym} 104800 -15840 0 1 {name=p104145 lab=_47912_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -15840 0 0 {name=X_47912_ }
C {devices/lab_pin.sym} 104660 -15750 0 0 {name=p104146 lab=_42060_/X }
C {devices/lab_pin.sym} 104660 -15710 0 0 {name=p104147 lab=_43031_/X }
C {devices/lab_pin.sym} 104660 -15670 0 0 {name=p104148 lab=_40590_/X }
C {devices/lab_pin.sym} 104660 -15630 0 0 {name=p104149 lab=_43032_/Y }
C {devices/lab_pin.sym} 104660 -15590 0 0 {name=p104150 lab=_43034_/X }
C {devices/lab_pin.sym} 104820 -15670 0 1 {name=p104151 lab=_43035_/Y }
C {sky130_stdcells/o32ai_4.sym} 104740 -15670 0 0 {name=X_43035_ }
C {devices/lab_pin.sym} 104680 -15530 0 0 {name=p104152 lab=_78732_/A }
C {devices/lab_pin.sym} 104680 -15490 0 0 {name=p104153 lab=_78732_/B }
C {devices/lab_pin.sym} 104680 -15450 0 0 {name=p104154 lab=_78732_/C }
C {devices/lab_pin.sym} 104800 -15490 0 1 {name=p104155 lab=_78732_/X }
C {sky130_stdcells/or3_4.sym} 104740 -15490 0 0 {name=X_78732_ }
C {devices/lab_pin.sym} 104700 -15350 0 0 {name=p104156 lab=CLK }
C {devices/lab_pin.sym} 104780 -15350 0 1 {name=p104157 lab=clkbuf_0_CLK/X }
C {sky130_stdcells/clkbuf_16.sym} 104740 -15350 0 0 {name=Xclkbuf_0_CLK }
C {devices/lab_pin.sym} 104660 -15250 0 0 {name=p104158 lab=_48955_/X }
C {devices/lab_pin.sym} 104660 -15210 0 0 {name=p104159 lab=_71046_/X }
C {devices/lab_pin.sym} 104660 -15170 0 0 {name=p104160 lab=_71066_/Y }
C {devices/lab_pin.sym} 104820 -15210 0 1 {name=p104161 lab=_71067_/Y }
C {sky130_stdcells/o21ai_4.sym} 104740 -15210 0 0 {name=X_71067_ }
C {devices/lab_pin.sym} 104680 -15080 0 0 {name=p104162 lab=_81509_/Q }
C {devices/lab_pin.sym} 104680 -15040 0 0 {name=p104163 lab=_75944_/B }
C {devices/lab_pin.sym} 104800 -15060 0 1 {name=p104164 lab=_81790_/D }
C {sky130_stdcells/xor2_4.sym} 104740 -15060 0 0 {name=X_75944_ }
C {devices/lab_pin.sym} 104660 -14950 0 0 {name=p104165 lab=_48606_/X }
C {devices/lab_pin.sym} 104660 -14910 0 0 {name=p104166 lab=_81216_/Q }
C {devices/lab_pin.sym} 104660 -14870 0 0 {name=p104167 lab=_48891_/Y }
C {devices/lab_pin.sym} 104820 -14910 0 1 {name=p104168 lab=_48893_/A }
C {sky130_stdcells/o21ai_4.sym} 104740 -14910 0 0 {name=X_48892_ }
C {devices/lab_pin.sym} 104660 -14790 0 0 {name=p104169 lab=_82552_/D }
C {devices/lab_pin.sym} 104660 -14750 0 0 {name=p104170 lab=_70010_/X }
C {devices/lab_pin.sym} 104660 -14710 0 0 {name=p104171 lab=_70017_/X }
C {devices/lab_pin.sym} 104820 -14750 0 1 {name=p104172 lab=_83872_/D }
C {sky130_stdcells/a21bo_4.sym} 104740 -14750 0 0 {name=X_70018_ }
C {devices/lab_pin.sym} 104700 -14610 0 0 {name=p104173 lab=_73591_/A }
C {devices/lab_pin.sym} 104780 -14610 0 1 {name=p104174 lab=_50224_/B }
C {sky130_stdcells/buf_2.sym} 104740 -14610 0 0 {name=X_47843_ }
C {devices/lab_pin.sym} 104700 -14490 0 0 {name=p104175 lab=_59875_/A }
C {devices/lab_pin.sym} 104780 -14490 0 1 {name=p104176 lab=_59829_/X }
C {sky130_stdcells/buf_2.sym} 104740 -14490 0 0 {name=X_59829_ }
C {devices/lab_pin.sym} 104680 -14390 0 0 {name=p104177 lab=_78663_/A }
C {devices/lab_pin.sym} 104680 -14350 0 0 {name=p104178 lab=_78663_/B }
C {devices/lab_pin.sym} 104680 -14310 0 0 {name=p104179 lab=_78663_/C }
C {devices/lab_pin.sym} 104800 -14350 0 1 {name=p104180 lab=_78663_/X }
C {sky130_stdcells/or3_4.sym} 104740 -14350 0 0 {name=X_78663_ }
C {devices/lab_pin.sym} 104680 -14230 0 0 {name=p104181 lab=_75862_/Y }
C {devices/lab_pin.sym} 104680 -14190 0 0 {name=p104182 lab=_75875_/B }
C {devices/lab_pin.sym} 104680 -14150 0 0 {name=p104183 lab=_75875_/C }
C {devices/lab_pin.sym} 104800 -14190 0 1 {name=p104184 lab=_75876_/B }
C {sky130_stdcells/nand3_4.sym} 104740 -14190 0 0 {name=X_75875_ }
C {devices/lab_pin.sym} 104680 -14070 0 0 {name=p104185 lab=_77614_/A }
C {devices/lab_pin.sym} 104680 -14030 0 0 {name=p104186 lab=_77614_/B }
C {devices/lab_pin.sym} 104680 -13990 0 0 {name=p104187 lab=_77614_/C }
C {devices/lab_pin.sym} 104800 -14030 0 1 {name=p104188 lab=_77614_/X }
C {sky130_stdcells/or3_4.sym} 104740 -14030 0 0 {name=X_77614_ }
C {devices/lab_pin.sym} 104700 -13890 0 0 {name=p104189 lab=_74826_/A }
C {devices/lab_pin.sym} 104780 -13890 0 1 {name=p104190 lab=_74826_/Y }
C {sky130_stdcells/inv_2.sym} 104740 -13890 0 0 {name=X_74826_ }
C {devices/lab_pin.sym} 104660 -13790 0 0 {name=p104191 lab=_62837_/X }
C {devices/lab_pin.sym} 104660 -13750 0 0 {name=p104192 lab=_62838_/X }
C {devices/lab_pin.sym} 104660 -13710 0 0 {name=p104193 lab=_62839_/Y }
C {devices/lab_pin.sym} 104820 -13750 0 1 {name=p104194 lab=_84378_/D }
C {sky130_stdcells/a21oi_4.sym} 104740 -13750 0 0 {name=X_62840_ }
C {devices/lab_pin.sym} 104660 -13630 0 0 {name=p104195 lab=_72428_/A }
C {devices/lab_pin.sym} 104660 -13590 0 0 {name=p104196 lab=_47760_/X }
C {devices/lab_pin.sym} 104660 -13550 0 0 {name=p104197 lab=_47773_/Y }
C {devices/lab_pin.sym} 104820 -13590 0 1 {name=p104198 lab=_47774_/Y }
C {sky130_stdcells/o21ai_4.sym} 104740 -13590 0 0 {name=X_47774_ }
C {devices/lab_pin.sym} 104680 -13460 0 0 {name=p104199 lab=_82517_/Q }
C {devices/lab_pin.sym} 104680 -13420 0 0 {name=p104200 lab=_82773_/D }
C {devices/lab_pin.sym} 104800 -13440 0 1 {name=p104201 lab=_78594_/X }
C {sky130_stdcells/xor2_4.sym} 104740 -13440 0 0 {name=X_78594_ }
C {devices/lab_pin.sym} 104700 -13310 0 0 {name=p104202 lab=_45212_/A }
C {devices/lab_pin.sym} 104780 -13310 0 1 {name=p104203 lab=_44986_/X }
C {sky130_stdcells/buf_2.sym} 104740 -13310 0 0 {name=X_44986_ }
C {devices/lab_pin.sym} 104660 -13210 0 0 {name=p104204 lab=_58920_/B }
C {devices/lab_pin.sym} 104660 -13170 0 0 {name=p104205 lab=_49496_/X }
C {devices/lab_pin.sym} 104660 -13130 0 0 {name=p104206 lab=_49512_/Y }
C {devices/lab_pin.sym} 104820 -13170 0 1 {name=p104207 lab=_49513_/Y }
C {sky130_stdcells/o21ai_4.sym} 104740 -13170 0 0 {name=X_49513_ }
C {devices/lab_pin.sym} 104700 -13030 0 0 {name=p104208 lab=_46725_/A }
C {devices/lab_pin.sym} 104780 -13030 0 1 {name=p104209 lab=_46915_/A }
C {sky130_stdcells/buf_2.sym} 104740 -13030 0 0 {name=X_46725_ }
C {devices/lab_pin.sym} 104660 -12930 0 0 {name=p104210 lab=_77508_/A }
C {devices/lab_pin.sym} 104660 -12890 0 0 {name=p104211 lab=_77511_/A }
C {devices/lab_pin.sym} 104660 -12850 0 0 {name=p104212 lab=_77520_/B }
C {devices/lab_pin.sym} 104820 -12890 0 1 {name=p104213 lab=_77561_/A }
C {sky130_stdcells/a21o_4.sym} 104740 -12890 0 0 {name=X_77545_ }
C {devices/lab_pin.sym} 104700 -12750 0 0 {name=p104214 lab=_43937_/A }
C {devices/lab_pin.sym} 104780 -12750 0 1 {name=p104215 lab=_43937_/Y }
C {sky130_stdcells/inv_2.sym} 104740 -12750 0 0 {name=X_43937_ }
C {devices/lab_pin.sym} 104660 -12670 0 0 {name=p104216 lab=_57660_/X }
C {devices/lab_pin.sym} 104660 -12630 0 0 {name=p104217 lab=_62749_/X }
C {devices/lab_pin.sym} 104660 -12590 0 0 {name=p104218 lab=_62768_/X }
C {devices/lab_pin.sym} 104660 -12550 0 0 {name=p104219 lab=_62759_/X }
C {devices/lab_pin.sym} 104660 -12520 0 0 {name=p104220 lab=_62770_/X }
C {devices/lab_pin.sym} 104820 -12590 0 1 {name=p104221 lab=_62771_/Y }
C {sky130_stdcells/a41oi_4.sym} 104740 -12590 0 0 {name=X_62771_ }
C {devices/lab_pin.sym} 104660 -12470 0 0 {name=p104222 lab=_83843_/Q }
C {devices/lab_pin.sym} 104660 -12430 0 0 {name=p104223 lab=_74735_/X }
C {devices/lab_pin.sym} 104660 -12390 0 0 {name=p104224 lab=_74754_/X }
C {devices/lab_pin.sym} 104660 -12350 0 0 {name=p104225 lab=_74755_/X }
C {devices/lab_pin.sym} 104660 -12310 0 0 {name=p104226 lab=_74756_/X }
C {devices/lab_pin.sym} 104820 -12390 0 1 {name=p104227 lab=_74758_/C }
C {sky130_stdcells/a2111oi_4.sym} 104740 -12390 0 0 {name=X_74757_ }
C {devices/lab_pin.sym} 104700 -12230 0 0 {name=p104228 lab=_72009_/A }
C {devices/lab_pin.sym} 104780 -12230 0 1 {name=p104229 lab=_71969_/X }
C {sky130_stdcells/buf_2.sym} 104740 -12230 0 0 {name=X_71969_ }
C {devices/lab_pin.sym} 104660 -12130 0 0 {name=p104230 lab=_64507_/Y }
C {devices/lab_pin.sym} 104660 -12090 0 0 {name=p104231 lab=_59655_/X }
C {devices/lab_pin.sym} 104660 -12050 0 0 {name=p104232 lab=_64509_/Y }
C {devices/lab_pin.sym} 104820 -12090 0 1 {name=p104233 lab=_64510_/Y }
C {sky130_stdcells/a21oi_4.sym} 104740 -12090 0 0 {name=X_64510_ }
C {devices/lab_pin.sym} 104700 -11950 0 0 {name=p104234 lab=_49444_/A }
C {devices/lab_pin.sym} 104780 -11950 0 1 {name=p104235 lab=_49454_/A }
C {sky130_stdcells/buf_2.sym} 104740 -11950 0 0 {name=X_49444_ }
C {devices/lab_pin.sym} 104700 -11830 0 0 {name=p104236 lab=_61722_/A }
C {devices/lab_pin.sym} 104780 -11830 0 1 {name=p104237 lab=_61752_/A }
C {sky130_stdcells/buf_2.sym} 104740 -11830 0 0 {name=X_61722_ }
C {devices/lab_pin.sym} 104660 -11740 0 0 {name=p104238 lab=_73605_/X }
C {devices/lab_pin.sym} 104660 -11700 0 0 {name=p104239 lab=_86235_/Q }
C {devices/lab_pin.sym} 104660 -11660 0 0 {name=p104240 lab=_73683_/X }
C {devices/lab_pin.sym} 104660 -11620 0 0 {name=p104241 lab=_73707_/X }
C {devices/lab_pin.sym} 104820 -11680 0 1 {name=p104242 lab=_73708_/X }
C {sky130_stdcells/a211o_4.sym} 104740 -11680 0 0 {name=X_73708_ }
C {devices/lab_pin.sym} 104700 -11530 0 0 {name=p104243 lab=_46845_/A }
C {devices/lab_pin.sym} 104780 -11530 0 1 {name=p104244 lab=_46682_/B }
C {sky130_stdcells/buf_2.sym} 104740 -11530 0 0 {name=X_46656_ }
C {devices/lab_pin.sym} 104660 -11440 0 0 {name=p104245 lab=_65453_/X }
C {devices/lab_pin.sym} 104660 -11400 0 0 {name=p104246 lab=_85597_/Q }
C {devices/lab_pin.sym} 104660 -11360 0 0 {name=p104247 lab=_65470_/X }
C {devices/lab_pin.sym} 104660 -11320 0 0 {name=p104248 lab=_65489_/X }
C {devices/lab_pin.sym} 104820 -11380 0 1 {name=p104249 lab=_65490_/X }
C {sky130_stdcells/a211o_4.sym} 104740 -11380 0 0 {name=X_65490_ }
C {devices/lab_pin.sym} 104680 -11240 0 0 {name=p104250 lab=_77476_/A }
C {devices/lab_pin.sym} 104680 -11200 0 0 {name=p104251 lab=_77473_/A }
C {devices/lab_pin.sym} 104800 -11220 0 1 {name=p104252 lab=_77476_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -11220 0 0 {name=X_77476_ }
C {devices/lab_pin.sym} 104700 -11090 0 0 {name=p104253 lab=_43842_/A }
C {devices/lab_pin.sym} 104780 -11090 0 1 {name=p104254 lab=_43868_/X }
C {sky130_stdcells/buf_2.sym} 104740 -11090 0 0 {name=X_43868_ }
C {devices/lab_pin.sym} 104680 -10980 0 0 {name=p104255 lab=_74694_/A }
C {devices/lab_pin.sym} 104680 -10940 0 0 {name=p104256 lab=_45787_/A }
C {devices/lab_pin.sym} 104800 -10960 0 1 {name=p104257 lab=_74688_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -10960 0 0 {name=X_74688_ }
C {devices/lab_pin.sym} 104700 -10830 0 0 {name=p104258 lab=_79215_/A }
C {devices/lab_pin.sym} 104780 -10830 0 1 {name=p104259 lab=_79215_/X }
C {sky130_stdcells/buf_2.sym} 104740 -10830 0 0 {name=X_79215_ }
C {devices/lab_pin.sym} 104700 -10710 0 0 {name=p104260 lab=_63158_/B }
C {devices/lab_pin.sym} 104780 -10710 0 1 {name=p104261 lab=_61492_/A }
C {sky130_stdcells/buf_2.sym} 104740 -10710 0 0 {name=X_45607_ }
C {devices/lab_pin.sym} 104680 -10600 0 0 {name=p104262 lab=_81269_/Q }
C {devices/lab_pin.sym} 104680 -10560 0 0 {name=p104263 lab=_81525_/D }
C {devices/lab_pin.sym} 104800 -10580 0 1 {name=p104264 lab=_76430_/B }
C {sky130_stdcells/nor2_4.sym} 104740 -10580 0 0 {name=X_76427_ }
C {devices/lab_pin.sym} 104660 -10490 0 0 {name=p104265 lab=_64432_/Y }
C {devices/lab_pin.sym} 104660 -10450 0 0 {name=p104266 lab=_64434_/X }
C {devices/lab_pin.sym} 104660 -10410 0 0 {name=p104267 lab=_64435_/X }
C {devices/lab_pin.sym} 104660 -10370 0 0 {name=p104268 lab=_64439_/Y }
C {devices/lab_pin.sym} 104660 -10330 0 0 {name=p104269 lab=_64440_/X }
C {devices/lab_pin.sym} 104820 -10410 0 1 {name=p104270 lab=_64441_/X }
C {sky130_stdcells/o41a_4.sym} 104740 -10410 0 0 {name=X_64441_ }
C {devices/lab_pin.sym} 104700 -10250 0 0 {name=p104271 lab=_42818_/Y }
C {devices/lab_pin.sym} 104780 -10250 0 1 {name=p104272 lab=_87702_/D }
C {sky130_stdcells/inv_2.sym} 104740 -10250 0 0 {name=X_42819_ }
C {devices/lab_pin.sym} 104660 -10150 0 0 {name=p104273 lab=_49373_/Y }
C {devices/lab_pin.sym} 104660 -10110 0 0 {name=p104274 lab=_49316_/X }
C {devices/lab_pin.sym} 104660 -10070 0 0 {name=p104275 lab=_49374_/X }
C {devices/lab_pin.sym} 104820 -10110 0 1 {name=p104276 lab=_49375_/Y }
C {sky130_stdcells/a21oi_4.sym} 104740 -10110 0 0 {name=X_49375_ }
C {devices/lab_pin.sym} 104700 -9970 0 0 {name=p104277 lab=_72528_/A }
C {devices/lab_pin.sym} 104780 -9970 0 1 {name=p104278 lab=_61653_/X }
C {sky130_stdcells/buf_2.sym} 104740 -9970 0 0 {name=X_61653_ }
C {devices/lab_pin.sym} 104660 -9880 0 0 {name=p104279 lab=_73609_/X }
C {devices/lab_pin.sym} 104660 -9840 0 0 {name=p104280 lab=_85630_/Q }
C {devices/lab_pin.sym} 104660 -9800 0 0 {name=p104281 lab=_73472_/X }
C {devices/lab_pin.sym} 104660 -9760 0 0 {name=p104282 lab=_73638_/X }
C {devices/lab_pin.sym} 104820 -9820 0 1 {name=p104283 lab=_73639_/X }
C {sky130_stdcells/a211o_4.sym} 104740 -9820 0 0 {name=X_73639_ }
C {devices/lab_pin.sym} 104680 -9680 0 0 {name=p104284 lab=_46547_/A }
C {devices/lab_pin.sym} 104680 -9640 0 0 {name=p104285 lab=_51389_/B }
C {devices/lab_pin.sym} 104800 -9660 0 1 {name=p104286 lab=_46587_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -9660 0 0 {name=X_46587_ }
C {devices/lab_pin.sym} 104700 -9530 0 0 {name=p104287 lab=_43799_/A }
C {devices/lab_pin.sym} 104780 -9530 0 1 {name=p104288 lab=_43799_/Y }
C {sky130_stdcells/inv_2.sym} 104740 -9530 0 0 {name=X_43799_ }
C {devices/lab_pin.sym} 104660 -9430 0 0 {name=p104289 lab=_48320_/Y }
C {devices/lab_pin.sym} 104660 -9390 0 0 {name=p104290 lab=_48322_/X }
C {devices/lab_pin.sym} 104660 -9350 0 0 {name=p104291 lab=_48325_/Y }
C {devices/lab_pin.sym} 104820 -9390 0 1 {name=p104292 lab=_48326_/Y }
C {sky130_stdcells/a21boi_4.sym} 104740 -9390 0 0 {name=X_48326_ }
C {devices/lab_pin.sym} 104660 -9280 0 0 {name=p104293 lab=_79129_/A }
C {devices/lab_pin.sym} 104660 -9240 0 0 {name=p104294 lab=_60577_/X }
C {devices/lab_pin.sym} 104660 -9200 0 0 {name=p104295 lab=_60603_/X }
C {devices/lab_pin.sym} 104660 -9160 0 0 {name=p104296 lab=_60481_/X }
C {devices/lab_pin.sym} 104820 -9220 0 1 {name=p104297 lab=_60604_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 104740 -9220 0 0 {name=X_60604_ }
C {devices/lab_pin.sym} 104700 -9070 0 0 {name=p104298 lab=_67039_/X }
C {devices/lab_pin.sym} 104780 -9070 0 1 {name=p104299 lab=_67160_/X }
C {sky130_stdcells/buf_2.sym} 104740 -9070 0 0 {name=X_67160_ }
C {devices/lab_pin.sym} 104680 -8960 0 0 {name=p104300 lab=_79146_/A }
C {devices/lab_pin.sym} 104680 -8920 0 0 {name=p104301 lab=_84478_/Q }
C {devices/lab_pin.sym} 104800 -8940 0 1 {name=p104302 lab=_79146_/X }
C {sky130_stdcells/xor2_4.sym} 104740 -8940 0 0 {name=X_79146_ }
C {devices/lab_pin.sym} 104680 -8820 0 0 {name=p104303 lab=_85048_/Q }
C {devices/lab_pin.sym} 104680 -8780 0 0 {name=p104304 lab=_45490_/B }
C {devices/lab_pin.sym} 104800 -8800 0 1 {name=p104305 lab=_45538_/Y }
C {sky130_stdcells/nor2_4.sym} 104740 -8800 0 0 {name=X_45538_ }
C {devices/lab_pin.sym} 104660 -8690 0 0 {name=p104306 lab=_79742_/B }
C {devices/lab_pin.sym} 104660 -8650 0 0 {name=p104307 lab=_64314_/X }
C {devices/lab_pin.sym} 104660 -8610 0 0 {name=p104308 lab=_64371_/X }
C {devices/lab_pin.sym} 104820 -8650 0 1 {name=p104309 lab=_64372_/X }
C {sky130_stdcells/a21o_4.sym} 104740 -8650 0 0 {name=X_64372_ }
C {devices/lab_pin.sym} 104680 -8520 0 0 {name=p104310 lab=_76338_/B }
C {devices/lab_pin.sym} 104680 -8480 0 0 {name=p104311 lab=_76357_/Y }
C {devices/lab_pin.sym} 104800 -8500 0 1 {name=p104312 lab=_76358_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -8500 0 0 {name=X_76358_ }
C {devices/lab_pin.sym} 104680 -8380 0 0 {name=p104313 lab=_84844_/Q }
C {devices/lab_pin.sym} 104680 -8340 0 0 {name=p104314 lab=_61323_/B }
C {devices/lab_pin.sym} 104800 -8360 0 1 {name=p104315 lab=_61584_/X }
C {sky130_stdcells/or2_4.sym} 104740 -8360 0 0 {name=X_61584_ }
C {devices/lab_pin.sym} 104700 -8230 0 0 {name=p104316 lab=_58124_/A }
C {devices/lab_pin.sym} 104780 -8230 0 1 {name=p104317 lab=_72155_/A }
C {sky130_stdcells/buf_2.sym} 104740 -8230 0 0 {name=X_66111_ }
C {devices/lab_pin.sym} 104680 -8140 0 0 {name=p104318 lab=_63289_/X }
C {devices/lab_pin.sym} 104680 -8100 0 0 {name=p104319 lab=_64525_/C }
C {devices/lab_pin.sym} 104680 -8060 0 0 {name=p104320 lab=_63341_/C }
C {devices/lab_pin.sym} 104680 -8020 0 0 {name=p104321 lab=_63332_/D }
C {devices/lab_pin.sym} 104800 -8080 0 1 {name=p104322 lab=_63323_/X }
C {sky130_stdcells/and4_4.sym} 104740 -8080 0 0 {name=X_63323_ }
C {devices/lab_pin.sym} 104680 -7940 0 0 {name=p104323 lab=_75309_/A }
C {devices/lab_pin.sym} 104680 -7900 0 0 {name=p104324 lab=_75308_/Y }
C {devices/lab_pin.sym} 104800 -7920 0 1 {name=p104325 lab=_81042_/D }
C {sky130_stdcells/xor2_4.sym} 104740 -7920 0 0 {name=X_75309_ }
C {devices/lab_pin.sym} 104680 -7810 0 0 {name=p104326 lab=_59772_/A }
C {devices/lab_pin.sym} 104680 -7770 0 0 {name=p104327 lab=_59837_/B }
C {devices/lab_pin.sym} 104680 -7730 0 0 {name=p104328 lab=_79144_/A }
C {devices/lab_pin.sym} 104800 -7770 0 1 {name=p104329 lab=_60535_/Y }
C {sky130_stdcells/nor3_4.sym} 104740 -7770 0 0 {name=X_60535_ }
C {devices/lab_pin.sym} 104680 -7640 0 0 {name=p104330 lab=_48229_/A }
C {devices/lab_pin.sym} 104680 -7600 0 0 {name=p104331 lab=_48257_/B }
C {devices/lab_pin.sym} 104800 -7620 0 1 {name=p104332 lab=_48257_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -7620 0 0 {name=X_48257_ }
C {devices/lab_pin.sym} 104660 -7510 0 0 {name=p104333 lab=_84084_/Q }
C {devices/lab_pin.sym} 104660 -7470 0 0 {name=p104334 lab=_66971_/X }
C {devices/lab_pin.sym} 104660 -7430 0 0 {name=p104335 lab=_67090_/X }
C {devices/lab_pin.sym} 104820 -7470 0 1 {name=p104336 lab=_84084_/D }
C {sky130_stdcells/a21bo_4.sym} 104740 -7470 0 0 {name=X_67091_ }
C {devices/lab_pin.sym} 104700 -7330 0 0 {name=p104337 lab=_79076_/Y }
C {devices/lab_pin.sym} 104780 -7330 0 1 {name=p104338 lab=_79077_/Y }
C {sky130_stdcells/inv_2.sym} 104740 -7330 0 0 {name=X_79077_ }
C {devices/lab_pin.sym} 104660 -7230 0 0 {name=p104339 lab=_45462_/X }
C {devices/lab_pin.sym} 104660 -7190 0 0 {name=p104340 lab=_45466_/X }
C {devices/lab_pin.sym} 104660 -7150 0 0 {name=p104341 lab=_45468_/Y }
C {devices/lab_pin.sym} 104820 -7190 0 1 {name=p104342 lab=_86875_/D }
C {sky130_stdcells/a21oi_4.sym} 104740 -7190 0 0 {name=X_45469_ }
C {devices/lab_pin.sym} 104680 -7060 0 0 {name=p104343 lab=_76289_/A }
C {devices/lab_pin.sym} 104680 -7020 0 0 {name=p104344 lab=_81560_/Q }
C {devices/lab_pin.sym} 104800 -7040 0 1 {name=p104345 lab=_76290_/B }
C {sky130_stdcells/xor2_4.sym} 104740 -7040 0 0 {name=X_76289_ }
C {devices/lab_pin.sym} 104700 -6910 0 0 {name=p104346 lab=_82371_/Q }
C {devices/lab_pin.sym} 104780 -6910 0 1 {name=p104347 lab=_47208_/Y }
C {sky130_stdcells/inv_2.sym} 104740 -6910 0 0 {name=X_47208_ }
C {devices/lab_pin.sym} 104660 -6820 0 0 {name=p104348 lab=_66040_/X }
C {devices/lab_pin.sym} 104660 -6780 0 0 {name=p104349 lab=_84984_/Q }
C {devices/lab_pin.sym} 104660 -6740 0 0 {name=p104350 lab=_66027_/X }
C {devices/lab_pin.sym} 104660 -6700 0 0 {name=p104351 lab=_66041_/X }
C {devices/lab_pin.sym} 104820 -6760 0 1 {name=p104352 lab=_66042_/X }
C {sky130_stdcells/a211o_4.sym} 104740 -6760 0 0 {name=X_66042_ }
C {devices/lab_pin.sym} 104680 -6620 0 0 {name=p104353 lab=_82257_/Q }
C {devices/lab_pin.sym} 104680 -6580 0 0 {name=p104354 lab=_81969_/Q }
C {devices/lab_pin.sym} 104800 -6600 0 1 {name=p104355 lab=_78028_/X }
C {sky130_stdcells/xor2_4.sym} 104740 -6600 0 0 {name=X_78028_ }
C {devices/lab_pin.sym} 104700 -6470 0 0 {name=p104356 lab=_63253_/X }
C {devices/lab_pin.sym} 104780 -6470 0 1 {name=p104357 lab=_63254_/Y }
C {sky130_stdcells/inv_2.sym} 104740 -6470 0 0 {name=X_63254_ }
C {devices/lab_pin.sym} 104700 -6350 0 0 {name=p104358 lab=_48478_/A }
C {devices/lab_pin.sym} 104780 -6350 0 1 {name=p104359 lab=_48188_/X }
C {sky130_stdcells/buf_2.sym} 104740 -6350 0 0 {name=X_48188_ }
C {devices/lab_pin.sym} 104700 -6230 0 0 {name=p104360 lab=_60420_/A }
C {devices/lab_pin.sym} 104780 -6230 0 1 {name=p104361 lab=_60466_/X }
C {sky130_stdcells/buf_2.sym} 104740 -6230 0 0 {name=X_60466_ }
C {devices/lab_pin.sym} 104700 -6110 0 0 {name=p104362 lab=_62620_/A }
C {devices/lab_pin.sym} 104780 -6110 0 1 {name=p104363 lab=_62249_/A }
C {sky130_stdcells/buf_2.sym} 104740 -6110 0 0 {name=X_62205_ }
C {devices/lab_pin.sym} 104700 -5990 0 0 {name=p104364 lab=_46902_/A }
C {devices/lab_pin.sym} 104780 -5990 0 1 {name=p104365 lab=_47140_/A }
C {sky130_stdcells/buf_2.sym} 104740 -5990 0 0 {name=X_47139_ }
C {devices/lab_pin.sym} 104680 -5900 0 0 {name=p104366 lab=_59419_/A }
C {devices/lab_pin.sym} 104680 -5860 0 0 {name=p104367 lab=_63170_/X }
C {devices/lab_pin.sym} 104680 -5820 0 0 {name=p104368 lab=_63161_/C }
C {devices/lab_pin.sym} 104680 -5780 0 0 {name=p104369 lab=_63149_/X }
C {devices/lab_pin.sym} 104800 -5840 0 1 {name=p104370 lab=_63185_/X }
C {sky130_stdcells/or4_4.sym} 104740 -5840 0 0 {name=X_63185_ }
C {devices/lab_pin.sym} 104700 -5690 0 0 {name=p104371 lab=_60459_/B }
C {devices/lab_pin.sym} 104780 -5690 0 1 {name=p104372 lab=_60473_/B }
C {sky130_stdcells/buf_2.sym} 104740 -5690 0 0 {name=X_60397_ }
C {devices/lab_pin.sym} 104660 -5590 0 0 {name=p104373 lab=_69374_/X }
C {devices/lab_pin.sym} 104660 -5550 0 0 {name=p104374 lab=_69377_/X }
C {devices/lab_pin.sym} 104660 -5510 0 0 {name=p104375 lab=_69728_/X }
C {devices/lab_pin.sym} 104820 -5550 0 1 {name=p104376 lab=_69801_/Y }
C {sky130_stdcells/a21oi_4.sym} 104740 -5550 0 0 {name=X_69801_ }
C {devices/lab_pin.sym} 104660 -5430 0 0 {name=p104377 lab=_65096_/B }
C {devices/lab_pin.sym} 104660 -5390 0 0 {name=p104378 lab=_50137_/X }
C {devices/lab_pin.sym} 104660 -5350 0 0 {name=p104379 lab=_50149_/Y }
C {devices/lab_pin.sym} 104820 -5390 0 1 {name=p104380 lab=_50150_/Y }
C {sky130_stdcells/o21ai_4.sym} 104740 -5390 0 0 {name=X_50150_ }
C {devices/lab_pin.sym} 104680 -5280 0 0 {name=p104381 lab=_61949_/A }
C {devices/lab_pin.sym} 104680 -5240 0 0 {name=p104382 lab=_62170_/B }
C {devices/lab_pin.sym} 104680 -5200 0 0 {name=p104383 lab=_62158_/C }
C {devices/lab_pin.sym} 104680 -5160 0 0 {name=p104384 lab=_63314_/B }
C {devices/lab_pin.sym} 104800 -5220 0 1 {name=p104385 lab=_62136_/X }
C {sky130_stdcells/and4_4.sym} 104740 -5220 0 0 {name=X_62136_ }
C {devices/lab_pin.sym} 104660 -5100 0 0 {name=p104386 lab=_87140_/Q }
C {devices/lab_pin.sym} 104660 -5060 0 0 {name=p104387 lab=_67942_/X }
C {devices/lab_pin.sym} 104660 -5020 0 0 {name=p104388 lab=_67991_/X }
C {devices/lab_pin.sym} 104660 -4980 0 0 {name=p104389 lab=_67992_/X }
C {devices/lab_pin.sym} 104820 -5040 0 1 {name=p104390 lab=_67993_/X }
C {sky130_stdcells/a211o_4.sym} 104740 -5040 0 0 {name=X_67993_ }
C {devices/lab_pin.sym} 104680 -4900 0 0 {name=p104391 lab=_79978_/Y }
C {devices/lab_pin.sym} 104680 -4860 0 0 {name=p104392 lab=_79968_/Y }
C {devices/lab_pin.sym} 104800 -4880 0 1 {name=p104393 lab=_79980_/B }
C {sky130_stdcells/nand2_4.sym} 104740 -4880 0 0 {name=X_79979_ }
C {devices/lab_pin.sym} 104700 -4750 0 0 {name=p104394 lab=_64732_/A }
C {devices/lab_pin.sym} 104780 -4750 0 1 {name=p104395 lab=_69732_/X }
C {sky130_stdcells/buf_2.sym} 104740 -4750 0 0 {name=X_69732_ }
C {devices/lab_pin.sym} 104660 -4650 0 0 {name=p104396 lab=_64755_/B }
C {devices/lab_pin.sym} 104660 -4610 0 0 {name=p104397 lab=_50061_/X }
C {devices/lab_pin.sym} 104660 -4570 0 0 {name=p104398 lab=_50080_/Y }
C {devices/lab_pin.sym} 104820 -4610 0 1 {name=p104399 lab=_50081_/Y }
C {sky130_stdcells/o21ai_4.sym} 104740 -4610 0 0 {name=X_50081_ }
C {devices/lab_pin.sym} 104660 -4490 0 0 {name=p104400 lab=_66940_/X }
C {devices/lab_pin.sym} 104660 -4450 0 0 {name=p104401 lab=_66943_/X }
C {devices/lab_pin.sym} 104660 -4410 0 0 {name=p104402 lab=_66871_/X }
C {devices/lab_pin.sym} 104820 -4450 0 1 {name=p104403 lab=_66944_/Y }
C {sky130_stdcells/a21oi_4.sym} 104740 -4450 0 0 {name=X_66944_ }
C {devices/lab_pin.sym} 104660 -4350 0 0 {name=p104404 lab=_62056_/X }
C {devices/lab_pin.sym} 104660 -4310 0 0 {name=p104405 lab=_62058_/X }
C {devices/lab_pin.sym} 104660 -4270 0 0 {name=p104406 lab=_62066_/Y }
C {devices/lab_pin.sym} 104660 -4230 0 0 {name=p104407 lab=_58457_/A }
C {devices/lab_pin.sym} 104660 -4190 0 0 {name=p104408 lab=_62048_/X }
C {devices/lab_pin.sym} 104820 -4270 0 1 {name=p104409 lab=_62067_/Y }
C {sky130_stdcells/o32ai_4.sym} 104740 -4270 0 0 {name=X_62067_ }
C {devices/lab_pin.sym} 104700 -4110 0 0 {name=p104410 lab=clkbuf_9_507_0_CLK/X }
C {devices/lab_pin.sym} 104780 -4110 0 1 {name=p104411 lab=_85581_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 104740 -4110 0 0 {name=Xclkbuf_10_1014_0_CLK }
C {devices/lab_pin.sym} 104650 -3990 0 0 {name=p104412 lab=_85134_/CLK }
C {devices/lab_pin.sym} 104650 -3970 0 0 {name=p104413 lab=_74672_/Y }
C {devices/lab_pin.sym} 104830 -3990 0 1 {name=p104414 lab=_82990_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -3980 0 0 {name=X_82990_ }
C {devices/lab_pin.sym} 104680 -3860 0 0 {name=p104415 lab=_60866_/A }
C {devices/lab_pin.sym} 104680 -3820 0 0 {name=p104416 lab=_60962_/A }
C {devices/lab_pin.sym} 104800 -3840 0 1 {name=p104417 lab=_61018_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -3840 0 0 {name=X_61018_ }
C {devices/lab_pin.sym} 104650 -3710 0 0 {name=p104418 lab=_82131_/CLK }
C {devices/lab_pin.sym} 104650 -3690 0 0 {name=p104419 lab=_81941_/D }
C {devices/lab_pin.sym} 104830 -3710 0 1 {name=p104420 lab=_81941_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -3700 0 0 {name=X_81941_ }
C {devices/lab_pin.sym} 104660 -3590 0 0 {name=p104421 lab=_69660_/X }
C {devices/lab_pin.sym} 104660 -3550 0 0 {name=p104422 lab=_69662_/X }
C {devices/lab_pin.sym} 104660 -3510 0 0 {name=p104423 lab=_68697_/X }
C {devices/lab_pin.sym} 104820 -3550 0 1 {name=p104424 lab=_69663_/X }
C {sky130_stdcells/a21o_4.sym} 104740 -3550 0 0 {name=X_69663_ }
C {devices/lab_pin.sym} 104700 -3410 0 0 {name=p104425 lab=_66758_/X }
C {devices/lab_pin.sym} 104780 -3410 0 1 {name=p104426 lab=_66875_/X }
C {sky130_stdcells/buf_2.sym} 104740 -3410 0 0 {name=X_66875_ }
C {devices/lab_pin.sym} 104700 -3290 0 0 {name=p104427 lab=_68614_/A }
C {devices/lab_pin.sym} 104780 -3290 0 1 {name=p104428 lab=_69685_/A }
C {sky130_stdcells/buf_2.sym} 104740 -3290 0 0 {name=X_68614_ }
C {devices/lab_pin.sym} 104660 -3190 0 0 {name=p104429 lab=_53837_/Y }
C {devices/lab_pin.sym} 104660 -3150 0 0 {name=p104430 lab=_53838_/X }
C {devices/lab_pin.sym} 104660 -3110 0 0 {name=p104431 lab=_53839_/Y }
C {devices/lab_pin.sym} 104820 -3150 0 1 {name=p104432 lab=_53840_/Y }
C {sky130_stdcells/a21boi_4.sym} 104740 -3150 0 0 {name=X_53840_ }
C {devices/lab_pin.sym} 104660 -3040 0 0 {name=p104433 lab=_65824_/X }
C {devices/lab_pin.sym} 104660 -3000 0 0 {name=p104434 lab=_83055_/Q }
C {devices/lab_pin.sym} 104660 -2960 0 0 {name=p104435 lab=_65707_/X }
C {devices/lab_pin.sym} 104660 -2920 0 0 {name=p104436 lab=_65825_/X }
C {devices/lab_pin.sym} 104820 -2980 0 1 {name=p104437 lab=_65827_/B }
C {sky130_stdcells/a211o_4.sym} 104740 -2980 0 0 {name=X_65826_ }
C {devices/lab_pin.sym} 104650 -2830 0 0 {name=p104438 lab=_84660_/CLK }
C {devices/lab_pin.sym} 104650 -2810 0 0 {name=p104439 lab=_60108_/Y }
C {devices/lab_pin.sym} 104830 -2830 0 1 {name=p104440 lab=_60107_/C }
C {sky130_stdcells/dfxtp_4.sym} 104740 -2820 0 0 {name=X_84660_ }
C {devices/lab_pin.sym} 104650 -2690 0 0 {name=p104441 lab=_81872_/CLK }
C {devices/lab_pin.sym} 104650 -2670 0 0 {name=p104442 lab=_78063_/X }
C {devices/lab_pin.sym} 104830 -2690 0 1 {name=p104443 lab=_81840_/D }
C {sky130_stdcells/dfxtp_4.sym} 104740 -2680 0 0 {name=X_81872_ }
C {devices/lab_pin.sym} 104680 -2560 0 0 {name=p104444 lab=_68360_/X }
C {devices/lab_pin.sym} 104680 -2520 0 0 {name=p104445 lab=_42548_/Y }
C {devices/lab_pin.sym} 104800 -2540 0 1 {name=p104446 lab=_69594_/Y }
C {sky130_stdcells/nor2_4.sym} 104740 -2540 0 0 {name=X_69594_ }
C {devices/lab_pin.sym} 104650 -2410 0 0 {name=p104447 lab=_83613_/CLK }
C {devices/lab_pin.sym} 104650 -2390 0 0 {name=p104448 lab=_71089_/Y }
C {devices/lab_pin.sym} 104830 -2410 0 1 {name=p104449 lab=_83611_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -2400 0 0 {name=X_83611_ }
C {devices/lab_pin.sym} 104700 -2270 0 0 {name=p104450 lab=_68517_/A }
C {devices/lab_pin.sym} 104780 -2270 0 1 {name=p104451 lab=_68545_/X }
C {sky130_stdcells/buf_2.sym} 104740 -2270 0 0 {name=X_68545_ }
C {devices/lab_pin.sym} 104650 -2150 0 0 {name=p104452 lab=_80962_/CLK }
C {devices/lab_pin.sym} 104650 -2130 0 0 {name=p104453 lab=_83967_/Q }
C {devices/lab_pin.sym} 104830 -2150 0 1 {name=p104454 lab=_75612_/B }
C {sky130_stdcells/dfxtp_4.sym} 104740 -2140 0 0 {name=X_80823_ }
C {devices/lab_pin.sym} 104660 -2030 0 0 {name=p104455 lab=_85571_/Q }
C {devices/lab_pin.sym} 104660 -1990 0 0 {name=p104456 lab=_53754_/X }
C {devices/lab_pin.sym} 104660 -1950 0 0 {name=p104457 lab=_53770_/Y }
C {devices/lab_pin.sym} 104820 -1990 0 1 {name=p104458 lab=_53771_/Y }
C {sky130_stdcells/o21ai_4.sym} 104740 -1990 0 0 {name=X_53771_ }
C {devices/lab_pin.sym} 104700 -1850 0 0 {name=p104459 lab=_65757_/A }
C {devices/lab_pin.sym} 104780 -1850 0 1 {name=p104460 lab=_65757_/X }
C {sky130_stdcells/buf_2.sym} 104740 -1850 0 0 {name=X_65757_ }
C {devices/lab_pin.sym} 104650 -1730 0 0 {name=p104461 lab=_84458_/CLK }
C {devices/lab_pin.sym} 104650 -1710 0 0 {name=p104462 lab=_60597_/Y }
C {devices/lab_pin.sym} 104830 -1730 0 1 {name=p104463 lab=_79131_/A }
C {sky130_stdcells/dfxtp_4.sym} 104740 -1720 0 0 {name=X_84591_ }
C {devices/lab_pin.sym} 104700 -1590 0 0 {name=p104464 lab=_50957_/A }
C {devices/lab_pin.sym} 104780 -1590 0 1 {name=p104465 lab=_50983_/X }
C {sky130_stdcells/buf_2.sym} 104740 -1590 0 0 {name=X_50983_ }
C {devices/lab_pin.sym} 104680 -1490 0 0 {name=p104466 lab=_62988_/A }
C {devices/lab_pin.sym} 104680 -1450 0 0 {name=p104467 lab=_62988_/B }
C {devices/lab_pin.sym} 104680 -1410 0 0 {name=p104468 lab=_84365_/Q }
C {devices/lab_pin.sym} 104800 -1450 0 1 {name=p104469 lab=_62969_/Y }
C {sky130_stdcells/nor3_4.sym} 104740 -1450 0 0 {name=X_62969_ }
C {devices/lab_pin.sym} 104700 -1310 0 0 {name=p104470 lab=_55470_/A }
C {devices/lab_pin.sym} 104780 -1310 0 1 {name=p104471 lab=_55510_/X }
C {sky130_stdcells/buf_2.sym} 104740 -1310 0 0 {name=X_55510_ }
C {devices/lab_pin.sym} 104650 -1190 0 0 {name=p104472 lab=_86647_/CLK }
C {devices/lab_pin.sym} 104650 -1170 0 0 {name=p104473 lab=_49752_/Y }
C {devices/lab_pin.sym} 104830 -1190 0 1 {name=p104474 lab=_57832_/B }
C {sky130_stdcells/dfxtp_4.sym} 104740 -1180 0 0 {name=X_86330_ }
C {devices/lab_pin.sym} 104680 -1060 0 0 {name=p104475 lab=_52718_/A }
C {devices/lab_pin.sym} 104680 -1020 0 0 {name=p104476 lab=_52722_/B }
C {devices/lab_pin.sym} 104800 -1040 0 1 {name=p104477 lab=_52722_/Y }
C {sky130_stdcells/nand2_4.sym} 104740 -1040 0 0 {name=X_52722_ }
C {devices/lab_pin.sym} 104700 -910 0 0 {name=p104478 lab=_58784_/A }
C {devices/lab_pin.sym} 104780 -910 0 1 {name=p104479 lab=_64898_/A }
C {sky130_stdcells/buf_2.sym} 104740 -910 0 0 {name=X_64708_ }
C {devices/lab_pin.sym} 104650 -790 0 0 {name=p104480 lab=_86222_/CLK }
C {devices/lab_pin.sym} 104650 -770 0 0 {name=p104481 lab=_83542_/D }
C {devices/lab_pin.sym} 104830 -790 0 1 {name=p104482 lab=_83542_/Q }
C {sky130_stdcells/dfxtp_4.sym} 104740 -780 0 0 {name=X_83542_ }
C {devices/lab_pin.sym} 105600 -42170 0 0 {name=p104483 lab=_56487_/X }
C {devices/lab_pin.sym} 105600 -42130 0 0 {name=p104484 lab=_56484_/X }
C {devices/lab_pin.sym} 105600 -42090 0 0 {name=p104485 lab=_85176_/Q }
C {devices/lab_pin.sym} 105720 -42130 0 1 {name=p104486 lab=_56490_/Y }
C {sky130_stdcells/nand3_4.sym} 105660 -42130 0 0 {name=X_56490_ }
C {devices/lab_pin.sym} 105570 -41990 0 0 {name=p104487 lab=_80754_/CLK }
C {devices/lab_pin.sym} 105570 -41970 0 0 {name=p104488 lab=_80754_/D }
C {devices/lab_pin.sym} 105750 -41990 0 1 {name=p104489 lab=_81130_/D }
C {sky130_stdcells/dfxtp_4.sym} 105660 -41980 0 0 {name=X_80754_ }
C {devices/lab_pin.sym} 105580 -41880 0 0 {name=p104490 lab=_87003_/Q }
C {devices/lab_pin.sym} 105580 -41840 0 0 {name=p104491 lab=_68472_/X }
C {devices/lab_pin.sym} 105580 -41800 0 0 {name=p104492 lab=_68473_/X }
C {devices/lab_pin.sym} 105580 -41760 0 0 {name=p104493 lab=_68475_/X }
C {devices/lab_pin.sym} 105740 -41820 0 1 {name=p104494 lab=_68476_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -41820 0 0 {name=X_68476_ }
C {devices/lab_pin.sym} 105580 -41700 0 0 {name=p104495 lab=_65685_/X }
C {devices/lab_pin.sym} 105580 -41660 0 0 {name=p104496 lab=_86192_/Q }
C {devices/lab_pin.sym} 105580 -41620 0 0 {name=p104497 lab=_65534_/X }
C {devices/lab_pin.sym} 105580 -41580 0 0 {name=p104498 lab=_65687_/X }
C {devices/lab_pin.sym} 105740 -41640 0 1 {name=p104499 lab=_65688_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -41640 0 0 {name=X_65688_ }
C {devices/lab_pin.sym} 105600 -41510 0 0 {name=p104500 lab=_55441_/A }
C {devices/lab_pin.sym} 105600 -41470 0 0 {name=p104501 lab=_55441_/B }
C {devices/lab_pin.sym} 105600 -41430 0 0 {name=p104502 lab=_55441_/C }
C {devices/lab_pin.sym} 105720 -41470 0 1 {name=p104503 lab=_55442_/A }
C {sky130_stdcells/nand3_4.sym} 105660 -41470 0 0 {name=X_55441_ }
C {devices/lab_pin.sym} 105600 -41340 0 0 {name=p104504 lab=_67333_/A }
C {devices/lab_pin.sym} 105600 -41300 0 0 {name=p104505 lab=_87663_/Q }
C {devices/lab_pin.sym} 105720 -41320 0 1 {name=p104506 lab=_67427_/X }
C {sky130_stdcells/and2_4.sym} 105660 -41320 0 0 {name=X_67427_ }
C {devices/lab_pin.sym} 105570 -41190 0 0 {name=p104507 lab=_85555_/CLK }
C {devices/lab_pin.sym} 105570 -41170 0 0 {name=p104508 lab=_86261_/D }
C {devices/lab_pin.sym} 105750 -41190 0 1 {name=p104509 lab=_64931_/B }
C {sky130_stdcells/dfxtp_4.sym} 105660 -41180 0 0 {name=X_86261_ }
C {devices/lab_pin.sym} 105620 -41050 0 0 {name=p104510 lab=_52626_/A }
C {devices/lab_pin.sym} 105700 -41050 0 1 {name=p104511 lab=_52654_/C }
C {sky130_stdcells/buf_2.sym} 105660 -41050 0 0 {name=X_52653_ }
C {devices/lab_pin.sym} 105580 -40950 0 0 {name=p104512 lab=_64634_/Y }
C {devices/lab_pin.sym} 105580 -40910 0 0 {name=p104513 lab=_60349_/X }
C {devices/lab_pin.sym} 105580 -40870 0 0 {name=p104514 lab=_64638_/X }
C {devices/lab_pin.sym} 105740 -40910 0 1 {name=p104515 lab=_84232_/D }
C {sky130_stdcells/a21o_4.sym} 105660 -40910 0 0 {name=X_64639_ }
C {devices/lab_pin.sym} 105570 -40770 0 0 {name=p104516 lab=_86600_/CLK }
C {devices/lab_pin.sym} 105570 -40750 0 0 {name=p104517 lab=_83473_/D }
C {devices/lab_pin.sym} 105750 -40770 0 1 {name=p104518 lab=_47751_/A }
C {sky130_stdcells/dfxtp_4.sym} 105660 -40760 0 0 {name=X_83473_ }
C {devices/lab_pin.sym} 105570 -40630 0 0 {name=p104519 lab=_81074_/CLK }
C {devices/lab_pin.sym} 105570 -40610 0 0 {name=p104520 lab=_80685_/D }
C {devices/lab_pin.sym} 105750 -40630 0 1 {name=p104521 lab=_75226_/A }
C {sky130_stdcells/dfxtp_4.sym} 105660 -40620 0 0 {name=X_80685_ }
C {devices/lab_pin.sym} 105570 -40490 0 0 {name=p104522 lab=_88001_/CLK }
C {devices/lab_pin.sym} 105570 -40470 0 0 {name=p104523 lab=_88000_/D }
C {devices/lab_pin.sym} 105750 -40490 0 1 {name=p104524 lab=_88000_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -40480 0 0 {name=X_88000_ }
C {devices/lab_pin.sym} 105570 -40350 0 0 {name=p104525 lab=_85244_/CLK }
C {devices/lab_pin.sym} 105570 -40330 0 0 {name=p104526 lab=_85212_/D }
C {devices/lab_pin.sym} 105750 -40350 0 1 {name=p104527 lab=_56390_/C }
C {sky130_stdcells/dfxtp_4.sym} 105660 -40340 0 0 {name=X_85212_ }
C {devices/lab_pin.sym} 105580 -40230 0 0 {name=p104528 lab=_51601_/Y }
C {devices/lab_pin.sym} 105580 -40190 0 0 {name=p104529 lab=_51585_/X }
C {devices/lab_pin.sym} 105580 -40150 0 0 {name=p104530 lab=_51603_/X }
C {devices/lab_pin.sym} 105740 -40190 0 1 {name=p104531 lab=_85980_/D }
C {sky130_stdcells/a21oi_4.sym} 105660 -40190 0 0 {name=X_51604_ }
C {devices/lab_pin.sym} 105600 -40060 0 0 {name=p104532 lab=_61368_/A }
C {devices/lab_pin.sym} 105600 -40020 0 0 {name=p104533 lab=_58160_/B }
C {devices/lab_pin.sym} 105720 -40040 0 1 {name=p104534 lab=_58160_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -40040 0 0 {name=X_58160_ }
C {sky130_stdcells/decap_3.sym} 105660 -39880 0 0 {name=XPHY_605 }
C {devices/lab_pin.sym} 105570 -39730 0 0 {name=p104535 lab=_84177_/CLK }
C {devices/lab_pin.sym} 105570 -39710 0 0 {name=p104536 lab=_82456_/Q }
C {devices/lab_pin.sym} 105750 -39730 0 1 {name=p104537 lab=_78630_/A }
C {sky130_stdcells/dfxtp_4.sym} 105660 -39720 0 0 {name=X_82424_ }
C {devices/lab_pin.sym} 105620 -39590 0 0 {name=p104538 lab=_55371_/X }
C {devices/lab_pin.sym} 105700 -39590 0 1 {name=p104539 lab=_55375_/A }
C {sky130_stdcells/inv_2.sym} 105660 -39590 0 0 {name=X_55372_ }
C {devices/lab_pin.sym} 105620 -39470 0 0 {name=p104540 lab=_67120_/X }
C {devices/lab_pin.sym} 105700 -39470 0 1 {name=p104541 lab=_67358_/X }
C {sky130_stdcells/buf_2.sym} 105660 -39470 0 0 {name=X_67358_ }
C {devices/lab_pin.sym} 105570 -39350 0 0 {name=p104542 lab=_83562_/CLK }
C {devices/lab_pin.sym} 105570 -39330 0 0 {name=p104543 lab=_50484_/Y }
C {devices/lab_pin.sym} 105750 -39350 0 1 {name=p104544 lab=_86192_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -39340 0 0 {name=X_86192_ }
C {devices/lab_pin.sym} 105600 -39240 0 0 {name=p104545 lab=_52588_/A }
C {devices/lab_pin.sym} 105600 -39200 0 0 {name=p104546 lab=_52594_/B }
C {devices/lab_pin.sym} 105600 -39160 0 0 {name=p104547 lab=_51919_/C }
C {devices/lab_pin.sym} 105600 -39120 0 0 {name=p104548 lab=_51756_/D }
C {devices/lab_pin.sym} 105720 -39180 0 1 {name=p104549 lab=_52584_/X }
C {sky130_stdcells/and4_4.sym} 105660 -39180 0 0 {name=X_52584_ }
C {sky130_stdcells/decap_3.sym} 105660 -39000 0 0 {name=XPHY_616 }
C {sky130_stdcells/decap_3.sym} 105660 -38820 0 0 {name=XPHY_627 }
C {sky130_stdcells/decap_3.sym} 105660 -38640 0 0 {name=XPHY_638 }
C {devices/lab_pin.sym} 105580 -38520 0 0 {name=p104550 lab=_57109_/X }
C {devices/lab_pin.sym} 105580 -38480 0 0 {name=p104551 lab=_56607_/X }
C {devices/lab_pin.sym} 105580 -38440 0 0 {name=p104552 lab=_45500_/A }
C {devices/lab_pin.sym} 105580 -38400 0 0 {name=p104553 lab=_57110_/X }
C {devices/lab_pin.sym} 105740 -38460 0 1 {name=p104554 lab=_85082_/D }
C {sky130_stdcells/a2bb2o_4.sym} 105660 -38460 0 0 {name=X_57111_ }
C {devices/lab_pin.sym} 105600 -38320 0 0 {name=p104555 lab=_54332_/A }
C {devices/lab_pin.sym} 105600 -38280 0 0 {name=p104556 lab=_52632_/B }
C {devices/lab_pin.sym} 105720 -38300 0 1 {name=p104557 lab=_54323_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -38300 0 0 {name=X_54323_ }
C {devices/lab_pin.sym} 105580 -38200 0 0 {name=p104558 lab=_66266_/X }
C {devices/lab_pin.sym} 105580 -38160 0 0 {name=p104559 lab=_86213_/Q }
C {devices/lab_pin.sym} 105580 -38120 0 0 {name=p104560 lab=_66295_/X }
C {devices/lab_pin.sym} 105580 -38080 0 0 {name=p104561 lab=_66308_/X }
C {devices/lab_pin.sym} 105740 -38140 0 1 {name=p104562 lab=_66309_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -38140 0 0 {name=X_66309_ }
C {sky130_stdcells/decap_3.sym} 105660 -37960 0 0 {name=XPHY_649 }
C {devices/lab_pin.sym} 105570 -37810 0 0 {name=p104563 lab=_85057_/CLK }
C {devices/lab_pin.sym} 105570 -37790 0 0 {name=p104564 lab=_56628_/Y }
C {devices/lab_pin.sym} 105750 -37810 0 1 {name=p104565 lab=_56627_/B }
C {sky130_stdcells/dfxtp_4.sym} 105660 -37800 0 0 {name=X_85143_ }
C {devices/lab_pin.sym} 105600 -37680 0 0 {name=p104566 lab=_51514_/A }
C {devices/lab_pin.sym} 105600 -37640 0 0 {name=p104567 lab=_53060_/B }
C {devices/lab_pin.sym} 105720 -37660 0 1 {name=p104568 lab=_51535_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -37660 0 0 {name=X_51535_ }
C {devices/lab_pin.sym} 105580 -37550 0 0 {name=p104569 lab=_58043_/X }
C {devices/lab_pin.sym} 105580 -37510 0 0 {name=p104570 lab=_85990_/Q }
C {devices/lab_pin.sym} 105580 -37470 0 0 {name=p104571 lab=_58090_/X }
C {devices/lab_pin.sym} 105740 -37510 0 1 {name=p104572 lab=_58091_/Y }
C {sky130_stdcells/o21ai_4.sym} 105660 -37510 0 0 {name=X_58091_ }
C {devices/lab_pin.sym} 105570 -37370 0 0 {name=p104573 lab=_82343_/CLK }
C {devices/lab_pin.sym} 105570 -37350 0 0 {name=p104574 lab=_77178_/X }
C {devices/lab_pin.sym} 105750 -37370 0 1 {name=p104575 lab=_47982_/A }
C {sky130_stdcells/dfxtp_4.sym} 105660 -37360 0 0 {name=X_82355_ }
C {devices/lab_pin.sym} 105580 -37250 0 0 {name=p104576 lab=_67286_/X }
C {devices/lab_pin.sym} 105580 -37210 0 0 {name=p104577 lab=_67288_/X }
C {devices/lab_pin.sym} 105580 -37170 0 0 {name=p104578 lab=_67264_/X }
C {devices/lab_pin.sym} 105740 -37210 0 1 {name=p104579 lab=_67292_/A }
C {sky130_stdcells/a21o_4.sym} 105660 -37210 0 0 {name=X_67289_ }
C {devices/lab_pin.sym} 105570 -37070 0 0 {name=p104580 lab=_81304_/CLK }
C {devices/lab_pin.sym} 105570 -37050 0 0 {name=p104581 lab=_76994_/X }
C {devices/lab_pin.sym} 105750 -37070 0 1 {name=p104582 lab=_81306_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -37060 0 0 {name=X_81306_ }
C {devices/lab_pin.sym} 105620 -36930 0 0 {name=p104583 lab=_56837_/X }
C {devices/lab_pin.sym} 105700 -36930 0 1 {name=p104584 lab=_57331_/C }
C {sky130_stdcells/buf_2.sym} 105660 -36930 0 0 {name=X_57042_ }
C {devices/lab_pin.sym} 105580 -36840 0 0 {name=p104585 lab=_44738_/A }
C {devices/lab_pin.sym} 105580 -36800 0 0 {name=p104586 lab=_68818_/X }
C {devices/lab_pin.sym} 105580 -36760 0 0 {name=p104587 lab=_68819_/X }
C {devices/lab_pin.sym} 105580 -36720 0 0 {name=p104588 lab=_69027_/X }
C {devices/lab_pin.sym} 105740 -36780 0 1 {name=p104589 lab=_69029_/B }
C {sky130_stdcells/a211o_4.sym} 105660 -36780 0 0 {name=X_69028_ }
C {devices/lab_pin.sym} 105620 -36630 0 0 {name=p104590 lab=_54254_/A }
C {devices/lab_pin.sym} 105700 -36630 0 1 {name=p104591 lab=_54255_/C }
C {sky130_stdcells/buf_2.sym} 105660 -36630 0 0 {name=X_54254_ }
C {devices/lab_pin.sym} 105570 -36510 0 0 {name=p104592 lab=_85074_/CLK }
C {devices/lab_pin.sym} 105570 -36490 0 0 {name=p104593 lab=_85074_/D }
C {devices/lab_pin.sym} 105750 -36510 0 1 {name=p104594 lab=_85074_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -36500 0 0 {name=X_85074_ }
C {devices/lab_pin.sym} 105620 -36370 0 0 {name=p104595 lab=_51218_/X }
C {devices/lab_pin.sym} 105700 -36370 0 1 {name=p104596 lab=_51473_/A }
C {sky130_stdcells/buf_2.sym} 105660 -36370 0 0 {name=X_51466_ }
C {devices/lab_pin.sym} 105570 -36250 0 0 {name=p104597 lab=_82288_/CLK }
C {devices/lab_pin.sym} 105570 -36230 0 0 {name=p104598 lab=_81910_/Q }
C {devices/lab_pin.sym} 105750 -36250 0 1 {name=p104599 lab=_82286_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -36240 0 0 {name=X_82286_ }
C {devices/lab_pin.sym} 105600 -36120 0 0 {name=p104600 lab=_53219_/A }
C {devices/lab_pin.sym} 105600 -36080 0 0 {name=p104601 lab=_53205_/B }
C {devices/lab_pin.sym} 105720 -36100 0 1 {name=p104602 lab=_53205_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -36100 0 0 {name=X_53205_ }
C {devices/lab_pin.sym} 105570 -35970 0 0 {name=p104603 lab=_81169_/CLK }
C {devices/lab_pin.sym} 105570 -35950 0 0 {name=p104604 lab=_84025_/D }
C {devices/lab_pin.sym} 105750 -35970 0 1 {name=p104605 lab=_82065_/D }
C {sky130_stdcells/dfxtp_4.sym} 105660 -35960 0 0 {name=X_84025_ }
C {devices/lab_pin.sym} 105600 -35840 0 0 {name=p104606 lab=_50556_/A }
C {devices/lab_pin.sym} 105600 -35800 0 0 {name=p104607 lab=_52119_/B }
C {devices/lab_pin.sym} 105720 -35820 0 1 {name=p104608 lab=_50417_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -35820 0 0 {name=X_50417_ }
C {devices/lab_pin.sym} 105570 -35690 0 0 {name=p104609 lab=_85332_/CLK }
C {devices/lab_pin.sym} 105570 -35670 0 0 {name=p104610 lab=_81045_/Q }
C {devices/lab_pin.sym} 105750 -35690 0 1 {name=p104611 lab=_81237_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -35680 0 0 {name=X_81237_ }
C {devices/lab_pin.sym} 105580 -35570 0 0 {name=p104612 lab=_85488_/Q }
C {devices/lab_pin.sym} 105580 -35530 0 0 {name=p104613 lab=_54167_/X }
C {devices/lab_pin.sym} 105580 -35490 0 0 {name=p104614 lab=_54184_/Y }
C {devices/lab_pin.sym} 105740 -35530 0 1 {name=p104615 lab=_54185_/Y }
C {sky130_stdcells/o21ai_4.sym} 105660 -35530 0 0 {name=X_54185_ }
C {devices/lab_pin.sym} 105580 -35410 0 0 {name=p104616 lab=_51395_/Y }
C {devices/lab_pin.sym} 105580 -35370 0 0 {name=p104617 lab=_51391_/X }
C {devices/lab_pin.sym} 105580 -35330 0 0 {name=p104618 lab=_51396_/X }
C {devices/lab_pin.sym} 105740 -35370 0 1 {name=p104619 lab=_51397_/Y }
C {sky130_stdcells/a21oi_4.sym} 105660 -35370 0 0 {name=X_51397_ }
C {devices/lab_pin.sym} 105620 -35230 0 0 {name=p104620 lab=clkbuf_9_340_0_CLK/X }
C {devices/lab_pin.sym} 105700 -35230 0 1 {name=p104621 lab=_87646_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 105660 -35230 0 0 {name=Xclkbuf_10_681_0_CLK }
C {devices/lab_pin.sym} 105580 -35130 0 0 {name=p104622 lab=_41143_/X }
C {devices/lab_pin.sym} 105580 -35090 0 0 {name=p104623 lab=_40624_/A }
C {devices/lab_pin.sym} 105580 -35050 0 0 {name=p104624 lab=_41149_/X }
C {devices/lab_pin.sym} 105740 -35090 0 1 {name=p104625 lab=_41151_/A }
C {sky130_stdcells/o21ai_4.sym} 105660 -35090 0 0 {name=X_41150_ }
C {devices/lab_pin.sym} 105580 -34970 0 0 {name=p104626 lab=_85690_/Q }
C {devices/lab_pin.sym} 105580 -34930 0 0 {name=p104627 lab=_53120_/X }
C {devices/lab_pin.sym} 105580 -34890 0 0 {name=p104628 lab=_53135_/Y }
C {devices/lab_pin.sym} 105740 -34930 0 1 {name=p104629 lab=_53136_/Y }
C {sky130_stdcells/o21ai_4.sym} 105660 -34930 0 0 {name=X_53136_ }
C {devices/lab_pin.sym} 105580 -34810 0 0 {name=p104630 lab=_50346_/Y }
C {devices/lab_pin.sym} 105580 -34770 0 0 {name=p104631 lab=_50313_/X }
C {devices/lab_pin.sym} 105580 -34730 0 0 {name=p104632 lab=_50347_/X }
C {devices/lab_pin.sym} 105740 -34770 0 1 {name=p104633 lab=_86219_/D }
C {sky130_stdcells/a21oi_4.sym} 105660 -34770 0 0 {name=X_50348_ }
C {devices/lab_pin.sym} 105570 -34630 0 0 {name=p104634 lab=_81179_/CLK }
C {devices/lab_pin.sym} 105570 -34610 0 0 {name=p104635 lab=_74949_/B }
C {devices/lab_pin.sym} 105750 -34630 0 1 {name=p104636 lab=_81168_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -34620 0 0 {name=X_81168_ }
C {devices/lab_pin.sym} 105620 -34490 0 0 {name=p104637 lab=_62186_/A }
C {devices/lab_pin.sym} 105700 -34490 0 1 {name=p104638 lab=_58993_/Y }
C {sky130_stdcells/inv_2.sym} 105660 -34490 0 0 {name=X_58993_ }
C {devices/lab_pin.sym} 105620 -34370 0 0 {name=p104639 lab=clkbuf_8_86_0_CLK/X }
C {devices/lab_pin.sym} 105700 -34370 0 1 {name=p104640 lab=clkbuf_9_172_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 105660 -34370 0 0 {name=Xclkbuf_9_172_0_CLK }
C {devices/lab_pin.sym} 105580 -34270 0 0 {name=p104641 lab=_80098_/B }
C {devices/lab_pin.sym} 105580 -34230 0 0 {name=p104642 lab=_80115_/X }
C {devices/lab_pin.sym} 105580 -34190 0 0 {name=p104643 lab=_80118_/Y }
C {devices/lab_pin.sym} 105740 -34230 0 1 {name=p104644 lab=_80119_/Y }
C {sky130_stdcells/a21oi_4.sym} 105660 -34230 0 0 {name=X_80119_ }
C {devices/lab_pin.sym} 105580 -34110 0 0 {name=p104645 lab=_41073_/X }
C {devices/lab_pin.sym} 105580 -34070 0 0 {name=p104646 lab=_81703_/Q }
C {devices/lab_pin.sym} 105580 -34030 0 0 {name=p104647 lab=_41080_/X }
C {devices/lab_pin.sym} 105740 -34070 0 1 {name=p104648 lab=_41081_/X }
C {sky130_stdcells/o21a_4.sym} 105660 -34070 0 0 {name=X_41081_ }
C {devices/lab_pin.sym} 105600 -33940 0 0 {name=p104649 lab=_53080_/A }
C {devices/lab_pin.sym} 105600 -33900 0 0 {name=p104650 lab=_53067_/B }
C {devices/lab_pin.sym} 105720 -33920 0 1 {name=p104651 lab=_53067_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -33920 0 0 {name=X_53067_ }
C {devices/lab_pin.sym} 105620 -33790 0 0 {name=p104652 lab=_84937_/Q }
C {devices/lab_pin.sym} 105700 -33790 0 1 {name=p104653 lab=_57944_/Y }
C {sky130_stdcells/inv_2.sym} 105660 -33790 0 0 {name=X_57944_ }
C {devices/lab_pin.sym} 105620 -33670 0 0 {name=p104654 lab=_50228_/X }
C {devices/lab_pin.sym} 105700 -33670 0 1 {name=p104655 lab=_50279_/X }
C {sky130_stdcells/buf_2.sym} 105660 -33670 0 0 {name=X_50279_ }
C {devices/lab_pin.sym} 105580 -33580 0 0 {name=p104656 lab=_43644_/Y }
C {devices/lab_pin.sym} 105580 -33540 0 0 {name=p104657 lab=_72853_/X }
C {devices/lab_pin.sym} 105580 -33500 0 0 {name=p104658 lab=_73920_/X }
C {devices/lab_pin.sym} 105580 -33460 0 0 {name=p104659 lab=_73989_/Y }
C {devices/lab_pin.sym} 105740 -33520 0 1 {name=p104660 lab=_73990_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -33520 0 0 {name=X_73990_ }
C {devices/lab_pin.sym} 105570 -33370 0 0 {name=p104661 lab=_85688_/CLK }
C {devices/lab_pin.sym} 105570 -33350 0 0 {name=p104662 lab=_51626_/Y }
C {devices/lab_pin.sym} 105750 -33370 0 1 {name=p104663 lab=_85976_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -33360 0 0 {name=X_85976_ }
C {devices/lab_pin.sym} 105570 -33230 0 0 {name=p104664 lab=_83944_/CLK }
C {devices/lab_pin.sym} 105570 -33210 0 0 {name=p104665 lab=_79654_/Y }
C {devices/lab_pin.sym} 105750 -33230 0 1 {name=p104666 lab=_81099_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -33220 0 0 {name=X_81099_ }
C {devices/lab_pin.sym} 105580 -33110 0 0 {name=p104667 lab=_52016_/Y }
C {devices/lab_pin.sym} 105580 -33070 0 0 {name=p104668 lab=_51987_/X }
C {devices/lab_pin.sym} 105580 -33030 0 0 {name=p104669 lab=_52017_/X }
C {devices/lab_pin.sym} 105740 -33070 0 1 {name=p104670 lab=_52018_/Y }
C {sky130_stdcells/a21oi_4.sym} 105660 -33070 0 0 {name=X_52018_ }
C {devices/lab_pin.sym} 105570 -32930 0 0 {name=p104671 lab=_87394_/CLK }
C {devices/lab_pin.sym} 105570 -32910 0 0 {name=p104672 lab=_87715_/D }
C {devices/lab_pin.sym} 105750 -32930 0 1 {name=p104673 lab=_67727_/B }
C {sky130_stdcells/dfxtp_4.sym} 105660 -32920 0 0 {name=X_87715_ }
C {devices/lab_pin.sym} 105580 -32810 0 0 {name=p104674 lab=_72939_/X }
C {devices/lab_pin.sym} 105580 -32770 0 0 {name=p104675 lab=_72940_/Y }
C {devices/lab_pin.sym} 105580 -32730 0 0 {name=p104676 lab=_72766_/X }
C {devices/lab_pin.sym} 105740 -32770 0 1 {name=p104677 lab=_72941_/Y }
C {sky130_stdcells/a21oi_4.sym} 105660 -32770 0 0 {name=X_72941_ }
C {devices/lab_pin.sym} 105570 -32630 0 0 {name=p104678 lab=_86627_/CLK }
C {devices/lab_pin.sym} 105570 -32610 0 0 {name=p104679 lab=_84927_/D }
C {devices/lab_pin.sym} 105750 -32630 0 1 {name=p104680 lab=_84927_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -32620 0 0 {name=X_84927_ }
C {devices/lab_pin.sym} 105620 -32490 0 0 {name=p104681 lab=clkbuf_9_348_0_CLK/X }
C {devices/lab_pin.sym} 105700 -32490 0 1 {name=p104682 lab=_87189_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 105660 -32490 0 0 {name=Xclkbuf_10_696_0_CLK }
C {devices/lab_pin.sym} 105620 -32370 0 0 {name=p104683 lab=_58703_/A }
C {devices/lab_pin.sym} 105700 -32370 0 1 {name=p104684 lab=_57875_/X }
C {sky130_stdcells/buf_2.sym} 105660 -32370 0 0 {name=X_57875_ }
C {devices/lab_pin.sym} 105620 -32250 0 0 {name=p104685 lab=_59613_/Y }
C {devices/lab_pin.sym} 105700 -32250 0 1 {name=p104686 lab=_60162_/A }
C {sky130_stdcells/buf_2.sym} 105660 -32250 0 0 {name=X_59614_ }
C {devices/lab_pin.sym} 105580 -32160 0 0 {name=p104687 lab=_41715_/A }
C {devices/lab_pin.sym} 105580 -32120 0 0 {name=p104688 lab=_44838_/X }
C {devices/lab_pin.sym} 105580 -32080 0 0 {name=p104689 lab=_67719_/B }
C {devices/lab_pin.sym} 105580 -32040 0 0 {name=p104690 lab=_44839_/X }
C {devices/lab_pin.sym} 105740 -32100 0 1 {name=p104691 lab=_44840_/X }
C {sky130_stdcells/a2bb2o_4.sym} 105660 -32100 0 0 {name=X_44840_ }
C {devices/lab_pin.sym} 105580 -31970 0 0 {name=p104692 lab=_56823_/Y }
C {devices/lab_pin.sym} 105580 -31930 0 0 {name=p104693 lab=_56825_/Y }
C {devices/lab_pin.sym} 105580 -31890 0 0 {name=p104694 lab=_44137_/A }
C {devices/lab_pin.sym} 105740 -31930 0 1 {name=p104695 lab=_56827_/B }
C {sky130_stdcells/a21o_4.sym} 105660 -31930 0 0 {name=X_56826_ }
C {devices/lab_pin.sym} 105600 -31800 0 0 {name=p104696 lab=_75660_/A }
C {devices/lab_pin.sym} 105600 -31760 0 0 {name=p104697 lab=_75660_/B }
C {devices/lab_pin.sym} 105720 -31780 0 1 {name=p104698 lab=_75665_/A }
C {sky130_stdcells/nand2_4.sym} 105660 -31780 0 0 {name=X_75660_ }
C {devices/lab_pin.sym} 105570 -31650 0 0 {name=p104699 lab=_87646_/CLK }
C {devices/lab_pin.sym} 105570 -31630 0 0 {name=p104700 lab=_87646_/D }
C {devices/lab_pin.sym} 105750 -31650 0 1 {name=p104701 lab=_67832_/B }
C {sky130_stdcells/dfxtp_4.sym} 105660 -31640 0 0 {name=X_87646_ }
C {devices/lab_pin.sym} 105580 -31540 0 0 {name=p104702 lab=_72870_/X }
C {devices/lab_pin.sym} 105580 -31500 0 0 {name=p104703 lab=_86205_/Q }
C {devices/lab_pin.sym} 105580 -31460 0 0 {name=p104704 lab=_45930_/X }
C {devices/lab_pin.sym} 105580 -31420 0 0 {name=p104705 lab=_72871_/X }
C {devices/lab_pin.sym} 105740 -31480 0 1 {name=p104706 lab=_72872_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -31480 0 0 {name=X_72872_ }
C {devices/lab_pin.sym} 105620 -31330 0 0 {name=p104707 lab=clkbuf_8_93_0_CLK/X }
C {devices/lab_pin.sym} 105700 -31330 0 1 {name=p104708 lab=clkbuf_9_187_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 105660 -31330 0 0 {name=Xclkbuf_9_187_0_CLK }
C {devices/lab_pin.sym} 105570 -31210 0 0 {name=p104709 lab=_84358_/CLK }
C {devices/lab_pin.sym} 105570 -31190 0 0 {name=p104710 lab=_58401_/X }
C {devices/lab_pin.sym} 105750 -31210 0 1 {name=p104711 lab=_58399_/A }
C {sky130_stdcells/dfxtp_4.sym} 105660 -31200 0 0 {name=X_84858_ }
C {devices/lab_pin.sym} 105580 -31090 0 0 {name=p104712 lab=_45290_/Y }
C {devices/lab_pin.sym} 105580 -31050 0 0 {name=p104713 lab=_74598_/X }
C {devices/lab_pin.sym} 105580 -31010 0 0 {name=p104714 lab=_74610_/X }
C {devices/lab_pin.sym} 105740 -31050 0 1 {name=p104715 lab=_83016_/D }
C {sky130_stdcells/o21ai_4.sym} 105660 -31050 0 0 {name=X_74611_ }
C {devices/lab_pin.sym} 105600 -30940 0 0 {name=p104716 lab=_71823_/A }
C {devices/lab_pin.sym} 105600 -30900 0 0 {name=p104717 lab=_70410_/Y }
C {devices/lab_pin.sym} 105600 -30860 0 0 {name=p104718 lab=_71713_/Y }
C {devices/lab_pin.sym} 105600 -30820 0 0 {name=p104719 lab=_70854_/A }
C {devices/lab_pin.sym} 105720 -30880 0 1 {name=p104720 lab=_71823_/Y }
C {sky130_stdcells/nor4_4.sym} 105660 -30880 0 0 {name=X_71823_ }
C {devices/lab_pin.sym} 105620 -30730 0 0 {name=p104721 lab=_59545_/A }
C {devices/lab_pin.sym} 105700 -30730 0 1 {name=p104722 lab=_59552_/B }
C {sky130_stdcells/inv_2.sym} 105660 -30730 0 0 {name=X_59545_ }
C {devices/lab_pin.sym} 105570 -30610 0 0 {name=p104723 lab=_83820_/CLK }
C {devices/lab_pin.sym} 105570 -30590 0 0 {name=p104724 lab=_83809_/D }
C {devices/lab_pin.sym} 105750 -30610 0 1 {name=p104725 lab=_74809_/A }
C {sky130_stdcells/dfxtp_4.sym} 105660 -30600 0 0 {name=X_83809_ }
C {devices/lab_pin.sym} 105580 -30510 0 0 {name=p104726 lab=_44766_/X }
C {devices/lab_pin.sym} 105580 -30470 0 0 {name=p104727 lab=_44767_/X }
C {devices/lab_pin.sym} 105580 -30430 0 0 {name=p104728 lab=_41346_/X }
C {devices/lab_pin.sym} 105580 -30390 0 0 {name=p104729 lab=_86964_/Q }
C {devices/lab_pin.sym} 105580 -30350 0 0 {name=p104730 lab=_44768_/X }
C {devices/lab_pin.sym} 105740 -30430 0 1 {name=p104731 lab=_44772_/A }
C {sky130_stdcells/o32ai_4.sym} 105660 -30430 0 0 {name=X_44771_ }
C {devices/lab_pin.sym} 105620 -30270 0 0 {name=p104732 lab=_57023_/A }
C {devices/lab_pin.sym} 105700 -30270 0 1 {name=p104733 lab=_56785_/B }
C {sky130_stdcells/buf_2.sym} 105660 -30270 0 0 {name=X_56757_ }
C {devices/lab_pin.sym} 105600 -30160 0 0 {name=p104734 lab=_75589_/Y }
C {devices/lab_pin.sym} 105600 -30120 0 0 {name=p104735 lab=_75889_/A }
C {devices/lab_pin.sym} 105720 -30140 0 1 {name=p104736 lab=_75591_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -30140 0 0 {name=X_75591_ }
C {devices/lab_pin.sym} 105570 -30010 0 0 {name=p104737 lab=_87577_/CLK }
C {devices/lab_pin.sym} 105570 -29990 0 0 {name=p104738 lab=_87577_/D }
C {devices/lab_pin.sym} 105750 -30010 0 1 {name=p104739 lab=_87577_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -30000 0 0 {name=X_87577_ }
C {devices/lab_pin.sym} 105600 -29890 0 0 {name=p104740 lab=_53969_/A }
C {devices/lab_pin.sym} 105600 -29850 0 0 {name=p104741 lab=_53964_/B }
C {devices/lab_pin.sym} 105600 -29810 0 0 {name=p104742 lab=_53969_/C }
C {devices/lab_pin.sym} 105720 -29850 0 1 {name=p104743 lab=_53969_/X }
C {sky130_stdcells/and3_4.sym} 105660 -29850 0 0 {name=X_53969_ }
C {devices/lab_pin.sym} 105620 -29710 0 0 {name=p104744 lab=_88082_/Q }
C {devices/lab_pin.sym} 105700 -29710 0 1 {name=p104745 lab=_41983_/Y }
C {sky130_stdcells/inv_2.sym} 105660 -29710 0 0 {name=X_41983_ }
C {devices/lab_pin.sym} 105570 -29590 0 0 {name=p104746 lab=_86695_/CLK }
C {devices/lab_pin.sym} 105570 -29570 0 0 {name=p104747 lab=_84789_/D }
C {devices/lab_pin.sym} 105750 -29590 0 1 {name=p104748 lab=_84789_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -29580 0 0 {name=X_84789_ }
C {devices/lab_pin.sym} 105620 -29450 0 0 {name=p104749 lab=_83634_/Q }
C {devices/lab_pin.sym} 105700 -29450 0 1 {name=p104750 lab=_54054_/B }
C {sky130_stdcells/inv_2.sym} 105660 -29450 0 0 {name=X_46510_ }
C {devices/lab_pin.sym} 105580 -29350 0 0 {name=p104751 lab=_77308_/Y }
C {devices/lab_pin.sym} 105580 -29310 0 0 {name=p104752 lab=_77310_/A }
C {devices/lab_pin.sym} 105580 -29270 0 0 {name=p104753 lab=_77307_/A }
C {devices/lab_pin.sym} 105740 -29310 0 1 {name=p104754 lab=_77332_/C }
C {sky130_stdcells/o21ai_4.sym} 105660 -29310 0 0 {name=X_77330_ }
C {devices/lab_pin.sym} 105580 -29200 0 0 {name=p104755 lab=_83014_/Q }
C {devices/lab_pin.sym} 105580 -29160 0 0 {name=p104756 lab=_55272_/X }
C {devices/lab_pin.sym} 105580 -29120 0 0 {name=p104757 lab=_44095_/A }
C {devices/lab_pin.sym} 105580 -29080 0 0 {name=p104758 lab=_55707_/X }
C {devices/lab_pin.sym} 105740 -29140 0 1 {name=p104759 lab=_55708_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -29140 0 0 {name=X_55708_ }
C {devices/lab_pin.sym} 105580 -29020 0 0 {name=p104760 lab=_40866_/A }
C {devices/lab_pin.sym} 105580 -28980 0 0 {name=p104761 lab=_43716_/X }
C {devices/lab_pin.sym} 105580 -28940 0 0 {name=p104762 lab=_69823_/B }
C {devices/lab_pin.sym} 105580 -28900 0 0 {name=p104763 lab=_43718_/X }
C {devices/lab_pin.sym} 105740 -28960 0 1 {name=p104764 lab=_43722_/X }
C {sky130_stdcells/a2bb2o_4.sym} 105660 -28960 0 0 {name=X_43722_ }
C {devices/lab_pin.sym} 105580 -28830 0 0 {name=p104765 lab=_55986_/X }
C {devices/lab_pin.sym} 105580 -28790 0 0 {name=p104766 lab=_74538_/Y }
C {devices/lab_pin.sym} 105580 -28750 0 0 {name=p104767 lab=_74541_/Y }
C {devices/lab_pin.sym} 105740 -28790 0 1 {name=p104768 lab=_83041_/D }
C {sky130_stdcells/o21ai_4.sym} 105660 -28790 0 0 {name=X_74542_ }
C {devices/lab_pin.sym} 105570 -28650 0 0 {name=p104769 lab=_86523_/CLK }
C {devices/lab_pin.sym} 105570 -28630 0 0 {name=p104770 lab=_48378_/Y }
C {devices/lab_pin.sym} 105750 -28650 0 1 {name=p104771 lab=_65444_/B }
C {sky130_stdcells/dfxtp_4.sym} 105660 -28640 0 0 {name=X_86528_ }
C {devices/lab_pin.sym} 105580 -28530 0 0 {name=p104772 lab=_40931_/X }
C {devices/lab_pin.sym} 105580 -28490 0 0 {name=p104773 lab=_41114_/A }
C {devices/lab_pin.sym} 105580 -28450 0 0 {name=p104774 lab=_40933_/X }
C {devices/lab_pin.sym} 105740 -28490 0 1 {name=p104775 lab=_40935_/A }
C {sky130_stdcells/o21ai_4.sym} 105660 -28490 0 0 {name=X_40934_ }
C {devices/lab_pin.sym} 105620 -28350 0 0 {name=p104776 lab=_47490_/A }
C {devices/lab_pin.sym} 105700 -28350 0 1 {name=p104777 lab=_53076_/B }
C {sky130_stdcells/buf_2.sym} 105660 -28350 0 0 {name=X_47490_ }
C {devices/lab_pin.sym} 105580 -28250 0 0 {name=p104778 lab=_52950_/B }
C {devices/lab_pin.sym} 105580 -28210 0 0 {name=p104779 lab=_71736_/X }
C {devices/lab_pin.sym} 105580 -28170 0 0 {name=p104780 lab=_71753_/Y }
C {devices/lab_pin.sym} 105740 -28210 0 1 {name=p104781 lab=_83388_/D }
C {sky130_stdcells/o21ai_4.sym} 105660 -28210 0 0 {name=X_71754_ }
C {devices/lab_pin.sym} 105620 -28070 0 0 {name=p104782 lab=_84721_/Q }
C {devices/lab_pin.sym} 105700 -28070 0 1 {name=p104783 lab=_59477_/A }
C {sky130_stdcells/buf_2.sym} 105660 -28070 0 0 {name=X_59476_ }
C {devices/lab_pin.sym} 105620 -27950 0 0 {name=p104784 lab=_56777_/B }
C {devices/lab_pin.sym} 105700 -27950 0 1 {name=p104785 lab=_56688_/X }
C {sky130_stdcells/buf_2.sym} 105660 -27950 0 0 {name=X_56688_ }
C {devices/lab_pin.sym} 105620 -27830 0 0 {name=p104786 lab=clkbuf_8_55_0_CLK/X }
C {devices/lab_pin.sym} 105700 -27830 0 1 {name=p104787 lab=clkbuf_9_110_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 105660 -27830 0 0 {name=Xclkbuf_9_110_0_CLK }
C {devices/lab_pin.sym} 105620 -27710 0 0 {name=p104788 lab=_83640_/Q }
C {devices/lab_pin.sym} 105700 -27710 0 1 {name=p104789 lab=_46441_/Y }
C {sky130_stdcells/inv_2.sym} 105660 -27710 0 0 {name=X_46441_ }
C {devices/lab_pin.sym} 105620 -27590 0 0 {name=p104790 lab=_70716_/A }
C {devices/lab_pin.sym} 105700 -27590 0 1 {name=p104791 lab=_70710_/C }
C {sky130_stdcells/buf_2.sym} 105660 -27590 0 0 {name=X_70705_ }
C {devices/lab_pin.sym} 105600 -27480 0 0 {name=p104792 lab=_58424_/Y }
C {devices/lab_pin.sym} 105600 -27440 0 0 {name=p104793 lab=_58426_/X }
C {devices/lab_pin.sym} 105720 -27460 0 1 {name=p104794 lab=_58427_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -27460 0 0 {name=X_58427_ }
C {devices/lab_pin.sym} 105600 -27340 0 0 {name=p104795 lab=_77261_/A }
C {devices/lab_pin.sym} 105600 -27300 0 0 {name=p104796 lab=_77260_/Y }
C {devices/lab_pin.sym} 105720 -27320 0 1 {name=p104797 lab=_82180_/D }
C {sky130_stdcells/xnor2_4.sym} 105660 -27320 0 0 {name=X_77261_ }
C {devices/lab_pin.sym} 105620 -27190 0 0 {name=p104798 lab=_43652_/X }
C {devices/lab_pin.sym} 105700 -27190 0 1 {name=p104799 lab=_43653_/Y }
C {sky130_stdcells/inv_2.sym} 105660 -27190 0 0 {name=X_43653_ }
C {devices/lab_pin.sym} 105580 -27090 0 0 {name=p104800 lab=_55636_/X }
C {devices/lab_pin.sym} 105580 -27050 0 0 {name=p104801 lab=_55638_/X }
C {devices/lab_pin.sym} 105580 -27010 0 0 {name=p104802 lab=_55615_/A }
C {devices/lab_pin.sym} 105740 -27050 0 1 {name=p104803 lab=_55643_/A }
C {sky130_stdcells/a21o_4.sym} 105660 -27050 0 0 {name=X_55639_ }
C {devices/lab_pin.sym} 105580 -26930 0 0 {name=p104804 lab=_74471_/Y }
C {devices/lab_pin.sym} 105580 -26890 0 0 {name=p104805 lab=_74463_/X }
C {devices/lab_pin.sym} 105580 -26850 0 0 {name=p104806 lab=_74472_/X }
C {devices/lab_pin.sym} 105740 -26890 0 1 {name=p104807 lab=_83059_/D }
C {sky130_stdcells/a21oi_4.sym} 105660 -26890 0 0 {name=X_74473_ }
C {devices/lab_pin.sym} 105570 -26750 0 0 {name=p104808 lab=_85561_/CLK }
C {devices/lab_pin.sym} 105570 -26730 0 0 {name=p104809 lab=_86459_/D }
C {devices/lab_pin.sym} 105750 -26750 0 1 {name=p104810 lab=_86459_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -26740 0 0 {name=X_86459_ }
C {devices/lab_pin.sym} 105580 -26630 0 0 {name=p104811 lab=_40857_/X }
C {devices/lab_pin.sym} 105580 -26590 0 0 {name=p104812 lab=_82286_/Q }
C {devices/lab_pin.sym} 105580 -26550 0 0 {name=p104813 lab=_40864_/X }
C {devices/lab_pin.sym} 105740 -26590 0 1 {name=p104814 lab=_40866_/A }
C {sky130_stdcells/o21a_4.sym} 105660 -26590 0 0 {name=X_40865_ }
C {devices/lab_pin.sym} 105620 -26450 0 0 {name=p104815 lab=_71641_/A }
C {devices/lab_pin.sym} 105700 -26450 0 1 {name=p104816 lab=_71685_/X }
C {sky130_stdcells/buf_2.sym} 105660 -26450 0 0 {name=X_71685_ }
C {devices/lab_pin.sym} 105600 -26340 0 0 {name=p104817 lab=_79000_/A }
C {devices/lab_pin.sym} 105600 -26300 0 0 {name=p104818 lab=_78999_/Y }
C {devices/lab_pin.sym} 105720 -26320 0 1 {name=p104819 lab=_79001_/B }
C {sky130_stdcells/xnor2_4.sym} 105660 -26320 0 0 {name=X_79000_ }
C {devices/lab_pin.sym} 105600 -26200 0 0 {name=p104820 lab=_76209_/Y }
C {devices/lab_pin.sym} 105600 -26160 0 0 {name=p104821 lab=_76211_/Y }
C {devices/lab_pin.sym} 105720 -26180 0 1 {name=p104822 lab=_76213_/B }
C {sky130_stdcells/xnor2_4.sym} 105660 -26180 0 0 {name=X_76212_ }
C {devices/lab_pin.sym} 105620 -26050 0 0 {name=p104823 lab=_73345_/A }
C {devices/lab_pin.sym} 105700 -26050 0 1 {name=p104824 lab=_42604_/Y }
C {sky130_stdcells/inv_2.sym} 105660 -26050 0 0 {name=X_42604_ }
C {devices/lab_pin.sym} 105580 -25950 0 0 {name=p104825 lab=_65319_/B }
C {devices/lab_pin.sym} 105580 -25910 0 0 {name=p104826 lab=_49153_/X }
C {devices/lab_pin.sym} 105580 -25870 0 0 {name=p104827 lab=_49159_/Y }
C {devices/lab_pin.sym} 105740 -25910 0 1 {name=p104828 lab=_49160_/Y }
C {sky130_stdcells/o21ai_4.sym} 105660 -25910 0 0 {name=X_49160_ }
C {devices/lab_pin.sym} 105600 -25780 0 0 {name=p104829 lab=_73353_/A }
C {devices/lab_pin.sym} 105600 -25740 0 0 {name=p104830 lab=_85863_/Q }
C {devices/lab_pin.sym} 105720 -25760 0 1 {name=p104831 lab=_73424_/X }
C {sky130_stdcells/and2_4.sym} 105660 -25760 0 0 {name=X_73424_ }
C {devices/lab_pin.sym} 105580 -25650 0 0 {name=p104832 lab=_46348_/X }
C {devices/lab_pin.sym} 105580 -25610 0 0 {name=p104833 lab=_48986_/A }
C {devices/lab_pin.sym} 105580 -25570 0 0 {name=p104834 lab=_46371_/X }
C {devices/lab_pin.sym} 105740 -25610 0 1 {name=p104835 lab=_51290_/B }
C {sky130_stdcells/o21ai_4.sym} 105660 -25610 0 0 {name=X_46372_ }
C {devices/lab_pin.sym} 105620 -25470 0 0 {name=p104836 lab=_70625_/Y }
C {devices/lab_pin.sym} 105700 -25470 0 1 {name=p104837 lab=_70637_/A }
C {sky130_stdcells/buf_2.sym} 105660 -25470 0 0 {name=X_70636_ }
C {devices/lab_pin.sym} 105620 -25350 0 0 {name=p104838 lab=_84869_/Q }
C {devices/lab_pin.sym} 105700 -25350 0 1 {name=p104839 lab=_63326_/A }
C {sky130_stdcells/inv_2.sym} 105660 -25350 0 0 {name=X_58358_ }
C {devices/lab_pin.sym} 105600 -25240 0 0 {name=p104840 lab=_77194_/A }
C {devices/lab_pin.sym} 105600 -25200 0 0 {name=p104841 lab=_77194_/B }
C {devices/lab_pin.sym} 105720 -25220 0 1 {name=p104842 lab=_77193_/A }
C {sky130_stdcells/or2_4.sym} 105660 -25220 0 0 {name=X_77192_ }
C {devices/lab_pin.sym} 105620 -25090 0 0 {name=p104843 lab=clkbuf_9_317_0_CLK/X }
C {devices/lab_pin.sym} 105700 -25090 0 1 {name=p104844 lab=_82327_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 105660 -25090 0 0 {name=Xclkbuf_10_634_0_CLK }
C {devices/lab_pin.sym} 105620 -24970 0 0 {name=p104845 lab=_43583_/Y }
C {devices/lab_pin.sym} 105700 -24970 0 1 {name=p104846 lab=_51337_/A }
C {sky130_stdcells/buf_2.sym} 105660 -24970 0 0 {name=X_43584_ }
C {devices/lab_pin.sym} 105600 -24860 0 0 {name=p104847 lab=_82875_/Q }
C {devices/lab_pin.sym} 105600 -24820 0 0 {name=p104848 lab=_40779_/B }
C {devices/lab_pin.sym} 105720 -24840 0 1 {name=p104849 lab=_40796_/X }
C {sky130_stdcells/or2_4.sym} 105660 -24840 0 0 {name=X_40796_ }
C {devices/lab_pin.sym} 105580 -24730 0 0 {name=p104850 lab=_48075_/X }
C {devices/lab_pin.sym} 105580 -24690 0 0 {name=p104851 lab=_82919_/Q }
C {devices/lab_pin.sym} 105580 -24650 0 0 {name=p104852 lab=_48110_/X }
C {devices/lab_pin.sym} 105740 -24690 0 1 {name=p104853 lab=_48112_/B }
C {sky130_stdcells/o21ai_4.sym} 105660 -24690 0 0 {name=X_48111_ }
C {devices/lab_pin.sym} 105580 -24570 0 0 {name=p104854 lab=_45316_/X }
C {devices/lab_pin.sym} 105580 -24530 0 0 {name=p104855 lab=_45320_/Y }
C {devices/lab_pin.sym} 105580 -24490 0 0 {name=p104856 lab=_45322_/Y }
C {devices/lab_pin.sym} 105740 -24530 0 1 {name=p104857 lab=_45323_/Y }
C {sky130_stdcells/a21oi_4.sym} 105660 -24530 0 0 {name=X_45323_ }
C {devices/lab_pin.sym} 105600 -24400 0 0 {name=p104858 lab=_76143_/A }
C {devices/lab_pin.sym} 105600 -24360 0 0 {name=p104859 lab=_76143_/B }
C {devices/lab_pin.sym} 105720 -24380 0 1 {name=p104860 lab=_76145_/A }
C {sky130_stdcells/nand2_4.sym} 105660 -24380 0 0 {name=X_76143_ }
C {devices/lab_pin.sym} 105580 -24270 0 0 {name=p104861 lab=_57261_/X }
C {devices/lab_pin.sym} 105580 -24230 0 0 {name=p104862 lab=_57007_/X }
C {devices/lab_pin.sym} 105580 -24190 0 0 {name=p104863 lab=_57308_/Y }
C {devices/lab_pin.sym} 105740 -24230 0 1 {name=p104864 lab=_57310_/A }
C {sky130_stdcells/o21ai_4.sym} 105660 -24230 0 0 {name=X_57309_ }
C {devices/lab_pin.sym} 105570 -24090 0 0 {name=p104865 lab=_88386_/CLK }
C {devices/lab_pin.sym} 105570 -24070 0 0 {name=p104866 lab=_88129_/D }
C {devices/lab_pin.sym} 105750 -24090 0 1 {name=p104867 lab=_67003_/B }
C {sky130_stdcells/dfxtp_4.sym} 105660 -24080 0 0 {name=X_88129_ }
C {devices/lab_pin.sym} 105580 -23990 0 0 {name=p104868 lab=_42517_/X }
C {devices/lab_pin.sym} 105580 -23950 0 0 {name=p104869 lab=_40748_/Y }
C {devices/lab_pin.sym} 105580 -23910 0 0 {name=p104870 lab=_42477_/X }
C {devices/lab_pin.sym} 105580 -23870 0 0 {name=p104871 lab=_42534_/Y }
C {devices/lab_pin.sym} 105580 -23830 0 0 {name=p104872 lab=_42519_/X }
C {devices/lab_pin.sym} 105740 -23910 0 1 {name=p104873 lab=_87830_/D }
C {sky130_stdcells/o32ai_4.sym} 105660 -23910 0 0 {name=X_42535_ }
C {devices/lab_pin.sym} 105600 -23770 0 0 {name=p104874 lab=_52365_/A }
C {devices/lab_pin.sym} 105600 -23730 0 0 {name=p104875 lab=_48940_/B }
C {devices/lab_pin.sym} 105600 -23690 0 0 {name=p104876 lab=_49091_/C }
C {devices/lab_pin.sym} 105720 -23730 0 1 {name=p104877 lab=_49091_/X }
C {sky130_stdcells/and3_4.sym} 105660 -23730 0 0 {name=X_49091_ }
C {devices/lab_pin.sym} 105620 -23590 0 0 {name=p104878 lab=_73355_/A }
C {devices/lab_pin.sym} 105700 -23590 0 1 {name=p104879 lab=_73355_/X }
C {sky130_stdcells/buf_2.sym} 105660 -23590 0 0 {name=X_73355_ }
C {devices/lab_pin.sym} 105620 -23470 0 0 {name=p104880 lab=_71887_/A }
C {devices/lab_pin.sym} 105700 -23470 0 1 {name=p104881 lab=_71865_/A }
C {sky130_stdcells/buf_2.sym} 105660 -23470 0 0 {name=X_70567_ }
C {devices/lab_pin.sym} 105580 -23370 0 0 {name=p104882 lab=_58271_/X }
C {devices/lab_pin.sym} 105580 -23330 0 0 {name=p104883 lab=_83407_/Q }
C {devices/lab_pin.sym} 105580 -23290 0 0 {name=p104884 lab=_58288_/Y }
C {devices/lab_pin.sym} 105740 -23330 0 1 {name=p104885 lab=_58289_/X }
C {sky130_stdcells/o21a_4.sym} 105660 -23330 0 0 {name=X_58289_ }
C {devices/lab_pin.sym} 105620 -23190 0 0 {name=p104886 lab=clkbuf_8_62_0_CLK/X }
C {devices/lab_pin.sym} 105700 -23190 0 1 {name=p104887 lab=clkbuf_9_125_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 105660 -23190 0 0 {name=Xclkbuf_9_125_0_CLK }
C {devices/lab_pin.sym} 105620 -23070 0 0 {name=p104888 lab=clkbuf_9_53_0_CLK/A }
C {devices/lab_pin.sym} 105700 -23070 0 1 {name=p104889 lab=clkbuf_9_52_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 105660 -23070 0 0 {name=Xclkbuf_9_52_0_CLK }
C {devices/lab_pin.sym} 105580 -22970 0 0 {name=p104890 lab=_66198_/B }
C {devices/lab_pin.sym} 105580 -22930 0 0 {name=p104891 lab=_47998_/X }
C {devices/lab_pin.sym} 105580 -22890 0 0 {name=p104892 lab=_48041_/Y }
C {devices/lab_pin.sym} 105740 -22930 0 1 {name=p104893 lab=_48042_/Y }
C {sky130_stdcells/o21ai_4.sym} 105660 -22930 0 0 {name=X_48042_ }
C {devices/lab_pin.sym} 105600 -22810 0 0 {name=p104894 lab=_60317_/A }
C {devices/lab_pin.sym} 105600 -22770 0 0 {name=p104895 lab=_60319_/X }
C {devices/lab_pin.sym} 105600 -22730 0 0 {name=p104896 lab=_79722_/A }
C {devices/lab_pin.sym} 105720 -22770 0 1 {name=p104897 lab=_60320_/Y }
C {sky130_stdcells/nor3_4.sym} 105660 -22770 0 0 {name=X_60320_ }
C {devices/lab_pin.sym} 105580 -22650 0 0 {name=p104898 lab=_72196_/X }
C {devices/lab_pin.sym} 105580 -22610 0 0 {name=p104899 lab=_85330_/Q }
C {devices/lab_pin.sym} 105580 -22570 0 0 {name=p104900 lab=_72255_/X }
C {devices/lab_pin.sym} 105740 -22610 0 1 {name=p104901 lab=_72306_/X }
C {sky130_stdcells/o21a_4.sym} 105660 -22610 0 0 {name=X_72306_ }
C {devices/lab_pin.sym} 105580 -22490 0 0 {name=p104902 lab=_85194_/Q }
C {devices/lab_pin.sym} 105580 -22450 0 0 {name=p104903 lab=_45252_/X }
C {devices/lab_pin.sym} 105580 -22410 0 0 {name=p104904 lab=_45253_/X }
C {devices/lab_pin.sym} 105740 -22450 0 1 {name=p104905 lab=_45254_/Y }
C {sky130_stdcells/o21ai_4.sym} 105660 -22450 0 0 {name=X_45254_ }
C {devices/lab_pin.sym} 105600 -22320 0 0 {name=p104906 lab=_81527_/Q }
C {devices/lab_pin.sym} 105600 -22280 0 0 {name=p104907 lab=_76074_/B }
C {devices/lab_pin.sym} 105720 -22300 0 1 {name=p104908 lab=_76074_/X }
C {sky130_stdcells/xor2_4.sym} 105660 -22300 0 0 {name=X_76074_ }
C {devices/lab_pin.sym} 105620 -22170 0 0 {name=p104909 lab=_42610_/A }
C {devices/lab_pin.sym} 105700 -22170 0 1 {name=p104910 lab=_42466_/X }
C {sky130_stdcells/buf_2.sym} 105660 -22170 0 0 {name=X_42466_ }
C {devices/lab_pin.sym} 105580 -22080 0 0 {name=p104911 lab=_73210_/X }
C {devices/lab_pin.sym} 105580 -22040 0 0 {name=p104912 lab=_85581_/Q }
C {devices/lab_pin.sym} 105580 -22000 0 0 {name=p104913 lab=_73284_/X }
C {devices/lab_pin.sym} 105580 -21960 0 0 {name=p104914 lab=_73285_/X }
C {devices/lab_pin.sym} 105740 -22020 0 1 {name=p104915 lab=_73286_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -22020 0 0 {name=X_73286_ }
C {devices/lab_pin.sym} 105600 -21900 0 0 {name=p104916 lab=_71115_/C }
C {devices/lab_pin.sym} 105600 -21860 0 0 {name=p104917 lab=_70700_/A }
C {devices/lab_pin.sym} 105600 -21820 0 0 {name=p104918 lab=_70700_/B }
C {devices/lab_pin.sym} 105600 -21780 0 0 {name=p104919 lab=_70609_/A }
C {devices/lab_pin.sym} 105720 -21840 0 1 {name=p104920 lab=_70502_/A }
C {sky130_stdcells/nand4_4.sym} 105660 -21840 0 0 {name=X_70498_ }
C {devices/lab_pin.sym} 105620 -21690 0 0 {name=p104921 lab=_44196_/B }
C {devices/lab_pin.sym} 105700 -21690 0 1 {name=p104922 lab=_56670_/A }
C {sky130_stdcells/buf_2.sym} 105660 -21690 0 0 {name=X_44205_ }
C {devices/lab_pin.sym} 105600 -21580 0 0 {name=p104923 lab=_81147_/D }
C {devices/lab_pin.sym} 105600 -21540 0 0 {name=p104924 lab=_75032_/B }
C {devices/lab_pin.sym} 105720 -21560 0 1 {name=p104925 lab=_75030_/A }
C {sky130_stdcells/xor2_4.sym} 105660 -21560 0 0 {name=X_75025_ }
C {devices/lab_pin.sym} 105580 -21450 0 0 {name=p104926 lab=_80264_/A }
C {devices/lab_pin.sym} 105580 -21410 0 0 {name=p104927 lab=_79900_/X }
C {devices/lab_pin.sym} 105580 -21370 0 0 {name=p104928 lab=_80263_/B }
C {devices/lab_pin.sym} 105740 -21410 0 1 {name=p104929 lab=_79902_/Y }
C {sky130_stdcells/a21boi_4.sym} 105660 -21410 0 0 {name=X_79902_ }
C {devices/lab_pin.sym} 105620 -21270 0 0 {name=p104930 lab=_40717_/X }
C {devices/lab_pin.sym} 105700 -21270 0 1 {name=p104931 lab=_41486_/A }
C {sky130_stdcells/buf_2.sym} 105660 -21270 0 0 {name=X_41417_ }
C {devices/lab_pin.sym} 105600 -21180 0 0 {name=p104932 lab=_60251_/A }
C {devices/lab_pin.sym} 105600 -21140 0 0 {name=p104933 lab=_60170_/A }
C {devices/lab_pin.sym} 105600 -21100 0 0 {name=p104934 lab=_60197_/C }
C {devices/lab_pin.sym} 105600 -21060 0 0 {name=p104935 lab=_60309_/D }
C {devices/lab_pin.sym} 105720 -21120 0 1 {name=p104936 lab=_60285_/A }
C {sky130_stdcells/nand4_4.sym} 105660 -21120 0 0 {name=X_60251_ }
C {devices/lab_pin.sym} 105620 -20970 0 0 {name=p104937 lab=_72358_/A }
C {devices/lab_pin.sym} 105700 -20970 0 1 {name=p104938 lab=_72237_/X }
C {sky130_stdcells/buf_2.sym} 105660 -20970 0 0 {name=X_72237_ }
C {devices/lab_pin.sym} 105620 -20850 0 0 {name=p104939 lab=clkbuf_9_324_0_CLK/X }
C {devices/lab_pin.sym} 105700 -20850 0 1 {name=p104940 lab=_86965_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 105660 -20850 0 0 {name=Xclkbuf_10_649_0_CLK }
C {devices/lab_pin.sym} 105580 -20750 0 0 {name=p104941 lab=_45127_/X }
C {devices/lab_pin.sym} 105580 -20710 0 0 {name=p104942 lab=_61548_/B }
C {devices/lab_pin.sym} 105580 -20670 0 0 {name=p104943 lab=_45144_/X }
C {devices/lab_pin.sym} 105740 -20710 0 1 {name=p104944 lab=_45185_/Y }
C {sky130_stdcells/o21ai_4.sym} 105660 -20710 0 0 {name=X_45185_ }
C {devices/lab_pin.sym} 105620 -20570 0 0 {name=p104945 lab=_42397_/A }
C {devices/lab_pin.sym} 105700 -20570 0 1 {name=p104946 lab=_42397_/X }
C {sky130_stdcells/buf_2.sym} 105660 -20570 0 0 {name=X_42397_ }
C {devices/lab_pin.sym} 105620 -20450 0 0 {name=p104947 lab=_44135_/X }
C {devices/lab_pin.sym} 105700 -20450 0 1 {name=p104948 lab=_44137_/A }
C {sky130_stdcells/buf_2.sym} 105660 -20450 0 0 {name=X_44136_ }
C {devices/lab_pin.sym} 105600 -20340 0 0 {name=p104949 lab=_79828_/Y }
C {devices/lab_pin.sym} 105600 -20300 0 0 {name=p104950 lab=_79832_/Y }
C {devices/lab_pin.sym} 105720 -20320 0 1 {name=p104951 lab=_79833_/X }
C {sky130_stdcells/xor2_4.sym} 105660 -20320 0 0 {name=X_79833_ }
C {devices/lab_pin.sym} 105580 -20230 0 0 {name=p104952 lab=_41337_/X }
C {devices/lab_pin.sym} 105580 -20190 0 0 {name=p104953 lab=_41338_/X }
C {devices/lab_pin.sym} 105580 -20150 0 0 {name=p104954 lab=_41347_/X }
C {devices/lab_pin.sym} 105580 -20110 0 0 {name=p104955 lab=_67600_/B }
C {devices/lab_pin.sym} 105580 -20070 0 0 {name=p104956 lab=_41333_/X }
C {devices/lab_pin.sym} 105740 -20150 0 1 {name=p104957 lab=_41349_/A }
C {sky130_stdcells/o32ai_4.sym} 105660 -20150 0 0 {name=X_41348_ }
C {devices/lab_pin.sym} 105620 -19990 0 0 {name=p104958 lab=_60182_/A }
C {devices/lab_pin.sym} 105700 -19990 0 1 {name=p104959 lab=_60182_/Y }
C {sky130_stdcells/inv_2.sym} 105660 -19990 0 0 {name=X_60182_ }
C {devices/lab_pin.sym} 105580 -19890 0 0 {name=p104960 lab=_72166_/X }
C {devices/lab_pin.sym} 105580 -19850 0 0 {name=p104961 lab=_85373_/Q }
C {devices/lab_pin.sym} 105580 -19810 0 0 {name=p104962 lab=_72167_/X }
C {devices/lab_pin.sym} 105740 -19850 0 1 {name=p104963 lab=_72168_/Y }
C {sky130_stdcells/o21ai_4.sym} 105660 -19850 0 0 {name=X_72168_ }
C {devices/lab_pin.sym} 105580 -19730 0 0 {name=p104964 lab=_72366_/B }
C {devices/lab_pin.sym} 105580 -19690 0 0 {name=p104965 lab=_49986_/X }
C {devices/lab_pin.sym} 105580 -19650 0 0 {name=p104966 lab=_49992_/Y }
C {devices/lab_pin.sym} 105740 -19690 0 1 {name=p104967 lab=_49993_/Y }
C {sky130_stdcells/o21ai_4.sym} 105660 -19690 0 0 {name=X_49993_ }
C {devices/lab_pin.sym} 105620 -19550 0 0 {name=p104968 lab=clkbuf_9_67_0_CLK/A }
C {devices/lab_pin.sym} 105700 -19550 0 1 {name=p104969 lab=clkbuf_9_67_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 105660 -19550 0 0 {name=Xclkbuf_9_67_0_CLK }
C {devices/lab_pin.sym} 105600 -19450 0 0 {name=p104970 lab=_71112_/X }
C {devices/lab_pin.sym} 105600 -19410 0 0 {name=p104971 lab=_71073_/B }
C {devices/lab_pin.sym} 105600 -19370 0 0 {name=p104972 lab=_71119_/C }
C {devices/lab_pin.sym} 105720 -19410 0 1 {name=p104973 lab=_71119_/Y }
C {sky130_stdcells/nand3_4.sym} 105660 -19410 0 0 {name=X_71119_ }
C {devices/lab_pin.sym} 105600 -19280 0 0 {name=p104974 lab=_48901_/A }
C {devices/lab_pin.sym} 105600 -19240 0 0 {name=p104975 lab=_48944_/B }
C {devices/lab_pin.sym} 105720 -19260 0 1 {name=p104976 lab=_48944_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -19260 0 0 {name=X_48944_ }
C {devices/lab_pin.sym} 105600 -19150 0 0 {name=p104977 lab=_44054_/Y }
C {devices/lab_pin.sym} 105600 -19110 0 0 {name=p104978 lab=_44067_/B }
C {devices/lab_pin.sym} 105600 -19070 0 0 {name=p104979 lab=_44116_/B }
C {devices/lab_pin.sym} 105720 -19110 0 1 {name=p104980 lab=_44067_/Y }
C {sky130_stdcells/nand3_4.sym} 105660 -19110 0 0 {name=X_44067_ }
C {devices/lab_pin.sym} 105600 -18980 0 0 {name=p104981 lab=_79764_/A }
C {devices/lab_pin.sym} 105600 -18940 0 0 {name=p104982 lab=_79764_/B }
C {devices/lab_pin.sym} 105720 -18960 0 1 {name=p104983 lab=_79765_/B }
C {sky130_stdcells/xor2_4.sym} 105660 -18960 0 0 {name=X_79764_ }
C {devices/lab_pin.sym} 105580 -18850 0 0 {name=p104984 lab=_64985_/X }
C {devices/lab_pin.sym} 105580 -18810 0 0 {name=p104985 lab=_64988_/X }
C {devices/lab_pin.sym} 105580 -18770 0 0 {name=p104986 lab=_64989_/X }
C {devices/lab_pin.sym} 105740 -18810 0 1 {name=p104987 lab=_64990_/X }
C {sky130_stdcells/a21o_4.sym} 105660 -18810 0 0 {name=X_64990_ }
C {devices/lab_pin.sym} 105620 -18670 0 0 {name=p104988 lab=_41279_/A }
C {devices/lab_pin.sym} 105700 -18670 0 1 {name=p104989 lab=_41279_/Y }
C {sky130_stdcells/inv_2.sym} 105660 -18670 0 0 {name=X_41279_ }
C {devices/lab_pin.sym} 105600 -18560 0 0 {name=p104990 lab=_74391_/A }
C {devices/lab_pin.sym} 105600 -18520 0 0 {name=p104991 lab=_50710_/B }
C {devices/lab_pin.sym} 105720 -18540 0 1 {name=p104992 lab=_72099_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -18540 0 0 {name=X_72099_ }
C {devices/lab_pin.sym} 105600 -18420 0 0 {name=p104993 lab=_76976_/A }
C {devices/lab_pin.sym} 105600 -18380 0 0 {name=p104994 lab=_84400_/Q }
C {devices/lab_pin.sym} 105720 -18400 0 1 {name=p104995 lab=_76976_/X }
C {sky130_stdcells/xor2_4.sym} 105660 -18400 0 0 {name=X_76976_ }
C {devices/lab_pin.sym} 105600 -18290 0 0 {name=p104996 lab=_41869_/A }
C {devices/lab_pin.sym} 105600 -18250 0 0 {name=p104997 lab=_42447_/C }
C {devices/lab_pin.sym} 105600 -18210 0 0 {name=p104998 lab=_41869_/C }
C {devices/lab_pin.sym} 105720 -18250 0 1 {name=p104999 lab=_43018_/Y }
C {sky130_stdcells/nor3_4.sym} 105660 -18250 0 0 {name=X_43018_ }
C {devices/lab_pin.sym} 105580 -18130 0 0 {name=p105000 lab=_78689_/Y }
C {devices/lab_pin.sym} 105580 -18090 0 0 {name=p105001 lab=_78690_/Y }
C {devices/lab_pin.sym} 105580 -18050 0 0 {name=p105002 lab=_78691_/Y }
C {devices/lab_pin.sym} 105740 -18090 0 1 {name=p105003 lab=_78715_/X }
C {sky130_stdcells/o21a_4.sym} 105660 -18090 0 0 {name=X_78715_ }
C {devices/lab_pin.sym} 105600 -17960 0 0 {name=p105004 lab=_81699_/D }
C {devices/lab_pin.sym} 105600 -17920 0 0 {name=p105005 lab=_75927_/B }
C {devices/lab_pin.sym} 105720 -17940 0 1 {name=p105006 lab=_75927_/X }
C {sky130_stdcells/xor2_4.sym} 105660 -17940 0 0 {name=X_75927_ }
C {devices/lab_pin.sym} 105600 -17840 0 0 {name=p105007 lab=_61481_/X }
C {devices/lab_pin.sym} 105600 -17800 0 0 {name=p105008 lab=_63908_/B }
C {devices/lab_pin.sym} 105600 -17760 0 0 {name=p105009 lab=_63894_/C }
C {devices/lab_pin.sym} 105600 -17720 0 0 {name=p105010 lab=_63908_/D }
C {devices/lab_pin.sym} 105720 -17780 0 1 {name=p105011 lab=_63941_/Y }
C {sky130_stdcells/nand4_4.sym} 105660 -17780 0 0 {name=X_63941_ }
C {devices/lab_pin.sym} 105580 -17650 0 0 {name=p105012 lab=_48873_/Y }
C {devices/lab_pin.sym} 105580 -17610 0 0 {name=p105013 lab=_48865_/X }
C {devices/lab_pin.sym} 105580 -17570 0 0 {name=p105014 lab=_48874_/X }
C {devices/lab_pin.sym} 105740 -17610 0 1 {name=p105015 lab=_86466_/D }
C {sky130_stdcells/a21oi_4.sym} 105660 -17610 0 0 {name=X_48875_ }
C {devices/lab_pin.sym} 105580 -17490 0 0 {name=p105016 lab=_79686_/Y }
C {devices/lab_pin.sym} 105580 -17450 0 0 {name=p105017 lab=_79704_/B }
C {devices/lab_pin.sym} 105580 -17410 0 0 {name=p105018 lab=_79694_/X }
C {devices/lab_pin.sym} 105740 -17450 0 1 {name=p105019 lab=_79696_/B }
C {sky130_stdcells/a21boi_4.sym} 105660 -17450 0 0 {name=X_79695_ }
C {devices/lab_pin.sym} 105620 -17310 0 0 {name=p105020 lab=_82369_/Q }
C {devices/lab_pin.sym} 105700 -17310 0 1 {name=p105021 lab=_48361_/B }
C {sky130_stdcells/inv_2.sym} 105660 -17310 0 0 {name=X_47826_ }
C {devices/lab_pin.sym} 105580 -17220 0 0 {name=p105022 lab=_66499_/B }
C {devices/lab_pin.sym} 105580 -17180 0 0 {name=p105023 lab=_66650_/Y }
C {devices/lab_pin.sym} 105580 -17140 0 0 {name=p105024 lab=_59782_/X }
C {devices/lab_pin.sym} 105580 -17100 0 0 {name=p105025 lab=_66659_/Y }
C {devices/lab_pin.sym} 105740 -17160 0 1 {name=p105026 lab=_66660_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -17160 0 0 {name=X_66660_ }
C {devices/lab_pin.sym} 105600 -17020 0 0 {name=p105027 lab=_78646_/A }
C {devices/lab_pin.sym} 105600 -16980 0 0 {name=p105028 lab=_82681_/D }
C {devices/lab_pin.sym} 105720 -17000 0 1 {name=p105029 lab=_78649_/B }
C {sky130_stdcells/nor2_4.sym} 105660 -17000 0 0 {name=X_78646_ }
C {devices/lab_pin.sym} 105620 -16870 0 0 {name=p105030 lab=_64012_/A }
C {devices/lab_pin.sym} 105700 -16870 0 1 {name=p105031 lab=_63902_/D }
C {sky130_stdcells/buf_2.sym} 105660 -16870 0 0 {name=X_63872_ }
C {devices/lab_pin.sym} 105580 -16770 0 0 {name=p105032 lab=_80927_/Q }
C {devices/lab_pin.sym} 105580 -16730 0 0 {name=p105033 lab=_75855_/Y }
C {devices/lab_pin.sym} 105580 -16690 0 0 {name=p105034 lab=_75857_/X }
C {devices/lab_pin.sym} 105740 -16730 0 1 {name=p105035 lab=_75858_/Y }
C {sky130_stdcells/o21ai_4.sym} 105660 -16730 0 0 {name=X_75858_ }
C {devices/lab_pin.sym} 105620 -16590 0 0 {name=p105036 lab=_64725_/A }
C {devices/lab_pin.sym} 105700 -16590 0 1 {name=p105037 lab=_65735_/A }
C {sky130_stdcells/buf_2.sym} 105660 -16590 0 0 {name=X_65611_ }
C {devices/lab_pin.sym} 105600 -16500 0 0 {name=p105038 lab=_62789_/A }
C {devices/lab_pin.sym} 105600 -16460 0 0 {name=p105039 lab=_59413_/Y }
C {devices/lab_pin.sym} 105600 -16420 0 0 {name=p105040 lab=_62848_/C }
C {devices/lab_pin.sym} 105600 -16380 0 0 {name=p105041 lab=_62789_/D }
C {devices/lab_pin.sym} 105720 -16440 0 1 {name=p105042 lab=_62823_/X }
C {sky130_stdcells/and4_4.sym} 105660 -16440 0 0 {name=X_62823_ }
C {devices/lab_pin.sym} 105600 -16320 0 0 {name=p105043 lab=_74809_/A }
C {devices/lab_pin.sym} 105600 -16280 0 0 {name=p105044 lab=_74796_/B }
C {devices/lab_pin.sym} 105600 -16240 0 0 {name=p105045 lab=_74796_/C }
C {devices/lab_pin.sym} 105600 -16200 0 0 {name=p105046 lab=_71016_/A }
C {devices/lab_pin.sym} 105720 -16260 0 1 {name=p105047 lab=_74810_/D }
C {sky130_stdcells/nand4_4.sym} 105660 -16260 0 0 {name=X_74809_ }
C {devices/lab_pin.sym} 105620 -16110 0 0 {name=p105048 lab=_47757_/A }
C {devices/lab_pin.sym} 105700 -16110 0 1 {name=p105049 lab=_53230_/D }
C {sky130_stdcells/buf_2.sym} 105660 -16110 0 0 {name=X_47757_ }
C {devices/lab_pin.sym} 105580 -16020 0 0 {name=p105050 lab=_87442_/Q }
C {devices/lab_pin.sym} 105580 -15980 0 0 {name=p105051 lab=_66538_/X }
C {devices/lab_pin.sym} 105580 -15940 0 0 {name=p105052 lab=_66540_/X }
C {devices/lab_pin.sym} 105580 -15900 0 0 {name=p105053 lab=_66590_/X }
C {devices/lab_pin.sym} 105740 -15960 0 1 {name=p105054 lab=_66591_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -15960 0 0 {name=X_66591_ }
C {devices/lab_pin.sym} 105600 -15830 0 0 {name=p105055 lab=_78561_/B }
C {devices/lab_pin.sym} 105600 -15790 0 0 {name=p105056 lab=_78560_/B }
C {devices/lab_pin.sym} 105600 -15750 0 0 {name=p105057 lab=_78560_/A }
C {devices/lab_pin.sym} 105720 -15790 0 1 {name=p105058 lab=_78577_/X }
C {sky130_stdcells/and3_4.sym} 105660 -15790 0 0 {name=X_78577_ }
C {devices/lab_pin.sym} 105620 -15650 0 0 {name=p105059 lab=_44968_/X }
C {devices/lab_pin.sym} 105700 -15650 0 1 {name=p105060 lab=_45033_/B }
C {sky130_stdcells/buf_2.sym} 105660 -15650 0 0 {name=X_44969_ }
C {devices/lab_pin.sym} 105620 -15530 0 0 {name=p105061 lab=_75779_/Y }
C {devices/lab_pin.sym} 105700 -15530 0 1 {name=p105062 lab=_75789_/Y }
C {sky130_stdcells/inv_2.sym} 105660 -15530 0 0 {name=X_75789_ }
C {devices/lab_pin.sym} 105580 -15430 0 0 {name=p105063 lab=_82629_/D }
C {devices/lab_pin.sym} 105580 -15390 0 0 {name=p105064 lab=_68318_/X }
C {devices/lab_pin.sym} 105580 -15350 0 0 {name=p105065 lab=_68329_/X }
C {devices/lab_pin.sym} 105740 -15390 0 1 {name=p105066 lab=_83981_/D }
C {sky130_stdcells/a21bo_4.sym} 105660 -15390 0 0 {name=X_68330_ }
C {devices/lab_pin.sym} 105600 -15280 0 0 {name=p105067 lab=_46717_/A }
C {devices/lab_pin.sym} 105600 -15240 0 0 {name=p105068 lab=_46717_/B }
C {devices/lab_pin.sym} 105600 -15200 0 0 {name=p105069 lab=_46682_/C }
C {devices/lab_pin.sym} 105600 -15160 0 0 {name=p105070 lab=_46707_/X }
C {devices/lab_pin.sym} 105720 -15220 0 1 {name=p105071 lab=_46708_/X }
C {sky130_stdcells/and4_4.sym} 105660 -15220 0 0 {name=X_46708_ }
C {devices/lab_pin.sym} 105580 -15100 0 0 {name=p105072 lab=_65428_/X }
C {devices/lab_pin.sym} 105580 -15060 0 0 {name=p105073 lab=_83074_/Q }
C {devices/lab_pin.sym} 105580 -15020 0 0 {name=p105074 lab=_65540_/X }
C {devices/lab_pin.sym} 105580 -14980 0 0 {name=p105075 lab=_65541_/X }
C {devices/lab_pin.sym} 105740 -15040 0 1 {name=p105076 lab=_65543_/B }
C {sky130_stdcells/a211o_4.sym} 105660 -15040 0 0 {name=X_65542_ }
C {devices/lab_pin.sym} 105600 -14900 0 0 {name=p105077 lab=_77528_/A }
C {devices/lab_pin.sym} 105600 -14860 0 0 {name=p105078 lab=_82198_/D }
C {devices/lab_pin.sym} 105720 -14880 0 1 {name=p105079 lab=_81910_/D }
C {sky130_stdcells/xor2_4.sym} 105660 -14880 0 0 {name=X_77528_ }
C {devices/lab_pin.sym} 105600 -14780 0 0 {name=p105080 lab=_61428_/X }
C {devices/lab_pin.sym} 105600 -14740 0 0 {name=p105081 lab=_62743_/B }
C {devices/lab_pin.sym} 105600 -14700 0 0 {name=p105082 lab=_62742_/X }
C {devices/lab_pin.sym} 105600 -14660 0 0 {name=p105083 lab=_62729_/D }
C {devices/lab_pin.sym} 105720 -14720 0 1 {name=p105084 lab=_62754_/Y }
C {sky130_stdcells/nand4_4.sym} 105660 -14720 0 0 {name=X_62754_ }
C {devices/lab_pin.sym} 105600 -14580 0 0 {name=p105085 lab=_47696_/A }
C {devices/lab_pin.sym} 105600 -14540 0 0 {name=p105086 lab=_53187_/B }
C {devices/lab_pin.sym} 105720 -14560 0 1 {name=p105087 lab=_47688_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -14560 0 0 {name=X_47688_ }
C {devices/lab_pin.sym} 105600 -14440 0 0 {name=p105088 lab=_49418_/A }
C {devices/lab_pin.sym} 105600 -14400 0 0 {name=p105089 lab=_51812_/B }
C {devices/lab_pin.sym} 105720 -14420 0 1 {name=p105090 lab=_49427_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -14420 0 0 {name=X_49427_ }
C {devices/lab_pin.sym} 105620 -14290 0 0 {name=p105091 lab=_61704_/Y }
C {devices/lab_pin.sym} 105700 -14290 0 1 {name=p105092 lab=_61715_/A }
C {sky130_stdcells/buf_2.sym} 105660 -14290 0 0 {name=X_61705_ }
C {devices/lab_pin.sym} 105580 -14190 0 0 {name=p105093 lab=_67607_/X }
C {devices/lab_pin.sym} 105580 -14150 0 0 {name=p105094 lab=_67609_/X }
C {devices/lab_pin.sym} 105580 -14110 0 0 {name=p105095 lab=_68260_/X }
C {devices/lab_pin.sym} 105740 -14150 0 1 {name=p105096 lab=_68261_/Y }
C {sky130_stdcells/a21oi_4.sym} 105660 -14150 0 0 {name=X_68261_ }
C {devices/lab_pin.sym} 105600 -14040 0 0 {name=p105097 lab=_46670_/A }
C {devices/lab_pin.sym} 105600 -14000 0 0 {name=p105098 lab=_46647_/B }
C {devices/lab_pin.sym} 105600 -13960 0 0 {name=p105099 lab=_46659_/C }
C {devices/lab_pin.sym} 105600 -13920 0 0 {name=p105100 lab=_51761_/D }
C {devices/lab_pin.sym} 105720 -13980 0 1 {name=p105101 lab=_46639_/X }
C {sky130_stdcells/and4_4.sym} 105660 -13980 0 0 {name=X_46639_ }
C {devices/lab_pin.sym} 105580 -13850 0 0 {name=p105102 lab=_65469_/X }
C {devices/lab_pin.sym} 105580 -13810 0 0 {name=p105103 lab=_65472_/X }
C {devices/lab_pin.sym} 105580 -13770 0 0 {name=p105104 lab=_65457_/X }
C {devices/lab_pin.sym} 105740 -13810 0 1 {name=p105105 lab=_65473_/X }
C {sky130_stdcells/a21o_4.sym} 105660 -13810 0 0 {name=X_65473_ }
C {devices/lab_pin.sym} 105600 -13680 0 0 {name=p105106 lab=_77452_/A }
C {devices/lab_pin.sym} 105600 -13640 0 0 {name=p105107 lab=_77433_/A }
C {devices/lab_pin.sym} 105720 -13660 0 1 {name=p105108 lab=_77459_/X }
C {sky130_stdcells/and2_4.sym} 105660 -13660 0 0 {name=X_77459_ }
C {devices/lab_pin.sym} 105600 -13560 0 0 {name=p105109 lab=_62669_/A }
C {devices/lab_pin.sym} 105600 -13520 0 0 {name=p105110 lab=_63033_/A }
C {devices/lab_pin.sym} 105600 -13480 0 0 {name=p105111 lab=_62704_/C }
C {devices/lab_pin.sym} 105600 -13440 0 0 {name=p105112 lab=_62669_/D }
C {devices/lab_pin.sym} 105720 -13500 0 1 {name=p105113 lab=_62685_/X }
C {sky130_stdcells/and4_4.sym} 105660 -13500 0 0 {name=X_62685_ }
C {devices/lab_pin.sym} 105620 -13350 0 0 {name=p105114 lab=_67093_/X }
C {devices/lab_pin.sym} 105700 -13350 0 1 {name=p105115 lab=_67259_/A }
C {sky130_stdcells/buf_2.sym} 105660 -13350 0 0 {name=X_67212_ }
C {devices/lab_pin.sym} 105600 -13250 0 0 {name=p105116 lab=_64380_/X }
C {devices/lab_pin.sym} 105600 -13210 0 0 {name=p105117 lab=_58382_/A }
C {devices/lab_pin.sym} 105600 -13170 0 0 {name=p105118 lab=_64381_/X }
C {devices/lab_pin.sym} 105720 -13210 0 1 {name=p105119 lab=_64424_/Y }
C {sky130_stdcells/nand3_4.sym} 105660 -13210 0 0 {name=X_64424_ }
C {devices/lab_pin.sym} 105600 -13090 0 0 {name=p105120 lab=_61636_/A }
C {devices/lab_pin.sym} 105600 -13050 0 0 {name=p105121 lab=_61636_/B }
C {devices/lab_pin.sym} 105600 -13010 0 0 {name=p105122 lab=_61590_/C }
C {devices/lab_pin.sym} 105720 -13050 0 1 {name=p105123 lab=_61636_/Y }
C {sky130_stdcells/nand3_4.sym} 105660 -13050 0 0 {name=X_61636_ }
C {devices/lab_pin.sym} 105600 -12930 0 0 {name=p105124 lab=_51396_/A }
C {devices/lab_pin.sym} 105600 -12890 0 0 {name=p105125 lab=_49317_/X }
C {devices/lab_pin.sym} 105600 -12850 0 0 {name=p105126 lab=_49312_/C }
C {devices/lab_pin.sym} 105720 -12890 0 1 {name=p105127 lab=_49358_/X }
C {sky130_stdcells/and3_4.sym} 105660 -12890 0 0 {name=X_49358_ }
C {devices/lab_pin.sym} 105580 -12770 0 0 {name=p105128 lab=_80467_/Y }
C {devices/lab_pin.sym} 105580 -12730 0 0 {name=p105129 lab=_80451_/B }
C {devices/lab_pin.sym} 105580 -12690 0 0 {name=p105130 lab=_80469_/X }
C {devices/lab_pin.sym} 105740 -12730 0 1 {name=p105131 lab=_80471_/B }
C {sky130_stdcells/o21ai_4.sym} 105660 -12730 0 0 {name=X_80470_ }
C {devices/lab_pin.sym} 105580 -12610 0 0 {name=p105132 lab=_84016_/Q }
C {devices/lab_pin.sym} 105580 -12570 0 0 {name=p105133 lab=_68180_/X }
C {devices/lab_pin.sym} 105580 -12530 0 0 {name=p105134 lab=_68191_/X }
C {devices/lab_pin.sym} 105740 -12570 0 1 {name=p105135 lab=_84016_/D }
C {sky130_stdcells/a21bo_4.sym} 105660 -12570 0 0 {name=X_68192_ }
C {devices/lab_pin.sym} 105580 -12450 0 0 {name=p105136 lab=_48306_/Y }
C {devices/lab_pin.sym} 105580 -12410 0 0 {name=p105137 lab=_48273_/X }
C {devices/lab_pin.sym} 105580 -12370 0 0 {name=p105138 lab=_48308_/Y }
C {devices/lab_pin.sym} 105740 -12410 0 1 {name=p105139 lab=_86538_/D }
C {sky130_stdcells/a21boi_4.sym} 105660 -12410 0 0 {name=X_48309_ }
C {devices/lab_pin.sym} 105580 -12300 0 0 {name=p105140 lab=_87867_/Q }
C {devices/lab_pin.sym} 105580 -12260 0 0 {name=p105141 lab=_67117_/X }
C {devices/lab_pin.sym} 105580 -12220 0 0 {name=p105142 lab=_67046_/X }
C {devices/lab_pin.sym} 105580 -12180 0 0 {name=p105143 lab=_67142_/X }
C {devices/lab_pin.sym} 105740 -12240 0 1 {name=p105144 lab=_67143_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -12240 0 0 {name=X_67143_ }
C {devices/lab_pin.sym} 105600 -12100 0 0 {name=p105145 lab=_79129_/A }
C {devices/lab_pin.sym} 105600 -12060 0 0 {name=p105146 lab=_79129_/B }
C {devices/lab_pin.sym} 105720 -12080 0 1 {name=p105147 lab=_82437_/D }
C {sky130_stdcells/xor2_4.sym} 105660 -12080 0 0 {name=X_79129_ }
C {devices/lab_pin.sym} 105600 -11970 0 0 {name=p105148 lab=_64336_/A }
C {devices/lab_pin.sym} 105600 -11930 0 0 {name=p105149 lab=_84821_/Q }
C {devices/lab_pin.sym} 105600 -11890 0 0 {name=p105150 lab=_64323_/X }
C {devices/lab_pin.sym} 105720 -11930 0 1 {name=p105151 lab=_64355_/Y }
C {sky130_stdcells/nand3_4.sym} 105660 -11930 0 0 {name=X_64355_ }
C {devices/lab_pin.sym} 105600 -11800 0 0 {name=p105152 lab=_49273_/A }
C {devices/lab_pin.sym} 105600 -11760 0 0 {name=p105153 lab=_50808_/B }
C {devices/lab_pin.sym} 105720 -11780 0 1 {name=p105154 lab=_49289_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -11780 0 0 {name=X_49289_ }
C {devices/lab_pin.sym} 105580 -11670 0 0 {name=p105155 lab=_61565_/X }
C {devices/lab_pin.sym} 105580 -11630 0 0 {name=p105156 lab=_61517_/X }
C {devices/lab_pin.sym} 105580 -11590 0 0 {name=p105157 lab=_61566_/Y }
C {devices/lab_pin.sym} 105740 -11630 0 1 {name=p105158 lab=_61567_/Y }
C {sky130_stdcells/a21oi_4.sym} 105660 -11630 0 0 {name=X_61567_ }
C {devices/lab_pin.sym} 105600 -11500 0 0 {name=p105159 lab=_51310_/X }
C {devices/lab_pin.sym} 105600 -11460 0 0 {name=p105160 lab=_51320_/B }
C {devices/lab_pin.sym} 105720 -11480 0 1 {name=p105161 lab=_51320_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -11480 0 0 {name=X_51320_ }
C {devices/lab_pin.sym} 105620 -11350 0 0 {name=p105162 lab=_63306_/A }
C {devices/lab_pin.sym} 105700 -11350 0 1 {name=p105163 lab=_63392_/B }
C {sky130_stdcells/buf_2.sym} 105660 -11350 0 0 {name=X_63306_ }
C {devices/lab_pin.sym} 105570 -11230 0 0 {name=p105164 lab=_82604_/CLK }
C {devices/lab_pin.sym} 105570 -11210 0 0 {name=p105165 lab=_77970_/X }
C {devices/lab_pin.sym} 105750 -11230 0 1 {name=p105166 lab=_82096_/D }
C {sky130_stdcells/dfxtp_4.sym} 105660 -11220 0 0 {name=X_82140_ }
C {devices/lab_pin.sym} 105580 -11110 0 0 {name=p105167 lab=_60488_/B }
C {devices/lab_pin.sym} 105580 -11070 0 0 {name=p105168 lab=_63004_/C }
C {devices/lab_pin.sym} 105580 -11030 0 0 {name=p105169 lab=_60556_/B }
C {devices/lab_pin.sym} 105740 -11070 0 1 {name=p105170 lab=_60518_/X }
C {sky130_stdcells/o21a_4.sym} 105660 -11070 0 0 {name=X_60518_ }
C {devices/lab_pin.sym} 105620 -10930 0 0 {name=p105171 lab=_66953_/X }
C {devices/lab_pin.sym} 105700 -10930 0 1 {name=p105172 lab=_67074_/X }
C {sky130_stdcells/buf_2.sym} 105660 -10930 0 0 {name=X_67074_ }
C {devices/lab_pin.sym} 105600 -10830 0 0 {name=p105173 lab=_64295_/A }
C {devices/lab_pin.sym} 105600 -10790 0 0 {name=p105174 lab=_64248_/B }
C {devices/lab_pin.sym} 105600 -10750 0 0 {name=p105175 lab=_64286_/C }
C {devices/lab_pin.sym} 105720 -10790 0 1 {name=p105176 lab=_64286_/X }
C {sky130_stdcells/and3_4.sym} 105660 -10790 0 0 {name=X_64286_ }
C {devices/lab_pin.sym} 105620 -10650 0 0 {name=p105177 lab=_61374_/A }
C {devices/lab_pin.sym} 105700 -10650 0 1 {name=p105178 lab=_61499_/A }
C {sky130_stdcells/buf_2.sym} 105660 -10650 0 0 {name=X_61498_ }
C {devices/lab_pin.sym} 105580 -10560 0 0 {name=p105179 lab=_65876_/X }
C {devices/lab_pin.sym} 105580 -10520 0 0 {name=p105180 lab=_85625_/Q }
C {devices/lab_pin.sym} 105580 -10480 0 0 {name=p105181 lab=_65976_/X }
C {devices/lab_pin.sym} 105580 -10440 0 0 {name=p105182 lab=_66024_/X }
C {devices/lab_pin.sym} 105740 -10500 0 1 {name=p105183 lab=_66025_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -10500 0 0 {name=X_66025_ }
C {devices/lab_pin.sym} 105600 -10360 0 0 {name=p105184 lab=_51278_/A }
C {devices/lab_pin.sym} 105600 -10320 0 0 {name=p105185 lab=_51251_/B }
C {devices/lab_pin.sym} 105720 -10340 0 1 {name=p105186 lab=_51251_/X }
C {sky130_stdcells/and2_4.sym} 105660 -10340 0 0 {name=X_51251_ }
C {devices/lab_pin.sym} 105620 -10210 0 0 {name=p105187 lab=_60459_/B }
C {devices/lab_pin.sym} 105700 -10210 0 1 {name=p105188 lab=_63237_/X }
C {sky130_stdcells/buf_2.sym} 105660 -10210 0 0 {name=X_63237_ }
C {devices/lab_pin.sym} 105570 -10090 0 0 {name=p105189 lab=_81154_/CLK }
C {devices/lab_pin.sym} 105570 -10070 0 0 {name=p105190 lab=_82071_/D }
C {devices/lab_pin.sym} 105750 -10090 0 1 {name=p105191 lab=_82071_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -10080 0 0 {name=X_82071_ }
C {devices/lab_pin.sym} 105580 -9990 0 0 {name=p105192 lab=_60438_/A }
C {devices/lab_pin.sym} 105580 -9950 0 0 {name=p105193 lab=_60420_/A }
C {devices/lab_pin.sym} 105580 -9910 0 0 {name=p105194 lab=_60440_/X }
C {devices/lab_pin.sym} 105580 -9870 0 0 {name=p105195 lab=_60439_/X }
C {devices/lab_pin.sym} 105580 -9840 0 0 {name=p105196 lab=_60473_/C }
C {devices/lab_pin.sym} 105740 -9910 0 1 {name=p105197 lab=_60572_/B }
C {sky130_stdcells/a41o_4.sym} 105660 -9910 0 0 {name=X_60449_ }
C {devices/lab_pin.sym} 105620 -9750 0 0 {name=p105198 lab=clkbuf_8_4_0_CLK/X }
C {devices/lab_pin.sym} 105700 -9750 0 1 {name=p105199 lab=clkbuf_9_8_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 105660 -9750 0 0 {name=Xclkbuf_9_8_0_CLK }
C {devices/lab_pin.sym} 105580 -9650 0 0 {name=p105200 lab=_50200_/Y }
C {devices/lab_pin.sym} 105580 -9610 0 0 {name=p105201 lab=_50191_/X }
C {devices/lab_pin.sym} 105580 -9570 0 0 {name=p105202 lab=_50201_/X }
C {devices/lab_pin.sym} 105740 -9610 0 1 {name=p105203 lab=_86244_/D }
C {sky130_stdcells/a21oi_4.sym} 105660 -9610 0 0 {name=X_50202_ }
C {devices/lab_pin.sym} 105570 -9470 0 0 {name=p105204 lab=_84210_/CLK }
C {devices/lab_pin.sym} 105570 -9450 0 0 {name=p105205 lab=_84230_/Q }
C {devices/lab_pin.sym} 105750 -9470 0 1 {name=p105206 lab=_81022_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -9460 0 0 {name=X_81022_ }
C {devices/lab_pin.sym} 105580 -9350 0 0 {name=p105207 lab=_51180_/Y }
C {devices/lab_pin.sym} 105580 -9310 0 0 {name=p105208 lab=_51175_/X }
C {devices/lab_pin.sym} 105580 -9270 0 0 {name=p105209 lab=_51181_/X }
C {devices/lab_pin.sym} 105740 -9310 0 1 {name=p105210 lab=_51182_/Y }
C {sky130_stdcells/a21oi_4.sym} 105660 -9310 0 0 {name=X_51182_ }
C {devices/lab_pin.sym} 105600 -9200 0 0 {name=p105211 lab=_63157_/X }
C {devices/lab_pin.sym} 105600 -9160 0 0 {name=p105212 lab=_63168_/B }
C {devices/lab_pin.sym} 105600 -9120 0 0 {name=p105213 lab=_63147_/C }
C {devices/lab_pin.sym} 105600 -9080 0 0 {name=p105214 lab=_63124_/D }
C {devices/lab_pin.sym} 105720 -9140 0 1 {name=p105215 lab=_63168_/X }
C {sky130_stdcells/and4_4.sym} 105660 -9140 0 0 {name=X_63168_ }
C {devices/lab_pin.sym} 105600 -9000 0 0 {name=p105216 lab=_50120_/A }
C {devices/lab_pin.sym} 105600 -8960 0 0 {name=p105217 lab=_50133_/B }
C {devices/lab_pin.sym} 105720 -8980 0 1 {name=p105218 lab=_50133_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -8980 0 0 {name=X_50133_ }
C {devices/lab_pin.sym} 105620 -8850 0 0 {name=p105219 lab=_61412_/A }
C {devices/lab_pin.sym} 105700 -8850 0 1 {name=p105220 lab=_62120_/A }
C {sky130_stdcells/buf_2.sym} 105660 -8850 0 0 {name=X_62119_ }
C {devices/lab_pin.sym} 105570 -8730 0 0 {name=p105221 lab=_85542_/CLK }
C {devices/lab_pin.sym} 105570 -8710 0 0 {name=p105222 lab=_52404_/Y }
C {devices/lab_pin.sym} 105750 -8730 0 1 {name=p105223 lab=_65313_/B }
C {sky130_stdcells/dfxtp_4.sym} 105660 -8720 0 0 {name=X_85830_ }
C {devices/lab_pin.sym} 105600 -8610 0 0 {name=p105224 lab=_56177_/A }
C {devices/lab_pin.sym} 105600 -8570 0 0 {name=p105225 lab=_45836_/X }
C {devices/lab_pin.sym} 105600 -8530 0 0 {name=p105226 lab=_55990_/C }
C {devices/lab_pin.sym} 105720 -8570 0 1 {name=p105227 lab=_55990_/Y }
C {sky130_stdcells/nand3_4.sym} 105660 -8570 0 0 {name=X_55990_ }
C {devices/lab_pin.sym} 105580 -8460 0 0 {name=p105228 lab=_87448_/Q }
C {devices/lab_pin.sym} 105580 -8420 0 0 {name=p105229 lab=_67953_/X }
C {devices/lab_pin.sym} 105580 -8380 0 0 {name=p105230 lab=_67954_/X }
C {devices/lab_pin.sym} 105580 -8340 0 0 {name=p105231 lab=_67975_/X }
C {devices/lab_pin.sym} 105740 -8400 0 1 {name=p105232 lab=_67976_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -8400 0 0 {name=X_67976_ }
C {devices/lab_pin.sym} 105620 -8250 0 0 {name=p105233 lab=_60469_/X }
C {devices/lab_pin.sym} 105700 -8250 0 1 {name=p105234 lab=_63100_/A }
C {sky130_stdcells/buf_2.sym} 105660 -8250 0 0 {name=X_63099_ }
C {devices/lab_pin.sym} 105580 -8150 0 0 {name=p105235 lab=_69712_/X }
C {devices/lab_pin.sym} 105580 -8110 0 0 {name=p105236 lab=_69714_/X }
C {devices/lab_pin.sym} 105580 -8070 0 0 {name=p105237 lab=_69655_/X }
C {devices/lab_pin.sym} 105740 -8110 0 1 {name=p105238 lab=_69715_/Y }
C {sky130_stdcells/a21oi_4.sym} 105660 -8110 0 0 {name=X_69715_ }
C {devices/lab_pin.sym} 105620 -7970 0 0 {name=p105239 lab=_50064_/A }
C {devices/lab_pin.sym} 105700 -7970 0 1 {name=p105240 lab=_50084_/A }
C {sky130_stdcells/buf_2.sym} 105660 -7970 0 0 {name=X_50064_ }
C {devices/lab_pin.sym} 105620 -7850 0 0 {name=p105241 lab=_54888_/A }
C {devices/lab_pin.sym} 105700 -7850 0 1 {name=p105242 lab=_54955_/A }
C {sky130_stdcells/buf_2.sym} 105660 -7850 0 0 {name=X_54941_ }
C {devices/lab_pin.sym} 105600 -7740 0 0 {name=p105243 lab=_66851_/X }
C {devices/lab_pin.sym} 105600 -7700 0 0 {name=p105244 lab=_66927_/B }
C {devices/lab_pin.sym} 105720 -7720 0 1 {name=p105245 lab=_66927_/X }
C {sky130_stdcells/and2_4.sym} 105660 -7720 0 0 {name=X_66927_ }
C {devices/lab_pin.sym} 105570 -7590 0 0 {name=p105246 lab=_85761_/CLK }
C {devices/lab_pin.sym} 105570 -7570 0 0 {name=p105247 lab=_52751_/Y }
C {devices/lab_pin.sym} 105750 -7590 0 1 {name=p105248 lab=_85761_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -7580 0 0 {name=X_85761_ }
C {devices/lab_pin.sym} 105570 -7450 0 0 {name=p105249 lab=_82973_/CLK }
C {devices/lab_pin.sym} 105570 -7430 0 0 {name=p105250 lab=_82781_/Q }
C {devices/lab_pin.sym} 105750 -7450 0 1 {name=p105251 lab=_82973_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -7440 0 0 {name=X_82973_ }
C {devices/lab_pin.sym} 105570 -7310 0 0 {name=p105252 lab=_88012_/CLK }
C {devices/lab_pin.sym} 105570 -7290 0 0 {name=p105253 lab=_87500_/D }
C {devices/lab_pin.sym} 105750 -7310 0 1 {name=p105254 lab=_87500_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -7300 0 0 {name=X_87500_ }
C {devices/lab_pin.sym} 105570 -7170 0 0 {name=p105255 lab=_84355_/CLK }
C {devices/lab_pin.sym} 105570 -7150 0 0 {name=p105256 lab=_59677_/Y }
C {devices/lab_pin.sym} 105750 -7170 0 1 {name=p105257 lab=_80614_/A }
C {sky130_stdcells/dfxtp_4.sym} 105660 -7160 0 0 {name=X_84712_ }
C {devices/lab_pin.sym} 105620 -7030 0 0 {name=p105258 lab=_84959_/Q }
C {devices/lab_pin.sym} 105700 -7030 0 1 {name=p105259 lab=_57660_/X }
C {sky130_stdcells/buf_2.sym} 105660 -7030 0 0 {name=X_57660_ }
C {devices/lab_pin.sym} 105600 -6920 0 0 {name=p105260 lab=_69605_/A }
C {devices/lab_pin.sym} 105600 -6880 0 0 {name=p105261 lab=_72924_/A }
C {devices/lab_pin.sym} 105720 -6900 0 1 {name=p105262 lab=_69646_/X }
C {sky130_stdcells/and2_4.sym} 105660 -6900 0 0 {name=X_69646_ }
C {devices/lab_pin.sym} 105570 -6770 0 0 {name=p105263 lab=_82116_/CLK }
C {devices/lab_pin.sym} 105570 -6750 0 0 {name=p105264 lab=_78047_/Y }
C {devices/lab_pin.sym} 105750 -6770 0 1 {name=p105265 lab=_77262_/A }
C {sky130_stdcells/dfxtp_4.sym} 105660 -6760 0 0 {name=X_81924_ }
C {devices/lab_pin.sym} 105580 -6650 0 0 {name=p105266 lab=_85362_/Q }
C {devices/lab_pin.sym} 105580 -6610 0 0 {name=p105267 lab=_54865_/X }
C {devices/lab_pin.sym} 105580 -6570 0 0 {name=p105268 lab=_54871_/Y }
C {devices/lab_pin.sym} 105740 -6610 0 1 {name=p105269 lab=_54872_/Y }
C {sky130_stdcells/o21ai_4.sym} 105660 -6610 0 0 {name=X_54872_ }
C {devices/lab_pin.sym} 105580 -6500 0 0 {name=p105270 lab=_87123_/Q }
C {devices/lab_pin.sym} 105580 -6460 0 0 {name=p105271 lab=_66833_/X }
C {devices/lab_pin.sym} 105580 -6420 0 0 {name=p105272 lab=_66834_/X }
C {devices/lab_pin.sym} 105580 -6380 0 0 {name=p105273 lab=_66857_/X }
C {devices/lab_pin.sym} 105740 -6440 0 1 {name=p105274 lab=_66858_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -6440 0 0 {name=X_66858_ }
C {devices/lab_pin.sym} 105570 -6290 0 0 {name=p105275 lab=_85692_/CLK }
C {devices/lab_pin.sym} 105570 -6270 0 0 {name=p105276 lab=_85692_/D }
C {devices/lab_pin.sym} 105750 -6290 0 1 {name=p105277 lab=_85692_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -6280 0 0 {name=X_85692_ }
C {devices/lab_pin.sym} 105580 -6190 0 0 {name=p105278 lab=_56629_/B }
C {devices/lab_pin.sym} 105580 -6150 0 0 {name=p105279 lab=_56580_/B }
C {devices/lab_pin.sym} 105580 -6110 0 0 {name=p105280 lab=_56616_/A }
C {devices/lab_pin.sym} 105580 -6070 0 0 {name=p105281 lab=_56616_/B }
C {devices/lab_pin.sym} 105580 -6040 0 0 {name=p105282 lab=_72654_/C }
C {devices/lab_pin.sym} 105740 -6110 0 1 {name=p105283 lab=_56611_/Y }
C {sky130_stdcells/a41oi_4.sym} 105660 -6110 0 0 {name=X_56611_ }
C {devices/lab_pin.sym} 105570 -5950 0 0 {name=p105284 lab=_87436_/CLK }
C {devices/lab_pin.sym} 105570 -5930 0 0 {name=p105285 lab=_43418_/Y }
C {devices/lab_pin.sym} 105750 -5950 0 1 {name=p105286 lab=_87431_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -5940 0 0 {name=X_87431_ }
C {devices/lab_pin.sym} 105600 -5820 0 0 {name=p105287 lab=_53819_/A }
C {devices/lab_pin.sym} 105600 -5780 0 0 {name=p105288 lab=_71996_/B }
C {devices/lab_pin.sym} 105720 -5800 0 1 {name=p105289 lab=_53823_/Y }
C {sky130_stdcells/nand2_4.sym} 105660 -5800 0 0 {name=X_53823_ }
C {devices/lab_pin.sym} 105620 -5670 0 0 {name=p105290 lab=_64729_/A }
C {devices/lab_pin.sym} 105700 -5670 0 1 {name=p105291 lab=_65809_/X }
C {sky130_stdcells/buf_2.sym} 105660 -5670 0 0 {name=X_65809_ }
C {devices/lab_pin.sym} 105570 -5550 0 0 {name=p105292 lab=_84333_/CLK }
C {devices/lab_pin.sym} 105570 -5530 0 0 {name=p105293 lab=_84643_/D }
C {devices/lab_pin.sym} 105750 -5550 0 1 {name=p105294 lab=_79817_/A }
C {sky130_stdcells/dfxtp_4.sym} 105660 -5540 0 0 {name=X_84643_ }
C {devices/lab_pin.sym} 105580 -5430 0 0 {name=p105295 lab=_84973_/Q }
C {devices/lab_pin.sym} 105580 -5390 0 0 {name=p105296 lab=_57562_/X }
C {devices/lab_pin.sym} 105580 -5350 0 0 {name=p105297 lab=_57590_/Y }
C {devices/lab_pin.sym} 105740 -5390 0 1 {name=p105298 lab=_57591_/Y }
C {sky130_stdcells/o21ai_4.sym} 105660 -5390 0 0 {name=X_57591_ }
C {devices/lab_pin.sym} 105570 -5250 0 0 {name=p105299 lab=_81094_/CLK }
C {devices/lab_pin.sym} 105570 -5230 0 0 {name=p105300 lab=_81887_/Q }
C {devices/lab_pin.sym} 105750 -5250 0 1 {name=p105301 lab=_77674_/A }
C {sky130_stdcells/dfxtp_4.sym} 105660 -5240 0 0 {name=X_81855_ }
C {devices/lab_pin.sym} 105580 -5140 0 0 {name=p105302 lab=_69505_/X }
C {devices/lab_pin.sym} 105580 -5100 0 0 {name=p105303 lab=_69574_/Y }
C {devices/lab_pin.sym} 105580 -5060 0 0 {name=p105304 lab=_69516_/X }
C {devices/lab_pin.sym} 105580 -5020 0 0 {name=p105305 lab=_69576_/Y }
C {devices/lab_pin.sym} 105740 -5080 0 1 {name=p105306 lab=_69577_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -5080 0 0 {name=X_69577_ }
C {devices/lab_pin.sym} 105600 -4940 0 0 {name=p105307 lab=_66769_/A }
C {devices/lab_pin.sym} 105600 -4900 0 0 {name=p105308 lab=_88202_/Q }
C {devices/lab_pin.sym} 105720 -4920 0 1 {name=p105309 lab=_66789_/X }
C {sky130_stdcells/and2_4.sym} 105660 -4920 0 0 {name=X_66789_ }
C {devices/lab_pin.sym} 105580 -4830 0 0 {name=p105310 lab=_59325_/X }
C {devices/lab_pin.sym} 105580 -4790 0 0 {name=p105311 lab=_59327_/Y }
C {devices/lab_pin.sym} 105580 -4750 0 0 {name=p105312 lab=_59328_/Y }
C {devices/lab_pin.sym} 105580 -4710 0 0 {name=p105313 lab=_59271_/X }
C {devices/lab_pin.sym} 105580 -4670 0 0 {name=p105314 lab=_59329_/X }
C {devices/lab_pin.sym} 105740 -4750 0 1 {name=p105315 lab=_59330_/X }
C {sky130_stdcells/o32a_4.sym} 105660 -4750 0 0 {name=X_59330_ }
C {devices/lab_pin.sym} 105600 -4610 0 0 {name=p105316 lab=_56538_/A }
C {devices/lab_pin.sym} 105600 -4570 0 0 {name=p105317 lab=_56535_/X }
C {devices/lab_pin.sym} 105600 -4530 0 0 {name=p105318 lab=_55715_/B }
C {devices/lab_pin.sym} 105720 -4570 0 1 {name=p105319 lab=_56542_/Y }
C {sky130_stdcells/nand3_4.sym} 105660 -4570 0 0 {name=X_56542_ }
C {devices/lab_pin.sym} 105570 -4430 0 0 {name=p105320 lab=_83973_/CLK }
C {devices/lab_pin.sym} 105570 -4410 0 0 {name=p105321 lab=_80806_/D }
C {devices/lab_pin.sym} 105750 -4430 0 1 {name=p105322 lab=_75750_/B }
C {sky130_stdcells/dfxtp_4.sym} 105660 -4420 0 0 {name=X_80806_ }
C {devices/lab_pin.sym} 105600 -4300 0 0 {name=p105323 lab=_68553_/A }
C {devices/lab_pin.sym} 105600 -4260 0 0 {name=p105324 lab=_68528_/B }
C {devices/lab_pin.sym} 105720 -4280 0 1 {name=p105325 lab=_68528_/X }
C {sky130_stdcells/and2_4.sym} 105660 -4280 0 0 {name=X_68528_ }
C {devices/lab_pin.sym} 105570 -4150 0 0 {name=p105326 lab=_88245_/CLK }
C {devices/lab_pin.sym} 105570 -4130 0 0 {name=p105327 lab=_87362_/D }
C {devices/lab_pin.sym} 105750 -4150 0 1 {name=p105328 lab=_87362_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -4140 0 0 {name=X_87362_ }
C {devices/lab_pin.sym} 105620 -4010 0 0 {name=p105329 lab=_53729_/A }
C {devices/lab_pin.sym} 105700 -4010 0 1 {name=p105330 lab=_53754_/X }
C {sky130_stdcells/buf_2.sym} 105660 -4010 0 0 {name=X_53754_ }
C {devices/lab_pin.sym} 105570 -3890 0 0 {name=p105331 lab=_84454_/CLK }
C {devices/lab_pin.sym} 105570 -3870 0 0 {name=p105332 lab=_84574_/D }
C {devices/lab_pin.sym} 105750 -3890 0 1 {name=p105333 lab=_60755_/C }
C {sky130_stdcells/dfxtp_4.sym} 105660 -3880 0 0 {name=X_84574_ }
C {devices/lab_pin.sym} 105620 -3750 0 0 {name=p105334 lab=_51021_/A }
C {devices/lab_pin.sym} 105700 -3750 0 1 {name=p105335 lab=_50971_/A }
C {sky130_stdcells/buf_2.sym} 105660 -3750 0 0 {name=X_50966_ }
C {devices/lab_pin.sym} 105570 -3630 0 0 {name=p105336 lab=_84980_/CLK }
C {devices/lab_pin.sym} 105570 -3610 0 0 {name=p105337 lab=_76154_/Y }
C {devices/lab_pin.sym} 105750 -3630 0 1 {name=p105338 lab=_48958_/B }
C {sky130_stdcells/dfxtp_4.sym} 105660 -3620 0 0 {name=X_81786_ }
C {devices/lab_pin.sym} 105570 -3490 0 0 {name=p105339 lab=_86312_/CLK }
C {devices/lab_pin.sym} 105570 -3470 0 0 {name=p105340 lab=_86313_/D }
C {devices/lab_pin.sym} 105750 -3490 0 1 {name=p105341 lab=_86313_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -3480 0 0 {name=X_86313_ }
C {devices/lab_pin.sym} 105580 -3370 0 0 {name=p105342 lab=_52701_/Y }
C {devices/lab_pin.sym} 105580 -3330 0 0 {name=p105343 lab=_52702_/X }
C {devices/lab_pin.sym} 105580 -3290 0 0 {name=p105344 lab=_52704_/X }
C {devices/lab_pin.sym} 105740 -3330 0 1 {name=p105345 lab=_52705_/Y }
C {sky130_stdcells/a21oi_4.sym} 105660 -3330 0 0 {name=X_52705_ }
C {devices/lab_pin.sym} 105580 -3210 0 0 {name=p105346 lab=_59135_/X }
C {devices/lab_pin.sym} 105580 -3170 0 0 {name=p105347 lab=_85644_/Q }
C {devices/lab_pin.sym} 105580 -3130 0 0 {name=p105348 lab=_59196_/X }
C {devices/lab_pin.sym} 105740 -3170 0 1 {name=p105349 lab=_59261_/X }
C {sky130_stdcells/o21a_4.sym} 105660 -3170 0 0 {name=X_59261_ }
C {devices/lab_pin.sym} 105570 -3030 0 0 {name=p105350 lab=_83526_/CLK }
C {devices/lab_pin.sym} 105570 -3010 0 0 {name=p105351 lab=_71362_/X }
C {devices/lab_pin.sym} 105750 -3030 0 1 {name=p105352 lab=_83525_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -3020 0 0 {name=X_83525_ }
C {devices/lab_pin.sym} 105580 -2910 0 0 {name=p105353 lab=_56462_/X }
C {devices/lab_pin.sym} 105580 -2870 0 0 {name=p105354 lab=_56016_/X }
C {devices/lab_pin.sym} 105580 -2830 0 0 {name=p105355 lab=_56472_/Y }
C {devices/lab_pin.sym} 105740 -2870 0 1 {name=p105356 lab=_56473_/Y }
C {sky130_stdcells/o21ai_4.sym} 105660 -2870 0 0 {name=X_56473_ }
C {devices/lab_pin.sym} 105580 -2760 0 0 {name=p105357 lab=_68301_/X }
C {devices/lab_pin.sym} 105580 -2720 0 0 {name=p105358 lab=_68446_/Y }
C {devices/lab_pin.sym} 105580 -2680 0 0 {name=p105359 lab=_68447_/X }
C {devices/lab_pin.sym} 105580 -2640 0 0 {name=p105360 lab=_68458_/Y }
C {devices/lab_pin.sym} 105740 -2700 0 1 {name=p105361 lab=_68459_/X }
C {sky130_stdcells/a211o_4.sym} 105660 -2700 0 0 {name=X_68459_ }
C {devices/lab_pin.sym} 105570 -2550 0 0 {name=p105362 lab=_81121_/CLK }
C {devices/lab_pin.sym} 105570 -2530 0 0 {name=p105363 lab=_80737_/D }
C {devices/lab_pin.sym} 105750 -2550 0 1 {name=p105364 lab=_80737_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -2540 0 0 {name=X_80737_ }
C {devices/lab_pin.sym} 105570 -2410 0 0 {name=p105365 lab=_87813_/CLK }
C {devices/lab_pin.sym} 105570 -2390 0 0 {name=p105366 lab=_43730_/Y }
C {devices/lab_pin.sym} 105750 -2410 0 1 {name=p105367 lab=_87293_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -2400 0 0 {name=X_87293_ }
C {devices/lab_pin.sym} 105600 -2290 0 0 {name=p105368 lab=_52166_/A }
C {devices/lab_pin.sym} 105600 -2250 0 0 {name=p105369 lab=_53666_/X }
C {devices/lab_pin.sym} 105600 -2210 0 0 {name=p105370 lab=_53692_/C }
C {devices/lab_pin.sym} 105720 -2250 0 1 {name=p105371 lab=_53685_/X }
C {sky130_stdcells/and3_4.sym} 105660 -2250 0 0 {name=X_53685_ }
C {devices/lab_pin.sym} 105620 -2110 0 0 {name=p105372 lab=_50952_/A }
C {devices/lab_pin.sym} 105700 -2110 0 1 {name=p105373 lab=_50897_/X }
C {sky130_stdcells/buf_2.sym} 105660 -2110 0 0 {name=X_50897_ }
C {devices/lab_pin.sym} 105580 -2010 0 0 {name=p105374 lab=_58191_/X }
C {devices/lab_pin.sym} 105580 -1970 0 0 {name=p105375 lab=_58209_/Y }
C {devices/lab_pin.sym} 105580 -1930 0 0 {name=p105376 lab=_58211_/Y }
C {devices/lab_pin.sym} 105740 -1970 0 1 {name=p105377 lab=_84907_/D }
C {sky130_stdcells/a21oi_4.sym} 105660 -1970 0 0 {name=X_58212_ }
C {devices/lab_pin.sym} 105600 -1840 0 0 {name=p105378 lab=_55297_/X }
C {devices/lab_pin.sym} 105600 -1800 0 0 {name=p105379 lab=_55373_/Y }
C {devices/lab_pin.sym} 105720 -1820 0 1 {name=p105380 lab=_57186_/B }
C {sky130_stdcells/xnor2_4.sym} 105660 -1820 0 0 {name=X_55424_ }
C {devices/lab_pin.sym} 105570 -1690 0 0 {name=p105381 lab=_85826_/CLK }
C {devices/lab_pin.sym} 105570 -1670 0 0 {name=p105382 lab=_86244_/D }
C {devices/lab_pin.sym} 105750 -1690 0 1 {name=p105383 lab=_86244_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -1680 0 0 {name=X_86244_ }
C {devices/lab_pin.sym} 105620 -1550 0 0 {name=p105384 lab=_40649_/Y }
C {devices/lab_pin.sym} 105700 -1550 0 1 {name=p105385 lab=_40650_/X }
C {sky130_stdcells/buf_2.sym} 105660 -1550 0 0 {name=X_40650_ }
C {devices/lab_pin.sym} 105580 -1450 0 0 {name=p105386 lab=_52633_/Y }
C {devices/lab_pin.sym} 105580 -1410 0 0 {name=p105387 lab=_52619_/X }
C {devices/lab_pin.sym} 105580 -1370 0 0 {name=p105388 lab=_52635_/X }
C {devices/lab_pin.sym} 105740 -1410 0 1 {name=p105389 lab=_85783_/D }
C {sky130_stdcells/a21oi_4.sym} 105660 -1410 0 0 {name=X_52636_ }
C {devices/lab_pin.sym} 105600 -1280 0 0 {name=p105390 lab=_59117_/A }
C {devices/lab_pin.sym} 105600 -1240 0 0 {name=p105391 lab=_86353_/Q }
C {devices/lab_pin.sym} 105720 -1260 0 1 {name=p105392 lab=_59192_/Y }
C {sky130_stdcells/nor2_4.sym} 105660 -1260 0 0 {name=X_59192_ }
C {devices/lab_pin.sym} 105620 -1130 0 0 {name=p105393 lab=_71418_/B }
C {devices/lab_pin.sym} 105700 -1130 0 1 {name=p105394 lab=_71479_/B }
C {sky130_stdcells/buf_2.sym} 105660 -1130 0 0 {name=X_71470_ }
C {devices/lab_pin.sym} 105570 -1010 0 0 {name=p105395 lab=_83457_/CLK }
C {devices/lab_pin.sym} 105570 -990 0 0 {name=p105396 lab=_83456_/D }
C {devices/lab_pin.sym} 105750 -1010 0 1 {name=p105397 lab=_83456_/Q }
C {sky130_stdcells/dfxtp_4.sym} 105660 -1000 0 0 {name=X_83456_ }
C {sky130_stdcells/decap_3.sym} 105660 -840 0 0 {name=XPHY_402 }
C {devices/lab_pin.sym} 105570 -690 0 0 {name=p105398 lab=_84531_/CLK }
C {devices/lab_pin.sym} 105570 -670 0 0 {name=p105399 lab=_80668_/D }
C {devices/lab_pin.sym} 105750 -690 0 1 {name=p105400 lab=_43945_/A }
C {sky130_stdcells/dfxtp_4.sym} 105660 -680 0 0 {name=X_80668_ }
C {sky130_stdcells/decap_3.sym} 106580 -42120 0 0 {name=XPHY_413 }
C {sky130_stdcells/decap_3.sym} 106580 -41940 0 0 {name=XPHY_424 }
C {devices/lab_pin.sym} 106500 -41810 0 0 {name=p105401 lab=_58139_/Y }
C {devices/lab_pin.sym} 106500 -41770 0 0 {name=p105402 lab=_58142_/Y }
C {devices/lab_pin.sym} 106500 -41730 0 0 {name=p105403 lab=_58105_/X }
C {devices/lab_pin.sym} 106660 -41770 0 1 {name=p105404 lab=_58143_/X }
C {sky130_stdcells/a21o_4.sym} 106580 -41770 0 0 {name=X_58143_ }
C {devices/lab_pin.sym} 106520 -41650 0 0 {name=p105405 lab=_71012_/A }
C {devices/lab_pin.sym} 106520 -41610 0 0 {name=p105406 lab=_70428_/A }
C {devices/lab_pin.sym} 106520 -41570 0 0 {name=p105407 lab=_70854_/A }
C {devices/lab_pin.sym} 106640 -41610 0 1 {name=p105408 lab=_70421_/Y }
C {sky130_stdcells/nor3_4.sym} 106580 -41610 0 0 {name=X_70421_ }
C {sky130_stdcells/decap_3.sym} 106580 -41440 0 0 {name=XPHY_435 }
C {devices/lab_pin.sym} 106490 -41290 0 0 {name=p105409 lab=_82443_/CLK }
C {devices/lab_pin.sym} 106490 -41270 0 0 {name=p105410 lab=_82439_/Q }
C {devices/lab_pin.sym} 106670 -41290 0 1 {name=p105411 lab=_78373_/A }
C {sky130_stdcells/dfxtp_4.sym} 106580 -41280 0 0 {name=X_82407_ }
C {devices/lab_pin.sym} 106500 -41180 0 0 {name=p105412 lab=_55356_/A }
C {devices/lab_pin.sym} 106500 -41140 0 0 {name=p105413 lab=_55362_/A }
C {devices/lab_pin.sym} 106500 -41100 0 0 {name=p105414 lab=_55353_/X }
C {devices/lab_pin.sym} 106500 -41060 0 0 {name=p105415 lab=_55354_/Y }
C {devices/lab_pin.sym} 106660 -41120 0 1 {name=p105416 lab=_55369_/A }
C {sky130_stdcells/a211o_4.sym} 106580 -41120 0 0 {name=X_55355_ }
C {devices/lab_pin.sym} 106490 -40970 0 0 {name=p105417 lab=_85566_/CLK }
C {devices/lab_pin.sym} 106490 -40950 0 0 {name=p105418 lab=_86175_/D }
C {devices/lab_pin.sym} 106670 -40970 0 1 {name=p105419 lab=_86175_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -40960 0 0 {name=X_86175_ }
C {devices/lab_pin.sym} 106540 -40830 0 0 {name=p105420 lab=_40581_/A }
C {devices/lab_pin.sym} 106620 -40830 0 1 {name=p105421 lab=_40581_/X }
C {sky130_stdcells/buf_2.sym} 106580 -40830 0 0 {name=X_40581_ }
C {devices/lab_pin.sym} 106520 -40720 0 0 {name=p105422 lab=_52567_/A }
C {devices/lab_pin.sym} 106520 -40680 0 0 {name=p105423 lab=_46585_/Y }
C {devices/lab_pin.sym} 106640 -40700 0 1 {name=p105424 lab=_52567_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -40700 0 0 {name=X_52567_ }
C {sky130_stdcells/decap_3.sym} 106580 -40540 0 0 {name=XPHY_446 }
C {devices/lab_pin.sym} 106490 -40390 0 0 {name=p105425 lab=_84945_/CLK }
C {devices/lab_pin.sym} 106490 -40370 0 0 {name=p105426 lab=_83387_/D }
C {devices/lab_pin.sym} 106670 -40390 0 1 {name=p105427 lab=_83387_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -40380 0 0 {name=X_83387_ }
C {devices/lab_pin.sym} 106540 -40250 0 0 {name=p105428 lab=_80598_/X }
C {devices/lab_pin.sym} 106620 -40250 0 1 {name=p105429 lab=_80599_/Y }
C {sky130_stdcells/inv_2.sym} 106580 -40250 0 0 {name=X_80599_ }
C {sky130_stdcells/decap_3.sym} 106580 -40100 0 0 {name=XPHY_457 }
C {sky130_stdcells/decap_3.sym} 106580 -39920 0 0 {name=XPHY_468 }
C {devices/lab_pin.sym} 106540 -39770 0 0 {name=p105430 lab=_42276_/A }
C {devices/lab_pin.sym} 106620 -39770 0 1 {name=p105431 lab=_42320_/X }
C {sky130_stdcells/buf_2.sym} 106580 -39770 0 0 {name=X_42320_ }
C {devices/lab_pin.sym} 106500 -39670 0 0 {name=p105432 lab=_85466_/Q }
C {devices/lab_pin.sym} 106500 -39630 0 0 {name=p105433 lab=_54294_/X }
C {devices/lab_pin.sym} 106500 -39590 0 0 {name=p105434 lab=_54305_/Y }
C {devices/lab_pin.sym} 106660 -39630 0 1 {name=p105435 lab=_54306_/Y }
C {sky130_stdcells/o21ai_4.sym} 106580 -39630 0 0 {name=X_54306_ }
C {devices/lab_pin.sym} 106520 -39500 0 0 {name=p105436 lab=_73137_/X }
C {devices/lab_pin.sym} 106520 -39460 0 0 {name=p105437 lab=_73139_/X }
C {devices/lab_pin.sym} 106640 -39480 0 1 {name=p105438 lab=_73141_/B }
C {sky130_stdcells/nand2_4.sym} 106580 -39480 0 0 {name=X_73140_ }
C {sky130_stdcells/decap_3.sym} 106580 -39320 0 0 {name=XPHY_479 }
C {devices/lab_pin.sym} 106490 -39170 0 0 {name=p105439 lab=_85134_/CLK }
C {devices/lab_pin.sym} 106490 -39150 0 0 {name=p105440 lab=_85126_/D }
C {devices/lab_pin.sym} 106670 -39170 0 1 {name=p105441 lab=_56887_/B }
C {sky130_stdcells/dfxtp_4.sym} 106580 -39160 0 0 {name=X_85126_ }
C {devices/lab_pin.sym} 106520 -39040 0 0 {name=p105442 lab=_51514_/A }
C {devices/lab_pin.sym} 106520 -39000 0 0 {name=p105443 lab=_53046_/B }
C {devices/lab_pin.sym} 106640 -39020 0 1 {name=p105444 lab=_51518_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -39020 0 0 {name=X_51518_ }
C {devices/lab_pin.sym} 106500 -38910 0 0 {name=p105445 lab=_58017_/X }
C {devices/lab_pin.sym} 106500 -38870 0 0 {name=p105446 lab=_85383_/Q }
C {devices/lab_pin.sym} 106500 -38830 0 0 {name=p105447 lab=_58073_/X }
C {devices/lab_pin.sym} 106660 -38870 0 1 {name=p105448 lab=_58074_/Y }
C {sky130_stdcells/o21ai_4.sym} 106580 -38870 0 0 {name=X_58074_ }
C {devices/lab_pin.sym} 106540 -38730 0 0 {name=p105449 lab=HASH_ADDR[3] }
C {devices/lab_pin.sym} 106620 -38730 0 1 {name=p105450 lab=_70496_/A }
C {sky130_stdcells/inv_2.sym} 106580 -38730 0 0 {name=X_70352_ }
C {devices/lab_pin.sym} 106490 -38610 0 0 {name=p105451 lab=_82103_/CLK }
C {devices/lab_pin.sym} 106490 -38590 0 0 {name=p105452 lab=_77049_/X }
C {devices/lab_pin.sym} 106670 -38610 0 1 {name=p105453 lab=_82338_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -38600 0 0 {name=X_82338_ }
C {devices/lab_pin.sym} 106520 -38490 0 0 {name=p105454 lab=_56868_/A }
C {devices/lab_pin.sym} 106520 -38450 0 0 {name=p105455 lab=_55671_/A }
C {devices/lab_pin.sym} 106520 -38410 0 0 {name=p105456 lab=_56868_/B }
C {devices/lab_pin.sym} 106640 -38450 0 1 {name=p105457 lab=_55286_/Y }
C {sky130_stdcells/nand3_4.sym} 106580 -38450 0 0 {name=X_55286_ }
C {devices/lab_pin.sym} 106520 -38330 0 0 {name=p105458 lab=_50802_/A }
C {devices/lab_pin.sym} 106520 -38290 0 0 {name=p105459 lab=_52446_/B }
C {devices/lab_pin.sym} 106520 -38250 0 0 {name=p105460 lab=_52498_/C }
C {devices/lab_pin.sym} 106640 -38290 0 1 {name=p105461 lab=_52498_/X }
C {sky130_stdcells/and3_4.sym} 106580 -38290 0 0 {name=X_52498_ }
C {devices/lab_pin.sym} 106520 -38160 0 0 {name=p105462 lab=_56800_/X }
C {devices/lab_pin.sym} 106520 -38120 0 0 {name=p105463 lab=_57024_/Y }
C {devices/lab_pin.sym} 106640 -38140 0 1 {name=p105464 lab=_57025_/X }
C {sky130_stdcells/xor2_4.sym} 106580 -38140 0 0 {name=X_57025_ }
C {devices/lab_pin.sym} 106500 -38040 0 0 {name=p105465 lab=_41437_/X }
C {devices/lab_pin.sym} 106500 -38000 0 0 {name=p105466 lab=_42248_/X }
C {devices/lab_pin.sym} 106500 -37960 0 0 {name=p105467 lab=_87959_/Q }
C {devices/lab_pin.sym} 106500 -37920 0 0 {name=p105468 lab=_42249_/X }
C {devices/lab_pin.sym} 106660 -37980 0 1 {name=p105469 lab=_87959_/D }
C {sky130_stdcells/a2bb2o_4.sym} 106580 -37980 0 0 {name=X_42251_ }
C {devices/lab_pin.sym} 106520 -37860 0 0 {name=p105470 lab=_54255_/A }
C {devices/lab_pin.sym} 106520 -37820 0 0 {name=p105471 lab=_54237_/B }
C {devices/lab_pin.sym} 106520 -37780 0 0 {name=p105472 lab=_54237_/C }
C {devices/lab_pin.sym} 106520 -37740 0 0 {name=p105473 lab=_53070_/D }
C {devices/lab_pin.sym} 106640 -37800 0 1 {name=p105474 lab=_54237_/X }
C {sky130_stdcells/and4_4.sym} 106580 -37800 0 0 {name=X_54237_ }
C {devices/lab_pin.sym} 106500 -37680 0 0 {name=p105475 lab=_72963_/X }
C {devices/lab_pin.sym} 106500 -37640 0 0 {name=p105476 lab=_83070_/Q }
C {devices/lab_pin.sym} 106500 -37600 0 0 {name=p105477 lab=_73015_/X }
C {devices/lab_pin.sym} 106500 -37560 0 0 {name=p105478 lab=_73070_/X }
C {devices/lab_pin.sym} 106660 -37620 0 1 {name=p105479 lab=_73071_/X }
C {sky130_stdcells/a211o_4.sym} 106580 -37620 0 0 {name=X_73071_ }
C {devices/lab_pin.sym} 106490 -37470 0 0 {name=p105480 lab=_85057_/CLK }
C {devices/lab_pin.sym} 106490 -37450 0 0 {name=p105481 lab=_85057_/D }
C {devices/lab_pin.sym} 106670 -37470 0 1 {name=p105482 lab=_85057_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -37460 0 0 {name=X_85057_ }
C {devices/lab_pin.sym} 106540 -37330 0 0 {name=p105483 lab=_46612_/A }
C {devices/lab_pin.sym} 106620 -37330 0 1 {name=p105484 lab=_52688_/A }
C {sky130_stdcells/buf_2.sym} 106580 -37330 0 0 {name=X_51449_ }
C {devices/lab_pin.sym} 106540 -37210 0 0 {name=p105485 lab=_70247_/X }
C {devices/lab_pin.sym} 106620 -37210 0 1 {name=p105486 lab=_70292_/B }
C {sky130_stdcells/buf_2.sym} 106580 -37210 0 0 {name=X_70283_ }
C {devices/lab_pin.sym} 106490 -37090 0 0 {name=p105487 lab=_83514_/CLK }
C {devices/lab_pin.sym} 106490 -37070 0 0 {name=p105488 lab=_82269_/D }
C {devices/lab_pin.sym} 106670 -37090 0 1 {name=p105489 lab=_82269_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -37080 0 0 {name=X_82269_ }
C {devices/lab_pin.sym} 106500 -36970 0 0 {name=p105490 lab=_41184_/X }
C {devices/lab_pin.sym} 106500 -36930 0 0 {name=p105491 lab=_81136_/Q }
C {devices/lab_pin.sym} 106500 -36890 0 0 {name=p105492 lab=_41201_/X }
C {devices/lab_pin.sym} 106660 -36930 0 1 {name=p105493 lab=_41203_/A }
C {sky130_stdcells/o21ai_4.sym} 106580 -36930 0 0 {name=X_41202_ }
C {devices/lab_pin.sym} 106520 -36800 0 0 {name=p105494 lab=_72017_/X }
C {devices/lab_pin.sym} 106520 -36760 0 0 {name=p105495 lab=_53848_/B }
C {devices/lab_pin.sym} 106640 -36780 0 1 {name=p105496 lab=_72022_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -36780 0 0 {name=X_72022_ }
C {devices/lab_pin.sym} 106490 -36650 0 0 {name=p105497 lab=_81783_/CLK }
C {devices/lab_pin.sym} 106490 -36630 0 0 {name=p105498 lab=_68224_/X }
C {devices/lab_pin.sym} 106670 -36650 0 1 {name=p105499 lab=_84008_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -36640 0 0 {name=X_84008_ }
C {devices/lab_pin.sym} 106500 -36540 0 0 {name=p105500 lab=_41259_/X }
C {devices/lab_pin.sym} 106500 -36500 0 0 {name=p105501 lab=_42161_/X }
C {devices/lab_pin.sym} 106500 -36460 0 0 {name=p105502 lab=_87993_/Q }
C {devices/lab_pin.sym} 106500 -36420 0 0 {name=p105503 lab=_42162_/X }
C {devices/lab_pin.sym} 106660 -36480 0 1 {name=p105504 lab=_87993_/D }
C {sky130_stdcells/a2bb2o_4.sym} 106580 -36480 0 0 {name=X_42182_ }
C {devices/lab_pin.sym} 106540 -36330 0 0 {name=p105505 lab=_54194_/A }
C {devices/lab_pin.sym} 106620 -36330 0 1 {name=p105506 lab=_54184_/A }
C {sky130_stdcells/buf_2.sym} 106580 -36330 0 0 {name=X_54168_ }
C {devices/lab_pin.sym} 106500 -36230 0 0 {name=p105507 lab=_53116_/Y }
C {devices/lab_pin.sym} 106500 -36190 0 0 {name=p105508 lab=_53111_/X }
C {devices/lab_pin.sym} 106500 -36150 0 0 {name=p105509 lab=_53118_/X }
C {devices/lab_pin.sym} 106660 -36190 0 1 {name=p105510 lab=_85694_/D }
C {sky130_stdcells/a21oi_4.sym} 106580 -36190 0 0 {name=X_53119_ }
C {devices/lab_pin.sym} 106500 -36070 0 0 {name=p105511 lab=_41100_/X }
C {devices/lab_pin.sym} 106500 -36030 0 0 {name=p105512 lab=_81149_/Q }
C {devices/lab_pin.sym} 106500 -35990 0 0 {name=p105513 lab=_41132_/X }
C {devices/lab_pin.sym} 106660 -36030 0 1 {name=p105514 lab=_41133_/Y }
C {sky130_stdcells/o21ai_4.sym} 106580 -36030 0 0 {name=X_41133_ }
C {devices/lab_pin.sym} 106520 -35900 0 0 {name=p105515 lab=_76812_/X }
C {devices/lab_pin.sym} 106520 -35860 0 0 {name=p105516 lab=_76825_/A }
C {devices/lab_pin.sym} 106640 -35880 0 1 {name=p105517 lab=_76831_/A }
C {sky130_stdcells/and2_4.sym} 106580 -35880 0 0 {name=X_76830_ }
C {devices/lab_pin.sym} 106540 -35750 0 0 {name=p105518 lab=_46990_/A }
C {devices/lab_pin.sym} 106620 -35750 0 1 {name=p105519 lab=_52790_/D }
C {sky130_stdcells/buf_2.sym} 106580 -35750 0 0 {name=X_46990_ }
C {devices/lab_pin.sym} 106540 -35630 0 0 {name=p105520 lab=_53418_/X }
C {devices/lab_pin.sym} 106620 -35630 0 1 {name=p105521 lab=_54123_/A }
C {sky130_stdcells/buf_2.sym} 106580 -35630 0 0 {name=X_54099_ }
C {devices/lab_pin.sym} 106520 -35520 0 0 {name=p105522 lab=_58976_/A }
C {devices/lab_pin.sym} 106520 -35480 0 0 {name=p105523 lab=_58973_/B }
C {devices/lab_pin.sym} 106640 -35500 0 1 {name=p105524 lab=_58976_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -35500 0 0 {name=X_58976_ }
C {devices/lab_pin.sym} 106540 -35370 0 0 {name=p105525 lab=_41064_/A }
C {devices/lab_pin.sym} 106620 -35370 0 1 {name=p105526 lab=_41064_/X }
C {sky130_stdcells/buf_2.sym} 106580 -35370 0 0 {name=X_41064_ }
C {devices/lab_pin.sym} 106540 -35250 0 0 {name=p105527 lab=_45941_/A }
C {devices/lab_pin.sym} 106620 -35250 0 1 {name=p105528 lab=_59539_/A }
C {sky130_stdcells/buf_2.sym} 106580 -35250 0 0 {name=X_45941_ }
C {devices/lab_pin.sym} 106500 -35150 0 0 {name=p105529 lab=_57773_/X }
C {devices/lab_pin.sym} 106500 -35110 0 0 {name=p105530 lab=_85715_/Q }
C {devices/lab_pin.sym} 106500 -35070 0 0 {name=p105531 lab=_44177_/X }
C {devices/lab_pin.sym} 106660 -35110 0 1 {name=p105532 lab=_57927_/X }
C {sky130_stdcells/o21a_4.sym} 106580 -35110 0 0 {name=X_57927_ }
C {devices/lab_pin.sym} 106500 -34990 0 0 {name=p105533 lab=_76746_/A }
C {devices/lab_pin.sym} 106500 -34950 0 0 {name=p105534 lab=_81357_/D }
C {devices/lab_pin.sym} 106500 -34910 0 0 {name=p105535 lab=_76760_/X }
C {devices/lab_pin.sym} 106660 -34950 0 1 {name=p105536 lab=_76761_/Y }
C {sky130_stdcells/o21ai_4.sym} 106580 -34950 0 0 {name=X_76761_ }
C {devices/lab_pin.sym} 106520 -34820 0 0 {name=p105537 lab=_73972_/X }
C {devices/lab_pin.sym} 106520 -34780 0 0 {name=p105538 lab=_66155_/B }
C {devices/lab_pin.sym} 106640 -34800 0 1 {name=p105539 lab=_73973_/X }
C {sky130_stdcells/and2_4.sym} 106580 -34800 0 0 {name=X_73973_ }
C {devices/lab_pin.sym} 106490 -34670 0 0 {name=p105540 lab=_85959_/CLK }
C {devices/lab_pin.sym} 106490 -34650 0 0 {name=p105541 lab=_51716_/Y }
C {devices/lab_pin.sym} 106670 -34670 0 1 {name=p105542 lab=_85959_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -34660 0 0 {name=X_85959_ }
C {devices/lab_pin.sym} 106520 -34540 0 0 {name=p105543 lab=_82511_/Q }
C {devices/lab_pin.sym} 106520 -34500 0 0 {name=p105544 lab=_82767_/D }
C {devices/lab_pin.sym} 106640 -34520 0 1 {name=p105545 lab=_82479_/D }
C {sky130_stdcells/xor2_4.sym} 106580 -34520 0 0 {name=X_78500_ }
C {devices/lab_pin.sym} 106520 -34400 0 0 {name=p105546 lab=_81009_/Q }
C {devices/lab_pin.sym} 106520 -34360 0 0 {name=p105547 lab=_75712_/B }
C {devices/lab_pin.sym} 106640 -34380 0 1 {name=p105548 lab=_75712_/X }
C {sky130_stdcells/xor2_4.sym} 106580 -34380 0 0 {name=X_75712_ }
C {devices/lab_pin.sym} 106540 -34250 0 0 {name=p105549 lab=_48660_/A }
C {devices/lab_pin.sym} 106620 -34250 0 1 {name=p105550 lab=_48851_/B }
C {sky130_stdcells/buf_2.sym} 106580 -34250 0 0 {name=X_48660_ }
C {devices/lab_pin.sym} 106520 -34140 0 0 {name=p105551 lab=_72924_/A }
C {devices/lab_pin.sym} 106520 -34100 0 0 {name=p105552 lab=_72924_/B }
C {devices/lab_pin.sym} 106640 -34120 0 1 {name=p105553 lab=_72924_/Y }
C {sky130_stdcells/nor2_4.sym} 106580 -34120 0 0 {name=X_72924_ }
C {devices/lab_pin.sym} 106540 -33990 0 0 {name=p105554 lab=_79480_/A }
C {devices/lab_pin.sym} 106620 -33990 0 1 {name=p105555 lab=_79480_/Y }
C {sky130_stdcells/inv_2.sym} 106580 -33990 0 0 {name=X_79480_ }
C {devices/lab_pin.sym} 106520 -33880 0 0 {name=p105556 lab=_86648_/Q }
C {devices/lab_pin.sym} 106520 -33840 0 0 {name=p105557 lab=_57845_/X }
C {devices/lab_pin.sym} 106640 -33860 0 1 {name=p105558 lab=_57858_/Y }
C {sky130_stdcells/nor2_4.sym} 106580 -33860 0 0 {name=X_57858_ }
C {devices/lab_pin.sym} 106500 -33760 0 0 {name=p105559 lab=_45870_/Y }
C {devices/lab_pin.sym} 106500 -33720 0 0 {name=p105560 lab=_44968_/X }
C {devices/lab_pin.sym} 106500 -33680 0 0 {name=p105561 lab=_44875_/X }
C {devices/lab_pin.sym} 106500 -33640 0 0 {name=p105562 lab=_45871_/Y }
C {devices/lab_pin.sym} 106660 -33700 0 1 {name=p105563 lab=_45872_/X }
C {sky130_stdcells/a211o_4.sym} 106580 -33700 0 0 {name=X_45872_ }
C {devices/lab_pin.sym} 106520 -33560 0 0 {name=p105564 lab=_81350_/D }
C {devices/lab_pin.sym} 106520 -33520 0 0 {name=p105565 lab=_76692_/B }
C {devices/lab_pin.sym} 106640 -33540 0 1 {name=p105566 lab=_76692_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -33540 0 0 {name=X_76692_ }
C {devices/lab_pin.sym} 106520 -33420 0 0 {name=p105567 lab=_47574_/A }
C {devices/lab_pin.sym} 106520 -33380 0 0 {name=p105568 lab=_53148_/B }
C {devices/lab_pin.sym} 106640 -33400 0 1 {name=p105569 lab=_47611_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -33400 0 0 {name=X_47611_ }
C {devices/lab_pin.sym} 106520 -33280 0 0 {name=p105570 lab=_82506_/Q }
C {devices/lab_pin.sym} 106520 -33240 0 0 {name=p105571 lab=_82762_/D }
C {devices/lab_pin.sym} 106640 -33260 0 1 {name=p105572 lab=_82474_/D }
C {sky130_stdcells/xor2_4.sym} 106580 -33260 0 0 {name=X_78431_ }
C {devices/lab_pin.sym} 106540 -33130 0 0 {name=p105573 lab=_44822_/Y }
C {devices/lab_pin.sym} 106620 -33130 0 1 {name=p105574 lab=_86936_/D }
C {sky130_stdcells/inv_2.sym} 106580 -33130 0 0 {name=X_44823_ }
C {devices/lab_pin.sym} 106540 -33010 0 0 {name=p105575 lab=_83322_/Q }
C {devices/lab_pin.sym} 106620 -33010 0 1 {name=p105576 lab=_56816_/A }
C {sky130_stdcells/buf_2.sym} 106580 -33010 0 0 {name=X_56809_ }
C {devices/lab_pin.sym} 106520 -32900 0 0 {name=p105577 lab=_75629_/X }
C {devices/lab_pin.sym} 106520 -32860 0 0 {name=p105578 lab=_75630_/A }
C {devices/lab_pin.sym} 106640 -32880 0 1 {name=p105579 lab=_75643_/X }
C {sky130_stdcells/and2_4.sym} 106580 -32880 0 0 {name=X_75643_ }
C {devices/lab_pin.sym} 106490 -32750 0 0 {name=p105580 lab=_88144_/CLK }
C {devices/lab_pin.sym} 106490 -32730 0 0 {name=p105581 lab=_42961_/X }
C {devices/lab_pin.sym} 106670 -32750 0 1 {name=p105582 lab=_87629_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -32740 0 0 {name=X_87629_ }
C {devices/lab_pin.sym} 106500 -32630 0 0 {name=p105583 lab=_48584_/Y }
C {devices/lab_pin.sym} 106500 -32590 0 0 {name=p105584 lab=_48585_/X }
C {devices/lab_pin.sym} 106500 -32550 0 0 {name=p105585 lab=_48590_/X }
C {devices/lab_pin.sym} 106660 -32590 0 1 {name=p105586 lab=_86509_/D }
C {sky130_stdcells/a21oi_4.sym} 106580 -32590 0 0 {name=X_48591_ }
C {devices/lab_pin.sym} 106520 -32460 0 0 {name=p105587 lab=_72855_/A }
C {devices/lab_pin.sym} 106520 -32420 0 0 {name=p105588 lab=_73438_/B }
C {devices/lab_pin.sym} 106640 -32440 0 1 {name=p105589 lab=_72855_/Y }
C {sky130_stdcells/nor2_4.sym} 106580 -32440 0 0 {name=X_72855_ }
C {devices/lab_pin.sym} 106540 -32310 0 0 {name=p105590 lab=_57788_/X }
C {devices/lab_pin.sym} 106620 -32310 0 1 {name=p105591 lab=_64621_/A }
C {sky130_stdcells/buf_2.sym} 106580 -32310 0 0 {name=X_57789_ }
C {devices/lab_pin.sym} 106500 -32210 0 0 {name=p105592 lab=_47538_/Y }
C {devices/lab_pin.sym} 106500 -32170 0 0 {name=p105593 lab=_47509_/X }
C {devices/lab_pin.sym} 106500 -32130 0 0 {name=p105594 lab=_47541_/X }
C {devices/lab_pin.sym} 106660 -32170 0 1 {name=p105595 lab=_86624_/D }
C {sky130_stdcells/a21oi_4.sym} 106580 -32170 0 0 {name=X_47542_ }
C {devices/lab_pin.sym} 106520 -32050 0 0 {name=p105596 lab=_71779_/A }
C {devices/lab_pin.sym} 106520 -32010 0 0 {name=p105597 lab=_71422_/C }
C {devices/lab_pin.sym} 106520 -31970 0 0 {name=p105598 lab=_70852_/C }
C {devices/lab_pin.sym} 106640 -32010 0 1 {name=p105599 lab=_71806_/X }
C {sky130_stdcells/and3_4.sym} 106580 -32010 0 0 {name=X_71806_ }
C {devices/lab_pin.sym} 106500 -31890 0 0 {name=p105600 lab=_44216_/X }
C {devices/lab_pin.sym} 106500 -31850 0 0 {name=p105601 lab=_44217_/X }
C {devices/lab_pin.sym} 106500 -31810 0 0 {name=p105602 lab=_45941_/A }
C {devices/lab_pin.sym} 106660 -31850 0 1 {name=p105603 lab=_59609_/D }
C {sky130_stdcells/a21oi_4.sym} 106580 -31850 0 0 {name=X_59528_ }
C {devices/lab_pin.sym} 106540 -31710 0 0 {name=p105604 lab=_78361_/Y }
C {devices/lab_pin.sym} 106620 -31710 0 1 {name=p105605 lab=_78362_/Y }
C {sky130_stdcells/inv_2.sym} 106580 -31710 0 0 {name=X_78362_ }
C {devices/lab_pin.sym} 106540 -31590 0 0 {name=p105606 lab=_44618_/A }
C {devices/lab_pin.sym} 106620 -31590 0 1 {name=p105607 lab=_44754_/X }
C {sky130_stdcells/buf_2.sym} 106580 -31590 0 0 {name=X_44754_ }
C {devices/lab_pin.sym} 106540 -31470 0 0 {name=p105608 lab=_75574_/A }
C {devices/lab_pin.sym} 106620 -31470 0 1 {name=p105609 lab=_75575_/A }
C {sky130_stdcells/inv_2.sym} 106580 -31470 0 0 {name=X_75574_ }
C {devices/lab_pin.sym} 106540 -31350 0 0 {name=p105610 lab=_88089_/Q }
C {devices/lab_pin.sym} 106620 -31350 0 1 {name=p105611 lab=_41966_/Y }
C {sky130_stdcells/inv_2.sym} 106580 -31350 0 0 {name=X_41966_ }
C {devices/lab_pin.sym} 106520 -31240 0 0 {name=p105612 lab=_72758_/X }
C {devices/lab_pin.sym} 106520 -31200 0 0 {name=p105613 lab=_65444_/B }
C {devices/lab_pin.sym} 106640 -31220 0 1 {name=p105614 lab=_72786_/X }
C {sky130_stdcells/and2_4.sym} 106580 -31220 0 0 {name=X_72786_ }
C {devices/lab_pin.sym} 106500 -31110 0 0 {name=p105615 lab=_77312_/Y }
C {devices/lab_pin.sym} 106500 -31070 0 0 {name=p105616 lab=_77292_/Y }
C {devices/lab_pin.sym} 106500 -31030 0 0 {name=p105617 lab=_77294_/Y }
C {devices/lab_pin.sym} 106660 -31070 0 1 {name=p105618 lab=_77315_/C }
C {sky130_stdcells/o21ai_4.sym} 106580 -31070 0 0 {name=X_77313_ }
C {devices/lab_pin.sym} 106540 -30930 0 0 {name=p105619 lab=_43705_/A }
C {devices/lab_pin.sym} 106620 -30930 0 1 {name=p105620 lab=_87302_/D }
C {sky130_stdcells/inv_2.sym} 106580 -30930 0 0 {name=X_43705_ }
C {devices/lab_pin.sym} 106520 -30840 0 0 {name=p105621 lab=_70383_/X }
C {devices/lab_pin.sym} 106520 -30800 0 0 {name=p105622 lab=_74518_/B }
C {devices/lab_pin.sym} 106520 -30760 0 0 {name=p105623 lab=_70880_/C }
C {devices/lab_pin.sym} 106520 -30720 0 0 {name=p105624 lab=_74531_/D }
C {devices/lab_pin.sym} 106640 -30780 0 1 {name=p105625 lab=_74525_/Y }
C {sky130_stdcells/nand4_4.sym} 106580 -30780 0 0 {name=X_74525_ }
C {devices/lab_pin.sym} 106500 -30670 0 0 {name=p105626 lab=_40870_/X }
C {devices/lab_pin.sym} 106500 -30630 0 0 {name=p105627 lab=_40871_/X }
C {devices/lab_pin.sym} 106500 -30590 0 0 {name=p105628 lab=_40914_/X }
C {devices/lab_pin.sym} 106500 -30550 0 0 {name=p105629 lab=_69935_/B }
C {devices/lab_pin.sym} 106500 -30510 0 0 {name=p105630 lab=_40916_/X }
C {devices/lab_pin.sym} 106660 -30590 0 1 {name=p105631 lab=_40918_/A }
C {sky130_stdcells/o32ai_4.sym} 106580 -30590 0 0 {name=X_40917_ }
C {devices/lab_pin.sym} 106540 -30430 0 0 {name=p105632 lab=_47473_/A }
C {devices/lab_pin.sym} 106620 -30430 0 1 {name=p105633 lab=_47474_/A }
C {sky130_stdcells/inv_2.sym} 106580 -30430 0 0 {name=X_47473_ }
C {devices/lab_pin.sym} 106540 -30310 0 0 {name=p105634 lab=_71736_/X }
C {devices/lab_pin.sym} 106620 -30310 0 1 {name=p105635 lab=_71737_/X }
C {sky130_stdcells/buf_2.sym} 106580 -30310 0 0 {name=X_71737_ }
C {devices/lab_pin.sym} 106540 -30190 0 0 {name=p105636 lab=_84726_/Q }
C {devices/lab_pin.sym} 106620 -30190 0 1 {name=p105637 lab=_59460_/A }
C {sky130_stdcells/inv_2.sym} 106580 -30190 0 0 {name=X_59459_ }
C {devices/lab_pin.sym} 106520 -30080 0 0 {name=p105638 lab=_82687_/Q }
C {devices/lab_pin.sym} 106520 -30040 0 0 {name=p105639 lab=_78293_/B }
C {devices/lab_pin.sym} 106640 -30060 0 1 {name=p105640 lab=_78293_/X }
C {sky130_stdcells/xor2_4.sym} 106580 -30060 0 0 {name=X_78293_ }
C {devices/lab_pin.sym} 106500 -29970 0 0 {name=p105641 lab=_44593_/X }
C {devices/lab_pin.sym} 106500 -29930 0 0 {name=p105642 lab=_44594_/X }
C {devices/lab_pin.sym} 106500 -29890 0 0 {name=p105643 lab=_40616_/Y }
C {devices/lab_pin.sym} 106500 -29850 0 0 {name=p105644 lab=_44684_/Y }
C {devices/lab_pin.sym} 106500 -29810 0 0 {name=p105645 lab=_44596_/X }
C {devices/lab_pin.sym} 106660 -29890 0 1 {name=p105646 lab=_44685_/Y }
C {sky130_stdcells/o32ai_4.sym} 106580 -29890 0 0 {name=X_44685_ }
C {devices/lab_pin.sym} 106540 -29730 0 0 {name=p105647 lab=clkbuf_9_286_0_CLK/X }
C {devices/lab_pin.sym} 106620 -29730 0 1 {name=p105648 lab=_82899_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 106580 -29730 0 0 {name=Xclkbuf_10_573_0_CLK }
C {devices/lab_pin.sym} 106500 -29650 0 0 {name=p105649 lab=_41894_/X }
C {devices/lab_pin.sym} 106500 -29610 0 0 {name=p105650 lab=_41879_/X }
C {devices/lab_pin.sym} 106500 -29570 0 0 {name=p105651 lab=_40610_/X }
C {devices/lab_pin.sym} 106500 -29530 0 0 {name=p105652 lab=_73675_/A }
C {devices/lab_pin.sym} 106500 -29490 0 0 {name=p105653 lab=_41882_/X }
C {devices/lab_pin.sym} 106660 -29570 0 1 {name=p105654 lab=_41897_/Y }
C {sky130_stdcells/o32ai_4.sym} 106580 -29570 0 0 {name=X_41897_ }
C {devices/lab_pin.sym} 106520 -29420 0 0 {name=p105655 lab=_49212_/A }
C {devices/lab_pin.sym} 106520 -29380 0 0 {name=p105656 lab=_49212_/B }
C {devices/lab_pin.sym} 106640 -29400 0 1 {name=p105657 lab=_49212_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -29400 0 0 {name=X_49212_ }
C {devices/lab_pin.sym} 106540 -29270 0 0 {name=p105658 lab=_82930_/Q }
C {devices/lab_pin.sym} 106620 -29270 0 1 {name=p105659 lab=_47991_/B }
C {sky130_stdcells/inv_2.sym} 106580 -29270 0 0 {name=X_46424_ }
C {devices/lab_pin.sym} 106500 -29170 0 0 {name=p105660 lab=_77245_/A }
C {devices/lab_pin.sym} 106500 -29130 0 0 {name=p105661 lab=_77245_/C }
C {devices/lab_pin.sym} 106500 -29090 0 0 {name=p105662 lab=_77243_/X }
C {devices/lab_pin.sym} 106660 -29130 0 1 {name=p105663 lab=_77244_/X }
C {sky130_stdcells/a21o_4.sym} 106580 -29130 0 0 {name=X_77244_ }
C {devices/lab_pin.sym} 106540 -28990 0 0 {name=p105664 lab=_43611_/A }
C {devices/lab_pin.sym} 106620 -28990 0 1 {name=p105665 lab=_43636_/X }
C {sky130_stdcells/buf_2.sym} 106580 -28990 0 0 {name=X_43636_ }
C {devices/lab_pin.sym} 106520 -28900 0 0 {name=p105666 lab=_62415_/X }
C {devices/lab_pin.sym} 106520 -28860 0 0 {name=p105667 lab=_62005_/A }
C {devices/lab_pin.sym} 106520 -28820 0 0 {name=p105668 lab=_62618_/D }
C {devices/lab_pin.sym} 106520 -28780 0 0 {name=p105669 lab=_62194_/D }
C {devices/lab_pin.sym} 106640 -28840 0 1 {name=p105670 lab=_62470_/X }
C {sky130_stdcells/and4_4.sym} 106580 -28840 0 0 {name=X_62470_ }
C {devices/lab_pin.sym} 106520 -28700 0 0 {name=p105671 lab=_74442_/X }
C {devices/lab_pin.sym} 106520 -28660 0 0 {name=p105672 lab=_48572_/A }
C {devices/lab_pin.sym} 106640 -28680 0 1 {name=p105673 lab=_74456_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -28680 0 0 {name=X_74456_ }
C {devices/lab_pin.sym} 106500 -28570 0 0 {name=p105674 lab=_40783_/X }
C {devices/lab_pin.sym} 106500 -28530 0 0 {name=p105675 lab=_41026_/A }
C {devices/lab_pin.sym} 106500 -28490 0 0 {name=p105676 lab=_40847_/X }
C {devices/lab_pin.sym} 106660 -28530 0 1 {name=p105677 lab=_40848_/X }
C {sky130_stdcells/o21a_4.sym} 106580 -28530 0 0 {name=X_40848_ }
C {devices/lab_pin.sym} 106520 -28400 0 0 {name=p105678 lab=_71528_/X }
C {devices/lab_pin.sym} 106520 -28360 0 0 {name=p105679 lab=_71289_/B }
C {devices/lab_pin.sym} 106640 -28380 0 1 {name=p105680 lab=_71669_/A }
C {sky130_stdcells/nor2_4.sym} 106580 -28380 0 0 {name=X_71668_ }
C {devices/lab_pin.sym} 106540 -28250 0 0 {name=p105681 lab=_83599_/Q }
C {devices/lab_pin.sym} 106620 -28250 0 1 {name=p105682 lab=_49144_/A }
C {sky130_stdcells/inv_2.sym} 106580 -28250 0 0 {name=X_49143_ }
C {devices/lab_pin.sym} 106520 -28160 0 0 {name=p105683 lab=_61421_/A }
C {devices/lab_pin.sym} 106520 -28120 0 0 {name=p105684 lab=_61404_/X }
C {devices/lab_pin.sym} 106520 -28080 0 0 {name=p105685 lab=_61406_/C }
C {devices/lab_pin.sym} 106520 -28040 0 0 {name=p105686 lab=_61390_/D }
C {devices/lab_pin.sym} 106640 -28100 0 1 {name=p105687 lab=_61421_/Y }
C {sky130_stdcells/nand4_4.sym} 106580 -28100 0 0 {name=X_61421_ }
C {devices/lab_pin.sym} 106520 -27960 0 0 {name=p105688 lab=_73407_/A }
C {devices/lab_pin.sym} 106520 -27920 0 0 {name=p105689 lab=_86504_/Q }
C {devices/lab_pin.sym} 106640 -27940 0 1 {name=p105690 lab=_73407_/X }
C {sky130_stdcells/and2_4.sym} 106580 -27940 0 0 {name=X_73407_ }
C {devices/lab_pin.sym} 106540 -27810 0 0 {name=p105691 lab=_83648_/Q }
C {devices/lab_pin.sym} 106620 -27810 0 1 {name=p105692 lab=_53985_/B }
C {sky130_stdcells/inv_2.sym} 106580 -27810 0 0 {name=X_46355_ }
C {devices/lab_pin.sym} 106540 -27690 0 0 {name=p105693 lab=_71005_/A }
C {devices/lab_pin.sym} 106620 -27690 0 1 {name=p105694 lab=_70724_/A }
C {sky130_stdcells/buf_2.sym} 106580 -27690 0 0 {name=X_70619_ }
C {devices/lab_pin.sym} 106520 -27580 0 0 {name=p105695 lab=_77175_/A }
C {devices/lab_pin.sym} 106520 -27540 0 0 {name=p105696 lab=_77173_/C }
C {devices/lab_pin.sym} 106640 -27560 0 1 {name=p105697 lab=_77175_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -27560 0 0 {name=X_77175_ }
C {devices/lab_pin.sym} 106500 -27470 0 0 {name=p105698 lab=_43557_/X }
C {devices/lab_pin.sym} 106500 -27430 0 0 {name=p105699 lab=_43563_/X }
C {devices/lab_pin.sym} 106500 -27390 0 0 {name=p105700 lab=_40501_/X }
C {devices/lab_pin.sym} 106500 -27350 0 0 {name=p105701 lab=_87357_/Q }
C {devices/lab_pin.sym} 106500 -27310 0 0 {name=p105702 lab=_43058_/A }
C {devices/lab_pin.sym} 106660 -27390 0 1 {name=p105703 lab=_43568_/A }
C {sky130_stdcells/o32ai_4.sym} 106580 -27390 0 0 {name=X_43567_ }
C {devices/lab_pin.sym} 106540 -27230 0 0 {name=p105704 lab=_46623_/A }
C {devices/lab_pin.sym} 106620 -27230 0 1 {name=p105705 lab=_74387_/X }
C {sky130_stdcells/buf_2.sym} 106580 -27230 0 0 {name=X_74387_ }
C {devices/lab_pin.sym} 106520 -27120 0 0 {name=p105706 lab=_82878_/Q }
C {devices/lab_pin.sym} 106520 -27080 0 0 {name=p105707 lab=_40779_/B }
C {devices/lab_pin.sym} 106640 -27100 0 1 {name=p105708 lab=_40779_/X }
C {sky130_stdcells/or2_4.sym} 106580 -27100 0 0 {name=X_40779_ }
C {devices/lab_pin.sym} 106500 -26990 0 0 {name=p105709 lab=_71581_/A }
C {devices/lab_pin.sym} 106500 -26950 0 0 {name=p105710 lab=_83443_/Q }
C {devices/lab_pin.sym} 106500 -26910 0 0 {name=p105711 lab=_71598_/Y }
C {devices/lab_pin.sym} 106660 -26950 0 1 {name=p105712 lab=_83443_/D }
C {sky130_stdcells/a21o_4.sym} 106580 -26950 0 0 {name=X_71599_ }
C {devices/lab_pin.sym} 106520 -26820 0 0 {name=p105713 lab=_45305_/Y }
C {devices/lab_pin.sym} 106520 -26780 0 0 {name=p105714 lab=_45272_/X }
C {devices/lab_pin.sym} 106640 -26800 0 1 {name=p105715 lab=_45306_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -26800 0 0 {name=X_45306_ }
C {devices/lab_pin.sym} 106520 -26690 0 0 {name=p105716 lab=_64187_/A }
C {devices/lab_pin.sym} 106520 -26650 0 0 {name=p105717 lab=_64187_/B }
C {devices/lab_pin.sym} 106520 -26610 0 0 {name=p105718 lab=_84271_/Q }
C {devices/lab_pin.sym} 106640 -26650 0 1 {name=p105719 lab=_64140_/Y }
C {sky130_stdcells/nor3_4.sym} 106580 -26650 0 0 {name=X_64140_ }
C {devices/lab_pin.sym} 106520 -26530 0 0 {name=p105720 lab=_76126_/A }
C {devices/lab_pin.sym} 106520 -26490 0 0 {name=p105721 lab=_81724_/D }
C {devices/lab_pin.sym} 106520 -26450 0 0 {name=p105722 lab=_76126_/C }
C {devices/lab_pin.sym} 106640 -26490 0 1 {name=p105723 lab=_76126_/Y }
C {sky130_stdcells/nand3_4.sym} 106580 -26490 0 0 {name=X_76126_ }
C {devices/lab_pin.sym} 106540 -26350 0 0 {name=p105724 lab=_42518_/A }
C {devices/lab_pin.sym} 106620 -26350 0 1 {name=p105725 lab=_42518_/Y }
C {sky130_stdcells/inv_2.sym} 106580 -26350 0 0 {name=X_42518_ }
C {devices/lab_pin.sym} 106520 -26250 0 0 {name=p105726 lab=_61384_/A }
C {devices/lab_pin.sym} 106520 -26210 0 0 {name=p105727 lab=_61384_/B }
C {devices/lab_pin.sym} 106520 -26170 0 0 {name=p105728 lab=_84488_/Q }
C {devices/lab_pin.sym} 106640 -26210 0 1 {name=p105729 lab=_61352_/Y }
C {sky130_stdcells/nor3_4.sym} 106580 -26210 0 0 {name=X_61352_ }
C {devices/lab_pin.sym} 106520 -26080 0 0 {name=p105730 lab=_49056_/A }
C {devices/lab_pin.sym} 106520 -26040 0 0 {name=p105731 lab=_49073_/X }
C {devices/lab_pin.sym} 106640 -26060 0 1 {name=p105732 lab=_49074_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -26060 0 0 {name=X_49074_ }
C {devices/lab_pin.sym} 106520 -25940 0 0 {name=p105733 lab=_73328_/Y }
C {devices/lab_pin.sym} 106520 -25900 0 0 {name=p105734 lab=_73337_/X }
C {devices/lab_pin.sym} 106640 -25920 0 1 {name=p105735 lab=_73339_/B }
C {sky130_stdcells/xnor2_4.sym} 106580 -25920 0 0 {name=X_73338_ }
C {devices/lab_pin.sym} 106540 -25790 0 0 {name=p105736 lab=clkbuf_9_294_0_CLK/X }
C {devices/lab_pin.sym} 106620 -25790 0 1 {name=p105737 lab=_81134_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 106580 -25790 0 0 {name=Xclkbuf_10_588_0_CLK }
C {devices/lab_pin.sym} 106500 -25690 0 0 {name=p105738 lab=_46262_/X }
C {devices/lab_pin.sym} 106500 -25650 0 0 {name=p105739 lab=_48915_/A }
C {devices/lab_pin.sym} 106500 -25610 0 0 {name=p105740 lab=_46285_/X }
C {devices/lab_pin.sym} 106660 -25650 0 1 {name=p105741 lab=_51251_/B }
C {sky130_stdcells/o21ai_4.sym} 106580 -25650 0 0 {name=X_46286_ }
C {devices/lab_pin.sym} 106540 -25510 0 0 {name=p105742 lab=_43513_/A }
C {devices/lab_pin.sym} 106620 -25510 0 1 {name=p105743 lab=_43498_/X }
C {sky130_stdcells/buf_2.sym} 106580 -25510 0 0 {name=X_43498_ }
C {devices/lab_pin.sym} 106500 -25410 0 0 {name=p105744 lab=_66168_/B }
C {devices/lab_pin.sym} 106500 -25370 0 0 {name=p105745 lab=_47998_/X }
C {devices/lab_pin.sym} 106500 -25330 0 0 {name=p105746 lab=_48024_/Y }
C {devices/lab_pin.sym} 106660 -25370 0 1 {name=p105747 lab=_48025_/Y }
C {sky130_stdcells/o21ai_4.sym} 106580 -25370 0 0 {name=X_48025_ }
C {devices/lab_pin.sym} 106520 -25260 0 0 {name=p105748 lab=_60239_/B }
C {devices/lab_pin.sym} 106520 -25220 0 0 {name=p105749 lab=_60189_/Y }
C {devices/lab_pin.sym} 106520 -25180 0 0 {name=p105750 lab=_60302_/X }
C {devices/lab_pin.sym} 106520 -25140 0 0 {name=p105751 lab=_60227_/A }
C {devices/lab_pin.sym} 106640 -25200 0 1 {name=p105752 lab=_60304_/A }
C {sky130_stdcells/nand4_4.sym} 106580 -25200 0 0 {name=X_60303_ }
C {devices/lab_pin.sym} 106540 -25050 0 0 {name=p105753 lab=_45237_/A }
C {devices/lab_pin.sym} 106620 -25050 0 1 {name=p105754 lab=_45237_/X }
C {sky130_stdcells/buf_2.sym} 106580 -25050 0 0 {name=X_45237_ }
C {devices/lab_pin.sym} 106520 -24950 0 0 {name=p105755 lab=_64162_/A }
C {devices/lab_pin.sym} 106520 -24910 0 0 {name=p105756 lab=_58452_/A }
C {devices/lab_pin.sym} 106520 -24870 0 0 {name=p105757 lab=_64071_/C }
C {devices/lab_pin.sym} 106640 -24910 0 1 {name=p105758 lab=_64071_/X }
C {sky130_stdcells/and3_4.sym} 106580 -24910 0 0 {name=X_64071_ }
C {devices/lab_pin.sym} 106520 -24780 0 0 {name=p105759 lab=_76063_/B }
C {devices/lab_pin.sym} 106520 -24740 0 0 {name=p105760 lab=_76063_/C }
C {devices/lab_pin.sym} 106640 -24760 0 1 {name=p105761 lab=_76057_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -24760 0 0 {name=X_76057_ }
C {devices/lab_pin.sym} 106500 -24650 0 0 {name=p105762 lab=_47872_/A }
C {devices/lab_pin.sym} 106500 -24610 0 0 {name=p105763 lab=_41902_/A }
C {devices/lab_pin.sym} 106500 -24570 0 0 {name=p105764 lab=_52398_/A }
C {devices/lab_pin.sym} 106660 -24610 0 1 {name=p105765 lab=_42449_/Y }
C {sky130_stdcells/a21oi_4.sym} 106580 -24610 0 0 {name=X_42449_ }
C {devices/lab_pin.sym} 106520 -24490 0 0 {name=p105766 lab=_61293_/B }
C {devices/lab_pin.sym} 106520 -24450 0 0 {name=p105767 lab=_59660_/C }
C {devices/lab_pin.sym} 106520 -24410 0 0 {name=p105768 lab=_59660_/D }
C {devices/lab_pin.sym} 106640 -24450 0 1 {name=p105769 lab=_61283_/Y }
C {sky130_stdcells/nand3_4.sym} 106580 -24450 0 0 {name=X_61283_ }
C {devices/lab_pin.sym} 106500 -24330 0 0 {name=p105770 lab=_73270_/B }
C {devices/lab_pin.sym} 106500 -24290 0 0 {name=p105771 lab=_73270_/C }
C {devices/lab_pin.sym} 106500 -24250 0 0 {name=p105772 lab=_73268_/X }
C {devices/lab_pin.sym} 106660 -24290 0 1 {name=p105773 lab=_73269_/X }
C {sky130_stdcells/a21o_4.sym} 106580 -24290 0 0 {name=X_73269_ }
C {devices/lab_pin.sym} 106520 -24180 0 0 {name=p105774 lab=_63022_/A }
C {devices/lab_pin.sym} 106520 -24140 0 0 {name=p105775 lab=_63004_/B }
C {devices/lab_pin.sym} 106520 -24100 0 0 {name=p105776 lab=_63004_/C }
C {devices/lab_pin.sym} 106520 -24060 0 0 {name=p105777 lab=_63252_/B }
C {devices/lab_pin.sym} 106640 -24120 0 1 {name=p105778 lab=_63022_/X }
C {sky130_stdcells/or4_4.sym} 106580 -24120 0 0 {name=X_63022_ }
C {devices/lab_pin.sym} 106520 -23980 0 0 {name=p105779 lab=_75008_/A }
C {devices/lab_pin.sym} 106520 -23940 0 0 {name=p105780 lab=_75008_/B }
C {devices/lab_pin.sym} 106640 -23960 0 1 {name=p105781 lab=_75008_/X }
C {sky130_stdcells/or2_4.sym} 106580 -23960 0 0 {name=X_75008_ }
C {devices/lab_pin.sym} 106520 -23840 0 0 {name=p105782 lab=_60288_/C }
C {devices/lab_pin.sym} 106520 -23800 0 0 {name=p105783 lab=_60217_/A }
C {devices/lab_pin.sym} 106640 -23820 0 1 {name=p105784 lab=_60235_/A }
C {sky130_stdcells/and2_4.sym} 106580 -23820 0 0 {name=X_60234_ }
C {devices/lab_pin.sym} 106540 -23690 0 0 {name=p105785 lab=_45168_/A }
C {devices/lab_pin.sym} 106620 -23690 0 1 {name=p105786 lab=_45169_/A }
C {sky130_stdcells/inv_2.sym} 106580 -23690 0 0 {name=X_45168_ }
C {devices/lab_pin.sym} 106540 -23570 0 0 {name=p105787 lab=clkbuf_9_255_0_CLK/X }
C {devices/lab_pin.sym} 106620 -23570 0 1 {name=p105788 lab=_82769_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 106580 -23570 0 0 {name=Xclkbuf_10_511_0_CLK }
C {devices/lab_pin.sym} 106500 -23470 0 0 {name=p105789 lab=_81485_/D }
C {devices/lab_pin.sym} 106500 -23430 0 0 {name=p105790 lab=_67806_/X }
C {devices/lab_pin.sym} 106500 -23390 0 0 {name=p105791 lab=_67829_/X }
C {devices/lab_pin.sym} 106660 -23430 0 1 {name=p105792 lab=_84053_/D }
C {sky130_stdcells/a21bo_4.sym} 106580 -23430 0 0 {name=X_67830_ }
C {devices/lab_pin.sym} 106520 -23300 0 0 {name=p105793 lab=_44119_/A }
C {devices/lab_pin.sym} 106520 -23260 0 0 {name=p105794 lab=_86770_/Q }
C {devices/lab_pin.sym} 106640 -23280 0 1 {name=p105795 lab=_44119_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -23280 0 0 {name=X_44119_ }
C {devices/lab_pin.sym} 106520 -23160 0 0 {name=p105796 lab=_84227_/Q }
C {devices/lab_pin.sym} 106520 -23120 0 0 {name=p105797 lab=_83275_/Q }
C {devices/lab_pin.sym} 106640 -23140 0 1 {name=p105798 lab=_79816_/X }
C {sky130_stdcells/xor2_4.sym} 106580 -23140 0 0 {name=X_79816_ }
C {devices/lab_pin.sym} 106520 -23020 0 0 {name=p105799 lab=_60165_/A }
C {devices/lab_pin.sym} 106520 -22980 0 0 {name=p105800 lab=_59602_/A }
C {devices/lab_pin.sym} 106640 -23000 0 1 {name=p105801 lab=_60165_/X }
C {sky130_stdcells/and2_4.sym} 106580 -23000 0 0 {name=X_60165_ }
C {devices/lab_pin.sym} 106500 -22890 0 0 {name=p105802 lab=_86288_/Q }
C {devices/lab_pin.sym} 106500 -22850 0 0 {name=p105803 lab=_49960_/X }
C {devices/lab_pin.sym} 106500 -22810 0 0 {name=p105804 lab=_49975_/Y }
C {devices/lab_pin.sym} 106660 -22850 0 1 {name=p105805 lab=_49976_/Y }
C {sky130_stdcells/o21ai_4.sym} 106580 -22850 0 0 {name=X_49976_ }
C {devices/lab_pin.sym} 106500 -22730 0 0 {name=p105806 lab=_45092_/X }
C {devices/lab_pin.sym} 106500 -22690 0 0 {name=p105807 lab=_45096_/Y }
C {devices/lab_pin.sym} 106500 -22650 0 0 {name=p105808 lab=_45098_/Y }
C {devices/lab_pin.sym} 106660 -22690 0 1 {name=p105809 lab=_86899_/D }
C {sky130_stdcells/a21oi_4.sym} 106580 -22690 0 0 {name=X_45099_ }
C {devices/lab_pin.sym} 106540 -22550 0 0 {name=p105810 lab=_48623_/A }
C {devices/lab_pin.sym} 106620 -22550 0 1 {name=p105811 lab=_48928_/C }
C {sky130_stdcells/buf_2.sym} 106580 -22550 0 0 {name=X_48927_ }
C {devices/lab_pin.sym} 106540 -22430 0 0 {name=p105812 lab=_67997_/A }
C {devices/lab_pin.sym} 106620 -22430 0 1 {name=p105813 lab=_67761_/X }
C {sky130_stdcells/buf_2.sym} 106580 -22430 0 0 {name=X_67761_ }
C {devices/lab_pin.sym} 106520 -22320 0 0 {name=p105814 lab=_79731_/Y }
C {devices/lab_pin.sym} 106520 -22280 0 0 {name=p105815 lab=_79734_/Y }
C {devices/lab_pin.sym} 106640 -22300 0 1 {name=p105816 lab=_79747_/X }
C {sky130_stdcells/or2_4.sym} 106580 -22300 0 0 {name=X_79747_ }
C {devices/lab_pin.sym} 106540 -22170 0 0 {name=p105817 lab=_64601_/A }
C {devices/lab_pin.sym} 106620 -22170 0 1 {name=p105818 lab=_65074_/A }
C {sky130_stdcells/buf_2.sym} 106580 -22170 0 0 {name=X_64973_ }
C {devices/lab_pin.sym} 106500 -22070 0 0 {name=p105819 lab=_60058_/B }
C {devices/lab_pin.sym} 106500 -22030 0 0 {name=p105820 lab=_59995_/X }
C {devices/lab_pin.sym} 106500 -21990 0 0 {name=p105821 lab=_60095_/X }
C {devices/lab_pin.sym} 106660 -22030 0 1 {name=p105822 lab=_60096_/Y }
C {sky130_stdcells/a21boi_4.sym} 106580 -22030 0 0 {name=X_60096_ }
C {devices/lab_pin.sym} 106540 -21890 0 0 {name=p105823 lab=_76792_/Y }
C {devices/lab_pin.sym} 106620 -21890 0 1 {name=p105824 lab=_81362_/D }
C {sky130_stdcells/inv_2.sym} 106580 -21890 0 0 {name=X_76959_ }
C {devices/lab_pin.sym} 106540 -21770 0 0 {name=p105825 lab=_69575_/A }
C {devices/lab_pin.sym} 106620 -21770 0 1 {name=p105826 lab=_69500_/X }
C {sky130_stdcells/buf_2.sym} 106580 -21770 0 0 {name=X_69500_ }
C {devices/lab_pin.sym} 106520 -21660 0 0 {name=p105827 lab=_66664_/X }
C {devices/lab_pin.sym} 106520 -21620 0 0 {name=p105828 lab=_86800_/Q }
C {devices/lab_pin.sym} 106640 -21640 0 1 {name=p105829 lab=_66712_/X }
C {sky130_stdcells/and2_4.sym} 106580 -21640 0 0 {name=X_66712_ }
C {devices/lab_pin.sym} 106520 -21540 0 0 {name=p105830 lab=_61461_/X }
C {devices/lab_pin.sym} 106520 -21500 0 0 {name=p105831 lab=_63908_/B }
C {devices/lab_pin.sym} 106520 -21460 0 0 {name=p105832 lab=_63894_/C }
C {devices/lab_pin.sym} 106520 -21420 0 0 {name=p105833 lab=_63908_/D }
C {devices/lab_pin.sym} 106640 -21480 0 1 {name=p105834 lab=_63924_/Y }
C {sky130_stdcells/nand4_4.sym} 106580 -21480 0 0 {name=X_63924_ }
C {devices/lab_pin.sym} 106540 -21330 0 0 {name=p105835 lab=_48833_/A }
C {devices/lab_pin.sym} 106620 -21330 0 1 {name=p105836 lab=_48859_/B }
C {sky130_stdcells/buf_2.sym} 106580 -21330 0 0 {name=X_48858_ }
C {devices/lab_pin.sym} 106540 -21210 0 0 {name=p105837 lab=clkbuf_9_263_0_CLK/X }
C {devices/lab_pin.sym} 106620 -21210 0 1 {name=p105838 lab=_81532_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 106580 -21210 0 0 {name=Xclkbuf_10_526_0_CLK }
C {devices/lab_pin.sym} 106500 -21110 0 0 {name=p105839 lab=_65142_/C }
C {devices/lab_pin.sym} 106500 -21070 0 0 {name=p105840 lab=_72357_/Y }
C {devices/lab_pin.sym} 106500 -21030 0 0 {name=p105841 lab=_79677_/Y }
C {devices/lab_pin.sym} 106660 -21070 0 1 {name=p105842 lab=_79678_/X }
C {sky130_stdcells/o21a_4.sym} 106580 -21070 0 0 {name=X_79678_ }
C {devices/lab_pin.sym} 106500 -20960 0 0 {name=p105843 lab=_87908_/Q }
C {devices/lab_pin.sym} 106500 -20920 0 0 {name=p105844 lab=_67591_/X }
C {devices/lab_pin.sym} 106500 -20880 0 0 {name=p105845 lab=_67641_/X }
C {devices/lab_pin.sym} 106500 -20840 0 0 {name=p105846 lab=_67691_/X }
C {devices/lab_pin.sym} 106660 -20900 0 1 {name=p105847 lab=_67692_/X }
C {sky130_stdcells/a211o_4.sym} 106580 -20900 0 0 {name=X_67692_ }
C {devices/lab_pin.sym} 106540 -20750 0 0 {name=p105848 lab=clkbuf_5_8_0_CLK/X }
C {devices/lab_pin.sym} 106620 -20750 0 1 {name=p105849 lab=clkbuf_7_35_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 106580 -20750 0 0 {name=Xclkbuf_6_17_0_CLK }
C {devices/lab_pin.sym} 106520 -20640 0 0 {name=p105850 lab=_69309_/A }
C {devices/lab_pin.sym} 106520 -20600 0 0 {name=p105851 lab=_69431_/B }
C {devices/lab_pin.sym} 106640 -20620 0 1 {name=p105852 lab=_69431_/X }
C {sky130_stdcells/and2_4.sym} 106580 -20620 0 0 {name=X_69431_ }
C {devices/lab_pin.sym} 106540 -20490 0 0 {name=p105853 lab=_47809_/A }
C {devices/lab_pin.sym} 106620 -20490 0 1 {name=p105854 lab=_53255_/B }
C {sky130_stdcells/buf_2.sym} 106580 -20490 0 0 {name=X_47809_ }
C {devices/lab_pin.sym} 106520 -20380 0 0 {name=p105855 lab=_78630_/A }
C {devices/lab_pin.sym} 106520 -20340 0 0 {name=p105856 lab=_82692_/Q }
C {devices/lab_pin.sym} 106640 -20360 0 1 {name=p105857 lab=_78632_/B }
C {sky130_stdcells/nor2_4.sym} 106580 -20360 0 0 {name=X_78629_ }
C {devices/lab_pin.sym} 106540 -20230 0 0 {name=p105858 lab=_66540_/A }
C {devices/lab_pin.sym} 106620 -20230 0 1 {name=p105859 lab=_66643_/X }
C {sky130_stdcells/buf_2.sym} 106580 -20230 0 0 {name=X_66643_ }
C {devices/lab_pin.sym} 106520 -20140 0 0 {name=p105860 lab=_63448_/B }
C {devices/lab_pin.sym} 106520 -20100 0 0 {name=p105861 lab=_63900_/B }
C {devices/lab_pin.sym} 106520 -20060 0 0 {name=p105862 lab=_63900_/C }
C {devices/lab_pin.sym} 106520 -20020 0 0 {name=p105863 lab=_63820_/D }
C {devices/lab_pin.sym} 106640 -20080 0 1 {name=p105864 lab=_63859_/B }
C {sky130_stdcells/nand4_4.sym} 106580 -20080 0 0 {name=X_63855_ }
C {devices/lab_pin.sym} 106500 -19950 0 0 {name=p105865 lab=_86482_/Q }
C {devices/lab_pin.sym} 106500 -19910 0 0 {name=p105866 lab=_48781_/X }
C {devices/lab_pin.sym} 106500 -19870 0 0 {name=p105867 lab=_48788_/Y }
C {devices/lab_pin.sym} 106660 -19910 0 1 {name=p105868 lab=_48789_/Y }
C {sky130_stdcells/o21ai_4.sym} 106580 -19910 0 0 {name=X_48789_ }
C {devices/lab_pin.sym} 106540 -19770 0 0 {name=p105869 lab=_50819_/X }
C {devices/lab_pin.sym} 106620 -19770 0 1 {name=p105870 lab=_50820_/X }
C {sky130_stdcells/buf_2.sym} 106580 -19770 0 0 {name=X_50820_ }
C {devices/lab_pin.sym} 106520 -19670 0 0 {name=p105871 lab=_62792_/X }
C {devices/lab_pin.sym} 106520 -19630 0 0 {name=p105872 lab=_62839_/B }
C {devices/lab_pin.sym} 106520 -19590 0 0 {name=p105873 lab=_62806_/C }
C {devices/lab_pin.sym} 106640 -19630 0 1 {name=p105874 lab=_62806_/Y }
C {sky130_stdcells/nor3_4.sym} 106580 -19630 0 0 {name=X_62806_ }
C {devices/lab_pin.sym} 106490 -19490 0 0 {name=p105875 lab=_81250_/CLK }
C {devices/lab_pin.sym} 106490 -19470 0 0 {name=p105876 lab=_76847_/A }
C {devices/lab_pin.sym} 106670 -19490 0 1 {name=p105877 lab=_81640_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -19480 0 0 {name=X_81640_ }
C {devices/lab_pin.sym} 106520 -19360 0 0 {name=p105878 lab=_69128_/X }
C {devices/lab_pin.sym} 106520 -19320 0 0 {name=p105879 lab=_69362_/B }
C {devices/lab_pin.sym} 106640 -19340 0 1 {name=p105880 lab=_69362_/X }
C {sky130_stdcells/and2_4.sym} 106580 -19340 0 0 {name=X_69362_ }
C {devices/lab_pin.sym} 106540 -19210 0 0 {name=p105881 lab=_69779_/A }
C {devices/lab_pin.sym} 106620 -19210 0 1 {name=p105882 lab=_66574_/X }
C {sky130_stdcells/buf_2.sym} 106580 -19210 0 0 {name=X_66574_ }
C {devices/lab_pin.sym} 106540 -19090 0 0 {name=p105883 lab=_64191_/D }
C {devices/lab_pin.sym} 106620 -19090 0 1 {name=p105884 lab=_63787_/D }
C {sky130_stdcells/buf_2.sym} 106580 -19090 0 0 {name=X_63786_ }
C {devices/lab_pin.sym} 106540 -18970 0 0 {name=p105885 lab=_64182_/C }
C {devices/lab_pin.sym} 106620 -18970 0 1 {name=p105886 lab=_60998_/X }
C {sky130_stdcells/buf_2.sym} 106580 -18970 0 0 {name=X_60998_ }
C {devices/lab_pin.sym} 106500 -18880 0 0 {name=p105887 lab=_68272_/X }
C {devices/lab_pin.sym} 106500 -18840 0 0 {name=p105888 lab=_67911_/Y }
C {devices/lab_pin.sym} 106500 -18800 0 0 {name=p105889 lab=_68308_/X }
C {devices/lab_pin.sym} 106500 -18760 0 0 {name=p105890 lab=_68312_/Y }
C {devices/lab_pin.sym} 106660 -18820 0 1 {name=p105891 lab=_68313_/X }
C {sky130_stdcells/a211o_4.sym} 106580 -18820 0 0 {name=X_68313_ }
C {devices/lab_pin.sym} 106520 -18680 0 0 {name=p105892 lab=_65416_/X }
C {devices/lab_pin.sym} 106520 -18640 0 0 {name=p105893 lab=_65525_/B }
C {devices/lab_pin.sym} 106640 -18660 0 1 {name=p105894 lab=_65525_/X }
C {sky130_stdcells/and2_4.sym} 106580 -18660 0 0 {name=X_65525_ }
C {devices/lab_pin.sym} 106520 -18550 0 0 {name=p105895 lab=_51256_/A }
C {devices/lab_pin.sym} 106520 -18510 0 0 {name=p105896 lab=_50751_/B }
C {devices/lab_pin.sym} 106520 -18470 0 0 {name=p105897 lab=_50751_/C }
C {devices/lab_pin.sym} 106640 -18510 0 1 {name=p105898 lab=_50751_/X }
C {sky130_stdcells/and3_4.sym} 106580 -18510 0 0 {name=X_50751_ }
C {devices/lab_pin.sym} 106540 -18370 0 0 {name=p105899 lab=_62737_/A }
C {devices/lab_pin.sym} 106620 -18370 0 1 {name=p105900 lab=_62737_/X }
C {sky130_stdcells/buf_2.sym} 106580 -18370 0 0 {name=X_62737_ }
C {devices/lab_pin.sym} 106490 -18250 0 0 {name=p105901 lab=_81587_/CLK }
C {devices/lab_pin.sym} 106490 -18230 0 0 {name=p105902 lab=_84171_/Q }
C {devices/lab_pin.sym} 106670 -18250 0 1 {name=p105903 lab=_76665_/A }
C {sky130_stdcells/dfxtp_4.sym} 106580 -18240 0 0 {name=X_81571_ }
C {devices/lab_pin.sym} 106540 -18110 0 0 {name=p105904 lab=clkbuf_2_3_0_CLK/A }
C {devices/lab_pin.sym} 106620 -18110 0 1 {name=p105905 lab=clkbuf_2_2_1_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 106580 -18110 0 0 {name=Xclkbuf_2_2_0_CLK }
C {devices/lab_pin.sym} 106520 -18000 0 0 {name=p105906 lab=_69290_/X }
C {devices/lab_pin.sym} 106520 -17960 0 0 {name=p105907 lab=_69292_/X }
C {devices/lab_pin.sym} 106640 -17980 0 1 {name=p105908 lab=_69293_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -17980 0 0 {name=X_69293_ }
C {devices/lab_pin.sym} 106490 -17850 0 0 {name=p105909 lab=_83310_/CLK }
C {devices/lab_pin.sym} 106490 -17830 0 0 {name=p105910 lab=_71975_/Y }
C {devices/lab_pin.sym} 106670 -17850 0 1 {name=p105911 lab=_83310_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -17840 0 0 {name=X_83310_ }
C {devices/lab_pin.sym} 106520 -17720 0 0 {name=p105912 lab=_80530_/A }
C {devices/lab_pin.sym} 106520 -17680 0 0 {name=p105913 lab=_80522_/B }
C {devices/lab_pin.sym} 106640 -17700 0 1 {name=p105914 lab=_80522_/Y }
C {sky130_stdcells/xnor2_4.sym} 106580 -17700 0 0 {name=X_80522_ }
C {devices/lab_pin.sym} 106500 -17600 0 0 {name=p105915 lab=_68221_/X }
C {devices/lab_pin.sym} 106500 -17560 0 0 {name=p105916 lab=_67506_/Y }
C {devices/lab_pin.sym} 106500 -17520 0 0 {name=p105917 lab=_68228_/X }
C {devices/lab_pin.sym} 106500 -17480 0 0 {name=p105918 lab=_68243_/Y }
C {devices/lab_pin.sym} 106660 -17540 0 1 {name=p105919 lab=_68244_/X }
C {sky130_stdcells/a211o_4.sym} 106580 -17540 0 0 {name=X_68244_ }
C {devices/lab_pin.sym} 106540 -17390 0 0 {name=p105920 lab=_43177_/Y }
C {devices/lab_pin.sym} 106620 -17390 0 1 {name=p105921 lab=_53798_/A }
C {sky130_stdcells/buf_2.sym} 106580 -17390 0 0 {name=X_53470_ }
C {devices/lab_pin.sym} 106500 -17300 0 0 {name=p105922 lab=_65453_/X }
C {devices/lab_pin.sym} 106500 -17260 0 0 {name=p105923 lab=_85599_/Q }
C {devices/lab_pin.sym} 106500 -17220 0 0 {name=p105924 lab=_65326_/X }
C {devices/lab_pin.sym} 106500 -17180 0 0 {name=p105925 lab=_65455_/X }
C {devices/lab_pin.sym} 106660 -17240 0 1 {name=p105926 lab=_65456_/X }
C {sky130_stdcells/a211o_4.sym} 106580 -17240 0 0 {name=X_65456_ }
C {devices/lab_pin.sym} 106490 -17090 0 0 {name=p105927 lab=_84287_/CLK }
C {devices/lab_pin.sym} 106490 -17070 0 0 {name=p105928 lab=_84290_/D }
C {devices/lab_pin.sym} 106670 -17090 0 1 {name=p105929 lab=_63864_/C }
C {sky130_stdcells/dfxtp_4.sym} 106580 -17080 0 0 {name=X_84290_ }
C {devices/lab_pin.sym} 106520 -16960 0 0 {name=p105930 lab=_50682_/A }
C {devices/lab_pin.sym} 106520 -16920 0 0 {name=p105931 lab=_50169_/B }
C {devices/lab_pin.sym} 106640 -16940 0 1 {name=p105932 lab=_50682_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -16940 0 0 {name=X_50682_ }
C {devices/lab_pin.sym} 106540 -16810 0 0 {name=p105933 lab=_62667_/X }
C {devices/lab_pin.sym} 106620 -16810 0 1 {name=p105934 lab=_62927_/A }
C {sky130_stdcells/buf_2.sym} 106580 -16810 0 0 {name=X_62668_ }
C {devices/lab_pin.sym} 106500 -16710 0 0 {name=p105935 lab=_52419_/Y }
C {devices/lab_pin.sym} 106500 -16670 0 0 {name=p105936 lab=_52415_/X }
C {devices/lab_pin.sym} 106500 -16630 0 0 {name=p105937 lab=_52420_/X }
C {devices/lab_pin.sym} 106660 -16670 0 1 {name=p105938 lab=_85826_/D }
C {sky130_stdcells/a21oi_4.sym} 106580 -16670 0 0 {name=X_52421_ }
C {devices/lab_pin.sym} 106500 -16550 0 0 {name=p105939 lab=_64399_/Y }
C {devices/lab_pin.sym} 106500 -16510 0 0 {name=p105940 lab=_64406_/X }
C {devices/lab_pin.sym} 106500 -16470 0 0 {name=p105941 lab=_64386_/X }
C {devices/lab_pin.sym} 106660 -16510 0 1 {name=p105942 lab=_64407_/X }
C {sky130_stdcells/o21a_4.sym} 106580 -16510 0 0 {name=X_64407_ }
C {devices/lab_pin.sym} 106490 -16370 0 0 {name=p105943 lab=_84333_/CLK }
C {devices/lab_pin.sym} 106490 -16350 0 0 {name=p105944 lab=_72513_/Y }
C {devices/lab_pin.sym} 106670 -16370 0 1 {name=p105945 lab=_79513_/B }
C {sky130_stdcells/dfxtp_4.sym} 106580 -16360 0 0 {name=X_83241_ }
C {devices/lab_pin.sym} 106520 -16250 0 0 {name=p105946 lab=_61608_/X }
C {devices/lab_pin.sym} 106520 -16210 0 0 {name=p105947 lab=_61618_/X }
C {devices/lab_pin.sym} 106520 -16170 0 0 {name=p105948 lab=_61619_/C }
C {devices/lab_pin.sym} 106640 -16210 0 1 {name=p105949 lab=_61619_/Y }
C {sky130_stdcells/nand3_4.sym} 106580 -16210 0 0 {name=X_61619_ }
C {devices/lab_pin.sym} 106500 -16090 0 0 {name=p105950 lab=_59204_/Y }
C {devices/lab_pin.sym} 106500 -16050 0 0 {name=p105951 lab=_66164_/C }
C {devices/lab_pin.sym} 106500 -16010 0 0 {name=p105952 lab=_80452_/Y }
C {devices/lab_pin.sym} 106660 -16050 0 1 {name=p105953 lab=_80457_/A }
C {sky130_stdcells/o21a_4.sym} 106580 -16050 0 0 {name=X_80453_ }
C {devices/lab_pin.sym} 106500 -15940 0 0 {name=p105954 lab=_68155_/X }
C {devices/lab_pin.sym} 106500 -15900 0 0 {name=p105955 lab=_67078_/Y }
C {devices/lab_pin.sym} 106500 -15860 0 0 {name=p105956 lab=_68168_/X }
C {devices/lab_pin.sym} 106500 -15820 0 0 {name=p105957 lab=_68174_/Y }
C {devices/lab_pin.sym} 106660 -15880 0 1 {name=p105958 lab=_68175_/X }
C {sky130_stdcells/a211o_4.sym} 106580 -15880 0 0 {name=X_68175_ }
C {devices/lab_pin.sym} 106520 -15740 0 0 {name=p105959 lab=_65387_/A }
C {devices/lab_pin.sym} 106520 -15700 0 0 {name=p105960 lab=_86243_/Q }
C {devices/lab_pin.sym} 106640 -15720 0 1 {name=p105961 lab=_65387_/X }
C {sky130_stdcells/and2_4.sym} 106580 -15720 0 0 {name=X_65387_ }
C {devices/lab_pin.sym} 106520 -15620 0 0 {name=p105962 lab=_61665_/B }
C {devices/lab_pin.sym} 106520 -15580 0 0 {name=p105963 lab=_62504_/X }
C {devices/lab_pin.sym} 106520 -15540 0 0 {name=p105964 lab=_62534_/X }
C {devices/lab_pin.sym} 106520 -15500 0 0 {name=p105965 lab=_62621_/D }
C {devices/lab_pin.sym} 106640 -15560 0 1 {name=p105966 lab=_62600_/D }
C {sky130_stdcells/nand4_4.sym} 106580 -15560 0 0 {name=X_62599_ }
C {devices/lab_pin.sym} 106540 -15410 0 0 {name=p105967 lab=_55140_/A }
C {devices/lab_pin.sym} 106620 -15410 0 1 {name=p105968 lab=_55140_/X }
C {sky130_stdcells/buf_2.sym} 106580 -15410 0 0 {name=X_55140_ }
C {devices/lab_pin.sym} 106540 -15290 0 0 {name=p105969 lab=_68742_/A }
C {devices/lab_pin.sym} 106620 -15290 0 1 {name=p105970 lab=_67126_/X }
C {sky130_stdcells/buf_2.sym} 106580 -15290 0 0 {name=X_67126_ }
C {devices/lab_pin.sym} 106500 -15190 0 0 {name=p105971 lab=_52350_/Y }
C {devices/lab_pin.sym} 106500 -15150 0 0 {name=p105972 lab=_52340_/X }
C {devices/lab_pin.sym} 106500 -15110 0 0 {name=p105973 lab=_52351_/X }
C {devices/lab_pin.sym} 106660 -15150 0 1 {name=p105974 lab=_85840_/D }
C {sky130_stdcells/a21oi_4.sym} 106580 -15150 0 0 {name=X_52352_ }
C {devices/lab_pin.sym} 106490 -15010 0 0 {name=p105975 lab=_84980_/CLK }
C {devices/lab_pin.sym} 106490 -14990 0 0 {name=p105976 lab=_83172_/D }
C {devices/lab_pin.sym} 106670 -15010 0 1 {name=p105977 lab=_83172_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -15000 0 0 {name=X_83172_ }
C {devices/lab_pin.sym} 106500 -14910 0 0 {name=p105978 lab=_64332_/X }
C {devices/lab_pin.sym} 106500 -14870 0 0 {name=p105979 lab=_64334_/X }
C {devices/lab_pin.sym} 106500 -14830 0 0 {name=p105980 lab=_64335_/X }
C {devices/lab_pin.sym} 106500 -14790 0 0 {name=p105981 lab=_64337_/Y }
C {devices/lab_pin.sym} 106500 -14750 0 0 {name=p105982 lab=_64326_/X }
C {devices/lab_pin.sym} 106660 -14830 0 1 {name=p105983 lab=_64338_/X }
C {sky130_stdcells/o41a_4.sym} 106580 -14830 0 0 {name=X_64338_ }
C {devices/lab_pin.sym} 106520 -14700 0 0 {name=p105984 lab=_80361_/A }
C {devices/lab_pin.sym} 106520 -14660 0 0 {name=p105985 lab=_80382_/X }
C {devices/lab_pin.sym} 106520 -14620 0 0 {name=p105986 lab=_80361_/B }
C {devices/lab_pin.sym} 106520 -14580 0 0 {name=p105987 lab=_80384_/D }
C {devices/lab_pin.sym} 106640 -14640 0 1 {name=p105988 lab=_80384_/Y }
C {sky130_stdcells/nand4_4.sym} 106580 -14640 0 0 {name=X_80384_ }
C {devices/lab_pin.sym} 106500 -14510 0 0 {name=p105989 lab=_51301_/Y }
C {devices/lab_pin.sym} 106500 -14470 0 0 {name=p105990 lab=_51289_/X }
C {devices/lab_pin.sym} 106500 -14430 0 0 {name=p105991 lab=_51302_/X }
C {devices/lab_pin.sym} 106660 -14470 0 1 {name=p105992 lab=_51303_/Y }
C {sky130_stdcells/a21oi_4.sym} 106580 -14470 0 0 {name=X_51303_ }
C {devices/lab_pin.sym} 106490 -14330 0 0 {name=p105993 lab=_82532_/CLK }
C {devices/lab_pin.sym} 106490 -14310 0 0 {name=p105994 lab=_77812_/X }
C {devices/lab_pin.sym} 106670 -14330 0 1 {name=p105995 lab=_82123_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -14320 0 0 {name=X_82123_ }
C {devices/lab_pin.sym} 106500 -14210 0 0 {name=p105996 lab=_55068_/Y }
C {devices/lab_pin.sym} 106500 -14170 0 0 {name=p105997 lab=_55050_/X }
C {devices/lab_pin.sym} 106500 -14130 0 0 {name=p105998 lab=_55070_/X }
C {devices/lab_pin.sym} 106660 -14170 0 1 {name=p105999 lab=_85324_/D }
C {sky130_stdcells/a21oi_4.sym} 106580 -14170 0 0 {name=X_55071_ }
C {devices/lab_pin.sym} 106520 -14040 0 0 {name=p106000 lab=_67057_/A }
C {devices/lab_pin.sym} 106520 -14000 0 0 {name=p106001 lab=_87615_/Q }
C {devices/lab_pin.sym} 106640 -14020 0 1 {name=p106002 lab=_67057_/X }
C {sky130_stdcells/and2_4.sym} 106580 -14020 0 0 {name=X_67057_ }
C {devices/lab_pin.sym} 106520 -13900 0 0 {name=p106003 lab=_52293_/A }
C {devices/lab_pin.sym} 106520 -13860 0 0 {name=p106004 lab=_48922_/B }
C {devices/lab_pin.sym} 106640 -13880 0 1 {name=p106005 lab=_52283_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -13880 0 0 {name=X_52283_ }
C {devices/lab_pin.sym} 106540 -13750 0 0 {name=p106006 lab=_64328_/A }
C {devices/lab_pin.sym} 106620 -13750 0 1 {name=p106007 lab=_64269_/X }
C {sky130_stdcells/buf_2.sym} 106580 -13750 0 0 {name=X_64269_ }
C {devices/lab_pin.sym} 106490 -13630 0 0 {name=p106008 lab=_88158_/CLK }
C {devices/lab_pin.sym} 106490 -13610 0 0 {name=p106009 lab=_87980_/D }
C {devices/lab_pin.sym} 106670 -13630 0 1 {name=p106010 lab=_87980_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -13620 0 0 {name=X_87980_ }
C {devices/lab_pin.sym} 106520 -13500 0 0 {name=p106011 lab=_53998_/A }
C {devices/lab_pin.sym} 106520 -13460 0 0 {name=p106012 lab=_50808_/B }
C {devices/lab_pin.sym} 106640 -13480 0 1 {name=p106013 lab=_54022_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -13480 0 0 {name=X_54022_ }
C {devices/lab_pin.sym} 106520 -13360 0 0 {name=p106014 lab=_65934_/X }
C {devices/lab_pin.sym} 106520 -13320 0 0 {name=p106015 lab=_66008_/B }
C {devices/lab_pin.sym} 106640 -13340 0 1 {name=p106016 lab=_66008_/X }
C {sky130_stdcells/and2_4.sym} 106580 -13340 0 0 {name=X_66008_ }
C {devices/lab_pin.sym} 106540 -13210 0 0 {name=p106017 lab=_51286_/A }
C {devices/lab_pin.sym} 106620 -13210 0 1 {name=p106018 lab=_51240_/A }
C {sky130_stdcells/buf_2.sym} 106580 -13210 0 0 {name=X_51234_ }
C {devices/lab_pin.sym} 106490 -13090 0 0 {name=p106019 lab=_87653_/CLK }
C {devices/lab_pin.sym} 106490 -13070 0 0 {name=p106020 lab=_86931_/D }
C {devices/lab_pin.sym} 106670 -13090 0 1 {name=p106021 lab=_67629_/B }
C {sky130_stdcells/dfxtp_4.sym} 106580 -13080 0 0 {name=X_86931_ }
C {devices/lab_pin.sym} 106490 -12950 0 0 {name=p106022 lab=_84020_/CLK }
C {devices/lab_pin.sym} 106490 -12930 0 0 {name=p106023 lab=_84014_/Q }
C {devices/lab_pin.sym} 106670 -12950 0 1 {name=p106024 lab=_77771_/B }
C {sky130_stdcells/dfxtp_4.sym} 106580 -12940 0 0 {name=X_82054_ }
C {devices/lab_pin.sym} 106490 -12810 0 0 {name=p106025 lab=_84210_/CLK }
C {devices/lab_pin.sym} 106490 -12790 0 0 {name=p106026 lab=_84213_/Q }
C {devices/lab_pin.sym} 106670 -12810 0 1 {name=p106027 lab=_81005_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -12800 0 0 {name=X_81005_ }
C {devices/lab_pin.sym} 106520 -12680 0 0 {name=p106028 lab=_58872_/A }
C {devices/lab_pin.sym} 106520 -12640 0 0 {name=p106029 lab=_58830_/B }
C {devices/lab_pin.sym} 106640 -12660 0 1 {name=p106030 lab=_58830_/Y }
C {sky130_stdcells/nor2_4.sym} 106580 -12660 0 0 {name=X_58830_ }
C {devices/lab_pin.sym} 106520 -12560 0 0 {name=p106031 lab=_51177_/A }
C {devices/lab_pin.sym} 106520 -12520 0 0 {name=p106032 lab=_51160_/B }
C {devices/lab_pin.sym} 106520 -12480 0 0 {name=p106033 lab=_51141_/X }
C {devices/lab_pin.sym} 106520 -12440 0 0 {name=p106034 lab=_52857_/D }
C {devices/lab_pin.sym} 106640 -12500 0 1 {name=p106035 lab=_51165_/X }
C {sky130_stdcells/and4_4.sym} 106580 -12500 0 0 {name=X_51165_ }
C {devices/lab_pin.sym} 106490 -12350 0 0 {name=p106036 lab=_80657_/CLK }
C {devices/lab_pin.sym} 106490 -12330 0 0 {name=p106037 lab=_45671_/Y }
C {devices/lab_pin.sym} 106670 -12350 0 1 {name=p106038 lab=_63206_/B }
C {sky130_stdcells/dfxtp_4.sym} 106580 -12340 0 0 {name=X_86862_ }
C {devices/lab_pin.sym} 106500 -12230 0 0 {name=p106039 lab=_64931_/B }
C {devices/lab_pin.sym} 106500 -12190 0 0 {name=p106040 lab=_50113_/X }
C {devices/lab_pin.sym} 106500 -12150 0 0 {name=p106041 lab=_50115_/Y }
C {devices/lab_pin.sym} 106660 -12190 0 1 {name=p106042 lab=_50116_/Y }
C {sky130_stdcells/o21ai_4.sym} 106580 -12190 0 0 {name=X_50116_ }
C {devices/lab_pin.sym} 106490 -12050 0 0 {name=p106043 lab=_85527_/CLK }
C {devices/lab_pin.sym} 106490 -12030 0 0 {name=p106044 lab=_52483_/Y }
C {devices/lab_pin.sym} 106670 -12050 0 1 {name=p106045 lab=_85813_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -12040 0 0 {name=X_85813_ }
C {devices/lab_pin.sym} 106540 -11910 0 0 {name=p106046 lab=_58939_/A }
C {devices/lab_pin.sym} 106620 -11910 0 1 {name=p106047 lab=_58761_/X }
C {sky130_stdcells/buf_2.sym} 106580 -11910 0 0 {name=X_58761_ }
C {devices/lab_pin.sym} 106500 -11810 0 0 {name=p106048 lab=_51092_/Y }
C {devices/lab_pin.sym} 106500 -11770 0 0 {name=p106049 lab=_51093_/X }
C {devices/lab_pin.sym} 106500 -11730 0 0 {name=p106050 lab=_51095_/X }
C {devices/lab_pin.sym} 106660 -11770 0 1 {name=p106051 lab=_86075_/D }
C {sky130_stdcells/a21oi_4.sym} 106580 -11770 0 0 {name=X_51096_ }
C {devices/lab_pin.sym} 106500 -11660 0 0 {name=p106052 lab=_74545_/C }
C {devices/lab_pin.sym} 106500 -11620 0 0 {name=p106053 lab=_55690_/X }
C {devices/lab_pin.sym} 106500 -11580 0 0 {name=p106054 lab=_44102_/X }
C {devices/lab_pin.sym} 106500 -11540 0 0 {name=p106055 lab=_55972_/X }
C {devices/lab_pin.sym} 106660 -11600 0 1 {name=p106056 lab=_55974_/B }
C {sky130_stdcells/a211o_4.sym} 106580 -11600 0 0 {name=X_55973_ }
C {devices/lab_pin.sym} 106520 -11460 0 0 {name=p106057 lab=_68025_/A }
C {devices/lab_pin.sym} 106520 -11420 0 0 {name=p106058 lab=_88217_/Q }
C {devices/lab_pin.sym} 106640 -11440 0 1 {name=p106059 lab=_67959_/X }
C {sky130_stdcells/and2_4.sym} 106580 -11440 0 0 {name=X_67959_ }
C {devices/lab_pin.sym} 106490 -11310 0 0 {name=p106060 lab=_87077_/CLK }
C {devices/lab_pin.sym} 106490 -11290 0 0 {name=p106061 lab=_46052_/X }
C {devices/lab_pin.sym} 106670 -11310 0 1 {name=p106062 lab=_86793_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -11300 0 0 {name=X_86793_ }
C {devices/lab_pin.sym} 106540 -11170 0 0 {name=p106063 lab=_57711_/X }
C {devices/lab_pin.sym} 106620 -11170 0 1 {name=p106064 lab=_57712_/X }
C {sky130_stdcells/buf_2.sym} 106580 -11170 0 0 {name=X_57712_ }
C {devices/lab_pin.sym} 106500 -11070 0 0 {name=p106065 lab=_50043_/Y }
C {devices/lab_pin.sym} 106500 -11030 0 0 {name=p106066 lab=_50029_/X }
C {devices/lab_pin.sym} 106500 -10990 0 0 {name=p106067 lab=_50046_/X }
C {devices/lab_pin.sym} 106660 -11030 0 1 {name=p106068 lab=_50047_/Y }
C {sky130_stdcells/a21oi_4.sym} 106580 -11030 0 0 {name=X_50047_ }
C {devices/lab_pin.sym} 106520 -10900 0 0 {name=p106069 lab=_54919_/X }
C {devices/lab_pin.sym} 106520 -10860 0 0 {name=p106070 lab=_47762_/Y }
C {devices/lab_pin.sym} 106640 -10880 0 1 {name=p106071 lab=_54924_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -10880 0 0 {name=X_54924_ }
C {devices/lab_pin.sym} 106490 -10750 0 0 {name=p106072 lab=_85748_/CLK }
C {devices/lab_pin.sym} 106490 -10730 0 0 {name=p106073 lab=_52847_/Y }
C {devices/lab_pin.sym} 106670 -10750 0 1 {name=p106074 lab=_85744_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -10740 0 0 {name=X_85744_ }
C {devices/lab_pin.sym} 106490 -10610 0 0 {name=p106075 lab=_82956_/CLK }
C {devices/lab_pin.sym} 106490 -10590 0 0 {name=p106076 lab=_82956_/D }
C {devices/lab_pin.sym} 106670 -10610 0 1 {name=p106077 lab=_82956_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -10600 0 0 {name=X_82956_ }
C {devices/lab_pin.sym} 106500 -10490 0 0 {name=p106078 lab=_50781_/B }
C {devices/lab_pin.sym} 106500 -10450 0 0 {name=p106079 lab=_70961_/X }
C {devices/lab_pin.sym} 106500 -10410 0 0 {name=p106080 lab=_70969_/Y }
C {devices/lab_pin.sym} 106660 -10450 0 1 {name=p106081 lab=_83646_/D }
C {sky130_stdcells/o21ai_4.sym} 106580 -10450 0 0 {name=X_70970_ }
C {devices/lab_pin.sym} 106500 -10330 0 0 {name=p106082 lab=_58682_/X }
C {devices/lab_pin.sym} 106500 -10290 0 0 {name=p106083 lab=_85783_/Q }
C {devices/lab_pin.sym} 106500 -10250 0 0 {name=p106084 lab=_58594_/X }
C {devices/lab_pin.sym} 106660 -10290 0 1 {name=p106085 lab=_58692_/X }
C {sky130_stdcells/o21a_4.sym} 106580 -10290 0 0 {name=X_58692_ }
C {devices/lab_pin.sym} 106500 -10170 0 0 {name=p106086 lab=_84963_/Q }
C {devices/lab_pin.sym} 106500 -10130 0 0 {name=p106087 lab=_57635_/X }
C {devices/lab_pin.sym} 106500 -10090 0 0 {name=p106088 lab=_57642_/Y }
C {devices/lab_pin.sym} 106660 -10130 0 1 {name=p106089 lab=_57643_/Y }
C {sky130_stdcells/o21ai_4.sym} 106580 -10130 0 0 {name=X_57643_ }
C {devices/lab_pin.sym} 106490 -9990 0 0 {name=p106090 lab=_82131_/CLK }
C {devices/lab_pin.sym} 106490 -9970 0 0 {name=p106091 lab=_81907_/D }
C {devices/lab_pin.sym} 106670 -9990 0 1 {name=p106092 lab=_82283_/D }
C {sky130_stdcells/dfxtp_4.sym} 106580 -9980 0 0 {name=X_81907_ }
C {devices/lab_pin.sym} 106500 -9870 0 0 {name=p106093 lab=_69625_/X }
C {devices/lab_pin.sym} 106500 -9830 0 0 {name=p106094 lab=_69628_/X }
C {devices/lab_pin.sym} 106500 -9790 0 0 {name=p106095 lab=_69389_/X }
C {devices/lab_pin.sym} 106660 -9830 0 1 {name=p106096 lab=_69629_/Y }
C {sky130_stdcells/a21oi_4.sym} 106580 -9830 0 0 {name=X_69629_ }
C {devices/lab_pin.sym} 106500 -9710 0 0 {name=p106097 lab=_85365_/Q }
C {devices/lab_pin.sym} 106500 -9670 0 0 {name=p106098 lab=_54839_/X }
C {devices/lab_pin.sym} 106500 -9630 0 0 {name=p106099 lab=_54854_/Y }
C {devices/lab_pin.sym} 106660 -9670 0 1 {name=p106100 lab=_54855_/Y }
C {sky130_stdcells/o21ai_4.sym} 106580 -9670 0 0 {name=X_54855_ }
C {devices/lab_pin.sym} 106490 -9530 0 0 {name=p106101 lab=_86400_/CLK }
C {devices/lab_pin.sym} 106490 -9510 0 0 {name=p106102 lab=_53218_/Y }
C {devices/lab_pin.sym} 106670 -9530 0 1 {name=p106103 lab=_85675_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -9520 0 0 {name=X_85675_ }
C {devices/lab_pin.sym} 106490 -9390 0 0 {name=p106104 lab=_82317_/CLK }
C {devices/lab_pin.sym} 106490 -9370 0 0 {name=p106105 lab=_78112_/B }
C {devices/lab_pin.sym} 106670 -9390 0 1 {name=p106106 lab=_82887_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -9380 0 0 {name=X_82887_ }
C {devices/lab_pin.sym} 106490 -9250 0 0 {name=p106107 lab=_87926_/CLK }
C {devices/lab_pin.sym} 106490 -9230 0 0 {name=p106108 lab=_43454_/Y }
C {devices/lab_pin.sym} 106670 -9250 0 1 {name=p106109 lab=_87414_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -9240 0 0 {name=X_87414_ }
C {devices/lab_pin.sym} 106540 -9110 0 0 {name=p106110 lab=_41819_/Y }
C {devices/lab_pin.sym} 106620 -9110 0 1 {name=p106111 lab=_88136_/D }
C {sky130_stdcells/inv_2.sym} 106580 -9110 0 0 {name=X_41820_ }
C {devices/lab_pin.sym} 106520 -9010 0 0 {name=p106112 lab=_48928_/A }
C {devices/lab_pin.sym} 106520 -8970 0 0 {name=p106113 lab=_53806_/B }
C {devices/lab_pin.sym} 106520 -8930 0 0 {name=p106114 lab=_53806_/C }
C {devices/lab_pin.sym} 106640 -8970 0 1 {name=p106115 lab=_53806_/X }
C {sky130_stdcells/and3_4.sym} 106580 -8970 0 0 {name=X_53806_ }
C {devices/lab_pin.sym} 106500 -8850 0 0 {name=p106116 lab=_70178_/C }
C {devices/lab_pin.sym} 106500 -8810 0 0 {name=p106117 lab=_72631_/X }
C {devices/lab_pin.sym} 106500 -8770 0 0 {name=p106118 lab=_72639_/Y }
C {devices/lab_pin.sym} 106660 -8810 0 1 {name=p106119 lab=_83207_/D }
C {sky130_stdcells/a21bo_4.sym} 106580 -8810 0 0 {name=X_72640_ }
C {devices/lab_pin.sym} 106490 -8670 0 0 {name=p106120 lab=_84623_/CLK }
C {devices/lab_pin.sym} 106490 -8650 0 0 {name=p106121 lab=_60347_/Y }
C {devices/lab_pin.sym} 106670 -8670 0 1 {name=p106122 lab=_60346_/C }
C {sky130_stdcells/dfxtp_4.sym} 106580 -8660 0 0 {name=X_84626_ }
C {devices/lab_pin.sym} 106520 -8540 0 0 {name=p106123 lab=_57552_/X }
C {devices/lab_pin.sym} 106520 -8500 0 0 {name=p106124 lab=_48014_/Y }
C {devices/lab_pin.sym} 106640 -8520 0 1 {name=p106125 lab=_57574_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -8520 0 0 {name=X_57574_ }
C {devices/lab_pin.sym} 106490 -8390 0 0 {name=p106126 lab=_81883_/CLK }
C {devices/lab_pin.sym} 106490 -8370 0 0 {name=p106127 lab=_81870_/Q }
C {devices/lab_pin.sym} 106670 -8390 0 1 {name=p106128 lab=_77406_/A }
C {sky130_stdcells/dfxtp_4.sym} 106580 -8380 0 0 {name=X_81838_ }
C {devices/lab_pin.sym} 106490 -8250 0 0 {name=p106129 lab=_88394_/CLK }
C {devices/lab_pin.sym} 106490 -8230 0 0 {name=p106130 lab=_88394_/D }
C {devices/lab_pin.sym} 106670 -8250 0 1 {name=p106131 lab=_88394_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -8240 0 0 {name=X_88394_ }
C {devices/lab_pin.sym} 106520 -8120 0 0 {name=p106132 lab=_54790_/A }
C {devices/lab_pin.sym} 106520 -8080 0 0 {name=p106133 lab=_47516_/A }
C {devices/lab_pin.sym} 106640 -8100 0 1 {name=p106134 lab=_54786_/Y }
C {sky130_stdcells/nand2_4.sym} 106580 -8100 0 0 {name=X_54786_ }
C {devices/lab_pin.sym} 106500 -7990 0 0 {name=p106135 lab=_66082_/B }
C {devices/lab_pin.sym} 106500 -7950 0 0 {name=p106136 lab=_51994_/X }
C {devices/lab_pin.sym} 106500 -7910 0 0 {name=p106137 lab=_51997_/Y }
C {devices/lab_pin.sym} 106660 -7950 0 1 {name=p106138 lab=_51998_/Y }
C {sky130_stdcells/o21ai_4.sym} 106580 -7950 0 0 {name=X_51998_ }
C {devices/lab_pin.sym} 106500 -7830 0 0 {name=p106139 lab=_59286_/X }
C {devices/lab_pin.sym} 106500 -7790 0 0 {name=p106140 lab=_86056_/Q }
C {devices/lab_pin.sym} 106500 -7750 0 0 {name=p106141 lab=_59312_/X }
C {devices/lab_pin.sym} 106660 -7790 0 1 {name=p106142 lab=_59313_/Y }
C {sky130_stdcells/o21ai_4.sym} 106580 -7790 0 0 {name=X_59313_ }
C {devices/lab_pin.sym} 106540 -7650 0 0 {name=p106143 lab=_56525_/A }
C {devices/lab_pin.sym} 106620 -7650 0 1 {name=p106144 lab=_56533_/A }
C {sky130_stdcells/buf_2.sym} 106580 -7650 0 0 {name=X_56525_ }
C {devices/lab_pin.sym} 106490 -7530 0 0 {name=p106145 lab=_87345_/CLK }
C {devices/lab_pin.sym} 106490 -7510 0 0 {name=p106146 lab=_43601_/Y }
C {devices/lab_pin.sym} 106670 -7530 0 1 {name=p106147 lab=_87345_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -7520 0 0 {name=X_87345_ }
C {devices/lab_pin.sym} 106540 -7390 0 0 {name=p106148 lab=_41814_/A }
C {devices/lab_pin.sym} 106620 -7390 0 1 {name=p106149 lab=_41751_/X }
C {sky130_stdcells/buf_2.sym} 106580 -7390 0 0 {name=X_41751_ }
C {devices/lab_pin.sym} 106500 -7290 0 0 {name=p106150 lab=_85578_/Q }
C {devices/lab_pin.sym} 106500 -7250 0 0 {name=p106151 lab=_53729_/X }
C {devices/lab_pin.sym} 106500 -7210 0 0 {name=p106152 lab=_53736_/Y }
C {devices/lab_pin.sym} 106660 -7250 0 1 {name=p106153 lab=_53737_/Y }
C {sky130_stdcells/o21ai_4.sym} 106580 -7250 0 0 {name=X_53737_ }
C {devices/lab_pin.sym} 106500 -7140 0 0 {name=p106154 lab=_79405_/B }
C {devices/lab_pin.sym} 106500 -7100 0 0 {name=p106155 lab=_61252_/X }
C {devices/lab_pin.sym} 106500 -7060 0 0 {name=p106156 lab=_72569_/Y }
C {devices/lab_pin.sym} 106500 -7020 0 0 {name=p106157 lab=_72570_/Y }
C {devices/lab_pin.sym} 106660 -7080 0 1 {name=p106158 lab=_83231_/D }
C {sky130_stdcells/o22a_4.sym} 106580 -7080 0 0 {name=X_72571_ }
C {devices/lab_pin.sym} 106490 -6930 0 0 {name=p106159 lab=_84562_/CLK }
C {devices/lab_pin.sym} 106490 -6910 0 0 {name=p106160 lab=_84557_/D }
C {devices/lab_pin.sym} 106670 -6930 0 1 {name=p106161 lab=_60826_/C }
C {sky130_stdcells/dfxtp_4.sym} 106580 -6920 0 0 {name=X_84557_ }
C {devices/lab_pin.sym} 106500 -6810 0 0 {name=p106162 lab=_50944_/Y }
C {devices/lab_pin.sym} 106500 -6770 0 0 {name=p106163 lab=_50928_/X }
C {devices/lab_pin.sym} 106500 -6730 0 0 {name=p106164 lab=_50948_/X }
C {devices/lab_pin.sym} 106660 -6770 0 1 {name=p106165 lab=_50949_/Y }
C {sky130_stdcells/a21oi_4.sym} 106580 -6770 0 0 {name=X_50949_ }
C {devices/lab_pin.sym} 106490 -6630 0 0 {name=p106166 lab=_82896_/CLK }
C {devices/lab_pin.sym} 106490 -6610 0 0 {name=p106167 lab=_76025_/X }
C {devices/lab_pin.sym} 106670 -6630 0 1 {name=p106168 lab=_81769_/Q }
C {sky130_stdcells/dfxtp_4.sym} 106580 -6620 0 0 {name=X_81769_ }
C {devices/lab_pin.sym} 106520 -6510 0 0 {name=p106169 lab=_74302_/X }
C {devices/lab_pin.sym} 106520 -6470 0 0 {name=p106170 lab=_74310_/B }
C {devices/lab_pin.sym} 106520 -6430 0 0 {name=p106171 lab=_74310_/C }
C {devices/lab_pin.sym} 106640 -6470 0 1 {name=p106172 lab=_74310_/Y }
C {sky130_stdcells/nand3_4.sym} 106580 -6470 0 0 {name=X_74310_ }
C {devices/lab_pin.sym} 106540 -6330 0 0 {name=p106173 lab=_40702_/A }
C {devices/lab_pin.sym} 106620 -6330 0 1 {name=p106174 lab=_40702_/X }
C {sky130_stdcells/buf_2.sym} 106580 -6330 0 0 {name=X_40702_ }
C {devices/lab_pin.sym} 106520 -6220 0 0 {name=p106175 lab=_59117_/A }
C {devices/lab_pin.sym} 106520 -6180 0 0 {name=p106176 lab=_59244_/B }
C {devices/lab_pin.sym} 106640 -6200 0 1 {name=p106177 lab=_59244_/Y }
C {sky130_stdcells/nor2_4.sym} 106580 -6200 0 0 {name=X_59244_ }
C {devices/lab_pin.sym} 106500 -6090 0 0 {name=p106178 lab=_51728_/B }
C {devices/lab_pin.sym} 106500 -6050 0 0 {name=p106179 lab=_71512_/A }
C {devices/lab_pin.sym} 106500 -6010 0 0 {name=p106180 lab=_71521_/Y }
C {devices/lab_pin.sym} 106660 -6050 0 1 {name=p106181 lab=_83468_/D }
C {sky130_stdcells/o21ai_4.sym} 106580 -6050 0 0 {name=X_71522_ }
