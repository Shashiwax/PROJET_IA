C {devices/lab_pin.sym} 120340 -40390 0 0 {name=p119103 lab=_72722_/X }
C {devices/lab_pin.sym} 120420 -40390 0 1 {name=p119104 lab=_72921_/X }
C {sky130_stdcells/buf_2.sym} 120380 -40390 0 0 {name=X_72921_ }
C {devices/lab_pin.sym} 120290 -40270 0 0 {name=p119105 lab=_84903_/CLK }
C {devices/lab_pin.sym} 120290 -40250 0 0 {name=p119106 lab=_84907_/D }
C {devices/lab_pin.sym} 120470 -40270 0 1 {name=p119107 lab=_64544_/C }
C {sky130_stdcells/dfxtp_4.sym} 120380 -40260 0 0 {name=X_84907_ }
C {devices/lab_pin.sym} 120300 -40150 0 0 {name=p119108 lab=_57851_/Y }
C {devices/lab_pin.sym} 120300 -40110 0 0 {name=p119109 lab=_57854_/Y }
C {devices/lab_pin.sym} 120300 -40070 0 0 {name=p119110 lab=_57829_/X }
C {devices/lab_pin.sym} 120460 -40110 0 1 {name=p119111 lab=_57855_/X }
C {sky130_stdcells/a21o_4.sym} 120380 -40110 0 0 {name=X_57855_ }
C {devices/lab_pin.sym} 120290 -39970 0 0 {name=p119112 lab=_85888_/CLK }
C {devices/lab_pin.sym} 120290 -39950 0 0 {name=p119113 lab=_85887_/D }
C {devices/lab_pin.sym} 120470 -39970 0 1 {name=p119114 lab=_65451_/B }
C {sky130_stdcells/dfxtp_4.sym} 120380 -39960 0 0 {name=X_85887_ }
C {devices/lab_pin.sym} 120340 -39830 0 0 {name=p119115 lab=_43014_/Y }
C {devices/lab_pin.sym} 120420 -39830 0 1 {name=p119116 lab=_46001_/A }
C {sky130_stdcells/buf_2.sym} 120380 -39830 0 0 {name=X_44820_ }
C {devices/lab_pin.sym} 120300 -39730 0 0 {name=p119117 lab=_44242_/C }
C {devices/lab_pin.sym} 120300 -39690 0 0 {name=p119118 lab=_85131_/Q }
C {devices/lab_pin.sym} 120300 -39650 0 0 {name=p119119 lab=_56805_/X }
C {devices/lab_pin.sym} 120460 -39690 0 1 {name=p119120 lab=_56806_/Y }
C {sky130_stdcells/a21oi_4.sym} 120380 -39690 0 0 {name=X_56806_ }
C {devices/lab_pin.sym} 120320 -39560 0 0 {name=p119121 lab=_75640_/A }
C {devices/lab_pin.sym} 120320 -39520 0 0 {name=p119122 lab=_75616_/A }
C {devices/lab_pin.sym} 120440 -39540 0 1 {name=p119123 lab=_75641_/B }
C {sky130_stdcells/nor2_4.sym} 120380 -39540 0 0 {name=X_75640_ }
C {devices/lab_pin.sym} 120290 -39410 0 0 {name=p119124 lab=_87883_/CLK }
C {devices/lab_pin.sym} 120290 -39390 0 0 {name=p119125 lab=_87626_/D }
C {devices/lab_pin.sym} 120470 -39410 0 1 {name=p119126 lab=_66795_/B }
C {sky130_stdcells/dfxtp_4.sym} 120380 -39400 0 0 {name=X_87626_ }
C {devices/lab_pin.sym} 120340 -39270 0 0 {name=p119127 lab=_73186_/A }
C {devices/lab_pin.sym} 120420 -39270 0 1 {name=p119128 lab=_72852_/X }
C {sky130_stdcells/buf_2.sym} 120380 -39270 0 0 {name=X_72852_ }
C {devices/lab_pin.sym} 120290 -39150 0 0 {name=p119129 lab=_84838_/CLK }
C {devices/lab_pin.sym} 120290 -39130 0 0 {name=p119130 lab=_84838_/D }
C {devices/lab_pin.sym} 120470 -39150 0 1 {name=p119131 lab=_84838_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -39140 0 0 {name=X_84838_ }
C {devices/lab_pin.sym} 120320 -39020 0 0 {name=p119132 lab=_57952_/A }
C {devices/lab_pin.sym} 120320 -38980 0 0 {name=p119133 lab=_86333_/Q }
C {devices/lab_pin.sym} 120440 -39000 0 1 {name=p119134 lab=_57786_/Y }
C {sky130_stdcells/nor2_4.sym} 120380 -39000 0 0 {name=X_57786_ }
C {devices/lab_pin.sym} 120340 -38870 0 0 {name=p119135 lab=_54253_/A }
C {devices/lab_pin.sym} 120420 -38870 0 1 {name=p119136 lab=_54998_/X }
C {sky130_stdcells/buf_2.sym} 120380 -38870 0 0 {name=X_54998_ }
C {devices/lab_pin.sym} 120320 -38760 0 0 {name=p119137 lab=_70500_/D }
C {devices/lab_pin.sym} 120320 -38720 0 0 {name=p119138 lab=_70830_/B }
C {devices/lab_pin.sym} 120440 -38740 0 1 {name=p119139 lab=_71804_/A }
C {sky130_stdcells/nor2_4.sym} 120380 -38740 0 0 {name=X_71803_ }
C {devices/lab_pin.sym} 120320 -38640 0 0 {name=p119140 lab=_59544_/A }
C {devices/lab_pin.sym} 120320 -38600 0 0 {name=p119141 lab=_59571_/C }
C {devices/lab_pin.sym} 120320 -38560 0 0 {name=p119142 lab=_59741_/C }
C {devices/lab_pin.sym} 120320 -38520 0 0 {name=p119143 lab=_59890_/B }
C {devices/lab_pin.sym} 120440 -38580 0 1 {name=p119144 lab=_60385_/A }
C {sky130_stdcells/and4_4.sym} 120380 -38580 0 0 {name=X_59525_ }
C {devices/lab_pin.sym} 120300 -38460 0 0 {name=p119145 lab=_41287_/Y }
C {devices/lab_pin.sym} 120300 -38420 0 0 {name=p119146 lab=_44665_/X }
C {devices/lab_pin.sym} 120300 -38380 0 0 {name=p119147 lab=_86975_/Q }
C {devices/lab_pin.sym} 120300 -38340 0 0 {name=p119148 lab=_44666_/X }
C {devices/lab_pin.sym} 120460 -38400 0 1 {name=p119149 lab=_86975_/D }
C {sky130_stdcells/a2bb2o_4.sym} 120380 -38400 0 0 {name=X_44751_ }
C {devices/lab_pin.sym} 120340 -38250 0 0 {name=p119150 lab=_56700_/Y }
C {devices/lab_pin.sym} 120420 -38250 0 1 {name=p119151 lab=_56737_/X }
C {sky130_stdcells/buf_2.sym} 120380 -38250 0 0 {name=X_56737_ }
C {devices/lab_pin.sym} 120320 -38140 0 0 {name=p119152 lab=_75571_/A }
C {devices/lab_pin.sym} 120320 -38100 0 0 {name=p119153 lab=_75571_/B }
C {devices/lab_pin.sym} 120440 -38120 0 1 {name=p119154 lab=_80962_/D }
C {sky130_stdcells/xor2_4.sym} 120380 -38120 0 0 {name=X_75571_ }
C {devices/lab_pin.sym} 120290 -37990 0 0 {name=p119155 lab=_87814_/CLK }
C {devices/lab_pin.sym} 120290 -37970 0 0 {name=p119156 lab=_43151_/Y }
C {devices/lab_pin.sym} 120470 -37990 0 1 {name=p119157 lab=_73126_/A }
C {sky130_stdcells/dfxtp_4.sym} 120380 -37980 0 0 {name=X_87557_ }
C {devices/lab_pin.sym} 120340 -37850 0 0 {name=p119158 lab=_41963_/A }
C {devices/lab_pin.sym} 120420 -37850 0 1 {name=p119159 lab=_41963_/Y }
C {sky130_stdcells/inv_2.sym} 120380 -37850 0 0 {name=X_41963_ }
C {devices/lab_pin.sym} 120320 -37740 0 0 {name=p119160 lab=_53949_/A }
C {devices/lab_pin.sym} 120320 -37700 0 0 {name=p119161 lab=_53949_/B }
C {devices/lab_pin.sym} 120440 -37720 0 1 {name=p119162 lab=_53949_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -37720 0 0 {name=X_53949_ }
C {devices/lab_pin.sym} 120300 -37610 0 0 {name=p119163 lab=_72780_/X }
C {devices/lab_pin.sym} 120300 -37570 0 0 {name=p119164 lab=_72782_/X }
C {devices/lab_pin.sym} 120300 -37530 0 0 {name=p119165 lab=_72735_/X }
C {devices/lab_pin.sym} 120460 -37570 0 1 {name=p119166 lab=_72783_/X }
C {sky130_stdcells/a21o_4.sym} 120380 -37570 0 0 {name=X_72783_ }
C {devices/lab_pin.sym} 120290 -37430 0 0 {name=p119167 lab=_86361_/CLK }
C {devices/lab_pin.sym} 120290 -37410 0 0 {name=p119168 lab=_84769_/D }
C {devices/lab_pin.sym} 120470 -37430 0 1 {name=p119169 lab=_84769_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -37420 0 0 {name=X_84769_ }
C {devices/lab_pin.sym} 120340 -37290 0 0 {name=p119170 lab=_77310_/A }
C {devices/lab_pin.sym} 120420 -37290 0 1 {name=p119171 lab=_77311_/A }
C {sky130_stdcells/inv_2.sym} 120380 -37290 0 0 {name=X_77310_ }
C {devices/lab_pin.sym} 120340 -37170 0 0 {name=p119172 lab=_43701_/X }
C {devices/lab_pin.sym} 120420 -37170 0 1 {name=p119173 lab=_87303_/D }
C {sky130_stdcells/inv_2.sym} 120380 -37170 0 0 {name=X_43702_ }
C {devices/lab_pin.sym} 120340 -37050 0 0 {name=p119174 lab=_70611_/X }
C {devices/lab_pin.sym} 120420 -37050 0 1 {name=p119175 lab=_74531_/D }
C {sky130_stdcells/buf_2.sym} 120380 -37050 0 0 {name=X_74522_ }
C {devices/lab_pin.sym} 120290 -36930 0 0 {name=p119176 lab=_86498_/CLK }
C {devices/lab_pin.sym} 120290 -36910 0 0 {name=p119177 lab=_86508_/D }
C {devices/lab_pin.sym} 120470 -36930 0 1 {name=p119178 lab=_73310_/B }
C {sky130_stdcells/dfxtp_4.sym} 120380 -36920 0 0 {name=X_86508_ }
C {devices/lab_pin.sym} 120340 -36790 0 0 {name=p119179 lab=_40913_/X }
C {devices/lab_pin.sym} 120420 -36790 0 1 {name=p119180 lab=_40914_/X }
C {sky130_stdcells/buf_2.sym} 120380 -36790 0 0 {name=X_40914_ }
C {devices/lab_pin.sym} 120320 -36680 0 0 {name=p119181 lab=_47444_/A }
C {devices/lab_pin.sym} 120320 -36640 0 0 {name=p119182 lab=_53067_/B }
C {devices/lab_pin.sym} 120440 -36660 0 1 {name=p119183 lab=_47470_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -36660 0 0 {name=X_47470_ }
C {devices/lab_pin.sym} 120300 -36550 0 0 {name=p119184 lab=_58246_/Y }
C {devices/lab_pin.sym} 120300 -36510 0 0 {name=p119185 lab=_71711_/Y }
C {devices/lab_pin.sym} 120300 -36470 0 0 {name=p119186 lab=_71733_/Y }
C {devices/lab_pin.sym} 120460 -36510 0 1 {name=p119187 lab=_71734_/Y }
C {sky130_stdcells/o21ai_4.sym} 120380 -36510 0 0 {name=X_71734_ }
C {devices/lab_pin.sym} 120340 -36370 0 0 {name=p119188 lab=_59456_/A }
C {devices/lab_pin.sym} 120420 -36370 0 1 {name=p119189 lab=_59456_/Y }
C {sky130_stdcells/inv_2.sym} 120380 -36370 0 0 {name=X_59456_ }
C {devices/lab_pin.sym} 120320 -36260 0 0 {name=p119190 lab=_82590_/Q }
C {devices/lab_pin.sym} 120320 -36220 0 0 {name=p119191 lab=_78290_/B }
C {devices/lab_pin.sym} 120440 -36240 0 1 {name=p119192 lab=_78290_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -36240 0 0 {name=X_78290_ }
C {devices/lab_pin.sym} 120300 -36140 0 0 {name=p119193 lab=_55489_/B }
C {devices/lab_pin.sym} 120300 -36100 0 0 {name=p119194 lab=_56553_/Y }
C {devices/lab_pin.sym} 120300 -36060 0 0 {name=p119195 lab=_56647_/X }
C {devices/lab_pin.sym} 120300 -36020 0 0 {name=p119196 lab=_56667_/Y }
C {devices/lab_pin.sym} 120460 -36080 0 1 {name=p119197 lab=_85138_/D }
C {sky130_stdcells/a2bb2o_4.sym} 120380 -36080 0 0 {name=X_56668_ }
C {devices/lab_pin.sym} 120300 -35970 0 0 {name=p119198 lab=_44679_/X }
C {devices/lab_pin.sym} 120300 -35930 0 0 {name=p119199 lab=_44680_/X }
C {devices/lab_pin.sym} 120300 -35890 0 0 {name=p119200 lab=_40610_/X }
C {devices/lab_pin.sym} 120300 -35850 0 0 {name=p119201 lab=_87002_/Q }
C {devices/lab_pin.sym} 120300 -35810 0 0 {name=p119202 lab=_44681_/X }
C {devices/lab_pin.sym} 120460 -35890 0 1 {name=p119203 lab=_44682_/Y }
C {sky130_stdcells/o32ai_4.sym} 120380 -35890 0 0 {name=X_44682_ }
C {devices/lab_pin.sym} 120290 -35730 0 0 {name=p119204 lab=_87758_/CLK }
C {devices/lab_pin.sym} 120290 -35710 0 0 {name=p119205 lab=_87488_/D }
C {devices/lab_pin.sym} 120470 -35730 0 1 {name=p119206 lab=_87488_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -35720 0 0 {name=X_87488_ }
C {devices/lab_pin.sym} 120340 -35590 0 0 {name=p119207 lab=_43047_/A }
C {devices/lab_pin.sym} 120420 -35590 0 1 {name=p119208 lab=_41894_/X }
C {sky130_stdcells/buf_2.sym} 120380 -35590 0 0 {name=X_41894_ }
C {devices/lab_pin.sym} 120320 -35480 0 0 {name=p119209 lab=_46421_/A }
C {devices/lab_pin.sym} 120320 -35440 0 0 {name=p119210 lab=_50799_/B }
C {devices/lab_pin.sym} 120440 -35460 0 1 {name=p119211 lab=_46421_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -35460 0 0 {name=X_46421_ }
C {devices/lab_pin.sym} 120340 -35330 0 0 {name=p119212 lab=_84856_/Q }
C {devices/lab_pin.sym} 120420 -35330 0 1 {name=p119213 lab=_58409_/A }
C {sky130_stdcells/inv_2.sym} 120380 -35330 0 0 {name=X_58407_ }
C {devices/lab_pin.sym} 120340 -35210 0 0 {name=p119214 lab=_77241_/A }
C {devices/lab_pin.sym} 120420 -35210 0 1 {name=p119215 lab=_77241_/Y }
C {sky130_stdcells/inv_2.sym} 120380 -35210 0 0 {name=X_77241_ }
C {devices/lab_pin.sym} 120340 -35090 0 0 {name=p119216 lab=_51337_/A }
C {devices/lab_pin.sym} 120420 -35090 0 1 {name=p119217 lab=_47834_/A }
C {sky130_stdcells/buf_2.sym} 120380 -35090 0 0 {name=X_43633_ }
C {devices/lab_pin.sym} 120340 -34970 0 0 {name=p119218 lab=_55619_/A }
C {devices/lab_pin.sym} 120420 -34970 0 1 {name=p119219 lab=_55689_/A }
C {sky130_stdcells/buf_2.sym} 120380 -34970 0 0 {name=X_55619_ }
C {devices/lab_pin.sym} 120340 -34850 0 0 {name=p119220 lab=_74453_/A }
C {devices/lab_pin.sym} 120420 -34850 0 1 {name=p119221 lab=_74478_/B }
C {sky130_stdcells/buf_2.sym} 120380 -34850 0 0 {name=X_74453_ }
C {devices/lab_pin.sym} 120290 -34730 0 0 {name=p119222 lab=_86154_/CLK }
C {devices/lab_pin.sym} 120290 -34710 0 0 {name=p119223 lab=_86439_/D }
C {devices/lab_pin.sym} 120470 -34730 0 1 {name=p119224 lab=_65289_/B }
C {sky130_stdcells/dfxtp_4.sym} 120380 -34720 0 0 {name=X_86439_ }
C {devices/lab_pin.sym} 120340 -34590 0 0 {name=p119225 lab=_40845_/A }
C {devices/lab_pin.sym} 120420 -34590 0 1 {name=p119226 lab=_40845_/X }
C {sky130_stdcells/buf_2.sym} 120380 -34590 0 0 {name=X_40845_ }
C {devices/lab_pin.sym} 120300 -34490 0 0 {name=p119227 lab=_58526_/Y }
C {devices/lab_pin.sym} 120300 -34450 0 0 {name=p119228 lab=_71649_/A }
C {devices/lab_pin.sym} 120300 -34410 0 0 {name=p119229 lab=_71664_/Y }
C {devices/lab_pin.sym} 120460 -34450 0 1 {name=p119230 lab=_83419_/D }
C {sky130_stdcells/o21ai_4.sym} 120380 -34450 0 0 {name=X_71665_ }
C {devices/lab_pin.sym} 120340 -34310 0 0 {name=p119231 lab=_63103_/A }
C {devices/lab_pin.sym} 120420 -34310 0 1 {name=p119232 lab=_59388_/A }
C {sky130_stdcells/buf_2.sym} 120380 -34310 0 0 {name=X_59387_ }
C {devices/lab_pin.sym} 120300 -34220 0 0 {name=p119233 lab=_56556_/Y }
C {devices/lab_pin.sym} 120300 -34180 0 0 {name=p119234 lab=_55570_/D }
C {devices/lab_pin.sym} 120300 -34140 0 0 {name=p119235 lab=_73078_/A }
C {devices/lab_pin.sym} 120300 -34100 0 0 {name=p119236 lab=_56598_/Y }
C {devices/lab_pin.sym} 120460 -34160 0 1 {name=p119237 lab=_56600_/A }
C {sky130_stdcells/a211o_4.sym} 120380 -34160 0 0 {name=X_56599_ }
C {devices/lab_pin.sym} 120340 -34010 0 0 {name=p119238 lab=clkbuf_9_170_0_CLK/X }
C {devices/lab_pin.sym} 120420 -34010 0 1 {name=p119239 lab=_85643_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 120380 -34010 0 0 {name=Xclkbuf_10_340_0_CLK }
C {devices/lab_pin.sym} 120320 -33900 0 0 {name=p119240 lab=_49140_/A }
C {devices/lab_pin.sym} 120320 -33860 0 0 {name=p119241 lab=_49140_/B }
C {devices/lab_pin.sym} 120440 -33880 0 1 {name=p119242 lab=_50693_/B }
C {sky130_stdcells/nor2_4.sym} 120380 -33880 0 0 {name=X_49140_ }
C {devices/lab_pin.sym} 120300 -33780 0 0 {name=p119243 lab=_73355_/X }
C {devices/lab_pin.sym} 120300 -33740 0 0 {name=p119244 lab=_85576_/Q }
C {devices/lab_pin.sym} 120300 -33700 0 0 {name=p119245 lab=_73284_/X }
C {devices/lab_pin.sym} 120300 -33660 0 0 {name=p119246 lab=_73403_/X }
C {devices/lab_pin.sym} 120460 -33720 0 1 {name=p119247 lab=_73404_/X }
C {sky130_stdcells/a211o_4.sym} 120380 -33720 0 0 {name=X_73404_ }
C {devices/lab_pin.sym} 120340 -33570 0 0 {name=p119248 lab=_51278_/B }
C {devices/lab_pin.sym} 120420 -33570 0 1 {name=p119249 lab=_53983_/B }
C {sky130_stdcells/buf_2.sym} 120380 -33570 0 0 {name=X_46352_ }
C {devices/lab_pin.sym} 120340 -33450 0 0 {name=p119250 lab=_70588_/A }
C {devices/lab_pin.sym} 120420 -33450 0 1 {name=p119251 lab=_70620_/B }
C {sky130_stdcells/buf_2.sym} 120380 -33450 0 0 {name=X_70616_ }
C {devices/lab_pin.sym} 120340 -33330 0 0 {name=p119252 lab=_58338_/A }
C {devices/lab_pin.sym} 120420 -33330 0 1 {name=p119253 lab=_58338_/Y }
C {sky130_stdcells/inv_2.sym} 120380 -33330 0 0 {name=X_58338_ }
C {devices/lab_pin.sym} 120320 -33220 0 0 {name=p119254 lab=_77172_/A }
C {devices/lab_pin.sym} 120320 -33180 0 0 {name=p119255 lab=_77172_/B }
C {devices/lab_pin.sym} 120440 -33200 0 1 {name=p119256 lab=_77177_/A }
C {sky130_stdcells/nor2_4.sym} 120380 -33200 0 0 {name=X_77172_ }
C {devices/lab_pin.sym} 120300 -33110 0 0 {name=p119257 lab=_43557_/X }
C {devices/lab_pin.sym} 120300 -33070 0 0 {name=p119258 lab=_43563_/X }
C {devices/lab_pin.sym} 120300 -33030 0 0 {name=p119259 lab=_40491_/X }
C {devices/lab_pin.sym} 120300 -32990 0 0 {name=p119260 lab=_87359_/Q }
C {devices/lab_pin.sym} 120300 -32950 0 0 {name=p119261 lab=_43549_/X }
C {devices/lab_pin.sym} 120460 -33030 0 1 {name=p119262 lab=_43564_/Y }
C {sky130_stdcells/o32ai_4.sym} 120380 -33030 0 0 {name=X_43564_ }
C {devices/lab_pin.sym} 120300 -32890 0 0 {name=p119263 lab=_83077_/Q }
C {devices/lab_pin.sym} 120300 -32850 0 0 {name=p119264 lab=_72090_/X }
C {devices/lab_pin.sym} 120300 -32810 0 0 {name=p119265 lab=_74383_/Y }
C {devices/lab_pin.sym} 120460 -32850 0 1 {name=p119266 lab=_74384_/Y }
C {sky130_stdcells/o21ai_4.sym} 120380 -32850 0 0 {name=X_74384_ }
C {devices/lab_pin.sym} 120340 -32710 0 0 {name=p119267 lab=_40776_/A }
C {devices/lab_pin.sym} 120420 -32710 0 1 {name=p119268 lab=_40776_/X }
C {sky130_stdcells/buf_2.sym} 120380 -32710 0 0 {name=X_40776_ }
C {devices/lab_pin.sym} 120340 -32590 0 0 {name=p119269 lab=clkbuf_9_485_0_CLK/X }
C {devices/lab_pin.sym} 120420 -32590 0 1 {name=p119270 lab=_86530_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 120380 -32590 0 0 {name=Xclkbuf_10_970_0_CLK }
C {devices/lab_pin.sym} 120300 -32490 0 0 {name=p119271 lab=_71581_/A }
C {devices/lab_pin.sym} 120300 -32450 0 0 {name=p119272 lab=_83444_/Q }
C {devices/lab_pin.sym} 120300 -32410 0 0 {name=p119273 lab=_71595_/Y }
C {devices/lab_pin.sym} 120460 -32450 0 1 {name=p119274 lab=_83444_/D }
C {sky130_stdcells/a21o_4.sym} 120380 -32450 0 0 {name=X_71596_ }
C {devices/lab_pin.sym} 120340 -32310 0 0 {name=p119275 lab=_45651_/A }
C {devices/lab_pin.sym} 120420 -32310 0 1 {name=p119276 lab=_45303_/X }
C {sky130_stdcells/buf_2.sym} 120380 -32310 0 0 {name=X_45303_ }
C {devices/lab_pin.sym} 120320 -32220 0 0 {name=p119277 lab=_76112_/A }
C {devices/lab_pin.sym} 120320 -32180 0 0 {name=p119278 lab=_76107_/A }
C {devices/lab_pin.sym} 120320 -32140 0 0 {name=p119279 lab=_76126_/A }
C {devices/lab_pin.sym} 120320 -32100 0 0 {name=p119280 lab=_76127_/B }
C {devices/lab_pin.sym} 120440 -32160 0 1 {name=p119281 lab=_76123_/Y }
C {sky130_stdcells/nand4_4.sym} 120380 -32160 0 0 {name=X_76123_ }
C {devices/lab_pin.sym} 120340 -32010 0 0 {name=p119282 lab=_74071_/A }
C {devices/lab_pin.sym} 120420 -32010 0 1 {name=p119283 lab=_68910_/B }
C {sky130_stdcells/inv_2.sym} 120380 -32010 0 0 {name=X_42515_ }
C {devices/lab_pin.sym} 120290 -31890 0 0 {name=p119284 lab=_87070_/CLK }
C {devices/lab_pin.sym} 120290 -31870 0 0 {name=p119285 lab=_41900_/Y }
C {devices/lab_pin.sym} 120470 -31890 0 1 {name=p119286 lab=_88109_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -31880 0 0 {name=X_88109_ }
C {devices/lab_pin.sym} 120300 -31770 0 0 {name=p119287 lab=_49066_/Y }
C {devices/lab_pin.sym} 120300 -31730 0 0 {name=p119288 lab=_49038_/X }
C {devices/lab_pin.sym} 120300 -31690 0 0 {name=p119289 lab=_49070_/X }
C {devices/lab_pin.sym} 120460 -31730 0 1 {name=p119290 lab=_86447_/D }
C {sky130_stdcells/a21oi_4.sym} 120380 -31730 0 0 {name=X_49071_ }
C {devices/lab_pin.sym} 120300 -31620 0 0 {name=p119291 lab=_73163_/X }
C {devices/lab_pin.sym} 120300 -31580 0 0 {name=p119292 lab=_83059_/Q }
C {devices/lab_pin.sym} 120300 -31540 0 0 {name=p119293 lab=_72880_/X }
C {devices/lab_pin.sym} 120300 -31500 0 0 {name=p119294 lab=_73334_/X }
C {devices/lab_pin.sym} 120460 -31560 0 1 {name=p119295 lab=_73335_/X }
C {sky130_stdcells/a211o_4.sym} 120380 -31560 0 0 {name=X_73335_ }
C {devices/lab_pin.sym} 120320 -31420 0 0 {name=p119296 lab=_46326_/A }
C {devices/lab_pin.sym} 120320 -31380 0 0 {name=p119297 lab=_50744_/B }
C {devices/lab_pin.sym} 120440 -31400 0 1 {name=p119298 lab=_46283_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -31400 0 0 {name=X_46283_ }
C {devices/lab_pin.sym} 120340 -31270 0 0 {name=p119299 lab=DATA_TO_HASH[5] }
C {devices/lab_pin.sym} 120420 -31270 0 1 {name=p119300 lab=_71857_/A }
C {sky130_stdcells/inv_2.sym} 120380 -31270 0 0 {name=X_70547_ }
C {devices/lab_pin.sym} 120300 -31170 0 0 {name=p119301 lab=_58253_/X }
C {devices/lab_pin.sym} 120300 -31130 0 0 {name=p119302 lab=_83444_/Q }
C {devices/lab_pin.sym} 120300 -31090 0 0 {name=p119303 lab=_58268_/Y }
C {devices/lab_pin.sym} 120460 -31130 0 1 {name=p119304 lab=_84892_/D }
C {sky130_stdcells/o21a_4.sym} 120380 -31130 0 0 {name=X_58269_ }
C {devices/lab_pin.sym} 120340 -30990 0 0 {name=p119305 lab=_43518_/A }
C {devices/lab_pin.sym} 120420 -30990 0 1 {name=p119306 lab=_43495_/X }
C {sky130_stdcells/buf_2.sym} 120380 -30990 0 0 {name=X_43495_ }
C {devices/lab_pin.sym} 120340 -30870 0 0 {name=p119307 lab=clkbuf_9_461_0_CLK/A }
C {devices/lab_pin.sym} 120420 -30870 0 1 {name=p119308 lab=clkbuf_9_461_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 120380 -30870 0 0 {name=Xclkbuf_9_461_0_CLK }
C {devices/lab_pin.sym} 120320 -30770 0 0 {name=p119309 lab=_60367_/B }
C {devices/lab_pin.sym} 120320 -30730 0 0 {name=p119310 lab=_60300_/B }
C {devices/lab_pin.sym} 120320 -30690 0 0 {name=p119311 lab=_60300_/C }
C {devices/lab_pin.sym} 120440 -30730 0 1 {name=p119312 lab=_60300_/Y }
C {sky130_stdcells/nand3_4.sym} 120380 -30730 0 0 {name=X_60300_ }
C {devices/lab_pin.sym} 120340 -30590 0 0 {name=p119313 lab=_83543_/Q }
C {devices/lab_pin.sym} 120420 -30590 0 1 {name=p119314 lab=_48022_/Y }
C {sky130_stdcells/inv_2.sym} 120380 -30590 0 0 {name=X_48022_ }
C {devices/lab_pin.sym} 120340 -30470 0 0 {name=p119315 lab=_64458_/B }
C {devices/lab_pin.sym} 120420 -30470 0 1 {name=p119316 lab=_61579_/B }
C {sky130_stdcells/buf_2.sym} 120380 -30470 0 0 {name=X_45234_ }
C {devices/lab_pin.sym} 120320 -30360 0 0 {name=p119317 lab=_76054_/A }
C {devices/lab_pin.sym} 120320 -30320 0 0 {name=p119318 lab=_81748_/D }
C {devices/lab_pin.sym} 120440 -30340 0 1 {name=p119319 lab=_76054_/X }
C {sky130_stdcells/xor2_4.sym} 120380 -30340 0 0 {name=X_76054_ }
C {devices/lab_pin.sym} 120340 -30210 0 0 {name=p119320 lab=_42446_/A }
C {devices/lab_pin.sym} 120420 -30210 0 1 {name=p119321 lab=_47872_/A }
C {sky130_stdcells/buf_2.sym} 120380 -30210 0 0 {name=X_42446_ }
C {devices/lab_pin.sym} 120320 -30120 0 0 {name=p119322 lab=_61286_/A }
C {devices/lab_pin.sym} 120320 -30080 0 0 {name=p119323 lab=_60593_/B }
C {devices/lab_pin.sym} 120320 -30040 0 0 {name=p119324 lab=_61079_/A }
C {devices/lab_pin.sym} 120320 -30000 0 0 {name=p119325 lab=_60509_/Y }
C {devices/lab_pin.sym} 120440 -30060 0 1 {name=p119326 lab=_61281_/A }
C {sky130_stdcells/nor4_4.sym} 120380 -30060 0 0 {name=X_61280_ }
C {devices/lab_pin.sym} 120300 -29940 0 0 {name=p119327 lab=_73214_/X }
C {devices/lab_pin.sym} 120300 -29900 0 0 {name=p119328 lab=_83062_/Q }
C {devices/lab_pin.sym} 120300 -29860 0 0 {name=p119329 lab=_73238_/X }
C {devices/lab_pin.sym} 120300 -29820 0 0 {name=p119330 lab=_73265_/X }
C {devices/lab_pin.sym} 120460 -29880 0 1 {name=p119331 lab=_73266_/X }
C {sky130_stdcells/a211o_4.sym} 120380 -29880 0 0 {name=X_73266_ }
C {devices/lab_pin.sym} 120300 -29750 0 0 {name=p119332 lab=_70466_/Y }
C {devices/lab_pin.sym} 120300 -29710 0 0 {name=p119333 lab=_58356_/B }
C {devices/lab_pin.sym} 120300 -29670 0 0 {name=p119334 lab=_70477_/X }
C {devices/lab_pin.sym} 120460 -29710 0 1 {name=p119335 lab=_83766_/D }
C {sky130_stdcells/a21o_4.sym} 120380 -29710 0 0 {name=X_70478_ }
C {devices/lab_pin.sym} 120340 -29570 0 0 {name=p119336 lab=clkbuf_9_177_0_CLK/X }
C {devices/lab_pin.sym} 120420 -29570 0 1 {name=p119337 lab=_86637_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 120380 -29570 0 0 {name=Xclkbuf_10_355_0_CLK }
C {devices/lab_pin.sym} 120320 -29460 0 0 {name=p119338 lab=_75001_/Y }
C {devices/lab_pin.sym} 120320 -29420 0 0 {name=p119339 lab=_75004_/X }
C {devices/lab_pin.sym} 120440 -29440 0 1 {name=p119340 lab=_75005_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -29440 0 0 {name=X_75005_ }
C {devices/lab_pin.sym} 120300 -29350 0 0 {name=p119341 lab=_60078_/X }
C {devices/lab_pin.sym} 120300 -29310 0 0 {name=p119342 lab=_60299_/A }
C {devices/lab_pin.sym} 120300 -29270 0 0 {name=p119343 lab=_60300_/B }
C {devices/lab_pin.sym} 120300 -29230 0 0 {name=p119344 lab=_60229_/Y }
C {devices/lab_pin.sym} 120300 -29200 0 0 {name=p119345 lab=_60230_/Y }
C {devices/lab_pin.sym} 120460 -29270 0 1 {name=p119346 lab=_60231_/Y }
C {sky130_stdcells/a41oi_4.sym} 120380 -29270 0 0 {name=X_60231_ }
C {devices/lab_pin.sym} 120300 -29130 0 0 {name=p119347 lab=_72155_/X }
C {devices/lab_pin.sym} 120300 -29090 0 0 {name=p119348 lab=_85689_/Q }
C {devices/lab_pin.sym} 120300 -29050 0 0 {name=p119349 lab=_72156_/X }
C {devices/lab_pin.sym} 120460 -29090 0 1 {name=p119350 lab=_72217_/X }
C {sky130_stdcells/o21a_4.sym} 120380 -29090 0 0 {name=X_72217_ }
C {devices/lab_pin.sym} 120300 -28970 0 0 {name=p119351 lab=_56420_/C }
C {devices/lab_pin.sym} 120300 -28930 0 0 {name=p119352 lab=_45102_/X }
C {devices/lab_pin.sym} 120300 -28890 0 0 {name=p119353 lab=_45164_/X }
C {devices/lab_pin.sym} 120460 -28930 0 1 {name=p119354 lab=_45165_/Y }
C {sky130_stdcells/o21ai_4.sym} 120380 -28930 0 0 {name=X_45165_ }
C {devices/lab_pin.sym} 120340 -28790 0 0 {name=p119355 lab=clkbuf_9_492_0_CLK/X }
C {devices/lab_pin.sym} 120420 -28790 0 1 {name=p119356 lab=_83562_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 120380 -28790 0 0 {name=Xclkbuf_10_985_0_CLK }
C {devices/lab_pin.sym} 120300 -28700 0 0 {name=p119357 lab=_41782_/X }
C {devices/lab_pin.sym} 120300 -28660 0 0 {name=p119358 lab=_42374_/X }
C {devices/lab_pin.sym} 120300 -28620 0 0 {name=p119359 lab=_87894_/Q }
C {devices/lab_pin.sym} 120300 -28580 0 0 {name=p119360 lab=_42375_/X }
C {devices/lab_pin.sym} 120460 -28640 0 1 {name=p119361 lab=_87894_/D }
C {sky130_stdcells/a2bb2o_4.sym} 120380 -28640 0 0 {name=X_42377_ }
C {devices/lab_pin.sym} 120300 -28520 0 0 {name=p119362 lab=_69790_/Y }
C {devices/lab_pin.sym} 120300 -28480 0 0 {name=p119363 lab=_73104_/B }
C {devices/lab_pin.sym} 120300 -28440 0 0 {name=p119364 lab=_73194_/X }
C {devices/lab_pin.sym} 120300 -28400 0 0 {name=p119365 lab=_73196_/Y }
C {devices/lab_pin.sym} 120460 -28460 0 1 {name=p119366 lab=_73197_/X }
C {sky130_stdcells/a211o_4.sym} 120380 -28460 0 0 {name=X_73197_ }
C {devices/lab_pin.sym} 120320 -28330 0 0 {name=p119367 lab=_43957_/B }
C {devices/lab_pin.sym} 120320 -28290 0 0 {name=p119368 lab=_44116_/B }
C {devices/lab_pin.sym} 120320 -28250 0 0 {name=p119369 lab=_43978_/Y }
C {devices/lab_pin.sym} 120440 -28290 0 1 {name=p119370 lab=_44117_/A }
C {sky130_stdcells/nor3_4.sym} 120380 -28290 0 0 {name=X_44116_ }
C {devices/lab_pin.sym} 120320 -28160 0 0 {name=p119371 lab=_79829_/A }
C {devices/lab_pin.sym} 120320 -28120 0 0 {name=p119372 lab=_79812_/Y }
C {devices/lab_pin.sym} 120440 -28140 0 1 {name=p119373 lab=_79813_/X }
C {sky130_stdcells/xor2_4.sym} 120380 -28140 0 0 {name=X_79813_ }
C {devices/lab_pin.sym} 120340 -28010 0 0 {name=p119374 lab=_41327_/Y }
C {devices/lab_pin.sym} 120420 -28010 0 1 {name=p119375 lab=_41328_/X }
C {sky130_stdcells/buf_2.sym} 120380 -28010 0 0 {name=X_41328_ }
C {devices/lab_pin.sym} 120320 -27920 0 0 {name=p119376 lab=_60162_/A }
C {devices/lab_pin.sym} 120320 -27880 0 0 {name=p119377 lab=_60636_/B }
C {devices/lab_pin.sym} 120320 -27840 0 0 {name=p119378 lab=_59615_/A }
C {devices/lab_pin.sym} 120320 -27800 0 0 {name=p119379 lab=_61287_/A }
C {devices/lab_pin.sym} 120440 -27860 0 1 {name=p119380 lab=_60162_/X }
C {sky130_stdcells/and4_4.sym} 120380 -27860 0 0 {name=X_60162_ }
C {devices/lab_pin.sym} 120300 -27730 0 0 {name=p119381 lab=_59381_/X }
C {devices/lab_pin.sym} 120300 -27690 0 0 {name=p119382 lab=_85983_/Q }
C {devices/lab_pin.sym} 120300 -27650 0 0 {name=p119383 lab=_72147_/X }
C {devices/lab_pin.sym} 120460 -27690 0 1 {name=p119384 lab=_72148_/Y }
C {sky130_stdcells/o21ai_4.sym} 120380 -27690 0 0 {name=X_72148_ }
C {devices/lab_pin.sym} 120320 -27580 0 0 {name=p119385 lab=_49973_/A }
C {devices/lab_pin.sym} 120320 -27540 0 0 {name=p119386 lab=_49973_/B }
C {devices/lab_pin.sym} 120320 -27500 0 0 {name=p119387 lab=_49973_/C }
C {devices/lab_pin.sym} 120320 -27460 0 0 {name=p119388 lab=_53185_/D }
C {devices/lab_pin.sym} 120440 -27520 0 1 {name=p119389 lab=_49973_/X }
C {sky130_stdcells/and4_4.sym} 120380 -27520 0 0 {name=X_49973_ }
C {devices/lab_pin.sym} 120300 -27390 0 0 {name=p119390 lab=_45093_/X }
C {devices/lab_pin.sym} 120300 -27350 0 0 {name=p119391 lab=_45095_/Y }
C {devices/lab_pin.sym} 120300 -27310 0 0 {name=p119392 lab=_45049_/X }
C {devices/lab_pin.sym} 120460 -27350 0 1 {name=p119393 lab=_45096_/Y }
C {sky130_stdcells/a21oi_4.sym} 120380 -27350 0 0 {name=X_45096_ }
C {devices/lab_pin.sym} 120340 -27210 0 0 {name=p119394 lab=clkbuf_8_238_0_CLK/X }
C {devices/lab_pin.sym} 120420 -27210 0 1 {name=p119395 lab=clkbuf_9_476_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 120380 -27210 0 0 {name=Xclkbuf_9_476_0_CLK }
C {devices/lab_pin.sym} 120320 -27100 0 0 {name=p119396 lab=_48924_/A }
C {devices/lab_pin.sym} 120320 -27060 0 0 {name=p119397 lab=_48699_/B }
C {devices/lab_pin.sym} 120440 -27080 0 1 {name=p119398 lab=_48924_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -27080 0 0 {name=X_48924_ }
C {devices/lab_pin.sym} 120340 -26950 0 0 {name=p119399 lab=_44046_/X }
C {devices/lab_pin.sym} 120420 -26950 0 1 {name=p119400 lab=_44047_/X }
C {sky130_stdcells/buf_2.sym} 120380 -26950 0 0 {name=X_44047_ }
C {devices/lab_pin.sym} 120320 -26840 0 0 {name=p119401 lab=_79740_/X }
C {devices/lab_pin.sym} 120320 -26800 0 0 {name=p119402 lab=_79743_/Y }
C {devices/lab_pin.sym} 120440 -26820 0 1 {name=p119403 lab=_79745_/A }
C {sky130_stdcells/xor2_4.sym} 120380 -26820 0 0 {name=X_79744_ }
C {devices/lab_pin.sym} 120340 -26690 0 0 {name=p119404 lab=_41259_/A }
C {devices/lab_pin.sym} 120420 -26690 0 1 {name=p119405 lab=_41259_/X }
C {sky130_stdcells/buf_2.sym} 120380 -26690 0 0 {name=X_41259_ }
C {devices/lab_pin.sym} 120300 -26590 0 0 {name=p119406 lab=_64966_/Y }
C {devices/lab_pin.sym} 120300 -26550 0 0 {name=p119407 lab=_64939_/X }
C {devices/lab_pin.sym} 120300 -26510 0 0 {name=p119408 lab=_64969_/X }
C {devices/lab_pin.sym} 120460 -26550 0 1 {name=p119409 lab=_64970_/X }
C {sky130_stdcells/a21o_4.sym} 120380 -26550 0 0 {name=X_64970_ }
C {devices/lab_pin.sym} 120300 -26440 0 0 {name=p119410 lab=_84663_/Q }
C {devices/lab_pin.sym} 120300 -26400 0 0 {name=p119411 lab=_59822_/X }
C {devices/lab_pin.sym} 120300 -26360 0 0 {name=p119412 lab=_59969_/X }
C {devices/lab_pin.sym} 120300 -26320 0 0 {name=p119413 lab=_60092_/Y }
C {devices/lab_pin.sym} 120460 -26380 0 1 {name=p119414 lab=_60093_/X }
C {sky130_stdcells/o22a_4.sym} 120380 -26380 0 0 {name=X_60093_ }
C {devices/lab_pin.sym} 120320 -26240 0 0 {name=p119415 lab=_72075_/A }
C {devices/lab_pin.sym} 120320 -26200 0 0 {name=p119416 lab=_72079_/B }
C {devices/lab_pin.sym} 120440 -26220 0 1 {name=p119417 lab=_72079_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -26220 0 0 {name=X_72079_ }
C {devices/lab_pin.sym} 120320 -26100 0 0 {name=p119418 lab=_76956_/A }
C {devices/lab_pin.sym} 120320 -26060 0 0 {name=p119419 lab=_76955_/Y }
C {devices/lab_pin.sym} 120440 -26080 0 1 {name=p119420 lab=_76958_/A }
C {sky130_stdcells/nand2_4.sym} 120380 -26080 0 0 {name=X_76956_ }
C {devices/lab_pin.sym} 120320 -25980 0 0 {name=p119421 lab=_57664_/X }
C {devices/lab_pin.sym} 120320 -25940 0 0 {name=p119422 lab=_63902_/B }
C {devices/lab_pin.sym} 120320 -25900 0 0 {name=p119423 lab=_63902_/C }
C {devices/lab_pin.sym} 120320 -25860 0 0 {name=p119424 lab=_63902_/D }
C {devices/lab_pin.sym} 120440 -25920 0 1 {name=p119425 lab=_63922_/D }
C {sky130_stdcells/nand4_4.sym} 120380 -25920 0 0 {name=X_63921_ }
C {devices/lab_pin.sym} 120320 -25780 0 0 {name=p119426 lab=_84505_/Q }
C {devices/lab_pin.sym} 120320 -25740 0 0 {name=p119427 lab=_75907_/B }
C {devices/lab_pin.sym} 120440 -25760 0 1 {name=p119428 lab=_75907_/X }
C {sky130_stdcells/xor2_4.sym} 120380 -25760 0 0 {name=X_75907_ }
C {devices/lab_pin.sym} 120300 -25650 0 0 {name=p119429 lab=_48852_/Y }
C {devices/lab_pin.sym} 120300 -25610 0 0 {name=p119430 lab=_48840_/X }
C {devices/lab_pin.sym} 120300 -25570 0 0 {name=p119431 lab=_48854_/X }
C {devices/lab_pin.sym} 120460 -25610 0 1 {name=p119432 lab=_48855_/Y }
C {sky130_stdcells/a21oi_4.sym} 120380 -25610 0 0 {name=X_48855_ }
C {devices/lab_pin.sym} 120300 -25490 0 0 {name=p119433 lab=_79667_/A }
C {devices/lab_pin.sym} 120300 -25450 0 0 {name=p119434 lab=_79666_/Y }
C {devices/lab_pin.sym} 120300 -25410 0 0 {name=p119435 lab=_79674_/X }
C {devices/lab_pin.sym} 120460 -25450 0 1 {name=p119436 lab=_79676_/B }
C {sky130_stdcells/o21ai_4.sym} 120380 -25450 0 0 {name=X_79675_ }
C {devices/lab_pin.sym} 120300 -25330 0 0 {name=p119437 lab=_76888_/A }
C {devices/lab_pin.sym} 120300 -25290 0 0 {name=p119438 lab=_76888_/C }
C {devices/lab_pin.sym} 120300 -25250 0 0 {name=p119439 lab=_76888_/B }
C {devices/lab_pin.sym} 120460 -25290 0 1 {name=p119440 lab=_76901_/A }
C {sky130_stdcells/a21o_4.sym} 120380 -25290 0 0 {name=X_76887_ }
C {devices/lab_pin.sym} 120340 -25150 0 0 {name=p119441 lab=_47714_/A }
C {devices/lab_pin.sym} 120420 -25150 0 1 {name=p119442 lab=_47806_/X }
C {sky130_stdcells/buf_2.sym} 120380 -25150 0 0 {name=X_47806_ }
C {devices/lab_pin.sym} 120320 -25040 0 0 {name=p119443 lab=_66689_/A }
C {devices/lab_pin.sym} 120320 -25000 0 0 {name=p119444 lab=_87632_/Q }
C {devices/lab_pin.sym} 120440 -25020 0 1 {name=p119445 lab=_66640_/X }
C {sky130_stdcells/and2_4.sym} 120380 -25020 0 0 {name=X_66640_ }
C {devices/lab_pin.sym} 120320 -24900 0 0 {name=p119446 lab=_78626_/A }
C {devices/lab_pin.sym} 120320 -24860 0 0 {name=p119447 lab=_78625_/Y }
C {devices/lab_pin.sym} 120440 -24880 0 1 {name=p119448 lab=_82775_/D }
C {sky130_stdcells/xor2_4.sym} 120380 -24880 0 0 {name=X_78626_ }
C {devices/lab_pin.sym} 120340 -24750 0 0 {name=p119449 lab=_80927_/Q }
C {devices/lab_pin.sym} 120420 -24750 0 1 {name=p119450 lab=_75838_/Y }
C {sky130_stdcells/inv_2.sym} 120380 -24750 0 0 {name=X_75838_ }
C {devices/lab_pin.sym} 120340 -24630 0 0 {name=p119451 lab=_63749_/A }
C {devices/lab_pin.sym} 120420 -24630 0 1 {name=p119452 lab=_63853_/B }
C {sky130_stdcells/buf_2.sym} 120380 -24630 0 0 {name=X_63852_ }
C {devices/lab_pin.sym} 120320 -24530 0 0 {name=p119453 lab=_50469_/A }
C {devices/lab_pin.sym} 120320 -24490 0 0 {name=p119454 lab=_48770_/X }
C {devices/lab_pin.sym} 120320 -24450 0 0 {name=p119455 lab=_48786_/C }
C {devices/lab_pin.sym} 120440 -24490 0 1 {name=p119456 lab=_48786_/X }
C {sky130_stdcells/and3_4.sym} 120380 -24490 0 0 {name=X_48786_ }
C {devices/lab_pin.sym} 120300 -24380 0 0 {name=p119457 lab=_40468_/Y }
C {devices/lab_pin.sym} 120300 -24340 0 0 {name=p119458 lab=_45974_/X }
C {devices/lab_pin.sym} 120300 -24300 0 0 {name=p119459 lab=_86822_/Q }
C {devices/lab_pin.sym} 120300 -24260 0 0 {name=p119460 lab=_45976_/X }
C {devices/lab_pin.sym} 120460 -24320 0 1 {name=p119461 lab=_45998_/X }
C {sky130_stdcells/a2bb2o_4.sym} 120380 -24320 0 0 {name=X_45998_ }
C {devices/lab_pin.sym} 120340 -24170 0 0 {name=p119462 lab=_62667_/X }
C {devices/lab_pin.sym} 120420 -24170 0 1 {name=p119463 lab=_62848_/C }
C {sky130_stdcells/buf_2.sym} 120380 -24170 0 0 {name=X_62803_ }
C {devices/lab_pin.sym} 120340 -24050 0 0 {name=p119464 lab=_81227_/Q }
C {devices/lab_pin.sym} 120420 -24050 0 1 {name=p119465 lab=_55078_/D }
C {sky130_stdcells/inv_2.sym} 120380 -24050 0 0 {name=X_47737_ }
C {devices/lab_pin.sym} 120340 -23930 0 0 {name=p119466 lab=_69162_/A }
C {devices/lab_pin.sym} 120420 -23930 0 1 {name=p119467 lab=_66571_/X }
C {sky130_stdcells/buf_2.sym} 120380 -23930 0 0 {name=X_66571_ }
C {devices/lab_pin.sym} 120320 -23830 0 0 {name=p119468 lab=_78548_/X }
C {devices/lab_pin.sym} 120320 -23790 0 0 {name=p119469 lab=_78557_/B }
C {devices/lab_pin.sym} 120320 -23750 0 0 {name=p119470 lab=_78556_/Y }
C {devices/lab_pin.sym} 120440 -23790 0 1 {name=p119471 lab=_78560_/A }
C {sky130_stdcells/or3_4.sym} 120380 -23790 0 0 {name=X_78557_ }
C {devices/lab_pin.sym} 120340 -23650 0 0 {name=p119472 lab=clkbuf_9_461_0_CLK/X }
C {devices/lab_pin.sym} 120420 -23650 0 1 {name=p119473 lab=_88337_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 120380 -23650 0 0 {name=Xclkbuf_10_923_0_CLK }
C {devices/lab_pin.sym} 120300 -23550 0 0 {name=p119474 lab=_55963_/B }
C {devices/lab_pin.sym} 120300 -23510 0 0 {name=p119475 lab=_44935_/X }
C {devices/lab_pin.sym} 120300 -23470 0 0 {name=p119476 lab=_45757_/A }
C {devices/lab_pin.sym} 120460 -23510 0 1 {name=p119477 lab=_44949_/X }
C {sky130_stdcells/o21a_4.sym} 120380 -23510 0 0 {name=X_44949_ }
C {devices/lab_pin.sym} 120300 -23410 0 0 {name=p119478 lab=_63779_/X }
C {devices/lab_pin.sym} 120300 -23370 0 0 {name=p119479 lab=_63736_/X }
C {devices/lab_pin.sym} 120300 -23330 0 0 {name=p119480 lab=_63780_/Y }
C {devices/lab_pin.sym} 120300 -23290 0 0 {name=p119481 lab=_63781_/Y }
C {devices/lab_pin.sym} 120300 -23260 0 0 {name=p119482 lab=_63782_/X }
C {devices/lab_pin.sym} 120460 -23330 0 1 {name=p119483 lab=_63783_/X }
C {sky130_stdcells/a41o_4.sym} 120380 -23330 0 0 {name=X_63783_ }
C {devices/lab_pin.sym} 120320 -23180 0 0 {name=p119484 lab=_81096_/Q }
C {devices/lab_pin.sym} 120320 -23140 0 0 {name=p119485 lab=_80808_/Q }
C {devices/lab_pin.sym} 120440 -23160 0 1 {name=p119486 lab=_75769_/Y }
C {sky130_stdcells/xnor2_4.sym} 120380 -23160 0 0 {name=X_75769_ }
C {devices/lab_pin.sym} 120340 -23030 0 0 {name=p119487 lab=_60994_/Y }
C {devices/lab_pin.sym} 120420 -23030 0 1 {name=p119488 lab=_60995_/Y }
C {sky130_stdcells/inv_2.sym} 120380 -23030 0 0 {name=X_60995_ }
C {devices/lab_pin.sym} 120300 -22940 0 0 {name=p119489 lab=_68301_/X }
C {devices/lab_pin.sym} 120300 -22900 0 0 {name=p119490 lab=_67887_/Y }
C {devices/lab_pin.sym} 120300 -22860 0 0 {name=p119491 lab=_68308_/X }
C {devices/lab_pin.sym} 120300 -22820 0 0 {name=p119492 lab=_68309_/Y }
C {devices/lab_pin.sym} 120460 -22880 0 1 {name=p119493 lab=_68310_/X }
C {sky130_stdcells/a211o_4.sym} 120380 -22880 0 0 {name=X_68310_ }
C {devices/lab_pin.sym} 120300 -22760 0 0 {name=p119494 lab=_65362_/X }
C {devices/lab_pin.sym} 120300 -22720 0 0 {name=p119495 lab=_85595_/Q }
C {devices/lab_pin.sym} 120300 -22680 0 0 {name=p119496 lab=_65363_/X }
C {devices/lab_pin.sym} 120300 -22640 0 0 {name=p119497 lab=_65521_/X }
C {devices/lab_pin.sym} 120460 -22700 0 1 {name=p119498 lab=_65522_/X }
C {sky130_stdcells/a211o_4.sym} 120380 -22700 0 0 {name=X_65522_ }
C {devices/lab_pin.sym} 120340 -22550 0 0 {name=p119499 lab=_77508_/A }
C {devices/lab_pin.sym} 120420 -22550 0 1 {name=p119500 lab=_77508_/Y }
C {sky130_stdcells/inv_2.sym} 120380 -22550 0 0 {name=X_77508_ }
C {devices/lab_pin.sym} 120340 -22430 0 0 {name=p119501 lab=_62672_/A }
C {devices/lab_pin.sym} 120420 -22430 0 1 {name=p119502 lab=_62766_/B }
C {sky130_stdcells/buf_2.sym} 120380 -22430 0 0 {name=X_62734_ }
C {devices/lab_pin.sym} 120300 -22330 0 0 {name=p119503 lab=_69287_/X }
C {devices/lab_pin.sym} 120300 -22290 0 0 {name=p119504 lab=_69289_/X }
C {devices/lab_pin.sym} 120300 -22250 0 0 {name=p119505 lab=_69251_/X }
C {devices/lab_pin.sym} 120460 -22290 0 1 {name=p119506 lab=_69290_/X }
C {sky130_stdcells/a21o_4.sym} 120380 -22290 0 0 {name=X_69290_ }
C {devices/lab_pin.sym} 120340 -22150 0 0 {name=p119507 lab=_47668_/A }
C {devices/lab_pin.sym} 120420 -22150 0 1 {name=p119508 lab=_54871_/B }
C {sky130_stdcells/inv_2.sym} 120380 -22150 0 0 {name=X_47668_ }
C {devices/lab_pin.sym} 120320 -22040 0 0 {name=p119509 lab=_78489_/A }
C {devices/lab_pin.sym} 120320 -22000 0 0 {name=p119510 lab=_82671_/D }
C {devices/lab_pin.sym} 120440 -22020 0 1 {name=p119511 lab=_78488_/Y }
C {sky130_stdcells/nor2_4.sym} 120380 -22020 0 0 {name=X_78488_ }
C {devices/lab_pin.sym} 120340 -21890 0 0 {name=p119512 lab=clkbuf_9_415_0_CLK/A }
C {devices/lab_pin.sym} 120420 -21890 0 1 {name=p119513 lab=clkbuf_9_414_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 120380 -21890 0 0 {name=Xclkbuf_9_414_0_CLK }
C {devices/lab_pin.sym} 120340 -21770 0 0 {name=p119514 lab=_49407_/A }
C {devices/lab_pin.sym} 120420 -21770 0 1 {name=p119515 lab=_49420_/A }
C {sky130_stdcells/buf_2.sym} 120380 -21770 0 0 {name=X_49407_ }
C {devices/lab_pin.sym} 120300 -21680 0 0 {name=p119516 lab=_68221_/X }
C {devices/lab_pin.sym} 120300 -21640 0 0 {name=p119517 lab=_67484_/Y }
C {devices/lab_pin.sym} 120300 -21600 0 0 {name=p119518 lab=_68228_/X }
C {devices/lab_pin.sym} 120300 -21560 0 0 {name=p119519 lab=_68240_/Y }
C {devices/lab_pin.sym} 120460 -21620 0 1 {name=p119520 lab=_68241_/X }
C {sky130_stdcells/a211o_4.sym} 120380 -21620 0 0 {name=X_68241_ }
C {devices/lab_pin.sym} 120340 -21470 0 0 {name=p119521 lab=_46619_/A }
C {devices/lab_pin.sym} 120420 -21470 0 1 {name=p119522 lab=_52580_/D }
C {sky130_stdcells/buf_2.sym} 120380 -21470 0 0 {name=X_46619_ }
C {devices/lab_pin.sym} 120340 -21350 0 0 {name=p119523 lab=_65118_/A }
C {devices/lab_pin.sym} 120420 -21350 0 1 {name=p119524 lab=_65453_/X }
C {sky130_stdcells/buf_2.sym} 120380 -21350 0 0 {name=X_65453_ }
C {devices/lab_pin.sym} 120300 -21250 0 0 {name=p119525 lab=_77403_/B }
C {devices/lab_pin.sym} 120300 -21210 0 0 {name=p119526 lab=_77434_/Y }
C {devices/lab_pin.sym} 120300 -21170 0 0 {name=p119527 lab=_77438_/Y }
C {devices/lab_pin.sym} 120460 -21210 0 1 {name=p119528 lab=_77439_/Y }
C {sky130_stdcells/a21oi_4.sym} 120380 -21210 0 0 {name=X_77439_ }
C {devices/lab_pin.sym} 120340 -21070 0 0 {name=p119529 lab=_62910_/A }
C {devices/lab_pin.sym} 120420 -21070 0 1 {name=p119530 lab=_62847_/A }
C {sky130_stdcells/buf_2.sym} 120380 -21070 0 0 {name=X_62665_ }
C {devices/lab_pin.sym} 120340 -20950 0 0 {name=p119531 lab=clkbuf_9_154_0_CLK/X }
C {devices/lab_pin.sym} 120420 -20950 0 1 {name=p119532 lab=_83431_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 120380 -20950 0 0 {name=Xclkbuf_10_308_0_CLK }
C {devices/lab_pin.sym} 120320 -20840 0 0 {name=p119533 lab=_47574_/A }
C {devices/lab_pin.sym} 120320 -20800 0 0 {name=p119534 lab=_53141_/B }
C {devices/lab_pin.sym} 120440 -20820 0 1 {name=p119535 lab=_47599_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -20820 0 0 {name=X_47599_ }
C {devices/lab_pin.sym} 120320 -20710 0 0 {name=p119536 lab=_64380_/X }
C {devices/lab_pin.sym} 120320 -20670 0 0 {name=p119537 lab=_84865_/Q }
C {devices/lab_pin.sym} 120320 -20630 0 0 {name=p119538 lab=_64381_/X }
C {devices/lab_pin.sym} 120440 -20670 0 1 {name=p119539 lab=_64404_/Y }
C {sky130_stdcells/nand3_4.sym} 120380 -20670 0 0 {name=X_64404_ }
C {devices/lab_pin.sym} 120320 -20540 0 0 {name=p119540 lab=_49327_/X }
C {devices/lab_pin.sym} 120320 -20500 0 0 {name=p119541 lab=_54071_/B }
C {devices/lab_pin.sym} 120440 -20520 0 1 {name=p119542 lab=_49338_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -20520 0 0 {name=X_49338_ }
C {devices/lab_pin.sym} 120340 -20390 0 0 {name=p119543 lab=clkbuf_9_469_0_CLK/X }
C {devices/lab_pin.sym} 120420 -20390 0 1 {name=p119544 lab=_87813_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 120380 -20390 0 0 {name=Xclkbuf_10_938_0_CLK }
C {devices/lab_pin.sym} 120300 -20290 0 0 {name=p119545 lab=_61614_/X }
C {devices/lab_pin.sym} 120300 -20250 0 0 {name=p119546 lab=_61576_/X }
C {devices/lab_pin.sym} 120300 -20210 0 0 {name=p119547 lab=_61615_/Y }
C {devices/lab_pin.sym} 120460 -20250 0 1 {name=p119548 lab=_61616_/Y }
C {sky130_stdcells/a21oi_4.sym} 120380 -20250 0 0 {name=X_61616_ }
C {devices/lab_pin.sym} 120300 -20130 0 0 {name=p119549 lab=_80429_/B }
C {devices/lab_pin.sym} 120300 -20090 0 0 {name=p119550 lab=_80446_/X }
C {devices/lab_pin.sym} 120300 -20050 0 0 {name=p119551 lab=_80449_/Y }
C {devices/lab_pin.sym} 120460 -20090 0 1 {name=p119552 lab=_80451_/B }
C {sky130_stdcells/a21oi_4.sym} 120380 -20090 0 0 {name=X_80450_ }
C {devices/lab_pin.sym} 120300 -19970 0 0 {name=p119553 lab=_82061_/D }
C {devices/lab_pin.sym} 120300 -19930 0 0 {name=p119554 lab=_68160_/X }
C {devices/lab_pin.sym} 120300 -19890 0 0 {name=p119555 lab=_68171_/X }
C {devices/lab_pin.sym} 120460 -19930 0 1 {name=p119556 lab=_68172_/X }
C {sky130_stdcells/a21bo_4.sym} 120380 -19930 0 0 {name=X_68172_ }
C {devices/lab_pin.sym} 120320 -19800 0 0 {name=p119557 lab=_65184_/A }
C {devices/lab_pin.sym} 120320 -19760 0 0 {name=p119558 lab=_65384_/B }
C {devices/lab_pin.sym} 120440 -19780 0 1 {name=p119559 lab=_65384_/X }
C {sky130_stdcells/and2_4.sym} 120380 -19780 0 0 {name=X_65384_ }
C {devices/lab_pin.sym} 120320 -19680 0 0 {name=p119560 lab=_62269_/X }
C {devices/lab_pin.sym} 120320 -19640 0 0 {name=p119561 lab=_58201_/X }
C {devices/lab_pin.sym} 120320 -19600 0 0 {name=p119562 lab=_62618_/C }
C {devices/lab_pin.sym} 120320 -19560 0 0 {name=p119563 lab=_62608_/D }
C {devices/lab_pin.sym} 120440 -19620 0 1 {name=p119564 lab=_62596_/X }
C {sky130_stdcells/and4_4.sym} 120380 -19620 0 0 {name=X_62596_ }
C {devices/lab_pin.sym} 120320 -19480 0 0 {name=p119565 lab=_67023_/A }
C {devices/lab_pin.sym} 120320 -19440 0 0 {name=p119566 lab=_67123_/B }
C {devices/lab_pin.sym} 120440 -19460 0 1 {name=p119567 lab=_67123_/X }
C {sky130_stdcells/and2_4.sym} 120380 -19460 0 0 {name=X_67123_ }
C {devices/lab_pin.sym} 120320 -19350 0 0 {name=p119568 lab=_79109_/A }
C {devices/lab_pin.sym} 120320 -19310 0 0 {name=p119569 lab=_79109_/B }
C {devices/lab_pin.sym} 120320 -19270 0 0 {name=p119570 lab=_79107_/A }
C {devices/lab_pin.sym} 120440 -19310 0 1 {name=p119571 lab=_79110_/B }
C {sky130_stdcells/nand3_4.sym} 120380 -19310 0 0 {name=X_79109_ }
C {devices/lab_pin.sym} 120320 -19190 0 0 {name=p119572 lab=_64295_/A }
C {devices/lab_pin.sym} 120320 -19150 0 0 {name=p119573 lab=_64307_/B }
C {devices/lab_pin.sym} 120320 -19110 0 0 {name=p119574 lab=_64335_/C }
C {devices/lab_pin.sym} 120440 -19150 0 1 {name=p119575 lab=_64335_/X }
C {sky130_stdcells/and3_4.sym} 120380 -19150 0 0 {name=X_64335_ }
C {devices/lab_pin.sym} 120340 -19010 0 0 {name=p119576 lab=clkbuf_9_429_0_CLK/A }
C {devices/lab_pin.sym} 120420 -19010 0 1 {name=p119577 lab=clkbuf_9_429_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 120380 -19010 0 0 {name=Xclkbuf_9_429_0_CLK }
C {devices/lab_pin.sym} 120300 -18910 0 0 {name=p119578 lab=_61545_/X }
C {devices/lab_pin.sym} 120300 -18870 0 0 {name=p119579 lab=_61517_/X }
C {devices/lab_pin.sym} 120300 -18830 0 0 {name=p119580 lab=_61546_/Y }
C {devices/lab_pin.sym} 120460 -18870 0 1 {name=p119581 lab=_61547_/Y }
C {sky130_stdcells/a21oi_4.sym} 120380 -18870 0 0 {name=X_61547_ }
C {devices/lab_pin.sym} 120320 -18740 0 0 {name=p119582 lab=_49261_/A }
C {devices/lab_pin.sym} 120320 -18700 0 0 {name=p119583 lab=_46396_/B }
C {devices/lab_pin.sym} 120440 -18720 0 1 {name=p119584 lab=_49269_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -18720 0 0 {name=X_49269_ }
C {devices/lab_pin.sym} 120320 -18600 0 0 {name=p119585 lab=_80394_/A }
C {devices/lab_pin.sym} 120320 -18560 0 0 {name=p119586 lab=_80394_/B }
C {devices/lab_pin.sym} 120440 -18580 0 1 {name=p119587 lab=_80404_/B }
C {sky130_stdcells/xor2_4.sym} 120380 -18580 0 0 {name=X_80381_ }
C {devices/lab_pin.sym} 120320 -18460 0 0 {name=p119588 lab=_51296_/A }
C {devices/lab_pin.sym} 120320 -18420 0 0 {name=p119589 lab=_46396_/B }
C {devices/lab_pin.sym} 120440 -18440 0 1 {name=p119590 lab=_51300_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -18440 0 0 {name=X_51300_ }
C {devices/lab_pin.sym} 120290 -18310 0 0 {name=p119591 lab=_82485_/CLK }
C {devices/lab_pin.sym} 120290 -18290 0 0 {name=p119592 lab=_82120_/D }
C {devices/lab_pin.sym} 120470 -18310 0 1 {name=p119593 lab=_82108_/D }
C {sky130_stdcells/dfxtp_4.sym} 120380 -18300 0 0 {name=X_82120_ }
C {devices/lab_pin.sym} 120320 -18180 0 0 {name=p119594 lab=_67051_/X }
C {devices/lab_pin.sym} 120320 -18140 0 0 {name=p119595 lab=_67053_/X }
C {devices/lab_pin.sym} 120440 -18160 0 1 {name=p119596 lab=_67054_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -18160 0 0 {name=X_67054_ }
C {devices/lab_pin.sym} 120340 -18030 0 0 {name=p119597 lab=_52319_/A }
C {devices/lab_pin.sym} 120420 -18030 0 1 {name=p119598 lab=_52280_/X }
C {sky130_stdcells/buf_2.sym} 120380 -18030 0 0 {name=X_52280_ }
C {devices/lab_pin.sym} 120300 -17930 0 0 {name=p119599 lab=_59463_/Y }
C {devices/lab_pin.sym} 120300 -17890 0 0 {name=p119600 lab=_64249_/X }
C {devices/lab_pin.sym} 120300 -17850 0 0 {name=p119601 lab=_64265_/Y }
C {devices/lab_pin.sym} 120460 -17890 0 1 {name=p119602 lab=_64266_/Y }
C {sky130_stdcells/o21ai_4.sym} 120380 -17890 0 0 {name=X_64266_ }
C {devices/lab_pin.sym} 120300 -17770 0 0 {name=p119603 lab=_61473_/X }
C {devices/lab_pin.sym} 120300 -17730 0 0 {name=p119604 lab=_61455_/X }
C {devices/lab_pin.sym} 120300 -17690 0 0 {name=p119605 lab=_61477_/Y }
C {devices/lab_pin.sym} 120460 -17730 0 1 {name=p119606 lab=_84478_/D }
C {sky130_stdcells/a21oi_4.sym} 120380 -17730 0 0 {name=X_61478_ }
C {devices/lab_pin.sym} 120300 -17610 0 0 {name=p119607 lab=_66001_/Y }
C {devices/lab_pin.sym} 120300 -17570 0 0 {name=p119608 lab=_65987_/X }
C {devices/lab_pin.sym} 120300 -17530 0 0 {name=p119609 lab=_66004_/X }
C {devices/lab_pin.sym} 120460 -17570 0 1 {name=p119610 lab=_66005_/X }
C {sky130_stdcells/a21o_4.sym} 120380 -17570 0 0 {name=X_66005_ }
C {devices/lab_pin.sym} 120320 -17460 0 0 {name=p119611 lab=_51220_/A }
C {devices/lab_pin.sym} 120320 -17420 0 0 {name=p119612 lab=_51230_/X }
C {devices/lab_pin.sym} 120320 -17380 0 0 {name=p119613 lab=_51225_/C }
C {devices/lab_pin.sym} 120320 -17340 0 0 {name=p119614 lab=_47218_/D }
C {devices/lab_pin.sym} 120440 -17400 0 1 {name=p119615 lab=_51231_/X }
C {sky130_stdcells/and4_4.sym} 120380 -17400 0 0 {name=X_51231_ }
C {devices/lab_pin.sym} 120320 -17280 0 0 {name=p119616 lab=_63216_/X }
C {devices/lab_pin.sym} 120320 -17240 0 0 {name=p119617 lab=_63217_/B }
C {devices/lab_pin.sym} 120320 -17200 0 0 {name=p119618 lab=_63241_/C }
C {devices/lab_pin.sym} 120320 -17160 0 0 {name=p119619 lab=_63181_/X }
C {devices/lab_pin.sym} 120440 -17220 0 1 {name=p119620 lab=_63217_/X }
C {sky130_stdcells/and4_4.sym} 120380 -17220 0 0 {name=X_63217_ }
C {devices/lab_pin.sym} 120290 -17070 0 0 {name=p119621 lab=_82053_/CLK }
C {devices/lab_pin.sym} 120290 -17050 0 0 {name=p119622 lab=_84011_/Q }
C {devices/lab_pin.sym} 120470 -17070 0 1 {name=p119623 lab=_82051_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -17060 0 0 {name=X_82051_ }
C {devices/lab_pin.sym} 120340 -16930 0 0 {name=p119624 lab=_60472_/A }
C {devices/lab_pin.sym} 120420 -16930 0 1 {name=p119625 lab=_60433_/A }
C {sky130_stdcells/buf_2.sym} 120380 -16930 0 0 {name=X_60429_ }
C {devices/lab_pin.sym} 120300 -16850 0 0 {name=p119626 lab=_64193_/X }
C {devices/lab_pin.sym} 120300 -16810 0 0 {name=p119627 lab=_63741_/X }
C {devices/lab_pin.sym} 120300 -16770 0 0 {name=p119628 lab=_64194_/Y }
C {devices/lab_pin.sym} 120300 -16730 0 0 {name=p119629 lab=_64195_/Y }
C {devices/lab_pin.sym} 120300 -16700 0 0 {name=p119630 lab=_64196_/Y }
C {devices/lab_pin.sym} 120460 -16770 0 1 {name=p119631 lab=_64197_/X }
C {sky130_stdcells/a41o_4.sym} 120380 -16770 0 0 {name=X_64197_ }
C {devices/lab_pin.sym} 120290 -16610 0 0 {name=p119632 lab=_84197_/CLK }
C {devices/lab_pin.sym} 120290 -16590 0 0 {name=p119633 lab=_84210_/Q }
C {devices/lab_pin.sym} 120470 -16610 0 1 {name=p119634 lab=_81002_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -16600 0 0 {name=X_81002_ }
C {devices/lab_pin.sym} 120320 -16480 0 0 {name=p119635 lab=_51167_/A }
C {devices/lab_pin.sym} 120320 -16440 0 0 {name=p119636 lab=_52855_/B }
C {devices/lab_pin.sym} 120440 -16460 0 1 {name=p119637 lab=_51162_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -16460 0 0 {name=X_51162_ }
C {devices/lab_pin.sym} 120300 -16370 0 0 {name=p119638 lab=_63142_/Y }
C {devices/lab_pin.sym} 120300 -16330 0 0 {name=p119639 lab=_63143_/X }
C {devices/lab_pin.sym} 120300 -16290 0 0 {name=p119640 lab=_63146_/X }
C {devices/lab_pin.sym} 120300 -16250 0 0 {name=p119641 lab=_63147_/X }
C {devices/lab_pin.sym} 120300 -16210 0 0 {name=p119642 lab=_63125_/X }
C {devices/lab_pin.sym} 120460 -16290 0 1 {name=p119643 lab=_63148_/Y }
C {sky130_stdcells/o41ai_4.sym} 120380 -16290 0 0 {name=X_63148_ }
C {devices/lab_pin.sym} 120340 -16130 0 0 {name=p119644 lab=_50113_/A }
C {devices/lab_pin.sym} 120420 -16130 0 1 {name=p119645 lab=_50113_/X }
C {sky130_stdcells/buf_2.sym} 120380 -16130 0 0 {name=X_50113_ }
C {devices/lab_pin.sym} 120290 -16010 0 0 {name=p119646 lab=_86030_/CLK }
C {devices/lab_pin.sym} 120290 -15990 0 0 {name=p119647 lab=_52499_/Y }
C {devices/lab_pin.sym} 120470 -16010 0 1 {name=p119648 lab=_65000_/B }
C {sky130_stdcells/dfxtp_4.sym} 120380 -16000 0 0 {name=X_85810_ }
C {devices/lab_pin.sym} 120340 -15870 0 0 {name=p119649 lab=_51039_/A }
C {devices/lab_pin.sym} 120420 -15870 0 1 {name=p119650 lab=_51093_/X }
C {sky130_stdcells/buf_2.sym} 120380 -15870 0 0 {name=X_51093_ }
C {devices/lab_pin.sym} 120300 -15780 0 0 {name=p119651 lab=_56381_/C }
C {devices/lab_pin.sym} 120300 -15740 0 0 {name=p119652 lab=_55689_/A }
C {devices/lab_pin.sym} 120300 -15700 0 0 {name=p119653 lab=_55611_/X }
C {devices/lab_pin.sym} 120300 -15660 0 0 {name=p119654 lab=_55969_/X }
C {devices/lab_pin.sym} 120460 -15720 0 1 {name=p119655 lab=_55970_/X }
C {sky130_stdcells/a211o_4.sym} 120380 -15720 0 0 {name=X_55970_ }
C {devices/lab_pin.sym} 120300 -15600 0 0 {name=p119656 lab=_87449_/Q }
C {devices/lab_pin.sym} 120300 -15560 0 0 {name=p119657 lab=_67953_/X }
C {devices/lab_pin.sym} 120300 -15520 0 0 {name=p119658 lab=_67954_/X }
C {devices/lab_pin.sym} 120300 -15480 0 0 {name=p119659 lab=_67955_/X }
C {devices/lab_pin.sym} 120460 -15540 0 1 {name=p119660 lab=_67956_/X }
C {sky130_stdcells/a211o_4.sym} 120380 -15540 0 0 {name=X_67956_ }
C {devices/lab_pin.sym} 120320 -15420 0 0 {name=p119661 lab=_63041_/A }
C {devices/lab_pin.sym} 120320 -15380 0 0 {name=p119662 lab=_63079_/B }
C {devices/lab_pin.sym} 120320 -15340 0 0 {name=p119663 lab=_63079_/C }
C {devices/lab_pin.sym} 120320 -15300 0 0 {name=p119664 lab=_63066_/D }
C {devices/lab_pin.sym} 120440 -15360 0 1 {name=p119665 lab=_63079_/X }
C {sky130_stdcells/and4_4.sym} 120380 -15360 0 0 {name=X_63079_ }
C {devices/lab_pin.sym} 120290 -15210 0 0 {name=p119666 lab=_86796_/CLK }
C {devices/lab_pin.sym} 120290 -15190 0 0 {name=p119667 lab=_86790_/D }
C {devices/lab_pin.sym} 120470 -15210 0 1 {name=p119668 lab=_66962_/B }
C {sky130_stdcells/dfxtp_4.sym} 120380 -15200 0 0 {name=X_86790_ }
C {devices/lab_pin.sym} 120340 -15070 0 0 {name=p119669 lab=_51012_/A }
C {devices/lab_pin.sym} 120420 -15070 0 1 {name=p119670 lab=_50929_/A }
C {sky130_stdcells/buf_2.sym} 120380 -15070 0 0 {name=X_50044_ }
C {devices/lab_pin.sym} 120300 -14970 0 0 {name=p119671 lab=_85353_/Q }
C {devices/lab_pin.sym} 120300 -14930 0 0 {name=p119672 lab=_54918_/X }
C {devices/lab_pin.sym} 120300 -14890 0 0 {name=p119673 lab=_54920_/Y }
C {devices/lab_pin.sym} 120460 -14930 0 1 {name=p119674 lab=_54921_/Y }
C {sky130_stdcells/o21ai_4.sym} 120380 -14930 0 0 {name=X_54921_ }
C {devices/lab_pin.sym} 120320 -14800 0 0 {name=p119675 lab=_66956_/A }
C {devices/lab_pin.sym} 120320 -14760 0 0 {name=p119676 lab=_88197_/Q }
C {devices/lab_pin.sym} 120440 -14780 0 1 {name=p119677 lab=_66907_/X }
C {sky130_stdcells/and2_4.sym} 120380 -14780 0 0 {name=X_66907_ }
C {devices/lab_pin.sym} 120290 -14650 0 0 {name=p119678 lab=_85741_/CLK }
C {devices/lab_pin.sym} 120290 -14630 0 0 {name=p119679 lab=_52862_/Y }
C {devices/lab_pin.sym} 120470 -14650 0 1 {name=p119680 lab=_85741_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -14640 0 0 {name=X_85741_ }
C {devices/lab_pin.sym} 120290 -14510 0 0 {name=p119681 lab=_82965_/CLK }
C {devices/lab_pin.sym} 120290 -14490 0 0 {name=p119682 lab=_82953_/D }
C {devices/lab_pin.sym} 120470 -14510 0 1 {name=p119683 lab=_82953_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -14500 0 0 {name=X_82953_ }
C {devices/lab_pin.sym} 120320 -14380 0 0 {name=p119684 lab=_67887_/A }
C {devices/lab_pin.sym} 120320 -14340 0 0 {name=p119685 lab=_67887_/B }
C {devices/lab_pin.sym} 120440 -14360 0 1 {name=p119686 lab=_67887_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -14360 0 0 {name=X_67887_ }
C {devices/lab_pin.sym} 120320 -14240 0 0 {name=p119687 lab=_71970_/A }
C {devices/lab_pin.sym} 120320 -14200 0 0 {name=p119688 lab=_50381_/B }
C {devices/lab_pin.sym} 120440 -14220 0 1 {name=p119689 lab=_57640_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -14220 0 0 {name=X_57640_ }
C {devices/lab_pin.sym} 120290 -14090 0 0 {name=p119690 lab=_81990_/CLK }
C {devices/lab_pin.sym} 120290 -14070 0 0 {name=p119691 lab=_77441_/X }
C {devices/lab_pin.sym} 120470 -14090 0 1 {name=p119692 lab=_82280_/D }
C {sky130_stdcells/dfxtp_4.sym} 120380 -14080 0 0 {name=X_81904_ }
C {devices/lab_pin.sym} 120340 -13950 0 0 {name=p119693 lab=_69626_/A }
C {devices/lab_pin.sym} 120420 -13950 0 1 {name=p119694 lab=_69865_/A }
C {sky130_stdcells/buf_2.sym} 120380 -13950 0 0 {name=X_69626_ }
C {devices/lab_pin.sym} 120320 -13860 0 0 {name=p119695 lab=_54857_/A }
C {devices/lab_pin.sym} 120320 -13820 0 0 {name=p119696 lab=_54857_/B }
C {devices/lab_pin.sym} 120320 -13780 0 0 {name=p119697 lab=_54857_/C }
C {devices/lab_pin.sym} 120320 -13740 0 0 {name=p119698 lab=_53159_/D }
C {devices/lab_pin.sym} 120440 -13800 0 1 {name=p119699 lab=_54852_/X }
C {sky130_stdcells/and4_4.sym} 120380 -13800 0 0 {name=X_54852_ }
C {devices/lab_pin.sym} 120320 -13660 0 0 {name=p119700 lab=_66795_/A }
C {devices/lab_pin.sym} 120320 -13620 0 0 {name=p119701 lab=_87624_/Q }
C {devices/lab_pin.sym} 120440 -13640 0 1 {name=p119702 lab=_66838_/X }
C {sky130_stdcells/and2_4.sym} 120380 -13640 0 0 {name=X_66838_ }
C {devices/lab_pin.sym} 120290 -13510 0 0 {name=p119703 lab=_84815_/CLK }
C {devices/lab_pin.sym} 120290 -13490 0 0 {name=p119704 lab=_53235_/Y }
C {devices/lab_pin.sym} 120470 -13510 0 1 {name=p119705 lab=_85672_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -13500 0 0 {name=X_85672_ }
C {devices/lab_pin.sym} 120290 -13370 0 0 {name=p119706 lab=_88267_/CLK }
C {devices/lab_pin.sym} 120290 -13350 0 0 {name=p119707 lab=_78095_/Y }
C {devices/lab_pin.sym} 120470 -13370 0 1 {name=p119708 lab=_82884_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -13360 0 0 {name=X_82884_ }
C {devices/lab_pin.sym} 120290 -13230 0 0 {name=p119709 lab=_83987_/CLK }
C {devices/lab_pin.sym} 120290 -13210 0 0 {name=p119710 lab=_87411_/D }
C {devices/lab_pin.sym} 120470 -13230 0 1 {name=p119711 lab=_87411_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -13220 0 0 {name=X_87411_ }
C {devices/lab_pin.sym} 120320 -13100 0 0 {name=p119712 lab=_53786_/A }
C {devices/lab_pin.sym} 120320 -13060 0 0 {name=p119713 lab=_48920_/Y }
C {devices/lab_pin.sym} 120440 -13080 0 1 {name=p119714 lab=_53803_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -13080 0 0 {name=X_53803_ }
C {devices/lab_pin.sym} 120290 -12950 0 0 {name=p119715 lab=_84623_/CLK }
C {devices/lab_pin.sym} 120290 -12930 0 0 {name=p119716 lab=_60358_/Y }
C {devices/lab_pin.sym} 120470 -12950 0 1 {name=p119717 lab=_79605_/A }
C {sky130_stdcells/dfxtp_4.sym} 120380 -12940 0 0 {name=X_84623_ }
C {devices/lab_pin.sym} 120340 -12810 0 0 {name=p119718 lab=_71959_/A }
C {devices/lab_pin.sym} 120420 -12810 0 1 {name=p119719 lab=_57619_/B }
C {sky130_stdcells/buf_2.sym} 120380 -12810 0 0 {name=X_57571_ }
C {devices/lab_pin.sym} 120300 -12710 0 0 {name=p119720 lab=_69554_/X }
C {devices/lab_pin.sym} 120300 -12670 0 0 {name=p119721 lab=_69556_/X }
C {devices/lab_pin.sym} 120300 -12630 0 0 {name=p119722 lab=_64629_/A }
C {devices/lab_pin.sym} 120460 -12670 0 1 {name=p119723 lab=_69557_/X }
C {sky130_stdcells/a21o_4.sym} 120380 -12670 0 0 {name=X_69557_ }
C {devices/lab_pin.sym} 120290 -12530 0 0 {name=p119724 lab=_82220_/CLK }
C {devices/lab_pin.sym} 120290 -12510 0 0 {name=p119725 lab=_81867_/Q }
C {devices/lab_pin.sym} 120470 -12530 0 1 {name=p119726 lab=_77353_/A }
C {sky130_stdcells/dfxtp_4.sym} 120380 -12520 0 0 {name=X_81835_ }
C {devices/lab_pin.sym} 120290 -12390 0 0 {name=p119727 lab=_88394_/CLK }
C {devices/lab_pin.sym} 120290 -12370 0 0 {name=p119728 lab=_40442_/Y }
C {devices/lab_pin.sym} 120470 -12390 0 1 {name=p119729 lab=_88391_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -12380 0 0 {name=X_88391_ }
C {devices/lab_pin.sym} 120340 -12250 0 0 {name=p119730 lab=_54034_/A }
C {devices/lab_pin.sym} 120420 -12250 0 1 {name=p119731 lab=_54892_/A }
C {sky130_stdcells/buf_2.sym} 120380 -12250 0 0 {name=X_54783_ }
C {devices/lab_pin.sym} 120320 -12140 0 0 {name=p119732 lab=_66769_/A }
C {devices/lab_pin.sym} 120320 -12100 0 0 {name=p119733 lab=_88203_/Q }
C {devices/lab_pin.sym} 120440 -12120 0 1 {name=p119734 lab=_66769_/X }
C {sky130_stdcells/and2_4.sym} 120380 -12120 0 0 {name=X_66769_ }
C {devices/lab_pin.sym} 120340 -11990 0 0 {name=p119735 lab=_52322_/A }
C {devices/lab_pin.sym} 120420 -11990 0 1 {name=p119736 lab=_52185_/A }
C {sky130_stdcells/buf_2.sym} 120380 -11990 0 0 {name=X_51995_ }
C {devices/lab_pin.sym} 120300 -11890 0 0 {name=p119737 lab=_59260_/X }
C {devices/lab_pin.sym} 120300 -11850 0 0 {name=p119738 lab=_85416_/Q }
C {devices/lab_pin.sym} 120300 -11810 0 0 {name=p119739 lab=_59309_/X }
C {devices/lab_pin.sym} 120460 -11850 0 1 {name=p119740 lab=_59310_/Y }
C {sky130_stdcells/o21ai_4.sym} 120380 -11850 0 0 {name=X_59310_ }
C {devices/lab_pin.sym} 120340 -11710 0 0 {name=p119741 lab=_46187_/A }
C {devices/lab_pin.sym} 120420 -11710 0 1 {name=p119742 lab=_56533_/B }
C {sky130_stdcells/buf_2.sym} 120380 -11710 0 0 {name=X_56522_ }
C {devices/lab_pin.sym} 120340 -11590 0 0 {name=p119743 lab=_46210_/A }
C {devices/lab_pin.sym} 120420 -11590 0 1 {name=p119744 lab=_68993_/A }
C {sky130_stdcells/buf_2.sym} 120380 -11590 0 0 {name=X_68508_ }
C {devices/lab_pin.sym} 120290 -11470 0 0 {name=p119745 lab=_86988_/CLK }
C {devices/lab_pin.sym} 120290 -11450 0 0 {name=p119746 lab=_43616_/Y }
C {devices/lab_pin.sym} 120470 -11470 0 1 {name=p119747 lab=_43614_/A }
C {sky130_stdcells/dfxtp_4.sym} 120380 -11460 0 0 {name=X_87342_ }
C {devices/lab_pin.sym} 120320 -11350 0 0 {name=p119748 lab=_50511_/A }
C {devices/lab_pin.sym} 120320 -11310 0 0 {name=p119749 lab=_53748_/B }
C {devices/lab_pin.sym} 120320 -11270 0 0 {name=p119750 lab=_53734_/C }
C {devices/lab_pin.sym} 120440 -11310 0 1 {name=p119751 lab=_53734_/X }
C {sky130_stdcells/and3_4.sym} 120380 -11310 0 0 {name=X_53734_ }
C {devices/lab_pin.sym} 120290 -11170 0 0 {name=p119752 lab=_84375_/CLK }
C {devices/lab_pin.sym} 120290 -11150 0 0 {name=p119753 lab=_84554_/D }
C {devices/lab_pin.sym} 120470 -11170 0 1 {name=p119754 lab=_78049_/A }
C {sky130_stdcells/dfxtp_4.sym} 120380 -11160 0 0 {name=X_84554_ }
C {devices/lab_pin.sym} 120340 -11030 0 0 {name=p119755 lab=_50946_/A }
C {devices/lab_pin.sym} 120420 -11030 0 1 {name=p119756 lab=_50973_/A }
C {sky130_stdcells/buf_2.sym} 120380 -11030 0 0 {name=X_50946_ }
C {devices/lab_pin.sym} 120290 -10910 0 0 {name=p119757 lab=_82642_/CLK }
C {devices/lab_pin.sym} 120290 -10890 0 0 {name=p119758 lab=_76003_/X }
C {devices/lab_pin.sym} 120470 -10910 0 1 {name=p119759 lab=_81766_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -10900 0 0 {name=X_81766_ }
C {devices/lab_pin.sym} 120300 -10790 0 0 {name=p119760 lab=_69484_/X }
C {devices/lab_pin.sym} 120300 -10750 0 0 {name=p119761 lab=_69487_/X }
C {devices/lab_pin.sym} 120300 -10710 0 0 {name=p119762 lab=_69389_/X }
C {devices/lab_pin.sym} 120460 -10750 0 1 {name=p119763 lab=_69488_/Y }
C {sky130_stdcells/a21oi_4.sym} 120380 -10750 0 0 {name=X_69488_ }
C {devices/lab_pin.sym} 120340 -10610 0 0 {name=p119764 lab=_58868_/A }
C {devices/lab_pin.sym} 120420 -10610 0 1 {name=p119765 lab=_59241_/X }
C {sky130_stdcells/buf_2.sym} 120380 -10610 0 0 {name=X_59241_ }
C {devices/lab_pin.sym} 120290 -10490 0 0 {name=p119766 lab=_84223_/CLK }
C {devices/lab_pin.sym} 120290 -10470 0 0 {name=p119767 lab=_83505_/D }
C {devices/lab_pin.sym} 120470 -10490 0 1 {name=p119768 lab=_83505_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -10480 0 0 {name=X_83505_ }
C {devices/lab_pin.sym} 120300 -10370 0 0 {name=p119769 lab=_56164_/X }
C {devices/lab_pin.sym} 120300 -10330 0 0 {name=p119770 lab=_56372_/X }
C {devices/lab_pin.sym} 120300 -10290 0 0 {name=p119771 lab=_56452_/Y }
C {devices/lab_pin.sym} 120460 -10330 0 1 {name=p119772 lab=_56453_/Y }
C {sky130_stdcells/o21ai_4.sym} 120380 -10330 0 0 {name=X_56453_ }
C {devices/lab_pin.sym} 120290 -10190 0 0 {name=p119773 lab=_81084_/CLK }
C {devices/lab_pin.sym} 120290 -10170 0 0 {name=p119774 lab=_75903_/X }
C {devices/lab_pin.sym} 120470 -10190 0 1 {name=p119775 lab=_80685_/D }
C {sky130_stdcells/dfxtp_4.sym} 120380 -10180 0 0 {name=X_80717_ }
C {devices/lab_pin.sym} 120340 -10050 0 0 {name=p119776 lab=_69088_/A }
C {devices/lab_pin.sym} 120420 -10050 0 1 {name=p119777 lab=_68439_/X }
C {sky130_stdcells/buf_2.sym} 120380 -10050 0 0 {name=X_68439_ }
C {devices/lab_pin.sym} 120290 -9930 0 0 {name=p119778 lab=_87273_/CLK }
C {devices/lab_pin.sym} 120290 -9910 0 0 {name=p119779 lab=_43773_/X }
C {devices/lab_pin.sym} 120470 -9930 0 1 {name=p119780 lab=_69274_/B }
C {sky130_stdcells/dfxtp_4.sym} 120380 -9920 0 0 {name=X_87273_ }
C {devices/lab_pin.sym} 120340 -9790 0 0 {name=p119781 lab=_50460_/A }
C {devices/lab_pin.sym} 120420 -9790 0 1 {name=p119782 lab=_53733_/A }
C {sky130_stdcells/buf_2.sym} 120380 -9790 0 0 {name=X_53665_ }
C {devices/lab_pin.sym} 120290 -9670 0 0 {name=p119783 lab=_82272_/CLK }
C {devices/lab_pin.sym} 120290 -9650 0 0 {name=p119784 lab=_61385_/Y }
C {devices/lab_pin.sym} 120470 -9670 0 1 {name=p119785 lab=_79153_/B }
C {sky130_stdcells/dfxtp_4.sym} 120380 -9660 0 0 {name=X_84485_ }
C {devices/lab_pin.sym} 120300 -9550 0 0 {name=p119786 lab=_50875_/Y }
C {devices/lab_pin.sym} 120300 -9510 0 0 {name=p119787 lab=_50243_/X }
C {devices/lab_pin.sym} 120300 -9470 0 0 {name=p119788 lab=_50876_/Y }
C {devices/lab_pin.sym} 120460 -9510 0 1 {name=p119789 lab=_50877_/Y }
C {sky130_stdcells/a21boi_4.sym} 120380 -9510 0 0 {name=X_50877_ }
C {devices/lab_pin.sym} 120290 -9370 0 0 {name=p119790 lab=_81697_/CLK }
C {devices/lab_pin.sym} 120290 -9350 0 0 {name=p119791 lab=_80261_/Y }
C {devices/lab_pin.sym} 120470 -9370 0 1 {name=p119792 lab=_81697_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -9360 0 0 {name=X_81697_ }
C {devices/lab_pin.sym} 120320 -9240 0 0 {name=p119793 lab=_55188_/X }
C {devices/lab_pin.sym} 120320 -9200 0 0 {name=p119794 lab=_55193_/X }
C {devices/lab_pin.sym} 120440 -9220 0 1 {name=p119795 lab=_55405_/A }
C {sky130_stdcells/and2_4.sym} 120380 -9220 0 0 {name=X_55404_ }
C {devices/lab_pin.sym} 120290 -9090 0 0 {name=p119796 lab=_83544_/CLK }
C {devices/lab_pin.sym} 120290 -9070 0 0 {name=p119797 lab=_86224_/D }
C {devices/lab_pin.sym} 120470 -9090 0 1 {name=p119798 lab=_86224_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -9080 0 0 {name=X_86224_ }
C {devices/lab_pin.sym} 120340 -8950 0 0 {name=p119799 lab=_48631_/A }
C {devices/lab_pin.sym} 120420 -8950 0 1 {name=p119800 lab=_40817_/A }
C {sky130_stdcells/buf_2.sym} 120380 -8950 0 0 {name=X_40630_ }
C {devices/lab_pin.sym} 120320 -8840 0 0 {name=p119801 lab=_52624_/A }
C {devices/lab_pin.sym} 120320 -8800 0 0 {name=p119802 lab=_54309_/B }
C {devices/lab_pin.sym} 120440 -8820 0 1 {name=p119803 lab=_52616_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -8820 0 0 {name=X_52616_ }
C {devices/lab_pin.sym} 120320 -8700 0 0 {name=p119804 lab=_59117_/A }
C {devices/lab_pin.sym} 120320 -8660 0 0 {name=p119805 lab=_86355_/Q }
C {devices/lab_pin.sym} 120440 -8680 0 1 {name=p119806 lab=_59172_/Y }
C {sky130_stdcells/nor2_4.sym} 120380 -8680 0 0 {name=X_59172_ }
C {devices/lab_pin.sym} 120320 -8570 0 0 {name=p119807 lab=_70676_/A }
C {devices/lab_pin.sym} 120320 -8530 0 0 {name=p119808 lab=_71626_/C }
C {devices/lab_pin.sym} 120320 -8490 0 0 {name=p119809 lab=_71450_/C }
C {devices/lab_pin.sym} 120440 -8530 0 1 {name=p119810 lab=_71450_/Y }
C {sky130_stdcells/nor3_4.sym} 120380 -8530 0 0 {name=X_71450_ }
C {devices/lab_pin.sym} 120290 -8390 0 0 {name=p119811 lab=_83491_/CLK }
C {devices/lab_pin.sym} 120290 -8370 0 0 {name=p119812 lab=_83436_/D }
C {devices/lab_pin.sym} 120470 -8390 0 1 {name=p119813 lab=_83436_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -8380 0 0 {name=X_83436_ }
C {devices/lab_pin.sym} 120340 -8250 0 0 {name=p119814 lab=_44207_/A }
C {devices/lab_pin.sym} 120420 -8250 0 1 {name=p119815 lab=_56436_/A }
C {sky130_stdcells/buf_2.sym} 120380 -8250 0 0 {name=X_56384_ }
C {sky130_stdcells/decap_3.sym} 120380 -8100 0 0 {name=XPHY_202 }
C {devices/lab_pin.sym} 120340 -7940 0 0 {name=p119816 lab=_74793_/X }
C {devices/lab_pin.sym} 120340 -7900 0 0 {name=p119817 lab=_74712_/Y }
C {devices/lab_pin.sym} 120420 -7940 0 1 {name=p119818 lab=DATA_FROM_HASH[5] }
C {sky130_stdcells/ebufn_2.sym} 120380 -7940 0 0 {name=X_80648_ }
C {devices/lab_pin.sym} 120300 -7830 0 0 {name=p119819 lab=_53594_/Y }
C {devices/lab_pin.sym} 120300 -7790 0 0 {name=p119820 lab=_53574_/X }
C {devices/lab_pin.sym} 120300 -7750 0 0 {name=p119821 lab=_53595_/Y }
C {devices/lab_pin.sym} 120460 -7790 0 1 {name=p119822 lab=_85606_/D }
C {sky130_stdcells/a21boi_4.sym} 120380 -7790 0 0 {name=X_53596_ }
C {sky130_stdcells/decap_3.sym} 120380 -7620 0 0 {name=XPHY_213 }
C {sky130_stdcells/decap_3.sym} 120380 -7440 0 0 {name=XPHY_224 }
C {devices/lab_pin.sym} 120340 -7290 0 0 {name=p119823 lab=_65034_/A }
C {devices/lab_pin.sym} 120420 -7290 0 1 {name=p119824 lab=_58124_/A }
C {sky130_stdcells/buf_2.sym} 120380 -7290 0 0 {name=X_58123_ }
C {devices/lab_pin.sym} 120340 -7170 0 0 {name=p119825 lab=_71005_/A }
C {devices/lab_pin.sym} 120420 -7170 0 1 {name=p119826 lab=_74531_/A }
C {sky130_stdcells/buf_2.sym} 120380 -7170 0 0 {name=X_70401_ }
C {sky130_stdcells/decap_3.sym} 120380 -7020 0 0 {name=XPHY_235 }
C {devices/lab_pin.sym} 120300 -6900 0 0 {name=p119827 lab=_56989_/B }
C {devices/lab_pin.sym} 120300 -6860 0 0 {name=p119828 lab=_44060_/X }
C {devices/lab_pin.sym} 120300 -6820 0 0 {name=p119829 lab=_44046_/X }
C {devices/lab_pin.sym} 120300 -6780 0 0 {name=p119830 lab=_55334_/Y }
C {devices/lab_pin.sym} 120460 -6840 0 1 {name=p119831 lab=_55335_/X }
C {sky130_stdcells/a211o_4.sym} 120380 -6840 0 0 {name=X_55335_ }
C {devices/lab_pin.sym} 120290 -6690 0 0 {name=p119832 lab=_86155_/CLK }
C {devices/lab_pin.sym} 120290 -6670 0 0 {name=p119833 lab=_86155_/D }
C {devices/lab_pin.sym} 120470 -6690 0 1 {name=p119834 lab=_86155_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -6680 0 0 {name=X_86155_ }
C {devices/lab_pin.sym} 120340 -6550 0 0 {name=p119835 lab=_42447_/C }
C {devices/lab_pin.sym} 120420 -6550 0 1 {name=p119836 lab=_41869_/B }
C {sky130_stdcells/inv_2.sym} 120380 -6550 0 0 {name=X_40561_ }
C {sky130_stdcells/decap_3.sym} 120380 -6400 0 0 {name=XPHY_246 }
C {devices/lab_pin.sym} 120320 -6260 0 0 {name=p119837 lab=_52542_/X }
C {devices/lab_pin.sym} 120320 -6220 0 0 {name=p119838 lab=_50854_/B }
C {devices/lab_pin.sym} 120440 -6240 0 1 {name=p119839 lab=_52547_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -6240 0 0 {name=X_52547_ }
C {devices/lab_pin.sym} 120290 -6110 0 0 {name=p119840 lab=_83367_/CLK }
C {devices/lab_pin.sym} 120290 -6090 0 0 {name=p119841 lab=_83367_/D }
C {devices/lab_pin.sym} 120470 -6110 0 1 {name=p119842 lab=_83367_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -6100 0 0 {name=X_83367_ }
C {devices/lab_pin.sym} 120320 -5990 0 0 {name=p119843 lab=_70676_/A }
C {devices/lab_pin.sym} 120320 -5950 0 0 {name=p119844 lab=_71377_/B }
C {devices/lab_pin.sym} 120320 -5910 0 0 {name=p119845 lab=_71377_/C }
C {devices/lab_pin.sym} 120440 -5950 0 1 {name=p119846 lab=_71381_/Y }
C {sky130_stdcells/nor3_4.sym} 120380 -5950 0 0 {name=X_71381_ }
C {sky130_stdcells/decap_3.sym} 120380 -5780 0 0 {name=XPHY_257 }
C {devices/lab_pin.sym} 120320 -5640 0 0 {name=p119847 lab=_80579_/A }
C {devices/lab_pin.sym} 120320 -5600 0 0 {name=p119848 lab=_80579_/B }
C {devices/lab_pin.sym} 120440 -5620 0 1 {name=p119849 lab=_80580_/B }
C {sky130_stdcells/xor2_4.sym} 120380 -5620 0 0 {name=X_80579_ }
C {sky130_stdcells/decap_3.sym} 120380 -5460 0 0 {name=XPHY_268 }
C {devices/lab_pin.sym} 120340 -5310 0 0 {name=p119850 lab=_42300_/A }
C {devices/lab_pin.sym} 120420 -5310 0 1 {name=p119851 lab=_42300_/Y }
C {sky130_stdcells/inv_2.sym} 120380 -5310 0 0 {name=X_42300_ }
C {devices/lab_pin.sym} 120320 -5200 0 0 {name=p119852 lab=_74428_/B }
C {devices/lab_pin.sym} 120320 -5160 0 0 {name=p119853 lab=_73120_/B }
C {devices/lab_pin.sym} 120440 -5180 0 1 {name=p119854 lab=_73120_/X }
C {sky130_stdcells/xor2_4.sym} 120380 -5180 0 0 {name=X_73120_ }
C {devices/lab_pin.sym} 120290 -5050 0 0 {name=p119855 lab=_85074_/CLK }
C {devices/lab_pin.sym} 120290 -5030 0 0 {name=p119856 lab=_85106_/D }
C {devices/lab_pin.sym} 120470 -5050 0 1 {name=p119857 lab=_85106_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -5040 0 0 {name=X_85106_ }
C {sky130_stdcells/decap_3.sym} 120380 -4880 0 0 {name=XPHY_279 }
C {devices/lab_pin.sym} 120320 -4740 0 0 {name=p119858 lab=_57991_/A }
C {devices/lab_pin.sym} 120320 -4700 0 0 {name=p119859 lab=_86313_/Q }
C {devices/lab_pin.sym} 120440 -4720 0 1 {name=p119860 lab=_58054_/Y }
C {sky130_stdcells/nor2_4.sym} 120380 -4720 0 0 {name=X_58054_ }
C {devices/lab_pin.sym} 120340 -4590 0 0 {name=p119861 lab=_70134_/X }
C {devices/lab_pin.sym} 120420 -4590 0 1 {name=p119862 lab=_70332_/X }
C {sky130_stdcells/buf_2.sym} 120380 -4590 0 0 {name=X_70332_ }
C {devices/lab_pin.sym} 120290 -4470 0 0 {name=p119863 lab=_82284_/CLK }
C {devices/lab_pin.sym} 120290 -4450 0 0 {name=p119864 lab=_77089_/B }
C {devices/lab_pin.sym} 120470 -4470 0 1 {name=p119865 lab=_82318_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -4460 0 0 {name=X_82318_ }
C {devices/lab_pin.sym} 120300 -4370 0 0 {name=p119866 lab=_43260_/X }
C {devices/lab_pin.sym} 120300 -4330 0 0 {name=p119867 lab=_43269_/X }
C {devices/lab_pin.sym} 120300 -4290 0 0 {name=p119868 lab=_41139_/X }
C {devices/lab_pin.sym} 120300 -4250 0 0 {name=p119869 lab=_87502_/Q }
C {devices/lab_pin.sym} 120300 -4210 0 0 {name=p119870 lab=_43273_/X }
C {devices/lab_pin.sym} 120460 -4290 0 1 {name=p119871 lab=_43280_/Y }
C {sky130_stdcells/o32ai_4.sym} 120380 -4290 0 0 {name=X_43280_ }
C {devices/lab_pin.sym} 120340 -4130 0 0 {name=p119872 lab=_55265_/Y }
C {devices/lab_pin.sym} 120420 -4130 0 1 {name=p119873 lab=_55288_/C }
C {sky130_stdcells/inv_2.sym} 120380 -4130 0 0 {name=X_55266_ }
C {devices/lab_pin.sym} 120290 -4010 0 0 {name=p119874 lab=_85767_/CLK }
C {devices/lab_pin.sym} 120290 -3990 0 0 {name=p119875 lab=_86086_/D }
C {devices/lab_pin.sym} 120470 -4010 0 1 {name=p119876 lab=_86086_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -4000 0 0 {name=X_86086_ }
C {devices/lab_pin.sym} 120340 -3870 0 0 {name=p119877 lab=_44736_/A }
C {devices/lab_pin.sym} 120420 -3870 0 1 {name=p119878 lab=_40492_/X }
C {sky130_stdcells/buf_2.sym} 120380 -3870 0 0 {name=X_40492_ }
C {devices/lab_pin.sym} 120320 -3760 0 0 {name=p119879 lab=_52468_/A }
C {devices/lab_pin.sym} 120320 -3720 0 0 {name=p119880 lab=_52478_/B }
C {devices/lab_pin.sym} 120440 -3740 0 1 {name=p119881 lab=_52478_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -3740 0 0 {name=X_52478_ }
C {devices/lab_pin.sym} 120290 -3610 0 0 {name=p119882 lab=_85554_/CLK }
C {devices/lab_pin.sym} 120290 -3590 0 0 {name=p119883 lab=_72035_/Y }
C {devices/lab_pin.sym} 120470 -3610 0 1 {name=p119884 lab=_83298_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -3600 0 0 {name=X_83298_ }
C {devices/lab_pin.sym} 120300 -3490 0 0 {name=p119885 lab=_57427_/A }
C {devices/lab_pin.sym} 120300 -3450 0 0 {name=p119886 lab=_56750_/Y }
C {devices/lab_pin.sym} 120300 -3410 0 0 {name=p119887 lab=_56982_/X }
C {devices/lab_pin.sym} 120460 -3450 0 1 {name=p119888 lab=_57005_/Y }
C {sky130_stdcells/a21oi_4.sym} 120380 -3450 0 0 {name=X_57005_ }
C {devices/lab_pin.sym} 120340 -3310 0 0 {name=p119889 lab=_42204_/X }
C {devices/lab_pin.sym} 120420 -3310 0 1 {name=p119890 lab=_42231_/X }
C {sky130_stdcells/buf_2.sym} 120380 -3310 0 0 {name=X_42231_ }
C {devices/lab_pin.sym} 120340 -3190 0 0 {name=p119891 lab=_54217_/A }
C {devices/lab_pin.sym} 120420 -3190 0 1 {name=p119892 lab=_54237_/B }
C {sky130_stdcells/buf_2.sym} 120380 -3190 0 0 {name=X_54217_ }
C {devices/lab_pin.sym} 120300 -3090 0 0 {name=p119893 lab=_83167_/Q }
C {devices/lab_pin.sym} 120300 -3050 0 0 {name=p119894 lab=_72943_/X }
C {devices/lab_pin.sym} 120300 -3010 0 0 {name=p119895 lab=_73050_/Y }
C {devices/lab_pin.sym} 120460 -3050 0 1 {name=p119896 lab=_83167_/D }
C {sky130_stdcells/a21o_4.sym} 120380 -3050 0 0 {name=X_73051_ }
C {devices/lab_pin.sym} 120290 -2910 0 0 {name=p119897 lab=_85037_/CLK }
C {devices/lab_pin.sym} 120290 -2890 0 0 {name=p119898 lab=_85037_/D }
C {devices/lab_pin.sym} 120470 -2910 0 1 {name=p119899 lab=_85037_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -2900 0 0 {name=X_85037_ }
C {devices/lab_pin.sym} 120340 -2770 0 0 {name=p119900 lab=_51539_/A }
C {devices/lab_pin.sym} 120420 -2770 0 1 {name=p119901 lab=_51429_/X }
C {sky130_stdcells/buf_2.sym} 120380 -2770 0 0 {name=X_51429_ }
C {devices/lab_pin.sym} 120340 -2650 0 0 {name=p119902 lab=_70247_/X }
C {devices/lab_pin.sym} 120420 -2650 0 1 {name=p119903 lab=_70267_/B }
C {sky130_stdcells/buf_2.sym} 120380 -2650 0 0 {name=X_70263_ }
C {devices/lab_pin.sym} 120290 -2530 0 0 {name=p119904 lab=_82820_/CLK }
C {devices/lab_pin.sym} 120290 -2510 0 0 {name=p119905 lab=_80375_/X }
C {devices/lab_pin.sym} 120470 -2530 0 1 {name=p119906 lab=_82249_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -2520 0 0 {name=X_82249_ }
C {devices/lab_pin.sym} 120320 -2410 0 0 {name=p119907 lab=_55164_/X }
C {devices/lab_pin.sym} 120320 -2370 0 0 {name=p119908 lab=_55298_/A }
C {devices/lab_pin.sym} 120320 -2330 0 0 {name=p119909 lab=_55400_/A }
C {devices/lab_pin.sym} 120440 -2370 0 1 {name=p119910 lab=_55201_/A }
C {sky130_stdcells/nand3_4.sym} 120380 -2370 0 0 {name=X_55197_ }
C {devices/lab_pin.sym} 120340 -2230 0 0 {name=p119911 lab=_57563_/X }
C {devices/lab_pin.sym} 120420 -2230 0 1 {name=p119912 lab=_72040_/A }
C {sky130_stdcells/buf_2.sym} 120380 -2230 0 0 {name=X_72002_ }
C {devices/lab_pin.sym} 120340 -2110 0 0 {name=p119913 lab=_42162_/A }
C {devices/lab_pin.sym} 120420 -2110 0 1 {name=p119914 lab=_42162_/X }
C {sky130_stdcells/buf_2.sym} 120380 -2110 0 0 {name=X_42162_ }
C {devices/lab_pin.sym} 120300 -2010 0 0 {name=p119915 lab=_54143_/Y }
C {devices/lab_pin.sym} 120300 -1970 0 0 {name=p119916 lab=_54144_/X }
C {devices/lab_pin.sym} 120300 -1930 0 0 {name=p119917 lab=_54147_/X }
C {devices/lab_pin.sym} 120460 -1970 0 1 {name=p119918 lab=_85496_/D }
C {sky130_stdcells/a21oi_4.sym} 120380 -1970 0 0 {name=X_54148_ }
C {devices/lab_pin.sym} 120300 -1850 0 0 {name=p119919 lab=_70192_/Y }
C {devices/lab_pin.sym} 120300 -1810 0 0 {name=p119920 lab=_70157_/X }
C {devices/lab_pin.sym} 120300 -1770 0 0 {name=p119921 lab=_70193_/Y }
C {devices/lab_pin.sym} 120460 -1810 0 1 {name=p119922 lab=_83842_/D }
C {sky130_stdcells/o21ai_4.sym} 120380 -1810 0 0 {name=X_70194_ }
C {devices/lab_pin.sym} 120340 -1670 0 0 {name=p119923 lab=_40946_/A }
C {devices/lab_pin.sym} 120420 -1670 0 1 {name=p119924 lab=_41113_/X }
C {sky130_stdcells/buf_2.sym} 120380 -1670 0 0 {name=X_41113_ }
C {devices/lab_pin.sym} 120340 -1550 0 0 {name=p119925 lab=_76810_/A }
C {devices/lab_pin.sym} 120420 -1550 0 1 {name=p119926 lab=_76812_/A }
C {sky130_stdcells/inv_2.sym} 120380 -1550 0 0 {name=X_76810_ }
C {devices/lab_pin.sym} 120300 -1450 0 0 {name=p119927 lab=_59057_/A }
C {devices/lab_pin.sym} 120300 -1410 0 0 {name=p119928 lab=_46955_/X }
C {devices/lab_pin.sym} 120300 -1370 0 0 {name=p119929 lab=_46969_/Y }
C {devices/lab_pin.sym} 120460 -1410 0 1 {name=p119930 lab=_46970_/Y }
C {sky130_stdcells/o21ai_4.sym} 120380 -1410 0 0 {name=X_46970_ }
C {devices/lab_pin.sym} 120340 -1270 0 0 {name=p119931 lab=_58599_/A }
C {devices/lab_pin.sym} 120420 -1270 0 1 {name=p119932 lab=_58956_/X }
C {sky130_stdcells/buf_2.sym} 120380 -1270 0 0 {name=X_58956_ }
C {devices/lab_pin.sym} 120320 -1160 0 0 {name=p119933 lab=_53801_/B }
C {devices/lab_pin.sym} 120320 -1120 0 0 {name=p119934 lab=_54079_/B }
C {devices/lab_pin.sym} 120440 -1140 0 1 {name=p119935 lab=_54079_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -1140 0 0 {name=X_54079_ }
C {devices/lab_pin.sym} 120340 -1010 0 0 {name=p119936 lab=_42093_/A }
C {devices/lab_pin.sym} 120420 -1010 0 1 {name=p119937 lab=_42093_/Y }
C {sky130_stdcells/inv_2.sym} 120380 -1010 0 0 {name=X_42093_ }
C {devices/lab_pin.sym} 120300 -910 0 0 {name=p119938 lab=_77796_/A }
C {devices/lab_pin.sym} 120300 -870 0 0 {name=p119939 lab=_77783_/Y }
C {devices/lab_pin.sym} 120300 -830 0 0 {name=p119940 lab=_77789_/Y }
C {devices/lab_pin.sym} 120460 -870 0 1 {name=p119941 lab=_77791_/B }
C {sky130_stdcells/o21ai_4.sym} 120380 -870 0 0 {name=X_77790_ }
C {devices/lab_pin.sym} 120290 -730 0 0 {name=p119942 lab=_86988_/CLK }
C {devices/lab_pin.sym} 120290 -710 0 0 {name=p119943 lab=_86988_/D }
C {devices/lab_pin.sym} 120470 -730 0 1 {name=p119944 lab=_44719_/A }
C {sky130_stdcells/dfxtp_4.sym} 120380 -720 0 0 {name=X_86988_ }
C {devices/lab_pin.sym} 121220 -42170 0 0 {name=p119945 lab=_57838_/X }
C {devices/lab_pin.sym} 121220 -42130 0 0 {name=p119946 lab=_86005_/Q }
C {devices/lab_pin.sym} 121220 -42090 0 0 {name=p119947 lab=_57906_/X }
C {devices/lab_pin.sym} 121380 -42130 0 1 {name=p119948 lab=_57907_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -42130 0 0 {name=X_57907_ }
C {devices/lab_pin.sym} 121260 -41990 0 0 {name=p119949 lab=_64565_/A }
C {devices/lab_pin.sym} 121340 -41990 0 1 {name=p119950 lab=_64902_/A }
C {sky130_stdcells/buf_2.sym} 121300 -41990 0 0 {name=X_45921_ }
C {devices/lab_pin.sym} 121220 -41890 0 0 {name=p119951 lab=_41042_/X }
C {devices/lab_pin.sym} 121220 -41850 0 0 {name=p119952 lab=_82286_/Q }
C {devices/lab_pin.sym} 121220 -41810 0 0 {name=p119953 lab=_41043_/X }
C {devices/lab_pin.sym} 121380 -41850 0 1 {name=p119954 lab=_41045_/A }
C {sky130_stdcells/o21a_4.sym} 121300 -41850 0 0 {name=X_41044_ }
C {devices/lab_pin.sym} 121220 -41740 0 0 {name=p119955 lab=_76727_/Y }
C {devices/lab_pin.sym} 121220 -41700 0 0 {name=p119956 lab=_76728_/Y }
C {devices/lab_pin.sym} 121220 -41660 0 0 {name=p119957 lab=_76714_/A }
C {devices/lab_pin.sym} 121220 -41620 0 0 {name=p119958 lab=_81354_/D }
C {devices/lab_pin.sym} 121380 -41680 0 1 {name=p119959 lab=_76741_/X }
C {sky130_stdcells/a2bb2o_4.sym} 121300 -41680 0 0 {name=X_76741_ }
C {devices/lab_pin.sym} 121220 -41550 0 0 {name=p119960 lab=_73950_/X }
C {devices/lab_pin.sym} 121220 -41510 0 0 {name=p119961 lab=_73952_/X }
C {devices/lab_pin.sym} 121220 -41470 0 0 {name=p119962 lab=_73857_/X }
C {devices/lab_pin.sym} 121380 -41510 0 1 {name=p119963 lab=_73956_/A }
C {sky130_stdcells/a21o_4.sym} 121300 -41510 0 0 {name=X_73953_ }
C {devices/lab_pin.sym} 121210 -41370 0 0 {name=p119964 lab=_86100_/CLK }
C {devices/lab_pin.sym} 121210 -41350 0 0 {name=p119965 lab=_85939_/D }
C {devices/lab_pin.sym} 121390 -41370 0 1 {name=p119966 lab=_85939_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -41360 0 0 {name=X_85939_ }
C {devices/lab_pin.sym} 121240 -41240 0 0 {name=p119967 lab=_58887_/A }
C {devices/lab_pin.sym} 121240 -41200 0 0 {name=p119968 lab=_58873_/B }
C {devices/lab_pin.sym} 121360 -41220 0 1 {name=p119969 lab=_58887_/Y }
C {sky130_stdcells/nor2_4.sym} 121300 -41220 0 0 {name=X_58887_ }
C {devices/lab_pin.sym} 121240 -41100 0 0 {name=p119970 lab=_48661_/A }
C {devices/lab_pin.sym} 121240 -41060 0 0 {name=p119971 lab=_48843_/B }
C {devices/lab_pin.sym} 121360 -41080 0 1 {name=p119972 lab=_48640_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -41080 0 0 {name=X_48640_ }
C {devices/lab_pin.sym} 121240 -40960 0 0 {name=p119973 lab=_72898_/X }
C {devices/lab_pin.sym} 121240 -40920 0 0 {name=p119974 lab=_72904_/B }
C {devices/lab_pin.sym} 121360 -40940 0 1 {name=p119975 lab=_72904_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -40940 0 0 {name=X_72904_ }
C {devices/lab_pin.sym} 121220 -40840 0 0 {name=p119976 lab=_79438_/A }
C {devices/lab_pin.sym} 121220 -40800 0 0 {name=p119977 lab=_79438_/B }
C {devices/lab_pin.sym} 121220 -40760 0 0 {name=p119978 lab=_79449_/A }
C {devices/lab_pin.sym} 121220 -40720 0 0 {name=p119979 lab=_79448_/Y }
C {devices/lab_pin.sym} 121380 -40780 0 1 {name=p119980 lab=_79460_/X }
C {sky130_stdcells/o22a_4.sym} 121300 -40780 0 0 {name=X_79460_ }
C {devices/lab_pin.sym} 121220 -40650 0 0 {name=p119981 lab=_45845_/X }
C {devices/lab_pin.sym} 121220 -40610 0 0 {name=p119982 lab=_45849_/Y }
C {devices/lab_pin.sym} 121220 -40570 0 0 {name=p119983 lab=_45851_/Y }
C {devices/lab_pin.sym} 121380 -40610 0 1 {name=p119984 lab=_45852_/Y }
C {sky130_stdcells/a21oi_4.sym} 121300 -40610 0 0 {name=X_45852_ }
C {devices/lab_pin.sym} 121260 -40470 0 0 {name=p119985 lab=_58618_/A }
C {devices/lab_pin.sym} 121340 -40470 0 1 {name=p119986 lab=_57838_/X }
C {sky130_stdcells/buf_2.sym} 121300 -40470 0 0 {name=X_57838_ }
C {devices/lab_pin.sym} 121240 -40370 0 0 {name=p119987 lab=_76668_/X }
C {devices/lab_pin.sym} 121240 -40330 0 0 {name=p119988 lab=_76672_/B }
C {devices/lab_pin.sym} 121240 -40290 0 0 {name=p119989 lab=_76669_/Y }
C {devices/lab_pin.sym} 121360 -40330 0 1 {name=p119990 lab=_76672_/Y }
C {sky130_stdcells/nand3_4.sym} 121300 -40330 0 0 {name=X_76672_ }
C {devices/lab_pin.sym} 121220 -40220 0 0 {name=p119991 lab=_73786_/X }
C {devices/lab_pin.sym} 121220 -40180 0 0 {name=p119992 lab=_84980_/Q }
C {devices/lab_pin.sym} 121220 -40140 0 0 {name=p119993 lab=_73859_/X }
C {devices/lab_pin.sym} 121220 -40100 0 0 {name=p119994 lab=_73883_/X }
C {devices/lab_pin.sym} 121380 -40160 0 1 {name=p119995 lab=_73884_/X }
C {sky130_stdcells/a211o_4.sym} 121300 -40160 0 0 {name=X_73884_ }
C {devices/lab_pin.sym} 121240 -40030 0 0 {name=p119996 lab=_78411_/A }
C {devices/lab_pin.sym} 121240 -39990 0 0 {name=p119997 lab=_78411_/B }
C {devices/lab_pin.sym} 121240 -39950 0 0 {name=p119998 lab=_78409_/Y }
C {devices/lab_pin.sym} 121360 -39990 0 1 {name=p119999 lab=_78412_/A }
C {sky130_stdcells/nand3_4.sym} 121300 -39990 0 0 {name=X_78411_ }
C {devices/lab_pin.sym} 121260 -39850 0 0 {name=p120000 lab=_44803_/A }
C {devices/lab_pin.sym} 121340 -39850 0 1 {name=p120001 lab=_46258_/A }
C {sky130_stdcells/buf_2.sym} 121300 -39850 0 0 {name=X_44803_ }
C {devices/lab_pin.sym} 121240 -39740 0 0 {name=p120002 lab=_80775_/D }
C {devices/lab_pin.sym} 121240 -39700 0 0 {name=p120003 lab=_75621_/A }
C {devices/lab_pin.sym} 121360 -39720 0 1 {name=p120004 lab=_75623_/X }
C {sky130_stdcells/and2_4.sym} 121300 -39720 0 0 {name=X_75623_ }
C {devices/lab_pin.sym} 121210 -39590 0 0 {name=p120005 lab=_82899_/CLK }
C {devices/lab_pin.sym} 121210 -39570 0 0 {name=p120006 lab=_87609_/D }
C {devices/lab_pin.sym} 121390 -39590 0 1 {name=p120007 lab=_87609_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -39580 0 0 {name=X_87609_ }
C {devices/lab_pin.sym} 121260 -39450 0 0 {name=p120008 lab=_48571_/A }
C {devices/lab_pin.sym} 121340 -39450 0 1 {name=p120009 lab=_48572_/A }
C {sky130_stdcells/inv_2.sym} 121300 -39450 0 0 {name=X_48571_ }
C {devices/lab_pin.sym} 121220 -39350 0 0 {name=p120010 lab=_44522_/Y }
C {devices/lab_pin.sym} 121220 -39310 0 0 {name=p120011 lab=_72775_/X }
C {devices/lab_pin.sym} 121220 -39270 0 0 {name=p120012 lab=_72834_/Y }
C {devices/lab_pin.sym} 121380 -39310 0 1 {name=p120013 lab=_72835_/X }
C {sky130_stdcells/a21o_4.sym} 121300 -39310 0 0 {name=X_72835_ }
C {devices/lab_pin.sym} 121240 -39180 0 0 {name=p120014 lab=_79384_/X }
C {devices/lab_pin.sym} 121240 -39140 0 0 {name=p120015 lab=_79391_/B }
C {devices/lab_pin.sym} 121360 -39160 0 1 {name=p120016 lab=_79391_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -39160 0 0 {name=X_79391_ }
C {devices/lab_pin.sym} 121260 -39030 0 0 {name=p120017 lab=_64923_/A }
C {devices/lab_pin.sym} 121340 -39030 0 1 {name=p120018 lab=_57770_/A }
C {sky130_stdcells/buf_2.sym} 121300 -39030 0 0 {name=X_57769_ }
C {devices/lab_pin.sym} 121220 -38930 0 0 {name=p120019 lab=_57340_/B }
C {devices/lab_pin.sym} 121220 -38890 0 0 {name=p120020 lab=_44933_/X }
C {devices/lab_pin.sym} 121220 -38850 0 0 {name=p120021 lab=_45782_/X }
C {devices/lab_pin.sym} 121380 -38890 0 1 {name=p120022 lab=_45783_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -38890 0 0 {name=X_45783_ }
C {devices/lab_pin.sym} 121260 -38750 0 0 {name=p120023 lab=_42951_/A }
C {devices/lab_pin.sym} 121340 -38750 0 1 {name=p120024 lab=_42995_/X }
C {sky130_stdcells/buf_2.sym} 121300 -38750 0 0 {name=X_42995_ }
C {devices/lab_pin.sym} 121240 -38660 0 0 {name=p120025 lab=_47513_/A }
C {devices/lab_pin.sym} 121240 -38620 0 0 {name=p120026 lab=_47549_/B }
C {devices/lab_pin.sym} 121240 -38580 0 0 {name=p120027 lab=_47519_/X }
C {devices/lab_pin.sym} 121240 -38540 0 0 {name=p120028 lab=_53099_/D }
C {devices/lab_pin.sym} 121360 -38600 0 1 {name=p120029 lab=_47522_/X }
C {sky130_stdcells/and4_4.sym} 121300 -38600 0 0 {name=X_47522_ }
C {devices/lab_pin.sym} 121260 -38450 0 0 {name=p120030 lab=_57689_/A }
C {devices/lab_pin.sym} 121340 -38450 0 1 {name=p120031 lab=_59508_/X }
C {sky130_stdcells/buf_2.sym} 121300 -38450 0 0 {name=X_59508_ }
C {devices/lab_pin.sym} 121240 -38340 0 0 {name=p120032 lab=_78344_/A }
C {devices/lab_pin.sym} 121240 -38300 0 0 {name=p120033 lab=_82661_/D }
C {devices/lab_pin.sym} 121360 -38320 0 1 {name=p120034 lab=_78342_/Y }
C {sky130_stdcells/nor2_4.sym} 121300 -38320 0 0 {name=X_78342_ }
C {devices/lab_pin.sym} 121260 -38190 0 0 {name=p120035 lab=_43047_/A }
C {devices/lab_pin.sym} 121340 -38190 0 1 {name=p120036 lab=_50731_/B }
C {sky130_stdcells/buf_2.sym} 121300 -38190 0 0 {name=X_44734_ }
C {devices/lab_pin.sym} 121240 -38080 0 0 {name=p120037 lab=_80704_/Q }
C {devices/lab_pin.sym} 121240 -38040 0 0 {name=p120038 lab=_75554_/B }
C {devices/lab_pin.sym} 121360 -38060 0 1 {name=p120039 lab=_75555_/A }
C {sky130_stdcells/nand2_4.sym} 121300 -38060 0 0 {name=X_75554_ }
C {devices/lab_pin.sym} 121260 -37930 0 0 {name=p120040 lab=_41945_/Y }
C {devices/lab_pin.sym} 121340 -37930 0 1 {name=p120041 lab=_41946_/Y }
C {sky130_stdcells/inv_2.sym} 121300 -37930 0 0 {name=X_41946_ }
C {devices/lab_pin.sym} 121260 -37810 0 0 {name=p120042 lab=_63371_/A }
C {devices/lab_pin.sym} 121340 -37810 0 1 {name=p120043 lab=_60780_/X }
C {sky130_stdcells/buf_2.sym} 121300 -37810 0 0 {name=X_60780_ }
C {devices/lab_pin.sym} 121260 -37690 0 0 {name=p120044 lab=_74140_/A }
C {devices/lab_pin.sym} 121340 -37690 0 1 {name=p120045 lab=_72766_/X }
C {sky130_stdcells/buf_2.sym} 121300 -37690 0 0 {name=X_72766_ }
C {devices/lab_pin.sym} 121240 -37590 0 0 {name=p120046 lab=_74505_/A }
C {devices/lab_pin.sym} 121240 -37550 0 0 {name=p120047 lab=_74509_/B }
C {devices/lab_pin.sym} 121240 -37510 0 0 {name=p120048 lab=_74501_/C }
C {devices/lab_pin.sym} 121360 -37550 0 1 {name=p120049 lab=_74505_/X }
C {sky130_stdcells/and3_4.sym} 121300 -37550 0 0 {name=X_74505_ }
C {devices/lab_pin.sym} 121220 -37430 0 0 {name=p120050 lab=_86633_/Q }
C {devices/lab_pin.sym} 121220 -37390 0 0 {name=p120051 lab=_47429_/X }
C {devices/lab_pin.sym} 121220 -37350 0 0 {name=p120052 lab=_47452_/Y }
C {devices/lab_pin.sym} 121380 -37390 0 1 {name=p120053 lab=_47453_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -37390 0 0 {name=X_47453_ }
C {devices/lab_pin.sym} 121220 -37270 0 0 {name=p120054 lab=_71712_/Y }
C {devices/lab_pin.sym} 121220 -37230 0 0 {name=p120055 lab=_83401_/Q }
C {devices/lab_pin.sym} 121220 -37190 0 0 {name=p120056 lab=_71716_/X }
C {devices/lab_pin.sym} 121380 -37230 0 1 {name=p120057 lab=_83401_/D }
C {sky130_stdcells/a21o_4.sym} 121300 -37230 0 0 {name=X_71717_ }
C {devices/lab_pin.sym} 121260 -37090 0 0 {name=p120058 lab=_84732_/Q }
C {devices/lab_pin.sym} 121340 -37090 0 1 {name=p120059 lab=_59439_/Y }
C {sky130_stdcells/inv_2.sym} 121300 -37090 0 0 {name=X_59439_ }
C {devices/lab_pin.sym} 121240 -36980 0 0 {name=p120060 lab=_78273_/A }
C {devices/lab_pin.sym} 121240 -36940 0 0 {name=p120061 lab=_78273_/B }
C {devices/lab_pin.sym} 121360 -36960 0 1 {name=p120062 lab=_78284_/B }
C {sky130_stdcells/nand2_4.sym} 121300 -36960 0 0 {name=X_78273_ }
C {devices/lab_pin.sym} 121260 -36830 0 0 {name=p120063 lab=_44618_/A }
C {devices/lab_pin.sym} 121340 -36830 0 1 {name=p120064 lab=_44665_/X }
C {sky130_stdcells/buf_2.sym} 121300 -36830 0 0 {name=X_44665_ }
C {devices/lab_pin.sym} 121220 -36730 0 0 {name=p120065 lab=_75465_/Y }
C {devices/lab_pin.sym} 121220 -36690 0 0 {name=p120066 lab=_75470_/Y }
C {devices/lab_pin.sym} 121220 -36650 0 0 {name=p120067 lab=_75507_/A }
C {devices/lab_pin.sym} 121380 -36690 0 1 {name=p120068 lab=_75485_/X }
C {sky130_stdcells/o21a_4.sym} 121300 -36690 0 0 {name=X_75485_ }
C {devices/lab_pin.sym} 121260 -36550 0 0 {name=p120069 lab=_41877_/A }
C {devices/lab_pin.sym} 121340 -36550 0 1 {name=p120070 lab=_41878_/A }
C {sky130_stdcells/buf_2.sym} 121300 -36550 0 0 {name=X_41877_ }
C {devices/lab_pin.sym} 121240 -36450 0 0 {name=p120071 lab=_72697_/A }
C {devices/lab_pin.sym} 121240 -36410 0 0 {name=p120072 lab=_72697_/B }
C {devices/lab_pin.sym} 121240 -36370 0 0 {name=p120073 lab=_56832_/X }
C {devices/lab_pin.sym} 121360 -36410 0 1 {name=p120074 lab=_72697_/Y }
C {sky130_stdcells/nand3_4.sym} 121300 -36410 0 0 {name=X_72697_ }
C {devices/lab_pin.sym} 121260 -36270 0 0 {name=p120075 lab=_46349_/A }
C {devices/lab_pin.sym} 121340 -36270 0 1 {name=p120076 lab=_46459_/B }
C {sky130_stdcells/buf_2.sym} 121300 -36270 0 0 {name=X_46404_ }
C {devices/lab_pin.sym} 121240 -36160 0 0 {name=p120077 lab=_82017_/Q }
C {devices/lab_pin.sym} 121240 -36120 0 0 {name=p120078 lab=_82305_/D }
C {devices/lab_pin.sym} 121360 -36140 0 1 {name=p120079 lab=_77227_/C }
C {sky130_stdcells/xnor2_4.sym} 121300 -36140 0 0 {name=X_77224_ }
C {devices/lab_pin.sym} 121260 -36010 0 0 {name=p120080 lab=_43616_/A }
C {devices/lab_pin.sym} 121340 -36010 0 1 {name=p120081 lab=_43616_/Y }
C {sky130_stdcells/inv_2.sym} 121300 -36010 0 0 {name=X_43616_ }
C {devices/lab_pin.sym} 121240 -35920 0 0 {name=p120082 lab=_61522_/X }
C {devices/lab_pin.sym} 121240 -35880 0 0 {name=p120083 lab=_62492_/B }
C {devices/lab_pin.sym} 121240 -35840 0 0 {name=p120084 lab=_62449_/X }
C {devices/lab_pin.sym} 121240 -35800 0 0 {name=p120085 lab=_62404_/X }
C {devices/lab_pin.sym} 121360 -35860 0 1 {name=p120086 lab=_62450_/Y }
C {sky130_stdcells/nand4_4.sym} 121300 -35860 0 0 {name=X_62450_ }
C {devices/lab_pin.sym} 121220 -35730 0 0 {name=p120087 lab=_74434_/Y }
C {devices/lab_pin.sym} 121220 -35690 0 0 {name=p120088 lab=_74430_/X }
C {devices/lab_pin.sym} 121220 -35650 0 0 {name=p120089 lab=_74435_/X }
C {devices/lab_pin.sym} 121380 -35690 0 1 {name=p120090 lab=_74436_/Y }
C {sky130_stdcells/a21oi_4.sym} 121300 -35690 0 0 {name=X_74436_ }
C {devices/lab_pin.sym} 121260 -35550 0 0 {name=p120091 lab=clkbuf_9_30_0_CLK/X }
C {devices/lab_pin.sym} 121340 -35550 0 1 {name=p120092 lab=_84998_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 121300 -35550 0 0 {name=Xclkbuf_10_61_0_CLK }
C {devices/lab_pin.sym} 121260 -35430 0 0 {name=p120093 lab=_40828_/A }
C {devices/lab_pin.sym} 121340 -35430 0 1 {name=p120094 lab=_40828_/Y }
C {sky130_stdcells/inv_2.sym} 121300 -35430 0 0 {name=X_40828_ }
C {devices/lab_pin.sym} 121260 -35310 0 0 {name=p120095 lab=_47525_/A }
C {devices/lab_pin.sym} 121340 -35310 0 1 {name=p120096 lab=_47404_/A }
C {sky130_stdcells/buf_2.sym} 121300 -35310 0 0 {name=X_47384_ }
C {devices/lab_pin.sym} 121240 -35210 0 0 {name=p120097 lab=_71507_/A }
C {devices/lab_pin.sym} 121240 -35170 0 0 {name=p120098 lab=_70854_/A }
C {devices/lab_pin.sym} 121240 -35130 0 0 {name=p120099 lab=_71528_/X }
C {devices/lab_pin.sym} 121360 -35170 0 1 {name=p120100 lab=_71649_/A }
C {sky130_stdcells/nor3_4.sym} 121300 -35170 0 0 {name=X_71648_ }
C {devices/lab_pin.sym} 121260 -35030 0 0 {name=p120101 lab=_44533_/A }
C {devices/lab_pin.sym} 121340 -35030 0 1 {name=p120102 lab=_44596_/X }
C {sky130_stdcells/buf_2.sym} 121300 -35030 0 0 {name=X_44596_ }
C {devices/lab_pin.sym} 121260 -34910 0 0 {name=p120103 lab=_61400_/X }
C {devices/lab_pin.sym} 121340 -34910 0 1 {name=p120104 lab=_61429_/C }
C {sky130_stdcells/buf_2.sym} 121300 -34910 0 0 {name=X_61401_ }
C {devices/lab_pin.sym} 121220 -34810 0 0 {name=p120105 lab=_49118_/Y }
C {devices/lab_pin.sym} 121220 -34770 0 0 {name=p120106 lab=_49086_/X }
C {devices/lab_pin.sym} 121220 -34730 0 0 {name=p120107 lab=_49122_/X }
C {devices/lab_pin.sym} 121380 -34770 0 1 {name=p120108 lab=_86442_/D }
C {sky130_stdcells/a21oi_4.sym} 121300 -34770 0 0 {name=X_49123_ }
C {devices/lab_pin.sym} 121240 -34640 0 0 {name=p120109 lab=_46326_/A }
C {devices/lab_pin.sym} 121240 -34600 0 0 {name=p120110 lab=_49241_/B }
C {devices/lab_pin.sym} 121360 -34620 0 1 {name=p120111 lab=_46335_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -34620 0 0 {name=X_46335_ }
C {devices/lab_pin.sym} 121240 -34500 0 0 {name=p120112 lab=_77146_/B }
C {devices/lab_pin.sym} 121240 -34460 0 0 {name=p120113 lab=_77155_/B }
C {devices/lab_pin.sym} 121360 -34480 0 1 {name=p120114 lab=_77159_/A }
C {sky130_stdcells/nand2_4.sym} 121300 -34480 0 0 {name=X_77155_ }
C {devices/lab_pin.sym} 121220 -34390 0 0 {name=p120115 lab=_43542_/X }
C {devices/lab_pin.sym} 121220 -34350 0 0 {name=p120116 lab=_43546_/X }
C {devices/lab_pin.sym} 121220 -34310 0 0 {name=p120117 lab=_40446_/X }
C {devices/lab_pin.sym} 121220 -34270 0 0 {name=p120118 lab=_87366_/Q }
C {devices/lab_pin.sym} 121220 -34230 0 0 {name=p120119 lab=_43528_/X }
C {devices/lab_pin.sym} 121380 -34310 0 1 {name=p120120 lab=_43548_/A }
C {sky130_stdcells/o32ai_4.sym} 121300 -34310 0 0 {name=X_43547_ }
C {devices/lab_pin.sym} 121220 -34190 0 0 {name=p120121 lab=_62371_/X }
C {devices/lab_pin.sym} 121220 -34150 0 0 {name=p120122 lab=_62378_/Y }
C {devices/lab_pin.sym} 121220 -34110 0 0 {name=p120123 lab=_62380_/X }
C {devices/lab_pin.sym} 121220 -34070 0 0 {name=p120124 lab=_84742_/Q }
C {devices/lab_pin.sym} 121220 -34030 0 0 {name=p120125 lab=_62367_/X }
C {devices/lab_pin.sym} 121380 -34110 0 1 {name=p120126 lab=_62381_/Y }
C {sky130_stdcells/o32ai_4.sym} 121300 -34110 0 0 {name=X_62381_ }
C {devices/lab_pin.sym} 121220 -33970 0 0 {name=p120127 lab=_74364_/Y }
C {devices/lab_pin.sym} 121220 -33930 0 0 {name=p120128 lab=_72059_/X }
C {devices/lab_pin.sym} 121220 -33890 0 0 {name=p120129 lab=_74366_/X }
C {devices/lab_pin.sym} 121380 -33930 0 1 {name=p120130 lab=_83081_/D }
C {sky130_stdcells/a21oi_4.sym} 121300 -33930 0 0 {name=X_74367_ }
C {devices/lab_pin.sym} 121260 -33790 0 0 {name=p120131 lab=_40836_/A }
C {devices/lab_pin.sym} 121340 -33790 0 1 {name=p120132 lab=_40759_/X }
C {sky130_stdcells/buf_2.sym} 121300 -33790 0 0 {name=X_40759_ }
C {devices/lab_pin.sym} 121240 -33680 0 0 {name=p120133 lab=_71602_/C }
C {devices/lab_pin.sym} 121240 -33640 0 0 {name=p120134 lab=_71189_/B }
C {devices/lab_pin.sym} 121360 -33660 0 1 {name=p120135 lab=_71580_/A }
C {sky130_stdcells/nor2_4.sym} 121300 -33660 0 0 {name=X_71579_ }
C {devices/lab_pin.sym} 121260 -33530 0 0 {name=p120136 lab=clkbuf_6_53_0_CLK/X }
C {devices/lab_pin.sym} 121340 -33530 0 1 {name=p120137 lab=clkbuf_8_213_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 121300 -33530 0 0 {name=Xclkbuf_7_106_0_CLK }
C {devices/lab_pin.sym} 121260 -33410 0 0 {name=p120138 lab=clkbuf_9_147_0_CLK/X }
C {devices/lab_pin.sym} 121340 -33410 0 1 {name=p120139 lab=_84263_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 121300 -33410 0 0 {name=Xclkbuf_10_294_0_CLK }
C {devices/lab_pin.sym} 121240 -33320 0 0 {name=p120140 lab=_63655_/B }
C {devices/lab_pin.sym} 121240 -33280 0 0 {name=p120141 lab=_64091_/B }
C {devices/lab_pin.sym} 121240 -33240 0 0 {name=p120142 lab=_64178_/C }
C {devices/lab_pin.sym} 121240 -33200 0 0 {name=p120143 lab=_64091_/D }
C {devices/lab_pin.sym} 121360 -33260 0 1 {name=p120144 lab=_64120_/Y }
C {sky130_stdcells/nand4_4.sym} 121300 -33260 0 0 {name=X_64120_ }
C {devices/lab_pin.sym} 121240 -33120 0 0 {name=p120145 lab=_76103_/A }
C {devices/lab_pin.sym} 121240 -33080 0 0 {name=p120146 lab=_76099_/A }
C {devices/lab_pin.sym} 121360 -33100 0 1 {name=p120147 lab=_76107_/A }
C {sky130_stdcells/and2_4.sym} 121300 -33100 0 0 {name=X_76106_ }
C {devices/lab_pin.sym} 121260 -32970 0 0 {name=p120148 lab=_49054_/A }
C {devices/lab_pin.sym} 121340 -32970 0 1 {name=p120149 lab=_49055_/A }
C {sky130_stdcells/inv_2.sym} 121300 -32970 0 0 {name=X_49054_ }
C {devices/lab_pin.sym} 121240 -32870 0 0 {name=p120150 lab=_61305_/A }
C {devices/lab_pin.sym} 121240 -32830 0 0 {name=p120151 lab=_61330_/X }
C {devices/lab_pin.sym} 121240 -32790 0 0 {name=p120152 lab=_61377_/C }
C {devices/lab_pin.sym} 121360 -32830 0 1 {name=p120153 lab=_61332_/Y }
C {sky130_stdcells/nand3_4.sym} 121300 -32830 0 0 {name=X_61332_ }
C {devices/lab_pin.sym} 121260 -32690 0 0 {name=p120154 lab=_73193_/A }
C {devices/lab_pin.sym} 121340 -32690 0 1 {name=p120155 lab=_73318_/X }
C {sky130_stdcells/buf_2.sym} 121300 -32690 0 0 {name=X_73318_ }
C {devices/lab_pin.sym} 121220 -32590 0 0 {name=p120156 lab=_46262_/X }
C {devices/lab_pin.sym} 121220 -32550 0 0 {name=p120157 lab=_81216_/Q }
C {devices/lab_pin.sym} 121220 -32510 0 0 {name=p120158 lab=_46265_/X }
C {devices/lab_pin.sym} 121380 -32550 0 1 {name=p120159 lab=_46267_/A }
C {sky130_stdcells/o21ai_4.sym} 121300 -32550 0 0 {name=X_46266_ }
C {devices/lab_pin.sym} 121240 -32420 0 0 {name=p120160 lab=_77085_/Y }
C {devices/lab_pin.sym} 121240 -32380 0 0 {name=p120161 lab=_77086_/B }
C {devices/lab_pin.sym} 121360 -32400 0 1 {name=p120162 lab=_77087_/B }
C {sky130_stdcells/and2_4.sym} 121300 -32400 0 0 {name=X_77086_ }
C {devices/lab_pin.sym} 121220 -32300 0 0 {name=p120163 lab=_41681_/X }
C {devices/lab_pin.sym} 121220 -32260 0 0 {name=p120164 lab=_43465_/X }
C {devices/lab_pin.sym} 121220 -32220 0 0 {name=p120165 lab=_87402_/Q }
C {devices/lab_pin.sym} 121220 -32180 0 0 {name=p120166 lab=_43467_/X }
C {devices/lab_pin.sym} 121380 -32240 0 1 {name=p120167 lab=_87402_/D }
C {sky130_stdcells/a2bb2o_4.sym} 121300 -32240 0 0 {name=X_43478_ }
C {devices/lab_pin.sym} 121220 -32110 0 0 {name=p120168 lab=_70280_/A }
C {devices/lab_pin.sym} 121220 -32070 0 0 {name=p120169 lab=_74288_/X }
C {devices/lab_pin.sym} 121220 -32030 0 0 {name=p120170 lab=_74297_/Y }
C {devices/lab_pin.sym} 121380 -32070 0 1 {name=p120171 lab=_74298_/X }
C {sky130_stdcells/a21bo_4.sym} 121300 -32070 0 0 {name=X_74298_ }
C {devices/lab_pin.sym} 121220 -31950 0 0 {name=p120172 lab=_66143_/B }
C {devices/lab_pin.sym} 121220 -31910 0 0 {name=p120173 lab=_47998_/X }
C {devices/lab_pin.sym} 121220 -31870 0 0 {name=p120174 lab=_48004_/Y }
C {devices/lab_pin.sym} 121380 -31910 0 1 {name=p120175 lab=_48005_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -31910 0 0 {name=X_48005_ }
C {devices/lab_pin.sym} 121220 -31790 0 0 {name=p120176 lab=_45214_/X }
C {devices/lab_pin.sym} 121220 -31750 0 0 {name=p120177 lab=_45216_/Y }
C {devices/lab_pin.sym} 121220 -31710 0 0 {name=p120178 lab=_45200_/X }
C {devices/lab_pin.sym} 121380 -31750 0 1 {name=p120179 lab=_45217_/Y }
C {sky130_stdcells/a21oi_4.sym} 121300 -31750 0 0 {name=X_45217_ }
C {devices/lab_pin.sym} 121260 -31610 0 0 {name=p120180 lab=clkbuf_9_38_0_CLK/X }
C {devices/lab_pin.sym} 121340 -31610 0 1 {name=p120181 lab=_84407_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 121300 -31610 0 0 {name=Xclkbuf_10_76_0_CLK }
C {devices/lab_pin.sym} 121260 -31490 0 0 {name=p120182 lab=_63972_/A }
C {devices/lab_pin.sym} 121340 -31490 0 1 {name=p120183 lab=_64150_/C }
C {sky130_stdcells/buf_2.sym} 121300 -31490 0 0 {name=X_64051_ }
C {devices/lab_pin.sym} 121240 -31380 0 0 {name=p120184 lab=_76037_/A }
C {devices/lab_pin.sym} 121240 -31340 0 0 {name=p120185 lab=_76028_/B }
C {devices/lab_pin.sym} 121360 -31360 0 1 {name=p120186 lab=_76038_/B }
C {sky130_stdcells/and2_4.sym} 121300 -31360 0 0 {name=X_76037_ }
C {devices/lab_pin.sym} 121260 -31230 0 0 {name=p120187 lab=_42429_/A }
C {devices/lab_pin.sym} 121340 -31230 0 1 {name=p120188 lab=_42574_/A }
C {sky130_stdcells/buf_2.sym} 121300 -31230 0 0 {name=X_42429_ }
C {devices/lab_pin.sym} 121220 -31150 0 0 {name=p120189 lab=_59716_/A }
C {devices/lab_pin.sym} 121220 -31110 0 0 {name=p120190 lab=_61176_/Y }
C {devices/lab_pin.sym} 121220 -31070 0 0 {name=p120191 lab=_59710_/Y }
C {devices/lab_pin.sym} 121220 -31030 0 0 {name=p120192 lab=_61260_/X }
C {devices/lab_pin.sym} 121220 -31000 0 0 {name=p120193 lab=_61262_/Y }
C {devices/lab_pin.sym} 121380 -31070 0 1 {name=p120194 lab=_84495_/D }
C {sky130_stdcells/a41oi_4.sym} 121300 -31070 0 0 {name=X_61263_ }
C {devices/lab_pin.sym} 121260 -30910 0 0 {name=p120195 lab=_72881_/A }
C {devices/lab_pin.sym} 121340 -30910 0 1 {name=p120196 lab=_73250_/A }
C {sky130_stdcells/buf_2.sym} 121300 -30910 0 0 {name=X_73249_ }
C {devices/lab_pin.sym} 121260 -30790 0 0 {name=p120197 lab=_57701_/A }
C {devices/lab_pin.sym} 121340 -30790 0 1 {name=p120198 lab=_66002_/A }
C {sky130_stdcells/inv_2.sym} 121300 -30790 0 0 {name=X_46197_ }
C {devices/lab_pin.sym} 121260 -30670 0 0 {name=p120199 lab=clkbuf_8_223_0_CLK/A }
C {devices/lab_pin.sym} 121340 -30670 0 1 {name=p120200 lab=clkbuf_9_444_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 121300 -30670 0 0 {name=Xclkbuf_8_222_0_CLK }
C {devices/lab_pin.sym} 121220 -30590 0 0 {name=p120201 lab=_63281_/B }
C {devices/lab_pin.sym} 121220 -30550 0 0 {name=p120202 lab=_60438_/A }
C {devices/lab_pin.sym} 121220 -30510 0 0 {name=p120203 lab=_60417_/A }
C {devices/lab_pin.sym} 121220 -30470 0 0 {name=p120204 lab=_60508_/A }
C {devices/lab_pin.sym} 121220 -30430 0 0 {name=p120205 lab=_60392_/C }
C {devices/lab_pin.sym} 121380 -30510 0 1 {name=p120206 lab=_63002_/X }
C {sky130_stdcells/o41a_4.sym} 121300 -30510 0 0 {name=X_63002_ }
C {devices/lab_pin.sym} 121240 -30370 0 0 {name=p120207 lab=_60244_/A }
C {devices/lab_pin.sym} 121240 -30330 0 0 {name=p120208 lab=_60214_/B }
C {devices/lab_pin.sym} 121240 -30290 0 0 {name=p120209 lab=_60214_/C }
C {devices/lab_pin.sym} 121360 -30330 0 1 {name=p120210 lab=_60214_/Y }
C {sky130_stdcells/nor3_4.sym} 121300 -30330 0 0 {name=X_60214_ }
C {devices/lab_pin.sym} 121220 -30210 0 0 {name=p120211 lab=_85233_/Q }
C {devices/lab_pin.sym} 121220 -30170 0 0 {name=p120212 lab=_45131_/X }
C {devices/lab_pin.sym} 121220 -30130 0 0 {name=p120213 lab=_45087_/X }
C {devices/lab_pin.sym} 121380 -30170 0 1 {name=p120214 lab=_45148_/X }
C {sky130_stdcells/o21a_4.sym} 121300 -30170 0 0 {name=X_45148_ }
C {devices/lab_pin.sym} 121260 -30030 0 0 {name=p120215 lab=_59789_/A }
C {devices/lab_pin.sym} 121340 -30030 0 1 {name=p120216 lab=_61194_/X }
C {sky130_stdcells/buf_2.sym} 121300 -30030 0 0 {name=X_61194_ }
C {devices/lab_pin.sym} 121240 -29920 0 0 {name=p120217 lab=_67739_/X }
C {devices/lab_pin.sym} 121240 -29880 0 0 {name=p120218 lab=_67810_/B }
C {devices/lab_pin.sym} 121360 -29900 0 1 {name=p120219 lab=_67810_/X }
C {sky130_stdcells/and2_4.sym} 121300 -29900 0 0 {name=X_67810_ }
C {devices/lab_pin.sym} 121260 -29770 0 0 {name=p120220 lab=_60145_/A }
C {devices/lab_pin.sym} 121340 -29770 0 1 {name=p120221 lab=_60145_/Y }
C {sky130_stdcells/inv_2.sym} 121300 -29770 0 0 {name=X_60145_ }
C {devices/lab_pin.sym} 121220 -29670 0 0 {name=p120222 lab=_72277_/B }
C {devices/lab_pin.sym} 121220 -29630 0 0 {name=p120223 lab=_49934_/X }
C {devices/lab_pin.sym} 121220 -29590 0 0 {name=p120224 lab=_49955_/Y }
C {devices/lab_pin.sym} 121380 -29630 0 1 {name=p120225 lab=_49956_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -29630 0 0 {name=X_49956_ }
C {devices/lab_pin.sym} 121260 -29490 0 0 {name=p120226 lab=_45153_/A }
C {devices/lab_pin.sym} 121340 -29490 0 1 {name=p120227 lab=_45079_/X }
C {sky130_stdcells/buf_2.sym} 121300 -29490 0 0 {name=X_45079_ }
C {devices/lab_pin.sym} 121240 -29380 0 0 {name=p120228 lab=_68542_/X }
C {devices/lab_pin.sym} 121240 -29340 0 0 {name=p120229 lab=_68790_/B }
C {devices/lab_pin.sym} 121360 -29360 0 1 {name=p120230 lab=_68790_/X }
C {sky130_stdcells/and2_4.sym} 121300 -29360 0 0 {name=X_68790_ }
C {devices/lab_pin.sym} 121260 -29230 0 0 {name=p120231 lab=_78010_/A }
C {devices/lab_pin.sym} 121340 -29230 0 1 {name=p120232 lab=_77993_/A }
C {sky130_stdcells/inv_2.sym} 121300 -29230 0 0 {name=X_77988_ }
C {devices/lab_pin.sym} 121260 -29110 0 0 {name=p120233 lab=_52275_/B }
C {devices/lab_pin.sym} 121340 -29110 0 1 {name=p120234 lab=_71970_/B }
C {sky130_stdcells/buf_2.sym} 121300 -29110 0 0 {name=X_48907_ }
C {devices/lab_pin.sym} 121220 -29010 0 0 {name=p120235 lab=_79711_/X }
C {devices/lab_pin.sym} 121220 -28970 0 0 {name=p120236 lab=_79714_/Y }
C {devices/lab_pin.sym} 121220 -28930 0 0 {name=p120237 lab=_79726_/X }
C {devices/lab_pin.sym} 121380 -28970 0 1 {name=p120238 lab=_79727_/X }
C {sky130_stdcells/a21o_4.sym} 121300 -28970 0 0 {name=X_79727_ }
C {devices/lab_pin.sym} 121220 -28860 0 0 {name=p120239 lab=_87394_/Q }
C {devices/lab_pin.sym} 121220 -28820 0 0 {name=p120240 lab=_67717_/X }
C {devices/lab_pin.sym} 121220 -28780 0 0 {name=p120241 lab=_67718_/X }
C {devices/lab_pin.sym} 121220 -28740 0 0 {name=p120242 lab=_67740_/X }
C {devices/lab_pin.sym} 121380 -28800 0 1 {name=p120243 lab=_67741_/X }
C {sky130_stdcells/a211o_4.sym} 121300 -28800 0 0 {name=X_67741_ }
C {devices/lab_pin.sym} 121240 -28660 0 0 {name=p120244 lab=_64953_/A }
C {devices/lab_pin.sym} 121240 -28620 0 0 {name=p120245 lab=_64953_/B }
C {devices/lab_pin.sym} 121360 -28640 0 1 {name=p120246 lab=_64953_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -28640 0 0 {name=X_64953_ }
C {devices/lab_pin.sym} 121240 -28520 0 0 {name=p120247 lab=_76939_/A }
C {devices/lab_pin.sym} 121240 -28480 0 0 {name=p120248 lab=_76938_/B }
C {devices/lab_pin.sym} 121360 -28500 0 1 {name=p120249 lab=_76939_/X }
C {sky130_stdcells/or2_4.sym} 121300 -28500 0 0 {name=X_76939_ }
C {devices/lab_pin.sym} 121260 -28370 0 0 {name=p120250 lab=_60075_/Y }
C {devices/lab_pin.sym} 121340 -28370 0 1 {name=p120251 lab=_84666_/D }
C {sky130_stdcells/inv_2.sym} 121300 -28370 0 0 {name=X_60076_ }
C {devices/lab_pin.sym} 121220 -28270 0 0 {name=p120252 lab=_72116_/B }
C {devices/lab_pin.sym} 121220 -28230 0 0 {name=p120253 lab=_49880_/X }
C {devices/lab_pin.sym} 121220 -28190 0 0 {name=p120254 lab=_49886_/Y }
C {devices/lab_pin.sym} 121380 -28230 0 1 {name=p120255 lab=_49887_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -28230 0 0 {name=X_49887_ }
C {devices/lab_pin.sym} 121260 -28090 0 0 {name=p120256 lab=clkbuf_8_237_0_CLK/A }
C {devices/lab_pin.sym} 121340 -28090 0 1 {name=p120257 lab=clkbuf_9_475_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 121300 -28090 0 0 {name=Xclkbuf_8_237_0_CLK }
C {devices/lab_pin.sym} 121260 -27970 0 0 {name=p120258 lab=clkbuf_9_116_0_CLK/X }
C {devices/lab_pin.sym} 121340 -27970 0 1 {name=p120259 lab=_81087_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 121300 -27970 0 0 {name=Xclkbuf_10_232_0_CLK }
C {devices/lab_pin.sym} 121260 -27850 0 0 {name=p120260 lab=_60909_/X }
C {devices/lab_pin.sym} 121340 -27850 0 1 {name=p120261 lab=_63905_/C }
C {sky130_stdcells/buf_2.sym} 121300 -27850 0 0 {name=X_63904_ }
C {devices/lab_pin.sym} 121240 -27740 0 0 {name=p120262 lab=_48851_/A }
C {devices/lab_pin.sym} 121240 -27700 0 0 {name=p120263 lab=_48628_/B }
C {devices/lab_pin.sym} 121360 -27720 0 1 {name=p120264 lab=_48838_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -27720 0 0 {name=X_48838_ }
C {devices/lab_pin.sym} 121240 -27600 0 0 {name=p120265 lab=_67696_/A }
C {devices/lab_pin.sym} 121240 -27560 0 0 {name=p120266 lab=_67672_/B }
C {devices/lab_pin.sym} 121360 -27580 0 1 {name=p120267 lab=_67672_/X }
C {sky130_stdcells/and2_4.sym} 121300 -27580 0 0 {name=X_67672_ }
C {devices/lab_pin.sym} 121240 -27460 0 0 {name=p120268 lab=_79658_/A }
C {devices/lab_pin.sym} 121240 -27420 0 0 {name=p120269 lab=_79658_/B }
C {devices/lab_pin.sym} 121360 -27440 0 1 {name=p120270 lab=_79668_/B }
C {sky130_stdcells/xor2_4.sym} 121300 -27440 0 0 {name=X_79658_ }
C {devices/lab_pin.sym} 121220 -27340 0 0 {name=p120271 lab=_64828_/X }
C {devices/lab_pin.sym} 121220 -27300 0 0 {name=p120272 lab=_85559_/Q }
C {devices/lab_pin.sym} 121220 -27260 0 0 {name=p120273 lab=_64829_/X }
C {devices/lab_pin.sym} 121220 -27220 0 0 {name=p120274 lab=_64883_/X }
C {devices/lab_pin.sym} 121380 -27280 0 1 {name=p120275 lab=_64884_/X }
C {sky130_stdcells/a211o_4.sym} 121300 -27280 0 0 {name=X_64884_ }
C {devices/lab_pin.sym} 121260 -27130 0 0 {name=p120276 lab=clkbuf_9_431_0_CLK/X }
C {devices/lab_pin.sym} 121340 -27130 0 1 {name=p120277 lab=_86424_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 121300 -27130 0 0 {name=Xclkbuf_10_862_0_CLK }
C {devices/lab_pin.sym} 121240 -27020 0 0 {name=p120278 lab=_69305_/A }
C {devices/lab_pin.sym} 121240 -26980 0 0 {name=p120279 lab=_69411_/B }
C {devices/lab_pin.sym} 121360 -27000 0 1 {name=p120280 lab=_69411_/X }
C {sky130_stdcells/and2_4.sym} 121300 -27000 0 0 {name=X_69411_ }
C {devices/lab_pin.sym} 121260 -26870 0 0 {name=p120281 lab=clkbuf_9_7_0_CLK/X }
C {devices/lab_pin.sym} 121340 -26870 0 1 {name=p120282 lab=_83001_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 121300 -26870 0 0 {name=Xclkbuf_10_14_0_CLK }
C {devices/lab_pin.sym} 121240 -26760 0 0 {name=p120283 lab=_66620_/X }
C {devices/lab_pin.sym} 121240 -26720 0 0 {name=p120284 lab=_66622_/X }
C {devices/lab_pin.sym} 121360 -26740 0 1 {name=p120285 lab=_66623_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -26740 0 0 {name=X_66623_ }
C {devices/lab_pin.sym} 121240 -26620 0 0 {name=p120286 lab=_78608_/A }
C {devices/lab_pin.sym} 121240 -26580 0 0 {name=p120287 lab=_82678_/D }
C {devices/lab_pin.sym} 121360 -26600 0 1 {name=p120288 lab=_78609_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -26600 0 0 {name=X_78609_ }
C {devices/lab_pin.sym} 121220 -26490 0 0 {name=p120289 lab=_63832_/X }
C {devices/lab_pin.sym} 121220 -26450 0 0 {name=p120290 lab=_63833_/X }
C {devices/lab_pin.sym} 121220 -26410 0 0 {name=p120291 lab=_63834_/Y }
C {devices/lab_pin.sym} 121380 -26450 0 1 {name=p120292 lab=_63835_/Y }
C {sky130_stdcells/a21oi_4.sym} 121300 -26450 0 0 {name=X_63835_ }
C {devices/lab_pin.sym} 121220 -26330 0 0 {name=p120293 lab=_86486_/Q }
C {devices/lab_pin.sym} 121220 -26290 0 0 {name=p120294 lab=_48754_/X }
C {devices/lab_pin.sym} 121220 -26250 0 0 {name=p120295 lab=_48768_/Y }
C {devices/lab_pin.sym} 121380 -26290 0 1 {name=p120296 lab=_48769_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -26290 0 0 {name=X_48769_ }
C {devices/lab_pin.sym} 121240 -26160 0 0 {name=p120297 lab=_79594_/B }
C {devices/lab_pin.sym} 121240 -26120 0 0 {name=p120298 lab=_79588_/Y }
C {devices/lab_pin.sym} 121360 -26140 0 1 {name=p120299 lab=_79592_/A }
C {sky130_stdcells/nand2_4.sym} 121300 -26140 0 0 {name=X_79589_ }
C {devices/lab_pin.sym} 121260 -26010 0 0 {name=p120300 lab=clkbuf_8_176_0_CLK/X }
C {devices/lab_pin.sym} 121340 -26010 0 1 {name=p120301 lab=clkbuf_9_353_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 121300 -26010 0 0 {name=Xclkbuf_9_353_0_CLK }
C {devices/lab_pin.sym} 121220 -25910 0 0 {name=p120302 lab=_86130_/Q }
C {devices/lab_pin.sym} 121220 -25870 0 0 {name=p120303 lab=_50727_/X }
C {devices/lab_pin.sym} 121220 -25830 0 0 {name=p120304 lab=_50799_/Y }
C {devices/lab_pin.sym} 121380 -25870 0 1 {name=p120305 lab=_50800_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -25870 0 0 {name=X_50800_ }
C {devices/lab_pin.sym} 121210 -25730 0 0 {name=p120306 lab=_81620_/CLK }
C {devices/lab_pin.sym} 121210 -25710 0 0 {name=p120307 lab=_76423_/X }
C {devices/lab_pin.sym} 121390 -25730 0 1 {name=p120308 lab=_81620_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -25720 0 0 {name=X_81620_ }
C {devices/lab_pin.sym} 121220 -25620 0 0 {name=p120309 lab=_88036_/Q }
C {devices/lab_pin.sym} 121220 -25580 0 0 {name=p120310 lab=_69162_/X }
C {devices/lab_pin.sym} 121220 -25540 0 0 {name=p120311 lab=_69202_/X }
C {devices/lab_pin.sym} 121220 -25500 0 0 {name=p120312 lab=_69341_/X }
C {devices/lab_pin.sym} 121380 -25560 0 1 {name=p120313 lab=_69342_/X }
C {sky130_stdcells/a211o_4.sym} 121300 -25560 0 0 {name=X_69342_ }
C {devices/lab_pin.sym} 121260 -25410 0 0 {name=p120314 lab=_66553_/X }
C {devices/lab_pin.sym} 121340 -25410 0 1 {name=p120315 lab=_66554_/X }
C {sky130_stdcells/buf_2.sym} 121300 -25410 0 0 {name=X_66554_ }
C {devices/lab_pin.sym} 121220 -25310 0 0 {name=p120316 lab=_85947_/Q }
C {devices/lab_pin.sym} 121220 -25270 0 0 {name=p120317 lab=_51763_/X }
C {devices/lab_pin.sym} 121220 -25230 0 0 {name=p120318 lab=_51779_/Y }
C {devices/lab_pin.sym} 121380 -25270 0 1 {name=p120319 lab=_51780_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -25270 0 0 {name=X_51780_ }
C {devices/lab_pin.sym} 121220 -25170 0 0 {name=p120320 lab=_63759_/X }
C {devices/lab_pin.sym} 121220 -25130 0 0 {name=p120321 lab=_63736_/X }
C {devices/lab_pin.sym} 121220 -25090 0 0 {name=p120322 lab=_63760_/Y }
C {devices/lab_pin.sym} 121220 -25050 0 0 {name=p120323 lab=_63762_/Y }
C {devices/lab_pin.sym} 121220 -25020 0 0 {name=p120324 lab=_63765_/X }
C {devices/lab_pin.sym} 121380 -25090 0 1 {name=p120325 lab=_63766_/X }
C {sky130_stdcells/a41o_4.sym} 121300 -25090 0 0 {name=X_63766_ }
C {devices/lab_pin.sym} 121220 -24970 0 0 {name=p120326 lab=_60961_/X }
C {devices/lab_pin.sym} 121220 -24930 0 0 {name=p120327 lab=_60972_/X }
C {devices/lab_pin.sym} 121220 -24890 0 0 {name=p120328 lab=_60976_/Y }
C {devices/lab_pin.sym} 121220 -24850 0 0 {name=p120329 lab=_60958_/X }
C {devices/lab_pin.sym} 121220 -24810 0 0 {name=p120330 lab=_60977_/X }
C {devices/lab_pin.sym} 121380 -24890 0 1 {name=p120331 lab=_84546_/D }
C {sky130_stdcells/o41a_4.sym} 121300 -24890 0 0 {name=X_60978_ }
C {devices/lab_pin.sym} 121260 -24730 0 0 {name=p120332 lab=clkbuf_9_123_0_CLK/X }
C {devices/lab_pin.sym} 121340 -24730 0 1 {name=p120333 lab=_84458_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 121300 -24730 0 0 {name=Xclkbuf_10_247_0_CLK }
C {devices/lab_pin.sym} 121240 -24620 0 0 {name=p120334 lab=_65387_/A }
C {devices/lab_pin.sym} 121240 -24580 0 0 {name=p120335 lab=_72911_/B }
C {devices/lab_pin.sym} 121360 -24600 0 1 {name=p120336 lab=_65505_/X }
C {sky130_stdcells/and2_4.sym} 121300 -24600 0 0 {name=X_65505_ }
C {devices/lab_pin.sym} 121240 -24490 0 0 {name=p120337 lab=_50731_/A }
C {devices/lab_pin.sym} 121240 -24450 0 0 {name=p120338 lab=_50731_/B }
C {devices/lab_pin.sym} 121240 -24410 0 0 {name=p120339 lab=_53944_/C }
C {devices/lab_pin.sym} 121360 -24450 0 1 {name=p120340 lab=_50731_/Y }
C {sky130_stdcells/nor3_4.sym} 121300 -24450 0 0 {name=X_50731_ }
C {devices/lab_pin.sym} 121260 -24310 0 0 {name=p120341 lab=_62717_/A }
C {devices/lab_pin.sym} 121340 -24310 0 1 {name=p120342 lab=_62717_/X }
C {sky130_stdcells/buf_2.sym} 121300 -24310 0 0 {name=X_62717_ }
C {devices/lab_pin.sym} 121210 -24190 0 0 {name=p120343 lab=_83918_/CLK }
C {devices/lab_pin.sym} 121210 -24170 0 0 {name=p120344 lab=_76771_/X }
C {devices/lab_pin.sym} 121390 -24190 0 1 {name=p120345 lab=_76158_/B }
C {sky130_stdcells/dfxtp_4.sym} 121300 -24180 0 0 {name=X_81551_ }
C {devices/lab_pin.sym} 121260 -24050 0 0 {name=p120346 lab=_69178_/A }
C {devices/lab_pin.sym} 121340 -24050 0 1 {name=p120347 lab=_69288_/A }
C {sky130_stdcells/buf_2.sym} 121300 -24050 0 0 {name=X_69273_ }
C {devices/lab_pin.sym} 121260 -23930 0 0 {name=p120348 lab=clkbuf_9_438_0_CLK/X }
C {devices/lab_pin.sym} 121340 -23930 0 1 {name=p120349 lab=_86749_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 121300 -23930 0 0 {name=Xclkbuf_10_877_0_CLK }
C {devices/lab_pin.sym} 121240 -23830 0 0 {name=p120350 lab=_66445_/A }
C {devices/lab_pin.sym} 121240 -23790 0 0 {name=p120351 lab=_66514_/B }
C {devices/lab_pin.sym} 121240 -23750 0 0 {name=p120352 lab=_66484_/Y }
C {devices/lab_pin.sym} 121360 -23790 0 1 {name=p120353 lab=_66485_/Y }
C {sky130_stdcells/nor3_4.sym} 121300 -23790 0 0 {name=X_66485_ }
C {devices/lab_pin.sym} 121240 -23670 0 0 {name=p120354 lab=_63697_/A }
C {devices/lab_pin.sym} 121240 -23630 0 0 {name=p120355 lab=_64534_/C }
C {devices/lab_pin.sym} 121240 -23590 0 0 {name=p120356 lab=_63458_/A }
C {devices/lab_pin.sym} 121360 -23630 0 1 {name=p120357 lab=_63697_/X }
C {sky130_stdcells/and3_4.sym} 121300 -23630 0 0 {name=X_63697_ }
C {devices/lab_pin.sym} 121260 -23490 0 0 {name=p120358 lab=clkbuf_9_14_0_CLK/X }
C {devices/lab_pin.sym} 121340 -23490 0 1 {name=p120359 lab=_85250_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 121300 -23490 0 0 {name=Xclkbuf_10_29_0_CLK }
C {devices/lab_pin.sym} 121240 -23380 0 0 {name=p120360 lab=_80502_/A }
C {devices/lab_pin.sym} 121240 -23340 0 0 {name=p120361 lab=_80501_/Y }
C {devices/lab_pin.sym} 121360 -23360 0 1 {name=p120362 lab=_82261_/D }
C {sky130_stdcells/xor2_4.sym} 121300 -23360 0 0 {name=X_80502_ }
C {devices/lab_pin.sym} 121220 -23250 0 0 {name=p120363 lab=_84008_/Q }
C {devices/lab_pin.sym} 121220 -23210 0 0 {name=p120364 lab=_68220_/X }
C {devices/lab_pin.sym} 121220 -23170 0 0 {name=p120365 lab=_68223_/X }
C {devices/lab_pin.sym} 121380 -23210 0 1 {name=p120366 lab=_68224_/X }
C {sky130_stdcells/a21bo_4.sym} 121300 -23210 0 0 {name=X_68224_ }
C {devices/lab_pin.sym} 121260 -23070 0 0 {name=p120367 lab=_53450_/A }
C {devices/lab_pin.sym} 121340 -23070 0 1 {name=p120368 lab=_54321_/A }
C {sky130_stdcells/buf_2.sym} 121300 -23070 0 0 {name=X_53450_ }
C {devices/lab_pin.sym} 121220 -22970 0 0 {name=p120369 lab=_65433_/Y }
C {devices/lab_pin.sym} 121220 -22930 0 0 {name=p120370 lab=_65347_/X }
C {devices/lab_pin.sym} 121220 -22890 0 0 {name=p120371 lab=_65435_/X }
C {devices/lab_pin.sym} 121380 -22930 0 1 {name=p120372 lab=_84201_/D }
C {sky130_stdcells/a21o_4.sym} 121300 -22930 0 0 {name=X_65436_ }
C {devices/lab_pin.sym} 121210 -22790 0 0 {name=p120373 lab=_84269_/CLK }
C {devices/lab_pin.sym} 121210 -22770 0 0 {name=p120374 lab=_84270_/D }
C {devices/lab_pin.sym} 121390 -22790 0 1 {name=p120375 lab=_79950_/B }
C {sky130_stdcells/dfxtp_4.sym} 121300 -22780 0 0 {name=X_84270_ }
C {devices/lab_pin.sym} 121240 -22660 0 0 {name=p120376 lab=_50627_/X }
C {devices/lab_pin.sym} 121240 -22620 0 0 {name=p120377 lab=_49073_/X }
C {devices/lab_pin.sym} 121360 -22640 0 1 {name=p120378 lab=_50662_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -22640 0 0 {name=X_50662_ }
C {devices/lab_pin.sym} 121210 -22510 0 0 {name=p120379 lab=_81482_/CLK }
C {devices/lab_pin.sym} 121210 -22490 0 0 {name=p120380 lab=_81482_/D }
C {devices/lab_pin.sym} 121390 -22510 0 1 {name=p120381 lab=_76714_/A }
C {sky130_stdcells/dfxtp_4.sym} 121300 -22500 0 0 {name=X_81482_ }
C {devices/lab_pin.sym} 121220 -22410 0 0 {name=p120382 lab=_84905_/Q }
C {devices/lab_pin.sym} 121220 -22370 0 0 {name=p120383 lab=_62924_/C }
C {devices/lab_pin.sym} 121220 -22330 0 0 {name=p120384 lab=_60220_/A }
C {devices/lab_pin.sym} 121220 -22290 0 0 {name=p120385 lab=_62644_/X }
C {devices/lab_pin.sym} 121220 -22260 0 0 {name=p120386 lab=_62647_/Y }
C {devices/lab_pin.sym} 121380 -22330 0 1 {name=p120387 lab=_62648_/X }
C {sky130_stdcells/a41o_4.sym} 121300 -22330 0 0 {name=X_62648_ }
C {devices/lab_pin.sym} 121260 -22170 0 0 {name=p120388 lab=clkbuf_8_184_0_CLK/X }
C {devices/lab_pin.sym} 121340 -22170 0 1 {name=p120389 lab=clkbuf_9_368_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 121300 -22170 0 0 {name=Xclkbuf_9_368_0_CLK }
C {devices/lab_pin.sym} 121240 -22060 0 0 {name=p120390 lab=_52400_/X }
C {devices/lab_pin.sym} 121240 -22020 0 0 {name=p120391 lab=_50188_/B }
C {devices/lab_pin.sym} 121360 -22040 0 1 {name=p120392 lab=_52401_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -22040 0 0 {name=X_52401_ }
C {devices/lab_pin.sym} 121210 -21910 0 0 {name=p120393 lab=_83227_/CLK }
C {devices/lab_pin.sym} 121210 -21890 0 0 {name=p120394 lab=_72601_/Y }
C {devices/lab_pin.sym} 121390 -21910 0 1 {name=p120395 lab=_83221_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -21900 0 0 {name=X_83221_ }
C {devices/lab_pin.sym} 121240 -21780 0 0 {name=p120396 lab=_80433_/A }
C {devices/lab_pin.sym} 121240 -21740 0 0 {name=p120397 lab=_84311_/Q }
C {devices/lab_pin.sym} 121360 -21760 0 1 {name=p120398 lab=_80434_/B }
C {sky130_stdcells/xor2_4.sym} 121300 -21760 0 0 {name=X_80433_ }
C {devices/lab_pin.sym} 121260 -21630 0 0 {name=p120399 lab=_68097_/A }
C {devices/lab_pin.sym} 121340 -21630 0 1 {name=p120400 lab=_68155_/X }
C {sky130_stdcells/buf_2.sym} 121300 -21630 0 0 {name=X_68155_ }
C {devices/lab_pin.sym} 121220 -21530 0 0 {name=p120401 lab=_85644_/Q }
C {devices/lab_pin.sym} 121220 -21490 0 0 {name=p120402 lab=_53378_/X }
C {devices/lab_pin.sym} 121220 -21450 0 0 {name=p120403 lab=_53380_/Y }
C {devices/lab_pin.sym} 121380 -21490 0 1 {name=p120404 lab=_53381_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -21490 0 0 {name=X_53381_ }
C {devices/lab_pin.sym} 121240 -21360 0 0 {name=p120405 lab=_65289_/A }
C {devices/lab_pin.sym} 121240 -21320 0 0 {name=p120406 lab=_65367_/B }
C {devices/lab_pin.sym} 121360 -21340 0 1 {name=p120407 lab=_65367_/X }
C {sky130_stdcells/and2_4.sym} 121300 -21340 0 0 {name=X_65367_ }
C {devices/lab_pin.sym} 121220 -21230 0 0 {name=p120408 lab=_50591_/Y }
C {devices/lab_pin.sym} 121220 -21190 0 0 {name=p120409 lab=_50577_/X }
C {devices/lab_pin.sym} 121220 -21150 0 0 {name=p120410 lab=_50592_/Y }
C {devices/lab_pin.sym} 121380 -21190 0 1 {name=p120411 lab=_86171_/D }
C {sky130_stdcells/a21boi_4.sym} 121300 -21190 0 0 {name=X_50593_ }
C {devices/lab_pin.sym} 121220 -21080 0 0 {name=p120412 lab=_60055_/A }
C {devices/lab_pin.sym} 121220 -21040 0 0 {name=p120413 lab=_62129_/X }
C {devices/lab_pin.sym} 121220 -21000 0 0 {name=p120414 lab=_59936_/X }
C {devices/lab_pin.sym} 121220 -20960 0 0 {name=p120415 lab=_58194_/A }
C {devices/lab_pin.sym} 121380 -21020 0 1 {name=p120416 lab=_62579_/Y }
C {sky130_stdcells/a22oi_4.sym} 121300 -21020 0 0 {name=X_62579_ }
C {devices/lab_pin.sym} 121260 -20870 0 0 {name=p120417 lab=clkbuf_9_400_0_CLK/X }
C {devices/lab_pin.sym} 121340 -20870 0 1 {name=p120418 lab=_82139_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 121300 -20870 0 0 {name=Xclkbuf_10_800_0_CLK }
C {devices/lab_pin.sym} 121240 -20780 0 0 {name=p120419 lab=_46647_/B }
C {devices/lab_pin.sym} 121240 -20740 0 0 {name=p120420 lab=_47877_/A }
C {devices/lab_pin.sym} 121240 -20700 0 0 {name=p120421 lab=_55120_/C }
C {devices/lab_pin.sym} 121240 -20660 0 0 {name=p120422 lab=_47822_/A }
C {devices/lab_pin.sym} 121360 -20720 0 1 {name=p120423 lab=_55120_/X }
C {sky130_stdcells/and4_4.sym} 121300 -20720 0 0 {name=X_55120_ }
C {devices/lab_pin.sym} 121260 -20570 0 0 {name=p120424 lab=_66628_/X }
C {devices/lab_pin.sym} 121340 -20570 0 1 {name=p120425 lab=_67106_/X }
C {sky130_stdcells/buf_2.sym} 121300 -20570 0 0 {name=X_67106_ }
C {devices/lab_pin.sym} 121240 -20460 0 0 {name=p120426 lab=_52320_/A }
C {devices/lab_pin.sym} 121240 -20420 0 0 {name=p120427 lab=_49021_/A }
C {devices/lab_pin.sym} 121360 -20440 0 1 {name=p120428 lab=_52332_/X }
C {sky130_stdcells/and2_4.sym} 121300 -20440 0 0 {name=X_52332_ }
C {devices/lab_pin.sym} 121240 -20340 0 0 {name=p120429 lab=_64304_/A }
C {devices/lab_pin.sym} 121240 -20300 0 0 {name=p120430 lab=_64303_/X }
C {devices/lab_pin.sym} 121240 -20260 0 0 {name=p120431 lab=_84960_/Q }
C {devices/lab_pin.sym} 121240 -20220 0 0 {name=p120432 lab=_64318_/D }
C {devices/lab_pin.sym} 121360 -20280 0 1 {name=p120433 lab=_64318_/X }
C {sky130_stdcells/and4_4.sym} 121300 -20280 0 0 {name=X_64318_ }
C {devices/lab_pin.sym} 121210 -20130 0 0 {name=p120434 lab=_86534_/CLK }
C {devices/lab_pin.sym} 121210 -20110 0 0 {name=p120435 lab=_73414_/X }
C {devices/lab_pin.sym} 121390 -20130 0 1 {name=p120436 lab=_83152_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -20120 0 0 {name=X_83152_ }
C {devices/lab_pin.sym} 121220 -20010 0 0 {name=p120437 lab=_80353_/A }
C {devices/lab_pin.sym} 121220 -19970 0 0 {name=p120438 lab=_80336_/Y }
C {devices/lab_pin.sym} 121220 -19930 0 0 {name=p120439 lab=_80353_/B }
C {devices/lab_pin.sym} 121380 -19970 0 1 {name=p120440 lab=_80364_/Y }
C {sky130_stdcells/a21boi_4.sym} 121300 -19970 0 0 {name=X_80364_ }
C {devices/lab_pin.sym} 121220 -19860 0 0 {name=p120441 lab=_67948_/X }
C {devices/lab_pin.sym} 121220 -19820 0 0 {name=p120442 lab=_68077_/Y }
C {devices/lab_pin.sym} 121220 -19780 0 0 {name=p120443 lab=_67983_/X }
C {devices/lab_pin.sym} 121220 -19740 0 0 {name=p120444 lab=_68085_/Y }
C {devices/lab_pin.sym} 121380 -19800 0 1 {name=p120445 lab=_68086_/X }
C {sky130_stdcells/a211o_4.sym} 121300 -19800 0 0 {name=X_68086_ }
C {devices/lab_pin.sym} 121240 -19660 0 0 {name=p120446 lab=_64593_/A }
C {devices/lab_pin.sym} 121240 -19620 0 0 {name=p120447 lab=_65298_/B }
C {devices/lab_pin.sym} 121360 -19640 0 1 {name=p120448 lab=_65298_/X }
C {sky130_stdcells/and2_4.sym} 121300 -19640 0 0 {name=X_65298_ }
C {devices/lab_pin.sym} 121210 -19510 0 0 {name=p120449 lab=_82103_/CLK }
C {devices/lab_pin.sym} 121210 -19490 0 0 {name=p120450 lab=_82103_/D }
C {devices/lab_pin.sym} 121390 -19510 0 1 {name=p120451 lab=_77152_/A }
C {sky130_stdcells/dfxtp_4.sym} 121300 -19500 0 0 {name=X_82103_ }
C {devices/lab_pin.sym} 121260 -19370 0 0 {name=p120452 lab=_54973_/A }
C {devices/lab_pin.sym} 121340 -19370 0 1 {name=p120453 lab=_55070_/C }
C {sky130_stdcells/buf_2.sym} 121300 -19370 0 0 {name=X_55051_ }
C {devices/lab_pin.sym} 121220 -19280 0 0 {name=p120454 lab=_87424_/Q }
C {devices/lab_pin.sym} 121220 -19240 0 0 {name=p120455 lab=_67035_/X }
C {devices/lab_pin.sym} 121220 -19200 0 0 {name=p120456 lab=_66984_/X }
C {devices/lab_pin.sym} 121220 -19160 0 0 {name=p120457 lab=_67036_/X }
C {devices/lab_pin.sym} 121380 -19220 0 1 {name=p120458 lab=_67037_/X }
C {sky130_stdcells/a211o_4.sym} 121300 -19220 0 0 {name=X_67037_ }
C {devices/lab_pin.sym} 121240 -19090 0 0 {name=p120459 lab=_48885_/A }
C {devices/lab_pin.sym} 121240 -19050 0 0 {name=p120460 lab=_52267_/B }
C {devices/lab_pin.sym} 121240 -19010 0 0 {name=p120461 lab=_52267_/C }
C {devices/lab_pin.sym} 121360 -19050 0 1 {name=p120462 lab=_52263_/X }
C {sky130_stdcells/and3_4.sym} 121300 -19050 0 0 {name=X_52263_ }
C {devices/lab_pin.sym} 121260 -18910 0 0 {name=p120463 lab=_64249_/A }
C {devices/lab_pin.sym} 121340 -18910 0 1 {name=p120464 lab=_64249_/X }
C {sky130_stdcells/buf_2.sym} 121300 -18910 0 0 {name=X_64249_ }
C {devices/lab_pin.sym} 121210 -18790 0 0 {name=p120465 lab=_87952_/CLK }
C {devices/lab_pin.sym} 121210 -18770 0 0 {name=p120466 lab=_87960_/D }
C {devices/lab_pin.sym} 121390 -18790 0 1 {name=p120467 lab=_87960_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -18780 0 0 {name=X_87960_ }
C {devices/lab_pin.sym} 121210 -18650 0 0 {name=p120468 lab=_83184_/CLK }
C {devices/lab_pin.sym} 121210 -18630 0 0 {name=p120469 lab=_83083_/D }
C {devices/lab_pin.sym} 121390 -18650 0 1 {name=p120470 lab=_83083_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -18640 0 0 {name=X_83083_ }
C {devices/lab_pin.sym} 121240 -18520 0 0 {name=p120471 lab=_59866_/Y }
C {devices/lab_pin.sym} 121240 -18480 0 0 {name=p120472 lab=_80293_/A }
C {devices/lab_pin.sym} 121360 -18500 0 1 {name=p120473 lab=_80297_/B }
C {sky130_stdcells/nand2_4.sym} 121300 -18500 0 0 {name=X_80295_ }
C {devices/lab_pin.sym} 121240 -18380 0 0 {name=p120474 lab=_53998_/A }
C {devices/lab_pin.sym} 121240 -18340 0 0 {name=p120475 lab=_52482_/B }
C {devices/lab_pin.sym} 121360 -18360 0 1 {name=p120476 lab=_54002_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -18360 0 0 {name=X_54002_ }
C {devices/lab_pin.sym} 121240 -18260 0 0 {name=p120477 lab=_51191_/X }
C {devices/lab_pin.sym} 121240 -18220 0 0 {name=p120478 lab=_51203_/B }
C {devices/lab_pin.sym} 121240 -18180 0 0 {name=p120479 lab=_51197_/C }
C {devices/lab_pin.sym} 121240 -18140 0 0 {name=p120480 lab=_51214_/D }
C {devices/lab_pin.sym} 121360 -18200 0 1 {name=p120481 lab=_51214_/X }
C {sky130_stdcells/and4_4.sym} 121300 -18200 0 0 {name=X_51214_ }
C {devices/lab_pin.sym} 121210 -18050 0 0 {name=p120482 lab=_86878_/CLK }
C {devices/lab_pin.sym} 121210 -18030 0 0 {name=p120483 lab=_44909_/Y }
C {devices/lab_pin.sym} 121390 -18050 0 1 {name=p120484 lab=_62195_/A }
C {sky130_stdcells/dfxtp_4.sym} 121300 -18040 0 0 {name=X_86911_ }
C {devices/lab_pin.sym} 121210 -17910 0 0 {name=p120485 lab=_82005_/CLK }
C {devices/lab_pin.sym} 121210 -17890 0 0 {name=p120486 lab=_77880_/X }
C {devices/lab_pin.sym} 121390 -17910 0 1 {name=p120487 lab=_82034_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -17900 0 0 {name=X_82034_ }
C {devices/lab_pin.sym} 121240 -17790 0 0 {name=p120488 lab=_52194_/A }
C {devices/lab_pin.sym} 121240 -17750 0 0 {name=p120489 lab=_52194_/B }
C {devices/lab_pin.sym} 121240 -17710 0 0 {name=p120490 lab=_52218_/C }
C {devices/lab_pin.sym} 121360 -17750 0 1 {name=p120491 lab=_52194_/X }
C {sky130_stdcells/and3_4.sym} 121300 -17750 0 0 {name=X_52194_ }
C {devices/lab_pin.sym} 121260 -17610 0 0 {name=p120492 lab=clkbuf_9_407_0_CLK/X }
C {devices/lab_pin.sym} 121340 -17610 0 1 {name=p120493 lab=_82596_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 121300 -17610 0 0 {name=Xclkbuf_10_815_0_CLK }
C {devices/lab_pin.sym} 121210 -17490 0 0 {name=p120494 lab=_87995_/CLK }
C {devices/lab_pin.sym} 121210 -17470 0 0 {name=p120495 lab=_87891_/D }
C {devices/lab_pin.sym} 121390 -17490 0 1 {name=p120496 lab=_87891_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -17480 0 0 {name=X_87891_ }
C {devices/lab_pin.sym} 121260 -17350 0 0 {name=p120497 lab=_58810_/A }
C {devices/lab_pin.sym} 121340 -17350 0 1 {name=p120498 lab=_58810_/X }
C {sky130_stdcells/buf_2.sym} 121300 -17350 0 0 {name=X_58810_ }
C {devices/lab_pin.sym} 121260 -17230 0 0 {name=p120499 lab=_86499_/CLK }
C {devices/lab_pin.sym} 121340 -17230 0 1 {name=p120500 lab=_86472_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 121300 -17230 0 0 {name=Xclkbuf_opt_23_CLK }
C {devices/lab_pin.sym} 121220 -17130 0 0 {name=p120501 lab=_86065_/Q }
C {devices/lab_pin.sym} 121220 -17090 0 0 {name=p120502 lab=_51128_/X }
C {devices/lab_pin.sym} 121220 -17050 0 0 {name=p120503 lab=_51144_/Y }
C {devices/lab_pin.sym} 121380 -17090 0 1 {name=p120504 lab=_51145_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -17090 0 0 {name=X_51145_ }
C {devices/lab_pin.sym} 121210 -16950 0 0 {name=p120505 lab=_84287_/CLK }
C {devices/lab_pin.sym} 121210 -16930 0 0 {name=p120506 lab=_86842_/D }
C {devices/lab_pin.sym} 121390 -16950 0 1 {name=p120507 lab=_86842_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -16940 0 0 {name=X_86842_ }
C {devices/lab_pin.sym} 121240 -16820 0 0 {name=p120508 lab=_59687_/Y }
C {devices/lab_pin.sym} 121240 -16780 0 0 {name=p120509 lab=_59790_/B }
C {devices/lab_pin.sym} 121360 -16800 0 1 {name=p120510 lab=_59790_/X }
C {sky130_stdcells/and2_4.sym} 121300 -16800 0 0 {name=X_59790_ }
C {devices/lab_pin.sym} 121260 -16670 0 0 {name=p120511 lab=clkbuf_9_307_0_CLK/A }
C {devices/lab_pin.sym} 121340 -16670 0 1 {name=p120512 lab=clkbuf_9_306_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 121300 -16670 0 0 {name=Xclkbuf_9_306_0_CLK }
C {devices/lab_pin.sym} 121220 -16580 0 0 {name=p120513 lab=_87578_/Q }
C {devices/lab_pin.sym} 121220 -16540 0 0 {name=p120514 lab=_68895_/X }
C {devices/lab_pin.sym} 121220 -16500 0 0 {name=p120515 lab=_68552_/X }
C {devices/lab_pin.sym} 121220 -16460 0 0 {name=p120516 lab=_68987_/X }
C {devices/lab_pin.sym} 121380 -16520 0 1 {name=p120517 lab=_68988_/X }
C {sky130_stdcells/a211o_4.sym} 121300 -16520 0 0 {name=X_68988_ }
C {devices/lab_pin.sym} 121220 -16390 0 0 {name=p120518 lab=_58641_/X }
C {devices/lab_pin.sym} 121220 -16350 0 0 {name=p120519 lab=_85939_/Q }
C {devices/lab_pin.sym} 121220 -16310 0 0 {name=p120520 lab=_58664_/X }
C {devices/lab_pin.sym} 121380 -16350 0 1 {name=p120521 lab=_58741_/X }
C {sky130_stdcells/o21a_4.sym} 121300 -16350 0 0 {name=X_58741_ }
C {devices/lab_pin.sym} 121240 -16220 0 0 {name=p120522 lab=_51097_/A }
C {devices/lab_pin.sym} 121240 -16180 0 0 {name=p120523 lab=_52768_/B }
C {devices/lab_pin.sym} 121360 -16200 0 1 {name=p120524 lab=_51076_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -16200 0 0 {name=X_51076_ }
C {devices/lab_pin.sym} 121220 -16100 0 0 {name=p120525 lab=_44966_/A }
C {devices/lab_pin.sym} 121220 -16060 0 0 {name=p120526 lab=_55619_/A }
C {devices/lab_pin.sym} 121220 -16020 0 0 {name=p120527 lab=_44102_/A }
C {devices/lab_pin.sym} 121220 -15980 0 0 {name=p120528 lab=_55952_/X }
C {devices/lab_pin.sym} 121380 -16040 0 1 {name=p120529 lab=_55954_/B }
C {sky130_stdcells/a211o_4.sym} 121300 -16040 0 0 {name=X_55953_ }
C {devices/lab_pin.sym} 121240 -15900 0 0 {name=p120530 lab=_67914_/X }
C {devices/lab_pin.sym} 121240 -15860 0 0 {name=p120531 lab=_67939_/B }
C {devices/lab_pin.sym} 121360 -15880 0 1 {name=p120532 lab=_67939_/X }
C {sky130_stdcells/and2_4.sym} 121300 -15880 0 0 {name=X_67939_ }
C {devices/lab_pin.sym} 121210 -15750 0 0 {name=p120533 lab=_86757_/CLK }
C {devices/lab_pin.sym} 121210 -15730 0 0 {name=p120534 lab=_46122_/Y }
C {devices/lab_pin.sym} 121390 -15750 0 1 {name=p120535 lab=_41863_/A }
C {sky130_stdcells/dfxtp_4.sym} 121300 -15740 0 0 {name=X_86773_ }
C {devices/lab_pin.sym} 121210 -15610 0 0 {name=p120536 lab=_82629_/CLK }
C {devices/lab_pin.sym} 121210 -15590 0 0 {name=p120537 lab=_68314_/X }
C {devices/lab_pin.sym} 121390 -15610 0 1 {name=p120538 lab=_82633_/D }
C {sky130_stdcells/dfxtp_4.sym} 121300 -15600 0 0 {name=X_83985_ }
C {devices/lab_pin.sym} 121240 -15480 0 0 {name=p120539 lab=_50027_/A }
C {devices/lab_pin.sym} 121240 -15440 0 0 {name=p120540 lab=_53240_/B }
C {devices/lab_pin.sym} 121360 -15460 0 1 {name=p120541 lab=_50027_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -15460 0 0 {name=X_50027_ }
C {devices/lab_pin.sym} 121220 -15350 0 0 {name=p120542 lab=_85356_/Q }
C {devices/lab_pin.sym} 121220 -15310 0 0 {name=p120543 lab=_54892_/X }
C {devices/lab_pin.sym} 121220 -15270 0 0 {name=p120544 lab=_54903_/Y }
C {devices/lab_pin.sym} 121380 -15310 0 1 {name=p120545 lab=_54904_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -15310 0 0 {name=X_54904_ }
C {devices/lab_pin.sym} 121210 -15170 0 0 {name=p120546 lab=_85725_/CLK }
C {devices/lab_pin.sym} 121210 -15150 0 0 {name=p120547 lab=_85724_/D }
C {devices/lab_pin.sym} 121390 -15170 0 1 {name=p120548 lab=_85724_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -15160 0 0 {name=X_85724_ }
C {devices/lab_pin.sym} 121220 -15050 0 0 {name=p120549 lab=_46295_/X }
C {devices/lab_pin.sym} 121220 -15010 0 0 {name=p120550 lab=_70937_/X }
C {devices/lab_pin.sym} 121220 -14970 0 0 {name=p120551 lab=_70949_/Y }
C {devices/lab_pin.sym} 121380 -15010 0 1 {name=p120552 lab=_83653_/D }
C {sky130_stdcells/o21ai_4.sym} 121300 -15010 0 0 {name=X_70950_ }
C {devices/lab_pin.sym} 121240 -14880 0 0 {name=p120553 lab=_58672_/A }
C {devices/lab_pin.sym} 121240 -14840 0 0 {name=p120554 lab=_58649_/B }
C {devices/lab_pin.sym} 121360 -14860 0 1 {name=p120555 lab=_58672_/Y }
C {sky130_stdcells/nor2_4.sym} 121300 -14860 0 0 {name=X_58672_ }
C {devices/lab_pin.sym} 121210 -14730 0 0 {name=p120556 lab=_82933_/CLK }
C {devices/lab_pin.sym} 121210 -14710 0 0 {name=p120557 lab=_78293_/X }
C {devices/lab_pin.sym} 121390 -14730 0 1 {name=p120558 lab=_82936_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -14720 0 0 {name=X_82936_ }
C {devices/lab_pin.sym} 121220 -14620 0 0 {name=p120559 lab=_56221_/C }
C {devices/lab_pin.sym} 121220 -14580 0 0 {name=p120560 lab=_55531_/X }
C {devices/lab_pin.sym} 121220 -14540 0 0 {name=p120561 lab=_44051_/A }
C {devices/lab_pin.sym} 121220 -14500 0 0 {name=p120562 lab=_55883_/X }
C {devices/lab_pin.sym} 121380 -14560 0 1 {name=p120563 lab=_55884_/X }
C {sky130_stdcells/a211o_4.sym} 121300 -14560 0 0 {name=X_55884_ }
C {devices/lab_pin.sym} 121240 -14420 0 0 {name=p120564 lab=_57608_/X }
C {devices/lab_pin.sym} 121240 -14380 0 0 {name=p120565 lab=_50368_/B }
C {devices/lab_pin.sym} 121360 -14400 0 1 {name=p120566 lab=_57623_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -14400 0 0 {name=X_57623_ }
C {devices/lab_pin.sym} 121220 -14300 0 0 {name=p120567 lab=_88080_/Q }
C {devices/lab_pin.sym} 121220 -14260 0 0 {name=p120568 lab=_69607_/X }
C {devices/lab_pin.sym} 121220 -14220 0 0 {name=p120569 lab=_68555_/X }
C {devices/lab_pin.sym} 121220 -14180 0 0 {name=p120570 lab=_69608_/Y }
C {devices/lab_pin.sym} 121380 -14240 0 1 {name=p120571 lab=_69609_/X }
C {sky130_stdcells/a211o_4.sym} 121300 -14240 0 0 {name=X_69609_ }
C {devices/lab_pin.sym} 121260 -14090 0 0 {name=p120572 lab=_54807_/A }
C {devices/lab_pin.sym} 121340 -14090 0 1 {name=p120573 lab=_54857_/A }
C {sky130_stdcells/buf_2.sym} 121300 -14090 0 0 {name=X_54835_ }
C {devices/lab_pin.sym} 121210 -13970 0 0 {name=p120574 lab=_85431_/CLK }
C {devices/lab_pin.sym} 121210 -13950 0 0 {name=p120575 lab=_85655_/D }
C {devices/lab_pin.sym} 121390 -13970 0 1 {name=p120576 lab=_85655_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -13960 0 0 {name=X_85655_ }
C {devices/lab_pin.sym} 121220 -13850 0 0 {name=p120577 lab=_46758_/X }
C {devices/lab_pin.sym} 121220 -13810 0 0 {name=p120578 lab=_70855_/A }
C {devices/lab_pin.sym} 121220 -13770 0 0 {name=p120579 lab=_70880_/Y }
C {devices/lab_pin.sym} 121380 -13810 0 1 {name=p120580 lab=_70881_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -13810 0 0 {name=X_70881_ }
C {devices/lab_pin.sym} 121210 -13670 0 0 {name=p120581 lab=_82349_/CLK }
C {devices/lab_pin.sym} 121210 -13650 0 0 {name=p120582 lab=_82491_/Q }
C {devices/lab_pin.sym} 121390 -13670 0 1 {name=p120583 lab=_82867_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -13660 0 0 {name=X_82867_ }
C {devices/lab_pin.sym} 121260 -13530 0 0 {name=p120584 lab=_41814_/A }
C {devices/lab_pin.sym} 121340 -13530 0 1 {name=p120585 lab=_41800_/X }
C {sky130_stdcells/buf_2.sym} 121300 -13530 0 0 {name=X_41800_ }
C {devices/lab_pin.sym} 121210 -13410 0 0 {name=p120586 lab=_84606_/CLK }
C {devices/lab_pin.sym} 121210 -13390 0 0 {name=p120587 lab=_60527_/Y }
C {devices/lab_pin.sym} 121390 -13410 0 1 {name=p120588 lab=_79146_/A }
C {sky130_stdcells/dfxtp_4.sym} 121300 -13400 0 0 {name=X_84606_ }
C {devices/lab_pin.sym} 121220 -13300 0 0 {name=p120589 lab=_79211_/A }
C {devices/lab_pin.sym} 121220 -13260 0 0 {name=p120590 lab=_59868_/X }
C {devices/lab_pin.sym} 121220 -13220 0 0 {name=p120591 lab=_72618_/X }
C {devices/lab_pin.sym} 121220 -13180 0 0 {name=p120592 lab=_72619_/Y }
C {devices/lab_pin.sym} 121380 -13240 0 1 {name=p120593 lab=_72620_/Y }
C {sky130_stdcells/a22oi_4.sym} 121300 -13240 0 0 {name=X_72620_ }
C {devices/lab_pin.sym} 121220 -13110 0 0 {name=p120594 lab=_84980_/Q }
C {devices/lab_pin.sym} 121220 -13070 0 0 {name=p120595 lab=_57550_/X }
C {devices/lab_pin.sym} 121220 -13030 0 0 {name=p120596 lab=_57553_/Y }
C {devices/lab_pin.sym} 121380 -13070 0 1 {name=p120597 lab=_57554_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -13070 0 0 {name=X_57554_ }
C {devices/lab_pin.sym} 121210 -12930 0 0 {name=p120598 lab=_81304_/CLK }
C {devices/lab_pin.sym} 121210 -12910 0 0 {name=p120599 lab=_81626_/Q }
C {devices/lab_pin.sym} 121390 -12930 0 1 {name=p120600 lab=_81818_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -12920 0 0 {name=X_81818_ }
C {devices/lab_pin.sym} 121210 -12790 0 0 {name=p120601 lab=_88376_/CLK }
C {devices/lab_pin.sym} 121210 -12770 0 0 {name=p120602 lab=_88374_/D }
C {devices/lab_pin.sym} 121390 -12790 0 1 {name=p120603 lab=_88374_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -12780 0 0 {name=X_88374_ }
C {devices/lab_pin.sym} 121260 -12650 0 0 {name=p120604 lab=_42779_/Y }
C {devices/lab_pin.sym} 121340 -12650 0 1 {name=p120605 lab=_87722_/D }
C {sky130_stdcells/inv_2.sym} 121300 -12650 0 0 {name=X_42780_ }
C {devices/lab_pin.sym} 121240 -12560 0 0 {name=p120606 lab=_54775_/A }
C {devices/lab_pin.sym} 121240 -12520 0 0 {name=p120607 lab=_54788_/B }
C {devices/lab_pin.sym} 121240 -12480 0 0 {name=p120608 lab=_54775_/C }
C {devices/lab_pin.sym} 121240 -12440 0 0 {name=p120609 lab=_47486_/A }
C {devices/lab_pin.sym} 121360 -12500 0 1 {name=p120610 lab=_54766_/X }
C {sky130_stdcells/and4_4.sym} 121300 -12500 0 0 {name=X_54766_ }
C {devices/lab_pin.sym} 121210 -12350 0 0 {name=p120611 lab=_83313_/CLK }
C {devices/lab_pin.sym} 121210 -12330 0 0 {name=p120612 lab=_53698_/Y }
C {devices/lab_pin.sym} 121390 -12350 0 1 {name=p120613 lab=_85586_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -12340 0 0 {name=X_85586_ }
C {devices/lab_pin.sym} 121220 -12230 0 0 {name=p120614 lab=_51976_/Y }
C {devices/lab_pin.sym} 121220 -12190 0 0 {name=p120615 lab=_51934_/X }
C {devices/lab_pin.sym} 121220 -12150 0 0 {name=p120616 lab=_51977_/Y }
C {devices/lab_pin.sym} 121380 -12190 0 1 {name=p120617 lab=_51978_/Y }
C {sky130_stdcells/a21boi_4.sym} 121300 -12190 0 0 {name=X_51978_ }
C {devices/lab_pin.sym} 121210 -12050 0 0 {name=p120618 lab=_82425_/CLK }
C {devices/lab_pin.sym} 121210 -12030 0 0 {name=p120619 lab=_82830_/Q }
C {devices/lab_pin.sym} 121390 -12050 0 1 {name=p120620 lab=_82798_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -12040 0 0 {name=X_82798_ }
C {devices/lab_pin.sym} 121240 -11930 0 0 {name=p120621 lab=_56510_/A }
C {devices/lab_pin.sym} 121240 -11890 0 0 {name=p120622 lab=_56507_/B }
C {devices/lab_pin.sym} 121240 -11850 0 0 {name=p120623 lab=_55848_/B }
C {devices/lab_pin.sym} 121360 -11890 0 1 {name=p120624 lab=_56505_/Y }
C {sky130_stdcells/nand3_4.sym} 121300 -11890 0 0 {name=X_56505_ }
C {devices/lab_pin.sym} 121260 -11750 0 0 {name=p120625 lab=_41730_/Y }
C {devices/lab_pin.sym} 121340 -11750 0 1 {name=p120626 lab=_41731_/X }
C {sky130_stdcells/buf_2.sym} 121300 -11750 0 0 {name=X_41731_ }
C {devices/lab_pin.sym} 121260 -11630 0 0 {name=p120627 lab=clkbuf_5_7_0_CLK/A }
C {devices/lab_pin.sym} 121340 -11630 0 1 {name=p120628 lab=clkbuf_5_6_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 121300 -11630 0 0 {name=Xclkbuf_5_6_0_CLK }
C {devices/lab_pin.sym} 121210 -11510 0 0 {name=p120629 lab=_87045_/CLK }
C {devices/lab_pin.sym} 121210 -11490 0 0 {name=p120630 lab=_43654_/X }
C {devices/lab_pin.sym} 121390 -11510 0 1 {name=p120631 lab=_87325_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -11500 0 0 {name=X_87325_ }
C {devices/lab_pin.sym} 121220 -11390 0 0 {name=p120632 lab=_53714_/Y }
C {devices/lab_pin.sym} 121220 -11350 0 0 {name=p120633 lab=_53715_/X }
C {devices/lab_pin.sym} 121220 -11310 0 0 {name=p120634 lab=_53716_/X }
C {devices/lab_pin.sym} 121380 -11350 0 1 {name=p120635 lab=_53717_/Y }
C {sky130_stdcells/a21oi_4.sym} 121300 -11350 0 0 {name=X_53717_ }
C {devices/lab_pin.sym} 121240 -11220 0 0 {name=p120636 lab=_72572_/B }
C {devices/lab_pin.sym} 121240 -11180 0 0 {name=p120637 lab=_65680_/A }
C {devices/lab_pin.sym} 121360 -11200 0 1 {name=p120638 lab=_72551_/X }
C {sky130_stdcells/and2_4.sym} 121300 -11200 0 0 {name=X_72551_ }
C {devices/lab_pin.sym} 121210 -11070 0 0 {name=p120639 lab=_84280_/CLK }
C {devices/lab_pin.sym} 121210 -11050 0 0 {name=p120640 lab=_84537_/D }
C {devices/lab_pin.sym} 121390 -11070 0 1 {name=p120641 lab=_76985_/A }
C {sky130_stdcells/dfxtp_4.sym} 121300 -11060 0 0 {name=X_84537_ }
C {devices/lab_pin.sym} 121260 -10930 0 0 {name=p120642 lab=_50929_/A }
C {devices/lab_pin.sym} 121340 -10930 0 1 {name=p120643 lab=_50941_/B }
C {sky130_stdcells/buf_2.sym} 121300 -10930 0 0 {name=X_50929_ }
C {devices/lab_pin.sym} 121210 -10810 0 0 {name=p120644 lab=_81749_/CLK }
C {devices/lab_pin.sym} 121210 -10790 0 0 {name=p120645 lab=_76061_/B }
C {devices/lab_pin.sym} 121390 -10810 0 1 {name=p120646 lab=_41350_/A }
C {sky130_stdcells/dfxtp_4.sym} 121300 -10800 0 0 {name=X_81749_ }
C {devices/lab_pin.sym} 121240 -10690 0 0 {name=p120647 lab=_57485_/A }
C {devices/lab_pin.sym} 121240 -10650 0 0 {name=p120648 lab=_57485_/B }
C {devices/lab_pin.sym} 121240 -10610 0 0 {name=p120649 lab=_57485_/C }
C {devices/lab_pin.sym} 121360 -10650 0 1 {name=p120650 lab=_57485_/X }
C {sky130_stdcells/and3_4.sym} 121300 -10650 0 0 {name=X_57485_ }
C {devices/lab_pin.sym} 121240 -10520 0 0 {name=p120651 lab=_54682_/A }
C {devices/lab_pin.sym} 121240 -10480 0 0 {name=p120652 lab=_47360_/A }
C {devices/lab_pin.sym} 121360 -10500 0 1 {name=p120653 lab=_54697_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -10500 0 0 {name=X_54697_ }
C {devices/lab_pin.sym} 121240 -10380 0 0 {name=p120654 lab=_59154_/A }
C {devices/lab_pin.sym} 121240 -10340 0 0 {name=p120655 lab=_86351_/Q }
C {devices/lab_pin.sym} 121360 -10360 0 1 {name=p120656 lab=_59224_/Y }
C {sky130_stdcells/nor2_4.sym} 121300 -10360 0 0 {name=X_59224_ }
C {devices/lab_pin.sym} 121240 -10250 0 0 {name=p120657 lab=_71308_/A }
C {devices/lab_pin.sym} 121240 -10210 0 0 {name=p120658 lab=_71777_/B }
C {devices/lab_pin.sym} 121240 -10170 0 0 {name=p120659 lab=_71496_/C }
C {devices/lab_pin.sym} 121360 -10210 0 1 {name=p120660 lab=_71502_/X }
C {sky130_stdcells/and3_4.sym} 121300 -10210 0 0 {name=X_71502_ }
C {devices/lab_pin.sym} 121220 -10110 0 0 {name=p120661 lab=_44447_/X }
C {devices/lab_pin.sym} 121220 -10070 0 0 {name=p120662 lab=_44448_/X }
C {devices/lab_pin.sym} 121220 -10030 0 0 {name=p120663 lab=_41115_/X }
C {devices/lab_pin.sym} 121220 -9990 0 0 {name=p120664 lab=_87103_/Q }
C {devices/lab_pin.sym} 121220 -9950 0 0 {name=p120665 lab=_44449_/X }
C {devices/lab_pin.sym} 121380 -10030 0 1 {name=p120666 lab=_44451_/A }
C {sky130_stdcells/o32ai_4.sym} 121300 -10030 0 0 {name=X_44450_ }
C {devices/lab_pin.sym} 121260 -9870 0 0 {name=p120667 lab=_56436_/A }
C {devices/lab_pin.sym} 121340 -9870 0 1 {name=p120668 lab=_56446_/B }
C {sky130_stdcells/buf_2.sym} 121300 -9870 0 0 {name=X_56436_ }
C {devices/lab_pin.sym} 121260 -9750 0 0 {name=p120669 lab=_75269_/Y }
C {devices/lab_pin.sym} 121340 -9750 0 1 {name=p120670 lab=_75270_/Y }
C {sky130_stdcells/inv_2.sym} 121300 -9750 0 0 {name=X_75270_ }
C {devices/lab_pin.sym} 121210 -9630 0 0 {name=p120671 lab=_87520_/CLK }
C {devices/lab_pin.sym} 121210 -9610 0 0 {name=p120672 lab=_43813_/Y }
C {devices/lab_pin.sym} 121390 -9630 0 1 {name=p120673 lab=_69509_/B }
C {sky130_stdcells/dfxtp_4.sym} 121300 -9620 0 0 {name=X_87256_ }
C {devices/lab_pin.sym} 121220 -9510 0 0 {name=p120674 lab=_41659_/X }
C {devices/lab_pin.sym} 121220 -9470 0 0 {name=p120675 lab=_41314_/A }
C {devices/lab_pin.sym} 121220 -9430 0 0 {name=p120676 lab=_41661_/X }
C {devices/lab_pin.sym} 121380 -9470 0 1 {name=p120677 lab=_41662_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -9470 0 0 {name=X_41662_ }
C {devices/lab_pin.sym} 121220 -9350 0 0 {name=p120678 lab=_85595_/Q }
C {devices/lab_pin.sym} 121220 -9310 0 0 {name=p120679 lab=_53626_/X }
C {devices/lab_pin.sym} 121220 -9270 0 0 {name=p120680 lab=_53647_/Y }
C {devices/lab_pin.sym} 121380 -9310 0 1 {name=p120681 lab=_53648_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -9310 0 0 {name=X_53648_ }
C {devices/lab_pin.sym} 121220 -9190 0 0 {name=p120682 lab=_72479_/Y }
C {devices/lab_pin.sym} 121220 -9150 0 0 {name=p120683 lab=_72481_/Y }
C {devices/lab_pin.sym} 121220 -9110 0 0 {name=p120684 lab=_57779_/X }
C {devices/lab_pin.sym} 121380 -9150 0 1 {name=p120685 lab=_72482_/X }
C {sky130_stdcells/a21o_4.sym} 121300 -9150 0 0 {name=X_72482_ }
C {devices/lab_pin.sym} 121210 -9010 0 0 {name=p120686 lab=_83216_/CLK }
C {devices/lab_pin.sym} 121210 -8990 0 0 {name=p120687 lab=_61588_/X }
C {devices/lab_pin.sym} 121390 -9010 0 1 {name=p120688 lab=_79136_/B }
C {sky130_stdcells/dfxtp_4.sym} 121300 -9000 0 0 {name=X_84468_ }
C {devices/lab_pin.sym} 121260 -8870 0 0 {name=p120689 lab=_43400_/Y }
C {devices/lab_pin.sym} 121340 -8870 0 1 {name=p120690 lab=_87440_/D }
C {sky130_stdcells/inv_2.sym} 121300 -8870 0 0 {name=X_43401_ }
C {devices/lab_pin.sym} 121210 -8750 0 0 {name=p120691 lab=_86203_/CLK }
C {devices/lab_pin.sym} 121210 -8730 0 0 {name=p120692 lab=_86207_/D }
C {devices/lab_pin.sym} 121390 -8750 0 1 {name=p120693 lab=_86207_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -8740 0 0 {name=X_86207_ }
C {devices/lab_pin.sym} 121240 -8620 0 0 {name=p120694 lab=_74211_/Y }
C {devices/lab_pin.sym} 121240 -8580 0 0 {name=p120695 lab=_74221_/B }
C {devices/lab_pin.sym} 121360 -8600 0 1 {name=p120696 lab=_74221_/Y }
C {sky130_stdcells/xnor2_4.sym} 121300 -8600 0 0 {name=X_74221_ }
C {devices/lab_pin.sym} 121220 -8510 0 0 {name=p120697 lab=_40550_/X }
C {devices/lab_pin.sym} 121220 -8470 0 0 {name=p120698 lab=_40556_/X }
C {devices/lab_pin.sym} 121220 -8430 0 0 {name=p120699 lab=_40610_/X }
C {devices/lab_pin.sym} 121220 -8390 0 0 {name=p120700 lab=_68498_/B }
C {devices/lab_pin.sym} 121220 -8350 0 0 {name=p120701 lab=_40612_/X }
C {devices/lab_pin.sym} 121380 -8430 0 1 {name=p120702 lab=_40614_/A }
C {sky130_stdcells/o32ai_4.sym} 121300 -8430 0 0 {name=X_40613_ }
C {devices/lab_pin.sym} 121240 -8280 0 0 {name=p120703 lab=_86677_/Q }
C {devices/lab_pin.sym} 121240 -8240 0 0 {name=p120704 lab=_59189_/B }
C {devices/lab_pin.sym} 121360 -8260 0 1 {name=p120705 lab=_59155_/Y }
C {sky130_stdcells/nor2_4.sym} 121300 -8260 0 0 {name=X_59155_ }
C {devices/lab_pin.sym} 121220 -8150 0 0 {name=p120706 lab=_71420_/X }
C {devices/lab_pin.sym} 121220 -8110 0 0 {name=p120707 lab=_83501_/Q }
C {devices/lab_pin.sym} 121220 -8070 0 0 {name=p120708 lab=_71432_/X }
C {devices/lab_pin.sym} 121380 -8110 0 1 {name=p120709 lab=_71433_/X }
C {sky130_stdcells/a21o_4.sym} 121300 -8110 0 0 {name=X_71433_ }
C {devices/lab_pin.sym} 121210 -7970 0 0 {name=p120710 lab=_83761_/CLK }
C {devices/lab_pin.sym} 121210 -7950 0 0 {name=p120711 lab=_83419_/D }
C {devices/lab_pin.sym} 121390 -7970 0 1 {name=p120712 lab=_58526_/A }
C {sky130_stdcells/dfxtp_4.sym} 121300 -7960 0 0 {name=X_83419_ }
C {devices/lab_pin.sym} 121260 -7830 0 0 {name=p120713 lab=_44381_/A }
C {devices/lab_pin.sym} 121340 -7830 0 1 {name=p120714 lab=_44381_/X }
C {sky130_stdcells/buf_2.sym} 121300 -7830 0 0 {name=X_44381_ }
C {devices/lab_pin.sym} 121240 -7730 0 0 {name=p120715 lab=_56175_/A }
C {devices/lab_pin.sym} 121240 -7690 0 0 {name=p120716 lab=_57223_/D }
C {devices/lab_pin.sym} 121240 -7650 0 0 {name=p120717 lab=_56174_/X }
C {devices/lab_pin.sym} 121360 -7690 0 1 {name=p120718 lab=_56367_/Y }
C {sky130_stdcells/nand3_4.sym} 121300 -7690 0 0 {name=X_56367_ }
C {devices/lab_pin.sym} 121220 -7580 0 0 {name=p120719 lab=_41592_/X }
C {devices/lab_pin.sym} 121220 -7540 0 0 {name=p120720 lab=_41581_/X }
C {devices/lab_pin.sym} 121220 -7500 0 0 {name=p120721 lab=_88186_/Q }
C {devices/lab_pin.sym} 121220 -7460 0 0 {name=p120722 lab=_41582_/X }
C {devices/lab_pin.sym} 121380 -7520 0 1 {name=p120723 lab=_41593_/X }
C {sky130_stdcells/a2bb2o_4.sym} 121300 -7520 0 0 {name=X_41593_ }
C {devices/lab_pin.sym} 121210 -7370 0 0 {name=p120724 lab=_83753_/CLK }
C {devices/lab_pin.sym} 121210 -7350 0 0 {name=p120725 lab=_44138_/Y }
C {devices/lab_pin.sym} 121390 -7370 0 1 {name=p120726 lab=_87187_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -7360 0 0 {name=X_87187_ }
C {devices/lab_pin.sym} 121240 -7240 0 0 {name=p120727 lab=_53565_/A }
C {devices/lab_pin.sym} 121240 -7200 0 0 {name=p120728 lab=_50356_/B }
C {devices/lab_pin.sym} 121360 -7220 0 1 {name=p120729 lab=_53579_/Y }
C {sky130_stdcells/nand2_4.sym} 121300 -7220 0 0 {name=X_53579_ }
C {devices/lab_pin.sym} 121210 -7090 0 0 {name=p120730 lab=_84424_/CLK }
C {devices/lab_pin.sym} 121210 -7070 0 0 {name=p120731 lab=_62584_/Y }
C {devices/lab_pin.sym} 121390 -7090 0 1 {name=p120732 lab=_84399_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -7080 0 0 {name=X_84399_ }
C {devices/lab_pin.sym} 121240 -6970 0 0 {name=p120733 lab=_46120_/A }
C {devices/lab_pin.sym} 121240 -6930 0 0 {name=p120734 lab=_46120_/B }
C {devices/lab_pin.sym} 121240 -6890 0 0 {name=p120735 lab=_41863_/A }
C {devices/lab_pin.sym} 121360 -6930 0 1 {name=p120736 lab=_46120_/Y }
C {sky130_stdcells/nand3_4.sym} 121300 -6930 0 0 {name=X_46120_ }
C {devices/lab_pin.sym} 121220 -6810 0 0 {name=p120737 lab=_58102_/Y }
C {devices/lab_pin.sym} 121220 -6770 0 0 {name=p120738 lab=_58104_/Y }
C {devices/lab_pin.sym} 121220 -6730 0 0 {name=p120739 lab=_58105_/X }
C {devices/lab_pin.sym} 121380 -6770 0 1 {name=p120740 lab=_58106_/X }
C {sky130_stdcells/a21o_4.sym} 121300 -6770 0 0 {name=X_58106_ }
C {devices/lab_pin.sym} 121260 -6630 0 0 {name=p120741 lab=_43332_/A }
C {devices/lab_pin.sym} 121340 -6630 0 1 {name=p120742 lab=_43332_/Y }
C {sky130_stdcells/inv_2.sym} 121300 -6630 0 0 {name=X_43332_ }
C {devices/lab_pin.sym} 121220 -6540 0 0 {name=p120743 lab=_85038_/Q }
C {devices/lab_pin.sym} 121220 -6500 0 0 {name=p120744 lab=_55305_/X }
C {devices/lab_pin.sym} 121220 -6460 0 0 {name=p120745 lab=_55301_/X }
C {devices/lab_pin.sym} 121220 -6420 0 0 {name=p120746 lab=_55317_/X }
C {devices/lab_pin.sym} 121380 -6480 0 1 {name=p120747 lab=_55318_/X }
C {sky130_stdcells/a211o_4.sym} 121300 -6480 0 0 {name=X_55318_ }
C {devices/lab_pin.sym} 121240 -6340 0 0 {name=p120748 lab=_74152_/A }
C {devices/lab_pin.sym} 121240 -6300 0 0 {name=p120749 lab=_86568_/Q }
C {devices/lab_pin.sym} 121360 -6320 0 1 {name=p120750 lab=_74152_/X }
C {sky130_stdcells/and2_4.sym} 121300 -6320 0 0 {name=X_74152_ }
C {devices/lab_pin.sym} 121210 -6190 0 0 {name=p120751 lab=_85529_/CLK }
C {devices/lab_pin.sym} 121210 -6170 0 0 {name=p120752 lab=_86138_/D }
C {devices/lab_pin.sym} 121390 -6190 0 1 {name=p120753 lab=_86138_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -6180 0 0 {name=X_86138_ }
C {devices/lab_pin.sym} 121260 -6050 0 0 {name=p120754 lab=_40509_/X }
C {devices/lab_pin.sym} 121340 -6050 0 1 {name=p120755 lab=_40544_/X }
C {sky130_stdcells/buf_2.sym} 121300 -6050 0 0 {name=X_40544_ }
C {devices/lab_pin.sym} 121220 -5950 0 0 {name=p120756 lab=_71344_/A }
C {devices/lab_pin.sym} 121220 -5910 0 0 {name=p120757 lab=_83524_/Q }
C {devices/lab_pin.sym} 121220 -5870 0 0 {name=p120758 lab=_71363_/X }
C {devices/lab_pin.sym} 121380 -5910 0 1 {name=p120759 lab=_71364_/X }
C {sky130_stdcells/a21o_4.sym} 121300 -5910 0 0 {name=X_71364_ }
C {devices/lab_pin.sym} 121220 -5790 0 0 {name=p120760 lab=_58846_/X }
C {devices/lab_pin.sym} 121220 -5750 0 0 {name=p120761 lab=_85754_/Q }
C {devices/lab_pin.sym} 121220 -5710 0 0 {name=p120762 lab=_58847_/X }
C {devices/lab_pin.sym} 121380 -5750 0 1 {name=p120763 lab=_59086_/X }
C {sky130_stdcells/o21a_4.sym} 121300 -5750 0 0 {name=X_59086_ }
C {devices/lab_pin.sym} 121260 -5610 0 0 {name=p120764 lab=_56245_/A }
C {devices/lab_pin.sym} 121340 -5610 0 1 {name=p120765 lab=_56298_/X }
C {sky130_stdcells/buf_2.sym} 121300 -5610 0 0 {name=X_56298_ }
C {devices/lab_pin.sym} 121220 -5510 0 0 {name=p120766 lab=_83165_/Q }
C {devices/lab_pin.sym} 121220 -5470 0 0 {name=p120767 lab=_73079_/X }
C {devices/lab_pin.sym} 121220 -5430 0 0 {name=p120768 lab=_73102_/Y }
C {devices/lab_pin.sym} 121380 -5470 0 1 {name=p120769 lab=_73103_/X }
C {sky130_stdcells/a21o_4.sym} 121300 -5470 0 0 {name=X_73103_ }
C {devices/lab_pin.sym} 121240 -5360 0 0 {name=p120770 lab=_70328_/A }
C {devices/lab_pin.sym} 121240 -5320 0 0 {name=p120771 lab=_70328_/B }
C {devices/lab_pin.sym} 121240 -5280 0 0 {name=p120772 lab=_70315_/C }
C {devices/lab_pin.sym} 121240 -5240 0 0 {name=p120773 lab=_70328_/D }
C {devices/lab_pin.sym} 121360 -5300 0 1 {name=p120774 lab=_70315_/X }
C {sky130_stdcells/and4_4.sym} 121300 -5300 0 0 {name=X_70315_ }
C {devices/lab_pin.sym} 121260 -5150 0 0 {name=p120775 lab=_46051_/A }
C {devices/lab_pin.sym} 121340 -5150 0 1 {name=p120776 lab=_46051_/Y }
C {sky130_stdcells/inv_2.sym} 121300 -5150 0 0 {name=X_46051_ }
C {devices/lab_pin.sym} 121220 -5060 0 0 {name=p120777 lab=_84931_/Q }
C {devices/lab_pin.sym} 121220 -5020 0 0 {name=p120778 lab=_58025_/X }
C {devices/lab_pin.sym} 121220 -4980 0 0 {name=p120779 lab=_58029_/X }
C {devices/lab_pin.sym} 121220 -4940 0 0 {name=p120780 lab=_58036_/X }
C {devices/lab_pin.sym} 121380 -5000 0 1 {name=p120781 lab=_84931_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 121300 -5000 0 0 {name=X_58037_ }
C {devices/lab_pin.sym} 121220 -4880 0 0 {name=p120782 lab=_41093_/X }
C {devices/lab_pin.sym} 121220 -4840 0 0 {name=p120783 lab=_43247_/X }
C {devices/lab_pin.sym} 121220 -4800 0 0 {name=p120784 lab=_87511_/Q }
C {devices/lab_pin.sym} 121220 -4760 0 0 {name=p120785 lab=_43248_/X }
C {devices/lab_pin.sym} 121380 -4820 0 1 {name=p120786 lab=_87511_/D }
C {sky130_stdcells/a2bb2o_4.sym} 121300 -4820 0 0 {name=X_43263_ }
C {devices/lab_pin.sym} 121220 -4700 0 0 {name=p120787 lab=_57340_/B }
C {devices/lab_pin.sym} 121220 -4660 0 0 {name=p120788 lab=_55126_/X }
C {devices/lab_pin.sym} 121220 -4620 0 0 {name=p120789 lab=_55168_/A }
C {devices/lab_pin.sym} 121220 -4580 0 0 {name=p120790 lab=_55248_/X }
C {devices/lab_pin.sym} 121380 -4640 0 1 {name=p120791 lab=_55249_/X }
C {sky130_stdcells/a211o_4.sym} 121300 -4640 0 0 {name=X_55249_ }
C {devices/lab_pin.sym} 121240 -4500 0 0 {name=p120792 lab=_73497_/A }
C {devices/lab_pin.sym} 121240 -4460 0 0 {name=p120793 lab=_74083_/B }
C {devices/lab_pin.sym} 121360 -4480 0 1 {name=p120794 lab=_74083_/X }
C {sky130_stdcells/and2_4.sym} 121300 -4480 0 0 {name=X_74083_ }
C {devices/lab_pin.sym} 121240 -4360 0 0 {name=p120795 lab=_82787_/D }
C {devices/lab_pin.sym} 121240 -4320 0 0 {name=p120796 lab=_78960_/B }
C {devices/lab_pin.sym} 121360 -4340 0 1 {name=p120797 lab=_78960_/Y }
C {sky130_stdcells/xnor2_4.sym} 121300 -4340 0 0 {name=X_78960_ }
C {devices/lab_pin.sym} 121210 -4210 0 0 {name=p120798 lab=_85751_/CLK }
C {devices/lab_pin.sym} 121210 -4190 0 0 {name=p120799 lab=_51126_/Y }
C {devices/lab_pin.sym} 121390 -4210 0 1 {name=p120800 lab=_86069_/Q }
C {sky130_stdcells/dfxtp_4.sym} 121300 -4200 0 0 {name=X_86069_ }
C {devices/lab_pin.sym} 121220 -4110 0 0 {name=p120801 lab=_40437_/X }
C {devices/lab_pin.sym} 121220 -4070 0 0 {name=p120802 lab=_40443_/X }
C {devices/lab_pin.sym} 121220 -4030 0 0 {name=p120803 lab=_40474_/X }
C {devices/lab_pin.sym} 121220 -3990 0 0 {name=p120804 lab=_88386_/Q }
C {devices/lab_pin.sym} 121220 -3950 0 0 {name=p120805 lab=_40447_/X }
C {devices/lab_pin.sym} 121380 -4030 0 1 {name=p120806 lab=_40475_/Y }
C {sky130_stdcells/o32ai_4.sym} 121300 -4030 0 0 {name=X_40475_ }
C {devices/lab_pin.sym} 121240 -3890 0 0 {name=p120807 lab=_71303_/A }
C {devices/lab_pin.sym} 121240 -3850 0 0 {name=p120808 lab=_71303_/B }
C {devices/lab_pin.sym} 121240 -3810 0 0 {name=p120809 lab=_71672_/C }
C {devices/lab_pin.sym} 121360 -3850 0 1 {name=p120810 lab=_71295_/Y }
C {sky130_stdcells/nand3_4.sym} 121300 -3850 0 0 {name=X_71295_ }
C {devices/lab_pin.sym} 121220 -3730 0 0 {name=p120811 lab=_56392_/C }
C {devices/lab_pin.sym} 121220 -3690 0 0 {name=p120812 lab=_44945_/X }
C {devices/lab_pin.sym} 121220 -3650 0 0 {name=p120813 lab=_45001_/X }
C {devices/lab_pin.sym} 121380 -3690 0 1 {name=p120814 lab=_45002_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -3690 0 0 {name=X_45002_ }
C {devices/lab_pin.sym} 121220 -3590 0 0 {name=p120815 lab=_42205_/X }
C {devices/lab_pin.sym} 121220 -3550 0 0 {name=p120816 lab=_42200_/X }
C {devices/lab_pin.sym} 121220 -3510 0 0 {name=p120817 lab=_41341_/X }
C {devices/lab_pin.sym} 121220 -3470 0 0 {name=p120818 lab=_87977_/Q }
C {devices/lab_pin.sym} 121220 -3430 0 0 {name=p120819 lab=_42201_/X }
C {devices/lab_pin.sym} 121380 -3510 0 1 {name=p120820 lab=_42215_/A }
C {sky130_stdcells/o32ai_4.sym} 121300 -3510 0 0 {name=X_42214_ }
C {devices/lab_pin.sym} 121260 -3350 0 0 {name=p120821 lab=_77900_/Y }
C {devices/lab_pin.sym} 121340 -3350 0 1 {name=p120822 lab=_81941_/D }
C {sky130_stdcells/inv_2.sym} 121300 -3350 0 0 {name=X_77911_ }
C {devices/lab_pin.sym} 121220 -3260 0 0 {name=p120823 lab=_69698_/B }
C {devices/lab_pin.sym} 121220 -3220 0 0 {name=p120824 lab=_73030_/X }
C {devices/lab_pin.sym} 121220 -3180 0 0 {name=p120825 lab=_73031_/X }
C {devices/lab_pin.sym} 121220 -3140 0 0 {name=p120826 lab=_73033_/Y }
C {devices/lab_pin.sym} 121380 -3200 0 1 {name=p120827 lab=_73034_/X }
C {sky130_stdcells/a211o_4.sym} 121300 -3200 0 0 {name=X_73034_ }
C {devices/lab_pin.sym} 121260 -3050 0 0 {name=p120828 lab=_70246_/A }
C {devices/lab_pin.sym} 121340 -3050 0 1 {name=p120829 lab=_70260_/A }
C {sky130_stdcells/buf_2.sym} 121300 -3050 0 0 {name=X_70246_ }
C {devices/lab_pin.sym} 121220 -2970 0 0 {name=p120830 lab=_43162_/X }
C {devices/lab_pin.sym} 121220 -2930 0 0 {name=p120831 lab=_43167_/X }
C {devices/lab_pin.sym} 121220 -2890 0 0 {name=p120832 lab=_40909_/X }
C {devices/lab_pin.sym} 121220 -2850 0 0 {name=p120833 lab=_73440_/A }
C {devices/lab_pin.sym} 121220 -2810 0 0 {name=p120834 lab=_43172_/X }
C {devices/lab_pin.sym} 121380 -2890 0 1 {name=p120835 lab=_43195_/A }
C {sky130_stdcells/o32ai_4.sym} 121300 -2890 0 0 {name=X_43194_ }
C {devices/lab_pin.sym} 121240 -2740 0 0 {name=p120836 lab=_82844_/Q }
C {devices/lab_pin.sym} 121240 -2700 0 0 {name=p120837 lab=_82556_/Q }
C {devices/lab_pin.sym} 121360 -2720 0 1 {name=p120838 lab=_78892_/B }
C {sky130_stdcells/xnor2_4.sym} 121300 -2720 0 0 {name=X_78891_ }
C {devices/lab_pin.sym} 121220 -2610 0 0 {name=p120839 lab=_57971_/B }
C {devices/lab_pin.sym} 121220 -2570 0 0 {name=p120840 lab=_49798_/X }
C {devices/lab_pin.sym} 121220 -2530 0 0 {name=p120841 lab=_49809_/Y }
C {devices/lab_pin.sym} 121380 -2570 0 1 {name=p120842 lab=_49810_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -2570 0 0 {name=X_49810_ }
C {devices/lab_pin.sym} 121260 -2430 0 0 {name=p120843 lab=_84906_/CLK }
C {devices/lab_pin.sym} 121340 -2430 0 1 {name=p120844 lab=_84778_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 121300 -2430 0 0 {name=Xclkbuf_opt_14_CLK }
C {devices/lab_pin.sym} 121220 -2340 0 0 {name=p120845 lab=_41147_/X }
C {devices/lab_pin.sym} 121220 -2300 0 0 {name=p120846 lab=_42137_/X }
C {devices/lab_pin.sym} 121220 -2260 0 0 {name=p120847 lab=_88013_/Q }
C {devices/lab_pin.sym} 121220 -2220 0 0 {name=p120848 lab=_42138_/X }
C {devices/lab_pin.sym} 121380 -2280 0 1 {name=p120849 lab=_42145_/X }
C {sky130_stdcells/a2bb2o_4.sym} 121300 -2280 0 0 {name=X_42145_ }
C {devices/lab_pin.sym} 121240 -2140 0 0 {name=p120850 lab=_77842_/A }
C {devices/lab_pin.sym} 121240 -2100 0 0 {name=p120851 lab=_77841_/Y }
C {devices/lab_pin.sym} 121360 -2120 0 1 {name=p120852 lab=_77843_/B }
C {sky130_stdcells/xor2_4.sym} 121300 -2120 0 0 {name=X_77842_ }
C {devices/lab_pin.sym} 121220 -2010 0 0 {name=p120853 lab=_70169_/X }
C {devices/lab_pin.sym} 121220 -1970 0 0 {name=p120854 lab=_83848_/Q }
C {devices/lab_pin.sym} 121220 -1930 0 0 {name=p120855 lab=_70176_/X }
C {devices/lab_pin.sym} 121380 -1970 0 1 {name=p120856 lab=_83848_/D }
C {sky130_stdcells/a21o_4.sym} 121300 -1970 0 0 {name=X_70177_ }
C {devices/lab_pin.sym} 121220 -1870 0 0 {name=p120857 lab=_62576_/C }
C {devices/lab_pin.sym} 121220 -1830 0 0 {name=p120858 lab=_59950_/B }
C {devices/lab_pin.sym} 121220 -1790 0 0 {name=p120859 lab=_59985_/X }
C {devices/lab_pin.sym} 121220 -1750 0 0 {name=p120860 lab=_59987_/X }
C {devices/lab_pin.sym} 121220 -1720 0 0 {name=p120861 lab=_59512_/A }
C {devices/lab_pin.sym} 121380 -1790 0 1 {name=p120862 lab=_59988_/Y }
C {sky130_stdcells/a41oi_4.sym} 121300 -1790 0 0 {name=X_59988_ }
C {devices/lab_pin.sym} 121260 -1630 0 0 {name=p120863 lab=_49002_/A }
C {devices/lab_pin.sym} 121340 -1630 0 1 {name=p120864 lab=_49825_/A }
C {sky130_stdcells/buf_2.sym} 121300 -1630 0 0 {name=X_49741_ }
C {devices/lab_pin.sym} 121240 -1540 0 0 {name=p120865 lab=_46915_/X }
C {devices/lab_pin.sym} 121240 -1500 0 0 {name=p120866 lab=_46944_/B }
C {devices/lab_pin.sym} 121240 -1460 0 0 {name=p120867 lab=_46981_/C }
C {devices/lab_pin.sym} 121240 -1420 0 0 {name=p120868 lab=_52771_/D }
C {devices/lab_pin.sym} 121360 -1480 0 1 {name=p120869 lab=_46953_/X }
C {sky130_stdcells/and4_4.sym} 121300 -1480 0 0 {name=X_46953_ }
C {devices/lab_pin.sym} 121260 -1330 0 0 {name=p120870 lab=_41878_/A }
C {devices/lab_pin.sym} 121340 -1330 0 1 {name=p120871 lab=_42077_/A }
C {sky130_stdcells/buf_2.sym} 121300 -1330 0 0 {name=X_42076_ }
C {devices/lab_pin.sym} 121260 -1210 0 0 {name=p120872 lab=_58939_/A }
C {devices/lab_pin.sym} 121340 -1210 0 1 {name=p120873 lab=_58939_/X }
C {sky130_stdcells/buf_2.sym} 121300 -1210 0 0 {name=X_58939_ }
C {devices/lab_pin.sym} 121240 -1100 0 0 {name=p120874 lab=_77773_/A }
C {devices/lab_pin.sym} 121240 -1060 0 0 {name=p120875 lab=_77773_/B }
C {devices/lab_pin.sym} 121360 -1080 0 1 {name=p120876 lab=_77774_/B }
C {sky130_stdcells/xnor2_4.sym} 121300 -1080 0 0 {name=X_77773_ }
C {devices/lab_pin.sym} 121240 -960 0 0 {name=p120877 lab=_80949_/Q }
C {devices/lab_pin.sym} 121240 -920 0 0 {name=p120878 lab=_74985_/B }
C {devices/lab_pin.sym} 121360 -940 0 1 {name=p120879 lab=_81198_/D }
C {sky130_stdcells/xor2_4.sym} 121300 -940 0 0 {name=X_74985_ }
C {devices/lab_pin.sym} 121240 -820 0 0 {name=p120880 lab=_79510_/Y }
C {devices/lab_pin.sym} 121240 -780 0 0 {name=p120881 lab=_79512_/B }
C {devices/lab_pin.sym} 121360 -800 0 1 {name=p120882 lab=_79520_/A }
C {sky130_stdcells/nand2_4.sym} 121300 -800 0 0 {name=X_79512_ }
C {devices/lab_pin.sym} 121220 -690 0 0 {name=p120883 lab=_41024_/X }
C {devices/lab_pin.sym} 121220 -650 0 0 {name=p120884 lab=_81713_/Q }
C {devices/lab_pin.sym} 121220 -610 0 0 {name=p120885 lab=_41026_/X }
C {devices/lab_pin.sym} 121380 -650 0 1 {name=p120886 lab=_41027_/Y }
C {sky130_stdcells/o21ai_4.sym} 121300 -650 0 0 {name=X_41027_ }
C {devices/lab_pin.sym} 122180 -42150 0 0 {name=p120887 lab=_72973_/B }
C {devices/lab_pin.sym} 122260 -42150 0 1 {name=p120888 lab=_45904_/X }
C {sky130_stdcells/buf_2.sym} 122220 -42150 0 0 {name=X_45904_ }
C {devices/lab_pin.sym} 122140 -42050 0 0 {name=p120889 lab=_76719_/Y }
C {devices/lab_pin.sym} 122140 -42010 0 0 {name=p120890 lab=_76687_/Y }
C {devices/lab_pin.sym} 122140 -41970 0 0 {name=p120891 lab=_76723_/Y }
C {devices/lab_pin.sym} 122300 -42010 0 1 {name=p120892 lab=_76724_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -42010 0 0 {name=X_76724_ }
C {devices/lab_pin.sym} 122140 -41910 0 0 {name=p120893 lab=_57680_/A }
C {devices/lab_pin.sym} 122140 -41870 0 0 {name=p120894 lab=_61902_/X }
C {devices/lab_pin.sym} 122140 -41830 0 0 {name=p120895 lab=_61916_/X }
C {devices/lab_pin.sym} 122140 -41790 0 0 {name=p120896 lab=_61948_/X }
C {devices/lab_pin.sym} 122140 -41760 0 0 {name=p120897 lab=_61949_/X }
C {devices/lab_pin.sym} 122300 -41830 0 1 {name=p120898 lab=_61950_/X }
C {sky130_stdcells/a41o_4.sym} 122220 -41830 0 0 {name=X_61950_ }
C {devices/lab_pin.sym} 122140 -41690 0 0 {name=p120899 lab=_86344_/Q }
C {devices/lab_pin.sym} 122140 -41650 0 0 {name=p120900 lab=_49660_/X }
C {devices/lab_pin.sym} 122140 -41610 0 0 {name=p120901 lab=_49671_/Y }
C {devices/lab_pin.sym} 122300 -41650 0 1 {name=p120902 lab=_49672_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -41650 0 0 {name=X_49672_ }
C {devices/lab_pin.sym} 122180 -41510 0 0 {name=p120903 lab=_73191_/B }
C {devices/lab_pin.sym} 122260 -41510 0 1 {name=p120904 lab=_74003_/B }
C {sky130_stdcells/buf_2.sym} 122220 -41510 0 0 {name=X_73936_ }
C {devices/lab_pin.sym} 122160 -41420 0 0 {name=p120905 lab=_46868_/A }
C {devices/lab_pin.sym} 122160 -41380 0 0 {name=p120906 lab=_46845_/X }
C {devices/lab_pin.sym} 122160 -41340 0 0 {name=p120907 lab=_46868_/C }
C {devices/lab_pin.sym} 122160 -41300 0 0 {name=p120908 lab=_52730_/D }
C {devices/lab_pin.sym} 122280 -41360 0 1 {name=p120909 lab=_46884_/X }
C {sky130_stdcells/and4_4.sym} 122220 -41360 0 0 {name=X_46884_ }
C {devices/lab_pin.sym} 122160 -41240 0 0 {name=p120910 lab=_60901_/A }
C {devices/lab_pin.sym} 122160 -41200 0 0 {name=p120911 lab=_60901_/B }
C {devices/lab_pin.sym} 122160 -41160 0 0 {name=p120912 lab=_60882_/X }
C {devices/lab_pin.sym} 122160 -41120 0 0 {name=p120913 lab=_60910_/B }
C {devices/lab_pin.sym} 122280 -41180 0 1 {name=p120914 lab=_60901_/X }
C {sky130_stdcells/and4_4.sym} 122220 -41180 0 0 {name=X_60901_ }
C {devices/lab_pin.sym} 122180 -41030 0 0 {name=p120915 lab=_48623_/A }
C {devices/lab_pin.sym} 122260 -41030 0 1 {name=p120916 lab=_48657_/C }
C {sky130_stdcells/buf_2.sym} 122220 -41030 0 0 {name=X_48623_ }
C {devices/lab_pin.sym} 122160 -40920 0 0 {name=p120917 lab=_79459_/A }
C {devices/lab_pin.sym} 122160 -40880 0 0 {name=p120918 lab=_79442_/Y }
C {devices/lab_pin.sym} 122280 -40900 0 1 {name=p120919 lab=_79443_/X }
C {sky130_stdcells/xor2_4.sym} 122220 -40900 0 0 {name=X_79443_ }
C {devices/lab_pin.sym} 122180 -40770 0 0 {name=p120920 lab=clkbuf_7_83_0_CLK/A }
C {devices/lab_pin.sym} 122260 -40770 0 1 {name=p120921 lab=clkbuf_7_83_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 122220 -40770 0 0 {name=Xclkbuf_7_83_0_CLK }
C {devices/lab_pin.sym} 122180 -40650 0 0 {name=p120922 lab=_45835_/A }
C {devices/lab_pin.sym} 122260 -40650 0 1 {name=p120923 lab=_46187_/A }
C {sky130_stdcells/buf_2.sym} 122220 -40650 0 0 {name=X_45835_ }
C {devices/lab_pin.sym} 122180 -40530 0 0 {name=p120924 lab=_81395_/Q }
C {devices/lab_pin.sym} 122260 -40530 0 1 {name=p120925 lab=_76655_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -40530 0 0 {name=X_76655_ }
C {devices/lab_pin.sym} 122180 -40410 0 0 {name=p120926 lab=_61645_/A }
C {devices/lab_pin.sym} 122260 -40410 0 1 {name=p120927 lab=_61881_/X }
C {sky130_stdcells/buf_2.sym} 122220 -40410 0 0 {name=X_61881_ }
C {devices/lab_pin.sym} 122140 -40310 0 0 {name=p120928 lab=_73865_/X }
C {devices/lab_pin.sym} 122140 -40270 0 0 {name=p120929 lab=_73866_/Y }
C {devices/lab_pin.sym} 122140 -40230 0 0 {name=p120930 lab=_73839_/X }
C {devices/lab_pin.sym} 122300 -40270 0 1 {name=p120931 lab=_73867_/X }
C {sky130_stdcells/a21o_4.sym} 122220 -40270 0 0 {name=X_73867_ }
C {devices/lab_pin.sym} 122140 -40170 0 0 {name=p120932 lab=_61579_/B }
C {devices/lab_pin.sym} 122140 -40130 0 0 {name=p120933 lab=_63426_/A }
C {devices/lab_pin.sym} 122140 -40090 0 0 {name=p120934 lab=_63358_/X }
C {devices/lab_pin.sym} 122140 -40050 0 0 {name=p120935 lab=_60767_/X }
C {devices/lab_pin.sym} 122140 -40010 0 0 {name=p120936 lab=_63619_/X }
C {devices/lab_pin.sym} 122300 -40090 0 1 {name=p120937 lab=_63620_/X }
C {sky130_stdcells/a2111o_4.sym} 122220 -40090 0 0 {name=X_63620_ }
C {devices/lab_pin.sym} 122160 -39940 0 0 {name=p120938 lab=_75606_/A }
C {devices/lab_pin.sym} 122160 -39900 0 0 {name=p120939 lab=_80774_/D }
C {devices/lab_pin.sym} 122280 -39920 0 1 {name=p120940 lab=_75640_/A }
C {sky130_stdcells/xnor2_4.sym} 122220 -39920 0 0 {name=X_75606_ }
C {devices/lab_pin.sym} 122160 -39800 0 0 {name=p120941 lab=_81776_/Q }
C {devices/lab_pin.sym} 122160 -39760 0 0 {name=p120942 lab=_48136_/B }
C {devices/lab_pin.sym} 122280 -39780 0 1 {name=p120943 lab=_48554_/X }
C {sky130_stdcells/or2_4.sym} 122220 -39780 0 0 {name=X_48554_ }
C {devices/lab_pin.sym} 122180 -39650 0 0 {name=p120944 lab=_60663_/Y }
C {devices/lab_pin.sym} 122260 -39650 0 1 {name=p120945 lab=_63487_/A }
C {sky130_stdcells/inv_2.sym} 122220 -39650 0 0 {name=X_60832_ }
C {devices/lab_pin.sym} 122140 -39560 0 0 {name=p120946 lab=_72755_/X }
C {devices/lab_pin.sym} 122140 -39520 0 0 {name=p120947 lab=_83079_/Q }
C {devices/lab_pin.sym} 122140 -39480 0 0 {name=p120948 lab=_72785_/X }
C {devices/lab_pin.sym} 122140 -39440 0 0 {name=p120949 lab=_72817_/X }
C {devices/lab_pin.sym} 122300 -39500 0 1 {name=p120950 lab=_72819_/B }
C {sky130_stdcells/a211o_4.sym} 122220 -39500 0 0 {name=X_72818_ }
C {devices/lab_pin.sym} 122160 -39360 0 0 {name=p120951 lab=_79374_/A }
C {devices/lab_pin.sym} 122160 -39320 0 0 {name=p120952 lab=_79373_/Y }
C {devices/lab_pin.sym} 122280 -39340 0 1 {name=p120953 lab=_79374_/X }
C {sky130_stdcells/xor2_4.sym} 122220 -39340 0 0 {name=X_79374_ }
C {devices/lab_pin.sym} 122140 -39230 0 0 {name=p120954 lab=_45748_/X }
C {devices/lab_pin.sym} 122140 -39190 0 0 {name=p120955 lab=_61611_/A }
C {devices/lab_pin.sym} 122140 -39150 0 0 {name=p120956 lab=_45765_/X }
C {devices/lab_pin.sym} 122300 -39190 0 1 {name=p120957 lab=_45766_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -39190 0 0 {name=X_45766_ }
C {devices/lab_pin.sym} 122160 -39060 0 0 {name=p120958 lab=_76585_/Y }
C {devices/lab_pin.sym} 122160 -39020 0 0 {name=p120959 lab=_76546_/X }
C {devices/lab_pin.sym} 122280 -39040 0 1 {name=p120960 lab=_76586_/X }
C {sky130_stdcells/or2_4.sym} 122220 -39040 0 0 {name=X_76586_ }
C {devices/lab_pin.sym} 122180 -38910 0 0 {name=p120961 lab=_42978_/A }
C {devices/lab_pin.sym} 122260 -38910 0 1 {name=p120962 lab=_42978_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -38910 0 0 {name=X_42978_ }
C {devices/lab_pin.sym} 122140 -38820 0 0 {name=p120963 lab=_43055_/Y }
C {devices/lab_pin.sym} 122140 -38780 0 0 {name=p120964 lab=_73627_/X }
C {devices/lab_pin.sym} 122140 -38740 0 0 {name=p120965 lab=_73772_/X }
C {devices/lab_pin.sym} 122140 -38700 0 0 {name=p120966 lab=_73797_/Y }
C {devices/lab_pin.sym} 122300 -38760 0 1 {name=p120967 lab=_73798_/X }
C {sky130_stdcells/a211o_4.sym} 122220 -38760 0 0 {name=X_73798_ }
C {devices/lab_pin.sym} 122180 -38610 0 0 {name=p120968 lab=_47505_/A }
C {devices/lab_pin.sym} 122260 -38610 0 1 {name=p120969 lab=_47506_/A }
C {sky130_stdcells/inv_2.sym} 122220 -38610 0 0 {name=X_47505_ }
C {devices/lab_pin.sym} 122160 -38500 0 0 {name=p120970 lab=_78323_/X }
C {devices/lab_pin.sym} 122160 -38460 0 0 {name=p120971 lab=_78325_/B }
C {devices/lab_pin.sym} 122280 -38480 0 1 {name=p120972 lab=_78325_/X }
C {sky130_stdcells/and2_4.sym} 122220 -38480 0 0 {name=X_78325_ }
C {devices/lab_pin.sym} 122140 -38390 0 0 {name=p120973 lab=_44712_/X }
C {devices/lab_pin.sym} 122140 -38350 0 0 {name=p120974 lab=_44713_/X }
C {devices/lab_pin.sym} 122140 -38310 0 0 {name=p120975 lab=_40691_/X }
C {devices/lab_pin.sym} 122140 -38270 0 0 {name=p120976 lab=_73985_/A }
C {devices/lab_pin.sym} 122140 -38230 0 0 {name=p120977 lab=_44714_/X }
C {devices/lab_pin.sym} 122300 -38310 0 1 {name=p120978 lab=_44718_/A }
C {sky130_stdcells/o32ai_4.sym} 122220 -38310 0 0 {name=X_44717_ }
C {devices/lab_pin.sym} 122140 -38180 0 0 {name=p120979 lab=_61509_/B }
C {devices/lab_pin.sym} 122140 -38140 0 0 {name=p120980 lab=_63548_/X }
C {devices/lab_pin.sym} 122140 -38100 0 0 {name=p120981 lab=_63549_/X }
C {devices/lab_pin.sym} 122140 -38060 0 0 {name=p120982 lab=_63550_/X }
C {devices/lab_pin.sym} 122300 -38120 0 1 {name=p120983 lab=_63551_/X }
C {sky130_stdcells/a211o_4.sym} 122220 -38120 0 0 {name=X_63551_ }
C {devices/lab_pin.sym} 122180 -37970 0 0 {name=p120984 lab=_75536_/X }
C {devices/lab_pin.sym} 122260 -37970 0 1 {name=p120985 lab=_75537_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -37970 0 0 {name=X_75537_ }
C {devices/lab_pin.sym} 122140 -37890 0 0 {name=p120986 lab=_41894_/X }
C {devices/lab_pin.sym} 122140 -37850 0 0 {name=p120987 lab=_41927_/X }
C {devices/lab_pin.sym} 122140 -37810 0 0 {name=p120988 lab=_40661_/X }
C {devices/lab_pin.sym} 122140 -37770 0 0 {name=p120989 lab=_88102_/Q }
C {devices/lab_pin.sym} 122140 -37730 0 0 {name=p120990 lab=_41928_/X }
C {devices/lab_pin.sym} 122300 -37810 0 1 {name=p120991 lab=_41930_/A }
C {sky130_stdcells/o32ai_4.sym} 122220 -37810 0 0 {name=X_41929_ }
C {devices/lab_pin.sym} 122140 -37680 0 0 {name=p120992 lab=_72744_/X }
C {devices/lab_pin.sym} 122140 -37640 0 0 {name=p120993 lab=_86209_/Q }
C {devices/lab_pin.sym} 122140 -37600 0 0 {name=p120994 lab=_72746_/X }
C {devices/lab_pin.sym} 122140 -37560 0 0 {name=p120995 lab=_72748_/X }
C {devices/lab_pin.sym} 122300 -37620 0 1 {name=p120996 lab=_72749_/X }
C {sky130_stdcells/a211o_4.sym} 122220 -37620 0 0 {name=X_72749_ }
C {devices/lab_pin.sym} 122160 -37480 0 0 {name=p120997 lab=_48485_/A }
C {devices/lab_pin.sym} 122160 -37440 0 0 {name=p120998 lab=_48485_/B }
C {devices/lab_pin.sym} 122280 -37460 0 1 {name=p120999 lab=_48485_/Y }
C {sky130_stdcells/nand2_4.sym} 122220 -37460 0 0 {name=X_48485_ }
C {devices/lab_pin.sym} 122160 -37350 0 0 {name=p121000 lab=_60761_/A }
C {devices/lab_pin.sym} 122160 -37310 0 0 {name=p121001 lab=_60761_/B }
C {devices/lab_pin.sym} 122160 -37270 0 0 {name=p121002 lab=_84572_/Q }
C {devices/lab_pin.sym} 122280 -37310 0 1 {name=p121003 lab=_60763_/Y }
C {sky130_stdcells/nor3_4.sym} 122220 -37310 0 0 {name=X_60763_ }
C {devices/lab_pin.sym} 122160 -37180 0 0 {name=p121004 lab=_45697_/A }
C {devices/lab_pin.sym} 122160 -37140 0 0 {name=p121005 lab=_45654_/B }
C {devices/lab_pin.sym} 122280 -37160 0 1 {name=p121006 lab=_45697_/Y }
C {sky130_stdcells/nand2_4.sym} 122220 -37160 0 0 {name=X_45697_ }
C {devices/lab_pin.sym} 122180 -37030 0 0 {name=p121007 lab=clkbuf_7_98_0_CLK/A }
C {devices/lab_pin.sym} 122260 -37030 0 1 {name=p121008 lab=clkbuf_7_98_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 122220 -37030 0 0 {name=Xclkbuf_7_98_0_CLK }
C {devices/lab_pin.sym} 122160 -36940 0 0 {name=p121009 lab=_61572_/A }
C {devices/lab_pin.sym} 122160 -36900 0 0 {name=p121010 lab=_62566_/B }
C {devices/lab_pin.sym} 122160 -36860 0 0 {name=p121011 lab=_62501_/X }
C {devices/lab_pin.sym} 122160 -36820 0 0 {name=p121012 lab=_62566_/D }
C {devices/lab_pin.sym} 122280 -36880 0 1 {name=p121013 lab=_62506_/B }
C {sky130_stdcells/nand4_4.sym} 122220 -36880 0 0 {name=X_62502_ }
C {devices/lab_pin.sym} 122180 -36730 0 0 {name=p121014 lab=_49406_/A }
C {devices/lab_pin.sym} 122260 -36730 0 1 {name=p121015 lab=_47530_/A }
C {sky130_stdcells/buf_2.sym} 122220 -36730 0 0 {name=X_47436_ }
C {devices/lab_pin.sym} 122160 -36620 0 0 {name=p121016 lab=_66237_/X }
C {devices/lab_pin.sym} 122160 -36580 0 0 {name=p121017 lab=_86568_/Q }
C {devices/lab_pin.sym} 122280 -36600 0 1 {name=p121018 lab=_66270_/X }
C {sky130_stdcells/and2_4.sym} 122220 -36600 0 0 {name=X_66270_ }
C {devices/lab_pin.sym} 122160 -36480 0 0 {name=p121019 lab=_78263_/B }
C {devices/lab_pin.sym} 122160 -36440 0 0 {name=p121020 lab=_78256_/B }
C {devices/lab_pin.sym} 122280 -36460 0 1 {name=p121021 lab=_78257_/B }
C {sky130_stdcells/xnor2_4.sym} 122220 -36460 0 0 {name=X_78256_ }
C {devices/lab_pin.sym} 122180 -36330 0 0 {name=p121022 lab=_44618_/A }
C {devices/lab_pin.sym} 122260 -36330 0 1 {name=p121023 lab=_44648_/X }
C {sky130_stdcells/buf_2.sym} 122220 -36330 0 0 {name=X_44648_ }
C {devices/lab_pin.sym} 122160 -36230 0 0 {name=p121024 lab=_63517_/A }
C {devices/lab_pin.sym} 122160 -36190 0 0 {name=p121025 lab=_63517_/B }
C {devices/lab_pin.sym} 122160 -36150 0 0 {name=p121026 lab=_80526_/B }
C {devices/lab_pin.sym} 122280 -36190 0 1 {name=p121027 lab=_63482_/Y }
C {sky130_stdcells/nor3_4.sym} 122220 -36190 0 0 {name=X_63482_ }
C {devices/lab_pin.sym} 122140 -36070 0 0 {name=p121028 lab=_75441_/X }
C {devices/lab_pin.sym} 122140 -36030 0 0 {name=p121029 lab=_75467_/Y }
C {devices/lab_pin.sym} 122140 -35990 0 0 {name=p121030 lab=_75432_/Y }
C {devices/lab_pin.sym} 122300 -36030 0 1 {name=p121031 lab=_75468_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -36030 0 0 {name=X_75468_ }
C {devices/lab_pin.sym} 122160 -35910 0 0 {name=p121032 lab=_63389_/B }
C {devices/lab_pin.sym} 122160 -35870 0 0 {name=p121033 lab=_60694_/B }
C {devices/lab_pin.sym} 122160 -35830 0 0 {name=p121034 lab=_60694_/C }
C {devices/lab_pin.sym} 122280 -35870 0 1 {name=p121035 lab=_60694_/Y }
C {sky130_stdcells/nand3_4.sym} 122220 -35870 0 0 {name=X_60694_ }
C {devices/lab_pin.sym} 122160 -35750 0 0 {name=p121036 lab=_65397_/A }
C {devices/lab_pin.sym} 122160 -35710 0 0 {name=p121037 lab=_65047_/B }
C {devices/lab_pin.sym} 122160 -35670 0 0 {name=p121038 lab=_65221_/C }
C {devices/lab_pin.sym} 122280 -35710 0 1 {name=p121039 lab=_65221_/Y }
C {sky130_stdcells/nor3_4.sym} 122220 -35710 0 0 {name=X_65221_ }
C {devices/lab_pin.sym} 122160 -35580 0 0 {name=p121040 lab=_77200_/X }
C {devices/lab_pin.sym} 122160 -35540 0 0 {name=p121041 lab=_77207_/B }
C {devices/lab_pin.sym} 122280 -35560 0 1 {name=p121042 lab=_77208_/B }
C {sky130_stdcells/xor2_4.sym} 122220 -35560 0 0 {name=X_77207_ }
C {devices/lab_pin.sym} 122180 -35430 0 0 {name=p121043 lab=_62504_/A }
C {devices/lab_pin.sym} 122260 -35430 0 1 {name=p121044 lab=_62492_/B }
C {sky130_stdcells/buf_2.sym} 122220 -35430 0 0 {name=X_62433_ }
C {devices/lab_pin.sym} 122140 -35330 0 0 {name=p121045 lab=_83070_/Q }
C {devices/lab_pin.sym} 122140 -35290 0 0 {name=p121046 lab=_74412_/X }
C {devices/lab_pin.sym} 122140 -35250 0 0 {name=p121047 lab=_74418_/Y }
C {devices/lab_pin.sym} 122300 -35290 0 1 {name=p121048 lab=_74419_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -35290 0 0 {name=X_74419_ }
C {devices/lab_pin.sym} 122180 -35150 0 0 {name=p121049 lab=_47556_/A }
C {devices/lab_pin.sym} 122260 -35150 0 1 {name=p121050 lab=_47408_/B }
C {sky130_stdcells/buf_2.sym} 122220 -35150 0 0 {name=X_47367_ }
C {devices/lab_pin.sym} 122140 -35050 0 0 {name=p121051 lab=_78192_/A }
C {devices/lab_pin.sym} 122140 -35010 0 0 {name=p121052 lab=_78191_/A }
C {devices/lab_pin.sym} 122140 -34970 0 0 {name=p121053 lab=_78186_/Y }
C {devices/lab_pin.sym} 122300 -35010 0 1 {name=p121054 lab=_78188_/B }
C {sky130_stdcells/a21boi_4.sym} 122220 -35010 0 0 {name=X_78187_ }
C {devices/lab_pin.sym} 122140 -34910 0 0 {name=p121055 lab=_44565_/X }
C {devices/lab_pin.sym} 122140 -34870 0 0 {name=p121056 lab=_44567_/X }
C {devices/lab_pin.sym} 122140 -34830 0 0 {name=p121057 lab=_40894_/X }
C {devices/lab_pin.sym} 122140 -34790 0 0 {name=p121058 lab=_73370_/A }
C {devices/lab_pin.sym} 122140 -34750 0 0 {name=p121059 lab=_44568_/X }
C {devices/lab_pin.sym} 122300 -34830 0 1 {name=p121060 lab=_44579_/Y }
C {sky130_stdcells/o32ai_4.sym} 122220 -34830 0 0 {name=X_44579_ }
C {devices/lab_pin.sym} 122180 -34670 0 0 {name=p121061 lab=_75399_/A }
C {devices/lab_pin.sym} 122260 -34670 0 1 {name=p121062 lab=_75399_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -34670 0 0 {name=X_75399_ }
C {devices/lab_pin.sym} 122180 -34550 0 0 {name=p121063 lab=_49106_/A }
C {devices/lab_pin.sym} 122260 -34550 0 1 {name=p121064 lab=_49106_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -34550 0 0 {name=X_49106_ }
C {devices/lab_pin.sym} 122160 -34440 0 0 {name=p121065 lab=_65206_/A }
C {devices/lab_pin.sym} 122160 -34400 0 0 {name=p121066 lab=_65152_/B }
C {devices/lab_pin.sym} 122280 -34420 0 1 {name=p121067 lab=_65152_/X }
C {sky130_stdcells/and2_4.sym} 122220 -34420 0 0 {name=X_65152_ }
C {devices/lab_pin.sym} 122180 -34290 0 0 {name=p121068 lab=_46318_/A }
C {devices/lab_pin.sym} 122260 -34290 0 1 {name=p121069 lab=_48936_/A }
C {sky130_stdcells/inv_2.sym} 122220 -34290 0 0 {name=X_46318_ }
C {devices/lab_pin.sym} 122160 -34180 0 0 {name=p121070 lab=_77135_/Y }
C {devices/lab_pin.sym} 122160 -34140 0 0 {name=p121071 lab=_77138_/B }
C {devices/lab_pin.sym} 122280 -34160 0 1 {name=p121072 lab=_77139_/B }
C {sky130_stdcells/xor2_4.sym} 122220 -34160 0 0 {name=X_77138_ }
C {devices/lab_pin.sym} 122180 -34030 0 0 {name=p121073 lab=_62276_/X }
C {devices/lab_pin.sym} 122260 -34030 0 1 {name=p121074 lab=_62364_/X }
C {sky130_stdcells/buf_2.sym} 122220 -34030 0 0 {name=X_62364_ }
C {devices/lab_pin.sym} 122180 -33910 0 0 {name=p121075 lab=clkbuf_7_21_0_CLK/A }
C {devices/lab_pin.sym} 122260 -33910 0 1 {name=p121076 lab=clkbuf_8_43_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 122220 -33910 0 0 {name=Xclkbuf_7_21_0_CLK }
C {devices/lab_pin.sym} 122180 -33790 0 0 {name=p121077 lab=_47297_/Y }
C {devices/lab_pin.sym} 122260 -33790 0 1 {name=p121078 lab=_52969_/B }
C {sky130_stdcells/buf_2.sym} 122220 -33790 0 0 {name=X_47298_ }
C {devices/lab_pin.sym} 122180 -33670 0 0 {name=p121079 lab=clkbuf_7_80_0_CLK/X }
C {devices/lab_pin.sym} 122260 -33670 0 1 {name=p121080 lab=clkbuf_9_323_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 122220 -33670 0 0 {name=Xclkbuf_8_161_0_CLK }
C {devices/lab_pin.sym} 122140 -33580 0 0 {name=p121081 lab=_58400_/A }
C {devices/lab_pin.sym} 122140 -33540 0 0 {name=p121082 lab=_61003_/Y }
C {devices/lab_pin.sym} 122140 -33500 0 0 {name=p121083 lab=_84834_/Q }
C {devices/lab_pin.sym} 122140 -33460 0 0 {name=p121084 lab=_60963_/X }
C {devices/lab_pin.sym} 122300 -33520 0 1 {name=p121085 lab=_64103_/X }
C {sky130_stdcells/a2bb2o_4.sym} 122220 -33520 0 0 {name=X_64103_ }
C {devices/lab_pin.sym} 122140 -33390 0 0 {name=p121086 lab=_86450_/Q }
C {devices/lab_pin.sym} 122140 -33350 0 0 {name=p121087 lab=_49003_/X }
C {devices/lab_pin.sym} 122140 -33310 0 0 {name=p121088 lab=_49036_/Y }
C {devices/lab_pin.sym} 122300 -33350 0 1 {name=p121089 lab=_49037_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -33350 0 0 {name=X_49037_ }
C {devices/lab_pin.sym} 122160 -33240 0 0 {name=p121090 lab=_61315_/A }
C {devices/lab_pin.sym} 122160 -33200 0 0 {name=p121091 lab=_72550_/A }
C {devices/lab_pin.sym} 122160 -33160 0 0 {name=p121092 lab=_72506_/C }
C {devices/lab_pin.sym} 122160 -33120 0 0 {name=p121093 lab=_72607_/B }
C {devices/lab_pin.sym} 122280 -33180 0 1 {name=p121094 lab=_61315_/Y }
C {sky130_stdcells/nand4_4.sym} 122220 -33180 0 0 {name=X_61315_ }
C {devices/lab_pin.sym} 122180 -33030 0 0 {name=p121095 lab=_46249_/A }
C {devices/lab_pin.sym} 122260 -33030 0 1 {name=p121096 lab=_46279_/A }
C {sky130_stdcells/buf_2.sym} 122220 -33030 0 0 {name=X_46249_ }
C {devices/lab_pin.sym} 122140 -32940 0 0 {name=p121097 lab=_65009_/X }
C {devices/lab_pin.sym} 122140 -32900 0 0 {name=p121098 lab=_86159_/Q }
C {devices/lab_pin.sym} 122140 -32860 0 0 {name=p121099 lab=_64902_/X }
C {devices/lab_pin.sym} 122140 -32820 0 0 {name=p121100 lab=_65082_/X }
C {devices/lab_pin.sym} 122300 -32880 0 1 {name=p121101 lab=_65083_/X }
C {sky130_stdcells/a211o_4.sym} 122220 -32880 0 0 {name=X_65083_ }
C {devices/lab_pin.sym} 122140 -32750 0 0 {name=p121102 lab=_69957_/X }
C {devices/lab_pin.sym} 122140 -32710 0 0 {name=p121103 lab=_69959_/X }
C {devices/lab_pin.sym} 122140 -32670 0 0 {name=p121104 lab=_64629_/A }
C {devices/lab_pin.sym} 122300 -32710 0 1 {name=p121105 lab=_69960_/X }
C {sky130_stdcells/a21o_4.sym} 122220 -32710 0 0 {name=X_69960_ }
C {devices/lab_pin.sym} 122160 -32580 0 0 {name=p121106 lab=_77069_/A }
C {devices/lab_pin.sym} 122160 -32540 0 0 {name=p121107 lab=_82283_/D }
C {devices/lab_pin.sym} 122280 -32560 0 1 {name=p121108 lab=_77069_/Y }
C {sky130_stdcells/nor2_4.sym} 122220 -32560 0 0 {name=X_77069_ }
C {devices/lab_pin.sym} 122160 -32450 0 0 {name=p121109 lab=_62249_/A }
C {devices/lab_pin.sym} 122160 -32410 0 0 {name=p121110 lab=_63424_/B }
C {devices/lab_pin.sym} 122160 -32370 0 0 {name=p121111 lab=_62632_/C }
C {devices/lab_pin.sym} 122280 -32410 0 1 {name=p121112 lab=_62299_/C }
C {sky130_stdcells/nand3_4.sym} 122220 -32410 0 0 {name=X_62295_ }
C {devices/lab_pin.sym} 122160 -32300 0 0 {name=p121113 lab=_61549_/X }
C {devices/lab_pin.sym} 122160 -32260 0 0 {name=p121114 lab=_64052_/B }
C {devices/lab_pin.sym} 122160 -32220 0 0 {name=p121115 lab=_64003_/C }
C {devices/lab_pin.sym} 122160 -32180 0 0 {name=p121116 lab=_64052_/D }
C {devices/lab_pin.sym} 122280 -32240 0 1 {name=p121117 lab=_64034_/Y }
C {sky130_stdcells/nand4_4.sym} 122220 -32240 0 0 {name=X_64034_ }
C {devices/lab_pin.sym} 122140 -32120 0 0 {name=p121118 lab=_41957_/A }
C {devices/lab_pin.sym} 122140 -32080 0 0 {name=p121119 lab=_68384_/X }
C {devices/lab_pin.sym} 122140 -32040 0 0 {name=p121120 lab=_68745_/X }
C {devices/lab_pin.sym} 122140 -32000 0 0 {name=p121121 lab=_68910_/Y }
C {devices/lab_pin.sym} 122300 -32060 0 1 {name=p121122 lab=_68911_/X }
C {sky130_stdcells/a211o_4.sym} 122220 -32060 0 0 {name=X_68911_ }
C {devices/lab_pin.sym} 122140 -31950 0 0 {name=p121123 lab=_60933_/X }
C {devices/lab_pin.sym} 122140 -31910 0 0 {name=p121124 lab=_61254_/B }
C {devices/lab_pin.sym} 122140 -31870 0 0 {name=p121125 lab=_61243_/Y }
C {devices/lab_pin.sym} 122140 -31830 0 0 {name=p121126 lab=_61264_/B }
C {devices/lab_pin.sym} 122140 -31800 0 0 {name=p121127 lab=_61245_/Y }
C {devices/lab_pin.sym} 122300 -31870 0 1 {name=p121128 lab=_84499_/D }
C {sky130_stdcells/a41oi_4.sym} 122220 -31870 0 0 {name=X_61246_ }
C {devices/lab_pin.sym} 122140 -31730 0 0 {name=p121129 lab=_80068_/X }
C {devices/lab_pin.sym} 122140 -31690 0 0 {name=p121130 lab=_80069_/X }
C {devices/lab_pin.sym} 122140 -31650 0 0 {name=p121131 lab=_80079_/Y }
C {devices/lab_pin.sym} 122300 -31690 0 1 {name=p121132 lab=_80080_/Y }
C {sky130_stdcells/a21boi_4.sym} 122220 -31690 0 0 {name=X_80080_ }
C {devices/lab_pin.sym} 122140 -31570 0 0 {name=p121133 lab=_69471_/X }
C {devices/lab_pin.sym} 122140 -31530 0 0 {name=p121134 lab=_69473_/X }
C {devices/lab_pin.sym} 122140 -31490 0 0 {name=p121135 lab=_69816_/X }
C {devices/lab_pin.sym} 122300 -31530 0 1 {name=p121136 lab=_69891_/Y }
C {sky130_stdcells/a21oi_4.sym} 122220 -31530 0 0 {name=X_69891_ }
C {devices/lab_pin.sym} 122180 -31390 0 0 {name=p121137 lab=clkbuf_6_18_0_CLK/X }
C {devices/lab_pin.sym} 122260 -31390 0 1 {name=p121138 lab=clkbuf_8_73_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 122220 -31390 0 0 {name=Xclkbuf_7_36_0_CLK }
C {devices/lab_pin.sym} 122140 -31300 0 0 {name=p121139 lab=_88096_/Q }
C {devices/lab_pin.sym} 122140 -31260 0 0 {name=p121140 lab=_68384_/X }
C {devices/lab_pin.sym} 122140 -31220 0 0 {name=p121141 lab=_68617_/X }
C {devices/lab_pin.sym} 122140 -31180 0 0 {name=p121142 lab=_68841_/Y }
C {devices/lab_pin.sym} 122300 -31240 0 1 {name=p121143 lab=_68842_/X }
C {sky130_stdcells/a211o_4.sym} 122220 -31240 0 0 {name=X_68842_ }
C {devices/lab_pin.sym} 122180 -31090 0 0 {name=p121144 lab=_61071_/A }
C {devices/lab_pin.sym} 122260 -31090 0 1 {name=p121145 lab=_61177_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -31090 0 0 {name=X_61177_ }
C {devices/lab_pin.sym} 122180 -30970 0 0 {name=p121146 lab=clkbuf_7_88_0_CLK/X }
C {devices/lab_pin.sym} 122260 -30970 0 1 {name=p121147 lab=clkbuf_8_176_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 122220 -30970 0 0 {name=Xclkbuf_8_176_0_CLK }
C {devices/lab_pin.sym} 122180 -30850 0 0 {name=p121148 lab=clkbuf_9_85_0_CLK/X }
C {devices/lab_pin.sym} 122260 -30850 0 1 {name=p121149 lab=_80912_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 122220 -30850 0 0 {name=Xclkbuf_10_171_0_CLK }
C {devices/lab_pin.sym} 122180 -30730 0 0 {name=p121150 lab=_62269_/A }
C {devices/lab_pin.sym} 122260 -30730 0 1 {name=p121151 lab=_62194_/A }
C {sky130_stdcells/buf_2.sym} 122220 -30730 0 0 {name=X_60128_ }
C {devices/lab_pin.sym} 122140 -30630 0 0 {name=p121152 lab=_49937_/Y }
C {devices/lab_pin.sym} 122140 -30590 0 0 {name=p121153 lab=_49924_/X }
C {devices/lab_pin.sym} 122140 -30550 0 0 {name=p121154 lab=_49938_/X }
C {devices/lab_pin.sym} 122300 -30590 0 1 {name=p121155 lab=_49939_/Y }
C {sky130_stdcells/a21oi_4.sym} 122220 -30590 0 0 {name=X_49939_ }
C {devices/lab_pin.sym} 122180 -30450 0 0 {name=p121156 lab=_57716_/A }
C {devices/lab_pin.sym} 122260 -30450 0 1 {name=p121157 lab=_68773_/X }
C {sky130_stdcells/buf_2.sym} 122220 -30450 0 0 {name=X_68773_ }
C {devices/lab_pin.sym} 122160 -30350 0 0 {name=p121158 lab=_65507_/X }
C {devices/lab_pin.sym} 122160 -30310 0 0 {name=p121159 lab=_66062_/B }
C {devices/lab_pin.sym} 122160 -30270 0 0 {name=p121160 lab=_65510_/X }
C {devices/lab_pin.sym} 122280 -30310 0 1 {name=p121161 lab=_65985_/Y }
C {sky130_stdcells/nand3_4.sym} 122220 -30310 0 0 {name=X_65985_ }
C {devices/lab_pin.sym} 122160 -30180 0 0 {name=p121162 lab=_67790_/A }
C {devices/lab_pin.sym} 122160 -30140 0 0 {name=p121163 lab=_67724_/B }
C {devices/lab_pin.sym} 122280 -30160 0 1 {name=p121164 lab=_67724_/X }
C {sky130_stdcells/and2_4.sym} 122220 -30160 0 0 {name=X_67724_ }
C {devices/lab_pin.sym} 122140 -30060 0 0 {name=p121165 lab=_64934_/X }
C {devices/lab_pin.sym} 122140 -30020 0 0 {name=p121166 lab=_83301_/Q }
C {devices/lab_pin.sym} 122140 -29980 0 0 {name=p121167 lab=_64864_/X }
C {devices/lab_pin.sym} 122140 -29940 0 0 {name=p121168 lab=_64935_/X }
C {devices/lab_pin.sym} 122300 -30000 0 1 {name=p121169 lab=_64936_/X }
C {sky130_stdcells/a211o_4.sym} 122220 -30000 0 0 {name=X_64936_ }
C {devices/lab_pin.sym} 122160 -29860 0 0 {name=p121170 lab=_52944_/A }
C {devices/lab_pin.sym} 122160 -29820 0 0 {name=p121171 lab=_52950_/B }
C {devices/lab_pin.sym} 122280 -29840 0 1 {name=p121172 lab=_52950_/Y }
C {sky130_stdcells/nand2_4.sym} 122220 -29840 0 0 {name=X_52950_ }
C {devices/lab_pin.sym} 122160 -29730 0 0 {name=p121173 lab=_60059_/A }
C {devices/lab_pin.sym} 122160 -29690 0 0 {name=p121174 lab=_60059_/B }
C {devices/lab_pin.sym} 122160 -29650 0 0 {name=p121175 lab=_60058_/Y }
C {devices/lab_pin.sym} 122280 -29690 0 1 {name=p121176 lab=_60059_/Y }
C {sky130_stdcells/nand3_4.sym} 122220 -29690 0 0 {name=X_60059_ }
C {devices/lab_pin.sym} 122130 -29550 0 0 {name=p121177 lab=_86554_/CLK }
C {devices/lab_pin.sym} 122130 -29530 0 0 {name=p121178 lab=_70451_/Y }
C {devices/lab_pin.sym} 122310 -29550 0 1 {name=p121179 lab=_83770_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -29540 0 0 {name=X_83770_ }
C {devices/lab_pin.sym} 122130 -29410 0 0 {name=p121180 lab=_80776_/CLK }
C {devices/lab_pin.sym} 122130 -29390 0 0 {name=p121181 lab=_80982_/D }
C {devices/lab_pin.sym} 122310 -29410 0 1 {name=p121182 lab=_80938_/D }
C {sky130_stdcells/dfxtp_4.sym} 122220 -29400 0 0 {name=X_80982_ }
C {devices/lab_pin.sym} 122180 -29270 0 0 {name=p121183 lab=clkbuf_8_146_0_CLK/X }
C {devices/lab_pin.sym} 122260 -29270 0 1 {name=p121184 lab=clkbuf_9_292_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 122220 -29270 0 0 {name=Xclkbuf_9_292_0_CLK }
C {devices/lab_pin.sym} 122180 -29150 0 0 {name=p121185 lab=_53269_/A }
C {devices/lab_pin.sym} 122260 -29150 0 1 {name=p121186 lab=_51902_/A }
C {sky130_stdcells/buf_2.sym} 122220 -29150 0 0 {name=X_51901_ }
C {devices/lab_pin.sym} 122130 -29030 0 0 {name=p121187 lab=_82743_/CLK }
C {devices/lab_pin.sym} 122130 -29010 0 0 {name=p121188 lab=_79114_/Y }
C {devices/lab_pin.sym} 122310 -29030 0 1 {name=p121189 lab=_82677_/D }
C {sky130_stdcells/dfxtp_4.sym} 122220 -29020 0 0 {name=X_82721_ }
C {devices/lab_pin.sym} 122140 -28920 0 0 {name=p121190 lab=_87398_/Q }
C {devices/lab_pin.sym} 122140 -28880 0 0 {name=p121191 lab=_67628_/X }
C {devices/lab_pin.sym} 122140 -28840 0 0 {name=p121192 lab=_67581_/X }
C {devices/lab_pin.sym} 122140 -28800 0 0 {name=p121193 lab=_67654_/X }
C {devices/lab_pin.sym} 122300 -28860 0 1 {name=p121194 lab=_67655_/X }
C {sky130_stdcells/a211o_4.sym} 122220 -28860 0 0 {name=X_67655_ }
C {devices/lab_pin.sym} 122160 -28720 0 0 {name=p121195 lab=_52885_/A }
C {devices/lab_pin.sym} 122160 -28680 0 0 {name=p121196 lab=_52881_/B }
C {devices/lab_pin.sym} 122280 -28700 0 1 {name=p121197 lab=_52881_/Y }
C {sky130_stdcells/nand2_4.sym} 122220 -28700 0 0 {name=X_52881_ }
C {devices/lab_pin.sym} 122160 -28590 0 0 {name=p121198 lab=_64862_/X }
C {devices/lab_pin.sym} 122160 -28550 0 0 {name=p121199 lab=_64867_/B }
C {devices/lab_pin.sym} 122160 -28510 0 0 {name=p121200 lab=_64866_/X }
C {devices/lab_pin.sym} 122280 -28550 0 1 {name=p121201 lab=_64867_/Y }
C {sky130_stdcells/nand3_4.sym} 122220 -28550 0 0 {name=X_64867_ }
C {devices/lab_pin.sym} 122180 -28410 0 0 {name=p121202 lab=clkbuf_9_93_0_CLK/X }
C {devices/lab_pin.sym} 122260 -28410 0 1 {name=p121203 lab=_81040_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 122220 -28410 0 0 {name=Xclkbuf_10_186_0_CLK }
C {devices/lab_pin.sym} 122140 -28310 0 0 {name=p121204 lab=_54615_/Y }
C {devices/lab_pin.sym} 122140 -28270 0 0 {name=p121205 lab=_54611_/X }
C {devices/lab_pin.sym} 122140 -28230 0 0 {name=p121206 lab=_54619_/X }
C {devices/lab_pin.sym} 122300 -28270 0 1 {name=p121207 lab=_85409_/D }
C {sky130_stdcells/a21oi_4.sym} 122220 -28270 0 0 {name=X_54620_ }
C {devices/lab_pin.sym} 122180 -28130 0 0 {name=p121208 lab=_66606_/A }
C {devices/lab_pin.sym} 122260 -28130 0 1 {name=p121209 lab=_66606_/X }
C {sky130_stdcells/buf_2.sym} 122220 -28130 0 0 {name=X_66606_ }
C {devices/lab_pin.sym} 122130 -28010 0 0 {name=p121210 lab=_85761_/CLK }
C {devices/lab_pin.sym} 122130 -27990 0 0 {name=p121211 lab=_85440_/D }
C {devices/lab_pin.sym} 122310 -28010 0 1 {name=p121212 lab=_85440_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -28000 0 0 {name=X_85440_ }
C {devices/lab_pin.sym} 122180 -27870 0 0 {name=p121213 lab=_51804_/A }
C {devices/lab_pin.sym} 122260 -27870 0 1 {name=p121214 lab=_51851_/A }
C {sky130_stdcells/buf_2.sym} 122220 -27870 0 0 {name=X_51832_ }
C {devices/lab_pin.sym} 122140 -27770 0 0 {name=p121215 lab=_63816_/X }
C {devices/lab_pin.sym} 122140 -27730 0 0 {name=p121216 lab=_63744_/X }
C {devices/lab_pin.sym} 122140 -27690 0 0 {name=p121217 lab=_63817_/Y }
C {devices/lab_pin.sym} 122300 -27730 0 1 {name=p121218 lab=_84293_/D }
C {sky130_stdcells/a21oi_4.sym} 122220 -27730 0 0 {name=X_63818_ }
C {devices/lab_pin.sym} 122130 -27590 0 0 {name=p121219 lab=_81746_/CLK }
C {devices/lab_pin.sym} 122130 -27570 0 0 {name=p121220 lab=_82652_/D }
C {devices/lab_pin.sym} 122310 -27590 0 1 {name=p121221 lab=_79048_/B }
C {sky130_stdcells/dfxtp_4.sym} 122220 -27580 0 0 {name=X_82652_ }
C {devices/lab_pin.sym} 122160 -27460 0 0 {name=p121222 lab=_67539_/X }
C {devices/lab_pin.sym} 122160 -27420 0 0 {name=p121223 lab=_88233_/Q }
C {devices/lab_pin.sym} 122280 -27440 0 1 {name=p121224 lab=_67586_/X }
C {sky130_stdcells/and2_4.sym} 122220 -27440 0 0 {name=X_67586_ }
C {devices/lab_pin.sym} 122160 -27320 0 0 {name=p121225 lab=_64773_/A }
C {devices/lab_pin.sym} 122160 -27280 0 0 {name=p121226 lab=_64798_/B }
C {devices/lab_pin.sym} 122280 -27300 0 1 {name=p121227 lab=_64798_/X }
C {sky130_stdcells/and2_4.sym} 122220 -27300 0 0 {name=X_64798_ }
C {devices/lab_pin.sym} 122130 -27170 0 0 {name=p121228 lab=_81603_/CLK }
C {devices/lab_pin.sym} 122130 -27150 0 0 {name=p121229 lab=_81603_/D }
C {devices/lab_pin.sym} 122310 -27170 0 1 {name=p121230 lab=_81795_/D }
C {sky130_stdcells/dfxtp_4.sym} 122220 -27160 0 0 {name=X_81603_ }
C {devices/lab_pin.sym} 122180 -27030 0 0 {name=p121231 lab=_68649_/A }
C {devices/lab_pin.sym} 122260 -27030 0 1 {name=p121232 lab=_69325_/X }
C {sky130_stdcells/buf_2.sym} 122220 -27030 0 0 {name=X_69325_ }
C {devices/lab_pin.sym} 122160 -26920 0 0 {name=p121233 lab=_54546_/A }
C {devices/lab_pin.sym} 122160 -26880 0 0 {name=p121234 lab=_53373_/B }
C {devices/lab_pin.sym} 122280 -26900 0 1 {name=p121235 lab=_54551_/Y }
C {sky130_stdcells/nand2_4.sym} 122220 -26900 0 0 {name=X_54551_ }
C {devices/lab_pin.sym} 122180 -26770 0 0 {name=p121236 lab=_68057_/A }
C {devices/lab_pin.sym} 122260 -26770 0 1 {name=p121237 lab=_66642_/A }
C {sky130_stdcells/buf_2.sym} 122220 -26770 0 0 {name=X_66537_ }
C {devices/lab_pin.sym} 122130 -26650 0 0 {name=p121238 lab=_83707_/CLK }
C {devices/lab_pin.sym} 122130 -26630 0 0 {name=p121239 lab=_54826_/Y }
C {devices/lab_pin.sym} 122310 -26650 0 1 {name=p121240 lab=_85371_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -26640 0 0 {name=X_85371_ }
C {devices/lab_pin.sym} 122180 -26510 0 0 {name=p121241 lab=_51789_/A }
C {devices/lab_pin.sym} 122260 -26510 0 1 {name=p121242 lab=_51763_/X }
C {sky130_stdcells/buf_2.sym} 122220 -26510 0 0 {name=X_51763_ }
C {devices/lab_pin.sym} 122180 -26390 0 0 {name=p121243 lab=_63749_/A }
C {devices/lab_pin.sym} 122260 -26390 0 1 {name=p121244 lab=_64177_/B }
C {sky130_stdcells/buf_2.sym} 122220 -26390 0 0 {name=X_63749_ }
C {devices/lab_pin.sym} 122130 -26270 0 0 {name=p121245 lab=_82589_/CLK }
C {devices/lab_pin.sym} 122130 -26250 0 0 {name=p121246 lab=_82615_/Q }
C {devices/lab_pin.sym} 122310 -26270 0 1 {name=p121247 lab=_82583_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -26260 0 0 {name=X_82583_ }
C {devices/lab_pin.sym} 122180 -26130 0 0 {name=p121248 lab=clkbuf_7_57_0_CLK/X }
C {devices/lab_pin.sym} 122260 -26130 0 1 {name=p121249 lab=clkbuf_8_114_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 122220 -26130 0 0 {name=Xclkbuf_8_114_0_CLK }
C {devices/lab_pin.sym} 122130 -26010 0 0 {name=p121250 lab=_87110_/CLK }
C {devices/lab_pin.sym} 122130 -25990 0 0 {name=p121251 lab=_87110_/D }
C {devices/lab_pin.sym} 122310 -26010 0 1 {name=p121252 lab=_87110_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -26000 0 0 {name=X_87110_ }
C {devices/lab_pin.sym} 122140 -25890 0 0 {name=p121253 lab=_85624_/Q }
C {devices/lab_pin.sym} 122140 -25850 0 0 {name=p121254 lab=_53476_/X }
C {devices/lab_pin.sym} 122140 -25810 0 0 {name=p121255 lab=_53501_/Y }
C {devices/lab_pin.sym} 122300 -25850 0 1 {name=p121256 lab=_53502_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -25850 0 0 {name=X_53502_ }
C {devices/lab_pin.sym} 122130 -25710 0 0 {name=p121257 lab=_84321_/CLK }
C {devices/lab_pin.sym} 122130 -25690 0 0 {name=p121258 lab=_84322_/D }
C {devices/lab_pin.sym} 122310 -25710 0 1 {name=p121259 lab=_84322_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -25700 0 0 {name=X_84322_ }
C {devices/lab_pin.sym} 122160 -25580 0 0 {name=p121260 lab=_50695_/A }
C {devices/lab_pin.sym} 122160 -25540 0 0 {name=p121261 lab=_50714_/B }
C {devices/lab_pin.sym} 122280 -25560 0 1 {name=p121262 lab=_50714_/Y }
C {sky130_stdcells/nand2_4.sym} 122220 -25560 0 0 {name=X_50714_ }
C {devices/lab_pin.sym} 122180 -25430 0 0 {name=p121263 lab=_57270_/A }
C {devices/lab_pin.sym} 122260 -25430 0 1 {name=p121264 lab=_57270_/X }
C {sky130_stdcells/buf_2.sym} 122220 -25430 0 0 {name=X_57270_ }
C {devices/lab_pin.sym} 122130 -25310 0 0 {name=p121265 lab=_81703_/CLK }
C {devices/lab_pin.sym} 122130 -25290 0 0 {name=p121266 lab=_81546_/Q }
C {devices/lab_pin.sym} 122310 -25310 0 1 {name=p121267 lab=_76130_/A }
C {sky130_stdcells/dfxtp_4.sym} 122220 -25300 0 0 {name=X_81534_ }
C {devices/lab_pin.sym} 122140 -25190 0 0 {name=p121268 lab=_68579_/X }
C {devices/lab_pin.sym} 122140 -25150 0 0 {name=p121269 lab=_68582_/X }
C {devices/lab_pin.sym} 122140 -25110 0 0 {name=p121270 lab=_69212_/X }
C {devices/lab_pin.sym} 122300 -25150 0 1 {name=p121271 lab=_69256_/Y }
C {sky130_stdcells/a21oi_4.sym} 122220 -25150 0 0 {name=X_69256_ }
C {devices/lab_pin.sym} 122130 -25010 0 0 {name=p121272 lab=_88086_/CLK }
C {devices/lab_pin.sym} 122130 -24990 0 0 {name=p121273 lab=_88090_/D }
C {devices/lab_pin.sym} 122310 -25010 0 1 {name=p121274 lab=_41963_/A }
C {sky130_stdcells/dfxtp_4.sym} 122220 -25000 0 0 {name=X_88090_ }
C {devices/lab_pin.sym} 122180 -24870 0 0 {name=p121275 lab=_54401_/A }
C {devices/lab_pin.sym} 122260 -24870 0 1 {name=p121276 lab=_54483_/C }
C {sky130_stdcells/buf_2.sym} 122220 -24870 0 0 {name=X_54482_ }
C {devices/lab_pin.sym} 122180 -24750 0 0 {name=p121277 lab=_65307_/A }
C {devices/lab_pin.sym} 122260 -24750 0 1 {name=p121278 lab=_66501_/A }
C {sky130_stdcells/buf_2.sym} 122220 -24750 0 0 {name=X_66468_ }
C {devices/lab_pin.sym} 122180 -24630 0 0 {name=p121279 lab=_51694_/A }
C {devices/lab_pin.sym} 122260 -24630 0 1 {name=p121280 lab=_51715_/B }
C {sky130_stdcells/buf_2.sym} 122220 -24630 0 0 {name=X_51694_ }
C {devices/lab_pin.sym} 122160 -24530 0 0 {name=p121281 lab=_56214_/A }
C {devices/lab_pin.sym} 122160 -24490 0 0 {name=p121282 lab=_56229_/B }
C {devices/lab_pin.sym} 122160 -24450 0 0 {name=p121283 lab=_56221_/C }
C {devices/lab_pin.sym} 122280 -24490 0 1 {name=p121284 lab=_56221_/Y }
C {sky130_stdcells/nand3_4.sym} 122220 -24490 0 0 {name=X_56221_ }
C {devices/lab_pin.sym} 122180 -24350 0 0 {name=p121285 lab=_68168_/A }
C {devices/lab_pin.sym} 122260 -24350 0 1 {name=p121286 lab=_68207_/X }
C {sky130_stdcells/buf_2.sym} 122220 -24350 0 0 {name=X_68207_ }
C {devices/lab_pin.sym} 122130 -24230 0 0 {name=p121287 lab=_83139_/CLK }
C {devices/lab_pin.sym} 122130 -24210 0 0 {name=p121288 lab=_44599_/Y }
C {devices/lab_pin.sym} 122310 -24230 0 1 {name=p121289 lab=_87041_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -24220 0 0 {name=X_87041_ }
C {devices/lab_pin.sym} 122180 -24090 0 0 {name=p121290 lab=_54194_/A }
C {devices/lab_pin.sym} 122260 -24090 0 1 {name=p121291 lab=_53434_/A }
C {sky130_stdcells/buf_2.sym} 122220 -24090 0 0 {name=X_53433_ }
C {devices/lab_pin.sym} 122160 -23990 0 0 {name=p121292 lab=_65415_/X }
C {devices/lab_pin.sym} 122160 -23950 0 0 {name=p121293 lab=_65340_/X }
C {devices/lab_pin.sym} 122160 -23910 0 0 {name=p121294 lab=_65418_/X }
C {devices/lab_pin.sym} 122280 -23950 0 1 {name=p121295 lab=_65419_/Y }
C {sky130_stdcells/nand3_4.sym} 122220 -23950 0 0 {name=X_65419_ }
C {devices/lab_pin.sym} 122130 -23810 0 0 {name=p121296 lab=_83766_/CLK }
C {devices/lab_pin.sym} 122130 -23790 0 0 {name=p121297 lab=_64359_/X }
C {devices/lab_pin.sym} 122310 -23810 0 1 {name=p121298 lab=_79755_/B }
C {sky130_stdcells/dfxtp_4.sym} 122220 -23800 0 0 {name=X_84253_ }
C {devices/lab_pin.sym} 122160 -23680 0 0 {name=p121299 lab=_50645_/A }
C {devices/lab_pin.sym} 122160 -23640 0 0 {name=p121300 lab=_50645_/B }
C {devices/lab_pin.sym} 122280 -23660 0 1 {name=p121301 lab=_50645_/X }
C {sky130_stdcells/or2_4.sym} 122220 -23660 0 0 {name=X_50645_ }
C {devices/lab_pin.sym} 122130 -23530 0 0 {name=p121302 lab=_81433_/CLK }
C {devices/lab_pin.sym} 122130 -23510 0 0 {name=p121303 lab=_81465_/D }
C {devices/lab_pin.sym} 122310 -23530 0 1 {name=p121304 lab=_81465_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -23520 0 0 {name=X_81465_ }
C {devices/lab_pin.sym} 122140 -23410 0 0 {name=p121305 lab=_68454_/X }
C {devices/lab_pin.sym} 122140 -23370 0 0 {name=p121306 lab=_68457_/X }
C {devices/lab_pin.sym} 122140 -23330 0 0 {name=p121307 lab=_69061_/X }
C {devices/lab_pin.sym} 122300 -23370 0 1 {name=p121308 lab=_69187_/Y }
C {sky130_stdcells/a21oi_4.sym} 122220 -23370 0 0 {name=X_69187_ }
C {devices/lab_pin.sym} 122140 -23250 0 0 {name=p121309 lab=_66366_/X }
C {devices/lab_pin.sym} 122140 -23210 0 0 {name=p121310 lab=_64800_/Y }
C {devices/lab_pin.sym} 122140 -23170 0 0 {name=p121311 lab=_66398_/Y }
C {devices/lab_pin.sym} 122300 -23210 0 1 {name=p121312 lab=_66399_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -23210 0 0 {name=X_66399_ }
C {devices/lab_pin.sym} 122180 -23070 0 0 {name=p121313 lab=clkbuf_9_230_0_CLK/A }
C {devices/lab_pin.sym} 122260 -23070 0 1 {name=p121314 lab=clkbuf_9_230_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 122220 -23070 0 0 {name=Xclkbuf_9_230_0_CLK }
C {devices/lab_pin.sym} 122130 -22950 0 0 {name=p121315 lab=_83843_/CLK }
C {devices/lab_pin.sym} 122130 -22930 0 0 {name=p121316 lab=_72649_/X }
C {devices/lab_pin.sym} 122310 -22950 0 1 {name=p121317 lab=_70188_/C }
C {sky130_stdcells/dfxtp_4.sym} 122220 -22940 0 0 {name=X_83204_ }
C {devices/lab_pin.sym} 122160 -22820 0 0 {name=p121318 lab=_80416_/A }
C {devices/lab_pin.sym} 122160 -22780 0 0 {name=p121319 lab=_80416_/B }
C {devices/lab_pin.sym} 122280 -22800 0 1 {name=p121320 lab=_80416_/X }
C {sky130_stdcells/or2_4.sym} 122220 -22800 0 0 {name=X_80416_ }
C {devices/lab_pin.sym} 122160 -22680 0 0 {name=p121321 lab=_56127_/B }
C {devices/lab_pin.sym} 122160 -22640 0 0 {name=p121322 lab=_56127_/C }
C {devices/lab_pin.sym} 122280 -22660 0 1 {name=p121323 lab=_56152_/Y }
C {sky130_stdcells/xnor2_4.sym} 122220 -22660 0 0 {name=X_56152_ }
C {devices/lab_pin.sym} 122140 -22560 0 0 {name=p121324 lab=_68121_/X }
C {devices/lab_pin.sym} 122140 -22520 0 0 {name=p121325 lab=_66859_/Y }
C {devices/lab_pin.sym} 122140 -22480 0 0 {name=p121326 lab=_68128_/X }
C {devices/lab_pin.sym} 122140 -22440 0 0 {name=p121327 lab=_68137_/Y }
C {devices/lab_pin.sym} 122300 -22500 0 1 {name=p121328 lab=_68138_/X }
C {sky130_stdcells/a211o_4.sym} 122220 -22500 0 0 {name=X_68138_ }
C {devices/lab_pin.sym} 122160 -22360 0 0 {name=p121329 lab=_53353_/A }
C {devices/lab_pin.sym} 122160 -22320 0 0 {name=p121330 lab=_53364_/B }
C {devices/lab_pin.sym} 122280 -22340 0 1 {name=p121331 lab=_53364_/Y }
C {sky130_stdcells/nand2_4.sym} 122220 -22340 0 0 {name=X_53364_ }
C {devices/lab_pin.sym} 122130 -22210 0 0 {name=p121332 lab=_84194_/CLK }
C {devices/lab_pin.sym} 122130 -22190 0 0 {name=p121333 lab=_84184_/D }
C {devices/lab_pin.sym} 122310 -22210 0 1 {name=p121334 lab=_65698_/C }
C {sky130_stdcells/dfxtp_4.sym} 122220 -22200 0 0 {name=X_84184_ }
C {devices/lab_pin.sym} 122140 -22090 0 0 {name=p121335 lab=_86174_/Q }
C {devices/lab_pin.sym} 122140 -22050 0 0 {name=p121336 lab=_50499_/X }
C {devices/lab_pin.sym} 122140 -22010 0 0 {name=p121337 lab=_50575_/Y }
C {devices/lab_pin.sym} 122300 -22050 0 1 {name=p121338 lab=_50576_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -22050 0 0 {name=X_50576_ }
C {devices/lab_pin.sym} 122130 -21910 0 0 {name=p121339 lab=_83933_/CLK }
C {devices/lab_pin.sym} 122130 -21890 0 0 {name=p121340 lab=_81396_/D }
C {devices/lab_pin.sym} 122310 -21910 0 1 {name=p121341 lab=_76967_/B }
C {sky130_stdcells/dfxtp_4.sym} 122220 -21900 0 0 {name=X_81396_ }
C {devices/lab_pin.sym} 122180 -21770 0 0 {name=p121342 lab=clkbuf_7_64_0_CLK/X }
C {devices/lab_pin.sym} 122260 -21770 0 1 {name=p121343 lab=clkbuf_9_259_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 122220 -21770 0 0 {name=Xclkbuf_8_129_0_CLK }
C {devices/lab_pin.sym} 122180 -21650 0 0 {name=p121344 lab=clkbuf_9_62_0_CLK/X }
C {devices/lab_pin.sym} 122260 -21650 0 1 {name=p121345 lab=_84396_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 122220 -21650 0 0 {name=Xclkbuf_10_124_0_CLK }
C {devices/lab_pin.sym} 122180 -21530 0 0 {name=p121346 lab=_49520_/A }
C {devices/lab_pin.sym} 122260 -21530 0 1 {name=p121347 lab=_55120_/C }
C {sky130_stdcells/buf_2.sym} 122220 -21530 0 0 {name=X_55103_ }
C {devices/lab_pin.sym} 122160 -21420 0 0 {name=p121348 lab=_52295_/A }
C {devices/lab_pin.sym} 122160 -21380 0 0 {name=p121349 lab=_48988_/A }
C {devices/lab_pin.sym} 122280 -21400 0 1 {name=p121350 lab=_52315_/X }
C {sky130_stdcells/and2_4.sym} 122220 -21400 0 0 {name=X_52315_ }
C {devices/lab_pin.sym} 122130 -21270 0 0 {name=p121351 lab=_83141_/CLK }
C {devices/lab_pin.sym} 122130 -21250 0 0 {name=p121352 lab=_83135_/D }
C {devices/lab_pin.sym} 122310 -21270 0 1 {name=p121353 lab=_83135_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -21260 0 0 {name=X_83135_ }
C {devices/lab_pin.sym} 122160 -21150 0 0 {name=p121354 lab=_55993_/Y }
C {devices/lab_pin.sym} 122160 -21110 0 0 {name=p121355 lab=_55994_/X }
C {devices/lab_pin.sym} 122160 -21070 0 0 {name=p121356 lab=_56083_/C }
C {devices/lab_pin.sym} 122280 -21110 0 1 {name=p121357 lab=_56083_/X }
C {sky130_stdcells/and3_4.sym} 122220 -21110 0 0 {name=X_56083_ }
C {devices/lab_pin.sym} 122160 -20980 0 0 {name=p121358 lab=_80347_/A }
C {devices/lab_pin.sym} 122160 -20940 0 0 {name=p121359 lab=_80347_/B }
C {devices/lab_pin.sym} 122280 -20960 0 1 {name=p121360 lab=_80349_/A }
C {sky130_stdcells/xnor2_4.sym} 122220 -20960 0 0 {name=X_80347_ }
C {devices/lab_pin.sym} 122180 -20830 0 0 {name=p121361 lab=_68640_/A }
C {devices/lab_pin.sym} 122260 -20830 0 1 {name=p121362 lab=_68069_/X }
C {sky130_stdcells/buf_2.sym} 122220 -20830 0 0 {name=X_68069_ }
C {devices/lab_pin.sym} 122180 -20710 0 0 {name=p121363 lab=_51900_/A }
C {devices/lab_pin.sym} 122260 -20710 0 1 {name=p121364 lab=_53295_/X }
C {sky130_stdcells/buf_2.sym} 122220 -20710 0 0 {name=X_53295_ }
C {devices/lab_pin.sym} 122180 -20590 0 0 {name=p121365 lab=clkbuf_9_377_0_CLK/X }
C {devices/lab_pin.sym} 122260 -20590 0 1 {name=p121366 lab=_87767_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 122220 -20590 0 0 {name=Xclkbuf_10_754_0_CLK }
C {devices/lab_pin.sym} 122180 -20470 0 0 {name=p121367 lab=_83133_/Q }
C {devices/lab_pin.sym} 122260 -20470 0 1 {name=p121368 lab=_70100_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -20470 0 0 {name=X_70100_ }
C {devices/lab_pin.sym} 122140 -20370 0 0 {name=p121369 lab=_85331_/Q }
C {devices/lab_pin.sym} 122140 -20330 0 0 {name=p121370 lab=_55020_/X }
C {devices/lab_pin.sym} 122140 -20290 0 0 {name=p121371 lab=_55033_/Y }
C {devices/lab_pin.sym} 122300 -20330 0 1 {name=p121372 lab=_55034_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -20330 0 0 {name=X_55034_ }
C {devices/lab_pin.sym} 122180 -20190 0 0 {name=p121373 lab=_59910_/X }
C {devices/lab_pin.sym} 122260 -20190 0 1 {name=p121374 lab=_62501_/A }
C {sky130_stdcells/buf_2.sym} 122220 -20190 0 0 {name=X_59911_ }
C {devices/lab_pin.sym} 122140 -20090 0 0 {name=p121375 lab=_85860_/Q }
C {devices/lab_pin.sym} 122140 -20050 0 0 {name=p121376 lab=_52239_/X }
C {devices/lab_pin.sym} 122140 -20010 0 0 {name=p121377 lab=_52245_/Y }
C {devices/lab_pin.sym} 122300 -20050 0 1 {name=p121378 lab=_52246_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -20050 0 0 {name=X_52246_ }
C {devices/lab_pin.sym} 122160 -19930 0 0 {name=p121379 lab=_71078_/A }
C {devices/lab_pin.sym} 122160 -19890 0 0 {name=p121380 lab=_71080_/B }
C {devices/lab_pin.sym} 122160 -19850 0 0 {name=p121381 lab=_71078_/C }
C {devices/lab_pin.sym} 122280 -19890 0 1 {name=p121382 lab=_71080_/Y }
C {sky130_stdcells/nand3_4.sym} 122220 -19890 0 0 {name=X_71080_ }
C {devices/lab_pin.sym} 122130 -19750 0 0 {name=p121383 lab=_83313_/CLK }
C {devices/lab_pin.sym} 122130 -19730 0 0 {name=p121384 lab=_83066_/D }
C {devices/lab_pin.sym} 122310 -19750 0 1 {name=p121385 lab=_83066_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -19740 0 0 {name=X_83066_ }
C {devices/lab_pin.sym} 122130 -19610 0 0 {name=p121386 lab=_88133_/CLK }
C {devices/lab_pin.sym} 122130 -19590 0 0 {name=p121387 lab=_42281_/Y }
C {devices/lab_pin.sym} 122310 -19610 0 1 {name=p121388 lab=_87943_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -19600 0 0 {name=X_87943_ }
C {devices/lab_pin.sym} 122180 -19470 0 0 {name=p121389 lab=_80277_/B }
C {devices/lab_pin.sym} 122260 -19470 0 1 {name=p121390 lab=_80278_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -19470 0 0 {name=X_80278_ }
C {devices/lab_pin.sym} 122180 -19350 0 0 {name=p121391 lab=clkbuf_9_245_0_CLK/A }
C {devices/lab_pin.sym} 122260 -19350 0 1 {name=p121392 lab=clkbuf_9_245_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 122220 -19350 0 0 {name=Xclkbuf_9_245_0_CLK }
C {devices/lab_pin.sym} 122130 -19230 0 0 {name=p121393 lab=_82047_/CLK }
C {devices/lab_pin.sym} 122130 -19210 0 0 {name=p121394 lab=_82017_/D }
C {devices/lab_pin.sym} 122310 -19230 0 1 {name=p121395 lab=_82017_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -19220 0 0 {name=X_82017_ }
C {devices/lab_pin.sym} 122140 -19120 0 0 {name=p121396 lab=_70011_/X }
C {devices/lab_pin.sym} 122140 -19080 0 0 {name=p121397 lab=_68701_/Y }
C {devices/lab_pin.sym} 122140 -19040 0 0 {name=p121398 lab=_70012_/X }
C {devices/lab_pin.sym} 122140 -19000 0 0 {name=p121399 lab=_70030_/Y }
C {devices/lab_pin.sym} 122300 -19060 0 1 {name=p121400 lab=_70031_/X }
C {sky130_stdcells/a211o_4.sym} 122220 -19060 0 0 {name=X_70031_ }
C {devices/lab_pin.sym} 122180 -18910 0 0 {name=p121401 lab=_59842_/A }
C {devices/lab_pin.sym} 122260 -18910 0 1 {name=p121402 lab=_59855_/A }
C {sky130_stdcells/buf_2.sym} 122220 -18910 0 0 {name=X_59842_ }
C {devices/lab_pin.sym} 122180 -18790 0 0 {name=p121403 lab=_52177_/A }
C {devices/lab_pin.sym} 122260 -18790 0 1 {name=p121404 lab=_52214_/A }
C {sky130_stdcells/buf_2.sym} 122220 -18790 0 0 {name=X_52177_ }
C {devices/lab_pin.sym} 122130 -18670 0 0 {name=p121405 lab=_88387_/CLK }
C {devices/lab_pin.sym} 122130 -18650 0 0 {name=p121406 lab=_42419_/Y }
C {devices/lab_pin.sym} 122310 -18670 0 1 {name=p121407 lab=_87874_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -18660 0 0 {name=X_87874_ }
C {devices/lab_pin.sym} 122180 -18530 0 0 {name=p121408 lab=clkbuf_9_69_0_CLK/X }
C {devices/lab_pin.sym} 122260 -18530 0 1 {name=p121409 lab=_81265_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 122220 -18530 0 0 {name=Xclkbuf_10_139_0_CLK }
C {devices/lab_pin.sym} 122180 -18410 0 0 {name=p121410 lab=_51128_/A }
C {devices/lab_pin.sym} 122260 -18410 0 1 {name=p121411 lab=_51128_/X }
C {sky130_stdcells/buf_2.sym} 122220 -18410 0 0 {name=X_51128_ }
C {devices/lab_pin.sym} 122130 -18290 0 0 {name=p121412 lab=_87073_/CLK }
C {devices/lab_pin.sym} 122130 -18270 0 0 {name=p121413 lab=_45991_/Y }
C {devices/lab_pin.sym} 122310 -18290 0 1 {name=p121414 lab=_86825_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -18280 0 0 {name=X_86825_ }
C {devices/lab_pin.sym} 122180 -18150 0 0 {name=p121415 lab=clkbuf_9_384_0_CLK/X }
C {devices/lab_pin.sym} 122260 -18150 0 1 {name=p121416 lab=_82515_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 122220 -18150 0 0 {name=Xclkbuf_10_769_0_CLK }
C {devices/lab_pin.sym} 122140 -18070 0 0 {name=p121417 lab=_59758_/X }
C {devices/lab_pin.sym} 122140 -18030 0 0 {name=p121418 lab=_59762_/Y }
C {devices/lab_pin.sym} 122140 -17990 0 0 {name=p121419 lab=_59763_/X }
C {devices/lab_pin.sym} 122140 -17950 0 0 {name=p121420 lab=_59768_/Y }
C {devices/lab_pin.sym} 122140 -17920 0 0 {name=p121421 lab=_59772_/Y }
C {devices/lab_pin.sym} 122300 -17990 0 1 {name=p121422 lab=_59773_/X }
C {sky130_stdcells/a41o_4.sym} 122220 -17990 0 0 {name=X_59773_ }
C {devices/lab_pin.sym} 122160 -17860 0 0 {name=p121423 lab=_56684_/B }
C {devices/lab_pin.sym} 122160 -17820 0 0 {name=p121424 lab=_57149_/B }
C {devices/lab_pin.sym} 122160 -17780 0 0 {name=p121425 lab=_57149_/C }
C {devices/lab_pin.sym} 122160 -17740 0 0 {name=p121426 lab=_56985_/D }
C {devices/lab_pin.sym} 122280 -17800 0 1 {name=p121427 lab=_56985_/X }
C {sky130_stdcells/and4_4.sym} 122220 -17800 0 0 {name=X_56985_ }
C {devices/lab_pin.sym} 122140 -17680 0 0 {name=p121428 lab=_58711_/Y }
C {devices/lab_pin.sym} 122140 -17640 0 0 {name=p121429 lab=_58624_/X }
C {devices/lab_pin.sym} 122140 -17600 0 0 {name=p121430 lab=_58719_/X }
C {devices/lab_pin.sym} 122140 -17560 0 0 {name=p121431 lab=_58723_/X }
C {devices/lab_pin.sym} 122300 -17620 0 1 {name=p121432 lab=_84805_/D }
C {sky130_stdcells/a22oi_4.sym} 122220 -17620 0 0 {name=X_58724_ }
C {devices/lab_pin.sym} 122180 -17470 0 0 {name=p121433 lab=_43950_/A }
C {devices/lab_pin.sym} 122260 -17470 0 1 {name=p121434 lab=_43951_/B }
C {sky130_stdcells/inv_2.sym} 122220 -17470 0 0 {name=X_43950_ }
C {devices/lab_pin.sym} 122140 -17370 0 0 {name=p121435 lab=_86081_/Q }
C {devices/lab_pin.sym} 122140 -17330 0 0 {name=p121436 lab=_51047_/X }
C {devices/lab_pin.sym} 122140 -17290 0 0 {name=p121437 lab=_51058_/Y }
C {devices/lab_pin.sym} 122300 -17330 0 1 {name=p121438 lab=_51059_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -17330 0 0 {name=X_51059_ }
C {devices/lab_pin.sym} 122160 -17200 0 0 {name=p121439 lab=_55936_/A }
C {devices/lab_pin.sym} 122160 -17160 0 0 {name=p121440 lab=_55936_/B }
C {devices/lab_pin.sym} 122280 -17180 0 1 {name=p121441 lab=_55937_/A }
C {sky130_stdcells/and2_4.sym} 122220 -17180 0 0 {name=X_55936_ }
C {devices/lab_pin.sym} 122160 -17080 0 0 {name=p121442 lab=_74770_/A }
C {devices/lab_pin.sym} 122160 -17040 0 0 {name=p121443 lab=_74796_/B }
C {devices/lab_pin.sym} 122160 -17000 0 0 {name=p121444 lab=_74797_/C }
C {devices/lab_pin.sym} 122160 -16960 0 0 {name=p121445 lab=_74769_/D }
C {devices/lab_pin.sym} 122280 -17020 0 1 {name=p121446 lab=_74772_/C }
C {sky130_stdcells/nand4_4.sym} 122220 -17020 0 0 {name=X_74770_ }
C {devices/lab_pin.sym} 122130 -16870 0 0 {name=p121447 lab=_81084_/CLK }
C {devices/lab_pin.sym} 122130 -16850 0 0 {name=p121448 lab=_86756_/D }
C {devices/lab_pin.sym} 122310 -16870 0 1 {name=p121449 lab=_42447_/D }
C {sky130_stdcells/dfxtp_4.sym} 122220 -16860 0 0 {name=X_86756_ }
C {devices/lab_pin.sym} 122140 -16750 0 0 {name=p121450 lab=_83308_/Q }
C {devices/lab_pin.sym} 122140 -16710 0 0 {name=p121451 lab=_57615_/X }
C {devices/lab_pin.sym} 122140 -16670 0 0 {name=p121452 lab=_71981_/Y }
C {devices/lab_pin.sym} 122300 -16710 0 1 {name=p121453 lab=_71982_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -16710 0 0 {name=X_71982_ }
C {devices/lab_pin.sym} 122130 -16570 0 0 {name=p121454 lab=_81990_/CLK }
C {devices/lab_pin.sym} 122130 -16550 0 0 {name=p121455 lab=_68611_/X }
C {devices/lab_pin.sym} 122310 -16570 0 1 {name=p121456 lab=_83968_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -16560 0 0 {name=X_83968_ }
C {devices/lab_pin.sym} 122180 -16430 0 0 {name=p121457 lab=_42832_/A }
C {devices/lab_pin.sym} 122260 -16430 0 1 {name=p121458 lab=_42901_/X }
C {sky130_stdcells/buf_2.sym} 122220 -16430 0 0 {name=X_42901_ }
C {devices/lab_pin.sym} 122130 -16310 0 0 {name=p121459 lab=_85704_/CLK }
C {devices/lab_pin.sym} 122130 -16290 0 0 {name=p121460 lab=_53049_/Y }
C {devices/lab_pin.sym} 122310 -16310 0 1 {name=p121461 lab=_85707_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -16300 0 0 {name=X_85707_ }
C {devices/lab_pin.sym} 122140 -16190 0 0 {name=p121462 lab=_73718_/X }
C {devices/lab_pin.sym} 122140 -16150 0 0 {name=p121463 lab=_73719_/Y }
C {devices/lab_pin.sym} 122140 -16110 0 0 {name=p121464 lab=_73720_/X }
C {devices/lab_pin.sym} 122300 -16150 0 1 {name=p121465 lab=_73721_/X }
C {sky130_stdcells/a21o_4.sym} 122220 -16150 0 0 {name=X_73721_ }
C {devices/lab_pin.sym} 122140 -16030 0 0 {name=p121466 lab=_58625_/X }
C {devices/lab_pin.sym} 122140 -15990 0 0 {name=p121467 lab=_85466_/Q }
C {devices/lab_pin.sym} 122140 -15950 0 0 {name=p121468 lab=_58654_/X }
C {devices/lab_pin.sym} 122300 -15990 0 1 {name=p121469 lab=_58655_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -15990 0 0 {name=X_58655_ }
C {devices/lab_pin.sym} 122160 -15860 0 0 {name=p121470 lab=HASH_ADDR[5] }
C {devices/lab_pin.sym} 122160 -15820 0 0 {name=p121471 lab=_70933_/B }
C {devices/lab_pin.sym} 122280 -15840 0 1 {name=p121472 lab=_71093_/C }
C {sky130_stdcells/nor2_4.sym} 122220 -15840 0 0 {name=X_70933_ }
C {devices/lab_pin.sym} 122130 -15710 0 0 {name=p121473 lab=_82923_/CLK }
C {devices/lab_pin.sym} 122130 -15690 0 0 {name=p121474 lab=_78168_/X }
C {devices/lab_pin.sym} 122310 -15710 0 1 {name=p121475 lab=_82919_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -15700 0 0 {name=X_82919_ }
C {devices/lab_pin.sym} 122140 -15600 0 0 {name=p121476 lab=_41282_/X }
C {devices/lab_pin.sym} 122140 -15560 0 0 {name=p121477 lab=_43879_/X }
C {devices/lab_pin.sym} 122140 -15520 0 0 {name=p121478 lab=_69125_/B }
C {devices/lab_pin.sym} 122140 -15480 0 0 {name=p121479 lab=_43880_/X }
C {devices/lab_pin.sym} 122300 -15540 0 1 {name=p121480 lab=_43881_/X }
C {sky130_stdcells/a2bb2o_4.sym} 122220 -15540 0 0 {name=X_43881_ }
C {devices/lab_pin.sym} 122160 -15400 0 0 {name=p121481 lab=_55549_/A }
C {devices/lab_pin.sym} 122160 -15360 0 0 {name=p121482 lab=_56501_/C }
C {devices/lab_pin.sym} 122280 -15380 0 1 {name=p121483 lab=_55867_/X }
C {sky130_stdcells/and2_4.sym} 122220 -15380 0 0 {name=X_55867_ }
C {devices/lab_pin.sym} 122130 -15250 0 0 {name=p121484 lab=_86688_/CLK }
C {devices/lab_pin.sym} 122130 -15230 0 0 {name=p121485 lab=_46945_/Y }
C {devices/lab_pin.sym} 122310 -15250 0 1 {name=p121486 lab=_59019_/A }
C {sky130_stdcells/dfxtp_4.sym} 122220 -15240 0 0 {name=X_86687_ }
C {devices/lab_pin.sym} 122130 -15110 0 0 {name=p121487 lab=_82116_/CLK }
C {devices/lab_pin.sym} 122130 -15090 0 0 {name=p121488 lab=_83899_/D }
C {devices/lab_pin.sym} 122310 -15110 0 1 {name=p121489 lab=_81971_/D }
C {sky130_stdcells/dfxtp_4.sym} 122220 -15100 0 0 {name=X_83899_ }
C {devices/lab_pin.sym} 122140 -14990 0 0 {name=p121490 lab=_85139_/Q }
C {devices/lab_pin.sym} 122140 -14950 0 0 {name=p121491 lab=_45507_/X }
C {devices/lab_pin.sym} 122140 -14910 0 0 {name=p121492 lab=_45429_/X }
C {devices/lab_pin.sym} 122300 -14950 0 1 {name=p121493 lab=_45620_/X }
C {sky130_stdcells/o21a_4.sym} 122220 -14950 0 0 {name=X_45620_ }
C {devices/lab_pin.sym} 122140 -14830 0 0 {name=p121494 lab=_84970_/Q }
C {devices/lab_pin.sym} 122140 -14790 0 0 {name=p121495 lab=_57603_/X }
C {devices/lab_pin.sym} 122140 -14750 0 0 {name=p121496 lab=_57605_/Y }
C {devices/lab_pin.sym} 122300 -14790 0 1 {name=p121497 lab=_57606_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -14790 0 0 {name=X_57606_ }
C {devices/lab_pin.sym} 122160 -14660 0 0 {name=p121498 lab=_76440_/A }
C {devices/lab_pin.sym} 122160 -14620 0 0 {name=p121499 lab=_76439_/X }
C {devices/lab_pin.sym} 122280 -14640 0 1 {name=p121500 lab=_76440_/X }
C {sky130_stdcells/xor2_4.sym} 122220 -14640 0 0 {name=X_76440_ }
C {devices/lab_pin.sym} 122180 -14510 0 0 {name=p121501 lab=_42832_/A }
C {devices/lab_pin.sym} 122260 -14510 0 1 {name=p121502 lab=_42832_/X }
C {sky130_stdcells/buf_2.sym} 122220 -14510 0 0 {name=X_42832_ }
C {devices/lab_pin.sym} 122160 -14400 0 0 {name=p121503 lab=_54823_/A }
C {devices/lab_pin.sym} 122160 -14360 0 0 {name=p121504 lab=_47572_/Y }
C {devices/lab_pin.sym} 122280 -14380 0 1 {name=p121505 lab=_54818_/Y }
C {sky130_stdcells/nand2_4.sym} 122220 -14380 0 0 {name=X_54818_ }
C {devices/lab_pin.sym} 122180 -14250 0 0 {name=p121506 lab=_56934_/X }
C {devices/lab_pin.sym} 122260 -14250 0 1 {name=p121507 lab=_73652_/X }
C {sky130_stdcells/buf_2.sym} 122220 -14250 0 0 {name=X_73652_ }
C {devices/lab_pin.sym} 122130 -14130 0 0 {name=p121508 lab=_86054_/CLK }
C {devices/lab_pin.sym} 122130 -14110 0 0 {name=p121509 lab=_53415_/Y }
C {devices/lab_pin.sym} 122310 -14130 0 1 {name=p121510 lab=_85638_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -14120 0 0 {name=X_85638_ }
C {devices/lab_pin.sym} 122140 -14010 0 0 {name=p121511 lab=_46701_/X }
C {devices/lab_pin.sym} 122140 -13970 0 0 {name=p121512 lab=_70855_/X }
C {devices/lab_pin.sym} 122140 -13930 0 0 {name=p121513 lab=_70863_/Y }
C {devices/lab_pin.sym} 122300 -13970 0 1 {name=p121514 lab=_70864_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -13970 0 0 {name=X_70864_ }
C {devices/lab_pin.sym} 122180 -13830 0 0 {name=p121515 lab=_58080_/A }
C {devices/lab_pin.sym} 122260 -13830 0 1 {name=p121516 lab=_58687_/A }
C {sky130_stdcells/buf_2.sym} 122220 -13830 0 0 {name=X_58586_ }
C {devices/lab_pin.sym} 122140 -13740 0 0 {name=p121517 lab=_83020_/Q }
C {devices/lab_pin.sym} 122140 -13700 0 0 {name=p121518 lab=_55306_/X }
C {devices/lab_pin.sym} 122140 -13660 0 0 {name=p121519 lab=_44095_/X }
C {devices/lab_pin.sym} 122140 -13620 0 0 {name=p121520 lab=_55797_/X }
C {devices/lab_pin.sym} 122300 -13680 0 1 {name=p121521 lab=_55798_/X }
C {sky130_stdcells/a211o_4.sym} 122220 -13680 0 0 {name=X_55798_ }
C {devices/lab_pin.sym} 122140 -13570 0 0 {name=p121522 lab=_72602_/X }
C {devices/lab_pin.sym} 122140 -13530 0 0 {name=p121523 lab=_72562_/A }
C {devices/lab_pin.sym} 122140 -13490 0 0 {name=p121524 lab=_72520_/X }
C {devices/lab_pin.sym} 122140 -13450 0 0 {name=p121525 lab=_83220_/Q }
C {devices/lab_pin.sym} 122140 -13410 0 0 {name=p121526 lab=_59509_/X }
C {devices/lab_pin.sym} 122300 -13490 0 1 {name=p121527 lab=_72603_/X }
C {sky130_stdcells/o32a_4.sym} 122220 -13490 0 0 {name=X_72603_ }
C {devices/lab_pin.sym} 122180 -13330 0 0 {name=p121528 lab=_57401_/B }
C {devices/lab_pin.sym} 122260 -13330 0 1 {name=p121529 lab=_45551_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -13330 0 0 {name=X_45551_ }
C {devices/lab_pin.sym} 122160 -13220 0 0 {name=p121530 lab=_57528_/X }
C {devices/lab_pin.sym} 122160 -13180 0 0 {name=p121531 lab=_57537_/B }
C {devices/lab_pin.sym} 122280 -13200 0 1 {name=p121532 lab=_57537_/Y }
C {sky130_stdcells/nand2_4.sym} 122220 -13200 0 0 {name=X_57537_ }
C {devices/lab_pin.sym} 122160 -13080 0 0 {name=p121533 lab=_76369_/X }
C {devices/lab_pin.sym} 122160 -13040 0 0 {name=p121534 lab=_76370_/Y }
C {devices/lab_pin.sym} 122280 -13060 0 1 {name=p121535 lab=_76371_/X }
C {sky130_stdcells/and2_4.sym} 122220 -13060 0 0 {name=X_76371_ }
C {devices/lab_pin.sym} 122130 -12930 0 0 {name=p121536 lab=_86998_/CLK }
C {devices/lab_pin.sym} 122130 -12910 0 0 {name=p121537 lab=_88357_/D }
C {devices/lab_pin.sym} 122310 -12930 0 1 {name=p121538 lab=_68735_/B }
C {sky130_stdcells/dfxtp_4.sym} 122220 -12920 0 0 {name=X_88357_ }
C {devices/lab_pin.sym} 122140 -12820 0 0 {name=p121539 lab=_41282_/X }
C {devices/lab_pin.sym} 122140 -12780 0 0 {name=p121540 lab=_42757_/X }
C {devices/lab_pin.sym} 122140 -12740 0 0 {name=p121541 lab=_69122_/B }
C {devices/lab_pin.sym} 122140 -12700 0 0 {name=p121542 lab=_42759_/X }
C {devices/lab_pin.sym} 122300 -12760 0 1 {name=p121543 lab=_87732_/D }
C {sky130_stdcells/a2bb2o_4.sym} 122220 -12760 0 0 {name=X_42763_ }
C {devices/lab_pin.sym} 122140 -12630 0 0 {name=p121544 lab=_54746_/Y }
C {devices/lab_pin.sym} 122140 -12590 0 0 {name=p121545 lab=_54747_/X }
C {devices/lab_pin.sym} 122140 -12550 0 0 {name=p121546 lab=_54748_/X }
C {devices/lab_pin.sym} 122300 -12590 0 1 {name=p121547 lab=_54749_/Y }
C {sky130_stdcells/a21oi_4.sym} 122220 -12590 0 0 {name=X_54749_ }
C {devices/lab_pin.sym} 122160 -12460 0 0 {name=p121548 lab=_73583_/A }
C {devices/lab_pin.sym} 122160 -12420 0 0 {name=p121549 lab=_73583_/B }
C {devices/lab_pin.sym} 122280 -12440 0 1 {name=p121550 lab=_73583_/X }
C {sky130_stdcells/and2_4.sym} 122220 -12440 0 0 {name=X_73583_ }
C {devices/lab_pin.sym} 122130 -12310 0 0 {name=p121551 lab=_83564_/CLK }
C {devices/lab_pin.sym} 122130 -12290 0 0 {name=p121552 lab=_53783_/Y }
C {devices/lab_pin.sym} 122310 -12310 0 1 {name=p121553 lab=_85569_/Q }
C {sky130_stdcells/dfxtp_4.sym} 122220 -12300 0 0 {name=X_85569_ }
C {devices/lab_pin.sym} 122180 -12170 0 0 {name=p121554 lab=_70862_/A }
C {devices/lab_pin.sym} 122260 -12170 0 1 {name=p121555 lab=_70841_/D }
C {sky130_stdcells/buf_2.sym} 122220 -12170 0 0 {name=X_70795_ }
C {devices/lab_pin.sym} 122140 -12070 0 0 {name=p121556 lab=_78105_/Y }
C {devices/lab_pin.sym} 122140 -12030 0 0 {name=p121557 lab=_78130_/A }
C {devices/lab_pin.sym} 122140 -11990 0 0 {name=p121558 lab=_78109_/Y }
C {devices/lab_pin.sym} 122300 -12030 0 1 {name=p121559 lab=_78110_/Y }
C {sky130_stdcells/a21boi_4.sym} 122220 -12030 0 0 {name=X_78110_ }
C {devices/lab_pin.sym} 122180 -11890 0 0 {name=p121560 lab=_44602_/A }
C {devices/lab_pin.sym} 122260 -11890 0 1 {name=p121561 lab=_44502_/X }
C {sky130_stdcells/buf_2.sym} 122220 -11890 0 0 {name=X_44502_ }
C {devices/lab_pin.sym} 122160 -11790 0 0 {name=p121562 lab=_75322_/A }
C {devices/lab_pin.sym} 122160 -11750 0 0 {name=p121563 lab=_75318_/X }
C {devices/lab_pin.sym} 122160 -11710 0 0 {name=p121564 lab=_75321_/Y }
C {devices/lab_pin.sym} 122280 -11750 0 1 {name=p121565 lab=_75322_/X }
C {sky130_stdcells/or3_4.sym} 122220 -11750 0 0 {name=X_75322_ }
C {devices/lab_pin.sym} 122130 -11610 0 0 {name=p121566 lab=_83158_/CLK }
C {devices/lab_pin.sym} 122130 -11590 0 0 {name=p121567 lab=_43689_/X }
C {devices/lab_pin.sym} 122310 -11610 0 1 {name=p121568 lab=_72947_/A }
C {sky130_stdcells/dfxtp_4.sym} 122220 -11600 0 0 {name=X_87308_ }
C {devices/lab_pin.sym} 122140 -11490 0 0 {name=p121569 lab=_41659_/X }
C {devices/lab_pin.sym} 122140 -11450 0 0 {name=p121570 lab=_41369_/A }
C {devices/lab_pin.sym} 122140 -11410 0 0 {name=p121571 lab=_41713_/X }
C {devices/lab_pin.sym} 122300 -11450 0 1 {name=p121572 lab=_41715_/A }
C {sky130_stdcells/o21ai_4.sym} 122220 -11450 0 0 {name=X_41714_ }
C {devices/lab_pin.sym} 122140 -11330 0 0 {name=p121573 lab=_48266_/Y }
C {devices/lab_pin.sym} 122140 -11290 0 0 {name=p121574 lab=_48233_/X }
C {devices/lab_pin.sym} 122140 -11250 0 0 {name=p121575 lab=_48269_/X }
C {devices/lab_pin.sym} 122300 -11290 0 1 {name=p121576 lab=_86545_/D }
C {sky130_stdcells/a21oi_4.sym} 122220 -11290 0 0 {name=X_48270_ }
C {devices/lab_pin.sym} 122140 -11170 0 0 {name=p121577 lab=_79476_/B }
C {devices/lab_pin.sym} 122140 -11130 0 0 {name=p121578 lab=_70085_/X }
C {devices/lab_pin.sym} 122140 -11090 0 0 {name=p121579 lab=_72533_/A }
C {devices/lab_pin.sym} 122300 -11130 0 1 {name=p121580 lab=_83238_/D }
C {sky130_stdcells/a21bo_4.sym} 122220 -11130 0 0 {name=X_72534_ }
C {devices/lab_pin.sym} 122180 -10990 0 0 {name=p121581 lab=_79064_/B }
C {devices/lab_pin.sym} 122260 -10990 0 1 {name=p121582 lab=_79090_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -10990 0 0 {name=X_79090_ }
C {devices/lab_pin.sym} 122180 -10870 0 0 {name=p121583 lab=_63066_/B }
C {devices/lab_pin.sym} 122260 -10870 0 1 {name=p121584 lab=_61390_/A }
C {sky130_stdcells/buf_2.sym} 122220 -10870 0 0 {name=X_45482_ }
C {devices/lab_pin.sym} 122160 -10760 0 0 {name=p121585 lab=_57468_/A }
C {devices/lab_pin.sym} 122160 -10720 0 0 {name=p121586 lab=_56551_/X }
C {devices/lab_pin.sym} 122280 -10740 0 1 {name=p121587 lab=_57468_/X }
C {sky130_stdcells/or2_4.sym} 122220 -10740 0 0 {name=X_57468_ }
C {devices/lab_pin.sym} 122180 -10610 0 0 {name=p121588 lab=clkbuf_9_353_0_CLK/X }
C {devices/lab_pin.sym} 122260 -10610 0 1 {name=p121589 lab=_87077_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 122220 -10610 0 0 {name=Xclkbuf_10_707_0_CLK }
C {devices/lab_pin.sym} 122130 -10490 0 0 {name=p121590 lab=_88288_/CLK }
C {devices/lab_pin.sym} 122130 -10470 0 0 {name=p121591 lab=_88288_/D }
C {devices/lab_pin.sym} 122310 -10490 0 1 {name=p121592 lab=_69401_/B }
C {sky130_stdcells/dfxtp_4.sym} 122220 -10480 0 0 {name=X_88288_ }
C {devices/lab_pin.sym} 122140 -10380 0 0 {name=p121593 lab=_41098_/X }
C {devices/lab_pin.sym} 122140 -10340 0 0 {name=p121594 lab=_42679_/X }
C {devices/lab_pin.sym} 122140 -10300 0 0 {name=p121595 lab=_69531_/B }
C {devices/lab_pin.sym} 122140 -10260 0 0 {name=p121596 lab=_42681_/X }
C {devices/lab_pin.sym} 122300 -10320 0 1 {name=p121597 lab=_87766_/D }
C {sky130_stdcells/a2bb2o_4.sym} 122220 -10320 0 0 {name=X_42694_ }
C {devices/lab_pin.sym} 122180 -10170 0 0 {name=p121598 lab=_47221_/A }
C {devices/lab_pin.sym} 122260 -10170 0 1 {name=p121599 lab=_52924_/B }
C {sky130_stdcells/buf_2.sym} 122220 -10170 0 0 {name=X_47221_ }
C {devices/lab_pin.sym} 122140 -10070 0 0 {name=p121600 lab=_59146_/X }
C {devices/lab_pin.sym} 122140 -10030 0 0 {name=p121601 lab=_85424_/Q }
C {devices/lab_pin.sym} 122140 -9990 0 0 {name=p121602 lab=_59206_/X }
C {devices/lab_pin.sym} 122300 -10030 0 1 {name=p121603 lab=_59207_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -10030 0 0 {name=X_59207_ }
C {devices/lab_pin.sym} 122180 -9890 0 0 {name=p121604 lab=_77919_/Y }
C {devices/lab_pin.sym} 122260 -9890 0 1 {name=p121605 lab=_81943_/D }
C {sky130_stdcells/inv_2.sym} 122220 -9890 0 0 {name=X_78041_ }
C {devices/lab_pin.sym} 122140 -9800 0 0 {name=p121606 lab=_41580_/X }
C {devices/lab_pin.sym} 122140 -9760 0 0 {name=p121607 lab=_44431_/X }
C {devices/lab_pin.sym} 122140 -9720 0 0 {name=p121608 lab=_87112_/Q }
C {devices/lab_pin.sym} 122140 -9680 0 0 {name=p121609 lab=_44432_/X }
C {devices/lab_pin.sym} 122300 -9740 0 1 {name=p121610 lab=_44433_/X }
C {sky130_stdcells/a2bb2o_4.sym} 122220 -9740 0 0 {name=X_44433_ }
C {devices/lab_pin.sym} 122140 -9610 0 0 {name=p121611 lab=_56458_/A }
C {devices/lab_pin.sym} 122140 -9570 0 0 {name=p121612 lab=_56094_/X }
C {devices/lab_pin.sym} 122140 -9530 0 0 {name=p121613 lab=_56418_/Y }
C {devices/lab_pin.sym} 122300 -9570 0 1 {name=p121614 lab=_85201_/D }
C {sky130_stdcells/o21ai_4.sym} 122220 -9570 0 0 {name=X_56419_ }
C {devices/lab_pin.sym} 122160 -9440 0 0 {name=p121615 lab=_75251_/Y }
C {devices/lab_pin.sym} 122160 -9400 0 0 {name=p121616 lab=_75252_/Y }
C {devices/lab_pin.sym} 122280 -9420 0 1 {name=p121617 lab=_75261_/A }
C {sky130_stdcells/and2_4.sym} 122220 -9420 0 0 {name=X_75253_ }
C {devices/lab_pin.sym} 122130 -9290 0 0 {name=p121618 lab=_87758_/CLK }
C {devices/lab_pin.sym} 122130 -9270 0 0 {name=p121619 lab=_87239_/D }
C {devices/lab_pin.sym} 122310 -9290 0 1 {name=p121620 lab=_68681_/B }
C {sky130_stdcells/dfxtp_4.sym} 122220 -9280 0 0 {name=X_87239_ }
C {devices/lab_pin.sym} 122160 -9160 0 0 {name=p121621 lab=_82910_/Q }
C {devices/lab_pin.sym} 122160 -9120 0 0 {name=p121622 lab=_41624_/B }
C {devices/lab_pin.sym} 122280 -9140 0 1 {name=p121623 lab=_41645_/X }
C {sky130_stdcells/or2_4.sym} 122220 -9140 0 0 {name=X_41645_ }
C {devices/lab_pin.sym} 122180 -9010 0 0 {name=p121624 lab=_72465_/A }
C {devices/lab_pin.sym} 122260 -9010 0 1 {name=p121625 lab=_72465_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -9010 0 0 {name=X_72465_ }
C {devices/lab_pin.sym} 122140 -8920 0 0 {name=p121626 lab=_57394_/X }
C {devices/lab_pin.sym} 122140 -8880 0 0 {name=p121627 lab=_56619_/X }
C {devices/lab_pin.sym} 122140 -8840 0 0 {name=p121628 lab=_85016_/Q }
C {devices/lab_pin.sym} 122140 -8800 0 0 {name=p121629 lab=_57395_/X }
C {devices/lab_pin.sym} 122300 -8860 0 1 {name=p121630 lab=_85016_/D }
C {sky130_stdcells/a2bb2o_4.sym} 122220 -8860 0 0 {name=X_57399_ }
C {devices/lab_pin.sym} 122160 -8720 0 0 {name=p121631 lab=_74204_/A }
C {devices/lab_pin.sym} 122160 -8680 0 0 {name=p121632 lab=_74095_/B }
C {devices/lab_pin.sym} 122280 -8700 0 1 {name=p121633 lab=_74204_/Y }
C {sky130_stdcells/nor2_4.sym} 122220 -8700 0 0 {name=X_74204_ }
C {devices/lab_pin.sym} 122180 -8570 0 0 {name=p121634 lab=_46961_/X }
C {devices/lab_pin.sym} 122260 -8570 0 1 {name=p121635 lab=_47152_/X }
C {sky130_stdcells/buf_2.sym} 122220 -8570 0 0 {name=X_47152_ }
C {devices/lab_pin.sym} 122140 -8470 0 0 {name=p121636 lab=_59073_/X }
C {devices/lab_pin.sym} 122140 -8430 0 0 {name=p121637 lab=_85750_/Q }
C {devices/lab_pin.sym} 122140 -8390 0 0 {name=p121638 lab=_59124_/X }
C {devices/lab_pin.sym} 122300 -8430 0 1 {name=p121639 lab=_59138_/X }
C {sky130_stdcells/o21a_4.sym} 122220 -8430 0 0 {name=X_59138_ }
C {devices/lab_pin.sym} 122160 -8310 0 0 {name=p121640 lab=_70692_/A }
C {devices/lab_pin.sym} 122160 -8270 0 0 {name=p121641 lab=_71411_/B }
C {devices/lab_pin.sym} 122160 -8230 0 0 {name=p121642 lab=_71450_/C }
C {devices/lab_pin.sym} 122280 -8270 0 1 {name=p121643 lab=_71416_/Y }
C {sky130_stdcells/nor3_4.sym} 122220 -8270 0 0 {name=X_71416_ }
C {devices/lab_pin.sym} 122180 -8130 0 0 {name=p121644 lab=_44363_/X }
C {devices/lab_pin.sym} 122260 -8130 0 1 {name=p121645 lab=_44364_/X }
C {sky130_stdcells/buf_2.sym} 122220 -8130 0 0 {name=X_44364_ }
C {devices/lab_pin.sym} 122160 -8020 0 0 {name=p121646 lab=_80682_/Q }
C {devices/lab_pin.sym} 122160 -7980 0 0 {name=p121647 lab=_80938_/D }
C {devices/lab_pin.sym} 122280 -8000 0 1 {name=p121648 lab=_75186_/A }
C {sky130_stdcells/xor2_4.sym} 122220 -8000 0 0 {name=X_75184_ }
C {devices/lab_pin.sym} 122180 -7870 0 0 {name=p121649 lab=_41576_/A }
C {devices/lab_pin.sym} 122260 -7870 0 1 {name=p121650 lab=_41576_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -7870 0 0 {name=X_41576_ }
C {devices/lab_pin.sym} 122140 -7770 0 0 {name=p121651 lab=_57709_/X }
C {devices/lab_pin.sym} 122140 -7730 0 0 {name=p121652 lab=_85354_/Q }
C {devices/lab_pin.sym} 122140 -7690 0 0 {name=p121653 lab=_72395_/X }
C {devices/lab_pin.sym} 122300 -7730 0 1 {name=p121654 lab=_72396_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -7730 0 0 {name=X_72396_ }
C {devices/lab_pin.sym} 122180 -7590 0 0 {name=p121655 lab=_58981_/A }
C {devices/lab_pin.sym} 122260 -7590 0 1 {name=p121656 lab=_72484_/A }
C {sky130_stdcells/buf_2.sym} 122220 -7590 0 0 {name=X_46103_ }
C {devices/lab_pin.sym} 122140 -7500 0 0 {name=p121657 lab=_41230_/X }
C {devices/lab_pin.sym} 122140 -7460 0 0 {name=p121658 lab=_43300_/X }
C {devices/lab_pin.sym} 122140 -7420 0 0 {name=p121659 lab=_87485_/Q }
C {devices/lab_pin.sym} 122140 -7380 0 0 {name=p121660 lab=_43302_/X }
C {devices/lab_pin.sym} 122300 -7440 0 1 {name=p121661 lab=_43315_/X }
C {sky130_stdcells/a2bb2o_4.sym} 122220 -7440 0 0 {name=X_43315_ }
C {devices/lab_pin.sym} 122160 -7300 0 0 {name=p121662 lab=_48081_/Y }
C {devices/lab_pin.sym} 122160 -7260 0 0 {name=p121663 lab=_74135_/B }
C {devices/lab_pin.sym} 122280 -7280 0 1 {name=p121664 lab=_74136_/B }
C {sky130_stdcells/xor2_4.sym} 122220 -7280 0 0 {name=X_74135_ }
C {devices/lab_pin.sym} 122140 -7170 0 0 {name=p121665 lab=_40463_/X }
C {devices/lab_pin.sym} 122140 -7130 0 0 {name=p121666 lab=_81158_/Q }
C {devices/lab_pin.sym} 122140 -7090 0 0 {name=p121667 lab=_40526_/X }
C {devices/lab_pin.sym} 122300 -7130 0 1 {name=p121668 lab=_40527_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -7130 0 0 {name=X_40527_ }
C {devices/lab_pin.sym} 122180 -6990 0 0 {name=p121669 lab=_47083_/A }
C {devices/lab_pin.sym} 122260 -6990 0 1 {name=p121670 lab=_47084_/A }
C {sky130_stdcells/inv_2.sym} 122220 -6990 0 0 {name=X_47083_ }
C {devices/lab_pin.sym} 122140 -6910 0 0 {name=p121671 lab=_59027_/X }
C {devices/lab_pin.sym} 122140 -6870 0 0 {name=p121672 lab=_59066_/Y }
C {devices/lab_pin.sym} 122140 -6830 0 0 {name=p121673 lab=_59068_/Y }
C {devices/lab_pin.sym} 122140 -6790 0 0 {name=p121674 lab=_59046_/X }
C {devices/lab_pin.sym} 122140 -6750 0 0 {name=p121675 lab=_59031_/X }
C {devices/lab_pin.sym} 122300 -6830 0 1 {name=p121676 lab=_59069_/X }
C {sky130_stdcells/o32a_4.sym} 122220 -6830 0 0 {name=X_59069_ }
C {devices/lab_pin.sym} 122180 -6670 0 0 {name=p121677 lab=DATA_TO_HASH[7] }
C {devices/lab_pin.sym} 122260 -6670 0 1 {name=p121678 lab=_71422_/C }
C {sky130_stdcells/buf_2.sym} 122220 -6670 0 0 {name=X_71347_ }
C {devices/lab_pin.sym} 122140 -6570 0 0 {name=p121679 lab=_44293_/Y }
C {devices/lab_pin.sym} 122140 -6530 0 0 {name=p121680 lab=_44294_/X }
C {devices/lab_pin.sym} 122140 -6490 0 0 {name=p121681 lab=_44277_/X }
C {devices/lab_pin.sym} 122300 -6530 0 1 {name=p121682 lab=_44295_/Y }
C {sky130_stdcells/a21oi_4.sym} 122220 -6530 0 0 {name=X_44295_ }
C {devices/lab_pin.sym} 122140 -6410 0 0 {name=p121683 lab=_79965_/Y }
C {devices/lab_pin.sym} 122140 -6370 0 0 {name=p121684 lab=_79990_/Y }
C {devices/lab_pin.sym} 122140 -6330 0 0 {name=p121685 lab=_79991_/Y }
C {devices/lab_pin.sym} 122300 -6370 0 1 {name=p121686 lab=_79992_/Y }
C {sky130_stdcells/a21oi_4.sym} 122220 -6370 0 0 {name=X_79992_ }
C {devices/lab_pin.sym} 122180 -6230 0 0 {name=p121687 lab=_61122_/A }
C {devices/lab_pin.sym} 122260 -6230 0 1 {name=p121688 lab=_61101_/A }
C {sky130_stdcells/inv_2.sym} 122220 -6230 0 0 {name=X_61100_ }
C {devices/lab_pin.sym} 122180 -6110 0 0 {name=p121689 lab=_46034_/A }
C {devices/lab_pin.sym} 122260 -6110 0 1 {name=p121690 lab=_46034_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -6110 0 0 {name=X_46034_ }
C {devices/lab_pin.sym} 122180 -5990 0 0 {name=p121691 lab=_43246_/A }
C {devices/lab_pin.sym} 122260 -5990 0 1 {name=p121692 lab=_43246_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -5990 0 0 {name=X_43246_ }
C {devices/lab_pin.sym} 122160 -5880 0 0 {name=p121693 lab=_48051_/Y }
C {devices/lab_pin.sym} 122160 -5840 0 0 {name=p121694 lab=_74066_/B }
C {devices/lab_pin.sym} 122280 -5860 0 1 {name=p121695 lab=_74066_/X }
C {sky130_stdcells/xor2_4.sym} 122220 -5860 0 0 {name=X_74066_ }
C {devices/lab_pin.sym} 122140 -5750 0 0 {name=p121696 lab=_62078_/Y }
C {devices/lab_pin.sym} 122140 -5710 0 0 {name=p121697 lab=_62033_/X }
C {devices/lab_pin.sym} 122140 -5670 0 0 {name=p121698 lab=_62079_/Y }
C {devices/lab_pin.sym} 122300 -5710 0 1 {name=p121699 lab=_62080_/Y }
C {sky130_stdcells/a21oi_4.sym} 122220 -5710 0 0 {name=X_62080_ }
C {devices/lab_pin.sym} 122180 -5570 0 0 {name=p121700 lab=_78930_/B }
C {devices/lab_pin.sym} 122260 -5570 0 1 {name=p121701 lab=_82512_/D }
C {sky130_stdcells/inv_2.sym} 122220 -5570 0 0 {name=X_78943_ }
C {devices/lab_pin.sym} 122140 -5470 0 0 {name=p121702 lab=_40456_/X }
C {devices/lab_pin.sym} 122140 -5430 0 0 {name=p121703 lab=_81170_/Q }
C {devices/lab_pin.sym} 122140 -5390 0 0 {name=p121704 lab=_40457_/X }
C {devices/lab_pin.sym} 122300 -5430 0 1 {name=p121705 lab=_40458_/X }
C {sky130_stdcells/o21a_4.sym} 122220 -5430 0 0 {name=X_40458_ }
C {devices/lab_pin.sym} 122180 -5290 0 0 {name=p121706 lab=_71026_/A }
C {devices/lab_pin.sym} 122260 -5290 0 1 {name=p121707 lab=_71279_/C }
C {sky130_stdcells/buf_2.sym} 122220 -5290 0 0 {name=X_71278_ }
C {devices/lab_pin.sym} 122140 -5210 0 0 {name=p121708 lab=_60953_/X }
C {devices/lab_pin.sym} 122140 -5170 0 0 {name=p121709 lab=_61030_/Y }
C {devices/lab_pin.sym} 122140 -5130 0 0 {name=p121710 lab=_61010_/Y }
C {devices/lab_pin.sym} 122140 -5090 0 0 {name=p121711 lab=_76983_/A }
C {devices/lab_pin.sym} 122140 -5050 0 0 {name=p121712 lab=_61020_/X }
C {devices/lab_pin.sym} 122300 -5130 0 1 {name=p121713 lab=_84535_/D }
C {sky130_stdcells/o32a_4.sym} 122220 -5130 0 0 {name=X_61031_ }
C {devices/lab_pin.sym} 122140 -5000 0 0 {name=p121714 lab=_72963_/X }
C {devices/lab_pin.sym} 122140 -4960 0 0 {name=p121715 lab=_83072_/Q }
C {devices/lab_pin.sym} 122140 -4920 0 0 {name=p121716 lab=_73015_/X }
C {devices/lab_pin.sym} 122140 -4880 0 0 {name=p121717 lab=_73016_/X }
C {devices/lab_pin.sym} 122300 -4940 0 1 {name=p121718 lab=_73018_/B }
C {sky130_stdcells/a211o_4.sym} 122220 -4940 0 0 {name=X_73017_ }
C {devices/lab_pin.sym} 122160 -4820 0 0 {name=p121719 lab=_70229_/A }
C {devices/lab_pin.sym} 122160 -4780 0 0 {name=p121720 lab=_70229_/B }
C {devices/lab_pin.sym} 122160 -4740 0 0 {name=p121721 lab=_70229_/C }
C {devices/lab_pin.sym} 122160 -4700 0 0 {name=p121722 lab=_70229_/D }
C {devices/lab_pin.sym} 122280 -4760 0 1 {name=p121723 lab=_70229_/X }
C {sky130_stdcells/and4_4.sym} 122220 -4760 0 0 {name=X_70229_ }
C {devices/lab_pin.sym} 122180 -4610 0 0 {name=p121724 lab=_53900_/A }
C {devices/lab_pin.sym} 122260 -4610 0 1 {name=p121725 lab=_43177_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -4610 0 0 {name=X_43177_ }
C {devices/lab_pin.sym} 122160 -4500 0 0 {name=p121726 lab=_78874_/A }
C {devices/lab_pin.sym} 122160 -4460 0 0 {name=p121727 lab=_78874_/B }
C {devices/lab_pin.sym} 122280 -4480 0 1 {name=p121728 lab=_78875_/B }
C {sky130_stdcells/nor2_4.sym} 122220 -4480 0 0 {name=X_78874_ }
C {devices/lab_pin.sym} 122160 -4360 0 0 {name=p121729 lab=_82333_/Q }
C {devices/lab_pin.sym} 122160 -4320 0 0 {name=p121730 lab=_40385_/B }
C {devices/lab_pin.sym} 122280 -4340 0 1 {name=p121731 lab=_40389_/X }
C {sky130_stdcells/or2_4.sym} 122220 -4340 0 0 {name=X_40389_ }
C {devices/lab_pin.sym} 122140 -4240 0 0 {name=p121732 lab=_41098_/X }
C {devices/lab_pin.sym} 122140 -4200 0 0 {name=p121733 lab=_42125_/X }
C {devices/lab_pin.sym} 122140 -4160 0 0 {name=p121734 lab=_88022_/Q }
C {devices/lab_pin.sym} 122140 -4120 0 0 {name=p121735 lab=_42126_/X }
C {devices/lab_pin.sym} 122300 -4180 0 1 {name=p121736 lab=_88022_/D }
C {sky130_stdcells/a2bb2o_4.sym} 122220 -4180 0 0 {name=X_42128_ }
C {devices/lab_pin.sym} 122180 -4030 0 0 {name=p121737 lab=_77825_/A }
C {devices/lab_pin.sym} 122260 -4030 0 1 {name=p121738 lab=_77827_/A }
C {sky130_stdcells/inv_2.sym} 122220 -4030 0 0 {name=X_77825_ }
C {devices/lab_pin.sym} 122140 -3930 0 0 {name=p121739 lab=_47980_/Y }
C {devices/lab_pin.sym} 122140 -3890 0 0 {name=p121740 lab=_47954_/X }
C {devices/lab_pin.sym} 122140 -3850 0 0 {name=p121741 lab=_47984_/X }
C {devices/lab_pin.sym} 122300 -3890 0 1 {name=p121742 lab=_47985_/Y }
C {sky130_stdcells/a21oi_4.sym} 122220 -3890 0 0 {name=X_47985_ }
C {devices/lab_pin.sym} 122160 -3780 0 0 {name=p121743 lab=_49708_/A }
C {devices/lab_pin.sym} 122160 -3740 0 0 {name=p121744 lab=_49724_/B }
C {devices/lab_pin.sym} 122160 -3700 0 0 {name=p121745 lab=_49724_/C }
C {devices/lab_pin.sym} 122160 -3660 0 0 {name=p121746 lab=_52938_/D }
C {devices/lab_pin.sym} 122280 -3720 0 1 {name=p121747 lab=_49724_/X }
C {sky130_stdcells/and4_4.sym} 122220 -3720 0 0 {name=X_49724_ }
C {devices/lab_pin.sym} 122180 -3570 0 0 {name=p121748 lab=_46936_/A }
C {devices/lab_pin.sym} 122260 -3570 0 1 {name=p121749 lab=_54451_/B }
C {sky130_stdcells/inv_2.sym} 122220 -3570 0 0 {name=X_46936_ }
C {devices/lab_pin.sym} 122180 -3450 0 0 {name=p121750 lab=_42059_/A }
C {devices/lab_pin.sym} 122260 -3450 0 1 {name=p121751 lab=_43129_/A }
C {sky130_stdcells/buf_2.sym} 122220 -3450 0 0 {name=X_42059_ }
C {devices/lab_pin.sym} 122140 -3360 0 0 {name=p121752 lab=_65660_/X }
C {devices/lab_pin.sym} 122140 -3320 0 0 {name=p121753 lab=_83059_/Q }
C {devices/lab_pin.sym} 122140 -3280 0 0 {name=p121754 lab=_65768_/X }
C {devices/lab_pin.sym} 122140 -3240 0 0 {name=p121755 lab=_65769_/X }
C {devices/lab_pin.sym} 122300 -3300 0 1 {name=p121756 lab=_65770_/X }
C {sky130_stdcells/a211o_4.sym} 122220 -3300 0 0 {name=X_65770_ }
C {devices/lab_pin.sym} 122160 -3160 0 0 {name=p121757 lab=_82261_/Q }
C {devices/lab_pin.sym} 122160 -3120 0 0 {name=p121758 lab=_81973_/Q }
C {devices/lab_pin.sym} 122280 -3140 0 1 {name=p121759 lab=_77756_/Y }
C {sky130_stdcells/xnor2_4.sym} 122220 -3140 0 0 {name=X_77756_ }
C {devices/lab_pin.sym} 122160 -3040 0 0 {name=p121760 lab=_61683_/X }
C {devices/lab_pin.sym} 122160 -3000 0 0 {name=p121761 lab=_62936_/X }
C {devices/lab_pin.sym} 122160 -2960 0 0 {name=p121762 lab=_62982_/C }
C {devices/lab_pin.sym} 122160 -2920 0 0 {name=p121763 lab=_60228_/A }
C {devices/lab_pin.sym} 122280 -2980 0 1 {name=p121764 lab=_62982_/Y }
C {sky130_stdcells/nand4_4.sym} 122220 -2980 0 0 {name=X_62982_ }
C {devices/lab_pin.sym} 122160 -2840 0 0 {name=p121765 lab=_74971_/B }
C {devices/lab_pin.sym} 122160 -2800 0 0 {name=p121766 lab=_74968_/B }
C {devices/lab_pin.sym} 122280 -2820 0 1 {name=p121767 lab=_74969_/B }
C {sky130_stdcells/xnor2_4.sym} 122220 -2820 0 0 {name=X_74968_ }
C {devices/lab_pin.sym} 122180 -2690 0 0 {name=p121768 lab=_65034_/A }
C {devices/lab_pin.sym} 122260 -2690 0 1 {name=p121769 lab=_64828_/A }
C {sky130_stdcells/buf_2.sym} 122220 -2690 0 0 {name=X_64721_ }
C {devices/lab_pin.sym} 122160 -2580 0 0 {name=p121770 lab=_76707_/A }
C {devices/lab_pin.sym} 122160 -2540 0 0 {name=p121771 lab=_76707_/B }
C {devices/lab_pin.sym} 122280 -2560 0 1 {name=p121772 lab=_76707_/X }
C {sky130_stdcells/xor2_4.sym} 122220 -2560 0 0 {name=X_76707_ }
C {devices/lab_pin.sym} 122140 -2450 0 0 {name=p121773 lab=_86347_/Q }
C {devices/lab_pin.sym} 122140 -2410 0 0 {name=p121774 lab=_49632_/X }
C {devices/lab_pin.sym} 122140 -2370 0 0 {name=p121775 lab=_49654_/Y }
C {devices/lab_pin.sym} 122300 -2410 0 1 {name=p121776 lab=_49655_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -2410 0 0 {name=X_49655_ }
C {devices/lab_pin.sym} 122180 -2270 0 0 {name=p121777 lab=_62185_/B }
C {devices/lab_pin.sym} 122260 -2270 0 1 {name=p121778 lab=_61933_/X }
C {sky130_stdcells/buf_2.sym} 122220 -2270 0 0 {name=X_61933_ }
C {devices/lab_pin.sym} 122140 -2180 0 0 {name=p121779 lab=_41938_/Y }
C {devices/lab_pin.sym} 122140 -2140 0 0 {name=p121780 lab=_72899_/A }
C {devices/lab_pin.sym} 122140 -2100 0 0 {name=p121781 lab=_45897_/X }
C {devices/lab_pin.sym} 122140 -2060 0 0 {name=p121782 lab=_73918_/Y }
C {devices/lab_pin.sym} 122300 -2120 0 1 {name=p121783 lab=_73919_/X }
C {sky130_stdcells/a211o_4.sym} 122220 -2120 0 0 {name=X_73919_ }
C {devices/lab_pin.sym} 122180 -1970 0 0 {name=p121784 lab=_46866_/Y }
C {devices/lab_pin.sym} 122260 -1970 0 1 {name=p121785 lab=_52720_/D }
C {sky130_stdcells/buf_2.sym} 122220 -1970 0 0 {name=X_46867_ }
C {devices/lab_pin.sym} 122160 -1860 0 0 {name=p121786 lab=_77686_/Y }
C {devices/lab_pin.sym} 122160 -1820 0 0 {name=p121787 lab=_77687_/B }
C {devices/lab_pin.sym} 122280 -1840 0 1 {name=p121788 lab=_77687_/Y }
C {sky130_stdcells/nand2_4.sym} 122220 -1840 0 0 {name=X_77687_ }
C {devices/lab_pin.sym} 122160 -1720 0 0 {name=p121789 lab=_74899_/A }
C {devices/lab_pin.sym} 122160 -1680 0 0 {name=p121790 lab=_74894_/A }
C {devices/lab_pin.sym} 122280 -1700 0 1 {name=p121791 lab=_74899_/Y }
C {sky130_stdcells/nand2_4.sym} 122220 -1700 0 0 {name=X_74899_ }
C {devices/lab_pin.sym} 122180 -1570 0 0 {name=p121792 lab=_48606_/A }
C {devices/lab_pin.sym} 122260 -1570 0 1 {name=p121793 lab=_48606_/X }
C {sky130_stdcells/buf_2.sym} 122220 -1570 0 0 {name=X_48606_ }
C {devices/lab_pin.sym} 122160 -1460 0 0 {name=p121794 lab=_67513_/A }
C {devices/lab_pin.sym} 122160 -1420 0 0 {name=p121795 lab=_67440_/B }
C {devices/lab_pin.sym} 122280 -1440 0 1 {name=p121796 lab=_67440_/X }
C {sky130_stdcells/and2_4.sym} 122220 -1440 0 0 {name=X_67440_ }
C {devices/lab_pin.sym} 122160 -1320 0 0 {name=p121797 lab=_84809_/Q }
C {devices/lab_pin.sym} 122160 -1280 0 0 {name=p121798 lab=_84129_/Q }
C {devices/lab_pin.sym} 122280 -1300 0 1 {name=p121799 lab=_79433_/A }
C {sky130_stdcells/xor2_4.sym} 122220 -1300 0 0 {name=X_79426_ }
C {devices/lab_pin.sym} 122140 -1190 0 0 {name=p121800 lab=_45815_/X }
C {devices/lab_pin.sym} 122140 -1150 0 0 {name=p121801 lab=_45817_/Y }
C {devices/lab_pin.sym} 122140 -1110 0 0 {name=p121802 lab=_45803_/X }
C {devices/lab_pin.sym} 122300 -1150 0 1 {name=p121803 lab=_45818_/Y }
C {sky130_stdcells/a21oi_4.sym} 122220 -1150 0 0 {name=X_45818_ }
C {devices/lab_pin.sym} 122140 -1040 0 0 {name=p121804 lab=_64650_/X }
C {devices/lab_pin.sym} 122140 -1000 0 0 {name=p121805 lab=_86175_/Q }
C {devices/lab_pin.sym} 122140 -960 0 0 {name=p121806 lab=_64583_/X }
C {devices/lab_pin.sym} 122140 -920 0 0 {name=p121807 lab=_64651_/X }
C {devices/lab_pin.sym} 122300 -980 0 1 {name=p121808 lab=_64652_/X }
C {sky130_stdcells/a211o_4.sym} 122220 -980 0 0 {name=X_64652_ }
C {devices/lab_pin.sym} 122180 -830 0 0 {name=p121809 lab=_76637_/X }
C {devices/lab_pin.sym} 122260 -830 0 1 {name=p121810 lab=_76638_/Y }
C {sky130_stdcells/inv_2.sym} 122220 -830 0 0 {name=X_76638_ }
C {devices/lab_pin.sym} 122140 -730 0 0 {name=p121811 lab=_86360_/Q }
C {devices/lab_pin.sym} 122140 -690 0 0 {name=p121812 lab=_49579_/X }
C {devices/lab_pin.sym} 122140 -650 0 0 {name=p121813 lab=_49585_/Y }
C {devices/lab_pin.sym} 122300 -690 0 1 {name=p121814 lab=_49586_/Y }
C {sky130_stdcells/o21ai_4.sym} 122220 -690 0 0 {name=X_49586_ }
C {devices/lab_pin.sym} 123060 -42190 0 0 {name=p121815 lab=_61851_/X }
C {devices/lab_pin.sym} 123060 -42150 0 0 {name=p121816 lab=_61854_/X }
C {devices/lab_pin.sym} 123060 -42110 0 0 {name=p121817 lab=_61863_/Y }
C {devices/lab_pin.sym} 123060 -42070 0 0 {name=p121818 lab=_84745_/Q }
C {devices/lab_pin.sym} 123060 -42030 0 0 {name=p121819 lab=_61815_/X }
C {devices/lab_pin.sym} 123220 -42110 0 1 {name=p121820 lab=_61864_/Y }
C {sky130_stdcells/o32ai_4.sym} 123140 -42110 0 0 {name=X_61864_ }
C {devices/lab_pin.sym} 123100 -41950 0 0 {name=p121821 lab=_46751_/A }
C {devices/lab_pin.sym} 123180 -41950 0 1 {name=p121822 lab=_46798_/X }
C {sky130_stdcells/buf_2.sym} 123140 -41950 0 0 {name=X_46798_ }
C {devices/lab_pin.sym} 123060 -41870 0 0 {name=p121823 lab=_63556_/X }
C {devices/lab_pin.sym} 123060 -41830 0 0 {name=p121824 lab=_63595_/X }
C {devices/lab_pin.sym} 123060 -41790 0 0 {name=p121825 lab=_63596_/X }
C {devices/lab_pin.sym} 123060 -41750 0 0 {name=p121826 lab=_63599_/X }
C {devices/lab_pin.sym} 123060 -41710 0 0 {name=p121827 lab=_63602_/Y }
C {devices/lab_pin.sym} 123220 -41790 0 1 {name=p121828 lab=_63603_/Y }
C {sky130_stdcells/o41ai_4.sym} 123140 -41790 0 0 {name=X_63603_ }
C {devices/lab_pin.sym} 123100 -41630 0 0 {name=p121829 lab=_48613_/A }
C {devices/lab_pin.sym} 123180 -41630 0 1 {name=p121830 lab=_48604_/A }
C {sky130_stdcells/buf_2.sym} 123140 -41630 0 0 {name=X_48537_ }
C {devices/lab_pin.sym} 123080 -41530 0 0 {name=p121831 lab=_60622_/C }
C {devices/lab_pin.sym} 123080 -41490 0 0 {name=p121832 lab=_60599_/A }
C {devices/lab_pin.sym} 123080 -41450 0 0 {name=p121833 lab=_60182_/Y }
C {devices/lab_pin.sym} 123200 -41490 0 1 {name=p121834 lab=_60815_/X }
C {sky130_stdcells/and3_4.sym} 123140 -41490 0 0 {name=X_60815_ }
C {devices/lab_pin.sym} 123060 -41380 0 0 {name=p121835 lab=_87474_/Q }
C {devices/lab_pin.sym} 123060 -41340 0 0 {name=p121836 lab=_67274_/X }
C {devices/lab_pin.sym} 123060 -41300 0 0 {name=p121837 lab=_67344_/X }
C {devices/lab_pin.sym} 123060 -41260 0 0 {name=p121838 lab=_67370_/X }
C {devices/lab_pin.sym} 123220 -41320 0 1 {name=p121839 lab=_67371_/X }
C {sky130_stdcells/a211o_4.sym} 123140 -41320 0 0 {name=X_67371_ }
C {devices/lab_pin.sym} 123060 -41190 0 0 {name=p121840 lab=_79341_/Y }
C {devices/lab_pin.sym} 123060 -41150 0 0 {name=p121841 lab=_79344_/Y }
C {devices/lab_pin.sym} 123060 -41110 0 0 {name=p121842 lab=_79356_/X }
C {devices/lab_pin.sym} 123220 -41150 0 1 {name=p121843 lab=_79357_/X }
C {sky130_stdcells/a21o_4.sym} 123140 -41150 0 0 {name=X_79357_ }
C {devices/lab_pin.sym} 123100 -41010 0 0 {name=p121844 lab=_63265_/B }
C {devices/lab_pin.sym} 123180 -41010 0 1 {name=p121845 lab=_61597_/A }
C {sky130_stdcells/buf_2.sym} 123140 -41010 0 0 {name=X_45749_ }
C {devices/lab_pin.sym} 123100 -40890 0 0 {name=p121846 lab=_64776_/A }
C {devices/lab_pin.sym} 123180 -40890 0 1 {name=p121847 lab=_64583_/X }
C {sky130_stdcells/buf_2.sym} 123140 -40890 0 0 {name=X_64583_ }
C {devices/lab_pin.sym} 123080 -40790 0 0 {name=p121848 lab=_76566_/Y }
C {devices/lab_pin.sym} 123080 -40750 0 0 {name=p121849 lab=_81373_/Q }
C {devices/lab_pin.sym} 123080 -40710 0 0 {name=p121850 lab=_76567_/Y }
C {devices/lab_pin.sym} 123200 -40750 0 1 {name=p121851 lab=_76569_/Y }
C {sky130_stdcells/nand3_4.sym} 123140 -40750 0 0 {name=X_76569_ }
C {devices/lab_pin.sym} 123080 -40640 0 0 {name=p121852 lab=_61375_/B }
C {devices/lab_pin.sym} 123080 -40600 0 0 {name=p121853 lab=_61795_/B }
C {devices/lab_pin.sym} 123080 -40560 0 0 {name=p121854 lab=_61795_/C }
C {devices/lab_pin.sym} 123080 -40520 0 0 {name=p121855 lab=_61778_/X }
C {devices/lab_pin.sym} 123200 -40580 0 1 {name=p121856 lab=_61795_/Y }
C {sky130_stdcells/nand4_4.sym} 123140 -40580 0 0 {name=X_61795_ }
C {devices/lab_pin.sym} 123100 -40430 0 0 {name=p121857 lab=_69110_/A }
C {devices/lab_pin.sym} 123180 -40430 0 1 {name=p121858 lab=_69110_/Y }
C {sky130_stdcells/inv_2.sym} 123140 -40430 0 0 {name=X_69110_ }
C {devices/lab_pin.sym} 123060 -40340 0 0 {name=p121859 lab=_66266_/X }
C {devices/lab_pin.sym} 123060 -40300 0 0 {name=p121860 lab=_86212_/Q }
C {devices/lab_pin.sym} 123060 -40260 0 0 {name=p121861 lab=_66295_/X }
C {devices/lab_pin.sym} 123060 -40220 0 0 {name=p121862 lab=_66321_/X }
C {devices/lab_pin.sym} 123220 -40280 0 1 {name=p121863 lab=_66322_/X }
C {sky130_stdcells/a211o_4.sym} 123140 -40280 0 0 {name=X_66322_ }
C {devices/lab_pin.sym} 123060 -40150 0 0 {name=p121864 lab=_78309_/A }
C {devices/lab_pin.sym} 123060 -40110 0 0 {name=p121865 lab=_78309_/C }
C {devices/lab_pin.sym} 123060 -40070 0 0 {name=p121866 lab=_78309_/B }
C {devices/lab_pin.sym} 123220 -40110 0 1 {name=p121867 lab=_78308_/Y }
C {sky130_stdcells/a21oi_4.sym} 123140 -40110 0 0 {name=X_78308_ }
C {devices/lab_pin.sym} 123060 -40000 0 0 {name=p121868 lab=_58557_/A }
C {devices/lab_pin.sym} 123060 -39960 0 0 {name=p121869 lab=_63497_/X }
C {devices/lab_pin.sym} 123060 -39920 0 0 {name=p121870 lab=_61502_/A }
C {devices/lab_pin.sym} 123060 -39880 0 0 {name=p121871 lab=_63498_/X }
C {devices/lab_pin.sym} 123220 -39940 0 1 {name=p121872 lab=_63534_/X }
C {sky130_stdcells/a2bb2o_4.sym} 123140 -39940 0 0 {name=X_63534_ }
C {devices/lab_pin.sym} 123100 -39790 0 0 {name=p121873 lab=_74414_/B }
C {devices/lab_pin.sym} 123180 -39790 0 1 {name=p121874 lab=_48763_/B }
C {sky130_stdcells/buf_2.sym} 123140 -39790 0 0 {name=X_48468_ }
C {devices/lab_pin.sym} 123080 -39690 0 0 {name=p121875 lab=_60700_/A }
C {devices/lab_pin.sym} 123080 -39650 0 0 {name=p121876 lab=_60752_/B }
C {devices/lab_pin.sym} 123080 -39610 0 0 {name=p121877 lab=_60746_/C }
C {devices/lab_pin.sym} 123200 -39650 0 1 {name=p121878 lab=_60746_/Y }
C {sky130_stdcells/nor3_4.sym} 123140 -39650 0 0 {name=X_60746_ }
C {devices/lab_pin.sym} 123080 -39520 0 0 {name=p121879 lab=_79288_/A }
C {devices/lab_pin.sym} 123080 -39480 0 0 {name=p121880 lab=_83220_/Q }
C {devices/lab_pin.sym} 123200 -39500 0 1 {name=p121881 lab=_79288_/X }
C {sky130_stdcells/xor2_4.sym} 123140 -39500 0 0 {name=X_79288_ }
C {devices/lab_pin.sym} 123060 -39390 0 0 {name=p121882 lab=_80806_/D }
C {devices/lab_pin.sym} 123060 -39350 0 0 {name=p121883 lab=_68954_/X }
C {devices/lab_pin.sym} 123060 -39310 0 0 {name=p121884 lab=_69040_/X }
C {devices/lab_pin.sym} 123220 -39350 0 1 {name=p121885 lab=_83950_/D }
C {sky130_stdcells/a21bo_4.sym} 123140 -39350 0 0 {name=X_69041_ }
C {devices/lab_pin.sym} 123060 -39230 0 0 {name=p121886 lab=_47413_/Y }
C {devices/lab_pin.sym} 123060 -39190 0 0 {name=p121887 lab=_47414_/X }
C {devices/lab_pin.sym} 123060 -39150 0 0 {name=p121888 lab=_47418_/X }
C {devices/lab_pin.sym} 123220 -39190 0 1 {name=p121889 lab=_86637_/D }
C {sky130_stdcells/a21oi_4.sym} 123140 -39190 0 0 {name=X_47419_ }
C {devices/lab_pin.sym} 123060 -39080 0 0 {name=p121890 lab=_66236_/X }
C {devices/lab_pin.sym} 123060 -39040 0 0 {name=p121891 lab=_85609_/Q }
C {devices/lab_pin.sym} 123060 -39000 0 0 {name=p121892 lab=_66251_/X }
C {devices/lab_pin.sym} 123060 -38960 0 0 {name=p121893 lab=_66252_/X }
C {devices/lab_pin.sym} 123220 -39020 0 1 {name=p121894 lab=_66253_/X }
C {sky130_stdcells/a211o_4.sym} 123140 -39020 0 0 {name=X_66253_ }
C {devices/lab_pin.sym} 123080 -38880 0 0 {name=p121895 lab=_78252_/A }
C {devices/lab_pin.sym} 123080 -38840 0 0 {name=p121896 lab=_78239_/B }
C {devices/lab_pin.sym} 123200 -38860 0 1 {name=p121897 lab=_78240_/B }
C {sky130_stdcells/xor2_4.sym} 123140 -38860 0 0 {name=X_78239_ }
C {devices/lab_pin.sym} 123080 -38760 0 0 {name=p121898 lab=_59388_/A }
C {devices/lab_pin.sym} 123080 -38720 0 0 {name=p121899 lab=_63465_/B }
C {devices/lab_pin.sym} 123080 -38680 0 0 {name=p121900 lab=_63465_/C }
C {devices/lab_pin.sym} 123080 -38640 0 0 {name=p121901 lab=_63465_/D }
C {devices/lab_pin.sym} 123200 -38700 0 1 {name=p121902 lab=_63465_/Y }
C {sky130_stdcells/nand4_4.sym} 123140 -38700 0 0 {name=X_63465_ }
C {devices/lab_pin.sym} 123100 -38550 0 0 {name=p121903 lab=_83589_/Q }
C {devices/lab_pin.sym} 123180 -38550 0 1 {name=p121904 lab=_74383_/B }
C {sky130_stdcells/inv_2.sym} 123140 -38550 0 0 {name=X_48399_ }
C {devices/lab_pin.sym} 123100 -38430 0 0 {name=p121905 lab=_60677_/A }
C {devices/lab_pin.sym} 123180 -38430 0 1 {name=p121906 lab=_63478_/A }
C {sky130_stdcells/buf_2.sym} 123140 -38430 0 0 {name=X_60677_ }
C {devices/lab_pin.sym} 123100 -38310 0 0 {name=p121907 lab=clkbuf_9_505_0_CLK/X }
C {devices/lab_pin.sym} 123180 -38310 0 1 {name=p121908 lab=_85566_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 123140 -38310 0 0 {name=Xclkbuf_10_1011_0_CLK }
C {devices/lab_pin.sym} 123060 -38220 0 0 {name=p121909 lab=_65118_/X }
C {devices/lab_pin.sym} 123060 -38180 0 0 {name=p121910 lab=_85546_/Q }
C {devices/lab_pin.sym} 123060 -38140 0 0 {name=p121911 lab=_65146_/X }
C {devices/lab_pin.sym} 123060 -38100 0 0 {name=p121912 lab=_65203_/X }
C {devices/lab_pin.sym} 123220 -38160 0 1 {name=p121913 lab=_65204_/X }
C {sky130_stdcells/a211o_4.sym} 123140 -38160 0 0 {name=X_65204_ }
C {devices/lab_pin.sym} 123080 -38030 0 0 {name=p121914 lab=_52135_/A }
C {devices/lab_pin.sym} 123080 -37990 0 0 {name=p121915 lab=_50430_/B }
C {devices/lab_pin.sym} 123080 -37950 0 0 {name=p121916 lab=_50435_/C }
C {devices/lab_pin.sym} 123200 -37990 0 1 {name=p121917 lab=_50430_/X }
C {sky130_stdcells/and3_4.sym} 123140 -37990 0 0 {name=X_50430_ }
C {devices/lab_pin.sym} 123080 -37880 0 0 {name=p121918 lab=_62415_/X }
C {devices/lab_pin.sym} 123080 -37840 0 0 {name=p121919 lab=_57680_/A }
C {devices/lab_pin.sym} 123080 -37800 0 0 {name=p121920 lab=_62565_/C }
C {devices/lab_pin.sym} 123080 -37760 0 0 {name=p121921 lab=_62355_/X }
C {devices/lab_pin.sym} 123200 -37820 0 1 {name=p121922 lab=_62416_/X }
C {sky130_stdcells/and4_4.sym} 123140 -37820 0 0 {name=X_62416_ }
C {devices/lab_pin.sym} 123050 -37670 0 0 {name=p121923 lab=_81250_/CLK }
C {devices/lab_pin.sym} 123050 -37650 0 0 {name=p121924 lab=_81250_/D }
C {devices/lab_pin.sym} 123230 -37670 0 1 {name=p121925 lab=_76155_/A }
C {sky130_stdcells/dfxtp_4.sym} 123140 -37660 0 0 {name=X_81250_ }
C {devices/lab_pin.sym} 123060 -37560 0 0 {name=p121926 lab=_66053_/X }
C {devices/lab_pin.sym} 123060 -37520 0 0 {name=p121927 lab=_85614_/Q }
C {devices/lab_pin.sym} 123060 -37480 0 0 {name=p121928 lab=_66096_/X }
C {devices/lab_pin.sym} 123060 -37440 0 0 {name=p121929 lab=_66183_/X }
C {devices/lab_pin.sym} 123220 -37500 0 1 {name=p121930 lab=_66184_/X }
C {sky130_stdcells/a211o_4.sym} 123140 -37500 0 0 {name=X_66184_ }
C {devices/lab_pin.sym} 123080 -37380 0 0 {name=p121931 lab=_63410_/A }
C {devices/lab_pin.sym} 123080 -37340 0 0 {name=p121932 lab=_63396_/B }
C {devices/lab_pin.sym} 123080 -37300 0 0 {name=p121933 lab=_63410_/C }
C {devices/lab_pin.sym} 123080 -37260 0 0 {name=p121934 lab=_63384_/D }
C {devices/lab_pin.sym} 123200 -37320 0 1 {name=p121935 lab=_63396_/X }
C {sky130_stdcells/and4_4.sym} 123140 -37320 0 0 {name=X_63396_ }
C {devices/lab_pin.sym} 123060 -37190 0 0 {name=p121936 lab=_80189_/A }
C {devices/lab_pin.sym} 123060 -37150 0 0 {name=p121937 lab=_80221_/B }
C {devices/lab_pin.sym} 123060 -37110 0 0 {name=p121938 lab=_80200_/X }
C {devices/lab_pin.sym} 123220 -37150 0 1 {name=p121939 lab=_80201_/Y }
C {sky130_stdcells/a21boi_4.sym} 123140 -37150 0 0 {name=X_80201_ }
C {devices/lab_pin.sym} 123100 -37010 0 0 {name=p121940 lab=_64601_/A }
C {devices/lab_pin.sym} 123180 -37010 0 1 {name=p121941 lab=_65782_/A }
C {sky130_stdcells/buf_2.sym} 123140 -37010 0 0 {name=X_65135_ }
C {devices/lab_pin.sym} 123060 -36910 0 0 {name=p121942 lab=_50359_/Y }
C {devices/lab_pin.sym} 123060 -36870 0 0 {name=p121943 lab=_50313_/X }
C {devices/lab_pin.sym} 123060 -36830 0 0 {name=p121944 lab=_50360_/X }
C {devices/lab_pin.sym} 123220 -36870 0 1 {name=p121945 lab=_50361_/Y }
C {sky130_stdcells/a21oi_4.sym} 123140 -36870 0 0 {name=X_50361_ }
C {devices/lab_pin.sym} 123060 -36750 0 0 {name=p121946 lab=_62196_/X }
C {devices/lab_pin.sym} 123060 -36710 0 0 {name=p121947 lab=_61876_/X }
C {devices/lab_pin.sym} 123060 -36670 0 0 {name=p121948 lab=_62346_/X }
C {devices/lab_pin.sym} 123220 -36710 0 1 {name=p121949 lab=_62347_/X }
C {sky130_stdcells/a21o_4.sym} 123140 -36710 0 0 {name=X_62347_ }
C {devices/lab_pin.sym} 123050 -36570 0 0 {name=p121950 lab=_81197_/CLK }
C {devices/lab_pin.sym} 123050 -36550 0 0 {name=p121951 lab=_75045_/B }
C {devices/lab_pin.sym} 123230 -36570 0 1 {name=p121952 lab=_81181_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -36560 0 0 {name=X_81181_ }
C {devices/lab_pin.sym} 123080 -36440 0 0 {name=p121953 lab=_52100_/A }
C {devices/lab_pin.sym} 123080 -36400 0 0 {name=p121954 lab=_48368_/X }
C {devices/lab_pin.sym} 123200 -36420 0 1 {name=p121955 lab=_52100_/Y }
C {sky130_stdcells/nand2_4.sym} 123140 -36420 0 0 {name=X_52100_ }
C {devices/lab_pin.sym} 123080 -36300 0 0 {name=p121956 lab=_84942_/Q }
C {devices/lab_pin.sym} 123080 -36260 0 0 {name=p121957 lab=_84190_/Q }
C {devices/lab_pin.sym} 123200 -36280 0 1 {name=p121958 lab=_80132_/X }
C {sky130_stdcells/xor2_4.sym} 123140 -36280 0 0 {name=X_80132_ }
C {devices/lab_pin.sym} 123080 -36160 0 0 {name=p121959 lab=_53080_/A }
C {devices/lab_pin.sym} 123080 -36120 0 0 {name=p121960 lab=_53080_/B }
C {devices/lab_pin.sym} 123200 -36140 0 1 {name=p121961 lab=_53080_/Y }
C {sky130_stdcells/nand2_4.sym} 123140 -36140 0 0 {name=X_53080_ }
C {devices/lab_pin.sym} 123080 -36020 0 0 {name=p121962 lab=_65005_/X }
C {devices/lab_pin.sym} 123080 -35980 0 0 {name=p121963 lab=_65066_/B }
C {devices/lab_pin.sym} 123200 -36000 0 1 {name=p121964 lab=_65066_/X }
C {sky130_stdcells/and2_4.sym} 123140 -36000 0 0 {name=X_65066_ }
C {devices/lab_pin.sym} 123100 -35870 0 0 {name=p121965 lab=_68823_/A }
C {devices/lab_pin.sym} 123180 -35870 0 1 {name=p121966 lab=_69943_/X }
C {sky130_stdcells/buf_2.sym} 123140 -35870 0 0 {name=X_69943_ }
C {devices/lab_pin.sym} 123060 -35770 0 0 {name=p121967 lab=_50290_/Y }
C {devices/lab_pin.sym} 123060 -35730 0 0 {name=p121968 lab=_50274_/X }
C {devices/lab_pin.sym} 123060 -35690 0 0 {name=p121969 lab=_50291_/Y }
C {devices/lab_pin.sym} 123220 -35730 0 1 {name=p121970 lab=_50292_/Y }
C {sky130_stdcells/a21boi_4.sym} 123140 -35730 0 0 {name=X_50292_ }
C {devices/lab_pin.sym} 123100 -35590 0 0 {name=p121971 lab=_62623_/C }
C {devices/lab_pin.sym} 123180 -35590 0 1 {name=p121972 lab=_62278_/X }
C {sky130_stdcells/buf_2.sym} 123140 -35590 0 0 {name=X_62278_ }
C {devices/lab_pin.sym} 123080 -35480 0 0 {name=p121973 lab=_52014_/X }
C {devices/lab_pin.sym} 123080 -35440 0 0 {name=p121974 lab=_50328_/B }
C {devices/lab_pin.sym} 123200 -35460 0 1 {name=p121975 lab=_52031_/Y }
C {sky130_stdcells/nand2_4.sym} 123140 -35460 0 0 {name=X_52031_ }
C {devices/lab_pin.sym} 123080 -35360 0 0 {name=p121976 lab=_64011_/Y }
C {devices/lab_pin.sym} 123080 -35320 0 0 {name=p121977 lab=_64013_/Y }
C {devices/lab_pin.sym} 123080 -35280 0 0 {name=p121978 lab=_64017_/C }
C {devices/lab_pin.sym} 123080 -35240 0 0 {name=p121979 lab=_64017_/D }
C {devices/lab_pin.sym} 123200 -35300 0 1 {name=p121980 lab=_64017_/X }
C {sky130_stdcells/and4_4.sym} 123140 -35300 0 0 {name=X_64017_ }
C {devices/lab_pin.sym} 123060 -35190 0 0 {name=p121981 lab=_61254_/C }
C {devices/lab_pin.sym} 123060 -35150 0 0 {name=p121982 lab=_61190_/X }
C {devices/lab_pin.sym} 123060 -35110 0 0 {name=p121983 lab=_61167_/Y }
C {devices/lab_pin.sym} 123060 -35070 0 0 {name=p121984 lab=_64454_/B }
C {devices/lab_pin.sym} 123060 -35040 0 0 {name=p121985 lab=_61228_/Y }
C {devices/lab_pin.sym} 123220 -35110 0 1 {name=p121986 lab=_84503_/D }
C {sky130_stdcells/a41oi_4.sym} 123140 -35110 0 0 {name=X_61229_ }
C {devices/lab_pin.sym} 123050 -34950 0 0 {name=p121987 lab=_85489_/CLK }
C {devices/lab_pin.sym} 123050 -34930 0 0 {name=p121988 lab=_84940_/D }
C {devices/lab_pin.sym} 123230 -34950 0 1 {name=p121989 lab=_84940_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -34940 0 0 {name=X_84940_ }
C {devices/lab_pin.sym} 123080 -34820 0 0 {name=p121990 lab=_80047_/X }
C {devices/lab_pin.sym} 123080 -34780 0 0 {name=p121991 lab=_80050_/Y }
C {devices/lab_pin.sym} 123200 -34800 0 1 {name=p121992 lab=_80063_/X }
C {sky130_stdcells/or2_4.sym} 123140 -34800 0 0 {name=X_80063_ }
C {devices/lab_pin.sym} 123080 -34680 0 0 {name=p121993 lab=_69687_/A }
C {devices/lab_pin.sym} 123080 -34640 0 0 {name=p121994 lab=_69873_/Y }
C {devices/lab_pin.sym} 123200 -34660 0 1 {name=p121995 lab=_69874_/Y }
C {sky130_stdcells/nor2_4.sym} 123140 -34660 0 0 {name=X_69874_ }
C {devices/lab_pin.sym} 123100 -34530 0 0 {name=p121996 lab=_87841_/Q }
C {devices/lab_pin.sym} 123180 -34530 0 1 {name=p121997 lab=_68826_/B }
C {sky130_stdcells/inv_2.sym} 123140 -34530 0 0 {name=X_68825_ }
C {devices/lab_pin.sym} 123050 -34410 0 0 {name=p121998 lab=_84299_/CLK }
C {devices/lab_pin.sym} 123050 -34390 0 0 {name=p121999 lab=_58353_/Y }
C {devices/lab_pin.sym} 123230 -34410 0 1 {name=p122000 lab=_84871_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -34400 0 0 {name=X_84871_ }
C {devices/lab_pin.sym} 123050 -34270 0 0 {name=p122001 lab=_86610_/CLK }
C {devices/lab_pin.sym} 123050 -34250 0 0 {name=p122002 lab=_47677_/Y }
C {devices/lab_pin.sym} 123230 -34270 0 1 {name=p122003 lab=_72302_/A }
C {sky130_stdcells/dfxtp_4.sym} 123140 -34260 0 0 {name=X_86610_ }
C {devices/lab_pin.sym} 123050 -34130 0 0 {name=p122004 lab=_83787_/CLK }
C {devices/lab_pin.sym} 123050 -34110 0 0 {name=p122005 lab=_83822_/D }
C {devices/lab_pin.sym} 123230 -34130 0 1 {name=p122006 lab=_74778_/B }
C {sky130_stdcells/dfxtp_4.sym} 123140 -34120 0 0 {name=X_83822_ }
C {devices/lab_pin.sym} 123100 -33990 0 0 {name=p122007 lab=_83325_/Q }
C {devices/lab_pin.sym} 123180 -33990 0 1 {name=p122008 lab=_57010_/A }
C {sky130_stdcells/buf_2.sym} 123140 -33990 0 0 {name=X_56770_ }
C {devices/lab_pin.sym} 123060 -33900 0 0 {name=p122009 lab=_88004_/Q }
C {devices/lab_pin.sym} 123060 -33860 0 0 {name=p122010 lab=_68650_/X }
C {devices/lab_pin.sym} 123060 -33820 0 0 {name=p122011 lab=_68651_/X }
C {devices/lab_pin.sym} 123060 -33780 0 0 {name=p122012 lab=_68755_/X }
C {devices/lab_pin.sym} 123220 -33840 0 1 {name=p122013 lab=_68756_/X }
C {sky130_stdcells/a211o_4.sym} 123140 -33840 0 0 {name=X_68756_ }
C {devices/lab_pin.sym} 123050 -33690 0 0 {name=p122014 lab=_88108_/CLK }
C {devices/lab_pin.sym} 123050 -33670 0 0 {name=p122015 lab=_43065_/Y }
C {devices/lab_pin.sym} 123230 -33690 0 1 {name=p122016 lab=_73873_/A }
C {sky130_stdcells/dfxtp_4.sym} 123140 -33680 0 0 {name=X_87590_ }
C {devices/lab_pin.sym} 123100 -33550 0 0 {name=p122017 lab=_53982_/A }
C {devices/lab_pin.sym} 123180 -33550 0 1 {name=p122018 lab=_53982_/X }
C {sky130_stdcells/buf_2.sym} 123140 -33550 0 0 {name=X_53982_ }
C {devices/lab_pin.sym} 123060 -33450 0 0 {name=p122019 lab=_65903_/X }
C {devices/lab_pin.sym} 123060 -33410 0 0 {name=p122020 lab=_65494_/Y }
C {devices/lab_pin.sym} 123060 -33370 0 0 {name=p122021 lab=_65967_/Y }
C {devices/lab_pin.sym} 123220 -33410 0 1 {name=p122022 lab=_65968_/Y }
C {sky130_stdcells/o21ai_4.sym} 123140 -33410 0 0 {name=X_65968_ }
C {devices/lab_pin.sym} 123060 -33290 0 0 {name=p122023 lab=_55794_/A }
C {devices/lab_pin.sym} 123060 -33250 0 0 {name=p122024 lab=_56165_/C }
C {devices/lab_pin.sym} 123060 -33210 0 0 {name=p122025 lab=_55140_/A }
C {devices/lab_pin.sym} 123220 -33250 0 1 {name=p122026 lab=_55721_/Y }
C {sky130_stdcells/a21oi_4.sym} 123140 -33250 0 0 {name=X_55721_ }
C {devices/lab_pin.sym} 123080 -33120 0 0 {name=p122027 lab=_67658_/X }
C {devices/lab_pin.sym} 123080 -33080 0 0 {name=p122028 lab=_67707_/B }
C {devices/lab_pin.sym} 123200 -33100 0 1 {name=p122029 lab=_67707_/X }
C {sky130_stdcells/and2_4.sym} 123140 -33100 0 0 {name=X_67707_ }
C {devices/lab_pin.sym} 123050 -32970 0 0 {name=p122030 lab=_86541_/CLK }
C {devices/lab_pin.sym} 123050 -32950 0 0 {name=p122031 lab=_86541_/D }
C {devices/lab_pin.sym} 123230 -32970 0 1 {name=p122032 lab=_86541_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -32960 0 0 {name=X_86541_ }
C {devices/lab_pin.sym} 123100 -32830 0 0 {name=p122033 lab=_52852_/A }
C {devices/lab_pin.sym} 123180 -32830 0 1 {name=p122034 lab=_52954_/B }
C {sky130_stdcells/buf_2.sym} 123140 -32830 0 0 {name=X_52933_ }
C {devices/lab_pin.sym} 123100 -32710 0 0 {name=p122035 lab=_65669_/A }
C {devices/lab_pin.sym} 123180 -32710 0 1 {name=p122036 lab=_64919_/X }
C {sky130_stdcells/buf_2.sym} 123140 -32710 0 0 {name=X_64919_ }
C {devices/lab_pin.sym} 123050 -32590 0 0 {name=p122037 lab=_83753_/CLK }
C {devices/lab_pin.sym} 123050 -32570 0 0 {name=p122038 lab=_70542_/X }
C {devices/lab_pin.sym} 123230 -32590 0 1 {name=p122039 lab=_83753_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -32580 0 0 {name=X_83753_ }
C {devices/lab_pin.sym} 123060 -32480 0 0 {name=p122040 lab=_87091_/Q }
C {devices/lab_pin.sym} 123060 -32440 0 0 {name=p122041 lab=_68580_/X }
C {devices/lab_pin.sym} 123060 -32400 0 0 {name=p122042 lab=_68630_/X }
C {devices/lab_pin.sym} 123060 -32360 0 0 {name=p122043 lab=_68686_/X }
C {devices/lab_pin.sym} 123220 -32420 0 1 {name=p122044 lab=_68687_/X }
C {sky130_stdcells/a211o_4.sym} 123140 -32420 0 0 {name=X_68687_ }
C {devices/lab_pin.sym} 123050 -32270 0 0 {name=p122045 lab=_80962_/CLK }
C {devices/lab_pin.sym} 123050 -32250 0 0 {name=p122046 lab=_75604_/X }
C {devices/lab_pin.sym} 123230 -32270 0 1 {name=p122047 lab=_80965_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -32260 0 0 {name=X_80965_ }
C {devices/lab_pin.sym} 123060 -32150 0 0 {name=p122048 lab=_65789_/X }
C {devices/lab_pin.sym} 123060 -32110 0 0 {name=p122049 lab=_65410_/Y }
C {devices/lab_pin.sym} 123060 -32070 0 0 {name=p122050 lab=_65898_/Y }
C {devices/lab_pin.sym} 123220 -32110 0 1 {name=p122051 lab=_65899_/Y }
C {sky130_stdcells/o21ai_4.sym} 123140 -32110 0 0 {name=X_65899_ }
C {devices/lab_pin.sym} 123100 -31970 0 0 {name=p122052 lab=_84847_/Q }
C {devices/lab_pin.sym} 123180 -31970 0 1 {name=p122053 lab=_58440_/Y }
C {sky130_stdcells/inv_2.sym} 123140 -31970 0 0 {name=X_58440_ }
C {devices/lab_pin.sym} 123050 -31850 0 0 {name=p122054 lab=_82491_/CLK }
C {devices/lab_pin.sym} 123050 -31830 0 0 {name=p122055 lab=_82704_/D }
C {devices/lab_pin.sym} 123230 -31850 0 1 {name=p122056 lab=_78330_/B }
C {sky130_stdcells/dfxtp_4.sym} 123140 -31840 0 0 {name=X_82704_ }
C {devices/lab_pin.sym} 123060 -31730 0 0 {name=p122057 lab=_67631_/X }
C {devices/lab_pin.sym} 123060 -31690 0 0 {name=p122058 lab=_67635_/X }
C {devices/lab_pin.sym} 123060 -31650 0 0 {name=p122059 lab=_67637_/X }
C {devices/lab_pin.sym} 123220 -31690 0 1 {name=p122060 lab=_67638_/Y }
C {sky130_stdcells/a21oi_4.sym} 123140 -31690 0 0 {name=X_67638_ }
C {devices/lab_pin.sym} 123100 -31550 0 0 {name=p122061 lab=_83318_/Q }
C {devices/lab_pin.sym} 123180 -31550 0 1 {name=p122062 lab=_55652_/Y }
C {sky130_stdcells/inv_2.sym} 123140 -31550 0 0 {name=X_55652_ }
C {devices/lab_pin.sym} 123050 -31430 0 0 {name=p122063 lab=_86472_/CLK }
C {devices/lab_pin.sym} 123050 -31410 0 0 {name=p122064 lab=_86472_/D }
C {devices/lab_pin.sym} 123230 -31430 0 1 {name=p122065 lab=_86472_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -31420 0 0 {name=X_86472_ }
C {devices/lab_pin.sym} 123060 -31310 0 0 {name=p122066 lab=_85740_/Q }
C {devices/lab_pin.sym} 123060 -31270 0 0 {name=p122067 lab=_52848_/X }
C {devices/lab_pin.sym} 123060 -31230 0 0 {name=p122068 lab=_52863_/Y }
C {devices/lab_pin.sym} 123220 -31270 0 1 {name=p122069 lab=_52864_/Y }
C {sky130_stdcells/o21ai_4.sym} 123140 -31270 0 0 {name=X_52864_ }
C {devices/lab_pin.sym} 123050 -31130 0 0 {name=p122070 lab=_84807_/CLK }
C {devices/lab_pin.sym} 123050 -31110 0 0 {name=p122071 lab=_70847_/Y }
C {devices/lab_pin.sym} 123230 -31130 0 1 {name=p122072 lab=_83684_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -31120 0 0 {name=X_83684_ }
C {devices/lab_pin.sym} 123050 -30990 0 0 {name=p122073 lab=_81994_/CLK }
C {devices/lab_pin.sym} 123050 -30970 0 0 {name=p122074 lab=_75860_/X }
C {devices/lab_pin.sym} 123230 -30990 0 1 {name=p122075 lab=_80896_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -30980 0 0 {name=X_80896_ }
C {devices/lab_pin.sym} 123050 -30850 0 0 {name=p122076 lab=_87484_/CLK }
C {devices/lab_pin.sym} 123050 -30830 0 0 {name=p122077 lab=_41462_/X }
C {devices/lab_pin.sym} 123230 -30850 0 1 {name=p122078 lab=_88211_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -30840 0 0 {name=X_88211_ }
C {devices/lab_pin.sym} 123080 -30740 0 0 {name=p122079 lab=_54589_/X }
C {devices/lab_pin.sym} 123080 -30700 0 0 {name=p122080 lab=_54607_/B }
C {devices/lab_pin.sym} 123080 -30660 0 0 {name=p122081 lab=_54591_/C }
C {devices/lab_pin.sym} 123080 -30620 0 0 {name=p122082 lab=_47201_/A }
C {devices/lab_pin.sym} 123200 -30680 0 1 {name=p122083 lab=_54603_/X }
C {sky130_stdcells/and4_4.sym} 123140 -30680 0 0 {name=X_54603_ }
C {devices/lab_pin.sym} 123050 -30530 0 0 {name=p122084 lab=_85648_/CLK }
C {devices/lab_pin.sym} 123050 -30510 0 0 {name=p122085 lab=_54545_/Y }
C {devices/lab_pin.sym} 123230 -30530 0 1 {name=p122086 lab=_85423_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -30520 0 0 {name=X_85423_ }
C {devices/lab_pin.sym} 123080 -30420 0 0 {name=p122087 lab=_51805_/A }
C {devices/lab_pin.sym} 123080 -30380 0 0 {name=p122088 lab=_51815_/B }
C {devices/lab_pin.sym} 123080 -30340 0 0 {name=p122089 lab=_51810_/C }
C {devices/lab_pin.sym} 123080 -30300 0 0 {name=p122090 lab=_46736_/X }
C {devices/lab_pin.sym} 123200 -30360 0 1 {name=p122091 lab=_51815_/X }
C {sky130_stdcells/and4_4.sym} 123140 -30360 0 0 {name=X_51815_ }
C {devices/lab_pin.sym} 123060 -30230 0 0 {name=p122092 lab=_58366_/X }
C {devices/lab_pin.sym} 123060 -30190 0 0 {name=p122093 lab=_83763_/Q }
C {devices/lab_pin.sym} 123060 -30150 0 0 {name=p122094 lab=_58370_/Y }
C {devices/lab_pin.sym} 123220 -30190 0 1 {name=p122095 lab=_84867_/D }
C {sky130_stdcells/o21a_4.sym} 123140 -30190 0 0 {name=X_58371_ }
C {devices/lab_pin.sym} 123050 -30050 0 0 {name=p122096 lab=_87416_/CLK }
C {devices/lab_pin.sym} 123050 -30030 0 0 {name=p122097 lab=_82635_/D }
C {devices/lab_pin.sym} 123230 -30050 0 1 {name=p122098 lab=_82635_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -30040 0 0 {name=X_82635_ }
C {devices/lab_pin.sym} 123060 -29940 0 0 {name=p122099 lab=_85117_/Q }
C {devices/lab_pin.sym} 123060 -29900 0 0 {name=p122100 lab=_55527_/X }
C {devices/lab_pin.sym} 123060 -29860 0 0 {name=p122101 lab=_44049_/X }
C {devices/lab_pin.sym} 123060 -29820 0 0 {name=p122102 lab=_55582_/Y }
C {devices/lab_pin.sym} 123220 -29880 0 1 {name=p122103 lab=_55583_/X }
C {sky130_stdcells/a211o_4.sym} 123140 -29880 0 0 {name=X_55583_ }
C {devices/lab_pin.sym} 123100 -29730 0 0 {name=p122104 lab=_67093_/X }
C {devices/lab_pin.sym} 123180 -29730 0 1 {name=p122105 lab=_67569_/X }
C {sky130_stdcells/buf_2.sym} 123140 -29730 0 0 {name=X_67569_ }
C {devices/lab_pin.sym} 123060 -29630 0 0 {name=p122106 lab=_85753_/Q }
C {devices/lab_pin.sym} 123060 -29590 0 0 {name=p122107 lab=_52792_/X }
C {devices/lab_pin.sym} 123060 -29550 0 0 {name=p122108 lab=_52794_/Y }
C {devices/lab_pin.sym} 123220 -29590 0 1 {name=p122109 lab=_52795_/Y }
C {sky130_stdcells/o21ai_4.sym} 123140 -29590 0 0 {name=X_52795_ }
C {devices/lab_pin.sym} 123080 -29460 0 0 {name=p122110 lab=_56814_/A }
C {devices/lab_pin.sym} 123080 -29420 0 0 {name=p122111 lab=_57322_/B }
C {devices/lab_pin.sym} 123200 -29440 0 1 {name=p122112 lab=_57322_/Y }
C {sky130_stdcells/nand2_4.sym} 123140 -29440 0 0 {name=X_57322_ }
C {sky130_stdcells/decap_3.sym} 123140 -29280 0 0 {name=XPHY_11 }
C {devices/lab_pin.sym} 123100 -29130 0 0 {name=p122113 lab=_64777_/A }
C {devices/lab_pin.sym} 123180 -29130 0 1 {name=p122114 lab=_69309_/A }
C {sky130_stdcells/buf_2.sym} 123140 -29130 0 0 {name=X_69308_ }
C {devices/lab_pin.sym} 123050 -29010 0 0 {name=p122115 lab=_88398_/CLK }
C {devices/lab_pin.sym} 123050 -28990 0 0 {name=p122116 lab=_88142_/D }
C {devices/lab_pin.sym} 123230 -29010 0 1 {name=p122117 lab=_66704_/B }
C {sky130_stdcells/dfxtp_4.sym} 123140 -29000 0 0 {name=X_88142_ }
C {devices/lab_pin.sym} 123060 -28890 0 0 {name=p122118 lab=_85424_/Q }
C {devices/lab_pin.sym} 123060 -28850 0 0 {name=p122119 lab=_54512_/X }
C {devices/lab_pin.sym} 123060 -28810 0 0 {name=p122120 lab=_54533_/Y }
C {devices/lab_pin.sym} 123220 -28850 0 1 {name=p122121 lab=_54534_/Y }
C {sky130_stdcells/o21ai_4.sym} 123140 -28850 0 0 {name=X_54534_ }
C {devices/lab_pin.sym} 123050 -28710 0 0 {name=p122122 lab=_85354_/CLK }
C {devices/lab_pin.sym} 123050 -28690 0 0 {name=p122123 lab=_85354_/D }
C {devices/lab_pin.sym} 123230 -28710 0 1 {name=p122124 lab=_85354_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -28700 0 0 {name=X_85354_ }
C {devices/lab_pin.sym} 123100 -28570 0 0 {name=p122125 lab=_46892_/A }
C {devices/lab_pin.sym} 123180 -28570 0 1 {name=p122126 lab=_51747_/A }
C {sky130_stdcells/buf_2.sym} 123140 -28570 0 0 {name=X_51746_ }
C {sky130_stdcells/decap_3.sym} 123140 -28420 0 0 {name=XPHY_22 }
C {devices/lab_pin.sym} 123100 -28270 0 0 {name=p122127 lab=_70579_/Y }
C {devices/lab_pin.sym} 123180 -28270 0 1 {name=p122128 lab=_74731_/A }
C {sky130_stdcells/buf_2.sym} 123140 -28270 0 0 {name=X_70580_ }
C {devices/lab_pin.sym} 123050 -28150 0 0 {name=p122129 lab=_82879_/CLK }
C {devices/lab_pin.sym} 123050 -28130 0 0 {name=p122130 lab=_82598_/Q }
C {devices/lab_pin.sym} 123230 -28150 0 1 {name=p122131 lab=_82566_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -28140 0 0 {name=X_82566_ }
C {sky130_stdcells/decap_3.sym} 123140 -27980 0 0 {name=XPHY_33 }
C {sky130_stdcells/decap_3.sym} 123140 -27800 0 0 {name=XPHY_44 }
C {sky130_stdcells/decap_3.sym} 123140 -27620 0 0 {name=XPHY_55 }
C {devices/lab_pin.sym} 123050 -27470 0 0 {name=p122132 lab=_84308_/CLK }
C {devices/lab_pin.sym} 123050 -27450 0 0 {name=p122133 lab=_84305_/D }
C {devices/lab_pin.sym} 123230 -27470 0 1 {name=p122134 lab=_80371_/B }
C {sky130_stdcells/dfxtp_4.sym} 123140 -27460 0 0 {name=X_84305_ }
C {devices/lab_pin.sym} 123100 -27330 0 0 {name=p122135 lab=_56774_/A }
C {devices/lab_pin.sym} 123180 -27330 0 1 {name=p122136 lab=_57359_/A }
C {sky130_stdcells/buf_2.sym} 123140 -27330 0 0 {name=X_57253_ }
C {devices/lab_pin.sym} 123050 -27210 0 0 {name=p122137 lab=_81749_/CLK }
C {devices/lab_pin.sym} 123050 -27190 0 0 {name=p122138 lab=_81561_/Q }
C {devices/lab_pin.sym} 123230 -27210 0 1 {name=p122139 lab=_81517_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -27200 0 0 {name=X_81517_ }
C {sky130_stdcells/decap_3.sym} 123140 -27040 0 0 {name=XPHY_66 }
C {devices/lab_pin.sym} 123100 -26890 0 0 {name=p122140 lab=_69485_/A }
C {devices/lab_pin.sym} 123180 -26890 0 1 {name=p122141 lab=_69239_/X }
C {sky130_stdcells/buf_2.sym} 123140 -26890 0 0 {name=X_69239_ }
C {devices/lab_pin.sym} 123050 -26770 0 0 {name=p122142 lab=_88326_/CLK }
C {devices/lab_pin.sym} 123050 -26750 0 0 {name=p122143 lab=_42009_/Y }
C {devices/lab_pin.sym} 123230 -26770 0 1 {name=p122144 lab=_73033_/A }
C {sky130_stdcells/dfxtp_4.sym} 123140 -26760 0 0 {name=X_88073_ }
C {devices/lab_pin.sym} 123060 -26650 0 0 {name=p122145 lab=_85437_/Q }
C {devices/lab_pin.sym} 123060 -26610 0 0 {name=p122146 lab=_54457_/X }
C {devices/lab_pin.sym} 123060 -26570 0 0 {name=p122147 lab=_54464_/Y }
C {devices/lab_pin.sym} 123220 -26610 0 1 {name=p122148 lab=_54465_/Y }
C {sky130_stdcells/o21ai_4.sym} 123140 -26610 0 0 {name=X_54465_ }
C {devices/lab_pin.sym} 123050 -26470 0 0 {name=p122149 lab=_83013_/CLK }
C {devices/lab_pin.sym} 123050 -26450 0 0 {name=p122150 lab=_56161_/Y }
C {devices/lab_pin.sym} 123230 -26470 0 1 {name=p122151 lab=_85285_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -26460 0 0 {name=X_85285_ }
C {devices/lab_pin.sym} 123080 -26340 0 0 {name=p122152 lab=_51697_/A }
C {devices/lab_pin.sym} 123080 -26300 0 0 {name=p122153 lab=_53200_/B }
C {devices/lab_pin.sym} 123200 -26320 0 1 {name=p122154 lab=_51677_/Y }
C {sky130_stdcells/nand2_4.sym} 123140 -26320 0 0 {name=X_51677_ }
C {sky130_stdcells/decap_3.sym} 123140 -26160 0 0 {name=XPHY_77 }
C {devices/lab_pin.sym} 123050 -26010 0 0 {name=p122155 lab=_82589_/CLK }
C {devices/lab_pin.sym} 123050 -25990 0 0 {name=p122156 lab=_78801_/Y }
C {devices/lab_pin.sym} 123230 -26010 0 1 {name=p122157 lab=_78241_/B }
C {sky130_stdcells/dfxtp_4.sym} 123140 -26000 0 0 {name=X_82497_ }
C {sky130_stdcells/decap_3.sym} 123140 -25840 0 0 {name=XPHY_88 }
C {sky130_stdcells/decap_3.sym} 123140 -25660 0 0 {name=XPHY_99 }
C {devices/lab_pin.sym} 123060 -25530 0 0 {name=p122158 lab=_56026_/X }
C {devices/lab_pin.sym} 123060 -25490 0 0 {name=p122159 lab=_56195_/X }
C {devices/lab_pin.sym} 123060 -25450 0 0 {name=p122160 lab=_56203_/Y }
C {devices/lab_pin.sym} 123220 -25490 0 1 {name=p122161 lab=_85277_/D }
C {sky130_stdcells/o21ai_4.sym} 123140 -25490 0 0 {name=X_56204_ }
C {devices/lab_pin.sym} 123060 -25380 0 0 {name=p122162 lab=_41429_/X }
C {devices/lab_pin.sym} 123060 -25340 0 0 {name=p122163 lab=_41418_/X }
C {devices/lab_pin.sym} 123060 -25300 0 0 {name=p122164 lab=_88217_/Q }
C {devices/lab_pin.sym} 123060 -25260 0 0 {name=p122165 lab=_41419_/X }
C {devices/lab_pin.sym} 123220 -25320 0 1 {name=p122166 lab=_41430_/X }
C {sky130_stdcells/a2bb2o_4.sym} 123140 -25320 0 0 {name=X_41430_ }
C {devices/lab_pin.sym} 123050 -25170 0 0 {name=p122167 lab=_87032_/CLK }
C {devices/lab_pin.sym} 123050 -25150 0 0 {name=p122168 lab=_87024_/D }
C {devices/lab_pin.sym} 123230 -25170 0 1 {name=p122169 lab=_87024_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -25160 0 0 {name=X_87024_ }
C {devices/lab_pin.sym} 123080 -25040 0 0 {name=p122170 lab=_53405_/X }
C {devices/lab_pin.sym} 123080 -25000 0 0 {name=p122171 lab=_47184_/A }
C {devices/lab_pin.sym} 123200 -25020 0 1 {name=p122172 lab=_53416_/Y }
C {sky130_stdcells/nand2_4.sym} 123140 -25020 0 0 {name=X_53416_ }
C {devices/lab_pin.sym} 123100 -24890 0 0 {name=p122173 lab=_72250_/A }
C {devices/lab_pin.sym} 123180 -24890 0 1 {name=p122174 lab=_72250_/X }
C {sky130_stdcells/buf_2.sym} 123140 -24890 0 0 {name=X_72250_ }
C {devices/lab_pin.sym} 123050 -24770 0 0 {name=p122175 lab=_82797_/CLK }
C {devices/lab_pin.sym} 123050 -24750 0 0 {name=p122176 lab=_84236_/D }
C {devices/lab_pin.sym} 123230 -24770 0 1 {name=p122177 lab=_79554_/B }
C {sky130_stdcells/dfxtp_4.sym} 123140 -24760 0 0 {name=X_84236_ }
C {devices/lab_pin.sym} 123080 -24640 0 0 {name=p122178 lab=_50627_/X }
C {devices/lab_pin.sym} 123080 -24600 0 0 {name=p122179 lab=_49015_/X }
C {devices/lab_pin.sym} 123200 -24620 0 1 {name=p122180 lab=_50628_/Y }
C {sky130_stdcells/nand2_4.sym} 123140 -24620 0 0 {name=X_50628_ }
C {devices/lab_pin.sym} 123080 -24500 0 0 {name=p122181 lab=_85066_/Q }
C {devices/lab_pin.sym} 123080 -24460 0 0 {name=p122182 lab=_57026_/X }
C {devices/lab_pin.sym} 123200 -24480 0 1 {name=p122183 lab=_57184_/Y }
C {sky130_stdcells/nor2_4.sym} 123140 -24480 0 0 {name=X_57184_ }
C {devices/lab_pin.sym} 123050 -24350 0 0 {name=p122184 lab=_81575_/CLK }
C {devices/lab_pin.sym} 123050 -24330 0 0 {name=p122185 lab=_81448_/D }
C {devices/lab_pin.sym} 123230 -24350 0 1 {name=p122186 lab=_81448_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -24340 0 0 {name=X_81448_ }
C {devices/lab_pin.sym} 123060 -24230 0 0 {name=p122187 lab=_54393_/Y }
C {devices/lab_pin.sym} 123060 -24190 0 0 {name=p122188 lab=_54394_/X }
C {devices/lab_pin.sym} 123060 -24150 0 0 {name=p122189 lab=_54395_/X }
C {devices/lab_pin.sym} 123220 -24190 0 1 {name=p122190 lab=_85450_/D }
C {sky130_stdcells/a21oi_4.sym} 123140 -24190 0 0 {name=X_54396_ }
C {devices/lab_pin.sym} 123100 -24050 0 0 {name=p122191 lab=clkbuf_9_346_0_CLK/X }
C {devices/lab_pin.sym} 123180 -24050 0 1 {name=p122192 lab=_87883_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 123140 -24050 0 0 {name=Xclkbuf_10_693_0_CLK }
C {devices/lab_pin.sym} 123100 -23930 0 0 {name=p122193 lab=_70382_/A }
C {devices/lab_pin.sym} 123180 -23930 0 1 {name=p122194 lab=_71226_/B }
C {sky130_stdcells/buf_2.sym} 123140 -23930 0 0 {name=X_71201_ }
C {devices/lab_pin.sym} 123100 -23810 0 0 {name=p122195 lab=_56104_/A }
C {devices/lab_pin.sym} 123180 -23810 0 1 {name=p122196 lab=_56140_/A }
C {sky130_stdcells/buf_2.sym} 123140 -23810 0 0 {name=X_56135_ }
C {devices/lab_pin.sym} 123100 -23690 0 0 {name=p122197 lab=_41360_/Y }
C {devices/lab_pin.sym} 123180 -23690 0 1 {name=p122198 lab=_41361_/X }
C {sky130_stdcells/buf_2.sym} 123140 -23690 0 0 {name=X_41361_ }
C {devices/lab_pin.sym} 123100 -23570 0 0 {name=p122199 lab=_53347_/A }
C {devices/lab_pin.sym} 123180 -23570 0 1 {name=p122200 lab=_53371_/B }
C {sky130_stdcells/buf_2.sym} 123140 -23570 0 0 {name=X_53347_ }
C {devices/lab_pin.sym} 123060 -23470 0 0 {name=p122201 lab=_72180_/X }
C {devices/lab_pin.sym} 123060 -23430 0 0 {name=p122202 lab=_85340_/Q }
C {devices/lab_pin.sym} 123060 -23390 0 0 {name=p122203 lab=_59365_/X }
C {devices/lab_pin.sym} 123220 -23430 0 1 {name=p122204 lab=_72181_/X }
C {sky130_stdcells/o21a_4.sym} 123140 -23430 0 0 {name=X_72181_ }
C {devices/lab_pin.sym} 123050 -23290 0 0 {name=p122205 lab=_84166_/CLK }
C {devices/lab_pin.sym} 123050 -23270 0 0 {name=p122206 lab=_65944_/X }
C {devices/lab_pin.sym} 123230 -23290 0 1 {name=p122207 lab=_84167_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -23280 0 0 {name=X_84167_ }
C {devices/lab_pin.sym} 123060 -23170 0 0 {name=p122208 lab=_86177_/Q }
C {devices/lab_pin.sym} 123060 -23130 0 0 {name=p122209 lab=_50533_/X }
C {devices/lab_pin.sym} 123060 -23090 0 0 {name=p122210 lab=_50558_/Y }
C {devices/lab_pin.sym} 123220 -23130 0 1 {name=p122211 lab=_50559_/Y }
C {sky130_stdcells/o21ai_4.sym} 123140 -23130 0 0 {name=X_50559_ }
C {devices/lab_pin.sym} 123050 -22990 0 0 {name=p122212 lab=_80784_/CLK }
C {devices/lab_pin.sym} 123050 -22970 0 0 {name=p122213 lab=_83915_/Q }
C {devices/lab_pin.sym} 123230 -22990 0 1 {name=p122214 lab=_76804_/B }
C {sky130_stdcells/dfxtp_4.sym} 123140 -22980 0 0 {name=X_81379_ }
C {devices/lab_pin.sym} 123100 -22850 0 0 {name=p122215 lab=clkbuf_8_92_0_CLK/X }
C {devices/lab_pin.sym} 123180 -22850 0 1 {name=p122216 lab=clkbuf_9_184_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 123140 -22850 0 0 {name=Xclkbuf_9_184_0_CLK }
C {devices/lab_pin.sym} 123100 -22730 0 0 {name=p122217 lab=_43146_/A }
C {devices/lab_pin.sym} 123180 -22730 0 1 {name=p122218 lab=_43100_/X }
C {sky130_stdcells/buf_2.sym} 123140 -22730 0 0 {name=X_43100_ }
C {devices/lab_pin.sym} 123060 -22630 0 0 {name=p122219 lab=_50716_/B }
C {devices/lab_pin.sym} 123060 -22590 0 0 {name=p122220 lab=_71117_/A }
C {devices/lab_pin.sym} 123060 -22550 0 0 {name=p122221 lab=_71131_/Y }
C {devices/lab_pin.sym} 123220 -22590 0 1 {name=p122222 lab=_71132_/Y }
C {sky130_stdcells/o21ai_4.sym} 123140 -22590 0 0 {name=X_71132_ }
C {devices/lab_pin.sym} 123050 -22450 0 0 {name=p122223 lab=_86213_/CLK }
C {devices/lab_pin.sym} 123050 -22430 0 0 {name=p122224 lab=_74203_/X }
C {devices/lab_pin.sym} 123230 -22450 0 1 {name=p122225 lab=_70129_/B }
C {sky130_stdcells/dfxtp_4.sym} 123140 -22440 0 0 {name=X_83118_ }
C {devices/lab_pin.sym} 123100 -22310 0 0 {name=p122226 lab=_44079_/X }
C {devices/lab_pin.sym} 123180 -22310 0 1 {name=p122227 lab=_55549_/A }
C {sky130_stdcells/buf_2.sym} 123140 -22310 0 0 {name=X_44080_ }
C {devices/lab_pin.sym} 123080 -22210 0 0 {name=p122228 lab=_56052_/A }
C {devices/lab_pin.sym} 123080 -22170 0 0 {name=p122229 lab=_56086_/B }
C {devices/lab_pin.sym} 123080 -22130 0 0 {name=p122230 lab=_55889_/B }
C {devices/lab_pin.sym} 123200 -22170 0 1 {name=p122231 lab=_56066_/Y }
C {sky130_stdcells/nand3_4.sym} 123140 -22170 0 0 {name=X_56066_ }
C {devices/lab_pin.sym} 123080 -22040 0 0 {name=p122232 lab=_41634_/B }
C {devices/lab_pin.sym} 123080 -22000 0 0 {name=p122233 lab=_41292_/B }
C {devices/lab_pin.sym} 123200 -22020 0 1 {name=p122234 lab=_41292_/X }
C {sky130_stdcells/or2_4.sym} 123140 -22020 0 0 {name=X_41292_ }
C {devices/lab_pin.sym} 123080 -21920 0 0 {name=p122235 lab=_51914_/A }
C {devices/lab_pin.sym} 123080 -21880 0 0 {name=p122236 lab=_53274_/B }
C {devices/lab_pin.sym} 123080 -21840 0 0 {name=p122237 lab=_53293_/C }
C {devices/lab_pin.sym} 123080 -21800 0 0 {name=p122238 lab=_52763_/D }
C {devices/lab_pin.sym} 123200 -21860 0 1 {name=p122239 lab=_53278_/X }
C {sky130_stdcells/and4_4.sym} 123140 -21860 0 0 {name=X_53278_ }
C {devices/lab_pin.sym} 123050 -21710 0 0 {name=p122240 lab=_80928_/CLK }
C {devices/lab_pin.sym} 123050 -21690 0 0 {name=p122241 lab=_84098_/D }
C {devices/lab_pin.sym} 123230 -21710 0 1 {name=p122242 lab=_84098_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -21700 0 0 {name=X_84098_ }
C {devices/lab_pin.sym} 123100 -21570 0 0 {name=p122243 lab=_43189_/A }
C {devices/lab_pin.sym} 123180 -21570 0 1 {name=p122244 lab=_43031_/X }
C {sky130_stdcells/buf_2.sym} 123140 -21570 0 0 {name=X_43031_ }
C {devices/lab_pin.sym} 123100 -21450 0 0 {name=p122245 lab=_46614_/X }
C {devices/lab_pin.sym} 123180 -21450 0 1 {name=p122246 lab=_55017_/X }
C {sky130_stdcells/buf_2.sym} 123140 -21450 0 0 {name=X_55017_ }
C {devices/lab_pin.sym} 123060 -21350 0 0 {name=p122247 lab=_52226_/Y }
C {devices/lab_pin.sym} 123060 -21310 0 0 {name=p122248 lab=_52203_/X }
C {devices/lab_pin.sym} 123060 -21270 0 0 {name=p122249 lab=_52228_/X }
C {devices/lab_pin.sym} 123220 -21310 0 1 {name=p122250 lab=_85864_/D }
C {sky130_stdcells/a21oi_4.sym} 123140 -21310 0 0 {name=X_52229_ }
C {devices/lab_pin.sym} 123060 -21190 0 0 {name=p122251 lab=_52287_/B }
C {devices/lab_pin.sym} 123060 -21150 0 0 {name=p122252 lab=_71046_/X }
C {devices/lab_pin.sym} 123060 -21110 0 0 {name=p122253 lab=_71062_/Y }
C {devices/lab_pin.sym} 123220 -21150 0 1 {name=p122254 lab=_83620_/D }
C {sky130_stdcells/o21ai_4.sym} 123140 -21150 0 0 {name=X_71063_ }
C {devices/lab_pin.sym} 123080 -21020 0 0 {name=p122255 lab=_81701_/D }
C {devices/lab_pin.sym} 123080 -20980 0 0 {name=p122256 lab=_75940_/B }
C {devices/lab_pin.sym} 123200 -21000 0 1 {name=p122257 lab=_75940_/Y }
C {sky130_stdcells/xnor2_4.sym} 123140 -21000 0 0 {name=X_75940_ }
C {devices/lab_pin.sym} 123050 -20870 0 0 {name=p122258 lab=_83049_/CLK }
C {devices/lab_pin.sym} 123050 -20850 0 0 {name=p122259 lab=_74519_/Y }
C {devices/lab_pin.sym} 123230 -20870 0 1 {name=p122260 lab=_83049_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -20860 0 0 {name=X_83049_ }
C {devices/lab_pin.sym} 123050 -20730 0 0 {name=p122261 lab=_87926_/CLK }
C {devices/lab_pin.sym} 123050 -20710 0 0 {name=p122262 lab=_42314_/Y }
C {devices/lab_pin.sym} 123230 -20730 0 1 {name=p122263 lab=_87926_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -20720 0 0 {name=X_87926_ }
C {devices/lab_pin.sym} 123060 -20620 0 0 {name=p122264 lab=_70011_/X }
C {devices/lab_pin.sym} 123060 -20580 0 0 {name=p122265 lab=_68574_/Y }
C {devices/lab_pin.sym} 123060 -20540 0 0 {name=p122266 lab=_70012_/X }
C {devices/lab_pin.sym} 123060 -20500 0 0 {name=p122267 lab=_70013_/Y }
C {devices/lab_pin.sym} 123220 -20560 0 1 {name=p122268 lab=_70014_/X }
C {sky130_stdcells/a211o_4.sym} 123140 -20560 0 0 {name=X_70014_ }
C {devices/lab_pin.sym} 123080 -20420 0 0 {name=p122269 lab=_59794_/A }
C {devices/lab_pin.sym} 123080 -20380 0 0 {name=p122270 lab=_59825_/B }
C {devices/lab_pin.sym} 123200 -20400 0 1 {name=p122271 lab=_59825_/X }
C {sky130_stdcells/and2_4.sym} 123140 -20400 0 0 {name=X_59825_ }
C {devices/lab_pin.sym} 123080 -20280 0 0 {name=p122272 lab=_81105_/Q }
C {devices/lab_pin.sym} 123080 -20240 0 0 {name=p122273 lab=_80817_/Q }
C {devices/lab_pin.sym} 123200 -20260 0 1 {name=p122274 lab=_75872_/B }
C {sky130_stdcells/xor2_4.sym} 123140 -20260 0 0 {name=X_75871_ }
C {devices/lab_pin.sym} 123050 -20130 0 0 {name=p122275 lab=_86984_/CLK }
C {devices/lab_pin.sym} 123050 -20110 0 0 {name=p122276 lab=_87857_/D }
C {devices/lab_pin.sym} 123230 -20130 0 1 {name=p122277 lab=_87857_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -20120 0 0 {name=X_87857_ }
C {devices/lab_pin.sym} 123100 -19990 0 0 {name=p122278 lab=clkbuf_8_99_0_CLK/X }
C {devices/lab_pin.sym} 123180 -19990 0 1 {name=p122279 lab=clkbuf_9_199_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 123140 -19990 0 0 {name=Xclkbuf_9_199_0_CLK }
C {devices/lab_pin.sym} 123100 -19870 0 0 {name=p122280 lab=_82236_/Q }
C {devices/lab_pin.sym} 123180 -19870 0 1 {name=p122281 lab=_77614_/A }
C {sky130_stdcells/inv_2.sym} 123140 -19870 0 0 {name=X_77610_ }
C {devices/lab_pin.sym} 123100 -19750 0 0 {name=p122282 lab=_74822_/A }
C {devices/lab_pin.sym} 123180 -19750 0 1 {name=p122283 lab=_74822_/Y }
C {sky130_stdcells/inv_2.sym} 123140 -19750 0 0 {name=X_74822_ }
C {devices/lab_pin.sym} 123050 -19630 0 0 {name=p122284 lab=_86807_/CLK }
C {devices/lab_pin.sym} 123050 -19610 0 0 {name=p122285 lab=_86808_/D }
C {devices/lab_pin.sym} 123230 -19630 0 1 {name=p122286 lab=_67287_/B }
C {sky130_stdcells/dfxtp_4.sym} 123140 -19620 0 0 {name=X_86808_ }
C {devices/lab_pin.sym} 123060 -19510 0 0 {name=p122287 lab=_47765_/Y }
C {devices/lab_pin.sym} 123060 -19470 0 0 {name=p122288 lab=_47745_/X }
C {devices/lab_pin.sym} 123060 -19430 0 0 {name=p122289 lab=_47769_/X }
C {devices/lab_pin.sym} 123220 -19470 0 1 {name=p122290 lab=_86600_/D }
C {sky130_stdcells/a21oi_4.sym} 123140 -19470 0 0 {name=X_47770_ }
C {devices/lab_pin.sym} 123100 -19330 0 0 {name=p122291 lab=_59756_/A }
C {devices/lab_pin.sym} 123180 -19330 0 1 {name=p122292 lab=_59756_/X }
C {sky130_stdcells/buf_2.sym} 123140 -19330 0 0 {name=X_59756_ }
C {devices/lab_pin.sym} 123080 -19220 0 0 {name=p122293 lab=_78588_/X }
C {devices/lab_pin.sym} 123080 -19180 0 0 {name=p122294 lab=_78589_/Y }
C {devices/lab_pin.sym} 123200 -19200 0 1 {name=p122295 lab=_78602_/A }
C {sky130_stdcells/and2_4.sym} 123140 -19200 0 0 {name=X_78590_ }
C {devices/lab_pin.sym} 123100 -19070 0 0 {name=p122296 lab=_45281_/A }
C {devices/lab_pin.sym} 123180 -19070 0 1 {name=p122297 lab=_44982_/X }
C {sky130_stdcells/buf_2.sym} 123140 -19070 0 0 {name=X_44982_ }
C {devices/lab_pin.sym} 123060 -18980 0 0 {name=p122298 lab=_56966_/X }
C {devices/lab_pin.sym} 123060 -18940 0 0 {name=p122299 lab=_56643_/X }
C {devices/lab_pin.sym} 123060 -18900 0 0 {name=p122300 lab=_85107_/Q }
C {devices/lab_pin.sym} 123060 -18860 0 0 {name=p122301 lab=_56989_/A }
C {devices/lab_pin.sym} 123220 -18920 0 1 {name=p122302 lab=_85107_/D }
C {sky130_stdcells/a2bb2o_4.sym} 123140 -18920 0 0 {name=X_56968_ }
C {devices/lab_pin.sym} 123050 -18770 0 0 {name=p122303 lab=_87544_/CLK }
C {devices/lab_pin.sym} 123050 -18750 0 0 {name=p122304 lab=_42646_/Y }
C {devices/lab_pin.sym} 123230 -18770 0 1 {name=p122305 lab=_87788_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -18760 0 0 {name=X_87788_ }
C {devices/lab_pin.sym} 123100 -18630 0 0 {name=p122306 lab=clkbuf_9_315_0_CLK/X }
C {devices/lab_pin.sym} 123180 -18630 0 1 {name=p122307 lab=_82009_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 123140 -18630 0 0 {name=Xclkbuf_10_631_0_CLK }
C {devices/lab_pin.sym} 123100 -18510 0 0 {name=p122308 lab=_46721_/A }
C {devices/lab_pin.sym} 123180 -18510 0 1 {name=p122309 lab=_52637_/B }
C {sky130_stdcells/inv_2.sym} 123140 -18510 0 0 {name=X_46721_ }
C {devices/lab_pin.sym} 123060 -18410 0 0 {name=p122310 lab=_58682_/X }
C {devices/lab_pin.sym} 123060 -18370 0 0 {name=p122311 lab=_85782_/Q }
C {devices/lab_pin.sym} 123060 -18330 0 0 {name=p122312 lab=_58706_/X }
C {devices/lab_pin.sym} 123220 -18370 0 1 {name=p122313 lab=_58707_/X }
C {sky130_stdcells/o21a_4.sym} 123140 -18370 0 0 {name=X_58707_ }
C {devices/lab_pin.sym} 123060 -18250 0 0 {name=p122314 lab=_77540_/B }
C {devices/lab_pin.sym} 123060 -18210 0 0 {name=p122315 lab=_77540_/C }
C {devices/lab_pin.sym} 123060 -18170 0 0 {name=p122316 lab=_77540_/A }
C {devices/lab_pin.sym} 123220 -18210 0 1 {name=p122317 lab=_77542_/A }
C {sky130_stdcells/o21a_4.sym} 123140 -18210 0 0 {name=X_77541_ }
C {devices/lab_pin.sym} 123060 -18100 0 0 {name=p122318 lab=_41429_/X }
C {devices/lab_pin.sym} 123060 -18060 0 0 {name=p122319 lab=_43928_/X }
C {devices/lab_pin.sym} 123060 -18020 0 0 {name=p122320 lab=_67955_/B }
C {devices/lab_pin.sym} 123060 -17980 0 0 {name=p122321 lab=_43929_/X }
C {devices/lab_pin.sym} 123220 -18040 0 1 {name=p122322 lab=_87193_/D }
C {sky130_stdcells/a2bb2o_4.sym} 123140 -18040 0 0 {name=X_43933_ }
C {devices/lab_pin.sym} 123080 -17900 0 0 {name=p122323 lab=_55620_/A }
C {devices/lab_pin.sym} 123080 -17860 0 0 {name=p122324 lab=_56306_/C }
C {devices/lab_pin.sym} 123200 -17880 0 1 {name=p122325 lab=_55919_/X }
C {sky130_stdcells/and2_4.sym} 123140 -17880 0 0 {name=X_55919_ }
C {devices/lab_pin.sym} 123100 -17750 0 0 {name=p122326 lab=_74731_/A }
C {devices/lab_pin.sym} 123180 -17750 0 1 {name=p122327 lab=_74753_/X }
C {sky130_stdcells/buf_2.sym} 123140 -17750 0 0 {name=X_74753_ }
C {devices/lab_pin.sym} 123050 -17630 0 0 {name=p122328 lab=_85815_/CLK }
C {devices/lab_pin.sym} 123050 -17610 0 0 {name=p122329 lab=_46418_/Y }
C {devices/lab_pin.sym} 123230 -17630 0 1 {name=p122330 lab=_86739_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -17620 0 0 {name=X_86739_ }
C {devices/lab_pin.sym} 123080 -17510 0 0 {name=p122331 lab=_48893_/A }
C {devices/lab_pin.sym} 123080 -17470 0 0 {name=p122332 lab=_71959_/X }
C {devices/lab_pin.sym} 123080 -17430 0 0 {name=p122333 lab=_71964_/X }
C {devices/lab_pin.sym} 123200 -17470 0 1 {name=p122334 lab=_71965_/X }
C {sky130_stdcells/and3_4.sym} 123140 -17470 0 0 {name=X_71965_ }
C {devices/lab_pin.sym} 123080 -17360 0 0 {name=p122335 lab=_59687_/A }
C {devices/lab_pin.sym} 123080 -17320 0 0 {name=p122336 lab=_59687_/B }
C {devices/lab_pin.sym} 123080 -17280 0 0 {name=p122337 lab=_59687_/C }
C {devices/lab_pin.sym} 123080 -17240 0 0 {name=p122338 lab=_59686_/Y }
C {devices/lab_pin.sym} 123200 -17300 0 1 {name=p122339 lab=_59687_/Y }
C {sky130_stdcells/nand4_4.sym} 123140 -17300 0 0 {name=X_59687_ }
C {devices/lab_pin.sym} 123080 -17170 0 0 {name=p122340 lab=_56675_/X }
C {devices/lab_pin.sym} 123080 -17130 0 0 {name=p122341 lab=_56876_/X }
C {devices/lab_pin.sym} 123080 -17090 0 0 {name=p122342 lab=_83330_/Q }
C {devices/lab_pin.sym} 123200 -17130 0 1 {name=p122343 lab=_56899_/Y }
C {sky130_stdcells/nand3_4.sym} 123140 -17130 0 0 {name=X_56899_ }
C {devices/lab_pin.sym} 123100 -16990 0 0 {name=p122344 lab=clkbuf_8_61_0_CLK/X }
C {devices/lab_pin.sym} 123180 -16990 0 1 {name=p122345 lab=clkbuf_9_122_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 123140 -16990 0 0 {name=Xclkbuf_9_122_0_CLK }
C {devices/lab_pin.sym} 123100 -16870 0 0 {name=p122346 lab=_49493_/A }
C {devices/lab_pin.sym} 123180 -16870 0 1 {name=p122347 lab=_49447_/C }
C {sky130_stdcells/buf_2.sym} 123140 -16870 0 0 {name=X_49440_ }
C {devices/lab_pin.sym} 123100 -16750 0 0 {name=p122348 lab=_73704_/A }
C {devices/lab_pin.sym} 123180 -16750 0 1 {name=p122349 lab=_73704_/X }
C {sky130_stdcells/buf_2.sym} 123140 -16750 0 0 {name=X_73704_ }
C {devices/lab_pin.sym} 123080 -16660 0 0 {name=p122350 lab=_70863_/A }
C {devices/lab_pin.sym} 123080 -16620 0 0 {name=p122351 lab=_70914_/B }
C {devices/lab_pin.sym} 123080 -16580 0 0 {name=p122352 lab=_70914_/C }
C {devices/lab_pin.sym} 123080 -16540 0 0 {name=p122353 lab=_70914_/D }
C {devices/lab_pin.sym} 123200 -16600 0 1 {name=p122354 lab=_70916_/Y }
C {sky130_stdcells/nand4_4.sym} 123140 -16600 0 0 {name=X_70916_ }
C {devices/lab_pin.sym} 123060 -16470 0 0 {name=p122355 lab=_86717_/Q }
C {devices/lab_pin.sym} 123060 -16430 0 0 {name=p122356 lab=_46622_/X }
C {devices/lab_pin.sym} 123060 -16390 0 0 {name=p122357 lab=_46651_/Y }
C {devices/lab_pin.sym} 123220 -16430 0 1 {name=p122358 lab=_46652_/Y }
C {sky130_stdcells/o21ai_4.sym} 123140 -16430 0 0 {name=X_46652_ }
C {devices/lab_pin.sym} 123060 -16320 0 0 {name=p122359 lab=_58623_/Y }
C {devices/lab_pin.sym} 123060 -16280 0 0 {name=p122360 lab=_58624_/X }
C {devices/lab_pin.sym} 123060 -16240 0 0 {name=p122361 lab=_58630_/X }
C {devices/lab_pin.sym} 123060 -16200 0 0 {name=p122362 lab=_58637_/X }
C {devices/lab_pin.sym} 123220 -16260 0 1 {name=p122363 lab=_84812_/D }
C {sky130_stdcells/a22oi_4.sym} 123140 -16260 0 0 {name=X_58638_ }
C {devices/lab_pin.sym} 123100 -16110 0 0 {name=p122364 lab=_77472_/A }
C {devices/lab_pin.sym} 123180 -16110 0 1 {name=p122365 lab=_77475_/B }
C {sky130_stdcells/inv_2.sym} 123140 -16110 0 0 {name=X_77472_ }
C {devices/lab_pin.sym} 123060 -16030 0 0 {name=p122366 lab=_43862_/X }
C {devices/lab_pin.sym} 123060 -15990 0 0 {name=p122367 lab=_43854_/X }
C {devices/lab_pin.sym} 123060 -15950 0 0 {name=p122368 lab=_41234_/X }
C {devices/lab_pin.sym} 123060 -15910 0 0 {name=p122369 lab=_68944_/B }
C {devices/lab_pin.sym} 123060 -15870 0 0 {name=p122370 lab=_43863_/X }
C {devices/lab_pin.sym} 123220 -15950 0 1 {name=p122371 lab=_43865_/A }
C {sky130_stdcells/o32ai_4.sym} 123140 -15950 0 0 {name=X_43864_ }
C {devices/lab_pin.sym} 123100 -15790 0 0 {name=p122372 lab=_74684_/A }
C {devices/lab_pin.sym} 123180 -15790 0 1 {name=p122373 lab=_74684_/Y }
C {sky130_stdcells/inv_2.sym} 123140 -15790 0 0 {name=X_74684_ }
C {devices/lab_pin.sym} 123080 -15700 0 0 {name=p122374 lab=_70368_/X }
C {devices/lab_pin.sym} 123080 -15660 0 0 {name=p122375 lab=_71893_/X }
C {devices/lab_pin.sym} 123080 -15620 0 0 {name=p122376 lab=_71755_/X }
C {devices/lab_pin.sym} 123080 -15580 0 0 {name=p122377 lab=_71898_/D }
C {devices/lab_pin.sym} 123200 -15640 0 1 {name=p122378 lab=_71896_/Y }
C {sky130_stdcells/nand4_4.sym} 123140 -15640 0 0 {name=X_71896_ }
C {devices/lab_pin.sym} 123080 -15500 0 0 {name=p122379 lab=_79211_/A }
C {devices/lab_pin.sym} 123080 -15460 0 0 {name=p122380 lab=_79211_/B }
C {devices/lab_pin.sym} 123200 -15480 0 1 {name=p122381 lab=_79213_/A }
C {sky130_stdcells/nand2_4.sym} 123140 -15480 0 0 {name=X_79211_ }
C {devices/lab_pin.sym} 123060 -15370 0 0 {name=p122382 lab=_45598_/X }
C {devices/lab_pin.sym} 123060 -15330 0 0 {name=p122383 lab=_45601_/X }
C {devices/lab_pin.sym} 123060 -15290 0 0 {name=p122384 lab=_45602_/X }
C {devices/lab_pin.sym} 123220 -15330 0 1 {name=p122385 lab=_45603_/X }
C {sky130_stdcells/a21o_4.sym} 123140 -15330 0 0 {name=X_45603_ }
C {devices/lab_pin.sym} 123080 -15200 0 0 {name=p122386 lab=_76419_/Y }
C {devices/lab_pin.sym} 123080 -15160 0 0 {name=p122387 lab=_76422_/Y }
C {devices/lab_pin.sym} 123200 -15180 0 1 {name=p122388 lab=_76423_/X }
C {sky130_stdcells/xor2_4.sym} 123140 -15180 0 0 {name=X_76423_ }
C {devices/lab_pin.sym} 123060 -15080 0 0 {name=p122389 lab=_41437_/X }
C {devices/lab_pin.sym} 123060 -15040 0 0 {name=p122390 lab=_42802_/X }
C {devices/lab_pin.sym} 123060 -15000 0 0 {name=p122391 lab=_87703_/Q }
C {devices/lab_pin.sym} 123060 -14960 0 0 {name=p122392 lab=_42803_/X }
C {devices/lab_pin.sym} 123220 -15020 0 1 {name=p122393 lab=_87703_/D }
C {sky130_stdcells/a2bb2o_4.sym} 123140 -15020 0 0 {name=X_42815_ }
C {devices/lab_pin.sym} 123060 -14890 0 0 {name=p122394 lab=_49367_/Y }
C {devices/lab_pin.sym} 123060 -14850 0 0 {name=p122395 lab=_49316_/X }
C {devices/lab_pin.sym} 123060 -14810 0 0 {name=p122396 lab=_49370_/X }
C {devices/lab_pin.sym} 123220 -14850 0 1 {name=p122397 lab=_86400_/D }
C {sky130_stdcells/a21oi_4.sym} 123140 -14850 0 0 {name=X_49371_ }
C {devices/lab_pin.sym} 123060 -14730 0 0 {name=p122398 lab=_44675_/Y }
C {devices/lab_pin.sym} 123060 -14690 0 0 {name=p122399 lab=_73420_/X }
C {devices/lab_pin.sym} 123060 -14650 0 0 {name=p122400 lab=_73634_/Y }
C {devices/lab_pin.sym} 123220 -14690 0 1 {name=p122401 lab=_73635_/X }
C {sky130_stdcells/a21o_4.sym} 123140 -14690 0 0 {name=X_73635_ }
C {devices/lab_pin.sym} 123080 -14560 0 0 {name=p122402 lab=_57497_/A }
C {devices/lab_pin.sym} 123080 -14520 0 0 {name=p122403 lab=_52565_/B }
C {devices/lab_pin.sym} 123200 -14540 0 1 {name=p122404 lab=_46583_/Y }
C {sky130_stdcells/nand2_4.sym} 123140 -14540 0 0 {name=X_46583_ }
C {devices/lab_pin.sym} 123060 -14430 0 0 {name=p122405 lab=_46662_/X }
C {devices/lab_pin.sym} 123060 -14390 0 0 {name=p122406 lab=_70830_/Y }
C {devices/lab_pin.sym} 123060 -14350 0 0 {name=p122407 lab=_70846_/Y }
C {devices/lab_pin.sym} 123220 -14390 0 1 {name=p122408 lab=_70847_/Y }
C {sky130_stdcells/o21ai_4.sym} 123140 -14390 0 0 {name=X_70847_ }
C {devices/lab_pin.sym} 123060 -14270 0 0 {name=p122409 lab=_58100_/X }
C {devices/lab_pin.sym} 123060 -14230 0 0 {name=p122410 lab=_85953_/Q }
C {devices/lab_pin.sym} 123060 -14190 0 0 {name=p122411 lab=_58568_/X }
C {devices/lab_pin.sym} 123220 -14230 0 1 {name=p122412 lab=_58569_/X }
C {sky130_stdcells/o21a_4.sym} 123140 -14230 0 0 {name=X_58569_ }
C {devices/lab_pin.sym} 123100 -14090 0 0 {name=p122413 lab=_43795_/A }
C {devices/lab_pin.sym} 123180 -14090 0 1 {name=p122414 lab=_43795_/Y }
C {sky130_stdcells/inv_2.sym} 123140 -14090 0 0 {name=X_43795_ }
C {devices/lab_pin.sym} 123100 -13970 0 0 {name=p122415 lab=clkbuf_9_323_0_CLK/X }
C {devices/lab_pin.sym} 123180 -13970 0 1 {name=p122416 lab=_87915_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 123140 -13970 0 0 {name=Xclkbuf_10_646_0_CLK }
C {devices/lab_pin.sym} 123100 -13850 0 0 {name=p122417 lab=_49247_/A }
C {devices/lab_pin.sym} 123180 -13850 0 1 {name=p122418 lab=_48322_/X }
C {sky130_stdcells/buf_2.sym} 123140 -13850 0 0 {name=X_48322_ }
C {devices/lab_pin.sym} 123080 -13750 0 0 {name=p122419 lab=_60612_/A }
C {devices/lab_pin.sym} 123080 -13710 0 0 {name=p122420 lab=_60612_/B }
C {devices/lab_pin.sym} 123080 -13670 0 0 {name=p122421 lab=_79130_/A }
C {devices/lab_pin.sym} 123200 -13710 0 1 {name=p122422 lab=_60600_/Y }
C {sky130_stdcells/nor3_4.sym} 123140 -13710 0 0 {name=X_60600_ }
C {devices/lab_pin.sym} 123080 -13580 0 0 {name=p122423 lab=_79142_/A }
C {devices/lab_pin.sym} 123080 -13540 0 0 {name=p122424 lab=_79142_/B }
C {devices/lab_pin.sym} 123200 -13560 0 1 {name=p122425 lab=_79142_/X }
C {sky130_stdcells/xor2_4.sym} 123140 -13560 0 0 {name=X_79142_ }
C {devices/lab_pin.sym} 123100 -13430 0 0 {name=p122426 lab=_45612_/A }
C {devices/lab_pin.sym} 123180 -13430 0 1 {name=p122427 lab=_45597_/B }
C {sky130_stdcells/buf_2.sym} 123140 -13430 0 0 {name=X_45534_ }
C {devices/lab_pin.sym} 123080 -13320 0 0 {name=p122428 lab=_76352_/X }
C {devices/lab_pin.sym} 123080 -13280 0 0 {name=p122429 lab=_76353_/Y }
C {devices/lab_pin.sym} 123200 -13300 0 1 {name=p122430 lab=_76381_/B }
C {sky130_stdcells/and2_4.sym} 123140 -13300 0 0 {name=X_76354_ }
C {devices/lab_pin.sym} 123100 -13170 0 0 {name=p122431 lab=_42681_/A }
C {devices/lab_pin.sym} 123180 -13170 0 1 {name=p122432 lab=_42746_/X }
C {sky130_stdcells/buf_2.sym} 123140 -13170 0 0 {name=X_42746_ }
C {devices/lab_pin.sym} 123100 -13050 0 0 {name=p122433 lab=_73163_/A }
C {devices/lab_pin.sym} 123180 -13050 0 1 {name=p122434 lab=_73566_/X }
C {sky130_stdcells/buf_2.sym} 123140 -13050 0 0 {name=X_73566_ }
C {devices/lab_pin.sym} 123100 -12930 0 0 {name=p122435 lab=_84860_/Q }
C {devices/lab_pin.sym} 123180 -12930 0 1 {name=p122436 lab=_61580_/X }
C {sky130_stdcells/buf_2.sym} 123140 -12930 0 0 {name=X_61580_ }
C {devices/lab_pin.sym} 123100 -12810 0 0 {name=p122437 lab=_70778_/A }
C {devices/lab_pin.sym} 123180 -12810 0 1 {name=p122438 lab=_70869_/A }
C {sky130_stdcells/buf_2.sym} 123140 -12810 0 0 {name=X_70778_ }
C {devices/lab_pin.sym} 123100 -12690 0 0 {name=p122439 lab=clkbuf_8_68_0_CLK/X }
C {devices/lab_pin.sym} 123180 -12690 0 1 {name=p122440 lab=clkbuf_9_137_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 123140 -12690 0 0 {name=Xclkbuf_9_137_0_CLK }
C {devices/lab_pin.sym} 123060 -12590 0 0 {name=p122441 lab=_75269_/Y }
C {devices/lab_pin.sym} 123060 -12550 0 0 {name=p122442 lab=_75271_/X }
C {devices/lab_pin.sym} 123060 -12510 0 0 {name=p122443 lab=_75293_/X }
C {devices/lab_pin.sym} 123220 -12550 0 1 {name=p122444 lab=_75305_/X }
C {sky130_stdcells/a21bo_4.sym} 123140 -12550 0 0 {name=X_75305_ }
C {devices/lab_pin.sym} 123060 -12430 0 0 {name=p122445 lab=_48250_/Y }
C {devices/lab_pin.sym} 123060 -12390 0 0 {name=p122446 lab=_48226_/X }
C {devices/lab_pin.sym} 123060 -12350 0 0 {name=p122447 lab=_48252_/Y }
C {devices/lab_pin.sym} 123220 -12390 0 1 {name=p122448 lab=_86548_/D }
C {sky130_stdcells/a21boi_4.sym} 123140 -12390 0 0 {name=X_48253_ }
C {devices/lab_pin.sym} 123100 -12250 0 0 {name=p122449 lab=clkbuf_9_65_0_CLK/A }
C {devices/lab_pin.sym} 123180 -12250 0 1 {name=p122450 lab=clkbuf_9_64_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 123140 -12250 0 0 {name=Xclkbuf_9_64_0_CLK }
C {devices/lab_pin.sym} 123060 -12170 0 0 {name=p122451 lab=_60481_/X }
C {devices/lab_pin.sym} 123060 -12130 0 0 {name=p122452 lab=_60517_/Y }
C {devices/lab_pin.sym} 123060 -12090 0 0 {name=p122453 lab=_60571_/B }
C {devices/lab_pin.sym} 123060 -12050 0 0 {name=p122454 lab=_60529_/Y }
C {devices/lab_pin.sym} 123060 -12020 0 0 {name=p122455 lab=_60530_/Y }
C {devices/lab_pin.sym} 123220 -12090 0 1 {name=p122456 lab=_60531_/Y }
C {sky130_stdcells/a41oi_4.sym} 123140 -12090 0 0 {name=X_60531_ }
C {devices/lab_pin.sym} 123080 -11940 0 0 {name=p122457 lab=_72517_/A }
C {devices/lab_pin.sym} 123080 -11900 0 0 {name=p122458 lab=_72517_/B }
C {devices/lab_pin.sym} 123200 -11920 0 1 {name=p122459 lab=_72517_/Y }
C {sky130_stdcells/nand2_4.sym} 123140 -11920 0 0 {name=X_72517_ }
C {devices/lab_pin.sym} 123080 -11800 0 0 {name=p122460 lab=_82831_/Q }
C {devices/lab_pin.sym} 123080 -11760 0 0 {name=p122461 lab=_82543_/Q }
C {devices/lab_pin.sym} 123200 -11780 0 1 {name=p122462 lab=_79089_/A }
C {sky130_stdcells/xnor2_4.sym} 123140 -11780 0 0 {name=X_79073_ }
C {devices/lab_pin.sym} 123060 -11670 0 0 {name=p122463 lab=_55590_/B }
C {devices/lab_pin.sym} 123060 -11630 0 0 {name=p122464 lab=_45464_/X }
C {devices/lab_pin.sym} 123060 -11590 0 0 {name=p122465 lab=_44919_/X }
C {devices/lab_pin.sym} 123220 -11630 0 1 {name=p122466 lab=_45465_/Y }
C {sky130_stdcells/o21ai_4.sym} 123140 -11630 0 0 {name=X_45465_ }
C {devices/lab_pin.sym} 123060 -11510 0 0 {name=p122467 lab=_76272_/Y }
C {devices/lab_pin.sym} 123060 -11470 0 0 {name=p122468 lab=_76267_/A }
C {devices/lab_pin.sym} 123060 -11430 0 0 {name=p122469 lab=_76267_/B }
C {devices/lab_pin.sym} 123220 -11470 0 1 {name=p122470 lab=_76286_/B }
C {sky130_stdcells/a21boi_4.sym} 123140 -11470 0 0 {name=X_76285_ }
C {devices/lab_pin.sym} 123060 -11370 0 0 {name=p122471 lab=_42665_/X }
C {devices/lab_pin.sym} 123060 -11330 0 0 {name=p122472 lab=_42666_/X }
C {devices/lab_pin.sym} 123060 -11290 0 0 {name=p122473 lab=_41054_/X }
C {devices/lab_pin.sym} 123060 -11250 0 0 {name=p122474 lab=_87774_/Q }
C {devices/lab_pin.sym} 123060 -11210 0 0 {name=p122475 lab=_42673_/X }
C {devices/lab_pin.sym} 123220 -11290 0 1 {name=p122476 lab=_42677_/Y }
C {sky130_stdcells/o32ai_4.sym} 123140 -11290 0 0 {name=X_42677_ }
C {devices/lab_pin.sym} 123080 -11140 0 0 {name=p122477 lab=_73497_/A }
C {devices/lab_pin.sym} 123080 -11100 0 0 {name=p122478 lab=_86468_/Q }
C {devices/lab_pin.sym} 123200 -11120 0 1 {name=p122479 lab=_73497_/X }
C {sky130_stdcells/and2_4.sym} 123140 -11120 0 0 {name=X_73497_ }
C {devices/lab_pin.sym} 123100 -10990 0 0 {name=p122480 lab=_47204_/A }
C {devices/lab_pin.sym} 123180 -10990 0 1 {name=p122481 lab=_53426_/B }
C {sky130_stdcells/inv_2.sym} 123140 -10990 0 0 {name=X_47204_ }
C {devices/lab_pin.sym} 123100 -10870 0 0 {name=p122482 lab=_78024_/A }
C {devices/lab_pin.sym} 123180 -10870 0 1 {name=p122483 lab=_78024_/Y }
C {sky130_stdcells/inv_2.sym} 123140 -10870 0 0 {name=X_78024_ }
C {devices/lab_pin.sym} 123100 -10750 0 0 {name=p122484 lab=_44415_/Y }
C {devices/lab_pin.sym} 123180 -10750 0 1 {name=p122485 lab=_87120_/D }
C {sky130_stdcells/inv_2.sym} 123140 -10750 0 0 {name=X_44416_ }
C {devices/lab_pin.sym} 123100 -10630 0 0 {name=p122486 lab=_60460_/A }
C {devices/lab_pin.sym} 123180 -10630 0 1 {name=p122487 lab=_63250_/X }
C {sky130_stdcells/buf_2.sym} 123140 -10630 0 0 {name=X_63250_ }
C {devices/lab_pin.sym} 123080 -10520 0 0 {name=p122488 lab=_80781_/Q }
C {devices/lab_pin.sym} 123080 -10480 0 0 {name=p122489 lab=_81037_/D }
C {devices/lab_pin.sym} 123200 -10500 0 1 {name=p122490 lab=_80749_/D }
C {sky130_stdcells/xor2_4.sym} 123140 -10500 0 0 {name=X_75236_ }
C {devices/lab_pin.sym} 123100 -10370 0 0 {name=p122491 lab=_40380_/A }
C {devices/lab_pin.sym} 123180 -10370 0 1 {name=p122492 lab=_41628_/X }
C {sky130_stdcells/buf_2.sym} 123140 -10370 0 0 {name=X_41628_ }
C {devices/lab_pin.sym} 123100 -10250 0 0 {name=p122493 lab=_60515_/B }
C {devices/lab_pin.sym} 123180 -10250 0 1 {name=p122494 lab=_60488_/A }
C {sky130_stdcells/buf_2.sym} 123140 -10250 0 0 {name=X_60462_ }
C {devices/lab_pin.sym} 123060 -10170 0 0 {name=p122495 lab=_72413_/X }
C {devices/lab_pin.sym} 123060 -10130 0 0 {name=p122496 lab=_72446_/Y }
C {devices/lab_pin.sym} 123060 -10090 0 0 {name=p122497 lab=_72447_/Y }
C {devices/lab_pin.sym} 123060 -10050 0 0 {name=p122498 lab=_57793_/X }
C {devices/lab_pin.sym} 123060 -10010 0 0 {name=p122499 lab=_72417_/X }
C {devices/lab_pin.sym} 123220 -10090 0 1 {name=p122500 lab=_72448_/X }
C {sky130_stdcells/o32a_4.sym} 123140 -10090 0 0 {name=X_72448_ }
C {devices/lab_pin.sym} 123080 -9940 0 0 {name=p122501 lab=_48184_/A }
C {devices/lab_pin.sym} 123080 -9900 0 0 {name=p122502 lab=_50234_/B }
C {devices/lab_pin.sym} 123200 -9920 0 1 {name=p122503 lab=_48184_/Y }
C {sky130_stdcells/nand2_4.sym} 123140 -9920 0 0 {name=X_48184_ }
C {devices/lab_pin.sym} 123100 -9790 0 0 {name=p122504 lab=_45395_/X }
C {devices/lab_pin.sym} 123180 -9790 0 1 {name=p122505 lab=_45396_/X }
C {sky130_stdcells/buf_2.sym} 123140 -9790 0 0 {name=X_45396_ }
C {devices/lab_pin.sym} 123100 -9670 0 0 {name=p122506 lab=_60084_/A }
C {devices/lab_pin.sym} 123180 -9670 0 1 {name=p122507 lab=_62560_/D }
C {sky130_stdcells/buf_2.sym} 123140 -9670 0 0 {name=X_62201_ }
C {devices/lab_pin.sym} 123100 -9550 0 0 {name=p122508 lab=_47135_/A }
C {devices/lab_pin.sym} 123180 -9550 0 1 {name=p122509 lab=_53390_/B }
C {sky130_stdcells/inv_2.sym} 123140 -9550 0 0 {name=X_47135_ }
C {devices/lab_pin.sym} 123060 -9460 0 0 {name=p122510 lab=_41701_/X }
C {devices/lab_pin.sym} 123060 -9420 0 0 {name=p122511 lab=_44345_/X }
C {devices/lab_pin.sym} 123060 -9380 0 0 {name=p122512 lab=_87154_/Q }
C {devices/lab_pin.sym} 123060 -9340 0 0 {name=p122513 lab=_44346_/X }
C {devices/lab_pin.sym} 123220 -9400 0 1 {name=p122514 lab=_87154_/D }
C {sky130_stdcells/a2bb2o_4.sym} 123140 -9400 0 0 {name=X_44347_ }
C {devices/lab_pin.sym} 123100 -9250 0 0 {name=p122515 lab=_60482_/Y }
C {devices/lab_pin.sym} 123180 -9250 0 1 {name=p122516 lab=_63181_/X }
C {sky130_stdcells/buf_2.sym} 123140 -9250 0 0 {name=X_63181_ }
C {devices/lab_pin.sym} 123080 -9140 0 0 {name=p122517 lab=_75163_/X }
C {devices/lab_pin.sym} 123080 -9100 0 0 {name=p122518 lab=_75167_/B }
C {devices/lab_pin.sym} 123200 -9120 0 1 {name=p122519 lab=_81032_/D }
C {sky130_stdcells/xor2_4.sym} 123140 -9120 0 0 {name=X_75167_ }
C {devices/lab_pin.sym} 123060 -9010 0 0 {name=p122520 lab=_41548_/X }
C {devices/lab_pin.sym} 123060 -8970 0 0 {name=p122521 lab=_82318_/Q }
C {devices/lab_pin.sym} 123060 -8930 0 0 {name=p122522 lab=_41558_/X }
C {devices/lab_pin.sym} 123220 -8970 0 1 {name=p122523 lab=_41559_/Y }
C {sky130_stdcells/o21ai_4.sym} 123140 -8970 0 0 {name=X_41559_ }
C {devices/lab_pin.sym} 123080 -8860 0 0 {name=p122524 lab=_59613_/Y }
C {devices/lab_pin.sym} 123080 -8820 0 0 {name=p122525 lab=_59639_/A }
C {devices/lab_pin.sym} 123080 -8780 0 0 {name=p122526 lab=_60222_/C }
C {devices/lab_pin.sym} 123080 -8740 0 0 {name=p122527 lab=_59532_/A }
C {devices/lab_pin.sym} 123200 -8800 0 1 {name=p122528 lab=_60393_/X }
C {sky130_stdcells/and4_4.sym} 123140 -8800 0 0 {name=X_60393_ }
C {devices/lab_pin.sym} 123060 -8690 0 0 {name=p122529 lab=_57800_/X }
C {devices/lab_pin.sym} 123060 -8650 0 0 {name=p122530 lab=_72377_/Y }
C {devices/lab_pin.sym} 123060 -8610 0 0 {name=p122531 lab=_72378_/Y }
C {devices/lab_pin.sym} 123060 -8570 0 0 {name=p122532 lab=_72296_/X }
C {devices/lab_pin.sym} 123060 -8530 0 0 {name=p122533 lab=_59833_/X }
C {devices/lab_pin.sym} 123220 -8610 0 1 {name=p122534 lab=_72379_/X }
C {sky130_stdcells/o32a_4.sym} 123140 -8610 0 0 {name=X_72379_ }
C {devices/lab_pin.sym} 123100 -8450 0 0 {name=p122535 lab=clkbuf_9_79_0_CLK/A }
C {devices/lab_pin.sym} 123180 -8450 0 1 {name=p122536 lab=clkbuf_9_79_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 123140 -8450 0 0 {name=Xclkbuf_9_79_0_CLK }
C {devices/lab_pin.sym} 123060 -8370 0 0 {name=p122537 lab=_62125_/X }
C {devices/lab_pin.sym} 123060 -8330 0 0 {name=p122538 lab=_62127_/X }
C {devices/lab_pin.sym} 123060 -8290 0 0 {name=p122539 lab=_62131_/Y }
C {devices/lab_pin.sym} 123060 -8250 0 0 {name=p122540 lab=_58352_/A }
C {devices/lab_pin.sym} 123060 -8210 0 0 {name=p122541 lab=_62117_/X }
C {devices/lab_pin.sym} 123220 -8290 0 1 {name=p122542 lab=_62132_/Y }
C {sky130_stdcells/o32ai_4.sym} 123140 -8290 0 0 {name=X_62132_ }
C {devices/lab_pin.sym} 123060 -8150 0 0 {name=p122543 lab=_83122_/Q }
C {devices/lab_pin.sym} 123060 -8110 0 0 {name=p122544 lab=_73549_/X }
C {devices/lab_pin.sym} 123060 -8070 0 0 {name=p122545 lab=_74117_/Y }
C {devices/lab_pin.sym} 123220 -8110 0 1 {name=p122546 lab=_83122_/D }
C {sky130_stdcells/a21o_4.sym} 123140 -8110 0 0 {name=X_74118_ }
C {devices/lab_pin.sym} 123100 -7970 0 0 {name=p122547 lab=_54526_/D }
C {devices/lab_pin.sym} 123180 -7970 0 1 {name=p122548 lab=_52835_/D }
C {sky130_stdcells/buf_2.sym} 123140 -7970 0 0 {name=X_47066_ }
C {devices/lab_pin.sym} 123060 -7870 0 0 {name=p122549 lab=_44266_/Y }
C {devices/lab_pin.sym} 123060 -7830 0 0 {name=p122550 lab=_44268_/Y }
C {devices/lab_pin.sym} 123060 -7790 0 0 {name=p122551 lab=_44277_/X }
C {devices/lab_pin.sym} 123220 -7830 0 1 {name=p122552 lab=_44278_/Y }
C {sky130_stdcells/a21oi_4.sym} 123140 -7830 0 0 {name=X_44278_ }
C {devices/lab_pin.sym} 123080 -7700 0 0 {name=p122553 lab=_79971_/X }
C {devices/lab_pin.sym} 123080 -7660 0 0 {name=p122554 lab=_79972_/Y }
C {devices/lab_pin.sym} 123200 -7680 0 1 {name=p122555 lab=_79975_/Y }
C {sky130_stdcells/nand2_4.sym} 123140 -7680 0 0 {name=X_79975_ }
C {devices/lab_pin.sym} 123080 -7570 0 0 {name=p122556 lab=_75098_/A }
C {devices/lab_pin.sym} 123080 -7530 0 0 {name=p122557 lab=_75100_/A }
C {devices/lab_pin.sym} 123080 -7490 0 0 {name=p122558 lab=_75099_/A }
C {devices/lab_pin.sym} 123200 -7530 0 1 {name=p122559 lab=_75104_/C }
C {sky130_stdcells/nand3_4.sym} 123140 -7530 0 0 {name=X_75098_ }
C {devices/lab_pin.sym} 123060 -7420 0 0 {name=p122560 lab=_40519_/Y }
C {devices/lab_pin.sym} 123060 -7380 0 0 {name=p122561 lab=_46007_/X }
C {devices/lab_pin.sym} 123060 -7340 0 0 {name=p122562 lab=_67179_/B }
C {devices/lab_pin.sym} 123060 -7300 0 0 {name=p122563 lab=_46008_/X }
C {devices/lab_pin.sym} 123220 -7360 0 1 {name=p122564 lab=_46017_/X }
C {sky130_stdcells/a2bb2o_4.sym} 123140 -7360 0 0 {name=X_46017_ }
C {devices/lab_pin.sym} 123100 -7210 0 0 {name=p122565 lab=_43167_/A }
C {devices/lab_pin.sym} 123180 -7210 0 1 {name=p122566 lab=_43229_/X }
C {sky130_stdcells/buf_2.sym} 123140 -7210 0 0 {name=X_43229_ }
C {devices/lab_pin.sym} 123060 -7110 0 0 {name=p122567 lab=_66937_/X }
C {devices/lab_pin.sym} 123060 -7070 0 0 {name=p122568 lab=_66939_/X }
C {devices/lab_pin.sym} 123060 -7030 0 0 {name=p122569 lab=_66843_/X }
C {devices/lab_pin.sym} 123220 -7070 0 1 {name=p122570 lab=_66940_/X }
C {sky130_stdcells/a21o_4.sym} 123140 -7070 0 0 {name=X_66940_ }
C {devices/lab_pin.sym} 123100 -6930 0 0 {name=p122571 lab=_59637_/A }
C {devices/lab_pin.sym} 123180 -6930 0 1 {name=p122572 lab=_62063_/X }
C {sky130_stdcells/buf_2.sym} 123140 -6930 0 0 {name=X_62063_ }
C {devices/lab_pin.sym} 123060 -6830 0 0 {name=p122573 lab=_74047_/X }
C {devices/lab_pin.sym} 123060 -6790 0 0 {name=p122574 lab=_74048_/Y }
C {devices/lab_pin.sym} 123060 -6750 0 0 {name=p122575 lab=_73982_/X }
C {devices/lab_pin.sym} 123220 -6790 0 1 {name=p122576 lab=_74049_/X }
C {sky130_stdcells/a21o_4.sym} 123140 -6790 0 0 {name=X_74049_ }
C {devices/lab_pin.sym} 123080 -6660 0 0 {name=p122577 lab=_78931_/B }
C {devices/lab_pin.sym} 123080 -6620 0 0 {name=p122578 lab=_78925_/Y }
C {devices/lab_pin.sym} 123200 -6640 0 1 {name=p122579 lab=_78927_/B }
C {sky130_stdcells/xnor2_4.sym} 123140 -6640 0 0 {name=X_78926_ }
C {devices/lab_pin.sym} 123080 -6530 0 0 {name=p122580 lab=_60946_/X }
C {devices/lab_pin.sym} 123080 -6490 0 0 {name=p122581 lab=_60838_/X }
C {devices/lab_pin.sym} 123080 -6450 0 0 {name=p122582 lab=_84540_/Q }
C {devices/lab_pin.sym} 123200 -6490 0 1 {name=p122583 lab=_61014_/Y }
C {sky130_stdcells/nor3_4.sym} 123140 -6490 0 0 {name=X_61014_ }
C {devices/lab_pin.sym} 123100 -6350 0 0 {name=p122584 lab=_66410_/A }
C {devices/lab_pin.sym} 123180 -6350 0 1 {name=p122585 lab=_66871_/X }
C {sky130_stdcells/buf_2.sym} 123140 -6350 0 0 {name=X_66871_ }
C {devices/lab_pin.sym} 123080 -6240 0 0 {name=p122586 lab=_78857_/A }
C {devices/lab_pin.sym} 123080 -6200 0 0 {name=p122587 lab=_78857_/B }
C {devices/lab_pin.sym} 123200 -6220 0 1 {name=p122588 lab=_78857_/X }
C {sky130_stdcells/and2_4.sym} 123140 -6220 0 0 {name=X_78857_ }
C {devices/lab_pin.sym} 123060 -6120 0 0 {name=p122589 lab=_68516_/X }
C {devices/lab_pin.sym} 123060 -6080 0 0 {name=p122590 lab=_68597_/Y }
C {devices/lab_pin.sym} 123060 -6040 0 0 {name=p122591 lab=_68447_/X }
C {devices/lab_pin.sym} 123060 -6000 0 0 {name=p122592 lab=_68609_/Y }
C {devices/lab_pin.sym} 123220 -6060 0 1 {name=p122593 lab=_68610_/X }
C {sky130_stdcells/a211o_4.sym} 123140 -6060 0 0 {name=X_68610_ }
C {devices/lab_pin.sym} 123060 -5940 0 0 {name=p122594 lab=_65638_/X }
C {devices/lab_pin.sym} 123060 -5900 0 0 {name=p122595 lab=_85575_/Q }
C {devices/lab_pin.sym} 123060 -5860 0 0 {name=p122596 lab=_65669_/X }
C {devices/lab_pin.sym} 123060 -5820 0 0 {name=p122597 lab=_65821_/X }
C {devices/lab_pin.sym} 123220 -5880 0 1 {name=p122598 lab=_65822_/X }
C {sky130_stdcells/a211o_4.sym} 123140 -5880 0 0 {name=X_65822_ }
C {devices/lab_pin.sym} 123080 -5740 0 0 {name=p122599 lab=_77806_/Y }
C {devices/lab_pin.sym} 123080 -5700 0 0 {name=p122600 lab=_77807_/Y }
C {devices/lab_pin.sym} 123200 -5720 0 1 {name=p122601 lab=_77808_/X }
C {sky130_stdcells/xor2_4.sym} 123140 -5720 0 0 {name=X_77808_ }
C {devices/lab_pin.sym} 123060 -5620 0 0 {name=p122602 lab=_69579_/X }
C {devices/lab_pin.sym} 123060 -5580 0 0 {name=p122603 lab=_69588_/Y }
C {devices/lab_pin.sym} 123060 -5540 0 0 {name=p122604 lab=_69516_/X }
C {devices/lab_pin.sym} 123060 -5500 0 0 {name=p122605 lab=_69589_/Y }
C {devices/lab_pin.sym} 123220 -5560 0 1 {name=p122606 lab=_69590_/X }
C {sky130_stdcells/a211o_4.sym} 123140 -5560 0 0 {name=X_69590_ }
C {devices/lab_pin.sym} 123100 -5410 0 0 {name=p122607 lab=_47967_/Y }
C {devices/lab_pin.sym} 123180 -5410 0 1 {name=p122608 lab=_47969_/B }
C {sky130_stdcells/buf_2.sym} 123140 -5410 0 0 {name=X_47968_ }
C {devices/lab_pin.sym} 123080 -5300 0 0 {name=p122609 lab=_78788_/A }
C {devices/lab_pin.sym} 123080 -5260 0 0 {name=p122610 lab=_82700_/Q }
C {devices/lab_pin.sym} 123200 -5280 0 1 {name=p122611 lab=_78788_/Y }
C {sky130_stdcells/nand2_4.sym} 123140 -5280 0 0 {name=X_78788_ }
C {devices/lab_pin.sym} 123100 -5150 0 0 {name=p122612 lab=_49678_/X }
C {devices/lab_pin.sym} 123180 -5150 0 1 {name=p122613 lab=_49708_/A }
C {sky130_stdcells/buf_2.sym} 123140 -5150 0 0 {name=X_49707_ }
C {devices/lab_pin.sym} 123100 -5030 0 0 {name=p122614 lab=_66565_/A }
C {devices/lab_pin.sym} 123180 -5030 0 1 {name=p122615 lab=_69190_/A }
C {sky130_stdcells/buf_2.sym} 123140 -5030 0 0 {name=X_68541_ }
C {devices/lab_pin.sym} 123060 -4930 0 0 {name=p122616 lab=_46914_/Y }
C {devices/lab_pin.sym} 123060 -4890 0 0 {name=p122617 lab=_46891_/X }
C {devices/lab_pin.sym} 123060 -4850 0 0 {name=p122618 lab=_46918_/X }
C {devices/lab_pin.sym} 123220 -4890 0 1 {name=p122619 lab=_86690_/D }
C {sky130_stdcells/a21oi_4.sym} 123140 -4890 0 0 {name=X_46919_ }
C {devices/lab_pin.sym} 123080 -4760 0 0 {name=p122620 lab=_65753_/A }
C {devices/lab_pin.sym} 123080 -4720 0 0 {name=p122621 lab=_73310_/B }
C {devices/lab_pin.sym} 123200 -4740 0 1 {name=p122622 lab=_65753_/X }
C {sky130_stdcells/and2_4.sym} 123140 -4740 0 0 {name=X_65753_ }
C {devices/lab_pin.sym} 123060 -4630 0 0 {name=p122623 lab=_78045_/A }
C {devices/lab_pin.sym} 123060 -4590 0 0 {name=p122624 lab=_78045_/B }
C {devices/lab_pin.sym} 123060 -4550 0 0 {name=p122625 lab=_77738_/Y }
C {devices/lab_pin.sym} 123220 -4590 0 1 {name=p122626 lab=_77739_/Y }
C {sky130_stdcells/a21oi_4.sym} 123140 -4590 0 0 {name=X_77739_ }
C {devices/lab_pin.sym} 123080 -4470 0 0 {name=p122627 lab=_62965_/A }
C {devices/lab_pin.sym} 123080 -4430 0 0 {name=p122628 lab=_62664_/B }
C {devices/lab_pin.sym} 123080 -4390 0 0 {name=p122629 lab=_62151_/X }
C {devices/lab_pin.sym} 123200 -4430 0 1 {name=p122630 lab=_62965_/Y }
C {sky130_stdcells/nand3_4.sym} 123140 -4430 0 0 {name=X_62965_ }
C {devices/lab_pin.sym} 123100 -4290 0 0 {name=p122631 lab=_47899_/A }
C {devices/lab_pin.sym} 123180 -4290 0 1 {name=p122632 lab=_73717_/A }
C {sky130_stdcells/inv_2.sym} 123140 -4290 0 0 {name=X_47899_ }
C {devices/lab_pin.sym} 123100 -4170 0 0 {name=p122633 lab=clkbuf_8_8_0_CLK/X }
C {devices/lab_pin.sym} 123180 -4170 0 1 {name=p122634 lab=clkbuf_9_17_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 123140 -4170 0 0 {name=Xclkbuf_9_17_0_CLK }
C {devices/lab_pin.sym} 123100 -4050 0 0 {name=p122635 lab=_64564_/X }
C {devices/lab_pin.sym} 123180 -4050 0 1 {name=p122636 lab=_64704_/X }
C {sky130_stdcells/buf_2.sym} 123140 -4050 0 0 {name=X_64704_ }
C {devices/lab_pin.sym} 123080 -3940 0 0 {name=p122637 lab=_49638_/A }
C {devices/lab_pin.sym} 123080 -3900 0 0 {name=p122638 lab=_52855_/B }
C {devices/lab_pin.sym} 123200 -3920 0 1 {name=p122639 lab=_49638_/Y }
C {sky130_stdcells/nand2_4.sym} 123140 -3920 0 0 {name=X_49638_ }
C {devices/lab_pin.sym} 123100 -3790 0 0 {name=p122640 lab=_61787_/X }
C {devices/lab_pin.sym} 123180 -3790 0 1 {name=p122641 lab=_61916_/X }
C {sky130_stdcells/buf_2.sym} 123140 -3790 0 0 {name=X_61916_ }
C {devices/lab_pin.sym} 123050 -3670 0 0 {name=p122642 lab=_80849_/CLK }
C {devices/lab_pin.sym} 123050 -3650 0 0 {name=p122643 lab=_75250_/X }
C {devices/lab_pin.sym} 123230 -3670 0 1 {name=p122644 lab=_81126_/D }
C {sky130_stdcells/dfxtp_4.sym} 123140 -3660 0 0 {name=X_80750_ }
C {devices/lab_pin.sym} 123100 -3530 0 0 {name=p122645 lab=_68472_/A }
C {devices/lab_pin.sym} 123180 -3530 0 1 {name=p122646 lab=_68472_/X }
C {sky130_stdcells/buf_2.sym} 123140 -3530 0 0 {name=X_68472_ }
C {devices/lab_pin.sym} 123060 -3430 0 0 {name=p122647 lab=_65679_/Y }
C {devices/lab_pin.sym} 123060 -3390 0 0 {name=p122648 lab=_65681_/X }
C {devices/lab_pin.sym} 123060 -3350 0 0 {name=p122649 lab=_65683_/Y }
C {devices/lab_pin.sym} 123220 -3390 0 1 {name=p122650 lab=_84185_/D }
C {sky130_stdcells/a21o_4.sym} 123140 -3390 0 0 {name=X_65684_ }
C {devices/lab_pin.sym} 123060 -3290 0 0 {name=p122651 lab=_60257_/X }
C {devices/lab_pin.sym} 123060 -3250 0 0 {name=p122652 lab=_61580_/X }
C {devices/lab_pin.sym} 123060 -3210 0 0 {name=p122653 lab=_62679_/X }
C {devices/lab_pin.sym} 123060 -3170 0 0 {name=p122654 lab=_60281_/A }
C {devices/lab_pin.sym} 123060 -3130 0 0 {name=p122655 lab=_84892_/Q }
C {devices/lab_pin.sym} 123220 -3210 0 1 {name=p122656 lab=_62897_/A }
C {sky130_stdcells/a32o_4.sym} 123140 -3210 0 0 {name=X_62896_ }
C {devices/lab_pin.sym} 123100 -3050 0 0 {name=p122657 lab=_66410_/A }
C {devices/lab_pin.sym} 123180 -3050 0 1 {name=p122658 lab=_67423_/X }
C {sky130_stdcells/buf_2.sym} 123140 -3050 0 0 {name=X_67423_ }
C {devices/lab_pin.sym} 123060 -2950 0 0 {name=p122659 lab=_79401_/B }
C {devices/lab_pin.sym} 123060 -2910 0 0 {name=p122660 lab=_79418_/B }
C {devices/lab_pin.sym} 123060 -2870 0 0 {name=p122661 lab=_79408_/X }
C {devices/lab_pin.sym} 123220 -2910 0 1 {name=p122662 lab=_79410_/B }
C {sky130_stdcells/a21boi_4.sym} 123140 -2910 0 0 {name=X_79409_ }
C {devices/lab_pin.sym} 123100 -2770 0 0 {name=p122663 lab=_45943_/A }
C {devices/lab_pin.sym} 123180 -2770 0 1 {name=p122664 lab=_64636_/A }
C {sky130_stdcells/buf_2.sym} 123140 -2770 0 0 {name=X_64635_ }
C {devices/lab_pin.sym} 123100 -2650 0 0 {name=p122665 lab=_49569_/A }
C {devices/lab_pin.sym} 123180 -2650 0 1 {name=p122666 lab=_49570_/A }
C {sky130_stdcells/buf_2.sym} 123140 -2650 0 0 {name=X_49569_ }
C {devices/lab_pin.sym} 123080 -2560 0 0 {name=p122667 lab=_61863_/A }
C {devices/lab_pin.sym} 123080 -2520 0 0 {name=p122668 lab=_61847_/B }
C {devices/lab_pin.sym} 123080 -2480 0 0 {name=p122669 lab=_61843_/Y }
C {devices/lab_pin.sym} 123080 -2440 0 0 {name=p122670 lab=_61846_/Y }
C {devices/lab_pin.sym} 123200 -2500 0 1 {name=p122671 lab=_61847_/Y }
C {sky130_stdcells/nand4_4.sym} 123140 -2500 0 0 {name=X_61847_ }
C {devices/lab_pin.sym} 123050 -2350 0 0 {name=p122672 lab=_80681_/CLK }
C {devices/lab_pin.sym} 123050 -2330 0 0 {name=p122673 lab=_80681_/D }
C {devices/lab_pin.sym} 123230 -2350 0 1 {name=p122674 lab=_80681_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -2340 0 0 {name=X_80681_ }
C {devices/lab_pin.sym} 123080 -2220 0 0 {name=p122675 lab=_51617_/A }
C {devices/lab_pin.sym} 123080 -2180 0 0 {name=p122676 lab=_53127_/B }
C {devices/lab_pin.sym} 123200 -2200 0 1 {name=p122677 lab=_51600_/Y }
C {sky130_stdcells/nand2_4.sym} 123140 -2200 0 0 {name=X_51600_ }
C {devices/lab_pin.sym} 123050 -2070 0 0 {name=p122678 lab=_82820_/CLK }
C {devices/lab_pin.sym} 123050 -2050 0 0 {name=p122679 lab=_82452_/Q }
C {devices/lab_pin.sym} 123230 -2070 0 1 {name=p122680 lab=_78566_/A }
C {sky130_stdcells/dfxtp_4.sym} 123140 -2060 0 0 {name=X_82420_ }
C {devices/lab_pin.sym} 123100 -1930 0 0 {name=p122681 lab=clkbuf_9_5_0_CLK/A }
C {devices/lab_pin.sym} 123180 -1930 0 1 {name=p122682 lab=clkbuf_9_5_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 123140 -1930 0 0 {name=Xclkbuf_9_5_0_CLK }
C {devices/lab_pin.sym} 123100 -1810 0 0 {name=p122683 lab=_68714_/A }
C {devices/lab_pin.sym} 123180 -1810 0 1 {name=p122684 lab=_67354_/X }
C {sky130_stdcells/buf_2.sym} 123140 -1810 0 0 {name=X_67354_ }
C {devices/lab_pin.sym} 123080 -1720 0 0 {name=p122685 lab=_52588_/A }
C {devices/lab_pin.sym} 123080 -1680 0 0 {name=p122686 lab=_52594_/B }
C {devices/lab_pin.sym} 123080 -1640 0 0 {name=p122687 lab=_51919_/C }
C {devices/lab_pin.sym} 123080 -1600 0 0 {name=p122688 lab=_52580_/D }
C {devices/lab_pin.sym} 123200 -1660 0 1 {name=p122689 lab=_52580_/X }
C {sky130_stdcells/and4_4.sym} 123140 -1660 0 0 {name=X_52580_ }
C {devices/lab_pin.sym} 123100 -1510 0 0 {name=p122690 lab=_64766_/A }
C {devices/lab_pin.sym} 123180 -1510 0 1 {name=p122691 lab=_64566_/X }
C {sky130_stdcells/buf_2.sym} 123140 -1510 0 0 {name=X_64566_ }
C {devices/lab_pin.sym} 123100 -1390 0 0 {name=p122692 lab=_59766_/X }
C {devices/lab_pin.sym} 123180 -1390 0 1 {name=p122693 lab=_61778_/X }
C {sky130_stdcells/buf_2.sym} 123140 -1390 0 0 {name=X_61778_ }
C {sky130_stdcells/decap_3.sym} 123140 -1240 0 0 {name=XPHY_609 }
C {devices/lab_pin.sym} 123060 -1110 0 0 {name=p122694 lab=_66294_/X }
C {devices/lab_pin.sym} 123060 -1070 0 0 {name=p122695 lab=_66303_/Y }
C {devices/lab_pin.sym} 123060 -1030 0 0 {name=p122696 lab=_66304_/Y }
C {devices/lab_pin.sym} 123220 -1070 0 1 {name=p122697 lab=_66305_/Y }
C {sky130_stdcells/o21ai_4.sym} 123140 -1070 0 0 {name=X_66305_ }
C {devices/lab_pin.sym} 123100 -930 0 0 {name=p122698 lab=_51557_/A }
C {devices/lab_pin.sym} 123180 -930 0 1 {name=p122699 lab=_51531_/X }
C {sky130_stdcells/buf_2.sym} 123140 -930 0 0 {name=X_51531_ }
C {devices/lab_pin.sym} 123080 -830 0 0 {name=p122700 lab=_63517_/A }
C {devices/lab_pin.sym} 123080 -790 0 0 {name=p122701 lab=_63517_/B }
C {devices/lab_pin.sym} 123080 -750 0 0 {name=p122702 lab=_63517_/C }
C {devices/lab_pin.sym} 123200 -790 0 1 {name=p122703 lab=_63517_/Y }
C {sky130_stdcells/nor3_4.sym} 123140 -790 0 0 {name=X_63517_ }
C {devices/lab_pin.sym} 123050 -650 0 0 {name=p122704 lab=_82343_/CLK }
C {devices/lab_pin.sym} 123050 -630 0 0 {name=p122705 lab=_77147_/X }
C {devices/lab_pin.sym} 123230 -650 0 1 {name=p122706 lab=_82351_/Q }
C {sky130_stdcells/dfxtp_4.sym} 123140 -640 0 0 {name=X_82351_ }
C {devices/lab_pin.sym} 123980 -42180 0 0 {name=p122707 lab=_78074_/A }
C {devices/lab_pin.sym} 123980 -42140 0 0 {name=p122708 lab=_60673_/X }
C {devices/lab_pin.sym} 123980 -42100 0 0 {name=p122709 lab=_60069_/Y }
C {devices/lab_pin.sym} 123980 -42060 0 0 {name=p122710 lab=_60702_/Y }
C {devices/lab_pin.sym} 124140 -42120 0 1 {name=p122711 lab=_84579_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 124060 -42120 0 0 {name=X_60729_ }
C {devices/lab_pin.sym} 124000 -41980 0 0 {name=p122712 lab=_67259_/A }
C {devices/lab_pin.sym} 124000 -41940 0 0 {name=p122713 lab=_67285_/B }
C {devices/lab_pin.sym} 124120 -41960 0 1 {name=p122714 lab=_67285_/X }
C {sky130_stdcells/and2_4.sym} 124060 -41960 0 0 {name=X_67285_ }
C {devices/lab_pin.sym} 123980 -41850 0 0 {name=p122715 lab=_58973_/A }
C {devices/lab_pin.sym} 123980 -41810 0 0 {name=p122716 lab=_64423_/X }
C {devices/lab_pin.sym} 123980 -41770 0 0 {name=p122717 lab=_64496_/Y }
C {devices/lab_pin.sym} 124140 -41810 0 1 {name=p122718 lab=_64497_/Y }
C {sky130_stdcells/o21ai_4.sym} 124060 -41810 0 0 {name=X_64497_ }
C {devices/lab_pin.sym} 123970 -41670 0 0 {name=p122719 lab=_81257_/CLK }
C {devices/lab_pin.sym} 123970 -41650 0 0 {name=p122720 lab=_76990_/X }
C {devices/lab_pin.sym} 124150 -41670 0 1 {name=p122721 lab=_81270_/D }
C {sky130_stdcells/dfxtp_4.sym} 124060 -41660 0 0 {name=X_81302_ }
C {devices/lab_pin.sym} 123980 -41560 0 0 {name=p122722 lab=_88088_/Q }
C {devices/lab_pin.sym} 123980 -41520 0 0 {name=p122723 lab=_68792_/X }
C {devices/lab_pin.sym} 123980 -41480 0 0 {name=p122724 lab=_68933_/X }
C {devices/lab_pin.sym} 123980 -41440 0 0 {name=p122725 lab=_69023_/Y }
C {devices/lab_pin.sym} 124140 -41500 0 1 {name=p122726 lab=_69024_/X }
C {sky130_stdcells/a211o_4.sym} 124060 -41500 0 0 {name=X_69024_ }
C {devices/lab_pin.sym} 124020 -41350 0 0 {name=p122727 lab=_54250_/A }
C {devices/lab_pin.sym} 124100 -41350 0 1 {name=p122728 lab=_54961_/A }
C {sky130_stdcells/buf_2.sym} 124060 -41350 0 0 {name=X_54250_ }
C {devices/lab_pin.sym} 124020 -41230 0 0 {name=p122729 lab=_66053_/A }
C {devices/lab_pin.sym} 124100 -41230 0 1 {name=p122730 lab=_66236_/X }
C {sky130_stdcells/buf_2.sym} 124060 -41230 0 0 {name=X_66236_ }
C {devices/lab_pin.sym} 123970 -41110 0 0 {name=p122731 lab=_85039_/CLK }
C {devices/lab_pin.sym} 123970 -41090 0 0 {name=p122732 lab=_57161_/Y }
C {devices/lab_pin.sym} 124150 -41110 0 1 {name=p122733 lab=_85070_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -41100 0 0 {name=X_85070_ }
C {devices/lab_pin.sym} 124000 -41000 0 0 {name=p122734 lab=_51456_/A }
C {devices/lab_pin.sym} 124000 -40960 0 0 {name=p122735 lab=_51473_/B }
C {devices/lab_pin.sym} 124000 -40920 0 0 {name=p122736 lab=_51467_/C }
C {devices/lab_pin.sym} 124000 -40880 0 0 {name=p122737 lab=_52989_/D }
C {devices/lab_pin.sym} 124120 -40940 0 1 {name=p122738 lab=_51462_/X }
C {sky130_stdcells/and4_4.sym} 124060 -40940 0 0 {name=X_51462_ }
C {devices/lab_pin.sym} 124000 -40820 0 0 {name=p122739 lab=_63448_/A }
C {devices/lab_pin.sym} 124000 -40780 0 0 {name=p122740 lab=_63448_/B }
C {devices/lab_pin.sym} 124000 -40740 0 0 {name=p122741 lab=_63410_/C }
C {devices/lab_pin.sym} 124000 -40700 0 0 {name=p122742 lab=_63410_/D }
C {devices/lab_pin.sym} 124120 -40760 0 1 {name=p122743 lab=_63448_/X }
C {sky130_stdcells/and4_4.sym} 124060 -40760 0 0 {name=X_63448_ }
C {devices/lab_pin.sym} 123970 -40610 0 0 {name=p122744 lab=_82288_/CLK }
C {devices/lab_pin.sym} 123970 -40590 0 0 {name=p122745 lab=_81906_/Q }
C {devices/lab_pin.sym} 124150 -40610 0 1 {name=p122746 lab=_82282_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -40600 0 0 {name=X_82282_ }
C {devices/lab_pin.sym} 123980 -40490 0 0 {name=p122747 lab=_85678_/Q }
C {devices/lab_pin.sym} 123980 -40450 0 0 {name=p122748 lab=_53198_/X }
C {devices/lab_pin.sym} 123980 -40410 0 0 {name=p122749 lab=_53200_/Y }
C {devices/lab_pin.sym} 124140 -40450 0 1 {name=p122750 lab=_53201_/Y }
C {sky130_stdcells/o21ai_4.sym} 124060 -40450 0 0 {name=X_53201_ }
C {devices/lab_pin.sym} 123970 -40310 0 0 {name=p122751 lab=_82067_/CLK }
C {devices/lab_pin.sym} 123970 -40290 0 0 {name=p122752 lab=_68172_/X }
C {devices/lab_pin.sym} 124150 -40310 0 1 {name=p122753 lab=_82061_/D }
C {sky130_stdcells/dfxtp_4.sym} 124060 -40300 0 0 {name=X_84021_ }
C {devices/lab_pin.sym} 123980 -40190 0 0 {name=p122754 lab=_50411_/Y }
C {devices/lab_pin.sym} 123980 -40150 0 0 {name=p122755 lab=_50395_/X }
C {devices/lab_pin.sym} 123980 -40110 0 0 {name=p122756 lab=_50412_/X }
C {devices/lab_pin.sym} 124140 -40150 0 1 {name=p122757 lab=_50413_/Y }
C {sky130_stdcells/a21oi_4.sym} 124060 -40150 0 0 {name=X_50413_ }
C {devices/lab_pin.sym} 123970 -40010 0 0 {name=p122758 lab=_81233_/CLK }
C {devices/lab_pin.sym} 123970 -39990 0 0 {name=p122759 lab=_81041_/Q }
C {devices/lab_pin.sym} 124150 -40010 0 1 {name=p122760 lab=_81233_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -40000 0 0 {name=X_81233_ }
C {devices/lab_pin.sym} 124020 -39870 0 0 {name=p122761 lab=_53418_/X }
C {devices/lab_pin.sym} 124100 -39870 0 1 {name=p122762 lab=_54191_/A }
C {sky130_stdcells/buf_2.sym} 124060 -39870 0 0 {name=X_54181_ }
C {devices/lab_pin.sym} 123980 -39780 0 0 {name=p122763 lab=_72155_/A }
C {devices/lab_pin.sym} 123980 -39740 0 0 {name=p122764 lab=_86223_/Q }
C {devices/lab_pin.sym} 123980 -39700 0 0 {name=p122765 lab=_64692_/X }
C {devices/lab_pin.sym} 123980 -39660 0 0 {name=p122766 lab=_66166_/X }
C {devices/lab_pin.sym} 124140 -39720 0 1 {name=p122767 lab=_66167_/X }
C {sky130_stdcells/a211o_4.sym} 124060 -39720 0 0 {name=X_66167_ }
C {devices/lab_pin.sym} 123980 -39590 0 0 {name=p122768 lab=_51390_/Y }
C {devices/lab_pin.sym} 123980 -39550 0 0 {name=p122769 lab=_51391_/X }
C {devices/lab_pin.sym} 123980 -39510 0 0 {name=p122770 lab=_51392_/X }
C {devices/lab_pin.sym} 124140 -39550 0 1 {name=p122771 lab=_51393_/Y }
C {sky130_stdcells/a21oi_4.sym} 124060 -39550 0 0 {name=X_51393_ }
C {devices/lab_pin.sym} 124020 -39410 0 0 {name=p122772 lab=_63443_/A }
C {devices/lab_pin.sym} 124100 -39410 0 1 {name=p122773 lab=_63418_/C }
C {sky130_stdcells/buf_2.sym} 124060 -39410 0 0 {name=X_63379_ }
C {devices/lab_pin.sym} 123980 -39310 0 0 {name=p122774 lab=_85691_/Q }
C {devices/lab_pin.sym} 123980 -39270 0 0 {name=p122775 lab=_53120_/X }
C {devices/lab_pin.sym} 123980 -39230 0 0 {name=p122776 lab=_53131_/Y }
C {devices/lab_pin.sym} 124140 -39270 0 1 {name=p122777 lab=_53132_/Y }
C {sky130_stdcells/o21ai_4.sym} 124060 -39270 0 0 {name=X_53132_ }
C {devices/lab_pin.sym} 124020 -39130 0 0 {name=p122778 lab=_65118_/A }
C {devices/lab_pin.sym} 124100 -39130 0 1 {name=p122779 lab=_65118_/X }
C {sky130_stdcells/buf_2.sym} 124060 -39130 0 0 {name=X_65118_ }
C {devices/lab_pin.sym} 123980 -39030 0 0 {name=p122780 lab=_50342_/Y }
C {devices/lab_pin.sym} 123980 -38990 0 0 {name=p122781 lab=_50299_/X }
C {devices/lab_pin.sym} 123980 -38950 0 0 {name=p122782 lab=_50343_/Y }
C {devices/lab_pin.sym} 124140 -38990 0 1 {name=p122783 lab=_86220_/D }
C {sky130_stdcells/a21boi_4.sym} 124060 -38990 0 0 {name=X_50344_ }
C {devices/lab_pin.sym} 123970 -38850 0 0 {name=p122784 lab=_80792_/CLK }
C {devices/lab_pin.sym} 123970 -38830 0 0 {name=p122785 lab=_74920_/B }
C {devices/lab_pin.sym} 124150 -38850 0 1 {name=p122786 lab=_81164_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -38840 0 0 {name=X_81164_ }
C {devices/lab_pin.sym} 123980 -38740 0 0 {name=p122787 lab=_66053_/X }
C {devices/lab_pin.sym} 123980 -38700 0 0 {name=p122788 lab=_85620_/Q }
C {devices/lab_pin.sym} 123980 -38660 0 0 {name=p122789 lab=_66096_/X }
C {devices/lab_pin.sym} 123980 -38620 0 0 {name=p122790 lab=_66097_/X }
C {devices/lab_pin.sym} 124140 -38680 0 1 {name=p122791 lab=_66098_/X }
C {sky130_stdcells/a211o_4.sym} 124060 -38680 0 0 {name=X_66098_ }
C {devices/lab_pin.sym} 124000 -38540 0 0 {name=p122792 lab=_80107_/A }
C {devices/lab_pin.sym} 124000 -38500 0 0 {name=p122793 lab=_80098_/A }
C {devices/lab_pin.sym} 124120 -38520 0 1 {name=p122794 lab=_80115_/X }
C {sky130_stdcells/and2_4.sym} 124060 -38520 0 0 {name=X_80115_ }
C {devices/lab_pin.sym} 124000 -38400 0 0 {name=p122795 lab=_57788_/X }
C {devices/lab_pin.sym} 124000 -38360 0 0 {name=p122796 lab=_65049_/B }
C {devices/lab_pin.sym} 124120 -38380 0 1 {name=p122797 lab=_65049_/X }
C {sky130_stdcells/and2_4.sym} 124060 -38380 0 0 {name=X_65049_ }
C {devices/lab_pin.sym} 124000 -38280 0 0 {name=p122798 lab=_53074_/A }
C {devices/lab_pin.sym} 124000 -38240 0 0 {name=p122799 lab=_53063_/B }
C {devices/lab_pin.sym} 124000 -38200 0 0 {name=p122800 lab=_53074_/C }
C {devices/lab_pin.sym} 124000 -38160 0 0 {name=p122801 lab=_53063_/D }
C {devices/lab_pin.sym} 124120 -38220 0 1 {name=p122802 lab=_53063_/X }
C {sky130_stdcells/and4_4.sym} 124060 -38220 0 0 {name=X_53063_ }
C {devices/lab_pin.sym} 123980 -38090 0 0 {name=p122803 lab=_57852_/X }
C {devices/lab_pin.sym} 123980 -38050 0 0 {name=p122804 lab=_85714_/Q }
C {devices/lab_pin.sym} 123980 -38010 0 0 {name=p122805 lab=_57878_/X }
C {devices/lab_pin.sym} 124140 -38050 0 1 {name=p122806 lab=_57940_/X }
C {sky130_stdcells/o21a_4.sym} 124060 -38050 0 0 {name=X_57940_ }
C {devices/lab_pin.sym} 123980 -37930 0 0 {name=p122807 lab=_69922_/X }
C {devices/lab_pin.sym} 123980 -37890 0 0 {name=p122808 lab=_69924_/X }
C {devices/lab_pin.sym} 123980 -37850 0 0 {name=p122809 lab=_69925_/X }
C {devices/lab_pin.sym} 124140 -37890 0 1 {name=p122810 lab=_69926_/Y }
C {sky130_stdcells/a21oi_4.sym} 124060 -37890 0 0 {name=X_69926_ }
C {devices/lab_pin.sym} 124000 -37760 0 0 {name=p122811 lab=_50230_/A }
C {devices/lab_pin.sym} 124000 -37720 0 0 {name=p122812 lab=_50275_/B }
C {devices/lab_pin.sym} 124120 -37740 0 1 {name=p122813 lab=_50275_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -37740 0 0 {name=X_50275_ }
C {devices/lab_pin.sym} 123970 -37610 0 0 {name=p122814 lab=_85969_/CLK }
C {devices/lab_pin.sym} 123970 -37590 0 0 {name=p122815 lab=_85972_/D }
C {devices/lab_pin.sym} 124150 -37610 0 1 {name=p122816 lab=_85972_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -37600 0 0 {name=X_85972_ }
C {devices/lab_pin.sym} 123970 -37470 0 0 {name=p122817 lab=_82084_/CLK }
C {devices/lab_pin.sym} 123970 -37450 0 0 {name=p122818 lab=_79613_/X }
C {devices/lab_pin.sym} 124150 -37470 0 1 {name=p122819 lab=_81095_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -37460 0 0 {name=X_81095_ }
C {devices/lab_pin.sym} 124020 -37330 0 0 {name=p122820 lab=_51922_/X }
C {devices/lab_pin.sym} 124100 -37330 0 1 {name=p122821 lab=_52014_/X }
C {sky130_stdcells/buf_2.sym} 124060 -37330 0 0 {name=X_52014_ }
C {devices/lab_pin.sym} 123970 -37210 0 0 {name=p122822 lab=_87394_/CLK }
C {devices/lab_pin.sym} 123970 -37190 0 0 {name=p122823 lab=_42801_/X }
C {devices/lab_pin.sym} 124150 -37210 0 1 {name=p122824 lab=_67808_/B }
C {sky130_stdcells/dfxtp_4.sym} 124060 -37200 0 0 {name=X_87711_ }
C {devices/lab_pin.sym} 123970 -37070 0 0 {name=p122825 lab=_85372_/CLK }
C {devices/lab_pin.sym} 123970 -37050 0 0 {name=p122826 lab=_84923_/D }
C {devices/lab_pin.sym} 124150 -37070 0 1 {name=p122827 lab=_84923_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -37060 0 0 {name=X_84923_ }
C {devices/lab_pin.sym} 124000 -36940 0 0 {name=p122828 lab=_80039_/X }
C {devices/lab_pin.sym} 124000 -36900 0 0 {name=p122829 lab=_80046_/B }
C {devices/lab_pin.sym} 124120 -36920 0 1 {name=p122830 lab=_80046_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -36920 0 0 {name=X_80046_ }
C {devices/lab_pin.sym} 124000 -36800 0 0 {name=p122831 lab=_86647_/Q }
C {devices/lab_pin.sym} 124000 -36760 0 0 {name=p122832 lab=_57845_/X }
C {devices/lab_pin.sym} 124120 -36780 0 1 {name=p122833 lab=_57871_/Y }
C {sky130_stdcells/nor2_4.sym} 124060 -36780 0 0 {name=X_57871_ }
C {devices/lab_pin.sym} 123980 -36680 0 0 {name=p122834 lab=_69832_/X }
C {devices/lab_pin.sym} 123980 -36640 0 0 {name=p122835 lab=_69855_/Y }
C {devices/lab_pin.sym} 123980 -36600 0 0 {name=p122836 lab=_69815_/X }
C {devices/lab_pin.sym} 123980 -36560 0 0 {name=p122837 lab=_69856_/Y }
C {devices/lab_pin.sym} 124140 -36620 0 1 {name=p122838 lab=_69857_/X }
C {sky130_stdcells/a211o_4.sym} 124060 -36620 0 0 {name=X_69857_ }
C {devices/lab_pin.sym} 124020 -36470 0 0 {name=p122839 lab=_59609_/X }
C {devices/lab_pin.sym} 124100 -36470 0 1 {name=p122840 lab=_60627_/A }
C {sky130_stdcells/buf_2.sym} 124060 -36470 0 0 {name=X_59610_ }
C {devices/lab_pin.sym} 123980 -36390 0 0 {name=p122841 lab=_56758_/X }
C {devices/lab_pin.sym} 123980 -36350 0 0 {name=p122842 lab=_56756_/X }
C {devices/lab_pin.sym} 123980 -36310 0 0 {name=p122843 lab=_56761_/X }
C {devices/lab_pin.sym} 123980 -36270 0 0 {name=p122844 lab=_56821_/X }
C {devices/lab_pin.sym} 123980 -36240 0 0 {name=p122845 lab=_45957_/A }
C {devices/lab_pin.sym} 124140 -36310 0 1 {name=p122846 lab=_56822_/Y }
C {sky130_stdcells/a41oi_4.sym} 124060 -36310 0 0 {name=X_56822_ }
C {devices/lab_pin.sym} 124000 -36160 0 0 {name=p122847 lab=_68785_/A }
C {devices/lab_pin.sym} 124000 -36120 0 0 {name=p122848 lab=_88354_/Q }
C {devices/lab_pin.sym} 124120 -36140 0 1 {name=p122849 lab=_68808_/X }
C {sky130_stdcells/and2_4.sym} 124060 -36140 0 0 {name=X_68808_ }
C {devices/lab_pin.sym} 123970 -36010 0 0 {name=p122850 lab=_86920_/CLK }
C {devices/lab_pin.sym} 123970 -35990 0 0 {name=p122851 lab=_87642_/D }
C {devices/lab_pin.sym} 124150 -36010 0 1 {name=p122852 lab=_67927_/B }
C {sky130_stdcells/dfxtp_4.sym} 124060 -36000 0 0 {name=X_87642_ }
C {devices/lab_pin.sym} 123970 -35870 0 0 {name=p122853 lab=_84732_/CLK }
C {devices/lab_pin.sym} 123970 -35850 0 0 {name=p122854 lab=_84854_/D }
C {devices/lab_pin.sym} 124150 -35870 0 1 {name=p122855 lab=_84854_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -35860 0 0 {name=X_84854_ }
C {devices/lab_pin.sym} 123980 -35750 0 0 {name=p122856 lab=_81969_/D }
C {devices/lab_pin.sym} 123980 -35710 0 0 {name=p122857 lab=_69763_/X }
C {devices/lab_pin.sym} 123980 -35670 0 0 {name=p122858 lab=_69787_/X }
C {devices/lab_pin.sym} 124140 -35710 0 1 {name=p122859 lab=_83897_/D }
C {sky130_stdcells/a21bo_4.sym} 124060 -35710 0 0 {name=X_69788_ }
C {devices/lab_pin.sym} 123970 -35570 0 0 {name=p122860 lab=_81807_/CLK }
C {devices/lab_pin.sym} 123970 -35550 0 0 {name=p122861 lab=_83805_/D }
C {devices/lab_pin.sym} 124150 -35570 0 1 {name=p122862 lab=_74770_/A }
C {sky130_stdcells/dfxtp_4.sym} 124060 -35560 0 0 {name=X_83805_ }
C {devices/lab_pin.sym} 124020 -35430 0 0 {name=p122863 lab=_59540_/Y }
C {devices/lab_pin.sym} 124100 -35430 0 1 {name=p122864 lab=_60407_/A }
C {sky130_stdcells/buf_2.sym} 124060 -35430 0 0 {name=X_59541_ }
C {devices/lab_pin.sym} 124000 -35320 0 0 {name=p122865 lab=_56753_/A }
C {devices/lab_pin.sym} 124000 -35280 0 0 {name=p122866 lab=_85134_/Q }
C {devices/lab_pin.sym} 124120 -35300 0 1 {name=p122867 lab=_56753_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -35300 0 0 {name=X_56753_ }
C {devices/lab_pin.sym} 123980 -35200 0 0 {name=p122868 lab=_68725_/Y }
C {devices/lab_pin.sym} 123980 -35160 0 0 {name=p122869 lab=_68358_/X }
C {devices/lab_pin.sym} 123980 -35120 0 0 {name=p122870 lab=_68649_/X }
C {devices/lab_pin.sym} 123980 -35080 0 0 {name=p122871 lab=_68738_/Y }
C {devices/lab_pin.sym} 124140 -35140 0 1 {name=p122872 lab=_68739_/X }
C {sky130_stdcells/a211o_4.sym} 124060 -35140 0 0 {name=X_68739_ }
C {devices/lab_pin.sym} 123970 -34990 0 0 {name=p122873 lab=_87826_/CLK }
C {devices/lab_pin.sym} 123970 -34970 0 0 {name=p122874 lab=_43109_/Y }
C {devices/lab_pin.sym} 124150 -34990 0 1 {name=p122875 lab=_87573_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -34980 0 0 {name=X_87573_ }
C {devices/lab_pin.sym} 123980 -34870 0 0 {name=p122876 lab=_53962_/Y }
C {devices/lab_pin.sym} 123980 -34830 0 0 {name=p122877 lab=_53892_/X }
C {devices/lab_pin.sym} 123980 -34790 0 0 {name=p122878 lab=_53964_/X }
C {devices/lab_pin.sym} 124140 -34830 0 1 {name=p122879 lab=_85533_/D }
C {sky130_stdcells/a21oi_4.sym} 124060 -34830 0 0 {name=X_53965_ }
C {devices/lab_pin.sym} 123970 -34690 0 0 {name=p122880 lab=_84906_/CLK }
C {devices/lab_pin.sym} 123970 -34670 0 0 {name=p122881 lab=_58971_/X }
C {devices/lab_pin.sym} 124150 -34690 0 1 {name=p122882 lab=_84785_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -34680 0 0 {name=X_84785_ }
C {devices/lab_pin.sym} 123970 -34550 0 0 {name=p122883 lab=_82133_/CLK }
C {devices/lab_pin.sym} 123970 -34530 0 0 {name=p122884 lab=_82029_/Q }
C {devices/lab_pin.sym} 124150 -34550 0 1 {name=p122885 lab=_81997_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -34540 0 0 {name=X_81997_ }
C {devices/lab_pin.sym} 124000 -34420 0 0 {name=p122886 lab=_55276_/A }
C {devices/lab_pin.sym} 124000 -34380 0 0 {name=p122887 lab=_56536_/C }
C {devices/lab_pin.sym} 124120 -34400 0 1 {name=p122888 lab=_55704_/X }
C {sky130_stdcells/and2_4.sym} 124060 -34400 0 0 {name=X_55704_ }
C {devices/lab_pin.sym} 123970 -34270 0 0 {name=p122889 lab=_83282_/CLK }
C {devices/lab_pin.sym} 123970 -34250 0 0 {name=p122890 lab=_86524_/D }
C {devices/lab_pin.sym} 124150 -34270 0 1 {name=p122891 lab=_86524_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -34260 0 0 {name=X_86524_ }
C {devices/lab_pin.sym} 123980 -34160 0 0 {name=p122892 lab=_40929_/X }
C {devices/lab_pin.sym} 123980 -34120 0 0 {name=p122893 lab=_40904_/X }
C {devices/lab_pin.sym} 123980 -34080 0 0 {name=p122894 lab=_69972_/B }
C {devices/lab_pin.sym} 123980 -34040 0 0 {name=p122895 lab=_40905_/X }
C {devices/lab_pin.sym} 124140 -34100 0 1 {name=p122896 lab=_88308_/D }
C {sky130_stdcells/a2bb2o_4.sym} 124060 -34100 0 0 {name=X_40930_ }
C {devices/lab_pin.sym} 124000 -33980 0 0 {name=p122897 lab=_52895_/A }
C {devices/lab_pin.sym} 124000 -33940 0 0 {name=p122898 lab=_52916_/B }
C {devices/lab_pin.sym} 124000 -33900 0 0 {name=p122899 lab=_52900_/C }
C {devices/lab_pin.sym} 124000 -33860 0 0 {name=p122900 lab=_51225_/D }
C {devices/lab_pin.sym} 124120 -33920 0 1 {name=p122901 lab=_52916_/X }
C {sky130_stdcells/and4_4.sym} 124060 -33920 0 0 {name=X_52916_ }
C {devices/lab_pin.sym} 123980 -33790 0 0 {name=p122902 lab=_52940_/B }
C {devices/lab_pin.sym} 123980 -33750 0 0 {name=p122903 lab=_71737_/X }
C {devices/lab_pin.sym} 123980 -33710 0 0 {name=p122904 lab=_71749_/Y }
C {devices/lab_pin.sym} 124140 -33750 0 1 {name=p122905 lab=_83390_/D }
C {sky130_stdcells/o21ai_4.sym} 124060 -33750 0 0 {name=X_71750_ }
C {devices/lab_pin.sym} 123980 -33630 0 0 {name=p122906 lab=_59462_/X }
C {devices/lab_pin.sym} 123980 -33590 0 0 {name=p122907 lab=_83459_/Q }
C {devices/lab_pin.sym} 123980 -33550 0 0 {name=p122908 lab=_59471_/Y }
C {devices/lab_pin.sym} 124140 -33590 0 1 {name=p122909 lab=_84723_/D }
C {sky130_stdcells/o21a_4.sym} 124060 -33590 0 0 {name=X_59472_ }
C {devices/lab_pin.sym} 123970 -33450 0 0 {name=p122910 lab=_83736_/CLK }
C {devices/lab_pin.sym} 123970 -33430 0 0 {name=p122911 lab=_83736_/D }
C {devices/lab_pin.sym} 124150 -33450 0 1 {name=p122912 lab=_47385_/A }
C {sky130_stdcells/dfxtp_4.sym} 124060 -33440 0 0 {name=X_83736_ }
C {devices/lab_pin.sym} 124000 -33340 0 0 {name=p122913 lab=_57270_/A }
C {devices/lab_pin.sym} 124000 -33300 0 0 {name=p122914 lab=_56684_/B }
C {devices/lab_pin.sym} 124000 -33260 0 0 {name=p122915 lab=_56684_/C }
C {devices/lab_pin.sym} 124000 -33220 0 0 {name=p122916 lab=_56739_/A }
C {devices/lab_pin.sym} 124120 -33280 0 1 {name=p122917 lab=_56685_/B }
C {sky130_stdcells/nand4_4.sym} 124060 -33280 0 0 {name=X_56684_ }
C {devices/lab_pin.sym} 123970 -33130 0 0 {name=p122918 lab=_81197_/CLK }
C {devices/lab_pin.sym} 123970 -33110 0 0 {name=p122919 lab=_80948_/D }
C {devices/lab_pin.sym} 124150 -33130 0 1 {name=p122920 lab=_80948_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -33120 0 0 {name=X_80948_ }
C {devices/lab_pin.sym} 124020 -32990 0 0 {name=p122921 lab=_53921_/A }
C {devices/lab_pin.sym} 124100 -32990 0 1 {name=p122922 lab=_53896_/X }
C {sky130_stdcells/buf_2.sym} 124060 -32990 0 0 {name=X_53896_ }
C {devices/lab_pin.sym} 124020 -32870 0 0 {name=p122923 lab=_70701_/A }
C {devices/lab_pin.sym} 124100 -32870 0 1 {name=p122924 lab=_70712_/A }
C {sky130_stdcells/buf_2.sym} 124060 -32870 0 0 {name=X_70701_ }
C {devices/lab_pin.sym} 124020 -32750 0 0 {name=p122925 lab=_58423_/A }
C {devices/lab_pin.sym} 124100 -32750 0 1 {name=p122926 lab=_58423_/X }
C {sky130_stdcells/buf_2.sym} 124060 -32750 0 0 {name=X_58423_ }
C {devices/lab_pin.sym} 124000 -32640 0 0 {name=p122927 lab=_44087_/B }
C {devices/lab_pin.sym} 124000 -32600 0 0 {name=p122928 lab=_55635_/B }
C {devices/lab_pin.sym} 124120 -32620 0 1 {name=p122929 lab=_55635_/Y }
C {sky130_stdcells/nor2_4.sym} 124060 -32620 0 0 {name=X_55635_ }
C {devices/lab_pin.sym} 123970 -32490 0 0 {name=p122930 lab=_83303_/CLK }
C {devices/lab_pin.sym} 123970 -32470 0 0 {name=p122931 lab=_48990_/Y }
C {devices/lab_pin.sym} 124150 -32490 0 1 {name=p122932 lab=_86455_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -32480 0 0 {name=X_86455_ }
C {devices/lab_pin.sym} 124020 -32350 0 0 {name=p122933 lab=_40861_/A }
C {devices/lab_pin.sym} 124100 -32350 0 1 {name=p122934 lab=_40861_/X }
C {sky130_stdcells/buf_2.sym} 124060 -32350 0 0 {name=X_40861_ }
C {devices/lab_pin.sym} 123980 -32250 0 0 {name=p122935 lab=_52844_/Y }
C {devices/lab_pin.sym} 123980 -32210 0 0 {name=p122936 lab=_52839_/X }
C {devices/lab_pin.sym} 123980 -32170 0 0 {name=p122937 lab=_52846_/X }
C {devices/lab_pin.sym} 124140 -32210 0 1 {name=p122938 lab=_52847_/Y }
C {sky130_stdcells/a21oi_4.sym} 124060 -32210 0 0 {name=X_52847_ }
C {devices/lab_pin.sym} 123980 -32090 0 0 {name=p122939 lab=_58485_/Y }
C {devices/lab_pin.sym} 123980 -32050 0 0 {name=p122940 lab=_71669_/X }
C {devices/lab_pin.sym} 123980 -32010 0 0 {name=p122941 lab=_71680_/Y }
C {devices/lab_pin.sym} 124140 -32050 0 1 {name=p122942 lab=_71681_/Y }
C {sky130_stdcells/o21ai_4.sym} 124060 -32050 0 0 {name=X_71681_ }
C {devices/lab_pin.sym} 123970 -31910 0 0 {name=p122943 lab=_86091_/CLK }
C {devices/lab_pin.sym} 123970 -31890 0 0 {name=p122944 lab=_70904_/Y }
C {devices/lab_pin.sym} 124150 -31910 0 1 {name=p122945 lab=_46824_/A }
C {sky130_stdcells/dfxtp_4.sym} 124060 -31900 0 0 {name=X_83667_ }
C {devices/lab_pin.sym} 123970 -31770 0 0 {name=p122946 lab=_80804_/CLK }
C {devices/lab_pin.sym} 123970 -31750 0 0 {name=p122947 lab=_75693_/B }
C {devices/lab_pin.sym} 124150 -31770 0 1 {name=p122948 lab=_80847_/D }
C {sky130_stdcells/dfxtp_4.sym} 124060 -31760 0 0 {name=X_80879_ }
C {devices/lab_pin.sym} 124020 -31630 0 0 {name=p122949 lab=_42600_/A }
C {devices/lab_pin.sym} 124100 -31630 0 1 {name=p122950 lab=_42600_/Y }
C {sky130_stdcells/inv_2.sym} 124060 -31630 0 0 {name=X_42600_ }
C {devices/lab_pin.sym} 124020 -31510 0 0 {name=p122951 lab=_56274_/X }
C {devices/lab_pin.sym} 124100 -31510 0 1 {name=p122952 lab=_73420_/X }
C {sky130_stdcells/buf_2.sym} 124060 -31510 0 0 {name=X_73420_ }
C {devices/lab_pin.sym} 123970 -31390 0 0 {name=p122953 lab=_85407_/CLK }
C {devices/lab_pin.sym} 123970 -31370 0 0 {name=p122954 lab=_85406_/D }
C {devices/lab_pin.sym} 124150 -31390 0 1 {name=p122955 lab=_85406_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -31380 0 0 {name=X_85406_ }
C {devices/lab_pin.sym} 124020 -31250 0 0 {name=p122956 lab=_70631_/X }
C {devices/lab_pin.sym} 124100 -31250 0 1 {name=p122957 lab=_70632_/X }
C {sky130_stdcells/buf_2.sym} 124060 -31250 0 0 {name=X_70632_ }
C {devices/lab_pin.sym} 124020 -31130 0 0 {name=p122958 lab=_84870_/Q }
C {devices/lab_pin.sym} 124100 -31130 0 1 {name=p122959 lab=_63316_/A }
C {sky130_stdcells/inv_2.sym} 124060 -31130 0 0 {name=X_58354_ }
C {devices/lab_pin.sym} 123970 -31010 0 0 {name=p122960 lab=_82503_/CLK }
C {devices/lab_pin.sym} 123970 -30990 0 0 {name=p122961 lab=_79028_/B }
C {devices/lab_pin.sym} 124150 -31010 0 1 {name=p122962 lab=_82586_/D }
C {sky130_stdcells/dfxtp_4.sym} 124060 -31000 0 0 {name=X_82618_ }
C {devices/lab_pin.sym} 123980 -30900 0 0 {name=p122963 lab=_40548_/X }
C {devices/lab_pin.sym} 123980 -30860 0 0 {name=p122964 lab=_53455_/A }
C {devices/lab_pin.sym} 123980 -30820 0 0 {name=p122965 lab=_87348_/Q }
C {devices/lab_pin.sym} 123980 -30780 0 0 {name=p122966 lab=_43185_/A }
C {devices/lab_pin.sym} 124140 -30840 0 1 {name=p122967 lab=_87348_/D }
C {sky130_stdcells/a2bb2o_4.sym} 124060 -30840 0 0 {name=X_43580_ }
C {devices/lab_pin.sym} 123980 -30720 0 0 {name=p122968 lab=_83002_/Q }
C {devices/lab_pin.sym} 123980 -30680 0 0 {name=p122969 lab=_55527_/X }
C {devices/lab_pin.sym} 123980 -30640 0 0 {name=p122970 lab=_44098_/X }
C {devices/lab_pin.sym} 123980 -30600 0 0 {name=p122971 lab=_55565_/X }
C {devices/lab_pin.sym} 124140 -30660 0 1 {name=p122972 lab=_56595_/B }
C {sky130_stdcells/a211o_4.sym} 124060 -30660 0 0 {name=X_55566_ }
C {devices/lab_pin.sym} 123970 -30510 0 0 {name=p122973 lab=_86384_/CLK }
C {devices/lab_pin.sym} 123970 -30490 0 0 {name=p122974 lab=_86386_/D }
C {devices/lab_pin.sym} 124150 -30510 0 1 {name=p122975 lab=_58763_/B }
C {sky130_stdcells/dfxtp_4.sym} 124060 -30500 0 0 {name=X_86386_ }
C {devices/lab_pin.sym} 124020 -30370 0 0 {name=p122976 lab=_40792_/A }
C {devices/lab_pin.sym} 124100 -30370 0 1 {name=p122977 lab=_40792_/X }
C {sky130_stdcells/buf_2.sym} 124060 -30370 0 0 {name=X_40792_ }
C {devices/lab_pin.sym} 123980 -30270 0 0 {name=p122978 lab=_85756_/Q }
C {devices/lab_pin.sym} 123980 -30230 0 0 {name=p122979 lab=_52765_/X }
C {devices/lab_pin.sym} 123980 -30190 0 0 {name=p122980 lab=_52777_/Y }
C {devices/lab_pin.sym} 124140 -30230 0 1 {name=p122981 lab=_52778_/Y }
C {sky130_stdcells/o21ai_4.sym} 124060 -30230 0 0 {name=X_52778_ }
C {devices/lab_pin.sym} 123970 -30090 0 0 {name=p122982 lab=_85542_/CLK }
C {devices/lab_pin.sym} 123970 -30070 0 0 {name=p122983 lab=_71126_/Y }
C {devices/lab_pin.sym} 124150 -30090 0 1 {name=p122984 lab=_49157_/A }
C {sky130_stdcells/dfxtp_4.sym} 124060 -30080 0 0 {name=X_83598_ }
C {devices/lab_pin.sym} 124000 -29980 0 0 {name=p122985 lab=_57010_/A }
C {devices/lab_pin.sym} 124000 -29940 0 0 {name=p122986 lab=_57268_/X }
C {devices/lab_pin.sym} 124000 -29900 0 0 {name=p122987 lab=_56767_/X }
C {devices/lab_pin.sym} 124000 -29860 0 0 {name=p122988 lab=_57163_/C }
C {devices/lab_pin.sym} 124120 -29920 0 1 {name=p122989 lab=_57305_/Y }
C {sky130_stdcells/nand4_4.sym} 124060 -29920 0 0 {name=X_57305_ }
C {devices/lab_pin.sym} 123970 -29770 0 0 {name=p122990 lab=_87116_/CLK }
C {devices/lab_pin.sym} 123970 -29750 0 0 {name=p122991 lab=_88125_/D }
C {devices/lab_pin.sym} 124150 -29770 0 1 {name=p122992 lab=_88125_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -29760 0 0 {name=X_88125_ }
C {devices/lab_pin.sym} 123980 -29670 0 0 {name=p122993 lab=_42517_/X }
C {devices/lab_pin.sym} 123980 -29630 0 0 {name=p122994 lab=_42527_/X }
C {devices/lab_pin.sym} 123980 -29590 0 0 {name=p122995 lab=_40739_/X }
C {devices/lab_pin.sym} 123980 -29550 0 0 {name=p122996 lab=_69023_/B }
C {devices/lab_pin.sym} 123980 -29510 0 0 {name=p122997 lab=_42519_/X }
C {devices/lab_pin.sym} 124140 -29590 0 1 {name=p122998 lab=_42531_/Y }
C {sky130_stdcells/o32ai_4.sym} 124060 -29590 0 0 {name=X_42531_ }
C {devices/lab_pin.sym} 123980 -29450 0 0 {name=p122999 lab=_54515_/Y }
C {devices/lab_pin.sym} 123980 -29410 0 0 {name=p123000 lab=_54502_/X }
C {devices/lab_pin.sym} 123980 -29370 0 0 {name=p123001 lab=_54516_/X }
C {devices/lab_pin.sym} 124140 -29410 0 1 {name=p123002 lab=_54517_/Y }
C {sky130_stdcells/a21oi_4.sym} 124060 -29410 0 0 {name=X_54517_ }
C {devices/lab_pin.sym} 124020 -29270 0 0 {name=p123003 lab=_73351_/A }
C {devices/lab_pin.sym} 124100 -29270 0 1 {name=p123004 lab=_73351_/X }
C {sky130_stdcells/buf_2.sym} 124060 -29270 0 0 {name=X_73351_ }
C {devices/lab_pin.sym} 123970 -29150 0 0 {name=p123005 lab=_85338_/CLK }
C {devices/lab_pin.sym} 123970 -29130 0 0 {name=p123006 lab=_85337_/D }
C {devices/lab_pin.sym} 124150 -29150 0 1 {name=p123007 lab=_85337_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -29140 0 0 {name=X_85337_ }
C {devices/lab_pin.sym} 123980 -29030 0 0 {name=p123008 lab=_85956_/Q }
C {devices/lab_pin.sym} 123980 -28990 0 0 {name=p123009 lab=_50220_/X }
C {devices/lab_pin.sym} 123980 -28950 0 0 {name=p123010 lab=_51728_/Y }
C {devices/lab_pin.sym} 124140 -28990 0 1 {name=p123011 lab=_51729_/Y }
C {sky130_stdcells/o21ai_4.sym} 124060 -28990 0 0 {name=X_51729_ }
C {devices/lab_pin.sym} 124020 -28850 0 0 {name=p123012 lab=_71215_/C }
C {devices/lab_pin.sym} 124100 -28850 0 1 {name=p123013 lab=_70568_/D }
C {sky130_stdcells/buf_2.sym} 124060 -28850 0 0 {name=X_70563_ }
C {devices/lab_pin.sym} 124000 -28740 0 0 {name=p123014 lab=_63655_/B }
C {devices/lab_pin.sym} 124000 -28700 0 0 {name=p123015 lab=_58248_/B }
C {devices/lab_pin.sym} 124120 -28720 0 1 {name=p123016 lab=_58285_/Y }
C {sky130_stdcells/nor2_4.sym} 124060 -28720 0 0 {name=X_58285_ }
C {devices/lab_pin.sym} 123970 -28590 0 0 {name=p123017 lab=_82369_/CLK }
C {devices/lab_pin.sym} 123970 -28570 0 0 {name=p123018 lab=_82549_/D }
C {devices/lab_pin.sym} 124150 -28590 0 1 {name=p123019 lab=_78833_/B }
C {sky130_stdcells/dfxtp_4.sym} 124060 -28580 0 0 {name=X_82549_ }
C {devices/lab_pin.sym} 123980 -28470 0 0 {name=p123020 lab=_55494_/X }
C {devices/lab_pin.sym} 123980 -28430 0 0 {name=p123021 lab=_55496_/X }
C {devices/lab_pin.sym} 123980 -28390 0 0 {name=p123022 lab=_44111_/X }
C {devices/lab_pin.sym} 124140 -28430 0 1 {name=p123023 lab=_55501_/A }
C {sky130_stdcells/a21o_4.sym} 124060 -28430 0 0 {name=X_55497_ }
C {devices/lab_pin.sym} 124000 -28300 0 0 {name=p123024 lab=_72302_/A }
C {devices/lab_pin.sym} 124000 -28260 0 0 {name=p123025 lab=_72348_/B }
C {devices/lab_pin.sym} 124120 -28280 0 1 {name=p123026 lab=_72302_/Y }
C {sky130_stdcells/nor2_4.sym} 124060 -28280 0 0 {name=X_72302_ }
C {devices/lab_pin.sym} 124020 -28150 0 0 {name=p123027 lab=_57235_/Y }
C {devices/lab_pin.sym} 124100 -28150 0 1 {name=p123028 lab=_57236_/X }
C {sky130_stdcells/buf_2.sym} 124060 -28150 0 0 {name=X_57236_ }
C {devices/lab_pin.sym} 123980 -28050 0 0 {name=p123029 lab=_55774_/B }
C {devices/lab_pin.sym} 123980 -28010 0 0 {name=p123030 lab=_45206_/X }
C {devices/lab_pin.sym} 123980 -27970 0 0 {name=p123031 lab=_45237_/X }
C {devices/lab_pin.sym} 124140 -28010 0 1 {name=p123032 lab=_45250_/X }
C {sky130_stdcells/o21a_4.sym} 124060 -28010 0 0 {name=X_45250_ }
C {devices/lab_pin.sym} 124000 -27880 0 0 {name=p123033 lab=_81719_/D }
C {devices/lab_pin.sym} 124000 -27840 0 0 {name=p123034 lab=_76070_/B }
C {devices/lab_pin.sym} 124120 -27860 0 1 {name=p123035 lab=_76073_/A }
C {sky130_stdcells/xor2_4.sym} 124060 -27860 0 0 {name=X_76070_ }
C {devices/lab_pin.sym} 123970 -27730 0 0 {name=p123036 lab=_88056_/CLK }
C {devices/lab_pin.sym} 123970 -27710 0 0 {name=p123037 lab=_42054_/Y }
C {devices/lab_pin.sym} 124150 -27730 0 1 {name=p123038 lab=_73438_/A }
C {sky130_stdcells/dfxtp_4.sym} 124060 -27720 0 0 {name=X_88056_ }
C {devices/lab_pin.sym} 124020 -27590 0 0 {name=p123039 lab=_42488_/A }
C {devices/lab_pin.sym} 124100 -27590 0 1 {name=p123040 lab=_42463_/A }
C {sky130_stdcells/buf_2.sym} 124060 -27590 0 0 {name=X_42462_ }
C {devices/lab_pin.sym} 124020 -27470 0 0 {name=p123041 lab=_54475_/A }
C {devices/lab_pin.sym} 124100 -27470 0 1 {name=p123042 lab=_54448_/X }
C {sky130_stdcells/buf_2.sym} 124060 -27470 0 0 {name=X_54448_ }
C {devices/lab_pin.sym} 124000 -27360 0 0 {name=p123043 lab=_73206_/X }
C {devices/lab_pin.sym} 124000 -27320 0 0 {name=p123044 lab=_85869_/Q }
C {devices/lab_pin.sym} 124120 -27340 0 1 {name=p123045 lab=_73282_/X }
C {sky130_stdcells/and2_4.sym} 124060 -27340 0 0 {name=X_73282_ }
C {devices/lab_pin.sym} 123970 -27210 0 0 {name=p123046 lab=_86900_/CLK }
C {devices/lab_pin.sym} 123970 -27190 0 0 {name=p123047 lab=_85268_/D }
C {devices/lab_pin.sym} 124150 -27210 0 1 {name=p123048 lab=_85268_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -27200 0 0 {name=X_85268_ }
C {devices/lab_pin.sym} 124020 -27070 0 0 {name=p123049 lab=_70696_/B }
C {devices/lab_pin.sym} 124100 -27070 0 1 {name=p123050 lab=_70500_/B }
C {sky130_stdcells/buf_2.sym} 124060 -27070 0 0 {name=X_70494_ }
C {devices/lab_pin.sym} 124000 -26980 0 0 {name=p123051 lab=_44139_/X }
C {devices/lab_pin.sym} 124000 -26940 0 0 {name=p123052 lab=_44141_/X }
C {devices/lab_pin.sym} 124000 -26900 0 0 {name=p123053 lab=_44142_/X }
C {devices/lab_pin.sym} 124000 -26860 0 0 {name=p123054 lab=_44166_/Y }
C {devices/lab_pin.sym} 124120 -26920 0 1 {name=p123055 lab=_44201_/Y }
C {sky130_stdcells/nand4_4.sym} 124060 -26920 0 0 {name=X_44201_ }
C {devices/lab_pin.sym} 124000 -26780 0 0 {name=p123056 lab=_75020_/Y }
C {devices/lab_pin.sym} 124000 -26740 0 0 {name=p123057 lab=_75021_/B }
C {devices/lab_pin.sym} 124120 -26760 0 1 {name=p123058 lab=_75021_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -26760 0 0 {name=X_75021_ }
C {devices/lab_pin.sym} 123970 -26630 0 0 {name=p123059 lab=_87859_/CLK }
C {devices/lab_pin.sym} 123970 -26610 0 0 {name=p123060 lab=_87007_/D }
C {devices/lab_pin.sym} 124150 -26630 0 1 {name=p123061 lab=_87007_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -26620 0 0 {name=X_87007_ }
C {devices/lab_pin.sym} 124020 -26490 0 0 {name=p123062 lab=_41186_/A }
C {devices/lab_pin.sym} 124100 -26490 0 1 {name=p123063 lab=_41435_/B }
C {sky130_stdcells/buf_2.sym} 124060 -26490 0 0 {name=X_41413_ }
C {devices/lab_pin.sym} 124000 -26380 0 0 {name=p123064 lab=_86616_/Q }
C {devices/lab_pin.sym} 124000 -26340 0 0 {name=p123065 lab=_72162_/B }
C {devices/lab_pin.sym} 124120 -26360 0 1 {name=p123066 lab=_72233_/Y }
C {sky130_stdcells/nor2_4.sym} 124060 -26360 0 0 {name=X_72233_ }
C {devices/lab_pin.sym} 123970 -26230 0 0 {name=p123067 lab=_81227_/CLK }
C {devices/lab_pin.sym} 123970 -26210 0 0 {name=p123068 lab=_84219_/D }
C {devices/lab_pin.sym} 124150 -26230 0 1 {name=p123069 lab=_84219_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -26220 0 0 {name=X_84219_ }
C {devices/lab_pin.sym} 124020 -26090 0 0 {name=p123070 lab=_45181_/A }
C {devices/lab_pin.sym} 124100 -26090 0 1 {name=p123071 lab=_45182_/A }
C {sky130_stdcells/inv_2.sym} 124060 -26090 0 0 {name=X_45181_ }
C {devices/lab_pin.sym} 123980 -25990 0 0 {name=p123072 lab=_55186_/B }
C {devices/lab_pin.sym} 123980 -25950 0 0 {name=p123073 lab=_57106_/X }
C {devices/lab_pin.sym} 123980 -25910 0 0 {name=p123074 lab=_57166_/X }
C {devices/lab_pin.sym} 124140 -25950 0 1 {name=p123075 lab=_85069_/D }
C {sky130_stdcells/o21ai_4.sym} 124060 -25950 0 0 {name=X_57167_ }
C {devices/lab_pin.sym} 123980 -25840 0 0 {name=p123076 lab=_40400_/X }
C {devices/lab_pin.sym} 123980 -25800 0 0 {name=p123077 lab=_42388_/X }
C {devices/lab_pin.sym} 123980 -25760 0 0 {name=p123078 lab=_87885_/Q }
C {devices/lab_pin.sym} 123980 -25720 0 0 {name=p123079 lab=_42389_/X }
C {devices/lab_pin.sym} 124140 -25780 0 1 {name=p123080 lab=_42393_/X }
C {sky130_stdcells/a2bb2o_4.sym} 124060 -25780 0 0 {name=X_42393_ }
C {devices/lab_pin.sym} 123980 -25650 0 0 {name=p123081 lab=_85453_/Q }
C {devices/lab_pin.sym} 123980 -25610 0 0 {name=p123082 lab=_54376_/X }
C {devices/lab_pin.sym} 123980 -25570 0 0 {name=p123083 lab=_54378_/Y }
C {devices/lab_pin.sym} 124140 -25610 0 1 {name=p123084 lab=_54379_/Y }
C {sky130_stdcells/o21ai_4.sym} 124060 -25610 0 0 {name=X_54379_ }
C {devices/lab_pin.sym} 123970 -25470 0 0 {name=p123085 lab=_85198_/CLK }
C {devices/lab_pin.sym} 123970 -25450 0 0 {name=p123086 lab=_85199_/D }
C {devices/lab_pin.sym} 124150 -25470 0 1 {name=p123087 lab=_56424_/C }
C {sky130_stdcells/dfxtp_4.sym} 124060 -25460 0 0 {name=X_85199_ }
C {devices/lab_pin.sym} 124020 -25330 0 0 {name=p123088 lab=_72784_/A }
C {devices/lab_pin.sym} 124100 -25330 0 1 {name=p123089 lab=_73614_/A }
C {sky130_stdcells/buf_2.sym} 124060 -25330 0 0 {name=X_44132_ }
C {devices/lab_pin.sym} 124020 -25210 0 0 {name=p123090 lab=_56118_/A }
C {devices/lab_pin.sym} 124100 -25210 0 1 {name=p123091 lab=_56138_/B }
C {sky130_stdcells/buf_2.sym} 124060 -25210 0 0 {name=X_56118_ }
C {devices/lab_pin.sym} 124020 -25090 0 0 {name=p123092 lab=_40365_/X }
C {devices/lab_pin.sym} 124100 -25090 0 1 {name=p123093 lab=_41344_/X }
C {sky130_stdcells/buf_2.sym} 124060 -25090 0 0 {name=X_41344_ }
C {devices/lab_pin.sym} 123980 -25000 0 0 {name=p123094 lab=_72151_/Y }
C {devices/lab_pin.sym} 123980 -24960 0 0 {name=p123095 lab=_72152_/X }
C {devices/lab_pin.sym} 123980 -24920 0 0 {name=p123096 lab=_72159_/X }
C {devices/lab_pin.sym} 123980 -24880 0 0 {name=p123097 lab=_72163_/X }
C {devices/lab_pin.sym} 124140 -24940 0 1 {name=p123098 lab=_83278_/D }
C {sky130_stdcells/a22oi_4.sym} 124060 -24940 0 0 {name=X_72164_ }
C {devices/lab_pin.sym} 124020 -24790 0 0 {name=p123099 lab=_57093_/Y }
C {devices/lab_pin.sym} 124100 -24790 0 1 {name=p123100 lab=_57221_/A }
C {sky130_stdcells/buf_2.sym} 124060 -24790 0 0 {name=X_57098_ }
C {devices/lab_pin.sym} 124000 -24700 0 0 {name=p123101 lab=_70913_/A }
C {devices/lab_pin.sym} 124000 -24660 0 0 {name=p123102 lab=_71115_/B }
C {devices/lab_pin.sym} 124000 -24620 0 0 {name=p123103 lab=_71115_/C }
C {devices/lab_pin.sym} 124000 -24580 0 0 {name=p123104 lab=_71115_/D }
C {devices/lab_pin.sym} 124120 -24640 0 1 {name=p123105 lab=_71115_/X }
C {sky130_stdcells/and4_4.sym} 124060 -24640 0 0 {name=X_71115_ }
C {devices/lab_pin.sym} 124000 -24510 0 0 {name=p123106 lab=_52291_/A }
C {devices/lab_pin.sym} 124000 -24470 0 0 {name=p123107 lab=_48940_/B }
C {devices/lab_pin.sym} 124000 -24430 0 0 {name=p123108 lab=_48928_/C }
C {devices/lab_pin.sym} 124120 -24470 0 1 {name=p123109 lab=_48940_/X }
C {sky130_stdcells/and3_4.sym} 124060 -24470 0 0 {name=X_48940_ }
C {devices/lab_pin.sym} 124020 -24330 0 0 {name=p123110 lab=_55470_/A }
C {devices/lab_pin.sym} 124100 -24330 0 1 {name=p123111 lab=_44063_/X }
C {sky130_stdcells/buf_2.sym} 124060 -24330 0 0 {name=X_44063_ }
C {devices/lab_pin.sym} 124000 -24230 0 0 {name=p123112 lab=_56171_/A }
C {devices/lab_pin.sym} 124000 -24190 0 0 {name=p123113 lab=_56171_/C }
C {devices/lab_pin.sym} 124000 -24150 0 0 {name=p123114 lab=_56048_/Y }
C {devices/lab_pin.sym} 124120 -24190 0 1 {name=p123115 lab=_56049_/Y }
C {sky130_stdcells/nand3_4.sym} 124060 -24190 0 0 {name=X_56049_ }
C {devices/lab_pin.sym} 124000 -24060 0 0 {name=p123116 lab=_79767_/B }
C {devices/lab_pin.sym} 124000 -24020 0 0 {name=p123117 lab=_79760_/B }
C {devices/lab_pin.sym} 124120 -24040 0 1 {name=p123118 lab=_79760_/X }
C {sky130_stdcells/xor2_4.sym} 124060 -24040 0 0 {name=X_79760_ }
C {devices/lab_pin.sym} 124000 -23920 0 0 {name=p123119 lab=_81699_/Q }
C {devices/lab_pin.sym} 124000 -23880 0 0 {name=p123120 lab=_41275_/B }
C {devices/lab_pin.sym} 124120 -23900 0 1 {name=p123121 lab=_41275_/X }
C {sky130_stdcells/or2_4.sym} 124060 -23900 0 0 {name=X_41275_ }
C {devices/lab_pin.sym} 123980 -23790 0 0 {name=p123122 lab=_72093_/Y }
C {devices/lab_pin.sym} 123980 -23750 0 0 {name=p123123 lab=_72083_/X }
C {devices/lab_pin.sym} 123980 -23710 0 0 {name=p123124 lab=_72094_/Y }
C {devices/lab_pin.sym} 124140 -23750 0 1 {name=p123125 lab=_83286_/D }
C {sky130_stdcells/a21boi_4.sym} 124060 -23750 0 0 {name=X_72095_ }
C {devices/lab_pin.sym} 124000 -23620 0 0 {name=p123126 lab=_84524_/Q }
C {devices/lab_pin.sym} 124000 -23580 0 0 {name=p123127 lab=_62616_/C }
C {devices/lab_pin.sym} 124120 -23600 0 1 {name=p123128 lab=_76972_/X }
C {sky130_stdcells/xor2_4.sym} 124060 -23600 0 0 {name=X_76972_ }
C {devices/lab_pin.sym} 124020 -23470 0 0 {name=p123129 lab=_43013_/X }
C {devices/lab_pin.sym} 124100 -23470 0 1 {name=p123130 lab=_43014_/Y }
C {sky130_stdcells/inv_2.sym} 124060 -23470 0 0 {name=X_43014_ }
C {devices/lab_pin.sym} 124000 -23360 0 0 {name=p123131 lab=_78710_/A }
C {devices/lab_pin.sym} 124000 -23320 0 0 {name=p123132 lab=_82685_/D }
C {devices/lab_pin.sym} 124120 -23340 0 1 {name=p123133 lab=_78712_/A }
C {sky130_stdcells/nand2_4.sym} 124060 -23340 0 0 {name=X_78711_ }
C {devices/lab_pin.sym} 124020 -23210 0 0 {name=p123134 lab=_71046_/A }
C {devices/lab_pin.sym} 124100 -23210 0 1 {name=p123135 lab=_71046_/X }
C {sky130_stdcells/buf_2.sym} 124060 -23210 0 0 {name=X_71046_ }
C {devices/lab_pin.sym} 124000 -23100 0 0 {name=p123136 lab=_61089_/C }
C {devices/lab_pin.sym} 124000 -23060 0 0 {name=p123137 lab=_75923_/B }
C {devices/lab_pin.sym} 124120 -23080 0 1 {name=p123138 lab=_80737_/D }
C {sky130_stdcells/xor2_4.sym} 124060 -23080 0 0 {name=X_75923_ }
C {devices/lab_pin.sym} 123970 -22950 0 0 {name=p123139 lab=_88220_/CLK }
C {devices/lab_pin.sym} 123970 -22930 0 0 {name=p123140 lab=_87909_/D }
C {devices/lab_pin.sym} 124150 -22950 0 1 {name=p123141 lab=_87909_/Q }
C {sky130_stdcells/dfxtp_4.sym} 124060 -22940 0 0 {name=X_87909_ }
C {devices/lab_pin.sym} 123980 -22830 0 0 {name=p123142 lab=_48869_/Y }
C {devices/lab_pin.sym} 123980 -22790 0 0 {name=p123143 lab=_48865_/X }
C {devices/lab_pin.sym} 123980 -22750 0 0 {name=p123144 lab=_48870_/X }
C {devices/lab_pin.sym} 124140 -22790 0 1 {name=p123145 lab=_86467_/D }
C {sky130_stdcells/a21oi_4.sym} 124060 -22790 0 0 {name=X_48871_ }
C {devices/lab_pin.sym} 124000 -22660 0 0 {name=p123146 lab=_79691_/A }
C {devices/lab_pin.sym} 124000 -22620 0 0 {name=p123147 lab=_79691_/B }
C {devices/lab_pin.sym} 124120 -22640 0 1 {name=p123148 lab=_79692_/B }
C {sky130_stdcells/xor2_4.sym} 124060 -22640 0 0 {name=X_79691_ }
C {devices/lab_pin.sym} 124020 -22510 0 0 {name=p123149 lab=clkbuf_9_285_0_CLK/X }
C {devices/lab_pin.sym} 124100 -22510 0 1 {name=p123150 lab=_88180_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 124060 -22510 0 0 {name=Xclkbuf_10_570_0_CLK }
C {devices/lab_pin.sym} 124020 -22390 0 0 {name=p123151 lab=clkbuf_6_61_0_CLK/A }
C {devices/lab_pin.sym} 124100 -22390 0 1 {name=p123152 lab=clkbuf_6_61_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 124060 -22390 0 0 {name=Xclkbuf_6_61_0_CLK }
C {devices/lab_pin.sym} 124020 -22270 0 0 {name=p123153 lab=_47822_/A }
C {devices/lab_pin.sym} 124100 -22270 0 1 {name=p123154 lab=_53261_/D }
C {sky130_stdcells/buf_2.sym} 124060 -22270 0 0 {name=X_47822_ }
C {devices/lab_pin.sym} 124020 -22150 0 0 {name=p123155 lab=_59824_/B }
C {devices/lab_pin.sym} 124100 -22150 0 1 {name=p123156 lab=_61966_/A }
C {sky130_stdcells/buf_2.sym} 124060 -22150 0 0 {name=X_59808_ }
C {devices/lab_pin.sym} 123980 -22050 0 0 {name=p123157 lab=_78605_/Y }
C {devices/lab_pin.sym} 123980 -22010 0 0 {name=p123158 lab=_78640_/X }
C {devices/lab_pin.sym} 123980 -21970 0 0 {name=p123159 lab=_78641_/Y }
C {devices/lab_pin.sym} 124140 -22010 0 1 {name=p123160 lab=_78642_/Y }
C {sky130_stdcells/a21oi_4.sym} 124060 -22010 0 0 {name=X_78642_ }
C {devices/lab_pin.sym} 124020 -21870 0 0 {name=p123161 lab=_75853_/X }
C {devices/lab_pin.sym} 124100 -21870 0 1 {name=p123162 lab=_75854_/Y }
C {sky130_stdcells/inv_2.sym} 124060 -21870 0 0 {name=X_75854_ }
C {devices/lab_pin.sym} 123980 -21780 0 0 {name=p123163 lab=_70158_/Y }
C {devices/lab_pin.sym} 123980 -21740 0 0 {name=p123164 lab=_70669_/A }
C {devices/lab_pin.sym} 123980 -21700 0 0 {name=p123165 lab=_83833_/Q }
C {devices/lab_pin.sym} 123980 -21660 0 0 {name=p123166 lab=_74716_/X }
C {devices/lab_pin.sym} 124140 -21720 0 1 {name=p123167 lab=_74805_/X }
C {sky130_stdcells/a2bb2o_4.sym} 124060 -21720 0 0 {name=X_74805_ }
C {devices/lab_pin.sym} 124000 -21580 0 0 {name=p123168 lab=_47715_/X }
C {devices/lab_pin.sym} 124000 -21540 0 0 {name=p123169 lab=_53227_/B }
C {devices/lab_pin.sym} 124120 -21560 0 1 {name=p123170 lab=_47753_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -21560 0 0 {name=X_47753_ }
C {devices/lab_pin.sym} 124020 -21430 0 0 {name=p123171 lab=_62640_/C }
C {devices/lab_pin.sym} 124100 -21430 0 1 {name=p123172 lab=_62717_/A }
C {sky130_stdcells/buf_2.sym} 124060 -21430 0 0 {name=X_59739_ }
C {devices/lab_pin.sym} 123980 -21330 0 0 {name=p123173 lab=_78569_/X }
C {devices/lab_pin.sym} 123980 -21290 0 0 {name=p123174 lab=_78574_/C }
C {devices/lab_pin.sym} 123980 -21250 0 0 {name=p123175 lab=_78572_/Y }
C {devices/lab_pin.sym} 124140 -21290 0 1 {name=p123176 lab=_78575_/A }
C {sky130_stdcells/a21o_4.sym} 124060 -21290 0 0 {name=X_78573_ }
C {devices/lab_pin.sym} 123980 -21170 0 0 {name=p123177 lab=_56027_/C }
C {devices/lab_pin.sym} 123980 -21130 0 0 {name=p123178 lab=_44963_/X }
C {devices/lab_pin.sym} 123980 -21090 0 0 {name=p123179 lab=_44964_/X }
C {devices/lab_pin.sym} 124140 -21130 0 1 {name=p123180 lab=_44965_/X }
C {sky130_stdcells/o21a_4.sym} 124060 -21130 0 0 {name=X_44965_ }
C {devices/lab_pin.sym} 124000 -21000 0 0 {name=p123181 lab=_81017_/Q }
C {devices/lab_pin.sym} 124000 -20960 0 0 {name=p123182 lab=_80889_/D }
C {devices/lab_pin.sym} 124120 -20980 0 1 {name=p123183 lab=_80985_/D }
C {sky130_stdcells/xor2_4.sym} 124060 -20980 0 0 {name=X_75785_ }
C {devices/lab_pin.sym} 124000 -20860 0 0 {name=p123184 lab=_72984_/Y }
C {devices/lab_pin.sym} 124000 -20820 0 0 {name=p123185 lab=_72996_/X }
C {devices/lab_pin.sym} 124120 -20840 0 1 {name=p123186 lab=_72997_/X }
C {sky130_stdcells/xor2_4.sym} 124060 -20840 0 0 {name=X_72997_ }
C {devices/lab_pin.sym} 124020 -20710 0 0 {name=p123187 lab=_46751_/A }
C {devices/lab_pin.sym} 124100 -20710 0 1 {name=p123188 lab=_46704_/X }
C {sky130_stdcells/buf_2.sym} 124060 -20710 0 0 {name=X_46704_ }
C {devices/lab_pin.sym} 123980 -20610 0 0 {name=p123189 lab=_77512_/A }
C {devices/lab_pin.sym} 123980 -20570 0 0 {name=p123190 lab=_77523_/Y }
C {devices/lab_pin.sym} 123980 -20530 0 0 {name=p123191 lab=_77495_/Y }
C {devices/lab_pin.sym} 124140 -20570 0 1 {name=p123192 lab=_77524_/Y }
C {sky130_stdcells/o21ai_4.sym} 124060 -20570 0 0 {name=X_77524_ }
C {devices/lab_pin.sym} 124020 -20430 0 0 {name=p123193 lab=_43810_/A }
C {devices/lab_pin.sym} 124100 -20430 0 1 {name=p123194 lab=_43916_/X }
C {sky130_stdcells/buf_2.sym} 124060 -20430 0 0 {name=X_43916_ }
C {devices/lab_pin.sym} 124000 -20340 0 0 {name=p123195 lab=_62711_/A }
C {devices/lab_pin.sym} 124000 -20300 0 0 {name=p123196 lab=_64307_/C }
C {devices/lab_pin.sym} 124000 -20260 0 0 {name=p123197 lab=_62737_/X }
C {devices/lab_pin.sym} 124000 -20220 0 0 {name=p123198 lab=_62738_/D }
C {devices/lab_pin.sym} 124120 -20280 0 1 {name=p123199 lab=_62750_/X }
C {sky130_stdcells/and4_4.sym} 124060 -20280 0 0 {name=X_62750_ }
C {devices/lab_pin.sym} 123980 -20150 0 0 {name=p123200 lab=_74716_/A }
C {devices/lab_pin.sym} 123980 -20110 0 0 {name=p123201 lab=_70586_/X }
C {devices/lab_pin.sym} 123980 -20070 0 0 {name=p123202 lab=_74731_/X }
C {devices/lab_pin.sym} 124140 -20110 0 1 {name=p123203 lab=_74736_/X }
C {sky130_stdcells/a21o_4.sym} 124060 -20110 0 0 {name=X_74736_ }
C {devices/lab_pin.sym} 124000 -20000 0 0 {name=p123204 lab=_47692_/A }
C {devices/lab_pin.sym} 124000 -19960 0 0 {name=p123205 lab=_47692_/B }
C {devices/lab_pin.sym} 124000 -19920 0 0 {name=p123206 lab=_47692_/C }
C {devices/lab_pin.sym} 124000 -19880 0 0 {name=p123207 lab=_53185_/D }
C {devices/lab_pin.sym} 124120 -19940 0 1 {name=p123208 lab=_47684_/X }
C {sky130_stdcells/and4_4.sym} 124060 -19940 0 0 {name=X_47684_ }
C {devices/lab_pin.sym} 123980 -19810 0 0 {name=p123209 lab=_55652_/Y }
C {devices/lab_pin.sym} 123980 -19770 0 0 {name=p123210 lab=_71939_/X }
C {devices/lab_pin.sym} 123980 -19730 0 0 {name=p123211 lab=_71947_/Y }
C {devices/lab_pin.sym} 124140 -19770 0 1 {name=p123212 lab=_83318_/D }
C {sky130_stdcells/o21ai_4.sym} 124060 -19770 0 0 {name=X_71948_ }
C {devices/lab_pin.sym} 124020 -19630 0 0 {name=p123213 lab=_44895_/X }
C {devices/lab_pin.sym} 124100 -19630 0 1 {name=p123214 lab=_45876_/B }
C {sky130_stdcells/buf_2.sym} 124060 -19630 0 0 {name=X_44896_ }
C {devices/lab_pin.sym} 124020 -19510 0 0 {name=p123215 lab=clkbuf_9_292_0_CLK/X }
C {devices/lab_pin.sym} 124100 -19510 0 1 {name=p123216 lab=_81130_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 124060 -19510 0 0 {name=Xclkbuf_10_585_0_CLK }
C {devices/lab_pin.sym} 123980 -19410 0 0 {name=p123217 lab=_58699_/B }
C {devices/lab_pin.sym} 123980 -19370 0 0 {name=p123218 lab=_49415_/X }
C {devices/lab_pin.sym} 123980 -19330 0 0 {name=p123219 lab=_49422_/Y }
C {devices/lab_pin.sym} 124140 -19370 0 1 {name=p123220 lab=_49423_/Y }
C {sky130_stdcells/o21ai_4.sym} 124060 -19370 0 0 {name=X_49423_ }
C {devices/lab_pin.sym} 123980 -19250 0 0 {name=p123221 lab=_61698_/X }
C {devices/lab_pin.sym} 123980 -19210 0 0 {name=p123222 lab=_61699_/X }
C {devices/lab_pin.sym} 123980 -19170 0 0 {name=p123223 lab=_61700_/Y }
C {devices/lab_pin.sym} 124140 -19210 0 1 {name=p123224 lab=_61701_/Y }
C {sky130_stdcells/a21oi_4.sym} 124060 -19210 0 0 {name=X_61701_ }
C {devices/lab_pin.sym} 124000 -19080 0 0 {name=p123225 lab=_46651_/A }
C {devices/lab_pin.sym} 124000 -19040 0 0 {name=p123226 lab=_50893_/B }
C {devices/lab_pin.sym} 124120 -19060 0 1 {name=p123227 lab=_46635_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -19060 0 0 {name=X_46635_ }
C {devices/lab_pin.sym} 124020 -18930 0 0 {name=p123228 lab=_77455_/A }
C {devices/lab_pin.sym} 124100 -18930 0 1 {name=p123229 lab=_77455_/Y }
C {sky130_stdcells/inv_2.sym} 124060 -18930 0 0 {name=X_77455_ }
C {devices/lab_pin.sym} 124020 -18810 0 0 {name=p123230 lab=_43776_/A }
C {devices/lab_pin.sym} 124100 -18810 0 1 {name=p123231 lab=_43847_/X }
C {sky130_stdcells/buf_2.sym} 124060 -18810 0 0 {name=X_43847_ }
C {devices/lab_pin.sym} 124000 -18700 0 0 {name=p123232 lab=_74679_/A }
C {devices/lab_pin.sym} 124000 -18660 0 0 {name=p123233 lab=_74667_/B }
C {devices/lab_pin.sym} 124120 -18680 0 1 {name=p123234 lab=_74667_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -18680 0 0 {name=X_74667_ }
C {devices/lab_pin.sym} 124020 -18550 0 0 {name=p123235 lab=_60179_/Y }
C {devices/lab_pin.sym} 124100 -18550 0 1 {name=p123236 lab=_62681_/X }
C {sky130_stdcells/buf_2.sym} 124060 -18550 0 0 {name=X_62681_ }
C {devices/lab_pin.sym} 124000 -18460 0 0 {name=p123237 lab=_71857_/A }
C {devices/lab_pin.sym} 124000 -18420 0 0 {name=p123238 lab=_71883_/B }
C {devices/lab_pin.sym} 124000 -18380 0 0 {name=p123239 lab=_71873_/X }
C {devices/lab_pin.sym} 124000 -18340 0 0 {name=p123240 lab=_71883_/D }
C {devices/lab_pin.sym} 124120 -18400 0 1 {name=p123241 lab=_71879_/Y }
C {sky130_stdcells/nor4_4.sym} 124060 -18400 0 0 {name=X_71879_ }
C {devices/lab_pin.sym} 124000 -18260 0 0 {name=p123242 lab=_76406_/A }
C {devices/lab_pin.sym} 124000 -18220 0 0 {name=p123243 lab=_76405_/Y }
C {devices/lab_pin.sym} 124120 -18240 0 1 {name=p123244 lab=_76407_/B }
C {sky130_stdcells/xor2_4.sym} 124060 -18240 0 0 {name=X_76406_ }
C {devices/lab_pin.sym} 124000 -18130 0 0 {name=p123245 lab=_64377_/X }
C {devices/lab_pin.sym} 124000 -18090 0 0 {name=p123246 lab=_64420_/B }
C {devices/lab_pin.sym} 124000 -18050 0 0 {name=p123247 lab=_64391_/X }
C {devices/lab_pin.sym} 124120 -18090 0 1 {name=p123248 lab=_64420_/X }
C {sky130_stdcells/and3_4.sym} 124060 -18090 0 0 {name=X_64420_ }
C {devices/lab_pin.sym} 124000 -17960 0 0 {name=p123249 lab=_48917_/X }
C {devices/lab_pin.sym} 124000 -17920 0 0 {name=p123250 lab=_54087_/B }
C {devices/lab_pin.sym} 124120 -17940 0 1 {name=p123251 lab=_49354_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -17940 0 0 {name=X_49354_ }
C {devices/lab_pin.sym} 124020 -17810 0 0 {name=p123252 lab=_61632_/A }
C {devices/lab_pin.sym} 124100 -17810 0 1 {name=p123253 lab=_61632_/Y }
C {sky130_stdcells/inv_2.sym} 124060 -17810 0 0 {name=X_61632_ }
C {devices/lab_pin.sym} 124000 -17700 0 0 {name=p123254 lab=_73618_/A }
C {devices/lab_pin.sym} 124000 -17660 0 0 {name=p123255 lab=_73617_/X }
C {devices/lab_pin.sym} 124120 -17680 0 1 {name=p123256 lab=_73618_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -17680 0 0 {name=X_73618_ }
C {devices/lab_pin.sym} 123980 -17570 0 0 {name=p123257 lab=_86725_/Q }
C {devices/lab_pin.sym} 123980 -17530 0 0 {name=p123258 lab=_46543_/X }
C {devices/lab_pin.sym} 123980 -17490 0 0 {name=p123259 lab=_46565_/Y }
C {devices/lab_pin.sym} 124140 -17530 0 1 {name=p123260 lab=_46566_/Y }
C {sky130_stdcells/o21ai_4.sym} 124060 -17530 0 0 {name=X_46566_ }
C {devices/lab_pin.sym} 124000 -17400 0 0 {name=p123261 lab=_77386_/A }
C {devices/lab_pin.sym} 124000 -17360 0 0 {name=p123262 lab=_77386_/B }
C {devices/lab_pin.sym} 124120 -17380 0 1 {name=p123263 lab=_77396_/A }
C {sky130_stdcells/xor2_4.sym} 124060 -17380 0 0 {name=X_77386_ }
C {devices/lab_pin.sym} 124020 -17250 0 0 {name=p123264 lab=_43777_/Y }
C {devices/lab_pin.sym} 124100 -17250 0 1 {name=p123265 lab=_87272_/D }
C {sky130_stdcells/inv_2.sym} 124060 -17250 0 0 {name=X_43778_ }
C {devices/lab_pin.sym} 124020 -17130 0 0 {name=p123266 lab=_74549_/Y }
C {devices/lab_pin.sym} 124100 -17130 0 1 {name=p123267 lab=_74598_/X }
C {sky130_stdcells/buf_2.sym} 124060 -17130 0 0 {name=X_74598_ }
C {devices/lab_pin.sym} 124000 -17020 0 0 {name=p123268 lab=_48319_/A }
C {devices/lab_pin.sym} 124000 -16980 0 0 {name=p123269 lab=_48073_/B }
C {devices/lab_pin.sym} 124120 -17000 0 1 {name=p123270 lab=_48305_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -17000 0 0 {name=X_48305_ }
C {devices/lab_pin.sym} 124020 -16870 0 0 {name=p123271 lab=_78833_/Y }
C {devices/lab_pin.sym} 124100 -16870 0 1 {name=p123272 lab=_82501_/D }
C {sky130_stdcells/inv_2.sym} 124060 -16870 0 0 {name=X_79125_ }
C {devices/lab_pin.sym} 124000 -16760 0 0 {name=p123273 lab=_85113_/Q }
C {devices/lab_pin.sym} 124000 -16720 0 0 {name=p123274 lab=_45456_/X }
C {devices/lab_pin.sym} 124120 -16740 0 1 {name=p123275 lab=_45517_/Y }
C {sky130_stdcells/nor2_4.sym} 124060 -16740 0 0 {name=X_45517_ }
C {devices/lab_pin.sym} 124000 -16620 0 0 {name=p123276 lab=_59407_/A }
C {devices/lab_pin.sym} 124000 -16580 0 0 {name=p123277 lab=_64316_/B }
C {devices/lab_pin.sym} 124120 -16600 0 1 {name=p123278 lab=_64351_/Y }
C {sky130_stdcells/nor2_4.sym} 124060 -16600 0 0 {name=X_64351_ }
C {devices/lab_pin.sym} 124020 -16470 0 0 {name=p123279 lab=_76337_/A }
C {devices/lab_pin.sym} 124100 -16470 0 1 {name=p123280 lab=_76338_/B }
C {sky130_stdcells/buf_2.sym} 124060 -16470 0 0 {name=X_76337_ }
C {devices/lab_pin.sym} 124020 -16350 0 0 {name=p123281 lab=_42728_/Y }
C {devices/lab_pin.sym} 124100 -16350 0 1 {name=p123282 lab=_87748_/D }
C {sky130_stdcells/inv_2.sym} 124060 -16350 0 0 {name=X_42729_ }
C {devices/lab_pin.sym} 124000 -16260 0 0 {name=p123283 lab=_58446_/A }
C {devices/lab_pin.sym} 124000 -16220 0 0 {name=p123284 lab=_61563_/B }
C {devices/lab_pin.sym} 124000 -16180 0 0 {name=p123285 lab=_61563_/C }
C {devices/lab_pin.sym} 124000 -16140 0 0 {name=p123286 lab=_61563_/D }
C {devices/lab_pin.sym} 124120 -16200 0 1 {name=p123287 lab=_61564_/A }
C {sky130_stdcells/nand4_4.sym} 124060 -16200 0 0 {name=X_61563_ }
C {devices/lab_pin.sym} 124020 -16050 0 0 {name=p123288 lab=_48548_/A }
C {devices/lab_pin.sym} 124100 -16050 0 1 {name=p123289 lab=_49285_/X }
C {sky130_stdcells/buf_2.sym} 124060 -16050 0 0 {name=X_49285_ }
C {devices/lab_pin.sym} 124020 -15930 0 0 {name=p123290 lab=_73193_/A }
C {devices/lab_pin.sym} 124100 -15930 0 1 {name=p123291 lab=_73549_/X }
C {sky130_stdcells/buf_2.sym} 124060 -15930 0 0 {name=X_73549_ }
C {devices/lab_pin.sym} 124020 -15810 0 0 {name=p123292 lab=_54047_/A }
C {devices/lab_pin.sym} 124100 -15810 0 1 {name=p123293 lab=_52528_/A }
C {sky130_stdcells/buf_2.sym} 124060 -15810 0 0 {name=X_46497_ }
C {devices/lab_pin.sym} 124020 -15690 0 0 {name=p123294 lab=_63301_/X }
C {devices/lab_pin.sym} 124100 -15690 0 1 {name=p123295 lab=_63302_/Y }
C {sky130_stdcells/inv_2.sym} 124060 -15690 0 0 {name=X_63302_ }
C {devices/lab_pin.sym} 123980 -15610 0 0 {name=p123296 lab=_60376_/X }
C {devices/lab_pin.sym} 123980 -15570 0 0 {name=p123297 lab=_60512_/Y }
C {devices/lab_pin.sym} 123980 -15530 0 0 {name=p123298 lab=_60399_/Y }
C {devices/lab_pin.sym} 123980 -15490 0 0 {name=p123299 lab=_60445_/A }
C {devices/lab_pin.sym} 123980 -15450 0 0 {name=p123300 lab=_60513_/X }
C {devices/lab_pin.sym} 124140 -15530 0 1 {name=p123301 lab=_60514_/X }
C {sky130_stdcells/o41a_4.sym} 124060 -15530 0 0 {name=X_60514_ }
C {devices/lab_pin.sym} 124000 -15380 0 0 {name=p123302 lab=_48204_/X }
C {devices/lab_pin.sym} 124000 -15340 0 0 {name=p123303 lab=_48236_/B }
C {devices/lab_pin.sym} 124120 -15360 0 1 {name=p123304 lab=_48236_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -15360 0 0 {name=X_48236_ }
C {devices/lab_pin.sym} 123980 -15260 0 0 {name=p123305 lab=_87870_/Q }
C {devices/lab_pin.sym} 123980 -15220 0 0 {name=p123306 lab=_66994_/X }
C {devices/lab_pin.sym} 123980 -15180 0 0 {name=p123307 lab=_67046_/X }
C {devices/lab_pin.sym} 123980 -15140 0 0 {name=p123308 lab=_67069_/X }
C {devices/lab_pin.sym} 124140 -15200 0 1 {name=p123309 lab=_67070_/X }
C {sky130_stdcells/a211o_4.sym} 124060 -15200 0 0 {name=X_67070_ }
C {devices/lab_pin.sym} 123980 -15070 0 0 {name=p123310 lab=_79057_/A }
C {devices/lab_pin.sym} 123980 -15030 0 0 {name=p123311 lab=_79057_/B }
C {devices/lab_pin.sym} 123980 -14990 0 0 {name=p123312 lab=_79057_/C }
C {devices/lab_pin.sym} 124140 -15030 0 1 {name=p123313 lab=_79058_/A }
C {sky130_stdcells/a21o_4.sym} 124060 -15030 0 0 {name=X_79056_ }
C {devices/lab_pin.sym} 124000 -14900 0 0 {name=p123314 lab=_45448_/A }
C {devices/lab_pin.sym} 124000 -14860 0 0 {name=p123315 lab=_44894_/B }
C {devices/lab_pin.sym} 124120 -14880 0 1 {name=p123316 lab=_45448_/Y }
C {sky130_stdcells/nor2_4.sym} 124060 -14880 0 0 {name=X_45448_ }
C {devices/lab_pin.sym} 124000 -14760 0 0 {name=p123317 lab=_64282_/A }
C {devices/lab_pin.sym} 124000 -14720 0 0 {name=p123318 lab=_64301_/B }
C {devices/lab_pin.sym} 124120 -14740 0 1 {name=p123319 lab=_64282_/Y }
C {sky130_stdcells/nor2_4.sym} 124060 -14740 0 0 {name=X_64282_ }
C {devices/lab_pin.sym} 124000 -14640 0 0 {name=p123320 lab=_76209_/Y }
C {devices/lab_pin.sym} 124000 -14600 0 0 {name=p123321 lab=_76223_/Y }
C {devices/lab_pin.sym} 124000 -14560 0 0 {name=p123322 lab=_76239_/X }
C {devices/lab_pin.sym} 124000 -14520 0 0 {name=p123323 lab=_76268_/D }
C {devices/lab_pin.sym} 124120 -14580 0 1 {name=p123324 lab=_76268_/Y }
C {sky130_stdcells/nand4_4.sym} 124060 -14580 0 0 {name=X_76268_ }
C {devices/lab_pin.sym} 124020 -14430 0 0 {name=p123325 lab=_61494_/A }
C {devices/lab_pin.sym} 124100 -14430 0 1 {name=p123326 lab=_61494_/Y }
C {sky130_stdcells/inv_2.sym} 124060 -14430 0 0 {name=X_61494_ }
C {devices/lab_pin.sym} 124020 -14310 0 0 {name=p123327 lab=_65400_/A }
C {devices/lab_pin.sym} 124100 -14310 0 1 {name=p123328 lab=_66021_/X }
C {sky130_stdcells/buf_2.sym} 124060 -14310 0 0 {name=X_66021_ }
C {devices/lab_pin.sym} 124000 -14200 0 0 {name=p123329 lab=_78007_/A }
C {devices/lab_pin.sym} 124000 -14160 0 0 {name=p123330 lab=_78006_/Y }
C {devices/lab_pin.sym} 124120 -14180 0 1 {name=p123331 lab=_78007_/Y }
C {sky130_stdcells/nand2_4.sym} 124060 -14180 0 0 {name=X_78007_ }
C {devices/lab_pin.sym} 123980 -14070 0 0 {name=p123332 lab=_79310_/A }
C {devices/lab_pin.sym} 123980 -14030 0 0 {name=p123333 lab=_63189_/X }
C {devices/lab_pin.sym} 123980 -13990 0 0 {name=p123334 lab=_63232_/Y }
C {devices/lab_pin.sym} 124140 -14030 0 1 {name=p123335 lab=_84342_/D }
C {sky130_stdcells/a21o_4.sym} 124060 -14030 0 0 {name=X_63233_ }
C {devices/lab_pin.sym} 123980 -13910 0 0 {name=p123336 lab=_75196_/Y }
C {devices/lab_pin.sym} 123980 -13870 0 0 {name=p123337 lab=_75217_/Y }
C {devices/lab_pin.sym} 123980 -13830 0 0 {name=p123338 lab=_75218_/Y }
C {devices/lab_pin.sym} 124140 -13870 0 1 {name=p123339 lab=_75219_/Y }
C {sky130_stdcells/a21oi_4.sym} 124060 -13870 0 0 {name=X_75219_ }
C {devices/lab_pin.sym} 124020 -13730 0 0 {name=p123340 lab=_48166_/Y }
C {devices/lab_pin.sym} 124100 -13730 0 1 {name=p123341 lab=_86561_/D }
C {sky130_stdcells/inv_2.sym} 124060 -13730 0 0 {name=X_48167_ }
C {devices/lab_pin.sym} 124000 -13620 0 0 {name=p123342 lab=_60445_/A }
C {devices/lab_pin.sym} 124000 -13580 0 0 {name=p123343 lab=_60444_/Y }
C {devices/lab_pin.sym} 124120 -13600 0 1 {name=p123344 lab=_60445_/Y }
C {sky130_stdcells/nor2_4.sym} 124060 -13600 0 0 {name=X_60445_ }
C {devices/lab_pin.sym} 123980 -13490 0 0 {name=p123345 lab=_55741_/B }
C {devices/lab_pin.sym} 123980 -13450 0 0 {name=p123346 lab=_45343_/X }
C {devices/lab_pin.sym} 123980 -13410 0 0 {name=p123347 lab=_45378_/X }
C {devices/lab_pin.sym} 124140 -13450 0 1 {name=p123348 lab=_45379_/X }
C {sky130_stdcells/o21a_4.sym} 124060 -13450 0 0 {name=X_45379_ }
C {devices/lab_pin.sym} 124000 -13320 0 0 {name=p123349 lab=_81349_/Q }
C {devices/lab_pin.sym} 124000 -13280 0 0 {name=p123350 lab=_76199_/B }
C {devices/lab_pin.sym} 124120 -13300 0 1 {name=p123351 lab=_76199_/Y }
C {sky130_stdcells/xnor2_4.sym} 124060 -13300 0 0 {name=X_76199_ }
C {devices/lab_pin.sym} 124020 -13170 0 0 {name=p123352 lab=clkbuf_9_261_0_CLK/X }
C {devices/lab_pin.sym} 124100 -13170 0 1 {name=p123353 lab=_82648_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 124060 -13170 0 0 {name=Xclkbuf_10_523_0_CLK }
C {devices/lab_pin.sym} 124020 -13050 0 0 {name=p123354 lab=clkbuf_5_7_0_CLK/X }
C {devices/lab_pin.sym} 124100 -13050 0 1 {name=p123355 lab=clkbuf_7_28_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 124060 -13050 0 0 {name=Xclkbuf_6_14_0_CLK }
C {devices/lab_pin.sym} 123980 -12950 0 0 {name=p123356 lab=_86668_/Q }
C {devices/lab_pin.sym} 123980 -12910 0 0 {name=p123357 lab=_47096_/X }
C {devices/lab_pin.sym} 123980 -12870 0 0 {name=p123358 lab=_47117_/Y }
C {devices/lab_pin.sym} 124140 -12910 0 1 {name=p123359 lab=_47118_/Y }
C {sky130_stdcells/o21ai_4.sym} 124060 -12910 0 0 {name=X_47118_ }
C {devices/lab_pin.sym} 123980 -12810 0 0 {name=p123360 lab=_58557_/A }
C {devices/lab_pin.sym} 123980 -12770 0 0 {name=p123361 lab=_63131_/X }
C {devices/lab_pin.sym} 123980 -12730 0 0 {name=p123362 lab=_63117_/X }
C {devices/lab_pin.sym} 123980 -12690 0 0 {name=p123363 lab=_58335_/Y }
C {devices/lab_pin.sym} 123980 -12650 0 0 {name=p123364 lab=_63118_/X }
C {devices/lab_pin.sym} 124140 -12730 0 1 {name=p123365 lab=_63164_/Y }
C {sky130_stdcells/o32ai_4.sym} 124060 -12730 0 0 {name=X_63164_ }
C {devices/lab_pin.sym} 124020 -12570 0 0 {name=p123366 lab=_57619_/A }
C {devices/lab_pin.sym} 124100 -12570 0 1 {name=p123367 lab=_50360_/A }
C {sky130_stdcells/buf_2.sym} 124060 -12570 0 0 {name=X_48098_ }
C {devices/lab_pin.sym} 124020 -12450 0 0 {name=p123368 lab=_59875_/A }
C {devices/lab_pin.sym} 124100 -12450 0 1 {name=p123369 lab=_60376_/X }
C {sky130_stdcells/buf_2.sym} 124060 -12450 0 0 {name=X_60376_ }
C {devices/lab_pin.sym} 124000 -12360 0 0 {name=p123370 lab=_62113_/X }
C {devices/lab_pin.sym} 124000 -12320 0 0 {name=p123371 lab=_62175_/B }
C {devices/lab_pin.sym} 124000 -12280 0 0 {name=p123372 lab=_62046_/C }
C {devices/lab_pin.sym} 124000 -12240 0 0 {name=p123373 lab=_62046_/D }
C {devices/lab_pin.sym} 124120 -12300 0 1 {name=p123374 lab=_62115_/Y }
C {sky130_stdcells/nand4_4.sym} 124060 -12300 0 0 {name=X_62115_ }
C {devices/lab_pin.sym} 123980 -12170 0 0 {name=p123375 lab=_47044_/Y }
C {devices/lab_pin.sym} 123980 -12130 0 0 {name=p123376 lab=_47035_/X }
C {devices/lab_pin.sym} 123980 -12090 0 0 {name=p123377 lab=_47048_/X }
C {devices/lab_pin.sym} 124140 -12130 0 1 {name=p123378 lab=_86676_/D }
C {sky130_stdcells/a21oi_4.sym} 124060 -12130 0 0 {name=X_47049_ }
C {devices/lab_pin.sym} 123980 -12030 0 0 {name=p123379 lab=_58535_/Y }
C {devices/lab_pin.sym} 123980 -11990 0 0 {name=p123380 lab=_63073_/X }
C {devices/lab_pin.sym} 123980 -11950 0 0 {name=p123381 lab=_63059_/X }
C {devices/lab_pin.sym} 123980 -11910 0 0 {name=p123382 lab=_58314_/A }
C {devices/lab_pin.sym} 123980 -11870 0 0 {name=p123383 lab=_63060_/X }
C {devices/lab_pin.sym} 124140 -11950 0 1 {name=p123384 lab=_63095_/Y }
C {sky130_stdcells/o32ai_4.sym} 124060 -11950 0 0 {name=X_63095_ }
C {devices/lab_pin.sym} 124000 -11800 0 0 {name=p123385 lab=_67972_/A }
C {devices/lab_pin.sym} 124000 -11760 0 0 {name=p123386 lab=_67972_/B }
C {devices/lab_pin.sym} 124120 -11780 0 1 {name=p123387 lab=_67972_/X }
C {sky130_stdcells/and2_4.sym} 124060 -11780 0 0 {name=X_67972_ }
C {devices/lab_pin.sym} 124000 -11660 0 0 {name=p123388 lab=_79958_/A }
C {devices/lab_pin.sym} 124000 -11620 0 0 {name=p123389 lab=_79957_/Y }
C {devices/lab_pin.sym} 124120 -11640 0 1 {name=p123390 lab=_79961_/A }
C {sky130_stdcells/nand2_4.sym} 124060 -11640 0 0 {name=X_79958_ }
C {devices/lab_pin.sym} 123980 -11540 0 0 {name=p123391 lab=_88072_/Q }
C {devices/lab_pin.sym} 123980 -11500 0 0 {name=p123392 lab=_69607_/X }
C {devices/lab_pin.sym} 123980 -11460 0 0 {name=p123393 lab=_68617_/X }
C {devices/lab_pin.sym} 123980 -11420 0 0 {name=p123394 lab=_69710_/Y }
C {devices/lab_pin.sym} 124140 -11480 0 1 {name=p123395 lab=_69711_/X }
C {sky130_stdcells/a211o_4.sym} 124060 -11480 0 0 {name=X_69711_ }
C {devices/lab_pin.sym} 123980 -11350 0 0 {name=p123396 lab=_50057_/Y }
C {devices/lab_pin.sym} 123980 -11310 0 0 {name=p123397 lab=_48865_/X }
C {devices/lab_pin.sym} 123980 -11270 0 0 {name=p123398 lab=_50059_/X }
C {devices/lab_pin.sym} 124140 -11310 0 1 {name=p123399 lab=_50060_/Y }
C {sky130_stdcells/a21oi_4.sym} 124060 -11310 0 0 {name=X_50060_ }
