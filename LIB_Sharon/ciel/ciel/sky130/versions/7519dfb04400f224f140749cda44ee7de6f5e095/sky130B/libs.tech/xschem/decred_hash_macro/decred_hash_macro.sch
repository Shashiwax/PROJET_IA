C {devices/lab_pin.sym} 71680 -25500 0 1 {name=p70997 lab=_64818_/X }
C {sky130_stdcells/and2_4.sym} 71620 -25500 0 0 {name=X_64818_ }
C {devices/lab_pin.sym} 71530 -25370 0 0 {name=p70998 lab=_86139_/CLK }
C {devices/lab_pin.sym} 71530 -25350 0 0 {name=p70999 lab=_83652_/D }
C {devices/lab_pin.sym} 71710 -25370 0 1 {name=p71000 lab=_46313_/A }
C {sky130_stdcells/dfxtp_4.sym} 71620 -25360 0 0 {name=X_83652_ }
C {devices/lab_pin.sym} 71580 -25230 0 0 {name=p71001 lab=_68586_/A }
C {devices/lab_pin.sym} 71660 -25230 0 1 {name=p71002 lab=_68586_/X }
C {sky130_stdcells/buf_2.sym} 71620 -25230 0 0 {name=X_68586_ }
C {devices/lab_pin.sym} 71530 -25110 0 0 {name=p71003 lab=_81994_/CLK }
C {devices/lab_pin.sym} 71530 -25090 0 0 {name=p71004 lab=_80896_/Q }
C {devices/lab_pin.sym} 71710 -25110 0 1 {name=p71005 lab=_75061_/B }
C {sky130_stdcells/dfxtp_4.sym} 71620 -25100 0 0 {name=X_80864_ }
C {devices/lab_pin.sym} 71540 -25000 0 0 {name=p71006 lab=_65660_/X }
C {devices/lab_pin.sym} 71540 -24960 0 0 {name=p71007 lab=_83057_/Q }
C {devices/lab_pin.sym} 71540 -24920 0 0 {name=p71008 lab=_65768_/X }
C {devices/lab_pin.sym} 71540 -24880 0 0 {name=p71009 lab=_65797_/X }
C {devices/lab_pin.sym} 71700 -24940 0 1 {name=p71010 lab=_65798_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -24940 0 0 {name=X_65798_ }
C {devices/lab_pin.sym} 71530 -24790 0 0 {name=p71011 lab=_82570_/CLK }
C {devices/lab_pin.sym} 71530 -24770 0 0 {name=p71012 lab=_78889_/B }
C {devices/lab_pin.sym} 71710 -24790 0 1 {name=p71013 lab=_82571_/D }
C {sky130_stdcells/dfxtp_4.sym} 71620 -24780 0 0 {name=X_82603_ }
C {devices/lab_pin.sym} 71540 -24680 0 0 {name=p71014 lab=_87403_/Q }
C {devices/lab_pin.sym} 71540 -24640 0 0 {name=p71015 lab=_67512_/X }
C {devices/lab_pin.sym} 71540 -24600 0 0 {name=p71016 lab=_67462_/X }
C {devices/lab_pin.sym} 71540 -24560 0 0 {name=p71017 lab=_67536_/X }
C {devices/lab_pin.sym} 71700 -24620 0 1 {name=p71018 lab=_67537_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -24620 0 0 {name=X_67537_ }
C {devices/lab_pin.sym} 71560 -24500 0 0 {name=p71019 lab=_56616_/A }
C {devices/lab_pin.sym} 71560 -24460 0 0 {name=p71020 lab=_55546_/X }
C {devices/lab_pin.sym} 71560 -24420 0 0 {name=p71021 lab=_56616_/B }
C {devices/lab_pin.sym} 71560 -24380 0 0 {name=p71022 lab=_55550_/X }
C {devices/lab_pin.sym} 71680 -24440 0 1 {name=p71023 lab=_55552_/A }
C {sky130_stdcells/and4_4.sym} 71620 -24440 0 0 {name=X_55551_ }
C {devices/lab_pin.sym} 71530 -24290 0 0 {name=p71024 lab=_83660_/CLK }
C {devices/lab_pin.sym} 71530 -24270 0 0 {name=p71025 lab=_49529_/Y }
C {devices/lab_pin.sym} 71710 -24290 0 1 {name=p71026 lab=_86371_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -24280 0 0 {name=X_86371_ }
C {devices/lab_pin.sym} 71560 -24180 0 0 {name=p71027 lab=_52775_/A }
C {devices/lab_pin.sym} 71560 -24140 0 0 {name=p71028 lab=_52746_/B }
C {devices/lab_pin.sym} 71560 -24100 0 0 {name=p71029 lab=_52775_/C }
C {devices/lab_pin.sym} 71560 -24060 0 0 {name=p71030 lab=_52763_/D }
C {devices/lab_pin.sym} 71680 -24120 0 1 {name=p71031 lab=_52763_/X }
C {sky130_stdcells/and4_4.sym} 71620 -24120 0 0 {name=X_52763_ }
C {devices/lab_pin.sym} 71560 -23980 0 0 {name=p71032 lab=_64810_/A }
C {devices/lab_pin.sym} 71560 -23940 0 0 {name=p71033 lab=_64749_/B }
C {devices/lab_pin.sym} 71680 -23960 0 1 {name=p71034 lab=_64749_/X }
C {sky130_stdcells/and2_4.sym} 71620 -23960 0 0 {name=X_64749_ }
C {devices/lab_pin.sym} 71530 -23830 0 0 {name=p71035 lab=_83068_/CLK }
C {devices/lab_pin.sym} 71530 -23810 0 0 {name=p71036 lab=_71174_/Y }
C {devices/lab_pin.sym} 71710 -23830 0 1 {name=p71037 lab=_83583_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -23820 0 0 {name=X_83583_ }
C {devices/lab_pin.sym} 71530 -23690 0 0 {name=p71038 lab=_80818_/CLK }
C {devices/lab_pin.sym} 71530 -23670 0 0 {name=p71039 lab=_80795_/D }
C {devices/lab_pin.sym} 71710 -23690 0 1 {name=p71040 lab=_80795_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -23680 0 0 {name=X_80795_ }
C {devices/lab_pin.sym} 71530 -23550 0 0 {name=p71041 lab=_88111_/CLK }
C {devices/lab_pin.sym} 71530 -23530 0 0 {name=p71042 lab=_88110_/D }
C {devices/lab_pin.sym} 71710 -23550 0 1 {name=p71043 lab=_73675_/A }
C {sky130_stdcells/dfxtp_4.sym} 71620 -23540 0 0 {name=X_88110_ }
C {devices/lab_pin.sym} 71580 -23410 0 0 {name=p71044 lab=_54475_/A }
C {devices/lab_pin.sym} 71660 -23410 0 1 {name=p71045 lab=_54502_/X }
C {sky130_stdcells/buf_2.sym} 71620 -23410 0 0 {name=X_54502_ }
C {devices/lab_pin.sym} 71530 -23290 0 0 {name=p71046 lab=_85351_/CLK }
C {devices/lab_pin.sym} 71530 -23270 0 0 {name=p71047 lab=_85322_/D }
C {devices/lab_pin.sym} 71710 -23290 0 1 {name=p71048 lab=_85322_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -23280 0 0 {name=X_85322_ }
C {devices/lab_pin.sym} 71580 -23150 0 0 {name=p71049 lab=_51608_/A }
C {devices/lab_pin.sym} 71660 -23150 0 1 {name=p71050 lab=_51715_/C }
C {sky130_stdcells/buf_2.sym} 71620 -23150 0 0 {name=X_51714_ }
C {devices/lab_pin.sym} 71580 -23030 0 0 {name=p71051 lab=_46155_/A }
C {devices/lab_pin.sym} 71660 -23030 0 1 {name=p71052 lab=_58328_/A }
C {sky130_stdcells/buf_2.sym} 71620 -23030 0 0 {name=X_58270_ }
C {devices/lab_pin.sym} 71530 -22910 0 0 {name=p71053 lab=_82536_/CLK }
C {devices/lab_pin.sym} 71530 -22890 0 0 {name=p71054 lab=_83854_/Q }
C {devices/lab_pin.sym} 71710 -22910 0 1 {name=p71055 lab=_82534_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -22900 0 0 {name=X_82534_ }
C {devices/lab_pin.sym} 71540 -22800 0 0 {name=p71056 lab=_85106_/Q }
C {devices/lab_pin.sym} 71540 -22760 0 0 {name=p71057 lab=_55468_/X }
C {devices/lab_pin.sym} 71540 -22720 0 0 {name=p71058 lab=_55469_/X }
C {devices/lab_pin.sym} 71540 -22680 0 0 {name=p71059 lab=_55481_/Y }
C {devices/lab_pin.sym} 71700 -22740 0 1 {name=p71060 lab=_55482_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -22740 0 0 {name=X_55482_ }
C {devices/lab_pin.sym} 71560 -22600 0 0 {name=p71061 lab=_67517_/A }
C {devices/lab_pin.sym} 71560 -22560 0 0 {name=p71062 lab=_67468_/B }
C {devices/lab_pin.sym} 71680 -22580 0 1 {name=p71063 lab=_67468_/X }
C {sky130_stdcells/and2_4.sym} 71620 -22580 0 0 {name=X_67468_ }
C {devices/lab_pin.sym} 71560 -22480 0 0 {name=p71064 lab=_52674_/X }
C {devices/lab_pin.sym} 71560 -22440 0 0 {name=p71065 lab=_52694_/B }
C {devices/lab_pin.sym} 71560 -22400 0 0 {name=p71066 lab=_52694_/C }
C {devices/lab_pin.sym} 71560 -22360 0 0 {name=p71067 lab=_52694_/D }
C {devices/lab_pin.sym} 71680 -22420 0 1 {name=p71068 lab=_52694_/X }
C {sky130_stdcells/and4_4.sym} 71620 -22420 0 0 {name=X_52694_ }
C {devices/lab_pin.sym} 71560 -22280 0 0 {name=p71069 lab=_57221_/A }
C {devices/lab_pin.sym} 71560 -22240 0 0 {name=p71070 lab=_85060_/Q }
C {devices/lab_pin.sym} 71680 -22260 0 1 {name=p71071 lab=_57221_/X }
C {sky130_stdcells/and2_4.sym} 71620 -22260 0 0 {name=X_57221_ }
C {devices/lab_pin.sym} 71540 -22160 0 0 {name=p71072 lab=_87534_/Q }
C {devices/lab_pin.sym} 71540 -22120 0 0 {name=p71073 lab=_69205_/X }
C {devices/lab_pin.sym} 71540 -22080 0 0 {name=p71074 lab=_69113_/X }
C {devices/lab_pin.sym} 71540 -22040 0 0 {name=p71075 lab=_69206_/X }
C {devices/lab_pin.sym} 71700 -22100 0 1 {name=p71076 lab=_69207_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -22100 0 0 {name=X_69207_ }
C {devices/lab_pin.sym} 71530 -21950 0 0 {name=p71077 lab=_87789_/CLK }
C {devices/lab_pin.sym} 71530 -21930 0 0 {name=p71078 lab=_42087_/X }
C {devices/lab_pin.sym} 71710 -21950 0 1 {name=p71079 lab=_88041_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -21940 0 0 {name=X_88041_ }
C {devices/lab_pin.sym} 71560 -21820 0 0 {name=p71080 lab=_54446_/A }
C {devices/lab_pin.sym} 71560 -21780 0 0 {name=p71081 lab=_52739_/B }
C {devices/lab_pin.sym} 71680 -21800 0 1 {name=p71082 lab=_54433_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -21800 0 0 {name=X_54433_ }
C {devices/lab_pin.sym} 71580 -21670 0 0 {name=p71083 lab=_66003_/A }
C {devices/lab_pin.sym} 71660 -21670 0 1 {name=p71084 lab=_66419_/X }
C {sky130_stdcells/buf_2.sym} 71620 -21670 0 0 {name=X_66419_ }
C {devices/lab_pin.sym} 71530 -21550 0 0 {name=p71085 lab=_85221_/CLK }
C {devices/lab_pin.sym} 71530 -21530 0 0 {name=p71086 lab=_85253_/D }
C {devices/lab_pin.sym} 71710 -21550 0 1 {name=p71087 lab=_85253_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -21540 0 0 {name=X_85253_ }
C {devices/lab_pin.sym} 71560 -21440 0 0 {name=p71088 lab=_51629_/X }
C {devices/lab_pin.sym} 71560 -21400 0 0 {name=p71089 lab=_51651_/B }
C {devices/lab_pin.sym} 71560 -21360 0 0 {name=p71090 lab=_51651_/C }
C {devices/lab_pin.sym} 71560 -21320 0 0 {name=p71091 lab=_53170_/D }
C {devices/lab_pin.sym} 71680 -21380 0 1 {name=p71092 lab=_51645_/X }
C {sky130_stdcells/and4_4.sym} 71620 -21380 0 0 {name=X_51645_ }
C {devices/lab_pin.sym} 71530 -21230 0 0 {name=p71093 lab=_82443_/CLK }
C {devices/lab_pin.sym} 71530 -21210 0 0 {name=p71094 lab=_82465_/D }
C {devices/lab_pin.sym} 71710 -21230 0 1 {name=p71095 lab=_82465_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -21220 0 0 {name=X_82465_ }
C {devices/lab_pin.sym} 71560 -21100 0 0 {name=p71096 lab=_67324_/A }
C {devices/lab_pin.sym} 71560 -21060 0 0 {name=p71097 lab=_67399_/B }
C {devices/lab_pin.sym} 71680 -21080 0 1 {name=p71098 lab=_67399_/X }
C {sky130_stdcells/and2_4.sym} 71620 -21080 0 0 {name=X_67399_ }
C {devices/lab_pin.sym} 71530 -20950 0 0 {name=p71099 lab=_84194_/CLK }
C {devices/lab_pin.sym} 71530 -20930 0 0 {name=p71100 lab=_84204_/D }
C {devices/lab_pin.sym} 71710 -20950 0 1 {name=p71101 lab=_84204_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -20940 0 0 {name=X_84204_ }
C {devices/lab_pin.sym} 71530 -20810 0 0 {name=p71102 lab=_81703_/CLK }
C {devices/lab_pin.sym} 71530 -20790 0 0 {name=p71103 lab=_81448_/Q }
C {devices/lab_pin.sym} 71710 -20810 0 1 {name=p71104 lab=_75968_/B }
C {sky130_stdcells/dfxtp_4.sym} 71620 -20800 0 0 {name=X_81416_ }
C {devices/lab_pin.sym} 71540 -20690 0 0 {name=p71105 lab=_45909_/A }
C {devices/lab_pin.sym} 71540 -20650 0 0 {name=p71106 lab=_45672_/Y }
C {devices/lab_pin.sym} 71540 -20610 0 0 {name=p71107 lab=_57151_/Y }
C {devices/lab_pin.sym} 71700 -20650 0 1 {name=p71108 lab=_57152_/X }
C {sky130_stdcells/o21a_4.sym} 71620 -20650 0 0 {name=X_57152_ }
C {devices/lab_pin.sym} 71580 -20510 0 0 {name=p71109 lab=_69035_/A }
C {devices/lab_pin.sym} 71660 -20510 0 1 {name=p71110 lab=_69138_/X }
C {sky130_stdcells/buf_2.sym} 71620 -20510 0 0 {name=X_69138_ }
C {devices/lab_pin.sym} 71560 -20400 0 0 {name=p71111 lab=_54355_/A }
C {devices/lab_pin.sym} 71560 -20360 0 0 {name=p71112 lab=_54364_/B }
C {devices/lab_pin.sym} 71680 -20380 0 1 {name=p71113 lab=_54364_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -20380 0 0 {name=X_54364_ }
C {devices/lab_pin.sym} 71530 -20250 0 0 {name=p71114 lab=_85184_/CLK }
C {devices/lab_pin.sym} 71530 -20230 0 0 {name=p71115 lab=_56470_/Y }
C {devices/lab_pin.sym} 71710 -20250 0 1 {name=p71116 lab=_56469_/C }
C {sky130_stdcells/dfxtp_4.sym} 71620 -20240 0 0 {name=X_85184_ }
C {devices/lab_pin.sym} 71540 -20130 0 0 {name=p71117 lab=_51573_/Y }
C {devices/lab_pin.sym} 71540 -20090 0 0 {name=p71118 lab=_51557_/X }
C {devices/lab_pin.sym} 71540 -20050 0 0 {name=p71119 lab=_51575_/X }
C {devices/lab_pin.sym} 71700 -20090 0 1 {name=p71120 lab=_51576_/Y }
C {sky130_stdcells/a21oi_4.sym} 71620 -20090 0 0 {name=X_51576_ }
C {devices/lab_pin.sym} 71530 -19950 0 0 {name=p71121 lab=_82965_/CLK }
C {devices/lab_pin.sym} 71530 -19930 0 0 {name=p71122 lab=_82204_/Q }
C {devices/lab_pin.sym} 71710 -19950 0 1 {name=p71123 lab=_82396_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -19940 0 0 {name=X_82396_ }
C {devices/lab_pin.sym} 71580 -19810 0 0 {name=p71124 lab=_56102_/X }
C {devices/lab_pin.sym} 71660 -19810 0 1 {name=p71125 lab=_56103_/X }
C {sky130_stdcells/buf_2.sym} 71620 -19810 0 0 {name=X_56103_ }
C {devices/lab_pin.sym} 71540 -19710 0 0 {name=p71126 lab=_85656_/Q }
C {devices/lab_pin.sym} 71540 -19670 0 0 {name=p71127 lab=_53295_/X }
C {devices/lab_pin.sym} 71540 -19630 0 0 {name=p71128 lab=_53314_/Y }
C {devices/lab_pin.sym} 71700 -19670 0 1 {name=p71129 lab=_53315_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -19670 0 0 {name=X_53315_ }
C {devices/lab_pin.sym} 71530 -19530 0 0 {name=p71130 lab=_82177_/CLK }
C {devices/lab_pin.sym} 71530 -19510 0 0 {name=p71131 lab=_84135_/D }
C {devices/lab_pin.sym} 71710 -19530 0 1 {name=p71132 lab=_84135_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -19520 0 0 {name=X_84135_ }
C {devices/lab_pin.sym} 71540 -19410 0 0 {name=p71133 lab=_50522_/Y }
C {devices/lab_pin.sym} 71540 -19370 0 0 {name=p71134 lab=_50525_/X }
C {devices/lab_pin.sym} 71540 -19330 0 0 {name=p71135 lab=_50526_/X }
C {devices/lab_pin.sym} 71700 -19370 0 1 {name=p71136 lab=_50527_/Y }
C {sky130_stdcells/a21oi_4.sym} 71620 -19370 0 0 {name=X_50527_ }
C {devices/lab_pin.sym} 71560 -19240 0 0 {name=p71137 lab=_56927_/A }
C {devices/lab_pin.sym} 71560 -19200 0 0 {name=p71138 lab=_56927_/C }
C {devices/lab_pin.sym} 71680 -19220 0 1 {name=p71139 lab=_57083_/X }
C {sky130_stdcells/and2_4.sym} 71620 -19220 0 0 {name=X_57083_ }
C {devices/lab_pin.sym} 71530 -19090 0 0 {name=p71140 lab=_84079_/CLK }
C {devices/lab_pin.sym} 71530 -19070 0 0 {name=p71141 lab=_76966_/Y }
C {devices/lab_pin.sym} 71710 -19090 0 1 {name=p71142 lab=_81347_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -19080 0 0 {name=X_81347_ }
C {devices/lab_pin.sym} 71560 -18960 0 0 {name=p71143 lab=_69958_/A }
C {devices/lab_pin.sym} 71560 -18920 0 0 {name=p71144 lab=_42534_/Y }
C {devices/lab_pin.sym} 71680 -18940 0 1 {name=p71145 lab=_69069_/Y }
C {sky130_stdcells/nor2_4.sym} 71620 -18940 0 0 {name=X_69069_ }
C {devices/lab_pin.sym} 71580 -18810 0 0 {name=p71146 lab=_54295_/A }
C {devices/lab_pin.sym} 71660 -18810 0 1 {name=p71147 lab=_54314_/A }
C {sky130_stdcells/buf_2.sym} 71620 -18810 0 0 {name=X_54295_ }
C {devices/lab_pin.sym} 71540 -18710 0 0 {name=p71148 lab=_50649_/B }
C {devices/lab_pin.sym} 71540 -18670 0 0 {name=p71149 lab=_71095_/X }
C {devices/lab_pin.sym} 71540 -18630 0 0 {name=p71150 lab=_71099_/Y }
C {devices/lab_pin.sym} 71700 -18670 0 1 {name=p71151 lab=_83608_/D }
C {sky130_stdcells/o21ai_4.sym} 71620 -18670 0 0 {name=X_71100_ }
C {devices/lab_pin.sym} 71560 -18540 0 0 {name=p71152 lab=_55956_/B }
C {devices/lab_pin.sym} 71560 -18500 0 0 {name=p71153 lab=_55956_/A }
C {devices/lab_pin.sym} 71680 -18520 0 1 {name=p71154 lab=_56035_/A }
C {sky130_stdcells/xnor2_4.sym} 71620 -18520 0 0 {name=X_56034_ }
C {devices/lab_pin.sym} 71540 -18420 0 0 {name=p71155 lab=_41259_/X }
C {devices/lab_pin.sym} 71540 -18380 0 0 {name=p71156 lab=_41251_/X }
C {devices/lab_pin.sym} 71540 -18340 0 0 {name=p71157 lab=_88249_/Q }
C {devices/lab_pin.sym} 71540 -18300 0 0 {name=p71158 lab=_41253_/X }
C {devices/lab_pin.sym} 71700 -18360 0 1 {name=p71159 lab=_88249_/D }
C {sky130_stdcells/a2bb2o_4.sym} 71620 -18360 0 0 {name=X_41260_ }
C {devices/lab_pin.sym} 71540 -18230 0 0 {name=p71160 lab=_72078_/Y }
C {devices/lab_pin.sym} 71540 -18190 0 0 {name=p71161 lab=_72033_/X }
C {devices/lab_pin.sym} 71540 -18150 0 0 {name=p71162 lab=_72079_/Y }
C {devices/lab_pin.sym} 71700 -18190 0 1 {name=p71163 lab=_83289_/D }
C {sky130_stdcells/a21boi_4.sym} 71620 -18190 0 0 {name=X_72080_ }
C {devices/lab_pin.sym} 71560 -18060 0 0 {name=p71164 lab=_53246_/A }
C {devices/lab_pin.sym} 71560 -18020 0 0 {name=p71165 lab=_53246_/B }
C {devices/lab_pin.sym} 71680 -18040 0 1 {name=p71166 lab=_53246_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -18040 0 0 {name=X_53246_ }
C {devices/lab_pin.sym} 71530 -17910 0 0 {name=p71167 lab=_81749_/CLK }
C {devices/lab_pin.sym} 71530 -17890 0 0 {name=p71168 lab=_84066_/D }
C {devices/lab_pin.sym} 71710 -17910 0 1 {name=p71169 lab=_81498_/D }
C {sky130_stdcells/dfxtp_4.sym} 71620 -17900 0 0 {name=X_84066_ }
C {devices/lab_pin.sym} 71560 -17780 0 0 {name=p71170 lab=_50439_/X }
C {devices/lab_pin.sym} 71560 -17740 0 0 {name=p71171 lab=_52163_/B }
C {devices/lab_pin.sym} 71680 -17760 0 1 {name=p71172 lab=_50458_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -17760 0 0 {name=X_50458_ }
C {devices/lab_pin.sym} 71530 -17630 0 0 {name=p71173 lab=_81269_/CLK }
C {devices/lab_pin.sym} 71530 -17610 0 0 {name=p71174 lab=_81310_/Q }
C {devices/lab_pin.sym} 71710 -17630 0 1 {name=p71175 lab=_81278_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -17620 0 0 {name=X_81278_ }
C {devices/lab_pin.sym} 71540 -17510 0 0 {name=p71176 lab=_53157_/B }
C {devices/lab_pin.sym} 71540 -17470 0 0 {name=p71177 lab=_71013_/X }
C {devices/lab_pin.sym} 71540 -17430 0 0 {name=p71178 lab=_71030_/Y }
C {devices/lab_pin.sym} 71700 -17470 0 1 {name=p71179 lab=_71031_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -17470 0 0 {name=X_71031_ }
C {devices/lab_pin.sym} 71530 -17330 0 0 {name=p71180 lab=_86887_/CLK }
C {devices/lab_pin.sym} 71530 -17310 0 0 {name=p71181 lab=_74609_/Y }
C {devices/lab_pin.sym} 71710 -17330 0 1 {name=p71182 lab=_83017_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -17320 0 0 {name=X_83017_ }
C {devices/lab_pin.sym} 71560 -17200 0 0 {name=p71183 lab=_84950_/Q }
C {devices/lab_pin.sym} 71560 -17160 0 0 {name=p71184 lab=_65481_/C }
C {devices/lab_pin.sym} 71680 -17180 0 1 {name=p71185 lab=_80229_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -17180 0 0 {name=X_80229_ }
C {devices/lab_pin.sym} 71560 -17060 0 0 {name=p71186 lab=_41007_/A }
C {devices/lab_pin.sym} 71560 -17020 0 0 {name=p71187 lab=_40671_/A }
C {devices/lab_pin.sym} 71680 -17040 0 1 {name=p71188 lab=_41191_/X }
C {sky130_stdcells/or2_4.sym} 71620 -17040 0 0 {name=X_41191_ }
C {devices/lab_pin.sym} 71560 -16940 0 0 {name=p71189 lab=_53181_/A }
C {devices/lab_pin.sym} 71560 -16900 0 0 {name=p71190 lab=_53181_/B }
C {devices/lab_pin.sym} 71560 -16860 0 0 {name=p71191 lab=_53169_/X }
C {devices/lab_pin.sym} 71560 -16820 0 0 {name=p71192 lab=_53177_/D }
C {devices/lab_pin.sym} 71680 -16880 0 1 {name=p71193 lab=_53177_/X }
C {sky130_stdcells/and4_4.sym} 71620 -16880 0 0 {name=X_53177_ }
C {devices/lab_pin.sym} 71560 -16740 0 0 {name=p71194 lab=_50481_/A }
C {devices/lab_pin.sym} 71560 -16700 0 0 {name=p71195 lab=_50389_/B }
C {devices/lab_pin.sym} 71680 -16720 0 1 {name=p71196 lab=_50389_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -16720 0 0 {name=X_50389_ }
C {devices/lab_pin.sym} 71560 -16600 0 0 {name=p71197 lab=_52127_/X }
C {devices/lab_pin.sym} 71560 -16560 0 0 {name=p71198 lab=_52128_/B }
C {devices/lab_pin.sym} 71680 -16580 0 1 {name=p71199 lab=_52128_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -16580 0 0 {name=X_52128_ }
C {devices/lab_pin.sym} 71530 -16450 0 0 {name=p71200 lab=_88081_/CLK }
C {devices/lab_pin.sym} 71530 -16430 0 0 {name=p71201 lab=_42549_/Y }
C {devices/lab_pin.sym} 71710 -16450 0 1 {name=p71202 lab=_42548_/A }
C {sky130_stdcells/dfxtp_4.sym} 71620 -16440 0 0 {name=X_87825_ }
C {devices/lab_pin.sym} 71540 -16330 0 0 {name=p71203 lab=_57983_/X }
C {devices/lab_pin.sym} 71540 -16290 0 0 {name=p71204 lab=_85390_/Q }
C {devices/lab_pin.sym} 71540 -16250 0 0 {name=p71205 lab=_57984_/X }
C {devices/lab_pin.sym} 71700 -16290 0 1 {name=p71206 lab=_57985_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -16290 0 0 {name=X_57985_ }
C {devices/lab_pin.sym} 71580 -16150 0 0 {name=p71207 lab=_59724_/A }
C {devices/lab_pin.sym} 71660 -16150 0 1 {name=p71208 lab=_59724_/Y }
C {sky130_stdcells/inv_2.sym} 71620 -16150 0 0 {name=X_59724_ }
C {devices/lab_pin.sym} 71540 -16050 0 0 {name=p71209 lab=_74547_/C }
C {devices/lab_pin.sym} 71540 -16010 0 0 {name=p71210 lab=_44933_/X }
C {devices/lab_pin.sym} 71540 -15970 0 0 {name=p71211 lab=_44949_/X }
C {devices/lab_pin.sym} 71700 -16010 0 1 {name=p71212 lab=_44950_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -16010 0 0 {name=X_44950_ }
C {devices/lab_pin.sym} 71580 -15870 0 0 {name=p71213 lab=_72720_/A }
C {devices/lab_pin.sym} 71660 -15870 0 1 {name=p71214 lab=_72978_/A }
C {sky130_stdcells/buf_2.sym} 71620 -15870 0 0 {name=X_56936_ }
C {devices/lab_pin.sym} 71540 -15770 0 0 {name=p71215 lab=_52057_/Y }
C {devices/lab_pin.sym} 71540 -15730 0 0 {name=p71216 lab=_52022_/X }
C {devices/lab_pin.sym} 71540 -15690 0 0 {name=p71217 lab=_52058_/Y }
C {devices/lab_pin.sym} 71700 -15730 0 1 {name=p71218 lab=_52059_/Y }
C {sky130_stdcells/a21boi_4.sym} 71620 -15730 0 0 {name=X_52059_ }
C {devices/lab_pin.sym} 71560 -15600 0 0 {name=p71219 lab=_75768_/Y }
C {devices/lab_pin.sym} 71560 -15560 0 0 {name=p71220 lab=_75769_/Y }
C {devices/lab_pin.sym} 71680 -15580 0 1 {name=p71221 lab=_75771_/A }
C {sky130_stdcells/xor2_4.sym} 71620 -15580 0 0 {name=X_75770_ }
C {devices/lab_pin.sym} 71530 -15450 0 0 {name=p71222 lab=_88012_/CLK }
C {devices/lab_pin.sym} 71530 -15430 0 0 {name=p71223 lab=_42713_/X }
C {devices/lab_pin.sym} 71710 -15450 0 1 {name=p71224 lab=_68543_/B }
C {sky130_stdcells/dfxtp_4.sym} 71620 -15440 0 0 {name=X_87756_ }
C {devices/lab_pin.sym} 71580 -15310 0 0 {name=p71225 lab=_56547_/X }
C {devices/lab_pin.sym} 71660 -15310 0 1 {name=p71226 lab=_72982_/X }
C {sky130_stdcells/buf_2.sym} 71620 -15310 0 0 {name=X_72982_ }
C {devices/lab_pin.sym} 71530 -15190 0 0 {name=p71227 lab=_86530_/CLK }
C {devices/lab_pin.sym} 71530 -15170 0 0 {name=p71228 lab=_57620_/Y }
C {devices/lab_pin.sym} 71710 -15190 0 1 {name=p71229 lab=_84968_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -15180 0 0 {name=X_84968_ }
C {devices/lab_pin.sym} 71580 -15050 0 0 {name=p71230 lab=_43901_/A }
C {devices/lab_pin.sym} 71660 -15050 0 1 {name=p71231 lab=_43901_/Y }
C {sky130_stdcells/inv_2.sym} 71620 -15050 0 0 {name=X_43901_ }
C {devices/lab_pin.sym} 71580 -14930 0 0 {name=p71232 lab=_71266_/X }
C {devices/lab_pin.sym} 71660 -14930 0 1 {name=p71233 lab=_74775_/A }
C {sky130_stdcells/buf_2.sym} 71620 -14930 0 0 {name=X_74721_ }
C {devices/lab_pin.sym} 71530 -14810 0 0 {name=p71234 lab=_86384_/CLK }
C {devices/lab_pin.sym} 71530 -14790 0 0 {name=p71235 lab=_86707_/D }
C {devices/lab_pin.sym} 71710 -14810 0 1 {name=p71236 lab=_58751_/A }
C {sky130_stdcells/dfxtp_4.sym} 71620 -14800 0 0 {name=X_86707_ }
C {devices/lab_pin.sym} 71560 -14700 0 0 {name=p71237 lab=_74531_/A }
C {devices/lab_pin.sym} 71560 -14660 0 0 {name=p71238 lab=_70979_/C }
C {devices/lab_pin.sym} 71560 -14620 0 0 {name=p71239 lab=_71940_/C }
C {devices/lab_pin.sym} 71560 -14580 0 0 {name=p71240 lab=_71945_/D }
C {devices/lab_pin.sym} 71680 -14640 0 1 {name=p71241 lab=_71933_/Y }
C {sky130_stdcells/nand4_4.sym} 71620 -14640 0 0 {name=X_71933_ }
C {devices/lab_pin.sym} 71580 -14490 0 0 {name=p71242 lab=_59654_/X }
C {devices/lab_pin.sym} 71660 -14490 0 1 {name=p71243 lab=_59655_/X }
C {sky130_stdcells/buf_2.sym} 71620 -14490 0 0 {name=X_59655_ }
C {devices/lab_pin.sym} 71530 -14370 0 0 {name=p71244 lab=_83918_/CLK }
C {devices/lab_pin.sym} 71530 -14350 0 0 {name=p71245 lab=_83919_/D }
C {devices/lab_pin.sym} 71710 -14370 0 1 {name=p71246 lab=_81383_/D }
C {sky130_stdcells/dfxtp_4.sym} 71620 -14360 0 0 {name=X_83919_ }
C {devices/lab_pin.sym} 71580 -14230 0 0 {name=p71247 lab=_80670_/Q }
C {devices/lab_pin.sym} 71660 -14230 0 1 {name=p71248 lab=_45281_/A }
C {sky130_stdcells/buf_2.sym} 71620 -14230 0 0 {name=X_44881_ }
C {devices/lab_pin.sym} 71540 -14130 0 0 {name=p71249 lab=_56856_/Y }
C {devices/lab_pin.sym} 71540 -14090 0 0 {name=p71250 lab=_56884_/B }
C {devices/lab_pin.sym} 71540 -14050 0 0 {name=p71251 lab=_56721_/D }
C {devices/lab_pin.sym} 71700 -14090 0 1 {name=p71252 lab=_56867_/X }
C {sky130_stdcells/a21bo_4.sym} 71620 -14090 0 0 {name=X_56867_ }
C {devices/lab_pin.sym} 71530 -13950 0 0 {name=p71253 lab=_88133_/CLK }
C {devices/lab_pin.sym} 71530 -13930 0 0 {name=p71254 lab=_42851_/Y }
C {devices/lab_pin.sym} 71710 -13950 0 1 {name=p71255 lab=_66852_/B }
C {sky130_stdcells/dfxtp_4.sym} 71620 -13940 0 0 {name=X_87687_ }
C {devices/lab_pin.sym} 71530 -13810 0 0 {name=p71256 lab=_84727_/CLK }
C {devices/lab_pin.sym} 71530 -13790 0 0 {name=p71257 lab=_84899_/D }
C {devices/lab_pin.sym} 71710 -13810 0 1 {name=p71258 lab=_64283_/C }
C {sky130_stdcells/dfxtp_4.sym} 71620 -13800 0 0 {name=X_84899_ }
C {devices/lab_pin.sym} 71560 -13700 0 0 {name=p71259 lab=_46620_/A }
C {devices/lab_pin.sym} 71560 -13660 0 0 {name=p71260 lab=_46647_/B }
C {devices/lab_pin.sym} 71560 -13620 0 0 {name=p71261 lab=_46659_/C }
C {devices/lab_pin.sym} 71560 -13580 0 0 {name=p71262 lab=_52580_/D }
C {devices/lab_pin.sym} 71680 -13640 0 1 {name=p71263 lab=_46620_/X }
C {sky130_stdcells/and4_4.sym} 71620 -13640 0 0 {name=X_46620_ }
C {devices/lab_pin.sym} 71540 -13510 0 0 {name=p71264 lab=_58605_/X }
C {devices/lab_pin.sym} 71540 -13470 0 0 {name=p71265 lab=_85950_/Q }
C {devices/lab_pin.sym} 71540 -13430 0 0 {name=p71266 lab=_58568_/X }
C {devices/lab_pin.sym} 71700 -13470 0 1 {name=p71267 lab=_58606_/X }
C {sky130_stdcells/o21a_4.sym} 71620 -13470 0 0 {name=X_58606_ }
C {devices/lab_pin.sym} 71560 -13340 0 0 {name=p71268 lab=_77433_/Y }
C {devices/lab_pin.sym} 71560 -13300 0 0 {name=p71269 lab=_77439_/Y }
C {devices/lab_pin.sym} 71680 -13320 0 1 {name=p71270 lab=_82192_/D }
C {sky130_stdcells/xor2_4.sym} 71620 -13320 0 0 {name=X_77440_ }
C {devices/lab_pin.sym} 71580 -13190 0 0 {name=p71271 lab=_43752_/A }
C {devices/lab_pin.sym} 71660 -13190 0 1 {name=p71272 lab=_43832_/X }
C {sky130_stdcells/buf_2.sym} 71620 -13190 0 0 {name=X_43832_ }
C {devices/lab_pin.sym} 71540 -13100 0 0 {name=p71273 lab=_45196_/A }
C {devices/lab_pin.sym} 71540 -13060 0 0 {name=p71274 lab=_55492_/X }
C {devices/lab_pin.sym} 71540 -13020 0 0 {name=p71275 lab=_55312_/X }
C {devices/lab_pin.sym} 71540 -12980 0 0 {name=p71276 lab=_55817_/X }
C {devices/lab_pin.sym} 71700 -13040 0 1 {name=p71277 lab=_55818_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -13040 0 0 {name=X_55818_ }
C {devices/lab_pin.sym} 71540 -12920 0 0 {name=p71278 lab=_74638_/X }
C {devices/lab_pin.sym} 71540 -12880 0 0 {name=p71279 lab=_56630_/A }
C {devices/lab_pin.sym} 71540 -12840 0 0 {name=p71280 lab=_45575_/A }
C {devices/lab_pin.sym} 71540 -12800 0 0 {name=p71281 lab=_74645_/X }
C {devices/lab_pin.sym} 71700 -12860 0 1 {name=p71282 lab=_82998_/D }
C {sky130_stdcells/a2bb2o_4.sym} 71620 -12860 0 0 {name=X_74652_ }
C {devices/lab_pin.sym} 71530 -12710 0 0 {name=p71283 lab=_86637_/CLK }
C {devices/lab_pin.sym} 71530 -12690 0 0 {name=p71284 lab=_47409_/Y }
C {devices/lab_pin.sym} 71710 -12710 0 1 {name=p71285 lab=_86638_/Q }
C {sky130_stdcells/dfxtp_4.sym} 71620 -12700 0 0 {name=X_86638_ }
C {devices/lab_pin.sym} 71540 -12590 0 0 {name=p71286 lab=_71847_/Y }
C {devices/lab_pin.sym} 71540 -12550 0 0 {name=p71287 lab=_83348_/Q }
C {devices/lab_pin.sym} 71540 -12510 0 0 {name=p71288 lab=_71863_/Y }
C {devices/lab_pin.sym} 71700 -12550 0 1 {name=p71289 lab=_83348_/D }
C {sky130_stdcells/a21o_4.sym} 71620 -12550 0 0 {name=X_71864_ }
C {devices/lab_pin.sym} 71560 -12440 0 0 {name=p71290 lab=_59662_/C }
C {devices/lab_pin.sym} 71560 -12400 0 0 {name=p71291 lab=_59657_/A }
C {devices/lab_pin.sym} 71560 -12360 0 0 {name=p71292 lab=_59615_/A }
C {devices/lab_pin.sym} 71560 -12320 0 0 {name=p71293 lab=_59775_/A }
C {devices/lab_pin.sym} 71680 -12380 0 1 {name=p71294 lab=_59586_/X }
C {sky130_stdcells/and4_4.sym} 71620 -12380 0 0 {name=X_59586_ }
C {devices/lab_pin.sym} 71560 -12240 0 0 {name=p71295 lab=_56798_/A }
C {devices/lab_pin.sym} 71560 -12200 0 0 {name=p71296 lab=_56798_/B }
C {devices/lab_pin.sym} 71680 -12220 0 1 {name=p71297 lab=_56798_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -12220 0 0 {name=X_56798_ }
C {devices/lab_pin.sym} 71540 -12110 0 0 {name=p71298 lab=_88369_/Q }
C {devices/lab_pin.sym} 71540 -12070 0 0 {name=p71299 lab=_73279_/X }
C {devices/lab_pin.sym} 71540 -12030 0 0 {name=p71300 lab=_73602_/X }
C {devices/lab_pin.sym} 71700 -12070 0 1 {name=p71301 lab=_73603_/X }
C {sky130_stdcells/o21a_4.sym} 71620 -12070 0 0 {name=X_73603_ }
C {devices/lab_pin.sym} 71540 -11950 0 0 {name=p71302 lab=_47174_/X }
C {devices/lab_pin.sym} 71540 -11910 0 0 {name=p71303 lab=_70802_/X }
C {devices/lab_pin.sym} 71540 -11870 0 0 {name=p71304 lab=_70814_/Y }
C {devices/lab_pin.sym} 71700 -11910 0 1 {name=p71305 lab=_70815_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -11910 0 0 {name=X_70815_ }
C {devices/lab_pin.sym} 71580 -11770 0 0 {name=p71306 lab=_51372_/B }
C {devices/lab_pin.sym} 71660 -11770 0 1 {name=p71307 lab=_54071_/B }
C {sky130_stdcells/buf_2.sym} 71620 -11770 0 0 {name=X_46551_ }
C {devices/lab_pin.sym} 71540 -11670 0 0 {name=p71308 lab=_58448_/X }
C {devices/lab_pin.sym} 71540 -11630 0 0 {name=p71309 lab=_83361_/Q }
C {devices/lab_pin.sym} 71540 -11590 0 0 {name=p71310 lab=_58536_/Y }
C {devices/lab_pin.sym} 71700 -11630 0 1 {name=p71311 lab=_58537_/X }
C {sky130_stdcells/o21a_4.sym} 71620 -11630 0 0 {name=X_58537_ }
C {devices/lab_pin.sym} 71560 -11510 0 0 {name=p71312 lab=_77371_/A }
C {devices/lab_pin.sym} 71560 -11470 0 0 {name=p71313 lab=_77361_/Y }
C {devices/lab_pin.sym} 71560 -11430 0 0 {name=p71314 lab=_77371_/C }
C {devices/lab_pin.sym} 71680 -11470 0 1 {name=p71315 lab=_77371_/Y }
C {sky130_stdcells/nor3_4.sym} 71620 -11470 0 0 {name=X_77371_ }
C {devices/lab_pin.sym} 71540 -11360 0 0 {name=p71316 lab=_40964_/X }
C {devices/lab_pin.sym} 71540 -11320 0 0 {name=p71317 lab=_43752_/X }
C {devices/lab_pin.sym} 71540 -11280 0 0 {name=p71318 lab=_69206_/B }
C {devices/lab_pin.sym} 71540 -11240 0 0 {name=p71319 lab=_43753_/X }
C {devices/lab_pin.sym} 71700 -11300 0 1 {name=p71320 lab=_87278_/D }
C {sky130_stdcells/a2bb2o_4.sym} 71620 -11300 0 0 {name=X_43763_ }
C {devices/lab_pin.sym} 71540 -11180 0 0 {name=p71321 lab=_85256_/Q }
C {devices/lab_pin.sym} 71540 -11140 0 0 {name=p71322 lab=_55747_/X }
C {devices/lab_pin.sym} 71540 -11100 0 0 {name=p71323 lab=_55165_/X }
C {devices/lab_pin.sym} 71540 -11060 0 0 {name=p71324 lab=_55748_/X }
C {devices/lab_pin.sym} 71700 -11120 0 1 {name=p71325 lab=_55749_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -11120 0 0 {name=X_55749_ }
C {devices/lab_pin.sym} 71580 -10970 0 0 {name=p71326 lab=_74552_/X }
C {devices/lab_pin.sym} 71660 -10970 0 1 {name=p71327 lab=_74583_/X }
C {sky130_stdcells/buf_2.sym} 71620 -10970 0 0 {name=X_74583_ }
C {devices/lab_pin.sym} 71530 -10850 0 0 {name=p71328 lab=_86535_/CLK }
C {devices/lab_pin.sym} 71530 -10830 0 0 {name=p71329 lab=_48089_/Y }
C {devices/lab_pin.sym} 71710 -10850 0 1 {name=p71330 lab=_74129_/B }
C {sky130_stdcells/dfxtp_4.sym} 71620 -10840 0 0 {name=X_86569_ }
C {devices/lab_pin.sym} 71560 -10720 0 0 {name=p71331 lab=_82297_/Q }
C {devices/lab_pin.sym} 71560 -10680 0 0 {name=p71332 lab=_40970_/B }
C {devices/lab_pin.sym} 71680 -10700 0 1 {name=p71333 lab=_40975_/X }
C {sky130_stdcells/or2_4.sym} 71620 -10700 0 0 {name=X_40975_ }
C {devices/lab_pin.sym} 71540 -10590 0 0 {name=p71334 lab=_58200_/Y }
C {devices/lab_pin.sym} 71540 -10550 0 0 {name=p71335 lab=_71784_/X }
C {devices/lab_pin.sym} 71540 -10510 0 0 {name=p71336 lab=_71794_/Y }
C {devices/lab_pin.sym} 71700 -10550 0 1 {name=p71337 lab=_71795_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -10550 0 0 {name=X_71795_ }
C {devices/lab_pin.sym} 71560 -10420 0 0 {name=p71338 lab=_79110_/A }
C {devices/lab_pin.sym} 71560 -10380 0 0 {name=p71339 lab=_79110_/B }
C {devices/lab_pin.sym} 71680 -10400 0 1 {name=p71340 lab=_82625_/D }
C {sky130_stdcells/nand2_4.sym} 71620 -10400 0 0 {name=X_79110_ }
C {devices/lab_pin.sym} 71540 -10300 0 0 {name=p71341 lab=_45500_/Y }
C {devices/lab_pin.sym} 71540 -10260 0 0 {name=p71342 lab=_45439_/X }
C {devices/lab_pin.sym} 71540 -10220 0 0 {name=p71343 lab=_45471_/X }
C {devices/lab_pin.sym} 71540 -10180 0 0 {name=p71344 lab=_45501_/Y }
C {devices/lab_pin.sym} 71700 -10240 0 1 {name=p71345 lab=_45502_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -10240 0 0 {name=X_45502_ }
C {devices/lab_pin.sym} 71540 -10110 0 0 {name=p71346 lab=_76305_/Y }
C {devices/lab_pin.sym} 71540 -10070 0 0 {name=p71347 lab=_76306_/A }
C {devices/lab_pin.sym} 71540 -10030 0 0 {name=p71348 lab=_76299_/Y }
C {devices/lab_pin.sym} 71700 -10070 0 1 {name=p71349 lab=_76322_/Y }
C {sky130_stdcells/a21boi_4.sym} 71620 -10070 0 0 {name=X_76322_ }
C {devices/lab_pin.sym} 71540 -9960 0 0 {name=p71350 lab=_41157_/X }
C {devices/lab_pin.sym} 71540 -9920 0 0 {name=p71351 lab=_42710_/X }
C {devices/lab_pin.sym} 71540 -9880 0 0 {name=p71352 lab=_87755_/Q }
C {devices/lab_pin.sym} 71540 -9840 0 0 {name=p71353 lab=_42711_/X }
C {devices/lab_pin.sym} 71700 -9900 0 1 {name=p71354 lab=_87755_/D }
C {sky130_stdcells/a2bb2o_4.sym} 71620 -9900 0 0 {name=X_42714_ }
C {devices/lab_pin.sym} 71530 -9750 0 0 {name=p71355 lab=_88324_/CLK }
C {devices/lab_pin.sym} 71530 -9730 0 0 {name=p71356 lab=_88308_/D }
C {devices/lab_pin.sym} 71710 -9750 0 1 {name=p71357 lab=_69972_/B }
C {sky130_stdcells/dfxtp_4.sym} 71620 -9740 0 0 {name=X_88308_ }
C {devices/lab_pin.sym} 71540 -9630 0 0 {name=p71358 lab=_86420_/Q }
C {devices/lab_pin.sym} 71540 -9590 0 0 {name=p71359 lab=_49255_/X }
C {devices/lab_pin.sym} 71540 -9550 0 0 {name=p71360 lab=_49269_/Y }
C {devices/lab_pin.sym} 71700 -9590 0 1 {name=p71361 lab=_49270_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -9590 0 0 {name=X_49270_ }
C {devices/lab_pin.sym} 71540 -9470 0 0 {name=p71362 lab=_44600_/Y }
C {devices/lab_pin.sym} 71540 -9430 0 0 {name=p71363 lab=_73420_/X }
C {devices/lab_pin.sym} 71540 -9390 0 0 {name=p71364 lab=_73533_/Y }
C {devices/lab_pin.sym} 71700 -9430 0 1 {name=p71365 lab=_73534_/X }
C {sky130_stdcells/a21o_4.sym} 71620 -9430 0 0 {name=X_73534_ }
C {devices/lab_pin.sym} 71560 -9300 0 0 {name=p71366 lab=_48044_/B }
C {devices/lab_pin.sym} 71560 -9260 0 0 {name=p71367 lab=_47915_/B }
C {devices/lab_pin.sym} 71680 -9280 0 1 {name=p71368 lab=_46482_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -9280 0 0 {name=X_46482_ }
C {devices/lab_pin.sym} 71540 -9170 0 0 {name=p71369 lab=_53109_/B }
C {devices/lab_pin.sym} 71540 -9130 0 0 {name=p71370 lab=_70738_/X }
C {devices/lab_pin.sym} 71540 -9090 0 0 {name=p71371 lab=_70745_/Y }
C {devices/lab_pin.sym} 71700 -9130 0 1 {name=p71372 lab=_83711_/D }
C {sky130_stdcells/o21ai_4.sym} 71620 -9130 0 0 {name=X_70746_ }
C {devices/lab_pin.sym} 71580 -8990 0 0 {name=p71373 lab=_83417_/Q }
C {devices/lab_pin.sym} 71660 -8990 0 1 {name=p71374 lab=_58468_/Y }
C {sky130_stdcells/inv_2.sym} 71620 -8990 0 0 {name=X_58468_ }
C {devices/lab_pin.sym} 71580 -8870 0 0 {name=p71375 lab=_43693_/X }
C {devices/lab_pin.sym} 71660 -8870 0 1 {name=p71376 lab=_87305_/D }
C {sky130_stdcells/inv_2.sym} 71620 -8870 0 0 {name=X_43694_ }
C {devices/lab_pin.sym} 71580 -8750 0 0 {name=p71377 lab=_48221_/A }
C {devices/lab_pin.sym} 71660 -8750 0 1 {name=p71378 lab=_50275_/B }
C {sky130_stdcells/buf_2.sym} 71620 -8750 0 0 {name=X_48221_ }
C {devices/lab_pin.sym} 71560 -8640 0 0 {name=p71379 lab=_79048_/B }
C {devices/lab_pin.sym} 71560 -8600 0 0 {name=p71380 lab=_82524_/D }
C {devices/lab_pin.sym} 71680 -8620 0 1 {name=p71381 lab=_79042_/A }
C {sky130_stdcells/xor2_4.sym} 71620 -8620 0 0 {name=X_79041_ }
C {devices/lab_pin.sym} 71560 -8500 0 0 {name=p71382 lab=_57419_/A }
C {devices/lab_pin.sym} 71560 -8460 0 0 {name=p71383 lab=_57413_/X }
C {devices/lab_pin.sym} 71680 -8480 0 1 {name=p71384 lab=_57419_/X }
C {sky130_stdcells/or2_4.sym} 71620 -8480 0 0 {name=X_57419_ }
C {devices/lab_pin.sym} 71580 -8350 0 0 {name=p71385 lab=_44904_/A }
C {devices/lab_pin.sym} 71660 -8350 0 1 {name=p71386 lab=_45668_/A }
C {sky130_stdcells/buf_2.sym} 71620 -8350 0 0 {name=X_45433_ }
C {devices/lab_pin.sym} 71540 -8250 0 0 {name=p71387 lab=_76254_/A }
C {devices/lab_pin.sym} 71540 -8210 0 0 {name=p71388 lab=_76254_/B }
C {devices/lab_pin.sym} 71540 -8170 0 0 {name=p71389 lab=_76252_/Y }
C {devices/lab_pin.sym} 71700 -8210 0 1 {name=p71390 lab=_76253_/Y }
C {sky130_stdcells/a21oi_4.sym} 71620 -8210 0 0 {name=X_76253_ }
C {devices/lab_pin.sym} 71530 -8070 0 0 {name=p71391 lab=_87472_/CLK }
C {devices/lab_pin.sym} 71530 -8050 0 0 {name=p71392 lab=_41309_/X }
C {devices/lab_pin.sym} 71710 -8070 0 1 {name=p71393 lab=_67444_/B }
C {sky130_stdcells/dfxtp_4.sym} 71620 -8060 0 0 {name=X_88239_ }
C {devices/lab_pin.sym} 71540 -7970 0 0 {name=p71394 lab=_42614_/X }
C {devices/lab_pin.sym} 71540 -7930 0 0 {name=p71395 lab=_42615_/X }
C {devices/lab_pin.sym} 71540 -7890 0 0 {name=p71396 lab=_40972_/X }
C {devices/lab_pin.sym} 71540 -7850 0 0 {name=p71397 lab=_87788_/Q }
C {devices/lab_pin.sym} 71540 -7810 0 0 {name=p71398 lab=_42637_/X }
C {devices/lab_pin.sym} 71700 -7890 0 1 {name=p71399 lab=_42645_/Y }
C {sky130_stdcells/o32ai_4.sym} 71620 -7890 0 0 {name=X_42645_ }
C {devices/lab_pin.sym} 71560 -7740 0 0 {name=p71400 lab=_73465_/A }
C {devices/lab_pin.sym} 71560 -7700 0 0 {name=p71401 lab=_73228_/B }
C {devices/lab_pin.sym} 71680 -7720 0 1 {name=p71402 lab=_73465_/Y }
C {sky130_stdcells/nor2_4.sym} 71620 -7720 0 0 {name=X_73465_ }
C {devices/lab_pin.sym} 71540 -7610 0 0 {name=p71403 lab=_70664_/X }
C {devices/lab_pin.sym} 71540 -7570 0 0 {name=p71404 lab=_47468_/A }
C {devices/lab_pin.sym} 71540 -7530 0 0 {name=p71405 lab=_70676_/Y }
C {devices/lab_pin.sym} 71700 -7570 0 1 {name=p71406 lab=_83727_/D }
C {sky130_stdcells/a21o_4.sym} 71620 -7570 0 0 {name=X_70677_ }
C {devices/lab_pin.sym} 71580 -7430 0 0 {name=p71407 lab=_58399_/A }
C {devices/lab_pin.sym} 71660 -7430 0 1 {name=p71408 lab=_58400_/A }
C {sky130_stdcells/inv_2.sym} 71620 -7430 0 0 {name=X_58399_ }
C {devices/lab_pin.sym} 71540 -7330 0 0 {name=p71409 lab=_75207_/B }
C {devices/lab_pin.sym} 71540 -7290 0 0 {name=p71410 lab=_75201_/Y }
C {devices/lab_pin.sym} 71540 -7250 0 0 {name=p71411 lab=_75203_/Y }
C {devices/lab_pin.sym} 71700 -7290 0 1 {name=p71412 lab=_75205_/A }
C {sky130_stdcells/a21boi_4.sym} 71620 -7290 0 0 {name=X_75204_ }
C {devices/lab_pin.sym} 71580 -7150 0 0 {name=p71413 lab=_48152_/A }
C {devices/lab_pin.sym} 71660 -7150 0 1 {name=p71414 lab=_48153_/A }
C {sky130_stdcells/inv_2.sym} 71620 -7150 0 0 {name=X_48152_ }
C {devices/lab_pin.sym} 71580 -7030 0 0 {name=p71415 lab=_60447_/A }
C {devices/lab_pin.sym} 71660 -7030 0 1 {name=p71416 lab=_60430_/Y }
C {sky130_stdcells/inv_2.sym} 71620 -7030 0 0 {name=X_60430_ }
C {devices/lab_pin.sym} 71560 -6920 0 0 {name=p71417 lab=_86600_/Q }
C {devices/lab_pin.sym} 71560 -6880 0 0 {name=p71418 lab=_72428_/B }
C {devices/lab_pin.sym} 71680 -6900 0 1 {name=p71419 lab=_72416_/Y }
C {sky130_stdcells/nor2_4.sym} 71620 -6900 0 0 {name=X_72416_ }
C {devices/lab_pin.sym} 71580 -6770 0 0 {name=p71420 lab=_83011_/Q }
C {devices/lab_pin.sym} 71660 -6770 0 1 {name=p71421 lab=_45365_/A }
C {sky130_stdcells/inv_2.sym} 71620 -6770 0 0 {name=X_45364_ }
C {devices/lab_pin.sym} 71560 -6660 0 0 {name=p71422 lab=_81348_/Q }
C {devices/lab_pin.sym} 71560 -6620 0 0 {name=p71423 lab=_76183_/Y }
C {devices/lab_pin.sym} 71680 -6640 0 1 {name=p71424 lab=_76184_/X }
C {sky130_stdcells/xor2_4.sym} 71620 -6640 0 0 {name=X_76184_ }
C {devices/lab_pin.sym} 71580 -6510 0 0 {name=p71425 lab=_42576_/A }
C {devices/lab_pin.sym} 71660 -6510 0 1 {name=p71426 lab=_42576_/Y }
C {sky130_stdcells/inv_2.sym} 71620 -6510 0 0 {name=X_42576_ }
C {devices/lab_pin.sym} 71560 -6400 0 0 {name=p71427 lab=_87290_/Q }
C {devices/lab_pin.sym} 71560 -6360 0 0 {name=p71428 lab=_73003_/B }
C {devices/lab_pin.sym} 71680 -6380 0 1 {name=p71429 lab=_73396_/Y }
C {sky130_stdcells/nor2_4.sym} 71620 -6380 0 0 {name=X_73396_ }
C {devices/lab_pin.sym} 71580 -6250 0 0 {name=p71430 lab=_82382_/Q }
C {devices/lab_pin.sym} 71660 -6250 0 1 {name=p71431 lab=_47103_/Y }
C {sky130_stdcells/inv_2.sym} 71620 -6250 0 0 {name=X_47103_ }
C {devices/lab_pin.sym} 71580 -6130 0 0 {name=p71432 lab=_44315_/A }
C {devices/lab_pin.sym} 71660 -6130 0 1 {name=p71433 lab=_58007_/A }
C {sky130_stdcells/buf_2.sym} 71620 -6130 0 0 {name=X_44315_ }
C {devices/lab_pin.sym} 71540 -6030 0 0 {name=p71434 lab=_75120_/A }
C {devices/lab_pin.sym} 71540 -5990 0 0 {name=p71435 lab=_75116_/X }
C {devices/lab_pin.sym} 71540 -5950 0 0 {name=p71436 lab=_75134_/Y }
C {devices/lab_pin.sym} 71700 -5990 0 1 {name=p71437 lab=_75135_/Y }
C {sky130_stdcells/a21oi_4.sym} 71620 -5990 0 0 {name=X_75135_ }
C {devices/lab_pin.sym} 71560 -5860 0 0 {name=p71438 lab=_41358_/X }
C {devices/lab_pin.sym} 71560 -5820 0 0 {name=p71439 lab=_82323_/Q }
C {devices/lab_pin.sym} 71680 -5840 0 1 {name=p71440 lab=_41527_/X }
C {sky130_stdcells/or2_4.sym} 71620 -5840 0 0 {name=X_41527_ }
C {devices/lab_pin.sym} 71580 -5710 0 0 {name=p71441 lab=_60360_/X }
C {devices/lab_pin.sym} 71660 -5710 0 1 {name=p71442 lab=_60362_/A }
C {sky130_stdcells/buf_2.sym} 71620 -5710 0 0 {name=X_60361_ }
C {devices/lab_pin.sym} 71560 -5600 0 0 {name=p71443 lab=_72347_/A }
C {devices/lab_pin.sym} 71560 -5560 0 0 {name=p71444 lab=_72347_/B }
C {devices/lab_pin.sym} 71680 -5580 0 1 {name=p71445 lab=_72347_/Y }
C {sky130_stdcells/nor2_4.sym} 71620 -5580 0 0 {name=X_72347_ }
C {devices/lab_pin.sym} 71560 -5460 0 0 {name=p71446 lab=_48092_/A }
C {devices/lab_pin.sym} 71560 -5420 0 0 {name=p71447 lab=_48310_/B }
C {devices/lab_pin.sym} 71680 -5440 0 1 {name=p71448 lab=_48083_/Y }
C {sky130_stdcells/nand2_4.sym} 71620 -5440 0 0 {name=X_48083_ }
C {devices/lab_pin.sym} 71540 -5330 0 0 {name=p71449 lab=_45277_/X }
C {devices/lab_pin.sym} 71540 -5290 0 0 {name=p71450 lab=_61627_/B }
C {devices/lab_pin.sym} 71540 -5250 0 0 {name=p71451 lab=_45294_/X }
C {devices/lab_pin.sym} 71700 -5290 0 1 {name=p71452 lab=_45295_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -5290 0 0 {name=X_45295_ }
C {devices/lab_pin.sym} 71540 -5190 0 0 {name=p71453 lab=_62093_/X }
C {devices/lab_pin.sym} 71540 -5150 0 0 {name=p71454 lab=_62095_/X }
C {devices/lab_pin.sym} 71540 -5110 0 0 {name=p71455 lab=_62099_/Y }
C {devices/lab_pin.sym} 71540 -5070 0 0 {name=p71456 lab=_58344_/A }
C {devices/lab_pin.sym} 71540 -5030 0 0 {name=p71457 lab=_62048_/X }
C {devices/lab_pin.sym} 71700 -5110 0 1 {name=p71458 lab=_62100_/Y }
C {sky130_stdcells/o32ai_4.sym} 71620 -5110 0 0 {name=X_62100_ }
C {devices/lab_pin.sym} 71540 -4970 0 0 {name=p71459 lab=_86677_/Q }
C {devices/lab_pin.sym} 71540 -4930 0 0 {name=p71460 lab=_47004_/X }
C {devices/lab_pin.sym} 71540 -4890 0 0 {name=p71461 lab=_47033_/Y }
C {devices/lab_pin.sym} 71700 -4930 0 1 {name=p71462 lab=_47034_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -4930 0 0 {name=X_47034_ }
C {devices/lab_pin.sym} 71580 -4790 0 0 {name=p71463 lab=_44246_/A }
C {devices/lab_pin.sym} 71660 -4790 0 1 {name=p71464 lab=_58631_/A }
C {sky130_stdcells/buf_2.sym} 71620 -4790 0 0 {name=X_44246_ }
C {devices/lab_pin.sym} 71540 -4690 0 0 {name=p71465 lab=_79940_/Y }
C {devices/lab_pin.sym} 71540 -4650 0 0 {name=p71466 lab=_79941_/Y }
C {devices/lab_pin.sym} 71540 -4610 0 0 {name=p71467 lab=_79942_/A }
C {devices/lab_pin.sym} 71700 -4650 0 1 {name=p71468 lab=_79945_/A }
C {sky130_stdcells/a21o_4.sym} 71620 -4650 0 0 {name=X_79943_ }
C {devices/lab_pin.sym} 71540 -4550 0 0 {name=p71469 lab=_63074_/Y }
C {devices/lab_pin.sym} 71540 -4510 0 0 {name=p71470 lab=_63075_/X }
C {devices/lab_pin.sym} 71540 -4470 0 0 {name=p71471 lab=_63077_/X }
C {devices/lab_pin.sym} 71540 -4430 0 0 {name=p71472 lab=_63079_/X }
C {devices/lab_pin.sym} 71540 -4390 0 0 {name=p71473 lab=_63067_/X }
C {devices/lab_pin.sym} 71700 -4470 0 1 {name=p71474 lab=_63080_/Y }
C {sky130_stdcells/o41ai_4.sym} 71620 -4470 0 0 {name=X_63080_ }
C {devices/lab_pin.sym} 71560 -4320 0 0 {name=p71475 lab=_80960_/Q }
C {devices/lab_pin.sym} 71560 -4280 0 0 {name=p71476 lab=_75066_/B }
C {devices/lab_pin.sym} 71680 -4300 0 1 {name=p71477 lab=_75066_/X }
C {sky130_stdcells/xor2_4.sym} 71620 -4300 0 0 {name=X_75066_ }
C {devices/lab_pin.sym} 71540 -4200 0 0 {name=p71478 lab=_41454_/X }
C {devices/lab_pin.sym} 71540 -4160 0 0 {name=p71479 lab=_41455_/X }
C {devices/lab_pin.sym} 71540 -4120 0 0 {name=p71480 lab=_88212_/Q }
C {devices/lab_pin.sym} 71540 -4080 0 0 {name=p71481 lab=_41457_/X }
C {devices/lab_pin.sym} 71700 -4140 0 1 {name=p71482 lab=_88212_/D }
C {sky130_stdcells/a2bb2o_4.sym} 71620 -4140 0 0 {name=X_41458_ }
C {devices/lab_pin.sym} 71580 -3990 0 0 {name=p71483 lab=_60292_/A }
C {devices/lab_pin.sym} 71660 -3990 0 1 {name=p71484 lab=_60337_/A }
C {sky130_stdcells/buf_2.sym} 71620 -3990 0 0 {name=X_60292_ }
C {devices/lab_pin.sym} 71560 -3880 0 0 {name=p71485 lab=_86612_/Q }
C {devices/lab_pin.sym} 71560 -3840 0 0 {name=p71486 lab=_72348_/B }
C {devices/lab_pin.sym} 71680 -3860 0 1 {name=p71487 lab=_72278_/Y }
C {sky130_stdcells/nor2_4.sym} 71620 -3860 0 0 {name=X_72278_ }
C {devices/lab_pin.sym} 71540 -3770 0 0 {name=p71488 lab=_62021_/X }
C {devices/lab_pin.sym} 71540 -3730 0 0 {name=p71489 lab=_62023_/X }
C {devices/lab_pin.sym} 71540 -3690 0 0 {name=p71490 lab=_62030_/Y }
C {devices/lab_pin.sym} 71540 -3650 0 0 {name=p71491 lab=_84846_/Q }
C {devices/lab_pin.sym} 71540 -3610 0 0 {name=p71492 lab=_61973_/X }
C {devices/lab_pin.sym} 71700 -3690 0 1 {name=p71493 lab=_62031_/Y }
C {sky130_stdcells/o32ai_4.sym} 71620 -3690 0 0 {name=X_62031_ }
C {devices/lab_pin.sym} 71560 -3540 0 0 {name=p71494 lab=_73972_/X }
C {devices/lab_pin.sym} 71560 -3500 0 0 {name=p71495 lab=_66183_/B }
C {devices/lab_pin.sym} 71680 -3520 0 1 {name=p71496 lab=_74017_/X }
C {sky130_stdcells/and2_4.sym} 71620 -3520 0 0 {name=X_74017_ }
C {devices/lab_pin.sym} 71580 -3390 0 0 {name=p71497 lab=_47363_/A }
C {devices/lab_pin.sym} 71660 -3390 0 1 {name=p71498 lab=_40409_/X }
C {sky130_stdcells/buf_2.sym} 71620 -3390 0 0 {name=X_40409_ }
C {devices/lab_pin.sym} 71540 -3290 0 0 {name=p71499 lab=_48673_/B }
C {devices/lab_pin.sym} 71540 -3250 0 0 {name=p71500 lab=_71216_/X }
C {devices/lab_pin.sym} 71540 -3210 0 0 {name=p71501 lab=_71228_/Y }
C {devices/lab_pin.sym} 71700 -3250 0 1 {name=p71502 lab=_71229_/Y }
C {sky130_stdcells/o21ai_4.sym} 71620 -3250 0 0 {name=X_71229_ }
C {devices/lab_pin.sym} 71580 -3110 0 0 {name=p71503 lab=_58126_/A }
C {devices/lab_pin.sym} 71660 -3110 0 1 {name=p71504 lab=_44177_/X }
C {sky130_stdcells/buf_2.sym} 71620 -3110 0 0 {name=X_44177_ }
C {devices/lab_pin.sym} 71560 -3000 0 0 {name=p71505 lab=_79870_/Y }
C {devices/lab_pin.sym} 71560 -2960 0 0 {name=p71506 lab=_79873_/Y }
C {devices/lab_pin.sym} 71680 -2980 0 1 {name=p71507 lab=_79874_/X }
C {sky130_stdcells/xor2_4.sym} 71620 -2980 0 0 {name=X_79874_ }
C {devices/lab_pin.sym} 71540 -2890 0 0 {name=p71508 lab=_41337_/X }
C {devices/lab_pin.sym} 71540 -2850 0 0 {name=p71509 lab=_41338_/X }
C {devices/lab_pin.sym} 71540 -2810 0 0 {name=p71510 lab=_41387_/X }
C {devices/lab_pin.sym} 71540 -2770 0 0 {name=p71511 lab=_67801_/B }
C {devices/lab_pin.sym} 71540 -2730 0 0 {name=p71512 lab=_41388_/X }
C {devices/lab_pin.sym} 71700 -2810 0 1 {name=p71513 lab=_41389_/Y }
C {sky130_stdcells/o32ai_4.sym} 71620 -2810 0 0 {name=X_41389_ }
C {devices/lab_pin.sym} 71540 -2690 0 0 {name=p71514 lab=_43046_/X }
C {devices/lab_pin.sym} 71540 -2650 0 0 {name=p71515 lab=_43125_/X }
C {devices/lab_pin.sym} 71540 -2610 0 0 {name=p71516 lab=_40792_/X }
C {devices/lab_pin.sym} 71540 -2570 0 0 {name=p71517 lab=_43126_/Y }
C {devices/lab_pin.sym} 71540 -2530 0 0 {name=p71518 lab=_43127_/X }
C {devices/lab_pin.sym} 71700 -2610 0 1 {name=p71519 lab=_87566_/D }
C {sky130_stdcells/o32ai_4.sym} 71620 -2610 0 0 {name=X_43128_ }
C {devices/lab_pin.sym} 71560 -2460 0 0 {name=p71520 lab=_78825_/A }
C {devices/lab_pin.sym} 71560 -2420 0 0 {name=p71521 lab=_82836_/Q }
C {devices/lab_pin.sym} 71680 -2440 0 1 {name=p71522 lab=_78828_/C }
C {sky130_stdcells/nand2_4.sym} 71620 -2440 0 0 {name=X_78825_ }
C {devices/lab_pin.sym} 71580 -2310 0 0 {name=p71523 lab=_48985_/A }
C {devices/lab_pin.sym} 71660 -2310 0 1 {name=p71524 lab=_48985_/X }
C {sky130_stdcells/buf_2.sym} 71620 -2310 0 0 {name=X_48985_ }
C {devices/lab_pin.sym} 71540 -2210 0 0 {name=p71525 lab=_47904_/X }
C {devices/lab_pin.sym} 71540 -2170 0 0 {name=p71526 lab=_82936_/Q }
C {devices/lab_pin.sym} 71540 -2130 0 0 {name=p71527 lab=_47935_/X }
C {devices/lab_pin.sym} 71700 -2170 0 1 {name=p71528 lab=_47937_/B }
C {sky130_stdcells/o21ai_4.sym} 71620 -2170 0 0 {name=X_47936_ }
C {devices/lab_pin.sym} 71540 -2070 0 0 {name=p71529 lab=_43053_/X }
C {devices/lab_pin.sym} 71540 -2030 0 0 {name=p71530 lab=_43054_/X }
C {devices/lab_pin.sym} 71540 -1990 0 0 {name=p71531 lab=_40650_/X }
C {devices/lab_pin.sym} 71540 -1950 0 0 {name=p71532 lab=_43057_/Y }
C {devices/lab_pin.sym} 71540 -1910 0 0 {name=p71533 lab=_43058_/X }
C {devices/lab_pin.sym} 71700 -1990 0 1 {name=p71534 lab=_87592_/D }
C {sky130_stdcells/o32ai_4.sym} 71620 -1990 0 0 {name=X_43059_ }
C {devices/lab_pin.sym} 71540 -1860 0 0 {name=p71535 lab=_87127_/Q }
C {devices/lab_pin.sym} 71540 -1820 0 0 {name=p71536 lab=_66715_/X }
C {devices/lab_pin.sym} 71540 -1780 0 0 {name=p71537 lab=_66717_/X }
C {devices/lab_pin.sym} 71540 -1740 0 0 {name=p71538 lab=_66769_/X }
C {devices/lab_pin.sym} 71700 -1800 0 1 {name=p71539 lab=_66770_/X }
C {sky130_stdcells/a211o_4.sym} 71620 -1800 0 0 {name=X_66770_ }
C {devices/lab_pin.sym} 71580 -1650 0 0 {name=p71540 lab=_78755_/X }
C {devices/lab_pin.sym} 71660 -1650 0 1 {name=p71541 lab=_78756_/Y }
C {sky130_stdcells/inv_2.sym} 71620 -1650 0 0 {name=X_78756_ }
C {devices/lab_pin.sym} 71580 -1530 0 0 {name=p71542 lab=_63724_/A }
C {devices/lab_pin.sym} 71660 -1530 0 1 {name=p71543 lab=_64046_/B }
C {sky130_stdcells/buf_2.sym} 71620 -1530 0 0 {name=X_63982_ }
C {devices/lab_pin.sym} 71560 -1420 0 0 {name=p71544 lab=_81704_/D }
C {devices/lab_pin.sym} 71560 -1380 0 0 {name=p71545 lab=_75968_/B }
C {devices/lab_pin.sym} 71680 -1400 0 1 {name=p71546 lab=_75969_/B }
C {sky130_stdcells/nand2_4.sym} 71620 -1400 0 0 {name=X_75968_ }
C {devices/lab_pin.sym} 71540 -1290 0 0 {name=p71547 lab=_65716_/X }
C {devices/lab_pin.sym} 71540 -1250 0 0 {name=p71548 lab=_65720_/X }
C {devices/lab_pin.sym} 71540 -1210 0 0 {name=p71549 lab=_65566_/X }
C {devices/lab_pin.sym} 71700 -1250 0 1 {name=p71550 lab=_65721_/X }
C {sky130_stdcells/a21o_4.sym} 71620 -1250 0 0 {name=X_65721_ }
C {devices/lab_pin.sym} 71580 -1110 0 0 {name=p71551 lab=_77707_/A }
C {devices/lab_pin.sym} 71660 -1110 0 1 {name=p71552 lab=_82208_/D }
C {sky130_stdcells/inv_2.sym} 71620 -1110 0 0 {name=X_77707_ }
C {devices/lab_pin.sym} 71560 -1020 0 0 {name=p71553 lab=_62971_/A }
C {devices/lab_pin.sym} 71560 -980 0 0 {name=p71554 lab=_84888_/Q }
C {devices/lab_pin.sym} 71560 -940 0 0 {name=p71555 lab=_62819_/C }
C {devices/lab_pin.sym} 71560 -900 0 0 {name=p71556 lab=_62979_/D }
C {devices/lab_pin.sym} 71680 -960 0 1 {name=p71557 lab=_62933_/X }
C {sky130_stdcells/and4_4.sym} 71620 -960 0 0 {name=X_62933_ }
C {devices/lab_pin.sym} 71560 -820 0 0 {name=p71558 lab=_74912_/X }
C {devices/lab_pin.sym} 71560 -780 0 0 {name=p71559 lab=_74930_/A }
C {devices/lab_pin.sym} 71680 -800 0 1 {name=p71560 lab=_74920_/B }
C {sky130_stdcells/xor2_4.sym} 71620 -800 0 0 {name=X_74919_ }
C {devices/lab_pin.sym} 71580 -670 0 0 {name=p71561 lab=_47867_/A }
C {devices/lab_pin.sym} 71660 -670 0 1 {name=p71562 lab=_47867_/X }
C {sky130_stdcells/buf_2.sym} 71620 -670 0 0 {name=X_47867_ }
C {devices/lab_pin.sym} 72480 -42160 0 0 {name=p71563 lab=_78701_/A }
C {devices/lab_pin.sym} 72480 -42120 0 0 {name=p71564 lab=_78686_/Y }
C {devices/lab_pin.sym} 72600 -42140 0 1 {name=p71565 lab=_82779_/D }
C {sky130_stdcells/xnor2_4.sym} 72540 -42140 0 0 {name=X_78687_ }
C {devices/lab_pin.sym} 72480 -42020 0 0 {name=p71566 lab=_75899_/A }
C {devices/lab_pin.sym} 72480 -41980 0 0 {name=p71567 lab=_84369_/Q }
C {devices/lab_pin.sym} 72600 -42000 0 1 {name=p71568 lab=_75899_/X }
C {sky130_stdcells/xor2_4.sym} 72540 -42000 0 0 {name=X_75899_ }
C {devices/lab_pin.sym} 72500 -41870 0 0 {name=p71569 lab=_49632_/A }
C {devices/lab_pin.sym} 72580 -41870 0 1 {name=p71570 lab=_49606_/X }
C {sky130_stdcells/buf_2.sym} 72540 -41870 0 0 {name=X_49606_ }
C {devices/lab_pin.sym} 72480 -41760 0 0 {name=p71571 lab=_66053_/A }
C {devices/lab_pin.sym} 72480 -41720 0 0 {name=p71572 lab=_68440_/B }
C {devices/lab_pin.sym} 72600 -41740 0 1 {name=p71573 lab=_68440_/Y }
C {sky130_stdcells/nor2_4.sym} 72540 -41740 0 0 {name=X_68440_ }
C {devices/lab_pin.sym} 72460 -41630 0 0 {name=p71574 lab=_86700_/Q }
C {devices/lab_pin.sym} 72460 -41590 0 0 {name=p71575 lab=_46813_/X }
C {devices/lab_pin.sym} 72460 -41550 0 0 {name=p71576 lab=_46817_/Y }
C {devices/lab_pin.sym} 72620 -41590 0 1 {name=p71577 lab=_46818_/Y }
C {sky130_stdcells/o21ai_4.sym} 72540 -41590 0 0 {name=X_46818_ }
C {devices/lab_pin.sym} 72460 -41470 0 0 {name=p71578 lab=_65648_/Y }
C {devices/lab_pin.sym} 72460 -41430 0 0 {name=p71579 lab=_65602_/X }
C {devices/lab_pin.sym} 72460 -41390 0 0 {name=p71580 lab=_65651_/Y }
C {devices/lab_pin.sym} 72620 -41430 0 1 {name=p71581 lab=_84187_/D }
C {sky130_stdcells/a21o_4.sym} 72540 -41430 0 0 {name=X_65652_ }
C {devices/lab_pin.sym} 72500 -41290 0 0 {name=p71582 lab=_77666_/B }
C {devices/lab_pin.sym} 72580 -41290 0 1 {name=p71583 lab=_77638_/Y }
C {sky130_stdcells/inv_2.sym} 72540 -41290 0 0 {name=X_77638_ }
C {devices/lab_pin.sym} 72480 -41190 0 0 {name=p71584 lab=_62894_/A }
C {devices/lab_pin.sym} 72480 -41150 0 0 {name=p71585 lab=_62852_/X }
C {devices/lab_pin.sym} 72480 -41110 0 0 {name=p71586 lab=_62864_/C }
C {devices/lab_pin.sym} 72600 -41150 0 1 {name=p71587 lab=_62864_/Y }
C {sky130_stdcells/nor3_4.sym} 72540 -41150 0 0 {name=X_62864_ }
C {devices/lab_pin.sym} 72500 -41010 0 0 {name=p71588 lab=_47798_/A }
C {devices/lab_pin.sym} 72580 -41010 0 1 {name=p71589 lab=_51728_/B }
C {sky130_stdcells/buf_2.sym} 72540 -41010 0 0 {name=X_47798_ }
C {devices/lab_pin.sym} 72480 -40900 0 0 {name=p71590 lab=_64684_/A }
C {devices/lab_pin.sym} 72480 -40860 0 0 {name=p71591 lab=_86465_/Q }
C {devices/lab_pin.sym} 72600 -40880 0 1 {name=p71592 lab=_64603_/X }
C {sky130_stdcells/and2_4.sym} 72540 -40880 0 0 {name=X_64603_ }
C {devices/lab_pin.sym} 72480 -40780 0 0 {name=p71593 lab=_49537_/A }
C {devices/lab_pin.sym} 72480 -40740 0 0 {name=p71594 lab=_49537_/B }
C {devices/lab_pin.sym} 72480 -40700 0 0 {name=p71595 lab=_49522_/C }
C {devices/lab_pin.sym} 72480 -40660 0 0 {name=p71596 lab=_52750_/D }
C {devices/lab_pin.sym} 72600 -40720 0 1 {name=p71597 lab=_49537_/X }
C {sky130_stdcells/and4_4.sym} 72540 -40720 0 0 {name=X_49537_ }
C {devices/lab_pin.sym} 72500 -40570 0 0 {name=p71598 lab=clkbuf_9_220_0_CLK/X }
C {devices/lab_pin.sym} 72580 -40570 0 1 {name=p71599 lab=_84150_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 72540 -40570 0 0 {name=Xclkbuf_10_441_0_CLK }
C {devices/lab_pin.sym} 72500 -40450 0 0 {name=p71600 lab=_61719_/A }
C {devices/lab_pin.sym} 72580 -40450 0 1 {name=p71601 lab=_61815_/X }
C {sky130_stdcells/buf_2.sym} 72540 -40450 0 0 {name=X_61815_ }
C {devices/lab_pin.sym} 72480 -40340 0 0 {name=p71602 lab=_68371_/A }
C {devices/lab_pin.sym} 72480 -40300 0 0 {name=p71603 lab=_88371_/Q }
C {devices/lab_pin.sym} 72600 -40320 0 1 {name=p71604 lab=_68371_/X }
C {sky130_stdcells/and2_4.sym} 72540 -40320 0 0 {name=X_68371_ }
C {devices/lab_pin.sym} 72480 -40200 0 0 {name=p71605 lab=_46733_/A }
C {devices/lab_pin.sym} 72480 -40160 0 0 {name=p71606 lab=_50961_/B }
C {devices/lab_pin.sym} 72600 -40180 0 1 {name=p71607 lab=_46749_/Y }
C {sky130_stdcells/nand2_4.sym} 72540 -40180 0 0 {name=X_46749_ }
C {devices/lab_pin.sym} 72500 -40050 0 0 {name=p71608 lab=_65782_/A }
C {devices/lab_pin.sym} 72580 -40050 0 1 {name=p71609 lab=_65769_/A }
C {sky130_stdcells/buf_2.sym} 72540 -40050 0 0 {name=X_65583_ }
C {devices/lab_pin.sym} 72500 -39930 0 0 {name=p71610 lab=_77568_/Y }
C {devices/lab_pin.sym} 72580 -39930 0 1 {name=p71611 lab=_77570_/C }
C {sky130_stdcells/inv_2.sym} 72540 -39930 0 0 {name=X_77569_ }
C {devices/lab_pin.sym} 72460 -39830 0 0 {name=p71612 lab=_62790_/X }
C {devices/lab_pin.sym} 72460 -39790 0 0 {name=p71613 lab=_62779_/X }
C {devices/lab_pin.sym} 72460 -39750 0 0 {name=p71614 lab=_62794_/Y }
C {devices/lab_pin.sym} 72620 -39790 0 1 {name=p71615 lab=_84382_/D }
C {sky130_stdcells/a21oi_4.sym} 72540 -39790 0 0 {name=X_62795_ }
C {devices/lab_pin.sym} 72500 -39650 0 0 {name=p71616 lab=_67203_/X }
C {devices/lab_pin.sym} 72580 -39650 0 1 {name=p71617 lab=_67322_/X }
C {sky130_stdcells/buf_2.sym} 72540 -39650 0 0 {name=X_67322_ }
C {devices/lab_pin.sym} 72460 -39550 0 0 {name=p71618 lab=_79302_/A }
C {devices/lab_pin.sym} 72460 -39510 0 0 {name=p71619 lab=_79301_/X }
C {devices/lab_pin.sym} 72460 -39470 0 0 {name=p71620 lab=_79307_/Y }
C {devices/lab_pin.sym} 72620 -39510 0 1 {name=p71621 lab=_79324_/A }
C {sky130_stdcells/a21boi_4.sym} 72540 -39510 0 0 {name=X_79308_ }
C {devices/lab_pin.sym} 72480 -39400 0 0 {name=p71622 lab=_64234_/A }
C {devices/lab_pin.sym} 72480 -39360 0 0 {name=p71623 lab=_64234_/B }
C {devices/lab_pin.sym} 72480 -39320 0 0 {name=p71624 lab=_64534_/C }
C {devices/lab_pin.sym} 72480 -39280 0 0 {name=p71625 lab=_64221_/X }
C {devices/lab_pin.sym} 72600 -39340 0 1 {name=p71626 lab=_64534_/X }
C {sky130_stdcells/and4_4.sym} 72540 -39340 0 0 {name=X_64534_ }
C {devices/lab_pin.sym} 72460 -39210 0 0 {name=p71627 lab=_49465_/Y }
C {devices/lab_pin.sym} 72460 -39170 0 0 {name=p71628 lab=_49460_/X }
C {devices/lab_pin.sym} 72460 -39130 0 0 {name=p71629 lab=_49467_/X }
C {devices/lab_pin.sym} 72620 -39170 0 1 {name=p71630 lab=_86382_/D }
C {sky130_stdcells/a21oi_4.sym} 72540 -39170 0 0 {name=X_49468_ }
C {devices/lab_pin.sym} 72500 -39030 0 0 {name=p71631 lab=_61966_/A }
C {devices/lab_pin.sym} 72580 -39030 0 1 {name=p71632 lab=_61765_/C }
C {sky130_stdcells/buf_2.sym} 72540 -39030 0 0 {name=X_61746_ }
C {devices/lab_pin.sym} 72480 -38920 0 0 {name=p71633 lab=_80580_/A }
C {devices/lab_pin.sym} 72480 -38880 0 0 {name=p71634 lab=_80580_/B }
C {devices/lab_pin.sym} 72600 -38900 0 1 {name=p71635 lab=_80596_/B }
C {sky130_stdcells/xnor2_4.sym} 72540 -38900 0 0 {name=X_80580_ }
C {devices/lab_pin.sym} 72500 -38770 0 0 {name=p71636 lab=_48478_/A }
C {devices/lab_pin.sym} 72580 -38770 0 1 {name=p71637 lab=_48419_/X }
C {sky130_stdcells/buf_2.sym} 72540 -38770 0 0 {name=X_48419_ }
C {devices/lab_pin.sym} 72500 -38650 0 0 {name=p71638 lab=_79239_/A }
C {devices/lab_pin.sym} 72580 -38650 0 1 {name=p71639 lab=_79240_/B }
C {sky130_stdcells/inv_2.sym} 72540 -38650 0 0 {name=X_79239_ }
C {devices/lab_pin.sym} 72480 -38540 0 0 {name=p71640 lab=_67183_/A }
C {devices/lab_pin.sym} 72480 -38500 0 0 {name=p71641 lab=_88183_/Q }
C {devices/lab_pin.sym} 72600 -38520 0 1 {name=p71642 lab=_67253_/X }
C {sky130_stdcells/and2_4.sym} 72540 -38520 0 0 {name=X_67253_ }
C {devices/lab_pin.sym} 72480 -38400 0 0 {name=p71643 lab=_63630_/A }
C {devices/lab_pin.sym} 72480 -38360 0 0 {name=p71644 lab=_64419_/B }
C {devices/lab_pin.sym} 72600 -38380 0 1 {name=p71645 lab=_64465_/Y }
C {sky130_stdcells/nor2_4.sym} 72540 -38380 0 0 {name=X_64465_ }
C {devices/lab_pin.sym} 72480 -38260 0 0 {name=p71646 lab=_49410_/A }
C {devices/lab_pin.sym} 72480 -38220 0 0 {name=p71647 lab=_46685_/X }
C {devices/lab_pin.sym} 72600 -38240 0 1 {name=p71648 lab=_49399_/Y }
C {sky130_stdcells/nand2_4.sym} 72540 -38240 0 0 {name=X_49399_ }
C {devices/lab_pin.sym} 72480 -38140 0 0 {name=p71649 lab=_58364_/A }
C {devices/lab_pin.sym} 72480 -38100 0 0 {name=p71650 lab=_61598_/X }
C {devices/lab_pin.sym} 72480 -38060 0 0 {name=p71651 lab=_61677_/C }
C {devices/lab_pin.sym} 72480 -38020 0 0 {name=p71652 lab=_72563_/B }
C {devices/lab_pin.sym} 72600 -38080 0 1 {name=p71653 lab=_61678_/A }
C {sky130_stdcells/nand4_4.sym} 72540 -38080 0 0 {name=X_61677_ }
C {devices/lab_pin.sym} 72500 -37930 0 0 {name=p71654 lab=clkbuf_9_228_0_CLK/X }
C {devices/lab_pin.sym} 72580 -37930 0 1 {name=p71655 lab=_83275_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 72540 -37930 0 0 {name=Xclkbuf_10_456_0_CLK }
C {devices/lab_pin.sym} 72480 -37820 0 0 {name=p71656 lab=_66204_/A }
C {devices/lab_pin.sym} 72480 -37780 0 0 {name=p71657 lab=_66203_/Y }
C {devices/lab_pin.sym} 72600 -37800 0 1 {name=p71658 lab=_66204_/Y }
C {sky130_stdcells/nand2_4.sym} 72540 -37800 0 0 {name=X_66204_ }
C {devices/lab_pin.sym} 72500 -37670 0 0 {name=p71659 lab=_51211_/A }
C {devices/lab_pin.sym} 72580 -37670 0 1 {name=p71660 lab=_51430_/X }
C {sky130_stdcells/buf_2.sym} 72540 -37670 0 0 {name=X_51430_ }
C {devices/lab_pin.sym} 72500 -37550 0 0 {name=p71661 lab=_63416_/A }
C {devices/lab_pin.sym} 72580 -37550 0 1 {name=p71662 lab=_63465_/B }
C {sky130_stdcells/buf_2.sym} 72540 -37550 0 0 {name=X_63416_ }
C {devices/lab_pin.sym} 72450 -37430 0 0 {name=p71663 lab=_82253_/CLK }
C {devices/lab_pin.sym} 72450 -37410 0 0 {name=p71664 lab=_80387_/X }
C {devices/lab_pin.sym} 72630 -37430 0 1 {name=p71665 lab=_82250_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -37420 0 0 {name=X_82250_ }
C {devices/lab_pin.sym} 72480 -37310 0 0 {name=p71666 lab=_60628_/A }
C {devices/lab_pin.sym} 72480 -37270 0 0 {name=p71667 lab=_59552_/C }
C {devices/lab_pin.sym} 72480 -37230 0 0 {name=p71668 lab=_60628_/C }
C {devices/lab_pin.sym} 72600 -37270 0 1 {name=p71669 lab=_60628_/Y }
C {sky130_stdcells/nand3_4.sym} 72540 -37270 0 0 {name=X_60628_ }
C {devices/lab_pin.sym} 72460 -37160 0 0 {name=p71670 lab=_88378_/Q }
C {devices/lab_pin.sym} 72460 -37120 0 0 {name=p71671 lab=_67110_/X }
C {devices/lab_pin.sym} 72460 -37080 0 0 {name=p71672 lab=_67160_/X }
C {devices/lab_pin.sym} 72460 -37040 0 0 {name=p71673 lab=_67183_/X }
C {devices/lab_pin.sym} 72620 -37100 0 1 {name=p71674 lab=_67184_/X }
C {sky130_stdcells/a211o_4.sym} 72540 -37100 0 0 {name=X_67184_ }
C {devices/lab_pin.sym} 72460 -36990 0 0 {name=p71675 lab=_64390_/X }
C {devices/lab_pin.sym} 72460 -36950 0 0 {name=p71676 lab=_64392_/X }
C {devices/lab_pin.sym} 72460 -36910 0 0 {name=p71677 lab=_64393_/X }
C {devices/lab_pin.sym} 72460 -36870 0 0 {name=p71678 lab=_64395_/Y }
C {devices/lab_pin.sym} 72460 -36830 0 0 {name=p71679 lab=_64384_/X }
C {devices/lab_pin.sym} 72620 -36910 0 1 {name=p71680 lab=_64396_/X }
C {sky130_stdcells/o41a_4.sym} 72540 -36910 0 0 {name=X_64396_ }
C {devices/lab_pin.sym} 72450 -36750 0 0 {name=p71681 lab=_84981_/CLK }
C {devices/lab_pin.sym} 72450 -36730 0 0 {name=p71682 lab=_75007_/X }
C {devices/lab_pin.sym} 72630 -36750 0 1 {name=p71683 lab=_49049_/A }
C {sky130_stdcells/dfxtp_4.sym} 72540 -36740 0 0 {name=X_81201_ }
C {devices/lab_pin.sym} 72480 -36630 0 0 {name=p71684 lab=_65659_/X }
C {devices/lab_pin.sym} 72480 -36590 0 0 {name=p71685 lab=_66135_/B }
C {devices/lab_pin.sym} 72480 -36550 0 0 {name=p71686 lab=_65662_/X }
C {devices/lab_pin.sym} 72600 -36590 0 1 {name=p71687 lab=_66135_/Y }
C {sky130_stdcells/nand3_4.sym} 72540 -36590 0 0 {name=X_66135_ }
C {devices/lab_pin.sym} 72460 -36470 0 0 {name=p71688 lab=_51359_/Y }
C {devices/lab_pin.sym} 72460 -36430 0 0 {name=p71689 lab=_51339_/X }
C {devices/lab_pin.sym} 72460 -36390 0 0 {name=p71690 lab=_51360_/X }
C {devices/lab_pin.sym} 72620 -36430 0 1 {name=p71691 lab=_86025_/D }
C {sky130_stdcells/a21oi_4.sym} 72540 -36430 0 0 {name=X_51361_ }
C {devices/lab_pin.sym} 72480 -36320 0 0 {name=p71692 lab=_60562_/B }
C {devices/lab_pin.sym} 72480 -36280 0 0 {name=p71693 lab=_61692_/B }
C {devices/lab_pin.sym} 72480 -36240 0 0 {name=p71694 lab=_63347_/C }
C {devices/lab_pin.sym} 72480 -36200 0 0 {name=p71695 lab=_60570_/A }
C {devices/lab_pin.sym} 72600 -36260 0 1 {name=p71696 lab=_63347_/X }
C {sky130_stdcells/and4_4.sym} 72540 -36260 0 0 {name=X_63347_ }
C {devices/lab_pin.sym} 72450 -36110 0 0 {name=p71697 lab=_84951_/CLK }
C {devices/lab_pin.sym} 72450 -36090 0 0 {name=p71698 lab=_77276_/Y }
C {devices/lab_pin.sym} 72630 -36110 0 1 {name=p71699 lab=_82181_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -36100 0 0 {name=X_82181_ }
C {devices/lab_pin.sym} 72500 -35970 0 0 {name=p71700 lab=_60558_/X }
C {devices/lab_pin.sym} 72580 -35970 0 1 {name=p71701 lab=_60612_/A }
C {sky130_stdcells/buf_2.sym} 72540 -35970 0 0 {name=X_60559_ }
C {devices/lab_pin.sym} 72460 -35870 0 0 {name=p71702 lab=_53096_/Y }
C {devices/lab_pin.sym} 72460 -35830 0 0 {name=p71703 lab=_53082_/X }
C {devices/lab_pin.sym} 72460 -35790 0 0 {name=p71704 lab=_53099_/X }
C {devices/lab_pin.sym} 72620 -35830 0 1 {name=p71705 lab=_85698_/D }
C {sky130_stdcells/a21oi_4.sym} 72540 -35830 0 0 {name=X_53100_ }
C {devices/lab_pin.sym} 72500 -35690 0 0 {name=p71706 lab=_50473_/A }
C {devices/lab_pin.sym} 72580 -35690 0 1 {name=p71707 lab=_50491_/A }
C {sky130_stdcells/buf_2.sym} 72540 -35690 0 0 {name=X_50312_ }
C {devices/lab_pin.sym} 72450 -35570 0 0 {name=p71708 lab=_80804_/CLK }
C {devices/lab_pin.sym} 72450 -35550 0 0 {name=p71709 lab=_81132_/D }
C {devices/lab_pin.sym} 72630 -35570 0 1 {name=p71710 lab=_40705_/A }
C {sky130_stdcells/dfxtp_4.sym} 72540 -35560 0 0 {name=X_81132_ }
C {devices/lab_pin.sym} 72460 -35450 0 0 {name=p71711 lab=_54078_/Y }
C {devices/lab_pin.sym} 72460 -35410 0 0 {name=p71712 lab=_54060_/X }
C {devices/lab_pin.sym} 72460 -35370 0 0 {name=p71713 lab=_54079_/Y }
C {devices/lab_pin.sym} 72620 -35410 0 1 {name=p71714 lab=_54080_/Y }
C {sky130_stdcells/a21boi_4.sym} 72540 -35410 0 0 {name=X_54080_ }
C {devices/lab_pin.sym} 72480 -35290 0 0 {name=p71715 lab=_65970_/A }
C {devices/lab_pin.sym} 72480 -35250 0 0 {name=p71716 lab=_66004_/B }
C {devices/lab_pin.sym} 72480 -35210 0 0 {name=p71717 lab=_84159_/Q }
C {devices/lab_pin.sym} 72600 -35250 0 1 {name=p71718 lab=_66066_/X }
C {sky130_stdcells/and3_4.sym} 72540 -35250 0 0 {name=X_66066_ }
C {devices/lab_pin.sym} 72480 -35120 0 0 {name=p71719 lab=_51296_/A }
C {devices/lab_pin.sym} 72480 -35080 0 0 {name=p71720 lab=_50781_/B }
C {devices/lab_pin.sym} 72600 -35100 0 1 {name=p71721 lab=_51292_/Y }
C {sky130_stdcells/nand2_4.sym} 72540 -35100 0 0 {name=X_51292_ }
C {devices/lab_pin.sym} 72460 -35000 0 0 {name=p71722 lab=_58970_/A }
C {devices/lab_pin.sym} 72460 -34960 0 0 {name=p71723 lab=_62999_/X }
C {devices/lab_pin.sym} 72460 -34920 0 0 {name=p71724 lab=_61617_/B }
C {devices/lab_pin.sym} 72460 -34880 0 0 {name=p71725 lab=_60608_/X }
C {devices/lab_pin.sym} 72620 -34940 0 1 {name=p71726 lab=_63278_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 72540 -34940 0 0 {name=X_63278_ }
C {devices/lab_pin.sym} 72480 -34820 0 0 {name=p71727 lab=_53048_/A }
C {devices/lab_pin.sym} 72480 -34780 0 0 {name=p71728 lab=_53036_/B }
C {devices/lab_pin.sym} 72480 -34740 0 0 {name=p71729 lab=_53019_/C }
C {devices/lab_pin.sym} 72480 -34700 0 0 {name=p71730 lab=_53031_/D }
C {devices/lab_pin.sym} 72600 -34760 0 1 {name=p71731 lab=_53031_/X }
C {sky130_stdcells/and4_4.sym} 72540 -34760 0 0 {name=X_53031_ }
C {devices/lab_pin.sym} 72460 -34640 0 0 {name=p71732 lab=_64835_/X }
C {devices/lab_pin.sym} 72460 -34600 0 0 {name=p71733 lab=_83298_/Q }
C {devices/lab_pin.sym} 72460 -34560 0 0 {name=p71734 lab=_65015_/X }
C {devices/lab_pin.sym} 72460 -34520 0 0 {name=p71735 lab=_65016_/X }
C {devices/lab_pin.sym} 72620 -34580 0 1 {name=p71736 lab=_65017_/X }
C {sky130_stdcells/a211o_4.sym} 72540 -34580 0 0 {name=X_65017_ }
C {devices/lab_pin.sym} 72500 -34430 0 0 {name=p71737 lab=_50768_/A }
C {devices/lab_pin.sym} 72580 -34430 0 1 {name=p71738 lab=_50243_/X }
C {sky130_stdcells/buf_2.sym} 72540 -34430 0 0 {name=X_50243_ }
C {devices/lab_pin.sym} 72480 -34330 0 0 {name=p71739 lab=_62632_/A }
C {devices/lab_pin.sym} 72480 -34290 0 0 {name=p71740 lab=_63369_/B }
C {devices/lab_pin.sym} 72480 -34250 0 0 {name=p71741 lab=_62319_/C }
C {devices/lab_pin.sym} 72600 -34290 0 1 {name=p71742 lab=_62229_/Y }
C {sky130_stdcells/nand3_4.sym} 72540 -34290 0 0 {name=X_62229_ }
C {devices/lab_pin.sym} 72450 -34150 0 0 {name=p71743 lab=_86100_/CLK }
C {devices/lab_pin.sym} 72450 -34130 0 0 {name=p71744 lab=_51825_/Y }
C {devices/lab_pin.sym} 72630 -34150 0 1 {name=p71745 lab=_85940_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -34140 0 0 {name=X_85940_ }
C {devices/lab_pin.sym} 72450 -34010 0 0 {name=p71746 lab=_81061_/CLK }
C {devices/lab_pin.sym} 72450 -33990 0 0 {name=p71747 lab=_81095_/Q }
C {devices/lab_pin.sym} 72630 -34010 0 1 {name=p71748 lab=_81063_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -34000 0 0 {name=X_81063_ }
C {devices/lab_pin.sym} 72480 -33880 0 0 {name=p71749 lab=_80008_/X }
C {devices/lab_pin.sym} 72480 -33840 0 0 {name=p71750 lab=_80013_/Y }
C {devices/lab_pin.sym} 72600 -33860 0 1 {name=p71751 lab=_81674_/D }
C {sky130_stdcells/xor2_4.sym} 72540 -33860 0 0 {name=X_80014_ }
C {devices/lab_pin.sym} 72500 -33730 0 0 {name=p71752 lab=clkbuf_9_501_0_CLK/A }
C {devices/lab_pin.sym} 72580 -33730 0 1 {name=p71753 lab=clkbuf_9_500_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 72540 -33730 0 0 {name=Xclkbuf_9_500_0_CLK }
C {devices/lab_pin.sym} 72460 -33630 0 0 {name=p71754 lab=_69822_/X }
C {devices/lab_pin.sym} 72460 -33590 0 0 {name=p71755 lab=_69824_/X }
C {devices/lab_pin.sym} 72460 -33550 0 0 {name=p71756 lab=_66579_/X }
C {devices/lab_pin.sym} 72620 -33590 0 1 {name=p71757 lab=_69825_/X }
C {sky130_stdcells/a21o_4.sym} 72540 -33590 0 0 {name=X_69825_ }
C {devices/lab_pin.sym} 72460 -33470 0 0 {name=p71758 lab=_86249_/Q }
C {devices/lab_pin.sym} 72460 -33430 0 0 {name=p71759 lab=_50162_/X }
C {devices/lab_pin.sym} 72460 -33390 0 0 {name=p71760 lab=_50173_/Y }
C {devices/lab_pin.sym} 72620 -33430 0 1 {name=p71761 lab=_50174_/Y }
C {sky130_stdcells/o21ai_4.sym} 72540 -33430 0 0 {name=X_50174_ }
C {devices/lab_pin.sym} 72450 -33290 0 0 {name=p71762 lab=_86500_/CLK }
C {devices/lab_pin.sym} 72450 -33270 0 0 {name=p71763 lab=_85871_/D }
C {devices/lab_pin.sym} 72630 -33290 0 1 {name=p71764 lab=_85871_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -33280 0 0 {name=X_85871_ }
C {devices/lab_pin.sym} 72450 -33150 0 0 {name=p71765 lab=_82899_/CLK }
C {devices/lab_pin.sym} 72450 -33130 0 0 {name=p71766 lab=_87610_/D }
C {devices/lab_pin.sym} 72630 -33150 0 1 {name=p71767 lab=_87610_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -33140 0 0 {name=X_87610_ }
C {devices/lab_pin.sym} 72450 -33010 0 0 {name=p71768 lab=_84869_/CLK }
C {devices/lab_pin.sym} 72450 -32990 0 0 {name=p71769 lab=_58549_/Y }
C {devices/lab_pin.sym} 72630 -33010 0 1 {name=p71770 lab=_58546_/A }
C {sky130_stdcells/dfxtp_4.sym} 72540 -33000 0 0 {name=X_84822_ }
C {devices/lab_pin.sym} 72500 -32870 0 0 {name=p71771 lab=_57770_/A }
C {devices/lab_pin.sym} 72580 -32870 0 1 {name=p71772 lab=_58796_/A }
C {sky130_stdcells/buf_2.sym} 72540 -32870 0 0 {name=X_57770_ }
C {devices/lab_pin.sym} 72480 -32760 0 0 {name=p71773 lab=_69770_/A }
C {devices/lab_pin.sym} 72480 -32720 0 0 {name=p71774 lab=_69756_/B }
C {devices/lab_pin.sym} 72600 -32740 0 1 {name=p71775 lab=_69756_/X }
C {sky130_stdcells/and2_4.sym} 72540 -32740 0 0 {name=X_69756_ }
C {devices/lab_pin.sym} 72460 -32630 0 0 {name=p71776 lab=_85341_/Q }
C {devices/lab_pin.sym} 72460 -32590 0 0 {name=p71777 lab=_54967_/X }
C {devices/lab_pin.sym} 72460 -32550 0 0 {name=p71778 lab=_54981_/Y }
C {devices/lab_pin.sym} 72620 -32590 0 1 {name=p71779 lab=_54982_/Y }
C {sky130_stdcells/o21ai_4.sym} 72540 -32590 0 0 {name=X_54982_ }
C {devices/lab_pin.sym} 72460 -32470 0 0 {name=p71780 lab=_66965_/X }
C {devices/lab_pin.sym} 72460 -32430 0 0 {name=p71781 lab=_66967_/X }
C {devices/lab_pin.sym} 72460 -32390 0 0 {name=p71782 lab=_66658_/X }
C {devices/lab_pin.sym} 72620 -32430 0 1 {name=p71783 lab=_66968_/Y }
C {sky130_stdcells/a21oi_4.sym} 72540 -32430 0 0 {name=X_66968_ }
C {devices/lab_pin.sym} 72480 -32320 0 0 {name=p71784 lab=_56721_/A }
C {devices/lab_pin.sym} 72480 -32280 0 0 {name=p71785 lab=_56651_/Y }
C {devices/lab_pin.sym} 72480 -32240 0 0 {name=p71786 lab=_56655_/Y }
C {devices/lab_pin.sym} 72480 -32200 0 0 {name=p71787 lab=_56721_/D }
C {devices/lab_pin.sym} 72600 -32260 0 1 {name=p71788 lab=_56721_/Y }
C {sky130_stdcells/nor4_4.sym} 72540 -32260 0 0 {name=X_56721_ }
C {devices/lab_pin.sym} 72500 -32110 0 0 {name=p71789 lab=_68059_/A }
C {devices/lab_pin.sym} 72580 -32110 0 1 {name=p71790 lab=_68707_/X }
C {sky130_stdcells/buf_2.sym} 72540 -32110 0 0 {name=X_68707_ }
C {devices/lab_pin.sym} 72450 -31990 0 0 {name=p71791 lab=_88085_/CLK }
C {devices/lab_pin.sym} 72450 -31970 0 0 {name=p71792 lab=_87541_/D }
C {devices/lab_pin.sym} 72630 -31990 0 1 {name=p71793 lab=_43201_/A }
C {sky130_stdcells/dfxtp_4.sym} 72540 -31980 0 0 {name=X_87541_ }
C {devices/lab_pin.sym} 72460 -31870 0 0 {name=p71794 lab=_85539_/Q }
C {devices/lab_pin.sym} 72460 -31830 0 0 {name=p71795 lab=_53921_/X }
C {devices/lab_pin.sym} 72460 -31790 0 0 {name=p71796 lab=_53932_/Y }
C {devices/lab_pin.sym} 72620 -31830 0 1 {name=p71797 lab=_53933_/Y }
C {sky130_stdcells/o21ai_4.sym} 72540 -31830 0 0 {name=X_53933_ }
C {devices/lab_pin.sym} 72480 -31700 0 0 {name=p71798 lab=_65763_/A }
C {devices/lab_pin.sym} 72480 -31660 0 0 {name=p71799 lab=_73583_/B }
C {devices/lab_pin.sym} 72600 -31680 0 1 {name=p71800 lab=_65919_/X }
C {sky130_stdcells/and2_4.sym} 72540 -31680 0 0 {name=X_65919_ }
C {devices/lab_pin.sym} 72450 -31550 0 0 {name=p71801 lab=_84760_/CLK }
C {devices/lab_pin.sym} 72450 -31530 0 0 {name=p71802 lab=_59303_/Y }
C {devices/lab_pin.sym} 72630 -31550 0 1 {name=p71803 lab=_84753_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -31540 0 0 {name=X_84753_ }
C {devices/lab_pin.sym} 72450 -31410 0 0 {name=p71804 lab=_82299_/CLK }
C {devices/lab_pin.sym} 72450 -31390 0 0 {name=p71805 lab=_83893_/Q }
C {devices/lab_pin.sym} 72630 -31410 0 1 {name=p71806 lab=_81965_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -31400 0 0 {name=X_81965_ }
C {devices/lab_pin.sym} 72480 -31280 0 0 {name=p71807 lab=_69687_/A }
C {devices/lab_pin.sym} 72480 -31240 0 0 {name=p71808 lab=_42564_/Y }
C {devices/lab_pin.sym} 72600 -31260 0 1 {name=p71809 lab=_69687_/Y }
C {sky130_stdcells/nor2_4.sym} 72540 -31260 0 0 {name=X_69687_ }
C {devices/lab_pin.sym} 72500 -31130 0 0 {name=p71810 lab=_66898_/X }
C {devices/lab_pin.sym} 72580 -31130 0 1 {name=p71811 lab=_66899_/X }
C {sky130_stdcells/buf_2.sym} 72540 -31130 0 0 {name=X_66899_ }
C {devices/lab_pin.sym} 72450 -31010 0 0 {name=p71812 lab=_85428_/CLK }
C {devices/lab_pin.sym} 72450 -30990 0 0 {name=p71813 lab=_70770_/Y }
C {devices/lab_pin.sym} 72630 -31010 0 1 {name=p71814 lab=_47077_/A }
C {sky130_stdcells/dfxtp_4.sym} 72540 -31000 0 0 {name=X_83704_ }
C {devices/lab_pin.sym} 72480 -30880 0 0 {name=p71815 lab=_59439_/Y }
C {devices/lab_pin.sym} 72480 -30840 0 0 {name=p71816 lab=_59424_/B }
C {devices/lab_pin.sym} 72600 -30860 0 1 {name=p71817 lab=_59440_/Y }
C {sky130_stdcells/nand2_4.sym} 72540 -30860 0 0 {name=X_59440_ }
C {devices/lab_pin.sym} 72450 -30730 0 0 {name=p71818 lab=_81507_/CLK }
C {devices/lab_pin.sym} 72450 -30710 0 0 {name=p71819 lab=_80916_/D }
C {devices/lab_pin.sym} 72630 -30730 0 1 {name=p71820 lab=_75732_/A }
C {sky130_stdcells/dfxtp_4.sym} 72540 -30720 0 0 {name=X_80916_ }
C {devices/lab_pin.sym} 72480 -30600 0 0 {name=p71821 lab=_83325_/Q }
C {devices/lab_pin.sym} 72480 -30560 0 0 {name=p71822 lab=_83324_/Q }
C {devices/lab_pin.sym} 72600 -30580 0 1 {name=p71823 lab=_57131_/A }
C {sky130_stdcells/nand2_4.sym} 72540 -30580 0 0 {name=X_56652_ }
C {devices/lab_pin.sym} 72450 -30450 0 0 {name=p71824 lab=_87472_/CLK }
C {devices/lab_pin.sym} 72450 -30430 0 0 {name=p71825 lab=_87472_/D }
C {devices/lab_pin.sym} 72630 -30450 0 1 {name=p71826 lab=_87472_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -30440 0 0 {name=X_87472_ }
C {devices/lab_pin.sym} 72480 -30320 0 0 {name=p71827 lab=_69086_/A }
C {devices/lab_pin.sym} 72480 -30280 0 0 {name=p71828 lab=_73822_/A }
C {devices/lab_pin.sym} 72600 -30300 0 1 {name=p71829 lab=_68638_/X }
C {sky130_stdcells/and2_4.sym} 72540 -30300 0 0 {name=X_68638_ }
C {devices/lab_pin.sym} 72460 -30190 0 0 {name=p71830 lab=_53861_/Y }
C {devices/lab_pin.sym} 72460 -30150 0 0 {name=p71831 lab=_53862_/X }
C {devices/lab_pin.sym} 72460 -30110 0 0 {name=p71832 lab=_53863_/Y }
C {devices/lab_pin.sym} 72620 -30150 0 1 {name=p71833 lab=_53864_/Y }
C {sky130_stdcells/a21boi_4.sym} 72540 -30150 0 0 {name=X_53864_ }
C {devices/lab_pin.sym} 72450 -30010 0 0 {name=p71834 lab=_84329_/CLK }
C {devices/lab_pin.sym} 72450 -29990 0 0 {name=p71835 lab=_59869_/Y }
C {devices/lab_pin.sym} 72630 -30010 0 1 {name=p71836 lab=_80294_/B }
C {sky130_stdcells/dfxtp_4.sym} 72540 -30000 0 0 {name=X_84684_ }
C {devices/lab_pin.sym} 72450 -29870 0 0 {name=p71837 lab=_82139_/CLK }
C {devices/lab_pin.sym} 72450 -29850 0 0 {name=p71838 lab=_77322_/X }
C {devices/lab_pin.sym} 72630 -29870 0 1 {name=p71839 lab=_77222_/B }
C {sky130_stdcells/dfxtp_4.sym} 72540 -29860 0 0 {name=X_81896_ }
C {devices/lab_pin.sym} 72500 -29730 0 0 {name=p71840 lab=clkbuf_9_204_0_CLK/X }
C {devices/lab_pin.sym} 72580 -29730 0 1 {name=p71841 lab=_83514_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 72540 -29730 0 0 {name=Xclkbuf_10_409_0_CLK }
C {devices/lab_pin.sym} 72480 -29640 0 0 {name=p71842 lab=_55570_/X }
C {devices/lab_pin.sym} 72480 -29600 0 0 {name=p71843 lab=_72648_/C }
C {devices/lab_pin.sym} 72480 -29560 0 0 {name=p71844 lab=_72643_/C }
C {devices/lab_pin.sym} 72480 -29520 0 0 {name=p71845 lab=_72641_/C }
C {devices/lab_pin.sym} 72600 -29580 0 1 {name=p71846 lab=_55603_/X }
C {sky130_stdcells/and4_4.sym} 72540 -29580 0 0 {name=X_55603_ }
C {devices/lab_pin.sym} 72450 -29430 0 0 {name=p71847 lab=_86422_/CLK }
C {devices/lab_pin.sym} 72450 -29410 0 0 {name=p71848 lab=_49260_/Y }
C {devices/lab_pin.sym} 72630 -29430 0 1 {name=p71849 lab=_86423_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -29420 0 0 {name=X_86423_ }
C {devices/lab_pin.sym} 72500 -29290 0 0 {name=p71850 lab=_49793_/A }
C {devices/lab_pin.sym} 72580 -29290 0 1 {name=p71851 lab=_53221_/A }
C {sky130_stdcells/buf_2.sym} 72540 -29290 0 0 {name=X_52815_ }
C {devices/lab_pin.sym} 72460 -29190 0 0 {name=p71852 lab=_59367_/Y }
C {devices/lab_pin.sym} 72460 -29150 0 0 {name=p71853 lab=_59370_/Y }
C {devices/lab_pin.sym} 72460 -29110 0 0 {name=p71854 lab=_59297_/X }
C {devices/lab_pin.sym} 72620 -29150 0 1 {name=p71855 lab=_59371_/X }
C {sky130_stdcells/a21o_4.sym} 72540 -29150 0 0 {name=X_59371_ }
C {devices/lab_pin.sym} 72450 -29010 0 0 {name=p71856 lab=_86122_/CLK }
C {devices/lab_pin.sym} 72450 -28990 0 0 {name=p71857 lab=_71007_/Y }
C {devices/lab_pin.sym} 72630 -29010 0 1 {name=p71858 lab=_83635_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -29000 0 0 {name=X_83635_ }
C {devices/lab_pin.sym} 72480 -28880 0 0 {name=p71859 lab=_72643_/C }
C {devices/lab_pin.sym} 72480 -28840 0 0 {name=p71860 lab=_56583_/B }
C {devices/lab_pin.sym} 72600 -28860 0 1 {name=p71861 lab=_56583_/X }
C {sky130_stdcells/xor2_4.sym} 72540 -28860 0 0 {name=X_56583_ }
C {devices/lab_pin.sym} 72450 -28730 0 0 {name=p71862 lab=_81130_/CLK }
C {devices/lab_pin.sym} 72450 -28710 0 0 {name=p71863 lab=_80847_/D }
C {devices/lab_pin.sym} 72630 -28730 0 1 {name=p71864 lab=_74945_/B }
C {sky130_stdcells/dfxtp_4.sym} 72540 -28720 0 0 {name=X_80847_ }
C {devices/lab_pin.sym} 72460 -28610 0 0 {name=p71865 lab=_68566_/X }
C {devices/lab_pin.sym} 72460 -28570 0 0 {name=p71866 lab=_68568_/X }
C {devices/lab_pin.sym} 72460 -28530 0 0 {name=p71867 lab=_68442_/X }
C {devices/lab_pin.sym} 72620 -28570 0 1 {name=p71868 lab=_68574_/A }
C {sky130_stdcells/a21o_4.sym} 72540 -28570 0 0 {name=X_68569_ }
C {devices/lab_pin.sym} 72460 -28450 0 0 {name=p71869 lab=_53792_/Y }
C {devices/lab_pin.sym} 72460 -28410 0 0 {name=p71870 lab=_53696_/X }
C {devices/lab_pin.sym} 72460 -28370 0 0 {name=p71871 lab=_53794_/Y }
C {devices/lab_pin.sym} 72620 -28410 0 1 {name=p71872 lab=_85567_/D }
C {sky130_stdcells/a21boi_4.sym} 72540 -28410 0 0 {name=X_53795_ }
C {devices/lab_pin.sym} 72500 -28270 0 0 {name=p71873 lab=clkbuf_6_0_0_CLK/X }
C {devices/lab_pin.sym} 72580 -28270 0 1 {name=p71874 lab=clkbuf_8_1_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 72540 -28270 0 0 {name=Xclkbuf_7_0_0_CLK }
C {devices/lab_pin.sym} 72460 -28170 0 0 {name=p71875 lab=_52973_/B }
C {devices/lab_pin.sym} 72460 -28130 0 0 {name=p71876 lab=_70584_/X }
C {devices/lab_pin.sym} 72460 -28090 0 0 {name=p71877 lab=_70599_/Y }
C {devices/lab_pin.sym} 72620 -28130 0 1 {name=p71878 lab=_83744_/D }
C {sky130_stdcells/o21ai_4.sym} 72540 -28130 0 0 {name=X_70600_ }
C {devices/lab_pin.sym} 72500 -27990 0 0 {name=p71879 lab=_58322_/A }
C {devices/lab_pin.sym} 72580 -27990 0 1 {name=p71880 lab=_58322_/Y }
C {sky130_stdcells/inv_2.sym} 72540 -27990 0 0 {name=X_58322_ }
C {devices/lab_pin.sym} 72480 -27880 0 0 {name=p71881 lab=_55534_/A }
C {devices/lab_pin.sym} 72480 -27840 0 0 {name=p71882 lab=_56627_/B }
C {devices/lab_pin.sym} 72600 -27860 0 1 {name=p71883 lab=_55534_/X }
C {sky130_stdcells/and2_4.sym} 72540 -27860 0 0 {name=X_55534_ }
C {devices/lab_pin.sym} 72450 -27730 0 0 {name=p71884 lab=_86353_/CLK }
C {devices/lab_pin.sym} 72450 -27710 0 0 {name=p71885 lab=_86354_/D }
C {devices/lab_pin.sym} 72630 -27730 0 1 {name=p71886 lab=_86354_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -27720 0 0 {name=X_86354_ }
C {devices/lab_pin.sym} 72480 -27600 0 0 {name=p71887 lab=_40760_/A }
C {devices/lab_pin.sym} 72480 -27560 0 0 {name=p71888 lab=_40760_/B }
C {devices/lab_pin.sym} 72600 -27580 0 1 {name=p71889 lab=_40760_/X }
C {sky130_stdcells/or2_4.sym} 72540 -27580 0 0 {name=X_40760_ }
C {devices/lab_pin.sym} 72480 -27480 0 0 {name=p71890 lab=_52729_/X }
C {devices/lab_pin.sym} 72480 -27440 0 0 {name=p71891 lab=_52746_/B }
C {devices/lab_pin.sym} 72480 -27400 0 0 {name=p71892 lab=_52746_/C }
C {devices/lab_pin.sym} 72480 -27360 0 0 {name=p71893 lab=_52746_/D }
C {devices/lab_pin.sym} 72600 -27420 0 1 {name=p71894 lab=_52746_/X }
C {sky130_stdcells/and4_4.sym} 72540 -27420 0 0 {name=X_52746_ }
C {devices/lab_pin.sym} 72500 -27270 0 0 {name=p71895 lab=_71580_/A }
C {devices/lab_pin.sym} 72580 -27270 0 1 {name=p71896 lab=_71581_/A }
C {sky130_stdcells/inv_2.sym} 72540 -27270 0 0 {name=X_71580_ }
C {devices/lab_pin.sym} 72450 -27150 0 0 {name=p71897 lab=_83311_/CLK }
C {devices/lab_pin.sym} 72450 -27130 0 0 {name=p71898 lab=_71227_/Y }
C {devices/lab_pin.sym} 72630 -27150 0 1 {name=p71899 lab=_48659_/A }
C {sky130_stdcells/dfxtp_4.sym} 72540 -27140 0 0 {name=X_83566_ }
C {devices/lab_pin.sym} 72450 -27010 0 0 {name=p71900 lab=_80849_/CLK }
C {devices/lab_pin.sym} 72450 -26990 0 0 {name=p71901 lab=_75662_/Y }
C {devices/lab_pin.sym} 72630 -27010 0 1 {name=p71902 lab=_80778_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -27000 0 0 {name=X_80778_ }
C {devices/lab_pin.sym} 72450 -26870 0 0 {name=p71903 lab=_85241_/CLK }
C {devices/lab_pin.sym} 72450 -26850 0 0 {name=p71904 lab=_85305_/D }
C {devices/lab_pin.sym} 72630 -26870 0 1 {name=p71905 lab=_55913_/B }
C {sky130_stdcells/dfxtp_4.sym} 72540 -26860 0 0 {name=X_85305_ }
C {devices/lab_pin.sym} 72480 -26750 0 0 {name=p71906 lab=_71507_/A }
C {devices/lab_pin.sym} 72480 -26710 0 0 {name=p71907 lab=_70530_/Y }
C {devices/lab_pin.sym} 72480 -26670 0 0 {name=p71908 lab=_70361_/A }
C {devices/lab_pin.sym} 72600 -26710 0 1 {name=p71909 lab=_70531_/Y }
C {sky130_stdcells/nor3_4.sym} 72540 -26710 0 0 {name=X_70531_ }
C {devices/lab_pin.sym} 72450 -26570 0 0 {name=p71910 lab=_82532_/CLK }
C {devices/lab_pin.sym} 72450 -26550 0 0 {name=p71911 lab=_82517_/D }
C {devices/lab_pin.sym} 72630 -26570 0 1 {name=p71912 lab=_82517_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -26560 0 0 {name=X_82517_ }
C {devices/lab_pin.sym} 72500 -26430 0 0 {name=p71913 lab=_58253_/A }
C {devices/lab_pin.sym} 72580 -26430 0 1 {name=p71914 lab=_58253_/X }
C {sky130_stdcells/buf_2.sym} 72540 -26430 0 0 {name=X_58253_ }
C {devices/lab_pin.sym} 72460 -26340 0 0 {name=p71915 lab=_45604_/A }
C {devices/lab_pin.sym} 72460 -26300 0 0 {name=p71916 lab=_55462_/X }
C {devices/lab_pin.sym} 72460 -26260 0 0 {name=p71917 lab=_44096_/X }
C {devices/lab_pin.sym} 72460 -26220 0 0 {name=p71918 lab=_55464_/X }
C {devices/lab_pin.sym} 72620 -26280 0 1 {name=p71919 lab=_55465_/X }
C {sky130_stdcells/a211o_4.sym} 72540 -26280 0 0 {name=X_55465_ }
C {devices/lab_pin.sym} 72450 -26130 0 0 {name=p71920 lab=_86282_/CLK }
C {devices/lab_pin.sym} 72450 -26110 0 0 {name=p71921 lab=_86285_/D }
C {devices/lab_pin.sym} 72630 -26130 0 1 {name=p71922 lab=_72366_/B }
C {sky130_stdcells/dfxtp_4.sym} 72540 -26120 0 0 {name=X_86285_ }
C {devices/lab_pin.sym} 72500 -25990 0 0 {name=p71923 lab=_40691_/A }
C {devices/lab_pin.sym} 72580 -25990 0 1 {name=p71924 lab=_40691_/X }
C {sky130_stdcells/buf_2.sym} 72540 -25990 0 0 {name=X_40691_ }
C {devices/lab_pin.sym} 72480 -25880 0 0 {name=p71925 lab=_52657_/X }
C {devices/lab_pin.sym} 72480 -25840 0 0 {name=p71926 lab=_52677_/B }
C {devices/lab_pin.sym} 72600 -25860 0 1 {name=p71927 lab=_52677_/Y }
C {sky130_stdcells/nand2_4.sym} 72540 -25860 0 0 {name=X_52677_ }
C {devices/lab_pin.sym} 72450 -25730 0 0 {name=p71928 lab=_84939_/CLK }
C {devices/lab_pin.sym} 72450 -25710 0 0 {name=p71929 lab=_71443_/Y }
C {devices/lab_pin.sym} 72630 -25730 0 1 {name=p71930 lab=_83497_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -25720 0 0 {name=X_83497_ }
C {devices/lab_pin.sym} 72460 -25620 0 0 {name=p71931 lab=_56857_/X }
C {devices/lab_pin.sym} 72460 -25580 0 0 {name=p71932 lab=_57129_/A }
C {devices/lab_pin.sym} 72460 -25540 0 0 {name=p71933 lab=_56863_/X }
C {devices/lab_pin.sym} 72460 -25500 0 0 {name=p71934 lab=_57198_/B }
C {devices/lab_pin.sym} 72620 -25560 0 1 {name=p71935 lab=_57204_/X }
C {sky130_stdcells/a211o_4.sym} 72540 -25560 0 0 {name=X_57204_ }
C {devices/lab_pin.sym} 72500 -25410 0 0 {name=p71936 lab=clkbuf_8_83_0_CLK/A }
C {devices/lab_pin.sym} 72580 -25410 0 1 {name=p71937 lab=clkbuf_8_83_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 72540 -25410 0 0 {name=Xclkbuf_8_83_0_CLK }
C {devices/lab_pin.sym} 72450 -25290 0 0 {name=p71938 lab=_87249_/CLK }
C {devices/lab_pin.sym} 72450 -25270 0 0 {name=p71939 lab=_88024_/D }
C {devices/lab_pin.sym} 72630 -25290 0 1 {name=p71940 lab=_88024_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -25280 0 0 {name=X_88024_ }
C {devices/lab_pin.sym} 72500 -25150 0 0 {name=p71941 lab=_42574_/A }
C {devices/lab_pin.sym} 72580 -25150 0 1 {name=p71942 lab=_42430_/X }
C {sky130_stdcells/buf_2.sym} 72540 -25150 0 0 {name=X_42430_ }
C {devices/lab_pin.sym} 72460 -25050 0 0 {name=p71943 lab=_85446_/Q }
C {devices/lab_pin.sym} 72460 -25010 0 0 {name=p71944 lab=_54404_/X }
C {devices/lab_pin.sym} 72460 -24970 0 0 {name=p71945 lab=_54415_/Y }
C {devices/lab_pin.sym} 72620 -25010 0 1 {name=p71946 lab=_54416_/Y }
C {sky130_stdcells/o21ai_4.sym} 72540 -25010 0 0 {name=X_54416_ }
C {devices/lab_pin.sym} 72500 -24870 0 0 {name=p71947 lab=_73250_/A }
C {devices/lab_pin.sym} 72580 -24870 0 1 {name=p71948 lab=_73250_/X }
C {sky130_stdcells/buf_2.sym} 72540 -24870 0 0 {name=X_73250_ }
C {devices/lab_pin.sym} 72450 -24750 0 0 {name=p71949 lab=_86900_/CLK }
C {devices/lab_pin.sym} 72450 -24730 0 0 {name=p71950 lab=_85236_/D }
C {devices/lab_pin.sym} 72630 -24750 0 1 {name=p71951 lab=_55865_/B }
C {sky130_stdcells/dfxtp_4.sym} 72540 -24740 0 0 {name=X_85236_ }
C {devices/lab_pin.sym} 72460 -24630 0 0 {name=p71952 lab=_85975_/Q }
C {devices/lab_pin.sym} 72460 -24590 0 0 {name=p71953 lab=_51621_/X }
C {devices/lab_pin.sym} 72460 -24550 0 0 {name=p71954 lab=_51627_/Y }
C {devices/lab_pin.sym} 72620 -24590 0 1 {name=p71955 lab=_51628_/Y }
C {sky130_stdcells/o21ai_4.sym} 72540 -24590 0 0 {name=X_51628_ }
C {devices/lab_pin.sym} 72500 -24450 0 0 {name=p71956 lab=_71483_/B }
C {devices/lab_pin.sym} 72580 -24450 0 1 {name=p71957 lab=_71500_/C }
C {sky130_stdcells/buf_2.sym} 72540 -24450 0 0 {name=X_70462_ }
C {devices/lab_pin.sym} 72480 -24340 0 0 {name=p71958 lab=_58184_/A }
C {devices/lab_pin.sym} 72480 -24300 0 0 {name=p71959 lab=_58184_/B }
C {devices/lab_pin.sym} 72600 -24320 0 1 {name=p71960 lab=_58184_/Y }
C {sky130_stdcells/nor2_4.sym} 72540 -24320 0 0 {name=X_58184_ }
C {devices/lab_pin.sym} 72450 -24190 0 0 {name=p71961 lab=_82828_/CLK }
C {devices/lab_pin.sym} 72450 -24170 0 0 {name=p71962 lab=_79140_/X }
C {devices/lab_pin.sym} 72630 -24190 0 1 {name=p71963 lab=_82448_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -24180 0 0 {name=X_82448_ }
C {devices/lab_pin.sym} 72480 -24060 0 0 {name=p71964 lab=_55373_/Y }
C {devices/lab_pin.sym} 72480 -24020 0 0 {name=p71965 lab=_55396_/B }
C {devices/lab_pin.sym} 72600 -24040 0 1 {name=p71966 lab=_55409_/A }
C {sky130_stdcells/nand2_4.sym} 72540 -24040 0 0 {name=X_55396_ }
C {devices/lab_pin.sym} 72500 -23910 0 0 {name=p71967 lab=_72201_/A }
C {devices/lab_pin.sym} 72580 -23910 0 1 {name=p71968 lab=_72201_/X }
C {sky130_stdcells/buf_2.sym} 72540 -23910 0 0 {name=X_72201_ }
C {devices/lab_pin.sym} 72480 -23800 0 0 {name=p71969 lab=_57134_/Y }
C {devices/lab_pin.sym} 72480 -23760 0 0 {name=p71970 lab=_56685_/X }
C {devices/lab_pin.sym} 72600 -23780 0 1 {name=p71971 lab=_57135_/Y }
C {sky130_stdcells/nor2_4.sym} 72540 -23780 0 0 {name=X_57135_ }
C {devices/lab_pin.sym} 72460 -23680 0 0 {name=p71972 lab=_41741_/X }
C {devices/lab_pin.sym} 72460 -23640 0 0 {name=p71973 lab=_42356_/X }
C {devices/lab_pin.sym} 72460 -23600 0 0 {name=p71974 lab=_87902_/Q }
C {devices/lab_pin.sym} 72460 -23560 0 0 {name=p71975 lab=_42357_/X }
C {devices/lab_pin.sym} 72620 -23620 0 1 {name=p71976 lab=_87902_/D }
C {sky130_stdcells/a2bb2o_4.sym} 72540 -23620 0 0 {name=X_42361_ }
C {devices/lab_pin.sym} 72480 -23500 0 0 {name=p71977 lab=_54362_/A }
C {devices/lab_pin.sym} 72480 -23460 0 0 {name=p71978 lab=_54353_/B }
C {devices/lab_pin.sym} 72480 -23420 0 0 {name=p71979 lab=_54362_/C }
C {devices/lab_pin.sym} 72480 -23380 0 0 {name=p71980 lab=_46753_/Y }
C {devices/lab_pin.sym} 72600 -23440 0 1 {name=p71981 lab=_54347_/X }
C {sky130_stdcells/and4_4.sym} 72540 -23440 0 0 {name=X_54347_ }
C {devices/lab_pin.sym} 72480 -23300 0 0 {name=p71982 lab=_73181_/A }
C {devices/lab_pin.sym} 72480 -23260 0 0 {name=p71983 lab=_85873_/Q }
C {devices/lab_pin.sym} 72600 -23280 0 1 {name=p71984 lab=_73181_/X }
C {sky130_stdcells/and2_4.sym} 72540 -23280 0 0 {name=X_73181_ }
C {devices/lab_pin.sym} 72450 -23150 0 0 {name=p71985 lab=_85167_/CLK }
C {devices/lab_pin.sym} 72450 -23130 0 0 {name=p71986 lab=_56514_/Y }
C {devices/lab_pin.sym} 72630 -23150 0 1 {name=p71987 lab=_55823_/B }
C {sky130_stdcells/dfxtp_4.sym} 72540 -23140 0 0 {name=X_85167_ }
C {devices/lab_pin.sym} 72480 -23040 0 0 {name=p71988 lab=_51553_/A }
C {devices/lab_pin.sym} 72480 -23000 0 0 {name=p71989 lab=_51580_/B }
C {devices/lab_pin.sym} 72480 -22960 0 0 {name=p71990 lab=_51553_/C }
C {devices/lab_pin.sym} 72480 -22920 0 0 {name=p71991 lab=_53084_/D }
C {devices/lab_pin.sym} 72600 -22980 0 1 {name=p71992 lab=_51559_/X }
C {sky130_stdcells/and4_4.sym} 72540 -22980 0 0 {name=X_51559_ }
C {devices/lab_pin.sym} 72450 -22830 0 0 {name=p71993 lab=_86054_/CLK }
C {devices/lab_pin.sym} 72450 -22810 0 0 {name=p71994 lab=_82187_/Q }
C {devices/lab_pin.sym} 72630 -22830 0 1 {name=p71995 lab=_82379_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -22820 0 0 {name=X_82379_ }
C {devices/lab_pin.sym} 72500 -22690 0 0 {name=p71996 lab=DATA_TO_HASH[2] }
C {devices/lab_pin.sym} 72580 -22690 0 1 {name=p71997 lab=_70819_/A }
C {sky130_stdcells/buf_2.sym} 72540 -22690 0 0 {name=X_70393_ }
C {devices/lab_pin.sym} 72500 -22570 0 0 {name=p71998 lab=_44099_/X }
C {devices/lab_pin.sym} 72580 -22570 0 1 {name=p71999 lab=_44101_/A }
C {sky130_stdcells/buf_2.sym} 72540 -22570 0 0 {name=X_44100_ }
C {devices/lab_pin.sym} 72500 -22450 0 0 {name=p72000 lab=_41311_/Y }
C {devices/lab_pin.sym} 72580 -22450 0 1 {name=p72001 lab=_41312_/X }
C {sky130_stdcells/buf_2.sym} 72540 -22450 0 0 {name=X_41312_ }
C {devices/lab_pin.sym} 72460 -22350 0 0 {name=p72002 lab=_59331_/X }
C {devices/lab_pin.sym} 72460 -22310 0 0 {name=p72003 lab=_85376_/Q }
C {devices/lab_pin.sym} 72460 -22270 0 0 {name=p72004 lab=_72131_/X }
C {devices/lab_pin.sym} 72620 -22310 0 1 {name=p72005 lab=_72132_/Y }
C {sky130_stdcells/o21ai_4.sym} 72540 -22310 0 0 {name=X_72132_ }
C {devices/lab_pin.sym} 72450 -22170 0 0 {name=p72006 lab=_84166_/CLK }
C {devices/lab_pin.sym} 72450 -22150 0 0 {name=p72007 lab=_84118_/D }
C {devices/lab_pin.sym} 72630 -22170 0 1 {name=p72008 lab=_84118_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -22160 0 0 {name=X_84118_ }
C {devices/lab_pin.sym} 72460 -22050 0 0 {name=p72009 lab=_55889_/B }
C {devices/lab_pin.sym} 72460 -22010 0 0 {name=p72010 lab=_45044_/X }
C {devices/lab_pin.sym} 72460 -21970 0 0 {name=p72011 lab=_45079_/X }
C {devices/lab_pin.sym} 72620 -22010 0 1 {name=p72012 lab=_45080_/X }
C {sky130_stdcells/o21a_4.sym} 72540 -22010 0 0 {name=X_45080_ }
C {devices/lab_pin.sym} 72500 -21870 0 0 {name=p72013 lab=_56912_/A }
C {devices/lab_pin.sym} 72580 -21870 0 1 {name=p72014 lab=_57289_/B }
C {sky130_stdcells/buf_2.sym} 72540 -21870 0 0 {name=X_57066_ }
C {devices/lab_pin.sym} 72460 -21780 0 0 {name=p72015 lab=_41556_/X }
C {devices/lab_pin.sym} 72460 -21740 0 0 {name=p72016 lab=_42290_/X }
C {devices/lab_pin.sym} 72460 -21700 0 0 {name=p72017 lab=_87937_/Q }
C {devices/lab_pin.sym} 72460 -21660 0 0 {name=p72018 lab=_42291_/X }
C {devices/lab_pin.sym} 72620 -21720 0 1 {name=p72019 lab=_42292_/X }
C {sky130_stdcells/a2bb2o_4.sym} 72540 -21720 0 0 {name=X_42292_ }
C {devices/lab_pin.sym} 72460 -21590 0 0 {name=p72020 lab=_85471_/Q }
C {devices/lab_pin.sym} 72460 -21550 0 0 {name=p72021 lab=_54266_/X }
C {devices/lab_pin.sym} 72460 -21510 0 0 {name=p72022 lab=_54277_/Y }
C {devices/lab_pin.sym} 72620 -21550 0 1 {name=p72023 lab=_54278_/Y }
C {sky130_stdcells/o21ai_4.sym} 72540 -21550 0 0 {name=X_54278_ }
C {devices/lab_pin.sym} 72450 -21410 0 0 {name=p72024 lab=_85031_/CLK }
C {devices/lab_pin.sym} 72450 -21390 0 0 {name=p72025 lab=_85098_/D }
C {devices/lab_pin.sym} 72630 -21410 0 1 {name=p72026 lab=_85098_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -21400 0 0 {name=X_85098_ }
C {devices/lab_pin.sym} 72500 -21270 0 0 {name=p72027 lab=clkbuf_8_99_0_CLK/A }
C {devices/lab_pin.sym} 72580 -21270 0 1 {name=p72028 lab=clkbuf_8_98_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 72540 -21270 0 0 {name=Xclkbuf_8_98_0_CLK }
C {devices/lab_pin.sym} 72500 -21150 0 0 {name=p72029 lab=_72255_/A }
C {devices/lab_pin.sym} 72580 -21150 0 1 {name=p72030 lab=_44031_/X }
C {sky130_stdcells/buf_2.sym} 72540 -21150 0 0 {name=X_44031_ }
C {devices/lab_pin.sym} 72480 -21050 0 0 {name=p72031 lab=_56177_/A }
C {devices/lab_pin.sym} 72480 -21010 0 0 {name=p72032 lab=_56017_/B }
C {devices/lab_pin.sym} 72480 -20970 0 0 {name=p72033 lab=_85311_/Q }
C {devices/lab_pin.sym} 72600 -21010 0 1 {name=p72034 lab=_56017_/Y }
C {sky130_stdcells/nand3_4.sym} 72540 -21010 0 0 {name=X_56017_ }
C {devices/lab_pin.sym} 72480 -20880 0 0 {name=p72035 lab=_41068_/B }
C {devices/lab_pin.sym} 72480 -20840 0 0 {name=p72036 lab=_41223_/B }
C {devices/lab_pin.sym} 72600 -20860 0 1 {name=p72037 lab=_41243_/X }
C {sky130_stdcells/or2_4.sym} 72540 -20860 0 0 {name=X_41243_ }
C {devices/lab_pin.sym} 72500 -20730 0 0 {name=p72038 lab=_53282_/A }
C {devices/lab_pin.sym} 72580 -20730 0 1 {name=p72039 lab=_53244_/B }
C {sky130_stdcells/buf_2.sym} 72540 -20730 0 0 {name=X_53229_ }
C {devices/lab_pin.sym} 72460 -20630 0 0 {name=p72040 lab=_83292_/Q }
C {devices/lab_pin.sym} 72460 -20590 0 0 {name=p72041 lab=_72001_/X }
C {devices/lab_pin.sym} 72460 -20550 0 0 {name=p72042 lab=_72062_/Y }
C {devices/lab_pin.sym} 72620 -20590 0 1 {name=p72043 lab=_72063_/Y }
C {sky130_stdcells/o21ai_4.sym} 72540 -20590 0 0 {name=X_72063_ }
C {devices/lab_pin.sym} 72480 -20460 0 0 {name=p72044 lab=_76938_/B }
C {devices/lab_pin.sym} 72480 -20420 0 0 {name=p72045 lab=_76939_/A }
C {devices/lab_pin.sym} 72600 -20440 0 1 {name=p72046 lab=_76953_/A }
C {sky130_stdcells/nand2_4.sym} 72540 -20440 0 0 {name=X_76940_ }
C {devices/lab_pin.sym} 72450 -20310 0 0 {name=p72047 lab=_84049_/CLK }
C {devices/lab_pin.sym} 72450 -20290 0 0 {name=p72048 lab=_84049_/D }
C {devices/lab_pin.sym} 72630 -20310 0 1 {name=p72049 lab=_81481_/D }
C {sky130_stdcells/dfxtp_4.sym} 72540 -20300 0 0 {name=X_84049_ }
C {devices/lab_pin.sym} 72500 -20170 0 0 {name=p72050 lab=_70763_/A }
C {devices/lab_pin.sym} 72580 -20170 0 1 {name=p72051 lab=_71168_/A }
C {sky130_stdcells/buf_2.sym} 72540 -20170 0 0 {name=X_71014_ }
C {devices/lab_pin.sym} 72500 -20050 0 0 {name=p72052 lab=_41173_/X }
C {devices/lab_pin.sym} 72580 -20050 0 1 {name=p72053 lab=_41174_/X }
C {sky130_stdcells/buf_2.sym} 72540 -20050 0 0 {name=X_41174_ }
C {devices/lab_pin.sym} 72480 -19940 0 0 {name=p72054 lab=_76910_/A }
C {devices/lab_pin.sym} 72480 -19900 0 0 {name=p72055 lab=_76870_/Y }
C {devices/lab_pin.sym} 72600 -19920 0 1 {name=p72056 lab=_81466_/D }
C {sky130_stdcells/xor2_4.sym} 72540 -19920 0 0 {name=X_76871_ }
C {devices/lab_pin.sym} 72460 -19810 0 0 {name=p72057 lab=_78596_/Y }
C {devices/lab_pin.sym} 72460 -19770 0 0 {name=p72058 lab=_78608_/Y }
C {devices/lab_pin.sym} 72460 -19730 0 0 {name=p72059 lab=_78609_/Y }
C {devices/lab_pin.sym} 72620 -19770 0 1 {name=p72060 lab=_78610_/X }
C {sky130_stdcells/o21a_4.sym} 72540 -19770 0 0 {name=X_78610_ }
C {devices/lab_pin.sym} 72460 -19650 0 0 {name=p72061 lab=_75811_/A }
C {devices/lab_pin.sym} 72460 -19610 0 0 {name=p72062 lab=_75815_/Y }
C {devices/lab_pin.sym} 72460 -19570 0 0 {name=p72063 lab=_75823_/C }
C {devices/lab_pin.sym} 72620 -19610 0 1 {name=p72064 lab=_75824_/A }
C {sky130_stdcells/a21o_4.sym} 72540 -19610 0 0 {name=X_75822_ }
C {devices/lab_pin.sym} 72500 -19470 0 0 {name=p72065 lab=clkbuf_8_21_0_CLK/A }
C {devices/lab_pin.sym} 72580 -19470 0 1 {name=p72066 lab=clkbuf_9_43_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 72540 -19470 0 0 {name=Xclkbuf_8_21_0_CLK }
C {devices/lab_pin.sym} 72450 -19350 0 0 {name=p72067 lab=_87814_/CLK }
C {devices/lab_pin.sym} 72450 -19330 0 0 {name=p72068 lab=_42596_/Y }
C {devices/lab_pin.sym} 72630 -19350 0 1 {name=p72069 lab=_87808_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -19340 0 0 {name=X_87808_ }
C {devices/lab_pin.sym} 72500 -19210 0 0 {name=p72070 lab=_52573_/B }
C {devices/lab_pin.sym} 72580 -19210 0 1 {name=p72071 lab=_48770_/X }
C {sky130_stdcells/buf_2.sym} 72540 -19210 0 0 {name=X_48770_ }
C {devices/lab_pin.sym} 72500 -19090 0 0 {name=p72072 lab=_79572_/Y }
C {devices/lab_pin.sym} 72580 -19090 0 1 {name=p72073 lab=_79590_/Y }
C {sky130_stdcells/inv_2.sym} 72540 -19090 0 0 {name=X_79590_ }
C {devices/lab_pin.sym} 72500 -18970 0 0 {name=p72074 lab=_45981_/X }
C {devices/lab_pin.sym} 72580 -18970 0 1 {name=p72075 lab=_45982_/X }
C {sky130_stdcells/buf_2.sym} 72540 -18970 0 0 {name=X_45982_ }
C {devices/lab_pin.sym} 72460 -18870 0 0 {name=p72076 lab=_57939_/X }
C {devices/lab_pin.sym} 72460 -18830 0 0 {name=p72077 lab=_86000_/Q }
C {devices/lab_pin.sym} 72460 -18790 0 0 {name=p72078 lab=_57967_/X }
C {devices/lab_pin.sym} 72620 -18830 0 1 {name=p72079 lab=_57968_/Y }
C {sky130_stdcells/o21ai_4.sym} 72540 -18830 0 0 {name=X_57968_ }
C {devices/lab_pin.sym} 72500 -18690 0 0 {name=p72080 lab=_81229_/Q }
C {devices/lab_pin.sym} 72580 -18690 0 1 {name=p72081 lab=_47722_/A }
C {sky130_stdcells/inv_2.sym} 72540 -18690 0 0 {name=X_47721_ }
C {devices/lab_pin.sym} 72500 -18570 0 0 {name=p72082 lab=_63001_/A }
C {devices/lab_pin.sym} 72580 -18570 0 1 {name=p72083 lab=_63344_/B }
C {sky130_stdcells/buf_2.sym} 72540 -18570 0 0 {name=X_59707_ }
C {devices/lab_pin.sym} 72460 -18470 0 0 {name=p72084 lab=_78528_/A }
C {devices/lab_pin.sym} 72460 -18430 0 0 {name=p72085 lab=_78528_/B }
C {devices/lab_pin.sym} 72460 -18390 0 0 {name=p72086 lab=_78521_/X }
C {devices/lab_pin.sym} 72620 -18430 0 1 {name=p72087 lab=_78541_/Y }
C {sky130_stdcells/a21boi_4.sym} 72540 -18430 0 0 {name=X_78541_ }
C {devices/lab_pin.sym} 72500 -18290 0 0 {name=p72088 lab=_45252_/A }
C {devices/lab_pin.sym} 72580 -18290 0 1 {name=p72089 lab=_44933_/X }
C {sky130_stdcells/buf_2.sym} 72540 -18290 0 0 {name=X_44933_ }
C {devices/lab_pin.sym} 72480 -18190 0 0 {name=p72090 lab=_56636_/X }
C {devices/lab_pin.sym} 72480 -18150 0 0 {name=p72091 lab=_59498_/A }
C {devices/lab_pin.sym} 72480 -18110 0 0 {name=p72092 lab=_57193_/D }
C {devices/lab_pin.sym} 72600 -18150 0 1 {name=p72093 lab=_56921_/B }
C {sky130_stdcells/nand3_4.sym} 72540 -18150 0 0 {name=X_56919_ }
C {devices/lab_pin.sym} 72500 -18010 0 0 {name=p72094 lab=_75752_/X }
C {devices/lab_pin.sym} 72580 -18010 0 1 {name=p72095 lab=_75753_/Y }
C {sky130_stdcells/inv_2.sym} 72540 -18010 0 0 {name=X_75753_ }
C {devices/lab_pin.sym} 72450 -17890 0 0 {name=p72096 lab=_87487_/CLK }
C {devices/lab_pin.sym} 72450 -17870 0 0 {name=p72097 lab=_42752_/Y }
C {devices/lab_pin.sym} 72630 -17890 0 1 {name=p72098 lab=_87739_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -17880 0 0 {name=X_87739_ }
C {devices/lab_pin.sym} 72460 -17780 0 0 {name=p72099 lab=_72963_/X }
C {devices/lab_pin.sym} 72460 -17740 0 0 {name=p72100 lab=_83074_/Q }
C {devices/lab_pin.sym} 72460 -17700 0 0 {name=p72101 lab=_72785_/X }
C {devices/lab_pin.sym} 72460 -17660 0 0 {name=p72102 lab=_72964_/X }
C {devices/lab_pin.sym} 72620 -17720 0 1 {name=p72103 lab=_72965_/X }
C {sky130_stdcells/a211o_4.sym} 72540 -17720 0 0 {name=X_72965_ }
C {devices/lab_pin.sym} 72500 -17570 0 0 {name=p72104 lab=_58098_/A }
C {devices/lab_pin.sym} 72580 -17570 0 1 {name=p72105 lab=_57899_/X }
C {sky130_stdcells/buf_2.sym} 72540 -17570 0 0 {name=X_57899_ }
C {devices/lab_pin.sym} 72500 -17450 0 0 {name=p72106 lab=_74704_/A }
C {devices/lab_pin.sym} 72580 -17450 0 1 {name=p72107 lab=_74704_/Y }
C {sky130_stdcells/inv_2.sym} 72540 -17450 0 0 {name=X_74704_ }
C {devices/lab_pin.sym} 72500 -17330 0 0 {name=p72108 lab=_47792_/A }
C {devices/lab_pin.sym} 72580 -17330 0 1 {name=p72109 lab=_47692_/B }
C {sky130_stdcells/buf_2.sym} 72540 -17330 0 0 {name=X_47652_ }
C {devices/lab_pin.sym} 72480 -17220 0 0 {name=p72110 lab=_70554_/A }
C {devices/lab_pin.sym} 72480 -17180 0 0 {name=p72111 lab=_71386_/B }
C {devices/lab_pin.sym} 72600 -17200 0 1 {name=p72112 lab=_71916_/Y }
C {sky130_stdcells/nor2_4.sym} 72540 -17200 0 0 {name=X_71916_ }
C {devices/lab_pin.sym} 72500 -17070 0 0 {name=p72113 lab=_59638_/A }
C {devices/lab_pin.sym} 72580 -17070 0 1 {name=p72114 lab=_59651_/A }
C {sky130_stdcells/inv_2.sym} 72540 -17070 0 0 {name=X_59638_ }
C {devices/lab_pin.sym} 72480 -16960 0 0 {name=p72115 lab=_78472_/A }
C {devices/lab_pin.sym} 72480 -16920 0 0 {name=p72116 lab=_82670_/D }
C {devices/lab_pin.sym} 72600 -16940 0 1 {name=p72117 lab=_78472_/X }
C {sky130_stdcells/xor2_4.sym} 72540 -16940 0 0 {name=X_78472_ }
C {devices/lab_pin.sym} 72500 -16810 0 0 {name=p72118 lab=_44863_/Y }
C {devices/lab_pin.sym} 72580 -16810 0 1 {name=p72119 lab=_86913_/D }
C {sky130_stdcells/inv_2.sym} 72540 -16810 0 0 {name=X_44864_ }
C {devices/lab_pin.sym} 72480 -16700 0 0 {name=p72120 lab=_75684_/A }
C {devices/lab_pin.sym} 72480 -16660 0 0 {name=p72121 lab=_75684_/B }
C {devices/lab_pin.sym} 72600 -16680 0 1 {name=p72122 lab=_75684_/Y }
C {sky130_stdcells/nand2_4.sym} 72540 -16680 0 0 {name=X_75684_ }
C {devices/lab_pin.sym} 72480 -16560 0 0 {name=p72123 lab=_87310_/Q }
C {devices/lab_pin.sym} 72480 -16520 0 0 {name=p72124 lab=_72896_/B }
C {devices/lab_pin.sym} 72600 -16540 0 1 {name=p72125 lab=_72896_/Y }
C {sky130_stdcells/nor2_4.sym} 72540 -16540 0 0 {name=X_72896_ }
C {devices/lab_pin.sym} 72500 -16410 0 0 {name=p72126 lab=clkbuf_8_37_0_CLK/A }
C {devices/lab_pin.sym} 72580 -16410 0 1 {name=p72127 lab=clkbuf_9_72_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 72540 -16410 0 0 {name=Xclkbuf_8_36_0_CLK }
C {devices/lab_pin.sym} 72500 -16290 0 0 {name=p72128 lab=_53874_/A }
C {devices/lab_pin.sym} 72580 -16290 0 1 {name=p72129 lab=_46603_/X }
C {sky130_stdcells/buf_2.sym} 72540 -16290 0 0 {name=X_46603_ }
C {devices/lab_pin.sym} 72480 -16180 0 0 {name=p72130 lab=_77423_/A }
C {devices/lab_pin.sym} 72480 -16140 0 0 {name=p72131 lab=_82096_/D }
C {devices/lab_pin.sym} 72600 -16160 0 1 {name=p72132 lab=_77423_/Y }
C {sky130_stdcells/nor2_4.sym} 72540 -16160 0 0 {name=X_77423_ }
C {devices/lab_pin.sym} 72460 -16060 0 0 {name=p72133 lab=_41098_/X }
C {devices/lab_pin.sym} 72460 -16020 0 0 {name=p72134 lab=_43801_/X }
C {devices/lab_pin.sym} 72460 -15980 0 0 {name=p72135 lab=_87254_/Q }
C {devices/lab_pin.sym} 72460 -15940 0 0 {name=p72136 lab=_43802_/X }
C {devices/lab_pin.sym} 72620 -16000 0 1 {name=p72137 lab=_43815_/X }
C {sky130_stdcells/a2bb2o_4.sym} 72540 -16000 0 0 {name=X_43815_ }
C {devices/lab_pin.sym} 72460 -15880 0 0 {name=p72138 lab=_45952_/X }
C {devices/lab_pin.sym} 72460 -15840 0 0 {name=p72139 lab=_56574_/Y }
C {devices/lab_pin.sym} 72460 -15800 0 0 {name=p72140 lab=_83007_/Q }
C {devices/lab_pin.sym} 72460 -15760 0 0 {name=p72141 lab=_74633_/X }
C {devices/lab_pin.sym} 72620 -15820 0 1 {name=p72142 lab=_83007_/D }
C {sky130_stdcells/a2bb2o_4.sym} 72540 -15820 0 0 {name=X_74635_ }
C {devices/lab_pin.sym} 72480 -15680 0 0 {name=p72143 lab=_47574_/A }
C {devices/lab_pin.sym} 72480 -15640 0 0 {name=p72144 lab=_53131_/B }
C {devices/lab_pin.sym} 72600 -15660 0 1 {name=p72145 lab=_47583_/Y }
C {sky130_stdcells/nand2_4.sym} 72540 -15660 0 0 {name=X_47583_ }
C {devices/lab_pin.sym} 72500 -15530 0 0 {name=p72146 lab=_71846_/Y }
C {devices/lab_pin.sym} 72580 -15530 0 1 {name=p72147 lab=_71847_/Y }
C {sky130_stdcells/inv_2.sym} 72540 -15530 0 0 {name=X_71847_ }
C {devices/lab_pin.sym} 72500 -15410 0 0 {name=p72148 lab=_59568_/X }
C {devices/lab_pin.sym} 72580 -15410 0 1 {name=p72149 lab=_59570_/A }
C {sky130_stdcells/buf_2.sym} 72540 -15410 0 0 {name=X_59569_ }
C {devices/lab_pin.sym} 72460 -15320 0 0 {name=p72150 lab=_41415_/Y }
C {devices/lab_pin.sym} 72460 -15280 0 0 {name=p72151 lab=_44788_/X }
C {devices/lab_pin.sym} 72460 -15240 0 0 {name=p72152 lab=_86951_/Q }
C {devices/lab_pin.sym} 72460 -15200 0 0 {name=p72153 lab=_44789_/X }
C {devices/lab_pin.sym} 72620 -15260 0 1 {name=p72154 lab=_86951_/D }
C {sky130_stdcells/a2bb2o_4.sym} 72540 -15260 0 0 {name=X_44795_ }
C {devices/lab_pin.sym} 72480 -15120 0 0 {name=p72155 lab=_49273_/A }
C {devices/lab_pin.sym} 72480 -15080 0 0 {name=p72156 lab=_49322_/B }
C {devices/lab_pin.sym} 72600 -15100 0 1 {name=p72157 lab=_49322_/Y }
C {sky130_stdcells/nand2_4.sym} 72540 -15100 0 0 {name=X_49322_ }
C {devices/lab_pin.sym} 72480 -15000 0 0 {name=p72158 lab=_58461_/A }
C {devices/lab_pin.sym} 72480 -14960 0 0 {name=p72159 lab=_61598_/X }
C {devices/lab_pin.sym} 72480 -14920 0 0 {name=p72160 lab=_61677_/C }
C {devices/lab_pin.sym} 72480 -14880 0 0 {name=p72161 lab=_61563_/D }
C {devices/lab_pin.sym} 72600 -14940 0 1 {name=p72162 lab=_61600_/Y }
C {sky130_stdcells/nand4_4.sym} 72540 -14940 0 0 {name=X_61600_ }
C {devices/lab_pin.sym} 72500 -14790 0 0 {name=p72163 lab=_52545_/B }
C {devices/lab_pin.sym} 72580 -14790 0 1 {name=p72164 lab=_50852_/B }
C {sky130_stdcells/buf_2.sym} 72540 -14790 0 0 {name=X_46534_ }
C {devices/lab_pin.sym} 72480 -14680 0 0 {name=p72165 lab=_77354_/A }
C {devices/lab_pin.sym} 72480 -14640 0 0 {name=p72166 lab=_77354_/B }
C {devices/lab_pin.sym} 72600 -14660 0 1 {name=p72167 lab=_77354_/X }
C {sky130_stdcells/or2_4.sym} 72540 -14660 0 0 {name=X_77354_ }
C {devices/lab_pin.sym} 72500 -14530 0 0 {name=p72168 lab=_43745_/X }
C {devices/lab_pin.sym} 72580 -14530 0 1 {name=p72169 lab=_87287_/D }
C {sky130_stdcells/inv_2.sym} 72540 -14530 0 0 {name=X_43746_ }
C {devices/lab_pin.sym} 72460 -14440 0 0 {name=p72170 lab=_74559_/X }
C {devices/lab_pin.sym} 72460 -14400 0 0 {name=p72171 lab=_74553_/X }
C {devices/lab_pin.sym} 72460 -14360 0 0 {name=p72172 lab=_56055_/A }
C {devices/lab_pin.sym} 72460 -14320 0 0 {name=p72173 lab=_74554_/X }
C {devices/lab_pin.sym} 72620 -14380 0 1 {name=p72174 lab=_74566_/X }
C {sky130_stdcells/a211o_4.sym} 72540 -14380 0 0 {name=X_74566_ }
C {devices/lab_pin.sym} 72480 -14260 0 0 {name=p72175 lab=_61637_/X }
C {devices/lab_pin.sym} 72480 -14220 0 0 {name=p72176 lab=_62560_/B }
C {devices/lab_pin.sym} 72480 -14180 0 0 {name=p72177 lab=_62560_/C }
C {devices/lab_pin.sym} 72480 -14140 0 0 {name=p72178 lab=_62560_/D }
C {devices/lab_pin.sym} 72600 -14200 0 1 {name=p72179 lab=_62580_/Y }
C {sky130_stdcells/nand4_4.sym} 72540 -14200 0 0 {name=X_62580_ }
C {devices/lab_pin.sym} 72460 -14070 0 0 {name=p72180 lab=_40512_/X }
C {devices/lab_pin.sym} 72460 -14030 0 0 {name=p72181 lab=_81725_/Q }
C {devices/lab_pin.sym} 72460 -13990 0 0 {name=p72182 lab=_40957_/X }
C {devices/lab_pin.sym} 72620 -14030 0 1 {name=p72183 lab=_40959_/A }
C {sky130_stdcells/o21a_4.sym} 72540 -14030 0 0 {name=X_40958_ }
C {devices/lab_pin.sym} 72460 -13910 0 0 {name=p72184 lab=_71761_/Y }
C {devices/lab_pin.sym} 72460 -13870 0 0 {name=p72185 lab=_83379_/Q }
C {devices/lab_pin.sym} 72460 -13830 0 0 {name=p72186 lab=_71777_/X }
C {devices/lab_pin.sym} 72620 -13870 0 1 {name=p72187 lab=_83379_/D }
C {sky130_stdcells/a21o_4.sym} 72540 -13870 0 0 {name=X_71778_ }
C {devices/lab_pin.sym} 72460 -13750 0 0 {name=p72188 lab=_76301_/Y }
C {devices/lab_pin.sym} 72460 -13710 0 0 {name=p72189 lab=_76303_/Y }
C {devices/lab_pin.sym} 72460 -13670 0 0 {name=p72190 lab=_76300_/Y }
C {devices/lab_pin.sym} 72620 -13710 0 1 {name=p72191 lab=_76305_/Y }
C {sky130_stdcells/o21ai_4.sym} 72540 -13710 0 0 {name=X_76305_ }
C {devices/lab_pin.sym} 72480 -13580 0 0 {name=p72192 lab=_49263_/A }
C {devices/lab_pin.sym} 72480 -13540 0 0 {name=p72193 lab=_52468_/B }
C {devices/lab_pin.sym} 72600 -13560 0 1 {name=p72194 lab=_49253_/Y }
C {sky130_stdcells/nand2_4.sym} 72540 -13560 0 0 {name=X_49253_ }
C {devices/lab_pin.sym} 72480 -13460 0 0 {name=p72195 lab=_58434_/A }
C {devices/lab_pin.sym} 72480 -13420 0 0 {name=p72196 lab=_61563_/B }
C {devices/lab_pin.sym} 72480 -13380 0 0 {name=p72197 lab=_61563_/C }
C {devices/lab_pin.sym} 72480 -13340 0 0 {name=p72198 lab=_61514_/D }
C {devices/lab_pin.sym} 72600 -13400 0 1 {name=p72199 lab=_61532_/A }
C {sky130_stdcells/nand4_4.sym} 72540 -13400 0 0 {name=X_61531_ }
C {devices/lab_pin.sym} 72460 -13280 0 0 {name=p72200 lab=_73355_/X }
C {devices/lab_pin.sym} 72460 -13240 0 0 {name=p72201 lab=_85571_/Q }
C {devices/lab_pin.sym} 72460 -13200 0 0 {name=p72202 lab=_73472_/X }
C {devices/lab_pin.sym} 72460 -13160 0 0 {name=p72203 lab=_73516_/X }
C {devices/lab_pin.sym} 72620 -13220 0 1 {name=p72204 lab=_73517_/X }
C {sky130_stdcells/a211o_4.sym} 72540 -13220 0 0 {name=X_73517_ }
C {devices/lab_pin.sym} 72500 -13070 0 0 {name=p72205 lab=_46464_/Y }
C {devices/lab_pin.sym} 72580 -13070 0 1 {name=p72206 lab=_51328_/B }
C {sky130_stdcells/buf_2.sym} 72540 -13070 0 0 {name=X_46465_ }
C {devices/lab_pin.sym} 72500 -12950 0 0 {name=p72207 lab=_70668_/D }
C {devices/lab_pin.sym} 72580 -12950 0 1 {name=p72208 lab=_71266_/A }
C {sky130_stdcells/buf_2.sym} 72540 -12950 0 0 {name=X_70729_ }
C {devices/lab_pin.sym} 72480 -12850 0 0 {name=p72209 lab=_77285_/A }
C {devices/lab_pin.sym} 72480 -12810 0 0 {name=p72210 lab=_77280_/X }
C {devices/lab_pin.sym} 72480 -12770 0 0 {name=p72211 lab=_77285_/C }
C {devices/lab_pin.sym} 72600 -12810 0 1 {name=p72212 lab=_77286_/A }
C {sky130_stdcells/nand3_4.sym} 72540 -12810 0 0 {name=X_77285_ }
C {devices/lab_pin.sym} 72500 -12670 0 0 {name=p72213 lab=_43677_/A }
C {devices/lab_pin.sym} 72580 -12670 0 1 {name=p72214 lab=_43677_/Y }
C {sky130_stdcells/inv_2.sym} 72540 -12670 0 0 {name=X_43677_ }
C {devices/lab_pin.sym} 72480 -12570 0 0 {name=p72215 lab=_48666_/A }
C {devices/lab_pin.sym} 72480 -12530 0 0 {name=p72216 lab=_74501_/B }
C {devices/lab_pin.sym} 72480 -12490 0 0 {name=p72217 lab=_74501_/C }
C {devices/lab_pin.sym} 72600 -12530 0 1 {name=p72218 lab=_74497_/X }
C {sky130_stdcells/and3_4.sym} 72540 -12530 0 0 {name=X_74497_ }
C {devices/lab_pin.sym} 72460 -12410 0 0 {name=p72219 lab=_40585_/X }
C {devices/lab_pin.sym} 72460 -12370 0 0 {name=p72220 lab=_82282_/Q }
C {devices/lab_pin.sym} 72460 -12330 0 0 {name=p72221 lab=_40888_/X }
C {devices/lab_pin.sym} 72620 -12370 0 1 {name=p72222 lab=_40889_/Y }
C {sky130_stdcells/o21ai_4.sym} 72540 -12370 0 0 {name=X_40889_ }
C {devices/lab_pin.sym} 72500 -12230 0 0 {name=p72223 lab=_48171_/X }
C {devices/lab_pin.sym} 72580 -12230 0 1 {name=p72224 lab=_48204_/X }
C {sky130_stdcells/buf_2.sym} 72540 -12230 0 0 {name=X_48204_ }
C {devices/lab_pin.sym} 72460 -12140 0 0 {name=p72225 lab=_79012_/Y }
C {devices/lab_pin.sym} 72460 -12100 0 0 {name=p72226 lab=_79014_/B }
C {devices/lab_pin.sym} 72460 -12060 0 0 {name=p72227 lab=_82648_/Q }
C {devices/lab_pin.sym} 72460 -12020 0 0 {name=p72228 lab=_82520_/D }
C {devices/lab_pin.sym} 72620 -12080 0 1 {name=p72229 lab=_79024_/X }
C {sky130_stdcells/a2bb2o_4.sym} 72540 -12080 0 0 {name=X_79024_ }
C {devices/lab_pin.sym} 72480 -11940 0 0 {name=p72230 lab=_45416_/A }
C {devices/lab_pin.sym} 72480 -11900 0 0 {name=p72231 lab=_44894_/B }
C {devices/lab_pin.sym} 72600 -11920 0 1 {name=p72232 lab=_45416_/Y }
C {sky130_stdcells/nor2_4.sym} 72540 -11920 0 0 {name=X_45416_ }
C {devices/lab_pin.sym} 72480 -11810 0 0 {name=p72233 lab=_64250_/A }
C {devices/lab_pin.sym} 72480 -11770 0 0 {name=p72234 lab=_84854_/Q }
C {devices/lab_pin.sym} 72480 -11730 0 0 {name=p72235 lab=_64250_/C }
C {devices/lab_pin.sym} 72600 -11770 0 1 {name=p72236 lab=_64250_/Y }
C {sky130_stdcells/nand3_4.sym} 72540 -11770 0 0 {name=X_64250_ }
C {devices/lab_pin.sym} 72460 -11650 0 0 {name=p72237 lab=_76231_/Y }
C {devices/lab_pin.sym} 72460 -11610 0 0 {name=p72238 lab=_76233_/Y }
C {devices/lab_pin.sym} 72460 -11570 0 0 {name=p72239 lab=_76235_/Y }
C {devices/lab_pin.sym} 72620 -11610 0 1 {name=p72240 lab=_76236_/X }
C {sky130_stdcells/a21o_4.sym} 72540 -11610 0 0 {name=X_76236_ }
C {devices/lab_pin.sym} 72500 -11470 0 0 {name=p72241 lab=_52274_/A }
C {devices/lab_pin.sym} 72580 -11470 0 1 {name=p72242 lab=_42743_/A }
C {sky130_stdcells/inv_2.sym} 72540 -11470 0 0 {name=X_42628_ }
C {devices/lab_pin.sym} 72500 -11350 0 0 {name=p72243 lab=_61400_/X }
C {devices/lab_pin.sym} 72580 -11350 0 1 {name=p72244 lab=_61482_/C }
C {sky130_stdcells/buf_2.sym} 72540 -11350 0 0 {name=X_61462_ }
C {devices/lab_pin.sym} 72460 -11260 0 0 {name=p72245 lab=_73378_/X }
C {devices/lab_pin.sym} 72460 -11220 0 0 {name=p72246 lab=_86182_/Q }
C {devices/lab_pin.sym} 72460 -11180 0 0 {name=p72247 lab=_73446_/X }
C {devices/lab_pin.sym} 72460 -11140 0 0 {name=p72248 lab=_73447_/X }
C {devices/lab_pin.sym} 72620 -11200 0 1 {name=p72249 lab=_73448_/X }
C {sky130_stdcells/a211o_4.sym} 72540 -11200 0 0 {name=X_73448_ }
C {devices/lab_pin.sym} 72500 -11050 0 0 {name=p72250 lab=_49184_/A }
C {devices/lab_pin.sym} 72580 -11050 0 1 {name=p72251 lab=_53932_/B }
C {sky130_stdcells/inv_2.sym} 72540 -11050 0 0 {name=X_49184_ }
C {devices/lab_pin.sym} 72480 -10940 0 0 {name=p72252 lab=_46387_/A }
C {devices/lab_pin.sym} 72480 -10900 0 0 {name=p72253 lab=_46396_/B }
C {devices/lab_pin.sym} 72600 -10920 0 1 {name=p72254 lab=_46396_/Y }
C {sky130_stdcells/nand2_4.sym} 72540 -10920 0 0 {name=X_46396_ }
C {devices/lab_pin.sym} 72460 -10830 0 0 {name=p72255 lab=_58380_/A }
C {devices/lab_pin.sym} 72460 -10790 0 0 {name=p72256 lab=_63190_/X }
C {devices/lab_pin.sym} 72460 -10750 0 0 {name=p72257 lab=_63175_/X }
C {devices/lab_pin.sym} 72460 -10710 0 0 {name=p72258 lab=_58254_/Y }
C {devices/lab_pin.sym} 72460 -10670 0 0 {name=p72259 lab=_63176_/X }
C {devices/lab_pin.sym} 72620 -10750 0 1 {name=p72260 lab=_63201_/Y }
C {sky130_stdcells/o32ai_4.sym} 72540 -10750 0 0 {name=X_63201_ }
C {devices/lab_pin.sym} 72500 -10590 0 0 {name=p72261 lab=_60412_/X }
C {devices/lab_pin.sym} 72580 -10590 0 1 {name=p72262 lab=_60413_/X }
C {sky130_stdcells/buf_2.sym} 72540 -10590 0 0 {name=X_60413_ }
C {devices/lab_pin.sym} 72500 -10470 0 0 {name=p72263 lab=_48135_/A }
C {devices/lab_pin.sym} 72580 -10470 0 1 {name=p72264 lab=_48136_/B }
C {sky130_stdcells/buf_2.sym} 72540 -10470 0 0 {name=X_48135_ }
C {devices/lab_pin.sym} 72480 -10360 0 0 {name=p72265 lab=_45347_/A }
C {devices/lab_pin.sym} 72480 -10320 0 0 {name=p72266 lab=_45381_/B }
C {devices/lab_pin.sym} 72600 -10340 0 1 {name=p72267 lab=_45347_/Y }
C {sky130_stdcells/nand2_4.sym} 72540 -10340 0 0 {name=X_45347_ }
C {devices/lab_pin.sym} 72480 -10240 0 0 {name=p72268 lab=_64181_/A }
C {devices/lab_pin.sym} 72480 -10200 0 0 {name=p72269 lab=_64181_/B }
C {devices/lab_pin.sym} 72480 -10160 0 0 {name=p72270 lab=_64181_/C }
C {devices/lab_pin.sym} 72480 -10120 0 0 {name=p72271 lab=_64181_/D }
C {devices/lab_pin.sym} 72600 -10180 0 1 {name=p72272 lab=_64181_/X }
C {sky130_stdcells/and4_4.sym} 72540 -10180 0 0 {name=X_64181_ }
C {devices/lab_pin.sym} 72480 -10050 0 0 {name=p72273 lab=_76160_/X }
C {devices/lab_pin.sym} 72480 -10010 0 0 {name=p72274 lab=_76165_/X }
C {devices/lab_pin.sym} 72480 -9970 0 0 {name=p72275 lab=_76161_/Y }
C {devices/lab_pin.sym} 72600 -10010 0 1 {name=p72276 lab=_76168_/B }
C {sky130_stdcells/nand3_4.sym} 72540 -10010 0 0 {name=X_76167_ }
C {devices/lab_pin.sym} 72460 -9910 0 0 {name=p72277 lab=_42554_/X }
C {devices/lab_pin.sym} 72460 -9870 0 0 {name=p72278 lab=_42547_/X }
C {devices/lab_pin.sym} 72460 -9830 0 0 {name=p72279 lab=_40798_/X }
C {devices/lab_pin.sym} 72460 -9790 0 0 {name=p72280 lab=_42558_/Y }
C {devices/lab_pin.sym} 72460 -9750 0 0 {name=p72281 lab=_42556_/X }
C {devices/lab_pin.sym} 72620 -9830 0 1 {name=p72282 lab=_42559_/Y }
C {sky130_stdcells/o32ai_4.sym} 72540 -9830 0 0 {name=X_42559_ }
C {devices/lab_pin.sym} 72460 -9710 0 0 {name=p72283 lab=_61386_/Y }
C {devices/lab_pin.sym} 72460 -9670 0 0 {name=p72284 lab=_61388_/Y }
C {devices/lab_pin.sym} 72460 -9630 0 0 {name=p72285 lab=_61334_/X }
C {devices/lab_pin.sym} 72460 -9590 0 0 {name=p72286 lab=_61390_/Y }
C {devices/lab_pin.sym} 72460 -9560 0 0 {name=p72287 lab=_61392_/Y }
C {devices/lab_pin.sym} 72620 -9630 0 1 {name=p72288 lab=_61393_/X }
C {sky130_stdcells/a41o_4.sym} 72540 -9630 0 0 {name=X_61393_ }
C {devices/lab_pin.sym} 72480 -9480 0 0 {name=p72289 lab=_73495_/A }
C {devices/lab_pin.sym} 72480 -9440 0 0 {name=p72290 lab=_85865_/Q }
C {devices/lab_pin.sym} 72600 -9460 0 1 {name=p72291 lab=_73379_/X }
C {sky130_stdcells/and2_4.sym} 72540 -9460 0 0 {name=X_73379_ }
C {devices/lab_pin.sym} 72460 -9370 0 0 {name=p72292 lab=_58546_/Y }
C {devices/lab_pin.sym} 72460 -9330 0 0 {name=p72293 lab=_63131_/X }
C {devices/lab_pin.sym} 72460 -9290 0 0 {name=p72294 lab=_63117_/X }
C {devices/lab_pin.sym} 72460 -9250 0 0 {name=p72295 lab=_58322_/Y }
C {devices/lab_pin.sym} 72460 -9210 0 0 {name=p72296 lab=_63118_/X }
C {devices/lab_pin.sym} 72620 -9290 0 1 {name=p72297 lab=_63132_/Y }
C {sky130_stdcells/o32ai_4.sym} 72540 -9290 0 0 {name=X_63132_ }
C {devices/lab_pin.sym} 72460 -9150 0 0 {name=p72298 lab=_75107_/A }
C {devices/lab_pin.sym} 72460 -9110 0 0 {name=p72299 lab=_75106_/A }
C {devices/lab_pin.sym} 72460 -9070 0 0 {name=p72300 lab=_75105_/A }
C {devices/lab_pin.sym} 72620 -9110 0 1 {name=p72301 lab=_75120_/A }
C {sky130_stdcells/o21ai_4.sym} 72540 -9110 0 0 {name=X_75118_ }
C {devices/lab_pin.sym} 72460 -8990 0 0 {name=p72302 lab=_47867_/X }
C {devices/lab_pin.sym} 72460 -8950 0 0 {name=p72303 lab=_82923_/Q }
C {devices/lab_pin.sym} 72460 -8910 0 0 {name=p72304 lab=_48065_/Y }
C {devices/lab_pin.sym} 72620 -8950 0 1 {name=p72305 lab=_48067_/A }
C {sky130_stdcells/o21ai_4.sym} 72540 -8950 0 0 {name=X_48066_ }
C {devices/lab_pin.sym} 72480 -8830 0 0 {name=p72306 lab=_60344_/A }
C {devices/lab_pin.sym} 72480 -8790 0 0 {name=p72307 lab=_60344_/B }
C {devices/lab_pin.sym} 72480 -8750 0 0 {name=p72308 lab=_60344_/C }
C {devices/lab_pin.sym} 72600 -8790 0 1 {name=p72309 lab=_60344_/Y }
C {sky130_stdcells/nand3_4.sym} 72540 -8790 0 0 {name=X_60344_ }
C {devices/lab_pin.sym} 72500 -8650 0 0 {name=p72310 lab=_62557_/A }
C {devices/lab_pin.sym} 72580 -8650 0 1 {name=p72311 lab=_61617_/B }
C {sky130_stdcells/buf_2.sym} 72540 -8650 0 0 {name=X_45278_ }
C {devices/lab_pin.sym} 72460 -8550 0 0 {name=p72312 lab=_76081_/Y }
C {devices/lab_pin.sym} 72460 -8510 0 0 {name=p72313 lab=_76095_/X }
C {devices/lab_pin.sym} 72460 -8470 0 0 {name=p72314 lab=_76097_/Y }
C {devices/lab_pin.sym} 72620 -8510 0 1 {name=p72315 lab=_76099_/B }
C {sky130_stdcells/a21oi_4.sym} 72540 -8510 0 0 {name=X_76098_ }
C {devices/lab_pin.sym} 72480 -8380 0 0 {name=p72316 lab=_47008_/A }
C {devices/lab_pin.sym} 72480 -8340 0 0 {name=p72317 lab=_52803_/B }
C {devices/lab_pin.sym} 72600 -8360 0 1 {name=p72318 lab=_47017_/Y }
C {sky130_stdcells/nand2_4.sym} 72540 -8360 0 0 {name=X_47017_ }
C {devices/lab_pin.sym} 72500 -8230 0 0 {name=p72319 lab=_44228_/X }
C {devices/lab_pin.sym} 72580 -8230 0 1 {name=p72320 lab=_56995_/A }
C {sky130_stdcells/buf_2.sym} 72540 -8230 0 0 {name=X_44229_ }
C {devices/lab_pin.sym} 72460 -8140 0 0 {name=p72321 lab=_87450_/Q }
C {devices/lab_pin.sym} 72460 -8100 0 0 {name=p72322 lab=_67868_/X }
C {devices/lab_pin.sym} 72460 -8060 0 0 {name=p72323 lab=_67938_/X }
C {devices/lab_pin.sym} 72460 -8020 0 0 {name=p72324 lab=_67939_/X }
C {devices/lab_pin.sym} 72620 -8080 0 1 {name=p72325 lab=_67940_/X }
C {sky130_stdcells/a211o_4.sym} 72540 -8080 0 0 {name=X_67940_ }
C {devices/lab_pin.sym} 72480 -7960 0 0 {name=p72326 lab=_63038_/A }
C {devices/lab_pin.sym} 72480 -7920 0 0 {name=p72327 lab=_64275_/B }
C {devices/lab_pin.sym} 72480 -7880 0 0 {name=p72328 lab=_63085_/C }
C {devices/lab_pin.sym} 72480 -7840 0 0 {name=p72329 lab=_63085_/D }
C {devices/lab_pin.sym} 72600 -7900 0 1 {name=p72330 lab=_63063_/X }
C {sky130_stdcells/and4_4.sym} 72540 -7900 0 0 {name=X_63063_ }
C {devices/lab_pin.sym} 72480 -7760 0 0 {name=p72331 lab=_75049_/A }
C {devices/lab_pin.sym} 72480 -7720 0 0 {name=p72332 lab=_75048_/Y }
C {devices/lab_pin.sym} 72600 -7740 0 1 {name=p72333 lab=_75051_/A }
C {sky130_stdcells/or2_4.sym} 72540 -7740 0 0 {name=X_75049_ }
C {devices/lab_pin.sym} 72480 -7630 0 0 {name=p72334 lab=_79926_/A }
C {devices/lab_pin.sym} 72480 -7590 0 0 {name=p72335 lab=_79918_/Y }
C {devices/lab_pin.sym} 72480 -7550 0 0 {name=p72336 lab=_79919_/Y }
C {devices/lab_pin.sym} 72600 -7590 0 1 {name=p72337 lab=_79927_/B }
C {sky130_stdcells/nand3_4.sym} 72540 -7590 0 0 {name=X_79926_ }
C {devices/lab_pin.sym} 72480 -7470 0 0 {name=p72338 lab=_60189_/Y }
C {devices/lab_pin.sym} 72480 -7430 0 0 {name=p72339 lab=_60274_/X }
C {devices/lab_pin.sym} 72480 -7390 0 0 {name=p72340 lab=_60253_/A }
C {devices/lab_pin.sym} 72600 -7430 0 1 {name=p72341 lab=_60275_/X }
C {sky130_stdcells/and3_4.sym} 72540 -7430 0 0 {name=X_60275_ }
C {devices/lab_pin.sym} 72480 -7320 0 0 {name=p72342 lab=_63585_/B }
C {devices/lab_pin.sym} 72480 -7280 0 0 {name=p72343 lab=_61999_/B }
C {devices/lab_pin.sym} 72480 -7240 0 0 {name=p72344 lab=_61971_/C }
C {devices/lab_pin.sym} 72480 -7200 0 0 {name=p72345 lab=_61971_/D }
C {devices/lab_pin.sym} 72600 -7260 0 1 {name=p72346 lab=_62015_/D }
C {sky130_stdcells/nand4_4.sym} 72540 -7260 0 0 {name=X_62014_ }
C {devices/lab_pin.sym} 72460 -7130 0 0 {name=p72347 lab=_67867_/X }
C {devices/lab_pin.sym} 72460 -7090 0 0 {name=p72348 lab=_67870_/X }
C {devices/lab_pin.sym} 72460 -7050 0 0 {name=p72349 lab=_67799_/X }
C {devices/lab_pin.sym} 72620 -7090 0 1 {name=p72350 lab=_67871_/X }
C {sky130_stdcells/a21o_4.sym} 72540 -7090 0 0 {name=X_67871_ }
C {devices/lab_pin.sym} 72500 -6950 0 0 {name=p72351 lab=_79856_/X }
C {devices/lab_pin.sym} 72580 -6950 0 1 {name=p72352 lab=_79857_/Y }
C {sky130_stdcells/inv_2.sym} 72540 -6950 0 0 {name=X_79857_ }
C {devices/lab_pin.sym} 72460 -6850 0 0 {name=p72353 lab=_69606_/X }
C {devices/lab_pin.sym} 72460 -6810 0 0 {name=p72354 lab=_69609_/X }
C {devices/lab_pin.sym} 72460 -6770 0 0 {name=p72355 lab=_69385_/X }
C {devices/lab_pin.sym} 72620 -6810 0 1 {name=p72356 lab=_69610_/X }
C {sky130_stdcells/a21o_4.sym} 72540 -6810 0 0 {name=X_69610_ }
C {devices/lab_pin.sym} 72500 -6670 0 0 {name=p72357 lab=_68474_/A }
C {devices/lab_pin.sym} 72580 -6670 0 1 {name=p72358 lab=_66823_/A }
C {sky130_stdcells/buf_2.sym} 72540 -6670 0 0 {name=X_66822_ }
C {devices/lab_pin.sym} 72500 -6550 0 0 {name=p72359 lab=_82834_/Q }
C {devices/lab_pin.sym} 72580 -6550 0 1 {name=p72360 lab=_78809_/A }
C {sky130_stdcells/inv_2.sym} 72540 -6550 0 0 {name=X_78808_ }
C {devices/lab_pin.sym} 72460 -6450 0 0 {name=p72361 lab=_48946_/X }
C {devices/lab_pin.sym} 72460 -6410 0 0 {name=p72362 lab=_48449_/A }
C {devices/lab_pin.sym} 72460 -6370 0 0 {name=p72363 lab=_48967_/Y }
C {devices/lab_pin.sym} 72620 -6410 0 1 {name=p72364 lab=_48969_/A }
C {sky130_stdcells/a21o_4.sym} 72540 -6410 0 0 {name=X_48968_ }
C {devices/lab_pin.sym} 72480 -6280 0 0 {name=p72365 lab=_79777_/X }
C {devices/lab_pin.sym} 72480 -6240 0 0 {name=p72366 lab=_79766_/X }
C {devices/lab_pin.sym} 72600 -6260 0 1 {name=p72367 lab=_79788_/X }
C {sky130_stdcells/and2_4.sym} 72540 -6260 0 0 {name=X_79788_ }
C {devices/lab_pin.sym} 72460 -6150 0 0 {name=p72368 lab=_81380_/D }
C {devices/lab_pin.sym} 72460 -6110 0 0 {name=p72369 lab=_69504_/X }
C {devices/lab_pin.sym} 72460 -6070 0 0 {name=p72370 lab=_69540_/X }
C {devices/lab_pin.sym} 72620 -6110 0 1 {name=p72371 lab=_83916_/D }
C {sky130_stdcells/a21bo_4.sym} 72540 -6110 0 0 {name=X_69541_ }
C {devices/lab_pin.sym} 72500 -5970 0 0 {name=p72372 lab=_48790_/A }
C {devices/lab_pin.sym} 72580 -5970 0 1 {name=p72373 lab=_47919_/X }
C {sky130_stdcells/buf_2.sym} 72540 -5970 0 0 {name=X_47919_ }
C {devices/lab_pin.sym} 72500 -5850 0 0 {name=p72374 lab=_78739_/A }
C {devices/lab_pin.sym} 72580 -5850 0 1 {name=p72375 lab=_78747_/A }
C {sky130_stdcells/inv_2.sym} 72540 -5850 0 0 {name=X_78739_ }
C {devices/lab_pin.sym} 72460 -5760 0 0 {name=p72376 lab=_87128_/Q }
C {devices/lab_pin.sym} 72460 -5720 0 0 {name=p72377 lab=_66751_/X }
C {devices/lab_pin.sym} 72460 -5680 0 0 {name=p72378 lab=_66682_/X }
C {devices/lab_pin.sym} 72460 -5640 0 0 {name=p72379 lab=_66752_/X }
C {devices/lab_pin.sym} 72620 -5700 0 1 {name=p72380 lab=_66753_/X }
C {sky130_stdcells/a211o_4.sym} 72540 -5700 0 0 {name=X_66753_ }
C {devices/lab_pin.sym} 72500 -5550 0 0 {name=p72381 lab=_63964_/Y }
C {devices/lab_pin.sym} 72580 -5550 0 1 {name=p72382 lab=_63965_/Y }
C {sky130_stdcells/inv_2.sym} 72540 -5550 0 0 {name=X_63965_ }
C {devices/lab_pin.sym} 72500 -5430 0 0 {name=p72383 lab=_83623_/Q }
C {devices/lab_pin.sym} 72580 -5430 0 1 {name=p72384 lab=_48899_/Y }
C {sky130_stdcells/inv_2.sym} 72540 -5430 0 0 {name=X_48899_ }
C {devices/lab_pin.sym} 72480 -5320 0 0 {name=p72385 lab=_65704_/A }
C {devices/lab_pin.sym} 72480 -5280 0 0 {name=p72386 lab=_86479_/Q }
C {devices/lab_pin.sym} 72600 -5300 0 1 {name=p72387 lab=_65704_/X }
C {sky130_stdcells/and2_4.sym} 72540 -5300 0 0 {name=X_65704_ }
C {devices/lab_pin.sym} 72480 -5200 0 0 {name=p72388 lab=_50941_/A }
C {devices/lab_pin.sym} 72480 -5160 0 0 {name=p72389 lab=_50941_/B }
C {devices/lab_pin.sym} 72480 -5120 0 0 {name=p72390 lab=_50948_/C }
C {devices/lab_pin.sym} 72480 -5080 0 0 {name=p72391 lab=_52622_/D }
C {devices/lab_pin.sym} 72600 -5140 0 1 {name=p72392 lab=_50930_/X }
C {sky130_stdcells/and4_4.sym} 72540 -5140 0 0 {name=X_50930_ }
C {devices/lab_pin.sym} 72500 -4990 0 0 {name=p72393 lab=_62916_/A }
C {devices/lab_pin.sym} 72580 -4990 0 1 {name=p72394 lab=_62916_/Y }
C {sky130_stdcells/inv_2.sym} 72540 -4990 0 0 {name=X_62916_ }
C {devices/lab_pin.sym} 72450 -4870 0 0 {name=p72395 lab=_81514_/CLK }
C {devices/lab_pin.sym} 72450 -4850 0 0 {name=p72396 lab=_76069_/B }
C {devices/lab_pin.sym} 72630 -4870 0 1 {name=p72397 lab=_81750_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -4860 0 0 {name=X_81750_ }
C {devices/lab_pin.sym} 72480 -4740 0 0 {name=p72398 lab=_69309_/A }
C {devices/lab_pin.sym} 72480 -4700 0 0 {name=p72399 lab=_69472_/B }
C {devices/lab_pin.sym} 72600 -4720 0 1 {name=p72400 lab=_69472_/X }
C {sky130_stdcells/and2_4.sym} 72540 -4720 0 0 {name=X_69472_ }
C {devices/lab_pin.sym} 72500 -4590 0 0 {name=p72401 lab=clkbuf_9_190_0_CLK/X }
C {devices/lab_pin.sym} 72580 -4590 0 1 {name=p72402 lab=_85436_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 72540 -4590 0 0 {name=Xclkbuf_10_380_0_CLK }
C {devices/lab_pin.sym} 72460 -4500 0 0 {name=p72403 lab=_88399_/Q }
C {devices/lab_pin.sym} 72460 -4460 0 0 {name=p72404 lab=_66633_/X }
C {devices/lab_pin.sym} 72460 -4420 0 0 {name=p72405 lab=_66682_/X }
C {devices/lab_pin.sym} 72460 -4380 0 0 {name=p72406 lab=_66683_/X }
C {devices/lab_pin.sym} 72620 -4440 0 1 {name=p72407 lab=_66684_/X }
C {sky130_stdcells/a211o_4.sym} 72540 -4440 0 0 {name=X_66684_ }
C {devices/lab_pin.sym} 72460 -4330 0 0 {name=p72408 lab=_63889_/X }
C {devices/lab_pin.sym} 72460 -4290 0 0 {name=p72409 lab=_63890_/X }
C {devices/lab_pin.sym} 72460 -4250 0 0 {name=p72410 lab=_63892_/Y }
C {devices/lab_pin.sym} 72460 -4210 0 0 {name=p72411 lab=_63894_/Y }
C {devices/lab_pin.sym} 72460 -4180 0 0 {name=p72412 lab=_63895_/X }
C {devices/lab_pin.sym} 72620 -4250 0 1 {name=p72413 lab=_63896_/X }
C {sky130_stdcells/a41o_4.sym} 72540 -4250 0 0 {name=X_63896_ }
C {devices/lab_pin.sym} 72450 -4090 0 0 {name=p72414 lab=_84276_/CLK }
C {devices/lab_pin.sym} 72450 -4070 0 0 {name=p72415 lab=_80733_/Q }
C {devices/lab_pin.sym} 72630 -4090 0 1 {name=p72416 lab=_75475_/A }
C {sky130_stdcells/dfxtp_4.sym} 72540 -4080 0 0 {name=X_80701_ }
C {devices/lab_pin.sym} 72460 -3980 0 0 {name=p72417 lab=_87005_/Q }
C {devices/lab_pin.sym} 72460 -3940 0 0 {name=p72418 lab=_68394_/X }
C {devices/lab_pin.sym} 72460 -3900 0 0 {name=p72419 lab=_68421_/X }
C {devices/lab_pin.sym} 72460 -3860 0 0 {name=p72420 lab=_68422_/X }
C {devices/lab_pin.sym} 72620 -3920 0 1 {name=p72421 lab=_68423_/X }
C {sky130_stdcells/a211o_4.sym} 72540 -3920 0 0 {name=X_68423_ }
C {devices/lab_pin.sym} 72460 -3790 0 0 {name=p72422 lab=_65632_/Y }
C {devices/lab_pin.sym} 72460 -3750 0 0 {name=p72423 lab=_65602_/X }
C {devices/lab_pin.sym} 72460 -3710 0 0 {name=p72424 lab=_65634_/Y }
C {devices/lab_pin.sym} 72620 -3750 0 1 {name=p72425 lab=_84188_/D }
C {sky130_stdcells/a21o_4.sym} 72540 -3750 0 0 {name=X_65635_ }
C {devices/lab_pin.sym} 72460 -3630 0 0 {name=p72426 lab=_50859_/Y }
C {devices/lab_pin.sym} 72460 -3590 0 0 {name=p72427 lab=_50849_/X }
C {devices/lab_pin.sym} 72460 -3550 0 0 {name=p72428 lab=_50860_/Y }
C {devices/lab_pin.sym} 72620 -3590 0 1 {name=p72429 lab=_86119_/D }
C {sky130_stdcells/a21boi_4.sym} 72540 -3590 0 0 {name=X_50861_ }
C {devices/lab_pin.sym} 72500 -3450 0 0 {name=p72430 lab=_62847_/A }
C {devices/lab_pin.sym} 72580 -3450 0 1 {name=p72431 lab=_62847_/X }
C {sky130_stdcells/buf_2.sym} 72540 -3450 0 0 {name=X_62847_ }
C {devices/lab_pin.sym} 72450 -3330 0 0 {name=p72432 lab=_81684_/CLK }
C {devices/lab_pin.sym} 72450 -3310 0 0 {name=p72433 lab=_81681_/D }
C {devices/lab_pin.sym} 72630 -3330 0 1 {name=p72434 lab=_81681_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -3320 0 0 {name=X_81681_ }
C {devices/lab_pin.sym} 72460 -3210 0 0 {name=p72435 lab=_52597_/Y }
C {devices/lab_pin.sym} 72460 -3170 0 0 {name=p72436 lab=_52592_/X }
C {devices/lab_pin.sym} 72460 -3130 0 0 {name=p72437 lab=_52599_/X }
C {devices/lab_pin.sym} 72620 -3170 0 1 {name=p72438 lab=_52600_/Y }
C {sky130_stdcells/a21oi_4.sym} 72540 -3170 0 0 {name=X_52600_ }
C {devices/lab_pin.sym} 72450 -3030 0 0 {name=p72439 lab=_83421_/CLK }
C {devices/lab_pin.sym} 72450 -3010 0 0 {name=p72440 lab=_83420_/D }
C {devices/lab_pin.sym} 72630 -3030 0 1 {name=p72441 lab=_58522_/A }
C {sky130_stdcells/dfxtp_4.sym} 72540 -3020 0 0 {name=X_83420_ }
C {devices/lab_pin.sym} 72480 -2900 0 0 {name=p72442 lab=_80632_/A }
C {devices/lab_pin.sym} 72480 -2860 0 0 {name=p72443 lab=_80632_/B }
C {devices/lab_pin.sym} 72600 -2880 0 1 {name=p72444 lab=_80632_/Y }
C {sky130_stdcells/nand2_4.sym} 72540 -2880 0 0 {name=X_80632_ }
C {devices/lab_pin.sym} 72500 -2750 0 0 {name=p72445 lab=_64980_/A }
C {devices/lab_pin.sym} 72580 -2750 0 1 {name=p72446 lab=_68354_/X }
C {sky130_stdcells/buf_2.sym} 72540 -2750 0 0 {name=X_68354_ }
C {devices/lab_pin.sym} 72460 -2650 0 0 {name=p72447 lab=_53578_/Y }
C {devices/lab_pin.sym} 72460 -2610 0 0 {name=p72448 lab=_53574_/X }
C {devices/lab_pin.sym} 72460 -2570 0 0 {name=p72449 lab=_53579_/Y }
C {devices/lab_pin.sym} 72620 -2610 0 1 {name=p72450 lab=_85609_/D }
C {sky130_stdcells/a21boi_4.sym} 72540 -2610 0 0 {name=X_53580_ }
C {devices/lab_pin.sym} 72500 -2470 0 0 {name=p72451 lab=_64807_/A }
C {devices/lab_pin.sym} 72580 -2470 0 1 {name=p72452 lab=_65566_/X }
C {sky130_stdcells/buf_2.sym} 72540 -2470 0 0 {name=X_65566_ }
C {devices/lab_pin.sym} 72500 -2350 0 0 {name=p72453 lab=_50768_/A }
C {devices/lab_pin.sym} 72580 -2350 0 1 {name=p72454 lab=_50792_/X }
C {sky130_stdcells/buf_2.sym} 72540 -2350 0 0 {name=X_50792_ }
C {devices/lab_pin.sym} 72460 -2270 0 0 {name=p72455 lab=_62771_/Y }
C {devices/lab_pin.sym} 72460 -2230 0 0 {name=p72456 lab=_62772_/X }
C {devices/lab_pin.sym} 72460 -2190 0 0 {name=p72457 lab=_62774_/Y }
C {devices/lab_pin.sym} 72460 -2150 0 0 {name=p72458 lab=_62775_/Y }
C {devices/lab_pin.sym} 72460 -2120 0 0 {name=p72459 lab=_62777_/X }
C {devices/lab_pin.sym} 72620 -2190 0 1 {name=p72460 lab=_62778_/X }
C {sky130_stdcells/a41o_4.sym} 72540 -2190 0 0 {name=X_62778_ }
C {devices/lab_pin.sym} 72500 -2030 0 0 {name=p72461 lab=_64608_/A }
C {devices/lab_pin.sym} 72580 -2030 0 1 {name=p72462 lab=_67305_/X }
C {sky130_stdcells/buf_2.sym} 72540 -2030 0 0 {name=X_67305_ }
C {devices/lab_pin.sym} 72460 -1930 0 0 {name=p72463 lab=_85803_/Q }
C {devices/lab_pin.sym} 72460 -1890 0 0 {name=p72464 lab=_52516_/X }
C {devices/lab_pin.sym} 72460 -1850 0 0 {name=p72465 lab=_52530_/Y }
C {devices/lab_pin.sym} 72620 -1890 0 1 {name=p72466 lab=_52531_/Y }
C {sky130_stdcells/o21ai_4.sym} 72540 -1890 0 0 {name=X_52531_ }
C {devices/lab_pin.sym} 72500 -1750 0 0 {name=p72467 lab=clkbuf_9_197_0_CLK/X }
C {devices/lab_pin.sym} 72580 -1750 0 1 {name=p72468 lab=_82452_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 72540 -1750 0 0 {name=Xclkbuf_10_395_0_CLK }
C {devices/lab_pin.sym} 72460 -1670 0 0 {name=p72469 lab=_64512_/X }
C {devices/lab_pin.sym} 72460 -1630 0 0 {name=p72470 lab=_64513_/X }
C {devices/lab_pin.sym} 72460 -1590 0 0 {name=p72471 lab=_64514_/X }
C {devices/lab_pin.sym} 72460 -1550 0 0 {name=p72472 lab=_64516_/Y }
C {devices/lab_pin.sym} 72460 -1510 0 0 {name=p72473 lab=_64440_/X }
C {devices/lab_pin.sym} 72620 -1590 0 1 {name=p72474 lab=_64517_/X }
C {sky130_stdcells/o41a_4.sym} 72540 -1590 0 0 {name=X_64517_ }
C {devices/lab_pin.sym} 72450 -1430 0 0 {name=p72475 lab=_83480_/CLK }
C {devices/lab_pin.sym} 72450 -1410 0 0 {name=p72476 lab=_83351_/D }
C {devices/lab_pin.sym} 72630 -1430 0 1 {name=p72477 lab=_83351_/Q }
C {sky130_stdcells/dfxtp_4.sym} 72540 -1420 0 0 {name=X_83351_ }
C {devices/lab_pin.sym} 72500 -1290 0 0 {name=p72478 lab=_59766_/X }
C {devices/lab_pin.sym} 72580 -1290 0 1 {name=p72479 lab=_62183_/D }
C {sky130_stdcells/buf_2.sym} 72540 -1290 0 0 {name=X_61729_ }
C {devices/lab_pin.sym} 72460 -1190 0 0 {name=p72480 lab=_80550_/A }
C {devices/lab_pin.sym} 72460 -1150 0 0 {name=p72481 lab=_80549_/Y }
C {devices/lab_pin.sym} 72460 -1110 0 0 {name=p72482 lab=_80562_/Y }
C {devices/lab_pin.sym} 72620 -1150 0 1 {name=p72483 lab=_80564_/B }
C {sky130_stdcells/o21a_4.sym} 72540 -1150 0 0 {name=X_80563_ }
C {devices/lab_pin.sym} 72460 -1040 0 0 {name=p72484 lab=_68254_/X }
C {devices/lab_pin.sym} 72460 -1000 0 0 {name=p72485 lab=_67746_/Y }
C {devices/lab_pin.sym} 72460 -960 0 0 {name=p72486 lab=_68268_/X }
C {devices/lab_pin.sym} 72460 -920 0 0 {name=p72487 lab=_68284_/Y }
C {devices/lab_pin.sym} 72620 -980 0 1 {name=p72488 lab=_68285_/X }
C {sky130_stdcells/a211o_4.sym} 72540 -980 0 0 {name=X_68285_ }
C {devices/lab_pin.sym} 72500 -830 0 0 {name=p72489 lab=_84197_/Q }
C {devices/lab_pin.sym} 72580 -830 0 1 {name=p72490 lab=_65498_/C }
C {sky130_stdcells/inv_2.sym} 72540 -830 0 0 {name=X_65497_ }
C {sky130_stdcells/decap_3.sym} 72540 -680 0 0 {name=XPHY_108 }
C {sky130_stdcells/decap_3.sym} 73460 -42120 0 0 {name=XPHY_119 }
C {devices/lab_pin.sym} 73370 -41970 0 0 {name=p72491 lab=_82343_/CLK }
C {devices/lab_pin.sym} 73370 -41950 0 0 {name=p72492 lab=_82302_/D }
C {devices/lab_pin.sym} 73550 -41970 0 1 {name=p72493 lab=_82302_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -41960 0 0 {name=X_82302_ }
C {devices/lab_pin.sym} 73380 -41850 0 0 {name=p72494 lab=_55247_/X }
C {devices/lab_pin.sym} 73380 -41810 0 0 {name=p72495 lab=_55249_/X }
C {devices/lab_pin.sym} 73380 -41770 0 0 {name=p72496 lab=_55138_/X }
C {devices/lab_pin.sym} 73540 -41810 0 1 {name=p72497 lab=_55254_/A }
C {sky130_stdcells/a21o_4.sym} 73460 -41810 0 0 {name=X_55250_ }
C {devices/lab_pin.sym} 73420 -41670 0 0 {name=p72498 lab=_66758_/X }
C {devices/lab_pin.sym} 73500 -41670 0 1 {name=p72499 lab=_67236_/X }
C {sky130_stdcells/buf_2.sym} 73460 -41670 0 0 {name=X_67236_ }
C {devices/lab_pin.sym} 73370 -41550 0 0 {name=p72500 lab=_85751_/CLK }
C {devices/lab_pin.sym} 73370 -41530 0 0 {name=p72501 lab=_51122_/Y }
C {devices/lab_pin.sym} 73550 -41550 0 1 {name=p72502 lab=_86070_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -41540 0 0 {name=X_86070_ }
C {devices/lab_pin.sym} 73420 -41410 0 0 {name=p72503 lab=_52462_/A }
C {devices/lab_pin.sym} 73500 -41410 0 1 {name=p72504 lab=_52462_/X }
C {sky130_stdcells/buf_2.sym} 73460 -41410 0 0 {name=X_52462_ }
C {devices/lab_pin.sym} 73400 -41310 0 0 {name=p72505 lab=_64402_/X }
C {devices/lab_pin.sym} 73400 -41270 0 0 {name=p72506 lab=_64421_/X }
C {devices/lab_pin.sym} 73400 -41230 0 0 {name=p72507 lab=_84837_/Q }
C {devices/lab_pin.sym} 73520 -41270 0 1 {name=p72508 lab=_64448_/X }
C {sky130_stdcells/and3_4.sym} 73460 -41270 0 0 {name=X_64448_ }
C {devices/lab_pin.sym} 73370 -41130 0 0 {name=p72509 lab=_83282_/CLK }
C {devices/lab_pin.sym} 73370 -41110 0 0 {name=p72510 lab=_72114_/Y }
C {devices/lab_pin.sym} 73550 -41130 0 1 {name=p72511 lab=_83282_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -41120 0 0 {name=X_83282_ }
C {devices/lab_pin.sym} 73400 -41000 0 0 {name=p72512 lab=_80494_/A }
C {devices/lab_pin.sym} 73400 -40960 0 0 {name=p72513 lab=_80494_/B }
C {devices/lab_pin.sym} 73520 -40980 0 1 {name=p72514 lab=_80494_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -40980 0 0 {name=X_80494_ }
C {devices/lab_pin.sym} 73400 -40860 0 0 {name=p72515 lab=_54215_/A }
C {devices/lab_pin.sym} 73400 -40820 0 0 {name=p72516 lab=_47411_/A }
C {devices/lab_pin.sym} 73520 -40840 0 1 {name=p72517 lab=_54201_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -40840 0 0 {name=X_54201_ }
C {devices/lab_pin.sym} 73370 -40710 0 0 {name=p72518 lab=_83008_/CLK }
C {devices/lab_pin.sym} 73370 -40690 0 0 {name=p72519 lab=_57389_/X }
C {devices/lab_pin.sym} 73550 -40710 0 1 {name=p72520 lab=_85021_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -40700 0 0 {name=X_85021_ }
C {devices/lab_pin.sym} 73400 -40580 0 0 {name=p72521 lab=_51403_/X }
C {devices/lab_pin.sym} 73400 -40540 0 0 {name=p72522 lab=_52940_/B }
C {devices/lab_pin.sym} 73520 -40560 0 1 {name=p72523 lab=_51413_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -40560 0 0 {name=X_51413_ }
C {devices/lab_pin.sym} 73370 -40430 0 0 {name=p72524 lab=_82531_/CLK }
C {devices/lab_pin.sym} 73370 -40410 0 0 {name=p72525 lab=_82265_/Q }
C {devices/lab_pin.sym} 73550 -40430 0 1 {name=p72526 lab=_82233_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -40420 0 0 {name=X_82233_ }
C {devices/lab_pin.sym} 73400 -40300 0 0 {name=p72527 lab=_55179_/X }
C {devices/lab_pin.sym} 73400 -40260 0 0 {name=p72528 lab=_55181_/B }
C {devices/lab_pin.sym} 73520 -40280 0 1 {name=p72529 lab=_55298_/A }
C {sky130_stdcells/and2_4.sym} 73460 -40280 0 0 {name=X_55181_ }
C {devices/lab_pin.sym} 73420 -40150 0 0 {name=p72530 lab=_67046_/A }
C {devices/lab_pin.sym} 73500 -40150 0 1 {name=p72531 lab=_67167_/X }
C {sky130_stdcells/buf_2.sym} 73460 -40150 0 0 {name=X_67167_ }
C {devices/lab_pin.sym} 73400 -40040 0 0 {name=p72532 lab=_52373_/X }
C {devices/lab_pin.sym} 73400 -40000 0 0 {name=p72533 lab=_49144_/X }
C {devices/lab_pin.sym} 73520 -40020 0 1 {name=p72534 lab=_52393_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -40020 0 0 {name=X_52393_ }
C {devices/lab_pin.sym} 73400 -39910 0 0 {name=p72535 lab=_64344_/X }
C {devices/lab_pin.sym} 73400 -39870 0 0 {name=p72536 lab=_64379_/B }
C {devices/lab_pin.sym} 73400 -39830 0 0 {name=p72537 lab=_64379_/C }
C {devices/lab_pin.sym} 73520 -39870 0 1 {name=p72538 lab=_64379_/X }
C {sky130_stdcells/and3_4.sym} 73460 -39870 0 0 {name=X_64379_ }
C {devices/lab_pin.sym} 73400 -39760 0 0 {name=p72539 lab=_54127_/X }
C {devices/lab_pin.sym} 73400 -39720 0 0 {name=p72540 lab=_54123_/B }
C {devices/lab_pin.sym} 73400 -39680 0 0 {name=p72541 lab=_54118_/X }
C {devices/lab_pin.sym} 73400 -39640 0 0 {name=p72542 lab=_52967_/D }
C {devices/lab_pin.sym} 73520 -39700 0 1 {name=p72543 lab=_54132_/X }
C {sky130_stdcells/and4_4.sym} 73460 -39700 0 0 {name=X_54132_ }
C {devices/lab_pin.sym} 73420 -39550 0 0 {name=p72544 lab=_64980_/A }
C {devices/lab_pin.sym} 73500 -39550 0 1 {name=p72545 lab=_66118_/X }
C {sky130_stdcells/buf_2.sym} 73460 -39550 0 0 {name=X_66118_ }
C {devices/lab_pin.sym} 73380 -39450 0 0 {name=p72546 lab=_51336_/Y }
C {devices/lab_pin.sym} 73380 -39410 0 0 {name=p72547 lab=_51339_/X }
C {devices/lab_pin.sym} 73380 -39370 0 0 {name=p72548 lab=_51343_/X }
C {devices/lab_pin.sym} 73540 -39410 0 1 {name=p72549 lab=_86029_/D }
C {sky130_stdcells/a21oi_4.sym} 73460 -39410 0 0 {name=X_51344_ }
C {devices/lab_pin.sym} 73370 -39270 0 0 {name=p72550 lab=_84166_/CLK }
C {devices/lab_pin.sym} 73370 -39250 0 0 {name=p72551 lab=_84156_/Q }
C {devices/lab_pin.sym} 73550 -39270 0 1 {name=p72552 lab=_82164_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -39260 0 0 {name=X_82164_ }
C {devices/lab_pin.sym} 73380 -39160 0 0 {name=p72553 lab=_87421_/Q }
C {devices/lab_pin.sym} 73380 -39120 0 0 {name=p72554 lab=_66997_/X }
C {devices/lab_pin.sym} 73380 -39080 0 0 {name=p72555 lab=_66998_/X }
C {devices/lab_pin.sym} 73380 -39040 0 0 {name=p72556 lab=_67097_/X }
C {devices/lab_pin.sym} 73540 -39100 0 1 {name=p72557 lab=_67098_/X }
C {sky130_stdcells/a211o_4.sym} 73460 -39100 0 0 {name=X_67098_ }
C {devices/lab_pin.sym} 73370 -38950 0 0 {name=p72558 lab=_81117_/CLK }
C {devices/lab_pin.sym} 73370 -38930 0 0 {name=p72559 lab=_79822_/Y }
C {devices/lab_pin.sym} 73550 -38950 0 1 {name=p72560 lab=_75650_/A }
C {sky130_stdcells/dfxtp_4.sym} 73460 -38940 0 0 {name=X_81115_ }
C {devices/lab_pin.sym} 73380 -38830 0 0 {name=p72561 lab=_58936_/Y }
C {devices/lab_pin.sym} 73380 -38790 0 0 {name=p72562 lab=_58938_/Y }
C {devices/lab_pin.sym} 73380 -38750 0 0 {name=p72563 lab=_58939_/X }
C {devices/lab_pin.sym} 73540 -38790 0 1 {name=p72564 lab=_58940_/X }
C {sky130_stdcells/a21o_4.sym} 73460 -38790 0 0 {name=X_58940_ }
C {devices/lab_pin.sym} 73400 -38660 0 0 {name=p72565 lab=_54020_/A }
C {devices/lab_pin.sym} 73400 -38620 0 0 {name=p72566 lab=_52545_/B }
C {devices/lab_pin.sym} 73520 -38640 0 1 {name=p72567 lab=_54063_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -38640 0 0 {name=X_54063_ }
C {devices/lab_pin.sym} 73380 -38530 0 0 {name=p72568 lab=_66045_/Y }
C {devices/lab_pin.sym} 73380 -38490 0 0 {name=p72569 lab=_65987_/X }
C {devices/lab_pin.sym} 73380 -38450 0 0 {name=p72570 lab=_66048_/Y }
C {devices/lab_pin.sym} 73540 -38490 0 1 {name=p72571 lab=_84160_/D }
C {sky130_stdcells/a21o_4.sym} 73460 -38490 0 0 {name=X_66049_ }
C {devices/lab_pin.sym} 73380 -38370 0 0 {name=p72572 lab=_51273_/Y }
C {devices/lab_pin.sym} 73380 -38330 0 0 {name=p72573 lab=_51263_/X }
C {devices/lab_pin.sym} 73380 -38290 0 0 {name=p72574 lab=_51274_/X }
C {devices/lab_pin.sym} 73540 -38330 0 1 {name=p72575 lab=_51275_/Y }
C {sky130_stdcells/a21oi_4.sym} 73460 -38330 0 0 {name=X_51275_ }
C {devices/lab_pin.sym} 73370 -38190 0 0 {name=p72576 lab=_87473_/CLK }
C {devices/lab_pin.sym} 73370 -38170 0 0 {name=p72577 lab=_44756_/X }
C {devices/lab_pin.sym} 73550 -38190 0 1 {name=p72578 lab=_86972_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -38180 0 0 {name=X_86972_ }
C {devices/lab_pin.sym} 73370 -38050 0 0 {name=p72579 lab=_82015_/CLK }
C {devices/lab_pin.sym} 73370 -38030 0 0 {name=p72580 lab=_82095_/D }
C {devices/lab_pin.sym} 73550 -38050 0 1 {name=p72581 lab=_82095_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -38040 0 0 {name=X_82095_ }
C {devices/lab_pin.sym} 73420 -37910 0 0 {name=p72582 lab=_53069_/A }
C {devices/lab_pin.sym} 73500 -37910 0 1 {name=p72583 lab=_53036_/B }
C {sky130_stdcells/buf_2.sym} 73460 -37910 0 0 {name=X_53014_ }
C {devices/lab_pin.sym} 73420 -37790 0 0 {name=p72584 lab=_50473_/A }
C {devices/lab_pin.sym} 73500 -37790 0 1 {name=p72585 lab=_50227_/A }
C {sky130_stdcells/buf_2.sym} 73460 -37790 0 0 {name=X_50226_ }
C {devices/lab_pin.sym} 73370 -37670 0 0 {name=p72586 lab=_85444_/CLK }
C {devices/lab_pin.sym} 73370 -37650 0 0 {name=p72587 lab=_51915_/Y }
C {devices/lab_pin.sym} 73550 -37670 0 1 {name=p72588 lab=_85923_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -37660 0 0 {name=X_85923_ }
C {devices/lab_pin.sym} 73420 -37530 0 0 {name=p72589 lab=clkbuf_9_166_0_CLK/X }
C {devices/lab_pin.sym} 73500 -37530 0 1 {name=p72590 lab=_86665_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 73460 -37530 0 0 {name=Xclkbuf_10_333_0_CLK }
C {devices/lab_pin.sym} 73370 -37410 0 0 {name=p72591 lab=_81082_/CLK }
C {devices/lab_pin.sym} 73370 -37390 0 0 {name=p72592 lab=_75370_/X }
C {devices/lab_pin.sym} 73550 -37410 0 1 {name=p72593 lab=_81046_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -37400 0 0 {name=X_81046_ }
C {devices/lab_pin.sym} 73420 -37270 0 0 {name=p72594 lab=_58599_/A }
C {devices/lab_pin.sym} 73500 -37270 0 1 {name=p72595 lab=_58871_/X }
C {sky130_stdcells/buf_2.sym} 73460 -37270 0 0 {name=X_58871_ }
C {devices/lab_pin.sym} 73420 -37150 0 0 {name=p72596 lab=clkbuf_9_481_0_CLK/X }
C {devices/lab_pin.sym} 73500 -37150 0 1 {name=p72597 lab=_85630_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 73460 -37150 0 0 {name=Xclkbuf_10_963_0_CLK }
C {devices/lab_pin.sym} 73420 -37030 0 0 {name=p72598 lab=_58098_/A }
C {devices/lab_pin.sym} 73500 -37030 0 1 {name=p72599 lab=_57822_/X }
C {sky130_stdcells/buf_2.sym} 73460 -37030 0 0 {name=X_57822_ }
C {devices/lab_pin.sym} 73400 -36920 0 0 {name=p72600 lab=_69897_/A }
C {devices/lab_pin.sym} 73400 -36880 0 0 {name=p72601 lab=_69808_/B }
C {devices/lab_pin.sym} 73520 -36900 0 1 {name=p72602 lab=_69808_/Y }
C {sky130_stdcells/nor2_4.sym} 73460 -36900 0 0 {name=X_69808_ }
C {devices/lab_pin.sym} 73380 -36790 0 0 {name=p72603 lab=_50154_/Y }
C {devices/lab_pin.sym} 73380 -36750 0 0 {name=p72604 lab=_50141_/X }
C {devices/lab_pin.sym} 73380 -36710 0 0 {name=p72605 lab=_50156_/X }
C {devices/lab_pin.sym} 73540 -36750 0 1 {name=p72606 lab=_50157_/Y }
C {sky130_stdcells/a21oi_4.sym} 73460 -36750 0 0 {name=X_50157_ }
C {devices/lab_pin.sym} 73370 -36610 0 0 {name=p72607 lab=_85566_/CLK }
C {devices/lab_pin.sym} 73370 -36590 0 0 {name=p72608 lab=_52282_/Y }
C {devices/lab_pin.sym} 73550 -36610 0 1 {name=p72609 lab=_85854_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -36600 0 0 {name=X_85854_ }
C {devices/lab_pin.sym} 73420 -36470 0 0 {name=p72610 lab=clkbuf_9_455_0_CLK/A }
C {devices/lab_pin.sym} 73500 -36470 0 1 {name=p72611 lab=clkbuf_9_454_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 73460 -36470 0 0 {name=Xclkbuf_9_454_0_CLK }
C {devices/lab_pin.sym} 73370 -36350 0 0 {name=p72612 lab=_84150_/CLK }
C {devices/lab_pin.sym} 73370 -36330 0 0 {name=p72613 lab=_84805_/D }
C {devices/lab_pin.sym} 73550 -36350 0 1 {name=p72614 lab=_84805_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -36340 0 0 {name=X_84805_ }
C {devices/lab_pin.sym} 73420 -36210 0 0 {name=p72615 lab=_84949_/Q }
C {devices/lab_pin.sym} 73500 -36210 0 1 {name=p72616 lab=_57753_/Y }
C {sky130_stdcells/inv_2.sym} 73460 -36210 0 0 {name=X_57753_ }
C {devices/lab_pin.sym} 73380 -36110 0 0 {name=p72617 lab=_69736_/X }
C {devices/lab_pin.sym} 73380 -36070 0 0 {name=p72618 lab=_69738_/X }
C {devices/lab_pin.sym} 73380 -36030 0 0 {name=p72619 lab=_69678_/X }
C {devices/lab_pin.sym} 73540 -36070 0 1 {name=p72620 lab=_69739_/X }
C {sky130_stdcells/a21o_4.sym} 73460 -36070 0 0 {name=X_69739_ }
C {devices/lab_pin.sym} 73420 -35930 0 0 {name=p72621 lab=_48836_/A }
C {devices/lab_pin.sym} 73500 -35930 0 1 {name=p72622 lab=_50088_/X }
C {sky130_stdcells/buf_2.sym} 73460 -35930 0 0 {name=X_50088_ }
C {devices/lab_pin.sym} 73380 -35830 0 0 {name=p72623 lab=_54962_/Y }
C {devices/lab_pin.sym} 73380 -35790 0 0 {name=p72624 lab=_54253_/X }
C {devices/lab_pin.sym} 73380 -35750 0 0 {name=p72625 lab=_54964_/X }
C {devices/lab_pin.sym} 73540 -35790 0 1 {name=p72626 lab=_54965_/Y }
C {sky130_stdcells/a21oi_4.sym} 73460 -35790 0 0 {name=X_54965_ }
C {devices/lab_pin.sym} 73370 -35650 0 0 {name=p72627 lab=_82768_/CLK }
C {devices/lab_pin.sym} 73370 -35630 0 0 {name=p72628 lab=_85785_/D }
C {devices/lab_pin.sym} 73550 -35650 0 1 {name=p72629 lab=_85785_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -35640 0 0 {name=X_85785_ }
C {devices/lab_pin.sym} 73370 -35510 0 0 {name=p72630 lab=_85013_/CLK }
C {devices/lab_pin.sym} 73370 -35490 0 0 {name=p72631 lab=_74653_/X }
C {devices/lab_pin.sym} 73550 -35510 0 1 {name=p72632 lab=_82997_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -35500 0 0 {name=X_82997_ }
C {devices/lab_pin.sym} 73420 -35370 0 0 {name=p72633 lab=clkbuf_9_174_0_CLK/X }
C {devices/lab_pin.sym} 73500 -35370 0 1 {name=p72634 lab=_85648_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 73460 -35370 0 0 {name=Xclkbuf_10_348_0_CLK }
C {devices/lab_pin.sym} 73420 -35250 0 0 {name=p72635 lab=_44290_/X }
C {devices/lab_pin.sym} 73500 -35250 0 1 {name=p72636 lab=_56704_/X }
C {sky130_stdcells/buf_2.sym} 73460 -35250 0 0 {name=X_56704_ }
C {devices/lab_pin.sym} 73370 -35130 0 0 {name=p72637 lab=_87782_/CLK }
C {devices/lab_pin.sym} 73370 -35110 0 0 {name=p72638 lab=_43238_/Y }
C {devices/lab_pin.sym} 73550 -35130 0 1 {name=p72639 lab=_87524_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -35120 0 0 {name=X_87524_ }
C {devices/lab_pin.sym} 73420 -34990 0 0 {name=p72640 lab=_41930_/A }
C {devices/lab_pin.sym} 73500 -34990 0 1 {name=p72641 lab=_41930_/Y }
C {sky130_stdcells/inv_2.sym} 73460 -34990 0 0 {name=X_41930_ }
C {devices/lab_pin.sym} 73380 -34890 0 0 {name=p72642 lab=_53913_/Y }
C {devices/lab_pin.sym} 73380 -34850 0 0 {name=p72643 lab=_53914_/X }
C {devices/lab_pin.sym} 73380 -34810 0 0 {name=p72644 lab=_53915_/Y }
C {devices/lab_pin.sym} 73540 -34850 0 1 {name=p72645 lab=_85543_/D }
C {sky130_stdcells/a21boi_4.sym} 73460 -34850 0 0 {name=X_53916_ }
C {devices/lab_pin.sym} 73420 -34710 0 0 {name=p72646 lab=_73257_/A }
C {devices/lab_pin.sym} 73500 -34710 0 1 {name=p72647 lab=_72750_/X }
C {sky130_stdcells/buf_2.sym} 73460 -34710 0 0 {name=X_72750_ }
C {devices/lab_pin.sym} 73370 -34590 0 0 {name=p72648 lab=_84829_/CLK }
C {devices/lab_pin.sym} 73370 -34570 0 0 {name=p72649 lab=_84736_/D }
C {devices/lab_pin.sym} 73550 -34590 0 1 {name=p72650 lab=_59427_/A }
C {sky130_stdcells/dfxtp_4.sym} 73460 -34580 0 0 {name=X_84736_ }
C {devices/lab_pin.sym} 73400 -34460 0 0 {name=p72651 lab=_57683_/X }
C {devices/lab_pin.sym} 73400 -34420 0 0 {name=p72652 lab=_57666_/B }
C {devices/lab_pin.sym} 73520 -34440 0 1 {name=p72653 lab=_57684_/Y }
C {sky130_stdcells/nor2_4.sym} 73460 -34440 0 0 {name=X_57684_ }
C {devices/lab_pin.sym} 73370 -34310 0 0 {name=p72654 lab=_81970_/CLK }
C {devices/lab_pin.sym} 73370 -34290 0 0 {name=p72655 lab=_81948_/D }
C {devices/lab_pin.sym} 73550 -34310 0 1 {name=p72656 lab=_77628_/A }
C {sky130_stdcells/dfxtp_4.sym} 73460 -34300 0 0 {name=X_81948_ }
C {devices/lab_pin.sym} 73400 -34200 0 0 {name=p72657 lab=_54910_/A }
C {devices/lab_pin.sym} 73400 -34160 0 0 {name=p72658 lab=_54883_/B }
C {devices/lab_pin.sym} 73400 -34120 0 0 {name=p72659 lab=_54910_/C }
C {devices/lab_pin.sym} 73400 -34080 0 0 {name=p72660 lab=_53203_/D }
C {devices/lab_pin.sym} 73520 -34140 0 1 {name=p72661 lab=_54896_/X }
C {sky130_stdcells/and4_4.sym} 73460 -34140 0 0 {name=X_54896_ }
C {devices/lab_pin.sym} 73420 -33990 0 0 {name=p72662 lab=clkbuf_9_489_0_CLK/X }
C {devices/lab_pin.sym} 73500 -33990 0 1 {name=p72663 lab=_83613_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 73460 -33990 0 0 {name=Xclkbuf_10_978_0_CLK }
C {devices/lab_pin.sym} 73380 -33890 0 0 {name=p72664 lab=_58290_/Y }
C {devices/lab_pin.sym} 73380 -33850 0 0 {name=p72665 lab=_71695_/X }
C {devices/lab_pin.sym} 73380 -33810 0 0 {name=p72666 lab=_71700_/Y }
C {devices/lab_pin.sym} 73540 -33850 0 1 {name=p72667 lab=_71701_/Y }
C {sky130_stdcells/o21ai_4.sym} 73460 -33850 0 0 {name=X_71701_ }
C {devices/lab_pin.sym} 73420 -33710 0 0 {name=p72668 lab=_59423_/A }
C {devices/lab_pin.sym} 73500 -33710 0 1 {name=p72669 lab=_59423_/Y }
C {sky130_stdcells/inv_2.sym} 73460 -33710 0 0 {name=X_59423_ }
C {devices/lab_pin.sym} 73380 -33620 0 0 {name=p72670 lab=_56587_/X }
C {devices/lab_pin.sym} 73380 -33580 0 0 {name=p72671 lab=_56634_/X }
C {devices/lab_pin.sym} 73380 -33540 0 0 {name=p72672 lab=_55499_/B }
C {devices/lab_pin.sym} 73380 -33500 0 0 {name=p72673 lab=_56590_/X }
C {devices/lab_pin.sym} 73540 -33560 0 1 {name=p72674 lab=_85141_/D }
C {sky130_stdcells/a2bb2o_4.sym} 73460 -33560 0 0 {name=X_56635_ }
C {devices/lab_pin.sym} 73370 -33410 0 0 {name=p72675 lab=_87720_/CLK }
C {devices/lab_pin.sym} 73370 -33390 0 0 {name=p72676 lab=_87455_/D }
C {devices/lab_pin.sym} 73550 -33410 0 1 {name=p72677 lab=_87455_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -33400 0 0 {name=X_87455_ }
C {devices/lab_pin.sym} 73420 -33270 0 0 {name=p72678 lab=_40363_/X }
C {devices/lab_pin.sym} 73500 -33270 0 1 {name=p72679 lab=_57491_/B }
C {sky130_stdcells/buf_2.sym} 73460 -33270 0 0 {name=X_41861_ }
C {devices/lab_pin.sym} 73420 -33150 0 0 {name=p72680 lab=_53956_/A }
C {devices/lab_pin.sym} 73500 -33150 0 1 {name=p72681 lab=_53848_/A }
C {sky130_stdcells/buf_2.sym} 73460 -33150 0 0 {name=X_53847_ }
C {devices/lab_pin.sym} 73400 -33050 0 0 {name=p72682 lab=_72683_/A }
C {devices/lab_pin.sym} 73400 -33010 0 0 {name=p72683 lab=_72683_/B }
C {devices/lab_pin.sym} 73400 -32970 0 0 {name=p72684 lab=_55387_/X }
C {devices/lab_pin.sym} 73520 -33010 0 1 {name=p72685 lab=_72681_/Y }
C {sky130_stdcells/nand3_4.sym} 73460 -33010 0 0 {name=X_72681_ }
C {devices/lab_pin.sym} 73370 -32870 0 0 {name=p72686 lab=_84660_/CLK }
C {devices/lab_pin.sym} 73370 -32850 0 0 {name=p72687 lab=_84667_/D }
C {devices/lab_pin.sym} 73550 -32870 0 1 {name=p72688 lab=_60067_/C }
C {sky130_stdcells/dfxtp_4.sym} 73460 -32860 0 0 {name=X_84667_ }
C {devices/lab_pin.sym} 73370 -32730 0 0 {name=p72689 lab=_82221_/CLK }
C {devices/lab_pin.sym} 73370 -32710 0 0 {name=p72690 lab=_78070_/X }
C {devices/lab_pin.sym} 73550 -32730 0 1 {name=p72691 lab=_81879_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -32720 0 0 {name=X_81879_ }
C {devices/lab_pin.sym} 73420 -32590 0 0 {name=p72692 lab=clkbuf_9_469_0_CLK/A }
C {devices/lab_pin.sym} 73500 -32590 0 1 {name=p72693 lab=clkbuf_9_469_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 73460 -32590 0 0 {name=Xclkbuf_9_469_0_CLK }
C {devices/lab_pin.sym} 73380 -32500 0 0 {name=p72694 lab=_40581_/A }
C {devices/lab_pin.sym} 73380 -32460 0 0 {name=p72695 lab=_43586_/X }
C {devices/lab_pin.sym} 73380 -32420 0 0 {name=p72696 lab=_68418_/B }
C {devices/lab_pin.sym} 73380 -32380 0 0 {name=p72697 lab=_43593_/X }
C {devices/lab_pin.sym} 73540 -32440 0 1 {name=p72698 lab=_43600_/X }
C {sky130_stdcells/a2bb2o_4.sym} 73460 -32440 0 0 {name=X_43600_ }
C {devices/lab_pin.sym} 73420 -32290 0 0 {name=p72699 lab=_74453_/A }
C {devices/lab_pin.sym} 73500 -32290 0 1 {name=p72700 lab=_74420_/X }
C {sky130_stdcells/buf_2.sym} 73460 -32290 0 0 {name=X_74420_ }
C {devices/lab_pin.sym} 73370 -32170 0 0 {name=p72701 lab=_83783_/CLK }
C {devices/lab_pin.sym} 73370 -32150 0 0 {name=p72702 lab=_49343_/Y }
C {devices/lab_pin.sym} 73550 -32170 0 1 {name=p72703 lab=_65310_/B }
C {sky130_stdcells/dfxtp_4.sym} 73460 -32160 0 0 {name=X_86406_ }
C {devices/lab_pin.sym} 73400 -32040 0 0 {name=p72704 lab=_82871_/Q }
C {devices/lab_pin.sym} 73400 -32000 0 0 {name=p72705 lab=_40847_/B }
C {devices/lab_pin.sym} 73520 -32020 0 1 {name=p72706 lab=_40812_/X }
C {sky130_stdcells/or2_4.sym} 73460 -32020 0 0 {name=X_40812_ }
C {devices/lab_pin.sym} 73370 -31890 0 0 {name=p72707 lab=_85562_/CLK }
C {devices/lab_pin.sym} 73370 -31870 0 0 {name=p72708 lab=_71067_/Y }
C {devices/lab_pin.sym} 73550 -31890 0 1 {name=p72709 lab=_83618_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -31880 0 0 {name=X_83618_ }
C {devices/lab_pin.sym} 73400 -31770 0 0 {name=p72710 lab=_71258_/A }
C {devices/lab_pin.sym} 73400 -31730 0 0 {name=p72711 lab=_71246_/B }
C {devices/lab_pin.sym} 73400 -31690 0 0 {name=p72712 lab=_71637_/C }
C {devices/lab_pin.sym} 73520 -31730 0 1 {name=p72713 lab=_71632_/Y }
C {sky130_stdcells/nand3_4.sym} 73460 -31730 0 0 {name=X_71632_ }
C {devices/lab_pin.sym} 73420 -31590 0 0 {name=p72714 lab=_84748_/Q }
C {devices/lab_pin.sym} 73500 -31590 0 1 {name=p72715 lab=_59354_/Y }
C {sky130_stdcells/inv_2.sym} 73460 -31590 0 0 {name=X_59354_ }
C {devices/lab_pin.sym} 73420 -31470 0 0 {name=p72716 lab=_44579_/Y }
C {devices/lab_pin.sym} 73500 -31470 0 1 {name=p72717 lab=_87047_/D }
C {sky130_stdcells/inv_2.sym} 73460 -31470 0 0 {name=X_44580_ }
C {devices/lab_pin.sym} 73380 -31370 0 0 {name=p72718 lab=_55640_/Y }
C {devices/lab_pin.sym} 73380 -31330 0 0 {name=p72719 lab=_56553_/Y }
C {devices/lab_pin.sym} 73380 -31290 0 0 {name=p72720 lab=_56565_/Y }
C {devices/lab_pin.sym} 73540 -31330 0 1 {name=p72721 lab=_85153_/D }
C {sky130_stdcells/o21ai_4.sym} 73460 -31330 0 0 {name=X_56566_ }
C {devices/lab_pin.sym} 73420 -31190 0 0 {name=p72722 lab=_41607_/X }
C {devices/lab_pin.sym} 73500 -31190 0 1 {name=p72723 lab=_41792_/X }
C {sky130_stdcells/buf_2.sym} 73460 -31190 0 0 {name=X_41792_ }
C {devices/lab_pin.sym} 73370 -31070 0 0 {name=p72724 lab=_86920_/CLK }
C {devices/lab_pin.sym} 73370 -31050 0 0 {name=p72725 lab=_87386_/D }
C {devices/lab_pin.sym} 73550 -31070 0 1 {name=p72726 lab=_87386_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -31060 0 0 {name=X_87386_ }
C {devices/lab_pin.sym} 73400 -30940 0 0 {name=p72727 lab=_53778_/A }
C {devices/lab_pin.sym} 73400 -30900 0 0 {name=p72728 lab=_50556_/B }
C {devices/lab_pin.sym} 73520 -30920 0 1 {name=p72729 lab=_53778_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -30920 0 0 {name=X_53778_ }
C {devices/lab_pin.sym} 73370 -30790 0 0 {name=p72730 lab=_84606_/CLK }
C {devices/lab_pin.sym} 73370 -30770 0 0 {name=p72731 lab=_60569_/Y }
C {devices/lab_pin.sym} 73550 -30790 0 1 {name=p72732 lab=_79138_/A }
C {sky130_stdcells/dfxtp_4.sym} 73460 -30780 0 0 {name=X_84598_ }
C {devices/lab_pin.sym} 73400 -30660 0 0 {name=p72733 lab=_63703_/B }
C {devices/lab_pin.sym} 73400 -30620 0 0 {name=p72734 lab=_58344_/B }
C {devices/lab_pin.sym} 73520 -30640 0 1 {name=p72735 lab=_58305_/Y }
C {sky130_stdcells/nor2_4.sym} 73460 -30640 0 0 {name=X_58305_ }
C {devices/lab_pin.sym} 73420 -30510 0 0 {name=p72736 lab=clkbuf_9_450_0_CLK/X }
C {devices/lab_pin.sym} 73500 -30510 0 1 {name=p72737 lab=_82541_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 73460 -30510 0 0 {name=Xclkbuf_10_901_0_CLK }
C {devices/lab_pin.sym} 73420 -30390 0 0 {name=p72738 lab=_43178_/X }
C {devices/lab_pin.sym} 73500 -30390 0 1 {name=p72739 lab=_53443_/A }
C {sky130_stdcells/buf_2.sym} 73460 -30390 0 0 {name=X_43531_ }
C {devices/lab_pin.sym} 73420 -30270 0 0 {name=p72740 lab=_55516_/X }
C {devices/lab_pin.sym} 73500 -30270 0 1 {name=p72741 lab=_55517_/X }
C {sky130_stdcells/buf_2.sym} 73460 -30270 0 0 {name=X_55517_ }
C {devices/lab_pin.sym} 73400 -30170 0 0 {name=p72742 lab=_74351_/A }
C {devices/lab_pin.sym} 73400 -30130 0 0 {name=p72743 lab=_74342_/X }
C {devices/lab_pin.sym} 73400 -30090 0 0 {name=p72744 lab=_56117_/C }
C {devices/lab_pin.sym} 73520 -30130 0 1 {name=p72745 lab=_74351_/Y }
C {sky130_stdcells/nand3_4.sym} 73460 -30130 0 0 {name=X_74351_ }
C {devices/lab_pin.sym} 73370 -29990 0 0 {name=p72746 lab=_86655_/CLK }
C {devices/lab_pin.sym} 73370 -29970 0 0 {name=p72747 lab=_49714_/Y }
C {devices/lab_pin.sym} 73550 -29990 0 1 {name=p72748 lab=_57692_/B }
C {sky130_stdcells/dfxtp_4.sym} 73460 -29980 0 0 {name=X_86337_ }
C {devices/lab_pin.sym} 73420 -29850 0 0 {name=p72749 lab=_40742_/X }
C {devices/lab_pin.sym} 73500 -29850 0 1 {name=p72750 lab=_40743_/X }
C {sky130_stdcells/buf_2.sym} 73460 -29850 0 0 {name=X_40743_ }
C {devices/lab_pin.sym} 73420 -29730 0 0 {name=p72751 lab=_52648_/A }
C {devices/lab_pin.sym} 73500 -29730 0 1 {name=p72752 lab=_52729_/X }
C {sky130_stdcells/buf_2.sym} 73460 -29730 0 0 {name=X_52729_ }
C {devices/lab_pin.sym} 73380 -29630 0 0 {name=p72753 lab=_59260_/X }
C {devices/lab_pin.sym} 73380 -29590 0 0 {name=p72754 lab=_85418_/Q }
C {devices/lab_pin.sym} 73380 -29550 0 0 {name=p72755 lab=_59284_/X }
C {devices/lab_pin.sym} 73540 -29590 0 1 {name=p72756 lab=_59285_/Y }
C {sky130_stdcells/o21ai_4.sym} 73460 -29590 0 0 {name=X_59285_ }
C {devices/lab_pin.sym} 73400 -29470 0 0 {name=p72757 lab=_71698_/A }
C {devices/lab_pin.sym} 73400 -29430 0 0 {name=p72758 lab=_71553_/B }
C {devices/lab_pin.sym} 73400 -29390 0 0 {name=p72759 lab=_71558_/X }
C {devices/lab_pin.sym} 73520 -29430 0 1 {name=p72760 lab=_71563_/Y }
C {sky130_stdcells/nor3_4.sym} 73460 -29430 0 0 {name=X_71563_ }
C {devices/lab_pin.sym} 73370 -29290 0 0 {name=p72761 lab=_83550_/CLK }
C {devices/lab_pin.sym} 73370 -29270 0 0 {name=p72762 lab=_71280_/Y }
C {devices/lab_pin.sym} 73550 -29290 0 1 {name=p72763 lab=_47716_/A }
C {sky130_stdcells/dfxtp_4.sym} 73460 -29280 0 0 {name=X_83549_ }
C {devices/lab_pin.sym} 73400 -29170 0 0 {name=p72764 lab=_56487_/X }
C {devices/lab_pin.sym} 73400 -29130 0 0 {name=p72765 lab=_56507_/B }
C {devices/lab_pin.sym} 73400 -29090 0 0 {name=p72766 lab=_55876_/B }
C {devices/lab_pin.sym} 73520 -29130 0 1 {name=p72767 lab=_56497_/Y }
C {sky130_stdcells/nand3_4.sym} 73460 -29130 0 0 {name=X_56497_ }
C {devices/lab_pin.sym} 73380 -29010 0 0 {name=p72768 lab=_88318_/Q }
C {devices/lab_pin.sym} 73380 -28970 0 0 {name=p72769 lab=_73059_/X }
C {devices/lab_pin.sym} 73380 -28930 0 0 {name=p72770 lab=_73007_/X }
C {devices/lab_pin.sym} 73540 -28970 0 1 {name=p72771 lab=_73302_/Y }
C {sky130_stdcells/o21ai_4.sym} 73460 -28970 0 0 {name=X_73302_ }
C {devices/lab_pin.sym} 73420 -28830 0 0 {name=p72772 lab=_46279_/A }
C {devices/lab_pin.sym} 73500 -28830 0 1 {name=p72773 lab=_46250_/X }
C {sky130_stdcells/buf_2.sym} 73460 -28830 0 0 {name=X_46250_ }
C {devices/lab_pin.sym} 73400 -28730 0 0 {name=p72774 lab=_70511_/A }
C {devices/lab_pin.sym} 73400 -28690 0 0 {name=p72775 lab=_70945_/B }
C {devices/lab_pin.sym} 73400 -28650 0 0 {name=p72776 lab=_70508_/X }
C {devices/lab_pin.sym} 73520 -28690 0 1 {name=p72777 lab=_70514_/Y }
C {sky130_stdcells/nand3_4.sym} 73460 -28690 0 0 {name=X_70514_ }
C {sky130_stdcells/decap_3.sym} 73460 -28520 0 0 {name=XPHY_620 }
C {devices/lab_pin.sym} 73420 -28370 0 0 {name=p72778 lab=_83396_/Q }
C {devices/lab_pin.sym} 73500 -28370 0 1 {name=p72779 lab=_58236_/Y }
C {sky130_stdcells/inv_2.sym} 73460 -28370 0 0 {name=X_58236_ }
C {devices/lab_pin.sym} 73400 -28260 0 0 {name=p72780 lab=_77069_/A }
C {devices/lab_pin.sym} 73400 -28220 0 0 {name=p72781 lab=_82283_/D }
C {devices/lab_pin.sym} 73520 -28240 0 1 {name=p72782 lab=_77070_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -28240 0 0 {name=X_77070_ }
C {devices/lab_pin.sym} 73380 -28140 0 0 {name=p72783 lab=_41636_/X }
C {devices/lab_pin.sym} 73380 -28100 0 0 {name=p72784 lab=_43446_/X }
C {devices/lab_pin.sym} 73380 -28060 0 0 {name=p72785 lab=_87410_/Q }
C {devices/lab_pin.sym} 73380 -28020 0 0 {name=p72786 lab=_43447_/X }
C {devices/lab_pin.sym} 73540 -28080 0 1 {name=p72787 lab=_43462_/X }
C {sky130_stdcells/a2bb2o_4.sym} 73460 -28080 0 0 {name=X_43462_ }
C {devices/lab_pin.sym} 73420 -27930 0 0 {name=p72788 lab=_55446_/A }
C {devices/lab_pin.sym} 73500 -27930 0 1 {name=p72789 lab=_55448_/Y }
C {sky130_stdcells/inv_2.sym} 73460 -27930 0 0 {name=X_55448_ }
C {devices/lab_pin.sym} 73370 -27810 0 0 {name=p72790 lab=_83306_/CLK }
C {devices/lab_pin.sym} 73370 -27790 0 0 {name=p72791 lab=_50083_/Y }
C {devices/lab_pin.sym} 73550 -27810 0 1 {name=p72792 lab=_64755_/B }
C {sky130_stdcells/dfxtp_4.sym} 73460 -27800 0 0 {name=X_86268_ }
C {devices/lab_pin.sym} 73380 -27690 0 0 {name=p72793 lab=_74280_/X }
C {devices/lab_pin.sym} 73380 -27650 0 0 {name=p72794 lab=_74281_/Y }
C {devices/lab_pin.sym} 73380 -27610 0 0 {name=p72795 lab=_72630_/X }
C {devices/lab_pin.sym} 73540 -27650 0 1 {name=p72796 lab=_74282_/X }
C {sky130_stdcells/a21o_4.sym} 73460 -27650 0 0 {name=X_74282_ }
C {sky130_stdcells/decap_3.sym} 73460 -27480 0 0 {name=XPHY_631 }
C {devices/lab_pin.sym} 73380 -27360 0 0 {name=p72797 lab=_40673_/X }
C {devices/lab_pin.sym} 73380 -27320 0 0 {name=p72798 lab=_40651_/X }
C {devices/lab_pin.sym} 73380 -27280 0 0 {name=p72799 lab=_68750_/B }
C {devices/lab_pin.sym} 73380 -27240 0 0 {name=p72800 lab=_40652_/X }
C {devices/lab_pin.sym} 73540 -27300 0 1 {name=p72801 lab=_88356_/D }
C {sky130_stdcells/a2bb2o_4.sym} 73460 -27300 0 0 {name=X_40674_ }
C {devices/lab_pin.sym} 73400 -27170 0 0 {name=p72802 lab=_71488_/X }
C {devices/lab_pin.sym} 73400 -27130 0 0 {name=p72803 lab=_71427_/C }
C {devices/lab_pin.sym} 73400 -27090 0 0 {name=p72804 lab=_71496_/C }
C {devices/lab_pin.sym} 73520 -27130 0 1 {name=p72805 lab=_71494_/X }
C {sky130_stdcells/and3_4.sym} 73460 -27130 0 0 {name=X_71494_ }
C {sky130_stdcells/decap_3.sym} 73460 -26960 0 0 {name=XPHY_642 }
C {sky130_stdcells/decap_3.sym} 73460 -26780 0 0 {name=XPHY_653 }
C {devices/lab_pin.sym} 73380 -26650 0 0 {name=p72806 lab=_45195_/X }
C {devices/lab_pin.sym} 73380 -26610 0 0 {name=p72807 lab=_45199_/Y }
C {devices/lab_pin.sym} 73380 -26570 0 0 {name=p72808 lab=_45200_/X }
C {devices/lab_pin.sym} 73540 -26610 0 1 {name=p72809 lab=_45201_/Y }
C {sky130_stdcells/a21oi_4.sym} 73460 -26610 0 0 {name=X_45201_ }
C {devices/lab_pin.sym} 73400 -26480 0 0 {name=p72810 lab=_81711_/D }
C {devices/lab_pin.sym} 73400 -26440 0 0 {name=p72811 lab=_76021_/B }
C {devices/lab_pin.sym} 73520 -26460 0 1 {name=p72812 lab=_76021_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -26460 0 0 {name=X_76021_ }
C {devices/lab_pin.sym} 73370 -26330 0 0 {name=p72813 lab=_87249_/CLK }
C {devices/lab_pin.sym} 73370 -26310 0 0 {name=p72814 lab=_88007_/D }
C {devices/lab_pin.sym} 73550 -26330 0 1 {name=p72815 lab=_88007_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -26320 0 0 {name=X_88007_ }
C {devices/lab_pin.sym} 73420 -26190 0 0 {name=p72816 lab=_42412_/Y }
C {devices/lab_pin.sym} 73500 -26190 0 1 {name=p72817 lab=_42413_/Y }
C {sky130_stdcells/inv_2.sym} 73460 -26190 0 0 {name=X_42413_ }
C {sky130_stdcells/decap_3.sym} 73460 -26040 0 0 {name=XPHY_664 }
C {devices/lab_pin.sym} 73400 -25900 0 0 {name=p72818 lab=_73206_/X }
C {devices/lab_pin.sym} 73400 -25860 0 0 {name=p72819 lab=_85871_/Q }
C {devices/lab_pin.sym} 73520 -25880 0 1 {name=p72820 lab=_73233_/X }
C {sky130_stdcells/and2_4.sym} 73460 -25880 0 0 {name=X_73233_ }
C {devices/lab_pin.sym} 73370 -25750 0 0 {name=p72821 lab=_85186_/CLK }
C {devices/lab_pin.sym} 73370 -25730 0 0 {name=p72822 lab=_85219_/D }
C {devices/lab_pin.sym} 73550 -25750 0 1 {name=p72823 lab=_55713_/B }
C {sky130_stdcells/dfxtp_4.sym} 73460 -25740 0 0 {name=X_85219_ }
C {devices/lab_pin.sym} 73420 -25610 0 0 {name=p72824 lab=_46098_/A }
C {devices/lab_pin.sym} 73500 -25610 0 1 {name=p72825 lab=_46181_/Y }
C {sky130_stdcells/inv_2.sym} 73460 -25610 0 0 {name=X_46181_ }
C {devices/lab_pin.sym} 73400 -25510 0 0 {name=p72826 lab=_71650_/A }
C {devices/lab_pin.sym} 73400 -25470 0 0 {name=p72827 lab=_74529_/A }
C {devices/lab_pin.sym} 73400 -25430 0 0 {name=p72828 lab=_71194_/C }
C {devices/lab_pin.sym} 73520 -25470 0 1 {name=p72829 lab=_70445_/Y }
C {sky130_stdcells/nand3_4.sym} 73460 -25470 0 0 {name=X_70445_ }
C {devices/lab_pin.sym} 73420 -25330 0 0 {name=p72830 lab=_63069_/A }
C {devices/lab_pin.sym} 73500 -25330 0 1 {name=p72831 lab=_64272_/A }
C {sky130_stdcells/buf_2.sym} 73460 -25330 0 0 {name=X_58167_ }
C {sky130_stdcells/decap_3.sym} 73460 -25180 0 0 {name=XPHY_675 }
C {devices/lab_pin.sym} 73380 -25060 0 0 {name=p72832 lab=_41454_/X }
C {devices/lab_pin.sym} 73380 -25020 0 0 {name=p72833 lab=_43386_/X }
C {devices/lab_pin.sym} 73380 -24980 0 0 {name=p72834 lab=_87444_/Q }
C {devices/lab_pin.sym} 73380 -24940 0 0 {name=p72835 lab=_43388_/X }
C {devices/lab_pin.sym} 73540 -25000 0 1 {name=p72836 lab=_87444_/D }
C {sky130_stdcells/a2bb2o_4.sym} 73460 -25000 0 0 {name=X_43393_ }
C {devices/lab_pin.sym} 73420 -24850 0 0 {name=p72837 lab=_55378_/X }
C {devices/lab_pin.sym} 73500 -24850 0 1 {name=p72838 lab=_55379_/Y }
C {sky130_stdcells/inv_2.sym} 73460 -24850 0 0 {name=X_55379_ }
C {devices/lab_pin.sym} 73370 -24730 0 0 {name=p72839 lab=_86196_/CLK }
C {devices/lab_pin.sym} 73370 -24710 0 0 {name=p72840 lab=_86199_/D }
C {devices/lab_pin.sym} 73550 -24730 0 1 {name=p72841 lab=_86199_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -24720 0 0 {name=X_86199_ }
C {sky130_stdcells/decap_3.sym} 73460 -24560 0 0 {name=XPHY_686 }
C {sky130_stdcells/decap_3.sym} 73460 -24380 0 0 {name=XPHY_697 }
C {devices/lab_pin.sym} 73420 -24230 0 0 {name=p72842 lab=clkbuf_9_458_0_CLK/X }
C {devices/lab_pin.sym} 73500 -24230 0 1 {name=p72843 lab=_84980_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 73460 -24230 0 0 {name=Xclkbuf_10_916_0_CLK }
C {devices/lab_pin.sym} 73380 -24130 0 0 {name=p72844 lab=_55846_/B }
C {devices/lab_pin.sym} 73380 -24090 0 0 {name=p72845 lab=_45131_/X }
C {devices/lab_pin.sym} 73380 -24050 0 0 {name=p72846 lab=_45087_/X }
C {devices/lab_pin.sym} 73540 -24090 0 1 {name=p72847 lab=_45132_/X }
C {sky130_stdcells/o21a_4.sym} 73460 -24090 0 0 {name=X_45132_ }
C {devices/lab_pin.sym} 73380 -23980 0 0 {name=p72848 lab=_57109_/X }
C {devices/lab_pin.sym} 73380 -23940 0 0 {name=p72849 lab=_56630_/X }
C {devices/lab_pin.sym} 73380 -23900 0 0 {name=p72850 lab=_85078_/Q }
C {devices/lab_pin.sym} 73380 -23860 0 0 {name=p72851 lab=_57110_/X }
C {devices/lab_pin.sym} 73540 -23920 0 1 {name=p72852 lab=_85078_/D }
C {sky130_stdcells/a2bb2o_4.sym} 73460 -23920 0 0 {name=X_57118_ }
C {devices/lab_pin.sym} 73380 -23800 0 0 {name=p72853 lab=_41697_/X }
C {devices/lab_pin.sym} 73380 -23760 0 0 {name=p72854 lab=_42342_/X }
C {devices/lab_pin.sym} 73380 -23720 0 0 {name=p72855 lab=_87911_/Q }
C {devices/lab_pin.sym} 73380 -23680 0 0 {name=p72856 lab=_42343_/X }
C {devices/lab_pin.sym} 73540 -23740 0 1 {name=p72857 lab=_87911_/D }
C {sky130_stdcells/a2bb2o_4.sym} 73460 -23740 0 0 {name=X_42344_ }
C {devices/lab_pin.sym} 73420 -23590 0 0 {name=p72858 lab=_72814_/A }
C {devices/lab_pin.sym} 73500 -23590 0 1 {name=p72859 lab=_73165_/A }
C {sky130_stdcells/buf_2.sym} 73460 -23590 0 0 {name=X_73164_ }
C {devices/lab_pin.sym} 73380 -23490 0 0 {name=p72860 lab=_50852_/B }
C {devices/lab_pin.sym} 73380 -23450 0 0 {name=p72861 lab=_70364_/X }
C {devices/lab_pin.sym} 73380 -23410 0 0 {name=p72862 lab=_70375_/Y }
C {devices/lab_pin.sym} 73540 -23450 0 1 {name=p72863 lab=_70376_/Y }
C {sky130_stdcells/o21ai_4.sym} 73460 -23450 0 0 {name=X_70376_ }
C {devices/lab_pin.sym} 73420 -23310 0 0 {name=p72864 lab=_58098_/A }
C {devices/lab_pin.sym} 73500 -23310 0 1 {name=p72865 lab=_58098_/X }
C {sky130_stdcells/buf_2.sym} 73460 -23310 0 0 {name=X_58098_ }
C {devices/lab_pin.sym} 73420 -23190 0 0 {name=p72866 lab=clkbuf_9_2_0_CLK/X }
C {devices/lab_pin.sym} 73500 -23190 0 1 {name=p72867 lab=_85297_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 73460 -23190 0 0 {name=Xclkbuf_10_5_0_CLK }
C {devices/lab_pin.sym} 73420 -23070 0 0 {name=p72868 lab=clkbuf_9_407_0_CLK/A }
C {devices/lab_pin.sym} 73500 -23070 0 1 {name=p72869 lab=clkbuf_9_407_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 73460 -23070 0 0 {name=Xclkbuf_9_407_0_CLK }
C {devices/lab_pin.sym} 73420 -22950 0 0 {name=p72870 lab=_72250_/A }
C {devices/lab_pin.sym} 73500 -22950 0 1 {name=p72871 lab=_72115_/X }
C {sky130_stdcells/buf_2.sym} 73460 -22950 0 0 {name=X_72115_ }
C {devices/lab_pin.sym} 73400 -22840 0 0 {name=p72872 lab=_49955_/A }
C {devices/lab_pin.sym} 73400 -22800 0 0 {name=p72873 lab=_53153_/B }
C {devices/lab_pin.sym} 73520 -22820 0 1 {name=p72874 lab=_49940_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -22820 0 0 {name=X_49940_ }
C {devices/lab_pin.sym} 73420 -22690 0 0 {name=p72875 lab=_45212_/A }
C {devices/lab_pin.sym} 73500 -22690 0 1 {name=p72876 lab=_45063_/X }
C {sky130_stdcells/buf_2.sym} 73460 -22690 0 0 {name=X_45063_ }
C {devices/lab_pin.sym} 73400 -22590 0 0 {name=p72877 lab=_57049_/A }
C {devices/lab_pin.sym} 73400 -22550 0 0 {name=p72878 lab=_85096_/Q }
C {devices/lab_pin.sym} 73400 -22510 0 0 {name=p72879 lab=_56953_/A }
C {devices/lab_pin.sym} 73520 -22550 0 1 {name=p72880 lab=_57049_/Y }
C {sky130_stdcells/nor3_4.sym} 73460 -22550 0 0 {name=X_57049_ }
C {devices/lab_pin.sym} 73420 -22410 0 0 {name=p72881 lab=_42199_/X }
C {devices/lab_pin.sym} 73500 -22410 0 1 {name=p72882 lab=_42275_/X }
C {sky130_stdcells/buf_2.sym} 73460 -22410 0 0 {name=X_42275_ }
C {devices/lab_pin.sym} 73380 -22310 0 0 {name=p72883 lab=_73091_/X }
C {devices/lab_pin.sym} 73380 -22270 0 0 {name=p72884 lab=_73094_/X }
C {devices/lab_pin.sym} 73380 -22230 0 0 {name=p72885 lab=_73067_/X }
C {devices/lab_pin.sym} 73540 -22270 0 1 {name=p72886 lab=_73098_/A }
C {sky130_stdcells/a21o_4.sym} 73460 -22270 0 0 {name=X_73095_ }
C {devices/lab_pin.sym} 73420 -22130 0 0 {name=p72887 lab=_77971_/X }
C {devices/lab_pin.sym} 73500 -22130 0 1 {name=p72888 lab=_77972_/Y }
C {sky130_stdcells/inv_2.sym} 73460 -22130 0 0 {name=X_77972_ }
C {devices/lab_pin.sym} 73420 -22010 0 0 {name=p72889 lab=_44174_/A }
C {devices/lab_pin.sym} 73500 -22010 0 1 {name=p72890 lab=_45920_/A }
C {sky130_stdcells/inv_2.sym} 73460 -22010 0 0 {name=X_44014_ }
C {devices/lab_pin.sym} 73380 -21910 0 0 {name=p72891 lab=_65072_/C }
C {devices/lab_pin.sym} 73380 -21870 0 0 {name=p72892 lab=_72323_/Y }
C {devices/lab_pin.sym} 73380 -21830 0 0 {name=p72893 lab=_79710_/Y }
C {devices/lab_pin.sym} 73540 -21870 0 1 {name=p72894 lab=_79711_/X }
C {sky130_stdcells/o21a_4.sym} 73460 -21870 0 0 {name=X_79711_ }
C {devices/lab_pin.sym} 73380 -21770 0 0 {name=p72895 lab=_41205_/X }
C {devices/lab_pin.sym} 73380 -21730 0 0 {name=p72896 lab=_41206_/X }
C {devices/lab_pin.sym} 73380 -21690 0 0 {name=p72897 lab=_41225_/X }
C {devices/lab_pin.sym} 73380 -21650 0 0 {name=p72898 lab=_88254_/Q }
C {devices/lab_pin.sym} 73380 -21610 0 0 {name=p72899 lab=_41194_/X }
C {devices/lab_pin.sym} 73540 -21690 0 1 {name=p72900 lab=_41227_/A }
C {sky130_stdcells/o32ai_4.sym} 73460 -21690 0 0 {name=X_41226_ }
C {devices/lab_pin.sym} 73380 -21550 0 0 {name=p72901 lab=_84669_/Q }
C {devices/lab_pin.sym} 73380 -21510 0 0 {name=p72902 lab=_60053_/X }
C {devices/lab_pin.sym} 73380 -21470 0 0 {name=p72903 lab=_60059_/Y }
C {devices/lab_pin.sym} 73540 -21510 0 1 {name=p72904 lab=_60060_/X }
C {sky130_stdcells/o21a_4.sym} 73460 -21510 0 0 {name=X_60060_ }
C {devices/lab_pin.sym} 73400 -21380 0 0 {name=p72905 lab=_72040_/A }
C {devices/lab_pin.sym} 73400 -21340 0 0 {name=p72906 lab=_49064_/A }
C {devices/lab_pin.sym} 73520 -21360 0 1 {name=p72907 lab=_72046_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -21360 0 0 {name=X_72046_ }
C {devices/lab_pin.sym} 73400 -21240 0 0 {name=p72908 lab=_76919_/Y }
C {devices/lab_pin.sym} 73400 -21200 0 0 {name=p72909 lab=_76922_/Y }
C {devices/lab_pin.sym} 73520 -21220 0 1 {name=p72910 lab=_76924_/A }
C {sky130_stdcells/xor2_4.sym} 73460 -21220 0 0 {name=X_76923_ }
C {devices/lab_pin.sym} 73420 -21090 0 0 {name=p72911 lab=_49925_/A }
C {devices/lab_pin.sym} 73500 -21090 0 1 {name=p72912 lab=_49893_/A }
C {sky130_stdcells/buf_2.sym} 73460 -21090 0 0 {name=X_49871_ }
C {devices/lab_pin.sym} 73420 -20970 0 0 {name=p72913 lab=_50105_/A }
C {devices/lab_pin.sym} 73500 -20970 0 1 {name=p72914 lab=_50069_/A }
C {sky130_stdcells/buf_2.sym} 73460 -20970 0 0 {name=X_48822_ }
C {devices/lab_pin.sym} 73400 -20880 0 0 {name=p72915 lab=_79619_/A }
C {devices/lab_pin.sym} 73400 -20840 0 0 {name=p72916 lab=_79642_/B }
C {devices/lab_pin.sym} 73400 -20800 0 0 {name=p72917 lab=_79619_/B }
C {devices/lab_pin.sym} 73400 -20760 0 0 {name=p72918 lab=_79642_/D }
C {devices/lab_pin.sym} 73520 -20820 0 1 {name=p72919 lab=_79642_/Y }
C {sky130_stdcells/nand4_4.sym} 73460 -20820 0 0 {name=X_79642_ }
C {devices/lab_pin.sym} 73420 -20670 0 0 {name=p72920 lab=_41157_/A }
C {devices/lab_pin.sym} 73500 -20670 0 1 {name=p72921 lab=_41157_/X }
C {sky130_stdcells/buf_2.sym} 73460 -20670 0 0 {name=X_41157_ }
C {devices/lab_pin.sym} 73400 -20560 0 0 {name=p72922 lab=_76854_/A }
C {devices/lab_pin.sym} 73400 -20520 0 0 {name=p72923 lab=_76854_/B }
C {devices/lab_pin.sym} 73520 -20540 0 1 {name=p72924 lab=_81464_/D }
C {sky130_stdcells/xor2_4.sym} 73460 -20540 0 0 {name=X_76854_ }
C {devices/lab_pin.sym} 73380 -20430 0 0 {name=p72925 lab=_75802_/B }
C {devices/lab_pin.sym} 73380 -20390 0 0 {name=p72926 lab=_75796_/Y }
C {devices/lab_pin.sym} 73380 -20350 0 0 {name=p72927 lab=_75804_/Y }
C {devices/lab_pin.sym} 73540 -20390 0 1 {name=p72928 lab=_75810_/C }
C {sky130_stdcells/o21a_4.sym} 73460 -20390 0 0 {name=X_75805_ }
C {devices/lab_pin.sym} 73380 -20270 0 0 {name=p72929 lab=_48751_/Y }
C {devices/lab_pin.sym} 73380 -20230 0 0 {name=p72930 lab=_48734_/X }
C {devices/lab_pin.sym} 73380 -20190 0 0 {name=p72931 lab=_48752_/X }
C {devices/lab_pin.sym} 73540 -20230 0 1 {name=p72932 lab=_48753_/Y }
C {sky130_stdcells/a21oi_4.sym} 73460 -20230 0 0 {name=X_48753_ }
C {devices/lab_pin.sym} 73400 -20110 0 0 {name=p72933 lab=_79569_/Y }
C {devices/lab_pin.sym} 73400 -20070 0 0 {name=p72934 lab=_79573_/B }
C {devices/lab_pin.sym} 73400 -20030 0 0 {name=p72935 lab=_79572_/Y }
C {devices/lab_pin.sym} 73520 -20070 0 1 {name=p72936 lab=_79576_/B }
C {sky130_stdcells/nand3_4.sym} 73460 -20070 0 0 {name=X_79573_ }
C {devices/lab_pin.sym} 73380 -19960 0 0 {name=p72937 lab=_41797_/X }
C {devices/lab_pin.sym} 73380 -19920 0 0 {name=p72938 lab=_45963_/X }
C {devices/lab_pin.sym} 73380 -19880 0 0 {name=p72939 lab=_66577_/B }
C {devices/lab_pin.sym} 73380 -19840 0 0 {name=p72940 lab=_45964_/X }
C {devices/lab_pin.sym} 73540 -19900 0 1 {name=p72941 lab=_45965_/X }
C {sky130_stdcells/a2bb2o_4.sym} 73460 -19900 0 0 {name=X_45965_ }
C {devices/lab_pin.sym} 73420 -19750 0 0 {name=p72942 lab=_40995_/A }
C {devices/lab_pin.sym} 73500 -19750 0 1 {name=p72943 lab=_41088_/X }
C {sky130_stdcells/buf_2.sym} 73460 -19750 0 0 {name=X_41088_ }
C {devices/lab_pin.sym} 73400 -19640 0 0 {name=p72944 lab=_81697_/Q }
C {devices/lab_pin.sym} 73400 -19600 0 0 {name=p72945 lab=_76785_/B }
C {devices/lab_pin.sym} 73520 -19620 0 1 {name=p72946 lab=_76785_/Y }
C {sky130_stdcells/xnor2_4.sym} 73460 -19620 0 0 {name=X_76785_ }
C {devices/lab_pin.sym} 73380 -19510 0 0 {name=p72947 lab=_73994_/X }
C {devices/lab_pin.sym} 73380 -19470 0 0 {name=p72948 lab=_73996_/X }
C {devices/lab_pin.sym} 73380 -19430 0 0 {name=p72949 lab=_72735_/X }
C {devices/lab_pin.sym} 73540 -19470 0 1 {name=p72950 lab=_74000_/A }
C {sky130_stdcells/a21o_4.sym} 73460 -19470 0 0 {name=X_73997_ }
C {devices/lab_pin.sym} 73420 -19330 0 0 {name=p72951 lab=_47704_/A }
C {devices/lab_pin.sym} 73500 -19330 0 1 {name=p72952 lab=_54894_/B }
C {sky130_stdcells/inv_2.sym} 73460 -19330 0 0 {name=X_47704_ }
C {devices/lab_pin.sym} 73400 -19220 0 0 {name=p72953 lab=_78524_/A }
C {devices/lab_pin.sym} 73400 -19180 0 0 {name=p72954 lab=_82673_/D }
C {devices/lab_pin.sym} 73520 -19200 0 1 {name=p72955 lab=_78525_/A }
C {sky130_stdcells/nand2_4.sym} 73460 -19200 0 0 {name=X_78524_ }
C {devices/lab_pin.sym} 73380 -19090 0 0 {name=p72956 lab=_44913_/Y }
C {devices/lab_pin.sym} 73380 -19050 0 0 {name=p72957 lab=_44915_/Y }
C {devices/lab_pin.sym} 73380 -19010 0 0 {name=p72958 lab=_44889_/X }
C {devices/lab_pin.sym} 73540 -19050 0 1 {name=p72959 lab=_44916_/X }
C {sky130_stdcells/a21o_4.sym} 73460 -19050 0 0 {name=X_44916_ }
C {devices/lab_pin.sym} 73420 -18910 0 0 {name=p72960 lab=_60996_/B }
C {devices/lab_pin.sym} 73500 -18910 0 1 {name=p72961 lab=_63753_/C }
C {sky130_stdcells/buf_2.sym} 73460 -18910 0 0 {name=X_63750_ }
C {devices/lab_pin.sym} 73400 -18800 0 0 {name=p72962 lab=_75723_/A }
C {devices/lab_pin.sym} 73400 -18760 0 0 {name=p72963 lab=_75736_/B }
C {devices/lab_pin.sym} 73520 -18780 0 1 {name=p72964 lab=_75736_/X }
C {sky130_stdcells/and2_4.sym} 73460 -18780 0 0 {name=X_75736_ }
C {devices/lab_pin.sym} 73420 -18650 0 0 {name=p72965 lab=_60962_/A }
C {devices/lab_pin.sym} 73500 -18650 0 1 {name=p72966 lab=_60962_/Y }
C {sky130_stdcells/inv_2.sym} 73460 -18650 0 0 {name=X_60962_ }
C {devices/lab_pin.sym} 73400 -18540 0 0 {name=p72967 lab=_48695_/A }
C {devices/lab_pin.sym} 73400 -18500 0 0 {name=p72968 lab=_48684_/B }
C {devices/lab_pin.sym} 73520 -18520 0 1 {name=p72969 lab=_48684_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -18520 0 0 {name=X_48684_ }
C {devices/lab_pin.sym} 73380 -18420 0 0 {name=p72970 lab=_43133_/Y }
C {devices/lab_pin.sym} 73380 -18380 0 0 {name=p72971 lab=_72830_/X }
C {devices/lab_pin.sym} 73380 -18340 0 0 {name=p72972 lab=_72799_/X }
C {devices/lab_pin.sym} 73380 -18300 0 0 {name=p72973 lab=_72947_/Y }
C {devices/lab_pin.sym} 73540 -18360 0 1 {name=p72974 lab=_72948_/X }
C {sky130_stdcells/a211o_4.sym} 73460 -18360 0 0 {name=X_72948_ }
C {devices/lab_pin.sym} 73420 -18210 0 0 {name=p72975 lab=_73948_/A }
C {devices/lab_pin.sym} 73500 -18210 0 1 {name=p72976 lab=_45896_/X }
C {sky130_stdcells/buf_2.sym} 73460 -18210 0 0 {name=X_45896_ }
C {devices/lab_pin.sym} 73420 -18090 0 0 {name=p72977 lab=clkbuf_6_7_0_CLK/A }
C {devices/lab_pin.sym} 73500 -18090 0 1 {name=p72978 lab=clkbuf_6_7_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 73460 -18090 0 0 {name=Xclkbuf_6_7_0_CLK }
C {devices/lab_pin.sym} 73380 -18010 0 0 {name=p72979 lab=_58232_/X }
C {devices/lab_pin.sym} 73380 -17970 0 0 {name=p72980 lab=_62689_/X }
C {devices/lab_pin.sym} 73380 -17930 0 0 {name=p72981 lab=_60205_/X }
C {devices/lab_pin.sym} 73380 -17890 0 0 {name=p72982 lab=_62699_/X }
C {devices/lab_pin.sym} 73380 -17860 0 0 {name=p72983 lab=_62700_/X }
C {devices/lab_pin.sym} 73540 -17930 0 1 {name=p72984 lab=_62701_/Y }
C {sky130_stdcells/a41oi_4.sym} 73460 -17930 0 0 {name=X_62701_ }
C {devices/lab_pin.sym} 73420 -17770 0 0 {name=p72985 lab=_81238_/Q }
C {devices/lab_pin.sym} 73500 -17770 0 1 {name=p72986 lab=_47636_/A }
C {sky130_stdcells/inv_2.sym} 73460 -17770 0 0 {name=X_47635_ }
C {devices/lab_pin.sym} 73400 -17660 0 0 {name=p72987 lab=_78455_/A }
C {devices/lab_pin.sym} 73400 -17620 0 0 {name=p72988 lab=_82668_/D }
C {devices/lab_pin.sym} 73520 -17640 0 1 {name=p72989 lab=_78455_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -17640 0 0 {name=X_78455_ }
C {devices/lab_pin.sym} 73380 -17540 0 0 {name=p72990 lab=_41741_/A }
C {devices/lab_pin.sym} 73380 -17500 0 0 {name=p72991 lab=_44838_/X }
C {devices/lab_pin.sym} 73380 -17460 0 0 {name=p72992 lab=_67836_/B }
C {devices/lab_pin.sym} 73380 -17420 0 0 {name=p72993 lab=_44839_/X }
C {devices/lab_pin.sym} 73540 -17480 0 1 {name=p72994 lab=_86922_/D }
C {sky130_stdcells/a2bb2o_4.sym} 73460 -17480 0 0 {name=X_44847_ }
C {devices/lab_pin.sym} 73380 -17350 0 0 {name=p72995 lab=_63678_/Y }
C {devices/lab_pin.sym} 73380 -17310 0 0 {name=p72996 lab=_63679_/X }
C {devices/lab_pin.sym} 73380 -17270 0 0 {name=p72997 lab=_63680_/Y }
C {devices/lab_pin.sym} 73540 -17310 0 1 {name=p72998 lab=_63681_/Y }
C {sky130_stdcells/a21oi_4.sym} 73460 -17310 0 0 {name=X_63681_ }
C {devices/lab_pin.sym} 73400 -17180 0 0 {name=p72999 lab=_81004_/Q }
C {devices/lab_pin.sym} 73400 -17140 0 0 {name=p73000 lab=_75667_/B }
C {devices/lab_pin.sym} 73520 -17160 0 1 {name=p73001 lab=_75667_/X }
C {sky130_stdcells/xor2_4.sym} 73460 -17160 0 0 {name=X_75667_ }
C {devices/lab_pin.sym} 73420 -17030 0 0 {name=p73002 lab=_60892_/Y }
C {devices/lab_pin.sym} 73500 -17030 0 1 {name=p73003 lab=_64180_/C }
C {sky130_stdcells/buf_2.sym} 73460 -17030 0 0 {name=X_60893_ }
C {devices/lab_pin.sym} 73420 -16910 0 0 {name=p73004 lab=_72784_/A }
C {devices/lab_pin.sym} 73500 -16910 0 1 {name=p73005 lab=_72880_/A }
C {sky130_stdcells/buf_2.sym} 73460 -16910 0 0 {name=X_72879_ }
C {devices/lab_pin.sym} 73380 -16810 0 0 {name=p73006 lab=_65399_/X }
C {devices/lab_pin.sym} 73380 -16770 0 0 {name=p73007 lab=_65410_/Y }
C {devices/lab_pin.sym} 73380 -16730 0 0 {name=p73008 lab=_65419_/Y }
C {devices/lab_pin.sym} 73540 -16770 0 1 {name=p73009 lab=_65420_/Y }
C {sky130_stdcells/o21ai_4.sym} 73460 -16770 0 0 {name=X_65420_ }
C {devices/lab_pin.sym} 73400 -16640 0 0 {name=p73010 lab=_77406_/A }
C {devices/lab_pin.sym} 73400 -16600 0 0 {name=p73011 lab=_82094_/D }
C {devices/lab_pin.sym} 73520 -16620 0 1 {name=p73012 lab=_77406_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -16620 0 0 {name=X_77406_ }
C {devices/lab_pin.sym} 73400 -16510 0 0 {name=p73013 lab=_62632_/A }
C {devices/lab_pin.sym} 73400 -16470 0 0 {name=p73014 lab=_84882_/Q }
C {devices/lab_pin.sym} 73400 -16430 0 0 {name=p73015 lab=_62632_/C }
C {devices/lab_pin.sym} 73520 -16470 0 1 {name=p73016 lab=_62634_/C }
C {sky130_stdcells/nand3_4.sym} 73460 -16470 0 0 {name=X_62632_ }
C {devices/lab_pin.sym} 73380 -16350 0 0 {name=p73017 lab=_45319_/A }
C {devices/lab_pin.sym} 73380 -16310 0 0 {name=p73018 lab=_74612_/X }
C {devices/lab_pin.sym} 73380 -16270 0 0 {name=p73019 lab=_74617_/X }
C {devices/lab_pin.sym} 73540 -16310 0 1 {name=p73020 lab=_83014_/D }
C {sky130_stdcells/o21ai_4.sym} 73460 -16310 0 0 {name=X_74618_ }
C {devices/lab_pin.sym} 73420 -16170 0 0 {name=p73021 lab=_81245_/Q }
C {devices/lab_pin.sym} 73500 -16170 0 1 {name=p73022 lab=_47567_/A }
C {sky130_stdcells/inv_2.sym} 73460 -16170 0 0 {name=X_47566_ }
C {devices/lab_pin.sym} 73420 -16050 0 0 {name=p73023 lab=_78385_/Y }
C {devices/lab_pin.sym} 73500 -16050 0 1 {name=p73024 lab=_78386_/Y }
C {sky130_stdcells/inv_2.sym} 73460 -16050 0 0 {name=X_78386_ }
C {devices/lab_pin.sym} 73380 -15960 0 0 {name=p73025 lab=_41366_/Y }
C {devices/lab_pin.sym} 73380 -15920 0 0 {name=p73026 lab=_44774_/X }
C {devices/lab_pin.sym} 73380 -15880 0 0 {name=p73027 lab=_86960_/Q }
C {devices/lab_pin.sym} 73380 -15840 0 0 {name=p73028 lab=_44775_/X }
C {devices/lab_pin.sym} 73540 -15900 0 1 {name=p73029 lab=_86960_/D }
C {sky130_stdcells/a2bb2o_4.sym} 73460 -15900 0 0 {name=X_44778_ }
C {devices/lab_pin.sym} 73420 -15750 0 0 {name=p73030 lab=_75598_/A }
C {devices/lab_pin.sym} 73500 -15750 0 1 {name=p73031 lab=_75607_/B }
C {sky130_stdcells/inv_2.sym} 73460 -15750 0 0 {name=X_75598_ }
C {devices/lab_pin.sym} 73380 -15650 0 0 {name=p73032 lab=_49303_/Y }
C {devices/lab_pin.sym} 73380 -15610 0 0 {name=p73033 lab=_49281_/X }
C {devices/lab_pin.sym} 73380 -15570 0 0 {name=p73034 lab=_49304_/X }
C {devices/lab_pin.sym} 73540 -15610 0 1 {name=p73035 lab=_49305_/Y }
C {sky130_stdcells/a21oi_4.sym} 73460 -15610 0 0 {name=X_49305_ }
C {devices/lab_pin.sym} 73400 -15480 0 0 {name=p73036 lab=_46408_/A }
C {devices/lab_pin.sym} 73400 -15440 0 0 {name=p73037 lab=_49322_/B }
C {devices/lab_pin.sym} 73520 -15460 0 1 {name=p73038 lab=_46517_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -15460 0 0 {name=X_46517_ }
C {devices/lab_pin.sym} 73420 -15330 0 0 {name=p73039 lab=_64667_/A }
C {devices/lab_pin.sym} 73500 -15330 0 1 {name=p73040 lab=_65401_/A }
C {sky130_stdcells/buf_2.sym} 73460 -15330 0 0 {name=X_65351_ }
C {devices/lab_pin.sym} 73400 -15220 0 0 {name=p73041 lab=_81929_/Q }
C {devices/lab_pin.sym} 73400 -15180 0 0 {name=p73042 lab=_82185_/D }
C {devices/lab_pin.sym} 73520 -15200 0 1 {name=p73043 lab=_77337_/X }
C {sky130_stdcells/xor2_4.sym} 73460 -15200 0 0 {name=X_77337_ }
C {devices/lab_pin.sym} 73380 -15100 0 0 {name=p73044 lab=_40885_/A }
C {devices/lab_pin.sym} 73380 -15060 0 0 {name=p73045 lab=_43716_/X }
C {devices/lab_pin.sym} 73380 -15020 0 0 {name=p73046 lab=_69862_/B }
C {devices/lab_pin.sym} 73380 -14980 0 0 {name=p73047 lab=_43718_/X }
C {devices/lab_pin.sym} 73540 -15040 0 1 {name=p73048 lab=_43729_/X }
C {sky130_stdcells/a2bb2o_4.sym} 73460 -15040 0 0 {name=X_43729_ }
C {devices/lab_pin.sym} 73400 -14910 0 0 {name=p73049 lab=_62551_/X }
C {devices/lab_pin.sym} 73400 -14870 0 0 {name=p73050 lab=_62553_/X }
C {devices/lab_pin.sym} 73400 -14830 0 0 {name=p73051 lab=_84401_/Q }
C {devices/lab_pin.sym} 73520 -14870 0 1 {name=p73052 lab=_62563_/Y }
C {sky130_stdcells/nor3_4.sym} 73460 -14870 0 0 {name=X_62563_ }
C {devices/lab_pin.sym} 73400 -14740 0 0 {name=p73053 lab=_74549_/A }
C {devices/lab_pin.sym} 73400 -14700 0 0 {name=p73054 lab=_45955_/X }
C {devices/lab_pin.sym} 73520 -14720 0 1 {name=p73055 lab=_74549_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -14720 0 0 {name=X_74549_ }
C {devices/lab_pin.sym} 73420 -14590 0 0 {name=p73056 lab=_47497_/A }
C {devices/lab_pin.sym} 73500 -14590 0 1 {name=p73057 lab=_54772_/B }
C {sky130_stdcells/inv_2.sym} 73460 -14590 0 0 {name=X_47497_ }
C {devices/lab_pin.sym} 73420 -14470 0 0 {name=p73058 lab=_64243_/A }
C {devices/lab_pin.sym} 73500 -14470 0 1 {name=p73059 lab=_64304_/A }
C {sky130_stdcells/buf_2.sym} 73460 -14470 0 0 {name=X_64302_ }
C {devices/lab_pin.sym} 73380 -14370 0 0 {name=p73060 lab=_49233_/Y }
C {devices/lab_pin.sym} 73380 -14330 0 0 {name=p73061 lab=_49189_/X }
C {devices/lab_pin.sym} 73380 -14290 0 0 {name=p73062 lab=_49235_/X }
C {devices/lab_pin.sym} 73540 -14330 0 1 {name=p73063 lab=_49236_/Y }
C {sky130_stdcells/a21oi_4.sym} 73460 -14330 0 0 {name=X_49236_ }
C {devices/lab_pin.sym} 73400 -14220 0 0 {name=p73064 lab=_59421_/A }
C {devices/lab_pin.sym} 73400 -14180 0 0 {name=p73065 lab=_61484_/B }
C {devices/lab_pin.sym} 73400 -14140 0 0 {name=p73066 lab=_61484_/C }
C {devices/lab_pin.sym} 73400 -14100 0 0 {name=p73067 lab=_61514_/D }
C {devices/lab_pin.sym} 73520 -14160 0 1 {name=p73068 lab=_61514_/Y }
C {sky130_stdcells/nand4_4.sym} 73460 -14160 0 0 {name=X_61514_ }
C {devices/lab_pin.sym} 73420 -14010 0 0 {name=p73069 lab=_69779_/A }
C {devices/lab_pin.sym} 73500 -14010 0 1 {name=p73070 lab=_68070_/X }
C {sky130_stdcells/buf_2.sym} 73460 -14010 0 0 {name=X_68070_ }
C {devices/lab_pin.sym} 73380 -13910 0 0 {name=p73071 lab=_46301_/X }
C {devices/lab_pin.sym} 73380 -13870 0 0 {name=p73072 lab=_82928_/Q }
C {devices/lab_pin.sym} 73380 -13830 0 0 {name=p73073 lab=_46447_/Y }
C {devices/lab_pin.sym} 73540 -13870 0 1 {name=p73074 lab=_46449_/A }
C {sky130_stdcells/o21ai_4.sym} 73460 -13870 0 0 {name=X_46448_ }
C {devices/lab_pin.sym} 73400 -13740 0 0 {name=p73075 lab=_65258_/A }
C {devices/lab_pin.sym} 73400 -13700 0 0 {name=p73076 lab=_65282_/B }
C {devices/lab_pin.sym} 73520 -13720 0 1 {name=p73077 lab=_65282_/X }
C {sky130_stdcells/and2_4.sym} 73460 -13720 0 0 {name=X_65282_ }
C {devices/lab_pin.sym} 73380 -13610 0 0 {name=p73078 lab=_77254_/Y }
C {devices/lab_pin.sym} 73380 -13570 0 0 {name=p73079 lab=_77250_/A }
C {devices/lab_pin.sym} 73380 -13530 0 0 {name=p73080 lab=_77253_/A }
C {devices/lab_pin.sym} 73540 -13570 0 1 {name=p73081 lab=_77268_/X }
C {sky130_stdcells/o21a_4.sym} 73460 -13570 0 0 {name=X_77268_ }
C {devices/lab_pin.sym} 73420 -13430 0 0 {name=p73082 lab=_62336_/A }
C {devices/lab_pin.sym} 73500 -13430 0 1 {name=p73083 lab=_62570_/A }
C {sky130_stdcells/buf_2.sym} 73460 -13430 0 0 {name=X_62494_ }
C {devices/lab_pin.sym} 73420 -13310 0 0 {name=p73084 lab=_66553_/X }
C {devices/lab_pin.sym} 73500 -13310 0 1 {name=p73085 lab=_67144_/A }
C {sky130_stdcells/buf_2.sym} 73460 -13310 0 0 {name=X_67021_ }
C {devices/lab_pin.sym} 73380 -13220 0 0 {name=p73086 lab=_78998_/A }
C {devices/lab_pin.sym} 73380 -13180 0 0 {name=p73087 lab=_78998_/B }
C {devices/lab_pin.sym} 73380 -13140 0 0 {name=p73088 lab=_78997_/A }
C {devices/lab_pin.sym} 73380 -13100 0 0 {name=p73089 lab=_78997_/B }
C {devices/lab_pin.sym} 73540 -13160 0 1 {name=p73090 lab=_79007_/X }
C {sky130_stdcells/o22a_4.sym} 73460 -13160 0 0 {name=X_79007_ }
C {devices/lab_pin.sym} 73400 -13020 0 0 {name=p73091 lab=_63389_/A }
C {devices/lab_pin.sym} 73400 -12980 0 0 {name=p73092 lab=_64219_/B }
C {devices/lab_pin.sym} 73520 -13000 0 1 {name=p73093 lab=_64233_/Y }
C {sky130_stdcells/nor2_4.sym} 73460 -13000 0 0 {name=X_64233_ }
C {devices/lab_pin.sym} 73400 -12880 0 0 {name=p73094 lab=_76219_/A }
C {devices/lab_pin.sym} 73400 -12840 0 0 {name=p73095 lab=_76201_/Y }
C {devices/lab_pin.sym} 73520 -12860 0 1 {name=p73096 lab=_76219_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -12860 0 0 {name=X_76219_ }
C {devices/lab_pin.sym} 73420 -12730 0 0 {name=p73097 lab=_49166_/Y }
C {devices/lab_pin.sym} 73500 -12730 0 1 {name=p73098 lab=_50708_/B }
C {sky130_stdcells/buf_2.sym} 73460 -12730 0 0 {name=X_49167_ }
C {devices/lab_pin.sym} 73400 -12630 0 0 {name=p73099 lab=_61434_/A }
C {devices/lab_pin.sym} 73400 -12590 0 0 {name=p73100 lab=_61434_/B }
C {devices/lab_pin.sym} 73400 -12550 0 0 {name=p73101 lab=_79148_/B }
C {devices/lab_pin.sym} 73520 -12590 0 1 {name=p73102 lab=_61445_/Y }
C {sky130_stdcells/nor3_4.sym} 73460 -12590 0 0 {name=X_61445_ }
C {devices/lab_pin.sym} 73380 -12470 0 0 {name=p73103 lab=_86742_/Q }
C {devices/lab_pin.sym} 73380 -12430 0 0 {name=p73104 lab=_46364_/X }
C {devices/lab_pin.sym} 73380 -12390 0 0 {name=p73105 lab=_46378_/Y }
C {devices/lab_pin.sym} 73540 -12430 0 1 {name=p73106 lab=_46379_/Y }
C {sky130_stdcells/o21ai_4.sym} 73460 -12430 0 0 {name=X_46379_ }
C {devices/lab_pin.sym} 73400 -12300 0 0 {name=p73107 lab=_82109_/Q }
C {devices/lab_pin.sym} 73400 -12260 0 0 {name=p73108 lab=_77199_/B }
C {devices/lab_pin.sym} 73520 -12280 0 1 {name=p73109 lab=_77199_/X }
C {sky130_stdcells/xor2_4.sym} 73460 -12280 0 0 {name=X_77199_ }
C {devices/lab_pin.sym} 73400 -12160 0 0 {name=p73110 lab=_82342_/Q }
C {devices/lab_pin.sym} 73400 -12120 0 0 {name=p73111 lab=_48086_/B }
C {devices/lab_pin.sym} 73520 -12140 0 1 {name=p73112 lab=_48118_/X }
C {sky130_stdcells/or2_4.sym} 73460 -12140 0 0 {name=X_48118_ }
C {devices/lab_pin.sym} 73400 -12030 0 0 {name=p73113 lab=_64187_/A }
C {devices/lab_pin.sym} 73400 -11990 0 0 {name=p73114 lab=_64187_/B }
C {devices/lab_pin.sym} 73400 -11950 0 0 {name=p73115 lab=_79937_/B }
C {devices/lab_pin.sym} 73520 -11990 0 1 {name=p73116 lab=_64164_/Y }
C {sky130_stdcells/nor3_4.sym} 73460 -11990 0 0 {name=X_64164_ }
C {devices/lab_pin.sym} 73380 -11870 0 0 {name=p73117 lab=_48881_/X }
C {devices/lab_pin.sym} 73380 -11830 0 0 {name=p73118 lab=_81772_/Q }
C {devices/lab_pin.sym} 73380 -11790 0 0 {name=p73119 lab=_49097_/Y }
C {devices/lab_pin.sym} 73540 -11830 0 1 {name=p73120 lab=_49099_/A }
C {sky130_stdcells/o21ai_4.sym} 73460 -11830 0 0 {name=X_49098_ }
C {devices/lab_pin.sym} 73420 -11690 0 0 {name=p73121 lab=_84853_/Q }
C {devices/lab_pin.sym} 73500 -11690 0 1 {name=p73122 lab=_61376_/X }
C {sky130_stdcells/buf_2.sym} 73460 -11690 0 0 {name=X_61376_ }
C {devices/lab_pin.sym} 73380 -11590 0 0 {name=p73123 lab=_63111_/Y }
C {devices/lab_pin.sym} 73380 -11550 0 0 {name=p73124 lab=_63113_/X }
C {devices/lab_pin.sym} 73380 -11510 0 0 {name=p73125 lab=_63114_/X }
C {devices/lab_pin.sym} 73540 -11550 0 1 {name=p73126 lab=_63115_/Y }
C {sky130_stdcells/a21oi_4.sym} 73460 -11550 0 0 {name=X_63115_ }
C {devices/lab_pin.sym} 73420 -11410 0 0 {name=p73127 lab=_47840_/A }
C {devices/lab_pin.sym} 73500 -11410 0 1 {name=p73128 lab=_48049_/X }
C {sky130_stdcells/buf_2.sym} 73460 -11410 0 0 {name=X_48049_ }
C {devices/lab_pin.sym} 73380 -11310 0 0 {name=p73129 lab=_60255_/B }
C {devices/lab_pin.sym} 73380 -11270 0 0 {name=p73130 lab=_60228_/A }
C {devices/lab_pin.sym} 73380 -11230 0 0 {name=p73131 lab=_60781_/A }
C {devices/lab_pin.sym} 73540 -11270 0 1 {name=p73132 lab=_60327_/X }
C {sky130_stdcells/a21o_4.sym} 73460 -11270 0 0 {name=X_60327_ }
C {devices/lab_pin.sym} 73380 -11150 0 0 {name=p73133 lab=_68969_/X }
C {devices/lab_pin.sym} 73380 -11110 0 0 {name=p73134 lab=_68971_/X }
C {devices/lab_pin.sym} 73380 -11070 0 0 {name=p73135 lab=_68878_/X }
C {devices/lab_pin.sym} 73540 -11110 0 1 {name=p73136 lab=_68972_/Y }
C {sky130_stdcells/a21oi_4.sym} 73460 -11110 0 0 {name=X_68972_ }
C {devices/lab_pin.sym} 73400 -11000 0 0 {name=p73137 lab=_63629_/B }
C {devices/lab_pin.sym} 73400 -10960 0 0 {name=p73138 lab=_64095_/B }
C {devices/lab_pin.sym} 73400 -10920 0 0 {name=p73139 lab=_64095_/C }
C {devices/lab_pin.sym} 73400 -10880 0 0 {name=p73140 lab=_64095_/D }
C {devices/lab_pin.sym} 73520 -10940 0 1 {name=p73141 lab=_64095_/Y }
C {sky130_stdcells/nand4_4.sym} 73460 -10940 0 0 {name=X_64095_ }
C {devices/lab_pin.sym} 73420 -10790 0 0 {name=p73142 lab=_51141_/A }
C {devices/lab_pin.sym} 73500 -10790 0 1 {name=p73143 lab=_51071_/C }
C {sky130_stdcells/buf_2.sym} 73460 -10790 0 0 {name=X_51060_ }
C {devices/lab_pin.sym} 73380 -10690 0 0 {name=p73144 lab=_81481_/D }
C {devices/lab_pin.sym} 73380 -10650 0 0 {name=p73145 lab=_67806_/X }
C {devices/lab_pin.sym} 73380 -10610 0 0 {name=p73146 lab=_67922_/X }
C {devices/lab_pin.sym} 73540 -10650 0 1 {name=p73147 lab=_84049_/D }
C {sky130_stdcells/a21bo_4.sym} 73460 -10650 0 0 {name=X_67923_ }
C {devices/lab_pin.sym} 73380 -10530 0 0 {name=p73148 lab=_79476_/A }
C {devices/lab_pin.sym} 73380 -10490 0 0 {name=p73149 lab=_63008_/X }
C {devices/lab_pin.sym} 73380 -10450 0 0 {name=p73150 lab=_63045_/Y }
C {devices/lab_pin.sym} 73540 -10490 0 1 {name=p73151 lab=_63046_/X }
C {sky130_stdcells/a21o_4.sym} 73460 -10490 0 0 {name=X_63046_ }
C {devices/lab_pin.sym} 73400 -10370 0 0 {name=p73152 lab=_79909_/A }
C {devices/lab_pin.sym} 73400 -10330 0 0 {name=p73153 lab=_79913_/A }
C {devices/lab_pin.sym} 73400 -10290 0 0 {name=p73154 lab=_79913_/B }
C {devices/lab_pin.sym} 73520 -10330 0 1 {name=p73155 lab=_79915_/A }
C {sky130_stdcells/nand3_4.sym} 73460 -10330 0 0 {name=X_79909_ }
C {devices/lab_pin.sym} 73420 -10190 0 0 {name=p73156 lab=_60257_/X }
C {devices/lab_pin.sym} 73500 -10190 0 1 {name=p73157 lab=_60259_/A }
C {sky130_stdcells/buf_2.sym} 73460 -10190 0 0 {name=X_60258_ }
C {devices/lab_pin.sym} 73380 -10090 0 0 {name=p73158 lab=_50008_/Y }
C {devices/lab_pin.sym} 73380 -10050 0 0 {name=p73159 lab=_50003_/X }
C {devices/lab_pin.sym} 73380 -10010 0 0 {name=p73160 lab=_50010_/X }
C {devices/lab_pin.sym} 73540 -10050 0 1 {name=p73161 lab=_86282_/D }
C {sky130_stdcells/a21oi_4.sym} 73460 -10050 0 0 {name=X_50011_ }
C {devices/lab_pin.sym} 73370 -9910 0 0 {name=p73162 lab=_82931_/CLK }
C {devices/lab_pin.sym} 73370 -9890 0 0 {name=p73163 lab=_78173_/X }
C {devices/lab_pin.sym} 73550 -9910 0 1 {name=p73164 lab=_82920_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -9900 0 0 {name=X_82920_ }
C {devices/lab_pin.sym} 73380 -9800 0 0 {name=p73165 lab=_87965_/Q }
C {devices/lab_pin.sym} 73380 -9760 0 0 {name=p73166 lab=_67831_/X }
C {devices/lab_pin.sym} 73380 -9720 0 0 {name=p73167 lab=_67761_/X }
C {devices/lab_pin.sym} 73380 -9680 0 0 {name=p73168 lab=_67853_/X }
C {devices/lab_pin.sym} 73540 -9740 0 1 {name=p73169 lab=_67854_/X }
C {sky130_stdcells/a211o_4.sym} 73460 -9740 0 0 {name=X_67854_ }
C {devices/lab_pin.sym} 73420 -9590 0 0 {name=p73170 lab=_60189_/A }
C {devices/lab_pin.sym} 73500 -9590 0 1 {name=p73171 lab=_60189_/Y }
C {sky130_stdcells/inv_2.sym} 73460 -9590 0 0 {name=X_60189_ }
C {devices/lab_pin.sym} 73380 -9500 0 0 {name=p73172 lab=_66757_/X }
C {devices/lab_pin.sym} 73380 -9460 0 0 {name=p73173 lab=_66791_/Y }
C {devices/lab_pin.sym} 73380 -9420 0 0 {name=p73174 lab=_66793_/X }
C {devices/lab_pin.sym} 73380 -9380 0 0 {name=p73175 lab=_66804_/Y }
C {devices/lab_pin.sym} 73540 -9440 0 1 {name=p73176 lab=_66805_/X }
C {sky130_stdcells/a211o_4.sym} 73460 -9440 0 0 {name=X_66805_ }
C {devices/lab_pin.sym} 73370 -9290 0 0 {name=p73177 lab=_82563_/CLK }
C {devices/lab_pin.sym} 73370 -9270 0 0 {name=p73178 lab=_78091_/B }
C {devices/lab_pin.sym} 73550 -9290 0 1 {name=p73179 lab=_40923_/A }
C {sky130_stdcells/dfxtp_4.sym} 73460 -9280 0 0 {name=X_82851_ }
C {devices/lab_pin.sym} 73400 -9160 0 0 {name=p73180 lab=_67739_/X }
C {devices/lab_pin.sym} 73400 -9120 0 0 {name=p73181 lab=_86924_/Q }
C {devices/lab_pin.sym} 73520 -9140 0 1 {name=p73182 lab=_67785_/X }
C {sky130_stdcells/and2_4.sym} 73460 -9140 0 0 {name=X_67785_ }
C {devices/lab_pin.sym} 73400 -9030 0 0 {name=p73183 lab=_65047_/A }
C {devices/lab_pin.sym} 73400 -8990 0 0 {name=p73184 lab=_64870_/B }
C {devices/lab_pin.sym} 73400 -8950 0 0 {name=p73185 lab=_64997_/C }
C {devices/lab_pin.sym} 73520 -8990 0 1 {name=p73186 lab=_64997_/Y }
C {sky130_stdcells/nor3_4.sym} 73460 -8990 0 0 {name=X_64997_ }
C {devices/lab_pin.sym} 73370 -8850 0 0 {name=p73187 lab=_83184_/CLK }
C {devices/lab_pin.sym} 73370 -8830 0 0 {name=p73188 lab=_81802_/D }
C {devices/lab_pin.sym} 73550 -8850 0 1 {name=p73189 lab=_81802_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -8840 0 0 {name=X_81802_ }
C {devices/lab_pin.sym} 73380 -8740 0 0 {name=p73190 lab=_87511_/Q }
C {devices/lab_pin.sym} 73380 -8700 0 0 {name=p73191 lab=_69356_/X }
C {devices/lab_pin.sym} 73380 -8660 0 0 {name=p73192 lab=_69371_/X }
C {devices/lab_pin.sym} 73380 -8620 0 0 {name=p73193 lab=_69523_/X }
C {devices/lab_pin.sym} 73540 -8680 0 1 {name=p73194 lab=_69524_/X }
C {sky130_stdcells/a211o_4.sym} 73460 -8680 0 0 {name=X_69524_ }
C {devices/lab_pin.sym} 73400 -8540 0 0 {name=p73195 lab=_54731_/X }
C {devices/lab_pin.sym} 73400 -8500 0 0 {name=p73196 lab=_47459_/A }
C {devices/lab_pin.sym} 73520 -8520 0 1 {name=p73197 lab=_54750_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -8520 0 0 {name=X_54750_ }
C {devices/lab_pin.sym} 73400 -8400 0 0 {name=p73198 lab=_66760_/A }
C {devices/lab_pin.sym} 73400 -8360 0 0 {name=p73199 lab=_87628_/Q }
C {devices/lab_pin.sym} 73520 -8380 0 1 {name=p73200 lab=_66736_/X }
C {sky130_stdcells/and2_4.sym} 73460 -8380 0 0 {name=X_66736_ }
C {devices/lab_pin.sym} 73370 -8250 0 0 {name=p73201 lab=_83572_/CLK }
C {devices/lab_pin.sym} 73370 -8230 0 0 {name=p73202 lab=_85570_/D }
C {devices/lab_pin.sym} 73550 -8250 0 1 {name=p73203 lab=_85570_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -8240 0 0 {name=X_85570_ }
C {devices/lab_pin.sym} 73400 -8120 0 0 {name=p73204 lab=_51961_/X }
C {devices/lab_pin.sym} 73400 -8080 0 0 {name=p73205 lab=_50260_/B }
C {devices/lab_pin.sym} 73520 -8100 0 1 {name=p73206 lab=_51962_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -8100 0 0 {name=X_51962_ }
C {devices/lab_pin.sym} 73420 -7970 0 0 {name=p73207 lab=_60930_/C }
C {devices/lab_pin.sym} 73500 -7970 0 1 {name=p73208 lab=_64027_/D }
C {sky130_stdcells/buf_2.sym} 73460 -7970 0 0 {name=X_63948_ }
C {devices/lab_pin.sym} 73370 -7850 0 0 {name=p73209 lab=_82975_/CLK }
C {devices/lab_pin.sym} 73370 -7830 0 0 {name=p73210 lab=_82782_/D }
C {devices/lab_pin.sym} 73550 -7850 0 1 {name=p73211 lab=_82782_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -7840 0 0 {name=X_82782_ }
C {devices/lab_pin.sym} 73420 -7710 0 0 {name=p73212 lab=_51842_/A }
C {devices/lab_pin.sym} 73500 -7710 0 1 {name=p73213 lab=_53763_/A }
C {sky130_stdcells/buf_2.sym} 73460 -7710 0 0 {name=X_53701_ }
C {devices/lab_pin.sym} 73370 -7590 0 0 {name=p73214 lab=_84623_/CLK }
C {devices/lab_pin.sym} 73370 -7570 0 0 {name=p73215 lab=_61091_/Y }
C {devices/lab_pin.sym} 73550 -7590 0 1 {name=p73216 lab=_61089_/C }
C {sky130_stdcells/dfxtp_4.sym} 73460 -7580 0 0 {name=X_84521_ }
C {devices/lab_pin.sym} 73380 -7470 0 0 {name=p73217 lab=_86108_/Q }
C {devices/lab_pin.sym} 73380 -7430 0 0 {name=p73218 lab=_50910_/X }
C {devices/lab_pin.sym} 73380 -7390 0 0 {name=p73219 lab=_50912_/Y }
C {devices/lab_pin.sym} 73540 -7430 0 1 {name=p73220 lab=_50913_/Y }
C {sky130_stdcells/o21ai_4.sym} 73460 -7430 0 0 {name=X_50913_ }
C {devices/lab_pin.sym} 73370 -7290 0 0 {name=p73221 lab=_84020_/CLK }
C {devices/lab_pin.sym} 73370 -7270 0 0 {name=p73222 lab=_75944_/B }
C {devices/lab_pin.sym} 73550 -7290 0 1 {name=p73223 lab=_41435_/A }
C {sky130_stdcells/dfxtp_4.sym} 73460 -7280 0 0 {name=X_81733_ }
C {devices/lab_pin.sym} 73380 -7180 0 0 {name=p73224 lab=_87516_/Q }
C {devices/lab_pin.sym} 73380 -7140 0 0 {name=p73225 lab=_69442_/X }
C {devices/lab_pin.sym} 73380 -7100 0 0 {name=p73226 lab=_69396_/X }
C {devices/lab_pin.sym} 73380 -7060 0 0 {name=p73227 lab=_69454_/X }
C {devices/lab_pin.sym} 73540 -7120 0 1 {name=p73228 lab=_69455_/X }
C {sky130_stdcells/a211o_4.sym} 73460 -7120 0 0 {name=X_69455_ }
C {devices/lab_pin.sym} 73380 -6990 0 0 {name=p73229 lab=_54679_/Y }
C {devices/lab_pin.sym} 73380 -6950 0 0 {name=p73230 lab=_54666_/X }
C {devices/lab_pin.sym} 73380 -6910 0 0 {name=p73231 lab=_54680_/X }
C {devices/lab_pin.sym} 73540 -6950 0 1 {name=p73232 lab=_54681_/Y }
C {sky130_stdcells/a21oi_4.sym} 73460 -6950 0 0 {name=X_54681_ }
C {devices/lab_pin.sym} 73420 -6810 0 0 {name=p73233 lab=_66547_/A }
C {devices/lab_pin.sym} 73500 -6810 0 1 {name=p73234 lab=_66667_/X }
C {sky130_stdcells/buf_2.sym} 73460 -6810 0 0 {name=X_66667_ }
C {devices/lab_pin.sym} 73400 -6720 0 0 {name=p73235 lab=_51887_/A }
C {devices/lab_pin.sym} 73400 -6680 0 0 {name=p73236 lab=_51870_/B }
C {devices/lab_pin.sym} 73400 -6640 0 0 {name=p73237 lab=_51893_/C }
C {devices/lab_pin.sym} 73400 -6600 0 0 {name=p73238 lab=_52720_/D }
C {devices/lab_pin.sym} 73520 -6660 0 1 {name=p73239 lab=_51893_/X }
C {sky130_stdcells/and4_4.sym} 73460 -6660 0 0 {name=X_51893_ }
C {devices/lab_pin.sym} 73380 -6550 0 0 {name=p73240 lab=_63874_/X }
C {devices/lab_pin.sym} 73380 -6510 0 0 {name=p73241 lab=_63810_/X }
C {devices/lab_pin.sym} 73380 -6470 0 0 {name=p73242 lab=_63876_/Y }
C {devices/lab_pin.sym} 73380 -6430 0 0 {name=p73243 lab=_63877_/Y }
C {devices/lab_pin.sym} 73380 -6400 0 0 {name=p73244 lab=_63878_/X }
C {devices/lab_pin.sym} 73540 -6470 0 1 {name=p73245 lab=_63879_/X }
C {sky130_stdcells/a41o_4.sym} 73460 -6470 0 0 {name=X_63879_ }
C {devices/lab_pin.sym} 73400 -6330 0 0 {name=p73246 lab=_56418_/A }
C {devices/lab_pin.sym} 73400 -6290 0 0 {name=p73247 lab=_56418_/B }
C {devices/lab_pin.sym} 73400 -6250 0 0 {name=p73248 lab=_56420_/C }
C {devices/lab_pin.sym} 73520 -6290 0 1 {name=p73249 lab=_56420_/Y }
C {sky130_stdcells/nand3_4.sym} 73460 -6290 0 0 {name=X_56420_ }
C {devices/lab_pin.sym} 73380 -6180 0 0 {name=p73250 lab=_87506_/Q }
C {devices/lab_pin.sym} 73380 -6140 0 0 {name=p73251 lab=_68365_/X }
C {devices/lab_pin.sym} 73380 -6100 0 0 {name=p73252 lab=_68053_/X }
C {devices/lab_pin.sym} 73380 -6060 0 0 {name=p73253 lab=_68405_/X }
C {devices/lab_pin.sym} 73540 -6120 0 1 {name=p73254 lab=_68406_/X }
C {sky130_stdcells/a211o_4.sym} 73460 -6120 0 0 {name=X_68406_ }
C {devices/lab_pin.sym} 73370 -5970 0 0 {name=p73255 lab=_88012_/CLK }
C {devices/lab_pin.sym} 73370 -5950 0 0 {name=p73256 lab=_43838_/X }
C {devices/lab_pin.sym} 73550 -5970 0 1 {name=p73257 lab=_87240_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -5960 0 0 {name=X_87240_ }
C {devices/lab_pin.sym} 73380 -5850 0 0 {name=p73258 lab=_53629_/Y }
C {devices/lab_pin.sym} 73380 -5810 0 0 {name=p73259 lab=_53619_/X }
C {devices/lab_pin.sym} 73380 -5770 0 0 {name=p73260 lab=_53631_/X }
C {devices/lab_pin.sym} 73540 -5810 0 1 {name=p73261 lab=_53632_/Y }
C {sky130_stdcells/a21oi_4.sym} 73460 -5810 0 0 {name=X_53632_ }
C {devices/lab_pin.sym} 73400 -5690 0 0 {name=p73262 lab=_65615_/X }
C {devices/lab_pin.sym} 73400 -5650 0 0 {name=p73263 lab=_65663_/B }
C {devices/lab_pin.sym} 73400 -5610 0 0 {name=p73264 lab=_65617_/X }
C {devices/lab_pin.sym} 73520 -5650 0 1 {name=p73265 lab=_65619_/B }
C {sky130_stdcells/nand3_4.sym} 73460 -5650 0 0 {name=X_65618_ }
C {devices/lab_pin.sym} 73370 -5510 0 0 {name=p73266 lab=_84452_/CLK }
C {devices/lab_pin.sym} 73370 -5490 0 0 {name=p73267 lab=_61822_/Y }
C {devices/lab_pin.sym} 73550 -5510 0 1 {name=p73268 lab=_78075_/B }
C {sky130_stdcells/dfxtp_4.sym} 73460 -5500 0 0 {name=X_84452_ }
C {devices/lab_pin.sym} 73420 -5370 0 0 {name=p73269 lab=_50638_/A }
C {devices/lab_pin.sym} 73500 -5370 0 1 {name=p73270 lab=_50845_/A }
C {sky130_stdcells/buf_2.sym} 73460 -5370 0 0 {name=X_50844_ }
C {devices/lab_pin.sym} 73370 -5250 0 0 {name=p73271 lab=_81587_/CLK }
C {devices/lab_pin.sym} 73370 -5230 0 0 {name=p73272 lab=_76773_/A }
C {devices/lab_pin.sym} 73550 -5250 0 1 {name=p73273 lab=_81664_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -5240 0 0 {name=X_81664_ }
C {devices/lab_pin.sym} 73380 -5130 0 0 {name=p73274 lab=_69382_/X }
C {devices/lab_pin.sym} 73380 -5090 0 0 {name=p73275 lab=_69384_/X }
C {devices/lab_pin.sym} 73380 -5050 0 0 {name=p73276 lab=_69385_/X }
C {devices/lab_pin.sym} 73540 -5090 0 1 {name=p73277 lab=_69386_/X }
C {sky130_stdcells/a21o_4.sym} 73460 -5090 0 0 {name=X_69386_ }
C {devices/lab_pin.sym} 73400 -4960 0 0 {name=p73278 lab=_69454_/A }
C {devices/lab_pin.sym} 73400 -4920 0 0 {name=p73279 lab=_66598_/B }
C {devices/lab_pin.sym} 73520 -4940 0 1 {name=p73280 lab=_66598_/X }
C {sky130_stdcells/and2_4.sym} 73460 -4940 0 0 {name=X_66598_ }
C {devices/lab_pin.sym} 73370 -4810 0 0 {name=p73281 lab=_83372_/CLK }
C {devices/lab_pin.sym} 73370 -4790 0 0 {name=p73282 lab=_83403_/D }
C {devices/lab_pin.sym} 73550 -4810 0 1 {name=p73283 lab=_58303_/A }
C {sky130_stdcells/dfxtp_4.sym} 73460 -4800 0 0 {name=X_83403_ }
C {devices/lab_pin.sym} 73400 -4680 0 0 {name=p73284 lab=_80613_/X }
C {devices/lab_pin.sym} 73400 -4640 0 0 {name=p73285 lab=_80614_/X }
C {devices/lab_pin.sym} 73520 -4660 0 1 {name=p73286 lab=_80615_/Y }
C {sky130_stdcells/xnor2_4.sym} 73460 -4660 0 0 {name=X_80615_ }
C {devices/lab_pin.sym} 73380 -4550 0 0 {name=p73287 lab=_83979_/Q }
C {devices/lab_pin.sym} 73380 -4510 0 0 {name=p73288 lab=_68318_/X }
C {devices/lab_pin.sym} 73380 -4470 0 0 {name=p73289 lab=_68336_/X }
C {devices/lab_pin.sym} 73540 -4510 0 1 {name=p73290 lab=_83979_/D }
C {sky130_stdcells/a21bo_4.sym} 73460 -4510 0 0 {name=X_68337_ }
C {devices/lab_pin.sym} 73420 -4370 0 0 {name=p73291 lab=_56351_/A }
C {devices/lab_pin.sym} 73500 -4370 0 1 {name=p73292 lab=_56358_/B }
C {sky130_stdcells/buf_2.sym} 73460 -4370 0 0 {name=X_56351_ }
C {devices/lab_pin.sym} 73370 -4250 0 0 {name=p73293 lab=_87169_/CLK }
C {devices/lab_pin.sym} 73370 -4230 0 0 {name=p73294 lab=_44311_/Y }
C {devices/lab_pin.sym} 73550 -4250 0 1 {name=p73295 lab=_43987_/A }
C {sky130_stdcells/dfxtp_4.sym} 73460 -4240 0 0 {name=X_87171_ }
C {devices/lab_pin.sym} 73400 -4120 0 0 {name=p73296 lab=_65184_/A }
C {devices/lab_pin.sym} 73400 -4080 0 0 {name=p73297 lab=_85881_/Q }
C {devices/lab_pin.sym} 73520 -4100 0 1 {name=p73298 lab=_65549_/X }
C {sky130_stdcells/and2_4.sym} 73460 -4100 0 0 {name=X_65549_ }
C {devices/lab_pin.sym} 73400 -3980 0 0 {name=p73299 lab=_53548_/A }
C {devices/lab_pin.sym} 73400 -3940 0 0 {name=p73300 lab=_48051_/Y }
C {devices/lab_pin.sym} 73520 -3960 0 1 {name=p73301 lab=_53563_/Y }
C {sky130_stdcells/nand2_4.sym} 73460 -3960 0 0 {name=X_53563_ }
C {devices/lab_pin.sym} 73370 -3830 0 0 {name=p73302 lab=_84520_/CLK }
C {devices/lab_pin.sym} 73370 -3810 0 0 {name=p73303 lab=_84383_/D }
C {devices/lab_pin.sym} 73550 -3830 0 1 {name=p73304 lab=_84383_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -3820 0 0 {name=X_84383_ }
C {devices/lab_pin.sym} 73420 -3690 0 0 {name=p73305 lab=_50742_/A }
C {devices/lab_pin.sym} 73500 -3690 0 1 {name=p73306 lab=_50775_/X }
C {sky130_stdcells/buf_2.sym} 73460 -3690 0 0 {name=X_50775_ }
C {devices/lab_pin.sym} 73370 -3570 0 0 {name=p73307 lab=_84064_/CLK }
C {devices/lab_pin.sym} 73370 -3550 0 0 {name=p73308 lab=_65531_/C }
C {devices/lab_pin.sym} 73550 -3570 0 1 {name=p73309 lab=_81595_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -3560 0 0 {name=X_81595_ }
C {devices/lab_pin.sym} 73420 -3430 0 0 {name=p73310 lab=_55192_/A }
C {devices/lab_pin.sym} 73500 -3430 0 1 {name=p73311 lab=_55317_/A }
C {sky130_stdcells/buf_2.sym} 73460 -3430 0 0 {name=X_55302_ }
C {devices/lab_pin.sym} 73370 -3310 0 0 {name=p73312 lab=_86122_/CLK }
C {devices/lab_pin.sym} 73370 -3290 0 0 {name=p73313 lab=_86122_/D }
C {devices/lab_pin.sym} 73550 -3310 0 1 {name=p73314 lab=_86122_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -3300 0 0 {name=X_86122_ }
C {devices/lab_pin.sym} 73380 -3190 0 0 {name=p73315 lab=_52512_/Y }
C {devices/lab_pin.sym} 73380 -3150 0 0 {name=p73316 lab=_52486_/X }
C {devices/lab_pin.sym} 73380 -3110 0 0 {name=p73317 lab=_52513_/Y }
C {devices/lab_pin.sym} 73540 -3150 0 1 {name=p73318 lab=_52514_/Y }
C {sky130_stdcells/a21boi_4.sym} 73460 -3150 0 0 {name=X_52514_ }
C {devices/lab_pin.sym} 73420 -3010 0 0 {name=p73319 lab=_58810_/A }
C {devices/lab_pin.sym} 73500 -3010 0 1 {name=p73320 lab=_59070_/X }
C {sky130_stdcells/buf_2.sym} 73460 -3010 0 0 {name=X_59070_ }
C {devices/lab_pin.sym} 73370 -2890 0 0 {name=p73321 lab=_83335_/CLK }
C {devices/lab_pin.sym} 73370 -2870 0 0 {name=p73322 lab=_83334_/D }
C {devices/lab_pin.sym} 73550 -2890 0 1 {name=p73323 lab=_83334_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -2880 0 0 {name=X_83334_ }
C {devices/lab_pin.sym} 73400 -2780 0 0 {name=p73324 lab=_73024_/B }
C {devices/lab_pin.sym} 73400 -2740 0 0 {name=p73325 lab=_56460_/B }
C {devices/lab_pin.sym} 73400 -2700 0 0 {name=p73326 lab=_56278_/A }
C {devices/lab_pin.sym} 73400 -2660 0 0 {name=p73327 lab=_56460_/D }
C {devices/lab_pin.sym} 73520 -2720 0 1 {name=p73328 lab=_56282_/Y }
C {sky130_stdcells/nand4_4.sym} 73460 -2720 0 0 {name=X_56282_ }
C {devices/lab_pin.sym} 73380 -2590 0 0 {name=p73329 lab=_80538_/X }
C {devices/lab_pin.sym} 73380 -2550 0 0 {name=p73330 lab=_80540_/B }
C {devices/lab_pin.sym} 73380 -2510 0 0 {name=p73331 lab=_80545_/Y }
C {devices/lab_pin.sym} 73540 -2550 0 1 {name=p73332 lab=_80550_/A }
C {sky130_stdcells/a21boi_4.sym} 73460 -2550 0 0 {name=X_80546_ }
C {devices/lab_pin.sym} 73420 -2410 0 0 {name=p73333 lab=_68447_/A }
C {devices/lab_pin.sym} 73500 -2410 0 1 {name=p73334 lab=_68268_/X }
C {sky130_stdcells/buf_2.sym} 73460 -2410 0 0 {name=X_68268_ }
C {devices/lab_pin.sym} 73380 -2310 0 0 {name=p73335 lab=_53491_/Y }
C {devices/lab_pin.sym} 73380 -2270 0 0 {name=p73336 lab=_53472_/X }
C {devices/lab_pin.sym} 73380 -2230 0 0 {name=p73337 lab=_53493_/X }
C {devices/lab_pin.sym} 73540 -2270 0 1 {name=p73338 lab=_53494_/Y }
C {sky130_stdcells/a21oi_4.sym} 73460 -2270 0 0 {name=X_53494_ }
C {devices/lab_pin.sym} 73380 -2150 0 0 {name=p73339 lab=_57966_/X }
C {devices/lab_pin.sym} 73380 -2110 0 0 {name=p73340 lab=_85708_/Q }
C {devices/lab_pin.sym} 73380 -2070 0 0 {name=p73341 lab=_58020_/X }
C {devices/lab_pin.sym} 73540 -2110 0 1 {name=p73342 lab=_58021_/X }
C {sky130_stdcells/o21a_4.sym} 73460 -2110 0 0 {name=X_58021_ }
C {devices/lab_pin.sym} 73380 -1990 0 0 {name=p73343 lab=_55230_/X }
C {devices/lab_pin.sym} 73380 -1950 0 0 {name=p73344 lab=_55232_/X }
C {devices/lab_pin.sym} 73380 -1910 0 0 {name=p73345 lab=_55138_/A }
C {devices/lab_pin.sym} 73540 -1950 0 1 {name=p73346 lab=_55655_/A }
C {sky130_stdcells/a21o_4.sym} 73460 -1950 0 0 {name=X_55233_ }
C {devices/lab_pin.sym} 73380 -1840 0 0 {name=p73347 lab=_88376_/Q }
C {devices/lab_pin.sym} 73380 -1800 0 0 {name=p73348 lab=_67193_/X }
C {devices/lab_pin.sym} 73380 -1760 0 0 {name=p73349 lab=_67194_/X }
C {devices/lab_pin.sym} 73380 -1720 0 0 {name=p73350 lab=_67218_/X }
C {devices/lab_pin.sym} 73540 -1780 0 1 {name=p73351 lab=_67219_/X }
C {sky130_stdcells/a211o_4.sym} 73460 -1780 0 0 {name=X_67219_ }
C {devices/lab_pin.sym} 73370 -1630 0 0 {name=p73352 lab=_86054_/CLK }
C {devices/lab_pin.sym} 73370 -1610 0 0 {name=p73353 lab=_86053_/D }
C {devices/lab_pin.sym} 73550 -1630 0 1 {name=p73354 lab=_86053_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -1620 0 0 {name=X_86053_ }
C {devices/lab_pin.sym} 73380 -1510 0 0 {name=p73355 lab=_64694_/B }
C {devices/lab_pin.sym} 73380 -1470 0 0 {name=p73356 lab=_52422_/X }
C {devices/lab_pin.sym} 73380 -1430 0 0 {name=p73357 lab=_52444_/Y }
C {devices/lab_pin.sym} 73540 -1470 0 1 {name=p73358 lab=_52445_/Y }
C {sky130_stdcells/o21ai_4.sym} 73460 -1470 0 0 {name=X_52445_ }
C {devices/lab_pin.sym} 73370 -1330 0 0 {name=p73359 lab=_81233_/CLK }
C {devices/lab_pin.sym} 73370 -1310 0 0 {name=p73360 lab=_83265_/D }
C {devices/lab_pin.sym} 73550 -1330 0 1 {name=p73361 lab=_72313_/A }
C {sky130_stdcells/dfxtp_4.sym} 73460 -1320 0 0 {name=X_83265_ }
C {devices/lab_pin.sym} 73400 -1200 0 0 {name=p73362 lab=_80489_/A }
C {devices/lab_pin.sym} 73400 -1160 0 0 {name=p73363 lab=_80489_/B }
C {devices/lab_pin.sym} 73520 -1180 0 1 {name=p73364 lab=_80480_/A }
C {sky130_stdcells/xor2_4.sym} 73460 -1180 0 0 {name=X_80477_ }
C {devices/lab_pin.sym} 73380 -1070 0 0 {name=p73365 lab=_84014_/Q }
C {devices/lab_pin.sym} 73380 -1030 0 0 {name=p73366 lab=_68180_/X }
C {devices/lab_pin.sym} 73380 -990 0 0 {name=p73367 lab=_68198_/X }
C {devices/lab_pin.sym} 73540 -1030 0 1 {name=p73368 lab=_68199_/X }
C {sky130_stdcells/a21bo_4.sym} 73460 -1030 0 0 {name=X_68199_ }
C {devices/lab_pin.sym} 73370 -890 0 0 {name=p73369 lab=_85034_/CLK }
C {devices/lab_pin.sym} 73370 -870 0 0 {name=p73370 lab=_85004_/D }
C {devices/lab_pin.sym} 73550 -890 0 1 {name=p73371 lab=_85004_/Q }
C {sky130_stdcells/dfxtp_4.sym} 73460 -880 0 0 {name=X_85004_ }
C {devices/lab_pin.sym} 73380 -770 0 0 {name=p73372 lab=_70224_/X }
C {devices/lab_pin.sym} 73380 -730 0 0 {name=p73373 lab=_83829_/Q }
C {devices/lab_pin.sym} 73380 -690 0 0 {name=p73374 lab=_70229_/X }
C {devices/lab_pin.sym} 73540 -730 0 1 {name=p73375 lab=_83829_/D }
C {sky130_stdcells/a21o_4.sym} 73460 -730 0 0 {name=X_70230_ }
C {devices/lab_pin.sym} 74290 -42150 0 0 {name=p73376 lab=_82084_/CLK }
C {devices/lab_pin.sym} 74290 -42130 0 0 {name=p73377 lab=_82248_/Q }
C {devices/lab_pin.sym} 74470 -42150 0 1 {name=p73378 lab=_77308_/A }
C {sky130_stdcells/dfxtp_4.sym} 74380 -42140 0 0 {name=X_82216_ }
C {devices/lab_pin.sym} 74300 -42030 0 0 {name=p73379 lab=_83747_/Q }
C {devices/lab_pin.sym} 74300 -41990 0 0 {name=p73380 lab=_55423_/B }
C {devices/lab_pin.sym} 74300 -41950 0 0 {name=p73381 lab=_55163_/Y }
C {devices/lab_pin.sym} 74460 -41990 0 1 {name=p73382 lab=_55164_/X }
C {sky130_stdcells/o21a_4.sym} 74380 -41990 0 0 {name=X_55164_ }
C {devices/lab_pin.sym} 74300 -41870 0 0 {name=p73383 lab=_40381_/X }
C {devices/lab_pin.sym} 74300 -41830 0 0 {name=p73384 lab=_81181_/Q }
C {devices/lab_pin.sym} 74300 -41790 0 0 {name=p73385 lab=_40389_/X }
C {devices/lab_pin.sym} 74460 -41830 0 1 {name=p73386 lab=_40390_/Y }
C {sky130_stdcells/o21ai_4.sym} 74380 -41830 0 0 {name=X_40390_ }
C {devices/lab_pin.sym} 74340 -41690 0 0 {name=p73387 lab=_52309_/A }
C {devices/lab_pin.sym} 74420 -41690 0 1 {name=p73388 lab=_52446_/B }
C {sky130_stdcells/buf_2.sym} 74380 -41690 0 0 {name=X_52376_ }
C {devices/lab_pin.sym} 74290 -41570 0 0 {name=p73389 lab=_83191_/CLK }
C {devices/lab_pin.sym} 74290 -41550 0 0 {name=p73390 lab=_83196_/D }
C {devices/lab_pin.sym} 74470 -41570 0 1 {name=p73391 lab=_70210_/C }
C {sky130_stdcells/dfxtp_4.sym} 74380 -41560 0 0 {name=X_83196_ }
C {devices/lab_pin.sym} 74320 -41440 0 0 {name=p73392 lab=_54134_/A }
C {devices/lab_pin.sym} 74320 -41400 0 0 {name=p73393 lab=_47260_/A }
C {devices/lab_pin.sym} 74440 -41420 0 1 {name=p73394 lab=_54115_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -41420 0 0 {name=X_54115_ }
C {devices/lab_pin.sym} 74300 -41310 0 0 {name=p73395 lab=_51325_/Y }
C {devices/lab_pin.sym} 74300 -41270 0 0 {name=p73396 lab=_51313_/X }
C {devices/lab_pin.sym} 74300 -41230 0 0 {name=p73397 lab=_51326_/X }
C {devices/lab_pin.sym} 74460 -41270 0 1 {name=p73398 lab=_51327_/Y }
C {sky130_stdcells/a21oi_4.sym} 74380 -41270 0 0 {name=X_51327_ }
C {devices/lab_pin.sym} 74340 -41130 0 0 {name=p73399 lab=_70154_/X }
C {devices/lab_pin.sym} 74420 -41130 0 1 {name=p73400 lab=_70348_/B }
C {sky130_stdcells/buf_2.sym} 74380 -41130 0 0 {name=X_70161_ }
C {devices/lab_pin.sym} 74290 -41010 0 0 {name=p73401 lab=_82147_/CLK }
C {devices/lab_pin.sym} 74290 -40990 0 0 {name=p73402 lab=_84139_/Q }
C {devices/lab_pin.sym} 74470 -41010 0 1 {name=p73403 lab=_82147_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -41000 0 0 {name=X_82147_ }
C {devices/lab_pin.sym} 74340 -40870 0 0 {name=p73404 lab=_46614_/X }
C {devices/lab_pin.sym} 74420 -40870 0 1 {name=p73405 lab=_55112_/A }
C {sky130_stdcells/buf_2.sym} 74380 -40870 0 0 {name=X_55095_ }
C {devices/lab_pin.sym} 74340 -40750 0 0 {name=p73406 lab=clkbuf_9_136_0_CLK/X }
C {devices/lab_pin.sym} 74420 -40750 0 1 {name=p73407 lab=_83415_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 74380 -40750 0 0 {name=Xclkbuf_10_272_0_CLK }
C {devices/lab_pin.sym} 74340 -40630 0 0 {name=p73408 lab=_62534_/A }
C {devices/lab_pin.sym} 74420 -40630 0 1 {name=p73409 lab=_59995_/A }
C {sky130_stdcells/buf_2.sym} 74380 -40630 0 0 {name=X_59972_ }
C {devices/lab_pin.sym} 74340 -40510 0 0 {name=p73410 lab=_58923_/A }
C {devices/lab_pin.sym} 74420 -40510 0 1 {name=p73411 lab=_58923_/X }
C {sky130_stdcells/buf_2.sym} 74380 -40510 0 0 {name=X_58923_ }
C {devices/lab_pin.sym} 74300 -40410 0 0 {name=p73412 lab=_85516_/Q }
C {devices/lab_pin.sym} 74300 -40370 0 0 {name=p73413 lab=_54035_/X }
C {devices/lab_pin.sym} 74300 -40330 0 0 {name=p73414 lab=_54045_/Y }
C {devices/lab_pin.sym} 74460 -40370 0 1 {name=p73415 lab=_54046_/Y }
C {sky130_stdcells/o21ai_4.sym} 74380 -40370 0 0 {name=X_54046_ }
C {devices/lab_pin.sym} 74340 -40230 0 0 {name=p73416 lab=_43129_/A }
C {devices/lab_pin.sym} 74420 -40230 0 1 {name=p73417 lab=_42060_/X }
C {sky130_stdcells/buf_2.sym} 74380 -40230 0 0 {name=X_42060_ }
C {devices/lab_pin.sym} 74340 -40110 0 0 {name=p73418 lab=_48808_/A }
C {devices/lab_pin.sym} 74420 -40110 0 1 {name=p73419 lab=_51259_/A }
C {sky130_stdcells/buf_2.sym} 74380 -40110 0 0 {name=X_51258_ }
C {devices/lab_pin.sym} 74300 -40010 0 0 {name=p73420 lab=_69960_/X }
C {devices/lab_pin.sym} 74300 -39970 0 0 {name=p73421 lab=_69962_/X }
C {devices/lab_pin.sym} 74300 -39930 0 0 {name=p73422 lab=_68400_/X }
C {devices/lab_pin.sym} 74460 -39970 0 1 {name=p73423 lab=_70092_/Y }
C {sky130_stdcells/a21oi_4.sym} 74380 -39970 0 0 {name=X_70092_ }
C {devices/lab_pin.sym} 74290 -39830 0 0 {name=p73424 lab=_88232_/CLK }
C {devices/lab_pin.sym} 74290 -39810 0 0 {name=p73425 lab=_86955_/D }
C {devices/lab_pin.sym} 74470 -39830 0 1 {name=p73426 lab=_86955_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -39820 0 0 {name=X_86955_ }
C {devices/lab_pin.sym} 74290 -39690 0 0 {name=p73427 lab=_81169_/CLK }
C {devices/lab_pin.sym} 74290 -39670 0 0 {name=p73428 lab=_82078_/D }
C {devices/lab_pin.sym} 74470 -39690 0 1 {name=p73429 lab=_82078_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -39680 0 0 {name=X_82078_ }
C {devices/lab_pin.sym} 74340 -39550 0 0 {name=p73430 lab=clkbuf_9_27_0_CLK/X }
C {devices/lab_pin.sym} 74420 -39550 0 1 {name=p73431 lab=_85100_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 74380 -39550 0 0 {name=Xclkbuf_10_54_0_CLK }
C {devices/lab_pin.sym} 74340 -39430 0 0 {name=p73432 lab=_41010_/Y }
C {devices/lab_pin.sym} 74420 -39430 0 1 {name=p73433 lab=_41011_/Y }
C {sky130_stdcells/inv_2.sym} 74380 -39430 0 0 {name=X_41011_ }
C {devices/lab_pin.sym} 74320 -39330 0 0 {name=p73434 lab=_50209_/A }
C {devices/lab_pin.sym} 74320 -39290 0 0 {name=p73435 lab=_51256_/B }
C {devices/lab_pin.sym} 74320 -39250 0 0 {name=p73436 lab=_50147_/C }
C {devices/lab_pin.sym} 74440 -39290 0 1 {name=p73437 lab=_50209_/X }
C {sky130_stdcells/and3_4.sym} 74380 -39290 0 0 {name=X_50209_ }
C {devices/lab_pin.sym} 74340 -39150 0 0 {name=p73438 lab=_72979_/X }
C {devices/lab_pin.sym} 74420 -39150 0 1 {name=p73439 lab=_73920_/X }
C {sky130_stdcells/buf_2.sym} 74380 -39150 0 0 {name=X_73920_ }
C {devices/lab_pin.sym} 74290 -39030 0 0 {name=p73440 lab=_86554_/CLK }
C {devices/lab_pin.sym} 74290 -39010 0 0 {name=p73441 lab=_52012_/Y }
C {devices/lab_pin.sym} 74470 -39030 0 1 {name=p73442 lab=_85906_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -39020 0 0 {name=X_85906_ }
C {devices/lab_pin.sym} 74290 -38890 0 0 {name=p73443 lab=_84197_/CLK }
C {devices/lab_pin.sym} 74290 -38870 0 0 {name=p73444 lab=_75122_/Y }
C {devices/lab_pin.sym} 74470 -38890 0 1 {name=p73445 lab=_81029_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -38880 0 0 {name=X_81029_ }
C {devices/lab_pin.sym} 74340 -38750 0 0 {name=p73446 lab=clkbuf_9_393_0_CLK/A }
C {devices/lab_pin.sym} 74420 -38750 0 1 {name=p73447 lab=clkbuf_9_393_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 74380 -38750 0 0 {name=Xclkbuf_9_393_0_CLK }
C {devices/lab_pin.sym} 74300 -38670 0 0 {name=p73448 lab=_58748_/X }
C {devices/lab_pin.sym} 74300 -38630 0 0 {name=p73449 lab=_58851_/Y }
C {devices/lab_pin.sym} 74300 -38590 0 0 {name=p73450 lab=_58853_/Y }
C {devices/lab_pin.sym} 74300 -38550 0 0 {name=p73451 lab=_58766_/X }
C {devices/lab_pin.sym} 74300 -38510 0 0 {name=p73452 lab=_58752_/X }
C {devices/lab_pin.sym} 74460 -38590 0 1 {name=p73453 lab=_58854_/X }
C {sky130_stdcells/o32a_4.sym} 74380 -38590 0 0 {name=X_58854_ }
C {devices/lab_pin.sym} 74320 -38440 0 0 {name=p73454 lab=_51184_/X }
C {devices/lab_pin.sym} 74320 -38400 0 0 {name=p73455 lab=_52881_/B }
C {devices/lab_pin.sym} 74440 -38420 0 1 {name=p73456 lab=_51189_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -38420 0 0 {name=X_51189_ }
C {devices/lab_pin.sym} 74340 -38290 0 0 {name=p73457 lab=clkbuf_8_201_0_CLK/A }
C {devices/lab_pin.sym} 74420 -38290 0 1 {name=p73458 lab=clkbuf_8_200_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 74380 -38290 0 0 {name=Xclkbuf_8_200_0_CLK }
C {devices/lab_pin.sym} 74290 -38170 0 0 {name=p73459 lab=_80664_/CLK }
C {devices/lab_pin.sym} 74290 -38150 0 0 {name=p73460 lab=_45296_/Y }
C {devices/lab_pin.sym} 74470 -38170 0 1 {name=p73461 lab=_64494_/B }
C {sky130_stdcells/dfxtp_4.sym} 74380 -38160 0 0 {name=X_86886_ }
C {devices/lab_pin.sym} 74340 -38030 0 0 {name=p73462 lab=_58697_/A }
C {devices/lab_pin.sym} 74420 -38030 0 1 {name=p73463 lab=_58080_/A }
C {sky130_stdcells/buf_2.sym} 74380 -38030 0 0 {name=X_57805_ }
C {devices/lab_pin.sym} 74340 -37910 0 0 {name=p73464 lab=clkbuf_9_143_0_CLK/X }
C {devices/lab_pin.sym} 74420 -37910 0 1 {name=p73465 lab=_85492_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 74380 -37910 0 0 {name=Xclkbuf_10_287_0_CLK }
C {devices/lab_pin.sym} 74340 -37790 0 0 {name=p73466 lab=_73709_/X }
C {devices/lab_pin.sym} 74420 -37790 0 1 {name=p73467 lab=_73949_/A }
C {sky130_stdcells/buf_2.sym} 74380 -37790 0 0 {name=X_73851_ }
C {devices/lab_pin.sym} 74290 -37670 0 0 {name=p73468 lab=_85837_/CLK }
C {devices/lab_pin.sym} 74290 -37650 0 0 {name=p73469 lab=_52366_/Y }
C {devices/lab_pin.sym} 74470 -37670 0 1 {name=p73470 lab=_65130_/B }
C {sky130_stdcells/dfxtp_4.sym} 74380 -37660 0 0 {name=X_85837_ }
C {devices/lab_pin.sym} 74340 -37530 0 0 {name=p73471 lab=_58785_/A }
C {devices/lab_pin.sym} 74420 -37530 0 1 {name=p73472 lab=_64836_/A }
C {sky130_stdcells/buf_2.sym} 74380 -37530 0 0 {name=X_58785_ }
C {devices/lab_pin.sym} 74340 -37410 0 0 {name=p73473 lab=_55996_/X }
C {devices/lab_pin.sym} 74420 -37410 0 1 {name=p73474 lab=_55997_/X }
C {sky130_stdcells/buf_2.sym} 74380 -37410 0 0 {name=X_55997_ }
C {devices/lab_pin.sym} 74300 -37310 0 0 {name=p73475 lab=_72797_/X }
C {devices/lab_pin.sym} 74300 -37270 0 0 {name=p73476 lab=_72801_/X }
C {devices/lab_pin.sym} 74300 -37230 0 0 {name=p73477 lab=_72737_/X }
C {devices/lab_pin.sym} 74460 -37270 0 1 {name=p73478 lab=_72802_/X }
C {sky130_stdcells/a21o_4.sym} 74380 -37270 0 0 {name=X_72802_ }
C {devices/lab_pin.sym} 74340 -37130 0 0 {name=p73479 lab=_57736_/A }
C {devices/lab_pin.sym} 74420 -37130 0 1 {name=p73480 lab=_57736_/X }
C {sky130_stdcells/buf_2.sym} 74380 -37130 0 0 {name=X_57736_ }
C {devices/lab_pin.sym} 74300 -37030 0 0 {name=p73481 lab=_45748_/X }
C {devices/lab_pin.sym} 74300 -36990 0 0 {name=p73482 lab=_61597_/A }
C {devices/lab_pin.sym} 74300 -36950 0 0 {name=p73483 lab=_45685_/X }
C {devices/lab_pin.sym} 74460 -36990 0 1 {name=p73484 lab=_45750_/Y }
C {sky130_stdcells/o21ai_4.sym} 74380 -36990 0 0 {name=X_45750_ }
C {devices/lab_pin.sym} 74340 -36850 0 0 {name=p73485 lab=_76569_/Y }
C {devices/lab_pin.sym} 74420 -36850 0 1 {name=p73486 lab=_76571_/B }
C {sky130_stdcells/inv_2.sym} 74380 -36850 0 0 {name=X_76570_ }
C {devices/lab_pin.sym} 74340 -36730 0 0 {name=p73487 lab=_42962_/A }
C {devices/lab_pin.sym} 74420 -36730 0 1 {name=p73488 lab=_42962_/X }
C {sky130_stdcells/buf_2.sym} 74380 -36730 0 0 {name=X_42962_ }
C {devices/lab_pin.sym} 74320 -36620 0 0 {name=p73489 lab=_53460_/A }
C {devices/lab_pin.sym} 74320 -36580 0 0 {name=p73490 lab=_47809_/A }
C {devices/lab_pin.sym} 74440 -36600 0 1 {name=p73491 lab=_54948_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -36600 0 0 {name=X_54948_ }
C {devices/lab_pin.sym} 74290 -36470 0 0 {name=p73492 lab=_85770_/CLK }
C {devices/lab_pin.sym} 74290 -36450 0 0 {name=p73493 lab=_52717_/Y }
C {devices/lab_pin.sym} 74470 -36470 0 1 {name=p73494 lab=_85768_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -36460 0 0 {name=X_85768_ }
C {devices/lab_pin.sym} 74340 -36330 0 0 {name=p73495 lab=_73284_/A }
C {devices/lab_pin.sym} 74420 -36330 0 1 {name=p73496 lab=_73782_/X }
C {sky130_stdcells/buf_2.sym} 74380 -36330 0 0 {name=X_73782_ }
C {devices/lab_pin.sym} 74340 -36210 0 0 {name=p73497 lab=clkbuf_9_34_0_CLK/X }
C {devices/lab_pin.sym} 74420 -36210 0 1 {name=p73498 lab=_80657_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 74380 -36210 0 0 {name=Xclkbuf_10_69_0_CLK }
C {devices/lab_pin.sym} 74340 -36090 0 0 {name=p73499 lab=_70994_/A }
C {devices/lab_pin.sym} 74420 -36090 0 1 {name=p73500 lab=_71080_/B }
C {sky130_stdcells/buf_2.sym} 74380 -36090 0 0 {name=X_70994_ }
C {devices/lab_pin.sym} 74300 -36010 0 0 {name=p73501 lab=_44679_/X }
C {devices/lab_pin.sym} 74300 -35970 0 0 {name=p73502 lab=_44680_/X }
C {devices/lab_pin.sym} 74300 -35930 0 0 {name=p73503 lab=_40661_/X }
C {devices/lab_pin.sym} 74300 -35890 0 0 {name=p73504 lab=_86994_/Q }
C {devices/lab_pin.sym} 74300 -35850 0 0 {name=p73505 lab=_44681_/X }
C {devices/lab_pin.sym} 74460 -35930 0 1 {name=p73506 lab=_44702_/A }
C {sky130_stdcells/o32ai_4.sym} 74380 -35930 0 0 {name=X_44701_ }
C {devices/lab_pin.sym} 74290 -35770 0 0 {name=p73507 lab=_87520_/CLK }
C {devices/lab_pin.sym} 74290 -35750 0 0 {name=p73508 lab=_43271_/Y }
C {devices/lab_pin.sym} 74470 -35770 0 1 {name=p73509 lab=_87507_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -35760 0 0 {name=X_87507_ }
C {devices/lab_pin.sym} 74300 -35650 0 0 {name=p73510 lab=_75498_/A }
C {devices/lab_pin.sym} 74300 -35610 0 0 {name=p73511 lab=_75495_/Y }
C {devices/lab_pin.sym} 74300 -35570 0 0 {name=p73512 lab=_75497_/A }
C {devices/lab_pin.sym} 74460 -35610 0 1 {name=p73513 lab=_75522_/A }
C {sky130_stdcells/o21a_4.sym} 74380 -35610 0 0 {name=X_75521_ }
C {devices/lab_pin.sym} 74300 -35500 0 0 {name=p73514 lab=_40626_/X }
C {devices/lab_pin.sym} 74300 -35460 0 0 {name=p73515 lab=_41907_/X }
C {devices/lab_pin.sym} 74300 -35420 0 0 {name=p73516 lab=_88108_/Q }
C {devices/lab_pin.sym} 74300 -35380 0 0 {name=p73517 lab=_41912_/X }
C {devices/lab_pin.sym} 74460 -35440 0 1 {name=p73518 lab=_41913_/X }
C {sky130_stdcells/a2bb2o_4.sym} 74380 -35440 0 0 {name=X_41913_ }
C {devices/lab_pin.sym} 74340 -35290 0 0 {name=p73519 lab=clkbuf_8_215_0_CLK/A }
C {devices/lab_pin.sym} 74420 -35290 0 1 {name=p73520 lab=clkbuf_9_430_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 74380 -35290 0 0 {name=Xclkbuf_8_215_0_CLK }
C {devices/lab_pin.sym} 74300 -35200 0 0 {name=p73521 lab=_43113_/Y }
C {devices/lab_pin.sym} 74300 -35160 0 0 {name=p73522 lab=_72731_/X }
C {devices/lab_pin.sym} 74300 -35120 0 0 {name=p73523 lab=_56935_/X }
C {devices/lab_pin.sym} 74300 -35080 0 0 {name=p73524 lab=_72732_/Y }
C {devices/lab_pin.sym} 74460 -35140 0 1 {name=p73525 lab=_72733_/X }
C {sky130_stdcells/a211o_4.sym} 74380 -35140 0 0 {name=X_72733_ }
C {devices/lab_pin.sym} 74290 -34990 0 0 {name=p73526 lab=_84903_/CLK }
C {devices/lab_pin.sym} 74290 -34970 0 0 {name=p73527 lab=_59487_/Y }
C {devices/lab_pin.sym} 74470 -34990 0 1 {name=p73528 lab=_64236_/C }
C {sky130_stdcells/dfxtp_4.sym} 74380 -34980 0 0 {name=X_84719_ }
C {devices/lab_pin.sym} 74340 -34850 0 0 {name=p73529 lab=_45681_/A }
C {devices/lab_pin.sym} 74420 -34850 0 1 {name=p73530 lab=_74667_/B }
C {sky130_stdcells/inv_2.sym} 74380 -34850 0 0 {name=X_45681_ }
C {devices/lab_pin.sym} 74300 -34750 0 0 {name=p73531 lab=_57650_/X }
C {devices/lab_pin.sym} 74300 -34710 0 0 {name=p73532 lab=_57663_/Y }
C {devices/lab_pin.sym} 74300 -34670 0 0 {name=p73533 lab=_57666_/Y }
C {devices/lab_pin.sym} 74460 -34710 0 1 {name=p73534 lab=_57667_/Y }
C {sky130_stdcells/a21oi_4.sym} 74380 -34710 0 0 {name=X_57667_ }
C {devices/lab_pin.sym} 74340 -34570 0 0 {name=p73535 lab=clkbuf_9_105_0_CLK/X }
C {devices/lab_pin.sym} 74420 -34570 0 1 {name=p73536 lab=_84503_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 74380 -34570 0 0 {name=Xclkbuf_10_210_0_CLK }
C {devices/lab_pin.sym} 74300 -34480 0 0 {name=p73537 lab=_41647_/X }
C {devices/lab_pin.sym} 74300 -34440 0 0 {name=p73538 lab=_42886_/X }
C {devices/lab_pin.sym} 74300 -34400 0 0 {name=p73539 lab=_67415_/B }
C {devices/lab_pin.sym} 74300 -34360 0 0 {name=p73540 lab=_42887_/X }
C {devices/lab_pin.sym} 74460 -34420 0 1 {name=p73541 lab=_87664_/D }
C {sky130_stdcells/a2bb2o_4.sym} 74380 -34420 0 0 {name=X_42893_ }
C {devices/lab_pin.sym} 74300 -34290 0 0 {name=p73542 lab=_54877_/Y }
C {devices/lab_pin.sym} 74300 -34250 0 0 {name=p73543 lab=_54856_/X }
C {devices/lab_pin.sym} 74300 -34210 0 0 {name=p73544 lab=_54878_/X }
C {devices/lab_pin.sym} 74460 -34250 0 1 {name=p73545 lab=_85361_/D }
C {sky130_stdcells/a21oi_4.sym} 74380 -34250 0 0 {name=X_54879_ }
C {devices/lab_pin.sym} 74290 -34110 0 0 {name=p73546 lab=_86688_/CLK }
C {devices/lab_pin.sym} 74290 -34090 0 0 {name=p73547 lab=_53091_/Y }
C {devices/lab_pin.sym} 74470 -34110 0 1 {name=p73548 lab=_85699_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -34100 0 0 {name=X_85699_ }
C {devices/lab_pin.sym} 74340 -33970 0 0 {name=p73549 lab=_83732_/Q }
C {devices/lab_pin.sym} 74420 -33970 0 1 {name=p73550 lab=_47420_/Y }
C {sky130_stdcells/inv_2.sym} 74380 -33970 0 0 {name=X_47420_ }
C {devices/lab_pin.sym} 74340 -33850 0 0 {name=p73551 lab=_63150_/A }
C {devices/lab_pin.sym} 74420 -33850 0 1 {name=p73552 lab=_59407_/A }
C {sky130_stdcells/buf_2.sym} 74380 -33850 0 0 {name=X_59406_ }
C {devices/lab_pin.sym} 74320 -33740 0 0 {name=p73553 lab=_78240_/A }
C {devices/lab_pin.sym} 74320 -33700 0 0 {name=p73554 lab=_78240_/B }
C {devices/lab_pin.sym} 74440 -33720 0 1 {name=p73555 lab=_78240_/X }
C {sky130_stdcells/xor2_4.sym} 74380 -33720 0 0 {name=X_78240_ }
C {devices/lab_pin.sym} 74300 -33630 0 0 {name=p73556 lab=_44622_/X }
C {devices/lab_pin.sym} 74300 -33590 0 0 {name=p73557 lab=_44623_/X }
C {devices/lab_pin.sym} 74300 -33550 0 0 {name=p73558 lab=_41016_/A }
C {devices/lab_pin.sym} 74300 -33510 0 0 {name=p73559 lab=_87025_/Q }
C {devices/lab_pin.sym} 74300 -33470 0 0 {name=p73560 lab=_44625_/X }
C {devices/lab_pin.sym} 74460 -33550 0 1 {name=p73561 lab=_44633_/A }
C {sky130_stdcells/o32ai_4.sym} 74380 -33550 0 0 {name=X_44632_ }
C {devices/lab_pin.sym} 74340 -33390 0 0 {name=p73562 lab=clkbuf_9_420_0_CLK/X }
C {devices/lab_pin.sym} 74420 -33390 0 1 {name=p73563 lab=_82177_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 74380 -33390 0 0 {name=Xclkbuf_10_840_0_CLK }
C {devices/lab_pin.sym} 74320 -33280 0 0 {name=p73564 lab=_72656_/C }
C {devices/lab_pin.sym} 74320 -33240 0 0 {name=p73565 lab=_56618_/B }
C {devices/lab_pin.sym} 74440 -33260 0 1 {name=p73566 lab=_56619_/A }
C {sky130_stdcells/xor2_4.sym} 74380 -33260 0 0 {name=X_56618_ }
C {devices/lab_pin.sym} 74320 -33140 0 0 {name=p73567 lab=_80795_/Q }
C {devices/lab_pin.sym} 74320 -33100 0 0 {name=p73568 lab=_75451_/Y }
C {devices/lab_pin.sym} 74440 -33120 0 1 {name=p73569 lab=_80763_/D }
C {sky130_stdcells/xor2_4.sym} 74380 -33120 0 0 {name=X_75452_ }
C {devices/lab_pin.sym} 74300 -33020 0 0 {name=p73570 lab=_40497_/X }
C {devices/lab_pin.sym} 74300 -32980 0 0 {name=p73571 lab=_41813_/X }
C {devices/lab_pin.sym} 74300 -32940 0 0 {name=p73572 lab=_88126_/Q }
C {devices/lab_pin.sym} 74300 -32900 0 0 {name=p73573 lab=_41814_/X }
C {devices/lab_pin.sym} 74460 -32960 0 1 {name=p73574 lab=_88126_/D }
C {sky130_stdcells/a2bb2o_4.sym} 74380 -32960 0 0 {name=X_41844_ }
C {devices/lab_pin.sym} 74290 -32810 0 0 {name=p73575 lab=_87484_/CLK }
C {devices/lab_pin.sym} 74290 -32790 0 0 {name=p73576 lab=_43403_/X }
C {devices/lab_pin.sym} 74470 -32810 0 1 {name=p73577 lab=_87438_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -32800 0 0 {name=X_87438_ }
C {devices/lab_pin.sym} 74320 -32690 0 0 {name=p73578 lab=_72668_/A }
C {devices/lab_pin.sym} 74320 -32650 0 0 {name=p73579 lab=_72668_/B }
C {devices/lab_pin.sym} 74320 -32610 0 0 {name=p73580 lab=_72664_/C }
C {devices/lab_pin.sym} 74440 -32650 0 1 {name=p73581 lab=_72664_/Y }
C {sky130_stdcells/nand3_4.sym} 74380 -32650 0 0 {name=X_72664_ }
C {devices/lab_pin.sym} 74300 -32530 0 0 {name=p73582 lab=_57596_/Y }
C {devices/lab_pin.sym} 74300 -32490 0 0 {name=p73583 lab=_57581_/X }
C {devices/lab_pin.sym} 74300 -32450 0 0 {name=p73584 lab=_57597_/Y }
C {devices/lab_pin.sym} 74460 -32490 0 1 {name=p73585 lab=_84972_/D }
C {sky130_stdcells/a21boi_4.sym} 74380 -32490 0 0 {name=X_57598_ }
C {devices/lab_pin.sym} 74320 -32360 0 0 {name=p73586 lab=_74408_/A }
C {devices/lab_pin.sym} 74320 -32320 0 0 {name=p73587 lab=_74403_/B }
C {devices/lab_pin.sym} 74440 -32340 0 1 {name=p73588 lab=_74403_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -32340 0 0 {name=X_74403_ }
C {devices/lab_pin.sym} 74340 -32210 0 0 {name=p73589 lab=_83739_/Q }
C {devices/lab_pin.sym} 74420 -32210 0 1 {name=p73590 lab=_47352_/A }
C {sky130_stdcells/inv_2.sym} 74380 -32210 0 0 {name=X_47351_ }
C {devices/lab_pin.sym} 74300 -32110 0 0 {name=p73591 lab=_71604_/X }
C {devices/lab_pin.sym} 74300 -32070 0 0 {name=p73592 lab=_83438_/Q }
C {devices/lab_pin.sym} 74300 -32030 0 0 {name=p73593 lab=_71614_/Y }
C {devices/lab_pin.sym} 74460 -32070 0 1 {name=p73594 lab=_83438_/D }
C {sky130_stdcells/a21o_4.sym} 74380 -32070 0 0 {name=X_71615_ }
C {devices/lab_pin.sym} 74300 -31950 0 0 {name=p73595 lab=_59333_/Y }
C {devices/lab_pin.sym} 74300 -31910 0 0 {name=p73596 lab=_59336_/Y }
C {devices/lab_pin.sym} 74300 -31870 0 0 {name=p73597 lab=_59278_/X }
C {devices/lab_pin.sym} 74460 -31910 0 1 {name=p73598 lab=_59337_/X }
C {sky130_stdcells/a21o_4.sym} 74380 -31910 0 0 {name=X_59337_ }
C {devices/lab_pin.sym} 74300 -31790 0 0 {name=p73599 lab=_78166_/Y }
C {devices/lab_pin.sym} 74300 -31750 0 0 {name=p73600 lab=_78167_/A }
C {devices/lab_pin.sym} 74300 -31710 0 0 {name=p73601 lab=_78170_/Y }
C {devices/lab_pin.sym} 74460 -31750 0 1 {name=p73602 lab=_78171_/Y }
C {sky130_stdcells/a21boi_4.sym} 74380 -31750 0 0 {name=X_78171_ }
C {devices/lab_pin.sym} 74300 -31650 0 0 {name=p73603 lab=_44547_/X }
C {devices/lab_pin.sym} 74300 -31610 0 0 {name=p73604 lab=_44548_/X }
C {devices/lab_pin.sym} 74300 -31570 0 0 {name=p73605 lab=_40861_/X }
C {devices/lab_pin.sym} 74300 -31530 0 0 {name=p73606 lab=_87053_/Q }
C {devices/lab_pin.sym} 74300 -31490 0 0 {name=p73607 lab=_44549_/X }
C {devices/lab_pin.sym} 74460 -31570 0 1 {name=p73608 lab=_44564_/A }
C {sky130_stdcells/o32ai_4.sym} 74380 -31570 0 0 {name=X_44563_ }
C {devices/lab_pin.sym} 74340 -31410 0 0 {name=p73609 lab=clkbuf_9_331_0_CLK/A }
C {devices/lab_pin.sym} 74420 -31410 0 1 {name=p73610 lab=clkbuf_9_331_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 74380 -31410 0 0 {name=Xclkbuf_9_331_0_CLK }
C {devices/lab_pin.sym} 74340 -31290 0 0 {name=p73611 lab=_56548_/X }
C {devices/lab_pin.sym} 74420 -31290 0 1 {name=p73612 lab=_56549_/X }
C {sky130_stdcells/buf_2.sym} 74380 -31290 0 0 {name=X_56549_ }
C {devices/lab_pin.sym} 74290 -31170 0 0 {name=p73613 lab=_87373_/CLK }
C {devices/lab_pin.sym} 74290 -31150 0 0 {name=p73614 lab=_87369_/D }
C {devices/lab_pin.sym} 74470 -31170 0 1 {name=p73615 lab=_87369_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -31160 0 0 {name=X_87369_ }
C {devices/lab_pin.sym} 74320 -31050 0 0 {name=p73616 lab=_75383_/A }
C {devices/lab_pin.sym} 74320 -31010 0 0 {name=p73617 lab=_75383_/B }
C {devices/lab_pin.sym} 74320 -30970 0 0 {name=p73618 lab=_75383_/C }
C {devices/lab_pin.sym} 74440 -31010 0 1 {name=p73619 lab=_75383_/X }
C {sky130_stdcells/or3_4.sym} 74380 -31010 0 0 {name=X_75383_ }
C {devices/lab_pin.sym} 74340 -30870 0 0 {name=p73620 lab=_41775_/A }
C {devices/lab_pin.sym} 74420 -30870 0 1 {name=p73621 lab=_88152_/D }
C {sky130_stdcells/inv_2.sym} 74380 -30870 0 0 {name=X_41775_ }
C {devices/lab_pin.sym} 74300 -30780 0 0 {name=p73622 lab=_72607_/B }
C {devices/lab_pin.sym} 74300 -30740 0 0 {name=p73623 lab=_72549_/B }
C {devices/lab_pin.sym} 74300 -30700 0 0 {name=p73624 lab=_59846_/X }
C {devices/lab_pin.sym} 74300 -30660 0 0 {name=p73625 lab=_72597_/C }
C {devices/lab_pin.sym} 74460 -30720 0 1 {name=p73626 lab=_72595_/X }
C {sky130_stdcells/a211o_4.sym} 74380 -30720 0 0 {name=X_72595_ }
C {devices/lab_pin.sym} 74340 -30570 0 0 {name=p73627 lab=_46302_/A }
C {devices/lab_pin.sym} 74420 -30570 0 1 {name=p73628 lab=_48924_/A }
C {sky130_stdcells/inv_2.sym} 74380 -30570 0 0 {name=X_46302_ }
C {devices/lab_pin.sym} 74320 -30460 0 0 {name=p73629 lab=_77122_/A }
C {devices/lab_pin.sym} 74320 -30420 0 0 {name=p73630 lab=_77121_/Y }
C {devices/lab_pin.sym} 74440 -30440 0 1 {name=p73631 lab=_77123_/B }
C {sky130_stdcells/xnor2_4.sym} 74380 -30440 0 0 {name=X_77122_ }
C {devices/lab_pin.sym} 74340 -30310 0 0 {name=p73632 lab=_43466_/X }
C {devices/lab_pin.sym} 74420 -30310 0 1 {name=p73633 lab=_43514_/X }
C {sky130_stdcells/buf_2.sym} 74380 -30310 0 0 {name=X_43514_ }
C {devices/lab_pin.sym} 74320 -30210 0 0 {name=p73634 lab=_74338_/A }
C {devices/lab_pin.sym} 74320 -30170 0 0 {name=p73635 lab=_74338_/B }
C {devices/lab_pin.sym} 74320 -30130 0 0 {name=p73636 lab=_56108_/A }
C {devices/lab_pin.sym} 74440 -30170 0 1 {name=p73637 lab=_74334_/Y }
C {sky130_stdcells/nand3_4.sym} 74380 -30170 0 0 {name=X_74334_ }
C {devices/lab_pin.sym} 74340 -30030 0 0 {name=p73638 lab=_40726_/A }
C {devices/lab_pin.sym} 74420 -30030 0 1 {name=p73639 lab=_40726_/Y }
C {sky130_stdcells/inv_2.sym} 74380 -30030 0 0 {name=X_40726_ }
C {devices/lab_pin.sym} 74340 -29910 0 0 {name=p73640 lab=_81819_/Q }
C {devices/lab_pin.sym} 74420 -29910 0 1 {name=p73641 lab=_47283_/A }
C {sky130_stdcells/inv_2.sym} 74380 -29910 0 0 {name=X_47282_ }
C {devices/lab_pin.sym} 74340 -29790 0 0 {name=p73642 lab=clkbuf_9_112_0_CLK/X }
C {devices/lab_pin.sym} 74420 -29790 0 1 {name=p73643 lab=_80708_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 74380 -29790 0 0 {name=Xclkbuf_10_225_0_CLK }
C {devices/lab_pin.sym} 74340 -29670 0 0 {name=p73644 lab=_59043_/A }
C {devices/lab_pin.sym} 74420 -29670 0 1 {name=p73645 lab=_59268_/X }
C {sky130_stdcells/buf_2.sym} 74380 -29670 0 0 {name=X_59268_ }
C {devices/lab_pin.sym} 74320 -29570 0 0 {name=p73646 lab=_70682_/A }
C {devices/lab_pin.sym} 74320 -29530 0 0 {name=p73647 lab=_71546_/B }
C {devices/lab_pin.sym} 74320 -29490 0 0 {name=p73648 lab=_71546_/C }
C {devices/lab_pin.sym} 74440 -29530 0 1 {name=p73649 lab=_71546_/Y }
C {sky130_stdcells/nor3_4.sym} 74380 -29530 0 0 {name=X_71546_ }
C {devices/lab_pin.sym} 74300 -29430 0 0 {name=p73650 lab=_44481_/X }
C {devices/lab_pin.sym} 74300 -29390 0 0 {name=p73651 lab=_44482_/X }
C {devices/lab_pin.sym} 74300 -29350 0 0 {name=p73652 lab=_41233_/X }
C {devices/lab_pin.sym} 74300 -29310 0 0 {name=p73653 lab=_87080_/Q }
C {devices/lab_pin.sym} 74300 -29270 0 0 {name=p73654 lab=_44484_/X }
C {devices/lab_pin.sym} 74460 -29350 0 1 {name=p73655 lab=_44495_/A }
C {sky130_stdcells/o32ai_4.sym} 74380 -29350 0 0 {name=X_44494_ }
C {devices/lab_pin.sym} 74340 -29190 0 0 {name=p73656 lab=_49021_/A }
C {devices/lab_pin.sym} 74420 -29190 0 1 {name=p73657 lab=_72025_/B }
C {sky130_stdcells/buf_2.sym} 74380 -29190 0 0 {name=X_49021_ }
C {devices/lab_pin.sym} 74340 -29070 0 0 {name=p73658 lab=clkbuf_9_427_0_CLK/X }
C {devices/lab_pin.sym} 74420 -29070 0 1 {name=p73659 lab=_82965_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 74380 -29070 0 0 {name=Xclkbuf_10_855_0_CLK }
C {devices/lab_pin.sym} 74320 -28960 0 0 {name=p73660 lab=_44120_/Y }
C {devices/lab_pin.sym} 74320 -28920 0 0 {name=p73661 lab=HASH_EN }
C {devices/lab_pin.sym} 74440 -28940 0 1 {name=p73662 lab=_46233_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -28940 0 0 {name=X_46233_ }
C {devices/lab_pin.sym} 74340 -28810 0 0 {name=p73663 lab=_58341_/A }
C {devices/lab_pin.sym} 74420 -28810 0 1 {name=p73664 lab=_58219_/X }
C {sky130_stdcells/buf_2.sym} 74380 -28810 0 0 {name=X_58219_ }
C {sky130_stdcells/decap_3.sym} 74380 -28660 0 0 {name=XPHY_450 }
C {devices/lab_pin.sym} 74320 -28520 0 0 {name=p73665 lab=_77038_/X }
C {devices/lab_pin.sym} 74320 -28480 0 0 {name=p73666 lab=_77045_/X }
C {devices/lab_pin.sym} 74440 -28500 0 1 {name=p73667 lab=_77053_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -28500 0 0 {name=X_77053_ }
C {devices/lab_pin.sym} 74340 -28370 0 0 {name=p73668 lab=_43178_/X }
C {devices/lab_pin.sym} 74420 -28370 0 1 {name=p73669 lab=_43513_/A }
C {sky130_stdcells/buf_2.sym} 74380 -28370 0 0 {name=X_43445_ }
C {devices/lab_pin.sym} 74300 -28280 0 0 {name=p73670 lab=_69110_/Y }
C {devices/lab_pin.sym} 74300 -28240 0 0 {name=p73671 lab=_73891_/X }
C {devices/lab_pin.sym} 74300 -28200 0 0 {name=p73672 lab=_45897_/X }
C {devices/lab_pin.sym} 74300 -28160 0 0 {name=p73673 lab=_74264_/Y }
C {devices/lab_pin.sym} 74460 -28220 0 1 {name=p73674 lab=_74265_/X }
C {sky130_stdcells/a211o_4.sym} 74380 -28220 0 0 {name=X_74265_ }
C {sky130_stdcells/decap_3.sym} 74380 -28040 0 0 {name=XPHY_461 }
C {devices/lab_pin.sym} 74300 -27930 0 0 {name=p73675 lab=_40635_/X }
C {devices/lab_pin.sym} 74300 -27890 0 0 {name=p73676 lab=_40638_/X }
C {devices/lab_pin.sym} 74300 -27850 0 0 {name=p73677 lab=_40656_/X }
C {devices/lab_pin.sym} 74300 -27810 0 0 {name=p73678 lab=_88359_/Q }
C {devices/lab_pin.sym} 74300 -27770 0 0 {name=p73679 lab=_40612_/X }
C {devices/lab_pin.sym} 74460 -27850 0 1 {name=p73680 lab=_40657_/Y }
C {sky130_stdcells/o32ai_4.sym} 74380 -27850 0 0 {name=X_40657_ }
C {devices/lab_pin.sym} 74300 -27710 0 0 {name=p73681 lab=_71464_/X }
C {devices/lab_pin.sym} 74300 -27670 0 0 {name=p73682 lab=_83485_/Q }
C {devices/lab_pin.sym} 74300 -27630 0 0 {name=p73683 lab=_71476_/X }
C {devices/lab_pin.sym} 74460 -27670 0 1 {name=p73684 lab=_83485_/D }
C {sky130_stdcells/a21o_4.sym} 74380 -27670 0 0 {name=X_71477_ }
C {devices/lab_pin.sym} 74340 -27530 0 0 {name=p73685 lab=_58904_/A }
C {devices/lab_pin.sym} 74420 -27530 0 1 {name=p73686 lab=_59199_/X }
C {sky130_stdcells/buf_2.sym} 74380 -27530 0 0 {name=X_59199_ }
C {sky130_stdcells/decap_3.sym} 74380 -27380 0 0 {name=XPHY_472 }
C {sky130_stdcells/decap_3.sym} 74380 -27200 0 0 {name=XPHY_483 }
C {devices/lab_pin.sym} 74320 -27060 0 0 {name=p73687 lab=_81710_/D }
C {devices/lab_pin.sym} 74320 -27020 0 0 {name=p73688 lab=_76013_/B }
C {devices/lab_pin.sym} 74440 -27040 0 1 {name=p73689 lab=_76010_/A }
C {sky130_stdcells/xor2_4.sym} 74380 -27040 0 0 {name=X_76004_ }
C {devices/lab_pin.sym} 74300 -26940 0 0 {name=p73690 lab=_73214_/X }
C {devices/lab_pin.sym} 74300 -26900 0 0 {name=p73691 lab=_83064_/Q }
C {devices/lab_pin.sym} 74300 -26860 0 0 {name=p73692 lab=_73015_/X }
C {devices/lab_pin.sym} 74300 -26820 0 0 {name=p73693 lab=_73215_/X }
C {devices/lab_pin.sym} 74460 -26880 0 1 {name=p73694 lab=_73216_/X }
C {sky130_stdcells/a211o_4.sym} 74380 -26880 0 0 {name=X_73216_ }
C {sky130_stdcells/decap_3.sym} 74380 -26700 0 0 {name=XPHY_494 }
C {devices/lab_pin.sym} 74320 -26570 0 0 {name=p73695 lab=_61109_/X }
C {devices/lab_pin.sym} 74320 -26530 0 0 {name=p73696 lab=_61271_/A }
C {devices/lab_pin.sym} 74320 -26490 0 0 {name=p73697 lab=_61230_/C }
C {devices/lab_pin.sym} 74440 -26530 0 1 {name=p73698 lab=_61264_/B }
C {sky130_stdcells/nand3_4.sym} 74380 -26530 0 0 {name=X_61230_ }
C {devices/lab_pin.sym} 74340 -26390 0 0 {name=p73699 lab=clkbuf_9_347_0_CLK/A }
C {devices/lab_pin.sym} 74420 -26390 0 1 {name=p73700 lab=clkbuf_9_346_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 74380 -26390 0 0 {name=Xclkbuf_9_346_0_CLK }
C {devices/lab_pin.sym} 74320 -26280 0 0 {name=p73701 lab=_46164_/A }
C {devices/lab_pin.sym} 74320 -26240 0 0 {name=p73702 lab=_46188_/A }
C {devices/lab_pin.sym} 74440 -26260 0 1 {name=p73703 lab=_46169_/C }
C {sky130_stdcells/nor2_4.sym} 74380 -26260 0 0 {name=X_46164_ }
C {devices/lab_pin.sym} 74340 -26130 0 0 {name=p73704 lab=_70428_/A }
C {devices/lab_pin.sym} 74420 -26130 0 1 {name=p73705 lab=_71145_/A }
C {sky130_stdcells/inv_2.sym} 74380 -26130 0 0 {name=X_70428_ }
C {devices/lab_pin.sym} 74300 -26050 0 0 {name=p73706 lab=_43367_/X }
C {devices/lab_pin.sym} 74300 -26010 0 0 {name=p73707 lab=_43375_/X }
C {devices/lab_pin.sym} 74300 -25970 0 0 {name=p73708 lab=_41403_/X }
C {devices/lab_pin.sym} 74300 -25930 0 0 {name=p73709 lab=_87453_/Q }
C {devices/lab_pin.sym} 74300 -25890 0 0 {name=p73710 lab=_43353_/X }
C {devices/lab_pin.sym} 74460 -25970 0 1 {name=p73711 lab=_43376_/Y }
C {sky130_stdcells/o32ai_4.sym} 74380 -25970 0 0 {name=X_43376_ }
C {devices/lab_pin.sym} 74300 -25830 0 0 {name=p73712 lab=_74193_/X }
C {devices/lab_pin.sym} 74300 -25790 0 0 {name=p73713 lab=_74195_/X }
C {devices/lab_pin.sym} 74300 -25750 0 0 {name=p73714 lab=_56547_/X }
C {devices/lab_pin.sym} 74460 -25790 0 1 {name=p73715 lab=_74199_/A }
C {sky130_stdcells/a21o_4.sym} 74380 -25790 0 0 {name=X_74196_ }
C {devices/lab_pin.sym} 74320 -25660 0 0 {name=p73716 lab=_40588_/A }
C {devices/lab_pin.sym} 74320 -25620 0 0 {name=p73717 lab=_40588_/B }
C {devices/lab_pin.sym} 74440 -25640 0 1 {name=p73718 lab=_40588_/X }
C {sky130_stdcells/or2_4.sym} 74380 -25640 0 0 {name=X_40588_ }
C {devices/lab_pin.sym} 74340 -25510 0 0 {name=p73719 lab=_45389_/A }
C {devices/lab_pin.sym} 74420 -25510 0 1 {name=p73720 lab=_45265_/A }
C {sky130_stdcells/buf_2.sym} 74380 -25510 0 0 {name=X_45115_ }
C {devices/lab_pin.sym} 74300 -25420 0 0 {name=p73721 lab=_41647_/X }
C {devices/lab_pin.sym} 74300 -25380 0 0 {name=p73722 lab=_42325_/X }
C {devices/lab_pin.sym} 74300 -25340 0 0 {name=p73723 lab=_87920_/Q }
C {devices/lab_pin.sym} 74300 -25300 0 0 {name=p73724 lab=_42326_/X }
C {devices/lab_pin.sym} 74460 -25360 0 1 {name=p73725 lab=_87920_/D }
C {sky130_stdcells/a2bb2o_4.sym} 74380 -25360 0 0 {name=X_42327_ }
C {devices/lab_pin.sym} 74320 -25230 0 0 {name=p73726 lab=_61179_/A }
C {devices/lab_pin.sym} 74320 -25190 0 0 {name=p73727 lab=_61153_/C }
C {devices/lab_pin.sym} 74320 -25150 0 0 {name=p73728 lab=_64456_/C }
C {devices/lab_pin.sym} 74440 -25190 0 1 {name=p73729 lab=_61254_/C }
C {sky130_stdcells/nand3_4.sym} 74380 -25190 0 0 {name=X_61161_ }
C {devices/lab_pin.sym} 74320 -25060 0 0 {name=p73730 lab=_42583_/A }
C {devices/lab_pin.sym} 74320 -25020 0 0 {name=p73731 lab=_72892_/B }
C {devices/lab_pin.sym} 74440 -25040 0 1 {name=p73732 lab=_73147_/Y }
C {sky130_stdcells/nor2_4.sym} 74380 -25040 0 0 {name=X_73147_ }
C {devices/lab_pin.sym} 74320 -24930 0 0 {name=p73733 lab=_46092_/X }
C {devices/lab_pin.sym} 74320 -24890 0 0 {name=p73734 lab=_46121_/A }
C {devices/lab_pin.sym} 74320 -24850 0 0 {name=p73735 lab=_46094_/X }
C {devices/lab_pin.sym} 74440 -24890 0 1 {name=p73736 lab=_46096_/D }
C {sky130_stdcells/nor3_4.sym} 74380 -24890 0 0 {name=X_46095_ }
C {devices/lab_pin.sym} 74340 -24750 0 0 {name=p73737 lab=HASH_ADDR[1] }
C {devices/lab_pin.sym} 74420 -24750 0 1 {name=p73738 lab=_70907_/B }
C {sky130_stdcells/buf_2.sym} 74380 -24750 0 0 {name=X_70359_ }
C {devices/lab_pin.sym} 74340 -24630 0 0 {name=p73739 lab=_60111_/X }
C {devices/lab_pin.sym} 74420 -24630 0 1 {name=p73740 lab=_64638_/B }
C {sky130_stdcells/buf_2.sym} 74380 -24630 0 0 {name=X_60112_ }
C {devices/lab_pin.sym} 74300 -24530 0 0 {name=p73741 lab=_86298_/Q }
C {devices/lab_pin.sym} 74300 -24490 0 0 {name=p73742 lab=_49906_/X }
C {devices/lab_pin.sym} 74300 -24450 0 0 {name=p73743 lab=_49922_/Y }
C {devices/lab_pin.sym} 74460 -24490 0 1 {name=p73744 lab=_49923_/Y }
C {sky130_stdcells/o21ai_4.sym} 74380 -24490 0 0 {name=X_49923_ }
C {devices/lab_pin.sym} 74340 -24350 0 0 {name=p73745 lab=_45046_/A }
C {devices/lab_pin.sym} 74420 -24350 0 1 {name=p73746 lab=_45046_/Y }
C {sky130_stdcells/inv_2.sym} 74380 -24350 0 0 {name=X_45046_ }
C {devices/lab_pin.sym} 74340 -24230 0 0 {name=p73747 lab=_42258_/A }
C {devices/lab_pin.sym} 74420 -24230 0 1 {name=p73748 lab=_42258_/X }
C {sky130_stdcells/buf_2.sym} 74380 -24230 0 0 {name=X_42258_ }
C {devices/lab_pin.sym} 74340 -24110 0 0 {name=p73749 lab=_73078_/A }
C {devices/lab_pin.sym} 74420 -24110 0 1 {name=p73750 lab=_73193_/A }
C {sky130_stdcells/buf_2.sym} 74380 -24110 0 0 {name=X_73078_ }
C {devices/lab_pin.sym} 74320 -24000 0 0 {name=p73751 lab=_77950_/B }
C {devices/lab_pin.sym} 74320 -23960 0 0 {name=p73752 lab=_77950_/A }
C {devices/lab_pin.sym} 74440 -23980 0 1 {name=p73753 lab=_77955_/X }
C {sky130_stdcells/and2_4.sym} 74380 -23980 0 0 {name=X_77955_ }
C {devices/lab_pin.sym} 74340 -23850 0 0 {name=p73754 lab=_64361_/A }
C {devices/lab_pin.sym} 74420 -23850 0 1 {name=p73755 lab=_64243_/A }
C {sky130_stdcells/buf_2.sym} 74380 -23850 0 0 {name=X_61092_ }
C {devices/lab_pin.sym} 74340 -23730 0 0 {name=p73756 lab=_41209_/A }
C {devices/lab_pin.sym} 74420 -23730 0 1 {name=p73757 lab=_41209_/X }
C {sky130_stdcells/buf_2.sym} 74380 -23730 0 0 {name=X_41209_ }
C {devices/lab_pin.sym} 74320 -23620 0 0 {name=p73758 lab=_64948_/A }
C {devices/lab_pin.sym} 74320 -23580 0 0 {name=p73759 lab=_64920_/B }
C {devices/lab_pin.sym} 74440 -23600 0 1 {name=p73760 lab=_64920_/X }
C {sky130_stdcells/and2_4.sym} 74380 -23600 0 0 {name=X_64920_ }
C {devices/lab_pin.sym} 74320 -23490 0 0 {name=p73761 lab=_59922_/C }
C {devices/lab_pin.sym} 74320 -23450 0 0 {name=p73762 lab=_60091_/A }
C {devices/lab_pin.sym} 74320 -23410 0 0 {name=p73763 lab=_59985_/X }
C {devices/lab_pin.sym} 74440 -23450 0 1 {name=p73764 lab=_60044_/A }
C {sky130_stdcells/and3_4.sym} 74380 -23450 0 0 {name=X_60043_ }
C {devices/lab_pin.sym} 74320 -23320 0 0 {name=p73765 lab=_72025_/A }
C {devices/lab_pin.sym} 74320 -23280 0 0 {name=p73766 lab=_53854_/B }
C {devices/lab_pin.sym} 74440 -23300 0 1 {name=p73767 lab=_72029_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -23300 0 0 {name=X_72029_ }
C {devices/lab_pin.sym} 74340 -23170 0 0 {name=p73768 lab=_76906_/A }
C {devices/lab_pin.sym} 74420 -23170 0 1 {name=p73769 lab=_76906_/Y }
C {sky130_stdcells/inv_2.sym} 74380 -23170 0 0 {name=X_76906_ }
C {devices/lab_pin.sym} 74340 -23050 0 0 {name=p73770 lab=_49854_/A }
C {devices/lab_pin.sym} 74420 -23050 0 1 {name=p73771 lab=_49864_/A }
C {sky130_stdcells/buf_2.sym} 74380 -23050 0 0 {name=X_49854_ }
C {devices/lab_pin.sym} 74340 -22930 0 0 {name=p73772 lab=_42189_/A }
C {devices/lab_pin.sym} 74420 -22930 0 1 {name=p73773 lab=_87989_/D }
C {sky130_stdcells/inv_2.sym} 74380 -22930 0 0 {name=X_42189_ }
C {devices/lab_pin.sym} 74300 -22830 0 0 {name=p73774 lab=_77880_/B }
C {devices/lab_pin.sym} 74300 -22790 0 0 {name=p73775 lab=_77880_/A }
C {devices/lab_pin.sym} 74300 -22750 0 0 {name=p73776 lab=_77885_/Y }
C {devices/lab_pin.sym} 74460 -22790 0 1 {name=p73777 lab=_77886_/Y }
C {sky130_stdcells/a21oi_4.sym} 74380 -22790 0 0 {name=X_77886_ }
C {devices/lab_pin.sym} 74320 -22670 0 0 {name=p73778 lab=_52194_/A }
C {devices/lab_pin.sym} 74320 -22630 0 0 {name=p73779 lab=_48829_/B }
C {devices/lab_pin.sym} 74320 -22590 0 0 {name=p73780 lab=_48814_/C }
C {devices/lab_pin.sym} 74440 -22630 0 1 {name=p73781 lab=_48805_/X }
C {sky130_stdcells/and3_4.sym} 74380 -22630 0 0 {name=X_48805_ }
C {devices/lab_pin.sym} 74320 -22500 0 0 {name=p73782 lab=_65268_/C }
C {devices/lab_pin.sym} 74320 -22460 0 0 {name=p73783 lab=_83256_/Q }
C {devices/lab_pin.sym} 74440 -22480 0 1 {name=p73784 lab=_79625_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -22480 0 0 {name=X_79625_ }
C {devices/lab_pin.sym} 74340 -22350 0 0 {name=p73785 lab=_64851_/A }
C {devices/lab_pin.sym} 74420 -22350 0 1 {name=p73786 lab=_64851_/X }
C {sky130_stdcells/buf_2.sym} 74380 -22350 0 0 {name=X_64851_ }
C {devices/lab_pin.sym} 74320 -22240 0 0 {name=p73787 lab=_76837_/A }
C {devices/lab_pin.sym} 74320 -22200 0 0 {name=p73788 lab=_76837_/B }
C {devices/lab_pin.sym} 74440 -22220 0 1 {name=p73789 lab=_76838_/B }
C {sky130_stdcells/xor2_4.sym} 74380 -22220 0 0 {name=X_76837_ }
C {devices/lab_pin.sym} 74320 -22100 0 0 {name=p73790 lab=_49769_/X }
C {devices/lab_pin.sym} 74320 -22060 0 0 {name=p73791 lab=_52999_/B }
C {devices/lab_pin.sym} 74440 -22080 0 1 {name=p73792 lab=_49785_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -22080 0 0 {name=X_49785_ }
C {devices/lab_pin.sym} 74340 -21950 0 0 {name=p73793 lab=_46903_/A }
C {devices/lab_pin.sym} 74420 -21950 0 1 {name=p73794 lab=_47029_/C }
C {sky130_stdcells/buf_2.sym} 74380 -21950 0 0 {name=X_46997_ }
C {devices/lab_pin.sym} 74340 -21830 0 0 {name=p73795 lab=_60920_/A }
C {devices/lab_pin.sym} 74420 -21830 0 1 {name=p73796 lab=_63803_/C }
C {sky130_stdcells/buf_2.sym} 74380 -21830 0 0 {name=X_63802_ }
C {devices/lab_pin.sym} 74300 -21730 0 0 {name=p73797 lab=_48733_/Y }
C {devices/lab_pin.sym} 74300 -21690 0 0 {name=p73798 lab=_48734_/X }
C {devices/lab_pin.sym} 74300 -21650 0 0 {name=p73799 lab=_48735_/X }
C {devices/lab_pin.sym} 74460 -21690 0 1 {name=p73800 lab=_86493_/D }
C {sky130_stdcells/a21oi_4.sym} 74380 -21690 0 0 {name=X_48736_ }
C {devices/lab_pin.sym} 74320 -21560 0 0 {name=p73801 lab=_67569_/X }
C {devices/lab_pin.sym} 74320 -21520 0 0 {name=p73802 lab=_87657_/Q }
C {devices/lab_pin.sym} 74440 -21540 0 1 {name=p73803 lab=_67570_/X }
C {sky130_stdcells/and2_4.sym} 74380 -21540 0 0 {name=X_67570_ }
C {devices/lab_pin.sym} 74320 -21420 0 0 {name=p73804 lab=_79555_/B }
C {devices/lab_pin.sym} 74320 -21380 0 0 {name=p73805 lab=_79555_/C }
C {devices/lab_pin.sym} 74440 -21400 0 1 {name=p73806 lab=_79557_/A }
C {sky130_stdcells/nand2_4.sym} 74380 -21400 0 0 {name=X_79556_ }
C {devices/lab_pin.sym} 74300 -21290 0 0 {name=p73807 lab=_45918_/Y }
C {devices/lab_pin.sym} 74300 -21250 0 0 {name=p73808 lab=_45947_/Y }
C {devices/lab_pin.sym} 74300 -21210 0 0 {name=p73809 lab=_86840_/Q }
C {devices/lab_pin.sym} 74460 -21250 0 1 {name=p73810 lab=_45948_/Y }
C {sky130_stdcells/a21boi_4.sym} 74380 -21250 0 0 {name=X_45948_ }
C {devices/lab_pin.sym} 74300 -21130 0 0 {name=p73811 lab=_64779_/X }
C {devices/lab_pin.sym} 74300 -21090 0 0 {name=p73812 lab=_64781_/X }
C {devices/lab_pin.sym} 74300 -21050 0 0 {name=p73813 lab=_64629_/X }
C {devices/lab_pin.sym} 74460 -21090 0 1 {name=p73814 lab=_64782_/X }
C {sky130_stdcells/a21o_4.sym} 74380 -21090 0 0 {name=X_64782_ }
C {devices/lab_pin.sym} 74320 -20960 0 0 {name=p73815 lab=_76768_/A }
C {devices/lab_pin.sym} 74320 -20920 0 0 {name=p73816 lab=_76755_/Y }
C {devices/lab_pin.sym} 74440 -20940 0 1 {name=p73817 lab=_76768_/Y }
C {sky130_stdcells/nor2_4.sym} 74380 -20940 0 0 {name=X_76768_ }
C {devices/lab_pin.sym} 74320 -20840 0 0 {name=p73818 lab=_61541_/B }
C {devices/lab_pin.sym} 74320 -20800 0 0 {name=p73819 lab=_61933_/X }
C {devices/lab_pin.sym} 74320 -20760 0 0 {name=p73820 lab=_61967_/C }
C {devices/lab_pin.sym} 74320 -20720 0 0 {name=p73821 lab=_61952_/D }
C {devices/lab_pin.sym} 74440 -20780 0 1 {name=p73822 lab=_62000_/B }
C {sky130_stdcells/nand4_4.sym} 74380 -20780 0 0 {name=X_61994_ }
C {devices/lab_pin.sym} 74320 -20650 0 0 {name=p73823 lab=_65415_/X }
C {devices/lab_pin.sym} 74320 -20610 0 0 {name=p73824 lab=_66521_/B }
C {devices/lab_pin.sym} 74320 -20570 0 0 {name=p73825 lab=_65418_/X }
C {devices/lab_pin.sym} 74440 -20610 0 1 {name=p73826 lab=_66521_/Y }
C {sky130_stdcells/nand3_4.sym} 74380 -20610 0 0 {name=X_66521_ }
C {devices/lab_pin.sym} 74300 -20490 0 0 {name=p73827 lab=_78487_/Y }
C {devices/lab_pin.sym} 74300 -20450 0 0 {name=p73828 lab=_78488_/Y }
C {devices/lab_pin.sym} 74300 -20410 0 0 {name=p73829 lab=_78489_/Y }
C {devices/lab_pin.sym} 74460 -20450 0 1 {name=p73830 lab=_78508_/A }
C {sky130_stdcells/o21a_4.sym} 74380 -20450 0 0 {name=X_78507_ }
C {devices/lab_pin.sym} 74340 -20310 0 0 {name=p73831 lab=_61278_/A }
C {devices/lab_pin.sym} 74420 -20310 0 1 {name=p73832 lab=_63733_/X }
C {sky130_stdcells/buf_2.sym} 74380 -20310 0 0 {name=X_63733_ }
C {devices/lab_pin.sym} 74340 -20190 0 0 {name=p73833 lab=_75695_/Y }
C {devices/lab_pin.sym} 74420 -20190 0 1 {name=p73834 lab=_75719_/Y }
C {sky130_stdcells/inv_2.sym} 74380 -20190 0 0 {name=X_75719_ }
C {devices/lab_pin.sym} 74320 -20090 0 0 {name=p73835 lab=_48667_/A }
C {devices/lab_pin.sym} 74320 -20050 0 0 {name=p73836 lab=_48657_/B }
C {devices/lab_pin.sym} 74320 -20010 0 0 {name=p73837 lab=_48657_/C }
C {devices/lab_pin.sym} 74440 -20050 0 1 {name=p73838 lab=_48667_/X }
C {sky130_stdcells/and3_4.sym} 74380 -20050 0 0 {name=X_48667_ }
C {devices/lab_pin.sym} 74340 -19910 0 0 {name=p73839 lab=_65515_/A }
C {devices/lab_pin.sym} 74420 -19910 0 1 {name=p73840 lab=_72543_/A }
C {sky130_stdcells/buf_2.sym} 74380 -19910 0 0 {name=X_60945_ }
C {devices/lab_pin.sym} 74340 -19790 0 0 {name=p73841 lab=_79487_/A }
C {devices/lab_pin.sym} 74420 -19790 0 1 {name=p73842 lab=_79487_/Y }
C {sky130_stdcells/inv_2.sym} 74380 -19790 0 0 {name=X_79487_ }
C {devices/lab_pin.sym} 74300 -19690 0 0 {name=p73843 lab=_45819_/X }
C {devices/lab_pin.sym} 74300 -19650 0 0 {name=p73844 lab=_61695_/A }
C {devices/lab_pin.sym} 74300 -19610 0 0 {name=p73845 lab=_45836_/X }
C {devices/lab_pin.sym} 74460 -19650 0 1 {name=p73846 lab=_45879_/Y }
C {sky130_stdcells/o21ai_4.sym} 74380 -19650 0 0 {name=X_45879_ }
C {devices/lab_pin.sym} 74320 -19520 0 0 {name=p73847 lab=_76691_/A }
C {devices/lab_pin.sym} 74320 -19480 0 0 {name=p73848 lab=_81351_/D }
C {devices/lab_pin.sym} 74440 -19500 0 1 {name=p73849 lab=_76699_/X }
C {sky130_stdcells/or2_4.sym} 74380 -19500 0 0 {name=X_76699_ }
C {devices/lab_pin.sym} 74340 -19370 0 0 {name=p73850 lab=clkbuf_9_404_0_CLK/X }
C {devices/lab_pin.sym} 74420 -19370 0 1 {name=p73851 lab=_82343_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 74380 -19370 0 0 {name=Xclkbuf_10_808_0_CLK }
C {devices/lab_pin.sym} 74320 -19260 0 0 {name=p73852 lab=_69128_/X }
C {devices/lab_pin.sym} 74320 -19220 0 0 {name=p73853 lab=_88300_/Q }
C {devices/lab_pin.sym} 74440 -19240 0 1 {name=p73854 lab=_69240_/X }
C {sky130_stdcells/and2_4.sym} 74380 -19240 0 0 {name=X_69240_ }
C {devices/lab_pin.sym} 74300 -19130 0 0 {name=p73855 lab=_47612_/Y }
C {devices/lab_pin.sym} 74300 -19090 0 0 {name=p73856 lab=_47602_/X }
C {devices/lab_pin.sym} 74300 -19050 0 0 {name=p73857 lab=_47617_/X }
C {devices/lab_pin.sym} 74460 -19090 0 1 {name=p73858 lab=_86616_/D }
C {sky130_stdcells/a21oi_4.sym} 74380 -19090 0 0 {name=X_47618_ }
C {devices/lab_pin.sym} 74300 -18970 0 0 {name=p73859 lab=_66448_/Y }
C {devices/lab_pin.sym} 74300 -18930 0 0 {name=p73860 lab=_66449_/X }
C {devices/lab_pin.sym} 74300 -18890 0 0 {name=p73861 lab=_66451_/Y }
C {devices/lab_pin.sym} 74460 -18930 0 1 {name=p73862 lab=_84121_/D }
C {sky130_stdcells/a21o_4.sym} 74380 -18930 0 0 {name=X_66452_ }
C {devices/lab_pin.sym} 74340 -18790 0 0 {name=p73863 lab=_78436_/Y }
C {devices/lab_pin.sym} 74420 -18790 0 1 {name=p73864 lab=_78438_/Y }
C {sky130_stdcells/inv_2.sym} 74380 -18790 0 0 {name=X_78438_ }
C {devices/lab_pin.sym} 74300 -18690 0 0 {name=p73865 lab=_63662_/Y }
C {devices/lab_pin.sym} 74300 -18650 0 0 {name=p73866 lab=_63635_/X }
C {devices/lab_pin.sym} 74300 -18610 0 0 {name=p73867 lab=_63663_/Y }
C {devices/lab_pin.sym} 74460 -18650 0 1 {name=p73868 lab=_63664_/Y }
C {sky130_stdcells/a21oi_4.sym} 74380 -18650 0 0 {name=X_63664_ }
C {devices/lab_pin.sym} 74300 -18530 0 0 {name=p73869 lab=_46423_/X }
C {devices/lab_pin.sym} 74300 -18490 0 0 {name=p73870 lab=_48056_/A }
C {devices/lab_pin.sym} 74300 -18450 0 0 {name=p73871 lab=_48597_/X }
C {devices/lab_pin.sym} 74460 -18490 0 1 {name=p73872 lab=_48823_/B }
C {sky130_stdcells/o21ai_4.sym} 74380 -18490 0 0 {name=X_48598_ }
C {devices/lab_pin.sym} 74340 -18350 0 0 {name=p73873 lab=_60909_/A }
C {devices/lab_pin.sym} 74420 -18350 0 1 {name=p73874 lab=_60934_/A }
C {sky130_stdcells/inv_2.sym} 74380 -18350 0 0 {name=X_60876_ }
C {devices/lab_pin.sym} 74320 -18240 0 0 {name=p73875 lab=_65403_/A }
C {devices/lab_pin.sym} 74320 -18200 0 0 {name=p73876 lab=_86242_/Q }
C {devices/lab_pin.sym} 74440 -18220 0 1 {name=p73877 lab=_65403_/X }
C {sky130_stdcells/and2_4.sym} 74380 -18220 0 0 {name=X_65403_ }
C {devices/lab_pin.sym} 74300 -18130 0 0 {name=p73878 lab=_62608_/X }
C {devices/lab_pin.sym} 74300 -18090 0 0 {name=p73879 lab=_62610_/X }
C {devices/lab_pin.sym} 74300 -18050 0 0 {name=p73880 lab=_62614_/Y }
C {devices/lab_pin.sym} 74300 -18010 0 0 {name=p73881 lab=_84868_/Q }
C {devices/lab_pin.sym} 74300 -17970 0 0 {name=p73882 lab=_62572_/X }
C {devices/lab_pin.sym} 74460 -18050 0 1 {name=p73883 lab=_62615_/Y }
C {sky130_stdcells/o32ai_4.sym} 74380 -18050 0 0 {name=X_62615_ }
C {devices/lab_pin.sym} 74340 -17890 0 0 {name=p73884 lab=_69156_/A }
C {devices/lab_pin.sym} 74420 -17890 0 1 {name=p73885 lab=_69171_/X }
C {sky130_stdcells/buf_2.sym} 74380 -17890 0 0 {name=X_69171_ }
C {devices/lab_pin.sym} 74320 -17800 0 0 {name=p73886 lab=_47530_/X }
C {devices/lab_pin.sym} 74320 -17760 0 0 {name=p73887 lab=_47549_/B }
C {devices/lab_pin.sym} 74320 -17720 0 0 {name=p73888 lab=_47519_/X }
C {devices/lab_pin.sym} 74320 -17680 0 0 {name=p73889 lab=_53113_/D }
C {devices/lab_pin.sym} 74440 -17740 0 1 {name=p73890 lab=_47549_/X }
C {sky130_stdcells/and4_4.sym} 74380 -17740 0 0 {name=X_47549_ }
C {devices/lab_pin.sym} 74300 -17610 0 0 {name=p73891 lab=_66381_/Y }
C {devices/lab_pin.sym} 74300 -17570 0 0 {name=p73892 lab=_66382_/Y }
C {devices/lab_pin.sym} 74300 -17530 0 0 {name=p73893 lab=_65842_/X }
C {devices/lab_pin.sym} 74460 -17570 0 1 {name=p73894 lab=_66383_/Y }
C {sky130_stdcells/a21oi_4.sym} 74380 -17570 0 0 {name=X_66383_ }
C {devices/lab_pin.sym} 74320 -17440 0 0 {name=p73895 lab=_78369_/A }
C {devices/lab_pin.sym} 74320 -17400 0 0 {name=p73896 lab=_78369_/B }
C {devices/lab_pin.sym} 74440 -17420 0 1 {name=p73897 lab=_82758_/D }
C {sky130_stdcells/xnor2_4.sym} 74380 -17420 0 0 {name=X_78369_ }
C {devices/lab_pin.sym} 74320 -17320 0 0 {name=p73898 lab=_63546_/A }
C {devices/lab_pin.sym} 74320 -17280 0 0 {name=p73899 lab=_58483_/A }
C {devices/lab_pin.sym} 74320 -17240 0 0 {name=p73900 lab=_63581_/X }
C {devices/lab_pin.sym} 74320 -17200 0 0 {name=p73901 lab=_63595_/D }
C {devices/lab_pin.sym} 74440 -17260 0 1 {name=p73902 lab=_63595_/X }
C {sky130_stdcells/and4_4.sym} 74380 -17260 0 0 {name=X_63595_ }
C {devices/lab_pin.sym} 74320 -17120 0 0 {name=p73903 lab=_80400_/A }
C {devices/lab_pin.sym} 74320 -17080 0 0 {name=p73904 lab=_80400_/B }
C {devices/lab_pin.sym} 74440 -17100 0 1 {name=p73905 lab=_80400_/X }
C {sky130_stdcells/xor2_4.sym} 74380 -17100 0 0 {name=X_80400_ }
C {devices/lab_pin.sym} 74300 -16990 0 0 {name=p73906 lab=_66776_/X }
C {devices/lab_pin.sym} 74300 -16950 0 0 {name=p73907 lab=_66778_/X }
C {devices/lab_pin.sym} 74300 -16910 0 0 {name=p73908 lab=_68106_/X }
C {devices/lab_pin.sym} 74460 -16950 0 1 {name=p73909 lab=_68122_/Y }
C {sky130_stdcells/a21oi_4.sym} 74380 -16950 0 0 {name=X_68122_ }
C {devices/lab_pin.sym} 74340 -16810 0 0 {name=p73910 lab=_64752_/A }
C {devices/lab_pin.sym} 74420 -16810 0 1 {name=p73911 lab=_65334_/X }
C {sky130_stdcells/buf_2.sym} 74380 -16810 0 0 {name=X_65334_ }
C {devices/lab_pin.sym} 74340 -16690 0 0 {name=p73912 lab=_50496_/A }
C {devices/lab_pin.sym} 74420 -16690 0 1 {name=p73913 lab=_50560_/X }
C {sky130_stdcells/buf_2.sym} 74380 -16690 0 0 {name=X_50560_ }
C {devices/lab_pin.sym} 74300 -16600 0 0 {name=p73914 lab=_60056_/A }
C {devices/lab_pin.sym} 74300 -16560 0 0 {name=p73915 lab=_84834_/Q }
C {devices/lab_pin.sym} 74300 -16520 0 0 {name=p73916 lab=_59936_/X }
C {devices/lab_pin.sym} 74300 -16480 0 0 {name=p73917 lab=_62081_/B }
C {devices/lab_pin.sym} 74460 -16540 0 1 {name=p73918 lab=_62549_/A }
C {sky130_stdcells/a22oi_4.sym} 74380 -16540 0 0 {name=X_62546_ }
C {devices/lab_pin.sym} 74290 -16390 0 0 {name=p73919 lab=_83918_/CLK }
C {devices/lab_pin.sym} 74290 -16370 0 0 {name=p73920 lab=_81380_/D }
C {devices/lab_pin.sym} 74470 -16390 0 1 {name=p73921 lab=_76811_/B }
C {sky130_stdcells/dfxtp_4.sym} 74380 -16380 0 0 {name=X_81380_ }
C {devices/lab_pin.sym} 74300 -16270 0 0 {name=p73922 lab=_64647_/B }
C {devices/lab_pin.sym} 74300 -16230 0 0 {name=p73923 lab=_48548_/X }
C {devices/lab_pin.sym} 74300 -16190 0 0 {name=p73924 lab=_49218_/Y }
C {devices/lab_pin.sym} 74460 -16230 0 1 {name=p73925 lab=_49219_/Y }
C {sky130_stdcells/o21ai_4.sym} 74380 -16230 0 0 {name=X_49219_ }
C {devices/lab_pin.sym} 74320 -16100 0 0 {name=p73926 lab=_80329_/Y }
C {devices/lab_pin.sym} 74320 -16060 0 0 {name=p73927 lab=_80330_/Y }
C {devices/lab_pin.sym} 74440 -16080 0 1 {name=p73928 lab=_80331_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -16080 0 0 {name=X_80331_ }
C {devices/lab_pin.sym} 74340 -15950 0 0 {name=p73929 lab=_68450_/A }
C {devices/lab_pin.sym} 74420 -15950 0 1 {name=p73930 lab=_68053_/X }
C {sky130_stdcells/buf_2.sym} 74380 -15950 0 0 {name=X_68053_ }
C {devices/lab_pin.sym} 74300 -15860 0 0 {name=p73931 lab=_65178_/X }
C {devices/lab_pin.sym} 74300 -15820 0 0 {name=p73932 lab=_86728_/Q }
C {devices/lab_pin.sym} 74300 -15780 0 0 {name=p73933 lab=_65239_/X }
C {devices/lab_pin.sym} 74300 -15740 0 0 {name=p73934 lab=_65264_/X }
C {devices/lab_pin.sym} 74460 -15800 0 1 {name=p73935 lab=_65265_/X }
C {sky130_stdcells/a211o_4.sym} 74380 -15800 0 0 {name=X_65265_ }
C {devices/lab_pin.sym} 74340 -15650 0 0 {name=p73936 lab=_50491_/A }
C {devices/lab_pin.sym} 74420 -15650 0 1 {name=p73937 lab=_50491_/X }
C {sky130_stdcells/buf_2.sym} 74380 -15650 0 0 {name=X_50491_ }
C {devices/lab_pin.sym} 74320 -15560 0 0 {name=p73938 lab=_62493_/A }
C {devices/lab_pin.sym} 74320 -15520 0 0 {name=p73939 lab=_62472_/Y }
C {devices/lab_pin.sym} 74320 -15480 0 0 {name=p73940 lab=_62477_/C }
C {devices/lab_pin.sym} 74320 -15440 0 0 {name=p73941 lab=_62476_/Y }
C {devices/lab_pin.sym} 74440 -15500 0 1 {name=p73942 lab=_62477_/Y }
C {sky130_stdcells/nand4_4.sym} 74380 -15500 0 0 {name=X_62477_ }
C {devices/lab_pin.sym} 74300 -15380 0 0 {name=p73943 lab=_88385_/Q }
C {devices/lab_pin.sym} 74300 -15340 0 0 {name=p73944 lab=_66954_/X }
C {devices/lab_pin.sym} 74300 -15300 0 0 {name=p73945 lab=_66955_/X }
C {devices/lab_pin.sym} 74300 -15260 0 0 {name=p73946 lab=_67003_/X }
C {devices/lab_pin.sym} 74460 -15320 0 1 {name=p73947 lab=_67004_/X }
C {sky130_stdcells/a211o_4.sym} 74380 -15320 0 0 {name=X_67004_ }
C {devices/lab_pin.sym} 74320 -15180 0 0 {name=p73948 lab=_52220_/A }
C {devices/lab_pin.sym} 74320 -15140 0 0 {name=p73949 lab=_48847_/B }
C {devices/lab_pin.sym} 74440 -15160 0 1 {name=p73950 lab=_52230_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -15160 0 0 {name=X_52230_ }
C {devices/lab_pin.sym} 74300 -15050 0 0 {name=p73951 lab=_64214_/Y }
C {devices/lab_pin.sym} 74300 -15010 0 0 {name=p73952 lab=_64186_/X }
C {devices/lab_pin.sym} 74300 -14970 0 0 {name=p73953 lab=_64215_/Y }
C {devices/lab_pin.sym} 74460 -15010 0 1 {name=p73954 lab=_64216_/Y }
C {sky130_stdcells/a21oi_4.sym} 74380 -15010 0 0 {name=X_64216_ }
C {devices/lab_pin.sym} 74290 -14870 0 0 {name=p73955 lab=_86498_/CLK }
C {devices/lab_pin.sym} 74290 -14850 0 0 {name=p73956 lab=_83050_/D }
C {devices/lab_pin.sym} 74470 -14870 0 1 {name=p73957 lab=_83050_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -14860 0 0 {name=X_83050_ }
C {devices/lab_pin.sym} 74340 -14730 0 0 {name=p73958 lab=_58535_/A }
C {devices/lab_pin.sym} 74420 -14730 0 1 {name=p73959 lab=_61428_/X }
C {sky130_stdcells/buf_2.sym} 74380 -14730 0 0 {name=X_61428_ }
C {devices/lab_pin.sym} 74320 -14620 0 0 {name=p73960 lab=_79902_/Y }
C {devices/lab_pin.sym} 74320 -14580 0 0 {name=p73961 lab=_80262_/B }
C {devices/lab_pin.sym} 74440 -14600 0 1 {name=p73962 lab=_80262_/X }
C {sky130_stdcells/xor2_4.sym} 74380 -14600 0 0 {name=X_80262_ }
C {devices/lab_pin.sym} 74320 -14490 0 0 {name=p73963 lab=_65196_/A }
C {devices/lab_pin.sym} 74320 -14450 0 0 {name=p73964 lab=_65268_/B }
C {devices/lab_pin.sym} 74320 -14410 0 0 {name=p73965 lab=_84211_/Q }
C {devices/lab_pin.sym} 74440 -14450 0 1 {name=p73966 lab=_65196_/X }
C {sky130_stdcells/and3_4.sym} 74380 -14450 0 0 {name=X_65196_ }
C {devices/lab_pin.sym} 74290 -14310 0 0 {name=p73967 lab=_82288_/CLK }
C {devices/lab_pin.sym} 74290 -14290 0 0 {name=p73968 lab=_82001_/D }
C {devices/lab_pin.sym} 74470 -14310 0 1 {name=p73969 lab=_77105_/A }
C {sky130_stdcells/dfxtp_4.sym} 74380 -14300 0 0 {name=X_82001_ }
C {devices/lab_pin.sym} 74320 -14190 0 0 {name=p73970 lab=_52161_/A }
C {devices/lab_pin.sym} 74320 -14150 0 0 {name=p73971 lab=_52140_/X }
C {devices/lab_pin.sym} 74320 -14110 0 0 {name=p73972 lab=_52182_/C }
C {devices/lab_pin.sym} 74440 -14150 0 1 {name=p73973 lab=_52161_/X }
C {sky130_stdcells/and3_4.sym} 74380 -14150 0 0 {name=X_52161_ }
C {devices/lab_pin.sym} 74320 -14040 0 0 {name=p73974 lab=_64142_/Y }
C {devices/lab_pin.sym} 74320 -14000 0 0 {name=p73975 lab=_64144_/Y }
C {devices/lab_pin.sym} 74320 -13960 0 0 {name=p73976 lab=_64145_/Y }
C {devices/lab_pin.sym} 74320 -13920 0 0 {name=p73977 lab=_64146_/Y }
C {devices/lab_pin.sym} 74440 -13980 0 1 {name=p73978 lab=_64147_/X }
C {sky130_stdcells/and4_4.sym} 74380 -13980 0 0 {name=X_64147_ }
C {devices/lab_pin.sym} 74320 -13860 0 0 {name=p73979 lab=_63389_/A }
C {devices/lab_pin.sym} 74320 -13820 0 0 {name=p73980 lab=_61368_/B }
C {devices/lab_pin.sym} 74320 -13780 0 0 {name=p73981 lab=_61368_/C }
C {devices/lab_pin.sym} 74320 -13740 0 0 {name=p73982 lab=_61368_/D }
C {devices/lab_pin.sym} 74440 -13800 0 1 {name=p73983 lab=_61359_/Y }
C {sky130_stdcells/nand4_4.sym} 74380 -13800 0 0 {name=X_61359_ }
C {devices/lab_pin.sym} 74300 -13670 0 0 {name=p73984 lab=_80187_/A }
C {devices/lab_pin.sym} 74300 -13630 0 0 {name=p73985 lab=_80186_/X }
C {devices/lab_pin.sym} 74300 -13590 0 0 {name=p73986 lab=_80192_/Y }
C {devices/lab_pin.sym} 74460 -13630 0 1 {name=p73987 lab=_80209_/A }
C {sky130_stdcells/a21boi_4.sym} 74380 -13630 0 0 {name=X_80193_ }
C {devices/lab_pin.sym} 74320 -13500 0 0 {name=p73988 lab=_51112_/A }
C {devices/lab_pin.sym} 74320 -13460 0 0 {name=p73989 lab=_52803_/B }
C {devices/lab_pin.sym} 74440 -13480 0 1 {name=p73990 lab=_51112_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -13480 0 0 {name=X_51112_ }
C {devices/lab_pin.sym} 74300 -13370 0 0 {name=p73991 lab=_85890_/Q }
C {devices/lab_pin.sym} 74300 -13330 0 0 {name=p73992 lab=_52089_/X }
C {devices/lab_pin.sym} 74300 -13290 0 0 {name=p73993 lab=_52091_/Y }
C {devices/lab_pin.sym} 74460 -13330 0 1 {name=p73994 lab=_52092_/Y }
C {sky130_stdcells/o21ai_4.sym} 74380 -13330 0 0 {name=X_52092_ }
C {devices/lab_pin.sym} 74300 -13220 0 0 {name=p73995 lab=_58393_/Y }
C {devices/lab_pin.sym} 74300 -13180 0 0 {name=p73996 lab=_61003_/Y }
C {devices/lab_pin.sym} 74300 -13140 0 0 {name=p73997 lab=_58490_/A }
C {devices/lab_pin.sym} 74300 -13100 0 0 {name=p73998 lab=_60962_/A }
C {devices/lab_pin.sym} 74460 -13160 0 1 {name=p73999 lab=_64078_/X }
C {sky130_stdcells/o22a_4.sym} 74380 -13160 0 0 {name=X_64078_ }
C {devices/lab_pin.sym} 74340 -13010 0 0 {name=p74000 lab=_68955_/A }
C {devices/lab_pin.sym} 74420 -13010 0 1 {name=p74001 lab=_68956_/B }
C {sky130_stdcells/inv_2.sym} 74380 -13010 0 0 {name=X_68955_ }
C {devices/lab_pin.sym} 74320 -12900 0 0 {name=p74002 lab=_51022_/A }
C {devices/lab_pin.sym} 74320 -12860 0 0 {name=p74003 lab=_51043_/B }
C {devices/lab_pin.sym} 74440 -12880 0 1 {name=p74004 lab=_51043_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -12880 0 0 {name=X_51043_ }
C {devices/lab_pin.sym} 74300 -12780 0 0 {name=p74005 lab=_56211_/C }
C {devices/lab_pin.sym} 74300 -12740 0 0 {name=p74006 lab=_44087_/B }
C {devices/lab_pin.sym} 74300 -12700 0 0 {name=p74007 lab=_44052_/A }
C {devices/lab_pin.sym} 74300 -12660 0 0 {name=p74008 lab=_55919_/X }
C {devices/lab_pin.sym} 74460 -12720 0 1 {name=p74009 lab=_55920_/X }
C {sky130_stdcells/a211o_4.sym} 74380 -12720 0 0 {name=X_55920_ }
C {devices/lab_pin.sym} 74340 -12570 0 0 {name=p74010 lab=_67550_/X }
C {devices/lab_pin.sym} 74420 -12570 0 1 {name=p74011 lab=_67906_/X }
C {sky130_stdcells/buf_2.sym} 74380 -12570 0 0 {name=X_67906_ }
C {devices/lab_pin.sym} 74320 -12480 0 0 {name=p74012 lab=_63039_/A }
C {devices/lab_pin.sym} 74320 -12440 0 0 {name=p74013 lab=_64236_/C }
C {devices/lab_pin.sym} 74320 -12400 0 0 {name=p74014 lab=_63028_/X }
C {devices/lab_pin.sym} 74320 -12360 0 0 {name=p74015 lab=_63014_/D }
C {devices/lab_pin.sym} 74440 -12420 0 1 {name=p74016 lab=_63029_/X }
C {sky130_stdcells/and4_4.sym} 74380 -12420 0 0 {name=X_63029_ }
C {devices/lab_pin.sym} 74290 -12270 0 0 {name=p74017 lab=_85527_/CLK }
C {devices/lab_pin.sym} 74290 -12250 0 0 {name=p74018 lab=_46409_/Y }
C {devices/lab_pin.sym} 74470 -12270 0 1 {name=p74019 lab=_86740_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -12260 0 0 {name=X_86740_ }
C {devices/lab_pin.sym} 74290 -12130 0 0 {name=p74020 lab=_80776_/CLK }
C {devices/lab_pin.sym} 74290 -12110 0 0 {name=p74021 lab=_83952_/D }
C {devices/lab_pin.sym} 74470 -12130 0 1 {name=p74022 lab=_80808_/D }
C {sky130_stdcells/dfxtp_4.sym} 74380 -12120 0 0 {name=X_83952_ }
C {devices/lab_pin.sym} 74320 -12000 0 0 {name=p74023 lab=_68669_/A }
C {devices/lab_pin.sym} 74320 -11960 0 0 {name=p74024 lab=_68886_/B }
C {devices/lab_pin.sym} 74440 -11980 0 1 {name=p74025 lab=_68886_/Y }
C {sky130_stdcells/nor2_4.sym} 74380 -11980 0 0 {name=X_68886_ }
C {devices/lab_pin.sym} 74290 -11850 0 0 {name=p74026 lab=_81783_/CLK }
C {devices/lab_pin.sym} 74290 -11830 0 0 {name=p74027 lab=_78231_/B }
C {devices/lab_pin.sym} 74470 -11850 0 1 {name=p74028 lab=_82903_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -11840 0 0 {name=X_82903_ }
C {devices/lab_pin.sym} 74320 -11720 0 0 {name=p74029 lab=_55477_/A }
C {devices/lab_pin.sym} 74320 -11680 0 0 {name=p74030 lab=_55851_/B }
C {devices/lab_pin.sym} 74440 -11700 0 1 {name=p74031 lab=_55851_/X }
C {sky130_stdcells/and2_4.sym} 74380 -11700 0 0 {name=X_55851_ }
C {devices/lab_pin.sym} 74300 -11600 0 0 {name=p74032 lab=_87390_/Q }
C {devices/lab_pin.sym} 74300 -11560 0 0 {name=p74033 lab=_67834_/X }
C {devices/lab_pin.sym} 74300 -11520 0 0 {name=p74034 lab=_67835_/X }
C {devices/lab_pin.sym} 74300 -11480 0 0 {name=p74035 lab=_67836_/X }
C {devices/lab_pin.sym} 74460 -11540 0 1 {name=p74036 lab=_67837_/X }
C {sky130_stdcells/a211o_4.sym} 74380 -11540 0 0 {name=X_67837_ }
C {devices/lab_pin.sym} 74290 -11390 0 0 {name=p74037 lab=_86353_/CLK }
C {devices/lab_pin.sym} 74290 -11370 0 0 {name=p74038 lab=_86671_/D }
C {devices/lab_pin.sym} 74470 -11390 0 1 {name=p74039 lab=_59226_/A }
C {sky130_stdcells/dfxtp_4.sym} 74380 -11380 0 0 {name=X_86671_ }
C {devices/lab_pin.sym} 74290 -11250 0 0 {name=p74040 lab=_82301_/CLK }
C {devices/lab_pin.sym} 74290 -11230 0 0 {name=p74041 lab=_83883_/D }
C {devices/lab_pin.sym} 74470 -11250 0 1 {name=p74042 lab=_83883_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -11240 0 0 {name=X_83883_ }
C {devices/lab_pin.sym} 74340 -11110 0 0 {name=p74043 lab=_54693_/X }
C {devices/lab_pin.sym} 74420 -11110 0 1 {name=p74044 lab=_54802_/X }
C {sky130_stdcells/buf_2.sym} 74380 -11110 0 0 {name=X_54802_ }
C {devices/lab_pin.sym} 74290 -10990 0 0 {name=p74045 lab=_86235_/CLK }
C {devices/lab_pin.sym} 74290 -10970 0 0 {name=p74046 lab=_53517_/Y }
C {devices/lab_pin.sym} 74470 -10990 0 1 {name=p74047 lab=_85622_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -10980 0 0 {name=X_85622_ }
C {devices/lab_pin.sym} 74300 -10870 0 0 {name=p74048 lab=_58085_/X }
C {devices/lab_pin.sym} 74300 -10830 0 0 {name=p74049 lab=_85473_/Q }
C {devices/lab_pin.sym} 74300 -10790 0 0 {name=p74050 lab=_58569_/X }
C {devices/lab_pin.sym} 74460 -10830 0 1 {name=p74051 lab=_58570_/Y }
C {sky130_stdcells/o21ai_4.sym} 74380 -10830 0 0 {name=X_58570_ }
C {devices/lab_pin.sym} 74290 -10690 0 0 {name=p74052 lab=_84119_/CLK }
C {devices/lab_pin.sym} 74290 -10670 0 0 {name=p74053 lab=_82834_/D }
C {devices/lab_pin.sym} 74470 -10690 0 1 {name=p74054 lab=_82834_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -10680 0 0 {name=X_82834_ }
C {devices/lab_pin.sym} 74340 -10550 0 0 {name=p74055 lab=_55781_/X }
C {devices/lab_pin.sym} 74420 -10550 0 1 {name=p74056 lab=_55801_/B }
C {sky130_stdcells/buf_2.sym} 74380 -10550 0 0 {name=X_55782_ }
C {devices/lab_pin.sym} 74300 -10460 0 0 {name=p74057 lab=_86957_/Q }
C {devices/lab_pin.sym} 74300 -10420 0 0 {name=p74058 lab=_67670_/X }
C {devices/lab_pin.sym} 74300 -10380 0 0 {name=p74059 lab=_67671_/X }
C {devices/lab_pin.sym} 74300 -10340 0 0 {name=p74060 lab=_67767_/X }
C {devices/lab_pin.sym} 74460 -10400 0 1 {name=p74061 lab=_67768_/X }
C {sky130_stdcells/a211o_4.sym} 74380 -10400 0 0 {name=X_67768_ }
C {devices/lab_pin.sym} 74300 -10270 0 0 {name=p74062 lab=_52992_/Y }
C {devices/lab_pin.sym} 74300 -10230 0 0 {name=p74063 lab=_52975_/X }
C {devices/lab_pin.sym} 74300 -10190 0 0 {name=p74064 lab=_52993_/X }
C {devices/lab_pin.sym} 74460 -10230 0 1 {name=p74065 lab=_52994_/Y }
C {sky130_stdcells/a21oi_4.sym} 74380 -10230 0 0 {name=X_52994_ }
C {devices/lab_pin.sym} 74320 -10100 0 0 {name=p74066 lab=_57531_/A }
C {devices/lab_pin.sym} 74320 -10060 0 0 {name=p74067 lab=_53488_/B }
C {devices/lab_pin.sym} 74440 -10080 0 1 {name=p74068 lab=_57521_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -10080 0 0 {name=X_57521_ }
C {devices/lab_pin.sym} 74320 -9960 0 0 {name=p74069 lab=_69580_/A }
C {devices/lab_pin.sym} 74320 -9920 0 0 {name=p74070 lab=_87768_/Q }
C {devices/lab_pin.sym} 74440 -9940 0 1 {name=p74071 lab=_69507_/X }
C {sky130_stdcells/and2_4.sym} 74380 -9940 0 0 {name=X_69507_ }
C {devices/lab_pin.sym} 74290 -9810 0 0 {name=p74072 lab=_88337_/CLK }
C {devices/lab_pin.sym} 74290 -9790 0 0 {name=p74073 lab=_88341_/D }
C {devices/lab_pin.sym} 74470 -9810 0 1 {name=p74074 lab=_88341_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -9800 0 0 {name=X_88341_ }
C {devices/lab_pin.sym} 74300 -9690 0 0 {name=p74075 lab=_85388_/Q }
C {devices/lab_pin.sym} 74300 -9650 0 0 {name=p74076 lab=_54729_/X }
C {devices/lab_pin.sym} 74300 -9610 0 0 {name=p74077 lab=_54732_/Y }
C {devices/lab_pin.sym} 74460 -9650 0 1 {name=p74078 lab=_54733_/Y }
C {sky130_stdcells/o21ai_4.sym} 74380 -9650 0 0 {name=X_54733_ }
C {devices/lab_pin.sym} 74300 -9540 0 0 {name=p74079 lab=_87129_/Q }
C {devices/lab_pin.sym} 74300 -9500 0 0 {name=p74080 lab=_66715_/X }
C {devices/lab_pin.sym} 74300 -9460 0 0 {name=p74081 lab=_66717_/X }
C {devices/lab_pin.sym} 74300 -9420 0 0 {name=p74082 lab=_66718_/X }
C {devices/lab_pin.sym} 74460 -9480 0 1 {name=p74083 lab=_66719_/X }
C {sky130_stdcells/a211o_4.sym} 74380 -9480 0 0 {name=X_66719_ }
C {devices/lab_pin.sym} 74290 -9330 0 0 {name=p74084 lab=_85553_/CLK }
C {devices/lab_pin.sym} 74290 -9310 0 0 {name=p74085 lab=_53864_/Y }
C {devices/lab_pin.sym} 74470 -9330 0 1 {name=p74086 lab=_85553_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -9320 0 0 {name=X_85553_ }
C {devices/lab_pin.sym} 74340 -9190 0 0 {name=p74087 lab=_52152_/A }
C {devices/lab_pin.sym} 74420 -9190 0 1 {name=p74088 lab=_51945_/X }
C {sky130_stdcells/buf_2.sym} 74380 -9190 0 0 {name=X_51945_ }
C {devices/lab_pin.sym} 74290 -9070 0 0 {name=p74089 lab=_82769_/CLK }
C {devices/lab_pin.sym} 74290 -9050 0 0 {name=p74090 lab=_82765_/D }
C {devices/lab_pin.sym} 74470 -9070 0 1 {name=p74091 lab=_82957_/D }
C {sky130_stdcells/dfxtp_4.sym} 74380 -9060 0 0 {name=X_82765_ }
C {devices/lab_pin.sym} 74340 -8930 0 0 {name=p74092 lab=_67222_/A }
C {devices/lab_pin.sym} 74420 -8930 0 1 {name=p74093 lab=_67793_/A }
C {sky130_stdcells/buf_2.sym} 74380 -8930 0 0 {name=X_67699_ }
C {devices/lab_pin.sym} 74290 -8810 0 0 {name=p74094 lab=_84493_/CLK }
C {devices/lab_pin.sym} 74290 -8790 0 0 {name=p74095 lab=_84504_/D }
C {devices/lab_pin.sym} 74470 -8810 0 1 {name=p74096 lab=_61223_/C }
C {sky130_stdcells/dfxtp_4.sym} 74380 -8800 0 0 {name=X_84504_ }
C {devices/lab_pin.sym} 74290 -8670 0 0 {name=p74097 lab=_81514_/CLK }
C {devices/lab_pin.sym} 74290 -8650 0 0 {name=p74098 lab=_81716_/D }
C {devices/lab_pin.sym} 74470 -8670 0 1 {name=p74099 lab=_41007_/B }
C {sky130_stdcells/dfxtp_4.sym} 74380 -8660 0 0 {name=X_81716_ }
C {devices/lab_pin.sym} 74340 -8530 0 0 {name=p74100 lab=_57452_/A }
C {devices/lab_pin.sym} 74420 -8530 0 1 {name=p74101 lab=_57452_/Y }
C {sky130_stdcells/inv_2.sym} 74380 -8530 0 0 {name=X_57452_ }
C {devices/lab_pin.sym} 74340 -8410 0 0 {name=p74102 lab=_70009_/A }
C {devices/lab_pin.sym} 74420 -8410 0 1 {name=p74103 lab=_69696_/A }
C {sky130_stdcells/buf_2.sym} 74380 -8410 0 0 {name=X_69438_ }
C {devices/lab_pin.sym} 74290 -8290 0 0 {name=p74104 lab=_88272_/CLK }
C {devices/lab_pin.sym} 74290 -8270 0 0 {name=p74105 lab=_41131_/X }
C {devices/lab_pin.sym} 74470 -8290 0 1 {name=p74106 lab=_88272_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -8280 0 0 {name=X_88272_ }
C {devices/lab_pin.sym} 74320 -8160 0 0 {name=p74107 lab=_54649_/X }
C {devices/lab_pin.sym} 74320 -8120 0 0 {name=p74108 lab=_47306_/A }
C {devices/lab_pin.sym} 74440 -8140 0 1 {name=p74109 lab=_54664_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -8140 0 0 {name=X_54664_ }
C {devices/lab_pin.sym} 74290 -8010 0 0 {name=p74110 lab=_85484_/CLK }
C {devices/lab_pin.sym} 74290 -7990 0 0 {name=p74111 lab=_85484_/D }
C {devices/lab_pin.sym} 74470 -8010 0 1 {name=p74112 lab=_85484_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -8000 0 0 {name=X_85484_ }
C {devices/lab_pin.sym} 74300 -7890 0 0 {name=p74113 lab=_85930_/Q }
C {devices/lab_pin.sym} 74300 -7850 0 0 {name=p74114 lab=_51873_/X }
C {devices/lab_pin.sym} 74300 -7810 0 0 {name=p74115 lab=_51875_/Y }
C {devices/lab_pin.sym} 74460 -7850 0 1 {name=p74116 lab=_51876_/Y }
C {sky130_stdcells/o21ai_4.sym} 74380 -7850 0 0 {name=X_51876_ }
C {devices/lab_pin.sym} 74290 -7710 0 0 {name=p74117 lab=_82933_/CLK }
C {devices/lab_pin.sym} 74290 -7690 0 0 {name=p74118 lab=_78862_/X }
C {devices/lab_pin.sym} 74470 -7710 0 1 {name=p74119 lab=_82684_/D }
C {sky130_stdcells/dfxtp_4.sym} 74380 -7700 0 0 {name=X_82696_ }
C {devices/lab_pin.sym} 74340 -7570 0 0 {name=p74120 lab=clkbuf_7_61_0_CLK/A }
C {devices/lab_pin.sym} 74420 -7570 0 1 {name=p74121 lab=clkbuf_7_61_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 74380 -7570 0 0 {name=Xclkbuf_7_61_0_CLK }
C {devices/lab_pin.sym} 74320 -7470 0 0 {name=p74122 lab=_56397_/X }
C {devices/lab_pin.sym} 74320 -7430 0 0 {name=p74123 lab=_56399_/B }
C {devices/lab_pin.sym} 74320 -7390 0 0 {name=p74124 lab=_85207_/Q }
C {devices/lab_pin.sym} 74440 -7430 0 1 {name=p74125 lab=_56403_/Y }
C {sky130_stdcells/nand3_4.sym} 74380 -7430 0 0 {name=X_56403_ }
C {devices/lab_pin.sym} 74290 -7290 0 0 {name=p74126 lab=_88002_/CLK }
C {devices/lab_pin.sym} 74290 -7270 0 0 {name=p74127 lab=_43874_/X }
C {devices/lab_pin.sym} 74470 -7290 0 1 {name=p74128 lab=_69045_/B }
C {sky130_stdcells/dfxtp_4.sym} 74380 -7280 0 0 {name=X_87223_ }
C {devices/lab_pin.sym} 74300 -7170 0 0 {name=p74129 lab=_53613_/Y }
C {devices/lab_pin.sym} 74300 -7130 0 0 {name=p74130 lab=_53603_/X }
C {devices/lab_pin.sym} 74300 -7090 0 0 {name=p74131 lab=_53614_/Y }
C {devices/lab_pin.sym} 74460 -7130 0 1 {name=p74132 lab=_85602_/D }
C {sky130_stdcells/a21boi_4.sym} 74380 -7130 0 0 {name=X_53615_ }
C {devices/lab_pin.sym} 74290 -6990 0 0 {name=p74133 lab=_84438_/CLK }
C {devices/lab_pin.sym} 74290 -6970 0 0 {name=p74134 lab=_62080_/Y }
C {devices/lab_pin.sym} 74470 -6990 0 1 {name=p74135 lab=_78058_/B }
C {sky130_stdcells/dfxtp_4.sym} 74380 -6980 0 0 {name=X_84435_ }
C {devices/lab_pin.sym} 74320 -6860 0 0 {name=p74136 lab=_50822_/A }
C {devices/lab_pin.sym} 74320 -6820 0 0 {name=p74137 lab=_50827_/B }
C {devices/lab_pin.sym} 74440 -6840 0 1 {name=p74138 lab=_50827_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -6840 0 0 {name=X_50827_ }
C {devices/lab_pin.sym} 74340 -6710 0 0 {name=p74139 lab=_57465_/A }
C {devices/lab_pin.sym} 74420 -6710 0 1 {name=p74140 lab=_57484_/A }
C {sky130_stdcells/buf_2.sym} 74380 -6710 0 0 {name=X_57383_ }
C {devices/lab_pin.sym} 74290 -6590 0 0 {name=p74141 lab=_81361_/CLK }
C {devices/lab_pin.sym} 74290 -6570 0 0 {name=p74142 lab=_76917_/A }
C {devices/lab_pin.sym} 74470 -6590 0 1 {name=p74143 lab=_76330_/A }
C {sky130_stdcells/dfxtp_4.sym} 74380 -6580 0 0 {name=X_81647_ }
C {devices/lab_pin.sym} 74320 -6460 0 0 {name=p74144 lab=_69234_/A }
C {devices/lab_pin.sym} 74320 -6420 0 0 {name=p74145 lab=_87778_/Q }
C {devices/lab_pin.sym} 74440 -6440 0 1 {name=p74146 lab=_69369_/X }
C {sky130_stdcells/and2_4.sym} 74380 -6440 0 0 {name=X_69369_ }
C {devices/lab_pin.sym} 74340 -6310 0 0 {name=p74147 lab=_54594_/X }
C {devices/lab_pin.sym} 74420 -6310 0 1 {name=p74148 lab=_54600_/A }
C {sky130_stdcells/buf_2.sym} 74380 -6310 0 0 {name=X_54595_ }
C {devices/lab_pin.sym} 74300 -6210 0 0 {name=p74149 lab=_59048_/X }
C {devices/lab_pin.sym} 74300 -6170 0 0 {name=p74150 lab=_85655_/Q }
C {devices/lab_pin.sym} 74300 -6130 0 0 {name=p74151 lab=_59070_/X }
C {devices/lab_pin.sym} 74460 -6170 0 1 {name=p74152 lab=_59122_/X }
C {sky130_stdcells/o21a_4.sym} 74380 -6170 0 0 {name=X_59122_ }
C {devices/lab_pin.sym} 74300 -6050 0 0 {name=p74153 lab=_71397_/X }
C {devices/lab_pin.sym} 74300 -6010 0 0 {name=p74154 lab=_83513_/Q }
C {devices/lab_pin.sym} 74300 -5970 0 0 {name=p74155 lab=_71399_/Y }
C {devices/lab_pin.sym} 74460 -6010 0 1 {name=p74156 lab=_71400_/X }
C {sky130_stdcells/a21o_4.sym} 74380 -6010 0 0 {name=X_71400_ }
C {devices/lab_pin.sym} 74340 -5870 0 0 {name=p74157 lab=_56347_/A }
C {devices/lab_pin.sym} 74420 -5870 0 1 {name=p74158 lab=_56345_/A }
C {sky130_stdcells/buf_2.sym} 74380 -5870 0 0 {name=X_56334_ }
C {devices/lab_pin.sym} 74290 -5750 0 0 {name=p74159 lab=_87149_/CLK }
C {devices/lab_pin.sym} 74290 -5730 0 0 {name=p74160 lab=_87154_/D }
C {devices/lab_pin.sym} 74470 -5750 0 1 {name=p74161 lab=_87154_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -5740 0 0 {name=X_87154_ }
C {devices/lab_pin.sym} 74320 -5620 0 0 {name=p74162 lab=_53565_/A }
C {devices/lab_pin.sym} 74320 -5580 0 0 {name=p74163 lab=_50322_/B }
C {devices/lab_pin.sym} 74440 -5600 0 1 {name=p74164 lab=_53546_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -5600 0 0 {name=X_53546_ }
C {devices/lab_pin.sym} 74340 -5470 0 0 {name=p74165 lab=_41559_/Y }
C {devices/lab_pin.sym} 74420 -5470 0 1 {name=p74166 lab=_41560_/X }
C {sky130_stdcells/buf_2.sym} 74380 -5470 0 0 {name=X_41560_ }
C {devices/lab_pin.sym} 74300 -5380 0 0 {name=p74167 lab=_72371_/Y }
C {devices/lab_pin.sym} 74300 -5340 0 0 {name=p74168 lab=_72358_/X }
C {devices/lab_pin.sym} 74300 -5300 0 0 {name=p74169 lab=_72376_/X }
C {devices/lab_pin.sym} 74300 -5260 0 0 {name=p74170 lab=_72379_/X }
C {devices/lab_pin.sym} 74460 -5320 0 1 {name=p74171 lab=_83260_/D }
C {sky130_stdcells/a22oi_4.sym} 74380 -5320 0 0 {name=X_72380_ }
C {devices/lab_pin.sym} 74290 -5170 0 0 {name=p74172 lab=_84449_/CLK }
C {devices/lab_pin.sym} 74290 -5150 0 0 {name=p74173 lab=_84366_/D }
C {devices/lab_pin.sym} 74470 -5170 0 1 {name=p74174 lab=_84366_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -5160 0 0 {name=X_84366_ }
C {devices/lab_pin.sym} 74300 -5050 0 0 {name=p74175 lab=_86139_/Q }
C {devices/lab_pin.sym} 74300 -5010 0 0 {name=p74176 lab=_50742_/X }
C {devices/lab_pin.sym} 74300 -4970 0 0 {name=p74177 lab=_50757_/Y }
C {devices/lab_pin.sym} 74460 -5010 0 1 {name=p74178 lab=_50758_/Y }
C {sky130_stdcells/o21ai_4.sym} 74380 -5010 0 0 {name=X_50758_ }
C {devices/lab_pin.sym} 74290 -4870 0 0 {name=p74179 lab=_81344_/CLK }
C {devices/lab_pin.sym} 74290 -4850 0 0 {name=p74180 lab=_84178_/Q }
C {devices/lab_pin.sym} 74470 -4870 0 1 {name=p74181 lab=_76726_/A }
C {sky130_stdcells/dfxtp_4.sym} 74380 -4860 0 0 {name=X_81578_ }
C {devices/lab_pin.sym} 74290 -4730 0 0 {name=p74182 lab=_86104_/CLK }
C {devices/lab_pin.sym} 74290 -4710 0 0 {name=p74183 lab=_86105_/D }
C {devices/lab_pin.sym} 74470 -4730 0 1 {name=p74184 lab=_86105_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -4720 0 0 {name=X_86105_ }
C {devices/lab_pin.sym} 74300 -4620 0 0 {name=p74185 lab=_40507_/X }
C {devices/lab_pin.sym} 74300 -4580 0 0 {name=p74186 lab=_40508_/X }
C {devices/lab_pin.sym} 74300 -4540 0 0 {name=p74187 lab=_88380_/Q }
C {devices/lab_pin.sym} 74300 -4500 0 0 {name=p74188 lab=_40510_/X }
C {devices/lab_pin.sym} 74460 -4560 0 1 {name=p74189 lab=_88380_/D }
C {sky130_stdcells/a2bb2o_4.sym} 74380 -4560 0 0 {name=X_40511_ }
C {devices/lab_pin.sym} 74320 -4430 0 0 {name=p74190 lab=_71335_/A }
C {devices/lab_pin.sym} 74320 -4390 0 0 {name=p74191 lab=_71335_/B }
C {devices/lab_pin.sym} 74320 -4350 0 0 {name=p74192 lab=_71680_/C }
C {devices/lab_pin.sym} 74440 -4390 0 1 {name=p74193 lab=_71331_/Y }
C {sky130_stdcells/nand3_4.sym} 74380 -4390 0 0 {name=X_71331_ }
C {devices/lab_pin.sym} 74340 -4250 0 0 {name=p74194 lab=_59053_/A }
C {devices/lab_pin.sym} 74420 -4250 0 1 {name=p74195 lab=_59053_/X }
C {sky130_stdcells/buf_2.sym} 74380 -4250 0 0 {name=X_59053_ }
C {devices/lab_pin.sym} 74290 -4130 0 0 {name=p74196 lab=_85003_/CLK }
C {devices/lab_pin.sym} 74290 -4110 0 0 {name=p74197 lab=_71950_/Y }
C {devices/lab_pin.sym} 74470 -4130 0 1 {name=p74198 lab=_83317_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -4120 0 0 {name=X_83317_ }
C {devices/lab_pin.sym} 74340 -3990 0 0 {name=p74199 lab=_80551_/A }
C {devices/lab_pin.sym} 74420 -3990 0 1 {name=p74200 lab=_80529_/Y }
C {sky130_stdcells/inv_2.sym} 74380 -3990 0 0 {name=X_80529_ }
C {devices/lab_pin.sym} 74320 -3890 0 0 {name=p74201 lab=_56194_/X }
C {devices/lab_pin.sym} 74320 -3850 0 0 {name=p74202 lab=_56263_/B }
C {devices/lab_pin.sym} 74320 -3810 0 0 {name=p74203 lab=_85253_/Q }
C {devices/lab_pin.sym} 74440 -3850 0 1 {name=p74204 lab=_56265_/Y }
C {sky130_stdcells/nand3_4.sym} 74380 -3850 0 0 {name=X_56265_ }
C {devices/lab_pin.sym} 74320 -3720 0 0 {name=p74205 lab=_81179_/Q }
C {devices/lab_pin.sym} 74320 -3680 0 0 {name=p74206 lab=_41471_/B }
C {devices/lab_pin.sym} 74440 -3700 0 1 {name=p74207 lab=_41491_/X }
C {sky130_stdcells/or2_4.sym} 74380 -3700 0 0 {name=X_41491_ }
C {devices/lab_pin.sym} 74290 -3570 0 0 {name=p74208 lab=_88263_/CLK }
C {devices/lab_pin.sym} 74290 -3550 0 0 {name=p74209 lab=_44486_/Y }
C {devices/lab_pin.sym} 74470 -3570 0 1 {name=p74210 lab=_87085_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -3560 0 0 {name=X_87085_ }
C {devices/lab_pin.sym} 74340 -3430 0 0 {name=p74211 lab=_54919_/A }
C {devices/lab_pin.sym} 74420 -3430 0 1 {name=p74212 lab=_53478_/A }
C {sky130_stdcells/buf_2.sym} 74380 -3430 0 0 {name=X_53477_ }
C {devices/lab_pin.sym} 74290 -3310 0 0 {name=p74213 lab=_84293_/CLK }
C {devices/lab_pin.sym} 74290 -3290 0 0 {name=p74214 lab=_84297_/D }
C {devices/lab_pin.sym} 74470 -3310 0 1 {name=p74215 lab=_63745_/C }
C {sky130_stdcells/dfxtp_4.sym} 74380 -3300 0 0 {name=X_84297_ }
C {devices/lab_pin.sym} 74300 -3190 0 0 {name=p74216 lab=_50687_/Y }
C {devices/lab_pin.sym} 74300 -3150 0 0 {name=p74217 lab=_50644_/X }
C {devices/lab_pin.sym} 74300 -3110 0 0 {name=p74218 lab=_50688_/Y }
C {devices/lab_pin.sym} 74460 -3150 0 1 {name=p74219 lab=_86153_/D }
C {sky130_stdcells/a21boi_4.sym} 74380 -3150 0 0 {name=X_50689_ }
C {devices/lab_pin.sym} 74340 -3010 0 0 {name=p74220 lab=clkbuf_7_77_0_CLK/A }
C {devices/lab_pin.sym} 74420 -3010 0 1 {name=p74221 lab=clkbuf_7_76_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 74380 -3010 0 0 {name=Xclkbuf_7_76_0_CLK }
C {devices/lab_pin.sym} 74300 -2910 0 0 {name=p74222 lab=_57999_/Y }
C {devices/lab_pin.sym} 74300 -2870 0 0 {name=p74223 lab=_58001_/Y }
C {devices/lab_pin.sym} 74300 -2830 0 0 {name=p74224 lab=_58003_/X }
C {devices/lab_pin.sym} 74460 -2870 0 1 {name=p74225 lab=_58004_/X }
C {sky130_stdcells/a21o_4.sym} 74380 -2870 0 0 {name=X_58004_ }
C {devices/lab_pin.sym} 74300 -2770 0 0 {name=p74226 lab=_43226_/X }
C {devices/lab_pin.sym} 74300 -2730 0 0 {name=p74227 lab=_43229_/X }
C {devices/lab_pin.sym} 74300 -2690 0 0 {name=p74228 lab=_41004_/X }
C {devices/lab_pin.sym} 74300 -2650 0 0 {name=p74229 lab=_87527_/Q }
C {devices/lab_pin.sym} 74300 -2610 0 0 {name=p74230 lab=_43212_/X }
C {devices/lab_pin.sym} 74460 -2690 0 1 {name=p74231 lab=_43231_/A }
C {sky130_stdcells/o32ai_4.sym} 74380 -2690 0 0 {name=X_43230_ }
C {devices/lab_pin.sym} 74320 -2540 0 0 {name=p74232 lab=_55741_/A }
C {devices/lab_pin.sym} 74320 -2500 0 0 {name=p74233 lab=_85122_/Q }
C {devices/lab_pin.sym} 74440 -2520 0 1 {name=p74234 lab=_55216_/X }
C {sky130_stdcells/and2_4.sym} 74380 -2520 0 0 {name=X_55216_ }
C {devices/lab_pin.sym} 74300 -2410 0 0 {name=p74235 lab=_70112_/C }
C {devices/lab_pin.sym} 74300 -2370 0 0 {name=p74236 lab=_73939_/X }
C {devices/lab_pin.sym} 74300 -2330 0 0 {name=p74237 lab=_74049_/X }
C {devices/lab_pin.sym} 74460 -2370 0 1 {name=p74238 lab=_74050_/Y }
C {sky130_stdcells/o21ai_4.sym} 74380 -2370 0 0 {name=X_74050_ }
C {devices/lab_pin.sym} 74290 -2230 0 0 {name=p74239 lab=_86040_/CLK }
C {devices/lab_pin.sym} 74290 -2210 0 0 {name=p74240 lab=_51303_/Y }
C {devices/lab_pin.sym} 74470 -2230 0 1 {name=p74241 lab=_86036_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -2220 0 0 {name=X_86036_ }
C {devices/lab_pin.sym} 74340 -2090 0 0 {name=p74242 lab=_40441_/Y }
C {devices/lab_pin.sym} 74420 -2090 0 1 {name=p74243 lab=_40442_/Y }
C {sky130_stdcells/inv_2.sym} 74380 -2090 0 0 {name=X_40442_ }
C {devices/lab_pin.sym} 74320 -1980 0 0 {name=p74244 lab=_52185_/X }
C {devices/lab_pin.sym} 74320 -1940 0 0 {name=p74245 lab=_53946_/B }
C {devices/lab_pin.sym} 74440 -1960 0 1 {name=p74246 lab=_52428_/Y }
C {sky130_stdcells/nand2_4.sym} 74380 -1960 0 0 {name=X_52428_ }
C {devices/lab_pin.sym} 74300 -1850 0 0 {name=p74247 lab=_50268_/B }
C {devices/lab_pin.sym} 74300 -1810 0 0 {name=p74248 lab=_71239_/A }
C {devices/lab_pin.sym} 74300 -1770 0 0 {name=p74249 lab=_71261_/Y }
C {devices/lab_pin.sym} 74460 -1810 0 1 {name=p74250 lab=_71262_/Y }
C {sky130_stdcells/o21ai_4.sym} 74380 -1810 0 0 {name=X_71262_ }
C {devices/lab_pin.sym} 74290 -1670 0 0 {name=p74251 lab=_83248_/CLK }
C {devices/lab_pin.sym} 74290 -1650 0 0 {name=p74252 lab=_83248_/D }
C {devices/lab_pin.sym} 74470 -1670 0 1 {name=p74253 lab=_83248_/Q }
C {sky130_stdcells/dfxtp_4.sym} 74380 -1660 0 0 {name=X_83248_ }
C {devices/lab_pin.sym} 74320 -1550 0 0 {name=p74254 lab=_56280_/A }
C {devices/lab_pin.sym} 74320 -1510 0 0 {name=p74255 lab=_56192_/B }
C {devices/lab_pin.sym} 74320 -1470 0 0 {name=p74256 lab=_56196_/C }
C {devices/lab_pin.sym} 74440 -1510 0 1 {name=p74257 lab=_56196_/Y }
C {sky130_stdcells/nand3_4.sym} 74380 -1510 0 0 {name=X_56196_ }
C {devices/lab_pin.sym} 74300 -1400 0 0 {name=p74258 lab=_42004_/Y }
C {devices/lab_pin.sym} 74300 -1360 0 0 {name=p74259 lab=_72921_/X }
C {devices/lab_pin.sym} 74300 -1320 0 0 {name=p74260 lab=_72944_/X }
C {devices/lab_pin.sym} 74300 -1280 0 0 {name=p74261 lab=_73000_/Y }
C {devices/lab_pin.sym} 74460 -1340 0 1 {name=p74262 lab=_73001_/X }
C {sky130_stdcells/a211o_4.sym} 74380 -1340 0 0 {name=X_73001_ }
C {devices/lab_pin.sym} 74300 -1210 0 0 {name=p74263 lab=_70209_/X }
C {devices/lab_pin.sym} 74300 -1170 0 0 {name=p74264 lab=_83835_/Q }
C {devices/lab_pin.sym} 74300 -1130 0 0 {name=p74265 lab=_70212_/X }
C {devices/lab_pin.sym} 74460 -1170 0 1 {name=p74266 lab=_83835_/D }
C {sky130_stdcells/a21o_4.sym} 74380 -1170 0 0 {name=X_70213_ }
C {devices/lab_pin.sym} 74320 -1040 0 0 {name=p74267 lab=_55139_/X }
C {devices/lab_pin.sym} 74320 -1000 0 0 {name=p74268 lab=_55146_/X }
C {devices/lab_pin.sym} 74440 -1020 0 1 {name=p74269 lab=_55147_/X }
C {sky130_stdcells/and2_4.sym} 74380 -1020 0 0 {name=X_55147_ }
C {devices/lab_pin.sym} 74340 -890 0 0 {name=p74270 lab=_43161_/A }
C {devices/lab_pin.sym} 74420 -890 0 1 {name=p74271 lab=_43162_/A }
C {sky130_stdcells/buf_2.sym} 74380 -890 0 0 {name=X_43161_ }
C {devices/lab_pin.sym} 74340 -770 0 0 {name=p74272 lab=_44624_/A }
C {devices/lab_pin.sym} 74420 -770 0 1 {name=p74273 lab=_44532_/A }
C {sky130_stdcells/buf_2.sym} 74380 -770 0 0 {name=X_40373_ }
C {devices/lab_pin.sym} 75260 -42150 0 0 {name=p74274 lab=_70984_/A }
C {devices/lab_pin.sym} 75340 -42150 0 1 {name=p74275 lab=_71217_/B }
C {sky130_stdcells/buf_2.sym} 75300 -42150 0 0 {name=X_71193_ }
C {devices/lab_pin.sym} 75260 -42030 0 0 {name=p74276 lab=_52319_/A }
C {devices/lab_pin.sym} 75340 -42030 0 1 {name=p74277 lab=_52385_/A }
C {sky130_stdcells/buf_2.sym} 75300 -42030 0 0 {name=X_52359_ }
C {devices/lab_pin.sym} 75210 -41910 0 0 {name=p74278 lab=_83820_/CLK }
C {devices/lab_pin.sym} 75210 -41890 0 0 {name=p74279 lab=_83179_/D }
C {devices/lab_pin.sym} 75390 -41910 0 1 {name=p74280 lab=_70260_/C }
C {sky130_stdcells/dfxtp_4.sym} 75300 -41900 0 0 {name=X_83179_ }
C {devices/lab_pin.sym} 75260 -41770 0 0 {name=p74281 lab=_42112_/A }
C {devices/lab_pin.sym} 75340 -41770 0 1 {name=p74282 lab=_42112_/Y }
C {sky130_stdcells/inv_2.sym} 75300 -41770 0 0 {name=X_42112_ }
C {devices/lab_pin.sym} 75240 -41680 0 0 {name=p74283 lab=_70144_/A }
C {devices/lab_pin.sym} 75240 -41640 0 0 {name=p74284 lab=_70144_/B }
C {devices/lab_pin.sym} 75240 -41600 0 0 {name=p74285 lab=_70144_/C }
C {devices/lab_pin.sym} 75240 -41560 0 0 {name=p74286 lab=_70144_/D }
C {devices/lab_pin.sym} 75360 -41620 0 1 {name=p74287 lab=_70144_/X }
C {sky130_stdcells/and4_4.sym} 75300 -41620 0 0 {name=X_70144_ }
C {devices/lab_pin.sym} 75220 -41510 0 0 {name=p74288 lab=_43072_/X }
C {devices/lab_pin.sym} 75220 -41470 0 0 {name=p74289 lab=_43075_/X }
C {devices/lab_pin.sym} 75220 -41430 0 0 {name=p74290 lab=_40724_/X }
C {devices/lab_pin.sym} 75220 -41390 0 0 {name=p74291 lab=_74123_/A }
C {devices/lab_pin.sym} 75220 -41350 0 0 {name=p74292 lab=_43080_/X }
C {devices/lab_pin.sym} 75380 -41430 0 1 {name=p74293 lab=_43092_/Y }
C {sky130_stdcells/o32ai_4.sym} 75300 -41430 0 0 {name=X_43092_ }
C {devices/lab_pin.sym} 75240 -41300 0 0 {name=p74294 lab=_55083_/A }
C {devices/lab_pin.sym} 75240 -41260 0 0 {name=p74295 lab=_55056_/X }
C {devices/lab_pin.sym} 75240 -41220 0 0 {name=p74296 lab=_55083_/C }
C {devices/lab_pin.sym} 75240 -41180 0 0 {name=p74297 lab=_55078_/D }
C {devices/lab_pin.sym} 75360 -41240 0 1 {name=p74298 lab=_55078_/X }
C {sky130_stdcells/and4_4.sym} 75300 -41240 0 0 {name=X_55078_ }
C {devices/lab_pin.sym} 75240 -41110 0 0 {name=p74299 lab=_60513_/A }
C {devices/lab_pin.sym} 75240 -41070 0 0 {name=p74300 lab=_61587_/B }
C {devices/lab_pin.sym} 75240 -41030 0 0 {name=p74301 lab=_84681_/Q }
C {devices/lab_pin.sym} 75360 -41070 0 1 {name=p74302 lab=_59955_/X }
C {sky130_stdcells/or3_4.sym} 75300 -41070 0 0 {name=X_59955_ }
C {devices/lab_pin.sym} 75210 -40930 0 0 {name=p74303 lab=_82317_/CLK }
C {devices/lab_pin.sym} 75210 -40910 0 0 {name=p74304 lab=_87987_/D }
C {devices/lab_pin.sym} 75390 -40930 0 1 {name=p74305 lab=_87987_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -40920 0 0 {name=X_87987_ }
C {devices/lab_pin.sym} 75260 -40790 0 0 {name=p74306 lab=_46920_/A }
C {devices/lab_pin.sym} 75340 -40790 0 1 {name=p74307 lab=_54442_/B }
C {sky130_stdcells/inv_2.sym} 75300 -40790 0 0 {name=X_46920_ }
C {devices/lab_pin.sym} 75260 -40670 0 0 {name=p74308 lab=_42024_/A }
C {devices/lab_pin.sym} 75340 -40670 0 1 {name=p74309 lab=_42043_/X }
C {sky130_stdcells/buf_2.sym} 75300 -40670 0 0 {name=X_42043_ }
C {devices/lab_pin.sym} 75220 -40570 0 0 {name=p74310 lab=_58891_/X }
C {devices/lab_pin.sym} 75220 -40530 0 0 {name=p74311 lab=_86087_/Q }
C {devices/lab_pin.sym} 75220 -40490 0 0 {name=p74312 lab=_58905_/X }
C {devices/lab_pin.sym} 75380 -40530 0 1 {name=p74313 lab=_58906_/Y }
C {sky130_stdcells/o21ai_4.sym} 75300 -40530 0 0 {name=X_58906_ }
C {devices/lab_pin.sym} 75220 -40410 0 0 {name=p74314 lab=_85519_/Q }
C {devices/lab_pin.sym} 75220 -40370 0 0 {name=p74315 lab=_54018_/X }
C {devices/lab_pin.sym} 75220 -40330 0 0 {name=p74316 lab=_54028_/Y }
C {devices/lab_pin.sym} 75380 -40370 0 1 {name=p74317 lab=_54029_/Y }
C {sky130_stdcells/o21ai_4.sym} 75300 -40370 0 0 {name=X_54029_ }
C {devices/lab_pin.sym} 75260 -40230 0 0 {name=p74318 lab=_77739_/Y }
C {devices/lab_pin.sym} 75340 -40230 0 1 {name=p74319 lab=_77742_/A }
C {sky130_stdcells/inv_2.sym} 75300 -40230 0 0 {name=X_77740_ }
C {devices/lab_pin.sym} 75240 -40120 0 0 {name=p74320 lab=_74958_/B }
C {devices/lab_pin.sym} 75240 -40080 0 0 {name=p74321 lab=_74961_/B }
C {devices/lab_pin.sym} 75360 -40100 0 1 {name=p74322 lab=_74952_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -40100 0 0 {name=X_74952_ }
C {devices/lab_pin.sym} 75220 -40000 0 0 {name=p74323 lab=_69603_/X }
C {devices/lab_pin.sym} 75220 -39960 0 0 {name=p74324 lab=_69902_/Y }
C {devices/lab_pin.sym} 75220 -39920 0 0 {name=p74325 lab=_70056_/X }
C {devices/lab_pin.sym} 75220 -39880 0 0 {name=p74326 lab=_70074_/Y }
C {devices/lab_pin.sym} 75380 -39940 0 1 {name=p74327 lab=_70075_/X }
C {sky130_stdcells/a211o_4.sym} 75300 -39940 0 0 {name=X_70075_ }
C {devices/lab_pin.sym} 75210 -39790 0 0 {name=p74328 lab=_83987_/CLK }
C {devices/lab_pin.sym} 75210 -39770 0 0 {name=p74329 lab=_44816_/Y }
C {devices/lab_pin.sym} 75390 -39790 0 1 {name=p74330 lab=_86938_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -39780 0 0 {name=X_86938_ }
C {devices/lab_pin.sym} 75260 -39650 0 0 {name=p74331 lab=_59615_/A }
C {devices/lab_pin.sym} 75340 -39650 0 1 {name=p74332 lab=_61277_/C }
C {sky130_stdcells/inv_2.sym} 75300 -39650 0 0 {name=X_59886_ }
C {devices/lab_pin.sym} 75260 -39530 0 0 {name=p74333 lab=_72909_/A }
C {devices/lab_pin.sym} 75340 -39530 0 1 {name=p74334 lab=_73903_/X }
C {sky130_stdcells/buf_2.sym} 75300 -39530 0 0 {name=X_73903_ }
C {devices/lab_pin.sym} 75260 -39410 0 0 {name=p74335 lab=_52713_/B }
C {devices/lab_pin.sym} 75340 -39410 0 1 {name=p74336 lab=_51022_/B }
C {sky130_stdcells/buf_2.sym} 75300 -39410 0 0 {name=X_46851_ }
C {devices/lab_pin.sym} 75220 -39310 0 0 {name=p74337 lab=_58835_/X }
C {devices/lab_pin.sym} 75220 -39270 0 0 {name=p74338 lab=_85452_/Q }
C {devices/lab_pin.sym} 75220 -39230 0 0 {name=p74339 lab=_58836_/X }
C {devices/lab_pin.sym} 75380 -39270 0 1 {name=p74340 lab=_58837_/Y }
C {sky130_stdcells/o21ai_4.sym} 75300 -39270 0 0 {name=X_58837_ }
C {devices/lab_pin.sym} 75240 -39140 0 0 {name=p74341 lab=_77671_/A }
C {devices/lab_pin.sym} 75240 -39100 0 0 {name=p74342 lab=_82206_/D }
C {devices/lab_pin.sym} 75360 -39120 0 1 {name=p74343 lab=_77671_/X }
C {sky130_stdcells/xor2_4.sym} 75300 -39120 0 0 {name=X_77671_ }
C {devices/lab_pin.sym} 75220 -39010 0 0 {name=p74344 lab=_74876_/Y }
C {devices/lab_pin.sym} 75220 -38970 0 0 {name=p74345 lab=_74881_/Y }
C {devices/lab_pin.sym} 75220 -38930 0 0 {name=p74346 lab=_74882_/Y }
C {devices/lab_pin.sym} 75380 -38970 0 1 {name=p74347 lab=_74887_/C }
C {sky130_stdcells/a21o_4.sym} 75300 -38970 0 0 {name=X_74883_ }
C {devices/lab_pin.sym} 75210 -38830 0 0 {name=p74348 lab=_86869_/CLK }
C {devices/lab_pin.sym} 75210 -38810 0 0 {name=p74349 lab=_86869_/D }
C {devices/lab_pin.sym} 75390 -38830 0 1 {name=p74350 lab=_63124_/B }
C {sky130_stdcells/dfxtp_4.sym} 75300 -38820 0 0 {name=X_86869_ }
C {devices/lab_pin.sym} 75260 -38690 0 0 {name=p74351 lab=clkbuf_6_7_0_CLK/X }
C {devices/lab_pin.sym} 75340 -38690 0 1 {name=p74352 lab=clkbuf_8_29_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 75300 -38690 0 0 {name=Xclkbuf_7_14_0_CLK }
C {devices/lab_pin.sym} 75240 -38580 0 0 {name=p74353 lab=_79418_/A }
C {devices/lab_pin.sym} 75240 -38540 0 0 {name=p74354 lab=_79410_/B }
C {devices/lab_pin.sym} 75360 -38560 0 1 {name=p74355 lab=_82839_/D }
C {sky130_stdcells/xnor2_4.sym} 75300 -38560 0 0 {name=X_79410_ }
C {devices/lab_pin.sym} 75240 -38440 0 0 {name=p74356 lab=_74691_/B }
C {devices/lab_pin.sym} 75240 -38400 0 0 {name=p74357 lab=_45832_/B }
C {devices/lab_pin.sym} 75360 -38420 0 1 {name=p74358 lab=_45802_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -38420 0 0 {name=X_45802_ }
C {devices/lab_pin.sym} 75240 -38300 0 0 {name=p74359 lab=_76618_/X }
C {devices/lab_pin.sym} 75240 -38260 0 0 {name=p74360 lab=_76621_/X }
C {devices/lab_pin.sym} 75360 -38280 0 1 {name=p74361 lab=_76623_/A }
C {sky130_stdcells/xor2_4.sym} 75300 -38280 0 0 {name=X_76622_ }
C {devices/lab_pin.sym} 75260 -38150 0 0 {name=p74362 lab=_49570_/A }
C {devices/lab_pin.sym} 75340 -38150 0 1 {name=p74363 lab=_49570_/X }
C {sky130_stdcells/buf_2.sym} 75300 -38150 0 0 {name=X_49570_ }
C {devices/lab_pin.sym} 75220 -38060 0 0 {name=p74364 lab=_73786_/X }
C {devices/lab_pin.sym} 75220 -38020 0 0 {name=p74365 lab=_84982_/Q }
C {devices/lab_pin.sym} 75220 -37980 0 0 {name=p74366 lab=_73740_/X }
C {devices/lab_pin.sym} 75220 -37940 0 0 {name=p74367 lab=_73833_/X }
C {devices/lab_pin.sym} 75380 -38000 0 1 {name=p74368 lab=_73835_/B }
C {sky130_stdcells/a211o_4.sym} 75300 -38000 0 0 {name=X_73834_ }
C {devices/lab_pin.sym} 75260 -37850 0 0 {name=p74369 lab=_82960_/Q }
C {devices/lab_pin.sym} 75340 -37850 0 1 {name=p74370 lab=_54362_/D }
C {sky130_stdcells/inv_2.sym} 75300 -37850 0 0 {name=X_46782_ }
C {devices/lab_pin.sym} 75220 -37760 0 0 {name=p74371 lab=_58755_/Y }
C {devices/lab_pin.sym} 75220 -37720 0 0 {name=p74372 lab=_58739_/X }
C {devices/lab_pin.sym} 75220 -37680 0 0 {name=p74373 lab=_58762_/X }
C {devices/lab_pin.sym} 75220 -37640 0 0 {name=p74374 lab=_58767_/X }
C {devices/lab_pin.sym} 75380 -37700 0 1 {name=p74375 lab=_84802_/D }
C {sky130_stdcells/a22oi_4.sym} 75300 -37700 0 0 {name=X_58768_ }
C {devices/lab_pin.sym} 75260 -37550 0 0 {name=p74376 lab=clkbuf_7_77_0_CLK/X }
C {devices/lab_pin.sym} 75340 -37550 0 1 {name=p74377 lab=clkbuf_8_154_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 75300 -37550 0 0 {name=Xclkbuf_8_154_0_CLK }
C {devices/lab_pin.sym} 75260 -37430 0 0 {name=p74378 lab=_43994_/A }
C {devices/lab_pin.sym} 75340 -37430 0 1 {name=p74379 lab=_43995_/A }
C {sky130_stdcells/buf_2.sym} 75300 -37430 0 0 {name=X_43994_ }
C {devices/lab_pin.sym} 75220 -37330 0 0 {name=p74380 lab=_48471_/X }
C {devices/lab_pin.sym} 75220 -37290 0 0 {name=p74381 lab=_47982_/A }
C {devices/lab_pin.sym} 75220 -37250 0 0 {name=p74382 lab=_48520_/Y }
C {devices/lab_pin.sym} 75380 -37290 0 1 {name=p74383 lab=_48522_/A }
C {sky130_stdcells/o21ai_4.sym} 75300 -37290 0 0 {name=X_48521_ }
C {devices/lab_pin.sym} 75220 -37170 0 0 {name=p74384 lab=_79331_/A }
C {devices/lab_pin.sym} 75220 -37130 0 0 {name=p74385 lab=_79331_/B }
C {devices/lab_pin.sym} 75220 -37090 0 0 {name=p74386 lab=_79340_/Y }
C {devices/lab_pin.sym} 75380 -37130 0 1 {name=p74387 lab=_79341_/Y }
C {sky130_stdcells/a21boi_4.sym} 75300 -37130 0 0 {name=X_79341_ }
C {devices/lab_pin.sym} 75260 -36990 0 0 {name=p74388 lab=_57027_/A }
C {devices/lab_pin.sym} 75340 -36990 0 1 {name=p74389 lab=_45733_/Y }
C {sky130_stdcells/inv_2.sym} 75300 -36990 0 0 {name=X_45733_ }
C {devices/lab_pin.sym} 75220 -36890 0 0 {name=p74390 lab=_57707_/Y }
C {devices/lab_pin.sym} 75220 -36850 0 0 {name=p74391 lab=_57714_/Y }
C {devices/lab_pin.sym} 75220 -36810 0 0 {name=p74392 lab=_57718_/X }
C {devices/lab_pin.sym} 75380 -36850 0 1 {name=p74393 lab=_57719_/X }
C {sky130_stdcells/a21o_4.sym} 75300 -36850 0 0 {name=X_57719_ }
C {devices/lab_pin.sym} 75260 -36710 0 0 {name=p74394 lab=_76552_/Y }
C {devices/lab_pin.sym} 75340 -36710 0 1 {name=p74395 lab=_76554_/C }
C {sky130_stdcells/inv_2.sym} 75300 -36710 0 0 {name=X_76553_ }
C {devices/lab_pin.sym} 75260 -36590 0 0 {name=p74396 lab=_42945_/A }
C {devices/lab_pin.sym} 75340 -36590 0 1 {name=p74397 lab=_42945_/X }
C {sky130_stdcells/buf_2.sym} 75300 -36590 0 0 {name=X_42945_ }
C {devices/lab_pin.sym} 75240 -36480 0 0 {name=p74398 lab=_73765_/A }
C {devices/lab_pin.sym} 75240 -36440 0 0 {name=p74399 lab=_73765_/B }
C {devices/lab_pin.sym} 75360 -36460 0 1 {name=p74400 lab=_73765_/X }
C {sky130_stdcells/xor2_4.sym} 75300 -36460 0 0 {name=X_73765_ }
C {devices/lab_pin.sym} 75220 -36350 0 0 {name=p74401 lab=_46412_/B }
C {devices/lab_pin.sym} 75220 -36310 0 0 {name=p74402 lab=_70961_/A }
C {devices/lab_pin.sym} 75220 -36270 0 0 {name=p74403 lab=_70976_/Y }
C {devices/lab_pin.sym} 75380 -36310 0 1 {name=p74404 lab=_70977_/Y }
C {sky130_stdcells/o21ai_4.sym} 75300 -36310 0 0 {name=X_70977_ }
C {devices/lab_pin.sym} 75240 -36180 0 0 {name=p74405 lab=_58699_/A }
C {devices/lab_pin.sym} 75240 -36140 0 0 {name=p74406 lab=_58699_/B }
C {devices/lab_pin.sym} 75360 -36160 0 1 {name=p74407 lab=_58699_/Y }
C {sky130_stdcells/nor2_4.sym} 75300 -36160 0 0 {name=X_58699_ }
C {devices/lab_pin.sym} 75240 -36040 0 0 {name=p74408 lab=_75536_/A }
C {devices/lab_pin.sym} 75240 -36000 0 0 {name=p74409 lab=_75503_/Y }
C {devices/lab_pin.sym} 75360 -36020 0 1 {name=p74410 lab=_75504_/X }
C {sky130_stdcells/and2_4.sym} 75300 -36020 0 0 {name=X_75504_ }
C {devices/lab_pin.sym} 75240 -35910 0 0 {name=p74411 lab=_48752_/A }
C {devices/lab_pin.sym} 75240 -35870 0 0 {name=p74412 lab=_48489_/B }
C {devices/lab_pin.sym} 75240 -35830 0 0 {name=p74413 lab=_48476_/C }
C {devices/lab_pin.sym} 75360 -35870 0 1 {name=p74414 lab=_48452_/X }
C {sky130_stdcells/and3_4.sym} 75300 -35870 0 0 {name=X_48452_ }
C {devices/lab_pin.sym} 75240 -35750 0 0 {name=p74415 lab=_72714_/A }
C {devices/lab_pin.sym} 75240 -35710 0 0 {name=p74416 lab=_72714_/B }
C {devices/lab_pin.sym} 75240 -35670 0 0 {name=p74417 lab=_56907_/X }
C {devices/lab_pin.sym} 75360 -35710 0 1 {name=p74418 lab=_72716_/Y }
C {sky130_stdcells/nand3_4.sym} 75300 -35710 0 0 {name=X_72716_ }
C {devices/lab_pin.sym} 75240 -35580 0 0 {name=p74419 lab=_60632_/X }
C {devices/lab_pin.sym} 75240 -35540 0 0 {name=p74420 lab=_60624_/X }
C {devices/lab_pin.sym} 75360 -35560 0 1 {name=p74421 lab=_60731_/A }
C {sky130_stdcells/nor2_4.sym} 75300 -35560 0 0 {name=X_60730_ }
C {devices/lab_pin.sym} 75240 -35460 0 0 {name=p74422 lab=_79247_/X }
C {devices/lab_pin.sym} 75240 -35420 0 0 {name=p74423 lab=_79270_/X }
C {devices/lab_pin.sym} 75240 -35380 0 0 {name=p74424 lab=_79248_/Y }
C {devices/lab_pin.sym} 75240 -35340 0 0 {name=p74425 lab=_79271_/Y }
C {devices/lab_pin.sym} 75360 -35400 0 1 {name=p74426 lab=_79272_/Y }
C {sky130_stdcells/nand4_4.sym} 75300 -35400 0 0 {name=X_79272_ }
C {devices/lab_pin.sym} 75220 -35270 0 0 {name=p74427 lab=_45661_/X }
C {devices/lab_pin.sym} 75220 -35230 0 0 {name=p74428 lab=_45663_/Y }
C {devices/lab_pin.sym} 75220 -35190 0 0 {name=p74429 lab=_45602_/X }
C {devices/lab_pin.sym} 75380 -35230 0 1 {name=p74430 lab=_45664_/X }
C {sky130_stdcells/a21o_4.sym} 75300 -35230 0 0 {name=X_45664_ }
C {devices/lab_pin.sym} 75220 -35110 0 0 {name=p74431 lab=_76448_/B }
C {devices/lab_pin.sym} 75220 -35070 0 0 {name=p74432 lab=_76482_/X }
C {devices/lab_pin.sym} 75220 -35030 0 0 {name=p74433 lab=_76483_/Y }
C {devices/lab_pin.sym} 75380 -35070 0 1 {name=p74434 lab=_76484_/Y }
C {sky130_stdcells/a21oi_4.sym} 75300 -35070 0 0 {name=X_76484_ }
C {devices/lab_pin.sym} 75220 -34970 0 0 {name=p74435 lab=_42874_/X }
C {devices/lab_pin.sym} 75220 -34930 0 0 {name=p74436 lab=_42875_/X }
C {devices/lab_pin.sym} 75220 -34890 0 0 {name=p74437 lab=_41596_/X }
C {devices/lab_pin.sym} 75220 -34850 0 0 {name=p74438 lab=_67188_/B }
C {devices/lab_pin.sym} 75220 -34810 0 0 {name=p74439 lab=_42858_/X }
C {devices/lab_pin.sym} 75380 -34890 0 1 {name=p74440 lab=_42877_/A }
C {sky130_stdcells/o32ai_4.sym} 75300 -34890 0 0 {name=X_42876_ }
C {devices/lab_pin.sym} 75260 -34730 0 0 {name=p74441 lab=clkbuf_9_271_0_CLK/A }
C {devices/lab_pin.sym} 75340 -34730 0 1 {name=p74442 lab=clkbuf_9_270_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 75300 -34730 0 0 {name=Xclkbuf_9_270_0_CLK }
C {devices/lab_pin.sym} 75220 -34630 0 0 {name=p74443 lab=_70125_/D }
C {devices/lab_pin.sym} 75220 -34590 0 0 {name=p74444 lab=_86754_/D }
C {devices/lab_pin.sym} 75220 -34550 0 0 {name=p74445 lab=_73695_/X }
C {devices/lab_pin.sym} 75380 -34590 0 1 {name=p74446 lab=_83140_/D }
C {sky130_stdcells/o21ai_4.sym} 75300 -34590 0 0 {name=X_73696_ }
C {devices/lab_pin.sym} 75260 -34450 0 0 {name=p74447 lab=clkbuf_7_28_0_CLK/A }
C {devices/lab_pin.sym} 75340 -34450 0 1 {name=p74448 lab=clkbuf_8_59_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 75300 -34450 0 0 {name=Xclkbuf_7_29_0_CLK }
C {devices/lab_pin.sym} 75260 -34330 0 0 {name=p74449 lab=_47403_/A }
C {devices/lab_pin.sym} 75340 -34330 0 1 {name=p74450 lab=_53025_/B }
C {sky130_stdcells/buf_2.sym} 75300 -34330 0 0 {name=X_47403_ }
C {devices/lab_pin.sym} 75240 -34220 0 0 {name=p74451 lab=_78222_/Y }
C {devices/lab_pin.sym} 75240 -34180 0 0 {name=p74452 lab=_78220_/C }
C {devices/lab_pin.sym} 75360 -34200 0 1 {name=p74453 lab=_78223_/X }
C {sky130_stdcells/and2_4.sym} 75300 -34200 0 0 {name=X_78223_ }
C {devices/lab_pin.sym} 75220 -34110 0 0 {name=p74454 lab=_44588_/X }
C {devices/lab_pin.sym} 75220 -34070 0 0 {name=p74455 lab=_44589_/X }
C {devices/lab_pin.sym} 75220 -34030 0 0 {name=p74456 lab=_40976_/X }
C {devices/lab_pin.sym} 75220 -33990 0 0 {name=p74457 lab=_87031_/Q }
C {devices/lab_pin.sym} 75220 -33950 0 0 {name=p74458 lab=_44590_/X }
C {devices/lab_pin.sym} 75380 -34030 0 1 {name=p74459 lab=_44616_/A }
C {sky130_stdcells/o32ai_4.sym} 75300 -34030 0 0 {name=X_44615_ }
C {devices/lab_pin.sym} 75260 -33870 0 0 {name=p74460 lab=clkbuf_7_84_0_CLK/X }
C {devices/lab_pin.sym} 75340 -33870 0 1 {name=p74461 lab=clkbuf_9_339_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 75300 -33870 0 0 {name=Xclkbuf_8_169_0_CLK }
C {devices/lab_pin.sym} 75240 -33780 0 0 {name=p74462 lab=_75400_/X }
C {devices/lab_pin.sym} 75240 -33740 0 0 {name=p74463 lab=_75435_/B }
C {devices/lab_pin.sym} 75240 -33700 0 0 {name=p74464 lab=_75401_/Y }
C {devices/lab_pin.sym} 75240 -33660 0 0 {name=p74465 lab=_75435_/D }
C {devices/lab_pin.sym} 75360 -33720 0 1 {name=p74466 lab=_75436_/A }
C {sky130_stdcells/and4_4.sym} 75300 -33720 0 0 {name=X_75435_ }
C {devices/lab_pin.sym} 75260 -33570 0 0 {name=p74467 lab=_41826_/Y }
C {devices/lab_pin.sym} 75340 -33570 0 1 {name=p74468 lab=_88134_/D }
C {sky130_stdcells/inv_2.sym} 75300 -33570 0 0 {name=X_41827_ }
C {devices/lab_pin.sym} 75260 -33450 0 0 {name=p74469 lab=_48193_/X }
C {devices/lab_pin.sym} 75340 -33450 0 1 {name=p74470 lab=_48383_/X }
C {sky130_stdcells/buf_2.sym} 75300 -33450 0 0 {name=X_48383_ }
C {devices/lab_pin.sym} 75240 -33360 0 0 {name=p74471 lab=_60694_/B }
C {devices/lab_pin.sym} 75240 -33320 0 0 {name=p74472 lab=_60654_/X }
C {devices/lab_pin.sym} 75240 -33280 0 0 {name=p74473 lab=_60697_/B }
C {devices/lab_pin.sym} 75240 -33240 0 0 {name=p74474 lab=_60660_/X }
C {devices/lab_pin.sym} 75360 -33300 0 1 {name=p74475 lab=_60671_/A }
C {sky130_stdcells/nand4_4.sym} 75300 -33300 0 0 {name=X_60661_ }
C {devices/lab_pin.sym} 75260 -33150 0 0 {name=p74476 lab=_44231_/A }
C {devices/lab_pin.sym} 75340 -33150 0 1 {name=p74477 lab=_72656_/B }
C {sky130_stdcells/buf_2.sym} 75300 -33150 0 0 {name=X_72647_ }
C {devices/lab_pin.sym} 75260 -33030 0 0 {name=p74478 lab=clkbuf_9_82_0_CLK/X }
C {devices/lab_pin.sym} 75340 -33030 0 1 {name=p74479 lab=_81671_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 75300 -33030 0 0 {name=Xclkbuf_10_164_0_CLK }
C {devices/lab_pin.sym} 75260 -32910 0 0 {name=p74480 lab=_45595_/A }
C {devices/lab_pin.sym} 75340 -32910 0 1 {name=p74481 lab=_45595_/Y }
C {sky130_stdcells/inv_2.sym} 75300 -32910 0 0 {name=X_45595_ }
C {devices/lab_pin.sym} 75260 -32790 0 0 {name=p74482 lab=_62471_/A }
C {devices/lab_pin.sym} 75340 -32790 0 1 {name=p74483 lab=_62431_/D }
C {sky130_stdcells/buf_2.sym} 75300 -32790 0 0 {name=X_62400_ }
C {devices/lab_pin.sym} 75260 -32670 0 0 {name=p74484 lab=_47334_/A }
C {devices/lab_pin.sym} 75340 -32670 0 1 {name=p74485 lab=_47334_/Y }
C {sky130_stdcells/inv_2.sym} 75300 -32670 0 0 {name=X_47334_ }
C {devices/lab_pin.sym} 75260 -32550 0 0 {name=p74486 lab=clkbuf_9_397_0_CLK/X }
C {devices/lab_pin.sym} 75340 -32550 0 1 {name=p74487 lab=_82589_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 75300 -32550 0 0 {name=Xclkbuf_10_794_0_CLK }
C {devices/lab_pin.sym} 75240 -32440 0 0 {name=p74488 lab=_78154_/A }
C {devices/lab_pin.sym} 75240 -32400 0 0 {name=p74489 lab=_78154_/B }
C {devices/lab_pin.sym} 75360 -32420 0 1 {name=p74490 lab=_78154_/X }
C {sky130_stdcells/or2_4.sym} 75300 -32420 0 0 {name=X_78154_ }
C {devices/lab_pin.sym} 75260 -32290 0 0 {name=p74491 lab=_44545_/Y }
C {devices/lab_pin.sym} 75340 -32290 0 1 {name=p74492 lab=_44546_/Y }
C {sky130_stdcells/inv_2.sym} 75300 -32290 0 0 {name=X_44546_ }
C {devices/lab_pin.sym} 75260 -32170 0 0 {name=p74493 lab=_75354_/X }
C {devices/lab_pin.sym} 75340 -32170 0 1 {name=p74494 lab=_75366_/Y }
C {sky130_stdcells/inv_2.sym} 75300 -32170 0 0 {name=X_75366_ }
C {devices/lab_pin.sym} 75240 -32080 0 0 {name=p74495 lab=_63380_/A }
C {devices/lab_pin.sym} 75240 -32040 0 0 {name=p74496 lab=_63389_/B }
C {devices/lab_pin.sym} 75240 -32000 0 0 {name=p74497 lab=_63418_/C }
C {devices/lab_pin.sym} 75240 -31960 0 0 {name=p74498 lab=_63389_/D }
C {devices/lab_pin.sym} 75360 -32020 0 1 {name=p74499 lab=_63380_/Y }
C {sky130_stdcells/nand4_4.sym} 75300 -32020 0 0 {name=X_63380_ }
C {devices/lab_pin.sym} 75220 -31910 0 0 {name=p74500 lab=_41753_/X }
C {devices/lab_pin.sym} 75220 -31870 0 0 {name=p74501 lab=_41754_/X }
C {devices/lab_pin.sym} 75220 -31830 0 0 {name=p74502 lab=_41757_/X }
C {devices/lab_pin.sym} 75220 -31790 0 0 {name=p74503 lab=_88155_/Q }
C {devices/lab_pin.sym} 75220 -31750 0 0 {name=p74504 lab=_41736_/X }
C {devices/lab_pin.sym} 75380 -31830 0 1 {name=p74505 lab=_41759_/A }
C {sky130_stdcells/o32ai_4.sym} 75300 -31830 0 0 {name=X_41758_ }
C {devices/lab_pin.sym} 75220 -31700 0 0 {name=p74506 lab=_79385_/B }
C {devices/lab_pin.sym} 75220 -31660 0 0 {name=p74507 lab=_61252_/X }
C {devices/lab_pin.sym} 75220 -31620 0 0 {name=p74508 lab=_72570_/Y }
C {devices/lab_pin.sym} 75220 -31580 0 0 {name=p74509 lab=_72577_/Y }
C {devices/lab_pin.sym} 75380 -31640 0 1 {name=p74510 lab=_72578_/X }
C {sky130_stdcells/o22a_4.sym} 75300 -31640 0 0 {name=X_72578_ }
C {devices/lab_pin.sym} 75260 -31490 0 0 {name=p74511 lab=_60591_/X }
C {devices/lab_pin.sym} 75340 -31490 0 1 {name=p74512 lab=_84592_/D }
C {sky130_stdcells/inv_2.sym} 75300 -31490 0 0 {name=X_60592_ }
C {devices/lab_pin.sym} 75240 -31380 0 0 {name=p74513 lab=_77105_/A }
C {devices/lab_pin.sym} 75240 -31340 0 0 {name=p74514 lab=_81913_/Q }
C {devices/lab_pin.sym} 75360 -31360 0 1 {name=p74515 lab=_77112_/C }
C {sky130_stdcells/nand2_4.sym} 75300 -31360 0 0 {name=X_77105_ }
C {devices/lab_pin.sym} 75240 -31250 0 0 {name=p74516 lab=_74325_/A }
C {devices/lab_pin.sym} 75240 -31210 0 0 {name=p74517 lab=_74325_/B }
C {devices/lab_pin.sym} 75240 -31170 0 0 {name=p74518 lab=_74317_/C }
C {devices/lab_pin.sym} 75360 -31210 0 1 {name=p74519 lab=_74317_/Y }
C {sky130_stdcells/nand3_4.sym} 75300 -31210 0 0 {name=X_74317_ }
C {devices/lab_pin.sym} 75260 -31070 0 0 {name=p74520 lab=_62236_/A }
C {devices/lab_pin.sym} 75340 -31070 0 1 {name=p74521 lab=_62332_/B }
C {sky130_stdcells/buf_2.sym} 75300 -31070 0 0 {name=X_62331_ }
C {devices/lab_pin.sym} 75260 -30950 0 0 {name=p74522 lab=_40709_/A }
C {devices/lab_pin.sym} 75340 -30950 0 1 {name=p74523 lab=_40709_/Y }
C {sky130_stdcells/inv_2.sym} 75300 -30950 0 0 {name=X_40709_ }
C {devices/lab_pin.sym} 75240 -30860 0 0 {name=p74524 lab=_47246_/X }
C {devices/lab_pin.sym} 75240 -30820 0 0 {name=p74525 lab=_47228_/B }
C {devices/lab_pin.sym} 75240 -30780 0 0 {name=p74526 lab=_47234_/X }
C {devices/lab_pin.sym} 75240 -30740 0 0 {name=p74527 lab=_52948_/D }
C {devices/lab_pin.sym} 75360 -30800 0 1 {name=p74528 lab=_47265_/X }
C {sky130_stdcells/and4_4.sym} 75300 -30800 0 0 {name=X_47265_ }
C {devices/lab_pin.sym} 75260 -30650 0 0 {name=p74529 lab=clkbuf_9_285_0_CLK/A }
C {devices/lab_pin.sym} 75340 -30650 0 1 {name=p74530 lab=clkbuf_9_285_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 75300 -30650 0 0 {name=Xclkbuf_9_285_0_CLK }
C {devices/lab_pin.sym} 75240 -30540 0 0 {name=p74531 lab=_71528_/X }
C {devices/lab_pin.sym} 75240 -30500 0 0 {name=p74532 lab=_71137_/B }
C {devices/lab_pin.sym} 75360 -30520 0 1 {name=p74533 lab=_71530_/A }
C {sky130_stdcells/nor2_4.sym} 75300 -30520 0 0 {name=X_71529_ }
C {devices/lab_pin.sym} 75240 -30400 0 0 {name=p74534 lab=_78085_/A }
C {devices/lab_pin.sym} 75240 -30360 0 0 {name=p74535 lab=_78084_/X }
C {devices/lab_pin.sym} 75360 -30380 0 1 {name=p74536 lab=_78085_/Y }
C {sky130_stdcells/xnor2_4.sym} 75300 -30380 0 0 {name=X_78085_ }
C {devices/lab_pin.sym} 75220 -30290 0 0 {name=p74537 lab=_44447_/X }
C {devices/lab_pin.sym} 75220 -30250 0 0 {name=p74538 lab=_44448_/X }
C {devices/lab_pin.sym} 75220 -30210 0 0 {name=p74539 lab=_41192_/X }
C {devices/lab_pin.sym} 75220 -30170 0 0 {name=p74540 lab=_87088_/Q }
C {devices/lab_pin.sym} 75220 -30130 0 0 {name=p74541 lab=_44449_/X }
C {devices/lab_pin.sym} 75380 -30210 0 1 {name=p74542 lab=_44478_/A }
C {sky130_stdcells/o32ai_4.sym} 75300 -30210 0 0 {name=X_44477_ }
C {devices/lab_pin.sym} 75240 -30060 0 0 {name=p74543 lab=_75297_/A }
C {devices/lab_pin.sym} 75240 -30020 0 0 {name=p74544 lab=_81041_/D }
C {devices/lab_pin.sym} 75360 -30040 0 1 {name=p74545 lab=_75297_/X }
C {sky130_stdcells/xor2_4.sym} 75300 -30040 0 0 {name=X_75297_ }
C {devices/lab_pin.sym} 75220 -29950 0 0 {name=p74546 lab=_41672_/X }
C {devices/lab_pin.sym} 75220 -29910 0 0 {name=p74547 lab=_41673_/X }
C {devices/lab_pin.sym} 75220 -29870 0 0 {name=p74548 lab=_41688_/X }
C {devices/lab_pin.sym} 75220 -29830 0 0 {name=p74549 lab=_67575_/B }
C {devices/lab_pin.sym} 75220 -29790 0 0 {name=p74550 lab=_41668_/X }
C {devices/lab_pin.sym} 75380 -29870 0 1 {name=p74551 lab=_41690_/A }
C {sky130_stdcells/o32ai_4.sym} 75300 -29870 0 0 {name=X_41689_ }
C {devices/lab_pin.sym} 75260 -29710 0 0 {name=p74552 lab=_48898_/A }
C {devices/lab_pin.sym} 75340 -29710 0 1 {name=p74553 lab=_49007_/A }
C {sky130_stdcells/buf_2.sym} 75300 -29710 0 0 {name=X_49004_ }
C {devices/lab_pin.sym} 75260 -29590 0 0 {name=p74554 lab=_46216_/A }
C {devices/lab_pin.sym} 75340 -29590 0 1 {name=p74555 lab=_46216_/Y }
C {sky130_stdcells/inv_2.sym} 75300 -29590 0 0 {name=X_46216_ }
C {devices/lab_pin.sym} 75220 -29500 0 0 {name=p74556 lab=_64691_/X }
C {devices/lab_pin.sym} 75220 -29460 0 0 {name=p74557 lab=_86128_/Q }
C {devices/lab_pin.sym} 75220 -29420 0 0 {name=p74558 lab=_64972_/X }
C {devices/lab_pin.sym} 75220 -29380 0 0 {name=p74559 lab=_65049_/X }
C {devices/lab_pin.sym} 75380 -29440 0 1 {name=p74560 lab=_65050_/X }
C {sky130_stdcells/a211o_4.sym} 75300 -29440 0 0 {name=X_65050_ }
C {sky130_stdcells/decap_3.sym} 75300 -29260 0 0 {name=XPHY_280 }
C {devices/lab_pin.sym} 75240 -29120 0 0 {name=p74561 lab=_77036_/A }
C {devices/lab_pin.sym} 75240 -29080 0 0 {name=p74562 lab=_77036_/B }
C {devices/lab_pin.sym} 75360 -29100 0 1 {name=p74563 lab=_77036_/Y }
C {sky130_stdcells/nor2_4.sym} 75300 -29100 0 0 {name=X_77036_ }
C {devices/lab_pin.sym} 75260 -28970 0 0 {name=p74564 lab=_43428_/A }
C {devices/lab_pin.sym} 75340 -28970 0 1 {name=p74565 lab=_43428_/Y }
C {sky130_stdcells/inv_2.sym} 75300 -28970 0 0 {name=X_43428_ }
C {devices/lab_pin.sym} 75260 -28850 0 0 {name=p74566 lab=clkbuf_9_89_0_CLK/X }
C {devices/lab_pin.sym} 75340 -28850 0 1 {name=p74567 lab=_81284_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 75300 -28850 0 0 {name=Xclkbuf_10_179_0_CLK }
C {devices/lab_pin.sym} 75240 -28760 0 0 {name=p74568 lab=_61365_/X }
C {devices/lab_pin.sym} 75240 -28720 0 0 {name=p74569 lab=_62560_/B }
C {devices/lab_pin.sym} 75240 -28680 0 0 {name=p74570 lab=_62560_/C }
C {devices/lab_pin.sym} 75240 -28640 0 0 {name=p74571 lab=_62211_/D }
C {devices/lab_pin.sym} 75360 -28700 0 1 {name=p74572 lab=_62262_/Y }
C {sky130_stdcells/nand4_4.sym} 75300 -28700 0 0 {name=X_62262_ }
C {devices/lab_pin.sym} 75220 -28570 0 0 {name=p74573 lab=_74245_/X }
C {devices/lab_pin.sym} 75220 -28530 0 0 {name=p74574 lab=_74247_/X }
C {devices/lab_pin.sym} 75220 -28490 0 0 {name=p74575 lab=_72741_/X }
C {devices/lab_pin.sym} 75380 -28530 0 1 {name=p74576 lab=_74248_/X }
C {sky130_stdcells/a21o_4.sym} 75300 -28530 0 0 {name=X_74248_ }
C {sky130_stdcells/decap_3.sym} 75300 -28360 0 0 {name=XPHY_291 }
C {devices/lab_pin.sym} 75240 -28220 0 0 {name=p74577 lab=_47196_/A }
C {devices/lab_pin.sym} 75240 -28180 0 0 {name=p74578 lab=_47195_/X }
C {devices/lab_pin.sym} 75360 -28200 0 1 {name=p74579 lab=_47196_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -28200 0 0 {name=X_47196_ }
C {devices/lab_pin.sym} 75240 -28100 0 0 {name=p74580 lab=_63997_/Y }
C {devices/lab_pin.sym} 75240 -28060 0 0 {name=p74581 lab=_63998_/Y }
C {devices/lab_pin.sym} 75240 -28020 0 0 {name=p74582 lab=_63999_/Y }
C {devices/lab_pin.sym} 75240 -27980 0 0 {name=p74583 lab=_64001_/D }
C {devices/lab_pin.sym} 75360 -28040 0 1 {name=p74584 lab=_64001_/X }
C {sky130_stdcells/and4_4.sym} 75300 -28040 0 0 {name=X_64001_ }
C {devices/lab_pin.sym} 75220 -27920 0 0 {name=p74585 lab=_75909_/A }
C {devices/lab_pin.sym} 75220 -27880 0 0 {name=p74586 lab=_60719_/X }
C {devices/lab_pin.sym} 75220 -27840 0 0 {name=p74587 lab=_61208_/Y }
C {devices/lab_pin.sym} 75220 -27800 0 0 {name=p74588 lab=_61212_/Y }
C {devices/lab_pin.sym} 75380 -27860 0 1 {name=p74589 lab=_84507_/D }
C {sky130_stdcells/o22a_4.sym} 75300 -27860 0 0 {name=X_61213_ }
C {devices/lab_pin.sym} 75260 -27710 0 0 {name=p74590 lab=_49793_/A }
C {devices/lab_pin.sym} 75340 -27710 0 1 {name=p74591 lab=_49520_/A }
C {sky130_stdcells/buf_2.sym} 75300 -27710 0 0 {name=X_46147_ }
C {devices/lab_pin.sym} 75220 -27620 0 0 {name=p74592 lab=_41356_/X }
C {devices/lab_pin.sym} 75220 -27580 0 0 {name=p74593 lab=_43356_/X }
C {devices/lab_pin.sym} 75220 -27540 0 0 {name=p74594 lab=_87462_/Q }
C {devices/lab_pin.sym} 75220 -27500 0 0 {name=p74595 lab=_43357_/X }
C {devices/lab_pin.sym} 75380 -27560 0 1 {name=p74596 lab=_87462_/D }
C {sky130_stdcells/a2bb2o_4.sym} 75300 -27560 0 0 {name=X_43359_ }
C {devices/lab_pin.sym} 75260 -27410 0 0 {name=p74597 lab=_44274_/D }
C {devices/lab_pin.sym} 75340 -27410 0 1 {name=p74598 lab=_56456_/A }
C {sky130_stdcells/buf_2.sym} 75300 -27410 0 0 {name=Xpsn_inst_psn_buff_18 }
C {devices/lab_pin.sym} 75260 -27290 0 0 {name=p74599 lab=_62193_/A }
C {devices/lab_pin.sym} 75340 -27290 0 1 {name=p74600 lab=_62618_/D }
C {sky130_stdcells/buf_2.sym} 75300 -27290 0 0 {name=X_62193_ }
C {devices/lab_pin.sym} 75240 -27180 0 0 {name=p74601 lab=_74176_/X }
C {devices/lab_pin.sym} 75240 -27140 0 0 {name=p74602 lab=_74179_/B }
C {devices/lab_pin.sym} 75360 -27160 0 1 {name=p74603 lab=_74180_/B }
C {sky130_stdcells/nand2_4.sym} 75300 -27160 0 0 {name=X_74179_ }
C {devices/lab_pin.sym} 75260 -27030 0 0 {name=p74604 lab=_50212_/A }
C {devices/lab_pin.sym} 75340 -27030 0 1 {name=p74605 lab=_50221_/A }
C {sky130_stdcells/buf_8.sym} 75300 -27030 0 0 {name=Xpsn_inst_psn_buff_29 }
C {devices/lab_pin.sym} 75260 -26910 0 0 {name=p74606 lab=_61144_/A }
C {devices/lab_pin.sym} 75340 -26910 0 1 {name=p74607 lab=_64221_/A }
C {sky130_stdcells/buf_2.sym} 75300 -26910 0 0 {name=X_61144_ }
C {devices/lab_pin.sym} 75260 -26790 0 0 {name=p74608 lab=clkbuf_7_53_0_CLK/X }
C {devices/lab_pin.sym} 75340 -26790 0 1 {name=p74609 lab=clkbuf_9_214_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 75300 -26790 0 0 {name=Xclkbuf_8_107_0_CLK }
C {devices/lab_pin.sym} 75260 -26670 0 0 {name=p74610 lab=_46077_/Y }
C {devices/lab_pin.sym} 75340 -26670 0 1 {name=p74611 lab=_46078_/Y }
C {sky130_stdcells/inv_2.sym} 75300 -26670 0 0 {name=X_46078_ }
C {devices/lab_pin.sym} 75260 -26550 0 0 {name=p74612 lab=clkbuf_9_51_0_CLK/X }
C {devices/lab_pin.sym} 75340 -26550 0 1 {name=p74613 lab=_84534_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 75300 -26550 0 0 {name=Xclkbuf_10_102_0_CLK }
C {devices/lab_pin.sym} 75260 -26430 0 0 {name=p74614 lab=_78986_/X }
C {devices/lab_pin.sym} 75340 -26430 0 1 {name=p74615 lab=_78987_/Y }
C {sky130_stdcells/inv_2.sym} 75300 -26430 0 0 {name=X_78987_ }
C {devices/lab_pin.sym} 75260 -26310 0 0 {name=p74616 lab=_49906_/A }
C {devices/lab_pin.sym} 75340 -26310 0 1 {name=p74617 lab=_49906_/X }
C {sky130_stdcells/buf_2.sym} 75300 -26310 0 0 {name=X_49906_ }
C {devices/lab_pin.sym} 75220 -26210 0 0 {name=p74618 lab=_85209_/Q }
C {devices/lab_pin.sym} 75220 -26170 0 0 {name=p74619 lab=_45027_/X }
C {devices/lab_pin.sym} 75220 -26130 0 0 {name=p74620 lab=_45028_/X }
C {devices/lab_pin.sym} 75380 -26170 0 1 {name=p74621 lab=_45029_/Y }
C {sky130_stdcells/o21ai_4.sym} 75300 -26170 0 0 {name=X_45029_ }
C {devices/lab_pin.sym} 75220 -26050 0 0 {name=p74622 lab=_83963_/Q }
C {devices/lab_pin.sym} 75220 -26010 0 0 {name=p74623 lab=_68713_/X }
C {devices/lab_pin.sym} 75220 -25970 0 0 {name=p74624 lab=_68739_/X }
C {devices/lab_pin.sym} 75380 -26010 0 1 {name=p74625 lab=_83963_/D }
C {sky130_stdcells/a21bo_4.sym} 75300 -26010 0 0 {name=X_68740_ }
C {devices/lab_pin.sym} 75260 -25870 0 0 {name=p74626 lab=clkbuf_9_366_0_CLK/X }
C {devices/lab_pin.sym} 75340 -25870 0 1 {name=p74627 lab=_87032_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 75300 -25870 0 0 {name=Xclkbuf_10_732_0_CLK }
C {devices/lab_pin.sym} 75220 -25780 0 0 {name=p74628 lab=_65924_/X }
C {devices/lab_pin.sym} 75220 -25740 0 0 {name=p74629 lab=_84990_/Q }
C {devices/lab_pin.sym} 75220 -25700 0 0 {name=p74630 lab=_65950_/X }
C {devices/lab_pin.sym} 75220 -25660 0 0 {name=p74631 lab=_65951_/X }
C {devices/lab_pin.sym} 75380 -25720 0 1 {name=p74632 lab=_65952_/X }
C {sky130_stdcells/a211o_4.sym} 75300 -25720 0 0 {name=X_65952_ }
C {devices/lab_pin.sym} 75240 -25600 0 0 {name=p74633 lab=_59639_/A }
C {devices/lab_pin.sym} 75240 -25560 0 0 {name=p74634 lab=_61075_/B }
C {devices/lab_pin.sym} 75240 -25520 0 0 {name=p74635 lab=_61075_/C }
C {devices/lab_pin.sym} 75240 -25480 0 0 {name=p74636 lab=_59552_/B }
C {devices/lab_pin.sym} 75360 -25540 0 1 {name=p74637 lab=_61075_/X }
C {sky130_stdcells/and4_4.sym} 75300 -25540 0 0 {name=X_61075_ }
C {devices/lab_pin.sym} 75260 -25390 0 0 {name=p74638 lab=_77927_/B }
C {devices/lab_pin.sym} 75340 -25390 0 1 {name=p74639 lab=_81944_/D }
C {sky130_stdcells/inv_2.sym} 75300 -25390 0 0 {name=X_77938_ }
C {devices/lab_pin.sym} 75260 -25270 0 0 {name=p74640 lab=_64903_/A }
C {devices/lab_pin.sym} 75340 -25270 0 1 {name=p74641 lab=_64904_/A }
C {sky130_stdcells/buf_2.sym} 75300 -25270 0 0 {name=X_64903_ }
C {devices/lab_pin.sym} 75260 -25150 0 0 {name=p74642 lab=_60025_/X }
C {devices/lab_pin.sym} 75340 -25150 0 1 {name=p74643 lab=_60027_/A }
C {sky130_stdcells/buf_2.sym} 75300 -25150 0 0 {name=X_60026_ }
C {devices/lab_pin.sym} 75240 -25040 0 0 {name=p74644 lab=_49827_/X }
C {devices/lab_pin.sym} 75240 -25000 0 0 {name=p74645 lab=_53050_/B }
C {devices/lab_pin.sym} 75360 -25020 0 1 {name=p74646 lab=_49837_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -25020 0 0 {name=X_49837_ }
C {devices/lab_pin.sym} 75260 -24890 0 0 {name=p74647 lab=_68386_/A }
C {devices/lab_pin.sym} 75340 -24890 0 1 {name=p74648 lab=_68746_/A }
C {sky130_stdcells/buf_2.sym} 75300 -24890 0 0 {name=X_68671_ }
C {devices/lab_pin.sym} 75260 -24770 0 0 {name=p74649 lab=clkbuf_9_222_0_CLK/A }
C {devices/lab_pin.sym} 75340 -24770 0 1 {name=p74650 lab=clkbuf_9_223_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 75300 -24770 0 0 {name=Xclkbuf_9_223_0_CLK }
C {devices/lab_pin.sym} 75220 -24680 0 0 {name=p74651 lab=_65824_/X }
C {devices/lab_pin.sym} 75220 -24640 0 0 {name=p74652 lab=_83051_/Q }
C {devices/lab_pin.sym} 75220 -24600 0 0 {name=p74653 lab=_65707_/X }
C {devices/lab_pin.sym} 75220 -24560 0 0 {name=p74654 lab=_65882_/X }
C {devices/lab_pin.sym} 75380 -24620 0 1 {name=p74655 lab=_65884_/B }
C {sky130_stdcells/a211o_4.sym} 75300 -24620 0 0 {name=X_65883_ }
C {devices/lab_pin.sym} 75240 -24480 0 0 {name=p74656 lab=_77869_/A }
C {devices/lab_pin.sym} 75240 -24440 0 0 {name=p74657 lab=_77868_/Y }
C {devices/lab_pin.sym} 75360 -24460 0 1 {name=p74658 lab=_82033_/D }
C {sky130_stdcells/xnor2_4.sym} 75300 -24460 0 0 {name=X_77869_ }
C {devices/lab_pin.sym} 75220 -24360 0 0 {name=p74659 lab=_86963_/Q }
C {devices/lab_pin.sym} 75220 -24320 0 0 {name=p74660 lab=_67551_/X }
C {devices/lab_pin.sym} 75220 -24280 0 0 {name=p74661 lab=_67552_/X }
C {devices/lab_pin.sym} 75220 -24240 0 0 {name=p74662 lab=_67621_/X }
C {devices/lab_pin.sym} 75380 -24300 0 1 {name=p74663 lab=_67623_/B }
C {sky130_stdcells/a211o_4.sym} 75300 -24300 0 0 {name=X_67622_ }
C {devices/lab_pin.sym} 75240 -24170 0 0 {name=p74664 lab=_79608_/A }
C {devices/lab_pin.sym} 75240 -24130 0 0 {name=p74665 lab=_79609_/A }
C {devices/lab_pin.sym} 75240 -24090 0 0 {name=p74666 lab=_79609_/B }
C {devices/lab_pin.sym} 75360 -24130 0 1 {name=p74667 lab=_79611_/A }
C {sky130_stdcells/nand3_4.sym} 75300 -24130 0 0 {name=X_79608_ }
C {devices/lab_pin.sym} 75260 -23990 0 0 {name=p74668 lab=_64834_/A }
C {devices/lab_pin.sym} 75340 -23990 0 1 {name=p74669 lab=_64888_/B }
C {sky130_stdcells/buf_2.sym} 75300 -23990 0 0 {name=X_64834_ }
C {devices/lab_pin.sym} 75260 -23870 0 0 {name=p74670 lab=clkbuf_9_58_0_CLK/X }
C {devices/lab_pin.sym} 75340 -23870 0 1 {name=p74671 lab=_84906_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 75300 -23870 0 0 {name=Xclkbuf_10_117_0_CLK }
C {devices/lab_pin.sym} 75260 -23750 0 0 {name=p74672 lab=_49825_/A }
C {devices/lab_pin.sym} 75340 -23750 0 1 {name=p74673 lab=_49768_/X }
C {sky130_stdcells/buf_2.sym} 75300 -23750 0 0 {name=X_49768_ }
C {devices/lab_pin.sym} 75210 -23630 0 0 {name=p74674 lab=_80849_/CLK }
C {devices/lab_pin.sym} 75210 -23610 0 0 {name=p74675 lab=_75705_/B }
C {devices/lab_pin.sym} 75390 -23630 0 1 {name=p74676 lab=_80880_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -23620 0 0 {name=X_80880_ }
C {devices/lab_pin.sym} 75260 -23490 0 0 {name=p74677 lab=clkbuf_9_373_0_CLK/X }
C {devices/lab_pin.sym} 75340 -23490 0 1 {name=p74678 lab=_87487_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 75300 -23490 0 0 {name=Xclkbuf_10_747_0_CLK }
C {devices/lab_pin.sym} 75240 -23390 0 0 {name=p74679 lab=_52103_/A }
C {devices/lab_pin.sym} 75240 -23350 0 0 {name=p74680 lab=_48099_/X }
C {devices/lab_pin.sym} 75240 -23310 0 0 {name=p74681 lab=_48723_/C }
C {devices/lab_pin.sym} 75360 -23350 0 1 {name=p74682 lab=_48719_/X }
C {sky130_stdcells/and3_4.sym} 75300 -23350 0 0 {name=X_48719_ }
C {devices/lab_pin.sym} 75240 -23220 0 0 {name=p74683 lab=_67575_/A }
C {devices/lab_pin.sym} 75240 -23180 0 0 {name=p74684 lab=_67553_/B }
C {devices/lab_pin.sym} 75360 -23200 0 1 {name=p74685 lab=_67553_/X }
C {sky130_stdcells/and2_4.sym} 75300 -23200 0 0 {name=X_67553_ }
C {devices/lab_pin.sym} 75240 -23080 0 0 {name=p74686 lab=_79538_/Y }
C {devices/lab_pin.sym} 75240 -23040 0 0 {name=p74687 lab=_64542_/A }
C {devices/lab_pin.sym} 75360 -23060 0 1 {name=p74688 lab=_79540_/C }
C {sky130_stdcells/nand2_4.sym} 75300 -23060 0 0 {name=X_79539_ }
C {devices/lab_pin.sym} 75220 -22950 0 0 {name=p74689 lab=_64762_/Y }
C {devices/lab_pin.sym} 75220 -22910 0 0 {name=p74690 lab=_64662_/X }
C {devices/lab_pin.sym} 75220 -22870 0 0 {name=p74691 lab=_64764_/Y }
C {devices/lab_pin.sym} 75380 -22910 0 1 {name=p74692 lab=_84228_/D }
C {sky130_stdcells/a21o_4.sym} 75300 -22910 0 0 {name=X_64765_ }
C {devices/lab_pin.sym} 75240 -22780 0 0 {name=p74693 lab=_49699_/A }
C {devices/lab_pin.sym} 75240 -22740 0 0 {name=p74694 lab=_51222_/B }
C {devices/lab_pin.sym} 75360 -22760 0 1 {name=p74695 lab=_49699_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -22760 0 0 {name=X_49699_ }
C {devices/lab_pin.sym} 75240 -22650 0 0 {name=p74696 lab=_62002_/A }
C {devices/lab_pin.sym} 75240 -22610 0 0 {name=p74697 lab=_62002_/B }
C {devices/lab_pin.sym} 75240 -22570 0 0 {name=p74698 lab=_78065_/B }
C {devices/lab_pin.sym} 75360 -22610 0 1 {name=p74699 lab=_61977_/Y }
C {sky130_stdcells/nor3_4.sym} 75300 -22610 0 0 {name=X_61977_ }
C {devices/lab_pin.sym} 75220 -22490 0 0 {name=p74700 lab=_66475_/X }
C {devices/lab_pin.sym} 75220 -22450 0 0 {name=p74701 lab=_66303_/Y }
C {devices/lab_pin.sym} 75220 -22410 0 0 {name=p74702 lab=_66503_/Y }
C {devices/lab_pin.sym} 75380 -22450 0 1 {name=p74703 lab=_66504_/Y }
C {sky130_stdcells/o21ai_4.sym} 75300 -22450 0 0 {name=X_66504_ }
C {devices/lab_pin.sym} 75260 -22310 0 0 {name=p74704 lab=clkbuf_9_239_0_CLK/A }
C {devices/lab_pin.sym} 75340 -22310 0 1 {name=p74705 lab=clkbuf_9_238_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 75300 -22310 0 0 {name=Xclkbuf_9_238_0_CLK }
C {devices/lab_pin.sym} 75240 -22220 0 0 {name=p74706 lab=_51709_/X }
C {devices/lab_pin.sym} 75240 -22180 0 0 {name=p74707 lab=_51721_/X }
C {devices/lab_pin.sym} 75240 -22140 0 0 {name=p74708 lab=_51715_/C }
C {devices/lab_pin.sym} 75240 -22100 0 0 {name=p74709 lab=_53253_/D }
C {devices/lab_pin.sym} 75360 -22160 0 1 {name=p74710 lab=_51730_/X }
C {sky130_stdcells/and4_4.sym} 75300 -22160 0 0 {name=X_51730_ }
C {devices/lab_pin.sym} 75220 -22050 0 0 {name=p74711 lab=_61695_/A }
C {devices/lab_pin.sym} 75220 -22010 0 0 {name=p74712 lab=_63384_/D }
C {devices/lab_pin.sym} 75220 -21970 0 0 {name=p74713 lab=_60667_/Y }
C {devices/lab_pin.sym} 75220 -21930 0 0 {name=p74714 lab=_60758_/X }
C {devices/lab_pin.sym} 75220 -21890 0 0 {name=p74715 lab=_84882_/Q }
C {devices/lab_pin.sym} 75380 -21970 0 1 {name=p74716 lab=_63716_/X }
C {sky130_stdcells/a32o_4.sym} 75300 -21970 0 0 {name=X_63716_ }
C {devices/lab_pin.sym} 75210 -21810 0 0 {name=p74717 lab=_82369_/CLK }
C {devices/lab_pin.sym} 75210 -21790 0 0 {name=p74718 lab=_82550_/D }
C {devices/lab_pin.sym} 75390 -21810 0 1 {name=p74719 lab=_78839_/B }
C {sky130_stdcells/dfxtp_4.sym} 75300 -21800 0 0 {name=X_82550_ }
C {devices/lab_pin.sym} 75260 -21670 0 0 {name=p74720 lab=_60928_/A }
C {devices/lab_pin.sym} 75340 -21670 0 1 {name=p74721 lab=_60928_/X }
C {sky130_stdcells/buf_2.sym} 75300 -21670 0 0 {name=X_60928_ }
C {devices/lab_pin.sym} 75240 -21560 0 0 {name=p74722 lab=_67484_/A }
C {devices/lab_pin.sym} 75240 -21520 0 0 {name=p74723 lab=_67483_/X }
C {devices/lab_pin.sym} 75360 -21540 0 1 {name=p74724 lab=_67484_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -21540 0 0 {name=X_67484_ }
C {devices/lab_pin.sym} 75260 -21410 0 0 {name=p74725 lab=_64696_/A }
C {devices/lab_pin.sym} 75340 -21410 0 1 {name=p74726 lab=_64696_/X }
C {sky130_stdcells/buf_2.sym} 75300 -21410 0 0 {name=X_64696_ }
C {devices/lab_pin.sym} 75210 -21290 0 0 {name=p74727 lab=_81428_/CLK }
C {devices/lab_pin.sym} 75210 -21270 0 0 {name=p74728 lab=_84069_/Q }
C {devices/lab_pin.sym} 75390 -21290 0 1 {name=p74729 lab=_76894_/A }
C {sky130_stdcells/dfxtp_4.sym} 75300 -21280 0 0 {name=X_81501_ }
C {devices/lab_pin.sym} 75260 -21150 0 0 {name=p74730 lab=_69223_/A }
C {devices/lab_pin.sym} 75340 -21150 0 1 {name=p74731 lab=_69253_/A }
C {sky130_stdcells/buf_2.sym} 75300 -21150 0 0 {name=X_69223_ }
C {devices/lab_pin.sym} 75260 -21030 0 0 {name=p74732 lab=_66435_/A }
C {devices/lab_pin.sym} 75340 -21030 0 1 {name=p74733 lab=_66435_/Y }
C {sky130_stdcells/inv_2.sym} 75300 -21030 0 0 {name=X_66435_ }
C {devices/lab_pin.sym} 75220 -20930 0 0 {name=p74734 lab=_85969_/Q }
C {devices/lab_pin.sym} 75220 -20890 0 0 {name=p74735 lab=_51647_/X }
C {devices/lab_pin.sym} 75220 -20850 0 0 {name=p74736 lab=_51660_/Y }
C {devices/lab_pin.sym} 75380 -20890 0 1 {name=p74737 lab=_51661_/Y }
C {sky130_stdcells/o21ai_4.sym} 75300 -20890 0 0 {name=X_51661_ }
C {devices/lab_pin.sym} 75220 -20770 0 0 {name=p74738 lab=_63642_/Y }
C {devices/lab_pin.sym} 75220 -20730 0 0 {name=p74739 lab=_63635_/X }
C {devices/lab_pin.sym} 75220 -20690 0 0 {name=p74740 lab=_63646_/Y }
C {devices/lab_pin.sym} 75380 -20730 0 1 {name=p74741 lab=_63647_/Y }
C {sky130_stdcells/a21oi_4.sym} 75300 -20730 0 0 {name=X_63647_ }
C {devices/lab_pin.sym} 75210 -20590 0 0 {name=p74742 lab=_82563_/CLK }
C {devices/lab_pin.sym} 75210 -20570 0 0 {name=p74743 lab=_82481_/D }
C {devices/lab_pin.sym} 75390 -20590 0 1 {name=p74744 lab=_78124_/B }
C {sky130_stdcells/dfxtp_4.sym} 75300 -20580 0 0 {name=X_82481_ }
C {devices/lab_pin.sym} 75260 -20450 0 0 {name=p74745 lab=_60915_/A }
C {devices/lab_pin.sym} 75340 -20450 0 1 {name=p74746 lab=_60865_/C }
C {sky130_stdcells/buf_2.sym} 75300 -20450 0 0 {name=X_60859_ }
C {devices/lab_pin.sym} 75220 -20350 0 0 {name=p74747 lab=_85640_/Q }
C {devices/lab_pin.sym} 75220 -20310 0 0 {name=p74748 lab=_53378_/X }
C {devices/lab_pin.sym} 75220 -20270 0 0 {name=p74749 lab=_53399_/Y }
C {devices/lab_pin.sym} 75380 -20310 0 1 {name=p74750 lab=_53400_/Y }
C {sky130_stdcells/o21ai_4.sym} 75300 -20310 0 0 {name=X_53400_ }
C {devices/lab_pin.sym} 75210 -20170 0 0 {name=p74751 lab=_84220_/CLK }
C {devices/lab_pin.sym} 75210 -20150 0 0 {name=p74752 lab=_64970_/X }
C {devices/lab_pin.sym} 75390 -20170 0 1 {name=p74753 lab=_84220_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -20160 0 0 {name=X_84220_ }
C {devices/lab_pin.sym} 75240 -20040 0 0 {name=p74754 lab=_50597_/A }
C {devices/lab_pin.sym} 75240 -20000 0 0 {name=p74755 lab=_48982_/X }
C {devices/lab_pin.sym} 75360 -20020 0 1 {name=p74756 lab=_50612_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -20020 0 0 {name=X_50612_ }
C {devices/lab_pin.sym} 75210 -19890 0 0 {name=p74757 lab=_81431_/CLK }
C {devices/lab_pin.sym} 75210 -19870 0 0 {name=p74758 lab=_81464_/Q }
C {devices/lab_pin.sym} 75390 -19890 0 1 {name=p74759 lab=_76075_/B }
C {sky130_stdcells/dfxtp_4.sym} 75300 -19880 0 0 {name=X_81432_ }
C {devices/lab_pin.sym} 75240 -19760 0 0 {name=p74760 lab=_69073_/A }
C {devices/lab_pin.sym} 75240 -19720 0 0 {name=p74761 lab=_88306_/Q }
C {devices/lab_pin.sym} 75360 -19740 0 1 {name=p74762 lab=_69154_/X }
C {sky130_stdcells/and2_4.sym} 75300 -19740 0 0 {name=X_69154_ }
C {devices/lab_pin.sym} 75240 -19640 0 0 {name=p74763 lab=_54395_/A }
C {devices/lab_pin.sym} 75240 -19600 0 0 {name=p74764 lab=_54362_/B }
C {devices/lab_pin.sym} 75240 -19560 0 0 {name=p74765 lab=_54395_/C }
C {devices/lab_pin.sym} 75240 -19520 0 0 {name=p74766 lab=_46809_/Y }
C {devices/lab_pin.sym} 75360 -19580 0 1 {name=p74767 lab=_54380_/X }
C {sky130_stdcells/and4_4.sym} 75300 -19580 0 0 {name=X_54380_ }
C {devices/lab_pin.sym} 75260 -19430 0 0 {name=p74768 lab=_66366_/A }
C {devices/lab_pin.sym} 75340 -19430 0 1 {name=p74769 lab=_66366_/X }
C {sky130_stdcells/buf_2.sym} 75300 -19430 0 0 {name=X_66366_ }
C {devices/lab_pin.sym} 75240 -19340 0 0 {name=p74770 lab=_51580_/A }
C {devices/lab_pin.sym} 75240 -19300 0 0 {name=p74771 lab=_51603_/B }
C {devices/lab_pin.sym} 75240 -19260 0 0 {name=p74772 lab=_51603_/C }
C {devices/lab_pin.sym} 75240 -19220 0 0 {name=p74773 lab=_53118_/D }
C {devices/lab_pin.sym} 75360 -19280 0 1 {name=p74774 lab=_51592_/X }
C {sky130_stdcells/and4_4.sym} 75300 -19280 0 0 {name=X_51592_ }
C {devices/lab_pin.sym} 75260 -19130 0 0 {name=p74775 lab=_63578_/A }
C {devices/lab_pin.sym} 75340 -19130 0 1 {name=p74776 lab=_63578_/X }
C {sky130_stdcells/buf_2.sym} 75300 -19130 0 0 {name=X_63578_ }
C {devices/lab_pin.sym} 75260 -19010 0 0 {name=p74777 lab=_67013_/X }
C {devices/lab_pin.sym} 75340 -19010 0 1 {name=p74778 lab=_68106_/A }
C {sky130_stdcells/buf_2.sym} 75300 -19010 0 0 {name=X_68105_ }
C {devices/lab_pin.sym} 75220 -18910 0 0 {name=p74779 lab=_53327_/Y }
C {devices/lab_pin.sym} 75220 -18870 0 0 {name=p74780 lab=_53328_/X }
C {devices/lab_pin.sym} 75220 -18830 0 0 {name=p74781 lab=_53330_/X }
C {devices/lab_pin.sym} 75380 -18870 0 1 {name=p74782 lab=_85654_/D }
C {sky130_stdcells/a21oi_4.sym} 75300 -18870 0 0 {name=X_53331_ }
C {devices/lab_pin.sym} 75220 -18750 0 0 {name=p74783 lab=_65314_/X }
C {devices/lab_pin.sym} 75220 -18710 0 0 {name=p74784 lab=_65316_/X }
C {devices/lab_pin.sym} 75220 -18670 0 0 {name=p74785 lab=_64701_/X }
C {devices/lab_pin.sym} 75380 -18710 0 1 {name=p74786 lab=_65317_/X }
C {sky130_stdcells/a21o_4.sym} 75300 -18710 0 0 {name=X_65317_ }
C {devices/lab_pin.sym} 75210 -18570 0 0 {name=p74787 lab=_81224_/CLK }
C {devices/lab_pin.sym} 75210 -18550 0 0 {name=p74788 lab=_84151_/D }
C {devices/lab_pin.sym} 75390 -18570 0 1 {name=p74789 lab=_84151_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -18560 0 0 {name=X_84151_ }
C {devices/lab_pin.sym} 75240 -18450 0 0 {name=p74790 lab=_48680_/A }
C {devices/lab_pin.sym} 75240 -18410 0 0 {name=p74791 lab=_50552_/B }
C {devices/lab_pin.sym} 75240 -18370 0 0 {name=p74792 lab=_50552_/C }
C {devices/lab_pin.sym} 75360 -18410 0 1 {name=p74793 lab=_50543_/X }
C {sky130_stdcells/and3_4.sym} 75300 -18410 0 0 {name=X_50543_ }
C {devices/lab_pin.sym} 75240 -18300 0 0 {name=p74794 lab=_62487_/X }
C {devices/lab_pin.sym} 75240 -18260 0 0 {name=p74795 lab=_83243_/Q }
C {devices/lab_pin.sym} 75240 -18220 0 0 {name=p74796 lab=_62628_/C }
C {devices/lab_pin.sym} 75240 -18180 0 0 {name=p74797 lab=_62219_/X }
C {devices/lab_pin.sym} 75360 -18240 0 1 {name=p74798 lab=_62529_/X }
C {sky130_stdcells/and4_4.sym} 75300 -18240 0 0 {name=X_62529_ }
C {devices/lab_pin.sym} 75210 -18090 0 0 {name=p74799 lab=_81811_/CLK }
C {devices/lab_pin.sym} 75210 -18070 0 0 {name=p74800 lab=_81363_/D }
C {devices/lab_pin.sym} 75390 -18090 0 1 {name=p74801 lab=_81363_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -18080 0 0 {name=X_81363_ }
C {devices/lab_pin.sym} 75220 -17970 0 0 {name=p74802 lab=_80804_/D }
C {devices/lab_pin.sym} 75220 -17930 0 0 {name=p74803 lab=_69066_/X }
C {devices/lab_pin.sym} 75220 -17890 0 0 {name=p74804 lab=_69084_/X }
C {devices/lab_pin.sym} 75380 -17930 0 1 {name=p74805 lab=_83948_/D }
C {sky130_stdcells/a21bo_4.sym} 75300 -17930 0 0 {name=X_69085_ }
C {devices/lab_pin.sym} 75220 -17820 0 0 {name=p74806 lab=_66266_/X }
C {devices/lab_pin.sym} 75220 -17780 0 0 {name=p74807 lab=_86214_/Q }
C {devices/lab_pin.sym} 75220 -17740 0 0 {name=p74808 lab=_66295_/X }
C {devices/lab_pin.sym} 75220 -17700 0 0 {name=p74809 lab=_66296_/X }
C {devices/lab_pin.sym} 75380 -17760 0 1 {name=p74810 lab=_66297_/X }
C {sky130_stdcells/a211o_4.sym} 75300 -17760 0 0 {name=X_66297_ }
C {devices/lab_pin.sym} 75210 -17610 0 0 {name=p74811 lab=_83095_/CLK }
C {devices/lab_pin.sym} 75210 -17590 0 0 {name=p74812 lab=_83102_/D }
C {devices/lab_pin.sym} 75390 -17610 0 1 {name=p74813 lab=_83102_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -17600 0 0 {name=X_83102_ }
C {devices/lab_pin.sym} 75260 -17470 0 0 {name=p74814 lab=_56049_/Y }
C {devices/lab_pin.sym} 75340 -17470 0 1 {name=p74815 lab=_56050_/X }
C {sky130_stdcells/buf_2.sym} 75300 -17470 0 0 {name=X_56050_ }
C {devices/lab_pin.sym} 75240 -17360 0 0 {name=p74816 lab=_84749_/Q }
C {devices/lab_pin.sym} 75240 -17320 0 0 {name=p74817 lab=_66319_/C }
C {devices/lab_pin.sym} 75360 -17340 0 1 {name=p74818 lab=_80314_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -17340 0 0 {name=X_80314_ }
C {devices/lab_pin.sym} 75220 -17240 0 0 {name=p74819 lab=_86946_/Q }
C {devices/lab_pin.sym} 75220 -17200 0 0 {name=p74820 lab=_67942_/X }
C {devices/lab_pin.sym} 75220 -17160 0 0 {name=p74821 lab=_67991_/X }
C {devices/lab_pin.sym} 75220 -17120 0 0 {name=p74822 lab=_68035_/X }
C {devices/lab_pin.sym} 75380 -17180 0 1 {name=p74823 lab=_68036_/X }
C {sky130_stdcells/a211o_4.sym} 75300 -17180 0 0 {name=X_68036_ }
C {devices/lab_pin.sym} 75220 -17050 0 0 {name=p74824 lab=_53260_/Y }
C {devices/lab_pin.sym} 75220 -17010 0 0 {name=p74825 lab=_53242_/X }
C {devices/lab_pin.sym} 75220 -16970 0 0 {name=p74826 lab=_53261_/X }
C {devices/lab_pin.sym} 75380 -17010 0 1 {name=p74827 lab=_53262_/Y }
C {sky130_stdcells/a21oi_4.sym} 75300 -17010 0 0 {name=X_53262_ }
C {devices/lab_pin.sym} 75220 -16900 0 0 {name=p74828 lab=_65199_/X }
C {devices/lab_pin.sym} 75220 -16860 0 0 {name=p74829 lab=_86152_/Q }
C {devices/lab_pin.sym} 75220 -16820 0 0 {name=p74830 lab=_65224_/X }
C {devices/lab_pin.sym} 75220 -16780 0 0 {name=p74831 lab=_65247_/X }
C {devices/lab_pin.sym} 75380 -16840 0 1 {name=p74832 lab=_65248_/X }
C {sky130_stdcells/a211o_4.sym} 75300 -16840 0 0 {name=X_65248_ }
C {devices/lab_pin.sym} 75210 -16690 0 0 {name=p74833 lab=_83933_/CLK }
C {devices/lab_pin.sym} 75210 -16670 0 0 {name=p74834 lab=_67140_/X }
C {devices/lab_pin.sym} 75390 -16690 0 1 {name=p74835 lab=_80906_/D }
C {sky130_stdcells/dfxtp_4.sym} 75300 -16680 0 0 {name=X_84082_ }
C {devices/lab_pin.sym} 75260 -16550 0 0 {name=p74836 lab=_50577_/A }
C {devices/lab_pin.sym} 75340 -16550 0 1 {name=p74837 lab=_50474_/X }
C {sky130_stdcells/buf_2.sym} 75300 -16550 0 0 {name=X_50474_ }
C {devices/lab_pin.sym} 75210 -16430 0 0 {name=p74838 lab=_81808_/CLK }
C {devices/lab_pin.sym} 75210 -16410 0 0 {name=p74839 lab=_76982_/X }
C {devices/lab_pin.sym} 75390 -16430 0 1 {name=p74840 lab=_81262_/D }
C {sky130_stdcells/dfxtp_4.sym} 75300 -16420 0 0 {name=X_81294_ }
C {devices/lab_pin.sym} 75220 -16310 0 0 {name=p74841 lab=_54997_/Y }
C {devices/lab_pin.sym} 75220 -16270 0 0 {name=p74842 lab=_54998_/X }
C {devices/lab_pin.sym} 75220 -16230 0 0 {name=p74843 lab=_55000_/X }
C {devices/lab_pin.sym} 75380 -16270 0 1 {name=p74844 lab=_55001_/Y }
C {sky130_stdcells/a21oi_4.sym} 75300 -16270 0 0 {name=X_55001_ }
C {devices/lab_pin.sym} 75220 -16150 0 0 {name=p74845 lab=_52211_/Y }
C {devices/lab_pin.sym} 75220 -16110 0 0 {name=p74846 lab=_52203_/X }
C {devices/lab_pin.sym} 75220 -16070 0 0 {name=p74847 lab=_52212_/X }
C {devices/lab_pin.sym} 75380 -16110 0 1 {name=p74848 lab=_52213_/Y }
C {sky130_stdcells/a21oi_4.sym} 75300 -16110 0 0 {name=X_52213_ }
C {devices/lab_pin.sym} 75210 -15970 0 0 {name=p74849 lab=_86930_/CLK }
C {devices/lab_pin.sym} 75210 -15950 0 0 {name=p74850 lab=_87910_/D }
C {devices/lab_pin.sym} 75390 -15970 0 1 {name=p74851 lab=_87910_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -15960 0 0 {name=X_87910_ }
C {devices/lab_pin.sym} 75210 -15830 0 0 {name=p74852 lab=_85241_/CLK }
C {devices/lab_pin.sym} 75210 -15810 0 0 {name=p74853 lab=_83033_/D }
C {devices/lab_pin.sym} 75390 -15830 0 1 {name=p74854 lab=_83033_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -15820 0 0 {name=X_83033_ }
C {devices/lab_pin.sym} 75220 -15720 0 0 {name=p74855 lab=_80213_/X }
C {devices/lab_pin.sym} 75220 -15680 0 0 {name=p74856 lab=_80216_/Y }
C {devices/lab_pin.sym} 75220 -15640 0 0 {name=p74857 lab=_80230_/Y }
C {devices/lab_pin.sym} 75220 -15600 0 0 {name=p74858 lab=_80233_/Y }
C {devices/lab_pin.sym} 75380 -15660 0 1 {name=p74859 lab=_80245_/X }
C {sky130_stdcells/o22a_4.sym} 75300 -15660 0 0 {name=X_80245_ }
C {devices/lab_pin.sym} 75240 -15520 0 0 {name=p74860 lab=_53187_/A }
C {devices/lab_pin.sym} 75240 -15480 0 0 {name=p74861 lab=_53193_/B }
C {devices/lab_pin.sym} 75360 -15500 0 1 {name=p74862 lab=_53193_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -15500 0 0 {name=X_53193_ }
C {devices/lab_pin.sym} 75240 -15380 0 0 {name=p74863 lab=_65164_/A }
C {devices/lab_pin.sym} 75240 -15340 0 0 {name=p74864 lab=_86411_/Q }
C {devices/lab_pin.sym} 75360 -15360 0 1 {name=p74865 lab=_65179_/X }
C {sky130_stdcells/and2_4.sym} 75300 -15360 0 0 {name=X_65179_ }
C {devices/lab_pin.sym} 75220 -15250 0 0 {name=p74866 lab=_85880_/Q }
C {devices/lab_pin.sym} 75220 -15210 0 0 {name=p74867 lab=_52125_/X }
C {devices/lab_pin.sym} 75220 -15170 0 0 {name=p74868 lab=_52143_/Y }
C {devices/lab_pin.sym} 75380 -15210 0 1 {name=p74869 lab=_52144_/Y }
C {sky130_stdcells/o21ai_4.sym} 75300 -15210 0 0 {name=X_52144_ }
C {devices/lab_pin.sym} 75210 -15070 0 0 {name=p74870 lab=_88097_/CLK }
C {devices/lab_pin.sym} 75210 -15050 0 0 {name=p74871 lab=_42508_/Y }
C {devices/lab_pin.sym} 75390 -15070 0 1 {name=p74872 lab=_87841_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -15060 0 0 {name=X_87841_ }
C {devices/lab_pin.sym} 75240 -14940 0 0 {name=p74873 lab=_80176_/A }
C {devices/lab_pin.sym} 75240 -14900 0 0 {name=p74874 lab=_80175_/X }
C {devices/lab_pin.sym} 75360 -14920 0 1 {name=p74875 lab=_80176_/Y }
C {sky130_stdcells/xnor2_4.sym} 75300 -14920 0 0 {name=X_80176_ }
C {devices/lab_pin.sym} 75220 -14810 0 0 {name=p74876 lab=_82559_/D }
C {devices/lab_pin.sym} 75220 -14770 0 0 {name=p74877 lab=_69955_/X }
C {devices/lab_pin.sym} 75220 -14730 0 0 {name=p74878 lab=_69986_/X }
C {devices/lab_pin.sym} 75380 -14770 0 1 {name=p74879 lab=_69987_/X }
C {sky130_stdcells/a21bo_4.sym} 75300 -14770 0 0 {name=X_69987_ }
C {devices/lab_pin.sym} 75260 -14630 0 0 {name=p74880 lab=_62717_/A }
C {devices/lab_pin.sym} 75340 -14630 0 1 {name=p74881 lab=_62669_/D }
C {sky130_stdcells/buf_2.sym} 75300 -14630 0 0 {name=X_59740_ }
C {devices/lab_pin.sym} 75260 -14510 0 0 {name=p74882 lab=_52438_/A }
C {devices/lab_pin.sym} 75340 -14510 0 1 {name=p74883 lab=_52075_/X }
C {sky130_stdcells/buf_2.sym} 75300 -14510 0 0 {name=X_52075_ }
C {devices/lab_pin.sym} 75260 -14390 0 0 {name=p74884 lab=_56952_/A }
C {devices/lab_pin.sym} 75340 -14390 0 1 {name=p74885 lab=_56952_/X }
C {sky130_stdcells/buf_2.sym} 75300 -14390 0 0 {name=X_56952_ }
C {devices/lab_pin.sym} 75240 -14280 0 0 {name=p74886 lab=_68938_/A }
C {devices/lab_pin.sym} 75240 -14240 0 0 {name=p74887 lab=_88348_/Q }
C {devices/lab_pin.sym} 75360 -14260 0 1 {name=p74888 lab=_68938_/X }
C {sky130_stdcells/and2_4.sym} 75300 -14260 0 0 {name=X_68938_ }
C {devices/lab_pin.sym} 75210 -14130 0 0 {name=p74889 lab=_87767_/CLK }
C {devices/lab_pin.sym} 75210 -14110 0 0 {name=p74890 lab=_42683_/X }
C {devices/lab_pin.sym} 75390 -14130 0 1 {name=p74891 lab=_69452_/B }
C {sky130_stdcells/dfxtp_4.sym} 75300 -14120 0 0 {name=X_87772_ }
C {devices/lab_pin.sym} 75210 -13990 0 0 {name=p74892 lab=_85915_/CLK }
C {devices/lab_pin.sym} 75210 -13970 0 0 {name=p74893 lab=_84984_/D }
C {devices/lab_pin.sym} 75390 -13990 0 1 {name=p74894 lab=_84984_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -13980 0 0 {name=X_84984_ }
C {devices/lab_pin.sym} 75240 -13860 0 0 {name=p74895 lab=_51022_/A }
C {devices/lab_pin.sym} 75240 -13820 0 0 {name=p74896 lab=_51026_/B }
C {devices/lab_pin.sym} 75360 -13840 0 1 {name=p74897 lab=_51026_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -13840 0 0 {name=X_51026_ }
C {devices/lab_pin.sym} 75240 -13720 0 0 {name=p74898 lab=_55903_/A }
C {devices/lab_pin.sym} 75240 -13680 0 0 {name=p74899 lab=_85241_/Q }
C {devices/lab_pin.sym} 75360 -13700 0 1 {name=p74900 lab=_55903_/X }
C {sky130_stdcells/and2_4.sym} 75300 -13700 0 0 {name=X_55903_ }
C {devices/lab_pin.sym} 75210 -13570 0 0 {name=p74901 lab=_86404_/CLK }
C {devices/lab_pin.sym} 75210 -13550 0 0 {name=p74902 lab=_46593_/Y }
C {devices/lab_pin.sym} 75390 -13570 0 1 {name=p74903 lab=_86723_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -13560 0 0 {name=X_86723_ }
C {devices/lab_pin.sym} 75260 -13430 0 0 {name=p74904 lab=_66046_/A }
C {devices/lab_pin.sym} 75340 -13430 0 1 {name=p74905 lab=_59696_/A }
C {sky130_stdcells/buf_2.sym} 75300 -13430 0 0 {name=X_59671_ }
C {devices/lab_pin.sym} 75210 -13310 0 0 {name=p74906 lab=_84087_/CLK }
C {devices/lab_pin.sym} 75210 -13290 0 0 {name=p74907 lab=_69284_/X }
C {devices/lab_pin.sym} 75390 -13310 0 1 {name=p74908 lab=_83935_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -13300 0 0 {name=X_83935_ }
C {devices/lab_pin.sym} 75220 -13190 0 0 {name=p74909 lab=_56866_/A }
C {devices/lab_pin.sym} 75220 -13150 0 0 {name=p74910 lab=_56859_/X }
C {devices/lab_pin.sym} 75220 -13110 0 0 {name=p74911 lab=_83334_/Q }
C {devices/lab_pin.sym} 75380 -13150 0 1 {name=p74912 lab=_56884_/C }
C {sky130_stdcells/a21o_4.sym} 75300 -13150 0 0 {name=X_56883_ }
C {devices/lab_pin.sym} 75220 -13040 0 0 {name=p74913 lab=_87999_/Q }
C {devices/lab_pin.sym} 75220 -13000 0 0 {name=p74914 lab=_68778_/X }
C {devices/lab_pin.sym} 75220 -12960 0 0 {name=p74915 lab=_68800_/X }
C {devices/lab_pin.sym} 75220 -12920 0 0 {name=p74916 lab=_68868_/X }
C {devices/lab_pin.sym} 75380 -12980 0 1 {name=p74917 lab=_68869_/X }
C {sky130_stdcells/a211o_4.sym} 75300 -12980 0 0 {name=X_68869_ }
C {devices/lab_pin.sym} 75220 -12850 0 0 {name=p74918 lab=_46805_/X }
C {devices/lab_pin.sym} 75220 -12810 0 0 {name=p74919 lab=_70885_/X }
C {devices/lab_pin.sym} 75220 -12770 0 0 {name=p74920 lab=_70899_/Y }
C {devices/lab_pin.sym} 75380 -12810 0 1 {name=p74921 lab=_70900_/Y }
C {sky130_stdcells/o21ai_4.sym} 75300 -12810 0 0 {name=X_70900_ }
C {devices/lab_pin.sym} 75220 -12700 0 0 {name=p74922 lab=_84813_/Q }
C {devices/lab_pin.sym} 75220 -12660 0 0 {name=p74923 lab=_58599_/X }
C {devices/lab_pin.sym} 75220 -12620 0 0 {name=p74924 lab=_58615_/X }
C {devices/lab_pin.sym} 75220 -12580 0 0 {name=p74925 lab=_58621_/X }
C {devices/lab_pin.sym} 75380 -12640 0 1 {name=p74926 lab=_84813_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 75300 -12640 0 0 {name=X_58622_ }
C {devices/lab_pin.sym} 75220 -12520 0 0 {name=p74927 lab=_85201_/Q }
C {devices/lab_pin.sym} 75220 -12480 0 0 {name=p74928 lab=_55475_/X }
C {devices/lab_pin.sym} 75220 -12440 0 0 {name=p74929 lab=_55523_/X }
C {devices/lab_pin.sym} 75220 -12400 0 0 {name=p74930 lab=_55833_/X }
C {devices/lab_pin.sym} 75380 -12460 0 1 {name=p74931 lab=_55834_/X }
C {sky130_stdcells/a211o_4.sym} 75300 -12460 0 0 {name=X_55834_ }
C {devices/lab_pin.sym} 75210 -12310 0 0 {name=p74932 lab=_86655_/CLK }
C {devices/lab_pin.sym} 75210 -12290 0 0 {name=p74933 lab=_86654_/D }
C {devices/lab_pin.sym} 75390 -12310 0 1 {name=p74934 lab=_86654_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -12300 0 0 {name=X_86654_ }
C {devices/lab_pin.sym} 75220 -12190 0 0 {name=p74935 lab=_71871_/X }
C {devices/lab_pin.sym} 75220 -12150 0 0 {name=p74936 lab=_83343_/Q }
C {devices/lab_pin.sym} 75220 -12110 0 0 {name=p74937 lab=_71879_/Y }
C {devices/lab_pin.sym} 75380 -12150 0 1 {name=p74938 lab=_71880_/X }
C {sky130_stdcells/a21o_4.sym} 75300 -12150 0 0 {name=X_71880_ }
C {devices/lab_pin.sym} 75210 -12010 0 0 {name=p74939 lab=_82541_/CLK }
C {devices/lab_pin.sym} 75210 -11990 0 0 {name=p74940 lab=_83866_/D }
C {devices/lab_pin.sym} 75390 -12010 0 1 {name=p74941 lab=_83866_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -12000 0 0 {name=X_83866_ }
C {devices/lab_pin.sym} 75210 -11870 0 0 {name=p74942 lab=_85895_/CLK }
C {devices/lab_pin.sym} 75210 -11850 0 0 {name=p74943 lab=_85605_/D }
C {devices/lab_pin.sym} 75390 -11870 0 1 {name=p74944 lab=_85605_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -11860 0 0 {name=X_85605_ }
C {devices/lab_pin.sym} 75260 -11730 0 0 {name=p74945 lab=_70830_/Y }
C {devices/lab_pin.sym} 75340 -11730 0 1 {name=p74946 lab=_70831_/X }
C {sky130_stdcells/buf_2.sym} 75300 -11730 0 0 {name=X_70831_ }
C {devices/lab_pin.sym} 75260 -11610 0 0 {name=p74947 lab=_84820_/Q }
C {devices/lab_pin.sym} 75340 -11610 0 1 {name=p74948 lab=_58554_/A }
C {sky130_stdcells/inv_2.sym} 75300 -11610 0 0 {name=X_58553_ }
C {devices/lab_pin.sym} 75210 -11490 0 0 {name=p74949 lab=_82740_/CLK }
C {devices/lab_pin.sym} 75210 -11470 0 0 {name=p74950 lab=_82849_/Q }
C {devices/lab_pin.sym} 75390 -11490 0 1 {name=p74951 lab=_82817_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -11480 0 0 {name=X_82817_ }
C {devices/lab_pin.sym} 75220 -11380 0 0 {name=p74952 lab=_85257_/Q }
C {devices/lab_pin.sym} 75220 -11340 0 0 {name=p74953 lab=_55152_/X }
C {devices/lab_pin.sym} 75220 -11300 0 0 {name=p74954 lab=_44043_/X }
C {devices/lab_pin.sym} 75220 -11260 0 0 {name=p74955 lab=_55764_/X }
C {devices/lab_pin.sym} 75380 -11320 0 1 {name=p74956 lab=_55765_/X }
C {sky130_stdcells/a211o_4.sym} 75300 -11320 0 0 {name=X_55765_ }
C {devices/lab_pin.sym} 75210 -11170 0 0 {name=p74957 lab=_86587_/CLK }
C {devices/lab_pin.sym} 75210 -11150 0 0 {name=p74958 lab=_86585_/D }
C {devices/lab_pin.sym} 75390 -11170 0 1 {name=p74959 lab=_66024_/B }
C {sky130_stdcells/dfxtp_4.sym} 75300 -11160 0 0 {name=X_86585_ }
C {devices/lab_pin.sym} 75260 -11030 0 0 {name=p74960 lab=_40783_/A }
C {devices/lab_pin.sym} 75340 -11030 0 1 {name=p74961 lab=_40991_/X }
C {sky130_stdcells/buf_2.sym} 75300 -11030 0 0 {name=X_40991_ }
C {devices/lab_pin.sym} 75240 -10940 0 0 {name=p74962 lab=_52997_/A }
C {devices/lab_pin.sym} 75240 -10900 0 0 {name=p74963 lab=_52982_/B }
C {devices/lab_pin.sym} 75240 -10860 0 0 {name=p74964 lab=_52977_/C }
C {devices/lab_pin.sym} 75240 -10820 0 0 {name=p74965 lab=_52977_/D }
C {devices/lab_pin.sym} 75360 -10880 0 1 {name=p74966 lab=_52977_/X }
C {sky130_stdcells/and4_4.sym} 75300 -10880 0 0 {name=X_52977_ }
C {devices/lab_pin.sym} 75210 -10730 0 0 {name=p74967 lab=_81808_/CLK }
C {devices/lab_pin.sym} 75210 -10710 0 0 {name=p74968 lab=_83797_/D }
C {devices/lab_pin.sym} 75390 -10730 0 1 {name=p74969 lab=_74768_/B }
C {sky130_stdcells/dfxtp_4.sym} 75300 -10720 0 0 {name=X_83797_ }
C {devices/lab_pin.sym} 75220 -10610 0 0 {name=p74970 lab=_84990_/Q }
C {devices/lab_pin.sym} 75220 -10570 0 0 {name=p74971 lab=_47806_/X }
C {devices/lab_pin.sym} 75220 -10530 0 0 {name=p74972 lab=_57503_/Y }
C {devices/lab_pin.sym} 75380 -10570 0 1 {name=p74973 lab=_57504_/Y }
C {sky130_stdcells/o21ai_4.sym} 75300 -10570 0 0 {name=X_57504_ }
C {devices/lab_pin.sym} 75210 -10430 0 0 {name=p74974 lab=_88324_/CLK }
C {devices/lab_pin.sym} 75210 -10410 0 0 {name=p74975 lab=_88324_/D }
C {devices/lab_pin.sym} 75390 -10430 0 1 {name=p74976 lab=_88324_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -10420 0 0 {name=X_88324_ }
C {devices/lab_pin.sym} 75220 -10320 0 0 {name=p74977 lab=_41199_/X }
C {devices/lab_pin.sym} 75220 -10280 0 0 {name=p74978 lab=_42717_/X }
C {devices/lab_pin.sym} 75220 -10240 0 0 {name=p74979 lab=_68768_/B }
C {devices/lab_pin.sym} 75220 -10200 0 0 {name=p74980 lab=_42718_/X }
C {devices/lab_pin.sym} 75380 -10260 0 1 {name=p74981 lab=_42730_/X }
C {sky130_stdcells/a2bb2o_4.sym} 75300 -10260 0 0 {name=X_42730_ }
C {devices/lab_pin.sym} 75240 -10140 0 0 {name=p74982 lab=_54699_/X }
C {devices/lab_pin.sym} 75240 -10100 0 0 {name=p74983 lab=_54734_/B }
C {devices/lab_pin.sym} 75240 -10060 0 0 {name=p74984 lab=_54721_/C }
C {devices/lab_pin.sym} 75240 -10020 0 0 {name=p74985 lab=_47399_/A }
C {devices/lab_pin.sym} 75360 -10080 0 1 {name=p74986 lab=_54716_/X }
C {sky130_stdcells/and4_4.sym} 75300 -10080 0 0 {name=X_54716_ }
C {devices/lab_pin.sym} 75260 -9930 0 0 {name=p74987 lab=_74140_/A }
C {devices/lab_pin.sym} 75340 -9930 0 1 {name=p74988 lab=_74117_/A }
C {sky130_stdcells/buf_2.sym} 75300 -9930 0 0 {name=X_73550_ }
C {devices/lab_pin.sym} 75210 -9810 0 0 {name=p74989 lab=_85536_/CLK }
C {devices/lab_pin.sym} 75210 -9790 0 0 {name=p74990 lab=_53950_/Y }
C {devices/lab_pin.sym} 75390 -9810 0 1 {name=p74991 lab=_85536_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -9800 0 0 {name=X_85536_ }
C {devices/lab_pin.sym} 75260 -9670 0 0 {name=p74992 lab=_52126_/A }
C {devices/lab_pin.sym} 75340 -9670 0 1 {name=p74993 lab=_51928_/X }
C {sky130_stdcells/buf_2.sym} 75300 -9670 0 0 {name=X_51928_ }
C {devices/lab_pin.sym} 75260 -9550 0 0 {name=p74994 lab=DATA_TO_HASH[7] }
C {devices/lab_pin.sym} 75340 -9550 0 1 {name=p74995 lab=_70763_/A }
C {sky130_stdcells/buf_2.sym} 75300 -9550 0 0 {name=X_70762_ }
C {devices/lab_pin.sym} 75220 -9450 0 0 {name=p74996 lab=_58467_/X }
C {devices/lab_pin.sym} 75220 -9410 0 0 {name=p74997 lab=_58480_/Y }
C {devices/lab_pin.sym} 75220 -9370 0 0 {name=p74998 lab=_58483_/Y }
C {devices/lab_pin.sym} 75380 -9410 0 1 {name=p74999 lab=_84838_/D }
C {sky130_stdcells/a21oi_4.sym} 75300 -9410 0 0 {name=X_58484_ }
C {devices/lab_pin.sym} 75210 -9270 0 0 {name=p75000 lab=_82748_/CLK }
C {devices/lab_pin.sym} 75210 -9250 0 0 {name=p75001 lab=_79455_/B }
C {devices/lab_pin.sym} 75390 -9270 0 1 {name=p75002 lab=_82748_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -9260 0 0 {name=X_82748_ }
C {devices/lab_pin.sym} 75220 -9160 0 0 {name=p75003 lab=_85217_/Q }
C {devices/lab_pin.sym} 75220 -9120 0 0 {name=p75004 lab=_55690_/A }
C {devices/lab_pin.sym} 75220 -9080 0 0 {name=p75005 lab=_55611_/X }
C {devices/lab_pin.sym} 75220 -9040 0 0 {name=p75006 lab=_55695_/X }
C {devices/lab_pin.sym} 75380 -9100 0 1 {name=p75007 lab=_55696_/X }
C {sky130_stdcells/a211o_4.sym} 75300 -9100 0 0 {name=X_55696_ }
C {devices/lab_pin.sym} 75220 -8970 0 0 {name=p75008 lab=_46150_/B }
C {devices/lab_pin.sym} 75220 -8930 0 0 {name=p75009 lab=_83378_/Q }
C {devices/lab_pin.sym} 75220 -8890 0 0 {name=p75010 lab=_72500_/Y }
C {devices/lab_pin.sym} 75380 -8930 0 1 {name=p75011 lab=_83242_/D }
C {sky130_stdcells/o21a_4.sym} 75300 -8930 0 0 {name=X_72501_ }
C {devices/lab_pin.sym} 75240 -8800 0 0 {name=p75012 lab=_85004_/Q }
C {devices/lab_pin.sym} 75240 -8760 0 0 {name=p75013 lab=_57413_/X }
C {devices/lab_pin.sym} 75360 -8780 0 1 {name=p75014 lab=_57435_/X }
C {sky130_stdcells/or2_4.sym} 75300 -8780 0 0 {name=X_57435_ }
C {devices/lab_pin.sym} 75210 -8650 0 0 {name=p75015 lab=_87083_/CLK }
C {devices/lab_pin.sym} 75210 -8630 0 0 {name=p75016 lab=_41222_/Y }
C {devices/lab_pin.sym} 75390 -8650 0 1 {name=p75017 lab=_88255_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -8640 0 0 {name=X_88255_ }
C {devices/lab_pin.sym} 75260 -8510 0 0 {name=p75018 lab=_54034_/A }
C {devices/lab_pin.sym} 75340 -8510 0 1 {name=p75019 lab=_54729_/A }
C {sky130_stdcells/buf_2.sym} 75300 -8510 0 0 {name=X_54647_ }
C {devices/lab_pin.sym} 75220 -8430 0 0 {name=p75020 lab=_42647_/X }
C {devices/lab_pin.sym} 75220 -8390 0 0 {name=p75021 lab=_42648_/X }
C {devices/lab_pin.sym} 75220 -8350 0 0 {name=p75022 lab=_41009_/X }
C {devices/lab_pin.sym} 75220 -8310 0 0 {name=p75023 lab=_87782_/Q }
C {devices/lab_pin.sym} 75220 -8270 0 0 {name=p75024 lab=_42658_/X }
C {devices/lab_pin.sym} 75380 -8350 0 1 {name=p75025 lab=_42661_/Y }
C {sky130_stdcells/o32ai_4.sym} 75300 -8350 0 0 {name=X_42661_ }
C {devices/lab_pin.sym} 75240 -8210 0 0 {name=p75026 lab=_73479_/X }
C {devices/lab_pin.sym} 75240 -8170 0 0 {name=p75027 lab=_73481_/B }
C {devices/lab_pin.sym} 75240 -8130 0 0 {name=p75028 lab=_73481_/C }
C {devices/lab_pin.sym} 75360 -8170 0 1 {name=p75029 lab=_73481_/Y }
C {sky130_stdcells/nand3_4.sym} 75300 -8170 0 0 {name=X_73481_ }
C {devices/lab_pin.sym} 75210 -8030 0 0 {name=p75030 lab=_82206_/CLK }
C {devices/lab_pin.sym} 75210 -8010 0 0 {name=p75031 lab=_54304_/Y }
C {devices/lab_pin.sym} 75390 -8030 0 1 {name=p75032 lab=_85467_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -8020 0 0 {name=X_85467_ }
C {devices/lab_pin.sym} 75260 -7890 0 0 {name=p75033 lab=_51804_/A }
C {devices/lab_pin.sym} 75340 -7890 0 1 {name=p75034 lab=_51870_/A }
C {sky130_stdcells/buf_2.sym} 75300 -7890 0 0 {name=X_51859_ }
C {devices/lab_pin.sym} 75220 -7790 0 0 {name=p75035 lab=_70664_/A }
C {devices/lab_pin.sym} 75220 -7750 0 0 {name=p75036 lab=_47515_/A }
C {devices/lab_pin.sym} 75220 -7710 0 0 {name=p75037 lab=_70692_/Y }
C {devices/lab_pin.sym} 75380 -7750 0 1 {name=p75038 lab=_70693_/X }
C {sky130_stdcells/a21o_4.sym} 75300 -7750 0 0 {name=X_70693_ }
C {devices/lab_pin.sym} 75210 -7610 0 0 {name=p75039 lab=_81216_/CLK }
C {devices/lab_pin.sym} 75210 -7590 0 0 {name=p75040 lab=_82679_/D }
C {devices/lab_pin.sym} 75390 -7610 0 1 {name=p75041 lab=_78231_/A }
C {sky130_stdcells/dfxtp_4.sym} 75300 -7600 0 0 {name=X_82679_ }
C {devices/lab_pin.sym} 75260 -7470 0 0 {name=p75042 lab=_44400_/A }
C {devices/lab_pin.sym} 75340 -7470 0 1 {name=p75043 lab=_44400_/Y }
C {sky130_stdcells/inv_2.sym} 75300 -7470 0 0 {name=X_44400_ }
C {devices/lab_pin.sym} 75240 -7360 0 0 {name=p75044 lab=_75216_/Y }
C {devices/lab_pin.sym} 75240 -7320 0 0 {name=p75045 lab=_75219_/Y }
C {devices/lab_pin.sym} 75360 -7340 0 1 {name=p75046 lab=_81036_/D }
C {sky130_stdcells/xor2_4.sym} 75300 -7340 0 0 {name=X_75220_ }
C {devices/lab_pin.sym} 75210 -7210 0 0 {name=p75047 lab=_87149_/CLK }
C {devices/lab_pin.sym} 75210 -7190 0 0 {name=p75048 lab=_43906_/X }
C {devices/lab_pin.sym} 75390 -7210 0 1 {name=p75049 lab=_67644_/B }
C {sky130_stdcells/dfxtp_4.sym} 75300 -7200 0 0 {name=X_87206_ }
C {devices/lab_pin.sym} 75260 -7070 0 0 {name=p75050 lab=_40637_/A }
C {devices/lab_pin.sym} 75340 -7070 0 1 {name=p75051 lab=_41825_/A }
C {sky130_stdcells/buf_2.sym} 75300 -7070 0 0 {name=X_41612_ }
C {devices/lab_pin.sym} 75220 -6970 0 0 {name=p75052 lab=_72389_/X }
C {devices/lab_pin.sym} 75220 -6930 0 0 {name=p75053 lab=_85671_/Q }
C {devices/lab_pin.sym} 75220 -6890 0 0 {name=p75054 lab=_72422_/X }
C {devices/lab_pin.sym} 75380 -6930 0 1 {name=p75055 lab=_72432_/X }
C {sky130_stdcells/o21a_4.sym} 75300 -6930 0 0 {name=X_72432_ }
C {devices/lab_pin.sym} 75210 -6790 0 0 {name=p75056 lab=_84418_/CLK }
C {devices/lab_pin.sym} 75210 -6770 0 0 {name=p75057 lab=_84418_/D }
C {devices/lab_pin.sym} 75390 -6790 0 1 {name=p75058 lab=_62328_/C }
C {sky130_stdcells/dfxtp_4.sym} 75300 -6780 0 0 {name=X_84418_ }
C {devices/lab_pin.sym} 75260 -6650 0 0 {name=p75059 lab=_45380_/A }
C {devices/lab_pin.sym} 75340 -6650 0 1 {name=p75060 lab=_45381_/A }
C {sky130_stdcells/inv_2.sym} 75300 -6650 0 0 {name=X_45380_ }
C {devices/lab_pin.sym} 75240 -6540 0 0 {name=p75061 lab=_57244_/X }
C {devices/lab_pin.sym} 75240 -6500 0 0 {name=p75062 lab=_45856_/Y }
C {devices/lab_pin.sym} 75360 -6520 0 1 {name=p75063 lab=_57366_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -6520 0 0 {name=X_57366_ }
C {devices/lab_pin.sym} 75210 -6390 0 0 {name=p75064 lab=_87110_/CLK }
C {devices/lab_pin.sym} 75210 -6370 0 0 {name=p75065 lab=_41593_/X }
C {devices/lab_pin.sym} 75390 -6390 0 1 {name=p75066 lab=_88186_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -6380 0 0 {name=X_88186_ }
C {devices/lab_pin.sym} 75260 -6250 0 0 {name=p75067 lab=_42592_/A }
C {devices/lab_pin.sym} 75340 -6250 0 1 {name=p75068 lab=_42592_/X }
C {sky130_stdcells/buf_2.sym} 75300 -6250 0 0 {name=X_42592_ }
C {devices/lab_pin.sym} 75240 -6140 0 0 {name=p75069 lab=_54578_/A }
C {devices/lab_pin.sym} 75240 -6100 0 0 {name=p75070 lab=_54578_/B }
C {devices/lab_pin.sym} 75360 -6120 0 1 {name=p75071 lab=_54578_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -6120 0 0 {name=X_54578_ }
C {devices/lab_pin.sym} 75210 -5990 0 0 {name=p75072 lab=_85492_/CLK }
C {devices/lab_pin.sym} 75210 -5970 0 0 {name=p75073 lab=_54681_/Y }
C {devices/lab_pin.sym} 75390 -5990 0 1 {name=p75074 lab=_85398_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -5980 0 0 {name=X_85398_ }
C {devices/lab_pin.sym} 75260 -5850 0 0 {name=p75075 lab=_58846_/A }
C {devices/lab_pin.sym} 75340 -5850 0 1 {name=p75076 lab=_59105_/X }
C {sky130_stdcells/buf_2.sym} 75300 -5850 0 0 {name=X_59105_ }
C {devices/lab_pin.sym} 75260 -5730 0 0 {name=p75077 lab=_44382_/A }
C {devices/lab_pin.sym} 75340 -5730 0 1 {name=p75078 lab=_44331_/X }
C {sky130_stdcells/buf_2.sym} 75300 -5730 0 0 {name=X_44331_ }
C {devices/lab_pin.sym} 75240 -5630 0 0 {name=p75079 lab=_56309_/A }
C {devices/lab_pin.sym} 75240 -5590 0 0 {name=p75080 lab=_56312_/X }
C {devices/lab_pin.sym} 75240 -5550 0 0 {name=p75081 lab=_56317_/C }
C {devices/lab_pin.sym} 75360 -5590 0 1 {name=p75082 lab=_56317_/Y }
C {sky130_stdcells/nand3_4.sym} 75300 -5590 0 0 {name=X_56317_ }
C {devices/lab_pin.sym} 75240 -5460 0 0 {name=p75083 lab=_80680_/Q }
C {devices/lab_pin.sym} 75240 -5420 0 0 {name=p75084 lab=_75151_/B }
C {devices/lab_pin.sym} 75360 -5440 0 1 {name=p75085 lab=_75151_/Y }
C {sky130_stdcells/nor2_4.sym} 75300 -5440 0 0 {name=X_75151_ }
C {devices/lab_pin.sym} 75210 -5310 0 0 {name=p75086 lab=_87137_/CLK }
C {devices/lab_pin.sym} 75210 -5290 0 0 {name=p75087 lab=_44385_/Y }
C {devices/lab_pin.sym} 75390 -5310 0 1 {name=p75088 lab=_87137_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -5300 0 0 {name=X_87137_ }
C {devices/lab_pin.sym} 75240 -5180 0 0 {name=p75089 lab=_41604_/A }
C {devices/lab_pin.sym} 75240 -5140 0 0 {name=p75090 lab=_82321_/Q }
C {devices/lab_pin.sym} 75360 -5160 0 1 {name=p75091 lab=_41543_/X }
C {sky130_stdcells/or2_4.sym} 75300 -5160 0 0 {name=X_41543_ }
C {devices/lab_pin.sym} 75240 -5040 0 0 {name=p75092 lab=_53503_/X }
C {devices/lab_pin.sym} 75240 -5000 0 0 {name=p75093 lab=_48257_/B }
C {devices/lab_pin.sym} 75360 -5020 0 1 {name=p75094 lab=_53529_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -5020 0 0 {name=X_53529_ }
C {devices/lab_pin.sym} 75220 -4910 0 0 {name=p75095 lab=_72361_/X }
C {devices/lab_pin.sym} 75220 -4870 0 0 {name=p75096 lab=_85677_/Q }
C {devices/lab_pin.sym} 75220 -4830 0 0 {name=p75097 lab=_72362_/X }
C {devices/lab_pin.sym} 75380 -4870 0 1 {name=p75098 lab=_72363_/X }
C {sky130_stdcells/o21a_4.sym} 75300 -4870 0 0 {name=X_72363_ }
C {devices/lab_pin.sym} 75210 -4730 0 0 {name=p75099 lab=_84350_/CLK }
C {devices/lab_pin.sym} 75210 -4710 0 0 {name=p75100 lab=_84349_/D }
C {devices/lab_pin.sym} 75390 -4730 0 1 {name=p75101 lab=_79385_/A }
C {sky130_stdcells/dfxtp_4.sym} 75300 -4720 0 0 {name=X_84349_ }
C {devices/lab_pin.sym} 75220 -4610 0 0 {name=p75102 lab=_57296_/Y }
C {devices/lab_pin.sym} 75220 -4570 0 0 {name=p75103 lab=_57290_/X }
C {devices/lab_pin.sym} 75220 -4530 0 0 {name=p75104 lab=_45888_/A }
C {devices/lab_pin.sym} 75380 -4570 0 1 {name=p75105 lab=_57297_/X }
C {sky130_stdcells/o21a_4.sym} 75300 -4570 0 0 {name=X_57297_ }
C {devices/lab_pin.sym} 75260 -4430 0 0 {name=p75106 lab=clkbuf_3_5_1_CLK/X }
C {devices/lab_pin.sym} 75340 -4430 0 1 {name=p75107 lab=clkbuf_4_11_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 75300 -4430 0 0 {name=Xclkbuf_4_11_0_CLK }
C {devices/lab_pin.sym} 75240 -4320 0 0 {name=p75108 lab=_74102_/A }
C {devices/lab_pin.sym} 75240 -4280 0 0 {name=p75109 lab=_74102_/B }
C {devices/lab_pin.sym} 75360 -4300 0 1 {name=p75110 lab=_74102_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -4300 0 0 {name=X_74102_ }
C {devices/lab_pin.sym} 75260 -4170 0 0 {name=p75111 lab=_47004_/A }
C {devices/lab_pin.sym} 75340 -4170 0 1 {name=p75112 lab=_47050_/X }
C {sky130_stdcells/buf_2.sym} 75300 -4170 0 0 {name=X_47050_ }
C {devices/lab_pin.sym} 75260 -4050 0 0 {name=p75113 lab=_59036_/A }
C {devices/lab_pin.sym} 75340 -4050 0 1 {name=p75114 lab=_59037_/A }
C {sky130_stdcells/buf_2.sym} 75300 -4050 0 0 {name=X_59036_ }
C {devices/lab_pin.sym} 75240 -3950 0 0 {name=p75115 lab=_71500_/A }
C {devices/lab_pin.sym} 75240 -3910 0 0 {name=p75116 lab=_71314_/B }
C {devices/lab_pin.sym} 75240 -3870 0 0 {name=p75117 lab=_71313_/X }
C {devices/lab_pin.sym} 75360 -3910 0 1 {name=p75118 lab=_71314_/Y }
C {sky130_stdcells/nand3_4.sym} 75300 -3910 0 0 {name=X_71314_ }
C {devices/lab_pin.sym} 75260 -3770 0 0 {name=p75119 lab=_64717_/A }
C {devices/lab_pin.sym} 75340 -3770 0 1 {name=p75120 lab=_64725_/A }
C {sky130_stdcells/buf_2.sym} 75300 -3770 0 0 {name=X_44262_ }
C {devices/lab_pin.sym} 75240 -3670 0 0 {name=p75121 lab=_56250_/A }
C {devices/lab_pin.sym} 75240 -3630 0 0 {name=p75122 lab=_56253_/B }
C {devices/lab_pin.sym} 75240 -3590 0 0 {name=p75123 lab=_85260_/Q }
C {devices/lab_pin.sym} 75360 -3630 0 1 {name=p75124 lab=_56248_/Y }
C {sky130_stdcells/nand3_4.sym} 75300 -3630 0 0 {name=X_56248_ }
C {devices/lab_pin.sym} 75240 -3500 0 0 {name=p75125 lab=_80675_/Q }
C {devices/lab_pin.sym} 75240 -3460 0 0 {name=p75126 lab=_75082_/B }
C {devices/lab_pin.sym} 75360 -3480 0 1 {name=p75127 lab=_75082_/X }
C {sky130_stdcells/or2_4.sym} 75300 -3480 0 0 {name=X_75082_ }
C {devices/lab_pin.sym} 75210 -3350 0 0 {name=p75128 lab=_87068_/CLK }
C {devices/lab_pin.sym} 75210 -3330 0 0 {name=p75129 lab=_87068_/D }
C {devices/lab_pin.sym} 75390 -3350 0 1 {name=p75130 lab=_87068_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -3340 0 0 {name=X_87068_ }
C {devices/lab_pin.sym} 75260 -3210 0 0 {name=p75131 lab=_41235_/X }
C {devices/lab_pin.sym} 75340 -3210 0 1 {name=p75132 lab=_41474_/X }
C {sky130_stdcells/buf_2.sym} 75300 -3210 0 0 {name=X_41474_ }
C {devices/lab_pin.sym} 75240 -3100 0 0 {name=p75133 lab=_72366_/A }
C {devices/lab_pin.sym} 75240 -3060 0 0 {name=p75134 lab=_72294_/B }
C {devices/lab_pin.sym} 75360 -3080 0 1 {name=p75135 lab=_72294_/Y }
C {sky130_stdcells/nor2_4.sym} 75300 -3080 0 0 {name=X_72294_ }
C {devices/lab_pin.sym} 75260 -2950 0 0 {name=p75136 lab=_46001_/A }
C {devices/lab_pin.sym} 75340 -2950 0 1 {name=p75137 lab=_46001_/X }
C {sky130_stdcells/buf_2.sym} 75300 -2950 0 0 {name=X_46001_ }
C {devices/lab_pin.sym} 75220 -2870 0 0 {name=p75138 lab=_43196_/X }
C {devices/lab_pin.sym} 75220 -2830 0 0 {name=p75139 lab=_43207_/X }
C {devices/lab_pin.sym} 75220 -2790 0 0 {name=p75140 lab=_40959_/X }
C {devices/lab_pin.sym} 75220 -2750 0 0 {name=p75141 lab=_87535_/Q }
C {devices/lab_pin.sym} 75220 -2710 0 0 {name=p75142 lab=_43212_/X }
C {devices/lab_pin.sym} 75380 -2790 0 1 {name=p75143 lab=_43214_/A }
C {sky130_stdcells/o32ai_4.sym} 75300 -2790 0 0 {name=X_43213_ }
C {devices/lab_pin.sym} 75260 -2630 0 0 {name=p75144 lab=_82638_/Q }
C {devices/lab_pin.sym} 75340 -2630 0 1 {name=p75145 lab=_78912_/A }
C {sky130_stdcells/inv_2.sym} 75300 -2630 0 0 {name=X_78910_ }
C {devices/lab_pin.sym} 75210 -2510 0 0 {name=p75146 lab=_85953_/CLK }
C {devices/lab_pin.sym} 75210 -2490 0 0 {name=p75147 lab=_51393_/Y }
C {devices/lab_pin.sym} 75390 -2510 0 1 {name=p75148 lab=_86019_/Q }
C {sky130_stdcells/dfxtp_4.sym} 75300 -2500 0 0 {name=X_86019_ }
C {devices/lab_pin.sym} 75240 -2380 0 0 {name=p75149 lab=_74033_/A }
C {devices/lab_pin.sym} 75240 -2340 0 0 {name=p75150 lab=_73873_/B }
C {devices/lab_pin.sym} 75360 -2360 0 1 {name=p75151 lab=_74033_/Y }
C {sky130_stdcells/nor2_4.sym} 75300 -2360 0 0 {name=X_74033_ }
C {devices/lab_pin.sym} 75220 -2250 0 0 {name=p75152 lab=_40421_/X }
C {devices/lab_pin.sym} 75220 -2210 0 0 {name=p75153 lab=_81175_/Q }
C {devices/lab_pin.sym} 75220 -2170 0 0 {name=p75154 lab=_40424_/X }
C {devices/lab_pin.sym} 75380 -2210 0 1 {name=p75155 lab=_40425_/X }
C {sky130_stdcells/o21a_4.sym} 75300 -2210 0 0 {name=X_40425_ }
C {devices/lab_pin.sym} 75260 -2070 0 0 {name=p75156 lab=_70809_/A }
C {devices/lab_pin.sym} 75340 -2070 0 1 {name=p75157 lab=_71246_/B }
C {sky130_stdcells/buf_2.sym} 75300 -2070 0 0 {name=X_71245_ }
C {devices/lab_pin.sym} 75260 -1950 0 0 {name=p75158 lab=_72745_/A }
C {devices/lab_pin.sym} 75340 -1950 0 1 {name=p75159 lab=_73948_/A }
C {sky130_stdcells/buf_2.sym} 75300 -1950 0 0 {name=X_44193_ }
C {devices/lab_pin.sym} 75260 -1830 0 0 {name=p75160 lab=_44187_/A }
C {devices/lab_pin.sym} 75340 -1830 0 1 {name=p75161 lab=_73378_/A }
C {sky130_stdcells/buf_2.sym} 75300 -1830 0 0 {name=X_56179_ }
C {devices/lab_pin.sym} 75240 -1720 0 0 {name=p75162 lab=_79890_/A }
C {devices/lab_pin.sym} 75240 -1680 0 0 {name=p75163 lab=_79890_/B }
C {devices/lab_pin.sym} 75360 -1700 0 1 {name=p75164 lab=_79890_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -1700 0 0 {name=X_79890_ }
C {devices/lab_pin.sym} 75220 -1610 0 0 {name=p75165 lab=_43100_/X }
C {devices/lab_pin.sym} 75220 -1570 0 0 {name=p75166 lab=_43110_/X }
C {devices/lab_pin.sym} 75220 -1530 0 0 {name=p75167 lab=_40826_/X }
C {devices/lab_pin.sym} 75220 -1490 0 0 {name=p75168 lab=_73083_/A }
C {devices/lab_pin.sym} 75220 -1450 0 0 {name=p75169 lab=_43121_/X }
C {devices/lab_pin.sym} 75380 -1530 0 1 {name=p75170 lab=_43145_/A }
C {sky130_stdcells/o32ai_4.sym} 75300 -1530 0 0 {name=X_43144_ }
C {devices/lab_pin.sym} 75240 -1380 0 0 {name=p75171 lab=_78833_/Y }
C {devices/lab_pin.sym} 75240 -1340 0 0 {name=p75172 lab=_78841_/B }
C {devices/lab_pin.sym} 75360 -1360 0 1 {name=p75173 lab=_78841_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -1360 0 0 {name=X_78841_ }
C {devices/lab_pin.sym} 75220 -1260 0 0 {name=p75174 lab=_40331_/X }
C {devices/lab_pin.sym} 75220 -1220 0 0 {name=p75175 lab=_40342_/X }
C {devices/lab_pin.sym} 75220 -1180 0 0 {name=p75176 lab=_88402_/Q }
C {devices/lab_pin.sym} 75220 -1140 0 0 {name=p75177 lab=_40355_/X }
C {devices/lab_pin.sym} 75380 -1200 0 1 {name=p75178 lab=_88402_/D }
C {sky130_stdcells/a2bb2o_4.sym} 75300 -1200 0 0 {name=X_40356_ }
C {devices/lab_pin.sym} 75220 -1070 0 0 {name=p75179 lab=_48482_/B }
C {devices/lab_pin.sym} 75220 -1030 0 0 {name=p75180 lab=_71165_/X }
C {devices/lab_pin.sym} 75220 -990 0 0 {name=p75181 lab=_71175_/Y }
C {devices/lab_pin.sym} 75380 -1030 0 1 {name=p75182 lab=_71176_/Y }
C {sky130_stdcells/o21ai_4.sym} 75300 -1030 0 0 {name=X_71176_ }
C {devices/lab_pin.sym} 75240 -920 0 0 {name=p75183 lab=_70118_/Y }
C {devices/lab_pin.sym} 75240 -880 0 0 {name=p75184 lab=_70119_/Y }
C {devices/lab_pin.sym} 75240 -840 0 0 {name=p75185 lab=_70127_/C }
C {devices/lab_pin.sym} 75240 -800 0 0 {name=p75186 lab=_70127_/D }
C {devices/lab_pin.sym} 75360 -860 0 1 {name=p75187 lab=_70127_/X }
C {sky130_stdcells/and4_4.sym} 75300 -860 0 0 {name=X_70127_ }
C {devices/lab_pin.sym} 75240 -720 0 0 {name=p75188 lab=_47988_/A }
C {devices/lab_pin.sym} 75240 -680 0 0 {name=p75189 lab=_48236_/B }
C {devices/lab_pin.sym} 75360 -700 0 1 {name=p75190 lab=_47952_/Y }
C {sky130_stdcells/nand2_4.sym} 75300 -700 0 0 {name=X_47952_ }
C {devices/lab_pin.sym} 76180 -42150 0 0 {name=p75191 lab=_43017_/A }
C {devices/lab_pin.sym} 76260 -42150 0 1 {name=p75192 lab=_43075_/X }
C {sky130_stdcells/buf_2.sym} 76220 -42150 0 0 {name=X_43075_ }
C {devices/lab_pin.sym} 76140 -42070 0 0 {name=p75193 lab=_59887_/Y }
C {devices/lab_pin.sym} 76140 -42030 0 0 {name=p75194 lab=_59892_/Y }
C {devices/lab_pin.sym} 76140 -41990 0 0 {name=p75195 lab=_60165_/A }
C {devices/lab_pin.sym} 76140 -41950 0 0 {name=p75196 lab=_59881_/X }
C {devices/lab_pin.sym} 76140 -41910 0 0 {name=p75197 lab=_59884_/X }
C {devices/lab_pin.sym} 76300 -41990 0 1 {name=p75198 lab=_59938_/Y }
C {sky130_stdcells/a32oi_4.sym} 76220 -41990 0 0 {name=X_59938_ }
C {devices/lab_pin.sym} 76160 -41840 0 0 {name=p75199 lab=_78772_/A }
C {devices/lab_pin.sym} 76160 -41800 0 0 {name=p75200 lab=_78746_/Y }
C {devices/lab_pin.sym} 76280 -41820 0 1 {name=p75201 lab=_78780_/A }
C {sky130_stdcells/or2_4.sym} 76220 -41820 0 0 {name=X_78772_ }
C {devices/lab_pin.sym} 76160 -41700 0 0 {name=p75202 lab=_81706_/D }
C {devices/lab_pin.sym} 76160 -41660 0 0 {name=p75203 lab=_75972_/B }
C {devices/lab_pin.sym} 76280 -41680 0 1 {name=p75204 lab=_75984_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -41680 0 0 {name=X_75984_ }
C {devices/lab_pin.sym} 76180 -41550 0 0 {name=p75205 lab=_46903_/A }
C {devices/lab_pin.sym} 76260 -41550 0 1 {name=p75206 lab=_46926_/C }
C {sky130_stdcells/buf_2.sym} 76220 -41550 0 0 {name=X_46903_ }
C {devices/lab_pin.sym} 76140 -41470 0 0 {name=p75207 lab=_42013_/X }
C {devices/lab_pin.sym} 76140 -41430 0 0 {name=p75208 lab=_42024_/X }
C {devices/lab_pin.sym} 76140 -41390 0 0 {name=p75209 lab=_40854_/X }
C {devices/lab_pin.sym} 76140 -41350 0 0 {name=p75210 lab=_73196_/A }
C {devices/lab_pin.sym} 76140 -41310 0 0 {name=p75211 lab=_42025_/X }
C {devices/lab_pin.sym} 76300 -41390 0 1 {name=p75212 lab=_42027_/A }
C {sky130_stdcells/o32ai_4.sym} 76220 -41390 0 0 {name=X_42026_ }
C {devices/lab_pin.sym} 76160 -41250 0 0 {name=p75213 lab=_77723_/A }
C {devices/lab_pin.sym} 76160 -41210 0 0 {name=p75214 lab=_77721_/A }
C {devices/lab_pin.sym} 76160 -41170 0 0 {name=p75215 lab=_77723_/C }
C {devices/lab_pin.sym} 76280 -41210 0 1 {name=p75216 lab=_77724_/B }
C {sky130_stdcells/nand3_4.sym} 76220 -41210 0 0 {name=X_77723_ }
C {devices/lab_pin.sym} 76180 -41070 0 0 {name=p75217 lab=clkbuf_9_502_0_CLK/X }
C {devices/lab_pin.sym} 76260 -41070 0 1 {name=p75218 lab=_85590_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 76220 -41070 0 0 {name=Xclkbuf_10_1004_0_CLK }
C {devices/lab_pin.sym} 76160 -40960 0 0 {name=p75219 lab=_74935_/A }
C {devices/lab_pin.sym} 76160 -40920 0 0 {name=p75220 lab=_74935_/B }
C {devices/lab_pin.sym} 76280 -40940 0 1 {name=p75221 lab=_81191_/D }
C {sky130_stdcells/xor2_4.sym} 76220 -40940 0 0 {name=X_74935_ }
C {devices/lab_pin.sym} 76140 -40840 0 0 {name=p75222 lab=_70040_/X }
C {devices/lab_pin.sym} 76140 -40800 0 0 {name=p75223 lab=_69844_/Y }
C {devices/lab_pin.sym} 76140 -40760 0 0 {name=p75224 lab=_70056_/X }
C {devices/lab_pin.sym} 76140 -40720 0 0 {name=p75225 lab=_70057_/Y }
C {devices/lab_pin.sym} 76300 -40780 0 1 {name=p75226 lab=_70058_/X }
C {sky130_stdcells/a211o_4.sym} 76220 -40780 0 0 {name=X_70058_ }
C {devices/lab_pin.sym} 76140 -40650 0 0 {name=p75227 lab=_86589_/Q }
C {devices/lab_pin.sym} 76140 -40610 0 0 {name=p75228 lab=_47840_/X }
C {devices/lab_pin.sym} 76140 -40570 0 0 {name=p75229 lab=_47882_/Y }
C {devices/lab_pin.sym} 76300 -40610 0 1 {name=p75230 lab=_47883_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -40610 0 0 {name=X_47883_ }
C {devices/lab_pin.sym} 76140 -40510 0 0 {name=p75231 lab=_59850_/Y }
C {devices/lab_pin.sym} 76140 -40470 0 0 {name=p75232 lab=_59789_/Y }
C {devices/lab_pin.sym} 76140 -40430 0 0 {name=p75233 lab=_59724_/Y }
C {devices/lab_pin.sym} 76140 -40390 0 0 {name=p75234 lab=_59866_/Y }
C {devices/lab_pin.sym} 76140 -40350 0 0 {name=p75235 lab=_59868_/X }
C {devices/lab_pin.sym} 76300 -40430 0 1 {name=p75236 lab=_59869_/Y }
C {sky130_stdcells/a32oi_4.sym} 76220 -40430 0 0 {name=X_59869_ }
C {devices/lab_pin.sym} 76140 -40290 0 0 {name=p75237 lab=_86353_/Q }
C {devices/lab_pin.sym} 76140 -40250 0 0 {name=p75238 lab=_49606_/X }
C {devices/lab_pin.sym} 76140 -40210 0 0 {name=p75239 lab=_49621_/Y }
C {devices/lab_pin.sym} 76300 -40250 0 1 {name=p75240 lab=_49622_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -40250 0 0 {name=X_49622_ }
C {devices/lab_pin.sym} 76140 -40130 0 0 {name=p75241 lab=_61896_/Y }
C {devices/lab_pin.sym} 76140 -40090 0 0 {name=p75242 lab=_61881_/X }
C {devices/lab_pin.sym} 76140 -40050 0 0 {name=p75243 lab=_61899_/Y }
C {devices/lab_pin.sym} 76300 -40090 0 1 {name=p75244 lab=_61900_/Y }
C {sky130_stdcells/a21oi_4.sym} 76220 -40090 0 0 {name=X_61900_ }
C {devices/lab_pin.sym} 76160 -39960 0 0 {name=p75245 lab=_46817_/A }
C {devices/lab_pin.sym} 76160 -39920 0 0 {name=p75246 lab=_51008_/B }
C {devices/lab_pin.sym} 76280 -39940 0 1 {name=p75247 lab=_46834_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -39940 0 0 {name=X_46834_ }
C {devices/lab_pin.sym} 76180 -39810 0 0 {name=p75248 lab=_77653_/Y }
C {devices/lab_pin.sym} 76260 -39810 0 1 {name=p75249 lab=_77654_/Y }
C {sky130_stdcells/inv_2.sym} 76220 -39810 0 0 {name=X_77654_ }
C {devices/lab_pin.sym} 76160 -39720 0 0 {name=p75250 lab=_62847_/X }
C {devices/lab_pin.sym} 76160 -39680 0 0 {name=p75251 lab=_63230_/A }
C {devices/lab_pin.sym} 76160 -39640 0 0 {name=p75252 lab=_62911_/C }
C {devices/lab_pin.sym} 76160 -39600 0 0 {name=p75253 lab=_62880_/D }
C {devices/lab_pin.sym} 76280 -39660 0 1 {name=p75254 lab=_62880_/X }
C {sky130_stdcells/and4_4.sym} 76220 -39660 0 0 {name=X_62880_ }
C {devices/lab_pin.sym} 76140 -39530 0 0 {name=p75255 lab=_74860_/Y }
C {devices/lab_pin.sym} 76140 -39490 0 0 {name=p75256 lab=_74865_/Y }
C {devices/lab_pin.sym} 76140 -39450 0 0 {name=p75257 lab=_74856_/Y }
C {devices/lab_pin.sym} 76300 -39490 0 1 {name=p75258 lab=_74866_/Y }
C {sky130_stdcells/a21oi_4.sym} 76220 -39490 0 0 {name=X_74866_ }
C {devices/lab_pin.sym} 76140 -39370 0 0 {name=p75259 lab=_76583_/Y }
C {devices/lab_pin.sym} 76140 -39330 0 0 {name=p75260 lab=_76616_/B }
C {devices/lab_pin.sym} 76140 -39290 0 0 {name=p75261 lab=_76614_/C }
C {devices/lab_pin.sym} 76300 -39330 0 1 {name=p75262 lab=_76605_/X }
C {sky130_stdcells/o21a_4.sym} 76220 -39330 0 0 {name=X_76605_ }
C {devices/lab_pin.sym} 76180 -39190 0 0 {name=p75263 lab=_49580_/A }
C {devices/lab_pin.sym} 76260 -39190 0 1 {name=p75264 lab=_49558_/A }
C {sky130_stdcells/buf_2.sym} 76220 -39190 0 0 {name=X_49553_ }
C {devices/lab_pin.sym} 76180 -39070 0 0 {name=p75265 lab=_84723_/Q }
C {devices/lab_pin.sym} 76260 -39070 0 1 {name=p75266 lab=_61831_/X }
C {sky130_stdcells/buf_2.sym} 76220 -39070 0 0 {name=X_61831_ }
C {devices/lab_pin.sym} 76140 -38970 0 0 {name=p75267 lab=_70102_/A }
C {devices/lab_pin.sym} 76140 -38930 0 0 {name=p75268 lab=_73697_/X }
C {devices/lab_pin.sym} 76140 -38890 0 0 {name=p75269 lab=_73816_/X }
C {devices/lab_pin.sym} 76300 -38930 0 1 {name=p75270 lab=_83135_/D }
C {sky130_stdcells/o21ai_4.sym} 76220 -38930 0 0 {name=X_73817_ }
C {devices/lab_pin.sym} 76140 -38810 0 0 {name=p75271 lab=_46760_/Y }
C {devices/lab_pin.sym} 76140 -38770 0 0 {name=p75272 lab=_46751_/X }
C {devices/lab_pin.sym} 76140 -38730 0 0 {name=p75273 lab=_46764_/X }
C {devices/lab_pin.sym} 76300 -38770 0 1 {name=p75274 lab=_86706_/D }
C {sky130_stdcells/a21oi_4.sym} 76220 -38770 0 0 {name=X_46765_ }
C {devices/lab_pin.sym} 76140 -38650 0 0 {name=p75275 lab=_77584_/B }
C {devices/lab_pin.sym} 76140 -38610 0 0 {name=p75276 lab=_77584_/C }
C {devices/lab_pin.sym} 76140 -38570 0 0 {name=p75277 lab=_77584_/A }
C {devices/lab_pin.sym} 76300 -38610 0 1 {name=p75278 lab=_77585_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -38610 0 0 {name=X_77585_ }
C {devices/lab_pin.sym} 76140 -38490 0 0 {name=p75279 lab=_43973_/X }
C {devices/lab_pin.sym} 76140 -38450 0 0 {name=p75280 lab=_43976_/X }
C {devices/lab_pin.sym} 76140 -38410 0 0 {name=p75281 lab=_80669_/Q }
C {devices/lab_pin.sym} 76300 -38450 0 1 {name=p75282 lab=_59899_/B }
C {sky130_stdcells/a21o_4.sym} 76220 -38450 0 0 {name=X_43977_ }
C {devices/lab_pin.sym} 76160 -38340 0 0 {name=p75283 lab=_74797_/A }
C {devices/lab_pin.sym} 76160 -38300 0 0 {name=p75284 lab=_74804_/A }
C {devices/lab_pin.sym} 76160 -38260 0 0 {name=p75285 lab=_74797_/C }
C {devices/lab_pin.sym} 76160 -38220 0 0 {name=p75286 lab=_71738_/X }
C {devices/lab_pin.sym} 76280 -38280 0 1 {name=p75287 lab=_74798_/D }
C {sky130_stdcells/nand4_4.sym} 76220 -38280 0 0 {name=X_74797_ }
C {devices/lab_pin.sym} 76180 -38130 0 0 {name=p75288 lab=_74428_/B }
C {devices/lab_pin.sym} 76260 -38130 0 1 {name=p75289 lab=_52163_/B }
C {sky130_stdcells/buf_2.sym} 76220 -38130 0 0 {name=X_48504_ }
C {devices/lab_pin.sym} 76180 -38010 0 0 {name=p75290 lab=clkbuf_9_509_0_CLK/X }
C {devices/lab_pin.sym} 76260 -38010 0 1 {name=p75291 lab=_85859_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 76220 -38010 0 0 {name=Xclkbuf_10_1019_0_CLK }
C {devices/lab_pin.sym} 76160 -37900 0 0 {name=p75292 lab=_79324_/A }
C {devices/lab_pin.sym} 76160 -37860 0 0 {name=p75293 lab=_79324_/B }
C {devices/lab_pin.sym} 76280 -37880 0 1 {name=p75294 lab=_79324_/X }
C {sky130_stdcells/or2_4.sym} 76220 -37880 0 0 {name=X_79324_ }
C {devices/lab_pin.sym} 76180 -37750 0 0 {name=p75295 lab=_63241_/B }
C {devices/lab_pin.sym} 76260 -37750 0 1 {name=p75296 lab=_61572_/A }
C {sky130_stdcells/buf_2.sym} 76220 -37750 0 0 {name=X_45716_ }
C {devices/lab_pin.sym} 76140 -37650 0 0 {name=p75297 lab=_64543_/Y }
C {devices/lab_pin.sym} 76140 -37610 0 0 {name=p75298 lab=_64549_/X }
C {devices/lab_pin.sym} 76140 -37570 0 0 {name=p75299 lab=_60074_/X }
C {devices/lab_pin.sym} 76300 -37610 0 1 {name=p75300 lab=_64550_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -37610 0 0 {name=X_64550_ }
C {devices/lab_pin.sym} 76140 -37490 0 0 {name=p75301 lab=_76535_/B }
C {devices/lab_pin.sym} 76140 -37450 0 0 {name=p75302 lab=_76534_/Y }
C {devices/lab_pin.sym} 76140 -37410 0 0 {name=p75303 lab=_76531_/Y }
C {devices/lab_pin.sym} 76300 -37450 0 1 {name=p75304 lab=_76540_/C }
C {sky130_stdcells/o21ai_4.sym} 76220 -37450 0 0 {name=X_76536_ }
C {devices/lab_pin.sym} 76180 -37310 0 0 {name=p75305 lab=_42927_/Y }
C {devices/lab_pin.sym} 76260 -37310 0 1 {name=p75306 lab=_87647_/D }
C {sky130_stdcells/inv_2.sym} 76220 -37310 0 0 {name=X_42928_ }
C {devices/lab_pin.sym} 76140 -37210 0 0 {name=p75307 lab=_49482_/Y }
C {devices/lab_pin.sym} 76140 -37170 0 0 {name=p75308 lab=_49460_/X }
C {devices/lab_pin.sym} 76140 -37130 0 0 {name=p75309 lab=_49483_/X }
C {devices/lab_pin.sym} 76300 -37170 0 1 {name=p75310 lab=_86379_/D }
C {sky130_stdcells/a21oi_4.sym} 76220 -37170 0 0 {name=X_49484_ }
C {devices/lab_pin.sym} 76180 -37030 0 0 {name=p75311 lab=_59456_/A }
C {devices/lab_pin.sym} 76260 -37030 0 1 {name=p75312 lab=_61762_/X }
C {sky130_stdcells/buf_2.sym} 76220 -37030 0 0 {name=X_61762_ }
C {devices/lab_pin.sym} 76140 -36930 0 0 {name=p75313 lab=_73746_/X }
C {devices/lab_pin.sym} 76140 -36890 0 0 {name=p75314 lab=_73747_/Y }
C {devices/lab_pin.sym} 76140 -36850 0 0 {name=p75315 lab=_73720_/X }
C {devices/lab_pin.sym} 76300 -36890 0 1 {name=p75316 lab=_73748_/X }
C {sky130_stdcells/a21o_4.sym} 76220 -36890 0 0 {name=X_73748_ }
C {devices/lab_pin.sym} 76180 -36750 0 0 {name=p75317 lab=_46696_/A }
C {devices/lab_pin.sym} 76260 -36750 0 1 {name=p75318 lab=_54312_/D }
C {sky130_stdcells/inv_2.sym} 76220 -36750 0 0 {name=X_46696_ }
C {devices/lab_pin.sym} 76180 -36630 0 0 {name=p75319 lab=_63375_/A }
C {devices/lab_pin.sym} 76260 -36630 0 1 {name=p75320 lab=_63512_/A }
C {sky130_stdcells/buf_2.sym} 76220 -36630 0 0 {name=X_63501_ }
C {devices/lab_pin.sym} 76180 -36510 0 0 {name=p75321 lab=_60713_/A }
C {devices/lab_pin.sym} 76260 -36510 0 1 {name=p75322 lab=_63417_/A }
C {sky130_stdcells/buf_2.sym} 76220 -36510 0 0 {name=X_60713_ }
C {devices/lab_pin.sym} 76160 -36400 0 0 {name=p75323 lab=_48469_/A }
C {devices/lab_pin.sym} 76160 -36360 0 0 {name=p75324 lab=_48435_/B }
C {devices/lab_pin.sym} 76280 -36380 0 1 {name=p75325 lab=_48435_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -36380 0 0 {name=X_48435_ }
C {devices/lab_pin.sym} 76160 -36260 0 0 {name=p75326 lab=_84792_/Q }
C {devices/lab_pin.sym} 76160 -36220 0 0 {name=p75327 lab=_66495_/C }
C {devices/lab_pin.sym} 76280 -36240 0 1 {name=p75328 lab=_79255_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -36240 0 0 {name=X_79255_ }
C {devices/lab_pin.sym} 76180 -36110 0 0 {name=p75329 lab=_45647_/A }
C {devices/lab_pin.sym} 76260 -36110 0 1 {name=p75330 lab=_45647_/Y }
C {sky130_stdcells/inv_2.sym} 76220 -36110 0 0 {name=X_45647_ }
C {devices/lab_pin.sym} 76140 -36010 0 0 {name=p75331 lab=_76448_/B }
C {devices/lab_pin.sym} 76140 -35970 0 0 {name=p75332 lab=_76482_/C }
C {devices/lab_pin.sym} 76140 -35930 0 0 {name=p75333 lab=_76482_/A }
C {devices/lab_pin.sym} 76300 -35970 0 1 {name=p75334 lab=_76468_/B }
C {sky130_stdcells/a21boi_4.sym} 76220 -35970 0 0 {name=X_76467_ }
C {devices/lab_pin.sym} 76160 -35850 0 0 {name=p75335 lab=_64490_/A }
C {devices/lab_pin.sym} 76160 -35810 0 0 {name=p75336 lab=_64490_/B }
C {devices/lab_pin.sym} 76160 -35770 0 0 {name=p75337 lab=_79637_/B }
C {devices/lab_pin.sym} 76280 -35810 0 1 {name=p75338 lab=_64481_/Y }
C {sky130_stdcells/nor3_4.sym} 76220 -35810 0 0 {name=X_64481_ }
C {devices/lab_pin.sym} 76140 -35710 0 0 {name=p75339 lab=_42847_/X }
C {devices/lab_pin.sym} 76140 -35670 0 0 {name=p75340 lab=_42849_/X }
C {devices/lab_pin.sym} 76140 -35630 0 0 {name=p75341 lab=_41545_/X }
C {devices/lab_pin.sym} 76140 -35590 0 0 {name=p75342 lab=_66959_/B }
C {devices/lab_pin.sym} 76140 -35550 0 0 {name=p75343 lab=_42858_/X }
C {devices/lab_pin.sym} 76300 -35630 0 1 {name=p75344 lab=_42860_/A }
C {sky130_stdcells/o32ai_4.sym} 76220 -35630 0 0 {name=X_42859_ }
C {devices/lab_pin.sym} 76180 -35470 0 0 {name=p75345 lab=_84730_/Q }
C {devices/lab_pin.sym} 76260 -35470 0 1 {name=p75346 lab=_61694_/B }
C {sky130_stdcells/buf_2.sym} 76220 -35470 0 0 {name=X_61693_ }
C {devices/lab_pin.sym} 76180 -35350 0 0 {name=p75347 lab=_72951_/A }
C {devices/lab_pin.sym} 76260 -35350 0 1 {name=p75348 lab=_73679_/X }
C {sky130_stdcells/buf_2.sym} 76220 -35350 0 0 {name=X_73679_ }
C {devices/lab_pin.sym} 76160 -35240 0 0 {name=p75349 lab=_66181_/A }
C {devices/lab_pin.sym} 76160 -35200 0 0 {name=p75350 lab=_85899_/Q }
C {devices/lab_pin.sym} 76280 -35220 0 1 {name=p75351 lab=_66220_/X }
C {sky130_stdcells/and2_4.sym} 76220 -35220 0 0 {name=X_66220_ }
C {devices/lab_pin.sym} 76160 -35100 0 0 {name=p75352 lab=_78198_/A }
C {devices/lab_pin.sym} 76160 -35060 0 0 {name=p75353 lab=_82491_/Q }
C {devices/lab_pin.sym} 76280 -35080 0 1 {name=p75354 lab=_78206_/Y }
C {sky130_stdcells/nor2_4.sym} 76220 -35080 0 0 {name=X_78206_ }
C {devices/lab_pin.sym} 76160 -34970 0 0 {name=p75355 lab=_63456_/A }
C {devices/lab_pin.sym} 76160 -34930 0 0 {name=p75356 lab=_63456_/B }
C {devices/lab_pin.sym} 76160 -34890 0 0 {name=p75357 lab=_80568_/B }
C {devices/lab_pin.sym} 76280 -34930 0 1 {name=p75358 lab=_63432_/Y }
C {sky130_stdcells/nor3_4.sym} 76220 -34930 0 0 {name=X_63432_ }
C {devices/lab_pin.sym} 76160 -34810 0 0 {name=p75359 lab=_75413_/X }
C {devices/lab_pin.sym} 76160 -34770 0 0 {name=p75360 lab=_75416_/Y }
C {devices/lab_pin.sym} 76160 -34730 0 0 {name=p75361 lab=_75414_/Y }
C {devices/lab_pin.sym} 76280 -34770 0 1 {name=p75362 lab=_75435_/D }
C {sky130_stdcells/nand3_4.sym} 76220 -34770 0 0 {name=X_75418_ }
C {devices/lab_pin.sym} 76140 -34650 0 0 {name=p75363 lab=_48360_/Y }
C {devices/lab_pin.sym} 76140 -34610 0 0 {name=p75364 lab=_48302_/X }
C {devices/lab_pin.sym} 76140 -34570 0 0 {name=p75365 lab=_48365_/X }
C {devices/lab_pin.sym} 76300 -34610 0 1 {name=p75366 lab=_86529_/D }
C {sky130_stdcells/a21oi_4.sym} 76220 -34610 0 0 {name=X_48366_ }
C {devices/lab_pin.sym} 76160 -34490 0 0 {name=p75367 lab=_60642_/C }
C {devices/lab_pin.sym} 76160 -34450 0 0 {name=p75368 lab=_60616_/Y }
C {devices/lab_pin.sym} 76160 -34410 0 0 {name=p75369 lab=_60644_/C }
C {devices/lab_pin.sym} 76280 -34450 0 1 {name=p75370 lab=_60644_/X }
C {sky130_stdcells/and3_4.sym} 76220 -34450 0 0 {name=X_60644_ }
C {devices/lab_pin.sym} 76160 -34320 0 0 {name=p75371 lab=_79185_/B }
C {devices/lab_pin.sym} 76160 -34280 0 0 {name=p75372 lab=_79185_/C }
C {devices/lab_pin.sym} 76280 -34300 0 1 {name=p75373 lab=_79186_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -34300 0 0 {name=X_79186_ }
C {devices/lab_pin.sym} 76180 -34170 0 0 {name=p75374 lab=_63137_/B }
C {devices/lab_pin.sym} 76260 -34170 0 1 {name=p75375 lab=_61468_/A }
C {sky130_stdcells/buf_2.sym} 76220 -34170 0 0 {name=X_45578_ }
C {devices/lab_pin.sym} 76160 -34060 0 0 {name=p75376 lab=_76398_/A }
C {devices/lab_pin.sym} 76160 -34020 0 0 {name=p75377 lab=_81651_/Q }
C {devices/lab_pin.sym} 76280 -34040 0 1 {name=p75378 lab=_76399_/A }
C {sky130_stdcells/nand2_4.sym} 76220 -34040 0 0 {name=X_76398_ }
C {devices/lab_pin.sym} 76180 -33910 0 0 {name=p75379 lab=_47128_/A }
C {devices/lab_pin.sym} 76260 -33910 0 1 {name=p75380 lab=_47317_/X }
C {sky130_stdcells/buf_2.sym} 76220 -33910 0 0 {name=X_47317_ }
C {devices/lab_pin.sym} 76160 -33810 0 0 {name=p75381 lab=_66123_/A }
C {devices/lab_pin.sym} 76160 -33770 0 0 {name=p75382 lab=_66151_/B }
C {devices/lab_pin.sym} 76160 -33730 0 0 {name=p75383 lab=_84153_/Q }
C {devices/lab_pin.sym} 76280 -33770 0 1 {name=p75384 lab=_66151_/X }
C {sky130_stdcells/and3_4.sym} 76220 -33770 0 0 {name=X_66151_ }
C {devices/lab_pin.sym} 76160 -33640 0 0 {name=p75385 lab=_78131_/Y }
C {devices/lab_pin.sym} 76160 -33600 0 0 {name=p75386 lab=_78136_/X }
C {devices/lab_pin.sym} 76280 -33620 0 1 {name=p75387 lab=_78137_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -33620 0 0 {name=X_78137_ }
C {devices/lab_pin.sym} 76180 -33490 0 0 {name=p75388 lab=_44529_/A }
C {devices/lab_pin.sym} 76260 -33490 0 1 {name=p75389 lab=_44529_/X }
C {sky130_stdcells/buf_2.sym} 76220 -33490 0 0 {name=X_44529_ }
C {devices/lab_pin.sym} 76180 -33370 0 0 {name=p75390 lab=_63363_/A }
C {devices/lab_pin.sym} 76260 -33370 0 1 {name=p75391 lab=_63363_/X }
C {sky130_stdcells/buf_2.sym} 76220 -33370 0 0 {name=X_63363_ }
C {devices/lab_pin.sym} 76160 -33260 0 0 {name=p75392 lab=_80693_/Q }
C {devices/lab_pin.sym} 76160 -33220 0 0 {name=p75393 lab=_80949_/D }
C {devices/lab_pin.sym} 76280 -33240 0 1 {name=p75394 lab=_75349_/Y }
C {sky130_stdcells/nor2_4.sym} 76220 -33240 0 0 {name=X_75349_ }
C {devices/lab_pin.sym} 76140 -33150 0 0 {name=p75395 lab=_60570_/X }
C {devices/lab_pin.sym} 76140 -33110 0 0 {name=p75396 lab=_60571_/Y }
C {devices/lab_pin.sym} 76140 -33070 0 0 {name=p75397 lab=_60546_/A }
C {devices/lab_pin.sym} 76140 -33030 0 0 {name=p75398 lab=_60572_/X }
C {devices/lab_pin.sym} 76140 -32990 0 0 {name=p75399 lab=_60574_/X }
C {devices/lab_pin.sym} 76300 -33070 0 1 {name=p75400 lab=_60575_/X }
C {sky130_stdcells/o41a_4.sym} 76220 -33070 0 0 {name=X_60575_ }
C {devices/lab_pin.sym} 76180 -32910 0 0 {name=p75401 lab=_48058_/B }
C {devices/lab_pin.sym} 76260 -32910 0 1 {name=p75402 lab=_48297_/X }
C {sky130_stdcells/buf_2.sym} 76220 -32910 0 0 {name=X_48297_ }
C {devices/lab_pin.sym} 76160 -32800 0 0 {name=p75403 lab=_65102_/A }
C {devices/lab_pin.sym} 76160 -32760 0 0 {name=p75404 lab=_65102_/B }
C {devices/lab_pin.sym} 76280 -32780 0 1 {name=p75405 lab=_65102_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -32780 0 0 {name=X_65102_ }
C {devices/lab_pin.sym} 76180 -32650 0 0 {name=p75406 lab=_62218_/A }
C {devices/lab_pin.sym} 76260 -32650 0 1 {name=p75407 lab=_62315_/C }
C {sky130_stdcells/buf_2.sym} 76220 -32650 0 0 {name=X_62314_ }
