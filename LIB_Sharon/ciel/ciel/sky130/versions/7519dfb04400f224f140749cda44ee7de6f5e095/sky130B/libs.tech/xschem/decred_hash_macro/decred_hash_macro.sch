C {devices/lab_pin.sym} 18220 -15790 0 0 {name=p17938 lab=_56448_/X }
C {devices/lab_pin.sym} 18300 -15790 0 1 {name=p17939 lab=_56454_/B }
C {sky130_stdcells/buf_2.sym} 18260 -15790 0 0 {name=X_56449_ }
C {devices/lab_pin.sym} 18180 -15690 0 0 {name=p17940 lab=_75248_/Y }
C {devices/lab_pin.sym} 18180 -15650 0 0 {name=p17941 lab=_75279_/Y }
C {devices/lab_pin.sym} 18180 -15610 0 0 {name=p17942 lab=_75282_/Y }
C {devices/lab_pin.sym} 18340 -15650 0 1 {name=p17943 lab=_75283_/Y }
C {sky130_stdcells/a21oi_4.sym} 18260 -15650 0 0 {name=X_75283_ }
C {devices/lab_pin.sym} 18180 -15530 0 0 {name=p17944 lab=_41628_/X }
C {devices/lab_pin.sym} 18180 -15490 0 0 {name=p17945 lab=_41326_/A }
C {devices/lab_pin.sym} 18180 -15450 0 0 {name=p17946 lab=_41674_/X }
C {devices/lab_pin.sym} 18340 -15490 0 1 {name=p17947 lab=_41675_/X }
C {sky130_stdcells/o21a_4.sym} 18260 -15490 0 0 {name=X_41675_ }
C {devices/lab_pin.sym} 18170 -15350 0 0 {name=p17948 lab=_87525_/CLK }
C {devices/lab_pin.sym} 18170 -15330 0 0 {name=p17949 lab=_87269_/D }
C {devices/lab_pin.sym} 18350 -15350 0 1 {name=p17950 lab=_69332_/B }
C {sky130_stdcells/dfxtp_4.sym} 18260 -15340 0 0 {name=X_87269_ }
C {devices/lab_pin.sym} 18180 -15230 0 0 {name=p17951 lab=_72484_/X }
C {devices/lab_pin.sym} 18180 -15190 0 0 {name=p17952 lab=_83381_/Q }
C {devices/lab_pin.sym} 18180 -15150 0 0 {name=p17953 lab=_72494_/Y }
C {devices/lab_pin.sym} 18340 -15190 0 1 {name=p17954 lab=_72495_/X }
C {sky130_stdcells/o21a_4.sym} 18260 -15190 0 0 {name=X_72495_ }
C {devices/lab_pin.sym} 18220 -15050 0 0 {name=p17955 lab=_58425_/A }
C {devices/lab_pin.sym} 18300 -15050 0 1 {name=p17956 lab=_58273_/A }
C {sky130_stdcells/buf_2.sym} 18260 -15050 0 0 {name=X_46202_ }
C {sky130_stdcells/decap_3.sym} 18260 -14900 0 0 {name=XPHY_140 }
C {devices/lab_pin.sym} 18200 -14760 0 0 {name=p17957 lab=_82085_/Q }
C {devices/lab_pin.sym} 18200 -14720 0 0 {name=p17958 lab=_77022_/B }
C {devices/lab_pin.sym} 18320 -14740 0 1 {name=p17959 lab=_82366_/D }
C {sky130_stdcells/xor2_4.sym} 18260 -14740 0 0 {name=X_77022_ }
C {devices/lab_pin.sym} 18180 -14640 0 0 {name=p17960 lab=_41511_/X }
C {devices/lab_pin.sym} 18180 -14600 0 0 {name=p17961 lab=_43412_/X }
C {devices/lab_pin.sym} 18180 -14560 0 0 {name=p17962 lab=_87433_/Q }
C {devices/lab_pin.sym} 18180 -14520 0 0 {name=p17963 lab=_43413_/X }
C {devices/lab_pin.sym} 18340 -14580 0 1 {name=p17964 lab=_87433_/D }
C {sky130_stdcells/a2bb2o_4.sym} 18260 -14580 0 0 {name=X_43414_ }
C {devices/lab_pin.sym} 18200 -14440 0 0 {name=p17965 lab=_73165_/A }
C {devices/lab_pin.sym} 18200 -14400 0 0 {name=p17966 lab=_74234_/B }
C {devices/lab_pin.sym} 18320 -14420 0 1 {name=p17967 lab=_74234_/X }
C {sky130_stdcells/and2_4.sym} 18260 -14420 0 0 {name=X_74234_ }
C {devices/lab_pin.sym} 18220 -14290 0 0 {name=p17968 lab=clkbuf_9_271_0_CLK/X }
C {devices/lab_pin.sym} 18300 -14290 0 1 {name=p17969 lab=_80928_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 18260 -14290 0 0 {name=Xclkbuf_10_543_0_CLK }
C {sky130_stdcells/decap_3.sym} 18260 -14140 0 0 {name=XPHY_151 }
C {devices/lab_pin.sym} 18220 -13990 0 0 {name=p17970 lab=_40625_/Y }
C {devices/lab_pin.sym} 18300 -13990 0 1 {name=p17971 lab=_40626_/X }
C {sky130_stdcells/buf_2.sym} 18260 -13990 0 0 {name=X_40626_ }
C {devices/lab_pin.sym} 18200 -13880 0 0 {name=p17972 lab=_86676_/Q }
C {devices/lab_pin.sym} 18200 -13840 0 0 {name=p17973 lab=_59189_/B }
C {devices/lab_pin.sym} 18320 -13860 0 1 {name=p17974 lab=_59168_/Y }
C {sky130_stdcells/nor2_4.sym} 18260 -13860 0 0 {name=X_59168_ }
C {devices/lab_pin.sym} 18180 -13750 0 0 {name=p17975 lab=_47176_/Y }
C {devices/lab_pin.sym} 18180 -13710 0 0 {name=p17976 lab=_47177_/X }
C {devices/lab_pin.sym} 18180 -13670 0 0 {name=p17977 lab=_47181_/X }
C {devices/lab_pin.sym} 18340 -13710 0 1 {name=p17978 lab=_47182_/Y }
C {sky130_stdcells/a21oi_4.sym} 18260 -13710 0 0 {name=X_47182_ }
C {devices/lab_pin.sym} 18220 -13570 0 0 {name=p17979 lab=_71238_/B }
C {devices/lab_pin.sym} 18300 -13570 0 1 {name=p17980 lab=_71446_/X }
C {sky130_stdcells/buf_2.sym} 18260 -13570 0 0 {name=X_71446_ }
C {devices/lab_pin.sym} 18220 -13450 0 0 {name=p17981 lab=clkbuf_6_35_0_CLK/A }
C {devices/lab_pin.sym} 18300 -13450 0 1 {name=p17982 lab=clkbuf_7_69_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 18260 -13450 0 0 {name=Xclkbuf_6_34_0_CLK }
C {devices/lab_pin.sym} 18220 -13330 0 0 {name=p17983 lab=_44363_/X }
C {devices/lab_pin.sym} 18300 -13330 0 1 {name=p17984 lab=_44394_/X }
C {sky130_stdcells/buf_2.sym} 18260 -13330 0 0 {name=X_44394_ }
C {sky130_stdcells/decap_3.sym} 18260 -13180 0 0 {name=XPHY_162 }
C {sky130_stdcells/decap_3.sym} 18260 -13000 0 0 {name=XPHY_173 }
C {sky130_stdcells/decap_3.sym} 18260 -12820 0 0 {name=XPHY_184 }
C {devices/lab_pin.sym} 18200 -12700 0 0 {name=p17985 lab=_46133_/A }
C {devices/lab_pin.sym} 18200 -12660 0 0 {name=p17986 lab=_46133_/B }
C {devices/lab_pin.sym} 18200 -12620 0 0 {name=p17987 lab=_46133_/C }
C {devices/lab_pin.sym} 18200 -12580 0 0 {name=p17988 lab=_46207_/B }
C {devices/lab_pin.sym} 18320 -12640 0 1 {name=p17989 lab=_46134_/A }
C {sky130_stdcells/and4_4.sym} 18260 -12640 0 0 {name=X_46133_ }
C {devices/lab_pin.sym} 18180 -12520 0 0 {name=p17990 lab=_58108_/Y }
C {devices/lab_pin.sym} 18180 -12480 0 0 {name=p17991 lab=_57981_/X }
C {devices/lab_pin.sym} 18180 -12440 0 0 {name=p17992 lab=_58115_/X }
C {devices/lab_pin.sym} 18180 -12400 0 0 {name=p17993 lab=_58118_/X }
C {devices/lab_pin.sym} 18340 -12460 0 1 {name=p17994 lab=_84924_/D }
C {sky130_stdcells/a22oi_4.sym} 18260 -12460 0 0 {name=X_58119_ }
C {sky130_stdcells/decap_3.sym} 18260 -12280 0 0 {name=XPHY_195 }
C {devices/lab_pin.sym} 18220 -12130 0 0 {name=p17995 lab=_43344_/Y }
C {devices/lab_pin.sym} 18300 -12130 0 1 {name=p17996 lab=_87468_/D }
C {sky130_stdcells/inv_2.sym} 18260 -12130 0 0 {name=X_43345_ }
C {devices/lab_pin.sym} 18180 -12040 0 0 {name=p17997 lab=_41966_/Y }
C {devices/lab_pin.sym} 18180 -12000 0 0 {name=p17998 lab=_73930_/X }
C {devices/lab_pin.sym} 18180 -11960 0 0 {name=p17999 lab=_73551_/X }
C {devices/lab_pin.sym} 18180 -11920 0 0 {name=p18000 lab=_74164_/Y }
C {devices/lab_pin.sym} 18340 -11980 0 1 {name=p18001 lab=_74165_/X }
C {sky130_stdcells/a211o_4.sym} 18260 -11980 0 0 {name=X_74165_ }
C {devices/lab_pin.sym} 18220 -11830 0 0 {name=p18002 lab=_48135_/A }
C {devices/lab_pin.sym} 18300 -11830 0 1 {name=p18003 lab=_48606_/A }
C {sky130_stdcells/buf_2.sym} 18260 -11830 0 0 {name=X_40557_ }
C {devices/lab_pin.sym} 18180 -11730 0 0 {name=p18004 lab=_59061_/X }
C {devices/lab_pin.sym} 18180 -11690 0 0 {name=p18005 lab=_86073_/Q }
C {devices/lab_pin.sym} 18180 -11650 0 0 {name=p18006 lab=_59098_/X }
C {devices/lab_pin.sym} 18340 -11690 0 1 {name=p18007 lab=_59099_/Y }
C {sky130_stdcells/o21ai_4.sym} 18260 -11690 0 0 {name=X_59099_ }
C {devices/lab_pin.sym} 18200 -11570 0 0 {name=p18008 lab=_70670_/A }
C {devices/lab_pin.sym} 18200 -11530 0 0 {name=p18009 lab=_71377_/B }
C {devices/lab_pin.sym} 18200 -11490 0 0 {name=p18010 lab=_71377_/C }
C {devices/lab_pin.sym} 18320 -11530 0 1 {name=p18011 lab=_71377_/Y }
C {sky130_stdcells/nor3_4.sym} 18260 -11530 0 0 {name=X_71377_ }
C {devices/lab_pin.sym} 18220 -11390 0 0 {name=p18012 lab=_83246_/CLK }
C {devices/lab_pin.sym} 18300 -11390 0 1 {name=p18013 lab=_84894_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 18260 -11390 0 0 {name=Xclkbuf_opt_2_CLK }
C {devices/lab_pin.sym} 18220 -11270 0 0 {name=p18014 lab=_64523_/B }
C {devices/lab_pin.sym} 18300 -11270 0 1 {name=p18015 lab=_61202_/B }
C {sky130_stdcells/buf_2.sym} 18260 -11270 0 0 {name=X_61130_ }
C {devices/lab_pin.sym} 18180 -11170 0 0 {name=p18016 lab=_73113_/X }
C {devices/lab_pin.sym} 18180 -11130 0 0 {name=p18017 lab=_73115_/X }
C {devices/lab_pin.sym} 18180 -11090 0 0 {name=p18018 lab=_72739_/X }
C {devices/lab_pin.sym} 18340 -11130 0 1 {name=p18019 lab=_73116_/X }
C {sky130_stdcells/a21o_4.sym} 18260 -11130 0 0 {name=X_73116_ }
C {devices/lab_pin.sym} 18180 -11030 0 0 {name=p18020 lab=_46046_/X }
C {devices/lab_pin.sym} 18180 -10990 0 0 {name=p18021 lab=_46054_/X }
C {devices/lab_pin.sym} 18180 -10950 0 0 {name=p18022 lab=_41564_/X }
C {devices/lab_pin.sym} 18180 -10910 0 0 {name=p18023 lab=_67049_/B }
C {devices/lab_pin.sym} 18180 -10870 0 0 {name=p18024 lab=_46047_/X }
C {devices/lab_pin.sym} 18340 -10950 0 1 {name=p18025 lab=_46065_/A }
C {sky130_stdcells/o32ai_4.sym} 18260 -10950 0 0 {name=X_46064_ }
C {devices/lab_pin.sym} 18200 -10820 0 0 {name=p18026 lab=_70328_/A }
C {devices/lab_pin.sym} 18200 -10780 0 0 {name=p18027 lab=_70328_/B }
C {devices/lab_pin.sym} 18200 -10740 0 0 {name=p18028 lab=_70328_/C }
C {devices/lab_pin.sym} 18200 -10700 0 0 {name=p18029 lab=_70328_/D }
C {devices/lab_pin.sym} 18320 -10760 0 1 {name=p18030 lab=_70328_/X }
C {sky130_stdcells/and4_4.sym} 18260 -10760 0 0 {name=X_70328_ }
C {devices/lab_pin.sym} 18180 -10640 0 0 {name=p18031 lab=_41130_/X }
C {devices/lab_pin.sym} 18180 -10600 0 0 {name=p18032 lab=_43264_/X }
C {devices/lab_pin.sym} 18180 -10560 0 0 {name=p18033 lab=_87504_/Q }
C {devices/lab_pin.sym} 18180 -10520 0 0 {name=p18034 lab=_43265_/X }
C {devices/lab_pin.sym} 18340 -10580 0 1 {name=p18035 lab=_43276_/X }
C {sky130_stdcells/a2bb2o_4.sym} 18260 -10580 0 0 {name=X_43276_ }
C {devices/lab_pin.sym} 18180 -10460 0 0 {name=p18036 lab=_42518_/Y }
C {devices/lab_pin.sym} 18180 -10420 0 0 {name=p18037 lab=_73319_/X }
C {devices/lab_pin.sym} 18180 -10380 0 0 {name=p18038 lab=_73551_/X }
C {devices/lab_pin.sym} 18180 -10340 0 0 {name=p18039 lab=_74095_/Y }
C {devices/lab_pin.sym} 18340 -10400 0 1 {name=p18040 lab=_74096_/X }
C {sky130_stdcells/a211o_4.sym} 18260 -10400 0 0 {name=X_74096_ }
C {devices/lab_pin.sym} 18180 -10270 0 0 {name=p18041 lab=_78957_/B }
C {devices/lab_pin.sym} 18180 -10230 0 0 {name=p18042 lab=_78970_/X }
C {devices/lab_pin.sym} 18180 -10190 0 0 {name=p18043 lab=_78972_/Y }
C {devices/lab_pin.sym} 18340 -10230 0 1 {name=p18044 lab=_78979_/B }
C {sky130_stdcells/a21oi_4.sym} 18260 -10230 0 0 {name=X_78973_ }
C {devices/lab_pin.sym} 18220 -10090 0 0 {name=p18045 lab=_44382_/A }
C {devices/lab_pin.sym} 18300 -10090 0 1 {name=p18046 lab=_40488_/X }
C {sky130_stdcells/buf_2.sym} 18260 -10090 0 0 {name=X_40488_ }
C {devices/lab_pin.sym} 18220 -9970 0 0 {name=p18047 lab=clkbuf_9_279_0_CLK/X }
C {devices/lab_pin.sym} 18300 -9970 0 1 {name=p18048 lab=_87408_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 18260 -9970 0 0 {name=Xclkbuf_10_558_0_CLK }
C {devices/lab_pin.sym} 18180 -9870 0 0 {name=p18049 lab=_85178_/Q }
C {devices/lab_pin.sym} 18180 -9830 0 0 {name=p18050 lab=_44982_/X }
C {devices/lab_pin.sym} 18180 -9790 0 0 {name=p18051 lab=_44959_/X }
C {devices/lab_pin.sym} 18340 -9830 0 1 {name=p18052 lab=_45015_/X }
C {sky130_stdcells/o21a_4.sym} 18260 -9830 0 0 {name=X_45015_ }
C {devices/lab_pin.sym} 18220 -9690 0 0 {name=p18053 lab=clkbuf_6_49_0_CLK/A }
C {devices/lab_pin.sym} 18300 -9690 0 1 {name=p18054 lab=clkbuf_7_98_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 18260 -9690 0 0 {name=Xclkbuf_6_49_0_CLK }
C {devices/lab_pin.sym} 18220 -9570 0 0 {name=p18055 lab=_41881_/A }
C {devices/lab_pin.sym} 18300 -9570 0 1 {name=p18056 lab=_42276_/A }
C {sky130_stdcells/buf_2.sym} 18260 -9570 0 0 {name=X_42227_ }
C {devices/lab_pin.sym} 18200 -9460 0 0 {name=p18057 lab=_73044_/X }
C {devices/lab_pin.sym} 18200 -9420 0 0 {name=p18058 lab=_73046_/X }
C {devices/lab_pin.sym} 18320 -9440 0 1 {name=p18059 lab=_73048_/B }
C {sky130_stdcells/nand2_4.sym} 18260 -9440 0 0 {name=X_73047_ }
C {devices/lab_pin.sym} 18200 -9330 0 0 {name=p18060 lab=_60946_/X }
C {devices/lab_pin.sym} 18200 -9290 0 0 {name=p18061 lab=_61138_/B }
C {devices/lab_pin.sym} 18200 -9250 0 0 {name=p18062 lab=_76971_/A }
C {devices/lab_pin.sym} 18320 -9290 0 1 {name=p18063 lab=_61061_/Y }
C {sky130_stdcells/nor3_4.sym} 18260 -9290 0 0 {name=X_61061_ }
C {devices/lab_pin.sym} 18200 -9160 0 0 {name=p18064 lab=_82167_/Q }
C {devices/lab_pin.sym} 18200 -9120 0 0 {name=p18065 lab=_82039_/D }
C {devices/lab_pin.sym} 18320 -9140 0 1 {name=p18066 lab=_82135_/D }
C {sky130_stdcells/xor2_4.sym} 18260 -9140 0 0 {name=X_77924_ }
C {devices/lab_pin.sym} 18180 -9030 0 0 {name=p18067 lab=_70255_/X }
C {devices/lab_pin.sym} 18180 -8990 0 0 {name=p18068 lab=_74764_/B }
C {devices/lab_pin.sym} 18180 -8950 0 0 {name=p18069 lab=_70258_/X }
C {devices/lab_pin.sym} 18340 -8990 0 1 {name=p18070 lab=_83820_/D }
C {sky130_stdcells/a21o_4.sym} 18260 -8990 0 0 {name=X_70259_ }
C {devices/lab_pin.sym} 18220 -8850 0 0 {name=p18071 lab=_62515_/C }
C {devices/lab_pin.sym} 18300 -8850 0 1 {name=p18072 lab=_62548_/D }
C {sky130_stdcells/buf_2.sym} 18260 -8850 0 0 {name=X_60012_ }
C {devices/lab_pin.sym} 18200 -8760 0 0 {name=p18073 lab=_49830_/A }
C {devices/lab_pin.sym} 18200 -8720 0 0 {name=p18074 lab=_49830_/B }
C {devices/lab_pin.sym} 18200 -8680 0 0 {name=p18075 lab=_49830_/C }
C {devices/lab_pin.sym} 18200 -8640 0 0 {name=p18076 lab=_53036_/D }
C {devices/lab_pin.sym} 18320 -8700 0 1 {name=p18077 lab=_49823_/X }
C {sky130_stdcells/and4_4.sym} 18260 -8700 0 0 {name=X_49823_ }
C {devices/lab_pin.sym} 18180 -8580 0 0 {name=p18078 lab=_41189_/X }
C {devices/lab_pin.sym} 18180 -8540 0 0 {name=p18079 lab=_42148_/X }
C {devices/lab_pin.sym} 18180 -8500 0 0 {name=p18080 lab=_88005_/Q }
C {devices/lab_pin.sym} 18180 -8460 0 0 {name=p18081 lab=_42150_/X }
C {devices/lab_pin.sym} 18340 -8520 0 1 {name=p18082 lab=_88005_/D }
C {sky130_stdcells/a2bb2o_4.sym} 18260 -8520 0 0 {name=X_42158_ }
C {devices/lab_pin.sym} 18200 -8380 0 0 {name=p18083 lab=_77841_/Y }
C {devices/lab_pin.sym} 18200 -8340 0 0 {name=p18084 lab=_77854_/X }
C {devices/lab_pin.sym} 18320 -8360 0 1 {name=p18085 lab=_77855_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -8360 0 0 {name=X_77855_ }
C {devices/lab_pin.sym} 18220 -8230 0 0 {name=p18086 lab=_40941_/A }
C {devices/lab_pin.sym} 18300 -8230 0 1 {name=p18087 lab=_41109_/X }
C {sky130_stdcells/buf_2.sym} 18260 -8230 0 0 {name=X_41109_ }
C {devices/lab_pin.sym} 18200 -8120 0 0 {name=p18088 lab=_64804_/A }
C {devices/lab_pin.sym} 18200 -8080 0 0 {name=p18089 lab=_64820_/B }
C {devices/lab_pin.sym} 18320 -8100 0 1 {name=p18090 lab=_64820_/X }
C {sky130_stdcells/and2_4.sym} 18260 -8100 0 0 {name=X_64820_ }
C {devices/lab_pin.sym} 18200 -7980 0 0 {name=p18091 lab=_76806_/A }
C {devices/lab_pin.sym} 18200 -7940 0 0 {name=p18092 lab=_76792_/Y }
C {devices/lab_pin.sym} 18320 -7960 0 1 {name=p18093 lab=_76806_/Y }
C {sky130_stdcells/nor2_4.sym} 18260 -7960 0 0 {name=X_76806_ }
C {devices/lab_pin.sym} 18180 -7850 0 0 {name=p18094 lab=_86329_/Q }
C {devices/lab_pin.sym} 18180 -7810 0 0 {name=p18095 lab=_49742_/X }
C {devices/lab_pin.sym} 18180 -7770 0 0 {name=p18096 lab=_49753_/Y }
C {devices/lab_pin.sym} 18340 -7810 0 1 {name=p18097 lab=_49754_/Y }
C {sky130_stdcells/o21ai_4.sym} 18260 -7810 0 0 {name=X_49754_ }
C {devices/lab_pin.sym} 18180 -7690 0 0 {name=p18098 lab=_46960_/Y }
C {devices/lab_pin.sym} 18180 -7650 0 0 {name=p18099 lab=_46940_/X }
C {devices/lab_pin.sym} 18180 -7610 0 0 {name=p18100 lab=_46965_/X }
C {devices/lab_pin.sym} 18340 -7650 0 1 {name=p18101 lab=_86685_/D }
C {sky130_stdcells/a21oi_4.sym} 18260 -7650 0 0 {name=X_46966_ }
C {devices/lab_pin.sym} 18220 -7510 0 0 {name=p18102 lab=_42088_/Y }
C {devices/lab_pin.sym} 18300 -7510 0 1 {name=p18103 lab=_88040_/D }
C {sky130_stdcells/inv_2.sym} 18260 -7510 0 0 {name=X_42089_ }
C {devices/lab_pin.sym} 18200 -7400 0 0 {name=p18104 lab=_82265_/Q }
C {devices/lab_pin.sym} 18200 -7360 0 0 {name=p18105 lab=_81977_/Q }
C {devices/lab_pin.sym} 18320 -7380 0 1 {name=p18106 lab=_77786_/X }
C {sky130_stdcells/xor2_4.sym} 18260 -7380 0 0 {name=X_77786_ }
C {devices/lab_pin.sym} 18200 -7260 0 0 {name=p18107 lab=_80951_/Q }
C {devices/lab_pin.sym} 18200 -7220 0 0 {name=p18108 lab=_74998_/B }
C {devices/lab_pin.sym} 18320 -7240 0 1 {name=p18109 lab=_74998_/X }
C {sky130_stdcells/xor2_4.sym} 18260 -7240 0 0 {name=X_74998_ }
C {devices/lab_pin.sym} 18220 -7110 0 0 {name=p18110 lab=_48704_/Y }
C {devices/lab_pin.sym} 18300 -7110 0 1 {name=p18111 lab=_48872_/B }
C {sky130_stdcells/buf_2.sym} 18260 -7110 0 0 {name=X_48705_ }
C {devices/lab_pin.sym} 18200 -7000 0 0 {name=p18112 lab=_79161_/Y }
C {devices/lab_pin.sym} 18200 -6960 0 0 {name=p18113 lab=_79525_/B }
C {devices/lab_pin.sym} 18320 -6980 0 1 {name=p18114 lab=_82818_/D }
C {sky130_stdcells/xnor2_4.sym} 18260 -6980 0 0 {name=X_79525_ }
C {devices/lab_pin.sym} 18220 -6850 0 0 {name=p18115 lab=_69626_/A }
C {devices/lab_pin.sym} 18300 -6850 0 1 {name=p18116 lab=_65381_/A }
C {sky130_stdcells/buf_2.sym} 18260 -6850 0 0 {name=X_45917_ }
C {devices/lab_pin.sym} 18200 -6750 0 0 {name=p18117 lab=_64747_/X }
C {devices/lab_pin.sym} 18200 -6710 0 0 {name=p18118 lab=_64712_/B }
C {devices/lab_pin.sym} 18200 -6670 0 0 {name=p18119 lab=_64750_/X }
C {devices/lab_pin.sym} 18320 -6710 0 1 {name=p18120 lab=_64751_/Y }
C {sky130_stdcells/nand3_4.sym} 18260 -6710 0 0 {name=X_64751_ }
C {devices/lab_pin.sym} 18200 -6580 0 0 {name=p18121 lab=_76725_/A }
C {devices/lab_pin.sym} 18200 -6540 0 0 {name=p18122 lab=_76732_/A }
C {devices/lab_pin.sym} 18320 -6560 0 1 {name=p18123 lab=_76737_/X }
C {sky130_stdcells/and2_4.sym} 18260 -6560 0 0 {name=X_76737_ }
C {devices/lab_pin.sym} 18200 -6460 0 0 {name=p18124 lab=_49685_/A }
C {devices/lab_pin.sym} 18200 -6420 0 0 {name=p18125 lab=_49669_/B }
C {devices/lab_pin.sym} 18200 -6380 0 0 {name=p18126 lab=_49685_/C }
C {devices/lab_pin.sym} 18200 -6340 0 0 {name=p18127 lab=_52900_/D }
C {devices/lab_pin.sym} 18320 -6400 0 1 {name=p18128 lab=_49685_/X }
C {sky130_stdcells/and4_4.sym} 18260 -6400 0 0 {name=X_49685_ }
C {devices/lab_pin.sym} 18200 -6280 0 0 {name=p18129 lab=_61962_/X }
C {devices/lab_pin.sym} 18200 -6240 0 0 {name=p18130 lab=_61945_/X }
C {devices/lab_pin.sym} 18200 -6200 0 0 {name=p18131 lab=_58533_/A }
C {devices/lab_pin.sym} 18200 -6160 0 0 {name=p18132 lab=_61947_/D }
C {devices/lab_pin.sym} 18320 -6220 0 1 {name=p18133 lab=_61963_/X }
C {sky130_stdcells/and4_4.sym} 18260 -6220 0 0 {name=X_61963_ }
C {devices/lab_pin.sym} 18200 -6080 0 0 {name=p18134 lab=_73949_/A }
C {devices/lab_pin.sym} 18200 -6040 0 0 {name=p18135 lab=_66141_/B }
C {devices/lab_pin.sym} 18320 -6060 0 1 {name=p18136 lab=_73949_/X }
C {sky130_stdcells/and2_4.sym} 18260 -6060 0 0 {name=X_73949_ }
C {devices/lab_pin.sym} 18180 -5950 0 0 {name=p18137 lab=_46889_/Y }
C {devices/lab_pin.sym} 18180 -5910 0 0 {name=p18138 lab=_46891_/X }
C {devices/lab_pin.sym} 18180 -5870 0 0 {name=p18139 lab=_46896_/X }
C {devices/lab_pin.sym} 18340 -5910 0 1 {name=p18140 lab=_46897_/Y }
C {sky130_stdcells/a21oi_4.sym} 18260 -5910 0 0 {name=X_46897_ }
C {devices/lab_pin.sym} 18180 -5790 0 0 {name=p18141 lab=_63700_/Y }
C {devices/lab_pin.sym} 18180 -5750 0 0 {name=p18142 lab=_63679_/X }
C {devices/lab_pin.sym} 18180 -5710 0 0 {name=p18143 lab=_63701_/Y }
C {devices/lab_pin.sym} 18340 -5750 0 1 {name=p18144 lab=_63702_/Y }
C {sky130_stdcells/a21oi_4.sym} 18260 -5750 0 0 {name=X_63702_ }
C {devices/lab_pin.sym} 18200 -5630 0 0 {name=p18145 lab=_48841_/A }
C {devices/lab_pin.sym} 18200 -5590 0 0 {name=p18146 lab=_48657_/B }
C {devices/lab_pin.sym} 18200 -5550 0 0 {name=p18147 lab=_48657_/C }
C {devices/lab_pin.sym} 18320 -5590 0 1 {name=p18148 lab=_48636_/X }
C {sky130_stdcells/and3_4.sym} 18260 -5590 0 0 {name=X_48636_ }
C {devices/lab_pin.sym} 18200 -5480 0 0 {name=p18149 lab=_60909_/X }
C {devices/lab_pin.sym} 18200 -5440 0 0 {name=p18150 lab=_60865_/B }
C {devices/lab_pin.sym} 18200 -5400 0 0 {name=p18151 lab=_64081_/C }
C {devices/lab_pin.sym} 18200 -5360 0 0 {name=p18152 lab=_60910_/B }
C {devices/lab_pin.sym} 18320 -5420 0 1 {name=p18153 lab=_60988_/A }
C {sky130_stdcells/nand4_4.sym} 18260 -5420 0 0 {name=X_60914_ }
C {devices/lab_pin.sym} 18180 -5290 0 0 {name=p18154 lab=_67465_/X }
C {devices/lab_pin.sym} 18180 -5250 0 0 {name=p18155 lab=_67469_/X }
C {devices/lab_pin.sym} 18180 -5210 0 0 {name=p18156 lab=_67423_/X }
C {devices/lab_pin.sym} 18340 -5250 0 1 {name=p18157 lab=_67470_/Y }
C {sky130_stdcells/a21oi_4.sym} 18260 -5250 0 0 {name=X_67470_ }
C {devices/lab_pin.sym} 18200 -5120 0 0 {name=p18158 lab=_79456_/A }
C {devices/lab_pin.sym} 18200 -5080 0 0 {name=p18159 lab=_79456_/B }
C {devices/lab_pin.sym} 18320 -5100 0 1 {name=p18160 lab=_79457_/B }
C {sky130_stdcells/xor2_4.sym} 18260 -5100 0 0 {name=X_79456_ }
C {devices/lab_pin.sym} 18200 -4980 0 0 {name=p18161 lab=_74700_/B }
C {devices/lab_pin.sym} 18200 -4940 0 0 {name=p18162 lab=_45832_/B }
C {devices/lab_pin.sym} 18320 -4960 0 1 {name=p18163 lab=_45848_/Y }
C {sky130_stdcells/nand2_4.sym} 18260 -4960 0 0 {name=X_45848_ }
C {devices/lab_pin.sym} 18180 -4850 0 0 {name=p18164 lab=_64677_/X }
C {devices/lab_pin.sym} 18180 -4810 0 0 {name=p18165 lab=_64681_/X }
C {devices/lab_pin.sym} 18180 -4770 0 0 {name=p18166 lab=_64629_/X }
C {devices/lab_pin.sym} 18340 -4810 0 1 {name=p18167 lab=_64682_/X }
C {sky130_stdcells/a21o_4.sym} 18260 -4810 0 0 {name=X_64682_ }
C {devices/lab_pin.sym} 18200 -4680 0 0 {name=p18168 lab=_81684_/Q }
C {devices/lab_pin.sym} 18200 -4640 0 0 {name=p18169 lab=_76667_/Y }
C {devices/lab_pin.sym} 18320 -4660 0 1 {name=p18170 lab=_76668_/X }
C {sky130_stdcells/or2_4.sym} 18260 -4660 0 0 {name=X_76668_ }
C {devices/lab_pin.sym} 18200 -4560 0 0 {name=p18171 lab=_61879_/A }
C {devices/lab_pin.sym} 18200 -4520 0 0 {name=p18172 lab=_61889_/Y }
C {devices/lab_pin.sym} 18200 -4480 0 0 {name=p18173 lab=_61890_/Y }
C {devices/lab_pin.sym} 18200 -4440 0 0 {name=p18174 lab=_61893_/Y }
C {devices/lab_pin.sym} 18320 -4500 0 1 {name=p18175 lab=_61894_/Y }
C {sky130_stdcells/nand4_4.sym} 18260 -4500 0 0 {name=X_61894_ }
C {devices/lab_pin.sym} 18180 -4370 0 0 {name=p18176 lab=_66418_/Y }
C {devices/lab_pin.sym} 18180 -4330 0 0 {name=p18177 lab=_66414_/X }
C {devices/lab_pin.sym} 18180 -4290 0 0 {name=p18178 lab=_66420_/X }
C {devices/lab_pin.sym} 18340 -4330 0 1 {name=p18179 lab=_84127_/D }
C {sky130_stdcells/a21o_4.sym} 18260 -4330 0 0 {name=X_66421_ }
C {devices/lab_pin.sym} 18220 -4190 0 0 {name=p18180 lab=_78402_/Y }
C {devices/lab_pin.sym} 18300 -4190 0 1 {name=p18181 lab=_78407_/Y }
C {sky130_stdcells/inv_2.sym} 18260 -4190 0 0 {name=X_78407_ }
C {devices/lab_pin.sym} 18200 -4100 0 0 {name=p18182 lab=_58461_/A }
C {devices/lab_pin.sym} 18200 -4060 0 0 {name=p18183 lab=_63600_/X }
C {devices/lab_pin.sym} 18200 -4020 0 0 {name=p18184 lab=_63661_/C }
C {devices/lab_pin.sym} 18200 -3980 0 0 {name=p18185 lab=_63661_/D }
C {devices/lab_pin.sym} 18320 -4040 0 1 {name=p18186 lab=_63633_/Y }
C {sky130_stdcells/nand4_4.sym} 18260 -4040 0 0 {name=X_63633_ }
C {devices/lab_pin.sym} 18200 -3900 0 0 {name=p18187 lab=_75619_/A }
C {devices/lab_pin.sym} 18200 -3860 0 0 {name=p18188 lab=_80776_/D }
C {devices/lab_pin.sym} 18320 -3880 0 1 {name=p18189 lab=_75632_/A }
C {sky130_stdcells/xnor2_4.sym} 18260 -3880 0 0 {name=X_75619_ }
C {devices/lab_pin.sym} 18220 -3750 0 0 {name=p18190 lab=_61075_/B }
C {devices/lab_pin.sym} 18300 -3750 0 1 {name=p18191 lab=_60845_/Y }
C {sky130_stdcells/inv_2.sym} 18260 -3750 0 0 {name=X_60845_ }
C {devices/lab_pin.sym} 18220 -3630 0 0 {name=p18192 lab=_48567_/A }
C {devices/lab_pin.sym} 18300 -3630 0 1 {name=p18193 lab=_52194_/A }
C {sky130_stdcells/buf_2.sym} 18260 -3630 0 0 {name=X_48567_ }
C {devices/lab_pin.sym} 18200 -3520 0 0 {name=p18194 lab=_79387_/A }
C {devices/lab_pin.sym} 18200 -3480 0 0 {name=p18195 lab=_79386_/Y }
C {devices/lab_pin.sym} 18320 -3500 0 1 {name=p18196 lab=_79387_/X }
C {sky130_stdcells/xor2_4.sym} 18260 -3500 0 0 {name=X_79387_ }
C {devices/lab_pin.sym} 18180 -3390 0 0 {name=p18197 lab=_45773_/X }
C {devices/lab_pin.sym} 18180 -3350 0 0 {name=p18198 lab=_45776_/X }
C {devices/lab_pin.sym} 18180 -3310 0 0 {name=p18199 lab=_45778_/Y }
C {devices/lab_pin.sym} 18340 -3350 0 1 {name=p18200 lab=_86855_/D }
C {sky130_stdcells/a21oi_4.sym} 18260 -3350 0 0 {name=X_45779_ }
C {devices/lab_pin.sym} 18180 -3230 0 0 {name=p18201 lab=_76572_/Y }
C {devices/lab_pin.sym} 18180 -3190 0 0 {name=p18202 lab=_76576_/B }
C {devices/lab_pin.sym} 18180 -3150 0 0 {name=p18203 lab=_76574_/Y }
C {devices/lab_pin.sym} 18340 -3190 0 1 {name=p18204 lab=_76599_/X }
C {sky130_stdcells/o21a_4.sym} 18260 -3190 0 0 {name=X_76599_ }
C {devices/lab_pin.sym} 18200 -3060 0 0 {name=p18205 lab=_69128_/X }
C {devices/lab_pin.sym} 18200 -3020 0 0 {name=p18206 lab=_88307_/Q }
C {devices/lab_pin.sym} 18320 -3040 0 1 {name=p18207 lab=_69140_/X }
C {sky130_stdcells/and2_4.sym} 18260 -3040 0 0 {name=X_69140_ }
C {devices/lab_pin.sym} 18180 -2930 0 0 {name=p18208 lab=_58136_/A }
C {devices/lab_pin.sym} 18180 -2890 0 0 {name=p18209 lab=_47478_/X }
C {devices/lab_pin.sym} 18180 -2850 0 0 {name=p18210 lab=_47517_/Y }
C {devices/lab_pin.sym} 18340 -2890 0 1 {name=p18211 lab=_47518_/Y }
C {sky130_stdcells/o21ai_4.sym} 18260 -2890 0 0 {name=X_47518_ }
C {devices/lab_pin.sym} 18180 -2770 0 0 {name=p18212 lab=_66348_/X }
C {devices/lab_pin.sym} 18180 -2730 0 0 {name=p18213 lab=_66351_/X }
C {devices/lab_pin.sym} 18180 -2690 0 0 {name=p18214 lab=_58882_/A }
C {devices/lab_pin.sym} 18340 -2730 0 1 {name=p18215 lab=_66352_/X }
C {sky130_stdcells/a21o_4.sym} 18260 -2730 0 0 {name=X_66352_ }
C {devices/lab_pin.sym} 18220 -2590 0 0 {name=p18216 lab=_78338_/A }
C {devices/lab_pin.sym} 18300 -2590 0 1 {name=p18217 lab=_78339_/B }
C {sky130_stdcells/inv_2.sym} 18260 -2590 0 0 {name=X_78338_ }
C {devices/lab_pin.sym} 18220 -2470 0 0 {name=p18218 lab=_63443_/A }
C {devices/lab_pin.sym} 18300 -2470 0 1 {name=p18219 lab=_63575_/C }
C {sky130_stdcells/buf_2.sym} 18260 -2470 0 0 {name=X_63564_ }
C {devices/lab_pin.sym} 18220 -2350 0 0 {name=p18220 lab=_48498_/A }
C {devices/lab_pin.sym} 18300 -2350 0 1 {name=p18221 lab=_52161_/A }
C {sky130_stdcells/buf_2.sym} 18260 -2350 0 0 {name=X_48498_ }
C {devices/lab_pin.sym} 18200 -2250 0 0 {name=p18222 lab=_60804_/C }
C {devices/lab_pin.sym} 18200 -2210 0 0 {name=p18223 lab=_70021_/C }
C {devices/lab_pin.sym} 18200 -2170 0 0 {name=p18224 lab=_60736_/X }
C {devices/lab_pin.sym} 18320 -2210 0 1 {name=p18225 lab=_60776_/Y }
C {sky130_stdcells/nand3_4.sym} 18260 -2210 0 0 {name=X_60776_ }
C {devices/lab_pin.sym} 18180 -2100 0 0 {name=p18226 lab=_65300_/X }
C {devices/lab_pin.sym} 18180 -2060 0 0 {name=p18227 lab=_85510_/Q }
C {devices/lab_pin.sym} 18180 -2020 0 0 {name=p18228 lab=_65301_/X }
C {devices/lab_pin.sym} 18180 -1980 0 0 {name=p18229 lab=_65302_/X }
C {devices/lab_pin.sym} 18340 -2040 0 1 {name=p18230 lab=_65303_/X }
C {sky130_stdcells/a211o_4.sym} 18260 -2040 0 0 {name=X_65303_ }
C {devices/lab_pin.sym} 18200 -1920 0 0 {name=p18231 lab=_62515_/A }
C {devices/lab_pin.sym} 18200 -1880 0 0 {name=p18232 lab=_59995_/A }
C {devices/lab_pin.sym} 18200 -1840 0 0 {name=p18233 lab=_62515_/C }
C {devices/lab_pin.sym} 18200 -1800 0 0 {name=p18234 lab=_61580_/X }
C {devices/lab_pin.sym} 18320 -1860 0 1 {name=p18235 lab=_62515_/X }
C {sky130_stdcells/and4_4.sym} 18260 -1860 0 0 {name=X_62515_ }
C {devices/lab_pin.sym} 18180 -1730 0 0 {name=p18236 lab=_69068_/X }
C {devices/lab_pin.sym} 18180 -1690 0 0 {name=p18237 lab=_69070_/X }
C {devices/lab_pin.sym} 18180 -1650 0 0 {name=p18238 lab=_68748_/X }
C {devices/lab_pin.sym} 18340 -1690 0 1 {name=p18239 lab=_69071_/X }
C {sky130_stdcells/a21o_4.sym} 18260 -1690 0 0 {name=X_69071_ }
C {devices/lab_pin.sym} 18180 -1570 0 0 {name=p18240 lab=_47445_/Y }
C {devices/lab_pin.sym} 18180 -1530 0 0 {name=p18241 lab=_47414_/X }
C {devices/lab_pin.sym} 18180 -1490 0 0 {name=p18242 lab=_47448_/X }
C {devices/lab_pin.sym} 18340 -1530 0 1 {name=p18243 lab=_86634_/D }
C {sky130_stdcells/a21oi_4.sym} 18260 -1530 0 0 {name=X_47449_ }
C {devices/lab_pin.sym} 18200 -1400 0 0 {name=p18244 lab=_64826_/A }
C {devices/lab_pin.sym} 18200 -1360 0 0 {name=p18245 lab=_66283_/B }
C {devices/lab_pin.sym} 18320 -1380 0 1 {name=p18246 lab=_66283_/X }
C {sky130_stdcells/and2_4.sym} 18260 -1380 0 0 {name=X_66283_ }
C {devices/lab_pin.sym} 18200 -1260 0 0 {name=p18247 lab=_78262_/X }
C {devices/lab_pin.sym} 18200 -1220 0 0 {name=p18248 lab=_78268_/Y }
C {devices/lab_pin.sym} 18320 -1240 0 1 {name=p18249 lab=_78270_/B }
C {sky130_stdcells/xor2_4.sym} 18260 -1240 0 0 {name=X_78269_ }
C {devices/lab_pin.sym} 18220 -1110 0 0 {name=p18250 lab=_63368_/A }
C {devices/lab_pin.sym} 18300 -1110 0 1 {name=p18251 lab=_63495_/X }
C {sky130_stdcells/buf_2.sym} 18260 -1110 0 0 {name=X_63495_ }
C {devices/lab_pin.sym} 18200 -1000 0 0 {name=p18252 lab=_80302_/B }
C {devices/lab_pin.sym} 18200 -960 0 0 {name=p18253 lab=_80299_/Y }
C {devices/lab_pin.sym} 18320 -980 0 1 {name=p18254 lab=_80300_/Y }
C {sky130_stdcells/nor2_4.sym} 18260 -980 0 0 {name=X_80300_ }
C {devices/lab_pin.sym} 18180 -870 0 0 {name=p18255 lab=_68019_/X }
C {devices/lab_pin.sym} 18180 -830 0 0 {name=p18256 lab=_68021_/X }
C {devices/lab_pin.sym} 18180 -790 0 0 {name=p18257 lab=_67977_/X }
C {devices/lab_pin.sym} 18340 -830 0 1 {name=p18258 lab=_68027_/A }
C {sky130_stdcells/a21o_4.sym} 18260 -830 0 0 {name=X_68022_ }
C {devices/lab_pin.sym} 18200 -700 0 0 {name=p18259 lab=_65155_/A }
C {devices/lab_pin.sym} 18200 -660 0 0 {name=p18260 lab=_65234_/B }
C {devices/lab_pin.sym} 18320 -680 0 1 {name=p18261 lab=_65234_/X }
C {sky130_stdcells/and2_4.sym} 18260 -680 0 0 {name=X_65234_ }
C {devices/lab_pin.sym} 19140 -42150 0 0 {name=p18262 lab=_50460_/A }
C {devices/lab_pin.sym} 19220 -42150 0 1 {name=p18263 lab=_50496_/A }
C {sky130_stdcells/buf_2.sym} 19180 -42150 0 0 {name=X_50460_ }
C {devices/lab_pin.sym} 19120 -42060 0 0 {name=p18264 lab=_61528_/A }
C {devices/lab_pin.sym} 19120 -42020 0 0 {name=p18265 lab=_62472_/B }
C {devices/lab_pin.sym} 19120 -41980 0 0 {name=p18266 lab=_62490_/C }
C {devices/lab_pin.sym} 19120 -41940 0 0 {name=p18267 lab=_62431_/D }
C {devices/lab_pin.sym} 19240 -42000 0 1 {name=p18268 lab=_62446_/Y }
C {sky130_stdcells/nand4_4.sym} 19180 -42000 0 0 {name=X_62446_ }
C {devices/lab_pin.sym} 19090 -41850 0 0 {name=p18269 lab=_81682_/CLK }
C {devices/lab_pin.sym} 19090 -41830 0 0 {name=p18270 lab=_81280_/D }
C {devices/lab_pin.sym} 19270 -41850 0 1 {name=p18271 lab=_76620_/A }
C {sky130_stdcells/dfxtp_4.sym} 19180 -41840 0 0 {name=X_81280_ }
C {devices/lab_pin.sym} 19140 -41710 0 0 {name=p18272 lab=clkbuf_8_3_0_CLK/A }
C {devices/lab_pin.sym} 19220 -41710 0 1 {name=p18273 lab=clkbuf_9_5_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 19180 -41710 0 0 {name=Xclkbuf_8_2_0_CLK }
C {devices/lab_pin.sym} 19120 -41600 0 0 {name=p18274 lab=_49119_/A }
C {devices/lab_pin.sym} 19120 -41560 0 0 {name=p18275 lab=_49029_/B }
C {devices/lab_pin.sym} 19240 -41580 0 1 {name=p18276 lab=_49119_/Y }
C {sky130_stdcells/nor2_4.sym} 19180 -41580 0 0 {name=X_49119_ }
C {devices/lab_pin.sym} 19120 -41460 0 0 {name=p18277 lab=_84951_/Q }
C {devices/lab_pin.sym} 19120 -41420 0 0 {name=p18278 lab=_65466_/C }
C {devices/lab_pin.sym} 19240 -41440 0 1 {name=p18279 lab=_80233_/A }
C {sky130_stdcells/xor2_4.sym} 19180 -41440 0 0 {name=X_80231_ }
C {devices/lab_pin.sym} 19100 -41340 0 0 {name=p18280 lab=_65065_/X }
C {devices/lab_pin.sym} 19100 -41300 0 0 {name=p18281 lab=_83292_/Q }
C {devices/lab_pin.sym} 19100 -41260 0 0 {name=p18282 lab=_65108_/X }
C {devices/lab_pin.sym} 19100 -41220 0 0 {name=p18283 lab=_65164_/X }
C {devices/lab_pin.sym} 19260 -41280 0 1 {name=p18284 lab=_65165_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -41280 0 0 {name=X_65165_ }
C {devices/lab_pin.sym} 19120 -41150 0 0 {name=p18285 lab=_50391_/A }
C {devices/lab_pin.sym} 19120 -41110 0 0 {name=p18286 lab=_50475_/B }
C {devices/lab_pin.sym} 19120 -41070 0 0 {name=p18287 lab=_50257_/X }
C {devices/lab_pin.sym} 19240 -41110 0 1 {name=p18288 lab=_50391_/Y }
C {sky130_stdcells/nand3_4.sym} 19180 -41110 0 0 {name=X_50391_ }
C {devices/lab_pin.sym} 19120 -41000 0 0 {name=p18289 lab=_61461_/X }
C {devices/lab_pin.sym} 19120 -40960 0 0 {name=p18290 lab=_62420_/B }
C {devices/lab_pin.sym} 19120 -40920 0 0 {name=p18291 lab=_62420_/C }
C {devices/lab_pin.sym} 19120 -40880 0 0 {name=p18292 lab=_62334_/D }
C {devices/lab_pin.sym} 19240 -40940 0 1 {name=p18293 lab=_62378_/D }
C {sky130_stdcells/nand4_4.sym} 19180 -40940 0 0 {name=X_62377_ }
C {devices/lab_pin.sym} 19120 -40810 0 0 {name=p18294 lab=_48744_/A }
C {devices/lab_pin.sym} 19120 -40770 0 0 {name=p18295 lab=_52135_/B }
C {devices/lab_pin.sym} 19120 -40730 0 0 {name=p18296 lab=_52097_/X }
C {devices/lab_pin.sym} 19240 -40770 0 1 {name=p18297 lab=_52130_/X }
C {sky130_stdcells/and3_4.sym} 19180 -40770 0 0 {name=X_52130_ }
C {devices/lab_pin.sym} 19120 -40650 0 0 {name=p18298 lab=_64116_/A }
C {devices/lab_pin.sym} 19120 -40610 0 0 {name=p18299 lab=_64087_/X }
C {devices/lab_pin.sym} 19120 -40570 0 0 {name=p18300 lab=_79998_/B }
C {devices/lab_pin.sym} 19240 -40610 0 1 {name=p18301 lab=_64116_/Y }
C {sky130_stdcells/nor3_4.sym} 19180 -40610 0 0 {name=X_64116_ }
C {devices/lab_pin.sym} 19140 -40470 0 0 {name=p18302 lab=_72515_/D }
C {devices/lab_pin.sym} 19220 -40470 0 1 {name=p18303 lab=_61375_/C }
C {sky130_stdcells/buf_2.sym} 19180 -40470 0 0 {name=X_61328_ }
C {devices/lab_pin.sym} 19120 -40360 0 0 {name=p18304 lab=_80156_/Y }
C {devices/lab_pin.sym} 19120 -40320 0 0 {name=p18305 lab=_80162_/B }
C {devices/lab_pin.sym} 19240 -40340 0 1 {name=p18306 lab=_80162_/X }
C {sky130_stdcells/xor2_4.sym} 19180 -40340 0 0 {name=X_80162_ }
C {devices/lab_pin.sym} 19120 -40220 0 0 {name=p18307 lab=_64948_/A }
C {devices/lab_pin.sym} 19120 -40180 0 0 {name=p18308 lab=_65096_/B }
C {devices/lab_pin.sym} 19240 -40200 0 1 {name=p18309 lab=_65096_/X }
C {sky130_stdcells/and2_4.sym} 19180 -40200 0 0 {name=X_65096_ }
C {devices/lab_pin.sym} 19100 -40100 0 0 {name=p18310 lab=_87040_/Q }
C {devices/lab_pin.sym} 19100 -40060 0 0 {name=p18311 lab=_66550_/X }
C {devices/lab_pin.sym} 19100 -40020 0 0 {name=p18312 lab=_66552_/X }
C {devices/lab_pin.sym} 19100 -39980 0 0 {name=p18313 lab=_69972_/X }
C {devices/lab_pin.sym} 19260 -40040 0 1 {name=p18314 lab=_69973_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -40040 0 0 {name=X_69973_ }
C {devices/lab_pin.sym} 19100 -39910 0 0 {name=p18315 lab=_85896_/Q }
C {devices/lab_pin.sym} 19100 -39870 0 0 {name=p18316 lab=_52013_/X }
C {devices/lab_pin.sym} 19100 -39830 0 0 {name=p18317 lab=_52060_/Y }
C {devices/lab_pin.sym} 19260 -39870 0 1 {name=p18318 lab=_52061_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -39870 0 0 {name=X_52061_ }
C {devices/lab_pin.sym} 19120 -39740 0 0 {name=p18319 lab=_68994_/A }
C {devices/lab_pin.sym} 19120 -39700 0 0 {name=p18320 lab=_68924_/B }
C {devices/lab_pin.sym} 19240 -39720 0 1 {name=p18321 lab=_68924_/X }
C {sky130_stdcells/and2_4.sym} 19180 -39720 0 0 {name=X_68924_ }
C {devices/lab_pin.sym} 19120 -39620 0 0 {name=p18322 lab=_64040_/Y }
C {devices/lab_pin.sym} 19120 -39580 0 0 {name=p18323 lab=_64042_/Y }
C {devices/lab_pin.sym} 19120 -39540 0 0 {name=p18324 lab=_64044_/Y }
C {devices/lab_pin.sym} 19120 -39500 0 0 {name=p18325 lab=_64047_/D }
C {devices/lab_pin.sym} 19240 -39560 0 1 {name=p18326 lab=_64047_/X }
C {sky130_stdcells/and4_4.sym} 19180 -39560 0 0 {name=X_64047_ }
C {devices/lab_pin.sym} 19120 -39430 0 0 {name=p18327 lab=_61293_/A }
C {devices/lab_pin.sym} 19120 -39390 0 0 {name=p18328 lab=_61293_/B }
C {devices/lab_pin.sym} 19120 -39350 0 0 {name=p18329 lab=_72625_/A }
C {devices/lab_pin.sym} 19240 -39390 0 1 {name=p18330 lab=_61260_/A }
C {sky130_stdcells/and3_4.sym} 19180 -39390 0 0 {name=X_61259_ }
C {devices/lab_pin.sym} 19090 -39250 0 0 {name=p18331 lab=_84970_/CLK }
C {devices/lab_pin.sym} 19090 -39230 0 0 {name=p18332 lab=_57610_/Y }
C {devices/lab_pin.sym} 19270 -39250 0 1 {name=p18333 lab=_84970_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -39240 0 0 {name=X_84970_ }
C {devices/lab_pin.sym} 19120 -39120 0 0 {name=p18334 lab=_80089_/X }
C {devices/lab_pin.sym} 19120 -39080 0 0 {name=p18335 lab=_80105_/B }
C {devices/lab_pin.sym} 19240 -39100 0 1 {name=p18336 lab=_80098_/A }
C {sky130_stdcells/xor2_4.sym} 19180 -39100 0 0 {name=X_80093_ }
C {devices/lab_pin.sym} 19140 -38970 0 0 {name=p18337 lab=_51012_/A }
C {devices/lab_pin.sym} 19220 -38970 0 1 {name=p18338 lab=_51013_/A }
C {sky130_stdcells/buf_2.sym} 19180 -38970 0 0 {name=X_51012_ }
C {devices/lab_pin.sym} 19090 -38850 0 0 {name=p18339 lab=_81507_/CLK }
C {devices/lab_pin.sym} 19090 -38830 0 0 {name=p18340 lab=_83921_/D }
C {devices/lab_pin.sym} 19270 -38850 0 1 {name=p18341 lab=_81385_/D }
C {sky130_stdcells/dfxtp_4.sym} 19180 -38840 0 0 {name=X_83921_ }
C {devices/lab_pin.sym} 19100 -38730 0 0 {name=p18342 lab=_68852_/X }
C {devices/lab_pin.sym} 19100 -38690 0 0 {name=p18343 lab=_68854_/X }
C {devices/lab_pin.sym} 19100 -38650 0 0 {name=p18344 lab=_68661_/X }
C {devices/lab_pin.sym} 19260 -38690 0 1 {name=p18345 lab=_68855_/Y }
C {sky130_stdcells/a21oi_4.sym} 19180 -38690 0 0 {name=X_68855_ }
C {devices/lab_pin.sym} 19140 -38550 0 0 {name=p18346 lab=_55819_/X }
C {devices/lab_pin.sym} 19220 -38550 0 1 {name=p18347 lab=_56108_/A }
C {sky130_stdcells/buf_2.sym} 19180 -38550 0 0 {name=X_55820_ }
C {devices/lab_pin.sym} 19140 -38430 0 0 {name=p18348 lab=_67806_/A }
C {devices/lab_pin.sym} 19220 -38430 0 1 {name=p18349 lab=_67806_/X }
C {sky130_stdcells/buf_2.sym} 19180 -38430 0 0 {name=X_67806_ }
C {devices/lab_pin.sym} 19090 -38310 0 0 {name=p18350 lab=_86640_/CLK }
C {devices/lab_pin.sym} 19090 -38290 0 0 {name=p18351 lab=_86640_/D }
C {devices/lab_pin.sym} 19270 -38310 0 1 {name=p18352 lab=_86640_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -38300 0 0 {name=X_86640_ }
C {devices/lab_pin.sym} 19090 -38170 0 0 {name=p18353 lab=_82536_/CLK }
C {devices/lab_pin.sym} 19090 -38150 0 0 {name=p18354 lab=_70091_/X }
C {devices/lab_pin.sym} 19270 -38170 0 1 {name=p18355 lab=_83852_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -38160 0 0 {name=X_83852_ }
C {devices/lab_pin.sym} 19100 -38060 0 0 {name=p18356 lab=_44709_/A }
C {devices/lab_pin.sym} 19100 -38020 0 0 {name=p18357 lab=_68707_/X }
C {devices/lab_pin.sym} 19100 -37980 0 0 {name=p18358 lab=_68762_/X }
C {devices/lab_pin.sym} 19100 -37940 0 0 {name=p18359 lab=_68785_/X }
C {devices/lab_pin.sym} 19260 -38000 0 1 {name=p18360 lab=_68786_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -38000 0 0 {name=X_68786_ }
C {devices/lab_pin.sym} 19100 -37880 0 0 {name=p18361 lab=_65824_/X }
C {devices/lab_pin.sym} 19100 -37840 0 0 {name=p18362 lab=_84987_/Q }
C {devices/lab_pin.sym} 19100 -37800 0 0 {name=p18363 lab=_65707_/X }
C {devices/lab_pin.sym} 19100 -37760 0 0 {name=p18364 lab=_65997_/X }
C {devices/lab_pin.sym} 19260 -37820 0 1 {name=p18365 lab=_65999_/B }
C {sky130_stdcells/a211o_4.sym} 19180 -37820 0 0 {name=X_65998_ }
C {devices/lab_pin.sym} 19090 -37670 0 0 {name=p18366 lab=_82803_/CLK }
C {devices/lab_pin.sym} 19090 -37650 0 0 {name=p18367 lab=_82835_/Q }
C {devices/lab_pin.sym} 19270 -37670 0 1 {name=p18368 lab=_78552_/A }
C {sky130_stdcells/dfxtp_4.sym} 19180 -37660 0 0 {name=X_82803_ }
C {devices/lab_pin.sym} 19100 -37560 0 0 {name=p18369 lab=_56442_/C }
C {devices/lab_pin.sym} 19100 -37520 0 0 {name=p18370 lab=_55272_/X }
C {devices/lab_pin.sym} 19100 -37480 0 0 {name=p18371 lab=_55168_/X }
C {devices/lab_pin.sym} 19100 -37440 0 0 {name=p18372 lab=_55750_/X }
C {devices/lab_pin.sym} 19260 -37500 0 1 {name=p18373 lab=_55752_/B }
C {sky130_stdcells/a211o_4.sym} 19180 -37500 0 0 {name=X_55751_ }
C {devices/lab_pin.sym} 19120 -37360 0 0 {name=p18374 lab=_67690_/X }
C {devices/lab_pin.sym} 19120 -37320 0 0 {name=p18375 lab=_87650_/Q }
C {devices/lab_pin.sym} 19240 -37340 0 1 {name=p18376 lab=_67737_/X }
C {sky130_stdcells/and2_4.sym} 19180 -37340 0 0 {name=X_67737_ }
C {devices/lab_pin.sym} 19090 -37210 0 0 {name=p18377 lab=_85601_/CLK }
C {devices/lab_pin.sym} 19090 -37190 0 0 {name=p18378 lab=_48070_/Y }
C {devices/lab_pin.sym} 19270 -37210 0 1 {name=p18379 lab=_74083_/B }
C {sky130_stdcells/dfxtp_4.sym} 19180 -37200 0 0 {name=X_86571_ }
C {devices/lab_pin.sym} 19120 -37100 0 0 {name=p18380 lab=_52947_/X }
C {devices/lab_pin.sym} 19120 -37060 0 0 {name=p18381 lab=_52982_/B }
C {devices/lab_pin.sym} 19120 -37020 0 0 {name=p18382 lab=_52977_/C }
C {devices/lab_pin.sym} 19120 -36980 0 0 {name=p18383 lab=_52963_/D }
C {devices/lab_pin.sym} 19240 -37040 0 1 {name=p18384 lab=_52963_/X }
C {sky130_stdcells/and4_4.sym} 19180 -37040 0 0 {name=X_52963_ }
C {devices/lab_pin.sym} 19100 -36920 0 0 {name=p18385 lab=_64846_/X }
C {devices/lab_pin.sym} 19100 -36880 0 0 {name=p18386 lab=_85556_/Q }
C {devices/lab_pin.sym} 19100 -36840 0 0 {name=p18387 lab=_64919_/X }
C {devices/lab_pin.sym} 19100 -36800 0 0 {name=p18388 lab=_64948_/X }
C {devices/lab_pin.sym} 19260 -36860 0 1 {name=p18389 lab=_64949_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -36860 0 0 {name=X_64949_ }
C {devices/lab_pin.sym} 19090 -36710 0 0 {name=p18390 lab=_83783_/CLK }
C {devices/lab_pin.sym} 19090 -36690 0 0 {name=p18391 lab=_70380_/Y }
C {devices/lab_pin.sym} 19270 -36710 0 1 {name=p18392 lab=_46545_/A }
C {sky130_stdcells/dfxtp_4.sym} 19180 -36700 0 0 {name=X_83783_ }
C {devices/lab_pin.sym} 19090 -36570 0 0 {name=p18393 lab=_82610_/CLK }
C {devices/lab_pin.sym} 19090 -36550 0 0 {name=p18394 lab=_84203_/Q }
C {devices/lab_pin.sym} 19270 -36570 0 1 {name=p18395 lab=_80995_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -36560 0 0 {name=X_80995_ }
C {devices/lab_pin.sym} 19090 -36430 0 0 {name=p18396 lab=_87851_/CLK }
C {devices/lab_pin.sym} 19090 -36410 0 0 {name=p18397 lab=_88310_/D }
C {devices/lab_pin.sym} 19270 -36430 0 1 {name=p18398 lab=_88310_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -36420 0 0 {name=X_88310_ }
C {devices/lab_pin.sym} 19100 -36310 0 0 {name=p18399 lab=_54698_/Y }
C {devices/lab_pin.sym} 19100 -36270 0 0 {name=p18400 lab=_54694_/X }
C {devices/lab_pin.sym} 19100 -36230 0 0 {name=p18401 lab=_54701_/X }
C {devices/lab_pin.sym} 19260 -36270 0 1 {name=p18402 lab=_85394_/D }
C {sky130_stdcells/a21oi_4.sym} 19180 -36270 0 0 {name=X_54702_ }
C {devices/lab_pin.sym} 19090 -36130 0 0 {name=p18403 lab=_86139_/CLK }
C {devices/lab_pin.sym} 19090 -36110 0 0 {name=p18404 lab=_85522_/D }
C {devices/lab_pin.sym} 19270 -36130 0 1 {name=p18405 lab=_85522_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -36120 0 0 {name=X_85522_ }
C {devices/lab_pin.sym} 19120 -36020 0 0 {name=p18406 lab=_51914_/A }
C {devices/lab_pin.sym} 19120 -35980 0 0 {name=p18407 lab=_51898_/B }
C {devices/lab_pin.sym} 19120 -35940 0 0 {name=p18408 lab=_51893_/C }
C {devices/lab_pin.sym} 19120 -35900 0 0 {name=p18409 lab=_52742_/D }
C {devices/lab_pin.sym} 19240 -35960 0 1 {name=p18410 lab=_51914_/X }
C {sky130_stdcells/and4_4.sym} 19180 -35960 0 0 {name=X_51914_ }
C {devices/lab_pin.sym} 19120 -35820 0 0 {name=p18411 lab=_63557_/B }
C {devices/lab_pin.sym} 19120 -35780 0 0 {name=p18412 lab=_58474_/B }
C {devices/lab_pin.sym} 19240 -35800 0 1 {name=p18413 lab=_58470_/Y }
C {sky130_stdcells/nor2_4.sym} 19180 -35800 0 0 {name=X_58470_ }
C {devices/lab_pin.sym} 19090 -35670 0 0 {name=p18414 lab=_82147_/CLK }
C {devices/lab_pin.sym} 19090 -35650 0 0 {name=p18415 lab=_84118_/Q }
C {devices/lab_pin.sym} 19270 -35670 0 1 {name=p18416 lab=_82734_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -35660 0 0 {name=X_82734_ }
C {devices/lab_pin.sym} 19140 -35530 0 0 {name=p18417 lab=_55681_/X }
C {devices/lab_pin.sym} 19220 -35530 0 1 {name=p18418 lab=_55683_/D }
C {sky130_stdcells/inv_2.sym} 19180 -35530 0 0 {name=X_55682_ }
C {devices/lab_pin.sym} 19100 -35440 0 0 {name=p18419 lab=_87461_/Q }
C {devices/lab_pin.sym} 19100 -35400 0 0 {name=p18420 lab=_67594_/X }
C {devices/lab_pin.sym} 19100 -35360 0 0 {name=p18421 lab=_67595_/X }
C {devices/lab_pin.sym} 19100 -35320 0 0 {name=p18422 lab=_67667_/X }
C {devices/lab_pin.sym} 19260 -35380 0 1 {name=p18423 lab=_67668_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -35380 0 0 {name=X_67668_ }
C {devices/lab_pin.sym} 19140 -35230 0 0 {name=p18424 lab=_52893_/X }
C {devices/lab_pin.sym} 19220 -35230 0 1 {name=p18425 lab=_52895_/A }
C {sky130_stdcells/buf_2.sym} 19180 -35230 0 0 {name=X_52894_ }
C {devices/lab_pin.sym} 19140 -35110 0 0 {name=p18426 lab=_57440_/A }
C {devices/lab_pin.sym} 19220 -35110 0 1 {name=p18427 lab=_57445_/B }
C {sky130_stdcells/buf_2.sym} 19180 -35110 0 0 {name=X_57421_ }
C {devices/lab_pin.sym} 19100 -35020 0 0 {name=p18428 lab=_69300_/X }
C {devices/lab_pin.sym} 19100 -34980 0 0 {name=p18429 lab=_69403_/Y }
C {devices/lab_pin.sym} 19100 -34940 0 0 {name=p18430 lab=_69405_/X }
C {devices/lab_pin.sym} 19100 -34900 0 0 {name=p18431 lab=_69406_/Y }
C {devices/lab_pin.sym} 19260 -34960 0 1 {name=p18432 lab=_69407_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -34960 0 0 {name=X_69407_ }
C {devices/lab_pin.sym} 19090 -34810 0 0 {name=p18433 lab=_87408_/CLK }
C {devices/lab_pin.sym} 19090 -34790 0 0 {name=p18434 lab=_88241_/D }
C {devices/lab_pin.sym} 19270 -34810 0 1 {name=p18435 lab=_67399_/B }
C {sky130_stdcells/dfxtp_4.sym} 19180 -34800 0 0 {name=X_88241_ }
C {devices/lab_pin.sym} 19100 -34690 0 0 {name=p18436 lab=_85406_/Q }
C {devices/lab_pin.sym} 19100 -34650 0 0 {name=p18437 lab=_54621_/X }
C {devices/lab_pin.sym} 19100 -34610 0 0 {name=p18438 lab=_54632_/Y }
C {devices/lab_pin.sym} 19260 -34650 0 1 {name=p18439 lab=_54633_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -34650 0 0 {name=X_54633_ }
C {devices/lab_pin.sym} 19100 -34540 0 0 {name=p18440 lab=_87377_/Q }
C {devices/lab_pin.sym} 19100 -34500 0 0 {name=p18441 lab=_66538_/X }
C {devices/lab_pin.sym} 19100 -34460 0 0 {name=p18442 lab=_66540_/X }
C {devices/lab_pin.sym} 19100 -34420 0 0 {name=p18443 lab=_66618_/X }
C {devices/lab_pin.sym} 19260 -34480 0 1 {name=p18444 lab=_66619_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -34480 0 0 {name=X_66619_ }
C {devices/lab_pin.sym} 19090 -34330 0 0 {name=p18445 lab=_85773_/CLK }
C {devices/lab_pin.sym} 19090 -34310 0 0 {name=p18446 lab=_85453_/D }
C {devices/lab_pin.sym} 19270 -34330 0 1 {name=p18447 lab=_85453_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -34320 0 0 {name=X_85453_ }
C {devices/lab_pin.sym} 19100 -34210 0 0 {name=p18448 lab=_51841_/Y }
C {devices/lab_pin.sym} 19100 -34170 0 0 {name=p18449 lab=_51823_/X }
C {devices/lab_pin.sym} 19100 -34130 0 0 {name=p18450 lab=_51844_/X }
C {devices/lab_pin.sym} 19260 -34170 0 1 {name=p18451 lab=_51845_/Y }
C {sky130_stdcells/a21oi_4.sym} 19180 -34170 0 0 {name=X_51845_ }
C {devices/lab_pin.sym} 19090 -34030 0 0 {name=p18452 lab=_82665_/CLK }
C {devices/lab_pin.sym} 19090 -34010 0 0 {name=p18453 lab=_82709_/Q }
C {devices/lab_pin.sym} 19270 -34030 0 1 {name=p18454 lab=_78128_/A }
C {sky130_stdcells/dfxtp_4.sym} 19180 -34020 0 0 {name=X_82665_ }
C {devices/lab_pin.sym} 19140 -33890 0 0 {name=p18455 lab=_67126_/X }
C {devices/lab_pin.sym} 19220 -33890 0 1 {name=p18456 lab=_67696_/A }
C {sky130_stdcells/buf_2.sym} 19180 -33890 0 0 {name=X_67599_ }
C {devices/lab_pin.sym} 19090 -33770 0 0 {name=p18457 lab=_84418_/CLK }
C {devices/lab_pin.sym} 19090 -33750 0 0 {name=p18458 lab=_62528_/Y }
C {devices/lab_pin.sym} 19270 -33770 0 1 {name=p18459 lab=_62527_/C }
C {sky130_stdcells/dfxtp_4.sym} 19180 -33760 0 0 {name=X_84404_ }
C {devices/lab_pin.sym} 19100 -33660 0 0 {name=p18460 lab=_57289_/B }
C {devices/lab_pin.sym} 19100 -33620 0 0 {name=p18461 lab=_56862_/Y }
C {devices/lab_pin.sym} 19100 -33580 0 0 {name=p18462 lab=_57346_/C }
C {devices/lab_pin.sym} 19100 -33540 0 0 {name=p18463 lab=_57337_/Y }
C {devices/lab_pin.sym} 19260 -33600 0 1 {name=p18464 lab=_57352_/X }
C {sky130_stdcells/o22a_4.sym} 19180 -33600 0 0 {name=X_57352_ }
C {devices/lab_pin.sym} 19090 -33450 0 0 {name=p18465 lab=_81808_/CLK }
C {devices/lab_pin.sym} 19090 -33430 0 0 {name=p18466 lab=_76363_/B }
C {devices/lab_pin.sym} 19270 -33450 0 1 {name=p18467 lab=_81808_/D }
C {sky130_stdcells/dfxtp_4.sym} 19180 -33440 0 0 {name=X_81616_ }
C {devices/lab_pin.sym} 19100 -33340 0 0 {name=p18468 lab=_69329_/X }
C {devices/lab_pin.sym} 19100 -33300 0 0 {name=p18469 lab=_68725_/Y }
C {devices/lab_pin.sym} 19100 -33260 0 0 {name=p18470 lab=_69325_/X }
C {devices/lab_pin.sym} 19100 -33220 0 0 {name=p18471 lab=_69337_/Y }
C {devices/lab_pin.sym} 19260 -33280 0 1 {name=p18472 lab=_69338_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -33280 0 0 {name=X_69338_ }
C {devices/lab_pin.sym} 19090 -33130 0 0 {name=p18473 lab=_83987_/CLK }
C {devices/lab_pin.sym} 19090 -33110 0 0 {name=p18474 lab=_41670_/Y }
C {devices/lab_pin.sym} 19270 -33130 0 1 {name=p18475 lab=_88172_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -33120 0 0 {name=X_88172_ }
C {devices/lab_pin.sym} 19140 -32990 0 0 {name=p18476 lab=_54537_/A }
C {devices/lab_pin.sym} 19220 -32990 0 1 {name=p18477 lab=_54565_/C }
C {sky130_stdcells/buf_2.sym} 19180 -32990 0 0 {name=X_54564_ }
C {devices/lab_pin.sym} 19090 -32870 0 0 {name=p18478 lab=_85379_/CLK }
C {devices/lab_pin.sym} 19090 -32850 0 0 {name=p18479 lab=_85384_/D }
C {devices/lab_pin.sym} 19270 -32870 0 1 {name=p18480 lab=_85384_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -32860 0 0 {name=X_85384_ }
C {devices/lab_pin.sym} 19140 -32730 0 0 {name=p18481 lab=_51747_/A }
C {devices/lab_pin.sym} 19220 -32730 0 1 {name=p18482 lab=_51794_/A }
C {sky130_stdcells/buf_2.sym} 19180 -32730 0 0 {name=X_51776_ }
C {devices/lab_pin.sym} 19090 -32610 0 0 {name=p18483 lab=_82596_/CLK }
C {devices/lab_pin.sym} 19090 -32590 0 0 {name=p18484 lab=_78831_/B }
C {devices/lab_pin.sym} 19270 -32610 0 1 {name=p18485 lab=_82564_/D }
C {sky130_stdcells/dfxtp_4.sym} 19180 -32600 0 0 {name=X_82596_ }
C {devices/lab_pin.sym} 19120 -32490 0 0 {name=p18486 lab=_56296_/A }
C {devices/lab_pin.sym} 19120 -32450 0 0 {name=p18487 lab=_56298_/X }
C {devices/lab_pin.sym} 19120 -32410 0 0 {name=p18488 lab=_56303_/C }
C {devices/lab_pin.sym} 19240 -32450 0 1 {name=p18489 lab=_56303_/Y }
C {sky130_stdcells/nand3_4.sym} 19180 -32450 0 0 {name=X_56303_ }
C {devices/lab_pin.sym} 19090 -32310 0 0 {name=p18490 lab=_87137_/CLK }
C {devices/lab_pin.sym} 19090 -32290 0 0 {name=p18491 lab=_87123_/D }
C {devices/lab_pin.sym} 19270 -32310 0 1 {name=p18492 lab=_87123_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -32300 0 0 {name=X_87123_ }
C {devices/lab_pin.sym} 19100 -32190 0 0 {name=p18493 lab=_85622_/Q }
C {devices/lab_pin.sym} 19100 -32150 0 0 {name=p18494 lab=_53506_/X }
C {devices/lab_pin.sym} 19100 -32110 0 0 {name=p18495 lab=_53514_/Y }
C {devices/lab_pin.sym} 19260 -32150 0 1 {name=p18496 lab=_53515_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -32150 0 0 {name=X_53515_ }
C {devices/lab_pin.sym} 19090 -32010 0 0 {name=p18497 lab=_83227_/CLK }
C {devices/lab_pin.sym} 19090 -31990 0 0 {name=p18498 lab=_63308_/Y }
C {devices/lab_pin.sym} 19270 -32010 0 1 {name=p18499 lab=_79231_/A }
C {sky130_stdcells/dfxtp_4.sym} 19180 -32000 0 0 {name=X_84335_ }
C {devices/lab_pin.sym} 19140 -31870 0 0 {name=p18500 lab=_50506_/A }
C {devices/lab_pin.sym} 19220 -31870 0 1 {name=p18501 lab=_50727_/X }
C {sky130_stdcells/buf_2.sym} 19180 -31870 0 0 {name=X_50727_ }
C {devices/lab_pin.sym} 19120 -31770 0 0 {name=p18502 lab=_57049_/A }
C {devices/lab_pin.sym} 19120 -31730 0 0 {name=p18503 lab=_57283_/B }
C {devices/lab_pin.sym} 19120 -31690 0 0 {name=p18504 lab=_57326_/C }
C {devices/lab_pin.sym} 19240 -31730 0 1 {name=p18505 lab=_57283_/Y }
C {sky130_stdcells/nor3_4.sym} 19180 -31730 0 0 {name=X_57283_ }
C {devices/lab_pin.sym} 19090 -31590 0 0 {name=p18506 lab=_81412_/CLK }
C {devices/lab_pin.sym} 19090 -31570 0 0 {name=p18507 lab=_81547_/D }
C {devices/lab_pin.sym} 19270 -31590 0 1 {name=p18508 lab=_76595_/B }
C {sky130_stdcells/dfxtp_4.sym} 19180 -31580 0 0 {name=X_81547_ }
C {devices/lab_pin.sym} 19100 -31480 0 0 {name=p18509 lab=_69216_/X }
C {devices/lab_pin.sym} 19100 -31440 0 0 {name=p18510 lab=_69267_/Y }
C {devices/lab_pin.sym} 19100 -31400 0 0 {name=p18511 lab=_69231_/X }
C {devices/lab_pin.sym} 19100 -31360 0 0 {name=p18512 lab=_69268_/Y }
C {devices/lab_pin.sym} 19260 -31420 0 1 {name=p18513 lab=_69269_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -31420 0 0 {name=X_69269_ }
C {devices/lab_pin.sym} 19100 -31290 0 0 {name=p18514 lab=_54492_/Y }
C {devices/lab_pin.sym} 19100 -31250 0 0 {name=p18515 lab=_54475_/X }
C {devices/lab_pin.sym} 19100 -31210 0 0 {name=p18516 lab=_54494_/X }
C {devices/lab_pin.sym} 19260 -31250 0 1 {name=p18517 lab=_85432_/D }
C {sky130_stdcells/a21oi_4.sym} 19180 -31250 0 0 {name=X_54495_ }
C {devices/lab_pin.sym} 19100 -31130 0 0 {name=p18518 lab=_58925_/X }
C {devices/lab_pin.sym} 19100 -31090 0 0 {name=p18519 lab=_85439_/Q }
C {devices/lab_pin.sym} 19100 -31050 0 0 {name=p18520 lab=_59021_/X }
C {devices/lab_pin.sym} 19260 -31090 0 1 {name=p18521 lab=_59022_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -31090 0 0 {name=X_59022_ }
C {devices/lab_pin.sym} 19120 -30970 0 0 {name=p18522 lab=_71303_/A }
C {devices/lab_pin.sym} 19120 -30930 0 0 {name=p18523 lab=_71303_/B }
C {devices/lab_pin.sym} 19120 -30890 0 0 {name=p18524 lab=_70472_/X }
C {devices/lab_pin.sym} 19240 -30930 0 1 {name=p18525 lab=_71300_/Y }
C {sky130_stdcells/nand3_4.sym} 19180 -30930 0 0 {name=X_71300_ }
C {devices/lab_pin.sym} 19100 -30810 0 0 {name=p18526 lab=_56085_/X }
C {devices/lab_pin.sym} 19100 -30770 0 0 {name=p18527 lab=_56225_/X }
C {devices/lab_pin.sym} 19100 -30730 0 0 {name=p18528 lab=_56233_/Y }
C {devices/lab_pin.sym} 19260 -30770 0 1 {name=p18529 lab=_56234_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -30770 0 0 {name=X_56234_ }
C {devices/lab_pin.sym} 19090 -30630 0 0 {name=p18530 lab=_88062_/CLK }
C {devices/lab_pin.sym} 19090 -30610 0 0 {name=p18531 lab=_44562_/Y }
C {devices/lab_pin.sym} 19270 -30630 0 1 {name=p18532 lab=_87054_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -30620 0 0 {name=X_87054_ }
C {devices/lab_pin.sym} 19100 -30510 0 0 {name=p18533 lab=_41449_/X }
C {devices/lab_pin.sym} 19100 -30470 0 0 {name=p18534 lab=_82337_/Q }
C {devices/lab_pin.sym} 19100 -30430 0 0 {name=p18535 lab=_41459_/X }
C {devices/lab_pin.sym} 19260 -30470 0 1 {name=p18536 lab=_41460_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -30470 0 0 {name=X_41460_ }
C {devices/lab_pin.sym} 19140 -30330 0 0 {name=p18537 lab=_53445_/Y }
C {devices/lab_pin.sym} 19220 -30330 0 1 {name=p18538 lab=_85633_/D }
C {sky130_stdcells/inv_2.sym} 19180 -30330 0 0 {name=X_53446_ }
C {devices/lab_pin.sym} 19100 -30230 0 0 {name=p18539 lab=_72196_/X }
C {devices/lab_pin.sym} 19100 -30190 0 0 {name=p18540 lab=_85332_/Q }
C {devices/lab_pin.sym} 19100 -30150 0 0 {name=p18541 lab=_72255_/X }
C {devices/lab_pin.sym} 19260 -30190 0 1 {name=p18542 lab=_72280_/X }
C {sky130_stdcells/o21a_4.sym} 19180 -30190 0 0 {name=X_72280_ }
C {devices/lab_pin.sym} 19090 -30050 0 0 {name=p18543 lab=_84652_/CLK }
C {devices/lab_pin.sym} 19090 -30030 0 0 {name=p18544 lab=_64201_/Y }
C {devices/lab_pin.sym} 19270 -30050 0 1 {name=p18545 lab=_64200_/C }
C {sky130_stdcells/dfxtp_4.sym} 19180 -30040 0 0 {name=X_84266_ }
C {devices/lab_pin.sym} 19100 -29930 0 0 {name=p18546 lab=_86159_/Q }
C {devices/lab_pin.sym} 19100 -29890 0 0 {name=p18547 lab=_50654_/X }
C {devices/lab_pin.sym} 19100 -29850 0 0 {name=p18548 lab=_50657_/Y }
C {devices/lab_pin.sym} 19260 -29890 0 1 {name=p18549 lab=_50658_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -29890 0 0 {name=X_50658_ }
C {devices/lab_pin.sym} 19090 -29750 0 0 {name=p18550 lab=_88116_/CLK }
C {devices/lab_pin.sym} 19090 -29730 0 0 {name=p18551 lab=_81478_/D }
C {devices/lab_pin.sym} 19270 -29750 0 1 {name=p18552 lab=_76692_/B }
C {sky130_stdcells/dfxtp_4.sym} 19180 -29740 0 0 {name=X_81478_ }
C {devices/lab_pin.sym} 19090 -29610 0 0 {name=p18553 lab=_86005_/CLK }
C {devices/lab_pin.sym} 19090 -29590 0 0 {name=p18554 lab=_86005_/D }
C {devices/lab_pin.sym} 19270 -29610 0 1 {name=p18555 lab=_86005_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -29600 0 0 {name=X_86005_ }
C {devices/lab_pin.sym} 19140 -29470 0 0 {name=p18556 lab=_40354_/X }
C {devices/lab_pin.sym} 19220 -29470 0 1 {name=p18557 lab=_40411_/X }
C {sky130_stdcells/buf_2.sym} 19180 -29470 0 0 {name=X_40411_ }
C {devices/lab_pin.sym} 19100 -29370 0 0 {name=p18558 lab=_48684_/B }
C {devices/lab_pin.sym} 19100 -29330 0 0 {name=p18559 lab=_71231_/A2 }
C {devices/lab_pin.sym} 19100 -29290 0 0 {name=p18560 lab=_71230_/Y }
C {devices/lab_pin.sym} 19260 -29330 0 1 {name=p18561 lab=_71231_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -29330 0 0 {name=X_71231_ }
C {devices/lab_pin.sym} 19090 -29190 0 0 {name=p18562 lab=_83218_/CLK }
C {devices/lab_pin.sym} 19090 -29170 0 0 {name=p18563 lab=_72611_/X }
C {devices/lab_pin.sym} 19270 -29190 0 1 {name=p18564 lab=_83217_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -29180 0 0 {name=X_83217_ }
C {devices/lab_pin.sym} 19120 -29070 0 0 {name=p18565 lab=_56169_/A }
C {devices/lab_pin.sym} 19120 -29030 0 0 {name=p18566 lab=_56150_/B }
C {devices/lab_pin.sym} 19120 -28990 0 0 {name=p18567 lab=_56165_/C }
C {devices/lab_pin.sym} 19240 -29030 0 1 {name=p18568 lab=_56165_/Y }
C {sky130_stdcells/nand3_4.sym} 19180 -29030 0 0 {name=X_56165_ }
C {devices/lab_pin.sym} 19120 -28900 0 0 {name=p18569 lab=_80446_/B }
C {devices/lab_pin.sym} 19120 -28860 0 0 {name=p18570 lab=_80429_/B }
C {devices/lab_pin.sym} 19240 -28880 0 1 {name=p18571 lab=_80429_/X }
C {sky130_stdcells/xor2_4.sym} 19180 -28880 0 0 {name=X_80429_ }
C {devices/lab_pin.sym} 19120 -28760 0 0 {name=p18572 lab=_81741_/Q }
C {devices/lab_pin.sym} 19120 -28720 0 0 {name=p18573 lab=_41325_/X }
C {devices/lab_pin.sym} 19240 -28740 0 1 {name=p18574 lab=_41391_/X }
C {sky130_stdcells/or2_4.sym} 19180 -28740 0 0 {name=X_41391_ }
C {devices/lab_pin.sym} 19100 -28630 0 0 {name=p18575 lab=_53374_/Y }
C {devices/lab_pin.sym} 19100 -28590 0 0 {name=p18576 lab=_53355_/X }
C {devices/lab_pin.sym} 19100 -28550 0 0 {name=p18577 lab=_53376_/X }
C {devices/lab_pin.sym} 19260 -28590 0 1 {name=p18578 lab=_85645_/D }
C {sky130_stdcells/a21oi_4.sym} 19180 -28590 0 0 {name=X_53377_ }
C {devices/lab_pin.sym} 19090 -28450 0 0 {name=p18579 lab=_84197_/CLK }
C {devices/lab_pin.sym} 19090 -28430 0 0 {name=p18580 lab=_84197_/D }
C {devices/lab_pin.sym} 19270 -28450 0 1 {name=p18581 lab=_84197_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -28440 0 0 {name=X_84197_ }
C {devices/lab_pin.sym} 19100 -28330 0 0 {name=p18582 lab=_50587_/Y }
C {devices/lab_pin.sym} 19100 -28290 0 0 {name=p18583 lab=_50551_/X }
C {devices/lab_pin.sym} 19100 -28250 0 0 {name=p18584 lab=_50588_/X }
C {devices/lab_pin.sym} 19260 -28290 0 1 {name=p18585 lab=_86172_/D }
C {sky130_stdcells/a21oi_4.sym} 19180 -28290 0 0 {name=X_50589_ }
C {devices/lab_pin.sym} 19140 -28150 0 0 {name=p18586 lab=_43189_/A }
C {devices/lab_pin.sym} 19220 -28150 0 1 {name=p18587 lab=_43130_/X }
C {sky130_stdcells/buf_2.sym} 19180 -28150 0 0 {name=X_43130_ }
C {devices/lab_pin.sym} 19120 -28060 0 0 {name=p18588 lab=_55112_/A }
C {devices/lab_pin.sym} 19120 -28020 0 0 {name=p18589 lab=_47877_/A }
C {devices/lab_pin.sym} 19120 -27980 0 0 {name=p18590 lab=_55120_/C }
C {devices/lab_pin.sym} 19120 -27940 0 0 {name=p18591 lab=_47814_/A }
C {devices/lab_pin.sym} 19240 -28000 0 1 {name=p18592 lab=_55116_/X }
C {sky130_stdcells/and4_4.sym} 19180 -28000 0 0 {name=X_55116_ }
C {devices/lab_pin.sym} 19120 -27860 0 0 {name=p18593 lab=_52320_/A }
C {devices/lab_pin.sym} 19120 -27820 0 0 {name=p18594 lab=_52328_/B }
C {devices/lab_pin.sym} 19240 -27840 0 1 {name=p18595 lab=_52328_/X }
C {sky130_stdcells/and2_4.sym} 19180 -27840 0 0 {name=X_52328_ }
C {devices/lab_pin.sym} 19140 -27710 0 0 {name=p18596 lab=_74492_/A }
C {devices/lab_pin.sym} 19220 -27710 0 1 {name=p18597 lab=_40342_/X }
C {sky130_stdcells/buf_2.sym} 19180 -27710 0 0 {name=X_40342_ }
C {devices/lab_pin.sym} 19120 -27620 0 0 {name=p18598 lab=_70758_/A }
C {devices/lab_pin.sym} 19120 -27580 0 0 {name=p18599 lab=_71162_/B }
C {devices/lab_pin.sym} 19120 -27540 0 0 {name=p18600 lab=_70827_/C }
C {devices/lab_pin.sym} 19120 -27500 0 0 {name=p18601 lab=_70578_/A }
C {devices/lab_pin.sym} 19240 -27560 0 1 {name=p18602 lab=_71163_/A }
C {sky130_stdcells/nand4_4.sym} 19180 -27560 0 0 {name=X_71162_ }
C {devices/lab_pin.sym} 19090 -27410 0 0 {name=p18603 lab=_86218_/CLK }
C {devices/lab_pin.sym} 19090 -27390 0 0 {name=p18604 lab=_73506_/X }
C {devices/lab_pin.sym} 19270 -27410 0 1 {name=p18605 lab=_83148_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -27400 0 0 {name=X_83148_ }
C {devices/lab_pin.sym} 19120 -27290 0 0 {name=p18606 lab=_56100_/A }
C {devices/lab_pin.sym} 19120 -27250 0 0 {name=p18607 lab=_56115_/B }
C {devices/lab_pin.sym} 19120 -27210 0 0 {name=p18608 lab=_85297_/Q }
C {devices/lab_pin.sym} 19240 -27250 0 1 {name=p18609 lab=_56096_/Y }
C {sky130_stdcells/nand3_4.sym} 19180 -27250 0 0 {name=X_56096_ }
C {devices/lab_pin.sym} 19140 -27110 0 0 {name=p18610 lab=_70113_/A }
C {devices/lab_pin.sym} 19220 -27110 0 1 {name=p18611 lab=_70117_/A }
C {sky130_stdcells/inv_2.sym} 19180 -27110 0 0 {name=X_70113_ }
C {devices/lab_pin.sym} 19140 -26990 0 0 {name=p18612 lab=_43121_/A }
C {devices/lab_pin.sym} 19220 -26990 0 1 {name=p18613 lab=_43061_/X }
C {sky130_stdcells/buf_2.sym} 19180 -26990 0 0 {name=X_43061_ }
C {devices/lab_pin.sym} 19140 -26870 0 0 {name=p18614 lab=_47838_/X }
C {devices/lab_pin.sym} 19220 -26870 0 1 {name=p18615 lab=_55054_/A }
C {sky130_stdcells/buf_2.sym} 19180 -26870 0 0 {name=X_55047_ }
C {devices/lab_pin.sym} 19140 -26750 0 0 {name=p18616 lab=_59923_/Y }
C {devices/lab_pin.sym} 19220 -26750 0 1 {name=p18617 lab=_62237_/A }
C {sky130_stdcells/buf_2.sym} 19180 -26750 0 0 {name=X_59924_ }
C {devices/lab_pin.sym} 19120 -26640 0 0 {name=p18618 lab=_52250_/A }
C {devices/lab_pin.sym} 19120 -26600 0 0 {name=p18619 lab=_48878_/B }
C {devices/lab_pin.sym} 19240 -26620 0 1 {name=p18620 lab=_52259_/Y }
C {sky130_stdcells/nand2_4.sym} 19180 -26620 0 0 {name=X_52259_ }
C {devices/lab_pin.sym} 19120 -26520 0 0 {name=p18621 lab=_70905_/D }
C {devices/lab_pin.sym} 19120 -26480 0 0 {name=p18622 lab=_70959_/B }
C {devices/lab_pin.sym} 19120 -26440 0 0 {name=p18623 lab=_71093_/C }
C {devices/lab_pin.sym} 19120 -26400 0 0 {name=p18624 lab=_71115_/D }
C {devices/lab_pin.sym} 19240 -26460 0 1 {name=p18625 lab=_71093_/X }
C {sky130_stdcells/and4_4.sym} 19180 -26460 0 0 {name=X_71093_ }
C {devices/lab_pin.sym} 19120 -26320 0 0 {name=p18626 lab=_75970_/A }
C {devices/lab_pin.sym} 19120 -26280 0 0 {name=p18627 lab=_75969_/Y }
C {devices/lab_pin.sym} 19240 -26300 0 1 {name=p18628 lab=_81737_/D }
C {sky130_stdcells/xor2_4.sym} 19180 -26300 0 0 {name=X_75970_ }
C {devices/lab_pin.sym} 19090 -26170 0 0 {name=p18629 lab=_83589_/CLK }
C {devices/lab_pin.sym} 19090 -26150 0 0 {name=p18630 lab=_74376_/Y }
C {devices/lab_pin.sym} 19270 -26170 0 1 {name=p18631 lab=_83079_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -26160 0 0 {name=X_83079_ }
C {devices/lab_pin.sym} 19090 -26030 0 0 {name=p18632 lab=_87126_/CLK }
C {devices/lab_pin.sym} 19090 -26010 0 0 {name=p18633 lab=_87956_/D }
C {devices/lab_pin.sym} 19270 -26030 0 1 {name=p18634 lab=_87956_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -26020 0 0 {name=X_87956_ }
C {devices/lab_pin.sym} 19100 -25930 0 0 {name=p18635 lab=_41998_/X }
C {devices/lab_pin.sym} 19100 -25890 0 0 {name=p18636 lab=_42010_/X }
C {devices/lab_pin.sym} 19100 -25850 0 0 {name=p18637 lab=_40820_/X }
C {devices/lab_pin.sym} 19100 -25810 0 0 {name=p18638 lab=_42011_/Y }
C {devices/lab_pin.sym} 19100 -25770 0 0 {name=p18639 lab=_42000_/X }
C {devices/lab_pin.sym} 19260 -25850 0 1 {name=p18640 lab=_42012_/Y }
C {sky130_stdcells/o32ai_4.sym} 19180 -25850 0 0 {name=X_42012_ }
C {devices/lab_pin.sym} 19120 -25700 0 0 {name=p18641 lab=_80757_/Q }
C {devices/lab_pin.sym} 19120 -25660 0 0 {name=p18642 lab=_74921_/B }
C {devices/lab_pin.sym} 19240 -25680 0 1 {name=p18643 lab=_74923_/A }
C {sky130_stdcells/or2_4.sym} 19180 -25680 0 0 {name=X_74921_ }
C {devices/lab_pin.sym} 19140 -25550 0 0 {name=p18644 lab=_69655_/A }
C {devices/lab_pin.sym} 19220 -25550 0 1 {name=p18645 lab=_70044_/X }
C {sky130_stdcells/buf_2.sym} 19180 -25550 0 0 {name=X_70044_ }
C {devices/lab_pin.sym} 19090 -25430 0 0 {name=p18646 lab=_84420_/CLK }
C {devices/lab_pin.sym} 19090 -25410 0 0 {name=p18647 lab=_44978_/Y }
C {devices/lab_pin.sym} 19270 -25430 0 1 {name=p18648 lab=_63049_/B }
C {sky130_stdcells/dfxtp_4.sym} 19180 -25420 0 0 {name=X_86907_ }
C {devices/lab_pin.sym} 19120 -25310 0 0 {name=p18649 lab=_59855_/A }
C {devices/lab_pin.sym} 19120 -25270 0 0 {name=p18650 lab=_59855_/B }
C {devices/lab_pin.sym} 19120 -25230 0 0 {name=p18651 lab=_80347_/A }
C {devices/lab_pin.sym} 19240 -25270 0 1 {name=p18652 lab=_59855_/Y }
C {sky130_stdcells/nor3_4.sym} 19180 -25270 0 0 {name=X_59855_ }
C {devices/lab_pin.sym} 19090 -25130 0 0 {name=p18653 lab=_88144_/CLK }
C {devices/lab_pin.sym} 19090 -25110 0 0 {name=p18654 lab=_87887_/D }
C {devices/lab_pin.sym} 19270 -25130 0 1 {name=p18655 lab=_87887_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -25120 0 0 {name=X_87887_ }
C {devices/lab_pin.sym} 19140 -24990 0 0 {name=p18656 lab=_82956_/Q }
C {devices/lab_pin.sym} 19220 -24990 0 1 {name=p18657 lab=_46820_/Y }
C {sky130_stdcells/inv_2.sym} 19180 -24990 0 0 {name=X_46820_ }
C {devices/lab_pin.sym} 19140 -24870 0 0 {name=p18658 lab=_58897_/A }
C {devices/lab_pin.sym} 19220 -24870 0 1 {name=p18659 lab=_58873_/B }
C {sky130_stdcells/buf_2.sym} 19180 -24870 0 0 {name=X_58806_ }
C {devices/lab_pin.sym} 19120 -24760 0 0 {name=p18660 lab=_77638_/Y }
C {devices/lab_pin.sym} 19120 -24720 0 0 {name=p18661 lab=_77639_/Y }
C {devices/lab_pin.sym} 19240 -24740 0 1 {name=p18662 lab=_77645_/B }
C {sky130_stdcells/and2_4.sym} 19180 -24740 0 0 {name=X_77640_ }
C {devices/lab_pin.sym} 19120 -24620 0 0 {name=p18663 lab=_74850_/Y }
C {devices/lab_pin.sym} 19120 -24580 0 0 {name=p18664 lab=_74852_/B }
C {devices/lab_pin.sym} 19240 -24600 0 1 {name=p18665 lab=_74853_/B }
C {sky130_stdcells/xnor2_4.sym} 19180 -24600 0 0 {name=X_74852_ }
C {devices/lab_pin.sym} 19090 -24470 0 0 {name=p18666 lab=_87225_/CLK }
C {devices/lab_pin.sym} 19090 -24450 0 0 {name=p18667 lab=_45965_/X }
C {devices/lab_pin.sym} 19270 -24470 0 1 {name=p18668 lab=_66577_/B }
C {sky130_stdcells/dfxtp_4.sym} 19180 -24460 0 0 {name=X_86838_ }
C {devices/lab_pin.sym} 19100 -24370 0 0 {name=p18669 lab=_59743_/B }
C {devices/lab_pin.sym} 19100 -24330 0 0 {name=p18670 lab=_59688_/X }
C {devices/lab_pin.sym} 19100 -24290 0 0 {name=p18671 lab=_59783_/Y }
C {devices/lab_pin.sym} 19100 -24250 0 0 {name=p18672 lab=_59763_/X }
C {devices/lab_pin.sym} 19100 -24220 0 0 {name=p18673 lab=_59785_/Y }
C {devices/lab_pin.sym} 19260 -24290 0 1 {name=p18674 lab=_59786_/Y }
C {sky130_stdcells/a41oi_4.sym} 19180 -24290 0 0 {name=X_59786_ }
C {devices/lab_pin.sym} 19120 -24140 0 0 {name=p18675 lab=_45673_/A }
C {devices/lab_pin.sym} 19120 -24100 0 0 {name=p18676 lab=_56997_/X }
C {devices/lab_pin.sym} 19240 -24120 0 1 {name=p18677 lab=_56998_/Y }
C {sky130_stdcells/nor2_4.sym} 19180 -24120 0 0 {name=X_56998_ }
C {devices/lab_pin.sym} 19100 -24010 0 0 {name=p18678 lab=_44695_/Y }
C {devices/lab_pin.sym} 19100 -23970 0 0 {name=p18679 lab=_73728_/X }
C {devices/lab_pin.sym} 19100 -23930 0 0 {name=p18680 lab=_73802_/Y }
C {devices/lab_pin.sym} 19260 -23970 0 1 {name=p18681 lab=_73815_/C }
C {sky130_stdcells/a21o_4.sym} 19180 -23970 0 0 {name=X_73803_ }
C {devices/lab_pin.sym} 19140 -23830 0 0 {name=p18682 lab=_46751_/A }
C {devices/lab_pin.sym} 19220 -23830 0 1 {name=p18683 lab=_46751_/X }
C {sky130_stdcells/buf_2.sym} 19180 -23830 0 0 {name=X_46751_ }
C {devices/lab_pin.sym} 19100 -23740 0 0 {name=p18684 lab=_84804_/Q }
C {devices/lab_pin.sym} 19100 -23700 0 0 {name=p18685 lab=_58725_/X }
C {devices/lab_pin.sym} 19100 -23660 0 0 {name=p18686 lab=_58729_/X }
C {devices/lab_pin.sym} 19100 -23620 0 0 {name=p18687 lab=_58736_/X }
C {devices/lab_pin.sym} 19260 -23680 0 1 {name=p18688 lab=_84804_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 19180 -23680 0 0 {name=X_58737_ }
C {devices/lab_pin.sym} 19100 -23550 0 0 {name=p18689 lab=_77567_/Y }
C {devices/lab_pin.sym} 19100 -23510 0 0 {name=p18690 lab=_77570_/C }
C {devices/lab_pin.sym} 19100 -23470 0 0 {name=p18691 lab=_77570_/A }
C {devices/lab_pin.sym} 19260 -23510 0 1 {name=p18692 lab=_77571_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -23510 0 0 {name=X_77571_ }
C {devices/lab_pin.sym} 19100 -23400 0 0 {name=p18693 lab=_44053_/A }
C {devices/lab_pin.sym} 19100 -23360 0 0 {name=p18694 lab=_43944_/A }
C {devices/lab_pin.sym} 19100 -23320 0 0 {name=p18695 lab=_43945_/Y }
C {devices/lab_pin.sym} 19100 -23280 0 0 {name=p18696 lab=_43962_/X }
C {devices/lab_pin.sym} 19260 -23340 0 1 {name=p18697 lab=_43963_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -23340 0 0 {name=X_43963_ }
C {devices/lab_pin.sym} 19120 -23200 0 0 {name=p18698 lab=_55949_/A }
C {devices/lab_pin.sym} 19120 -23160 0 0 {name=p18699 lab=_55949_/B }
C {devices/lab_pin.sym} 19240 -23180 0 1 {name=p18700 lab=_55949_/X }
C {sky130_stdcells/and2_4.sym} 19180 -23180 0 0 {name=X_55949_ }
C {devices/lab_pin.sym} 19120 -23080 0 0 {name=p18701 lab=_74783_/A }
C {devices/lab_pin.sym} 19120 -23040 0 0 {name=p18702 lab=_74796_/B }
C {devices/lab_pin.sym} 19120 -23000 0 0 {name=p18703 lab=_74796_/C }
C {devices/lab_pin.sym} 19120 -22960 0 0 {name=p18704 lab=_71016_/A }
C {devices/lab_pin.sym} 19240 -23020 0 1 {name=p18705 lab=_74783_/Y }
C {sky130_stdcells/nand4_4.sym} 19180 -23020 0 0 {name=X_74783_ }
C {devices/lab_pin.sym} 19090 -22870 0 0 {name=p18706 lab=_84970_/CLK }
C {devices/lab_pin.sym} 19090 -22850 0 0 {name=p18707 lab=_86769_/D }
C {devices/lab_pin.sym} 19270 -22870 0 1 {name=p18708 lab=_44131_/A }
C {sky130_stdcells/dfxtp_4.sym} 19180 -22860 0 0 {name=X_86769_ }
C {devices/lab_pin.sym} 19100 -22750 0 0 {name=p18709 lab=_71992_/Y }
C {devices/lab_pin.sym} 19100 -22710 0 0 {name=p18710 lab=_71969_/X }
C {devices/lab_pin.sym} 19100 -22670 0 0 {name=p18711 lab=_71994_/Y }
C {devices/lab_pin.sym} 19260 -22710 0 1 {name=p18712 lab=_71995_/Y }
C {sky130_stdcells/a21boi_4.sym} 19180 -22710 0 0 {name=X_71995_ }
C {devices/lab_pin.sym} 19120 -22580 0 0 {name=p18713 lab=_79310_/A }
C {devices/lab_pin.sym} 19120 -22540 0 0 {name=p18714 lab=_79310_/B }
C {devices/lab_pin.sym} 19240 -22560 0 1 {name=p18715 lab=_79311_/B }
C {sky130_stdcells/xor2_4.sym} 19180 -22560 0 0 {name=X_79310_ }
C {devices/lab_pin.sym} 19140 -22430 0 0 {name=p18716 lab=_85069_/Q }
C {devices/lab_pin.sym} 19220 -22430 0 1 {name=p18717 lab=_55186_/B }
C {sky130_stdcells/inv_2.sym} 19180 -22430 0 0 {name=X_45702_ }
C {devices/lab_pin.sym} 19120 -22320 0 0 {name=p18718 lab=_76522_/A }
C {devices/lab_pin.sym} 19120 -22280 0 0 {name=p18719 lab=_76522_/B }
C {devices/lab_pin.sym} 19240 -22300 0 1 {name=p18720 lab=_76522_/Y }
C {sky130_stdcells/nand2_4.sym} 19180 -22300 0 0 {name=X_76522_ }
C {devices/lab_pin.sym} 19100 -22210 0 0 {name=p18721 lab=_42895_/X }
C {devices/lab_pin.sym} 19100 -22170 0 0 {name=p18722 lab=_42896_/X }
C {devices/lab_pin.sym} 19100 -22130 0 0 {name=p18723 lab=_41705_/X }
C {devices/lab_pin.sym} 19100 -22090 0 0 {name=p18724 lab=_67675_/B }
C {devices/lab_pin.sym} 19100 -22050 0 0 {name=p18725 lab=_42905_/X }
C {devices/lab_pin.sym} 19260 -22130 0 1 {name=p18726 lab=_42914_/Y }
C {sky130_stdcells/o32ai_4.sym} 19180 -22130 0 0 {name=X_42914_ }
C {devices/lab_pin.sym} 19140 -21970 0 0 {name=p18727 lab=_49496_/A }
C {devices/lab_pin.sym} 19220 -21970 0 1 {name=p18728 lab=_49470_/X }
C {sky130_stdcells/buf_2.sym} 19180 -21970 0 0 {name=X_49470_ }
C {devices/lab_pin.sym} 19100 -21880 0 0 {name=p18729 lab=_73731_/X }
C {devices/lab_pin.sym} 19100 -21840 0 0 {name=p18730 lab=_86234_/Q }
C {devices/lab_pin.sym} 19100 -21800 0 0 {name=p18731 lab=_73683_/X }
C {devices/lab_pin.sym} 19100 -21760 0 0 {name=p18732 lab=_73733_/X }
C {devices/lab_pin.sym} 19260 -21820 0 1 {name=p18733 lab=_73734_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -21820 0 0 {name=X_73734_ }
C {devices/lab_pin.sym} 19100 -21690 0 0 {name=p18734 lab=_58125_/X }
C {devices/lab_pin.sym} 19100 -21650 0 0 {name=p18735 lab=_85785_/Q }
C {devices/lab_pin.sym} 19100 -21610 0 0 {name=p18736 lab=_58126_/X }
C {devices/lab_pin.sym} 19260 -21650 0 1 {name=p18737 lab=_58668_/X }
C {sky130_stdcells/o21a_4.sym} 19180 -21650 0 0 {name=X_58668_ }
C {devices/lab_pin.sym} 19100 -21530 0 0 {name=p18738 lab=_50738_/B }
C {devices/lab_pin.sym} 19100 -21490 0 0 {name=p18739 lab=_70937_/X }
C {devices/lab_pin.sym} 19100 -21450 0 0 {name=p18740 lab=_70945_/Y }
C {devices/lab_pin.sym} 19260 -21490 0 1 {name=p18741 lab=_70946_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -21490 0 0 {name=X_70946_ }
C {devices/lab_pin.sym} 19120 -21380 0 0 {name=p18742 lab=_46717_/A }
C {devices/lab_pin.sym} 19120 -21340 0 0 {name=p18743 lab=_46682_/B }
C {devices/lab_pin.sym} 19120 -21300 0 0 {name=p18744 lab=_46682_/C }
C {devices/lab_pin.sym} 19120 -21260 0 0 {name=p18745 lab=_50919_/D }
C {devices/lab_pin.sym} 19240 -21320 0 1 {name=p18746 lab=_46682_/X }
C {sky130_stdcells/and4_4.sym} 19180 -21320 0 0 {name=X_46682_ }
C {devices/lab_pin.sym} 19100 -21200 0 0 {name=p18747 lab=_41328_/X }
C {devices/lab_pin.sym} 19100 -21160 0 0 {name=p18748 lab=_43886_/X }
C {devices/lab_pin.sym} 19100 -21120 0 0 {name=p18749 lab=_67527_/B }
C {devices/lab_pin.sym} 19100 -21080 0 0 {name=p18750 lab=_43887_/X }
C {devices/lab_pin.sym} 19260 -21140 0 1 {name=p18751 lab=_43894_/X }
C {sky130_stdcells/a2bb2o_4.sym} 19180 -21140 0 0 {name=X_43894_ }
C {devices/lab_pin.sym} 19140 -20990 0 0 {name=p18752 lab=_48613_/A }
C {devices/lab_pin.sym} 19220 -20990 0 1 {name=p18753 lab=_48469_/A }
C {sky130_stdcells/buf_2.sym} 19180 -20990 0 0 {name=X_48421_ }
C {devices/lab_pin.sym} 19120 -20880 0 0 {name=p18754 lab=_79238_/Y }
C {devices/lab_pin.sym} 19120 -20840 0 0 {name=p18755 lab=_79240_/Y }
C {devices/lab_pin.sym} 19240 -20860 0 1 {name=p18756 lab=_79251_/B }
C {sky130_stdcells/nand2_4.sym} 19180 -20860 0 0 {name=X_79241_ }
C {devices/lab_pin.sym} 19120 -20740 0 0 {name=p18757 lab=_55483_/A }
C {devices/lab_pin.sym} 19120 -20700 0 0 {name=p18758 lab=_45354_/X }
C {devices/lab_pin.sym} 19240 -20720 0 1 {name=p18759 lab=_45633_/Y }
C {sky130_stdcells/nor2_4.sym} 19180 -20720 0 0 {name=X_45633_ }
C {devices/lab_pin.sym} 19120 -20610 0 0 {name=p18760 lab=_57619_/A }
C {devices/lab_pin.sym} 19120 -20570 0 0 {name=p18761 lab=_57619_/B }
C {devices/lab_pin.sym} 19120 -20530 0 0 {name=p18762 lab=_71960_/C }
C {devices/lab_pin.sym} 19240 -20570 0 1 {name=p18763 lab=_57619_/X }
C {sky130_stdcells/and3_4.sym} 19180 -20570 0 0 {name=X_57619_ }
C {devices/lab_pin.sym} 19140 -20430 0 0 {name=p18764 lab=_76453_/A }
C {devices/lab_pin.sym} 19220 -20430 0 1 {name=p18765 lab=_76453_/Y }
C {sky130_stdcells/inv_2.sym} 19180 -20430 0 0 {name=X_76453_ }
C {devices/lab_pin.sym} 19140 -20310 0 0 {name=p18766 lab=_42845_/A }
C {devices/lab_pin.sym} 19220 -20310 0 1 {name=p18767 lab=_87688_/D }
C {sky130_stdcells/inv_2.sym} 19180 -20310 0 0 {name=X_42845_ }
C {devices/lab_pin.sym} 19140 -20190 0 0 {name=p18768 lab=_72829_/A }
C {devices/lab_pin.sym} 19220 -20190 0 1 {name=p18769 lab=_73665_/X }
C {sky130_stdcells/buf_2.sym} 19180 -20190 0 0 {name=X_73665_ }
C {devices/lab_pin.sym} 19100 -20090 0 0 {name=p18770 lab=_50961_/B }
C {devices/lab_pin.sym} 19100 -20050 0 0 {name=p18771 lab=_70855_/A }
C {devices/lab_pin.sym} 19100 -20010 0 0 {name=p18772 lab=_70876_/Y }
C {devices/lab_pin.sym} 19260 -20050 0 1 {name=p18773 lab=_70877_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -20050 0 0 {name=X_70877_ }
C {devices/lab_pin.sym} 19140 -19910 0 0 {name=p18774 lab=_58599_/A }
C {devices/lab_pin.sym} 19220 -19910 0 1 {name=p18775 lab=_58599_/X }
C {sky130_stdcells/buf_2.sym} 19180 -19910 0 0 {name=X_58599_ }
C {devices/lab_pin.sym} 19120 -19820 0 0 {name=p18776 lab=_75404_/A }
C {devices/lab_pin.sym} 19120 -19780 0 0 {name=p18777 lab=_75404_/B }
C {devices/lab_pin.sym} 19120 -19740 0 0 {name=p18778 lab=_75383_/X }
C {devices/lab_pin.sym} 19120 -19700 0 0 {name=p18779 lab=_75386_/B }
C {devices/lab_pin.sym} 19240 -19760 0 1 {name=p18780 lab=_75404_/X }
C {sky130_stdcells/and4_4.sym} 19180 -19760 0 0 {name=X_75404_ }
C {devices/lab_pin.sym} 19120 -19620 0 0 {name=p18781 lab=_48392_/A }
C {devices/lab_pin.sym} 19120 -19580 0 0 {name=p18782 lab=_50389_/B }
C {devices/lab_pin.sym} 19240 -19600 0 1 {name=p18783 lab=_48352_/Y }
C {sky130_stdcells/nand2_4.sym} 19180 -19600 0 0 {name=X_48352_ }
C {devices/lab_pin.sym} 19120 -19500 0 0 {name=p18784 lab=_60630_/A }
C {devices/lab_pin.sym} 19120 -19460 0 0 {name=p18785 lab=_60620_/C }
C {devices/lab_pin.sym} 19120 -19420 0 0 {name=p18786 lab=_60630_/C }
C {devices/lab_pin.sym} 19120 -19380 0 0 {name=p18787 lab=_60620_/B }
C {devices/lab_pin.sym} 19240 -19440 0 1 {name=p18788 lab=_60631_/D }
C {sky130_stdcells/and4_4.sym} 19180 -19440 0 0 {name=X_60630_ }
C {devices/lab_pin.sym} 19100 -19330 0 0 {name=p18789 lab=_60053_/X }
C {devices/lab_pin.sym} 19100 -19290 0 0 {name=p18790 lab=_72614_/X }
C {devices/lab_pin.sym} 19100 -19250 0 0 {name=p18791 lab=_72625_/B }
C {devices/lab_pin.sym} 19100 -19210 0 0 {name=p18792 lab=_72607_/Y }
C {devices/lab_pin.sym} 19100 -19180 0 0 {name=p18793 lab=_72615_/Y }
C {devices/lab_pin.sym} 19260 -19250 0 1 {name=p18794 lab=_72616_/Y }
C {sky130_stdcells/a41oi_4.sym} 19180 -19250 0 0 {name=X_72616_ }
C {devices/lab_pin.sym} 19120 -19100 0 0 {name=p18795 lab=_84787_/Q }
C {devices/lab_pin.sym} 19120 -19060 0 0 {name=p18796 lab=_82723_/D }
C {devices/lab_pin.sym} 19240 -19080 0 1 {name=p18797 lab=_79174_/A }
C {sky130_stdcells/nor2_4.sym} 19180 -19080 0 0 {name=X_79172_ }
C {devices/lab_pin.sym} 19100 -18970 0 0 {name=p18798 lab=_45511_/X }
C {devices/lab_pin.sym} 19100 -18930 0 0 {name=p18799 lab=_61451_/A }
C {devices/lab_pin.sym} 19100 -18890 0 0 {name=p18800 lab=_45530_/X }
C {devices/lab_pin.sym} 19260 -18930 0 1 {name=p18801 lab=_45564_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -18930 0 0 {name=X_45564_ }
C {devices/lab_pin.sym} 19100 -18810 0 0 {name=p18802 lab=_76369_/X }
C {devices/lab_pin.sym} 19100 -18770 0 0 {name=p18803 lab=_76370_/Y }
C {devices/lab_pin.sym} 19100 -18730 0 0 {name=p18804 lab=_76364_/X }
C {devices/lab_pin.sym} 19260 -18770 0 1 {name=p18805 lab=_76384_/Y }
C {sky130_stdcells/a21boi_4.sym} 19180 -18770 0 0 {name=X_76384_ }
C {devices/lab_pin.sym} 19100 -18670 0 0 {name=p18806 lab=_42774_/X }
C {devices/lab_pin.sym} 19100 -18630 0 0 {name=p18807 lab=_42775_/X }
C {devices/lab_pin.sym} 19100 -18590 0 0 {name=p18808 lab=_41321_/X }
C {devices/lab_pin.sym} 19100 -18550 0 0 {name=p18809 lab=_87724_/Q }
C {devices/lab_pin.sym} 19100 -18510 0 0 {name=p18810 lab=_42750_/X }
C {devices/lab_pin.sym} 19260 -18590 0 1 {name=p18811 lab=_42776_/Y }
C {sky130_stdcells/o32ai_4.sym} 19180 -18590 0 0 {name=X_42776_ }
C {devices/lab_pin.sym} 19100 -18460 0 0 {name=p18812 lab=_68415_/Y }
C {devices/lab_pin.sym} 19100 -18420 0 0 {name=p18813 lab=_73250_/X }
C {devices/lab_pin.sym} 19100 -18380 0 0 {name=p18814 lab=_73344_/X }
C {devices/lab_pin.sym} 19100 -18340 0 0 {name=p18815 lab=_73595_/Y }
C {devices/lab_pin.sym} 19260 -18400 0 1 {name=p18816 lab=_73596_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -18400 0 0 {name=X_73596_ }
C {devices/lab_pin.sym} 19120 -18280 0 0 {name=p18817 lab=_47330_/A }
C {devices/lab_pin.sym} 19120 -18240 0 0 {name=p18818 lab=_47311_/B }
C {devices/lab_pin.sym} 19120 -18200 0 0 {name=p18819 lab=_47321_/C }
C {devices/lab_pin.sym} 19120 -18160 0 0 {name=p18820 lab=_52971_/D }
C {devices/lab_pin.sym} 19240 -18220 0 1 {name=p18821 lab=_47303_/X }
C {sky130_stdcells/and4_4.sym} 19180 -18220 0 0 {name=X_47303_ }
C {devices/lab_pin.sym} 19120 -18080 0 0 {name=p18822 lab=_82664_/Q }
C {devices/lab_pin.sym} 19120 -18040 0 0 {name=p18823 lab=_78123_/B }
C {devices/lab_pin.sym} 19240 -18060 0 1 {name=p18824 lab=_78123_/X }
C {sky130_stdcells/xor2_4.sym} 19180 -18060 0 0 {name=X_78123_ }
C {devices/lab_pin.sym} 19140 -17930 0 0 {name=p18825 lab=_44532_/A }
C {devices/lab_pin.sym} 19220 -17930 0 1 {name=p18826 lab=_44516_/A }
C {sky130_stdcells/buf_2.sym} 19180 -17930 0 0 {name=X_44515_ }
C {devices/lab_pin.sym} 19100 -17830 0 0 {name=p18827 lab=_75331_/Y }
C {devices/lab_pin.sym} 19100 -17790 0 0 {name=p18828 lab=_75333_/Y }
C {devices/lab_pin.sym} 19100 -17750 0 0 {name=p18829 lab=_75330_/Y }
C {devices/lab_pin.sym} 19260 -17790 0 1 {name=p18830 lab=_75339_/C }
C {sky130_stdcells/o21ai_4.sym} 19180 -17790 0 0 {name=X_75335_ }
C {devices/lab_pin.sym} 19140 -17650 0 0 {name=p18831 lab=clkbuf_9_241_0_CLK/X }
C {devices/lab_pin.sym} 19220 -17650 0 1 {name=p18832 lab=_86282_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 19180 -17650 0 0 {name=Xclkbuf_10_482_0_CLK }
C {devices/lab_pin.sym} 19140 -17530 0 0 {name=p18833 lab=_41727_/A }
C {devices/lab_pin.sym} 19220 -17530 0 1 {name=p18834 lab=_41727_/X }
C {sky130_stdcells/buf_2.sym} 19180 -17530 0 0 {name=X_41727_ }
C {devices/lab_pin.sym} 19100 -17430 0 0 {name=p18835 lab=_48280_/Y }
C {devices/lab_pin.sym} 19100 -17390 0 0 {name=p18836 lab=_48273_/X }
C {devices/lab_pin.sym} 19100 -17350 0 0 {name=p18837 lab=_48282_/Y }
C {devices/lab_pin.sym} 19260 -17390 0 1 {name=p18838 lab=_86543_/D }
C {sky130_stdcells/a21boi_4.sym} 19180 -17390 0 0 {name=X_48283_ }
C {devices/lab_pin.sym} 19100 -17290 0 0 {name=p18839 lab=_60465_/Y }
C {devices/lab_pin.sym} 19100 -17250 0 0 {name=p18840 lab=_60481_/A }
C {devices/lab_pin.sym} 19100 -17210 0 0 {name=p18841 lab=_60471_/X }
C {devices/lab_pin.sym} 19100 -17170 0 0 {name=p18842 lab=_60557_/Y }
C {devices/lab_pin.sym} 19100 -17140 0 0 {name=p18843 lab=_60560_/Y }
C {devices/lab_pin.sym} 19260 -17210 0 1 {name=p18844 lab=_60561_/Y }
C {sky130_stdcells/a41oi_4.sym} 19180 -17210 0 0 {name=X_60561_ }
C {devices/lab_pin.sym} 19120 -17070 0 0 {name=p18845 lab=_72573_/A }
C {devices/lab_pin.sym} 19120 -17030 0 0 {name=p18846 lab=_72544_/B }
C {devices/lab_pin.sym} 19120 -16990 0 0 {name=p18847 lab=_79456_/B }
C {devices/lab_pin.sym} 19240 -17030 0 1 {name=p18848 lab=_72547_/Y }
C {sky130_stdcells/nor3_4.sym} 19180 -17030 0 0 {name=X_72547_ }
C {devices/lab_pin.sym} 19120 -16900 0 0 {name=p18849 lab=_45495_/A }
C {devices/lab_pin.sym} 19120 -16860 0 0 {name=p18850 lab=_45381_/B }
C {devices/lab_pin.sym} 19240 -16880 0 1 {name=p18851 lab=_45495_/Y }
C {sky130_stdcells/nand2_4.sym} 19180 -16880 0 0 {name=X_45495_ }
C {devices/lab_pin.sym} 19140 -16750 0 0 {name=p18852 lab=_62214_/A }
C {devices/lab_pin.sym} 19220 -16750 0 1 {name=p18853 lab=_62300_/X }
C {sky130_stdcells/buf_2.sym} 19180 -16750 0 0 {name=X_62300_ }
C {devices/lab_pin.sym} 19140 -16630 0 0 {name=p18854 lab=_47140_/A }
C {devices/lab_pin.sym} 19220 -16630 0 1 {name=p18855 lab=_47234_/X }
C {sky130_stdcells/buf_2.sym} 19180 -16630 0 0 {name=X_47234_ }
C {devices/lab_pin.sym} 19120 -16520 0 0 {name=p18856 lab=_60817_/C }
C {devices/lab_pin.sym} 19120 -16480 0 0 {name=p18857 lab=_78054_/B }
C {devices/lab_pin.sym} 19240 -16500 0 1 {name=p18858 lab=_78054_/X }
C {sky130_stdcells/xor2_4.sym} 19180 -16500 0 0 {name=X_78054_ }
C {devices/lab_pin.sym} 19140 -16370 0 0 {name=p18859 lab=_44587_/A }
C {devices/lab_pin.sym} 19220 -16370 0 1 {name=p18860 lab=_44547_/A }
C {sky130_stdcells/buf_2.sym} 19180 -16370 0 0 {name=X_44446_ }
C {devices/lab_pin.sym} 19120 -16270 0 0 {name=p18861 lab=_63272_/A }
C {devices/lab_pin.sym} 19120 -16230 0 0 {name=p18862 lab=_63280_/B }
C {devices/lab_pin.sym} 19120 -16190 0 0 {name=p18863 lab=_63280_/C }
C {devices/lab_pin.sym} 19240 -16230 0 1 {name=p18864 lab=_63280_/Y }
C {sky130_stdcells/nand3_4.sym} 19180 -16230 0 0 {name=X_63280_ }
C {devices/lab_pin.sym} 19120 -16100 0 0 {name=p18865 lab=_80783_/Q }
C {devices/lab_pin.sym} 19120 -16060 0 0 {name=p18866 lab=_81039_/D }
C {devices/lab_pin.sym} 19240 -16080 0 1 {name=p18867 lab=_80751_/D }
C {sky130_stdcells/xor2_4.sym} 19180 -16080 0 0 {name=X_75266_ }
C {devices/lab_pin.sym} 19140 -15950 0 0 {name=p18868 lab=_41658_/A }
C {devices/lab_pin.sym} 19220 -15950 0 1 {name=p18869 lab=_88174_/D }
C {sky130_stdcells/inv_2.sym} 19180 -15950 0 0 {name=X_41658_ }
C {devices/lab_pin.sym} 19100 -15860 0 0 {name=p18870 lab=_79151_/A }
C {devices/lab_pin.sym} 19100 -15820 0 0 {name=p18871 lab=_60246_/X }
C {devices/lab_pin.sym} 19100 -15780 0 0 {name=p18872 lab=_60488_/Y }
C {devices/lab_pin.sym} 19100 -15740 0 0 {name=p18873 lab=_60491_/X }
C {devices/lab_pin.sym} 19260 -15800 0 1 {name=p18874 lab=_60492_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 19180 -15800 0 0 {name=X_60492_ }
C {devices/lab_pin.sym} 19100 -15670 0 0 {name=p18875 lab=_64758_/X }
C {devices/lab_pin.sym} 19100 -15630 0 0 {name=p18876 lab=_85314_/Q }
C {devices/lab_pin.sym} 19100 -15590 0 0 {name=p18877 lab=_57763_/X }
C {devices/lab_pin.sym} 19260 -15630 0 1 {name=p18878 lab=_72478_/X }
C {sky130_stdcells/o21a_4.sym} 19180 -15630 0 0 {name=X_72478_ }
C {devices/lab_pin.sym} 19120 -15500 0 0 {name=p18879 lab=_77013_/A }
C {devices/lab_pin.sym} 19120 -15460 0 0 {name=p18880 lab=_77013_/B }
C {devices/lab_pin.sym} 19240 -15480 0 1 {name=p18881 lab=_77006_/B }
C {sky130_stdcells/xor2_4.sym} 19180 -15480 0 0 {name=X_77005_ }
C {devices/lab_pin.sym} 19140 -15350 0 0 {name=p18882 lab=_59918_/Y }
C {devices/lab_pin.sym} 19220 -15350 0 1 {name=p18883 lab=_62471_/A }
C {sky130_stdcells/buf_2.sym} 19180 -15350 0 0 {name=X_62231_ }
C {devices/lab_pin.sym} 19120 -15240 0 0 {name=p18884 lab=_74237_/A }
C {devices/lab_pin.sym} 19120 -15200 0 0 {name=p18885 lab=_86533_/Q }
C {devices/lab_pin.sym} 19240 -15220 0 1 {name=p18886 lab=_74217_/X }
C {sky130_stdcells/and2_4.sym} 19180 -15220 0 0 {name=X_74217_ }
C {devices/lab_pin.sym} 19100 -15110 0 0 {name=p18887 lab=_40601_/X }
C {devices/lab_pin.sym} 19100 -15070 0 0 {name=p18888 lab=_81148_/Q }
C {devices/lab_pin.sym} 19100 -15030 0 0 {name=p18889 lab=_40608_/X }
C {devices/lab_pin.sym} 19260 -15070 0 1 {name=p18890 lab=_40610_/A }
C {sky130_stdcells/o21a_4.sym} 19180 -15070 0 0 {name=X_40609_ }
C {devices/lab_pin.sym} 19140 -14930 0 0 {name=p18891 lab=_83695_/Q }
C {devices/lab_pin.sym} 19220 -14930 0 1 {name=p18892 lab=_47165_/Y }
C {sky130_stdcells/inv_2.sym} 19180 -14930 0 0 {name=X_47165_ }
C {devices/lab_pin.sym} 19140 -14810 0 0 {name=p18893 lab=_71429_/A }
C {devices/lab_pin.sym} 19220 -14810 0 1 {name=p18894 lab=_71432_/D }
C {sky130_stdcells/buf_2.sym} 19180 -14810 0 0 {name=X_71429_ }
C {devices/lab_pin.sym} 19140 -14690 0 0 {name=p18895 lab=_44363_/X }
C {devices/lab_pin.sym} 19220 -14690 0 1 {name=p18896 lab=_44377_/X }
C {sky130_stdcells/buf_2.sym} 19180 -14690 0 0 {name=X_44377_ }
C {devices/lab_pin.sym} 19120 -14580 0 0 {name=p18897 lab=_75217_/A }
C {devices/lab_pin.sym} 19120 -14540 0 0 {name=p18898 lab=_75196_/Y }
C {devices/lab_pin.sym} 19240 -14560 0 1 {name=p18899 lab=_81034_/D }
C {sky130_stdcells/xnor2_4.sym} 19180 -14560 0 0 {name=X_75197_ }
C {devices/lab_pin.sym} 19140 -14430 0 0 {name=p18900 lab=_41482_/A }
C {devices/lab_pin.sym} 19220 -14430 0 1 {name=p18901 lab=_41624_/B }
C {sky130_stdcells/buf_2.sym} 19180 -14430 0 0 {name=X_41589_ }
C {devices/lab_pin.sym} 19120 -14320 0 0 {name=p18902 lab=_46141_/A }
C {devices/lab_pin.sym} 19120 -14280 0 0 {name=p18903 lab=_80653_/Q }
C {devices/lab_pin.sym} 19240 -14300 0 1 {name=p18904 lab=_46204_/D }
C {sky130_stdcells/nor2_4.sym} 19180 -14300 0 0 {name=X_46116_ }
C {devices/lab_pin.sym} 19140 -14170 0 0 {name=p18905 lab=clkbuf_9_248_0_CLK/X }
C {devices/lab_pin.sym} 19220 -14170 0 1 {name=p18906 lab=_83673_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 19180 -14170 0 0 {name=Xclkbuf_10_497_0_CLK }
C {devices/lab_pin.sym} 19100 -14080 0 0 {name=p18907 lab=_41272_/X }
C {devices/lab_pin.sym} 19100 -14040 0 0 {name=p18908 lab=_43325_/X }
C {devices/lab_pin.sym} 19100 -14000 0 0 {name=p18909 lab=_87478_/Q }
C {devices/lab_pin.sym} 19100 -13960 0 0 {name=p18910 lab=_43326_/X }
C {devices/lab_pin.sym} 19260 -14020 0 1 {name=p18911 lab=_43328_/X }
C {sky130_stdcells/a2bb2o_4.sym} 19180 -14020 0 0 {name=X_43328_ }
C {devices/lab_pin.sym} 19140 -13870 0 0 {name=p18912 lab=_58987_/A }
C {devices/lab_pin.sym} 19220 -13870 0 1 {name=p18913 lab=_62162_/X }
C {sky130_stdcells/buf_2.sym} 19180 -13870 0 0 {name=X_62162_ }
C {devices/lab_pin.sym} 19100 -13770 0 0 {name=p18914 lab=_74141_/Y }
C {devices/lab_pin.sym} 19100 -13730 0 0 {name=p18915 lab=_74142_/Y }
C {devices/lab_pin.sym} 19100 -13690 0 0 {name=p18916 lab=_74147_/X }
C {devices/lab_pin.sym} 19260 -13730 0 1 {name=p18917 lab=_74148_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -13730 0 0 {name=X_74148_ }
C {devices/lab_pin.sym} 19140 -13590 0 0 {name=p18918 lab=_47004_/A }
C {devices/lab_pin.sym} 19220 -13590 0 1 {name=p18919 lab=_47096_/X }
C {sky130_stdcells/buf_2.sym} 19180 -13590 0 0 {name=X_47096_ }
C {devices/lab_pin.sym} 19140 -13470 0 0 {name=p18920 lab=_61066_/Y }
C {devices/lab_pin.sym} 19220 -13470 0 1 {name=p18921 lab=_61205_/A }
C {sky130_stdcells/buf_2.sym} 19180 -13470 0 0 {name=X_61113_ }
C {devices/lab_pin.sym} 19140 -13350 0 0 {name=p18922 lab=_45981_/X }
C {devices/lab_pin.sym} 19220 -13350 0 1 {name=p18923 lab=_46047_/X }
C {sky130_stdcells/buf_2.sym} 19180 -13350 0 0 {name=X_46047_ }
C {devices/lab_pin.sym} 19140 -13230 0 0 {name=p18924 lab=_43259_/A }
C {devices/lab_pin.sym} 19220 -13230 0 1 {name=p18925 lab=_87513_/D }
C {sky130_stdcells/inv_2.sym} 19180 -13230 0 0 {name=X_43259_ }
C {devices/lab_pin.sym} 19100 -13130 0 0 {name=p18926 lab=_80913_/D }
C {devices/lab_pin.sym} 19100 -13090 0 0 {name=p18927 lab=_66850_/X }
C {devices/lab_pin.sym} 19100 -13050 0 0 {name=p18928 lab=_66969_/X }
C {devices/lab_pin.sym} 19260 -13090 0 1 {name=p18929 lab=_84089_/D }
C {sky130_stdcells/a21bo_4.sym} 19180 -13090 0 0 {name=X_66970_ }
C {devices/lab_pin.sym} 19100 -12970 0 0 {name=p18930 lab=_59858_/A }
C {devices/lab_pin.sym} 19100 -12930 0 0 {name=p18931 lab=_61618_/X }
C {devices/lab_pin.sym} 19100 -12890 0 0 {name=p18932 lab=_62092_/X }
C {devices/lab_pin.sym} 19260 -12930 0 1 {name=p18933 lab=_62093_/X }
C {sky130_stdcells/a21o_4.sym} 19180 -12930 0 0 {name=X_62093_ }
C {devices/lab_pin.sym} 19120 -12800 0 0 {name=p18934 lab=_78956_/A }
C {devices/lab_pin.sym} 19120 -12760 0 0 {name=p18935 lab=_78956_/B }
C {devices/lab_pin.sym} 19240 -12780 0 1 {name=p18936 lab=_78957_/B }
C {sky130_stdcells/nand2_4.sym} 19180 -12780 0 0 {name=X_78956_ }
C {devices/lab_pin.sym} 19120 -12660 0 0 {name=p18937 lab=_74079_/A }
C {devices/lab_pin.sym} 19120 -12620 0 0 {name=p18938 lab=_74078_/X }
C {devices/lab_pin.sym} 19240 -12640 0 1 {name=p18939 lab=_74079_/Y }
C {sky130_stdcells/nand2_4.sym} 19180 -12640 0 0 {name=X_74079_ }
C {devices/lab_pin.sym} 19120 -12520 0 0 {name=p18940 lab=_44263_/X }
C {devices/lab_pin.sym} 19120 -12480 0 0 {name=p18941 lab=_65921_/B }
C {devices/lab_pin.sym} 19240 -12500 0 1 {name=p18942 lab=_65921_/X }
C {sky130_stdcells/and2_4.sym} 19180 -12500 0 0 {name=X_65921_ }
C {devices/lab_pin.sym} 19100 -12390 0 0 {name=p18943 lab=_60993_/B }
C {devices/lab_pin.sym} 19100 -12350 0 0 {name=p18944 lab=_60954_/X }
C {devices/lab_pin.sym} 19100 -12310 0 0 {name=p18945 lab=_60908_/A }
C {devices/lab_pin.sym} 19260 -12350 0 1 {name=p18946 lab=_61044_/X }
C {sky130_stdcells/o21a_4.sym} 19180 -12350 0 0 {name=X_61044_ }
C {devices/lab_pin.sym} 19120 -12220 0 0 {name=p18947 lab=_82246_/Q }
C {devices/lab_pin.sym} 19120 -12180 0 0 {name=p18948 lab=_81958_/Q }
C {devices/lab_pin.sym} 19240 -12200 0 1 {name=p18949 lab=_77907_/Y }
C {sky130_stdcells/xnor2_4.sym} 19180 -12200 0 0 {name=X_77907_ }
C {devices/lab_pin.sym} 19140 -12070 0 0 {name=p18950 lab=clkbuf_9_210_0_CLK/X }
C {devices/lab_pin.sym} 19220 -12070 0 1 {name=p18951 lab=_83508_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 19180 -12070 0 0 {name=Xclkbuf_10_420_0_CLK }
C {devices/lab_pin.sym} 19100 -11970 0 0 {name=p18952 lab=_78880_/Y }
C {devices/lab_pin.sym} 19100 -11930 0 0 {name=p18953 lab=_78881_/A }
C {devices/lab_pin.sym} 19100 -11890 0 0 {name=p18954 lab=_78886_/Y }
C {devices/lab_pin.sym} 19260 -11930 0 1 {name=p18955 lab=_78888_/B }
C {sky130_stdcells/a21oi_4.sym} 19180 -11930 0 0 {name=X_78887_ }
C {devices/lab_pin.sym} 19140 -11790 0 0 {name=p18956 lab=_49861_/A }
C {devices/lab_pin.sym} 19220 -11790 0 1 {name=p18957 lab=_49830_/B }
C {sky130_stdcells/buf_2.sym} 19180 -11790 0 0 {name=X_49806_ }
C {devices/lab_pin.sym} 19140 -11670 0 0 {name=p18958 lab=_68640_/A }
C {devices/lab_pin.sym} 19220 -11670 0 1 {name=p18959 lab=_68640_/X }
C {sky130_stdcells/buf_2.sym} 19180 -11670 0 0 {name=X_68640_ }
C {devices/lab_pin.sym} 19100 -11580 0 0 {name=p18960 lab=_65811_/X }
C {devices/lab_pin.sym} 19100 -11540 0 0 {name=p18961 lab=_83053_/Q }
C {devices/lab_pin.sym} 19100 -11500 0 0 {name=p18962 lab=_65768_/X }
C {devices/lab_pin.sym} 19100 -11460 0 0 {name=p18963 lab=_65851_/X }
C {devices/lab_pin.sym} 19260 -11520 0 1 {name=p18964 lab=_65852_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -11520 0 0 {name=X_65852_ }
C {devices/lab_pin.sym} 19140 -11370 0 0 {name=p18965 lab=clkbuf_4_12_1_CLK/A }
C {devices/lab_pin.sym} 19220 -11370 0 1 {name=p18966 lab=clkbuf_4_12_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 19180 -11370 0 0 {name=Xclkbuf_4_12_1_CLK }
C {devices/lab_pin.sym} 19140 -11250 0 0 {name=p18967 lab=_77814_/Y }
C {devices/lab_pin.sym} 19220 -11250 0 1 {name=p18968 lab=_77838_/Y }
C {sky130_stdcells/inv_2.sym} 19180 -11250 0 0 {name=X_77838_ }
C {devices/lab_pin.sym} 19140 -11130 0 0 {name=p18969 lab=_47840_/A }
C {devices/lab_pin.sym} 19220 -11130 0 1 {name=p18970 lab=_47998_/X }
C {sky130_stdcells/buf_2.sym} 19180 -11130 0 0 {name=X_47998_ }
C {devices/lab_pin.sym} 19140 -11010 0 0 {name=p18971 lab=_64803_/A }
C {devices/lab_pin.sym} 19220 -11010 0 1 {name=p18972 lab=_64804_/A }
C {sky130_stdcells/buf_2.sym} 19180 -11010 0 0 {name=X_64803_ }
C {devices/lab_pin.sym} 19100 -10910 0 0 {name=p18973 lab=_86332_/Q }
C {devices/lab_pin.sym} 19100 -10870 0 0 {name=p18974 lab=_49715_/X }
C {devices/lab_pin.sym} 19100 -10830 0 0 {name=p18975 lab=_49736_/Y }
C {devices/lab_pin.sym} 19260 -10870 0 1 {name=p18976 lab=_49737_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -10870 0 0 {name=X_49737_ }
C {devices/lab_pin.sym} 19140 -10730 0 0 {name=p18977 lab=_69797_/A }
C {devices/lab_pin.sym} 19220 -10730 0 1 {name=p18978 lab=_68571_/X }
C {sky130_stdcells/buf_2.sym} 19180 -10730 0 0 {name=X_68571_ }
C {devices/lab_pin.sym} 19100 -10630 0 0 {name=p18979 lab=_59030_/A }
C {devices/lab_pin.sym} 19100 -10590 0 0 {name=p18980 lab=_46908_/X }
C {devices/lab_pin.sym} 19100 -10550 0 0 {name=p18981 lab=_46948_/Y }
C {devices/lab_pin.sym} 19260 -10590 0 1 {name=p18982 lab=_46949_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -10590 0 0 {name=X_46949_ }
C {devices/lab_pin.sym} 19120 -10460 0 0 {name=p18983 lab=_65812_/A }
C {devices/lab_pin.sym} 19120 -10420 0 0 {name=p18984 lab=_86506_/Q }
C {devices/lab_pin.sym} 19240 -10440 0 1 {name=p18985 lab=_65783_/X }
C {sky130_stdcells/and2_4.sym} 19180 -10440 0 0 {name=X_65783_ }
C {devices/lab_pin.sym} 19120 -10320 0 0 {name=p18986 lab=_82263_/Q }
C {devices/lab_pin.sym} 19120 -10280 0 0 {name=p18987 lab=_81975_/Q }
C {devices/lab_pin.sym} 19240 -10300 0 1 {name=p18988 lab=_81927_/D }
C {sky130_stdcells/xor2_4.sym} 19180 -10300 0 0 {name=X_77769_ }
C {devices/lab_pin.sym} 19120 -10190 0 0 {name=p18989 lab=_63285_/A }
C {devices/lab_pin.sym} 19120 -10150 0 0 {name=p18990 lab=_63285_/B }
C {devices/lab_pin.sym} 19120 -10110 0 0 {name=p18991 lab=_62995_/C }
C {devices/lab_pin.sym} 19240 -10150 0 1 {name=p18992 lab=_62995_/Y }
C {sky130_stdcells/nor3_4.sym} 19180 -10150 0 0 {name=X_62995_ }
C {devices/lab_pin.sym} 19140 -10010 0 0 {name=p18993 lab=_66898_/X }
C {devices/lab_pin.sym} 19220 -10010 0 1 {name=p18994 lab=_67522_/X }
C {sky130_stdcells/buf_2.sym} 19180 -10010 0 0 {name=X_67522_ }
C {devices/lab_pin.sym} 19100 -9910 0 0 {name=p18995 lab=_79505_/Y }
C {devices/lab_pin.sym} 19100 -9870 0 0 {name=p18996 lab=_79488_/Y }
C {devices/lab_pin.sym} 19100 -9830 0 0 {name=p18997 lab=_79507_/X }
C {devices/lab_pin.sym} 19260 -9870 0 1 {name=p18998 lab=_79510_/A }
C {sky130_stdcells/o21ai_4.sym} 19180 -9870 0 0 {name=X_79508_ }
C {devices/lab_pin.sym} 19140 -9730 0 0 {name=p18999 lab=clkbuf_9_217_0_CLK/X }
C {devices/lab_pin.sym} 19220 -9730 0 1 {name=p19000 lab=_84223_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 19180 -9730 0 0 {name=Xclkbuf_10_435_0_CLK }
C {devices/lab_pin.sym} 19120 -9620 0 0 {name=p19001 lab=_64684_/A }
C {devices/lab_pin.sym} 19120 -9580 0 0 {name=p19002 lab=_86461_/Q }
C {devices/lab_pin.sym} 19240 -9600 0 1 {name=p19003 lab=_64734_/X }
C {sky130_stdcells/and2_4.sym} 19180 -9600 0 0 {name=X_64734_ }
C {devices/lab_pin.sym} 19140 -9470 0 0 {name=p19004 lab=_61787_/X }
C {devices/lab_pin.sym} 19220 -9470 0 1 {name=p19005 lab=_61947_/D }
C {sky130_stdcells/buf_2.sym} 19180 -9470 0 0 {name=X_61946_ }
C {devices/lab_pin.sym} 19140 -9350 0 0 {name=p19006 lab=_49641_/A }
C {devices/lab_pin.sym} 19220 -9350 0 1 {name=p19007 lab=_49669_/B }
C {sky130_stdcells/buf_2.sym} 19180 -9350 0 0 {name=X_49668_ }
C {devices/lab_pin.sym} 19090 -9230 0 0 {name=p19008 lab=_80849_/CLK }
C {devices/lab_pin.sym} 19090 -9210 0 0 {name=p19009 lab=_80780_/D }
C {devices/lab_pin.sym} 19270 -9230 0 1 {name=p19010 lab=_80780_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -9220 0 0 {name=X_80780_ }
C {devices/lab_pin.sym} 19120 -9100 0 0 {name=p19011 lab=_48618_/Y }
C {devices/lab_pin.sym} 19120 -9060 0 0 {name=p19012 lab=_48565_/B }
C {devices/lab_pin.sym} 19240 -9080 0 1 {name=p19013 lab=_48619_/Y }
C {sky130_stdcells/nand2_4.sym} 19180 -9080 0 0 {name=X_48619_ }
C {devices/lab_pin.sym} 19120 -8960 0 0 {name=p19014 lab=_67381_/A }
C {devices/lab_pin.sym} 19120 -8920 0 0 {name=p19015 lab=_67453_/B }
C {devices/lab_pin.sym} 19240 -8940 0 1 {name=p19016 lab=_67453_/X }
C {sky130_stdcells/and2_4.sym} 19180 -8940 0 0 {name=X_67453_ }
C {devices/lab_pin.sym} 19120 -8820 0 0 {name=p19017 lab=_79439_/A }
C {devices/lab_pin.sym} 19120 -8780 0 0 {name=p19018 lab=_79429_/X }
C {devices/lab_pin.sym} 19240 -8800 0 1 {name=p19019 lab=_79439_/Y }
C {sky130_stdcells/nand2_4.sym} 19180 -8800 0 0 {name=X_79439_ }
C {devices/lab_pin.sym} 19140 -8670 0 0 {name=p19020 lab=_64665_/A }
C {devices/lab_pin.sym} 19220 -8670 0 1 {name=p19021 lab=_64666_/A }
C {sky130_stdcells/buf_2.sym} 19180 -8670 0 0 {name=X_64665_ }
C {devices/lab_pin.sym} 19100 -8570 0 0 {name=p19022 lab=_49595_/Y }
C {devices/lab_pin.sym} 19100 -8530 0 0 {name=p19023 lab=_49596_/X }
C {devices/lab_pin.sym} 19100 -8490 0 0 {name=p19024 lab=_49598_/X }
C {devices/lab_pin.sym} 19260 -8530 0 1 {name=p19025 lab=_86358_/D }
C {sky130_stdcells/a21oi_4.sym} 19180 -8530 0 0 {name=X_49599_ }
C {devices/lab_pin.sym} 19140 -8390 0 0 {name=p19026 lab=_61777_/A }
C {devices/lab_pin.sym} 19220 -8390 0 1 {name=p19027 lab=_61878_/C }
C {sky130_stdcells/buf_2.sym} 19180 -8390 0 0 {name=X_61877_ }
C {devices/lab_pin.sym} 19120 -8290 0 0 {name=p19028 lab=_64822_/X }
C {devices/lab_pin.sym} 19120 -8250 0 0 {name=p19029 lab=_66417_/B }
C {devices/lab_pin.sym} 19120 -8210 0 0 {name=p19030 lab=_64824_/X }
C {devices/lab_pin.sym} 19240 -8250 0 1 {name=p19031 lab=_66404_/Y }
C {sky130_stdcells/nand3_4.sym} 19180 -8250 0 0 {name=X_66404_ }
C {devices/lab_pin.sym} 19120 -8140 0 0 {name=p19032 lab=_51629_/X }
C {devices/lab_pin.sym} 19120 -8100 0 0 {name=p19033 lab=_51619_/B }
C {devices/lab_pin.sym} 19120 -8060 0 0 {name=p19034 lab=_51608_/X }
C {devices/lab_pin.sym} 19120 -8020 0 0 {name=p19035 lab=_53155_/D }
C {devices/lab_pin.sym} 19240 -8080 0 1 {name=p19036 lab=_51630_/X }
C {sky130_stdcells/and4_4.sym} 19180 -8080 0 0 {name=X_51630_ }
C {devices/lab_pin.sym} 19100 -7950 0 0 {name=p19037 lab=_63614_/Y }
C {devices/lab_pin.sym} 19100 -7910 0 0 {name=p19038 lab=_63578_/X }
C {devices/lab_pin.sym} 19100 -7870 0 0 {name=p19039 lab=_63615_/Y }
C {devices/lab_pin.sym} 19260 -7910 0 1 {name=p19040 lab=_63616_/Y }
C {sky130_stdcells/a21oi_4.sym} 19180 -7910 0 0 {name=X_63616_ }
C {devices/lab_pin.sym} 19090 -7770 0 0 {name=p19041 lab=_82822_/CLK }
C {devices/lab_pin.sym} 19090 -7750 0 0 {name=p19042 lab=_79142_/X }
C {devices/lab_pin.sym} 19270 -7770 0 1 {name=p19043 lab=_82450_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -7760 0 0 {name=X_82450_ }
C {devices/lab_pin.sym} 19140 -7630 0 0 {name=p19044 lab=_64738_/A }
C {devices/lab_pin.sym} 19220 -7630 0 1 {name=p19045 lab=_72592_/A }
C {sky130_stdcells/buf_2.sym} 19180 -7630 0 0 {name=X_60828_ }
C {devices/lab_pin.sym} 19100 -7530 0 0 {name=p19046 lab=_67379_/X }
C {devices/lab_pin.sym} 19100 -7490 0 0 {name=p19047 lab=_67382_/X }
C {devices/lab_pin.sym} 19100 -7450 0 0 {name=p19048 lab=_67383_/X }
C {devices/lab_pin.sym} 19260 -7490 0 1 {name=p19049 lab=_67387_/A }
C {sky130_stdcells/a21o_4.sym} 19180 -7490 0 0 {name=X_67384_ }
C {devices/lab_pin.sym} 19140 -7350 0 0 {name=p19050 lab=_64731_/A }
C {devices/lab_pin.sym} 19220 -7350 0 1 {name=p19051 lab=_64683_/A }
C {sky130_stdcells/buf_2.sym} 19180 -7350 0 0 {name=X_64596_ }
C {devices/lab_pin.sym} 19090 -7230 0 0 {name=p19052 lab=_81351_/CLK }
C {devices/lab_pin.sym} 19090 -7210 0 0 {name=p19053 lab=_83937_/Q }
C {devices/lab_pin.sym} 19270 -7230 0 1 {name=p19054 lab=_76707_/B }
C {sky130_stdcells/dfxtp_4.sym} 19180 -7220 0 0 {name=X_81401_ }
C {devices/lab_pin.sym} 19100 -7120 0 0 {name=p19055 lab=_87988_/Q }
C {devices/lab_pin.sym} 19100 -7080 0 0 {name=p19056 lab=_69121_/X }
C {devices/lab_pin.sym} 19100 -7040 0 0 {name=p19057 lab=_69051_/X }
C {devices/lab_pin.sym} 19100 -7000 0 0 {name=p19058 lab=_69122_/X }
C {devices/lab_pin.sym} 19260 -7060 0 1 {name=p19059 lab=_69123_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -7060 0 0 {name=X_69123_ }
C {devices/lab_pin.sym} 19100 -6940 0 0 {name=p19060 lab=_65300_/X }
C {devices/lab_pin.sym} 19100 -6900 0 0 {name=p19061 lab=_86211_/Q }
C {devices/lab_pin.sym} 19100 -6860 0 0 {name=p19062 lab=_64692_/X }
C {devices/lab_pin.sym} 19100 -6820 0 0 {name=p19063 lab=_66334_/X }
C {devices/lab_pin.sym} 19260 -6880 0 1 {name=p19064 lab=_66335_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -6880 0 0 {name=X_66335_ }
C {devices/lab_pin.sym} 19120 -6740 0 0 {name=p19065 lab=_51545_/A }
C {devices/lab_pin.sym} 19120 -6700 0 0 {name=p19066 lab=_53086_/B }
C {devices/lab_pin.sym} 19240 -6720 0 1 {name=p19067 lab=_51561_/Y }
C {sky130_stdcells/nand2_4.sym} 19180 -6720 0 0 {name=X_51561_ }
C {devices/lab_pin.sym} 19090 -6590 0 0 {name=p19068 lab=_82381_/CLK }
C {devices/lab_pin.sym} 19090 -6570 0 0 {name=p19069 lab=_82189_/Q }
C {devices/lab_pin.sym} 19270 -6590 0 1 {name=p19070 lab=_47111_/A }
C {sky130_stdcells/dfxtp_4.sym} 19180 -6580 0 0 {name=X_82381_ }
C {devices/lab_pin.sym} 19100 -6480 0 0 {name=p19071 lab=_58562_/A }
C {devices/lab_pin.sym} 19100 -6440 0 0 {name=p19072 lab=_63497_/X }
C {devices/lab_pin.sym} 19100 -6400 0 0 {name=p19073 lab=_61513_/A }
C {devices/lab_pin.sym} 19100 -6360 0 0 {name=p19074 lab=_63498_/X }
C {devices/lab_pin.sym} 19260 -6420 0 1 {name=p19075 lab=_63547_/X }
C {sky130_stdcells/a2bb2o_4.sym} 19180 -6420 0 0 {name=X_63547_ }
C {devices/lab_pin.sym} 19100 -6310 0 0 {name=p19076 lab=_63389_/D }
C {devices/lab_pin.sym} 19100 -6270 0 0 {name=p19077 lab=_60804_/B }
C {devices/lab_pin.sym} 19100 -6230 0 0 {name=p19078 lab=_59512_/X }
C {devices/lab_pin.sym} 19100 -6190 0 0 {name=p19079 lab=_60758_/X }
C {devices/lab_pin.sym} 19100 -6150 0 0 {name=p19080 lab=_60690_/X }
C {devices/lab_pin.sym} 19260 -6230 0 1 {name=p19081 lab=_60759_/Y }
C {sky130_stdcells/a2111oi_4.sym} 19180 -6230 0 0 {name=X_60759_ }
C {devices/lab_pin.sym} 19140 -6070 0 0 {name=p19082 lab=_51822_/A }
C {devices/lab_pin.sym} 19220 -6070 0 1 {name=p19083 lab=_53355_/A }
C {sky130_stdcells/buf_2.sym} 19180 -6070 0 0 {name=X_53300_ }
C {devices/lab_pin.sym} 19090 -5950 0 0 {name=p19084 lab=_81019_/CLK }
C {devices/lab_pin.sym} 19090 -5930 0 0 {name=p19085 lab=_84120_/D }
C {devices/lab_pin.sym} 19270 -5950 0 1 {name=p19086 lab=_84120_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -5940 0 0 {name=X_84120_ }
C {devices/lab_pin.sym} 19100 -5830 0 0 {name=p19087 lab=_50509_/Y }
C {devices/lab_pin.sym} 19100 -5790 0 0 {name=p19088 lab=_50491_/X }
C {devices/lab_pin.sym} 19100 -5750 0 0 {name=p19089 lab=_50511_/X }
C {devices/lab_pin.sym} 19260 -5790 0 1 {name=p19090 lab=_86187_/D }
C {sky130_stdcells/a21oi_4.sym} 19180 -5790 0 0 {name=X_50512_ }
C {devices/lab_pin.sym} 19090 -5650 0 0 {name=p19091 lab=_81755_/CLK }
C {devices/lab_pin.sym} 19090 -5630 0 0 {name=p19092 lab=_76424_/X }
C {devices/lab_pin.sym} 19270 -5650 0 1 {name=p19093 lab=_81708_/D }
C {sky130_stdcells/dfxtp_4.sym} 19180 -5640 0 0 {name=X_81332_ }
C {devices/lab_pin.sym} 19100 -5540 0 0 {name=p19094 lab=_74204_/A }
C {devices/lab_pin.sym} 19100 -5500 0 0 {name=p19095 lab=_69007_/X }
C {devices/lab_pin.sym} 19100 -5460 0 0 {name=p19096 lab=_69051_/X }
C {devices/lab_pin.sym} 19100 -5420 0 0 {name=p19097 lab=_69053_/Y }
C {devices/lab_pin.sym} 19260 -5480 0 1 {name=p19098 lab=_69054_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -5480 0 0 {name=X_69054_ }
C {devices/lab_pin.sym} 19100 -5350 0 0 {name=p19099 lab=_54278_/Y }
C {devices/lab_pin.sym} 19100 -5310 0 0 {name=p19100 lab=_54051_/X }
C {devices/lab_pin.sym} 19100 -5270 0 0 {name=p19101 lab=_54279_/X }
C {devices/lab_pin.sym} 19260 -5310 0 1 {name=p19102 lab=_54280_/Y }
C {sky130_stdcells/a21oi_4.sym} 19180 -5310 0 0 {name=X_54280_ }
C {devices/lab_pin.sym} 19140 -5170 0 0 {name=p19103 lab=_65484_/A }
C {devices/lab_pin.sym} 19220 -5170 0 1 {name=p19104 lab=_66266_/X }
C {sky130_stdcells/buf_2.sym} 19180 -5170 0 0 {name=X_66266_ }
C {devices/lab_pin.sym} 19100 -5070 0 0 {name=p19105 lab=_86000_/Q }
C {devices/lab_pin.sym} 19100 -5030 0 0 {name=p19106 lab=_51485_/X }
C {devices/lab_pin.sym} 19100 -4990 0 0 {name=p19107 lab=_51491_/Y }
C {devices/lab_pin.sym} 19260 -5030 0 1 {name=p19108 lab=_51492_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -5030 0 0 {name=X_51492_ }
C {devices/lab_pin.sym} 19140 -4890 0 0 {name=p19109 lab=_63478_/A }
C {devices/lab_pin.sym} 19220 -4890 0 1 {name=p19110 lab=_63491_/B }
C {sky130_stdcells/buf_2.sym} 19180 -4890 0 0 {name=X_63478_ }
C {devices/lab_pin.sym} 19120 -4780 0 0 {name=p19111 lab=_68002_/X }
C {devices/lab_pin.sym} 19120 -4740 0 0 {name=p19112 lab=_68004_/X }
C {devices/lab_pin.sym} 19240 -4760 0 1 {name=p19113 lab=_68005_/Y }
C {sky130_stdcells/nand2_4.sym} 19180 -4760 0 0 {name=X_68005_ }
C {devices/lab_pin.sym} 19100 -4650 0 0 {name=p19114 lab=_53228_/Y }
C {devices/lab_pin.sym} 19100 -4610 0 0 {name=p19115 lab=_53215_/X }
C {devices/lab_pin.sym} 19100 -4570 0 0 {name=p19116 lab=_53230_/X }
C {devices/lab_pin.sym} 19260 -4610 0 1 {name=p19117 lab=_53231_/Y }
C {sky130_stdcells/a21oi_4.sym} 19180 -4610 0 0 {name=X_53231_ }
C {devices/lab_pin.sym} 19100 -4500 0 0 {name=p19118 lab=_65178_/X }
C {devices/lab_pin.sym} 19100 -4460 0 0 {name=p19119 lab=_86730_/Q }
C {devices/lab_pin.sym} 19100 -4420 0 0 {name=p19120 lab=_65108_/X }
C {devices/lab_pin.sym} 19100 -4380 0 0 {name=p19121 lab=_65216_/X }
C {devices/lab_pin.sym} 19260 -4440 0 1 {name=p19122 lab=_65217_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -4440 0 0 {name=X_65217_ }
C {devices/lab_pin.sym} 19090 -4290 0 0 {name=p19123 lab=_84049_/CLK }
C {devices/lab_pin.sym} 19090 -4270 0 0 {name=p19124 lab=_84051_/D }
C {devices/lab_pin.sym} 19270 -4290 0 1 {name=p19125 lab=_81483_/D }
C {sky130_stdcells/dfxtp_4.sym} 19180 -4280 0 0 {name=X_84051_ }
C {devices/lab_pin.sym} 19120 -4170 0 0 {name=p19126 lab=_50443_/A }
C {devices/lab_pin.sym} 19120 -4130 0 0 {name=p19127 lab=_50456_/B }
C {devices/lab_pin.sym} 19120 -4090 0 0 {name=p19128 lab=_50462_/C }
C {devices/lab_pin.sym} 19240 -4130 0 1 {name=p19129 lab=_50443_/X }
C {sky130_stdcells/and3_4.sym} 19180 -4130 0 0 {name=X_50443_ }
C {devices/lab_pin.sym} 19120 -4020 0 0 {name=p19130 lab=_62415_/X }
C {devices/lab_pin.sym} 19120 -3980 0 0 {name=p19131 lab=_57683_/X }
C {devices/lab_pin.sym} 19120 -3940 0 0 {name=p19132 lab=_62565_/C }
C {devices/lab_pin.sym} 19120 -3900 0 0 {name=p19133 lab=_62608_/D }
C {devices/lab_pin.sym} 19240 -3960 0 1 {name=p19134 lab=_62429_/X }
C {sky130_stdcells/and4_4.sym} 19180 -3960 0 0 {name=X_62429_ }
C {devices/lab_pin.sym} 19090 -3810 0 0 {name=p19135 lab=_81296_/CLK }
C {devices/lab_pin.sym} 19090 -3790 0 0 {name=p19136 lab=_81295_/Q }
C {devices/lab_pin.sym} 19270 -3810 0 1 {name=p19137 lab=_76332_/A }
C {sky130_stdcells/dfxtp_4.sym} 19180 -3800 0 0 {name=X_81263_ }
C {devices/lab_pin.sym} 19100 -3700 0 0 {name=p19138 lab=_64598_/X }
C {devices/lab_pin.sym} 19100 -3660 0 0 {name=p19139 lab=_86221_/Q }
C {devices/lab_pin.sym} 19100 -3620 0 0 {name=p19140 lab=_65761_/X }
C {devices/lab_pin.sym} 19100 -3580 0 0 {name=p19141 lab=_66196_/X }
C {devices/lab_pin.sym} 19260 -3640 0 1 {name=p19142 lab=_66197_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -3640 0 0 {name=X_66197_ }
C {devices/lab_pin.sym} 19090 -3490 0 0 {name=p19143 lab=_82998_/CLK }
C {devices/lab_pin.sym} 19090 -3470 0 0 {name=p19144 lab=_83002_/D }
C {devices/lab_pin.sym} 19270 -3490 0 1 {name=p19145 lab=_83002_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -3480 0 0 {name=X_83002_ }
C {devices/lab_pin.sym} 19120 -3360 0 0 {name=p19146 lab=_84950_/Q }
C {devices/lab_pin.sym} 19120 -3320 0 0 {name=p19147 lab=_65481_/C }
C {devices/lab_pin.sym} 19240 -3340 0 1 {name=p19148 lab=_80216_/A }
C {sky130_stdcells/xor2_4.sym} 19180 -3340 0 0 {name=X_80214_ }
C {devices/lab_pin.sym} 19100 -3230 0 0 {name=p19149 lab=_85685_/Q }
C {devices/lab_pin.sym} 19100 -3190 0 0 {name=p19150 lab=_53146_/X }
C {devices/lab_pin.sym} 19100 -3150 0 0 {name=p19151 lab=_53161_/Y }
C {devices/lab_pin.sym} 19260 -3190 0 1 {name=p19152 lab=_53162_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -3190 0 0 {name=X_53162_ }
C {devices/lab_pin.sym} 19100 -3080 0 0 {name=p19153 lab=_65118_/X }
C {devices/lab_pin.sym} 19100 -3040 0 0 {name=p19154 lab=_85516_/Q }
C {devices/lab_pin.sym} 19100 -3000 0 0 {name=p19155 lab=_65146_/X }
C {devices/lab_pin.sym} 19100 -2960 0 0 {name=p19156 lab=_65147_/X }
C {devices/lab_pin.sym} 19260 -3020 0 1 {name=p19157 lab=_65148_/X }
C {sky130_stdcells/a211o_4.sym} 19180 -3020 0 0 {name=X_65148_ }
C {devices/lab_pin.sym} 19120 -2880 0 0 {name=p19158 lab=_50383_/A }
C {devices/lab_pin.sym} 19120 -2840 0 0 {name=p19159 lab=_48335_/B }
C {devices/lab_pin.sym} 19240 -2860 0 1 {name=p19160 lab=_50374_/Y }
C {sky130_stdcells/nand2_4.sym} 19180 -2860 0 0 {name=X_50374_ }
C {devices/lab_pin.sym} 19090 -2730 0 0 {name=p19161 lab=_84115_/CLK }
C {devices/lab_pin.sym} 19090 -2710 0 0 {name=p19162 lab=_81194_/D }
C {devices/lab_pin.sym} 19270 -2730 0 1 {name=p19163 lab=_49119_/A }
C {sky130_stdcells/dfxtp_4.sym} 19180 -2720 0 0 {name=X_81194_ }
C {devices/lab_pin.sym} 19120 -2610 0 0 {name=p19164 lab=_53636_/A }
C {devices/lab_pin.sym} 19120 -2570 0 0 {name=p19165 lab=_52135_/B }
C {devices/lab_pin.sym} 19120 -2530 0 0 {name=p19166 lab=_52097_/X }
C {devices/lab_pin.sym} 19240 -2570 0 1 {name=p19167 lab=_52113_/X }
C {sky130_stdcells/and3_4.sym} 19180 -2570 0 0 {name=X_52113_ }
C {devices/lab_pin.sym} 19090 -2430 0 0 {name=p19168 lab=_87553_/CLK }
C {devices/lab_pin.sym} 19090 -2410 0 0 {name=p19169 lab=_42588_/Y }
C {devices/lab_pin.sym} 19270 -2430 0 1 {name=p19170 lab=_69790_/A }
C {sky130_stdcells/dfxtp_4.sym} 19180 -2420 0 0 {name=X_87810_ }
C {devices/lab_pin.sym} 19120 -2300 0 0 {name=p19171 lab=_80143_/X }
C {devices/lab_pin.sym} 19120 -2260 0 0 {name=p19172 lab=_80144_/X }
C {devices/lab_pin.sym} 19240 -2280 0 1 {name=p19173 lab=_80145_/Y }
C {sky130_stdcells/xnor2_4.sym} 19180 -2280 0 0 {name=X_80145_ }
C {devices/lab_pin.sym} 19140 -2150 0 0 {name=p19174 lab=_53172_/A }
C {devices/lab_pin.sym} 19220 -2150 0 1 {name=p19175 lab=_53093_/X }
C {sky130_stdcells/buf_2.sym} 19180 -2150 0 0 {name=X_53093_ }
C {devices/lab_pin.sym} 19100 -2060 0 0 {name=p19176 lab=_84936_/Q }
C {devices/lab_pin.sym} 19100 -2020 0 0 {name=p19177 lab=_57896_/X }
C {devices/lab_pin.sym} 19100 -1980 0 0 {name=p19178 lab=_57961_/X }
C {devices/lab_pin.sym} 19100 -1940 0 0 {name=p19179 lab=_57969_/X }
C {devices/lab_pin.sym} 19260 -2000 0 1 {name=p19180 lab=_57970_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 19180 -2000 0 0 {name=X_57970_ }
C {devices/lab_pin.sym} 19120 -1860 0 0 {name=p19181 lab=_65381_/A }
C {devices/lab_pin.sym} 19120 -1820 0 0 {name=p19182 lab=_86415_/Q }
C {devices/lab_pin.sym} 19240 -1840 0 1 {name=p19183 lab=_65079_/X }
C {sky130_stdcells/and2_4.sym} 19180 -1840 0 0 {name=X_65079_ }
C {devices/lab_pin.sym} 19120 -1720 0 0 {name=p19184 lab=_69956_/A }
C {devices/lab_pin.sym} 19120 -1680 0 0 {name=p19185 lab=_73509_/A }
C {devices/lab_pin.sym} 19240 -1700 0 1 {name=p19186 lab=_69956_/X }
C {sky130_stdcells/and2_4.sym} 19180 -1700 0 0 {name=X_69956_ }
C {devices/lab_pin.sym} 19100 -1590 0 0 {name=p19187 lab=_66209_/B }
C {devices/lab_pin.sym} 19100 -1550 0 0 {name=p19188 lab=_52041_/X }
C {devices/lab_pin.sym} 19100 -1510 0 0 {name=p19189 lab=_52043_/Y }
C {devices/lab_pin.sym} 19260 -1550 0 1 {name=p19190 lab=_52044_/Y }
C {sky130_stdcells/o21ai_4.sym} 19180 -1550 0 0 {name=X_52044_ }
C {devices/lab_pin.sym} 19120 -1430 0 0 {name=p19191 lab=_56917_/Y }
C {devices/lab_pin.sym} 19120 -1390 0 0 {name=p19192 lab=_56921_/B }
C {devices/lab_pin.sym} 19120 -1350 0 0 {name=p19193 lab=_56921_/C }
C {devices/lab_pin.sym} 19240 -1390 0 1 {name=p19194 lab=_85123_/D }
C {sky130_stdcells/nand3_4.sym} 19180 -1390 0 0 {name=X_56921_ }
C {devices/lab_pin.sym} 19140 -1250 0 0 {name=p19195 lab=_69146_/A }
C {devices/lab_pin.sym} 19220 -1250 0 1 {name=p19196 lab=_68907_/X }
C {sky130_stdcells/buf_2.sym} 19180 -1250 0 0 {name=X_68907_ }
C {devices/lab_pin.sym} 19090 -1130 0 0 {name=p19197 lab=_88001_/CLK }
C {devices/lab_pin.sym} 19090 -1110 0 0 {name=p19198 lab=_42747_/X }
C {devices/lab_pin.sym} 19270 -1130 0 1 {name=p19199 lab=_68918_/B }
C {sky130_stdcells/dfxtp_4.sym} 19180 -1120 0 0 {name=X_87741_ }
C {devices/lab_pin.sym} 19090 -990 0 0 {name=p19200 lab=_85404_/CLK }
C {devices/lab_pin.sym} 19090 -970 0 0 {name=p19201 lab=_84953_/D }
C {devices/lab_pin.sym} 19270 -990 0 1 {name=p19202 lab=_84953_/Q }
C {sky130_stdcells/dfxtp_4.sym} 19180 -980 0 0 {name=X_84953_ }
C {devices/lab_pin.sym} 19100 -870 0 0 {name=p19203 lab=_80063_/X }
C {devices/lab_pin.sym} 19100 -830 0 0 {name=p19204 lab=_80074_/X }
C {devices/lab_pin.sym} 19100 -790 0 0 {name=p19205 lab=_80075_/X }
C {devices/lab_pin.sym} 19260 -830 0 1 {name=p19206 lab=_80076_/Y }
C {sky130_stdcells/a21oi_4.sym} 19180 -830 0 0 {name=X_80076_ }
C {devices/lab_pin.sym} 19100 -710 0 0 {name=p19207 lab=_69884_/X }
C {devices/lab_pin.sym} 19100 -670 0 0 {name=p19208 lab=_69886_/X }
C {devices/lab_pin.sym} 19100 -630 0 0 {name=p19209 lab=_69624_/X }
C {devices/lab_pin.sym} 19260 -670 0 1 {name=p19210 lab=_69887_/X }
C {sky130_stdcells/a21o_4.sym} 19180 -670 0 0 {name=X_69887_ }
C {devices/lab_pin.sym} 20010 -42150 0 0 {name=p19211 lab=_81928_/CLK }
C {devices/lab_pin.sym} 20010 -42130 0 0 {name=p19212 lab=_83904_/D }
C {devices/lab_pin.sym} 20190 -42150 0 1 {name=p19213 lab=_81976_/D }
C {sky130_stdcells/dfxtp_4.sym} 20100 -42140 0 0 {name=X_83904_ }
C {devices/lab_pin.sym} 20060 -42010 0 0 {name=p19214 lab=_59640_/A }
C {devices/lab_pin.sym} 20140 -42010 0 1 {name=p19215 lab=_60402_/A }
C {sky130_stdcells/buf_2.sym} 20100 -42010 0 0 {name=X_59640_ }
C {devices/lab_pin.sym} 20040 -41910 0 0 {name=p19216 lab=_56852_/A }
C {devices/lab_pin.sym} 20040 -41870 0 0 {name=p19217 lab=_56730_/X }
C {devices/lab_pin.sym} 20040 -41830 0 0 {name=p19218 lab=_56851_/X }
C {devices/lab_pin.sym} 20160 -41870 0 1 {name=p19219 lab=_56852_/X }
C {sky130_stdcells/or3_4.sym} 20100 -41870 0 0 {name=X_56852_ }
C {devices/lab_pin.sym} 20060 -41730 0 0 {name=p19220 lab=_68586_/A }
C {devices/lab_pin.sym} 20140 -41730 0 1 {name=p19221 lab=_68838_/X }
C {sky130_stdcells/buf_2.sym} 20100 -41730 0 0 {name=X_68838_ }
C {devices/lab_pin.sym} 20010 -41610 0 0 {name=p19222 lab=_87675_/CLK }
C {devices/lab_pin.sym} 20010 -41590 0 0 {name=p19223 lab=_87672_/D }
C {devices/lab_pin.sym} 20190 -41610 0 1 {name=p19224 lab=_67223_/B }
C {sky130_stdcells/dfxtp_4.sym} 20100 -41600 0 0 {name=X_87672_ }
C {devices/lab_pin.sym} 20010 -41470 0 0 {name=p19225 lab=_84884_/CLK }
C {devices/lab_pin.sym} 20010 -41450 0 0 {name=p19226 lab=_84884_/D }
C {devices/lab_pin.sym} 20190 -41470 0 1 {name=p19227 lab=_64536_/C }
C {sky130_stdcells/dfxtp_4.sym} 20100 -41460 0 0 {name=X_84884_ }
C {devices/lab_pin.sym} 20060 -41330 0 0 {name=p19228 lab=clkbuf_9_509_0_CLK/A }
C {devices/lab_pin.sym} 20140 -41330 0 1 {name=p19229 lab=clkbuf_9_509_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 20100 -41330 0 0 {name=Xclkbuf_9_509_0_CLK }
C {devices/lab_pin.sym} 20040 -41220 0 0 {name=p19230 lab=_44077_/X }
C {devices/lab_pin.sym} 20040 -41180 0 0 {name=p19231 lab=_56341_/C }
C {devices/lab_pin.sym} 20160 -41200 0 1 {name=p19232 lab=_55803_/X }
C {sky130_stdcells/and2_4.sym} 20100 -41200 0 0 {name=X_55803_ }
C {devices/lab_pin.sym} 20010 -41070 0 0 {name=p19233 lab=_84922_/CLK }
C {devices/lab_pin.sym} 20010 -41050 0 0 {name=p19234 lab=_47550_/Y }
C {devices/lab_pin.sym} 20190 -41070 0 1 {name=p19235 lab=_86623_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -41060 0 0 {name=X_86623_ }
C {devices/lab_pin.sym} 20040 -40960 0 0 {name=p19236 lab=_59562_/B }
C {devices/lab_pin.sym} 20040 -40920 0 0 {name=p19237 lab=_59571_/B }
C {devices/lab_pin.sym} 20040 -40880 0 0 {name=p19238 lab=_59571_/C }
C {devices/lab_pin.sym} 20040 -40840 0 0 {name=p19239 lab=_59741_/C }
C {devices/lab_pin.sym} 20160 -40900 0 1 {name=p19240 lab=_60160_/B }
C {sky130_stdcells/nand4_4.sym} 20100 -40900 0 0 {name=X_59571_ }
C {devices/lab_pin.sym} 20010 -40750 0 0 {name=p19241 lab=_83835_/CLK }
C {devices/lab_pin.sym} 20010 -40730 0 0 {name=p19242 lab=_83835_/D }
C {devices/lab_pin.sym} 20190 -40750 0 1 {name=p19243 lab=_83835_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -40740 0 0 {name=X_83835_ }
C {devices/lab_pin.sym} 20060 -40610 0 0 {name=p19244 lab=_83324_/Q }
C {devices/lab_pin.sym} 20140 -40610 0 1 {name=p19245 lab=_56783_/X }
C {sky130_stdcells/buf_2.sym} 20100 -40610 0 0 {name=X_56783_ }
C {devices/lab_pin.sym} 20020 -40520 0 0 {name=p19246 lab=_88003_/Q }
C {devices/lab_pin.sym} 20020 -40480 0 0 {name=p19247 lab=_68715_/X }
C {devices/lab_pin.sym} 20020 -40440 0 0 {name=p19248 lab=_68540_/X }
C {devices/lab_pin.sym} 20020 -40400 0 0 {name=p19249 lab=_68768_/X }
C {devices/lab_pin.sym} 20180 -40460 0 1 {name=p19250 lab=_68769_/X }
C {sky130_stdcells/a211o_4.sym} 20100 -40460 0 0 {name=X_68769_ }
C {devices/lab_pin.sym} 20040 -40320 0 0 {name=p19251 lab=_53991_/A }
C {devices/lab_pin.sym} 20040 -40280 0 0 {name=p19252 lab=_46376_/Y }
C {devices/lab_pin.sym} 20160 -40300 0 1 {name=p19253 lab=_53995_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -40300 0 0 {name=X_53995_ }
C {devices/lab_pin.sym} 20040 -40180 0 0 {name=p19254 lab=_71221_/A }
C {devices/lab_pin.sym} 20040 -40140 0 0 {name=p19255 lab=_70712_/A }
C {devices/lab_pin.sym} 20160 -40160 0 1 {name=p19256 lab=_70800_/X }
C {sky130_stdcells/and2_4.sym} 20100 -40160 0 0 {name=X_70800_ }
C {devices/lab_pin.sym} 20060 -40030 0 0 {name=p19257 lab=_58522_/A }
C {devices/lab_pin.sym} 20140 -40030 0 1 {name=p19258 lab=_58522_/Y }
C {sky130_stdcells/inv_2.sym} 20100 -40030 0 0 {name=X_58522_ }
C {devices/lab_pin.sym} 20020 -39930 0 0 {name=p19259 lab=_55731_/X }
C {devices/lab_pin.sym} 20020 -39890 0 0 {name=p19260 lab=_55733_/X }
C {devices/lab_pin.sym} 20020 -39850 0 0 {name=p19261 lab=_44108_/X }
C {devices/lab_pin.sym} 20180 -39890 0 1 {name=p19262 lab=_55734_/Y }
C {sky130_stdcells/a21oi_4.sym} 20100 -39890 0 0 {name=X_55734_ }
C {devices/lab_pin.sym} 20010 -39750 0 0 {name=p19263 lab=_86554_/CLK }
C {devices/lab_pin.sym} 20010 -39730 0 0 {name=p19264 lab=_48218_/Y }
C {devices/lab_pin.sym} 20190 -39750 0 1 {name=p19265 lab=_86554_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -39740 0 0 {name=X_86554_ }
C {devices/lab_pin.sym} 20060 -39610 0 0 {name=p19266 lab=clkbuf_8_63_0_CLK/A }
C {devices/lab_pin.sym} 20140 -39610 0 1 {name=p19267 lab=clkbuf_8_62_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 20100 -39610 0 0 {name=Xclkbuf_8_62_0_CLK }
C {devices/lab_pin.sym} 20020 -39530 0 0 {name=p19268 lab=_40944_/X }
C {devices/lab_pin.sym} 20020 -39490 0 0 {name=p19269 lab=_40946_/X }
C {devices/lab_pin.sym} 20020 -39450 0 0 {name=p19270 lab=_40959_/X }
C {devices/lab_pin.sym} 20020 -39410 0 0 {name=p19271 lab=_88303_/Q }
C {devices/lab_pin.sym} 20020 -39370 0 0 {name=p19272 lab=_40916_/X }
C {devices/lab_pin.sym} 20180 -39450 0 1 {name=p19273 lab=_40960_/Y }
C {sky130_stdcells/o32ai_4.sym} 20100 -39450 0 0 {name=X_40960_ }
C {devices/lab_pin.sym} 20060 -39290 0 0 {name=p19274 lab=_52892_/A }
C {devices/lab_pin.sym} 20140 -39290 0 1 {name=p19275 lab=_52946_/X }
C {sky130_stdcells/buf_2.sym} 20100 -39290 0 0 {name=X_52946_ }
C {devices/lab_pin.sym} 20020 -39190 0 0 {name=p19276 lab=_71761_/Y }
C {devices/lab_pin.sym} 20020 -39150 0 0 {name=p19277 lab=_83378_/Q }
C {devices/lab_pin.sym} 20020 -39110 0 0 {name=p19278 lab=_71779_/X }
C {devices/lab_pin.sym} 20180 -39150 0 1 {name=p19279 lab=_83378_/D }
C {sky130_stdcells/a21o_4.sym} 20100 -39150 0 0 {name=X_71780_ }
C {devices/lab_pin.sym} 20010 -39010 0 0 {name=p19280 lab=_83766_/CLK }
C {devices/lab_pin.sym} 20010 -38990 0 0 {name=p19281 lab=_83766_/D }
C {devices/lab_pin.sym} 20190 -39010 0 1 {name=p19282 lab=_58356_/B }
C {sky130_stdcells/dfxtp_4.sym} 20100 -39000 0 0 {name=X_83766_ }
C {devices/lab_pin.sym} 20010 -38870 0 0 {name=p19283 lab=_81059_/CLK }
C {devices/lab_pin.sym} 20010 -38850 0 0 {name=p19284 lab=_75724_/X }
C {devices/lab_pin.sym} 20190 -38870 0 1 {name=p19285 lab=_75124_/B }
C {sky130_stdcells/dfxtp_4.sym} 20100 -38860 0 0 {name=X_80978_ }
C {devices/lab_pin.sym} 20010 -38730 0 0 {name=p19286 lab=_85505_/CLK }
C {devices/lab_pin.sym} 20010 -38710 0 0 {name=p19287 lab=_85505_/D }
C {devices/lab_pin.sym} 20190 -38730 0 1 {name=p19288 lab=_85505_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -38720 0 0 {name=X_85505_ }
C {devices/lab_pin.sym} 20040 -38600 0 0 {name=p19289 lab=_70358_/X }
C {devices/lab_pin.sym} 20040 -38560 0 0 {name=p19290 lab=_70827_/B }
C {devices/lab_pin.sym} 20160 -38580 0 1 {name=p19291 lab=_71735_/D }
C {sky130_stdcells/nor2_4.sym} 20100 -38580 0 0 {name=X_70731_ }
C {devices/lab_pin.sym} 20020 -38470 0 0 {name=p19292 lab=_58448_/X }
C {devices/lab_pin.sym} 20020 -38430 0 0 {name=p19293 lab=_83477_/Q }
C {devices/lab_pin.sym} 20020 -38390 0 0 {name=p19294 lab=_58452_/Y }
C {devices/lab_pin.sym} 20180 -38430 0 1 {name=p19295 lab=_84845_/D }
C {sky130_stdcells/o21a_4.sym} 20100 -38430 0 0 {name=X_58453_ }
C {devices/lab_pin.sym} 20010 -38290 0 0 {name=p19296 lab=_82503_/CLK }
C {devices/lab_pin.sym} 20010 -38270 0 0 {name=p19297 lab=_82717_/D }
C {devices/lab_pin.sym} 20190 -38290 0 1 {name=p19298 lab=_82673_/D }
C {sky130_stdcells/dfxtp_4.sym} 20100 -38280 0 0 {name=X_82717_ }
C {devices/lab_pin.sym} 20040 -38170 0 0 {name=p19299 lab=_55243_/A }
C {devices/lab_pin.sym} 20040 -38130 0 0 {name=p19300 lab=_83317_/Q }
C {devices/lab_pin.sym} 20040 -38090 0 0 {name=p19301 lab=_55243_/B }
C {devices/lab_pin.sym} 20160 -38130 0 1 {name=p19302 lab=_55665_/Y }
C {sky130_stdcells/nand3_4.sym} 20100 -38130 0 0 {name=X_55665_ }
C {devices/lab_pin.sym} 20010 -37990 0 0 {name=p19303 lab=_86196_/CLK }
C {devices/lab_pin.sym} 20010 -37970 0 0 {name=p19304 lab=_86485_/D }
C {devices/lab_pin.sym} 20190 -37990 0 1 {name=p19305 lab=_65612_/B }
C {sky130_stdcells/dfxtp_4.sym} 20100 -37980 0 0 {name=X_86485_ }
C {devices/lab_pin.sym} 20020 -37880 0 0 {name=p19306 lab=_40890_/X }
C {devices/lab_pin.sym} 20020 -37840 0 0 {name=p19307 lab=_40821_/X }
C {devices/lab_pin.sym} 20020 -37800 0 0 {name=p19308 lab=_88316_/Q }
C {devices/lab_pin.sym} 20020 -37760 0 0 {name=p19309 lab=_40822_/X }
C {devices/lab_pin.sym} 20180 -37820 0 1 {name=p19310 lab=_40891_/X }
C {sky130_stdcells/a2bb2o_4.sym} 20100 -37820 0 0 {name=X_40891_ }
C {devices/lab_pin.sym} 20020 -37690 0 0 {name=p19311 lab=_85738_/Q }
C {devices/lab_pin.sym} 20020 -37650 0 0 {name=p19312 lab=_52874_/X }
C {devices/lab_pin.sym} 20020 -37610 0 0 {name=p19313 lab=_52876_/Y }
C {devices/lab_pin.sym} 20180 -37650 0 1 {name=p19314 lab=_52877_/Y }
C {sky130_stdcells/o21ai_4.sym} 20100 -37650 0 0 {name=X_52877_ }
C {devices/lab_pin.sym} 20010 -37510 0 0 {name=p19315 lab=_83699_/CLK }
C {devices/lab_pin.sym} 20010 -37490 0 0 {name=p19316 lab=_70808_/Y }
C {devices/lab_pin.sym} 20190 -37510 0 1 {name=p19317 lab=_83697_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -37500 0 0 {name=X_83697_ }
C {devices/lab_pin.sym} 20020 -37400 0 0 {name=p19318 lab=_57394_/X }
C {devices/lab_pin.sym} 20020 -37360 0 0 {name=p19319 lab=_56634_/X }
C {devices/lab_pin.sym} 20020 -37320 0 0 {name=p19320 lab=_45584_/A }
C {devices/lab_pin.sym} 20020 -37280 0 0 {name=p19321 lab=_57395_/X }
C {devices/lab_pin.sym} 20180 -37340 0 1 {name=p19322 lab=_85013_/D }
C {sky130_stdcells/a2bb2o_4.sym} 20100 -37340 0 0 {name=X_57404_ }
C {devices/lab_pin.sym} 20010 -37190 0 0 {name=p19323 lab=_88224_/CLK }
C {devices/lab_pin.sym} 20010 -37170 0 0 {name=p19324 lab=_88224_/D }
C {devices/lab_pin.sym} 20190 -37190 0 1 {name=p19325 lab=_67801_/B }
C {sky130_stdcells/dfxtp_4.sym} 20100 -37180 0 0 {name=X_88224_ }
C {devices/lab_pin.sym} 20060 -37050 0 0 {name=p19326 lab=_52754_/A }
C {devices/lab_pin.sym} 20140 -37050 0 1 {name=p19327 lab=_53189_/A }
C {sky130_stdcells/buf_2.sym} 20100 -37050 0 0 {name=X_42630_ }
C {devices/lab_pin.sym} 20060 -36930 0 0 {name=p19328 lab=_54344_/A }
C {devices/lab_pin.sym} 20140 -36930 0 1 {name=p19329 lab=_54616_/X }
C {sky130_stdcells/buf_2.sym} 20100 -36930 0 0 {name=X_54616_ }
C {devices/lab_pin.sym} 20060 -36810 0 0 {name=p19330 lab=_72909_/A }
C {devices/lab_pin.sym} 20140 -36810 0 1 {name=p19331 lab=_73450_/X }
C {sky130_stdcells/buf_2.sym} 20100 -36810 0 0 {name=X_73450_ }
C {devices/lab_pin.sym} 20010 -36690 0 0 {name=p19332 lab=_85436_/CLK }
C {devices/lab_pin.sym} 20010 -36670 0 0 {name=p19333 lab=_85436_/D }
C {devices/lab_pin.sym} 20190 -36690 0 1 {name=p19334 lab=_85436_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -36680 0 0 {name=X_85436_ }
C {devices/lab_pin.sym} 20040 -36580 0 0 {name=p19335 lab=_51805_/A }
C {devices/lab_pin.sym} 20040 -36540 0 0 {name=p19336 lab=_51815_/B }
C {devices/lab_pin.sym} 20040 -36500 0 0 {name=p19337 lab=_51810_/C }
C {devices/lab_pin.sym} 20040 -36460 0 0 {name=p19338 lab=_52654_/D }
C {devices/lab_pin.sym} 20160 -36520 0 1 {name=p19339 lab=_51828_/X }
C {sky130_stdcells/and4_4.sym} 20100 -36520 0 0 {name=X_51828_ }
C {devices/lab_pin.sym} 20060 -36370 0 0 {name=p19340 lab=_70500_/B }
C {devices/lab_pin.sym} 20140 -36370 0 1 {name=p19341 lab=_70662_/X }
C {sky130_stdcells/buf_2.sym} 20100 -36370 0 0 {name=X_70662_ }
C {devices/lab_pin.sym} 20010 -36250 0 0 {name=p19342 lab=_82648_/CLK }
C {devices/lab_pin.sym} 20010 -36230 0 0 {name=p19343 lab=_82648_/D }
C {devices/lab_pin.sym} 20190 -36250 0 1 {name=p19344 lab=_82648_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -36240 0 0 {name=X_82648_ }
C {devices/lab_pin.sym} 20020 -36130 0 0 {name=p19345 lab=_58366_/X }
C {devices/lab_pin.sym} 20020 -36090 0 0 {name=p19346 lab=_83351_/Q }
C {devices/lab_pin.sym} 20020 -36050 0 0 {name=p19347 lab=_58383_/Y }
C {devices/lab_pin.sym} 20180 -36090 0 1 {name=p19348 lab=_84863_/D }
C {sky130_stdcells/o21a_4.sym} 20100 -36090 0 0 {name=X_58384_ }
C {devices/lab_pin.sym} 20040 -35960 0 0 {name=p19349 lab=_44064_/X }
C {devices/lab_pin.sym} 20040 -35920 0 0 {name=p19350 lab=_55596_/B }
C {devices/lab_pin.sym} 20160 -35940 0 1 {name=p19351 lab=_55596_/Y }
C {sky130_stdcells/nor2_4.sym} 20100 -35940 0 0 {name=X_55596_ }
C {devices/lab_pin.sym} 20040 -35820 0 0 {name=p19352 lab=_86602_/Q }
C {devices/lab_pin.sym} 20040 -35780 0 0 {name=p19353 lab=_72401_/B }
C {devices/lab_pin.sym} 20160 -35800 0 1 {name=p19354 lab=_72401_/Y }
C {sky130_stdcells/nor2_4.sym} 20100 -35800 0 0 {name=X_72401_ }
C {devices/lab_pin.sym} 20060 -35670 0 0 {name=p19355 lab=clkbuf_8_77_0_CLK/A }
C {devices/lab_pin.sym} 20140 -35670 0 1 {name=p19356 lab=clkbuf_8_77_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 20100 -35670 0 0 {name=Xclkbuf_8_77_0_CLK }
C {devices/lab_pin.sym} 20040 -35560 0 0 {name=p19357 lab=_57331_/Y }
C {devices/lab_pin.sym} 20040 -35520 0 0 {name=p19358 lab=_57335_/B }
C {devices/lab_pin.sym} 20160 -35540 0 1 {name=p19359 lab=_57335_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -35540 0 0 {name=X_57335_ }
C {devices/lab_pin.sym} 20010 -35410 0 0 {name=p19360 lab=_88220_/CLK }
C {devices/lab_pin.sym} 20010 -35390 0 0 {name=p19361 lab=_41759_/Y }
C {devices/lab_pin.sym} 20190 -35410 0 1 {name=p19362 lab=_88155_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -35400 0 0 {name=X_88155_ }
C {devices/lab_pin.sym} 20020 -35310 0 0 {name=p19363 lab=_42554_/X }
C {devices/lab_pin.sym} 20020 -35270 0 0 {name=p19364 lab=_40802_/A }
C {devices/lab_pin.sym} 20020 -35230 0 0 {name=p19365 lab=_42477_/X }
C {devices/lab_pin.sym} 20020 -35190 0 0 {name=p19366 lab=_69661_/B }
C {devices/lab_pin.sym} 20020 -35150 0 0 {name=p19367 lab=_42556_/X }
C {devices/lab_pin.sym} 20180 -35230 0 1 {name=p19368 lab=_87820_/D }
C {sky130_stdcells/o32ai_4.sym} 20100 -35230 0 0 {name=X_42561_ }
C {devices/lab_pin.sym} 20020 -35090 0 0 {name=p19369 lab=_85422_/Q }
C {devices/lab_pin.sym} 20020 -35050 0 0 {name=p19370 lab=_54540_/X }
C {devices/lab_pin.sym} 20020 -35010 0 0 {name=p19371 lab=_54546_/Y }
C {devices/lab_pin.sym} 20180 -35050 0 1 {name=p19372 lab=_54547_/Y }
C {sky130_stdcells/o21ai_4.sym} 20100 -35050 0 0 {name=X_54547_ }
C {devices/lab_pin.sym} 20040 -34920 0 0 {name=p19373 lab=_73381_/A }
C {devices/lab_pin.sym} 20040 -34880 0 0 {name=p19374 lab=_86473_/Q }
C {devices/lab_pin.sym} 20160 -34900 0 1 {name=p19375 lab=_73381_/X }
C {sky130_stdcells/and2_4.sym} 20100 -34900 0 0 {name=X_73381_ }
C {devices/lab_pin.sym} 20010 -34770 0 0 {name=p19376 lab=_83275_/CLK }
C {devices/lab_pin.sym} 20010 -34750 0 0 {name=p19377 lab=_54849_/Y }
C {devices/lab_pin.sym} 20190 -34770 0 1 {name=p19378 lab=_85367_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -34760 0 0 {name=X_85367_ }
C {devices/lab_pin.sym} 20020 -34650 0 0 {name=p19379 lab=_85951_/Q }
C {devices/lab_pin.sym} 20020 -34610 0 0 {name=p19380 lab=_51387_/X }
C {devices/lab_pin.sym} 20020 -34570 0 0 {name=p19381 lab=_51758_/Y }
C {devices/lab_pin.sym} 20180 -34610 0 1 {name=p19382 lab=_51759_/Y }
C {sky130_stdcells/o21ai_4.sym} 20100 -34610 0 0 {name=X_51759_ }
C {devices/lab_pin.sym} 20060 -34470 0 0 {name=p19383 lab=_74716_/A }
C {devices/lab_pin.sym} 20140 -34470 0 1 {name=p19384 lab=_70620_/D }
C {sky130_stdcells/buf_2.sym} 20100 -34470 0 0 {name=X_70593_ }
C {devices/lab_pin.sym} 20060 -34350 0 0 {name=p19385 lab=clkbuf_6_4_0_CLK/X }
C {devices/lab_pin.sym} 20140 -34350 0 1 {name=p19386 lab=clkbuf_7_9_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 20100 -34350 0 0 {name=Xclkbuf_7_9_0_CLK }
C {devices/lab_pin.sym} 20010 -34230 0 0 {name=p19387 lab=_82711_/CLK }
C {devices/lab_pin.sym} 20010 -34210 0 0 {name=p19388 lab=_82611_/Q }
C {devices/lab_pin.sym} 20190 -34230 0 1 {name=p19389 lab=_78198_/A }
C {sky130_stdcells/dfxtp_4.sym} 20100 -34220 0 0 {name=X_82579_ }
C {devices/lab_pin.sym} 20040 -34120 0 0 {name=p19390 lab=_64619_/A }
C {devices/lab_pin.sym} 20040 -34080 0 0 {name=p19391 lab=_58020_/A }
C {devices/lab_pin.sym} 20040 -34040 0 0 {name=p19392 lab=_59238_/A }
C {devices/lab_pin.sym} 20040 -34000 0 0 {name=p19393 lab=_44265_/D }
C {devices/lab_pin.sym} 20160 -34060 0 1 {name=p19394 lab=_44300_/Y }
C {sky130_stdcells/nor4_4.sym} 20100 -34060 0 0 {name=X_44300_ }
C {devices/lab_pin.sym} 20040 -33930 0 0 {name=p19395 lab=_75120_/A }
C {devices/lab_pin.sym} 20040 -33890 0 0 {name=p19396 lab=_75120_/B }
C {devices/lab_pin.sym} 20040 -33850 0 0 {name=p19397 lab=_75116_/X }
C {devices/lab_pin.sym} 20160 -33890 0 1 {name=p19398 lab=_75121_/B }
C {sky130_stdcells/nand3_4.sym} 20100 -33890 0 0 {name=X_75120_ }
C {devices/lab_pin.sym} 20010 -33750 0 0 {name=p19399 lab=_87926_/CLK }
C {devices/lab_pin.sym} 20010 -33730 0 0 {name=p19400 lab=_87106_/D }
C {devices/lab_pin.sym} 20190 -33750 0 1 {name=p19401 lab=_87106_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -33740 0 0 {name=X_87106_ }
C {devices/lab_pin.sym} 20020 -33640 0 0 {name=p19402 lab=_41511_/X }
C {devices/lab_pin.sym} 20020 -33600 0 0 {name=p19403 lab=_41486_/X }
C {devices/lab_pin.sym} 20020 -33560 0 0 {name=p19404 lab=_88201_/Q }
C {devices/lab_pin.sym} 20020 -33520 0 0 {name=p19405 lab=_41487_/X }
C {devices/lab_pin.sym} 20180 -33580 0 1 {name=p19406 lab=_41512_/X }
C {sky130_stdcells/a2bb2o_4.sym} 20100 -33580 0 0 {name=X_41512_ }
C {devices/lab_pin.sym} 20040 -33440 0 0 {name=p19407 lab=_72332_/A }
C {devices/lab_pin.sym} 20040 -33400 0 0 {name=p19408 lab=_72332_/B }
C {devices/lab_pin.sym} 20160 -33420 0 1 {name=p19409 lab=_72332_/Y }
C {sky130_stdcells/nor2_4.sym} 20100 -33420 0 0 {name=X_72332_ }
C {devices/lab_pin.sym} 20010 -33290 0 0 {name=p19410 lab=_84321_/CLK }
C {devices/lab_pin.sym} 20010 -33270 0 0 {name=p19411 lab=_84318_/D }
C {devices/lab_pin.sym} 20190 -33290 0 1 {name=p19412 lab=_80506_/B }
C {sky130_stdcells/dfxtp_4.sym} 20100 -33280 0 0 {name=X_84318_ }
C {devices/lab_pin.sym} 20020 -33170 0 0 {name=p19413 lab=_45268_/X }
C {devices/lab_pin.sym} 20020 -33130 0 0 {name=p19414 lab=_45276_/Y }
C {devices/lab_pin.sym} 20020 -33090 0 0 {name=p19415 lab=_45279_/Y }
C {devices/lab_pin.sym} 20180 -33130 0 1 {name=p19416 lab=_45280_/Y }
C {sky130_stdcells/a21oi_4.sym} 20100 -33130 0 0 {name=X_45280_ }
C {devices/lab_pin.sym} 20020 -33010 0 0 {name=p19417 lab=_45631_/Y }
C {devices/lab_pin.sym} 20020 -32970 0 0 {name=p19418 lab=_57247_/Y }
C {devices/lab_pin.sym} 20020 -32930 0 0 {name=p19419 lab=_57265_/X }
C {devices/lab_pin.sym} 20180 -32970 0 1 {name=p19420 lab=_85042_/D }
C {sky130_stdcells/o21ai_4.sym} 20100 -32970 0 0 {name=X_57266_ }
C {devices/lab_pin.sym} 20010 -32830 0 0 {name=p19421 lab=_88086_/CLK }
C {devices/lab_pin.sym} 20010 -32810 0 0 {name=p19422 lab=_41974_/Y }
C {devices/lab_pin.sym} 20190 -32830 0 1 {name=p19423 lab=_41973_/A }
C {sky130_stdcells/dfxtp_4.sym} 20100 -32820 0 0 {name=X_88086_ }
C {devices/lab_pin.sym} 20040 -32700 0 0 {name=p19424 lab=_54478_/A }
C {devices/lab_pin.sym} 20040 -32660 0 0 {name=p19425 lab=_54478_/B }
C {devices/lab_pin.sym} 20160 -32680 0 1 {name=p19426 lab=_54478_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -32680 0 0 {name=X_54478_ }
C {devices/lab_pin.sym} 20060 -32550 0 0 {name=p19427 lab=_42492_/A }
C {devices/lab_pin.sym} 20140 -32550 0 1 {name=p19428 lab=_87847_/D }
C {sky130_stdcells/inv_2.sym} 20100 -32550 0 0 {name=X_42492_ }
C {devices/lab_pin.sym} 20010 -32430 0 0 {name=p19429 lab=_85279_/CLK }
C {devices/lab_pin.sym} 20010 -32410 0 0 {name=p19430 lab=_56087_/Y }
C {devices/lab_pin.sym} 20190 -32430 0 1 {name=p19431 lab=_55851_/B }
C {sky130_stdcells/dfxtp_4.sym} 20100 -32420 0 0 {name=X_85298_ }
C {devices/lab_pin.sym} 20020 -32320 0 0 {name=p19432 lab=_84777_/Q }
C {devices/lab_pin.sym} 20020 -32280 0 0 {name=p19433 lab=_58956_/X }
C {devices/lab_pin.sym} 20020 -32240 0 0 {name=p19434 lab=_58998_/X }
C {devices/lab_pin.sym} 20020 -32200 0 0 {name=p19435 lab=_59004_/X }
C {devices/lab_pin.sym} 20180 -32260 0 1 {name=p19436 lab=_84777_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 20100 -32260 0 0 {name=X_59005_ }
C {devices/lab_pin.sym} 20020 -32130 0 0 {name=p19437 lab=_56055_/X }
C {devices/lab_pin.sym} 20020 -32090 0 0 {name=p19438 lab=_56210_/X }
C {devices/lab_pin.sym} 20020 -32050 0 0 {name=p19439 lab=_56216_/Y }
C {devices/lab_pin.sym} 20180 -32090 0 1 {name=p19440 lab=_85272_/D }
C {sky130_stdcells/o21ai_4.sym} 20100 -32090 0 0 {name=X_56217_ }
C {devices/lab_pin.sym} 20060 -31950 0 0 {name=p19441 lab=_44231_/A }
C {devices/lab_pin.sym} 20140 -31950 0 1 {name=p19442 lab=_44242_/C }
C {sky130_stdcells/buf_2.sym} 20100 -31950 0 0 {name=X_44231_ }
C {devices/lab_pin.sym} 20040 -31850 0 0 {name=p19443 lab=_75051_/A }
C {devices/lab_pin.sym} 20040 -31810 0 0 {name=p19444 lab=_75051_/B }
C {devices/lab_pin.sym} 20040 -31770 0 0 {name=p19445 lab=_75050_/Y }
C {devices/lab_pin.sym} 20160 -31810 0 1 {name=p19446 lab=_75051_/X }
C {sky130_stdcells/and3_4.sym} 20100 -31810 0 0 {name=X_75051_ }
C {devices/lab_pin.sym} 20010 -31670 0 0 {name=p19447 lab=_87032_/CLK }
C {devices/lab_pin.sym} 20010 -31650 0 0 {name=p19448 lab=_87037_/D }
C {devices/lab_pin.sym} 20190 -31670 0 1 {name=p19449 lab=_87037_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -31660 0 0 {name=X_87037_ }
C {devices/lab_pin.sym} 20040 -31560 0 0 {name=p19450 lab=_53420_/A }
C {devices/lab_pin.sym} 20040 -31520 0 0 {name=p19451 lab=_53428_/X }
C {devices/lab_pin.sym} 20040 -31480 0 0 {name=p19452 lab=_53410_/C }
C {devices/lab_pin.sym} 20040 -31440 0 0 {name=p19453 lab=_51225_/D }
C {devices/lab_pin.sym} 20160 -31500 0 1 {name=p19454 lab=_53429_/X }
C {sky130_stdcells/and4_4.sym} 20100 -31500 0 0 {name=X_53429_ }
C {devices/lab_pin.sym} 20020 -31390 0 0 {name=p19455 lab=_41399_/X }
C {devices/lab_pin.sym} 20020 -31350 0 0 {name=p19456 lab=_41400_/X }
C {devices/lab_pin.sym} 20020 -31310 0 0 {name=p19457 lab=_41442_/X }
C {devices/lab_pin.sym} 20020 -31270 0 0 {name=p19458 lab=_88214_/Q }
C {devices/lab_pin.sym} 20020 -31230 0 0 {name=p19459 lab=_41388_/X }
C {devices/lab_pin.sym} 20180 -31310 0 1 {name=p19460 lab=_41444_/A }
C {sky130_stdcells/o32ai_4.sym} 20100 -31310 0 0 {name=X_41443_ }
C {devices/lab_pin.sym} 20060 -31150 0 0 {name=p19461 lab=_83269_/Q }
C {devices/lab_pin.sym} 20140 -31150 0 1 {name=p19462 lab=_72263_/Y }
C {sky130_stdcells/inv_2.sym} 20100 -31150 0 0 {name=X_72263_ }
C {devices/lab_pin.sym} 20010 -31030 0 0 {name=p19463 lab=_84849_/CLK }
C {devices/lab_pin.sym} 20010 -31010 0 0 {name=p19464 lab=_64408_/X }
C {devices/lab_pin.sym} 20190 -31030 0 1 {name=p19465 lab=_79713_/B }
C {sky130_stdcells/dfxtp_4.sym} 20100 -31020 0 0 {name=X_84249_ }
C {devices/lab_pin.sym} 20040 -30900 0 0 {name=p19466 lab=_56848_/X }
C {devices/lab_pin.sym} 20040 -30860 0 0 {name=p19467 lab=_57196_/Y }
C {devices/lab_pin.sym} 20160 -30880 0 1 {name=p19468 lab=_57198_/B }
C {sky130_stdcells/nor2_4.sym} 20100 -30880 0 0 {name=X_57197_ }
C {devices/lab_pin.sym} 20040 -30760 0 0 {name=p19469 lab=_73992_/Y }
C {devices/lab_pin.sym} 20040 -30720 0 0 {name=p19470 lab=_74002_/B }
C {devices/lab_pin.sym} 20160 -30740 0 1 {name=p19471 lab=_74002_/X }
C {sky130_stdcells/xor2_4.sym} 20100 -30740 0 0 {name=X_74002_ }
C {devices/lab_pin.sym} 20020 -30630 0 0 {name=p19472 lab=_52216_/B }
C {devices/lab_pin.sym} 20020 -30590 0 0 {name=p19473 lab=_71190_/A }
C {devices/lab_pin.sym} 20020 -30550 0 0 {name=p19474 lab=_71213_/Y }
C {devices/lab_pin.sym} 20180 -30590 0 1 {name=p19475 lab=_71214_/Y }
C {sky130_stdcells/o21ai_4.sym} 20100 -30590 0 0 {name=X_71214_ }
C {devices/lab_pin.sym} 20020 -30480 0 0 {name=p19476 lab=_43957_/B }
C {devices/lab_pin.sym} 20020 -30440 0 0 {name=p19477 lab=_44160_/A }
C {devices/lab_pin.sym} 20020 -30400 0 0 {name=p19478 lab=_59901_/C }
C {devices/lab_pin.sym} 20020 -30360 0 0 {name=p19479 lab=_44025_/X }
C {devices/lab_pin.sym} 20180 -30420 0 1 {name=p19480 lab=_44162_/Y }
C {sky130_stdcells/a22oi_4.sym} 20100 -30420 0 0 {name=X_44162_ }
C {devices/lab_pin.sym} 20060 -30270 0 0 {name=p19481 lab=_56148_/A }
C {devices/lab_pin.sym} 20140 -30270 0 1 {name=p19482 lab=_56148_/X }
C {sky130_stdcells/buf_2.sym} 20100 -30270 0 0 {name=X_56148_ }
C {devices/lab_pin.sym} 20040 -30160 0 0 {name=p19483 lab=_41374_/A }
C {devices/lab_pin.sym} 20040 -30120 0 0 {name=p19484 lab=_41275_/B }
C {devices/lab_pin.sym} 20160 -30140 0 1 {name=p19485 lab=_41374_/X }
C {sky130_stdcells/or2_4.sym} 20100 -30140 0 0 {name=X_41374_ }
C {devices/lab_pin.sym} 20060 -30010 0 0 {name=p19486 lab=_59133_/A }
C {devices/lab_pin.sym} 20140 -30010 0 1 {name=p19487 lab=_72194_/X }
C {sky130_stdcells/buf_2.sym} 20100 -30010 0 0 {name=X_72194_ }
C {devices/lab_pin.sym} 20060 -29890 0 0 {name=p19488 lab=_87571_/Q }
C {devices/lab_pin.sym} 20140 -29890 0 1 {name=p19489 lab=_43113_/Y }
C {sky130_stdcells/inv_2.sym} 20100 -29890 0 0 {name=X_43113_ }
C {devices/lab_pin.sym} 20020 -29790 0 0 {name=p19490 lab=_78807_/Y }
C {devices/lab_pin.sym} 20020 -29750 0 0 {name=p19491 lab=_78809_/Y }
C {devices/lab_pin.sym} 20020 -29710 0 0 {name=p19492 lab=_78802_/Y }
C {devices/lab_pin.sym} 20180 -29750 0 1 {name=p19493 lab=_78810_/Y }
C {sky130_stdcells/a21oi_4.sym} 20100 -29750 0 0 {name=X_78810_ }
C {devices/lab_pin.sym} 20060 -29610 0 0 {name=p19494 lab=_40324_/X }
C {devices/lab_pin.sym} 20140 -29610 0 1 {name=p19495 lab=_40325_/X }
C {sky130_stdcells/buf_2.sym} 20100 -29610 0 0 {name=X_40325_ }
C {devices/lab_pin.sym} 20060 -29490 0 0 {name=p19496 lab=_71145_/A }
C {devices/lab_pin.sym} 20140 -29490 0 1 {name=p19497 lab=_71225_/A }
C {sky130_stdcells/buf_2.sym} 20100 -29490 0 0 {name=X_71145_ }
C {devices/lab_pin.sym} 20040 -29380 0 0 {name=p19498 lab=_48908_/A }
C {devices/lab_pin.sym} 20040 -29340 0 0 {name=p19499 lab=_71998_/B }
C {devices/lab_pin.sym} 20160 -29360 0 1 {name=p19500 lab=_48970_/X }
C {sky130_stdcells/and2_4.sym} 20100 -29360 0 0 {name=X_48970_ }
C {devices/lab_pin.sym} 20060 -29230 0 0 {name=p19501 lab=_56079_/A }
C {devices/lab_pin.sym} 20140 -29230 0 1 {name=p19502 lab=_56079_/X }
C {sky130_stdcells/buf_2.sym} 20100 -29230 0 0 {name=X_56079_ }
C {devices/lab_pin.sym} 20060 -29110 0 0 {name=p19503 lab=_55158_/A }
C {devices/lab_pin.sym} 20140 -29110 0 1 {name=p19504 lab=_55140_/A }
C {sky130_stdcells/buf_2.sym} 20100 -29110 0 0 {name=X_44093_ }
C {devices/lab_pin.sym} 20040 -29000 0 0 {name=p19505 lab=_79776_/Y }
C {devices/lab_pin.sym} 20040 -28960 0 0 {name=p19506 lab=_79790_/B }
C {devices/lab_pin.sym} 20160 -28980 0 1 {name=p19507 lab=_79790_/X }
C {sky130_stdcells/and2_4.sym} 20100 -28980 0 0 {name=X_79790_ }
C {devices/lab_pin.sym} 20020 -28870 0 0 {name=p19508 lab=_47913_/Y }
C {devices/lab_pin.sym} 20020 -28830 0 0 {name=p19509 lab=_47903_/X }
C {devices/lab_pin.sym} 20020 -28790 0 0 {name=p19510 lab=_47920_/X }
C {devices/lab_pin.sym} 20180 -28830 0 1 {name=p19511 lab=_47921_/Y }
C {sky130_stdcells/a21oi_4.sym} 20100 -28830 0 0 {name=X_47921_ }
C {devices/lab_pin.sym} 20060 -28690 0 0 {name=p19512 lab=clkbuf_7_7_0_CLK/X }
C {devices/lab_pin.sym} 20140 -28690 0 1 {name=p19513 lab=clkbuf_9_31_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 20100 -28690 0 0 {name=Xclkbuf_8_15_0_CLK }
C {devices/lab_pin.sym} 20060 -28570 0 0 {name=p19514 lab=_59906_/X }
C {devices/lab_pin.sym} 20140 -28570 0 1 {name=p19515 lab=_63632_/A }
C {sky130_stdcells/buf_2.sym} 20100 -28570 0 0 {name=X_59907_ }
C {devices/lab_pin.sym} 20020 -28490 0 0 {name=p19516 lab=_42060_/X }
C {devices/lab_pin.sym} 20020 -28450 0 0 {name=p19517 lab=_43031_/X }
C {devices/lab_pin.sym} 20020 -28410 0 0 {name=p19518 lab=_40626_/X }
C {devices/lab_pin.sym} 20020 -28370 0 0 {name=p19519 lab=_43043_/Y }
C {devices/lab_pin.sym} 20020 -28330 0 0 {name=p19520 lab=_43034_/X }
C {devices/lab_pin.sym} 20180 -28410 0 1 {name=p19521 lab=_87596_/D }
C {sky130_stdcells/o32ai_4.sym} 20100 -28410 0 0 {name=X_43044_ }
C {devices/lab_pin.sym} 20040 -28280 0 0 {name=p19522 lab=_78722_/A }
C {devices/lab_pin.sym} 20040 -28240 0 0 {name=p19523 lab=_78697_/X }
C {devices/lab_pin.sym} 20040 -28200 0 0 {name=p19524 lab=_78717_/X }
C {devices/lab_pin.sym} 20040 -28160 0 0 {name=p19525 lab=_78718_/Y }
C {devices/lab_pin.sym} 20160 -28220 0 1 {name=p19526 lab=_78742_/A }
C {sky130_stdcells/nand4_4.sym} 20100 -28220 0 0 {name=X_78741_ }
C {devices/lab_pin.sym} 20040 -28090 0 0 {name=p19527 lab=_71078_/A }
C {devices/lab_pin.sym} 20040 -28050 0 0 {name=p19528 lab=_71076_/B }
C {devices/lab_pin.sym} 20040 -28010 0 0 {name=p19529 lab=_71078_/C }
C {devices/lab_pin.sym} 20160 -28050 0 1 {name=p19530 lab=_71076_/Y }
C {sky130_stdcells/nand3_4.sym} 20100 -28050 0 0 {name=X_71076_ }
C {devices/lab_pin.sym} 20010 -27910 0 0 {name=p19531 lab=_88386_/CLK }
C {devices/lab_pin.sym} 20010 -27890 0 0 {name=p19532 lab=_87939_/D }
C {devices/lab_pin.sym} 20190 -27910 0 1 {name=p19533 lab=_87939_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -27900 0 0 {name=X_87939_ }
C {devices/lab_pin.sym} 20020 -27790 0 0 {name=p19534 lab=_75948_/Y }
C {devices/lab_pin.sym} 20020 -27750 0 0 {name=p19535 lab=_75949_/A }
C {devices/lab_pin.sym} 20020 -27710 0 0 {name=p19536 lab=_75952_/Y }
C {devices/lab_pin.sym} 20180 -27750 0 1 {name=p19537 lab=_75953_/Y }
C {sky130_stdcells/a21boi_4.sym} 20100 -27750 0 0 {name=X_75953_ }
C {devices/lab_pin.sym} 20040 -27620 0 0 {name=p19538 lab=_74904_/A }
C {devices/lab_pin.sym} 20040 -27580 0 0 {name=p19539 lab=_74904_/B }
C {devices/lab_pin.sym} 20160 -27600 0 1 {name=p19540 lab=_74904_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -27600 0 0 {name=X_74904_ }
C {devices/lab_pin.sym} 20020 -27500 0 0 {name=p19541 lab=_69520_/X }
C {devices/lab_pin.sym} 20020 -27460 0 0 {name=p19542 lab=_69727_/Y }
C {devices/lab_pin.sym} 20020 -27420 0 0 {name=p19543 lab=_70012_/X }
C {devices/lab_pin.sym} 20020 -27380 0 0 {name=p19544 lab=_70026_/Y }
C {devices/lab_pin.sym} 20180 -27440 0 1 {name=p19545 lab=_70027_/X }
C {sky130_stdcells/a211o_4.sym} 20100 -27440 0 0 {name=X_70027_ }
C {devices/lab_pin.sym} 20020 -27310 0 0 {name=p19546 lab=_47845_/Y }
C {devices/lab_pin.sym} 20020 -27270 0 0 {name=p19547 lab=_47846_/X }
C {devices/lab_pin.sym} 20020 -27230 0 0 {name=p19548 lab=_47851_/X }
C {devices/lab_pin.sym} 20180 -27270 0 1 {name=p19549 lab=_86592_/D }
C {sky130_stdcells/a21oi_4.sym} 20100 -27270 0 0 {name=X_47852_ }
C {devices/lab_pin.sym} 20020 -27170 0 0 {name=p19550 lab=_59758_/X }
C {devices/lab_pin.sym} 20020 -27130 0 0 {name=p19551 lab=_59654_/X }
C {devices/lab_pin.sym} 20020 -27090 0 0 {name=p19552 lab=_59724_/Y }
C {devices/lab_pin.sym} 20020 -27050 0 0 {name=p19553 lab=_59836_/Y }
C {devices/lab_pin.sym} 20020 -27020 0 0 {name=p19554 lab=_59837_/Y }
C {devices/lab_pin.sym} 20180 -27090 0 1 {name=p19555 lab=_59839_/A }
C {sky130_stdcells/a41o_4.sym} 20100 -27090 0 0 {name=X_59838_ }
C {devices/lab_pin.sym} 20060 -26930 0 0 {name=p19556 lab=_78671_/X }
C {devices/lab_pin.sym} 20140 -26930 0 1 {name=p19557 lab=_78672_/Y }
C {sky130_stdcells/inv_2.sym} 20100 -26930 0 0 {name=X_78672_ }
C {devices/lab_pin.sym} 20060 -26810 0 0 {name=p19558 lab=_75762_/Y }
C {devices/lab_pin.sym} 20140 -26810 0 1 {name=p19559 lab=_80791_/D }
C {sky130_stdcells/inv_2.sym} 20100 -26810 0 0 {name=X_75884_ }
C {devices/lab_pin.sym} 20020 -26710 0 0 {name=p19560 lab=_46797_/Y }
C {devices/lab_pin.sym} 20020 -26670 0 0 {name=p19561 lab=_46798_/X }
C {devices/lab_pin.sym} 20020 -26630 0 0 {name=p19562 lab=_46802_/X }
C {devices/lab_pin.sym} 20180 -26670 0 1 {name=p19563 lab=_86702_/D }
C {sky130_stdcells/a21oi_4.sym} 20100 -26670 0 0 {name=X_46803_ }
C {devices/lab_pin.sym} 20060 -26530 0 0 {name=p19564 lab=_77605_/X }
C {devices/lab_pin.sym} 20140 -26530 0 1 {name=p19565 lab=_77623_/Y }
C {sky130_stdcells/inv_2.sym} 20100 -26530 0 0 {name=X_77623_ }
C {devices/lab_pin.sym} 20060 -26410 0 0 {name=p19566 lab=_74835_/A }
C {devices/lab_pin.sym} 20140 -26410 0 1 {name=p19567 lab=_74835_/Y }
C {sky130_stdcells/inv_2.sym} 20100 -26410 0 0 {name=X_74835_ }
C {devices/lab_pin.sym} 20060 -26290 0 0 {name=p19568 lab=_81222_/Q }
C {devices/lab_pin.sym} 20140 -26290 0 1 {name=p19569 lab=_47784_/A }
C {sky130_stdcells/inv_2.sym} 20100 -26290 0 0 {name=X_47783_ }
C {devices/lab_pin.sym} 20060 -26170 0 0 {name=p19570 lab=_44173_/X }
C {devices/lab_pin.sym} 20140 -26170 0 1 {name=p19571 lab=_59772_/A }
C {sky130_stdcells/buf_2.sym} 20100 -26170 0 0 {name=X_59769_ }
C {devices/lab_pin.sym} 20060 -26050 0 0 {name=p19572 lab=_45219_/A }
C {devices/lab_pin.sym} 20140 -26050 0 1 {name=p19573 lab=_44995_/X }
C {sky130_stdcells/buf_2.sym} 20100 -26050 0 0 {name=X_44995_ }
C {devices/lab_pin.sym} 20020 -25970 0 0 {name=p19574 lab=_61789_/X }
C {devices/lab_pin.sym} 20020 -25930 0 0 {name=p19575 lab=_61792_/X }
C {devices/lab_pin.sym} 20020 -25890 0 0 {name=p19576 lab=_61799_/Y }
C {devices/lab_pin.sym} 20020 -25850 0 0 {name=p19577 lab=_58162_/A }
C {devices/lab_pin.sym} 20020 -25810 0 0 {name=p19578 lab=_61719_/X }
C {devices/lab_pin.sym} 20180 -25890 0 1 {name=p19579 lab=_61800_/Y }
C {sky130_stdcells/o32ai_4.sym} 20100 -25890 0 0 {name=X_61800_ }
C {devices/lab_pin.sym} 20040 -25760 0 0 {name=p19580 lab=_49537_/A }
C {devices/lab_pin.sym} 20040 -25720 0 0 {name=p19581 lab=_49516_/B }
C {devices/lab_pin.sym} 20040 -25680 0 0 {name=p19582 lab=_49522_/C }
C {devices/lab_pin.sym} 20040 -25640 0 0 {name=p19583 lab=_52735_/D }
C {devices/lab_pin.sym} 20160 -25700 0 1 {name=p19584 lab=_49522_/X }
C {sky130_stdcells/and4_4.sym} 20100 -25700 0 0 {name=X_49522_ }
C {devices/lab_pin.sym} 20020 -25570 0 0 {name=p19585 lab=_58722_/A }
C {devices/lab_pin.sym} 20020 -25530 0 0 {name=p19586 lab=_46719_/X }
C {devices/lab_pin.sym} 20020 -25490 0 0 {name=p19587 lab=_46733_/Y }
C {devices/lab_pin.sym} 20180 -25530 0 1 {name=p19588 lab=_46734_/Y }
C {sky130_stdcells/o21ai_4.sym} 20100 -25530 0 0 {name=X_46734_ }
C {devices/lab_pin.sym} 20020 -25410 0 0 {name=p19589 lab=_77553_/B }
C {devices/lab_pin.sym} 20020 -25370 0 0 {name=p19590 lab=_77552_/Y }
C {devices/lab_pin.sym} 20020 -25330 0 0 {name=p19591 lab=_77553_/A }
C {devices/lab_pin.sym} 20180 -25370 0 1 {name=p19592 lab=_77558_/C }
C {sky130_stdcells/o21ai_4.sym} 20100 -25370 0 0 {name=X_77554_ }
C {devices/lab_pin.sym} 20060 -25230 0 0 {name=p19593 lab=_80667_/Q }
C {devices/lab_pin.sym} 20140 -25230 0 1 {name=p19594 lab=_43979_/A }
C {sky130_stdcells/buf_2.sym} 20100 -25230 0 0 {name=X_43946_ }
C {devices/lab_pin.sym} 20040 -25130 0 0 {name=p19595 lab=_62766_/A }
C {devices/lab_pin.sym} 20040 -25090 0 0 {name=p19596 lab=_62766_/B }
C {devices/lab_pin.sym} 20040 -25050 0 0 {name=p19597 lab=_84383_/Q }
C {devices/lab_pin.sym} 20160 -25090 0 1 {name=p19598 lab=_62780_/Y }
C {sky130_stdcells/nor3_4.sym} 20100 -25090 0 0 {name=X_62780_ }
C {devices/lab_pin.sym} 20020 -24990 0 0 {name=p19599 lab=_74735_/X }
C {devices/lab_pin.sym} 20020 -24950 0 0 {name=p19600 lab=_83844_/Q }
C {devices/lab_pin.sym} 20020 -24910 0 0 {name=p19601 lab=_74763_/X }
C {devices/lab_pin.sym} 20020 -24870 0 0 {name=p19602 lab=_74764_/X }
C {devices/lab_pin.sym} 20020 -24830 0 0 {name=p19603 lab=_74765_/X }
C {devices/lab_pin.sym} 20180 -24910 0 1 {name=p19604 lab=_74766_/X }
C {sky130_stdcells/a2111o_4.sym} 20100 -24910 0 0 {name=X_74766_ }
C {devices/lab_pin.sym} 20060 -24750 0 0 {name=p19605 lab=_71978_/A }
C {devices/lab_pin.sym} 20140 -24750 0 1 {name=p19606 lab=_71978_/X }
C {sky130_stdcells/buf_2.sym} 20100 -24750 0 0 {name=X_71978_ }
C {devices/lab_pin.sym} 20060 -24630 0 0 {name=p19607 lab=clkbuf_3_1_0_CLK/X }
C {devices/lab_pin.sym} 20140 -24630 0 1 {name=p19608 lab=clkbuf_4_3_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 20100 -24630 0 0 {name=Xclkbuf_3_1_1_CLK }
C {devices/lab_pin.sym} 20040 -24530 0 0 {name=p19609 lab=_76501_/Y }
C {devices/lab_pin.sym} 20040 -24490 0 0 {name=p19610 lab=_76502_/Y }
C {devices/lab_pin.sym} 20040 -24450 0 0 {name=p19611 lab=_76504_/Y }
C {devices/lab_pin.sym} 20160 -24490 0 1 {name=p19612 lab=_76510_/A }
C {sky130_stdcells/or3_4.sym} 20100 -24490 0 0 {name=X_76505_ }
C {devices/lab_pin.sym} 20020 -24370 0 0 {name=p19613 lab=_49450_/Y }
C {devices/lab_pin.sym} 20020 -24330 0 0 {name=p19614 lab=_49434_/X }
C {devices/lab_pin.sym} 20020 -24290 0 0 {name=p19615 lab=_49452_/X }
C {devices/lab_pin.sym} 20180 -24330 0 1 {name=p19616 lab=_86385_/D }
C {sky130_stdcells/a21oi_4.sym} 20100 -24330 0 0 {name=X_49453_ }
C {devices/lab_pin.sym} 20060 -24190 0 0 {name=p19617 lab=_59684_/X }
C {devices/lab_pin.sym} 20140 -24190 0 1 {name=p19618 lab=_61791_/B }
C {sky130_stdcells/buf_2.sym} 20100 -24190 0 0 {name=X_61731_ }
C {devices/lab_pin.sym} 20040 -24080 0 0 {name=p19619 lab=_73717_/A }
C {devices/lab_pin.sym} 20040 -24040 0 0 {name=p19620 lab=_73717_/B }
C {devices/lab_pin.sym} 20160 -24060 0 1 {name=p19621 lab=_73717_/X }
C {sky130_stdcells/xor2_4.sym} 20100 -24060 0 0 {name=X_73717_ }
C {devices/lab_pin.sym} 20060 -23930 0 0 {name=p19622 lab=_46616_/A }
C {devices/lab_pin.sym} 20140 -23930 0 1 {name=p19623 lab=_46902_/A }
C {sky130_stdcells/buf_2.sym} 20100 -23930 0 0 {name=X_46665_ }
C {devices/lab_pin.sym} 20020 -23830 0 0 {name=p19624 lab=_46899_/X }
C {devices/lab_pin.sym} 20020 -23790 0 0 {name=p19625 lab=_70909_/A }
C {devices/lab_pin.sym} 20020 -23750 0 0 {name=p19626 lab=_70928_/Y }
C {devices/lab_pin.sym} 20180 -23790 0 1 {name=p19627 lab=_70929_/Y }
C {sky130_stdcells/o21ai_4.sym} 20100 -23790 0 0 {name=X_70929_ }
C {devices/lab_pin.sym} 20040 -23660 0 0 {name=p19628 lab=_77485_/A }
C {devices/lab_pin.sym} 20040 -23620 0 0 {name=p19629 lab=_82195_/D }
C {devices/lab_pin.sym} 20160 -23640 0 1 {name=p19630 lab=_81907_/D }
C {sky130_stdcells/xor2_4.sym} 20100 -23640 0 0 {name=X_77485_ }
C {devices/lab_pin.sym} 20020 -23550 0 0 {name=p19631 lab=_43862_/X }
C {devices/lab_pin.sym} 20020 -23510 0 0 {name=p19632 lab=_43876_/X }
C {devices/lab_pin.sym} 20020 -23470 0 0 {name=p19633 lab=_41277_/X }
C {devices/lab_pin.sym} 20020 -23430 0 0 {name=p19634 lab=_69100_/B }
C {devices/lab_pin.sym} 20020 -23390 0 0 {name=p19635 lab=_43863_/X }
C {devices/lab_pin.sym} 20180 -23470 0 1 {name=p19636 lab=_43877_/Y }
C {sky130_stdcells/o32ai_4.sym} 20100 -23470 0 0 {name=X_43877_ }
C {devices/lab_pin.sym} 20040 -23320 0 0 {name=p19637 lab=_74691_/A }
C {devices/lab_pin.sym} 20040 -23280 0 0 {name=p19638 lab=_45832_/A }
C {devices/lab_pin.sym} 20160 -23300 0 1 {name=p19639 lab=_74697_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -23300 0 0 {name=X_74697_ }
C {devices/lab_pin.sym} 20060 -23170 0 0 {name=p19640 lab=_49215_/A }
C {devices/lab_pin.sym} 20140 -23170 0 1 {name=p19641 lab=_48557_/A }
C {sky130_stdcells/buf_2.sym} 20100 -23170 0 0 {name=X_48404_ }
C {devices/lab_pin.sym} 20040 -23060 0 0 {name=p19642 lab=_79224_/A }
C {devices/lab_pin.sym} 20040 -23020 0 0 {name=p19643 lab=_79224_/B }
C {devices/lab_pin.sym} 20160 -23040 0 1 {name=p19644 lab=_79251_/A }
C {sky130_stdcells/nand2_4.sym} 20100 -23040 0 0 {name=X_79224_ }
C {devices/lab_pin.sym} 20060 -22910 0 0 {name=p19645 lab=_45395_/X }
C {devices/lab_pin.sym} 20140 -22910 0 1 {name=p19646 lab=_45616_/X }
C {sky130_stdcells/buf_2.sym} 20100 -22910 0 0 {name=X_45616_ }
C {devices/lab_pin.sym} 20020 -22810 0 0 {name=p19647 lab=_58264_/Y }
C {devices/lab_pin.sym} 20020 -22770 0 0 {name=p19648 lab=_64423_/X }
C {devices/lab_pin.sym} 20020 -22730 0 0 {name=p19649 lab=_64449_/Y }
C {devices/lab_pin.sym} 20180 -22770 0 1 {name=p19650 lab=_64450_/Y }
C {sky130_stdcells/o21ai_4.sym} 20100 -22770 0 0 {name=X_64450_ }
C {devices/lab_pin.sym} 20040 -22640 0 0 {name=p19651 lab=_81365_/Q }
C {devices/lab_pin.sym} 20040 -22600 0 0 {name=p19652 lab=_76435_/Y }
C {devices/lab_pin.sym} 20160 -22620 0 1 {name=p19653 lab=_81333_/D }
C {sky130_stdcells/xor2_4.sym} 20100 -22620 0 0 {name=X_76436_ }
C {devices/lab_pin.sym} 20020 -22530 0 0 {name=p19654 lab=_42816_/X }
C {devices/lab_pin.sym} 20020 -22490 0 0 {name=p19655 lab=_42817_/X }
C {devices/lab_pin.sym} 20020 -22450 0 0 {name=p19656 lab=_41473_/X }
C {devices/lab_pin.sym} 20020 -22410 0 0 {name=p19657 lab=_66651_/B }
C {devices/lab_pin.sym} 20020 -22370 0 0 {name=p19658 lab=_42805_/X }
C {devices/lab_pin.sym} 20180 -22450 0 1 {name=p19659 lab=_42828_/Y }
C {sky130_stdcells/o32ai_4.sym} 20100 -22450 0 0 {name=X_42828_ }
C {devices/lab_pin.sym} 20060 -22290 0 0 {name=p19660 lab=_49520_/A }
C {devices/lab_pin.sym} 20140 -22290 0 1 {name=p19661 lab=_49493_/A }
C {sky130_stdcells/buf_2.sym} 20100 -22290 0 0 {name=X_49384_ }
C {devices/lab_pin.sym} 20020 -22190 0 0 {name=p19662 lab=_61658_/X }
C {devices/lab_pin.sym} 20020 -22150 0 0 {name=p19663 lab=_61645_/X }
C {devices/lab_pin.sym} 20020 -22110 0 0 {name=p19664 lab=_61661_/Y }
C {devices/lab_pin.sym} 20180 -22150 0 1 {name=p19665 lab=_84462_/D }
C {sky130_stdcells/a21oi_4.sym} 20100 -22150 0 0 {name=X_61662_ }
C {devices/lab_pin.sym} 20020 -22030 0 0 {name=p19666 lab=_70122_/Y }
C {devices/lab_pin.sym} 20020 -21990 0 0 {name=p19667 lab=_86754_/D }
C {devices/lab_pin.sym} 20020 -21950 0 0 {name=p19668 lab=_73647_/X }
C {devices/lab_pin.sym} 20180 -21990 0 1 {name=p19669 lab=_73648_/Y }
C {sky130_stdcells/o21ai_4.sym} 20100 -21990 0 0 {name=X_73648_ }
C {devices/lab_pin.sym} 20040 -21860 0 0 {name=p19670 lab=_46491_/A }
C {devices/lab_pin.sym} 20040 -21820 0 0 {name=p19671 lab=_51394_/B }
C {devices/lab_pin.sym} 20160 -21840 0 1 {name=p19672 lab=_46596_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -21840 0 0 {name=X_46596_ }
C {devices/lab_pin.sym} 20020 -21740 0 0 {name=p19673 lab=_61364_/B }
C {devices/lab_pin.sym} 20020 -21700 0 0 {name=p19674 lab=_60834_/X }
C {devices/lab_pin.sym} 20020 -21660 0 0 {name=p19675 lab=_63399_/X }
C {devices/lab_pin.sym} 20020 -21620 0 0 {name=p19676 lab=_63400_/X }
C {devices/lab_pin.sym} 20180 -21680 0 1 {name=p19677 lab=_63401_/X }
C {sky130_stdcells/a211o_4.sym} 20100 -21680 0 0 {name=X_63401_ }
C {devices/lab_pin.sym} 20040 -21540 0 0 {name=p19678 lab=_48401_/A }
C {devices/lab_pin.sym} 20040 -21500 0 0 {name=p19679 lab=_48335_/B }
C {devices/lab_pin.sym} 20160 -21520 0 1 {name=p19680 lab=_48335_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -21520 0 0 {name=X_48335_ }
C {devices/lab_pin.sym} 20020 -21430 0 0 {name=p19681 lab=_60359_/X }
C {devices/lab_pin.sym} 20020 -21390 0 0 {name=p19682 lab=_60524_/Y }
C {devices/lab_pin.sym} 20020 -21350 0 0 {name=p19683 lab=_60392_/B }
C {devices/lab_pin.sym} 20020 -21310 0 0 {name=p19684 lab=_60598_/Y }
C {devices/lab_pin.sym} 20020 -21280 0 0 {name=p19685 lab=_60612_/Y }
C {devices/lab_pin.sym} 20180 -21350 0 1 {name=p19686 lab=_60613_/Y }
C {sky130_stdcells/a41oi_4.sym} 20100 -21350 0 0 {name=X_60613_ }
C {devices/lab_pin.sym} 20040 -21200 0 0 {name=p19687 lab=_79155_/A }
C {devices/lab_pin.sym} 20040 -21160 0 0 {name=p19688 lab=_84487_/Q }
C {devices/lab_pin.sym} 20160 -21180 0 1 {name=p19689 lab=_79155_/X }
C {sky130_stdcells/xor2_4.sym} 20100 -21180 0 0 {name=X_79155_ }
C {devices/lab_pin.sym} 20060 -21050 0 0 {name=p19690 lab=_85079_/Q }
C {devices/lab_pin.sym} 20140 -21050 0 1 {name=p19691 lab=_55520_/B }
C {sky130_stdcells/inv_2.sym} 20100 -21050 0 0 {name=X_45547_ }
C {devices/lab_pin.sym} 20060 -20930 0 0 {name=p19692 lab=_64323_/A }
C {devices/lab_pin.sym} 20140 -20930 0 1 {name=p19693 lab=_64381_/X }
C {sky130_stdcells/buf_2.sym} 20100 -20930 0 0 {name=X_64381_ }
C {devices/lab_pin.sym} 20040 -20820 0 0 {name=p19694 lab=_76366_/A }
C {devices/lab_pin.sym} 20040 -20780 0 0 {name=p19695 lab=_76366_/B }
C {devices/lab_pin.sym} 20160 -20800 0 1 {name=p19696 lab=_76368_/A }
C {sky130_stdcells/nand2_4.sym} 20100 -20800 0 0 {name=X_76367_ }
C {devices/lab_pin.sym} 20060 -20670 0 0 {name=p19697 lab=_42822_/A }
C {devices/lab_pin.sym} 20140 -20670 0 1 {name=p19698 lab=_42759_/X }
C {sky130_stdcells/buf_2.sym} 20100 -20670 0 0 {name=X_42759_ }
C {devices/lab_pin.sym} 20040 -20570 0 0 {name=p19699 lab=_61541_/A }
C {devices/lab_pin.sym} 20040 -20530 0 0 {name=p19700 lab=_61593_/B }
C {devices/lab_pin.sym} 20040 -20490 0 0 {name=p19701 lab=_61619_/C }
C {devices/lab_pin.sym} 20160 -20530 0 1 {name=p19702 lab=_61593_/Y }
C {sky130_stdcells/nand3_4.sym} 20100 -20530 0 0 {name=X_61593_ }
C {devices/lab_pin.sym} 20020 -20410 0 0 {name=p19703 lab=_73576_/X }
C {devices/lab_pin.sym} 20020 -20370 0 0 {name=p19704 lab=_73578_/X }
C {devices/lab_pin.sym} 20020 -20330 0 0 {name=p19705 lab=_73489_/X }
C {devices/lab_pin.sym} 20180 -20370 0 1 {name=p19706 lab=_73582_/A }
C {sky130_stdcells/a21o_4.sym} 20100 -20370 0 0 {name=X_73579_ }
C {devices/lab_pin.sym} 20020 -20260 0 0 {name=p19707 lab=_66117_/X }
C {devices/lab_pin.sym} 20020 -20220 0 0 {name=p19708 lab=_84979_/Q }
C {devices/lab_pin.sym} 20020 -20180 0 0 {name=p19709 lab=_66118_/X }
C {devices/lab_pin.sym} 20020 -20140 0 0 {name=p19710 lab=_66119_/X }
C {devices/lab_pin.sym} 20180 -20200 0 1 {name=p19711 lab=_66120_/X }
C {sky130_stdcells/a211o_4.sym} 20100 -20200 0 0 {name=X_66120_ }
C {devices/lab_pin.sym} 20040 -20060 0 0 {name=p19712 lab=_78130_/A }
C {devices/lab_pin.sym} 20040 -20020 0 0 {name=p19713 lab=_78105_/Y }
C {devices/lab_pin.sym} 20160 -20040 0 1 {name=p19714 lab=_78107_/B }
C {sky130_stdcells/xor2_4.sym} 20100 -20040 0 0 {name=X_78106_ }
C {devices/lab_pin.sym} 20040 -19940 0 0 {name=p19715 lab=_63289_/X }
C {devices/lab_pin.sym} 20040 -19900 0 0 {name=p19716 lab=_64536_/C }
C {devices/lab_pin.sym} 20040 -19860 0 0 {name=p19717 lab=_63341_/C }
C {devices/lab_pin.sym} 20040 -19820 0 0 {name=p19718 lab=_63332_/D }
C {devices/lab_pin.sym} 20160 -19880 0 1 {name=p19719 lab=_63332_/X }
C {sky130_stdcells/and4_4.sym} 20100 -19880 0 0 {name=X_63332_ }
C {devices/lab_pin.sym} 20020 -19750 0 0 {name=p19720 lab=_75314_/Y }
C {devices/lab_pin.sym} 20020 -19710 0 0 {name=p19721 lab=_75319_/B }
C {devices/lab_pin.sym} 20020 -19670 0 0 {name=p19722 lab=_75317_/Y }
C {devices/lab_pin.sym} 20180 -19710 0 1 {name=p19723 lab=_75318_/X }
C {sky130_stdcells/o21a_4.sym} 20100 -19710 0 0 {name=X_75318_ }
C {devices/lab_pin.sym} 20020 -19590 0 0 {name=p19724 lab=_86545_/Q }
C {devices/lab_pin.sym} 20020 -19550 0 0 {name=p19725 lab=_48263_/X }
C {devices/lab_pin.sym} 20020 -19510 0 0 {name=p19726 lab=_48265_/Y }
C {devices/lab_pin.sym} 20180 -19550 0 1 {name=p19727 lab=_48266_/Y }
C {sky130_stdcells/o21ai_4.sym} 20100 -19550 0 0 {name=X_48266_ }
C {devices/lab_pin.sym} 20020 -19450 0 0 {name=p19728 lab=_60541_/Y }
C {devices/lab_pin.sym} 20020 -19410 0 0 {name=p19729 lab=_60475_/A }
C {devices/lab_pin.sym} 20020 -19370 0 0 {name=p19730 lab=_60543_/Y }
C {devices/lab_pin.sym} 20020 -19330 0 0 {name=p19731 lab=_79143_/A }
C {devices/lab_pin.sym} 20020 -19290 0 0 {name=p19732 lab=_60341_/X }
C {devices/lab_pin.sym} 20180 -19370 0 1 {name=p19733 lab=_60544_/X }
C {sky130_stdcells/o32a_4.sym} 20100 -19370 0 0 {name=X_60544_ }
C {devices/lab_pin.sym} 20040 -19220 0 0 {name=p19734 lab=_79086_/A }
C {devices/lab_pin.sym} 20040 -19180 0 0 {name=p19735 lab=_79086_/B }
C {devices/lab_pin.sym} 20160 -19200 0 1 {name=p19736 lab=_79095_/A }
C {sky130_stdcells/xnor2_4.sym} 20100 -19200 0 0 {name=X_79086_ }
C {devices/lab_pin.sym} 20020 -19090 0 0 {name=p19737 lab=_45473_/X }
C {devices/lab_pin.sym} 20020 -19050 0 0 {name=p19738 lab=_45477_/X }
C {devices/lab_pin.sym} 20020 -19010 0 0 {name=p19739 lab=_45446_/X }
C {devices/lab_pin.sym} 20180 -19050 0 1 {name=p19740 lab=_45478_/X }
C {sky130_stdcells/a21o_4.sym} 20100 -19050 0 0 {name=X_45478_ }
C {devices/lab_pin.sym} 20040 -18920 0 0 {name=p19741 lab=_76289_/A }
C {devices/lab_pin.sym} 20040 -18880 0 0 {name=p19742 lab=_81560_/Q }
C {devices/lab_pin.sym} 20160 -18900 0 1 {name=p19743 lab=_76298_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -18900 0 0 {name=X_76298_ }
C {devices/lab_pin.sym} 20060 -18770 0 0 {name=p19744 lab=_54612_/D }
C {devices/lab_pin.sym} 20140 -18770 0 1 {name=p19745 lab=_47218_/D }
C {sky130_stdcells/buf_2.sym} 20100 -18770 0 0 {name=X_47217_ }
C {devices/lab_pin.sym} 20020 -18680 0 0 {name=p19746 lab=_65990_/X }
C {devices/lab_pin.sym} 20020 -18640 0 0 {name=p19747 lab=_86231_/Q }
C {devices/lab_pin.sym} 20020 -18600 0 0 {name=p19748 lab=_66021_/X }
C {devices/lab_pin.sym} 20020 -18560 0 0 {name=p19749 lab=_66050_/X }
C {devices/lab_pin.sym} 20180 -18620 0 1 {name=p19750 lab=_66051_/X }
C {sky130_stdcells/a211o_4.sym} 20100 -18620 0 0 {name=X_66051_ }
C {devices/lab_pin.sym} 20040 -18480 0 0 {name=p19751 lab=_78037_/A }
C {devices/lab_pin.sym} 20040 -18440 0 0 {name=p19752 lab=_78037_/B }
C {devices/lab_pin.sym} 20160 -18460 0 1 {name=p19753 lab=_82145_/D }
C {sky130_stdcells/nand2_4.sym} 20100 -18460 0 0 {name=X_78037_ }
C {devices/lab_pin.sym} 20020 -18370 0 0 {name=p19754 lab=_44425_/X }
C {devices/lab_pin.sym} 20020 -18330 0 0 {name=p19755 lab=_44427_/X }
C {devices/lab_pin.sym} 20020 -18290 0 0 {name=p19756 lab=_41574_/X }
C {devices/lab_pin.sym} 20020 -18250 0 0 {name=p19757 lab=_87113_/Q }
C {devices/lab_pin.sym} 20020 -18210 0 0 {name=p19758 lab=_44428_/X }
C {devices/lab_pin.sym} 20180 -18290 0 1 {name=p19759 lab=_44430_/A }
C {sky130_stdcells/o32ai_4.sym} 20100 -18290 0 0 {name=X_44429_ }
C {devices/lab_pin.sym} 20040 -18140 0 0 {name=p19760 lab=_75241_/Y }
C {devices/lab_pin.sym} 20040 -18100 0 0 {name=p19761 lab=_75248_/Y }
C {devices/lab_pin.sym} 20160 -18120 0 1 {name=p19762 lab=_75249_/Y }
C {sky130_stdcells/xnor2_4.sym} 20100 -18120 0 0 {name=X_75249_ }
C {devices/lab_pin.sym} 20040 -18020 0 0 {name=p19763 lab=_63203_/X }
C {devices/lab_pin.sym} 20040 -17980 0 0 {name=p19764 lab=_64467_/C }
C {devices/lab_pin.sym} 20040 -17940 0 0 {name=p19765 lab=_63204_/X }
C {devices/lab_pin.sym} 20040 -17900 0 0 {name=p19766 lab=_63332_/D }
C {devices/lab_pin.sym} 20160 -17960 0 1 {name=p19767 lab=_63263_/X }
C {sky130_stdcells/and4_4.sym} 20100 -17960 0 0 {name=X_63263_ }
C {devices/lab_pin.sym} 20020 -17830 0 0 {name=p19768 lab=_48191_/Y }
C {devices/lab_pin.sym} 20020 -17790 0 0 {name=p19769 lab=_48194_/X }
C {devices/lab_pin.sym} 20020 -17750 0 0 {name=p19770 lab=_48196_/X }
C {devices/lab_pin.sym} 20180 -17790 0 1 {name=p19771 lab=_48197_/Y }
C {sky130_stdcells/a21oi_4.sym} 20100 -17790 0 0 {name=X_48197_ }
C {devices/lab_pin.sym} 20060 -17650 0 0 {name=p19772 lab=_60475_/A }
C {devices/lab_pin.sym} 20140 -17650 0 1 {name=p19773 lab=_60586_/A }
C {sky130_stdcells/inv_2.sym} 20100 -17650 0 0 {name=X_60475_ }
C {devices/lab_pin.sym} 20040 -17540 0 0 {name=p19774 lab=_65002_/A }
C {devices/lab_pin.sym} 20040 -17500 0 0 {name=p19775 lab=_65002_/B }
C {devices/lab_pin.sym} 20160 -17520 0 1 {name=p19776 lab=_65002_/X }
C {sky130_stdcells/and2_4.sym} 20100 -17520 0 0 {name=X_65002_ }
C {devices/lab_pin.sym} 20060 -17390 0 0 {name=p19777 lab=_62214_/A }
C {devices/lab_pin.sym} 20140 -17390 0 1 {name=p19778 lab=_62214_/X }
C {sky130_stdcells/buf_2.sym} 20100 -17390 0 0 {name=X_62214_ }
C {devices/lab_pin.sym} 20060 -17270 0 0 {name=p19779 lab=_83697_/Q }
C {devices/lab_pin.sym} 20140 -17270 0 1 {name=p19780 lab=_53395_/B }
C {sky130_stdcells/inv_2.sym} 20100 -17270 0 0 {name=X_47148_ }
C {devices/lab_pin.sym} 20040 -17180 0 0 {name=p19781 lab=_63144_/X }
C {devices/lab_pin.sym} 20040 -17140 0 0 {name=p19782 lab=_84841_/Q }
C {devices/lab_pin.sym} 20040 -17100 0 0 {name=p19783 lab=_63146_/C }
C {devices/lab_pin.sym} 20040 -17060 0 0 {name=p19784 lab=_63239_/D }
C {devices/lab_pin.sym} 20160 -17120 0 1 {name=p19785 lab=_63194_/X }
C {sky130_stdcells/and4_4.sym} 20100 -17120 0 0 {name=X_63194_ }
C {devices/lab_pin.sym} 20020 -16990 0 0 {name=p19786 lab=_69806_/X }
C {devices/lab_pin.sym} 20020 -16950 0 0 {name=p19787 lab=_69809_/X }
C {devices/lab_pin.sym} 20020 -16910 0 0 {name=p19788 lab=_69768_/X }
C {devices/lab_pin.sym} 20180 -16950 0 1 {name=p19789 lab=_69810_/X }
C {sky130_stdcells/a21o_4.sym} 20100 -16950 0 0 {name=X_69810_ }
C {devices/lab_pin.sym} 20020 -16830 0 0 {name=p19790 lab=_62143_/Y }
C {devices/lab_pin.sym} 20020 -16790 0 0 {name=p19791 lab=_62101_/X }
C {devices/lab_pin.sym} 20020 -16750 0 0 {name=p19792 lab=_62144_/Y }
C {devices/lab_pin.sym} 20180 -16790 0 1 {name=p19793 lab=_62145_/Y }
C {sky130_stdcells/a21oi_4.sym} 20100 -16790 0 0 {name=X_62145_ }
C {devices/lab_pin.sym} 20040 -16660 0 0 {name=p19794 lab=_47063_/A }
C {devices/lab_pin.sym} 20040 -16620 0 0 {name=p19795 lab=_52843_/B }
C {devices/lab_pin.sym} 20160 -16640 0 1 {name=p19796 lab=_47079_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -16640 0 0 {name=X_47079_ }
C {devices/lab_pin.sym} 20040 -16520 0 0 {name=p19797 lab=_79988_/A }
C {devices/lab_pin.sym} 20040 -16480 0 0 {name=p19798 lab=_79988_/B }
C {devices/lab_pin.sym} 20160 -16500 0 1 {name=p19799 lab=_79989_/A }
C {sky130_stdcells/and2_4.sym} 20100 -16500 0 0 {name=X_79988_ }
C {devices/lab_pin.sym} 20020 -16400 0 0 {name=p19800 lab=_73104_/A }
C {devices/lab_pin.sym} 20020 -16360 0 0 {name=p19801 lab=_69690_/X }
C {devices/lab_pin.sym} 20020 -16320 0 0 {name=p19802 lab=_68473_/X }
C {devices/lab_pin.sym} 20020 -16280 0 0 {name=p19803 lab=_69740_/X }
C {devices/lab_pin.sym} 20180 -16340 0 1 {name=p19804 lab=_69741_/X }
C {sky130_stdcells/a211o_4.sym} 20100 -16340 0 0 {name=X_69741_ }
C {devices/lab_pin.sym} 20040 -16200 0 0 {name=p19805 lab=_50103_/A }
C {devices/lab_pin.sym} 20040 -16160 0 0 {name=p19806 lab=_48955_/X }
C {devices/lab_pin.sym} 20160 -16180 0 1 {name=p19807 lab=_50090_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -16180 0 0 {name=X_50090_ }
C {devices/lab_pin.sym} 20060 -16050 0 0 {name=p19808 lab=_68342_/A }
C {devices/lab_pin.sym} 20140 -16050 0 1 {name=p19809 lab=_66953_/X }
C {sky130_stdcells/buf_2.sym} 20100 -16050 0 0 {name=X_66953_ }
C {devices/lab_pin.sym} 20040 -15960 0 0 {name=p19810 lab=_63629_/B }
C {devices/lab_pin.sym} 20040 -15920 0 0 {name=p19811 lab=_61999_/B }
C {devices/lab_pin.sym} 20040 -15880 0 0 {name=p19812 lab=_62046_/C }
C {devices/lab_pin.sym} 20040 -15840 0 0 {name=p19813 lab=_62046_/D }
C {devices/lab_pin.sym} 20160 -15900 0 1 {name=p19814 lab=_62077_/D }
C {sky130_stdcells/nand4_4.sym} 20100 -15900 0 0 {name=X_62076_ }
C {devices/lab_pin.sym} 20040 -15760 0 0 {name=p19815 lab=_78939_/A }
C {devices/lab_pin.sym} 20040 -15720 0 0 {name=p19816 lab=_78939_/B }
C {devices/lab_pin.sym} 20160 -15740 0 1 {name=p19817 lab=_82704_/D }
C {sky130_stdcells/xor2_4.sym} 20100 -15740 0 0 {name=X_78939_ }
C {devices/lab_pin.sym} 20060 -15610 0 0 {name=p19818 lab=_65790_/A }
C {devices/lab_pin.sym} 20140 -15610 0 1 {name=p19819 lab=_65904_/X }
C {sky130_stdcells/buf_2.sym} 20100 -15610 0 0 {name=X_65904_ }
C {devices/lab_pin.sym} 20040 -15510 0 0 {name=p19820 lab=_60915_/A }
C {devices/lab_pin.sym} 20040 -15470 0 0 {name=p19821 lab=_60892_/Y }
C {devices/lab_pin.sym} 20040 -15430 0 0 {name=p19822 lab=_60853_/X }
C {devices/lab_pin.sym} 20160 -15470 0 1 {name=p19823 lab=_61027_/X }
C {sky130_stdcells/and3_4.sym} 20100 -15470 0 0 {name=X_61027_ }
C {devices/lab_pin.sym} 20060 -15330 0 0 {name=p19824 lab=_69733_/A }
C {devices/lab_pin.sym} 20140 -15330 0 1 {name=p19825 lab=_69672_/X }
C {sky130_stdcells/buf_2.sym} 20100 -15330 0 0 {name=X_69672_ }
C {devices/lab_pin.sym} 20010 -15210 0 0 {name=p19826 lab=_82047_/CLK }
C {devices/lab_pin.sym} 20010 -15190 0 0 {name=p19827 lab=_78013_/Y }
C {devices/lab_pin.sym} 20190 -15210 0 1 {name=p19828 lab=_77671_/A }
C {sky130_stdcells/dfxtp_4.sym} 20100 -15200 0 0 {name=X_81950_ }
C {devices/lab_pin.sym} 20060 -15070 0 0 {name=p19829 lab=clkbuf_8_240_0_CLK/X }
C {devices/lab_pin.sym} 20140 -15070 0 1 {name=p19830 lab=clkbuf_9_480_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 20100 -15070 0 0 {name=Xclkbuf_9_480_0_CLK }
C {devices/lab_pin.sym} 20040 -14960 0 0 {name=p19831 lab=_66956_/A }
C {devices/lab_pin.sym} 20040 -14920 0 0 {name=p19832 lab=_88198_/Q }
C {devices/lab_pin.sym} 20160 -14940 0 1 {name=p19833 lab=_66884_/X }
C {sky130_stdcells/and2_4.sym} 20100 -14940 0 0 {name=X_66884_ }
C {devices/lab_pin.sym} 20010 -14810 0 0 {name=p19834 lab=_82067_/CLK }
C {devices/lab_pin.sym} 20010 -14790 0 0 {name=p19835 lab=_80901_/D }
C {devices/lab_pin.sym} 20190 -14810 0 1 {name=p19836 lab=_75598_/A }
C {sky130_stdcells/dfxtp_4.sym} 20100 -14800 0 0 {name=X_80901_ }
C {devices/lab_pin.sym} 20020 -14690 0 0 {name=p19837 lab=_68620_/X }
C {devices/lab_pin.sym} 20020 -14650 0 0 {name=p19838 lab=_68622_/X }
C {devices/lab_pin.sym} 20020 -14610 0 0 {name=p19839 lab=_68477_/X }
C {devices/lab_pin.sym} 20180 -14650 0 1 {name=p19840 lab=_68623_/Y }
C {sky130_stdcells/a21oi_4.sym} 20100 -14650 0 0 {name=X_68623_ }
C {devices/lab_pin.sym} 20020 -14540 0 0 {name=p19841 lab=_64691_/X }
C {devices/lab_pin.sym} 20020 -14500 0 0 {name=p19842 lab=_86182_/Q }
C {devices/lab_pin.sym} 20020 -14460 0 0 {name=p19843 lab=_64972_/X }
C {devices/lab_pin.sym} 20020 -14420 0 0 {name=p19844 lab=_65834_/X }
C {devices/lab_pin.sym} 20180 -14480 0 1 {name=p19845 lab=_65835_/X }
C {sky130_stdcells/a211o_4.sym} 20100 -14480 0 0 {name=X_65835_ }
C {devices/lab_pin.sym} 20060 -14330 0 0 {name=p19846 lab=clkbuf_9_187_0_CLK/X }
C {devices/lab_pin.sym} 20140 -14330 0 1 {name=p19847 lab=_85433_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 20100 -14330 0 0 {name=Xclkbuf_10_374_0_CLK }
C {devices/lab_pin.sym} 20010 -14210 0 0 {name=p19848 lab=_82531_/CLK }
C {devices/lab_pin.sym} 20010 -14190 0 0 {name=p19849 lab=_78072_/X }
C {devices/lab_pin.sym} 20190 -14210 0 1 {name=p19850 lab=_81881_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -14200 0 0 {name=X_81881_ }
C {devices/lab_pin.sym} 20020 -14090 0 0 {name=p19851 lab=_85752_/Q }
C {devices/lab_pin.sym} 20020 -14050 0 0 {name=p19852 lab=_52792_/X }
C {devices/lab_pin.sym} 20020 -14010 0 0 {name=p19853 lab=_52799_/Y }
C {devices/lab_pin.sym} 20180 -14050 0 1 {name=p19854 lab=_52800_/Y }
C {sky130_stdcells/o21ai_4.sym} 20100 -14050 0 0 {name=X_52800_ }
C {devices/lab_pin.sym} 20010 -13910 0 0 {name=p19855 lab=_85561_/CLK }
C {devices/lab_pin.sym} 20010 -13890 0 0 {name=p19856 lab=_83620_/D }
C {devices/lab_pin.sym} 20190 -13910 0 1 {name=p19857 lab=_48930_/A }
C {sky130_stdcells/dfxtp_4.sym} 20100 -13900 0 0 {name=X_83620_ }
C {devices/lab_pin.sym} 20010 -13770 0 0 {name=p19858 lab=_81065_/CLK }
C {devices/lab_pin.sym} 20010 -13750 0 0 {name=p19859 lab=_83976_/Q }
C {devices/lab_pin.sym} 20190 -13770 0 1 {name=p19860 lab=_75695_/B }
C {sky130_stdcells/dfxtp_4.sym} 20100 -13760 0 0 {name=X_80832_ }
C {devices/lab_pin.sym} 20020 -13660 0 0 {name=p19861 lab=_43043_/A }
C {devices/lab_pin.sym} 20020 -13620 0 0 {name=p19862 lab=_68527_/X }
C {devices/lab_pin.sym} 20020 -13580 0 0 {name=p19863 lab=_68552_/X }
C {devices/lab_pin.sym} 20020 -13540 0 0 {name=p19864 lab=_68553_/X }
C {devices/lab_pin.sym} 20180 -13600 0 1 {name=p19865 lab=_68554_/X }
C {sky130_stdcells/a211o_4.sym} 20100 -13600 0 0 {name=X_68554_ }
C {devices/lab_pin.sym} 20040 -13460 0 0 {name=p19866 lab=_53766_/A }
C {devices/lab_pin.sym} 20040 -13420 0 0 {name=p19867 lab=_48876_/Y }
C {devices/lab_pin.sym} 20160 -13440 0 1 {name=p19868 lab=_53780_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -13440 0 0 {name=X_53780_ }
C {devices/lab_pin.sym} 20020 -13340 0 0 {name=p19869 lab=_65733_/X }
C {devices/lab_pin.sym} 20020 -13300 0 0 {name=p19870 lab=_85579_/Q }
C {devices/lab_pin.sym} 20020 -13260 0 0 {name=p19871 lab=_65734_/X }
C {devices/lab_pin.sym} 20020 -13220 0 0 {name=p19872 lab=_65765_/X }
C {devices/lab_pin.sym} 20180 -13280 0 1 {name=p19873 lab=_65766_/X }
C {sky130_stdcells/a211o_4.sym} 20100 -13280 0 0 {name=X_65766_ }
C {devices/lab_pin.sym} 20060 -13130 0 0 {name=p19874 lab=_51101_/A }
C {devices/lab_pin.sym} 20140 -13130 0 1 {name=p19875 lab=_50992_/X }
C {sky130_stdcells/buf_2.sym} 20100 -13130 0 0 {name=X_50992_ }
C {devices/lab_pin.sym} 20020 -13030 0 0 {name=p19876 lab=_62976_/X }
C {devices/lab_pin.sym} 20020 -12990 0 0 {name=p19877 lab=_62942_/X }
C {devices/lab_pin.sym} 20020 -12950 0 0 {name=p19878 lab=_62977_/Y }
C {devices/lab_pin.sym} 20180 -12990 0 1 {name=p19879 lab=_62978_/Y }
C {sky130_stdcells/a21oi_4.sym} 20100 -12990 0 0 {name=X_62978_ }
C {devices/lab_pin.sym} 20020 -12880 0 0 {name=p19880 lab=_87160_/Q }
C {devices/lab_pin.sym} 20020 -12840 0 0 {name=p19881 lab=_67432_/X }
C {devices/lab_pin.sym} 20020 -12800 0 0 {name=p19882 lab=_67433_/X }
C {devices/lab_pin.sym} 20020 -12760 0 0 {name=p19883 lab=_67504_/X }
C {devices/lab_pin.sym} 20180 -12820 0 1 {name=p19884 lab=_67506_/B }
C {sky130_stdcells/a211o_4.sym} 20100 -12820 0 0 {name=X_67505_ }
C {devices/lab_pin.sym} 20020 -12690 0 0 {name=p19885 lab=_52727_/Y }
C {devices/lab_pin.sym} 20020 -12650 0 0 {name=p19886 lab=_52728_/X }
C {devices/lab_pin.sym} 20020 -12610 0 0 {name=p19887 lab=_52730_/X }
C {devices/lab_pin.sym} 20180 -12650 0 1 {name=p19888 lab=_52731_/Y }
C {sky130_stdcells/a21oi_4.sym} 20100 -12650 0 0 {name=X_52731_ }
C {devices/lab_pin.sym} 20060 -12510 0 0 {name=p19889 lab=clkbuf_9_495_0_CLK/A }
C {devices/lab_pin.sym} 20140 -12510 0 1 {name=p19890 lab=clkbuf_9_495_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 20100 -12510 0 0 {name=Xclkbuf_9_495_0_CLK }
C {devices/lab_pin.sym} 20060 -12390 0 0 {name=p19891 lab=_64717_/A }
C {devices/lab_pin.sym} 20140 -12390 0 1 {name=p19892 lab=_64903_/A }
C {sky130_stdcells/buf_2.sym} 20100 -12390 0 0 {name=X_64717_ }
C {devices/lab_pin.sym} 20010 -12270 0 0 {name=p19893 lab=_83550_/CLK }
C {devices/lab_pin.sym} 20010 -12250 0 0 {name=p19894 lab=_83551_/D }
C {devices/lab_pin.sym} 20190 -12270 0 1 {name=p19895 lab=_47694_/A }
C {sky130_stdcells/dfxtp_4.sym} 20100 -12260 0 0 {name=X_83551_ }
C {devices/lab_pin.sym} 20040 -12160 0 0 {name=p19896 lab=_61915_/A }
C {devices/lab_pin.sym} 20040 -12120 0 0 {name=p19897 lab=_61915_/B }
C {devices/lab_pin.sym} 20040 -12080 0 0 {name=p19898 lab=_63520_/B }
C {devices/lab_pin.sym} 20040 -12040 0 0 {name=p19899 lab=_61915_/D }
C {devices/lab_pin.sym} 20160 -12100 0 1 {name=p19900 lab=_61929_/X }
C {sky130_stdcells/and4_4.sym} 20100 -12100 0 0 {name=X_61929_ }
C {devices/lab_pin.sym} 20010 -11950 0 0 {name=p19901 lab=_80854_/CLK }
C {devices/lab_pin.sym} 20010 -11930 0 0 {name=p19902 lab=_80763_/D }
C {devices/lab_pin.sym} 20190 -11950 0 1 {name=p19903 lab=_80763_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -11940 0 0 {name=X_80763_ }
C {devices/lab_pin.sym} 20040 -11820 0 0 {name=p19904 lab=_68409_/A }
C {devices/lab_pin.sym} 20040 -11780 0 0 {name=p19905 lab=_68485_/B }
C {devices/lab_pin.sym} 20160 -11800 0 1 {name=p19906 lab=_68485_/X }
C {sky130_stdcells/and2_4.sym} 20100 -11800 0 0 {name=X_68485_ }
C {devices/lab_pin.sym} 20060 -11670 0 0 {name=p19907 lab=_65929_/A }
C {devices/lab_pin.sym} 20140 -11670 0 1 {name=p19908 lab=_65775_/B }
C {sky130_stdcells/buf_2.sym} 20100 -11670 0 0 {name=X_65697_ }
C {devices/lab_pin.sym} 20010 -11550 0 0 {name=p19909 lab=_82675_/CLK }
C {devices/lab_pin.sym} 20010 -11530 0 0 {name=p19910 lab=_78839_/X }
C {devices/lab_pin.sym} 20190 -11550 0 1 {name=p19911 lab=_78370_/A }
C {sky130_stdcells/dfxtp_4.sym} 20100 -11540 0 0 {name=X_82502_ }
C {devices/lab_pin.sym} 20060 -11410 0 0 {name=p19912 lab=clkbuf_9_194_0_CLK/X }
C {devices/lab_pin.sym} 20140 -11410 0 1 {name=p19913 lab=_83227_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 20100 -11410 0 0 {name=Xclkbuf_10_389_0_CLK }
C {devices/lab_pin.sym} 20020 -11310 0 0 {name=p19914 lab=_55330_/X }
C {devices/lab_pin.sym} 20020 -11270 0 0 {name=p19915 lab=_55448_/Y }
C {devices/lab_pin.sym} 20020 -11230 0 0 {name=p19916 lab=_55449_/Y }
C {devices/lab_pin.sym} 20180 -11270 0 1 {name=p19917 lab=_55451_/B }
C {sky130_stdcells/o21a_4.sym} 20100 -11270 0 0 {name=X_55450_ }
C {devices/lab_pin.sym} 20040 -11140 0 0 {name=p19918 lab=_67436_/A }
C {devices/lab_pin.sym} 20040 -11100 0 0 {name=p19919 lab=_67435_/X }
C {devices/lab_pin.sym} 20160 -11120 0 1 {name=p19920 lab=_67436_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -11120 0 0 {name=X_67436_ }
C {devices/lab_pin.sym} 20010 -10990 0 0 {name=p19921 lab=_85561_/CLK }
C {devices/lab_pin.sym} 20010 -10970 0 0 {name=p19922 lab=_86270_/D }
C {devices/lab_pin.sym} 20190 -10990 0 1 {name=p19923 lab=_86270_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -10980 0 0 {name=X_86270_ }
C {devices/lab_pin.sym} 20020 -10870 0 0 {name=p19924 lab=_52659_/Y }
C {devices/lab_pin.sym} 20020 -10830 0 0 {name=p19925 lab=_52647_/X }
C {devices/lab_pin.sym} 20020 -10790 0 0 {name=p19926 lab=_52661_/X }
C {devices/lab_pin.sym} 20180 -10830 0 1 {name=p19927 lab=_52662_/Y }
C {sky130_stdcells/a21oi_4.sym} 20100 -10830 0 0 {name=X_52662_ }
C {devices/lab_pin.sym} 20020 -10720 0 0 {name=p19928 lab=_64577_/X }
C {devices/lab_pin.sym} 20020 -10680 0 0 {name=p19929 lab=_86751_/Q }
C {devices/lab_pin.sym} 20020 -10640 0 0 {name=p19930 lab=_64579_/X }
C {devices/lab_pin.sym} 20020 -10600 0 0 {name=p19931 lab=_64647_/X }
C {devices/lab_pin.sym} 20180 -10660 0 1 {name=p19932 lab=_64648_/X }
C {sky130_stdcells/a211o_4.sym} 20100 -10660 0 0 {name=X_64648_ }
C {devices/lab_pin.sym} 20010 -10510 0 0 {name=p19933 lab=_83482_/CLK }
C {devices/lab_pin.sym} 20010 -10490 0 0 {name=p19934 lab=_83482_/D }
C {devices/lab_pin.sym} 20190 -10510 0 1 {name=p19935 lab=_83482_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -10500 0 0 {name=X_83482_ }
C {devices/lab_pin.sym} 20010 -10370 0 0 {name=p19936 lab=_81104_/CLK }
C {devices/lab_pin.sym} 20010 -10350 0 0 {name=p19937 lab=_80694_/D }
C {devices/lab_pin.sym} 20190 -10370 0 1 {name=p19938 lab=_80694_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -10360 0 0 {name=X_80694_ }
C {devices/lab_pin.sym} 20060 -10230 0 0 {name=p19939 lab=_54401_/A }
C {devices/lab_pin.sym} 20140 -10230 0 1 {name=p19940 lab=_54402_/C }
C {sky130_stdcells/buf_2.sym} 20100 -10230 0 0 {name=X_54401_ }
C {devices/lab_pin.sym} 20010 -10110 0 0 {name=p19941 lab=_85221_/CLK }
C {devices/lab_pin.sym} 20010 -10090 0 0 {name=p19942 lab=_85221_/D }
C {devices/lab_pin.sym} 20190 -10110 0 1 {name=p19943 lab=_55730_/B }
C {sky130_stdcells/dfxtp_4.sym} 20100 -10100 0 0 {name=X_85221_ }
C {devices/lab_pin.sym} 20060 -9970 0 0 {name=p19944 lab=_51639_/A }
C {devices/lab_pin.sym} 20140 -9970 0 1 {name=p19945 lab=_51613_/X }
C {sky130_stdcells/buf_2.sym} 20100 -9970 0 0 {name=X_51613_ }
C {devices/lab_pin.sym} 20010 -9850 0 0 {name=p19946 lab=_82248_/CLK }
C {devices/lab_pin.sym} 20010 -9830 0 0 {name=p19947 lab=_82465_/Q }
C {devices/lab_pin.sym} 20190 -9850 0 1 {name=p19948 lab=_82433_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -9840 0 0 {name=X_82433_ }
C {devices/lab_pin.sym} 20040 -9720 0 0 {name=p19949 lab=_55316_/X }
C {devices/lab_pin.sym} 20040 -9680 0 0 {name=p19950 lab=_55328_/C }
C {devices/lab_pin.sym} 20160 -9700 0 1 {name=p19951 lab=_55382_/A }
C {sky130_stdcells/and2_4.sym} 20100 -9700 0 0 {name=X_55381_ }
C {devices/lab_pin.sym} 20040 -9580 0 0 {name=p19952 lab=_67367_/A }
C {devices/lab_pin.sym} 20040 -9540 0 0 {name=p19953 lab=_67366_/X }
C {devices/lab_pin.sym} 20160 -9560 0 1 {name=p19954 lab=_67367_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -9560 0 0 {name=X_67367_ }
C {sky130_stdcells/decap_3.sym} 20100 -9400 0 0 {name=XPHY_706 }
C {devices/lab_pin.sym} 20060 -9250 0 0 {name=p19955 lab=_52593_/A }
C {devices/lab_pin.sym} 20140 -9250 0 1 {name=p19956 lab=_52614_/A }
C {sky130_stdcells/buf_2.sym} 20100 -9250 0 0 {name=X_52593_ }
C {devices/lab_pin.sym} 20060 -9130 0 0 {name=p19957 lab=_64772_/A }
C {devices/lab_pin.sym} 20140 -9130 0 1 {name=p19958 lab=_64579_/X }
C {sky130_stdcells/buf_2.sym} 20100 -9130 0 0 {name=X_64579_ }
C {sky130_stdcells/decap_3.sym} 20100 -8980 0 0 {name=XPHY_717 }
C {devices/lab_pin.sym} 20020 -8860 0 0 {name=p19959 lab=_57109_/X }
C {devices/lab_pin.sym} 20020 -8820 0 0 {name=p19960 lab=_56639_/X }
C {devices/lab_pin.sym} 20020 -8780 0 0 {name=p19961 lab=_45595_/A }
C {devices/lab_pin.sym} 20020 -8740 0 0 {name=p19962 lab=_57110_/X }
C {devices/lab_pin.sym} 20180 -8800 0 1 {name=p19963 lab=_85076_/D }
C {sky130_stdcells/a2bb2o_4.sym} 20100 -8800 0 0 {name=X_57120_ }
C {devices/lab_pin.sym} 20020 -8670 0 0 {name=p19964 lab=_69102_/X }
C {devices/lab_pin.sym} 20020 -8630 0 0 {name=p19965 lab=_69105_/X }
C {devices/lab_pin.sym} 20020 -8590 0 0 {name=p19966 lab=_69017_/X }
C {devices/lab_pin.sym} 20180 -8630 0 1 {name=p19967 lab=_69106_/Y }
C {sky130_stdcells/a21oi_4.sym} 20100 -8630 0 0 {name=X_69106_ }
C {devices/lab_pin.sym} 20040 -8500 0 0 {name=p19968 lab=_54332_/A }
C {devices/lab_pin.sym} 20040 -8460 0 0 {name=p19969 lab=_54332_/B }
C {devices/lab_pin.sym} 20160 -8480 0 1 {name=p19970 lab=_54332_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -8480 0 0 {name=X_54332_ }
C {devices/lab_pin.sym} 20060 -8350 0 0 {name=p19971 lab=_65307_/A }
C {devices/lab_pin.sym} 20140 -8350 0 1 {name=p19972 lab=_66318_/X }
C {sky130_stdcells/buf_2.sym} 20100 -8350 0 0 {name=X_66318_ }
C {devices/lab_pin.sym} 20010 -8230 0 0 {name=p19973 lab=_85152_/CLK }
C {devices/lab_pin.sym} 20010 -8210 0 0 {name=p19974 lab=_56573_/X }
C {devices/lab_pin.sym} 20190 -8230 0 1 {name=p19975 lab=_85152_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -8220 0 0 {name=X_85152_ }
C {devices/lab_pin.sym} 20020 -8110 0 0 {name=p19976 lab=_51542_/Y }
C {devices/lab_pin.sym} 20020 -8070 0 0 {name=p19977 lab=_51531_/X }
C {devices/lab_pin.sym} 20020 -8030 0 0 {name=p19978 lab=_51543_/X }
C {devices/lab_pin.sym} 20180 -8070 0 1 {name=p19979 lab=_85991_/D }
C {sky130_stdcells/a21oi_4.sym} 20100 -8070 0 0 {name=X_51544_ }
C {devices/lab_pin.sym} 20010 -7930 0 0 {name=p19980 lab=_82925_/CLK }
C {devices/lab_pin.sym} 20010 -7910 0 0 {name=p19981 lab=_77007_/X }
C {devices/lab_pin.sym} 20190 -7930 0 1 {name=p19982 lab=_47893_/A }
C {sky130_stdcells/dfxtp_4.sym} 20100 -7920 0 0 {name=X_82364_ }
C {devices/lab_pin.sym} 20060 -7790 0 0 {name=p19983 lab=clkbuf_9_156_0_CLK/X }
C {devices/lab_pin.sym} 20140 -7790 0 1 {name=p19984 lab=_83380_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 20100 -7790 0 0 {name=Xclkbuf_10_312_0_CLK }
C {devices/lab_pin.sym} 20020 -7690 0 0 {name=p19985 lab=_67295_/X }
C {devices/lab_pin.sym} 20020 -7650 0 0 {name=p19986 lab=_67297_/X }
C {devices/lab_pin.sym} 20020 -7610 0 0 {name=p19987 lab=_67204_/X }
C {devices/lab_pin.sym} 20180 -7650 0 1 {name=p19988 lab=_67298_/X }
C {sky130_stdcells/a21o_4.sym} 20100 -7650 0 0 {name=X_67298_ }
C {devices/lab_pin.sym} 20010 -7510 0 0 {name=p19989 lab=_81169_/CLK }
C {devices/lab_pin.sym} 20010 -7490 0 0 {name=p19990 lab=_84103_/D }
C {devices/lab_pin.sym} 20190 -7510 0 1 {name=p19991 lab=_80927_/D }
C {sky130_stdcells/dfxtp_4.sym} 20100 -7500 0 0 {name=X_84103_ }
C {devices/lab_pin.sym} 20010 -7370 0 0 {name=p19992 lab=_84079_/CLK }
C {devices/lab_pin.sym} 20010 -7350 0 0 {name=p19993 lab=_76170_/X }
C {devices/lab_pin.sym} 20190 -7370 0 1 {name=p19994 lab=_81723_/D }
C {sky130_stdcells/dfxtp_4.sym} 20100 -7360 0 0 {name=X_81315_ }
C {devices/lab_pin.sym} 20060 -7230 0 0 {name=p19995 lab=_57051_/A }
C {devices/lab_pin.sym} 20140 -7230 0 1 {name=p19996 lab=_57051_/Y }
C {sky130_stdcells/inv_2.sym} 20100 -7230 0 0 {name=X_57051_ }
C {devices/lab_pin.sym} 20040 -7120 0 0 {name=p19997 lab=_69059_/A }
C {devices/lab_pin.sym} 20040 -7080 0 0 {name=p19998 lab=_88248_/Q }
C {devices/lab_pin.sym} 20160 -7100 0 1 {name=p19999 lab=_69037_/X }
C {sky130_stdcells/and2_4.sym} 20100 -7100 0 0 {name=X_69037_ }
C {devices/lab_pin.sym} 20060 -6970 0 0 {name=p20000 lab=clkbuf_9_471_0_CLK/X }
C {devices/lab_pin.sym} 20140 -6970 0 1 {name=p20001 lab=_88060_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 20100 -6970 0 0 {name=Xclkbuf_10_942_0_CLK }
C {devices/lab_pin.sym} 20060 -6850 0 0 {name=p20002 lab=_54316_/A }
C {devices/lab_pin.sym} 20140 -6850 0 1 {name=p20003 lab=_54286_/A }
C {sky130_stdcells/buf_2.sym} 20100 -6850 0 0 {name=X_54263_ }
C {devices/lab_pin.sym} 20040 -6740 0 0 {name=p20004 lab=_66181_/A }
C {devices/lab_pin.sym} 20040 -6700 0 0 {name=p20005 lab=_74127_/B }
C {devices/lab_pin.sym} 20160 -6720 0 1 {name=p20006 lab=_66249_/X }
C {sky130_stdcells/and2_4.sym} 20100 -6720 0 0 {name=X_66249_ }
C {devices/lab_pin.sym} 20010 -6590 0 0 {name=p20007 lab=_85083_/CLK }
C {devices/lab_pin.sym} 20010 -6570 0 0 {name=p20008 lab=_85083_/D }
C {devices/lab_pin.sym} 20190 -6590 0 1 {name=p20009 lab=_85083_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -6580 0 0 {name=X_85083_ }
C {devices/lab_pin.sym} 20040 -6460 0 0 {name=p20010 lab=_51481_/A }
C {devices/lab_pin.sym} 20040 -6420 0 0 {name=p20011 lab=_52999_/B }
C {devices/lab_pin.sym} 20160 -6440 0 1 {name=p20012 lab=_51475_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -6440 0 0 {name=X_51475_ }
C {devices/lab_pin.sym} 20010 -6310 0 0 {name=p20013 lab=_82103_/CLK }
C {devices/lab_pin.sym} 20010 -6290 0 0 {name=p20014 lab=_77157_/B }
C {devices/lab_pin.sym} 20190 -6310 0 1 {name=p20015 lab=_82295_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -6300 0 0 {name=X_82295_ }
C {devices/lab_pin.sym} 20060 -6170 0 0 {name=p20016 lab=_56002_/A }
C {devices/lab_pin.sym} 20140 -6170 0 1 {name=p20017 lab=_56002_/Y }
C {sky130_stdcells/inv_2.sym} 20100 -6170 0 0 {name=X_56002_ }
C {devices/lab_pin.sym} 20020 -6070 0 0 {name=p20018 lab=_85675_/Q }
C {devices/lab_pin.sym} 20020 -6030 0 0 {name=p20019 lab=_53198_/X }
C {devices/lab_pin.sym} 20020 -5990 0 0 {name=p20020 lab=_53213_/Y }
C {devices/lab_pin.sym} 20180 -6030 0 1 {name=p20021 lab=_53214_/Y }
C {sky130_stdcells/o21ai_4.sym} 20100 -6030 0 0 {name=X_53214_ }
C {devices/lab_pin.sym} 20010 -5890 0 0 {name=p20022 lab=_81160_/CLK }
C {devices/lab_pin.sym} 20010 -5870 0 0 {name=p20023 lab=_68119_/X }
C {devices/lab_pin.sym} 20190 -5890 0 1 {name=p20024 lab=_82074_/D }
C {sky130_stdcells/dfxtp_4.sym} 20100 -5880 0 0 {name=X_84034_ }
C {devices/lab_pin.sym} 20020 -5770 0 0 {name=p20025 lab=_50424_/Y }
C {devices/lab_pin.sym} 20020 -5730 0 0 {name=p20026 lab=_50395_/X }
C {devices/lab_pin.sym} 20020 -5690 0 0 {name=p20027 lab=_50425_/X }
C {devices/lab_pin.sym} 20180 -5730 0 1 {name=p20028 lab=_86203_/D }
C {sky130_stdcells/a21oi_4.sym} 20100 -5730 0 0 {name=X_50426_ }
C {devices/lab_pin.sym} 20060 -5590 0 0 {name=p20029 lab=clkbuf_8_216_0_CLK/X }
C {devices/lab_pin.sym} 20140 -5590 0 1 {name=p20030 lab=clkbuf_9_433_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 20100 -5590 0 0 {name=Xclkbuf_9_433_0_CLK }
C {devices/lab_pin.sym} 20010 -5470 0 0 {name=p20031 lab=_85378_/CLK }
C {devices/lab_pin.sym} 20010 -5450 0 0 {name=p20032 lab=_81054_/Q }
C {devices/lab_pin.sym} 20190 -5470 0 1 {name=p20033 lab=_81246_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -5460 0 0 {name=X_81246_ }
C {devices/lab_pin.sym} 20060 -5330 0 0 {name=p20034 lab=_54194_/A }
C {devices/lab_pin.sym} 20140 -5330 0 1 {name=p20035 lab=_54215_/A }
C {sky130_stdcells/buf_2.sym} 20100 -5330 0 0 {name=X_54194_ }
C {devices/lab_pin.sym} 20060 -5210 0 0 {name=p20036 lab=_86505_/CLK }
C {devices/lab_pin.sym} 20140 -5210 0 1 {name=p20037 lab=_86473_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 20100 -5210 0 0 {name=Xclkbuf_opt_25_CLK }
C {devices/lab_pin.sym} 20060 -5090 0 0 {name=p20038 lab=clkbuf_9_163_0_CLK/X }
C {devices/lab_pin.sym} 20140 -5090 0 1 {name=p20039 lab=_86342_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 20100 -5090 0 0 {name=Xclkbuf_10_327_0_CLK }
C {devices/lab_pin.sym} 20020 -4990 0 0 {name=p20040 lab=_53142_/Y }
C {devices/lab_pin.sym} 20020 -4950 0 0 {name=p20041 lab=_53137_/X }
C {devices/lab_pin.sym} 20020 -4910 0 0 {name=p20042 lab=_53144_/X }
C {devices/lab_pin.sym} 20180 -4950 0 1 {name=p20043 lab=_53145_/Y }
C {sky130_stdcells/a21oi_4.sym} 20100 -4950 0 0 {name=X_53145_ }
C {devices/lab_pin.sym} 20020 -4830 0 0 {name=p20044 lab=_50355_/Y }
C {devices/lab_pin.sym} 20020 -4790 0 0 {name=p20045 lab=_50351_/X }
C {devices/lab_pin.sym} 20020 -4750 0 0 {name=p20046 lab=_50356_/Y }
C {devices/lab_pin.sym} 20180 -4790 0 1 {name=p20047 lab=_50357_/Y }
C {sky130_stdcells/a21boi_4.sym} 20100 -4790 0 0 {name=X_50357_ }
C {devices/lab_pin.sym} 20010 -4650 0 0 {name=p20048 lab=_86758_/CLK }
C {devices/lab_pin.sym} 20010 -4630 0 0 {name=p20049 lab=_75014_/B }
C {devices/lab_pin.sym} 20190 -4650 0 1 {name=p20050 lab=_81177_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -4640 0 0 {name=X_81177_ }
C {devices/lab_pin.sym} 20060 -4510 0 0 {name=p20051 lab=clkbuf_9_478_0_CLK/X }
C {devices/lab_pin.sym} 20140 -4510 0 1 {name=p20052 lab=_85895_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 20100 -4510 0 0 {name=Xclkbuf_10_957_0_CLK }
C {devices/lab_pin.sym} 20020 -4410 0 0 {name=p20053 lab=_80114_/Y }
C {devices/lab_pin.sym} 20020 -4370 0 0 {name=p20054 lab=_80119_/Y }
C {devices/lab_pin.sym} 20020 -4330 0 0 {name=p20055 lab=_80127_/X }
C {devices/lab_pin.sym} 20180 -4370 0 1 {name=p20056 lab=_80129_/B }
C {sky130_stdcells/o21ai_4.sym} 20100 -4370 0 0 {name=X_80128_ }
C {devices/lab_pin.sym} 20060 -4230 0 0 {name=p20057 lab=_41090_/A }
C {devices/lab_pin.sym} 20140 -4230 0 1 {name=p20058 lab=_41090_/Y }
C {sky130_stdcells/inv_2.sym} 20100 -4230 0 0 {name=X_41090_ }
C {devices/lab_pin.sym} 20060 -4110 0 0 {name=p20059 lab=_64621_/A }
C {devices/lab_pin.sym} 20140 -4110 0 1 {name=p20060 lab=_58721_/A }
C {sky130_stdcells/buf_2.sym} 20100 -4110 0 0 {name=X_57953_ }
C {devices/lab_pin.sym} 20040 -4000 0 0 {name=p20061 lab=_53080_/A }
C {devices/lab_pin.sym} 20040 -3960 0 0 {name=p20062 lab=_53076_/B }
C {devices/lab_pin.sym} 20160 -3980 0 1 {name=p20063 lab=_53076_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -3980 0 0 {name=X_53076_ }
C {devices/lab_pin.sym} 20060 -3850 0 0 {name=p20064 lab=_70001_/A }
C {devices/lab_pin.sym} 20140 -3850 0 1 {name=p20065 lab=_69939_/X }
C {sky130_stdcells/buf_2.sym} 20100 -3850 0 0 {name=X_69939_ }
C {devices/lab_pin.sym} 20020 -3750 0 0 {name=p20066 lab=_50286_/Y }
C {devices/lab_pin.sym} 20020 -3710 0 0 {name=p20067 lab=_50274_/X }
C {devices/lab_pin.sym} 20020 -3670 0 0 {name=p20068 lab=_50287_/Y }
C {devices/lab_pin.sym} 20180 -3710 0 1 {name=p20069 lab=_86231_/D }
C {sky130_stdcells/a21boi_4.sym} 20100 -3710 0 0 {name=X_50288_ }
C {devices/lab_pin.sym} 20010 -3570 0 0 {name=p20070 lab=_85697_/CLK }
C {devices/lab_pin.sym} 20010 -3550 0 0 {name=p20071 lab=_51576_/Y }
C {devices/lab_pin.sym} 20190 -3570 0 1 {name=p20072 lab=_85985_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -3560 0 0 {name=X_85985_ }
C {devices/lab_pin.sym} 20060 -3430 0 0 {name=p20073 lab=clkbuf_8_224_0_CLK/X }
C {devices/lab_pin.sym} 20140 -3430 0 1 {name=p20074 lab=clkbuf_9_448_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 20100 -3430 0 0 {name=Xclkbuf_9_448_0_CLK }
C {devices/lab_pin.sym} 20040 -3320 0 0 {name=p20075 lab=_52027_/A }
C {devices/lab_pin.sym} 20040 -3280 0 0 {name=p20076 lab=_48024_/B }
C {devices/lab_pin.sym} 20160 -3300 0 1 {name=p20077 lab=_52027_/Y }
C {sky130_stdcells/nand2_4.sym} 20100 -3300 0 0 {name=X_52027_ }
C {devices/lab_pin.sym} 20020 -3200 0 0 {name=p20078 lab=_56647_/X }
C {devices/lab_pin.sym} 20020 -3160 0 0 {name=p20079 lab=_56898_/Y }
C {devices/lab_pin.sym} 20020 -3120 0 0 {name=p20080 lab=_56725_/B }
C {devices/lab_pin.sym} 20020 -3080 0 0 {name=p20081 lab=_56903_/X }
C {devices/lab_pin.sym} 20180 -3140 0 1 {name=p20082 lab=_85124_/D }
C {sky130_stdcells/a2bb2o_4.sym} 20100 -3140 0 0 {name=X_56904_ }
C {devices/lab_pin.sym} 20010 -2990 0 0 {name=p20083 lab=_87708_/CLK }
C {devices/lab_pin.sym} 20010 -2970 0 0 {name=p20084 lab=_87724_/D }
C {devices/lab_pin.sym} 20190 -2990 0 1 {name=p20085 lab=_87724_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -2980 0 0 {name=X_87724_ }
C {devices/lab_pin.sym} 20060 -2850 0 0 {name=p20086 lab=_72949_/X }
C {devices/lab_pin.sym} 20140 -2850 0 1 {name=p20087 lab=_72951_/A }
C {sky130_stdcells/buf_2.sym} 20100 -2850 0 0 {name=X_72950_ }
C {devices/lab_pin.sym} 20010 -2730 0 0 {name=p20088 lab=_86317_/CLK }
C {devices/lab_pin.sym} 20010 -2710 0 0 {name=p20089 lab=_57970_/Y }
C {devices/lab_pin.sym} 20190 -2730 0 1 {name=p20090 lab=_84936_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -2720 0 0 {name=X_84936_ }
C {devices/lab_pin.sym} 20040 -2600 0 0 {name=p20091 lab=_84935_/Q }
C {devices/lab_pin.sym} 20040 -2560 0 0 {name=p20092 lab=_65713_/C }
C {devices/lab_pin.sym} 20160 -2580 0 1 {name=p20093 lab=_80059_/X }
C {sky130_stdcells/xor2_4.sym} 20100 -2580 0 0 {name=X_80059_ }
C {devices/lab_pin.sym} 20060 -2450 0 0 {name=p20094 lab=_45926_/X }
C {devices/lab_pin.sym} 20140 -2450 0 1 {name=p20095 lab=_57884_/X }
C {sky130_stdcells/buf_2.sym} 20100 -2450 0 0 {name=X_57884_ }
C {devices/lab_pin.sym} 20020 -2350 0 0 {name=p20096 lab=_56857_/X }
C {devices/lab_pin.sym} 20020 -2310 0 0 {name=p20097 lab=_71892_/X }
C {devices/lab_pin.sym} 20020 -2270 0 0 {name=p20098 lab=_71900_/Y }
C {devices/lab_pin.sym} 20180 -2310 0 1 {name=p20099 lab=_71901_/Y }
C {sky130_stdcells/o21ai_4.sym} 20100 -2310 0 0 {name=X_71901_ }
C {devices/lab_pin.sym} 20060 -2170 0 0 {name=p20100 lab=_60615_/A }
C {devices/lab_pin.sym} 20140 -2170 0 1 {name=p20101 lab=_59753_/B }
C {sky130_stdcells/buf_2.sym} 20100 -2170 0 0 {name=X_59623_ }
C {devices/lab_pin.sym} 20060 -2050 0 0 {name=p20102 lab=_56660_/A }
C {devices/lab_pin.sym} 20140 -2050 0 1 {name=p20103 lab=_56866_/A }
C {sky130_stdcells/buf_2.sym} 20100 -2050 0 0 {name=X_56835_ }
C {devices/lab_pin.sym} 20010 -1930 0 0 {name=p20104 lab=_86932_/CLK }
C {devices/lab_pin.sym} 20010 -1910 0 0 {name=p20105 lab=_42912_/X }
C {devices/lab_pin.sym} 20190 -1930 0 1 {name=p20106 lab=_87655_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -1920 0 0 {name=X_87655_ }
C {devices/lab_pin.sym} 20040 -1800 0 0 {name=p20107 lab=_72881_/A }
C {devices/lab_pin.sym} 20040 -1760 0 0 {name=p20108 lab=_86525_/Q }
C {devices/lab_pin.sym} 20160 -1780 0 1 {name=p20109 lab=_72881_/X }
C {sky130_stdcells/and2_4.sym} 20100 -1780 0 0 {name=X_72881_ }
C {devices/lab_pin.sym} 20010 -1650 0 0 {name=p20110 lab=_84250_/CLK }
C {devices/lab_pin.sym} 20010 -1630 0 0 {name=p20111 lab=_84867_/D }
C {devices/lab_pin.sym} 20190 -1650 0 1 {name=p20112 lab=_84867_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -1640 0 0 {name=X_84867_ }
C {devices/lab_pin.sym} 20020 -1540 0 0 {name=p20113 lab=_41059_/X }
C {devices/lab_pin.sym} 20020 -1500 0 0 {name=p20114 lab=_43770_/X }
C {devices/lab_pin.sym} 20020 -1460 0 0 {name=p20115 lab=_69443_/B }
C {devices/lab_pin.sym} 20020 -1420 0 0 {name=p20116 lab=_43772_/X }
C {devices/lab_pin.sym} 20180 -1480 0 1 {name=p20117 lab=_43800_/X }
C {sky130_stdcells/a2bb2o_4.sym} 20100 -1480 0 0 {name=X_43800_ }
C {devices/lab_pin.sym} 20020 -1350 0 0 {name=p20118 lab=_45331_/Y }
C {devices/lab_pin.sym} 20020 -1310 0 0 {name=p20119 lab=_74612_/X }
C {devices/lab_pin.sym} 20020 -1270 0 0 {name=p20120 lab=_74619_/X }
C {devices/lab_pin.sym} 20180 -1310 0 1 {name=p20121 lab=_83013_/D }
C {sky130_stdcells/o21ai_4.sym} 20100 -1310 0 0 {name=X_74620_ }
C {devices/lab_pin.sym} 20010 -1170 0 0 {name=p20122 lab=_86610_/CLK }
C {devices/lab_pin.sym} 20010 -1150 0 0 {name=p20123 lab=_86606_/D }
C {devices/lab_pin.sym} 20190 -1170 0 1 {name=p20124 lab=_86606_/Q }
C {sky130_stdcells/dfxtp_4.sym} 20100 -1160 0 0 {name=X_86606_ }
C {devices/lab_pin.sym} 20020 -1050 0 0 {name=p20125 lab=_71825_/X }
C {devices/lab_pin.sym} 20020 -1010 0 0 {name=p20126 lab=_83360_/Q }
C {devices/lab_pin.sym} 20020 -970 0 0 {name=p20127 lab=_71831_/X }
C {devices/lab_pin.sym} 20180 -1010 0 1 {name=p20128 lab=_83360_/D }
C {sky130_stdcells/a21o_4.sym} 20100 -1010 0 0 {name=X_71832_ }
C {devices/lab_pin.sym} 20040 -880 0 0 {name=p20129 lab=_59520_/A }
C {devices/lab_pin.sym} 20040 -840 0 0 {name=p20130 lab=_59535_/A }
C {devices/lab_pin.sym} 20160 -860 0 1 {name=p20131 lab=_59602_/A }
C {sky130_stdcells/and2_4.sym} 20100 -860 0 0 {name=X_59554_ }
C {devices/lab_pin.sym} 20010 -730 0 0 {name=p20132 lab=_83842_/CLK }
C {devices/lab_pin.sym} 20010 -710 0 0 {name=p20133 lab=_70266_/X }
C {devices/lab_pin.sym} 20190 -730 0 1 {name=p20134 lab=_74720_/B }
C {sky130_stdcells/dfxtp_4.sym} 20100 -720 0 0 {name=X_83818_ }
C {devices/lab_pin.sym} 20940 -42190 0 0 {name=p20135 lab=_44766_/X }
C {devices/lab_pin.sym} 20940 -42150 0 0 {name=p20136 lab=_44767_/X }
C {devices/lab_pin.sym} 20940 -42110 0 0 {name=p20137 lab=_41376_/A }
C {devices/lab_pin.sym} 20940 -42070 0 0 {name=p20138 lab=_86958_/Q }
C {devices/lab_pin.sym} 20940 -42030 0 0 {name=p20139 lab=_44768_/X }
C {devices/lab_pin.sym} 21100 -42110 0 1 {name=p20140 lab=_44780_/Y }
C {sky130_stdcells/o32ai_4.sym} 21020 -42110 0 0 {name=X_44780_ }
C {devices/lab_pin.sym} 20980 -41950 0 0 {name=p20141 lab=_57023_/A }
C {devices/lab_pin.sym} 21060 -41950 0 1 {name=p20142 lab=_56766_/X }
C {sky130_stdcells/buf_2.sym} 21020 -41950 0 0 {name=X_56766_ }
C {devices/lab_pin.sym} 20930 -41830 0 0 {name=p20143 lab=_88111_/CLK }
C {devices/lab_pin.sym} 20930 -41810 0 0 {name=p20144 lab=_87586_/D }
C {devices/lab_pin.sym} 21110 -41830 0 1 {name=p20145 lab=_87586_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -41820 0 0 {name=X_87586_ }
C {devices/lab_pin.sym} 20980 -41690 0 0 {name=p20146 lab=_41992_/A }
C {devices/lab_pin.sym} 21060 -41690 0 1 {name=p20147 lab=_41993_/A }
C {sky130_stdcells/buf_2.sym} 21020 -41690 0 0 {name=X_41992_ }
C {devices/lab_pin.sym} 20960 -41580 0 0 {name=p20148 lab=_53978_/A }
C {devices/lab_pin.sym} 20960 -41540 0 0 {name=p20149 lab=_53978_/B }
C {devices/lab_pin.sym} 21080 -41560 0 1 {name=p20150 lab=_53978_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -41560 0 0 {name=X_53978_ }
C {devices/lab_pin.sym} 20930 -41430 0 0 {name=p20151 lab=_84797_/CLK }
C {devices/lab_pin.sym} 20930 -41410 0 0 {name=p20152 lab=_84798_/D }
C {devices/lab_pin.sym} 21110 -41430 0 1 {name=p20153 lab=_84798_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -41420 0 0 {name=X_84798_ }
C {devices/lab_pin.sym} 20980 -41290 0 0 {name=p20154 lab=_84832_/Q }
C {devices/lab_pin.sym} 21060 -41290 0 1 {name=p20155 lab=_58506_/A }
C {sky130_stdcells/buf_2.sym} 21020 -41290 0 0 {name=X_58505_ }
C {devices/lab_pin.sym} 20940 -41200 0 0 {name=p20156 lab=_40890_/X }
C {devices/lab_pin.sym} 20940 -41160 0 0 {name=p20157 lab=_43695_/X }
C {devices/lab_pin.sym} 20940 -41120 0 0 {name=p20158 lab=_87292_/Q }
C {devices/lab_pin.sym} 20940 -41080 0 0 {name=p20159 lab=_43696_/X }
C {devices/lab_pin.sym} 21100 -41140 0 1 {name=p20160 lab=_43731_/X }
C {sky130_stdcells/a2bb2o_4.sym} 21020 -41140 0 0 {name=X_43731_ }
C {devices/lab_pin.sym} 20940 -41010 0 0 {name=p20161 lab=_55714_/X }
C {devices/lab_pin.sym} 20940 -40970 0 0 {name=p20162 lab=_55716_/X }
C {devices/lab_pin.sym} 20940 -40930 0 0 {name=p20163 lab=_44108_/X }
C {devices/lab_pin.sym} 21100 -40970 0 1 {name=p20164 lab=_55717_/Y }
C {sky130_stdcells/a21oi_4.sym} 21020 -40970 0 0 {name=X_55717_ }
C {devices/lab_pin.sym} 20980 -40830 0 0 {name=p20165 lab=_74625_/A }
C {devices/lab_pin.sym} 21060 -40830 0 1 {name=p20166 lab=_74551_/X }
C {sky130_stdcells/buf_2.sym} 21020 -40830 0 0 {name=X_74551_ }
C {devices/lab_pin.sym} 20930 -40710 0 0 {name=p20167 lab=_86218_/CLK }
C {devices/lab_pin.sym} 20930 -40690 0 0 {name=p20168 lab=_48314_/Y }
C {devices/lab_pin.sym} 21110 -40710 0 1 {name=p20169 lab=_66256_/B }
C {sky130_stdcells/dfxtp_4.sym} 21020 -40700 0 0 {name=X_86537_ }
C {devices/lab_pin.sym} 20980 -40570 0 0 {name=p20170 lab=_52821_/A }
C {devices/lab_pin.sym} 21060 -40570 0 1 {name=p20171 lab=_52929_/X }
C {sky130_stdcells/buf_2.sym} 21020 -40570 0 0 {name=X_52929_ }
C {devices/lab_pin.sym} 20940 -40480 0 0 {name=p20172 lab=_40939_/X }
C {devices/lab_pin.sym} 20940 -40440 0 0 {name=p20173 lab=_40941_/X }
C {devices/lab_pin.sym} 20940 -40400 0 0 {name=p20174 lab=_88306_/Q }
C {devices/lab_pin.sym} 20940 -40360 0 0 {name=p20175 lab=_40942_/X }
C {devices/lab_pin.sym} 21100 -40420 0 1 {name=p20176 lab=_88306_/D }
C {sky130_stdcells/a2bb2o_4.sym} 21020 -40420 0 0 {name=X_40943_ }
C {devices/lab_pin.sym} 20980 -40270 0 0 {name=p20177 lab=_70504_/A }
C {devices/lab_pin.sym} 21060 -40270 0 1 {name=p20178 lab=_71763_/X }
C {sky130_stdcells/buf_2.sym} 21020 -40270 0 0 {name=X_71763_ }
C {devices/lab_pin.sym} 20930 -40150 0 0 {name=p20179 lab=_83749_/CLK }
C {devices/lab_pin.sym} 20930 -40130 0 0 {name=p20180 lab=_83749_/D }
C {devices/lab_pin.sym} 21110 -40150 0 1 {name=p20181 lab=_83749_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -40140 0 0 {name=X_83749_ }
C {devices/lab_pin.sym} 20980 -40010 0 0 {name=p20182 lab=_64236_/C }
C {devices/lab_pin.sym} 21060 -40010 0 1 {name=p20183 lab=_63384_/B }
C {sky130_stdcells/buf_2.sym} 21020 -40010 0 0 {name=X_59485_ }
C {devices/lab_pin.sym} 20940 -39910 0 0 {name=p20184 lab=_56725_/B }
C {devices/lab_pin.sym} 20940 -39870 0 0 {name=p20185 lab=_56687_/X }
C {devices/lab_pin.sym} 20940 -39830 0 0 {name=p20186 lab=_56696_/Y }
C {devices/lab_pin.sym} 21100 -39870 0 1 {name=p20187 lab=_56697_/X }
C {sky130_stdcells/o21a_4.sym} 21020 -39870 0 0 {name=X_56697_ }
C {devices/lab_pin.sym} 20960 -39740 0 0 {name=p20188 lab=_73502_/A }
C {devices/lab_pin.sym} 20960 -39700 0 0 {name=p20189 lab=_73501_/X }
C {devices/lab_pin.sym} 21080 -39720 0 1 {name=p20190 lab=_73502_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -39720 0 0 {name=X_73502_ }
C {devices/lab_pin.sym} 20960 -39620 0 0 {name=p20191 lab=_70714_/A }
C {devices/lab_pin.sym} 20960 -39580 0 0 {name=p20192 lab=_70713_/X }
C {devices/lab_pin.sym} 20960 -39540 0 0 {name=p20193 lab=_70710_/C }
C {devices/lab_pin.sym} 20960 -39500 0 0 {name=p20194 lab=_70710_/D }
C {devices/lab_pin.sym} 21080 -39560 0 1 {name=p20195 lab=_70714_/Y }
C {sky130_stdcells/nand4_4.sym} 21020 -39560 0 0 {name=X_70714_ }
C {devices/lab_pin.sym} 20980 -39410 0 0 {name=p20196 lab=_46450_/A }
C {devices/lab_pin.sym} 21060 -39410 0 1 {name=p20197 lab=_50460_/A }
C {sky130_stdcells/buf_2.sym} 21020 -39410 0 0 {name=X_46450_ }
C {devices/lab_pin.sym} 20980 -39290 0 0 {name=p20198 lab=_84848_/Q }
C {devices/lab_pin.sym} 21060 -39290 0 1 {name=p20199 lab=_63209_/A }
C {sky130_stdcells/inv_2.sym} 21020 -39290 0 0 {name=X_58436_ }
C {devices/lab_pin.sym} 20940 -39190 0 0 {name=p20200 lab=_77266_/X }
C {devices/lab_pin.sym} 20940 -39150 0 0 {name=p20201 lab=_77267_/Y }
C {devices/lab_pin.sym} 20940 -39110 0 0 {name=p20202 lab=_77269_/Y }
C {devices/lab_pin.sym} 21100 -39150 0 1 {name=p20203 lab=_77270_/X }
C {sky130_stdcells/a21o_4.sym} 21020 -39150 0 0 {name=X_77270_ }
C {devices/lab_pin.sym} 20940 -39040 0 0 {name=p20204 lab=_40723_/X }
C {devices/lab_pin.sym} 20940 -39000 0 0 {name=p20205 lab=_43659_/X }
C {devices/lab_pin.sym} 20940 -38960 0 0 {name=p20206 lab=_68959_/B }
C {devices/lab_pin.sym} 20940 -38920 0 0 {name=p20207 lab=_43661_/X }
C {devices/lab_pin.sym} 21100 -38980 0 1 {name=p20208 lab=_43663_/A }
C {sky130_stdcells/a2bb2o_4.sym} 21020 -38980 0 0 {name=X_43662_ }
C {devices/lab_pin.sym} 20960 -38840 0 0 {name=p20209 lab=_55647_/X }
C {devices/lab_pin.sym} 20960 -38800 0 0 {name=p20210 lab=_55676_/B }
C {devices/lab_pin.sym} 21080 -38820 0 1 {name=p20211 lab=_55648_/X }
C {sky130_stdcells/and2_4.sym} 21020 -38820 0 0 {name=X_55648_ }
C {devices/lab_pin.sym} 20980 -38690 0 0 {name=p20212 lab=_46725_/A }
C {devices/lab_pin.sym} 21060 -38690 0 1 {name=p20213 lab=_74501_/B }
C {sky130_stdcells/buf_2.sym} 21020 -38690 0 0 {name=X_74482_ }
C {devices/lab_pin.sym} 20930 -38570 0 0 {name=p20214 lab=_83311_/CLK }
C {devices/lab_pin.sym} 20930 -38550 0 0 {name=p20215 lab=_86468_/D }
C {devices/lab_pin.sym} 21110 -38570 0 1 {name=p20216 lab=_86468_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -38560 0 0 {name=X_86468_ }
C {devices/lab_pin.sym} 20980 -38430 0 0 {name=p20217 lab=_40873_/X }
C {devices/lab_pin.sym} 21060 -38430 0 1 {name=p20218 lab=_40874_/X }
C {sky130_stdcells/buf_2.sym} 21020 -38430 0 0 {name=X_40874_ }
C {devices/lab_pin.sym} 20940 -38330 0 0 {name=p20219 lab=_71691_/Y }
C {devices/lab_pin.sym} 20940 -38290 0 0 {name=p20220 lab=_83409_/Q }
C {devices/lab_pin.sym} 20940 -38250 0 0 {name=p20221 lab=_71693_/Y }
C {devices/lab_pin.sym} 21100 -38290 0 1 {name=p20222 lab=_83409_/D }
C {sky130_stdcells/a21o_4.sym} 21020 -38290 0 0 {name=X_71694_ }
C {devices/lab_pin.sym} 20980 -38150 0 0 {name=p20223 lab=_45596_/A }
C {devices/lab_pin.sym} 21060 -38150 0 1 {name=p20224 lab=_45401_/X }
C {sky130_stdcells/buf_2.sym} 21020 -38150 0 0 {name=X_45401_ }
C {devices/lab_pin.sym} 20960 -38050 0 0 {name=p20225 lab=_76219_/Y }
C {devices/lab_pin.sym} 20960 -38010 0 0 {name=p20226 lab=_76217_/X }
C {devices/lab_pin.sym} 20960 -37970 0 0 {name=p20227 lab=_76221_/C }
C {devices/lab_pin.sym} 21080 -38010 0 1 {name=p20228 lab=_76221_/Y }
C {sky130_stdcells/nand3_4.sym} 21020 -38010 0 0 {name=X_76221_ }
C {devices/lab_pin.sym} 20930 -37870 0 0 {name=p20229 lab=_87950_/CLK }
C {devices/lab_pin.sym} 20930 -37850 0 0 {name=p20230 lab=_41480_/X }
C {devices/lab_pin.sym} 21110 -37870 0 1 {name=p20231 lab=_88207_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -37860 0 0 {name=X_88207_ }
C {devices/lab_pin.sym} 20940 -37770 0 0 {name=p20232 lab=_49210_/B }
C {devices/lab_pin.sym} 20940 -37730 0 0 {name=p20233 lab=_40903_/A }
C {devices/lab_pin.sym} 20940 -37690 0 0 {name=p20234 lab=_41888_/X }
C {devices/lab_pin.sym} 20940 -37650 0 0 {name=p20235 lab=_42611_/Y }
C {devices/lab_pin.sym} 20940 -37610 0 0 {name=p20236 lab=_42612_/X }
C {devices/lab_pin.sym} 21100 -37690 0 1 {name=p20237 lab=_42613_/Y }
C {sky130_stdcells/o32ai_4.sym} 21020 -37690 0 0 {name=X_42613_ }
C {devices/lab_pin.sym} 20980 -37530 0 0 {name=p20238 lab=clkbuf_4_6_1_CLK/X }
C {devices/lab_pin.sym} 21060 -37530 0 1 {name=p20239 lab=clkbuf_6_25_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 21020 -37530 0 0 {name=Xclkbuf_5_12_0_CLK }
C {devices/lab_pin.sym} 20940 -37430 0 0 {name=p20240 lab=_73434_/B }
C {devices/lab_pin.sym} 20940 -37390 0 0 {name=p20241 lab=_73434_/C }
C {devices/lab_pin.sym} 20940 -37350 0 0 {name=p20242 lab=_73432_/X }
C {devices/lab_pin.sym} 21100 -37390 0 1 {name=p20243 lab=_73433_/X }
C {sky130_stdcells/a21o_4.sym} 21020 -37390 0 0 {name=X_73433_ }
C {devices/lab_pin.sym} 20930 -37250 0 0 {name=p20244 lab=_85643_/CLK }
C {devices/lab_pin.sym} 20930 -37230 0 0 {name=p20245 lab=_54566_/Y }
C {devices/lab_pin.sym} 21110 -37250 0 1 {name=p20246 lab=_85419_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -37240 0 0 {name=X_85419_ }
C {devices/lab_pin.sym} 20940 -37130 0 0 {name=p20247 lab=_46348_/X }
C {devices/lab_pin.sym} 20940 -37090 0 0 {name=p20248 lab=_48996_/A }
C {devices/lab_pin.sym} 20940 -37050 0 0 {name=p20249 lab=_46380_/X }
C {devices/lab_pin.sym} 21100 -37090 0 1 {name=p20250 lab=_51294_/B }
C {sky130_stdcells/o21ai_4.sym} 21020 -37090 0 0 {name=X_46381_ }
C {devices/lab_pin.sym} 20960 -36980 0 0 {name=p20251 lab=_70714_/A }
C {devices/lab_pin.sym} 20960 -36940 0 0 {name=p20252 lab=_70639_/B }
C {devices/lab_pin.sym} 20960 -36900 0 0 {name=p20253 lab=_70642_/X }
C {devices/lab_pin.sym} 20960 -36860 0 0 {name=p20254 lab=_70638_/X }
C {devices/lab_pin.sym} 21080 -36920 0 1 {name=p20255 lab=_70645_/Y }
C {sky130_stdcells/nand4_4.sym} 21020 -36920 0 0 {name=X_70645_ }
C {devices/lab_pin.sym} 20980 -36770 0 0 {name=p20256 lab=_84867_/Q }
C {devices/lab_pin.sym} 21060 -36770 0 1 {name=p20257 lab=_63344_/A }
C {sky130_stdcells/inv_2.sym} 21020 -36770 0 0 {name=X_58367_ }
C {devices/lab_pin.sym} 20940 -36680 0 0 {name=p20258 lab=_45479_/A }
C {devices/lab_pin.sym} 20940 -36640 0 0 {name=p20259 lab=_44086_/A }
C {devices/lab_pin.sym} 20940 -36600 0 0 {name=p20260 lab=_55533_/X }
C {devices/lab_pin.sym} 20940 -36560 0 0 {name=p20261 lab=_55578_/X }
C {devices/lab_pin.sym} 21100 -36620 0 1 {name=p20262 lab=_55580_/B }
C {sky130_stdcells/a211o_4.sym} 21020 -36620 0 0 {name=X_55579_ }
C {devices/lab_pin.sym} 20980 -36470 0 0 {name=p20263 lab=_43611_/A }
C {devices/lab_pin.sym} 21060 -36470 0 1 {name=p20264 lab=_43593_/X }
C {sky130_stdcells/buf_2.sym} 21020 -36470 0 0 {name=X_43593_ }
C {devices/lab_pin.sym} 20930 -36350 0 0 {name=p20265 lab=_86398_/CLK }
C {devices/lab_pin.sym} 20930 -36330 0 0 {name=p20266 lab=_49375_/Y }
C {devices/lab_pin.sym} 21110 -36350 0 1 {name=p20267 lab=_58587_/B }
C {sky130_stdcells/dfxtp_4.sym} 21020 -36340 0 0 {name=X_86399_ }
C {devices/lab_pin.sym} 20960 -36220 0 0 {name=p20268 lab=_48138_/A }
C {devices/lab_pin.sym} 20960 -36180 0 0 {name=p20269 lab=_48329_/A }
C {devices/lab_pin.sym} 21080 -36200 0 1 {name=p20270 lab=_48120_/X }
C {sky130_stdcells/and2_4.sym} 21020 -36200 0 0 {name=X_48120_ }
C {devices/lab_pin.sym} 20960 -36100 0 0 {name=p20271 lab=_56766_/X }
C {devices/lab_pin.sym} 20960 -36060 0 0 {name=p20272 lab=_56782_/X }
C {devices/lab_pin.sym} 20960 -36020 0 0 {name=p20273 lab=_56810_/X }
C {devices/lab_pin.sym} 20960 -35980 0 0 {name=p20274 lab=_57318_/D }
C {devices/lab_pin.sym} 21080 -36040 0 1 {name=p20275 lab=_57318_/Y }
C {sky130_stdcells/nand4_4.sym} 21020 -36040 0 0 {name=X_57318_ }
C {devices/lab_pin.sym} 20960 -35900 0 0 {name=p20276 lab=_45331_/Y }
C {devices/lab_pin.sym} 20960 -35860 0 0 {name=p20277 lab=_45272_/X }
C {devices/lab_pin.sym} 21080 -35880 0 1 {name=p20278 lab=_45332_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -35880 0 0 {name=X_45332_ }
C {devices/lab_pin.sym} 20960 -35770 0 0 {name=p20279 lab=_76150_/A }
C {devices/lab_pin.sym} 20960 -35730 0 0 {name=p20280 lab=_81537_/Q }
C {devices/lab_pin.sym} 20960 -35690 0 0 {name=p20281 lab=_76150_/B }
C {devices/lab_pin.sym} 21080 -35730 0 1 {name=p20282 lab=_76152_/Y }
C {sky130_stdcells/nand3_4.sym} 21020 -35730 0 0 {name=X_76152_ }
C {devices/lab_pin.sym} 20930 -35590 0 0 {name=p20283 lab=_88394_/CLK }
C {devices/lab_pin.sym} 20930 -35570 0 0 {name=p20284 lab=_88138_/D }
C {devices/lab_pin.sym} 21110 -35590 0 1 {name=p20285 lab=_66802_/B }
C {sky130_stdcells/dfxtp_4.sym} 21020 -35580 0 0 {name=X_88138_ }
C {devices/lab_pin.sym} 20940 -35490 0 0 {name=p20286 lab=_42536_/X }
C {devices/lab_pin.sym} 20940 -35450 0 0 {name=p20287 lab=_42527_/X }
C {devices/lab_pin.sym} 20940 -35410 0 0 {name=p20288 lab=_40767_/X }
C {devices/lab_pin.sym} 20940 -35370 0 0 {name=p20289 lab=_42543_/Y }
C {devices/lab_pin.sym} 20940 -35330 0 0 {name=p20290 lab=_42538_/X }
C {devices/lab_pin.sym} 21100 -35410 0 1 {name=p20291 lab=_87827_/D }
C {sky130_stdcells/o32ai_4.sym} 21020 -35410 0 0 {name=X_42544_ }
C {devices/lab_pin.sym} 20940 -35270 0 0 {name=p20292 lab=_73365_/B }
C {devices/lab_pin.sym} 20940 -35230 0 0 {name=p20293 lab=_73365_/C }
C {devices/lab_pin.sym} 20940 -35190 0 0 {name=p20294 lab=_73363_/X }
C {devices/lab_pin.sym} 21100 -35230 0 1 {name=p20295 lab=_73364_/X }
C {sky130_stdcells/a21o_4.sym} 21020 -35230 0 0 {name=X_73364_ }
C {devices/lab_pin.sym} 20960 -35120 0 0 {name=p20296 lab=_71162_/B }
C {devices/lab_pin.sym} 20960 -35080 0 0 {name=p20297 lab=_70412_/X }
C {devices/lab_pin.sym} 20960 -35040 0 0 {name=p20298 lab=_70933_/B }
C {devices/lab_pin.sym} 20960 -35000 0 0 {name=p20299 lab=_70423_/X }
C {devices/lab_pin.sym} 21080 -35060 0 1 {name=p20300 lab=_70576_/X }
C {sky130_stdcells/and4_4.sym} 21020 -35060 0 0 {name=X_70576_ }
C {devices/lab_pin.sym} 20980 -34910 0 0 {name=p20301 lab=_58298_/A }
C {devices/lab_pin.sym} 21060 -34910 0 1 {name=p20302 lab=_58298_/Y }
C {sky130_stdcells/inv_2.sym} 21020 -34910 0 0 {name=X_58298_ }
C {devices/lab_pin.sym} 20940 -34810 0 0 {name=p20303 lab=_75104_/C }
C {devices/lab_pin.sym} 20940 -34770 0 0 {name=p20304 lab=_75104_/B }
C {devices/lab_pin.sym} 20940 -34730 0 0 {name=p20305 lab=_75104_/A }
C {devices/lab_pin.sym} 21100 -34770 0 1 {name=p20306 lab=_75106_/A }
C {sky130_stdcells/a21oi_4.sym} 21020 -34770 0 0 {name=X_75103_ }
C {devices/lab_pin.sym} 20980 -34630 0 0 {name=p20307 lab=_83540_/Q }
C {devices/lab_pin.sym} 21060 -34630 0 1 {name=p20308 lab=_48051_/Y }
C {sky130_stdcells/inv_2.sym} 21020 -34630 0 0 {name=X_48051_ }
C {devices/lab_pin.sym} 20940 -34530 0 0 {name=p20309 lab=_72264_/X }
C {devices/lab_pin.sym} 20940 -34490 0 0 {name=p20310 lab=_85361_/Q }
C {devices/lab_pin.sym} 20940 -34450 0 0 {name=p20311 lab=_72314_/X }
C {devices/lab_pin.sym} 21100 -34490 0 1 {name=p20312 lab=_72315_/Y }
C {sky130_stdcells/o21ai_4.sym} 21020 -34490 0 0 {name=X_72315_ }
C {devices/lab_pin.sym} 20940 -34370 0 0 {name=p20313 lab=_55764_/B }
C {devices/lab_pin.sym} 20940 -34330 0 0 {name=p20314 lab=_45206_/X }
C {devices/lab_pin.sym} 20940 -34290 0 0 {name=p20315 lab=_45237_/X }
C {devices/lab_pin.sym} 21100 -34330 0 1 {name=p20316 lab=_45263_/X }
C {sky130_stdcells/o21a_4.sym} 21020 -34330 0 0 {name=X_45263_ }
C {devices/lab_pin.sym} 20980 -34190 0 0 {name=p20317 lab=_57340_/C }
C {devices/lab_pin.sym} 21060 -34190 0 1 {name=p20318 lab=_57249_/X }
C {sky130_stdcells/buf_2.sym} 21020 -34190 0 0 {name=X_57249_ }
C {devices/lab_pin.sym} 20960 -34080 0 0 {name=p20319 lab=_81528_/Q }
C {devices/lab_pin.sym} 20960 -34040 0 0 {name=p20320 lab=_76083_/B }
C {devices/lab_pin.sym} 21080 -34060 0 1 {name=p20321 lab=_81777_/D }
C {sky130_stdcells/xor2_4.sym} 21020 -34060 0 0 {name=X_76083_ }
C {devices/lab_pin.sym} 20930 -33930 0 0 {name=p20322 lab=_87813_/CLK }
C {devices/lab_pin.sym} 20930 -33910 0 0 {name=p20323 lab=_88069_/D }
C {devices/lab_pin.sym} 21110 -33930 0 1 {name=p20324 lab=_73124_/A }
C {sky130_stdcells/dfxtp_4.sym} 21020 -33920 0 0 {name=X_88069_ }
C {devices/lab_pin.sym} 20980 -33790 0 0 {name=p20325 lab=_42475_/A }
C {devices/lab_pin.sym} 21060 -33790 0 1 {name=p20326 lab=_42475_/Y }
C {sky130_stdcells/inv_2.sym} 21020 -33790 0 0 {name=X_42475_ }
C {devices/lab_pin.sym} 20940 -33690 0 0 {name=p20327 lab=_83157_/Q }
C {devices/lab_pin.sym} 20940 -33650 0 0 {name=p20328 lab=_73193_/X }
C {devices/lab_pin.sym} 20940 -33610 0 0 {name=p20329 lab=_73294_/Y }
C {devices/lab_pin.sym} 21100 -33650 0 1 {name=p20330 lab=_73295_/X }
C {sky130_stdcells/a21o_4.sym} 21020 -33650 0 0 {name=X_73295_ }
C {devices/lab_pin.sym} 20980 -33510 0 0 {name=p20331 lab=_47002_/A }
C {devices/lab_pin.sym} 21060 -33510 0 1 {name=p20332 lab=_47003_/A }
C {sky130_stdcells/buf_2.sym} 21020 -33510 0 0 {name=X_47002_ }
C {devices/lab_pin.sym} 20980 -33390 0 0 {name=p20333 lab=clkbuf_5_27_0_CLK/A }
C {devices/lab_pin.sym} 21060 -33390 0 1 {name=p20334 lab=clkbuf_6_55_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 21020 -33390 0 0 {name=Xclkbuf_5_27_0_CLK }
C {devices/lab_pin.sym} 20980 -33270 0 0 {name=p20335 lab=_44213_/X }
C {devices/lab_pin.sym} 21060 -33270 0 1 {name=p20336 lab=_44214_/X }
C {sky130_stdcells/buf_2.sym} 21020 -33270 0 0 {name=X_44214_ }
C {devices/lab_pin.sym} 20940 -33170 0 0 {name=p20337 lab=_75016_/Y }
C {devices/lab_pin.sym} 20940 -33130 0 0 {name=p20338 lab=_75032_/Y }
C {devices/lab_pin.sym} 20940 -33090 0 0 {name=p20339 lab=_75033_/Y }
C {devices/lab_pin.sym} 21100 -33130 0 1 {name=p20340 lab=_75049_/A }
C {sky130_stdcells/a21o_4.sym} 21020 -33130 0 0 {name=X_75034_ }
C {devices/lab_pin.sym} 20980 -32990 0 0 {name=p20341 lab=_79911_/A }
C {devices/lab_pin.sym} 21060 -32990 0 1 {name=p20342 lab=_79911_/Y }
C {sky130_stdcells/inv_2.sym} 21020 -32990 0 0 {name=X_79911_ }
C {devices/lab_pin.sym} 20980 -32870 0 0 {name=p20343 lab=_41425_/Y }
C {devices/lab_pin.sym} 21060 -32870 0 1 {name=p20344 lab=_88218_/D }
C {sky130_stdcells/inv_2.sym} 21020 -32870 0 0 {name=X_41426_ }
C {devices/lab_pin.sym} 20960 -32770 0 0 {name=p20345 lab=_60244_/A }
C {devices/lab_pin.sym} 20960 -32730 0 0 {name=p20346 lab=_60244_/B }
C {devices/lab_pin.sym} 20960 -32690 0 0 {name=p20347 lab=_79837_/A }
C {devices/lab_pin.sym} 21080 -32730 0 1 {name=p20348 lab=_60260_/Y }
C {sky130_stdcells/nor3_4.sym} 21020 -32730 0 0 {name=X_60260_ }
C {devices/lab_pin.sym} 20980 -32590 0 0 {name=p20349 lab=_57790_/X }
C {devices/lab_pin.sym} 21060 -32590 0 1 {name=p20350 lab=_72332_/B }
C {sky130_stdcells/buf_2.sym} 21020 -32590 0 0 {name=X_72246_ }
C {devices/lab_pin.sym} 20980 -32470 0 0 {name=p20351 lab=_45709_/A }
C {devices/lab_pin.sym} 21060 -32470 0 1 {name=p20352 lab=_45194_/X }
C {sky130_stdcells/buf_2.sym} 21020 -32470 0 0 {name=X_45194_ }
C {devices/lab_pin.sym} 20980 -32350 0 0 {name=p20353 lab=_84518_/CLK }
C {devices/lab_pin.sym} 21060 -32350 0 1 {name=p20354 lab=_84634_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 21020 -32350 0 0 {name=Xclkbuf_opt_16_CLK }
C {devices/lab_pin.sym} 20940 -32250 0 0 {name=p20355 lab=_44143_/Y }
C {devices/lab_pin.sym} 20940 -32210 0 0 {name=p20356 lab=_44144_/Y }
C {devices/lab_pin.sym} 20940 -32170 0 0 {name=p20357 lab=_44163_/B }
C {devices/lab_pin.sym} 21100 -32210 0 1 {name=p20358 lab=_87186_/D }
C {sky130_stdcells/a21oi_4.sym} 21020 -32210 0 0 {name=X_44145_ }
C {devices/lab_pin.sym} 20960 -32080 0 0 {name=p20359 lab=_79839_/X }
C {devices/lab_pin.sym} 20960 -32040 0 0 {name=p20360 lab=_79842_/B }
C {devices/lab_pin.sym} 21080 -32060 0 1 {name=p20361 lab=_79842_/X }
C {sky130_stdcells/xor2_4.sym} 21020 -32060 0 0 {name=X_79842_ }
C {devices/lab_pin.sym} 20940 -31960 0 0 {name=p20362 lab=_41356_/X }
C {devices/lab_pin.sym} 20940 -31920 0 0 {name=p20363 lab=_41307_/X }
C {devices/lab_pin.sym} 20940 -31880 0 0 {name=p20364 lab=_67647_/B }
C {devices/lab_pin.sym} 20940 -31840 0 0 {name=p20365 lab=_41308_/X }
C {devices/lab_pin.sym} 21100 -31900 0 1 {name=p20366 lab=_88230_/D }
C {sky130_stdcells/a2bb2o_4.sym} 21020 -31900 0 0 {name=X_41357_ }
C {devices/lab_pin.sym} 20980 -31750 0 0 {name=p20367 lab=_60324_/B }
C {devices/lab_pin.sym} 21060 -31750 0 1 {name=p20368 lab=_60268_/A }
C {sky130_stdcells/buf_2.sym} 21020 -31750 0 0 {name=X_60191_ }
C {devices/lab_pin.sym} 20940 -31670 0 0 {name=p20369 lab=_72172_/X }
C {devices/lab_pin.sym} 20940 -31630 0 0 {name=p20370 lab=_72174_/Y }
C {devices/lab_pin.sym} 20940 -31590 0 0 {name=p20371 lab=_72175_/Y }
C {devices/lab_pin.sym} 20940 -31550 0 0 {name=p20372 lab=_59301_/X }
C {devices/lab_pin.sym} 20940 -31510 0 0 {name=p20373 lab=_72176_/X }
C {devices/lab_pin.sym} 21100 -31590 0 1 {name=p20374 lab=_72177_/X }
C {sky130_stdcells/o32a_4.sym} 21020 -31590 0 0 {name=X_72177_ }
C {devices/lab_pin.sym} 20940 -31450 0 0 {name=p20375 lab=_50708_/B }
C {devices/lab_pin.sym} 20940 -31410 0 0 {name=p20376 lab=_71117_/X }
C {devices/lab_pin.sym} 20940 -31370 0 0 {name=p20377 lab=_71127_/Y }
C {devices/lab_pin.sym} 21100 -31410 0 1 {name=p20378 lab=_83597_/D }
C {sky130_stdcells/o21ai_4.sym} 21020 -31410 0 0 {name=X_71128_ }
C {devices/lab_pin.sym} 20980 -31270 0 0 {name=p20379 lab=_48898_/A }
C {devices/lab_pin.sym} 21060 -31270 0 1 {name=p20380 lab=_48964_/A }
C {sky130_stdcells/buf_2.sym} 21020 -31270 0 0 {name=X_48953_ }
C {devices/lab_pin.sym} 20980 -31150 0 0 {name=p20381 lab=_55159_/A }
C {devices/lab_pin.sym} 21060 -31150 0 1 {name=p20382 lab=_55761_/A }
C {sky130_stdcells/buf_2.sym} 21020 -31150 0 0 {name=X_44076_ }
C {devices/lab_pin.sym} 20940 -31050 0 0 {name=p20383 lab=_79763_/X }
C {devices/lab_pin.sym} 20940 -31010 0 0 {name=p20384 lab=_79765_/B }
C {devices/lab_pin.sym} 20940 -30970 0 0 {name=p20385 lab=_79772_/Y }
C {devices/lab_pin.sym} 21100 -31010 0 1 {name=p20386 lab=_79790_/B }
C {sky130_stdcells/a21boi_4.sym} 21020 -31010 0 0 {name=X_79773_ }
C {devices/lab_pin.sym} 20980 -30870 0 0 {name=p20387 lab=_41287_/Y }
C {devices/lab_pin.sym} 21060 -30870 0 1 {name=p20388 lab=_41288_/X }
C {sky130_stdcells/buf_2.sym} 21020 -30870 0 0 {name=X_41288_ }
C {devices/lab_pin.sym} 20960 -30760 0 0 {name=p20389 lab=_76985_/A }
C {devices/lab_pin.sym} 20960 -30720 0 0 {name=p20390 lab=_76985_/B }
C {devices/lab_pin.sym} 21080 -30740 0 1 {name=p20391 lab=_76985_/X }
C {sky130_stdcells/xor2_4.sym} 21020 -30740 0 0 {name=X_76985_ }
C {devices/lab_pin.sym} 20980 -30610 0 0 {name=p20392 lab=_47904_/A }
C {devices/lab_pin.sym} 21060 -30610 0 1 {name=p20393 lab=_47904_/X }
C {sky130_stdcells/buf_2.sym} 21020 -30610 0 0 {name=X_47904_ }
C {devices/lab_pin.sym} 20980 -30490 0 0 {name=p20394 lab=_43027_/A }
C {devices/lab_pin.sym} 21060 -30490 0 1 {name=p20395 lab=_43027_/Y }
C {sky130_stdcells/inv_2.sym} 21020 -30490 0 0 {name=X_43027_ }
C {devices/lab_pin.sym} 20940 -30390 0 0 {name=p20396 lab=_78722_/Y }
C {devices/lab_pin.sym} 20940 -30350 0 0 {name=p20397 lab=_78723_/Y }
C {devices/lab_pin.sym} 20940 -30310 0 0 {name=p20398 lab=_78720_/A }
C {devices/lab_pin.sym} 21100 -30350 0 1 {name=p20399 lab=_78725_/B }
C {sky130_stdcells/o21ai_4.sym} 21020 -30350 0 0 {name=X_78724_ }
C {devices/lab_pin.sym} 20980 -30210 0 0 {name=p20400 lab=_60871_/Y }
C {devices/lab_pin.sym} 21060 -30210 0 1 {name=p20401 lab=_64029_/B }
C {sky130_stdcells/buf_2.sym} 21020 -30210 0 0 {name=X_63950_ }
C {devices/lab_pin.sym} 20940 -30110 0 0 {name=p20402 lab=_48912_/B }
C {devices/lab_pin.sym} 20940 -30070 0 0 {name=p20403 lab=_71047_/X }
C {devices/lab_pin.sym} 20940 -30030 0 0 {name=p20404 lab=_71058_/Y }
C {devices/lab_pin.sym} 21100 -30070 0 1 {name=p20405 lab=_71059_/Y }
C {sky130_stdcells/o21ai_4.sym} 21020 -30070 0 0 {name=X_71059_ }
C {devices/lab_pin.sym} 20940 -29950 0 0 {name=p20406 lab=_75928_/A }
C {devices/lab_pin.sym} 20940 -29910 0 0 {name=p20407 lab=_75934_/Y }
C {devices/lab_pin.sym} 20940 -29870 0 0 {name=p20408 lab=_75935_/Y }
C {devices/lab_pin.sym} 21100 -29910 0 1 {name=p20409 lab=_75936_/Y }
C {sky130_stdcells/o21ai_4.sym} 21020 -29910 0 0 {name=X_75936_ }
C {devices/lab_pin.sym} 20980 -29770 0 0 {name=p20410 lab=_48884_/A }
C {devices/lab_pin.sym} 21060 -29770 0 1 {name=p20411 lab=_48885_/A }
C {sky130_stdcells/buf_2.sym} 21020 -29770 0 0 {name=X_48884_ }
C {devices/lab_pin.sym} 20980 -29650 0 0 {name=p20412 lab=_62791_/X }
C {devices/lab_pin.sym} 21060 -29650 0 1 {name=p20413 lab=_62930_/A }
C {sky130_stdcells/buf_2.sym} 21020 -29650 0 0 {name=X_62901_ }
C {devices/lab_pin.sym} 20940 -29550 0 0 {name=p20414 lab=_43585_/X }
C {devices/lab_pin.sym} 20940 -29510 0 0 {name=p20415 lab=_57491_/C }
C {devices/lab_pin.sym} 20940 -29470 0 0 {name=p20416 lab=_47834_/Y }
C {devices/lab_pin.sym} 21100 -29510 0 1 {name=p20417 lab=_47835_/X }
C {sky130_stdcells/o21a_4.sym} 21020 -29510 0 0 {name=X_47835_ }
C {devices/lab_pin.sym} 20960 -29380 0 0 {name=p20418 lab=_78653_/X }
C {devices/lab_pin.sym} 20960 -29340 0 0 {name=p20419 lab=_78655_/B }
C {devices/lab_pin.sym} 21080 -29360 0 1 {name=p20420 lab=_78655_/X }
C {sky130_stdcells/and2_4.sym} 21020 -29360 0 0 {name=X_78655_ }
C {devices/lab_pin.sym} 20940 -29250 0 0 {name=p20421 lab=_63879_/X }
C {devices/lab_pin.sym} 20940 -29210 0 0 {name=p20422 lab=_63833_/X }
C {devices/lab_pin.sym} 20940 -29170 0 0 {name=p20423 lab=_63880_/Y }
C {devices/lab_pin.sym} 21100 -29210 0 1 {name=p20424 lab=_84289_/D }
C {sky130_stdcells/a21oi_4.sym} 21020 -29210 0 0 {name=X_63881_ }
C {devices/lab_pin.sym} 20980 -29070 0 0 {name=p20425 lab=_75867_/A }
C {devices/lab_pin.sym} 21060 -29070 0 1 {name=p20426 lab=_75867_/Y }
C {sky130_stdcells/inv_2.sym} 21020 -29070 0 0 {name=X_75867_ }
C {devices/lab_pin.sym} 20980 -28950 0 0 {name=p20427 lab=_64967_/X }
C {devices/lab_pin.sym} 21060 -28950 0 1 {name=p20428 lab=_65621_/A }
C {sky130_stdcells/buf_2.sym} 21020 -28950 0 0 {name=X_65620_ }
C {devices/lab_pin.sym} 20960 -28840 0 0 {name=p20429 lab=_77606_/A }
C {devices/lab_pin.sym} 20960 -28800 0 0 {name=p20430 lab=_77605_/X }
C {devices/lab_pin.sym} 21080 -28820 0 1 {name=p20431 lab=_77622_/A }
C {sky130_stdcells/xnor2_4.sym} 21020 -28820 0 0 {name=X_77606_ }
C {devices/lab_pin.sym} 20980 -28690 0 0 {name=p20432 lab=_60362_/A }
C {devices/lab_pin.sym} 21060 -28690 0 1 {name=p20433 lab=_62869_/A }
C {sky130_stdcells/buf_2.sym} 21020 -28690 0 0 {name=X_62832_ }
C {devices/lab_pin.sym} 20960 -28580 0 0 {name=p20434 lab=_59426_/X }
C {devices/lab_pin.sym} 20960 -28540 0 0 {name=p20435 lab=_46111_/A }
C {devices/lab_pin.sym} 21080 -28560 0 1 {name=p20436 lab=_74818_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -28560 0 0 {name=X_74818_ }
C {devices/lab_pin.sym} 20980 -28430 0 0 {name=p20437 lab=_49379_/A }
C {devices/lab_pin.sym} 21060 -28430 0 1 {name=p20438 lab=_47804_/A }
C {sky130_stdcells/buf_2.sym} 21020 -28430 0 0 {name=X_47766_ }
C {devices/lab_pin.sym} 20960 -28320 0 0 {name=p20439 lab=_78586_/A }
C {devices/lab_pin.sym} 20960 -28280 0 0 {name=p20440 lab=_82677_/D }
C {devices/lab_pin.sym} 21080 -28300 0 1 {name=p20441 lab=_78586_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -28300 0 0 {name=X_78586_ }
C {devices/lab_pin.sym} 20940 -28190 0 0 {name=p20442 lab=_44962_/X }
C {devices/lab_pin.sym} 20940 -28150 0 0 {name=p20443 lab=_44974_/Y }
C {devices/lab_pin.sym} 20940 -28110 0 0 {name=p20444 lab=_44977_/Y }
C {devices/lab_pin.sym} 21100 -28150 0 1 {name=p20445 lab=_44978_/Y }
C {sky130_stdcells/a21oi_4.sym} 21020 -28150 0 0 {name=X_44978_ }
C {devices/lab_pin.sym} 20960 -28020 0 0 {name=p20446 lab=_75793_/B }
C {devices/lab_pin.sym} 20960 -27980 0 0 {name=p20447 lab=_75793_/A }
C {devices/lab_pin.sym} 21080 -28000 0 1 {name=p20448 lab=_75798_/X }
C {sky130_stdcells/and2_4.sym} 21020 -28000 0 0 {name=X_75798_ }
C {devices/lab_pin.sym} 20980 -27870 0 0 {name=p20449 lab=_49614_/A }
C {devices/lab_pin.sym} 21060 -27870 0 1 {name=p20450 lab=_49516_/B }
C {sky130_stdcells/buf_2.sym} 21020 -27870 0 0 {name=X_49505_ }
C {devices/lab_pin.sym} 20960 -27780 0 0 {name=p20451 lab=_46717_/A }
C {devices/lab_pin.sym} 20960 -27740 0 0 {name=p20452 lab=_46717_/B }
C {devices/lab_pin.sym} 20960 -27700 0 0 {name=p20453 lab=_46717_/C }
C {devices/lab_pin.sym} 20960 -27660 0 0 {name=p20454 lab=_46716_/X }
C {devices/lab_pin.sym} 21080 -27720 0 1 {name=p20455 lab=_46717_/X }
C {sky130_stdcells/and4_4.sym} 21020 -27720 0 0 {name=X_46717_ }
C {devices/lab_pin.sym} 20960 -27580 0 0 {name=p20456 lab=_65387_/A }
C {devices/lab_pin.sym} 20960 -27540 0 0 {name=p20457 lab=_65551_/B }
C {devices/lab_pin.sym} 21080 -27560 0 1 {name=p20458 lab=_65551_/X }
C {sky130_stdcells/and2_4.sym} 21020 -27560 0 0 {name=X_65551_ }
C {devices/lab_pin.sym} 20960 -27440 0 0 {name=p20459 lab=_77537_/A }
C {devices/lab_pin.sym} 20960 -27400 0 0 {name=p20460 lab=_77537_/B }
C {devices/lab_pin.sym} 21080 -27420 0 1 {name=p20461 lab=_77537_/Y }
C {sky130_stdcells/nor2_4.sym} 21020 -27420 0 0 {name=X_77537_ }
C {devices/lab_pin.sym} 20980 -27290 0 0 {name=p20462 lab=_43869_/X }
C {devices/lab_pin.sym} 21060 -27290 0 1 {name=p20463 lab=_43929_/X }
C {sky130_stdcells/buf_2.sym} 21020 -27290 0 0 {name=X_43929_ }
C {devices/lab_pin.sym} 20980 -27170 0 0 {name=p20464 lab=_74731_/A }
C {devices/lab_pin.sym} 21060 -27170 0 1 {name=p20465 lab=_74764_/A }
C {sky130_stdcells/buf_2.sym} 21020 -27170 0 0 {name=X_74749_ }
C {devices/lab_pin.sym} 20960 -27080 0 0 {name=p20466 lab=_61438_/X }
C {devices/lab_pin.sym} 20960 -27040 0 0 {name=p20467 lab=_62743_/B }
C {devices/lab_pin.sym} 20960 -27000 0 0 {name=p20468 lab=_62742_/X }
C {devices/lab_pin.sym} 20960 -26960 0 0 {name=p20469 lab=_62729_/D }
C {devices/lab_pin.sym} 21080 -27020 0 1 {name=p20470 lab=_62763_/Y }
C {sky130_stdcells/nand4_4.sym} 21020 -27020 0 0 {name=X_62763_ }
C {devices/lab_pin.sym} 20940 -26890 0 0 {name=p20471 lab=_72336_/A }
C {devices/lab_pin.sym} 20940 -26850 0 0 {name=p20472 lab=_47666_/X }
C {devices/lab_pin.sym} 20940 -26810 0 0 {name=p20473 lab=_47696_/Y }
C {devices/lab_pin.sym} 21100 -26850 0 1 {name=p20474 lab=_47697_/Y }
C {sky130_stdcells/o21ai_4.sym} 21020 -26850 0 0 {name=X_47697_ }
C {devices/lab_pin.sym} 20960 -26730 0 0 {name=p20475 lab=_64474_/X }
C {devices/lab_pin.sym} 20960 -26690 0 0 {name=p20476 lab=_64525_/B }
C {devices/lab_pin.sym} 20960 -26650 0 0 {name=p20477 lab=_62129_/X }
C {devices/lab_pin.sym} 21080 -26690 0 1 {name=p20478 lab=_64504_/C }
C {sky130_stdcells/nand3_4.sym} 21020 -26690 0 0 {name=X_64502_ }
C {devices/lab_pin.sym} 20960 -26580 0 0 {name=p20479 lab=_49447_/A }
C {devices/lab_pin.sym} 20960 -26540 0 0 {name=p20480 lab=_49447_/B }
C {devices/lab_pin.sym} 20960 -26500 0 0 {name=p20481 lab=_49420_/C }
C {devices/lab_pin.sym} 20960 -26460 0 0 {name=p20482 lab=_46744_/X }
C {devices/lab_pin.sym} 21080 -26520 0 1 {name=p20483 lab=_49436_/X }
C {sky130_stdcells/and4_4.sym} 21020 -26520 0 0 {name=X_49436_ }
C {devices/lab_pin.sym} 20960 -26400 0 0 {name=p20484 lab=_61714_/A }
C {devices/lab_pin.sym} 20960 -26360 0 0 {name=p20485 lab=_62128_/B }
C {devices/lab_pin.sym} 20960 -26320 0 0 {name=p20486 lab=_59608_/A }
C {devices/lab_pin.sym} 20960 -26280 0 0 {name=p20487 lab=_59761_/B }
C {devices/lab_pin.sym} 21080 -26340 0 1 {name=p20488 lab=_61714_/Y }
C {sky130_stdcells/nand4_4.sym} 21020 -26340 0 0 {name=X_61714_ }
C {devices/lab_pin.sym} 20940 -26220 0 0 {name=p20489 lab=_68246_/X }
C {devices/lab_pin.sym} 20940 -26180 0 0 {name=p20490 lab=_67649_/Y }
C {devices/lab_pin.sym} 20940 -26140 0 0 {name=p20491 lab=_68268_/X }
C {devices/lab_pin.sym} 20940 -26100 0 0 {name=p20492 lab=_68269_/Y }
C {devices/lab_pin.sym} 21100 -26160 0 1 {name=p20493 lab=_68270_/X }
C {sky130_stdcells/a211o_4.sym} 21020 -26160 0 0 {name=X_68270_ }
C {devices/lab_pin.sym} 20940 -26030 0 0 {name=p20494 lab=_46644_/Y }
C {devices/lab_pin.sym} 20940 -25990 0 0 {name=p20495 lab=_46598_/X }
C {devices/lab_pin.sym} 20940 -25950 0 0 {name=p20496 lab=_46647_/X }
C {devices/lab_pin.sym} 21100 -25990 0 1 {name=p20497 lab=_46648_/Y }
C {sky130_stdcells/a21oi_4.sym} 21020 -25990 0 0 {name=X_46648_ }
C {devices/lab_pin.sym} 20940 -25870 0 0 {name=p20498 lab=_65480_/Y }
C {devices/lab_pin.sym} 20940 -25830 0 0 {name=p20499 lab=_65448_/X }
C {devices/lab_pin.sym} 20940 -25790 0 0 {name=p20500 lab=_65481_/X }
C {devices/lab_pin.sym} 21100 -25830 0 1 {name=p20501 lab=_84198_/D }
C {sky130_stdcells/a21o_4.sym} 21020 -25830 0 0 {name=X_65482_ }
C {devices/lab_pin.sym} 20960 -25700 0 0 {name=p20502 lab=_77468_/A }
C {devices/lab_pin.sym} 20960 -25660 0 0 {name=p20503 lab=_77468_/B }
C {devices/lab_pin.sym} 21080 -25680 0 1 {name=p20504 lab=_77468_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -25680 0 0 {name=X_77468_ }
C {devices/lab_pin.sym} 20960 -25580 0 0 {name=p20505 lab=_61365_/X }
C {devices/lab_pin.sym} 20960 -25540 0 0 {name=p20506 lab=_62694_/B }
C {devices/lab_pin.sym} 20960 -25500 0 0 {name=p20507 lab=_62694_/C }
C {devices/lab_pin.sym} 20960 -25460 0 0 {name=p20508 lab=_62664_/D }
C {devices/lab_pin.sym} 21080 -25520 0 1 {name=p20509 lab=_62694_/Y }
C {sky130_stdcells/nand4_4.sym} 21020 -25520 0 0 {name=X_62694_ }
C {devices/lab_pin.sym} 20980 -25370 0 0 {name=p20510 lab=_67816_/A }
C {devices/lab_pin.sym} 21060 -25370 0 1 {name=p20511 lab=_67222_/A }
C {sky130_stdcells/buf_2.sym} 21020 -25370 0 0 {name=X_67221_ }
C {devices/lab_pin.sym} 20960 -25260 0 0 {name=p20512 lab=_79206_/Y }
C {devices/lab_pin.sym} 20960 -25220 0 0 {name=p20513 lab=_79207_/B }
C {devices/lab_pin.sym} 21080 -25240 0 1 {name=p20514 lab=_79208_/B }
C {sky130_stdcells/nand2_4.sym} 21020 -25240 0 0 {name=X_79207_ }
C {devices/lab_pin.sym} 20980 -25110 0 0 {name=p20515 lab=_64377_/A }
C {devices/lab_pin.sym} 21060 -25110 0 1 {name=p20516 lab=_64494_/A }
C {sky130_stdcells/buf_2.sym} 21020 -25110 0 0 {name=X_64433_ }
C {devices/lab_pin.sym} 20980 -24990 0 0 {name=p20517 lab=_76418_/X }
C {devices/lab_pin.sym} 21060 -24990 0 1 {name=p20518 lab=_76419_/Y }
C {sky130_stdcells/inv_2.sym} 21020 -24990 0 0 {name=X_76419_ }
C {devices/lab_pin.sym} 20940 -24890 0 0 {name=p20519 lab=_58576_/B }
C {devices/lab_pin.sym} 20940 -24850 0 0 {name=p20520 lab=_49360_/X }
C {devices/lab_pin.sym} 20940 -24810 0 0 {name=p20521 lab=_49366_/Y }
C {devices/lab_pin.sym} 21100 -24850 0 1 {name=p20522 lab=_49367_/Y }
C {sky130_stdcells/o21ai_4.sym} 21020 -24850 0 0 {name=X_49367_ }
C {devices/lab_pin.sym} 20980 -24710 0 0 {name=p20523 lab=_61645_/A }
C {devices/lab_pin.sym} 21060 -24710 0 1 {name=p20524 lab=_61645_/X }
C {sky130_stdcells/buf_2.sym} 21020 -24710 0 0 {name=X_61645_ }
C {devices/lab_pin.sym} 20980 -24590 0 0 {name=p20525 lab=_47972_/A }
C {devices/lab_pin.sym} 21060 -24590 0 1 {name=p20526 lab=_46579_/X }
C {sky130_stdcells/buf_2.sym} 21020 -24590 0 0 {name=X_46579_ }
C {devices/lab_pin.sym} 20960 -24480 0 0 {name=p20527 lab=_77386_/B }
C {devices/lab_pin.sym} 20960 -24440 0 0 {name=p20528 lab=_77398_/Y }
C {devices/lab_pin.sym} 21080 -24460 0 1 {name=p20529 lab=_77399_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -24460 0 0 {name=X_77399_ }
C {devices/lab_pin.sym} 20940 -24350 0 0 {name=p20530 lab=_48316_/Y }
C {devices/lab_pin.sym} 20940 -24310 0 0 {name=p20531 lab=_48302_/X }
C {devices/lab_pin.sym} 20940 -24270 0 0 {name=p20532 lab=_48317_/X }
C {devices/lab_pin.sym} 21100 -24310 0 1 {name=p20533 lab=_48318_/Y }
C {sky130_stdcells/a21oi_4.sym} 21020 -24310 0 0 {name=X_48318_ }
C {devices/lab_pin.sym} 20980 -24170 0 0 {name=p20534 lab=_66910_/A }
C {devices/lab_pin.sym} 21060 -24170 0 1 {name=p20535 lab=_67152_/X }
C {sky130_stdcells/buf_2.sym} 21020 -24170 0 0 {name=X_67152_ }
C {devices/lab_pin.sym} 20960 -24060 0 0 {name=p20536 lab=_79138_/A }
C {devices/lab_pin.sym} 20960 -24020 0 0 {name=p20537 lab=_79138_/B }
C {devices/lab_pin.sym} 21080 -24040 0 1 {name=p20538 lab=_79138_/X }
C {sky130_stdcells/xor2_4.sym} 21020 -24040 0 0 {name=X_79138_ }
C {devices/lab_pin.sym} 20960 -23930 0 0 {name=p20539 lab=_64319_/X }
C {devices/lab_pin.sym} 20960 -23890 0 0 {name=p20540 lab=_64364_/B }
C {devices/lab_pin.sym} 20960 -23850 0 0 {name=p20541 lab=_64333_/X }
C {devices/lab_pin.sym} 21080 -23890 0 1 {name=p20542 lab=_64364_/X }
C {sky130_stdcells/and3_4.sym} 21020 -23890 0 0 {name=X_64364_ }
C {devices/lab_pin.sym} 20940 -23770 0 0 {name=p20543 lab=_49296_/Y }
C {devices/lab_pin.sym} 20940 -23730 0 0 {name=p20544 lab=_49271_/X }
C {devices/lab_pin.sym} 20940 -23690 0 0 {name=p20545 lab=_49297_/Y }
C {devices/lab_pin.sym} 21100 -23730 0 1 {name=p20546 lab=_86415_/D }
C {sky130_stdcells/a21boi_4.sym} 21020 -23730 0 0 {name=X_49298_ }
C {devices/lab_pin.sym} 20980 -23590 0 0 {name=p20547 lab=_61394_/A }
C {devices/lab_pin.sym} 21060 -23590 0 1 {name=p20548 lab=_61576_/X }
C {sky130_stdcells/buf_2.sym} 21020 -23590 0 0 {name=X_61576_ }
C {devices/lab_pin.sym} 20960 -23480 0 0 {name=p20549 lab=_66099_/X }
C {devices/lab_pin.sym} 20960 -23440 0 0 {name=p20550 lab=_66102_/X }
C {devices/lab_pin.sym} 21080 -23460 0 1 {name=p20551 lab=_66103_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -23460 0 0 {name=X_66103_ }
C {devices/lab_pin.sym} 20940 -23370 0 0 {name=p20552 lab=_63311_/Y }
C {devices/lab_pin.sym} 20940 -23330 0 0 {name=p20553 lab=_63312_/X }
C {devices/lab_pin.sym} 20940 -23290 0 0 {name=p20554 lab=_63313_/X }
C {devices/lab_pin.sym} 20940 -23250 0 0 {name=p20555 lab=_63314_/X }
C {devices/lab_pin.sym} 20940 -23210 0 0 {name=p20556 lab=_63242_/X }
C {devices/lab_pin.sym} 21100 -23290 0 1 {name=p20557 lab=_63315_/Y }
C {sky130_stdcells/o41ai_4.sym} 21020 -23290 0 0 {name=X_63315_ }
C {devices/lab_pin.sym} 20960 -23140 0 0 {name=p20558 lab=_48244_/A }
C {devices/lab_pin.sym} 20960 -23100 0 0 {name=p20559 lab=_47969_/B }
C {devices/lab_pin.sym} 21080 -23120 0 1 {name=p20560 lab=_48249_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -23120 0 0 {name=X_48249_ }
C {devices/lab_pin.sym} 20940 -23030 0 0 {name=p20561 lab=_60523_/X }
C {devices/lab_pin.sym} 20940 -22990 0 0 {name=p20562 lab=_60481_/X }
C {devices/lab_pin.sym} 20940 -22950 0 0 {name=p20563 lab=_60524_/Y }
C {devices/lab_pin.sym} 20940 -22910 0 0 {name=p20564 lab=_60491_/X }
C {devices/lab_pin.sym} 20940 -22880 0 0 {name=p20565 lab=_60526_/Y }
C {devices/lab_pin.sym} 21100 -22950 0 1 {name=p20566 lab=_60527_/Y }
C {sky130_stdcells/a41oi_4.sym} 21020 -22950 0 0 {name=X_60527_ }
C {devices/lab_pin.sym} 20960 -22800 0 0 {name=p20567 lab=_67133_/A }
C {devices/lab_pin.sym} 20960 -22760 0 0 {name=p20568 lab=_86785_/Q }
C {devices/lab_pin.sym} 21080 -22780 0 1 {name=p20569 lab=_67083_/X }
C {sky130_stdcells/and2_4.sym} 21020 -22780 0 0 {name=X_67083_ }
C {devices/lab_pin.sym} 20940 -22670 0 0 {name=p20570 lab=_79027_/B }
C {devices/lab_pin.sym} 20940 -22630 0 0 {name=p20571 lab=_79066_/X }
C {devices/lab_pin.sym} 20940 -22590 0 0 {name=p20572 lab=_79068_/X }
C {devices/lab_pin.sym} 21100 -22630 0 1 {name=p20573 lab=_79070_/B }
C {sky130_stdcells/a21boi_4.sym} 21020 -22630 0 0 {name=X_79069_ }
C {devices/lab_pin.sym} 20960 -22510 0 0 {name=p20574 lab=_64295_/A }
C {devices/lab_pin.sym} 20960 -22470 0 0 {name=p20575 lab=_64248_/B }
C {devices/lab_pin.sym} 20960 -22430 0 0 {name=p20576 lab=_64295_/C }
C {devices/lab_pin.sym} 21080 -22470 0 1 {name=p20577 lab=_64295_/X }
C {sky130_stdcells/and3_4.sym} 21020 -22470 0 0 {name=X_64295_ }
C {devices/lab_pin.sym} 20930 -22330 0 0 {name=p20578 lab=_82220_/CLK }
C {devices/lab_pin.sym} 20930 -22310 0 0 {name=p20579 lab=_79667_/X }
C {devices/lab_pin.sym} 21110 -22330 0 1 {name=p20580 lab=_81100_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -22320 0 0 {name=X_81100_ }
C {devices/lab_pin.sym} 20940 -22210 0 0 {name=p20581 lab=_66032_/Y }
C {devices/lab_pin.sym} 20940 -22170 0 0 {name=p20582 lab=_65987_/X }
C {devices/lab_pin.sym} 20940 -22130 0 0 {name=p20583 lab=_66033_/X }
C {devices/lab_pin.sym} 21100 -22170 0 1 {name=p20584 lab=_84161_/D }
C {sky130_stdcells/a21o_4.sym} 21020 -22170 0 0 {name=X_66034_ }
C {devices/lab_pin.sym} 20980 -22030 0 0 {name=p20585 lab=_51286_/A }
C {devices/lab_pin.sym} 21060 -22030 0 1 {name=p20586 lab=_51280_/A }
C {sky130_stdcells/buf_2.sym} 21020 -22030 0 0 {name=X_51260_ }
C {devices/lab_pin.sym} 20940 -21930 0 0 {name=p20587 lab=_79301_/A }
C {devices/lab_pin.sym} 20940 -21890 0 0 {name=p20588 lab=_63189_/X }
C {devices/lab_pin.sym} 20940 -21850 0 0 {name=p20589 lab=_63245_/Y }
C {devices/lab_pin.sym} 21100 -21890 0 1 {name=p20590 lab=_63246_/X }
C {sky130_stdcells/a21o_4.sym} 21020 -21890 0 0 {name=X_63246_ }
C {devices/lab_pin.sym} 20930 -21750 0 0 {name=p20591 lab=_81169_/CLK }
C {devices/lab_pin.sym} 20930 -21730 0 0 {name=p20592 lab=_84040_/Q }
C {devices/lab_pin.sym} 21110 -21750 0 1 {name=p20593 lab=_78009_/A }
C {sky130_stdcells/dfxtp_4.sym} 21020 -21740 0 0 {name=X_82080_ }
C {devices/lab_pin.sym} 20980 -21610 0 0 {name=p20594 lab=_60447_/A }
C {devices/lab_pin.sym} 21060 -21610 0 1 {name=p20595 lab=_60458_/X }
C {sky130_stdcells/buf_2.sym} 21020 -21610 0 0 {name=X_60458_ }
C {devices/lab_pin.sym} 20980 -21490 0 0 {name=p20596 lab=clkbuf_6_55_0_CLK/X }
C {devices/lab_pin.sym} 21060 -21490 0 1 {name=p20597 lab=clkbuf_8_221_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 21020 -21490 0 0 {name=Xclkbuf_7_110_0_CLK }
C {devices/lab_pin.sym} 20980 -21370 0 0 {name=p20598 lab=_50523_/A }
C {devices/lab_pin.sym} 21060 -21370 0 1 {name=p20599 lab=_50473_/A }
C {sky130_stdcells/buf_2.sym} 21020 -21370 0 0 {name=X_50211_ }
C {devices/lab_pin.sym} 20930 -21250 0 0 {name=p20600 lab=_81061_/CLK }
C {devices/lab_pin.sym} 20930 -21230 0 0 {name=p20601 lab=_81031_/D }
C {devices/lab_pin.sym} 21110 -21250 0 1 {name=p20602 lab=_81031_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -21240 0 0 {name=X_81031_ }
C {devices/lab_pin.sym} 20980 -21110 0 0 {name=p20603 lab=_51191_/A }
C {devices/lab_pin.sym} 21060 -21110 0 1 {name=p20604 lab=_51191_/X }
C {sky130_stdcells/buf_2.sym} 21020 -21110 0 0 {name=X_51191_ }
C {devices/lab_pin.sym} 20940 -21030 0 0 {name=p20605 lab=_58562_/A }
C {devices/lab_pin.sym} 20940 -20990 0 0 {name=p20606 lab=_63131_/X }
C {devices/lab_pin.sym} 20940 -20950 0 0 {name=p20607 lab=_63175_/X }
C {devices/lab_pin.sym} 20940 -20910 0 0 {name=p20608 lab=_58338_/Y }
C {devices/lab_pin.sym} 20940 -20870 0 0 {name=p20609 lab=_63176_/X }
C {devices/lab_pin.sym} 21100 -20950 0 1 {name=p20610 lab=_63177_/Y }
C {sky130_stdcells/o32ai_4.sym} 21020 -20950 0 0 {name=X_63177_ }
C {devices/lab_pin.sym} 20980 -20790 0 0 {name=p20611 lab=_60606_/A }
C {devices/lab_pin.sym} 21060 -20790 0 1 {name=p20612 lab=_60473_/C }
C {sky130_stdcells/buf_2.sym} 21020 -20790 0 0 {name=X_60389_ }
C {devices/lab_pin.sym} 20980 -20670 0 0 {name=p20613 lab=clkbuf_9_40_0_CLK/X }
C {devices/lab_pin.sym} 21060 -20670 0 1 {name=p20614 lab=_86772_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21020 -20670 0 0 {name=Xclkbuf_10_80_0_CLK }
C {devices/lab_pin.sym} 20960 -20570 0 0 {name=p20615 lab=_50142_/A }
C {devices/lab_pin.sym} 20960 -20530 0 0 {name=p20616 lab=_50082_/B }
C {devices/lab_pin.sym} 20960 -20490 0 0 {name=p20617 lab=_50059_/C }
C {devices/lab_pin.sym} 21080 -20530 0 1 {name=p20618 lab=_50142_/X }
C {sky130_stdcells/and3_4.sym} 21020 -20530 0 0 {name=X_50142_ }
C {devices/lab_pin.sym} 20960 -20420 0 0 {name=p20619 lab=_62948_/C }
C {devices/lab_pin.sym} 20960 -20380 0 0 {name=p20620 lab=_62128_/B }
C {devices/lab_pin.sym} 20960 -20340 0 0 {name=p20621 lab=_62128_/C }
C {devices/lab_pin.sym} 20960 -20300 0 0 {name=p20622 lab=_59761_/B }
C {devices/lab_pin.sym} 21080 -20360 0 1 {name=p20623 lab=_62131_/C }
C {sky130_stdcells/nand4_4.sym} 21020 -20360 0 0 {name=X_62128_ }
C {devices/lab_pin.sym} 20960 -20220 0 0 {name=p20624 lab=_68028_/A }
C {devices/lab_pin.sym} 20960 -20180 0 0 {name=p20625 lab=_67985_/B }
C {devices/lab_pin.sym} 21080 -20200 0 1 {name=p20626 lab=_67985_/X }
C {sky130_stdcells/and2_4.sym} 21020 -20200 0 0 {name=X_67985_ }
C {devices/lab_pin.sym} 20940 -20090 0 0 {name=p20627 lab=_69720_/X }
C {devices/lab_pin.sym} 20940 -20050 0 0 {name=p20628 lab=_69723_/X }
C {devices/lab_pin.sym} 20940 -20010 0 0 {name=p20629 lab=_68697_/X }
C {devices/lab_pin.sym} 21100 -20050 0 1 {name=p20630 lab=_69727_/A }
C {sky130_stdcells/a21o_4.sym} 21020 -20050 0 0 {name=X_69724_ }
C {devices/lab_pin.sym} 20940 -19930 0 0 {name=p20631 lab=_50578_/A }
C {devices/lab_pin.sym} 20940 -19890 0 0 {name=p20632 lab=_50578_/B }
C {devices/lab_pin.sym} 20940 -19850 0 0 {name=p20633 lab=_47848_/X }
C {devices/lab_pin.sym} 21100 -19890 0 1 {name=p20634 lab=_50073_/X }
C {sky130_stdcells/o21a_4.sym} 21020 -19890 0 0 {name=X_50073_ }
C {devices/lab_pin.sym} 20980 -19750 0 0 {name=p20635 lab=_54927_/A }
C {devices/lab_pin.sym} 21060 -19750 0 1 {name=p20636 lab=_54955_/B }
C {sky130_stdcells/buf_2.sym} 21020 -19750 0 0 {name=X_54950_ }
C {devices/lab_pin.sym} 20960 -19640 0 0 {name=p20637 lab=_66912_/A }
C {devices/lab_pin.sym} 20960 -19600 0 0 {name=p20638 lab=_87620_/Q }
C {devices/lab_pin.sym} 21080 -19620 0 1 {name=p20639 lab=_66936_/X }
C {sky130_stdcells/and2_4.sym} 21020 -19620 0 0 {name=X_66936_ }
C {devices/lab_pin.sym} 20930 -19490 0 0 {name=p20640 lab=_85770_/CLK }
C {devices/lab_pin.sym} 20930 -19470 0 0 {name=p20641 lab=_52705_/Y }
C {devices/lab_pin.sym} 21110 -19490 0 1 {name=p20642 lab=_85770_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -19480 0 0 {name=X_85770_ }
C {devices/lab_pin.sym} 20980 -19350 0 0 {name=p20643 lab=_61704_/Y }
C {devices/lab_pin.sym} 21060 -19350 0 1 {name=p20644 lab=_62088_/B }
C {sky130_stdcells/buf_2.sym} 21020 -19350 0 0 {name=X_62059_ }
C {devices/lab_pin.sym} 20980 -19230 0 0 {name=p20645 lab=clkbuf_6_62_0_CLK/X }
C {devices/lab_pin.sym} 21060 -19230 0 1 {name=p20646 lab=clkbuf_8_251_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 21020 -19230 0 0 {name=Xclkbuf_7_125_0_CLK }
C {devices/lab_pin.sym} 20930 -19110 0 0 {name=p20647 lab=_83012_/CLK }
C {devices/lab_pin.sym} 20930 -19090 0 0 {name=p20648 lab=_82982_/D }
C {devices/lab_pin.sym} 21110 -19110 0 1 {name=p20649 lab=_82982_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -19100 0 0 {name=X_82982_ }
C {devices/lab_pin.sym} 20980 -18970 0 0 {name=p20650 lab=_53929_/A }
C {devices/lab_pin.sym} 21060 -18970 0 1 {name=p20651 lab=_53902_/A }
C {sky130_stdcells/buf_2.sym} 21020 -18970 0 0 {name=X_53901_ }
C {devices/lab_pin.sym} 20930 -18850 0 0 {name=p20652 lab=_83464_/CLK }
C {devices/lab_pin.sym} 20930 -18830 0 0 {name=p20653 lab=_84721_/D }
C {devices/lab_pin.sym} 21110 -18850 0 1 {name=p20654 lab=_84721_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -18840 0 0 {name=X_84721_ }
C {devices/lab_pin.sym} 20930 -18710 0 0 {name=p20655 lab=_81933_/CLK }
C {devices/lab_pin.sym} 20930 -18690 0 0 {name=p20656 lab=_81933_/D }
C {devices/lab_pin.sym} 21110 -18710 0 1 {name=p20657 lab=_77390_/A }
C {sky130_stdcells/dfxtp_4.sym} 21020 -18700 0 0 {name=X_81933_ }
C {devices/lab_pin.sym} 20980 -18570 0 0 {name=p20658 lab=_69655_/A }
C {devices/lab_pin.sym} 21060 -18570 0 1 {name=p20659 lab=_69655_/X }
C {sky130_stdcells/buf_2.sym} 21020 -18570 0 0 {name=X_69655_ }
C {devices/lab_pin.sym} 20940 -18470 0 0 {name=p20660 lab=_85360_/Q }
C {devices/lab_pin.sym} 20940 -18430 0 0 {name=p20661 lab=_54865_/X }
C {devices/lab_pin.sym} 20940 -18390 0 0 {name=p20662 lab=_54880_/Y }
C {devices/lab_pin.sym} 21100 -18430 0 1 {name=p20663 lab=_54881_/Y }
C {sky130_stdcells/o21ai_4.sym} 21020 -18430 0 0 {name=X_54881_ }
C {devices/lab_pin.sym} 20980 -18290 0 0 {name=p20664 lab=_69751_/A }
C {devices/lab_pin.sym} 21060 -18290 0 1 {name=p20665 lab=_66868_/A }
C {sky130_stdcells/buf_2.sym} 21020 -18290 0 0 {name=X_66867_ }
C {devices/lab_pin.sym} 20980 -18170 0 0 {name=p20666 lab=clkbuf_9_47_0_CLK/X }
C {devices/lab_pin.sym} 21060 -18170 0 1 {name=p20667 lab=_84914_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21020 -18170 0 0 {name=Xclkbuf_10_95_0_CLK }
C {devices/lab_pin.sym} 20940 -18080 0 0 {name=p20668 lab=_56587_/X }
C {devices/lab_pin.sym} 20940 -18040 0 0 {name=p20669 lab=_56619_/X }
C {devices/lab_pin.sym} 20940 -18000 0 0 {name=p20670 lab=_85144_/Q }
C {devices/lab_pin.sym} 20940 -17960 0 0 {name=p20671 lab=_56590_/X }
C {devices/lab_pin.sym} 21100 -18020 0 1 {name=p20672 lab=_56620_/X }
C {sky130_stdcells/a2bb2o_4.sym} 21020 -18020 0 0 {name=X_56620_ }
C {devices/lab_pin.sym} 20940 -17890 0 0 {name=p20673 lab=_68600_/X }
C {devices/lab_pin.sym} 20940 -17850 0 0 {name=p20674 lab=_68605_/X }
C {devices/lab_pin.sym} 20940 -17810 0 0 {name=p20675 lab=_68558_/X }
C {devices/lab_pin.sym} 21100 -17850 0 1 {name=p20676 lab=_68606_/X }
C {sky130_stdcells/a21o_4.sym} 21020 -17850 0 0 {name=X_68606_ }
C {devices/lab_pin.sym} 20930 -17710 0 0 {name=p20677 lab=_87952_/CLK }
C {devices/lab_pin.sym} 20930 -17690 0 0 {name=p20678 lab=_87440_/D }
C {devices/lab_pin.sym} 21110 -17710 0 1 {name=p20679 lab=_87440_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -17700 0 0 {name=X_87440_ }
C {devices/lab_pin.sym} 20960 -17580 0 0 {name=p20680 lab=_53819_/A }
C {devices/lab_pin.sym} 20960 -17540 0 0 {name=p20681 lab=_72007_/B }
C {devices/lab_pin.sym} 21080 -17560 0 1 {name=p20682 lab=_53832_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -17560 0 0 {name=X_53832_ }
C {devices/lab_pin.sym} 20940 -17450 0 0 {name=p20683 lab=_65815_/Y }
C {devices/lab_pin.sym} 20940 -17410 0 0 {name=p20684 lab=_65757_/X }
C {devices/lab_pin.sym} 20940 -17370 0 0 {name=p20685 lab=_65817_/X }
C {devices/lab_pin.sym} 21100 -17410 0 1 {name=p20686 lab=_84176_/D }
C {sky130_stdcells/a21o_4.sym} 21020 -17410 0 0 {name=X_65818_ }
C {devices/lab_pin.sym} 20930 -17270 0 0 {name=p20687 lab=_84652_/CLK }
C {devices/lab_pin.sym} 20930 -17250 0 0 {name=p20688 lab=_60146_/Y }
C {devices/lab_pin.sym} 21110 -17270 0 1 {name=p20689 lab=_60145_/A }
C {sky130_stdcells/dfxtp_4.sym} 21020 -17260 0 0 {name=X_84652_ }
C {devices/lab_pin.sym} 20930 -17130 0 0 {name=p20690 lab=_84375_/CLK }
C {devices/lab_pin.sym} 20930 -17110 0 0 {name=p20691 lab=_78055_/X }
C {devices/lab_pin.sym} 21110 -17130 0 1 {name=p20692 lab=_81864_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -17120 0 0 {name=X_81864_ }
C {devices/lab_pin.sym} 20960 -17000 0 0 {name=p20693 lab=_69586_/A }
C {devices/lab_pin.sym} 20960 -16960 0 0 {name=p20694 lab=_88338_/Q }
C {devices/lab_pin.sym} 21080 -16980 0 1 {name=p20695 lab=_69586_/X }
C {sky130_stdcells/and2_4.sym} 21020 -16980 0 0 {name=X_69586_ }
C {devices/lab_pin.sym} 20980 -16850 0 0 {name=p20696 lab=clkbuf_8_241_0_CLK/A }
C {devices/lab_pin.sym} 21060 -16850 0 1 {name=p20697 lab=clkbuf_9_483_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 21020 -16850 0 0 {name=Xclkbuf_8_241_0_CLK }
C {devices/lab_pin.sym} 20960 -16740 0 0 {name=p20698 lab=_66819_/A }
C {devices/lab_pin.sym} 20960 -16700 0 0 {name=p20699 lab=_86829_/Q }
C {devices/lab_pin.sym} 21080 -16720 0 1 {name=p20700 lab=_66798_/X }
C {sky130_stdcells/and2_4.sym} 21020 -16720 0 0 {name=X_66798_ }
C {devices/lab_pin.sym} 20930 -16590 0 0 {name=p20701 lab=_86155_/CLK }
C {devices/lab_pin.sym} 20930 -16570 0 0 {name=p20702 lab=_71111_/Y }
C {devices/lab_pin.sym} 21110 -16590 0 1 {name=p20703 lab=_49106_/A }
C {sky130_stdcells/dfxtp_4.sym} 21020 -16580 0 0 {name=X_83603_ }
C {devices/lab_pin.sym} 20980 -16450 0 0 {name=p20704 lab=_44037_/X }
C {devices/lab_pin.sym} 21060 -16450 0 1 {name=p20705 lab=_56551_/X }
C {sky130_stdcells/buf_2.sym} 21020 -16450 0 0 {name=X_56551_ }
C {devices/lab_pin.sym} 20930 -16330 0 0 {name=p20706 lab=_80991_/CLK }
C {devices/lab_pin.sym} 20930 -16310 0 0 {name=p20707 lab=_83959_/Q }
C {devices/lab_pin.sym} 21110 -16330 0 1 {name=p20708 lab=_75839_/B }
C {sky130_stdcells/dfxtp_4.sym} 21020 -16320 0 0 {name=X_80815_ }
C {devices/lab_pin.sym} 20930 -16190 0 0 {name=p20709 lab=_87373_/CLK }
C {devices/lab_pin.sym} 20930 -16170 0 0 {name=p20710 lab=_87371_/D }
C {devices/lab_pin.sym} 21110 -16190 0 1 {name=p20711 lab=_87371_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -16180 0 0 {name=X_87371_ }
C {devices/lab_pin.sym} 20940 -16070 0 0 {name=p20712 lab=_68532_/X }
C {devices/lab_pin.sym} 20940 -16030 0 0 {name=p20713 lab=_68536_/X }
C {devices/lab_pin.sym} 20940 -15990 0 0 {name=p20714 lab=_68512_/X }
C {devices/lab_pin.sym} 21100 -16030 0 1 {name=p20715 lab=_68537_/Y }
C {sky130_stdcells/a21oi_4.sym} 21020 -16030 0 0 {name=X_68537_ }
C {devices/lab_pin.sym} 20980 -15890 0 0 {name=p20716 lab=_53763_/A }
C {devices/lab_pin.sym} 21060 -15890 0 1 {name=p20717 lab=_53774_/C }
C {sky130_stdcells/buf_2.sym} 21020 -15890 0 0 {name=X_53763_ }
C {devices/lab_pin.sym} 20940 -15800 0 0 {name=p20718 lab=_65654_/X }
C {devices/lab_pin.sym} 20940 -15760 0 0 {name=p20719 lab=_86188_/Q }
C {devices/lab_pin.sym} 20940 -15720 0 0 {name=p20720 lab=_65576_/X }
C {devices/lab_pin.sym} 20940 -15680 0 0 {name=p20721 lab=_65748_/X }
C {devices/lab_pin.sym} 21100 -15740 0 1 {name=p20722 lab=_65749_/X }
C {sky130_stdcells/a211o_4.sym} 21020 -15740 0 0 {name=X_65749_ }
C {devices/lab_pin.sym} 20930 -15590 0 0 {name=p20723 lab=_84583_/CLK }
C {devices/lab_pin.sym} 20930 -15570 0 0 {name=p20724 lab=_60701_/Y }
C {devices/lab_pin.sym} 21110 -15590 0 1 {name=p20725 lab=_60700_/C }
C {sky130_stdcells/dfxtp_4.sym} 21020 -15580 0 0 {name=X_84583_ }
C {devices/lab_pin.sym} 20940 -15470 0 0 {name=p20726 lab=_50972_/Y }
C {devices/lab_pin.sym} 20940 -15430 0 0 {name=p20727 lab=_50957_/X }
C {devices/lab_pin.sym} 20940 -15390 0 0 {name=p20728 lab=_50974_/X }
C {devices/lab_pin.sym} 21100 -15430 0 1 {name=p20729 lab=_86097_/D }
C {sky130_stdcells/a21oi_4.sym} 21020 -15430 0 0 {name=X_50975_ }
C {devices/lab_pin.sym} 20930 -15290 0 0 {name=p20730 lab=_81284_/CLK }
C {devices/lab_pin.sym} 20930 -15270 0 0 {name=p20731 lab=_81795_/D }
C {devices/lab_pin.sym} 21110 -15290 0 1 {name=p20732 lab=_81795_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -15280 0 0 {name=X_81795_ }
C {devices/lab_pin.sym} 20980 -15150 0 0 {name=p20733 lab=_55501_/X }
C {devices/lab_pin.sym} 21060 -15150 0 1 {name=p20734 lab=_55503_/D }
C {sky130_stdcells/buf_2.sym} 21020 -15150 0 0 {name=X_55502_ }
C {devices/lab_pin.sym} 20930 -15030 0 0 {name=p20735 lab=_86322_/CLK }
C {devices/lab_pin.sym} 20930 -15010 0 0 {name=p20736 lab=_86322_/D }
C {devices/lab_pin.sym} 21110 -15030 0 1 {name=p20737 lab=_57934_/B }
C {sky130_stdcells/dfxtp_4.sym} 21020 -15020 0 0 {name=X_86322_ }
C {devices/lab_pin.sym} 20940 -14910 0 0 {name=p20738 lab=_85768_/Q }
C {devices/lab_pin.sym} 20940 -14870 0 0 {name=p20739 lab=_52711_/X }
C {devices/lab_pin.sym} 20940 -14830 0 0 {name=p20740 lab=_52713_/Y }
C {devices/lab_pin.sym} 21100 -14870 0 1 {name=p20741 lab=_52714_/Y }
C {sky130_stdcells/o21ai_4.sym} 21020 -14870 0 0 {name=X_52714_ }
C {devices/lab_pin.sym} 20960 -14740 0 0 {name=p20742 lab=_59270_/A }
C {devices/lab_pin.sym} 20960 -14700 0 0 {name=p20743 lab=_59282_/B }
C {devices/lab_pin.sym} 21080 -14720 0 1 {name=p20744 lab=_59270_/Y }
C {sky130_stdcells/nor2_4.sym} 21020 -14720 0 0 {name=X_59270_ }
C {devices/lab_pin.sym} 20930 -14590 0 0 {name=p20745 lab=_86534_/CLK }
C {devices/lab_pin.sym} 20930 -14570 0 0 {name=p20746 lab=_83534_/D }
C {devices/lab_pin.sym} 21110 -14590 0 1 {name=p20747 lab=_83534_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -14580 0 0 {name=X_83534_ }
C {devices/lab_pin.sym} 20940 -14470 0 0 {name=p20748 lab=_56035_/X }
C {devices/lab_pin.sym} 20940 -14430 0 0 {name=p20749 lab=_56468_/X }
C {devices/lab_pin.sym} 20940 -14390 0 0 {name=p20750 lab=_56481_/Y }
C {devices/lab_pin.sym} 21100 -14430 0 1 {name=p20751 lab=_85179_/D }
C {sky130_stdcells/o21ai_4.sym} 21020 -14430 0 0 {name=X_56482_ }
C {devices/lab_pin.sym} 20930 -14290 0 0 {name=p20752 lab=_80746_/CLK }
C {devices/lab_pin.sym} 20930 -14270 0 0 {name=p20753 lab=_75198_/X }
C {devices/lab_pin.sym} 21110 -14290 0 1 {name=p20754 lab=_81122_/D }
C {sky130_stdcells/dfxtp_4.sym} 21020 -14280 0 0 {name=X_80746_ }
C {devices/lab_pin.sym} 20960 -14160 0 0 {name=p20755 lab=_57804_/A }
C {devices/lab_pin.sym} 20960 -14120 0 0 {name=p20756 lab=_68468_/B }
C {devices/lab_pin.sym} 21080 -14140 0 1 {name=p20757 lab=_68468_/Y }
C {sky130_stdcells/nor2_4.sym} 21020 -14140 0 0 {name=X_68468_ }
C {devices/lab_pin.sym} 20960 -14020 0 0 {name=p20758 lab=_53611_/X }
C {devices/lab_pin.sym} 20960 -13980 0 0 {name=p20759 lab=_74437_/B }
C {devices/lab_pin.sym} 21080 -14000 0 1 {name=p20760 lab=_53694_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -14000 0 0 {name=X_53694_ }
C {devices/lab_pin.sym} 20980 -13870 0 0 {name=p20761 lab=_63376_/B }
C {devices/lab_pin.sym} 21060 -13870 0 1 {name=p20762 lab=_58221_/X }
C {sky130_stdcells/buf_2.sym} 21020 -13870 0 0 {name=X_58221_ }
C {devices/lab_pin.sym} 20940 -13770 0 0 {name=p20763 lab=_55423_/Y }
C {devices/lab_pin.sym} 20940 -13730 0 0 {name=p20764 lab=_55427_/Y }
C {devices/lab_pin.sym} 20940 -13690 0 0 {name=p20765 lab=_55421_/Y }
C {devices/lab_pin.sym} 21100 -13730 0 1 {name=p20766 lab=_55434_/B }
C {sky130_stdcells/a21boi_4.sym} 21020 -13730 0 0 {name=X_55433_ }
C {devices/lab_pin.sym} 20940 -13610 0 0 {name=p20767 lab=_67416_/X }
C {devices/lab_pin.sym} 20940 -13570 0 0 {name=p20768 lab=_67418_/X }
C {devices/lab_pin.sym} 20940 -13530 0 0 {name=p20769 lab=_67322_/X }
C {devices/lab_pin.sym} 21100 -13570 0 1 {name=p20770 lab=_67419_/X }
C {sky130_stdcells/a21o_4.sym} 21020 -13570 0 0 {name=X_67419_ }
C {devices/lab_pin.sym} 20930 -13430 0 0 {name=p20771 lab=_83303_/CLK }
C {devices/lab_pin.sym} 20930 -13410 0 0 {name=p20772 lab=_50157_/Y }
C {devices/lab_pin.sym} 21110 -13430 0 1 {name=p20773 lab=_86253_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -13420 0 0 {name=X_86253_ }
C {devices/lab_pin.sym} 20960 -13300 0 0 {name=p20774 lab=_52637_/A }
C {devices/lab_pin.sym} 20960 -13260 0 0 {name=p20775 lab=_52645_/B }
C {devices/lab_pin.sym} 21080 -13280 0 1 {name=p20776 lab=_52645_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -13280 0 0 {name=X_52645_ }
C {devices/lab_pin.sym} 20930 -13150 0 0 {name=p20777 lab=_83464_/CLK }
C {devices/lab_pin.sym} 20930 -13130 0 0 {name=p20778 lab=_83465_/D }
C {devices/lab_pin.sym} 21110 -13150 0 1 {name=p20779 lab=_83465_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -13140 0 0 {name=X_83465_ }
C {devices/lab_pin.sym} 20930 -13010 0 0 {name=p20780 lab=_82211_/CLK }
C {devices/lab_pin.sym} 20930 -12990 0 0 {name=p20781 lab=_80709_/Q }
C {devices/lab_pin.sym} 21110 -13010 0 1 {name=p20782 lab=_75109_/A }
C {sky130_stdcells/dfxtp_4.sym} 21020 -13000 0 0 {name=X_80677_ }
C {devices/lab_pin.sym} 20980 -12870 0 0 {name=p20783 lab=_67013_/X }
C {devices/lab_pin.sym} 21060 -12870 0 1 {name=p20784 lab=_70001_/A }
C {sky130_stdcells/buf_2.sym} 21020 -12870 0 0 {name=X_68399_ }
C {devices/lab_pin.sym} 20980 -12750 0 0 {name=p20785 lab=clkbuf_9_125_0_CLK/X }
C {devices/lab_pin.sym} 21060 -12750 0 1 {name=p20786 lab=_81839_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21020 -12750 0 0 {name=Xclkbuf_10_251_0_CLK }
C {sky130_stdcells/decap_3.sym} 21020 -12600 0 0 {name=XPHY_503 }
C {sky130_stdcells/decap_3.sym} 21020 -12420 0 0 {name=XPHY_514 }
C {devices/lab_pin.sym} 20930 -12270 0 0 {name=p20787 lab=_85168_/CLK }
C {devices/lab_pin.sym} 20930 -12250 0 0 {name=p20788 lab=_85204_/D }
C {devices/lab_pin.sym} 21110 -12270 0 1 {name=p20789 lab=_85204_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -12260 0 0 {name=X_85204_ }
C {devices/lab_pin.sym} 20980 -12130 0 0 {name=p20790 lab=_71196_/A }
C {devices/lab_pin.sym} 21060 -12130 0 1 {name=p20791 lab=_70431_/C }
C {sky130_stdcells/buf_2.sym} 21020 -12130 0 0 {name=X_70430_ }
C {devices/lab_pin.sym} 20940 -12030 0 0 {name=p20792 lab=_46158_/B }
C {devices/lab_pin.sym} 20940 -11990 0 0 {name=p20793 lab=_63380_/A }
C {devices/lab_pin.sym} 20940 -11950 0 0 {name=p20794 lab=_58151_/Y }
C {devices/lab_pin.sym} 21100 -11990 0 1 {name=p20795 lab=_84920_/D }
C {sky130_stdcells/a21oi_4.sym} 21020 -11990 0 0 {name=X_58152_ }
C {devices/lab_pin.sym} 20930 -11850 0 0 {name=p20796 lab=_82462_/CLK }
C {devices/lab_pin.sym} 20930 -11830 0 0 {name=p20797 lab=_82448_/Q }
C {devices/lab_pin.sym} 21110 -11850 0 1 {name=p20798 lab=_78503_/A }
C {sky130_stdcells/dfxtp_4.sym} 21020 -11840 0 0 {name=X_82416_ }
C {sky130_stdcells/decap_3.sym} 21020 -11680 0 0 {name=XPHY_525 }
C {devices/lab_pin.sym} 20980 -11530 0 0 {name=p20799 lab=clkbuf_9_440_0_CLK/X }
C {devices/lab_pin.sym} 21060 -11530 0 1 {name=p20800 lab=_86029_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21020 -11530 0 0 {name=Xclkbuf_10_881_0_CLK }
C {devices/lab_pin.sym} 20960 -11420 0 0 {name=p20801 lab=_56708_/A }
C {devices/lab_pin.sym} 20960 -11380 0 0 {name=p20802 lab=_56708_/C }
C {devices/lab_pin.sym} 21080 -11400 0 1 {name=p20803 lab=_55392_/B }
C {sky130_stdcells/nand2_4.sym} 21020 -11400 0 0 {name=X_55364_ }
C {devices/lab_pin.sym} 20930 -11270 0 0 {name=p20804 lab=_86500_/CLK }
C {devices/lab_pin.sym} 20930 -11250 0 0 {name=p20805 lab=_50527_/Y }
C {devices/lab_pin.sym} 21110 -11270 0 1 {name=p20806 lab=_86184_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -11260 0 0 {name=X_86184_ }
C {devices/lab_pin.sym} 20980 -11130 0 0 {name=p20807 lab=_40590_/A }
C {devices/lab_pin.sym} 21060 -11130 0 1 {name=p20808 lab=_40590_/X }
C {sky130_stdcells/buf_2.sym} 21020 -11130 0 0 {name=X_40590_ }
C {devices/lab_pin.sym} 20980 -11010 0 0 {name=p20809 lab=_52602_/A }
C {devices/lab_pin.sym} 21060 -11010 0 1 {name=p20810 lab=_52590_/A }
C {sky130_stdcells/buf_2.sym} 21020 -11010 0 0 {name=X_52576_ }
C {sky130_stdcells/decap_3.sym} 21020 -10860 0 0 {name=XPHY_536 }
C {devices/lab_pin.sym} 20930 -10710 0 0 {name=p20811 lab=_83431_/CLK }
C {devices/lab_pin.sym} 20930 -10690 0 0 {name=p20812 lab=_83396_/D }
C {devices/lab_pin.sym} 21110 -10710 0 1 {name=p20813 lab=_83396_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -10700 0 0 {name=X_83396_ }
C {sky130_stdcells/decap_3.sym} 21020 -10540 0 0 {name=XPHY_547 }
C {sky130_stdcells/decap_3.sym} 21020 -10360 0 0 {name=XPHY_558 }
C {devices/lab_pin.sym} 20980 -10210 0 0 {name=p20814 lab=clkbuf_9_16_0_CLK/X }
C {devices/lab_pin.sym} 21060 -10210 0 1 {name=p20815 lab=_85114_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21020 -10210 0 0 {name=Xclkbuf_10_33_0_CLK }
C {devices/lab_pin.sym} 20940 -10120 0 0 {name=p20816 lab=_57097_/X }
C {devices/lab_pin.sym} 20940 -10080 0 0 {name=p20817 lab=_56584_/X }
C {devices/lab_pin.sym} 20940 -10040 0 0 {name=p20818 lab=_45455_/A }
C {devices/lab_pin.sym} 20940 -10000 0 0 {name=p20819 lab=_57099_/X }
C {devices/lab_pin.sym} 21100 -10060 0 1 {name=p20820 lab=_85085_/D }
C {sky130_stdcells/a2bb2o_4.sym} 21020 -10060 0 0 {name=X_57103_ }
C {devices/lab_pin.sym} 20940 -9930 0 0 {name=p20821 lab=_85464_/Q }
C {devices/lab_pin.sym} 20940 -9890 0 0 {name=p20822 lab=_54294_/X }
C {devices/lab_pin.sym} 20940 -9850 0 0 {name=p20823 lab=_54314_/Y }
C {devices/lab_pin.sym} 21100 -9890 0 1 {name=p20824 lab=_54315_/Y }
C {sky130_stdcells/o21ai_4.sym} 21020 -9890 0 0 {name=X_54315_ }
C {sky130_stdcells/decap_3.sym} 21020 -9720 0 0 {name=XPHY_569 }
C {devices/lab_pin.sym} 20930 -9570 0 0 {name=p20825 lab=_85067_/CLK }
C {devices/lab_pin.sym} 20930 -9550 0 0 {name=p20826 lab=_85135_/D }
C {devices/lab_pin.sym} 21110 -9570 0 1 {name=p20827 lab=_85135_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -9560 0 0 {name=X_85135_ }
C {devices/lab_pin.sym} 20960 -9460 0 0 {name=p20828 lab=_51521_/X }
C {devices/lab_pin.sym} 20960 -9420 0 0 {name=p20829 lab=_51527_/B }
C {devices/lab_pin.sym} 20960 -9380 0 0 {name=p20830 lab=_51533_/C }
C {devices/lab_pin.sym} 20960 -9340 0 0 {name=p20831 lab=_53052_/D }
C {devices/lab_pin.sym} 21080 -9400 0 1 {name=p20832 lab=_51527_/X }
C {sky130_stdcells/and4_4.sym} 21020 -9400 0 0 {name=X_51527_ }
C {devices/lab_pin.sym} 20980 -9250 0 0 {name=p20833 lab=_58701_/A }
C {devices/lab_pin.sym} 21060 -9250 0 1 {name=p20834 lab=_58083_/X }
C {sky130_stdcells/buf_2.sym} 21020 -9250 0 0 {name=X_58083_ }
C {devices/lab_pin.sym} 20980 -9130 0 0 {name=p20835 lab=_70361_/A }
C {devices/lab_pin.sym} 21060 -9130 0 1 {name=p20836 lab=_70361_/Y }
C {sky130_stdcells/inv_2.sym} 21020 -9130 0 0 {name=X_70361_ }
C {devices/lab_pin.sym} 20930 -9010 0 0 {name=p20837 lab=_82859_/CLK }
C {devices/lab_pin.sym} 20930 -8990 0 0 {name=p20838 lab=_77118_/X }
C {devices/lab_pin.sym} 21110 -9010 0 1 {name=p20839 lab=_48064_/A }
C {sky130_stdcells/dfxtp_4.sym} 21020 -9000 0 0 {name=X_82347_ }
C {devices/lab_pin.sym} 20940 -8890 0 0 {name=p20840 lab=_55156_/X }
C {devices/lab_pin.sym} 20940 -8850 0 0 {name=p20841 lab=_55160_/X }
C {devices/lab_pin.sym} 20940 -8810 0 0 {name=p20842 lab=_83746_/Q }
C {devices/lab_pin.sym} 21100 -8850 0 1 {name=p20843 lab=_55296_/A }
C {sky130_stdcells/a21o_4.sym} 21020 -8850 0 0 {name=X_55295_ }
C {devices/lab_pin.sym} 20980 -8710 0 0 {name=p20844 lab=clkbuf_9_373_0_CLK/A }
C {devices/lab_pin.sym} 21060 -8710 0 1 {name=p20845 lab=clkbuf_9_372_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 21020 -8710 0 0 {name=Xclkbuf_9_372_0_CLK }
C {devices/lab_pin.sym} 20940 -8610 0 0 {name=p20846 lab=_72097_/Y }
C {devices/lab_pin.sym} 20940 -8570 0 0 {name=p20847 lab=_72083_/X }
C {devices/lab_pin.sym} 20940 -8530 0 0 {name=p20848 lab=_72099_/Y }
C {devices/lab_pin.sym} 21100 -8570 0 1 {name=p20849 lab=_83285_/D }
C {sky130_stdcells/a21boi_4.sym} 21020 -8570 0 0 {name=X_72100_ }
C {devices/lab_pin.sym} 20960 -8450 0 0 {name=p20850 lab=_57019_/A }
C {devices/lab_pin.sym} 20960 -8410 0 0 {name=p20851 lab=_57024_/Y }
C {devices/lab_pin.sym} 20960 -8370 0 0 {name=p20852 lab=_57034_/C }
C {devices/lab_pin.sym} 21080 -8410 0 1 {name=p20853 lab=_57034_/Y }
C {sky130_stdcells/nand3_4.sym} 21020 -8410 0 0 {name=X_57034_ }
C {devices/lab_pin.sym} 20940 -8300 0 0 {name=p20854 lab=_41465_/X }
C {devices/lab_pin.sym} 20940 -8260 0 0 {name=p20855 lab=_42258_/X }
C {devices/lab_pin.sym} 20940 -8220 0 0 {name=p20856 lab=_87954_/Q }
C {devices/lab_pin.sym} 20940 -8180 0 0 {name=p20857 lab=_42259_/X }
C {devices/lab_pin.sym} 21100 -8240 0 1 {name=p20858 lab=_87954_/D }
C {sky130_stdcells/a2bb2o_4.sym} 21020 -8240 0 0 {name=X_42260_ }
C {devices/lab_pin.sym} 20980 -8090 0 0 {name=p20859 lab=_54329_/A }
C {devices/lab_pin.sym} 21060 -8090 0 1 {name=p20860 lab=_54246_/X }
C {sky130_stdcells/buf_2.sym} 21020 -8090 0 0 {name=X_54246_ }
C {devices/lab_pin.sym} 20930 -7970 0 0 {name=p20861 lab=_83335_/CLK }
C {devices/lab_pin.sym} 20930 -7950 0 0 {name=p20862 lab=_57190_/Y }
C {devices/lab_pin.sym} 21110 -7970 0 1 {name=p20863 lab=_85066_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -7960 0 0 {name=X_85066_ }
C {devices/lab_pin.sym} 20980 -7830 0 0 {name=p20864 lab=_57376_/X }
C {devices/lab_pin.sym} 21060 -7830 0 1 {name=p20865 lab=_73104_/B }
C {sky130_stdcells/buf_2.sym} 21020 -7830 0 0 {name=X_73080_ }
C {devices/lab_pin.sym} 20980 -7710 0 0 {name=p20866 lab=_51539_/A }
C {devices/lab_pin.sym} 21060 -7710 0 1 {name=p20867 lab=_51458_/X }
C {sky130_stdcells/buf_2.sym} 21020 -7710 0 0 {name=X_51458_ }
C {devices/lab_pin.sym} 20980 -7590 0 0 {name=p20868 lab=clkbuf_9_133_0_CLK/X }
C {devices/lab_pin.sym} 21060 -7590 0 1 {name=p20869 lab=_84714_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21020 -7590 0 0 {name=Xclkbuf_10_266_0_CLK }
C {devices/lab_pin.sym} 20960 -7500 0 0 {name=p20870 lab=_70292_/A }
C {devices/lab_pin.sym} 20960 -7460 0 0 {name=p20871 lab=_70292_/B }
C {devices/lab_pin.sym} 20960 -7420 0 0 {name=p20872 lab=_70292_/C }
C {devices/lab_pin.sym} 20960 -7380 0 0 {name=p20873 lab=_70292_/D }
C {devices/lab_pin.sym} 21080 -7440 0 1 {name=p20874 lab=_70292_/X }
C {sky130_stdcells/and4_4.sym} 21020 -7440 0 0 {name=X_70292_ }
C {devices/lab_pin.sym} 20930 -7290 0 0 {name=p20875 lab=_82284_/CLK }
C {devices/lab_pin.sym} 20930 -7270 0 0 {name=p20876 lab=_77023_/B }
C {devices/lab_pin.sym} 21110 -7290 0 1 {name=p20877 lab=_41085_/A }
C {sky130_stdcells/dfxtp_4.sym} 21020 -7280 0 0 {name=X_82278_ }
C {devices/lab_pin.sym} 20980 -7150 0 0 {name=p20878 lab=_41210_/Y }
C {devices/lab_pin.sym} 21060 -7150 0 1 {name=p20879 lab=_88257_/D }
C {sky130_stdcells/inv_2.sym} 21020 -7150 0 0 {name=X_41211_ }
C {devices/lab_pin.sym} 20960 -7040 0 0 {name=p20880 lab=_72017_/X }
C {devices/lab_pin.sym} 20960 -7000 0 0 {name=p20881 lab=_53856_/B }
C {devices/lab_pin.sym} 21080 -7020 0 1 {name=p20882 lab=_72031_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -7020 0 0 {name=X_72031_ }
C {devices/lab_pin.sym} 20930 -6890 0 0 {name=p20883 lab=_84014_/CLK }
C {devices/lab_pin.sym} 20930 -6870 0 0 {name=p20884 lab=_84017_/D }
C {devices/lab_pin.sym} 21110 -6890 0 1 {name=p20885 lab=_82057_/D }
C {sky130_stdcells/dfxtp_4.sym} 21020 -6880 0 0 {name=X_84017_ }
C {devices/lab_pin.sym} 20980 -6750 0 0 {name=p20886 lab=clkbuf_9_448_0_CLK/X }
C {devices/lab_pin.sym} 21060 -6750 0 1 {name=p20887 lab=_87345_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21020 -6750 0 0 {name=Xclkbuf_10_896_0_CLK }
C {devices/lab_pin.sym} 20940 -6650 0 0 {name=p20888 lab=_50406_/Y }
C {devices/lab_pin.sym} 20940 -6610 0 0 {name=p20889 lab=_50395_/X }
C {devices/lab_pin.sym} 20940 -6570 0 0 {name=p20890 lab=_50408_/X }
C {devices/lab_pin.sym} 21100 -6610 0 1 {name=p20891 lab=_86207_/D }
C {sky130_stdcells/a21oi_4.sym} 21020 -6610 0 0 {name=X_50409_ }
C {devices/lab_pin.sym} 20930 -6470 0 0 {name=p20892 lab=_81227_/CLK }
C {devices/lab_pin.sym} 20930 -6450 0 0 {name=p20893 lab=_81229_/D }
C {devices/lab_pin.sym} 21110 -6470 0 1 {name=p20894 lab=_81229_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -6460 0 0 {name=X_81229_ }
C {devices/lab_pin.sym} 20940 -6360 0 0 {name=p20895 lab=_41288_/X }
C {devices/lab_pin.sym} 20940 -6320 0 0 {name=p20896 lab=_42183_/X }
C {devices/lab_pin.sym} 20940 -6280 0 0 {name=p20897 lab=_87987_/Q }
C {devices/lab_pin.sym} 20940 -6240 0 0 {name=p20898 lab=_42184_/X }
C {devices/lab_pin.sym} 21100 -6300 0 1 {name=p20899 lab=_87987_/D }
C {sky130_stdcells/a2bb2o_4.sym} 21020 -6300 0 0 {name=X_42191_ }
C {devices/lab_pin.sym} 20960 -6180 0 0 {name=p20900 lab=_54160_/A }
C {devices/lab_pin.sym} 20960 -6140 0 0 {name=p20901 lab=_54186_/B }
C {devices/lab_pin.sym} 20960 -6100 0 0 {name=p20902 lab=_54191_/C }
C {devices/lab_pin.sym} 20960 -6060 0 0 {name=p20903 lab=_53008_/D }
C {devices/lab_pin.sym} 21080 -6120 0 1 {name=p20904 lab=_54177_/X }
C {sky130_stdcells/and4_4.sym} 21020 -6120 0 0 {name=X_54177_ }
C {devices/lab_pin.sym} 20960 -5980 0 0 {name=p20905 lab=_51758_/A }
C {devices/lab_pin.sym} 20960 -5940 0 0 {name=p20906 lab=_51389_/B }
C {devices/lab_pin.sym} 21080 -5960 0 1 {name=p20907 lab=_51389_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -5960 0 0 {name=X_51389_ }
C {devices/lab_pin.sym} 20980 -5830 0 0 {name=p20908 lab=clkbuf_9_24_0_CLK/X }
C {devices/lab_pin.sym} 21060 -5830 0 1 {name=p20909 lab=_85074_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21020 -5830 0 0 {name=Xclkbuf_10_48_0_CLK }
C {devices/lab_pin.sym} 20980 -5710 0 0 {name=p20910 lab=_40380_/A }
C {devices/lab_pin.sym} 21060 -5710 0 1 {name=p20911 lab=_41143_/A }
C {sky130_stdcells/buf_2.sym} 21020 -5710 0 0 {name=X_41142_ }
C {devices/lab_pin.sym} 20940 -5610 0 0 {name=p20912 lab=_85692_/Q }
C {devices/lab_pin.sym} 20940 -5570 0 0 {name=p20913 lab=_53120_/X }
C {devices/lab_pin.sym} 20940 -5530 0 0 {name=p20914 lab=_53127_/Y }
C {devices/lab_pin.sym} 21100 -5570 0 1 {name=p20915 lab=_53128_/Y }
C {sky130_stdcells/o21ai_4.sym} 21020 -5570 0 0 {name=X_53128_ }
C {devices/lab_pin.sym} 20980 -5430 0 0 {name=p20916 lab=clkbuf_9_387_0_CLK/A }
C {devices/lab_pin.sym} 21060 -5430 0 1 {name=p20917 lab=clkbuf_9_387_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 21020 -5430 0 0 {name=Xclkbuf_9_387_0_CLK }
C {devices/lab_pin.sym} 20960 -5320 0 0 {name=p20918 lab=_58985_/A }
C {devices/lab_pin.sym} 20960 -5280 0 0 {name=p20919 lab=_58988_/B }
C {devices/lab_pin.sym} 21080 -5300 0 1 {name=p20920 lab=_58985_/Y }
C {sky130_stdcells/nand2_4.sym} 21020 -5300 0 0 {name=X_58985_ }
C {devices/lab_pin.sym} 20960 -5190 0 0 {name=p20921 lab=_45950_/A }
C {devices/lab_pin.sym} 20960 -5150 0 0 {name=p20922 lab=_45950_/B }
C {devices/lab_pin.sym} 20960 -5110 0 0 {name=p20923 lab=_44210_/X }
C {devices/lab_pin.sym} 21080 -5150 0 1 {name=p20924 lab=_45950_/Y }
C {sky130_stdcells/nor3_4.sym} 21020 -5150 0 0 {name=X_45950_ }
C {devices/lab_pin.sym} 20980 -5010 0 0 {name=p20925 lab=_41072_/X }
C {devices/lab_pin.sym} 21060 -5010 0 1 {name=p20926 lab=_41073_/X }
C {sky130_stdcells/buf_2.sym} 21020 -5010 0 0 {name=X_41073_ }
C {devices/lab_pin.sym} 20940 -4910 0 0 {name=p20927 lab=_53055_/Y }
C {devices/lab_pin.sym} 20940 -4870 0 0 {name=p20928 lab=_53056_/X }
C {devices/lab_pin.sym} 20940 -4830 0 0 {name=p20929 lab=_53058_/X }
C {devices/lab_pin.sym} 21100 -4870 0 1 {name=p20930 lab=_53059_/Y }
C {sky130_stdcells/a21oi_4.sym} 21020 -4870 0 0 {name=X_53059_ }
C {devices/lab_pin.sym} 20940 -4770 0 0 {name=p20931 lab=_57868_/X }
C {devices/lab_pin.sym} 20940 -4730 0 0 {name=p20932 lab=_57934_/Y }
C {devices/lab_pin.sym} 20940 -4690 0 0 {name=p20933 lab=_57935_/Y }
C {devices/lab_pin.sym} 20940 -4650 0 0 {name=p20934 lab=_57899_/X }
C {devices/lab_pin.sym} 20940 -4610 0 0 {name=p20935 lab=_57872_/X }
C {devices/lab_pin.sym} 21100 -4690 0 1 {name=p20936 lab=_57936_/X }
C {sky130_stdcells/o32a_4.sym} 21020 -4690 0 0 {name=X_57936_ }
C {devices/lab_pin.sym} 20960 -4540 0 0 {name=p20937 lab=_76770_/A }
C {devices/lab_pin.sym} 20960 -4500 0 0 {name=p20938 lab=_76769_/Y }
C {devices/lab_pin.sym} 21080 -4520 0 1 {name=p20939 lab=_76771_/B }
C {sky130_stdcells/xnor2_4.sym} 21020 -4520 0 0 {name=X_76770_ }
C {devices/lab_pin.sym} 20980 -4390 0 0 {name=p20940 lab=_73367_/A }
C {devices/lab_pin.sym} 21060 -4390 0 1 {name=p20941 lab=_73982_/X }
C {sky130_stdcells/buf_2.sym} 21020 -4390 0 0 {name=X_73982_ }
C {devices/lab_pin.sym} 20930 -4270 0 0 {name=p20942 lab=_85679_/CLK }
C {devices/lab_pin.sym} 20930 -4250 0 0 {name=p20943 lab=_51670_/Y }
C {devices/lab_pin.sym} 21110 -4270 0 1 {name=p20944 lab=_85968_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -4260 0 0 {name=X_85968_ }
C {devices/lab_pin.sym} 20980 -4130 0 0 {name=p20945 lab=_45819_/A }
C {devices/lab_pin.sym} 21060 -4130 0 1 {name=p20946 lab=_44901_/X }
C {sky130_stdcells/buf_2.sym} 21020 -4130 0 0 {name=X_44901_ }
C {devices/lab_pin.sym} 20940 -4030 0 0 {name=p20947 lab=_80913_/Q }
C {devices/lab_pin.sym} 20940 -3990 0 0 {name=p20948 lab=_80785_/D }
C {devices/lab_pin.sym} 20940 -3950 0 0 {name=p20949 lab=_75720_/X }
C {devices/lab_pin.sym} 21100 -3990 0 1 {name=p20950 lab=_75722_/B }
C {sky130_stdcells/o21ai_4.sym} 21020 -3990 0 0 {name=X_75721_ }
C {devices/lab_pin.sym} 20930 -3850 0 0 {name=p20951 lab=_87195_/CLK }
C {devices/lab_pin.sym} 20930 -3830 0 0 {name=p20952 lab=_42810_/X }
C {devices/lab_pin.sym} 21110 -3850 0 1 {name=p20953 lab=_67901_/B }
C {sky130_stdcells/dfxtp_4.sym} 21020 -3840 0 0 {name=X_87707_ }
C {devices/lab_pin.sym} 20940 -3740 0 0 {name=p20954 lab=_72750_/X }
C {devices/lab_pin.sym} 20940 -3700 0 0 {name=p20955 lab=_85595_/Q }
C {devices/lab_pin.sym} 20940 -3660 0 0 {name=p20956 lab=_72839_/X }
C {devices/lab_pin.sym} 20940 -3620 0 0 {name=p20957 lab=_72932_/X }
C {devices/lab_pin.sym} 21100 -3680 0 1 {name=p20958 lab=_72933_/X }
C {sky130_stdcells/a211o_4.sym} 21020 -3680 0 0 {name=X_72933_ }
C {devices/lab_pin.sym} 20930 -3530 0 0 {name=p20959 lab=_84905_/CLK }
C {devices/lab_pin.sym} 20930 -3510 0 0 {name=p20960 lab=_84919_/D }
C {devices/lab_pin.sym} 21110 -3530 0 1 {name=p20961 lab=_58154_/A }
C {sky130_stdcells/dfxtp_4.sym} 21020 -3520 0 0 {name=X_84919_ }
C {devices/lab_pin.sym} 20980 -3390 0 0 {name=p20962 lab=_44196_/A }
C {devices/lab_pin.sym} 21060 -3390 0 1 {name=p20963 lab=_45882_/A }
C {sky130_stdcells/buf_2.sym} 21020 -3390 0 0 {name=X_45881_ }
C {devices/lab_pin.sym} 20980 -3270 0 0 {name=p20964 lab=_58827_/A }
C {devices/lab_pin.sym} 21060 -3270 0 1 {name=p20965 lab=_58696_/A }
C {sky130_stdcells/buf_2.sym} 21020 -3270 0 0 {name=X_57867_ }
C {devices/lab_pin.sym} 20980 -3150 0 0 {name=p20966 lab=clkbuf_9_311_0_CLK/A }
C {devices/lab_pin.sym} 21060 -3150 0 1 {name=p20967 lab=clkbuf_9_310_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 21020 -3150 0 0 {name=Xclkbuf_9_310_0_CLK }
C {devices/lab_pin.sym} 20930 -3030 0 0 {name=p20968 lab=_86210_/CLK }
C {devices/lab_pin.sym} 20930 -3010 0 0 {name=p20969 lab=_52051_/Y }
C {devices/lab_pin.sym} 21110 -3030 0 1 {name=p20970 lab=_85899_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21020 -3020 0 0 {name=X_85899_ }
C {devices/lab_pin.sym} 20980 -2890 0 0 {name=p20971 lab=_57563_/A }
C {devices/lab_pin.sym} 21060 -2890 0 1 {name=p20972 lab=_47620_/X }
C {sky130_stdcells/buf_2.sym} 21020 -2890 0 0 {name=X_47620_ }
C {devices/lab_pin.sym} 20980 -2770 0 0 {name=p20973 lab=_59605_/Y }
C {devices/lab_pin.sym} 21060 -2770 0 1 {name=p20974 lab=_59637_/A }
C {sky130_stdcells/buf_2.sym} 21020 -2770 0 0 {name=X_59606_ }
C {devices/lab_pin.sym} 20980 -2650 0 0 {name=p20975 lab=_78439_/Y }
C {devices/lab_pin.sym} 21060 -2650 0 1 {name=p20976 lab=_78450_/B }
C {sky130_stdcells/inv_2.sym} 21020 -2650 0 0 {name=X_78440_ }
C {devices/lab_pin.sym} 20980 -2530 0 0 {name=p20977 lab=clkbuf_8_209_0_CLK/A }
C {devices/lab_pin.sym} 21060 -2530 0 1 {name=p20978 lab=clkbuf_9_419_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 21020 -2530 0 0 {name=Xclkbuf_8_209_0_CLK }
C {devices/lab_pin.sym} 20980 -2410 0 0 {name=p20979 lab=_45980_/A }
C {devices/lab_pin.sym} 21060 -2410 0 1 {name=p20980 lab=_44832_/X }
C {sky130_stdcells/buf_2.sym} 21020 -2410 0 0 {name=X_44832_ }
C {devices/lab_pin.sym} 20940 -2310 0 0 {name=p20981 lab=_45882_/A }
C {devices/lab_pin.sym} 20940 -2270 0 0 {name=p20982 lab=_56670_/A }
C {devices/lab_pin.sym} 20940 -2230 0 0 {name=p20983 lab=_56817_/X }
C {devices/lab_pin.sym} 21100 -2270 0 1 {name=p20984 lab=_56818_/X }
C {sky130_stdcells/a21o_4.sym} 21020 -2270 0 0 {name=X_56818_ }
C {devices/lab_pin.sym} 20960 -2140 0 0 {name=p20985 lab=_75638_/A }
C {devices/lab_pin.sym} 20960 -2100 0 0 {name=p20986 lab=_75637_/Y }
C {devices/lab_pin.sym} 21080 -2120 0 1 {name=p20987 lab=_75652_/Y }
C {sky130_stdcells/nor2_4.sym} 21020 -2120 0 0 {name=X_75652_ }
C {devices/lab_pin.sym} 20930 -1990 0 0 {name=p20988 lab=_87189_/CLK }
C {devices/lab_pin.sym} 20930 -1970 0 0 {name=p20989 lab=_87638_/D }
C {devices/lab_pin.sym} 21110 -1990 0 1 {name=p20990 lab=_68018_/B }
C {sky130_stdcells/dfxtp_4.sym} 21020 -1980 0 0 {name=X_87638_ }
C {devices/lab_pin.sym} 20980 -1850 0 0 {name=p20991 lab=_73124_/B }
C {devices/lab_pin.sym} 21060 -1850 0 1 {name=p20992 lab=_73370_/B }
C {sky130_stdcells/buf_2.sym} 21020 -1850 0 0 {name=X_72864_ }
C {devices/lab_pin.sym} 20980 -1730 0 0 {name=p20993 lab=clkbuf_9_102_0_CLK/X }
C {devices/lab_pin.sym} 21060 -1730 0 1 {name=p20994 lab=_84269_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21020 -1730 0 0 {name=Xclkbuf_10_204_0_CLK }
C {devices/lab_pin.sym} 20980 -1610 0 0 {name=p20995 lab=_46210_/A }
C {devices/lab_pin.sym} 21060 -1610 0 1 {name=p20996 lab=_57866_/A }
C {sky130_stdcells/buf_2.sym} 21020 -1610 0 0 {name=X_57798_ }
C {devices/lab_pin.sym} 20940 -1520 0 0 {name=p20997 lab=_74591_/X }
C {devices/lab_pin.sym} 20940 -1480 0 0 {name=p20998 lab=_74599_/X }
C {devices/lab_pin.sym} 20940 -1440 0 0 {name=p20999 lab=_56130_/A }
C {devices/lab_pin.sym} 20940 -1400 0 0 {name=p21000 lab=_74600_/X }
C {devices/lab_pin.sym} 21100 -1460 0 1 {name=p21001 lab=_74603_/X }
C {sky130_stdcells/a211o_4.sym} 21020 -1460 0 0 {name=X_74603_ }
C {devices/lab_pin.sym} 20980 -1310 0 0 {name=p21002 lab=_83710_/Q }
C {devices/lab_pin.sym} 21060 -1310 0 1 {name=p21003 lab=_47552_/A }
C {sky130_stdcells/inv_2.sym} 21020 -1310 0 0 {name=X_47551_ }
C {devices/lab_pin.sym} 20980 -1190 0 0 {name=p21004 lab=clkbuf_9_417_0_CLK/X }
C {devices/lab_pin.sym} 21060 -1190 0 1 {name=p21005 lab=_84231_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21020 -1190 0 0 {name=Xclkbuf_10_834_0_CLK }
C {devices/lab_pin.sym} 20960 -1090 0 0 {name=p21006 lab=_71813_/A }
C {devices/lab_pin.sym} 20960 -1050 0 0 {name=p21007 lab=_71815_/B }
C {devices/lab_pin.sym} 20960 -1010 0 0 {name=p21008 lab=_71049_/A }
C {devices/lab_pin.sym} 21080 -1050 0 1 {name=p21009 lab=_71815_/X }
C {sky130_stdcells/and3_4.sym} 21020 -1050 0 0 {name=X_71815_ }
C {devices/lab_pin.sym} 20980 -910 0 0 {name=p21010 lab=_59537_/A }
C {devices/lab_pin.sym} 21060 -910 0 1 {name=p21011 lab=_59662_/B }
C {sky130_stdcells/inv_2.sym} 21020 -910 0 0 {name=X_59537_ }
C {devices/lab_pin.sym} 20960 -800 0 0 {name=p21012 lab=_78373_/A }
C {devices/lab_pin.sym} 20960 -760 0 0 {name=p21013 lab=_82663_/D }
C {devices/lab_pin.sym} 21080 -780 0 1 {name=p21014 lab=_78371_/Y }
C {sky130_stdcells/nor2_4.sym} 21020 -780 0 0 {name=X_78371_ }
C {devices/lab_pin.sym} 21860 -42180 0 0 {name=p21015 lab=_41327_/Y }
C {devices/lab_pin.sym} 21860 -42140 0 0 {name=p21016 lab=_44754_/X }
C {devices/lab_pin.sym} 21860 -42100 0 0 {name=p21017 lab=_86967_/Q }
C {devices/lab_pin.sym} 21860 -42060 0 0 {name=p21018 lab=_44755_/X }
C {devices/lab_pin.sym} 22020 -42120 0 1 {name=p21019 lab=_86967_/D }
C {sky130_stdcells/a2bb2o_4.sym} 21940 -42120 0 0 {name=X_44763_ }
C {devices/lab_pin.sym} 21860 -41990 0 0 {name=p21020 lab=_56713_/A }
C {devices/lab_pin.sym} 21860 -41950 0 0 {name=p21021 lab=_57149_/D }
C {devices/lab_pin.sym} 21860 -41910 0 0 {name=p21022 lab=_56739_/A }
C {devices/lab_pin.sym} 22020 -41950 0 1 {name=p21023 lab=_56749_/X }
C {sky130_stdcells/a21o_4.sym} 21940 -41950 0 0 {name=X_56749_ }
C {devices/lab_pin.sym} 21900 -41810 0 0 {name=p21024 lab=_75583_/A }
C {devices/lab_pin.sym} 21980 -41810 0 1 {name=p21025 lab=_75583_/Y }
C {sky130_stdcells/inv_2.sym} 21940 -41810 0 0 {name=X_75583_ }
C {devices/lab_pin.sym} 21850 -41690 0 0 {name=p21026 lab=_85895_/CLK }
C {devices/lab_pin.sym} 21850 -41670 0 0 {name=p21027 lab=_43118_/Y }
C {devices/lab_pin.sym} 22030 -41690 0 1 {name=p21028 lab=_87569_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -41680 0 0 {name=X_87569_ }
C {devices/lab_pin.sym} 21900 -41550 0 0 {name=p21029 lab=_42477_/A }
C {devices/lab_pin.sym} 21980 -41550 0 1 {name=p21030 lab=_41975_/X }
C {sky130_stdcells/buf_2.sym} 21940 -41550 0 0 {name=X_41975_ }
C {devices/lab_pin.sym} 21900 -41430 0 0 {name=p21031 lab=_72795_/A }
C {devices/lab_pin.sym} 21980 -41430 0 1 {name=p21032 lab=_73000_/B }
C {sky130_stdcells/buf_2.sym} 21940 -41430 0 0 {name=X_72795_ }
C {devices/lab_pin.sym} 21880 -41320 0 0 {name=p21033 lab=_46491_/A }
C {devices/lab_pin.sym} 21880 -41280 0 0 {name=p21034 lab=_51350_/B }
C {devices/lab_pin.sym} 22000 -41300 0 1 {name=p21035 lab=_46502_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -41300 0 0 {name=X_46502_ }
C {devices/lab_pin.sym} 21880 -41180 0 0 {name=p21036 lab=_81928_/Q }
C {devices/lab_pin.sym} 21880 -41140 0 0 {name=p21037 lab=_82184_/D }
C {devices/lab_pin.sym} 22000 -41160 0 1 {name=p21038 lab=_77322_/X }
C {sky130_stdcells/xor2_4.sym} 21940 -41160 0 0 {name=X_77322_ }
C {devices/lab_pin.sym} 21860 -41060 0 0 {name=p21039 lab=_40853_/X }
C {devices/lab_pin.sym} 21860 -41020 0 0 {name=p21040 lab=_43698_/X }
C {devices/lab_pin.sym} 21860 -40980 0 0 {name=p21041 lab=_69793_/B }
C {devices/lab_pin.sym} 21860 -40940 0 0 {name=p21042 lab=_43700_/X }
C {devices/lab_pin.sym} 22020 -41000 0 1 {name=p21043 lab=_43715_/A }
C {sky130_stdcells/a2bb2o_4.sym} 21940 -41000 0 0 {name=X_43714_ }
C {devices/lab_pin.sym} 21860 -40870 0 0 {name=p21044 lab=_52833_/B }
C {devices/lab_pin.sym} 21860 -40830 0 0 {name=p21045 lab=_74516_/X }
C {devices/lab_pin.sym} 21860 -40790 0 0 {name=p21046 lab=_74533_/Y }
C {devices/lab_pin.sym} 22020 -40830 0 1 {name=p21047 lab=_74534_/Y }
C {sky130_stdcells/o21ai_4.sym} 21940 -40830 0 0 {name=X_74534_ }
C {devices/lab_pin.sym} 21860 -40720 0 0 {name=p21048 lab=_40925_/X }
C {devices/lab_pin.sym} 21860 -40680 0 0 {name=p21049 lab=_40904_/X }
C {devices/lab_pin.sym} 21860 -40640 0 0 {name=p21050 lab=_69961_/B }
C {devices/lab_pin.sym} 21860 -40600 0 0 {name=p21051 lab=_40905_/X }
C {devices/lab_pin.sym} 22020 -40660 0 1 {name=p21052 lab=_40926_/X }
C {sky130_stdcells/a2bb2o_4.sym} 21940 -40660 0 0 {name=X_40926_ }
C {devices/lab_pin.sym} 21880 -40520 0 0 {name=p21053 lab=_47517_/A }
C {devices/lab_pin.sym} 21880 -40480 0 0 {name=p21054 lab=_53072_/B }
C {devices/lab_pin.sym} 22000 -40500 0 1 {name=p21055 lab=_47482_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -40500 0 0 {name=X_47482_ }
C {devices/lab_pin.sym} 21900 -40370 0 0 {name=p21056 lab=clkbuf_9_325_0_CLK/A }
C {devices/lab_pin.sym} 21980 -40370 0 1 {name=p21057 lab=clkbuf_9_325_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 21940 -40370 0 0 {name=Xclkbuf_9_325_0_CLK }
C {devices/lab_pin.sym} 21900 -40250 0 0 {name=p21058 lab=_70635_/A }
C {devices/lab_pin.sym} 21980 -40250 0 1 {name=p21059 lab=_71753_/B }
C {sky130_stdcells/buf_2.sym} 21940 -40250 0 0 {name=X_71746_ }
C {devices/lab_pin.sym} 21880 -40140 0 0 {name=p21060 lab=_59467_/Y }
C {devices/lab_pin.sym} 21880 -40100 0 0 {name=p21061 lab=_59478_/B }
C {devices/lab_pin.sym} 22000 -40120 0 1 {name=p21062 lab=_59468_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -40120 0 0 {name=X_59468_ }
C {devices/lab_pin.sym} 21900 -39990 0 0 {name=p21063 lab=_44694_/A }
C {devices/lab_pin.sym} 21980 -39990 0 1 {name=p21064 lab=_44694_/Y }
C {sky130_stdcells/inv_2.sym} 21940 -39990 0 0 {name=X_44694_ }
C {devices/lab_pin.sym} 21860 -39890 0 0 {name=p21065 lab=_49219_/Y }
C {devices/lab_pin.sym} 21860 -39850 0 0 {name=p21066 lab=_49214_/X }
C {devices/lab_pin.sym} 21860 -39810 0 0 {name=p21067 lab=_49220_/Y }
C {devices/lab_pin.sym} 22020 -39850 0 1 {name=p21068 lab=_86431_/D }
C {sky130_stdcells/a21boi_4.sym} 21940 -39850 0 0 {name=X_49221_ }
C {devices/lab_pin.sym} 21900 -39710 0 0 {name=p21069 lab=_46433_/A }
C {devices/lab_pin.sym} 21980 -39710 0 1 {name=p21070 lab=_51316_/B }
C {sky130_stdcells/buf_2.sym} 21940 -39710 0 0 {name=X_46433_ }
C {devices/lab_pin.sym} 21860 -39610 0 0 {name=p21071 lab=_58406_/X }
C {devices/lab_pin.sym} 21860 -39570 0 0 {name=p21072 lab=_83365_/Q }
C {devices/lab_pin.sym} 21860 -39530 0 0 {name=p21073 lab=_58418_/Y }
C {devices/lab_pin.sym} 22020 -39570 0 1 {name=p21074 lab=_58419_/X }
C {sky130_stdcells/o21a_4.sym} 21940 -39570 0 0 {name=X_58419_ }
C {devices/lab_pin.sym} 21900 -39430 0 0 {name=p21075 lab=_77253_/A }
C {devices/lab_pin.sym} 21980 -39430 0 1 {name=p21076 lab=_77253_/Y }
C {sky130_stdcells/inv_2.sym} 21940 -39430 0 0 {name=X_77253_ }
C {devices/lab_pin.sym} 21900 -39310 0 0 {name=p21077 lab=clkbuf_9_109_0_CLK/X }
C {devices/lab_pin.sym} 21980 -39310 0 1 {name=p21078 lab=_84507_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21940 -39310 0 0 {name=Xclkbuf_10_219_0_CLK }
C {devices/lab_pin.sym} 21860 -39220 0 0 {name=p21079 lab=_40691_/A }
C {devices/lab_pin.sym} 21860 -39180 0 0 {name=p21080 lab=_43634_/X }
C {devices/lab_pin.sym} 21860 -39140 0 0 {name=p21081 lab=_43644_/Y }
C {devices/lab_pin.sym} 21860 -39100 0 0 {name=p21082 lab=_43636_/X }
C {devices/lab_pin.sym} 22020 -39160 0 1 {name=p21083 lab=_43645_/X }
C {sky130_stdcells/a2bb2o_4.sym} 21940 -39160 0 0 {name=X_43645_ }
C {devices/lab_pin.sym} 21860 -39030 0 0 {name=p21084 lab=_74462_/Y }
C {devices/lab_pin.sym} 21860 -38990 0 0 {name=p21085 lab=_74463_/X }
C {devices/lab_pin.sym} 21860 -38950 0 0 {name=p21086 lab=_74464_/X }
C {devices/lab_pin.sym} 22020 -38990 0 1 {name=p21087 lab=_83061_/D }
C {sky130_stdcells/a21oi_4.sym} 21940 -38990 0 0 {name=X_74465_ }
C {devices/lab_pin.sym} 21900 -38850 0 0 {name=p21088 lab=_40783_/A }
C {devices/lab_pin.sym} 21980 -38850 0 1 {name=p21089 lab=_40857_/X }
C {sky130_stdcells/buf_2.sym} 21940 -38850 0 0 {name=X_40857_ }
C {devices/lab_pin.sym} 21860 -38750 0 0 {name=p21090 lab=_58476_/Y }
C {devices/lab_pin.sym} 21860 -38710 0 0 {name=p21091 lab=_71669_/X }
C {devices/lab_pin.sym} 21860 -38670 0 0 {name=p21092 lab=_71676_/Y }
C {devices/lab_pin.sym} 22020 -38710 0 1 {name=p21093 lab=_83415_/D }
C {sky130_stdcells/o21ai_4.sym} 21940 -38710 0 0 {name=X_71677_ }
C {devices/lab_pin.sym} 21880 -38580 0 0 {name=p21094 lab=_59399_/A }
C {devices/lab_pin.sym} 21880 -38540 0 0 {name=p21095 lab=_59399_/B }
C {devices/lab_pin.sym} 22000 -38560 0 1 {name=p21096 lab=_59399_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -38560 0 0 {name=X_59399_ }
C {devices/lab_pin.sym} 21900 -38430 0 0 {name=p21097 lab=clkbuf_9_424_0_CLK/X }
C {devices/lab_pin.sym} 21980 -38430 0 1 {name=p21098 lab=_82206_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21940 -38430 0 0 {name=Xclkbuf_10_849_0_CLK }
C {devices/lab_pin.sym} 21860 -38330 0 0 {name=p21099 lab=_76189_/A }
C {devices/lab_pin.sym} 21860 -38290 0 0 {name=p21100 lab=_76189_/B }
C {devices/lab_pin.sym} 21860 -38250 0 0 {name=p21101 lab=_76187_/Y }
C {devices/lab_pin.sym} 22020 -38290 0 1 {name=p21102 lab=_76205_/A }
C {sky130_stdcells/a21boi_4.sym} 21940 -38290 0 0 {name=X_76204_ }
C {devices/lab_pin.sym} 21860 -38170 0 0 {name=p21103 lab=_49146_/Y }
C {devices/lab_pin.sym} 21860 -38130 0 0 {name=p21104 lab=_49138_/X }
C {devices/lab_pin.sym} 21860 -38090 0 0 {name=p21105 lab=_49151_/X }
C {devices/lab_pin.sym} 22020 -38130 0 1 {name=p21106 lab=_86439_/D }
C {sky130_stdcells/a21oi_4.sym} 21940 -38130 0 0 {name=X_49152_ }
C {devices/lab_pin.sym} 21880 -38020 0 0 {name=p21107 lab=_61430_/A }
C {devices/lab_pin.sym} 21880 -37980 0 0 {name=p21108 lab=_61404_/X }
C {devices/lab_pin.sym} 21880 -37940 0 0 {name=p21109 lab=_61406_/C }
C {devices/lab_pin.sym} 21880 -37900 0 0 {name=p21110 lab=_61390_/D }
C {devices/lab_pin.sym} 22000 -37960 0 1 {name=p21111 lab=_61430_/Y }
C {sky130_stdcells/nand4_4.sym} 21940 -37960 0 0 {name=X_61430_ }
C {devices/lab_pin.sym} 21860 -37840 0 0 {name=p21112 lab=_42050_/Y }
C {devices/lab_pin.sym} 21860 -37800 0 0 {name=p21113 lab=_72974_/X }
C {devices/lab_pin.sym} 21860 -37760 0 0 {name=p21114 lab=_73393_/X }
C {devices/lab_pin.sym} 21860 -37720 0 0 {name=p21115 lab=_73415_/Y }
C {devices/lab_pin.sym} 22020 -37780 0 1 {name=p21116 lab=_73416_/X }
C {sky130_stdcells/a211o_4.sym} 21940 -37780 0 0 {name=X_73416_ }
C {devices/lab_pin.sym} 21900 -37630 0 0 {name=p21117 lab=_46279_/A }
C {devices/lab_pin.sym} 21980 -37630 0 1 {name=p21118 lab=_46364_/X }
C {sky130_stdcells/buf_2.sym} 21940 -37630 0 0 {name=X_46364_ }
C {devices/lab_pin.sym} 21880 -37520 0 0 {name=p21119 lab=HASH_ADDR[5] }
C {devices/lab_pin.sym} 21880 -37480 0 0 {name=p21120 lab=HASH_ADDR[4] }
C {devices/lab_pin.sym} 22000 -37500 0 1 {name=p21121 lab=_70668_/D }
C {sky130_stdcells/nor2_4.sym} 21940 -37500 0 0 {name=X_70628_ }
C {devices/lab_pin.sym} 21880 -37380 0 0 {name=p21122 lab=_77184_/A }
C {devices/lab_pin.sym} 21880 -37340 0 0 {name=p21123 lab=_77177_/A }
C {devices/lab_pin.sym} 22000 -37360 0 1 {name=p21124 lab=_77184_/X }
C {sky130_stdcells/and2_4.sym} 21940 -37360 0 0 {name=X_77184_ }
C {devices/lab_pin.sym} 21860 -37270 0 0 {name=p21125 lab=_43557_/X }
C {devices/lab_pin.sym} 21860 -37230 0 0 {name=p21126 lab=_43563_/X }
C {devices/lab_pin.sym} 21860 -37190 0 0 {name=p21127 lab=_40532_/X }
C {devices/lab_pin.sym} 21860 -37150 0 0 {name=p21128 lab=_87351_/Q }
C {devices/lab_pin.sym} 21860 -37110 0 0 {name=p21129 lab=_43058_/A }
C {devices/lab_pin.sym} 22020 -37190 0 1 {name=p21130 lab=_43577_/A }
C {sky130_stdcells/o32ai_4.sym} 21940 -37190 0 0 {name=X_43576_ }
C {devices/lab_pin.sym} 21880 -37050 0 0 {name=p21131 lab=_74396_/A }
C {devices/lab_pin.sym} 21880 -37010 0 0 {name=p21132 lab=_74395_/X }
C {devices/lab_pin.sym} 21880 -36970 0 0 {name=p21133 lab=_74366_/C }
C {devices/lab_pin.sym} 22000 -37010 0 1 {name=p21134 lab=_74396_/X }
C {sky130_stdcells/and3_4.sym} 21940 -37010 0 0 {name=X_74396_ }
C {devices/lab_pin.sym} 21860 -36910 0 0 {name=p21135 lab=_40758_/X }
C {devices/lab_pin.sym} 21860 -36870 0 0 {name=p21136 lab=_40759_/X }
C {devices/lab_pin.sym} 21860 -36830 0 0 {name=p21137 lab=_40787_/X }
C {devices/lab_pin.sym} 21860 -36790 0 0 {name=p21138 lab=_69627_/B }
C {devices/lab_pin.sym} 21860 -36750 0 0 {name=p21139 lab=_40744_/X }
C {devices/lab_pin.sym} 22020 -36830 0 1 {name=p21140 lab=_40788_/Y }
C {sky130_stdcells/o32ai_4.sym} 21940 -36830 0 0 {name=X_40788_ }
C {devices/lab_pin.sym} 21900 -36670 0 0 {name=p21141 lab=_48781_/A }
C {devices/lab_pin.sym} 21980 -36670 0 1 {name=p21142 lab=_48103_/X }
C {sky130_stdcells/buf_2.sym} 21940 -36670 0 0 {name=X_48103_ }
C {devices/lab_pin.sym} 21860 -36570 0 0 {name=p21143 lab=_85190_/Q }
C {devices/lab_pin.sym} 21860 -36530 0 0 {name=p21144 lab=_45252_/X }
C {devices/lab_pin.sym} 21860 -36490 0 0 {name=p21145 lab=_45314_/X }
C {devices/lab_pin.sym} 22020 -36530 0 1 {name=p21146 lab=_45315_/Y }
C {sky130_stdcells/o21ai_4.sym} 21940 -36530 0 0 {name=X_45315_ }
C {devices/lab_pin.sym} 21880 -36400 0 0 {name=p21147 lab=_76135_/A }
C {devices/lab_pin.sym} 21880 -36360 0 0 {name=p21148 lab=_76134_/Y }
C {devices/lab_pin.sym} 22000 -36380 0 1 {name=p21149 lab=_76136_/B }
C {sky130_stdcells/xor2_4.sym} 21940 -36380 0 0 {name=X_76135_ }
C {devices/lab_pin.sym} 21900 -36250 0 0 {name=p21150 lab=_42547_/A }
C {devices/lab_pin.sym} 21980 -36250 0 1 {name=p21151 lab=_42527_/X }
C {sky130_stdcells/buf_2.sym} 21940 -36250 0 0 {name=X_42527_ }
C {devices/lab_pin.sym} 21860 -36170 0 0 {name=p21152 lab=_61354_/Y }
C {devices/lab_pin.sym} 21860 -36130 0 0 {name=p21153 lab=_61357_/Y }
C {devices/lab_pin.sym} 21860 -36090 0 0 {name=p21154 lab=_61334_/X }
C {devices/lab_pin.sym} 21860 -36050 0 0 {name=p21155 lab=_61358_/Y }
C {devices/lab_pin.sym} 21860 -36020 0 0 {name=p21156 lab=_61360_/Y }
C {devices/lab_pin.sym} 22020 -36090 0 1 {name=p21157 lab=_61361_/X }
C {sky130_stdcells/a41o_4.sym} 21940 -36090 0 0 {name=X_61361_ }
C {devices/lab_pin.sym} 21900 -35930 0 0 {name=p21158 lab=_49083_/A }
C {devices/lab_pin.sym} 21980 -35930 0 1 {name=p21159 lab=_50153_/B }
C {sky130_stdcells/buf_2.sym} 21940 -35930 0 0 {name=X_49083_ }
C {devices/lab_pin.sym} 21900 -35810 0 0 {name=p21160 lab=_72951_/A }
C {devices/lab_pin.sym} 21980 -35810 0 1 {name=p21161 lab=_73347_/X }
C {sky130_stdcells/buf_2.sym} 21940 -35810 0 0 {name=X_73347_ }
C {devices/lab_pin.sym} 21900 -35690 0 0 {name=p21162 lab=_46295_/A }
C {devices/lab_pin.sym} 21980 -35690 0 1 {name=p21163 lab=_46295_/X }
C {sky130_stdcells/buf_2.sym} 21940 -35690 0 0 {name=X_46295_ }
C {devices/lab_pin.sym} 21880 -35600 0 0 {name=p21164 lab=_70558_/X }
C {devices/lab_pin.sym} 21880 -35560 0 0 {name=p21165 lab=_70549_/X }
C {devices/lab_pin.sym} 21880 -35520 0 0 {name=p21166 lab=_70568_/C }
C {devices/lab_pin.sym} 21880 -35480 0 0 {name=p21167 lab=_70550_/D }
C {devices/lab_pin.sym} 22000 -35540 0 1 {name=p21168 lab=_70559_/Y }
C {sky130_stdcells/nor4_4.sym} 21940 -35540 0 0 {name=X_70559_ }
C {devices/lab_pin.sym} 21880 -35420 0 0 {name=p21169 lab=_63100_/A }
C {devices/lab_pin.sym} 21880 -35380 0 0 {name=p21170 lab=_63100_/B }
C {devices/lab_pin.sym} 21880 -35340 0 0 {name=p21171 lab=_63079_/C }
C {devices/lab_pin.sym} 21880 -35300 0 0 {name=p21172 lab=_63066_/D }
C {devices/lab_pin.sym} 22000 -35360 0 1 {name=p21173 lab=_63100_/X }
C {sky130_stdcells/and4_4.sym} 21940 -35360 0 0 {name=X_63100_ }
C {devices/lab_pin.sym} 21880 -35240 0 0 {name=p21174 lab=_59755_/A }
C {devices/lab_pin.sym} 21880 -35200 0 0 {name=p21175 lab=_59716_/A }
C {devices/lab_pin.sym} 21880 -35160 0 0 {name=p21176 lab=_60312_/C }
C {devices/lab_pin.sym} 21880 -35120 0 0 {name=p21177 lab=_60312_/D }
C {devices/lab_pin.sym} 22000 -35180 0 1 {name=p21178 lab=_60312_/Y }
C {sky130_stdcells/nand4_4.sym} 21940 -35180 0 0 {name=X_60312_ }
C {devices/lab_pin.sym} 21880 -35040 0 0 {name=p21179 lab=_48044_/A }
C {devices/lab_pin.sym} 21880 -35000 0 0 {name=p21180 lab=_48034_/B }
C {devices/lab_pin.sym} 22000 -35020 0 1 {name=p21181 lab=_48034_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -35020 0 0 {name=X_48034_ }
C {devices/lab_pin.sym} 21860 -34910 0 0 {name=p21182 lab=_45243_/X }
C {devices/lab_pin.sym} 21860 -34870 0 0 {name=p21183 lab=_45245_/Y }
C {devices/lab_pin.sym} 21860 -34830 0 0 {name=p21184 lab=_45200_/X }
C {devices/lab_pin.sym} 22020 -34870 0 1 {name=p21185 lab=_45246_/Y }
C {sky130_stdcells/a21oi_4.sym} 21940 -34870 0 0 {name=X_45246_ }
C {devices/lab_pin.sym} 21900 -34730 0 0 {name=p21186 lab=_60926_/X }
C {devices/lab_pin.sym} 21980 -34730 0 1 {name=p21187 lab=_64179_/D }
C {sky130_stdcells/buf_2.sym} 21940 -34730 0 0 {name=X_64080_ }
C {devices/lab_pin.sym} 21880 -34620 0 0 {name=p21188 lab=_76065_/Y }
C {devices/lab_pin.sym} 21880 -34580 0 0 {name=p21189 lab=_76063_/C }
C {devices/lab_pin.sym} 22000 -34600 0 1 {name=p21190 lab=_76066_/X }
C {sky130_stdcells/and2_4.sym} 21940 -34600 0 0 {name=X_76066_ }
C {devices/lab_pin.sym} 21860 -34510 0 0 {name=p21191 lab=_51238_/B }
C {devices/lab_pin.sym} 21860 -34470 0 0 {name=p21192 lab=_42430_/X }
C {devices/lab_pin.sym} 21860 -34430 0 0 {name=p21193 lab=_40581_/X }
C {devices/lab_pin.sym} 21860 -34390 0 0 {name=p21194 lab=_87857_/Q }
C {devices/lab_pin.sym} 21860 -34350 0 0 {name=p21195 lab=_42453_/X }
C {devices/lab_pin.sym} 22020 -34430 0 1 {name=p21196 lab=_42458_/Y }
C {sky130_stdcells/o32ai_4.sym} 21940 -34430 0 0 {name=X_42458_ }
C {devices/lab_pin.sym} 21900 -34270 0 0 {name=p21197 lab=_61292_/A }
C {devices/lab_pin.sym} 21980 -34270 0 1 {name=p21198 lab=_61329_/A }
C {sky130_stdcells/buf_2.sym} 21940 -34270 0 0 {name=X_61292_ }
C {devices/lab_pin.sym} 21900 -34150 0 0 {name=p21199 lab=_44189_/X }
C {devices/lab_pin.sym} 21980 -34150 0 1 {name=p21200 lab=_74246_/B }
C {sky130_stdcells/buf_2.sym} 21940 -34150 0 0 {name=X_73278_ }
C {devices/lab_pin.sym} 21860 -34070 0 0 {name=p21201 lab=_63025_/Y }
C {devices/lab_pin.sym} 21860 -34030 0 0 {name=p21202 lab=_63026_/X }
C {devices/lab_pin.sym} 21860 -33990 0 0 {name=p21203 lab=_63029_/X }
C {devices/lab_pin.sym} 21860 -33950 0 0 {name=p21204 lab=_63030_/X }
C {devices/lab_pin.sym} 21860 -33910 0 0 {name=p21205 lab=_63020_/X }
C {devices/lab_pin.sym} 22020 -33990 0 1 {name=p21206 lab=_63031_/Y }
C {sky130_stdcells/o41ai_4.sym} 21940 -33990 0 0 {name=X_63031_ }
C {devices/lab_pin.sym} 21900 -33830 0 0 {name=p21207 lab=_75016_/Y }
C {devices/lab_pin.sym} 21980 -33830 0 1 {name=p21208 lab=_75017_/Y }
C {sky130_stdcells/inv_2.sym} 21940 -33830 0 0 {name=X_75017_ }
C {devices/lab_pin.sym} 21860 -33750 0 0 {name=p21209 lab=_41399_/X }
C {devices/lab_pin.sym} 21860 -33710 0 0 {name=p21210 lab=_41400_/X }
C {devices/lab_pin.sym} 21860 -33670 0 0 {name=p21211 lab=_41408_/X }
C {devices/lab_pin.sym} 21860 -33630 0 0 {name=p21212 lab=_88220_/Q }
C {devices/lab_pin.sym} 21860 -33590 0 0 {name=p21213 lab=_41388_/X }
C {devices/lab_pin.sym} 22020 -33670 0 1 {name=p21214 lab=_41410_/A }
C {sky130_stdcells/o32ai_4.sym} 21940 -33670 0 0 {name=X_41409_ }
C {devices/lab_pin.sym} 21900 -33510 0 0 {name=p21215 lab=_60525_/A }
C {devices/lab_pin.sym} 21980 -33510 0 1 {name=p21216 lab=_60244_/B }
C {sky130_stdcells/buf_2.sym} 21940 -33510 0 0 {name=X_60243_ }
C {devices/lab_pin.sym} 21860 -33410 0 0 {name=p21217 lab=_72155_/X }
C {devices/lab_pin.sym} 21860 -33370 0 0 {name=p21218 lab=_85688_/Q }
C {devices/lab_pin.sym} 21860 -33330 0 0 {name=p21219 lab=_72156_/X }
C {devices/lab_pin.sym} 22020 -33370 0 1 {name=p21220 lab=_72229_/X }
C {sky130_stdcells/o21a_4.sym} 21940 -33370 0 0 {name=X_72229_ }
C {devices/lab_pin.sym} 21860 -33250 0 0 {name=p21221 lab=_55823_/B }
C {devices/lab_pin.sym} 21860 -33210 0 0 {name=p21222 lab=_45134_/X }
C {devices/lab_pin.sym} 21860 -33170 0 0 {name=p21223 lab=_45116_/X }
C {devices/lab_pin.sym} 22020 -33210 0 1 {name=p21224 lab=_45177_/X }
C {sky130_stdcells/o21a_4.sym} 21940 -33210 0 0 {name=X_45177_ }
C {devices/lab_pin.sym} 21900 -33070 0 0 {name=p21225 lab=_41911_/A }
C {devices/lab_pin.sym} 21980 -33070 0 1 {name=p21226 lab=_42389_/X }
C {sky130_stdcells/buf_2.sym} 21940 -33070 0 0 {name=X_42389_ }
C {devices/lab_pin.sym} 21900 -32950 0 0 {name=p21227 lab=_44127_/X }
C {devices/lab_pin.sym} 21980 -32950 0 1 {name=p21228 lab=_44128_/X }
C {sky130_stdcells/buf_2.sym} 21940 -32950 0 0 {name=X_44128_ }
C {devices/lab_pin.sym} 21880 -32840 0 0 {name=p21229 lab=_84228_/Q }
C {devices/lab_pin.sym} 21880 -32800 0 0 {name=p21230 lab=_83276_/Q }
C {devices/lab_pin.sym} 22000 -32820 0 1 {name=p21231 lab=_79825_/X }
C {sky130_stdcells/xor2_4.sym} 21940 -32820 0 0 {name=X_79825_ }
C {devices/lab_pin.sym} 21880 -32720 0 0 {name=p21232 lab=_72625_/B }
C {devices/lab_pin.sym} 21880 -32680 0 0 {name=p21233 lab=_72625_/A }
C {devices/lab_pin.sym} 21880 -32640 0 0 {name=p21234 lab=_60174_/C }
C {devices/lab_pin.sym} 21880 -32600 0 0 {name=p21235 lab=_60174_/D }
C {devices/lab_pin.sym} 22000 -32660 0 1 {name=p21236 lab=_60174_/X }
C {sky130_stdcells/and4_4.sym} 21940 -32660 0 0 {name=X_60174_ }
C {devices/lab_pin.sym} 21860 -32530 0 0 {name=p21237 lab=_49982_/Y }
C {devices/lab_pin.sym} 21860 -32490 0 0 {name=p21238 lab=_49977_/X }
C {devices/lab_pin.sym} 21860 -32450 0 0 {name=p21239 lab=_49984_/X }
C {devices/lab_pin.sym} 22020 -32490 0 1 {name=p21240 lab=_49985_/Y }
C {sky130_stdcells/a21oi_4.sym} 21940 -32490 0 0 {name=X_49985_ }
C {devices/lab_pin.sym} 21880 -32360 0 0 {name=p21241 lab=_48936_/A }
C {devices/lab_pin.sym} 21880 -32320 0 0 {name=p21242 lab=_48699_/B }
C {devices/lab_pin.sym} 22000 -32340 0 1 {name=p21243 lab=_48936_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -32340 0 0 {name=X_48936_ }
C {devices/lab_pin.sym} 21900 -32210 0 0 {name=p21244 lab=_44059_/A }
C {devices/lab_pin.sym} 21980 -32210 0 1 {name=p21245 lab=_44059_/X }
C {sky130_stdcells/buf_2.sym} 21940 -32210 0 0 {name=X_44059_ }
C {devices/lab_pin.sym} 21900 -32090 0 0 {name=p21246 lab=_68402_/A }
C {devices/lab_pin.sym} 21980 -32090 0 1 {name=p21247 lab=_67770_/X }
C {sky130_stdcells/buf_2.sym} 21940 -32090 0 0 {name=X_67770_ }
C {devices/lab_pin.sym} 21880 -31980 0 0 {name=p21248 lab=_79761_/A }
C {devices/lab_pin.sym} 21880 -31940 0 0 {name=p21249 lab=_79761_/B }
C {devices/lab_pin.sym} 22000 -31960 0 1 {name=p21250 lab=_79756_/Y }
C {sky130_stdcells/xnor2_4.sym} 21940 -31960 0 0 {name=X_79756_ }
C {devices/lab_pin.sym} 21860 -31860 0 0 {name=p21251 lab=_44150_/X }
C {devices/lab_pin.sym} 21860 -31820 0 0 {name=p21252 lab=_86739_/Q }
C {devices/lab_pin.sym} 21860 -31780 0 0 {name=p21253 lab=_64980_/X }
C {devices/lab_pin.sym} 21860 -31740 0 0 {name=p21254 lab=_64981_/X }
C {devices/lab_pin.sym} 22020 -31800 0 1 {name=p21255 lab=_64982_/X }
C {sky130_stdcells/a211o_4.sym} 21940 -31800 0 0 {name=X_64982_ }
C {devices/lab_pin.sym} 21900 -31650 0 0 {name=p21256 lab=_76967_/Y }
C {devices/lab_pin.sym} 21980 -31650 0 1 {name=p21257 lab=_76968_/Y }
C {sky130_stdcells/inv_2.sym} 21940 -31650 0 0 {name=X_76968_ }
C {devices/lab_pin.sym} 21880 -31540 0 0 {name=p21258 lab=_66651_/A }
C {devices/lab_pin.sym} 21880 -31500 0 0 {name=p21259 lab=_87629_/Q }
C {devices/lab_pin.sym} 22000 -31520 0 1 {name=p21260 lab=_66721_/X }
C {sky130_stdcells/and2_4.sym} 21940 -31520 0 0 {name=X_66721_ }
C {devices/lab_pin.sym} 21880 -31400 0 0 {name=p21261 lab=_78707_/A }
C {devices/lab_pin.sym} 21880 -31360 0 0 {name=p21262 lab=_82780_/D }
C {devices/lab_pin.sym} 22000 -31380 0 1 {name=p21263 lab=_82492_/D }
C {sky130_stdcells/xor2_4.sym} 21940 -31380 0 0 {name=X_78707_ }
C {devices/lab_pin.sym} 21880 -31280 0 0 {name=p21264 lab=_61483_/A }
C {devices/lab_pin.sym} 21880 -31240 0 0 {name=p21265 lab=_63947_/B }
C {devices/lab_pin.sym} 21880 -31200 0 0 {name=p21266 lab=_63947_/C }
C {devices/lab_pin.sym} 21880 -31160 0 0 {name=p21267 lab=_63866_/X }
C {devices/lab_pin.sym} 22000 -31220 0 1 {name=p21268 lab=_63933_/Y }
C {sky130_stdcells/nand4_4.sym} 21940 -31220 0 0 {name=X_63933_ }
C {devices/lab_pin.sym} 21880 -31080 0 0 {name=p21269 lab=_84517_/Q }
C {devices/lab_pin.sym} 21880 -31040 0 0 {name=p21270 lab=_84389_/Q }
C {devices/lab_pin.sym} 22000 -31060 0 1 {name=p21271 lab=_80733_/D }
C {sky130_stdcells/xor2_4.sym} 21940 -31060 0 0 {name=X_75919_ }
C {devices/lab_pin.sym} 21860 -30950 0 0 {name=p21272 lab=_48864_/Y }
C {devices/lab_pin.sym} 21860 -30910 0 0 {name=p21273 lab=_48865_/X }
C {devices/lab_pin.sym} 21860 -30870 0 0 {name=p21274 lab=_48866_/X }
C {devices/lab_pin.sym} 22020 -30910 0 1 {name=p21275 lab=_86468_/D }
C {sky130_stdcells/a21oi_4.sym} 21940 -30910 0 0 {name=X_48867_ }
C {devices/lab_pin.sym} 21880 -30780 0 0 {name=p21276 lab=_79704_/B }
C {devices/lab_pin.sym} 21880 -30740 0 0 {name=p21277 lab=_79686_/Y }
C {devices/lab_pin.sym} 22000 -30760 0 1 {name=p21278 lab=_79687_/X }
C {sky130_stdcells/xor2_4.sym} 21940 -30760 0 0 {name=X_79687_ }
C {devices/lab_pin.sym} 21880 -30640 0 0 {name=p21279 lab=_76899_/A }
C {devices/lab_pin.sym} 21880 -30600 0 0 {name=p21280 lab=_76899_/B }
C {devices/lab_pin.sym} 22000 -30620 0 1 {name=p21281 lab=_76899_/Y }
C {sky130_stdcells/nor2_4.sym} 21940 -30620 0 0 {name=X_76899_ }
C {devices/lab_pin.sym} 21880 -30500 0 0 {name=p21282 lab=_69286_/A }
C {devices/lab_pin.sym} 21880 -30460 0 0 {name=p21283 lab=_87773_/Q }
C {devices/lab_pin.sym} 22000 -30480 0 1 {name=p21284 lab=_69440_/X }
C {sky130_stdcells/and2_4.sym} 21940 -30480 0 0 {name=X_69440_ }
C {devices/lab_pin.sym} 21900 -30350 0 0 {name=p21285 lab=_47818_/A }
C {devices/lab_pin.sym} 21980 -30350 0 1 {name=p21286 lab=_53259_/B }
C {sky130_stdcells/buf_2.sym} 21940 -30350 0 0 {name=X_47818_ }
C {devices/lab_pin.sym} 21880 -30240 0 0 {name=p21287 lab=_78638_/A }
C {devices/lab_pin.sym} 21880 -30200 0 0 {name=p21288 lab=_78638_/B }
C {devices/lab_pin.sym} 22000 -30220 0 1 {name=p21289 lab=_78639_/A }
C {sky130_stdcells/and2_4.sym} 21940 -30220 0 0 {name=X_78638_ }
C {devices/lab_pin.sym} 21860 -30120 0 0 {name=p21290 lab=_87952_/Q }
C {devices/lab_pin.sym} 21860 -30080 0 0 {name=p21291 lab=_66562_/X }
C {devices/lab_pin.sym} 21860 -30040 0 0 {name=p21292 lab=_66564_/X }
C {devices/lab_pin.sym} 21860 -30000 0 0 {name=p21293 lab=_66651_/X }
C {devices/lab_pin.sym} 22020 -30060 0 1 {name=p21294 lab=_66652_/X }
C {sky130_stdcells/a211o_4.sym} 21940 -30060 0 0 {name=X_66652_ }
C {devices/lab_pin.sym} 21880 -29930 0 0 {name=p21295 lab=_63848_/X }
C {devices/lab_pin.sym} 21880 -29890 0 0 {name=p21296 lab=_63849_/X }
C {devices/lab_pin.sym} 21880 -29850 0 0 {name=p21297 lab=_63864_/C }
C {devices/lab_pin.sym} 22000 -29890 0 1 {name=p21298 lab=_63864_/Y }
C {sky130_stdcells/nor3_4.sym} 21940 -29890 0 0 {name=X_63864_ }
C {devices/lab_pin.sym} 21860 -29770 0 0 {name=p21299 lab=_48794_/Y }
C {devices/lab_pin.sym} 21860 -29730 0 0 {name=p21300 lab=_48785_/X }
C {devices/lab_pin.sym} 21860 -29690 0 0 {name=p21301 lab=_48797_/X }
C {devices/lab_pin.sym} 22020 -29730 0 1 {name=p21302 lab=_86481_/D }
C {sky130_stdcells/a21oi_4.sym} 21940 -29730 0 0 {name=X_48798_ }
C {devices/lab_pin.sym} 21900 -29590 0 0 {name=p21303 lab=_64739_/A }
C {devices/lab_pin.sym} 21980 -29590 0 1 {name=p21304 lab=_65634_/A }
C {sky130_stdcells/buf_2.sym} 21940 -29590 0 0 {name=X_65603_ }
C {devices/lab_pin.sym} 21860 -29510 0 0 {name=p21305 lab=_62810_/Y }
C {devices/lab_pin.sym} 21860 -29470 0 0 {name=p21306 lab=_62772_/X }
C {devices/lab_pin.sym} 21860 -29430 0 0 {name=p21307 lab=_62812_/Y }
C {devices/lab_pin.sym} 21860 -29390 0 0 {name=p21308 lab=_62813_/Y }
C {devices/lab_pin.sym} 21860 -29360 0 0 {name=p21309 lab=_62814_/X }
C {devices/lab_pin.sym} 22020 -29430 0 1 {name=p21310 lab=_62815_/X }
C {sky130_stdcells/a41o_4.sym} 21940 -29430 0 0 {name=X_62815_ }
C {devices/lab_pin.sym} 21900 -29270 0 0 {name=p21311 lab=_69371_/A }
C {devices/lab_pin.sym} 21980 -29270 0 1 {name=p21312 lab=_69371_/X }
C {sky130_stdcells/buf_2.sym} 21940 -29270 0 0 {name=X_69371_ }
C {devices/lab_pin.sym} 21880 -29180 0 0 {name=p21313 lab=_47758_/A }
C {devices/lab_pin.sym} 21880 -29140 0 0 {name=p21314 lab=_47777_/B }
C {devices/lab_pin.sym} 21880 -29100 0 0 {name=p21315 lab=_47749_/C }
C {devices/lab_pin.sym} 21880 -29060 0 0 {name=p21316 lab=_53223_/D }
C {devices/lab_pin.sym} 22000 -29120 0 1 {name=p21317 lab=_47749_/X }
C {sky130_stdcells/and4_4.sym} 21940 -29120 0 0 {name=X_47749_ }
C {devices/lab_pin.sym} 21880 -28980 0 0 {name=p21318 lab=_66683_/A }
C {devices/lab_pin.sym} 21880 -28940 0 0 {name=p21319 lab=_66583_/B }
C {devices/lab_pin.sym} 22000 -28960 0 1 {name=p21320 lab=_66583_/X }
C {sky130_stdcells/and2_4.sym} 21940 -28960 0 0 {name=X_66583_ }
C {devices/lab_pin.sym} 21880 -28850 0 0 {name=p21321 lab=_78569_/A }
C {devices/lab_pin.sym} 21880 -28810 0 0 {name=p21322 lab=_78569_/B }
C {devices/lab_pin.sym} 21880 -28770 0 0 {name=p21323 lab=_78569_/C }
C {devices/lab_pin.sym} 22000 -28810 0 1 {name=p21324 lab=_78569_/X }
C {sky130_stdcells/or3_4.sym} 21940 -28810 0 0 {name=X_78569_ }
C {devices/lab_pin.sym} 21900 -28670 0 0 {name=p21325 lab=_64032_/A }
C {devices/lab_pin.sym} 21980 -28670 0 1 {name=p21326 lab=_63860_/B }
C {sky130_stdcells/buf_2.sym} 21940 -28670 0 0 {name=X_63795_ }
C {devices/lab_pin.sym} 21860 -28570 0 0 {name=p21327 lab=_80554_/Y }
C {devices/lab_pin.sym} 21860 -28530 0 0 {name=p21328 lab=_80594_/X }
C {devices/lab_pin.sym} 21860 -28490 0 0 {name=p21329 lab=_80599_/Y }
C {devices/lab_pin.sym} 22020 -28530 0 1 {name=p21330 lab=_80600_/Y }
C {sky130_stdcells/a21oi_4.sym} 21940 -28530 0 0 {name=X_80600_ }
C {devices/lab_pin.sym} 21860 -28410 0 0 {name=p21331 lab=_83983_/Q }
C {devices/lab_pin.sym} 21860 -28370 0 0 {name=p21332 lab=_68318_/X }
C {devices/lab_pin.sym} 21860 -28330 0 0 {name=p21333 lab=_68321_/X }
C {devices/lab_pin.sym} 22020 -28370 0 1 {name=p21334 lab=_83983_/D }
C {sky130_stdcells/a21bo_4.sym} 21940 -28370 0 0 {name=X_68322_ }
C {devices/lab_pin.sym} 21900 -28230 0 0 {name=p21335 lab=_65400_/A }
C {devices/lab_pin.sym} 21980 -28230 0 1 {name=p21336 lab=_65534_/X }
C {sky130_stdcells/buf_2.sym} 21940 -28230 0 0 {name=X_65534_ }
C {devices/lab_pin.sym} 21860 -28130 0 0 {name=p21337 lab=_50758_/Y }
C {devices/lab_pin.sym} 21860 -28090 0 0 {name=p21338 lab=_50735_/X }
C {devices/lab_pin.sym} 21860 -28050 0 0 {name=p21339 lab=_50759_/Y }
C {devices/lab_pin.sym} 22020 -28090 0 1 {name=p21340 lab=_86139_/D }
C {sky130_stdcells/a21boi_4.sym} 21940 -28090 0 0 {name=X_50760_ }
C {devices/lab_pin.sym} 21860 -27990 0 0 {name=p21341 lab=_62739_/Y }
C {devices/lab_pin.sym} 21860 -27950 0 0 {name=p21342 lab=_62713_/X }
C {devices/lab_pin.sym} 21860 -27910 0 0 {name=p21343 lab=_62740_/Y }
C {devices/lab_pin.sym} 21860 -27870 0 0 {name=p21344 lab=_62743_/Y }
C {devices/lab_pin.sym} 21860 -27840 0 0 {name=p21345 lab=_62745_/X }
C {devices/lab_pin.sym} 22020 -27910 0 1 {name=p21346 lab=_62746_/X }
C {sky130_stdcells/a41o_4.sym} 21940 -27910 0 0 {name=X_62746_ }
C {devices/lab_pin.sym} 21850 -27750 0 0 {name=p21347 lab=_81352_/CLK }
C {devices/lab_pin.sym} 21850 -27730 0 0 {name=p21348 lab=_84180_/Q }
C {devices/lab_pin.sym} 22030 -27750 0 1 {name=p21349 lab=_76745_/A }
C {sky130_stdcells/dfxtp_4.sym} 21940 -27740 0 0 {name=X_81580_ }
C {devices/lab_pin.sym} 21860 -27630 0 0 {name=p21350 lab=_58687_/B }
C {devices/lab_pin.sym} 21860 -27590 0 0 {name=p21351 lab=_49415_/X }
C {devices/lab_pin.sym} 21860 -27550 0 0 {name=p21352 lab=_49418_/Y }
C {devices/lab_pin.sym} 22020 -27590 0 1 {name=p21353 lab=_49419_/Y }
C {sky130_stdcells/o21ai_4.sym} 21940 -27590 0 0 {name=X_49419_ }
C {devices/lab_pin.sym} 21880 -27460 0 0 {name=p21354 lab=_80531_/A }
C {devices/lab_pin.sym} 21880 -27420 0 0 {name=p21355 lab=_80531_/B }
C {devices/lab_pin.sym} 22000 -27440 0 1 {name=p21356 lab=_80531_/X }
C {sky130_stdcells/or2_4.sym} 21940 -27440 0 0 {name=X_80531_ }
C {devices/lab_pin.sym} 21860 -27330 0 0 {name=p21357 lab=_82648_/D }
C {devices/lab_pin.sym} 21860 -27290 0 0 {name=p21358 lab=_68238_/X }
C {devices/lab_pin.sym} 21860 -27250 0 0 {name=p21359 lab=_68252_/X }
C {devices/lab_pin.sym} 22020 -27290 0 1 {name=p21360 lab=_68253_/X }
C {sky130_stdcells/a21bo_4.sym} 21940 -27290 0 0 {name=X_68253_ }
C {devices/lab_pin.sym} 21900 -27150 0 0 {name=p21361 lab=_65929_/A }
C {devices/lab_pin.sym} 21980 -27150 0 1 {name=p21362 lab=_65546_/B }
C {sky130_stdcells/buf_2.sym} 21940 -27150 0 0 {name=X_65465_ }
C {devices/lab_pin.sym} 21860 -27050 0 0 {name=p21363 lab=_86152_/Q }
C {devices/lab_pin.sym} 21860 -27010 0 0 {name=p21364 lab=_50680_/X }
C {devices/lab_pin.sym} 21860 -26970 0 0 {name=p21365 lab=_50690_/Y }
C {devices/lab_pin.sym} 22020 -27010 0 1 {name=p21366 lab=_50691_/Y }
C {sky130_stdcells/o21ai_4.sym} 21940 -27010 0 0 {name=X_50691_ }
C {devices/lab_pin.sym} 21860 -26910 0 0 {name=p21367 lab=_58225_/X }
C {devices/lab_pin.sym} 21860 -26870 0 0 {name=p21368 lab=_60221_/A }
C {devices/lab_pin.sym} 21860 -26830 0 0 {name=p21369 lab=_60205_/X }
C {devices/lab_pin.sym} 21860 -26790 0 0 {name=p21370 lab=_60263_/C }
C {devices/lab_pin.sym} 21860 -26760 0 0 {name=p21371 lab=_62676_/X }
C {devices/lab_pin.sym} 22020 -26830 0 1 {name=p21372 lab=_62677_/Y }
C {sky130_stdcells/a41oi_4.sym} 21940 -26830 0 0 {name=X_62677_ }
C {devices/lab_pin.sym} 21900 -26670 0 0 {name=p21373 lab=_67203_/X }
C {devices/lab_pin.sym} 21980 -26670 0 1 {name=p21374 lab=_67204_/X }
C {sky130_stdcells/buf_2.sym} 21940 -26670 0 0 {name=X_67204_ }
C {devices/lab_pin.sym} 21900 -26550 0 0 {name=p21375 lab=_52462_/A }
C {devices/lab_pin.sym} 21980 -26550 0 1 {name=p21376 lab=_52430_/X }
C {sky130_stdcells/buf_2.sym} 21940 -26550 0 0 {name=X_52430_ }
C {devices/lab_pin.sym} 21860 -26450 0 0 {name=p21377 lab=_64409_/Y }
C {devices/lab_pin.sym} 21860 -26410 0 0 {name=p21378 lab=_64415_/X }
C {devices/lab_pin.sym} 21860 -26370 0 0 {name=p21379 lab=_64386_/X }
C {devices/lab_pin.sym} 22020 -26410 0 1 {name=p21380 lab=_64416_/X }
C {sky130_stdcells/o21a_4.sym} 21940 -26410 0 0 {name=X_64416_ }
C {devices/lab_pin.sym} 21850 -26270 0 0 {name=p21381 lab=_85317_/CLK }
C {devices/lab_pin.sym} 21850 -26250 0 0 {name=p21382 lab=_83250_/D }
C {devices/lab_pin.sym} 22030 -26270 0 1 {name=p21383 lab=_83250_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -26260 0 0 {name=X_83250_ }
C {devices/lab_pin.sym} 21900 -26130 0 0 {name=p21384 lab=_59427_/A }
C {devices/lab_pin.sym} 21980 -26130 0 1 {name=p21385 lab=_61629_/B }
C {sky130_stdcells/buf_2.sym} 21940 -26130 0 0 {name=X_61628_ }
C {devices/lab_pin.sym} 21860 -26030 0 0 {name=p21386 lab=_80456_/A }
C {devices/lab_pin.sym} 21860 -25990 0 0 {name=p21387 lab=_80456_/B }
C {devices/lab_pin.sym} 21860 -25950 0 0 {name=p21388 lab=_80461_/Y }
C {devices/lab_pin.sym} 22020 -25990 0 1 {name=p21389 lab=_80478_/A }
C {sky130_stdcells/a21boi_4.sym} 21940 -25990 0 0 {name=X_80462_ }
C {devices/lab_pin.sym} 21860 -25870 0 0 {name=p21390 lab=_67159_/X }
C {devices/lab_pin.sym} 21860 -25830 0 0 {name=p21391 lab=_67162_/X }
C {devices/lab_pin.sym} 21860 -25790 0 0 {name=p21392 lab=_68173_/X }
C {devices/lab_pin.sym} 22020 -25830 0 1 {name=p21393 lab=_68184_/Y }
C {sky130_stdcells/a21oi_4.sym} 21940 -25830 0 0 {name=X_68184_ }
C {devices/lab_pin.sym} 21900 -25690 0 0 {name=p21394 lab=_84203_/Q }
C {devices/lab_pin.sym} 21980 -25690 0 1 {name=p21395 lab=_65397_/C }
C {sky130_stdcells/inv_2.sym} 21940 -25690 0 0 {name=X_65396_ }
C {devices/lab_pin.sym} 21850 -25570 0 0 {name=p21396 lab=_86104_/CLK }
C {devices/lab_pin.sym} 21850 -25550 0 0 {name=p21397 lab=_82201_/D }
C {devices/lab_pin.sym} 22030 -25570 0 1 {name=p21398 lab=_82393_/D }
C {sky130_stdcells/dfxtp_4.sym} 21940 -25560 0 0 {name=X_82201_ }
C {devices/lab_pin.sym} 21860 -25450 0 0 {name=p21399 lab=_67132_/X }
C {devices/lab_pin.sym} 21860 -25410 0 0 {name=p21400 lab=_67134_/X }
C {devices/lab_pin.sym} 21860 -25370 0 0 {name=p21401 lab=_67085_/X }
C {devices/lab_pin.sym} 22020 -25410 0 1 {name=p21402 lab=_67135_/X }
C {sky130_stdcells/a21o_4.sym} 21940 -25410 0 0 {name=X_67135_ }
C {devices/lab_pin.sym} 21860 -25290 0 0 {name=p21403 lab=_52358_/Y }
C {devices/lab_pin.sym} 21860 -25250 0 0 {name=p21404 lab=_52340_/X }
C {devices/lab_pin.sym} 21860 -25210 0 0 {name=p21405 lab=_52360_/X }
C {devices/lab_pin.sym} 22020 -25250 0 1 {name=p21406 lab=_85838_/D }
C {sky130_stdcells/a21oi_4.sym} 21940 -25250 0 0 {name=X_52361_ }
C {devices/lab_pin.sym} 21860 -25130 0 0 {name=p21407 lab=_58322_/Y }
C {devices/lab_pin.sym} 21860 -25090 0 0 {name=p21408 lab=_64308_/X }
C {devices/lab_pin.sym} 21860 -25050 0 0 {name=p21409 lab=_64346_/Y }
C {devices/lab_pin.sym} 22020 -25090 0 1 {name=p21410 lab=_64347_/Y }
C {sky130_stdcells/o21ai_4.sym} 21940 -25090 0 0 {name=X_64347_ }
C {devices/lab_pin.sym} 21850 -24950 0 0 {name=p21411 lab=_81696_/CLK }
C {devices/lab_pin.sym} 21850 -24930 0 0 {name=p21412 lab=_72713_/X }
C {devices/lab_pin.sym} 22030 -24950 0 1 {name=p21413 lab=_83181_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -24940 0 0 {name=X_83181_ }
C {devices/lab_pin.sym} 21880 -24820 0 0 {name=p21414 lab=_80406_/B }
C {devices/lab_pin.sym} 21880 -24780 0 0 {name=p21415 lab=_80406_/A }
C {devices/lab_pin.sym} 22000 -24800 0 1 {name=p21416 lab=_80393_/X }
C {sky130_stdcells/xor2_4.sym} 21940 -24800 0 0 {name=X_80393_ }
C {devices/lab_pin.sym} 21900 -24670 0 0 {name=p21417 lab=_84862_/Q }
C {devices/lab_pin.sym} 21980 -24670 0 1 {name=p21418 lab=_61560_/B }
C {sky130_stdcells/buf_2.sym} 21940 -24670 0 0 {name=X_61559_ }
C {devices/lab_pin.sym} 21880 -24580 0 0 {name=p21419 lab=_54123_/A }
C {devices/lab_pin.sym} 21880 -24540 0 0 {name=p21420 lab=_53428_/X }
C {devices/lab_pin.sym} 21880 -24500 0 0 {name=p21421 lab=_54111_/C }
C {devices/lab_pin.sym} 21880 -24460 0 0 {name=p21422 lab=_52934_/D }
C {devices/lab_pin.sym} 22000 -24520 0 1 {name=p21423 lab=_54100_/X }
C {sky130_stdcells/and4_4.sym} 21940 -24520 0 0 {name=X_54100_ }
C {devices/lab_pin.sym} 21860 -24390 0 0 {name=p21424 lab=_65002_/B }
C {devices/lab_pin.sym} 21860 -24350 0 0 {name=p21425 lab=_51309_/X }
C {devices/lab_pin.sym} 21860 -24310 0 0 {name=p21426 lab=_51311_/Y }
C {devices/lab_pin.sym} 22020 -24350 0 1 {name=p21427 lab=_51312_/Y }
C {sky130_stdcells/o21ai_4.sym} 21940 -24350 0 0 {name=X_51312_ }
C {devices/lab_pin.sym} 21850 -24210 0 0 {name=p21428 lab=_81970_/CLK }
C {devices/lab_pin.sym} 21850 -24190 0 0 {name=p21429 lab=_82132_/D }
C {devices/lab_pin.sym} 22030 -24210 0 1 {name=p21430 lab=_82132_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -24200 0 0 {name=X_82132_ }
C {devices/lab_pin.sym} 21880 -24080 0 0 {name=p21431 lab=_55093_/A }
C {devices/lab_pin.sym} 21880 -24040 0 0 {name=p21432 lab=_47741_/Y }
C {devices/lab_pin.sym} 22000 -24060 0 1 {name=p21433 lab=_55080_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -24060 0 0 {name=X_55080_ }
C {devices/lab_pin.sym} 21860 -23950 0 0 {name=p21434 lab=_67061_/X }
C {devices/lab_pin.sym} 21860 -23910 0 0 {name=p21435 lab=_67065_/X }
C {devices/lab_pin.sym} 21860 -23870 0 0 {name=p21436 lab=_66871_/X }
C {devices/lab_pin.sym} 22020 -23910 0 1 {name=p21437 lab=_67066_/Y }
C {sky130_stdcells/a21oi_4.sym} 21940 -23910 0 0 {name=X_67066_ }
C {devices/lab_pin.sym} 21860 -23790 0 0 {name=p21438 lab=_52288_/Y }
C {devices/lab_pin.sym} 21860 -23750 0 0 {name=p21439 lab=_52289_/X }
C {devices/lab_pin.sym} 21860 -23710 0 0 {name=p21440 lab=_52291_/X }
C {devices/lab_pin.sym} 22020 -23750 0 1 {name=p21441 lab=_52292_/Y }
C {sky130_stdcells/a21oi_4.sym} 21940 -23750 0 0 {name=X_52292_ }
C {devices/lab_pin.sym} 21860 -23630 0 0 {name=p21442 lab=_59467_/Y }
C {devices/lab_pin.sym} 21860 -23590 0 0 {name=p21443 lab=_64249_/X }
C {devices/lab_pin.sym} 21860 -23550 0 0 {name=p21444 lab=_64277_/Y }
C {devices/lab_pin.sym} 22020 -23590 0 1 {name=p21445 lab=_64278_/Y }
C {sky130_stdcells/o21ai_4.sym} 21940 -23590 0 0 {name=X_64278_ }
C {devices/lab_pin.sym} 21880 -23460 0 0 {name=p21446 lab=_54031_/A }
C {devices/lab_pin.sym} 21880 -23420 0 0 {name=p21447 lab=_50816_/B }
C {devices/lab_pin.sym} 22000 -23440 0 1 {name=p21448 lab=_54031_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -23440 0 0 {name=X_54031_ }
C {devices/lab_pin.sym} 21880 -23330 0 0 {name=p21449 lab=_65888_/A }
C {devices/lab_pin.sym} 21880 -23290 0 0 {name=p21450 lab=_65888_/B }
C {devices/lab_pin.sym} 21880 -23250 0 0 {name=p21451 lab=_66016_/Y }
C {devices/lab_pin.sym} 22000 -23290 0 1 {name=p21452 lab=_66017_/Y }
C {sky130_stdcells/nor3_4.sym} 21940 -23290 0 0 {name=X_66017_ }
C {devices/lab_pin.sym} 21860 -23170 0 0 {name=p21453 lab=_51241_/Y }
C {devices/lab_pin.sym} 21860 -23130 0 0 {name=p21454 lab=_51237_/X }
C {devices/lab_pin.sym} 21860 -23090 0 0 {name=p21455 lab=_51242_/X }
C {devices/lab_pin.sym} 22020 -23130 0 1 {name=p21456 lab=_51243_/Y }
C {sky130_stdcells/a21oi_4.sym} 21940 -23130 0 0 {name=X_51243_ }
C {devices/lab_pin.sym} 21900 -22990 0 0 {name=p21457 lab=_63053_/A }
C {devices/lab_pin.sym} 21980 -22990 0 1 {name=p21458 lab=_63316_/B }
C {sky130_stdcells/buf_2.sym} 21940 -22990 0 0 {name=X_63229_ }
C {devices/lab_pin.sym} 21850 -22870 0 0 {name=p21459 lab=_87922_/CLK }
C {devices/lab_pin.sym} 21850 -22850 0 0 {name=p21460 lab=_44813_/X }
C {devices/lab_pin.sym} 22030 -22870 0 1 {name=p21461 lab=_67417_/B }
C {sky130_stdcells/dfxtp_4.sym} 21940 -22860 0 0 {name=X_86940_ }
C {devices/lab_pin.sym} 21850 -22730 0 0 {name=p21462 lab=_83933_/CLK }
C {devices/lab_pin.sym} 21850 -22710 0 0 {name=p21463 lab=_84023_/Q }
C {devices/lab_pin.sym} 22030 -22730 0 1 {name=p21464 lab=_82063_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -22720 0 0 {name=X_82063_ }
C {devices/lab_pin.sym} 21850 -22590 0 0 {name=p21465 lab=_84197_/CLK }
C {devices/lab_pin.sym} 21850 -22570 0 0 {name=p21466 lab=_84222_/Q }
C {devices/lab_pin.sym} 22030 -22590 0 1 {name=p21467 lab=_81014_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -22580 0 0 {name=X_81014_ }
C {devices/lab_pin.sym} 21860 -22470 0 0 {name=p21468 lab=_86060_/Q }
C {devices/lab_pin.sym} 21860 -22430 0 0 {name=p21469 lab=_51156_/X }
C {devices/lab_pin.sym} 21860 -22390 0 0 {name=p21470 lab=_51173_/Y }
C {devices/lab_pin.sym} 22020 -22430 0 1 {name=p21471 lab=_51174_/Y }
C {sky130_stdcells/o21ai_4.sym} 21940 -22430 0 0 {name=X_51174_ }
C {devices/lab_pin.sym} 21850 -22290 0 0 {name=p21472 lab=_86882_/CLK }
C {devices/lab_pin.sym} 21850 -22270 0 0 {name=p21473 lab=_45532_/Y }
C {devices/lab_pin.sym} 22030 -22290 0 1 {name=p21474 lab=_63100_/B }
C {sky130_stdcells/dfxtp_4.sym} 21940 -22280 0 0 {name=X_86871_ }
C {devices/lab_pin.sym} 21860 -22170 0 0 {name=p21475 lab=_86259_/Q }
C {devices/lab_pin.sym} 21860 -22130 0 0 {name=p21476 lab=_50113_/X }
C {devices/lab_pin.sym} 21860 -22090 0 0 {name=p21477 lab=_50124_/Y }
C {devices/lab_pin.sym} 22020 -22130 0 1 {name=p21478 lab=_50125_/Y }
C {sky130_stdcells/o21ai_4.sym} 21940 -22130 0 0 {name=X_50125_ }
C {devices/lab_pin.sym} 21850 -21990 0 0 {name=p21479 lab=_85822_/CLK }
C {devices/lab_pin.sym} 21850 -21970 0 0 {name=p21480 lab=_52443_/Y }
C {devices/lab_pin.sym} 22030 -21990 0 1 {name=p21481 lab=_85822_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -21980 0 0 {name=X_85822_ }
C {devices/lab_pin.sym} 21860 -21870 0 0 {name=p21482 lab=_58756_/X }
C {devices/lab_pin.sym} 21860 -21830 0 0 {name=p21483 lab=_85937_/Q }
C {devices/lab_pin.sym} 21860 -21790 0 0 {name=p21484 lab=_58664_/X }
C {devices/lab_pin.sym} 22020 -21830 0 1 {name=p21485 lab=_58770_/X }
C {sky130_stdcells/o21a_4.sym} 21940 -21830 0 0 {name=X_58770_ }
C {devices/lab_pin.sym} 21860 -21720 0 0 {name=p21486 lab=_44917_/A }
C {devices/lab_pin.sym} 21860 -21680 0 0 {name=p21487 lab=_55690_/X }
C {devices/lab_pin.sym} 21860 -21640 0 0 {name=p21488 lab=_44102_/X }
C {devices/lab_pin.sym} 21860 -21600 0 0 {name=p21489 lab=_55981_/X }
C {devices/lab_pin.sym} 22020 -21660 0 1 {name=p21490 lab=_55983_/B }
C {sky130_stdcells/a211o_4.sym} 21940 -21660 0 0 {name=X_55982_ }
C {devices/lab_pin.sym} 21860 -21540 0 0 {name=p21491 lab=_87141_/Q }
C {devices/lab_pin.sym} 21860 -21500 0 0 {name=p21492 lab=_67942_/X }
C {devices/lab_pin.sym} 21860 -21460 0 0 {name=p21493 lab=_67872_/X }
C {devices/lab_pin.sym} 21860 -21420 0 0 {name=p21494 lab=_67967_/X }
C {devices/lab_pin.sym} 22020 -21480 0 1 {name=p21495 lab=_67968_/X }
C {sky130_stdcells/a211o_4.sym} 21940 -21480 0 0 {name=X_67968_ }
C {devices/lab_pin.sym} 21880 -21340 0 0 {name=p21496 lab=_44151_/X }
C {devices/lab_pin.sym} 21880 -21300 0 0 {name=p21497 lab=_57721_/B }
C {devices/lab_pin.sym} 22000 -21320 0 1 {name=p21498 lab=_57721_/Y }
C {sky130_stdcells/nor2_4.sym} 21940 -21320 0 0 {name=X_57721_ }
C {devices/lab_pin.sym} 21900 -21190 0 0 {name=p21499 lab=clkbuf_7_41_0_CLK/A }
C {devices/lab_pin.sym} 21980 -21190 0 1 {name=p21500 lab=clkbuf_8_81_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 21940 -21190 0 0 {name=Xclkbuf_7_40_0_CLK }
C {devices/lab_pin.sym} 21860 -21090 0 0 {name=p21501 lab=_81975_/D }
C {devices/lab_pin.sym} 21860 -21050 0 0 {name=p21502 lab=_69696_/X }
C {devices/lab_pin.sym} 21860 -21010 0 0 {name=p21503 lab=_69706_/X }
C {devices/lab_pin.sym} 22020 -21050 0 1 {name=p21504 lab=_83903_/D }
C {sky130_stdcells/a21bo_4.sym} 21940 -21050 0 0 {name=X_69707_ }
C {devices/lab_pin.sym} 21880 -20920 0 0 {name=p21505 lab=_50056_/A }
C {devices/lab_pin.sym} 21880 -20880 0 0 {name=p21506 lab=_48889_/B }
C {devices/lab_pin.sym} 22000 -20900 0 1 {name=p21507 lab=_50056_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -20900 0 0 {name=X_50056_ }
C {devices/lab_pin.sym} 21860 -20790 0 0 {name=p21508 lab=_54931_/Y }
C {devices/lab_pin.sym} 21860 -20750 0 0 {name=p21509 lab=_54909_/X }
C {devices/lab_pin.sym} 21860 -20710 0 0 {name=p21510 lab=_54932_/X }
C {devices/lab_pin.sym} 22020 -20750 0 1 {name=p21511 lab=_85351_/D }
C {sky130_stdcells/a21oi_4.sym} 21940 -20750 0 0 {name=X_54933_ }
C {devices/lab_pin.sym} 21900 -20610 0 0 {name=p21512 lab=_57866_/A }
C {devices/lab_pin.sym} 21980 -20610 0 1 {name=p21513 lab=_66919_/X }
C {sky130_stdcells/buf_2.sym} 21940 -20610 0 0 {name=X_66919_ }
C {devices/lab_pin.sym} 21850 -20490 0 0 {name=p21514 lab=_85754_/CLK }
C {devices/lab_pin.sym} 21850 -20470 0 0 {name=p21515 lab=_52798_/Y }
C {devices/lab_pin.sym} 22030 -20490 0 1 {name=p21516 lab=_85753_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -20480 0 0 {name=X_85753_ }
C {devices/lab_pin.sym} 21850 -20350 0 0 {name=p21517 lab=_82965_/CLK }
C {devices/lab_pin.sym} 21850 -20330 0 0 {name=p21518 lab=_82773_/Q }
C {devices/lab_pin.sym} 22030 -20350 0 1 {name=p21519 lab=_46735_/A }
C {sky130_stdcells/dfxtp_4.sym} 21940 -20340 0 0 {name=X_82965_ }
C {devices/lab_pin.sym} 21860 -20240 0 0 {name=p21520 lab=_67782_/X }
C {devices/lab_pin.sym} 21860 -20200 0 0 {name=p21521 lab=_67887_/Y }
C {devices/lab_pin.sym} 21860 -20160 0 0 {name=p21522 lab=_67863_/X }
C {devices/lab_pin.sym} 21860 -20120 0 0 {name=p21523 lab=_67898_/Y }
C {devices/lab_pin.sym} 22020 -20180 0 1 {name=p21524 lab=_67899_/X }
C {sky130_stdcells/a211o_4.sym} 21940 -20180 0 0 {name=X_67899_ }
C {devices/lab_pin.sym} 21900 -20030 0 0 {name=p21525 lab=clkbuf_7_90_0_CLK/X }
C {devices/lab_pin.sym} 21980 -20030 0 1 {name=p21526 lab=clkbuf_8_180_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 21940 -20030 0 0 {name=Xclkbuf_8_180_0_CLK }
C {devices/lab_pin.sym} 21850 -19910 0 0 {name=p21527 lab=_84713_/CLK }
C {devices/lab_pin.sym} 21850 -19890 0 0 {name=p21528 lab=_84704_/D }
C {devices/lab_pin.sym} 22030 -19910 0 1 {name=p21529 lab=_80526_/A }
C {sky130_stdcells/dfxtp_4.sym} 21940 -19900 0 0 {name=X_84704_ }
C {devices/lab_pin.sym} 21900 -19770 0 0 {name=p21530 lab=_84961_/Q }
C {devices/lab_pin.sym} 21980 -19770 0 1 {name=p21531 lab=_57652_/X }
C {sky130_stdcells/buf_2.sym} 21940 -19770 0 0 {name=X_57652_ }
C {devices/lab_pin.sym} 21850 -19650 0 0 {name=p21532 lab=_82008_/CLK }
C {devices/lab_pin.sym} 21850 -19630 0 0 {name=p21533 lab=_81916_/D }
C {devices/lab_pin.sym} 22030 -19650 0 1 {name=p21534 lab=_81916_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -19640 0 0 {name=X_81916_ }
C {devices/lab_pin.sym} 21880 -19520 0 0 {name=p21535 lab=_69586_/A }
C {devices/lab_pin.sym} 21880 -19480 0 0 {name=p21536 lab=_88334_/Q }
C {devices/lab_pin.sym} 22000 -19500 0 1 {name=p21537 lab=_69638_/X }
C {sky130_stdcells/and2_4.sym} 21940 -19500 0 0 {name=X_69638_ }
C {devices/lab_pin.sym} 21860 -19390 0 0 {name=p21538 lab=_54860_/Y }
C {devices/lab_pin.sym} 21860 -19350 0 0 {name=p21539 lab=_54856_/X }
C {devices/lab_pin.sym} 21860 -19310 0 0 {name=p21540 lab=_54863_/X }
C {devices/lab_pin.sym} 22020 -19350 0 1 {name=p21541 lab=_85364_/D }
C {sky130_stdcells/a21oi_4.sym} 21940 -19350 0 0 {name=X_54864_ }
C {devices/lab_pin.sym} 21850 -19210 0 0 {name=p21542 lab=_84787_/CLK }
C {devices/lab_pin.sym} 21850 -19190 0 0 {name=p21543 lab=_85684_/D }
C {devices/lab_pin.sym} 22030 -19210 0 1 {name=p21544 lab=_85684_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -19200 0 0 {name=X_85684_ }
C {devices/lab_pin.sym} 21850 -19070 0 0 {name=p21545 lab=_82896_/CLK }
C {devices/lab_pin.sym} 21850 -19050 0 0 {name=p21546 lab=_78182_/B }
C {devices/lab_pin.sym} 22030 -19070 0 1 {name=p21547 lab=_41719_/A }
C {sky130_stdcells/dfxtp_4.sym} 21940 -19060 0 0 {name=X_82896_ }
C {devices/lab_pin.sym} 21900 -18930 0 0 {name=p21548 lab=_44135_/X }
C {devices/lab_pin.sym} 21980 -18930 0 1 {name=p21549 lab=_56696_/B }
C {sky130_stdcells/buf_2.sym} 21940 -18930 0 0 {name=X_56603_ }
C {devices/lab_pin.sym} 21850 -18810 0 0 {name=p21550 lab=_87421_/CLK }
C {devices/lab_pin.sym} 21850 -18790 0 0 {name=p21551 lab=_87423_/D }
C {devices/lab_pin.sym} 22030 -18810 0 1 {name=p21552 lab=_87423_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -18800 0 0 {name=X_87423_ }
C {devices/lab_pin.sym} 21860 -18690 0 0 {name=p21553 lab=_53813_/Y }
C {devices/lab_pin.sym} 21860 -18650 0 0 {name=p21554 lab=_53799_/X }
C {devices/lab_pin.sym} 21860 -18610 0 0 {name=p21555 lab=_53814_/Y }
C {devices/lab_pin.sym} 22020 -18650 0 1 {name=p21556 lab=_53815_/Y }
C {sky130_stdcells/a21boi_4.sym} 21940 -18650 0 0 {name=X_53815_ }
C {devices/lab_pin.sym} 21850 -18510 0 0 {name=p21557 lab=_84645_/CLK }
C {devices/lab_pin.sym} 21850 -18490 0 0 {name=p21558 lab=_60318_/Y }
C {devices/lab_pin.sym} 22030 -18510 0 1 {name=p21559 lab=_79733_/A }
C {sky130_stdcells/dfxtp_4.sym} 21940 -18500 0 0 {name=X_84635_ }
C {devices/lab_pin.sym} 21860 -18390 0 0 {name=p21560 lab=_57579_/Y }
C {devices/lab_pin.sym} 21860 -18350 0 0 {name=p21561 lab=_57581_/X }
C {devices/lab_pin.sym} 21860 -18310 0 0 {name=p21562 lab=_57582_/Y }
C {devices/lab_pin.sym} 22020 -18350 0 1 {name=p21563 lab=_57583_/Y }
C {sky130_stdcells/a21boi_4.sym} 21940 -18350 0 0 {name=X_57583_ }
C {devices/lab_pin.sym} 21850 -18210 0 0 {name=p21564 lab=_82221_/CLK }
C {devices/lab_pin.sym} 21850 -18190 0 0 {name=p21565 lab=_81879_/Q }
C {devices/lab_pin.sym} 22030 -18210 0 1 {name=p21566 lab=_77532_/A }
C {sky130_stdcells/dfxtp_4.sym} 21940 -18200 0 0 {name=X_81847_ }
C {devices/lab_pin.sym} 21860 -18100 0 0 {name=p21567 lab=_41980_/A }
C {devices/lab_pin.sym} 21860 -18060 0 0 {name=p21568 lab=_69442_/X }
C {devices/lab_pin.sym} 21860 -18020 0 0 {name=p21569 lab=_69567_/X }
C {devices/lab_pin.sym} 21860 -17980 0 0 {name=p21570 lab=_69568_/Y }
C {devices/lab_pin.sym} 22020 -18040 0 1 {name=p21571 lab=_69569_/X }
C {sky130_stdcells/a211o_4.sym} 21940 -18040 0 0 {name=X_69569_ }
C {devices/lab_pin.sym} 21860 -17910 0 0 {name=p21572 lab=_54791_/Y }
C {devices/lab_pin.sym} 21860 -17870 0 0 {name=p21573 lab=_54774_/X }
C {devices/lab_pin.sym} 21860 -17830 0 0 {name=p21574 lab=_54794_/X }
C {devices/lab_pin.sym} 22020 -17870 0 1 {name=p21575 lab=_85377_/D }
C {sky130_stdcells/a21oi_4.sym} 21940 -17870 0 0 {name=X_54795_ }
C {devices/lab_pin.sym} 21900 -17730 0 0 {name=p21576 lab=clkbuf_7_55_0_CLK/A }
C {devices/lab_pin.sym} 21980 -17730 0 1 {name=p21577 lab=clkbuf_7_55_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 21940 -17730 0 0 {name=Xclkbuf_7_55_0_CLK }
C {devices/lab_pin.sym} 21860 -17630 0 0 {name=p21578 lab=_59286_/X }
C {devices/lab_pin.sym} 21860 -17590 0 0 {name=p21579 lab=_86055_/Q }
C {devices/lab_pin.sym} 21860 -17550 0 0 {name=p21580 lab=_59321_/X }
C {devices/lab_pin.sym} 22020 -17590 0 1 {name=p21581 lab=_59322_/Y }
C {sky130_stdcells/o21ai_4.sym} 21940 -17590 0 0 {name=X_59322_ }
C {devices/lab_pin.sym} 21880 -17470 0 0 {name=p21582 lab=_71576_/X }
C {devices/lab_pin.sym} 21880 -17430 0 0 {name=p21583 lab=_71626_/B }
C {devices/lab_pin.sym} 21880 -17390 0 0 {name=p21584 lab=_71598_/C }
C {devices/lab_pin.sym} 22000 -17430 0 1 {name=p21585 lab=_71600_/Y }
C {sky130_stdcells/nor3_4.sym} 21940 -17430 0 0 {name=X_71600_ }
C {devices/lab_pin.sym} 21860 -17310 0 0 {name=p21586 lab=_56148_/X }
C {devices/lab_pin.sym} 21860 -17270 0 0 {name=p21587 lab=_56528_/X }
C {devices/lab_pin.sym} 21860 -17230 0 0 {name=p21588 lab=_56533_/Y }
C {devices/lab_pin.sym} 22020 -17270 0 1 {name=p21589 lab=_56534_/Y }
C {sky130_stdcells/o21ai_4.sym} 21940 -17270 0 0 {name=X_56534_ }
C {devices/lab_pin.sym} 21850 -17130 0 0 {name=p21590 lab=_81182_/CLK }
C {devices/lab_pin.sym} 21850 -17110 0 0 {name=p21591 lab=_87354_/D }
C {devices/lab_pin.sym} 22030 -17130 0 1 {name=p21592 lab=_87354_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -17120 0 0 {name=X_87354_ }
C {devices/lab_pin.sym} 21880 -17000 0 0 {name=p21593 lab=_40414_/X }
C {devices/lab_pin.sym} 21880 -16960 0 0 {name=p21594 lab=_41422_/A }
C {devices/lab_pin.sym} 22000 -16980 0 1 {name=p21595 lab=_41760_/X }
C {sky130_stdcells/or2_4.sym} 21940 -16980 0 0 {name=X_41760_ }
C {devices/lab_pin.sym} 21860 -16870 0 0 {name=p21596 lab=_85576_/Q }
C {devices/lab_pin.sym} 21860 -16830 0 0 {name=p21597 lab=_53729_/X }
C {devices/lab_pin.sym} 21860 -16790 0 0 {name=p21598 lab=_53745_/Y }
C {devices/lab_pin.sym} 22020 -16830 0 1 {name=p21599 lab=_53746_/Y }
C {sky130_stdcells/o21ai_4.sym} 21940 -16830 0 0 {name=X_53746_ }
C {devices/lab_pin.sym} 21900 -16690 0 0 {name=p21600 lab=_64561_/A }
C {devices/lab_pin.sym} 21980 -16690 0 1 {name=p21601 lab=_72581_/A }
C {sky130_stdcells/buf_2.sym} 21940 -16690 0 0 {name=X_72580_ }
C {devices/lab_pin.sym} 21850 -16570 0 0 {name=p21602 lab=_84583_/CLK }
C {devices/lab_pin.sym} 21850 -16550 0 0 {name=p21603 lab=_84566_/D }
C {devices/lab_pin.sym} 22030 -16570 0 1 {name=p21604 lab=_84566_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -16560 0 0 {name=X_84566_ }
C {devices/lab_pin.sym} 21900 -16430 0 0 {name=p21605 lab=_50929_/A }
C {devices/lab_pin.sym} 21980 -16430 0 1 {name=p21606 lab=_50963_/B }
C {sky130_stdcells/buf_2.sym} 21940 -16430 0 0 {name=X_50958_ }
C {devices/lab_pin.sym} 21900 -16310 0 0 {name=p21607 lab=clkbuf_7_97_0_CLK/X }
C {devices/lab_pin.sym} 21980 -16310 0 1 {name=p21608 lab=clkbuf_9_391_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 21940 -16310 0 0 {name=Xclkbuf_8_195_0_CLK }
C {devices/lab_pin.sym} 21850 -16190 0 0 {name=p21609 lab=_82053_/CLK }
C {devices/lab_pin.sym} 21850 -16170 0 0 {name=p21610 lab=_76090_/X }
C {devices/lab_pin.sym} 22030 -16190 0 1 {name=p21611 lab=_81778_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -16180 0 0 {name=X_81778_ }
C {devices/lab_pin.sym} 21900 -16050 0 0 {name=p21612 lab=clkbuf_9_95_0_CLK/X }
C {devices/lab_pin.sym} 21980 -16050 0 1 {name=p21613 lab=_81038_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21940 -16050 0 0 {name=Xclkbuf_10_190_0_CLK }
C {devices/lab_pin.sym} 21850 -15930 0 0 {name=p21614 lab=_86303_/CLK }
C {devices/lab_pin.sym} 21850 -15910 0 0 {name=p21615 lab=_49890_/Y }
C {devices/lab_pin.sym} 22030 -15930 0 1 {name=p21616 lab=_72116_/B }
C {sky130_stdcells/dfxtp_4.sym} 21940 -15920 0 0 {name=X_86305_ }
C {devices/lab_pin.sym} 21860 -15810 0 0 {name=p21617 lab=_40670_/X }
C {devices/lab_pin.sym} 21860 -15770 0 0 {name=p21618 lab=_40883_/A }
C {devices/lab_pin.sym} 21860 -15730 0 0 {name=p21619 lab=_40710_/X }
C {devices/lab_pin.sym} 22020 -15770 0 1 {name=p21620 lab=_40712_/A }
C {sky130_stdcells/o21ai_4.sym} 21940 -15770 0 0 {name=X_40711_ }
C {devices/lab_pin.sym} 21900 -15630 0 0 {name=p21621 lab=_58918_/A }
C {devices/lab_pin.sym} 21980 -15630 0 1 {name=p21622 lab=_59253_/X }
C {sky130_stdcells/buf_2.sym} 21940 -15630 0 0 {name=X_59253_ }
C {devices/lab_pin.sym} 21900 -15510 0 0 {name=p21623 lab=_71530_/Y }
C {devices/lab_pin.sym} 21980 -15510 0 1 {name=p21624 lab=_71531_/X }
C {sky130_stdcells/buf_2.sym} 21940 -15510 0 0 {name=X_71531_ }
C {devices/lab_pin.sym} 21850 -15390 0 0 {name=p21625 lab=_83520_/CLK }
C {devices/lab_pin.sym} 21850 -15370 0 0 {name=p21626 lab=_83517_/D }
C {devices/lab_pin.sym} 22030 -15390 0 1 {name=p21627 lab=_83517_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -15380 0 0 {name=X_83517_ }
C {devices/lab_pin.sym} 21880 -15270 0 0 {name=p21628 lab=_56545_/A }
C {devices/lab_pin.sym} 21880 -15230 0 0 {name=p21629 lab=_56454_/B }
C {devices/lab_pin.sym} 21880 -15190 0 0 {name=p21630 lab=_85185_/Q }
C {devices/lab_pin.sym} 22000 -15230 0 1 {name=p21631 lab=_56465_/Y }
C {sky130_stdcells/nand3_4.sym} 21940 -15230 0 0 {name=X_56465_ }
C {devices/lab_pin.sym} 21850 -15090 0 0 {name=p21632 lab=_80728_/CLK }
C {devices/lab_pin.sym} 21850 -15070 0 0 {name=p21633 lab=_75915_/X }
C {devices/lab_pin.sym} 22030 -15090 0 1 {name=p21634 lab=_80729_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -15080 0 0 {name=X_80729_ }
C {devices/lab_pin.sym} 21880 -14960 0 0 {name=p21635 lab=_82902_/Q }
C {devices/lab_pin.sym} 21880 -14920 0 0 {name=p21636 lab=_41660_/X }
C {devices/lab_pin.sym} 22000 -14940 0 1 {name=p21637 lab=_41691_/X }
C {sky130_stdcells/or2_4.sym} 21940 -14940 0 0 {name=X_41691_ }
C {devices/lab_pin.sym} 21850 -14810 0 0 {name=p21638 lab=_87285_/CLK }
C {devices/lab_pin.sym} 21850 -14790 0 0 {name=p21639 lab=_43748_/X }
C {devices/lab_pin.sym} 22030 -14810 0 1 {name=p21640 lab=_73509_/A }
C {sky130_stdcells/dfxtp_4.sym} 21940 -14800 0 0 {name=X_87285_ }
C {devices/lab_pin.sym} 21860 -14690 0 0 {name=p21641 lab=_53675_/Y }
C {devices/lab_pin.sym} 21860 -14650 0 0 {name=p21642 lab=_53653_/X }
C {devices/lab_pin.sym} 21860 -14610 0 0 {name=p21643 lab=_53676_/X }
C {devices/lab_pin.sym} 22020 -14650 0 1 {name=p21644 lab=_53677_/Y }
C {sky130_stdcells/a21oi_4.sym} 21940 -14650 0 0 {name=X_53677_ }
C {devices/lab_pin.sym} 21850 -14510 0 0 {name=p21645 lab=_84559_/CLK }
C {devices/lab_pin.sym} 21850 -14490 0 0 {name=p21646 lab=_61255_/X }
C {devices/lab_pin.sym} 22030 -14510 0 1 {name=p21647 lab=_75899_/A }
C {sky130_stdcells/dfxtp_4.sym} 21940 -14500 0 0 {name=X_84497_ }
C {devices/lab_pin.sym} 21860 -14390 0 0 {name=p21648 lab=_86112_/Q }
C {devices/lab_pin.sym} 21860 -14350 0 0 {name=p21649 lab=_50882_/X }
C {devices/lab_pin.sym} 21860 -14310 0 0 {name=p21650 lab=_50888_/Y }
C {devices/lab_pin.sym} 22020 -14350 0 1 {name=p21651 lab=_50889_/Y }
C {sky130_stdcells/o21ai_4.sym} 21940 -14350 0 0 {name=X_50889_ }
C {devices/lab_pin.sym} 21900 -14210 0 0 {name=p21652 lab=_83372_/Q }
C {devices/lab_pin.sym} 21980 -14210 0 1 {name=p21653 lab=_58204_/Y }
C {sky130_stdcells/inv_2.sym} 21940 -14210 0 0 {name=X_58204_ }
C {sky130_stdcells/decap_3.sym} 21940 -14060 0 0 {name=XPHY_300 }
C {devices/lab_pin.sym} 21860 -13940 0 0 {name=p21654 lab=_41556_/X }
C {devices/lab_pin.sym} 21860 -13900 0 0 {name=p21655 lab=_43412_/X }
C {devices/lab_pin.sym} 21860 -13860 0 0 {name=p21656 lab=_87425_/Q }
C {devices/lab_pin.sym} 21860 -13820 0 0 {name=p21657 lab=_43413_/X }
C {devices/lab_pin.sym} 22020 -13880 0 1 {name=p21658 lab=_87425_/D }
C {sky130_stdcells/a2bb2o_4.sym} 21940 -13880 0 0 {name=X_43430_ }
C {devices/lab_pin.sym} 21880 -13740 0 0 {name=p21659 lab=_55373_/Y }
C {devices/lab_pin.sym} 21880 -13700 0 0 {name=p21660 lab=_55297_/X }
C {devices/lab_pin.sym} 22000 -13720 0 1 {name=p21661 lab=_55416_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -13720 0 0 {name=X_55416_ }
C {devices/lab_pin.sym} 21860 -13610 0 0 {name=p21662 lab=_44747_/Y }
C {devices/lab_pin.sym} 21860 -13570 0 0 {name=p21663 lab=_56183_/X }
C {devices/lab_pin.sym} 21860 -13530 0 0 {name=p21664 lab=_74249_/Y }
C {devices/lab_pin.sym} 22020 -13570 0 1 {name=p21665 lab=_74250_/X }
C {sky130_stdcells/a21o_4.sym} 21940 -13570 0 0 {name=X_74250_ }
C {devices/lab_pin.sym} 21850 -13430 0 0 {name=p21666 lab=_84991_/CLK }
C {devices/lab_pin.sym} 21850 -13410 0 0 {name=p21667 lab=_50263_/Y }
C {devices/lab_pin.sym} 22030 -13430 0 1 {name=p21668 lab=_86236_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -13420 0 0 {name=X_86236_ }
C {sky130_stdcells/decap_3.sym} 21940 -13260 0 0 {name=XPHY_311 }
C {devices/lab_pin.sym} 21860 -13150 0 0 {name=p21669 lab=_40635_/X }
C {devices/lab_pin.sym} 21860 -13110 0 0 {name=p21670 lab=_40638_/X }
C {devices/lab_pin.sym} 21860 -13070 0 0 {name=p21671 lab=_40641_/X }
C {devices/lab_pin.sym} 21860 -13030 0 0 {name=p21672 lab=_68595_/B }
C {devices/lab_pin.sym} 21860 -12990 0 0 {name=p21673 lab=_40612_/X }
C {devices/lab_pin.sym} 22020 -13070 0 1 {name=p21674 lab=_40643_/A }
C {sky130_stdcells/o32ai_4.sym} 21940 -13070 0 0 {name=X_40642_ }
C {devices/lab_pin.sym} 21860 -12930 0 0 {name=p21675 lab=_52625_/Y }
C {devices/lab_pin.sym} 21860 -12890 0 0 {name=p21676 lab=_52619_/X }
C {devices/lab_pin.sym} 21860 -12850 0 0 {name=p21677 lab=_52627_/X }
C {devices/lab_pin.sym} 22020 -12890 0 1 {name=p21678 lab=_85784_/D }
C {sky130_stdcells/a21oi_4.sym} 21940 -12890 0 0 {name=X_52628_ }
C {devices/lab_pin.sym} 21860 -12770 0 0 {name=p21679 lab=_59146_/X }
C {devices/lab_pin.sym} 21860 -12730 0 0 {name=p21680 lab=_85426_/Q }
C {devices/lab_pin.sym} 21860 -12690 0 0 {name=p21681 lab=_59183_/X }
C {devices/lab_pin.sym} 22020 -12730 0 1 {name=p21682 lab=_59184_/Y }
C {sky130_stdcells/o21ai_4.sym} 21940 -12730 0 0 {name=X_59184_ }
C {devices/lab_pin.sym} 21880 -12600 0 0 {name=p21683 lab=_70426_/A }
C {devices/lab_pin.sym} 21880 -12560 0 0 {name=p21684 lab=_71462_/B }
C {devices/lab_pin.sym} 22000 -12580 0 1 {name=p21685 lab=_71463_/A }
C {sky130_stdcells/and2_4.sym} 21940 -12580 0 0 {name=X_71462_ }
C {devices/lab_pin.sym} 21850 -12450 0 0 {name=p21686 lab=_83480_/CLK }
C {devices/lab_pin.sym} 21850 -12430 0 0 {name=p21687 lab=_83448_/D }
C {devices/lab_pin.sym} 22030 -12450 0 1 {name=p21688 lab=_83448_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -12440 0 0 {name=X_83448_ }
C {sky130_stdcells/decap_3.sym} 21940 -12280 0 0 {name=XPHY_322 }
C {devices/lab_pin.sym} 21860 -12150 0 0 {name=p21689 lab=_56040_/X }
C {devices/lab_pin.sym} 21860 -12110 0 0 {name=p21690 lab=_56394_/X }
C {devices/lab_pin.sym} 21860 -12070 0 0 {name=p21691 lab=_56395_/Y }
C {devices/lab_pin.sym} 22020 -12110 0 1 {name=p21692 lab=_85210_/D }
C {sky130_stdcells/o21ai_4.sym} 21940 -12110 0 0 {name=X_56396_ }
C {sky130_stdcells/decap_3.sym} 21940 -11940 0 0 {name=XPHY_333 }
C {sky130_stdcells/decap_3.sym} 21940 -11760 0 0 {name=XPHY_344 }
C {devices/lab_pin.sym} 21860 -11630 0 0 {name=p21693 lab=_73197_/X }
C {devices/lab_pin.sym} 21860 -11590 0 0 {name=p21694 lab=_73199_/X }
C {devices/lab_pin.sym} 21860 -11550 0 0 {name=p21695 lab=_73200_/X }
C {devices/lab_pin.sym} 22020 -11590 0 1 {name=p21696 lab=_73220_/B }
C {sky130_stdcells/a21o_4.sym} 21940 -11590 0 0 {name=X_73201_ }
C {devices/lab_pin.sym} 21880 -11460 0 0 {name=p21697 lab=_58576_/A }
C {devices/lab_pin.sym} 21880 -11420 0 0 {name=p21698 lab=_58135_/B }
C {devices/lab_pin.sym} 22000 -11440 0 1 {name=p21699 lab=_58135_/Y }
C {sky130_stdcells/nor2_4.sym} 21940 -11440 0 0 {name=X_58135_ }
C {devices/lab_pin.sym} 21900 -11310 0 0 {name=p21700 lab=HASH_ADDR[3] }
C {devices/lab_pin.sym} 21980 -11310 0 1 {name=p21701 lab=_70694_/A }
C {sky130_stdcells/buf_2.sym} 21940 -11310 0 0 {name=X_70413_ }
C {sky130_stdcells/decap_3.sym} 21940 -11160 0 0 {name=XPHY_355 }
C {devices/lab_pin.sym} 21860 -11040 0 0 {name=p21702 lab=_41367_/X }
C {devices/lab_pin.sym} 21860 -11000 0 0 {name=p21703 lab=_43356_/X }
C {devices/lab_pin.sym} 21860 -10960 0 0 {name=p21704 lab=_87460_/Q }
C {devices/lab_pin.sym} 21860 -10920 0 0 {name=p21705 lab=_43357_/X }
C {devices/lab_pin.sym} 22020 -10980 0 1 {name=p21706 lab=_87460_/D }
C {sky130_stdcells/a2bb2o_4.sym} 21940 -10980 0 0 {name=X_43361_ }
C {devices/lab_pin.sym} 21860 -10860 0 0 {name=p21707 lab=_45647_/A }
C {devices/lab_pin.sym} 21860 -10820 0 0 {name=p21708 lab=_44060_/X }
C {devices/lab_pin.sym} 21860 -10780 0 0 {name=p21709 lab=_55301_/X }
C {devices/lab_pin.sym} 21860 -10740 0 0 {name=p21710 lab=_55346_/Y }
C {devices/lab_pin.sym} 22020 -10800 0 1 {name=p21711 lab=_55347_/X }
C {sky130_stdcells/a211o_4.sym} 21940 -10800 0 0 {name=X_55347_ }
C {devices/lab_pin.sym} 21850 -10650 0 0 {name=p21712 lab=_85561_/CLK }
C {devices/lab_pin.sym} 21850 -10630 0 0 {name=p21713 lab=_50616_/Y }
C {devices/lab_pin.sym} 22030 -10650 0 1 {name=p21714 lab=_86167_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -10640 0 0 {name=X_86167_ }
C {devices/lab_pin.sym} 21880 -10520 0 0 {name=p21715 lab=_74181_/A }
C {devices/lab_pin.sym} 21880 -10480 0 0 {name=p21716 lab=_74181_/B }
C {devices/lab_pin.sym} 22000 -10500 0 1 {name=p21717 lab=_74181_/Y }
C {sky130_stdcells/xnor2_4.sym} 21940 -10500 0 0 {name=X_74181_ }
C {devices/lab_pin.sym} 21900 -10370 0 0 {name=p21718 lab=_40573_/A }
C {devices/lab_pin.sym} 21980 -10370 0 1 {name=p21719 lab=_40573_/X }
C {sky130_stdcells/buf_2.sym} 21940 -10370 0 0 {name=X_40573_ }
C {sky130_stdcells/decap_3.sym} 21940 -10220 0 0 {name=XPHY_366 }
C {devices/lab_pin.sym} 21880 -10080 0 0 {name=p21720 lab=_52567_/A }
C {devices/lab_pin.sym} 21880 -10040 0 0 {name=p21721 lab=_54077_/B }
C {devices/lab_pin.sym} 22000 -10060 0 1 {name=p21722 lab=_52559_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -10060 0 0 {name=X_52559_ }
C {devices/lab_pin.sym} 21850 -9930 0 0 {name=p21723 lab=_83414_/CLK }
C {devices/lab_pin.sym} 21850 -9910 0 0 {name=p21724 lab=_83379_/D }
C {devices/lab_pin.sym} 22030 -9930 0 1 {name=p21725 lab=_83379_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -9920 0 0 {name=X_83379_ }
C {devices/lab_pin.sym} 21880 -9810 0 0 {name=p21726 lab=_70692_/A }
C {devices/lab_pin.sym} 21880 -9770 0 0 {name=p21727 lab=_71386_/B }
C {devices/lab_pin.sym} 21880 -9730 0 0 {name=p21728 lab=_71399_/C }
C {devices/lab_pin.sym} 22000 -9770 0 1 {name=p21729 lab=_71393_/Y }
C {sky130_stdcells/nor3_4.sym} 21940 -9770 0 0 {name=X_71393_ }
C {sky130_stdcells/decap_3.sym} 21940 -9600 0 0 {name=XPHY_377 }
C {devices/lab_pin.sym} 21860 -9470 0 0 {name=p21730 lab=_55865_/B }
C {devices/lab_pin.sym} 21860 -9430 0 0 {name=p21731 lab=_45056_/X }
C {devices/lab_pin.sym} 21860 -9390 0 0 {name=p21732 lab=_45087_/X }
C {devices/lab_pin.sym} 22020 -9430 0 1 {name=p21733 lab=_45100_/X }
C {sky130_stdcells/o21a_4.sym} 21940 -9430 0 0 {name=X_45100_ }
C {sky130_stdcells/decap_3.sym} 21940 -9260 0 0 {name=XPHY_388 }
C {devices/lab_pin.sym} 21900 -9110 0 0 {name=p21734 lab=_42312_/A }
C {devices/lab_pin.sym} 21980 -9110 0 1 {name=p21735 lab=_87927_/D }
C {sky130_stdcells/inv_2.sym} 21940 -9110 0 0 {name=X_42312_ }
C {devices/lab_pin.sym} 21880 -9000 0 0 {name=p21736 lab=_73132_/A }
C {devices/lab_pin.sym} 21880 -8960 0 0 {name=p21737 lab=_85875_/Q }
C {devices/lab_pin.sym} 22000 -8980 0 1 {name=p21738 lab=_73132_/X }
C {sky130_stdcells/and2_4.sym} 21940 -8980 0 0 {name=X_73132_ }
C {devices/lab_pin.sym} 21850 -8850 0 0 {name=p21739 lab=_85152_/CLK }
C {devices/lab_pin.sym} 21850 -8830 0 0 {name=p21740 lab=_85118_/D }
C {devices/lab_pin.sym} 22030 -8850 0 1 {name=p21741 lab=_45440_/A }
C {sky130_stdcells/dfxtp_4.sym} 21940 -8840 0 0 {name=X_85118_ }
C {sky130_stdcells/decap_3.sym} 21940 -8680 0 0 {name=XPHY_399 }
C {devices/lab_pin.sym} 21900 -8530 0 0 {name=p21742 lab=_46080_/A }
C {devices/lab_pin.sym} 21980 -8530 0 1 {name=p21743 lab=_46080_/Y }
C {sky130_stdcells/inv_2.sym} 21940 -8530 0 0 {name=X_46080_ }
C {devices/lab_pin.sym} 21860 -8430 0 0 {name=p21744 lab=_58065_/X }
C {devices/lab_pin.sym} 21860 -8390 0 0 {name=p21745 lab=_85704_/Q }
C {devices/lab_pin.sym} 21860 -8350 0 0 {name=p21746 lab=_58020_/X }
C {devices/lab_pin.sym} 22020 -8390 0 1 {name=p21747 lab=_58066_/X }
C {sky130_stdcells/o21a_4.sym} 21940 -8390 0 0 {name=X_58066_ }
C {devices/lab_pin.sym} 21880 -8280 0 0 {name=p21748 lab=_70348_/A }
C {devices/lab_pin.sym} 21880 -8240 0 0 {name=p21749 lab=_70348_/B }
C {devices/lab_pin.sym} 21880 -8200 0 0 {name=p21750 lab=_83085_/Q }
C {devices/lab_pin.sym} 21880 -8160 0 0 {name=p21751 lab=_70348_/D }
C {devices/lab_pin.sym} 22000 -8220 0 1 {name=p21752 lab=_70344_/X }
C {sky130_stdcells/and4_4.sym} 21940 -8220 0 0 {name=X_70344_ }
C {devices/lab_pin.sym} 21900 -8070 0 0 {name=p21753 lab=_43292_/A }
C {devices/lab_pin.sym} 21980 -8070 0 1 {name=p21754 lab=_87495_/D }
C {sky130_stdcells/inv_2.sym} 21940 -8070 0 0 {name=X_43292_ }
C {devices/lab_pin.sym} 21880 -7960 0 0 {name=p21755 lab=_55278_/A }
C {devices/lab_pin.sym} 21880 -7920 0 0 {name=p21756 lab=_45792_/Y }
C {devices/lab_pin.sym} 22000 -7940 0 1 {name=p21757 lab=_55278_/Y }
C {sky130_stdcells/nor2_4.sym} 21940 -7940 0 0 {name=X_55278_ }
C {devices/lab_pin.sym} 21850 -7810 0 0 {name=p21758 lab=_85459_/CLK }
C {devices/lab_pin.sym} 21850 -7790 0 0 {name=p21759 lab=_50970_/Y }
C {devices/lab_pin.sym} 22030 -7810 0 1 {name=p21760 lab=_86098_/Q }
C {sky130_stdcells/dfxtp_4.sym} 21940 -7800 0 0 {name=X_86098_ }
C {devices/lab_pin.sym} 21860 -7690 0 0 {name=p21761 lab=_55913_/B }
C {devices/lab_pin.sym} 21860 -7650 0 0 {name=p21762 lab=_44963_/X }
C {devices/lab_pin.sym} 21860 -7610 0 0 {name=p21763 lab=_45004_/X }
C {devices/lab_pin.sym} 22020 -7650 0 1 {name=p21764 lab=_45031_/X }
C {sky130_stdcells/o21a_4.sym} 21940 -7650 0 0 {name=X_45031_ }
C {devices/lab_pin.sym} 21900 -7510 0 0 {name=p21765 lab=_57017_/A }
C {devices/lab_pin.sym} 21980 -7510 0 1 {name=p21766 lab=_85101_/D }
C {sky130_stdcells/inv_2.sym} 21940 -7510 0 0 {name=X_57017_ }
C {devices/lab_pin.sym} 21900 -7390 0 0 {name=p21767 lab=_42199_/X }
C {devices/lab_pin.sym} 21980 -7390 0 1 {name=p21768 lab=_42243_/X }
C {sky130_stdcells/buf_2.sym} 21940 -7390 0 0 {name=X_42243_ }
C {devices/lab_pin.sym} 21860 -7290 0 0 {name=p21769 lab=_54224_/Y }
C {devices/lab_pin.sym} 21860 -7250 0 0 {name=p21770 lab=_54226_/X }
C {devices/lab_pin.sym} 21860 -7210 0 0 {name=p21771 lab=_54228_/X }
C {devices/lab_pin.sym} 22020 -7250 0 1 {name=p21772 lab=_85481_/D }
C {sky130_stdcells/a21oi_4.sym} 21940 -7250 0 0 {name=X_54229_ }
C {devices/lab_pin.sym} 21880 -7120 0 0 {name=p21773 lab=_73132_/A }
C {devices/lab_pin.sym} 21880 -7080 0 0 {name=p21774 lab=_85878_/Q }
C {devices/lab_pin.sym} 22000 -7100 0 1 {name=p21775 lab=_73063_/X }
C {sky130_stdcells/and2_4.sym} 21940 -7100 0 0 {name=X_73063_ }
C {devices/lab_pin.sym} 21860 -6990 0 0 {name=p21776 lab=_82072_/Q }
C {devices/lab_pin.sym} 21860 -6950 0 0 {name=p21777 lab=_81944_/D }
C {devices/lab_pin.sym} 21860 -6910 0 0 {name=p21778 lab=_77939_/Y }
C {devices/lab_pin.sym} 22020 -6950 0 1 {name=p21779 lab=_77940_/Y }
C {sky130_stdcells/a21oi_4.sym} 21940 -6950 0 0 {name=X_77940_ }
C {devices/lab_pin.sym} 21850 -6810 0 0 {name=p21780 lab=_85049_/CLK }
C {devices/lab_pin.sym} 21850 -6790 0 0 {name=p21781 lab=_57255_/Y }
C {devices/lab_pin.sym} 22030 -6810 0 1 {name=p21782 lab=_57254_/B }
C {sky130_stdcells/dfxtp_4.sym} 21940 -6800 0 0 {name=X_85049_ }
C {devices/lab_pin.sym} 21880 -6700 0 0 {name=p21783 lab=_70267_/A }
C {devices/lab_pin.sym} 21880 -6660 0 0 {name=p21784 lab=_70267_/B }
C {devices/lab_pin.sym} 21880 -6620 0 0 {name=p21785 lab=_70275_/C }
C {devices/lab_pin.sym} 21880 -6580 0 0 {name=p21786 lab=_70264_/X }
C {devices/lab_pin.sym} 22000 -6640 0 1 {name=p21787 lab=_70275_/X }
C {sky130_stdcells/and4_4.sym} 21940 -6640 0 0 {name=X_70275_ }
C {devices/lab_pin.sym} 21900 -6490 0 0 {name=p21788 lab=clkbuf_7_66_0_CLK/X }
C {devices/lab_pin.sym} 21980 -6490 0 1 {name=p21789 lab=clkbuf_9_267_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 21940 -6490 0 0 {name=Xclkbuf_8_133_0_CLK }
C {devices/lab_pin.sym} 21880 -6380 0 0 {name=p21790 lab=_71993_/X }
C {devices/lab_pin.sym} 21880 -6340 0 0 {name=p21791 lab=_72014_/B }
C {devices/lab_pin.sym} 22000 -6360 0 1 {name=p21792 lab=_72014_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -6360 0 0 {name=X_72014_ }
C {devices/lab_pin.sym} 21860 -6270 0 0 {name=p21793 lab=_42173_/X }
C {devices/lab_pin.sym} 21860 -6230 0 0 {name=p21794 lab=_42169_/X }
C {devices/lab_pin.sym} 21860 -6190 0 0 {name=p21795 lab=_41225_/X }
C {devices/lab_pin.sym} 21860 -6150 0 0 {name=p21796 lab=_87998_/Q }
C {devices/lab_pin.sym} 21860 -6110 0 0 {name=p21797 lab=_42170_/X }
C {devices/lab_pin.sym} 22020 -6190 0 1 {name=p21798 lab=_42175_/A }
C {sky130_stdcells/o32ai_4.sym} 21940 -6190 0 0 {name=X_42174_ }
C {devices/lab_pin.sym} 21900 -6030 0 0 {name=p21799 lab=_82066_/Q }
C {devices/lab_pin.sym} 21980 -6030 0 1 {name=p21800 lab=_77885_/A }
C {sky130_stdcells/inv_2.sym} 21940 -6030 0 0 {name=X_77871_ }
C {devices/lab_pin.sym} 21880 -5920 0 0 {name=p21801 lab=_79610_/A }
C {devices/lab_pin.sym} 21880 -5880 0 0 {name=p21802 lab=_79599_/Y }
C {devices/lab_pin.sym} 22000 -5900 0 1 {name=p21803 lab=_79611_/B }
C {sky130_stdcells/nand2_4.sym} 21940 -5900 0 0 {name=X_79610_ }
C {devices/lab_pin.sym} 21900 -5770 0 0 {name=p21804 lab=_41124_/X }
C {devices/lab_pin.sym} 21980 -5770 0 1 {name=p21805 lab=_41125_/X }
C {sky130_stdcells/buf_2.sym} 21940 -5770 0 0 {name=X_41125_ }
C {devices/lab_pin.sym} 21880 -5660 0 0 {name=p21806 lab=_76822_/A }
C {devices/lab_pin.sym} 21880 -5620 0 0 {name=p21807 lab=_76821_/Y }
C {devices/lab_pin.sym} 22000 -5640 0 1 {name=p21808 lab=_76825_/A }
C {sky130_stdcells/xor2_4.sym} 21940 -5640 0 0 {name=X_76822_ }
C {devices/lab_pin.sym} 21880 -5520 0 0 {name=p21809 lab=_49769_/X }
C {devices/lab_pin.sym} 21880 -5480 0 0 {name=p21810 lab=_52986_/B }
C {devices/lab_pin.sym} 22000 -5500 0 1 {name=p21811 lab=_49770_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -5500 0 0 {name=X_49770_ }
C {devices/lab_pin.sym} 21860 -5390 0 0 {name=p21812 lab=_46978_/Y }
C {devices/lab_pin.sym} 21860 -5350 0 0 {name=p21813 lab=_46940_/X }
C {devices/lab_pin.sym} 21860 -5310 0 0 {name=p21814 lab=_46981_/X }
C {devices/lab_pin.sym} 22020 -5350 0 1 {name=p21815 lab=_46982_/Y }
C {sky130_stdcells/a21oi_4.sym} 21940 -5350 0 0 {name=X_46982_ }
C {devices/lab_pin.sym} 21860 -5240 0 0 {name=p21816 lab=_84786_/Q }
C {devices/lab_pin.sym} 21860 -5200 0 0 {name=p21817 lab=_58956_/X }
C {devices/lab_pin.sym} 21860 -5160 0 0 {name=p21818 lab=_58960_/X }
C {devices/lab_pin.sym} 21860 -5120 0 0 {name=p21819 lab=_58967_/X }
C {devices/lab_pin.sym} 22020 -5180 0 1 {name=p21820 lab=_84786_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 21940 -5180 0 0 {name=X_58968_ }
C {devices/lab_pin.sym} 21880 -5040 0 0 {name=p21821 lab=_48725_/A }
C {devices/lab_pin.sym} 21880 -5000 0 0 {name=p21822 lab=_48380_/X }
C {devices/lab_pin.sym} 22000 -5020 0 1 {name=p21823 lab=_48721_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -5020 0 0 {name=X_48721_ }
C {devices/lab_pin.sym} 21880 -4900 0 0 {name=p21824 lab=_84203_/Q }
C {devices/lab_pin.sym} 21880 -4860 0 0 {name=p21825 lab=_72465_/A }
C {devices/lab_pin.sym} 22000 -4880 0 1 {name=p21826 lab=_79543_/A }
C {sky130_stdcells/nor2_4.sym} 21940 -4880 0 0 {name=X_79541_ }
C {devices/lab_pin.sym} 21880 -4760 0 0 {name=p21827 lab=_57919_/A }
C {devices/lab_pin.sym} 21880 -4720 0 0 {name=p21828 lab=_57791_/X }
C {devices/lab_pin.sym} 22000 -4740 0 1 {name=p21829 lab=_57919_/Y }
C {sky130_stdcells/nor2_4.sym} 21940 -4740 0 0 {name=X_57919_ }
C {devices/lab_pin.sym} 21900 -4610 0 0 {name=p21830 lab=_45932_/Y }
C {devices/lab_pin.sym} 21980 -4610 0 1 {name=p21831 lab=_45933_/Y }
C {sky130_stdcells/inv_2.sym} 21940 -4610 0 0 {name=X_45933_ }
C {devices/lab_pin.sym} 21900 -4490 0 0 {name=p21832 lab=_41056_/A }
C {devices/lab_pin.sym} 21980 -4490 0 1 {name=p21833 lab=_41056_/Y }
C {sky130_stdcells/inv_2.sym} 21940 -4490 0 0 {name=X_41056_ }
C {devices/lab_pin.sym} 21880 -4380 0 0 {name=p21834 lab=_76753_/A }
C {devices/lab_pin.sym} 21880 -4340 0 0 {name=p21835 lab=_76753_/B }
C {devices/lab_pin.sym} 22000 -4360 0 1 {name=p21836 lab=_76753_/X }
C {sky130_stdcells/xor2_4.sym} 21940 -4360 0 0 {name=X_76753_ }
C {devices/lab_pin.sym} 21900 -4230 0 0 {name=p21837 lab=clkbuf_7_74_0_CLK/X }
C {devices/lab_pin.sym} 21980 -4230 0 1 {name=p21838 lab=clkbuf_9_296_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 21940 -4230 0 0 {name=Xclkbuf_8_148_0_CLK }
C {devices/lab_pin.sym} 21880 -4120 0 0 {name=p21839 lab=_87586_/Q }
C {devices/lab_pin.sym} 21880 -4080 0 0 {name=p21840 lab=_73873_/B }
C {devices/lab_pin.sym} 22000 -4100 0 1 {name=p21841 lab=_73965_/Y }
C {sky130_stdcells/nor2_4.sym} 21940 -4100 0 0 {name=X_73965_ }
C {devices/lab_pin.sym} 21900 -3970 0 0 {name=p21842 lab=clkbuf_9_71_0_CLK/X }
C {devices/lab_pin.sym} 21980 -3970 0 1 {name=p21843 lab=_81362_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21940 -3970 0 0 {name=Xclkbuf_10_143_0_CLK }
C {devices/lab_pin.sym} 21860 -3890 0 0 {name=p21844 lab=_58828_/X }
C {devices/lab_pin.sym} 21860 -3850 0 0 {name=p21845 lab=_58896_/Y }
C {devices/lab_pin.sym} 21860 -3810 0 0 {name=p21846 lab=_58898_/Y }
C {devices/lab_pin.sym} 21860 -3770 0 0 {name=p21847 lab=_58874_/X }
C {devices/lab_pin.sym} 21860 -3730 0 0 {name=p21848 lab=_58832_/X }
C {devices/lab_pin.sym} 22020 -3810 0 1 {name=p21849 lab=_58899_/X }
C {sky130_stdcells/o32a_4.sym} 21940 -3810 0 0 {name=X_58899_ }
C {devices/lab_pin.sym} 21880 -3660 0 0 {name=p21850 lab=_75696_/X }
C {devices/lab_pin.sym} 21880 -3620 0 0 {name=p21851 lab=_75704_/B }
C {devices/lab_pin.sym} 22000 -3640 0 1 {name=p21852 lab=_75705_/B }
C {sky130_stdcells/xor2_4.sym} 21940 -3640 0 0 {name=X_75704_ }
C {devices/lab_pin.sym} 21900 -3510 0 0 {name=p21853 lab=_48471_/A }
C {devices/lab_pin.sym} 21980 -3510 0 1 {name=p21854 lab=_48652_/X }
C {sky130_stdcells/buf_2.sym} 21940 -3510 0 0 {name=X_48652_ }
C {devices/lab_pin.sym} 21880 -3410 0 0 {name=p21855 lab=_60930_/A }
C {devices/lab_pin.sym} 21880 -3370 0 0 {name=p21856 lab=_60926_/X }
C {devices/lab_pin.sym} 21880 -3330 0 0 {name=p21857 lab=_60930_/C }
C {devices/lab_pin.sym} 22000 -3370 0 1 {name=p21858 lab=_60962_/A }
C {sky130_stdcells/nand3_4.sym} 21940 -3370 0 0 {name=X_60930_ }
C {devices/lab_pin.sym} 21880 -3240 0 0 {name=p21859 lab=_72916_/A }
C {devices/lab_pin.sym} 21880 -3200 0 0 {name=p21860 lab=_72916_/B }
C {devices/lab_pin.sym} 22000 -3220 0 1 {name=p21861 lab=_72917_/B }
C {sky130_stdcells/nand2_4.sym} 21940 -3220 0 0 {name=X_72916_ }
C {devices/lab_pin.sym} 21880 -3100 0 0 {name=p21862 lab=_79480_/A }
C {devices/lab_pin.sym} 21880 -3060 0 0 {name=p21863 lab=_79471_/Y }
C {devices/lab_pin.sym} 22000 -3080 0 1 {name=p21864 lab=_82845_/D }
C {sky130_stdcells/xor2_4.sym} 21940 -3080 0 0 {name=X_79472_ }
C {devices/lab_pin.sym} 21900 -2950 0 0 {name=p21865 lab=clkbuf_9_386_0_CLK/X }
C {devices/lab_pin.sym} 21980 -2950 0 1 {name=p21866 lab=_82665_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 21940 -2950 0 0 {name=Xclkbuf_10_773_0_CLK }
C {devices/lab_pin.sym} 21900 -2830 0 0 {name=p21867 lab=_63342_/B }
C {devices/lab_pin.sym} 21980 -2830 0 1 {name=p21868 lab=_61685_/A }
C {sky130_stdcells/buf_2.sym} 21940 -2830 0 0 {name=X_45864_ }
C {devices/lab_pin.sym} 21880 -2720 0 0 {name=p21869 lab=_76692_/B }
C {devices/lab_pin.sym} 21880 -2680 0 0 {name=p21870 lab=_81350_/D }
C {devices/lab_pin.sym} 22000 -2700 0 1 {name=p21871 lab=_76688_/A }
C {sky130_stdcells/xnor2_4.sym} 21940 -2700 0 0 {name=X_76684_ }
C {devices/lab_pin.sym} 21860 -2600 0 0 {name=p21872 lab=_68732_/B }
C {devices/lab_pin.sym} 21860 -2560 0 0 {name=p21873 lab=_73872_/X }
C {devices/lab_pin.sym} 21860 -2520 0 0 {name=p21874 lab=_73894_/X }
C {devices/lab_pin.sym} 21860 -2480 0 0 {name=p21875 lab=_73895_/Y }
C {devices/lab_pin.sym} 22020 -2540 0 1 {name=p21876 lab=_73896_/X }
C {sky130_stdcells/a211o_4.sym} 21940 -2540 0 0 {name=X_73896_ }
C {devices/lab_pin.sym} 21900 -2390 0 0 {name=p21877 lab=_49504_/A }
C {devices/lab_pin.sym} 21980 -2390 0 1 {name=p21878 lab=_47792_/A }
C {sky130_stdcells/buf_2.sym} 21940 -2390 0 0 {name=X_47603_ }
C {devices/lab_pin.sym} 21880 -2290 0 0 {name=p21879 lab=_78423_/A }
C {devices/lab_pin.sym} 21880 -2250 0 0 {name=p21880 lab=_78421_/Y }
C {devices/lab_pin.sym} 21880 -2210 0 0 {name=p21881 lab=_78423_/C }
C {devices/lab_pin.sym} 22000 -2250 0 1 {name=p21882 lab=_78423_/Y }
C {sky130_stdcells/nand3_4.sym} 21940 -2250 0 0 {name=X_78423_ }
C {devices/lab_pin.sym} 21860 -2150 0 0 {name=p21883 lab=_44807_/X }
C {devices/lab_pin.sym} 21860 -2110 0 0 {name=p21884 lab=_43924_/X }
C {devices/lab_pin.sym} 21860 -2070 0 0 {name=p21885 lab=_41655_/X }
C {devices/lab_pin.sym} 21860 -2030 0 0 {name=p21886 lab=_86938_/Q }
C {devices/lab_pin.sym} 21860 -1990 0 0 {name=p21887 lab=_44808_/X }
C {devices/lab_pin.sym} 22020 -2070 0 1 {name=p21888 lab=_44816_/A }
C {sky130_stdcells/o32ai_4.sym} 21940 -2070 0 0 {name=X_44815_ }
C {devices/lab_pin.sym} 21880 -1920 0 0 {name=p21889 lab=_75635_/A }
C {devices/lab_pin.sym} 21880 -1880 0 0 {name=p21890 lab=_75635_/B }
C {devices/lab_pin.sym} 22000 -1900 0 1 {name=p21891 lab=_75635_/X }
C {sky130_stdcells/xor2_4.sym} 21940 -1900 0 0 {name=X_75635_ }
C {devices/lab_pin.sym} 21880 -1800 0 0 {name=p21892 lab=_59540_/Y }
C {devices/lab_pin.sym} 21880 -1760 0 0 {name=p21893 lab=_61278_/B }
C {devices/lab_pin.sym} 21880 -1720 0 0 {name=p21894 lab=_60615_/A }
C {devices/lab_pin.sym} 21880 -1680 0 0 {name=p21895 lab=_61075_/C }
C {devices/lab_pin.sym} 22000 -1740 0 1 {name=p21896 lab=_60861_/X }
C {sky130_stdcells/and4_4.sym} 21940 -1740 0 0 {name=X_60861_ }
C {devices/lab_pin.sym} 21880 -1600 0 0 {name=p21897 lab=_48604_/A }
C {devices/lab_pin.sym} 21880 -1560 0 0 {name=p21898 lab=_48816_/B }
C {devices/lab_pin.sym} 22000 -1580 0 1 {name=p21899 lab=_48583_/Y }
C {sky130_stdcells/nand2_4.sym} 21940 -1580 0 0 {name=X_48583_ }
C {devices/lab_pin.sym} 21860 -1470 0 0 {name=p21900 lab=_72848_/B }
C {devices/lab_pin.sym} 21860 -1430 0 0 {name=p21901 lab=_72835_/X }
C {devices/lab_pin.sym} 21860 -1390 0 0 {name=p21902 lab=_72846_/X }
C {devices/lab_pin.sym} 22020 -1430 0 1 {name=p21903 lab=_72847_/X }
C {sky130_stdcells/a21o_4.sym} 21940 -1430 0 0 {name=X_72847_ }
C {devices/lab_pin.sym} 21900 -1290 0 0 {name=p21904 lab=clkbuf_8_132_0_CLK/X }
C {devices/lab_pin.sym} 21980 -1290 0 1 {name=p21905 lab=clkbuf_9_264_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 21940 -1290 0 0 {name=Xclkbuf_9_264_0_CLK }
C {devices/lab_pin.sym} 21860 -1190 0 0 {name=p21906 lab=_84999_/Q }
C {devices/lab_pin.sym} 21860 -1150 0 0 {name=p21907 lab=_44935_/X }
C {devices/lab_pin.sym} 21860 -1110 0 0 {name=p21908 lab=_45389_/X }
C {devices/lab_pin.sym} 22020 -1150 0 1 {name=p21909 lab=_45795_/X }
C {sky130_stdcells/o21a_4.sym} 21940 -1150 0 0 {name=X_45795_ }
C {devices/lab_pin.sym} 21880 -1040 0 0 {name=p21910 lab=_62622_/A }
C {devices/lab_pin.sym} 21880 -1000 0 0 {name=p21911 lab=_62600_/B }
C {devices/lab_pin.sym} 21880 -960 0 0 {name=p21912 lab=_62600_/C }
C {devices/lab_pin.sym} 21880 -920 0 0 {name=p21913 lab=_62600_/D }
C {devices/lab_pin.sym} 22000 -980 0 1 {name=p21914 lab=_62600_/Y }
C {sky130_stdcells/nand4_4.sym} 21940 -980 0 0 {name=X_62600_ }
C {devices/lab_pin.sym} 21860 -850 0 0 {name=p21915 lab=_47529_/Y }
C {devices/lab_pin.sym} 21860 -810 0 0 {name=p21916 lab=_47509_/X }
C {devices/lab_pin.sym} 21860 -770 0 0 {name=p21917 lab=_47533_/X }
C {devices/lab_pin.sym} 22020 -810 0 1 {name=p21918 lab=_47534_/Y }
C {sky130_stdcells/a21oi_4.sym} 21940 -810 0 0 {name=X_47534_ }
C {devices/lab_pin.sym} 21880 -680 0 0 {name=p21919 lab=_78352_/X }
C {devices/lab_pin.sym} 21880 -640 0 0 {name=p21920 lab=_78354_/B }
C {devices/lab_pin.sym} 22000 -660 0 1 {name=p21921 lab=_78356_/B }
C {sky130_stdcells/nand2_4.sym} 21940 -660 0 0 {name=X_78354_ }
C {devices/lab_pin.sym} 22780 -42190 0 0 {name=p21922 lab=_49210_/A }
C {devices/lab_pin.sym} 22780 -42150 0 0 {name=p21923 lab=_50731_/B }
C {devices/lab_pin.sym} 22780 -42110 0 0 {name=p21924 lab=_40749_/X }
C {devices/lab_pin.sym} 22780 -42070 0 0 {name=p21925 lab=_44745_/Y }
C {devices/lab_pin.sym} 22780 -42030 0 0 {name=p21926 lab=_44736_/X }
C {devices/lab_pin.sym} 22940 -42110 0 1 {name=p21927 lab=_86978_/D }
C {sky130_stdcells/o32ai_4.sym} 22860 -42110 0 0 {name=X_44746_ }
C {devices/lab_pin.sym} 22780 -41970 0 0 {name=p21928 lab=_63576_/Y }
C {devices/lab_pin.sym} 22780 -41930 0 0 {name=p21929 lab=_63578_/X }
C {devices/lab_pin.sym} 22780 -41890 0 0 {name=p21930 lab=_63579_/Y }
C {devices/lab_pin.sym} 22940 -41930 0 1 {name=p21931 lab=_63580_/Y }
C {sky130_stdcells/a21oi_4.sym} 22860 -41930 0 0 {name=X_63580_ }
C {devices/lab_pin.sym} 22820 -41790 0 0 {name=p21932 lab=clkbuf_9_79_0_CLK/X }
C {devices/lab_pin.sym} 22900 -41790 0 1 {name=p21933 lab=_81680_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 22860 -41790 0 0 {name=Xclkbuf_10_158_0_CLK }
C {devices/lab_pin.sym} 22800 -41690 0 0 {name=p21934 lab=_75561_/Y }
C {devices/lab_pin.sym} 22800 -41650 0 0 {name=p21935 lab=_80801_/Q }
C {devices/lab_pin.sym} 22800 -41610 0 0 {name=p21936 lab=_75563_/B }
C {devices/lab_pin.sym} 22920 -41650 0 1 {name=p21937 lab=_75567_/B }
C {sky130_stdcells/nand3_4.sym} 22860 -41650 0 0 {name=X_75566_ }
C {devices/lab_pin.sym} 22780 -41550 0 0 {name=p21938 lab=_41937_/X }
C {devices/lab_pin.sym} 22780 -41510 0 0 {name=p21939 lab=_41956_/X }
C {devices/lab_pin.sym} 22780 -41470 0 0 {name=p21940 lab=_40712_/X }
C {devices/lab_pin.sym} 22780 -41430 0 0 {name=p21941 lab=_41957_/Y }
C {devices/lab_pin.sym} 22780 -41390 0 0 {name=p21942 lab=_41939_/X }
C {devices/lab_pin.sym} 22940 -41470 0 1 {name=p21943 lab=_88093_/D }
C {sky130_stdcells/o32ai_4.sym} 22860 -41470 0 0 {name=X_41958_ }
C {devices/lab_pin.sym} 22800 -41330 0 0 {name=p21944 lab=_60792_/A }
C {devices/lab_pin.sym} 22800 -41290 0 0 {name=p21945 lab=_60761_/B }
C {devices/lab_pin.sym} 22800 -41250 0 0 {name=p21946 lab=_84566_/Q }
C {devices/lab_pin.sym} 22920 -41290 0 1 {name=p21947 lab=_60792_/Y }
C {sky130_stdcells/nor3_4.sym} 22860 -41290 0 0 {name=X_60792_ }
C {devices/lab_pin.sym} 22780 -41170 0 0 {name=p21948 lab=_44518_/Y }
C {devices/lab_pin.sym} 22780 -41130 0 0 {name=p21949 lab=_72775_/X }
C {devices/lab_pin.sym} 22780 -41090 0 0 {name=p21950 lab=_72777_/Y }
C {devices/lab_pin.sym} 22940 -41130 0 1 {name=p21951 lab=_72791_/C }
C {sky130_stdcells/a21o_4.sym} 22860 -41130 0 0 {name=X_72778_ }
C {devices/lab_pin.sym} 22800 -41000 0 0 {name=p21952 lab=_77305_/A }
C {devices/lab_pin.sym} 22800 -40960 0 0 {name=p21953 lab=_82132_/Q }
C {devices/lab_pin.sym} 22920 -40980 0 1 {name=p21954 lab=_77310_/A }
C {sky130_stdcells/nor2_4.sym} 22860 -40980 0 0 {name=X_77305_ }
C {devices/lab_pin.sym} 22820 -40850 0 0 {name=p21955 lab=clkbuf_9_394_0_CLK/X }
C {devices/lab_pin.sym} 22900 -40850 0 1 {name=p21956 lab=_82740_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 22860 -40850 0 0 {name=Xclkbuf_10_788_0_CLK }
C {devices/lab_pin.sym} 22800 -40760 0 0 {name=p21957 lab=_61597_/A }
C {devices/lab_pin.sym} 22800 -40720 0 0 {name=p21958 lab=_62566_/B }
C {devices/lab_pin.sym} 22800 -40680 0 0 {name=p21959 lab=_62501_/X }
C {devices/lab_pin.sym} 22800 -40640 0 0 {name=p21960 lab=_62566_/D }
C {devices/lab_pin.sym} 22920 -40700 0 1 {name=p21961 lab=_62536_/B }
C {sky130_stdcells/nand4_4.sym} 22860 -40700 0 0 {name=X_62531_ }
C {devices/lab_pin.sym} 22820 -40550 0 0 {name=p21962 lab=_74516_/X }
C {devices/lab_pin.sym} 22900 -40550 0 1 {name=p21963 lab=_74517_/X }
C {sky130_stdcells/buf_2.sym} 22860 -40550 0 0 {name=X_74517_ }
C {devices/lab_pin.sym} 22820 -40430 0 0 {name=p21964 lab=_40908_/X }
C {devices/lab_pin.sym} 22900 -40430 0 1 {name=p21965 lab=_40909_/X }
C {sky130_stdcells/buf_2.sym} 22860 -40430 0 0 {name=X_40909_ }
C {devices/lab_pin.sym} 22820 -40310 0 0 {name=p21966 lab=_47465_/A }
C {devices/lab_pin.sym} 22900 -40310 0 1 {name=p21967 lab=_53063_/D }
C {sky130_stdcells/buf_2.sym} 22860 -40310 0 0 {name=X_47465_ }
C {devices/lab_pin.sym} 22800 -40210 0 0 {name=p21968 lab=_71729_/A }
C {devices/lab_pin.sym} 22800 -40170 0 0 {name=p21969 lab=_71256_/B }
C {devices/lab_pin.sym} 22800 -40130 0 0 {name=p21970 lab=_71724_/X }
C {devices/lab_pin.sym} 22920 -40170 0 1 {name=p21971 lab=_71729_/Y }
C {sky130_stdcells/nand3_4.sym} 22860 -40170 0 0 {name=X_71729_ }
C {devices/lab_pin.sym} 22780 -40050 0 0 {name=p21972 lab=_78280_/Y }
C {devices/lab_pin.sym} 22780 -40010 0 0 {name=p21973 lab=_78256_/B }
C {devices/lab_pin.sym} 22780 -39970 0 0 {name=p21974 lab=_78284_/X }
C {devices/lab_pin.sym} 22940 -40010 0 1 {name=p21975 lab=_78286_/B }
C {sky130_stdcells/o21ai_4.sym} 22860 -40010 0 0 {name=X_78285_ }
C {devices/lab_pin.sym} 22780 -39910 0 0 {name=p21976 lab=_44658_/X }
C {devices/lab_pin.sym} 22780 -39870 0 0 {name=p21977 lab=_44659_/X }
C {devices/lab_pin.sym} 22780 -39830 0 0 {name=p21978 lab=_40605_/X }
C {devices/lab_pin.sym} 22780 -39790 0 0 {name=p21979 lab=_87003_/Q }
C {devices/lab_pin.sym} 22780 -39750 0 0 {name=p21980 lab=_44660_/X }
C {devices/lab_pin.sym} 22940 -39830 0 1 {name=p21981 lab=_44677_/Y }
C {sky130_stdcells/o32ai_4.sym} 22860 -39830 0 0 {name=X_44677_ }
C {devices/lab_pin.sym} 22820 -39670 0 0 {name=p21982 lab=_75497_/A }
C {devices/lab_pin.sym} 22900 -39670 0 1 {name=p21983 lab=_75497_/Y }
C {sky130_stdcells/inv_2.sym} 22860 -39670 0 0 {name=X_75497_ }
C {devices/lab_pin.sym} 22820 -39550 0 0 {name=p21984 lab=_88112_/Q }
C {devices/lab_pin.sym} 22900 -39550 0 1 {name=p21985 lab=_41889_/Y }
C {sky130_stdcells/inv_2.sym} 22860 -39550 0 0 {name=X_41889_ }
C {devices/lab_pin.sym} 22820 -39430 0 0 {name=p21986 lab=_49052_/A }
C {devices/lab_pin.sym} 22900 -39430 0 1 {name=p21987 lab=_49204_/X }
C {sky130_stdcells/buf_2.sym} 22860 -39430 0 0 {name=X_49204_ }
C {devices/lab_pin.sym} 22820 -39310 0 0 {name=p21988 lab=_46416_/A }
C {devices/lab_pin.sym} 22900 -39310 0 1 {name=p21989 lab=_46417_/B }
C {sky130_stdcells/buf_2.sym} 22860 -39310 0 0 {name=X_46416_ }
C {devices/lab_pin.sym} 22780 -39220 0 0 {name=p21990 lab=_65118_/X }
C {devices/lab_pin.sym} 22780 -39180 0 0 {name=p21991 lab=_85544_/Q }
C {devices/lab_pin.sym} 22780 -39140 0 0 {name=p21992 lab=_65146_/X }
C {devices/lab_pin.sym} 22780 -39100 0 0 {name=p21993 lab=_65249_/X }
C {devices/lab_pin.sym} 22940 -39160 0 1 {name=p21994 lab=_65250_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -39160 0 0 {name=X_65250_ }
C {devices/lab_pin.sym} 22800 -39020 0 0 {name=p21995 lab=_77236_/A }
C {devices/lab_pin.sym} 22800 -38980 0 0 {name=p21996 lab=_82083_/D }
C {devices/lab_pin.sym} 22920 -39000 0 1 {name=p21997 lab=_77239_/A }
C {sky130_stdcells/or2_4.sym} 22860 -39000 0 0 {name=X_77236_ }
C {devices/lab_pin.sym} 22780 -38900 0 0 {name=p21998 lab=_40656_/A }
C {devices/lab_pin.sym} 22780 -38860 0 0 {name=p21999 lab=_43609_/X }
C {devices/lab_pin.sym} 22780 -38820 0 0 {name=p22000 lab=_68672_/B }
C {devices/lab_pin.sym} 22780 -38780 0 0 {name=p22001 lab=_43611_/X }
C {devices/lab_pin.sym} 22940 -38840 0 1 {name=p22002 lab=_43628_/X }
C {sky130_stdcells/a2bb2o_4.sym} 22860 -38840 0 0 {name=X_43628_ }
C {devices/lab_pin.sym} 22820 -38690 0 0 {name=p22003 lab=clkbuf_9_278_0_CLK/A }
C {devices/lab_pin.sym} 22900 -38690 0 1 {name=p22004 lab=clkbuf_9_279_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 22860 -38690 0 0 {name=Xclkbuf_9_279_0_CLK }
C {devices/lab_pin.sym} 22820 -38570 0 0 {name=p22005 lab=_62623_/C }
C {devices/lab_pin.sym} 22900 -38570 0 1 {name=p22006 lab=_62462_/X }
C {sky130_stdcells/buf_2.sym} 22860 -38570 0 0 {name=X_62462_ }
C {devices/lab_pin.sym} 22780 -38470 0 0 {name=p22007 lab=_83064_/Q }
C {devices/lab_pin.sym} 22780 -38430 0 0 {name=p22008 lab=_74387_/X }
C {devices/lab_pin.sym} 22780 -38390 0 0 {name=p22009 lab=_74447_/Y }
C {devices/lab_pin.sym} 22940 -38430 0 1 {name=p22010 lab=_74448_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -38430 0 0 {name=X_74448_ }
C {devices/lab_pin.sym} 22800 -38300 0 0 {name=p22011 lab=_47404_/A }
C {devices/lab_pin.sym} 22800 -38260 0 0 {name=p22012 lab=_53021_/B }
C {devices/lab_pin.sym} 22920 -38280 0 1 {name=p22013 lab=_47396_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -38280 0 0 {name=X_47396_ }
C {devices/lab_pin.sym} 22780 -38170 0 0 {name=p22014 lab=_64197_/X }
C {devices/lab_pin.sym} 22780 -38130 0 0 {name=p22015 lab=_64186_/X }
C {devices/lab_pin.sym} 22780 -38090 0 0 {name=p22016 lab=_64200_/Y }
C {devices/lab_pin.sym} 22940 -38130 0 1 {name=p22017 lab=_64201_/Y }
C {sky130_stdcells/a21oi_4.sym} 22860 -38130 0 0 {name=X_64201_ }
C {devices/lab_pin.sym} 22820 -37990 0 0 {name=p22018 lab=_49135_/A }
C {devices/lab_pin.sym} 22900 -37990 0 1 {name=p22019 lab=_49135_/X }
C {sky130_stdcells/buf_2.sym} 22860 -37990 0 0 {name=X_49135_ }
C {devices/lab_pin.sym} 22820 -37870 0 0 {name=p22020 lab=_61413_/A }
C {devices/lab_pin.sym} 22900 -37870 0 1 {name=p22021 lab=_61434_/A }
C {sky130_stdcells/buf_2.sym} 22860 -37870 0 0 {name=X_61413_ }
C {devices/lab_pin.sym} 22820 -37750 0 0 {name=p22022 lab=_46347_/A }
C {devices/lab_pin.sym} 22900 -37750 0 1 {name=p22023 lab=_46362_/A }
C {sky130_stdcells/buf_2.sym} 22860 -37750 0 0 {name=X_46347_ }
C {devices/lab_pin.sym} 22800 -37650 0 0 {name=p22024 lab=_65177_/X }
C {devices/lab_pin.sym} 22800 -37610 0 0 {name=p22025 lab=_65056_/B }
C {devices/lab_pin.sym} 22800 -37570 0 0 {name=p22026 lab=_65180_/X }
C {devices/lab_pin.sym} 22920 -37610 0 1 {name=p22027 lab=_65181_/Y }
C {sky130_stdcells/nand3_4.sym} 22860 -37610 0 0 {name=X_65181_ }
C {devices/lab_pin.sym} 22800 -37480 0 0 {name=p22028 lab=_77167_/A }
C {devices/lab_pin.sym} 22800 -37440 0 0 {name=p22029 lab=_77167_/B }
C {devices/lab_pin.sym} 22920 -37460 0 1 {name=p22030 lab=_77168_/B }
C {sky130_stdcells/xor2_4.sym} 22860 -37460 0 0 {name=X_77167_ }
C {devices/lab_pin.sym} 22820 -37330 0 0 {name=p22031 lab=_43558_/Y }
C {devices/lab_pin.sym} 22900 -37330 0 1 {name=p22032 lab=_87361_/D }
C {sky130_stdcells/inv_2.sym} 22860 -37330 0 0 {name=X_43559_ }
C {devices/lab_pin.sym} 22820 -37210 0 0 {name=p22033 lab=clkbuf_9_355_0_CLK/X }
C {devices/lab_pin.sym} 22900 -37210 0 1 {name=p22034 lab=_88268_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 22860 -37210 0 0 {name=Xclkbuf_10_711_0_CLK }
C {devices/lab_pin.sym} 22780 -37130 0 0 {name=p22035 lab=_61479_/B }
C {devices/lab_pin.sym} 22780 -37090 0 0 {name=p22036 lab=_62390_/X }
C {devices/lab_pin.sym} 22780 -37050 0 0 {name=p22037 lab=_62363_/X }
C {devices/lab_pin.sym} 22780 -37010 0 0 {name=p22038 lab=_62323_/X }
C {devices/lab_pin.sym} 22780 -36980 0 0 {name=p22039 lab=_62392_/X }
C {devices/lab_pin.sym} 22940 -37050 0 1 {name=p22040 lab=_62393_/X }
C {sky130_stdcells/a41o_4.sym} 22860 -37050 0 0 {name=X_62393_ }
C {devices/lab_pin.sym} 22800 -36900 0 0 {name=p22041 lab=_74408_/A }
C {devices/lab_pin.sym} 22800 -36860 0 0 {name=p22042 lab=_48391_/A }
C {devices/lab_pin.sym} 22920 -36880 0 1 {name=p22043 lab=_74379_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -36880 0 0 {name=X_74379_ }
C {devices/lab_pin.sym} 22800 -36760 0 0 {name=p22044 lab=_58976_/A }
C {devices/lab_pin.sym} 22800 -36720 0 0 {name=p22045 lab=_64102_/B }
C {devices/lab_pin.sym} 22920 -36740 0 1 {name=p22046 lab=_64132_/Y }
C {sky130_stdcells/nor2_4.sym} 22860 -36740 0 0 {name=X_64132_ }
C {devices/lab_pin.sym} 22800 -36620 0 0 {name=p22047 lab=_81724_/D }
C {devices/lab_pin.sym} 22800 -36580 0 0 {name=p22048 lab=_76126_/C }
C {devices/lab_pin.sym} 22920 -36600 0 1 {name=p22049 lab=_76118_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -36600 0 0 {name=X_76118_ }
C {devices/lab_pin.sym} 22780 -36490 0 0 {name=p22050 lab=_65087_/B }
C {devices/lab_pin.sym} 22780 -36450 0 0 {name=p22051 lab=_49052_/X }
C {devices/lab_pin.sym} 22780 -36410 0 0 {name=p22052 lab=_49065_/Y }
C {devices/lab_pin.sym} 22940 -36450 0 1 {name=p22053 lab=_49066_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -36450 0 0 {name=X_49066_ }
C {devices/lab_pin.sym} 22800 -36340 0 0 {name=p22054 lab=_63380_/A }
C {devices/lab_pin.sym} 22800 -36300 0 0 {name=p22055 lab=_61368_/B }
C {devices/lab_pin.sym} 22800 -36260 0 0 {name=p22056 lab=_61368_/C }
C {devices/lab_pin.sym} 22800 -36220 0 0 {name=p22057 lab=_61368_/D }
C {devices/lab_pin.sym} 22920 -36280 0 1 {name=p22058 lab=_61344_/Y }
C {sky130_stdcells/nand4_4.sym} 22860 -36280 0 0 {name=X_61344_ }
C {devices/lab_pin.sym} 22780 -36150 0 0 {name=p22059 lab=_46273_/Y }
C {devices/lab_pin.sym} 22780 -36110 0 0 {name=p22060 lab=_46258_/X }
C {devices/lab_pin.sym} 22780 -36070 0 0 {name=p22061 lab=_46277_/Y }
C {devices/lab_pin.sym} 22940 -36110 0 1 {name=p22062 lab=_46278_/Y }
C {sky130_stdcells/a21boi_4.sym} 22860 -36110 0 0 {name=X_46278_ }
C {devices/lab_pin.sym} 22800 -35980 0 0 {name=p22063 lab=_77098_/A }
C {devices/lab_pin.sym} 22800 -35940 0 0 {name=p22064 lab=_82287_/D }
C {devices/lab_pin.sym} 22920 -35960 0 1 {name=p22065 lab=_77098_/Y }
C {sky130_stdcells/nor2_4.sym} 22860 -35960 0 0 {name=X_77098_ }
C {devices/lab_pin.sym} 22820 -35830 0 0 {name=p22066 lab=clkbuf_9_203_0_CLK/A }
C {devices/lab_pin.sym} 22900 -35830 0 1 {name=p22067 lab=clkbuf_9_202_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 22860 -35830 0 0 {name=Xclkbuf_9_202_0_CLK }
C {devices/lab_pin.sym} 22780 -35730 0 0 {name=p22068 lab=_66155_/B }
C {devices/lab_pin.sym} 22780 -35690 0 0 {name=p22069 lab=_47998_/X }
C {devices/lab_pin.sym} 22780 -35650 0 0 {name=p22070 lab=_48016_/Y }
C {devices/lab_pin.sym} 22940 -35690 0 1 {name=p22071 lab=_48017_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -35690 0 0 {name=X_48017_ }
C {devices/lab_pin.sym} 22820 -35550 0 0 {name=p22072 lab=_45651_/A }
C {devices/lab_pin.sym} 22900 -35550 0 1 {name=p22073 lab=_45229_/X }
C {sky130_stdcells/buf_2.sym} 22860 -35550 0 0 {name=X_45229_ }
C {devices/lab_pin.sym} 22800 -35460 0 0 {name=p22074 lab=_83245_/Q }
C {devices/lab_pin.sym} 22800 -35420 0 0 {name=p22075 lab=_64158_/B }
C {devices/lab_pin.sym} 22800 -35380 0 0 {name=p22076 lab=_64158_/C }
C {devices/lab_pin.sym} 22800 -35340 0 0 {name=p22077 lab=_64045_/X }
C {devices/lab_pin.sym} 22920 -35400 0 1 {name=p22078 lab=_64064_/D }
C {sky130_stdcells/nand4_4.sym} 22860 -35400 0 0 {name=X_64063_ }
C {devices/lab_pin.sym} 22800 -35260 0 0 {name=p22079 lab=_68937_/X }
C {devices/lab_pin.sym} 22800 -35220 0 0 {name=p22080 lab=_68940_/B }
C {devices/lab_pin.sym} 22920 -35240 0 1 {name=p22081 lab=_68940_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -35240 0 0 {name=X_68940_ }
C {devices/lab_pin.sym} 22800 -35120 0 0 {name=p22082 lab=_81339_/Q }
C {devices/lab_pin.sym} 22800 -35080 0 0 {name=p22083 lab=_76041_/B }
C {devices/lab_pin.sym} 22920 -35100 0 1 {name=p22084 lab=_76049_/Y }
C {sky130_stdcells/nor2_4.sym} 22860 -35100 0 0 {name=X_76049_ }
C {devices/lab_pin.sym} 22780 -35010 0 0 {name=p22085 lab=_60440_/X }
C {devices/lab_pin.sym} 22780 -34970 0 0 {name=p22086 lab=_61272_/B }
C {devices/lab_pin.sym} 22780 -34930 0 0 {name=p22087 lab=_61264_/B }
C {devices/lab_pin.sym} 22780 -34890 0 0 {name=p22088 lab=_61202_/Y }
C {devices/lab_pin.sym} 22780 -34860 0 0 {name=p22089 lab=_61274_/Y }
C {devices/lab_pin.sym} 22940 -34930 0 1 {name=p22090 lab=_61275_/Y }
C {sky130_stdcells/a41oi_4.sym} 22860 -34930 0 0 {name=X_61275_ }
C {devices/lab_pin.sym} 22800 -34800 0 0 {name=p22091 lab=_60595_/C }
C {devices/lab_pin.sym} 22800 -34760 0 0 {name=p22092 lab=_64225_/C }
C {devices/lab_pin.sym} 22800 -34720 0 0 {name=p22093 lab=_60399_/B }
C {devices/lab_pin.sym} 22800 -34680 0 0 {name=p22094 lab=_63014_/D }
C {devices/lab_pin.sym} 22920 -34740 0 1 {name=p22095 lab=_63014_/X }
C {sky130_stdcells/and4_4.sym} 22860 -34740 0 0 {name=X_63014_ }
C {devices/lab_pin.sym} 22820 -34590 0 0 {name=p22096 lab=_60255_/B }
C {devices/lab_pin.sym} 22900 -34590 0 1 {name=p22097 lab=_60331_/B }
C {sky130_stdcells/buf_2.sym} 22860 -34590 0 0 {name=X_60226_ }
C {devices/lab_pin.sym} 22820 -34470 0 0 {name=p22098 lab=clkbuf_9_363_0_CLK/X }
C {devices/lab_pin.sym} 22900 -34470 0 1 {name=p22099 lab=_88301_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 22860 -34470 0 0 {name=Xclkbuf_10_726_0_CLK }
C {devices/lab_pin.sym} 22820 -34350 0 0 {name=p22100 lab=_69371_/A }
C {devices/lab_pin.sym} 22900 -34350 0 1 {name=p22101 lab=_68871_/X }
C {sky130_stdcells/buf_2.sym} 22860 -34350 0 0 {name=X_68871_ }
C {devices/lab_pin.sym} 22800 -34240 0 0 {name=p22102 lab=_67891_/A }
C {devices/lab_pin.sym} 22800 -34200 0 0 {name=p22103 lab=_86923_/Q }
C {devices/lab_pin.sym} 22920 -34220 0 1 {name=p22104 lab=_67822_/X }
C {sky130_stdcells/and2_4.sym} 22860 -34220 0 0 {name=X_67822_ }
C {devices/lab_pin.sym} 22800 -34100 0 0 {name=p22105 lab=_79804_/X }
C {devices/lab_pin.sym} 22800 -34060 0 0 {name=p22106 lab=_79820_/B }
C {devices/lab_pin.sym} 22920 -34080 0 1 {name=p22107 lab=_79829_/A }
C {sky130_stdcells/xor2_4.sym} 22860 -34080 0 0 {name=X_79808_ }
C {devices/lab_pin.sym} 22820 -33950 0 0 {name=p22108 lab=_60156_/Y }
C {devices/lab_pin.sym} 22900 -33950 0 1 {name=p22109 lab=_60251_/A }
C {sky130_stdcells/buf_2.sym} 22860 -33950 0 0 {name=X_60157_ }
C {devices/lab_pin.sym} 22820 -33830 0 0 {name=p22110 lab=clkbuf_9_217_0_CLK/A }
C {devices/lab_pin.sym} 22900 -33830 0 1 {name=p22111 lab=clkbuf_9_217_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 22860 -33830 0 0 {name=Xclkbuf_9_217_0_CLK }
C {devices/lab_pin.sym} 22820 -33710 0 0 {name=p22112 lab=_49915_/A }
C {devices/lab_pin.sym} 22900 -33710 0 1 {name=p22113 lab=_49973_/B }
C {sky130_stdcells/buf_2.sym} 22860 -33710 0 0 {name=X_49968_ }
C {devices/lab_pin.sym} 22780 -33610 0 0 {name=p22114 lab=_48913_/Y }
C {devices/lab_pin.sym} 22780 -33570 0 0 {name=p22115 lab=_48880_/X }
C {devices/lab_pin.sym} 22780 -33530 0 0 {name=p22116 lab=_48918_/X }
C {devices/lab_pin.sym} 22940 -33570 0 1 {name=p22117 lab=_48919_/Y }
C {sky130_stdcells/a21oi_4.sym} 22860 -33570 0 0 {name=X_48919_ }
C {devices/lab_pin.sym} 22800 -33440 0 0 {name=p22118 lab=_79732_/X }
C {devices/lab_pin.sym} 22800 -33400 0 0 {name=p22119 lab=_79739_/B }
C {devices/lab_pin.sym} 22920 -33420 0 1 {name=p22120 lab=_79739_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -33420 0 0 {name=X_79739_ }
C {devices/lab_pin.sym} 22780 -33320 0 0 {name=p22121 lab=_87458_/Q }
C {devices/lab_pin.sym} 22780 -33280 0 0 {name=p22122 lab=_67751_/X }
C {devices/lab_pin.sym} 22780 -33240 0 0 {name=p22123 lab=_67702_/X }
C {devices/lab_pin.sym} 22780 -33200 0 0 {name=p22124 lab=_67752_/X }
C {devices/lab_pin.sym} 22940 -33260 0 1 {name=p22125 lab=_67753_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -33260 0 0 {name=X_67753_ }
C {devices/lab_pin.sym} 22800 -33130 0 0 {name=p22126 lab=_64960_/X }
C {devices/lab_pin.sym} 22800 -33090 0 0 {name=p22127 lab=_65111_/B }
C {devices/lab_pin.sym} 22800 -33050 0 0 {name=p22128 lab=_64964_/X }
C {devices/lab_pin.sym} 22920 -33090 0 1 {name=p22129 lab=_64965_/Y }
C {sky130_stdcells/nand3_4.sym} 22860 -33090 0 0 {name=X_64965_ }
C {devices/lab_pin.sym} 22820 -32950 0 0 {name=p22130 lab=_59852_/A }
C {devices/lab_pin.sym} 22900 -32950 0 1 {name=p22131 lab=_60103_/B }
C {sky130_stdcells/buf_2.sym} 22860 -32950 0 0 {name=X_60088_ }
C {devices/lab_pin.sym} 22800 -32860 0 0 {name=p22132 lab=_49904_/A }
C {devices/lab_pin.sym} 22800 -32820 0 0 {name=p22133 lab=_49893_/B }
C {devices/lab_pin.sym} 22800 -32780 0 0 {name=p22134 lab=_49893_/C }
C {devices/lab_pin.sym} 22800 -32740 0 0 {name=p22135 lab=_53113_/D }
C {devices/lab_pin.sym} 22920 -32800 0 1 {name=p22136 lab=_49899_/X }
C {sky130_stdcells/and4_4.sym} 22860 -32800 0 0 {name=X_49899_ }
C {devices/lab_pin.sym} 22800 -32660 0 0 {name=p22137 lab=_66728_/A }
C {devices/lab_pin.sym} 22800 -32620 0 0 {name=p22138 lab=_66704_/B }
C {devices/lab_pin.sym} 22920 -32640 0 1 {name=p22139 lab=_66704_/X }
C {sky130_stdcells/and2_4.sym} 22860 -32640 0 0 {name=X_66704_ }
C {devices/lab_pin.sym} 22820 -32510 0 0 {name=p22140 lab=clkbuf_4_3_0_CLK/A }
C {devices/lab_pin.sym} 22900 -32510 0 1 {name=p22141 lab=clkbuf_4_2_1_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 22860 -32510 0 0 {name=Xclkbuf_4_2_0_CLK }
C {devices/lab_pin.sym} 22820 -32390 0 0 {name=p22142 lab=_52322_/A }
C {devices/lab_pin.sym} 22900 -32390 0 1 {name=p22143 lab=_53199_/A }
C {sky130_stdcells/buf_2.sym} 22860 -32390 0 0 {name=X_51930_ }
C {devices/lab_pin.sym} 22800 -32300 0 0 {name=p22144 lab=_61468_/A }
C {devices/lab_pin.sym} 22800 -32260 0 0 {name=p22145 lab=_63853_/B }
C {devices/lab_pin.sym} 22800 -32220 0 0 {name=p22146 lab=_63947_/C }
C {devices/lab_pin.sym} 22800 -32180 0 0 {name=p22147 lab=_63866_/X }
C {devices/lab_pin.sym} 22920 -32240 0 1 {name=p22148 lab=_63916_/Y }
C {sky130_stdcells/nand4_4.sym} 22860 -32240 0 0 {name=X_63916_ }
C {devices/lab_pin.sym} 22770 -32090 0 0 {name=p22149 lab=_84161_/CLK }
C {devices/lab_pin.sym} 22770 -32070 0 0 {name=p22150 lab=_84134_/Q }
C {devices/lab_pin.sym} 22950 -32090 0 1 {name=p22151 lab=_79071_/A }
C {sky130_stdcells/dfxtp_4.sym} 22860 -32080 0 0 {name=X_82750_ }
C {devices/lab_pin.sym} 22780 -31980 0 0 {name=p22152 lab=_87153_/Q }
C {devices/lab_pin.sym} 22780 -31940 0 0 {name=p22153 lab=_67585_/X }
C {devices/lab_pin.sym} 22780 -31900 0 0 {name=p22154 lab=_67633_/X }
C {devices/lab_pin.sym} 22780 -31860 0 0 {name=p22155 lab=_67683_/X }
C {devices/lab_pin.sym} 22940 -31920 0 1 {name=p22156 lab=_67684_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -31920 0 0 {name=X_67684_ }
C {devices/lab_pin.sym} 22780 -31800 0 0 {name=p22157 lab=_64696_/X }
C {devices/lab_pin.sym} 22780 -31760 0 0 {name=p22158 lab=_85526_/Q }
C {devices/lab_pin.sym} 22780 -31720 0 0 {name=p22159 lab=_64697_/X }
C {devices/lab_pin.sym} 22780 -31680 0 0 {name=p22160 lab=_64895_/X }
C {devices/lab_pin.sym} 22940 -31740 0 1 {name=p22161 lab=_64896_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -31740 0 0 {name=X_64896_ }
C {devices/lab_pin.sym} 22770 -31590 0 0 {name=p22162 lab=_82053_/CLK }
C {devices/lab_pin.sym} 22770 -31570 0 0 {name=p22163 lab=_81701_/D }
C {devices/lab_pin.sym} 22950 -31590 0 1 {name=p22164 lab=_41266_/A }
C {sky130_stdcells/dfxtp_4.sym} 22860 -31580 0 0 {name=X_81701_ }
C {devices/lab_pin.sym} 22820 -31450 0 0 {name=p22165 lab=_69746_/A }
C {devices/lab_pin.sym} 22900 -31450 0 1 {name=p22166 lab=_69423_/X }
C {sky130_stdcells/buf_2.sym} 22860 -31450 0 0 {name=X_69423_ }
C {devices/lab_pin.sym} 22780 -31360 0 0 {name=p22167 lab=_87133_/Q }
C {devices/lab_pin.sym} 22780 -31320 0 0 {name=p22168 lab=_66633_/X }
C {devices/lab_pin.sym} 22780 -31280 0 0 {name=p22169 lab=_46212_/A }
C {devices/lab_pin.sym} 22780 -31240 0 0 {name=p22170 lab=_66634_/X }
C {devices/lab_pin.sym} 22940 -31300 0 1 {name=p22171 lab=_66635_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -31300 0 0 {name=X_66635_ }
C {devices/lab_pin.sym} 22780 -31170 0 0 {name=p22172 lab=_51858_/Y }
C {devices/lab_pin.sym} 22780 -31130 0 0 {name=p22173 lab=_51850_/X }
C {devices/lab_pin.sym} 22780 -31090 0 0 {name=p22174 lab=_51860_/X }
C {devices/lab_pin.sym} 22940 -31130 0 1 {name=p22175 lab=_51861_/Y }
C {sky130_stdcells/a21oi_4.sym} 22860 -31130 0 0 {name=X_51861_ }
C {devices/lab_pin.sym} 22780 -31030 0 0 {name=p22176 lab=_63842_/X }
C {devices/lab_pin.sym} 22780 -30990 0 0 {name=p22177 lab=_63810_/X }
C {devices/lab_pin.sym} 22780 -30950 0 0 {name=p22178 lab=_63843_/Y }
C {devices/lab_pin.sym} 22780 -30910 0 0 {name=p22179 lab=_63844_/Y }
C {devices/lab_pin.sym} 22780 -30880 0 0 {name=p22180 lab=_63846_/X }
C {devices/lab_pin.sym} 22940 -30950 0 1 {name=p22181 lab=_63847_/X }
C {sky130_stdcells/a41o_4.sym} 22860 -30950 0 0 {name=X_63847_ }
C {devices/lab_pin.sym} 22770 -30790 0 0 {name=p22182 lab=_81198_/CLK }
C {devices/lab_pin.sym} 22770 -30770 0 0 {name=p22183 lab=_82681_/D }
C {devices/lab_pin.sym} 22950 -30790 0 1 {name=p22184 lab=_78247_/A }
C {sky130_stdcells/dfxtp_4.sym} 22860 -30780 0 0 {name=X_82681_ }
C {devices/lab_pin.sym} 22780 -30670 0 0 {name=p22185 lab=_53598_/Y }
C {devices/lab_pin.sym} 22780 -30630 0 0 {name=p22186 lab=_53574_/X }
C {devices/lab_pin.sym} 22780 -30590 0 0 {name=p22187 lab=_53599_/Y }
C {devices/lab_pin.sym} 22940 -30630 0 1 {name=p22188 lab=_85605_/D }
C {sky130_stdcells/a21boi_4.sym} 22860 -30630 0 0 {name=X_53600_ }
C {devices/lab_pin.sym} 22770 -30490 0 0 {name=p22189 lab=_84420_/CLK }
C {devices/lab_pin.sym} 22770 -30470 0 0 {name=p22190 lab=_62303_/Y }
C {devices/lab_pin.sym} 22950 -30490 0 1 {name=p22191 lab=_62302_/C }
C {sky130_stdcells/dfxtp_4.sym} 22860 -30480 0 0 {name=X_84420_ }
C {devices/lab_pin.sym} 22800 -30370 0 0 {name=p22192 lab=_50812_/A }
C {devices/lab_pin.sym} 22800 -30330 0 0 {name=p22193 lab=_50751_/B }
C {devices/lab_pin.sym} 22800 -30290 0 0 {name=p22194 lab=_50751_/C }
C {devices/lab_pin.sym} 22920 -30330 0 1 {name=p22195 lab=_50812_/X }
C {sky130_stdcells/and3_4.sym} 22860 -30330 0 0 {name=X_50812_ }
C {devices/lab_pin.sym} 22770 -30190 0 0 {name=p22196 lab=_81632_/CLK }
C {devices/lab_pin.sym} 22770 -30170 0 0 {name=p22197 lab=_76628_/Y }
C {devices/lab_pin.sym} 22950 -30190 0 1 {name=p22198 lab=_81632_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -30180 0 0 {name=X_81632_ }
C {devices/lab_pin.sym} 22800 -30060 0 0 {name=p22199 lab=_69234_/A }
C {devices/lab_pin.sym} 22800 -30020 0 0 {name=p22200 lab=_69354_/B }
C {devices/lab_pin.sym} 22920 -30040 0 1 {name=p22201 lab=_69354_/X }
C {sky130_stdcells/and2_4.sym} 22860 -30040 0 0 {name=X_69354_ }
C {devices/lab_pin.sym} 22800 -29940 0 0 {name=p22202 lab=_54565_/A }
C {devices/lab_pin.sym} 22800 -29900 0 0 {name=p22203 lab=_54585_/B }
C {devices/lab_pin.sym} 22800 -29860 0 0 {name=p22204 lab=_54565_/C }
C {devices/lab_pin.sym} 22800 -29820 0 0 {name=p22205 lab=_54580_/D }
C {devices/lab_pin.sym} 22920 -29880 0 1 {name=p22206 lab=_54580_/X }
C {sky130_stdcells/and4_4.sym} 22860 -29880 0 0 {name=X_54580_ }
C {devices/lab_pin.sym} 22820 -29730 0 0 {name=p22207 lab=_69178_/A }
C {devices/lab_pin.sym} 22900 -29730 0 1 {name=p22208 lab=_69454_/A }
C {sky130_stdcells/buf_2.sym} 22860 -29730 0 0 {name=X_66566_ }
C {devices/lab_pin.sym} 22780 -29630 0 0 {name=p22209 lab=_85945_/Q }
C {devices/lab_pin.sym} 22780 -29590 0 0 {name=p22210 lab=_51789_/X }
C {devices/lab_pin.sym} 22780 -29550 0 0 {name=p22211 lab=_51791_/Y }
C {devices/lab_pin.sym} 22940 -29590 0 1 {name=p22212 lab=_51792_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -29590 0 0 {name=X_51792_ }
C {devices/lab_pin.sym} 22800 -29480 0 0 {name=p22213 lab=_58225_/X }
C {devices/lab_pin.sym} 22800 -29440 0 0 {name=p22214 lab=_64189_/C }
C {devices/lab_pin.sym} 22800 -29400 0 0 {name=p22215 lab=_60908_/A }
C {devices/lab_pin.sym} 22800 -29360 0 0 {name=p22216 lab=_63731_/D }
C {devices/lab_pin.sym} 22920 -29420 0 1 {name=p22217 lab=_63779_/D }
C {sky130_stdcells/nand4_4.sym} 22860 -29420 0 0 {name=X_63778_ }
C {devices/lab_pin.sym} 22780 -29290 0 0 {name=p22218 lab=_67871_/X }
C {devices/lab_pin.sym} 22780 -29250 0 0 {name=p22219 lab=_67874_/X }
C {devices/lab_pin.sym} 22780 -29210 0 0 {name=p22220 lab=_68295_/X }
C {devices/lab_pin.sym} 22940 -29250 0 1 {name=p22221 lab=_68305_/Y }
C {sky130_stdcells/a21oi_4.sym} 22860 -29250 0 0 {name=X_68305_ }
C {devices/lab_pin.sym} 22800 -29120 0 0 {name=p22222 lab=_53468_/A }
C {devices/lab_pin.sym} 22800 -29080 0 0 {name=p22223 lab=_53531_/B }
C {devices/lab_pin.sym} 22920 -29100 0 1 {name=p22224 lab=_53531_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -29100 0 0 {name=X_53531_ }
C {devices/lab_pin.sym} 22820 -28970 0 0 {name=p22225 lab=_65790_/A }
C {devices/lab_pin.sym} 22900 -28970 0 1 {name=p22226 lab=_65517_/X }
C {sky130_stdcells/buf_2.sym} 22860 -28970 0 0 {name=X_65517_ }
C {devices/lab_pin.sym} 22770 -28850 0 0 {name=p22227 lab=_84350_/CLK }
C {devices/lab_pin.sym} 22770 -28830 0 0 {name=p22228 lab=_84351_/D }
C {devices/lab_pin.sym} 22950 -28850 0 1 {name=p22229 lab=_84351_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -28840 0 0 {name=X_84351_ }
C {devices/lab_pin.sym} 22820 -28710 0 0 {name=p22230 lab=_50596_/A }
C {devices/lab_pin.sym} 22900 -28710 0 1 {name=p22231 lab=_50771_/A }
C {sky130_stdcells/buf_2.sym} 22860 -28710 0 0 {name=X_50743_ }
C {devices/lab_pin.sym} 22800 -28620 0 0 {name=p22232 lab=_61399_/X }
C {devices/lab_pin.sym} 22800 -28580 0 0 {name=p22233 lab=_62694_/B }
C {devices/lab_pin.sym} 22800 -28540 0 0 {name=p22234 lab=_62694_/C }
C {devices/lab_pin.sym} 22800 -28500 0 0 {name=p22235 lab=_62729_/D }
C {devices/lab_pin.sym} 22920 -28560 0 1 {name=p22236 lab=_62729_/Y }
C {sky130_stdcells/nand4_4.sym} 22860 -28560 0 0 {name=X_62729_ }
C {devices/lab_pin.sym} 22770 -28410 0 0 {name=p22237 lab=_84064_/CLK }
C {devices/lab_pin.sym} 22770 -28390 0 0 {name=p22238 lab=_76879_/X }
C {devices/lab_pin.sym} 22950 -28410 0 1 {name=p22239 lab=_81563_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -28400 0 0 {name=X_81563_ }
C {devices/lab_pin.sym} 22820 -28270 0 0 {name=p22240 lab=_69190_/A }
C {devices/lab_pin.sym} 22900 -28270 0 1 {name=p22241 lab=_69286_/A }
C {sky130_stdcells/buf_2.sym} 22860 -28270 0 0 {name=X_69285_ }
C {devices/lab_pin.sym} 22820 -28150 0 0 {name=p22242 lab=_64636_/A }
C {devices/lab_pin.sym} 22900 -28150 0 1 {name=p22243 lab=_68823_/A }
C {sky130_stdcells/buf_2.sym} 22860 -28150 0 0 {name=X_66497_ }
C {devices/lab_pin.sym} 22770 -28030 0 0 {name=p22244 lab=_83303_/CLK }
C {devices/lab_pin.sym} 22770 -28010 0 0 {name=p22245 lab=_72015_/Y }
C {devices/lab_pin.sym} 22950 -28030 0 1 {name=p22246 lab=_83302_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -28020 0 0 {name=X_83302_ }
C {devices/lab_pin.sym} 22800 -27900 0 0 {name=p22247 lab=_84766_/Q }
C {devices/lab_pin.sym} 22800 -27860 0 0 {name=p22248 lab=_84158_/Q }
C {devices/lab_pin.sym} 22920 -27880 0 1 {name=p22249 lab=_80514_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -27880 0 0 {name=X_80514_ }
C {devices/lab_pin.sym} 22780 -27780 0 0 {name=p22250 lab=_68188_/X }
C {devices/lab_pin.sym} 22780 -27740 0 0 {name=p22251 lab=_67458_/Y }
C {devices/lab_pin.sym} 22780 -27700 0 0 {name=p22252 lab=_68228_/X }
C {devices/lab_pin.sym} 22780 -27660 0 0 {name=p22253 lab=_68235_/Y }
C {devices/lab_pin.sym} 22940 -27720 0 1 {name=p22254 lab=_68236_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -27720 0 0 {name=X_68236_ }
C {devices/lab_pin.sym} 22800 -27590 0 0 {name=p22255 lab=_56250_/A }
C {devices/lab_pin.sym} 22800 -27550 0 0 {name=p22256 lab=_56253_/B }
C {devices/lab_pin.sym} 22800 -27510 0 0 {name=p22257 lab=_56250_/C }
C {devices/lab_pin.sym} 22920 -27550 0 1 {name=p22258 lab=_56250_/Y }
C {sky130_stdcells/nand3_4.sym} 22860 -27550 0 0 {name=X_56250_ }
C {devices/lab_pin.sym} 22770 -27410 0 0 {name=p22259 lab=_87070_/CLK }
C {devices/lab_pin.sym} 22770 -27390 0 0 {name=p22260 lab=_87070_/D }
C {devices/lab_pin.sym} 22950 -27410 0 1 {name=p22261 lab=_44518_/A }
C {sky130_stdcells/dfxtp_4.sym} 22860 -27400 0 0 {name=X_87070_ }
C {devices/lab_pin.sym} 22800 -27280 0 0 {name=p22262 lab=_53458_/A }
C {devices/lab_pin.sym} 22800 -27240 0 0 {name=p22263 lab=_50234_/B }
C {devices/lab_pin.sym} 22920 -27260 0 1 {name=p22264 lab=_53462_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -27260 0 0 {name=X_53462_ }
C {devices/lab_pin.sym} 22820 -27130 0 0 {name=p22265 lab=_65529_/A }
C {devices/lab_pin.sym} 22900 -27130 0 1 {name=p22266 lab=_65448_/X }
C {sky130_stdcells/buf_2.sym} 22860 -27130 0 0 {name=X_65448_ }
C {devices/lab_pin.sym} 22770 -27010 0 0 {name=p22267 lab=_84280_/CLK }
C {devices/lab_pin.sym} 22770 -26990 0 0 {name=p22268 lab=_84282_/D }
C {devices/lab_pin.sym} 22950 -27010 0 1 {name=p22269 lab=_63995_/C }
C {sky130_stdcells/dfxtp_4.sym} 22860 -27000 0 0 {name=X_84282_ }
C {devices/lab_pin.sym} 22800 -26880 0 0 {name=p22270 lab=_50657_/A }
C {devices/lab_pin.sym} 22800 -26840 0 0 {name=p22271 lab=_50674_/B }
C {devices/lab_pin.sym} 22920 -26860 0 1 {name=p22272 lab=_50674_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -26860 0 0 {name=X_50674_ }
C {devices/lab_pin.sym} 22770 -26730 0 0 {name=p22273 lab=_81333_/CLK }
C {devices/lab_pin.sym} 22770 -26710 0 0 {name=p22274 lab=_81494_/D }
C {devices/lab_pin.sym} 22950 -26730 0 1 {name=p22275 lab=_81494_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -26720 0 0 {name=X_81494_ }
C {devices/lab_pin.sym} 22800 -26610 0 0 {name=p22276 lab=_55201_/A }
C {devices/lab_pin.sym} 22800 -26570 0 0 {name=p22277 lab=_55196_/B }
C {devices/lab_pin.sym} 22800 -26530 0 0 {name=p22278 lab=_55201_/C }
C {devices/lab_pin.sym} 22920 -26570 0 1 {name=p22279 lab=_55201_/Y }
C {sky130_stdcells/nand3_4.sym} 22860 -26570 0 0 {name=X_55201_ }
C {devices/lab_pin.sym} 22770 -26430 0 0 {name=p22280 lab=_86121_/CLK }
C {devices/lab_pin.sym} 22770 -26410 0 0 {name=p22281 lab=_51381_/Y }
C {devices/lab_pin.sym} 22950 -26430 0 1 {name=p22282 lab=_65337_/B }
C {sky130_stdcells/dfxtp_4.sym} 22860 -26420 0 0 {name=X_86021_ }
C {devices/lab_pin.sym} 22800 -26300 0 0 {name=p22283 lab=_52400_/X }
C {devices/lab_pin.sym} 22800 -26260 0 0 {name=p22284 lab=_50716_/B }
C {devices/lab_pin.sym} 22920 -26280 0 1 {name=p22285 lab=_52413_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -26280 0 0 {name=X_52413_ }
C {devices/lab_pin.sym} 22770 -26150 0 0 {name=p22286 lab=_83227_/CLK }
C {devices/lab_pin.sym} 22770 -26130 0 0 {name=p22287 lab=_72566_/Y }
C {devices/lab_pin.sym} 22950 -26150 0 1 {name=p22288 lab=_79427_/B }
C {sky130_stdcells/dfxtp_4.sym} 22860 -26140 0 0 {name=X_83233_ }
C {devices/lab_pin.sym} 22820 -26010 0 0 {name=p22289 lab=_73163_/A }
C {devices/lab_pin.sym} 22900 -26010 0 1 {name=p22290 lab=_56181_/X }
C {sky130_stdcells/buf_2.sym} 22860 -26010 0 0 {name=X_56181_ }
C {devices/lab_pin.sym} 22820 -25890 0 0 {name=p22291 lab=_80467_/A }
C {devices/lab_pin.sym} 22900 -25890 0 1 {name=p22292 lab=_80445_/Y }
C {sky130_stdcells/inv_2.sym} 22860 -25890 0 0 {name=X_80445_ }
C {devices/lab_pin.sym} 22820 -25770 0 0 {name=p22293 lab=_67388_/X }
C {devices/lab_pin.sym} 22900 -25770 0 1 {name=p22294 lab=_68168_/A }
C {sky130_stdcells/buf_2.sym} 22860 -25770 0 0 {name=X_68167_ }
C {devices/lab_pin.sym} 22800 -25680 0 0 {name=p22295 lab=_53397_/A }
C {devices/lab_pin.sym} 22800 -25640 0 0 {name=p22296 lab=_53388_/B }
C {devices/lab_pin.sym} 22800 -25600 0 0 {name=p22297 lab=_53388_/C }
C {devices/lab_pin.sym} 22800 -25560 0 0 {name=p22298 lab=_52879_/D }
C {devices/lab_pin.sym} 22920 -25620 0 1 {name=p22299 lab=_53393_/X }
C {sky130_stdcells/and4_4.sym} 22860 -25620 0 0 {name=X_53393_ }
C {devices/lab_pin.sym} 22780 -25490 0 0 {name=p22300 lab=_65376_/X }
C {devices/lab_pin.sym} 22780 -25450 0 0 {name=p22301 lab=_65378_/X }
C {devices/lab_pin.sym} 22780 -25410 0 0 {name=p22302 lab=_64574_/X }
C {devices/lab_pin.sym} 22940 -25450 0 1 {name=p22303 lab=_65379_/X }
C {sky130_stdcells/a21o_4.sym} 22860 -25450 0 0 {name=X_65379_ }
C {devices/lab_pin.sym} 22780 -25340 0 0 {name=p22304 lab=_85035_/Q }
C {devices/lab_pin.sym} 22780 -25300 0 0 {name=p22305 lab=_55126_/X }
C {devices/lab_pin.sym} 22780 -25260 0 0 {name=p22306 lab=_55128_/X }
C {devices/lab_pin.sym} 22780 -25220 0 0 {name=p22307 lab=_55131_/X }
C {devices/lab_pin.sym} 22940 -25280 0 1 {name=p22308 lab=_55132_/X }
C {sky130_stdcells/a211o_4.sym} 22860 -25280 0 0 {name=X_55132_ }
C {devices/lab_pin.sym} 22800 -25140 0 0 {name=p22309 lab=_67095_/A }
C {devices/lab_pin.sym} 22800 -25100 0 0 {name=p22310 lab=_67118_/B }
C {devices/lab_pin.sym} 22920 -25120 0 1 {name=p22311 lab=_67118_/X }
C {sky130_stdcells/and2_4.sym} 22860 -25120 0 0 {name=X_67118_ }
C {devices/lab_pin.sym} 22780 -25010 0 0 {name=p22312 lab=_65032_/B }
C {devices/lab_pin.sym} 22780 -24970 0 0 {name=p22313 lab=_52324_/X }
C {devices/lab_pin.sym} 22780 -24930 0 0 {name=p22314 lab=_52343_/Y }
C {devices/lab_pin.sym} 22940 -24970 0 1 {name=p22315 lab=_52344_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -24970 0 0 {name=X_52344_ }
C {devices/lab_pin.sym} 22770 -24830 0 0 {name=p22316 lab=_86570_/CLK }
C {devices/lab_pin.sym} 22770 -24810 0 0 {name=p22317 lab=_73123_/X }
C {devices/lab_pin.sym} 22950 -24830 0 1 {name=p22318 lab=_83164_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -24820 0 0 {name=X_83164_ }
C {devices/lab_pin.sym} 22800 -24700 0 0 {name=p22319 lab=_80370_/X }
C {devices/lab_pin.sym} 22800 -24660 0 0 {name=p22320 lab=_80372_/B }
C {devices/lab_pin.sym} 22920 -24680 0 1 {name=p22321 lab=_80376_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -24680 0 0 {name=X_80376_ }
C {devices/lab_pin.sym} 22780 -24570 0 0 {name=p22322 lab=_66632_/X }
C {devices/lab_pin.sym} 22780 -24530 0 0 {name=p22323 lab=_66635_/X }
C {devices/lab_pin.sym} 22780 -24490 0 0 {name=p22324 lab=_68062_/X }
C {devices/lab_pin.sym} 22940 -24530 0 1 {name=p22325 lab=_68098_/Y }
C {sky130_stdcells/a21oi_4.sym} 22860 -24530 0 0 {name=X_68098_ }
C {devices/lab_pin.sym} 22770 -24390 0 0 {name=p22326 lab=_82104_/CLK }
C {devices/lab_pin.sym} 22770 -24370 0 0 {name=p22327 lab=_82115_/D }
C {devices/lab_pin.sym} 22950 -24390 0 1 {name=p22328 lab=_82103_/D }
C {sky130_stdcells/dfxtp_4.sym} 22860 -24380 0 0 {name=X_82115_ }
C {devices/lab_pin.sym} 22800 -24260 0 0 {name=p22329 lab=_55054_/A }
C {devices/lab_pin.sym} 22800 -24220 0 0 {name=p22330 lab=_54898_/B }
C {devices/lab_pin.sym} 22920 -24240 0 1 {name=p22331 lab=_55063_/Y }
C {sky130_stdcells/nand2_4.sym} 22860 -24240 0 0 {name=X_55063_ }
C {devices/lab_pin.sym} 22800 -24130 0 0 {name=p22332 lab=_59938_/Y }
C {devices/lab_pin.sym} 22800 -24090 0 0 {name=p22333 lab=_59910_/X }
C {devices/lab_pin.sym} 22800 -24050 0 0 {name=p22334 lab=_62463_/A }
C {devices/lab_pin.sym} 22920 -24090 0 1 {name=p22335 lab=_59951_/B }
C {sky130_stdcells/nand3_4.sym} 22860 -24090 0 0 {name=X_59940_ }
C {devices/lab_pin.sym} 22800 -23960 0 0 {name=p22336 lab=_67023_/A }
C {devices/lab_pin.sym} 22800 -23920 0 0 {name=p22337 lab=_67049_/B }
C {devices/lab_pin.sym} 22920 -23940 0 1 {name=p22338 lab=_67049_/X }
C {sky130_stdcells/and2_4.sym} 22860 -23940 0 0 {name=X_67049_ }
C {devices/lab_pin.sym} 22800 -23820 0 0 {name=p22339 lab=_52295_/A }
C {devices/lab_pin.sym} 22800 -23780 0 0 {name=p22340 lab=_52275_/B }
C {devices/lab_pin.sym} 22920 -23800 0 1 {name=p22341 lab=_52275_/X }
C {sky130_stdcells/and2_4.sym} 22860 -23800 0 0 {name=X_52275_ }
C {devices/lab_pin.sym} 22770 -23670 0 0 {name=p22342 lab=_87150_/CLK }
C {devices/lab_pin.sym} 22770 -23650 0 0 {name=p22343 lab=_42221_/X }
C {devices/lab_pin.sym} 22950 -23670 0 1 {name=p22344 lab=_87972_/Q }
C {sky130_stdcells/dfxtp_4.sym} 22860 -23660 0 0 {name=X_87972_ }
C {devices/lab_pin.sym} 22770 -23530 0 0 {name=p22345 lab=_83095_/CLK }
C {devices/lab_pin.sym} 22770 -23510 0 0 {name=p22346 lab=_74333_/X }
C {devices/lab_pin.sym} 22950 -23530 0 1 {name=p22347 lab=_70318_/A }
C {sky130_stdcells/dfxtp_4.sym} 22860 -23520 0 0 {name=X_83095_ }
C {devices/lab_pin.sym} 22780 -23410 0 0 {name=p22348 lab=_85522_/Q }
C {devices/lab_pin.sym} 22780 -23370 0 0 {name=p22349 lab=_53940_/X }
C {devices/lab_pin.sym} 22780 -23330 0 0 {name=p22350 lab=_54013_/Y }
C {devices/lab_pin.sym} 22940 -23370 0 1 {name=p22351 lab=_54014_/Y }
C {sky130_stdcells/o21ai_4.sym} 22860 -23370 0 0 {name=X_54014_ }
C {devices/lab_pin.sym} 22780 -23250 0 0 {name=p22352 lab=_51223_/Y }
C {devices/lab_pin.sym} 22780 -23210 0 0 {name=p22353 lab=_51201_/X }
C {devices/lab_pin.sym} 22780 -23170 0 0 {name=p22354 lab=_51225_/X }
C {devices/lab_pin.sym} 22940 -23210 0 1 {name=p22355 lab=_86051_/D }
C {sky130_stdcells/a21oi_4.sym} 22860 -23210 0 0 {name=X_51226_ }
C {devices/lab_pin.sym} 22780 -23090 0 0 {name=p22356 lab=_68890_/X }
