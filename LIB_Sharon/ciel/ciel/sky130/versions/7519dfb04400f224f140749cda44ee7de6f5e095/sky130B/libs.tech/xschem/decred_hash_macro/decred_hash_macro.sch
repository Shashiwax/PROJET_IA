C {sky130_stdcells/clkbuf_1.sym} 9060 -2590 0 0 {name=Xclkbuf_10_253_0_CLK }
C {devices/lab_pin.sym} 9020 -2470 0 0 {name=p9087 lab=_50599_/X }
C {devices/lab_pin.sym} 9100 -2470 0 1 {name=p9088 lab=_71994_/B }
C {sky130_stdcells/buf_2.sym} 9060 -2470 0 0 {name=X_50600_ }
C {devices/lab_pin.sym} 8970 -2350 0 0 {name=p9089 lab=_84064_/CLK }
C {devices/lab_pin.sym} 8970 -2330 0 0 {name=p9090 lab=_81452_/Q }
C {devices/lab_pin.sym} 9150 -2350 0 1 {name=p9091 lab=_81420_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -2340 0 0 {name=X_81420_ }
C {devices/lab_pin.sym} 9020 -2210 0 0 {name=p9092 lab=_68660_/X }
C {devices/lab_pin.sym} 9100 -2210 0 1 {name=p9093 lab=_69142_/X }
C {sky130_stdcells/buf_2.sym} 9060 -2210 0 0 {name=X_69142_ }
C {devices/lab_pin.sym} 8980 -2120 0 0 {name=p9094 lab=_66117_/X }
C {devices/lab_pin.sym} 8980 -2080 0 0 {name=p9095 lab=_84962_/Q }
C {devices/lab_pin.sym} 8980 -2040 0 0 {name=p9096 lab=_66118_/X }
C {devices/lab_pin.sym} 8980 -2000 0 0 {name=p9097 lab=_66353_/X }
C {devices/lab_pin.sym} 9140 -2060 0 1 {name=p9098 lab=_66354_/X }
C {sky130_stdcells/a211o_4.sym} 9060 -2060 0 0 {name=X_66354_ }
C {devices/lab_pin.sym} 9020 -1910 0 0 {name=p9099 lab=clkbuf_9_441_0_CLK/X }
C {devices/lab_pin.sym} 9100 -1910 0 1 {name=p9100 lab=_85516_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9060 -1910 0 0 {name=Xclkbuf_10_883_0_CLK }
C {devices/lab_pin.sym} 9000 -1820 0 0 {name=p9101 lab=_51580_/A }
C {devices/lab_pin.sym} 9000 -1780 0 0 {name=p9102 lab=_51580_/B }
C {devices/lab_pin.sym} 9000 -1740 0 0 {name=p9103 lab=_51603_/C }
C {devices/lab_pin.sym} 9000 -1700 0 0 {name=p9104 lab=_53107_/D }
C {devices/lab_pin.sym} 9120 -1760 0 1 {name=p9105 lab=_51580_/X }
C {sky130_stdcells/and4_4.sym} 9060 -1760 0 0 {name=X_51580_ }
C {devices/lab_pin.sym} 8980 -1650 0 0 {name=p9106 lab=_63556_/X }
C {devices/lab_pin.sym} 8980 -1610 0 0 {name=p9107 lab=_63557_/X }
C {devices/lab_pin.sym} 8980 -1570 0 0 {name=p9108 lab=_63560_/X }
C {devices/lab_pin.sym} 8980 -1530 0 0 {name=p9109 lab=_63563_/X }
C {devices/lab_pin.sym} 8980 -1490 0 0 {name=p9110 lab=_63565_/Y }
C {devices/lab_pin.sym} 9140 -1570 0 1 {name=p9111 lab=_63566_/Y }
C {sky130_stdcells/o41ai_4.sym} 9060 -1570 0 0 {name=X_63566_ }
C {devices/lab_pin.sym} 9000 -1430 0 0 {name=p9112 lab=_60682_/A }
C {devices/lab_pin.sym} 9000 -1390 0 0 {name=p9113 lab=_63540_/A }
C {devices/lab_pin.sym} 9000 -1350 0 0 {name=p9114 lab=_60660_/A }
C {devices/lab_pin.sym} 9120 -1390 0 1 {name=p9115 lab=_60778_/Y }
C {sky130_stdcells/nand3_4.sym} 9060 -1390 0 0 {name=X_60778_ }
C {devices/lab_pin.sym} 9020 -1250 0 0 {name=p9116 lab=clkbuf_9_17_0_CLK/X }
C {devices/lab_pin.sym} 9100 -1250 0 1 {name=p9117 lab=_85050_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9060 -1250 0 0 {name=Xclkbuf_10_35_0_CLK }
C {devices/lab_pin.sym} 8980 -1150 0 0 {name=p9118 lab=_65299_/X }
C {devices/lab_pin.sym} 8980 -1110 0 0 {name=p9119 lab=_65303_/X }
C {devices/lab_pin.sym} 8980 -1070 0 0 {name=p9120 lab=_65304_/X }
C {devices/lab_pin.sym} 9140 -1110 0 1 {name=p9121 lab=_65305_/X }
C {sky130_stdcells/a21o_4.sym} 9060 -1110 0 0 {name=X_65305_ }
C {devices/lab_pin.sym} 9000 -990 0 0 {name=p9122 lab=_48849_/A }
C {devices/lab_pin.sym} 9000 -950 0 0 {name=p9123 lab=_50552_/B }
C {devices/lab_pin.sym} 9000 -910 0 0 {name=p9124 lab=_50526_/C }
C {devices/lab_pin.sym} 9120 -950 0 1 {name=p9125 lab=_50531_/X }
C {sky130_stdcells/and3_4.sym} 9060 -950 0 0 {name=X_50531_ }
C {devices/lab_pin.sym} 9020 -810 0 0 {name=p9126 lab=_62055_/B }
C {devices/lab_pin.sym} 9100 -810 0 1 {name=p9127 lab=_62517_/Y }
C {sky130_stdcells/inv_2.sym} 9060 -810 0 0 {name=X_62517_ }
C {devices/lab_pin.sym} 8970 -690 0 0 {name=p9128 lab=_81351_/CLK }
C {devices/lab_pin.sym} 8970 -670 0 0 {name=p9129 lab=_81351_/D }
C {devices/lab_pin.sym} 9150 -690 0 1 {name=p9130 lab=_76226_/A }
C {sky130_stdcells/dfxtp_4.sym} 9060 -680 0 0 {name=X_81351_ }
C {devices/lab_pin.sym} 9920 -42160 0 0 {name=p9131 lab=_69073_/A }
C {devices/lab_pin.sym} 9920 -42120 0 0 {name=p9132 lab=_88342_/Q }
C {devices/lab_pin.sym} 10040 -42140 0 1 {name=p9133 lab=_69073_/X }
C {sky130_stdcells/and2_4.sym} 9980 -42140 0 0 {name=X_69073_ }
C {devices/lab_pin.sym} 9920 -42020 0 0 {name=p9134 lab=_65934_/X }
C {devices/lab_pin.sym} 9920 -41980 0 0 {name=p9135 lab=_66285_/B }
C {devices/lab_pin.sym} 10040 -42000 0 1 {name=p9136 lab=_66285_/X }
C {sky130_stdcells/and2_4.sym} 9980 -42000 0 0 {name=X_66285_ }
C {devices/lab_pin.sym} 9940 -41870 0 0 {name=p9137 lab=clkbuf_9_375_0_CLK/A }
C {devices/lab_pin.sym} 10020 -41870 0 1 {name=p9138 lab=clkbuf_9_374_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 9980 -41870 0 0 {name=Xclkbuf_9_374_0_CLK }
C {devices/lab_pin.sym} 9940 -41750 0 0 {name=p9139 lab=_63436_/A }
C {devices/lab_pin.sym} 10020 -41750 0 1 {name=p9140 lab=_63497_/X }
C {sky130_stdcells/buf_2.sym} 9980 -41750 0 0 {name=X_63497_ }
C {devices/lab_pin.sym} 9920 -41640 0 0 {name=p9141 lab=_80299_/Y }
C {devices/lab_pin.sym} 9920 -41600 0 0 {name=p9142 lab=_80302_/B }
C {devices/lab_pin.sym} 10040 -41620 0 1 {name=p9143 lab=_80303_/B }
C {sky130_stdcells/nand2_4.sym} 9980 -41620 0 0 {name=X_80302_ }
C {devices/lab_pin.sym} 9940 -41490 0 0 {name=p9144 lab=_69797_/A }
C {devices/lab_pin.sym} 10020 -41490 0 1 {name=p9145 lab=_68024_/X }
C {sky130_stdcells/buf_2.sym} 9980 -41490 0 0 {name=X_68024_ }
C {devices/lab_pin.sym} 9900 -41390 0 0 {name=p9146 lab=_53247_/Y }
C {devices/lab_pin.sym} 9900 -41350 0 0 {name=p9147 lab=_53242_/X }
C {devices/lab_pin.sym} 9900 -41310 0 0 {name=p9148 lab=_53249_/X }
C {devices/lab_pin.sym} 10060 -41350 0 1 {name=p9149 lab=_85669_/D }
C {sky130_stdcells/a21oi_4.sym} 9980 -41350 0 0 {name=X_53250_ }
C {devices/lab_pin.sym} 9920 -41220 0 0 {name=p9150 lab=_65159_/A }
C {devices/lab_pin.sym} 9920 -41180 0 0 {name=p9151 lab=_86025_/Q }
C {devices/lab_pin.sym} 10040 -41200 0 1 {name=p9152 lab=_65236_/X }
C {sky130_stdcells/and2_4.sym} 9980 -41200 0 0 {name=X_65236_ }
C {devices/lab_pin.sym} 9890 -41070 0 0 {name=p9153 lab=_81461_/CLK }
C {devices/lab_pin.sym} 9890 -41050 0 0 {name=p9154 lab=_84070_/D }
C {devices/lab_pin.sym} 10070 -41070 0 1 {name=p9155 lab=_81502_/D }
C {sky130_stdcells/dfxtp_4.sym} 9980 -41060 0 0 {name=X_84070_ }
C {devices/lab_pin.sym} 9920 -40950 0 0 {name=p9156 lab=_52166_/A }
C {devices/lab_pin.sym} 9920 -40910 0 0 {name=p9157 lab=_50492_/B }
C {devices/lab_pin.sym} 9920 -40870 0 0 {name=p9158 lab=_50462_/C }
C {devices/lab_pin.sym} 10040 -40910 0 1 {name=p9159 lab=_50462_/X }
C {sky130_stdcells/and3_4.sym} 9980 -40910 0 0 {name=X_50462_ }
C {devices/lab_pin.sym} 9920 -40790 0 0 {name=p9160 lab=_62448_/A }
C {devices/lab_pin.sym} 9920 -40750 0 0 {name=p9161 lab=_63557_/B }
C {devices/lab_pin.sym} 9920 -40710 0 0 {name=p9162 lab=_62491_/C }
C {devices/lab_pin.sym} 10040 -40750 0 1 {name=p9163 lab=_62451_/C }
C {sky130_stdcells/nand3_4.sym} 9980 -40750 0 0 {name=X_62448_ }
C {devices/lab_pin.sym} 9890 -40610 0 0 {name=p9164 lab=_81282_/CLK }
C {devices/lab_pin.sym} 9890 -40590 0 0 {name=p9165 lab=_76970_/X }
C {devices/lab_pin.sym} 10070 -40610 0 1 {name=p9166 lab=_81250_/D }
C {sky130_stdcells/dfxtp_4.sym} 9980 -40600 0 0 {name=X_81282_ }
C {devices/lab_pin.sym} 9940 -40470 0 0 {name=p9167 lab=clkbuf_9_134_0_CLK/X }
C {devices/lab_pin.sym} 10020 -40470 0 1 {name=p9168 lab=_84823_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9980 -40470 0 0 {name=Xclkbuf_10_268_0_CLK }
C {devices/lab_pin.sym} 9920 -40360 0 0 {name=p9169 lab=_52210_/A }
C {devices/lab_pin.sym} 9920 -40320 0 0 {name=p9170 lab=_48816_/B }
C {devices/lab_pin.sym} 10040 -40340 0 1 {name=p9171 lab=_52201_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -40340 0 0 {name=X_52201_ }
C {devices/lab_pin.sym} 9890 -40210 0 0 {name=p9172 lab=_85221_/CLK }
C {devices/lab_pin.sym} 9890 -40190 0 0 {name=p9173 lab=_83021_/D }
C {devices/lab_pin.sym} 10070 -40210 0 1 {name=p9174 lab=_45215_/A }
C {sky130_stdcells/dfxtp_4.sym} 9980 -40200 0 0 {name=X_83021_ }
C {devices/lab_pin.sym} 9920 -40080 0 0 {name=p9175 lab=_80233_/A }
C {devices/lab_pin.sym} 9920 -40040 0 0 {name=p9176 lab=_80232_/X }
C {devices/lab_pin.sym} 10040 -40060 0 1 {name=p9177 lab=_80233_/Y }
C {sky130_stdcells/xnor2_4.sym} 9980 -40060 0 0 {name=X_80233_ }
C {devices/lab_pin.sym} 9940 -39930 0 0 {name=p9178 lab=clkbuf_9_449_0_CLK/X }
C {devices/lab_pin.sym} 10020 -39930 0 1 {name=p9179 lab=_86998_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9980 -39930 0 0 {name=Xclkbuf_10_898_0_CLK }
C {devices/lab_pin.sym} 9920 -39840 0 0 {name=p9180 lab=_53181_/A }
C {devices/lab_pin.sym} 9920 -39800 0 0 {name=p9181 lab=_53181_/B }
C {devices/lab_pin.sym} 9920 -39760 0 0 {name=p9182 lab=_53169_/X }
C {devices/lab_pin.sym} 9920 -39720 0 0 {name=p9183 lab=_53181_/D }
C {devices/lab_pin.sym} 10040 -39780 0 1 {name=p9184 lab=_53181_/X }
C {sky130_stdcells/and4_4.sym} 9980 -39780 0 0 {name=X_53181_ }
C {devices/lab_pin.sym} 9900 -39650 0 0 {name=p9185 lab=_64915_/X }
C {devices/lab_pin.sym} 9900 -39610 0 0 {name=p9186 lab=_65154_/Y }
C {devices/lab_pin.sym} 9900 -39570 0 0 {name=p9187 lab=_65166_/Y }
C {devices/lab_pin.sym} 10060 -39610 0 1 {name=p9188 lab=_65167_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -39610 0 0 {name=X_65167_ }
C {devices/lab_pin.sym} 9920 -39480 0 0 {name=p9189 lab=_50398_/A }
C {devices/lab_pin.sym} 9920 -39440 0 0 {name=p9190 lab=_48358_/X }
C {devices/lab_pin.sym} 10040 -39460 0 1 {name=p9191 lab=_50393_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -39460 0 0 {name=X_50393_ }
C {devices/lab_pin.sym} 9920 -39360 0 0 {name=p9192 lab=_62337_/A }
C {devices/lab_pin.sym} 9920 -39320 0 0 {name=p9193 lab=_61909_/X }
C {devices/lab_pin.sym} 9920 -39280 0 0 {name=p9194 lab=_62364_/X }
C {devices/lab_pin.sym} 9920 -39240 0 0 {name=p9195 lab=_62280_/D }
C {devices/lab_pin.sym} 10040 -39300 0 1 {name=p9196 lab=_62379_/X }
C {sky130_stdcells/and4_4.sym} 9980 -39300 0 0 {name=X_62379_ }
C {devices/lab_pin.sym} 9920 -39160 0 0 {name=p9197 lab=_52127_/X }
C {devices/lab_pin.sym} 9920 -39120 0 0 {name=p9198 lab=_48435_/B }
C {devices/lab_pin.sym} 10040 -39140 0 1 {name=p9199 lab=_52132_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -39140 0 0 {name=X_52132_ }
C {devices/lab_pin.sym} 9920 -39040 0 0 {name=p9200 lab=_61630_/A }
C {devices/lab_pin.sym} 9920 -39000 0 0 {name=p9201 lab=_64118_/B }
C {devices/lab_pin.sym} 9920 -38960 0 0 {name=p9202 lab=_64155_/C }
C {devices/lab_pin.sym} 9920 -38920 0 0 {name=p9203 lab=_64142_/D }
C {devices/lab_pin.sym} 10040 -38980 0 1 {name=p9204 lab=_64118_/Y }
C {sky130_stdcells/nand4_4.sym} 9980 -38980 0 0 {name=X_64118_ }
C {devices/lab_pin.sym} 9940 -38830 0 0 {name=p9205 lab=clkbuf_9_389_0_CLK/A }
C {devices/lab_pin.sym} 10020 -38830 0 1 {name=p9206 lab=clkbuf_9_389_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 9980 -38830 0 0 {name=Xclkbuf_9_389_0_CLK }
C {devices/lab_pin.sym} 9900 -38730 0 0 {name=p9207 lab=_80154_/A }
C {devices/lab_pin.sym} 9900 -38690 0 0 {name=p9208 lab=_80153_/X }
C {devices/lab_pin.sym} 9900 -38650 0 0 {name=p9209 lab=_80163_/Y }
C {devices/lab_pin.sym} 10060 -38690 0 1 {name=p9210 lab=_80164_/Y }
C {sky130_stdcells/a21boi_4.sym} 9980 -38690 0 0 {name=X_80164_ }
C {devices/lab_pin.sym} 9900 -38570 0 0 {name=p9211 lab=_65095_/X }
C {devices/lab_pin.sym} 9900 -38530 0 0 {name=p9212 lab=_65097_/X }
C {devices/lab_pin.sym} 9900 -38490 0 0 {name=p9213 lab=_64851_/X }
C {devices/lab_pin.sym} 10060 -38530 0 1 {name=p9214 lab=_65102_/A }
C {sky130_stdcells/a21o_4.sym} 9980 -38530 0 0 {name=X_65098_ }
C {devices/lab_pin.sym} 9900 -38410 0 0 {name=p9215 lab=_69557_/X }
C {devices/lab_pin.sym} 9900 -38370 0 0 {name=p9216 lab=_69559_/X }
C {devices/lab_pin.sym} 9900 -38330 0 0 {name=p9217 lab=_69939_/X }
C {devices/lab_pin.sym} 10060 -38370 0 1 {name=p9218 lab=_69975_/Y }
C {sky130_stdcells/a21oi_4.sym} 9980 -38370 0 0 {name=X_69975_ }
C {devices/lab_pin.sym} 9900 -38270 0 0 {name=p9219 lab=_45886_/X }
C {devices/lab_pin.sym} 9900 -38230 0 0 {name=p9220 lab=_45890_/X }
C {devices/lab_pin.sym} 9900 -38190 0 0 {name=p9221 lab=_56935_/X }
C {devices/lab_pin.sym} 9900 -38150 0 0 {name=p9222 lab=_56939_/X }
C {devices/lab_pin.sym} 9900 -38120 0 0 {name=p9223 lab=_44184_/A }
C {devices/lab_pin.sym} 10060 -38190 0 1 {name=p9224 lab=_56940_/Y }
C {sky130_stdcells/a41oi_4.sym} 9980 -38190 0 0 {name=X_56940_ }
C {devices/lab_pin.sym} 9900 -38050 0 0 {name=p9225 lab=_52061_/Y }
C {devices/lab_pin.sym} 9900 -38010 0 0 {name=p9226 lab=_52049_/X }
C {devices/lab_pin.sym} 9900 -37970 0 0 {name=p9227 lab=_52062_/X }
C {devices/lab_pin.sym} 10060 -38010 0 1 {name=p9228 lab=_85896_/D }
C {sky130_stdcells/a21oi_4.sym} 9980 -38010 0 0 {name=X_52063_ }
C {devices/lab_pin.sym} 9900 -37890 0 0 {name=p9229 lab=_68923_/X }
C {devices/lab_pin.sym} 9900 -37850 0 0 {name=p9230 lab=_68925_/X }
C {devices/lab_pin.sym} 9900 -37810 0 0 {name=p9231 lab=_68878_/X }
C {devices/lab_pin.sym} 10060 -37850 0 1 {name=p9232 lab=_68926_/Y }
C {sky130_stdcells/a21oi_4.sym} 9980 -37850 0 0 {name=X_68926_ }
C {devices/lab_pin.sym} 9940 -37710 0 0 {name=p9233 lab=_60864_/X }
C {devices/lab_pin.sym} 10020 -37710 0 1 {name=p9234 lab=_64095_/D }
C {sky130_stdcells/buf_2.sym} 9980 -37710 0 0 {name=X_64049_ }
C {devices/lab_pin.sym} 9890 -37590 0 0 {name=p9235 lab=_87260_/CLK }
C {devices/lab_pin.sym} 9890 -37570 0 0 {name=p9236 lab=_42706_/X }
C {devices/lab_pin.sym} 10070 -37590 0 1 {name=p9237 lab=_87760_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -37580 0 0 {name=X_87760_ }
C {devices/lab_pin.sym} 9890 -37450 0 0 {name=p9238 lab=_83544_/CLK }
C {devices/lab_pin.sym} 9890 -37430 0 0 {name=p9239 lab=_84972_/D }
C {devices/lab_pin.sym} 10070 -37450 0 1 {name=p9240 lab=_84972_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -37440 0 0 {name=X_84972_ }
C {devices/lab_pin.sym} 9940 -37310 0 0 {name=p9241 lab=clkbuf_9_410_0_CLK/X }
C {devices/lab_pin.sym} 10020 -37310 0 1 {name=p9242 lab=_82933_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9980 -37310 0 0 {name=Xclkbuf_10_821_0_CLK }
C {devices/lab_pin.sym} 9900 -37220 0 0 {name=p9243 lab=_80071_/A }
C {devices/lab_pin.sym} 9900 -37180 0 0 {name=p9244 lab=_80070_/Y }
C {devices/lab_pin.sym} 9900 -37140 0 0 {name=p9245 lab=_80080_/Y }
C {devices/lab_pin.sym} 9900 -37100 0 0 {name=p9246 lab=_80083_/Y }
C {devices/lab_pin.sym} 10060 -37160 0 1 {name=p9247 lab=_80095_/X }
C {sky130_stdcells/o22a_4.sym} 9980 -37160 0 0 {name=X_80095_ }
C {devices/lab_pin.sym} 9920 -37040 0 0 {name=p9248 lab=_51018_/A }
C {devices/lab_pin.sym} 9920 -37000 0 0 {name=p9249 lab=_51029_/B }
C {devices/lab_pin.sym} 9920 -36960 0 0 {name=p9250 lab=_51029_/C }
C {devices/lab_pin.sym} 9920 -36920 0 0 {name=p9251 lab=_52704_/D }
C {devices/lab_pin.sym} 10040 -36980 0 1 {name=p9252 lab=_51014_/X }
C {sky130_stdcells/and4_4.sym} 9980 -36980 0 0 {name=X_51014_ }
C {devices/lab_pin.sym} 9890 -36830 0 0 {name=p9253 lab=_86711_/CLK }
C {devices/lab_pin.sym} 9890 -36810 0 0 {name=p9254 lab=_46718_/Y }
C {devices/lab_pin.sym} 10070 -36830 0 1 {name=p9255 lab=_58688_/A }
C {sky130_stdcells/dfxtp_4.sym} 9980 -36820 0 0 {name=X_86711_ }
C {devices/lab_pin.sym} 9890 -36690 0 0 {name=p9256 lab=_81507_/CLK }
C {devices/lab_pin.sym} 9890 -36670 0 0 {name=p9257 lab=_83923_/D }
C {devices/lab_pin.sym} 10070 -36690 0 1 {name=p9258 lab=_83923_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -36680 0 0 {name=X_83923_ }
C {devices/lab_pin.sym} 9900 -36570 0 0 {name=p9259 lab=_56869_/Y }
C {devices/lab_pin.sym} 9900 -36530 0 0 {name=p9260 lab=_55675_/X }
C {devices/lab_pin.sym} 9900 -36490 0 0 {name=p9261 lab=_56870_/Y }
C {devices/lab_pin.sym} 10060 -36530 0 1 {name=p9262 lab=_56871_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -36530 0 0 {name=X_56871_ }
C {devices/lab_pin.sym} 9900 -36410 0 0 {name=p9263 lab=_83958_/Q }
C {devices/lab_pin.sym} 9900 -36370 0 0 {name=p9264 lab=_68838_/X }
C {devices/lab_pin.sym} 9900 -36330 0 0 {name=p9265 lab=_68856_/X }
C {devices/lab_pin.sym} 10060 -36370 0 1 {name=p9266 lab=_68857_/X }
C {sky130_stdcells/a21bo_4.sym} 9980 -36370 0 0 {name=X_68857_ }
C {devices/lab_pin.sym} 9890 -36230 0 0 {name=p9267 lab=_87950_/CLK }
C {devices/lab_pin.sym} 9890 -36210 0 0 {name=p9268 lab=_42841_/X }
C {devices/lab_pin.sym} 10070 -36230 0 1 {name=p9269 lab=_87691_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -36220 0 0 {name=X_87691_ }
C {devices/lab_pin.sym} 9940 -36090 0 0 {name=p9270 lab=clkbuf_9_313_0_CLK/A }
C {devices/lab_pin.sym} 10020 -36090 0 1 {name=p9271 lab=clkbuf_9_312_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 9980 -36090 0 0 {name=Xclkbuf_9_312_0_CLK }
C {devices/lab_pin.sym} 9940 -35970 0 0 {name=p9272 lab=_58610_/A }
C {devices/lab_pin.sym} 10020 -35970 0 1 {name=p9273 lab=_58610_/X }
C {sky130_stdcells/buf_2.sym} 9980 -35970 0 0 {name=X_58610_ }
C {devices/lab_pin.sym} 9900 -35880 0 0 {name=p9274 lab=_85263_/Q }
C {devices/lab_pin.sym} 9900 -35840 0 0 {name=p9275 lab=_55492_/X }
C {devices/lab_pin.sym} 9900 -35800 0 0 {name=p9276 lab=_44047_/X }
C {devices/lab_pin.sym} 9900 -35760 0 0 {name=p9277 lab=_55821_/X }
C {devices/lab_pin.sym} 10060 -35820 0 1 {name=p9278 lab=_55822_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -35820 0 0 {name=X_55822_ }
C {devices/lab_pin.sym} 9920 -35680 0 0 {name=p9279 lab=_67901_/A }
C {devices/lab_pin.sym} 9920 -35640 0 0 {name=p9280 lab=_67808_/B }
C {devices/lab_pin.sym} 10040 -35660 0 1 {name=p9281 lab=_67808_/X }
C {sky130_stdcells/and2_4.sym} 9980 -35660 0 0 {name=X_67808_ }
C {devices/lab_pin.sym} 9890 -35530 0 0 {name=p9282 lab=_86640_/CLK }
C {devices/lab_pin.sym} 9890 -35510 0 0 {name=p9283 lab=_86642_/D }
C {devices/lab_pin.sym} 10070 -35530 0 1 {name=p9284 lab=_86642_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -35520 0 0 {name=X_86642_ }
C {devices/lab_pin.sym} 9940 -35390 0 0 {name=p9285 lab=_61948_/A }
C {devices/lab_pin.sym} 10020 -35390 0 1 {name=p9286 lab=_59591_/A }
C {sky130_stdcells/buf_2.sym} 9980 -35390 0 0 {name=X_59590_ }
C {devices/lab_pin.sym} 9890 -35270 0 0 {name=p9287 lab=_82536_/CLK }
C {devices/lab_pin.sym} 9890 -35250 0 0 {name=p9288 lab=_83854_/D }
C {devices/lab_pin.sym} 10070 -35270 0 1 {name=p9289 lab=_83854_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -35260 0 0 {name=X_83854_ }
C {devices/lab_pin.sym} 9940 -35130 0 0 {name=p9290 lab=clkbuf_9_103_0_CLK/X }
C {devices/lab_pin.sym} 10020 -35130 0 1 {name=p9291 lab=_80697_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9980 -35130 0 0 {name=Xclkbuf_10_206_0_CLK }
C {devices/lab_pin.sym} 9900 -35040 0 0 {name=p9292 lab=_68777_/Y }
C {devices/lab_pin.sym} 9900 -35000 0 0 {name=p9293 lab=_68358_/X }
C {devices/lab_pin.sym} 9900 -34960 0 0 {name=p9294 lab=_68649_/X }
C {devices/lab_pin.sym} 9900 -34920 0 0 {name=p9295 lab=_68787_/Y }
C {devices/lab_pin.sym} 10060 -34980 0 1 {name=p9296 lab=_68788_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -34980 0 0 {name=X_68788_ }
C {devices/lab_pin.sym} 9920 -34840 0 0 {name=p9297 lab=_58541_/A }
C {devices/lab_pin.sym} 9920 -34800 0 0 {name=p9298 lab=_58557_/B }
C {devices/lab_pin.sym} 10040 -34820 0 1 {name=p9299 lab=_58541_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -34820 0 0 {name=X_58541_ }
C {devices/lab_pin.sym} 9890 -34690 0 0 {name=p9300 lab=_82529_/CLK }
C {devices/lab_pin.sym} 9890 -34670 0 0 {name=p9301 lab=_82837_/Q }
C {devices/lab_pin.sym} 10070 -34690 0 1 {name=p9302 lab=_82805_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -34680 0 0 {name=X_82805_ }
C {devices/lab_pin.sym} 9940 -34550 0 0 {name=p9303 lab=clkbuf_9_418_0_CLK/X }
C {devices/lab_pin.sym} 10020 -34550 0 1 {name=p9304 lab=_85346_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9980 -34550 0 0 {name=Xclkbuf_10_836_0_CLK }
C {devices/lab_pin.sym} 9940 -34430 0 0 {name=p9305 lab=_66554_/X }
C {devices/lab_pin.sym} 10020 -34430 0 1 {name=p9306 lab=_67739_/X }
C {sky130_stdcells/buf_2.sym} 9980 -34430 0 0 {name=X_67739_ }
C {devices/lab_pin.sym} 9920 -34320 0 0 {name=p9307 lab=_55192_/A }
C {devices/lab_pin.sym} 9920 -34280 0 0 {name=p9308 lab=_56145_/C }
C {devices/lab_pin.sym} 10040 -34300 0 1 {name=p9309 lab=_55753_/X }
C {sky130_stdcells/and2_4.sym} 9980 -34300 0 0 {name=X_55753_ }
C {devices/lab_pin.sym} 9890 -34170 0 0 {name=p9310 lab=_86530_/CLK }
C {devices/lab_pin.sym} 9890 -34150 0 0 {name=p9311 lab=_86573_/D }
C {devices/lab_pin.sym} 10070 -34170 0 1 {name=p9312 lab=_66198_/B }
C {sky130_stdcells/dfxtp_4.sym} 9980 -34160 0 0 {name=X_86573_ }
C {devices/lab_pin.sym} 9920 -34040 0 0 {name=p9313 lab=_52979_/A }
C {devices/lab_pin.sym} 9920 -34000 0 0 {name=p9314 lab=_52965_/B }
C {devices/lab_pin.sym} 10040 -34020 0 1 {name=p9315 lab=_52965_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -34020 0 0 {name=X_52965_ }
C {devices/lab_pin.sym} 9890 -33890 0 0 {name=p9316 lab=_85953_/CLK }
C {devices/lab_pin.sym} 9890 -33870 0 0 {name=p9317 lab=_70372_/Y }
C {devices/lab_pin.sym} 10070 -33890 0 1 {name=p9318 lab=_83785_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -33880 0 0 {name=X_83785_ }
C {devices/lab_pin.sym} 9890 -33750 0 0 {name=p9319 lab=_82610_/CLK }
C {devices/lab_pin.sym} 9890 -33730 0 0 {name=p9320 lab=_65348_/C }
C {devices/lab_pin.sym} 10070 -33750 0 1 {name=p9321 lab=_80997_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -33740 0 0 {name=X_80997_ }
C {devices/lab_pin.sym} 9890 -33610 0 0 {name=p9322 lab=_88326_/CLK }
C {devices/lab_pin.sym} 9890 -33590 0 0 {name=p9323 lab=_40911_/Y }
C {devices/lab_pin.sym} 10070 -33610 0 1 {name=p9324 lab=_69923_/B }
C {sky130_stdcells/dfxtp_4.sym} 9980 -33600 0 0 {name=X_88312_ }
C {devices/lab_pin.sym} 9940 -33470 0 0 {name=p9325 lab=_54594_/X }
C {devices/lab_pin.sym} 10020 -33470 0 1 {name=p9326 lab=_54718_/A }
C {sky130_stdcells/buf_2.sym} 9980 -33470 0 0 {name=X_54704_ }
C {devices/lab_pin.sym} 9890 -33350 0 0 {name=p9327 lab=_85815_/CLK }
C {devices/lab_pin.sym} 9890 -33330 0 0 {name=p9328 lab=_54008_/Y }
C {devices/lab_pin.sym} 10070 -33350 0 1 {name=p9329 lab=_85524_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -33340 0 0 {name=X_85524_ }
C {devices/lab_pin.sym} 9920 -33220 0 0 {name=p9330 lab=_51902_/A }
C {devices/lab_pin.sym} 9920 -33180 0 0 {name=p9331 lab=_46912_/X }
C {devices/lab_pin.sym} 10040 -33200 0 1 {name=p9332 lab=_51916_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -33200 0 0 {name=X_51916_ }
C {devices/lab_pin.sym} 9900 -33090 0 0 {name=p9333 lab=_53122_/B }
C {devices/lab_pin.sym} 9900 -33050 0 0 {name=p9334 lab=_70738_/X }
C {devices/lab_pin.sym} 9900 -33010 0 0 {name=p9335 lab=_70749_/Y }
C {devices/lab_pin.sym} 10060 -33050 0 1 {name=p9336 lab=_70750_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -33050 0 0 {name=X_70750_ }
C {devices/lab_pin.sym} 9940 -32910 0 0 {name=p9337 lab=_83416_/Q }
C {devices/lab_pin.sym} 10020 -32910 0 1 {name=p9338 lab=_58472_/Y }
C {sky130_stdcells/inv_2.sym} 9980 -32910 0 0 {name=X_58472_ }
C {devices/lab_pin.sym} 9890 -32790 0 0 {name=p9339 lab=_82147_/CLK }
C {devices/lab_pin.sym} 9890 -32770 0 0 {name=p9340 lab=_84120_/Q }
C {devices/lab_pin.sym} 10070 -32790 0 1 {name=p9341 lab=_78939_/A }
C {sky130_stdcells/dfxtp_4.sym} 9980 -32780 0 0 {name=X_82736_ }
C {devices/lab_pin.sym} 9940 -32650 0 0 {name=p9342 lab=clkbuf_9_326_0_CLK/A }
C {devices/lab_pin.sym} 10020 -32650 0 1 {name=p9343 lab=clkbuf_9_327_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 9980 -32650 0 0 {name=Xclkbuf_9_327_0_CLK }
C {devices/lab_pin.sym} 9900 -32550 0 0 {name=p9344 lab=_55683_/Y }
C {devices/lab_pin.sym} 9900 -32510 0 0 {name=p9345 lab=_55443_/Y }
C {devices/lab_pin.sym} 9900 -32470 0 0 {name=p9346 lab=_46234_/Y }
C {devices/lab_pin.sym} 10060 -32510 0 1 {name=p9347 lab=_55684_/X }
C {sky130_stdcells/o21a_4.sym} 9980 -32510 0 0 {name=X_55684_ }
C {devices/lab_pin.sym} 9900 -32390 0 0 {name=p9348 lab=_52890_/Y }
C {devices/lab_pin.sym} 9900 -32350 0 0 {name=p9349 lab=_52892_/X }
C {devices/lab_pin.sym} 9900 -32310 0 0 {name=p9350 lab=_52895_/X }
C {devices/lab_pin.sym} 10060 -32350 0 1 {name=p9351 lab=_52896_/Y }
C {sky130_stdcells/a21oi_4.sym} 9980 -32350 0 0 {name=X_52896_ }
C {devices/lab_pin.sym} 9900 -32230 0 0 {name=p9352 lab=_57408_/X }
C {devices/lab_pin.sym} 9900 -32190 0 0 {name=p9353 lab=_57420_/X }
C {devices/lab_pin.sym} 9900 -32150 0 0 {name=p9354 lab=_57422_/Y }
C {devices/lab_pin.sym} 10060 -32190 0 1 {name=p9355 lab=_57423_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -32190 0 0 {name=X_57423_ }
C {devices/lab_pin.sym} 9920 -32060 0 0 {name=p9356 lab=_69302_/A }
C {devices/lab_pin.sym} 9920 -32020 0 0 {name=p9357 lab=_69409_/B }
C {devices/lab_pin.sym} 10040 -32040 0 1 {name=p9358 lab=_69409_/X }
C {sky130_stdcells/and2_4.sym} 9980 -32040 0 0 {name=X_69409_ }
C {devices/lab_pin.sym} 9890 -31910 0 0 {name=p9359 lab=_87416_/CLK }
C {devices/lab_pin.sym} 9890 -31890 0 0 {name=p9360 lab=_88243_/D }
C {devices/lab_pin.sym} 10070 -31910 0 1 {name=p9361 lab=_67338_/B }
C {sky130_stdcells/dfxtp_4.sym} 9980 -31900 0 0 {name=X_88243_ }
C {devices/lab_pin.sym} 9900 -31790 0 0 {name=p9362 lab=_54633_/Y }
C {devices/lab_pin.sym} 9900 -31750 0 0 {name=p9363 lab=_54611_/X }
C {devices/lab_pin.sym} 9900 -31710 0 0 {name=p9364 lab=_54634_/X }
C {devices/lab_pin.sym} 10060 -31750 0 1 {name=p9365 lab=_85406_/D }
C {sky130_stdcells/a21oi_4.sym} 9980 -31750 0 0 {name=X_54635_ }
C {devices/lab_pin.sym} 9890 -31610 0 0 {name=p9366 lab=_85778_/CLK }
C {devices/lab_pin.sym} 9890 -31590 0 0 {name=p9367 lab=_54368_/Y }
C {devices/lab_pin.sym} 10070 -31610 0 1 {name=p9368 lab=_85455_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -31600 0 0 {name=X_85455_ }
C {devices/lab_pin.sym} 9940 -31470 0 0 {name=p9369 lab=_53269_/A }
C {devices/lab_pin.sym} 10020 -31470 0 1 {name=p9370 lab=_51853_/A }
C {sky130_stdcells/buf_2.sym} 9980 -31470 0 0 {name=X_51847_ }
C {devices/lab_pin.sym} 9940 -31350 0 0 {name=p9371 lab=_71883_/A }
C {devices/lab_pin.sym} 10020 -31350 0 1 {name=p9372 lab=_70682_/A }
C {sky130_stdcells/buf_2.sym} 9980 -31350 0 0 {name=X_70681_ }
C {devices/lab_pin.sym} 9890 -31230 0 0 {name=p9373 lab=_82879_/CLK }
C {devices/lab_pin.sym} 9890 -31210 0 0 {name=p9374 lab=_82667_/D }
C {devices/lab_pin.sym} 10070 -31230 0 1 {name=p9375 lab=_82667_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -31220 0 0 {name=X_82667_ }
C {devices/lab_pin.sym} 9900 -31110 0 0 {name=p9376 lab=_41577_/X }
C {devices/lab_pin.sym} 9900 -31070 0 0 {name=p9377 lab=_81158_/Q }
C {devices/lab_pin.sym} 9900 -31030 0 0 {name=p9378 lab=_41599_/X }
C {devices/lab_pin.sym} 10060 -31070 0 1 {name=p9379 lab=_41600_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -31070 0 0 {name=X_41600_ }
C {devices/lab_pin.sym} 9900 -30950 0 0 {name=p9380 lab=_72339_/X }
C {devices/lab_pin.sym} 9900 -30910 0 0 {name=p9381 lab=_85320_/Q }
C {devices/lab_pin.sym} 9900 -30870 0 0 {name=p9382 lab=_72386_/X }
C {devices/lab_pin.sym} 10060 -30910 0 1 {name=p9383 lab=_72420_/X }
C {sky130_stdcells/o21a_4.sym} 9980 -30910 0 0 {name=X_72420_ }
C {devices/lab_pin.sym} 9890 -30770 0 0 {name=p9384 lab=_84420_/CLK }
C {devices/lab_pin.sym} 9890 -30750 0 0 {name=p9385 lab=_84406_/D }
C {devices/lab_pin.sym} 10070 -30770 0 1 {name=p9386 lab=_62498_/C }
C {sky130_stdcells/dfxtp_4.sym} 9980 -30760 0 0 {name=X_84406_ }
C {devices/lab_pin.sym} 9900 -30650 0 0 {name=p9387 lab=_57261_/X }
C {devices/lab_pin.sym} 9900 -30610 0 0 {name=p9388 lab=_57352_/X }
C {devices/lab_pin.sym} 9900 -30570 0 0 {name=p9389 lab=_57353_/Y }
C {devices/lab_pin.sym} 10060 -30610 0 1 {name=p9390 lab=_57354_/Y }
C {sky130_stdcells/a21oi_4.sym} 9980 -30610 0 0 {name=X_57354_ }
C {devices/lab_pin.sym} 9890 -30470 0 0 {name=p9391 lab=_81631_/CLK }
C {devices/lab_pin.sym} 9890 -30450 0 0 {name=p9392 lab=_81618_/D }
C {devices/lab_pin.sym} 10070 -30470 0 1 {name=p9393 lab=_81618_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -30460 0 0 {name=X_81618_ }
C {devices/lab_pin.sym} 9890 -30330 0 0 {name=p9394 lab=_83987_/CLK }
C {devices/lab_pin.sym} 9890 -30310 0 0 {name=p9395 lab=_88174_/D }
C {devices/lab_pin.sym} 10070 -30330 0 1 {name=p9396 lab=_67468_/B }
C {sky130_stdcells/dfxtp_4.sym} 9980 -30320 0 0 {name=X_88174_ }
C {devices/lab_pin.sym} 9940 -30190 0 0 {name=p9397 lab=_42580_/A }
C {devices/lab_pin.sym} 10020 -30190 0 1 {name=p9398 lab=_42580_/X }
C {sky130_stdcells/buf_2.sym} 9980 -30190 0 0 {name=X_42580_ }
C {devices/lab_pin.sym} 9900 -30090 0 0 {name=p9399 lab=_54562_/Y }
C {devices/lab_pin.sym} 9900 -30050 0 0 {name=p9400 lab=_54558_/X }
C {devices/lab_pin.sym} 9900 -30010 0 0 {name=p9401 lab=_54565_/X }
C {devices/lab_pin.sym} 10060 -30050 0 1 {name=p9402 lab=_54566_/Y }
C {sky130_stdcells/a21oi_4.sym} 9980 -30050 0 0 {name=X_54566_ }
C {devices/lab_pin.sym} 9890 -29910 0 0 {name=p9403 lab=_85484_/CLK }
C {devices/lab_pin.sym} 9890 -29890 0 0 {name=p9404 lab=_54744_/Y }
C {devices/lab_pin.sym} 10070 -29910 0 1 {name=p9405 lab=_85386_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -29900 0 0 {name=X_85386_ }
C {devices/lab_pin.sym} 9900 -29790 0 0 {name=p9406 lab=_51775_/Y }
C {devices/lab_pin.sym} 9900 -29750 0 0 {name=p9407 lab=_51767_/X }
C {devices/lab_pin.sym} 9900 -29710 0 0 {name=p9408 lab=_51777_/X }
C {devices/lab_pin.sym} 10060 -29750 0 1 {name=p9409 lab=_85948_/D }
C {sky130_stdcells/a21oi_4.sym} 9980 -29750 0 0 {name=X_51778_ }
C {devices/lab_pin.sym} 9890 -29610 0 0 {name=p9410 lab=_82879_/CLK }
C {devices/lab_pin.sym} 9890 -29590 0 0 {name=p9411 lab=_78845_/B }
C {devices/lab_pin.sym} 10070 -29610 0 1 {name=p9412 lab=_82598_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -29600 0 0 {name=X_82598_ }
C {devices/lab_pin.sym} 9940 -29470 0 0 {name=p9413 lab=_56360_/A }
C {devices/lab_pin.sym} 10020 -29470 0 1 {name=p9414 lab=_56305_/X }
C {sky130_stdcells/buf_2.sym} 9980 -29470 0 0 {name=X_56305_ }
C {devices/lab_pin.sym} 9940 -29350 0 0 {name=p9415 lab=_41457_/A }
C {devices/lab_pin.sym} 10020 -29350 0 1 {name=p9416 lab=_41531_/X }
C {sky130_stdcells/buf_2.sym} 9980 -29350 0 0 {name=X_41531_ }
C {devices/lab_pin.sym} 9890 -29230 0 0 {name=p9417 lab=_88201_/CLK }
C {devices/lab_pin.sym} 9890 -29210 0 0 {name=p9418 lab=_44403_/X }
C {devices/lab_pin.sym} 10070 -29230 0 1 {name=p9419 lab=_87125_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -29220 0 0 {name=X_87125_ }
C {devices/lab_pin.sym} 9900 -29110 0 0 {name=p9420 lab=_53515_/Y }
C {devices/lab_pin.sym} 9900 -29070 0 0 {name=p9421 lab=_53498_/X }
C {devices/lab_pin.sym} 9900 -29030 0 0 {name=p9422 lab=_53516_/Y }
C {devices/lab_pin.sym} 10060 -29070 0 1 {name=p9423 lab=_53517_/Y }
C {sky130_stdcells/a21boi_4.sym} 9980 -29070 0 0 {name=X_53517_ }
C {devices/lab_pin.sym} 9900 -28950 0 0 {name=p9424 lab=_72305_/X }
C {devices/lab_pin.sym} 9900 -28910 0 0 {name=p9425 lab=_85358_/Q }
C {devices/lab_pin.sym} 9900 -28870 0 0 {name=p9426 lab=_72350_/X }
C {devices/lab_pin.sym} 10060 -28910 0 1 {name=p9427 lab=_72351_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -28910 0 0 {name=X_72351_ }
C {devices/lab_pin.sym} 9890 -28770 0 0 {name=p9428 lab=_83218_/CLK }
C {devices/lab_pin.sym} 9890 -28750 0 0 {name=p9429 lab=_63286_/Y }
C {devices/lab_pin.sym} 10070 -28770 0 1 {name=p9430 lab=_79259_/A }
C {sky130_stdcells/dfxtp_4.sym} 9980 -28760 0 0 {name=X_84337_ }
C {devices/lab_pin.sym} 9920 -28640 0 0 {name=p9431 lab=_50799_/A }
C {devices/lab_pin.sym} 9920 -28600 0 0 {name=p9432 lab=_51235_/B }
C {devices/lab_pin.sym} 10040 -28620 0 1 {name=p9433 lab=_50729_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -28620 0 0 {name=X_50729_ }
C {devices/lab_pin.sym} 9940 -28490 0 0 {name=p9434 lab=_57284_/Y }
C {devices/lab_pin.sym} 10020 -28490 0 1 {name=p9435 lab=_57285_/Y }
C {sky130_stdcells/inv_2.sym} 9980 -28490 0 0 {name=X_57285_ }
C {devices/lab_pin.sym} 9890 -28370 0 0 {name=p9436 lab=_83940_/CLK }
C {devices/lab_pin.sym} 9890 -28350 0 0 {name=p9437 lab=_76753_/X }
C {devices/lab_pin.sym} 10070 -28370 0 1 {name=p9438 lab=_81537_/D }
C {sky130_stdcells/dfxtp_4.sym} 9980 -28360 0 0 {name=X_81549_ }
C {devices/lab_pin.sym} 9900 -28250 0 0 {name=p9439 lab=_85431_/Q }
C {devices/lab_pin.sym} 9900 -28210 0 0 {name=p9440 lab=_54485_/X }
C {devices/lab_pin.sym} 9900 -28170 0 0 {name=p9441 lab=_54496_/Y }
C {devices/lab_pin.sym} 10060 -28210 0 1 {name=p9442 lab=_54497_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -28210 0 0 {name=X_54497_ }
C {devices/lab_pin.sym} 9900 -28090 0 0 {name=p9443 lab=_59001_/X }
C {devices/lab_pin.sym} 9900 -28050 0 0 {name=p9444 lab=_86079_/Q }
C {devices/lab_pin.sym} 9900 -28010 0 0 {name=p9445 lab=_59023_/X }
C {devices/lab_pin.sym} 10060 -28050 0 1 {name=p9446 lab=_59024_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -28050 0 0 {name=X_59024_ }
C {devices/lab_pin.sym} 9940 -27910 0 0 {name=p9447 lab=_70382_/A }
C {devices/lab_pin.sym} 10020 -27910 0 1 {name=p9448 lab=_71302_/X }
C {sky130_stdcells/buf_2.sym} 9980 -27910 0 0 {name=X_71302_ }
C {devices/lab_pin.sym} 9900 -27810 0 0 {name=p9449 lab=_56280_/A }
C {devices/lab_pin.sym} 9900 -27770 0 0 {name=p9450 lab=_56094_/X }
C {devices/lab_pin.sym} 9900 -27730 0 0 {name=p9451 lab=_56235_/Y }
C {devices/lab_pin.sym} 10060 -27770 0 1 {name=p9452 lab=_56236_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -27770 0 0 {name=X_56236_ }
C {devices/lab_pin.sym} 9940 -27630 0 0 {name=p9453 lab=_68385_/A }
C {devices/lab_pin.sym} 10020 -27630 0 1 {name=p9454 lab=_59036_/A }
C {sky130_stdcells/buf_2.sym} 9980 -27630 0 0 {name=X_44250_ }
C {devices/lab_pin.sym} 9920 -27520 0 0 {name=p9455 lab=_81153_/D }
C {devices/lab_pin.sym} 9920 -27480 0 0 {name=p9456 lab=_80865_/Q }
C {devices/lab_pin.sym} 10040 -27500 0 1 {name=p9457 lab=_75070_/Y }
C {sky130_stdcells/xnor2_4.sym} 9980 -27500 0 0 {name=X_75070_ }
C {devices/lab_pin.sym} 9890 -27370 0 0 {name=p9458 lab=_87045_/CLK }
C {devices/lab_pin.sym} 9890 -27350 0 0 {name=p9459 lab=_87056_/D }
C {devices/lab_pin.sym} 10070 -27370 0 1 {name=p9460 lab=_44556_/A }
C {sky130_stdcells/dfxtp_4.sym} 9980 -27360 0 0 {name=X_87056_ }
C {devices/lab_pin.sym} 9900 -27260 0 0 {name=p9461 lab=_41461_/X }
C {devices/lab_pin.sym} 9900 -27220 0 0 {name=p9462 lab=_41455_/X }
C {devices/lab_pin.sym} 9900 -27180 0 0 {name=p9463 lab=_88211_/Q }
C {devices/lab_pin.sym} 9900 -27140 0 0 {name=p9464 lab=_41457_/X }
C {devices/lab_pin.sym} 10060 -27200 0 1 {name=p9465 lab=_41462_/X }
C {sky130_stdcells/a2bb2o_4.sym} 9980 -27200 0 0 {name=X_41462_ }
C {devices/lab_pin.sym} 9900 -27070 0 0 {name=p9466 lab=_72258_/X }
C {devices/lab_pin.sym} 9900 -27030 0 0 {name=p9467 lab=_85684_/Q }
C {devices/lab_pin.sym} 9900 -26990 0 0 {name=p9468 lab=_72146_/X }
C {devices/lab_pin.sym} 10060 -27030 0 1 {name=p9469 lab=_72282_/X }
C {sky130_stdcells/o21a_4.sym} 9980 -27030 0 0 {name=X_72282_ }
C {devices/lab_pin.sym} 9940 -26890 0 0 {name=p9470 lab=_53661_/A }
C {devices/lab_pin.sym} 10020 -26890 0 1 {name=p9471 lab=_53448_/X }
C {sky130_stdcells/buf_2.sym} 9980 -26890 0 0 {name=X_53448_ }
C {devices/lab_pin.sym} 9890 -26770 0 0 {name=p9472 lab=_84269_/CLK }
C {devices/lab_pin.sym} 9890 -26750 0 0 {name=p9473 lab=_64176_/Y }
C {devices/lab_pin.sym} 10070 -26770 0 1 {name=p9474 lab=_79921_/A }
C {sky130_stdcells/dfxtp_4.sym} 9980 -26760 0 0 {name=X_84268_ }
C {devices/lab_pin.sym} 9940 -26630 0 0 {name=p9475 lab=_43201_/A }
C {devices/lab_pin.sym} 10020 -26630 0 1 {name=p9476 lab=_43201_/Y }
C {sky130_stdcells/inv_2.sym} 9980 -26630 0 0 {name=X_43201_ }
C {devices/lab_pin.sym} 9940 -26510 0 0 {name=p9477 lab=_72880_/A }
C {devices/lab_pin.sym} 10020 -26510 0 1 {name=p9478 lab=_74021_/X }
C {sky130_stdcells/buf_2.sym} 9980 -26510 0 0 {name=X_74021_ }
C {devices/lab_pin.sym} 9890 -26390 0 0 {name=p9479 lab=_86005_/CLK }
C {devices/lab_pin.sym} 9890 -26370 0 0 {name=p9480 lab=_51457_/Y }
C {devices/lab_pin.sym} 10070 -26390 0 1 {name=p9481 lab=_86007_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -26380 0 0 {name=X_86007_ }
C {devices/lab_pin.sym} 9940 -26250 0 0 {name=p9482 lab=_40629_/A }
C {devices/lab_pin.sym} 10020 -26250 0 1 {name=p9483 lab=_40413_/X }
C {sky130_stdcells/buf_2.sym} 9980 -26250 0 0 {name=X_40413_ }
C {devices/lab_pin.sym} 9900 -26150 0 0 {name=p9484 lab=_48695_/B }
C {devices/lab_pin.sym} 9900 -26110 0 0 {name=p9485 lab=_71233_/A2 }
C {devices/lab_pin.sym} 9900 -26070 0 0 {name=p9486 lab=_71232_/Y }
C {devices/lab_pin.sym} 10060 -26110 0 1 {name=p9487 lab=_71233_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -26110 0 0 {name=X_71233_ }
C {devices/lab_pin.sym} 9890 -25970 0 0 {name=p9488 lab=_84350_/CLK }
C {devices/lab_pin.sym} 9890 -25950 0 0 {name=p9489 lab=_72605_/Y }
C {devices/lab_pin.sym} 10070 -25970 0 1 {name=p9490 lab=_79279_/B }
C {sky130_stdcells/dfxtp_4.sym} 9980 -25960 0 0 {name=X_83219_ }
C {devices/lab_pin.sym} 9940 -25830 0 0 {name=p9491 lab=_64817_/A }
C {devices/lab_pin.sym} 10020 -25830 0 1 {name=p9492 lab=_44181_/X }
C {sky130_stdcells/buf_2.sym} 9980 -25830 0 0 {name=X_44181_ }
C {devices/lab_pin.sym} 9920 -25720 0 0 {name=p9493 lab=_56167_/A }
C {devices/lab_pin.sym} 9920 -25680 0 0 {name=p9494 lab=_56167_/B }
C {devices/lab_pin.sym} 10040 -25700 0 1 {name=p9495 lab=_56168_/A }
C {sky130_stdcells/xnor2_4.sym} 9980 -25700 0 0 {name=X_56167_ }
C {devices/lab_pin.sym} 9940 -25570 0 0 {name=p9496 lab=_41392_/Y }
C {devices/lab_pin.sym} 10020 -25570 0 1 {name=p9497 lab=_41393_/X }
C {sky130_stdcells/buf_2.sym} 9980 -25570 0 0 {name=X_41393_ }
C {devices/lab_pin.sym} 9940 -25450 0 0 {name=p9498 lab=_53352_/A }
C {devices/lab_pin.sym} 10020 -25450 0 1 {name=p9499 lab=_53386_/A }
C {sky130_stdcells/buf_2.sym} 9980 -25450 0 0 {name=X_53379_ }
C {devices/lab_pin.sym} 9890 -25330 0 0 {name=p9500 lab=_84194_/CLK }
C {devices/lab_pin.sym} 9890 -25310 0 0 {name=p9501 lab=_84199_/D }
C {devices/lab_pin.sym} 10070 -25330 0 1 {name=p9502 lab=_65466_/C }
C {sky130_stdcells/dfxtp_4.sym} 9980 -25320 0 0 {name=X_84199_ }
C {devices/lab_pin.sym} 9900 -25230 0 0 {name=p9503 lab=_43129_/X }
C {devices/lab_pin.sym} 9900 -25190 0 0 {name=p9504 lab=_43130_/X }
C {devices/lab_pin.sym} 9900 -25150 0 0 {name=p9505 lab=_40798_/X }
C {devices/lab_pin.sym} 9900 -25110 0 0 {name=p9506 lab=_43131_/Y }
C {devices/lab_pin.sym} 9900 -25070 0 0 {name=p9507 lab=_43127_/X }
C {devices/lab_pin.sym} 10060 -25150 0 1 {name=p9508 lab=_43132_/Y }
C {sky130_stdcells/o32ai_4.sym} 9980 -25150 0 0 {name=X_43132_ }
C {devices/lab_pin.sym} 9920 -25000 0 0 {name=p9509 lab=_55118_/A }
C {devices/lab_pin.sym} 9920 -24960 0 0 {name=p9510 lab=_47818_/A }
C {devices/lab_pin.sym} 10040 -24980 0 1 {name=p9511 lab=_55118_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -24980 0 0 {name=X_55118_ }
C {devices/lab_pin.sym} 9940 -24850 0 0 {name=p9512 lab=_40344_/A }
C {devices/lab_pin.sym} 10020 -24850 0 1 {name=p9513 lab=_46610_/A }
C {sky130_stdcells/buf_2.sym} 9980 -24850 0 0 {name=X_40344_ }
C {devices/lab_pin.sym} 9920 -24740 0 0 {name=p9514 lab=_71137_/A }
C {devices/lab_pin.sym} 9920 -24700 0 0 {name=p9515 lab=_71164_/B }
C {devices/lab_pin.sym} 10040 -24720 0 1 {name=p9516 lab=_71164_/Y }
C {sky130_stdcells/nor2_4.sym} 9980 -24720 0 0 {name=X_71164_ }
C {devices/lab_pin.sym} 9920 -24600 0 0 {name=p9517 lab=_56098_/A }
C {devices/lab_pin.sym} 9920 -24560 0 0 {name=p9518 lab=_55830_/X }
C {devices/lab_pin.sym} 10040 -24580 0 1 {name=p9519 lab=_56099_/A }
C {sky130_stdcells/xnor2_4.sym} 9980 -24580 0 0 {name=X_56098_ }
C {devices/lab_pin.sym} 9940 -24450 0 0 {name=p9520 lab=_70115_/A }
C {devices/lab_pin.sym} 10020 -24450 0 1 {name=p9521 lab=_70117_/C }
C {sky130_stdcells/inv_2.sym} 9980 -24450 0 0 {name=X_70115_ }
C {devices/lab_pin.sym} 9940 -24330 0 0 {name=p9522 lab=_57537_/B }
C {devices/lab_pin.sym} 10020 -24330 0 1 {name=p9523 lab=_48231_/B }
C {sky130_stdcells/buf_2.sym} 9980 -24330 0 0 {name=X_47940_ }
C {devices/lab_pin.sym} 9940 -24210 0 0 {name=p9524 lab=_43062_/Y }
C {devices/lab_pin.sym} 10020 -24210 0 1 {name=p9525 lab=_87591_/D }
C {sky130_stdcells/inv_2.sym} 9980 -24210 0 0 {name=X_43063_ }
C {devices/lab_pin.sym} 9900 -24110 0 0 {name=p9526 lab=_85328_/Q }
C {devices/lab_pin.sym} 9900 -24070 0 0 {name=p9527 lab=_55046_/X }
C {devices/lab_pin.sym} 9900 -24030 0 0 {name=p9528 lab=_55048_/Y }
C {devices/lab_pin.sym} 10060 -24070 0 1 {name=p9529 lab=_55049_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -24070 0 0 {name=X_55049_ }
C {devices/lab_pin.sym} 9940 -23930 0 0 {name=p9530 lab=_78759_/X }
C {devices/lab_pin.sym} 10020 -23930 0 1 {name=p9531 lab=_78762_/A }
C {sky130_stdcells/inv_2.sym} 9980 -23930 0 0 {name=X_78760_ }
C {devices/lab_pin.sym} 9940 -23810 0 0 {name=p9532 lab=_59926_/A }
C {devices/lab_pin.sym} 10020 -23810 0 1 {name=p9533 lab=_59929_/C }
C {sky130_stdcells/buf_2.sym} 9980 -23810 0 0 {name=X_59926_ }
C {devices/lab_pin.sym} 9940 -23690 0 0 {name=p9534 lab=_71095_/A }
C {devices/lab_pin.sym} 10020 -23690 0 1 {name=p9535 lab=_71095_/X }
C {sky130_stdcells/buf_2.sym} 9980 -23690 0 0 {name=X_71095_ }
C {devices/lab_pin.sym} 9890 -23570 0 0 {name=p9536 lab=_87221_/CLK }
C {devices/lab_pin.sym} 9890 -23550 0 0 {name=p9537 lab=_42254_/Y }
C {devices/lab_pin.sym} 10070 -23570 0 1 {name=p9538 lab=_87958_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -23560 0 0 {name=X_87958_ }
C {devices/lab_pin.sym} 9920 -23440 0 0 {name=p9539 lab=_81706_/D }
C {devices/lab_pin.sym} 9920 -23400 0 0 {name=p9540 lab=_75972_/B }
C {devices/lab_pin.sym} 10040 -23420 0 1 {name=p9541 lab=_75981_/A }
C {sky130_stdcells/xor2_4.sym} 9980 -23420 0 0 {name=X_75972_ }
C {devices/lab_pin.sym} 9900 -23330 0 0 {name=p9542 lab=_42013_/X }
C {devices/lab_pin.sym} 9900 -23290 0 0 {name=p9543 lab=_42006_/X }
C {devices/lab_pin.sym} 9900 -23250 0 0 {name=p9544 lab=_40826_/X }
C {devices/lab_pin.sym} 9900 -23210 0 0 {name=p9545 lab=_73081_/A }
C {devices/lab_pin.sym} 9900 -23170 0 0 {name=p9546 lab=_42007_/X }
C {devices/lab_pin.sym} 10060 -23250 0 1 {name=p9547 lab=_42014_/Y }
C {sky130_stdcells/o32ai_4.sym} 9980 -23250 0 0 {name=X_42014_ }
C {devices/lab_pin.sym} 9920 -23100 0 0 {name=p9548 lab=_77712_/A }
C {devices/lab_pin.sym} 9920 -23060 0 0 {name=p9549 lab=_82124_/Q }
C {devices/lab_pin.sym} 10040 -23080 0 1 {name=p9550 lab=_77711_/Y }
C {sky130_stdcells/nor2_4.sym} 9980 -23080 0 0 {name=X_77711_ }
C {devices/lab_pin.sym} 9920 -22960 0 0 {name=p9551 lab=_74923_/A }
C {devices/lab_pin.sym} 9920 -22920 0 0 {name=p9552 lab=_74923_/B }
C {devices/lab_pin.sym} 10040 -22940 0 1 {name=p9553 lab=_74926_/A }
C {sky130_stdcells/nand2_4.sym} 9980 -22940 0 0 {name=X_74923_ }
C {devices/lab_pin.sym} 9900 -22840 0 0 {name=p9554 lab=_70040_/X }
C {devices/lab_pin.sym} 9900 -22800 0 0 {name=p9555 lab=_69800_/Y }
C {devices/lab_pin.sym} 9900 -22760 0 0 {name=p9556 lab=_70033_/X }
C {devices/lab_pin.sym} 9900 -22720 0 0 {name=p9557 lab=_70045_/Y }
C {devices/lab_pin.sym} 10060 -22780 0 1 {name=p9558 lab=_70046_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -22780 0 0 {name=X_70046_ }
C {devices/lab_pin.sym} 9890 -22630 0 0 {name=p9559 lab=_86878_/CLK }
C {devices/lab_pin.sym} 9890 -22610 0 0 {name=p9560 lab=_44942_/Y }
C {devices/lab_pin.sym} 10070 -22630 0 1 {name=p9561 lab=_64235_/B }
C {sky130_stdcells/dfxtp_4.sym} 9980 -22620 0 0 {name=X_86909_ }
C {devices/lab_pin.sym} 9940 -22490 0 0 {name=p9562 lab=_47871_/A }
C {devices/lab_pin.sym} 10020 -22490 0 1 {name=p9563 lab=_48196_/A }
C {sky130_stdcells/buf_2.sym} 9980 -22490 0 0 {name=X_47871_ }
C {devices/lab_pin.sym} 9920 -22390 0 0 {name=p9564 lab=_59823_/X }
C {devices/lab_pin.sym} 9920 -22350 0 0 {name=p9565 lab=_59637_/A }
C {devices/lab_pin.sym} 9920 -22310 0 0 {name=p9566 lab=_59648_/A }
C {devices/lab_pin.sym} 10040 -22350 0 1 {name=p9567 lab=_59858_/A }
C {sky130_stdcells/nor3_4.sym} 9980 -22350 0 0 {name=X_59857_ }
C {devices/lab_pin.sym} 9920 -22220 0 0 {name=p9568 lab=_78691_/A }
C {devices/lab_pin.sym} 9920 -22180 0 0 {name=p9569 lab=_82684_/D }
C {devices/lab_pin.sym} 10040 -22200 0 1 {name=p9570 lab=_78691_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -22200 0 0 {name=X_78691_ }
C {devices/lab_pin.sym} 9890 -22070 0 0 {name=p9571 lab=_87625_/CLK }
C {devices/lab_pin.sym} 9890 -22050 0 0 {name=p9572 lab=_87889_/D }
C {devices/lab_pin.sym} 10070 -22070 0 1 {name=p9573 lab=_87889_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -22060 0 0 {name=X_87889_ }
C {devices/lab_pin.sym} 9920 -21960 0 0 {name=p9574 lab=_49610_/A }
C {devices/lab_pin.sym} 9920 -21920 0 0 {name=p9575 lab=_49592_/B }
C {devices/lab_pin.sym} 9920 -21880 0 0 {name=p9576 lab=_49615_/C }
C {devices/lab_pin.sym} 9920 -21840 0 0 {name=p9577 lab=_52827_/D }
C {devices/lab_pin.sym} 10040 -21900 0 1 {name=p9578 lab=_49610_/X }
C {sky130_stdcells/and4_4.sym} 9980 -21900 0 0 {name=X_49610_ }
C {devices/lab_pin.sym} 9920 -21780 0 0 {name=p9579 lab=_46830_/A }
C {devices/lab_pin.sym} 9920 -21740 0 0 {name=p9580 lab=_46830_/B }
C {devices/lab_pin.sym} 9920 -21700 0 0 {name=p9581 lab=_46830_/C }
C {devices/lab_pin.sym} 9920 -21660 0 0 {name=p9582 lab=_52694_/D }
C {devices/lab_pin.sym} 10040 -21720 0 1 {name=p9583 lab=_46822_/X }
C {sky130_stdcells/and4_4.sym} 9980 -21720 0 0 {name=X_46822_ }
C {devices/lab_pin.sym} 9900 -21610 0 0 {name=p9584 lab=_58696_/X }
C {devices/lab_pin.sym} 9900 -21570 0 0 {name=p9585 lab=_58804_/Y }
C {devices/lab_pin.sym} 9900 -21530 0 0 {name=p9586 lab=_58807_/Y }
C {devices/lab_pin.sym} 9900 -21490 0 0 {name=p9587 lab=_58728_/X }
C {devices/lab_pin.sym} 9900 -21450 0 0 {name=p9588 lab=_58701_/X }
C {devices/lab_pin.sym} 10060 -21530 0 1 {name=p9589 lab=_58808_/X }
C {sky130_stdcells/o32a_4.sym} 9980 -21530 0 0 {name=X_58808_ }
C {devices/lab_pin.sym} 9900 -21390 0 0 {name=p9590 lab=_77627_/A }
C {devices/lab_pin.sym} 9900 -21350 0 0 {name=p9591 lab=_77626_/Y }
C {devices/lab_pin.sym} 9900 -21310 0 0 {name=p9592 lab=_77666_/A }
C {devices/lab_pin.sym} 10060 -21350 0 1 {name=p9593 lab=_77643_/B }
C {sky130_stdcells/o21a_4.sym} 9980 -21350 0 0 {name=X_77642_ }
C {devices/lab_pin.sym} 9920 -21220 0 0 {name=p9594 lab=_81124_/D }
C {devices/lab_pin.sym} 9920 -21180 0 0 {name=p9595 lab=_74854_/B }
C {devices/lab_pin.sym} 10040 -21200 0 1 {name=p9596 lab=_74865_/A }
C {sky130_stdcells/nor2_4.sym} 9980 -21200 0 0 {name=X_74854_ }
C {devices/lab_pin.sym} 9940 -21070 0 0 {name=p9597 lab=_59512_/A }
C {devices/lab_pin.sym} 10020 -21070 0 1 {name=p9598 lab=_59789_/A }
C {sky130_stdcells/buf_2.sym} 9980 -21070 0 0 {name=X_59788_ }
C {devices/lab_pin.sym} 9940 -20950 0 0 {name=p9599 lab=_49434_/A }
C {devices/lab_pin.sym} 10020 -20950 0 1 {name=p9600 lab=_49541_/X }
C {sky130_stdcells/buf_2.sym} 9980 -20950 0 0 {name=X_49541_ }
C {devices/lab_pin.sym} 9920 -20840 0 0 {name=p9601 lab=_73733_/A }
C {devices/lab_pin.sym} 9920 -20800 0 0 {name=p9602 lab=_85911_/Q }
C {devices/lab_pin.sym} 10040 -20820 0 1 {name=p9603 lab=_73805_/X }
C {sky130_stdcells/and2_4.sym} 9980 -20820 0 0 {name=X_73805_ }
C {devices/lab_pin.sym} 9940 -20690 0 0 {name=p9604 lab=_82963_/Q }
C {devices/lab_pin.sym} 10020 -20690 0 1 {name=p9605 lab=_46753_/Y }
C {sky130_stdcells/inv_2.sym} 9980 -20690 0 0 {name=X_46753_ }
C {devices/lab_pin.sym} 9940 -20570 0 0 {name=p9606 lab=_58857_/A }
C {devices/lab_pin.sym} 10020 -20570 0 1 {name=p9607 lab=_58739_/X }
C {sky130_stdcells/buf_2.sym} 9980 -20570 0 0 {name=X_58739_ }
C {devices/lab_pin.sym} 9940 -20450 0 0 {name=p9608 lab=_77572_/X }
C {devices/lab_pin.sym} 10020 -20450 0 1 {name=p9609 lab=_77575_/B }
C {sky130_stdcells/inv_2.sym} 9980 -20450 0 0 {name=X_77573_ }
C {devices/lab_pin.sym} 9900 -20360 0 0 {name=p9610 lab=_87174_/Q }
C {devices/lab_pin.sym} 9900 -20320 0 0 {name=p9611 lab=_43944_/A }
C {devices/lab_pin.sym} 9900 -20280 0 0 {name=p9612 lab=_43945_/A }
C {devices/lab_pin.sym} 9900 -20240 0 0 {name=p9613 lab=_43964_/X }
C {devices/lab_pin.sym} 10060 -20300 0 1 {name=p9614 lab=_43965_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -20300 0 0 {name=X_43965_ }
C {devices/lab_pin.sym} 9900 -20190 0 0 {name=p9615 lab=_83838_/Q }
C {devices/lab_pin.sym} 9900 -20150 0 0 {name=p9616 lab=_74731_/X }
C {devices/lab_pin.sym} 9900 -20110 0 0 {name=p9617 lab=_74778_/X }
C {devices/lab_pin.sym} 9900 -20070 0 0 {name=p9618 lab=_74779_/X }
C {devices/lab_pin.sym} 9900 -20030 0 0 {name=p9619 lab=_74784_/Y }
C {devices/lab_pin.sym} 10060 -20110 0 1 {name=p9620 lab=_74785_/X }
C {sky130_stdcells/a2111o_4.sym} 9980 -20110 0 0 {name=X_74785_ }
C {devices/lab_pin.sym} 9900 -19970 0 0 {name=p9621 lab=_83305_/Q }
C {devices/lab_pin.sym} 9900 -19930 0 0 {name=p9622 lab=_71985_/X }
C {devices/lab_pin.sym} 9900 -19890 0 0 {name=p9623 lab=_71996_/Y }
C {devices/lab_pin.sym} 10060 -19930 0 1 {name=p9624 lab=_71997_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -19930 0 0 {name=X_71997_ }
C {devices/lab_pin.sym} 9920 -19800 0 0 {name=p9625 lab=_79324_/A }
C {devices/lab_pin.sym} 9920 -19760 0 0 {name=p9626 lab=_79324_/B }
C {devices/lab_pin.sym} 10040 -19780 0 1 {name=p9627 lab=_79334_/B }
C {sky130_stdcells/xor2_4.sym} 9980 -19780 0 0 {name=X_79312_ }
C {devices/lab_pin.sym} 9900 -19680 0 0 {name=p9628 lab=_55186_/B }
C {devices/lab_pin.sym} 9900 -19640 0 0 {name=p9629 lab=_45596_/X }
C {devices/lab_pin.sym} 9900 -19600 0 0 {name=p9630 lab=_45644_/X }
C {devices/lab_pin.sym} 9900 -19560 0 0 {name=p9631 lab=_45703_/Y }
C {devices/lab_pin.sym} 10060 -19620 0 1 {name=p9632 lab=_45704_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -19620 0 0 {name=X_45704_ }
C {devices/lab_pin.sym} 9920 -19490 0 0 {name=p9633 lab=_76520_/Y }
C {devices/lab_pin.sym} 9920 -19450 0 0 {name=p9634 lab=_76521_/Y }
C {devices/lab_pin.sym} 9920 -19410 0 0 {name=p9635 lab=_76524_/C }
C {devices/lab_pin.sym} 10040 -19450 0 1 {name=p9636 lab=_76524_/X }
C {sky130_stdcells/or3_4.sym} 9980 -19450 0 0 {name=X_76524_ }
C {devices/lab_pin.sym} 9940 -19310 0 0 {name=p9637 lab=_42846_/X }
C {devices/lab_pin.sym} 10020 -19310 0 1 {name=p9638 lab=_42916_/X }
C {sky130_stdcells/buf_2.sym} 9980 -19310 0 0 {name=X_42916_ }
C {devices/lab_pin.sym} 9920 -19200 0 0 {name=p9639 lab=_49481_/A }
C {devices/lab_pin.sym} 9920 -19160 0 0 {name=p9640 lab=_46805_/X }
C {devices/lab_pin.sym} 10040 -19180 0 1 {name=p9641 lab=_49472_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -19180 0 0 {name=X_49472_ }
C {devices/lab_pin.sym} 9920 -19080 0 0 {name=p9642 lab=_61782_/A }
C {devices/lab_pin.sym} 9920 -19040 0 0 {name=p9643 lab=_61750_/B }
C {devices/lab_pin.sym} 9920 -19000 0 0 {name=p9644 lab=_61743_/Y }
C {devices/lab_pin.sym} 9920 -18960 0 0 {name=p9645 lab=_61749_/Y }
C {devices/lab_pin.sym} 10040 -19020 0 1 {name=p9646 lab=_61750_/Y }
C {sky130_stdcells/nand4_4.sym} 9980 -19020 0 0 {name=X_61750_ }
C {devices/lab_pin.sym} 9920 -18880 0 0 {name=p9647 lab=_73711_/A }
C {devices/lab_pin.sym} 9920 -18840 0 0 {name=p9648 lab=_66008_/B }
C {devices/lab_pin.sym} 10040 -18860 0 1 {name=p9649 lab=_73736_/X }
C {sky130_stdcells/and2_4.sym} 9980 -18860 0 0 {name=X_73736_ }
C {devices/lab_pin.sym} 9940 -18730 0 0 {name=p9650 lab=_83682_/Q }
C {devices/lab_pin.sym} 10020 -18730 0 1 {name=p9651 lab=_46685_/A }
C {sky130_stdcells/inv_2.sym} 9980 -18730 0 0 {name=X_46684_ }
C {devices/lab_pin.sym} 9900 -18630 0 0 {name=p9652 lab=_50744_/B }
C {devices/lab_pin.sym} 9900 -18590 0 0 {name=p9653 lab=_70937_/X }
C {devices/lab_pin.sym} 9900 -18550 0 0 {name=p9654 lab=_70947_/Y }
C {devices/lab_pin.sym} 10060 -18590 0 1 {name=p9655 lab=_70948_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -18590 0 0 {name=X_70948_ }
C {devices/lab_pin.sym} 9940 -18450 0 0 {name=p9656 lab=_43756_/A }
C {devices/lab_pin.sym} 10020 -18450 0 1 {name=p9657 lab=_43896_/X }
C {sky130_stdcells/buf_2.sym} 9980 -18450 0 0 {name=X_43896_ }
C {devices/lab_pin.sym} 9940 -18330 0 0 {name=p9658 lab=_53647_/B }
C {devices/lab_pin.sym} 10020 -18330 0 1 {name=p9659 lab=_52128_/B }
C {sky130_stdcells/buf_2.sym} 9980 -18330 0 0 {name=X_48423_ }
C {devices/lab_pin.sym} 9900 -18250 0 0 {name=p9660 lab=_60692_/X }
C {devices/lab_pin.sym} 9900 -18210 0 0 {name=p9661 lab=_60694_/Y }
C {devices/lab_pin.sym} 9900 -18170 0 0 {name=p9662 lab=_60696_/Y }
C {devices/lab_pin.sym} 9900 -18130 0 0 {name=p9663 lab=_60698_/X }
C {devices/lab_pin.sym} 9900 -18100 0 0 {name=p9664 lab=_60700_/Y }
C {devices/lab_pin.sym} 10060 -18170 0 1 {name=p9665 lab=_60701_/Y }
C {sky130_stdcells/a41oi_4.sym} 9980 -18170 0 0 {name=X_60701_ }
C {devices/lab_pin.sym} 9920 -18020 0 0 {name=p9666 lab=_79251_/B }
C {devices/lab_pin.sym} 9920 -17980 0 0 {name=p9667 lab=_79242_/Y }
C {devices/lab_pin.sym} 10040 -18000 0 1 {name=p9668 lab=_82823_/D }
C {sky130_stdcells/xor2_4.sym} 9980 -18000 0 0 {name=X_79243_ }
C {devices/lab_pin.sym} 9900 -17890 0 0 {name=p9669 lab=_45630_/X }
C {devices/lab_pin.sym} 9900 -17850 0 0 {name=p9670 lab=_45634_/X }
C {devices/lab_pin.sym} 9900 -17810 0 0 {name=p9671 lab=_45602_/X }
C {devices/lab_pin.sym} 10060 -17850 0 1 {name=p9672 lab=_45635_/X }
C {sky130_stdcells/a21o_4.sym} 9980 -17850 0 0 {name=X_45635_ }
C {devices/lab_pin.sym} 9920 -17720 0 0 {name=p9673 lab=_76455_/A }
C {devices/lab_pin.sym} 9920 -17680 0 0 {name=p9674 lab=_76455_/B }
C {devices/lab_pin.sym} 10040 -17700 0 1 {name=p9675 lab=_76456_/A }
C {sky130_stdcells/nor2_4.sym} 9980 -17700 0 0 {name=X_76455_ }
C {devices/lab_pin.sym} 9940 -17570 0 0 {name=p9676 lab=_42846_/X }
C {devices/lab_pin.sym} 10020 -17570 0 1 {name=p9677 lab=_42847_/X }
C {sky130_stdcells/buf_2.sym} 9980 -17570 0 0 {name=X_42847_ }
C {devices/lab_pin.sym} 9900 -17480 0 0 {name=p9678 lab=_73665_/X }
C {devices/lab_pin.sym} 9900 -17440 0 0 {name=p9679 lab=_84989_/Q }
C {devices/lab_pin.sym} 9900 -17400 0 0 {name=p9680 lab=_73614_/X }
C {devices/lab_pin.sym} 9900 -17360 0 0 {name=p9681 lab=_73666_/X }
C {devices/lab_pin.sym} 10060 -17420 0 1 {name=p9682 lab=_73667_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -17420 0 0 {name=X_73667_ }
C {devices/lab_pin.sym} 9900 -17290 0 0 {name=p9683 lab=_61679_/X }
C {devices/lab_pin.sym} 9900 -17250 0 0 {name=p9684 lab=_61645_/X }
C {devices/lab_pin.sym} 9900 -17210 0 0 {name=p9685 lab=_61680_/Y }
C {devices/lab_pin.sym} 10060 -17250 0 1 {name=p9686 lab=_84460_/D }
C {sky130_stdcells/a21oi_4.sym} 9980 -17250 0 0 {name=X_61681_ }
C {devices/lab_pin.sym} 9940 -17110 0 0 {name=p9687 lab=_70712_/A }
C {devices/lab_pin.sym} 10020 -17110 0 1 {name=p9688 lab=_70880_/C }
C {sky130_stdcells/buf_2.sym} 9980 -17110 0 0 {name=X_70879_ }
C {devices/lab_pin.sym} 9920 -17010 0 0 {name=p9689 lab=_63456_/A }
C {devices/lab_pin.sym} 9920 -16970 0 0 {name=p9690 lab=_63456_/B }
C {devices/lab_pin.sym} 9920 -16930 0 0 {name=p9691 lab=_80579_/B }
C {devices/lab_pin.sym} 10040 -16970 0 1 {name=p9692 lab=_63420_/Y }
C {sky130_stdcells/nor3_4.sym} 9980 -16970 0 0 {name=X_63420_ }
C {devices/lab_pin.sym} 9900 -16850 0 0 {name=p9693 lab=_75369_/Y }
C {devices/lab_pin.sym} 9900 -16810 0 0 {name=p9694 lab=_75404_/X }
C {devices/lab_pin.sym} 9900 -16770 0 0 {name=p9695 lab=_75405_/Y }
C {devices/lab_pin.sym} 10060 -16810 0 1 {name=p9696 lab=_75406_/Y }
C {sky130_stdcells/a21oi_4.sym} 9980 -16810 0 0 {name=X_75406_ }
C {devices/lab_pin.sym} 9940 -16670 0 0 {name=p9697 lab=_48545_/A }
C {devices/lab_pin.sym} 10020 -16670 0 1 {name=p9698 lab=_48354_/X }
C {sky130_stdcells/buf_2.sym} 9980 -16670 0 0 {name=X_48354_ }
C {devices/lab_pin.sym} 9940 -16550 0 0 {name=p9699 lab=_60632_/A }
C {devices/lab_pin.sym} 10020 -16550 0 1 {name=p9700 lab=_60632_/X }
C {sky130_stdcells/buf_2.sym} 9980 -16550 0 0 {name=X_60632_ }
C {devices/lab_pin.sym} 9900 -16450 0 0 {name=p9701 lab=_72576_/Y }
C {devices/lab_pin.sym} 9900 -16410 0 0 {name=p9702 lab=_72522_/Y }
C {devices/lab_pin.sym} 9900 -16370 0 0 {name=p9703 lab=_72535_/Y }
C {devices/lab_pin.sym} 10060 -16410 0 1 {name=p9704 lab=_72618_/X }
C {sky130_stdcells/a21bo_4.sym} 9980 -16410 0 0 {name=X_72618_ }
C {devices/lab_pin.sym} 9920 -16280 0 0 {name=p9705 lab=_79174_/A }
C {devices/lab_pin.sym} 9920 -16240 0 0 {name=p9706 lab=_79173_/Y }
C {devices/lab_pin.sym} 10040 -16260 0 1 {name=p9707 lab=_79176_/A }
C {sky130_stdcells/nor2_4.sym} 9980 -16260 0 0 {name=X_79174_ }
C {devices/lab_pin.sym} 9940 -16130 0 0 {name=p9708 lab=_85014_/Q }
C {devices/lab_pin.sym} 10020 -16130 0 1 {name=p9709 lab=_55514_/B }
C {sky130_stdcells/inv_2.sym} 9980 -16130 0 0 {name=X_45566_ }
C {devices/lab_pin.sym} 9900 -16030 0 0 {name=p9710 lab=_76382_/Y }
C {devices/lab_pin.sym} 9900 -15990 0 0 {name=p9711 lab=_76361_/Y }
C {devices/lab_pin.sym} 9900 -15950 0 0 {name=p9712 lab=_76385_/X }
C {devices/lab_pin.sym} 10060 -15990 0 1 {name=p9713 lab=_76387_/B }
C {sky130_stdcells/o21ai_4.sym} 9980 -15990 0 0 {name=X_76386_ }
C {devices/lab_pin.sym} 9900 -15880 0 0 {name=p9714 lab=_41328_/X }
C {devices/lab_pin.sym} 9900 -15840 0 0 {name=p9715 lab=_42767_/X }
C {devices/lab_pin.sym} 9900 -15800 0 0 {name=p9716 lab=_87723_/Q }
C {devices/lab_pin.sym} 9900 -15760 0 0 {name=p9717 lab=_42768_/X }
C {devices/lab_pin.sym} 10060 -15820 0 1 {name=p9718 lab=_42778_/X }
C {sky130_stdcells/a2bb2o_4.sym} 9980 -15820 0 0 {name=X_42778_ }
C {devices/lab_pin.sym} 9940 -15670 0 0 {name=p9719 lab=_72852_/X }
C {devices/lab_pin.sym} 10020 -15670 0 1 {name=p9720 lab=_73599_/B }
C {sky130_stdcells/buf_2.sym} 9980 -15670 0 0 {name=X_73598_ }
C {devices/lab_pin.sym} 9940 -15550 0 0 {name=p9721 lab=_47305_/A }
C {devices/lab_pin.sym} 10020 -15550 0 1 {name=p9722 lab=_47306_/A }
C {sky130_stdcells/inv_2.sym} 9980 -15550 0 0 {name=X_47305_ }
C {devices/lab_pin.sym} 9920 -15440 0 0 {name=p9723 lab=_82568_/Q }
C {devices/lab_pin.sym} 9920 -15400 0 0 {name=p9724 lab=_78125_/B }
C {devices/lab_pin.sym} 10040 -15420 0 1 {name=p9725 lab=_78125_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -15420 0 0 {name=X_78125_ }
C {devices/lab_pin.sym} 9900 -15330 0 0 {name=p9726 lab=_44512_/X }
C {devices/lab_pin.sym} 9900 -15290 0 0 {name=p9727 lab=_44513_/X }
C {devices/lab_pin.sym} 9900 -15250 0 0 {name=p9728 lab=_40767_/A }
C {devices/lab_pin.sym} 9900 -15210 0 0 {name=p9729 lab=_44514_/Y }
C {devices/lab_pin.sym} 9900 -15170 0 0 {name=p9730 lab=_44516_/X }
C {devices/lab_pin.sym} 10060 -15250 0 1 {name=p9731 lab=_87071_/D }
C {sky130_stdcells/o32ai_4.sym} 9980 -15250 0 0 {name=X_44517_ }
C {devices/lab_pin.sym} 9900 -15130 0 0 {name=p9732 lab=_63003_/Y }
C {devices/lab_pin.sym} 9900 -15090 0 0 {name=p9733 lab=_63347_/X }
C {devices/lab_pin.sym} 9900 -15050 0 0 {name=p9734 lab=_63350_/X }
C {devices/lab_pin.sym} 9900 -15010 0 0 {name=p9735 lab=_58374_/A }
C {devices/lab_pin.sym} 9900 -14970 0 0 {name=p9736 lab=_63020_/X }
C {devices/lab_pin.sym} 10060 -15050 0 1 {name=p9737 lab=_63351_/Y }
C {sky130_stdcells/o32ai_4.sym} 9980 -15050 0 0 {name=X_63351_ }
C {devices/lab_pin.sym} 9940 -14890 0 0 {name=p9738 lab=_75336_/X }
C {devices/lab_pin.sym} 10020 -14890 0 1 {name=p9739 lab=_75337_/Y }
C {sky130_stdcells/inv_2.sym} 9980 -14890 0 0 {name=X_75337_ }
C {devices/lab_pin.sym} 9920 -14780 0 0 {name=p9740 lab=_41729_/A }
C {devices/lab_pin.sym} 9920 -14740 0 0 {name=p9741 lab=_41718_/X }
C {devices/lab_pin.sym} 10040 -14760 0 1 {name=p9742 lab=_41729_/X }
C {sky130_stdcells/or2_4.sym} 9980 -14760 0 0 {name=X_41729_ }
C {devices/lab_pin.sym} 9900 -14670 0 0 {name=p9743 lab=_60500_/Y }
C {devices/lab_pin.sym} 9900 -14630 0 0 {name=p9744 lab=_60501_/Y }
C {devices/lab_pin.sym} 9900 -14590 0 0 {name=p9745 lab=_60602_/B }
C {devices/lab_pin.sym} 9900 -14550 0 0 {name=p9746 lab=_60583_/A }
C {devices/lab_pin.sym} 9900 -14510 0 0 {name=p9747 lab=_60479_/Y }
C {devices/lab_pin.sym} 10060 -14590 0 1 {name=p9748 lab=_60563_/X }
C {sky130_stdcells/o41a_4.sym} 9980 -14590 0 0 {name=X_60563_ }
C {devices/lab_pin.sym} 9900 -14450 0 0 {name=p9749 lab=_86542_/Q }
C {devices/lab_pin.sym} 9900 -14410 0 0 {name=p9750 lab=_48263_/X }
C {devices/lab_pin.sym} 9900 -14370 0 0 {name=p9751 lab=_48284_/Y }
C {devices/lab_pin.sym} 10060 -14410 0 1 {name=p9752 lab=_48285_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -14410 0 0 {name=X_48285_ }
C {devices/lab_pin.sym} 9920 -14280 0 0 {name=p9753 lab=_72525_/A }
C {devices/lab_pin.sym} 9920 -14240 0 0 {name=p9754 lab=_72549_/B }
C {devices/lab_pin.sym} 10040 -14260 0 1 {name=p9755 lab=_72549_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -14260 0 0 {name=X_72549_ }
C {devices/lab_pin.sym} 9940 -14130 0 0 {name=p9756 lab=_63079_/B }
C {devices/lab_pin.sym} 10020 -14130 0 1 {name=p9757 lab=_61406_/A }
C {sky130_stdcells/buf_2.sym} 9980 -14130 0 0 {name=X_45497_ }
C {devices/lab_pin.sym} 9920 -14030 0 0 {name=p9758 lab=_62267_/A }
C {devices/lab_pin.sym} 9920 -13990 0 0 {name=p9759 lab=_62267_/B }
C {devices/lab_pin.sym} 9920 -13950 0 0 {name=p9760 lab=_62302_/C }
C {devices/lab_pin.sym} 10040 -13990 0 1 {name=p9761 lab=_62302_/Y }
C {sky130_stdcells/nor3_4.sym} 9980 -13990 0 0 {name=X_62302_ }
C {devices/lab_pin.sym} 9940 -13850 0 0 {name=p9762 lab=_47236_/A }
C {devices/lab_pin.sym} 10020 -13850 0 1 {name=p9763 lab=_52934_/D }
C {sky130_stdcells/buf_2.sym} 9980 -13850 0 0 {name=X_47236_ }
C {devices/lab_pin.sym} 9900 -13760 0 0 {name=p9764 lab=_64589_/X }
C {devices/lab_pin.sym} 9900 -13720 0 0 {name=p9765 lab=_86230_/Q }
C {devices/lab_pin.sym} 9900 -13680 0 0 {name=p9766 lab=_45922_/X }
C {devices/lab_pin.sym} 9900 -13640 0 0 {name=p9767 lab=_66069_/X }
C {devices/lab_pin.sym} 10060 -13700 0 1 {name=p9768 lab=_66070_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -13700 0 0 {name=X_66070_ }
C {devices/lab_pin.sym} 9920 -13560 0 0 {name=p9769 lab=_60810_/C }
C {devices/lab_pin.sym} 9920 -13520 0 0 {name=p9770 lab=_78056_/B }
C {devices/lab_pin.sym} 10040 -13540 0 1 {name=p9771 lab=_78056_/X }
C {sky130_stdcells/xor2_4.sym} 9980 -13540 0 0 {name=X_78056_ }
C {devices/lab_pin.sym} 9940 -13410 0 0 {name=p9772 lab=_44548_/A }
C {devices/lab_pin.sym} 10020 -13410 0 1 {name=p9773 lab=_44448_/X }
C {sky130_stdcells/buf_2.sym} 9980 -13410 0 0 {name=X_44448_ }
C {devices/lab_pin.sym} 9940 -13290 0 0 {name=p9774 lab=_63281_/X }
C {devices/lab_pin.sym} 10020 -13290 0 1 {name=p9775 lab=_63282_/Y }
C {sky130_stdcells/inv_2.sym} 9980 -13290 0 0 {name=X_63282_ }
C {devices/lab_pin.sym} 9920 -13180 0 0 {name=p9776 lab=_75269_/A }
C {devices/lab_pin.sym} 9920 -13140 0 0 {name=p9777 lab=_80944_/D }
C {devices/lab_pin.sym} 10040 -13160 0 1 {name=p9778 lab=_75268_/Y }
C {sky130_stdcells/nor2_4.sym} 9980 -13160 0 0 {name=X_75268_ }
C {devices/lab_pin.sym} 9940 -13030 0 0 {name=p9779 lab=_59755_/A }
C {devices/lab_pin.sym} 10020 -13030 0 1 {name=p9780 lab=_72590_/A }
C {sky130_stdcells/buf_2.sym} 9980 -13030 0 0 {name=X_60494_ }
C {devices/lab_pin.sym} 9900 -12930 0 0 {name=p9781 lab=_65019_/Y }
C {devices/lab_pin.sym} 9900 -12890 0 0 {name=p9782 lab=_64939_/X }
C {devices/lab_pin.sym} 9900 -12850 0 0 {name=p9783 lab=_65020_/X }
C {devices/lab_pin.sym} 10060 -12890 0 1 {name=p9784 lab=_84218_/D }
C {sky130_stdcells/a21o_4.sym} 9980 -12890 0 0 {name=X_65021_ }
C {devices/lab_pin.sym} 9920 -12760 0 0 {name=p9785 lab=_82083_/Q }
C {devices/lab_pin.sym} 9920 -12720 0 0 {name=p9786 lab=_77006_/Y }
C {devices/lab_pin.sym} 10040 -12740 0 1 {name=p9787 lab=_77007_/X }
C {sky130_stdcells/xor2_4.sym} 9980 -12740 0 0 {name=X_77007_ }
C {devices/lab_pin.sym} 9920 -12640 0 0 {name=p9788 lab=_61330_/X }
C {devices/lab_pin.sym} 9920 -12600 0 0 {name=p9789 lab=_59898_/A }
C {devices/lab_pin.sym} 9920 -12560 0 0 {name=p9790 lab=_62233_/C }
C {devices/lab_pin.sym} 9920 -12520 0 0 {name=p9791 lab=_62597_/D }
C {devices/lab_pin.sym} 10040 -12580 0 1 {name=p9792 lab=_62234_/D }
C {sky130_stdcells/nand4_4.sym} 9980 -12580 0 0 {name=X_62233_ }
C {devices/lab_pin.sym} 9920 -12440 0 0 {name=p9793 lab=_74216_/X }
C {devices/lab_pin.sym} 9920 -12400 0 0 {name=p9794 lab=_74218_/X }
C {devices/lab_pin.sym} 10040 -12420 0 1 {name=p9795 lab=_74220_/B }
C {sky130_stdcells/nand2_4.sym} 9980 -12420 0 0 {name=X_74219_ }
C {devices/lab_pin.sym} 9920 -12300 0 0 {name=p9796 lab=_47150_/A }
C {devices/lab_pin.sym} 9920 -12260 0 0 {name=p9797 lab=_52889_/B }
C {devices/lab_pin.sym} 10040 -12280 0 1 {name=p9798 lab=_47167_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -12280 0 0 {name=X_47167_ }
C {devices/lab_pin.sym} 9940 -12150 0 0 {name=p9799 lab=_44454_/A }
C {devices/lab_pin.sym} 10020 -12150 0 1 {name=p9800 lab=_44379_/X }
C {sky130_stdcells/buf_2.sym} 9980 -12150 0 0 {name=X_44379_ }
C {devices/lab_pin.sym} 9920 -12040 0 0 {name=p9801 lab=_80683_/Q }
C {devices/lab_pin.sym} 9920 -12000 0 0 {name=p9802 lab=_80983_/Q }
C {devices/lab_pin.sym} 10040 -12020 0 1 {name=p9803 lab=_75201_/A }
C {sky130_stdcells/xor2_4.sym} 9980 -12020 0 0 {name=X_75199_ }
C {devices/lab_pin.sym} 9940 -11890 0 0 {name=p9804 lab=_46117_/X }
C {devices/lab_pin.sym} 10020 -11890 0 1 {name=p9805 lab=_46119_/A }
C {sky130_stdcells/buf_2.sym} 9980 -11890 0 0 {name=X_46118_ }
C {devices/lab_pin.sym} 9920 -11800 0 0 {name=p9806 lab=_61715_/A }
C {devices/lab_pin.sym} 9920 -11760 0 0 {name=p9807 lab=_62160_/Y }
C {devices/lab_pin.sym} 9920 -11720 0 0 {name=p9808 lab=_62161_/Y }
C {devices/lab_pin.sym} 9920 -11680 0 0 {name=p9809 lab=_62163_/Y }
C {devices/lab_pin.sym} 10040 -11740 0 1 {name=p9810 lab=_62164_/Y }
C {sky130_stdcells/nand4_4.sym} 9980 -11740 0 0 {name=X_62164_ }
C {devices/lab_pin.sym} 9940 -11590 0 0 {name=p9811 lab=_83702_/Q }
C {devices/lab_pin.sym} 10020 -11590 0 1 {name=p9812 lab=_53369_/B }
C {sky130_stdcells/inv_2.sym} 9980 -11590 0 0 {name=X_47098_ }
C {devices/lab_pin.sym} 9940 -11470 0 0 {name=p9813 lab=_64285_/A }
C {devices/lab_pin.sym} 10020 -11470 0 1 {name=p9814 lab=_64474_/A }
C {sky130_stdcells/buf_2.sym} 9980 -11470 0 0 {name=X_61115_ }
C {devices/lab_pin.sym} 9940 -11350 0 0 {name=p9815 lab=_46049_/A }
C {devices/lab_pin.sym} 10020 -11350 0 1 {name=p9816 lab=_86795_/D }
C {sky130_stdcells/inv_2.sym} 9980 -11350 0 0 {name=X_46049_ }
C {devices/lab_pin.sym} 9900 -11260 0 0 {name=p9817 lab=_69746_/X }
C {devices/lab_pin.sym} 9900 -11220 0 0 {name=p9818 lab=_69758_/Y }
C {devices/lab_pin.sym} 9900 -11180 0 0 {name=p9819 lab=_69733_/X }
C {devices/lab_pin.sym} 9900 -11140 0 0 {name=p9820 lab=_69759_/Y }
C {devices/lab_pin.sym} 10060 -11200 0 1 {name=p9821 lab=_69760_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -11200 0 0 {name=X_69760_ }
C {devices/lab_pin.sym} 9940 -11050 0 0 {name=p9822 lab=_66534_/A }
C {devices/lab_pin.sym} 10020 -11050 0 1 {name=p9823 lab=_66972_/X }
C {sky130_stdcells/buf_2.sym} 9980 -11050 0 0 {name=X_66972_ }
C {devices/lab_pin.sym} 9900 -10950 0 0 {name=p9824 lab=_61716_/X }
C {devices/lab_pin.sym} 9900 -10910 0 0 {name=p9825 lab=_61617_/B }
C {devices/lab_pin.sym} 9900 -10870 0 0 {name=p9826 lab=_62094_/X }
C {devices/lab_pin.sym} 10060 -10910 0 1 {name=p9827 lab=_62095_/X }
C {sky130_stdcells/a21o_4.sym} 9980 -10910 0 0 {name=X_62095_ }
C {devices/lab_pin.sym} 9920 -10780 0 0 {name=p9828 lab=_82738_/Q }
C {devices/lab_pin.sym} 9920 -10740 0 0 {name=p9829 lab=_78958_/B }
C {devices/lab_pin.sym} 10040 -10760 0 1 {name=p9830 lab=_78958_/X }
C {sky130_stdcells/xor2_4.sym} 9980 -10760 0 0 {name=X_78958_ }
C {devices/lab_pin.sym} 9900 -10660 0 0 {name=p9831 lab=_68516_/X }
C {devices/lab_pin.sym} 9900 -10620 0 0 {name=p9832 lab=_68701_/Y }
C {devices/lab_pin.sym} 9900 -10580 0 0 {name=p9833 lab=_68649_/X }
C {devices/lab_pin.sym} 9900 -10540 0 0 {name=p9834 lab=_68710_/Y }
C {devices/lab_pin.sym} 10060 -10600 0 1 {name=p9835 lab=_68711_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -10600 0 0 {name=X_68711_ }
C {devices/lab_pin.sym} 9940 -10450 0 0 {name=p9836 lab=clkbuf_7_42_0_CLK/A }
C {devices/lab_pin.sym} 10020 -10450 0 1 {name=p9837 lab=clkbuf_8_85_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 9980 -10450 0 0 {name=Xclkbuf_7_42_0_CLK }
C {devices/lab_pin.sym} 9900 -10350 0 0 {name=p9838 lab=_65920_/X }
C {devices/lab_pin.sym} 9900 -10310 0 0 {name=p9839 lab=_65922_/X }
C {devices/lab_pin.sym} 9900 -10270 0 0 {name=p9840 lab=_65304_/X }
C {devices/lab_pin.sym} 10060 -10310 0 1 {name=p9841 lab=_65923_/X }
C {sky130_stdcells/a21o_4.sym} 9980 -10310 0 0 {name=X_65923_ }
C {devices/lab_pin.sym} 9940 -10170 0 0 {name=p9842 lab=_61412_/A }
C {devices/lab_pin.sym} 10020 -10170 0 1 {name=p9843 lab=_61055_/A }
C {sky130_stdcells/buf_2.sym} 9980 -10170 0 0 {name=X_61046_ }
C {devices/lab_pin.sym} 9920 -10060 0 0 {name=p9844 lab=_77892_/A }
C {devices/lab_pin.sym} 9920 -10020 0 0 {name=p9845 lab=_77904_/A }
C {devices/lab_pin.sym} 10040 -10040 0 1 {name=p9846 lab=_77909_/X }
C {sky130_stdcells/and2_4.sym} 9980 -10040 0 0 {name=X_77909_ }
C {devices/lab_pin.sym} 9920 -9920 0 0 {name=p9847 lab=_69680_/A }
C {devices/lab_pin.sym} 9920 -9880 0 0 {name=p9848 lab=_88330_/Q }
C {devices/lab_pin.sym} 10040 -9900 0 1 {name=p9849 lab=_69691_/X }
C {sky130_stdcells/and2_4.sym} 9980 -9900 0 0 {name=X_69691_ }
C {devices/lab_pin.sym} 9920 -9780 0 0 {name=p9850 lab=_78889_/A }
C {devices/lab_pin.sym} 9920 -9740 0 0 {name=p9851 lab=_78889_/B }
C {devices/lab_pin.sym} 10040 -9760 0 1 {name=p9852 lab=_82699_/D }
C {sky130_stdcells/xor2_4.sym} 9980 -9760 0 0 {name=X_78889_ }
C {devices/lab_pin.sym} 9940 -9630 0 0 {name=p9853 lab=clkbuf_7_91_0_CLK/X }
C {devices/lab_pin.sym} 10020 -9630 0 1 {name=p9854 lab=clkbuf_9_365_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 9980 -9630 0 0 {name=Xclkbuf_8_182_0_CLK }
C {devices/lab_pin.sym} 9900 -9530 0 0 {name=p9855 lab=_49805_/Y }
C {devices/lab_pin.sym} 9900 -9490 0 0 {name=p9856 lab=_49787_/X }
C {devices/lab_pin.sym} 9900 -9450 0 0 {name=p9857 lab=_49807_/X }
C {devices/lab_pin.sym} 10060 -9490 0 1 {name=p9858 lab=_49808_/Y }
C {sky130_stdcells/a21oi_4.sym} 9980 -9490 0 0 {name=X_49808_ }
C {devices/lab_pin.sym} 9890 -9350 0 0 {name=p9859 lab=_84105_/CLK }
C {devices/lab_pin.sym} 9890 -9330 0 0 {name=p9860 lab=_84096_/Q }
C {devices/lab_pin.sym} 10070 -9350 0 1 {name=p9861 lab=_80920_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -9340 0 0 {name=X_80920_ }
C {devices/lab_pin.sym} 9900 -9240 0 0 {name=p9862 lab=_41922_/A }
C {devices/lab_pin.sym} 9900 -9200 0 0 {name=p9863 lab=_68640_/X }
C {devices/lab_pin.sym} 9900 -9160 0 0 {name=p9864 lab=_68439_/X }
C {devices/lab_pin.sym} 9900 -9120 0 0 {name=p9865 lab=_68641_/Y }
C {devices/lab_pin.sym} 10060 -9180 0 1 {name=p9866 lab=_68642_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -9180 0 0 {name=X_68642_ }
C {devices/lab_pin.sym} 9900 -9050 0 0 {name=p9867 lab=_65789_/X }
C {devices/lab_pin.sym} 9900 -9010 0 0 {name=p9868 lab=_65333_/Y }
C {devices/lab_pin.sym} 9900 -8970 0 0 {name=p9869 lab=_65853_/Y }
C {devices/lab_pin.sym} 10060 -9010 0 1 {name=p9870 lab=_65854_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -9010 0 0 {name=X_65854_ }
C {devices/lab_pin.sym} 9900 -8900 0 0 {name=p9871 lab=_64678_/X }
C {devices/lab_pin.sym} 9900 -8860 0 0 {name=p9872 lab=_85562_/Q }
C {devices/lab_pin.sym} 9900 -8820 0 0 {name=p9873 lab=_64679_/X }
C {devices/lab_pin.sym} 9900 -8780 0 0 {name=p9874 lab=_64804_/X }
C {devices/lab_pin.sym} 10060 -8840 0 1 {name=p9875 lab=_64805_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -8840 0 0 {name=X_64805_ }
C {devices/lab_pin.sym} 9920 -8720 0 0 {name=p9876 lab=_49751_/A }
C {devices/lab_pin.sym} 9920 -8680 0 0 {name=p9877 lab=_49724_/B }
C {devices/lab_pin.sym} 9920 -8640 0 0 {name=p9878 lab=_49761_/C }
C {devices/lab_pin.sym} 9920 -8600 0 0 {name=p9879 lab=_52954_/D }
C {devices/lab_pin.sym} 10040 -8660 0 1 {name=p9880 lab=_49739_/X }
C {sky130_stdcells/and4_4.sym} 9980 -8660 0 0 {name=X_49739_ }
C {devices/lab_pin.sym} 9890 -8510 0 0 {name=p9881 lab=_80792_/CLK }
C {devices/lab_pin.sym} 9890 -8490 0 0 {name=p9882 lab=_80851_/D }
C {devices/lab_pin.sym} 10070 -8510 0 1 {name=p9883 lab=_74965_/B }
C {sky130_stdcells/dfxtp_4.sym} 9980 -8500 0 0 {name=X_80851_ }
C {devices/lab_pin.sym} 9900 -8400 0 0 {name=p9884 lab=_44691_/A }
C {devices/lab_pin.sym} 9900 -8360 0 0 {name=p9885 lab=_68570_/X }
C {devices/lab_pin.sym} 9900 -8320 0 0 {name=p9886 lab=_68571_/X }
C {devices/lab_pin.sym} 9900 -8280 0 0 {name=p9887 lab=_68572_/X }
C {devices/lab_pin.sym} 10060 -8340 0 1 {name=p9888 lab=_68573_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -8340 0 0 {name=X_68573_ }
C {devices/lab_pin.sym} 9920 -8210 0 0 {name=p9889 lab=_65781_/X }
C {devices/lab_pin.sym} 9920 -8170 0 0 {name=p9890 lab=_65725_/B }
C {devices/lab_pin.sym} 9920 -8130 0 0 {name=p9891 lab=_65784_/X }
C {devices/lab_pin.sym} 10040 -8170 0 1 {name=p9892 lab=_65785_/Y }
C {sky130_stdcells/nand3_4.sym} 9980 -8170 0 0 {name=X_65785_ }
C {devices/lab_pin.sym} 9900 -8060 0 0 {name=p9893 lab=_59478_/A }
C {devices/lab_pin.sym} 9900 -8020 0 0 {name=p9894 lab=_60571_/B }
C {devices/lab_pin.sym} 9900 -7980 0 0 {name=p9895 lab=_61298_/B }
C {devices/lab_pin.sym} 9900 -7940 0 0 {name=p9896 lab=_60608_/A }
C {devices/lab_pin.sym} 10060 -8000 0 1 {name=p9897 lab=_62997_/X }
C {sky130_stdcells/a2bb2o_4.sym} 9980 -8000 0 0 {name=X_62997_ }
C {devices/lab_pin.sym} 9940 -7850 0 0 {name=p9898 lab=clkbuf_7_57_0_CLK/A }
C {devices/lab_pin.sym} 10020 -7850 0 1 {name=p9899 lab=clkbuf_7_57_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 9980 -7850 0 0 {name=Xclkbuf_7_57_0_CLK }
C {devices/lab_pin.sym} 9940 -7730 0 0 {name=p9900 lab=_67997_/A }
C {devices/lab_pin.sym} 10020 -7730 0 1 {name=p9901 lab=_67524_/X }
C {sky130_stdcells/buf_2.sym} 9980 -7730 0 0 {name=X_67524_ }
C {devices/lab_pin.sym} 9920 -7640 0 0 {name=p9902 lab=_52729_/X }
C {devices/lab_pin.sym} 9920 -7600 0 0 {name=p9903 lab=_52746_/B }
C {devices/lab_pin.sym} 9920 -7560 0 0 {name=p9904 lab=_52746_/C }
C {devices/lab_pin.sym} 9920 -7520 0 0 {name=p9905 lab=_52750_/D }
C {devices/lab_pin.sym} 10040 -7580 0 1 {name=p9906 lab=_52750_/X }
C {sky130_stdcells/and4_4.sym} 9980 -7580 0 0 {name=X_52750_ }
C {devices/lab_pin.sym} 9920 -7450 0 0 {name=p9907 lab=_64730_/X }
C {devices/lab_pin.sym} 9920 -7410 0 0 {name=p9908 lab=_64761_/B }
C {devices/lab_pin.sym} 9920 -7370 0 0 {name=p9909 lab=_64735_/X }
C {devices/lab_pin.sym} 10040 -7410 0 1 {name=p9910 lab=_64736_/Y }
C {sky130_stdcells/nand3_4.sym} 9980 -7410 0 0 {name=X_64736_ }
C {devices/lab_pin.sym} 9890 -7270 0 0 {name=p9911 lab=_86505_/CLK }
C {devices/lab_pin.sym} 9890 -7250 0 0 {name=p9912 lab=_71214_/Y }
C {devices/lab_pin.sym} 10070 -7270 0 1 {name=p9913 lab=_48614_/A }
C {sky130_stdcells/dfxtp_4.sym} 9980 -7260 0 0 {name=X_83570_ }
C {devices/lab_pin.sym} 9940 -7130 0 0 {name=p9914 lab=_61948_/A }
C {devices/lab_pin.sym} 10020 -7130 0 1 {name=p9915 lab=_61948_/X }
C {sky130_stdcells/buf_2.sym} 9980 -7130 0 0 {name=X_61948_ }
C {devices/lab_pin.sym} 9890 -7010 0 0 {name=p9916 lab=_80784_/CLK }
C {devices/lab_pin.sym} 9890 -6990 0 0 {name=p9917 lab=_80782_/D }
C {devices/lab_pin.sym} 10070 -7010 0 1 {name=p9918 lab=_80782_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -7000 0 0 {name=X_80782_ }
C {devices/lab_pin.sym} 9940 -6870 0 0 {name=p9919 lab=clkbuf_7_98_0_CLK/X }
C {devices/lab_pin.sym} 10020 -6870 0 1 {name=p9920 lab=clkbuf_9_395_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 9980 -6870 0 0 {name=Xclkbuf_8_197_0_CLK }
C {devices/lab_pin.sym} 9940 -6750 0 0 {name=p9921 lab=clkbuf_9_96_0_CLK/X }
C {devices/lab_pin.sym} 10020 -6750 0 1 {name=p9922 lab=_83753_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9980 -6750 0 0 {name=Xclkbuf_10_192_0_CLK }
C {devices/lab_pin.sym} 9940 -6630 0 0 {name=p9923 lab=_50219_/X }
C {devices/lab_pin.sym} 10020 -6630 0 1 {name=p9924 lab=_51701_/X }
C {sky130_stdcells/buf_2.sym} 9980 -6630 0 0 {name=X_51701_ }
C {devices/lab_pin.sym} 9890 -6510 0 0 {name=p9925 lab=_82617_/CLK }
C {devices/lab_pin.sym} 9890 -6490 0 0 {name=p9926 lab=_79023_/Y }
C {devices/lab_pin.sym} 10070 -6510 0 1 {name=p9927 lab=_82521_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -6500 0 0 {name=X_82521_ }
C {devices/lab_pin.sym} 9900 -6390 0 0 {name=p9928 lab=_67452_/X }
C {devices/lab_pin.sym} 9900 -6350 0 0 {name=p9929 lab=_67454_/X }
C {devices/lab_pin.sym} 9900 -6310 0 0 {name=p9930 lab=_67383_/X }
C {devices/lab_pin.sym} 10060 -6350 0 1 {name=p9931 lab=_67455_/X }
C {sky130_stdcells/a21o_4.sym} 9980 -6350 0 0 {name=X_67455_ }
C {devices/lab_pin.sym} 9920 -6240 0 0 {name=p9932 lab=_52674_/X }
C {devices/lab_pin.sym} 9920 -6200 0 0 {name=p9933 lab=_52661_/B }
C {devices/lab_pin.sym} 9920 -6160 0 0 {name=p9934 lab=_52694_/C }
C {devices/lab_pin.sym} 9920 -6120 0 0 {name=p9935 lab=_52681_/D }
C {devices/lab_pin.sym} 10040 -6180 0 1 {name=p9936 lab=_52681_/X }
C {sky130_stdcells/and4_4.sym} 9980 -6180 0 0 {name=X_52681_ }
C {devices/lab_pin.sym} 9940 -6030 0 0 {name=p9937 lab=_64667_/A }
C {devices/lab_pin.sym} 10020 -6030 0 1 {name=p9938 lab=_64767_/A }
C {sky130_stdcells/buf_2.sym} 9980 -6030 0 0 {name=X_64667_ }
C {devices/lab_pin.sym} 9920 -5940 0 0 {name=p9939 lab=_61879_/A }
C {devices/lab_pin.sym} 9920 -5900 0 0 {name=p9940 lab=_61879_/B }
C {devices/lab_pin.sym} 9920 -5860 0 0 {name=p9941 lab=_61875_/Y }
C {devices/lab_pin.sym} 9920 -5820 0 0 {name=p9942 lab=_61879_/D }
C {devices/lab_pin.sym} 10040 -5880 0 1 {name=p9943 lab=_61879_/Y }
C {sky130_stdcells/nand4_4.sym} 9980 -5880 0 0 {name=X_61879_ }
C {devices/lab_pin.sym} 9900 -5750 0 0 {name=p9944 lab=_85445_/Q }
C {devices/lab_pin.sym} 9900 -5710 0 0 {name=p9945 lab=_54404_/X }
C {devices/lab_pin.sym} 9900 -5670 0 0 {name=p9946 lab=_54419_/Y }
C {devices/lab_pin.sym} 10060 -5710 0 1 {name=p9947 lab=_54420_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -5710 0 0 {name=X_54420_ }
C {devices/lab_pin.sym} 9940 -5570 0 0 {name=p9948 lab=_84129_/Q }
C {devices/lab_pin.sym} 10020 -5570 0 1 {name=p9949 lab=_66407_/C }
C {sky130_stdcells/inv_2.sym} 9980 -5570 0 0 {name=X_66406_ }
C {devices/lab_pin.sym} 9890 -5450 0 0 {name=p9950 lab=_85269_/CLK }
C {devices/lab_pin.sym} 9890 -5430 0 0 {name=p9951 lab=_85240_/D }
C {devices/lab_pin.sym} 10070 -5450 0 1 {name=p9952 lab=_55908_/B }
C {sky130_stdcells/dfxtp_4.sym} 9980 -5440 0 0 {name=X_85240_ }
C {devices/lab_pin.sym} 9920 -5320 0 0 {name=p9953 lab=_51627_/A }
C {devices/lab_pin.sym} 9920 -5280 0 0 {name=p9954 lab=_53157_/B }
C {devices/lab_pin.sym} 10040 -5300 0 1 {name=p9955 lab=_51632_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -5300 0 0 {name=X_51632_ }
C {devices/lab_pin.sym} 9900 -5210 0 0 {name=p9956 lab=_64454_/A }
C {devices/lab_pin.sym} 9900 -5170 0 0 {name=p9957 lab=_60732_/C }
C {devices/lab_pin.sym} 9900 -5130 0 0 {name=p9958 lab=_60739_/X }
C {devices/lab_pin.sym} 9900 -5090 0 0 {name=p9959 lab=_58490_/A }
C {devices/lab_pin.sym} 9900 -5050 0 0 {name=p9960 lab=_60704_/Y }
C {devices/lab_pin.sym} 10060 -5130 0 1 {name=p9961 lab=_63618_/Y }
C {sky130_stdcells/o32ai_4.sym} 9980 -5130 0 0 {name=X_63618_ }
C {devices/lab_pin.sym} 9890 -4970 0 0 {name=p9962 lab=_82452_/CLK }
C {devices/lab_pin.sym} 9890 -4950 0 0 {name=p9963 lab=_79144_/X }
C {devices/lab_pin.sym} 10070 -4970 0 1 {name=p9964 lab=_82452_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -4960 0 0 {name=X_82452_ }
C {devices/lab_pin.sym} 9900 -4860 0 0 {name=p9965 lab=_87165_/Q }
C {devices/lab_pin.sym} 9900 -4820 0 0 {name=p9966 lab=_67311_/X }
C {devices/lab_pin.sym} 9900 -4780 0 0 {name=p9967 lab=_67313_/X }
C {devices/lab_pin.sym} 9900 -4740 0 0 {name=p9968 lab=_67385_/X }
C {devices/lab_pin.sym} 10060 -4800 0 1 {name=p9969 lab=_67386_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -4800 0 0 {name=X_67386_ }
C {devices/lab_pin.sym} 9940 -4650 0 0 {name=p9970 lab=_64678_/A }
C {devices/lab_pin.sym} 10020 -4650 0 1 {name=p9971 lab=_64598_/X }
C {sky130_stdcells/buf_2.sym} 9980 -4650 0 0 {name=X_64598_ }
C {devices/lab_pin.sym} 9940 -4530 0 0 {name=p9972 lab=clkbuf_7_60_0_CLK/X }
C {devices/lab_pin.sym} 10020 -4530 0 1 {name=p9973 lab=clkbuf_8_120_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 9980 -4530 0 0 {name=Xclkbuf_8_120_0_CLK }
C {devices/lab_pin.sym} 9890 -4410 0 0 {name=p9974 lab=_81352_/CLK }
C {devices/lab_pin.sym} 9890 -4390 0 0 {name=p9975 lab=_83939_/Q }
C {devices/lab_pin.sym} 10070 -4410 0 1 {name=p9976 lab=_76728_/B }
C {sky130_stdcells/dfxtp_4.sym} 9980 -4400 0 0 {name=X_81403_ }
C {devices/lab_pin.sym} 9920 -4280 0 0 {name=p9977 lab=_69236_/A }
C {devices/lab_pin.sym} 9920 -4240 0 0 {name=p9978 lab=_69125_/B }
C {devices/lab_pin.sym} 10040 -4260 0 1 {name=p9979 lab=_69125_/X }
C {sky130_stdcells/and2_4.sym} 9980 -4260 0 0 {name=X_69125_ }
C {devices/lab_pin.sym} 9920 -4140 0 0 {name=p9980 lab=_54355_/A }
C {devices/lab_pin.sym} 9920 -4100 0 0 {name=p9981 lab=_52658_/B }
C {devices/lab_pin.sym} 10040 -4120 0 1 {name=p9982 lab=_54351_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -4120 0 0 {name=X_54351_ }
C {devices/lab_pin.sym} 9900 -4020 0 0 {name=p9983 lab=_64971_/X }
C {devices/lab_pin.sym} 9900 -3980 0 0 {name=p9984 lab=_85603_/Q }
C {devices/lab_pin.sym} 9900 -3940 0 0 {name=p9985 lab=_44261_/X }
C {devices/lab_pin.sym} 9900 -3900 0 0 {name=p9986 lab=_66336_/X }
C {devices/lab_pin.sym} 10060 -3960 0 1 {name=p9987 lab=_66337_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -3960 0 0 {name=X_66337_ }
C {devices/lab_pin.sym} 9890 -3810 0 0 {name=p9988 lab=_85297_/CLK }
C {devices/lab_pin.sym} 9890 -3790 0 0 {name=p9989 lab=_85171_/D }
C {devices/lab_pin.sym} 10070 -3810 0 1 {name=p9990 lab=_55857_/B }
C {sky130_stdcells/dfxtp_4.sym} 9980 -3800 0 0 {name=X_85171_ }
C {devices/lab_pin.sym} 9920 -3700 0 0 {name=p9991 lab=_51553_/A }
C {devices/lab_pin.sym} 9920 -3660 0 0 {name=p9992 lab=_51580_/B }
C {devices/lab_pin.sym} 9920 -3620 0 0 {name=p9993 lab=_51553_/C }
C {devices/lab_pin.sym} 9920 -3580 0 0 {name=p9994 lab=_53090_/D }
C {devices/lab_pin.sym} 10040 -3640 0 1 {name=p9995 lab=_51563_/X }
C {sky130_stdcells/and4_4.sym} 9980 -3640 0 0 {name=X_51563_ }
C {devices/lab_pin.sym} 9920 -3500 0 0 {name=p9996 lab=_63523_/A }
C {devices/lab_pin.sym} 9920 -3460 0 0 {name=p9997 lab=_61969_/X }
C {devices/lab_pin.sym} 10040 -3480 0 1 {name=p9998 lab=_63549_/X }
C {sky130_stdcells/and2_4.sym} 9980 -3480 0 0 {name=X_63549_ }
C {devices/lab_pin.sym} 9890 -3350 0 0 {name=p9999 lab=_83703_/CLK }
C {devices/lab_pin.sym} 9890 -3330 0 0 {name=p10000 lab=_82191_/Q }
C {devices/lab_pin.sym} 10070 -3350 0 1 {name=p10001 lab=_47092_/A }
C {sky130_stdcells/dfxtp_4.sym} 9980 -3340 0 0 {name=X_82383_ }
C {devices/lab_pin.sym} 9940 -3210 0 0 {name=p10002 lab=_53302_/A }
C {devices/lab_pin.sym} 10020 -3210 0 1 {name=p10003 lab=_53302_/X }
C {sky130_stdcells/buf_2.sym} 9980 -3210 0 0 {name=X_53302_ }
C {devices/lab_pin.sym} 9890 -3090 0 0 {name=p10004 lab=_84220_/CLK }
C {devices/lab_pin.sym} 9890 -3070 0 0 {name=p10005 lab=_66446_/X }
C {devices/lab_pin.sym} 10070 -3090 0 1 {name=p10006 lab=_84122_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9980 -3080 0 0 {name=X_84122_ }
C {devices/lab_pin.sym} 9900 -2970 0 0 {name=p10007 lab=_86186_/Q }
C {devices/lab_pin.sym} 9900 -2930 0 0 {name=p10008 lab=_50506_/X }
C {devices/lab_pin.sym} 9900 -2890 0 0 {name=p10009 lab=_50513_/Y }
C {devices/lab_pin.sym} 10060 -2930 0 1 {name=p10010 lab=_50514_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -2930 0 0 {name=X_50514_ }
C {devices/lab_pin.sym} 9890 -2790 0 0 {name=p10011 lab=_81352_/CLK }
C {devices/lab_pin.sym} 9890 -2770 0 0 {name=p10012 lab=_76449_/X }
C {devices/lab_pin.sym} 10070 -2790 0 1 {name=p10013 lab=_81710_/D }
C {sky130_stdcells/dfxtp_4.sym} 9980 -2780 0 0 {name=X_81334_ }
C {devices/lab_pin.sym} 9900 -2680 0 0 {name=p10014 lab=_56971_/C }
C {devices/lab_pin.sym} 9900 -2640 0 0 {name=p10015 lab=_56971_/B }
C {devices/lab_pin.sym} 9900 -2600 0 0 {name=p10016 lab=_56995_/X }
C {devices/lab_pin.sym} 9900 -2560 0 0 {name=p10017 lab=_57069_/Y }
C {devices/lab_pin.sym} 10060 -2620 0 1 {name=p10018 lab=_57070_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -2620 0 0 {name=X_57070_ }
C {devices/lab_pin.sym} 9900 -2500 0 0 {name=p10019 lab=_74206_/A }
C {devices/lab_pin.sym} 9900 -2460 0 0 {name=p10020 lab=_68989_/X }
C {devices/lab_pin.sym} 9900 -2420 0 0 {name=p10021 lab=_69010_/X }
C {devices/lab_pin.sym} 9900 -2380 0 0 {name=p10022 lab=_69055_/Y }
C {devices/lab_pin.sym} 10060 -2440 0 1 {name=p10023 lab=_69056_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -2440 0 0 {name=X_69056_ }
C {devices/lab_pin.sym} 9900 -2310 0 0 {name=p10024 lab=_85470_/Q }
C {devices/lab_pin.sym} 9900 -2270 0 0 {name=p10025 lab=_54266_/X }
C {devices/lab_pin.sym} 9900 -2230 0 0 {name=p10026 lab=_54281_/Y }
C {devices/lab_pin.sym} 10060 -2270 0 1 {name=p10027 lab=_54282_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -2270 0 0 {name=X_54282_ }
C {devices/lab_pin.sym} 9920 -2140 0 0 {name=p10028 lab=_66267_/X }
C {devices/lab_pin.sym} 9920 -2100 0 0 {name=p10029 lab=_85896_/Q }
C {devices/lab_pin.sym} 10040 -2120 0 1 {name=p10030 lab=_66268_/X }
C {sky130_stdcells/and2_4.sym} 9980 -2120 0 0 {name=X_66268_ }
C {devices/lab_pin.sym} 9920 -2020 0 0 {name=p10031 lab=_51509_/A }
C {devices/lab_pin.sym} 9920 -1980 0 0 {name=p10032 lab=_51494_/B }
C {devices/lab_pin.sym} 9920 -1940 0 0 {name=p10033 lab=_51494_/C }
C {devices/lab_pin.sym} 9920 -1900 0 0 {name=p10034 lab=_53019_/D }
C {devices/lab_pin.sym} 10040 -1960 0 1 {name=p10035 lab=_51494_/X }
C {sky130_stdcells/and4_4.sym} 9980 -1960 0 0 {name=X_51494_ }
C {devices/lab_pin.sym} 9940 -1810 0 0 {name=p10036 lab=_55686_/Y }
C {devices/lab_pin.sym} 10020 -1810 0 1 {name=p10037 lab=_56142_/A }
C {sky130_stdcells/buf_2.sym} 9980 -1810 0 0 {name=X_56021_ }
C {devices/lab_pin.sym} 9920 -1700 0 0 {name=p10038 lab=_68028_/A }
C {devices/lab_pin.sym} 9920 -1660 0 0 {name=p10039 lab=_87639_/Q }
C {devices/lab_pin.sym} 10040 -1680 0 1 {name=p10040 lab=_68007_/X }
C {sky130_stdcells/and2_4.sym} 9980 -1680 0 0 {name=X_68007_ }
C {devices/lab_pin.sym} 9900 -1570 0 0 {name=p10041 lab=_85672_/Q }
C {devices/lab_pin.sym} 9900 -1530 0 0 {name=p10042 lab=_53225_/X }
C {devices/lab_pin.sym} 9900 -1490 0 0 {name=p10043 lab=_53232_/Y }
C {devices/lab_pin.sym} 10060 -1530 0 1 {name=p10044 lab=_53233_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -1530 0 0 {name=X_53233_ }
C {devices/lab_pin.sym} 9900 -1410 0 0 {name=p10045 lab=_65198_/X }
C {devices/lab_pin.sym} 9900 -1370 0 0 {name=p10046 lab=_65208_/Y }
C {devices/lab_pin.sym} 9900 -1330 0 0 {name=p10047 lab=_65218_/Y }
C {devices/lab_pin.sym} 10060 -1370 0 1 {name=p10048 lab=_65219_/Y }
C {sky130_stdcells/o21ai_4.sym} 9980 -1370 0 0 {name=X_65219_ }
C {devices/lab_pin.sym} 9890 -1230 0 0 {name=p10049 lab=_81431_/CLK }
C {devices/lab_pin.sym} 9890 -1210 0 0 {name=p10050 lab=_84053_/D }
C {devices/lab_pin.sym} 10070 -1230 0 1 {name=p10051 lab=_81485_/D }
C {sky130_stdcells/dfxtp_4.sym} 9980 -1220 0 0 {name=X_84053_ }
C {devices/lab_pin.sym} 9920 -1100 0 0 {name=p10052 lab=_50439_/X }
C {devices/lab_pin.sym} 9920 -1060 0 0 {name=p10053 lab=_48763_/B }
C {devices/lab_pin.sym} 10040 -1080 0 1 {name=p10054 lab=_50445_/Y }
C {sky130_stdcells/nand2_4.sym} 9980 -1080 0 0 {name=X_50445_ }
C {devices/lab_pin.sym} 9890 -950 0 0 {name=p10055 lab=_81265_/CLK }
C {devices/lab_pin.sym} 9890 -930 0 0 {name=p10056 lab=_81265_/D }
C {devices/lab_pin.sym} 10070 -950 0 1 {name=p10057 lab=_76366_/A }
C {sky130_stdcells/dfxtp_4.sym} 9980 -940 0 0 {name=X_81265_ }
C {devices/lab_pin.sym} 9900 -840 0 0 {name=p10058 lab=_57947_/A }
C {devices/lab_pin.sym} 9900 -800 0 0 {name=p10059 lab=_85613_/Q }
C {devices/lab_pin.sym} 9900 -760 0 0 {name=p10060 lab=_65301_/X }
C {devices/lab_pin.sym} 9900 -720 0 0 {name=p10061 lab=_66198_/X }
C {devices/lab_pin.sym} 10060 -780 0 1 {name=p10062 lab=_66199_/X }
C {sky130_stdcells/a211o_4.sym} 9980 -780 0 0 {name=X_66199_ }
C {devices/lab_pin.sym} 10860 -42150 0 0 {name=p10063 lab=clkbuf_7_67_0_CLK/X }
C {devices/lab_pin.sym} 10940 -42150 0 1 {name=p10064 lab=clkbuf_9_271_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 10900 -42150 0 0 {name=Xclkbuf_8_135_0_CLK }
C {devices/lab_pin.sym} 10860 -42030 0 0 {name=p10065 lab=clkbuf_9_65_0_CLK/X }
C {devices/lab_pin.sym} 10940 -42030 0 1 {name=p10066 lab=_81615_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 10900 -42030 0 0 {name=Xclkbuf_10_130_0_CLK }
C {devices/lab_pin.sym} 10810 -41910 0 0 {name=p10067 lab=_85050_/CLK }
C {devices/lab_pin.sym} 10810 -41890 0 0 {name=p10068 lab=_83004_/D }
C {devices/lab_pin.sym} 10990 -41910 0 1 {name=p10069 lab=_45479_/A }
C {sky130_stdcells/dfxtp_4.sym} 10900 -41900 0 0 {name=X_83004_ }
C {devices/lab_pin.sym} 10840 -41780 0 0 {name=p10070 lab=_80216_/A }
C {devices/lab_pin.sym} 10840 -41740 0 0 {name=p10071 lab=_80215_/X }
C {devices/lab_pin.sym} 10960 -41760 0 1 {name=p10072 lab=_80216_/Y }
C {sky130_stdcells/xnor2_4.sym} 10900 -41760 0 0 {name=X_80216_ }
C {devices/lab_pin.sym} 10860 -41630 0 0 {name=p10073 lab=_53190_/A }
C {devices/lab_pin.sym} 10940 -41630 0 1 {name=p10074 lab=_53181_/A }
C {sky130_stdcells/buf_2.sym} 10900 -41630 0 0 {name=X_53164_ }
C {devices/lab_pin.sym} 10840 -41520 0 0 {name=p10075 lab=_50381_/A }
C {devices/lab_pin.sym} 10840 -41480 0 0 {name=p10076 lab=_52079_/B }
C {devices/lab_pin.sym} 10960 -41500 0 1 {name=p10077 lab=_50376_/Y }
C {sky130_stdcells/nand2_4.sym} 10900 -41500 0 0 {name=X_50376_ }
C {devices/lab_pin.sym} 10810 -41370 0 0 {name=p10078 lab=_83974_/CLK }
C {devices/lab_pin.sym} 10810 -41350 0 0 {name=p10079 lab=_74969_/X }
C {devices/lab_pin.sym} 10990 -41370 0 1 {name=p10080 lab=_81196_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -41360 0 0 {name=X_81196_ }
C {devices/lab_pin.sym} 10860 -41230 0 0 {name=p10081 lab=clkbuf_9_380_0_CLK/X }
C {devices/lab_pin.sym} 10940 -41230 0 1 {name=p10082 lab=_87776_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 10900 -41230 0 0 {name=Xclkbuf_10_760_0_CLK }
C {devices/lab_pin.sym} 10840 -41120 0 0 {name=p10083 lab=_52121_/A }
C {devices/lab_pin.sym} 10840 -41080 0 0 {name=p10084 lab=_48401_/B }
C {devices/lab_pin.sym} 10960 -41100 0 1 {name=p10085 lab=_52115_/Y }
C {sky130_stdcells/nand2_4.sym} 10900 -41100 0 0 {name=X_52115_ }
C {devices/lab_pin.sym} 10810 -40970 0 0 {name=p10086 lab=_87820_/CLK }
C {devices/lab_pin.sym} 10810 -40950 0 0 {name=p10087 lab=_42584_/Y }
C {devices/lab_pin.sym} 10990 -40970 0 1 {name=p10088 lab=_42583_/A }
C {sky130_stdcells/dfxtp_4.sym} 10900 -40960 0 0 {name=X_87812_ }
C {devices/lab_pin.sym} 10840 -40840 0 0 {name=p10089 lab=_80131_/Y }
C {devices/lab_pin.sym} 10840 -40800 0 0 {name=p10090 lab=_80134_/Y }
C {devices/lab_pin.sym} 10960 -40820 0 1 {name=p10091 lab=_80147_/X }
C {sky130_stdcells/or2_4.sym} 10900 -40820 0 0 {name=X_80147_ }
C {devices/lab_pin.sym} 10840 -40700 0 0 {name=p10092 lab=_53115_/A }
C {devices/lab_pin.sym} 10840 -40660 0 0 {name=p10093 lab=_53095_/B }
C {devices/lab_pin.sym} 10960 -40680 0 1 {name=p10094 lab=_53095_/Y }
C {sky130_stdcells/nand2_4.sym} 10900 -40680 0 0 {name=X_53095_ }
C {devices/lab_pin.sym} 10840 -40560 0 0 {name=p10095 lab=_86639_/Q }
C {devices/lab_pin.sym} 10840 -40520 0 0 {name=p10096 lab=_58039_/B }
C {devices/lab_pin.sym} 10960 -40540 0 1 {name=p10097 lab=_57972_/Y }
C {sky130_stdcells/nor2_4.sym} 10900 -40540 0 0 {name=X_57972_ }
C {devices/lab_pin.sym} 10840 -40420 0 0 {name=p10098 lab=_69958_/A }
C {devices/lab_pin.sym} 10840 -40380 0 0 {name=p10099 lab=_69958_/B }
C {devices/lab_pin.sym} 10960 -40400 0 1 {name=p10100 lab=_69958_/Y }
C {sky130_stdcells/nor2_4.sym} 10900 -40400 0 0 {name=X_69958_ }
C {devices/lab_pin.sym} 10860 -40270 0 0 {name=p10101 lab=clkbuf_9_251_0_CLK/A }
C {devices/lab_pin.sym} 10940 -40270 0 1 {name=p10102 lab=clkbuf_9_251_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 10900 -40270 0 0 {name=Xclkbuf_9_251_0_CLK }
C {devices/lab_pin.sym} 10840 -40170 0 0 {name=p10103 lab=_59696_/A }
C {devices/lab_pin.sym} 10840 -40130 0 0 {name=p10104 lab=_59711_/B }
C {devices/lab_pin.sym} 10840 -40090 0 0 {name=p10105 lab=_80579_/A }
C {devices/lab_pin.sym} 10960 -40130 0 1 {name=p10106 lab=_59711_/Y }
C {sky130_stdcells/nor3_4.sym} 10900 -40130 0 0 {name=X_59711_ }
C {devices/lab_pin.sym} 10820 -40010 0 0 {name=p10107 lab=_52044_/Y }
C {devices/lab_pin.sym} 10820 -39970 0 0 {name=p10108 lab=_52022_/X }
C {devices/lab_pin.sym} 10820 -39930 0 0 {name=p10109 lab=_52045_/Y }
C {devices/lab_pin.sym} 10980 -39970 0 1 {name=p10110 lab=_85900_/D }
C {sky130_stdcells/a21boi_4.sym} 10900 -39970 0 0 {name=X_52046_ }
C {devices/lab_pin.sym} 10840 -39840 0 0 {name=p10111 lab=_44282_/X }
C {devices/lab_pin.sym} 10840 -39800 0 0 {name=p10112 lab=_56922_/X }
C {devices/lab_pin.sym} 10960 -39820 0 1 {name=p10113 lab=_56923_/Y }
C {sky130_stdcells/nand2_4.sym} 10900 -39820 0 0 {name=X_56923_ }
C {devices/lab_pin.sym} 10820 -39720 0 0 {name=p10114 lab=_87581_/Q }
C {devices/lab_pin.sym} 10820 -39680 0 0 {name=p10115 lab=_66538_/X }
C {devices/lab_pin.sym} 10820 -39640 0 0 {name=p10116 lab=_66540_/X }
C {devices/lab_pin.sym} 10820 -39600 0 0 {name=p10117 lab=_68908_/X }
C {devices/lab_pin.sym} 10980 -39660 0 1 {name=p10118 lab=_68909_/X }
C {sky130_stdcells/a211o_4.sym} 10900 -39660 0 0 {name=X_68909_ }
C {devices/lab_pin.sym} 10810 -39510 0 0 {name=p10119 lab=_87748_/CLK }
C {devices/lab_pin.sym} 10810 -39490 0 0 {name=p10120 lab=_87743_/D }
C {devices/lab_pin.sym} 10990 -39510 0 1 {name=p10121 lab=_68868_/B }
C {sky130_stdcells/dfxtp_4.sym} 10900 -39500 0 0 {name=X_87743_ }
C {devices/lab_pin.sym} 10840 -39380 0 0 {name=p10122 lab=_80072_/Y }
C {devices/lab_pin.sym} 10840 -39340 0 0 {name=p10123 lab=_80077_/Y }
C {devices/lab_pin.sym} 10960 -39360 0 1 {name=p10124 lab=_80078_/X }
C {sky130_stdcells/xor2_4.sym} 10900 -39360 0 0 {name=X_80078_ }
C {devices/lab_pin.sym} 10810 -39230 0 0 {name=p10125 lab=_84714_/CLK }
C {devices/lab_pin.sym} 10810 -39210 0 0 {name=p10126 lab=_84955_/D }
C {devices/lab_pin.sym} 10990 -39230 0 1 {name=p10127 lab=_84955_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -39220 0 0 {name=X_84955_ }
C {devices/lab_pin.sym} 10820 -39120 0 0 {name=p10128 lab=_73370_/A }
C {devices/lab_pin.sym} 10820 -39080 0 0 {name=p10129 lab=_69796_/X }
C {devices/lab_pin.sym} 10820 -39040 0 0 {name=p10130 lab=_69797_/X }
C {devices/lab_pin.sym} 10820 -39000 0 0 {name=p10131 lab=_69888_/X }
C {devices/lab_pin.sym} 10980 -39060 0 1 {name=p10132 lab=_69889_/X }
C {sky130_stdcells/a211o_4.sym} 10900 -39060 0 0 {name=X_69889_ }
C {devices/lab_pin.sym} 10860 -38910 0 0 {name=p10133 lab=clkbuf_9_72_0_CLK/X }
C {devices/lab_pin.sym} 10940 -38910 0 1 {name=p10134 lab=_83184_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 10900 -38910 0 0 {name=Xclkbuf_10_145_0_CLK }
C {devices/lab_pin.sym} 10860 -38790 0 0 {name=p10135 lab=_71916_/Y }
C {devices/lab_pin.sym} 10940 -38790 0 1 {name=p10136 lab=_71920_/Y }
C {sky130_stdcells/inv_2.sym} 10900 -38790 0 0 {name=X_71920_ }
C {devices/lab_pin.sym} 10810 -38670 0 0 {name=p10137 lab=_83906_/CLK }
C {devices/lab_pin.sym} 10810 -38650 0 0 {name=p10138 lab=_83906_/D }
C {devices/lab_pin.sym} 10990 -38670 0 1 {name=p10139 lab=_81978_/D }
C {sky130_stdcells/dfxtp_4.sym} 10900 -38660 0 0 {name=X_83906_ }
C {devices/lab_pin.sym} 10840 -38560 0 0 {name=p10140 lab=_59634_/B }
C {devices/lab_pin.sym} 10840 -38520 0 0 {name=p10141 lab=_59661_/A }
C {devices/lab_pin.sym} 10840 -38480 0 0 {name=p10142 lab=_59662_/B }
C {devices/lab_pin.sym} 10840 -38440 0 0 {name=p10143 lab=_59661_/D }
C {devices/lab_pin.sym} 10960 -38500 0 1 {name=p10144 lab=_59642_/X }
C {sky130_stdcells/and4_4.sym} 10900 -38500 0 0 {name=X_59642_ }
C {devices/lab_pin.sym} 10820 -38370 0 0 {name=p10145 lab=_56852_/X }
C {devices/lab_pin.sym} 10820 -38330 0 0 {name=p10146 lab=_56853_/Y }
C {devices/lab_pin.sym} 10820 -38290 0 0 {name=p10147 lab=_44137_/A }
C {devices/lab_pin.sym} 10980 -38330 0 1 {name=p10148 lab=_56854_/X }
C {sky130_stdcells/a21o_4.sym} 10900 -38330 0 0 {name=X_56854_ }
C {devices/lab_pin.sym} 10810 -38190 0 0 {name=p10149 lab=_87675_/CLK }
C {devices/lab_pin.sym} 10810 -38170 0 0 {name=p10150 lab=_42873_/X }
C {devices/lab_pin.sym} 10990 -38190 0 1 {name=p10151 lab=_87674_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -38180 0 0 {name=X_87674_ }
C {devices/lab_pin.sym} 10860 -38050 0 0 {name=p10152 lab=clkbuf_9_387_0_CLK/X }
C {devices/lab_pin.sym} 10940 -38050 0 1 {name=p10153 lab=_82617_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 10900 -38050 0 0 {name=Xclkbuf_10_775_0_CLK }
C {devices/lab_pin.sym} 10810 -37930 0 0 {name=p10154 lab=_84886_/CLK }
C {devices/lab_pin.sym} 10810 -37910 0 0 {name=p10155 lab=_84886_/D }
C {devices/lab_pin.sym} 10990 -37930 0 1 {name=p10156 lab=_84886_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -37920 0 0 {name=X_84886_ }
C {devices/lab_pin.sym} 10840 -37800 0 0 {name=p10157 lab=_44077_/X }
C {devices/lab_pin.sym} 10840 -37760 0 0 {name=p10158 lab=_56518_/C }
C {devices/lab_pin.sym} 10960 -37780 0 1 {name=p10159 lab=_55805_/X }
C {sky130_stdcells/and2_4.sym} 10900 -37780 0 0 {name=X_55805_ }
C {devices/lab_pin.sym} 10810 -37650 0 0 {name=p10160 lab=_84922_/CLK }
C {devices/lab_pin.sym} 10810 -37630 0 0 {name=p10161 lab=_47534_/Y }
C {devices/lab_pin.sym} 10990 -37650 0 1 {name=p10162 lab=_86625_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -37640 0 0 {name=X_86625_ }
C {devices/lab_pin.sym} 10860 -37510 0 0 {name=p10163 lab=_70884_/B }
C {devices/lab_pin.sym} 10940 -37510 0 1 {name=p10164 lab=_71851_/X }
C {sky130_stdcells/buf_2.sym} 10900 -37510 0 0 {name=X_71851_ }
C {devices/lab_pin.sym} 10840 -37410 0 0 {name=p10165 lab=_59557_/A }
C {devices/lab_pin.sym} 10840 -37370 0 0 {name=p10166 lab=_59890_/B }
C {devices/lab_pin.sym} 10840 -37330 0 0 {name=p10167 lab=_59741_/C }
C {devices/lab_pin.sym} 10960 -37370 0 1 {name=p10168 lab=_59574_/A }
C {sky130_stdcells/nand3_4.sym} 10900 -37370 0 0 {name=X_59573_ }
C {devices/lab_pin.sym} 10810 -37230 0 0 {name=p10169 lab=_83835_/CLK }
C {devices/lab_pin.sym} 10810 -37210 0 0 {name=p10170 lab=_83837_/D }
C {devices/lab_pin.sym} 10990 -37230 0 1 {name=p10171 lab=_74773_/C }
C {sky130_stdcells/dfxtp_4.sym} 10900 -37220 0 0 {name=X_83837_ }
C {devices/lab_pin.sym} 10840 -37120 0 0 {name=p10172 lab=_56782_/X }
C {devices/lab_pin.sym} 10840 -37080 0 0 {name=p10173 lab=_56785_/B }
C {devices/lab_pin.sym} 10840 -37040 0 0 {name=p10174 lab=_56783_/X }
C {devices/lab_pin.sym} 10840 -37000 0 0 {name=p10175 lab=_56785_/D }
C {devices/lab_pin.sym} 10960 -37060 0 1 {name=p10176 lab=_56786_/A }
C {sky130_stdcells/and4_4.sym} 10900 -37060 0 0 {name=X_56785_ }
C {devices/lab_pin.sym} 10860 -36910 0 0 {name=p10177 lab=clkbuf_9_267_0_CLK/A }
C {devices/lab_pin.sym} 10940 -36910 0 1 {name=p10178 lab=clkbuf_9_266_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 10900 -36910 0 0 {name=Xclkbuf_9_266_0_CLK }
C {devices/lab_pin.sym} 10860 -36790 0 0 {name=p10179 lab=_53929_/A }
C {devices/lab_pin.sym} 10940 -36790 0 1 {name=p10180 lab=_53998_/A }
C {sky130_stdcells/buf_2.sym} 10900 -36790 0 0 {name=X_53997_ }
C {devices/lab_pin.sym} 10860 -36670 0 0 {name=p10181 lab=_70802_/A }
C {devices/lab_pin.sym} 10940 -36670 0 1 {name=p10182 lab=_70802_/X }
C {sky130_stdcells/buf_2.sym} 10900 -36670 0 0 {name=X_70802_ }
C {devices/lab_pin.sym} 10840 -36560 0 0 {name=p10183 lab=_63520_/B }
C {devices/lab_pin.sym} 10840 -36520 0 0 {name=p10184 lab=_58510_/X }
C {devices/lab_pin.sym} 10960 -36540 0 1 {name=p10185 lab=_58524_/Y }
C {sky130_stdcells/nor2_4.sym} 10900 -36540 0 0 {name=X_58524_ }
C {devices/lab_pin.sym} 10840 -36420 0 0 {name=p10186 lab=_55741_/A }
C {devices/lab_pin.sym} 10840 -36380 0 0 {name=p10187 lab=_55736_/B }
C {devices/lab_pin.sym} 10960 -36400 0 1 {name=p10188 lab=_55736_/X }
C {sky130_stdcells/and2_4.sym} 10900 -36400 0 0 {name=X_55736_ }
C {devices/lab_pin.sym} 10820 -36300 0 0 {name=p10189 lab=_40935_/X }
C {devices/lab_pin.sym} 10820 -36260 0 0 {name=p10190 lab=_43736_/X }
C {devices/lab_pin.sym} 10820 -36220 0 0 {name=p10191 lab=_87283_/Q }
C {devices/lab_pin.sym} 10820 -36180 0 0 {name=p10192 lab=_43737_/X }
C {devices/lab_pin.sym} 10980 -36240 0 1 {name=p10193 lab=_87283_/D }
C {sky130_stdcells/a2bb2o_4.sym} 10900 -36240 0 0 {name=X_43750_ }
C {devices/lab_pin.sym} 10860 -36090 0 0 {name=p10194 lab=_74600_/A }
C {devices/lab_pin.sym} 10940 -36090 0 1 {name=p10195 lab=_74570_/X }
C {sky130_stdcells/buf_2.sym} 10900 -36090 0 0 {name=X_74570_ }
C {devices/lab_pin.sym} 10810 -35970 0 0 {name=p10196 lab=_86560_/CLK }
C {devices/lab_pin.sym} 10810 -35950 0 0 {name=p10197 lab=_86556_/D }
C {devices/lab_pin.sym} 10990 -35970 0 1 {name=p10198 lab=_73689_/B }
C {sky130_stdcells/dfxtp_4.sym} 10900 -35960 0 0 {name=X_86556_ }
C {devices/lab_pin.sym} 10840 -35840 0 0 {name=p10199 lab=_40790_/B }
C {devices/lab_pin.sym} 10840 -35800 0 0 {name=p10200 lab=_40932_/X }
C {devices/lab_pin.sym} 10960 -35820 0 1 {name=p10201 lab=_40962_/X }
C {sky130_stdcells/or2_4.sym} 10900 -35820 0 0 {name=X_40962_ }
C {devices/lab_pin.sym} 10840 -35720 0 0 {name=p10202 lab=_52947_/X }
C {devices/lab_pin.sym} 10840 -35680 0 0 {name=p10203 lab=_52954_/B }
C {devices/lab_pin.sym} 10840 -35640 0 0 {name=p10204 lab=_52926_/X }
C {devices/lab_pin.sym} 10840 -35600 0 0 {name=p10205 lab=_52948_/D }
C {devices/lab_pin.sym} 10960 -35660 0 1 {name=p10206 lab=_52948_/X }
C {sky130_stdcells/and4_4.sym} 10900 -35660 0 0 {name=X_52948_ }
C {devices/lab_pin.sym} 10860 -35510 0 0 {name=p10207 lab=_71713_/Y }
C {devices/lab_pin.sym} 10940 -35510 0 1 {name=p10208 lab=_71783_/C }
C {sky130_stdcells/buf_2.sym} 10900 -35510 0 0 {name=X_71782_ }
C {devices/lab_pin.sym} 10810 -35390 0 0 {name=p10209 lab=_83482_/CLK }
C {devices/lab_pin.sym} 10810 -35370 0 0 {name=p10210 lab=_70471_/X }
C {devices/lab_pin.sym} 10990 -35390 0 1 {name=p10211 lab=_83768_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -35380 0 0 {name=X_83768_ }
C {devices/lab_pin.sym} 10820 -35290 0 0 {name=p10212 lab=_42687_/X }
C {devices/lab_pin.sym} 10820 -35250 0 0 {name=p10213 lab=_42688_/X }
C {devices/lab_pin.sym} 10820 -35210 0 0 {name=p10214 lab=_41116_/X }
C {devices/lab_pin.sym} 10820 -35170 0 0 {name=p10215 lab=_68343_/B }
C {devices/lab_pin.sym} 10820 -35130 0 0 {name=p10216 lab=_42700_/X }
C {devices/lab_pin.sym} 10980 -35210 0 1 {name=p10217 lab=_42701_/Y }
C {sky130_stdcells/o32ai_4.sym} 10900 -35210 0 0 {name=X_42701_ }
C {devices/lab_pin.sym} 10840 -35060 0 0 {name=p10218 lab=_73521_/A }
C {devices/lab_pin.sym} 10840 -35020 0 0 {name=p10219 lab=_73521_/B }
C {devices/lab_pin.sym} 10960 -35040 0 1 {name=p10220 lab=_73521_/Y }
C {sky130_stdcells/nand2_4.sym} 10900 -35040 0 0 {name=X_73521_ }
C {devices/lab_pin.sym} 10810 -34910 0 0 {name=p10221 lab=_85507_/CLK }
C {devices/lab_pin.sym} 10810 -34890 0 0 {name=p10222 lab=_54088_/Y }
C {devices/lab_pin.sym} 10990 -34910 0 1 {name=p10223 lab=_85507_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -34900 0 0 {name=X_85507_ }
C {devices/lab_pin.sym} 10840 -34780 0 0 {name=p10224 lab=HASH_ADDR[3] }
C {devices/lab_pin.sym} 10840 -34740 0 0 {name=p10225 lab=_70495_/A }
C {devices/lab_pin.sym} 10960 -34760 0 1 {name=p10226 lab=_70733_/Y }
C {sky130_stdcells/nor2_4.sym} 10900 -34760 0 0 {name=X_70733_ }
C {devices/lab_pin.sym} 10860 -34630 0 0 {name=p10227 lab=_84844_/Q }
C {devices/lab_pin.sym} 10940 -34630 0 1 {name=p10228 lab=_58457_/A }
C {sky130_stdcells/buf_2.sym} 10900 -34630 0 0 {name=X_58455_ }
C {devices/lab_pin.sym} 10810 -34510 0 0 {name=p10229 lab=_82715_/CLK }
C {devices/lab_pin.sym} 10810 -34490 0 0 {name=p10230 lab=_82719_/D }
C {devices/lab_pin.sym} 10990 -34510 0 1 {name=p10231 lab=_82675_/D }
C {sky130_stdcells/dfxtp_4.sym} 10900 -34500 0 0 {name=X_82719_ }
C {devices/lab_pin.sym} 10820 -34400 0 0 {name=p10232 lab=_40781_/X }
C {devices/lab_pin.sym} 10820 -34360 0 0 {name=p10233 lab=_43671_/X }
C {devices/lab_pin.sym} 10820 -34320 0 0 {name=p10234 lab=_72831_/A }
C {devices/lab_pin.sym} 10820 -34280 0 0 {name=p10235 lab=_43673_/X }
C {devices/lab_pin.sym} 10980 -34340 0 1 {name=p10236 lab=_43681_/X }
C {sky130_stdcells/a2bb2o_4.sym} 10900 -34340 0 0 {name=X_43681_ }
C {devices/lab_pin.sym} 10840 -34220 0 0 {name=p10237 lab=_55661_/X }
C {devices/lab_pin.sym} 10840 -34180 0 0 {name=p10238 lab=_55664_/Y }
C {devices/lab_pin.sym} 10840 -34140 0 0 {name=p10239 lab=_55665_/Y }
C {devices/lab_pin.sym} 10840 -34100 0 0 {name=p10240 lab=_55666_/Y }
C {devices/lab_pin.sym} 10960 -34160 0 1 {name=p10241 lab=_55676_/A }
C {sky130_stdcells/and4_4.sym} 10900 -34160 0 0 {name=X_55667_ }
C {devices/lab_pin.sym} 10810 -34010 0 0 {name=p10242 lab=_86196_/CLK }
C {devices/lab_pin.sym} 10810 -33990 0 0 {name=p10243 lab=_86487_/D }
C {devices/lab_pin.sym} 10990 -34010 0 1 {name=p10244 lab=_73042_/B }
C {sky130_stdcells/dfxtp_4.sym} 10900 -34000 0 0 {name=X_86487_ }
C {devices/lab_pin.sym} 10820 -33890 0 0 {name=p10245 lab=_40857_/X }
C {devices/lab_pin.sym} 10820 -33850 0 0 {name=p10246 lab=_82281_/Q }
C {devices/lab_pin.sym} 10820 -33810 0 0 {name=p10247 lab=_40892_/X }
C {devices/lab_pin.sym} 10980 -33850 0 1 {name=p10248 lab=_40894_/A }
C {sky130_stdcells/o21a_4.sym} 10900 -33850 0 0 {name=X_40893_ }
C {devices/lab_pin.sym} 10840 -33740 0 0 {name=p10249 lab=_52867_/A }
C {devices/lab_pin.sym} 10840 -33700 0 0 {name=p10250 lab=_52879_/B }
C {devices/lab_pin.sym} 10840 -33660 0 0 {name=p10251 lab=_52872_/C }
C {devices/lab_pin.sym} 10840 -33620 0 0 {name=p10252 lab=_52879_/D }
C {devices/lab_pin.sym} 10960 -33680 0 1 {name=p10253 lab=_52879_/X }
C {sky130_stdcells/and4_4.sym} 10900 -33680 0 0 {name=X_52879_ }
C {devices/lab_pin.sym} 10810 -33530 0 0 {name=p10254 lab=_83699_/CLK }
C {devices/lab_pin.sym} 10810 -33510 0 0 {name=p10255 lab=_70792_/Y }
C {devices/lab_pin.sym} 10990 -33530 0 1 {name=p10256 lab=_83699_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -33520 0 0 {name=X_83699_ }
C {devices/lab_pin.sym} 10820 -33410 0 0 {name=p10257 lab=_45350_/X }
C {devices/lab_pin.sym} 10820 -33370 0 0 {name=p10258 lab=_61338_/A }
C {devices/lab_pin.sym} 10820 -33330 0 0 {name=p10259 lab=_45370_/X }
C {devices/lab_pin.sym} 10980 -33370 0 1 {name=p10260 lab=_45420_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -33370 0 0 {name=X_45420_ }
C {devices/lab_pin.sym} 10820 -33260 0 0 {name=p10261 lab=_57484_/A }
C {devices/lab_pin.sym} 10820 -33220 0 0 {name=p10262 lab=_56643_/X }
C {devices/lab_pin.sym} 10820 -33180 0 0 {name=p10263 lab=_85011_/Q }
C {devices/lab_pin.sym} 10820 -33140 0 0 {name=p10264 lab=_57380_/X }
C {devices/lab_pin.sym} 10980 -33200 0 1 {name=p10265 lab=_85011_/D }
C {sky130_stdcells/a2bb2o_4.sym} 10900 -33200 0 0 {name=X_57406_ }
C {devices/lab_pin.sym} 10840 -33060 0 0 {name=p10266 lab=_76209_/Y }
C {devices/lab_pin.sym} 10840 -33020 0 0 {name=p10267 lab=_76223_/Y }
C {devices/lab_pin.sym} 10960 -33040 0 1 {name=p10268 lab=_76240_/Y }
C {sky130_stdcells/nand2_4.sym} 10900 -33040 0 0 {name=X_76240_ }
C {devices/lab_pin.sym} 10810 -32910 0 0 {name=p10269 lab=_88224_/CLK }
C {devices/lab_pin.sym} 10810 -32890 0 0 {name=p10270 lab=_41378_/Y }
C {devices/lab_pin.sym} 10990 -32910 0 1 {name=p10271 lab=_67756_/B }
C {sky130_stdcells/dfxtp_4.sym} 10900 -32900 0 0 {name=X_88226_ }
C {devices/lab_pin.sym} 10860 -32770 0 0 {name=p10272 lab=_42449_/Y }
C {devices/lab_pin.sym} 10940 -32770 0 1 {name=p10273 lab=_42680_/A }
C {sky130_stdcells/buf_2.sym} 10900 -32770 0 0 {name=X_42632_ }
C {devices/lab_pin.sym} 10860 -32650 0 0 {name=p10274 lab=_54537_/A }
C {devices/lab_pin.sym} 10940 -32650 0 1 {name=p10275 lab=_54618_/X }
C {sky130_stdcells/buf_2.sym} 10900 -32650 0 0 {name=X_54618_ }
C {devices/lab_pin.sym} 10840 -32540 0 0 {name=p10276 lab=_73497_/A }
C {devices/lab_pin.sym} 10840 -32500 0 0 {name=p10277 lab=_86470_/Q }
C {devices/lab_pin.sym} 10960 -32520 0 1 {name=p10278 lab=_73452_/X }
C {sky130_stdcells/and2_4.sym} 10900 -32520 0 0 {name=X_73452_ }
C {devices/lab_pin.sym} 10810 -32390 0 0 {name=p10279 lab=_85439_/CLK }
C {devices/lab_pin.sym} 10810 -32370 0 0 {name=p10280 lab=_85438_/D }
C {devices/lab_pin.sym} 10990 -32390 0 1 {name=p10281 lab=_85438_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -32380 0 0 {name=X_85438_ }
C {devices/lab_pin.sym} 10860 -32250 0 0 {name=p10282 lab=_70664_/A }
C {devices/lab_pin.sym} 10940 -32250 0 1 {name=p10283 lab=_70664_/X }
C {sky130_stdcells/buf_2.sym} 10900 -32250 0 0 {name=X_70664_ }
C {devices/lab_pin.sym} 10840 -32140 0 0 {name=p10284 lab=_58385_/Y }
C {devices/lab_pin.sym} 10840 -32100 0 0 {name=p10285 lab=_58369_/X }
C {devices/lab_pin.sym} 10960 -32120 0 1 {name=p10286 lab=_58386_/Y }
C {sky130_stdcells/nand2_4.sym} 10900 -32120 0 0 {name=X_58386_ }
C {devices/lab_pin.sym} 10820 -32010 0 0 {name=p10287 lab=_55595_/X }
C {devices/lab_pin.sym} 10820 -31970 0 0 {name=p10288 lab=_55597_/X }
C {devices/lab_pin.sym} 10820 -31930 0 0 {name=p10289 lab=_55517_/X }
C {devices/lab_pin.sym} 10980 -31970 0 1 {name=p10290 lab=_55601_/A }
C {sky130_stdcells/a21o_4.sym} 10900 -31970 0 0 {name=X_55598_ }
C {devices/lab_pin.sym} 10820 -31860 0 0 {name=p10291 lab=_72394_/Y }
C {devices/lab_pin.sym} 10820 -31820 0 0 {name=p10292 lab=_72358_/X }
C {devices/lab_pin.sym} 10820 -31780 0 0 {name=p10293 lab=_72399_/X }
C {devices/lab_pin.sym} 10820 -31740 0 0 {name=p10294 lab=_72402_/X }
C {devices/lab_pin.sym} 10980 -31800 0 1 {name=p10295 lab=_83258_/D }
C {sky130_stdcells/a22oi_4.sym} 10900 -31800 0 0 {name=X_72403_ }
C {devices/lab_pin.sym} 10840 -31660 0 0 {name=p10296 lab=_57289_/B }
C {devices/lab_pin.sym} 10840 -31620 0 0 {name=p10297 lab=_56849_/X }
C {devices/lab_pin.sym} 10960 -31640 0 1 {name=p10298 lab=_57337_/Y }
C {sky130_stdcells/nor2_4.sym} 10900 -31640 0 0 {name=X_57337_ }
C {devices/lab_pin.sym} 10860 -31510 0 0 {name=p10299 lab=_64535_/B }
C {devices/lab_pin.sym} 10940 -31510 0 1 {name=p10300 lab=_61673_/B }
C {sky130_stdcells/buf_2.sym} 10900 -31510 0 0 {name=X_45351_ }
C {devices/lab_pin.sym} 10840 -31400 0 0 {name=p10301 lab=_76171_/A }
C {devices/lab_pin.sym} 10840 -31360 0 0 {name=p10302 lab=_76171_/B }
C {devices/lab_pin.sym} 10960 -31380 0 1 {name=p10303 lab=_76171_/Y }
C {sky130_stdcells/nor2_4.sym} 10900 -31380 0 0 {name=X_76171_ }
C {devices/lab_pin.sym} 10810 -31250 0 0 {name=p10304 lab=_87144_/CLK }
C {devices/lab_pin.sym} 10810 -31230 0 0 {name=p10305 lab=_88157_/D }
C {devices/lab_pin.sym} 10990 -31250 0 1 {name=p10306 lab=_67873_/B }
C {sky130_stdcells/dfxtp_4.sym} 10900 -31240 0 0 {name=X_88157_ }
C {devices/lab_pin.sym} 10820 -31150 0 0 {name=p10307 lab=_42554_/X }
C {devices/lab_pin.sym} 10820 -31110 0 0 {name=p10308 lab=_42547_/X }
C {devices/lab_pin.sym} 10820 -31070 0 0 {name=p10309 lab=_40806_/X }
C {devices/lab_pin.sym} 10820 -31030 0 0 {name=p10310 lab=_69676_/B }
C {devices/lab_pin.sym} 10820 -30990 0 0 {name=p10311 lab=_42556_/X }
C {devices/lab_pin.sym} 10980 -31070 0 1 {name=p10312 lab=_87819_/D }
C {sky130_stdcells/o32ai_4.sym} 10900 -31070 0 0 {name=X_42563_ }
C {devices/lab_pin.sym} 10840 -30940 0 0 {name=p10313 lab=_54538_/A }
C {devices/lab_pin.sym} 10840 -30900 0 0 {name=p10314 lab=_54559_/B }
C {devices/lab_pin.sym} 10840 -30860 0 0 {name=p10315 lab=_54538_/C }
C {devices/lab_pin.sym} 10840 -30820 0 0 {name=p10316 lab=_47103_/Y }
C {devices/lab_pin.sym} 10960 -30880 0 1 {name=p10317 lab=_54549_/X }
C {sky130_stdcells/and4_4.sym} 10900 -30880 0 0 {name=X_54549_ }
C {devices/lab_pin.sym} 10860 -30730 0 0 {name=p10318 lab=_72877_/A }
C {devices/lab_pin.sym} 10940 -30730 0 1 {name=p10319 lab=_73383_/X }
C {sky130_stdcells/buf_2.sym} 10900 -30730 0 0 {name=X_73383_ }
C {devices/lab_pin.sym} 10810 -30610 0 0 {name=p10320 lab=_83275_/CLK }
C {devices/lab_pin.sym} 10810 -30590 0 0 {name=p10321 lab=_85369_/D }
C {devices/lab_pin.sym} 10990 -30610 0 1 {name=p10322 lab=_85369_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -30600 0 0 {name=X_85369_ }
C {devices/lab_pin.sym} 10860 -30470 0 0 {name=p10323 lab=clkbuf_9_356_0_CLK/X }
C {devices/lab_pin.sym} 10940 -30470 0 1 {name=p10324 lab=_88247_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 10900 -30470 0 0 {name=Xclkbuf_10_713_0_CLK }
C {devices/lab_pin.sym} 10840 -30380 0 0 {name=p10325 lab=_70585_/X }
C {devices/lab_pin.sym} 10840 -30340 0 0 {name=p10326 lab=_70613_/B }
C {devices/lab_pin.sym} 10840 -30300 0 0 {name=p10327 lab=_74533_/D }
C {devices/lab_pin.sym} 10840 -30260 0 0 {name=p10328 lab=_70594_/X }
C {devices/lab_pin.sym} 10960 -30320 0 1 {name=p10329 lab=_70595_/Y }
C {sky130_stdcells/nand4_4.sym} 10900 -30320 0 0 {name=X_70595_ }
C {devices/lab_pin.sym} 10860 -30170 0 0 {name=p10330 lab=_44300_/Y }
C {devices/lab_pin.sym} 10940 -30170 0 1 {name=p10331 lab=_44313_/A }
C {sky130_stdcells/inv_2.sym} 10900 -30170 0 0 {name=X_44302_ }
C {devices/lab_pin.sym} 10810 -30050 0 0 {name=p10332 lab=_87110_/CLK }
C {devices/lab_pin.sym} 10810 -30030 0 0 {name=p10333 lab=_87108_/D }
C {devices/lab_pin.sym} 10990 -30050 0 1 {name=p10334 lab=_87108_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -30040 0 0 {name=X_87108_ }
C {devices/lab_pin.sym} 10860 -29910 0 0 {name=p10335 lab=_75122_/A }
C {devices/lab_pin.sym} 10940 -29910 0 1 {name=p10336 lab=_75122_/Y }
C {sky130_stdcells/inv_2.sym} 10900 -29910 0 0 {name=X_75122_ }
C {devices/lab_pin.sym} 10820 -29810 0 0 {name=p10337 lab=_41344_/X }
C {devices/lab_pin.sym} 10820 -29770 0 0 {name=p10338 lab=_40430_/B }
C {devices/lab_pin.sym} 10820 -29730 0 0 {name=p10339 lab=_41513_/X }
C {devices/lab_pin.sym} 10980 -29770 0 1 {name=p10340 lab=_41514_/X }
C {sky130_stdcells/o21a_4.sym} 10900 -29770 0 0 {name=X_41514_ }
C {devices/lab_pin.sym} 10820 -29650 0 0 {name=p10341 lab=_48063_/Y }
C {devices/lab_pin.sym} 10820 -29610 0 0 {name=p10342 lab=_48055_/X }
C {devices/lab_pin.sym} 10820 -29570 0 0 {name=p10343 lab=_48069_/X }
C {devices/lab_pin.sym} 10980 -29610 0 1 {name=p10344 lab=_48070_/Y }
C {sky130_stdcells/a21oi_4.sym} 10900 -29610 0 0 {name=X_48070_ }
C {devices/lab_pin.sym} 10820 -29500 0 0 {name=p10345 lab=_72323_/Y }
C {devices/lab_pin.sym} 10820 -29460 0 0 {name=p10346 lab=_72237_/X }
C {devices/lab_pin.sym} 10820 -29420 0 0 {name=p10347 lab=_72330_/X }
C {devices/lab_pin.sym} 10820 -29380 0 0 {name=p10348 lab=_72333_/X }
C {devices/lab_pin.sym} 10980 -29440 0 1 {name=p10349 lab=_83264_/D }
C {sky130_stdcells/a22oi_4.sym} 10900 -29440 0 0 {name=X_72334_ }
C {devices/lab_pin.sym} 10820 -29310 0 0 {name=p10350 lab=_55748_/B }
C {devices/lab_pin.sym} 10820 -29270 0 0 {name=p10351 lab=_45281_/X }
C {devices/lab_pin.sym} 10820 -29230 0 0 {name=p10352 lab=_45237_/X }
C {devices/lab_pin.sym} 10980 -29270 0 1 {name=p10353 lab=_45282_/X }
C {sky130_stdcells/o21a_4.sym} 10900 -29270 0 0 {name=X_45282_ }
C {devices/lab_pin.sym} 10860 -29130 0 0 {name=p10354 lab=_57267_/X }
C {devices/lab_pin.sym} 10940 -29130 0 1 {name=p10355 lab=_57268_/X }
C {sky130_stdcells/buf_2.sym} 10900 -29130 0 0 {name=X_57268_ }
C {devices/lab_pin.sym} 10860 -29010 0 0 {name=p10356 lab=_42494_/A }
C {devices/lab_pin.sym} 10940 -29010 0 1 {name=p10357 lab=_87846_/D }
C {sky130_stdcells/inv_2.sym} 10900 -29010 0 0 {name=X_42494_ }
C {devices/lab_pin.sym} 10810 -28890 0 0 {name=p10358 lab=_88086_/CLK }
C {devices/lab_pin.sym} 10810 -28870 0 0 {name=p10359 lab=_41970_/Y }
C {devices/lab_pin.sym} 10990 -28890 0 1 {name=p10360 lab=_88088_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -28880 0 0 {name=X_88088_ }
C {devices/lab_pin.sym} 10860 -28750 0 0 {name=p10361 lab=clkbuf_8_102_0_CLK/X }
C {devices/lab_pin.sym} 10940 -28750 0 1 {name=p10362 lab=clkbuf_9_204_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 10900 -28750 0 0 {name=Xclkbuf_9_204_0_CLK }
C {devices/lab_pin.sym} 10840 -28660 0 0 {name=p10363 lab=_47029_/A }
C {devices/lab_pin.sym} 10840 -28620 0 0 {name=p10364 lab=_47029_/B }
C {devices/lab_pin.sym} 10840 -28580 0 0 {name=p10365 lab=_47029_/C }
C {devices/lab_pin.sym} 10840 -28540 0 0 {name=p10366 lab=_52805_/D }
C {devices/lab_pin.sym} 10960 -28600 0 1 {name=p10367 lab=_47021_/X }
C {sky130_stdcells/and4_4.sym} 10900 -28600 0 0 {name=X_47021_ }
C {devices/lab_pin.sym} 10860 -28450 0 0 {name=p10368 lab=_58897_/A }
C {devices/lab_pin.sym} 10940 -28450 0 1 {name=p10369 lab=_59008_/B }
C {sky130_stdcells/buf_2.sym} 10900 -28450 0 0 {name=X_59007_ }
C {devices/lab_pin.sym} 10860 -28330 0 0 {name=p10370 lab=_72814_/A }
C {devices/lab_pin.sym} 10940 -28330 0 1 {name=p10371 lab=_73181_/A }
C {sky130_stdcells/buf_2.sym} 10900 -28330 0 0 {name=X_44233_ }
C {devices/lab_pin.sym} 10840 -28230 0 0 {name=p10372 lab=_56214_/A }
C {devices/lab_pin.sym} 10840 -28190 0 0 {name=p10373 lab=_56229_/B }
C {devices/lab_pin.sym} 10840 -28150 0 0 {name=p10374 lab=_56219_/C }
C {devices/lab_pin.sym} 10960 -28190 0 1 {name=p10375 lab=_56219_/Y }
C {sky130_stdcells/nand3_4.sym} 10900 -28190 0 0 {name=X_56219_ }
C {devices/lab_pin.sym} 10840 -28060 0 0 {name=p10376 lab=_75046_/X }
C {devices/lab_pin.sym} 10840 -28020 0 0 {name=p10377 lab=_75053_/B }
C {devices/lab_pin.sym} 10960 -28040 0 1 {name=p10378 lab=_75053_/X }
C {sky130_stdcells/xor2_4.sym} 10900 -28040 0 0 {name=X_75053_ }
C {devices/lab_pin.sym} 10840 -27920 0 0 {name=p10379 lab=_79928_/B }
C {devices/lab_pin.sym} 10840 -27880 0 0 {name=p10380 lab=_79928_/A }
C {devices/lab_pin.sym} 10960 -27900 0 1 {name=p10381 lab=_79931_/B }
C {sky130_stdcells/nand2_4.sym} 10900 -27900 0 0 {name=X_79930_ }
C {devices/lab_pin.sym} 10840 -27780 0 0 {name=p10382 lab=_41784_/B }
C {devices/lab_pin.sym} 10840 -27740 0 0 {name=p10383 lab=_41435_/B }
C {devices/lab_pin.sym} 10960 -27760 0 1 {name=p10384 lab=_41445_/X }
C {sky130_stdcells/or2_4.sym} 10900 -27760 0 0 {name=X_41445_ }
C {devices/lab_pin.sym} 10810 -27630 0 0 {name=p10385 lab=_86989_/CLK }
C {devices/lab_pin.sym} 10810 -27610 0 0 {name=p10386 lab=_44604_/X }
C {devices/lab_pin.sym} 10990 -27630 0 1 {name=p10387 lab=_87039_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -27620 0 0 {name=X_87039_ }
C {devices/lab_pin.sym} 10820 -27510 0 0 {name=p10388 lab=_72180_/X }
C {devices/lab_pin.sym} 10820 -27470 0 0 {name=p10389 lab=_85333_/Q }
C {devices/lab_pin.sym} 10820 -27430 0 0 {name=p10390 lab=_72225_/X }
C {devices/lab_pin.sym} 10980 -27470 0 1 {name=p10391 lab=_72265_/X }
C {sky130_stdcells/o21a_4.sym} 10900 -27470 0 0 {name=X_72265_ }
C {devices/lab_pin.sym} 10840 -27340 0 0 {name=p10392 lab=_57199_/A }
C {devices/lab_pin.sym} 10840 -27300 0 0 {name=p10393 lab=_44282_/X }
C {devices/lab_pin.sym} 10960 -27320 0 1 {name=p10394 lab=_57199_/Y }
C {sky130_stdcells/nor2_4.sym} 10900 -27320 0 0 {name=X_57199_ }
C {devices/lab_pin.sym} 10820 -27210 0 0 {name=p10395 lab=_70108_/Y }
C {devices/lab_pin.sym} 10820 -27170 0 0 {name=p10396 lab=_73939_/X }
C {devices/lab_pin.sym} 10820 -27130 0 0 {name=p10397 lab=_74003_/Y }
C {devices/lab_pin.sym} 10980 -27170 0 1 {name=p10398 lab=_74004_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -27170 0 0 {name=X_74004_ }
C {devices/lab_pin.sym} 10860 -27030 0 0 {name=p10399 lab=_71216_/A }
C {devices/lab_pin.sym} 10940 -27030 0 1 {name=p10400 lab=_71216_/X }
C {sky130_stdcells/buf_2.sym} 10900 -27030 0 0 {name=X_71216_ }
C {devices/lab_pin.sym} 10860 -26910 0 0 {name=p10401 lab=_44024_/A }
C {devices/lab_pin.sym} 10940 -26910 0 1 {name=p10402 lab=_44164_/X }
C {sky130_stdcells/buf_2.sym} 10900 -26910 0 0 {name=X_44164_ }
C {devices/lab_pin.sym} 10860 -26790 0 0 {name=p10403 lab=clkbuf_9_364_0_CLK/X }
C {devices/lab_pin.sym} 10940 -26790 0 1 {name=p10404 lab=_88288_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 10900 -26790 0 0 {name=Xclkbuf_10_728_0_CLK }
C {devices/lab_pin.sym} 10820 -26690 0 0 {name=p10405 lab=_64688_/Y }
C {devices/lab_pin.sym} 10820 -26650 0 0 {name=p10406 lab=_72151_/Y }
C {devices/lab_pin.sym} 10820 -26610 0 0 {name=p10407 lab=_79860_/Y }
C {devices/lab_pin.sym} 10980 -26650 0 1 {name=p10408 lab=_79861_/X }
C {sky130_stdcells/o21a_4.sym} 10900 -26650 0 0 {name=X_79861_ }
C {devices/lab_pin.sym} 10860 -26510 0 0 {name=p10409 lab=_41376_/A }
C {devices/lab_pin.sym} 10940 -26510 0 1 {name=p10410 lab=_41376_/X }
C {sky130_stdcells/buf_2.sym} 10900 -26510 0 0 {name=X_41376_ }
C {devices/lab_pin.sym} 10860 -26390 0 0 {name=p10411 lab=_59345_/X }
C {devices/lab_pin.sym} 10940 -26390 0 1 {name=p10412 lab=_72196_/X }
C {sky130_stdcells/buf_2.sym} 10900 -26390 0 0 {name=X_72196_ }
C {devices/lab_pin.sym} 10860 -26270 0 0 {name=p10413 lab=_43115_/A }
C {devices/lab_pin.sym} 10940 -26270 0 1 {name=p10414 lab=_43115_/Y }
C {sky130_stdcells/inv_2.sym} 10900 -26270 0 0 {name=X_43115_ }
C {devices/lab_pin.sym} 10840 -26160 0 0 {name=p10415 lab=_78812_/A }
C {devices/lab_pin.sym} 10840 -26120 0 0 {name=p10416 lab=_82835_/Q }
C {devices/lab_pin.sym} 10960 -26140 0 1 {name=p10417 lab=_79122_/A }
C {sky130_stdcells/nand2_4.sym} 10900 -26140 0 0 {name=X_78812_ }
C {devices/lab_pin.sym} 10860 -26010 0 0 {name=p10418 lab=_40629_/A }
C {devices/lab_pin.sym} 10940 -26010 0 1 {name=p10419 lab=_40878_/A }
C {sky130_stdcells/buf_2.sym} 10900 -26010 0 0 {name=X_40327_ }
C {devices/lab_pin.sym} 10840 -25920 0 0 {name=p10420 lab=_71173_/A }
C {devices/lab_pin.sym} 10840 -25880 0 0 {name=p10421 lab=_71155_/B }
C {devices/lab_pin.sym} 10840 -25840 0 0 {name=p10422 lab=_71152_/C }
C {devices/lab_pin.sym} 10840 -25800 0 0 {name=p10423 lab=_70875_/X }
C {devices/lab_pin.sym} 10960 -25860 0 1 {name=p10424 lab=_71147_/Y }
C {sky130_stdcells/nand4_4.sym} 10900 -25860 0 0 {name=X_71147_ }
C {devices/lab_pin.sym} 10860 -25710 0 0 {name=p10425 lab=_48972_/A }
C {devices/lab_pin.sym} 10940 -25710 0 1 {name=p10426 lab=_48973_/A }
C {sky130_stdcells/inv_2.sym} 10900 -25710 0 0 {name=X_48972_ }
C {devices/lab_pin.sym} 10860 -25590 0 0 {name=p10427 lab=_44095_/A }
C {devices/lab_pin.sym} 10940 -25590 0 1 {name=p10428 lab=_44095_/X }
C {sky130_stdcells/buf_2.sym} 10900 -25590 0 0 {name=X_44095_ }
C {devices/lab_pin.sym} 10860 -25470 0 0 {name=p10429 lab=clkbuf_9_219_0_CLK/A }
C {devices/lab_pin.sym} 10940 -25470 0 1 {name=p10430 lab=clkbuf_9_219_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 10900 -25470 0 0 {name=Xclkbuf_9_219_0_CLK }
C {devices/lab_pin.sym} 10820 -25370 0 0 {name=p10431 lab=_79770_/Y }
C {devices/lab_pin.sym} 10820 -25330 0 0 {name=p10432 lab=_79788_/X }
C {devices/lab_pin.sym} 10820 -25290 0 0 {name=p10433 lab=_79791_/Y }
C {devices/lab_pin.sym} 10980 -25330 0 1 {name=p10434 lab=_79793_/B }
C {sky130_stdcells/a21oi_4.sym} 10900 -25330 0 0 {name=X_79792_ }
C {devices/lab_pin.sym} 10860 -25190 0 0 {name=p10435 lab=_73765_/A }
C {devices/lab_pin.sym} 10940 -25190 0 1 {name=p10436 lab=_47924_/B }
C {sky130_stdcells/buf_2.sym} 10900 -25190 0 0 {name=X_47923_ }
C {devices/lab_pin.sym} 10840 -25090 0 0 {name=p10437 lab=_59909_/A }
C {devices/lab_pin.sym} 10840 -25050 0 0 {name=p10438 lab=_63632_/A }
C {devices/lab_pin.sym} 10840 -25010 0 0 {name=p10439 lab=_59909_/C }
C {devices/lab_pin.sym} 10960 -25050 0 1 {name=p10440 lab=_59909_/Y }
C {sky130_stdcells/nand3_4.sym} 10900 -25050 0 0 {name=X_59909_ }
C {devices/lab_pin.sym} 10860 -24910 0 0 {name=p10441 lab=_43046_/A }
C {devices/lab_pin.sym} 10940 -24910 0 1 {name=p10442 lab=_43046_/X }
C {sky130_stdcells/buf_2.sym} 10900 -24910 0 0 {name=X_43046_ }
C {devices/lab_pin.sym} 10840 -24800 0 0 {name=p10443 lab=_78717_/X }
C {devices/lab_pin.sym} 10840 -24760 0 0 {name=p10444 lab=_78722_/Y }
C {devices/lab_pin.sym} 10960 -24780 0 1 {name=p10445 lab=_78744_/C }
C {sky130_stdcells/nand2_4.sym} 10900 -24780 0 0 {name=X_78743_ }
C {devices/lab_pin.sym} 10840 -24670 0 0 {name=p10446 lab=_71078_/A }
C {devices/lab_pin.sym} 10840 -24630 0 0 {name=p10447 lab=_71055_/B }
C {devices/lab_pin.sym} 10840 -24590 0 0 {name=p10448 lab=_71078_/C }
C {devices/lab_pin.sym} 10960 -24630 0 1 {name=p10449 lab=_71078_/Y }
C {sky130_stdcells/nand3_4.sym} 10900 -24630 0 0 {name=X_71078_ }
C {devices/lab_pin.sym} 10840 -24500 0 0 {name=p10450 lab=_81511_/Q }
C {devices/lab_pin.sym} 10840 -24460 0 0 {name=p10451 lab=_75955_/B }
C {devices/lab_pin.sym} 10960 -24480 0 1 {name=p10452 lab=_75955_/X }
C {sky130_stdcells/xor2_4.sym} 10900 -24480 0 0 {name=X_75955_ }
C {devices/lab_pin.sym} 10840 -24360 0 0 {name=p10453 lab=_74906_/A }
C {devices/lab_pin.sym} 10840 -24320 0 0 {name=p10454 lab=_74906_/B }
C {devices/lab_pin.sym} 10960 -24340 0 1 {name=p10455 lab=_74906_/X }
C {sky130_stdcells/xor2_4.sym} 10900 -24340 0 0 {name=X_74906_ }
C {devices/lab_pin.sym} 10820 -24250 0 0 {name=p10456 lab=_62916_/Y }
C {devices/lab_pin.sym} 10820 -24210 0 0 {name=p10457 lab=_60337_/A }
C {devices/lab_pin.sym} 10820 -24170 0 0 {name=p10458 lab=_62660_/X }
C {devices/lab_pin.sym} 10820 -24130 0 0 {name=p10459 lab=_62918_/X }
C {devices/lab_pin.sym} 10820 -24100 0 0 {name=p10460 lab=_62919_/Y }
C {devices/lab_pin.sym} 10980 -24170 0 1 {name=p10461 lab=_62920_/X }
C {sky130_stdcells/a41o_4.sym} 10900 -24170 0 0 {name=X_62920_ }
C {devices/lab_pin.sym} 10860 -24010 0 0 {name=p10462 lab=clkbuf_4_5_0_CLK/A }
C {devices/lab_pin.sym} 10940 -24010 0 1 {name=p10463 lab=clkbuf_4_4_1_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 10900 -24010 0 0 {name=Xclkbuf_4_4_0_CLK }
C {devices/lab_pin.sym} 10860 -23890 0 0 {name=p10464 lab=_70048_/A }
C {devices/lab_pin.sym} 10940 -23890 0 1 {name=p10465 lab=_70029_/X }
C {sky130_stdcells/buf_2.sym} 10900 -23890 0 0 {name=X_70029_ }
C {devices/lab_pin.sym} 10860 -23770 0 0 {name=p10466 lab=_47853_/Y }
C {devices/lab_pin.sym} 10940 -23770 0 1 {name=p10467 lab=_50232_/B }
C {sky130_stdcells/buf_2.sym} 10900 -23770 0 0 {name=X_47854_ }
C {devices/lab_pin.sym} 10820 -23670 0 0 {name=p10468 lab=_78672_/Y }
C {devices/lab_pin.sym} 10820 -23630 0 0 {name=p10469 lab=_78642_/Y }
C {devices/lab_pin.sym} 10820 -23590 0 0 {name=p10470 lab=_78673_/X }
C {devices/lab_pin.sym} 10980 -23630 0 1 {name=p10471 lab=_78675_/B }
C {sky130_stdcells/o21ai_4.sym} 10900 -23630 0 0 {name=X_78674_ }
C {devices/lab_pin.sym} 10860 -23490 0 0 {name=p10472 lab=_75817_/Y }
C {devices/lab_pin.sym} 10940 -23490 0 1 {name=p10473 lab=_75886_/Y }
C {sky130_stdcells/inv_2.sym} 10900 -23490 0 0 {name=X_75886_ }
C {devices/lab_pin.sym} 10860 -23370 0 0 {name=p10474 lab=_52686_/B }
C {devices/lab_pin.sym} 10940 -23370 0 1 {name=p10475 lab=_46805_/X }
C {sky130_stdcells/buf_2.sym} 10900 -23370 0 0 {name=X_46805_ }
C {devices/lab_pin.sym} 10820 -23270 0 0 {name=p10476 lab=_77606_/A }
C {devices/lab_pin.sym} 10820 -23230 0 0 {name=p10477 lab=_77623_/Y }
C {devices/lab_pin.sym} 10820 -23190 0 0 {name=p10478 lab=_77624_/Y }
C {devices/lab_pin.sym} 10980 -23230 0 1 {name=p10479 lab=_77625_/X }
C {sky130_stdcells/a21bo_4.sym} 10900 -23230 0 0 {name=X_77625_ }
C {devices/lab_pin.sym} 10860 -23090 0 0 {name=p10480 lab=_62851_/A }
C {devices/lab_pin.sym} 10940 -23090 0 1 {name=p10481 lab=_63306_/A }
C {sky130_stdcells/buf_2.sym} 10900 -23090 0 0 {name=X_62851_ }
C {devices/lab_pin.sym} 10860 -22970 0 0 {name=p10482 lab=_74836_/Y }
C {devices/lab_pin.sym} 10940 -22970 0 1 {name=p10483 lab=_80655_/D }
C {sky130_stdcells/inv_2.sym} 10900 -22970 0 0 {name=X_74837_ }
C {devices/lab_pin.sym} 10840 -22880 0 0 {name=p10484 lab=_47804_/A }
C {devices/lab_pin.sym} 10840 -22840 0 0 {name=p10485 lab=_47777_/B }
C {devices/lab_pin.sym} 10840 -22800 0 0 {name=p10486 lab=_47777_/C }
C {devices/lab_pin.sym} 10840 -22760 0 0 {name=p10487 lab=_53244_/D }
C {devices/lab_pin.sym} 10960 -22820 0 1 {name=p10488 lab=_47785_/X }
C {sky130_stdcells/and4_4.sym} 10900 -22820 0 0 {name=X_47785_ }
C {devices/lab_pin.sym} 10820 -22690 0 0 {name=p10489 lab=_44987_/X }
C {devices/lab_pin.sym} 10820 -22650 0 0 {name=p10490 lab=_44991_/Y }
C {devices/lab_pin.sym} 10820 -22610 0 0 {name=p10491 lab=_44996_/Y }
C {devices/lab_pin.sym} 10980 -22650 0 1 {name=p10492 lab=_44997_/Y }
C {sky130_stdcells/a21oi_4.sym} 10900 -22650 0 0 {name=X_44997_ }
C {devices/lab_pin.sym} 10840 -22530 0 0 {name=p10493 lab=_61752_/A }
C {devices/lab_pin.sym} 10840 -22490 0 0 {name=p10494 lab=_61723_/X }
C {devices/lab_pin.sym} 10840 -22450 0 0 {name=p10495 lab=_78076_/B }
C {devices/lab_pin.sym} 10960 -22490 0 1 {name=p10496 lab=_61802_/Y }
C {sky130_stdcells/nor3_4.sym} 10900 -22490 0 0 {name=X_61802_ }
C {devices/lab_pin.sym} 10860 -22350 0 0 {name=p10497 lab=_49496_/A }
C {devices/lab_pin.sym} 10940 -22350 0 1 {name=p10498 lab=_49524_/X }
C {sky130_stdcells/buf_2.sym} 10900 -22350 0 0 {name=X_49524_ }
C {devices/lab_pin.sym} 10860 -22230 0 0 {name=p10499 lab=_46735_/Y }
C {devices/lab_pin.sym} 10940 -22230 0 1 {name=p10500 lab=_46736_/X }
C {sky130_stdcells/buf_2.sym} 10900 -22230 0 0 {name=X_46736_ }
C {devices/lab_pin.sym} 10820 -22140 0 0 {name=p10501 lab=_65524_/X }
C {devices/lab_pin.sym} 10820 -22100 0 0 {name=p10502 lab=_83072_/Q }
C {devices/lab_pin.sym} 10820 -22060 0 0 {name=p10503 lab=_65568_/X }
C {devices/lab_pin.sym} 10820 -22020 0 0 {name=p10504 lab=_65569_/X }
C {devices/lab_pin.sym} 10980 -22080 0 1 {name=p10505 lab=_65570_/X }
C {sky130_stdcells/a211o_4.sym} 10900 -22080 0 0 {name=X_65570_ }
C {devices/lab_pin.sym} 10860 -21930 0 0 {name=p10506 lab=_77555_/X }
C {devices/lab_pin.sym} 10940 -21930 0 1 {name=p10507 lab=_77556_/Y }
C {sky130_stdcells/inv_2.sym} 10900 -21930 0 0 {name=X_77556_ }
C {devices/lab_pin.sym} 10840 -21820 0 0 {name=p10508 lab=_43979_/A }
C {devices/lab_pin.sym} 10840 -21780 0 0 {name=p10509 lab=_43948_/B }
C {devices/lab_pin.sym} 10960 -21800 0 1 {name=p10510 lab=_43948_/Y }
C {sky130_stdcells/nor2_4.sym} 10900 -21800 0 0 {name=X_43948_ }
C {devices/lab_pin.sym} 10860 -21670 0 0 {name=p10511 lab=_60199_/X }
C {devices/lab_pin.sym} 10940 -21670 0 1 {name=p10512 lab=_62782_/X }
C {sky130_stdcells/buf_2.sym} 10900 -21670 0 0 {name=X_62782_ }
C {devices/lab_pin.sym} 10840 -21570 0 0 {name=p10513 lab=_74723_/X }
C {devices/lab_pin.sym} 10840 -21530 0 0 {name=p10514 lab=_74768_/B }
C {devices/lab_pin.sym} 10840 -21490 0 0 {name=p10515 lab=_74780_/D }
C {devices/lab_pin.sym} 10960 -21530 0 1 {name=p10516 lab=_74768_/Y }
C {sky130_stdcells/nand3_4.sym} 10900 -21530 0 0 {name=X_74768_ }
C {devices/lab_pin.sym} 10820 -21410 0 0 {name=p10517 lab=_76487_/Y }
C {devices/lab_pin.sym} 10820 -21370 0 0 {name=p10518 lab=_76491_/B }
C {devices/lab_pin.sym} 10820 -21330 0 0 {name=p10519 lab=_76489_/Y }
C {devices/lab_pin.sym} 10980 -21370 0 1 {name=p10520 lab=_76508_/A }
C {sky130_stdcells/o21a_4.sym} 10900 -21370 0 0 {name=X_76507_ }
C {devices/lab_pin.sym} 10860 -21230 0 0 {name=p10521 lab=_64315_/A }
C {devices/lab_pin.sym} 10940 -21230 0 1 {name=p10522 lab=_64521_/X }
C {sky130_stdcells/buf_2.sym} 10900 -21230 0 0 {name=X_64521_ }
C {devices/lab_pin.sym} 10820 -21130 0 0 {name=p10523 lab=_86384_/Q }
C {devices/lab_pin.sym} 10820 -21090 0 0 {name=p10524 lab=_49443_/X }
C {devices/lab_pin.sym} 10820 -21050 0 0 {name=p10525 lab=_49454_/Y }
C {devices/lab_pin.sym} 10980 -21090 0 1 {name=p10526 lab=_49455_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -21090 0 0 {name=X_49455_ }
C {devices/lab_pin.sym} 10840 -20980 0 0 {name=p10527 lab=_61730_/X }
C {devices/lab_pin.sym} 10840 -20940 0 0 {name=p10528 lab=_61791_/B }
C {devices/lab_pin.sym} 10840 -20900 0 0 {name=p10529 lab=_61732_/X }
C {devices/lab_pin.sym} 10840 -20860 0 0 {name=p10530 lab=_63017_/B }
C {devices/lab_pin.sym} 10960 -20920 0 1 {name=p10531 lab=_61733_/X }
C {sky130_stdcells/and4_4.sym} 10900 -20920 0 0 {name=X_61733_ }
C {devices/lab_pin.sym} 10840 -20790 0 0 {name=p10532 lab=_73717_/X }
C {devices/lab_pin.sym} 10840 -20750 0 0 {name=p10533 lab=_73719_/B }
C {devices/lab_pin.sym} 10840 -20710 0 0 {name=p10534 lab=_73719_/C }
C {devices/lab_pin.sym} 10960 -20750 0 1 {name=p10535 lab=_73719_/Y }
C {sky130_stdcells/nand3_4.sym} 10900 -20750 0 0 {name=X_73719_ }
C {devices/lab_pin.sym} 10860 -20610 0 0 {name=p10536 lab=_46667_/A }
C {devices/lab_pin.sym} 10940 -20610 0 1 {name=p10537 lab=_46682_/C }
C {sky130_stdcells/buf_2.sym} 10900 -20610 0 0 {name=X_46667_ }
C {devices/lab_pin.sym} 10840 -20500 0 0 {name=p10538 lab=_77488_/A }
C {devices/lab_pin.sym} 10840 -20460 0 0 {name=p10539 lab=_77488_/B }
C {devices/lab_pin.sym} 10960 -20480 0 1 {name=p10540 lab=_77487_/Y }
C {sky130_stdcells/nor2_4.sym} 10900 -20480 0 0 {name=X_77487_ }
C {devices/lab_pin.sym} 10860 -20350 0 0 {name=p10541 lab=_43842_/A }
C {devices/lab_pin.sym} 10940 -20350 0 1 {name=p10542 lab=_43879_/X }
C {sky130_stdcells/buf_2.sym} 10900 -20350 0 0 {name=X_43879_ }
C {devices/lab_pin.sym} 10860 -20230 0 0 {name=p10543 lab=_74698_/Y }
C {devices/lab_pin.sym} 10940 -20230 0 1 {name=p10544 lab=_82981_/D }
C {sky130_stdcells/inv_2.sym} 10900 -20230 0 0 {name=X_74699_ }
C {devices/lab_pin.sym} 10820 -20130 0 0 {name=p10545 lab=_48134_/X }
C {devices/lab_pin.sym} 10820 -20090 0 0 {name=p10546 lab=_82365_/Q }
C {devices/lab_pin.sym} 10820 -20050 0 0 {name=p10547 lab=_48405_/X }
C {devices/lab_pin.sym} 10980 -20090 0 1 {name=p10548 lab=_48407_/A }
C {sky130_stdcells/o21ai_4.sym} 10900 -20090 0 0 {name=X_48406_ }
C {devices/lab_pin.sym} 10860 -19950 0 0 {name=p10549 lab=_66879_/A }
C {devices/lab_pin.sym} 10940 -19950 0 1 {name=p10550 lab=_67240_/X }
C {sky130_stdcells/buf_2.sym} 10900 -19950 0 0 {name=X_67240_ }
C {devices/lab_pin.sym} 10840 -19840 0 0 {name=p10551 lab=_79251_/A }
C {devices/lab_pin.sym} 10840 -19800 0 0 {name=p10552 lab=_79225_/Y }
C {devices/lab_pin.sym} 10960 -19820 0 1 {name=p10553 lab=_79227_/A }
C {sky130_stdcells/xor2_4.sym} 10900 -19820 0 0 {name=X_79226_ }
C {devices/lab_pin.sym} 10820 -19720 0 0 {name=p10554 lab=_45615_/Y }
C {devices/lab_pin.sym} 10820 -19680 0 0 {name=p10555 lab=_45570_/X }
C {devices/lab_pin.sym} 10820 -19640 0 0 {name=p10556 lab=_45616_/X }
C {devices/lab_pin.sym} 10820 -19600 0 0 {name=p10557 lab=_45617_/Y }
C {devices/lab_pin.sym} 10980 -19660 0 1 {name=p10558 lab=_45618_/X }
C {sky130_stdcells/a211o_4.sym} 10900 -19660 0 0 {name=X_45618_ }
C {devices/lab_pin.sym} 10820 -19530 0 0 {name=p10559 lab=_64445_/Y }
C {devices/lab_pin.sym} 10820 -19490 0 0 {name=p10560 lab=_64451_/X }
C {devices/lab_pin.sym} 10820 -19450 0 0 {name=p10561 lab=_64442_/X }
C {devices/lab_pin.sym} 10980 -19490 0 1 {name=p10562 lab=_64452_/X }
C {sky130_stdcells/o21a_4.sym} 10900 -19490 0 0 {name=X_64452_ }
C {devices/lab_pin.sym} 10860 -19350 0 0 {name=p10563 lab=_76438_/A }
C {devices/lab_pin.sym} 10940 -19350 0 1 {name=p10564 lab=_76440_/A }
C {sky130_stdcells/inv_2.sym} 10900 -19350 0 0 {name=X_76438_ }
C {devices/lab_pin.sym} 10860 -19230 0 0 {name=p10565 lab=_64526_/B }
C {devices/lab_pin.sym} 10940 -19230 0 1 {name=p10566 lab=_61665_/B }
C {sky130_stdcells/buf_2.sym} 10900 -19230 0 0 {name=X_61664_ }
C {devices/lab_pin.sym} 10840 -19140 0 0 {name=p10567 lab=_49397_/A }
C {devices/lab_pin.sym} 10840 -19100 0 0 {name=p10568 lab=_49369_/X }
C {devices/lab_pin.sym} 10840 -19060 0 0 {name=p10569 lab=_49408_/C }
C {devices/lab_pin.sym} 10840 -19020 0 0 {name=p10570 lab=_51772_/D }
C {devices/lab_pin.sym} 10960 -19080 0 1 {name=p10571 lab=_49386_/X }
C {sky130_stdcells/and4_4.sym} 10900 -19080 0 0 {name=X_49386_ }
C {devices/lab_pin.sym} 10860 -18930 0 0 {name=p10572 lab=_72083_/A }
C {devices/lab_pin.sym} 10940 -18930 0 1 {name=p10573 lab=_46598_/X }
C {sky130_stdcells/buf_2.sym} 10900 -18930 0 0 {name=X_46598_ }
C {devices/lab_pin.sym} 10820 -18850 0 0 {name=p10574 lab=_63368_/X }
C {devices/lab_pin.sym} 10820 -18810 0 0 {name=p10575 lab=_63396_/X }
C {devices/lab_pin.sym} 10820 -18770 0 0 {name=p10576 lab=_63397_/X }
C {devices/lab_pin.sym} 10820 -18730 0 0 {name=p10577 lab=_63401_/X }
C {devices/lab_pin.sym} 10820 -18690 0 0 {name=p10578 lab=_63402_/Y }
C {devices/lab_pin.sym} 10980 -18770 0 1 {name=p10579 lab=_63403_/Y }
C {sky130_stdcells/o41ai_4.sym} 10900 -18770 0 0 {name=X_63403_ }
C {devices/lab_pin.sym} 10840 -18630 0 0 {name=p10580 lab=_60615_/A }
C {devices/lab_pin.sym} 10840 -18590 0 0 {name=p10581 lab=_60312_/C }
C {devices/lab_pin.sym} 10840 -18550 0 0 {name=p10582 lab=_60312_/D }
C {devices/lab_pin.sym} 10960 -18590 0 1 {name=p10583 lab=_60616_/B }
C {sky130_stdcells/nand3_4.sym} 10900 -18590 0 0 {name=X_60615_ }
C {devices/lab_pin.sym} 10860 -18450 0 0 {name=p10584 lab=_48337_/A }
C {devices/lab_pin.sym} 10940 -18450 0 1 {name=p10585 lab=_52079_/B }
C {sky130_stdcells/buf_2.sym} 10900 -18450 0 0 {name=X_48337_ }
C {devices/lab_pin.sym} 10820 -18360 0 0 {name=p10586 lab=_87418_/Q }
C {devices/lab_pin.sym} 10820 -18320 0 0 {name=p10587 lab=_67121_/X }
C {devices/lab_pin.sym} 10820 -18280 0 0 {name=p10588 lab=_67122_/X }
C {devices/lab_pin.sym} 10820 -18240 0 0 {name=p10589 lab=_67170_/X }
C {devices/lab_pin.sym} 10980 -18300 0 1 {name=p10590 lab=_67171_/X }
C {sky130_stdcells/a211o_4.sym} 10900 -18300 0 0 {name=X_67171_ }
C {devices/lab_pin.sym} 10840 -18160 0 0 {name=p10591 lab=_79157_/A }
C {devices/lab_pin.sym} 10840 -18120 0 0 {name=p10592 lab=_84489_/Q }
C {devices/lab_pin.sym} 10960 -18140 0 1 {name=p10593 lab=_82465_/D }
C {sky130_stdcells/xor2_4.sym} 10900 -18140 0 0 {name=X_79157_ }
C {devices/lab_pin.sym} 10840 -18020 0 0 {name=p10594 lab=_45549_/A }
C {devices/lab_pin.sym} 10840 -17980 0 0 {name=p10595 lab=_45597_/B }
C {devices/lab_pin.sym} 10960 -18000 0 1 {name=p10596 lab=_45549_/Y }
C {sky130_stdcells/nor2_4.sym} 10900 -18000 0 0 {name=X_45549_ }
C {devices/lab_pin.sym} 10820 -17890 0 0 {name=p10597 lab=_58335_/Y }
C {devices/lab_pin.sym} 10820 -17850 0 0 {name=p10598 lab=_64367_/X }
C {devices/lab_pin.sym} 10820 -17810 0 0 {name=p10599 lab=_64382_/Y }
C {devices/lab_pin.sym} 10980 -17850 0 1 {name=p10600 lab=_64383_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -17850 0 0 {name=X_64383_ }
C {devices/lab_pin.sym} 10840 -17730 0 0 {name=p10601 lab=_76369_/A }
C {devices/lab_pin.sym} 10840 -17690 0 0 {name=p10602 lab=_76369_/B }
C {devices/lab_pin.sym} 10840 -17650 0 0 {name=p10603 lab=_76368_/Y }
C {devices/lab_pin.sym} 10960 -17690 0 1 {name=p10604 lab=_76369_/X }
C {sky130_stdcells/or3_4.sym} 10900 -17690 0 0 {name=X_76369_ }
C {devices/lab_pin.sym} 10860 -17550 0 0 {name=p10605 lab=_72528_/A }
C {devices/lab_pin.sym} 10940 -17550 0 1 {name=p10606 lab=_61611_/B }
C {sky130_stdcells/buf_2.sym} 10900 -17550 0 0 {name=X_61595_ }
C {devices/lab_pin.sym} 10820 -17450 0 0 {name=p10607 lab=_66068_/X }
C {devices/lab_pin.sym} 10820 -17410 0 0 {name=p10608 lab=_65646_/Y }
C {devices/lab_pin.sym} 10820 -17370 0 0 {name=p10609 lab=_66121_/Y }
C {devices/lab_pin.sym} 10980 -17410 0 1 {name=p10610 lab=_66122_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -17410 0 0 {name=X_66122_ }
C {devices/lab_pin.sym} 10840 -17280 0 0 {name=p10611 lab=_82567_/Q }
C {devices/lab_pin.sym} 10840 -17240 0 0 {name=p10612 lab=_78108_/B }
C {devices/lab_pin.sym} 10960 -17260 0 1 {name=p10613 lab=_78130_/B }
C {sky130_stdcells/xor2_4.sym} 10900 -17260 0 0 {name=X_78108_ }
C {devices/lab_pin.sym} 10820 -17170 0 0 {name=p10614 lab=_63330_/Y }
C {devices/lab_pin.sym} 10820 -17130 0 0 {name=p10615 lab=_63331_/X }
C {devices/lab_pin.sym} 10820 -17090 0 0 {name=p10616 lab=_63332_/X }
C {devices/lab_pin.sym} 10820 -17050 0 0 {name=p10617 lab=_63333_/X }
C {devices/lab_pin.sym} 10820 -17010 0 0 {name=p10618 lab=_63020_/A }
C {devices/lab_pin.sym} 10980 -17090 0 1 {name=p10619 lab=_63334_/Y }
C {sky130_stdcells/o41ai_4.sym} 10900 -17090 0 0 {name=X_63334_ }
C {devices/lab_pin.sym} 10860 -16930 0 0 {name=p10620 lab=_48545_/A }
C {devices/lab_pin.sym} 10940 -16930 0 1 {name=p10621 lab=_48287_/C }
C {sky130_stdcells/buf_2.sym} 10900 -16930 0 0 {name=X_48268_ }
C {devices/lab_pin.sym} 10860 -16810 0 0 {name=p10622 lab=_60546_/A }
C {devices/lab_pin.sym} 10940 -16810 0 1 {name=p10623 lab=_60546_/Y }
C {sky130_stdcells/inv_2.sym} 10900 -16810 0 0 {name=X_60546_ }
C {devices/lab_pin.sym} 10860 -16690 0 0 {name=p10624 lab=_79088_/A }
C {devices/lab_pin.sym} 10940 -16690 0 1 {name=p10625 lab=_79088_/Y }
C {sky130_stdcells/inv_2.sym} 10900 -16690 0 0 {name=X_79088_ }
C {devices/lab_pin.sym} 10820 -16590 0 0 {name=p10626 lab=_47215_/Y }
C {devices/lab_pin.sym} 10820 -16550 0 0 {name=p10627 lab=_47177_/X }
C {devices/lab_pin.sym} 10820 -16510 0 0 {name=p10628 lab=_47218_/X }
C {devices/lab_pin.sym} 10980 -16550 0 1 {name=p10629 lab=_47219_/Y }
C {sky130_stdcells/a21oi_4.sym} 10900 -16550 0 0 {name=X_47219_ }
C {devices/lab_pin.sym} 10860 -16410 0 0 {name=p10630 lab=_66053_/A }
C {devices/lab_pin.sym} 10940 -16410 0 1 {name=p10631 lab=_66053_/X }
C {sky130_stdcells/buf_2.sym} 10900 -16410 0 0 {name=X_66053_ }
C {devices/lab_pin.sym} 10860 -16290 0 0 {name=p10632 lab=_77883_/Y }
C {devices/lab_pin.sym} 10940 -16290 0 1 {name=p10633 lab=_81939_/D }
C {sky130_stdcells/inv_2.sym} 10900 -16290 0 0 {name=X_78039_ }
C {devices/lab_pin.sym} 10840 -16200 0 0 {name=p10634 lab=_63216_/X }
C {devices/lab_pin.sym} 10840 -16160 0 0 {name=p10635 lab=_63265_/B }
C {devices/lab_pin.sym} 10840 -16120 0 0 {name=p10636 lab=_63333_/C }
C {devices/lab_pin.sym} 10840 -16080 0 0 {name=p10637 lab=_63240_/X }
C {devices/lab_pin.sym} 10960 -16140 0 1 {name=p10638 lab=_63265_/X }
C {sky130_stdcells/and4_4.sym} 10900 -16140 0 0 {name=X_63265_ }
C {devices/lab_pin.sym} 10820 -16010 0 0 {name=p10639 lab=_86557_/Q }
C {devices/lab_pin.sym} 10820 -15970 0 0 {name=p10640 lab=_48188_/X }
C {devices/lab_pin.sym} 10820 -15930 0 0 {name=p10641 lab=_48198_/Y }
C {devices/lab_pin.sym} 10980 -15970 0 1 {name=p10642 lab=_48199_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -15970 0 0 {name=X_48199_ }
C {devices/lab_pin.sym} 10840 -15850 0 0 {name=p10643 lab=_60477_/A }
C {devices/lab_pin.sym} 10840 -15810 0 0 {name=p10644 lab=_60519_/B }
C {devices/lab_pin.sym} 10840 -15770 0 0 {name=p10645 lab=_79153_/A }
C {devices/lab_pin.sym} 10960 -15810 0 1 {name=p10646 lab=_60477_/Y }
C {sky130_stdcells/nor3_4.sym} 10900 -15810 0 0 {name=X_60477_ }
C {devices/lab_pin.sym} 10820 -15690 0 0 {name=p10647 lab=_65001_/X }
C {devices/lab_pin.sym} 10820 -15650 0 0 {name=p10648 lab=_65003_/X }
C {devices/lab_pin.sym} 10820 -15610 0 0 {name=p10649 lab=_64959_/X }
C {devices/lab_pin.sym} 10980 -15650 0 1 {name=p10650 lab=_65004_/X }
C {sky130_stdcells/a21o_4.sym} 10900 -15650 0 0 {name=X_65004_ }
C {devices/lab_pin.sym} 10840 -15520 0 0 {name=p10651 lab=_50230_/A }
C {devices/lab_pin.sym} 10840 -15480 0 0 {name=p10652 lab=_48178_/X }
C {devices/lab_pin.sym} 10960 -15500 0 1 {name=p10653 lab=_50230_/Y }
C {sky130_stdcells/nand2_4.sym} 10900 -15500 0 0 {name=X_50230_ }
C {devices/lab_pin.sym} 10810 -15370 0 0 {name=p10654 lab=_81048_/CLK }
C {devices/lab_pin.sym} 10810 -15350 0 0 {name=p10655 lab=_75440_/B }
C {devices/lab_pin.sym} 10990 -15370 0 1 {name=p10656 lab=_81050_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -15360 0 0 {name=X_81050_ }
C {devices/lab_pin.sym} 10840 -15250 0 0 {name=p10657 lab=_62181_/A }
C {devices/lab_pin.sym} 10840 -15210 0 0 {name=p10658 lab=_62181_/B }
C {devices/lab_pin.sym} 10840 -15170 0 0 {name=p10659 lab=_84425_/Q }
C {devices/lab_pin.sym} 10960 -15210 0 1 {name=p10660 lab=_62216_/Y }
C {sky130_stdcells/nor3_4.sym} 10900 -15210 0 0 {name=X_62216_ }
C {devices/lab_pin.sym} 10840 -15100 0 0 {name=p10661 lab=_63157_/X }
C {devices/lab_pin.sym} 10840 -15060 0 0 {name=p10662 lab=_63196_/B }
C {devices/lab_pin.sym} 10840 -15020 0 0 {name=p10663 lab=_63241_/C }
C {devices/lab_pin.sym} 10840 -14980 0 0 {name=p10664 lab=_63181_/X }
C {devices/lab_pin.sym} 10960 -15040 0 1 {name=p10665 lab=_63196_/X }
C {sky130_stdcells/and4_4.sym} 10900 -15040 0 0 {name=X_63196_ }
C {devices/lab_pin.sym} 10820 -14910 0 0 {name=p10666 lab=_79989_/Y }
C {devices/lab_pin.sym} 10820 -14870 0 0 {name=p10667 lab=_79992_/Y }
C {devices/lab_pin.sym} 10820 -14830 0 0 {name=p10668 lab=_79988_/A }
C {devices/lab_pin.sym} 10980 -14870 0 1 {name=p10669 lab=_80002_/B }
C {sky130_stdcells/o21ai_4.sym} 10900 -14870 0 0 {name=X_80001_ }
C {devices/lab_pin.sym} 10820 -14760 0 0 {name=p10670 lab=_87053_/Q }
C {devices/lab_pin.sym} 10820 -14720 0 0 {name=p10671 lab=_69796_/X }
C {devices/lab_pin.sym} 10820 -14680 0 0 {name=p10672 lab=_69797_/X }
C {devices/lab_pin.sym} 10820 -14640 0 0 {name=p10673 lab=_69811_/X }
C {devices/lab_pin.sym} 10980 -14700 0 1 {name=p10674 lab=_69813_/B }
C {sky130_stdcells/a211o_4.sym} 10900 -14700 0 0 {name=X_69812_ }
C {devices/lab_pin.sym} 10820 -14570 0 0 {name=p10675 lab=_50159_/Y }
C {devices/lab_pin.sym} 10820 -14530 0 0 {name=p10676 lab=_50141_/X }
C {devices/lab_pin.sym} 10820 -14490 0 0 {name=p10677 lab=_50160_/X }
C {devices/lab_pin.sym} 10980 -14530 0 1 {name=p10678 lab=_86252_/D }
C {sky130_stdcells/a21oi_4.sym} 10900 -14530 0 0 {name=X_50161_ }
C {devices/lab_pin.sym} 10840 -14420 0 0 {name=p10679 lab=_59730_/A }
C {devices/lab_pin.sym} 10840 -14380 0 0 {name=p10680 lab=_62170_/B }
C {devices/lab_pin.sym} 10840 -14340 0 0 {name=p10681 lab=_62158_/C }
C {devices/lab_pin.sym} 10840 -14300 0 0 {name=p10682 lab=_63324_/B }
C {devices/lab_pin.sym} 10960 -14360 0 1 {name=p10683 lab=_62147_/X }
C {sky130_stdcells/and4_4.sym} 10900 -14360 0 0 {name=X_62147_ }
C {devices/lab_pin.sym} 10820 -14230 0 0 {name=p10684 lab=_69739_/X }
C {devices/lab_pin.sym} 10820 -14190 0 0 {name=p10685 lab=_69741_/X }
C {devices/lab_pin.sym} 10820 -14150 0 0 {name=p10686 lab=_69742_/X }
C {devices/lab_pin.sym} 10980 -14190 0 1 {name=p10687 lab=_69743_/Y }
C {sky130_stdcells/a21oi_4.sym} 10900 -14190 0 0 {name=X_69743_ }
C {devices/lab_pin.sym} 10860 -14050 0 0 {name=p10688 lab=_50092_/A }
C {devices/lab_pin.sym} 10940 -14050 0 1 {name=p10689 lab=_50092_/X }
C {sky130_stdcells/buf_2.sym} 10900 -14050 0 0 {name=X_50092_ }
C {devices/lab_pin.sym} 10860 -13930 0 0 {name=p10690 lab=_66717_/A }
C {devices/lab_pin.sym} 10940 -13930 0 1 {name=p10691 lab=_66955_/X }
C {sky130_stdcells/buf_2.sym} 10900 -13930 0 0 {name=X_66955_ }
C {devices/lab_pin.sym} 10820 -13850 0 0 {name=p10692 lab=_62070_/X }
C {devices/lab_pin.sym} 10820 -13810 0 0 {name=p10693 lab=_62072_/X }
C {devices/lab_pin.sym} 10820 -13770 0 0 {name=p10694 lab=_62077_/Y }
C {devices/lab_pin.sym} 10820 -13730 0 0 {name=p10695 lab=_84843_/Q }
C {devices/lab_pin.sym} 10820 -13690 0 0 {name=p10696 lab=_62048_/X }
C {devices/lab_pin.sym} 10980 -13770 0 1 {name=p10697 lab=_62078_/Y }
C {sky130_stdcells/o32ai_4.sym} 10900 -13770 0 0 {name=X_62078_ }
C {devices/lab_pin.sym} 10820 -13630 0 0 {name=p10698 lab=_53918_/Y }
C {devices/lab_pin.sym} 10820 -13590 0 0 {name=p10699 lab=_53914_/X }
C {devices/lab_pin.sym} 10820 -13550 0 0 {name=p10700 lab=_53919_/Y }
C {devices/lab_pin.sym} 10980 -13590 0 1 {name=p10701 lab=_53920_/Y }
C {sky130_stdcells/a21boi_4.sym} 10900 -13590 0 0 {name=X_53920_ }
C {devices/lab_pin.sym} 10840 -13460 0 0 {name=p10702 lab=_65932_/A }
C {devices/lab_pin.sym} 10840 -13420 0 0 {name=p10703 lab=_73561_/B }
C {devices/lab_pin.sym} 10960 -13440 0 1 {name=p10704 lab=_65906_/X }
C {sky130_stdcells/and2_4.sym} 10900 -13440 0 0 {name=X_65906_ }
C {devices/lab_pin.sym} 10860 -13310 0 0 {name=p10705 lab=_61028_/X }
C {devices/lab_pin.sym} 10940 -13310 0 1 {name=p10706 lab=_61030_/A }
C {sky130_stdcells/inv_2.sym} 10900 -13310 0 0 {name=X_61029_ }
C {devices/lab_pin.sym} 10810 -13190 0 0 {name=p10707 lab=_83766_/CLK }
C {devices/lab_pin.sym} 10810 -13170 0 0 {name=p10708 lab=_84740_/D }
C {devices/lab_pin.sym} 10990 -13190 0 1 {name=p10709 lab=_84740_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -13180 0 0 {name=X_84740_ }
C {devices/lab_pin.sym} 10820 -13080 0 0 {name=p10710 lab=_87563_/Q }
C {devices/lab_pin.sym} 10820 -13040 0 0 {name=p10711 lab=_69645_/X }
C {devices/lab_pin.sym} 10820 -13000 0 0 {name=p10712 lab=_68613_/X }
C {devices/lab_pin.sym} 10820 -12960 0 0 {name=p10713 lab=_69673_/X }
C {devices/lab_pin.sym} 10980 -13020 0 1 {name=p10714 lab=_69674_/X }
C {sky130_stdcells/a211o_4.sym} 10900 -13020 0 0 {name=X_69674_ }
C {devices/lab_pin.sym} 10810 -12870 0 0 {name=p10715 lab=_82145_/CLK }
C {devices/lab_pin.sym} 10810 -12850 0 0 {name=p10716 lab=_78024_/Y }
C {devices/lab_pin.sym} 10990 -12870 0 1 {name=p10717 lab=_81952_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -12860 0 0 {name=X_81952_ }
C {devices/lab_pin.sym} 10840 -12740 0 0 {name=p10718 lab=_66886_/A }
C {devices/lab_pin.sym} 10840 -12700 0 0 {name=p10719 lab=_66885_/X }
C {devices/lab_pin.sym} 10960 -12720 0 1 {name=p10720 lab=_66886_/Y }
C {sky130_stdcells/nand2_4.sym} 10900 -12720 0 0 {name=X_66886_ }
C {devices/lab_pin.sym} 10810 -12590 0 0 {name=p10721 lab=_83933_/CLK }
C {devices/lab_pin.sym} 10810 -12570 0 0 {name=p10722 lab=_80903_/D }
C {devices/lab_pin.sym} 10990 -12590 0 1 {name=p10723 lab=_75621_/A }
C {sky130_stdcells/dfxtp_4.sym} 10900 -12580 0 0 {name=X_80903_ }
C {devices/lab_pin.sym} 10820 -12480 0 0 {name=p10724 lab=_88009_/Q }
C {devices/lab_pin.sym} 10820 -12440 0 0 {name=p10725 lab=_68527_/X }
C {devices/lab_pin.sym} 10820 -12400 0 0 {name=p10726 lab=_68501_/X }
C {devices/lab_pin.sym} 10820 -12360 0 0 {name=p10727 lab=_68624_/X }
C {devices/lab_pin.sym} 10980 -12420 0 1 {name=p10728 lab=_68625_/X }
C {sky130_stdcells/a211o_4.sym} 10900 -12420 0 0 {name=X_68625_ }
C {devices/lab_pin.sym} 10820 -12290 0 0 {name=p10729 lab=_53849_/Y }
C {devices/lab_pin.sym} 10820 -12250 0 0 {name=p10730 lab=_53838_/X }
C {devices/lab_pin.sym} 10820 -12210 0 0 {name=p10731 lab=_53850_/Y }
C {devices/lab_pin.sym} 10980 -12250 0 1 {name=p10732 lab=_85556_/D }
C {sky130_stdcells/a21boi_4.sym} 10900 -12250 0 0 {name=X_53851_ }
C {devices/lab_pin.sym} 10820 -12140 0 0 {name=p10733 lab=_64696_/X }
C {devices/lab_pin.sym} 10820 -12100 0 0 {name=p10734 lab=_85574_/Q }
C {devices/lab_pin.sym} 10820 -12060 0 0 {name=p10735 lab=_64697_/X }
C {devices/lab_pin.sym} 10820 -12020 0 0 {name=p10736 lab=_65836_/X }
C {devices/lab_pin.sym} 10980 -12080 0 1 {name=p10737 lab=_65837_/X }
C {sky130_stdcells/a211o_4.sym} 10900 -12080 0 0 {name=X_65837_ }
C {devices/lab_pin.sym} 10810 -11930 0 0 {name=p10738 lab=_84671_/CLK }
C {devices/lab_pin.sym} 10810 -11910 0 0 {name=p10739 lab=_84671_/D }
C {devices/lab_pin.sym} 10990 -11930 0 1 {name=p10740 lab=_60047_/C }
C {sky130_stdcells/dfxtp_4.sym} 10900 -11920 0 0 {name=X_84671_ }
C {devices/lab_pin.sym} 10810 -11790 0 0 {name=p10741 lab=_81883_/CLK }
C {devices/lab_pin.sym} 10810 -11770 0 0 {name=p10742 lab=_78074_/X }
C {devices/lab_pin.sym} 10990 -11790 0 1 {name=p10743 lab=_81883_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -11780 0 0 {name=X_81883_ }
C {devices/lab_pin.sym} 10810 -11650 0 0 {name=p10744 lab=_86127_/CLK }
C {devices/lab_pin.sym} 10810 -11630 0 0 {name=p10745 lab=_86410_/D }
C {devices/lab_pin.sym} 10990 -11650 0 1 {name=p10746 lab=_86410_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -11640 0 0 {name=X_86410_ }
C {devices/lab_pin.sym} 10820 -11530 0 0 {name=p10747 lab=_52800_/Y }
C {devices/lab_pin.sym} 10820 -11490 0 0 {name=p10748 lab=_52783_/X }
C {devices/lab_pin.sym} 10820 -11450 0 0 {name=p10749 lab=_52801_/X }
C {devices/lab_pin.sym} 10980 -11490 0 1 {name=p10750 lab=_85752_/D }
C {sky130_stdcells/a21oi_4.sym} 10900 -11490 0 0 {name=X_52802_ }
C {devices/lab_pin.sym} 10810 -11350 0 0 {name=p10751 lab=_83310_/CLK }
C {devices/lab_pin.sym} 10810 -11330 0 0 {name=p10752 lab=_71059_/Y }
C {devices/lab_pin.sym} 10990 -11350 0 1 {name=p10753 lab=_83622_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -11340 0 0 {name=X_83622_ }
C {devices/lab_pin.sym} 10840 -11220 0 0 {name=p10754 lab=_56564_/C }
C {devices/lab_pin.sym} 10840 -11180 0 0 {name=p10755 lab=_56569_/X }
C {devices/lab_pin.sym} 10960 -11200 0 1 {name=p10756 lab=_56570_/Y }
C {sky130_stdcells/xnor2_4.sym} 10900 -11200 0 0 {name=X_56570_ }
C {devices/lab_pin.sym} 10810 -11070 0 0 {name=p10757 lab=_80835_/CLK }
C {devices/lab_pin.sym} 10810 -11050 0 0 {name=p10758 lab=_80834_/D }
C {devices/lab_pin.sym} 10990 -11070 0 1 {name=p10759 lab=_74848_/B }
C {sky130_stdcells/dfxtp_4.sym} 10900 -11060 0 0 {name=X_80834_ }
C {devices/lab_pin.sym} 10840 -10940 0 0 {name=p10760 lab=_68366_/X }
C {devices/lab_pin.sym} 10840 -10900 0 0 {name=p10761 lab=_42475_/Y }
C {devices/lab_pin.sym} 10960 -10920 0 1 {name=p10762 lab=_68556_/Y }
C {sky130_stdcells/nor2_4.sym} 10900 -10920 0 0 {name=X_68556_ }
C {devices/lab_pin.sym} 10810 -10790 0 0 {name=p10763 lab=_87644_/CLK }
C {devices/lab_pin.sym} 10810 -10770 0 0 {name=p10764 lab=_87390_/D }
C {devices/lab_pin.sym} 10990 -10790 0 1 {name=p10765 lab=_87390_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -10780 0 0 {name=X_87390_ }
C {devices/lab_pin.sym} 10840 -10670 0 0 {name=p10766 lab=_48885_/A }
C {devices/lab_pin.sym} 10840 -10630 0 0 {name=p10767 lab=_53774_/B }
C {devices/lab_pin.sym} 10840 -10590 0 0 {name=p10768 lab=_53774_/C }
C {devices/lab_pin.sym} 10960 -10630 0 1 {name=p10769 lab=_53782_/X }
C {sky130_stdcells/and3_4.sym} 10900 -10630 0 0 {name=X_53782_ }
C {devices/lab_pin.sym} 10860 -10490 0 0 {name=p10770 lab=_65768_/A }
C {devices/lab_pin.sym} 10940 -10490 0 1 {name=p10771 lab=_65768_/X }
C {sky130_stdcells/buf_2.sym} 10900 -10490 0 0 {name=X_65768_ }
C {devices/lab_pin.sym} 10840 -10380 0 0 {name=p10772 lab=_51003_/A }
C {devices/lab_pin.sym} 10840 -10340 0 0 {name=p10773 lab=_46805_/X }
C {devices/lab_pin.sym} 10960 -10360 0 1 {name=p10774 lab=_50994_/Y }
C {sky130_stdcells/nand2_4.sym} 10900 -10360 0 0 {name=X_50994_ }
C {devices/lab_pin.sym} 10820 -10260 0 0 {name=p10775 lab=_45549_/A }
C {devices/lab_pin.sym} 10820 -10220 0 0 {name=p10776 lab=_55511_/X }
C {devices/lab_pin.sym} 10820 -10180 0 0 {name=p10777 lab=_55506_/X }
C {devices/lab_pin.sym} 10820 -10140 0 0 {name=p10778 lab=_55520_/Y }
C {devices/lab_pin.sym} 10980 -10200 0 1 {name=p10779 lab=_55521_/X }
C {sky130_stdcells/a211o_4.sym} 10900 -10200 0 0 {name=X_55521_ }
C {devices/lab_pin.sym} 10860 -10050 0 0 {name=p10780 lab=_67863_/A }
C {devices/lab_pin.sym} 10940 -10050 0 1 {name=p10781 lab=_67507_/X }
C {sky130_stdcells/buf_2.sym} 10900 -10050 0 0 {name=X_67507_ }
C {devices/lab_pin.sym} 10810 -9930 0 0 {name=p10782 lab=_86342_/CLK }
C {devices/lab_pin.sym} 10810 -9910 0 0 {name=p10783 lab=_49693_/Y }
C {devices/lab_pin.sym} 10990 -9930 0 1 {name=p10784 lab=_86341_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -9920 0 0 {name=X_86341_ }
C {devices/lab_pin.sym} 10820 -9810 0 0 {name=p10785 lab=_85764_/Q }
C {devices/lab_pin.sym} 10820 -9770 0 0 {name=p10786 lab=_52711_/X }
C {devices/lab_pin.sym} 10820 -9730 0 0 {name=p10787 lab=_52732_/Y }
C {devices/lab_pin.sym} 10980 -9770 0 1 {name=p10788 lab=_52733_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -9770 0 0 {name=X_52733_ }
C {devices/lab_pin.sym} 10840 -9640 0 0 {name=p10789 lab=_64826_/A }
C {devices/lab_pin.sym} 10840 -9600 0 0 {name=p10790 lab=_64719_/B }
C {devices/lab_pin.sym} 10960 -9620 0 1 {name=p10791 lab=_64719_/X }
C {sky130_stdcells/and2_4.sym} 10900 -9620 0 0 {name=X_64719_ }
C {devices/lab_pin.sym} 10810 -9490 0 0 {name=p10792 lab=_83550_/CLK }
C {devices/lab_pin.sym} 10810 -9470 0 0 {name=p10793 lab=_71270_/Y }
C {devices/lab_pin.sym} 10990 -9490 0 1 {name=p10794 lab=_83553_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -9480 0 0 {name=X_83553_ }
C {devices/lab_pin.sym} 10810 -9350 0 0 {name=p10795 lab=_80817_/CLK }
C {devices/lab_pin.sym} 10810 -9330 0 0 {name=p10796 lab=_75493_/Y }
C {devices/lab_pin.sym} 10990 -9350 0 1 {name=p10797 lab=_81141_/D }
C {sky130_stdcells/dfxtp_4.sym} 10900 -9340 0 0 {name=X_80765_ }
C {devices/lab_pin.sym} 10820 -9230 0 0 {name=p10798 lab=_68484_/X }
C {devices/lab_pin.sym} 10820 -9190 0 0 {name=p10799 lab=_68486_/X }
C {devices/lab_pin.sym} 10820 -9150 0 0 {name=p10800 lab=_68331_/X }
C {devices/lab_pin.sym} 10980 -9190 0 1 {name=p10801 lab=_68487_/Y }
C {sky130_stdcells/a21oi_4.sym} 10900 -9190 0 0 {name=X_68487_ }
C {devices/lab_pin.sym} 10820 -9070 0 0 {name=p10802 lab=_65696_/Y }
C {devices/lab_pin.sym} 10820 -9030 0 0 {name=p10803 lab=_65681_/X }
C {devices/lab_pin.sym} 10820 -8990 0 0 {name=p10804 lab=_65698_/X }
C {devices/lab_pin.sym} 10980 -9030 0 1 {name=p10805 lab=_84184_/D }
C {sky130_stdcells/a21o_4.sym} 10900 -9030 0 0 {name=X_65699_ }
C {devices/lab_pin.sym} 10860 -8890 0 0 {name=p10806 lab=_58240_/A }
C {devices/lab_pin.sym} 10940 -8890 0 1 {name=p10807 lab=_58240_/Y }
C {sky130_stdcells/inv_2.sym} 10900 -8890 0 0 {name=X_58240_ }
C {devices/lab_pin.sym} 10810 -8770 0 0 {name=p10808 lab=_81198_/CLK }
C {devices/lab_pin.sym} 10810 -8750 0 0 {name=p10809 lab=_78852_/X }
C {devices/lab_pin.sym} 10990 -8770 0 1 {name=p10810 lab=_82504_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -8760 0 0 {name=X_82504_ }
C {devices/lab_pin.sym} 10820 -8650 0 0 {name=p10811 lab=_55394_/Y }
C {devices/lab_pin.sym} 10820 -8610 0 0 {name=p10812 lab=_55444_/Y }
C {devices/lab_pin.sym} 10820 -8570 0 0 {name=p10813 lab=_55676_/B }
C {devices/lab_pin.sym} 10980 -8610 0 1 {name=p10814 lab=_55650_/A }
C {sky130_stdcells/o21ai_4.sym} 10900 -8610 0 0 {name=X_55452_ }
C {devices/lab_pin.sym} 10820 -8500 0 0 {name=p10815 lab=_87983_/Q }
C {devices/lab_pin.sym} 10820 -8460 0 0 {name=p10816 lab=_67414_/X }
C {devices/lab_pin.sym} 10820 -8420 0 0 {name=p10817 lab=_67391_/X }
C {devices/lab_pin.sym} 10820 -8380 0 0 {name=p10818 lab=_67437_/X }
C {devices/lab_pin.sym} 10980 -8440 0 1 {name=p10819 lab=_67438_/X }
C {sky130_stdcells/a211o_4.sym} 10900 -8440 0 0 {name=X_67438_ }
C {devices/lab_pin.sym} 10810 -8290 0 0 {name=p10820 lab=_83310_/CLK }
C {devices/lab_pin.sym} 10810 -8270 0 0 {name=p10821 lab=_50060_/Y }
C {devices/lab_pin.sym} 10990 -8290 0 1 {name=p10822 lab=_64627_/B }
C {sky130_stdcells/dfxtp_4.sym} 10900 -8280 0 0 {name=X_86272_ }
C {devices/lab_pin.sym} 10820 -8170 0 0 {name=p10823 lab=_85777_/Q }
C {devices/lab_pin.sym} 10820 -8130 0 0 {name=p10824 lab=_52656_/X }
C {devices/lab_pin.sym} 10820 -8090 0 0 {name=p10825 lab=_52663_/Y }
C {devices/lab_pin.sym} 10980 -8130 0 1 {name=p10826 lab=_52664_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -8130 0 0 {name=X_52664_ }
C {devices/lab_pin.sym} 10810 -7990 0 0 {name=p10827 lab=_83414_/CLK }
C {devices/lab_pin.sym} 10810 -7970 0 0 {name=p10828 lab=_83484_/D }
C {devices/lab_pin.sym} 10990 -7990 0 1 {name=p10829 lab=_83484_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -7980 0 0 {name=X_83484_ }
C {devices/lab_pin.sym} 10810 -7850 0 0 {name=p10830 lab=_80696_/CLK }
C {devices/lab_pin.sym} 10810 -7830 0 0 {name=p10831 lab=_80696_/D }
C {devices/lab_pin.sym} 10990 -7850 0 1 {name=p10832 lab=_75393_/A }
C {sky130_stdcells/dfxtp_4.sym} 10900 -7840 0 0 {name=X_80696_ }
C {devices/lab_pin.sym} 10810 -7710 0 0 {name=p10833 lab=_87757_/CLK }
C {devices/lab_pin.sym} 10810 -7690 0 0 {name=p10834 lab=_88011_/D }
C {devices/lab_pin.sym} 10990 -7710 0 1 {name=p10835 lab=_88011_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -7700 0 0 {name=X_88011_ }
C {sky130_stdcells/decap_3.sym} 10900 -7540 0 0 {name=XPHY_704 }
C {devices/lab_pin.sym} 10820 -7410 0 0 {name=p10836 lab=_54398_/Y }
C {devices/lab_pin.sym} 10820 -7370 0 0 {name=p10837 lab=_54394_/X }
C {devices/lab_pin.sym} 10820 -7330 0 0 {name=p10838 lab=_54402_/X }
C {devices/lab_pin.sym} 10980 -7370 0 1 {name=p10839 lab=_54403_/Y }
C {sky130_stdcells/a21oi_4.sym} 10900 -7370 0 0 {name=X_54403_ }
C {devices/lab_pin.sym} 10810 -7230 0 0 {name=p10840 lab=_85190_/CLK }
C {devices/lab_pin.sym} 10810 -7210 0 0 {name=p10841 lab=_85223_/D }
C {devices/lab_pin.sym} 10990 -7230 0 1 {name=p10842 lab=_55756_/B }
C {sky130_stdcells/dfxtp_4.sym} 10900 -7220 0 0 {name=X_85223_ }
C {devices/lab_pin.sym} 10840 -7120 0 0 {name=p10843 lab=_51619_/A }
C {devices/lab_pin.sym} 10840 -7080 0 0 {name=p10844 lab=_51619_/B }
C {devices/lab_pin.sym} 10840 -7040 0 0 {name=p10845 lab=_51608_/X }
C {devices/lab_pin.sym} 10840 -7000 0 0 {name=p10846 lab=_53139_/D }
C {devices/lab_pin.sym} 10960 -7060 0 1 {name=p10847 lab=_51615_/X }
C {sky130_stdcells/and4_4.sym} 10900 -7060 0 0 {name=X_51615_ }
C {devices/lab_pin.sym} 10860 -6910 0 0 {name=p10848 lab=_58253_/A }
C {devices/lab_pin.sym} 10940 -6910 0 1 {name=p10849 lab=_58171_/X }
C {sky130_stdcells/buf_2.sym} 10900 -6910 0 0 {name=X_58171_ }
C {devices/lab_pin.sym} 10810 -6790 0 0 {name=p10850 lab=_82443_/CLK }
C {devices/lab_pin.sym} 10810 -6770 0 0 {name=p10851 lab=_79127_/X }
C {devices/lab_pin.sym} 10990 -6790 0 1 {name=p10852 lab=_82435_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -6780 0 0 {name=X_82435_ }
C {sky130_stdcells/decap_3.sym} 10900 -6620 0 0 {name=XPHY_715 }
C {devices/lab_pin.sym} 10840 -6490 0 0 {name=p10853 lab=_55383_/A }
C {devices/lab_pin.sym} 10840 -6450 0 0 {name=p10854 lab=_55384_/A }
C {devices/lab_pin.sym} 10840 -6410 0 0 {name=p10855 lab=_55383_/C }
C {devices/lab_pin.sym} 10960 -6450 0 1 {name=p10856 lab=_56719_/A }
C {sky130_stdcells/nand3_4.sym} 10900 -6450 0 0 {name=X_55383_ }
C {devices/lab_pin.sym} 10820 -6340 0 0 {name=p10857 lab=_87986_/Q }
C {devices/lab_pin.sym} 10820 -6300 0 0 {name=p10858 lab=_67293_/X }
C {devices/lab_pin.sym} 10820 -6260 0 0 {name=p10859 lab=_67271_/X }
C {devices/lab_pin.sym} 10820 -6220 0 0 {name=p10860 lab=_67368_/X }
C {devices/lab_pin.sym} 10980 -6280 0 1 {name=p10861 lab=_67369_/X }
C {sky130_stdcells/a211o_4.sym} 10900 -6280 0 0 {name=X_67369_ }
C {devices/lab_pin.sym} 10820 -6150 0 0 {name=p10862 lab=_52591_/Y }
C {devices/lab_pin.sym} 10820 -6110 0 0 {name=p10863 lab=_52592_/X }
C {devices/lab_pin.sym} 10820 -6070 0 0 {name=p10864 lab=_52594_/X }
C {devices/lab_pin.sym} 10980 -6110 0 1 {name=p10865 lab=_85790_/D }
C {sky130_stdcells/a21oi_4.sym} 10900 -6110 0 0 {name=X_52595_ }
C {devices/lab_pin.sym} 10820 -6000 0 0 {name=p10866 lab=_57121_/X }
C {devices/lab_pin.sym} 10820 -5960 0 0 {name=p10867 lab=_56643_/X }
C {devices/lab_pin.sym} 10820 -5920 0 0 {name=p10868 lab=_45611_/A }
C {devices/lab_pin.sym} 10820 -5880 0 0 {name=p10869 lab=_57192_/A }
C {devices/lab_pin.sym} 10980 -5940 0 1 {name=p10870 lab=_85075_/D }
C {sky130_stdcells/a2bb2o_4.sym} 10900 -5940 0 0 {name=X_57122_ }
C {devices/lab_pin.sym} 10820 -5810 0 0 {name=p10871 lab=_80803_/D }
C {devices/lab_pin.sym} 10820 -5770 0 0 {name=p10872 lab=_69066_/X }
C {devices/lab_pin.sym} 10820 -5730 0 0 {name=p10873 lab=_69107_/X }
C {devices/lab_pin.sym} 10980 -5770 0 1 {name=p10874 lab=_83947_/D }
C {sky130_stdcells/a21bo_4.sym} 10900 -5770 0 0 {name=X_69108_ }
C {devices/lab_pin.sym} 10840 -5660 0 0 {name=p10875 lab=_54325_/A }
C {devices/lab_pin.sym} 10840 -5620 0 0 {name=p10876 lab=_54353_/B }
C {devices/lab_pin.sym} 10840 -5580 0 0 {name=p10877 lab=_54317_/X }
C {devices/lab_pin.sym} 10840 -5540 0 0 {name=p10878 lab=_46735_/Y }
C {devices/lab_pin.sym} 10960 -5600 0 1 {name=p10879 lab=_54334_/X }
C {sky130_stdcells/and4_4.sym} 10900 -5600 0 0 {name=X_54334_ }
C {devices/lab_pin.sym} 10810 -5450 0 0 {name=p10880 lab=_82993_/CLK }
C {devices/lab_pin.sym} 10810 -5430 0 0 {name=p10881 lab=_85154_/D }
C {devices/lab_pin.sym} 10990 -5450 0 1 {name=p10882 lab=_55738_/B }
C {sky130_stdcells/dfxtp_4.sym} 10900 -5440 0 0 {name=X_85154_ }
C {devices/lab_pin.sym} 10820 -5330 0 0 {name=p10883 lab=_85990_/Q }
C {devices/lab_pin.sym} 10820 -5290 0 0 {name=p10884 lab=_51539_/X }
C {devices/lab_pin.sym} 10820 -5250 0 0 {name=p10885 lab=_51545_/Y }
C {devices/lab_pin.sym} 10980 -5290 0 1 {name=p10886 lab=_51546_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -5290 0 0 {name=X_51546_ }
C {devices/lab_pin.sym} 10820 -5170 0 0 {name=p10887 lab=_50858_/B }
C {devices/lab_pin.sym} 10820 -5130 0 0 {name=p10888 lab=_70364_/X }
C {devices/lab_pin.sym} 10820 -5090 0 0 {name=p10889 lab=_70379_/Y }
C {devices/lab_pin.sym} 10980 -5130 0 1 {name=p10890 lab=_70380_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -5130 0 0 {name=X_70380_ }
C {devices/lab_pin.sym} 10810 -4990 0 0 {name=p10891 lab=_83133_/CLK }
C {devices/lab_pin.sym} 10810 -4970 0 0 {name=p10892 lab=_82366_/D }
C {devices/lab_pin.sym} 10990 -4990 0 1 {name=p10893 lab=_82366_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -4980 0 0 {name=X_82366_ }
C {devices/lab_pin.sym} 10810 -4850 0 0 {name=p10894 lab=_84105_/CLK }
C {devices/lab_pin.sym} 10810 -4830 0 0 {name=p10895 lab=_84105_/D }
C {devices/lab_pin.sym} 10990 -4850 0 1 {name=p10896 lab=_84105_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -4840 0 0 {name=X_84105_ }
C {devices/lab_pin.sym} 10810 -4710 0 0 {name=p10897 lab=_84105_/CLK }
C {devices/lab_pin.sym} 10810 -4690 0 0 {name=p10898 lab=_76199_/Y }
C {devices/lab_pin.sym} 10990 -4710 0 1 {name=p10899 lab=_81725_/D }
C {sky130_stdcells/dfxtp_4.sym} 10900 -4700 0 0 {name=X_81317_ }
C {devices/lab_pin.sym} 10860 -4570 0 0 {name=p10900 lab=_57052_/X }
C {devices/lab_pin.sym} 10940 -4570 0 1 {name=p10901 lab=_85096_/D }
C {sky130_stdcells/inv_2.sym} 10900 -4570 0 0 {name=X_57053_ }
C {devices/lab_pin.sym} 10820 -4470 0 0 {name=p10902 lab=_69036_/X }
C {devices/lab_pin.sym} 10820 -4430 0 0 {name=p10903 lab=_69038_/X }
C {devices/lab_pin.sym} 10820 -4390 0 0 {name=p10904 lab=_69017_/X }
C {devices/lab_pin.sym} 10980 -4430 0 1 {name=p10905 lab=_69039_/Y }
C {sky130_stdcells/a21oi_4.sym} 10900 -4430 0 0 {name=X_69039_ }
C {devices/lab_pin.sym} 10820 -4310 0 0 {name=p10906 lab=_54262_/Y }
C {devices/lab_pin.sym} 10820 -4270 0 0 {name=p10907 lab=_54253_/X }
C {devices/lab_pin.sym} 10820 -4230 0 0 {name=p10908 lab=_54264_/X }
C {devices/lab_pin.sym} 10980 -4270 0 1 {name=p10909 lab=_54265_/Y }
C {sky130_stdcells/a21oi_4.sym} 10900 -4270 0 0 {name=X_54265_ }
C {devices/lab_pin.sym} 10810 -4130 0 0 {name=p10910 lab=_85152_/CLK }
C {devices/lab_pin.sym} 10810 -4110 0 0 {name=p10911 lab=_85085_/D }
C {devices/lab_pin.sym} 10990 -4130 0 1 {name=p10912 lab=_45455_/A }
C {sky130_stdcells/dfxtp_4.sym} 10900 -4120 0 0 {name=X_85085_ }
C {devices/lab_pin.sym} 10860 -3990 0 0 {name=p10913 lab=_51557_/A }
C {devices/lab_pin.sym} 10940 -3990 0 1 {name=p10914 lab=_51477_/X }
C {sky130_stdcells/buf_2.sym} 10900 -3990 0 0 {name=X_51477_ }
C {devices/lab_pin.sym} 10810 -3870 0 0 {name=p10915 lab=_82343_/CLK }
C {devices/lab_pin.sym} 10810 -3850 0 0 {name=p10916 lab=_81921_/Q }
C {devices/lab_pin.sym} 10990 -3870 0 1 {name=p10917 lab=_82297_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -3860 0 0 {name=X_82297_ }
C {devices/lab_pin.sym} 10840 -3740 0 0 {name=p10918 lab=_74286_/C }
C {devices/lab_pin.sym} 10840 -3700 0 0 {name=p10919 lab=_56003_/Y }
C {devices/lab_pin.sym} 10960 -3720 0 1 {name=p10920 lab=_56004_/X }
C {sky130_stdcells/xor2_4.sym} 10900 -3720 0 0 {name=X_56004_ }
C {devices/lab_pin.sym} 10860 -3590 0 0 {name=p10921 lab=_41230_/A }
C {devices/lab_pin.sym} 10940 -3590 0 1 {name=p10922 lab=_41230_/X }
C {sky130_stdcells/buf_2.sym} 10900 -3590 0 0 {name=X_41230_ }
C {devices/lab_pin.sym} 10860 -3470 0 0 {name=p10923 lab=_53190_/A }
C {devices/lab_pin.sym} 10940 -3470 0 1 {name=p10924 lab=_53217_/A }
C {sky130_stdcells/buf_2.sym} 10900 -3470 0 0 {name=X_53216_ }
C {devices/lab_pin.sym} 10820 -3370 0 0 {name=p10925 lab=_72047_/Y }
C {devices/lab_pin.sym} 10820 -3330 0 0 {name=p10926 lab=_71978_/X }
C {devices/lab_pin.sym} 10820 -3290 0 0 {name=p10927 lab=_72049_/X }
C {devices/lab_pin.sym} 10980 -3330 0 1 {name=p10928 lab=_72050_/Y }
C {sky130_stdcells/a21oi_4.sym} 10900 -3330 0 0 {name=X_72050_ }
C {devices/lab_pin.sym} 10810 -3190 0 0 {name=p10929 lab=_81160_/CLK }
C {devices/lab_pin.sym} 10810 -3170 0 0 {name=p10930 lab=_68113_/X }
C {devices/lab_pin.sym} 10990 -3190 0 1 {name=p10931 lab=_82076_/D }
C {sky130_stdcells/dfxtp_4.sym} 10900 -3180 0 0 {name=X_84036_ }
C {devices/lab_pin.sym} 10820 -3070 0 0 {name=p10932 lab=_86202_/Q }
C {devices/lab_pin.sym} 10820 -3030 0 0 {name=p10933 lab=_50403_/X }
C {devices/lab_pin.sym} 10820 -2990 0 0 {name=p10934 lab=_50427_/Y }
C {devices/lab_pin.sym} 10980 -3030 0 1 {name=p10935 lab=_50428_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -3030 0 0 {name=X_50428_ }
C {devices/lab_pin.sym} 10810 -2890 0 0 {name=p10936 lab=_85375_/CLK }
C {devices/lab_pin.sym} 10810 -2870 0 0 {name=p10937 lab=_81056_/Q }
C {devices/lab_pin.sym} 10990 -2890 0 1 {name=p10938 lab=_47539_/A }
C {sky130_stdcells/dfxtp_4.sym} 10900 -2880 0 0 {name=X_81248_ }
C {devices/lab_pin.sym} 10820 -2770 0 0 {name=p10939 lab=_85486_/Q }
C {devices/lab_pin.sym} 10820 -2730 0 0 {name=p10940 lab=_54193_/X }
C {devices/lab_pin.sym} 10820 -2690 0 0 {name=p10941 lab=_54195_/Y }
C {devices/lab_pin.sym} 10980 -2730 0 1 {name=p10942 lab=_54196_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -2730 0 0 {name=X_54196_ }
C {devices/lab_pin.sym} 10860 -2590 0 0 {name=p10943 lab=clkbuf_8_95_0_CLK/X }
C {devices/lab_pin.sym} 10940 -2590 0 1 {name=p10944 lab=clkbuf_9_190_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 10900 -2590 0 0 {name=Xclkbuf_9_190_0_CLK }
C {devices/lab_pin.sym} 10840 -2490 0 0 {name=p10945 lab=_70990_/A }
C {devices/lab_pin.sym} 10840 -2450 0 0 {name=p10946 lab=_70952_/B }
C {devices/lab_pin.sym} 10840 -2410 0 0 {name=p10947 lab=_71001_/C }
C {devices/lab_pin.sym} 10960 -2450 0 1 {name=p10948 lab=_71001_/Y }
C {sky130_stdcells/nand3_4.sym} 10900 -2450 0 0 {name=X_71001_ }
C {devices/lab_pin.sym} 10860 -2310 0 0 {name=p10949 lab=_53147_/A }
C {devices/lab_pin.sym} 10940 -2310 0 1 {name=p10950 lab=_53147_/X }
C {sky130_stdcells/buf_2.sym} 10900 -2310 0 0 {name=X_53147_ }
C {devices/lab_pin.sym} 10860 -2190 0 0 {name=p10951 lab=_41161_/A }
C {devices/lab_pin.sym} 10940 -2190 0 1 {name=p10952 lab=_41161_/X }
C {sky130_stdcells/buf_2.sym} 10900 -2190 0 0 {name=X_41161_ }
C {devices/lab_pin.sym} 10820 -2090 0 0 {name=p10953 lab=_86216_/Q }
C {devices/lab_pin.sym} 10820 -2050 0 0 {name=p10954 lab=_50333_/X }
C {devices/lab_pin.sym} 10820 -2010 0 0 {name=p10955 lab=_50358_/Y }
C {devices/lab_pin.sym} 10980 -2050 0 1 {name=p10956 lab=_50359_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -2050 0 0 {name=X_50359_ }
C {devices/lab_pin.sym} 10810 -1910 0 0 {name=p10957 lab=_81179_/CLK }
C {devices/lab_pin.sym} 10810 -1890 0 0 {name=p10958 lab=_75028_/B }
C {devices/lab_pin.sym} 10990 -1910 0 1 {name=p10959 lab=_81179_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -1900 0 0 {name=X_81179_ }
C {devices/lab_pin.sym} 10820 -1790 0 0 {name=p10960 lab=_41024_/X }
C {devices/lab_pin.sym} 10820 -1750 0 0 {name=p10961 lab=_41266_/A }
C {devices/lab_pin.sym} 10820 -1710 0 0 {name=p10962 lab=_41091_/X }
C {devices/lab_pin.sym} 10980 -1750 0 1 {name=p10963 lab=_41092_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -1750 0 0 {name=X_41092_ }
C {devices/lab_pin.sym} 10840 -1640 0 0 {name=p10964 lab=_53074_/A }
C {devices/lab_pin.sym} 10840 -1600 0 0 {name=p10965 lab=_53069_/X }
C {devices/lab_pin.sym} 10840 -1560 0 0 {name=p10966 lab=_53074_/C }
C {devices/lab_pin.sym} 10840 -1520 0 0 {name=p10967 lab=_53078_/D }
C {devices/lab_pin.sym} 10960 -1580 0 1 {name=p10968 lab=_53078_/X }
C {sky130_stdcells/and4_4.sym} 10900 -1580 0 0 {name=X_53078_ }
C {devices/lab_pin.sym} 10840 -1440 0 0 {name=p10969 lab=_86641_/Q }
C {devices/lab_pin.sym} 10840 -1400 0 0 {name=p10970 lab=_57954_/X }
C {devices/lab_pin.sym} 10960 -1420 0 1 {name=p10971 lab=_57955_/Y }
C {sky130_stdcells/nor2_4.sym} 10900 -1420 0 0 {name=X_57955_ }
C {devices/lab_pin.sym} 10810 -1290 0 0 {name=p10972 lab=_85700_/CLK }
C {devices/lab_pin.sym} 10810 -1270 0 0 {name=p10973 lab=_51564_/Y }
C {devices/lab_pin.sym} 10990 -1290 0 1 {name=p10974 lab=_85987_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10900 -1280 0 0 {name=X_85987_ }
C {devices/lab_pin.sym} 10820 -1170 0 0 {name=p10975 lab=_85312_/Q }
C {devices/lab_pin.sym} 10820 -1130 0 0 {name=p10976 lab=_45876_/B }
C {devices/lab_pin.sym} 10820 -1090 0 0 {name=p10977 lab=_44919_/X }
C {devices/lab_pin.sym} 10980 -1130 0 1 {name=p10978 lab=_44920_/Y }
C {sky130_stdcells/o21ai_4.sym} 10900 -1130 0 0 {name=X_44920_ }
C {devices/lab_pin.sym} 10840 -1000 0 0 {name=p10979 lab=_52058_/A }
C {devices/lab_pin.sym} 10840 -960 0 0 {name=p10980 lab=_50326_/B }
C {devices/lab_pin.sym} 10960 -980 0 1 {name=p10981 lab=_52029_/Y }
C {sky130_stdcells/nand2_4.sym} 10900 -980 0 0 {name=X_52029_ }
C {devices/lab_pin.sym} 10840 -860 0 0 {name=p10982 lab=_55227_/A }
C {devices/lab_pin.sym} 10840 -820 0 0 {name=p10983 lab=_55225_/X }
C {devices/lab_pin.sym} 10960 -840 0 1 {name=p10984 lab=_56906_/X }
C {sky130_stdcells/and2_4.sym} 10900 -840 0 0 {name=X_56906_ }
C {devices/lab_pin.sym} 10840 -720 0 0 {name=p10985 lab=_75735_/Y }
C {devices/lab_pin.sym} 10840 -680 0 0 {name=p10986 lab=_75740_/B }
C {devices/lab_pin.sym} 10960 -700 0 1 {name=p10987 lab=_75741_/B }
C {sky130_stdcells/xor2_4.sym} 10900 -700 0 0 {name=X_75740_ }
C {devices/lab_pin.sym} 11730 -42150 0 0 {name=p10988 lab=_87472_/CLK }
C {devices/lab_pin.sym} 11730 -42130 0 0 {name=p10989 lab=_42771_/X }
C {devices/lab_pin.sym} 11910 -42150 0 1 {name=p10990 lab=_67451_/B }
C {sky130_stdcells/dfxtp_4.sym} 11820 -42140 0 0 {name=X_87726_ }
C {devices/lab_pin.sym} 11740 -42030 0 0 {name=p10991 lab=_72946_/X }
C {devices/lab_pin.sym} 11740 -41990 0 0 {name=p10992 lab=_72948_/X }
C {devices/lab_pin.sym} 11740 -41950 0 0 {name=p10993 lab=_72951_/X }
C {devices/lab_pin.sym} 11900 -41990 0 1 {name=p10994 lab=_72969_/B }
C {sky130_stdcells/a21o_4.sym} 11820 -41990 0 0 {name=X_72952_ }
C {devices/lab_pin.sym} 11730 -41850 0 0 {name=p10995 lab=_83736_/CLK }
C {devices/lab_pin.sym} 11730 -41830 0 0 {name=p10996 lab=_57943_/Y }
C {devices/lab_pin.sym} 11910 -41850 0 1 {name=p10997 lab=_84938_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -41840 0 0 {name=X_84938_ }
C {devices/lab_pin.sym} 11740 -41730 0 0 {name=p10998 lab=_57760_/X }
C {devices/lab_pin.sym} 11740 -41690 0 0 {name=p10999 lab=_85398_/Q }
C {devices/lab_pin.sym} 11740 -41650 0 0 {name=p11000 lab=_57885_/X }
C {devices/lab_pin.sym} 11900 -41690 0 1 {name=p11001 lab=_57886_/Y }
C {sky130_stdcells/o21ai_4.sym} 11820 -41690 0 0 {name=X_57886_ }
C {devices/lab_pin.sym} 11760 -41580 0 0 {name=p11002 lab=_70383_/X }
C {devices/lab_pin.sym} 11760 -41540 0 0 {name=p11003 lab=_71893_/X }
C {devices/lab_pin.sym} 11760 -41500 0 0 {name=p11004 lab=_71902_/X }
C {devices/lab_pin.sym} 11760 -41460 0 0 {name=p11005 lab=_71898_/D }
C {devices/lab_pin.sym} 11880 -41520 0 1 {name=p11006 lab=_71903_/Y }
C {sky130_stdcells/nand4_4.sym} 11820 -41520 0 0 {name=X_71903_ }
C {devices/lab_pin.sym} 11780 -41370 0 0 {name=p11007 lab=_59624_/X }
C {devices/lab_pin.sym} 11860 -41370 0 1 {name=p11008 lab=_59664_/A }
C {sky130_stdcells/buf_2.sym} 11820 -41370 0 0 {name=X_59625_ }
C {devices/lab_pin.sym} 11740 -41280 0 0 {name=p11009 lab=_41748_/Y }
C {devices/lab_pin.sym} 11740 -41240 0 0 {name=p11010 lab=_44848_/X }
C {devices/lab_pin.sym} 11740 -41200 0 0 {name=p11011 lab=_86920_/Q }
C {devices/lab_pin.sym} 11740 -41160 0 0 {name=p11012 lab=_44849_/X }
C {devices/lab_pin.sym} 11900 -41220 0 1 {name=p11013 lab=_86920_/D }
C {sky130_stdcells/a2bb2o_4.sym} 11820 -41220 0 0 {name=X_44851_ }
C {devices/lab_pin.sym} 11740 -41100 0 0 {name=p11014 lab=_56698_/Y }
C {devices/lab_pin.sym} 11740 -41060 0 0 {name=p11015 lab=_56836_/Y }
C {devices/lab_pin.sym} 11740 -41020 0 0 {name=p11016 lab=_56713_/A }
C {devices/lab_pin.sym} 11740 -40980 0 0 {name=p11017 lab=_56707_/X }
C {devices/lab_pin.sym} 11900 -41040 0 1 {name=p11018 lab=_56837_/X }
C {sky130_stdcells/a211o_4.sym} 11820 -41040 0 0 {name=X_56837_ }
C {devices/lab_pin.sym} 11780 -40890 0 0 {name=p11019 lab=_75657_/Y }
C {devices/lab_pin.sym} 11860 -40890 0 1 {name=p11020 lab=_80780_/D }
C {sky130_stdcells/inv_2.sym} 11820 -40890 0 0 {name=X_75671_ }
C {devices/lab_pin.sym} 11730 -40770 0 0 {name=p11021 lab=_87397_/CLK }
C {devices/lab_pin.sym} 11730 -40750 0 0 {name=p11022 lab=_42910_/Y }
C {devices/lab_pin.sym} 11910 -40770 0 1 {name=p11023 lab=_87657_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -40760 0 0 {name=X_87657_ }
C {devices/lab_pin.sym} 11760 -40640 0 0 {name=p11024 lab=_72883_/A }
C {devices/lab_pin.sym} 11760 -40600 0 0 {name=p11025 lab=_72883_/B }
C {devices/lab_pin.sym} 11880 -40620 0 1 {name=p11026 lab=_72884_/B }
C {sky130_stdcells/nand2_4.sym} 11820 -40620 0 0 {name=X_72883_ }
C {devices/lab_pin.sym} 11730 -40490 0 0 {name=p11027 lab=_84869_/CLK }
C {devices/lab_pin.sym} 11730 -40470 0 0 {name=p11028 lab=_84869_/D }
C {devices/lab_pin.sym} 11910 -40490 0 1 {name=p11029 lab=_84869_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -40480 0 0 {name=X_84869_ }
C {devices/lab_pin.sym} 11760 -40360 0 0 {name=p11030 lab=_77409_/A }
C {devices/lab_pin.sym} 11760 -40320 0 0 {name=p11031 lab=_82095_/D }
C {devices/lab_pin.sym} 11880 -40340 0 1 {name=p11032 lab=_77410_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -40340 0 0 {name=X_77410_ }
C {devices/lab_pin.sym} 11780 -40210 0 0 {name=p11033 lab=_43802_/A }
C {devices/lab_pin.sym} 11860 -40210 0 1 {name=p11034 lab=_43802_/X }
C {sky130_stdcells/buf_2.sym} 11820 -40210 0 0 {name=X_43802_ }
C {devices/lab_pin.sym} 11730 -40090 0 0 {name=p11035 lab=_86610_/CLK }
C {devices/lab_pin.sym} 11730 -40070 0 0 {name=p11036 lab=_86608_/D }
C {devices/lab_pin.sym} 11910 -40090 0 1 {name=p11037 lab=_72332_/A }
C {sky130_stdcells/dfxtp_4.sym} 11820 -40080 0 0 {name=X_86608_ }
C {devices/lab_pin.sym} 11740 -39970 0 0 {name=p11038 lab=_45347_/A }
C {devices/lab_pin.sym} 11740 -39930 0 0 {name=p11039 lab=_74612_/X }
C {devices/lab_pin.sym} 11740 -39890 0 0 {name=p11040 lab=_74621_/X }
C {devices/lab_pin.sym} 11900 -39930 0 1 {name=p11041 lab=_83012_/D }
C {sky130_stdcells/o21ai_4.sym} 11820 -39930 0 0 {name=X_74622_ }
C {devices/lab_pin.sym} 11780 -39790 0 0 {name=p11042 lab=_47619_/A }
C {devices/lab_pin.sym} 11860 -39790 0 1 {name=p11043 lab=_47570_/X }
C {sky130_stdcells/buf_2.sym} 11820 -39790 0 0 {name=X_47570_ }
C {devices/lab_pin.sym} 11740 -39690 0 0 {name=p11044 lab=_71825_/X }
C {devices/lab_pin.sym} 11740 -39650 0 0 {name=p11045 lab=_83359_/Q }
C {devices/lab_pin.sym} 11740 -39610 0 0 {name=p11046 lab=_71833_/X }
C {devices/lab_pin.sym} 11900 -39650 0 1 {name=p11047 lab=_83359_/D }
C {sky130_stdcells/a21o_4.sym} 11820 -39650 0 0 {name=X_71834_ }
C {devices/lab_pin.sym} 11780 -39510 0 0 {name=p11048 lab=_61276_/B }
C {devices/lab_pin.sym} 11860 -39510 0 1 {name=p11049 lab=_60599_/A }
C {sky130_stdcells/buf_2.sym} 11820 -39510 0 0 {name=X_59556_ }
C {devices/lab_pin.sym} 11760 -39410 0 0 {name=p11050 lab=_78390_/A }
C {devices/lab_pin.sym} 11760 -39370 0 0 {name=p11051 lab=_82792_/Q }
C {devices/lab_pin.sym} 11760 -39330 0 0 {name=p11052 lab=_78385_/Y }
C {devices/lab_pin.sym} 11880 -39370 0 1 {name=p11053 lab=_78394_/B }
C {sky130_stdcells/nand3_4.sym} 11820 -39370 0 0 {name=X_78390_ }
C {devices/lab_pin.sym} 11740 -39270 0 0 {name=p11054 lab=_44766_/X }
C {devices/lab_pin.sym} 11740 -39230 0 0 {name=p11055 lab=_44767_/X }
C {devices/lab_pin.sym} 11740 -39190 0 0 {name=p11056 lab=_41381_/X }
C {devices/lab_pin.sym} 11740 -39150 0 0 {name=p11057 lab=_86957_/Q }
C {devices/lab_pin.sym} 11740 -39110 0 0 {name=p11058 lab=_44768_/X }
C {devices/lab_pin.sym} 11900 -39190 0 1 {name=p11059 lab=_44783_/A }
C {sky130_stdcells/o32ai_4.sym} 11820 -39190 0 0 {name=X_44782_ }
C {devices/lab_pin.sym} 11780 -39030 0 0 {name=p11060 lab=_56653_/Y }
C {devices/lab_pin.sym} 11860 -39030 0 1 {name=p11061 lab=_56768_/Y }
C {sky130_stdcells/inv_2.sym} 11820 -39030 0 0 {name=X_56768_ }
C {devices/lab_pin.sym} 11730 -38910 0 0 {name=p11062 lab=_87588_/CLK }
C {devices/lab_pin.sym} 11730 -38890 0 0 {name=p11063 lab=_43069_/Y }
C {devices/lab_pin.sym} 11910 -38910 0 1 {name=p11064 lab=_43068_/A }
C {sky130_stdcells/dfxtp_4.sym} 11820 -38900 0 0 {name=X_87588_ }
C {devices/lab_pin.sym} 11780 -38770 0 0 {name=p11065 lab=_88078_/Q }
C {devices/lab_pin.sym} 11860 -38770 0 1 {name=p11066 lab=_41994_/Y }
C {sky130_stdcells/inv_2.sym} 11820 -38770 0 0 {name=X_41994_ }
C {devices/lab_pin.sym} 11760 -38660 0 0 {name=p11067 lab=_46434_/A }
C {devices/lab_pin.sym} 11760 -38620 0 0 {name=p11068 lab=_51358_/B }
C {devices/lab_pin.sym} 11880 -38640 0 1 {name=p11069 lab=_46521_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -38640 0 0 {name=X_46521_ }
C {devices/lab_pin.sym} 11740 -38530 0 0 {name=p11070 lab=_58492_/X }
C {devices/lab_pin.sym} 11740 -38490 0 0 {name=p11071 lab=_58504_/Y }
C {devices/lab_pin.sym} 11740 -38450 0 0 {name=p11072 lab=_58506_/Y }
C {devices/lab_pin.sym} 11900 -38490 0 1 {name=p11073 lab=_84832_/D }
C {sky130_stdcells/a21oi_4.sym} 11820 -38490 0 0 {name=X_58507_ }
C {devices/lab_pin.sym} 11740 -38370 0 0 {name=p11074 lab=_77326_/Y }
C {devices/lab_pin.sym} 11740 -38330 0 0 {name=p11075 lab=_77323_/Y }
C {devices/lab_pin.sym} 11740 -38290 0 0 {name=p11076 lab=_77325_/A }
C {devices/lab_pin.sym} 11900 -38330 0 1 {name=p11077 lab=_77341_/X }
C {sky130_stdcells/o21a_4.sym} 11820 -38330 0 0 {name=X_77341_ }
C {devices/lab_pin.sym} 11740 -38220 0 0 {name=p11078 lab=_40894_/A }
C {devices/lab_pin.sym} 11740 -38180 0 0 {name=p11079 lab=_43716_/X }
C {devices/lab_pin.sym} 11740 -38140 0 0 {name=p11080 lab=_69885_/B }
C {devices/lab_pin.sym} 11740 -38100 0 0 {name=p11081 lab=_43718_/X }
C {devices/lab_pin.sym} 11900 -38160 0 1 {name=p11082 lab=_43733_/X }
C {sky130_stdcells/a2bb2o_4.sym} 11820 -38160 0 0 {name=X_43733_ }
C {devices/lab_pin.sym} 11760 -38020 0 0 {name=p11083 lab=_45345_/A }
C {devices/lab_pin.sym} 11760 -37980 0 0 {name=p11084 lab=_55710_/B }
C {devices/lab_pin.sym} 11880 -38000 0 1 {name=p11085 lab=_55719_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -38000 0 0 {name=X_55719_ }
C {devices/lab_pin.sym} 11780 -37870 0 0 {name=p11086 lab=_74552_/X }
C {devices/lab_pin.sym} 11860 -37870 0 1 {name=p11087 lab=_74553_/X }
C {sky130_stdcells/buf_2.sym} 11820 -37870 0 0 {name=X_74553_ }
C {devices/lab_pin.sym} 11730 -37750 0 0 {name=p11088 lab=_86210_/CLK }
C {devices/lab_pin.sym} 11730 -37730 0 0 {name=p11089 lab=_86539_/D }
C {devices/lab_pin.sym} 11910 -37750 0 1 {name=p11090 lab=_86539_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -37740 0 0 {name=X_86539_ }
C {devices/lab_pin.sym} 11780 -37610 0 0 {name=p11091 lab=_40637_/A }
C {devices/lab_pin.sym} 11860 -37610 0 1 {name=p11092 lab=_40946_/A }
C {sky130_stdcells/buf_2.sym} 11820 -37610 0 0 {name=X_40945_ }
C {devices/lab_pin.sym} 11740 -37510 0 0 {name=p11093 lab=_71762_/X }
C {devices/lab_pin.sym} 11740 -37470 0 0 {name=p11094 lab=_83385_/Q }
C {devices/lab_pin.sym} 11740 -37430 0 0 {name=p11095 lab=_71764_/X }
C {devices/lab_pin.sym} 11900 -37470 0 1 {name=p11096 lab=_83385_/D }
C {sky130_stdcells/a21o_4.sym} 11820 -37470 0 0 {name=X_71765_ }
C {devices/lab_pin.sym} 11740 -37350 0 0 {name=p11097 lab=_46159_/X }
C {devices/lab_pin.sym} 11740 -37310 0 0 {name=p11098 lab=_59484_/Y }
C {devices/lab_pin.sym} 11740 -37270 0 0 {name=p11099 lab=_59486_/Y }
C {devices/lab_pin.sym} 11900 -37310 0 1 {name=p11100 lab=_59487_/Y }
C {sky130_stdcells/a21oi_4.sym} 11820 -37310 0 0 {name=X_59487_ }
C {devices/lab_pin.sym} 11780 -37170 0 0 {name=p11101 lab=_83336_/Q }
C {devices/lab_pin.sym} 11860 -37170 0 1 {name=p11102 lab=_56842_/A }
C {sky130_stdcells/inv_2.sym} 11820 -37170 0 0 {name=X_56699_ }
C {devices/lab_pin.sym} 11740 -37070 0 0 {name=p11103 lab=_49238_/Y }
C {devices/lab_pin.sym} 11740 -37030 0 0 {name=p11104 lab=_49214_/X }
C {devices/lab_pin.sym} 11740 -36990 0 0 {name=p11105 lab=_49239_/Y }
C {devices/lab_pin.sym} 11900 -37030 0 1 {name=p11106 lab=_86427_/D }
C {sky130_stdcells/a21boi_4.sym} 11820 -37030 0 0 {name=X_49240_ }
C {devices/lab_pin.sym} 11760 -36900 0 0 {name=p11107 lab=_73494_/Y }
C {devices/lab_pin.sym} 11760 -36860 0 0 {name=p11108 lab=_73503_/X }
C {devices/lab_pin.sym} 11880 -36880 0 1 {name=p11109 lab=_73505_/B }
C {sky130_stdcells/xnor2_4.sym} 11820 -36880 0 0 {name=X_73504_ }
C {devices/lab_pin.sym} 11780 -36750 0 0 {name=p11110 lab=_70716_/A }
C {devices/lab_pin.sym} 11860 -36750 0 1 {name=p11111 lab=_70727_/C }
C {sky130_stdcells/buf_2.sym} 11820 -36750 0 0 {name=X_70716_ }
C {devices/lab_pin.sym} 11780 -36630 0 0 {name=p11112 lab=_53874_/A }
C {devices/lab_pin.sym} 11860 -36630 0 1 {name=p11113 lab=_46472_/C }
C {sky130_stdcells/buf_2.sym} 11820 -36630 0 0 {name=X_46452_ }
C {devices/lab_pin.sym} 11760 -36520 0 0 {name=p11114 lab=_58438_/A }
C {devices/lab_pin.sym} 11760 -36480 0 0 {name=p11115 lab=_58426_/X }
C {devices/lab_pin.sym} 11880 -36500 0 1 {name=p11116 lab=_58438_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -36500 0 0 {name=X_58438_ }
C {devices/lab_pin.sym} 11740 -36390 0 0 {name=p11117 lab=_77261_/A }
C {devices/lab_pin.sym} 11740 -36350 0 0 {name=p11118 lab=_77260_/A }
C {devices/lab_pin.sym} 11740 -36310 0 0 {name=p11119 lab=_77258_/Y }
C {devices/lab_pin.sym} 11900 -36350 0 1 {name=p11120 lab=_77272_/Y }
C {sky130_stdcells/o21ai_4.sym} 11820 -36350 0 0 {name=X_77272_ }
C {devices/lab_pin.sym} 11740 -36240 0 0 {name=p11121 lab=_40729_/X }
C {devices/lab_pin.sym} 11740 -36200 0 0 {name=p11122 lab=_43656_/X }
C {devices/lab_pin.sym} 11740 -36160 0 0 {name=p11123 lab=_74145_/A }
C {devices/lab_pin.sym} 11740 -36120 0 0 {name=p11124 lab=_43657_/X }
C {devices/lab_pin.sym} 11900 -36180 0 1 {name=p11125 lab=_87322_/D }
C {sky130_stdcells/a2bb2o_4.sym} 11820 -36180 0 0 {name=X_43664_ }
C {devices/lab_pin.sym} 11740 -36050 0 0 {name=p11126 lab=_74481_/Y }
C {devices/lab_pin.sym} 11740 -36010 0 0 {name=p11127 lab=_74463_/X }
C {devices/lab_pin.sym} 11740 -35970 0 0 {name=p11128 lab=_74483_/X }
C {devices/lab_pin.sym} 11900 -36010 0 1 {name=p11129 lab=_83057_/D }
C {sky130_stdcells/a21oi_4.sym} 11820 -36010 0 0 {name=X_74484_ }
C {devices/lab_pin.sym} 11780 -35870 0 0 {name=p11130 lab=_40875_/Y }
C {devices/lab_pin.sym} 11860 -35870 0 1 {name=p11131 lab=_88319_/D }
C {sky130_stdcells/inv_2.sym} 11820 -35870 0 0 {name=X_40876_ }
C {devices/lab_pin.sym} 11760 -35770 0 0 {name=p11132 lab=_71338_/A }
C {devices/lab_pin.sym} 11760 -35730 0 0 {name=p11133 lab=_71685_/X }
C {devices/lab_pin.sym} 11760 -35690 0 0 {name=p11134 lab=_71297_/X }
C {devices/lab_pin.sym} 11880 -35730 0 1 {name=p11135 lab=_71696_/Y }
C {sky130_stdcells/nand3_4.sym} 11820 -35730 0 0 {name=X_71696_ }
C {devices/lab_pin.sym} 11780 -35590 0 0 {name=p11136 lab=clkbuf_9_326_0_CLK/X }
C {devices/lab_pin.sym} 11860 -35590 0 1 {name=p11137 lab=_87397_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 11820 -35590 0 0 {name=Xclkbuf_10_652_0_CLK }
C {devices/lab_pin.sym} 11760 -35480 0 0 {name=p11138 lab=_79011_/A }
C {devices/lab_pin.sym} 11760 -35440 0 0 {name=p11139 lab=_79011_/B }
C {devices/lab_pin.sym} 11880 -35460 0 1 {name=p11140 lab=_79011_/X }
C {sky130_stdcells/xor2_4.sym} 11820 -35460 0 0 {name=X_79011_ }
C {devices/lab_pin.sym} 11740 -35350 0 0 {name=p11141 lab=_83009_/Q }
C {devices/lab_pin.sym} 11740 -35310 0 0 {name=p11142 lab=_45401_/X }
C {devices/lab_pin.sym} 11740 -35270 0 0 {name=p11143 lab=_45402_/X }
C {devices/lab_pin.sym} 11900 -35310 0 1 {name=p11144 lab=_45403_/Y }
C {sky130_stdcells/o21ai_4.sym} 11820 -35310 0 0 {name=X_45403_ }
C {devices/lab_pin.sym} 11760 -35180 0 0 {name=p11145 lab=_76220_/Y }
C {devices/lab_pin.sym} 11760 -35140 0 0 {name=p11146 lab=_76222_/Y }
C {devices/lab_pin.sym} 11880 -35160 0 1 {name=p11147 lab=_76223_/Y }
C {sky130_stdcells/nor2_4.sym} 11820 -35160 0 0 {name=X_76223_ }
C {devices/lab_pin.sym} 11730 -35030 0 0 {name=p11148 lab=_87950_/CLK }
C {devices/lab_pin.sym} 11730 -35010 0 0 {name=p11149 lab=_41470_/X }
C {devices/lab_pin.sym} 11910 -35030 0 1 {name=p11150 lab=_66634_/B }
C {sky130_stdcells/dfxtp_4.sym} 11820 -35020 0 0 {name=X_88209_ }
C {devices/lab_pin.sym} 11780 -34890 0 0 {name=p11151 lab=_42592_/A }
C {devices/lab_pin.sym} 11860 -34890 0 1 {name=p11152 lab=_42615_/X }
C {sky130_stdcells/buf_2.sym} 11820 -34890 0 0 {name=X_42615_ }
C {devices/lab_pin.sym} 11740 -34790 0 0 {name=p11153 lab=_49128_/X }
C {devices/lab_pin.sym} 11740 -34750 0 0 {name=p11154 lab=_48676_/A }
C {devices/lab_pin.sym} 11740 -34710 0 0 {name=p11155 lab=_49170_/Y }
C {devices/lab_pin.sym} 11900 -34750 0 1 {name=p11156 lab=_49172_/A }
C {sky130_stdcells/a21o_4.sym} 11820 -34750 0 0 {name=X_49171_ }
C {devices/lab_pin.sym} 11740 -34630 0 0 {name=p11157 lab=_73433_/X }
C {devices/lab_pin.sym} 11740 -34590 0 0 {name=p11158 lab=_73434_/Y }
C {devices/lab_pin.sym} 11740 -34550 0 0 {name=p11159 lab=_73367_/X }
C {devices/lab_pin.sym} 11900 -34590 0 1 {name=p11160 lab=_73435_/Y }
C {sky130_stdcells/a21oi_4.sym} 11820 -34590 0 0 {name=X_73435_ }
C {devices/lab_pin.sym} 11760 -34460 0 0 {name=p11161 lab=_46362_/A }
C {devices/lab_pin.sym} 11760 -34420 0 0 {name=p11162 lab=_52478_/B }
C {devices/lab_pin.sym} 11880 -34440 0 1 {name=p11163 lab=_46383_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -34440 0 0 {name=X_46383_ }
C {devices/lab_pin.sym} 11760 -34340 0 0 {name=p11164 lab=_70717_/A }
C {devices/lab_pin.sym} 11760 -34300 0 0 {name=p11165 lab=_70639_/B }
C {devices/lab_pin.sym} 11760 -34260 0 0 {name=p11166 lab=_70642_/X }
C {devices/lab_pin.sym} 11760 -34220 0 0 {name=p11167 lab=_70638_/X }
C {devices/lab_pin.sym} 11880 -34280 0 1 {name=p11168 lab=_70647_/Y }
C {sky130_stdcells/nand4_4.sym} 11820 -34280 0 0 {name=X_70647_ }
C {devices/lab_pin.sym} 11780 -34130 0 0 {name=p11169 lab=_58408_/A }
C {devices/lab_pin.sym} 11860 -34130 0 1 {name=p11170 lab=_58369_/X }
C {sky130_stdcells/buf_2.sym} 11820 -34130 0 0 {name=X_58369_ }
C {devices/lab_pin.sym} 11780 -34010 0 0 {name=p11171 lab=_43595_/A }
C {devices/lab_pin.sym} 11860 -34010 0 1 {name=p11172 lab=_87347_/D }
C {sky130_stdcells/inv_2.sym} 11820 -34010 0 0 {name=X_43595_ }
C {devices/lab_pin.sym} 11780 -33890 0 0 {name=p11173 lab=clkbuf_8_71_0_CLK/X }
C {devices/lab_pin.sym} 11860 -33890 0 1 {name=p11174 lab=clkbuf_9_143_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 11820 -33890 0 0 {name=Xclkbuf_9_143_0_CLK }
C {devices/lab_pin.sym} 11780 -33770 0 0 {name=p11175 lab=_83533_/Q }
C {devices/lab_pin.sym} 11860 -33770 0 1 {name=p11176 lab=_48122_/Y }
C {sky130_stdcells/inv_2.sym} 11820 -33770 0 0 {name=X_48122_ }
C {devices/lab_pin.sym} 11780 -33650 0 0 {name=p11177 lab=_60395_/X }
C {devices/lab_pin.sym} 11860 -33650 0 1 {name=p11178 lab=_60400_/Y }
C {sky130_stdcells/inv_2.sym} 11820 -33650 0 0 {name=X_60400_ }
C {devices/lab_pin.sym} 11780 -33530 0 0 {name=p11179 lab=_64524_/B }
C {devices/lab_pin.sym} 11860 -33530 0 1 {name=p11180 lab=_61663_/B }
C {sky130_stdcells/buf_2.sym} 11820 -33530 0 0 {name=X_45334_ }
C {devices/lab_pin.sym} 11780 -33410 0 0 {name=p11181 lab=clkbuf_9_71_0_CLK/A }
C {devices/lab_pin.sym} 11860 -33410 0 1 {name=p11182 lab=clkbuf_9_70_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 11820 -33410 0 0 {name=Xclkbuf_9_70_0_CLK }
C {devices/lab_pin.sym} 11760 -33300 0 0 {name=p11183 lab=_76151_/Y }
C {devices/lab_pin.sym} 11760 -33260 0 0 {name=p11184 lab=_76153_/Y }
C {devices/lab_pin.sym} 11880 -33280 0 1 {name=p11185 lab=_76154_/Y }
C {sky130_stdcells/nor2_4.sym} 11820 -33280 0 0 {name=X_76154_ }
C {devices/lab_pin.sym} 11740 -33190 0 0 {name=p11186 lab=_42536_/X }
C {devices/lab_pin.sym} 11740 -33150 0 0 {name=p11187 lab=_42527_/X }
C {devices/lab_pin.sym} 11740 -33110 0 0 {name=p11188 lab=_40771_/X }
C {devices/lab_pin.sym} 11740 -33070 0 0 {name=p11189 lab=_69583_/B }
C {devices/lab_pin.sym} 11740 -33030 0 0 {name=p11190 lab=_42538_/X }
C {devices/lab_pin.sym} 11900 -33110 0 1 {name=p11191 lab=_87826_/D }
C {sky130_stdcells/o32ai_4.sym} 11820 -33110 0 0 {name=X_42546_ }
C {devices/lab_pin.sym} 11780 -32950 0 0 {name=p11192 lab=_61380_/A }
C {devices/lab_pin.sym} 11860 -32950 0 1 {name=p11193 lab=_61391_/D }
C {sky130_stdcells/buf_2.sym} 11820 -32950 0 0 {name=X_61380_ }
C {devices/lab_pin.sym} 11780 -32830 0 0 {name=p11194 lab=_72765_/A }
C {devices/lab_pin.sym} 11860 -32830 0 1 {name=p11195 lab=_73367_/A }
C {sky130_stdcells/buf_2.sym} 11820 -32830 0 0 {name=X_73366_ }
C {devices/lab_pin.sym} 11780 -32710 0 0 {name=p11196 lab=_70578_/A }
C {devices/lab_pin.sym} 11860 -32710 0 1 {name=p11197 lab=_74515_/C }
C {sky130_stdcells/buf_2.sym} 11820 -32710 0 0 {name=X_70578_ }
C {devices/lab_pin.sym} 11780 -32590 0 0 {name=p11198 lab=_75105_/A }
C {devices/lab_pin.sym} 11860 -32590 0 1 {name=p11199 lab=_75105_/Y }
C {sky130_stdcells/inv_2.sym} 11820 -32590 0 0 {name=X_75105_ }
C {devices/lab_pin.sym} 11740 -32490 0 0 {name=p11200 lab=_72228_/X }
C {devices/lab_pin.sym} 11740 -32450 0 0 {name=p11201 lab=_85969_/Q }
C {devices/lab_pin.sym} 11740 -32410 0 0 {name=p11202 lab=_72316_/X }
C {devices/lab_pin.sym} 11900 -32450 0 1 {name=p11203 lab=_72317_/Y }
C {sky130_stdcells/o21ai_4.sym} 11820 -32450 0 0 {name=X_72317_ }
C {devices/lab_pin.sym} 11760 -32320 0 0 {name=p11204 lab=_48092_/A }
C {devices/lab_pin.sym} 11760 -32280 0 0 {name=p11205 lab=_50341_/B }
C {devices/lab_pin.sym} 11880 -32300 0 1 {name=p11206 lab=_48053_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -32300 0 0 {name=X_48053_ }
C {devices/lab_pin.sym} 11760 -32200 0 0 {name=p11207 lab=_60268_/C }
C {devices/lab_pin.sym} 11760 -32160 0 0 {name=p11208 lab=_60331_/B }
C {devices/lab_pin.sym} 11760 -32120 0 0 {name=p11209 lab=_60268_/A }
C {devices/lab_pin.sym} 11760 -32080 0 0 {name=p11210 lab=_60331_/D }
C {devices/lab_pin.sym} 11880 -32140 0 1 {name=p11211 lab=_60331_/Y }
C {sky130_stdcells/nand4_4.sym} 11820 -32140 0 0 {name=X_60331_ }
C {devices/lab_pin.sym} 11780 -31990 0 0 {name=p11212 lab=_45265_/A }
C {devices/lab_pin.sym} 11860 -31990 0 1 {name=p11213 lab=_45265_/X }
C {sky130_stdcells/buf_2.sym} 11820 -31990 0 0 {name=X_45265_ }
C {devices/lab_pin.sym} 11760 -31880 0 0 {name=p11214 lab=_81721_/D }
C {devices/lab_pin.sym} 11760 -31840 0 0 {name=p11215 lab=_76085_/B }
C {devices/lab_pin.sym} 11880 -31860 0 1 {name=p11216 lab=_76097_/B }
C {sky130_stdcells/nand2_4.sym} 11820 -31860 0 0 {name=X_76085_ }
C {devices/lab_pin.sym} 11780 -31730 0 0 {name=p11217 lab=clkbuf_9_333_0_CLK/X }
C {devices/lab_pin.sym} 11860 -31730 0 1 {name=p11218 lab=_87137_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 11820 -31730 0 0 {name=Xclkbuf_10_667_0_CLK }
C {devices/lab_pin.sym} 11780 -31610 0 0 {name=p11219 lab=_42477_/A }
C {devices/lab_pin.sym} 11860 -31610 0 1 {name=p11220 lab=_42477_/X }
C {sky130_stdcells/buf_2.sym} 11820 -31610 0 0 {name=X_42477_ }
C {devices/lab_pin.sym} 11740 -31520 0 0 {name=p11221 lab=_42036_/Y }
C {devices/lab_pin.sym} 11740 -31480 0 0 {name=p11222 lab=_72921_/X }
C {devices/lab_pin.sym} 11740 -31440 0 0 {name=p11223 lab=_73194_/X }
C {devices/lab_pin.sym} 11740 -31400 0 0 {name=p11224 lab=_73296_/Y }
C {devices/lab_pin.sym} 11900 -31460 0 1 {name=p11225 lab=_73297_/X }
C {sky130_stdcells/a211o_4.sym} 11820 -31460 0 0 {name=X_73297_ }
C {devices/lab_pin.sym} 11780 -31310 0 0 {name=p11226 lab=_47004_/A }
C {devices/lab_pin.sym} 11860 -31310 0 1 {name=p11227 lab=_47004_/X }
C {sky130_stdcells/buf_2.sym} 11820 -31310 0 0 {name=X_47004_ }
C {devices/lab_pin.sym} 11780 -31190 0 0 {name=p11228 lab=_43959_/A }
C {devices/lab_pin.sym} 11860 -31190 0 1 {name=p11229 lab=_44216_/X }
C {sky130_stdcells/buf_2.sym} 11820 -31190 0 0 {name=X_44216_ }
C {devices/lab_pin.sym} 11760 -31100 0 0 {name=p11230 lab=_63039_/A }
C {devices/lab_pin.sym} 11760 -31060 0 0 {name=p11231 lab=_84717_/Q }
C {devices/lab_pin.sym} 11760 -31020 0 0 {name=p11232 lab=_63028_/X }
C {devices/lab_pin.sym} 11760 -30980 0 0 {name=p11233 lab=_63014_/D }
C {devices/lab_pin.sym} 11880 -31040 0 1 {name=p11234 lab=_63050_/X }
C {sky130_stdcells/and4_4.sym} 11820 -31040 0 0 {name=X_63050_ }
C {devices/lab_pin.sym} 11760 -30900 0 0 {name=p11235 lab=_75047_/A }
C {devices/lab_pin.sym} 11760 -30860 0 0 {name=p11236 lab=_75035_/Y }
C {devices/lab_pin.sym} 11880 -30880 0 1 {name=p11237 lab=_75036_/X }
C {sky130_stdcells/xor2_4.sym} 11820 -30880 0 0 {name=X_75036_ }
C {devices/lab_pin.sym} 11760 -30760 0 0 {name=p11238 lab=_79913_/A }
C {devices/lab_pin.sym} 11760 -30720 0 0 {name=p11239 lab=_79913_/B }
C {devices/lab_pin.sym} 11880 -30740 0 1 {name=p11240 lab=_79914_/B }
C {sky130_stdcells/nand2_4.sym} 11820 -30740 0 0 {name=X_79913_ }
C {devices/lab_pin.sym} 11740 -30630 0 0 {name=p11241 lab=_41412_/X }
C {devices/lab_pin.sym} 11740 -30590 0 0 {name=p11242 lab=_82887_/Q }
C {devices/lab_pin.sym} 11740 -30550 0 0 {name=p11243 lab=_41427_/X }
C {devices/lab_pin.sym} 11900 -30590 0 1 {name=p11244 lab=_41428_/Y }
C {sky130_stdcells/o21ai_4.sym} 11820 -30590 0 0 {name=X_41428_ }
C {devices/lab_pin.sym} 11780 -30450 0 0 {name=p11245 lab=_60211_/A }
C {devices/lab_pin.sym} 11860 -30450 0 1 {name=p11246 lab=_60263_/C }
C {sky130_stdcells/buf_2.sym} 11820 -30450 0 0 {name=X_60262_ }
C {devices/lab_pin.sym} 11740 -30370 0 0 {name=p11247 lab=_72172_/X }
C {devices/lab_pin.sym} 11740 -30330 0 0 {name=p11248 lab=_72245_/Y }
C {devices/lab_pin.sym} 11740 -30290 0 0 {name=p11249 lab=_72247_/Y }
C {devices/lab_pin.sym} 11740 -30250 0 0 {name=p11250 lab=_72189_/X }
C {devices/lab_pin.sym} 11740 -30210 0 0 {name=p11251 lab=_72176_/X }
C {devices/lab_pin.sym} 11900 -30290 0 1 {name=p11252 lab=_72248_/X }
C {sky130_stdcells/o32a_4.sym} 11820 -30290 0 0 {name=X_72248_ }
C {devices/lab_pin.sym} 11780 -30130 0 0 {name=p11253 lab=_45196_/A }
C {devices/lab_pin.sym} 11860 -30130 0 1 {name=p11254 lab=_45199_/A }
C {sky130_stdcells/inv_2.sym} 11820 -30130 0 0 {name=X_45196_ }
C {devices/lab_pin.sym} 11780 -30010 0 0 {name=p11255 lab=clkbuf_8_79_0_CLK/X }
C {devices/lab_pin.sym} 11860 -30010 0 1 {name=p11256 lab=clkbuf_9_158_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 11820 -30010 0 0 {name=Xclkbuf_9_158_0_CLK }
C {devices/lab_pin.sym} 11780 -29890 0 0 {name=p11257 lab=clkbuf_2_1_1_CLK/X }
C {devices/lab_pin.sym} 11860 -29890 0 1 {name=p11258 lab=clkbuf_3_3_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 11820 -29890 0 0 {name=Xclkbuf_2_1_2_CLK }
C {devices/lab_pin.sym} 11740 -29810 0 0 {name=p11259 lab=_61991_/X }
C {devices/lab_pin.sym} 11740 -29770 0 0 {name=p11260 lab=_61993_/X }
C {devices/lab_pin.sym} 11740 -29730 0 0 {name=p11261 lab=_62000_/Y }
C {devices/lab_pin.sym} 11740 -29690 0 0 {name=p11262 lab=_84848_/Q }
C {devices/lab_pin.sym} 11740 -29650 0 0 {name=p11263 lab=_61973_/X }
C {devices/lab_pin.sym} 11900 -29730 0 1 {name=p11264 lab=_62001_/Y }
C {sky130_stdcells/o32ai_4.sym} 11820 -29730 0 0 {name=X_62001_ }
C {devices/lab_pin.sym} 11780 -29570 0 0 {name=p11265 lab=clkbuf_8_42_0_CLK/X }
C {devices/lab_pin.sym} 11860 -29570 0 1 {name=p11266 lab=clkbuf_9_85_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 11820 -29570 0 0 {name=Xclkbuf_9_85_0_CLK }
C {devices/lab_pin.sym} 11780 -29450 0 0 {name=p11267 lab=_44147_/A }
C {devices/lab_pin.sym} 11860 -29450 0 1 {name=p11268 lab=_44148_/A }
C {sky130_stdcells/buf_2.sym} 11820 -29450 0 0 {name=X_44147_ }
C {devices/lab_pin.sym} 11740 -29350 0 0 {name=p11269 lab=_64741_/C }
C {devices/lab_pin.sym} 11740 -29310 0 0 {name=p11270 lab=_72165_/Y }
C {devices/lab_pin.sym} 11740 -29270 0 0 {name=p11271 lab=_79843_/Y }
C {devices/lab_pin.sym} 11900 -29310 0 1 {name=p11272 lab=_79844_/X }
C {sky130_stdcells/o21a_4.sym} 11820 -29310 0 0 {name=X_79844_ }
C {devices/lab_pin.sym} 11760 -29180 0 0 {name=p11273 lab=_41358_/X }
C {devices/lab_pin.sym} 11760 -29140 0 0 {name=p11274 lab=_82899_/Q }
C {devices/lab_pin.sym} 11880 -29160 0 1 {name=p11275 lab=_41359_/X }
C {sky130_stdcells/or2_4.sym} 11820 -29160 0 0 {name=X_41359_ }
C {devices/lab_pin.sym} 11780 -29030 0 0 {name=p11276 lab=_83276_/Q }
C {devices/lab_pin.sym} 11860 -29030 0 1 {name=p11277 lab=_72179_/Y }
C {sky130_stdcells/inv_2.sym} 11820 -29030 0 0 {name=X_72179_ }
C {devices/lab_pin.sym} 11780 -28910 0 0 {name=p11278 lab=_60193_/A }
C {devices/lab_pin.sym} 11860 -28910 0 1 {name=p11279 lab=_60239_/B }
C {sky130_stdcells/buf_2.sym} 11820 -28910 0 0 {name=X_60193_ }
C {devices/lab_pin.sym} 11780 -28790 0 0 {name=p11280 lab=_53819_/B }
C {devices/lab_pin.sym} 11860 -28790 0 1 {name=p11281 lab=_48955_/X }
C {sky130_stdcells/buf_2.sym} 11820 -28790 0 0 {name=X_48955_ }
C {devices/lab_pin.sym} 11780 -28670 0 0 {name=p11282 lab=_44077_/X }
C {devices/lab_pin.sym} 11860 -28670 0 1 {name=p11283 lab=_55817_/A }
C {sky130_stdcells/buf_2.sym} 11820 -28670 0 0 {name=X_44078_ }
C {devices/lab_pin.sym} 11760 -28560 0 0 {name=p11284 lab=_79775_/A }
C {devices/lab_pin.sym} 11760 -28520 0 0 {name=p11285 lab=_79775_/B }
C {devices/lab_pin.sym} 11880 -28540 0 1 {name=p11286 lab=_79781_/B }
C {sky130_stdcells/xor2_4.sym} 11820 -28540 0 0 {name=X_79775_ }
C {devices/lab_pin.sym} 11760 -28420 0 0 {name=p11287 lab=_76987_/A }
C {devices/lab_pin.sym} 11760 -28380 0 0 {name=p11288 lab=_62426_/C }
C {devices/lab_pin.sym} 11880 -28400 0 1 {name=p11289 lab=_76987_/X }
C {sky130_stdcells/xor2_4.sym} 11820 -28400 0 0 {name=X_76987_ }
C {devices/lab_pin.sym} 11760 -28280 0 0 {name=p11290 lab=_82363_/Q }
C {devices/lab_pin.sym} 11760 -28240 0 0 {name=p11291 lab=_47963_/B }
C {devices/lab_pin.sym} 11880 -28260 0 1 {name=p11292 lab=_47906_/X }
C {sky130_stdcells/or2_4.sym} 11820 -28260 0 0 {name=X_47906_ }
C {devices/lab_pin.sym} 11780 -28130 0 0 {name=p11293 lab=_43029_/A }
C {devices/lab_pin.sym} 11860 -28130 0 1 {name=p11294 lab=_43029_/Y }
C {sky130_stdcells/inv_2.sym} 11820 -28130 0 0 {name=X_43029_ }
C {devices/lab_pin.sym} 11740 -28030 0 0 {name=p11295 lab=_66737_/X }
C {devices/lab_pin.sym} 11740 -27990 0 0 {name=p11296 lab=_66739_/X }
C {devices/lab_pin.sym} 11740 -27950 0 0 {name=p11297 lab=_66667_/X }
C {devices/lab_pin.sym} 11900 -27990 0 1 {name=p11298 lab=_66743_/A }
C {sky130_stdcells/a21o_4.sym} 11820 -27990 0 0 {name=X_66740_ }
C {devices/lab_pin.sym} 11760 -27860 0 0 {name=p11299 lab=_78725_/A }
C {devices/lab_pin.sym} 11760 -27820 0 0 {name=p11300 lab=_78725_/B }
C {devices/lab_pin.sym} 11880 -27840 0 1 {name=p11301 lab=_78726_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -27840 0 0 {name=X_78726_ }
C {devices/lab_pin.sym} 11780 -27710 0 0 {name=p11302 lab=_64045_/A }
C {devices/lab_pin.sym} 11860 -27710 0 1 {name=p11303 lab=_64016_/D }
C {sky130_stdcells/buf_2.sym} 11820 -27710 0 0 {name=X_63952_ }
C {devices/lab_pin.sym} 11780 -27590 0 0 {name=p11304 lab=_75939_/B }
C {devices/lab_pin.sym} 11860 -27590 0 1 {name=p11305 lab=_75938_/Y }
C {sky130_stdcells/inv_2.sym} 11820 -27590 0 0 {name=X_75938_ }
C {devices/lab_pin.sym} 11740 -27490 0 0 {name=p11306 lab=_48879_/Y }
C {devices/lab_pin.sym} 11740 -27450 0 0 {name=p11307 lab=_48880_/X }
C {devices/lab_pin.sym} 11740 -27410 0 0 {name=p11308 lab=_48885_/X }
C {devices/lab_pin.sym} 11900 -27450 0 1 {name=p11309 lab=_86465_/D }
C {sky130_stdcells/a21oi_4.sym} 11820 -27450 0 0 {name=X_48886_ }
C {devices/lab_pin.sym} 11760 -27330 0 0 {name=p11310 lab=_62930_/A }
C {devices/lab_pin.sym} 11760 -27290 0 0 {name=p11311 lab=_62930_/B }
C {devices/lab_pin.sym} 11760 -27250 0 0 {name=p11312 lab=_84372_/Q }
C {devices/lab_pin.sym} 11880 -27290 0 1 {name=p11313 lab=_62903_/Y }
C {sky130_stdcells/nor3_4.sym} 11820 -27290 0 0 {name=X_62903_ }
C {devices/lab_pin.sym} 11780 -27150 0 0 {name=p11314 lab=_47836_/Y }
C {devices/lab_pin.sym} 11860 -27150 0 1 {name=p11315 lab=_86593_/D }
C {sky130_stdcells/inv_2.sym} 11820 -27150 0 0 {name=X_47837_ }
C {devices/lab_pin.sym} 11760 -27040 0 0 {name=p11316 lab=_78655_/X }
C {devices/lab_pin.sym} 11760 -27000 0 0 {name=p11317 lab=_78657_/B }
C {devices/lab_pin.sym} 11880 -27020 0 1 {name=p11318 lab=_82777_/D }
C {sky130_stdcells/xor2_4.sym} 11820 -27020 0 0 {name=X_78657_ }
C {devices/lab_pin.sym} 11760 -26900 0 0 {name=p11319 lab=_66668_/X }
C {devices/lab_pin.sym} 11760 -26860 0 0 {name=p11320 lab=_66670_/X }
C {devices/lab_pin.sym} 11880 -26880 0 1 {name=p11321 lab=_66671_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -26880 0 0 {name=X_66671_ }
C {devices/lab_pin.sym} 11760 -26780 0 0 {name=p11322 lab=_61440_/A }
C {devices/lab_pin.sym} 11760 -26740 0 0 {name=p11323 lab=_63853_/B }
C {devices/lab_pin.sym} 11760 -26700 0 0 {name=p11324 lab=_63947_/C }
C {devices/lab_pin.sym} 11760 -26660 0 0 {name=p11325 lab=_63866_/X }
C {devices/lab_pin.sym} 11880 -26720 0 1 {name=p11326 lab=_63883_/Y }
C {sky130_stdcells/nand4_4.sym} 11820 -26720 0 0 {name=X_63883_ }
C {devices/lab_pin.sym} 11780 -26570 0 0 {name=p11327 lab=clkbuf_9_302_0_CLK/X }
C {devices/lab_pin.sym} 11860 -26570 0 1 {name=p11328 lab=_82116_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 11820 -26570 0 0 {name=Xclkbuf_10_605_0_CLK }
C {devices/lab_pin.sym} 11780 -26450 0 0 {name=p11329 lab=_75868_/X }
C {devices/lab_pin.sym} 11860 -26450 0 1 {name=p11330 lab=_75875_/B }
C {sky130_stdcells/inv_2.sym} 11820 -26450 0 0 {name=X_75869_ }
C {devices/lab_pin.sym} 11740 -26360 0 0 {name=p11331 lab=_87102_/Q }
C {devices/lab_pin.sym} 11740 -26320 0 0 {name=p11332 lab=_68059_/X }
C {devices/lab_pin.sym} 11740 -26280 0 0 {name=p11333 lab=_68370_/X }
C {devices/lab_pin.sym} 11740 -26240 0 0 {name=p11334 lab=_68409_/X }
C {devices/lab_pin.sym} 11900 -26300 0 1 {name=p11335 lab=_68410_/X }
C {sky130_stdcells/a211o_4.sym} 11820 -26300 0 0 {name=X_68410_ }
C {devices/lab_pin.sym} 11740 -26170 0 0 {name=p11336 lab=_65619_/Y }
C {devices/lab_pin.sym} 11740 -26130 0 0 {name=p11337 lab=_65602_/X }
C {devices/lab_pin.sym} 11740 -26090 0 0 {name=p11338 lab=_65621_/X }
C {devices/lab_pin.sym} 11900 -26130 0 1 {name=p11339 lab=_84189_/D }
C {sky130_stdcells/a21o_4.sym} 11820 -26130 0 0 {name=X_65622_ }
C {devices/lab_pin.sym} 11760 -26000 0 0 {name=p11340 lab=_77622_/A }
C {devices/lab_pin.sym} 11760 -25960 0 0 {name=p11341 lab=_77607_/Y }
C {devices/lab_pin.sym} 11880 -25980 0 1 {name=p11342 lab=_82203_/D }
C {sky130_stdcells/xnor2_4.sym} 11820 -25980 0 0 {name=X_77608_ }
C {devices/lab_pin.sym} 11760 -25880 0 0 {name=p11343 lab=_61510_/X }
C {devices/lab_pin.sym} 11760 -25840 0 0 {name=p11344 lab=_62834_/B }
C {devices/lab_pin.sym} 11760 -25800 0 0 {name=p11345 lab=_62801_/X }
C {devices/lab_pin.sym} 11760 -25760 0 0 {name=p11346 lab=_62834_/D }
C {devices/lab_pin.sym} 11880 -25820 0 1 {name=p11347 lab=_62834_/Y }
C {sky130_stdcells/nand4_4.sym} 11820 -25820 0 0 {name=X_62834_ }
C {devices/lab_pin.sym} 11740 -25690 0 0 {name=p11348 lab=_69386_/X }
C {devices/lab_pin.sym} 11740 -25650 0 0 {name=p11349 lab=_69388_/X }
C {devices/lab_pin.sym} 11740 -25610 0 0 {name=p11350 lab=_69389_/X }
C {devices/lab_pin.sym} 11900 -25650 0 1 {name=p11351 lab=_69390_/Y }
C {sky130_stdcells/a21oi_4.sym} 11820 -25650 0 0 {name=X_69390_ }
C {devices/lab_pin.sym} 11780 -25510 0 0 {name=p11352 lab=_47768_/A }
C {devices/lab_pin.sym} 11860 -25510 0 1 {name=p11353 lab=_53234_/D }
C {sky130_stdcells/buf_2.sym} 11820 -25510 0 0 {name=X_47768_ }
C {devices/lab_pin.sym} 11760 -25410 0 0 {name=p11354 lab=_78584_/Y }
C {devices/lab_pin.sym} 11760 -25370 0 0 {name=p11355 lab=_78585_/Y }
C {devices/lab_pin.sym} 11760 -25330 0 0 {name=p11356 lab=_78587_/Y }
C {devices/lab_pin.sym} 11880 -25370 0 1 {name=p11357 lab=_78588_/X }
C {sky130_stdcells/or3_4.sym} 11820 -25370 0 0 {name=X_78588_ }
C {devices/lab_pin.sym} 11740 -25250 0 0 {name=p11358 lab=_49503_/Y }
C {devices/lab_pin.sym} 11740 -25210 0 0 {name=p11359 lab=_49487_/X }
C {devices/lab_pin.sym} 11740 -25170 0 0 {name=p11360 lab=_49506_/X }
C {devices/lab_pin.sym} 11900 -25210 0 1 {name=p11361 lab=_86375_/D }
C {sky130_stdcells/a21oi_4.sym} 11820 -25210 0 0 {name=X_49507_ }
C {devices/lab_pin.sym} 11780 -25070 0 0 {name=p11362 lab=clkbuf_9_23_0_CLK/A }
C {devices/lab_pin.sym} 11860 -25070 0 1 {name=p11363 lab=clkbuf_9_23_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 11820 -25070 0 0 {name=Xclkbuf_9_23_0_CLK }
C {devices/lab_pin.sym} 11740 -24970 0 0 {name=p11364 lab=_82626_/D }
C {devices/lab_pin.sym} 11740 -24930 0 0 {name=p11365 lab=_68338_/X }
C {devices/lab_pin.sym} 11740 -24890 0 0 {name=p11366 lab=_68340_/X }
C {devices/lab_pin.sym} 11900 -24930 0 1 {name=p11367 lab=_68341_/X }
C {sky130_stdcells/a21bo_4.sym} 11820 -24930 0 0 {name=X_68341_ }
C {devices/lab_pin.sym} 11780 -24790 0 0 {name=p11368 lab=_46719_/A }
C {devices/lab_pin.sym} 11860 -24790 0 1 {name=p11369 lab=_46719_/X }
C {sky130_stdcells/buf_2.sym} 11820 -24790 0 0 {name=X_46719_ }
C {devices/lab_pin.sym} 11740 -24690 0 0 {name=p11370 lab=_65550_/X }
C {devices/lab_pin.sym} 11740 -24650 0 0 {name=p11371 lab=_65552_/X }
C {devices/lab_pin.sym} 11740 -24610 0 0 {name=p11372 lab=_65389_/X }
C {devices/lab_pin.sym} 11900 -24650 0 1 {name=p11373 lab=_65553_/X }
C {sky130_stdcells/a21o_4.sym} 11820 -24650 0 0 {name=X_65553_ }
C {devices/lab_pin.sym} 11780 -24510 0 0 {name=p11374 lab=_77539_/A }
C {devices/lab_pin.sym} 11860 -24510 0 1 {name=p11375 lab=_77540_/C }
C {sky130_stdcells/inv_2.sym} 11820 -24510 0 0 {name=X_77539_ }
C {devices/lab_pin.sym} 11740 -24430 0 0 {name=p11376 lab=_62761_/Y }
C {devices/lab_pin.sym} 11740 -24390 0 0 {name=p11377 lab=_62713_/X }
C {devices/lab_pin.sym} 11740 -24350 0 0 {name=p11378 lab=_62762_/Y }
C {devices/lab_pin.sym} 11740 -24310 0 0 {name=p11379 lab=_62763_/Y }
C {devices/lab_pin.sym} 11740 -24280 0 0 {name=p11380 lab=_62764_/X }
C {devices/lab_pin.sym} 11900 -24350 0 1 {name=p11381 lab=_62765_/X }
C {sky130_stdcells/a41o_4.sym} 11820 -24350 0 0 {name=X_62765_ }
C {devices/lab_pin.sym} 11780 -24190 0 0 {name=p11382 lab=_47792_/A }
C {devices/lab_pin.sym} 11860 -24190 0 1 {name=p11383 lab=_47739_/B }
C {sky130_stdcells/buf_2.sym} 11820 -24190 0 0 {name=X_47699_ }
C {devices/lab_pin.sym} 11760 -24100 0 0 {name=p11384 lab=_64457_/B }
C {devices/lab_pin.sym} 11760 -24060 0 0 {name=p11385 lab=_64229_/X }
C {devices/lab_pin.sym} 11760 -24020 0 0 {name=p11386 lab=_64504_/C }
C {devices/lab_pin.sym} 11760 -23980 0 0 {name=p11387 lab=_64503_/Y }
C {devices/lab_pin.sym} 11880 -24040 0 1 {name=p11388 lab=_64504_/Y }
C {sky130_stdcells/nand4_4.sym} 11820 -24040 0 0 {name=X_64504_ }
C {devices/lab_pin.sym} 11760 -23900 0 0 {name=p11389 lab=_49418_/A }
C {devices/lab_pin.sym} 11760 -23860 0 0 {name=p11390 lab=_50961_/B }
C {devices/lab_pin.sym} 11880 -23880 0 1 {name=p11391 lab=_49438_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -23880 0 0 {name=X_49438_ }
C {devices/lab_pin.sym} 11760 -23760 0 0 {name=p11392 lab=_80550_/A }
C {devices/lab_pin.sym} 11760 -23720 0 0 {name=p11393 lab=_80549_/Y }
C {devices/lab_pin.sym} 11880 -23740 0 1 {name=p11394 lab=_80562_/B }
C {sky130_stdcells/xor2_4.sym} 11820 -23740 0 0 {name=X_80550_ }
C {devices/lab_pin.sym} 11780 -23610 0 0 {name=p11395 lab=_59638_/A }
C {devices/lab_pin.sym} 11860 -23610 0 1 {name=p11396 lab=_61716_/X }
C {sky130_stdcells/buf_2.sym} 11820 -23610 0 0 {name=X_61716_ }
C {devices/lab_pin.sym} 11780 -23490 0 0 {name=p11397 lab=_68376_/A }
C {devices/lab_pin.sym} 11860 -23490 0 1 {name=p11398 lab=_68272_/X }
C {sky130_stdcells/buf_2.sym} 11820 -23490 0 0 {name=X_68272_ }
C {devices/lab_pin.sym} 11780 -23370 0 0 {name=p11399 lab=_65484_/A }
C {devices/lab_pin.sym} 11860 -23370 0 1 {name=p11400 lab=_65484_/X }
C {sky130_stdcells/buf_2.sym} 11820 -23370 0 0 {name=X_65484_ }
C {devices/lab_pin.sym} 11740 -23290 0 0 {name=p11401 lab=_62691_/Y }
C {devices/lab_pin.sym} 11740 -23250 0 0 {name=p11402 lab=_62660_/X }
C {devices/lab_pin.sym} 11740 -23210 0 0 {name=p11403 lab=_62693_/Y }
C {devices/lab_pin.sym} 11740 -23170 0 0 {name=p11404 lab=_62694_/Y }
C {devices/lab_pin.sym} 11740 -23140 0 0 {name=p11405 lab=_62695_/X }
C {devices/lab_pin.sym} 11900 -23210 0 1 {name=p11406 lab=_62696_/X }
C {sky130_stdcells/a41o_4.sym} 11820 -23210 0 0 {name=X_62696_ }
C {devices/lab_pin.sym} 11760 -23060 0 0 {name=p11407 lab=_67248_/A }
C {devices/lab_pin.sym} 11760 -23020 0 0 {name=p11408 lab=_67223_/B }
C {devices/lab_pin.sym} 11880 -23040 0 1 {name=p11409 lab=_67223_/X }
C {sky130_stdcells/and2_4.sym} 11820 -23040 0 0 {name=X_67223_ }
C {devices/lab_pin.sym} 11740 -22930 0 0 {name=p11410 lab=_79178_/Y }
C {devices/lab_pin.sym} 11740 -22890 0 0 {name=p11411 lab=_79192_/B }
C {devices/lab_pin.sym} 11740 -22850 0 0 {name=p11412 lab=_79189_/Y }
C {devices/lab_pin.sym} 11900 -22890 0 1 {name=p11413 lab=_79209_/Y }
C {sky130_stdcells/a21oi_4.sym} 11820 -22890 0 0 {name=X_79209_ }
C {devices/lab_pin.sym} 11760 -22770 0 0 {name=p11414 lab=_64402_/X }
C {devices/lab_pin.sym} 11760 -22730 0 0 {name=p11415 lab=_64421_/X }
C {devices/lab_pin.sym} 11760 -22690 0 0 {name=p11416 lab=_84838_/Q }
C {devices/lab_pin.sym} 11880 -22730 0 1 {name=p11417 lab=_64435_/X }
C {sky130_stdcells/and3_4.sym} 11820 -22730 0 0 {name=X_64435_ }
C {devices/lab_pin.sym} 11780 -22590 0 0 {name=p11418 lab=_49451_/A }
C {devices/lab_pin.sym} 11860 -22590 0 1 {name=p11419 lab=_49369_/X }
C {sky130_stdcells/buf_2.sym} 11820 -22590 0 0 {name=X_49369_ }
C {devices/lab_pin.sym} 11740 -22490 0 0 {name=p11420 lab=_61643_/X }
C {devices/lab_pin.sym} 11740 -22450 0 0 {name=p11421 lab=_61645_/X }
C {devices/lab_pin.sym} 11740 -22410 0 0 {name=p11422 lab=_61646_/Y }
C {devices/lab_pin.sym} 11900 -22450 0 1 {name=p11423 lab=_61647_/Y }
C {sky130_stdcells/a21oi_4.sym} 11820 -22450 0 0 {name=X_61647_ }
C {devices/lab_pin.sym} 11760 -22320 0 0 {name=p11424 lab=_84763_/Q }
C {devices/lab_pin.sym} 11760 -22280 0 0 {name=p11425 lab=_80481_/B }
C {devices/lab_pin.sym} 11880 -22300 0 1 {name=p11426 lab=_80481_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -22300 0 0 {name=X_80481_ }
C {devices/lab_pin.sym} 11780 -22170 0 0 {name=p11427 lab=clkbuf_9_39_0_CLK/A }
C {devices/lab_pin.sym} 11860 -22170 0 1 {name=p11428 lab=clkbuf_9_38_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 11820 -22170 0 0 {name=Xclkbuf_9_38_0_CLK }
C {devices/lab_pin.sym} 11760 -22080 0 0 {name=p11429 lab=_51220_/A }
C {devices/lab_pin.sym} 11760 -22040 0 0 {name=p11430 lab=_51230_/X }
C {devices/lab_pin.sym} 11760 -22000 0 0 {name=p11431 lab=_51225_/C }
C {devices/lab_pin.sym} 11760 -21960 0 0 {name=p11432 lab=_52927_/D }
C {devices/lab_pin.sym} 11880 -22020 0 1 {name=p11433 lab=_51400_/X }
C {sky130_stdcells/and4_4.sym} 11820 -22020 0 0 {name=X_51400_ }
C {devices/lab_pin.sym} 11730 -21870 0 0 {name=p11434 lab=_82220_/CLK }
C {devices/lab_pin.sym} 11730 -21850 0 0 {name=p11435 lab=_82252_/Q }
C {devices/lab_pin.sym} 11910 -21870 0 1 {name=p11436 lab=_82220_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -21860 0 0 {name=X_82220_ }
C {devices/lab_pin.sym} 11760 -21740 0 0 {name=p11437 lab=_67131_/A }
C {devices/lab_pin.sym} 11760 -21700 0 0 {name=p11438 lab=_87675_/Q }
C {devices/lab_pin.sym} 11880 -21720 0 1 {name=p11439 lab=_67154_/X }
C {sky130_stdcells/and2_4.sym} 11820 -21720 0 0 {name=X_67154_ }
C {devices/lab_pin.sym} 11740 -21610 0 0 {name=p11440 lab=_85834_/Q }
C {devices/lab_pin.sym} 11740 -21570 0 0 {name=p11441 lab=_52372_/X }
C {devices/lab_pin.sym} 11740 -21530 0 0 {name=p11442 lab=_52379_/Y }
C {devices/lab_pin.sym} 11900 -21570 0 1 {name=p11443 lab=_52380_/Y }
C {sky130_stdcells/o21ai_4.sym} 11820 -21570 0 0 {name=X_52380_ }
C {devices/lab_pin.sym} 11760 -21450 0 0 {name=p11444 lab=_64344_/X }
C {devices/lab_pin.sym} 11760 -21410 0 0 {name=p11445 lab=_64379_/B }
C {devices/lab_pin.sym} 11760 -21370 0 0 {name=p11446 lab=_84828_/Q }
C {devices/lab_pin.sym} 11880 -21410 0 1 {name=p11447 lab=_64366_/X }
C {sky130_stdcells/and3_4.sym} 11820 -21410 0 0 {name=X_64366_ }
C {devices/lab_pin.sym} 11740 -21290 0 0 {name=p11448 lab=_61575_/X }
C {devices/lab_pin.sym} 11740 -21250 0 0 {name=p11449 lab=_61576_/X }
C {devices/lab_pin.sym} 11740 -21210 0 0 {name=p11450 lab=_61577_/Y }
C {devices/lab_pin.sym} 11900 -21250 0 1 {name=p11451 lab=_61578_/Y }
C {sky130_stdcells/a21oi_4.sym} 11820 -21250 0 0 {name=X_61578_ }
C {devices/lab_pin.sym} 11760 -21130 0 0 {name=p11452 lab=_65628_/X }
C {devices/lab_pin.sym} 11760 -21090 0 0 {name=p11453 lab=_66135_/B }
C {devices/lab_pin.sym} 11760 -21050 0 0 {name=p11454 lab=_65630_/X }
C {devices/lab_pin.sym} 11880 -21090 0 1 {name=p11455 lab=_66105_/Y }
C {sky130_stdcells/nand3_4.sym} 11820 -21090 0 0 {name=X_66105_ }
C {devices/lab_pin.sym} 11740 -20970 0 0 {name=p11456 lab=_51329_/Y }
C {devices/lab_pin.sym} 11740 -20930 0 0 {name=p11457 lab=_51313_/X }
C {devices/lab_pin.sym} 11740 -20890 0 0 {name=p11458 lab=_51330_/X }
C {devices/lab_pin.sym} 11900 -20930 0 1 {name=p11459 lab=_86030_/D }
C {sky130_stdcells/a21oi_4.sym} 11820 -20930 0 0 {name=X_51331_ }
C {devices/lab_pin.sym} 11780 -20790 0 0 {name=p11460 lab=_63231_/A }
C {devices/lab_pin.sym} 11860 -20790 0 1 {name=p11461 lab=_63317_/X }
C {sky130_stdcells/buf_2.sym} 11820 -20790 0 0 {name=X_63317_ }
C {devices/lab_pin.sym} 11730 -20670 0 0 {name=p11462 lab=_82152_/CLK }
C {devices/lab_pin.sym} 11730 -20650 0 0 {name=p11463 lab=_84143_/Q }
C {devices/lab_pin.sym} 11910 -20670 0 1 {name=p11464 lab=_82151_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -20660 0 0 {name=X_82151_ }
C {devices/lab_pin.sym} 11760 -20540 0 0 {name=p11465 lab=_60529_/A }
C {devices/lab_pin.sym} 11760 -20500 0 0 {name=p11466 lab=_60529_/B }
C {devices/lab_pin.sym} 11880 -20520 0 1 {name=p11467 lab=_60529_/Y }
C {sky130_stdcells/nor2_4.sym} 11820 -20520 0 0 {name=X_60529_ }
C {devices/lab_pin.sym} 11780 -20390 0 0 {name=p11468 lab=_66606_/A }
C {devices/lab_pin.sym} 11860 -20390 0 1 {name=p11469 lab=_67085_/X }
C {sky130_stdcells/buf_2.sym} 11820 -20390 0 0 {name=X_67085_ }
C {devices/lab_pin.sym} 11740 -20290 0 0 {name=p11470 lab=_59474_/A }
C {devices/lab_pin.sym} 11740 -20250 0 0 {name=p11471 lab=_64249_/X }
C {devices/lab_pin.sym} 11740 -20210 0 0 {name=p11472 lab=_64296_/Y }
C {devices/lab_pin.sym} 11900 -20250 0 1 {name=p11473 lab=_64297_/Y }
C {sky130_stdcells/o21ai_4.sym} 11820 -20250 0 0 {name=X_64297_ }
C {devices/lab_pin.sym} 11730 -20110 0 0 {name=p11474 lab=_80817_/CLK }
C {devices/lab_pin.sym} 11730 -20090 0 0 {name=p11475 lab=_79687_/X }
C {devices/lab_pin.sym} 11910 -20110 0 1 {name=p11476 lab=_81102_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -20100 0 0 {name=X_81102_ }
C {devices/lab_pin.sym} 11740 -19990 0 0 {name=p11477 lab=_85515_/Q }
C {devices/lab_pin.sym} 11740 -19950 0 0 {name=p11478 lab=_54035_/X }
C {devices/lab_pin.sym} 11740 -19910 0 0 {name=p11479 lab=_54049_/Y }
C {devices/lab_pin.sym} 11900 -19950 0 1 {name=p11480 lab=_54050_/Y }
C {sky130_stdcells/o21ai_4.sym} 11820 -19950 0 0 {name=X_54050_ }
C {devices/lab_pin.sym} 11740 -19840 0 0 {name=p11481 lab=_65990_/X }
C {devices/lab_pin.sym} 11740 -19800 0 0 {name=p11482 lab=_86232_/Q }
C {devices/lab_pin.sym} 11740 -19760 0 0 {name=p11483 lab=_66021_/X }
C {devices/lab_pin.sym} 11740 -19720 0 0 {name=p11484 lab=_66035_/X }
C {devices/lab_pin.sym} 11900 -19780 0 1 {name=p11485 lab=_66036_/X }
C {sky130_stdcells/a211o_4.sym} 11820 -19780 0 0 {name=X_66036_ }
C {devices/lab_pin.sym} 11740 -19650 0 0 {name=p11486 lab=_64745_/B }
C {devices/lab_pin.sym} 11740 -19610 0 0 {name=p11487 lab=_51259_/X }
C {devices/lab_pin.sym} 11740 -19570 0 0 {name=p11488 lab=_51261_/Y }
C {devices/lab_pin.sym} 11900 -19610 0 1 {name=p11489 lab=_51262_/Y }
C {sky130_stdcells/o21ai_4.sym} 11820 -19610 0 0 {name=X_51262_ }
C {devices/lab_pin.sym} 11740 -19510 0 0 {name=p11490 lab=_63344_/B }
C {devices/lab_pin.sym} 11740 -19470 0 0 {name=p11491 lab=_60583_/A }
C {devices/lab_pin.sym} 11740 -19430 0 0 {name=p11492 lab=_60515_/B }
C {devices/lab_pin.sym} 11740 -19390 0 0 {name=p11493 lab=_63281_/D }
C {devices/lab_pin.sym} 11740 -19350 0 0 {name=p11494 lab=_60392_/A }
C {devices/lab_pin.sym} 11900 -19430 0 1 {name=p11495 lab=_63248_/X }
C {sky130_stdcells/o41a_4.sym} 11820 -19430 0 0 {name=X_63248_ }
C {devices/lab_pin.sym} 11730 -19270 0 0 {name=p11496 lab=_82104_/CLK }
C {devices/lab_pin.sym} 11730 -19250 0 0 {name=p11497 lab=_82082_/D }
C {devices/lab_pin.sym} 11910 -19270 0 1 {name=p11498 lab=_82082_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -19260 0 0 {name=X_82082_ }
C {devices/lab_pin.sym} 11780 -19130 0 0 {name=p11499 lab=_52892_/A }
C {devices/lab_pin.sym} 11860 -19130 0 1 {name=p11500 lab=_53001_/X }
C {sky130_stdcells/buf_2.sym} 11820 -19130 0 0 {name=X_53001_ }
C {devices/lab_pin.sym} 11780 -19010 0 0 {name=p11501 lab=_50595_/A }
C {devices/lab_pin.sym} 11860 -19010 0 1 {name=p11502 lab=_50213_/X }
C {sky130_stdcells/buf_2.sym} 11820 -19010 0 0 {name=X_50213_ }
C {devices/lab_pin.sym} 11730 -18890 0 0 {name=p11503 lab=_86587_/CLK }
C {devices/lab_pin.sym} 11730 -18870 0 0 {name=p11504 lab=_85910_/D }
C {devices/lab_pin.sym} 11910 -18890 0 1 {name=p11505 lab=_73827_/B }
C {sky130_stdcells/dfxtp_4.sym} 11820 -18880 0 0 {name=X_85910_ }
C {devices/lab_pin.sym} 11730 -18750 0 0 {name=p11506 lab=_82084_/CLK }
C {devices/lab_pin.sym} 11730 -18730 0 0 {name=p11507 lab=_81033_/D }
C {devices/lab_pin.sym} 11910 -18750 0 1 {name=p11508 lab=_81033_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -18740 0 0 {name=X_81033_ }
C {devices/lab_pin.sym} 11740 -18630 0 0 {name=p11509 lab=_51190_/Y }
C {devices/lab_pin.sym} 11740 -18590 0 0 {name=p11510 lab=_51175_/X }
C {devices/lab_pin.sym} 11740 -18550 0 0 {name=p11511 lab=_51192_/X }
C {devices/lab_pin.sym} 11900 -18590 0 1 {name=p11512 lab=_51193_/Y }
C {sky130_stdcells/a21oi_4.sym} 11820 -18590 0 0 {name=X_51193_ }
C {devices/lab_pin.sym} 11760 -18480 0 0 {name=p11513 lab=_63154_/X }
C {devices/lab_pin.sym} 11760 -18440 0 0 {name=p11514 lab=_64392_/B }
C {devices/lab_pin.sym} 11760 -18400 0 0 {name=p11515 lab=_63165_/X }
C {devices/lab_pin.sym} 11760 -18360 0 0 {name=p11516 lab=_63192_/D }
C {devices/lab_pin.sym} 11880 -18420 0 1 {name=p11517 lab=_63179_/X }
C {sky130_stdcells/and4_4.sym} 11820 -18420 0 0 {name=X_63179_ }
C {devices/lab_pin.sym} 11730 -18270 0 0 {name=p11518 lab=_86861_/CLK }
C {devices/lab_pin.sym} 11730 -18250 0 0 {name=p11519 lab=_45236_/Y }
C {devices/lab_pin.sym} 11910 -18270 0 1 {name=p11520 lab=_64458_/B }
C {sky130_stdcells/dfxtp_4.sym} 11820 -18260 0 0 {name=X_86890_ }
C {devices/lab_pin.sym} 11760 -18140 0 0 {name=p11521 lab=_50153_/A }
C {devices/lab_pin.sym} 11760 -18100 0 0 {name=p11522 lab=_50144_/B }
C {devices/lab_pin.sym} 11880 -18120 0 1 {name=p11523 lab=_50144_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -18120 0 0 {name=X_50144_ }
C {devices/lab_pin.sym} 11730 -17990 0 0 {name=p11524 lab=_85555_/CLK }
C {devices/lab_pin.sym} 11730 -17970 0 0 {name=p11525 lab=_52346_/Y }
C {devices/lab_pin.sym} 11910 -17990 0 1 {name=p11526 lab=_65032_/B }
C {sky130_stdcells/dfxtp_4.sym} 11820 -17980 0 0 {name=X_85841_ }
C {devices/lab_pin.sym} 11780 -17850 0 0 {name=p11527 lab=_67987_/A }
C {devices/lab_pin.sym} 11860 -17850 0 1 {name=p11528 lab=_67987_/X }
C {sky130_stdcells/buf_2.sym} 11820 -17850 0 0 {name=X_67987_ }
C {devices/lab_pin.sym} 11740 -17750 0 0 {name=p11529 lab=_57739_/X }
C {devices/lab_pin.sym} 11740 -17710 0 0 {name=p11530 lab=_85727_/Q }
C {devices/lab_pin.sym} 11740 -17670 0 0 {name=p11531 lab=_44252_/X }
C {devices/lab_pin.sym} 11900 -17710 0 1 {name=p11532 lab=_57740_/X }
C {sky130_stdcells/o21a_4.sym} 11820 -17710 0 0 {name=X_57740_ }
C {devices/lab_pin.sym} 11740 -17600 0 0 {name=p11533 lab=_87059_/Q }
C {devices/lab_pin.sym} 11740 -17560 0 0 {name=p11534 lab=_69664_/X }
C {devices/lab_pin.sym} 11740 -17520 0 0 {name=p11535 lab=_69665_/X }
C {devices/lab_pin.sym} 11740 -17480 0 0 {name=p11536 lab=_69725_/X }
C {devices/lab_pin.sym} 11900 -17540 0 1 {name=p11537 lab=_69727_/B }
C {sky130_stdcells/a211o_4.sym} 11820 -17540 0 0 {name=X_69726_ }
C {devices/lab_pin.sym} 11740 -17410 0 0 {name=p11538 lab=_54949_/Y }
C {devices/lab_pin.sym} 11740 -17370 0 0 {name=p11539 lab=_54936_/X }
C {devices/lab_pin.sym} 11740 -17330 0 0 {name=p11540 lab=_54951_/X }
C {devices/lab_pin.sym} 11900 -17370 0 1 {name=p11541 lab=_85347_/D }
C {sky130_stdcells/a21oi_4.sym} 11820 -17370 0 0 {name=X_54952_ }
C {devices/lab_pin.sym} 11760 -17240 0 0 {name=p11542 lab=_50084_/A }
C {devices/lab_pin.sym} 11760 -17200 0 0 {name=p11543 lab=_48922_/B }
C {devices/lab_pin.sym} 11880 -17220 0 1 {name=p11544 lab=_50075_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -17220 0 0 {name=X_50075_ }
C {devices/lab_pin.sym} 11760 -17100 0 0 {name=p11545 lab=_66840_/X }
C {devices/lab_pin.sym} 11760 -17060 0 0 {name=p11546 lab=_66938_/B }
C {devices/lab_pin.sym} 11880 -17080 0 1 {name=p11547 lab=_66938_/X }
C {sky130_stdcells/and2_4.sym} 11820 -17080 0 0 {name=X_66938_ }
C {devices/lab_pin.sym} 11730 -16950 0 0 {name=p11548 lab=_85773_/CLK }
C {devices/lab_pin.sym} 11730 -16930 0 0 {name=p11549 lab=_52695_/Y }
C {devices/lab_pin.sym} 11910 -16950 0 1 {name=p11550 lab=_85772_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -16940 0 0 {name=X_85772_ }
C {devices/lab_pin.sym} 11730 -16810 0 0 {name=p11551 lab=_85134_/CLK }
C {devices/lab_pin.sym} 11730 -16790 0 0 {name=p11552 lab=_82984_/D }
C {devices/lab_pin.sym} 11910 -16810 0 1 {name=p11553 lab=_82984_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -16800 0 0 {name=X_82984_ }
C {devices/lab_pin.sym} 11730 -16670 0 0 {name=p11554 lab=_87767_/CLK }
C {devices/lab_pin.sym} 11730 -16650 0 0 {name=p11555 lab=_87511_/D }
C {devices/lab_pin.sym} 11910 -16670 0 1 {name=p11556 lab=_87511_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -16660 0 0 {name=X_87511_ }
C {devices/lab_pin.sym} 11740 -16550 0 0 {name=p11557 lab=_53899_/Y }
C {devices/lab_pin.sym} 11740 -16510 0 0 {name=p11558 lab=_53862_/X }
C {devices/lab_pin.sym} 11740 -16470 0 0 {name=p11559 lab=_53902_/Y }
C {devices/lab_pin.sym} 11900 -16510 0 1 {name=p11560 lab=_85546_/D }
C {sky130_stdcells/a21boi_4.sym} 11820 -16510 0 0 {name=X_53903_ }
C {devices/lab_pin.sym} 11730 -16370 0 0 {name=p11561 lab=_83464_/CLK }
C {devices/lab_pin.sym} 11730 -16350 0 0 {name=p11562 lab=_84723_/D }
C {devices/lab_pin.sym} 11910 -16370 0 1 {name=p11563 lab=_84723_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -16360 0 0 {name=X_84723_ }
C {devices/lab_pin.sym} 11740 -16250 0 0 {name=p11564 lab=_57650_/X }
C {devices/lab_pin.sym} 11740 -16210 0 0 {name=p11565 lab=_57668_/Y }
C {devices/lab_pin.sym} 11740 -16170 0 0 {name=p11566 lab=_57670_/Y }
C {devices/lab_pin.sym} 11900 -16210 0 1 {name=p11567 lab=_57671_/Y }
C {sky130_stdcells/a21oi_4.sym} 11820 -16210 0 0 {name=X_57671_ }
C {devices/lab_pin.sym} 11730 -16070 0 0 {name=p11568 lab=_81985_/CLK }
C {devices/lab_pin.sym} 11730 -16050 0 0 {name=p11569 lab=_77856_/Y }
C {devices/lab_pin.sym} 11910 -16070 0 1 {name=p11570 lab=_77421_/A }
C {sky130_stdcells/dfxtp_4.sym} 11820 -16060 0 0 {name=X_81935_ }
C {devices/lab_pin.sym} 11740 -15960 0 0 {name=p11571 lab=_69226_/Y }
C {devices/lab_pin.sym} 11740 -15920 0 0 {name=p11572 lab=_69644_/X }
C {devices/lab_pin.sym} 11740 -15880 0 0 {name=p11573 lab=_69604_/X }
C {devices/lab_pin.sym} 11740 -15840 0 0 {name=p11574 lab=_69656_/Y }
C {devices/lab_pin.sym} 11900 -15900 0 1 {name=p11575 lab=_69657_/X }
C {sky130_stdcells/a211o_4.sym} 11820 -15900 0 0 {name=X_69657_ }
C {devices/lab_pin.sym} 11760 -15780 0 0 {name=p11576 lab=_54883_/A }
C {devices/lab_pin.sym} 11760 -15740 0 0 {name=p11577 lab=_54883_/B }
C {devices/lab_pin.sym} 11760 -15700 0 0 {name=p11578 lab=_54883_/C }
C {devices/lab_pin.sym} 11760 -15660 0 0 {name=p11579 lab=_53191_/D }
C {devices/lab_pin.sym} 11880 -15720 0 1 {name=p11580 lab=_54883_/X }
C {sky130_stdcells/and4_4.sym} 11820 -15720 0 0 {name=X_54883_ }
C {devices/lab_pin.sym} 11760 -15580 0 0 {name=p11581 lab=_66823_/A }
C {devices/lab_pin.sym} 11760 -15540 0 0 {name=p11582 lab=_88135_/Q }
C {devices/lab_pin.sym} 11880 -15560 0 1 {name=p11583 lab=_66869_/X }
C {sky130_stdcells/and2_4.sym} 11820 -15560 0 0 {name=X_66869_ }
C {devices/lab_pin.sym} 11780 -15430 0 0 {name=p11584 lab=_63161_/A }
C {devices/lab_pin.sym} 11860 -15430 0 1 {name=p11585 lab=_59411_/A }
C {sky130_stdcells/buf_2.sym} 11820 -15430 0 0 {name=X_59410_ }
C {devices/lab_pin.sym} 11780 -15310 0 0 {name=p11586 lab=_56621_/X }
C {devices/lab_pin.sym} 11860 -15310 0 1 {name=p11587 lab=_72664_/C }
C {sky130_stdcells/buf_2.sym} 11820 -15310 0 0 {name=X_56622_ }
C {devices/lab_pin.sym} 11740 -15220 0 0 {name=p11588 lab=_87094_/Q }
C {devices/lab_pin.sym} 11740 -15180 0 0 {name=p11589 lab=_68580_/X }
C {devices/lab_pin.sym} 11740 -15140 0 0 {name=p11590 lab=_68509_/X }
C {devices/lab_pin.sym} 11740 -15100 0 0 {name=p11591 lab=_68607_/X }
C {devices/lab_pin.sym} 11900 -15160 0 1 {name=p11592 lab=_68608_/X }
C {sky130_stdcells/a211o_4.sym} 11820 -15160 0 0 {name=X_68608_ }
C {devices/lab_pin.sym} 11730 -15010 0 0 {name=p11593 lab=_87888_/CLK }
C {devices/lab_pin.sym} 11730 -14990 0 0 {name=p11594 lab=_87442_/D }
C {devices/lab_pin.sym} 11910 -15010 0 1 {name=p11595 lab=_87442_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -15000 0 0 {name=X_87442_ }
C {devices/lab_pin.sym} 11760 -14880 0 0 {name=p11596 lab=_53825_/A }
C {devices/lab_pin.sym} 11760 -14840 0 0 {name=p11597 lab=_53834_/B }
C {devices/lab_pin.sym} 11880 -14860 0 1 {name=p11598 lab=_53834_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -14860 0 0 {name=X_53834_ }
C {devices/lab_pin.sym} 11730 -14730 0 0 {name=p11599 lab=_84672_/CLK }
C {devices/lab_pin.sym} 11730 -14710 0 0 {name=p11600 lab=_60140_/Y }
C {devices/lab_pin.sym} 11910 -14730 0 1 {name=p11601 lab=_60139_/C }
C {sky130_stdcells/dfxtp_4.sym} 11820 -14720 0 0 {name=X_84654_ }
C {devices/lab_pin.sym} 11730 -14590 0 0 {name=p11602 lab=_84441_/CLK }
C {devices/lab_pin.sym} 11730 -14570 0 0 {name=p11603 lab=_78057_/X }
C {devices/lab_pin.sym} 11910 -14590 0 1 {name=p11604 lab=_81866_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -14580 0 0 {name=X_81866_ }
C {devices/lab_pin.sym} 11760 -14460 0 0 {name=p11605 lab=_69585_/X }
C {devices/lab_pin.sym} 11760 -14420 0 0 {name=p11606 lab=_69587_/X }
C {devices/lab_pin.sym} 11880 -14440 0 1 {name=p11607 lab=_69588_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -14440 0 0 {name=X_69588_ }
C {devices/lab_pin.sym} 11760 -14320 0 0 {name=p11608 lab=_86661_/Q }
C {devices/lab_pin.sym} 11760 -14280 0 0 {name=p11609 lab=_59306_/B }
C {devices/lab_pin.sym} 11880 -14300 0 1 {name=p11610 lab=_59341_/Y }
C {sky130_stdcells/nor2_4.sym} 11820 -14300 0 0 {name=X_59341_ }
C {devices/lab_pin.sym} 11730 -14170 0 0 {name=p11611 lab=_85837_/CLK }
C {devices/lab_pin.sym} 11730 -14150 0 0 {name=p11612 lab=_71107_/Y }
C {devices/lab_pin.sym} 11910 -14170 0 1 {name=p11613 lab=_49082_/A }
C {sky130_stdcells/dfxtp_4.sym} 11820 -14160 0 0 {name=X_83605_ }
C {devices/lab_pin.sym} 11780 -14030 0 0 {name=p11614 lab=_56552_/Y }
C {devices/lab_pin.sym} 11860 -14030 0 1 {name=p11615 lab=_56553_/Y }
C {sky130_stdcells/inv_2.sym} 11820 -14030 0 0 {name=X_56553_ }
C {devices/lab_pin.sym} 11730 -13910 0 0 {name=p11616 lab=_80817_/CLK }
C {devices/lab_pin.sym} 11730 -13890 0 0 {name=p11617 lab=_83961_/Q }
C {devices/lab_pin.sym} 11910 -13910 0 1 {name=p11618 lab=_80817_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -13900 0 0 {name=X_80817_ }
C {devices/lab_pin.sym} 11740 -13790 0 0 {name=p11619 lab=_80827_/D }
C {devices/lab_pin.sym} 11740 -13750 0 0 {name=p11620 lab=_68462_/X }
C {devices/lab_pin.sym} 11740 -13710 0 0 {name=p11621 lab=_68538_/X }
C {devices/lab_pin.sym} 11900 -13750 0 1 {name=p11622 lab=_83971_/D }
C {sky130_stdcells/a21bo_4.sym} 11820 -13750 0 0 {name=X_68539_ }
C {devices/lab_pin.sym} 11730 -13610 0 0 {name=p11623 lab=_87373_/CLK }
C {devices/lab_pin.sym} 11730 -13590 0 0 {name=p11624 lab=_87373_/D }
C {devices/lab_pin.sym} 11910 -13610 0 1 {name=p11625 lab=_87373_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -13600 0 0 {name=X_87373_ }
C {devices/lab_pin.sym} 11740 -13490 0 0 {name=p11626 lab=_53762_/Y }
C {devices/lab_pin.sym} 11740 -13450 0 0 {name=p11627 lab=_53747_/X }
C {devices/lab_pin.sym} 11740 -13410 0 0 {name=p11628 lab=_53764_/X }
C {devices/lab_pin.sym} 11900 -13450 0 1 {name=p11629 lab=_85573_/D }
C {sky130_stdcells/a21oi_4.sym} 11820 -13450 0 0 {name=X_53765_ }
C {devices/lab_pin.sym} 11730 -13310 0 0 {name=p11630 lab=_84458_/CLK }
C {devices/lab_pin.sym} 11730 -13290 0 0 {name=p11631 lab=_84585_/D }
C {devices/lab_pin.sym} 11910 -13310 0 1 {name=p11632 lab=_78080_/A }
C {sky130_stdcells/dfxtp_4.sym} 11820 -13300 0 0 {name=X_84585_ }
C {devices/lab_pin.sym} 11740 -13190 0 0 {name=p11633 lab=_86096_/Q }
C {devices/lab_pin.sym} 11740 -13150 0 0 {name=p11634 lab=_50965_/X }
C {devices/lab_pin.sym} 11740 -13110 0 0 {name=p11635 lab=_50976_/Y }
C {devices/lab_pin.sym} 11900 -13150 0 1 {name=p11636 lab=_50977_/Y }
C {sky130_stdcells/o21ai_4.sym} 11820 -13150 0 0 {name=X_50977_ }
C {devices/lab_pin.sym} 11730 -13010 0 0 {name=p11637 lab=_85381_/CLK }
C {devices/lab_pin.sym} 11730 -12990 0 0 {name=p11638 lab=_81605_/Q }
C {devices/lab_pin.sym} 11910 -13010 0 1 {name=p11639 lab=_47493_/A }
C {sky130_stdcells/dfxtp_4.sym} 11820 -13000 0 0 {name=X_81797_ }
C {devices/lab_pin.sym} 11740 -12890 0 0 {name=p11640 lab=_55447_/Y }
C {devices/lab_pin.sym} 11740 -12850 0 0 {name=p11641 lab=_55451_/B }
C {devices/lab_pin.sym} 11740 -12810 0 0 {name=p11642 lab=_55503_/Y }
C {devices/lab_pin.sym} 11900 -12850 0 1 {name=p11643 lab=_55504_/Y }
C {sky130_stdcells/a21oi_4.sym} 11820 -12850 0 0 {name=X_55504_ }
C {devices/lab_pin.sym} 11730 -12710 0 0 {name=p11644 lab=_86322_/CLK }
C {devices/lab_pin.sym} 11730 -12690 0 0 {name=p11645 lab=_49784_/Y }
C {devices/lab_pin.sym} 11910 -12710 0 1 {name=p11646 lab=_57918_/B }
C {sky130_stdcells/dfxtp_4.sym} 11820 -12700 0 0 {name=X_86324_ }
C {devices/lab_pin.sym} 11740 -12600 0 0 {name=p11647 lab=_40729_/X }
C {devices/lab_pin.sym} 11740 -12560 0 0 {name=p11648 lab=_40719_/X }
C {devices/lab_pin.sym} 11740 -12520 0 0 {name=p11649 lab=_88346_/Q }
C {devices/lab_pin.sym} 11740 -12480 0 0 {name=p11650 lab=_40720_/X }
C {devices/lab_pin.sym} 11900 -12540 0 1 {name=p11651 lab=_88346_/D }
C {sky130_stdcells/a2bb2o_4.sym} 11820 -12540 0 0 {name=X_40730_ }
C {devices/lab_pin.sym} 11760 -12420 0 0 {name=p11652 lab=_52704_/A }
C {devices/lab_pin.sym} 11760 -12380 0 0 {name=p11653 lab=_52724_/B }
C {devices/lab_pin.sym} 11760 -12340 0 0 {name=p11654 lab=_52708_/X }
C {devices/lab_pin.sym} 11760 -12300 0 0 {name=p11655 lab=_52716_/D }
C {devices/lab_pin.sym} 11880 -12360 0 1 {name=p11656 lab=_52716_/X }
C {sky130_stdcells/and4_4.sym} 11820 -12360 0 0 {name=X_52716_ }
C {devices/lab_pin.sym} 11740 -12250 0 0 {name=p11657 lab=_59253_/X }
C {devices/lab_pin.sym} 11740 -12210 0 0 {name=p11658 lab=_59269_/Y }
C {devices/lab_pin.sym} 11740 -12170 0 0 {name=p11659 lab=_59270_/Y }
C {devices/lab_pin.sym} 11740 -12130 0 0 {name=p11660 lab=_59271_/X }
C {devices/lab_pin.sym} 11740 -12090 0 0 {name=p11661 lab=_59258_/X }
C {devices/lab_pin.sym} 11900 -12170 0 1 {name=p11662 lab=_59272_/X }
C {sky130_stdcells/o32a_4.sym} 11820 -12170 0 0 {name=X_59272_ }
C {devices/lab_pin.sym} 11760 -12030 0 0 {name=p11663 lab=_70689_/A }
C {devices/lab_pin.sym} 11760 -11990 0 0 {name=p11664 lab=_71546_/B }
C {devices/lab_pin.sym} 11760 -11950 0 0 {name=p11665 lab=_71536_/A }
C {devices/lab_pin.sym} 11880 -11990 0 1 {name=p11666 lab=_71550_/Y }
C {sky130_stdcells/nor3_4.sym} 11820 -11990 0 0 {name=X_71550_ }
C {devices/lab_pin.sym} 11730 -11850 0 0 {name=p11667 lab=_86210_/CLK }
C {devices/lab_pin.sym} 11730 -11830 0 0 {name=p11668 lab=_71324_/Y }
C {devices/lab_pin.sym} 11910 -11850 0 1 {name=p11669 lab=_83536_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -11840 0 0 {name=X_83536_ }
C {devices/lab_pin.sym} 11780 -11710 0 0 {name=p11670 lab=_56448_/X }
C {devices/lab_pin.sym} 11860 -11710 0 1 {name=p11671 lab=_56484_/X }
C {sky130_stdcells/buf_2.sym} 11820 -11710 0 0 {name=X_56484_ }
C {devices/lab_pin.sym} 11730 -11590 0 0 {name=p11672 lab=_81125_/CLK }
C {devices/lab_pin.sym} 11730 -11570 0 0 {name=p11673 lab=_80748_/D }
C {devices/lab_pin.sym} 11910 -11590 0 1 {name=p11674 lab=_81124_/D }
C {sky130_stdcells/dfxtp_4.sym} 11820 -11580 0 0 {name=X_80748_ }
C {devices/lab_pin.sym} 11780 -11450 0 0 {name=p11675 lab=_53696_/A }
C {devices/lab_pin.sym} 11860 -11450 0 1 {name=p11676 lab=_53696_/X }
C {sky130_stdcells/buf_2.sym} 11820 -11450 0 0 {name=X_53696_ }
C {devices/lab_pin.sym} 11780 -11330 0 0 {name=p11677 lab=_70500_/Y }
C {devices/lab_pin.sym} 11860 -11330 0 1 {name=p11678 lab=_70501_/X }
C {sky130_stdcells/buf_2.sym} 11820 -11330 0 0 {name=X_70501_ }
C {devices/lab_pin.sym} 11740 -11230 0 0 {name=p11679 lab=_58219_/X }
C {devices/lab_pin.sym} 11740 -11190 0 0 {name=p11680 lab=_58220_/Y }
C {devices/lab_pin.sym} 11740 -11150 0 0 {name=p11681 lab=_58222_/Y }
C {devices/lab_pin.sym} 11900 -11190 0 1 {name=p11682 lab=_58223_/Y }
C {sky130_stdcells/a21oi_4.sym} 11820 -11190 0 0 {name=X_58223_ }
C {devices/lab_pin.sym} 11740 -11070 0 0 {name=p11683 lab=_55431_/Y }
C {devices/lab_pin.sym} 11740 -11030 0 0 {name=p11684 lab=_55432_/Y }
C {devices/lab_pin.sym} 11740 -10990 0 0 {name=p11685 lab=_55434_/Y }
C {devices/lab_pin.sym} 11900 -11030 0 1 {name=p11686 lab=_55435_/X }
C {sky130_stdcells/o21a_4.sym} 11820 -11030 0 0 {name=X_55435_ }
C {devices/lab_pin.sym} 11730 -10890 0 0 {name=p11687 lab=_86256_/CLK }
C {devices/lab_pin.sym} 11730 -10870 0 0 {name=p11688 lab=_86255_/D }
C {devices/lab_pin.sym} 11910 -10890 0 1 {name=p11689 lab=_65084_/B }
C {sky130_stdcells/dfxtp_4.sym} 11820 -10880 0 0 {name=X_86255_ }
C {sky130_stdcells/decap_3.sym} 11820 -10720 0 0 {name=XPHY_501 }
C {devices/lab_pin.sym} 11780 -10570 0 0 {name=p11690 lab=_40660_/X }
C {devices/lab_pin.sym} 11860 -10570 0 1 {name=p11691 lab=_40661_/X }
C {sky130_stdcells/buf_2.sym} 11820 -10570 0 0 {name=X_40661_ }
C {devices/lab_pin.sym} 11780 -10450 0 0 {name=p11692 lab=_52619_/A }
C {devices/lab_pin.sym} 11860 -10450 0 1 {name=p11693 lab=_52647_/X }
C {sky130_stdcells/buf_2.sym} 11820 -10450 0 0 {name=X_52647_ }
C {devices/lab_pin.sym} 11760 -10360 0 0 {name=p11694 lab=_71827_/A }
C {devices/lab_pin.sym} 11760 -10320 0 0 {name=p11695 lab=_71479_/B }
C {devices/lab_pin.sym} 11760 -10280 0 0 {name=p11696 lab=_70790_/A }
C {devices/lab_pin.sym} 11760 -10240 0 0 {name=p11697 lab=_71716_/D }
C {devices/lab_pin.sym} 11880 -10300 0 1 {name=p11698 lab=_71481_/X }
C {sky130_stdcells/and4_4.sym} 11820 -10300 0 0 {name=X_71481_ }
C {devices/lab_pin.sym} 11730 -10150 0 0 {name=p11699 lab=_85955_/CLK }
C {devices/lab_pin.sym} 11730 -10130 0 0 {name=p11700 lab=_83467_/D }
C {devices/lab_pin.sym} 11910 -10150 0 1 {name=p11701 lab=_47808_/A }
C {sky130_stdcells/dfxtp_4.sym} 11820 -10140 0 0 {name=X_83467_ }
C {sky130_stdcells/decap_3.sym} 11820 -9980 0 0 {name=XPHY_512 }
C {devices/lab_pin.sym} 11730 -9830 0 0 {name=p11702 lab=_80679_/CLK }
C {devices/lab_pin.sym} 11730 -9810 0 0 {name=p11703 lab=_80679_/D }
C {devices/lab_pin.sym} 11910 -9830 0 1 {name=p11704 lab=_75138_/A }
C {sky130_stdcells/dfxtp_4.sym} 11820 -9820 0 0 {name=X_80679_ }
C {sky130_stdcells/decap_3.sym} 11820 -9660 0 0 {name=XPHY_523 }
C {devices/lab_pin.sym} 11780 -9510 0 0 {name=p11705 lab=_42400_/A }
C {devices/lab_pin.sym} 11860 -9510 0 1 {name=p11706 lab=_87881_/D }
C {sky130_stdcells/inv_2.sym} 11820 -9510 0 0 {name=X_42400_ }
C {sky130_stdcells/decap_3.sym} 11820 -9360 0 0 {name=XPHY_534 }
C {devices/lab_pin.sym} 11760 -9230 0 0 {name=p11707 lab=_73218_/X }
C {devices/lab_pin.sym} 11760 -9190 0 0 {name=p11708 lab=_73220_/B }
C {devices/lab_pin.sym} 11760 -9150 0 0 {name=p11709 lab=_73220_/C }
C {devices/lab_pin.sym} 11880 -9190 0 1 {name=p11710 lab=_73220_/Y }
C {sky130_stdcells/nand3_4.sym} 11820 -9190 0 0 {name=X_73220_ }
C {devices/lab_pin.sym} 11730 -9050 0 0 {name=p11711 lab=_85269_/CLK }
C {devices/lab_pin.sym} 11730 -9030 0 0 {name=p11712 lab=_56406_/Y }
C {devices/lab_pin.sym} 11910 -9050 0 1 {name=p11713 lab=_85206_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -9040 0 0 {name=X_85206_ }
C {devices/lab_pin.sym} 11740 -8930 0 0 {name=p11714 lab=_47924_/B }
C {devices/lab_pin.sym} 11740 -8890 0 0 {name=p11715 lab=_70422_/X }
C {devices/lab_pin.sym} 11740 -8850 0 0 {name=p11716 lab=_70431_/Y }
C {devices/lab_pin.sym} 11900 -8890 0 1 {name=p11717 lab=_70432_/Y }
C {sky130_stdcells/o21ai_4.sym} 11820 -8890 0 0 {name=X_70432_ }
C {devices/lab_pin.sym} 11780 -8750 0 0 {name=p11718 lab=_58154_/A }
C {devices/lab_pin.sym} 11860 -8750 0 1 {name=p11719 lab=_63033_/A }
C {sky130_stdcells/inv_2.sym} 11820 -8750 0 0 {name=X_58154_ }
C {devices/lab_pin.sym} 11730 -8630 0 0 {name=p11720 lab=_82820_/CLK }
C {devices/lab_pin.sym} 11730 -8610 0 0 {name=p11721 lab=_82450_/Q }
C {devices/lab_pin.sym} 11910 -8630 0 1 {name=p11722 lab=_78547_/A }
C {sky130_stdcells/dfxtp_4.sym} 11820 -8620 0 0 {name=X_82418_ }
C {sky130_stdcells/decap_3.sym} 11820 -8460 0 0 {name=XPHY_545 }
C {devices/lab_pin.sym} 11780 -8310 0 0 {name=p11723 lab=_43379_/Y }
C {devices/lab_pin.sym} 11860 -8310 0 1 {name=p11724 lab=_87452_/D }
C {sky130_stdcells/inv_2.sym} 11820 -8310 0 0 {name=X_43380_ }
C {devices/lab_pin.sym} 11780 -8190 0 0 {name=p11725 lab=_55366_/A }
C {devices/lab_pin.sym} 11860 -8190 0 1 {name=p11726 lab=_55392_/A }
C {sky130_stdcells/buf_2.sym} 11820 -8190 0 0 {name=X_55366_ }
C {devices/lab_pin.sym} 11730 -8070 0 0 {name=p11727 lab=_86186_/CLK }
C {devices/lab_pin.sym} 11730 -8050 0 0 {name=p11728 lab=_50516_/Y }
C {devices/lab_pin.sym} 11910 -8070 0 1 {name=p11729 lab=_86186_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -8060 0 0 {name=X_86186_ }
C {devices/lab_pin.sym} 11780 -7930 0 0 {name=p11730 lab=_40591_/X }
C {devices/lab_pin.sym} 11860 -7930 0 1 {name=p11731 lab=_48903_/A }
C {sky130_stdcells/buf_2.sym} 11820 -7930 0 0 {name=X_40592_ }
C {sky130_stdcells/decap_3.sym} 11820 -7780 0 0 {name=XPHY_556 }
C {devices/lab_pin.sym} 11740 -7650 0 0 {name=p11732 lab=_85793_/Q }
C {devices/lab_pin.sym} 11740 -7610 0 0 {name=p11733 lab=_52575_/X }
C {devices/lab_pin.sym} 11740 -7570 0 0 {name=p11734 lab=_52577_/Y }
C {devices/lab_pin.sym} 11900 -7610 0 1 {name=p11735 lab=_52578_/Y }
C {sky130_stdcells/o21ai_4.sym} 11820 -7610 0 0 {name=X_52578_ }
C {devices/lab_pin.sym} 11730 -7470 0 0 {name=p11736 lab=_83431_/CLK }
C {devices/lab_pin.sym} 11730 -7450 0 0 {name=p11737 lab=_71726_/Y }
C {devices/lab_pin.sym} 11910 -7470 0 1 {name=p11738 lab=_58229_/A }
C {sky130_stdcells/dfxtp_4.sym} 11820 -7460 0 0 {name=X_83398_ }
C {sky130_stdcells/decap_3.sym} 11820 -7300 0 0 {name=XPHY_567 }
C {sky130_stdcells/decap_3.sym} 11820 -7120 0 0 {name=XPHY_578 }
C {devices/lab_pin.sym} 11780 -6970 0 0 {name=p11739 lab=_57093_/Y }
C {devices/lab_pin.sym} 11860 -6970 0 1 {name=p11740 lab=_57105_/Y }
C {sky130_stdcells/inv_2.sym} 11820 -6970 0 0 {name=X_57105_ }
C {devices/lab_pin.sym} 11740 -6890 0 0 {name=p11741 lab=_42330_/X }
C {devices/lab_pin.sym} 11740 -6850 0 0 {name=p11742 lab=_42319_/X }
C {devices/lab_pin.sym} 11740 -6810 0 0 {name=p11743 lab=_41656_/X }
C {devices/lab_pin.sym} 11740 -6770 0 0 {name=p11744 lab=_87918_/Q }
C {devices/lab_pin.sym} 11740 -6730 0 0 {name=p11745 lab=_42320_/X }
C {devices/lab_pin.sym} 11900 -6810 0 1 {name=p11746 lab=_42331_/Y }
C {sky130_stdcells/o32ai_4.sym} 11820 -6810 0 0 {name=X_42331_ }
C {devices/lab_pin.sym} 11780 -6650 0 0 {name=p11747 lab=_54317_/A }
C {devices/lab_pin.sym} 11860 -6650 0 1 {name=p11748 lab=_54317_/X }
C {sky130_stdcells/buf_2.sym} 11820 -6650 0 0 {name=X_54317_ }
C {sky130_stdcells/decap_3.sym} 11820 -6500 0 0 {name=XPHY_589 }
C {devices/lab_pin.sym} 11740 -6370 0 0 {name=p11749 lab=_73148_/X }
C {devices/lab_pin.sym} 11740 -6330 0 0 {name=p11750 lab=_73150_/X }
C {devices/lab_pin.sym} 11740 -6290 0 0 {name=p11751 lab=_72862_/X }
C {devices/lab_pin.sym} 11900 -6330 0 1 {name=p11752 lab=_73156_/A }
C {sky130_stdcells/a21o_4.sym} 11820 -6330 0 0 {name=X_73151_ }
C {devices/lab_pin.sym} 11730 -6190 0 0 {name=p11753 lab=_85071_/CLK }
C {devices/lab_pin.sym} 11730 -6170 0 0 {name=p11754 lab=_56697_/X }
C {devices/lab_pin.sym} 11910 -6190 0 1 {name=p11755 lab=_85137_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -6180 0 0 {name=X_85137_ }
C {devices/lab_pin.sym} 11760 -6060 0 0 {name=p11756 lab=_51514_/A }
C {devices/lab_pin.sym} 11760 -6020 0 0 {name=p11757 lab=_53054_/B }
C {devices/lab_pin.sym} 11880 -6040 0 1 {name=p11758 lab=_51529_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -6040 0 0 {name=X_51529_ }
C {devices/lab_pin.sym} 11780 -5910 0 0 {name=p11759 lab=_70362_/X }
C {devices/lab_pin.sym} 11860 -5910 0 1 {name=p11760 lab=_70364_/A }
C {sky130_stdcells/buf_2.sym} 11820 -5910 0 0 {name=X_70363_ }
C {devices/lab_pin.sym} 11780 -5790 0 0 {name=p11761 lab=_58703_/A }
C {devices/lab_pin.sym} 11860 -5790 0 1 {name=p11762 lab=_58085_/X }
C {sky130_stdcells/buf_2.sym} 11820 -5790 0 0 {name=X_58085_ }
C {devices/lab_pin.sym} 11730 -5670 0 0 {name=p11763 lab=_82349_/CLK }
C {devices/lab_pin.sym} 11730 -5650 0 0 {name=p11764 lab=_77132_/X }
C {devices/lab_pin.sym} 11910 -5670 0 1 {name=p11765 lab=_82349_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -5660 0 0 {name=X_82349_ }
C {devices/lab_pin.sym} 11780 -5530 0 0 {name=p11766 lab=_55297_/A }
C {devices/lab_pin.sym} 11860 -5530 0 1 {name=p11767 lab=_55297_/X }
C {sky130_stdcells/buf_2.sym} 11820 -5530 0 0 {name=X_55297_ }
C {devices/lab_pin.sym} 11740 -5430 0 0 {name=p11768 lab=_83284_/Q }
C {devices/lab_pin.sym} 11740 -5390 0 0 {name=p11769 lab=_72090_/X }
C {devices/lab_pin.sym} 11740 -5350 0 0 {name=p11770 lab=_72101_/Y }
C {devices/lab_pin.sym} 11900 -5390 0 1 {name=p11771 lab=_72102_/Y }
C {sky130_stdcells/o21ai_4.sym} 11820 -5390 0 0 {name=X_72102_ }
C {devices/lab_pin.sym} 11740 -5270 0 0 {name=p11772 lab=_45045_/X }
C {devices/lab_pin.sym} 11740 -5230 0 0 {name=p11773 lab=_45048_/Y }
C {devices/lab_pin.sym} 11740 -5190 0 0 {name=p11774 lab=_45049_/X }
C {devices/lab_pin.sym} 11900 -5230 0 1 {name=p11775 lab=_45050_/Y }
C {sky130_stdcells/a21oi_4.sym} 11820 -5230 0 0 {name=X_45050_ }
C {devices/lab_pin.sym} 11740 -5110 0 0 {name=p11776 lab=_45752_/Y }
C {devices/lab_pin.sym} 11740 -5070 0 0 {name=p11777 lab=_56952_/X }
C {devices/lab_pin.sym} 11740 -5030 0 0 {name=p11778 lab=_57035_/X }
C {devices/lab_pin.sym} 11900 -5070 0 1 {name=p11779 lab=_85098_/D }
C {sky130_stdcells/o21ai_4.sym} 11820 -5070 0 0 {name=X_57036_ }
C {devices/lab_pin.sym} 11740 -4950 0 0 {name=p11780 lab=_54244_/Y }
C {devices/lab_pin.sym} 11740 -4910 0 0 {name=p11781 lab=_54226_/X }
C {devices/lab_pin.sym} 11740 -4870 0 0 {name=p11782 lab=_54247_/X }
C {devices/lab_pin.sym} 11900 -4910 0 1 {name=p11783 lab=_54248_/Y }
C {sky130_stdcells/a21oi_4.sym} 11820 -4910 0 0 {name=X_54248_ }
C {devices/lab_pin.sym} 11740 -4810 0 0 {name=p11784 lab=_42252_/X }
C {devices/lab_pin.sym} 11740 -4770 0 0 {name=p11785 lab=_42243_/X }
C {devices/lab_pin.sym} 11740 -4730 0 0 {name=p11786 lab=_41473_/X }
C {devices/lab_pin.sym} 11740 -4690 0 0 {name=p11787 lab=_87952_/Q }
C {devices/lab_pin.sym} 11740 -4650 0 0 {name=p11788 lab=_42244_/X }
C {devices/lab_pin.sym} 11900 -4730 0 1 {name=p11789 lab=_42262_/Y }
C {sky130_stdcells/o32ai_4.sym} 11820 -4730 0 0 {name=X_42262_ }
C {devices/lab_pin.sym} 11740 -4600 0 0 {name=p11790 lab=_69719_/B }
C {devices/lab_pin.sym} 11740 -4560 0 0 {name=p11791 lab=_73104_/B }
C {devices/lab_pin.sym} 11740 -4520 0 0 {name=p11792 lab=_72944_/X }
C {devices/lab_pin.sym} 11740 -4480 0 0 {name=p11793 lab=_73081_/Y }
C {devices/lab_pin.sym} 11900 -4540 0 1 {name=p11794 lab=_73082_/X }
C {sky130_stdcells/a211o_4.sym} 11820 -4540 0 0 {name=X_73082_ }
C {devices/lab_pin.sym} 11730 -4390 0 0 {name=p11795 lab=_84998_/CLK }
C {devices/lab_pin.sym} 11730 -4370 0 0 {name=p11796 lab=_85068_/D }
C {devices/lab_pin.sym} 11910 -4390 0 1 {name=p11797 lab=_85068_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -4380 0 0 {name=X_85068_ }
C {devices/lab_pin.sym} 11760 -4280 0 0 {name=p11798 lab=_70292_/A }
C {devices/lab_pin.sym} 11760 -4240 0 0 {name=p11799 lab=_70292_/B }
C {devices/lab_pin.sym} 11760 -4200 0 0 {name=p11800 lab=_83103_/Q }
C {devices/lab_pin.sym} 11760 -4160 0 0 {name=p11801 lab=_70292_/D }
C {devices/lab_pin.sym} 11880 -4220 0 1 {name=p11802 lab=_70294_/X }
C {sky130_stdcells/and4_4.sym} 11820 -4220 0 0 {name=X_70294_ }
C {devices/lab_pin.sym} 11780 -4070 0 0 {name=p11803 lab=_59544_/B }
C {devices/lab_pin.sym} 11860 -4070 0 1 {name=p11804 lab=_62640_/C }
C {sky130_stdcells/buf_2.sym} 11820 -4070 0 0 {name=X_44001_ }
C {devices/lab_pin.sym} 11740 -3970 0 0 {name=p11805 lab=_41042_/X }
C {devices/lab_pin.sym} 11740 -3930 0 0 {name=p11806 lab=_41043_/B }
C {devices/lab_pin.sym} 11740 -3890 0 0 {name=p11807 lab=_41212_/X }
C {devices/lab_pin.sym} 11900 -3930 0 1 {name=p11808 lab=_41213_/X }
C {sky130_stdcells/o21a_4.sym} 11820 -3930 0 0 {name=X_41213_ }
C {devices/lab_pin.sym} 11780 -3790 0 0 {name=p11809 lab=_72009_/A }
C {devices/lab_pin.sym} 11860 -3790 0 1 {name=p11810 lab=_72033_/X }
C {sky130_stdcells/buf_2.sym} 11820 -3790 0 0 {name=X_72033_ }
C {devices/lab_pin.sym} 11760 -3700 0 0 {name=p11811 lab=_76910_/A }
C {devices/lab_pin.sym} 11760 -3660 0 0 {name=p11812 lab=_76885_/X }
C {devices/lab_pin.sym} 11760 -3620 0 0 {name=p11813 lab=_76910_/C }
C {devices/lab_pin.sym} 11760 -3580 0 0 {name=p11814 lab=_76899_/Y }
C {devices/lab_pin.sym} 11880 -3640 0 1 {name=p11815 lab=_76910_/X }
C {sky130_stdcells/and4_4.sym} 11820 -3640 0 0 {name=X_76910_ }
C {devices/lab_pin.sym} 11730 -3490 0 0 {name=p11816 lab=_84020_/CLK }
C {devices/lab_pin.sym} 11730 -3470 0 0 {name=p11817 lab=_68179_/X }
C {devices/lab_pin.sym} 11910 -3490 0 1 {name=p11818 lab=_82059_/D }
C {sky130_stdcells/dfxtp_4.sym} 11820 -3480 0 0 {name=X_84019_ }
C {devices/lab_pin.sym} 11780 -3350 0 0 {name=p11819 lab=_42162_/A }
C {devices/lab_pin.sym} 11860 -3350 0 1 {name=p11820 lab=_42193_/X }
C {sky130_stdcells/buf_2.sym} 11820 -3350 0 0 {name=X_42193_ }
C {devices/lab_pin.sym} 11760 -3240 0 0 {name=p11821 lab=_54184_/A }
C {devices/lab_pin.sym} 11760 -3200 0 0 {name=p11822 lab=_47372_/Y }
C {devices/lab_pin.sym} 11880 -3220 0 1 {name=p11823 lab=_54179_/Y }
C {sky130_stdcells/nand2_4.sym} 11820 -3220 0 0 {name=X_54179_ }
C {devices/lab_pin.sym} 11760 -3100 0 0 {name=p11824 lab=_82244_/Q }
C {devices/lab_pin.sym} 11760 -3060 0 0 {name=p11825 lab=_77890_/B }
C {devices/lab_pin.sym} 11880 -3080 0 1 {name=p11826 lab=_77890_/Y }
C {sky130_stdcells/xnor2_4.sym} 11820 -3080 0 0 {name=X_77890_ }
C {devices/lab_pin.sym} 11780 -2950 0 0 {name=p11827 lab=_40932_/A }
C {devices/lab_pin.sym} 11860 -2950 0 1 {name=p11828 lab=_41145_/B }
C {sky130_stdcells/buf_2.sym} 11820 -2950 0 0 {name=X_41144_ }
C {devices/lab_pin.sym} 11760 -2840 0 0 {name=p11829 lab=_76841_/A }
C {devices/lab_pin.sym} 11760 -2800 0 0 {name=p11830 lab=_76840_/Y }
C {devices/lab_pin.sym} 11880 -2820 0 1 {name=p11831 lab=_76844_/A }
C {sky130_stdcells/xor2_4.sym} 11820 -2820 0 0 {name=X_76841_ }
C {devices/lab_pin.sym} 11780 -2690 0 0 {name=p11832 lab=_58987_/A }
C {devices/lab_pin.sym} 11860 -2690 0 1 {name=p11833 lab=_58987_/Y }
C {sky130_stdcells/inv_2.sym} 11820 -2690 0 0 {name=X_58987_ }
C {devices/lab_pin.sym} 11740 -2590 0 0 {name=p11834 lab=_48738_/Y }
C {devices/lab_pin.sym} 11740 -2550 0 0 {name=p11835 lab=_48734_/X }
C {devices/lab_pin.sym} 11740 -2510 0 0 {name=p11836 lab=_48739_/X }
C {devices/lab_pin.sym} 11900 -2550 0 1 {name=p11837 lab=_86492_/D }
C {sky130_stdcells/a21oi_4.sym} 11820 -2550 0 0 {name=X_48740_ }
C {devices/lab_pin.sym} 11780 -2410 0 0 {name=p11838 lab=_79559_/Y }
C {devices/lab_pin.sym} 11860 -2410 0 1 {name=p11839 lab=_79560_/Y }
C {sky130_stdcells/inv_2.sym} 11820 -2410 0 0 {name=X_79560_ }
C {devices/lab_pin.sym} 11740 -2310 0 0 {name=p11840 lab=_57875_/X }
C {devices/lab_pin.sym} 11740 -2270 0 0 {name=p11841 lab=_85394_/Q }
C {devices/lab_pin.sym} 11740 -2230 0 0 {name=p11842 lab=_57937_/X }
C {devices/lab_pin.sym} 11900 -2270 0 1 {name=p11843 lab=_57938_/Y }
C {sky130_stdcells/o21ai_4.sym} 11820 -2270 0 0 {name=X_57938_ }
C {devices/lab_pin.sym} 11780 -2130 0 0 {name=p11844 lab=_45951_/Y }
C {devices/lab_pin.sym} 11860 -2130 0 1 {name=p11845 lab=_45952_/X }
C {sky130_stdcells/buf_2.sym} 11820 -2130 0 0 {name=X_45952_ }
C {devices/lab_pin.sym} 11740 -2030 0 0 {name=p11846 lab=_41073_/X }
C {devices/lab_pin.sym} 11740 -1990 0 0 {name=p11847 lab=_81704_/Q }
C {devices/lab_pin.sym} 11740 -1950 0 0 {name=p11848 lab=_41074_/X }
C {devices/lab_pin.sym} 11900 -1990 0 1 {name=p11849 lab=_41076_/A }
C {sky130_stdcells/o21a_4.sym} 11820 -1990 0 0 {name=X_41075_ }
C {devices/lab_pin.sym} 11780 -1850 0 0 {name=p11850 lab=_81488_/Q }
C {devices/lab_pin.sym} 11860 -1850 0 1 {name=p11851 lab=_76772_/Y }
C {sky130_stdcells/inv_2.sym} 11820 -1850 0 0 {name=X_76772_ }
C {devices/lab_pin.sym} 11740 -1750 0 0 {name=p11852 lab=_70117_/D }
C {devices/lab_pin.sym} 11740 -1710 0 0 {name=p11853 lab=_73939_/X }
C {devices/lab_pin.sym} 11740 -1670 0 0 {name=p11854 lab=_73983_/X }
C {devices/lab_pin.sym} 11900 -1710 0 1 {name=p11855 lab=_83128_/D }
C {sky130_stdcells/o21ai_4.sym} 11820 -1710 0 0 {name=X_73984_ }
C {devices/lab_pin.sym} 11760 -1580 0 0 {name=p11856 lab=_78511_/A }
C {devices/lab_pin.sym} 11760 -1540 0 0 {name=p11857 lab=_78510_/Y }
C {devices/lab_pin.sym} 11880 -1560 0 1 {name=p11858 lab=_78511_/X }
C {sky130_stdcells/and2_4.sym} 11820 -1560 0 0 {name=X_78511_ }
C {devices/lab_pin.sym} 11780 -1430 0 0 {name=p11859 lab=_62195_/A }
C {devices/lab_pin.sym} 11860 -1430 0 1 {name=p11860 lab=_61298_/B }
C {sky130_stdcells/buf_2.sym} 11820 -1430 0 0 {name=X_44903_ }
C {devices/lab_pin.sym} 11730 -1310 0 0 {name=p11861 lab=_87708_/CLK }
C {devices/lab_pin.sym} 11730 -1290 0 0 {name=p11862 lab=_87709_/D }
C {devices/lab_pin.sym} 11910 -1310 0 1 {name=p11863 lab=_87709_/Q }
C {sky130_stdcells/dfxtp_4.sym} 11820 -1300 0 0 {name=X_87709_ }
C {devices/lab_pin.sym} 11760 -1180 0 0 {name=p11864 lab=_75723_/A }
C {devices/lab_pin.sym} 11760 -1140 0 0 {name=p11865 lab=_75723_/B }
C {devices/lab_pin.sym} 11880 -1160 0 1 {name=p11866 lab=_75724_/B }
C {sky130_stdcells/xor2_4.sym} 11820 -1160 0 0 {name=X_75723_ }
C {devices/lab_pin.sym} 11780 -1030 0 0 {name=p11867 lab=_48671_/A }
C {devices/lab_pin.sym} 11860 -1030 0 1 {name=p11868 lab=_48672_/A }
C {sky130_stdcells/inv_2.sym} 11820 -1030 0 0 {name=X_48671_ }
C {devices/lab_pin.sym} 11760 -920 0 0 {name=p11869 lab=_72816_/X }
C {devices/lab_pin.sym} 11760 -880 0 0 {name=p11870 lab=_65525_/B }
C {devices/lab_pin.sym} 11880 -900 0 1 {name=p11871 lab=_72935_/X }
C {sky130_stdcells/and2_4.sym} 11820 -900 0 0 {name=X_72935_ }
C {devices/lab_pin.sym} 11740 -790 0 0 {name=p11872 lab=_79475_/X }
C {devices/lab_pin.sym} 11740 -750 0 0 {name=p11873 lab=_79476_/X }
C {devices/lab_pin.sym} 11740 -710 0 0 {name=p11874 lab=_79490_/Y }
C {devices/lab_pin.sym} 11900 -750 0 1 {name=p11875 lab=_79491_/Y }
C {sky130_stdcells/a21boi_4.sym} 11820 -750 0 0 {name=X_79491_ }
C {devices/lab_pin.sym} 12680 -42160 0 0 {name=p11876 lab=_45889_/A }
C {devices/lab_pin.sym} 12680 -42120 0 0 {name=p11877 lab=_45883_/B }
C {devices/lab_pin.sym} 12800 -42140 0 1 {name=p11878 lab=_45884_/A }
C {sky130_stdcells/nor2_4.sym} 12740 -42140 0 0 {name=X_45883_ }
C {devices/lab_pin.sym} 12700 -42010 0 0 {name=p11879 lab=_58080_/A }
C {devices/lab_pin.sym} 12780 -42010 0 1 {name=p11880 lab=_57971_/A }
C {sky130_stdcells/buf_2.sym} 12740 -42010 0 0 {name=X_57869_ }
C {devices/lab_pin.sym} 12700 -41890 0 0 {name=p11881 lab=_47622_/A }
C {devices/lab_pin.sym} 12780 -41890 0 1 {name=p11882 lab=_47623_/A }
C {sky130_stdcells/inv_2.sym} 12740 -41890 0 0 {name=X_47622_ }
C {devices/lab_pin.sym} 12700 -41770 0 0 {name=p11883 lab=_59608_/A }
C {devices/lab_pin.sym} 12780 -41770 0 1 {name=p11884 lab=_59689_/B }
C {sky130_stdcells/buf_2.sym} 12740 -41770 0 0 {name=X_59608_ }
C {devices/lab_pin.sym} 12660 -41670 0 0 {name=p11885 lab=_78429_/Y }
C {devices/lab_pin.sym} 12660 -41630 0 0 {name=p11886 lab=_78422_/X }
C {devices/lab_pin.sym} 12660 -41590 0 0 {name=p11887 lab=_78423_/Y }
C {devices/lab_pin.sym} 12820 -41630 0 1 {name=p11888 lab=_78443_/B }
C {sky130_stdcells/a21boi_4.sym} 12740 -41630 0 0 {name=X_78442_ }
C {devices/lab_pin.sym} 12660 -41530 0 0 {name=p11889 lab=_44832_/X }
C {devices/lab_pin.sym} 12660 -41490 0 0 {name=p11890 lab=_44821_/X }
C {devices/lab_pin.sym} 12660 -41450 0 0 {name=p11891 lab=_41704_/X }
C {devices/lab_pin.sym} 12660 -41410 0 0 {name=p11892 lab=_67679_/B }
C {devices/lab_pin.sym} 12660 -41370 0 0 {name=p11893 lab=_44833_/X }
C {devices/lab_pin.sym} 12820 -41450 0 1 {name=p11894 lab=_44835_/A }
C {sky130_stdcells/o32ai_4.sym} 12740 -41450 0 0 {name=X_44834_ }
C {devices/lab_pin.sym} 12680 -41300 0 0 {name=p11895 lab=_75659_/B }
C {devices/lab_pin.sym} 12680 -41260 0 0 {name=p11896 lab=_75653_/Y }
C {devices/lab_pin.sym} 12800 -41280 0 1 {name=p11897 lab=_75655_/B }
C {sky130_stdcells/xnor2_4.sym} 12740 -41280 0 0 {name=X_75654_ }
C {devices/lab_pin.sym} 12700 -41150 0 0 {name=p11898 lab=_60879_/Y }
C {devices/lab_pin.sym} 12780 -41150 0 1 {name=p11899 lab=_60880_/X }
C {sky130_stdcells/buf_2.sym} 12740 -41150 0 0 {name=X_60880_ }
C {devices/lab_pin.sym} 12700 -41030 0 0 {name=p11900 lab=_72739_/X }
C {devices/lab_pin.sym} 12780 -41030 0 1 {name=p11901 lab=_72866_/X }
C {sky130_stdcells/buf_2.sym} 12740 -41030 0 0 {name=X_72866_ }
C {devices/lab_pin.sym} 12700 -40910 0 0 {name=p11902 lab=_46155_/A }
C {devices/lab_pin.sym} 12780 -40910 0 1 {name=p11903 lab=_74605_/X }
C {sky130_stdcells/buf_2.sym} 12740 -40910 0 0 {name=X_74605_ }
C {devices/lab_pin.sym} 12680 -40800 0 0 {name=p11904 lab=_47553_/A }
C {devices/lab_pin.sym} 12680 -40760 0 0 {name=p11905 lab=_53115_/B }
C {devices/lab_pin.sym} 12800 -40780 0 1 {name=p11906 lab=_47553_/Y }
C {sky130_stdcells/nand2_4.sym} 12740 -40780 0 0 {name=X_47553_ }
C {devices/lab_pin.sym} 12680 -40670 0 0 {name=p11907 lab=_71813_/A }
C {devices/lab_pin.sym} 12680 -40630 0 0 {name=p11908 lab=_71435_/C }
C {devices/lab_pin.sym} 12680 -40590 0 0 {name=p11909 lab=_71049_/A }
C {devices/lab_pin.sym} 12800 -40630 0 1 {name=p11910 lab=_71817_/X }
C {sky130_stdcells/and3_4.sym} 12740 -40630 0 0 {name=X_71817_ }
C {devices/lab_pin.sym} 12680 -40500 0 0 {name=p11911 lab=_59539_/A }
C {devices/lab_pin.sym} 12680 -40460 0 0 {name=p11912 lab=_61078_/B }
C {devices/lab_pin.sym} 12800 -40480 0 1 {name=p11913 lab=_60593_/A }
C {sky130_stdcells/nor2_4.sym} 12740 -40480 0 0 {name=X_59539_ }
C {devices/lab_pin.sym} 12680 -40360 0 0 {name=p11914 lab=_78373_/A }
C {devices/lab_pin.sym} 12680 -40320 0 0 {name=p11915 lab=_82663_/D }
C {devices/lab_pin.sym} 12800 -40340 0 1 {name=p11916 lab=_78375_/C }
C {sky130_stdcells/nand2_4.sym} 12740 -40340 0 0 {name=X_78373_ }
C {devices/lab_pin.sym} 12700 -40210 0 0 {name=p11917 lab=_44765_/A }
C {devices/lab_pin.sym} 12780 -40210 0 1 {name=p11918 lab=_86966_/D }
C {sky130_stdcells/inv_2.sym} 12740 -40210 0 0 {name=X_44765_ }
C {devices/lab_pin.sym} 12680 -40100 0 0 {name=p11919 lab=_75583_/Y }
C {devices/lab_pin.sym} 12680 -40060 0 0 {name=p11920 lab=_75584_/Y }
C {devices/lab_pin.sym} 12800 -40080 0 1 {name=p11921 lab=_75585_/Y }
C {sky130_stdcells/nand2_4.sym} 12740 -40080 0 0 {name=X_75585_ }
C {devices/lab_pin.sym} 12660 -39990 0 0 {name=p11922 lab=_41965_/X }
C {devices/lab_pin.sym} 12660 -39950 0 0 {name=p11923 lab=_41975_/X }
C {devices/lab_pin.sym} 12660 -39910 0 0 {name=p11924 lab=_40753_/X }
C {devices/lab_pin.sym} 12660 -39870 0 0 {name=p11925 lab=_41976_/Y }
C {devices/lab_pin.sym} 12660 -39830 0 0 {name=p11926 lab=_41967_/X }
C {devices/lab_pin.sym} 12820 -39910 0 1 {name=p11927 lab=_88085_/D }
C {sky130_stdcells/o32ai_4.sym} 12740 -39910 0 0 {name=X_41977_ }
C {devices/lab_pin.sym} 12660 -39780 0 0 {name=p11928 lab=_41986_/Y }
C {devices/lab_pin.sym} 12660 -39740 0 0 {name=p11929 lab=_72723_/X }
C {devices/lab_pin.sym} 12660 -39700 0 0 {name=p11930 lab=_72725_/X }
C {devices/lab_pin.sym} 12660 -39660 0 0 {name=p11931 lab=_72796_/Y }
C {devices/lab_pin.sym} 12820 -39720 0 1 {name=p11932 lab=_72797_/X }
C {sky130_stdcells/a211o_4.sym} 12740 -39720 0 0 {name=X_72797_ }
C {devices/lab_pin.sym} 12700 -39570 0 0 {name=p11933 lab=clkbuf_9_295_0_CLK/X }
C {devices/lab_pin.sym} 12780 -39570 0 1 {name=p11934 lab=_80821_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 12740 -39570 0 0 {name=Xclkbuf_10_591_0_CLK }
C {devices/lab_pin.sym} 12700 -39450 0 0 {name=p11935 lab=_46504_/A }
C {devices/lab_pin.sym} 12780 -39450 0 1 {name=p11936 lab=_49110_/A }
C {sky130_stdcells/inv_2.sym} 12740 -39450 0 0 {name=X_46504_ }
C {devices/lab_pin.sym} 12680 -39340 0 0 {name=p11937 lab=_77324_/A }
C {devices/lab_pin.sym} 12680 -39300 0 0 {name=p11938 lab=_82089_/D }
C {devices/lab_pin.sym} 12800 -39320 0 1 {name=p11939 lab=_77325_/A }
C {sky130_stdcells/nand2_4.sym} 12740 -39320 0 0 {name=X_77324_ }
C {devices/lab_pin.sym} 12700 -39190 0 0 {name=p11940 lab=_47834_/A }
C {devices/lab_pin.sym} 12780 -39190 0 1 {name=p11941 lab=_43716_/X }
C {sky130_stdcells/buf_2.sym} 12740 -39190 0 0 {name=X_43716_ }
C {devices/lab_pin.sym} 12660 -39110 0 0 {name=p11942 lab=_62543_/X }
C {devices/lab_pin.sym} 12660 -39070 0 0 {name=p11943 lab=_62545_/X }
C {devices/lab_pin.sym} 12660 -39030 0 0 {name=p11944 lab=_62549_/Y }
C {devices/lab_pin.sym} 12660 -38990 0 0 {name=p11945 lab=_58465_/A }
C {devices/lab_pin.sym} 12660 -38950 0 0 {name=p11946 lab=_62511_/X }
C {devices/lab_pin.sym} 12820 -39030 0 1 {name=p11947 lab=_62550_/Y }
C {sky130_stdcells/o32ai_4.sym} 12740 -39030 0 0 {name=X_62550_ }
C {devices/lab_pin.sym} 12700 -38870 0 0 {name=p11948 lab=_74614_/A }
C {devices/lab_pin.sym} 12780 -38870 0 1 {name=p11949 lab=_74600_/A }
C {sky130_stdcells/buf_2.sym} 12740 -38870 0 0 {name=X_74536_ }
C {devices/lab_pin.sym} 12660 -38770 0 0 {name=p11950 lab=_40817_/X }
C {devices/lab_pin.sym} 12660 -38730 0 0 {name=p11951 lab=_82274_/Q }
C {devices/lab_pin.sym} 12660 -38690 0 0 {name=p11952 lab=_40927_/X }
C {devices/lab_pin.sym} 12820 -38730 0 1 {name=p11953 lab=_40929_/A }
C {sky130_stdcells/o21ai_4.sym} 12740 -38730 0 0 {name=X_40928_ }
C {devices/lab_pin.sym} 12700 -38590 0 0 {name=p11954 lab=_47530_/A }
C {devices/lab_pin.sym} 12780 -38590 0 1 {name=p11955 lab=_47513_/A }
C {sky130_stdcells/buf_2.sym} 12740 -38590 0 0 {name=X_47484_ }
C {devices/lab_pin.sym} 12660 -38490 0 0 {name=p11956 lab=_52936_/B }
C {devices/lab_pin.sym} 12660 -38450 0 0 {name=p11957 lab=_71737_/X }
C {devices/lab_pin.sym} 12660 -38410 0 0 {name=p11958 lab=_71747_/Y }
C {devices/lab_pin.sym} 12820 -38450 0 1 {name=p11959 lab=_83391_/D }
C {sky130_stdcells/o21ai_4.sym} 12740 -38450 0 0 {name=X_71748_ }
C {devices/lab_pin.sym} 12660 -38350 0 0 {name=p11960 lab=_44686_/X }
C {devices/lab_pin.sym} 12660 -38310 0 0 {name=p11961 lab=_44687_/X }
C {devices/lab_pin.sym} 12660 -38270 0 0 {name=p11962 lab=_40645_/Y }
C {devices/lab_pin.sym} 12660 -38230 0 0 {name=p11963 lab=_44695_/Y }
C {devices/lab_pin.sym} 12660 -38190 0 0 {name=p11964 lab=_44689_/X }
C {devices/lab_pin.sym} 12820 -38270 0 1 {name=p11965 lab=_44696_/Y }
C {sky130_stdcells/o32ai_4.sym} 12740 -38270 0 0 {name=X_44696_ }
C {devices/lab_pin.sym} 12700 -38110 0 0 {name=p11966 lab=_49223_/A }
C {devices/lab_pin.sym} 12780 -38110 0 1 {name=p11967 lab=_49241_/A }
C {sky130_stdcells/buf_2.sym} 12740 -38110 0 0 {name=X_49223_ }
C {devices/lab_pin.sym} 12680 -38010 0 0 {name=p11968 lab=_61482_/A }
C {devices/lab_pin.sym} 12680 -37970 0 0 {name=p11969 lab=_61500_/X }
C {devices/lab_pin.sym} 12680 -37930 0 0 {name=p11970 lab=_61482_/C }
C {devices/lab_pin.sym} 12800 -37970 0 1 {name=p11971 lab=_61501_/Y }
C {sky130_stdcells/nand3_4.sym} 12740 -37970 0 0 {name=X_61501_ }
C {devices/lab_pin.sym} 12660 -37850 0 0 {name=p11972 lab=_86737_/Q }
C {devices/lab_pin.sym} 12660 -37810 0 0 {name=p11973 lab=_46430_/X }
C {devices/lab_pin.sym} 12660 -37770 0 0 {name=p11974 lab=_46434_/Y }
C {devices/lab_pin.sym} 12820 -37810 0 1 {name=p11975 lab=_46435_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -37810 0 0 {name=X_46435_ }
C {devices/lab_pin.sym} 12660 -37690 0 0 {name=p11976 lab=_77250_/A }
C {devices/lab_pin.sym} 12660 -37650 0 0 {name=p11977 lab=_77253_/Y }
C {devices/lab_pin.sym} 12660 -37610 0 0 {name=p11978 lab=_77254_/Y }
C {devices/lab_pin.sym} 12820 -37650 0 1 {name=p11979 lab=_77255_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -37650 0 0 {name=X_77255_ }
C {devices/lab_pin.sym} 12660 -37550 0 0 {name=p11980 lab=_62470_/X }
C {devices/lab_pin.sym} 12660 -37510 0 0 {name=p11981 lab=_62477_/Y }
C {devices/lab_pin.sym} 12660 -37470 0 0 {name=p11982 lab=_62480_/X }
C {devices/lab_pin.sym} 12660 -37430 0 0 {name=p11983 lab=_84847_/Q }
C {devices/lab_pin.sym} 12660 -37390 0 0 {name=p11984 lab=_62440_/X }
C {devices/lab_pin.sym} 12820 -37470 0 1 {name=p11985 lab=_62481_/Y }
C {sky130_stdcells/o32ai_4.sym} 12740 -37470 0 0 {name=X_62481_ }
C {devices/lab_pin.sym} 12660 -37340 0 0 {name=p11986 lab=_40696_/X }
C {devices/lab_pin.sym} 12660 -37300 0 0 {name=p11987 lab=_43624_/X }
C {devices/lab_pin.sym} 12660 -37260 0 0 {name=p11988 lab=_87328_/Q }
C {devices/lab_pin.sym} 12660 -37220 0 0 {name=p11989 lab=_43625_/X }
C {devices/lab_pin.sym} 12820 -37280 0 1 {name=p11990 lab=_87328_/D }
C {sky130_stdcells/a2bb2o_4.sym} 12740 -37280 0 0 {name=X_43647_ }
C {devices/lab_pin.sym} 12660 -37150 0 0 {name=p11991 lab=_83060_/Q }
C {devices/lab_pin.sym} 12660 -37110 0 0 {name=p11992 lab=_74387_/X }
C {devices/lab_pin.sym} 12660 -37070 0 0 {name=p11993 lab=_74466_/Y }
C {devices/lab_pin.sym} 12820 -37110 0 1 {name=p11994 lab=_74467_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -37110 0 0 {name=X_74467_ }
C {devices/lab_pin.sym} 12680 -36980 0 0 {name=p11995 lab=_82863_/Q }
C {devices/lab_pin.sym} 12680 -36940 0 0 {name=p11996 lab=_40883_/B }
C {devices/lab_pin.sym} 12800 -36960 0 1 {name=p11997 lab=_40859_/X }
C {sky130_stdcells/or2_4.sym} 12740 -36960 0 0 {name=X_40859_ }
C {devices/lab_pin.sym} 12660 -36850 0 0 {name=p11998 lab=_58480_/Y }
C {devices/lab_pin.sym} 12660 -36810 0 0 {name=p11999 lab=_71669_/X }
C {devices/lab_pin.sym} 12660 -36770 0 0 {name=p12000 lab=_71678_/Y }
C {devices/lab_pin.sym} 12820 -36810 0 1 {name=p12001 lab=_83414_/D }
C {sky130_stdcells/o21ai_4.sym} 12740 -36810 0 0 {name=X_71679_ }
C {devices/lab_pin.sym} 12700 -36670 0 0 {name=p12002 lab=_64243_/A }
C {devices/lab_pin.sym} 12780 -36670 0 1 {name=p12003 lab=_64234_/A }
C {sky130_stdcells/buf_2.sym} 12740 -36670 0 0 {name=X_64220_ }
C {devices/lab_pin.sym} 12660 -36570 0 0 {name=p12004 lab=_76202_/X }
C {devices/lab_pin.sym} 12660 -36530 0 0 {name=p12005 lab=_76219_/A }
C {devices/lab_pin.sym} 12660 -36490 0 0 {name=p12006 lab=_76205_/Y }
C {devices/lab_pin.sym} 12820 -36530 0 1 {name=p12007 lab=_76206_/Y }
C {sky130_stdcells/a21oi_4.sym} 12740 -36530 0 0 {name=X_76206_ }
C {devices/lab_pin.sym} 12700 -36390 0 0 {name=p12008 lab=_48162_/A }
C {devices/lab_pin.sym} 12780 -36390 0 1 {name=p12009 lab=_49416_/A }
C {sky130_stdcells/buf_2.sym} 12740 -36390 0 0 {name=X_49154_ }
C {devices/lab_pin.sym} 12660 -36300 0 0 {name=p12010 lab=_43192_/Y }
C {devices/lab_pin.sym} 12660 -36260 0 0 {name=p12011 lab=_73298_/X }
C {devices/lab_pin.sym} 12660 -36220 0 0 {name=p12012 lab=_73251_/X }
C {devices/lab_pin.sym} 12660 -36180 0 0 {name=p12013 lab=_73417_/Y }
C {devices/lab_pin.sym} 12820 -36240 0 1 {name=p12014 lab=_73418_/X }
C {sky130_stdcells/a211o_4.sym} 12740 -36240 0 0 {name=X_73418_ }
C {devices/lab_pin.sym} 12700 -36090 0 0 {name=p12015 lab=_61431_/Y }
C {devices/lab_pin.sym} 12780 -36090 0 1 {name=p12016 lab=_61432_/Y }
C {sky130_stdcells/inv_2.sym} 12740 -36090 0 0 {name=X_61432_ }
C {devices/lab_pin.sym} 12700 -35970 0 0 {name=p12017 lab=_46366_/A }
C {devices/lab_pin.sym} 12780 -35970 0 1 {name=p12018 lab=_46387_/A }
C {sky130_stdcells/buf_2.sym} 12740 -35970 0 0 {name=X_46366_ }
C {devices/lab_pin.sym} 12680 -35860 0 0 {name=p12019 lab=_82011_/Q }
C {devices/lab_pin.sym} 12680 -35820 0 0 {name=p12020 lab=_82299_/D }
C {devices/lab_pin.sym} 12800 -35840 0 1 {name=p12021 lab=_77186_/Y }
C {sky130_stdcells/nand2_4.sym} 12740 -35840 0 0 {name=X_77186_ }
C {devices/lab_pin.sym} 12660 -35740 0 0 {name=p12022 lab=_40538_/X }
C {devices/lab_pin.sym} 12660 -35700 0 0 {name=p12023 lab=_53455_/A }
C {devices/lab_pin.sym} 12660 -35660 0 0 {name=p12024 lab=_87350_/Q }
C {devices/lab_pin.sym} 12660 -35620 0 0 {name=p12025 lab=_43185_/A }
C {devices/lab_pin.sym} 12820 -35680 0 1 {name=p12026 lab=_43578_/X }
C {sky130_stdcells/a2bb2o_4.sym} 12740 -35680 0 0 {name=X_43578_ }
C {devices/lab_pin.sym} 12680 -35540 0 0 {name=p12027 lab=_74408_/A }
C {devices/lab_pin.sym} 12680 -35500 0 0 {name=p12028 lab=_53651_/B }
C {devices/lab_pin.sym} 12800 -35520 0 1 {name=p12029 lab=_74398_/Y }
C {sky130_stdcells/nand2_4.sym} 12740 -35520 0 0 {name=X_74398_ }
C {devices/lab_pin.sym} 12700 -35390 0 0 {name=p12030 lab=_48105_/A }
C {devices/lab_pin.sym} 12780 -35390 0 1 {name=p12031 lab=_53588_/B }
C {sky130_stdcells/inv_2.sym} 12740 -35390 0 0 {name=X_48105_ }
C {devices/lab_pin.sym} 12660 -35290 0 0 {name=p12032 lab=_55707_/B }
C {devices/lab_pin.sym} 12660 -35250 0 0 {name=p12033 lab=_45269_/X }
C {devices/lab_pin.sym} 12660 -35210 0 0 {name=p12034 lab=_45303_/X }
C {devices/lab_pin.sym} 12820 -35250 0 1 {name=p12035 lab=_45317_/X }
C {sky130_stdcells/o21a_4.sym} 12740 -35250 0 0 {name=X_45317_ }
C {devices/lab_pin.sym} 12680 -35130 0 0 {name=p12036 lab=_64162_/A }
C {devices/lab_pin.sym} 12680 -35090 0 0 {name=p12037 lab=_61656_/A }
C {devices/lab_pin.sym} 12680 -35050 0 0 {name=p12038 lab=_64173_/C }
C {devices/lab_pin.sym} 12800 -35090 0 1 {name=p12039 lab=_64151_/X }
C {sky130_stdcells/and3_4.sym} 12740 -35090 0 0 {name=X_64151_ }
C {devices/lab_pin.sym} 12680 -34960 0 0 {name=p12040 lab=_81728_/D }
C {devices/lab_pin.sym} 12680 -34920 0 0 {name=p12041 lab=_76144_/B }
C {devices/lab_pin.sym} 12800 -34940 0 1 {name=p12042 lab=_76143_/B }
C {sky130_stdcells/xor2_4.sym} 12740 -34940 0 0 {name=X_76137_ }
C {devices/lab_pin.sym} 12660 -34850 0 0 {name=p12043 lab=_42517_/X }
C {devices/lab_pin.sym} 12660 -34810 0 0 {name=p12044 lab=_42527_/X }
C {devices/lab_pin.sym} 12660 -34770 0 0 {name=p12045 lab=_40734_/X }
C {devices/lab_pin.sym} 12660 -34730 0 0 {name=p12046 lab=_42528_/Y }
C {devices/lab_pin.sym} 12660 -34690 0 0 {name=p12047 lab=_42519_/X }
C {devices/lab_pin.sym} 12820 -34770 0 1 {name=p12048 lab=_87833_/D }
C {sky130_stdcells/o32ai_4.sym} 12740 -34770 0 0 {name=X_42529_ }
C {devices/lab_pin.sym} 12660 -34630 0 0 {name=p12049 lab=_86445_/Q }
C {devices/lab_pin.sym} 12660 -34590 0 0 {name=p12050 lab=_49052_/X }
C {devices/lab_pin.sym} 12660 -34550 0 0 {name=p12051 lab=_49084_/Y }
C {devices/lab_pin.sym} 12820 -34590 0 1 {name=p12052 lab=_49085_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -34590 0 0 {name=X_49085_ }
C {devices/lab_pin.sym} 12660 -34470 0 0 {name=p12053 lab=_61361_/X }
C {devices/lab_pin.sym} 12660 -34430 0 0 {name=p12054 lab=_61349_/X }
C {devices/lab_pin.sym} 12660 -34390 0 0 {name=p12055 lab=_61362_/Y }
C {devices/lab_pin.sym} 12820 -34430 0 1 {name=p12056 lab=_61363_/Y }
C {sky130_stdcells/a21oi_4.sym} 12740 -34430 0 0 {name=X_61363_ }
C {devices/lab_pin.sym} 12660 -34310 0 0 {name=p12057 lab=_88316_/Q }
C {devices/lab_pin.sym} 12660 -34270 0 0 {name=p12058 lab=_73059_/X }
C {devices/lab_pin.sym} 12660 -34230 0 0 {name=p12059 lab=_73007_/X }
C {devices/lab_pin.sym} 12820 -34270 0 1 {name=p12060 lab=_73349_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -34270 0 0 {name=X_73349_ }
C {devices/lab_pin.sym} 12660 -34150 0 0 {name=p12061 lab=_86749_/Q }
C {devices/lab_pin.sym} 12660 -34110 0 0 {name=p12062 lab=_46292_/X }
C {devices/lab_pin.sym} 12660 -34070 0 0 {name=p12063 lab=_46296_/Y }
C {devices/lab_pin.sym} 12820 -34110 0 1 {name=p12064 lab=_46297_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -34110 0 0 {name=X_46297_ }
C {devices/lab_pin.sym} 12700 -33970 0 0 {name=p12065 lab=_60489_/X }
C {devices/lab_pin.sym} 12780 -33970 0 1 {name=p12066 lab=_63103_/C }
C {sky130_stdcells/buf_2.sym} 12740 -33970 0 0 {name=X_63102_ }
C {devices/lab_pin.sym} 12700 -33850 0 0 {name=p12067 lab=_48036_/A }
C {devices/lab_pin.sym} 12780 -33850 0 1 {name=p12068 lab=_48287_/A }
C {sky130_stdcells/buf_2.sym} 12740 -33850 0 0 {name=X_48036_ }
C {devices/lab_pin.sym} 12680 -33750 0 0 {name=p12069 lab=_59772_/A }
C {devices/lab_pin.sym} 12680 -33710 0 0 {name=p12070 lab=_59837_/B }
C {devices/lab_pin.sym} 12680 -33670 0 0 {name=p12071 lab=_79742_/A }
C {devices/lab_pin.sym} 12800 -33710 0 1 {name=p12072 lab=_60314_/Y }
C {sky130_stdcells/nor3_4.sym} 12740 -33710 0 0 {name=X_60314_ }
C {devices/lab_pin.sym} 12660 -33590 0 0 {name=p12073 lab=_45202_/X }
C {devices/lab_pin.sym} 12660 -33550 0 0 {name=p12074 lab=_61590_/B }
C {devices/lab_pin.sym} 12660 -33510 0 0 {name=p12075 lab=_45219_/X }
C {devices/lab_pin.sym} 12820 -33550 0 1 {name=p12076 lab=_45248_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -33550 0 0 {name=X_45248_ }
C {devices/lab_pin.sym} 12680 -33420 0 0 {name=p12077 lab=_76068_/A }
C {devices/lab_pin.sym} 12680 -33380 0 0 {name=p12078 lab=_76067_/Y }
C {devices/lab_pin.sym} 12800 -33400 0 1 {name=p12079 lab=_76069_/B }
C {sky130_stdcells/xor2_4.sym} 12740 -33400 0 0 {name=X_76068_ }
C {devices/lab_pin.sym} 12660 -33290 0 0 {name=p12080 lab=_62517_/Y }
C {devices/lab_pin.sym} 12660 -33250 0 0 {name=p12081 lab=_61030_/A }
C {devices/lab_pin.sym} 12660 -33210 0 0 {name=p12082 lab=_64081_/Y }
C {devices/lab_pin.sym} 12820 -33250 0 1 {name=p12083 lab=_64082_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -33250 0 0 {name=X_64082_ }
C {devices/lab_pin.sym} 12680 -33140 0 0 {name=p12084 lab=_60353_/B }
C {devices/lab_pin.sym} 12680 -33100 0 0 {name=p12085 lab=_61287_/D }
C {devices/lab_pin.sym} 12680 -33060 0 0 {name=p12086 lab=_60403_/B }
C {devices/lab_pin.sym} 12680 -33020 0 0 {name=p12087 lab=_61294_/D }
C {devices/lab_pin.sym} 12800 -33080 0 1 {name=p12088 lab=_72540_/B }
C {sky130_stdcells/nand4_4.sym} 12740 -33080 0 0 {name=X_61294_ }
C {devices/lab_pin.sym} 12700 -32930 0 0 {name=p12089 lab=clkbuf_6_21_0_CLK/A }
C {devices/lab_pin.sym} 12780 -32930 0 1 {name=p12090 lab=clkbuf_7_41_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 12740 -32930 0 0 {name=Xclkbuf_6_20_0_CLK }
C {devices/lab_pin.sym} 12660 -32840 0 0 {name=p12091 lab=_86951_/Q }
C {devices/lab_pin.sym} 12660 -32800 0 0 {name=p12092 lab=_67906_/X }
C {devices/lab_pin.sym} 12660 -32760 0 0 {name=p12093 lab=_67908_/X }
C {devices/lab_pin.sym} 12660 -32720 0 0 {name=p12094 lab=_67909_/X }
C {devices/lab_pin.sym} 12820 -32780 0 1 {name=p12095 lab=_67911_/B }
C {sky130_stdcells/a211o_4.sym} 12740 -32780 0 0 {name=X_67910_ }
C {devices/lab_pin.sym} 12680 -32650 0 0 {name=p12096 lab=_74999_/X }
C {devices/lab_pin.sym} 12680 -32610 0 0 {name=p12097 lab=_75008_/X }
C {devices/lab_pin.sym} 12680 -32570 0 0 {name=p12098 lab=_75021_/B }
C {devices/lab_pin.sym} 12800 -32610 0 1 {name=p12099 lab=_75019_/X }
C {sky130_stdcells/and3_4.sym} 12740 -32610 0 0 {name=X_75019_ }
C {devices/lab_pin.sym} 12680 -32500 0 0 {name=p12100 lab=_63033_/A }
C {devices/lab_pin.sym} 12680 -32460 0 0 {name=p12101 lab=_63004_/B }
C {devices/lab_pin.sym} 12680 -32420 0 0 {name=p12102 lab=_63004_/C }
C {devices/lab_pin.sym} 12680 -32380 0 0 {name=p12103 lab=_63033_/D }
C {devices/lab_pin.sym} 12800 -32440 0 1 {name=p12104 lab=_63033_/X }
C {sky130_stdcells/or4_4.sym} 12740 -32440 0 0 {name=X_63033_ }
C {devices/lab_pin.sym} 12660 -32330 0 0 {name=p12105 lab=_60232_/Y }
C {devices/lab_pin.sym} 12660 -32290 0 0 {name=p12106 lab=_60238_/Y }
C {devices/lab_pin.sym} 12660 -32250 0 0 {name=p12107 lab=_59756_/X }
C {devices/lab_pin.sym} 12660 -32210 0 0 {name=p12108 lab=_60367_/B }
C {devices/lab_pin.sym} 12660 -32180 0 0 {name=p12109 lab=_60244_/Y }
C {devices/lab_pin.sym} 12820 -32250 0 1 {name=p12110 lab=_60245_/Y }
C {sky130_stdcells/a41oi_4.sym} 12740 -32250 0 0 {name=X_60245_ }
C {devices/lab_pin.sym} 12660 -32110 0 0 {name=p12111 lab=_45175_/Y }
C {devices/lab_pin.sym} 12660 -32070 0 0 {name=p12112 lab=_45178_/Y }
C {devices/lab_pin.sym} 12660 -32030 0 0 {name=p12113 lab=_45137_/X }
C {devices/lab_pin.sym} 12820 -32070 0 1 {name=p12114 lab=_45179_/X }
C {sky130_stdcells/a21o_4.sym} 12740 -32070 0 0 {name=X_45179_ }
C {devices/lab_pin.sym} 12660 -31950 0 0 {name=p12115 lab=_68887_/X }
C {devices/lab_pin.sym} 12660 -31910 0 0 {name=p12116 lab=_68889_/X }
C {devices/lab_pin.sym} 12660 -31870 0 0 {name=p12117 lab=_68748_/X }
C {devices/lab_pin.sym} 12820 -31910 0 1 {name=p12118 lab=_68890_/X }
C {sky130_stdcells/a21o_4.sym} 12740 -31910 0 0 {name=X_68890_ }
C {devices/lab_pin.sym} 12660 -31800 0 0 {name=p12119 lab=_87146_/Q }
C {devices/lab_pin.sym} 12660 -31760 0 0 {name=p12120 lab=_67788_/X }
C {devices/lab_pin.sym} 12660 -31720 0 0 {name=p12121 lab=_67789_/X }
C {devices/lab_pin.sym} 12660 -31680 0 0 {name=p12122 lab=_67840_/X }
C {devices/lab_pin.sym} 12820 -31740 0 1 {name=p12123 lab=_67842_/B }
C {sky130_stdcells/a211o_4.sym} 12740 -31740 0 0 {name=X_67841_ }
C {devices/lab_pin.sym} 12680 -31600 0 0 {name=p12124 lab=_79825_/X }
C {devices/lab_pin.sym} 12680 -31560 0 0 {name=p12125 lab=_79834_/B }
C {devices/lab_pin.sym} 12800 -31580 0 1 {name=p12126 lab=_79827_/Y }
C {sky130_stdcells/xnor2_4.sym} 12740 -31580 0 0 {name=X_79827_ }
C {devices/lab_pin.sym} 12700 -31450 0 0 {name=p12127 lab=_61286_/B }
C {devices/lab_pin.sym} 12780 -31450 0 1 {name=p12128 lab=_61316_/A }
C {sky130_stdcells/inv_2.sym} 12740 -31450 0 0 {name=X_60176_ }
C {devices/lab_pin.sym} 12700 -31330 0 0 {name=p12129 lab=_48171_/X }
C {devices/lab_pin.sym} 12780 -31330 0 1 {name=p12130 lab=_50001_/A }
C {sky130_stdcells/buf_2.sym} 12740 -31330 0 0 {name=X_49987_ }
C {devices/lab_pin.sym} 12700 -31210 0 0 {name=p12131 lab=_48938_/A }
C {devices/lab_pin.sym} 12780 -31210 0 1 {name=p12132 lab=_52291_/A }
C {sky130_stdcells/buf_2.sym} 12740 -31210 0 0 {name=X_48938_ }
C {devices/lab_pin.sym} 12680 -31100 0 0 {name=p12133 lab=_79740_/X }
C {devices/lab_pin.sym} 12680 -31060 0 0 {name=p12134 lab=_79743_/Y }
C {devices/lab_pin.sym} 12800 -31080 0 1 {name=p12135 lab=_79758_/X }
C {sky130_stdcells/or2_4.sym} 12740 -31080 0 0 {name=X_79758_ }
C {devices/lab_pin.sym} 12660 -30980 0 0 {name=p12136 lab=_87905_/Q }
C {devices/lab_pin.sym} 12660 -30940 0 0 {name=p12137 lab=_67770_/X }
C {devices/lab_pin.sym} 12660 -30900 0 0 {name=p12138 lab=_67748_/X }
C {devices/lab_pin.sym} 12660 -30860 0 0 {name=p12139 lab=_67771_/X }
C {devices/lab_pin.sym} 12820 -30920 0 1 {name=p12140 lab=_67772_/X }
C {sky130_stdcells/a211o_4.sym} 12740 -30920 0 0 {name=X_67772_ }
C {devices/lab_pin.sym} 12680 -30780 0 0 {name=p12141 lab=_64904_/A }
C {devices/lab_pin.sym} 12680 -30740 0 0 {name=p12142 lab=_85843_/Q }
C {devices/lab_pin.sym} 12800 -30760 0 1 {name=p12143 lab=_64984_/X }
C {sky130_stdcells/and2_4.sym} 12740 -30760 0 0 {name=X_64984_ }
C {devices/lab_pin.sym} 12700 -30630 0 0 {name=p12144 lab=clkbuf_9_272_0_CLK/X }
C {devices/lab_pin.sym} 12780 -30630 0 1 {name=p12145 lab=_81749_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 12740 -30630 0 0 {name=Xclkbuf_10_544_0_CLK }
C {devices/lab_pin.sym} 12700 -30510 0 0 {name=p12146 lab=clkbuf_6_35_0_CLK/A }
C {devices/lab_pin.sym} 12780 -30510 0 1 {name=p12147 lab=clkbuf_7_70_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 12740 -30510 0 0 {name=Xclkbuf_6_35_0_CLK }
C {devices/lab_pin.sym} 12660 -30410 0 0 {name=p12148 lab=_69508_/X }
C {devices/lab_pin.sym} 12660 -30370 0 0 {name=p12149 lab=_69510_/X }
C {devices/lab_pin.sym} 12660 -30330 0 0 {name=p12150 lab=_69399_/X }
C {devices/lab_pin.sym} 12820 -30370 0 1 {name=p12151 lab=_69511_/X }
C {sky130_stdcells/a21o_4.sym} 12740 -30370 0 0 {name=X_69511_ }
C {devices/lab_pin.sym} 12700 -30230 0 0 {name=p12152 lab=_68721_/A }
C {devices/lab_pin.sym} 12780 -30230 0 1 {name=p12153 lab=_66819_/A }
C {sky130_stdcells/buf_2.sym} 12740 -30230 0 0 {name=X_66723_ }
C {devices/lab_pin.sym} 12700 -30110 0 0 {name=p12154 lab=_82813_/Q }
C {devices/lab_pin.sym} 12780 -30110 0 1 {name=p12155 lab=_78709_/Y }
C {sky130_stdcells/inv_2.sym} 12740 -30110 0 0 {name=X_78709_ }
C {devices/lab_pin.sym} 12680 -30020 0 0 {name=p12156 lab=_58520_/A }
C {devices/lab_pin.sym} 12680 -29980 0 0 {name=p12157 lab=_63934_/X }
C {devices/lab_pin.sym} 12680 -29940 0 0 {name=p12158 lab=_63949_/C }
C {devices/lab_pin.sym} 12680 -29900 0 0 {name=p12159 lab=_63900_/D }
C {devices/lab_pin.sym} 12800 -29960 0 1 {name=p12160 lab=_63935_/Y }
C {sky130_stdcells/nand4_4.sym} 12740 -29960 0 0 {name=X_63935_ }
C {devices/lab_pin.sym} 12660 -29830 0 0 {name=p12161 lab=_86467_/Q }
C {devices/lab_pin.sym} 12660 -29790 0 0 {name=p12162 lab=_48861_/X }
C {devices/lab_pin.sym} 12660 -29750 0 0 {name=p12163 lab=_48868_/Y }
C {devices/lab_pin.sym} 12820 -29790 0 1 {name=p12164 lab=_48869_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -29790 0 0 {name=X_48869_ }
C {devices/lab_pin.sym} 12660 -29670 0 0 {name=p12165 lab=_79679_/X }
C {devices/lab_pin.sym} 12660 -29630 0 0 {name=p12166 lab=_79681_/B }
C {devices/lab_pin.sym} 12660 -29590 0 0 {name=p12167 lab=_79688_/Y }
C {devices/lab_pin.sym} 12820 -29630 0 1 {name=p12168 lab=_79689_/Y }
C {sky130_stdcells/a21boi_4.sym} 12740 -29630 0 0 {name=X_79689_ }
C {devices/lab_pin.sym} 12680 -29500 0 0 {name=p12169 lab=_50906_/A }
C {devices/lab_pin.sym} 12680 -29460 0 0 {name=p12170 lab=_51765_/B }
C {devices/lab_pin.sym} 12800 -29480 0 1 {name=p12171 lab=_50900_/Y }
C {sky130_stdcells/nand2_4.sym} 12740 -29480 0 0 {name=X_50900_ }
C {devices/lab_pin.sym} 12650 -29350 0 0 {name=p12172 lab=_81412_/CLK }
C {devices/lab_pin.sym} 12650 -29330 0 0 {name=p12173 lab=_81720_/D }
C {devices/lab_pin.sym} 12830 -29350 0 1 {name=p12174 lab=_81720_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -29340 0 0 {name=X_81720_ }
C {devices/lab_pin.sym} 12700 -29210 0 0 {name=p12175 lab=_69442_/A }
C {devices/lab_pin.sym} 12780 -29210 0 1 {name=p12176 lab=_69442_/X }
C {sky130_stdcells/buf_2.sym} 12740 -29210 0 0 {name=X_69442_ }
C {devices/lab_pin.sym} 12660 -29120 0 0 {name=p12177 lab=_87440_/Q }
C {devices/lab_pin.sym} 12660 -29080 0 0 {name=p12178 lab=_66571_/X }
C {devices/lab_pin.sym} 12660 -29040 0 0 {name=p12179 lab=_66629_/X }
C {devices/lab_pin.sym} 12660 -29000 0 0 {name=p12180 lab=_66653_/X }
C {devices/lab_pin.sym} 12820 -29060 0 1 {name=p12181 lab=_66654_/X }
C {sky130_stdcells/a211o_4.sym} 12740 -29060 0 0 {name=X_66654_ }
C {devices/lab_pin.sym} 12680 -28920 0 0 {name=p12182 lab=_51875_/A }
C {devices/lab_pin.sym} 12680 -28880 0 0 {name=p12183 lab=_51016_/B }
C {devices/lab_pin.sym} 12800 -28900 0 1 {name=p12184 lab=_51880_/Y }
C {sky130_stdcells/nand2_4.sym} 12740 -28900 0 0 {name=X_51880_ }
C {devices/lab_pin.sym} 12700 -28770 0 0 {name=p12185 lab=_64191_/D }
C {devices/lab_pin.sym} 12780 -28770 0 1 {name=p12186 lab=_63866_/X }
C {sky130_stdcells/buf_2.sym} 12740 -28770 0 0 {name=X_63866_ }
C {devices/lab_pin.sym} 12680 -28670 0 0 {name=p12187 lab=_65634_/A }
C {devices/lab_pin.sym} 12680 -28630 0 0 {name=p12188 lab=_65397_/B }
C {devices/lab_pin.sym} 12680 -28590 0 0 {name=p12189 lab=_65605_/C }
C {devices/lab_pin.sym} 12800 -28630 0 1 {name=p12190 lab=_65605_/Y }
C {sky130_stdcells/nor3_4.sym} 12740 -28630 0 0 {name=X_65605_ }
C {devices/lab_pin.sym} 12660 -28510 0 0 {name=p12191 lab=_50828_/Y }
C {devices/lab_pin.sym} 12660 -28470 0 0 {name=p12192 lab=_50801_/X }
C {devices/lab_pin.sym} 12660 -28430 0 0 {name=p12193 lab=_50830_/X }
C {devices/lab_pin.sym} 12820 -28470 0 1 {name=p12194 lab=_86125_/D }
C {sky130_stdcells/a21oi_4.sym} 12740 -28470 0 0 {name=X_50831_ }
C {devices/lab_pin.sym} 12660 -28350 0 0 {name=p12195 lab=_62815_/X }
C {devices/lab_pin.sym} 12660 -28310 0 0 {name=p12196 lab=_62779_/X }
C {devices/lab_pin.sym} 12660 -28270 0 0 {name=p12197 lab=_62816_/Y }
C {devices/lab_pin.sym} 12820 -28310 0 1 {name=p12198 lab=_62817_/Y }
C {sky130_stdcells/a21oi_4.sym} 12740 -28310 0 0 {name=X_62817_ }
C {devices/lab_pin.sym} 12650 -28170 0 0 {name=p12199 lab=_81330_/CLK }
C {devices/lab_pin.sym} 12650 -28150 0 0 {name=p12200 lab=_76656_/B }
C {devices/lab_pin.sym} 12830 -28170 0 1 {name=p12201 lab=_81651_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -28160 0 0 {name=X_81651_ }
C {devices/lab_pin.sym} 12660 -28060 0 0 {name=p12202 lab=_87522_/Q }
C {devices/lab_pin.sym} 12660 -28020 0 0 {name=p12203 lab=_69356_/X }
C {devices/lab_pin.sym} 12660 -27980 0 0 {name=p12204 lab=_69371_/X }
C {devices/lab_pin.sym} 12660 -27940 0 0 {name=p12205 lab=_69372_/X }
C {devices/lab_pin.sym} 12820 -28000 0 1 {name=p12206 lab=_69373_/X }
C {sky130_stdcells/a211o_4.sym} 12740 -28000 0 0 {name=X_69373_ }
C {devices/lab_pin.sym} 12700 -27850 0 0 {name=p12207 lab=clkbuf_9_279_0_CLK/X }
C {devices/lab_pin.sym} 12780 -27850 0 1 {name=p12208 lab=_82906_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 12740 -27850 0 0 {name=Xclkbuf_10_559_0_CLK }
C {devices/lab_pin.sym} 12660 -27750 0 0 {name=p12209 lab=_66580_/X }
C {devices/lab_pin.sym} 12660 -27710 0 0 {name=p12210 lab=_66584_/X }
C {devices/lab_pin.sym} 12660 -27670 0 0 {name=p12211 lab=_66411_/A }
C {devices/lab_pin.sym} 12820 -27710 0 1 {name=p12212 lab=_66585_/Y }
C {sky130_stdcells/a21oi_4.sym} 12740 -27710 0 0 {name=X_66585_ }
C {devices/lab_pin.sym} 12680 -27600 0 0 {name=p12213 lab=_61365_/X }
C {devices/lab_pin.sym} 12680 -27560 0 0 {name=p12214 lab=_63781_/B }
C {devices/lab_pin.sym} 12680 -27520 0 0 {name=p12215 lab=_63781_/C }
C {devices/lab_pin.sym} 12680 -27480 0 0 {name=p12216 lab=_63761_/X }
C {devices/lab_pin.sym} 12800 -27540 0 1 {name=p12217 lab=_63797_/Y }
C {sky130_stdcells/nand4_4.sym} 12740 -27540 0 0 {name=X_63797_ }
C {devices/lab_pin.sym} 12680 -27400 0 0 {name=p12218 lab=_84774_/Q }
C {devices/lab_pin.sym} 12680 -27360 0 0 {name=p12219 lab=_84166_/Q }
C {devices/lab_pin.sym} 12800 -27380 0 1 {name=p12220 lab=_80602_/Y }
C {sky130_stdcells/nand2_4.sym} 12740 -27380 0 0 {name=X_80602_ }
C {devices/lab_pin.sym} 12660 -27280 0 0 {name=p12221 lab=_68319_/X }
C {devices/lab_pin.sym} 12660 -27240 0 0 {name=p12222 lab=_67981_/Y }
C {devices/lab_pin.sym} 12660 -27200 0 0 {name=p12223 lab=_68308_/X }
C {devices/lab_pin.sym} 12660 -27160 0 0 {name=p12224 lab=_68323_/Y }
C {devices/lab_pin.sym} 12820 -27220 0 1 {name=p12225 lab=_68324_/X }
C {sky130_stdcells/a211o_4.sym} 12740 -27220 0 0 {name=X_68324_ }
C {devices/lab_pin.sym} 12680 -27080 0 0 {name=p12226 lab=_53565_/A }
C {devices/lab_pin.sym} 12680 -27040 0 0 {name=p12227 lab=_50326_/B }
C {devices/lab_pin.sym} 12800 -27060 0 1 {name=p12228 lab=_53550_/Y }
C {sky130_stdcells/nand2_4.sym} 12740 -27060 0 0 {name=X_53550_ }
C {devices/lab_pin.sym} 12660 -26960 0 0 {name=p12229 lab=_65484_/X }
C {devices/lab_pin.sym} 12660 -26920 0 0 {name=p12230 lab=_86202_/Q }
C {devices/lab_pin.sym} 12660 -26880 0 0 {name=p12231 lab=_65534_/X }
C {devices/lab_pin.sym} 12660 -26840 0 0 {name=p12232 lab=_65535_/X }
C {devices/lab_pin.sym} 12820 -26900 0 1 {name=p12233 lab=_65536_/X }
C {sky130_stdcells/a211o_4.sym} 12740 -26900 0 0 {name=X_65536_ }
C {devices/lab_pin.sym} 12650 -26750 0 0 {name=p12234 lab=_84449_/CLK }
C {devices/lab_pin.sym} 12650 -26730 0 0 {name=p12235 lab=_84370_/D }
C {devices/lab_pin.sym} 12830 -26750 0 1 {name=p12236 lab=_62921_/C }
C {sky130_stdcells/dfxtp_4.sym} 12740 -26740 0 0 {name=X_84370_ }
C {devices/lab_pin.sym} 12660 -26630 0 0 {name=p12237 lab=_86138_/Q }
C {devices/lab_pin.sym} 12660 -26590 0 0 {name=p12238 lab=_50742_/X }
C {devices/lab_pin.sym} 12660 -26550 0 0 {name=p12239 lab=_50761_/Y }
C {devices/lab_pin.sym} 12820 -26590 0 1 {name=p12240 lab=_50762_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -26590 0 0 {name=X_50762_ }
C {devices/lab_pin.sym} 12660 -26470 0 0 {name=p12241 lab=_62746_/X }
C {devices/lab_pin.sym} 12660 -26430 0 0 {name=p12242 lab=_62721_/X }
C {devices/lab_pin.sym} 12660 -26390 0 0 {name=p12243 lab=_62747_/Y }
C {devices/lab_pin.sym} 12820 -26430 0 1 {name=p12244 lab=_84386_/D }
C {sky130_stdcells/a21oi_4.sym} 12740 -26430 0 0 {name=X_62748_ }
C {devices/lab_pin.sym} 12650 -26290 0 0 {name=p12245 lab=_81582_/CLK }
C {devices/lab_pin.sym} 12650 -26270 0 0 {name=p12246 lab=_84182_/Q }
C {devices/lab_pin.sym} 12830 -26290 0 1 {name=p12247 lab=_81582_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -26280 0 0 {name=X_81582_ }
C {devices/lab_pin.sym} 12700 -26150 0 0 {name=p12248 lab=_52177_/A }
C {devices/lab_pin.sym} 12780 -26150 0 1 {name=p12249 lab=_52501_/X }
C {sky130_stdcells/buf_2.sym} 12740 -26150 0 0 {name=X_52501_ }
C {devices/lab_pin.sym} 12650 -26030 0 0 {name=p12250 lab=_83316_/CLK }
C {devices/lab_pin.sym} 12650 -26010 0 0 {name=p12251 lab=_71941_/Y }
C {devices/lab_pin.sym} 12830 -26030 0 1 {name=p12252 lab=_83321_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -26020 0 0 {name=X_83321_ }
C {devices/lab_pin.sym} 12660 -25910 0 0 {name=p12253 lab=_80520_/X }
C {devices/lab_pin.sym} 12660 -25870 0 0 {name=p12254 lab=_80531_/X }
C {devices/lab_pin.sym} 12660 -25830 0 0 {name=p12255 lab=_80532_/X }
C {devices/lab_pin.sym} 12820 -25870 0 1 {name=p12256 lab=_80533_/Y }
C {sky130_stdcells/a21oi_4.sym} 12740 -25870 0 0 {name=X_80533_ }
C {devices/lab_pin.sym} 12660 -25750 0 0 {name=p12257 lab=_67584_/X }
C {devices/lab_pin.sym} 12660 -25710 0 0 {name=p12258 lab=_67587_/X }
C {devices/lab_pin.sym} 12660 -25670 0 0 {name=p12259 lab=_68239_/X }
C {devices/lab_pin.sym} 12820 -25710 0 1 {name=p12260 lab=_68255_/Y }
C {sky130_stdcells/a21oi_4.sym} 12740 -25710 0 0 {name=X_68255_ }
C {devices/lab_pin.sym} 12660 -25590 0 0 {name=p12261 lab=_53479_/Y }
C {devices/lab_pin.sym} 12660 -25550 0 0 {name=p12262 lab=_53455_/X }
C {devices/lab_pin.sym} 12660 -25510 0 0 {name=p12263 lab=_53480_/Y }
C {devices/lab_pin.sym} 12820 -25550 0 1 {name=p12264 lab=_85629_/D }
C {sky130_stdcells/a21boi_4.sym} 12740 -25550 0 0 {name=X_53481_ }
C {devices/lab_pin.sym} 12660 -25430 0 0 {name=p12265 lab=_65463_/Y }
C {devices/lab_pin.sym} 12660 -25390 0 0 {name=p12266 lab=_65448_/X }
C {devices/lab_pin.sym} 12660 -25350 0 0 {name=p12267 lab=_65466_/X }
C {devices/lab_pin.sym} 12820 -25390 0 1 {name=p12268 lab=_84199_/D }
C {sky130_stdcells/a21o_4.sym} 12740 -25390 0 0 {name=X_65467_ }
C {devices/lab_pin.sym} 12680 -25260 0 0 {name=p12269 lab=_50693_/A }
C {devices/lab_pin.sym} 12680 -25220 0 0 {name=p12270 lab=_50693_/B }
C {devices/lab_pin.sym} 12800 -25240 0 1 {name=p12271 lab=_50693_/X }
C {sky130_stdcells/or2_4.sym} 12740 -25240 0 0 {name=X_50693_ }
C {devices/lab_pin.sym} 12700 -25110 0 0 {name=p12272 lab=_60271_/X }
C {devices/lab_pin.sym} 12780 -25110 0 1 {name=p12273 lab=_62679_/X }
C {sky130_stdcells/buf_2.sym} 12740 -25110 0 0 {name=X_62679_ }
C {devices/lab_pin.sym} 12660 -25020 0 0 {name=p12274 lab=_85027_/Q }
C {devices/lab_pin.sym} 12660 -24980 0 0 {name=p12275 lab=_55152_/A }
C {devices/lab_pin.sym} 12660 -24940 0 0 {name=p12276 lab=_55128_/A }
C {devices/lab_pin.sym} 12660 -24900 0 0 {name=p12277 lab=_55219_/X }
C {devices/lab_pin.sym} 12820 -24960 0 1 {name=p12278 lab=_55220_/X }
C {sky130_stdcells/a211o_4.sym} 12740 -24960 0 0 {name=X_55220_ }
C {devices/lab_pin.sym} 12650 -24810 0 0 {name=p12279 lab=_86040_/CLK }
C {devices/lab_pin.sym} 12650 -24790 0 0 {name=p12280 lab=_86040_/D }
C {devices/lab_pin.sym} 12830 -24810 0 1 {name=p12281 lab=_64860_/B }
C {sky130_stdcells/dfxtp_4.sym} 12740 -24800 0 0 {name=X_86040_ }
C {devices/lab_pin.sym} 12680 -24680 0 0 {name=p12282 lab=_67183_/A }
C {devices/lab_pin.sym} 12680 -24640 0 0 {name=p12283 lab=_67206_/B }
C {devices/lab_pin.sym} 12800 -24660 0 1 {name=p12284 lab=_67206_/X }
C {sky130_stdcells/and2_4.sym} 12740 -24660 0 0 {name=X_67206_ }
C {devices/lab_pin.sym} 12680 -24540 0 0 {name=p12285 lab=_52436_/A }
C {devices/lab_pin.sym} 12680 -24500 0 0 {name=p12286 lab=_53949_/B }
C {devices/lab_pin.sym} 12800 -24520 0 1 {name=p12287 lab=_52432_/Y }
C {sky130_stdcells/nand2_4.sym} 12740 -24520 0 0 {name=X_52432_ }
C {devices/lab_pin.sym} 12680 -24400 0 0 {name=p12288 lab=_58442_/A }
C {devices/lab_pin.sym} 12680 -24360 0 0 {name=p12289 lab=_64418_/B }
C {devices/lab_pin.sym} 12800 -24380 0 1 {name=p12290 lab=_64418_/Y }
C {sky130_stdcells/nor2_4.sym} 12740 -24380 0 0 {name=X_64418_ }
C {devices/lab_pin.sym} 12650 -24250 0 0 {name=p12291 lab=_85317_/CLK }
C {devices/lab_pin.sym} 12650 -24230 0 0 {name=p12292 lab=_83252_/D }
C {devices/lab_pin.sym} 12830 -24250 0 1 {name=p12293 lab=_83252_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -24240 0 0 {name=X_83252_ }
C {devices/lab_pin.sym} 12680 -24120 0 0 {name=p12294 lab=_80464_/A }
C {devices/lab_pin.sym} 12680 -24080 0 0 {name=p12295 lab=_63554_/C }
C {devices/lab_pin.sym} 12800 -24100 0 1 {name=p12296 lab=_80472_/B }
C {sky130_stdcells/xor2_4.sym} 12740 -24100 0 0 {name=X_80464_ }
C {devices/lab_pin.sym} 12660 -23990 0 0 {name=p12297 lab=_82057_/D }
C {devices/lab_pin.sym} 12660 -23950 0 0 {name=p12298 lab=_68180_/X }
C {devices/lab_pin.sym} 12660 -23910 0 0 {name=p12299 lab=_68185_/X }
C {devices/lab_pin.sym} 12820 -23950 0 1 {name=p12300 lab=_84017_/D }
C {sky130_stdcells/a21bo_4.sym} 12740 -23950 0 0 {name=X_68186_ }
C {devices/lab_pin.sym} 12660 -23830 0 0 {name=p12301 lab=_65395_/Y }
C {devices/lab_pin.sym} 12660 -23790 0 0 {name=p12302 lab=_65347_/X }
C {devices/lab_pin.sym} 12660 -23750 0 0 {name=p12303 lab=_65397_/Y }
C {devices/lab_pin.sym} 12820 -23790 0 1 {name=p12304 lab=_84203_/D }
C {sky130_stdcells/a21o_4.sym} 12740 -23790 0 0 {name=X_65398_ }
C {devices/lab_pin.sym} 12650 -23650 0 0 {name=p12305 lab=_82965_/CLK }
C {devices/lab_pin.sym} 12650 -23630 0 0 {name=p12306 lab=_82203_/D }
C {devices/lab_pin.sym} 12830 -23650 0 1 {name=p12307 lab=_82395_/D }
C {sky130_stdcells/dfxtp_4.sym} 12740 -23640 0 0 {name=X_82203_ }
C {devices/lab_pin.sym} 12660 -23540 0 0 {name=p12308 lab=_85098_/Q }
C {devices/lab_pin.sym} 12660 -23500 0 0 {name=p12309 lab=_44058_/A }
C {devices/lab_pin.sym} 12660 -23460 0 0 {name=p12310 lab=_55134_/X }
C {devices/lab_pin.sym} 12660 -23420 0 0 {name=p12311 lab=_55150_/X }
C {devices/lab_pin.sym} 12820 -23480 0 1 {name=p12312 lab=_55151_/X }
C {sky130_stdcells/a211o_4.sym} 12740 -23480 0 0 {name=X_55151_ }
C {devices/lab_pin.sym} 12660 -23360 0 0 {name=p12313 lab=_88380_/Q }
C {devices/lab_pin.sym} 12660 -23320 0 0 {name=p12314 lab=_67110_/X }
C {devices/lab_pin.sym} 12660 -23280 0 0 {name=p12315 lab=_67040_/X }
C {devices/lab_pin.sym} 12660 -23240 0 0 {name=p12316 lab=_67136_/X }
C {devices/lab_pin.sym} 12820 -23300 0 1 {name=p12317 lab=_67137_/X }
C {sky130_stdcells/a211o_4.sym} 12740 -23300 0 0 {name=X_67137_ }
C {devices/lab_pin.sym} 12660 -23170 0 0 {name=p12318 lab=_65130_/B }
C {devices/lab_pin.sym} 12660 -23130 0 0 {name=p12319 lab=_52347_/X }
C {devices/lab_pin.sym} 12660 -23090 0 0 {name=p12320 lab=_52362_/Y }
C {devices/lab_pin.sym} 12820 -23130 0 1 {name=p12321 lab=_52363_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -23130 0 0 {name=X_52363_ }
C {devices/lab_pin.sym} 12660 -23010 0 0 {name=p12322 lab=_64341_/Y }
C {devices/lab_pin.sym} 12660 -22970 0 0 {name=p12323 lab=_64348_/X }
C {devices/lab_pin.sym} 12660 -22930 0 0 {name=p12324 lab=_64328_/X }
C {devices/lab_pin.sym} 12820 -22970 0 1 {name=p12325 lab=_64349_/X }
C {sky130_stdcells/o21a_4.sym} 12740 -22970 0 0 {name=X_64349_ }
C {devices/lab_pin.sym} 12650 -22830 0 0 {name=p12326 lab=_83820_/CLK }
C {devices/lab_pin.sym} 12650 -22810 0 0 {name=p12327 lab=_72707_/X }
C {devices/lab_pin.sym} 12830 -22830 0 1 {name=p12328 lab=_70251_/C }
C {sky130_stdcells/dfxtp_4.sym} 12740 -22820 0 0 {name=X_83183_ }
C {devices/lab_pin.sym} 12660 -22710 0 0 {name=p12329 lab=_80386_/Y }
C {devices/lab_pin.sym} 12660 -22670 0 0 {name=p12330 lab=_80404_/B }
C {devices/lab_pin.sym} 12660 -22630 0 0 {name=p12331 lab=_80394_/X }
C {devices/lab_pin.sym} 12820 -22670 0 1 {name=p12332 lab=_80395_/Y }
C {sky130_stdcells/a21boi_4.sym} 12740 -22670 0 0 {name=X_80395_ }
C {devices/lab_pin.sym} 12680 -22540 0 0 {name=p12333 lab=_53434_/A }
C {devices/lab_pin.sym} 12680 -22500 0 0 {name=p12334 lab=_54102_/B }
C {devices/lab_pin.sym} 12800 -22520 0 1 {name=p12335 lab=_54102_/Y }
C {sky130_stdcells/nand2_4.sym} 12740 -22520 0 0 {name=X_54102_ }
C {devices/lab_pin.sym} 12680 -22410 0 0 {name=p12336 lab=_50802_/A }
C {devices/lab_pin.sym} 12680 -22370 0 0 {name=p12337 lab=_51266_/B }
C {devices/lab_pin.sym} 12680 -22330 0 0 {name=p12338 lab=_51330_/C }
C {devices/lab_pin.sym} 12800 -22370 0 1 {name=p12339 lab=_51314_/X }
C {sky130_stdcells/and3_4.sym} 12740 -22370 0 0 {name=X_51314_ }
C {devices/lab_pin.sym} 12650 -22230 0 0 {name=p12340 lab=_82009_/CLK }
C {devices/lab_pin.sym} 12650 -22210 0 0 {name=p12341 lab=_82134_/D }
C {devices/lab_pin.sym} 12830 -22230 0 1 {name=p12342 lab=_77338_/B }
C {sky130_stdcells/dfxtp_4.sym} 12740 -22220 0 0 {name=X_82134_ }
C {devices/lab_pin.sym} 12700 -22090 0 0 {name=p12343 lab=_47918_/A }
C {devices/lab_pin.sym} 12780 -22090 0 1 {name=p12344 lab=_55104_/B }
C {sky130_stdcells/buf_2.sym} 12740 -22090 0 0 {name=X_55082_ }
C {devices/lab_pin.sym} 12660 -21990 0 0 {name=p12345 lab=_84085_/Q }
C {devices/lab_pin.sym} 12660 -21950 0 0 {name=p12346 lab=_66971_/X }
C {devices/lab_pin.sym} 12660 -21910 0 0 {name=p12347 lab=_67067_/X }
C {devices/lab_pin.sym} 12820 -21950 0 1 {name=p12348 lab=_67068_/X }
C {sky130_stdcells/a21bo_4.sym} 12740 -21950 0 0 {name=X_67068_ }
C {devices/lab_pin.sym} 12660 -21830 0 0 {name=p12349 lab=_85851_/Q }
C {devices/lab_pin.sym} 12660 -21790 0 0 {name=p12350 lab=_52269_/X }
C {devices/lab_pin.sym} 12660 -21750 0 0 {name=p12351 lab=_52293_/Y }
C {devices/lab_pin.sym} 12820 -21790 0 1 {name=p12352 lab=_52294_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -21790 0 0 {name=X_52294_ }
C {devices/lab_pin.sym} 12650 -21650 0 0 {name=p12353 lab=_87749_/CLK }
C {devices/lab_pin.sym} 12650 -21630 0 0 {name=p12354 lab=_87991_/D }
C {devices/lab_pin.sym} 12830 -21650 0 1 {name=p12355 lab=_87991_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -21640 0 0 {name=X_87991_ }
C {devices/lab_pin.sym} 12680 -21520 0 0 {name=p12356 lab=_86694_/Q }
C {devices/lab_pin.sym} 12680 -21480 0 0 {name=p12357 lab=_58898_/B }
C {devices/lab_pin.sym} 12800 -21500 0 1 {name=p12358 lab=_58910_/Y }
C {sky130_stdcells/nor2_4.sym} 12740 -21500 0 0 {name=X_58910_ }
C {devices/lab_pin.sym} 12700 -21370 0 0 {name=p12359 lab=_53817_/A }
C {devices/lab_pin.sym} 12780 -21370 0 1 {name=p12360 lab=_54034_/A }
C {sky130_stdcells/buf_2.sym} 12740 -21370 0 0 {name=X_54033_ }
C {devices/lab_pin.sym} 12700 -21250 0 0 {name=p12361 lab=_60150_/A }
C {devices/lab_pin.sym} 12780 -21250 0 1 {name=p12362 lab=_66366_/A }
C {sky130_stdcells/buf_2.sym} 12740 -21250 0 0 {name=X_66019_ }
C {devices/lab_pin.sym} 12660 -21150 0 0 {name=p12363 lab=_64643_/B }
C {devices/lab_pin.sym} 12660 -21110 0 0 {name=p12364 lab=_51233_/X }
C {devices/lab_pin.sym} 12660 -21070 0 0 {name=p12365 lab=_51244_/Y }
C {devices/lab_pin.sym} 12820 -21110 0 1 {name=p12366 lab=_51245_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -21110 0 0 {name=X_51245_ }
C {devices/lab_pin.sym} 12650 -20970 0 0 {name=p12367 lab=_87416_/CLK }
C {devices/lab_pin.sym} 12650 -20950 0 0 {name=p12368 lab=_86942_/D }
C {devices/lab_pin.sym} 12830 -20970 0 1 {name=p12369 lab=_67361_/B }
C {sky130_stdcells/dfxtp_4.sym} 12740 -20960 0 0 {name=X_86942_ }
C {devices/lab_pin.sym} 12650 -20830 0 0 {name=p12370 lab=_80928_/CLK }
C {devices/lab_pin.sym} 12650 -20810 0 0 {name=p12371 lab=_82065_/D }
C {devices/lab_pin.sym} 12830 -20830 0 1 {name=p12372 lab=_82065_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -20820 0 0 {name=X_82065_ }
C {devices/lab_pin.sym} 12680 -20710 0 0 {name=p12373 lab=_59557_/X }
C {devices/lab_pin.sym} 12680 -20670 0 0 {name=p12374 lab=_59890_/B }
C {devices/lab_pin.sym} 12680 -20630 0 0 {name=p12375 lab=_59890_/C }
C {devices/lab_pin.sym} 12800 -20670 0 1 {name=p12376 lab=_60171_/A }
C {sky130_stdcells/nand3_4.sym} 12740 -20670 0 0 {name=X_59890_ }
C {devices/lab_pin.sym} 12650 -20530 0 0 {name=p12377 lab=_84150_/CLK }
C {devices/lab_pin.sym} 12650 -20510 0 0 {name=p12378 lab=_84224_/Q }
C {devices/lab_pin.sym} 12830 -20530 0 1 {name=p12379 lab=_81016_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -20520 0 0 {name=X_81016_ }
C {devices/lab_pin.sym} 12660 -20410 0 0 {name=p12380 lab=_58837_/Y }
C {devices/lab_pin.sym} 12660 -20370 0 0 {name=p12381 lab=_58840_/Y }
C {devices/lab_pin.sym} 12660 -20330 0 0 {name=p12382 lab=_58735_/X }
C {devices/lab_pin.sym} 12820 -20370 0 1 {name=p12383 lab=_58841_/X }
C {sky130_stdcells/a21o_4.sym} 12740 -20370 0 0 {name=X_58841_ }
C {devices/lab_pin.sym} 12700 -20230 0 0 {name=p12384 lab=_51149_/A }
C {devices/lab_pin.sym} 12780 -20230 0 1 {name=p12385 lab=_51192_/B }
C {sky130_stdcells/buf_2.sym} 12740 -20230 0 0 {name=X_51176_ }
C {devices/lab_pin.sym} 12650 -20110 0 0 {name=p12386 lab=_86873_/CLK }
C {devices/lab_pin.sym} 12650 -20090 0 0 {name=p12387 lab=_45499_/Y }
C {devices/lab_pin.sym} 12830 -20110 0 1 {name=p12388 lab=_63079_/B }
C {sky130_stdcells/dfxtp_4.sym} 12740 -20100 0 0 {name=X_86873_ }
C {devices/lab_pin.sym} 12660 -19990 0 0 {name=p12389 lab=_50125_/Y }
C {devices/lab_pin.sym} 12660 -19950 0 0 {name=p12390 lab=_50117_/X }
C {devices/lab_pin.sym} 12660 -19910 0 0 {name=p12391 lab=_50126_/X }
C {devices/lab_pin.sym} 12820 -19950 0 1 {name=p12392 lab=_50127_/Y }
C {sky130_stdcells/a21oi_4.sym} 12740 -19950 0 0 {name=X_50127_ }
C {devices/lab_pin.sym} 12650 -19810 0 0 {name=p12393 lab=_85535_/CLK }
C {devices/lab_pin.sym} 12650 -19790 0 0 {name=p12394 lab=_52433_/Y }
C {devices/lab_pin.sym} 12830 -19810 0 1 {name=p12395 lab=_85824_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -19800 0 0 {name=X_85824_ }
C {devices/lab_pin.sym} 12660 -19690 0 0 {name=p12396 lab=_58714_/X }
C {devices/lab_pin.sym} 12660 -19650 0 0 {name=p12397 lab=_85777_/Q }
C {devices/lab_pin.sym} 12660 -19610 0 0 {name=p12398 lab=_58716_/X }
C {devices/lab_pin.sym} 12820 -19650 0 1 {name=p12399 lab=_58772_/X }
C {sky130_stdcells/o21a_4.sym} 12740 -19650 0 0 {name=X_58772_ }
C {devices/lab_pin.sym} 12700 -19510 0 0 {name=p12400 lab=_55984_/A }
C {devices/lab_pin.sym} 12780 -19510 0 1 {name=p12401 lab=_74286_/C }
C {sky130_stdcells/buf_2.sym} 12740 -19510 0 0 {name=X_55984_ }
C {devices/lab_pin.sym} 12660 -19430 0 0 {name=p12402 lab=_46213_/X }
C {devices/lab_pin.sym} 12660 -19390 0 0 {name=p12403 lab=_57721_/Y }
C {devices/lab_pin.sym} 12660 -19350 0 0 {name=p12404 lab=_57722_/Y }
C {devices/lab_pin.sym} 12660 -19310 0 0 {name=p12405 lab=_57700_/X }
C {devices/lab_pin.sym} 12660 -19270 0 0 {name=p12406 lab=_57703_/X }
C {devices/lab_pin.sym} 12820 -19350 0 1 {name=p12407 lab=_57723_/X }
C {sky130_stdcells/o32a_4.sym} 12740 -19350 0 0 {name=X_57723_ }
C {devices/lab_pin.sym} 12660 -19220 0 0 {name=p12408 lab=_43141_/A }
C {devices/lab_pin.sym} 12660 -19180 0 0 {name=p12409 lab=_69645_/X }
C {devices/lab_pin.sym} 12660 -19140 0 0 {name=p12410 lab=_68613_/X }
C {devices/lab_pin.sym} 12660 -19100 0 0 {name=p12411 lab=_69708_/X }
C {devices/lab_pin.sym} 12820 -19160 0 1 {name=p12412 lab=_69709_/X }
C {sky130_stdcells/a211o_4.sym} 12740 -19160 0 0 {name=X_69709_ }
C {devices/lab_pin.sym} 12700 -19010 0 0 {name=p12413 lab=clkbuf_8_3_0_CLK/A }
C {devices/lab_pin.sym} 12780 -19010 0 1 {name=p12414 lab=clkbuf_9_7_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 12740 -19010 0 0 {name=Xclkbuf_8_3_0_CLK }
C {devices/lab_pin.sym} 12700 -18890 0 0 {name=p12415 lab=_48853_/A }
C {devices/lab_pin.sym} 12780 -18890 0 1 {name=p12416 lab=_50059_/C }
C {sky130_stdcells/buf_2.sym} 12740 -18890 0 0 {name=X_50058_ }
C {devices/lab_pin.sym} 12660 -18790 0 0 {name=p12417 lab=_85350_/Q }
C {devices/lab_pin.sym} 12660 -18750 0 0 {name=p12418 lab=_54918_/X }
C {devices/lab_pin.sym} 12660 -18710 0 0 {name=p12419 lab=_54934_/Y }
C {devices/lab_pin.sym} 12820 -18750 0 1 {name=p12420 lab=_54935_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -18750 0 0 {name=X_54935_ }
C {devices/lab_pin.sym} 12650 -18610 0 0 {name=p12421 lab=_85754_/CLK }
C {devices/lab_pin.sym} 12650 -18590 0 0 {name=p12422 lab=_52786_/Y }
C {devices/lab_pin.sym} 12830 -18610 0 1 {name=p12423 lab=_85755_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -18600 0 0 {name=X_85755_ }
C {devices/lab_pin.sym} 12680 -18500 0 0 {name=p12424 lab=_70764_/A }
C {devices/lab_pin.sym} 12680 -18460 0 0 {name=p12425 lab=_70959_/B }
C {devices/lab_pin.sym} 12680 -18420 0 0 {name=p12426 lab=_70959_/C }
C {devices/lab_pin.sym} 12680 -18380 0 0 {name=p12427 lab=_71115_/B }
C {devices/lab_pin.sym} 12800 -18440 0 1 {name=p12428 lab=_70981_/X }
C {sky130_stdcells/and4_4.sym} 12740 -18440 0 0 {name=X_70981_ }
C {devices/lab_pin.sym} 12650 -18290 0 0 {name=p12429 lab=_82965_/CLK }
C {devices/lab_pin.sym} 12650 -18270 0 0 {name=p12430 lab=_82967_/D }
C {devices/lab_pin.sym} 12830 -18290 0 1 {name=p12431 lab=_46715_/A }
C {sky130_stdcells/dfxtp_4.sym} 12740 -18280 0 0 {name=X_82967_ }
C {devices/lab_pin.sym} 12660 -18190 0 0 {name=p12432 lab=_41887_/X }
C {devices/lab_pin.sym} 12660 -18150 0 0 {name=p12433 lab=_41888_/X }
C {devices/lab_pin.sym} 12660 -18110 0 0 {name=p12434 lab=_40617_/X }
C {devices/lab_pin.sym} 12660 -18070 0 0 {name=p12435 lab=_41899_/Y }
C {devices/lab_pin.sym} 12660 -18030 0 0 {name=p12436 lab=_41891_/X }
C {devices/lab_pin.sym} 12820 -18110 0 1 {name=p12437 lab=_41900_/Y }
C {sky130_stdcells/o32ai_4.sym} 12740 -18110 0 0 {name=X_41900_ }
C {devices/lab_pin.sym} 12700 -17950 0 0 {name=p12438 lab=_72720_/A }
C {devices/lab_pin.sym} 12780 -17950 0 1 {name=p12439 lab=_73257_/A }
C {sky130_stdcells/buf_2.sym} 12740 -17950 0 0 {name=X_72720_ }
C {devices/lab_pin.sym} 12650 -17830 0 0 {name=p12440 lab=_84329_/CLK }
C {devices/lab_pin.sym} 12650 -17810 0 0 {name=p12441 lab=_59738_/Y }
C {devices/lab_pin.sym} 12830 -17830 0 1 {name=p12442 lab=_80548_/A }
C {sky130_stdcells/dfxtp_4.sym} 12740 -17820 0 0 {name=X_84706_ }
C {devices/lab_pin.sym} 12660 -17710 0 0 {name=p12443 lab=_57650_/X }
C {devices/lab_pin.sym} 12660 -17670 0 0 {name=p12444 lab=_57651_/Y }
C {devices/lab_pin.sym} 12660 -17630 0 0 {name=p12445 lab=_57653_/Y }
C {devices/lab_pin.sym} 12820 -17670 0 1 {name=p12446 lab=_84961_/D }
C {sky130_stdcells/a21oi_4.sym} 12740 -17670 0 0 {name=X_57654_ }
C {devices/lab_pin.sym} 12650 -17530 0 0 {name=p12447 lab=_82047_/CLK }
C {devices/lab_pin.sym} 12650 -17510 0 0 {name=p12448 lab=_77671_/X }
C {devices/lab_pin.sym} 12830 -17530 0 1 {name=p12449 lab=_81918_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -17520 0 0 {name=X_81918_ }
C {devices/lab_pin.sym} 12700 -17390 0 0 {name=p12450 lab=_42879_/Y }
C {devices/lab_pin.sym} 12780 -17390 0 1 {name=p12451 lab=_87671_/D }
C {sky130_stdcells/inv_2.sym} 12740 -17390 0 0 {name=X_42880_ }
C {devices/lab_pin.sym} 12700 -17270 0 0 {name=p12452 lab=_54919_/A }
C {devices/lab_pin.sym} 12780 -17270 0 1 {name=p12453 lab=_54885_/A }
C {sky130_stdcells/buf_2.sym} 12740 -17270 0 0 {name=X_54866_ }
C {devices/lab_pin.sym} 12650 -17150 0 0 {name=p12454 lab=_84787_/CLK }
C {devices/lab_pin.sym} 12650 -17130 0 0 {name=p12455 lab=_85686_/D }
C {devices/lab_pin.sym} 12830 -17150 0 1 {name=p12456 lab=_85686_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -17140 0 0 {name=X_85686_ }
C {devices/lab_pin.sym} 12650 -17010 0 0 {name=p12457 lab=_82327_/CLK }
C {devices/lab_pin.sym} 12650 -16990 0 0 {name=p12458 lab=_78197_/B }
C {devices/lab_pin.sym} 12830 -17010 0 1 {name=p12459 lab=_82898_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -17000 0 0 {name=X_82898_ }
C {devices/lab_pin.sym} 12660 -16890 0 0 {name=p12460 lab=_56600_/X }
C {devices/lab_pin.sym} 12660 -16850 0 0 {name=p12461 lab=_56553_/Y }
C {devices/lab_pin.sym} 12660 -16810 0 0 {name=p12462 lab=_56604_/Y }
C {devices/lab_pin.sym} 12820 -16850 0 1 {name=p12463 lab=_56605_/Y }
C {sky130_stdcells/a21oi_4.sym} 12740 -16850 0 0 {name=X_56605_ }
C {devices/lab_pin.sym} 12650 -16710 0 0 {name=p12464 lab=_86814_/CLK }
C {devices/lab_pin.sym} 12650 -16690 0 0 {name=p12465 lab=_87425_/D }
C {devices/lab_pin.sym} 12830 -16710 0 1 {name=p12466 lab=_87425_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -16700 0 0 {name=X_87425_ }
C {devices/lab_pin.sym} 12700 -16570 0 0 {name=p12467 lab=_41830_/Y }
C {devices/lab_pin.sym} 12780 -16570 0 1 {name=p12468 lab=_41831_/Y }
C {sky130_stdcells/inv_2.sym} 12740 -16570 0 0 {name=X_41831_ }
C {devices/lab_pin.sym} 12700 -16450 0 0 {name=p12469 lab=_53817_/A }
C {devices/lab_pin.sym} 12780 -16450 0 1 {name=p12470 lab=_53956_/A }
C {sky130_stdcells/buf_2.sym} 12740 -16450 0 0 {name=X_53817_ }
C {devices/lab_pin.sym} 12660 -16350 0 0 {name=p12471 lab=_83203_/Q }
C {devices/lab_pin.sym} 12660 -16310 0 0 {name=p12472 lab=_72645_/X }
C {devices/lab_pin.sym} 12660 -16270 0 0 {name=p12473 lab=_72650_/Y }
C {devices/lab_pin.sym} 12820 -16310 0 1 {name=p12474 lab=_83203_/D }
C {sky130_stdcells/a21bo_4.sym} 12740 -16310 0 0 {name=X_72651_ }
C {devices/lab_pin.sym} 12650 -16170 0 0 {name=p12475 lab=_83218_/CLK }
C {devices/lab_pin.sym} 12650 -16150 0 0 {name=p12476 lab=_84637_/D }
C {devices/lab_pin.sym} 12830 -16170 0 1 {name=p12477 lab=_79755_/A }
C {sky130_stdcells/dfxtp_4.sym} 12740 -16160 0 0 {name=X_84637_ }
C {devices/lab_pin.sym} 12660 -16050 0 0 {name=p12478 lab=_84974_/Q }
C {devices/lab_pin.sym} 12660 -16010 0 0 {name=p12479 lab=_57562_/X }
C {devices/lab_pin.sym} 12660 -15970 0 0 {name=p12480 lab=_57584_/Y }
C {devices/lab_pin.sym} 12820 -16010 0 1 {name=p12481 lab=_57585_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -16010 0 0 {name=X_57585_ }
C {devices/lab_pin.sym} 12650 -15870 0 0 {name=p12482 lab=_82515_/CLK }
C {devices/lab_pin.sym} 12650 -15850 0 0 {name=p12483 lab=_81881_/Q }
C {devices/lab_pin.sym} 12830 -15870 0 1 {name=p12484 lab=_77568_/A }
C {sky130_stdcells/dfxtp_4.sym} 12740 -15860 0 0 {name=X_81849_ }
C {devices/lab_pin.sym} 12660 -15750 0 0 {name=p12485 lab=_85376_/Q }
C {devices/lab_pin.sym} 12660 -15710 0 0 {name=p12486 lab=_54784_/X }
C {devices/lab_pin.sym} 12660 -15670 0 0 {name=p12487 lab=_54796_/Y }
C {devices/lab_pin.sym} 12820 -15710 0 1 {name=p12488 lab=_54797_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -15710 0 0 {name=X_54797_ }
C {devices/lab_pin.sym} 12660 -15600 0 0 {name=p12489 lab=_84751_/Q }
C {devices/lab_pin.sym} 12660 -15560 0 0 {name=p12490 lab=_59268_/X }
C {devices/lab_pin.sym} 12660 -15520 0 0 {name=p12491 lab=_59318_/X }
C {devices/lab_pin.sym} 12660 -15480 0 0 {name=p12492 lab=_59323_/X }
C {devices/lab_pin.sym} 12820 -15540 0 1 {name=p12493 lab=_59324_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 12740 -15540 0 0 {name=X_59324_ }
C {devices/lab_pin.sym} 12680 -15410 0 0 {name=p12494 lab=_70410_/Y }
C {devices/lab_pin.sym} 12680 -15370 0 0 {name=p12495 lab=_70361_/A }
C {devices/lab_pin.sym} 12680 -15330 0 0 {name=p12496 lab=_71602_/C }
C {devices/lab_pin.sym} 12800 -15370 0 1 {name=p12497 lab=_71603_/A }
C {sky130_stdcells/nor3_4.sym} 12740 -15370 0 0 {name=X_71602_ }
C {devices/lab_pin.sym} 12660 -15270 0 0 {name=p12498 lab=_44547_/X }
C {devices/lab_pin.sym} 12660 -15230 0 0 {name=p12499 lab=_44548_/X }
C {devices/lab_pin.sym} 12660 -15190 0 0 {name=p12500 lab=_40831_/X }
C {devices/lab_pin.sym} 12660 -15150 0 0 {name=p12501 lab=_73104_/A }
C {devices/lab_pin.sym} 12660 -15110 0 0 {name=p12502 lab=_44549_/X }
C {devices/lab_pin.sym} 12820 -15190 0 1 {name=p12503 lab=_44551_/A }
C {sky130_stdcells/o32ai_4.sym} 12740 -15190 0 0 {name=X_44550_ }
C {devices/lab_pin.sym} 12680 -15050 0 0 {name=p12504 lab=_56533_/A }
C {devices/lab_pin.sym} 12680 -15010 0 0 {name=p12505 lab=_56535_/X }
C {devices/lab_pin.sym} 12680 -14970 0 0 {name=p12506 lab=_56536_/C }
C {devices/lab_pin.sym} 12800 -15010 0 1 {name=p12507 lab=_56536_/Y }
C {sky130_stdcells/nand3_4.sym} 12740 -15010 0 0 {name=X_56536_ }
C {devices/lab_pin.sym} 12680 -14880 0 0 {name=p12508 lab=_75370_/A }
C {devices/lab_pin.sym} 12680 -14840 0 0 {name=p12509 lab=_75369_/Y }
C {devices/lab_pin.sym} 12800 -14860 0 1 {name=p12510 lab=_75370_/X }
C {sky130_stdcells/xor2_4.sym} 12740 -14860 0 0 {name=X_75370_ }
C {devices/lab_pin.sym} 12650 -14730 0 0 {name=p12511 lab=_81182_/CLK }
C {devices/lab_pin.sym} 12650 -14710 0 0 {name=p12512 lab=_43569_/X }
C {devices/lab_pin.sym} 12830 -14730 0 1 {name=p12513 lab=_87356_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -14720 0 0 {name=X_87356_ }
C {devices/lab_pin.sym} 12680 -14610 0 0 {name=p12514 lab=_48845_/A }
C {devices/lab_pin.sym} 12680 -14570 0 0 {name=p12515 lab=_53748_/B }
C {devices/lab_pin.sym} 12680 -14530 0 0 {name=p12516 lab=_53748_/C }
C {devices/lab_pin.sym} 12800 -14570 0 1 {name=p12517 lab=_53748_/X }
C {sky130_stdcells/and3_4.sym} 12740 -14570 0 0 {name=X_53748_ }
C {devices/lab_pin.sym} 12700 -14430 0 0 {name=p12518 lab=_41761_/X }
C {devices/lab_pin.sym} 12780 -14430 0 1 {name=p12519 lab=_41762_/X }
C {sky130_stdcells/buf_2.sym} 12740 -14430 0 0 {name=X_41762_ }
C {devices/lab_pin.sym} 12660 -14350 0 0 {name=p12520 lab=_72510_/Y }
C {devices/lab_pin.sym} 12660 -14310 0 0 {name=p12521 lab=_72546_/Y }
C {devices/lab_pin.sym} 12660 -14270 0 0 {name=p12522 lab=_72584_/A }
C {devices/lab_pin.sym} 12660 -14230 0 0 {name=p12523 lab=_72579_/Y }
C {devices/lab_pin.sym} 12660 -14200 0 0 {name=p12524 lab=_72581_/Y }
C {devices/lab_pin.sym} 12820 -14270 0 1 {name=p12525 lab=_72582_/Y }
C {sky130_stdcells/a41oi_4.sym} 12740 -14270 0 0 {name=X_72582_ }
C {devices/lab_pin.sym} 12650 -14110 0 0 {name=p12526 lab=_84583_/CLK }
C {devices/lab_pin.sym} 12650 -14090 0 0 {name=p12527 lab=_60787_/Y }
C {devices/lab_pin.sym} 12830 -14110 0 1 {name=p12528 lab=_84568_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -14100 0 0 {name=X_84568_ }
C {devices/lab_pin.sym} 12660 -14000 0 0 {name=p12529 lab=_41745_/X }
C {devices/lab_pin.sym} 12660 -13960 0 0 {name=p12530 lab=_43498_/X }
C {devices/lab_pin.sym} 12660 -13920 0 0 {name=p12531 lab=_87389_/Q }
C {devices/lab_pin.sym} 12660 -13880 0 0 {name=p12532 lab=_43499_/X }
C {devices/lab_pin.sym} 12820 -13940 0 1 {name=p12533 lab=_87389_/D }
C {sky130_stdcells/a2bb2o_4.sym} 12740 -13940 0 0 {name=X_43501_ }
C {devices/lab_pin.sym} 12680 -13810 0 0 {name=p12534 lab=_74325_/A }
C {devices/lab_pin.sym} 12680 -13770 0 0 {name=p12535 lab=_74325_/B }
C {devices/lab_pin.sym} 12680 -13730 0 0 {name=p12536 lab=_55863_/X }
C {devices/lab_pin.sym} 12800 -13770 0 1 {name=p12537 lab=_74321_/Y }
C {sky130_stdcells/nand3_4.sym} 12740 -13770 0 0 {name=X_74321_ }
C {devices/lab_pin.sym} 12650 -13630 0 0 {name=p12538 lab=_86627_/CLK }
C {devices/lab_pin.sym} 12650 -13610 0 0 {name=p12539 lab=_86307_/D }
C {devices/lab_pin.sym} 12830 -13630 0 1 {name=p12540 lab=_58130_/B }
C {sky130_stdcells/dfxtp_4.sym} 12740 -13620 0 0 {name=X_86307_ }
C {devices/lab_pin.sym} 12660 -13520 0 0 {name=p12541 lab=_40712_/X }
C {devices/lab_pin.sym} 12660 -13480 0 0 {name=p12542 lab=_40651_/X }
C {devices/lab_pin.sym} 12660 -13440 0 0 {name=p12543 lab=_88349_/Q }
C {devices/lab_pin.sym} 12660 -13400 0 0 {name=p12544 lab=_40652_/X }
C {devices/lab_pin.sym} 12820 -13460 0 1 {name=p12545 lab=_40713_/X }
C {sky130_stdcells/a2bb2o_4.sym} 12740 -13460 0 0 {name=X_40713_ }
C {devices/lab_pin.sym} 12700 -13310 0 0 {name=p12546 lab=_71602_/C }
C {devices/lab_pin.sym} 12780 -13310 0 1 {name=p12547 lab=_71585_/A }
C {sky130_stdcells/buf_2.sym} 12740 -13310 0 0 {name=X_71533_ }
C {devices/lab_pin.sym} 12700 -13190 0 0 {name=p12548 lab=_59255_/A }
C {devices/lab_pin.sym} 12780 -13190 0 1 {name=p12549 lab=_59256_/A }
C {sky130_stdcells/buf_2.sym} 12740 -13190 0 0 {name=X_59255_ }
C {devices/lab_pin.sym} 12650 -13070 0 0 {name=p12550 lab=_83521_/CLK }
C {devices/lab_pin.sym} 12650 -13050 0 0 {name=p12551 lab=_71382_/X }
C {devices/lab_pin.sym} 12830 -13070 0 1 {name=p12552 lab=_83519_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -13060 0 0 {name=X_83519_ }
C {devices/lab_pin.sym} 12700 -12930 0 0 {name=p12553 lab=_44547_/A }
C {devices/lab_pin.sym} 12780 -12930 0 1 {name=p12554 lab=_44481_/X }
C {sky130_stdcells/buf_2.sym} 12740 -12930 0 0 {name=X_44481_ }
C {devices/lab_pin.sym} 12700 -12810 0 0 {name=p12555 lab=_56463_/A }
C {devices/lab_pin.sym} 12780 -12810 0 1 {name=p12556 lab=_56538_/A }
C {sky130_stdcells/buf_2.sym} 12740 -12810 0 0 {name=X_56467_ }
C {devices/lab_pin.sym} 12700 -12690 0 0 {name=p12557 lab=_41692_/Y }
C {devices/lab_pin.sym} 12780 -12690 0 1 {name=p12558 lab=_41693_/X }
C {sky130_stdcells/buf_2.sym} 12740 -12690 0 0 {name=X_41693_ }
C {devices/lab_pin.sym} 12650 -12570 0 0 {name=p12559 lab=_87577_/CLK }
C {devices/lab_pin.sym} 12650 -12550 0 0 {name=p12560 lab=_87287_/D }
C {devices/lab_pin.sym} 12830 -12570 0 1 {name=p12561 lab=_43744_/A }
C {sky130_stdcells/dfxtp_4.sym} 12740 -12560 0 0 {name=X_87287_ }
C {devices/lab_pin.sym} 12660 -12450 0 0 {name=p12562 lab=_85589_/Q }
C {devices/lab_pin.sym} 12660 -12410 0 0 {name=p12563 lab=_53660_/X }
C {devices/lab_pin.sym} 12660 -12370 0 0 {name=p12564 lab=_53678_/Y }
C {devices/lab_pin.sym} 12820 -12410 0 1 {name=p12565 lab=_53679_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -12410 0 0 {name=X_53679_ }
C {devices/lab_pin.sym} 12650 -12270 0 0 {name=p12566 lab=_84493_/CLK }
C {devices/lab_pin.sym} 12650 -12250 0 0 {name=p12567 lab=_84499_/D }
C {devices/lab_pin.sym} 12830 -12270 0 1 {name=p12568 lab=_75901_/A }
C {sky130_stdcells/dfxtp_4.sym} 12740 -12260 0 0 {name=X_84499_ }
C {devices/lab_pin.sym} 12700 -12130 0 0 {name=p12569 lab=_46220_/A }
C {devices/lab_pin.sym} 12780 -12130 0 1 {name=p12570 lab=_46220_/Y }
C {sky130_stdcells/inv_2.sym} 12740 -12130 0 0 {name=X_46220_ }
C {sky130_stdcells/decap_3.sym} 12740 -11980 0 0 {name=XPHY_320 }
C {devices/lab_pin.sym} 12700 -11830 0 0 {name=p12571 lab=_57665_/A }
C {devices/lab_pin.sym} 12780 -11830 0 1 {name=p12572 lab=_58238_/B }
C {sky130_stdcells/buf_2.sym} 12740 -11830 0 0 {name=X_58206_ }
C {devices/lab_pin.sym} 12660 -11730 0 0 {name=p12573 lab=_77041_/A }
C {devices/lab_pin.sym} 12660 -11690 0 0 {name=p12574 lab=_77041_/C }
C {devices/lab_pin.sym} 12660 -11650 0 0 {name=p12575 lab=_77041_/B }
C {devices/lab_pin.sym} 12820 -11690 0 1 {name=p12576 lab=_77047_/A }
C {sky130_stdcells/a21o_4.sym} 12740 -11690 0 0 {name=X_77040_ }
C {devices/lab_pin.sym} 12700 -11550 0 0 {name=p12577 lab=_43397_/A }
C {devices/lab_pin.sym} 12780 -11550 0 1 {name=p12578 lab=_43432_/X }
C {sky130_stdcells/buf_2.sym} 12740 -11550 0 0 {name=X_43432_ }
C {devices/lab_pin.sym} 12660 -11450 0 0 {name=p12579 lab=_55416_/Y }
C {devices/lab_pin.sym} 12660 -11410 0 0 {name=p12580 lab=_55296_/B }
C {devices/lab_pin.sym} 12660 -11370 0 0 {name=p12581 lab=_55417_/Y }
C {devices/lab_pin.sym} 12820 -11410 0 1 {name=p12582 lab=_56807_/A }
C {sky130_stdcells/a21o_4.sym} 12740 -11410 0 0 {name=X_55418_ }
C {devices/lab_pin.sym} 12660 -11300 0 0 {name=p12583 lab=_74012_/X }
C {devices/lab_pin.sym} 12660 -11260 0 0 {name=p12584 lab=_86211_/Q }
C {devices/lab_pin.sym} 12660 -11220 0 0 {name=p12585 lab=_45930_/X }
C {devices/lab_pin.sym} 12660 -11180 0 0 {name=p12586 lab=_74251_/X }
C {devices/lab_pin.sym} 12820 -11240 0 1 {name=p12587 lab=_74252_/X }
C {sky130_stdcells/a211o_4.sym} 12740 -11240 0 0 {name=X_74252_ }
C {devices/lab_pin.sym} 12650 -11090 0 0 {name=p12588 lab=_86238_/CLK }
C {devices/lab_pin.sym} 12650 -11070 0 0 {name=p12589 lab=_86238_/D }
C {devices/lab_pin.sym} 12830 -11090 0 1 {name=p12590 lab=_86238_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -11080 0 0 {name=X_86238_ }
C {devices/lab_pin.sym} 12680 -10960 0 0 {name=p12591 lab=_40644_/A }
C {devices/lab_pin.sym} 12680 -10920 0 0 {name=p12592 lab=_40588_/B }
C {devices/lab_pin.sym} 12800 -10940 0 1 {name=p12593 lab=_40644_/X }
C {sky130_stdcells/or2_4.sym} 12740 -10940 0 0 {name=X_40644_ }
C {sky130_stdcells/decap_3.sym} 12740 -10780 0 0 {name=XPHY_331 }
C {devices/lab_pin.sym} 12660 -10650 0 0 {name=p12594 lab=_59085_/X }
C {devices/lab_pin.sym} 12660 -10610 0 0 {name=p12595 lab=_86066_/Q }
C {devices/lab_pin.sym} 12660 -10570 0 0 {name=p12596 lab=_59185_/X }
C {devices/lab_pin.sym} 12820 -10610 0 1 {name=p12597 lab=_59186_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -10610 0 0 {name=X_59186_ }
C {devices/lab_pin.sym} 12700 -10470 0 0 {name=p12598 lab=_71463_/Y }
C {devices/lab_pin.sym} 12780 -10470 0 1 {name=p12599 lab=_71464_/X }
C {sky130_stdcells/buf_2.sym} 12740 -10470 0 0 {name=X_71464_ }
C {devices/lab_pin.sym} 12700 -10350 0 0 {name=p12600 lab=_56436_/A }
C {devices/lab_pin.sym} 12780 -10350 0 1 {name=p12601 lab=_56399_/B }
C {sky130_stdcells/buf_2.sym} 12740 -10350 0 0 {name=X_56398_ }
C {sky130_stdcells/decap_3.sym} 12740 -10200 0 0 {name=XPHY_342 }
C {sky130_stdcells/decap_3.sym} 12740 -10020 0 0 {name=XPHY_353 }
C {sky130_stdcells/decap_3.sym} 12740 -9840 0 0 {name=XPHY_364 }
C {devices/lab_pin.sym} 12660 -9710 0 0 {name=p12602 lab=_88322_/Q }
C {devices/lab_pin.sym} 12660 -9670 0 0 {name=p12603 lab=_73086_/X }
C {devices/lab_pin.sym} 12660 -9630 0 0 {name=p12604 lab=_73202_/X }
C {devices/lab_pin.sym} 12820 -9670 0 1 {name=p12605 lab=_73203_/X }
C {sky130_stdcells/o21a_4.sym} 12740 -9670 0 0 {name=X_73203_ }
C {devices/lab_pin.sym} 12680 -9550 0 0 {name=p12606 lab=_46101_/A }
C {devices/lab_pin.sym} 12680 -9510 0 0 {name=p12607 lab=_46151_/B }
C {devices/lab_pin.sym} 12680 -9470 0 0 {name=p12608 lab=_46108_/D }
C {devices/lab_pin.sym} 12800 -9510 0 1 {name=p12609 lab=_46166_/C }
C {sky130_stdcells/and3_4.sym} 12740 -9510 0 0 {name=X_46151_ }
C {devices/lab_pin.sym} 12660 -9410 0 0 {name=p12610 lab=_58079_/X }
C {devices/lab_pin.sym} 12660 -9370 0 0 {name=p12611 lab=_58135_/Y }
C {devices/lab_pin.sym} 12660 -9330 0 0 {name=p12612 lab=_58136_/Y }
C {devices/lab_pin.sym} 12660 -9290 0 0 {name=p12613 lab=_58098_/X }
C {devices/lab_pin.sym} 12660 -9250 0 0 {name=p12614 lab=_58083_/X }
C {devices/lab_pin.sym} 12820 -9330 0 1 {name=p12615 lab=_58137_/X }
C {sky130_stdcells/o32a_4.sym} 12740 -9330 0 0 {name=X_58137_ }
C {devices/lab_pin.sym} 12680 -9190 0 0 {name=p12616 lab=_70412_/X }
C {devices/lab_pin.sym} 12680 -9150 0 0 {name=p12617 lab=_70694_/A }
C {devices/lab_pin.sym} 12680 -9110 0 0 {name=p12618 lab=_70700_/B }
C {devices/lab_pin.sym} 12800 -9150 0 1 {name=p12619 lab=_70428_/A }
C {sky130_stdcells/nand3_4.sym} 12740 -9150 0 0 {name=X_70415_ }
C {sky130_stdcells/decap_3.sym} 12740 -8980 0 0 {name=XPHY_375 }
C {devices/lab_pin.sym} 12680 -8840 0 0 {name=p12620 lab=_55323_/A }
C {devices/lab_pin.sym} 12680 -8800 0 0 {name=p12621 lab=_85137_/Q }
C {devices/lab_pin.sym} 12800 -8820 0 1 {name=p12622 lab=_55349_/X }
C {sky130_stdcells/and2_4.sym} 12740 -8820 0 0 {name=X_55349_ }
C {devices/lab_pin.sym} 12660 -8730 0 0 {name=p12623 lab=_43347_/X }
C {devices/lab_pin.sym} 12660 -8690 0 0 {name=p12624 lab=_43350_/X }
C {devices/lab_pin.sym} 12660 -8650 0 0 {name=p12625 lab=_41376_/X }
C {devices/lab_pin.sym} 12660 -8610 0 0 {name=p12626 lab=_87458_/Q }
C {devices/lab_pin.sym} 12660 -8570 0 0 {name=p12627 lab=_43353_/X }
C {devices/lab_pin.sym} 12820 -8650 0 1 {name=p12628 lab=_43364_/A }
C {sky130_stdcells/o32ai_4.sym} 12740 -8650 0 0 {name=X_43363_ }
C {devices/lab_pin.sym} 12660 -8510 0 0 {name=p12629 lab=_70129_/A }
C {devices/lab_pin.sym} 12660 -8470 0 0 {name=p12630 lab=_74139_/X }
C {devices/lab_pin.sym} 12660 -8430 0 0 {name=p12631 lab=_74182_/Y }
C {devices/lab_pin.sym} 12820 -8470 0 1 {name=p12632 lab=_74183_/X }
C {sky130_stdcells/a21o_4.sym} 12740 -8470 0 0 {name=X_74183_ }
C {devices/lab_pin.sym} 12650 -8330 0 0 {name=p12633 lab=_85562_/CLK }
C {devices/lab_pin.sym} 12650 -8310 0 0 {name=p12634 lab=_86169_/D }
C {devices/lab_pin.sym} 12830 -8330 0 1 {name=p12635 lab=_86169_/Q }
C {sky130_stdcells/dfxtp_4.sym} 12740 -8320 0 0 {name=X_86169_ }
C {devices/lab_pin.sym} 12700 -8190 0 0 {name=p12636 lab=_40574_/Y }
C {devices/lab_pin.sym} 12780 -8190 0 1 {name=p12637 lab=_40575_/Y }
C {sky130_stdcells/inv_2.sym} 12740 -8190 0 0 {name=X_40575_ }
C {sky130_stdcells/decap_3.sym} 12740 -8040 0 0 {name=XPHY_386 }
C {devices/lab_pin.sym} 12680 -7900 0 0 {name=p12638 lab=_71191_/A }
C {devices/lab_pin.sym} 12680 -7860 0 0 {name=p12639 lab=_71342_/B }
C {devices/lab_pin.sym} 12800 -7880 0 1 {name=p12640 lab=_71395_/Y }
C {sky130_stdcells/nor2_4.sym} 12740 -7880 0 0 {name=X_71395_ }
C {sky130_stdcells/decap_3.sym} 12740 -7720 0 0 {name=XPHY_397 }
C {devices/lab_pin.sym} 12700 -7570 0 0 {name=p12641 lab=_45827_/B }
C {devices/lab_pin.sym} 12780 -7570 0 1 {name=p12642 lab=_45102_/X }
C {sky130_stdcells/buf_2.sym} 12740 -7570 0 0 {name=X_45102_ }
C {devices/lab_pin.sym} 12700 -7450 0 0 {name=p12643 lab=_42314_/A }
C {devices/lab_pin.sym} 12780 -7450 0 1 {name=p12644 lab=_42314_/Y }
C {sky130_stdcells/inv_2.sym} 12740 -7450 0 0 {name=X_42314_ }
C {devices/lab_pin.sym} 12700 -7330 0 0 {name=p12645 lab=_73306_/A }
C {devices/lab_pin.sym} 12780 -7330 0 1 {name=p12646 lab=_73260_/A }
C {sky130_stdcells/buf_2.sym} 12740 -7330 0 0 {name=X_73134_ }
C {devices/lab_pin.sym} 12700 -7210 0 0 {name=p12647 lab=_46082_/A }
C {devices/lab_pin.sym} 12780 -7210 0 1 {name=p12648 lab=_46082_/Y }
C {sky130_stdcells/inv_2.sym} 12740 -7210 0 0 {name=X_46082_ }
C {devices/lab_pin.sym} 12660 -7110 0 0 {name=p12649 lab=_58064_/Y }
C {devices/lab_pin.sym} 12660 -7070 0 0 {name=p12650 lab=_58067_/Y }
C {devices/lab_pin.sym} 12660 -7030 0 0 {name=p12651 lab=_58035_/X }
C {devices/lab_pin.sym} 12820 -7070 0 1 {name=p12652 lab=_58068_/X }
C {sky130_stdcells/a21o_4.sym} 12740 -7070 0 0 {name=X_58068_ }
C {devices/lab_pin.sym} 12680 -6960 0 0 {name=p12653 lab=_70348_/A }
C {devices/lab_pin.sym} 12680 -6920 0 0 {name=p12654 lab=_70348_/B }
C {devices/lab_pin.sym} 12680 -6880 0 0 {name=p12655 lab=_70346_/C }
C {devices/lab_pin.sym} 12680 -6840 0 0 {name=p12656 lab=_70348_/D }
C {devices/lab_pin.sym} 12800 -6900 0 1 {name=p12657 lab=_70346_/X }
C {sky130_stdcells/and4_4.sym} 12740 -6900 0 0 {name=X_70346_ }
C {devices/lab_pin.sym} 12660 -6780 0 0 {name=p12658 lab=_41189_/X }
C {devices/lab_pin.sym} 12660 -6740 0 0 {name=p12659 lab=_43287_/X }
C {devices/lab_pin.sym} 12660 -6700 0 0 {name=p12660 lab=_87493_/Q }
C {devices/lab_pin.sym} 12660 -6660 0 0 {name=p12661 lab=_43288_/X }
C {devices/lab_pin.sym} 12820 -6720 0 1 {name=p12662 lab=_43294_/X }
C {sky130_stdcells/a2bb2o_4.sym} 12740 -6720 0 0 {name=X_43294_ }
C {devices/lab_pin.sym} 12660 -6590 0 0 {name=p12663 lab=_82645_/Q }
C {devices/lab_pin.sym} 12660 -6550 0 0 {name=p12664 lab=_82517_/D }
C {devices/lab_pin.sym} 12660 -6510 0 0 {name=p12665 lab=_78990_/X }
C {devices/lab_pin.sym} 12820 -6550 0 1 {name=p12666 lab=_78991_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -6550 0 0 {name=X_78991_ }
C {devices/lab_pin.sym} 12680 -6440 0 0 {name=p12667 lab=_49904_/A }
C {devices/lab_pin.sym} 12680 -6400 0 0 {name=p12668 lab=_49893_/B }
C {devices/lab_pin.sym} 12680 -6360 0 0 {name=p12669 lab=_49904_/C }
C {devices/lab_pin.sym} 12680 -6320 0 0 {name=p12670 lab=_53125_/D }
C {devices/lab_pin.sym} 12800 -6380 0 1 {name=p12671 lab=_49910_/X }
C {sky130_stdcells/and4_4.sym} 12740 -6380 0 0 {name=X_49910_ }
C {devices/lab_pin.sym} 12680 -6240 0 0 {name=p12672 lab=_74564_/C }
C {devices/lab_pin.sym} 12680 -6200 0 0 {name=p12673 lab=_45033_/B }
C {devices/lab_pin.sym} 12800 -6220 0 1 {name=p12674 lab=_45033_/Y }
C {sky130_stdcells/nand2_4.sym} 12740 -6220 0 0 {name=X_45033_ }
C {devices/lab_pin.sym} 12680 -6110 0 0 {name=p12675 lab=_57019_/A }
C {devices/lab_pin.sym} 12680 -6070 0 0 {name=p12676 lab=_57011_/Y }
C {devices/lab_pin.sym} 12680 -6030 0 0 {name=p12677 lab=_57019_/C }
C {devices/lab_pin.sym} 12800 -6070 0 1 {name=p12678 lab=_57019_/X }
C {sky130_stdcells/and3_4.sym} 12740 -6070 0 0 {name=X_57019_ }
C {devices/lab_pin.sym} 12660 -5970 0 0 {name=p12679 lab=_42231_/X }
C {devices/lab_pin.sym} 12660 -5930 0 0 {name=p12680 lab=_42243_/X }
C {devices/lab_pin.sym} 12660 -5890 0 0 {name=p12681 lab=_41424_/X }
C {devices/lab_pin.sym} 12660 -5850 0 0 {name=p12682 lab=_87962_/Q }
C {devices/lab_pin.sym} 12660 -5810 0 0 {name=p12683 lab=_42244_/X }
C {devices/lab_pin.sym} 12820 -5890 0 1 {name=p12684 lab=_42245_/Y }
C {sky130_stdcells/o32ai_4.sym} 12740 -5890 0 0 {name=X_42245_ }
C {devices/lab_pin.sym} 12680 -5740 0 0 {name=p12685 lab=_73093_/A }
C {devices/lab_pin.sym} 12680 -5700 0 0 {name=p12686 lab=_86486_/Q }
C {devices/lab_pin.sym} 12800 -5720 0 1 {name=p12687 lab=_73065_/X }
C {sky130_stdcells/and2_4.sym} 12740 -5720 0 0 {name=X_73065_ }
C {devices/lab_pin.sym} 12680 -5600 0 0 {name=p12688 lab=_77942_/A }
C {devices/lab_pin.sym} 12680 -5560 0 0 {name=p12689 lab=_77942_/B }
C {devices/lab_pin.sym} 12800 -5580 0 1 {name=p12690 lab=_77942_/X }
C {sky130_stdcells/xor2_4.sym} 12740 -5580 0 0 {name=X_77942_ }
C {devices/lab_pin.sym} 12680 -5480 0 0 {name=p12691 lab=_70267_/A }
C {devices/lab_pin.sym} 12680 -5440 0 0 {name=p12692 lab=_70267_/B }
C {devices/lab_pin.sym} 12680 -5400 0 0 {name=p12693 lab=_70277_/C }
C {devices/lab_pin.sym} 12680 -5360 0 0 {name=p12694 lab=_70264_/X }
C {devices/lab_pin.sym} 12800 -5420 0 1 {name=p12695 lab=_70277_/X }
C {sky130_stdcells/and4_4.sym} 12740 -5420 0 0 {name=X_70277_ }
C {devices/lab_pin.sym} 12680 -5300 0 0 {name=p12696 lab=_60079_/B }
C {devices/lab_pin.sym} 12680 -5260 0 0 {name=p12697 lab=_59922_/C }
C {devices/lab_pin.sym} 12680 -5220 0 0 {name=p12698 lab=_60091_/A }
C {devices/lab_pin.sym} 12680 -5180 0 0 {name=p12699 lab=_60091_/C }
C {devices/lab_pin.sym} 12800 -5240 0 1 {name=p12700 lab=_60030_/Y }
C {sky130_stdcells/nand4_4.sym} 12740 -5240 0 0 {name=X_60030_ }
C {devices/lab_pin.sym} 12700 -5090 0 0 {name=p12701 lab=_71985_/A }
C {devices/lab_pin.sym} 12780 -5090 0 1 {name=p12702 lab=_72016_/X }
C {sky130_stdcells/buf_2.sym} 12740 -5090 0 0 {name=X_72016_ }
C {devices/lab_pin.sym} 12680 -4980 0 0 {name=p12703 lab=_49827_/X }
C {devices/lab_pin.sym} 12680 -4940 0 0 {name=p12704 lab=_53054_/B }
C {devices/lab_pin.sym} 12800 -4960 0 1 {name=p12705 lab=_49841_/Y }
C {sky130_stdcells/nand2_4.sym} 12740 -4960 0 0 {name=X_49841_ }
C {devices/lab_pin.sym} 12660 -4860 0 0 {name=p12706 lab=_41230_/X }
C {devices/lab_pin.sym} 12660 -4820 0 0 {name=p12707 lab=_42161_/X }
C {devices/lab_pin.sym} 12660 -4780 0 0 {name=p12708 lab=_87997_/Q }
C {devices/lab_pin.sym} 12660 -4740 0 0 {name=p12709 lab=_42162_/X }
C {devices/lab_pin.sym} 12820 -4800 0 1 {name=p12710 lab=_42176_/X }
C {sky130_stdcells/a2bb2o_4.sym} 12740 -4800 0 0 {name=X_42176_ }
C {devices/lab_pin.sym} 12680 -4660 0 0 {name=p12711 lab=_77885_/A }
C {devices/lab_pin.sym} 12680 -4620 0 0 {name=p12712 lab=_77872_/Y }
C {devices/lab_pin.sym} 12800 -4640 0 1 {name=p12713 lab=_77880_/A }
C {sky130_stdcells/xor2_4.sym} 12740 -4640 0 0 {name=X_77873_ }
C {devices/lab_pin.sym} 12660 -4530 0 0 {name=p12714 lab=_79596_/Y }
C {devices/lab_pin.sym} 12660 -4490 0 0 {name=p12715 lab=_79592_/Y }
C {devices/lab_pin.sym} 12660 -4450 0 0 {name=p12716 lab=_79594_/Y }
C {devices/lab_pin.sym} 12820 -4490 0 1 {name=p12717 lab=_79612_/Y }
C {sky130_stdcells/a21boi_4.sym} 12740 -4490 0 0 {name=X_79612_ }
C {devices/lab_pin.sym} 12700 -4350 0 0 {name=p12718 lab=_41127_/A }
C {devices/lab_pin.sym} 12780 -4350 0 1 {name=p12719 lab=_41127_/Y }
C {sky130_stdcells/inv_2.sym} 12740 -4350 0 0 {name=X_41127_ }
C {devices/lab_pin.sym} 12660 -4250 0 0 {name=p12720 lab=_76812_/A }
C {devices/lab_pin.sym} 12660 -4210 0 0 {name=p12721 lab=_76811_/Y }
C {devices/lab_pin.sym} 12660 -4170 0 0 {name=p12722 lab=_76823_/X }
C {devices/lab_pin.sym} 12820 -4210 0 1 {name=p12723 lab=_76824_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -4210 0 0 {name=X_76824_ }
C {devices/lab_pin.sym} 12680 -4100 0 0 {name=p12724 lab=_49779_/A }
C {devices/lab_pin.sym} 12680 -4060 0 0 {name=p12725 lab=_49750_/X }
C {devices/lab_pin.sym} 12680 -4020 0 0 {name=p12726 lab=_49789_/C }
C {devices/lab_pin.sym} 12680 -3980 0 0 {name=p12727 lab=_52989_/D }
C {devices/lab_pin.sym} 12800 -4040 0 1 {name=p12728 lab=_49772_/X }
C {sky130_stdcells/and4_4.sym} 12740 -4040 0 0 {name=X_49772_ }
C {devices/lab_pin.sym} 12700 -3890 0 0 {name=p12729 lab=_54478_/B }
C {devices/lab_pin.sym} 12780 -3890 0 1 {name=p12730 lab=_52787_/B }
C {sky130_stdcells/buf_2.sym} 12740 -3890 0 0 {name=X_46984_ }
C {devices/lab_pin.sym} 12680 -3790 0 0 {name=p12731 lab=_48388_/A }
C {devices/lab_pin.sym} 12680 -3750 0 0 {name=p12732 lab=_48099_/X }
C {devices/lab_pin.sym} 12680 -3710 0 0 {name=p12733 lab=_48723_/C }
C {devices/lab_pin.sym} 12800 -3750 0 1 {name=p12734 lab=_48723_/X }
C {sky130_stdcells/and3_4.sym} 12740 -3750 0 0 {name=X_48723_ }
C {devices/lab_pin.sym} 12680 -3620 0 0 {name=p12735 lab=_79543_/A }
C {devices/lab_pin.sym} 12680 -3580 0 0 {name=p12736 lab=_79542_/Y }
C {devices/lab_pin.sym} 12800 -3600 0 1 {name=p12737 lab=_79543_/Y }
C {sky130_stdcells/nor2_4.sym} 12740 -3600 0 0 {name=X_79543_ }
C {devices/lab_pin.sym} 12700 -3470 0 0 {name=p12738 lab=_45935_/A }
C {devices/lab_pin.sym} 12780 -3470 0 1 {name=p12739 lab=_45935_/X }
C {sky130_stdcells/buf_2.sym} 12740 -3470 0 0 {name=X_45935_ }
C {devices/lab_pin.sym} 12660 -3370 0 0 {name=p12740 lab=_41024_/X }
C {devices/lab_pin.sym} 12660 -3330 0 0 {name=p12741 lab=_41228_/A }
C {devices/lab_pin.sym} 12660 -3290 0 0 {name=p12742 lab=_41057_/X }
C {devices/lab_pin.sym} 12820 -3330 0 1 {name=p12743 lab=_41058_/Y }
C {sky130_stdcells/o21ai_4.sym} 12740 -3330 0 0 {name=X_41058_ }
C {devices/lab_pin.sym} 12680 -3200 0 0 {name=p12744 lab=_76755_/A }
C {devices/lab_pin.sym} 12680 -3160 0 0 {name=p12745 lab=_76755_/B }
C {devices/lab_pin.sym} 12800 -3180 0 1 {name=p12746 lab=_76755_/Y }
C {sky130_stdcells/xnor2_4.sym} 12740 -3180 0 0 {name=X_76755_ }
C {devices/lab_pin.sym} 12700 -3050 0 0 {name=p12747 lab=_59807_/A }
C {devices/lab_pin.sym} 12780 -3050 0 1 {name=p12748 lab=_61981_/X }
C {sky130_stdcells/buf_2.sym} 12740 -3050 0 0 {name=X_61981_ }
C {devices/lab_pin.sym} 12660 -2950 0 0 {name=p12749 lab=_73964_/X }
C {devices/lab_pin.sym} 12660 -2910 0 0 {name=p12750 lab=_73966_/X }
C {devices/lab_pin.sym} 12660 -2870 0 0 {name=p12751 lab=_73944_/X }
C {devices/lab_pin.sym} 12820 -2910 0 1 {name=p12752 lab=_73967_/X }
C {sky130_stdcells/a21o_4.sym} 12740 -2910 0 0 {name=X_73967_ }
C {devices/lab_pin.sym} 12700 -2770 0 0 {name=p12753 lab=_60920_/A }
C {devices/lab_pin.sym} 12780 -2770 0 1 {name=p12754 lab=_63721_/C }
C {sky130_stdcells/buf_2.sym} 12740 -2770 0 0 {name=X_63720_ }
C {devices/lab_pin.sym} 12700 -2650 0 0 {name=p12755 lab=_80913_/Q }
C {devices/lab_pin.sym} 12780 -2650 0 1 {name=p12756 lab=_75708_/A }
C {sky130_stdcells/inv_2.sym} 12740 -2650 0 0 {name=X_75706_ }
C {devices/lab_pin.sym} 12680 -2540 0 0 {name=p12757 lab=_72904_/Y }
C {devices/lab_pin.sym} 12680 -2500 0 0 {name=p12758 lab=_72917_/X }
C {devices/lab_pin.sym} 12800 -2520 0 1 {name=p12759 lab=_72918_/Y }
C {sky130_stdcells/xnor2_4.sym} 12740 -2520 0 0 {name=X_72918_ }
C {devices/lab_pin.sym} 12680 -2400 0 0 {name=p12760 lab=_48654_/A }
C {devices/lab_pin.sym} 12680 -2360 0 0 {name=p12761 lab=_48632_/B }
C {devices/lab_pin.sym} 12800 -2380 0 1 {name=p12762 lab=_48654_/Y }
C {sky130_stdcells/nand2_4.sym} 12740 -2380 0 0 {name=X_48654_ }
C {devices/lab_pin.sym} 12660 -2290 0 0 {name=p12763 lab=_60707_/X }
C {devices/lab_pin.sym} 12660 -2250 0 0 {name=p12764 lab=_60913_/Y }
C {devices/lab_pin.sym} 12660 -2210 0 0 {name=p12765 lab=_60988_/A }
C {devices/lab_pin.sym} 12660 -2170 0 0 {name=p12766 lab=_60962_/A }
C {devices/lab_pin.sym} 12660 -2140 0 0 {name=p12767 lab=_60931_/Y }
C {devices/lab_pin.sym} 12820 -2210 0 1 {name=p12768 lab=_60932_/Y }
C {sky130_stdcells/a41oi_4.sym} 12740 -2210 0 0 {name=X_60932_ }
C {devices/lab_pin.sym} 12660 -2070 0 0 {name=p12769 lab=_79466_/X }
C {devices/lab_pin.sym} 12660 -2030 0 0 {name=p12770 lab=_79468_/B }
C {devices/lab_pin.sym} 12660 -1990 0 0 {name=p12771 lab=_79473_/Y }
C {devices/lab_pin.sym} 12820 -2030 0 1 {name=p12772 lab=_79474_/Y }
C {sky130_stdcells/a21boi_4.sym} 12740 -2030 0 0 {name=X_79474_ }
C {devices/lab_pin.sym} 12660 -1910 0 0 {name=p12773 lab=_45859_/X }
C {devices/lab_pin.sym} 12660 -1870 0 0 {name=p12774 lab=_45863_/Y }
C {devices/lab_pin.sym} 12660 -1830 0 0 {name=p12775 lab=_45865_/Y }
C {devices/lab_pin.sym} 12820 -1870 0 1 {name=p12776 lab=_45866_/Y }
C {sky130_stdcells/a21oi_4.sym} 12740 -1870 0 0 {name=X_45866_ }
C {devices/lab_pin.sym} 12680 -1740 0 0 {name=p12777 lab=_76686_/A }
C {devices/lab_pin.sym} 12680 -1700 0 0 {name=p12778 lab=_76969_/A }
C {devices/lab_pin.sym} 12800 -1720 0 1 {name=p12779 lab=_76686_/Y }
C {sky130_stdcells/nor2_4.sym} 12740 -1720 0 0 {name=X_76686_ }
C {devices/lab_pin.sym} 12700 -1590 0 0 {name=p12780 lab=_72861_/X }
C {devices/lab_pin.sym} 12780 -1590 0 1 {name=p12781 lab=_73898_/X }
C {sky130_stdcells/buf_2.sym} 12740 -1590 0 0 {name=X_73898_ }
C {devices/lab_pin.sym} 12700 -1470 0 0 {name=p12782 lab=_81241_/Q }
C {devices/lab_pin.sym} 12780 -1470 0 1 {name=p12783 lab=_55005_/D }
C {sky130_stdcells/inv_2.sym} 12740 -1470 0 0 {name=X_47605_ }
C {devices/lab_pin.sym} 12680 -1380 0 0 {name=p12784 lab=_78369_/A }
C {devices/lab_pin.sym} 12680 -1340 0 0 {name=p12785 lab=_78397_/B }
C {devices/lab_pin.sym} 12680 -1300 0 0 {name=p12786 lab=_78400_/A }
C {devices/lab_pin.sym} 12680 -1260 0 0 {name=p12787 lab=_78413_/Y }
C {devices/lab_pin.sym} 12800 -1320 0 1 {name=p12788 lab=_78425_/Y }
C {sky130_stdcells/nand4_4.sym} 12740 -1320 0 0 {name=X_78425_ }
C {devices/lab_pin.sym} 12700 -1170 0 0 {name=p12789 lab=_43927_/X }
C {devices/lab_pin.sym} 12780 -1170 0 1 {name=p12790 lab=_44817_/X }
C {sky130_stdcells/buf_2.sym} 12740 -1170 0 0 {name=X_44817_ }
C {devices/lab_pin.sym} 12660 -1090 0 0 {name=p12791 lab=_62094_/D }
C {devices/lab_pin.sym} 12660 -1050 0 0 {name=p12792 lab=_60780_/X }
C {devices/lab_pin.sym} 12660 -1010 0 0 {name=p12793 lab=_63357_/X }
C {devices/lab_pin.sym} 12660 -970 0 0 {name=p12794 lab=_60767_/X }
C {devices/lab_pin.sym} 12660 -930 0 0 {name=p12795 lab=_63650_/Y }
C {devices/lab_pin.sym} 12820 -1010 0 1 {name=p12796 lab=_63651_/X }
C {sky130_stdcells/a2111o_4.sym} 12740 -1010 0 0 {name=X_63651_ }
C {devices/lab_pin.sym} 12680 -860 0 0 {name=p12797 lab=_75637_/A }
C {devices/lab_pin.sym} 12680 -820 0 0 {name=p12798 lab=_80826_/Q }
C {devices/lab_pin.sym} 12800 -840 0 1 {name=p12799 lab=_75637_/Y }
C {sky130_stdcells/xnor2_4.sym} 12740 -840 0 0 {name=X_75637_ }
C {devices/lab_pin.sym} 12700 -710 0 0 {name=p12800 lab=_48651_/A }
C {devices/lab_pin.sym} 12780 -710 0 1 {name=p12801 lab=_48585_/X }
C {sky130_stdcells/buf_2.sym} 12740 -710 0 0 {name=X_48585_ }
C {devices/lab_pin.sym} 13620 -42150 0 0 {name=p12802 lab=_60863_/A }
C {devices/lab_pin.sym} 13700 -42150 0 1 {name=p12803 lab=_60863_/X }
C {sky130_stdcells/buf_2.sym} 13660 -42150 0 0 {name=X_60863_ }
C {devices/lab_pin.sym} 13580 -42050 0 0 {name=p12804 lab=_72847_/X }
C {devices/lab_pin.sym} 13580 -42010 0 0 {name=p12805 lab=_72848_/Y }
C {devices/lab_pin.sym} 13580 -41970 0 0 {name=p12806 lab=_72766_/X }
C {devices/lab_pin.sym} 13740 -42010 0 1 {name=p12807 lab=_72849_/Y }
C {sky130_stdcells/a21oi_4.sym} 13660 -42010 0 0 {name=X_72849_ }
C {devices/lab_pin.sym} 13580 -41890 0 0 {name=p12808 lab=_45794_/X }
C {devices/lab_pin.sym} 13580 -41850 0 0 {name=p12809 lab=_45796_/Y }
C {devices/lab_pin.sym} 13580 -41810 0 0 {name=p12810 lab=_45757_/X }
C {devices/lab_pin.sym} 13740 -41850 0 1 {name=p12811 lab=_45797_/X }
C {sky130_stdcells/a21o_4.sym} 13660 -41850 0 0 {name=X_45797_ }
C {devices/lab_pin.sym} 13580 -41750 0 0 {name=p12812 lab=_61663_/B }
C {devices/lab_pin.sym} 13580 -41710 0 0 {name=p12813 lab=_62548_/C }
C {devices/lab_pin.sym} 13580 -41670 0 0 {name=p12814 lab=_62507_/X }
C {devices/lab_pin.sym} 13580 -41630 0 0 {name=p12815 lab=_62548_/B }
C {devices/lab_pin.sym} 13580 -41600 0 0 {name=p12816 lab=_62601_/X }
C {devices/lab_pin.sym} 13740 -41670 0 1 {name=p12817 lab=_62602_/X }
C {sky130_stdcells/a41o_4.sym} 13660 -41670 0 0 {name=X_62602_ }
C {devices/lab_pin.sym} 13620 -41510 0 0 {name=p12818 lab=_47536_/A }
C {devices/lab_pin.sym} 13700 -41510 0 1 {name=p12819 lab=_53105_/B }
C {sky130_stdcells/buf_2.sym} 13660 -41510 0 0 {name=X_47536_ }
C {devices/lab_pin.sym} 13580 -41410 0 0 {name=p12820 lab=_66368_/Y }
C {devices/lab_pin.sym} 13580 -41370 0 0 {name=p12821 lab=_66343_/X }
C {devices/lab_pin.sym} 13580 -41330 0 0 {name=p12822 lab=_66369_/X }
C {devices/lab_pin.sym} 13740 -41370 0 1 {name=p12823 lab=_84136_/D }
C {sky130_stdcells/a21o_4.sym} 13660 -41370 0 0 {name=X_66370_ }
C {devices/lab_pin.sym} 13600 -41240 0 0 {name=p12824 lab=_78356_/A }
C {devices/lab_pin.sym} 13600 -41200 0 0 {name=p12825 lab=_78356_/B }
C {devices/lab_pin.sym} 13720 -41220 0 1 {name=p12826 lab=_82469_/D }
C {sky130_stdcells/xnor2_4.sym} 13660 -41220 0 0 {name=X_78356_ }
C {devices/lab_pin.sym} 13580 -41130 0 0 {name=p12827 lab=_49210_/A }
C {devices/lab_pin.sym} 13580 -41090 0 0 {name=p12828 lab=_50731_/B }
C {devices/lab_pin.sym} 13580 -41050 0 0 {name=p12829 lab=_40753_/A }
C {devices/lab_pin.sym} 13580 -41010 0 0 {name=p12830 lab=_44747_/Y }
C {devices/lab_pin.sym} 13580 -40970 0 0 {name=p12831 lab=_44736_/X }
C {devices/lab_pin.sym} 13740 -41050 0 1 {name=p12832 lab=_86977_/D }
C {sky130_stdcells/o32ai_4.sym} 13660 -41050 0 0 {name=X_44748_ }
C {devices/lab_pin.sym} 13620 -40890 0 0 {name=p12833 lab=_75568_/A }
C {devices/lab_pin.sym} 13700 -40890 0 1 {name=p12834 lab=_75570_/A }
C {sky130_stdcells/inv_2.sym} 13660 -40890 0 0 {name=X_75568_ }
C {devices/lab_pin.sym} 13600 -40800 0 0 {name=p12835 lab=_63546_/A }
C {devices/lab_pin.sym} 13600 -40760 0 0 {name=p12836 lab=_58478_/A }
C {devices/lab_pin.sym} 13600 -40720 0 0 {name=p12837 lab=_63581_/X }
C {devices/lab_pin.sym} 13600 -40680 0 0 {name=p12838 lab=_63546_/D }
C {devices/lab_pin.sym} 13720 -40740 0 1 {name=p12839 lab=_63582_/X }
C {sky130_stdcells/and4_4.sym} 13660 -40740 0 0 {name=X_63582_ }
C {devices/lab_pin.sym} 13580 -40630 0 0 {name=p12840 lab=_60736_/X }
C {devices/lab_pin.sym} 13580 -40590 0 0 {name=p12841 lab=_60711_/X }
C {devices/lab_pin.sym} 13580 -40550 0 0 {name=p12842 lab=_60725_/A }
C {devices/lab_pin.sym} 13580 -40510 0 0 {name=p12843 lab=_60697_/B }
C {devices/lab_pin.sym} 13580 -40480 0 0 {name=p12844 lab=_60528_/A }
C {devices/lab_pin.sym} 13740 -40550 0 1 {name=p12845 lab=_60794_/Y }
C {sky130_stdcells/a41oi_4.sym} 13660 -40550 0 0 {name=X_60794_ }
C {devices/lab_pin.sym} 13600 -40410 0 0 {name=p12846 lab=_65317_/X }
C {devices/lab_pin.sym} 13600 -40370 0 0 {name=p12847 lab=_66423_/B }
C {devices/lab_pin.sym} 13600 -40330 0 0 {name=p12848 lab=_65320_/X }
C {devices/lab_pin.sym} 13720 -40370 0 1 {name=p12849 lab=_65321_/Y }
C {sky130_stdcells/nand3_4.sym} 13660 -40370 0 0 {name=X_65321_ }
C {devices/lab_pin.sym} 13620 -40230 0 0 {name=p12850 lab=_77307_/A }
C {devices/lab_pin.sym} 13700 -40230 0 1 {name=p12851 lab=_77307_/Y }
C {sky130_stdcells/inv_2.sym} 13660 -40230 0 0 {name=X_77307_ }
C {devices/lab_pin.sym} 13580 -40130 0 0 {name=p12852 lab=_52794_/B }
C {devices/lab_pin.sym} 13580 -40090 0 0 {name=p12853 lab=_74517_/X }
C {devices/lab_pin.sym} 13580 -40050 0 0 {name=p12854 lab=_74518_/Y }
C {devices/lab_pin.sym} 13740 -40090 0 1 {name=p12855 lab=_74519_/Y }
C {sky130_stdcells/o21ai_4.sym} 13660 -40090 0 0 {name=X_74519_ }
C {devices/lab_pin.sym} 13600 -39970 0 0 {name=p12856 lab=_62533_/A }
C {devices/lab_pin.sym} 13600 -39930 0 0 {name=p12857 lab=_58495_/A }
C {devices/lab_pin.sym} 13600 -39890 0 0 {name=p12858 lab=_62532_/X }
C {devices/lab_pin.sym} 13720 -39930 0 1 {name=p12859 lab=_62536_/C }
C {sky130_stdcells/nand3_4.sym} 13660 -39930 0 0 {name=X_62533_ }
C {devices/lab_pin.sym} 13580 -39810 0 0 {name=p12860 lab=_47461_/Y }
C {devices/lab_pin.sym} 13580 -39770 0 0 {name=p12861 lab=_47462_/X }
C {devices/lab_pin.sym} 13580 -39730 0 0 {name=p12862 lab=_47466_/X }
C {devices/lab_pin.sym} 13740 -39770 0 1 {name=p12863 lab=_47467_/Y }
C {sky130_stdcells/a21oi_4.sym} 13660 -39770 0 0 {name=X_47467_ }
C {devices/lab_pin.sym} 13600 -39640 0 0 {name=p12864 lab=_82686_/Q }
C {devices/lab_pin.sym} 13600 -39600 0 0 {name=p12865 lab=_78287_/B }
C {devices/lab_pin.sym} 13720 -39620 0 1 {name=p12866 lab=_78287_/X }
C {sky130_stdcells/xor2_4.sym} 13660 -39620 0 0 {name=X_78287_ }
C {devices/lab_pin.sym} 13620 -39490 0 0 {name=p12867 lab=_44679_/A }
C {devices/lab_pin.sym} 13700 -39490 0 1 {name=p12868 lab=_44679_/X }
C {sky130_stdcells/buf_2.sym} 13660 -39490 0 0 {name=X_44679_ }
C {devices/lab_pin.sym} 13580 -39390 0 0 {name=p12869 lab=_75495_/Y }
C {devices/lab_pin.sym} 13580 -39350 0 0 {name=p12870 lab=_75497_/Y }
C {devices/lab_pin.sym} 13580 -39310 0 0 {name=p12871 lab=_75498_/A }
C {devices/lab_pin.sym} 13740 -39350 0 1 {name=p12872 lab=_75503_/C }
C {sky130_stdcells/o21ai_4.sym} 13660 -39350 0 0 {name=X_75499_ }
C {devices/lab_pin.sym} 13620 -39210 0 0 {name=p12873 lab=_46242_/Y }
C {devices/lab_pin.sym} 13700 -39210 0 1 {name=p12874 lab=_51235_/B }
C {sky130_stdcells/buf_2.sym} 13660 -39210 0 0 {name=X_49206_ }
C {devices/lab_pin.sym} 13620 -39090 0 0 {name=p12875 lab=_68120_/A }
C {devices/lab_pin.sym} 13700 -39090 0 1 {name=p12876 lab=_68040_/X }
C {sky130_stdcells/buf_2.sym} 13660 -39090 0 0 {name=X_68040_ }
C {devices/lab_pin.sym} 13580 -38990 0 0 {name=p12877 lab=_46413_/Y }
C {devices/lab_pin.sym} 13580 -38950 0 0 {name=p12878 lab=_46399_/X }
C {devices/lab_pin.sym} 13580 -38910 0 0 {name=p12879 lab=_46417_/Y }
C {devices/lab_pin.sym} 13740 -38950 0 1 {name=p12880 lab=_46418_/Y }
C {sky130_stdcells/a21boi_4.sym} 13660 -38950 0 0 {name=X_46418_ }
C {devices/lab_pin.sym} 13620 -38810 0 0 {name=p12881 lab=_64797_/A }
C {devices/lab_pin.sym} 13700 -38810 0 1 {name=p12882 lab=_65252_/X }
C {sky130_stdcells/buf_2.sym} 13660 -38810 0 0 {name=X_65252_ }
C {devices/lab_pin.sym} 13580 -38710 0 0 {name=p12883 lab=_77239_/A }
C {devices/lab_pin.sym} 13580 -38670 0 0 {name=p12884 lab=_77239_/C }
C {devices/lab_pin.sym} 13580 -38630 0 0 {name=p12885 lab=_77239_/B }
C {devices/lab_pin.sym} 13740 -38670 0 1 {name=p12886 lab=_77245_/A }
C {sky130_stdcells/a21o_4.sym} 13660 -38670 0 0 {name=X_77238_ }
C {devices/lab_pin.sym} 13600 -38560 0 0 {name=p12887 lab=_62479_/A }
C {devices/lab_pin.sym} 13600 -38520 0 0 {name=p12888 lab=_61997_/X }
C {devices/lab_pin.sym} 13600 -38480 0 0 {name=p12889 lab=_62479_/C }
C {devices/lab_pin.sym} 13600 -38440 0 0 {name=p12890 lab=_62463_/X }
C {devices/lab_pin.sym} 13720 -38500 0 1 {name=p12891 lab=_62464_/X }
C {sky130_stdcells/and4_4.sym} 13660 -38500 0 0 {name=X_62464_ }
C {devices/lab_pin.sym} 13620 -38350 0 0 {name=p12892 lab=_81807_/Q }
C {devices/lab_pin.sym} 13700 -38350 0 1 {name=p12893 lab=_47399_/A }
C {sky130_stdcells/inv_2.sym} 13660 -38350 0 0 {name=X_47398_ }
C {devices/lab_pin.sym} 13600 -38260 0 0 {name=p12894 lab=_59716_/A }
C {devices/lab_pin.sym} 13600 -38220 0 0 {name=p12895 lab=_64203_/B }
C {devices/lab_pin.sym} 13600 -38180 0 0 {name=p12896 lab=_72625_/A }
C {devices/lab_pin.sym} 13600 -38140 0 0 {name=p12897 lab=_64421_/A }
C {devices/lab_pin.sym} 13720 -38200 0 1 {name=p12898 lab=_64440_/A }
C {sky130_stdcells/nand4_4.sym} 13660 -38200 0 0 {name=X_64203_ }
C {devices/lab_pin.sym} 13600 -38070 0 0 {name=p12899 lab=_61434_/A }
C {devices/lab_pin.sym} 13600 -38030 0 0 {name=p12900 lab=_61434_/B }
C {devices/lab_pin.sym} 13600 -37990 0 0 {name=p12901 lab=_79151_/B }
C {devices/lab_pin.sym} 13720 -38030 0 1 {name=p12902 lab=_61415_/Y }
C {sky130_stdcells/nor3_4.sym} 13660 -38030 0 0 {name=X_61415_ }
C {devices/lab_pin.sym} 13580 -37910 0 0 {name=p12903 lab=_65253_/B }
C {devices/lab_pin.sym} 13580 -37870 0 0 {name=p12904 lab=_49104_/X }
C {devices/lab_pin.sym} 13580 -37830 0 0 {name=p12905 lab=_49136_/Y }
C {devices/lab_pin.sym} 13740 -37870 0 1 {name=p12906 lab=_49137_/Y }
C {sky130_stdcells/o21ai_4.sym} 13660 -37870 0 0 {name=X_49137_ }
C {devices/lab_pin.sym} 13620 -37730 0 0 {name=p12907 lab=_46349_/A }
C {devices/lab_pin.sym} 13700 -37730 0 1 {name=p12908 lab=_46380_/B }
C {sky130_stdcells/buf_2.sym} 13660 -37730 0 0 {name=X_46349_ }
C {devices/lab_pin.sym} 13620 -37610 0 0 {name=p12909 lab=_64903_/A }
C {devices/lab_pin.sym} 13700 -37610 0 1 {name=p12910 lab=_65184_/A }
C {sky130_stdcells/buf_2.sym} 13660 -37610 0 0 {name=X_65183_ }
C {devices/lab_pin.sym} 13600 -37500 0 0 {name=p12911 lab=_77170_/A }
C {devices/lab_pin.sym} 13600 -37460 0 0 {name=p12912 lab=_77170_/B }
C {devices/lab_pin.sym} 13720 -37480 0 1 {name=p12913 lab=_77172_/A }
C {sky130_stdcells/nor2_4.sym} 13660 -37480 0 0 {name=X_77169_ }
C {devices/lab_pin.sym} 13620 -37350 0 0 {name=p12914 lab=_61348_/A }
C {devices/lab_pin.sym} 13700 -37350 0 1 {name=p12915 lab=_62395_/X }
C {sky130_stdcells/buf_2.sym} 13660 -37350 0 0 {name=X_62395_ }
C {devices/lab_pin.sym} 13580 -37260 0 0 {name=p12916 lab=_62577_/Y }
C {devices/lab_pin.sym} 13580 -37220 0 0 {name=p12917 lab=_60879_/Y }
C {devices/lab_pin.sym} 13580 -37180 0 0 {name=p12918 lab=_62124_/B }
C {devices/lab_pin.sym} 13580 -37140 0 0 {name=p12919 lab=_61028_/X }
C {devices/lab_pin.sym} 13740 -37200 0 1 {name=p12920 lab=_64134_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 13660 -37200 0 0 {name=X_64134_ }
C {devices/lab_pin.sym} 13580 -37070 0 0 {name=p12921 lab=_48606_/X }
C {devices/lab_pin.sym} 13580 -37030 0 0 {name=p12922 lab=_81199_/Q }
C {devices/lab_pin.sym} 13580 -36990 0 0 {name=p12923 lab=_49067_/Y }
C {devices/lab_pin.sym} 13740 -37030 0 1 {name=p12924 lab=_49069_/A }
C {sky130_stdcells/o21ai_4.sym} 13660 -37030 0 0 {name=X_49068_ }
C {devices/lab_pin.sym} 13580 -36930 0 0 {name=p12925 lab=_61329_/Y }
C {devices/lab_pin.sym} 13580 -36890 0 0 {name=p12926 lab=_61332_/Y }
C {devices/lab_pin.sym} 13580 -36850 0 0 {name=p12927 lab=_61334_/X }
C {devices/lab_pin.sym} 13580 -36810 0 0 {name=p12928 lab=_61338_/Y }
C {devices/lab_pin.sym} 13580 -36780 0 0 {name=p12929 lab=_61345_/Y }
C {devices/lab_pin.sym} 13740 -36850 0 1 {name=p12930 lab=_61346_/X }
C {sky130_stdcells/a41o_4.sym} 13660 -36850 0 0 {name=X_61346_ }
C {devices/lab_pin.sym} 13580 -36710 0 0 {name=p12931 lab=_80164_/Y }
C {devices/lab_pin.sym} 13580 -36670 0 0 {name=p12932 lab=_80167_/Y }
C {devices/lab_pin.sym} 13580 -36630 0 0 {name=p12933 lab=_80179_/X }
C {devices/lab_pin.sym} 13740 -36670 0 1 {name=p12934 lab=_80180_/X }
C {sky130_stdcells/a21o_4.sym} 13660 -36670 0 0 {name=X_80180_ }
C {devices/lab_pin.sym} 13580 -36550 0 0 {name=p12935 lab=_82558_/D }
C {devices/lab_pin.sym} 13580 -36510 0 0 {name=p12936 lab=_69988_/X }
C {devices/lab_pin.sym} 13580 -36470 0 0 {name=p12937 lab=_69990_/X }
C {devices/lab_pin.sym} 13740 -36510 0 1 {name=p12938 lab=_83878_/D }
C {sky130_stdcells/a21bo_4.sym} 13660 -36510 0 0 {name=X_69991_ }
C {devices/lab_pin.sym} 13580 -36390 0 0 {name=p12939 lab=_47971_/X }
C {devices/lab_pin.sym} 13580 -36350 0 0 {name=p12940 lab=_82928_/Q }
C {devices/lab_pin.sym} 13580 -36310 0 0 {name=p12941 lab=_48018_/X }
C {devices/lab_pin.sym} 13740 -36350 0 1 {name=p12942 lab=_48020_/B }
C {sky130_stdcells/o21ai_4.sym} 13660 -36350 0 0 {name=X_48019_ }
C {devices/lab_pin.sym} 13580 -36240 0 0 {name=p12943 lab=_87996_/Q }
C {devices/lab_pin.sym} 13580 -36200 0 0 {name=p12944 lab=_68895_/X }
C {devices/lab_pin.sym} 13580 -36160 0 0 {name=p12945 lab=_68916_/X }
C {devices/lab_pin.sym} 13580 -36120 0 0 {name=p12946 lab=_68941_/X }
C {devices/lab_pin.sym} 13740 -36180 0 1 {name=p12947 lab=_68942_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -36180 0 0 {name=X_68942_ }
C {devices/lab_pin.sym} 13620 -36030 0 0 {name=p12948 lab=_60909_/X }
C {devices/lab_pin.sym} 13700 -36030 0 1 {name=p12949 lab=_64095_/C }
C {sky130_stdcells/buf_2.sym} 13660 -36030 0 0 {name=X_64065_ }
C {devices/lab_pin.sym} 13600 -35930 0 0 {name=p12950 lab=_59545_/A }
C {devices/lab_pin.sym} 13600 -35890 0 0 {name=p12951 lab=_61277_/B }
C {devices/lab_pin.sym} 13600 -35850 0 0 {name=p12952 lab=_61277_/C }
C {devices/lab_pin.sym} 13720 -35890 0 1 {name=p12953 lab=_61281_/C }
C {sky130_stdcells/nor3_4.sym} 13660 -35890 0 0 {name=X_61277_ }
C {devices/lab_pin.sym} 13580 -35770 0 0 {name=p12954 lab=_51027_/Y }
C {devices/lab_pin.sym} 13580 -35730 0 0 {name=p12955 lab=_51011_/X }
C {devices/lab_pin.sym} 13580 -35690 0 0 {name=p12956 lab=_51029_/X }
C {devices/lab_pin.sym} 13740 -35730 0 1 {name=p12957 lab=_51030_/Y }
C {sky130_stdcells/a21oi_4.sym} 13660 -35730 0 0 {name=X_51030_ }
C {devices/lab_pin.sym} 13620 -35590 0 0 {name=p12958 lab=_63342_/C }
C {devices/lab_pin.sym} 13700 -35590 0 1 {name=p12959 lab=_63030_/C }
C {sky130_stdcells/buf_2.sym} 13660 -35590 0 0 {name=X_63016_ }
C {devices/lab_pin.sym} 13620 -35470 0 0 {name=p12960 lab=_60228_/A }
C {devices/lab_pin.sym} 13700 -35470 0 1 {name=p12961 lab=_60331_/D }
C {sky130_stdcells/buf_2.sym} 13660 -35470 0 0 {name=X_60228_ }
C {devices/lab_pin.sym} 13580 -35380 0 0 {name=p12962 lab=_87487_/Q }
C {devices/lab_pin.sym} 13580 -35340 0 0 {name=p12963 lab=_68870_/X }
C {devices/lab_pin.sym} 13580 -35300 0 0 {name=p12964 lab=_68871_/X }
C {devices/lab_pin.sym} 13580 -35260 0 0 {name=p12965 lab=_68872_/X }
C {devices/lab_pin.sym} 13740 -35320 0 1 {name=p12966 lab=_68873_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -35320 0 0 {name=X_68873_ }
C {devices/lab_pin.sym} 13620 -35170 0 0 {name=p12967 lab=clkbuf_9_241_0_CLK/X }
C {devices/lab_pin.sym} 13700 -35170 0 1 {name=p12968 lab=_85962_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 13660 -35170 0 0 {name=Xclkbuf_10_483_0_CLK }
C {devices/lab_pin.sym} 13580 -35070 0 0 {name=p12969 lab=_67819_/X }
C {devices/lab_pin.sym} 13580 -35030 0 0 {name=p12970 lab=_67823_/X }
C {devices/lab_pin.sym} 13580 -34990 0 0 {name=p12971 lab=_67799_/X }
C {devices/lab_pin.sym} 13740 -35030 0 1 {name=p12972 lab=_67824_/X }
C {sky130_stdcells/a21o_4.sym} 13660 -35030 0 0 {name=X_67824_ }
C {devices/lab_pin.sym} 13620 -34890 0 0 {name=p12973 lab=_60159_/A }
C {devices/lab_pin.sym} 13700 -34890 0 1 {name=p12974 lab=_60263_/A }
C {sky130_stdcells/buf_2.sym} 13660 -34890 0 0 {name=X_60159_ }
C {devices/lab_pin.sym} 13570 -34770 0 0 {name=p12975 lab=_82369_/CLK }
C {devices/lab_pin.sym} 13570 -34750 0 0 {name=p12976 lab=_83870_/D }
C {devices/lab_pin.sym} 13750 -34770 0 1 {name=p12977 lab=_82550_/D }
C {sky130_stdcells/dfxtp_4.sym} 13660 -34760 0 0 {name=X_83870_ }
C {devices/lab_pin.sym} 13570 -34630 0 0 {name=p12978 lab=_82822_/CLK }
C {devices/lab_pin.sym} 13570 -34610 0 0 {name=p12979 lab=_82821_/D }
C {devices/lab_pin.sym} 13750 -34630 0 1 {name=p12980 lab=_82821_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -34620 0 0 {name=X_82821_ }
C {devices/lab_pin.sym} 13620 -34490 0 0 {name=p12981 lab=_68370_/A }
C {devices/lab_pin.sym} 13700 -34490 0 1 {name=p12982 lab=_67755_/X }
C {sky130_stdcells/buf_2.sym} 13660 -34490 0 0 {name=X_67755_ }
C {devices/lab_pin.sym} 13620 -34370 0 0 {name=p12983 lab=_53062_/A }
C {devices/lab_pin.sym} 13700 -34370 0 1 {name=p12984 lab=_52997_/C }
C {sky130_stdcells/buf_2.sym} 13660 -34370 0 0 {name=X_52981_ }
C {devices/lab_pin.sym} 13620 -34250 0 0 {name=p12985 lab=_64961_/A }
C {devices/lab_pin.sym} 13700 -34250 0 1 {name=p12986 lab=_64967_/X }
C {sky130_stdcells/buf_2.sym} 13660 -34250 0 0 {name=X_64967_ }
C {devices/lab_pin.sym} 13620 -34130 0 0 {name=p12987 lab=_54693_/X }
C {devices/lab_pin.sym} 13700 -34130 0 1 {name=p12988 lab=_54720_/X }
C {sky130_stdcells/buf_2.sym} 13660 -34130 0 0 {name=X_54720_ }
C {devices/lab_pin.sym} 13620 -34010 0 0 {name=p12989 lab=_66410_/A }
C {devices/lab_pin.sym} 13700 -34010 0 1 {name=p12990 lab=_66706_/X }
C {sky130_stdcells/buf_2.sym} 13660 -34010 0 0 {name=X_66706_ }
C {devices/lab_pin.sym} 13570 -33890 0 0 {name=p12991 lab=_86149_/CLK }
C {devices/lab_pin.sym} 13570 -33870 0 0 {name=p12992 lab=_53931_/Y }
C {devices/lab_pin.sym} 13750 -33890 0 1 {name=p12993 lab=_85540_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -33880 0 0 {name=X_85540_ }
C {devices/lab_pin.sym} 13600 -33760 0 0 {name=p12994 lab=_53259_/A }
C {devices/lab_pin.sym} 13600 -33720 0 0 {name=p12995 lab=_50224_/B }
C {devices/lab_pin.sym} 13720 -33740 0 1 {name=p12996 lab=_51932_/Y }
C {sky130_stdcells/nand2_4.sym} 13660 -33740 0 0 {name=X_51932_ }
C {devices/lab_pin.sym} 13600 -33640 0 0 {name=p12997 lab=_63496_/B }
C {devices/lab_pin.sym} 13600 -33600 0 0 {name=p12998 lab=_63900_/B }
C {devices/lab_pin.sym} 13600 -33560 0 0 {name=p12999 lab=_63949_/C }
C {devices/lab_pin.sym} 13600 -33520 0 0 {name=p13000 lab=_63900_/D }
C {devices/lab_pin.sym} 13720 -33580 0 1 {name=p13001 lab=_63922_/B }
C {sky130_stdcells/nand4_4.sym} 13660 -33580 0 0 {name=X_63918_ }
C {devices/lab_pin.sym} 13570 -33430 0 0 {name=p13002 lab=_81019_/CLK }
C {devices/lab_pin.sym} 13570 -33410 0 0 {name=p13003 lab=_84136_/Q }
C {devices/lab_pin.sym} 13750 -33430 0 1 {name=p13004 lab=_82752_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -33420 0 0 {name=X_82752_ }
C {devices/lab_pin.sym} 13580 -33320 0 0 {name=p13005 lab=_67664_/X }
C {devices/lab_pin.sym} 13580 -33280 0 0 {name=p13006 lab=_67674_/Y }
C {devices/lab_pin.sym} 13580 -33240 0 0 {name=p13007 lab=_67624_/X }
C {devices/lab_pin.sym} 13580 -33200 0 0 {name=p13008 lab=_67685_/Y }
C {devices/lab_pin.sym} 13740 -33260 0 1 {name=p13009 lab=_67686_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -33260 0 0 {name=X_67686_ }
C {devices/lab_pin.sym} 13620 -33110 0 0 {name=p13010 lab=clkbuf_9_249_0_CLK/X }
C {devices/lab_pin.sym} 13700 -33110 0 1 {name=p13011 lab=_86711_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 13660 -33110 0 0 {name=Xclkbuf_10_498_0_CLK }
C {devices/lab_pin.sym} 13620 -32990 0 0 {name=p13012 lab=_64898_/A }
C {devices/lab_pin.sym} 13700 -32990 0 1 {name=p13013 lab=_65319_/A }
C {sky130_stdcells/buf_2.sym} 13660 -32990 0 0 {name=X_64898_ }
C {devices/lab_pin.sym} 13570 -32870 0 0 {name=p13014 lab=_81703_/CLK }
C {devices/lab_pin.sym} 13570 -32850 0 0 {name=p13015 lab=_75957_/A }
C {devices/lab_pin.sym} 13750 -32870 0 1 {name=p13016 lab=_81703_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -32860 0 0 {name=X_81703_ }
C {devices/lab_pin.sym} 13600 -32740 0 0 {name=p13017 lab=_69302_/A }
C {devices/lab_pin.sym} 13600 -32700 0 0 {name=p13018 lab=_87774_/Q }
C {devices/lab_pin.sym} 13720 -32720 0 1 {name=p13019 lab=_69425_/X }
C {sky130_stdcells/and2_4.sym} 13660 -32720 0 0 {name=X_69425_ }
C {devices/lab_pin.sym} 13580 -32610 0 0 {name=p13020 lab=_85403_/Q }
C {devices/lab_pin.sym} 13580 -32570 0 0 {name=p13021 lab=_54648_/X }
C {devices/lab_pin.sym} 13580 -32530 0 0 {name=p13022 lab=_54650_/Y }
C {devices/lab_pin.sym} 13740 -32570 0 1 {name=p13023 lab=_54651_/Y }
C {sky130_stdcells/o21ai_4.sym} 13660 -32570 0 0 {name=X_54651_ }
C {devices/lab_pin.sym} 13580 -32460 0 0 {name=p13024 lab=_66499_/B }
C {devices/lab_pin.sym} 13580 -32420 0 0 {name=p13025 lab=_66623_/Y }
C {devices/lab_pin.sym} 13580 -32380 0 0 {name=p13026 lab=_59782_/X }
C {devices/lab_pin.sym} 13580 -32340 0 0 {name=p13027 lab=_66636_/Y }
C {devices/lab_pin.sym} 13740 -32400 0 1 {name=p13028 lab=_66637_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -32400 0 0 {name=X_66637_ }
C {devices/lab_pin.sym} 13570 -32250 0 0 {name=p13029 lab=_85471_/CLK }
C {devices/lab_pin.sym} 13570 -32230 0 0 {name=p13030 lab=_54280_/Y }
C {devices/lab_pin.sym} 13750 -32250 0 1 {name=p13031 lab=_85471_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -32240 0 0 {name=X_85471_ }
C {devices/lab_pin.sym} 13580 -32130 0 0 {name=p13032 lab=_85932_/Q }
C {devices/lab_pin.sym} 13580 -32090 0 0 {name=p13033 lab=_51846_/X }
C {devices/lab_pin.sym} 13580 -32050 0 0 {name=p13034 lab=_51862_/Y }
C {devices/lab_pin.sym} 13740 -32090 0 1 {name=p13035 lab=_51863_/Y }
C {sky130_stdcells/o21ai_4.sym} 13660 -32090 0 0 {name=X_51863_ }
C {devices/lab_pin.sym} 13620 -31950 0 0 {name=p13036 lab=_63849_/A }
C {devices/lab_pin.sym} 13700 -31950 0 1 {name=p13037 lab=_63849_/X }
C {sky130_stdcells/buf_2.sym} 13660 -31950 0 0 {name=X_63849_ }
C {devices/lab_pin.sym} 13570 -31830 0 0 {name=p13038 lab=_82931_/CLK }
C {devices/lab_pin.sym} 13570 -31810 0 0 {name=p13039 lab=_78680_/B }
C {devices/lab_pin.sym} 13750 -31830 0 1 {name=p13040 lab=_82683_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -31820 0 0 {name=X_82683_ }
C {devices/lab_pin.sym} 13570 -31690 0 0 {name=p13041 lab=_87210_/CLK }
C {devices/lab_pin.sym} 13570 -31670 0 0 {name=p13042 lab=_87210_/D }
C {devices/lab_pin.sym} 13750 -31690 0 1 {name=p13043 lab=_87210_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -31680 0 0 {name=X_87210_ }
C {devices/lab_pin.sym} 13580 -31570 0 0 {name=p13044 lab=_85604_/Q }
C {devices/lab_pin.sym} 13580 -31530 0 0 {name=p13045 lab=_53586_/X }
C {devices/lab_pin.sym} 13580 -31490 0 0 {name=p13046 lab=_53601_/Y }
C {devices/lab_pin.sym} 13740 -31530 0 1 {name=p13047 lab=_53602_/Y }
C {sky130_stdcells/o21ai_4.sym} 13660 -31530 0 0 {name=X_53602_ }
C {devices/lab_pin.sym} 13570 -31390 0 0 {name=p13048 lab=_84538_/CLK }
C {devices/lab_pin.sym} 13570 -31370 0 0 {name=p13049 lab=_84422_/D }
C {devices/lab_pin.sym} 13750 -31390 0 1 {name=p13050 lab=_76998_/B }
C {sky130_stdcells/dfxtp_4.sym} 13660 -31380 0 0 {name=X_84422_ }
C {devices/lab_pin.sym} 13600 -31260 0 0 {name=p13051 lab=_50806_/A }
C {devices/lab_pin.sym} 13600 -31220 0 0 {name=p13052 lab=_51324_/B }
C {devices/lab_pin.sym} 13720 -31240 0 1 {name=p13053 lab=_50814_/Y }
C {sky130_stdcells/nand2_4.sym} 13660 -31240 0 0 {name=X_50814_ }
C {devices/lab_pin.sym} 13580 -31130 0 0 {name=p13054 lab=_57236_/X }
C {devices/lab_pin.sym} 13580 -31090 0 0 {name=p13055 lab=_57083_/X }
C {devices/lab_pin.sym} 13580 -31050 0 0 {name=p13056 lab=_57369_/Y }
C {devices/lab_pin.sym} 13740 -31090 0 1 {name=p13057 lab=_57370_/X }
C {sky130_stdcells/o21a_4.sym} 13660 -31090 0 0 {name=X_57370_ }
C {devices/lab_pin.sym} 13570 -30950 0 0 {name=p13058 lab=_83914_/CLK }
C {devices/lab_pin.sym} 13570 -30930 0 0 {name=p13059 lab=_81666_/Q }
C {devices/lab_pin.sym} 13750 -30950 0 1 {name=p13060 lab=_81634_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -30940 0 0 {name=X_81634_ }
C {devices/lab_pin.sym} 13620 -30810 0 0 {name=p13061 lab=_69607_/A }
C {devices/lab_pin.sym} 13700 -30810 0 1 {name=p13062 lab=_69356_/X }
C {sky130_stdcells/buf_2.sym} 13660 -30810 0 0 {name=X_69356_ }
C {devices/lab_pin.sym} 13570 -30690 0 0 {name=p13063 lab=_87116_/CLK }
C {devices/lab_pin.sym} 13570 -30670 0 0 {name=p13064 lab=_88190_/D }
C {devices/lab_pin.sym} 13750 -30690 0 1 {name=p13065 lab=_67087_/B }
C {sky130_stdcells/dfxtp_4.sym} 13660 -30680 0 0 {name=X_88190_ }
C {devices/lab_pin.sym} 13600 -30560 0 0 {name=p13066 lab=_54578_/A }
C {devices/lab_pin.sym} 13600 -30520 0 0 {name=p13067 lab=_47165_/Y }
C {devices/lab_pin.sym} 13720 -30540 0 1 {name=p13068 lab=_54582_/Y }
C {sky130_stdcells/nand2_4.sym} 13660 -30540 0 0 {name=X_54582_ }
C {devices/lab_pin.sym} 13580 -30440 0 0 {name=p13069 lab=_87891_/Q }
C {devices/lab_pin.sym} 13580 -30400 0 0 {name=p13070 lab=_66562_/X }
C {devices/lab_pin.sym} 13580 -30360 0 0 {name=p13071 lab=_66564_/X }
C {devices/lab_pin.sym} 13580 -30320 0 0 {name=p13072 lab=_66567_/X }
C {devices/lab_pin.sym} 13740 -30380 0 1 {name=p13073 lab=_66568_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -30380 0 0 {name=X_66568_ }
C {devices/lab_pin.sym} 13600 -30260 0 0 {name=p13074 lab=_51794_/A }
C {devices/lab_pin.sym} 13600 -30220 0 0 {name=p13075 lab=_51794_/B }
C {devices/lab_pin.sym} 13600 -30180 0 0 {name=p13076 lab=_51794_/C }
C {devices/lab_pin.sym} 13600 -30140 0 0 {name=p13077 lab=_52622_/D }
C {devices/lab_pin.sym} 13720 -30200 0 1 {name=p13078 lab=_51794_/X }
C {sky130_stdcells/and4_4.sym} 13660 -30200 0 0 {name=X_51794_ }
C {devices/lab_pin.sym} 13620 -30050 0 0 {name=p13079 lab=clkbuf_9_210_0_CLK/X }
C {devices/lab_pin.sym} 13700 -30050 0 1 {name=p13080 lab=_83507_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 13660 -30050 0 0 {name=Xclkbuf_10_421_0_CLK }
C {devices/lab_pin.sym} 13620 -29930 0 0 {name=p13081 lab=_56350_/A }
C {devices/lab_pin.sym} 13700 -29930 0 1 {name=p13082 lab=_56321_/X }
C {sky130_stdcells/buf_2.sym} 13660 -29930 0 0 {name=X_56321_ }
C {devices/lab_pin.sym} 13580 -29830 0 0 {name=p13083 lab=_82635_/D }
C {devices/lab_pin.sym} 13580 -29790 0 0 {name=p13084 lab=_68299_/X }
C {devices/lab_pin.sym} 13580 -29750 0 0 {name=p13085 lab=_68306_/X }
C {devices/lab_pin.sym} 13740 -29790 0 1 {name=p13086 lab=_68307_/X }
C {sky130_stdcells/a21bo_4.sym} 13660 -29790 0 0 {name=X_68307_ }
C {devices/lab_pin.sym} 13570 -29650 0 0 {name=p13087 lab=_87141_/CLK }
C {devices/lab_pin.sym} 13570 -29630 0 0 {name=p13088 lab=_87141_/D }
C {devices/lab_pin.sym} 13750 -29650 0 1 {name=p13089 lab=_87141_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -29640 0 0 {name=X_87141_ }
C {devices/lab_pin.sym} 13600 -29530 0 0 {name=p13090 lab=_50308_/A }
C {devices/lab_pin.sym} 13600 -29490 0 0 {name=p13091 lab=_53474_/B }
C {devices/lab_pin.sym} 13600 -29450 0 0 {name=p13092 lab=_53492_/X }
C {devices/lab_pin.sym} 13720 -29490 0 1 {name=p13093 lab=_53533_/X }
C {sky130_stdcells/and3_4.sym} 13660 -29490 0 0 {name=X_53533_ }
C {devices/lab_pin.sym} 13600 -29360 0 0 {name=p13094 lab=_65777_/A }
C {devices/lab_pin.sym} 13600 -29320 0 0 {name=p13095 lab=_65519_/B }
C {devices/lab_pin.sym} 13720 -29340 0 1 {name=p13096 lab=_65519_/X }
C {sky130_stdcells/and2_4.sym} 13660 -29340 0 0 {name=X_65519_ }
C {devices/lab_pin.sym} 13570 -29210 0 0 {name=p13097 lab=_83227_/CLK }
C {devices/lab_pin.sym} 13570 -29190 0 0 {name=p13098 lab=_63105_/X }
C {devices/lab_pin.sym} 13750 -29210 0 1 {name=p13099 lab=_79427_/A }
C {sky130_stdcells/dfxtp_4.sym} 13660 -29200 0 0 {name=X_84353_ }
C {devices/lab_pin.sym} 13580 -29090 0 0 {name=p13100 lab=_86142_/Q }
C {devices/lab_pin.sym} 13580 -29050 0 0 {name=p13101 lab=_50742_/X }
C {devices/lab_pin.sym} 13580 -29010 0 0 {name=p13102 lab=_50744_/Y }
C {devices/lab_pin.sym} 13740 -29050 0 1 {name=p13103 lab=_50745_/Y }
C {sky130_stdcells/o21ai_4.sym} 13660 -29050 0 0 {name=X_50745_ }
C {devices/lab_pin.sym} 13570 -28910 0 0 {name=p13104 lab=_84064_/CLK }
C {devices/lab_pin.sym} 13570 -28890 0 0 {name=p13105 lab=_76905_/Y }
C {devices/lab_pin.sym} 13750 -28910 0 1 {name=p13106 lab=_76366_/B }
C {sky130_stdcells/dfxtp_4.sym} 13660 -28900 0 0 {name=X_81565_ }
C {devices/lab_pin.sym} 13580 -28800 0 0 {name=p13107 lab=_88040_/Q }
C {devices/lab_pin.sym} 13580 -28760 0 0 {name=p13108 lab=_69217_/X }
C {devices/lab_pin.sym} 13580 -28720 0 0 {name=p13109 lab=_69245_/X }
C {devices/lab_pin.sym} 13580 -28680 0 0 {name=p13110 lab=_69286_/X }
C {devices/lab_pin.sym} 13740 -28740 0 1 {name=p13111 lab=_69287_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -28740 0 0 {name=X_69287_ }
C {devices/lab_pin.sym} 13600 -28610 0 0 {name=p13112 lab=_66287_/X }
C {devices/lab_pin.sym} 13600 -28570 0 0 {name=p13113 lab=_66499_/B }
C {devices/lab_pin.sym} 13600 -28530 0 0 {name=p13114 lab=_66289_/X }
C {devices/lab_pin.sym} 13720 -28570 0 1 {name=p13115 lab=_66499_/Y }
C {sky130_stdcells/nand3_4.sym} 13660 -28570 0 0 {name=X_66499_ }
C {devices/lab_pin.sym} 13620 -28430 0 0 {name=p13116 lab=clkbuf_4_13_0_CLK/X }
C {devices/lab_pin.sym} 13700 -28430 0 1 {name=p13117 lab=clkbuf_5_27_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 13660 -28430 0 0 {name=Xclkbuf_4_13_1_CLK }
C {devices/lab_pin.sym} 13580 -28330 0 0 {name=p13118 lab=_59035_/Y }
C {devices/lab_pin.sym} 13580 -28290 0 0 {name=p13119 lab=_59039_/Y }
C {devices/lab_pin.sym} 13580 -28250 0 0 {name=p13120 lab=_58966_/X }
C {devices/lab_pin.sym} 13740 -28290 0 1 {name=p13121 lab=_59040_/X }
C {sky130_stdcells/a21o_4.sym} 13660 -28290 0 0 {name=X_59040_ }
C {devices/lab_pin.sym} 13570 -28150 0 0 {name=p13122 lab=_83304_/CLK }
C {devices/lab_pin.sym} 13570 -28130 0 0 {name=p13123 lab=_72006_/Y }
C {devices/lab_pin.sym} 13750 -28150 0 1 {name=p13124 lab=_83304_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -28140 0 0 {name=X_83304_ }
C {devices/lab_pin.sym} 13620 -28010 0 0 {name=p13125 lab=_56252_/A }
C {devices/lab_pin.sym} 13700 -28010 0 1 {name=p13126 lab=_56263_/A }
C {sky130_stdcells/buf_2.sym} 13660 -28010 0 0 {name=X_56252_ }
C {devices/lab_pin.sym} 13600 -27900 0 0 {name=p13127 lab=_84767_/Q }
C {devices/lab_pin.sym} 13600 -27860 0 0 {name=p13128 lab=_84159_/Q }
C {devices/lab_pin.sym} 13720 -27880 0 1 {name=p13129 lab=_80518_/A }
C {sky130_stdcells/xor2_4.sym} 13660 -27880 0 0 {name=X_80516_ }
C {devices/lab_pin.sym} 13620 -27750 0 0 {name=p13130 lab=_68160_/A }
C {devices/lab_pin.sym} 13700 -27750 0 1 {name=p13131 lab=_68238_/X }
C {sky130_stdcells/buf_2.sym} 13660 -27750 0 0 {name=X_68238_ }
C {devices/lab_pin.sym} 13570 -27630 0 0 {name=p13132 lab=_87077_/CLK }
C {devices/lab_pin.sym} 13570 -27610 0 0 {name=p13133 lab=_87072_/D }
C {devices/lab_pin.sym} 13750 -27630 0 1 {name=p13134 lab=_87072_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -27620 0 0 {name=X_87072_ }
C {devices/lab_pin.sym} 13620 -27490 0 0 {name=p13135 lab=_53817_/A }
C {devices/lab_pin.sym} 13700 -27490 0 1 {name=p13136 lab=_53990_/A }
C {sky130_stdcells/buf_2.sym} 13660 -27490 0 0 {name=X_53464_ }
C {devices/lab_pin.sym} 13570 -27370 0 0 {name=p13137 lab=_84668_/CLK }
C {devices/lab_pin.sym} 13570 -27350 0 0 {name=p13138 lab=_84284_/D }
C {devices/lab_pin.sym} 13750 -27370 0 1 {name=p13139 lab=_80111_/B }
C {sky130_stdcells/dfxtp_4.sym} 13660 -27360 0 0 {name=X_84284_ }
C {devices/lab_pin.sym} 13620 -27230 0 0 {name=p13140 lab=_50551_/A }
C {devices/lab_pin.sym} 13700 -27230 0 1 {name=p13141 lab=_50676_/X }
C {sky130_stdcells/buf_2.sym} 13660 -27230 0 0 {name=X_50676_ }
C {devices/lab_pin.sym} 13570 -27110 0 0 {name=p13142 lab=_82648_/CLK }
C {devices/lab_pin.sym} 13570 -27090 0 0 {name=p13143 lab=_84064_/Q }
C {devices/lab_pin.sym} 13750 -27110 0 1 {name=p13144 lab=_81496_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -27100 0 0 {name=X_81496_ }
C {devices/lab_pin.sym} 13580 -27000 0 0 {name=p13145 lab=_57071_/B }
C {devices/lab_pin.sym} 13580 -26960 0 0 {name=p13146 lab=_55157_/X }
C {devices/lab_pin.sym} 13580 -26920 0 0 {name=p13147 lab=_55165_/X }
C {devices/lab_pin.sym} 13580 -26880 0 0 {name=p13148 lab=_55202_/Y }
C {devices/lab_pin.sym} 13740 -26940 0 1 {name=p13149 lab=_55203_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -26940 0 0 {name=X_55203_ }
C {devices/lab_pin.sym} 13570 -26790 0 0 {name=p13150 lab=_86118_/CLK }
C {devices/lab_pin.sym} 13570 -26770 0 0 {name=p13151 lab=_51373_/Y }
C {devices/lab_pin.sym} 13750 -26790 0 1 {name=p13152 lab=_65275_/B }
C {sky130_stdcells/dfxtp_4.sym} 13660 -26780 0 0 {name=X_86023_ }
C {devices/lab_pin.sym} 13620 -26650 0 0 {name=p13153 lab=_52496_/A }
C {devices/lab_pin.sym} 13700 -26650 0 1 {name=p13154 lab=_52415_/X }
C {sky130_stdcells/buf_2.sym} 13660 -26650 0 0 {name=X_52415_ }
C {devices/lab_pin.sym} 13570 -26530 0 0 {name=p13155 lab=_84487_/CLK }
C {devices/lab_pin.sym} 13570 -26510 0 0 {name=p13156 lab=_83235_/D }
C {devices/lab_pin.sym} 13750 -26530 0 1 {name=p13157 lab=_79447_/B }
C {sky130_stdcells/dfxtp_4.sym} 13660 -26520 0 0 {name=X_83235_ }
C {devices/lab_pin.sym} 13600 -26400 0 0 {name=p13158 lab=_80448_/B }
C {devices/lab_pin.sym} 13600 -26360 0 0 {name=p13159 lab=_80448_/A }
C {devices/lab_pin.sym} 13720 -26380 0 1 {name=p13160 lab=_80447_/X }
C {sky130_stdcells/or2_4.sym} 13660 -26380 0 0 {name=X_80447_ }
C {devices/lab_pin.sym} 13620 -26250 0 0 {name=p13161 lab=_56182_/X }
C {devices/lab_pin.sym} 13700 -26250 0 1 {name=p13162 lab=_56183_/X }
C {sky130_stdcells/buf_2.sym} 13660 -26250 0 0 {name=X_56183_ }
C {devices/lab_pin.sym} 13620 -26130 0 0 {name=p13163 lab=_68106_/A }
C {devices/lab_pin.sym} 13700 -26130 0 1 {name=p13164 lab=_68169_/X }
C {sky130_stdcells/buf_2.sym} 13660 -26130 0 0 {name=X_68169_ }
C {devices/lab_pin.sym} 13600 -26020 0 0 {name=p13165 lab=_53386_/A }
C {devices/lab_pin.sym} 13600 -25980 0 0 {name=p13166 lab=_53395_/B }
C {devices/lab_pin.sym} 13720 -26000 0 1 {name=p13167 lab=_53395_/Y }
C {sky130_stdcells/nand2_4.sym} 13660 -26000 0 0 {name=X_53395_ }
C {devices/lab_pin.sym} 13620 -25870 0 0 {name=p13168 lab=clkbuf_9_218_0_CLK/X }
C {devices/lab_pin.sym} 13700 -25870 0 1 {name=p13169 lab=_81233_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 13660 -25870 0 0 {name=Xclkbuf_10_436_0_CLK }
C {devices/lab_pin.sym} 13600 -25780 0 0 {name=p13170 lab=_70200_/A }
C {devices/lab_pin.sym} 13600 -25740 0 0 {name=p13171 lab=_70200_/B }
C {devices/lab_pin.sym} 13600 -25700 0 0 {name=p13172 lab=_83199_/Q }
C {devices/lab_pin.sym} 13600 -25660 0 0 {name=p13173 lab=_70200_/D }
C {devices/lab_pin.sym} 13720 -25720 0 1 {name=p13174 lab=_70200_/X }
C {sky130_stdcells/and4_4.sym} 13660 -25720 0 0 {name=X_70200_ }
C {devices/lab_pin.sym} 13620 -25570 0 0 {name=p13175 lab=_55133_/X }
C {devices/lab_pin.sym} 13700 -25570 0 1 {name=p13176 lab=_55134_/X }
C {sky130_stdcells/buf_2.sym} 13660 -25570 0 0 {name=X_55134_ }
C {devices/lab_pin.sym} 13620 -25450 0 0 {name=p13177 lab=_44528_/A }
C {devices/lab_pin.sym} 13700 -25450 0 1 {name=p13178 lab=_57491_/A }
C {sky130_stdcells/buf_2.sym} 13660 -25450 0 0 {name=X_40360_ }
C {devices/lab_pin.sym} 13580 -25350 0 0 {name=p13179 lab=_52344_/Y }
C {devices/lab_pin.sym} 13580 -25310 0 0 {name=p13180 lab=_52340_/X }
C {devices/lab_pin.sym} 13580 -25270 0 0 {name=p13181 lab=_52345_/X }
C {devices/lab_pin.sym} 13740 -25310 0 1 {name=p13182 lab=_52346_/Y }
C {sky130_stdcells/a21oi_4.sym} 13660 -25310 0 0 {name=X_52346_ }
C {devices/lab_pin.sym} 13620 -25170 0 0 {name=p13183 lab=_70611_/X }
C {devices/lab_pin.sym} 13700 -25170 0 1 {name=p13184 lab=_74518_/D }
C {sky130_stdcells/buf_2.sym} 13660 -25170 0 0 {name=X_71180_ }
C {devices/lab_pin.sym} 13570 -25050 0 0 {name=p13185 lab=_83167_/CLK }
C {devices/lab_pin.sym} 13570 -25030 0 0 {name=p13186 lab=_73077_/X }
C {devices/lab_pin.sym} 13750 -25050 0 1 {name=p13187 lab=_83166_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -25040 0 0 {name=X_83166_ }
C {devices/lab_pin.sym} 13600 -24920 0 0 {name=p13188 lab=_84754_/Q }
C {devices/lab_pin.sym} 13600 -24880 0 0 {name=p13189 lab=_66247_/C }
C {devices/lab_pin.sym} 13720 -24900 0 1 {name=p13190 lab=_80378_/X }
C {sky130_stdcells/xor2_4.sym} 13660 -24900 0 0 {name=X_80378_ }
C {devices/lab_pin.sym} 13600 -24790 0 0 {name=p13191 lab=_70131_/A }
C {devices/lab_pin.sym} 13600 -24750 0 0 {name=p13192 lab=_70131_/B }
C {devices/lab_pin.sym} 13600 -24710 0 0 {name=p13193 lab=_70131_/C }
C {devices/lab_pin.sym} 13720 -24750 0 1 {name=p13194 lab=_70131_/X }
C {sky130_stdcells/and3_4.sym} 13660 -24750 0 0 {name=X_70131_ }
C {devices/lab_pin.sym} 13570 -24610 0 0 {name=p13195 lab=_82145_/CLK }
C {devices/lab_pin.sym} 13570 -24590 0 0 {name=p13196 lab=_77761_/X }
C {devices/lab_pin.sym} 13750 -24610 0 1 {name=p13197 lab=_82105_/D }
C {sky130_stdcells/dfxtp_4.sym} 13660 -24600 0 0 {name=X_82117_ }
C {devices/lab_pin.sym} 13620 -24470 0 0 {name=p13198 lab=_59923_/Y }
C {devices/lab_pin.sym} 13700 -24470 0 1 {name=p13199 lab=_62534_/A }
C {sky130_stdcells/buf_2.sym} 13660 -24470 0 0 {name=X_59942_ }
C {devices/lab_pin.sym} 13600 -24380 0 0 {name=p13200 lab=_55043_/X }
C {devices/lab_pin.sym} 13600 -24340 0 0 {name=p13201 lab=_55056_/X }
C {devices/lab_pin.sym} 13600 -24300 0 0 {name=p13202 lab=_55070_/C }
C {devices/lab_pin.sym} 13600 -24260 0 0 {name=p13203 lab=_47722_/A }
C {devices/lab_pin.sym} 13720 -24320 0 1 {name=p13204 lab=_55065_/X }
C {sky130_stdcells/and4_4.sym} 13660 -24320 0 0 {name=X_55065_ }
C {devices/lab_pin.sym} 13600 -24180 0 0 {name=p13205 lab=_52293_/A }
C {devices/lab_pin.sym} 13600 -24140 0 0 {name=p13206 lab=_48912_/B }
C {devices/lab_pin.sym} 13720 -24160 0 1 {name=p13207 lab=_52277_/Y }
C {sky130_stdcells/nand2_4.sym} 13660 -24160 0 0 {name=X_52277_ }
C {devices/lab_pin.sym} 13570 -24030 0 0 {name=p13208 lab=_87149_/CLK }
C {devices/lab_pin.sym} 13570 -24010 0 0 {name=p13209 lab=_87974_/D }
C {devices/lab_pin.sym} 13750 -24030 0 1 {name=p13210 lab=_87974_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -24020 0 0 {name=X_87974_ }
C {devices/lab_pin.sym} 13570 -23890 0 0 {name=p13211 lab=_83095_/CLK }
C {devices/lab_pin.sym} 13570 -23870 0 0 {name=p13212 lab=_83097_/D }
C {devices/lab_pin.sym} 13750 -23890 0 1 {name=p13213 lab=_70313_/C }
C {sky130_stdcells/dfxtp_4.sym} 13660 -23880 0 0 {name=X_83097_ }
C {devices/lab_pin.sym} 13620 -23750 0 0 {name=p13214 lab=_42029_/Y }
C {devices/lab_pin.sym} 13700 -23750 0 1 {name=p13215 lab=_88065_/D }
C {sky130_stdcells/inv_2.sym} 13660 -23750 0 0 {name=X_42030_ }
C {devices/lab_pin.sym} 13600 -23650 0 0 {name=p13216 lab=_46427_/A }
C {devices/lab_pin.sym} 13600 -23610 0 0 {name=p13217 lab=_53964_/B }
C {devices/lab_pin.sym} 13600 -23570 0 0 {name=p13218 lab=_53969_/C }
C {devices/lab_pin.sym} 13720 -23610 0 1 {name=p13219 lab=_54016_/X }
C {sky130_stdcells/and3_4.sym} 13660 -23610 0 0 {name=X_54016_ }
C {devices/lab_pin.sym} 13580 -23490 0 0 {name=p13220 lab=_86050_/Q }
C {devices/lab_pin.sym} 13580 -23450 0 0 {name=p13221 lab=_51209_/X }
C {devices/lab_pin.sym} 13580 -23410 0 0 {name=p13222 lab=_51227_/Y }
C {devices/lab_pin.sym} 13740 -23450 0 1 {name=p13223 lab=_51228_/Y }
C {sky130_stdcells/o21ai_4.sym} 13660 -23450 0 0 {name=X_51228_ }
C {devices/lab_pin.sym} 13570 -23310 0 0 {name=p13224 lab=_87652_/CLK }
C {devices/lab_pin.sym} 13570 -23290 0 0 {name=p13225 lab=_44842_/X }
C {devices/lab_pin.sym} 13750 -23310 0 1 {name=p13226 lab=_67773_/B }
C {sky130_stdcells/dfxtp_4.sym} 13660 -23300 0 0 {name=X_86925_ }
C {devices/lab_pin.sym} 13570 -23170 0 0 {name=p13227 lab=_82047_/CLK }
C {devices/lab_pin.sym} 13570 -23150 0 0 {name=p13228 lab=_78017_/X }
C {devices/lab_pin.sym} 13750 -23170 0 1 {name=p13229 lab=_82016_/D }
C {sky130_stdcells/dfxtp_4.sym} 13660 -23160 0 0 {name=X_82048_ }
C {devices/lab_pin.sym} 13580 -23050 0 0 {name=p13230 lab=_82540_/D }
C {devices/lab_pin.sym} 13580 -23010 0 0 {name=p13231 lab=_70048_/X }
C {devices/lab_pin.sym} 13580 -22970 0 0 {name=p13232 lab=_70061_/X }
C {devices/lab_pin.sym} 13740 -23010 0 1 {name=p13233 lab=_70062_/X }
C {sky130_stdcells/a21bo_4.sym} 13660 -23010 0 0 {name=X_70062_ }
C {devices/lab_pin.sym} 13600 -22890 0 0 {name=p13234 lab=_59873_/A }
C {devices/lab_pin.sym} 13600 -22850 0 0 {name=p13235 lab=_59873_/B }
C {devices/lab_pin.sym} 13600 -22810 0 0 {name=p13236 lab=_80266_/B }
C {devices/lab_pin.sym} 13720 -22850 0 1 {name=p13237 lab=_59873_/Y }
C {sky130_stdcells/nor3_4.sym} 13660 -22850 0 0 {name=X_59873_ }
C {devices/lab_pin.sym} 13580 -22730 0 0 {name=p13238 lab=_58787_/X }
C {devices/lab_pin.sym} 13580 -22690 0 0 {name=p13239 lab=_86093_/Q }
C {devices/lab_pin.sym} 13580 -22650 0 0 {name=p13240 lab=_58823_/X }
C {devices/lab_pin.sym} 13740 -22690 0 1 {name=p13241 lab=_58824_/Y }
C {sky130_stdcells/o21ai_4.sym} 13660 -22690 0 0 {name=X_58824_ }
C {devices/lab_pin.sym} 13580 -22570 0 0 {name=p13242 lab=_86063_/Q }
C {devices/lab_pin.sym} 13580 -22530 0 0 {name=p13243 lab=_51156_/X }
C {devices/lab_pin.sym} 13580 -22490 0 0 {name=p13244 lab=_51158_/Y }
C {devices/lab_pin.sym} 13740 -22530 0 1 {name=p13245 lab=_51159_/Y }
C {sky130_stdcells/o21ai_4.sym} 13660 -22530 0 0 {name=X_51159_ }
C {devices/lab_pin.sym} 13600 -22400 0 0 {name=p13246 lab=_81125_/D }
C {devices/lab_pin.sym} 13600 -22360 0 0 {name=p13247 lab=_74870_/B }
C {devices/lab_pin.sym} 13720 -22380 0 1 {name=p13248 lab=_74870_/Y }
C {sky130_stdcells/nor2_4.sym} 13660 -22380 0 0 {name=X_74870_ }
C {devices/lab_pin.sym} 13570 -22250 0 0 {name=p13249 lab=_86855_/CLK }
C {devices/lab_pin.sym} 13570 -22230 0 0 {name=p13250 lab=_45767_/Y }
C {devices/lab_pin.sym} 13750 -22250 0 1 {name=p13251 lab=_62083_/D }
C {sky130_stdcells/dfxtp_4.sym} 13660 -22240 0 0 {name=X_86856_ }
C {devices/lab_pin.sym} 13580 -22140 0 0 {name=p13252 lab=_41922_/Y }
C {devices/lab_pin.sym} 13580 -22100 0 0 {name=p13253 lab=_56182_/X }
C {devices/lab_pin.sym} 13580 -22060 0 0 {name=p13254 lab=_73819_/X }
C {devices/lab_pin.sym} 13580 -22020 0 0 {name=p13255 lab=_73820_/Y }
C {devices/lab_pin.sym} 13740 -22080 0 1 {name=p13256 lab=_73821_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -22080 0 0 {name=X_73821_ }
C {devices/lab_pin.sym} 13570 -21930 0 0 {name=p13257 lab=_86127_/CLK }
C {devices/lab_pin.sym} 13570 -21910 0 0 {name=p13258 lab=_52514_/Y }
C {devices/lab_pin.sym} 13750 -21930 0 1 {name=p13259 lab=_65074_/B }
C {sky130_stdcells/dfxtp_4.sym} 13660 -21920 0 0 {name=X_85807_ }
C {devices/lab_pin.sym} 13620 -21790 0 0 {name=p13260 lab=_84802_/Q }
C {devices/lab_pin.sym} 13700 -21790 0 1 {name=p13261 lab=_58755_/Y }
C {sky130_stdcells/inv_2.sym} 13660 -21790 0 0 {name=X_58755_ }
C {devices/lab_pin.sym} 13600 -21680 0 0 {name=p13262 lab=_59899_/B }
C {devices/lab_pin.sym} 13600 -21640 0 0 {name=p13263 lab=_59899_/D }
C {devices/lab_pin.sym} 13720 -21660 0 1 {name=p13264 lab=_59538_/C }
C {sky130_stdcells/and2_4.sym} 13660 -21660 0 0 {name=X_43981_ }
C {devices/lab_pin.sym} 13600 -21540 0 0 {name=p13265 lab=_55695_/A }
C {devices/lab_pin.sym} 13600 -21500 0 0 {name=p13266 lab=_85247_/Q }
C {devices/lab_pin.sym} 13720 -21520 0 1 {name=p13267 lab=_55967_/X }
C {sky130_stdcells/and2_4.sym} 13660 -21520 0 0 {name=X_55967_ }
C {devices/lab_pin.sym} 13570 -21390 0 0 {name=p13268 lab=_86784_/CLK }
C {devices/lab_pin.sym} 13570 -21370 0 0 {name=p13269 lab=_46063_/X }
C {devices/lab_pin.sym} 13750 -21390 0 1 {name=p13270 lab=_86787_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -21380 0 0 {name=X_86787_ }
C {devices/lab_pin.sym} 13570 -21250 0 0 {name=p13271 lab=_81755_/CLK }
C {devices/lab_pin.sym} 13570 -21230 0 0 {name=p13272 lab=_83999_/D }
C {devices/lab_pin.sym} 13750 -21250 0 1 {name=p13273 lab=_83999_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -21240 0 0 {name=X_83999_ }
C {devices/lab_pin.sym} 13620 -21110 0 0 {name=p13274 lab=_45720_/A }
C {devices/lab_pin.sym} 13700 -21110 0 1 {name=p13275 lab=_45720_/X }
C {sky130_stdcells/buf_2.sym} 13660 -21110 0 0 {name=X_45720_ }
C {devices/lab_pin.sym} 13580 -21010 0 0 {name=p13276 lab=_57705_/X }
C {devices/lab_pin.sym} 13580 -20970 0 0 {name=p13277 lab=_85505_/Q }
C {devices/lab_pin.sym} 13580 -20930 0 0 {name=p13278 lab=_44031_/X }
C {devices/lab_pin.sym} 13740 -20970 0 1 {name=p13279 lab=_57706_/X }
C {sky130_stdcells/o21a_4.sym} 13660 -20970 0 0 {name=X_57706_ }
C {devices/lab_pin.sym} 13600 -20850 0 0 {name=p13280 lab=_76535_/X }
C {devices/lab_pin.sym} 13600 -20810 0 0 {name=p13281 lab=_76540_/B }
C {devices/lab_pin.sym} 13600 -20770 0 0 {name=p13282 lab=_76540_/C }
C {devices/lab_pin.sym} 13720 -20810 0 1 {name=p13283 lab=_76541_/B }
C {sky130_stdcells/nand3_4.sym} 13660 -20810 0 0 {name=X_76540_ }
C {devices/lab_pin.sym} 13580 -20700 0 0 {name=p13284 lab=_41745_/X }
C {devices/lab_pin.sym} 13580 -20660 0 0 {name=p13285 lab=_42930_/X }
C {devices/lab_pin.sym} 13580 -20620 0 0 {name=p13286 lab=_87645_/Q }
C {devices/lab_pin.sym} 13580 -20580 0 0 {name=p13287 lab=_42931_/X }
C {devices/lab_pin.sym} 13740 -20640 0 1 {name=p13288 lab=_42932_/X }
C {sky130_stdcells/a2bb2o_4.sym} 13660 -20640 0 0 {name=X_42932_ }
C {devices/lab_pin.sym} 13620 -20490 0 0 {name=p13289 lab=_53448_/X }
C {devices/lab_pin.sym} 13700 -20490 0 1 {name=p13290 lab=_54918_/X }
C {sky130_stdcells/buf_2.sym} 13660 -20490 0 0 {name=X_54918_ }
C {devices/lab_pin.sym} 13600 -20380 0 0 {name=p13291 lab=_73752_/A }
C {devices/lab_pin.sym} 13600 -20340 0 0 {name=p13292 lab=_73701_/B }
C {devices/lab_pin.sym} 13720 -20360 0 1 {name=p13293 lab=_73752_/Y }
C {sky130_stdcells/nor2_4.sym} 13660 -20360 0 0 {name=X_73752_ }
C {devices/lab_pin.sym} 13570 -20230 0 0 {name=p13294 lab=_85738_/CLK }
C {devices/lab_pin.sym} 13570 -20210 0 0 {name=p13295 lab=_52880_/Y }
C {devices/lab_pin.sym} 13750 -20230 0 1 {name=p13296 lab=_85738_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -20220 0 0 {name=X_85738_ }
C {devices/lab_pin.sym} 13600 -20110 0 0 {name=p13297 lab=_70969_/A }
C {devices/lab_pin.sym} 13600 -20070 0 0 {name=p13298 lab=_70942_/B }
C {devices/lab_pin.sym} 13600 -20030 0 0 {name=p13299 lab=_70962_/C }
C {devices/lab_pin.sym} 13720 -20070 0 1 {name=p13300 lab=_70964_/Y }
C {sky130_stdcells/nand3_4.sym} 13660 -20070 0 0 {name=X_70964_ }
C {devices/lab_pin.sym} 13580 -19960 0 0 {name=p13301 lab=_84808_/Q }
C {devices/lab_pin.sym} 13580 -19920 0 0 {name=p13302 lab=_58599_/X }
C {devices/lab_pin.sym} 13580 -19880 0 0 {name=p13303 lab=_58678_/X }
C {devices/lab_pin.sym} 13580 -19840 0 0 {name=p13304 lab=_58685_/X }
C {devices/lab_pin.sym} 13740 -19900 0 1 {name=p13305 lab=_84808_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 13660 -19900 0 0 {name=X_58686_ }
C {devices/lab_pin.sym} 13580 -19770 0 0 {name=p13306 lab=_55895_/X }
C {devices/lab_pin.sym} 13580 -19730 0 0 {name=p13307 lab=_55897_/X }
C {devices/lab_pin.sym} 13580 -19690 0 0 {name=p13308 lab=_44118_/B }
C {devices/lab_pin.sym} 13740 -19730 0 1 {name=p13309 lab=_55902_/A }
C {sky130_stdcells/a21o_4.sym} 13660 -19730 0 0 {name=X_55898_ }
C {devices/lab_pin.sym} 13620 -19590 0 0 {name=p13310 lab=_45891_/X }
C {devices/lab_pin.sym} 13700 -19590 0 1 {name=p13311 lab=_72704_/A }
C {sky130_stdcells/buf_2.sym} 13660 -19590 0 0 {name=X_72703_ }
C {devices/lab_pin.sym} 13620 -19470 0 0 {name=p13312 lab=_45651_/A }
C {devices/lab_pin.sym} 13700 -19470 0 1 {name=p13313 lab=_45651_/X }
C {sky130_stdcells/buf_2.sym} 13660 -19470 0 0 {name=X_45651_ }
C {devices/lab_pin.sym} 13600 -19360 0 0 {name=p13314 lab=_71972_/A }
C {devices/lab_pin.sym} 13600 -19320 0 0 {name=p13315 lab=_57637_/B }
C {devices/lab_pin.sym} 13720 -19340 0 1 {name=p13316 lab=_57637_/Y }
C {sky130_stdcells/nand2_4.sym} 13660 -19340 0 0 {name=X_57637_ }
C {devices/lab_pin.sym} 13600 -19220 0 0 {name=p13317 lab=_81272_/Q }
C {devices/lab_pin.sym} 13600 -19180 0 0 {name=p13318 lab=_81528_/D }
C {devices/lab_pin.sym} 13720 -19200 0 1 {name=p13319 lab=_76471_/Y }
C {sky130_stdcells/nor2_4.sym} 13660 -19200 0 0 {name=X_76471_ }
C {devices/lab_pin.sym} 13580 -19090 0 0 {name=p13320 lab=_54846_/Y }
C {devices/lab_pin.sym} 13580 -19050 0 0 {name=p13321 lab=_54830_/X }
C {devices/lab_pin.sym} 13580 -19010 0 0 {name=p13322 lab=_54848_/X }
C {devices/lab_pin.sym} 13740 -19050 0 1 {name=p13323 lab=_54849_/Y }
C {sky130_stdcells/a21oi_4.sym} 13660 -19050 0 0 {name=X_54849_ }
C {devices/lab_pin.sym} 13580 -18940 0 0 {name=p13324 lab=_41560_/X }
C {devices/lab_pin.sym} 13580 -18900 0 0 {name=p13325 lab=_42852_/X }
C {devices/lab_pin.sym} 13580 -18860 0 0 {name=p13326 lab=_67033_/B }
C {devices/lab_pin.sym} 13580 -18820 0 0 {name=p13327 lab=_42853_/X }
C {devices/lab_pin.sym} 13740 -18880 0 1 {name=p13328 lab=_42863_/X }
C {sky130_stdcells/a2bb2o_4.sym} 13660 -18880 0 0 {name=X_42863_ }
C {devices/lab_pin.sym} 13620 -18730 0 0 {name=p13329 lab=_73948_/A }
C {devices/lab_pin.sym} 13700 -18730 0 1 {name=p13330 lab=_73683_/X }
C {sky130_stdcells/buf_2.sym} 13660 -18730 0 0 {name=X_73683_ }
C {devices/lab_pin.sym} 13570 -18610 0 0 {name=p13331 lab=_84815_/CLK }
C {devices/lab_pin.sym} 13570 -18590 0 0 {name=p13332 lab=_85669_/D }
C {devices/lab_pin.sym} 13750 -18610 0 1 {name=p13333 lab=_85669_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -18600 0 0 {name=X_85669_ }
C {devices/lab_pin.sym} 13620 -18470 0 0 {name=p13334 lab=_70866_/A }
C {devices/lab_pin.sym} 13700 -18470 0 1 {name=p13335 lab=_70903_/B }
C {sky130_stdcells/buf_2.sym} 13660 -18470 0 0 {name=X_70895_ }
C {devices/lab_pin.sym} 13600 -18360 0 0 {name=p13336 lab=_78220_/A }
C {devices/lab_pin.sym} 13600 -18320 0 0 {name=p13337 lab=_78210_/B }
C {devices/lab_pin.sym} 13720 -18340 0 1 {name=p13338 lab=_78211_/B }
C {sky130_stdcells/xor2_4.sym} 13660 -18340 0 0 {name=X_78210_ }
C {devices/lab_pin.sym} 13620 -18210 0 0 {name=p13339 lab=_44602_/A }
C {devices/lab_pin.sym} 13700 -18210 0 1 {name=p13340 lab=_44602_/X }
C {sky130_stdcells/buf_2.sym} 13660 -18210 0 0 {name=X_44602_ }
C {devices/lab_pin.sym} 13600 -18100 0 0 {name=p13341 lab=_80793_/Q }
C {devices/lab_pin.sym} 13600 -18060 0 0 {name=p13342 lab=_75421_/X }
C {devices/lab_pin.sym} 13720 -18080 0 1 {name=p13343 lab=_80761_/D }
C {sky130_stdcells/xor2_4.sym} 13660 -18080 0 0 {name=X_75422_ }
C {devices/lab_pin.sym} 13570 -17950 0 0 {name=p13344 lab=_87408_/CLK }
C {devices/lab_pin.sym} 13570 -17930 0 0 {name=p13345 lab=_87408_/D }
C {devices/lab_pin.sym} 13750 -17950 0 1 {name=p13346 lab=_87408_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -17940 0 0 {name=X_87408_ }
C {devices/lab_pin.sym} 13620 -17810 0 0 {name=p13347 lab=_41814_/A }
C {devices/lab_pin.sym} 13700 -17810 0 1 {name=p13348 lab=_41814_/X }
C {sky130_stdcells/buf_2.sym} 13660 -17810 0 0 {name=X_41814_ }
C {devices/lab_pin.sym} 13580 -17710 0 0 {name=p13349 lab=_65444_/B }
C {devices/lab_pin.sym} 13580 -17670 0 0 {name=p13350 lab=_48350_/X }
C {devices/lab_pin.sym} 13580 -17630 0 0 {name=p13351 lab=_48369_/Y }
C {devices/lab_pin.sym} 13740 -17670 0 1 {name=p13352 lab=_48370_/Y }
C {sky130_stdcells/o21ai_4.sym} 13660 -17670 0 0 {name=X_48370_ }
C {devices/lab_pin.sym} 13620 -17530 0 0 {name=p13353 lab=_44231_/A }
C {devices/lab_pin.sym} 13700 -17530 0 1 {name=p13354 lab=_72643_/B }
C {sky130_stdcells/buf_2.sym} 13660 -17530 0 0 {name=X_72634_ }
C {devices/lab_pin.sym} 13620 -17410 0 0 {name=p13355 lab=_79189_/Y }
C {devices/lab_pin.sym} 13700 -17410 0 1 {name=p13356 lab=_79190_/Y }
C {sky130_stdcells/inv_2.sym} 13660 -17410 0 0 {name=X_79190_ }
C {devices/lab_pin.sym} 13600 -17300 0 0 {name=p13357 lab=_45582_/A }
C {devices/lab_pin.sym} 13600 -17260 0 0 {name=p13358 lab=_45597_/B }
C {devices/lab_pin.sym} 13720 -17280 0 1 {name=p13359 lab=_45582_/Y }
C {sky130_stdcells/nor2_4.sym} 13660 -17280 0 0 {name=X_45582_ }
C {devices/lab_pin.sym} 13580 -17170 0 0 {name=p13360 lab=_57566_/Y }
C {devices/lab_pin.sym} 13580 -17130 0 0 {name=p13361 lab=_57506_/X }
C {devices/lab_pin.sym} 13580 -17090 0 0 {name=p13362 lab=_57567_/X }
C {devices/lab_pin.sym} 13740 -17130 0 1 {name=p13363 lab=_84978_/D }
C {sky130_stdcells/a21oi_4.sym} 13660 -17130 0 0 {name=X_57568_ }
C {devices/lab_pin.sym} 13620 -16990 0 0 {name=p13364 lab=_42794_/A }
C {devices/lab_pin.sym} 13700 -16990 0 1 {name=p13365 lab=_87714_/D }
C {sky130_stdcells/inv_2.sym} 13660 -16990 0 0 {name=X_42794_ }
C {devices/lab_pin.sym} 13570 -16870 0 0 {name=p13366 lab=_88394_/CLK }
C {devices/lab_pin.sym} 13570 -16850 0 0 {name=p13367 lab=_40461_/Y }
C {devices/lab_pin.sym} 13750 -16870 0 1 {name=p13368 lab=_88388_/Q }
C {sky130_stdcells/dfxtp_4.sym} 13660 -16860 0 0 {name=X_88388_ }
C {devices/lab_pin.sym} 13600 -16760 0 0 {name=p13369 lab=_47330_/A }
C {devices/lab_pin.sym} 13600 -16720 0 0 {name=p13370 lab=_47349_/B }
C {devices/lab_pin.sym} 13600 -16680 0 0 {name=p13371 lab=_47321_/C }
C {devices/lab_pin.sym} 13600 -16640 0 0 {name=p13372 lab=_52982_/D }
C {devices/lab_pin.sym} 13720 -16700 0 1 {name=p13373 lab=_47321_/X }
C {sky130_stdcells/and4_4.sym} 13660 -16700 0 0 {name=X_47321_ }
C {devices/lab_pin.sym} 13580 -16590 0 0 {name=p13374 lab=_59253_/X }
C {devices/lab_pin.sym} 13580 -16550 0 0 {name=p13375 lab=_59304_/Y }
C {devices/lab_pin.sym} 13580 -16510 0 0 {name=p13376 lab=_59306_/Y }
C {devices/lab_pin.sym} 13580 -16470 0 0 {name=p13377 lab=_59271_/X }
C {devices/lab_pin.sym} 13580 -16430 0 0 {name=p13378 lab=_59258_/X }
C {devices/lab_pin.sym} 13740 -16510 0 1 {name=p13379 lab=_59307_/X }
C {sky130_stdcells/o32a_4.sym} 13660 -16510 0 0 {name=X_59307_ }
C {devices/lab_pin.sym} 13600 -16360 0 0 {name=p13380 lab=_82570_/Q }
C {devices/lab_pin.sym} 13600 -16320 0 0 {name=p13381 lab=_82858_/D }
C {devices/lab_pin.sym} 13720 -16340 0 1 {name=p13382 lab=_78141_/Y }
C {sky130_stdcells/nand2_4.sym} 13660 -16340 0 0 {name=X_78141_ }
C {devices/lab_pin.sym} 13620 -16210 0 0 {name=p13383 lab=_44533_/A }
C {devices/lab_pin.sym} 13700 -16210 0 1 {name=p13384 lab=_44533_/X }
C {sky130_stdcells/buf_2.sym} 13660 -16210 0 0 {name=X_44533_ }
C {devices/lab_pin.sym} 13580 -16110 0 0 {name=p13385 lab=_56114_/X }
C {devices/lab_pin.sym} 13580 -16070 0 0 {name=p13386 lab=_56515_/X }
C {devices/lab_pin.sym} 13580 -16030 0 0 {name=p13387 lab=_56518_/Y }
C {devices/lab_pin.sym} 13740 -16070 0 1 {name=p13388 lab=_85165_/D }
C {sky130_stdcells/o21ai_4.sym} 13660 -16070 0 0 {name=X_56519_ }
C {devices/lab_pin.sym} 13580 -15950 0 0 {name=p13389 lab=_75349_/Y }
C {devices/lab_pin.sym} 13580 -15910 0 0 {name=p13390 lab=_75351_/Y }
C {devices/lab_pin.sym} 13580 -15870 0 0 {name=p13391 lab=_75348_/Y }
C {devices/lab_pin.sym} 13740 -15910 0 1 {name=p13392 lab=_75353_/Y }
C {sky130_stdcells/o21ai_4.sym} 13660 -15910 0 0 {name=X_75353_ }
C {devices/lab_pin.sym} 13620 -15770 0 0 {name=p13393 lab=_41744_/Y }
C {devices/lab_pin.sym} 13700 -15770 0 1 {name=p13394 lab=_41745_/X }
C {sky130_stdcells/buf_2.sym} 13660 -15770 0 0 {name=X_41745_ }
C {devices/lab_pin.sym} 13570 -15650 0 0 {name=p13395 lab=_87070_/CLK }
C {devices/lab_pin.sym} 13570 -15630 0 0 {name=p13396 lab=_43619_/X }
C {devices/lab_pin.sym} 13750 -15650 0 1 {name=p13397 lab=_73752_/A }
C {sky130_stdcells/dfxtp_4.sym} 13660 -15640 0 0 {name=X_87339_ }
C {devices/lab_pin.sym} 13600 -15530 0 0 {name=p13398 lab=_72573_/A }
C {devices/lab_pin.sym} 13600 -15490 0 0 {name=p13399 lab=_72573_/B }
C {devices/lab_pin.sym} 13600 -15450 0 0 {name=p13400 lab=_79427_/B }
C {devices/lab_pin.sym} 13720 -15490 0 1 {name=p13401 lab=_72565_/Y }
C {sky130_stdcells/nor3_4.sym} 13660 -15490 0 0 {name=X_72565_ }
C {devices/lab_pin.sym} 13600 -15360 0 0 {name=p13402 lab=_57499_/A }
C {devices/lab_pin.sym} 13600 -15320 0 0 {name=p13403 lab=_47853_/Y }
C {devices/lab_pin.sym} 13720 -15340 0 1 {name=p13404 lab=_57499_/Y }
C {sky130_stdcells/nand2_4.sym} 13660 -15340 0 0 {name=X_57499_ }
C {devices/lab_pin.sym} 13600 -15230 0 0 {name=p13405 lab=_74302_/X }
C {devices/lab_pin.sym} 13600 -15190 0 0 {name=p13406 lab=_74310_/B }
C {devices/lab_pin.sym} 13600 -15150 0 0 {name=p13407 lab=_55927_/X }
C {devices/lab_pin.sym} 13720 -15190 0 1 {name=p13408 lab=_74304_/Y }
C {sky130_stdcells/nand3_4.sym} 13660 -15190 0 0 {name=X_74304_ }
C {devices/lab_pin.sym} 13620 -15050 0 0 {name=p13409 lab=_59238_/A }
C {devices/lab_pin.sym} 13700 -15050 0 1 {name=p13410 lab=_59238_/X }
C {sky130_stdcells/buf_2.sym} 13660 -15050 0 0 {name=X_59238_ }
C {devices/lab_pin.sym} 13580 -14950 0 0 {name=p13411 lab=_53236_/B }
C {devices/lab_pin.sym} 13580 -14910 0 0 {name=p13412 lab=_71508_/X }
C {devices/lab_pin.sym} 13580 -14870 0 0 {name=p13413 lab=_71515_/Y }
C {devices/lab_pin.sym} 13740 -14910 0 1 {name=p13414 lab=_83471_/D }
C {sky130_stdcells/o21ai_4.sym} 13660 -14910 0 0 {name=X_71516_ }
C {devices/lab_pin.sym} 13620 -14770 0 0 {name=p13415 lab=_54106_/B }
C {devices/lab_pin.sym} 13700 -14770 0 1 {name=p13416 lab=_52940_/B }
C {sky130_stdcells/buf_2.sym} 13660 -14770 0 0 {name=X_47252_ }
C {devices/lab_pin.sym} 13600 -14660 0 0 {name=p13417 lab=_60744_/C }
C {devices/lab_pin.sym} 13600 -14620 0 0 {name=p13418 lab=_78072_/B }
C {devices/lab_pin.sym} 13720 -14640 0 1 {name=p13419 lab=_78072_/X }
C {sky130_stdcells/xor2_4.sym} 13660 -14640 0 0 {name=X_78072_ }
C {devices/lab_pin.sym} 13620 -14510 0 0 {name=p13420 lab=_44602_/A }
C {devices/lab_pin.sym} 13700 -14510 0 1 {name=p13421 lab=_44464_/X }
C {sky130_stdcells/buf_2.sym} 13660 -14510 0 0 {name=X_44464_ }
C {devices/lab_pin.sym} 13600 -14400 0 0 {name=p13422 lab=_75284_/A }
C {devices/lab_pin.sym} 13600 -14360 0 0 {name=p13423 lab=_75283_/Y }
C {devices/lab_pin.sym} 13720 -14380 0 1 {name=p13424 lab=_75284_/X }
C {sky130_stdcells/xor2_4.sym} 13660 -14380 0 0 {name=X_75284_ }
C {devices/lab_pin.sym} 13620 -14250 0 0 {name=p13425 lab=_41675_/X }
C {devices/lab_pin.sym} 13700 -14250 0 1 {name=p13426 lab=_41676_/X }
C {sky130_stdcells/buf_2.sym} 13660 -14250 0 0 {name=X_41676_ }
C {devices/lab_pin.sym} 13600 -14140 0 0 {name=p13427 lab=_64454_/A }
C {devices/lab_pin.sym} 13600 -14100 0 0 {name=p13428 lab=_72498_/B }
C {devices/lab_pin.sym} 13720 -14120 0 1 {name=p13429 lab=_72496_/Y }
C {sky130_stdcells/nand2_4.sym} 13660 -14120 0 0 {name=X_72496_ }
C {devices/lab_pin.sym} 13620 -13990 0 0 {name=p13430 lab=_58273_/A }
C {devices/lab_pin.sym} 13700 -13990 0 1 {name=p13431 lab=_58160_/B }
C {sky130_stdcells/buf_2.sym} 13660 -13990 0 0 {name=X_46203_ }
C {sky130_stdcells/decap_3.sym} 13660 -13840 0 0 {name=XPHY_150 }
C {devices/lab_pin.sym} 13600 -13700 0 0 {name=p13432 lab=_77023_/A }
C {devices/lab_pin.sym} 13600 -13660 0 0 {name=p13433 lab=_77023_/B }
C {devices/lab_pin.sym} 13720 -13680 0 1 {name=p13434 lab=_77034_/B }
C {sky130_stdcells/xor2_4.sym} 13660 -13680 0 0 {name=X_77023_ }
C {devices/lab_pin.sym} 13580 -13590 0 0 {name=p13435 lab=_43399_/X }
C {devices/lab_pin.sym} 13580 -13550 0 0 {name=p13436 lab=_43404_/X }
C {devices/lab_pin.sym} 13580 -13510 0 0 {name=p13437 lab=_41515_/X }
C {devices/lab_pin.sym} 13580 -13470 0 0 {name=p13438 lab=_87432_/Q }
C {devices/lab_pin.sym} 13580 -13430 0 0 {name=p13439 lab=_43407_/X }
C {devices/lab_pin.sym} 13740 -13510 0 1 {name=p13440 lab=_43416_/A }
C {sky130_stdcells/o32ai_4.sym} 13660 -13510 0 0 {name=X_43415_ }
C {devices/lab_pin.sym} 13580 -13380 0 0 {name=p13441 lab=_44270_/X }
C {devices/lab_pin.sym} 13580 -13340 0 0 {name=p13442 lab=_85604_/Q }
C {devices/lab_pin.sym} 13580 -13300 0 0 {name=p13443 lab=_44272_/X }
C {devices/lab_pin.sym} 13580 -13260 0 0 {name=p13444 lab=_74234_/X }
C {devices/lab_pin.sym} 13740 -13320 0 1 {name=p13445 lab=_74235_/X }
C {sky130_stdcells/a211o_4.sym} 13660 -13320 0 0 {name=X_74235_ }
C {sky130_stdcells/decap_3.sym} 13660 -13140 0 0 {name=XPHY_161 }
C {devices/lab_pin.sym} 13580 -13020 0 0 {name=p13446 lab=_40626_/X }
C {devices/lab_pin.sym} 13580 -12980 0 0 {name=p13447 lab=_40596_/X }
C {devices/lab_pin.sym} 13580 -12940 0 0 {name=p13448 lab=_88364_/Q }
C {devices/lab_pin.sym} 13580 -12900 0 0 {name=p13449 lab=_40599_/X }
C {devices/lab_pin.sym} 13740 -12960 0 1 {name=p13450 lab=_88364_/D }
C {sky130_stdcells/a2bb2o_4.sym} 13660 -12960 0 0 {name=X_40627_ }
C {devices/lab_pin.sym} 13620 -12810 0 0 {name=p13451 lab=_47183_/A }
C {devices/lab_pin.sym} 13700 -12810 0 1 {name=p13452 lab=_47184_/A }
C {sky130_stdcells/inv_2.sym} 13660 -12810 0 0 {name=X_47183_ }
C {devices/lab_pin.sym} 13620 -12690 0 0 {name=p13453 lab=_58766_/A }
C {devices/lab_pin.sym} 13700 -12690 0 1 {name=p13454 lab=_59169_/X }
C {sky130_stdcells/buf_2.sym} 13660 -12690 0 0 {name=X_59169_ }
C {devices/lab_pin.sym} 13620 -12570 0 0 {name=p13455 lab=_71446_/X }
C {devices/lab_pin.sym} 13700 -12570 0 1 {name=p13456 lab=_71626_/C }
C {sky130_stdcells/buf_2.sym} 13660 -12570 0 0 {name=X_71447_ }
C {devices/lab_pin.sym} 13620 -12450 0 0 {name=p13457 lab=_44454_/A }
C {devices/lab_pin.sym} 13700 -12450 0 1 {name=p13458 lab=_44395_/X }
C {sky130_stdcells/buf_2.sym} 13660 -12450 0 0 {name=X_44395_ }
C {sky130_stdcells/decap_3.sym} 13660 -12300 0 0 {name=XPHY_172 }
C {sky130_stdcells/decap_3.sym} 13660 -12120 0 0 {name=XPHY_183 }
C {devices/lab_pin.sym} 13620 -11970 0 0 {name=p13459 lab=clkbuf_8_63_0_CLK/A }
C {devices/lab_pin.sym} 13700 -11970 0 1 {name=p13460 lab=clkbuf_8_63_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 13660 -11970 0 0 {name=Xclkbuf_8_63_0_CLK }
C {sky130_stdcells/decap_3.sym} 13660 -11820 0 0 {name=XPHY_194 }
C {devices/lab_pin.sym} 13600 -11690 0 0 {name=p13461 lab=_66518_/B }
C {devices/lab_pin.sym} 13600 -11650 0 0 {name=p13462 lab=_59771_/X }
C {devices/lab_pin.sym} 13600 -11610 0 0 {name=p13463 lab=_61200_/C }
C {devices/lab_pin.sym} 13720 -11650 0 1 {name=p13464 lab=_61200_/X }
C {sky130_stdcells/or3_4.sym} 13660 -11650 0 0 {name=X_61200_ }
C {devices/lab_pin.sym} 13620 -11510 0 0 {name=p13465 lab=_46134_/A }
C {devices/lab_pin.sym} 13700 -11510 0 1 {name=p13466 lab=_46135_/A }
C {sky130_stdcells/inv_2.sym} 13660 -11510 0 0 {name=X_46134_ }
C {devices/lab_pin.sym} 13580 -11420 0 0 {name=p13467 lab=_41328_/X }
C {devices/lab_pin.sym} 13580 -11380 0 0 {name=p13468 lab=_43336_/X }
C {devices/lab_pin.sym} 13580 -11340 0 0 {name=p13469 lab=_87467_/Q }
C {devices/lab_pin.sym} 13580 -11300 0 0 {name=p13470 lab=_43337_/X }
C {devices/lab_pin.sym} 13740 -11360 0 1 {name=p13471 lab=_87467_/D }
C {sky130_stdcells/a2bb2o_4.sym} 13660 -11360 0 0 {name=X_43346_ }
C {devices/lab_pin.sym} 13620 -11210 0 0 {name=p13472 lab=_62179_/X }
C {devices/lab_pin.sym} 13700 -11210 0 1 {name=p13473 lab=_62181_/B }
C {sky130_stdcells/buf_2.sym} 13660 -11210 0 0 {name=X_62180_ }
C {devices/lab_pin.sym} 13600 -11100 0 0 {name=p13474 lab=_74166_/A }
C {devices/lab_pin.sym} 13600 -11060 0 0 {name=p13475 lab=_74073_/X }
C {devices/lab_pin.sym} 13720 -11080 0 1 {name=p13476 lab=_74166_/Y }
C {sky130_stdcells/nor2_4.sym} 13660 -11080 0 0 {name=X_74166_ }
C {devices/lab_pin.sym} 13600 -10960 0 0 {name=p13477 lab=_40558_/A }
C {devices/lab_pin.sym} 13600 -10920 0 0 {name=p13478 lab=_48606_/A }
C {devices/lab_pin.sym} 13720 -10940 0 1 {name=p13479 lab=_40558_/X }
C {sky130_stdcells/or2_4.sym} 13660 -10940 0 0 {name=X_40558_ }
C {devices/lab_pin.sym} 13580 -10830 0 0 {name=p13480 lab=_71373_/X }
C {devices/lab_pin.sym} 13580 -10790 0 0 {name=p13481 lab=_83521_/Q }
C {devices/lab_pin.sym} 13580 -10750 0 0 {name=p13482 lab=_71377_/Y }
C {devices/lab_pin.sym} 13740 -10790 0 1 {name=p13483 lab=_83521_/D }
C {sky130_stdcells/a21o_4.sym} 13660 -10790 0 0 {name=X_71378_ }
C {devices/lab_pin.sym} 13600 -10660 0 0 {name=p13484 lab=_61153_/A }
C {devices/lab_pin.sym} 13600 -10620 0 0 {name=p13485 lab=_61202_/B }
C {devices/lab_pin.sym} 13720 -10640 0 1 {name=p13486 lab=_61131_/Y }
C {sky130_stdcells/nand2_4.sym} 13660 -10640 0 0 {name=X_61131_ }
C {devices/lab_pin.sym} 13600 -10520 0 0 {name=p13487 lab=_73186_/A }
C {devices/lab_pin.sym} 13600 -10480 0 0 {name=p13488 lab=_86516_/Q }
C {devices/lab_pin.sym} 13720 -10500 0 1 {name=p13489 lab=_73117_/X }
C {sky130_stdcells/and2_4.sym} 13660 -10500 0 0 {name=X_73117_ }
C {devices/lab_pin.sym} 13580 -10390 0 0 {name=p13490 lab=_70320_/X }
C {devices/lab_pin.sym} 13580 -10350 0 0 {name=p13491 lab=_74742_/B }
C {devices/lab_pin.sym} 13580 -10310 0 0 {name=p13492 lab=_70328_/X }
C {devices/lab_pin.sym} 13740 -10350 0 1 {name=p13493 lab=_70329_/X }
C {sky130_stdcells/a21o_4.sym} 13660 -10350 0 0 {name=X_70329_ }
C {devices/lab_pin.sym} 13620 -10210 0 0 {name=p13494 lab=_46065_/A }
C {devices/lab_pin.sym} 13700 -10210 0 1 {name=p13495 lab=_86786_/D }
C {sky130_stdcells/inv_2.sym} 13660 -10210 0 0 {name=X_46065_ }
C {devices/lab_pin.sym} 13620 -10090 0 0 {name=p13496 lab=_43180_/A }
C {devices/lab_pin.sym} 13700 -10090 0 1 {name=p13497 lab=_43277_/X }
C {sky130_stdcells/buf_2.sym} 13660 -10090 0 0 {name=X_43277_ }
C {devices/lab_pin.sym} 13600 -9980 0 0 {name=p13498 lab=_74097_/A }
C {devices/lab_pin.sym} 13600 -9940 0 0 {name=p13499 lab=_74073_/X }
C {devices/lab_pin.sym} 13720 -9960 0 1 {name=p13500 lab=_74097_/Y }
C {sky130_stdcells/nor2_4.sym} 13660 -9960 0 0 {name=X_74097_ }
C {devices/lab_pin.sym} 13600 -9840 0 0 {name=p13501 lab=_78979_/A }
C {devices/lab_pin.sym} 13600 -9800 0 0 {name=p13502 lab=_78979_/B }
C {devices/lab_pin.sym} 13720 -9820 0 1 {name=p13503 lab=_78975_/B }
C {sky130_stdcells/xor2_4.sym} 13660 -9820 0 0 {name=X_78974_ }
C {devices/lab_pin.sym} 13600 -9700 0 0 {name=p13504 lab=_40489_/A }
C {devices/lab_pin.sym} 13600 -9660 0 0 {name=p13505 lab=_40471_/X }
C {devices/lab_pin.sym} 13720 -9680 0 1 {name=p13506 lab=_40489_/X }
C {sky130_stdcells/or2_4.sym} 13660 -9680 0 0 {name=X_40489_ }
C {devices/lab_pin.sym} 13580 -9570 0 0 {name=p13507 lab=_56395_/C }
C {devices/lab_pin.sym} 13580 -9530 0 0 {name=p13508 lab=_44945_/X }
C {devices/lab_pin.sym} 13580 -9490 0 0 {name=p13509 lab=_45015_/X }
C {devices/lab_pin.sym} 13740 -9530 0 1 {name=p13510 lab=_45016_/Y }
C {sky130_stdcells/o21ai_4.sym} 13660 -9530 0 0 {name=X_45016_ }
C {devices/lab_pin.sym} 13620 -9390 0 0 {name=p13511 lab=_42276_/A }
C {devices/lab_pin.sym} 13700 -9390 0 1 {name=p13512 lab=_42228_/X }
C {sky130_stdcells/buf_2.sym} 13660 -9390 0 0 {name=X_42228_ }
C {devices/lab_pin.sym} 13580 -9310 0 0 {name=p13513 lab=_60880_/X }
C {devices/lab_pin.sym} 13580 -9270 0 0 {name=p13514 lab=_61037_/A }
C {devices/lab_pin.sym} 13580 -9230 0 0 {name=p13515 lab=_60891_/Y }
C {devices/lab_pin.sym} 13580 -9190 0 0 {name=p13516 lab=_61041_/Y }
C {devices/lab_pin.sym} 13580 -9160 0 0 {name=p13517 lab=_61061_/Y }
C {devices/lab_pin.sym} 13740 -9230 0 1 {name=p13518 lab=_61062_/Y }
C {sky130_stdcells/a41oi_4.sym} 13660 -9230 0 0 {name=X_61062_ }
C {devices/lab_pin.sym} 13600 -9080 0 0 {name=p13519 lab=_74414_/B }
C {devices/lab_pin.sym} 13600 -9040 0 0 {name=p13520 lab=_73048_/B }
C {devices/lab_pin.sym} 13720 -9060 0 1 {name=p13521 lab=_73048_/X }
C {sky130_stdcells/xor2_4.sym} 13660 -9060 0 0 {name=X_73048_ }
C {devices/lab_pin.sym} 13620 -8930 0 0 {name=p13522 lab=_82072_/Q }
C {devices/lab_pin.sym} 13700 -8930 0 1 {name=p13523 lab=_77925_/Y }
C {sky130_stdcells/inv_2.sym} 13660 -8930 0 0 {name=X_77925_ }
C {devices/lab_pin.sym} 13620 -8810 0 0 {name=p13524 lab=clkbuf_8_79_0_CLK/A }
C {devices/lab_pin.sym} 13700 -8810 0 1 {name=p13525 lab=clkbuf_8_78_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 13660 -8810 0 0 {name=Xclkbuf_8_78_0_CLK }
C {devices/lab_pin.sym} 13620 -8690 0 0 {name=p13526 lab=_45943_/A }
C {devices/lab_pin.sym} 13700 -8690 0 1 {name=p13527 lab=_60109_/A }
