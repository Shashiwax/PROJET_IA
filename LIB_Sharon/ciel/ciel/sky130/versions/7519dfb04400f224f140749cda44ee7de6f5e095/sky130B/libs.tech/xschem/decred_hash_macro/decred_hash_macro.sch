C {sky130_stdcells/nand2_4.sym} 49540 -26360 0 0 {name=X_80585_ }
C {sky130_stdcells/decap_3.sym} 49540 -26200 0 0 {name=XPHY_317 }
C {sky130_stdcells/decap_3.sym} 49540 -26020 0 0 {name=XPHY_328 }
C {devices/lab_pin.sym} 49450 -25870 0 0 {name=p48890 lab=_85144_/CLK }
C {devices/lab_pin.sym} 49450 -25850 0 0 {name=p48891 lab=_85112_/D }
C {devices/lab_pin.sym} 49630 -25870 0 1 {name=p48892 lab=_45535_/A }
C {sky130_stdcells/dfxtp_4.sym} 49540 -25860 0 0 {name=X_85112_ }
C {sky130_stdcells/decap_3.sym} 49540 -25700 0 0 {name=XPHY_339 }
C {devices/lab_pin.sym} 49500 -25550 0 0 {name=p48893 lab=_51504_/A }
C {devices/lab_pin.sym} 49580 -25550 0 1 {name=p48894 lab=_51527_/B }
C {sky130_stdcells/buf_2.sym} 49540 -25550 0 0 {name=X_51504_ }
C {devices/lab_pin.sym} 49480 -25440 0 0 {name=p48895 lab=_86632_/Q }
C {devices/lab_pin.sym} 49480 -25400 0 0 {name=p48896 lab=_58136_/B }
C {devices/lab_pin.sym} 49600 -25420 0 1 {name=p48897 lab=_58060_/Y }
C {sky130_stdcells/nor2_4.sym} 49540 -25420 0 0 {name=X_58060_ }
C {devices/lab_pin.sym} 49450 -25290 0 0 {name=p48898 lab=_82327_/CLK }
C {devices/lab_pin.sym} 49450 -25270 0 0 {name=p48899 lab=_77132_/B }
C {devices/lab_pin.sym} 49630 -25290 0 1 {name=p48900 lab=_82324_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -25280 0 0 {name=X_82324_ }
C {devices/lab_pin.sym} 49500 -25150 0 0 {name=p48901 lab=_55272_/A }
C {devices/lab_pin.sym} 49580 -25150 0 1 {name=p48902 lab=_55272_/X }
C {sky130_stdcells/buf_2.sym} 49540 -25150 0 0 {name=X_55272_ }
C {devices/lab_pin.sym} 49460 -25050 0 0 {name=p48903 lab=_80901_/D }
C {devices/lab_pin.sym} 49460 -25010 0 0 {name=p48904 lab=_67211_/X }
C {devices/lab_pin.sym} 49460 -24970 0 0 {name=p48905 lab=_67257_/X }
C {devices/lab_pin.sym} 49620 -25010 0 1 {name=p48906 lab=_67258_/X }
C {sky130_stdcells/a21bo_4.sym} 49540 -25010 0 0 {name=X_67258_ }
C {devices/lab_pin.sym} 49450 -24870 0 0 {name=p48907 lab=_85773_/CLK }
C {devices/lab_pin.sym} 49450 -24850 0 0 {name=p48908 lab=_51002_/Y }
C {devices/lab_pin.sym} 49630 -24870 0 1 {name=p48909 lab=_86092_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -24860 0 0 {name=X_86092_ }
C {devices/lab_pin.sym} 49480 -24740 0 0 {name=p48910 lab=_52476_/A }
C {devices/lab_pin.sym} 49480 -24700 0 0 {name=p48911 lab=_52484_/B }
C {devices/lab_pin.sym} 49600 -24720 0 1 {name=p48912 lab=_52484_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -24720 0 0 {name=X_52484_ }
C {devices/lab_pin.sym} 49480 -24620 0 0 {name=p48913 lab=_56783_/X }
C {devices/lab_pin.sym} 49480 -24580 0 0 {name=p48914 lab=_56700_/Y }
C {devices/lab_pin.sym} 49480 -24540 0 0 {name=p48915 lab=_56768_/Y }
C {devices/lab_pin.sym} 49480 -24500 0 0 {name=p48916 lab=_57024_/D }
C {devices/lab_pin.sym} 49600 -24560 0 1 {name=p48917 lab=_57011_/Y }
C {sky130_stdcells/nand4_4.sym} 49540 -24560 0 0 {name=X_57011_ }
C {devices/lab_pin.sym} 49480 -24420 0 0 {name=p48918 lab=_54230_/A }
C {devices/lab_pin.sym} 49480 -24380 0 0 {name=p48919 lab=_53054_/B }
C {devices/lab_pin.sym} 49600 -24400 0 1 {name=p48920 lab=_54223_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -24400 0 0 {name=X_54223_ }
C {devices/lab_pin.sym} 49480 -24280 0 0 {name=p48921 lab=_65763_/A }
C {devices/lab_pin.sym} 49480 -24240 0 0 {name=p48922 lab=_66209_/B }
C {devices/lab_pin.sym} 49600 -24260 0 1 {name=p48923 lab=_66209_/X }
C {sky130_stdcells/and2_4.sym} 49540 -24260 0 0 {name=X_66209_ }
C {devices/lab_pin.sym} 49450 -24130 0 0 {name=p48924 lab=_85042_/CLK }
C {devices/lab_pin.sym} 49450 -24110 0 0 {name=p48925 lab=_85043_/D }
C {devices/lab_pin.sym} 49630 -24130 0 1 {name=p48926 lab=_45617_/A }
C {sky130_stdcells/dfxtp_4.sym} 49540 -24120 0 0 {name=X_85043_ }
C {devices/lab_pin.sym} 49480 -24000 0 0 {name=p48927 lab=_51430_/X }
C {devices/lab_pin.sym} 49480 -23960 0 0 {name=p48928 lab=_52965_/B }
C {devices/lab_pin.sym} 49600 -23980 0 1 {name=p48929 lab=_51435_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -23980 0 0 {name=X_51435_ }
C {devices/lab_pin.sym} 49450 -23850 0 0 {name=p48930 lab=_85381_/CLK }
C {devices/lab_pin.sym} 49450 -23830 0 0 {name=p48931 lab=_80438_/Y }
C {devices/lab_pin.sym} 49630 -23850 0 1 {name=p48932 lab=_82255_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -23840 0 0 {name=X_82255_ }
C {devices/lab_pin.sym} 49460 -23740 0 0 {name=p48933 lab=_87929_/Q }
C {devices/lab_pin.sym} 49460 -23700 0 0 {name=p48934 lab=_67117_/X }
C {devices/lab_pin.sym} 49460 -23660 0 0 {name=p48935 lab=_67167_/X }
C {devices/lab_pin.sym} 49460 -23620 0 0 {name=p48936 lab=_67188_/X }
C {devices/lab_pin.sym} 49620 -23680 0 1 {name=p48937 lab=_67189_/X }
C {sky130_stdcells/a211o_4.sym} 49540 -23680 0 0 {name=X_67189_ }
C {devices/lab_pin.sym} 49450 -23530 0 0 {name=p48938 lab=_81197_/CLK }
C {devices/lab_pin.sym} 49450 -23510 0 0 {name=p48939 lab=_75045_/X }
C {devices/lab_pin.sym} 49630 -23530 0 1 {name=p48940 lab=_48996_/A }
C {sky130_stdcells/dfxtp_4.sym} 49540 -23520 0 0 {name=X_81206_ }
C {devices/lab_pin.sym} 49460 -23410 0 0 {name=p48941 lab=_85494_/Q }
C {devices/lab_pin.sym} 49460 -23370 0 0 {name=p48942 lab=_54140_/X }
C {devices/lab_pin.sym} 49460 -23330 0 0 {name=p48943 lab=_54153_/Y }
C {devices/lab_pin.sym} 49620 -23370 0 1 {name=p48944 lab=_54154_/Y }
C {sky130_stdcells/o21ai_4.sym} 49540 -23370 0 0 {name=X_54154_ }
C {devices/lab_pin.sym} 49500 -23230 0 0 {name=p48945 lab=_51793_/A }
C {devices/lab_pin.sym} 49580 -23230 0 1 {name=p48946 lab=_51366_/X }
C {sky130_stdcells/buf_2.sym} 49540 -23230 0 0 {name=X_51366_ }
C {devices/lab_pin.sym} 49450 -23110 0 0 {name=p48947 lab=_84951_/CLK }
C {devices/lab_pin.sym} 49450 -23090 0 0 {name=p48948 lab=_82186_/D }
C {devices/lab_pin.sym} 49630 -23110 0 1 {name=p48949 lab=_82186_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -23100 0 0 {name=X_82186_ }
C {devices/lab_pin.sym} 49480 -22980 0 0 {name=p48950 lab=_53115_/A }
C {devices/lab_pin.sym} 49480 -22940 0 0 {name=p48951 lab=_53105_/B }
C {devices/lab_pin.sym} 49600 -22960 0 1 {name=p48952 lab=_53105_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -22960 0 0 {name=X_53105_ }
C {devices/lab_pin.sym} 49500 -22830 0 0 {name=p48953 lab=_50500_/A }
C {devices/lab_pin.sym} 49580 -22830 0 1 {name=p48954 lab=_50317_/X }
C {sky130_stdcells/buf_2.sym} 49540 -22830 0 0 {name=X_50317_ }
C {devices/lab_pin.sym} 49450 -22710 0 0 {name=p48955 lab=_80968_/CLK }
C {devices/lab_pin.sym} 49450 -22690 0 0 {name=p48956 lab=_81137_/D }
C {devices/lab_pin.sym} 49630 -22710 0 1 {name=p48957 lab=_40676_/A }
C {sky130_stdcells/dfxtp_4.sym} 49540 -22700 0 0 {name=X_81137_ }
C {devices/lab_pin.sym} 49460 -22590 0 0 {name=p48958 lab=_58961_/X }
C {devices/lab_pin.sym} 49460 -22550 0 0 {name=p48959 lab=_85922_/Q }
C {devices/lab_pin.sym} 49460 -22510 0 0 {name=p48960 lab=_58900_/X }
C {devices/lab_pin.sym} 49620 -22550 0 1 {name=p48961 lab=_58962_/X }
C {sky130_stdcells/o21a_4.sym} 49540 -22550 0 0 {name=X_58962_ }
C {devices/lab_pin.sym} 49480 -22420 0 0 {name=p48962 lab=_54068_/X }
C {devices/lab_pin.sym} 49480 -22380 0 0 {name=p48963 lab=_46585_/Y }
C {devices/lab_pin.sym} 49600 -22400 0 1 {name=p48964 lab=_54085_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -22400 0 0 {name=X_54085_ }
C {devices/lab_pin.sym} 49460 -22290 0 0 {name=p48965 lab=_64920_/B }
C {devices/lab_pin.sym} 49460 -22250 0 0 {name=p48966 lab=_51285_/X }
C {devices/lab_pin.sym} 49460 -22210 0 0 {name=p48967 lab=_51296_/Y }
C {devices/lab_pin.sym} 49620 -22250 0 1 {name=p48968 lab=_51297_/Y }
C {sky130_stdcells/o21ai_4.sym} 49540 -22250 0 0 {name=X_51297_ }
C {devices/lab_pin.sym} 49450 -22110 0 0 {name=p48969 lab=_86998_/CLK }
C {devices/lab_pin.sym} 49450 -22090 0 0 {name=p48970 lab=_44702_/Y }
C {devices/lab_pin.sym} 49630 -22110 0 1 {name=p48971 lab=_86994_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -22100 0 0 {name=X_86994_ }
C {devices/lab_pin.sym} 49500 -21970 0 0 {name=p48972 lab=_41050_/A }
C {devices/lab_pin.sym} 49580 -21970 0 1 {name=p48973 lab=_41050_/X }
C {sky130_stdcells/buf_2.sym} 49540 -21970 0 0 {name=X_41050_ }
C {devices/lab_pin.sym} 49480 -21880 0 0 {name=p48974 lab=_53048_/A }
C {devices/lab_pin.sym} 49480 -21840 0 0 {name=p48975 lab=_53036_/B }
C {devices/lab_pin.sym} 49480 -21800 0 0 {name=p48976 lab=_53058_/C }
C {devices/lab_pin.sym} 49480 -21760 0 0 {name=p48977 lab=_53036_/D }
C {devices/lab_pin.sym} 49600 -21820 0 1 {name=p48978 lab=_53036_/X }
C {sky130_stdcells/and4_4.sym} 49540 -21820 0 0 {name=X_53036_ }
C {devices/lab_pin.sym} 49460 -21690 0 0 {name=p48979 lab=_57884_/X }
C {devices/lab_pin.sym} 49460 -21650 0 0 {name=p48980 lab=_85492_/Q }
C {devices/lab_pin.sym} 49460 -21610 0 0 {name=p48981 lab=_57763_/X }
C {devices/lab_pin.sym} 49620 -21650 0 1 {name=p48982 lab=_57913_/X }
C {sky130_stdcells/o21a_4.sym} 49540 -21650 0 0 {name=X_57913_ }
C {devices/lab_pin.sym} 49480 -21530 0 0 {name=p48983 lab=_48196_/A }
C {devices/lab_pin.sym} 49480 -21490 0 0 {name=p48984 lab=_74509_/C }
C {devices/lab_pin.sym} 49480 -21450 0 0 {name=p48985 lab=_50247_/X }
C {devices/lab_pin.sym} 49600 -21490 0 1 {name=p48986 lab=_50248_/X }
C {sky130_stdcells/and3_4.sym} 49540 -21490 0 0 {name=X_50248_ }
C {devices/lab_pin.sym} 49450 -21350 0 0 {name=p48987 lab=_82774_/CLK }
C {devices/lab_pin.sym} 49450 -21330 0 0 {name=p48988 lab=_51795_/Y }
C {devices/lab_pin.sym} 49630 -21350 0 1 {name=p48989 lab=_85945_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -21340 0 0 {name=X_85945_ }
C {devices/lab_pin.sym} 49450 -21210 0 0 {name=p48990 lab=_80813_/CLK }
C {devices/lab_pin.sym} 49450 -21190 0 0 {name=p48991 lab=_81100_/Q }
C {devices/lab_pin.sym} 49630 -21210 0 1 {name=p48992 lab=_81068_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -21200 0 0 {name=X_81068_ }
C {devices/lab_pin.sym} 49460 -21090 0 0 {name=p48993 lab=_58891_/X }
C {devices/lab_pin.sym} 49460 -21050 0 0 {name=p48994 lab=_86088_/Q }
C {devices/lab_pin.sym} 49460 -21010 0 0 {name=p48995 lab=_58892_/X }
C {devices/lab_pin.sym} 49620 -21050 0 1 {name=p48996 lab=_58893_/Y }
C {sky130_stdcells/o21ai_4.sym} 49540 -21050 0 0 {name=X_58893_ }
C {devices/lab_pin.sym} 49500 -20910 0 0 {name=p48997 lab=clkbuf_9_491_0_CLK/A }
C {devices/lab_pin.sym} 49580 -20910 0 1 {name=p48998 lab=clkbuf_9_490_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 49540 -20910 0 0 {name=Xclkbuf_9_490_0_CLK }
C {devices/lab_pin.sym} 49500 -20790 0 0 {name=p48999 lab=_72910_/A }
C {devices/lab_pin.sym} 49580 -20790 0 1 {name=p49000 lab=_73381_/A }
C {sky130_stdcells/buf_2.sym} 49540 -20790 0 0 {name=X_72910_ }
C {devices/lab_pin.sym} 49480 -20680 0 0 {name=p49001 lab=_80019_/A }
C {devices/lab_pin.sym} 49480 -20640 0 0 {name=p49002 lab=_80018_/X }
C {devices/lab_pin.sym} 49600 -20660 0 1 {name=p49003 lab=_80019_/Y }
C {sky130_stdcells/xnor2_4.sym} 49540 -20660 0 0 {name=X_80019_ }
C {devices/lab_pin.sym} 49500 -20530 0 0 {name=p49004 lab=_58805_/A }
C {devices/lab_pin.sym} 49580 -20530 0 1 {name=p49005 lab=_58676_/A }
C {sky130_stdcells/buf_2.sym} 49540 -20530 0 0 {name=X_57844_ }
C {devices/lab_pin.sym} 49460 -20430 0 0 {name=p49006 lab=_50693_/A }
C {devices/lab_pin.sym} 49460 -20390 0 0 {name=p49007 lab=_50693_/B }
C {devices/lab_pin.sym} 49460 -20350 0 0 {name=p49008 lab=_47848_/X }
C {devices/lab_pin.sym} 49620 -20390 0 1 {name=p49009 lab=_50179_/X }
C {sky130_stdcells/o21a_4.sym} 49540 -20390 0 0 {name=X_50179_ }
C {devices/lab_pin.sym} 49500 -20250 0 0 {name=p49010 lab=clkbuf_9_192_0_CLK/X }
C {devices/lab_pin.sym} 49580 -20250 0 1 {name=p49011 lab=_83218_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 49540 -20250 0 0 {name=Xclkbuf_10_384_0_CLK }
C {devices/lab_pin.sym} 49450 -20130 0 0 {name=p49012 lab=_86193_/CLK }
C {devices/lab_pin.sym} 49450 -20110 0 0 {name=p49013 lab=_85876_/D }
C {devices/lab_pin.sym} 49630 -20130 0 1 {name=p49014 lab=_85876_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -20120 0 0 {name=X_85876_ }
C {devices/lab_pin.sym} 49460 -20010 0 0 {name=p49015 lab=_70101_/Y }
C {devices/lab_pin.sym} 49460 -19970 0 0 {name=p49016 lab=_73818_/X }
C {devices/lab_pin.sym} 49460 -19930 0 0 {name=p49017 lab=_73889_/X }
C {devices/lab_pin.sym} 49620 -19970 0 1 {name=p49018 lab=_83132_/D }
C {sky130_stdcells/o21ai_4.sym} 49540 -19970 0 0 {name=X_73890_ }
C {devices/lab_pin.sym} 49450 -19830 0 0 {name=p49019 lab=_82888_/CLK }
C {devices/lab_pin.sym} 49450 -19810 0 0 {name=p49020 lab=_42992_/Y }
C {devices/lab_pin.sym} 49630 -19830 0 1 {name=p49021 lab=_87615_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -19820 0 0 {name=X_87615_ }
C {devices/lab_pin.sym} 49460 -19720 0 0 {name=p49022 lab=_72750_/X }
C {devices/lab_pin.sym} 49460 -19680 0 0 {name=p49023 lab=_85598_/Q }
C {devices/lab_pin.sym} 49460 -19640 0 0 {name=p49024 lab=_72839_/X }
C {devices/lab_pin.sym} 49460 -19600 0 0 {name=p49025 lab=_72840_/X }
C {devices/lab_pin.sym} 49620 -19660 0 1 {name=p49026 lab=_72841_/X }
C {sky130_stdcells/a211o_4.sym} 49540 -19660 0 0 {name=X_72841_ }
C {devices/lab_pin.sym} 49450 -19510 0 0 {name=p49027 lab=_84829_/CLK }
C {devices/lab_pin.sym} 49450 -19490 0 0 {name=p49028 lab=_84827_/D }
C {devices/lab_pin.sym} 49630 -19510 0 1 {name=p49029 lab=_64379_/C }
C {sky130_stdcells/dfxtp_4.sym} 49540 -19500 0 0 {name=X_84827_ }
C {devices/lab_pin.sym} 49460 -19390 0 0 {name=p49030 lab=_72476_/B }
C {devices/lab_pin.sym} 49460 -19350 0 0 {name=p49031 lab=_86013_/Q }
C {devices/lab_pin.sym} 49460 -19310 0 0 {name=p49032 lab=_57774_/X }
C {devices/lab_pin.sym} 49620 -19350 0 1 {name=p49033 lab=_57775_/Y }
C {sky130_stdcells/o21ai_4.sym} 49540 -19350 0 0 {name=X_57775_ }
C {devices/lab_pin.sym} 49480 -19240 0 0 {name=p49034 lab=_54964_/A }
C {devices/lab_pin.sym} 49480 -19200 0 0 {name=p49035 lab=_54978_/X }
C {devices/lab_pin.sym} 49480 -19160 0 0 {name=p49036 lab=_54974_/C }
C {devices/lab_pin.sym} 49480 -19120 0 0 {name=p49037 lab=_47578_/A }
C {devices/lab_pin.sym} 49600 -19180 0 1 {name=p49038 lab=_54987_/X }
C {sky130_stdcells/and4_4.sym} 49540 -19180 0 0 {name=X_54987_ }
C {devices/lab_pin.sym} 49500 -19030 0 0 {name=p49039 lab=_59538_/C }
C {devices/lab_pin.sym} 49580 -19030 0 1 {name=p49040 lab=_59521_/A }
C {sky130_stdcells/inv_2.sym} 49540 -19030 0 0 {name=X_59514_ }
C {devices/lab_pin.sym} 49500 -18910 0 0 {name=p49041 lab=_44528_/A }
C {devices/lab_pin.sym} 49580 -18910 0 1 {name=p49042 lab=_44740_/X }
C {sky130_stdcells/buf_2.sym} 49540 -18910 0 0 {name=X_44740_ }
C {devices/lab_pin.sym} 49500 -18790 0 0 {name=p49043 lab=_56684_/C }
C {devices/lab_pin.sym} 49580 -18790 0 1 {name=p49044 lab=_56726_/X }
C {sky130_stdcells/buf_2.sym} 49540 -18790 0 0 {name=X_56726_ }
C {devices/lab_pin.sym} 49500 -18670 0 0 {name=p49045 lab=_75559_/X }
C {devices/lab_pin.sym} 49580 -18670 0 1 {name=p49046 lab=_75561_/B }
C {sky130_stdcells/inv_2.sym} 49540 -18670 0 0 {name=X_75560_ }
C {devices/lab_pin.sym} 49450 -18550 0 0 {name=p49047 lab=_88062_/CLK }
C {devices/lab_pin.sym} 49450 -18530 0 0 {name=p49048 lab=_87546_/D }
C {devices/lab_pin.sym} 49630 -18550 0 1 {name=p49049 lab=_43190_/A }
C {sky130_stdcells/dfxtp_4.sym} 49540 -18540 0 0 {name=X_87546_ }
C {devices/lab_pin.sym} 49480 -18430 0 0 {name=p49050 lab=_50209_/A }
C {devices/lab_pin.sym} 49480 -18390 0 0 {name=p49051 lab=_53875_/B }
C {devices/lab_pin.sym} 49480 -18350 0 0 {name=p49052 lab=_53888_/C }
C {devices/lab_pin.sym} 49600 -18390 0 1 {name=p49053 lab=_53938_/X }
C {sky130_stdcells/and3_4.sym} 49540 -18390 0 0 {name=X_53938_ }
C {devices/lab_pin.sym} 49500 -18250 0 0 {name=p49054 lab=_41881_/A }
C {devices/lab_pin.sym} 49580 -18250 0 1 {name=p49055 lab=_42025_/A }
C {sky130_stdcells/buf_2.sym} 49540 -18250 0 0 {name=X_41952_ }
C {devices/lab_pin.sym} 49480 -18140 0 0 {name=p49056 lab=_87314_/Q }
C {devices/lab_pin.sym} 49480 -18100 0 0 {name=p49057 lab=_72924_/B }
C {devices/lab_pin.sym} 49600 -18120 0 1 {name=p49058 lab=_72772_/Y }
C {sky130_stdcells/nor2_4.sym} 49540 -18120 0 0 {name=X_72772_ }
C {devices/lab_pin.sym} 49450 -17990 0 0 {name=p49059 lab=_84760_/CLK }
C {devices/lab_pin.sym} 49450 -17970 0 0 {name=p49060 lab=_59243_/Y }
C {devices/lab_pin.sym} 49630 -17990 0 1 {name=p49061 lab=_59229_/A }
C {sky130_stdcells/dfxtp_4.sym} 49540 -17980 0 0 {name=X_84758_ }
C {devices/lab_pin.sym} 49480 -17860 0 0 {name=p49062 lab=_74466_/A }
C {devices/lab_pin.sym} 49480 -17820 0 0 {name=p49063 lab=_48704_/Y }
C {devices/lab_pin.sym} 49600 -17840 0 1 {name=p49064 lab=_74511_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -17840 0 0 {name=X_74511_ }
C {devices/lab_pin.sym} 49500 -17710 0 0 {name=p49065 lab=_40903_/A }
C {devices/lab_pin.sym} 49580 -17710 0 1 {name=p49066 lab=_40903_/X }
C {sky130_stdcells/buf_2.sym} 49540 -17710 0 0 {name=X_40903_ }
C {devices/lab_pin.sym} 49500 -17590 0 0 {name=p49067 lab=_70504_/A }
C {devices/lab_pin.sym} 49580 -17590 0 1 {name=p49068 lab=_71729_/A }
C {sky130_stdcells/buf_2.sym} 49540 -17590 0 0 {name=X_71723_ }
C {devices/lab_pin.sym} 49450 -17470 0 0 {name=p49069 lab=_83707_/CLK }
C {devices/lab_pin.sym} 49450 -17450 0 0 {name=p49070 lab=_70750_/Y }
C {devices/lab_pin.sym} 49630 -17470 0 1 {name=p49071 lab=_47561_/A }
C {sky130_stdcells/dfxtp_4.sym} 49540 -17460 0 0 {name=X_83709_ }
C {devices/lab_pin.sym} 49480 -17340 0 0 {name=p49072 lab=_59445_/A }
C {devices/lab_pin.sym} 49480 -17300 0 0 {name=p49073 lab=_59444_/X }
C {devices/lab_pin.sym} 49600 -17320 0 1 {name=p49074 lab=_59445_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -17320 0 0 {name=X_59445_ }
C {devices/lab_pin.sym} 49500 -17190 0 0 {name=p49075 lab=clkbuf_9_199_0_CLK/X }
C {devices/lab_pin.sym} 49580 -17190 0 1 {name=p49076 lab=_84187_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 49540 -17190 0 0 {name=Xclkbuf_10_399_0_CLK }
C {devices/lab_pin.sym} 49460 -17110 0 0 {name=p49077 lab=_44658_/X }
C {devices/lab_pin.sym} 49460 -17070 0 0 {name=p49078 lab=_44659_/X }
C {devices/lab_pin.sym} 49460 -17030 0 0 {name=p49079 lab=_40573_/X }
C {devices/lab_pin.sym} 49460 -16990 0 0 {name=p49080 lab=_87006_/Q }
C {devices/lab_pin.sym} 49460 -16950 0 0 {name=p49081 lab=_44660_/X }
C {devices/lab_pin.sym} 49620 -17030 0 1 {name=p49082 lab=_44672_/A }
C {sky130_stdcells/o32ai_4.sym} 49540 -17030 0 0 {name=X_44671_ }
C {devices/lab_pin.sym} 49480 -16880 0 0 {name=p49083 lab=_56912_/A }
C {devices/lab_pin.sym} 49480 -16840 0 0 {name=p49084 lab=_56645_/Y }
C {devices/lab_pin.sym} 49600 -16860 0 1 {name=p49085 lab=_56660_/A }
C {sky130_stdcells/nand2_4.sym} 49540 -16860 0 0 {name=X_56657_ }
C {devices/lab_pin.sym} 49450 -16730 0 0 {name=p49086 lab=_87952_/CLK }
C {devices/lab_pin.sym} 49450 -16710 0 0 {name=p49087 lab=_43332_/Y }
C {devices/lab_pin.sym} 49630 -16730 0 1 {name=p49088 lab=_87477_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -16720 0 0 {name=X_87477_ }
C {devices/lab_pin.sym} 49480 -16610 0 0 {name=p49089 lab=_75488_/Y }
C {devices/lab_pin.sym} 49480 -16570 0 0 {name=p49090 lab=_75491_/B }
C {devices/lab_pin.sym} 49480 -16530 0 0 {name=p49091 lab=_75491_/C }
C {devices/lab_pin.sym} 49600 -16570 0 1 {name=p49092 lab=_75492_/A }
C {sky130_stdcells/nand3_4.sym} 49540 -16570 0 0 {name=X_75491_ }
C {devices/lab_pin.sym} 49460 -16470 0 0 {name=p49093 lab=_57491_/B }
C {devices/lab_pin.sym} 49460 -16430 0 0 {name=p49094 lab=_41879_/X }
C {devices/lab_pin.sym} 49460 -16390 0 0 {name=p49095 lab=_40581_/X }
C {devices/lab_pin.sym} 49460 -16350 0 0 {name=p49096 lab=_73595_/A }
C {devices/lab_pin.sym} 49460 -16310 0 0 {name=p49097 lab=_41882_/X }
C {devices/lab_pin.sym} 49620 -16390 0 1 {name=p49098 lab=_41884_/A }
C {sky130_stdcells/o32ai_4.sym} 49540 -16390 0 0 {name=X_41883_ }
C {devices/lab_pin.sym} 49500 -16230 0 0 {name=p49099 lab=_53729_/A }
C {devices/lab_pin.sym} 49580 -16230 0 1 {name=p49100 lab=_53869_/X }
C {sky130_stdcells/buf_2.sym} 49540 -16230 0 0 {name=X_53869_ }
C {devices/lab_pin.sym} 49450 -16110 0 0 {name=p49101 lab=_84358_/CLK }
C {devices/lab_pin.sym} 49450 -16090 0 0 {name=p49102 lab=_84689_/D }
C {devices/lab_pin.sym} 49630 -16110 0 1 {name=p49103 lab=_80371_/A }
C {sky130_stdcells/dfxtp_4.sym} 49540 -16100 0 0 {name=X_84689_ }
C {devices/lab_pin.sym} 49500 -15970 0 0 {name=p49104 lab=_46410_/A }
C {devices/lab_pin.sym} 49580 -15970 0 1 {name=p49105 lab=_46411_/A }
C {sky130_stdcells/inv_2.sym} 49540 -15970 0 0 {name=X_46410_ }
C {devices/lab_pin.sym} 49480 -15870 0 0 {name=p49106 lab=_77230_/A }
C {devices/lab_pin.sym} 49480 -15830 0 0 {name=p49107 lab=_77230_/B }
C {devices/lab_pin.sym} 49480 -15790 0 0 {name=p49108 lab=_77230_/C }
C {devices/lab_pin.sym} 49600 -15830 0 1 {name=p49109 lab=_77230_/Y }
C {sky130_stdcells/nand3_4.sym} 49540 -15830 0 0 {name=X_77230_ }
C {devices/lab_pin.sym} 49500 -15690 0 0 {name=p49110 lab=_43622_/A }
C {devices/lab_pin.sym} 49580 -15690 0 1 {name=p49111 lab=_43622_/Y }
C {sky130_stdcells/inv_2.sym} 49540 -15690 0 0 {name=X_43622_ }
C {devices/lab_pin.sym} 49460 -15600 0 0 {name=p49112 lab=_85119_/Q }
C {devices/lab_pin.sym} 49460 -15560 0 0 {name=p49113 lab=_55605_/X }
C {devices/lab_pin.sym} 49460 -15520 0 0 {name=p49114 lab=_44090_/B }
C {devices/lab_pin.sym} 49460 -15480 0 0 {name=p49115 lab=_55607_/Y }
C {devices/lab_pin.sym} 49620 -15540 0 1 {name=p49116 lab=_55608_/X }
C {sky130_stdcells/a211o_4.sym} 49540 -15540 0 0 {name=X_55608_ }
C {devices/lab_pin.sym} 49500 -15390 0 0 {name=p49117 lab=_46280_/A }
C {devices/lab_pin.sym} 49580 -15390 0 1 {name=p49118 lab=_74442_/X }
C {sky130_stdcells/buf_2.sym} 49540 -15390 0 0 {name=X_74442_ }
C {devices/lab_pin.sym} 49450 -15270 0 0 {name=p49119 lab=_86246_/CLK }
C {devices/lab_pin.sym} 49450 -15250 0 0 {name=p49120 lab=_49236_/Y }
C {devices/lab_pin.sym} 49630 -15270 0 1 {name=p49121 lab=_64749_/B }
C {sky130_stdcells/dfxtp_4.sym} 49540 -15260 0 0 {name=X_86428_ }
C {devices/lab_pin.sym} 49500 -15130 0 0 {name=p49122 lab=_40833_/Y }
C {devices/lab_pin.sym} 49580 -15130 0 1 {name=p49123 lab=_88326_/D }
C {sky130_stdcells/inv_2.sym} 49540 -15130 0 0 {name=X_40834_ }
C {devices/lab_pin.sym} 49500 -15010 0 0 {name=p49124 lab=_81808_/Q }
C {devices/lab_pin.sym} 49580 -15010 0 1 {name=p49125 lab=_47391_/A }
C {sky130_stdcells/inv_2.sym} 49540 -15010 0 0 {name=X_47390_ }
C {devices/lab_pin.sym} 49480 -14900 0 0 {name=p49126 lab=_59326_/X }
C {devices/lab_pin.sym} 49480 -14860 0 0 {name=p49127 lab=_59376_/B }
C {devices/lab_pin.sym} 49600 -14880 0 1 {name=p49128 lab=_59376_/Y }
C {sky130_stdcells/nor2_4.sym} 49540 -14880 0 0 {name=X_59376_ }
C {devices/lab_pin.sym} 49500 -14750 0 0 {name=p49129 lab=_70426_/A }
C {devices/lab_pin.sym} 49580 -14750 0 1 {name=p49130 lab=_71660_/A }
C {sky130_stdcells/buf_2.sym} 49540 -14750 0 0 {name=X_71654_ }
C {devices/lab_pin.sym} 49480 -14640 0 0 {name=p49131 lab=_72648_/C }
C {devices/lab_pin.sym} 49480 -14600 0 0 {name=p49132 lab=_55570_/X }
C {devices/lab_pin.sym} 49600 -14620 0 1 {name=p49133 lab=_56589_/A }
C {sky130_stdcells/xnor2_4.sym} 49540 -14620 0 0 {name=X_56588_ }
C {devices/lab_pin.sym} 49460 -14510 0 0 {name=p49134 lab=_46336_/Y }
C {devices/lab_pin.sym} 49460 -14470 0 0 {name=p49135 lab=_46258_/X }
C {devices/lab_pin.sym} 49460 -14430 0 0 {name=p49136 lab=_46340_/Y }
C {devices/lab_pin.sym} 49620 -14470 0 1 {name=p49137 lab=_86746_/D }
C {sky130_stdcells/a21boi_4.sym} 49540 -14470 0 0 {name=X_46341_ }
C {devices/lab_pin.sym} 49500 -14330 0 0 {name=p49138 lab=_70994_/A }
C {devices/lab_pin.sym} 49580 -14330 0 1 {name=p49139 lab=_70717_/A }
C {sky130_stdcells/buf_2.sym} 49540 -14330 0 0 {name=X_70605_ }
C {devices/lab_pin.sym} 49460 -14230 0 0 {name=p49140 lab=_58310_/X }
C {devices/lab_pin.sym} 49460 -14190 0 0 {name=p49141 lab=_83453_/Q }
C {devices/lab_pin.sym} 49460 -14150 0 0 {name=p49142 lab=_58326_/Y }
C {devices/lab_pin.sym} 49620 -14190 0 1 {name=p49143 lab=_84877_/D }
C {sky130_stdcells/o21a_4.sym} 49540 -14190 0 0 {name=X_58327_ }
C {devices/lab_pin.sym} 49480 -14060 0 0 {name=p49144 lab=_77161_/A }
C {devices/lab_pin.sym} 49480 -14020 0 0 {name=p49145 lab=_77161_/B }
C {devices/lab_pin.sym} 49600 -14040 0 1 {name=p49146 lab=_77161_/X }
C {sky130_stdcells/xor2_4.sym} 49540 -14040 0 0 {name=X_77161_ }
C {devices/lab_pin.sym} 49480 -13920 0 0 {name=p49147 lab=_55498_/X }
C {devices/lab_pin.sym} 49480 -13880 0 0 {name=p49148 lab=_55539_/B }
C {devices/lab_pin.sym} 49600 -13900 0 1 {name=p49149 lab=_55539_/Y }
C {sky130_stdcells/nor2_4.sym} 49540 -13900 0 0 {name=X_55539_ }
C {devices/lab_pin.sym} 49500 -13770 0 0 {name=p49150 lab=_43553_/A }
C {devices/lab_pin.sym} 49580 -13770 0 1 {name=p49151 lab=_87364_/D }
C {sky130_stdcells/inv_2.sym} 49540 -13770 0 0 {name=X_43553_ }
C {devices/lab_pin.sym} 49480 -13660 0 0 {name=p49152 lab=_72068_/A }
C {devices/lab_pin.sym} 49480 -13620 0 0 {name=p49153 lab=_74373_/B }
C {devices/lab_pin.sym} 49600 -13640 0 1 {name=p49154 lab=_74373_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -13640 0 0 {name=X_74373_ }
C {devices/lab_pin.sym} 49450 -13510 0 0 {name=p49155 lab=_86359_/CLK }
C {devices/lab_pin.sym} 49450 -13490 0 0 {name=p49156 lab=_86359_/D }
C {devices/lab_pin.sym} 49630 -13510 0 1 {name=p49157 lab=_86359_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -13500 0 0 {name=X_86359_ }
C {devices/lab_pin.sym} 49480 -13380 0 0 {name=p49158 lab=_82881_/Q }
C {devices/lab_pin.sym} 49480 -13340 0 0 {name=p49159 lab=_40765_/B }
C {devices/lab_pin.sym} 49600 -13360 0 1 {name=p49160 lab=_40765_/X }
C {sky130_stdcells/or2_4.sym} 49540 -13360 0 0 {name=X_40765_ }
C {devices/lab_pin.sym} 49500 -13230 0 0 {name=p49161 lab=_71585_/A }
C {devices/lab_pin.sym} 49580 -13230 0 1 {name=p49162 lab=_71590_/B }
C {sky130_stdcells/buf_2.sym} 49540 -13230 0 0 {name=X_71585_ }
C {devices/lab_pin.sym} 49500 -13110 0 0 {name=p49163 lab=clkbuf_9_161_0_CLK/X }
C {devices/lab_pin.sym} 49580 -13110 0 1 {name=p49164 lab=_86651_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 49540 -13110 0 0 {name=Xclkbuf_10_322_0_CLK }
C {devices/lab_pin.sym} 49480 -13000 0 0 {name=p49165 lab=_76112_/A }
C {devices/lab_pin.sym} 49480 -12960 0 0 {name=p49166 lab=_76112_/B }
C {devices/lab_pin.sym} 49600 -12980 0 1 {name=p49167 lab=_76113_/B }
C {sky130_stdcells/xor2_4.sym} 49540 -12980 0 0 {name=X_76112_ }
C {devices/lab_pin.sym} 49460 -12890 0 0 {name=p49168 lab=_42495_/X }
C {devices/lab_pin.sym} 49460 -12850 0 0 {name=p49169 lab=_42496_/X }
C {devices/lab_pin.sym} 49460 -12810 0 0 {name=p49170 lab=_40682_/X }
C {devices/lab_pin.sym} 49460 -12770 0 0 {name=p49171 lab=_68801_/A }
C {devices/lab_pin.sym} 49460 -12730 0 0 {name=p49172 lab=_42480_/X }
C {devices/lab_pin.sym} 49620 -12810 0 1 {name=p49173 lab=_42505_/A }
C {sky130_stdcells/o32ai_4.sym} 49540 -12810 0 0 {name=X_42504_ }
C {devices/lab_pin.sym} 49500 -12650 0 0 {name=p49174 lab=_49060_/A }
C {devices/lab_pin.sym} 49580 -12650 0 1 {name=p49175 lab=_50142_/A }
C {sky130_stdcells/buf_2.sym} 49540 -12650 0 0 {name=X_49060_ }
C {devices/lab_pin.sym} 49460 -12560 0 0 {name=p49176 lab=_69862_/B }
C {devices/lab_pin.sym} 49460 -12520 0 0 {name=p49177 lab=_44128_/X }
C {devices/lab_pin.sym} 49460 -12480 0 0 {name=p49178 lab=_72858_/X }
C {devices/lab_pin.sym} 49460 -12440 0 0 {name=p49179 lab=_73323_/Y }
C {devices/lab_pin.sym} 49620 -12500 0 1 {name=p49180 lab=_73324_/X }
C {sky130_stdcells/a211o_4.sym} 49540 -12500 0 0 {name=X_73324_ }
C {devices/lab_pin.sym} 49480 -12360 0 0 {name=p49181 lab=_46272_/A }
C {devices/lab_pin.sym} 49480 -12320 0 0 {name=p49182 lab=_50738_/B }
C {devices/lab_pin.sym} 49600 -12340 0 1 {name=p49183 lab=_46272_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -12340 0 0 {name=X_46272_ }
C {devices/lab_pin.sym} 49500 -12210 0 0 {name=p49184 lab=_71012_/A }
C {devices/lab_pin.sym} 49580 -12210 0 1 {name=p49185 lab=_70692_/B }
C {sky130_stdcells/buf_2.sym} 49540 -12210 0 0 {name=X_70536_ }
C {devices/lab_pin.sym} 49500 -12090 0 0 {name=p49186 lab=_58258_/A }
C {devices/lab_pin.sym} 49580 -12090 0 1 {name=p49187 lab=_58259_/A }
C {sky130_stdcells/inv_2.sym} 49540 -12090 0 0 {name=X_58258_ }
C {devices/lab_pin.sym} 49500 -11970 0 0 {name=p49188 lab=clkbuf_9_476_0_CLK/X }
C {devices/lab_pin.sym} 49580 -11970 0 1 {name=p49189 lab=_87824_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 49540 -11970 0 0 {name=Xclkbuf_10_952_0_CLK }
C {devices/lab_pin.sym} 49460 -11870 0 0 {name=p49190 lab=_77097_/A }
C {devices/lab_pin.sym} 49460 -11830 0 0 {name=p49191 lab=_77096_/A }
C {devices/lab_pin.sym} 49460 -11790 0 0 {name=p49192 lab=_77091_/Y }
C {devices/lab_pin.sym} 49620 -11830 0 1 {name=p49193 lab=_77093_/B }
C {sky130_stdcells/a21boi_4.sym} 49540 -11830 0 0 {name=X_77092_ }
C {devices/lab_pin.sym} 49500 -11690 0 0 {name=p49194 lab=_43513_/A }
C {devices/lab_pin.sym} 49580 -11690 0 1 {name=p49195 lab=_43484_/X }
C {sky130_stdcells/buf_2.sym} 49540 -11690 0 0 {name=X_43484_ }
C {devices/lab_pin.sym} 49500 -11570 0 0 {name=p49196 lab=_40695_/Y }
C {devices/lab_pin.sym} 49580 -11570 0 1 {name=p49197 lab=_40696_/X }
C {sky130_stdcells/buf_2.sym} 49540 -11570 0 0 {name=X_40696_ }
C {devices/lab_pin.sym} 49500 -11450 0 0 {name=p49198 lab=_48011_/A }
C {devices/lab_pin.sym} 49580 -11450 0 1 {name=p49199 lab=_50314_/A }
C {sky130_stdcells/buf_2.sym} 49540 -11450 0 0 {name=X_48011_ }
C {devices/lab_pin.sym} 49460 -11350 0 0 {name=p49200 lab=_85228_/Q }
C {devices/lab_pin.sym} 49460 -11310 0 0 {name=p49201 lab=_45206_/X }
C {devices/lab_pin.sym} 49460 -11270 0 0 {name=p49202 lab=_45161_/X }
C {devices/lab_pin.sym} 49620 -11310 0 1 {name=p49203 lab=_45223_/X }
C {sky130_stdcells/o21a_4.sym} 49540 -11310 0 0 {name=X_45223_ }
C {devices/lab_pin.sym} 49460 -11190 0 0 {name=p49204 lab=_57208_/Y }
C {devices/lab_pin.sym} 49460 -11150 0 0 {name=p49205 lab=_57129_/A }
C {devices/lab_pin.sym} 49460 -11110 0 0 {name=p49206 lab=_56704_/X }
C {devices/lab_pin.sym} 49620 -11150 0 1 {name=p49207 lab=_57209_/Y }
C {sky130_stdcells/a21oi_4.sym} 49540 -11150 0 0 {name=X_57209_ }
C {devices/lab_pin.sym} 49460 -11030 0 0 {name=p49208 lab=_76039_/B }
C {devices/lab_pin.sym} 49460 -10990 0 0 {name=p49209 lab=_76047_/A }
C {devices/lab_pin.sym} 49460 -10950 0 0 {name=p49210 lab=_76042_/Y }
C {devices/lab_pin.sym} 49620 -10990 0 1 {name=p49211 lab=_76043_/Y }
C {sky130_stdcells/a21boi_4.sym} 49540 -10990 0 0 {name=X_76043_ }
C {devices/lab_pin.sym} 49500 -10850 0 0 {name=p49212 lab=_41911_/A }
C {devices/lab_pin.sym} 49580 -10850 0 1 {name=p49213 lab=_42435_/X }
C {sky130_stdcells/buf_2.sym} 49540 -10850 0 0 {name=X_42435_ }
C {devices/lab_pin.sym} 49450 -10730 0 0 {name=p49214 lab=_87767_/CLK }
C {devices/lab_pin.sym} 49450 -10710 0 0 {name=p49215 lab=_42113_/X }
C {devices/lab_pin.sym} 49630 -10730 0 1 {name=p49216 lab=_88029_/Q }
C {sky130_stdcells/dfxtp_4.sym} 49540 -10720 0 0 {name=X_88029_ }
C {devices/lab_pin.sym} 49460 -10610 0 0 {name=p49217 lab=_69826_/B }
C {devices/lab_pin.sym} 49460 -10570 0 0 {name=p49218 lab=_73086_/X }
C {devices/lab_pin.sym} 49460 -10530 0 0 {name=p49219 lab=_73202_/X }
C {devices/lab_pin.sym} 49620 -10570 0 1 {name=p49220 lab=_73255_/X }
C {sky130_stdcells/o21a_4.sym} 49540 -10570 0 0 {name=X_73255_ }
C {devices/lab_pin.sym} 49500 -10430 0 0 {name=p49221 lab=clkbuf_9_443_0_CLK/A }
C {devices/lab_pin.sym} 49580 -10430 0 1 {name=p49222 lab=clkbuf_9_443_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 49540 -10430 0 0 {name=Xclkbuf_9_443_0_CLK }
C {devices/lab_pin.sym} 49500 -10310 0 0 {name=p49223 lab=_71337_/A }
C {devices/lab_pin.sym} 49580 -10310 0 1 {name=p49224 lab=_71706_/A }
C {sky130_stdcells/buf_2.sym} 49540 -10310 0 0 {name=X_70467_ }
C {devices/lab_pin.sym} 49460 -10210 0 0 {name=p49225 lab=_57677_/X }
C {devices/lab_pin.sym} 49460 -10170 0 0 {name=p49226 lab=_58186_/Y }
C {devices/lab_pin.sym} 49460 -10130 0 0 {name=p49227 lab=_58188_/Y }
C {devices/lab_pin.sym} 49620 -10170 0 1 {name=p49228 lab=_84912_/D }
C {sky130_stdcells/a21oi_4.sym} 49540 -10170 0 0 {name=X_58189_ }
C {devices/lab_pin.sym} 49500 -10030 0 0 {name=p49229 lab=_60220_/A }
C {devices/lab_pin.sym} 49580 -10030 0 1 {name=p49230 lab=_60344_/C }
C {sky130_stdcells/buf_2.sym} 49540 -10030 0 0 {name=X_60220_ }
C {devices/lab_pin.sym} 49460 -9950 0 0 {name=p49231 lab=_72137_/X }
C {devices/lab_pin.sym} 49460 -9910 0 0 {name=p49232 lab=_72204_/Y }
C {devices/lab_pin.sym} 49460 -9870 0 0 {name=p49233 lab=_72205_/Y }
C {devices/lab_pin.sym} 49460 -9830 0 0 {name=p49234 lab=_72194_/X }
C {devices/lab_pin.sym} 49460 -9790 0 0 {name=p49235 lab=_72141_/X }
C {devices/lab_pin.sym} 49620 -9870 0 1 {name=p49236 lab=_72206_/X }
C {sky130_stdcells/o32a_4.sym} 49540 -9870 0 0 {name=X_72206_ }
C {devices/lab_pin.sym} 49460 -9730 0 0 {name=p49237 lab=_85297_/Q }
C {devices/lab_pin.sym} 49460 -9690 0 0 {name=p49238 lab=_45120_/X }
C {devices/lab_pin.sym} 49460 -9650 0 0 {name=p49239 lab=_45153_/X }
C {devices/lab_pin.sym} 49620 -9690 0 1 {name=p49240 lab=_45154_/X }
C {sky130_stdcells/o21a_4.sym} 49540 -9690 0 0 {name=X_45154_ }
C {devices/lab_pin.sym} 49500 -9550 0 0 {name=p49241 lab=clkbuf_9_168_0_CLK/X }
C {devices/lab_pin.sym} 49580 -9550 0 1 {name=p49242 lab=_85735_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 49540 -9550 0 0 {name=Xclkbuf_10_337_0_CLK }
C {devices/lab_pin.sym} 49460 -9470 0 0 {name=p49243 lab=_42350_/X }
C {devices/lab_pin.sym} 49460 -9430 0 0 {name=p49244 lab=_42346_/X }
C {devices/lab_pin.sym} 49460 -9390 0 0 {name=p49245 lab=_41762_/X }
C {devices/lab_pin.sym} 49460 -9350 0 0 {name=p49246 lab=_87898_/Q }
C {devices/lab_pin.sym} 49460 -9310 0 0 {name=p49247 lab=_42347_/X }
C {devices/lab_pin.sym} 49620 -9390 0 1 {name=p49248 lab=_42367_/A }
C {sky130_stdcells/o32ai_4.sym} 49540 -9390 0 0 {name=X_42366_ }
C {devices/lab_pin.sym} 49480 -9240 0 0 {name=p49249 lab=_73186_/A }
C {devices/lab_pin.sym} 49480 -9200 0 0 {name=p49250 lab=_86513_/Q }
C {devices/lab_pin.sym} 49600 -9220 0 1 {name=p49251 lab=_73186_/X }
C {sky130_stdcells/and2_4.sym} 49540 -9220 0 0 {name=X_73186_ }
C {devices/lab_pin.sym} 49460 -9110 0 0 {name=p49252 lab=_50870_/B }
C {devices/lab_pin.sym} 49460 -9070 0 0 {name=p49253 lab=_70364_/A }
C {devices/lab_pin.sym} 49460 -9030 0 0 {name=p49254 lab=_70397_/Y }
C {devices/lab_pin.sym} 49620 -9070 0 1 {name=p49255 lab=_83780_/D }
C {sky130_stdcells/o21ai_4.sym} 49540 -9070 0 0 {name=X_70398_ }
C {devices/lab_pin.sym} 49500 -8930 0 0 {name=p49256 lab=_44086_/A }
C {devices/lab_pin.sym} 49580 -8930 0 1 {name=p49257 lab=_44106_/C }
C {sky130_stdcells/buf_2.sym} 49540 -8930 0 0 {name=X_44105_ }
C {devices/lab_pin.sym} 49480 -8820 0 0 {name=p49258 lab=_79799_/X }
C {devices/lab_pin.sym} 49480 -8780 0 0 {name=p49259 lab=_79801_/Y }
C {devices/lab_pin.sym} 49600 -8800 0 1 {name=p49260 lab=_79802_/X }
C {sky130_stdcells/xor2_4.sym} 49540 -8800 0 0 {name=X_79802_ }
C {devices/lab_pin.sym} 49500 -8670 0 0 {name=p49261 lab=clkbuf_9_483_0_CLK/X }
C {devices/lab_pin.sym} 49580 -8670 0 1 {name=p49262 lab=_85538_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 49540 -8670 0 0 {name=Xclkbuf_10_967_0_CLK }
C {devices/lab_pin.sym} 49460 -8590 0 0 {name=p49263 lab=_41239_/X }
C {devices/lab_pin.sym} 49460 -8550 0 0 {name=p49264 lab=_41241_/X }
C {devices/lab_pin.sym} 49460 -8510 0 0 {name=p49265 lab=_41316_/X }
C {devices/lab_pin.sym} 49460 -8470 0 0 {name=p49266 lab=_88237_/Q }
C {devices/lab_pin.sym} 49460 -8430 0 0 {name=p49267 lab=_41236_/X }
C {devices/lab_pin.sym} 49620 -8510 0 1 {name=p49268 lab=_41317_/Y }
C {sky130_stdcells/o32ai_4.sym} 49540 -8510 0 0 {name=X_41317_ }
C {devices/lab_pin.sym} 49500 -8350 0 0 {name=p49269 lab=_65198_/A }
C {devices/lab_pin.sym} 49580 -8350 0 1 {name=p49270 lab=_60151_/X }
C {sky130_stdcells/buf_2.sym} 49540 -8350 0 0 {name=X_60151_ }
C {devices/lab_pin.sym} 49500 -8230 0 0 {name=p49271 lab=_59325_/A }
C {devices/lab_pin.sym} 49580 -8230 0 1 {name=p49272 lab=_72137_/X }
C {sky130_stdcells/buf_2.sym} 49540 -8230 0 0 {name=X_72137_ }
C {devices/lab_pin.sym} 49480 -8120 0 0 {name=p49273 lab=_49981_/A }
C {devices/lab_pin.sym} 49480 -8080 0 0 {name=p49274 lab=_53174_/B }
C {devices/lab_pin.sym} 49600 -8100 0 1 {name=p49275 lab=_49962_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -8100 0 0 {name=X_49962_ }
C {devices/lab_pin.sym} 49460 -7990 0 0 {name=p49276 lab=_45052_/X }
C {devices/lab_pin.sym} 49460 -7950 0 0 {name=p49277 lab=_61460_/B }
C {devices/lab_pin.sym} 49460 -7910 0 0 {name=p49278 lab=_45070_/X }
C {devices/lab_pin.sym} 49620 -7950 0 1 {name=p49279 lab=_45085_/Y }
C {sky130_stdcells/o21ai_4.sym} 49540 -7950 0 0 {name=X_45085_ }
C {devices/lab_pin.sym} 49500 -7810 0 0 {name=p49280 lab=_42199_/X }
C {devices/lab_pin.sym} 49580 -7810 0 1 {name=p49281 lab=_42297_/X }
C {sky130_stdcells/buf_2.sym} 49540 -7810 0 0 {name=X_42297_ }
C {devices/lab_pin.sym} 49480 -7700 0 0 {name=p49282 lab=_77994_/A }
C {devices/lab_pin.sym} 49480 -7660 0 0 {name=p49283 lab=_77994_/B }
C {devices/lab_pin.sym} 49600 -7680 0 1 {name=p49284 lab=_82142_/D }
C {sky130_stdcells/xor2_4.sym} 49540 -7680 0 0 {name=X_77994_ }
C {devices/lab_pin.sym} 49460 -7570 0 0 {name=p49285 lab=_64684_/B }
C {devices/lab_pin.sym} 49460 -7530 0 0 {name=p49286 lab=_48896_/X }
C {devices/lab_pin.sym} 49460 -7490 0 0 {name=p49287 lab=_48912_/Y }
C {devices/lab_pin.sym} 49620 -7530 0 1 {name=p49288 lab=_48913_/Y }
C {sky130_stdcells/o21ai_4.sym} 49540 -7530 0 0 {name=X_48913_ }
C {devices/lab_pin.sym} 49500 -7390 0 0 {name=p49289 lab=_44010_/A }
C {devices/lab_pin.sym} 49580 -7390 0 1 {name=p49290 lab=_44036_/Y }
C {sky130_stdcells/inv_2.sym} 49540 -7390 0 0 {name=X_44036_ }
C {devices/lab_pin.sym} 49500 -7270 0 0 {name=p49291 lab=clkbuf_9_459_0_CLK/A }
C {devices/lab_pin.sym} 49580 -7270 0 1 {name=p49292 lab=clkbuf_9_458_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 49540 -7270 0 0 {name=Xclkbuf_9_458_0_CLK }
C {devices/lab_pin.sym} 49480 -7160 0 0 {name=p49293 lab=_79733_/A }
C {devices/lab_pin.sym} 49480 -7120 0 0 {name=p49294 lab=_79733_/B }
C {devices/lab_pin.sym} 49600 -7140 0 1 {name=p49295 lab=_79739_/B }
C {sky130_stdcells/xor2_4.sym} 49540 -7140 0 0 {name=X_79733_ }
C {devices/lab_pin.sym} 49480 -7020 0 0 {name=p49296 lab=_81704_/Q }
C {devices/lab_pin.sym} 49480 -6980 0 0 {name=p49297 lab=_41197_/B }
C {devices/lab_pin.sym} 49600 -7000 0 1 {name=p49298 lab=_41248_/X }
C {sky130_stdcells/or2_4.sym} 49540 -7000 0 0 {name=X_41248_ }
C {devices/lab_pin.sym} 49460 -6910 0 0 {name=p49299 lab=_60078_/X }
C {devices/lab_pin.sym} 49460 -6870 0 0 {name=p49300 lab=_60079_/Y }
C {devices/lab_pin.sym} 49460 -6830 0 0 {name=p49301 lab=_60403_/A }
C {devices/lab_pin.sym} 49460 -6790 0 0 {name=p49302 lab=_72625_/B }
C {devices/lab_pin.sym} 49460 -6760 0 0 {name=p49303 lab=_60081_/Y }
C {devices/lab_pin.sym} 49620 -6830 0 1 {name=p49304 lab=_60082_/Y }
C {sky130_stdcells/a41oi_4.sym} 49540 -6830 0 0 {name=X_60082_ }
C {devices/lab_pin.sym} 49480 -6680 0 0 {name=p49305 lab=_72068_/A }
C {devices/lab_pin.sym} 49480 -6640 0 0 {name=p49306 lab=_49106_/Y }
C {devices/lab_pin.sym} 49600 -6660 0 1 {name=p49307 lab=_72068_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -6660 0 0 {name=X_72068_ }
C {devices/lab_pin.sym} 49500 -6530 0 0 {name=p49308 lab=_76945_/A }
C {devices/lab_pin.sym} 49580 -6530 0 1 {name=p49309 lab=_81376_/D }
C {sky130_stdcells/inv_2.sym} 49540 -6530 0 0 {name=X_76945_ }
C {devices/lab_pin.sym} 49480 -6440 0 0 {name=p49310 lab=_49893_/A }
C {devices/lab_pin.sym} 49480 -6400 0 0 {name=p49311 lab=_49893_/B }
C {devices/lab_pin.sym} 49480 -6360 0 0 {name=p49312 lab=_49893_/C }
C {devices/lab_pin.sym} 49480 -6320 0 0 {name=p49313 lab=_53107_/D }
C {devices/lab_pin.sym} 49600 -6380 0 1 {name=p49314 lab=_49893_/X }
C {sky130_stdcells/and4_4.sym} 49540 -6380 0 0 {name=X_49893_ }
C {devices/lab_pin.sym} 49480 -6250 0 0 {name=p49315 lab=_63942_/A }
C {devices/lab_pin.sym} 49480 -6210 0 0 {name=p49316 lab=_59399_/A }
C {devices/lab_pin.sym} 49480 -6170 0 0 {name=p49317 lab=_63862_/C }
C {devices/lab_pin.sym} 49600 -6210 0 1 {name=p49318 lab=_63910_/X }
C {sky130_stdcells/and3_4.sym} 49540 -6210 0 0 {name=X_63910_ }
C {devices/lab_pin.sym} 49460 -6090 0 0 {name=p49319 lab=_53141_/B }
C {devices/lab_pin.sym} 49460 -6050 0 0 {name=p49320 lab=_71013_/X }
C {devices/lab_pin.sym} 49460 -6010 0 0 {name=p49321 lab=_71018_/Y }
C {devices/lab_pin.sym} 49620 -6050 0 1 {name=p49322 lab=_83633_/D }
C {sky130_stdcells/o21ai_4.sym} 49540 -6050 0 0 {name=X_71019_ }
C {devices/lab_pin.sym} 49460 -5930 0 0 {name=p49323 lab=_86472_/Q }
C {devices/lab_pin.sym} 49460 -5890 0 0 {name=p49324 lab=_48836_/X }
C {devices/lab_pin.sym} 49460 -5850 0 0 {name=p49325 lab=_48843_/Y }
C {devices/lab_pin.sym} 49620 -5890 0 1 {name=p49326 lab=_48844_/Y }
C {sky130_stdcells/o21ai_4.sym} 49540 -5890 0 0 {name=X_48844_ }
C {devices/lab_pin.sym} 49480 -5760 0 0 {name=p49327 lab=_79664_/A }
C {devices/lab_pin.sym} 49480 -5720 0 0 {name=p49328 lab=_79647_/X }
C {devices/lab_pin.sym} 49600 -5740 0 1 {name=p49329 lab=_79664_/X }
C {sky130_stdcells/and2_4.sym} 49540 -5740 0 0 {name=X_79664_ }
C {devices/lab_pin.sym} 49500 -5610 0 0 {name=p49330 lab=_41178_/Y }
C {devices/lab_pin.sym} 49580 -5610 0 1 {name=p49331 lab=_41179_/X }
C {sky130_stdcells/buf_2.sym} 49540 -5610 0 0 {name=X_41179_ }
C {devices/lab_pin.sym} 49500 -5490 0 0 {name=p49332 lab=_84223_/Q }
C {devices/lab_pin.sym} 49580 -5490 0 1 {name=p49333 lab=_64891_/C }
C {sky130_stdcells/inv_2.sym} 49540 -5490 0 0 {name=X_64890_ }
C {devices/lab_pin.sym} 49480 -5380 0 0 {name=p49334 lab=_76870_/Y }
C {devices/lab_pin.sym} 49480 -5340 0 0 {name=p49335 lab=_76910_/A }
C {devices/lab_pin.sym} 49600 -5360 0 1 {name=p49336 lab=_76876_/X }
C {sky130_stdcells/and2_4.sym} 49540 -5360 0 0 {name=X_76876_ }
C {devices/lab_pin.sym} 49460 -5250 0 0 {name=p49337 lab=_78616_/A }
C {devices/lab_pin.sym} 49460 -5210 0 0 {name=p49338 lab=_78616_/B }
C {devices/lab_pin.sym} 49460 -5170 0 0 {name=p49339 lab=_78614_/Y }
C {devices/lab_pin.sym} 49620 -5210 0 1 {name=p49340 lab=_78615_/X }
C {sky130_stdcells/o21a_4.sym} 49540 -5210 0 0 {name=X_78615_ }
C {devices/lab_pin.sym} 49480 -5100 0 0 {name=p49341 lab=_58241_/X }
C {devices/lab_pin.sym} 49480 -5060 0 0 {name=p49342 lab=_63858_/B }
C {devices/lab_pin.sym} 49480 -5020 0 0 {name=p49343 lab=_63858_/C }
C {devices/lab_pin.sym} 49480 -4980 0 0 {name=p49344 lab=_63793_/D }
C {devices/lab_pin.sym} 49600 -5040 0 1 {name=p49345 lab=_63841_/Y }
C {sky130_stdcells/nand4_4.sym} 49540 -5040 0 0 {name=X_63841_ }
C {devices/lab_pin.sym} 49480 -4900 0 0 {name=p49346 lab=_75825_/X }
C {devices/lab_pin.sym} 49480 -4860 0 0 {name=p49347 lab=_75827_/B }
C {devices/lab_pin.sym} 49600 -4880 0 1 {name=p49348 lab=_80989_/D }
C {sky130_stdcells/nand2_4.sym} 49540 -4880 0 0 {name=X_75827_ }
C {devices/lab_pin.sym} 49480 -4770 0 0 {name=p49349 lab=_52161_/A }
C {devices/lab_pin.sym} 49480 -4730 0 0 {name=p49350 lab=_48770_/X }
C {devices/lab_pin.sym} 49480 -4690 0 0 {name=p49351 lab=_48786_/C }
C {devices/lab_pin.sym} 49600 -4730 0 1 {name=p49352 lab=_48775_/X }
C {sky130_stdcells/and3_4.sym} 49540 -4730 0 0 {name=X_48775_ }
C {devices/lab_pin.sym} 49480 -4600 0 0 {name=p49353 lab=_79592_/Y }
C {devices/lab_pin.sym} 49480 -4560 0 0 {name=p49354 lab=_79594_/Y }
C {devices/lab_pin.sym} 49600 -4580 0 1 {name=p49355 lab=_79597_/A }
C {sky130_stdcells/nand2_4.sym} 49540 -4580 0 0 {name=X_79595_ }
C {devices/lab_pin.sym} 49500 -4450 0 0 {name=p49356 lab=_46001_/A }
C {devices/lab_pin.sym} 49580 -4450 0 1 {name=p49357 lab=_45987_/X }
C {sky130_stdcells/buf_2.sym} 49540 -4450 0 0 {name=X_45987_ }
C {devices/lab_pin.sym} 49500 -4330 0 0 {name=p49358 lab=_54903_/B }
C {devices/lab_pin.sym} 49580 -4330 0 1 {name=p49359 lab=_53209_/B }
C {sky130_stdcells/buf_2.sym} 49540 -4330 0 0 {name=X_47726_ }
C {devices/lab_pin.sym} 49500 -4210 0 0 {name=p49360 lab=_44147_/A }
C {devices/lab_pin.sym} 49580 -4210 0 1 {name=p49361 lab=_66560_/X }
C {sky130_stdcells/buf_2.sym} 49540 -4210 0 0 {name=X_66560_ }
C {devices/lab_pin.sym} 49480 -4100 0 0 {name=p49362 lab=_78547_/A }
C {devices/lab_pin.sym} 49480 -4060 0 0 {name=p49363 lab=_82674_/D }
C {devices/lab_pin.sym} 49600 -4080 0 1 {name=p49364 lab=_78546_/Y }
C {sky130_stdcells/nor2_4.sym} 49540 -4080 0 0 {name=X_78546_ }
C {devices/lab_pin.sym} 49500 -3950 0 0 {name=p49365 lab=_45819_/A }
C {devices/lab_pin.sym} 49580 -3950 0 1 {name=p49366 lab=_44939_/B }
C {sky130_stdcells/buf_2.sym} 49540 -3950 0 0 {name=X_44938_ }
C {devices/lab_pin.sym} 49480 -3860 0 0 {name=p49367 lab=_61358_/A }
C {devices/lab_pin.sym} 49480 -3820 0 0 {name=p49368 lab=_63772_/B }
C {devices/lab_pin.sym} 49480 -3780 0 0 {name=p49369 lab=_63721_/C }
C {devices/lab_pin.sym} 49480 -3740 0 0 {name=p49370 lab=_61012_/A }
C {devices/lab_pin.sym} 49600 -3800 0 1 {name=p49371 lab=_63772_/Y }
C {sky130_stdcells/nand4_4.sym} 49540 -3800 0 0 {name=X_63772_ }
C {devices/lab_pin.sym} 49460 -3670 0 0 {name=p49372 lab=_75753_/Y }
C {devices/lab_pin.sym} 49460 -3630 0 0 {name=p49373 lab=_75740_/B }
C {devices/lab_pin.sym} 49460 -3590 0 0 {name=p49374 lab=_75757_/Y }
C {devices/lab_pin.sym} 49620 -3630 0 1 {name=p49375 lab=_75759_/B }
C {sky130_stdcells/o21ai_4.sym} 49540 -3630 0 0 {name=X_75758_ }
C {devices/lab_pin.sym} 49500 -3490 0 0 {name=p49376 lab=_60984_/A }
C {devices/lab_pin.sym} 49580 -3490 0 1 {name=p49377 lab=_63738_/D }
C {sky130_stdcells/buf_2.sym} 49540 -3490 0 0 {name=X_60984_ }
C {devices/lab_pin.sym} 49480 -3390 0 0 {name=p49378 lab=_65507_/X }
C {devices/lab_pin.sym} 49480 -3350 0 0 {name=p49379 lab=_65663_/B }
C {devices/lab_pin.sym} 49480 -3310 0 0 {name=p49380 lab=_65510_/X }
C {devices/lab_pin.sym} 49600 -3350 0 1 {name=p49381 lab=_65511_/Y }
C {sky130_stdcells/nand3_4.sym} 49540 -3350 0 0 {name=X_65511_ }
C {devices/lab_pin.sym} 49500 -3210 0 0 {name=p49382 lab=clkbuf_9_452_0_CLK/X }
C {devices/lab_pin.sym} 49580 -3210 0 1 {name=p49383 lab=_86984_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 49540 -3210 0 0 {name=Xclkbuf_10_905_0_CLK }
C {devices/lab_pin.sym} 49500 -3090 0 0 {name=p49384 lab=_74711_/A }
C {devices/lab_pin.sym} 49580 -3090 0 1 {name=p49385 lab=_74709_/Y }
C {sky130_stdcells/inv_2.sym} 49540 -3090 0 0 {name=X_74709_ }
C {devices/lab_pin.sym} 49460 -2990 0 0 {name=p49386 lab=_62719_/X }
C {devices/lab_pin.sym} 49460 -2950 0 0 {name=p49387 lab=_62721_/X }
C {devices/lab_pin.sym} 49460 -2910 0 0 {name=p49388 lab=_62722_/Y }
C {devices/lab_pin.sym} 49620 -2950 0 1 {name=p49389 lab=_62723_/Y }
C {sky130_stdcells/a21oi_4.sym} 49540 -2950 0 0 {name=X_62723_ }
C {devices/lab_pin.sym} 49500 -2810 0 0 {name=p49390 lab=_47657_/A }
C {devices/lab_pin.sym} 49580 -2810 0 1 {name=p49391 lab=_54867_/B }
C {sky130_stdcells/inv_2.sym} 49540 -2810 0 0 {name=X_47657_ }
C {devices/lab_pin.sym} 49460 -2710 0 0 {name=p49392 lab=_66488_/Y }
C {devices/lab_pin.sym} 49460 -2670 0 0 {name=p49393 lab=_66483_/X }
C {devices/lab_pin.sym} 49460 -2630 0 0 {name=p49394 lab=_66490_/X }
C {devices/lab_pin.sym} 49620 -2670 0 1 {name=p49395 lab=_84113_/D }
C {sky130_stdcells/a21o_4.sym} 49540 -2670 0 0 {name=X_66491_ }
C {devices/lab_pin.sym} 49500 -2530 0 0 {name=p49396 lab=_78465_/A }
C {devices/lab_pin.sym} 49580 -2530 0 1 {name=p49397 lab=_78478_/B }
C {sky130_stdcells/inv_2.sym} 49540 -2530 0 0 {name=X_78477_ }
C {devices/lab_pin.sym} 49500 -2410 0 0 {name=p49398 lab=_45387_/A }
C {devices/lab_pin.sym} 49580 -2410 0 1 {name=p49399 lab=_45612_/A }
C {sky130_stdcells/buf_2.sym} 49540 -2410 0 0 {name=X_44869_ }
C {devices/lab_pin.sym} 49480 -2300 0 0 {name=p49400 lab=_75689_/A }
C {devices/lab_pin.sym} 49480 -2260 0 0 {name=p49401 lab=_75688_/Y }
C {devices/lab_pin.sym} 49600 -2280 0 1 {name=p49402 lab=_75692_/A }
C {sky130_stdcells/xor2_4.sym} 49540 -2280 0 0 {name=X_75689_ }
C {devices/lab_pin.sym} 49460 -2180 0 0 {name=p49403 lab=_68188_/X }
C {devices/lab_pin.sym} 49460 -2140 0 0 {name=p49404 lab=_67413_/Y }
C {devices/lab_pin.sym} 49460 -2100 0 0 {name=p49405 lab=_68228_/X }
C {devices/lab_pin.sym} 49460 -2060 0 0 {name=p49406 lab=_68229_/Y }
C {devices/lab_pin.sym} 49620 -2120 0 1 {name=p49407 lab=_68230_/X }
C {sky130_stdcells/a211o_4.sym} 49540 -2120 0 0 {name=X_68230_ }
C {devices/lab_pin.sym} 49480 -1980 0 0 {name=p49408 lab=_46491_/A }
C {devices/lab_pin.sym} 49480 -1940 0 0 {name=p49409 lab=_51744_/B }
C {devices/lab_pin.sym} 49600 -1960 0 1 {name=p49410 lab=_46608_/Y }
C {sky130_stdcells/nand2_4.sym} 49540 -1960 0 0 {name=X_46608_ }
C {devices/lab_pin.sym} 49460 -1860 0 0 {name=p49411 lab=_65059_/X }
C {devices/lab_pin.sym} 49460 -1820 0 0 {name=p49412 lab=_85600_/Q }
C {devices/lab_pin.sym} 49460 -1780 0 0 {name=p49413 lab=_65060_/X }
C {devices/lab_pin.sym} 49460 -1740 0 0 {name=p49414 lab=_65441_/X }
C {devices/lab_pin.sym} 49620 -1800 0 1 {name=p49415 lab=_65442_/X }
C {sky130_stdcells/a211o_4.sym} 49540 -1800 0 0 {name=X_65442_ }
C {devices/lab_pin.sym} 49460 -1670 0 0 {name=p49416 lab=_77412_/A }
C {devices/lab_pin.sym} 49460 -1630 0 0 {name=p49417 lab=_77412_/B }
C {devices/lab_pin.sym} 49460 -1590 0 0 {name=p49418 lab=_77410_/Y }
C {devices/lab_pin.sym} 49620 -1630 0 1 {name=p49419 lab=_77428_/X }
C {sky130_stdcells/o21a_4.sym} 49540 -1630 0 0 {name=X_77428_ }
C {devices/lab_pin.sym} 49500 -1490 0 0 {name=p49420 lab=clkbuf_5_23_0_CLK/A }
C {devices/lab_pin.sym} 49580 -1490 0 1 {name=p49421 lab=clkbuf_6_45_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 49540 -1490 0 0 {name=Xclkbuf_5_22_0_CLK }
C {devices/lab_pin.sym} 49460 -1390 0 0 {name=p49422 lab=_62651_/Y }
C {devices/lab_pin.sym} 49460 -1350 0 0 {name=p49423 lab=_62652_/X }
C {devices/lab_pin.sym} 49460 -1310 0 0 {name=p49424 lab=_62653_/Y }
C {devices/lab_pin.sym} 49620 -1350 0 1 {name=p49425 lab=_62654_/Y }
C {sky130_stdcells/a21oi_4.sym} 49540 -1350 0 0 {name=X_62654_ }
C {devices/lab_pin.sym} 49460 -1230 0 0 {name=p49426 lab=_47584_/Y }
C {devices/lab_pin.sym} 49460 -1190 0 0 {name=p49427 lab=_47555_/X }
C {devices/lab_pin.sym} 49460 -1150 0 0 {name=p49428 lab=_47587_/X }
C {devices/lab_pin.sym} 49620 -1190 0 1 {name=p49429 lab=_86619_/D }
C {sky130_stdcells/a21oi_4.sym} 49540 -1190 0 0 {name=X_47588_ }
C {devices/lab_pin.sym} 49500 -1050 0 0 {name=p49430 lab=_48995_/A }
C {devices/lab_pin.sym} 49580 -1050 0 1 {name=p49431 lab=_49327_/X }
C {sky130_stdcells/buf_2.sym} 49540 -1050 0 0 {name=X_49327_ }
C {devices/lab_pin.sym} 49480 -950 0 0 {name=p49432 lab=_61634_/A }
C {devices/lab_pin.sym} 49480 -910 0 0 {name=p49433 lab=_61634_/B }
C {devices/lab_pin.sym} 49480 -870 0 0 {name=p49434 lab=_79135_/B }
C {devices/lab_pin.sym} 49600 -910 0 1 {name=p49435 lab=_61605_/Y }
C {sky130_stdcells/nor3_4.sym} 49540 -910 0 0 {name=X_61605_ }
C {devices/lab_pin.sym} 49460 -790 0 0 {name=p49436 lab=_67010_/X }
C {devices/lab_pin.sym} 49460 -750 0 0 {name=p49437 lab=_67012_/X }
C {devices/lab_pin.sym} 49460 -710 0 0 {name=p49438 lab=_68129_/X }
C {devices/lab_pin.sym} 49620 -750 0 1 {name=p49439 lab=_68161_/Y }
C {sky130_stdcells/a21oi_4.sym} 49540 -750 0 0 {name=X_68161_ }
C {devices/lab_pin.sym} 50420 -42150 0 0 {name=p49440 lab=_46539_/A }
C {devices/lab_pin.sym} 50500 -42150 0 1 {name=p49441 lab=_50854_/B }
C {sky130_stdcells/buf_2.sym} 50460 -42150 0 0 {name=X_46539_ }
C {devices/lab_pin.sym} 50400 -42050 0 0 {name=p49442 lab=_65397_/A }
C {devices/lab_pin.sym} 50400 -42010 0 0 {name=p49443 lab=_65397_/B }
C {devices/lab_pin.sym} 50400 -41970 0 0 {name=p49444 lab=_65373_/C }
C {devices/lab_pin.sym} 50520 -42010 0 1 {name=p49445 lab=_65373_/Y }
C {sky130_stdcells/nor3_4.sym} 50460 -42010 0 0 {name=X_65373_ }
C {devices/lab_pin.sym} 50420 -41870 0 0 {name=p49446 lab=_77359_/A }
C {devices/lab_pin.sym} 50500 -41870 0 1 {name=p49447 lab=_77360_/A }
C {sky130_stdcells/inv_2.sym} 50460 -41870 0 0 {name=X_77359_ }
C {devices/lab_pin.sym} 50400 -41780 0 0 {name=p49448 lab=_62487_/X }
C {devices/lab_pin.sym} 50400 -41740 0 0 {name=p49449 lab=_58198_/A }
C {devices/lab_pin.sym} 50400 -41700 0 0 {name=p49450 lab=_62618_/C }
C {devices/lab_pin.sym} 50400 -41660 0 0 {name=p49451 lab=_62608_/D }
C {devices/lab_pin.sym} 50520 -41720 0 1 {name=p49452 lab=_62585_/X }
C {sky130_stdcells/and4_4.sym} 50460 -41720 0 0 {name=X_62585_ }
C {devices/lab_pin.sym} 50380 -41600 0 0 {name=p49453 lab=_88381_/Q }
C {devices/lab_pin.sym} 50380 -41560 0 0 {name=p49454 lab=_67110_/X }
C {devices/lab_pin.sym} 50380 -41520 0 0 {name=p49455 lab=_67040_/X }
C {devices/lab_pin.sym} 50380 -41480 0 0 {name=p49456 lab=_67111_/X }
C {devices/lab_pin.sym} 50540 -41540 0 1 {name=p49457 lab=_67112_/X }
C {sky130_stdcells/a211o_4.sym} 50460 -41540 0 0 {name=X_67112_ }
C {devices/lab_pin.sym} 50400 -41410 0 0 {name=p49458 lab=_64336_/A }
C {devices/lab_pin.sym} 50400 -41370 0 0 {name=p49459 lab=_84824_/Q }
C {devices/lab_pin.sym} 50400 -41330 0 0 {name=p49460 lab=_64323_/X }
C {devices/lab_pin.sym} 50520 -41370 0 1 {name=p49461 lab=_64324_/Y }
C {sky130_stdcells/nand3_4.sym} 50460 -41370 0 0 {name=X_64324_ }
C {devices/lab_pin.sym} 50380 -41250 0 0 {name=p49462 lab=_86423_/Q }
C {devices/lab_pin.sym} 50380 -41210 0 0 {name=p49463 lab=_49255_/X }
C {devices/lab_pin.sym} 50380 -41170 0 0 {name=p49464 lab=_49257_/Y }
C {devices/lab_pin.sym} 50540 -41210 0 1 {name=p49465 lab=_49258_/Y }
C {sky130_stdcells/o21ai_4.sym} 50460 -41210 0 0 {name=X_49258_ }
C {devices/lab_pin.sym} 50400 -41090 0 0 {name=p49466 lab=_61546_/A }
C {devices/lab_pin.sym} 50400 -41050 0 0 {name=p49467 lab=_61546_/B }
C {devices/lab_pin.sym} 50400 -41010 0 0 {name=p49468 lab=_79141_/B }
C {devices/lab_pin.sym} 50520 -41050 0 1 {name=p49469 lab=_61536_/Y }
C {sky130_stdcells/nor3_4.sym} 50460 -41050 0 0 {name=X_61536_ }
C {devices/lab_pin.sym} 50400 -40920 0 0 {name=p49470 lab=_84753_/Q }
C {devices/lab_pin.sym} 50400 -40880 0 0 {name=p49471 lab=_84145_/Q }
C {devices/lab_pin.sym} 50520 -40900 0 1 {name=p49472 lab=_80370_/X }
C {sky130_stdcells/xor2_4.sym} 50460 -40900 0 0 {name=X_80370_ }
C {devices/lab_pin.sym} 50380 -40790 0 0 {name=p49473 lab=_82081_/D }
C {devices/lab_pin.sym} 50380 -40750 0 0 {name=p49474 lab=_68040_/X }
C {devices/lab_pin.sym} 50380 -40710 0 0 {name=p49475 lab=_68091_/X }
C {devices/lab_pin.sym} 50540 -40750 0 1 {name=p49476 lab=_68092_/X }
C {sky130_stdcells/a21bo_4.sym} 50460 -40750 0 0 {name=X_68092_ }
C {devices/lab_pin.sym} 50420 -40610 0 0 {name=p49477 lab=clkbuf_9_4_0_CLK/X }
C {devices/lab_pin.sym} 50500 -40610 0 1 {name=p49478 lab=_85277_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 50460 -40610 0 0 {name=Xclkbuf_10_9_0_CLK }
C {devices/lab_pin.sym} 50380 -40510 0 0 {name=p49479 lab=_48206_/Y }
C {devices/lab_pin.sym} 50380 -40470 0 0 {name=p49480 lab=_48175_/X }
C {devices/lab_pin.sym} 50380 -40430 0 0 {name=p49481 lab=_48208_/Y }
C {devices/lab_pin.sym} 50540 -40470 0 1 {name=p49482 lab=_86556_/D }
C {sky130_stdcells/a21boi_4.sym} 50460 -40470 0 0 {name=X_48209_ }
C {devices/lab_pin.sym} 50380 -40350 0 0 {name=p49483 lab=_67038_/X }
C {devices/lab_pin.sym} 50380 -40310 0 0 {name=p49484 lab=_67042_/X }
C {devices/lab_pin.sym} 50380 -40270 0 0 {name=p49485 lab=_67015_/X }
C {devices/lab_pin.sym} 50540 -40310 0 1 {name=p49486 lab=_67043_/Y }
C {sky130_stdcells/a21oi_4.sym} 50460 -40310 0 0 {name=X_67043_ }
C {devices/lab_pin.sym} 50420 -40170 0 0 {name=p49487 lab=_82651_/Q }
C {devices/lab_pin.sym} 50500 -40170 0 1 {name=p49488 lab=_79029_/Y }
C {sky130_stdcells/inv_2.sym} 50460 -40170 0 0 {name=X_79029_ }
C {devices/lab_pin.sym} 50420 -40050 0 0 {name=p49489 lab=_64314_/A }
C {devices/lab_pin.sym} 50500 -40050 0 1 {name=p49490 lab=_64255_/X }
C {sky130_stdcells/buf_2.sym} 50460 -40050 0 0 {name=X_64255_ }
C {devices/lab_pin.sym} 50420 -39930 0 0 {name=p49491 lab=_72529_/C }
C {devices/lab_pin.sym} 50500 -39930 0 1 {name=p49492 lab=_61467_/X }
C {sky130_stdcells/buf_2.sym} 50460 -39930 0 0 {name=X_61467_ }
C {devices/lab_pin.sym} 50420 -39810 0 0 {name=p49493 lab=_49405_/A }
C {devices/lab_pin.sym} 50500 -39810 0 1 {name=p49494 lab=_49189_/X }
C {sky130_stdcells/buf_2.sym} 50460 -39810 0 0 {name=X_49189_ }
C {devices/lab_pin.sym} 50400 -39720 0 0 {name=p49495 lab=_51220_/A }
C {devices/lab_pin.sym} 50400 -39680 0 0 {name=p49496 lab=_51203_/B }
C {devices/lab_pin.sym} 50400 -39640 0 0 {name=p49497 lab=_51197_/C }
C {devices/lab_pin.sym} 50400 -39600 0 0 {name=p49498 lab=_51220_/D }
C {devices/lab_pin.sym} 50520 -39660 0 1 {name=p49499 lab=_51220_/X }
C {sky130_stdcells/and4_4.sym} 50460 -39660 0 0 {name=X_51220_ }
C {devices/lab_pin.sym} 50400 -39540 0 0 {name=p49500 lab=_63157_/X }
C {devices/lab_pin.sym} 50400 -39500 0 0 {name=p49501 lab=_63206_/B }
C {devices/lab_pin.sym} 50400 -39460 0 0 {name=p49502 lab=_63241_/C }
C {devices/lab_pin.sym} 50400 -39420 0 0 {name=p49503 lab=_63181_/X }
C {devices/lab_pin.sym} 50520 -39480 0 1 {name=p49504 lab=_63206_/X }
C {sky130_stdcells/and4_4.sym} 50460 -39480 0 0 {name=X_63206_ }
C {devices/lab_pin.sym} 50370 -39330 0 0 {name=p49505 lab=_82009_/CLK }
C {devices/lab_pin.sym} 50370 -39310 0 0 {name=p49506 lab=_77934_/B }
C {devices/lab_pin.sym} 50550 -39330 0 1 {name=p49507 lab=_82040_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -39320 0 0 {name=X_82040_ }
C {devices/lab_pin.sym} 50400 -39220 0 0 {name=p49508 lab=_60155_/C }
C {devices/lab_pin.sym} 50400 -39180 0 0 {name=p49509 lab=_60407_/A }
C {devices/lab_pin.sym} 50400 -39140 0 0 {name=p49510 lab=_60403_/B }
C {devices/lab_pin.sym} 50400 -39100 0 0 {name=p49511 lab=_60418_/D }
C {devices/lab_pin.sym} 50520 -39160 0 1 {name=p49512 lab=_60502_/A }
C {sky130_stdcells/and4_4.sym} 50460 -39160 0 0 {name=X_60418_ }
C {devices/lab_pin.sym} 50420 -39010 0 0 {name=p49513 lab=_63912_/X }
C {devices/lab_pin.sym} 50500 -39010 0 1 {name=p49514 lab=_64186_/X }
C {sky130_stdcells/buf_2.sym} 50460 -39010 0 0 {name=X_64186_ }
C {devices/lab_pin.sym} 50400 -38910 0 0 {name=p49515 lab=_61375_/A }
C {devices/lab_pin.sym} 50400 -38870 0 0 {name=p49516 lab=_61398_/B }
C {devices/lab_pin.sym} 50400 -38830 0 0 {name=p49517 lab=_61398_/C }
C {devices/lab_pin.sym} 50520 -38870 0 1 {name=p49518 lab=_61398_/Y }
C {sky130_stdcells/nand3_4.sym} 50460 -38870 0 0 {name=X_61398_ }
C {devices/lab_pin.sym} 50380 -38750 0 0 {name=p49519 lab=_51145_/Y }
C {devices/lab_pin.sym} 50380 -38710 0 0 {name=p49520 lab=_51147_/X }
C {devices/lab_pin.sym} 50380 -38670 0 0 {name=p49521 lab=_51150_/X }
C {devices/lab_pin.sym} 50540 -38710 0 1 {name=p49522 lab=_51151_/Y }
C {sky130_stdcells/a21oi_4.sym} 50460 -38710 0 0 {name=X_51151_ }
C {devices/lab_pin.sym} 50400 -38600 0 0 {name=p49523 lab=_63100_/A }
C {devices/lab_pin.sym} 50400 -38560 0 0 {name=p49524 lab=_63137_/B }
C {devices/lab_pin.sym} 50400 -38520 0 0 {name=p49525 lab=_63147_/C }
C {devices/lab_pin.sym} 50400 -38480 0 0 {name=p49526 lab=_63124_/D }
C {devices/lab_pin.sym} 50520 -38540 0 1 {name=p49527 lab=_63137_/X }
C {sky130_stdcells/and4_4.sym} 50460 -38540 0 0 {name=X_63137_ }
C {devices/lab_pin.sym} 50420 -38390 0 0 {name=p49528 lab=_64939_/A }
C {devices/lab_pin.sym} 50500 -38390 0 1 {name=p49529 lab=_60349_/X }
C {sky130_stdcells/buf_2.sym} 50460 -38390 0 0 {name=X_60349_ }
C {devices/lab_pin.sym} 50400 -38280 0 0 {name=p49530 lab=_68994_/A }
C {devices/lab_pin.sym} 50400 -38240 0 0 {name=p49531 lab=_88346_/Q }
C {devices/lab_pin.sym} 50520 -38260 0 1 {name=p49532 lab=_68994_/X }
C {sky130_stdcells/and2_4.sym} 50460 -38260 0 0 {name=X_68994_ }
C {devices/lab_pin.sym} 50380 -38150 0 0 {name=p49533 lab=_50100_/Y }
C {devices/lab_pin.sym} 50380 -38110 0 0 {name=p49534 lab=_50092_/X }
C {devices/lab_pin.sym} 50380 -38070 0 0 {name=p49535 lab=_50101_/X }
C {devices/lab_pin.sym} 50540 -38110 0 1 {name=p49536 lab=_50102_/Y }
C {sky130_stdcells/a21oi_4.sym} 50460 -38110 0 0 {name=X_50102_ }
C {devices/lab_pin.sym} 50420 -37970 0 0 {name=p49537 lab=_50946_/A }
C {devices/lab_pin.sym} 50500 -37970 0 1 {name=p49538 lab=_51191_/A }
C {sky130_stdcells/buf_2.sym} 50460 -37970 0 0 {name=X_51082_ }
C {devices/lab_pin.sym} 50380 -37870 0 0 {name=p49539 lab=_67941_/X }
C {devices/lab_pin.sym} 50380 -37830 0 0 {name=p49540 lab=_67944_/X }
C {devices/lab_pin.sym} 50380 -37790 0 0 {name=p49541 lab=_67897_/X }
C {devices/lab_pin.sym} 50540 -37830 0 1 {name=p49542 lab=_67945_/Y }
C {sky130_stdcells/a21oi_4.sym} 50460 -37830 0 0 {name=X_67945_ }
C {devices/lab_pin.sym} 50380 -37730 0 0 {name=p49543 lab=_63061_/Y }
C {devices/lab_pin.sym} 50380 -37690 0 0 {name=p49544 lab=_63063_/X }
C {devices/lab_pin.sym} 50380 -37650 0 0 {name=p49545 lab=_63064_/X }
C {devices/lab_pin.sym} 50380 -37610 0 0 {name=p49546 lab=_63066_/X }
C {devices/lab_pin.sym} 50380 -37570 0 0 {name=p49547 lab=_63067_/X }
C {devices/lab_pin.sym} 50540 -37650 0 1 {name=p49548 lab=_63068_/Y }
C {sky130_stdcells/o41ai_4.sym} 50460 -37650 0 0 {name=X_63068_ }
C {devices/lab_pin.sym} 50370 -37490 0 0 {name=p49549 lab=_82896_/CLK }
C {devices/lab_pin.sym} 50370 -37470 0 0 {name=p49550 lab=_83991_/D }
C {devices/lab_pin.sym} 50550 -37490 0 1 {name=p49551 lab=_82639_/D }
C {sky130_stdcells/dfxtp_4.sym} 50460 -37480 0 0 {name=X_83991_ }
C {devices/lab_pin.sym} 50400 -37360 0 0 {name=p49552 lab=_50027_/A }
C {devices/lab_pin.sym} 50400 -37320 0 0 {name=p49553 lab=_53246_/B }
C {devices/lab_pin.sym} 50520 -37340 0 1 {name=p49554 lab=_50033_/Y }
C {sky130_stdcells/nand2_4.sym} 50460 -37340 0 0 {name=X_50033_ }
C {devices/lab_pin.sym} 50400 -37240 0 0 {name=p49555 lab=_54910_/A }
C {devices/lab_pin.sym} 50400 -37200 0 0 {name=p49556 lab=_54910_/B }
C {devices/lab_pin.sym} 50400 -37160 0 0 {name=p49557 lab=_54910_/C }
C {devices/lab_pin.sym} 50400 -37120 0 0 {name=p49558 lab=_53217_/D }
C {devices/lab_pin.sym} 50520 -37180 0 1 {name=p49559 lab=_54910_/X }
C {sky130_stdcells/and4_4.sym} 50460 -37180 0 0 {name=X_54910_ }
C {devices/lab_pin.sym} 50370 -37030 0 0 {name=p49560 lab=_83690_/CLK }
C {devices/lab_pin.sym} 50370 -37010 0 0 {name=p49561 lab=_52923_/Y }
C {devices/lab_pin.sym} 50550 -37030 0 1 {name=p49562 lab=_85730_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -37020 0 0 {name=X_85730_ }
C {devices/lab_pin.sym} 50420 -36890 0 0 {name=p49563 lab=_59765_/A }
C {devices/lab_pin.sym} 50500 -36890 0 1 {name=p49564 lab=_62021_/B }
C {sky130_stdcells/buf_2.sym} 50460 -36890 0 0 {name=X_62019_ }
C {devices/lab_pin.sym} 50370 -36770 0 0 {name=p49565 lab=_82942_/CLK }
C {devices/lab_pin.sym} 50370 -36750 0 0 {name=p49566 lab=_78101_/X }
C {devices/lab_pin.sym} 50550 -36770 0 1 {name=p49567 lab=_46285_/A }
C {sky130_stdcells/dfxtp_4.sym} 50460 -36760 0 0 {name=X_82942_ }
C {devices/lab_pin.sym} 50380 -36660 0 0 {name=p49568 lab=_45081_/A }
C {devices/lab_pin.sym} 50380 -36620 0 0 {name=p49569 lab=_55617_/A }
C {devices/lab_pin.sym} 50380 -36580 0 0 {name=p49570 lab=_44099_/X }
C {devices/lab_pin.sym} 50380 -36540 0 0 {name=p49571 lab=_55889_/X }
C {devices/lab_pin.sym} 50540 -36600 0 1 {name=p49572 lab=_55890_/X }
C {sky130_stdcells/a211o_4.sym} 50460 -36600 0 0 {name=X_55890_ }
C {devices/lab_pin.sym} 50380 -36470 0 0 {name=p49573 lab=_67871_/X }
C {devices/lab_pin.sym} 50380 -36430 0 0 {name=p49574 lab=_67874_/X }
C {devices/lab_pin.sym} 50380 -36390 0 0 {name=p49575 lab=_67875_/X }
C {devices/lab_pin.sym} 50540 -36430 0 1 {name=p49576 lab=_67876_/Y }
C {sky130_stdcells/a21oi_4.sym} 50460 -36430 0 0 {name=X_67876_ }
C {devices/lab_pin.sym} 50380 -36320 0 0 {name=p49577 lab=_69186_/Y }
C {devices/lab_pin.sym} 50380 -36280 0 0 {name=p49578 lab=_69603_/X }
C {devices/lab_pin.sym} 50380 -36240 0 0 {name=p49579 lab=_69604_/X }
C {devices/lab_pin.sym} 50380 -36200 0 0 {name=p49580 lab=_69614_/Y }
C {devices/lab_pin.sym} 50540 -36260 0 1 {name=p49581 lab=_69615_/X }
C {sky130_stdcells/a211o_4.sym} 50460 -36260 0 0 {name=X_69615_ }
C {devices/lab_pin.sym} 50400 -36120 0 0 {name=p49582 lab=_54850_/A }
C {devices/lab_pin.sym} 50400 -36080 0 0 {name=p49583 lab=_47610_/A }
C {devices/lab_pin.sym} 50520 -36100 0 1 {name=p49584 lab=_54841_/Y }
C {sky130_stdcells/nand2_4.sym} 50460 -36100 0 0 {name=X_54841_ }
C {devices/lab_pin.sym} 50380 -35990 0 0 {name=p49585 lab=_80919_/D }
C {devices/lab_pin.sym} 50380 -35950 0 0 {name=p49586 lab=_66734_/X }
C {devices/lab_pin.sym} 50380 -35910 0 0 {name=p49587 lab=_66826_/X }
C {devices/lab_pin.sym} 50540 -35950 0 1 {name=p49588 lab=_66827_/X }
C {sky130_stdcells/a21bo_4.sym} 50460 -35950 0 0 {name=X_66827_ }
C {devices/lab_pin.sym} 50370 -35810 0 0 {name=p49589 lab=_85436_/CLK }
C {devices/lab_pin.sym} 50370 -35790 0 0 {name=p49590 lab=_53289_/Y }
C {devices/lab_pin.sym} 50550 -35810 0 1 {name=p49591 lab=_85661_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -35800 0 0 {name=X_85661_ }
C {devices/lab_pin.sym} 50370 -35670 0 0 {name=p49592 lab=_82942_/CLK }
C {devices/lab_pin.sym} 50370 -35650 0 0 {name=p49593 lab=_78241_/B }
C {devices/lab_pin.sym} 50550 -35670 0 1 {name=p49594 lab=_82873_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -35660 0 0 {name=X_82873_ }
C {devices/lab_pin.sym} 50370 -35530 0 0 {name=p49595 lab=_87653_/CLK }
C {devices/lab_pin.sym} 50370 -35510 0 0 {name=p49596 lab=_43482_/X }
C {devices/lab_pin.sym} 50550 -35530 0 1 {name=p49597 lab=_87400_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -35520 0 0 {name=X_87400_ }
C {devices/lab_pin.sym} 50370 -35390 0 0 {name=p49598 lab=_84469_/CLK }
C {devices/lab_pin.sym} 50370 -35370 0 0 {name=p49599 lab=_84612_/D }
C {devices/lab_pin.sym} 50550 -35390 0 1 {name=p49600 lab=_79152_/A }
C {sky130_stdcells/dfxtp_4.sym} 50460 -35380 0 0 {name=X_84612_ }
C {devices/lab_pin.sym} 50370 -35250 0 0 {name=p49601 lab=_83761_/CLK }
C {devices/lab_pin.sym} 50370 -35230 0 0 {name=p49602 lab=_81632_/Q }
C {devices/lab_pin.sym} 50550 -35250 0 1 {name=p49603 lab=_81824_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -35240 0 0 {name=X_81824_ }
C {devices/lab_pin.sym} 50400 -35120 0 0 {name=p49604 lab=_57597_/A }
C {devices/lab_pin.sym} 50400 -35080 0 0 {name=p49605 lab=_48257_/B }
C {devices/lab_pin.sym} 50520 -35100 0 1 {name=p49606 lab=_57560_/Y }
C {sky130_stdcells/nand2_4.sym} 50460 -35100 0 0 {name=X_57560_ }
C {devices/lab_pin.sym} 50380 -34990 0 0 {name=p49607 lab=_69543_/X }
C {devices/lab_pin.sym} 50380 -34950 0 0 {name=p49608 lab=_69545_/X }
C {devices/lab_pin.sym} 50380 -34910 0 0 {name=p49609 lab=_64629_/A }
C {devices/lab_pin.sym} 50540 -34950 0 1 {name=p49610 lab=_69546_/X }
C {sky130_stdcells/a21o_4.sym} 50460 -34950 0 0 {name=X_69546_ }
C {devices/lab_pin.sym} 50370 -34810 0 0 {name=p49611 lab=_87865_/CLK }
C {devices/lab_pin.sym} 50370 -34790 0 0 {name=p49612 lab=_88380_/D }
C {devices/lab_pin.sym} 50550 -34810 0 1 {name=p49613 lab=_88380_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -34800 0 0 {name=X_88380_ }
C {devices/lab_pin.sym} 50400 -34680 0 0 {name=p49614 lab=_54758_/X }
C {devices/lab_pin.sym} 50400 -34640 0 0 {name=p49615 lab=_54772_/B }
C {devices/lab_pin.sym} 50520 -34660 0 1 {name=p49616 lab=_54772_/Y }
C {sky130_stdcells/nand2_4.sym} 50460 -34660 0 0 {name=X_54772_ }
C {devices/lab_pin.sym} 50370 -34530 0 0 {name=p49617 lab=_85590_/CLK }
C {devices/lab_pin.sym} 50370 -34510 0 0 {name=p49618 lab=_53668_/Y }
C {devices/lab_pin.sym} 50550 -34530 0 1 {name=p49619 lab=_85592_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -34520 0 0 {name=X_85592_ }
C {devices/lab_pin.sym} 50420 -34390 0 0 {name=p49620 lab=_68386_/A }
C {devices/lab_pin.sym} 50500 -34390 0 1 {name=p49621 lab=_66758_/X }
C {sky130_stdcells/buf_2.sym} 50460 -34390 0 0 {name=X_66758_ }
C {devices/lab_pin.sym} 50380 -34290 0 0 {name=p49622 lab=_51980_/Y }
C {devices/lab_pin.sym} 50380 -34250 0 0 {name=p49623 lab=_51981_/X }
C {devices/lab_pin.sym} 50380 -34210 0 0 {name=p49624 lab=_51983_/Y }
C {devices/lab_pin.sym} 50540 -34250 0 1 {name=p49625 lab=_51984_/Y }
C {sky130_stdcells/a21boi_4.sym} 50460 -34250 0 0 {name=X_51984_ }
C {devices/lab_pin.sym} 50380 -34130 0 0 {name=p49626 lab=_56099_/X }
C {devices/lab_pin.sym} 50380 -34090 0 0 {name=p49627 lab=_56499_/X }
C {devices/lab_pin.sym} 50380 -34050 0 0 {name=p49628 lab=_56510_/Y }
C {devices/lab_pin.sym} 50540 -34090 0 1 {name=p49629 lab=_85168_/D }
C {sky130_stdcells/o21ai_4.sym} 50460 -34090 0 0 {name=X_56511_ }
C {devices/lab_pin.sym} 50370 -33950 0 0 {name=p49630 lab=_87045_/CLK }
C {devices/lab_pin.sym} 50370 -33930 0 0 {name=p49631 lab=_43640_/X }
C {devices/lab_pin.sym} 50550 -33950 0 1 {name=p49632 lab=_87331_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -33940 0 0 {name=X_87331_ }
C {devices/lab_pin.sym} 50420 -33810 0 0 {name=p49633 lab=_53723_/A }
C {devices/lab_pin.sym} 50500 -33810 0 1 {name=p49634 lab=_53791_/A }
C {sky130_stdcells/buf_2.sym} 50460 -33810 0 0 {name=X_53723_ }
C {devices/lab_pin.sym} 50380 -33720 0 0 {name=p49635 lab=_65596_/X }
C {devices/lab_pin.sym} 50380 -33680 0 0 {name=p49636 lab=_83063_/Q }
C {devices/lab_pin.sym} 50380 -33640 0 0 {name=p49637 lab=_65707_/X }
C {devices/lab_pin.sym} 50380 -33600 0 0 {name=p49638 lab=_65708_/X }
C {devices/lab_pin.sym} 50540 -33660 0 1 {name=p49639 lab=_65710_/B }
C {sky130_stdcells/a211o_4.sym} 50460 -33660 0 0 {name=X_65709_ }
C {devices/lab_pin.sym} 50370 -33510 0 0 {name=p49640 lab=_84529_/CLK }
C {devices/lab_pin.sym} 50370 -33490 0 0 {name=p49641 lab=_84543_/D }
C {devices/lab_pin.sym} 50550 -33510 0 1 {name=p49642 lab=_84543_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -33500 0 0 {name=X_84543_ }
C {devices/lab_pin.sym} 50380 -33390 0 0 {name=p49643 lab=_50933_/Y }
C {devices/lab_pin.sym} 50380 -33350 0 0 {name=p49644 lab=_50928_/X }
C {devices/lab_pin.sym} 50380 -33310 0 0 {name=p49645 lab=_50934_/X }
C {devices/lab_pin.sym} 50540 -33350 0 1 {name=p49646 lab=_50935_/Y }
C {sky130_stdcells/a21oi_4.sym} 50460 -33350 0 0 {name=X_50935_ }
C {devices/lab_pin.sym} 50400 -33230 0 0 {name=p49647 lab=_57491_/A }
C {devices/lab_pin.sym} 50400 -33190 0 0 {name=p49648 lab=_57491_/B }
C {devices/lab_pin.sym} 50400 -33150 0 0 {name=p49649 lab=_57491_/C }
C {devices/lab_pin.sym} 50520 -33190 0 1 {name=p49650 lab=_57491_/Y }
C {sky130_stdcells/nor3_4.sym} 50460 -33190 0 0 {name=X_57491_ }
C {devices/lab_pin.sym} 50370 -33050 0 0 {name=p49651 lab=_81755_/CLK }
C {devices/lab_pin.sym} 50370 -33030 0 0 {name=p49652 lab=_76104_/B }
C {devices/lab_pin.sym} 50550 -33050 0 1 {name=p49653 lab=_41314_/A }
C {sky130_stdcells/dfxtp_4.sym} 50460 -33040 0 0 {name=X_81755_ }
C {devices/lab_pin.sym} 50380 -32930 0 0 {name=p49654 lab=_81385_/D }
C {devices/lab_pin.sym} 50380 -32890 0 0 {name=p49655 lab=_69439_/X }
C {devices/lab_pin.sym} 50380 -32850 0 0 {name=p49656 lab=_69476_/X }
C {devices/lab_pin.sym} 50540 -32890 0 1 {name=p49657 lab=_83921_/D }
C {sky130_stdcells/a21bo_4.sym} 50460 -32890 0 0 {name=X_69477_ }
C {devices/lab_pin.sym} 50400 -32760 0 0 {name=p49658 lab=_66689_/A }
C {devices/lab_pin.sym} 50400 -32720 0 0 {name=p49659 lab=_66689_/B }
C {devices/lab_pin.sym} 50520 -32740 0 1 {name=p49660 lab=_66689_/X }
C {sky130_stdcells/and2_4.sym} 50460 -32740 0 0 {name=X_66689_ }
C {devices/lab_pin.sym} 50420 -32610 0 0 {name=p49661 lab=_72358_/A }
C {devices/lab_pin.sym} 50500 -32610 0 1 {name=p49662 lab=_59230_/X }
C {sky130_stdcells/buf_2.sym} 50460 -32610 0 0 {name=X_59230_ }
C {devices/lab_pin.sym} 50400 -32510 0 0 {name=p49663 lab=_56446_/A }
C {devices/lab_pin.sym} 50400 -32470 0 0 {name=p49664 lab=_56446_/B }
C {devices/lab_pin.sym} 50400 -32430 0 0 {name=p49665 lab=_56442_/C }
C {devices/lab_pin.sym} 50520 -32470 0 1 {name=p49666 lab=_56442_/Y }
C {sky130_stdcells/nand3_4.sym} 50460 -32470 0 0 {name=X_56442_ }
C {devices/lab_pin.sym} 50380 -32360 0 0 {name=p49667 lab=_87505_/Q }
C {devices/lab_pin.sym} 50380 -32320 0 0 {name=p49668 lab=_68365_/X }
C {devices/lab_pin.sym} 50380 -32280 0 0 {name=p49669 lab=_68053_/X }
C {devices/lab_pin.sym} 50380 -32240 0 0 {name=p49670 lab=_68427_/X }
C {devices/lab_pin.sym} 50540 -32300 0 1 {name=p49671 lab=_68428_/X }
C {sky130_stdcells/a211o_4.sym} 50460 -32300 0 0 {name=X_68428_ }
C {devices/lab_pin.sym} 50370 -32150 0 0 {name=p49672 lab=_81104_/CLK }
C {devices/lab_pin.sym} 50370 -32130 0 0 {name=p49673 lab=_75892_/X }
C {devices/lab_pin.sym} 50550 -32150 0 1 {name=p49674 lab=_80674_/D }
C {sky130_stdcells/dfxtp_4.sym} 50460 -32140 0 0 {name=X_80706_ }
C {devices/lab_pin.sym} 50370 -32010 0 0 {name=p49675 lab=_87776_/CLK }
C {devices/lab_pin.sym} 50370 -31990 0 0 {name=p49676 lab=_43799_/Y }
C {devices/lab_pin.sym} 50550 -32010 0 1 {name=p49677 lab=_69427_/B }
C {sky130_stdcells/dfxtp_4.sym} 50460 -32000 0 0 {name=X_87262_ }
C {devices/lab_pin.sym} 50400 -31890 0 0 {name=p49678 lab=_52135_/A }
C {devices/lab_pin.sym} 50400 -31850 0 0 {name=p49679 lab=_53658_/B }
C {devices/lab_pin.sym} 50400 -31810 0 0 {name=p49680 lab=_53667_/C }
C {devices/lab_pin.sym} 50520 -31850 0 1 {name=p49681 lab=_53654_/X }
C {sky130_stdcells/and3_4.sym} 50460 -31850 0 0 {name=X_53654_ }
C {devices/lab_pin.sym} 50370 -31710 0 0 {name=p49682 lab=_82822_/CLK }
C {devices/lab_pin.sym} 50370 -31690 0 0 {name=p49683 lab=_61519_/Y }
C {devices/lab_pin.sym} 50550 -31710 0 1 {name=p49684 lab=_79142_/B }
C {sky130_stdcells/dfxtp_4.sym} 50460 -31700 0 0 {name=X_84474_ }
C {devices/lab_pin.sym} 50400 -31580 0 0 {name=p49685 lab=_50857_/X }
C {devices/lab_pin.sym} 50400 -31540 0 0 {name=p49686 lab=_51378_/B }
C {devices/lab_pin.sym} 50520 -31560 0 1 {name=p49687 lab=_50866_/Y }
C {sky130_stdcells/nand2_4.sym} 50460 -31560 0 0 {name=X_50866_ }
C {devices/lab_pin.sym} 50370 -31430 0 0 {name=p49688 lab=_81257_/CLK }
C {devices/lab_pin.sym} 50370 -31410 0 0 {name=p49689 lab=_81686_/D }
C {devices/lab_pin.sym} 50550 -31430 0 1 {name=p49690 lab=_81686_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -31420 0 0 {name=X_81686_ }
C {devices/lab_pin.sym} 50370 -31290 0 0 {name=p49691 lab=_86213_/CLK }
C {devices/lab_pin.sym} 50370 -31270 0 0 {name=p49692 lab=_50377_/Y }
C {devices/lab_pin.sym} 50550 -31290 0 1 {name=p49693 lab=_86213_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -31280 0 0 {name=X_86213_ }
C {devices/lab_pin.sym} 50420 -31150 0 0 {name=p49694 lab=_52605_/A }
C {devices/lab_pin.sym} 50500 -31150 0 1 {name=p49695 lab=_52605_/X }
C {sky130_stdcells/buf_2.sym} 50460 -31150 0 0 {name=X_52605_ }
C {devices/lab_pin.sym} 50380 -31050 0 0 {name=p49696 lab=_59160_/X }
C {devices/lab_pin.sym} 50380 -31010 0 0 {name=p49697 lab=_85652_/Q }
C {devices/lab_pin.sym} 50380 -30970 0 0 {name=p49698 lab=_59081_/X }
C {devices/lab_pin.sym} 50540 -31010 0 1 {name=p49699 lab=_59161_/X }
C {sky130_stdcells/o21a_4.sym} 50460 -31010 0 0 {name=X_59161_ }
C {devices/lab_pin.sym} 50370 -30870 0 0 {name=p49700 lab=_82386_/CLK }
C {devices/lab_pin.sym} 50370 -30850 0 0 {name=p49701 lab=_83425_/D }
C {devices/lab_pin.sym} 50550 -30870 0 1 {name=p49702 lab=_83425_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -30860 0 0 {name=X_83425_ }
C {devices/lab_pin.sym} 50420 -30730 0 0 {name=p49703 lab=_56370_/Y }
C {devices/lab_pin.sym} 50500 -30730 0 1 {name=p49704 lab=_56435_/A }
C {sky130_stdcells/buf_2.sym} 50460 -30730 0 0 {name=X_56373_ }
C {devices/lab_pin.sym} 50400 -30620 0 0 {name=p49705 lab=_46128_/D }
C {devices/lab_pin.sym} 50400 -30580 0 0 {name=p49706 lab=_46158_/B }
C {devices/lab_pin.sym} 50520 -30600 0 1 {name=p49707 lab=_80651_/D }
C {sky130_stdcells/nand2_4.sym} 50460 -30600 0 0 {name=X_80637_ }
C {devices/lab_pin.sym} 50420 -30470 0 0 {name=p49708 lab=_68651_/A }
C {devices/lab_pin.sym} 50500 -30470 0 1 {name=p49709 lab=_68359_/X }
C {sky130_stdcells/buf_2.sym} 50460 -30470 0 0 {name=X_68359_ }
C {devices/lab_pin.sym} 50370 -30350 0 0 {name=p49710 lab=_87189_/CLK }
C {devices/lab_pin.sym} 50370 -30330 0 0 {name=p49711 lab=_87193_/D }
C {devices/lab_pin.sym} 50550 -30350 0 1 {name=p49712 lab=_67955_/B }
C {sky130_stdcells/dfxtp_4.sym} 50460 -30340 0 0 {name=X_87193_ }
C {devices/lab_pin.sym} 50420 -30210 0 0 {name=p49713 lab=_53661_/A }
C {devices/lab_pin.sym} 50500 -30210 0 1 {name=p49714 lab=_53846_/A }
C {sky130_stdcells/buf_2.sym} 50460 -30210 0 0 {name=X_53585_ }
C {sky130_stdcells/decap_3.sym} 50460 -30060 0 0 {name=XPHY_103 }
C {devices/lab_pin.sym} 50400 -29920 0 0 {name=p49715 lab=_50787_/X }
C {devices/lab_pin.sym} 50400 -29880 0 0 {name=p49716 lab=_46417_/B }
C {devices/lab_pin.sym} 50520 -29900 0 1 {name=p49717 lab=_50797_/Y }
C {sky130_stdcells/nand2_4.sym} 50460 -29900 0 0 {name=X_50797_ }
C {sky130_stdcells/decap_3.sym} 50460 -29740 0 0 {name=XPHY_114 }
C {devices/lab_pin.sym} 50420 -29590 0 0 {name=p49718 lab=_58796_/A }
C {devices/lab_pin.sym} 50500 -29590 0 1 {name=p49719 lab=_58112_/X }
C {sky130_stdcells/buf_2.sym} 50460 -29590 0 0 {name=X_58112_ }
C {sky130_stdcells/decap_3.sym} 50460 -29440 0 0 {name=XPHY_125 }
C {devices/lab_pin.sym} 50380 -29320 0 0 {name=p49720 lab=_82990_/Q }
C {devices/lab_pin.sym} 50380 -29280 0 0 {name=p49721 lab=_55311_/X }
C {devices/lab_pin.sym} 50380 -29240 0 0 {name=p49722 lab=_55312_/X }
C {devices/lab_pin.sym} 50380 -29200 0 0 {name=p49723 lab=_55323_/X }
C {devices/lab_pin.sym} 50540 -29260 0 1 {name=p49724 lab=_55324_/X }
C {sky130_stdcells/a211o_4.sym} 50460 -29260 0 0 {name=X_55324_ }
C {devices/lab_pin.sym} 50370 -29110 0 0 {name=p49725 lab=_85535_/CLK }
C {devices/lab_pin.sym} 50370 -29090 0 0 {name=p49726 lab=_50737_/Y }
C {devices/lab_pin.sym} 50550 -29110 0 1 {name=p49727 lab=_86144_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -29100 0 0 {name=X_86144_ }
C {devices/lab_pin.sym} 50420 -28970 0 0 {name=p49728 lab=_44733_/A }
C {devices/lab_pin.sym} 50500 -28970 0 1 {name=p49729 lab=_40550_/X }
C {sky130_stdcells/buf_2.sym} 50460 -28970 0 0 {name=X_40550_ }
C {devices/lab_pin.sym} 50380 -28870 0 0 {name=p49730 lab=_65209_/B }
C {devices/lab_pin.sym} 50380 -28830 0 0 {name=p49731 lab=_52500_/X }
C {devices/lab_pin.sym} 50380 -28790 0 0 {name=p49732 lab=_52535_/Y }
C {devices/lab_pin.sym} 50540 -28830 0 1 {name=p49733 lab=_52536_/Y }
C {sky130_stdcells/o21ai_4.sym} 50460 -28830 0 0 {name=X_52536_ }
C {sky130_stdcells/decap_3.sym} 50460 -28660 0 0 {name=XPHY_136 }
C {devices/lab_pin.sym} 50380 -28540 0 0 {name=p49734 lab=_59078_/Y }
C {devices/lab_pin.sym} 50380 -28500 0 0 {name=p49735 lab=_58857_/X }
C {devices/lab_pin.sym} 50380 -28460 0 0 {name=p49736 lab=_59088_/X }
C {devices/lab_pin.sym} 50380 -28420 0 0 {name=p49737 lab=_59091_/X }
C {devices/lab_pin.sym} 50540 -28480 0 1 {name=p49738 lab=_59092_/Y }
C {sky130_stdcells/a22oi_4.sym} 50460 -28480 0 0 {name=X_59092_ }
C {devices/lab_pin.sym} 50380 -28350 0 0 {name=p49739 lab=_71344_/A }
C {devices/lab_pin.sym} 50380 -28310 0 0 {name=p49740 lab=_83522_/Q }
C {devices/lab_pin.sym} 50380 -28270 0 0 {name=p49741 lab=_71369_/X }
C {devices/lab_pin.sym} 50540 -28310 0 1 {name=p49742 lab=_71370_/X }
C {sky130_stdcells/a21o_4.sym} 50460 -28310 0 0 {name=X_71370_ }
C {devices/lab_pin.sym} 50370 -28170 0 0 {name=p49743 lab=_83414_/CLK }
C {devices/lab_pin.sym} 50370 -28150 0 0 {name=p49744 lab=_83356_/D }
C {devices/lab_pin.sym} 50550 -28170 0 1 {name=p49745 lab=_83356_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -28160 0 0 {name=X_83356_ }
C {devices/lab_pin.sym} 50400 -28040 0 0 {name=p49746 lab=_80568_/A }
C {devices/lab_pin.sym} 50400 -28000 0 0 {name=p49747 lab=_80568_/B }
C {devices/lab_pin.sym} 50520 -28020 0 1 {name=p49748 lab=_80569_/B }
C {sky130_stdcells/xor2_4.sym} 50460 -28020 0 0 {name=X_80568_ }
C {sky130_stdcells/decap_3.sym} 50460 -27860 0 0 {name=XPHY_147 }
C {sky130_stdcells/decap_3.sym} 50460 -27680 0 0 {name=XPHY_158 }
C {sky130_stdcells/decap_3.sym} 50460 -27500 0 0 {name=XPHY_169 }
C {devices/lab_pin.sym} 50420 -27350 0 0 {name=p49749 lab=_58618_/A }
C {devices/lab_pin.sym} 50500 -27350 0 1 {name=p49750 lab=_58043_/X }
C {sky130_stdcells/buf_2.sym} 50460 -27350 0 0 {name=X_58043_ }
C {devices/lab_pin.sym} 50400 -27260 0 0 {name=p49751 lab=_70328_/A }
C {devices/lab_pin.sym} 50400 -27220 0 0 {name=p49752 lab=_70328_/B }
C {devices/lab_pin.sym} 50400 -27180 0 0 {name=p49753 lab=_70321_/C }
C {devices/lab_pin.sym} 50400 -27140 0 0 {name=p49754 lab=_70328_/D }
C {devices/lab_pin.sym} 50520 -27200 0 1 {name=p49755 lab=_70321_/X }
C {sky130_stdcells/and4_4.sym} 50460 -27200 0 0 {name=X_70321_ }
C {devices/lab_pin.sym} 50370 -27050 0 0 {name=p49756 lab=_80835_/CLK }
C {devices/lab_pin.sym} 50370 -27030 0 0 {name=p49757 lab=_77006_/Y }
C {devices/lab_pin.sym} 50550 -27050 0 1 {name=p49758 lab=_82307_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -27040 0 0 {name=X_82307_ }
C {devices/lab_pin.sym} 50380 -26930 0 0 {name=p49759 lab=_55254_/A }
C {devices/lab_pin.sym} 50380 -26890 0 0 {name=p49760 lab=_55253_/X }
C {devices/lab_pin.sym} 50380 -26850 0 0 {name=p49761 lab=_83320_/Q }
C {devices/lab_pin.sym} 50540 -26890 0 1 {name=p49762 lab=_55678_/A }
C {sky130_stdcells/a21o_4.sym} 50460 -26890 0 0 {name=X_55255_ }
C {devices/lab_pin.sym} 50370 -26750 0 0 {name=p49763 lab=_85754_/CLK }
C {devices/lab_pin.sym} 50370 -26730 0 0 {name=p49764 lab=_86075_/D }
C {devices/lab_pin.sym} 50550 -26750 0 1 {name=p49765 lab=_86075_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -26740 0 0 {name=X_86075_ }
C {devices/lab_pin.sym} 50380 -26650 0 0 {name=p49766 lab=_40477_/X }
C {devices/lab_pin.sym} 50380 -26610 0 0 {name=p49767 lab=_40443_/X }
C {devices/lab_pin.sym} 50380 -26570 0 0 {name=p49768 lab=_40480_/X }
C {devices/lab_pin.sym} 50380 -26530 0 0 {name=p49769 lab=_88385_/Q }
C {devices/lab_pin.sym} 50380 -26490 0 0 {name=p49770 lab=_40447_/X }
C {devices/lab_pin.sym} 50540 -26570 0 1 {name=p49771 lab=_40481_/Y }
C {sky130_stdcells/o32ai_4.sym} 50460 -26570 0 0 {name=X_40481_ }
C {devices/lab_pin.sym} 50380 -26430 0 0 {name=p49772 lab=_85816_/Q }
C {devices/lab_pin.sym} 50380 -26390 0 0 {name=p49773 lab=_52438_/X }
C {devices/lab_pin.sym} 50380 -26350 0 0 {name=p49774 lab=_52466_/Y }
C {devices/lab_pin.sym} 50540 -26390 0 1 {name=p49775 lab=_52467_/Y }
C {sky130_stdcells/o21ai_4.sym} 50460 -26390 0 0 {name=X_52467_ }
C {devices/lab_pin.sym} 50370 -26250 0 0 {name=p49776 lab=_85542_/CLK }
C {devices/lab_pin.sym} 50370 -26230 0 0 {name=p49777 lab=_83287_/D }
C {devices/lab_pin.sym} 50550 -26250 0 1 {name=p49778 lab=_83287_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -26240 0 0 {name=X_83287_ }
C {devices/lab_pin.sym} 50400 -26120 0 0 {name=p49779 lab=_80495_/X }
C {devices/lab_pin.sym} 50400 -26080 0 0 {name=p49780 lab=_80498_/Y }
C {devices/lab_pin.sym} 50520 -26100 0 1 {name=p49781 lab=_80502_/A }
C {sky130_stdcells/xor2_4.sym} 50460 -26100 0 0 {name=X_80499_ }
C {devices/lab_pin.sym} 50420 -25970 0 0 {name=p49782 lab=clkbuf_6_60_0_CLK/X }
C {devices/lab_pin.sym} 50500 -25970 0 1 {name=p49783 lab=clkbuf_8_241_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 50460 -25970 0 0 {name=Xclkbuf_7_120_0_CLK }
C {devices/lab_pin.sym} 50380 -25880 0 0 {name=p49784 lab=_41361_/X }
C {devices/lab_pin.sym} 50380 -25840 0 0 {name=p49785 lab=_42209_/X }
C {devices/lab_pin.sym} 50380 -25800 0 0 {name=p49786 lab=_87973_/Q }
C {devices/lab_pin.sym} 50380 -25760 0 0 {name=p49787 lab=_42210_/X }
C {devices/lab_pin.sym} 50540 -25820 0 1 {name=p49788 lab=_87973_/D }
C {sky130_stdcells/a2bb2o_4.sym} 50460 -25820 0 0 {name=X_42220_ }
C {devices/lab_pin.sym} 50380 -25690 0 0 {name=p49789 lab=_85484_/Q }
C {devices/lab_pin.sym} 50380 -25650 0 0 {name=p49790 lab=_54193_/X }
C {devices/lab_pin.sym} 50380 -25610 0 0 {name=p49791 lab=_54205_/Y }
C {devices/lab_pin.sym} 50540 -25650 0 1 {name=p49792 lab=_54206_/Y }
C {sky130_stdcells/o21ai_4.sym} 50460 -25650 0 0 {name=X_54206_ }
C {devices/lab_pin.sym} 50400 -25520 0 0 {name=p49793 lab=_73040_/A }
C {devices/lab_pin.sym} 50400 -25480 0 0 {name=p49794 lab=_73040_/B }
C {devices/lab_pin.sym} 50520 -25500 0 1 {name=p49795 lab=_73040_/X }
C {sky130_stdcells/and2_4.sym} 50460 -25500 0 0 {name=X_73040_ }
C {devices/lab_pin.sym} 50370 -25370 0 0 {name=p49796 lab=_85100_/CLK }
C {devices/lab_pin.sym} 50370 -25350 0 0 {name=p49797 lab=_57370_/X }
C {devices/lab_pin.sym} 50550 -25370 0 1 {name=p49798 lab=_85026_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -25360 0 0 {name=X_85026_ }
C {devices/lab_pin.sym} 50400 -25240 0 0 {name=p49799 lab=_51403_/X }
C {devices/lab_pin.sym} 50400 -25200 0 0 {name=p49800 lab=_52944_/B }
C {devices/lab_pin.sym} 50520 -25220 0 1 {name=p49801 lab=_51418_/Y }
C {sky130_stdcells/nand2_4.sym} 50460 -25220 0 0 {name=X_51418_ }
C {devices/lab_pin.sym} 50380 -25110 0 0 {name=p49802 lab=_70238_/X }
C {devices/lab_pin.sym} 50380 -25070 0 0 {name=p49803 lab=_74790_/B }
C {devices/lab_pin.sym} 50380 -25030 0 0 {name=p49804 lab=_70251_/X }
C {devices/lab_pin.sym} 50540 -25070 0 1 {name=p49805 lab=_70252_/X }
C {sky130_stdcells/a21o_4.sym} 50460 -25070 0 0 {name=X_70252_ }
C {devices/lab_pin.sym} 50370 -24930 0 0 {name=p49806 lab=_82515_/CLK }
C {devices/lab_pin.sym} 50370 -24910 0 0 {name=p49807 lab=_82270_/Q }
C {devices/lab_pin.sym} 50550 -24930 0 1 {name=p49808 lab=_82238_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -24920 0 0 {name=X_82238_ }
C {devices/lab_pin.sym} 50400 -24800 0 0 {name=p49809 lab=_55174_/X }
C {devices/lab_pin.sym} 50400 -24760 0 0 {name=p49810 lab=_55186_/B }
C {devices/lab_pin.sym} 50520 -24780 0 1 {name=p49811 lab=_55186_/Y }
C {sky130_stdcells/nor2_4.sym} 50460 -24780 0 0 {name=X_55186_ }
C {devices/lab_pin.sym} 50420 -24650 0 0 {name=p49812 lab=_52398_/A }
C {devices/lab_pin.sym} 50500 -24650 0 1 {name=p49813 lab=_52630_/A }
C {sky130_stdcells/buf_2.sym} 50460 -24650 0 0 {name=X_52398_ }
C {devices/lab_pin.sym} 50420 -24530 0 0 {name=p49814 lab=clkbuf_2_3_0_CLK/X }
C {devices/lab_pin.sym} 50500 -24530 0 1 {name=p49815 lab=clkbuf_2_3_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 50460 -24530 0 0 {name=Xclkbuf_2_3_1_CLK }
C {devices/lab_pin.sym} 50380 -24440 0 0 {name=p49816 lab=_41161_/X }
C {devices/lab_pin.sym} 50380 -24400 0 0 {name=p49817 lab=_42148_/X }
C {devices/lab_pin.sym} 50380 -24360 0 0 {name=p49818 lab=_88010_/Q }
C {devices/lab_pin.sym} 50380 -24320 0 0 {name=p49819 lab=_42150_/X }
C {devices/lab_pin.sym} 50540 -24380 0 1 {name=p49820 lab=_42151_/X }
C {sky130_stdcells/a2bb2o_4.sym} 50460 -24380 0 0 {name=X_42151_ }
C {devices/lab_pin.sym} 50400 -24260 0 0 {name=p49821 lab=_54127_/X }
C {devices/lab_pin.sym} 50400 -24220 0 0 {name=p49822 lab=_54160_/B }
C {devices/lab_pin.sym} 50400 -24180 0 0 {name=p49823 lab=_54118_/X }
C {devices/lab_pin.sym} 50400 -24140 0 0 {name=p49824 lab=_52971_/D }
C {devices/lab_pin.sym} 50520 -24200 0 1 {name=p49825 lab=_54137_/X }
C {sky130_stdcells/and4_4.sym} 50460 -24200 0 0 {name=X_54137_ }
C {devices/lab_pin.sym} 50420 -24050 0 0 {name=p49826 lab=clkbuf_9_45_0_CLK/X }
C {devices/lab_pin.sym} 50500 -24050 0 1 {name=p49827 lab=_84403_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 50460 -24050 0 0 {name=Xclkbuf_10_90_0_CLK }
C {devices/lab_pin.sym} 50380 -23950 0 0 {name=p49828 lab=_51346_/Y }
C {devices/lab_pin.sym} 50380 -23910 0 0 {name=p49829 lab=_51339_/X }
C {devices/lab_pin.sym} 50380 -23870 0 0 {name=p49830 lab=_51348_/X }
C {devices/lab_pin.sym} 50540 -23910 0 1 {name=p49831 lab=_51349_/Y }
C {sky130_stdcells/a21oi_4.sym} 50460 -23910 0 0 {name=X_51349_ }
C {devices/lab_pin.sym} 50400 -23800 0 0 {name=p49832 lab=_70183_/A }
C {devices/lab_pin.sym} 50400 -23760 0 0 {name=p49833 lab=_70183_/B }
C {devices/lab_pin.sym} 50400 -23720 0 0 {name=p49834 lab=_70183_/C }
C {devices/lab_pin.sym} 50400 -23680 0 0 {name=p49835 lab=_70183_/D }
C {devices/lab_pin.sym} 50520 -23740 0 1 {name=p49836 lab=_70183_/X }
C {sky130_stdcells/and4_4.sym} 50460 -23740 0 0 {name=X_70183_ }
C {devices/lab_pin.sym} 50370 -23590 0 0 {name=p49837 lab=_82047_/CLK }
C {devices/lab_pin.sym} 50370 -23570 0 0 {name=p49838 lab=_84161_/Q }
C {devices/lab_pin.sym} 50550 -23590 0 1 {name=p49839 lab=_77942_/A }
C {sky130_stdcells/dfxtp_4.sym} 50460 -23580 0 0 {name=X_82169_ }
C {devices/lab_pin.sym} 50420 -23450 0 0 {name=p49840 lab=_66064_/A }
C {devices/lab_pin.sym} 50500 -23450 0 1 {name=p49841 lab=_60543_/B }
C {sky130_stdcells/buf_2.sym} 50460 -23450 0 0 {name=X_59994_ }
C {devices/lab_pin.sym} 50400 -23340 0 0 {name=p49842 lab=_82275_/Q }
C {devices/lab_pin.sym} 50400 -23300 0 0 {name=p49843 lab=_41102_/B }
C {devices/lab_pin.sym} 50520 -23320 0 1 {name=p49844 lab=_41102_/X }
C {sky130_stdcells/or2_4.sym} 50460 -23320 0 0 {name=X_41102_ }
C {devices/lab_pin.sym} 50420 -23190 0 0 {name=p49845 lab=_43161_/A }
C {devices/lab_pin.sym} 50500 -23190 0 1 {name=p49846 lab=_42083_/A }
C {sky130_stdcells/buf_2.sym} 50460 -23190 0 0 {name=X_42082_ }
C {devices/lab_pin.sym} 50380 -23100 0 0 {name=p49847 lab=_79180_/A }
C {devices/lab_pin.sym} 50380 -23060 0 0 {name=p49848 lab=_58857_/X }
C {devices/lab_pin.sym} 50380 -23020 0 0 {name=p49849 lab=_58940_/X }
C {devices/lab_pin.sym} 50380 -22980 0 0 {name=p49850 lab=_58944_/X }
C {devices/lab_pin.sym} 50540 -23040 0 1 {name=p49851 lab=_58945_/Y }
C {sky130_stdcells/a22oi_4.sym} 50460 -23040 0 0 {name=X_58945_ }
C {devices/lab_pin.sym} 50420 -22890 0 0 {name=p49852 lab=_53990_/A }
C {devices/lab_pin.sym} 50500 -22890 0 1 {name=p49853 lab=_54068_/X }
C {sky130_stdcells/buf_2.sym} 50460 -22890 0 0 {name=X_54068_ }
C {devices/lab_pin.sym} 50400 -22780 0 0 {name=p49854 lab=_74988_/Y }
C {devices/lab_pin.sym} 50400 -22740 0 0 {name=p49855 lab=_74990_/X }
C {devices/lab_pin.sym} 50520 -22760 0 1 {name=p49856 lab=_75001_/A }
C {sky130_stdcells/nand2_4.sym} 50460 -22760 0 0 {name=X_74991_ }
C {devices/lab_pin.sym} 50370 -22630 0 0 {name=p49857 lab=_88363_/CLK }
C {devices/lab_pin.sym} 50370 -22610 0 0 {name=p49858 lab=_86977_/D }
C {devices/lab_pin.sym} 50550 -22630 0 1 {name=p49859 lab=_44747_/A }
C {sky130_stdcells/dfxtp_4.sym} 50460 -22620 0 0 {name=X_86977_ }
C {devices/lab_pin.sym} 50380 -22510 0 0 {name=p49860 lab=_45893_/B }
C {devices/lab_pin.sym} 50380 -22470 0 0 {name=p49861 lab=_86770_/Q }
C {devices/lab_pin.sym} 50380 -22430 0 0 {name=p49862 lab=_45909_/X }
C {devices/lab_pin.sym} 50540 -22470 0 1 {name=p49863 lab=_86844_/D }
C {sky130_stdcells/a21o_4.sym} 50460 -22470 0 0 {name=X_45910_ }
C {devices/lab_pin.sym} 50380 -22360 0 0 {name=p49864 lab=_41032_/X }
C {devices/lab_pin.sym} 50380 -22320 0 0 {name=p49865 lab=_40987_/X }
C {devices/lab_pin.sym} 50380 -22280 0 0 {name=p49866 lab=_69376_/B }
C {devices/lab_pin.sym} 50380 -22240 0 0 {name=p49867 lab=_40989_/X }
C {devices/lab_pin.sym} 50540 -22300 0 1 {name=p49868 lab=_88290_/D }
C {sky130_stdcells/a2bb2o_4.sym} 50460 -22300 0 0 {name=X_41033_ }
C {devices/lab_pin.sym} 50400 -22180 0 0 {name=p49869 lab=_53019_/A }
C {devices/lab_pin.sym} 50400 -22140 0 0 {name=p49870 lab=_53036_/B }
C {devices/lab_pin.sym} 50400 -22100 0 0 {name=p49871 lab=_53019_/C }
C {devices/lab_pin.sym} 50400 -22060 0 0 {name=p49872 lab=_53019_/D }
C {devices/lab_pin.sym} 50520 -22120 0 1 {name=p49873 lab=_53019_/X }
C {sky130_stdcells/and4_4.sym} 50460 -22120 0 0 {name=X_53019_ }
C {devices/lab_pin.sym} 50400 -21980 0 0 {name=p49874 lab=_76714_/Y }
C {devices/lab_pin.sym} 50400 -21940 0 0 {name=p49875 lab=_76715_/Y }
C {devices/lab_pin.sym} 50520 -21960 0 1 {name=p49876 lab=_76730_/Y }
C {sky130_stdcells/nor2_4.sym} 50460 -21960 0 0 {name=X_76730_ }
C {devices/lab_pin.sym} 50400 -21840 0 0 {name=p49877 lab=_87331_/Q }
C {devices/lab_pin.sym} 50400 -21800 0 0 {name=p49878 lab=_74246_/B }
C {devices/lab_pin.sym} 50520 -21820 0 1 {name=p49879 lab=_73942_/Y }
C {sky130_stdcells/nor2_4.sym} 50460 -21820 0 0 {name=X_73942_ }
C {devices/lab_pin.sym} 50370 -21690 0 0 {name=p49880 lab=_86089_/CLK }
C {devices/lab_pin.sym} 50370 -21670 0 0 {name=p49881 lab=_51888_/Y }
C {devices/lab_pin.sym} 50550 -21690 0 1 {name=p49882 lab=_85928_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -21680 0 0 {name=X_85928_ }
C {devices/lab_pin.sym} 50420 -21550 0 0 {name=p49883 lab=_46653_/A }
C {devices/lab_pin.sym} 50500 -21550 0 1 {name=p49884 lab=_47081_/A }
C {sky130_stdcells/buf_2.sym} 50460 -21550 0 0 {name=X_46890_ }
C {devices/lab_pin.sym} 50420 -21430 0 0 {name=p49885 lab=_58876_/A }
C {devices/lab_pin.sym} 50500 -21430 0 1 {name=p49886 lab=_58877_/A }
C {sky130_stdcells/buf_2.sym} 50460 -21430 0 0 {name=X_58876_ }
C {devices/lab_pin.sym} 50380 -21340 0 0 {name=p49887 lab=_55231_/B }
C {devices/lab_pin.sym} 50380 -21300 0 0 {name=p49888 lab=_45394_/X }
C {devices/lab_pin.sym} 50380 -21260 0 0 {name=p49889 lab=_45396_/X }
C {devices/lab_pin.sym} 50380 -21220 0 0 {name=p49890 lab=_45840_/Y }
C {devices/lab_pin.sym} 50540 -21280 0 1 {name=p49891 lab=_45841_/X }
C {sky130_stdcells/a211o_4.sym} 50460 -21280 0 0 {name=X_45841_ }
C {devices/lab_pin.sym} 50380 -21150 0 0 {name=p49892 lab=_57739_/X }
C {devices/lab_pin.sym} 50380 -21110 0 0 {name=p49893 lab=_85723_/Q }
C {devices/lab_pin.sym} 50380 -21070 0 0 {name=p49894 lab=_57814_/X }
C {devices/lab_pin.sym} 50540 -21110 0 1 {name=p49895 lab=_57827_/X }
C {sky130_stdcells/o21a_4.sym} 50460 -21110 0 0 {name=X_57827_ }
C {devices/lab_pin.sym} 50420 -20970 0 0 {name=p49896 lab=_76661_/A }
C {devices/lab_pin.sym} 50500 -20970 0 1 {name=p49897 lab=_76663_/A }
C {sky130_stdcells/inv_2.sym} 50460 -20970 0 0 {name=X_76661_ }
C {devices/lab_pin.sym} 50400 -20860 0 0 {name=p49898 lab=_73873_/A }
C {devices/lab_pin.sym} 50400 -20820 0 0 {name=p49899 lab=_73873_/B }
C {devices/lab_pin.sym} 50520 -20840 0 1 {name=p49900 lab=_73873_/Y }
C {sky130_stdcells/nor2_4.sym} 50460 -20840 0 0 {name=X_73873_ }
C {devices/lab_pin.sym} 50370 -20710 0 0 {name=p49901 lab=_85859_/CLK }
C {devices/lab_pin.sym} 50370 -20690 0 0 {name=p49902 lab=_85859_/D }
C {devices/lab_pin.sym} 50550 -20710 0 1 {name=p49903 lab=_85859_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -20700 0 0 {name=X_85859_ }
C {devices/lab_pin.sym} 50420 -20570 0 0 {name=p49904 lab=clkbuf_8_251_0_CLK/A }
C {devices/lab_pin.sym} 50500 -20570 0 1 {name=p49905 lab=clkbuf_9_502_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 50460 -20570 0 0 {name=Xclkbuf_8_251_0_CLK }
C {devices/lab_pin.sym} 50400 -20460 0 0 {name=p49906 lab=_78400_/A }
C {devices/lab_pin.sym} 50400 -20420 0 0 {name=p49907 lab=_78400_/B }
C {devices/lab_pin.sym} 50520 -20440 0 1 {name=p49908 lab=_82760_/D }
C {sky130_stdcells/xor2_4.sym} 50460 -20440 0 0 {name=X_78400_ }
C {devices/lab_pin.sym} 50400 -20320 0 0 {name=p49909 lab=_81111_/Q }
C {devices/lab_pin.sym} 50400 -20280 0 0 {name=p49910 lab=_75612_/B }
C {devices/lab_pin.sym} 50520 -20300 0 1 {name=p49911 lab=_80775_/D }
C {sky130_stdcells/xor2_4.sym} 50460 -20300 0 0 {name=X_75612_ }
C {devices/lab_pin.sym} 50420 -20170 0 0 {name=p49912 lab=_48559_/Y }
C {devices/lab_pin.sym} 50500 -20170 0 1 {name=p49913 lab=_48561_/B }
C {sky130_stdcells/buf_2.sym} 50460 -20170 0 0 {name=X_48560_ }
C {devices/lab_pin.sym} 50380 -20070 0 0 {name=p49914 lab=_83175_/Q }
C {devices/lab_pin.sym} 50380 -20030 0 0 {name=p49915 lab=_72794_/X }
C {devices/lab_pin.sym} 50380 -19990 0 0 {name=p49916 lab=_72823_/Y }
C {devices/lab_pin.sym} 50540 -20030 0 1 {name=p49917 lab=_83175_/D }
C {sky130_stdcells/a21o_4.sym} 50460 -20030 0 0 {name=X_72824_ }
C {devices/lab_pin.sym} 50380 -19910 0 0 {name=p49918 lab=_79358_/Y }
C {devices/lab_pin.sym} 50380 -19870 0 0 {name=p49919 lab=_79376_/X }
C {devices/lab_pin.sym} 50380 -19830 0 0 {name=p49920 lab=_79379_/Y }
C {devices/lab_pin.sym} 50540 -19870 0 1 {name=p49921 lab=_79381_/B }
C {sky130_stdcells/a21oi_4.sym} 50460 -19870 0 0 {name=X_79380_ }
C {devices/lab_pin.sym} 50380 -19750 0 0 {name=p49922 lab=_85033_/Q }
C {devices/lab_pin.sym} 50380 -19710 0 0 {name=p49923 lab=_44933_/X }
C {devices/lab_pin.sym} 50380 -19670 0 0 {name=p49924 lab=_45771_/X }
C {devices/lab_pin.sym} 50540 -19710 0 1 {name=p49925 lab=_45772_/Y }
C {sky130_stdcells/o21ai_4.sym} 50460 -19710 0 0 {name=X_45772_ }
C {devices/lab_pin.sym} 50420 -19570 0 0 {name=p49926 lab=_58857_/A }
C {devices/lab_pin.sym} 50500 -19570 0 1 {name=p49927 lab=_57758_/X }
C {sky130_stdcells/buf_2.sym} 50460 -19570 0 0 {name=X_57758_ }
C {devices/lab_pin.sym} 50400 -19460 0 0 {name=p49928 lab=_81374_/Q }
C {devices/lab_pin.sym} 50400 -19420 0 0 {name=p49929 lab=_76591_/X }
C {devices/lab_pin.sym} 50520 -19440 0 1 {name=p49930 lab=_76592_/X }
C {sky130_stdcells/xor2_4.sym} 50460 -19440 0 0 {name=X_76592_ }
C {devices/lab_pin.sym} 50420 -19310 0 0 {name=p49931 lab=_43774_/A }
C {devices/lab_pin.sym} 50500 -19310 0 1 {name=p49932 lab=_42984_/X }
C {sky130_stdcells/buf_2.sym} 50460 -19310 0 0 {name=X_42984_ }
C {devices/lab_pin.sym} 50420 -19190 0 0 {name=p49933 lab=_81795_/Q }
C {devices/lab_pin.sym} 50500 -19190 0 1 {name=p49934 lab=_47511_/Y }
C {sky130_stdcells/inv_2.sym} 50460 -19190 0 0 {name=X_47511_ }
C {devices/lab_pin.sym} 50400 -19090 0 0 {name=p49935 lab=_78329_/Y }
C {devices/lab_pin.sym} 50400 -19050 0 0 {name=p49936 lab=_78331_/B }
C {devices/lab_pin.sym} 50400 -19010 0 0 {name=p49937 lab=_78332_/A }
C {devices/lab_pin.sym} 50520 -19050 0 1 {name=p49938 lab=_78337_/C }
C {sky130_stdcells/nand3_4.sym} 50460 -19050 0 0 {name=X_78331_ }
C {devices/lab_pin.sym} 50380 -18950 0 0 {name=p49939 lab=_44712_/X }
C {devices/lab_pin.sym} 50380 -18910 0 0 {name=p49940 lab=_44713_/X }
C {devices/lab_pin.sym} 50380 -18870 0 0 {name=p49941 lab=_40707_/X }
C {devices/lab_pin.sym} 50380 -18830 0 0 {name=p49942 lab=_86986_/Q }
C {devices/lab_pin.sym} 50380 -18790 0 0 {name=p49943 lab=_44714_/X }
C {devices/lab_pin.sym} 50540 -18870 0 1 {name=p49944 lab=_44723_/Y }
C {sky130_stdcells/o32ai_4.sym} 50460 -18870 0 0 {name=X_44723_ }
C {devices/lab_pin.sym} 50420 -18710 0 0 {name=p49945 lab=_57284_/A }
C {devices/lab_pin.sym} 50500 -18710 0 1 {name=p49946 lab=_57416_/A }
C {sky130_stdcells/buf_2.sym} 50460 -18710 0 0 {name=X_56709_ }
C {devices/lab_pin.sym} 50400 -18600 0 0 {name=p49947 lab=_75543_/A }
C {devices/lab_pin.sym} 50400 -18560 0 0 {name=p49948 lab=_75543_/B }
C {devices/lab_pin.sym} 50520 -18580 0 1 {name=p49949 lab=_75543_/X }
C {sky130_stdcells/xor2_4.sym} 50460 -18580 0 0 {name=X_75543_ }
C {devices/lab_pin.sym} 50420 -18450 0 0 {name=p49950 lab=_42081_/A }
C {devices/lab_pin.sym} 50500 -18450 0 1 {name=p49951 lab=_41936_/A }
C {sky130_stdcells/buf_2.sym} 50460 -18450 0 0 {name=X_41935_ }
C {devices/lab_pin.sym} 50370 -18330 0 0 {name=p49952 lab=_87533_/CLK }
C {devices/lab_pin.sym} 50370 -18310 0 0 {name=p49953 lab=_43225_/X }
C {devices/lab_pin.sym} 50550 -18330 0 1 {name=p49954 lab=_87529_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -18320 0 0 {name=X_87529_ }
C {devices/lab_pin.sym} 50420 -18190 0 0 {name=p49955 lab=_83581_/Q }
C {devices/lab_pin.sym} 50500 -18190 0 1 {name=p49956 lab=_53678_/B }
C {sky130_stdcells/inv_2.sym} 50460 -18190 0 0 {name=X_48491_ }
C {devices/lab_pin.sym} 50420 -18070 0 0 {name=p49957 lab=_73359_/A }
C {devices/lab_pin.sym} 50500 -18070 0 1 {name=p49958 lab=_72755_/X }
C {sky130_stdcells/buf_2.sym} 50460 -18070 0 0 {name=X_72755_ }
C {devices/lab_pin.sym} 50420 -17950 0 0 {name=p49959 lab=_57689_/A }
C {devices/lab_pin.sym} 50500 -17950 0 1 {name=p49960 lab=_58094_/A }
C {sky130_stdcells/buf_2.sym} 50460 -17950 0 0 {name=X_57689_ }
C {devices/lab_pin.sym} 50420 -17830 0 0 {name=p49961 lab=_83730_/Q }
C {devices/lab_pin.sym} 50500 -17830 0 1 {name=p49962 lab=_47442_/Y }
C {sky130_stdcells/inv_2.sym} 50460 -17830 0 0 {name=X_47442_ }
C {devices/lab_pin.sym} 50400 -17730 0 0 {name=p49963 lab=_71706_/A }
C {devices/lab_pin.sym} 50400 -17690 0 0 {name=p49964 lab=_71637_/C }
C {devices/lab_pin.sym} 50400 -17650 0 0 {name=p49965 lab=_71777_/B }
C {devices/lab_pin.sym} 50520 -17690 0 1 {name=p49966 lab=_71706_/Y }
C {sky130_stdcells/nand3_4.sym} 50460 -17690 0 0 {name=X_71706_ }
C {devices/lab_pin.sym} 50400 -17560 0 0 {name=p49967 lab=_58548_/A }
C {devices/lab_pin.sym} 50400 -17520 0 0 {name=p49968 lab=_83344_/Q }
C {devices/lab_pin.sym} 50520 -17540 0 1 {name=p49969 lab=_59428_/Y }
C {sky130_stdcells/nor2_4.sym} 50460 -17540 0 0 {name=X_59428_ }
C {devices/lab_pin.sym} 50400 -17420 0 0 {name=p49970 lab=_78262_/A }
C {devices/lab_pin.sym} 50400 -17380 0 0 {name=p49971 lab=_78262_/B }
C {devices/lab_pin.sym} 50520 -17400 0 1 {name=p49972 lab=_78262_/X }
C {sky130_stdcells/xor2_4.sym} 50460 -17400 0 0 {name=X_78262_ }
C {devices/lab_pin.sym} 50380 -17310 0 0 {name=p49973 lab=_44638_/X }
C {devices/lab_pin.sym} 50380 -17270 0 0 {name=p49974 lab=_44639_/X }
C {devices/lab_pin.sym} 50380 -17230 0 0 {name=p49975 lab=_41076_/A }
C {devices/lab_pin.sym} 50380 -17190 0 0 {name=p49976 lab=_87014_/Q }
C {devices/lab_pin.sym} 50380 -17150 0 0 {name=p49977 lab=_44640_/X }
C {devices/lab_pin.sym} 50540 -17230 0 1 {name=p49978 lab=_44655_/A }
C {sky130_stdcells/o32ai_4.sym} 50460 -17230 0 0 {name=X_44654_ }
C {devices/lab_pin.sym} 50400 -17080 0 0 {name=p49979 lab=_75475_/A }
C {devices/lab_pin.sym} 50400 -17040 0 0 {name=p49980 lab=_75475_/B }
C {devices/lab_pin.sym} 50520 -17060 0 1 {name=p49981 lab=_75477_/B }
C {sky130_stdcells/nor2_4.sym} 50460 -17060 0 0 {name=X_75474_ }
C {devices/lab_pin.sym} 50420 -16930 0 0 {name=p49982 lab=_41877_/A }
C {devices/lab_pin.sym} 50500 -16930 0 1 {name=p49983 lab=_42429_/A }
C {sky130_stdcells/buf_2.sym} 50460 -16930 0 0 {name=X_41866_ }
C {devices/lab_pin.sym} 50420 -16810 0 0 {name=p49984 lab=_72686_/A }
C {devices/lab_pin.sym} 50500 -16810 0 1 {name=p49985 lab=_72686_/X }
C {sky130_stdcells/buf_2.sym} 50460 -16810 0 0 {name=X_72686_ }
C {devices/lab_pin.sym} 50420 -16690 0 0 {name=p49986 lab=clkbuf_9_130_0_CLK/X }
C {devices/lab_pin.sym} 50500 -16690 0 1 {name=p49987 lab=_83480_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 50460 -16690 0 0 {name=Xclkbuf_10_261_0_CLK }
C {devices/lab_pin.sym} 50400 -16580 0 0 {name=p49988 lab=_77213_/A }
C {devices/lab_pin.sym} 50400 -16540 0 0 {name=p49989 lab=_77212_/Y }
C {devices/lab_pin.sym} 50520 -16560 0 1 {name=p49990 lab=_77214_/B }
C {sky130_stdcells/xor2_4.sym} 50460 -16560 0 0 {name=X_77213_ }
C {devices/lab_pin.sym} 50420 -16430 0 0 {name=p49991 lab=_43605_/A }
C {devices/lab_pin.sym} 50500 -16430 0 1 {name=p49992 lab=_43606_/A }
C {sky130_stdcells/buf_2.sym} 50460 -16430 0 0 {name=X_43605_ }
C {devices/lab_pin.sym} 50420 -16310 0 0 {name=p49993 lab=_74458_/A }
C {devices/lab_pin.sym} 50500 -16310 0 1 {name=p49994 lab=_74425_/X }
C {sky130_stdcells/buf_2.sym} 50460 -16310 0 0 {name=X_74425_ }
C {devices/lab_pin.sym} 50420 -16190 0 0 {name=p49995 lab=_40817_/A }
C {devices/lab_pin.sym} 50500 -16190 0 1 {name=p49996 lab=_40817_/X }
C {sky130_stdcells/buf_2.sym} 50460 -16190 0 0 {name=X_40817_ }
C {devices/lab_pin.sym} 50420 -16070 0 0 {name=p49997 lab=_47372_/Y }
C {devices/lab_pin.sym} 50500 -16070 0 1 {name=p49998 lab=_53012_/B }
C {sky130_stdcells/buf_2.sym} 50460 -16070 0 0 {name=X_47373_ }
C {devices/lab_pin.sym} 50380 -15970 0 0 {name=p49999 lab=_59356_/Y }
C {devices/lab_pin.sym} 50380 -15930 0 0 {name=p50000 lab=_59358_/Y }
C {devices/lab_pin.sym} 50380 -15890 0 0 {name=p50001 lab=_59297_/X }
C {devices/lab_pin.sym} 50540 -15930 0 1 {name=p50002 lab=_59359_/X }
C {sky130_stdcells/a21o_4.sym} 50460 -15930 0 0 {name=X_59359_ }
C {devices/lab_pin.sym} 50400 -15810 0 0 {name=p50003 lab=_71637_/A }
C {devices/lab_pin.sym} 50400 -15770 0 0 {name=p50004 lab=_71226_/B }
C {devices/lab_pin.sym} 50400 -15730 0 0 {name=p50005 lab=_71637_/C }
C {devices/lab_pin.sym} 50520 -15770 0 1 {name=p50006 lab=_71637_/Y }
C {sky130_stdcells/nand3_4.sym} 50460 -15770 0 0 {name=X_71637_ }
C {sky130_stdcells/decap_3.sym} 50460 -15600 0 0 {name=XPHY_5 }
C {devices/lab_pin.sym} 50400 -15470 0 0 {name=p50007 lab=_78191_/B }
C {devices/lab_pin.sym} 50400 -15430 0 0 {name=p50008 lab=_78193_/B }
C {devices/lab_pin.sym} 50400 -15390 0 0 {name=p50009 lab=_78174_/B }
C {devices/lab_pin.sym} 50520 -15430 0 1 {name=p50010 lab=_78193_/Y }
C {sky130_stdcells/nand3_4.sym} 50460 -15430 0 0 {name=X_78193_ }
C {devices/lab_pin.sym} 50420 -15290 0 0 {name=p50011 lab=clkbuf_9_445_0_CLK/X }
C {devices/lab_pin.sym} 50500 -15290 0 1 {name=p50012 lab=_86145_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 50460 -15290 0 0 {name=Xclkbuf_10_891_0_CLK }
C {devices/lab_pin.sym} 50380 -15210 0 0 {name=p50013 lab=_44565_/X }
C {devices/lab_pin.sym} 50380 -15170 0 0 {name=p50014 lab=_44567_/X }
C {devices/lab_pin.sym} 50380 -15130 0 0 {name=p50015 lab=_40909_/X }
C {devices/lab_pin.sym} 50380 -15090 0 0 {name=p50016 lab=_87044_/Q }
C {devices/lab_pin.sym} 50380 -15050 0 0 {name=p50017 lab=_44568_/X }
C {devices/lab_pin.sym} 50540 -15130 0 1 {name=p50018 lab=_44586_/A }
C {sky130_stdcells/o32ai_4.sym} 50460 -15130 0 0 {name=X_44585_ }
C {devices/lab_pin.sym} 50420 -14970 0 0 {name=p50019 lab=_41796_/Y }
C {devices/lab_pin.sym} 50500 -14970 0 1 {name=p50020 lab=_41797_/X }
C {sky130_stdcells/buf_2.sym} 50460 -14970 0 0 {name=X_41797_ }
C {devices/lab_pin.sym} 50420 -14850 0 0 {name=p50021 lab=_49112_/A }
C {devices/lab_pin.sym} 50500 -14850 0 1 {name=p50022 lab=_50677_/A }
C {sky130_stdcells/buf_2.sym} 50460 -14850 0 0 {name=X_49112_ }
C {devices/lab_pin.sym} 50420 -14730 0 0 {name=p50023 lab=clkbuf_9_21_0_CLK/X }
C {devices/lab_pin.sym} 50500 -14730 0 1 {name=p50024 lab=_83843_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 50460 -14730 0 0 {name=Xclkbuf_10_43_0_CLK }
C {devices/lab_pin.sym} 50420 -14610 0 0 {name=p50025 lab=_83651_/Q }
C {devices/lab_pin.sym} 50500 -14610 0 1 {name=p50026 lab=_53971_/B }
C {sky130_stdcells/inv_2.sym} 50460 -14610 0 0 {name=X_46324_ }
C {devices/lab_pin.sym} 50400 -14500 0 0 {name=p50027 lab=_77143_/Y }
C {devices/lab_pin.sym} 50400 -14460 0 0 {name=p50028 lab=_77141_/C }
C {devices/lab_pin.sym} 50520 -14480 0 1 {name=p50029 lab=_77144_/X }
C {sky130_stdcells/and2_4.sym} 50460 -14480 0 0 {name=X_77144_ }
C {devices/lab_pin.sym} 50380 -14380 0 0 {name=p50030 lab=_40408_/X }
C {devices/lab_pin.sym} 50380 -14340 0 0 {name=p50031 lab=_43532_/X }
C {devices/lab_pin.sym} 50380 -14300 0 0 {name=p50032 lab=_87371_/Q }
C {devices/lab_pin.sym} 50380 -14260 0 0 {name=p50033 lab=_43533_/X }
C {devices/lab_pin.sym} 50540 -14320 0 1 {name=p50034 lab=_87371_/D }
C {sky130_stdcells/a2bb2o_4.sym} 50460 -14320 0 0 {name=X_43536_ }
C {devices/lab_pin.sym} 50380 -14190 0 0 {name=p50035 lab=_62368_/Y }
C {devices/lab_pin.sym} 50380 -14150 0 0 {name=p50036 lab=_62327_/X }
C {devices/lab_pin.sym} 50380 -14110 0 0 {name=p50037 lab=_62369_/Y }
C {devices/lab_pin.sym} 50540 -14150 0 1 {name=p50038 lab=_84415_/D }
C {sky130_stdcells/a21oi_4.sym} 50460 -14150 0 0 {name=X_62370_ }
C {devices/lab_pin.sym} 50380 -14030 0 0 {name=p50039 lab=_83085_/Q }
C {devices/lab_pin.sym} 50380 -13990 0 0 {name=p50040 lab=_72699_/X }
C {devices/lab_pin.sym} 50380 -13950 0 0 {name=p50041 lab=_74355_/Y }
C {devices/lab_pin.sym} 50540 -13990 0 1 {name=p50042 lab=_74356_/X }
C {sky130_stdcells/a21bo_4.sym} 50460 -13990 0 0 {name=X_74356_ }
C {devices/lab_pin.sym} 50380 -13870 0 0 {name=p50043 lab=_40628_/X }
C {devices/lab_pin.sym} 50380 -13830 0 0 {name=p50044 lab=_81124_/Q }
C {devices/lab_pin.sym} 50380 -13790 0 0 {name=p50045 lab=_40747_/X }
C {devices/lab_pin.sym} 50540 -13830 0 1 {name=p50046 lab=_40748_/Y }
C {sky130_stdcells/o21ai_4.sym} 50460 -13830 0 0 {name=X_40748_ }
C {devices/lab_pin.sym} 50400 -13710 0 0 {name=p50047 lab=_70558_/X }
C {devices/lab_pin.sym} 50400 -13670 0 0 {name=p50048 lab=_71583_/B }
C {devices/lab_pin.sym} 50400 -13630 0 0 {name=p50049 lab=_71558_/X }
C {devices/lab_pin.sym} 50520 -13670 0 1 {name=p50050 lab=_71568_/Y }
C {sky130_stdcells/nor3_4.sym} 50460 -13670 0 0 {name=X_71568_ }
C {devices/lab_pin.sym} 50420 -13530 0 0 {name=p50051 lab=clkbuf_9_382_0_CLK/A }
C {devices/lab_pin.sym} 50500 -13530 0 1 {name=p50052 lab=clkbuf_9_382_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 50460 -13530 0 0 {name=Xclkbuf_9_382_0_CLK }
C {devices/lab_pin.sym} 50400 -13430 0 0 {name=p50053 lab=_72507_/A }
C {devices/lab_pin.sym} 50400 -13390 0 0 {name=p50054 lab=_61317_/A }
C {devices/lab_pin.sym} 50400 -13350 0 0 {name=p50055 lab=_61313_/A }
C {devices/lab_pin.sym} 50520 -13390 0 1 {name=p50056 lab=_61321_/Y }
C {sky130_stdcells/nand3_4.sym} 50460 -13390 0 0 {name=X_61321_ }
C {devices/lab_pin.sym} 50380 -13270 0 0 {name=p50057 lab=_49037_/Y }
C {devices/lab_pin.sym} 50380 -13230 0 0 {name=p50058 lab=_49038_/X }
C {devices/lab_pin.sym} 50380 -13190 0 0 {name=p50059 lab=_49042_/X }
C {devices/lab_pin.sym} 50540 -13230 0 1 {name=p50060 lab=_86450_/D }
C {sky130_stdcells/a21oi_4.sym} 50460 -13230 0 0 {name=X_49043_ }
C {devices/lab_pin.sym} 50400 -13100 0 0 {name=p50061 lab=_73426_/A }
C {devices/lab_pin.sym} 50400 -13060 0 0 {name=p50062 lab=_86476_/Q }
C {devices/lab_pin.sym} 50520 -13080 0 1 {name=p50063 lab=_73307_/X }
C {sky130_stdcells/and2_4.sym} 50460 -13080 0 0 {name=X_73307_ }
C {devices/lab_pin.sym} 50420 -12950 0 0 {name=p50064 lab=_53946_/B }
C {devices/lab_pin.sym} 50500 -12950 0 1 {name=p50065 lab=_49212_/B }
C {sky130_stdcells/buf_2.sym} 50460 -12950 0 0 {name=X_46255_ }
C {devices/lab_pin.sym} 50380 -12850 0 0 {name=p50066 lab=_57668_/Y }
C {devices/lab_pin.sym} 50380 -12810 0 0 {name=p50067 lab=_70501_/X }
C {devices/lab_pin.sym} 50380 -12770 0 0 {name=p50068 lab=_70518_/Y }
C {devices/lab_pin.sym} 50540 -12810 0 1 {name=p50069 lab=_70519_/Y }
C {sky130_stdcells/o21ai_4.sym} 50460 -12810 0 0 {name=X_70519_ }
C {sky130_stdcells/decap_3.sym} 50460 -12640 0 0 {name=XPHY_670 }
C {devices/lab_pin.sym} 50400 -12500 0 0 {name=p50070 lab=_81997_/Q }
C {devices/lab_pin.sym} 50400 -12460 0 0 {name=p50071 lab=_82285_/D }
C {devices/lab_pin.sym} 50520 -12480 0 1 {name=p50072 lab=_77077_/A }
C {sky130_stdcells/or2_4.sym} 50460 -12480 0 0 {name=X_77075_ }
C {devices/lab_pin.sym} 50420 -12350 0 0 {name=p50073 lab=_43466_/X }
C {devices/lab_pin.sym} 50500 -12350 0 1 {name=p50074 lab=_43467_/X }
C {sky130_stdcells/buf_2.sym} 50460 -12350 0 0 {name=X_43467_ }
C {devices/lab_pin.sym} 50380 -12250 0 0 {name=p50075 lab=_83112_/Q }
C {devices/lab_pin.sym} 50380 -12210 0 0 {name=p50076 lab=_72702_/X }
C {devices/lab_pin.sym} 50380 -12170 0 0 {name=p50077 lab=_74286_/Y }
C {devices/lab_pin.sym} 50540 -12210 0 1 {name=p50078 lab=_83112_/D }
C {sky130_stdcells/a21bo_4.sym} 50460 -12210 0 0 {name=X_74287_ }
C {sky130_stdcells/decap_3.sym} 50460 -12040 0 0 {name=XPHY_681 }
C {devices/lab_pin.sym} 50420 -11890 0 0 {name=p50079 lab=clkbuf_9_138_0_CLK/X }
C {devices/lab_pin.sym} 50500 -11890 0 1 {name=p50080 lab=_85407_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 50460 -11890 0 0 {name=Xclkbuf_10_276_0_CLK }
C {devices/lab_pin.sym} 50380 -11800 0 0 {name=p50081 lab=_40678_/X }
C {devices/lab_pin.sym} 50380 -11760 0 0 {name=p50082 lab=_40651_/X }
C {devices/lab_pin.sym} 50380 -11720 0 0 {name=p50083 lab=_88355_/Q }
C {devices/lab_pin.sym} 50380 -11680 0 0 {name=p50084 lab=_40652_/X }
C {devices/lab_pin.sym} 50540 -11740 0 1 {name=p50085 lab=_88355_/D }
C {sky130_stdcells/a2bb2o_4.sym} 50460 -11740 0 0 {name=X_40679_ }
C {devices/lab_pin.sym} 50380 -11610 0 0 {name=p50086 lab=_71487_/X }
C {devices/lab_pin.sym} 50380 -11570 0 0 {name=p50087 lab=_83477_/Q }
C {devices/lab_pin.sym} 50380 -11530 0 0 {name=p50088 lab=_71498_/X }
C {devices/lab_pin.sym} 50540 -11570 0 1 {name=p50089 lab=_83477_/D }
C {sky130_stdcells/a21o_4.sym} 50460 -11570 0 0 {name=X_71499_ }
C {sky130_stdcells/decap_3.sym} 50460 -11400 0 0 {name=XPHY_692 }
C {devices/lab_pin.sym} 50420 -11250 0 0 {name=p50090 lab=_45281_/A }
C {devices/lab_pin.sym} 50500 -11250 0 1 {name=p50091 lab=_45206_/X }
C {sky130_stdcells/buf_2.sym} 50460 -11250 0 0 {name=X_45206_ }
C {devices/lab_pin.sym} 50400 -11160 0 0 {name=p50092 lab=_63227_/B }
C {devices/lab_pin.sym} 50400 -11120 0 0 {name=p50093 lab=_64118_/B }
C {devices/lab_pin.sym} 50400 -11080 0 0 {name=p50094 lab=_64040_/C }
C {devices/lab_pin.sym} 50400 -11040 0 0 {name=p50095 lab=_64142_/D }
C {devices/lab_pin.sym} 50520 -11100 0 1 {name=p50096 lab=_64040_/Y }
C {sky130_stdcells/nand4_4.sym} 50460 -11100 0 0 {name=X_64040_ }
C {devices/lab_pin.sym} 50400 -10960 0 0 {name=p50097 lab=_81713_/D }
C {devices/lab_pin.sym} 50400 -10920 0 0 {name=p50098 lab=_76027_/B }
C {devices/lab_pin.sym} 50520 -10940 0 1 {name=p50099 lab=_76028_/A }
C {sky130_stdcells/or2_4.sym} 50460 -10940 0 0 {name=X_76026_ }
C {devices/lab_pin.sym} 50380 -10850 0 0 {name=p50100 lab=_42417_/X }
C {devices/lab_pin.sym} 50380 -10810 0 0 {name=p50101 lab=_42410_/X }
C {devices/lab_pin.sym} 50380 -10770 0 0 {name=p50102 lab=_40474_/X }
C {devices/lab_pin.sym} 50380 -10730 0 0 {name=p50103 lab=_87874_/Q }
C {devices/lab_pin.sym} 50380 -10690 0 0 {name=p50104 lab=_42411_/X }
C {devices/lab_pin.sym} 50540 -10770 0 1 {name=p50105 lab=_42419_/A }
C {sky130_stdcells/o32ai_4.sym} 50460 -10770 0 0 {name=X_42418_ }
C {devices/lab_pin.sym} 50420 -10610 0 0 {name=p50106 lab=_72590_/A }
C {devices/lab_pin.sym} 50500 -10610 0 1 {name=p50107 lab=_61252_/X }
C {sky130_stdcells/buf_2.sym} 50460 -10610 0 0 {name=X_61252_ }
C {devices/lab_pin.sym} 50420 -10490 0 0 {name=p50108 lab=_73238_/A }
C {devices/lab_pin.sym} 50500 -10490 0 1 {name=p50109 lab=_73238_/X }
C {sky130_stdcells/buf_2.sym} 50460 -10490 0 0 {name=X_73238_ }
C {devices/lab_pin.sym} 50400 -10380 0 0 {name=p50110 lab=_46186_/A }
C {devices/lab_pin.sym} 50400 -10340 0 0 {name=p50111 lab=_46125_/A }
C {devices/lab_pin.sym} 50520 -10360 0 1 {name=p50112 lab=_46186_/X }
C {sky130_stdcells/or2_4.sym} 50460 -10360 0 0 {name=X_46186_ }
C {devices/lab_pin.sym} 50380 -10260 0 0 {name=p50113 lab=_41469_/X }
C {devices/lab_pin.sym} 50380 -10220 0 0 {name=p50114 lab=_43396_/X }
C {devices/lab_pin.sym} 50380 -10180 0 0 {name=p50115 lab=_87441_/Q }
C {devices/lab_pin.sym} 50380 -10140 0 0 {name=p50116 lab=_43397_/X }
C {devices/lab_pin.sym} 50540 -10200 0 1 {name=p50117 lab=_87441_/D }
C {sky130_stdcells/a2bb2o_4.sym} 50460 -10200 0 0 {name=X_43398_ }
C {devices/lab_pin.sym} 50420 -10050 0 0 {name=p50118 lab=clkbuf_9_29_0_CLK/X }
C {devices/lab_pin.sym} 50500 -10050 0 1 {name=p50119 lab=_85040_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 50460 -10050 0 0 {name=Xclkbuf_10_58_0_CLK }
C {devices/lab_pin.sym} 50420 -9930 0 0 {name=p50120 lab=_62737_/A }
C {devices/lab_pin.sym} 50500 -9930 0 1 {name=p50121 lab=_60218_/A }
C {sky130_stdcells/buf_2.sym} 50460 -9930 0 0 {name=X_60203_ }
C {devices/lab_pin.sym} 50420 -9810 0 0 {name=p50122 lab=_45212_/A }
C {devices/lab_pin.sym} 50500 -9810 0 1 {name=p50123 lab=_45137_/X }
C {sky130_stdcells/buf_2.sym} 50460 -9810 0 0 {name=X_45137_ }
C {devices/lab_pin.sym} 50420 -9690 0 0 {name=p50124 lab=_42348_/Y }
C {devices/lab_pin.sym} 50500 -9690 0 1 {name=p50125 lab=_87909_/D }
C {sky130_stdcells/inv_2.sym} 50460 -9690 0 0 {name=X_42349_ }
C {devices/lab_pin.sym} 50400 -9600 0 0 {name=p50126 lab=_61183_/A }
C {devices/lab_pin.sym} 50400 -9560 0 0 {name=p50127 lab=_61177_/Y }
C {devices/lab_pin.sym} 50400 -9520 0 0 {name=p50128 lab=_61178_/Y }
C {devices/lab_pin.sym} 50400 -9480 0 0 {name=p50129 lab=_61182_/X }
C {devices/lab_pin.sym} 50520 -9540 0 1 {name=p50130 lab=_61183_/Y }
C {sky130_stdcells/nor4_4.sym} 50460 -9540 0 0 {name=X_61183_ }
C {devices/lab_pin.sym} 50400 -9400 0 0 {name=p50131 lab=_74437_/B }
C {devices/lab_pin.sym} 50400 -9360 0 0 {name=p50132 lab=_73169_/B }
C {devices/lab_pin.sym} 50520 -9380 0 1 {name=p50133 lab=_73169_/X }
C {sky130_stdcells/xor2_4.sym} 50460 -9380 0 0 {name=X_73169_ }
C {devices/lab_pin.sym} 50420 -9250 0 0 {name=p50134 lab=clkbuf_8_198_0_CLK/X }
C {devices/lab_pin.sym} 50500 -9250 0 1 {name=p50135 lab=clkbuf_9_397_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 50460 -9250 0 0 {name=Xclkbuf_9_397_0_CLK }
C {devices/lab_pin.sym} 50420 -9130 0 0 {name=p50136 lab=clkbuf_8_205_0_CLK/A }
C {devices/lab_pin.sym} 50500 -9130 0 1 {name=p50137 lab=clkbuf_9_409_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 50460 -9130 0 0 {name=Xclkbuf_8_204_0_CLK }
C {devices/lab_pin.sym} 50380 -9040 0 0 {name=p50138 lab=_84656_/Q }
C {devices/lab_pin.sym} 50380 -9000 0 0 {name=p50139 lab=_60132_/X }
C {devices/lab_pin.sym} 50380 -8960 0 0 {name=p50140 lab=_60133_/Y }
C {devices/lab_pin.sym} 50380 -8920 0 0 {name=p50141 lab=_60015_/Y }
C {devices/lab_pin.sym} 50540 -8980 0 1 {name=p50142 lab=_60134_/X }
C {sky130_stdcells/a2bb2o_4.sym} 50460 -8980 0 0 {name=X_60134_ }
C {devices/lab_pin.sym} 50400 -8840 0 0 {name=p50143 lab=_49955_/A }
C {devices/lab_pin.sym} 50400 -8800 0 0 {name=p50144 lab=_53157_/B }
C {devices/lab_pin.sym} 50520 -8820 0 1 {name=p50145 lab=_49945_/Y }
C {sky130_stdcells/nand2_4.sym} 50460 -8820 0 0 {name=X_49945_ }
C {devices/lab_pin.sym} 50380 -8710 0 0 {name=p50146 lab=_45065_/X }
C {devices/lab_pin.sym} 50380 -8670 0 0 {name=p50147 lab=_45067_/Y }
C {devices/lab_pin.sym} 50380 -8630 0 0 {name=p50148 lab=_45049_/X }
C {devices/lab_pin.sym} 50540 -8670 0 1 {name=p50149 lab=_45068_/Y }
C {sky130_stdcells/a21oi_4.sym} 50460 -8670 0 0 {name=X_45068_ }
C {devices/lab_pin.sym} 50420 -8530 0 0 {name=p50150 lab=_65486_/A }
C {devices/lab_pin.sym} 50500 -8530 0 1 {name=p50151 lab=_65992_/A }
C {sky130_stdcells/buf_2.sym} 50460 -8530 0 0 {name=X_65991_ }
C {devices/lab_pin.sym} 50420 -8410 0 0 {name=p50152 lab=_77977_/A }
C {devices/lab_pin.sym} 50500 -8410 0 1 {name=p50153 lab=_77977_/Y }
C {sky130_stdcells/inv_2.sym} 50460 -8410 0 0 {name=X_77977_ }
C {devices/lab_pin.sym} 50420 -8290 0 0 {name=p50154 lab=_44019_/A }
C {devices/lab_pin.sym} 50500 -8290 0 1 {name=p50155 lab=_44020_/A }
C {sky130_stdcells/buf_2.sym} 50460 -8290 0 0 {name=X_44019_ }
C {devices/lab_pin.sym} 50380 -8200 0 0 {name=p50156 lab=_87459_/Q }
C {devices/lab_pin.sym} 50380 -8160 0 0 {name=p50157 lab=_67628_/X }
C {devices/lab_pin.sym} 50380 -8120 0 0 {name=p50158 lab=_67702_/X }
C {devices/lab_pin.sym} 50380 -8080 0 0 {name=p50159 lab=_67729_/X }
C {devices/lab_pin.sym} 50540 -8140 0 1 {name=p50160 lab=_67730_/X }
C {sky130_stdcells/a211o_4.sym} 50460 -8140 0 0 {name=X_67730_ }
C {devices/lab_pin.sym} 50400 -8000 0 0 {name=p50161 lab=_79702_/A }
C {devices/lab_pin.sym} 50400 -7960 0 0 {name=p50162 lab=_79701_/Y }
C {devices/lab_pin.sym} 50520 -7980 0 1 {name=p50163 lab=_79716_/X }
C {sky130_stdcells/or2_4.sym} 50460 -7980 0 0 {name=X_79716_ }
C {devices/lab_pin.sym} 50400 -7870 0 0 {name=p50164 lab=_65047_/A }
C {devices/lab_pin.sym} 50400 -7830 0 0 {name=p50165 lab=_64870_/B }
C {devices/lab_pin.sym} 50400 -7790 0 0 {name=p50166 lab=_64942_/C }
C {devices/lab_pin.sym} 50520 -7830 0 1 {name=p50167 lab=_64942_/Y }
C {sky130_stdcells/nor3_4.sym} 50460 -7830 0 0 {name=X_64942_ }
C {devices/lab_pin.sym} 50380 -7730 0 0 {name=p50168 lab=_59951_/D }
C {devices/lab_pin.sym} 50380 -7690 0 0 {name=p50169 lab=_60061_/Y }
C {devices/lab_pin.sym} 50380 -7650 0 0 {name=p50170 lab=_60063_/Y }
C {devices/lab_pin.sym} 50380 -7610 0 0 {name=p50171 lab=_60129_/B }
C {devices/lab_pin.sym} 50380 -7580 0 0 {name=p50172 lab=_60064_/Y }
C {devices/lab_pin.sym} 50540 -7650 0 1 {name=p50173 lab=_84668_/D }
C {sky130_stdcells/a41oi_4.sym} 50460 -7650 0 0 {name=X_60065_ }
C {devices/lab_pin.sym} 50400 -7500 0 0 {name=p50174 lab=_76928_/A }
C {devices/lab_pin.sym} 50400 -7460 0 0 {name=p50175 lab=_76927_/Y }
C {devices/lab_pin.sym} 50520 -7480 0 1 {name=p50176 lab=_81567_/D }
C {sky130_stdcells/nand2_4.sym} 50460 -7480 0 0 {name=X_76928_ }
C {devices/lab_pin.sym} 50420 -7350 0 0 {name=p50177 lab=_49794_/X }
C {devices/lab_pin.sym} 50500 -7350 0 1 {name=p50178 lab=_49893_/C }
C {sky130_stdcells/buf_2.sym} 50460 -7350 0 0 {name=X_49876_ }
C {devices/lab_pin.sym} 50420 -7230 0 0 {name=p50179 lab=clkbuf_8_160_0_CLK/X }
C {devices/lab_pin.sym} 50500 -7230 0 1 {name=p50180 lab=clkbuf_9_320_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 50460 -7230 0 0 {name=Xclkbuf_9_320_0_CLK }
C {devices/lab_pin.sym} 50420 -7110 0 0 {name=p50181 lab=_47918_/A }
C {devices/lab_pin.sym} 50500 -7110 0 1 {name=p50182 lab=_48853_/A }
C {sky130_stdcells/buf_2.sym} 50460 -7110 0 0 {name=X_48827_ }
C {devices/lab_pin.sym} 50380 -7010 0 0 {name=p50183 lab=_67656_/X }
C {devices/lab_pin.sym} 50380 -6970 0 0 {name=p50184 lab=_67660_/X }
C {devices/lab_pin.sym} 50380 -6930 0 0 {name=p50185 lab=_67637_/X }
C {devices/lab_pin.sym} 50540 -6970 0 1 {name=p50186 lab=_67661_/Y }
C {sky130_stdcells/a21oi_4.sym} 50460 -6970 0 0 {name=X_67661_ }
C {devices/lab_pin.sym} 50380 -6850 0 0 {name=p50187 lab=_65221_/C }
C {devices/lab_pin.sym} 50380 -6810 0 0 {name=p50188 lab=_72394_/Y }
C {devices/lab_pin.sym} 50380 -6770 0 0 {name=p50189 lab=_79646_/Y }
C {devices/lab_pin.sym} 50540 -6810 0 1 {name=p50190 lab=_79647_/X }
C {sky130_stdcells/o21a_4.sym} 50460 -6810 0 0 {name=X_79647_ }
C {devices/lab_pin.sym} 50420 -6670 0 0 {name=p50191 lab=clkbuf_8_219_0_CLK/A }
C {devices/lab_pin.sym} 50500 -6670 0 1 {name=p50192 lab=clkbuf_9_438_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 50460 -6670 0 0 {name=Xclkbuf_8_219_0_CLK }
C {devices/lab_pin.sym} 50380 -6580 0 0 {name=p50193 lab=_64817_/X }
C {devices/lab_pin.sym} 50380 -6540 0 0 {name=p50194 lab=_86135_/Q }
C {devices/lab_pin.sym} 50380 -6500 0 0 {name=p50195 lab=_64776_/X }
C {devices/lab_pin.sym} 50380 -6460 0 0 {name=p50196 lab=_64872_/X }
C {devices/lab_pin.sym} 50540 -6520 0 1 {name=p50197 lab=_64873_/X }
C {sky130_stdcells/a211o_4.sym} 50460 -6520 0 0 {name=X_64873_ }
C {devices/lab_pin.sym} 50420 -6370 0 0 {name=p50198 lab=_76847_/Y }
C {devices/lab_pin.sym} 50500 -6370 0 1 {name=p50199 lab=_81368_/D }
C {sky130_stdcells/inv_2.sym} 50460 -6370 0 0 {name=X_76859_ }
C {devices/lab_pin.sym} 50420 -6250 0 0 {name=p50200 lab=clkbuf_9_107_0_CLK/X }
C {devices/lab_pin.sym} 50500 -6250 0 1 {name=p50201 lab=_84623_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 50460 -6250 0 0 {name=Xclkbuf_10_214_0_CLK }
C {devices/lab_pin.sym} 50380 -6150 0 0 {name=p50202 lab=_69395_/X }
C {devices/lab_pin.sym} 50380 -6110 0 0 {name=p50203 lab=_69398_/X }
C {devices/lab_pin.sym} 50380 -6070 0 0 {name=p50204 lab=_69399_/X }
C {devices/lab_pin.sym} 50540 -6110 0 1 {name=p50205 lab=_69400_/X }
C {sky130_stdcells/a21o_4.sym} 50460 -6110 0 0 {name=X_69400_ }
C {devices/lab_pin.sym} 50380 -6000 0 0 {name=p50206 lab=_66526_/X }
C {devices/lab_pin.sym} 50380 -5960 0 0 {name=p50207 lab=_66597_/Y }
C {devices/lab_pin.sym} 50380 -5920 0 0 {name=p50208 lab=_59782_/X }
C {devices/lab_pin.sym} 50380 -5880 0 0 {name=p50209 lab=_66611_/Y }
C {devices/lab_pin.sym} 50540 -5940 0 1 {name=p50210 lab=_66612_/X }
C {sky130_stdcells/a211o_4.sym} 50460 -5940 0 0 {name=X_66612_ }
C {devices/lab_pin.sym} 50420 -5790 0 0 {name=p50211 lab=_60882_/X }
C {devices/lab_pin.sym} 50500 -5790 0 1 {name=p50212 lab=_63860_/C }
C {sky130_stdcells/buf_2.sym} 50460 -5790 0 0 {name=X_63824_ }
C {devices/lab_pin.sym} 50420 -5670 0 0 {name=p50213 lab=clkbuf_9_422_0_CLK/X }
C {devices/lab_pin.sym} 50500 -5670 0 1 {name=p50214 lab=_82748_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 50460 -5670 0 0 {name=Xclkbuf_10_844_0_CLK }
C {devices/lab_pin.sym} 50380 -5570 0 0 {name=p50215 lab=_73012_/B }
C {devices/lab_pin.sym} 50380 -5530 0 0 {name=p50216 lab=_48754_/X }
C {devices/lab_pin.sym} 50380 -5490 0 0 {name=p50217 lab=_48757_/Y }
C {devices/lab_pin.sym} 50540 -5530 0 1 {name=p50218 lab=_48758_/Y }
C {sky130_stdcells/o21ai_4.sym} 50460 -5530 0 0 {name=X_48758_ }
C {devices/lab_pin.sym} 50400 -5400 0 0 {name=p50219 lab=_67569_/X }
C {devices/lab_pin.sym} 50400 -5360 0 0 {name=p50220 lab=_87720_/Q }
C {devices/lab_pin.sym} 50520 -5380 0 1 {name=p50221 lab=_67592_/X }
C {sky130_stdcells/and2_4.sym} 50460 -5380 0 0 {name=X_67592_ }
C {devices/lab_pin.sym} 50400 -5260 0 0 {name=p50222 lab=_79575_/Y }
C {devices/lab_pin.sym} 50400 -5220 0 0 {name=p50223 lab=_79578_/B }
C {devices/lab_pin.sym} 50520 -5240 0 1 {name=p50224 lab=_79580_/A }
C {sky130_stdcells/nand2_4.sym} 50460 -5240 0 0 {name=X_79578_ }
C {devices/lab_pin.sym} 50380 -5140 0 0 {name=p50225 lab=_88037_/Q }
C {devices/lab_pin.sym} 50380 -5100 0 0 {name=p50226 lab=_69121_/X }
C {devices/lab_pin.sym} 50380 -5060 0 0 {name=p50227 lab=_69232_/X }
C {devices/lab_pin.sym} 50380 -5020 0 0 {name=p50228 lab=_69330_/X }
C {devices/lab_pin.sym} 50540 -5080 0 1 {name=p50229 lab=_69331_/X }
C {sky130_stdcells/a211o_4.sym} 50460 -5080 0 0 {name=X_69331_ }
C {devices/lab_pin.sym} 50420 -4930 0 0 {name=p50230 lab=_81230_/Q }
C {devices/lab_pin.sym} 50500 -4930 0 1 {name=p50231 lab=_47710_/A }
C {sky130_stdcells/inv_2.sym} 50460 -4930 0 0 {name=X_47709_ }
C {devices/lab_pin.sym} 50420 -4810 0 0 {name=p50232 lab=_68614_/A }
C {devices/lab_pin.sym} 50500 -4810 0 1 {name=p50233 lab=_68999_/A }
C {sky130_stdcells/buf_2.sym} 50460 -4810 0 0 {name=X_66543_ }
C {devices/lab_pin.sym} 50400 -4700 0 0 {name=p50234 lab=_78521_/X }
C {devices/lab_pin.sym} 50400 -4660 0 0 {name=p50235 lab=_78528_/X }
C {devices/lab_pin.sym} 50520 -4680 0 1 {name=p50236 lab=_78529_/Y }
C {sky130_stdcells/xnor2_4.sym} 50460 -4680 0 0 {name=X_78529_ }
C {devices/lab_pin.sym} 50420 -4550 0 0 {name=p50237 lab=_60879_/D }
C {devices/lab_pin.sym} 50500 -4550 0 1 {name=p50238 lab=_64045_/A }
C {sky130_stdcells/buf_2.sym} 50460 -4550 0 0 {name=X_63755_ }
C {devices/lab_pin.sym} 50420 -4430 0 0 {name=p50239 lab=clkbuf_9_335_0_CLK/A }
C {devices/lab_pin.sym} 50500 -4430 0 1 {name=p50240 lab=clkbuf_9_335_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 50460 -4430 0 0 {name=Xclkbuf_9_335_0_CLK }
C {devices/lab_pin.sym} 50420 -4310 0 0 {name=p50241 lab=_60967_/A }
C {devices/lab_pin.sym} 50500 -4310 0 1 {name=p50242 lab=_60967_/X }
C {sky130_stdcells/buf_2.sym} 50460 -4310 0 0 {name=X_60967_ }
C {devices/lab_pin.sym} 50420 -4190 0 0 {name=p50243 lab=_74505_/A }
C {devices/lab_pin.sym} 50500 -4190 0 1 {name=p50244 lab=_48691_/A }
C {sky130_stdcells/buf_2.sym} 50460 -4190 0 0 {name=X_48689_ }
C {devices/lab_pin.sym} 50380 -4090 0 0 {name=p50245 lab=_50717_/Y }
C {devices/lab_pin.sym} 50380 -4050 0 0 {name=p50246 lab=_50699_/X }
C {devices/lab_pin.sym} 50380 -4010 0 0 {name=p50247 lab=_50719_/Y }
C {devices/lab_pin.sym} 50540 -4050 0 1 {name=p50248 lab=_86147_/D }
C {sky130_stdcells/a21boi_4.sym} 50460 -4050 0 0 {name=X_50720_ }
C {devices/lab_pin.sym} 50400 -3930 0 0 {name=p50249 lab=_62673_/A }
C {devices/lab_pin.sym} 50400 -3890 0 0 {name=p50250 lab=_62673_/B }
C {devices/lab_pin.sym} 50400 -3850 0 0 {name=p50251 lab=_84389_/Q }
C {devices/lab_pin.sym} 50520 -3890 0 1 {name=p50252 lab=_62706_/Y }
C {sky130_stdcells/nor3_4.sym} 50460 -3890 0 0 {name=X_62706_ }
C {devices/lab_pin.sym} 50370 -3750 0 0 {name=p50253 lab=_83940_/CLK }
C {devices/lab_pin.sym} 50370 -3730 0 0 {name=p50254 lab=_81540_/D }
C {devices/lab_pin.sym} 50550 -3750 0 1 {name=p50255 lab=_81528_/D }
C {sky130_stdcells/dfxtp_4.sym} 50460 -3740 0 0 {name=X_81540_ }
C {devices/lab_pin.sym} 50400 -3620 0 0 {name=p50256 lab=_69179_/A }
C {devices/lab_pin.sym} 50400 -3580 0 0 {name=p50257 lab=_69262_/B }
C {devices/lab_pin.sym} 50520 -3600 0 1 {name=p50258 lab=_69262_/X }
C {sky130_stdcells/and2_4.sym} 50460 -3600 0 0 {name=X_69262_ }
C {devices/lab_pin.sym} 50380 -3490 0 0 {name=p50259 lab=_66472_/Y }
C {devices/lab_pin.sym} 50380 -3450 0 0 {name=p50260 lab=_66449_/X }
C {devices/lab_pin.sym} 50380 -3410 0 0 {name=p50261 lab=_66473_/X }
C {devices/lab_pin.sym} 50540 -3450 0 1 {name=p50262 lab=_84116_/D }
C {sky130_stdcells/a21o_4.sym} 50460 -3450 0 0 {name=X_66474_ }
C {devices/lab_pin.sym} 50420 -3310 0 0 {name=p50263 lab=clkbuf_9_114_0_CLK/X }
C {devices/lab_pin.sym} 50500 -3310 0 1 {name=p50264 lab=_84438_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 50460 -3310 0 0 {name=Xclkbuf_10_229_0_CLK }
C {devices/lab_pin.sym} 50380 -3220 0 0 {name=p50265 lab=_61663_/B }
C {devices/lab_pin.sym} 50380 -3180 0 0 {name=p50266 lab=_63609_/X }
C {devices/lab_pin.sym} 50380 -3140 0 0 {name=p50267 lab=_63684_/X }
C {devices/lab_pin.sym} 50380 -3100 0 0 {name=p50268 lab=_63685_/X }
C {devices/lab_pin.sym} 50540 -3160 0 1 {name=p50269 lab=_63686_/X }
C {sky130_stdcells/a211o_4.sym} 50460 -3160 0 0 {name=X_63686_ }
C {devices/lab_pin.sym} 50420 -3010 0 0 {name=p50270 lab=_60341_/A }
C {devices/lab_pin.sym} 50500 -3010 0 1 {name=p50271 lab=_60898_/X }
C {sky130_stdcells/buf_2.sym} 50460 -3010 0 0 {name=X_60898_ }
C {devices/lab_pin.sym} 50380 -2910 0 0 {name=p50272 lab=_67323_/X }
C {devices/lab_pin.sym} 50380 -2870 0 0 {name=p50273 lab=_67325_/X }
C {devices/lab_pin.sym} 50380 -2830 0 0 {name=p50274 lab=_68209_/X }
C {devices/lab_pin.sym} 50540 -2870 0 1 {name=p50275 lab=_68213_/Y }
C {sky130_stdcells/a21oi_4.sym} 50460 -2870 0 0 {name=X_68213_ }
C {devices/lab_pin.sym} 50420 -2730 0 0 {name=p50276 lab=clkbuf_9_429_0_CLK/X }
C {devices/lab_pin.sym} 50500 -2730 0 1 {name=p50277 lab=_86122_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 50460 -2730 0 0 {name=Xclkbuf_10_859_0_CLK }
C {devices/lab_pin.sym} 50400 -2620 0 0 {name=p50278 lab=_65403_/A }
C {devices/lab_pin.sym} 50400 -2580 0 0 {name=p50279 lab=_65425_/B }
C {devices/lab_pin.sym} 50520 -2600 0 1 {name=p50280 lab=_65425_/X }
C {sky130_stdcells/and2_4.sym} 50460 -2600 0 0 {name=X_65425_ }
C {devices/lab_pin.sym} 50420 -2470 0 0 {name=p50281 lab=_50496_/A }
C {devices/lab_pin.sym} 50500 -2470 0 1 {name=p50282 lab=_50651_/X }
C {sky130_stdcells/buf_2.sym} 50460 -2470 0 0 {name=X_50651_ }
C {devices/lab_pin.sym} 50380 -2370 0 0 {name=p50283 lab=_62635_/Y }
C {devices/lab_pin.sym} 50380 -2330 0 0 {name=p50284 lab=_62593_/X }
C {devices/lab_pin.sym} 50380 -2290 0 0 {name=p50285 lab=_62636_/Y }
C {devices/lab_pin.sym} 50540 -2330 0 1 {name=p50286 lab=_84394_/D }
C {sky130_stdcells/a21oi_4.sym} 50460 -2330 0 0 {name=X_62637_ }
C {devices/lab_pin.sym} 50370 -2190 0 0 {name=p50287 lab=_81482_/CLK }
C {devices/lab_pin.sym} 50370 -2170 0 0 {name=p50288 lab=_81471_/D }
C {devices/lab_pin.sym} 50550 -2190 0 1 {name=p50289 lab=_81471_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -2180 0 0 {name=X_81471_ }
C {devices/lab_pin.sym} 50400 -2060 0 0 {name=p50290 lab=_69179_/A }
C {devices/lab_pin.sym} 50400 -2020 0 0 {name=p50291 lab=_87279_/Q }
C {devices/lab_pin.sym} 50520 -2040 0 1 {name=p50292 lab=_69193_/X }
C {sky130_stdcells/and2_4.sym} 50460 -2040 0 0 {name=X_69193_ }
C {devices/lab_pin.sym} 50370 -1910 0 0 {name=p50293 lab=_83231_/CLK }
C {devices/lab_pin.sym} 50370 -1890 0 0 {name=p50294 lab=_72629_/Y }
C {devices/lab_pin.sym} 50550 -1910 0 1 {name=p50295 lab=_79160_/B }
C {sky130_stdcells/dfxtp_4.sym} 50460 -1900 0 0 {name=X_83210_ }
C {devices/lab_pin.sym} 50400 -1780 0 0 {name=p50296 lab=_80422_/A }
C {devices/lab_pin.sym} 50400 -1740 0 0 {name=p50297 lab=_80422_/B }
C {devices/lab_pin.sym} 50520 -1760 0 1 {name=p50298 lab=_80423_/B }
C {sky130_stdcells/xor2_4.sym} 50460 -1760 0 0 {name=X_80422_ }
C {devices/lab_pin.sym} 50420 -1630 0 0 {name=p50299 lab=_67495_/X }
C {devices/lab_pin.sym} 50500 -1630 0 1 {name=p50300 lab=_68144_/X }
C {sky130_stdcells/buf_2.sym} 50460 -1630 0 0 {name=X_68144_ }
C {devices/lab_pin.sym} 50380 -1530 0 0 {name=p50301 lab=_85646_/Q }
C {devices/lab_pin.sym} 50380 -1490 0 0 {name=p50302 lab=_53351_/X }
C {devices/lab_pin.sym} 50380 -1450 0 0 {name=p50303 lab=_53369_/Y }
C {devices/lab_pin.sym} 50540 -1490 0 1 {name=p50304 lab=_53370_/Y }
C {sky130_stdcells/o21ai_4.sym} 50460 -1490 0 0 {name=X_53370_ }
C {devices/lab_pin.sym} 50380 -1370 0 0 {name=p50305 lab=_65353_/X }
C {devices/lab_pin.sym} 50380 -1330 0 0 {name=p50306 lab=_65355_/X }
C {devices/lab_pin.sym} 50380 -1290 0 0 {name=p50307 lab=_65277_/X }
C {devices/lab_pin.sym} 50540 -1330 0 1 {name=p50308 lab=_65359_/A }
C {sky130_stdcells/a21o_4.sym} 50460 -1330 0 0 {name=X_65356_ }
C {devices/lab_pin.sym} 50370 -1190 0 0 {name=p50309 lab=_83520_/CLK }
C {devices/lab_pin.sym} 50370 -1170 0 0 {name=p50310 lab=_65606_/X }
C {devices/lab_pin.sym} 50550 -1190 0 1 {name=p50311 lab=_84190_/Q }
C {sky130_stdcells/dfxtp_4.sym} 50460 -1180 0 0 {name=X_84190_ }
C {devices/lab_pin.sym} 50400 -1060 0 0 {name=p50312 lab=_50607_/A }
C {devices/lab_pin.sym} 50400 -1020 0 0 {name=p50313 lab=_48922_/B }
C {devices/lab_pin.sym} 50520 -1040 0 1 {name=p50314 lab=_50582_/Y }
C {sky130_stdcells/nand2_4.sym} 50460 -1040 0 0 {name=X_50582_ }
C {devices/lab_pin.sym} 50400 -940 0 0 {name=p50315 lab=_61629_/B }
C {devices/lab_pin.sym} 50400 -900 0 0 {name=p50316 lab=_62504_/X }
C {devices/lab_pin.sym} 50400 -860 0 0 {name=p50317 lab=_62534_/X }
C {devices/lab_pin.sym} 50400 -820 0 0 {name=p50318 lab=_62475_/X }
C {devices/lab_pin.sym} 50520 -880 0 1 {name=p50319 lab=_62569_/D }
C {sky130_stdcells/nand4_4.sym} 50460 -880 0 0 {name=X_62568_ }
C {devices/lab_pin.sym} 50380 -750 0 0 {name=p50320 lab=_52318_/Y }
C {devices/lab_pin.sym} 50380 -710 0 0 {name=p50321 lab=_52314_/X }
C {devices/lab_pin.sym} 50380 -670 0 0 {name=p50322 lab=_52320_/X }
C {devices/lab_pin.sym} 50540 -710 0 1 {name=p50323 lab=_52321_/Y }
C {sky130_stdcells/a21oi_4.sym} 50460 -710 0 0 {name=X_52321_ }
C {devices/lab_pin.sym} 51320 -42170 0 0 {name=p50324 lab=_64295_/A }
C {devices/lab_pin.sym} 51320 -42130 0 0 {name=p50325 lab=_64307_/B }
C {devices/lab_pin.sym} 51320 -42090 0 0 {name=p50326 lab=_64307_/C }
C {devices/lab_pin.sym} 51440 -42130 0 1 {name=p50327 lab=_64307_/X }
C {sky130_stdcells/and3_4.sym} 51380 -42130 0 0 {name=X_64307_ }
C {devices/lab_pin.sym} 51290 -41990 0 0 {name=p50328 lab=_83141_/CLK }
C {devices/lab_pin.sym} 51290 -41970 0 0 {name=p50329 lab=_73673_/Y }
C {devices/lab_pin.sym} 51470 -41990 0 1 {name=p50330 lab=_70123_/A }
C {sky130_stdcells/dfxtp_4.sym} 51380 -41980 0 0 {name=X_83141_ }
C {devices/lab_pin.sym} 51320 -41860 0 0 {name=p50331 lab=_80353_/A }
C {devices/lab_pin.sym} 51320 -41820 0 0 {name=p50332 lab=_80353_/B }
C {devices/lab_pin.sym} 51440 -41840 0 1 {name=p50333 lab=_80353_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -41840 0 0 {name=X_80353_ }
C {devices/lab_pin.sym} 51300 -41730 0 0 {name=p50334 lab=_61516_/X }
C {devices/lab_pin.sym} 51300 -41690 0 0 {name=p50335 lab=_61517_/X }
C {devices/lab_pin.sym} 51300 -41650 0 0 {name=p50336 lab=_61518_/Y }
C {devices/lab_pin.sym} 51460 -41690 0 1 {name=p50337 lab=_61519_/Y }
C {sky130_stdcells/a21oi_4.sym} 51380 -41690 0 0 {name=X_61519_ }
C {devices/lab_pin.sym} 51320 -41560 0 0 {name=p50338 lab=_68444_/A }
C {devices/lab_pin.sym} 51320 -41520 0 0 {name=p50339 lab=_88212_/Q }
C {devices/lab_pin.sym} 51440 -41540 0 1 {name=p50340 lab=_68075_/X }
C {sky130_stdcells/and2_4.sym} 51380 -41540 0 0 {name=X_68075_ }
C {devices/lab_pin.sym} 51340 -41410 0 0 {name=p50341 lab=_64807_/A }
C {devices/lab_pin.sym} 51420 -41410 0 1 {name=p50342 lab=_65287_/X }
C {sky130_stdcells/buf_2.sym} 51380 -41410 0 0 {name=X_65287_ }
C {devices/lab_pin.sym} 51300 -41310 0 0 {name=p50343 lab=_62497_/Y }
C {devices/lab_pin.sym} 51300 -41270 0 0 {name=p50344 lab=_62467_/X }
C {devices/lab_pin.sym} 51300 -41230 0 0 {name=p50345 lab=_62498_/Y }
C {devices/lab_pin.sym} 51460 -41270 0 1 {name=p50346 lab=_84406_/D }
C {sky130_stdcells/a21oi_4.sym} 51380 -41270 0 0 {name=X_62499_ }
C {devices/lab_pin.sym} 51300 -41150 0 0 {name=p50347 lab=_55038_/Y }
C {devices/lab_pin.sym} 51300 -41110 0 0 {name=p50348 lab=_55024_/X }
C {devices/lab_pin.sym} 51300 -41070 0 0 {name=p50349 lab=_55039_/X }
C {devices/lab_pin.sym} 51460 -41110 0 1 {name=p50350 lab=_85330_/D }
C {sky130_stdcells/a21oi_4.sym} 51380 -41110 0 0 {name=X_55040_ }
C {devices/lab_pin.sym} 51340 -40970 0 0 {name=p50351 lab=_67025_/X }
C {devices/lab_pin.sym} 51420 -40970 0 1 {name=p50352 lab=_67026_/X }
C {sky130_stdcells/buf_2.sym} 51380 -40970 0 0 {name=X_67026_ }
C {devices/lab_pin.sym} 51340 -40850 0 0 {name=p50353 lab=_52198_/A }
C {devices/lab_pin.sym} 51420 -40850 0 1 {name=p50354 lab=_52267_/B }
C {sky130_stdcells/buf_2.sym} 51380 -40850 0 0 {name=X_52252_ }
C {devices/lab_pin.sym} 51300 -40750 0 0 {name=p50355 lab=_59456_/Y }
C {devices/lab_pin.sym} 51300 -40710 0 0 {name=p50356 lab=_64226_/X }
C {devices/lab_pin.sym} 51300 -40670 0 0 {name=p50357 lab=_64237_/Y }
C {devices/lab_pin.sym} 51460 -40710 0 1 {name=p50358 lab=_64238_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -40710 0 0 {name=X_64238_ }
C {devices/lab_pin.sym} 51290 -40570 0 0 {name=p50359 lab=_83584_/CLK }
C {devices/lab_pin.sym} 51290 -40550 0 0 {name=p50360 lab=_74411_/Y }
C {devices/lab_pin.sym} 51470 -40570 0 1 {name=p50361 lab=_83072_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -40560 0 0 {name=X_83072_ }
C {devices/lab_pin.sym} 51320 -40440 0 0 {name=p50362 lab=_80280_/B }
C {devices/lab_pin.sym} 51320 -40400 0 0 {name=p50363 lab=_80280_/C }
C {devices/lab_pin.sym} 51440 -40420 0 1 {name=p50364 lab=_80284_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -40420 0 0 {name=X_80284_ }
C {devices/lab_pin.sym} 51320 -40320 0 0 {name=p50365 lab=_51191_/X }
C {devices/lab_pin.sym} 51320 -40280 0 0 {name=p50366 lab=_51203_/B }
C {devices/lab_pin.sym} 51320 -40240 0 0 {name=p50367 lab=_51197_/C }
C {devices/lab_pin.sym} 51320 -40200 0 0 {name=p50368 lab=_52895_/D }
C {devices/lab_pin.sym} 51440 -40260 0 1 {name=p50369 lab=_51203_/X }
C {sky130_stdcells/and4_4.sym} 51380 -40260 0 0 {name=X_51203_ }
C {devices/lab_pin.sym} 51290 -40110 0 0 {name=p50370 lab=_86900_/CLK }
C {devices/lab_pin.sym} 51290 -40090 0 0 {name=p50371 lab=_45086_/Y }
C {devices/lab_pin.sym} 51470 -40110 0 1 {name=p50372 lab=_64343_/B }
C {sky130_stdcells/dfxtp_4.sym} 51380 -40100 0 0 {name=X_86900_ }
C {devices/lab_pin.sym} 51290 -39970 0 0 {name=p50373 lab=_81990_/CLK }
C {devices/lab_pin.sym} 51290 -39950 0 0 {name=p50374 lab=_77774_/B }
C {devices/lab_pin.sym} 51470 -39970 0 1 {name=p50375 lab=_81991_/D }
C {sky130_stdcells/dfxtp_4.sym} 51380 -39960 0 0 {name=X_82023_ }
C {devices/lab_pin.sym} 51300 -39850 0 0 {name=p50376 lab=_52181_/Y }
C {devices/lab_pin.sym} 51300 -39810 0 0 {name=p50377 lab=_52170_/X }
C {devices/lab_pin.sym} 51300 -39770 0 0 {name=p50378 lab=_52182_/X }
C {devices/lab_pin.sym} 51460 -39810 0 1 {name=p50379 lab=_85873_/D }
C {sky130_stdcells/a21oi_4.sym} 51380 -39810 0 0 {name=X_52183_ }
C {devices/lab_pin.sym} 51320 -39700 0 0 {name=p50380 lab=_58207_/A }
C {devices/lab_pin.sym} 51320 -39660 0 0 {name=p50381 lab=_64192_/C }
C {devices/lab_pin.sym} 51320 -39620 0 0 {name=p50382 lab=_64180_/C }
C {devices/lab_pin.sym} 51320 -39580 0 0 {name=p50383 lab=_64192_/D }
C {devices/lab_pin.sym} 51440 -39640 0 1 {name=p50384 lab=_64169_/Y }
C {sky130_stdcells/nand4_4.sym} 51380 -39640 0 0 {name=X_64169_ }
C {devices/lab_pin.sym} 51290 -39490 0 0 {name=p50385 lab=_87883_/CLK }
C {devices/lab_pin.sym} 51290 -39470 0 0 {name=p50386 lab=_42403_/Y }
C {devices/lab_pin.sym} 51470 -39490 0 1 {name=p50387 lab=_87880_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -39480 0 0 {name=X_87880_ }
C {devices/lab_pin.sym} 51320 -39360 0 0 {name=p50388 lab=_51130_/A }
C {devices/lab_pin.sym} 51320 -39320 0 0 {name=p50389 lab=_52829_/B }
C {devices/lab_pin.sym} 51440 -39340 0 1 {name=p50390 lab=_51134_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -39340 0 0 {name=X_51134_ }
C {devices/lab_pin.sym} 51290 -39210 0 0 {name=p50391 lab=_87990_/CLK }
C {devices/lab_pin.sym} 51290 -39190 0 0 {name=p50392 lab=_45977_/X }
C {devices/lab_pin.sym} 51470 -39210 0 1 {name=p50393 lab=_86831_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -39200 0 0 {name=X_86831_ }
C {devices/lab_pin.sym} 51340 -39070 0 0 {name=p50394 lab=_56985_/D }
C {devices/lab_pin.sym} 51420 -39070 0 1 {name=p50395 lab=_56991_/Y }
C {sky130_stdcells/inv_2.sym} 51380 -39070 0 0 {name=X_56991_ }
C {devices/lab_pin.sym} 51320 -38960 0 0 {name=p50396 lab=_69021_/A }
C {devices/lab_pin.sym} 51320 -38920 0 0 {name=p50397 lab=_68977_/B }
C {devices/lab_pin.sym} 51440 -38940 0 1 {name=p50398 lab=_68977_/X }
C {sky130_stdcells/and2_4.sym} 51380 -38940 0 0 {name=X_68977_ }
C {devices/lab_pin.sym} 51340 -38810 0 0 {name=p50399 lab=_58605_/A }
C {devices/lab_pin.sym} 51420 -38810 0 1 {name=p50400 lab=_58730_/X }
C {sky130_stdcells/buf_2.sym} 51380 -38810 0 0 {name=X_58730_ }
C {devices/lab_pin.sym} 51340 -38690 0 0 {name=p50401 lab=_51039_/A }
C {devices/lab_pin.sym} 51420 -38690 0 1 {name=p50402 lab=_51065_/X }
C {sky130_stdcells/buf_2.sym} 51380 -38690 0 0 {name=X_51065_ }
C {devices/lab_pin.sym} 51300 -38590 0 0 {name=p50403 lab=_55939_/X }
C {devices/lab_pin.sym} 51300 -38550 0 0 {name=p50404 lab=_55941_/X }
C {devices/lab_pin.sym} 51300 -38510 0 0 {name=p50405 lab=_55615_/A }
C {devices/lab_pin.sym} 51460 -38550 0 1 {name=p50406 lab=_55945_/A }
C {sky130_stdcells/a21o_4.sym} 51380 -38550 0 0 {name=X_55942_ }
C {devices/lab_pin.sym} 51300 -38440 0 0 {name=p50407 lab=_87898_/Q }
C {devices/lab_pin.sym} 51300 -38400 0 0 {name=p50408 lab=_67831_/X }
C {devices/lab_pin.sym} 51300 -38360 0 0 {name=p50409 lab=_67879_/X }
C {devices/lab_pin.sym} 51300 -38320 0 0 {name=p50410 lab=_67927_/X }
C {devices/lab_pin.sym} 51460 -38380 0 1 {name=p50411 lab=_67928_/X }
C {sky130_stdcells/a211o_4.sym} 51380 -38380 0 0 {name=X_67928_ }
C {devices/lab_pin.sym} 51290 -38230 0 0 {name=p50412 lab=_80672_/CLK }
C {devices/lab_pin.sym} 51290 -38210 0 0 {name=p50413 lab=_86762_/D }
C {devices/lab_pin.sym} 51470 -38230 0 1 {name=p50414 lab=_86762_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -38220 0 0 {name=X_86762_ }
C {devices/lab_pin.sym} 51290 -38090 0 0 {name=p50415 lab=_83974_/CLK }
C {devices/lab_pin.sym} 51290 -38070 0 0 {name=p50416 lab=_83974_/D }
C {devices/lab_pin.sym} 51470 -38090 0 1 {name=p50417 lab=_83974_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -38080 0 0 {name=X_83974_ }
C {devices/lab_pin.sym} 51320 -37980 0 0 {name=p50418 lab=_50025_/A }
C {devices/lab_pin.sym} 51320 -37940 0 0 {name=p50419 lab=_49994_/X }
C {devices/lab_pin.sym} 51320 -37900 0 0 {name=p50420 lab=_50025_/C }
C {devices/lab_pin.sym} 51320 -37860 0 0 {name=p50421 lab=_53230_/D }
C {devices/lab_pin.sym} 51440 -37920 0 1 {name=p50422 lab=_50016_/X }
C {sky130_stdcells/and4_4.sym} 51380 -37920 0 0 {name=X_50016_ }
C {devices/lab_pin.sym} 51290 -37770 0 0 {name=p50423 lab=_84766_/CLK }
C {devices/lab_pin.sym} 51290 -37750 0 0 {name=p50424 lab=_53016_/Y }
C {devices/lab_pin.sym} 51470 -37770 0 1 {name=p50425 lab=_85713_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -37760 0 0 {name=X_85713_ }
C {devices/lab_pin.sym} 51300 -37670 0 0 {name=p50426 lab=_58631_/X }
C {devices/lab_pin.sym} 51300 -37630 0 0 {name=p50427 lab=_58659_/Y }
C {devices/lab_pin.sym} 51300 -37590 0 0 {name=p50428 lab=_58660_/Y }
C {devices/lab_pin.sym} 51300 -37550 0 0 {name=p50429 lab=_58650_/X }
C {devices/lab_pin.sym} 51300 -37510 0 0 {name=p50430 lab=_58636_/X }
C {devices/lab_pin.sym} 51460 -37590 0 1 {name=p50431 lab=_58661_/X }
C {sky130_stdcells/o32a_4.sym} 51380 -37590 0 0 {name=X_58661_ }
C {devices/lab_pin.sym} 51290 -37430 0 0 {name=p50432 lab=_82925_/CLK }
C {devices/lab_pin.sym} 51290 -37410 0 0 {name=p50433 lab=_78211_/X }
C {devices/lab_pin.sym} 51470 -37430 0 1 {name=p50434 lab=_82925_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -37420 0 0 {name=X_82925_ }
C {devices/lab_pin.sym} 51340 -37290 0 0 {name=p50435 lab=_55873_/A }
C {devices/lab_pin.sym} 51420 -37290 0 1 {name=p50436 lab=_56073_/A }
C {sky130_stdcells/buf_2.sym} 51380 -37290 0 0 {name=X_55873_ }
C {devices/lab_pin.sym} 51300 -37190 0 0 {name=p50437 lab=_67854_/X }
C {devices/lab_pin.sym} 51300 -37150 0 0 {name=p50438 lab=_67857_/X }
C {devices/lab_pin.sym} 51300 -37110 0 0 {name=p50439 lab=_67858_/X }
C {devices/lab_pin.sym} 51460 -37150 0 1 {name=p50440 lab=_67859_/X }
C {sky130_stdcells/a21o_4.sym} 51380 -37150 0 0 {name=X_67859_ }
C {devices/lab_pin.sym} 51290 -37010 0 0 {name=p50441 lab=_86695_/CLK }
C {devices/lab_pin.sym} 51290 -36990 0 0 {name=p50442 lab=_86693_/D }
C {devices/lab_pin.sym} 51470 -37010 0 1 {name=p50443 lab=_58921_/A }
C {sky130_stdcells/dfxtp_4.sym} 51380 -37000 0 0 {name=X_86693_ }
C {devices/lab_pin.sym} 51300 -36890 0 0 {name=p50444 lab=_84969_/Q }
C {devices/lab_pin.sym} 51300 -36850 0 0 {name=p50445 lab=_57603_/X }
C {devices/lab_pin.sym} 51300 -36810 0 0 {name=p50446 lab=_57611_/Y }
C {devices/lab_pin.sym} 51460 -36850 0 1 {name=p50447 lab=_57612_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -36850 0 0 {name=X_57612_ }
C {devices/lab_pin.sym} 51300 -36730 0 0 {name=p50448 lab=_85371_/Q }
C {devices/lab_pin.sym} 51300 -36690 0 0 {name=p50449 lab=_54812_/X }
C {devices/lab_pin.sym} 51300 -36650 0 0 {name=p50450 lab=_54823_/Y }
C {devices/lab_pin.sym} 51460 -36690 0 1 {name=p50451 lab=_54824_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -36690 0 0 {name=X_54824_ }
C {devices/lab_pin.sym} 51290 -36550 0 0 {name=p50452 lab=_85738_/CLK }
C {devices/lab_pin.sym} 51290 -36530 0 0 {name=p50453 lab=_53385_/Y }
C {devices/lab_pin.sym} 51470 -36550 0 1 {name=p50454 lab=_85644_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -36540 0 0 {name=X_85644_ }
C {devices/lab_pin.sym} 51300 -36430 0 0 {name=p50455 lab=_51807_/B }
C {devices/lab_pin.sym} 51300 -36390 0 0 {name=p50456 lab=_70855_/X }
C {devices/lab_pin.sym} 51300 -36350 0 0 {name=p50457 lab=_70869_/Y }
C {devices/lab_pin.sym} 51460 -36390 0 1 {name=p50458 lab=_70870_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -36390 0 0 {name=X_70870_ }
C {devices/lab_pin.sym} 51300 -36270 0 0 {name=p50459 lab=_58100_/X }
C {devices/lab_pin.sym} 51300 -36230 0 0 {name=p50460 lab=_85951_/Q }
C {devices/lab_pin.sym} 51300 -36190 0 0 {name=p50461 lab=_58568_/X }
C {devices/lab_pin.sym} 51460 -36230 0 1 {name=p50462 lab=_58592_/X }
C {sky130_stdcells/o21a_4.sym} 51380 -36230 0 0 {name=X_58592_ }
C {devices/lab_pin.sym} 51290 -36090 0 0 {name=p50463 lab=_82855_/CLK }
C {devices/lab_pin.sym} 51290 -36070 0 0 {name=p50464 lab=_78125_/B }
C {devices/lab_pin.sym} 51470 -36090 0 1 {name=p50465 lab=_40897_/A }
C {sky130_stdcells/dfxtp_4.sym} 51380 -36080 0 0 {name=X_82856_ }
C {devices/lab_pin.sym} 51340 -35950 0 0 {name=p50466 lab=_46399_/A }
C {devices/lab_pin.sym} 51420 -35950 0 1 {name=p50467 lab=_57543_/X }
C {sky130_stdcells/buf_2.sym} 51380 -35950 0 0 {name=X_57543_ }
C {devices/lab_pin.sym} 51290 -35830 0 0 {name=p50468 lab=_81807_/CLK }
C {devices/lab_pin.sym} 51290 -35810 0 0 {name=p50469 lab=_81807_/D }
C {devices/lab_pin.sym} 51470 -35830 0 1 {name=p50470 lab=_81807_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -35820 0 0 {name=X_81807_ }
C {devices/lab_pin.sym} 51300 -35720 0 0 {name=p50471 lab=_69520_/X }
C {devices/lab_pin.sym} 51300 -35680 0 0 {name=p50472 lab=_69050_/Y }
C {devices/lab_pin.sym} 51300 -35640 0 0 {name=p50473 lab=_69516_/X }
C {devices/lab_pin.sym} 51300 -35600 0 0 {name=p50474 lab=_69528_/Y }
C {devices/lab_pin.sym} 51460 -35660 0 1 {name=p50475 lab=_69529_/X }
C {sky130_stdcells/a211o_4.sym} 51380 -35660 0 0 {name=X_69529_ }
C {devices/lab_pin.sym} 51290 -35510 0 0 {name=p50476 lab=_88363_/CLK }
C {devices/lab_pin.sym} 51290 -35490 0 0 {name=p50477 lab=_88363_/D }
C {devices/lab_pin.sym} 51470 -35510 0 1 {name=p50478 lab=_88363_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -35500 0 0 {name=X_88363_ }
C {devices/lab_pin.sym} 51320 -35400 0 0 {name=p50479 lab=_54775_/A }
C {devices/lab_pin.sym} 51320 -35360 0 0 {name=p50480 lab=_54755_/B }
C {devices/lab_pin.sym} 51320 -35320 0 0 {name=p50481 lab=_54775_/C }
C {devices/lab_pin.sym} 51320 -35280 0 0 {name=p50482 lab=_47465_/A }
C {devices/lab_pin.sym} 51440 -35340 0 1 {name=p50483 lab=_54755_/X }
C {sky130_stdcells/and4_4.sym} 51380 -35340 0 0 {name=X_54755_ }
C {devices/lab_pin.sym} 51290 -35190 0 0 {name=p50484 lab=_86500_/CLK }
C {devices/lab_pin.sym} 51290 -35170 0 0 {name=p50485 lab=_53753_/Y }
C {devices/lab_pin.sym} 51470 -35190 0 1 {name=p50486 lab=_85575_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -35180 0 0 {name=X_85575_ }
C {devices/lab_pin.sym} 51300 -35070 0 0 {name=p50487 lab=_73707_/B }
C {devices/lab_pin.sym} 51300 -35030 0 0 {name=p50488 lab=_51960_/X }
C {devices/lab_pin.sym} 51300 -34990 0 0 {name=p50489 lab=_51966_/Y }
C {devices/lab_pin.sym} 51460 -35030 0 1 {name=p50490 lab=_51967_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -35030 0 0 {name=X_51967_ }
C {devices/lab_pin.sym} 51290 -34890 0 0 {name=p50491 lab=_83238_/CLK }
C {devices/lab_pin.sym} 51290 -34870 0 0 {name=p50492 lab=_82787_/D }
C {devices/lab_pin.sym} 51470 -34890 0 1 {name=p50493 lab=_78318_/B }
C {sky130_stdcells/dfxtp_4.sym} 51380 -34880 0 0 {name=X_82787_ }
C {devices/lab_pin.sym} 51290 -34750 0 0 {name=p50494 lab=_83153_/CLK }
C {devices/lab_pin.sym} 51290 -34730 0 0 {name=p50495 lab=_43679_/X }
C {devices/lab_pin.sym} 51470 -34750 0 1 {name=p50496 lab=_87314_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -34740 0 0 {name=X_87314_ }
C {devices/lab_pin.sym} 51300 -34630 0 0 {name=p50497 lab=_41717_/X }
C {devices/lab_pin.sym} 51300 -34590 0 0 {name=p50498 lab=_41374_/A }
C {devices/lab_pin.sym} 51300 -34550 0 0 {name=p50499 lab=_41719_/X }
C {devices/lab_pin.sym} 51460 -34590 0 1 {name=p50500 lab=_41720_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -34590 0 0 {name=X_41720_ }
C {devices/lab_pin.sym} 51300 -34470 0 0 {name=p50501 lab=_85584_/Q }
C {devices/lab_pin.sym} 51300 -34430 0 0 {name=p50502 lab=_53610_/X }
C {devices/lab_pin.sym} 51300 -34390 0 0 {name=p50503 lab=_53705_/Y }
C {devices/lab_pin.sym} 51460 -34430 0 1 {name=p50504 lab=_53706_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -34430 0 0 {name=X_53706_ }
C {devices/lab_pin.sym} 51290 -34290 0 0 {name=p50505 lab=_84400_/CLK }
C {devices/lab_pin.sym} 51290 -34270 0 0 {name=p50506 lab=_61056_/X }
C {devices/lab_pin.sym} 51470 -34290 0 1 {name=p50507 lab=_61055_/C }
C {sky130_stdcells/dfxtp_4.sym} 51380 -34280 0 0 {name=X_84526_ }
C {devices/lab_pin.sym} 51320 -34170 0 0 {name=p50508 lab=_61295_/A }
C {devices/lab_pin.sym} 51320 -34130 0 0 {name=p50509 lab=_72540_/B }
C {devices/lab_pin.sym} 51320 -34090 0 0 {name=p50510 lab=_72510_/C }
C {devices/lab_pin.sym} 51440 -34130 0 1 {name=p50511 lab=_72540_/Y }
C {sky130_stdcells/nor3_4.sym} 51380 -34130 0 0 {name=X_72540_ }
C {devices/lab_pin.sym} 51340 -33990 0 0 {name=p50512 lab=_50918_/A }
C {devices/lab_pin.sym} 51420 -33990 0 1 {name=p50513 lab=_50941_/A }
C {sky130_stdcells/buf_2.sym} 51380 -33990 0 0 {name=X_50918_ }
C {devices/lab_pin.sym} 51290 -33870 0 0 {name=p50514 lab=_81783_/CLK }
C {devices/lab_pin.sym} 51290 -33850 0 0 {name=p50515 lab=_75982_/B }
C {devices/lab_pin.sym} 51470 -33870 0 1 {name=p50516 lab=_41406_/A }
C {sky130_stdcells/dfxtp_4.sym} 51380 -33860 0 0 {name=X_81738_ }
C {devices/lab_pin.sym} 51300 -33750 0 0 {name=p50517 lab=_74831_/A }
C {devices/lab_pin.sym} 51300 -33710 0 0 {name=p50518 lab=_56971_/B }
C {devices/lab_pin.sym} 51300 -33670 0 0 {name=p50519 lab=_57473_/Y }
C {devices/lab_pin.sym} 51460 -33710 0 1 {name=p50520 lab=_57474_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -33710 0 0 {name=X_57474_ }
C {devices/lab_pin.sym} 51290 -33570 0 0 {name=p50521 lab=_87253_/CLK }
C {devices/lab_pin.sym} 51290 -33550 0 0 {name=p50522 lab=_41011_/Y }
C {devices/lab_pin.sym} 51470 -33570 0 1 {name=p50523 lab=_88294_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -33560 0 0 {name=X_88294_ }
C {devices/lab_pin.sym} 51300 -33450 0 0 {name=p50524 lab=_54683_/Y }
C {devices/lab_pin.sym} 51300 -33410 0 0 {name=p50525 lab=_54666_/X }
C {devices/lab_pin.sym} 51300 -33370 0 0 {name=p50526 lab=_54685_/X }
C {devices/lab_pin.sym} 51460 -33410 0 1 {name=p50527 lab=_54686_/Y }
C {sky130_stdcells/a21oi_4.sym} 51380 -33410 0 0 {name=X_54686_ }
C {devices/lab_pin.sym} 51320 -33300 0 0 {name=p50528 lab=_51887_/A }
C {devices/lab_pin.sym} 51320 -33260 0 0 {name=p50529 lab=_51898_/B }
C {devices/lab_pin.sym} 51320 -33220 0 0 {name=p50530 lab=_51893_/C }
C {devices/lab_pin.sym} 51320 -33180 0 0 {name=p50531 lab=_52724_/D }
C {devices/lab_pin.sym} 51440 -33240 0 1 {name=p50532 lab=_51898_/X }
C {sky130_stdcells/and4_4.sym} 51380 -33240 0 0 {name=X_51898_ }
C {devices/lab_pin.sym} 51320 -33100 0 0 {name=p50533 lab=_86672_/Q }
C {devices/lab_pin.sym} 51320 -33060 0 0 {name=p50534 lab=_59189_/B }
C {devices/lab_pin.sym} 51440 -33080 0 1 {name=p50535 lab=_59213_/Y }
C {sky130_stdcells/nor2_4.sym} 51380 -33080 0 0 {name=X_59213_ }
C {devices/lab_pin.sym} 51300 -32970 0 0 {name=p50536 lab=_56103_/X }
C {devices/lab_pin.sym} 51300 -32930 0 0 {name=p50537 lab=_56409_/X }
C {devices/lab_pin.sym} 51300 -32890 0 0 {name=p50538 lab=_56424_/Y }
C {devices/lab_pin.sym} 51460 -32930 0 1 {name=p50539 lab=_85199_/D }
C {sky130_stdcells/o21ai_4.sym} 51380 -32930 0 0 {name=X_56425_ }
C {devices/lab_pin.sym} 51340 -32790 0 0 {name=p50540 lab=_41651_/A }
C {devices/lab_pin.sym} 51420 -32790 0 1 {name=p50541 lab=_41651_/X }
C {sky130_stdcells/buf_2.sym} 51380 -32790 0 0 {name=X_41651_ }
C {devices/lab_pin.sym} 51290 -32670 0 0 {name=p50542 lab=_87766_/CLK }
C {devices/lab_pin.sym} 51290 -32650 0 0 {name=p50543 lab=_87245_/D }
C {devices/lab_pin.sym} 51470 -32670 0 1 {name=p50544 lab=_68530_/B }
C {sky130_stdcells/dfxtp_4.sym} 51380 -32660 0 0 {name=X_87245_ }
C {devices/lab_pin.sym} 51300 -32550 0 0 {name=p50545 lab=_53634_/Y }
C {devices/lab_pin.sym} 51300 -32510 0 0 {name=p50546 lab=_53619_/X }
C {devices/lab_pin.sym} 51300 -32470 0 0 {name=p50547 lab=_53636_/X }
C {devices/lab_pin.sym} 51460 -32510 0 1 {name=p50548 lab=_53637_/Y }
C {sky130_stdcells/a21oi_4.sym} 51380 -32510 0 0 {name=X_53637_ }
C {devices/lab_pin.sym} 51320 -32380 0 0 {name=p50549 lab=_72461_/A }
C {devices/lab_pin.sym} 51320 -32340 0 0 {name=p50550 lab=_72471_/B }
C {devices/lab_pin.sym} 51440 -32360 0 1 {name=p50551 lab=_72471_/Y }
C {sky130_stdcells/nor2_4.sym} 51380 -32360 0 0 {name=X_72471_ }
C {devices/lab_pin.sym} 51290 -32230 0 0 {name=p50552 lab=_84454_/CLK }
C {devices/lab_pin.sym} 51290 -32210 0 0 {name=p50553 lab=_84457_/D }
C {devices/lab_pin.sym} 51470 -32230 0 1 {name=p50554 lab=_78080_/B }
C {sky130_stdcells/dfxtp_4.sym} 51380 -32220 0 0 {name=X_84457_ }
C {devices/lab_pin.sym} 51340 -32090 0 0 {name=p50555 lab=_50768_/A }
C {devices/lab_pin.sym} 51420 -32090 0 1 {name=p50556 lab=_50849_/X }
C {sky130_stdcells/buf_2.sym} 51380 -32090 0 0 {name=X_50849_ }
C {devices/lab_pin.sym} 51290 -31970 0 0 {name=p50557 lab=_81288_/CLK }
C {devices/lab_pin.sym} 51290 -31950 0 0 {name=p50558 lab=_79949_/X }
C {devices/lab_pin.sym} 51470 -31970 0 1 {name=p50559 lab=_81637_/D }
C {sky130_stdcells/dfxtp_4.sym} 51380 -31960 0 0 {name=X_81669_ }
C {devices/lab_pin.sym} 51300 -31850 0 0 {name=p50560 lab=_86979_/Q }
C {devices/lab_pin.sym} 51300 -31810 0 0 {name=p50561 lab=_57092_/X }
C {devices/lab_pin.sym} 51300 -31770 0 0 {name=p50562 lab=_74209_/X }
C {devices/lab_pin.sym} 51460 -31810 0 1 {name=p50563 lab=_74210_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -31810 0 0 {name=X_74210_ }
C {devices/lab_pin.sym} 51340 -31670 0 0 {name=p50564 lab=_40420_/A }
C {devices/lab_pin.sym} 51420 -31670 0 1 {name=p50565 lab=_47943_/A }
C {sky130_stdcells/buf_2.sym} 51380 -31670 0 0 {name=X_40602_ }
C {devices/lab_pin.sym} 51340 -31550 0 0 {name=p50566 lab=_57757_/A }
C {devices/lab_pin.sym} 51420 -31550 0 1 {name=p50567 lab=_72358_/A }
C {sky130_stdcells/buf_2.sym} 51380 -31550 0 0 {name=X_59144_ }
C {devices/lab_pin.sym} 51320 -31460 0 0 {name=p50568 lab=_70407_/C }
C {devices/lab_pin.sym} 51320 -31420 0 0 {name=p50569 lab=_71432_/B }
C {devices/lab_pin.sym} 51320 -31380 0 0 {name=p50570 lab=_71422_/C }
C {devices/lab_pin.sym} 51320 -31340 0 0 {name=p50571 lab=_71365_/X }
C {devices/lab_pin.sym} 51440 -31400 0 1 {name=p50572 lab=_71422_/X }
C {sky130_stdcells/and4_4.sym} 51380 -31400 0 0 {name=X_71422_ }
C {devices/lab_pin.sym} 51290 -31250 0 0 {name=p50573 lab=_83482_/CLK }
C {devices/lab_pin.sym} 51290 -31230 0 0 {name=p50574 lab=_71697_/Y }
C {devices/lab_pin.sym} 51470 -31250 0 1 {name=p50575 lab=_58283_/A }
C {sky130_stdcells/dfxtp_4.sym} 51380 -31240 0 0 {name=X_83408_ }
C {devices/lab_pin.sym} 51340 -31110 0 0 {name=p50576 lab=_44370_/A }
C {devices/lab_pin.sym} 51420 -31110 0 1 {name=p50577 lab=_87143_/D }
C {sky130_stdcells/inv_2.sym} 51380 -31110 0 0 {name=X_44370_ }
C {devices/lab_pin.sym} 51320 -31010 0 0 {name=p50578 lab=_56358_/A }
C {devices/lab_pin.sym} 51320 -30970 0 0 {name=p50579 lab=_56358_/B }
C {devices/lab_pin.sym} 51320 -30930 0 0 {name=p50580 lab=_55756_/B }
C {devices/lab_pin.sym} 51440 -30970 0 1 {name=p50581 lab=_56356_/Y }
C {sky130_stdcells/nand3_4.sym} 51380 -30970 0 0 {name=X_56356_ }
C {devices/lab_pin.sym} 51320 -30850 0 0 {name=p50582 lab=_75190_/A }
C {devices/lab_pin.sym} 51320 -30810 0 0 {name=p50583 lab=_75190_/B }
C {devices/lab_pin.sym} 51320 -30770 0 0 {name=p50584 lab=_75190_/C }
C {devices/lab_pin.sym} 51440 -30810 0 1 {name=p50585 lab=_75190_/Y }
C {sky130_stdcells/nand3_4.sym} 51380 -30810 0 0 {name=X_75190_ }
C {devices/lab_pin.sym} 51290 -30670 0 0 {name=p50586 lab=_87178_/CLK }
C {devices/lab_pin.sym} 51290 -30650 0 0 {name=p50587 lab=_44258_/Y }
C {devices/lab_pin.sym} 51470 -30670 0 1 {name=p50588 lab=_87176_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -30660 0 0 {name=X_87176_ }
C {devices/lab_pin.sym} 51340 -30530 0 0 {name=p50589 lab=_41457_/A }
C {devices/lab_pin.sym} 51420 -30530 0 1 {name=p50590 lab=_41582_/X }
C {sky130_stdcells/buf_2.sym} 51380 -30530 0 0 {name=X_41582_ }
C {devices/lab_pin.sym} 51300 -30430 0 0 {name=p50591 lab=_85611_/Q }
C {devices/lab_pin.sym} 51300 -30390 0 0 {name=p50592 lab=_53556_/X }
C {devices/lab_pin.sym} 51300 -30350 0 0 {name=p50593 lab=_53567_/Y }
C {devices/lab_pin.sym} 51460 -30390 0 1 {name=p50594 lab=_53568_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -30390 0 0 {name=X_53568_ }
C {devices/lab_pin.sym} 51290 -30250 0 0 {name=p50595 lab=_84392_/CLK }
C {devices/lab_pin.sym} 51290 -30230 0 0 {name=p50596 lab=_62723_/Y }
C {devices/lab_pin.sym} 51470 -30250 0 1 {name=p50597 lab=_75918_/B }
C {sky130_stdcells/dfxtp_4.sym} 51380 -30240 0 0 {name=X_84388_ }
C {devices/lab_pin.sym} 51340 -30110 0 0 {name=p50598 lab=_43320_/Y }
C {devices/lab_pin.sym} 51420 -30110 0 1 {name=p50599 lab=_87483_/D }
C {sky130_stdcells/inv_2.sym} 51380 -30110 0 0 {name=X_43321_ }
C {devices/lab_pin.sym} 51320 -30000 0 0 {name=p50600 lab=_55306_/X }
C {devices/lab_pin.sym} 51320 -29960 0 0 {name=p50601 lab=_45672_/Y }
C {devices/lab_pin.sym} 51440 -29980 0 1 {name=p50602 lab=_55307_/Y }
C {sky130_stdcells/nor2_4.sym} 51380 -29980 0 0 {name=X_55307_ }
C {devices/lab_pin.sym} 51290 -29850 0 0 {name=p50603 lab=_86127_/CLK }
C {devices/lab_pin.sym} 51290 -29830 0 0 {name=p50604 lab=_50817_/Y }
C {devices/lab_pin.sym} 51470 -29850 0 1 {name=p50605 lab=_86127_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -29840 0 0 {name=X_86127_ }
C {devices/lab_pin.sym} 51320 -29720 0 0 {name=p50606 lab=_86982_/Q }
C {devices/lab_pin.sym} 51320 -29680 0 0 {name=p50607 lab=_73370_/B }
C {devices/lab_pin.sym} 51440 -29700 0 1 {name=p50608 lab=_74141_/Y }
C {sky130_stdcells/nor2_4.sym} 51380 -29700 0 0 {name=X_74141_ }
C {devices/lab_pin.sym} 51300 -29610 0 0 {name=p50609 lab=_40477_/X }
C {devices/lab_pin.sym} 51300 -29570 0 0 {name=p50610 lab=_40488_/X }
C {devices/lab_pin.sym} 51300 -29530 0 0 {name=p50611 lab=_40532_/X }
C {devices/lab_pin.sym} 51300 -29490 0 0 {name=p50612 lab=_88375_/Q }
C {devices/lab_pin.sym} 51300 -29450 0 0 {name=p50613 lab=_40492_/X }
C {devices/lab_pin.sym} 51460 -29530 0 1 {name=p50614 lab=_40534_/A }
C {sky130_stdcells/o32ai_4.sym} 51380 -29530 0 0 {name=X_40533_ }
C {devices/lab_pin.sym} 51300 -29390 0 0 {name=p50615 lab=_65103_/B }
C {devices/lab_pin.sym} 51300 -29350 0 0 {name=p50616 lab=_52516_/X }
C {devices/lab_pin.sym} 51300 -29310 0 0 {name=p50617 lab=_52518_/Y }
C {devices/lab_pin.sym} 51460 -29350 0 1 {name=p50618 lab=_52519_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -29350 0 0 {name=X_52519_ }
C {devices/lab_pin.sym} 51300 -29230 0 0 {name=p50619 lab=_59061_/X }
C {devices/lab_pin.sym} 51300 -29190 0 0 {name=p50620 lab=_86075_/Q }
C {devices/lab_pin.sym} 51300 -29150 0 0 {name=p50621 lab=_59074_/X }
C {devices/lab_pin.sym} 51460 -29190 0 1 {name=p50622 lab=_59075_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -29190 0 0 {name=X_59075_ }
C {devices/lab_pin.sym} 51340 -29050 0 0 {name=p50623 lab=_71429_/A }
C {devices/lab_pin.sym} 51420 -29050 0 1 {name=p50624 lab=_71363_/D }
C {sky130_stdcells/buf_2.sym} 51380 -29050 0 0 {name=X_71353_ }
C {devices/lab_pin.sym} 51290 -28930 0 0 {name=p50625 lab=_83362_/CLK }
C {devices/lab_pin.sym} 51290 -28910 0 0 {name=p50626 lab=_83339_/D }
C {devices/lab_pin.sym} 51470 -28930 0 1 {name=p50627 lab=_83339_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -28920 0 0 {name=X_83339_ }
C {devices/lab_pin.sym} 51320 -28810 0 0 {name=p50628 lab=_56368_/A }
C {devices/lab_pin.sym} 51320 -28770 0 0 {name=p50629 lab=_56270_/B }
C {devices/lab_pin.sym} 51320 -28730 0 0 {name=p50630 lab=_56287_/C }
C {devices/lab_pin.sym} 51440 -28770 0 1 {name=p50631 lab=_56287_/Y }
C {sky130_stdcells/nand3_4.sym} 51380 -28770 0 0 {name=X_56287_ }
C {devices/lab_pin.sym} 51320 -28640 0 0 {name=p50632 lab=_53458_/A }
C {devices/lab_pin.sym} 51320 -28600 0 0 {name=p50633 lab=_50275_/B }
C {devices/lab_pin.sym} 51440 -28620 0 1 {name=p50634 lab=_53499_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -28620 0 0 {name=X_53499_ }
C {devices/lab_pin.sym} 51340 -28490 0 0 {name=p50635 lab=_46039_/Y }
C {devices/lab_pin.sym} 51420 -28490 0 1 {name=p50636 lab=_86799_/D }
C {sky130_stdcells/inv_2.sym} 51380 -28490 0 0 {name=X_46040_ }
C {devices/lab_pin.sym} 51320 -28380 0 0 {name=p50637 lab=_58070_/A }
C {devices/lab_pin.sym} 51320 -28340 0 0 {name=p50638 lab=_58026_/B }
C {devices/lab_pin.sym} 51440 -28360 0 1 {name=p50639 lab=_58026_/Y }
C {sky130_stdcells/nor2_4.sym} 51380 -28360 0 0 {name=X_58026_ }
C {devices/lab_pin.sym} 51320 -28260 0 0 {name=p50640 lab=_70296_/X }
C {devices/lab_pin.sym} 51320 -28220 0 0 {name=p50641 lab=_70297_/X }
C {devices/lab_pin.sym} 51320 -28180 0 0 {name=p50642 lab=_70304_/C }
C {devices/lab_pin.sym} 51320 -28140 0 0 {name=p50643 lab=_70301_/D }
C {devices/lab_pin.sym} 51440 -28200 0 1 {name=p50644 lab=_70304_/X }
C {sky130_stdcells/and4_4.sym} 51380 -28200 0 0 {name=X_70304_ }
C {devices/lab_pin.sym} 51340 -28050 0 0 {name=p50645 lab=_43251_/Y }
C {devices/lab_pin.sym} 51420 -28050 0 1 {name=p50646 lab=_87518_/D }
C {sky130_stdcells/inv_2.sym} 51380 -28050 0 0 {name=X_43252_ }
C {devices/lab_pin.sym} 51320 -27950 0 0 {name=p50647 lab=_55655_/A }
C {devices/lab_pin.sym} 51320 -27910 0 0 {name=p50648 lab=_83316_/Q }
C {devices/lab_pin.sym} 51320 -27870 0 0 {name=p50649 lab=_55655_/B }
C {devices/lab_pin.sym} 51440 -27910 0 1 {name=p50650 lab=_55243_/B }
C {sky130_stdcells/nand3_4.sym} 51380 -27910 0 0 {name=X_55238_ }
C {devices/lab_pin.sym} 51300 -27800 0 0 {name=p50651 lab=_41957_/Y }
C {devices/lab_pin.sym} 51300 -27760 0 0 {name=p50652 lab=_72888_/X }
C {devices/lab_pin.sym} 51300 -27720 0 0 {name=p50653 lab=_73551_/X }
C {devices/lab_pin.sym} 51300 -27680 0 0 {name=p50654 lab=_74071_/Y }
C {devices/lab_pin.sym} 51460 -27740 0 1 {name=p50655 lab=_74072_/X }
C {sky130_stdcells/a211o_4.sym} 51380 -27740 0 0 {name=X_74072_ }
C {devices/lab_pin.sym} 51290 -27590 0 0 {name=p50656 lab=_85645_/CLK }
C {devices/lab_pin.sym} 51290 -27570 0 0 {name=p50657 lab=_86058_/D }
C {devices/lab_pin.sym} 51470 -27590 0 1 {name=p50658 lab=_86058_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -27580 0 0 {name=X_86058_ }
C {devices/lab_pin.sym} 51340 -27450 0 0 {name=p50659 lab=_46526_/A }
C {devices/lab_pin.sym} 51420 -27450 0 1 {name=p50660 lab=_40784_/A }
C {sky130_stdcells/buf_2.sym} 51380 -27450 0 0 {name=X_40464_ }
C {devices/lab_pin.sym} 51300 -27350 0 0 {name=p50661 lab=_53213_/B }
C {devices/lab_pin.sym} 51300 -27310 0 0 {name=p50662 lab=_71264_/X }
C {devices/lab_pin.sym} 51300 -27270 0 0 {name=p50663 lab=_71283_/Y }
C {devices/lab_pin.sym} 51460 -27310 0 1 {name=p50664 lab=_83547_/D }
C {sky130_stdcells/o21ai_4.sym} 51380 -27310 0 0 {name=X_71284_ }
C {devices/lab_pin.sym} 51340 -27170 0 0 {name=p50665 lab=_42203_/A }
C {devices/lab_pin.sym} 51420 -27170 0 1 {name=p50666 lab=_42203_/Y }
C {sky130_stdcells/inv_2.sym} 51380 -27170 0 0 {name=X_42203_ }
C {devices/lab_pin.sym} 51300 -27070 0 0 {name=p50667 lab=_83168_/Q }
C {devices/lab_pin.sym} 51300 -27030 0 0 {name=p50668 lab=_72943_/X }
C {devices/lab_pin.sym} 51300 -26990 0 0 {name=p50669 lab=_73022_/Y }
C {devices/lab_pin.sym} 51460 -27030 0 1 {name=p50670 lab=_73023_/X }
C {sky130_stdcells/a21o_4.sym} 51380 -27030 0 0 {name=X_73023_ }
C {devices/lab_pin.sym} 51320 -26900 0 0 {name=p50671 lab=_82245_/Q }
C {devices/lab_pin.sym} 51320 -26860 0 0 {name=p50672 lab=_81957_/Q }
C {devices/lab_pin.sym} 51440 -26880 0 1 {name=p50673 lab=_77900_/Y }
C {sky130_stdcells/xnor2_4.sym} 51380 -26880 0 0 {name=X_77900_ }
C {devices/lab_pin.sym} 51290 -26750 0 0 {name=p50674 lab=_85037_/CLK }
C {devices/lab_pin.sym} 51290 -26730 0 0 {name=p50675 lab=_57412_/X }
C {devices/lab_pin.sym} 51470 -26750 0 1 {name=p50676 lab=_57409_/A }
C {sky130_stdcells/dfxtp_4.sym} 51380 -26740 0 0 {name=X_85009_ }
C {devices/lab_pin.sym} 51300 -26630 0 0 {name=p50677 lab=_70224_/X }
C {devices/lab_pin.sym} 51300 -26590 0 0 {name=p50678 lab=_83828_/Q }
C {devices/lab_pin.sym} 51300 -26550 0 0 {name=p50679 lab=_70234_/X }
C {devices/lab_pin.sym} 51460 -26590 0 1 {name=p50680 lab=_70235_/X }
C {sky130_stdcells/a21o_4.sym} 51380 -26590 0 0 {name=X_70235_ }
C {devices/lab_pin.sym} 51340 -26450 0 0 {name=p50681 lab=_43182_/Y }
C {devices/lab_pin.sym} 51420 -26450 0 1 {name=p50682 lab=_43217_/A }
C {sky130_stdcells/buf_2.sym} 51380 -26450 0 0 {name=X_43183_ }
C {devices/lab_pin.sym} 51320 -26340 0 0 {name=p50683 lab=_55159_/A }
C {devices/lab_pin.sym} 51320 -26300 0 0 {name=p50684 lab=_85004_/Q }
C {devices/lab_pin.sym} 51440 -26320 0 1 {name=p50685 lab=_55169_/X }
C {sky130_stdcells/and2_4.sym} 51380 -26320 0 0 {name=X_55169_ }
C {devices/lab_pin.sym} 51300 -26210 0 0 {name=p50686 lab=_78875_/Y }
C {devices/lab_pin.sym} 51300 -26170 0 0 {name=p50687 lab=_78854_/B }
C {devices/lab_pin.sym} 51300 -26130 0 0 {name=p50688 lab=_78879_/Y }
C {devices/lab_pin.sym} 51460 -26170 0 1 {name=p50689 lab=_78880_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -26170 0 0 {name=X_78880_ }
C {devices/lab_pin.sym} 51340 -26030 0 0 {name=p50690 lab=_40394_/X }
C {devices/lab_pin.sym} 51420 -26030 0 1 {name=p50691 lab=_40395_/X }
C {sky130_stdcells/buf_2.sym} 51380 -26030 0 0 {name=X_40395_ }
C {devices/lab_pin.sym} 51300 -25950 0 0 {name=p50692 lab=_42120_/X }
C {devices/lab_pin.sym} 51300 -25910 0 0 {name=p50693 lab=_42116_/X }
C {devices/lab_pin.sym} 51300 -25870 0 0 {name=p50694 lab=_41125_/X }
C {devices/lab_pin.sym} 51300 -25830 0 0 {name=p50695 lab=_88017_/Q }
C {devices/lab_pin.sym} 51300 -25790 0 0 {name=p50696 lab=_42117_/X }
C {devices/lab_pin.sym} 51460 -25870 0 1 {name=p50697 lab=_42134_/Y }
C {sky130_stdcells/o32ai_4.sym} 51380 -25870 0 0 {name=X_42134_ }
C {devices/lab_pin.sym} 51320 -25720 0 0 {name=p50698 lab=_82157_/Q }
C {devices/lab_pin.sym} 51320 -25680 0 0 {name=p50699 lab=_77831_/B }
C {devices/lab_pin.sym} 51440 -25700 0 1 {name=p50700 lab=_77831_/X }
C {sky130_stdcells/xor2_4.sym} 51380 -25700 0 0 {name=X_77831_ }
C {devices/lab_pin.sym} 51300 -25590 0 0 {name=p50701 lab=_70158_/Y }
C {devices/lab_pin.sym} 51300 -25550 0 0 {name=p50702 lab=_70157_/X }
C {devices/lab_pin.sym} 51300 -25510 0 0 {name=p50703 lab=_70165_/Y }
C {devices/lab_pin.sym} 51460 -25550 0 1 {name=p50704 lab=_83849_/D }
C {sky130_stdcells/o21ai_4.sym} 51380 -25550 0 0 {name=X_70166_ }
C {devices/lab_pin.sym} 51320 -25420 0 0 {name=p50705 lab=_48044_/A }
C {devices/lab_pin.sym} 51320 -25380 0 0 {name=p50706 lab=_47991_/B }
C {devices/lab_pin.sym} 51440 -25400 0 1 {name=p50707 lab=_47991_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -25400 0 0 {name=X_47991_ }
C {devices/lab_pin.sym} 51320 -25280 0 0 {name=p50708 lab=_59977_/A }
C {devices/lab_pin.sym} 51320 -25240 0 0 {name=p50709 lab=_59977_/B }
C {devices/lab_pin.sym} 51440 -25260 0 1 {name=p50710 lab=_59977_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -25260 0 0 {name=X_59977_ }
C {devices/lab_pin.sym} 51320 -25140 0 0 {name=p50711 lab=_49716_/X }
C {devices/lab_pin.sym} 51320 -25100 0 0 {name=p50712 lab=_52944_/B }
C {devices/lab_pin.sym} 51440 -25120 0 1 {name=p50713 lab=_49730_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -25120 0 0 {name=X_49730_ }
C {devices/lab_pin.sym} 51340 -24990 0 0 {name=p50714 lab=_82399_/Q }
C {devices/lab_pin.sym} 51420 -24990 0 1 {name=p50715 lab=_46942_/Y }
C {sky130_stdcells/inv_2.sym} 51380 -24990 0 0 {name=X_46942_ }
C {devices/lab_pin.sym} 51340 -24870 0 0 {name=p50716 lab=_58928_/A }
C {devices/lab_pin.sym} 51420 -24870 0 1 {name=p50717 lab=_58928_/X }
C {sky130_stdcells/buf_2.sym} 51380 -24870 0 0 {name=X_58928_ }
C {devices/lab_pin.sym} 51340 -24750 0 0 {name=p50718 lab=clkbuf_7_50_0_CLK/A }
C {devices/lab_pin.sym} 51420 -24750 0 1 {name=p50719 lab=clkbuf_7_50_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 51380 -24750 0 0 {name=Xclkbuf_7_50_0_CLK }
C {devices/lab_pin.sym} 51300 -24660 0 0 {name=p50720 lab=_40935_/X }
C {devices/lab_pin.sym} 51300 -24620 0 0 {name=p50721 lab=_41907_/X }
C {devices/lab_pin.sym} 51300 -24580 0 0 {name=p50722 lab=_88051_/Q }
C {devices/lab_pin.sym} 51300 -24540 0 0 {name=p50723 lab=_41912_/X }
C {devices/lab_pin.sym} 51460 -24600 0 1 {name=p50724 lab=_88051_/D }
C {sky130_stdcells/a2bb2o_4.sym} 51380 -24600 0 0 {name=X_42065_ }
C {devices/lab_pin.sym} 51320 -24460 0 0 {name=p50725 lab=_82262_/Q }
C {devices/lab_pin.sym} 51320 -24420 0 0 {name=p50726 lab=_81974_/Q }
C {devices/lab_pin.sym} 51440 -24440 0 1 {name=p50727 lab=_81926_/D }
C {sky130_stdcells/xor2_4.sym} 51380 -24440 0 0 {name=X_77762_ }
C {devices/lab_pin.sym} 51320 -24320 0 0 {name=p50728 lab=_80763_/Q }
C {devices/lab_pin.sym} 51320 -24280 0 0 {name=p50729 lab=_74965_/B }
C {devices/lab_pin.sym} 51440 -24300 0 1 {name=p50730 lab=_74974_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -24300 0 0 {name=X_74974_ }
C {devices/lab_pin.sym} 51300 -24190 0 0 {name=p50731 lab=_82530_/D }
C {devices/lab_pin.sym} 51300 -24150 0 0 {name=p50732 lab=_70085_/X }
C {devices/lab_pin.sym} 51300 -24110 0 0 {name=p50733 lab=_70096_/X }
C {devices/lab_pin.sym} 51460 -24150 0 1 {name=p50734 lab=_70097_/X }
C {sky130_stdcells/a21bo_4.sym} 51380 -24150 0 0 {name=X_70097_ }
C {devices/lab_pin.sym} 51340 -24010 0 0 {name=p50735 lab=clkbuf_7_95_0_CLK/X }
C {devices/lab_pin.sym} 51420 -24010 0 1 {name=p50736 lab=clkbuf_8_190_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 51380 -24010 0 0 {name=Xclkbuf_8_190_0_CLK }
C {devices/lab_pin.sym} 51320 -23900 0 0 {name=p50737 lab=_84816_/Q }
C {devices/lab_pin.sym} 51320 -23860 0 0 {name=p50738 lab=_84136_/Q }
C {devices/lab_pin.sym} 51440 -23880 0 1 {name=p50739 lab=_79503_/A }
C {sky130_stdcells/xor2_4.sym} 51380 -23880 0 0 {name=X_79501_ }
C {devices/lab_pin.sym} 51340 -23750 0 0 {name=p50740 lab=_41016_/A }
C {devices/lab_pin.sym} 51420 -23750 0 1 {name=p50741 lab=_41016_/X }
C {sky130_stdcells/buf_2.sym} 51380 -23750 0 0 {name=X_41016_ }
C {devices/lab_pin.sym} 51320 -23640 0 0 {name=p50742 lab=_76713_/A }
C {devices/lab_pin.sym} 51320 -23600 0 0 {name=p50743 lab=_76713_/B }
C {devices/lab_pin.sym} 51440 -23620 0 1 {name=p50744 lab=_81545_/D }
C {sky130_stdcells/xor2_4.sym} 51380 -23620 0 0 {name=X_76713_ }
C {devices/lab_pin.sym} 51340 -23490 0 0 {name=p50745 lab=_49580_/A }
C {devices/lab_pin.sym} 51420 -23490 0 1 {name=p50746 lab=_49661_/X }
C {sky130_stdcells/buf_2.sym} 51380 -23490 0 0 {name=X_49661_ }
C {devices/lab_pin.sym} 51320 -23380 0 0 {name=p50747 lab=_44126_/X }
C {devices/lab_pin.sym} 51320 -23340 0 0 {name=p50748 lab=_85906_/Q }
C {devices/lab_pin.sym} 51440 -23360 0 1 {name=p50749 lab=_73925_/X }
C {sky130_stdcells/and2_4.sym} 51380 -23360 0 0 {name=X_73925_ }
C {devices/lab_pin.sym} 51300 -23250 0 0 {name=p50750 lab=_86694_/Q }
C {devices/lab_pin.sym} 51300 -23210 0 0 {name=p50751 lab=_46859_/X }
C {devices/lab_pin.sym} 51300 -23170 0 0 {name=p50752 lab=_46872_/Y }
C {devices/lab_pin.sym} 51460 -23210 0 1 {name=p50753 lab=_46873_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -23210 0 0 {name=X_46873_ }
C {devices/lab_pin.sym} 51300 -23090 0 0 {name=p50754 lab=_58756_/X }
C {devices/lab_pin.sym} 51300 -23050 0 0 {name=p50755 lab=_85930_/Q }
C {devices/lab_pin.sym} 51300 -23010 0 0 {name=p50756 lab=_58793_/X }
C {devices/lab_pin.sym} 51460 -23050 0 1 {name=p50757 lab=_58859_/X }
C {sky130_stdcells/o21a_4.sym} 51380 -23050 0 0 {name=X_58859_ }
C {devices/lab_pin.sym} 51320 -22940 0 0 {name=p50758 lab=_77693_/A }
C {devices/lab_pin.sym} 51320 -22900 0 0 {name=p50759 lab=_77680_/X }
C {devices/lab_pin.sym} 51320 -22860 0 0 {name=p50760 lab=_77693_/C }
C {devices/lab_pin.sym} 51320 -22820 0 0 {name=p50761 lab=_77693_/D }
C {devices/lab_pin.sym} 51440 -22880 0 1 {name=p50762 lab=_77694_/A }
C {sky130_stdcells/and4_4.sym} 51380 -22880 0 0 {name=X_77693_ }
C {devices/lab_pin.sym} 51340 -22730 0 0 {name=p50763 lab=_48612_/A }
C {devices/lab_pin.sym} 51420 -22730 0 1 {name=p50764 lab=_48612_/X }
C {sky130_stdcells/buf_2.sym} 51380 -22730 0 0 {name=X_48612_ }
C {devices/lab_pin.sym} 51320 -22620 0 0 {name=p50765 lab=_79429_/X }
C {devices/lab_pin.sym} 51320 -22580 0 0 {name=p50766 lab=_79431_/Y }
C {devices/lab_pin.sym} 51440 -22600 0 1 {name=p50767 lab=_79432_/X }
C {sky130_stdcells/xor2_4.sym} 51380 -22600 0 0 {name=X_79432_ }
C {devices/lab_pin.sym} 51320 -22480 0 0 {name=p50768 lab=_57071_/B }
C {devices/lab_pin.sym} 51320 -22440 0 0 {name=p50769 lab=_45824_/B }
C {devices/lab_pin.sym} 51440 -22460 0 1 {name=p50770 lab=_45824_/Y }
C {sky130_stdcells/nor2_4.sym} 51380 -22460 0 0 {name=X_45824_ }
C {devices/lab_pin.sym} 51320 -22350 0 0 {name=p50771 lab=_76639_/Y }
C {devices/lab_pin.sym} 51320 -22310 0 0 {name=p50772 lab=_81377_/Q }
C {devices/lab_pin.sym} 51320 -22270 0 0 {name=p50773 lab=_76640_/Y }
C {devices/lab_pin.sym} 51440 -22310 0 1 {name=p50774 lab=_76644_/Y }
C {sky130_stdcells/nand3_4.sym} 51380 -22310 0 0 {name=X_76644_ }
C {devices/lab_pin.sym} 51320 -22200 0 0 {name=p50775 lab=_49571_/X }
C {devices/lab_pin.sym} 51320 -22160 0 0 {name=p50776 lab=_49592_/B }
C {devices/lab_pin.sym} 51320 -22120 0 0 {name=p50777 lab=_49577_/C }
C {devices/lab_pin.sym} 51320 -22080 0 0 {name=p50778 lab=_52805_/D }
C {devices/lab_pin.sym} 51440 -22140 0 1 {name=p50779 lab=_49592_/X }
C {sky130_stdcells/and4_4.sym} 51380 -22140 0 0 {name=X_49592_ }
C {devices/lab_pin.sym} 51340 -21990 0 0 {name=p50780 lab=_61948_/A }
C {devices/lab_pin.sym} 51420 -21990 0 1 {name=p50781 lab=_61870_/X }
C {sky130_stdcells/buf_2.sym} 51380 -21990 0 0 {name=X_61870_ }
C {devices/lab_pin.sym} 51300 -21900 0 0 {name=p50782 lab=_73854_/X }
C {devices/lab_pin.sym} 51300 -21860 0 0 {name=p50783 lab=_85621_/Q }
C {devices/lab_pin.sym} 51300 -21820 0 0 {name=p50784 lab=_73782_/X }
C {devices/lab_pin.sym} 51300 -21780 0 0 {name=p50785 lab=_73855_/X }
C {devices/lab_pin.sym} 51460 -21840 0 1 {name=p50786 lab=_73856_/X }
C {sky130_stdcells/a211o_4.sym} 51380 -21840 0 0 {name=X_73856_ }
C {devices/lab_pin.sym} 51340 -21690 0 0 {name=p50787 lab=clkbuf_6_32_0_CLK/X }
C {devices/lab_pin.sym} 51420 -21690 0 1 {name=p50788 lab=clkbuf_7_65_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 51380 -21690 0 0 {name=Xclkbuf_7_65_0_CLK }
C {devices/lab_pin.sym} 51340 -21570 0 0 {name=p50789 lab=_64738_/A }
C {devices/lab_pin.sym} 51420 -21570 0 1 {name=p50790 lab=_64561_/A }
C {sky130_stdcells/buf_2.sym} 51380 -21570 0 0 {name=X_60821_ }
C {devices/lab_pin.sym} 51320 -21460 0 0 {name=p50791 lab=_72929_/A }
C {devices/lab_pin.sym} 51320 -21420 0 0 {name=p50792 lab=_65451_/B }
C {devices/lab_pin.sym} 51440 -21440 0 1 {name=p50793 lab=_72807_/X }
C {sky130_stdcells/and2_4.sym} 51380 -21440 0 0 {name=X_72807_ }
C {devices/lab_pin.sym} 51300 -21330 0 0 {name=p50794 lab=_48043_/X }
C {devices/lab_pin.sym} 51300 -21290 0 0 {name=p50795 lab=_49048_/B }
C {devices/lab_pin.sym} 51300 -21250 0 0 {name=p50796 lab=_48542_/Y }
C {devices/lab_pin.sym} 51460 -21290 0 1 {name=p50797 lab=_48544_/A }
C {sky130_stdcells/o21ai_4.sym} 51380 -21290 0 0 {name=X_48543_ }
C {devices/lab_pin.sym} 51320 -21160 0 0 {name=p50798 lab=_79363_/A }
C {devices/lab_pin.sym} 51320 -21120 0 0 {name=p50799 lab=_79363_/B }
C {devices/lab_pin.sym} 51440 -21140 0 1 {name=p50800 lab=_79369_/B }
C {sky130_stdcells/xor2_4.sym} 51380 -21140 0 0 {name=X_79363_ }
C {devices/lab_pin.sym} 51300 -21030 0 0 {name=p50801 lab=_57448_/A }
C {devices/lab_pin.sym} 51300 -20990 0 0 {name=p50802 lab=_45705_/X }
C {devices/lab_pin.sym} 51300 -20950 0 0 {name=p50803 lab=_45691_/X }
C {devices/lab_pin.sym} 51460 -20990 0 1 {name=p50804 lab=_45755_/X }
C {sky130_stdcells/o21a_4.sym} 51380 -20990 0 0 {name=X_45755_ }
C {devices/lab_pin.sym} 51340 -20850 0 0 {name=p50805 lab=_76574_/Y }
C {devices/lab_pin.sym} 51420 -20850 0 1 {name=p50806 lab=_76575_/Y }
C {sky130_stdcells/inv_2.sym} 51380 -20850 0 0 {name=X_76575_ }
C {devices/lab_pin.sym} 51300 -20770 0 0 {name=p50807 lab=_42944_/X }
C {devices/lab_pin.sym} 51300 -20730 0 0 {name=p50808 lab=_42945_/X }
C {devices/lab_pin.sym} 51300 -20690 0 0 {name=p50809 lab=_40426_/X }
C {devices/lab_pin.sym} 51300 -20650 0 0 {name=p50810 lab=_66808_/B }
C {devices/lab_pin.sym} 51300 -20610 0 0 {name=p50811 lab=_42954_/X }
C {devices/lab_pin.sym} 51460 -20690 0 1 {name=p50812 lab=_42968_/A }
C {sky130_stdcells/o32ai_4.sym} 51380 -20690 0 0 {name=X_42967_ }
C {devices/lab_pin.sym} 51320 -20540 0 0 {name=p50813 lab=_73742_/A }
C {devices/lab_pin.sym} 51320 -20500 0 0 {name=p50814 lab=_66041_/B }
C {devices/lab_pin.sym} 51440 -20520 0 1 {name=p50815 lab=_73787_/X }
C {sky130_stdcells/and2_4.sym} 51380 -20520 0 0 {name=X_73787_ }
C {devices/lab_pin.sym} 51300 -20410 0 0 {name=p50816 lab=_50827_/B }
C {devices/lab_pin.sym} 51300 -20370 0 0 {name=p50817 lab=_70983_/X }
C {devices/lab_pin.sym} 51300 -20330 0 0 {name=p50818 lab=_70998_/Y }
C {devices/lab_pin.sym} 51460 -20370 0 1 {name=p50819 lab=_70999_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -20370 0 0 {name=X_70999_ }
C {devices/lab_pin.sym} 51320 -20240 0 0 {name=p50820 lab=_78314_/A }
C {devices/lab_pin.sym} 51320 -20200 0 0 {name=p50821 lab=_82754_/D }
C {devices/lab_pin.sym} 51440 -20220 0 1 {name=p50822 lab=_82466_/D }
C {sky130_stdcells/xor2_4.sym} 51380 -20220 0 0 {name=X_78314_ }
C {devices/lab_pin.sym} 51300 -20130 0 0 {name=p50823 lab=_44686_/X }
C {devices/lab_pin.sym} 51300 -20090 0 0 {name=p50824 lab=_44687_/X }
C {devices/lab_pin.sym} 51300 -20050 0 0 {name=p50825 lab=_40672_/Y }
C {devices/lab_pin.sym} 51300 -20010 0 0 {name=p50826 lab=_44705_/Y }
C {devices/lab_pin.sym} 51300 -19970 0 0 {name=p50827 lab=_44689_/X }
C {devices/lab_pin.sym} 51460 -20050 0 1 {name=p50828 lab=_86992_/D }
C {sky130_stdcells/o32ai_4.sym} 51380 -20050 0 0 {name=X_44706_ }
C {devices/lab_pin.sym} 51340 -19890 0 0 {name=p50829 lab=_63540_/A }
C {devices/lab_pin.sym} 51420 -19890 0 1 {name=p50830 lab=_63541_/D }
C {sky130_stdcells/buf_2.sym} 51380 -19890 0 0 {name=X_63540_ }
C {devices/lab_pin.sym} 51340 -19770 0 0 {name=p50831 lab=_75525_/X }
C {devices/lab_pin.sym} 51420 -19770 0 1 {name=p50832 lab=_75528_/A }
C {sky130_stdcells/inv_2.sym} 51380 -19770 0 0 {name=X_75526_ }
C {devices/lab_pin.sym} 51340 -19650 0 0 {name=p50833 lab=_41992_/A }
C {devices/lab_pin.sym} 51420 -19650 0 1 {name=p50834 lab=_42477_/A }
C {sky130_stdcells/buf_2.sym} 51380 -19650 0 0 {name=X_41918_ }
C {devices/lab_pin.sym} 51300 -19550 0 0 {name=p50835 lab=_48471_/X }
C {devices/lab_pin.sym} 51300 -19510 0 0 {name=p50836 lab=_82359_/Q }
C {devices/lab_pin.sym} 51300 -19470 0 0 {name=p50837 lab=_48473_/Y }
C {devices/lab_pin.sym} 51460 -19510 0 1 {name=p50838 lab=_74416_/A }
C {sky130_stdcells/o21ai_4.sym} 51380 -19510 0 0 {name=X_48474_ }
C {devices/lab_pin.sym} 51320 -19390 0 0 {name=p50839 lab=_60761_/A }
C {devices/lab_pin.sym} 51320 -19350 0 0 {name=p50840 lab=_60752_/B }
C {devices/lab_pin.sym} 51320 -19310 0 0 {name=p50841 lab=_84575_/Q }
C {devices/lab_pin.sym} 51440 -19350 0 1 {name=p50842 lab=_60752_/Y }
C {sky130_stdcells/nor3_4.sym} 51380 -19350 0 0 {name=X_60752_ }
C {devices/lab_pin.sym} 51300 -19230 0 0 {name=p50843 lab=_72729_/X }
C {devices/lab_pin.sym} 51300 -19190 0 0 {name=p50844 lab=_72733_/X }
C {devices/lab_pin.sym} 51300 -19150 0 0 {name=p50845 lab=_72737_/X }
C {devices/lab_pin.sym} 51460 -19190 0 1 {name=p50846 lab=_72738_/X }
C {sky130_stdcells/a21o_4.sym} 51380 -19190 0 0 {name=X_72738_ }
C {devices/lab_pin.sym} 51320 -19060 0 0 {name=p50847 lab=_79280_/Y }
C {devices/lab_pin.sym} 51320 -19020 0 0 {name=p50848 lab=_79277_/X }
C {devices/lab_pin.sym} 51440 -19040 0 1 {name=p50849 lab=_79294_/X }
C {sky130_stdcells/and2_4.sym} 51380 -19040 0 0 {name=X_79294_ }
C {devices/lab_pin.sym} 51300 -18930 0 0 {name=p50850 lab=_45668_/X }
C {devices/lab_pin.sym} 51300 -18890 0 0 {name=p50851 lab=_61551_/A }
C {devices/lab_pin.sym} 51300 -18850 0 0 {name=p50852 lab=_45685_/X }
C {devices/lab_pin.sym} 51460 -18890 0 1 {name=p50853 lab=_45686_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -18890 0 0 {name=X_45686_ }
C {devices/lab_pin.sym} 51340 -18750 0 0 {name=p50854 lab=_42898_/A }
C {devices/lab_pin.sym} 51420 -18750 0 1 {name=p50855 lab=_87662_/D }
C {sky130_stdcells/inv_2.sym} 51380 -18750 0 0 {name=X_42898_ }
C {devices/lab_pin.sym} 51340 -18630 0 0 {name=p50856 lab=_81804_/Q }
C {devices/lab_pin.sym} 51420 -18630 0 1 {name=p50857 lab=_47426_/A }
C {sky130_stdcells/inv_2.sym} 51380 -18630 0 0 {name=X_47425_ }
C {devices/lab_pin.sym} 51300 -18530 0 0 {name=p50858 lab=_78253_/B }
C {devices/lab_pin.sym} 51300 -18490 0 0 {name=p50859 lab=_82496_/Q }
C {devices/lab_pin.sym} 51300 -18450 0 0 {name=p50860 lab=_78244_/Y }
C {devices/lab_pin.sym} 51460 -18490 0 1 {name=p50861 lab=_78245_/Y }
C {sky130_stdcells/a21oi_4.sym} 51380 -18490 0 0 {name=X_78245_ }
C {devices/lab_pin.sym} 51300 -18380 0 0 {name=p50862 lab=_41032_/A }
C {devices/lab_pin.sym} 51300 -18340 0 0 {name=p50863 lab=_44618_/X }
C {devices/lab_pin.sym} 51300 -18300 0 0 {name=p50864 lab=_87022_/Q }
C {devices/lab_pin.sym} 51300 -18260 0 0 {name=p50865 lab=_44619_/X }
C {devices/lab_pin.sym} 51460 -18320 0 1 {name=p50866 lab=_87022_/D }
C {sky130_stdcells/a2bb2o_4.sym} 51380 -18320 0 0 {name=X_44637_ }
C {devices/lab_pin.sym} 51340 -18170 0 0 {name=p50867 lab=_63471_/A }
C {devices/lab_pin.sym} 51420 -18170 0 1 {name=p50868 lab=_63496_/D }
C {sky130_stdcells/buf_2.sym} 51380 -18170 0 0 {name=X_63471_ }
C {devices/lab_pin.sym} 51320 -18070 0 0 {name=p50869 lab=_75457_/A }
C {devices/lab_pin.sym} 51320 -18030 0 0 {name=p50870 lab=_75457_/B }
C {devices/lab_pin.sym} 51320 -17990 0 0 {name=p50871 lab=_75457_/C }
C {devices/lab_pin.sym} 51440 -18030 0 1 {name=p50872 lab=_75458_/A }
C {sky130_stdcells/or3_4.sym} 51380 -18030 0 0 {name=X_75457_ }
C {devices/lab_pin.sym} 51300 -17920 0 0 {name=p50873 lab=_40507_/X }
C {devices/lab_pin.sym} 51300 -17880 0 0 {name=p50874 lab=_41847_/X }
C {devices/lab_pin.sym} 51300 -17840 0 0 {name=p50875 lab=_67136_/B }
C {devices/lab_pin.sym} 51300 -17800 0 0 {name=p50876 lab=_41848_/X }
C {devices/lab_pin.sym} 51460 -17860 0 1 {name=p50877 lab=_41849_/X }
C {sky130_stdcells/a2bb2o_4.sym} 51380 -17860 0 0 {name=X_41849_ }
C {devices/lab_pin.sym} 51340 -17710 0 0 {name=p50878 lab=_63540_/A }
C {devices/lab_pin.sym} 51420 -17710 0 1 {name=p50879 lab=_63699_/D }
C {sky130_stdcells/buf_2.sym} 51380 -17710 0 0 {name=X_60683_ }
C {devices/lab_pin.sym} 51300 -17610 0 0 {name=p50880 lab=_70210_/C }
C {devices/lab_pin.sym} 51300 -17570 0 0 {name=p50881 lab=_72658_/X }
C {devices/lab_pin.sym} 51300 -17530 0 0 {name=p50882 lab=_72668_/Y }
C {devices/lab_pin.sym} 51460 -17570 0 1 {name=p50883 lab=_83196_/D }
C {sky130_stdcells/a21bo_4.sym} 51380 -17570 0 0 {name=X_72669_ }
C {devices/lab_pin.sym} 51300 -17460 0 0 {name=p50884 lab=_65172_/X }
C {devices/lab_pin.sym} 51300 -17420 0 0 {name=p50885 lab=_86122_/Q }
C {devices/lab_pin.sym} 51300 -17380 0 0 {name=p50886 lab=_65127_/X }
C {devices/lab_pin.sym} 51300 -17340 0 0 {name=p50887 lab=_65209_/X }
C {devices/lab_pin.sym} 51460 -17400 0 1 {name=p50888 lab=_65210_/X }
C {sky130_stdcells/a211o_4.sym} 51380 -17400 0 0 {name=X_65210_ }
C {devices/lab_pin.sym} 51340 -17250 0 0 {name=p50889 lab=_62336_/A }
C {devices/lab_pin.sym} 51420 -17250 0 1 {name=p50890 lab=_62479_/A }
C {sky130_stdcells/buf_2.sym} 51380 -17250 0 0 {name=X_62422_ }
C {devices/lab_pin.sym} 51320 -17140 0 0 {name=p50891 lab=_74408_/A }
C {devices/lab_pin.sym} 51320 -17100 0 0 {name=p50892 lab=_53663_/B }
C {devices/lab_pin.sym} 51440 -17120 0 1 {name=p50893 lab=_74408_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -17120 0 0 {name=X_74408_ }
C {devices/lab_pin.sym} 51340 -16990 0 0 {name=p50894 lab=_47355_/Y }
C {devices/lab_pin.sym} 51420 -16990 0 1 {name=p50895 lab=_53003_/D }
C {sky130_stdcells/buf_2.sym} 51380 -16990 0 0 {name=X_47356_ }
C {devices/lab_pin.sym} 51320 -16890 0 0 {name=p50896 lab=_65721_/X }
C {devices/lab_pin.sym} 51320 -16850 0 0 {name=p50897 lab=_66135_/B }
C {devices/lab_pin.sym} 51320 -16810 0 0 {name=p50898 lab=_65724_/X }
C {devices/lab_pin.sym} 51440 -16850 0 1 {name=p50899 lab=_66190_/Y }
C {sky130_stdcells/nand3_4.sym} 51380 -16850 0 0 {name=X_66190_ }
C {devices/lab_pin.sym} 51320 -16720 0 0 {name=p50900 lab=_78166_/Y }
C {devices/lab_pin.sym} 51320 -16680 0 0 {name=p50901 lab=_78175_/X }
C {devices/lab_pin.sym} 51440 -16700 0 1 {name=p50902 lab=_78176_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -16700 0 0 {name=X_78176_ }
C {devices/lab_pin.sym} 51340 -16570 0 0 {name=p50903 lab=_44549_/A }
C {devices/lab_pin.sym} 51420 -16570 0 1 {name=p50904 lab=_44568_/X }
C {sky130_stdcells/buf_2.sym} 51380 -16570 0 0 {name=X_44568_ }
C {devices/lab_pin.sym} 51300 -16470 0 0 {name=p50905 lab=_75351_/A }
C {devices/lab_pin.sym} 51300 -16430 0 0 {name=p50906 lab=_75354_/A }
C {devices/lab_pin.sym} 51300 -16390 0 0 {name=p50907 lab=_75362_/X }
C {devices/lab_pin.sym} 51460 -16430 0 1 {name=p50908 lab=_75404_/A }
C {sky130_stdcells/a21o_4.sym} 51380 -16430 0 0 {name=X_75388_ }
C {devices/lab_pin.sym} 51340 -16290 0 0 {name=p50909 lab=_48499_/A }
C {devices/lab_pin.sym} 51420 -16290 0 1 {name=p50910 lab=_46308_/A }
C {sky130_stdcells/buf_2.sym} 51380 -16290 0 0 {name=X_46307_ }
C {devices/lab_pin.sym} 51340 -16170 0 0 {name=p50911 lab=_84213_/Q }
C {devices/lab_pin.sym} 51420 -16170 0 1 {name=p50912 lab=_65142_/C }
C {sky130_stdcells/inv_2.sym} 51380 -16170 0 0 {name=X_65141_ }
C {devices/lab_pin.sym} 51320 -16060 0 0 {name=p50913 lab=_77127_/A }
C {devices/lab_pin.sym} 51320 -16020 0 0 {name=p50914 lab=_77127_/B }
C {devices/lab_pin.sym} 51440 -16040 0 1 {name=p50915 lab=_77127_/Y }
C {sky130_stdcells/nor2_4.sym} 51380 -16040 0 0 {name=X_77127_ }
C {devices/lab_pin.sym} 51300 -15950 0 0 {name=p50916 lab=_43518_/X }
C {devices/lab_pin.sym} 51300 -15910 0 0 {name=p50917 lab=_43503_/X }
C {devices/lab_pin.sym} 51300 -15870 0 0 {name=p50918 lab=_41791_/X }
C {devices/lab_pin.sym} 51300 -15830 0 0 {name=p50919 lab=_87380_/Q }
C {devices/lab_pin.sym} 51300 -15790 0 0 {name=p50920 lab=_43506_/X }
C {devices/lab_pin.sym} 51460 -15870 0 1 {name=p50921 lab=_43519_/Y }
C {sky130_stdcells/o32ai_4.sym} 51380 -15870 0 0 {name=X_43519_ }
C {devices/lab_pin.sym} 51320 -15730 0 0 {name=p50922 lab=_62342_/A }
C {devices/lab_pin.sym} 51320 -15690 0 0 {name=p50923 lab=_62341_/X }
C {devices/lab_pin.sym} 51320 -15650 0 0 {name=p50924 lab=_84416_/Q }
C {devices/lab_pin.sym} 51440 -15690 0 1 {name=p50925 lab=_62353_/Y }
C {sky130_stdcells/nor3_4.sym} 51380 -15690 0 0 {name=X_62353_ }
C {devices/lab_pin.sym} 51300 -15570 0 0 {name=p50926 lab=_70326_/A }
C {devices/lab_pin.sym} 51300 -15530 0 0 {name=p50927 lab=_74327_/X }
C {devices/lab_pin.sym} 51300 -15490 0 0 {name=p50928 lab=_74338_/Y }
C {devices/lab_pin.sym} 51460 -15530 0 1 {name=p50929 lab=_74339_/X }
C {sky130_stdcells/a21bo_4.sym} 51380 -15530 0 0 {name=X_74339_ }
C {devices/lab_pin.sym} 51340 -15390 0 0 {name=p50930 lab=_47147_/A }
C {devices/lab_pin.sym} 51420 -15390 0 1 {name=p50931 lab=_47287_/X }
C {sky130_stdcells/buf_2.sym} 51380 -15390 0 0 {name=X_47287_ }
C {devices/lab_pin.sym} 51300 -15310 0 0 {name=p50932 lab=_44496_/X }
C {devices/lab_pin.sym} 51300 -15270 0 0 {name=p50933 lab=_44497_/X }
C {devices/lab_pin.sym} 51300 -15230 0 0 {name=p50934 lab=_41244_/X }
C {devices/lab_pin.sym} 51300 -15190 0 0 {name=p50935 lab=_87079_/Q }
C {devices/lab_pin.sym} 51300 -15150 0 0 {name=p50936 lab=_44498_/X }
C {devices/lab_pin.sym} 51460 -15230 0 1 {name=p50937 lab=_44500_/A }
C {sky130_stdcells/o32ai_4.sym} 51380 -15230 0 0 {name=X_44499_ }
C {devices/lab_pin.sym} 51320 -15080 0 0 {name=p50938 lab=_49007_/A }
C {devices/lab_pin.sym} 51320 -15040 0 0 {name=p50939 lab=_49025_/X }
C {devices/lab_pin.sym} 51440 -15060 0 1 {name=p50940 lab=_49026_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -15060 0 0 {name=X_49026_ }
C {devices/lab_pin.sym} 51340 -14930 0 0 {name=p50941 lab=_72563_/C }
C {devices/lab_pin.sym} 51420 -14930 0 1 {name=p50942 lab=_72583_/C }
C {sky130_stdcells/buf_2.sym} 51380 -14930 0 0 {name=X_61304_ }
C {devices/lab_pin.sym} 51340 -14810 0 0 {name=p50943 lab=_73939_/A }
C {devices/lab_pin.sym} 51420 -14810 0 1 {name=p50944 lab=_86754_/D }
C {sky130_stdcells/buf_2.sym} 51380 -14810 0 0 {name=X_46238_ }
C {devices/lab_pin.sym} 51320 -14710 0 0 {name=p50945 lab=_65047_/A }
C {devices/lab_pin.sym} 51320 -14670 0 0 {name=p50946 lab=_65047_/B }
C {devices/lab_pin.sym} 51320 -14630 0 0 {name=p50947 lab=_65072_/C }
C {devices/lab_pin.sym} 51440 -14670 0 1 {name=p50948 lab=_65072_/Y }
C {sky130_stdcells/nor3_4.sym} 51380 -14670 0 0 {name=X_65072_ }
C {devices/lab_pin.sym} 51320 -14540 0 0 {name=p50949 lab=_77052_/Y }
C {devices/lab_pin.sym} 51320 -14500 0 0 {name=p50950 lab=_77057_/X }
C {devices/lab_pin.sym} 51440 -14520 0 1 {name=p50951 lab=_77068_/A }
C {sky130_stdcells/nand2_4.sym} 51380 -14520 0 0 {name=X_77058_ }
C {devices/lab_pin.sym} 51300 -14410 0 0 {name=p50952 lab=_62282_/Y }
C {devices/lab_pin.sym} 51300 -14370 0 0 {name=p50953 lab=_62253_/X }
C {devices/lab_pin.sym} 51300 -14330 0 0 {name=p50954 lab=_62283_/Y }
C {devices/lab_pin.sym} 51460 -14370 0 1 {name=p50955 lab=_62284_/Y }
C {sky130_stdcells/a21oi_4.sym} 51380 -14370 0 0 {name=X_62284_ }
C {devices/lab_pin.sym} 51340 -14230 0 0 {name=p50956 lab=clkbuf_7_71_0_CLK/X }
C {devices/lab_pin.sym} 51420 -14230 0 1 {name=p50957 lab=clkbuf_9_286_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 51380 -14230 0 0 {name=Xclkbuf_8_143_0_CLK }
C {devices/lab_pin.sym} 51300 -14130 0 0 {name=p50958 lab=_68897_/X }
C {devices/lab_pin.sym} 51300 -14090 0 0 {name=p50959 lab=_68899_/X }
C {devices/lab_pin.sym} 51300 -14050 0 0 {name=p50960 lab=_68806_/X }
C {devices/lab_pin.sym} 51460 -14090 0 1 {name=p50961 lab=_68900_/X }
C {sky130_stdcells/a21o_4.sym} 51380 -14090 0 0 {name=X_68900_ }
C {devices/lab_pin.sym} 51300 -13970 0 0 {name=p50962 lab=_64021_/X }
C {devices/lab_pin.sym} 51300 -13930 0 0 {name=p50963 lab=_63994_/X }
C {devices/lab_pin.sym} 51300 -13890 0 0 {name=p50964 lab=_64022_/Y }
C {devices/lab_pin.sym} 51460 -13930 0 1 {name=p50965 lab=_64023_/Y }
C {sky130_stdcells/a21oi_4.sym} 51380 -13930 0 0 {name=X_64023_ }
C {devices/lab_pin.sym} 51320 -13800 0 0 {name=p50966 lab=_76009_/A }
C {devices/lab_pin.sym} 51320 -13760 0 0 {name=p50967 lab=_76009_/B }
C {devices/lab_pin.sym} 51440 -13780 0 1 {name=p50968 lab=_76009_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -13780 0 0 {name=X_76009_ }
C {devices/lab_pin.sym} 51300 -13690 0 0 {name=p50969 lab=_61264_/B }
C {devices/lab_pin.sym} 51300 -13650 0 0 {name=p50970 lab=_61149_/X }
C {devices/lab_pin.sym} 51300 -13610 0 0 {name=p50971 lab=_61215_/Y }
C {devices/lab_pin.sym} 51300 -13570 0 0 {name=p50972 lab=_61264_/A }
C {devices/lab_pin.sym} 51300 -13540 0 0 {name=p50973 lab=_61234_/Y }
C {devices/lab_pin.sym} 51460 -13610 0 1 {name=p50974 lab=_61235_/Y }
C {sky130_stdcells/a41oi_4.sym} 51380 -13610 0 0 {name=X_61235_ }
C {devices/lab_pin.sym} 51320 -13470 0 0 {name=p50975 lab=_46166_/A }
C {devices/lab_pin.sym} 51320 -13430 0 0 {name=p50976 lab=_46128_/D }
C {devices/lab_pin.sym} 51320 -13390 0 0 {name=p50977 lab=_46169_/C }
C {devices/lab_pin.sym} 51440 -13430 0 1 {name=p50978 lab=_46169_/Y }
C {sky130_stdcells/nand3_4.sym} 51380 -13430 0 0 {name=X_46169_ }
C {devices/lab_pin.sym} 51300 -13320 0 0 {name=p50979 lab=_69461_/Y }
C {devices/lab_pin.sym} 51300 -13280 0 0 {name=p50980 lab=_69732_/X }
C {devices/lab_pin.sym} 51300 -13240 0 0 {name=p50981 lab=_69870_/X }
C {devices/lab_pin.sym} 51300 -13200 0 0 {name=p50982 lab=_69879_/Y }
C {devices/lab_pin.sym} 51460 -13260 0 1 {name=p50983 lab=_69880_/X }
C {sky130_stdcells/a211o_4.sym} 51380 -13260 0 0 {name=X_69880_ }
C {devices/lab_pin.sym} 51300 -13130 0 0 {name=p50984 lab=_68827_/X }
C {devices/lab_pin.sym} 51300 -13090 0 0 {name=p50985 lab=_68830_/X }
C {devices/lab_pin.sym} 51300 -13050 0 0 {name=p50986 lab=_68806_/X }
C {devices/lab_pin.sym} 51460 -13090 0 1 {name=p50987 lab=_68831_/X }
C {sky130_stdcells/a21o_4.sym} 51380 -13090 0 0 {name=X_68831_ }
C {devices/lab_pin.sym} 51300 -12990 0 0 {name=p50988 lab=_61160_/Y }
C {devices/lab_pin.sym} 51300 -12950 0 0 {name=p50989 lab=_61162_/X }
C {devices/lab_pin.sym} 51300 -12910 0 0 {name=p50990 lab=_61254_/B }
C {devices/lab_pin.sym} 51300 -12870 0 0 {name=p50991 lab=_61163_/Y }
C {devices/lab_pin.sym} 51300 -12840 0 0 {name=p50992 lab=_61165_/Y }
C {devices/lab_pin.sym} 51460 -12910 0 1 {name=p50993 lab=_84516_/D }
C {sky130_stdcells/a41oi_4.sym} 51380 -12910 0 0 {name=X_61166_ }
C {devices/lab_pin.sym} 51340 -12750 0 0 {name=p50994 lab=clkbuf_6_9_0_CLK/X }
C {devices/lab_pin.sym} 51420 -12750 0 1 {name=p50995 lab=clkbuf_8_37_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 51380 -12750 0 0 {name=Xclkbuf_7_18_0_CLK }
C {devices/lab_pin.sym} 51340 -12630 0 0 {name=p50996 lab=_62193_/A }
C {devices/lab_pin.sym} 51420 -12630 0 1 {name=p50997 lab=_62244_/D }
C {sky130_stdcells/buf_2.sym} 51380 -12630 0 0 {name=X_60117_ }
C {devices/lab_pin.sym} 51320 -12520 0 0 {name=p50998 lab=_49928_/A }
C {devices/lab_pin.sym} 51320 -12480 0 0 {name=p50999 lab=_53141_/B }
C {devices/lab_pin.sym} 51440 -12500 0 1 {name=p51000 lab=_49928_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -12500 0 0 {name=X_49928_ }
C {devices/lab_pin.sym} 51340 -12370 0 0 {name=p51001 lab=_68993_/A }
C {devices/lab_pin.sym} 51420 -12370 0 1 {name=p51002 lab=_68762_/X }
C {sky130_stdcells/buf_2.sym} 51380 -12370 0 0 {name=X_68762_ }
C {devices/lab_pin.sym} 51340 -12250 0 0 {name=p51003 lab=_44174_/A }
C {devices/lab_pin.sym} 51420 -12250 0 1 {name=p51004 lab=_68347_/A }
C {sky130_stdcells/buf_2.sym} 51380 -12250 0 0 {name=X_65974_ }
C {devices/lab_pin.sym} 51340 -12130 0 0 {name=p51005 lab=_61096_/X }
C {devices/lab_pin.sym} 51420 -12130 0 1 {name=p51006 lab=_61097_/X }
C {sky130_stdcells/buf_2.sym} 51380 -12130 0 0 {name=X_61097_ }
C {devices/lab_pin.sym} 51340 -12010 0 0 {name=p51007 lab=clkbuf_7_79_0_CLK/X }
C {devices/lab_pin.sym} 51420 -12010 0 1 {name=p51008 lab=clkbuf_8_158_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 51380 -12010 0 0 {name=Xclkbuf_8_158_0_CLK }
C {devices/lab_pin.sym} 51340 -11890 0 0 {name=p51009 lab=clkbuf_9_76_0_CLK/X }
C {devices/lab_pin.sym} 51420 -11890 0 1 {name=p51010 lab=_81275_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 51380 -11890 0 0 {name=Xclkbuf_10_153_0_CLK }
C {devices/lab_pin.sym} 51340 -11770 0 0 {name=p51011 lab=_67354_/X }
C {devices/lab_pin.sym} 51420 -11770 0 1 {name=p51012 lab=_67713_/X }
C {sky130_stdcells/buf_2.sym} 51380 -11770 0 0 {name=X_67713_ }
C {devices/lab_pin.sym} 51300 -11680 0 0 {name=p51013 lab=_64797_/X }
C {devices/lab_pin.sym} 51300 -11640 0 0 {name=p51014 lab=_86741_/Q }
C {devices/lab_pin.sym} 51300 -11600 0 0 {name=p51015 lab=_64772_/X }
C {devices/lab_pin.sym} 51300 -11560 0 0 {name=p51016 lab=_64924_/X }
C {devices/lab_pin.sym} 51460 -11620 0 1 {name=p51017 lab=_64926_/B }
C {sky130_stdcells/a211o_4.sym} 51380 -11620 0 0 {name=X_64925_ }
C {devices/lab_pin.sym} 51300 -11510 0 0 {name=p51018 lab=_59727_/X }
C {devices/lab_pin.sym} 51300 -11470 0 0 {name=p51019 lab=_60059_/A }
C {devices/lab_pin.sym} 51300 -11430 0 0 {name=p51020 lab=_60044_/Y }
C {devices/lab_pin.sym} 51300 -11390 0 0 {name=p51021 lab=_60045_/Y }
C {devices/lab_pin.sym} 51300 -11360 0 0 {name=p51022 lab=_60047_/Y }
C {devices/lab_pin.sym} 51460 -11430 0 1 {name=p51023 lab=_84671_/D }
C {sky130_stdcells/a41oi_4.sym} 51380 -11430 0 0 {name=X_60048_ }
C {devices/lab_pin.sym} 51320 -11280 0 0 {name=p51024 lab=_49864_/A }
C {devices/lab_pin.sym} 51320 -11240 0 0 {name=p51025 lab=_53072_/B }
C {devices/lab_pin.sym} 51440 -11260 0 1 {name=p51026 lab=_49859_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -11260 0 0 {name=X_49859_ }
C {devices/lab_pin.sym} 51290 -11130 0 0 {name=p51027 lab=_80931_/CLK }
C {devices/lab_pin.sym} 51290 -11110 0 0 {name=p51028 lab=_75655_/X }
C {devices/lab_pin.sym} 51470 -11130 0 1 {name=p51029 lab=_80959_/D }
C {sky130_stdcells/dfxtp_4.sym} 51380 -11120 0 0 {name=X_80971_ }
C {devices/lab_pin.sym} 51320 -11000 0 0 {name=p51030 lab=_68587_/X }
C {devices/lab_pin.sym} 51320 -10960 0 0 {name=p51031 lab=_68693_/B }
C {devices/lab_pin.sym} 51440 -10980 0 1 {name=p51032 lab=_68693_/Y }
C {sky130_stdcells/nor2_4.sym} 51380 -10980 0 0 {name=X_68693_ }
C {devices/lab_pin.sym} 51340 -10850 0 0 {name=p51033 lab=clkbuf_9_391_0_CLK/X }
C {devices/lab_pin.sym} 51420 -10850 0 1 {name=p51034 lab=_82491_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 51380 -10850 0 0 {name=Xclkbuf_10_783_0_CLK }
C {devices/lab_pin.sym} 51290 -10730 0 0 {name=p51035 lab=_82803_/CLK }
C {devices/lab_pin.sym} 51290 -10710 0 0 {name=p51036 lab=_82710_/D }
C {devices/lab_pin.sym} 51470 -10730 0 1 {name=p51037 lab=_82710_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -10720 0 0 {name=X_82710_ }
C {devices/lab_pin.sym} 51320 -10600 0 0 {name=p51038 lab=_67615_/X }
C {devices/lab_pin.sym} 51320 -10560 0 0 {name=p51039 lab=_67644_/B }
C {devices/lab_pin.sym} 51440 -10580 0 1 {name=p51040 lab=_67644_/X }
C {sky130_stdcells/and2_4.sym} 51380 -10580 0 0 {name=X_67644_ }
C {devices/lab_pin.sym} 51300 -10470 0 0 {name=p51041 lab=_85739_/Q }
C {devices/lab_pin.sym} 51300 -10430 0 0 {name=p51042 lab=_52848_/X }
C {devices/lab_pin.sym} 51300 -10390 0 0 {name=p51043 lab=_52869_/Y }
C {devices/lab_pin.sym} 51460 -10430 0 1 {name=p51044 lab=_52870_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -10430 0 0 {name=X_52870_ }
C {devices/lab_pin.sym} 51320 -10300 0 0 {name=p51045 lab=_64778_/A }
C {devices/lab_pin.sym} 51320 -10260 0 0 {name=p51046 lab=_85816_/Q }
C {devices/lab_pin.sym} 51440 -10280 0 1 {name=p51047 lab=_64856_/X }
C {sky130_stdcells/and2_4.sym} 51380 -10280 0 0 {name=X_64856_ }
C {devices/lab_pin.sym} 51290 -10150 0 0 {name=p51048 lab=_83690_/CLK }
C {devices/lab_pin.sym} 51290 -10130 0 0 {name=p51049 lab=_83690_/D }
C {devices/lab_pin.sym} 51470 -10150 0 1 {name=p51050 lab=_47212_/A }
C {sky130_stdcells/dfxtp_4.sym} 51380 -10140 0 0 {name=X_83690_ }
C {devices/lab_pin.sym} 51340 -10010 0 0 {name=p51051 lab=clkbuf_9_274_0_CLK/A }
C {devices/lab_pin.sym} 51420 -10010 0 1 {name=p51052 lab=clkbuf_9_274_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 51380 -10010 0 0 {name=Xclkbuf_9_274_0_CLK }
C {devices/lab_pin.sym} 51300 -9910 0 0 {name=p51053 lab=_85940_/Q }
C {devices/lab_pin.sym} 51300 -9870 0 0 {name=p51054 lab=_51817_/X }
C {devices/lab_pin.sym} 51300 -9830 0 0 {name=p51055 lab=_51820_/Y }
C {devices/lab_pin.sym} 51460 -9870 0 1 {name=p51056 lab=_51821_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -9870 0 0 {name=X_51821_ }
C {devices/lab_pin.sym} 51340 -9730 0 0 {name=p51057 lab=_60906_/X }
C {devices/lab_pin.sym} 51420 -9730 0 1 {name=p51058 lab=_63858_/C }
C {sky130_stdcells/buf_2.sym} 51380 -9730 0 0 {name=X_63807_ }
C {devices/lab_pin.sym} 51290 -9610 0 0 {name=p51059 lab=_82896_/CLK }
C {devices/lab_pin.sym} 51290 -9590 0 0 {name=p51060 lab=_83993_/Q }
C {devices/lab_pin.sym} 51470 -9610 0 1 {name=p51061 lab=_78940_/A }
C {sky130_stdcells/dfxtp_4.sym} 51380 -9600 0 0 {name=X_82641_ }
C {devices/lab_pin.sym} 51320 -9480 0 0 {name=p51062 lab=_67575_/A }
C {devices/lab_pin.sym} 51320 -9440 0 0 {name=p51063 lab=_67575_/B }
C {devices/lab_pin.sym} 51440 -9460 0 1 {name=p51064 lab=_67575_/X }
C {sky130_stdcells/and2_4.sym} 51380 -9460 0 0 {name=X_67575_ }
C {devices/lab_pin.sym} 51300 -9350 0 0 {name=p51065 lab=_60151_/X }
C {devices/lab_pin.sym} 51300 -9310 0 0 {name=p51066 lab=_64775_/Y }
C {devices/lab_pin.sym} 51300 -9270 0 0 {name=p51067 lab=_64786_/Y }
C {devices/lab_pin.sym} 51460 -9310 0 1 {name=p51068 lab=_64787_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -9310 0 0 {name=X_64787_ }
C {devices/lab_pin.sym} 51340 -9170 0 0 {name=p51069 lab=clkbuf_9_84_0_CLK/X }
C {devices/lab_pin.sym} 51420 -9170 0 1 {name=p51070 lab=_81682_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 51380 -9170 0 0 {name=Xclkbuf_10_168_0_CLK }
C {devices/lab_pin.sym} 51320 -9080 0 0 {name=p51071 lab=_61997_/X }
C {devices/lab_pin.sym} 51320 -9040 0 0 {name=p51072 lab=_61999_/B }
C {devices/lab_pin.sym} 51320 -9000 0 0 {name=p51073 lab=_61971_/C }
C {devices/lab_pin.sym} 51320 -8960 0 0 {name=p51074 lab=_61971_/D }
C {devices/lab_pin.sym} 51440 -9020 0 1 {name=p51075 lab=_62000_/D }
C {sky130_stdcells/nand4_4.sym} 51380 -9020 0 0 {name=X_61999_ }
C {devices/lab_pin.sym} 51300 -8890 0 0 {name=p51076 lab=_83933_/Q }
C {devices/lab_pin.sym} 51300 -8850 0 0 {name=p51077 lab=_69299_/X }
C {devices/lab_pin.sym} 51300 -8810 0 0 {name=p51078 lab=_69313_/X }
C {devices/lab_pin.sym} 51460 -8850 0 1 {name=p51079 lab=_69314_/X }
C {sky130_stdcells/a21bo_4.sym} 51380 -8850 0 0 {name=X_69314_ }
C {devices/lab_pin.sym} 51340 -8710 0 0 {name=p51080 lab=_54540_/A }
C {devices/lab_pin.sym} 51420 -8710 0 1 {name=p51081 lab=_54540_/X }
C {sky130_stdcells/buf_2.sym} 51380 -8710 0 0 {name=X_54540_ }
C {devices/lab_pin.sym} 51340 -8590 0 0 {name=p51082 lab=_60371_/A }
C {devices/lab_pin.sym} 51420 -8590 0 1 {name=p51083 lab=_66526_/X }
C {sky130_stdcells/buf_2.sym} 51380 -8590 0 0 {name=X_66526_ }
C {devices/lab_pin.sym} 51290 -8470 0 0 {name=p51084 lab=_86289_/CLK }
C {devices/lab_pin.sym} 51290 -8450 0 0 {name=p51085 lab=_85360_/D }
C {devices/lab_pin.sym} 51470 -8470 0 1 {name=p51086 lab=_85360_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -8460 0 0 {name=X_85360_ }
C {devices/lab_pin.sym} 51340 -8330 0 0 {name=p51087 lab=clkbuf_9_399_0_CLK/X }
C {devices/lab_pin.sym} 51420 -8330 0 1 {name=p51088 lab=_81216_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 51380 -8330 0 0 {name=Xclkbuf_10_798_0_CLK }
C {devices/lab_pin.sym} 51320 -8220 0 0 {name=p51089 lab=_51758_/A }
C {devices/lab_pin.sym} 51320 -8180 0 0 {name=p51090 lab=_46625_/X }
C {devices/lab_pin.sym} 51440 -8200 0 1 {name=p51091 lab=_51752_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -8200 0 0 {name=X_51752_ }
C {devices/lab_pin.sym} 51320 -8100 0 0 {name=p51092 lab=_84729_/Q }
C {devices/lab_pin.sym} 51320 -8060 0 0 {name=p51093 lab=_63738_/B }
C {devices/lab_pin.sym} 51320 -8020 0 0 {name=p51094 lab=_63738_/C }
C {devices/lab_pin.sym} 51320 -7980 0 0 {name=p51095 lab=_63738_/D }
C {devices/lab_pin.sym} 51440 -8040 0 1 {name=p51096 lab=_63738_/Y }
C {sky130_stdcells/nand4_4.sym} 51380 -8040 0 0 {name=X_63738_ }
C {devices/lab_pin.sym} 51290 -7890 0 0 {name=p51097 lab=_82604_/CLK }
C {devices/lab_pin.sym} 51290 -7870 0 0 {name=p51098 lab=_82572_/D }
C {devices/lab_pin.sym} 51470 -7890 0 1 {name=p51099 lab=_78145_/A }
C {sky130_stdcells/dfxtp_4.sym} 51380 -7880 0 0 {name=X_82572_ }
C {devices/lab_pin.sym} 51290 -7750 0 0 {name=p51100 lab=_84308_/CLK }
C {devices/lab_pin.sym} 51290 -7730 0 0 {name=p51101 lab=_63593_/Y }
C {devices/lab_pin.sym} 51470 -7750 0 1 {name=p51102 lab=_84311_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -7740 0 0 {name=X_84311_ }
C {devices/lab_pin.sym} 51300 -7630 0 0 {name=p51103 lab=_86150_/Q }
C {devices/lab_pin.sym} 51300 -7590 0 0 {name=p51104 lab=_50680_/X }
C {devices/lab_pin.sym} 51300 -7550 0 0 {name=p51105 lab=_50702_/Y }
C {devices/lab_pin.sym} 51460 -7590 0 1 {name=p51106 lab=_50703_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -7590 0 0 {name=X_50703_ }
C {devices/lab_pin.sym} 51290 -7450 0 0 {name=p51107 lab=_81514_/CLK }
C {devices/lab_pin.sym} 51290 -7430 0 0 {name=p51108 lab=_81567_/Q }
C {devices/lab_pin.sym} 51470 -7450 0 1 {name=p51109 lab=_81523_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -7440 0 0 {name=X_81523_ }
C {devices/lab_pin.sym} 51340 -7310 0 0 {name=p51110 lab=_69245_/A }
C {devices/lab_pin.sym} 51420 -7310 0 1 {name=p51111 lab=_69245_/X }
C {sky130_stdcells/buf_2.sym} 51380 -7310 0 0 {name=X_69245_ }
C {devices/lab_pin.sym} 51320 -7220 0 0 {name=p51112 lab=_54453_/X }
C {devices/lab_pin.sym} 51320 -7180 0 0 {name=p51113 lab=_54471_/B }
C {devices/lab_pin.sym} 51320 -7140 0 0 {name=p51114 lab=_54471_/C }
C {devices/lab_pin.sym} 51320 -7100 0 0 {name=p51115 lab=_46971_/Y }
C {devices/lab_pin.sym} 51440 -7160 0 1 {name=p51116 lab=_54471_/X }
C {sky130_stdcells/and4_4.sym} 51380 -7160 0 0 {name=X_54471_ }
C {devices/lab_pin.sym} 51340 -7010 0 0 {name=p51117 lab=_82735_/D }
C {devices/lab_pin.sym} 51420 -7010 0 1 {name=p51118 lab=_66457_/Y }
C {sky130_stdcells/inv_2.sym} 51380 -7010 0 0 {name=X_66457_ }
C {devices/lab_pin.sym} 51290 -6890 0 0 {name=p51119 lab=_80670_/CLK }
C {devices/lab_pin.sym} 51290 -6870 0 0 {name=p51120 lab=_85291_/D }
C {devices/lab_pin.sym} 51470 -6890 0 1 {name=p51121 lab=_85291_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -6880 0 0 {name=X_85291_ }
C {devices/lab_pin.sym} 51340 -6750 0 0 {name=p51122 lab=clkbuf_8_144_0_CLK/X }
C {devices/lab_pin.sym} 51420 -6750 0 1 {name=p51123 lab=clkbuf_9_289_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 51380 -6750 0 0 {name=Xclkbuf_9_289_0_CLK }
C {devices/lab_pin.sym} 51340 -6630 0 0 {name=p51124 lab=_52593_/A }
C {devices/lab_pin.sym} 51420 -6630 0 1 {name=p51125 lab=_51695_/A }
C {sky130_stdcells/buf_2.sym} 51380 -6630 0 0 {name=X_51683_ }
C {devices/lab_pin.sym} 51300 -6550 0 0 {name=p51126 lab=_63665_/Y }
C {devices/lab_pin.sym} 51300 -6510 0 0 {name=p51127 lab=_63666_/X }
C {devices/lab_pin.sym} 51300 -6470 0 0 {name=p51128 lab=_63668_/X }
C {devices/lab_pin.sym} 51300 -6430 0 0 {name=p51129 lab=_58352_/A }
C {devices/lab_pin.sym} 51300 -6390 0 0 {name=p51130 lab=_63363_/X }
C {devices/lab_pin.sym} 51460 -6470 0 1 {name=p51131 lab=_63669_/Y }
C {sky130_stdcells/o32ai_4.sym} 51380 -6470 0 0 {name=X_63669_ }
C {devices/lab_pin.sym} 51340 -6310 0 0 {name=p51132 lab=_56194_/X }
C {devices/lab_pin.sym} 51420 -6310 0 1 {name=p51133 lab=_56210_/X }
C {sky130_stdcells/buf_2.sym} 51380 -6310 0 0 {name=X_56210_ }
C {devices/lab_pin.sym} 51290 -6190 0 0 {name=p51134 lab=_88301_/CLK }
C {devices/lab_pin.sym} 51290 -6170 0 0 {name=p51135 lab=_87030_/D }
C {devices/lab_pin.sym} 51470 -6190 0 1 {name=p51136 lab=_87030_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -6180 0 0 {name=X_87030_ }
C {devices/lab_pin.sym} 51320 -6060 0 0 {name=p51137 lab=_53405_/X }
C {devices/lab_pin.sym} 51320 -6020 0 0 {name=p51138 lab=_47195_/A }
C {devices/lab_pin.sym} 51440 -6040 0 1 {name=p51139 lab=_53422_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -6040 0 0 {name=X_53422_ }
C {devices/lab_pin.sym} 51320 -5920 0 0 {name=p51140 lab=_65408_/A }
C {devices/lab_pin.sym} 51320 -5880 0 0 {name=p51141 lab=_86434_/Q }
C {devices/lab_pin.sym} 51440 -5900 0 1 {name=p51142 lab=_65408_/X }
C {sky130_stdcells/and2_4.sym} 51380 -5900 0 0 {name=X_65408_ }
C {devices/lab_pin.sym} 51290 -5770 0 0 {name=p51143 lab=_84241_/CLK }
C {devices/lab_pin.sym} 51290 -5750 0 0 {name=p51144 lab=_64482_/Y }
C {devices/lab_pin.sym} 51470 -5770 0 1 {name=p51145 lab=_79637_/B }
C {sky130_stdcells/dfxtp_4.sym} 51380 -5760 0 0 {name=X_84242_ }
C {devices/lab_pin.sym} 51320 -5640 0 0 {name=p51146 lab=_50624_/A }
C {devices/lab_pin.sym} 51320 -5600 0 0 {name=p51147 lab=_53854_/B }
C {devices/lab_pin.sym} 51440 -5620 0 1 {name=p51148 lab=_50634_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -5620 0 0 {name=X_50634_ }
C {devices/lab_pin.sym} 51340 -5490 0 0 {name=p51149 lab=_57189_/Y }
C {devices/lab_pin.sym} 51420 -5490 0 1 {name=p51150 lab=_57190_/Y }
C {sky130_stdcells/inv_2.sym} 51380 -5490 0 0 {name=X_57190_ }
C {devices/lab_pin.sym} 51290 -5370 0 0 {name=p51151 lab=_81492_/CLK }
C {devices/lab_pin.sym} 51290 -5350 0 0 {name=p51152 lab=_76764_/B }
C {devices/lab_pin.sym} 51470 -5370 0 1 {name=p51153 lab=_81454_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -5360 0 0 {name=X_81454_ }
C {devices/lab_pin.sym} 51320 -5240 0 0 {name=p51154 lab=_69021_/A }
C {devices/lab_pin.sym} 51320 -5200 0 0 {name=p51155 lab=_69176_/B }
C {devices/lab_pin.sym} 51440 -5220 0 1 {name=p51156 lab=_69176_/X }
C {sky130_stdcells/and2_4.sym} 51380 -5220 0 0 {name=X_69176_ }
C {devices/lab_pin.sym} 51340 -5090 0 0 {name=p51157 lab=_79455_/B }
C {devices/lab_pin.sym} 51420 -5090 0 1 {name=p51158 lab=_66389_/C }
C {sky130_stdcells/inv_2.sym} 51380 -5090 0 0 {name=X_66388_ }
C {devices/lab_pin.sym} 51340 -4970 0 0 {name=p51159 lab=clkbuf_9_360_0_CLK/X }
C {devices/lab_pin.sym} 51420 -4970 0 1 {name=p51160 lab=_88283_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 51380 -4970 0 0 {name=Xclkbuf_10_721_0_CLK }
C {devices/lab_pin.sym} 51300 -4870 0 0 {name=p51161 lab=_56112_/X }
C {devices/lab_pin.sym} 51300 -4830 0 0 {name=p51162 lab=_56139_/X }
C {devices/lab_pin.sym} 51300 -4790 0 0 {name=p51163 lab=_56140_/Y }
C {devices/lab_pin.sym} 51460 -4830 0 1 {name=p51164 lab=_56141_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -4830 0 0 {name=X_56141_ }
C {devices/lab_pin.sym} 51320 -4700 0 0 {name=p51165 lab=_80406_/B }
C {devices/lab_pin.sym} 51320 -4660 0 0 {name=p51166 lab=_80406_/A }
C {devices/lab_pin.sym} 51440 -4680 0 1 {name=p51167 lab=_80405_/X }
C {sky130_stdcells/or2_4.sym} 51380 -4680 0 0 {name=X_80405_ }
C {devices/lab_pin.sym} 51300 -4570 0 0 {name=p51168 lab=_82072_/D }
C {devices/lab_pin.sym} 51300 -4530 0 0 {name=p51169 lab=_68120_/X }
C {devices/lab_pin.sym} 51300 -4490 0 0 {name=p51170 lab=_68126_/X }
C {devices/lab_pin.sym} 51460 -4530 0 1 {name=p51171 lab=_68127_/X }
C {sky130_stdcells/a21bo_4.sym} 51380 -4530 0 0 {name=X_68127_ }
C {devices/lab_pin.sym} 51320 -4400 0 0 {name=p51172 lab=_53353_/A }
C {devices/lab_pin.sym} 51320 -4360 0 0 {name=p51173 lab=_53353_/B }
C {devices/lab_pin.sym} 51440 -4380 0 1 {name=p51174 lab=_53353_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -4380 0 0 {name=X_53353_ }
C {devices/lab_pin.sym} 51300 -4270 0 0 {name=p51175 lab=_65336_/X }
C {devices/lab_pin.sym} 51300 -4230 0 0 {name=p51176 lab=_65338_/X }
C {devices/lab_pin.sym} 51300 -4190 0 0 {name=p51177 lab=_65287_/X }
C {devices/lab_pin.sym} 51460 -4230 0 1 {name=p51178 lab=_65339_/X }
C {sky130_stdcells/a21o_4.sym} 51380 -4230 0 0 {name=X_65339_ }
C {devices/lab_pin.sym} 51290 -4090 0 0 {name=p51179 lab=_82746_/CLK }
C {devices/lab_pin.sym} 51290 -4070 0 0 {name=p51180 lab=_84173_/D }
C {devices/lab_pin.sym} 51470 -4090 0 1 {name=p51181 lab=_65855_/C }
C {sky130_stdcells/dfxtp_4.sym} 51380 -4080 0 0 {name=X_84173_ }
C {devices/lab_pin.sym} 51320 -3960 0 0 {name=p51182 lab=_50607_/A }
C {devices/lab_pin.sym} 51320 -3920 0 0 {name=p51183 lab=_48889_/B }
C {devices/lab_pin.sym} 51440 -3940 0 1 {name=p51184 lab=_50565_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -3940 0 0 {name=X_50565_ }
C {devices/lab_pin.sym} 51340 -3810 0 0 {name=p51185 lab=_71216_/A }
C {devices/lab_pin.sym} 51420 -3810 0 1 {name=p51186 lab=_71236_/A2 }
C {sky130_stdcells/buf_2.sym} 51380 -3810 0 0 {name=Xpsn_inst_psn_buff_6 }
C {devices/lab_pin.sym} 51290 -3690 0 0 {name=p51187 lab=_83932_/CLK }
C {devices/lab_pin.sym} 51290 -3670 0 0 {name=p51188 lab=_81385_/D }
C {devices/lab_pin.sym} 51470 -3690 0 1 {name=p51189 lab=_76857_/B }
C {sky130_stdcells/dfxtp_4.sym} 51380 -3680 0 0 {name=X_81385_ }
C {devices/lab_pin.sym} 51340 -3550 0 0 {name=p51190 lab=clkbuf_8_106_0_CLK/X }
C {devices/lab_pin.sym} 51420 -3550 0 1 {name=p51191 lab=clkbuf_9_212_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 51380 -3550 0 0 {name=Xclkbuf_9_212_0_CLK }
C {devices/lab_pin.sym} 51300 -3450 0 0 {name=p51192 lab=_64826_/B }
C {devices/lab_pin.sym} 51300 -3410 0 0 {name=p51193 lab=_52297_/X }
C {devices/lab_pin.sym} 51300 -3370 0 0 {name=p51194 lab=_52303_/Y }
C {devices/lab_pin.sym} 51460 -3410 0 1 {name=p51195 lab=_52304_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -3410 0 0 {name=X_52304_ }
C {devices/lab_pin.sym} 51290 -3270 0 0 {name=p51196 lab=_83145_/CLK }
C {devices/lab_pin.sym} 51290 -3250 0 0 {name=p51197 lab=_74070_/Y }
C {devices/lab_pin.sym} 51470 -3270 0 1 {name=p51198 lab=_83124_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -3260 0 0 {name=X_83124_ }
C {devices/lab_pin.sym} 51320 -3150 0 0 {name=p51199 lab=_80336_/A }
C {devices/lab_pin.sym} 51320 -3110 0 0 {name=p51200 lab=_80329_/Y }
C {devices/lab_pin.sym} 51320 -3070 0 0 {name=p51201 lab=_80330_/Y }
C {devices/lab_pin.sym} 51440 -3110 0 1 {name=p51202 lab=_80336_/Y }
C {sky130_stdcells/nand3_4.sym} 51380 -3110 0 0 {name=X_80336_ }
C {devices/lab_pin.sym} 51300 -2990 0 0 {name=p51203 lab=_56058_/X }
C {devices/lab_pin.sym} 51300 -2950 0 0 {name=p51204 lab=_56070_/X }
C {devices/lab_pin.sym} 51300 -2910 0 0 {name=p51205 lab=_56071_/Y }
C {devices/lab_pin.sym} 51460 -2950 0 1 {name=p51206 lab=_56072_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -2950 0 0 {name=X_56072_ }
C {devices/lab_pin.sym} 51340 -2810 0 0 {name=p51207 lab=_68377_/A }
C {devices/lab_pin.sym} 51420 -2810 0 1 {name=p51208 lab=_68059_/A }
C {sky130_stdcells/buf_2.sym} 51380 -2810 0 0 {name=X_68058_ }
C {devices/lab_pin.sym} 51320 -2720 0 0 {name=p51209 lab=_53293_/A }
C {devices/lab_pin.sym} 51320 -2680 0 0 {name=p51210 lab=_53274_/B }
C {devices/lab_pin.sym} 51320 -2640 0 0 {name=p51211 lab=_53293_/C }
C {devices/lab_pin.sym} 51320 -2600 0 0 {name=p51212 lab=_52771_/D }
C {devices/lab_pin.sym} 51440 -2660 0 1 {name=p51213 lab=_53284_/X }
C {sky130_stdcells/and4_4.sym} 51380 -2660 0 0 {name=X_53284_ }
C {devices/lab_pin.sym} 51340 -2510 0 0 {name=p51214 lab=_50496_/A }
C {devices/lab_pin.sym} 51420 -2510 0 1 {name=p51215 lab=_50526_/B }
C {sky130_stdcells/buf_2.sym} 51380 -2510 0 0 {name=X_50496_ }
C {devices/lab_pin.sym} 51340 -2390 0 0 {name=p51216 lab=clkbuf_9_53_0_CLK/X }
C {devices/lab_pin.sym} 51420 -2390 0 1 {name=p51217 lab=_87174_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 51380 -2390 0 0 {name=Xclkbuf_10_106_0_CLK }
C {devices/lab_pin.sym} 51300 -2290 0 0 {name=p51218 lab=_85333_/Q }
C {devices/lab_pin.sym} 51300 -2250 0 0 {name=p51219 lab=_55020_/X }
C {devices/lab_pin.sym} 51300 -2210 0 0 {name=p51220 lab=_55022_/Y }
C {devices/lab_pin.sym} 51460 -2250 0 1 {name=p51221 lab=_55023_/Y }
C {sky130_stdcells/o21ai_4.sym} 51380 -2250 0 0 {name=X_55023_ }
C {devices/lab_pin.sym} 51340 -2110 0 0 {name=p51222 lab=_59899_/X }
C {devices/lab_pin.sym} 51420 -2110 0 1 {name=p51223 lab=_59901_/A }
C {sky130_stdcells/buf_2.sym} 51380 -2110 0 0 {name=X_59900_ }
C {devices/lab_pin.sym} 51300 -2020 0 0 {name=p51224 lab=_87425_/Q }
C {devices/lab_pin.sym} 51300 -1980 0 0 {name=p51225 lab=_66915_/X }
C {devices/lab_pin.sym} 51300 -1940 0 0 {name=p51226 lab=_66984_/X }
C {devices/lab_pin.sym} 51300 -1900 0 0 {name=p51227 lab=_67008_/X }
C {devices/lab_pin.sym} 51460 -1960 0 1 {name=p51228 lab=_67009_/X }
C {sky130_stdcells/a211o_4.sym} 51380 -1960 0 0 {name=X_67009_ }
C {devices/lab_pin.sym} 51320 -1820 0 0 {name=p51229 lab=_52220_/A }
C {devices/lab_pin.sym} 51320 -1780 0 0 {name=p51230 lab=_48851_/B }
C {devices/lab_pin.sym} 51440 -1800 0 1 {name=p51231 lab=_52235_/Y }
C {sky130_stdcells/nand2_4.sym} 51380 -1800 0 0 {name=X_52235_ }
C {devices/lab_pin.sym} 51290 -1670 0 0 {name=p51232 lab=_85566_/CLK }
C {devices/lab_pin.sym} 51290 -1650 0 0 {name=p51233 lab=_83055_/D }
C {devices/lab_pin.sym} 51470 -1670 0 1 {name=p51234 lab=_83055_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -1660 0 0 {name=X_83055_ }
C {devices/lab_pin.sym} 51290 -1530 0 0 {name=p51235 lab=_82886_/CLK }
C {devices/lab_pin.sym} 51290 -1510 0 0 {name=p51236 lab=_87932_/D }
C {devices/lab_pin.sym} 51470 -1530 0 1 {name=p51237 lab=_87932_/Q }
C {sky130_stdcells/dfxtp_4.sym} 51380 -1520 0 0 {name=X_87932_ }
C {devices/lab_pin.sym} 51340 -1390 0 0 {name=p51238 lab=clkbuf_9_368_0_CLK/X }
C {devices/lab_pin.sym} 51420 -1390 0 1 {name=p51239 lab=_87373_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 51380 -1390 0 0 {name=Xclkbuf_10_736_0_CLK }
C {devices/lab_pin.sym} 51340 -1270 0 0 {name=p51240 lab=_80266_/B }
C {devices/lab_pin.sym} 51420 -1270 0 1 {name=p51241 lab=_80267_/Y }
C {sky130_stdcells/inv_2.sym} 51380 -1270 0 0 {name=X_80267_ }
C {devices/lab_pin.sym} 51300 -1170 0 0 {name=p51242 lab=_69702_/X }
C {devices/lab_pin.sym} 51300 -1130 0 0 {name=p51243 lab=_69704_/X }
C {devices/lab_pin.sym} 51300 -1090 0 0 {name=p51244 lab=_69994_/X }
C {devices/lab_pin.sym} 51460 -1130 0 1 {name=p51245 lab=_70020_/X }
C {sky130_stdcells/a21o_4.sym} 51380 -1130 0 0 {name=X_70020_ }
C {devices/lab_pin.sym} 51290 -990 0 0 {name=p51246 lab=_82008_/CLK }
C {devices/lab_pin.sym} 51290 -970 0 0 {name=p51247 lab=_82038_/Q }
C {devices/lab_pin.sym} 51470 -990 0 1 {name=p51248 lab=_77149_/A }
C {sky130_stdcells/dfxtp_4.sym} 51380 -980 0 0 {name=X_82006_ }
C {devices/lab_pin.sym} 51340 -850 0 0 {name=p51249 lab=_44315_/A }
C {devices/lab_pin.sym} 51420 -850 0 1 {name=p51250 lab=_59831_/X }
C {sky130_stdcells/buf_2.sym} 51380 -850 0 0 {name=X_59831_ }
C {devices/lab_pin.sym} 51320 -750 0 0 {name=p51251 lab=_52166_/A }
C {devices/lab_pin.sym} 51320 -710 0 0 {name=p51252 lab=_52194_/B }
C {devices/lab_pin.sym} 51320 -670 0 0 {name=p51253 lab=_52182_/C }
C {devices/lab_pin.sym} 51440 -710 0 1 {name=p51254 lab=_52166_/X }
C {sky130_stdcells/and3_4.sym} 51380 -710 0 0 {name=X_52166_ }
C {devices/lab_pin.sym} 52210 -42150 0 0 {name=p51255 lab=_87073_/CLK }
C {devices/lab_pin.sym} 52210 -42130 0 0 {name=p51256 lab=_87863_/D }
C {devices/lab_pin.sym} 52390 -42150 0 1 {name=p51257 lab=_87863_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -42140 0 0 {name=X_87863_ }
C {devices/lab_pin.sym} 52260 -42010 0 0 {name=p51258 lab=clkbuf_8_113_0_CLK/X }
C {devices/lab_pin.sym} 52340 -42010 0 1 {name=p51259 lab=clkbuf_9_227_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 52300 -42010 0 0 {name=Xclkbuf_9_227_0_CLK }
C {devices/lab_pin.sym} 52240 -41900 0 0 {name=p51260 lab=_80198_/A }
C {devices/lab_pin.sym} 52240 -41860 0 0 {name=p51261 lab=_80198_/B }
C {devices/lab_pin.sym} 52360 -41880 0 1 {name=p51262 lab=_80221_/B }
C {sky130_stdcells/and2_4.sym} 52300 -41880 0 0 {name=X_80198_ }
C {devices/lab_pin.sym} 52240 -41760 0 0 {name=p51263 lab=_51112_/A }
C {devices/lab_pin.sym} 52240 -41720 0 0 {name=p51264 lab=_52807_/B }
C {devices/lab_pin.sym} 52360 -41740 0 1 {name=p51265 lab=_51117_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -41740 0 0 {name=X_51117_ }
C {devices/lab_pin.sym} 52210 -41610 0 0 {name=p51266 lab=_86814_/CLK }
C {devices/lab_pin.sym} 52210 -41590 0 0 {name=p51267 lab=_46016_/Y }
C {devices/lab_pin.sym} 52390 -41610 0 1 {name=p51268 lab=_86814_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -41600 0 0 {name=X_86814_ }
C {devices/lab_pin.sym} 52260 -41470 0 0 {name=p51269 lab=_59761_/X }
C {devices/lab_pin.sym} 52340 -41470 0 1 {name=p51270 lab=_59762_/Y }
C {sky130_stdcells/inv_2.sym} 52300 -41470 0 0 {name=X_59762_ }
C {devices/lab_pin.sym} 52260 -41350 0 0 {name=p51271 lab=_51956_/X }
C {devices/lab_pin.sym} 52340 -41350 0 1 {name=p51272 lab=_52097_/X }
C {sky130_stdcells/buf_2.sym} 52300 -41350 0 0 {name=X_52097_ }
C {devices/lab_pin.sym} 52220 -41250 0 0 {name=p51273 lab=_45626_/Y }
C {devices/lab_pin.sym} 52220 -41210 0 0 {name=p51274 lab=_56952_/X }
C {devices/lab_pin.sym} 52220 -41170 0 0 {name=p51275 lab=_56973_/X }
C {devices/lab_pin.sym} 52380 -41210 0 1 {name=p51276 lab=_85106_/D }
C {sky130_stdcells/o21ai_4.sym} 52300 -41210 0 0 {name=X_56974_ }
C {devices/lab_pin.sym} 52210 -41070 0 0 {name=p51277 lab=_88097_/CLK }
C {devices/lab_pin.sym} 52210 -41050 0 0 {name=p51278 lab=_87794_/D }
C {devices/lab_pin.sym} 52390 -41070 0 1 {name=p51279 lab=_69147_/B }
C {sky130_stdcells/dfxtp_4.sym} 52300 -41060 0 0 {name=X_87794_ }
C {devices/lab_pin.sym} 52220 -40950 0 0 {name=p51280 lab=_58625_/X }
C {devices/lab_pin.sym} 52220 -40910 0 0 {name=p51281 lab=_85461_/Q }
C {devices/lab_pin.sym} 52220 -40870 0 0 {name=p51282 lab=_58712_/X }
C {devices/lab_pin.sym} 52380 -40910 0 1 {name=p51283 lab=_58713_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -40910 0 0 {name=X_58713_ }
C {devices/lab_pin.sym} 52260 -40770 0 0 {name=p51284 lab=_51021_/A }
C {devices/lab_pin.sym} 52340 -40770 0 1 {name=p51285 lab=_51058_/A }
C {sky130_stdcells/buf_2.sym} 52300 -40770 0 0 {name=X_51048_ }
C {devices/lab_pin.sym} 52220 -40680 0 0 {name=p51286 lab=_83034_/Q }
C {devices/lab_pin.sym} 52220 -40640 0 0 {name=p51287 lab=_55607_/A }
C {devices/lab_pin.sym} 52220 -40600 0 0 {name=p51288 lab=_44101_/A }
C {devices/lab_pin.sym} 52220 -40560 0 0 {name=p51289 lab=_55924_/X }
C {devices/lab_pin.sym} 52380 -40620 0 1 {name=p51290 lab=_55926_/B }
C {sky130_stdcells/a211o_4.sym} 52300 -40620 0 0 {name=X_55925_ }
C {devices/lab_pin.sym} 52210 -40470 0 0 {name=p51291 lab=_85529_/CLK }
C {devices/lab_pin.sym} 52210 -40450 0 0 {name=p51292 lab=_86745_/D }
C {devices/lab_pin.sym} 52390 -40470 0 1 {name=p51293 lab=_86745_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -40460 0 0 {name=X_86745_ }
C {devices/lab_pin.sym} 52220 -40350 0 0 {name=p51294 lab=_71968_/Y }
C {devices/lab_pin.sym} 52220 -40310 0 0 {name=p51295 lab=_71969_/X }
C {devices/lab_pin.sym} 52220 -40270 0 0 {name=p51296 lab=_71970_/Y }
C {devices/lab_pin.sym} 52380 -40310 0 1 {name=p51297 lab=_71971_/Y }
C {sky130_stdcells/a21boi_4.sym} 52300 -40310 0 0 {name=X_71971_ }
C {devices/lab_pin.sym} 52260 -40170 0 0 {name=p51298 lab=_59692_/Y }
C {devices/lab_pin.sym} 52340 -40170 0 1 {name=p51299 lab=_62185_/B }
C {sky130_stdcells/buf_2.sym} 52300 -40170 0 0 {name=X_59693_ }
C {devices/lab_pin.sym} 52210 -40050 0 0 {name=p51300 lab=_83957_/CLK }
C {devices/lab_pin.sym} 52210 -40030 0 0 {name=p51301 lab=_68881_/X }
C {devices/lab_pin.sym} 52390 -40050 0 1 {name=p51302 lab=_83957_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -40040 0 0 {name=X_83957_ }
C {devices/lab_pin.sym} 52260 -39910 0 0 {name=p51303 lab=_73709_/X }
C {devices/lab_pin.sym} 52340 -39910 0 1 {name=p51304 lab=_73711_/A }
C {sky130_stdcells/buf_2.sym} 52300 -39910 0 0 {name=X_73710_ }
C {devices/lab_pin.sym} 52220 -39810 0 0 {name=p51305 lab=_58125_/X }
C {devices/lab_pin.sym} 52220 -39770 0 0 {name=p51306 lab=_85787_/Q }
C {devices/lab_pin.sym} 52220 -39730 0 0 {name=p51307 lab=_58126_/X }
C {devices/lab_pin.sym} 52380 -39770 0 1 {name=p51308 lab=_58644_/X }
C {sky130_stdcells/o21a_4.sym} 52300 -39770 0 0 {name=X_58644_ }
C {devices/lab_pin.sym} 52220 -39650 0 0 {name=p51309 lab=_51031_/B }
C {devices/lab_pin.sym} 52220 -39610 0 0 {name=p51310 lab=_70909_/X }
C {devices/lab_pin.sym} 52220 -39570 0 0 {name=p51311 lab=_70921_/Y }
C {devices/lab_pin.sym} 52380 -39610 0 1 {name=p51312 lab=_70922_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -39610 0 0 {name=X_70922_ }
C {devices/lab_pin.sym} 52210 -39470 0 0 {name=p51313 lab=_82906_/CLK }
C {devices/lab_pin.sym} 52210 -39450 0 0 {name=p51314 lab=_78270_/B }
C {devices/lab_pin.sym} 52390 -39470 0 1 {name=p51315 lab=_82908_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -39460 0 0 {name=X_82908_ }
C {devices/lab_pin.sym} 52220 -39360 0 0 {name=p51316 lab=_85267_/Q }
C {devices/lab_pin.sym} 52220 -39320 0 0 {name=p51317 lab=_55489_/A }
C {devices/lab_pin.sym} 52220 -39280 0 0 {name=p51318 lab=_55469_/X }
C {devices/lab_pin.sym} 52220 -39240 0 0 {name=p51319 lab=_55855_/X }
C {devices/lab_pin.sym} 52380 -39300 0 1 {name=p51320 lab=_55856_/X }
C {sky130_stdcells/a211o_4.sym} 52300 -39300 0 0 {name=X_55856_ }
C {devices/lab_pin.sym} 52260 -39150 0 0 {name=p51321 lab=_43869_/X }
C {devices/lab_pin.sym} 52340 -39150 0 1 {name=p51322 lab=_43870_/X }
C {sky130_stdcells/buf_2.sym} 52300 -39150 0 0 {name=X_43870_ }
C {devices/lab_pin.sym} 52260 -39030 0 0 {name=p51323 lab=_74689_/X }
C {devices/lab_pin.sym} 52340 -39030 0 1 {name=p51324 lab=_82984_/D }
C {sky130_stdcells/inv_2.sym} 52300 -39030 0 0 {name=X_74690_ }
C {devices/lab_pin.sym} 52210 -38910 0 0 {name=p51325 lab=_86359_/CLK }
C {devices/lab_pin.sym} 52210 -38890 0 0 {name=p51326 lab=_86676_/D }
C {devices/lab_pin.sym} 52390 -38910 0 1 {name=p51327 lab=_86676_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -38900 0 0 {name=X_86676_ }
C {devices/lab_pin.sym} 52210 -38770 0 0 {name=p51328 lab=_82339_/CLK }
C {devices/lab_pin.sym} 52210 -38750 0 0 {name=p51329 lab=_69905_/X }
C {devices/lab_pin.sym} 52390 -38770 0 1 {name=p51330 lab=_83888_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -38760 0 0 {name=X_83888_ }
C {devices/lab_pin.sym} 52260 -38630 0 0 {name=p51331 lab=_42820_/X }
C {devices/lab_pin.sym} 52340 -38630 0 1 {name=p51332 lab=_42821_/X }
C {sky130_stdcells/buf_2.sym} 52300 -38630 0 0 {name=X_42821_ }
C {devices/lab_pin.sym} 52260 -38510 0 0 {name=p51333 lab=_54807_/A }
C {devices/lab_pin.sym} 52340 -38510 0 1 {name=p51334 lab=_54825_/A }
C {sky130_stdcells/buf_2.sym} 52300 -38510 0 0 {name=X_54807_ }
C {devices/lab_pin.sym} 52240 -38400 0 0 {name=p51335 lab=_73641_/A }
C {devices/lab_pin.sym} 52240 -38360 0 0 {name=p51336 lab=_86558_/Q }
C {devices/lab_pin.sym} 52360 -38380 0 1 {name=p51337 lab=_73641_/X }
C {sky130_stdcells/and2_4.sym} 52300 -38380 0 0 {name=X_73641_ }
C {devices/lab_pin.sym} 52210 -38250 0 0 {name=p51338 lab=_86237_/CLK }
C {devices/lab_pin.sym} 52210 -38230 0 0 {name=p51339 lab=_85627_/D }
C {devices/lab_pin.sym} 52390 -38250 0 1 {name=p51340 lab=_85627_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -38240 0 0 {name=X_85627_ }
C {devices/lab_pin.sym} 52220 -38130 0 0 {name=p51341 lab=_46685_/X }
C {devices/lab_pin.sym} 52220 -38090 0 0 {name=p51342 lab=_70830_/Y }
C {devices/lab_pin.sym} 52220 -38050 0 0 {name=p51343 lab=_70852_/Y }
C {devices/lab_pin.sym} 52380 -38090 0 1 {name=p51344 lab=_70853_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -38090 0 0 {name=X_70853_ }
C {devices/lab_pin.sym} 52220 -37980 0 0 {name=p51345 lab=_84817_/Q }
C {devices/lab_pin.sym} 52220 -37940 0 0 {name=p51346 lab=_58095_/X }
C {devices/lab_pin.sym} 52220 -37900 0 0 {name=p51347 lab=_58567_/X }
C {devices/lab_pin.sym} 52220 -37860 0 0 {name=p51348 lab=_58574_/X }
C {devices/lab_pin.sym} 52380 -37920 0 1 {name=p51349 lab=_84817_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 52300 -37920 0 0 {name=X_58575_ }
C {devices/lab_pin.sym} 52210 -37770 0 0 {name=p51350 lab=_82740_/CLK }
C {devices/lab_pin.sym} 52210 -37750 0 0 {name=p51351 lab=_82839_/D }
C {devices/lab_pin.sym} 52390 -37770 0 1 {name=p51352 lab=_82839_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -37760 0 0 {name=X_82839_ }
C {devices/lab_pin.sym} 52220 -37650 0 0 {name=p51353 lab=_55784_/X }
C {devices/lab_pin.sym} 52220 -37610 0 0 {name=p51354 lab=_55786_/X }
C {devices/lab_pin.sym} 52220 -37570 0 0 {name=p51355 lab=_44110_/X }
C {devices/lab_pin.sym} 52380 -37610 0 1 {name=p51356 lab=_55787_/X }
C {sky130_stdcells/a21o_4.sym} 52300 -37610 0 0 {name=X_55787_ }
C {devices/lab_pin.sym} 52240 -37480 0 0 {name=p51357 lab=_52999_/A }
C {devices/lab_pin.sym} 52240 -37440 0 0 {name=p51358 lab=_52999_/B }
C {devices/lab_pin.sym} 52360 -37460 0 1 {name=p51359 lab=_52999_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -37460 0 0 {name=X_52999_ }
C {devices/lab_pin.sym} 52220 -37350 0 0 {name=p51360 lab=_45536_/X }
C {devices/lab_pin.sym} 52220 -37310 0 0 {name=p51361 lab=_45539_/X }
C {devices/lab_pin.sym} 52220 -37270 0 0 {name=p51362 lab=_45523_/X }
C {devices/lab_pin.sym} 52380 -37310 0 1 {name=p51363 lab=_45540_/X }
C {sky130_stdcells/a21o_4.sym} 52300 -37310 0 0 {name=X_45540_ }
C {devices/lab_pin.sym} 52220 -37190 0 0 {name=p51364 lab=_57524_/Y }
C {devices/lab_pin.sym} 52220 -37150 0 0 {name=p51365 lab=_57506_/X }
C {devices/lab_pin.sym} 52220 -37110 0 0 {name=p51366 lab=_57525_/X }
C {devices/lab_pin.sym} 52380 -37150 0 1 {name=p51367 lab=_84986_/D }
C {sky130_stdcells/a21oi_4.sym} 52300 -37150 0 0 {name=X_57526_ }
C {devices/lab_pin.sym} 52220 -37030 0 0 {name=p51368 lab=_76340_/X }
C {devices/lab_pin.sym} 52220 -36990 0 0 {name=p51369 lab=_76358_/Y }
C {devices/lab_pin.sym} 52220 -36950 0 0 {name=p51370 lab=_76359_/Y }
C {devices/lab_pin.sym} 52380 -36990 0 1 {name=p51371 lab=_76360_/Y }
C {sky130_stdcells/a21oi_4.sym} 52300 -36990 0 0 {name=X_76360_ }
C {devices/lab_pin.sym} 52260 -36850 0 0 {name=p51372 lab=_42752_/A }
C {devices/lab_pin.sym} 52340 -36850 0 1 {name=p51373 lab=_42752_/Y }
C {sky130_stdcells/inv_2.sym} 52300 -36850 0 0 {name=X_42752_ }
C {devices/lab_pin.sym} 52210 -36730 0 0 {name=p51374 lab=_87851_/CLK }
C {devices/lab_pin.sym} 52210 -36710 0 0 {name=p51375 lab=_88346_/D }
C {devices/lab_pin.sym} 52390 -36730 0 1 {name=p51376 lab=_88346_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -36720 0 0 {name=X_88346_ }
C {devices/lab_pin.sym} 52260 -36590 0 0 {name=p51377 lab=_54656_/X }
C {devices/lab_pin.sym} 52340 -36590 0 1 {name=p51378 lab=_54755_/B }
C {sky130_stdcells/buf_2.sym} 52300 -36590 0 0 {name=X_54738_ }
C {devices/lab_pin.sym} 52240 -36480 0 0 {name=p51379 lab=_73559_/Y }
C {devices/lab_pin.sym} 52240 -36440 0 0 {name=p51380 lab=_73572_/B }
C {devices/lab_pin.sym} 52360 -36460 0 1 {name=p51381 lab=_73572_/Y }
C {sky130_stdcells/xnor2_4.sym} 52300 -36460 0 0 {name=X_73572_ }
C {devices/lab_pin.sym} 52210 -36330 0 0 {name=p51382 lab=_85558_/CLK }
C {devices/lab_pin.sym} 52210 -36310 0 0 {name=p51383 lab=_53840_/Y }
C {devices/lab_pin.sym} 52390 -36330 0 1 {name=p51384 lab=_85558_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -36320 0 0 {name=X_85558_ }
C {devices/lab_pin.sym} 52240 -36220 0 0 {name=p51385 lab=_70871_/A }
C {devices/lab_pin.sym} 52240 -36180 0 0 {name=p51386 lab=_70791_/B }
C {devices/lab_pin.sym} 52240 -36140 0 0 {name=p51387 lab=_70791_/C }
C {devices/lab_pin.sym} 52240 -36100 0 0 {name=p51388 lab=_70791_/D }
C {devices/lab_pin.sym} 52360 -36160 0 1 {name=p51389 lab=_70784_/Y }
C {sky130_stdcells/nand4_4.sym} 52300 -36160 0 0 {name=X_70784_ }
C {devices/lab_pin.sym} 52240 -36020 0 0 {name=p51390 lab=_80690_/Q }
C {devices/lab_pin.sym} 52240 -35980 0 0 {name=p51391 lab=_80990_/Q }
C {devices/lab_pin.sym} 52360 -36000 0 1 {name=p51392 lab=_75311_/Y }
C {sky130_stdcells/nor2_4.sym} 52300 -36000 0 0 {name=X_75311_ }
C {devices/lab_pin.sym} 52240 -35880 0 0 {name=p51393 lab=_41604_/A }
C {devices/lab_pin.sym} 52240 -35840 0 0 {name=p51394 lab=_41703_/B }
C {devices/lab_pin.sym} 52360 -35860 0 1 {name=p51395 lab=_41703_/X }
C {sky130_stdcells/or2_4.sym} 52300 -35860 0 0 {name=X_41703_ }
C {devices/lab_pin.sym} 52220 -35750 0 0 {name=p51396 lab=_61260_/X }
C {devices/lab_pin.sym} 52220 -35710 0 0 {name=p51397 lab=_61319_/X }
C {devices/lab_pin.sym} 52220 -35670 0 0 {name=p51398 lab=_72503_/A }
C {devices/lab_pin.sym} 52380 -35710 0 1 {name=p51399 lab=_72602_/A }
C {sky130_stdcells/a21boi_4.sym} 52300 -35710 0 0 {name=X_72523_ }
C {devices/lab_pin.sym} 52210 -35570 0 0 {name=p51400 lab=_84623_/CLK }
C {devices/lab_pin.sym} 52210 -35550 0 0 {name=p51401 lab=_61201_/X }
C {devices/lab_pin.sym} 52390 -35570 0 1 {name=p51402 lab=_61200_/C }
C {sky130_stdcells/dfxtp_4.sym} 52300 -35560 0 0 {name=X_84509_ }
C {devices/lab_pin.sym} 52260 -35430 0 0 {name=p51403 lab=_45389_/X }
C {devices/lab_pin.sym} 52340 -35430 0 1 {name=p51404 lab=_45471_/X }
C {sky130_stdcells/buf_2.sym} 52300 -35430 0 0 {name=X_45471_ }
C {devices/lab_pin.sym} 52260 -35310 0 0 {name=p51405 lab=_57456_/Y }
C {devices/lab_pin.sym} 52340 -35310 0 1 {name=p51406 lab=_85001_/D }
C {sky130_stdcells/inv_2.sym} 52300 -35310 0 0 {name=X_57457_ }
C {devices/lab_pin.sym} 52240 -35200 0 0 {name=p51407 lab=_76288_/Y }
C {devices/lab_pin.sym} 52240 -35160 0 0 {name=p51408 lab=_76309_/B }
C {devices/lab_pin.sym} 52360 -35180 0 1 {name=p51409 lab=_76291_/X }
C {sky130_stdcells/xor2_4.sym} 52300 -35180 0 0 {name=X_76291_ }
C {devices/lab_pin.sym} 52210 -35050 0 0 {name=p51410 lab=_82301_/CLK }
C {devices/lab_pin.sym} 52210 -35030 0 0 {name=p51411 lab=_88277_/D }
C {devices/lab_pin.sym} 52390 -35050 0 1 {name=p51412 lab=_69547_/B }
C {sky130_stdcells/dfxtp_4.sym} 52300 -35040 0 0 {name=X_88277_ }
C {devices/lab_pin.sym} 52220 -34940 0 0 {name=p51413 lab=_41064_/X }
C {devices/lab_pin.sym} 52220 -34900 0 0 {name=p51414 lab=_42679_/X }
C {devices/lab_pin.sym} 52220 -34860 0 0 {name=p51415 lab=_69452_/B }
C {devices/lab_pin.sym} 52220 -34820 0 0 {name=p51416 lab=_42681_/X }
C {devices/lab_pin.sym} 52380 -34880 0 1 {name=p51417 lab=_42683_/X }
C {sky130_stdcells/a2bb2o_4.sym} 52300 -34880 0 0 {name=X_42683_ }
C {devices/lab_pin.sym} 52240 -34740 0 0 {name=p51418 lab=_54649_/X }
C {devices/lab_pin.sym} 52240 -34700 0 0 {name=p51419 lab=_47313_/Y }
C {devices/lab_pin.sym} 52360 -34720 0 1 {name=p51420 lab=_54669_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -34720 0 0 {name=X_54669_ }
C {devices/lab_pin.sym} 52210 -34590 0 0 {name=p51421 lab=_85489_/CLK }
C {devices/lab_pin.sym} 52210 -34570 0 0 {name=p51422 lab=_85489_/D }
C {devices/lab_pin.sym} 52390 -34590 0 1 {name=p51423 lab=_85489_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -34580 0 0 {name=X_85489_ }
C {devices/lab_pin.sym} 52240 -34480 0 0 {name=p51424 lab=_47210_/A }
C {devices/lab_pin.sym} 52240 -34440 0 0 {name=p51425 lab=_47181_/B }
C {devices/lab_pin.sym} 52240 -34400 0 0 {name=p51426 lab=_47210_/C }
C {devices/lab_pin.sym} 52240 -34360 0 0 {name=p51427 lab=_51225_/D }
C {devices/lab_pin.sym} 52360 -34420 0 1 {name=p51428 lab=_47210_/X }
C {sky130_stdcells/and4_4.sym} 52300 -34420 0 0 {name=X_47210_ }
C {devices/lab_pin.sym} 52260 -34270 0 0 {name=p51429 lab=_78030_/A }
C {devices/lab_pin.sym} 52340 -34270 0 1 {name=p51430 lab=_78031_/B }
C {sky130_stdcells/inv_2.sym} 52300 -34270 0 0 {name=X_78030_ }
C {devices/lab_pin.sym} 52220 -34190 0 0 {name=p51431 lab=_44404_/X }
C {devices/lab_pin.sym} 52220 -34150 0 0 {name=p51432 lab=_44405_/X }
C {devices/lab_pin.sym} 52220 -34110 0 0 {name=p51433 lab=_41565_/X }
C {devices/lab_pin.sym} 52220 -34070 0 0 {name=p51434 lab=_87115_/Q }
C {devices/lab_pin.sym} 52220 -34030 0 0 {name=p51435 lab=_44406_/X }
C {devices/lab_pin.sym} 52380 -34110 0 1 {name=p51436 lab=_44422_/Y }
C {sky130_stdcells/o32ai_4.sym} 52300 -34110 0 0 {name=X_44422_ }
C {devices/lab_pin.sym} 52220 -33970 0 0 {name=p51437 lab=_56070_/X }
C {devices/lab_pin.sym} 52220 -33930 0 0 {name=p51438 lab=_56394_/X }
C {devices/lab_pin.sym} 52220 -33890 0 0 {name=p51439 lab=_56407_/Y }
C {devices/lab_pin.sym} 52380 -33930 0 1 {name=p51440 lab=_85205_/D }
C {sky130_stdcells/o21ai_4.sym} 52300 -33930 0 0 {name=X_56408_ }
C {devices/lab_pin.sym} 52210 -33790 0 0 {name=p51441 lab=_87487_/CLK }
C {devices/lab_pin.sym} 52210 -33770 0 0 {name=p51442 lab=_87228_/D }
C {devices/lab_pin.sym} 52390 -33790 0 1 {name=p51443 lab=_68944_/B }
C {sky130_stdcells/dfxtp_4.sym} 52300 -33780 0 0 {name=X_87228_ }
C {devices/lab_pin.sym} 52240 -33660 0 0 {name=p51444 lab=_75242_/A }
C {devices/lab_pin.sym} 52240 -33620 0 0 {name=p51445 lab=_75216_/Y }
C {devices/lab_pin.sym} 52360 -33640 0 1 {name=p51446 lab=_75243_/A }
C {sky130_stdcells/nor2_4.sym} 52300 -33640 0 0 {name=X_75242_ }
C {devices/lab_pin.sym} 52240 -33520 0 0 {name=p51447 lab=_40620_/X }
C {devices/lab_pin.sym} 52240 -33480 0 0 {name=p51448 lab=_41634_/B }
C {devices/lab_pin.sym} 52360 -33500 0 1 {name=p51449 lab=_41634_/X }
C {sky130_stdcells/or2_4.sym} 52300 -33500 0 0 {name=X_41634_ }
C {devices/lab_pin.sym} 52240 -33380 0 0 {name=p51450 lab=_48190_/A }
C {devices/lab_pin.sym} 52240 -33340 0 0 {name=p51451 lab=_51947_/B }
C {devices/lab_pin.sym} 52360 -33360 0 1 {name=p51452 lab=_48190_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -33360 0 0 {name=X_48190_ }
C {devices/lab_pin.sym} 52220 -33260 0 0 {name=p51453 lab=_83253_/Q }
C {devices/lab_pin.sym} 52220 -33220 0 0 {name=p51454 lab=_72445_/X }
C {devices/lab_pin.sym} 52220 -33180 0 0 {name=p51455 lab=_72448_/X }
C {devices/lab_pin.sym} 52220 -33140 0 0 {name=p51456 lab=_72453_/X }
C {devices/lab_pin.sym} 52380 -33200 0 1 {name=p51457 lab=_83253_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 52300 -33200 0 0 {name=X_72454_ }
C {devices/lab_pin.sym} 52220 -33080 0 0 {name=p51458 lab=_57384_/X }
C {devices/lab_pin.sym} 52220 -33040 0 0 {name=p51459 lab=_56578_/X }
C {devices/lab_pin.sym} 52220 -33000 0 0 {name=p51460 lab=_85022_/Q }
C {devices/lab_pin.sym} 52220 -32960 0 0 {name=p51461 lab=_57385_/X }
C {devices/lab_pin.sym} 52380 -33020 0 1 {name=p51462 lab=_57388_/X }
C {sky130_stdcells/a2bb2o_4.sym} 52300 -33020 0 0 {name=X_57388_ }
C {devices/lab_pin.sym} 52260 -32870 0 0 {name=p51463 lab=_82378_/Q }
C {devices/lab_pin.sym} 52340 -32870 0 1 {name=p51464 lab=_54571_/D }
C {sky130_stdcells/inv_2.sym} 52300 -32870 0 0 {name=X_47141_ }
C {devices/lab_pin.sym} 52220 -32770 0 0 {name=p51465 lab=_59123_/Y }
C {devices/lab_pin.sym} 52220 -32730 0 0 {name=p51466 lab=_59126_/Y }
C {devices/lab_pin.sym} 52220 -32690 0 0 {name=p51467 lab=_59053_/X }
C {devices/lab_pin.sym} 52380 -32730 0 1 {name=p51468 lab=_59127_/X }
C {sky130_stdcells/a21o_4.sym} 52300 -32730 0 0 {name=X_59127_ }
C {devices/lab_pin.sym} 52220 -32610 0 0 {name=p51469 lab=_71397_/X }
C {devices/lab_pin.sym} 52220 -32570 0 0 {name=p51470 lab=_83511_/Q }
C {devices/lab_pin.sym} 52220 -32530 0 0 {name=p51471 lab=_71404_/Y }
C {devices/lab_pin.sym} 52380 -32570 0 1 {name=p51472 lab=_83511_/D }
C {sky130_stdcells/a21o_4.sym} 52300 -32570 0 0 {name=X_71405_ }
C {devices/lab_pin.sym} 52260 -32430 0 0 {name=p51473 lab=_44352_/X }
C {devices/lab_pin.sym} 52340 -32430 0 1 {name=p51474 lab=_44353_/X }
C {sky130_stdcells/buf_2.sym} 52300 -32430 0 0 {name=X_44353_ }
C {devices/lab_pin.sym} 52240 -32330 0 0 {name=p51475 lab=_56345_/A }
C {devices/lab_pin.sym} 52240 -32290 0 0 {name=p51476 lab=_56345_/B }
C {devices/lab_pin.sym} 52240 -32250 0 0 {name=p51477 lab=_56339_/C }
C {devices/lab_pin.sym} 52360 -32290 0 1 {name=p51478 lab=_56339_/Y }
C {sky130_stdcells/nand3_4.sym} 52300 -32290 0 0 {name=X_56339_ }
C {devices/lab_pin.sym} 52220 -32170 0 0 {name=p51479 lab=_75169_/Y }
C {devices/lab_pin.sym} 52220 -32130 0 0 {name=p51480 lab=_75171_/Y }
C {devices/lab_pin.sym} 52220 -32090 0 0 {name=p51481 lab=_75172_/Y }
C {devices/lab_pin.sym} 52380 -32130 0 1 {name=p51482 lab=_75178_/A }
C {sky130_stdcells/o21ai_4.sym} 52300 -32130 0 0 {name=X_75173_ }
C {devices/lab_pin.sym} 52210 -31990 0 0 {name=p51483 lab=_86935_/CLK }
C {devices/lab_pin.sym} 52210 -31970 0 0 {name=p51484 lab=_87159_/D }
C {devices/lab_pin.sym} 52390 -31990 0 1 {name=p51485 lab=_87159_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -31980 0 0 {name=X_87159_ }
C {devices/lab_pin.sym} 52260 -31850 0 0 {name=p51486 lab=_41564_/X }
C {devices/lab_pin.sym} 52340 -31850 0 1 {name=p51487 lab=_41565_/X }
C {sky130_stdcells/buf_2.sym} 52300 -31850 0 0 {name=X_41565_ }
C {devices/lab_pin.sym} 52220 -31770 0 0 {name=p51488 lab=_72299_/X }
C {devices/lab_pin.sym} 52220 -31730 0 0 {name=p51489 lab=_72382_/Y }
C {devices/lab_pin.sym} 52220 -31690 0 0 {name=p51490 lab=_72384_/Y }
C {devices/lab_pin.sym} 52220 -31650 0 0 {name=p51491 lab=_72337_/X }
C {devices/lab_pin.sym} 52220 -31610 0 0 {name=p51492 lab=_72303_/X }
C {devices/lab_pin.sym} 52380 -31690 0 1 {name=p51493 lab=_72385_/X }
C {sky130_stdcells/o32a_4.sym} 52300 -31690 0 0 {name=X_72385_ }
C {devices/lab_pin.sym} 52260 -31530 0 0 {name=p51494 lab=_43166_/A }
C {devices/lab_pin.sym} 52340 -31530 0 1 {name=p51495 lab=_43305_/A }
C {sky130_stdcells/buf_2.sym} 52300 -31530 0 0 {name=X_43304_ }
C {devices/lab_pin.sym} 52220 -31440 0 0 {name=p51496 lab=_68959_/B }
C {devices/lab_pin.sym} 52220 -31400 0 0 {name=p51497 lab=_57376_/X }
C {devices/lab_pin.sym} 52220 -31360 0 0 {name=p51498 lab=_72798_/X }
C {devices/lab_pin.sym} 52220 -31320 0 0 {name=p51499 lab=_74123_/Y }
C {devices/lab_pin.sym} 52380 -31380 0 1 {name=p51500 lab=_74124_/X }
C {sky130_stdcells/a211o_4.sym} 52300 -31380 0 0 {name=X_74124_ }
C {devices/lab_pin.sym} 52220 -31270 0 0 {name=p51501 lab=_40477_/X }
C {devices/lab_pin.sym} 52220 -31230 0 0 {name=p51502 lab=_40488_/X }
C {devices/lab_pin.sym} 52220 -31190 0 0 {name=p51503 lab=_40515_/X }
C {devices/lab_pin.sym} 52220 -31150 0 0 {name=p51504 lab=_88379_/Q }
C {devices/lab_pin.sym} 52220 -31110 0 0 {name=p51505 lab=_40492_/X }
C {devices/lab_pin.sym} 52380 -31190 0 1 {name=p51506 lab=_40516_/Y }
C {sky130_stdcells/o32ai_4.sym} 52300 -31190 0 0 {name=X_40516_ }
C {devices/lab_pin.sym} 52220 -31050 0 0 {name=p51507 lab=_86673_/Q }
C {devices/lab_pin.sym} 52220 -31010 0 0 {name=p51508 lab=_47050_/X }
C {devices/lab_pin.sym} 52220 -30970 0 0 {name=p51509 lab=_47071_/Y }
C {devices/lab_pin.sym} 52380 -31010 0 1 {name=p51510 lab=_47072_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -31010 0 0 {name=X_47072_ }
C {devices/lab_pin.sym} 52220 -30890 0 0 {name=p51511 lab=_50383_/B }
C {devices/lab_pin.sym} 52220 -30850 0 0 {name=p51512 lab=_71320_/A }
C {devices/lab_pin.sym} 52220 -30810 0 0 {name=p51513 lab=_71335_/Y }
C {devices/lab_pin.sym} 52380 -30850 0 1 {name=p51514 lab=_71336_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -30850 0 0 {name=X_71336_ }
C {devices/lab_pin.sym} 52220 -30750 0 0 {name=p51515 lab=_59027_/X }
C {devices/lab_pin.sym} 52220 -30710 0 0 {name=p51516 lab=_59056_/Y }
C {devices/lab_pin.sym} 52220 -30670 0 0 {name=p51517 lab=_59057_/Y }
C {devices/lab_pin.sym} 52220 -30630 0 0 {name=p51518 lab=_59046_/X }
C {devices/lab_pin.sym} 52220 -30590 0 0 {name=p51519 lab=_59031_/X }
C {devices/lab_pin.sym} 52380 -30670 0 1 {name=p51520 lab=_59058_/X }
C {sky130_stdcells/o32a_4.sym} 52300 -30670 0 0 {name=X_59058_ }
C {devices/lab_pin.sym} 52240 -30530 0 0 {name=p51521 lab=_44072_/Y }
C {devices/lab_pin.sym} 52240 -30490 0 0 {name=p51522 lab=_57650_/A }
C {devices/lab_pin.sym} 52240 -30450 0 0 {name=p51523 lab=_44284_/C }
C {devices/lab_pin.sym} 52360 -30490 0 1 {name=p51524 lab=_44284_/Y }
C {sky130_stdcells/nor3_4.sym} 52300 -30490 0 0 {name=X_44284_ }
C {devices/lab_pin.sym} 52220 -30370 0 0 {name=p51525 lab=_79965_/Y }
C {devices/lab_pin.sym} 52220 -30330 0 0 {name=p51526 lab=_79964_/A }
C {devices/lab_pin.sym} 52220 -30290 0 0 {name=p51527 lab=_79963_/Y }
C {devices/lab_pin.sym} 52380 -30330 0 1 {name=p51528 lab=_79981_/Y }
C {sky130_stdcells/a21boi_4.sym} 52300 -30330 0 0 {name=X_79981_ }
C {devices/lab_pin.sym} 52240 -30200 0 0 {name=p51529 lab=_41513_/A }
C {devices/lab_pin.sym} 52240 -30160 0 0 {name=p51530 lab=_82330_/Q }
C {devices/lab_pin.sym} 52360 -30180 0 1 {name=p51531 lab=_41496_/X }
C {sky130_stdcells/or2_4.sym} 52300 -30180 0 0 {name=X_41496_ }
C {devices/lab_pin.sym} 52260 -30050 0 0 {name=p51532 lab=_45975_/X }
C {devices/lab_pin.sym} 52340 -30050 0 1 {name=p51533 lab=_46023_/X }
C {sky130_stdcells/buf_2.sym} 52300 -30050 0 0 {name=X_46023_ }
C {devices/lab_pin.sym} 52220 -29960 0 0 {name=p51534 lab=_57996_/Y }
C {devices/lab_pin.sym} 52220 -29920 0 0 {name=p51535 lab=_57981_/X }
C {devices/lab_pin.sym} 52220 -29880 0 0 {name=p51536 lab=_58004_/X }
C {devices/lab_pin.sym} 52220 -29840 0 0 {name=p51537 lab=_58008_/X }
C {devices/lab_pin.sym} 52380 -29900 0 1 {name=p51538 lab=_84933_/D }
C {sky130_stdcells/a22oi_4.sym} 52300 -29900 0 0 {name=X_58009_ }
C {devices/lab_pin.sym} 52220 -29790 0 0 {name=p51539 lab=_43226_/X }
C {devices/lab_pin.sym} 52220 -29750 0 0 {name=p51540 lab=_43229_/X }
C {devices/lab_pin.sym} 52220 -29710 0 0 {name=p51541 lab=_41016_/X }
C {devices/lab_pin.sym} 52220 -29670 0 0 {name=p51542 lab=_87525_/Q }
C {devices/lab_pin.sym} 52220 -29630 0 0 {name=p51543 lab=_43232_/X }
C {devices/lab_pin.sym} 52380 -29710 0 1 {name=p51544 lab=_43236_/A }
C {sky130_stdcells/o32ai_4.sym} 52300 -29710 0 0 {name=X_43235_ }
C {devices/lab_pin.sym} 52220 -29570 0 0 {name=p51545 lab=_74052_/X }
C {devices/lab_pin.sym} 52220 -29530 0 0 {name=p51546 lab=_74054_/X }
C {devices/lab_pin.sym} 52220 -29490 0 0 {name=p51547 lab=_73944_/X }
C {devices/lab_pin.sym} 52380 -29530 0 1 {name=p51548 lab=_74055_/X }
C {sky130_stdcells/a21o_4.sym} 52300 -29530 0 0 {name=X_74055_ }
C {devices/lab_pin.sym} 52240 -29400 0 0 {name=p51549 lab=_78918_/Y }
C {devices/lab_pin.sym} 52240 -29360 0 0 {name=p51550 lab=_78931_/X }
C {devices/lab_pin.sym} 52360 -29380 0 1 {name=p51551 lab=_78937_/A }
C {sky130_stdcells/nand2_4.sym} 52300 -29380 0 0 {name=X_78932_ }
C {devices/lab_pin.sym} 52260 -29250 0 0 {name=p51552 lab=_44736_/A }
C {devices/lab_pin.sym} 52340 -29250 0 1 {name=p51553 lab=_40447_/X }
C {sky130_stdcells/buf_2.sym} 52300 -29250 0 0 {name=X_40447_ }
C {devices/lab_pin.sym} 52260 -29130 0 0 {name=p51554 lab=_71266_/X }
C {devices/lab_pin.sym} 52340 -29130 0 1 {name=p51555 lab=_71268_/A }
C {sky130_stdcells/buf_2.sym} 52300 -29130 0 0 {name=X_71267_ }
C {devices/lab_pin.sym} 52260 -29010 0 0 {name=p51556 lab=_59508_/X }
C {devices/lab_pin.sym} 52340 -29010 0 1 {name=p51557 lab=_61020_/X }
C {sky130_stdcells/buf_2.sym} 52300 -29010 0 0 {name=X_61020_ }
C {devices/lab_pin.sym} 52260 -28890 0 0 {name=p51558 lab=_56274_/X }
C {devices/lab_pin.sym} 52340 -28890 0 1 {name=p51559 lab=_73006_/X }
C {sky130_stdcells/buf_2.sym} 52300 -28890 0 0 {name=X_73006_ }
C {devices/lab_pin.sym} 52260 -28770 0 0 {name=p51560 lab=_70233_/A }
C {devices/lab_pin.sym} 52340 -28770 0 1 {name=p51561 lab=_70229_/D }
C {sky130_stdcells/buf_2.sym} 52300 -28770 0 0 {name=X_70218_ }
C {devices/lab_pin.sym} 52260 -28650 0 0 {name=p51562 lab=_43166_/A }
C {devices/lab_pin.sym} 52340 -28650 0 1 {name=p51563 lab=_43167_/A }
C {sky130_stdcells/buf_2.sym} 52300 -28650 0 0 {name=X_43166_ }
C {devices/lab_pin.sym} 52240 -28540 0 0 {name=p51564 lab=_82841_/Q }
C {devices/lab_pin.sym} 52240 -28500 0 0 {name=p51565 lab=_82553_/Q }
C {devices/lab_pin.sym} 52360 -28520 0 1 {name=p51566 lab=_78877_/A }
C {sky130_stdcells/xor2_4.sym} 52300 -28520 0 0 {name=X_78863_ }
C {devices/lab_pin.sym} 52260 -28390 0 0 {name=p51567 lab=_40629_/A }
C {devices/lab_pin.sym} 52340 -28390 0 1 {name=p51568 lab=_47825_/A }
C {sky130_stdcells/buf_2.sym} 52300 -28390 0 0 {name=X_40378_ }
C {devices/lab_pin.sym} 52220 -28290 0 0 {name=p51569 lab=_48551_/X }
C {devices/lab_pin.sym} 52220 -28250 0 0 {name=p51570 lab=_71190_/X }
C {devices/lab_pin.sym} 52220 -28210 0 0 {name=p51571 lab=_71197_/Y }
C {devices/lab_pin.sym} 52380 -28250 0 1 {name=p51572 lab=_71198_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -28250 0 0 {name=X_71198_ }
C {devices/lab_pin.sym} 52260 -28110 0 0 {name=p51573 lab=_42096_/A }
C {devices/lab_pin.sym} 52340 -28110 0 1 {name=p51574 lab=_42117_/X }
C {sky130_stdcells/buf_2.sym} 52300 -28110 0 0 {name=X_42117_ }
C {devices/lab_pin.sym} 52240 -28000 0 0 {name=p51575 lab=_82268_/Q }
C {devices/lab_pin.sym} 52240 -27960 0 0 {name=p51576 lab=_77814_/B }
C {devices/lab_pin.sym} 52360 -27980 0 1 {name=p51577 lab=_77814_/Y }
C {sky130_stdcells/xnor2_4.sym} 52300 -27980 0 0 {name=X_77814_ }
C {devices/lab_pin.sym} 52240 -27880 0 0 {name=p51578 lab=_70149_/A }
C {devices/lab_pin.sym} 52240 -27840 0 0 {name=p51579 lab=_70146_/Y }
C {devices/lab_pin.sym} 52240 -27800 0 0 {name=p51580 lab=_70147_/Y }
C {devices/lab_pin.sym} 52240 -27760 0 0 {name=p51581 lab=_70148_/Y }
C {devices/lab_pin.sym} 52360 -27820 0 1 {name=p51582 lab=_70149_/X }
C {sky130_stdcells/and4_4.sym} 52300 -27820 0 0 {name=X_70149_ }
C {devices/lab_pin.sym} 52220 -27690 0 0 {name=p51583 lab=_47971_/X }
C {devices/lab_pin.sym} 52220 -27650 0 0 {name=p51584 lab=_82932_/Q }
C {devices/lab_pin.sym} 52220 -27610 0 0 {name=p51585 lab=_47973_/X }
C {devices/lab_pin.sym} 52380 -27650 0 1 {name=p51586 lab=_47975_/B }
C {sky130_stdcells/o21ai_4.sym} 52300 -27650 0 0 {name=X_47974_ }
C {devices/lab_pin.sym} 52220 -27550 0 0 {name=p51587 lab=_43085_/X }
C {devices/lab_pin.sym} 52220 -27510 0 0 {name=p51588 lab=_43086_/X }
C {devices/lab_pin.sym} 52220 -27470 0 0 {name=p51589 lab=_40734_/X }
C {devices/lab_pin.sym} 52220 -27430 0 0 {name=p51590 lab=_43096_/Y }
C {devices/lab_pin.sym} 52220 -27390 0 0 {name=p51591 lab=_43090_/X }
C {devices/lab_pin.sym} 52380 -27470 0 1 {name=p51592 lab=_87577_/D }
C {sky130_stdcells/o32ai_4.sym} 52300 -27470 0 0 {name=X_43097_ }
C {devices/lab_pin.sym} 52260 -27310 0 0 {name=p51593 lab=_78794_/A }
C {devices/lab_pin.sym} 52340 -27310 0 1 {name=p51594 lab=_78795_/B }
C {sky130_stdcells/inv_2.sym} 52300 -27310 0 0 {name=X_78794_ }
C {devices/lab_pin.sym} 52240 -27220 0 0 {name=p51595 lab=_49708_/A }
C {devices/lab_pin.sym} 52240 -27180 0 0 {name=p51596 lab=_49697_/B }
C {devices/lab_pin.sym} 52240 -27140 0 0 {name=p51597 lab=_49724_/C }
C {devices/lab_pin.sym} 52240 -27100 0 0 {name=p51598 lab=_52927_/D }
C {devices/lab_pin.sym} 52360 -27160 0 1 {name=p51599 lab=_49713_/X }
C {sky130_stdcells/and4_4.sym} 52300 -27160 0 0 {name=X_49713_ }
C {devices/lab_pin.sym} 52260 -27010 0 0 {name=p51600 lab=_46924_/Y }
C {devices/lab_pin.sym} 52340 -27010 0 1 {name=p51601 lab=_52750_/D }
C {sky130_stdcells/buf_2.sym} 52300 -27010 0 0 {name=X_46925_ }
C {devices/lab_pin.sym} 52220 -26930 0 0 {name=p51602 lab=_42035_/X }
C {devices/lab_pin.sym} 52220 -26890 0 0 {name=p51603 lab=_42010_/X }
C {devices/lab_pin.sym} 52220 -26850 0 0 {name=p51604 lab=_40899_/X }
C {devices/lab_pin.sym} 52220 -26810 0 0 {name=p51605 lab=_42047_/Y }
C {devices/lab_pin.sym} 52220 -26770 0 0 {name=p51606 lab=_42037_/X }
C {devices/lab_pin.sym} 52380 -26850 0 1 {name=p51607 lab=_88058_/D }
C {sky130_stdcells/o32ai_4.sym} 52300 -26850 0 0 {name=X_42048_ }
C {devices/lab_pin.sym} 52220 -26710 0 0 {name=p51608 lab=_77743_/A }
C {devices/lab_pin.sym} 52220 -26670 0 0 {name=p51609 lab=_77741_/Y }
C {devices/lab_pin.sym} 52220 -26630 0 0 {name=p51610 lab=_77739_/Y }
C {devices/lab_pin.sym} 52380 -26670 0 1 {name=p51611 lab=_77745_/Y }
C {sky130_stdcells/a21oi_4.sym} 52300 -26670 0 0 {name=X_77745_ }
C {devices/lab_pin.sym} 52240 -26560 0 0 {name=p51612 lab=_62971_/A }
C {devices/lab_pin.sym} 52240 -26520 0 0 {name=p51613 lab=_64536_/C }
C {devices/lab_pin.sym} 52240 -26480 0 0 {name=p51614 lab=_60302_/X }
C {devices/lab_pin.sym} 52240 -26440 0 0 {name=p51615 lab=_62979_/D }
C {devices/lab_pin.sym} 52360 -26500 0 1 {name=p51616 lab=_62971_/X }
C {sky130_stdcells/and4_4.sym} 52300 -26500 0 0 {name=X_62971_ }
C {devices/lab_pin.sym} 52240 -26360 0 0 {name=p51617 lab=_80762_/Q }
C {devices/lab_pin.sym} 52240 -26320 0 0 {name=p51618 lab=_74957_/B }
C {devices/lab_pin.sym} 52360 -26340 0 1 {name=p51619 lab=_74971_/A }
C {sky130_stdcells/xor2_4.sym} 52300 -26340 0 0 {name=X_74957_ }
C {devices/lab_pin.sym} 52240 -26220 0 0 {name=p51620 lab=_64710_/A }
C {devices/lab_pin.sym} 52240 -26180 0 0 {name=p51621 lab=_64710_/B }
C {devices/lab_pin.sym} 52360 -26200 0 1 {name=p51622 lab=_64710_/X }
C {sky130_stdcells/and2_4.sym} 52300 -26200 0 0 {name=X_64710_ }
C {devices/lab_pin.sym} 52260 -26070 0 0 {name=p51623 lab=_84877_/Q }
C {devices/lab_pin.sym} 52340 -26070 0 1 {name=p51624 lab=_61922_/X }
C {sky130_stdcells/buf_2.sym} 52300 -26070 0 0 {name=X_61922_ }
C {devices/lab_pin.sym} 52240 -25960 0 0 {name=p51625 lab=_49638_/A }
C {devices/lab_pin.sym} 52240 -25920 0 0 {name=p51626 lab=_52859_/B }
C {devices/lab_pin.sym} 52360 -25940 0 1 {name=p51627 lab=_49644_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -25940 0 0 {name=X_49644_ }
C {devices/lab_pin.sym} 52240 -25820 0 0 {name=p51628 lab=_73954_/A }
C {devices/lab_pin.sym} 52240 -25780 0 0 {name=p51629 lab=_66119_/B }
C {devices/lab_pin.sym} 52360 -25800 0 1 {name=p51630 lab=_73908_/X }
C {sky130_stdcells/and2_4.sym} 52300 -25800 0 0 {name=X_73908_ }
C {devices/lab_pin.sym} 52260 -25670 0 0 {name=p51631 lab=_46856_/A }
C {devices/lab_pin.sym} 52340 -25670 0 1 {name=p51632 lab=_52716_/D }
C {sky130_stdcells/buf_2.sym} 52300 -25670 0 0 {name=X_46856_ }
C {devices/lab_pin.sym} 52220 -25580 0 0 {name=p51633 lab=_65638_/X }
C {devices/lab_pin.sym} 52220 -25540 0 0 {name=p51634 lab=_85584_/Q }
C {devices/lab_pin.sym} 52220 -25500 0 0 {name=p51635 lab=_65669_/X }
C {devices/lab_pin.sym} 52220 -25460 0 0 {name=p51636 lab=_65689_/X }
C {devices/lab_pin.sym} 52380 -25520 0 1 {name=p51637 lab=_65690_/X }
C {sky130_stdcells/a211o_4.sym} 52300 -25520 0 0 {name=X_65690_ }
C {devices/lab_pin.sym} 52240 -25390 0 0 {name=p51638 lab=_77676_/A }
C {devices/lab_pin.sym} 52240 -25350 0 0 {name=p51639 lab=_77673_/Y }
C {devices/lab_pin.sym} 52240 -25310 0 0 {name=p51640 lab=_77675_/Y }
C {devices/lab_pin.sym} 52360 -25350 0 1 {name=p51641 lab=_77676_/X }
C {sky130_stdcells/or3_4.sym} 52300 -25350 0 0 {name=X_77676_ }
C {devices/lab_pin.sym} 52240 -25220 0 0 {name=p51642 lab=_74888_/A }
C {devices/lab_pin.sym} 52240 -25180 0 0 {name=p51643 lab=_74887_/Y }
C {devices/lab_pin.sym} 52360 -25200 0 1 {name=p51644 lab=_74889_/A }
C {sky130_stdcells/and2_4.sym} 52300 -25200 0 0 {name=X_74888_ }
C {devices/lab_pin.sym} 52240 -25080 0 0 {name=p51645 lab=_79415_/A }
C {devices/lab_pin.sym} 52240 -25040 0 0 {name=p51646 lab=_79414_/X }
C {devices/lab_pin.sym} 52360 -25060 0 1 {name=p51647 lab=_79416_/B }
C {sky130_stdcells/xnor2_4.sym} 52300 -25060 0 0 {name=X_79415_ }
C {devices/lab_pin.sym} 52220 -24950 0 0 {name=p51648 lab=_45797_/X }
C {devices/lab_pin.sym} 52220 -24910 0 0 {name=p51649 lab=_45804_/Y }
C {devices/lab_pin.sym} 52220 -24870 0 0 {name=p51650 lab=_45806_/Y }
C {devices/lab_pin.sym} 52380 -24910 0 1 {name=p51651 lab=_45807_/Y }
C {sky130_stdcells/a21oi_4.sym} 52300 -24910 0 0 {name=X_45807_ }
C {devices/lab_pin.sym} 52220 -24800 0 0 {name=p51652 lab=_64564_/X }
C {devices/lab_pin.sym} 52220 -24760 0 0 {name=p51653 lab=_86143_/Q }
C {devices/lab_pin.sym} 52220 -24720 0 0 {name=p51654 lab=_64566_/X }
C {devices/lab_pin.sym} 52220 -24680 0 0 {name=p51655 lab=_64640_/X }
C {devices/lab_pin.sym} 52380 -24740 0 1 {name=p51656 lab=_64641_/X }
C {sky130_stdcells/a211o_4.sym} 52300 -24740 0 0 {name=X_64641_ }
C {devices/lab_pin.sym} 52240 -24600 0 0 {name=p51657 lab=_76624_/Y }
C {devices/lab_pin.sym} 52240 -24560 0 0 {name=p51658 lab=_76640_/A }
C {devices/lab_pin.sym} 52360 -24580 0 1 {name=p51659 lab=_76628_/A }
C {sky130_stdcells/nand2_4.sym} 52300 -24580 0 0 {name=X_76627_ }
C {devices/lab_pin.sym} 52220 -24470 0 0 {name=p51660 lab=_86362_/Q }
C {devices/lab_pin.sym} 52220 -24430 0 0 {name=p51661 lab=_49551_/X }
C {devices/lab_pin.sym} 52220 -24390 0 0 {name=p51662 lab=_49574_/Y }
C {devices/lab_pin.sym} 52380 -24430 0 1 {name=p51663 lab=_49575_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -24430 0 0 {name=X_49575_ }
C {devices/lab_pin.sym} 52240 -24320 0 0 {name=p51664 lab=_61871_/A }
C {devices/lab_pin.sym} 52240 -24280 0 0 {name=p51665 lab=_61839_/B }
C {devices/lab_pin.sym} 52240 -24240 0 0 {name=p51666 lab=_61839_/C }
C {devices/lab_pin.sym} 52240 -24200 0 0 {name=p51667 lab=_63100_/B }
C {devices/lab_pin.sym} 52360 -24260 0 1 {name=p51668 lab=_61853_/X }
C {sky130_stdcells/and4_4.sym} 52300 -24260 0 0 {name=X_61853_ }
C {devices/lab_pin.sym} 52260 -24110 0 0 {name=p51669 lab=_73367_/A }
C {devices/lab_pin.sym} 52340 -24110 0 1 {name=p51670 lab=_73839_/X }
C {sky130_stdcells/buf_2.sym} 52300 -24110 0 0 {name=X_73839_ }
C {devices/lab_pin.sym} 52260 -23990 0 0 {name=p51671 lab=_54364_/B }
C {devices/lab_pin.sym} 52340 -23990 0 1 {name=p51672 lab=_50981_/B }
C {sky130_stdcells/buf_2.sym} 52300 -23990 0 0 {name=X_46787_ }
C {devices/lab_pin.sym} 52260 -23870 0 0 {name=p51673 lab=_59516_/A }
C {devices/lab_pin.sym} 52340 -23870 0 1 {name=p51674 lab=_59598_/A }
C {sky130_stdcells/buf_2.sym} 52300 -23870 0 0 {name=X_43999_ }
C {devices/lab_pin.sym} 52260 -23750 0 0 {name=p51675 lab=_74437_/B }
C {devices/lab_pin.sym} 52340 -23750 0 1 {name=p51676 lab=_48788_/B }
C {sky130_stdcells/buf_2.sym} 52300 -23750 0 0 {name=X_48526_ }
C {devices/lab_pin.sym} 52240 -23650 0 0 {name=p51677 lab=_63699_/D }
C {devices/lab_pin.sym} 52240 -23610 0 0 {name=p51678 lab=_60804_/B }
C {devices/lab_pin.sym} 52240 -23570 0 0 {name=p51679 lab=_60804_/C }
C {devices/lab_pin.sym} 52360 -23610 0 1 {name=p51680 lab=_60804_/Y }
C {sky130_stdcells/nor3_4.sym} 52300 -23610 0 0 {name=X_60804_ }
C {devices/lab_pin.sym} 52260 -23470 0 0 {name=p51681 lab=_67359_/X }
C {devices/lab_pin.sym} 52340 -23470 0 1 {name=p51682 lab=_67360_/X }
C {sky130_stdcells/buf_2.sym} 52300 -23470 0 0 {name=X_67360_ }
C {devices/lab_pin.sym} 52240 -23360 0 0 {name=p51683 lab=_79346_/A }
C {devices/lab_pin.sym} 52240 -23320 0 0 {name=p51684 lab=_79346_/B }
C {devices/lab_pin.sym} 52360 -23340 0 1 {name=p51685 lab=_79346_/X }
C {sky130_stdcells/or2_4.sym} 52300 -23340 0 0 {name=X_79346_ }
C {devices/lab_pin.sym} 52260 -23210 0 0 {name=p51686 lab=_85035_/Q }
C {devices/lab_pin.sym} 52340 -23210 0 1 {name=p51687 lab=_45738_/Y }
C {sky130_stdcells/inv_2.sym} 52300 -23210 0 0 {name=X_45738_ }
C {devices/lab_pin.sym} 52240 -23100 0 0 {name=p51688 lab=_58785_/A }
C {devices/lab_pin.sym} 52240 -23060 0 0 {name=p51689 lab=_64572_/B }
C {devices/lab_pin.sym} 52360 -23080 0 1 {name=p51690 lab=_64572_/X }
C {sky130_stdcells/and2_4.sym} 52300 -23080 0 0 {name=X_64572_ }
C {devices/lab_pin.sym} 52220 -22970 0 0 {name=p51691 lab=_76554_/X }
C {devices/lab_pin.sym} 52220 -22930 0 0 {name=p51692 lab=_76555_/Y }
C {devices/lab_pin.sym} 52220 -22890 0 0 {name=p51693 lab=_76560_/B }
C {devices/lab_pin.sym} 52380 -22930 0 1 {name=p51694 lab=_76559_/A }
C {sky130_stdcells/a21oi_4.sym} 52300 -22930 0 0 {name=X_76558_ }
C {devices/lab_pin.sym} 52240 -22810 0 0 {name=p51695 lab=_61752_/A }
C {devices/lab_pin.sym} 52240 -22770 0 0 {name=p51696 lab=_61723_/X }
C {devices/lab_pin.sym} 52240 -22730 0 0 {name=p51697 lab=_78077_/B }
C {devices/lab_pin.sym} 52360 -22770 0 1 {name=p51698 lab=_61784_/Y }
C {sky130_stdcells/nor3_4.sym} 52300 -22770 0 0 {name=X_61784_ }
C {devices/lab_pin.sym} 52220 -22660 0 0 {name=p51699 lab=_66236_/X }
C {devices/lab_pin.sym} 52220 -22620 0 0 {name=p51700 lab=_85605_/Q }
C {devices/lab_pin.sym} 52220 -22580 0 0 {name=p51701 lab=_66251_/X }
C {devices/lab_pin.sym} 52220 -22540 0 0 {name=p51702 lab=_66310_/X }
C {devices/lab_pin.sym} 52380 -22600 0 1 {name=p51703 lab=_66311_/X }
C {sky130_stdcells/a211o_4.sym} 52300 -22600 0 0 {name=X_66311_ }
C {devices/lab_pin.sym} 52240 -22460 0 0 {name=p51704 lab=_63523_/A }
C {devices/lab_pin.sym} 52240 -22420 0 0 {name=p51705 lab=_61939_/X }
C {devices/lab_pin.sym} 52360 -22440 0 1 {name=p51706 lab=_63523_/X }
C {sky130_stdcells/and2_4.sym} 52300 -22440 0 0 {name=X_63523_ }
C {devices/lab_pin.sym} 52240 -22340 0 0 {name=p51707 lab=_75509_/A }
C {devices/lab_pin.sym} 52240 -22300 0 0 {name=p51708 lab=_75481_/X }
C {devices/lab_pin.sym} 52240 -22260 0 0 {name=p51709 lab=_75509_/C }
C {devices/lab_pin.sym} 52240 -22220 0 0 {name=p51710 lab=_75458_/X }
C {devices/lab_pin.sym} 52360 -22280 0 1 {name=p51711 lab=_75509_/Y }
C {sky130_stdcells/nand4_4.sym} 52300 -22280 0 0 {name=X_75509_ }
C {devices/lab_pin.sym} 52220 -22150 0 0 {name=p51712 lab=_73016_/B }
C {devices/lab_pin.sym} 52220 -22110 0 0 {name=p51713 lab=_48419_/X }
C {devices/lab_pin.sym} 52220 -22070 0 0 {name=p51714 lab=_48456_/Y }
C {devices/lab_pin.sym} 52380 -22110 0 1 {name=p51715 lab=_48457_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -22110 0 0 {name=X_48457_ }
C {devices/lab_pin.sym} 52260 -21970 0 0 {name=p51716 lab=_60720_/A }
C {devices/lab_pin.sym} 52340 -21970 0 1 {name=p51717 lab=_63400_/C }
C {sky130_stdcells/buf_2.sym} 52300 -21970 0 0 {name=X_60735_ }
C {devices/lab_pin.sym} 52220 -21880 0 0 {name=p51718 lab=_88373_/Q }
C {devices/lab_pin.sym} 52220 -21840 0 0 {name=p51719 lab=_67193_/X }
C {devices/lab_pin.sym} 52220 -21800 0 0 {name=p51720 lab=_67194_/X }
C {devices/lab_pin.sym} 52220 -21760 0 0 {name=p51721 lab=_67290_/X }
C {devices/lab_pin.sym} 52380 -21820 0 1 {name=p51722 lab=_67291_/X }
C {sky130_stdcells/a211o_4.sym} 52300 -21820 0 0 {name=X_67291_ }
C {devices/lab_pin.sym} 52220 -21690 0 0 {name=p51723 lab=_58856_/Y }
C {devices/lab_pin.sym} 52220 -21650 0 0 {name=p51724 lab=_66484_/Y }
C {devices/lab_pin.sym} 52220 -21610 0 0 {name=p51725 lab=_79276_/Y }
C {devices/lab_pin.sym} 52380 -21650 0 1 {name=p51726 lab=_79277_/X }
C {sky130_stdcells/o21a_4.sym} 52300 -21650 0 0 {name=X_79277_ }
C {devices/lab_pin.sym} 52260 -21510 0 0 {name=p51727 lab=_63206_/B }
C {devices/lab_pin.sym} 52340 -21510 0 1 {name=p51728 lab=_61542_/A }
C {sky130_stdcells/buf_2.sym} 52300 -21510 0 0 {name=X_45669_ }
C {devices/lab_pin.sym} 52240 -21400 0 0 {name=p51729 lab=_76489_/A }
C {devices/lab_pin.sym} 52240 -21360 0 0 {name=p51730 lab=_81541_/Q }
C {devices/lab_pin.sym} 52360 -21380 0 1 {name=p51731 lab=_76489_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -21380 0 0 {name=X_76489_ }
C {devices/lab_pin.sym} 52260 -21250 0 0 {name=p51732 lab=clkbuf_3_7_1_CLK/X }
C {devices/lab_pin.sym} 52340 -21250 0 1 {name=p51733 lab=clkbuf_4_15_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 52300 -21250 0 0 {name=Xclkbuf_4_15_0_CLK }
C {devices/lab_pin.sym} 52260 -21130 0 0 {name=p51734 lab=_69233_/A }
C {devices/lab_pin.sym} 52340 -21130 0 1 {name=p51735 lab=_69134_/A }
C {sky130_stdcells/buf_2.sym} 52300 -21130 0 0 {name=X_69030_ }
C {devices/lab_pin.sym} 52240 -21040 0 0 {name=p51736 lab=_47418_/A }
C {devices/lab_pin.sym} 52240 -21000 0 0 {name=p51737 lab=_47408_/B }
C {devices/lab_pin.sym} 52240 -20960 0 0 {name=p51738 lab=_47377_/X }
C {devices/lab_pin.sym} 52240 -20920 0 0 {name=p51739 lab=_53031_/D }
C {devices/lab_pin.sym} 52360 -20980 0 1 {name=p51740 lab=_47408_/X }
C {sky130_stdcells/and4_4.sym} 52300 -20980 0 0 {name=X_47408_ }
C {devices/lab_pin.sym} 52240 -20840 0 0 {name=p51741 lab=_66226_/A }
C {devices/lab_pin.sym} 52240 -20800 0 0 {name=p51742 lab=_66242_/B }
C {devices/lab_pin.sym} 52360 -20820 0 1 {name=p51743 lab=_66242_/X }
C {sky130_stdcells/and2_4.sym} 52300 -20820 0 0 {name=X_66242_ }
C {devices/lab_pin.sym} 52240 -20700 0 0 {name=p51744 lab=_78228_/A }
C {devices/lab_pin.sym} 52240 -20660 0 0 {name=p51745 lab=_78228_/B }
C {devices/lab_pin.sym} 52360 -20680 0 1 {name=p51746 lab=_78228_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -20680 0 0 {name=X_78228_ }
C {devices/lab_pin.sym} 52220 -20590 0 0 {name=p51747 lab=_63434_/X }
C {devices/lab_pin.sym} 52220 -20550 0 0 {name=p51748 lab=_63448_/X }
C {devices/lab_pin.sym} 52220 -20510 0 0 {name=p51749 lab=_63449_/X }
C {devices/lab_pin.sym} 52220 -20470 0 0 {name=p51750 lab=_63452_/X }
C {devices/lab_pin.sym} 52220 -20430 0 0 {name=p51751 lab=_63453_/Y }
C {devices/lab_pin.sym} 52380 -20510 0 1 {name=p51752 lab=_63454_/Y }
C {sky130_stdcells/o41ai_4.sym} 52300 -20510 0 0 {name=X_63454_ }
C {devices/lab_pin.sym} 52240 -20370 0 0 {name=p51753 lab=_48388_/A }
C {devices/lab_pin.sym} 52240 -20330 0 0 {name=p51754 lab=_48364_/X }
C {devices/lab_pin.sym} 52240 -20290 0 0 {name=p51755 lab=_48354_/X }
C {devices/lab_pin.sym} 52360 -20330 0 1 {name=p51756 lab=_48388_/X }
C {sky130_stdcells/and3_4.sym} 52300 -20330 0 0 {name=X_48388_ }
C {devices/lab_pin.sym} 52260 -20190 0 0 {name=p51757 lab=_60665_/X }
C {devices/lab_pin.sym} 52340 -20190 0 1 {name=p51758 lab=_60667_/A }
C {sky130_stdcells/buf_2.sym} 52300 -20190 0 0 {name=X_60666_ }
C {devices/lab_pin.sym} 52240 -20100 0 0 {name=p51759 lab=_61490_/X }
C {devices/lab_pin.sym} 52240 -20060 0 0 {name=p51760 lab=_62420_/B }
C {devices/lab_pin.sym} 52240 -20020 0 0 {name=p51761 lab=_62420_/C }
C {devices/lab_pin.sym} 52240 -19980 0 0 {name=p51762 lab=_62404_/X }
C {devices/lab_pin.sym} 52360 -20040 0 1 {name=p51763 lab=_62405_/Y }
C {sky130_stdcells/nand4_4.sym} 52300 -20040 0 0 {name=X_62405_ }
C {devices/lab_pin.sym} 52260 -19890 0 0 {name=p51764 lab=_81813_/Q }
C {devices/lab_pin.sym} 52340 -19890 0 1 {name=p51765 lab=_54685_/D }
C {sky130_stdcells/inv_2.sym} 52300 -19890 0 0 {name=X_47339_ }
C {devices/lab_pin.sym} 52240 -19790 0 0 {name=p51766 lab=_66173_/A }
C {devices/lab_pin.sym} 52240 -19750 0 0 {name=p51767 lab=_66385_/B }
C {devices/lab_pin.sym} 52240 -19710 0 0 {name=p51768 lab=_66173_/C }
C {devices/lab_pin.sym} 52360 -19750 0 1 {name=p51769 lab=_66173_/Y }
C {sky130_stdcells/nand3_4.sym} 52300 -19750 0 0 {name=X_66173_ }
C {devices/lab_pin.sym} 52240 -19620 0 0 {name=p51770 lab=_78156_/Y }
C {devices/lab_pin.sym} 52240 -19580 0 0 {name=p51771 lab=_78159_/B }
C {devices/lab_pin.sym} 52360 -19600 0 1 {name=p51772 lab=_78160_/B }
C {sky130_stdcells/xor2_4.sym} 52300 -19600 0 0 {name=X_78159_ }
C {devices/lab_pin.sym} 52220 -19500 0 0 {name=p51773 lab=_58412_/A }
C {devices/lab_pin.sym} 52220 -19460 0 0 {name=p51774 lab=_63370_/X }
C {devices/lab_pin.sym} 52220 -19420 0 0 {name=p51775 lab=_61358_/A }
C {devices/lab_pin.sym} 52220 -19380 0 0 {name=p51776 lab=_63372_/X }
C {devices/lab_pin.sym} 52380 -19440 0 1 {name=p51777 lab=_63385_/X }
C {sky130_stdcells/a2bb2o_4.sym} 52300 -19440 0 0 {name=X_63385_ }
C {devices/lab_pin.sym} 52220 -19320 0 0 {name=p51778 lab=_79131_/A }
C {devices/lab_pin.sym} 52220 -19280 0 0 {name=p51779 lab=_60577_/X }
C {devices/lab_pin.sym} 52220 -19240 0 0 {name=p51780 lab=_60586_/D }
C {devices/lab_pin.sym} 52220 -19200 0 0 {name=p51781 lab=_60596_/Y }
C {devices/lab_pin.sym} 52380 -19260 0 1 {name=p51782 lab=_60597_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 52300 -19260 0 0 {name=X_60597_ }
C {devices/lab_pin.sym} 52240 -19120 0 0 {name=p51783 lab=_64924_/A }
C {devices/lab_pin.sym} 52240 -19080 0 0 {name=p51784 lab=_65124_/B }
C {devices/lab_pin.sym} 52360 -19100 0 1 {name=p51785 lab=_65124_/X }
C {sky130_stdcells/and2_4.sym} 52300 -19100 0 0 {name=X_65124_ }
C {devices/lab_pin.sym} 52220 -18990 0 0 {name=p51786 lab=_86218_/Q }
C {devices/lab_pin.sym} 52220 -18950 0 0 {name=p51787 lab=_50316_/X }
C {devices/lab_pin.sym} 52220 -18910 0 0 {name=p51788 lab=_50349_/Y }
C {devices/lab_pin.sym} 52380 -18950 0 1 {name=p51789 lab=_50350_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -18950 0 0 {name=X_50350_ }
C {devices/lab_pin.sym} 52260 -18810 0 0 {name=p51790 lab=_62336_/A }
C {devices/lab_pin.sym} 52340 -18810 0 1 {name=p51791 lab=_62337_/A }
C {sky130_stdcells/buf_2.sym} 52300 -18810 0 0 {name=X_62336_ }
C {devices/lab_pin.sym} 52210 -18690 0 0 {name=p51792 lab=_82335_/CLK }
C {devices/lab_pin.sym} 52210 -18670 0 0 {name=p51793 lab=_74964_/B }
C {devices/lab_pin.sym} 52390 -18690 0 1 {name=p51794 lab=_81170_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -18680 0 0 {name=X_81170_ }
C {devices/lab_pin.sym} 52240 -18560 0 0 {name=p51795 lab=_49009_/A }
C {devices/lab_pin.sym} 52240 -18520 0 0 {name=p51796 lab=_49009_/B }
C {devices/lab_pin.sym} 52360 -18540 0 1 {name=p51797 lab=_49009_/Y }
C {sky130_stdcells/nor2_4.sym} 52300 -18540 0 0 {name=X_49009_ }
C {devices/lab_pin.sym} 52240 -18420 0 0 {name=p51798 lab=_80121_/A }
C {devices/lab_pin.sym} 52240 -18380 0 0 {name=p51799 lab=_80121_/B }
C {devices/lab_pin.sym} 52360 -18400 0 1 {name=p51800 lab=_80121_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -18400 0 0 {name=X_80121_ }
C {devices/lab_pin.sym} 52220 -18300 0 0 {name=p51801 lab=_64704_/X }
C {devices/lab_pin.sym} 52220 -18260 0 0 {name=p51802 lab=_86736_/Q }
C {devices/lab_pin.sym} 52220 -18220 0 0 {name=p51803 lab=_64707_/X }
C {devices/lab_pin.sym} 52220 -18180 0 0 {name=p51804 lab=_65054_/X }
C {devices/lab_pin.sym} 52380 -18240 0 1 {name=p51805 lab=_65055_/X }
C {sky130_stdcells/a211o_4.sym} 52300 -18240 0 0 {name=X_65055_ }
C {devices/lab_pin.sym} 52240 -18100 0 0 {name=p51806 lab=_69897_/A }
C {devices/lab_pin.sym} 52240 -18060 0 0 {name=p51807 lab=_69932_/B }
C {devices/lab_pin.sym} 52360 -18080 0 1 {name=p51808 lab=_69932_/Y }
C {sky130_stdcells/nor2_4.sym} 52300 -18080 0 0 {name=X_69932_ }
C {devices/lab_pin.sym} 52260 -17950 0 0 {name=p51809 lab=_55686_/C }
C {devices/lab_pin.sym} 52340 -17950 0 1 {name=p51810 lab=_56892_/C }
C {sky130_stdcells/buf_2.sym} 52300 -17950 0 0 {name=Xpsn_inst_psn_buff_13 }
C {devices/lab_pin.sym} 52220 -17850 0 0 {name=p51811 lab=_50278_/Y }
C {devices/lab_pin.sym} 52220 -17810 0 0 {name=p51812 lab=_50274_/X }
C {devices/lab_pin.sym} 52220 -17770 0 0 {name=p51813 lab=_50280_/Y }
C {devices/lab_pin.sym} 52380 -17810 0 1 {name=p51814 lab=_86232_/D }
C {sky130_stdcells/a21boi_4.sym} 52300 -17810 0 0 {name=X_50281_ }
C {devices/lab_pin.sym} 52240 -17690 0 0 {name=p51815 lab=_62267_/A }
C {devices/lab_pin.sym} 52240 -17650 0 0 {name=p51816 lab=_62267_/B }
C {devices/lab_pin.sym} 52240 -17610 0 0 {name=p51817 lab=_76998_/B }
C {devices/lab_pin.sym} 52360 -17650 0 1 {name=p51818 lab=_62267_/Y }
C {sky130_stdcells/nor3_4.sym} 52300 -17650 0 0 {name=X_62267_ }
C {devices/lab_pin.sym} 52260 -17510 0 0 {name=p51819 lab=_53441_/A }
C {devices/lab_pin.sym} 52340 -17510 0 1 {name=p51820 lab=_53450_/A }
C {sky130_stdcells/buf_2.sym} 52300 -17510 0 0 {name=Xpsn_inst_psn_buff_24 }
C {devices/lab_pin.sym} 52220 -17410 0 0 {name=p51821 lab=_66153_/B }
C {devices/lab_pin.sym} 52220 -17370 0 0 {name=p51822 lab=_51994_/X }
C {devices/lab_pin.sym} 52220 -17330 0 0 {name=p51823 lab=_52019_/Y }
C {devices/lab_pin.sym} 52380 -17370 0 1 {name=p51824 lab=_52020_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -17370 0 0 {name=X_52020_ }
C {devices/lab_pin.sym} 52220 -17270 0 0 {name=p51825 lab=_64001_/X }
C {devices/lab_pin.sym} 52220 -17230 0 0 {name=p51826 lab=_63969_/X }
C {devices/lab_pin.sym} 52220 -17190 0 0 {name=p51827 lab=_64002_/Y }
C {devices/lab_pin.sym} 52220 -17150 0 0 {name=p51828 lab=_64003_/Y }
C {devices/lab_pin.sym} 52220 -17120 0 0 {name=p51829 lab=_64005_/X }
C {devices/lab_pin.sym} 52380 -17190 0 1 {name=p51830 lab=_64006_/X }
C {sky130_stdcells/a41o_4.sym} 52300 -17190 0 0 {name=X_64006_ }
C {devices/lab_pin.sym} 52220 -17050 0 0 {name=p51831 lab=_61103_/X }
C {devices/lab_pin.sym} 52220 -17010 0 0 {name=p51832 lab=_61096_/X }
C {devices/lab_pin.sym} 52220 -16970 0 0 {name=p51833 lab=_72590_/A }
C {devices/lab_pin.sym} 52380 -17010 0 1 {name=p51834 lab=_61218_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -17010 0 0 {name=X_61218_ }
C {devices/lab_pin.sym} 52240 -16880 0 0 {name=p51835 lab=_80030_/A }
C {devices/lab_pin.sym} 52240 -16840 0 0 {name=p51836 lab=_80052_/B }
C {devices/lab_pin.sym} 52360 -16860 0 1 {name=p51837 lab=_80052_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -16860 0 0 {name=X_80052_ }
C {devices/lab_pin.sym} 52260 -16730 0 0 {name=p51838 lab=clkbuf_9_504_0_CLK/X }
C {devices/lab_pin.sym} 52340 -16730 0 1 {name=p51839 lab=_83572_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 52300 -16730 0 0 {name=Xclkbuf_10_1008_0_CLK }
C {devices/lab_pin.sym} 52220 -16640 0 0 {name=p51840 lab=_73323_/A }
C {devices/lab_pin.sym} 52220 -16600 0 0 {name=p51841 lab=_68377_/X }
C {devices/lab_pin.sym} 52220 -16560 0 0 {name=p51842 lab=_66574_/X }
C {devices/lab_pin.sym} 52220 -16520 0 0 {name=p51843 lab=_69862_/Y }
C {devices/lab_pin.sym} 52380 -16580 0 1 {name=p51844 lab=_69863_/X }
C {sky130_stdcells/a211o_4.sym} 52300 -16580 0 0 {name=X_69863_ }
C {devices/lab_pin.sym} 52240 -16460 0 0 {name=p51845 lab=_62237_/A }
C {devices/lab_pin.sym} 52240 -16420 0 0 {name=p51846 lab=_62198_/B }
C {devices/lab_pin.sym} 52240 -16380 0 0 {name=p51847 lab=_59985_/A }
C {devices/lab_pin.sym} 52240 -16340 0 0 {name=p51848 lab=_59943_/A }
C {devices/lab_pin.sym} 52360 -16400 0 1 {name=p51849 lab=_62198_/Y }
C {sky130_stdcells/nand4_4.sym} 52300 -16400 0 0 {name=X_62198_ }
C {devices/lab_pin.sym} 52220 -16280 0 0 {name=p51850 lab=_88001_/Q }
C {devices/lab_pin.sym} 52220 -16240 0 0 {name=p51851 lab=_68715_/X }
C {devices/lab_pin.sym} 52220 -16200 0 0 {name=p51852 lab=_68540_/X }
C {devices/lab_pin.sym} 52220 -16160 0 0 {name=p51853 lab=_68813_/X }
C {devices/lab_pin.sym} 52380 -16220 0 1 {name=p51854 lab=_68814_/X }
C {sky130_stdcells/a211o_4.sym} 52300 -16220 0 0 {name=X_68814_ }
C {devices/lab_pin.sym} 52260 -16070 0 0 {name=p51855 lab=_61148_/X }
C {devices/lab_pin.sym} 52340 -16070 0 1 {name=p51856 lab=_61149_/X }
C {sky130_stdcells/buf_2.sym} 52300 -16070 0 0 {name=X_61149_ }
C {devices/lab_pin.sym} 52210 -15950 0 0 {name=p51857 lab=_84358_/CLK }
C {devices/lab_pin.sym} 52210 -15930 0 0 {name=p51858 lab=_58395_/X }
C {devices/lab_pin.sym} 52390 -15950 0 1 {name=p51859 lab=_84860_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -15940 0 0 {name=X_84860_ }
C {devices/lab_pin.sym} 52220 -15840 0 0 {name=p51860 lab=_73198_/A }
C {devices/lab_pin.sym} 52220 -15800 0 0 {name=p51861 lab=_69751_/X }
C {devices/lab_pin.sym} 52220 -15760 0 0 {name=p51862 lab=_69779_/X }
C {devices/lab_pin.sym} 52220 -15720 0 0 {name=p51863 lab=_69793_/Y }
C {devices/lab_pin.sym} 52380 -15780 0 1 {name=p51864 lab=_69794_/X }
C {sky130_stdcells/a211o_4.sym} 52300 -15780 0 0 {name=X_69794_ }
C {devices/lab_pin.sym} 52210 -15630 0 0 {name=p51865 lab=_83813_/CLK }
C {devices/lab_pin.sym} 52210 -15610 0 0 {name=p51866 lab=_70286_/X }
C {devices/lab_pin.sym} 52390 -15630 0 1 {name=p51867 lab=_74756_/B }
C {sky130_stdcells/dfxtp_4.sym} 52300 -15620 0 0 {name=X_83811_ }
C {devices/lab_pin.sym} 52260 -15490 0 0 {name=p51868 lab=_68617_/A }
C {devices/lab_pin.sym} 52340 -15490 0 1 {name=p51869 lab=_68745_/X }
C {sky130_stdcells/buf_2.sym} 52300 -15490 0 0 {name=X_68745_ }
C {devices/lab_pin.sym} 52240 -15380 0 0 {name=p51870 lab=_53956_/X }
C {devices/lab_pin.sym} 52240 -15340 0 0 {name=p51871 lab=_53971_/B }
C {devices/lab_pin.sym} 52360 -15360 0 1 {name=p51872 lab=_53971_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -15360 0 0 {name=X_53971_ }
C {devices/lab_pin.sym} 52240 -15240 0 0 {name=p51873 lab=_64593_/A }
C {devices/lab_pin.sym} 52240 -15200 0 0 {name=p51874 lab=_85917_/Q }
C {devices/lab_pin.sym} 52360 -15220 0 1 {name=p51875 lab=_65957_/X }
C {sky130_stdcells/and2_4.sym} 52300 -15220 0 0 {name=X_65957_ }
C {devices/lab_pin.sym} 52210 -15090 0 0 {name=p51876 lab=_86697_/CLK }
C {devices/lab_pin.sym} 52210 -15070 0 0 {name=p51877 lab=_58908_/Y }
C {devices/lab_pin.sym} 52390 -15090 0 1 {name=p51878 lab=_84791_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -15080 0 0 {name=X_84791_ }
C {devices/lab_pin.sym} 52240 -14960 0 0 {name=p51879 lab=_83011_/Q }
C {devices/lab_pin.sym} 52240 -14920 0 0 {name=p51880 lab=_55710_/B }
C {devices/lab_pin.sym} 52360 -14940 0 1 {name=p51881 lab=_55710_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -14940 0 0 {name=X_55710_ }
C {devices/lab_pin.sym} 52210 -14810 0 0 {name=p51882 lab=_86530_/CLK }
C {devices/lab_pin.sym} 52210 -14790 0 0 {name=p51883 lab=_86530_/D }
C {devices/lab_pin.sym} 52390 -14810 0 1 {name=p51884 lab=_86530_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -14800 0 0 {name=X_86530_ }
C {devices/lab_pin.sym} 52220 -14690 0 0 {name=p51885 lab=_64905_/X }
C {devices/lab_pin.sym} 52220 -14650 0 0 {name=p51886 lab=_64907_/X }
C {devices/lab_pin.sym} 52220 -14610 0 0 {name=p51887 lab=_64729_/X }
C {devices/lab_pin.sym} 52380 -14650 0 1 {name=p51888 lab=_64908_/X }
C {sky130_stdcells/a21o_4.sym} 52300 -14650 0 0 {name=X_64908_ }
C {devices/lab_pin.sym} 52240 -14540 0 0 {name=p51889 lab=_52922_/A }
C {devices/lab_pin.sym} 52240 -14500 0 0 {name=p51890 lab=_52916_/B }
C {devices/lab_pin.sym} 52240 -14460 0 0 {name=p51891 lab=_52900_/C }
C {devices/lab_pin.sym} 52240 -14420 0 0 {name=p51892 lab=_47218_/D }
C {devices/lab_pin.sym} 52360 -14480 0 1 {name=p51893 lab=_52922_/X }
C {sky130_stdcells/and4_4.sym} 52300 -14480 0 0 {name=X_52922_ }
C {devices/lab_pin.sym} 52210 -14330 0 0 {name=p51894 lab=_86322_/CLK }
C {devices/lab_pin.sym} 52210 -14310 0 0 {name=p51895 lab=_70607_/Y }
C {devices/lab_pin.sym} 52390 -14330 0 1 {name=p51896 lab=_47323_/A }
C {sky130_stdcells/dfxtp_4.sym} 52300 -14320 0 0 {name=X_83742_ }
C {devices/lab_pin.sym} 52260 -14190 0 0 {name=p51897 lab=_46233_/Y }
C {devices/lab_pin.sym} 52340 -14190 0 1 {name=p51898 lab=_56691_/A }
C {sky130_stdcells/buf_2.sym} 52300 -14190 0 0 {name=X_56690_ }
C {devices/lab_pin.sym} 52210 -14070 0 0 {name=p51899 lab=_81197_/CLK }
C {devices/lab_pin.sym} 52210 -14050 0 0 {name=p51900 lab=_75424_/B }
C {devices/lab_pin.sym} 52390 -14070 0 1 {name=p51901 lab=_80954_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -14060 0 0 {name=X_80954_ }
C {devices/lab_pin.sym} 52240 -13940 0 0 {name=p51902 lab=_68750_/A }
C {devices/lab_pin.sym} 52240 -13900 0 0 {name=p51903 lab=_88359_/Q }
C {devices/lab_pin.sym} 52360 -13920 0 1 {name=p51904 lab=_68676_/X }
C {sky130_stdcells/and2_4.sym} 52300 -13920 0 0 {name=X_68676_ }
C {devices/lab_pin.sym} 52240 -13810 0 0 {name=p51905 lab=_65888_/A }
C {devices/lab_pin.sym} 52240 -13770 0 0 {name=p51906 lab=_65888_/B }
C {devices/lab_pin.sym} 52240 -13730 0 0 {name=p51907 lab=_65888_/C }
C {devices/lab_pin.sym} 52360 -13770 0 1 {name=p51908 lab=_65888_/Y }
C {sky130_stdcells/nor3_4.sym} 52300 -13770 0 0 {name=X_65888_ }
C {devices/lab_pin.sym} 52240 -13640 0 0 {name=p51909 lab=_55641_/A }
C {devices/lab_pin.sym} 52240 -13600 0 0 {name=p51910 lab=_55640_/Y }
C {devices/lab_pin.sym} 52360 -13620 0 1 {name=p51911 lab=_55641_/Y }
C {sky130_stdcells/nor2_4.sym} 52300 -13620 0 0 {name=X_55641_ }
C {devices/lab_pin.sym} 52220 -13520 0 0 {name=p51912 lab=_87911_/Q }
C {devices/lab_pin.sym} 52220 -13480 0 0 {name=p51913 lab=_67533_/X }
C {devices/lab_pin.sym} 52220 -13440 0 0 {name=p51914 lab=_67625_/X }
C {devices/lab_pin.sym} 52220 -13400 0 0 {name=p51915 lab=_67626_/X }
C {devices/lab_pin.sym} 52380 -13460 0 1 {name=p51916 lab=_67627_/X }
C {sky130_stdcells/a211o_4.sym} 52300 -13460 0 0 {name=X_67627_ }
C {devices/lab_pin.sym} 52210 -13310 0 0 {name=p51917 lab=_83623_/CLK }
C {devices/lab_pin.sym} 52210 -13290 0 0 {name=p51918 lab=_86461_/D }
C {devices/lab_pin.sym} 52390 -13310 0 1 {name=p51919 lab=_86461_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -13300 0 0 {name=X_86461_ }
C {devices/lab_pin.sym} 52240 -13200 0 0 {name=p51920 lab=_52853_/A }
C {devices/lab_pin.sym} 52240 -13160 0 0 {name=p51921 lab=_52853_/B }
C {devices/lab_pin.sym} 52240 -13120 0 0 {name=p51922 lab=_52853_/C }
C {devices/lab_pin.sym} 52240 -13080 0 0 {name=p51923 lab=_52853_/D }
C {devices/lab_pin.sym} 52360 -13140 0 1 {name=p51924 lab=_52853_/X }
C {sky130_stdcells/and4_4.sym} 52300 -13140 0 0 {name=X_52853_ }
C {devices/lab_pin.sym} 52240 -13000 0 0 {name=p51925 lab=_64825_/Y }
C {devices/lab_pin.sym} 52240 -12960 0 0 {name=p51926 lab=_64838_/Y }
C {devices/lab_pin.sym} 52360 -12980 0 1 {name=p51927 lab=_64839_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -12980 0 0 {name=X_64839_ }
C {devices/lab_pin.sym} 52210 -12850 0 0 {name=p51928 lab=_83673_/CLK }
C {devices/lab_pin.sym} 52210 -12830 0 0 {name=p51929 lab=_70889_/Y }
C {devices/lab_pin.sym} 52390 -12850 0 1 {name=p51930 lab=_46769_/A }
C {sky130_stdcells/dfxtp_4.sym} 52300 -12840 0 0 {name=X_83673_ }
C {devices/lab_pin.sym} 52210 -12710 0 0 {name=p51931 lab=_80854_/CLK }
C {devices/lab_pin.sym} 52210 -12690 0 0 {name=p51932 lab=_75748_/B }
C {devices/lab_pin.sym} 52390 -12710 0 1 {name=p51933 lab=_80885_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -12700 0 0 {name=X_80885_ }
C {devices/lab_pin.sym} 52210 -12570 0 0 {name=p51934 lab=_88133_/CLK }
C {devices/lab_pin.sym} 52210 -12550 0 0 {name=p51935 lab=_41517_/Y }
C {devices/lab_pin.sym} 52390 -12570 0 1 {name=p51936 lab=_88200_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -12560 0 0 {name=X_88200_ }
C {devices/lab_pin.sym} 52210 -12430 0 0 {name=p51937 lab=_85635_/CLK }
C {devices/lab_pin.sym} 52210 -12410 0 0 {name=p51938 lab=_85412_/D }
C {devices/lab_pin.sym} 52390 -12430 0 1 {name=p51939 lab=_85412_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -12420 0 0 {name=X_85412_ }
C {devices/lab_pin.sym} 52260 -12290 0 0 {name=p51940 lab=_51804_/A }
C {devices/lab_pin.sym} 52340 -12290 0 1 {name=p51941 lab=_51805_/A }
C {sky130_stdcells/buf_2.sym} 52300 -12290 0 0 {name=X_51804_ }
C {devices/lab_pin.sym} 52240 -12180 0 0 {name=p51942 lab=_58360_/A }
C {devices/lab_pin.sym} 52240 -12140 0 0 {name=p51943 lab=_58364_/B }
C {devices/lab_pin.sym} 52360 -12160 0 1 {name=p51944 lab=_58360_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -12160 0 0 {name=X_58360_ }
C {devices/lab_pin.sym} 52210 -12030 0 0 {name=p51945 lab=_82624_/CLK }
C {devices/lab_pin.sym} 52210 -12010 0 0 {name=p51946 lab=_79094_/X }
C {devices/lab_pin.sym} 52390 -12030 0 1 {name=p51947 lab=_82624_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -12020 0 0 {name=X_82624_ }
C {devices/lab_pin.sym} 52260 -11890 0 0 {name=p51948 lab=_44063_/X }
C {devices/lab_pin.sym} 52340 -11890 0 1 {name=p51949 lab=_55572_/X }
C {sky130_stdcells/buf_2.sym} 52300 -11890 0 0 {name=X_55572_ }
C {devices/lab_pin.sym} 52260 -11770 0 0 {name=p51950 lab=_67082_/A }
C {devices/lab_pin.sym} 52340 -11770 0 1 {name=p51951 lab=_67582_/A }
C {sky130_stdcells/buf_2.sym} 52300 -11770 0 0 {name=X_67558_ }
C {devices/lab_pin.sym} 52210 -11650 0 0 {name=p51952 lab=_86393_/CLK }
C {devices/lab_pin.sym} 52210 -11630 0 0 {name=p51953 lab=_49414_/Y }
C {devices/lab_pin.sym} 52390 -11650 0 1 {name=p51954 lab=_86392_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -11640 0 0 {name=X_86392_ }
C {devices/lab_pin.sym} 52260 -11510 0 0 {name=p51955 lab=_52757_/A }
C {devices/lab_pin.sym} 52340 -11510 0 1 {name=p51956 lab=_52784_/X }
C {sky130_stdcells/buf_2.sym} 52300 -11510 0 0 {name=X_52784_ }
C {devices/lab_pin.sym} 52220 -11430 0 0 {name=p51957 lab=_56730_/X }
C {devices/lab_pin.sym} 52220 -11390 0 0 {name=p51958 lab=_56766_/X }
C {devices/lab_pin.sym} 52220 -11350 0 0 {name=p51959 lab=_56785_/D }
C {devices/lab_pin.sym} 52220 -11310 0 0 {name=p51960 lab=_57318_/D }
C {devices/lab_pin.sym} 52220 -11280 0 0 {name=p51961 lab=_56767_/X }
C {devices/lab_pin.sym} 52380 -11350 0 1 {name=p51962 lab=_57311_/X }
C {sky130_stdcells/a41o_4.sym} 52300 -11350 0 0 {name=X_57311_ }
C {devices/lab_pin.sym} 52210 -11190 0 0 {name=p51963 lab=_86796_/CLK }
C {devices/lab_pin.sym} 52210 -11170 0 0 {name=p51964 lab=_41832_/X }
C {devices/lab_pin.sym} 52390 -11190 0 1 {name=p51965 lab=_88131_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -11180 0 0 {name=X_88131_ }
C {devices/lab_pin.sym} 52220 -11070 0 0 {name=p51966 lab=_54519_/Y }
C {devices/lab_pin.sym} 52220 -11030 0 0 {name=p51967 lab=_54502_/X }
C {devices/lab_pin.sym} 52220 -10990 0 0 {name=p51968 lab=_54522_/X }
C {devices/lab_pin.sym} 52380 -11030 0 1 {name=p51969 lab=_54523_/Y }
C {sky130_stdcells/a21oi_4.sym} 52300 -11030 0 0 {name=X_54523_ }
C {devices/lab_pin.sym} 52240 -10910 0 0 {name=p51970 lab=_64867_/B }
C {devices/lab_pin.sym} 52240 -10870 0 0 {name=p51971 lab=_66501_/B }
C {devices/lab_pin.sym} 52240 -10830 0 0 {name=p51972 lab=_66509_/C }
C {devices/lab_pin.sym} 52360 -10870 0 1 {name=p51973 lab=_66509_/X }
C {sky130_stdcells/and3_4.sym} 52300 -10870 0 0 {name=X_66509_ }
C {devices/lab_pin.sym} 52210 -10730 0 0 {name=p51974 lab=_85375_/CLK }
C {devices/lab_pin.sym} 52210 -10710 0 0 {name=p51975 lab=_54975_/Y }
C {devices/lab_pin.sym} 52390 -10730 0 1 {name=p51976 lab=_85343_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -10720 0 0 {name=X_85343_ }
C {devices/lab_pin.sym} 52240 -10620 0 0 {name=p51977 lab=_52588_/A }
C {devices/lab_pin.sym} 52240 -10580 0 0 {name=p51978 lab=_51721_/X }
C {devices/lab_pin.sym} 52240 -10540 0 0 {name=p51979 lab=_51715_/C }
C {devices/lab_pin.sym} 52240 -10500 0 0 {name=p51980 lab=_53257_/D }
C {devices/lab_pin.sym} 52360 -10560 0 1 {name=p51981 lab=_51735_/X }
C {sky130_stdcells/and4_4.sym} 52300 -10560 0 0 {name=X_51735_ }
C {devices/lab_pin.sym} 52260 -10410 0 0 {name=p51982 lab=_84886_/Q }
C {devices/lab_pin.sym} 52340 -10410 0 1 {name=p51983 lab=_63672_/B }
C {sky130_stdcells/buf_2.sym} 52300 -10410 0 0 {name=X_58291_ }
C {devices/lab_pin.sym} 52210 -10290 0 0 {name=p51984 lab=_82596_/CLK }
C {devices/lab_pin.sym} 52210 -10270 0 0 {name=p51985 lab=_82555_/D }
C {devices/lab_pin.sym} 52390 -10290 0 1 {name=p51986 lab=_82555_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -10280 0 0 {name=X_82555_ }
C {devices/lab_pin.sym} 52220 -10170 0 0 {name=p51987 lab=_67486_/X }
C {devices/lab_pin.sym} 52220 -10130 0 0 {name=p51988 lab=_67488_/X }
C {devices/lab_pin.sym} 52220 -10090 0 0 {name=p51989 lab=_67442_/X }
C {devices/lab_pin.sym} 52380 -10130 0 1 {name=p51990 lab=_67489_/X }
C {sky130_stdcells/a21o_4.sym} 52300 -10130 0 0 {name=X_67489_ }
C {devices/lab_pin.sym} 52260 -9990 0 0 {name=p51991 lab=clkbuf_9_330_0_CLK/X }
C {devices/lab_pin.sym} 52340 -9990 0 1 {name=p51992 lab=_87116_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 52300 -9990 0 0 {name=Xclkbuf_10_660_0_CLK }
C {devices/lab_pin.sym} 52220 -9900 0 0 {name=p51993 lab=_44288_/X }
C {devices/lab_pin.sym} 52220 -9860 0 0 {name=p51994 lab=_56584_/X }
C {devices/lab_pin.sym} 52220 -9820 0 0 {name=p51995 lab=_45460_/A }
C {devices/lab_pin.sym} 52220 -9780 0 0 {name=p51996 lab=_57238_/X }
C {devices/lab_pin.sym} 52380 -9840 0 1 {name=p51997 lab=_85053_/D }
C {sky130_stdcells/a2bb2o_4.sym} 52300 -9840 0 0 {name=X_57242_ }
C {devices/lab_pin.sym} 52210 -9690 0 0 {name=p51998 lab=_83918_/CLK }
C {devices/lab_pin.sym} 52210 -9670 0 0 {name=p51999 lab=_76155_/B }
C {devices/lab_pin.sym} 52390 -9690 0 1 {name=p52000 lab=_81506_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -9680 0 0 {name=X_81506_ }
C {devices/lab_pin.sym} 52220 -9580 0 0 {name=p52001 lab=_69216_/X }
C {devices/lab_pin.sym} 52220 -9540 0 0 {name=p52002 lab=_69226_/Y }
C {devices/lab_pin.sym} 52220 -9500 0 0 {name=p52003 lab=_69095_/X }
C {devices/lab_pin.sym} 52220 -9460 0 0 {name=p52004 lab=_69227_/Y }
C {devices/lab_pin.sym} 52380 -9520 0 1 {name=p52005 lab=_69228_/X }
C {sky130_stdcells/a211o_4.sym} 52300 -9520 0 0 {name=X_69228_ }
C {devices/lab_pin.sym} 52210 -9370 0 0 {name=p52006 lab=_88062_/CLK }
C {devices/lab_pin.sym} 52210 -9350 0 0 {name=p52007 lab=_88062_/D }
C {devices/lab_pin.sym} 52390 -9370 0 1 {name=p52008 lab=_42036_/A }
C {sky130_stdcells/dfxtp_4.sym} 52300 -9360 0 0 {name=X_88062_ }
C {devices/lab_pin.sym} 52260 -9230 0 0 {name=p52009 lab=_54401_/A }
C {devices/lab_pin.sym} 52340 -9230 0 1 {name=p52010 lab=_54471_/C }
C {sky130_stdcells/buf_2.sym} 52300 -9230 0 0 {name=X_54454_ }
C {devices/lab_pin.sym} 52210 -9110 0 0 {name=p52011 lab=_85277_/CLK }
C {devices/lab_pin.sym} 52210 -9090 0 0 {name=p52012 lab=_56212_/Y }
C {devices/lab_pin.sym} 52390 -9110 0 1 {name=p52013 lab=_56211_/C }
C {sky130_stdcells/dfxtp_4.sym} 52300 -9100 0 0 {name=X_85274_ }
C {devices/lab_pin.sym} 52220 -8990 0 0 {name=p52014 lab=_85968_/Q }
C {devices/lab_pin.sym} 52220 -8950 0 0 {name=p52015 lab=_51647_/X }
C {devices/lab_pin.sym} 52220 -8910 0 0 {name=p52016 lab=_51665_/Y }
C {devices/lab_pin.sym} 52380 -8950 0 1 {name=p52017 lab=_51666_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -8950 0 0 {name=X_51666_ }
C {devices/lab_pin.sym} 52210 -8810 0 0 {name=p52018 lab=_82485_/CLK }
C {devices/lab_pin.sym} 52210 -8790 0 0 {name=p52019 lab=_82486_/D }
C {devices/lab_pin.sym} 52390 -8810 0 1 {name=p52020 lab=_82862_/D }
C {sky130_stdcells/dfxtp_4.sym} 52300 -8800 0 0 {name=X_82486_ }
C {devices/lab_pin.sym} 52260 -8670 0 0 {name=p52021 lab=clkbuf_8_75_0_CLK/X }
C {devices/lab_pin.sym} 52340 -8670 0 1 {name=p52022 lab=clkbuf_9_151_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 52300 -8670 0 0 {name=Xclkbuf_9_151_0_CLK }
C {devices/lab_pin.sym} 52210 -8550 0 0 {name=p52023 lab=_88288_/CLK }
C {devices/lab_pin.sym} 52210 -8530 0 0 {name=p52024 lab=_44657_/Y }
C {devices/lab_pin.sym} 52390 -8550 0 1 {name=p52025 lab=_87013_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -8540 0 0 {name=X_87013_ }
C {devices/lab_pin.sym} 52260 -8410 0 0 {name=p52026 lab=_53352_/A }
C {devices/lab_pin.sym} 52340 -8410 0 1 {name=p52027 lab=_53405_/X }
C {sky130_stdcells/buf_2.sym} 52300 -8410 0 0 {name=X_53405_ }
C {devices/lab_pin.sym} 52210 -8290 0 0 {name=p52028 lab=_84223_/CLK }
C {devices/lab_pin.sym} 52210 -8270 0 0 {name=p52029 lab=_84225_/D }
C {devices/lab_pin.sym} 52390 -8290 0 1 {name=p52030 lab=_84225_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -8280 0 0 {name=X_84225_ }
C {devices/lab_pin.sym} 52240 -8160 0 0 {name=p52031 lab=_50597_/A }
C {devices/lab_pin.sym} 52240 -8120 0 0 {name=p52032 lab=_48992_/X }
C {devices/lab_pin.sym} 52360 -8140 0 1 {name=p52033 lab=_50617_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -8140 0 0 {name=X_50617_ }
C {devices/lab_pin.sym} 52210 -8010 0 0 {name=p52034 lab=_82648_/CLK }
C {devices/lab_pin.sym} 52210 -7990 0 0 {name=p52035 lab=_81469_/Q }
C {devices/lab_pin.sym} 52390 -8010 0 1 {name=p52036 lab=_76116_/B }
C {sky130_stdcells/dfxtp_4.sym} 52300 -8000 0 0 {name=X_81437_ }
C {devices/lab_pin.sym} 52240 -7880 0 0 {name=p52037 lab=_85068_/Q }
C {devices/lab_pin.sym} 52240 -7840 0 0 {name=p52038 lab=_56997_/X }
C {devices/lab_pin.sym} 52360 -7860 0 1 {name=p52039 lab=_57173_/Y }
C {sky130_stdcells/nor2_4.sym} 52300 -7860 0 0 {name=X_57173_ }
C {devices/lab_pin.sym} 52220 -7760 0 0 {name=p52040 lab=_69146_/X }
C {devices/lab_pin.sym} 52220 -7720 0 0 {name=p52041 lab=_69109_/X }
C {devices/lab_pin.sym} 52220 -7680 0 0 {name=p52042 lab=_69157_/Y }
C {devices/lab_pin.sym} 52220 -7640 0 0 {name=p52043 lab=_69158_/Y }
C {devices/lab_pin.sym} 52380 -7700 0 1 {name=p52044 lab=_69159_/X }
C {sky130_stdcells/a211o_4.sym} 52300 -7700 0 0 {name=X_69159_ }
C {devices/lab_pin.sym} 52260 -7550 0 0 {name=p52045 lab=_54385_/A }
C {devices/lab_pin.sym} 52340 -7550 0 1 {name=p52046 lab=_54395_/B }
C {sky130_stdcells/buf_2.sym} 52300 -7550 0 0 {name=X_54385_ }
C {devices/lab_pin.sym} 52220 -7450 0 0 {name=p52047 lab=_85981_/Q }
C {devices/lab_pin.sym} 52220 -7410 0 0 {name=p52048 lab=_51594_/X }
C {devices/lab_pin.sym} 52220 -7370 0 0 {name=p52049 lab=_51596_/Y }
C {devices/lab_pin.sym} 52380 -7410 0 1 {name=p52050 lab=_51597_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -7410 0 0 {name=X_51597_ }
C {devices/lab_pin.sym} 52240 -7290 0 0 {name=p52051 lab=_56131_/A }
C {devices/lab_pin.sym} 52240 -7250 0 0 {name=p52052 lab=_56140_/B }
C {devices/lab_pin.sym} 52240 -7210 0 0 {name=p52053 lab=_56124_/C }
C {devices/lab_pin.sym} 52360 -7250 0 1 {name=p52054 lab=_56124_/Y }
C {sky130_stdcells/nand3_4.sym} 52300 -7250 0 0 {name=X_56124_ }
C {devices/lab_pin.sym} 52240 -7120 0 0 {name=p52055 lab=_41350_/A }
C {devices/lab_pin.sym} 52240 -7080 0 0 {name=p52056 lab=_41325_/X }
C {devices/lab_pin.sym} 52360 -7100 0 1 {name=p52057 lab=_41350_/X }
C {sky130_stdcells/or2_4.sym} 52300 -7100 0 0 {name=X_41350_ }
C {devices/lab_pin.sym} 52240 -6980 0 0 {name=p52058 lab=_53332_/A }
C {devices/lab_pin.sym} 52240 -6940 0 0 {name=p52059 lab=_53336_/B }
C {devices/lab_pin.sym} 52360 -6960 0 1 {name=p52060 lab=_53336_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -6960 0 0 {name=X_53336_ }
C {devices/lab_pin.sym} 52220 -6850 0 0 {name=p52061 lab=_59368_/X }
C {devices/lab_pin.sym} 52220 -6810 0 0 {name=p52062 lab=_85981_/Q }
C {devices/lab_pin.sym} 52220 -6770 0 0 {name=p52063 lab=_72169_/X }
C {devices/lab_pin.sym} 52380 -6810 0 1 {name=p52064 lab=_72170_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -6810 0 0 {name=X_72170_ }
C {devices/lab_pin.sym} 52210 -6670 0 0 {name=p52065 lab=_82177_/CLK }
C {devices/lab_pin.sym} 52210 -6650 0 0 {name=p52066 lab=_84156_/D }
C {devices/lab_pin.sym} 52390 -6670 0 1 {name=p52067 lab=_84156_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -6660 0 0 {name=X_84156_ }
C {devices/lab_pin.sym} 52220 -6550 0 0 {name=p52068 lab=_50546_/Y }
C {devices/lab_pin.sym} 52220 -6510 0 0 {name=p52069 lab=_50525_/X }
C {devices/lab_pin.sym} 52220 -6470 0 0 {name=p52070 lab=_50547_/X }
C {devices/lab_pin.sym} 52380 -6510 0 1 {name=p52071 lab=_86180_/D }
C {sky130_stdcells/a21oi_4.sym} 52300 -6510 0 0 {name=X_50548_ }
C {devices/lab_pin.sym} 52210 -6370 0 0 {name=p52072 lab=_81333_/CLK }
C {devices/lab_pin.sym} 52210 -6350 0 0 {name=p52073 lab=_81368_/D }
C {devices/lab_pin.sym} 52390 -6370 0 1 {name=p52074 lab=_76486_/A }
C {sky130_stdcells/dfxtp_4.sym} 52300 -6360 0 0 {name=X_81368_ }
C {devices/lab_pin.sym} 52260 -6230 0 0 {name=p52075 lab=clkbuf_9_337_0_CLK/X }
C {devices/lab_pin.sym} 52340 -6230 0 1 {name=p52076 lab=_87652_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 52300 -6230 0 0 {name=Xclkbuf_10_675_0_CLK }
C {devices/lab_pin.sym} 52240 -6130 0 0 {name=p52077 lab=_71112_/X }
C {devices/lab_pin.sym} 52240 -6090 0 0 {name=p52078 lab=_71076_/B }
C {devices/lab_pin.sym} 52240 -6050 0 0 {name=p52079 lab=_71119_/C }
C {devices/lab_pin.sym} 52360 -6090 0 1 {name=p52080 lab=_71121_/Y }
C {sky130_stdcells/nand3_4.sym} 52300 -6090 0 0 {name=X_71121_ }
C {devices/lab_pin.sym} 52210 -5950 0 0 {name=p52081 lab=_82998_/CLK }
C {devices/lab_pin.sym} 52210 -5930 0 0 {name=p52082 lab=_83107_/D }
C {devices/lab_pin.sym} 52390 -5950 0 1 {name=p52083 lab=_70285_/C }
C {sky130_stdcells/dfxtp_4.sym} 52300 -5940 0 0 {name=X_83107_ }
C {devices/lab_pin.sym} 52260 -5810 0 0 {name=p52084 lab=_56055_/A }
C {devices/lab_pin.sym} 52340 -5810 0 1 {name=p52085 lab=_56055_/X }
C {sky130_stdcells/buf_2.sym} 52300 -5810 0 0 {name=X_56055_ }
C {devices/lab_pin.sym} 52240 -5700 0 0 {name=p52086 lab=_80318_/Y }
C {devices/lab_pin.sym} 52240 -5660 0 0 {name=p52087 lab=_80319_/B }
C {devices/lab_pin.sym} 52360 -5680 0 1 {name=p52088 lab=_80320_/B }
C {sky130_stdcells/nand2_4.sym} 52300 -5680 0 0 {name=X_80319_ }
C {devices/lab_pin.sym} 52220 -5570 0 0 {name=p52089 lab=_53264_/Y }
C {devices/lab_pin.sym} 52220 -5530 0 0 {name=p52090 lab=_51904_/X }
C {devices/lab_pin.sym} 52220 -5490 0 0 {name=p52091 lab=_53266_/X }
C {devices/lab_pin.sym} 52380 -5530 0 1 {name=p52092 lab=_53267_/Y }
C {sky130_stdcells/a21oi_4.sym} 52300 -5530 0 0 {name=X_53267_ }
C {devices/lab_pin.sym} 52220 -5410 0 0 {name=p52093 lab=_41255_/X }
C {devices/lab_pin.sym} 52220 -5370 0 0 {name=p52094 lab=_40760_/A }
C {devices/lab_pin.sym} 52220 -5330 0 0 {name=p52095 lab=_41280_/X }
C {devices/lab_pin.sym} 52380 -5370 0 1 {name=p52096 lab=_41281_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -5370 0 0 {name=X_41281_ }
C {devices/lab_pin.sym} 52210 -5230 0 0 {name=p52097 lab=_84087_/CLK }
C {devices/lab_pin.sym} 52210 -5210 0 0 {name=p52098 lab=_84087_/D }
C {devices/lab_pin.sym} 52390 -5230 0 1 {name=p52099 lab=_80911_/D }
C {sky130_stdcells/dfxtp_4.sym} 52300 -5220 0 0 {name=X_84087_ }
C {devices/lab_pin.sym} 52240 -5110 0 0 {name=p52100 lab=_52182_/A }
C {devices/lab_pin.sym} 52240 -5070 0 0 {name=p52101 lab=_50492_/B }
C {devices/lab_pin.sym} 52240 -5030 0 0 {name=p52102 lab=_50497_/C }
C {devices/lab_pin.sym} 52360 -5070 0 1 {name=p52103 lab=_50479_/X }
C {sky130_stdcells/and3_4.sym} 52300 -5070 0 0 {name=X_50479_ }
C {devices/lab_pin.sym} 52210 -4930 0 0 {name=p52104 lab=_81279_/CLK }
C {devices/lab_pin.sym} 52210 -4910 0 0 {name=p52105 lab=_76987_/X }
C {devices/lab_pin.sym} 52390 -4930 0 1 {name=p52106 lab=_81267_/D }
C {sky130_stdcells/dfxtp_4.sym} 52300 -4920 0 0 {name=X_81299_ }
C {devices/lab_pin.sym} 52260 -4790 0 0 {name=p52107 lab=clkbuf_8_83_0_CLK/X }
C {devices/lab_pin.sym} 52340 -4790 0 1 {name=p52108 lab=clkbuf_9_166_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 52300 -4790 0 0 {name=Xclkbuf_9_166_0_CLK }
C {devices/lab_pin.sym} 52220 -4690 0 0 {name=p52109 lab=_55003_/Y }
C {devices/lab_pin.sym} 52220 -4650 0 0 {name=p52110 lab=_54998_/X }
C {devices/lab_pin.sym} 52220 -4610 0 0 {name=p52111 lab=_55005_/X }
C {devices/lab_pin.sym} 52380 -4650 0 1 {name=p52112 lab=_85337_/D }
C {sky130_stdcells/a21oi_4.sym} 52300 -4650 0 0 {name=X_55006_ }
C {devices/lab_pin.sym} 52260 -4510 0 0 {name=p52113 lab=_43020_/A }
C {devices/lab_pin.sym} 52340 -4510 0 1 {name=p52114 lab=_43024_/A }
C {sky130_stdcells/buf_2.sym} 52300 -4510 0 0 {name=X_43020_ }
C {devices/lab_pin.sym} 52260 -4390 0 0 {name=p52115 lab=clkbuf_9_93_0_CLK/A }
C {devices/lab_pin.sym} 52340 -4390 0 1 {name=p52116 lab=clkbuf_9_93_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 52300 -4390 0 0 {name=Xclkbuf_9_93_0_CLK }
C {devices/lab_pin.sym} 52240 -4290 0 0 {name=p52117 lab=_52218_/A }
C {devices/lab_pin.sym} 52240 -4250 0 0 {name=p52118 lab=_52198_/X }
C {devices/lab_pin.sym} 52240 -4210 0 0 {name=p52119 lab=_52218_/C }
C {devices/lab_pin.sym} 52360 -4250 0 1 {name=p52120 lab=_52218_/X }
C {sky130_stdcells/and3_4.sym} 52300 -4250 0 0 {name=X_52218_ }
C {devices/lab_pin.sym} 52240 -4130 0 0 {name=p52121 lab=_71055_/A }
C {devices/lab_pin.sym} 52240 -4090 0 0 {name=p52122 lab=_70942_/B }
C {devices/lab_pin.sym} 52240 -4050 0 0 {name=p52123 lab=_71055_/C }
C {devices/lab_pin.sym} 52360 -4090 0 1 {name=p52124 lab=_71052_/Y }
C {sky130_stdcells/nand3_4.sym} 52300 -4090 0 0 {name=X_71052_ }
C {devices/lab_pin.sym} 52210 -3950 0 0 {name=p52125 lab=_87915_/CLK }
C {devices/lab_pin.sym} 52210 -3930 0 0 {name=p52126 lab=_87915_/D }
C {devices/lab_pin.sym} 52390 -3950 0 1 {name=p52127 lab=_87915_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -3940 0 0 {name=X_87915_ }
C {devices/lab_pin.sym} 52210 -3810 0 0 {name=p52128 lab=_83001_/CLK }
C {devices/lab_pin.sym} 52210 -3790 0 0 {name=p52129 lab=_74548_/Y }
C {devices/lab_pin.sym} 52390 -3810 0 1 {name=p52130 lab=_74547_/C }
C {sky130_stdcells/dfxtp_4.sym} 52300 -3800 0 0 {name=X_83038_ }
C {devices/lab_pin.sym} 52260 -3670 0 0 {name=p52131 lab=_53172_/A }
C {devices/lab_pin.sym} 52340 -3670 0 1 {name=p52132 lab=_53198_/X }
C {sky130_stdcells/buf_2.sym} 52300 -3670 0 0 {name=X_53198_ }
C {devices/lab_pin.sym} 52220 -3580 0 0 {name=p52133 lab=_69943_/X }
C {devices/lab_pin.sym} 52220 -3540 0 0 {name=p52134 lab=_68525_/Y }
C {devices/lab_pin.sym} 52220 -3500 0 0 {name=p52135 lab=_69984_/X }
C {devices/lab_pin.sym} 52220 -3460 0 0 {name=p52136 lab=_70002_/Y }
C {devices/lab_pin.sym} 52380 -3520 0 1 {name=p52137 lab=_70003_/X }
C {sky130_stdcells/a211o_4.sym} 52300 -3520 0 0 {name=X_70003_ }
C {devices/lab_pin.sym} 52260 -3370 0 0 {name=p52138 lab=_60341_/A }
C {devices/lab_pin.sym} 52340 -3370 0 1 {name=p52139 lab=_59814_/X }
C {sky130_stdcells/buf_2.sym} 52300 -3370 0 0 {name=X_59814_ }
C {devices/lab_pin.sym} 52220 -3270 0 0 {name=p52140 lab=_73040_/B }
C {devices/lab_pin.sym} 52220 -3230 0 0 {name=p52141 lab=_52125_/X }
C {devices/lab_pin.sym} 52220 -3190 0 0 {name=p52142 lab=_52148_/Y }
C {devices/lab_pin.sym} 52380 -3230 0 1 {name=p52143 lab=_52149_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -3230 0 0 {name=X_52149_ }
C {devices/lab_pin.sym} 52240 -3100 0 0 {name=p52144 lab=_75860_/A }
C {devices/lab_pin.sym} 52240 -3060 0 0 {name=p52145 lab=_75860_/B }
C {devices/lab_pin.sym} 52360 -3080 0 1 {name=p52146 lab=_75860_/X }
C {sky130_stdcells/xor2_4.sym} 52300 -3080 0 0 {name=X_75860_ }
C {devices/lab_pin.sym} 52210 -2950 0 0 {name=p52147 lab=_87850_/CLK }
C {devices/lab_pin.sym} 52210 -2930 0 0 {name=p52148 lab=_87846_/D }
C {devices/lab_pin.sym} 52390 -2950 0 1 {name=p52149 lab=_68692_/A }
C {sky130_stdcells/dfxtp_4.sym} 52300 -2940 0 0 {name=X_87846_ }
C {devices/lab_pin.sym} 52220 -2850 0 0 {name=p52150 lab=_83841_/Q }
C {devices/lab_pin.sym} 52220 -2810 0 0 {name=p52151 lab=_74731_/X }
C {devices/lab_pin.sym} 52220 -2770 0 0 {name=p52152 lab=_74804_/X }
C {devices/lab_pin.sym} 52220 -2730 0 0 {name=p52153 lab=_74805_/X }
C {devices/lab_pin.sym} 52220 -2690 0 0 {name=p52154 lab=_74810_/Y }
C {devices/lab_pin.sym} 52380 -2770 0 1 {name=p52155 lab=_74811_/X }
C {sky130_stdcells/a2111o_4.sym} 52300 -2770 0 0 {name=X_74811_ }
C {devices/lab_pin.sym} 52260 -2610 0 0 {name=p52156 lab=_59651_/B }
C {devices/lab_pin.sym} 52340 -2610 0 1 {name=p52157 lab=_59745_/X }
C {sky130_stdcells/buf_2.sym} 52300 -2610 0 0 {name=X_59745_ }
C {devices/lab_pin.sym} 52260 -2490 0 0 {name=p52158 lab=_44904_/A }
C {devices/lab_pin.sym} 52340 -2490 0 1 {name=p52159 lab=_44972_/A }
C {sky130_stdcells/inv_2.sym} 52300 -2490 0 0 {name=X_44971_ }
C {devices/lab_pin.sym} 52240 -2390 0 0 {name=p52160 lab=_56602_/X }
C {devices/lab_pin.sym} 52240 -2350 0 0 {name=p52161 lab=_85113_/Q }
C {devices/lab_pin.sym} 52240 -2310 0 0 {name=p52162 lab=_56953_/X }
C {devices/lab_pin.sym} 52360 -2350 0 1 {name=p52163 lab=_56957_/Y }
C {sky130_stdcells/nor3_4.sym} 52300 -2350 0 0 {name=X_56957_ }
C {devices/lab_pin.sym} 52220 -2230 0 0 {name=p52164 lab=_75778_/A }
C {devices/lab_pin.sym} 52220 -2190 0 0 {name=p52165 lab=_75789_/Y }
C {devices/lab_pin.sym} 52220 -2150 0 0 {name=p52166 lab=_75790_/X }
C {devices/lab_pin.sym} 52380 -2190 0 1 {name=p52167 lab=_75791_/Y }
C {sky130_stdcells/o21ai_4.sym} 52300 -2190 0 0 {name=X_75791_ }
C {devices/lab_pin.sym} 52210 -2050 0 0 {name=p52168 lab=_87525_/CLK }
C {devices/lab_pin.sym} 52210 -2030 0 0 {name=p52169 lab=_42672_/Y }
C {devices/lab_pin.sym} 52390 -2050 0 1 {name=p52170 lab=_69381_/B }
C {sky130_stdcells/dfxtp_4.sym} 52300 -2040 0 0 {name=X_87777_ }
C {devices/lab_pin.sym} 52210 -1910 0 0 {name=p52171 lab=_84991_/CLK }
C {devices/lab_pin.sym} 52210 -1890 0 0 {name=p52172 lab=_84989_/D }
C {devices/lab_pin.sym} 52390 -1910 0 1 {name=p52173 lab=_84989_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -1900 0 0 {name=X_84989_ }
C {devices/lab_pin.sym} 52260 -1770 0 0 {name=p52174 lab=_83679_/Q }
C {devices/lab_pin.sym} 52340 -1770 0 1 {name=p52175 lab=_52632_/B }
C {sky130_stdcells/inv_2.sym} 52300 -1770 0 0 {name=X_46710_ }
C {devices/lab_pin.sym} 52240 -1660 0 0 {name=p52176 lab=_77518_/A }
C {devices/lab_pin.sym} 52240 -1620 0 0 {name=p52177 lab=_82114_/Q }
C {devices/lab_pin.sym} 52360 -1640 0 1 {name=p52178 lab=_77530_/Y }
C {sky130_stdcells/nand2_4.sym} 52300 -1640 0 0 {name=X_77530_ }
C {devices/lab_pin.sym} 52220 -1550 0 0 {name=p52179 lab=_43916_/X }
C {devices/lab_pin.sym} 52220 -1510 0 0 {name=p52180 lab=_43902_/X }
C {devices/lab_pin.sym} 52220 -1470 0 0 {name=p52181 lab=_41403_/X }
C {devices/lab_pin.sym} 52220 -1430 0 0 {name=p52182 lab=_67856_/B }
C {devices/lab_pin.sym} 52220 -1390 0 0 {name=p52183 lab=_43917_/X }
C {devices/lab_pin.sym} 52380 -1470 0 1 {name=p52184 lab=_43922_/Y }
C {sky130_stdcells/o32ai_4.sym} 52300 -1470 0 0 {name=X_43922_ }
C {devices/lab_pin.sym} 52240 -1320 0 0 {name=p52185 lab=_55908_/A }
C {devices/lab_pin.sym} 52240 -1280 0 0 {name=p52186 lab=_55908_/B }
C {devices/lab_pin.sym} 52360 -1300 0 1 {name=p52187 lab=_55908_/X }
C {sky130_stdcells/and2_4.sym} 52300 -1300 0 0 {name=X_55908_ }
C {devices/lab_pin.sym} 52210 -1170 0 0 {name=p52188 lab=_86121_/CLK }
C {devices/lab_pin.sym} 52210 -1150 0 0 {name=p52189 lab=_46541_/Y }
C {devices/lab_pin.sym} 52390 -1170 0 1 {name=p52190 lab=_86728_/Q }
C {sky130_stdcells/dfxtp_4.sym} 52300 -1160 0 0 {name=X_86728_ }
C {devices/lab_pin.sym} 52240 -1050 0 0 {name=p52191 lab=_70588_/A }
C {devices/lab_pin.sym} 52240 -1010 0 0 {name=p52192 lab=_74742_/B }
C {devices/lab_pin.sym} 52240 -970 0 0 {name=p52193 lab=_71039_/D }
C {devices/lab_pin.sym} 52360 -1010 0 1 {name=p52194 lab=_74752_/A }
C {sky130_stdcells/nand3_4.sym} 52300 -1010 0 0 {name=X_74742_ }
C {devices/lab_pin.sym} 52260 -870 0 0 {name=p52195 lab=_81232_/Q }
C {devices/lab_pin.sym} 52340 -870 0 1 {name=p52196 lab=_47691_/A }
C {sky130_stdcells/inv_2.sym} 52300 -870 0 0 {name=X_47690_ }
C {devices/lab_pin.sym} 52240 -770 0 0 {name=p52197 lab=_59696_/A }
C {devices/lab_pin.sym} 52240 -730 0 0 {name=p52198 lab=_66514_/B }
C {devices/lab_pin.sym} 52240 -690 0 0 {name=p52199 lab=_80614_/A }
C {devices/lab_pin.sym} 52360 -730 0 1 {name=p52200 lab=_59676_/Y }
C {sky130_stdcells/nor3_4.sym} 52300 -730 0 0 {name=X_59676_ }
C {devices/lab_pin.sym} 53140 -42170 0 0 {name=p52201 lab=_56908_/A }
C {devices/lab_pin.sym} 53140 -42130 0 0 {name=p52202 lab=_71939_/X }
C {devices/lab_pin.sym} 53140 -42090 0 0 {name=p52203 lab=_71953_/Y }
C {devices/lab_pin.sym} 53300 -42130 0 1 {name=p52204 lab=_83315_/D }
C {sky130_stdcells/o21ai_4.sym} 53220 -42130 0 0 {name=X_71954_ }
C {devices/lab_pin.sym} 53140 -42010 0 0 {name=p52205 lab=_56572_/X }
C {devices/lab_pin.sym} 53140 -41970 0 0 {name=p52206 lab=_56886_/Y }
C {devices/lab_pin.sym} 53140 -41930 0 0 {name=p52207 lab=_56887_/Y }
C {devices/lab_pin.sym} 53300 -41970 0 1 {name=p52208 lab=_85126_/D }
C {sky130_stdcells/o21ai_4.sym} 53220 -41970 0 0 {name=X_56888_ }
C {devices/lab_pin.sym} 53180 -41830 0 0 {name=p52209 lab=clkbuf_9_306_0_CLK/X }
C {devices/lab_pin.sym} 53260 -41830 0 1 {name=p52210 lab=_80991_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 53220 -41830 0 0 {name=Xclkbuf_10_613_0_CLK }
C {devices/lab_pin.sym} 53180 -41710 0 0 {name=p52211 lab=_83686_/Q }
C {devices/lab_pin.sym} 53260 -41710 0 1 {name=p52212 lab=_52590_/B }
C {sky130_stdcells/inv_2.sym} 53220 -41710 0 0 {name=X_46641_ }
C {devices/lab_pin.sym} 53160 -41620 0 0 {name=p52213 lab=_70905_/A }
C {devices/lab_pin.sym} 53160 -41580 0 0 {name=p52214 lab=_70903_/B }
C {devices/lab_pin.sym} 53160 -41540 0 0 {name=p52215 lab=_70899_/C }
C {devices/lab_pin.sym} 53160 -41500 0 0 {name=p52216 lab=_70905_/D }
C {devices/lab_pin.sym} 53280 -41560 0 1 {name=p52217 lab=_70905_/Y }
C {sky130_stdcells/nand4_4.sym} 53220 -41560 0 0 {name=X_70905_ }
C {devices/lab_pin.sym} 53140 -41430 0 0 {name=p52218 lab=_58625_/X }
C {devices/lab_pin.sym} 53140 -41390 0 0 {name=p52219 lab=_85468_/Q }
C {devices/lab_pin.sym} 53140 -41350 0 0 {name=p52220 lab=_58626_/X }
C {devices/lab_pin.sym} 53300 -41390 0 1 {name=p52221 lab=_58627_/Y }
C {sky130_stdcells/o21ai_4.sym} 53220 -41390 0 0 {name=X_58627_ }
C {devices/lab_pin.sym} 53140 -41270 0 0 {name=p52222 lab=_77424_/Y }
C {devices/lab_pin.sym} 53140 -41230 0 0 {name=p52223 lab=_77426_/X }
C {devices/lab_pin.sym} 53140 -41190 0 0 {name=p52224 lab=_77449_/X }
C {devices/lab_pin.sym} 53300 -41230 0 1 {name=p52225 lab=_77461_/X }
C {sky130_stdcells/a21bo_4.sym} 53220 -41230 0 0 {name=X_77461_ }
C {devices/lab_pin.sym} 53180 -41090 0 0 {name=p52226 lab=_43852_/Y }
C {devices/lab_pin.sym} 53260 -41090 0 1 {name=p52227 lab=_87233_/D }
C {sky130_stdcells/inv_2.sym} 53220 -41090 0 0 {name=X_43853_ }
C {devices/lab_pin.sym} 53140 -41000 0 0 {name=p52228 lab=_56420_/C }
C {devices/lab_pin.sym} 53140 -40960 0 0 {name=p52229 lab=_44063_/X }
C {devices/lab_pin.sym} 53140 -40920 0 0 {name=p52230 lab=_55523_/X }
C {devices/lab_pin.sym} 53140 -40880 0 0 {name=p52231 lab=_55838_/X }
C {devices/lab_pin.sym} 53300 -40940 0 1 {name=p52232 lab=_55839_/X }
C {sky130_stdcells/a211o_4.sym} 53220 -40940 0 0 {name=X_55839_ }
C {devices/lab_pin.sym} 53160 -40800 0 0 {name=p52233 lab=_74673_/A }
C {devices/lab_pin.sym} 53160 -40760 0 0 {name=p52234 lab=_45713_/A }
C {devices/lab_pin.sym} 53280 -40780 0 1 {name=p52235 lab=_74673_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -40780 0 0 {name=X_74673_ }
C {devices/lab_pin.sym} 53130 -40650 0 0 {name=p52236 lab=_86665_/CLK }
C {devices/lab_pin.sym} 53130 -40630 0 0 {name=p52237 lab=_47211_/Y }
C {devices/lab_pin.sym} 53310 -40650 0 1 {name=p52238 lab=_59373_/A }
C {sky130_stdcells/dfxtp_4.sym} 53220 -40640 0 0 {name=X_86659_ }
C {devices/lab_pin.sym} 53160 -40540 0 0 {name=p52239 lab=_71863_/A }
C {devices/lab_pin.sym} 53160 -40500 0 0 {name=p52240 lab=_71783_/A }
C {devices/lab_pin.sym} 53160 -40460 0 0 {name=p52241 lab=_71783_/C }
C {devices/lab_pin.sym} 53160 -40420 0 0 {name=p52242 lab=_71883_/D }
C {devices/lab_pin.sym} 53280 -40480 0 1 {name=p52243 lab=_71885_/Y }
C {sky130_stdcells/nor4_4.sym} 53220 -40480 0 0 {name=X_71885_ }
C {devices/lab_pin.sym} 53180 -40330 0 0 {name=p52244 lab=clkbuf_8_52_0_CLK/X }
C {devices/lab_pin.sym} 53260 -40330 0 1 {name=p52245 lab=clkbuf_9_104_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 53220 -40330 0 0 {name=Xclkbuf_9_104_0_CLK }
C {devices/lab_pin.sym} 53160 -40220 0 0 {name=p52246 lab=_84789_/Q }
C {devices/lab_pin.sym} 53160 -40180 0 0 {name=p52247 lab=_66509_/C }
C {devices/lab_pin.sym} 53280 -40200 0 1 {name=p52248 lab=_79201_/A }
C {sky130_stdcells/nor2_4.sym} 53220 -40200 0 0 {name=X_79200_ }
C {devices/lab_pin.sym} 53160 -40090 0 0 {name=p52249 lab=_76408_/Y }
C {devices/lab_pin.sym} 53160 -40050 0 0 {name=p52250 lab=_76409_/Y }
C {devices/lab_pin.sym} 53160 -40010 0 0 {name=p52251 lab=_76411_/Y }
C {devices/lab_pin.sym} 53280 -40050 0 1 {name=p52252 lab=_76412_/X }
C {sky130_stdcells/or3_4.sym} 53220 -40050 0 0 {name=X_76412_ }
C {devices/lab_pin.sym} 53140 -39940 0 0 {name=p52253 lab=_41397_/X }
C {devices/lab_pin.sym} 53140 -39900 0 0 {name=p52254 lab=_42802_/X }
C {devices/lab_pin.sym} 53140 -39860 0 0 {name=p52255 lab=_87710_/Q }
C {devices/lab_pin.sym} 53140 -39820 0 0 {name=p52256 lab=_42803_/X }
C {devices/lab_pin.sym} 53300 -39880 0 1 {name=p52257 lab=_42804_/X }
C {sky130_stdcells/a2bb2o_4.sym} 53220 -39880 0 0 {name=X_42804_ }
C {devices/lab_pin.sym} 53180 -39730 0 0 {name=p52258 lab=clkbuf_9_31_0_CLK/A }
C {devices/lab_pin.sym} 53260 -39730 0 1 {name=p52259 lab=clkbuf_9_31_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 53220 -39730 0 0 {name=Xclkbuf_9_31_0_CLK }
C {devices/lab_pin.sym} 53180 -39610 0 0 {name=p52260 lab=_49415_/A }
C {devices/lab_pin.sym} 53260 -39610 0 1 {name=p52261 lab=_49360_/X }
C {sky130_stdcells/buf_2.sym} 53220 -39610 0 0 {name=X_49360_ }
C {devices/lab_pin.sym} 53180 -39490 0 0 {name=p52262 lab=_72978_/X }
C {devices/lab_pin.sym} 53260 -39490 0 1 {name=p52263 lab=_73624_/X }
C {sky130_stdcells/buf_2.sym} 53220 -39490 0 0 {name=X_73624_ }
C {devices/lab_pin.sym} 53160 -39400 0 0 {name=p52264 lab=_70863_/A }
C {devices/lab_pin.sym} 53160 -39360 0 0 {name=p52265 lab=_70846_/B }
C {devices/lab_pin.sym} 53160 -39320 0 0 {name=p52266 lab=_71066_/C }
C {devices/lab_pin.sym} 53160 -39280 0 0 {name=p52267 lab=_70841_/D }
C {devices/lab_pin.sym} 53280 -39340 0 1 {name=p52268 lab=_70836_/Y }
C {sky130_stdcells/nand4_4.sym} 53220 -39340 0 0 {name=X_70836_ }
C {devices/lab_pin.sym} 53180 -39190 0 0 {name=p52269 lab=_83780_/Q }
C {devices/lab_pin.sym} 53260 -39190 0 1 {name=p52270 lab=_52563_/B }
C {sky130_stdcells/inv_2.sym} 53220 -39190 0 0 {name=X_46572_ }
C {devices/lab_pin.sym} 53140 -39090 0 0 {name=p52271 lab=_58538_/X }
C {devices/lab_pin.sym} 53140 -39050 0 0 {name=p52272 lab=_83355_/Q }
C {devices/lab_pin.sym} 53140 -39010 0 0 {name=p52273 lab=_58557_/Y }
C {devices/lab_pin.sym} 53300 -39050 0 1 {name=p52274 lab=_84819_/D }
C {sky130_stdcells/o21a_4.sym} 53220 -39050 0 0 {name=X_58558_ }
C {devices/lab_pin.sym} 53180 -38910 0 0 {name=p52275 lab=_77392_/A }
C {devices/lab_pin.sym} 53260 -38910 0 1 {name=p52276 lab=_77394_/A }
C {sky130_stdcells/inv_2.sym} 53220 -38910 0 0 {name=X_77392_ }
C {devices/lab_pin.sym} 53140 -38830 0 0 {name=p52277 lab=_43774_/X }
C {devices/lab_pin.sym} 53140 -38790 0 0 {name=p52278 lab=_43781_/X }
C {devices/lab_pin.sym} 53140 -38750 0 0 {name=p52279 lab=_41016_/X }
C {devices/lab_pin.sym} 53140 -38710 0 0 {name=p52280 lab=_69332_/B }
C {devices/lab_pin.sym} 53140 -38670 0 0 {name=p52281 lab=_43776_/X }
C {devices/lab_pin.sym} 53300 -38750 0 1 {name=p52282 lab=_43784_/Y }
C {sky130_stdcells/o32ai_4.sym} 53220 -38750 0 0 {name=X_43784_ }
C {devices/lab_pin.sym} 53140 -38630 0 0 {name=p52283 lab=_40944_/X }
C {devices/lab_pin.sym} 53140 -38590 0 0 {name=p52284 lab=_40946_/X }
C {devices/lab_pin.sym} 53140 -38550 0 0 {name=p52285 lab=_40994_/X }
C {devices/lab_pin.sym} 53140 -38510 0 0 {name=p52286 lab=_88296_/Q }
C {devices/lab_pin.sym} 53140 -38470 0 0 {name=p52287 lab=_40995_/X }
C {devices/lab_pin.sym} 53300 -38550 0 1 {name=p52288 lab=_40996_/Y }
C {sky130_stdcells/o32ai_4.sym} 53220 -38550 0 0 {name=X_40996_ }
C {devices/lab_pin.sym} 53140 -38410 0 0 {name=p52289 lab=_66256_/B }
C {devices/lab_pin.sym} 53140 -38370 0 0 {name=p52290 lab=_48293_/X }
C {devices/lab_pin.sym} 53140 -38330 0 0 {name=p52291 lab=_48310_/Y }
C {devices/lab_pin.sym} 53300 -38370 0 1 {name=p52292 lab=_48311_/Y }
C {sky130_stdcells/o21ai_4.sym} 53220 -38370 0 0 {name=X_48311_ }
C {devices/lab_pin.sym} 53160 -38240 0 0 {name=p52293 lab=_79131_/A }
C {devices/lab_pin.sym} 53160 -38200 0 0 {name=p52294 lab=_79131_/B }
C {devices/lab_pin.sym} 53280 -38220 0 1 {name=p52295 lab=_79131_/X }
C {sky130_stdcells/xor2_4.sym} 53220 -38220 0 0 {name=X_79131_ }
C {devices/lab_pin.sym} 53180 -38090 0 0 {name=p52296 lab=_45678_/A }
C {devices/lab_pin.sym} 53260 -38090 0 1 {name=p52297 lab=_45523_/X }
C {sky130_stdcells/buf_2.sym} 53220 -38090 0 0 {name=X_45523_ }
C {devices/lab_pin.sym} 53160 -37980 0 0 {name=p52298 lab=_57499_/A }
C {devices/lab_pin.sym} 53160 -37940 0 0 {name=p52299 lab=_47880_/Y }
C {devices/lab_pin.sym} 53280 -37960 0 1 {name=p52300 lab=_57509_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -37960 0 0 {name=X_57509_ }
C {devices/lab_pin.sym} 53160 -37840 0 0 {name=p52301 lab=_76343_/A }
C {devices/lab_pin.sym} 53160 -37800 0 0 {name=p52302 lab=_81615_/D }
C {devices/lab_pin.sym} 53280 -37820 0 1 {name=p52303 lab=_76343_/X }
C {sky130_stdcells/xor2_4.sym} 53220 -37820 0 0 {name=X_76343_ }
C {devices/lab_pin.sym} 53130 -37690 0 0 {name=p52304 lab=_87288_/CLK }
C {devices/lab_pin.sym} 53130 -37670 0 0 {name=p52305 lab=_40816_/Y }
C {devices/lab_pin.sym} 53310 -37690 0 1 {name=p52306 lab=_88329_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -37680 0 0 {name=X_88329_ }
C {devices/lab_pin.sym} 53140 -37590 0 0 {name=p52307 lab=_42721_/X }
C {devices/lab_pin.sym} 53140 -37550 0 0 {name=p52308 lab=_42723_/X }
C {devices/lab_pin.sym} 53140 -37510 0 0 {name=p52309 lab=_41214_/X }
C {devices/lab_pin.sym} 53140 -37470 0 0 {name=p52310 lab=_68848_/B }
C {devices/lab_pin.sym} 53140 -37430 0 0 {name=p52311 lab=_42732_/X }
C {devices/lab_pin.sym} 53300 -37510 0 1 {name=p52312 lab=_42736_/A }
C {sky130_stdcells/o32ai_4.sym} 53220 -37510 0 0 {name=X_42735_ }
C {devices/lab_pin.sym} 53160 -37360 0 0 {name=p52313 lab=_49232_/A }
C {devices/lab_pin.sym} 53160 -37320 0 0 {name=p52314 lab=_51320_/B }
C {devices/lab_pin.sym} 53280 -37340 0 1 {name=p52315 lab=_49291_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -37340 0 0 {name=X_49291_ }
C {devices/lab_pin.sym} 53140 -37240 0 0 {name=p52316 lab=_43587_/Y }
C {devices/lab_pin.sym} 53140 -37200 0 0 {name=p52317 lab=_73030_/X }
C {devices/lab_pin.sym} 53140 -37160 0 0 {name=p52318 lab=_73486_/X }
C {devices/lab_pin.sym} 53140 -37120 0 0 {name=p52319 lab=_73554_/Y }
C {devices/lab_pin.sym} 53300 -37180 0 1 {name=p52320 lab=_73555_/X }
C {sky130_stdcells/a211o_4.sym} 53220 -37180 0 0 {name=X_73555_ }
C {devices/lab_pin.sym} 53180 -37030 0 0 {name=p52321 lab=clkbuf_9_314_0_CLK/X }
C {devices/lab_pin.sym} 53260 -37030 0 1 {name=p52322 lab=_82131_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 53220 -37030 0 0 {name=Xclkbuf_10_628_0_CLK }
C {devices/lab_pin.sym} 53140 -36930 0 0 {name=p52323 lab=_52837_/B }
C {devices/lab_pin.sym} 53140 -36890 0 0 {name=p52324 lab=_70761_/X }
C {devices/lab_pin.sym} 53140 -36850 0 0 {name=p52325 lab=_70766_/Y }
C {devices/lab_pin.sym} 53300 -36890 0 1 {name=p52326 lab=_70767_/Y }
C {sky130_stdcells/o21ai_4.sym} 53220 -36890 0 0 {name=X_70767_ }
C {devices/lab_pin.sym} 53180 -36750 0 0 {name=p52327 lab=_84836_/Q }
C {devices/lab_pin.sym} 53260 -36750 0 1 {name=p52328 lab=_58490_/A }
C {sky130_stdcells/inv_2.sym} 53220 -36750 0 0 {name=X_58489_ }
C {devices/lab_pin.sym} 53180 -36630 0 0 {name=p52329 lab=_48186_/A }
C {devices/lab_pin.sym} 53260 -36630 0 1 {name=p52330 lab=_49223_/A }
C {sky130_stdcells/buf_2.sym} 53220 -36630 0 0 {name=X_48242_ }
C {devices/lab_pin.sym} 53140 -36550 0 0 {name=p52331 lab=_60359_/X }
C {devices/lab_pin.sym} 53140 -36510 0 0 {name=p52332 lab=_60517_/Y }
C {devices/lab_pin.sym} 53140 -36470 0 0 {name=p52333 lab=_60481_/A }
C {devices/lab_pin.sym} 53140 -36430 0 0 {name=p52334 lab=_60518_/X }
C {devices/lab_pin.sym} 53140 -36400 0 0 {name=p52335 lab=_60519_/Y }
C {devices/lab_pin.sym} 53300 -36470 0 1 {name=p52336 lab=_60520_/Y }
C {sky130_stdcells/a41oi_4.sym} 53220 -36470 0 0 {name=X_60520_ }
C {devices/lab_pin.sym} 53160 -36340 0 0 {name=p52337 lab=_72516_/C }
C {devices/lab_pin.sym} 53160 -36300 0 0 {name=p52338 lab=_72535_/A }
C {devices/lab_pin.sym} 53160 -36260 0 0 {name=p52339 lab=_72506_/C }
C {devices/lab_pin.sym} 53160 -36220 0 0 {name=p52340 lab=_72535_/B }
C {devices/lab_pin.sym} 53280 -36280 0 1 {name=p52341 lab=_72506_/Y }
C {sky130_stdcells/nand4_4.sym} 53220 -36280 0 0 {name=X_72506_ }
C {devices/lab_pin.sym} 53180 -36130 0 0 {name=p52342 lab=_82654_/Q }
C {devices/lab_pin.sym} 53260 -36130 0 1 {name=p52343 lab=_79064_/A }
C {sky130_stdcells/inv_2.sym} 53220 -36130 0 0 {name=X_79062_ }
C {devices/lab_pin.sym} 53140 -36030 0 0 {name=p52344 lab=_45447_/X }
C {devices/lab_pin.sym} 53140 -35990 0 0 {name=p52345 lab=_45450_/X }
C {devices/lab_pin.sym} 53140 -35950 0 0 {name=p52346 lab=_45453_/Y }
C {devices/lab_pin.sym} 53300 -35990 0 1 {name=p52347 lab=_45454_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -35990 0 0 {name=X_45454_ }
C {devices/lab_pin.sym} 53160 -35860 0 0 {name=p52348 lab=_76274_/A }
C {devices/lab_pin.sym} 53160 -35820 0 0 {name=p52349 lab=_81610_/D }
C {devices/lab_pin.sym} 53280 -35840 0 1 {name=p52350 lab=_76274_/X }
C {sky130_stdcells/xor2_4.sym} 53220 -35840 0 0 {name=X_76274_ }
C {devices/lab_pin.sym} 53180 -35710 0 0 {name=p52351 lab=_42592_/A }
C {devices/lab_pin.sym} 53260 -35710 0 1 {name=p52352 lab=_42666_/X }
C {sky130_stdcells/buf_2.sym} 53220 -35710 0 0 {name=X_42666_ }
C {devices/lab_pin.sym} 53180 -35590 0 0 {name=p52353 lab=_72857_/X }
C {devices/lab_pin.sym} 53260 -35590 0 1 {name=p52354 lab=_73486_/X }
C {sky130_stdcells/buf_2.sym} 53220 -35590 0 0 {name=X_73486_ }
C {devices/lab_pin.sym} 53180 -35470 0 0 {name=p52355 lab=clkbuf_8_59_0_CLK/X }
C {devices/lab_pin.sym} 53260 -35470 0 1 {name=p52356 lab=clkbuf_9_119_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 53220 -35470 0 0 {name=Xclkbuf_9_119_0_CLK }
C {devices/lab_pin.sym} 53160 -35360 0 0 {name=p52357 lab=_70698_/A }
C {devices/lab_pin.sym} 53160 -35320 0 0 {name=p52358 lab=_70698_/B }
C {devices/lab_pin.sym} 53280 -35340 0 1 {name=p52359 lab=_70699_/A }
C {sky130_stdcells/nor2_4.sym} 53220 -35340 0 0 {name=X_70698_ }
C {devices/lab_pin.sym} 53180 -35210 0 0 {name=p52360 lab=clkbuf_9_47_0_CLK/A }
C {devices/lab_pin.sym} 53260 -35210 0 1 {name=p52361 lab=clkbuf_9_46_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 53220 -35210 0 0 {name=Xclkbuf_9_46_0_CLK }
C {devices/lab_pin.sym} 53180 -35090 0 0 {name=p52362 lab=_77999_/B }
C {devices/lab_pin.sym} 53260 -35090 0 1 {name=p52363 lab=_78013_/Y }
C {sky130_stdcells/inv_2.sym} 53220 -35090 0 0 {name=X_78013_ }
C {devices/lab_pin.sym} 53180 -34970 0 0 {name=p52364 lab=_44382_/A }
C {devices/lab_pin.sym} 53260 -34970 0 1 {name=p52365 lab=_44405_/X }
C {sky130_stdcells/buf_2.sym} 53220 -34970 0 0 {name=X_44405_ }
C {devices/lab_pin.sym} 53160 -34860 0 0 {name=p52366 lab=_75226_/A }
C {devices/lab_pin.sym} 53160 -34820 0 0 {name=p52367 lab=_80985_/Q }
C {devices/lab_pin.sym} 53280 -34840 0 1 {name=p52368 lab=_75225_/Y }
C {sky130_stdcells/nor2_4.sym} 53220 -34840 0 0 {name=X_75225_ }
C {devices/lab_pin.sym} 53140 -34750 0 0 {name=p52369 lab=_41611_/X }
C {devices/lab_pin.sym} 53140 -34710 0 0 {name=p52370 lab=_41613_/X }
C {devices/lab_pin.sym} 53140 -34670 0 0 {name=p52371 lab=_41616_/X }
C {devices/lab_pin.sym} 53140 -34630 0 0 {name=p52372 lab=_67279_/B }
C {devices/lab_pin.sym} 53140 -34590 0 0 {name=p52373 lab=_41608_/X }
C {devices/lab_pin.sym} 53300 -34670 0 1 {name=p52374 lab=_41617_/Y }
C {sky130_stdcells/o32ai_4.sym} 53220 -34670 0 0 {name=X_41617_ }
C {devices/lab_pin.sym} 53160 -34520 0 0 {name=p52375 lab=_86598_/Q }
C {devices/lab_pin.sym} 53160 -34480 0 0 {name=p52376 lab=_72428_/B }
C {devices/lab_pin.sym} 53280 -34500 0 1 {name=p52377 lab=_72437_/Y }
C {sky130_stdcells/nor2_4.sym} 53220 -34500 0 0 {name=X_72437_ }
C {devices/lab_pin.sym} 53160 -34380 0 0 {name=p52378 lab=_50048_/A }
C {devices/lab_pin.sym} 53160 -34340 0 0 {name=p52379 lab=_50224_/B }
C {devices/lab_pin.sym} 53280 -34360 0 1 {name=p52380 lab=_48173_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -34360 0 0 {name=X_48173_ }
C {devices/lab_pin.sym} 53140 -34270 0 0 {name=p52381 lab=_60408_/C }
C {devices/lab_pin.sym} 53140 -34230 0 0 {name=p52382 lab=_60408_/A }
C {devices/lab_pin.sym} 53140 -34190 0 0 {name=p52383 lab=_60439_/X }
C {devices/lab_pin.sym} 53140 -34150 0 0 {name=p52384 lab=_60440_/X }
C {devices/lab_pin.sym} 53140 -34120 0 0 {name=p52385 lab=_60588_/A }
C {devices/lab_pin.sym} 53300 -34190 0 1 {name=p52386 lab=_60572_/C }
C {sky130_stdcells/a41o_4.sym} 53220 -34190 0 0 {name=X_60451_ }
C {devices/lab_pin.sym} 53140 -34050 0 0 {name=p52387 lab=_45377_/X }
C {devices/lab_pin.sym} 53140 -34010 0 0 {name=p52388 lab=_45382_/Y }
C {devices/lab_pin.sym} 53140 -33970 0 0 {name=p52389 lab=_45384_/Y }
C {devices/lab_pin.sym} 53300 -34010 0 1 {name=p52390 lab=_45385_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -34010 0 0 {name=X_45385_ }
C {devices/lab_pin.sym} 53180 -33870 0 0 {name=p52391 lab=_42580_/A }
C {devices/lab_pin.sym} 53260 -33870 0 1 {name=p52392 lab=_42597_/X }
C {sky130_stdcells/buf_2.sym} 53220 -33870 0 0 {name=X_42597_ }
C {devices/lab_pin.sym} 53180 -33750 0 0 {name=p52393 lab=_53386_/B }
C {devices/lab_pin.sym} 53260 -33750 0 1 {name=p52394 lab=_52869_/B }
C {sky130_stdcells/buf_2.sym} 53220 -33750 0 0 {name=X_47124_ }
C {devices/lab_pin.sym} 53140 -33670 0 0 {name=p52395 lab=_44330_/X }
C {devices/lab_pin.sym} 53140 -33630 0 0 {name=p52396 lab=_44331_/X }
C {devices/lab_pin.sym} 53140 -33590 0 0 {name=p52397 lab=_41667_/X }
C {devices/lab_pin.sym} 53140 -33550 0 0 {name=p52398 lab=_87160_/Q }
C {devices/lab_pin.sym} 53140 -33510 0 0 {name=p52399 lab=_44332_/X }
C {devices/lab_pin.sym} 53300 -33590 0 1 {name=p52400 lab=_44336_/Y }
C {sky130_stdcells/o32ai_4.sym} 53220 -33590 0 0 {name=X_44336_ }
C {devices/lab_pin.sym} 53180 -33430 0 0 {name=p52401 lab=_63053_/A }
C {devices/lab_pin.sym} 53260 -33430 0 1 {name=p52402 lab=_63170_/X }
C {sky130_stdcells/buf_2.sym} 53220 -33430 0 0 {name=X_63170_ }
C {devices/lab_pin.sym} 53180 -33310 0 0 {name=p52403 lab=_75151_/Y }
C {devices/lab_pin.sym} 53260 -33310 0 1 {name=p52404 lab=_75156_/Y }
C {sky130_stdcells/inv_2.sym} 53220 -33310 0 0 {name=X_75156_ }
C {devices/lab_pin.sym} 53180 -33190 0 0 {name=p52405 lab=clkbuf_2_2_2_CLK/X }
C {devices/lab_pin.sym} 53260 -33190 0 1 {name=p52406 lab=clkbuf_3_4_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 53220 -33190 0 0 {name=Xclkbuf_3_4_0_CLK }
C {devices/lab_pin.sym} 53180 -33070 0 0 {name=p52407 lab=_41411_/X }
C {devices/lab_pin.sym} 53260 -33070 0 1 {name=p52408 lab=_41548_/X }
C {sky130_stdcells/buf_2.sym} 53220 -33070 0 0 {name=X_41548_ }
C {devices/lab_pin.sym} 53180 -32950 0 0 {name=p52409 lab=_60447_/A }
C {devices/lab_pin.sym} 53260 -32950 0 1 {name=p52410 lab=_60383_/A }
C {sky130_stdcells/buf_2.sym} 53220 -32950 0 0 {name=X_60382_ }
C {devices/lab_pin.sym} 53160 -32840 0 0 {name=p52411 lab=_72368_/A }
C {devices/lab_pin.sym} 53160 -32800 0 0 {name=p52412 lab=_72401_/B }
C {devices/lab_pin.sym} 53280 -32820 0 1 {name=p52413 lab=_72368_/Y }
C {sky130_stdcells/nor2_4.sym} 53220 -32820 0 0 {name=X_72368_ }
C {devices/lab_pin.sym} 53180 -32690 0 0 {name=p52414 lab=_61820_/A }
C {devices/lab_pin.sym} 53260 -32690 0 1 {name=p52415 lab=_62121_/X }
C {sky130_stdcells/buf_2.sym} 53220 -32690 0 0 {name=X_62121_ }
C {devices/lab_pin.sym} 53180 -32570 0 0 {name=p52416 lab=_72909_/A }
C {devices/lab_pin.sym} 53260 -32570 0 1 {name=p52417 lab=_74107_/X }
C {sky130_stdcells/buf_2.sym} 53220 -32570 0 0 {name=X_74107_ }
C {devices/lab_pin.sym} 53140 -32470 0 0 {name=p52418 lab=_86675_/Q }
C {devices/lab_pin.sym} 53140 -32430 0 0 {name=p52419 lab=_47050_/X }
C {devices/lab_pin.sym} 53140 -32390 0 0 {name=p52420 lab=_47054_/Y }
C {devices/lab_pin.sym} 53300 -32430 0 1 {name=p52421 lab=_47055_/Y }
C {sky130_stdcells/o21ai_4.sym} 53220 -32430 0 0 {name=X_47055_ }
C {devices/lab_pin.sym} 53160 -32300 0 0 {name=p52422 lab=_70428_/A }
C {devices/lab_pin.sym} 53160 -32260 0 0 {name=p52423 lab=_71319_/B }
C {devices/lab_pin.sym} 53280 -32280 0 1 {name=p52424 lab=_71320_/A }
C {sky130_stdcells/nor2_4.sym} 53220 -32280 0 0 {name=X_71319_ }
C {devices/lab_pin.sym} 53180 -32150 0 0 {name=p52425 lab=_44267_/A }
C {devices/lab_pin.sym} 53260 -32150 0 1 {name=p52426 lab=_44268_/A }
C {sky130_stdcells/inv_2.sym} 53220 -32150 0 0 {name=X_44267_ }
C {devices/lab_pin.sym} 53160 -32040 0 0 {name=p52427 lab=_79964_/A }
C {devices/lab_pin.sym} 53160 -32000 0 0 {name=p52428 lab=_79963_/Y }
C {devices/lab_pin.sym} 53280 -32020 0 1 {name=p52429 lab=_79964_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -32020 0 0 {name=X_79964_ }
C {devices/lab_pin.sym} 53180 -31890 0 0 {name=p52430 lab=_75086_/Y }
C {devices/lab_pin.sym} 53260 -31890 0 1 {name=p52431 lab=_75087_/Y }
C {sky130_stdcells/inv_2.sym} 53220 -31890 0 0 {name=X_75087_ }
C {devices/lab_pin.sym} 53180 -31770 0 0 {name=p52432 lab=_41478_/Y }
C {devices/lab_pin.sym} 53260 -31770 0 1 {name=p52433 lab=_41479_/X }
C {sky130_stdcells/buf_2.sym} 53220 -31770 0 0 {name=X_41479_ }
C {devices/lab_pin.sym} 53180 -31650 0 0 {name=p52434 lab=_59325_/A }
C {devices/lab_pin.sym} 53260 -31650 0 1 {name=p52435 lab=_72299_/X }
C {sky130_stdcells/buf_2.sym} 53220 -31650 0 0 {name=X_72299_ }
C {devices/lab_pin.sym} 53180 -31530 0 0 {name=p52436 lab=_46006_/A }
C {devices/lab_pin.sym} 53260 -31530 0 1 {name=p52437 lab=_46006_/Y }
C {sky130_stdcells/inv_2.sym} 53220 -31530 0 0 {name=X_46006_ }
C {devices/lab_pin.sym} 53180 -31410 0 0 {name=p52438 lab=_43218_/A }
C {devices/lab_pin.sym} 53260 -31410 0 1 {name=p52439 lab=_43218_/X }
C {sky130_stdcells/buf_2.sym} 53220 -31410 0 0 {name=X_43218_ }
C {devices/lab_pin.sym} 53160 -31310 0 0 {name=p52440 lab=_62050_/X }
C {devices/lab_pin.sym} 53160 -31270 0 0 {name=p52441 lab=_62090_/B }
C {devices/lab_pin.sym} 53160 -31230 0 0 {name=p52442 lab=_78060_/B }
C {devices/lab_pin.sym} 53280 -31270 0 1 {name=p52443 lab=_62052_/Y }
C {sky130_stdcells/nor3_4.sym} 53220 -31270 0 0 {name=X_62052_ }
C {devices/lab_pin.sym} 53180 -31130 0 0 {name=p52444 lab=_78903_/Y }
C {devices/lab_pin.sym} 53260 -31130 0 1 {name=p52445 lab=_82509_/D }
C {sky130_stdcells/inv_2.sym} 53220 -31130 0 0 {name=X_78915_ }
C {devices/lab_pin.sym} 53160 -31020 0 0 {name=p52446 lab=_74038_/A }
C {devices/lab_pin.sym} 53160 -30980 0 0 {name=p52447 lab=_85901_/Q }
C {devices/lab_pin.sym} 53280 -31000 0 1 {name=p52448 lab=_74038_/X }
C {sky130_stdcells/and2_4.sym} 53220 -31000 0 0 {name=X_74038_ }
C {devices/lab_pin.sym} 53180 -30870 0 0 {name=p52449 lab=_56953_/A }
C {devices/lab_pin.sym} 53260 -30870 0 1 {name=p52450 lab=_57043_/B }
C {sky130_stdcells/buf_2.sym} 53220 -30870 0 0 {name=X_44198_ }
C {devices/lab_pin.sym} 53160 -30760 0 0 {name=p52451 lab=_79895_/A }
C {devices/lab_pin.sym} 53160 -30720 0 0 {name=p52452 lab=_79895_/B }
C {devices/lab_pin.sym} 53280 -30740 0 1 {name=p52453 lab=_81090_/D }
C {sky130_stdcells/xnor2_4.sym} 53220 -30740 0 0 {name=X_79895_ }
C {devices/lab_pin.sym} 53160 -30630 0 0 {name=p52454 lab=_61003_/A }
C {devices/lab_pin.sym} 53160 -30590 0 0 {name=p52455 lab=_60865_/C }
C {devices/lab_pin.sym} 53160 -30550 0 0 {name=p52456 lab=_60865_/B }
C {devices/lab_pin.sym} 53280 -30590 0 1 {name=p52457 lab=_61003_/Y }
C {sky130_stdcells/nand3_4.sym} 53220 -30590 0 0 {name=X_61003_ }
C {devices/lab_pin.sym} 53180 -30450 0 0 {name=p52458 lab=_43017_/A }
C {devices/lab_pin.sym} 53260 -30450 0 1 {name=p52459 lab=_43149_/X }
C {sky130_stdcells/buf_2.sym} 53220 -30450 0 0 {name=X_43149_ }
C {devices/lab_pin.sym} 53180 -30330 0 0 {name=p52460 lab=_66625_/A }
C {devices/lab_pin.sym} 53260 -30330 0 1 {name=p52461 lab=_66912_/A }
C {sky130_stdcells/buf_2.sym} 53220 -30330 0 0 {name=X_66860_ }
C {devices/lab_pin.sym} 53160 -30220 0 0 {name=p52462 lab=_82839_/Q }
C {devices/lab_pin.sym} 53160 -30180 0 0 {name=p52463 lab=_82551_/Q }
C {devices/lab_pin.sym} 53280 -30200 0 1 {name=p52464 lab=_78857_/A }
C {sky130_stdcells/xor2_4.sym} 53220 -30200 0 0 {name=X_78846_ }
C {devices/lab_pin.sym} 53180 -30070 0 0 {name=p52465 lab=_65660_/A }
C {devices/lab_pin.sym} 53260 -30070 0 1 {name=p52466 lab=_65811_/X }
C {sky130_stdcells/buf_2.sym} 53220 -30070 0 0 {name=X_65811_ }
C {devices/lab_pin.sym} 53160 -29960 0 0 {name=p52467 lab=_47946_/A }
C {devices/lab_pin.sym} 53160 -29920 0 0 {name=p52468 lab=_47957_/B }
C {devices/lab_pin.sym} 53280 -29940 0 1 {name=p52469 lab=_47957_/X }
C {sky130_stdcells/and2_4.sym} 53220 -29940 0 0 {name=X_47957_ }
C {devices/lab_pin.sym} 53160 -29820 0 0 {name=p52470 lab=_66791_/A }
C {devices/lab_pin.sym} 53160 -29780 0 0 {name=p52471 lab=_66790_/X }
C {devices/lab_pin.sym} 53280 -29800 0 1 {name=p52472 lab=_66791_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -29800 0 0 {name=X_66791_ }
C {devices/lab_pin.sym} 53160 -29680 0 0 {name=p52473 lab=_78775_/Y }
C {devices/lab_pin.sym} 53160 -29640 0 0 {name=p52474 lab=_78777_/B }
C {devices/lab_pin.sym} 53280 -29660 0 1 {name=p52475 lab=_78778_/B }
C {sky130_stdcells/xor2_4.sym} 53220 -29660 0 0 {name=X_78777_ }
C {devices/lab_pin.sym} 53160 -29540 0 0 {name=p52476 lab=_75981_/A }
C {devices/lab_pin.sym} 53160 -29500 0 0 {name=p52477 lab=_75986_/A }
C {devices/lab_pin.sym} 53280 -29520 0 1 {name=p52478 lab=_75990_/B }
C {sky130_stdcells/and2_4.sym} 53220 -29520 0 0 {name=X_75989_ }
C {devices/lab_pin.sym} 53160 -29400 0 0 {name=p52479 lab=_68452_/A }
C {devices/lab_pin.sym} 53160 -29360 0 0 {name=p52480 lab=_68530_/B }
C {devices/lab_pin.sym} 53280 -29380 0 1 {name=p52481 lab=_68530_/X }
C {sky130_stdcells/and2_4.sym} 53220 -29380 0 0 {name=X_68530_ }
C {devices/lab_pin.sym} 53180 -29250 0 0 {name=p52482 lab=_46767_/A }
C {devices/lab_pin.sym} 53260 -29250 0 1 {name=p52483 lab=_46908_/X }
C {sky130_stdcells/buf_2.sym} 53220 -29250 0 0 {name=X_46908_ }
C {devices/lab_pin.sym} 53160 -29140 0 0 {name=p52484 lab=_65742_/A }
C {devices/lab_pin.sym} 53160 -29100 0 0 {name=p52485 lab=_65742_/B }
C {devices/lab_pin.sym} 53280 -29120 0 1 {name=p52486 lab=_65742_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -29120 0 0 {name=X_65742_ }
C {devices/lab_pin.sym} 53160 -29000 0 0 {name=p52487 lab=_77728_/A }
C {devices/lab_pin.sym} 53160 -28960 0 0 {name=p52488 lab=_77728_/B }
C {devices/lab_pin.sym} 53280 -28980 0 1 {name=p52489 lab=_77728_/X }
C {sky130_stdcells/xor2_4.sym} 53220 -28980 0 0 {name=X_77728_ }
C {devices/lab_pin.sym} 53140 -28870 0 0 {name=p52490 lab=_62950_/Y }
C {devices/lab_pin.sym} 53140 -28830 0 0 {name=p52491 lab=_62942_/X }
C {devices/lab_pin.sym} 53140 -28790 0 0 {name=p52492 lab=_62953_/Y }
C {devices/lab_pin.sym} 53300 -28830 0 1 {name=p52493 lab=_62954_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -28830 0 0 {name=X_62954_ }
C {devices/lab_pin.sym} 53140 -28710 0 0 {name=p52494 lab=_47883_/Y }
C {devices/lab_pin.sym} 53140 -28670 0 0 {name=p52495 lab=_47846_/X }
C {devices/lab_pin.sym} 53140 -28630 0 0 {name=p52496 lab=_47887_/X }
C {devices/lab_pin.sym} 53300 -28670 0 1 {name=p52497 lab=_47888_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -28670 0 0 {name=X_47888_ }
C {devices/lab_pin.sym} 53160 -28540 0 0 {name=p52498 lab=_49607_/X }
C {devices/lab_pin.sym} 53160 -28500 0 0 {name=p52499 lab=_52843_/B }
C {devices/lab_pin.sym} 53280 -28520 0 1 {name=p52500 lab=_49627_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -28520 0 0 {name=X_49627_ }
C {devices/lab_pin.sym} 53160 -28420 0 0 {name=p52501 lab=_61871_/A }
C {devices/lab_pin.sym} 53160 -28380 0 0 {name=p52502 lab=_61949_/B }
C {devices/lab_pin.sym} 53160 -28340 0 0 {name=p52503 lab=_61949_/C }
C {devices/lab_pin.sym} 53160 -28300 0 0 {name=p52504 lab=_63137_/B }
C {devices/lab_pin.sym} 53280 -28360 0 1 {name=p52505 lab=_61905_/X }
C {sky130_stdcells/and4_4.sym} 53220 -28360 0 0 {name=X_61905_ }
C {devices/lab_pin.sym} 53180 -28210 0 0 {name=p52506 lab=_68461_/A }
C {devices/lab_pin.sym} 53260 -28210 0 1 {name=p52507 lab=_68586_/A }
C {sky130_stdcells/buf_2.sym} 53220 -28210 0 0 {name=X_68461_ }
C {devices/lab_pin.sym} 53140 -28110 0 0 {name=p52508 lab=_46835_/Y }
C {devices/lab_pin.sym} 53140 -28070 0 0 {name=p52509 lab=_46798_/X }
C {devices/lab_pin.sym} 53140 -28030 0 0 {name=p52510 lab=_46838_/X }
C {devices/lab_pin.sym} 53300 -28070 0 1 {name=p52511 lab=_86698_/D }
C {sky130_stdcells/a21oi_4.sym} 53220 -28070 0 0 {name=X_46839_ }
C {devices/lab_pin.sym} 53180 -27930 0 0 {name=p52512 lab=_65673_/A }
C {devices/lab_pin.sym} 53260 -27930 0 1 {name=p52513 lab=_65825_/A }
C {sky130_stdcells/buf_2.sym} 53220 -27930 0 0 {name=X_65673_ }
C {devices/lab_pin.sym} 53140 -27830 0 0 {name=p52514 lab=_77660_/A }
C {devices/lab_pin.sym} 53140 -27790 0 0 {name=p52515 lab=_77656_/Y }
C {devices/lab_pin.sym} 53140 -27750 0 0 {name=p52516 lab=_77658_/Y }
C {devices/lab_pin.sym} 53300 -27790 0 1 {name=p52517 lab=_77693_/A }
C {sky130_stdcells/a21o_4.sym} 53220 -27790 0 0 {name=X_77659_ }
C {devices/lab_pin.sym} 53140 -27670 0 0 {name=p52518 lab=_63611_/A }
C {devices/lab_pin.sym} 53140 -27630 0 0 {name=p52519 lab=_62875_/X }
C {devices/lab_pin.sym} 53140 -27590 0 0 {name=p52520 lab=_62884_/Y }
C {devices/lab_pin.sym} 53300 -27630 0 1 {name=p52521 lab=_62885_/X }
C {sky130_stdcells/o21a_4.sym} 53220 -27630 0 0 {name=X_62885_ }
C {devices/lab_pin.sym} 53140 -27520 0 0 {name=p52522 lab=_86972_/Q }
C {devices/lab_pin.sym} 53140 -27480 0 0 {name=p52523 lab=_67311_/X }
C {devices/lab_pin.sym} 53140 -27440 0 0 {name=p52524 lab=_67313_/X }
C {devices/lab_pin.sym} 53140 -27400 0 0 {name=p52525 lab=_67411_/X }
C {devices/lab_pin.sym} 53300 -27460 0 1 {name=p52526 lab=_67413_/B }
C {sky130_stdcells/a211o_4.sym} 53220 -27460 0 0 {name=X_67412_ }
C {devices/lab_pin.sym} 53160 -27320 0 0 {name=p52527 lab=_64676_/A }
C {devices/lab_pin.sym} 53160 -27280 0 0 {name=p52528 lab=_85856_/Q }
C {devices/lab_pin.sym} 53280 -27300 0 1 {name=p52529 lab=_64624_/X }
C {sky130_stdcells/and2_4.sym} 53220 -27300 0 0 {name=X_64624_ }
C {devices/lab_pin.sym} 53160 -27180 0 0 {name=p52530 lab=_49558_/A }
C {devices/lab_pin.sym} 53160 -27140 0 0 {name=p52531 lab=_52773_/B }
C {devices/lab_pin.sym} 53280 -27160 0 1 {name=p52532 lab=_49558_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -27160 0 0 {name=X_49558_ }
C {devices/lab_pin.sym} 53140 -27050 0 0 {name=p52533 lab=_61834_/Y }
C {devices/lab_pin.sym} 53140 -27010 0 0 {name=p52534 lab=_61801_/X }
C {devices/lab_pin.sym} 53140 -26970 0 0 {name=p52535 lab=_61835_/Y }
C {devices/lab_pin.sym} 53300 -27010 0 1 {name=p52536 lab=_61836_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -27010 0 0 {name=X_61836_ }
C {devices/lab_pin.sym} 53130 -26870 0 0 {name=p52537 lab=_80670_/CLK }
C {devices/lab_pin.sym} 53130 -26850 0 0 {name=p52538 lab=_80670_/D }
C {devices/lab_pin.sym} 53310 -26870 0 1 {name=p52539 lab=_80670_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -26860 0 0 {name=X_80670_ }
C {devices/lab_pin.sym} 53180 -26730 0 0 {name=p52540 lab=_68392_/A }
C {devices/lab_pin.sym} 53260 -26730 0 1 {name=p52541 lab=_69607_/A }
C {sky130_stdcells/buf_2.sym} 53220 -26730 0 0 {name=X_68392_ }
C {devices/lab_pin.sym} 53140 -26630 0 0 {name=p52542 lab=_48471_/X }
C {devices/lab_pin.sym} 53140 -26590 0 0 {name=p52543 lab=_47973_/A }
C {devices/lab_pin.sym} 53140 -26550 0 0 {name=p52544 lab=_48508_/Y }
C {devices/lab_pin.sym} 53300 -26590 0 1 {name=p52545 lab=_74431_/A }
C {sky130_stdcells/o21ai_4.sym} 53220 -26590 0 0 {name=X_48509_ }
C {devices/lab_pin.sym} 53140 -26480 0 0 {name=p52546 lab=_87923_/Q }
C {devices/lab_pin.sym} 53140 -26440 0 0 {name=p52547 lab=_67293_/X }
C {devices/lab_pin.sym} 53140 -26400 0 0 {name=p52548 lab=_67271_/X }
C {devices/lab_pin.sym} 53140 -26360 0 0 {name=p52549 lab=_67342_/X }
C {devices/lab_pin.sym} 53300 -26420 0 1 {name=p52550 lab=_67343_/X }
C {sky130_stdcells/a211o_4.sym} 53220 -26420 0 0 {name=X_67343_ }
C {devices/lab_pin.sym} 53160 -26280 0 0 {name=p52551 lab=_84800_/Q }
C {devices/lab_pin.sym} 53160 -26240 0 0 {name=p52552 lab=_84120_/Q }
C {devices/lab_pin.sym} 53280 -26260 0 1 {name=p52553 lab=_79331_/A }
C {sky130_stdcells/xor2_4.sym} 53220 -26260 0 0 {name=X_79329_ }
C {devices/lab_pin.sym} 53160 -26160 0 0 {name=p52554 lab=_64210_/A }
C {devices/lab_pin.sym} 53160 -26120 0 0 {name=p52555 lab=_64229_/X }
C {devices/lab_pin.sym} 53160 -26080 0 0 {name=p52556 lab=_64553_/Y }
C {devices/lab_pin.sym} 53160 -26040 0 0 {name=p52557 lab=_64554_/Y }
C {devices/lab_pin.sym} 53280 -26100 0 1 {name=p52558 lab=_64555_/Y }
C {sky130_stdcells/nand4_4.sym} 53220 -26100 0 0 {name=X_64555_ }
C {devices/lab_pin.sym} 53160 -25980 0 0 {name=p52559 lab=_49500_/A }
C {devices/lab_pin.sym} 53160 -25940 0 0 {name=p52560 lab=_49500_/B }
C {devices/lab_pin.sym} 53160 -25900 0 0 {name=p52561 lab=_49467_/C }
C {devices/lab_pin.sym} 53160 -25860 0 0 {name=p52562 lab=_52704_/D }
C {devices/lab_pin.sym} 53280 -25920 0 1 {name=p52563 lab=_49489_/X }
C {sky130_stdcells/and4_4.sym} 53220 -25920 0 0 {name=X_49489_ }
C {devices/lab_pin.sym} 53140 -25810 0 0 {name=p52564 lab=_61754_/X }
C {devices/lab_pin.sym} 53140 -25770 0 0 {name=p52565 lab=_61758_/X }
C {devices/lab_pin.sym} 53140 -25730 0 0 {name=p52566 lab=_61766_/Y }
C {devices/lab_pin.sym} 53140 -25690 0 0 {name=p52567 lab=_58154_/A }
C {devices/lab_pin.sym} 53140 -25650 0 0 {name=p52568 lab=_61719_/X }
C {devices/lab_pin.sym} 53300 -25730 0 1 {name=p52569 lab=_61767_/Y }
C {sky130_stdcells/o32ai_4.sym} 53220 -25730 0 0 {name=X_61767_ }
C {devices/lab_pin.sym} 53180 -25570 0 0 {name=p52570 lab=_50946_/A }
C {devices/lab_pin.sym} 53260 -25570 0 1 {name=p52571 lab=_51629_/A }
C {sky130_stdcells/buf_2.sym} 53220 -25570 0 0 {name=X_51520_ }
C {devices/lab_pin.sym} 53140 -25490 0 0 {name=p52572 lab=_63495_/X }
C {devices/lab_pin.sym} 53140 -25450 0 0 {name=p52573 lab=_63496_/X }
C {devices/lab_pin.sym} 53140 -25410 0 0 {name=p52574 lab=_63499_/X }
C {devices/lab_pin.sym} 53140 -25370 0 0 {name=p52575 lab=_63503_/X }
C {devices/lab_pin.sym} 53140 -25330 0 0 {name=p52576 lab=_63505_/Y }
C {devices/lab_pin.sym} 53300 -25410 0 1 {name=p52577 lab=_63506_/Y }
C {sky130_stdcells/o41ai_4.sym} 53220 -25410 0 0 {name=X_63506_ }
C {devices/lab_pin.sym} 53130 -25250 0 0 {name=p52578 lab=_82299_/CLK }
C {devices/lab_pin.sym} 53130 -25230 0 0 {name=p52579 lab=_77065_/X }
C {devices/lab_pin.sym} 53310 -25250 0 1 {name=p52580 lab=_48136_/A }
C {sky130_stdcells/dfxtp_4.sym} 53220 -25240 0 0 {name=X_82340_ }
C {devices/lab_pin.sym} 53140 -25150 0 0 {name=p52581 lab=_60707_/X }
C {devices/lab_pin.sym} 53140 -25110 0 0 {name=p52582 lab=_60709_/X }
C {devices/lab_pin.sym} 53140 -25070 0 0 {name=p52583 lab=_60820_/A }
C {devices/lab_pin.sym} 53140 -25030 0 0 {name=p52584 lab=_60714_/Y }
C {devices/lab_pin.sym} 53140 -25000 0 0 {name=p52585 lab=_60717_/Y }
C {devices/lab_pin.sym} 53300 -25070 0 1 {name=p52586 lab=_84581_/D }
C {sky130_stdcells/a41oi_4.sym} 53220 -25070 0 0 {name=X_60718_ }
C {devices/lab_pin.sym} 53180 -24910 0 0 {name=p52587 lab=_66915_/A }
C {devices/lab_pin.sym} 53260 -24910 0 1 {name=p52588 lab=_67274_/X }
C {sky130_stdcells/buf_2.sym} 53220 -24910 0 0 {name=X_67274_ }
C {devices/lab_pin.sym} 53160 -24820 0 0 {name=p52589 lab=_61238_/C }
C {devices/lab_pin.sym} 53160 -24780 0 0 {name=p52590 lab=_64457_/C }
C {devices/lab_pin.sym} 53160 -24740 0 0 {name=p52591 lab=_64484_/Y }
C {devices/lab_pin.sym} 53160 -24700 0 0 {name=p52592 lab=_64485_/Y }
C {devices/lab_pin.sym} 53280 -24760 0 1 {name=p52593 lab=_64486_/Y }
C {sky130_stdcells/nand4_4.sym} 53220 -24760 0 0 {name=X_64486_ }
C {devices/lab_pin.sym} 53140 -24650 0 0 {name=p52594 lab=_61692_/Y }
C {devices/lab_pin.sym} 53140 -24610 0 0 {name=p52595 lab=_61694_/Y }
C {devices/lab_pin.sym} 53140 -24570 0 0 {name=p52596 lab=_61320_/Y }
C {devices/lab_pin.sym} 53140 -24530 0 0 {name=p52597 lab=_61695_/Y }
C {devices/lab_pin.sym} 53140 -24500 0 0 {name=p52598 lab=_61697_/Y }
C {devices/lab_pin.sym} 53300 -24570 0 1 {name=p52599 lab=_61698_/X }
C {sky130_stdcells/a41o_4.sym} 53220 -24570 0 0 {name=X_61698_ }
C {devices/lab_pin.sym} 53140 -24430 0 0 {name=p52600 lab=_69009_/X }
C {devices/lab_pin.sym} 53140 -24390 0 0 {name=p52601 lab=_69012_/X }
C {devices/lab_pin.sym} 53140 -24350 0 0 {name=p52602 lab=_68922_/X }
C {devices/lab_pin.sym} 53300 -24390 0 1 {name=p52603 lab=_69013_/X }
C {sky130_stdcells/a21o_4.sym} 53220 -24390 0 0 {name=X_69013_ }
C {devices/lab_pin.sym} 53180 -24250 0 0 {name=p52604 lab=_65595_/X }
C {devices/lab_pin.sym} 53260 -24250 0 1 {name=p52605 lab=_66225_/X }
C {sky130_stdcells/buf_2.sym} 53220 -24250 0 0 {name=X_66225_ }
C {devices/lab_pin.sym} 53180 -24130 0 0 {name=p52606 lab=_51504_/A }
C {devices/lab_pin.sym} 53260 -24130 0 1 {name=p52607 lab=_51473_/B }
C {sky130_stdcells/buf_2.sym} 53220 -24130 0 0 {name=X_51451_ }
C {devices/lab_pin.sym} 53180 -24010 0 0 {name=p52608 lab=_63372_/A }
C {devices/lab_pin.sym} 53260 -24010 0 1 {name=p52609 lab=_63437_/X }
C {sky130_stdcells/buf_2.sym} 53220 -24010 0 0 {name=X_63437_ }
C {devices/lab_pin.sym} 53130 -23890 0 0 {name=p52610 lab=_82272_/CLK }
C {devices/lab_pin.sym} 53130 -23870 0 0 {name=p52611 lab=_82271_/D }
C {devices/lab_pin.sym} 53310 -23890 0 1 {name=p52612 lab=_82271_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -23880 0 0 {name=X_82271_ }
C {devices/lab_pin.sym} 53180 -23750 0 0 {name=p52613 lab=_60724_/B }
C {devices/lab_pin.sym} 53260 -23750 0 1 {name=p52614 lab=_60712_/B }
C {sky130_stdcells/buf_2.sym} 53220 -23750 0 0 {name=X_60649_ }
C {devices/lab_pin.sym} 53130 -23630 0 0 {name=p52615 lab=_84074_/CLK }
C {devices/lab_pin.sym} 53130 -23610 0 0 {name=p52616 lab=_68215_/X }
C {devices/lab_pin.sym} 53310 -23630 0 1 {name=p52617 lab=_82050_/D }
C {sky130_stdcells/dfxtp_4.sym} 53220 -23620 0 0 {name=X_84010_ }
C {devices/lab_pin.sym} 53140 -23510 0 0 {name=p52618 lab=_50399_/Y }
C {devices/lab_pin.sym} 53140 -23470 0 0 {name=p52619 lab=_50395_/X }
C {devices/lab_pin.sym} 53140 -23430 0 0 {name=p52620 lab=_50401_/X }
C {devices/lab_pin.sym} 53300 -23470 0 1 {name=p52621 lab=_86208_/D }
C {sky130_stdcells/a21oi_4.sym} 53220 -23470 0 0 {name=X_50402_ }
C {devices/lab_pin.sym} 53130 -23330 0 0 {name=p52622 lab=_85317_/CLK }
C {devices/lab_pin.sym} 53130 -23310 0 0 {name=p52623 lab=_81222_/D }
C {devices/lab_pin.sym} 53310 -23330 0 1 {name=p52624 lab=_81222_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -23320 0 0 {name=X_81222_ }
C {devices/lab_pin.sym} 53140 -23210 0 0 {name=p52625 lab=_85491_/Q }
C {devices/lab_pin.sym} 53140 -23170 0 0 {name=p52626 lab=_54167_/X }
C {devices/lab_pin.sym} 53140 -23130 0 0 {name=p52627 lab=_54169_/Y }
C {devices/lab_pin.sym} 53300 -23170 0 1 {name=p52628 lab=_54170_/Y }
C {sky130_stdcells/o21ai_4.sym} 53220 -23170 0 0 {name=X_54170_ }
C {devices/lab_pin.sym} 53140 -23060 0 0 {name=p52629 lab=_65300_/X }
C {devices/lab_pin.sym} 53140 -23020 0 0 {name=p52630 lab=_85616_/Q }
C {devices/lab_pin.sym} 53140 -22980 0 0 {name=p52631 lab=_44261_/X }
C {devices/lab_pin.sym} 53140 -22940 0 0 {name=p52632 lab=_66155_/X }
C {devices/lab_pin.sym} 53300 -23000 0 1 {name=p52633 lab=_66156_/X }
C {sky130_stdcells/a211o_4.sym} 53220 -23000 0 0 {name=X_66156_ }
C {devices/lab_pin.sym} 53160 -22860 0 0 {name=p52634 lab=_51364_/A }
C {devices/lab_pin.sym} 53160 -22820 0 0 {name=p52635 lab=_50870_/B }
C {devices/lab_pin.sym} 53280 -22840 0 1 {name=p52636 lab=_51382_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -22840 0 0 {name=X_51382_ }
C {devices/lab_pin.sym} 53180 -22710 0 0 {name=p52637 lab=_63368_/A }
C {devices/lab_pin.sym} 53260 -22710 0 1 {name=p52638 lab=_63368_/X }
C {sky130_stdcells/buf_2.sym} 53220 -22710 0 0 {name=X_63368_ }
C {devices/lab_pin.sym} 53180 -22590 0 0 {name=p52639 lab=_53147_/A }
C {devices/lab_pin.sym} 53260 -22590 0 1 {name=p52640 lab=_53121_/X }
C {sky130_stdcells/buf_2.sym} 53220 -22590 0 0 {name=X_53121_ }
C {devices/lab_pin.sym} 53140 -22490 0 0 {name=p52641 lab=_65104_/X }
C {devices/lab_pin.sym} 53140 -22450 0 0 {name=p52642 lab=_65106_/X }
C {devices/lab_pin.sym} 53140 -22410 0 0 {name=p52643 lab=_64959_/X }
C {devices/lab_pin.sym} 53300 -22450 0 1 {name=p52644 lab=_65107_/X }
C {sky130_stdcells/a21o_4.sym} 53220 -22450 0 0 {name=X_65107_ }
C {devices/lab_pin.sym} 53180 -22310 0 0 {name=p52645 lab=_50464_/A }
C {devices/lab_pin.sym} 53260 -22310 0 1 {name=p52646 lab=_50333_/X }
C {sky130_stdcells/buf_2.sym} 53220 -22310 0 0 {name=X_50333_ }
C {devices/lab_pin.sym} 53160 -22210 0 0 {name=p52647 lab=_62319_/A }
C {devices/lab_pin.sym} 53160 -22170 0 0 {name=p52648 lab=_63448_/B }
C {devices/lab_pin.sym} 53160 -22130 0 0 {name=p52649 lab=_62319_/C }
C {devices/lab_pin.sym} 53280 -22170 0 1 {name=p52650 lab=_62322_/C }
C {sky130_stdcells/nand3_4.sym} 53220 -22170 0 0 {name=X_62319_ }
C {devices/lab_pin.sym} 53130 -22030 0 0 {name=p52651 lab=_82284_/CLK }
C {devices/lab_pin.sym} 53130 -22010 0 0 {name=p52652 lab=_81153_/D }
C {devices/lab_pin.sym} 53310 -22030 0 1 {name=p52653 lab=_40558_/A }
C {sky130_stdcells/dfxtp_4.sym} 53220 -22020 0 0 {name=X_81153_ }
C {devices/lab_pin.sym} 53160 -21900 0 0 {name=p52654 lab=_66011_/X }
C {devices/lab_pin.sym} 53160 -21860 0 0 {name=p52655 lab=_66087_/B }
C {devices/lab_pin.sym} 53280 -21880 0 1 {name=p52656 lab=_66087_/X }
C {sky130_stdcells/and2_4.sym} 53220 -21880 0 0 {name=X_66087_ }
C {devices/lab_pin.sym} 53140 -21780 0 0 {name=p52657 lab=_58287_/Y }
C {devices/lab_pin.sym} 53140 -21740 0 0 {name=p52658 lab=_63250_/X }
C {devices/lab_pin.sym} 53140 -21700 0 0 {name=p52659 lab=_59430_/Y }
C {devices/lab_pin.sym} 53140 -21660 0 0 {name=p52660 lab=_60493_/A }
C {devices/lab_pin.sym} 53300 -21720 0 1 {name=p52661 lab=_63299_/X }
C {sky130_stdcells/o22a_4.sym} 53220 -21720 0 0 {name=X_63299_ }
C {devices/lab_pin.sym} 53160 -21580 0 0 {name=p52662 lab=_80117_/B }
C {devices/lab_pin.sym} 53160 -21540 0 0 {name=p52663 lab=_80103_/Y }
C {devices/lab_pin.sym} 53280 -21560 0 1 {name=p52664 lab=_80107_/A }
C {sky130_stdcells/xor2_4.sym} 53220 -21560 0 0 {name=X_80104_ }
C {devices/lab_pin.sym} 53160 -21460 0 0 {name=p52665 lab=_53048_/A }
C {devices/lab_pin.sym} 53160 -21420 0 0 {name=p52666 lab=_53063_/B }
C {devices/lab_pin.sym} 53160 -21380 0 0 {name=p52667 lab=_53058_/C }
C {devices/lab_pin.sym} 53160 -21340 0 0 {name=p52668 lab=_53052_/D }
C {devices/lab_pin.sym} 53280 -21400 0 1 {name=p52669 lab=_53052_/X }
C {sky130_stdcells/and4_4.sym} 53220 -21400 0 0 {name=X_53052_ }
C {devices/lab_pin.sym} 53140 -21280 0 0 {name=p52670 lab=_65035_/X }
C {devices/lab_pin.sym} 53140 -21240 0 0 {name=p52671 lab=_85553_/Q }
C {devices/lab_pin.sym} 53140 -21200 0 0 {name=p52672 lab=_65036_/X }
C {devices/lab_pin.sym} 53140 -21160 0 0 {name=p52673 lab=_65037_/X }
C {devices/lab_pin.sym} 53300 -21220 0 1 {name=p52674 lab=_65038_/X }
C {sky130_stdcells/a211o_4.sym} 53220 -21220 0 0 {name=X_65038_ }
C {devices/lab_pin.sym} 53140 -21090 0 0 {name=p52675 lab=_81959_/D }
C {devices/lab_pin.sym} 53140 -21050 0 0 {name=p52676 lab=_69894_/X }
C {devices/lab_pin.sym} 53140 -21010 0 0 {name=p52677 lab=_69914_/X }
C {devices/lab_pin.sym} 53300 -21050 0 1 {name=p52678 lab=_83887_/D }
C {sky130_stdcells/a21bo_4.sym} 53220 -21050 0 0 {name=X_69915_ }
C {devices/lab_pin.sym} 53160 -20920 0 0 {name=p52679 lab=_50251_/X }
C {devices/lab_pin.sym} 53160 -20880 0 0 {name=p52680 lab=_50264_/B }
C {devices/lab_pin.sym} 53280 -20900 0 1 {name=p52681 lab=_50264_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -20900 0 0 {name=X_50264_ }
C {devices/lab_pin.sym} 53130 -20770 0 0 {name=p52682 lab=_85961_/CLK }
C {devices/lab_pin.sym} 53130 -20750 0 0 {name=p52683 lab=_51706_/Y }
C {devices/lab_pin.sym} 53310 -20770 0 1 {name=p52684 lab=_85961_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -20760 0 0 {name=X_85961_ }
C {devices/lab_pin.sym} 53130 -20630 0 0 {name=p52685 lab=_81084_/CLK }
C {devices/lab_pin.sym} 53130 -20610 0 0 {name=p52686 lab=_75657_/A }
C {devices/lab_pin.sym} 53310 -20630 0 1 {name=p52687 lab=_81084_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -20620 0 0 {name=X_81084_ }
C {devices/lab_pin.sym} 53160 -20500 0 0 {name=p52688 lab=_51982_/X }
C {devices/lab_pin.sym} 53160 -20460 0 0 {name=p52689 lab=_50300_/B }
C {devices/lab_pin.sym} 53280 -20480 0 1 {name=p52690 lab=_52003_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -20480 0 0 {name=X_52003_ }
C {devices/lab_pin.sym} 53130 -20350 0 0 {name=p52691 lab=_87126_/CLK }
C {devices/lab_pin.sym} 53130 -20330 0 0 {name=p52692 lab=_42824_/X }
C {devices/lab_pin.sym} 53310 -20350 0 1 {name=p52693 lab=_68067_/B }
C {sky130_stdcells/dfxtp_4.sym} 53220 -20340 0 0 {name=X_87700_ }
C {devices/lab_pin.sym} 53140 -20230 0 0 {name=p52694 lab=_80013_/Y }
C {devices/lab_pin.sym} 53140 -20190 0 0 {name=p52695 lab=_80031_/X }
C {devices/lab_pin.sym} 53140 -20150 0 0 {name=p52696 lab=_80034_/Y }
C {devices/lab_pin.sym} 53300 -20190 0 1 {name=p52697 lab=_80035_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -20190 0 0 {name=X_80035_ }
C {devices/lab_pin.sym} 53130 -20050 0 0 {name=p52698 lab=_84714_/CLK }
C {devices/lab_pin.sym} 53130 -20030 0 0 {name=p52699 lab=_84912_/D }
C {devices/lab_pin.sym} 53310 -20050 0 1 {name=p52700 lab=_58187_/A }
C {sky130_stdcells/dfxtp_4.sym} 53220 -20040 0 0 {name=X_84912_ }
C {devices/lab_pin.sym} 53140 -19930 0 0 {name=p52701 lab=_57824_/X }
C {devices/lab_pin.sym} 53140 -19890 0 0 {name=p52702 lab=_85496_/Q }
C {devices/lab_pin.sym} 53140 -19850 0 0 {name=p52703 lab=_57849_/X }
C {devices/lab_pin.sym} 53300 -19890 0 1 {name=p52704 lab=_57860_/X }
C {sky130_stdcells/o21a_4.sym} 53220 -19890 0 0 {name=X_57860_ }
C {devices/lab_pin.sym} 53140 -19780 0 0 {name=p52705 lab=_69832_/X }
C {devices/lab_pin.sym} 53140 -19740 0 0 {name=p52706 lab=_69844_/Y }
C {devices/lab_pin.sym} 53140 -19700 0 0 {name=p52707 lab=_69815_/X }
C {devices/lab_pin.sym} 53140 -19660 0 0 {name=p52708 lab=_69845_/Y }
C {devices/lab_pin.sym} 53300 -19720 0 1 {name=p52709 lab=_69846_/X }
C {sky130_stdcells/a211o_4.sym} 53220 -19720 0 0 {name=X_69846_ }
C {devices/lab_pin.sym} 53160 -19580 0 0 {name=p52710 lab=_50187_/X }
C {devices/lab_pin.sym} 53160 -19540 0 0 {name=p52711 lab=_50708_/B }
C {devices/lab_pin.sym} 53280 -19560 0 1 {name=p52712 lab=_50195_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -19560 0 0 {name=X_50195_ }
C {devices/lab_pin.sym} 53130 -19430 0 0 {name=p52713 lab=_86203_/CLK }
C {devices/lab_pin.sym} 53130 -19410 0 0 {name=p52714 lab=_85892_/D }
C {devices/lab_pin.sym} 53310 -19430 0 1 {name=p52715 lab=_74232_/B }
C {sky130_stdcells/dfxtp_4.sym} 53220 -19420 0 0 {name=X_85892_ }
C {devices/lab_pin.sym} 53160 -19300 0 0 {name=p52716 lab=_56713_/A }
C {devices/lab_pin.sym} 53160 -19260 0 0 {name=p52717 lab=_56810_/X }
C {devices/lab_pin.sym} 53280 -19280 0 1 {name=p52718 lab=_56811_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -19280 0 0 {name=X_56811_ }
C {devices/lab_pin.sym} 53130 -19150 0 0 {name=p52719 lab=_87888_/CLK }
C {devices/lab_pin.sym} 53130 -19130 0 0 {name=p52720 lab=_87631_/D }
C {devices/lab_pin.sym} 53310 -19150 0 1 {name=p52721 lab=_66676_/B }
C {sky130_stdcells/dfxtp_4.sym} 53220 -19140 0 0 {name=X_87631_ }
C {devices/lab_pin.sym} 53130 -19010 0 0 {name=p52722 lab=_84877_/CLK }
C {devices/lab_pin.sym} 53130 -18990 0 0 {name=p52723 lab=_84843_/D }
C {devices/lab_pin.sym} 53310 -19010 0 1 {name=p52724 lab=_84843_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -19000 0 0 {name=X_84843_ }
C {devices/lab_pin.sym} 53180 -18870 0 0 {name=p52725 lab=_57790_/X }
C {devices/lab_pin.sym} 53260 -18870 0 1 {name=p52726 lab=_57791_/X }
C {sky130_stdcells/buf_2.sym} 53220 -18870 0 0 {name=X_57791_ }
C {devices/lab_pin.sym} 53160 -18760 0 0 {name=p52727 lab=_68587_/X }
C {devices/lab_pin.sym} 53160 -18720 0 0 {name=p52728 lab=_69776_/Y }
C {devices/lab_pin.sym} 53280 -18740 0 1 {name=p52729 lab=_69777_/Y }
C {sky130_stdcells/nor2_4.sym} 53220 -18740 0 0 {name=X_69777_ }
C {devices/lab_pin.sym} 53160 -18620 0 0 {name=p52730 lab=_66942_/A }
C {devices/lab_pin.sym} 53160 -18580 0 0 {name=p52731 lab=_88194_/Q }
C {devices/lab_pin.sym} 53280 -18600 0 1 {name=p52732 lab=_66989_/X }
C {sky130_stdcells/and2_4.sym} 53220 -18600 0 0 {name=X_66989_ }
C {devices/lab_pin.sym} 53180 -18470 0 0 {name=p52733 lab=_59529_/X }
C {devices/lab_pin.sym} 53260 -18470 0 1 {name=p52734 lab=_61183_/A }
C {sky130_stdcells/buf_2.sym} 53220 -18470 0 0 {name=X_59530_ }
C {devices/lab_pin.sym} 53140 -18370 0 0 {name=p52735 lab=_56727_/X }
C {devices/lab_pin.sym} 53140 -18330 0 0 {name=p52736 lab=_56736_/X }
C {devices/lab_pin.sym} 53140 -18290 0 0 {name=p52737 lab=_56741_/Y }
C {devices/lab_pin.sym} 53300 -18330 0 1 {name=p52738 lab=_56742_/Y }
C {sky130_stdcells/o21ai_4.sym} 53220 -18330 0 0 {name=X_56742_ }
C {devices/lab_pin.sym} 53160 -18200 0 0 {name=p52739 lab=_69735_/A }
C {devices/lab_pin.sym} 53160 -18160 0 0 {name=p52740 lab=_68727_/Y }
C {devices/lab_pin.sym} 53280 -18180 0 1 {name=p52741 lab=_68728_/Y }
C {sky130_stdcells/nor2_4.sym} 53220 -18180 0 0 {name=X_68728_ }
C {devices/lab_pin.sym} 53130 -18050 0 0 {name=p52742 lab=_83158_/CLK }
C {devices/lab_pin.sym} 53130 -18030 0 0 {name=p52743 lab=_87562_/D }
C {devices/lab_pin.sym} 53310 -18050 0 1 {name=p52744 lab=_43137_/A }
C {sky130_stdcells/dfxtp_4.sym} 53220 -18040 0 0 {name=X_87562_ }
C {devices/lab_pin.sym} 53140 -17930 0 0 {name=p52745 lab=_53952_/Y }
C {devices/lab_pin.sym} 53140 -17890 0 0 {name=p52746 lab=_53948_/X }
C {devices/lab_pin.sym} 53140 -17850 0 0 {name=p52747 lab=_53953_/Y }
C {devices/lab_pin.sym} 53300 -17890 0 1 {name=p52748 lab=_85535_/D }
C {sky130_stdcells/a21boi_4.sym} 53220 -17890 0 0 {name=X_53954_ }
C {devices/lab_pin.sym} 53130 -17750 0 0 {name=p52749 lab=_86688_/CLK }
C {devices/lab_pin.sym} 53130 -17730 0 0 {name=p52750 lab=_84774_/D }
C {devices/lab_pin.sym} 53310 -17750 0 1 {name=p52751 lab=_84774_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -17740 0 0 {name=X_84774_ }
C {devices/lab_pin.sym} 53130 -17610 0 0 {name=p52752 lab=_82104_/CLK }
C {devices/lab_pin.sym} 53130 -17590 0 0 {name=p52753 lab=_81986_/D }
C {devices/lab_pin.sym} 53310 -17610 0 1 {name=p52754 lab=_81986_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -17600 0 0 {name=X_81986_ }
C {devices/lab_pin.sym} 53130 -17470 0 0 {name=p52755 lab=_85859_/CLK }
C {devices/lab_pin.sym} 53130 -17450 0 0 {name=p52756 lab=_48547_/Y }
C {devices/lab_pin.sym} 53310 -17470 0 1 {name=p52757 lab=_86513_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -17460 0 0 {name=X_86513_ }
C {devices/lab_pin.sym} 53160 -17340 0 0 {name=p52758 lab=_52910_/A }
C {devices/lab_pin.sym} 53160 -17300 0 0 {name=p52759 lab=_47184_/X }
C {devices/lab_pin.sym} 53280 -17320 0 1 {name=p52760 lab=_52905_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -17320 0 0 {name=X_52905_ }
C {devices/lab_pin.sym} 53140 -17210 0 0 {name=p52761 lab=_59442_/X }
C {devices/lab_pin.sym} 53140 -17170 0 0 {name=p52762 lab=_83462_/Q }
C {devices/lab_pin.sym} 53140 -17130 0 0 {name=p52763 lab=_59460_/Y }
C {devices/lab_pin.sym} 53300 -17170 0 1 {name=p52764 lab=_84726_/D }
C {sky130_stdcells/o21a_4.sym} 53220 -17170 0 0 {name=X_59461_ }
C {devices/lab_pin.sym} 53130 -17030 0 0 {name=p52765 lab=_85379_/CLK }
C {devices/lab_pin.sym} 53130 -17010 0 0 {name=p52766 lab=_83725_/D }
C {devices/lab_pin.sym} 53310 -17030 0 1 {name=p52767 lab=_47489_/A }
C {sky130_stdcells/dfxtp_4.sym} 53220 -17020 0 0 {name=X_83725_ }
C {devices/lab_pin.sym} 53180 -16890 0 0 {name=p52768 lab=_83328_/Q }
C {devices/lab_pin.sym} 53260 -16890 0 1 {name=p52769 lab=_57270_/A }
C {sky130_stdcells/buf_2.sym} 53220 -16890 0 0 {name=X_56673_ }
C {devices/lab_pin.sym} 53140 -16800 0 0 {name=p52770 lab=_87092_/Q }
C {devices/lab_pin.sym} 53140 -16760 0 0 {name=p52771 lab=_68580_/X }
C {devices/lab_pin.sym} 53140 -16720 0 0 {name=p52772 lab=_68630_/X }
C {devices/lab_pin.sym} 53140 -16680 0 0 {name=p52773 lab=_68658_/X }
C {devices/lab_pin.sym} 53300 -16740 0 1 {name=p52774 lab=_68659_/X }
C {sky130_stdcells/a211o_4.sym} 53220 -16740 0 0 {name=X_68659_ }
C {devices/lab_pin.sym} 53130 -16590 0 0 {name=p52775 lab=_80962_/CLK }
C {devices/lab_pin.sym} 53130 -16570 0 0 {name=p52776 lab=_80937_/D }
C {devices/lab_pin.sym} 53310 -16590 0 1 {name=p52777 lab=_80937_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -16580 0 0 {name=X_80937_ }
C {devices/lab_pin.sym} 53130 -16450 0 0 {name=p52778 lab=_88012_/CLK }
C {devices/lab_pin.sym} 53130 -16430 0 0 {name=p52779 lab=_43294_/X }
C {devices/lab_pin.sym} 53310 -16450 0 1 {name=p52780 lab=_87493_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -16440 0 0 {name=X_87493_ }
C {devices/lab_pin.sym} 53140 -16330 0 0 {name=p52781 lab=_53882_/Y }
C {devices/lab_pin.sym} 53140 -16290 0 0 {name=p52782 lab=_53829_/X }
C {devices/lab_pin.sym} 53140 -16250 0 0 {name=p52783 lab=_53884_/X }
C {devices/lab_pin.sym} 53300 -16290 0 1 {name=p52784 lab=_53885_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -16290 0 0 {name=X_53885_ }
C {devices/lab_pin.sym} 53160 -16160 0 0 {name=p52785 lab=_58412_/A }
C {devices/lab_pin.sym} 53160 -16120 0 0 {name=p52786 lab=_58415_/B }
C {devices/lab_pin.sym} 53280 -16140 0 1 {name=p52787 lab=_58412_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -16140 0 0 {name=X_58412_ }
C {devices/lab_pin.sym} 53160 -16020 0 0 {name=p52788 lab=_55616_/X }
C {devices/lab_pin.sym} 53160 -15980 0 0 {name=p52789 lab=_55624_/B }
C {devices/lab_pin.sym} 53280 -16000 0 1 {name=p52790 lab=_55624_/X }
C {sky130_stdcells/and2_4.sym} 53220 -16000 0 0 {name=X_55624_ }
C {devices/lab_pin.sym} 53130 -15870 0 0 {name=p52791 lab=_86155_/CLK }
C {devices/lab_pin.sym} 53130 -15850 0 0 {name=p52792 lab=_86444_/D }
C {devices/lab_pin.sym} 53310 -15870 0 1 {name=p52793 lab=_65164_/B }
C {sky130_stdcells/dfxtp_4.sym} 53220 -15860 0 0 {name=X_86444_ }
C {devices/lab_pin.sym} 53140 -15770 0 0 {name=p52794 lab=_40835_/X }
C {devices/lab_pin.sym} 53140 -15730 0 0 {name=p52795 lab=_40836_/X }
C {devices/lab_pin.sym} 53140 -15690 0 0 {name=p52796 lab=_40849_/X }
C {devices/lab_pin.sym} 53140 -15650 0 0 {name=p52797 lab=_88323_/Q }
C {devices/lab_pin.sym} 53140 -15610 0 0 {name=p52798 lab=_40832_/X }
C {devices/lab_pin.sym} 53300 -15690 0 1 {name=p52799 lab=_40850_/Y }
C {sky130_stdcells/o32ai_4.sym} 53220 -15690 0 0 {name=X_40850_ }
C {devices/lab_pin.sym} 53140 -15550 0 0 {name=p52800 lab=_52834_/Y }
C {devices/lab_pin.sym} 53140 -15510 0 0 {name=p52801 lab=_52809_/X }
C {devices/lab_pin.sym} 53140 -15470 0 0 {name=p52802 lab=_52835_/X }
C {devices/lab_pin.sym} 53300 -15510 0 1 {name=p52803 lab=_52836_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -15510 0 0 {name=X_52836_ }
C {devices/lab_pin.sym} 53180 -15370 0 0 {name=p52804 lab=_71308_/A }
C {devices/lab_pin.sym} 53260 -15370 0 1 {name=p52805 lab=_71680_/A }
C {sky130_stdcells/buf_2.sym} 53220 -15370 0 0 {name=X_71670_ }
C {devices/lab_pin.sym} 53160 -15260 0 0 {name=p52806 lab=_59392_/A }
C {devices/lab_pin.sym} 53160 -15220 0 0 {name=p52807 lab=_58988_/B }
C {devices/lab_pin.sym} 53280 -15240 0 1 {name=p52808 lab=_59392_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -15240 0 0 {name=X_59392_ }
C {devices/lab_pin.sym} 53130 -15110 0 0 {name=p52809 lab=_85536_/CLK }
C {devices/lab_pin.sym} 53130 -15090 0 0 {name=p52810 lab=_70943_/Y }
C {devices/lab_pin.sym} 53310 -15110 0 1 {name=p52811 lab=_83656_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -15100 0 0 {name=X_83656_ }
C {devices/lab_pin.sym} 53130 -14970 0 0 {name=p52812 lab=_81125_/CLK }
C {devices/lab_pin.sym} 53130 -14950 0 0 {name=p52813 lab=_75597_/B }
C {devices/lab_pin.sym} 53310 -14970 0 1 {name=p52814 lab=_80868_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -14960 0 0 {name=X_80868_ }
C {devices/lab_pin.sym} 53140 -14850 0 0 {name=p52815 lab=_52999_/B }
C {devices/lab_pin.sym} 53140 -14810 0 0 {name=p52816 lab=_70583_/X }
C {devices/lab_pin.sym} 53140 -14770 0 0 {name=p52817 lab=_70620_/Y }
C {devices/lab_pin.sym} 53300 -14810 0 1 {name=p52818 lab=_83739_/D }
C {sky130_stdcells/o21ai_4.sym} 53220 -14810 0 0 {name=X_70621_ }
C {devices/lab_pin.sym} 53180 -14670 0 0 {name=p52819 lab=_84873_/Q }
C {devices/lab_pin.sym} 53260 -14670 0 1 {name=p52820 lab=_58344_/A }
C {sky130_stdcells/buf_2.sym} 53220 -14670 0 0 {name=X_58343_ }
C {devices/lab_pin.sym} 53130 -14550 0 0 {name=p52821 lab=_82575_/CLK }
C {devices/lab_pin.sym} 53130 -14530 0 0 {name=p52822 lab=_78927_/B }
C {devices/lab_pin.sym} 53310 -14550 0 1 {name=p52823 lab=_82607_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -14540 0 0 {name=X_82607_ }
C {devices/lab_pin.sym} 53160 -14420 0 0 {name=p52824 lab=_55524_/A }
C {devices/lab_pin.sym} 53160 -14380 0 0 {name=p52825 lab=_55555_/B }
C {devices/lab_pin.sym} 53280 -14400 0 1 {name=p52826 lab=_55555_/Y }
C {sky130_stdcells/nor2_4.sym} 53220 -14400 0 0 {name=X_55555_ }
C {devices/lab_pin.sym} 53130 -14270 0 0 {name=p52827 lab=_83663_/CLK }
C {devices/lab_pin.sym} 53130 -14250 0 0 {name=p52828 lab=_86375_/D }
C {devices/lab_pin.sym} 53310 -14270 0 1 {name=p52829 lab=_58896_/B }
C {sky130_stdcells/dfxtp_4.sym} 53220 -14260 0 0 {name=X_86375_ }
C {devices/lab_pin.sym} 53180 -14130 0 0 {name=p52830 lab=_52767_/A }
C {devices/lab_pin.sym} 53260 -14130 0 1 {name=p52831 lab=_52773_/A }
C {sky130_stdcells/buf_2.sym} 53220 -14130 0 0 {name=X_52767_ }
C {devices/lab_pin.sym} 53180 -14010 0 0 {name=p52832 lab=_40780_/Y }
C {devices/lab_pin.sym} 53260 -14010 0 1 {name=p52833 lab=_40781_/X }
C {sky130_stdcells/buf_2.sym} 53220 -14010 0 0 {name=X_40781_ }
C {devices/lab_pin.sym} 53130 -13890 0 0 {name=p52834 lab=_85593_/CLK }
C {devices/lab_pin.sym} 53130 -13870 0 0 {name=p52835 lab=_83587_/D }
C {devices/lab_pin.sym} 53310 -13890 0 1 {name=p52836 lab=_83587_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -13880 0 0 {name=X_83587_ }
C {devices/lab_pin.sym} 53130 -13750 0 0 {name=p52837 lab=_80817_/CLK }
C {devices/lab_pin.sym} 53130 -13730 0 0 {name=p52838 lab=_75855_/Y }
C {devices/lab_pin.sym} 53310 -13750 0 1 {name=p52839 lab=_75533_/B }
C {sky130_stdcells/dfxtp_4.sym} 53220 -13740 0 0 {name=X_80799_ }
C {devices/lab_pin.sym} 53130 -13610 0 0 {name=p52840 lab=_87834_/CLK }
C {devices/lab_pin.sym} 53130 -13590 0 0 {name=p52841 lab=_88114_/D }
C {devices/lab_pin.sym} 53310 -13610 0 1 {name=p52842 lab=_88114_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -13600 0 0 {name=X_88114_ }
C {devices/lab_pin.sym} 53140 -13490 0 0 {name=p52843 lab=_85429_/Q }
C {devices/lab_pin.sym} 53140 -13450 0 0 {name=p52844 lab=_54485_/X }
C {devices/lab_pin.sym} 53140 -13410 0 0 {name=p52845 lab=_54505_/Y }
C {devices/lab_pin.sym} 53300 -13450 0 1 {name=p52846 lab=_54506_/Y }
C {sky130_stdcells/o21ai_4.sym} 53220 -13450 0 0 {name=X_54506_ }
C {devices/lab_pin.sym} 53140 -13350 0 0 {name=p52847 lab=_42517_/X }
C {devices/lab_pin.sym} 53140 -13310 0 0 {name=p52848 lab=_42501_/X }
C {devices/lab_pin.sym} 53140 -13270 0 0 {name=p52849 lab=_40716_/X }
C {devices/lab_pin.sym} 53140 -13230 0 0 {name=p52850 lab=_42518_/Y }
C {devices/lab_pin.sym} 53140 -13190 0 0 {name=p52851 lab=_42519_/X }
C {devices/lab_pin.sym} 53300 -13270 0 1 {name=p52852 lab=_87836_/D }
C {sky130_stdcells/o32ai_4.sym} 53220 -13270 0 0 {name=X_42520_ }
C {devices/lab_pin.sym} 53140 -13130 0 0 {name=p52853 lab=_83155_/Q }
C {devices/lab_pin.sym} 53140 -13090 0 0 {name=p52854 lab=_73318_/X }
C {devices/lab_pin.sym} 53140 -13050 0 0 {name=p52855 lab=_73339_/Y }
C {devices/lab_pin.sym} 53300 -13090 0 1 {name=p52856 lab=_83155_/D }
C {sky130_stdcells/a21o_4.sym} 53220 -13090 0 0 {name=X_73340_ }
C {devices/lab_pin.sym} 53130 -12950 0 0 {name=p52857 lab=_83550_/CLK }
C {devices/lab_pin.sym} 53130 -12930 0 0 {name=p52858 lab=_85326_/D }
C {devices/lab_pin.sym} 53310 -12950 0 1 {name=p52859 lab=_85326_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -12940 0 0 {name=X_85326_ }
C {devices/lab_pin.sym} 53140 -12830 0 0 {name=p52860 lab=_85958_/Q }
C {devices/lab_pin.sym} 53140 -12790 0 0 {name=p52861 lab=_51701_/X }
C {devices/lab_pin.sym} 53140 -12750 0 0 {name=p52862 lab=_51717_/Y }
C {devices/lab_pin.sym} 53300 -12790 0 1 {name=p52863 lab=_51718_/Y }
C {sky130_stdcells/o21ai_4.sym} 53220 -12790 0 0 {name=X_51718_ }
C {devices/lab_pin.sym} 53180 -12650 0 0 {name=p52864 lab=DATA_TO_HASH[4] }
C {devices/lab_pin.sym} 53260 -12650 0 1 {name=p52865 lab=_70552_/Y }
C {sky130_stdcells/inv_2.sym} 53220 -12650 0 0 {name=X_70552_ }
C {devices/lab_pin.sym} 53160 -12540 0 0 {name=p52866 lab=_58274_/A }
C {devices/lab_pin.sym} 53160 -12500 0 0 {name=p52867 lab=_58280_/B }
C {devices/lab_pin.sym} 53280 -12520 0 1 {name=p52868 lab=_58274_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -12520 0 0 {name=X_58274_ }
C {devices/lab_pin.sym} 53130 -12390 0 0 {name=p52869 lab=_82538_/CLK }
C {devices/lab_pin.sym} 53130 -12370 0 0 {name=p52870 lab=_82538_/D }
C {devices/lab_pin.sym} 53310 -12390 0 1 {name=p52871 lab=_79020_/B }
C {sky130_stdcells/dfxtp_4.sym} 53220 -12380 0 0 {name=X_82538_ }
C {devices/lab_pin.sym} 53140 -12270 0 0 {name=p52872 lab=_55482_/X }
C {devices/lab_pin.sym} 53140 -12230 0 0 {name=p52873 lab=_55485_/X }
C {devices/lab_pin.sym} 53140 -12190 0 0 {name=p52874 lab=_44112_/X }
C {devices/lab_pin.sym} 53300 -12230 0 1 {name=p52875 lab=_55491_/A }
C {sky130_stdcells/a21o_4.sym} 53220 -12230 0 0 {name=X_55486_ }
C {devices/lab_pin.sym} 53160 -12120 0 0 {name=p52876 lab=_52674_/X }
C {devices/lab_pin.sym} 53160 -12080 0 0 {name=p52877 lab=_52694_/B }
C {devices/lab_pin.sym} 53160 -12040 0 0 {name=p52878 lab=_52694_/C }
C {devices/lab_pin.sym} 53160 -12000 0 0 {name=p52879 lab=_52698_/D }
C {devices/lab_pin.sym} 53280 -12060 0 1 {name=p52880 lab=_52698_/X }
C {sky130_stdcells/and4_4.sym} 53220 -12060 0 0 {name=X_52698_ }
C {devices/lab_pin.sym} 53160 -11920 0 0 {name=p52881 lab=_56852_/A }
C {devices/lab_pin.sym} 53160 -11880 0 0 {name=p52882 lab=_57193_/D }
C {devices/lab_pin.sym} 53280 -11900 0 1 {name=p52883 lab=_57225_/Y }
C {sky130_stdcells/nor2_4.sym} 53220 -11900 0 0 {name=X_57225_ }
C {devices/lab_pin.sym} 53180 -11770 0 0 {name=p52884 lab=_42579_/A }
C {devices/lab_pin.sym} 53260 -11770 0 1 {name=p52885 lab=_42488_/A }
C {sky130_stdcells/buf_2.sym} 53220 -11770 0 0 {name=X_42451_ }
C {devices/lab_pin.sym} 53130 -11650 0 0 {name=p52886 lab=_88084_/CLK }
C {devices/lab_pin.sym} 53130 -11630 0 0 {name=p52887 lab=_42075_/X }
C {devices/lab_pin.sym} 53310 -11650 0 1 {name=p52888 lab=_88045_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -11640 0 0 {name=X_88045_ }
C {devices/lab_pin.sym} 53160 -11520 0 0 {name=p52889 lab=_54446_/A }
C {devices/lab_pin.sym} 53160 -11480 0 0 {name=p52890 lab=_52744_/B }
C {devices/lab_pin.sym} 53280 -11500 0 1 {name=p52891 lab=_54437_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -11500 0 0 {name=X_54437_ }
C {devices/lab_pin.sym} 53140 -11390 0 0 {name=p52892 lab=_73269_/X }
C {devices/lab_pin.sym} 53140 -11350 0 0 {name=p52893 lab=_73270_/Y }
C {devices/lab_pin.sym} 53140 -11310 0 0 {name=p52894 lab=_73221_/X }
C {devices/lab_pin.sym} 53300 -11350 0 1 {name=p52895 lab=_73271_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -11350 0 0 {name=X_73271_ }
C {devices/lab_pin.sym} 53130 -11210 0 0 {name=p52896 lab=_85257_/CLK }
C {devices/lab_pin.sym} 53130 -11190 0 0 {name=p52897 lab=_56257_/Y }
C {devices/lab_pin.sym} 53310 -11210 0 1 {name=p52898 lab=_85257_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -11200 0 0 {name=X_85257_ }
C {devices/lab_pin.sym} 53160 -11080 0 0 {name=p52899 lab=_51671_/A }
C {devices/lab_pin.sym} 53160 -11040 0 0 {name=p52900 lab=_53174_/B }
C {devices/lab_pin.sym} 53280 -11060 0 1 {name=p52901 lab=_51649_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -11060 0 0 {name=X_51649_ }
C {devices/lab_pin.sym} 53160 -10950 0 0 {name=p52902 lab=_71706_/A }
C {devices/lab_pin.sym} 53160 -10910 0 0 {name=p52903 lab=_70483_/B }
C {devices/lab_pin.sym} 53160 -10870 0 0 {name=p52904 lab=_71435_/C }
C {devices/lab_pin.sym} 53280 -10910 0 1 {name=p52905 lab=_70483_/X }
C {sky130_stdcells/and3_4.sym} 53220 -10910 0 0 {name=X_70483_ }
C {devices/lab_pin.sym} 53130 -10770 0 0 {name=p52906 lab=_82924_/CLK }
C {devices/lab_pin.sym} 53130 -10750 0 0 {name=p52907 lab=_82469_/D }
C {devices/lab_pin.sym} 53310 -10770 0 1 {name=p52908 lab=_78273_/B }
C {sky130_stdcells/dfxtp_4.sym} 53220 -10760 0 0 {name=X_82469_ }
C {devices/lab_pin.sym} 53160 -10640 0 0 {name=p52909 lab=_75008_/X }
C {devices/lab_pin.sym} 53160 -10600 0 0 {name=p52910 lab=_75021_/B }
C {devices/lab_pin.sym} 53280 -10620 0 1 {name=p52911 lab=_75010_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -10620 0 0 {name=X_75010_ }
C {devices/lab_pin.sym} 53140 -10510 0 0 {name=p52912 lab=_41373_/X }
C {devices/lab_pin.sym} 53140 -10470 0 0 {name=p52913 lab=_82891_/Q }
C {devices/lab_pin.sym} 53140 -10430 0 0 {name=p52914 lab=_41401_/X }
C {devices/lab_pin.sym} 53300 -10470 0 1 {name=p52915 lab=_41402_/X }
C {sky130_stdcells/o21a_4.sym} 53220 -10470 0 0 {name=X_41402_ }
C {devices/lab_pin.sym} 53140 -10370 0 0 {name=p52916 lab=_72172_/X }
C {devices/lab_pin.sym} 53140 -10330 0 0 {name=p52917 lab=_72220_/Y }
C {devices/lab_pin.sym} 53140 -10290 0 0 {name=p52918 lab=_72221_/Y }
C {devices/lab_pin.sym} 53140 -10250 0 0 {name=p52919 lab=_72189_/X }
C {devices/lab_pin.sym} 53140 -10210 0 0 {name=p52920 lab=_72176_/X }
C {devices/lab_pin.sym} 53300 -10290 0 1 {name=p52921 lab=_72222_/X }
C {sky130_stdcells/o32a_4.sym} 53220 -10290 0 0 {name=X_72222_ }
C {devices/lab_pin.sym} 53130 -10130 0 0 {name=p52922 lab=_85315_/CLK }
C {devices/lab_pin.sym} 53130 -10110 0 0 {name=p52923 lab=_84208_/D }
C {devices/lab_pin.sym} 53310 -10130 0 1 {name=p52924 lab=_65268_/C }
C {sky130_stdcells/dfxtp_4.sym} 53220 -10120 0 0 {name=X_84208_ }
C {devices/lab_pin.sym} 53140 -10010 0 0 {name=p52925 lab=_45167_/X }
C {devices/lab_pin.sym} 53140 -9970 0 0 {name=p52926 lab=_45169_/Y }
C {devices/lab_pin.sym} 53140 -9930 0 0 {name=p52927 lab=_45125_/X }
C {devices/lab_pin.sym} 53300 -9970 0 1 {name=p52928 lab=_45170_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -9970 0 0 {name=X_45170_ }
C {devices/lab_pin.sym} 53180 -9830 0 0 {name=p52929 lab=_57129_/Y }
C {devices/lab_pin.sym} 53260 -9830 0 1 {name=p52930 lab=_57156_/X }
C {sky130_stdcells/buf_2.sym} 53220 -9830 0 0 {name=X_57156_ }
C {devices/lab_pin.sym} 53140 -9730 0 0 {name=p52931 lab=_54365_/Y }
C {devices/lab_pin.sym} 53140 -9690 0 0 {name=p52932 lab=_54366_/X }
C {devices/lab_pin.sym} 53140 -9650 0 0 {name=p52933 lab=_54367_/X }
C {devices/lab_pin.sym} 53300 -9690 0 1 {name=p52934 lab=_54368_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -9690 0 0 {name=X_54368_ }
C {devices/lab_pin.sym} 53180 -9550 0 0 {name=p52935 lab=_42382_/A }
C {devices/lab_pin.sym} 53260 -9550 0 1 {name=p52936 lab=_87892_/D }
C {sky130_stdcells/inv_2.sym} 53220 -9550 0 0 {name=X_42382_ }
C {devices/lab_pin.sym} 53130 -9430 0 0 {name=p52937 lab=_85186_/CLK }
C {devices/lab_pin.sym} 53130 -9410 0 0 {name=p52938 lab=_56453_/Y }
C {devices/lab_pin.sym} 53310 -9430 0 1 {name=p52939 lab=_56452_/C }
C {sky130_stdcells/dfxtp_4.sym} 53220 -9420 0 0 {name=X_85188_ }
C {devices/lab_pin.sym} 53160 -9300 0 0 {name=p52940 lab=_55802_/X }
C {devices/lab_pin.sym} 53160 -9260 0 0 {name=p52941 lab=_55811_/X }
C {devices/lab_pin.sym} 53280 -9280 0 1 {name=p52942 lab=_56108_/B }
C {sky130_stdcells/and2_4.sym} 53220 -9280 0 0 {name=X_56107_ }
C {devices/lab_pin.sym} 53180 -9150 0 0 {name=p52943 lab=_44120_/Y }
C {devices/lab_pin.sym} 53260 -9150 0 1 {name=p52944 lab=_44196_/A }
C {sky130_stdcells/buf_2.sym} 53220 -9150 0 0 {name=X_44121_ }
C {devices/lab_pin.sym} 53180 -9030 0 0 {name=p52945 lab=_41235_/X }
C {devices/lab_pin.sym} 53260 -9030 0 1 {name=p52946 lab=_41333_/X }
C {sky130_stdcells/buf_2.sym} 53220 -9030 0 0 {name=X_41333_ }
C {devices/lab_pin.sym} 53140 -8930 0 0 {name=p52947 lab=_85655_/Q }
C {devices/lab_pin.sym} 53140 -8890 0 0 {name=p52948 lab=_53295_/X }
C {devices/lab_pin.sym} 53140 -8850 0 0 {name=p52949 lab=_53318_/Y }
C {devices/lab_pin.sym} 53300 -8890 0 1 {name=p52950 lab=_53319_/Y }
C {sky130_stdcells/o21ai_4.sym} 53220 -8890 0 0 {name=X_53319_ }
C {devices/lab_pin.sym} 53140 -8770 0 0 {name=p52951 lab=_59292_/X }
C {devices/lab_pin.sym} 53140 -8730 0 0 {name=p52952 lab=_85342_/Q }
C {devices/lab_pin.sym} 53140 -8690 0 0 {name=p52953 lab=_59365_/X }
C {devices/lab_pin.sym} 53300 -8730 0 1 {name=p52954 lab=_72153_/X }
C {sky130_stdcells/o21a_4.sym} 53220 -8730 0 0 {name=X_72153_ }
C {devices/lab_pin.sym} 53130 -8590 0 0 {name=p52955 lab=_82746_/CLK }
C {devices/lab_pin.sym} 53130 -8570 0 0 {name=p52956 lab=_84139_/D }
C {devices/lab_pin.sym} 53310 -8590 0 1 {name=p52957 lab=_84139_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -8580 0 0 {name=X_84139_ }
C {devices/lab_pin.sym} 53180 -8450 0 0 {name=p52958 lab=_57086_/X }
C {devices/lab_pin.sym} 53260 -8450 0 1 {name=p52959 lab=_57087_/X }
C {sky130_stdcells/buf_2.sym} 53220 -8450 0 0 {name=X_57087_ }
C {devices/lab_pin.sym} 53140 -8350 0 0 {name=p52960 lab=_54297_/Y }
C {devices/lab_pin.sym} 53140 -8310 0 0 {name=p52961 lab=_54285_/X }
C {devices/lab_pin.sym} 53140 -8270 0 0 {name=p52962 lab=_54298_/X }
C {devices/lab_pin.sym} 53300 -8310 0 1 {name=p52963 lab=_54299_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -8310 0 0 {name=X_54299_ }
C {devices/lab_pin.sym} 53160 -8190 0 0 {name=p52964 lab=_71101_/X }
C {devices/lab_pin.sym} 53160 -8150 0 0 {name=p52965 lab=_71080_/B }
C {devices/lab_pin.sym} 53160 -8110 0 0 {name=p52966 lab=_71099_/C }
C {devices/lab_pin.sym} 53280 -8150 0 1 {name=p52967 lab=_71104_/Y }
C {sky130_stdcells/nand3_4.sym} 53220 -8150 0 0 {name=X_71104_ }
C {devices/lab_pin.sym} 53180 -8010 0 0 {name=p52968 lab=_44052_/A }
C {devices/lab_pin.sym} 53260 -8010 0 1 {name=p52969 lab=_44052_/X }
C {sky130_stdcells/buf_2.sym} 53220 -8010 0 0 {name=X_44052_ }
C {devices/lab_pin.sym} 53140 -7910 0 0 {name=p52970 lab=_56029_/X }
C {devices/lab_pin.sym} 53140 -7870 0 0 {name=p52971 lab=_56035_/X }
C {devices/lab_pin.sym} 53140 -7830 0 0 {name=p52972 lab=_56037_/Y }
C {devices/lab_pin.sym} 53300 -7870 0 1 {name=p52973 lab=_85307_/D }
C {sky130_stdcells/o21ai_4.sym} 53220 -7870 0 0 {name=X_56038_ }
C {devices/lab_pin.sym} 53180 -7730 0 0 {name=p52974 lab=_41264_/A }
C {devices/lab_pin.sym} 53260 -7730 0 1 {name=p52975 lab=_41264_/X }
C {sky130_stdcells/buf_2.sym} 53220 -7730 0 0 {name=X_41264_ }
C {devices/lab_pin.sym} 53160 -7620 0 0 {name=p52976 lab=_72075_/A }
C {devices/lab_pin.sym} 53160 -7580 0 0 {name=p52977 lab=_53910_/A }
C {devices/lab_pin.sym} 53280 -7600 0 1 {name=p52978 lab=_72084_/Y }
C {sky130_stdcells/nand2_4.sym} 53220 -7600 0 0 {name=X_72084_ }
C {devices/lab_pin.sym} 53180 -7470 0 0 {name=p52979 lab=_76828_/Y }
C {devices/lab_pin.sym} 53260 -7470 0 1 {name=p52980 lab=_76961_/Y }
C {sky130_stdcells/inv_2.sym} 53220 -7470 0 0 {name=X_76961_ }
C {devices/lab_pin.sym} 53140 -7380 0 0 {name=p52981 lab=_40524_/X }
C {devices/lab_pin.sym} 53140 -7340 0 0 {name=p52982 lab=_42994_/X }
C {devices/lab_pin.sym} 53140 -7300 0 0 {name=p52983 lab=_87609_/Q }
C {devices/lab_pin.sym} 53140 -7260 0 0 {name=p52984 lab=_42995_/X }
C {devices/lab_pin.sym} 53300 -7320 0 1 {name=p52985 lab=_87609_/D }
C {sky130_stdcells/a2bb2o_4.sym} 53220 -7320 0 0 {name=X_43003_ }
C {devices/lab_pin.sym} 53180 -7170 0 0 {name=p52986 lab=_78700_/A }
C {devices/lab_pin.sym} 53260 -7170 0 1 {name=p52987 lab=_78700_/Y }
C {sky130_stdcells/inv_2.sym} 53220 -7170 0 0 {name=X_78700_ }
C {devices/lab_pin.sym} 53180 -7050 0 0 {name=p52988 lab=_70786_/A }
C {devices/lab_pin.sym} 53260 -7050 0 1 {name=p52989 lab=_71181_/A }
C {sky130_stdcells/buf_2.sym} 53220 -7050 0 0 {name=X_71035_ }
C {devices/lab_pin.sym} 53160 -6940 0 0 {name=p52990 lab=_61192_/C }
C {devices/lab_pin.sym} 53160 -6900 0 0 {name=p52991 lab=_75912_/B }
C {devices/lab_pin.sym} 53280 -6920 0 1 {name=p52992 lab=_75912_/X }
C {sky130_stdcells/xor2_4.sym} 53220 -6920 0 0 {name=X_75912_ }
C {devices/lab_pin.sym} 53140 -6810 0 0 {name=p52993 lab=_48857_/Y }
C {devices/lab_pin.sym} 53140 -6770 0 0 {name=p52994 lab=_48840_/X }
C {devices/lab_pin.sym} 53140 -6730 0 0 {name=p52995 lab=_48859_/X }
C {devices/lab_pin.sym} 53300 -6770 0 1 {name=p52996 lab=_48860_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -6770 0 0 {name=X_48860_ }
C {devices/lab_pin.sym} 53160 -6640 0 0 {name=p52997 lab=_79680_/A }
C {devices/lab_pin.sym} 53160 -6600 0 0 {name=p52998 lab=_84246_/Q }
C {devices/lab_pin.sym} 53280 -6620 0 1 {name=p52999 lab=_79681_/B }
C {sky130_stdcells/xor2_4.sym} 53220 -6620 0 0 {name=X_79680_ }
C {devices/lab_pin.sym} 53140 -6530 0 0 {name=p53000 lab=_41112_/X }
C {devices/lab_pin.sym} 53140 -6490 0 0 {name=p53001 lab=_41113_/X }
C {devices/lab_pin.sym} 53140 -6450 0 0 {name=p53002 lab=_41193_/X }
C {devices/lab_pin.sym} 53140 -6410 0 0 {name=p53003 lab=_68763_/B }
C {devices/lab_pin.sym} 53140 -6370 0 0 {name=p53004 lab=_41194_/X }
C {devices/lab_pin.sym} 53300 -6450 0 1 {name=p53005 lab=_41196_/A }
C {sky130_stdcells/o32ai_4.sym} 53220 -6450 0 0 {name=X_41195_ }
C {devices/lab_pin.sym} 53160 -6300 0 0 {name=p53006 lab=_76884_/X }
C {devices/lab_pin.sym} 53160 -6260 0 0 {name=p53007 lab=_81500_/Q }
C {devices/lab_pin.sym} 53280 -6280 0 1 {name=p53008 lab=_76893_/A }
C {sky130_stdcells/and2_4.sym} 53220 -6280 0 0 {name=X_76892_ }
C {devices/lab_pin.sym} 53140 -6170 0 0 {name=p53009 lab=_86595_/Q }
C {devices/lab_pin.sym} 53140 -6130 0 0 {name=p53010 lab=_47806_/X }
C {devices/lab_pin.sym} 53140 -6090 0 0 {name=p53011 lab=_47810_/Y }
C {devices/lab_pin.sym} 53300 -6130 0 1 {name=p53012 lab=_47811_/Y }
C {sky130_stdcells/o21ai_4.sym} 53220 -6130 0 0 {name=X_47811_ }
C {devices/lab_pin.sym} 53180 -5990 0 0 {name=p53013 lab=_78630_/Y }
C {devices/lab_pin.sym} 53260 -5990 0 1 {name=p53014 lab=_78632_/C }
C {sky130_stdcells/inv_2.sym} 53220 -5990 0 0 {name=X_78631_ }
C {devices/lab_pin.sym} 53180 -5870 0 0 {name=p53015 lab=_75842_/Y }
C {devices/lab_pin.sym} 53260 -5870 0 1 {name=p53016 lab=_75843_/Y }
C {sky130_stdcells/inv_2.sym} 53220 -5870 0 0 {name=X_75843_ }
C {devices/lab_pin.sym} 53130 -5750 0 0 {name=p53017 lab=_87826_/CLK }
C {devices/lab_pin.sym} 53130 -5730 0 0 {name=p53018 lab=_87829_/D }
C {devices/lab_pin.sym} 53310 -5750 0 1 {name=p53019 lab=_87829_/Q }
C {sky130_stdcells/dfxtp_4.sym} 53220 -5740 0 0 {name=X_87829_ }
C {devices/lab_pin.sym} 53160 -5630 0 0 {name=p53020 lab=_48533_/A }
C {devices/lab_pin.sym} 53160 -5590 0 0 {name=p53021 lab=_48770_/X }
C {devices/lab_pin.sym} 53160 -5550 0 0 {name=p53022 lab=_48814_/C }
C {devices/lab_pin.sym} 53280 -5590 0 1 {name=p53023 lab=_48791_/X }
C {sky130_stdcells/and3_4.sym} 53220 -5590 0 0 {name=X_48791_ }
C {devices/lab_pin.sym} 53180 -5450 0 0 {name=p53024 lab=_58631_/A }
C {devices/lab_pin.sym} 53260 -5450 0 1 {name=p53025 lab=_57989_/X }
C {sky130_stdcells/buf_2.sym} 53220 -5450 0 0 {name=X_57989_ }
C {devices/lab_pin.sym} 53180 -5330 0 0 {name=p53026 lab=clkbuf_9_276_0_CLK/X }
C {devices/lab_pin.sym} 53260 -5330 0 1 {name=p53027 lab=_88175_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 53220 -5330 0 0 {name=Xclkbuf_10_552_0_CLK }
C {devices/lab_pin.sym} 53180 -5210 0 0 {name=p53028 lab=clkbuf_6_43_0_CLK/A }
C {devices/lab_pin.sym} 53260 -5210 0 1 {name=p53029 lab=clkbuf_7_87_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 53220 -5210 0 0 {name=Xclkbuf_6_43_0_CLK }
C {devices/lab_pin.sym} 53180 -5090 0 0 {name=p53030 lab=_47741_/Y }
C {devices/lab_pin.sym} 53260 -5090 0 1 {name=p53031 lab=_53219_/B }
C {sky130_stdcells/buf_2.sym} 53220 -5090 0 0 {name=X_47742_ }
C {devices/lab_pin.sym} 53140 -4990 0 0 {name=p53032 lab=_59689_/B }
C {devices/lab_pin.sym} 53140 -4950 0 0 {name=p53033 lab=_59689_/A }
C {devices/lab_pin.sym} 53140 -4910 0 0 {name=p53034 lab=_59666_/A }
C {devices/lab_pin.sym} 53300 -4950 0 1 {name=p53035 lab=_59728_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -4950 0 0 {name=X_59728_ }
C {devices/lab_pin.sym} 53140 -4830 0 0 {name=p53036 lab=_78533_/X }
C {devices/lab_pin.sym} 53140 -4790 0 0 {name=p53037 lab=_78536_/X }
C {devices/lab_pin.sym} 53140 -4750 0 0 {name=p53038 lab=_78561_/Y }
C {devices/lab_pin.sym} 53300 -4790 0 1 {name=p53039 lab=_78562_/X }
C {sky130_stdcells/o21a_4.sym} 53220 -4790 0 0 {name=X_78562_ }
C {devices/lab_pin.sym} 53140 -4670 0 0 {name=p53040 lab=_44905_/X }
C {devices/lab_pin.sym} 53140 -4630 0 0 {name=p53041 lab=_61364_/B }
C {devices/lab_pin.sym} 53140 -4590 0 0 {name=p53042 lab=_44907_/X }
C {devices/lab_pin.sym} 53300 -4630 0 1 {name=p53043 lab=_44954_/Y }
C {sky130_stdcells/o21ai_4.sym} 53220 -4630 0 0 {name=X_44954_ }
C {devices/lab_pin.sym} 53140 -4510 0 0 {name=p53044 lab=_75761_/Y }
C {devices/lab_pin.sym} 53140 -4470 0 0 {name=p53045 lab=_75762_/Y }
C {devices/lab_pin.sym} 53140 -4430 0 0 {name=p53046 lab=_75773_/X }
C {devices/lab_pin.sym} 53300 -4470 0 1 {name=p53047 lab=_75774_/Y }
C {sky130_stdcells/a21oi_4.sym} 53220 -4470 0 0 {name=X_75774_ }
C {devices/lab_pin.sym} 53160 -4340 0 0 {name=p53048 lab=_73181_/A }
C {devices/lab_pin.sym} 53160 -4300 0 0 {name=p53049 lab=_85881_/Q }
C {devices/lab_pin.sym} 53280 -4320 0 1 {name=p53050 lab=_72986_/X }
C {sky130_stdcells/and2_4.sym} 53220 -4320 0 0 {name=X_72986_ }
C {devices/lab_pin.sym} 53140 -4210 0 0 {name=p53051 lab=_77502_/A }
C {devices/lab_pin.sym} 53140 -4170 0 0 {name=p53052 lab=_77501_/Y }
C {devices/lab_pin.sym} 53140 -4130 0 0 {name=p53053 lab=_77495_/Y }
C {devices/lab_pin.sym} 53300 -4170 0 1 {name=p53054 lab=_77514_/B }
C {sky130_stdcells/o21ai_4.sym} 53220 -4170 0 0 {name=X_77513_ }
C {devices/lab_pin.sym} 53140 -4060 0 0 {name=p53055 lab=_41352_/X }
C {devices/lab_pin.sym} 53140 -4020 0 0 {name=p53056 lab=_43886_/X }
C {devices/lab_pin.sym} 53140 -3980 0 0 {name=p53057 lab=_67616_/B }
C {devices/lab_pin.sym} 53140 -3940 0 0 {name=p53058 lab=_43887_/X }
C {devices/lab_pin.sym} 53300 -4000 0 1 {name=p53059 lab=_87207_/D }
C {sky130_stdcells/a2bb2o_4.sym} 53220 -4000 0 0 {name=X_43905_ }
C {devices/lab_pin.sym} 53160 -3870 0 0 {name=p53060 lab=_74723_/X }
C {devices/lab_pin.sym} 53160 -3830 0 0 {name=p53061 lab=_83794_/Q }
C {devices/lab_pin.sym} 53160 -3790 0 0 {name=p53062 lab=_74745_/D }
C {devices/lab_pin.sym} 53280 -3830 0 1 {name=p53063 lab=_74730_/B }
C {sky130_stdcells/nand3_4.sym} 53220 -3830 0 0 {name=X_74725_ }
C {devices/lab_pin.sym} 53180 -3690 0 0 {name=p53064 lab=_49379_/A }
C {devices/lab_pin.sym} 53260 -3690 0 1 {name=p53065 lab=_47692_/A }
C {sky130_stdcells/buf_2.sym} 53220 -3690 0 0 {name=X_47673_ }
C {devices/lab_pin.sym} 53140 -3590 0 0 {name=p53066 lab=_56816_/Y }
C {devices/lab_pin.sym} 53140 -3550 0 0 {name=p53067 lab=_71917_/X }
C {devices/lab_pin.sym} 53140 -3510 0 0 {name=p53068 lab=_71936_/Y }
C {devices/lab_pin.sym} 53300 -3550 0 1 {name=p53069 lab=_71937_/Y }
C {sky130_stdcells/o21ai_4.sym} 53220 -3550 0 0 {name=X_71937_ }
C {devices/lab_pin.sym} 53180 -3410 0 0 {name=p53070 lab=_59582_/B }
C {devices/lab_pin.sym} 53260 -3410 0 1 {name=p53071 lab=_59660_/D }
C {sky130_stdcells/buf_2.sym} 53220 -3410 0 0 {name=X_59659_ }
C {devices/lab_pin.sym} 53160 -3300 0 0 {name=p53072 lab=_78491_/X }
C {devices/lab_pin.sym} 53160 -3260 0 0 {name=p53073 lab=_78492_/Y }
C {devices/lab_pin.sym} 53280 -3280 0 1 {name=p53074 lab=_78494_/A }
C {sky130_stdcells/and2_4.sym} 53220 -3280 0 0 {name=X_78493_ }
C {devices/lab_pin.sym} 53140 -3170 0 0 {name=p53075 lab=_85185_/Q }
C {devices/lab_pin.sym} 53140 -3130 0 0 {name=p53076 lab=_44882_/X }
C {devices/lab_pin.sym} 53140 -3090 0 0 {name=p53077 lab=_44884_/X }
C {devices/lab_pin.sym} 53300 -3130 0 1 {name=p53078 lab=_44885_/X }
C {sky130_stdcells/o21a_4.sym} 53220 -3130 0 0 {name=X_44885_ }
C {devices/lab_pin.sym} 53180 -2990 0 0 {name=p53079 lab=_49493_/A }
C {devices/lab_pin.sym} 53260 -2990 0 1 {name=p53080 lab=_49420_/C }
C {sky130_stdcells/buf_2.sym} 53220 -2990 0 0 {name=X_49412_ }
C {devices/lab_pin.sym} 53180 -2870 0 0 {name=p53081 lab=_46624_/A }
C {devices/lab_pin.sym} 53260 -2870 0 1 {name=p53082 lab=_46624_/Y }
C {sky130_stdcells/inv_2.sym} 53220 -2870 0 0 {name=X_46624_ }
C {devices/lab_pin.sym} 53160 -2760 0 0 {name=p53083 lab=_77444_/A }
C {devices/lab_pin.sym} 53160 -2720 0 0 {name=p53084 lab=_77444_/B }
C {devices/lab_pin.sym} 53280 -2740 0 1 {name=p53085 lab=_77444_/Y }
C {sky130_stdcells/nor2_4.sym} 53220 -2740 0 0 {name=X_77444_ }
C {devices/lab_pin.sym} 53140 -2640 0 0 {name=p53086 lab=_41161_/X }
C {devices/lab_pin.sym} 53140 -2600 0 0 {name=p53087 lab=_43832_/X }
C {devices/lab_pin.sym} 53140 -2560 0 0 {name=p53088 lab=_68604_/B }
C {devices/lab_pin.sym} 53140 -2520 0 0 {name=p53089 lab=_43833_/X }
C {devices/lab_pin.sym} 53300 -2580 0 1 {name=p53090 lab=_43836_/X }
C {sky130_stdcells/a2bb2o_4.sym} 53220 -2580 0 0 {name=X_43836_ }
C {devices/lab_pin.sym} 53140 -2470 0 0 {name=p53091 lab=_62659_/Y }
C {devices/lab_pin.sym} 53140 -2430 0 0 {name=p53092 lab=_62660_/X }
C {devices/lab_pin.sym} 53140 -2390 0 0 {name=p53093 lab=_62661_/Y }
C {devices/lab_pin.sym} 53140 -2350 0 0 {name=p53094 lab=_62664_/Y }
C {devices/lab_pin.sym} 53140 -2320 0 0 {name=p53095 lab=_62669_/X }
C {devices/lab_pin.sym} 53300 -2390 0 1 {name=p53096 lab=_62670_/X }
C {sky130_stdcells/a41o_4.sym} 53220 -2390 0 0 {name=X_62670_ }
C {devices/lab_pin.sym} 53180 -2230 0 0 {name=p53097 lab=_74685_/C }
C {devices/lab_pin.sym} 53260 -2230 0 1 {name=p53098 lab=_74656_/X }
C {sky130_stdcells/buf_2.sym} 53220 -2230 0 0 {name=X_74656_ }
C {devices/lab_pin.sym} 53140 -2130 0 0 {name=p53099 lab=_71847_/Y }
C {devices/lab_pin.sym} 53140 -2090 0 0 {name=p53100 lab=_83346_/Q }
C {devices/lab_pin.sym} 53140 -2050 0 0 {name=p53101 lab=_71867_/Y }
C {devices/lab_pin.sym} 53300 -2090 0 1 {name=p53102 lab=_83346_/D }
C {sky130_stdcells/a21o_4.sym} 53220 -2090 0 0 {name=X_71868_ }
C {devices/lab_pin.sym} 53180 -1950 0 0 {name=p53103 lab=clkbuf_9_283_0_CLK/X }
C {devices/lab_pin.sym} 53260 -1950 0 1 {name=p53104 lab=_86807_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 53220 -1950 0 0 {name=Xclkbuf_10_567_0_CLK }
C {devices/lab_pin.sym} 53180 -1830 0 0 {name=p53105 lab=clkbuf_6_59_0_CLK/A }
C {devices/lab_pin.sym} 53260 -1830 0 1 {name=p53106 lab=clkbuf_6_58_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 53220 -1830 0 0 {name=Xclkbuf_6_58_0_CLK }
C {devices/lab_pin.sym} 53140 -1730 0 0 {name=p53107 lab=_49341_/Y }
C {devices/lab_pin.sym} 53140 -1690 0 0 {name=p53108 lab=_49326_/X }
C {devices/lab_pin.sym} 53140 -1650 0 0 {name=p53109 lab=_49342_/Y }
C {devices/lab_pin.sym} 53300 -1690 0 1 {name=p53110 lab=_49343_/Y }
C {sky130_stdcells/a21boi_4.sym} 53220 -1690 0 0 {name=X_49343_ }
C {devices/lab_pin.sym} 53160 -1560 0 0 {name=p53111 lab=_84873_/Q }
C {devices/lab_pin.sym} 53160 -1520 0 0 {name=p53112 lab=_61323_/B }
C {devices/lab_pin.sym} 53280 -1540 0 1 {name=p53113 lab=_61621_/X }
C {sky130_stdcells/or2_4.sym} 53220 -1540 0 0 {name=X_61621_ }
C {devices/lab_pin.sym} 53160 -1420 0 0 {name=p53114 lab=_73607_/A }
C {devices/lab_pin.sym} 53160 -1380 0 0 {name=p53115 lab=_65932_/B }
C {devices/lab_pin.sym} 53280 -1400 0 1 {name=p53116 lab=_73607_/X }
C {sky130_stdcells/and2_4.sym} 53220 -1400 0 0 {name=X_73607_ }
C {devices/lab_pin.sym} 53180 -1270 0 0 {name=p53117 lab=_70819_/A }
C {devices/lab_pin.sym} 53260 -1270 0 1 {name=p53118 lab=_70952_/B }
C {sky130_stdcells/buf_2.sym} 53220 -1270 0 0 {name=X_70819_ }
C {devices/lab_pin.sym} 53180 -1150 0 0 {name=p53119 lab=_54073_/B }
C {devices/lab_pin.sym} 53260 -1150 0 1 {name=p53120 lab=_50862_/B }
C {sky130_stdcells/buf_2.sym} 53220 -1150 0 0 {name=X_46555_ }
C {devices/lab_pin.sym} 53160 -1040 0 0 {name=p53121 lab=_81932_/Q }
C {devices/lab_pin.sym} 53160 -1000 0 0 {name=p53122 lab=_82188_/D }
C {devices/lab_pin.sym} 53280 -1020 0 1 {name=p53123 lab=_77375_/X }
C {sky130_stdcells/xor2_4.sym} 53220 -1020 0 0 {name=X_77375_ }
C {devices/lab_pin.sym} 53140 -930 0 0 {name=p53124 lab=_43005_/X }
C {devices/lab_pin.sym} 53140 -890 0 0 {name=p53125 lab=_43760_/X }
C {devices/lab_pin.sym} 53140 -850 0 0 {name=p53126 lab=_40977_/X }
C {devices/lab_pin.sym} 53140 -810 0 0 {name=p53127 lab=_87275_/Q }
C {devices/lab_pin.sym} 53140 -770 0 0 {name=p53128 lab=_43756_/X }
C {devices/lab_pin.sym} 53300 -850 0 1 {name=p53129 lab=_43767_/Y }
C {sky130_stdcells/o32ai_4.sym} 53220 -850 0 0 {name=X_43767_ }
C {devices/lab_pin.sym} 53160 -710 0 0 {name=p53130 lab=_74549_/A }
C {devices/lab_pin.sym} 53160 -670 0 0 {name=p53131 lab=_46228_/A }
C {devices/lab_pin.sym} 53160 -630 0 0 {name=p53132 lab=_45156_/A }
C {devices/lab_pin.sym} 53280 -670 0 1 {name=p53133 lab=_74587_/Y }
C {sky130_stdcells/nand3_4.sym} 53220 -670 0 0 {name=X_74587_ }
C {devices/lab_pin.sym} 54100 -42150 0 0 {name=p53134 lab=_40978_/Y }
C {devices/lab_pin.sym} 54180 -42150 0 1 {name=p53135 lab=_40979_/Y }
C {sky130_stdcells/inv_2.sym} 54140 -42150 0 0 {name=X_40979_ }
C {devices/lab_pin.sym} 54060 -42050 0 0 {name=p53136 lab=_58209_/Y }
C {devices/lab_pin.sym} 54060 -42010 0 0 {name=p53137 lab=_71783_/Y }
C {devices/lab_pin.sym} 54060 -41970 0 0 {name=p53138 lab=_71798_/Y }
C {devices/lab_pin.sym} 54220 -42010 0 1 {name=p53139 lab=_83371_/D }
C {sky130_stdcells/o21ai_4.sym} 54140 -42010 0 0 {name=X_71799_ }
C {devices/lab_pin.sym} 54080 -41880 0 0 {name=p53140 lab=_79114_/A }
C {devices/lab_pin.sym} 54080 -41840 0 0 {name=p53141 lab=_79113_/Y }
C {devices/lab_pin.sym} 54200 -41860 0 1 {name=p53142 lab=_79114_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -41860 0 0 {name=X_79114_ }
C {devices/lab_pin.sym} 54100 -41730 0 0 {name=p53143 lab=clkbuf_1_1_1_CLK/X }
C {devices/lab_pin.sym} 54180 -41730 0 1 {name=p53144 lab=clkbuf_2_3_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 54140 -41730 0 0 {name=Xclkbuf_1_1_2_CLK }
C {devices/lab_pin.sym} 54060 -41630 0 0 {name=p53145 lab=_45502_/X }
C {devices/lab_pin.sym} 54060 -41590 0 0 {name=p53146 lab=_45505_/X }
C {devices/lab_pin.sym} 54060 -41550 0 0 {name=p53147 lab=_45446_/X }
C {devices/lab_pin.sym} 54220 -41590 0 1 {name=p53148 lab=_45506_/X }
C {sky130_stdcells/a21o_4.sym} 54140 -41590 0 0 {name=X_45506_ }
C {devices/lab_pin.sym} 54060 -41470 0 0 {name=p53149 lab=_79775_/B }
C {devices/lab_pin.sym} 54060 -41430 0 0 {name=p53150 lab=_64314_/X }
C {devices/lab_pin.sym} 54060 -41390 0 0 {name=p53151 lab=_64339_/X }
C {devices/lab_pin.sym} 54220 -41430 0 1 {name=p53152 lab=_64340_/X }
C {sky130_stdcells/a21o_4.sym} 54140 -41430 0 0 {name=X_64340_ }
C {devices/lab_pin.sym} 54080 -41300 0 0 {name=p53153 lab=_81358_/Q }
C {devices/lab_pin.sym} 54080 -41260 0 0 {name=p53154 lab=_76326_/B }
C {devices/lab_pin.sym} 54200 -41280 0 1 {name=p53155 lab=_76326_/X }
C {sky130_stdcells/xor2_4.sym} 54140 -41280 0 0 {name=X_76326_ }
C {devices/lab_pin.sym} 54100 -41150 0 0 {name=p53156 lab=_42681_/A }
C {devices/lab_pin.sym} 54180 -41150 0 1 {name=p53157 lab=_42718_/X }
C {sky130_stdcells/buf_2.sym} 54140 -41150 0 0 {name=X_42718_ }
C {devices/lab_pin.sym} 54060 -41050 0 0 {name=p53158 lab=_49270_/Y }
C {devices/lab_pin.sym} 54060 -41010 0 0 {name=p53159 lab=_49271_/X }
C {devices/lab_pin.sym} 54060 -40970 0 0 {name=p53160 lab=_49273_/Y }
C {devices/lab_pin.sym} 54220 -41010 0 1 {name=p53161 lab=_49274_/Y }
C {sky130_stdcells/a21boi_4.sym} 54140 -41010 0 0 {name=X_49274_ }
C {devices/lab_pin.sym} 54080 -40900 0 0 {name=p53162 lab=_58442_/A }
C {devices/lab_pin.sym} 54080 -40860 0 0 {name=p53163 lab=_61563_/B }
C {devices/lab_pin.sym} 54080 -40820 0 0 {name=p53164 lab=_61563_/C }
C {devices/lab_pin.sym} 54080 -40780 0 0 {name=p53165 lab=_61514_/D }
C {devices/lab_pin.sym} 54200 -40840 0 1 {name=p53166 lab=_61553_/A }
C {sky130_stdcells/nand4_4.sym} 54140 -40840 0 0 {name=X_61552_ }
C {devices/lab_pin.sym} 54060 -40720 0 0 {name=p53167 lab=_72829_/A }
C {devices/lab_pin.sym} 54060 -40680 0 0 {name=p53168 lab=_85570_/Q }
C {devices/lab_pin.sym} 54060 -40640 0 0 {name=p53169 lab=_73472_/X }
C {devices/lab_pin.sym} 54060 -40600 0 0 {name=p53170 lab=_73537_/X }
C {devices/lab_pin.sym} 54220 -40660 0 1 {name=p53171 lab=_73538_/X }
C {sky130_stdcells/a211o_4.sym} 54140 -40660 0 0 {name=X_73538_ }
C {devices/lab_pin.sym} 54100 -40510 0 0 {name=p53172 lab=_46485_/X }
C {devices/lab_pin.sym} 54180 -40510 0 1 {name=p53173 lab=_46487_/B }
C {sky130_stdcells/buf_2.sym} 54140 -40510 0 0 {name=X_46486_ }
C {devices/lab_pin.sym} 54100 -40390 0 0 {name=p53174 lab=_47834_/A }
C {devices/lab_pin.sym} 54180 -40390 0 1 {name=p53175 lab=_43698_/X }
C {sky130_stdcells/buf_2.sym} 54140 -40390 0 0 {name=X_43698_ }
C {devices/lab_pin.sym} 54060 -40290 0 0 {name=p53176 lab=_66041_/B }
C {devices/lab_pin.sym} 54060 -40250 0 0 {name=p53177 lab=_48203_/X }
C {devices/lab_pin.sym} 54060 -40210 0 0 {name=p53178 lab=_48224_/Y }
C {devices/lab_pin.sym} 54220 -40250 0 1 {name=p53179 lab=_48225_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -40250 0 0 {name=X_48225_ }
C {devices/lab_pin.sym} 54100 -40110 0 0 {name=p53180 lab=_60502_/Y }
C {devices/lab_pin.sym} 54180 -40110 0 1 {name=p53181 lab=_60503_/X }
C {sky130_stdcells/buf_2.sym} 54140 -40110 0 0 {name=X_60503_ }
C {devices/lab_pin.sym} 54080 -40000 0 0 {name=p53182 lab=_79057_/A }
C {devices/lab_pin.sym} 54080 -39960 0 0 {name=p53183 lab=_79044_/Y }
C {devices/lab_pin.sym} 54200 -39980 0 1 {name=p53184 lab=_79045_/X }
C {sky130_stdcells/and2_4.sym} 54140 -39980 0 0 {name=X_79045_ }
C {devices/lab_pin.sym} 54060 -39870 0 0 {name=p53185 lab=_45428_/X }
C {devices/lab_pin.sym} 54060 -39830 0 0 {name=p53186 lab=_45432_/X }
C {devices/lab_pin.sym} 54060 -39790 0 0 {name=p53187 lab=_45436_/Y }
C {devices/lab_pin.sym} 54220 -39830 0 1 {name=p53188 lab=_45437_/Y }
C {sky130_stdcells/a21oi_4.sym} 54140 -39830 0 0 {name=X_45437_ }
C {devices/lab_pin.sym} 54060 -39710 0 0 {name=p53189 lab=_79837_/B }
C {devices/lab_pin.sym} 54060 -39670 0 0 {name=p53190 lab=_64255_/X }
C {devices/lab_pin.sym} 54060 -39630 0 0 {name=p53191 lab=_64270_/X }
C {devices/lab_pin.sym} 54220 -39670 0 1 {name=p53192 lab=_64271_/X }
C {sky130_stdcells/a21o_4.sym} 54140 -39670 0 0 {name=X_64271_ }
C {devices/lab_pin.sym} 54060 -39550 0 0 {name=p53193 lab=_76242_/Y }
C {devices/lab_pin.sym} 54060 -39510 0 0 {name=p53194 lab=_76236_/X }
C {devices/lab_pin.sym} 54060 -39470 0 0 {name=p53195 lab=_76237_/Y }
C {devices/lab_pin.sym} 54220 -39510 0 1 {name=p53196 lab=_76257_/Y }
C {sky130_stdcells/a21boi_4.sym} 54140 -39510 0 0 {name=X_76257_ }
C {devices/lab_pin.sym} 54060 -39410 0 0 {name=p53197 lab=_42647_/X }
C {devices/lab_pin.sym} 54060 -39370 0 0 {name=p53198 lab=_42648_/X }
C {devices/lab_pin.sym} 54060 -39330 0 0 {name=p53199 lab=_40977_/X }
C {devices/lab_pin.sym} 54060 -39290 0 0 {name=p53200 lab=_87787_/Q }
C {devices/lab_pin.sym} 54060 -39250 0 0 {name=p53201 lab=_42637_/X }
C {devices/lab_pin.sym} 54220 -39330 0 1 {name=p53202 lab=_42649_/Y }
C {sky130_stdcells/o32ai_4.sym} 54140 -39330 0 0 {name=X_42649_ }
C {devices/lab_pin.sym} 54080 -39200 0 0 {name=p53203 lab=_61483_/A }
C {devices/lab_pin.sym} 54080 -39160 0 0 {name=p53204 lab=_61468_/B }
C {devices/lab_pin.sym} 54080 -39120 0 0 {name=p53205 lab=_61467_/X }
C {devices/lab_pin.sym} 54080 -39080 0 0 {name=p53206 lab=_61451_/D }
C {devices/lab_pin.sym} 54200 -39140 0 1 {name=p53207 lab=_61483_/Y }
C {sky130_stdcells/nand4_4.sym} 54140 -39140 0 0 {name=X_61483_ }
C {devices/lab_pin.sym} 54060 -39010 0 0 {name=p53208 lab=_87043_/Q }
C {devices/lab_pin.sym} 54060 -38970 0 0 {name=p53209 lab=_56550_/X }
C {devices/lab_pin.sym} 54060 -38930 0 0 {name=p53210 lab=_73468_/X }
C {devices/lab_pin.sym} 54220 -38970 0 1 {name=p53211 lab=_73481_/C }
C {sky130_stdcells/o21ai_4.sym} 54140 -38970 0 0 {name=X_73469_ }
C {devices/lab_pin.sym} 54060 -38850 0 0 {name=p53212 lab=_66007_/X }
C {devices/lab_pin.sym} 54060 -38810 0 0 {name=p53213 lab=_66009_/X }
C {devices/lab_pin.sym} 54060 -38770 0 0 {name=p53214 lab=_65937_/X }
C {devices/lab_pin.sym} 54220 -38810 0 1 {name=p53215 lab=_66010_/X }
C {sky130_stdcells/a21o_4.sym} 54140 -38810 0 0 {name=X_66010_ }
C {devices/lab_pin.sym} 54060 -38690 0 0 {name=p53216 lab=_79321_/A }
C {devices/lab_pin.sym} 54060 -38650 0 0 {name=p53217 lab=_63189_/X }
C {devices/lab_pin.sym} 54060 -38610 0 0 {name=p53218 lab=_63221_/Y }
C {devices/lab_pin.sym} 54220 -38650 0 1 {name=p53219 lab=_63222_/X }
C {sky130_stdcells/a21o_4.sym} 54140 -38650 0 0 {name=X_63222_ }
C {devices/lab_pin.sym} 54080 -38520 0 0 {name=p53220 lab=_75205_/Y }
C {devices/lab_pin.sym} 54080 -38480 0 0 {name=p53221 lab=_75207_/Y }
C {devices/lab_pin.sym} 54200 -38500 0 1 {name=p53222 lab=_75217_/B }
C {sky130_stdcells/nand2_4.sym} 54140 -38500 0 0 {name=X_75208_ }
C {devices/lab_pin.sym} 54100 -38370 0 0 {name=p53223 lab=_60516_/B }
C {devices/lab_pin.sym} 54180 -38370 0 1 {name=p53224 lab=_60435_/C }
C {sky130_stdcells/buf_2.sym} 54140 -38370 0 0 {name=X_60434_ }
C {devices/lab_pin.sym} 54100 -38250 0 0 {name=p53225 lab=_48734_/A }
C {devices/lab_pin.sym} 54180 -38250 0 1 {name=p53226 lab=_48156_/X }
C {sky130_stdcells/buf_2.sym} 54140 -38250 0 0 {name=X_48156_ }
C {devices/lab_pin.sym} 54100 -38130 0 0 {name=p53227 lab=_56670_/A }
C {devices/lab_pin.sym} 54180 -38130 0 1 {name=p53228 lab=_45369_/A }
C {sky130_stdcells/buf_2.sym} 54140 -38130 0 0 {name=X_45368_ }
C {devices/lab_pin.sym} 54060 -38030 0 0 {name=p53229 lab=_76189_/A }
C {devices/lab_pin.sym} 54060 -37990 0 0 {name=p53230 lab=_76187_/Y }
C {devices/lab_pin.sym} 54060 -37950 0 0 {name=p53231 lab=_76189_/B }
C {devices/lab_pin.sym} 54220 -37990 0 1 {name=p53232 lab=_76188_/X }
C {sky130_stdcells/a21o_4.sym} 54140 -37990 0 0 {name=X_76188_ }
C {devices/lab_pin.sym} 54100 -37850 0 0 {name=p53233 lab=_83701_/Q }
C {devices/lab_pin.sym} 54180 -37850 0 1 {name=p53234 lab=_53373_/B }
C {sky130_stdcells/inv_2.sym} 54140 -37850 0 0 {name=X_47107_ }
C {devices/lab_pin.sym} 54060 -37760 0 0 {name=p53235 lab=_43951_/B }
C {devices/lab_pin.sym} 54060 -37720 0 0 {name=p53236 lab=_44316_/X }
C {devices/lab_pin.sym} 54060 -37680 0 0 {name=p53237 lab=_44313_/A }
C {devices/lab_pin.sym} 54060 -37640 0 0 {name=p53238 lab=_44218_/X }
C {devices/lab_pin.sym} 54220 -37700 0 1 {name=p53239 lab=_44320_/A }
C {sky130_stdcells/o22a_4.sym} 54140 -37700 0 0 {name=X_44319_ }
C {devices/lab_pin.sym} 54060 -37590 0 0 {name=p53240 lab=_58554_/A }
C {devices/lab_pin.sym} 54060 -37550 0 0 {name=p53241 lab=_63131_/X }
C {devices/lab_pin.sym} 54060 -37510 0 0 {name=p53242 lab=_63117_/X }
C {devices/lab_pin.sym} 54060 -37470 0 0 {name=p53243 lab=_58331_/A }
C {devices/lab_pin.sym} 54060 -37430 0 0 {name=p53244 lab=_63118_/X }
C {devices/lab_pin.sym} 54220 -37510 0 1 {name=p53245 lab=_63153_/Y }
C {sky130_stdcells/o32ai_4.sym} 54140 -37510 0 0 {name=X_63153_ }
C {devices/lab_pin.sym} 54100 -37350 0 0 {name=p53246 lab=_75138_/Y }
C {devices/lab_pin.sym} 54180 -37350 0 1 {name=p53247 lab=_75142_/A }
C {sky130_stdcells/inv_2.sym} 54140 -37350 0 0 {name=X_75139_ }
C {devices/lab_pin.sym} 54060 -37250 0 0 {name=p53248 lab=_48075_/X }
C {devices/lab_pin.sym} 54060 -37210 0 0 {name=p53249 lab=_46528_/A }
C {devices/lab_pin.sym} 54060 -37170 0 0 {name=p53250 lab=_48086_/X }
C {devices/lab_pin.sym} 54220 -37210 0 1 {name=p53251 lab=_48088_/B }
C {sky130_stdcells/o21ai_4.sym} 54140 -37210 0 0 {name=X_48087_ }
C {devices/lab_pin.sym} 54080 -37090 0 0 {name=p53252 lab=_60477_/A }
C {devices/lab_pin.sym} 54080 -37050 0 0 {name=p53253 lab=_60519_/B }
C {devices/lab_pin.sym} 54080 -37010 0 0 {name=p53254 lab=_79581_/A }
C {devices/lab_pin.sym} 54200 -37050 0 1 {name=p53255 lab=_60365_/Y }
C {sky130_stdcells/nor3_4.sym} 54140 -37050 0 0 {name=X_60365_ }
C {devices/lab_pin.sym} 54060 -36930 0 0 {name=p53256 lab=_85255_/Q }
C {devices/lab_pin.sym} 54060 -36890 0 0 {name=p53257 lab=_45297_/X }
C {devices/lab_pin.sym} 54060 -36850 0 0 {name=p53258 lab=_45298_/X }
C {devices/lab_pin.sym} 54220 -36890 0 1 {name=p53259 lab=_45299_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -36890 0 0 {name=X_45299_ }
C {devices/lab_pin.sym} 54100 -36750 0 0 {name=p53260 lab=clkbuf_9_252_0_CLK/X }
C {devices/lab_pin.sym} 54180 -36750 0 1 {name=p53261 lab=_83681_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 54140 -36750 0 0 {name=Xclkbuf_10_505_0_CLK }
C {devices/lab_pin.sym} 54080 -36660 0 0 {name=p53262 lab=_62037_/X }
C {devices/lab_pin.sym} 54080 -36620 0 0 {name=p53263 lab=_62021_/B }
C {devices/lab_pin.sym} 54080 -36580 0 0 {name=p53264 lab=_63655_/B }
C {devices/lab_pin.sym} 54080 -36540 0 0 {name=p53265 lab=_62020_/X }
C {devices/lab_pin.sym} 54200 -36600 0 1 {name=p53266 lab=_62104_/X }
C {sky130_stdcells/and4_4.sym} 54140 -36600 0 0 {name=X_62104_ }
C {devices/lab_pin.sym} 54100 -36450 0 0 {name=p53267 lab=_54509_/D }
C {devices/lab_pin.sym} 54180 -36450 0 1 {name=p53268 lab=_52818_/D }
C {sky130_stdcells/buf_2.sym} 54140 -36450 0 0 {name=X_47038_ }
C {devices/lab_pin.sym} 54060 -36370 0 0 {name=p53269 lab=_58429_/Y }
C {devices/lab_pin.sym} 54060 -36330 0 0 {name=p53270 lab=_63073_/X }
C {devices/lab_pin.sym} 54060 -36290 0 0 {name=p53271 lab=_63059_/X }
C {devices/lab_pin.sym} 54060 -36250 0 0 {name=p53272 lab=_59474_/A }
C {devices/lab_pin.sym} 54060 -36210 0 0 {name=p53273 lab=_63060_/X }
C {devices/lab_pin.sym} 54220 -36290 0 1 {name=p53274 lab=_63084_/Y }
C {sky130_stdcells/o32ai_4.sym} 54140 -36290 0 0 {name=X_63084_ }
C {devices/lab_pin.sym} 54080 -36140 0 0 {name=p53275 lab=_67961_/A }
C {devices/lab_pin.sym} 54080 -36100 0 0 {name=p53276 lab=_67960_/X }
C {devices/lab_pin.sym} 54200 -36120 0 1 {name=p53277 lab=_67961_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -36120 0 0 {name=X_67961_ }
C {devices/lab_pin.sym} 54080 -36000 0 0 {name=p53278 lab=_79944_/Y }
C {devices/lab_pin.sym} 54080 -35960 0 0 {name=p53279 lab=_79946_/Y }
C {devices/lab_pin.sym} 54200 -35980 0 1 {name=p53280 lab=_79947_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -35980 0 0 {name=X_79947_ }
C {devices/lab_pin.sym} 54100 -35850 0 0 {name=p53281 lab=_60267_/A }
C {devices/lab_pin.sym} 54180 -35850 0 1 {name=p53282 lab=_60296_/X }
C {sky130_stdcells/buf_2.sym} 54140 -35850 0 0 {name=X_60296_ }
C {devices/lab_pin.sym} 54080 -35740 0 0 {name=p53283 lab=_69908_/A }
C {devices/lab_pin.sym} 54080 -35700 0 0 {name=p53284 lab=_69700_/B }
C {devices/lab_pin.sym} 54200 -35720 0 1 {name=p53285 lab=_69700_/Y }
C {sky130_stdcells/nor2_4.sym} 54140 -35720 0 0 {name=X_69700_ }
C {devices/lab_pin.sym} 54080 -35600 0 0 {name=p53286 lab=_66912_/A }
C {devices/lab_pin.sym} 54080 -35560 0 0 {name=p53287 lab=_87621_/Q }
C {devices/lab_pin.sym} 54200 -35580 0 1 {name=p53288 lab=_66912_/X }
C {sky130_stdcells/and2_4.sym} 54140 -35580 0 0 {name=X_66912_ }
C {devices/lab_pin.sym} 54060 -35470 0 0 {name=p53289 lab=_62031_/Y }
C {devices/lab_pin.sym} 54060 -35430 0 0 {name=p53290 lab=_62033_/X }
C {devices/lab_pin.sym} 54060 -35390 0 0 {name=p53291 lab=_62034_/Y }
C {devices/lab_pin.sym} 54220 -35430 0 1 {name=p53292 lab=_62035_/Y }
C {sky130_stdcells/a21oi_4.sym} 54140 -35430 0 0 {name=X_62035_ }
C {devices/lab_pin.sym} 54060 -35320 0 0 {name=p53293 lab=_87452_/Q }
C {devices/lab_pin.sym} 54060 -35280 0 0 {name=p53294 lab=_67868_/X }
C {devices/lab_pin.sym} 54060 -35240 0 0 {name=p53295 lab=_67821_/X }
C {devices/lab_pin.sym} 54060 -35200 0 0 {name=p53296 lab=_67891_/X }
C {devices/lab_pin.sym} 54220 -35260 0 1 {name=p53297 lab=_67892_/X }
C {sky130_stdcells/a211o_4.sym} 54140 -35260 0 0 {name=X_67892_ }
C {devices/lab_pin.sym} 54060 -35130 0 0 {name=p53298 lab=_79875_/Y }
C {devices/lab_pin.sym} 54060 -35090 0 0 {name=p53299 lab=_79858_/Y }
C {devices/lab_pin.sym} 54060 -35050 0 0 {name=p53300 lab=_79877_/X }
C {devices/lab_pin.sym} 54220 -35090 0 1 {name=p53301 lab=_79878_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -35090 0 0 {name=X_79878_ }
C {devices/lab_pin.sym} 54060 -34970 0 0 {name=p53302 lab=_81981_/D }
C {devices/lab_pin.sym} 54060 -34930 0 0 {name=p53303 lab=_69564_/X }
C {devices/lab_pin.sym} 54060 -34890 0 0 {name=p53304 lab=_69630_/X }
C {devices/lab_pin.sym} 54220 -34930 0 1 {name=p53305 lab=_83909_/D }
C {sky130_stdcells/a21bo_4.sym} 54140 -34930 0 0 {name=X_69631_ }
C {devices/lab_pin.sym} 54100 -34790 0 0 {name=p53306 lab=_66606_/A }
C {devices/lab_pin.sym} 54180 -34790 0 1 {name=p53307 lab=_66843_/X }
C {sky130_stdcells/buf_2.sym} 54140 -34790 0 0 {name=X_66843_ }
C {devices/lab_pin.sym} 54080 -34680 0 0 {name=p53308 lab=_78829_/A }
