C {devices/lab_pin.sym} 27380 -30810 0 0 {name=p26792 lab=_69299_/X }
C {devices/lab_pin.sym} 27380 -30770 0 0 {name=p26793 lab=_69352_/X }
C {devices/lab_pin.sym} 27540 -30810 0 1 {name=p26794 lab=_69353_/X }
C {sky130_stdcells/a21bo_4.sym} 27460 -30810 0 0 {name=X_69353_ }
C {devices/lab_pin.sym} 27420 -30670 0 0 {name=p26795 lab=_66565_/A }
C {devices/lab_pin.sym} 27500 -30670 0 1 {name=p26796 lab=_69178_/A }
C {sky130_stdcells/buf_2.sym} 27460 -30670 0 0 {name=X_66565_ }
C {devices/lab_pin.sym} 27400 -30560 0 0 {name=p26797 lab=_51796_/A }
C {devices/lab_pin.sym} 27400 -30520 0 0 {name=p26798 lab=_51791_/B }
C {devices/lab_pin.sym} 27520 -30540 0 1 {name=p26799 lab=_51791_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -30540 0 0 {name=X_51791_ }
C {devices/lab_pin.sym} 27400 -30440 0 0 {name=p26800 lab=_61354_/B }
C {devices/lab_pin.sym} 27400 -30400 0 0 {name=p26801 lab=_64192_/B }
C {devices/lab_pin.sym} 27400 -30360 0 0 {name=p26802 lab=_63757_/C }
C {devices/lab_pin.sym} 27400 -30320 0 0 {name=p26803 lab=_63776_/X }
C {devices/lab_pin.sym} 27520 -30380 0 1 {name=p26804 lab=_63777_/Y }
C {sky130_stdcells/nand4_4.sym} 27460 -30380 0 0 {name=X_63777_ }
C {devices/lab_pin.sym} 27420 -30230 0 0 {name=p26805 lab=clkbuf_9_447_0_CLK/X }
C {devices/lab_pin.sym} 27500 -30230 0 1 {name=p26806 lab=_85535_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 27460 -30230 0 0 {name=Xclkbuf_10_895_0_CLK }
C {devices/lab_pin.sym} 27380 -30130 0 0 {name=p26807 lab=_60950_/Y }
C {devices/lab_pin.sym} 27380 -30090 0 0 {name=p26808 lab=_60993_/B }
C {devices/lab_pin.sym} 27380 -30050 0 0 {name=p26809 lab=_60988_/Y }
C {devices/lab_pin.sym} 27540 -30090 0 1 {name=p26810 lab=_60989_/X }
C {sky130_stdcells/a21o_4.sym} 27460 -30090 0 0 {name=X_60989_ }
C {devices/lab_pin.sym} 27380 -29970 0 0 {name=p26811 lab=_83988_/Q }
C {devices/lab_pin.sym} 27380 -29930 0 0 {name=p26812 lab=_68299_/X }
C {devices/lab_pin.sym} 27380 -29890 0 0 {name=p26813 lab=_68303_/X }
C {devices/lab_pin.sym} 27540 -29930 0 1 {name=p26814 lab=_83988_/D }
C {sky130_stdcells/a21bo_4.sym} 27460 -29930 0 0 {name=X_68304_ }
C {devices/lab_pin.sym} 27420 -29790 0 0 {name=p26815 lab=_65516_/A }
C {devices/lab_pin.sym} 27500 -29790 0 1 {name=p26816 lab=_65516_/X }
C {sky130_stdcells/buf_2.sym} 27460 -29790 0 0 {name=X_65516_ }
C {devices/lab_pin.sym} 27380 -29690 0 0 {name=p26817 lab=_53528_/Y }
C {devices/lab_pin.sym} 27380 -29650 0 0 {name=p26818 lab=_53524_/X }
C {devices/lab_pin.sym} 27380 -29610 0 0 {name=p26819 lab=_53529_/Y }
C {devices/lab_pin.sym} 27540 -29650 0 1 {name=p26820 lab=_53530_/Y }
C {sky130_stdcells/a21boi_4.sym} 27460 -29650 0 0 {name=X_53530_ }
C {devices/lab_pin.sym} 27420 -29510 0 0 {name=p26821 lab=clkbuf_9_23_0_CLK/X }
C {devices/lab_pin.sym} 27500 -29510 0 1 {name=p26822 lab=_83191_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 27460 -29510 0 0 {name=Xclkbuf_10_47_0_CLK }
C {devices/lab_pin.sym} 27370 -29390 0 0 {name=p26823 lab=_84350_/CLK }
C {devices/lab_pin.sym} 27370 -29370 0 0 {name=p26824 lab=_63141_/X }
C {devices/lab_pin.sym} 27550 -29390 0 1 {name=p26825 lab=_79394_/A }
C {sky130_stdcells/dfxtp_4.sym} 27460 -29380 0 0 {name=X_84350_ }
C {devices/lab_pin.sym} 27420 -29250 0 0 {name=p26826 lab=_50742_/A }
C {devices/lab_pin.sym} 27500 -29250 0 1 {name=p26827 lab=_50742_/X }
C {sky130_stdcells/buf_2.sym} 27460 -29250 0 0 {name=X_50742_ }
C {devices/lab_pin.sym} 27420 -29130 0 0 {name=p26828 lab=_60274_/X }
C {devices/lab_pin.sym} 27500 -29130 0 1 {name=p26829 lab=_62729_/D }
C {sky130_stdcells/buf_2.sym} 27460 -29130 0 0 {name=X_62728_ }
C {devices/lab_pin.sym} 27370 -29010 0 0 {name=p26830 lab=_84064_/CLK }
C {devices/lab_pin.sym} 27370 -28990 0 0 {name=p26831 lab=_81562_/D }
C {devices/lab_pin.sym} 27550 -29010 0 1 {name=p26832 lab=_81518_/D }
C {sky130_stdcells/dfxtp_4.sym} 27460 -29000 0 0 {name=X_81562_ }
C {devices/lab_pin.sym} 27380 -28890 0 0 {name=p26833 lab=_83935_/Q }
C {devices/lab_pin.sym} 27380 -28850 0 0 {name=p26834 lab=_69230_/X }
C {devices/lab_pin.sym} 27380 -28810 0 0 {name=p26835 lab=_69283_/X }
C {devices/lab_pin.sym} 27540 -28850 0 1 {name=p26836 lab=_69284_/X }
C {sky130_stdcells/a21bo_4.sym} 27460 -28850 0 0 {name=X_69284_ }
C {devices/lab_pin.sym} 27380 -28730 0 0 {name=p26837 lab=_66494_/Y }
C {devices/lab_pin.sym} 27380 -28690 0 0 {name=p26838 lab=_66483_/X }
C {devices/lab_pin.sym} 27380 -28650 0 0 {name=p26839 lab=_66495_/X }
C {devices/lab_pin.sym} 27540 -28690 0 1 {name=p26840 lab=_84112_/D }
C {sky130_stdcells/a21o_4.sym} 27460 -28690 0 0 {name=X_66496_ }
C {devices/lab_pin.sym} 27420 -28550 0 0 {name=p26841 lab=clkbuf_9_387_0_CLK/A }
C {devices/lab_pin.sym} 27500 -28550 0 1 {name=p26842 lab=clkbuf_9_386_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 27460 -28550 0 0 {name=Xclkbuf_9_386_0_CLK }
C {devices/lab_pin.sym} 27370 -28430 0 0 {name=p26843 lab=_85555_/CLK }
C {devices/lab_pin.sym} 27370 -28410 0 0 {name=p26844 lab=_72021_/Y }
C {devices/lab_pin.sym} 27550 -28430 0 1 {name=p26845 lab=_83301_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -28420 0 0 {name=X_83301_ }
C {devices/lab_pin.sym} 27400 -28300 0 0 {name=p26846 lab=_80513_/A }
C {devices/lab_pin.sym} 27400 -28260 0 0 {name=p26847 lab=_80512_/Y }
C {devices/lab_pin.sym} 27520 -28280 0 1 {name=p26848 lab=_82262_/D }
C {sky130_stdcells/xor2_4.sym} 27460 -28280 0 0 {name=X_80513_ }
C {devices/lab_pin.sym} 27380 -28170 0 0 {name=p26849 lab=_67465_/X }
C {devices/lab_pin.sym} 27380 -28130 0 0 {name=p26850 lab=_67469_/X }
C {devices/lab_pin.sym} 27380 -28090 0 0 {name=p26851 lab=_68216_/X }
C {devices/lab_pin.sym} 27540 -28130 0 1 {name=p26852 lab=_68235_/Y }
C {sky130_stdcells/a21oi_4.sym} 27460 -28130 0 0 {name=X_68235_ }
C {devices/lab_pin.sym} 27380 -28010 0 0 {name=p26853 lab=_85631_/Q }
C {devices/lab_pin.sym} 27380 -27970 0 0 {name=p26854 lab=_53449_/X }
C {devices/lab_pin.sym} 27380 -27930 0 0 {name=p26855 lab=_53460_/Y }
C {devices/lab_pin.sym} 27540 -27970 0 1 {name=p26856 lab=_53461_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -27970 0 0 {name=X_53461_ }
C {devices/lab_pin.sym} 27400 -27840 0 0 {name=p26857 lab=_65447_/A }
C {devices/lab_pin.sym} 27400 -27800 0 0 {name=p26858 lab=_65446_/Y }
C {devices/lab_pin.sym} 27520 -27820 0 1 {name=p26859 lab=_65447_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -27820 0 0 {name=X_65447_ }
C {devices/lab_pin.sym} 27370 -27690 0 0 {name=p26860 lab=_84668_/CLK }
C {devices/lab_pin.sym} 27370 -27670 0 0 {name=p26861 lab=_64010_/Y }
C {devices/lab_pin.sym} 27550 -27690 0 1 {name=p26862 lab=_80082_/B }
C {sky130_stdcells/dfxtp_4.sym} 27460 -27680 0 0 {name=X_84281_ }
C {devices/lab_pin.sym} 27380 -27570 0 0 {name=p26863 lab=_50671_/Y }
C {devices/lab_pin.sym} 27380 -27530 0 0 {name=p26864 lab=_50609_/X }
C {devices/lab_pin.sym} 27380 -27490 0 0 {name=p26865 lab=_50672_/X }
C {devices/lab_pin.sym} 27540 -27530 0 1 {name=p26866 lab=_50673_/Y }
C {sky130_stdcells/a21oi_4.sym} 27460 -27530 0 0 {name=X_50673_ }
C {devices/lab_pin.sym} 27380 -27430 0 0 {name=p26867 lab=_58221_/X }
C {devices/lab_pin.sym} 27380 -27390 0 0 {name=p26868 lab=_60221_/A }
C {devices/lab_pin.sym} 27380 -27350 0 0 {name=p26869 lab=_60205_/X }
C {devices/lab_pin.sym} 27380 -27310 0 0 {name=p26870 lab=_60263_/C }
C {devices/lab_pin.sym} 27380 -27280 0 0 {name=p26871 lab=_62658_/X }
C {devices/lab_pin.sym} 27540 -27350 0 1 {name=p26872 lab=_62659_/Y }
C {sky130_stdcells/a41oi_4.sym} 27460 -27350 0 0 {name=X_62659_ }
C {devices/lab_pin.sym} 27370 -27190 0 0 {name=p26873 lab=_81492_/CLK }
C {devices/lab_pin.sym} 27370 -27170 0 0 {name=p26874 lab=_84061_/Q }
C {devices/lab_pin.sym} 27550 -27190 0 1 {name=p26875 lab=_81493_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -27180 0 0 {name=X_81493_ }
C {devices/lab_pin.sym} 27400 -27070 0 0 {name=p26876 lab=_55196_/A }
C {devices/lab_pin.sym} 27400 -27030 0 0 {name=p26877 lab=_83748_/Q }
C {devices/lab_pin.sym} 27400 -26990 0 0 {name=p26878 lab=_55200_/C }
C {devices/lab_pin.sym} 27520 -27030 0 1 {name=p26879 lab=_55201_/C }
C {sky130_stdcells/nand3_4.sym} 27460 -27030 0 0 {name=X_55200_ }
C {devices/lab_pin.sym} 27370 -26890 0 0 {name=p26880 lab=_86118_/CLK }
C {devices/lab_pin.sym} 27370 -26870 0 0 {name=p26881 lab=_86020_/D }
C {devices/lab_pin.sym} 27550 -26890 0 1 {name=p26882 lab=_86020_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -26880 0 0 {name=X_86020_ }
C {devices/lab_pin.sym} 27380 -26770 0 0 {name=p26883 lab=_52410_/Y }
C {devices/lab_pin.sym} 27380 -26730 0 0 {name=p26884 lab=_52390_/X }
C {devices/lab_pin.sym} 27380 -26690 0 0 {name=p26885 lab=_52411_/X }
C {devices/lab_pin.sym} 27540 -26730 0 1 {name=p26886 lab=_52412_/Y }
C {sky130_stdcells/a21oi_4.sym} 27460 -26730 0 0 {name=X_52412_ }
C {devices/lab_pin.sym} 27370 -26590 0 0 {name=p26887 lab=_83229_/CLK }
C {devices/lab_pin.sym} 27370 -26570 0 0 {name=p26888 lab=_72568_/Y }
C {devices/lab_pin.sym} 27550 -26590 0 1 {name=p26889 lab=_79414_/B }
C {sky130_stdcells/dfxtp_4.sym} 27460 -26580 0 0 {name=X_83232_ }
C {devices/lab_pin.sym} 27400 -26460 0 0 {name=p26890 lab=_80458_/A }
C {devices/lab_pin.sym} 27400 -26420 0 0 {name=p26891 lab=_80458_/B }
C {devices/lab_pin.sym} 27520 -26440 0 1 {name=p26892 lab=_80467_/A }
C {sky130_stdcells/xor2_4.sym} 27460 -26440 0 0 {name=X_80444_ }
C {devices/lab_pin.sym} 27420 -26310 0 0 {name=p26893 lab=_73378_/A }
C {devices/lab_pin.sym} 27500 -26310 0 1 {name=p26894 lab=_73163_/A }
C {sky130_stdcells/buf_2.sym} 27460 -26310 0 0 {name=X_56180_ }
C {devices/lab_pin.sym} 27380 -26210 0 0 {name=p26895 lab=_82062_/D }
C {devices/lab_pin.sym} 27380 -26170 0 0 {name=p26896 lab=_68160_/X }
C {devices/lab_pin.sym} 27380 -26130 0 0 {name=p26897 lab=_68165_/X }
C {devices/lab_pin.sym} 27540 -26170 0 1 {name=p26898 lab=_68166_/X }
C {sky130_stdcells/a21bo_4.sym} 27460 -26170 0 0 {name=X_68166_ }
C {devices/lab_pin.sym} 27420 -26030 0 0 {name=p26899 lab=_53311_/A }
C {devices/lab_pin.sym} 27500 -26030 0 1 {name=p26900 lab=_53397_/A }
C {sky130_stdcells/buf_2.sym} 27460 -26030 0 0 {name=X_53392_ }
C {devices/lab_pin.sym} 27380 -25940 0 0 {name=p26901 lab=_44149_/X }
C {devices/lab_pin.sym} 27380 -25900 0 0 {name=p26902 lab=_85507_/Q }
C {devices/lab_pin.sym} 27380 -25860 0 0 {name=p26903 lab=_64571_/X }
C {devices/lab_pin.sym} 27380 -25820 0 0 {name=p26904 lab=_65377_/X }
C {devices/lab_pin.sym} 27540 -25880 0 1 {name=p26905 lab=_65378_/X }
C {sky130_stdcells/a211o_4.sym} 27460 -25880 0 0 {name=X_65378_ }
C {devices/lab_pin.sym} 27400 -25740 0 0 {name=p26906 lab=_55135_/A }
C {devices/lab_pin.sym} 27400 -25700 0 0 {name=p26907 lab=_85003_/Q }
C {devices/lab_pin.sym} 27520 -25720 0 1 {name=p26908 lab=_55131_/X }
C {sky130_stdcells/and2_4.sym} 27460 -25720 0 0 {name=X_55131_ }
C {devices/lab_pin.sym} 27420 -25590 0 0 {name=p26909 lab=_66758_/X }
C {devices/lab_pin.sym} 27500 -25590 0 1 {name=p26910 lab=_67117_/X }
C {sky130_stdcells/buf_2.sym} 27460 -25590 0 0 {name=X_67117_ }
C {devices/lab_pin.sym} 27400 -25480 0 0 {name=p26911 lab=_52334_/A }
C {devices/lab_pin.sym} 27400 -25440 0 0 {name=p26912 lab=_50133_/B }
C {devices/lab_pin.sym} 27520 -25460 0 1 {name=p26913 lab=_52343_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -25460 0 0 {name=X_52343_ }
C {devices/lab_pin.sym} 27380 -25350 0 0 {name=p26914 lab=_64316_/Y }
C {devices/lab_pin.sym} 27380 -25310 0 0 {name=p26915 lab=_64327_/X }
C {devices/lab_pin.sym} 27380 -25270 0 0 {name=p26916 lab=_64328_/X }
C {devices/lab_pin.sym} 27540 -25310 0 1 {name=p26917 lab=_64329_/X }
C {sky130_stdcells/o21a_4.sym} 27460 -25310 0 0 {name=X_64329_ }
C {devices/lab_pin.sym} 27370 -25170 0 0 {name=p26918 lab=_86570_/CLK }
C {devices/lab_pin.sym} 27370 -25150 0 0 {name=p26919 lab=_73145_/X }
C {devices/lab_pin.sym} 27550 -25170 0 1 {name=p26920 lab=_83163_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -25160 0 0 {name=X_83163_ }
C {devices/lab_pin.sym} 27400 -25040 0 0 {name=p26921 lab=_80375_/A }
C {devices/lab_pin.sym} 27400 -25000 0 0 {name=p26922 lab=_80375_/B }
C {devices/lab_pin.sym} 27520 -25020 0 1 {name=p26923 lab=_80375_/X }
C {sky130_stdcells/xor2_4.sym} 27460 -25020 0 0 {name=X_80375_ }
C {devices/lab_pin.sym} 27420 -24890 0 0 {name=p26924 lab=_68097_/A }
C {devices/lab_pin.sym} 27500 -24890 0 1 {name=p26925 lab=_68097_/X }
C {sky130_stdcells/buf_2.sym} 27460 -24890 0 0 {name=X_68097_ }
C {devices/lab_pin.sym} 27420 -24770 0 0 {name=p26926 lab=clkbuf_8_209_0_CLK/A }
C {devices/lab_pin.sym} 27500 -24770 0 1 {name=p26927 lab=clkbuf_8_208_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 27460 -24770 0 0 {name=Xclkbuf_8_208_0_CLK }
C {devices/lab_pin.sym} 27420 -24650 0 0 {name=p26928 lab=clkbuf_9_101_0_CLK/X }
C {devices/lab_pin.sym} 27500 -24650 0 1 {name=p26929 lab=_81117_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 27460 -24650 0 0 {name=Xclkbuf_10_203_0_CLK }
C {devices/lab_pin.sym} 27370 -24530 0 0 {name=p26930 lab=_82145_/CLK }
C {devices/lab_pin.sym} 27370 -24510 0 0 {name=p26931 lab=_77728_/X }
C {devices/lab_pin.sym} 27550 -24530 0 1 {name=p26932 lab=_82114_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -24520 0 0 {name=X_82114_ }
C {devices/lab_pin.sym} 27380 -24410 0 0 {name=p26933 lab=_55060_/Y }
C {devices/lab_pin.sym} 27380 -24370 0 0 {name=p26934 lab=_55050_/X }
C {devices/lab_pin.sym} 27380 -24330 0 0 {name=p26935 lab=_55061_/X }
C {devices/lab_pin.sym} 27540 -24370 0 1 {name=p26936 lab=_85326_/D }
C {sky130_stdcells/a21oi_4.sym} 27460 -24370 0 0 {name=X_55062_ }
C {devices/lab_pin.sym} 27380 -24260 0 0 {name=p26937 lab=_87935_/Q }
C {devices/lab_pin.sym} 27380 -24220 0 0 {name=p26938 lab=_66994_/X }
C {devices/lab_pin.sym} 27380 -24180 0 0 {name=p26939 lab=_67046_/X }
C {devices/lab_pin.sym} 27380 -24140 0 0 {name=p26940 lab=_67047_/X }
C {devices/lab_pin.sym} 27540 -24200 0 1 {name=p26941 lab=_67048_/X }
C {sky130_stdcells/a211o_4.sym} 27460 -24200 0 0 {name=X_67048_ }
C {devices/lab_pin.sym} 27420 -24050 0 0 {name=p26942 lab=_52274_/A }
C {devices/lab_pin.sym} 27500 -24050 0 1 {name=p26943 lab=_52295_/A }
C {sky130_stdcells/buf_2.sym} 27460 -24050 0 0 {name=X_52274_ }
C {devices/lab_pin.sym} 27370 -23930 0 0 {name=p26944 lab=_87720_/CLK }
C {devices/lab_pin.sym} 27370 -23910 0 0 {name=p26945 lab=_87971_/D }
C {devices/lab_pin.sym} 27550 -23930 0 1 {name=p26946 lab=_87971_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -23920 0 0 {name=X_87971_ }
C {devices/lab_pin.sym} 27370 -23790 0 0 {name=p26947 lab=_83846_/CLK }
C {devices/lab_pin.sym} 27370 -23770 0 0 {name=p26948 lab=_74335_/X }
C {devices/lab_pin.sym} 27550 -23790 0 1 {name=p26949 lab=_70321_/C }
C {sky130_stdcells/dfxtp_4.sym} 27460 -23780 0 0 {name=X_83094_ }
C {devices/lab_pin.sym} 27420 -23650 0 0 {name=p26950 lab=clkbuf_9_416_0_CLK/X }
C {devices/lab_pin.sym} 27500 -23650 0 1 {name=p26951 lab=_85315_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 27460 -23650 0 0 {name=Xclkbuf_10_833_0_CLK }
C {devices/lab_pin.sym} 27400 -23540 0 0 {name=p26952 lab=_53942_/A }
C {devices/lab_pin.sym} 27400 -23500 0 0 {name=p26953 lab=_52494_/B }
C {devices/lab_pin.sym} 27520 -23520 0 1 {name=p26954 lab=_54013_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -23520 0 0 {name=X_54013_ }
C {devices/lab_pin.sym} 27400 -23420 0 0 {name=p26955 lab=_51220_/A }
C {devices/lab_pin.sym} 27400 -23380 0 0 {name=p26956 lab=_51203_/B }
C {devices/lab_pin.sym} 27400 -23340 0 0 {name=p26957 lab=_51225_/C }
C {devices/lab_pin.sym} 27400 -23300 0 0 {name=p26958 lab=_51225_/D }
C {devices/lab_pin.sym} 27520 -23360 0 1 {name=p26959 lab=_51225_/X }
C {sky130_stdcells/and4_4.sym} 27460 -23360 0 0 {name=X_51225_ }
C {devices/lab_pin.sym} 27370 -23210 0 0 {name=p26960 lab=_87652_/CLK }
C {devices/lab_pin.sym} 27370 -23190 0 0 {name=p26961 lab=_86922_/D }
C {devices/lab_pin.sym} 27550 -23210 0 1 {name=p26962 lab=_67836_/B }
C {sky130_stdcells/dfxtp_4.sym} 27460 -23200 0 0 {name=X_86922_ }
C {devices/lab_pin.sym} 27370 -23070 0 0 {name=p26963 lab=_82047_/CLK }
C {devices/lab_pin.sym} 27370 -23050 0 0 {name=p26964 lab=_77981_/Y }
C {devices/lab_pin.sym} 27550 -23070 0 1 {name=p26965 lab=_82013_/D }
C {sky130_stdcells/dfxtp_4.sym} 27460 -23060 0 0 {name=X_82045_ }
C {devices/lab_pin.sym} 27400 -22950 0 0 {name=p26966 lab=_59873_/A }
C {devices/lab_pin.sym} 27400 -22910 0 0 {name=p26967 lab=_59855_/B }
C {devices/lab_pin.sym} 27400 -22870 0 0 {name=p26968 lab=_80277_/B }
C {devices/lab_pin.sym} 27520 -22910 0 1 {name=p26969 lab=_59870_/Y }
C {sky130_stdcells/nor3_4.sym} 27460 -22910 0 0 {name=X_59870_ }
C {devices/lab_pin.sym} 27420 -22770 0 0 {name=p26970 lab=clkbuf_9_325_0_CLK/A }
C {devices/lab_pin.sym} 27500 -22770 0 1 {name=p26971 lab=clkbuf_9_324_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 27460 -22770 0 0 {name=Xclkbuf_9_324_0_CLK }
C {devices/lab_pin.sym} 27380 -22670 0 0 {name=p26972 lab=_58730_/X }
C {devices/lab_pin.sym} 27380 -22630 0 0 {name=p26973 lab=_85933_/Q }
C {devices/lab_pin.sym} 27380 -22590 0 0 {name=p26974 lab=_58810_/X }
C {devices/lab_pin.sym} 27540 -22630 0 1 {name=p26975 lab=_58821_/X }
C {sky130_stdcells/o21a_4.sym} 27460 -22630 0 0 {name=X_58821_ }
C {devices/lab_pin.sym} 27420 -22490 0 0 {name=p26976 lab=_51128_/A }
C {devices/lab_pin.sym} 27500 -22490 0 1 {name=p26977 lab=_51156_/X }
C {sky130_stdcells/buf_2.sym} 27460 -22490 0 0 {name=X_51156_ }
C {devices/lab_pin.sym} 27370 -22370 0 0 {name=p26978 lab=_86855_/CLK }
C {devices/lab_pin.sym} 27370 -22350 0 0 {name=p26979 lab=_45807_/Y }
C {devices/lab_pin.sym} 27550 -22370 0 1 {name=p26980 lab=_62126_/D }
C {sky130_stdcells/dfxtp_4.sym} 27460 -22360 0 0 {name=X_86853_ }
C {devices/lab_pin.sym} 27400 -22240 0 0 {name=p26981 lab=_68999_/A }
C {devices/lab_pin.sym} 27400 -22200 0 0 {name=p26982 lab=_74166_/A }
C {devices/lab_pin.sym} 27520 -22220 0 1 {name=p26983 lab=_68999_/X }
C {sky130_stdcells/and2_4.sym} 27460 -22220 0 0 {name=X_68999_ }
C {devices/lab_pin.sym} 27420 -22090 0 0 {name=p26984 lab=clkbuf_9_109_0_CLK/X }
C {devices/lab_pin.sym} 27500 -22090 0 1 {name=p26985 lab=_84375_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 27460 -22090 0 0 {name=Xclkbuf_10_218_0_CLK }
C {devices/lab_pin.sym} 27380 -21990 0 0 {name=p26986 lab=_50104_/Y }
C {devices/lab_pin.sym} 27380 -21950 0 0 {name=p26987 lab=_50092_/X }
C {devices/lab_pin.sym} 27380 -21910 0 0 {name=p26988 lab=_50106_/X }
C {devices/lab_pin.sym} 27540 -21950 0 1 {name=p26989 lab=_86263_/D }
C {sky130_stdcells/a21oi_4.sym} 27460 -21950 0 0 {name=X_50107_ }
C {devices/lab_pin.sym} 27370 -21810 0 0 {name=p26990 lab=_86040_/CLK }
C {devices/lab_pin.sym} 27370 -21790 0 0 {name=p26991 lab=_52529_/Y }
C {devices/lab_pin.sym} 27550 -21810 0 1 {name=p26992 lab=_65144_/B }
C {sky130_stdcells/dfxtp_4.sym} 27460 -21800 0 0 {name=X_85804_ }
C {devices/lab_pin.sym} 27420 -21670 0 0 {name=p26993 lab=_58868_/A }
C {devices/lab_pin.sym} 27500 -21670 0 1 {name=p26994 lab=_58752_/X }
C {sky130_stdcells/buf_2.sym} 27460 -21670 0 0 {name=X_58752_ }
C {devices/lab_pin.sym} 27380 -21570 0 0 {name=p26995 lab=_86076_/Q }
C {devices/lab_pin.sym} 27380 -21530 0 0 {name=p26996 lab=_51073_/X }
C {devices/lab_pin.sym} 27380 -21490 0 0 {name=p26997 lab=_51086_/Y }
C {devices/lab_pin.sym} 27540 -21530 0 1 {name=p26998 lab=_51087_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -21530 0 0 {name=X_51087_ }
C {devices/lab_pin.sym} 27420 -21390 0 0 {name=p26999 lab=clkbuf_9_424_0_CLK/X }
C {devices/lab_pin.sym} 27500 -21390 0 1 {name=p27000 lab=_82394_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 27460 -21390 0 0 {name=Xclkbuf_10_848_0_CLK }
C {devices/lab_pin.sym} 27380 -21300 0 0 {name=p27001 lab=_74547_/C }
C {devices/lab_pin.sym} 27380 -21260 0 0 {name=p27002 lab=_55690_/X }
C {devices/lab_pin.sym} 27380 -21220 0 0 {name=p27003 lab=_44102_/X }
C {devices/lab_pin.sym} 27380 -21180 0 0 {name=p27004 lab=_55963_/X }
C {devices/lab_pin.sym} 27540 -21240 0 1 {name=p27005 lab=_55965_/B }
C {sky130_stdcells/a211o_4.sym} 27460 -21240 0 0 {name=X_55964_ }
C {devices/lab_pin.sym} 27370 -21090 0 0 {name=p27006 lab=_86784_/CLK }
C {devices/lab_pin.sym} 27370 -21070 0 0 {name=p27007 lab=_46070_/Y }
C {devices/lab_pin.sym} 27550 -21090 0 1 {name=p27008 lab=_86784_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -21080 0 0 {name=X_86784_ }
C {devices/lab_pin.sym} 27370 -20950 0 0 {name=p27009 lab=_82642_/CLK }
C {devices/lab_pin.sym} 27370 -20930 0 0 {name=p27010 lab=_83996_/D }
C {devices/lab_pin.sym} 27550 -20950 0 1 {name=p27011 lab=_82644_/D }
C {sky130_stdcells/dfxtp_4.sym} 27460 -20940 0 0 {name=X_83996_ }
C {devices/lab_pin.sym} 27420 -20810 0 0 {name=p27012 lab=_57872_/A }
C {devices/lab_pin.sym} 27500 -20810 0 1 {name=p27013 lab=_57703_/X }
C {sky130_stdcells/buf_2.sym} 27460 -20810 0 0 {name=X_57703_ }
C {devices/lab_pin.sym} 27400 -20700 0 0 {name=p27014 lab=_50048_/A }
C {devices/lab_pin.sym} 27400 -20660 0 0 {name=p27015 lab=_51728_/B }
C {devices/lab_pin.sym} 27520 -20680 0 1 {name=p27016 lab=_50038_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -20680 0 0 {name=X_50038_ }
C {devices/lab_pin.sym} 27420 -20550 0 0 {name=p27017 lab=_54889_/A }
C {devices/lab_pin.sym} 27500 -20550 0 1 {name=p27018 lab=_54932_/C }
C {sky130_stdcells/buf_2.sym} 27460 -20550 0 0 {name=X_54915_ }
C {devices/lab_pin.sym} 27370 -20430 0 0 {name=p27019 lab=_85735_/CLK }
C {devices/lab_pin.sym} 27370 -20410 0 0 {name=p27020 lab=_52896_/Y }
C {devices/lab_pin.sym} 27550 -20430 0 1 {name=p27021 lab=_85735_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -20420 0 0 {name=X_85735_ }
C {devices/lab_pin.sym} 27380 -20310 0 0 {name=p27022 lab=_58682_/X }
C {devices/lab_pin.sym} 27380 -20270 0 0 {name=p27023 lab=_85784_/Q }
C {devices/lab_pin.sym} 27380 -20230 0 0 {name=p27024 lab=_58594_/X }
C {devices/lab_pin.sym} 27540 -20270 0 1 {name=p27025 lab=_58683_/X }
C {sky130_stdcells/o21a_4.sym} 27460 -20270 0 0 {name=X_58683_ }
C {devices/lab_pin.sym} 27420 -20130 0 0 {name=p27026 lab=_70961_/A }
C {devices/lab_pin.sym} 27500 -20130 0 1 {name=p27027 lab=_70961_/X }
C {sky130_stdcells/buf_2.sym} 27460 -20130 0 0 {name=X_70961_ }
C {devices/lab_pin.sym} 27370 -20010 0 0 {name=p27028 lab=_82961_/CLK }
C {devices/lab_pin.sym} 27370 -19990 0 0 {name=p27029 lab=_82755_/Q }
C {devices/lab_pin.sym} 27550 -20010 0 1 {name=p27030 lab=_82947_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -20000 0 0 {name=X_82947_ }
C {devices/lab_pin.sym} 27420 -19870 0 0 {name=p27031 lab=clkbuf_9_339_0_CLK/A }
C {devices/lab_pin.sym} 27500 -19870 0 1 {name=p27032 lab=clkbuf_9_339_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 27460 -19870 0 0 {name=Xclkbuf_9_339_0_CLK }
C {devices/lab_pin.sym} 27380 -19780 0 0 {name=p27033 lab=_56219_/C }
C {devices/lab_pin.sym} 27380 -19740 0 0 {name=p27034 lab=_44070_/B }
C {devices/lab_pin.sym} 27380 -19700 0 0 {name=p27035 lab=_44051_/A }
C {devices/lab_pin.sym} 27380 -19660 0 0 {name=p27036 lab=_55894_/X }
C {devices/lab_pin.sym} 27540 -19720 0 1 {name=p27037 lab=_55895_/X }
C {sky130_stdcells/a211o_4.sym} 27460 -19720 0 0 {name=X_55895_ }
C {devices/lab_pin.sym} 27400 -19600 0 0 {name=p27038 lab=_72710_/A }
C {devices/lab_pin.sym} 27400 -19560 0 0 {name=p27039 lab=_56824_/X }
C {devices/lab_pin.sym} 27400 -19520 0 0 {name=p27040 lab=_55254_/A }
C {devices/lab_pin.sym} 27400 -19480 0 0 {name=p27041 lab=_55253_/X }
C {devices/lab_pin.sym} 27520 -19540 0 1 {name=p27042 lab=_72700_/X }
C {sky130_stdcells/and4_4.sym} 27460 -19540 0 0 {name=X_72700_ }
C {devices/lab_pin.sym} 27420 -19390 0 0 {name=p27043 lab=_46249_/A }
C {devices/lab_pin.sym} 27500 -19390 0 1 {name=p27044 lab=_71985_/A }
C {sky130_stdcells/buf_2.sym} 27460 -19390 0 0 {name=X_57634_ }
C {devices/lab_pin.sym} 27420 -19270 0 0 {name=p27045 lab=_42860_/A }
C {devices/lab_pin.sym} 27500 -19270 0 1 {name=p27046 lab=_42860_/Y }
C {sky130_stdcells/inv_2.sym} 27460 -19270 0 0 {name=X_42860_ }
C {devices/lab_pin.sym} 27380 -19170 0 0 {name=p27047 lab=_85367_/Q }
C {devices/lab_pin.sym} 27380 -19130 0 0 {name=p27048 lab=_54839_/X }
C {devices/lab_pin.sym} 27380 -19090 0 0 {name=p27049 lab=_54845_/Y }
C {devices/lab_pin.sym} 27540 -19130 0 1 {name=p27050 lab=_54846_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -19130 0 0 {name=X_54846_ }
C {devices/lab_pin.sym} 27380 -19010 0 0 {name=p27051 lab=_73676_/X }
C {devices/lab_pin.sym} 27380 -18970 0 0 {name=p27052 lab=_73678_/X }
C {devices/lab_pin.sym} 27380 -18930 0 0 {name=p27053 lab=_73679_/X }
C {devices/lab_pin.sym} 27540 -18970 0 1 {name=p27054 lab=_73694_/B }
C {sky130_stdcells/a21o_4.sym} 27460 -18970 0 0 {name=X_73680_ }
C {devices/lab_pin.sym} 27370 -18830 0 0 {name=p27055 lab=_85471_/CLK }
C {devices/lab_pin.sym} 27370 -18810 0 0 {name=p27056 lab=_53262_/Y }
C {devices/lab_pin.sym} 27550 -18830 0 1 {name=p27057 lab=_85666_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -18820 0 0 {name=X_85666_ }
C {devices/lab_pin.sym} 27420 -18690 0 0 {name=p27058 lab=_70905_/D }
C {devices/lab_pin.sym} 27500 -18690 0 1 {name=p27059 lab=_70899_/D }
C {sky130_stdcells/buf_2.sym} 27460 -18690 0 0 {name=X_70892_ }
C {devices/lab_pin.sym} 27370 -18570 0 0 {name=p27060 lab=_82942_/CLK }
C {devices/lab_pin.sym} 27370 -18550 0 0 {name=p27061 lab=_78290_/B }
C {devices/lab_pin.sym} 27550 -18570 0 1 {name=p27062 lab=_82878_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -18560 0 0 {name=X_82878_ }
C {devices/lab_pin.sym} 27370 -18430 0 0 {name=p27063 lab=_87471_/CLK }
C {devices/lab_pin.sym} 27370 -18410 0 0 {name=p27064 lab=_87405_/D }
C {devices/lab_pin.sym} 27550 -18430 0 1 {name=p27065 lab=_87405_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -18420 0 0 {name=X_87405_ }
C {devices/lab_pin.sym} 27380 -18320 0 0 {name=p27066 lab=_40404_/X }
C {devices/lab_pin.sym} 27380 -18280 0 0 {name=p27067 lab=_41799_/X }
C {devices/lab_pin.sym} 27380 -18240 0 0 {name=p27068 lab=_88140_/Q }
C {devices/lab_pin.sym} 27380 -18200 0 0 {name=p27069 lab=_41800_/X }
C {devices/lab_pin.sym} 27540 -18260 0 1 {name=p27070 lab=_88140_/D }
C {sky130_stdcells/a2bb2o_4.sym} 27460 -18260 0 0 {name=X_41811_ }
C {devices/lab_pin.sym} 27420 -18110 0 0 {name=p27071 lab=_72630_/X }
C {devices/lab_pin.sym} 27500 -18110 0 1 {name=p27072 lab=_72631_/X }
C {sky130_stdcells/buf_2.sym} 27460 -18110 0 0 {name=X_72631_ }
C {devices/lab_pin.sym} 27370 -17990 0 0 {name=p27073 lab=_83218_/CLK }
C {devices/lab_pin.sym} 27370 -17970 0 0 {name=p27074 lab=_60424_/X }
C {devices/lab_pin.sym} 27550 -17990 0 1 {name=p27075 lab=_79157_/A }
C {sky130_stdcells/dfxtp_4.sym} 27460 -17980 0 0 {name=X_84617_ }
C {devices/lab_pin.sym} 27400 -17860 0 0 {name=p27076 lab=_57564_/X }
C {devices/lab_pin.sym} 27400 -17820 0 0 {name=p27077 lab=_53531_/B }
C {devices/lab_pin.sym} 27520 -17840 0 1 {name=p27078 lab=_57565_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -17840 0 0 {name=X_57565_ }
C {devices/lab_pin.sym} 27370 -17710 0 0 {name=p27079 lab=_80708_/CLK }
C {devices/lab_pin.sym} 27370 -17690 0 0 {name=p27080 lab=_81861_/Q }
C {devices/lab_pin.sym} 27550 -17710 0 1 {name=p27081 lab=_77265_/A }
C {sky130_stdcells/dfxtp_4.sym} 27460 -17700 0 0 {name=X_81829_ }
C {devices/lab_pin.sym} 27370 -17570 0 0 {name=p27082 lab=_88386_/CLK }
C {devices/lab_pin.sym} 27370 -17550 0 0 {name=p27083 lab=_88385_/D }
C {devices/lab_pin.sym} 27550 -17570 0 1 {name=p27084 lab=_88385_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -17560 0 0 {name=X_88385_ }
C {devices/lab_pin.sym} 27380 -17460 0 0 {name=p27085 lab=_41367_/X }
C {devices/lab_pin.sym} 27380 -17420 0 0 {name=p27086 lab=_42787_/X }
C {devices/lab_pin.sym} 27380 -17380 0 0 {name=p27087 lab=_67700_/B }
C {devices/lab_pin.sym} 27380 -17340 0 0 {name=p27088 lab=_42788_/X }
C {devices/lab_pin.sym} 27540 -17400 0 1 {name=p27089 lab=_87716_/D }
C {sky130_stdcells/a2bb2o_4.sym} 27460 -17400 0 0 {name=X_42791_ }
C {devices/lab_pin.sym} 27400 -17260 0 0 {name=p27090 lab=_54758_/X }
C {devices/lab_pin.sym} 27400 -17220 0 0 {name=p27091 lab=_47506_/A }
C {devices/lab_pin.sym} 27520 -17240 0 1 {name=p27092 lab=_54777_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -17240 0 0 {name=X_54777_ }
C {devices/lab_pin.sym} 27370 -17110 0 0 {name=p27093 lab=_85596_/CLK }
C {devices/lab_pin.sym} 27370 -17090 0 0 {name=p27094 lab=_53642_/Y }
C {devices/lab_pin.sym} 27550 -17110 0 1 {name=p27095 lab=_85597_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -17100 0 0 {name=X_85597_ }
C {devices/lab_pin.sym} 27380 -16990 0 0 {name=p27096 lab=_51986_/Y }
C {devices/lab_pin.sym} 27380 -16950 0 0 {name=p27097 lab=_51987_/X }
C {devices/lab_pin.sym} 27380 -16910 0 0 {name=p27098 lab=_51988_/X }
C {devices/lab_pin.sym} 27540 -16950 0 1 {name=p27099 lab=_85911_/D }
C {sky130_stdcells/a21oi_4.sym} 27460 -16950 0 0 {name=X_51989_ }
C {devices/lab_pin.sym} 27400 -16820 0 0 {name=p27100 lab=_59256_/A }
C {devices/lab_pin.sym} 27400 -16780 0 0 {name=p27101 lab=_86344_/Q }
C {devices/lab_pin.sym} 27520 -16800 0 1 {name=p27102 lab=_59304_/Y }
C {sky130_stdcells/nor2_4.sym} 27460 -16800 0 0 {name=X_59304_ }
C {devices/lab_pin.sym} 27420 -16670 0 0 {name=p27103 lab=_44530_/A }
C {devices/lab_pin.sym} 27500 -16670 0 1 {name=p27104 lab=_44530_/X }
C {sky130_stdcells/buf_2.sym} 27460 -16670 0 0 {name=X_44530_ }
C {devices/lab_pin.sym} 27400 -16570 0 0 {name=p27105 lab=_56523_/A }
C {devices/lab_pin.sym} 27400 -16530 0 0 {name=p27106 lab=_56520_/B }
C {devices/lab_pin.sym} 27400 -16490 0 0 {name=p27107 lab=_55814_/B }
C {devices/lab_pin.sym} 27520 -16530 0 1 {name=p27108 lab=_56516_/Y }
C {sky130_stdcells/nand3_4.sym} 27460 -16530 0 0 {name=X_56516_ }
C {devices/lab_pin.sym} 27400 -16400 0 0 {name=p27109 lab=_80693_/Q }
C {devices/lab_pin.sym} 27400 -16360 0 0 {name=p27110 lab=_80949_/D }
C {devices/lab_pin.sym} 27520 -16380 0 1 {name=p27111 lab=_75351_/A }
C {sky130_stdcells/nand2_4.sym} 27460 -16380 0 0 {name=X_75350_ }
C {devices/lab_pin.sym} 27370 -16250 0 0 {name=p27112 lab=_87045_/CLK }
C {devices/lab_pin.sym} 27370 -16230 0 0 {name=p27113 lab=_43626_/X }
C {devices/lab_pin.sym} 27550 -16250 0 1 {name=p27114 lab=_73822_/A }
C {sky130_stdcells/dfxtp_4.sym} 27460 -16240 0 0 {name=X_87336_ }
C {devices/lab_pin.sym} 27380 -16140 0 0 {name=p27115 lab=_41741_/X }
C {devices/lab_pin.sym} 27380 -16100 0 0 {name=p27116 lab=_41722_/X }
C {devices/lab_pin.sym} 27380 -16060 0 0 {name=p27117 lab=_67840_/B }
C {devices/lab_pin.sym} 27380 -16020 0 0 {name=p27118 lab=_41723_/X }
C {devices/lab_pin.sym} 27540 -16080 0 1 {name=p27119 lab=_88158_/D }
C {sky130_stdcells/a2bb2o_4.sym} 27460 -16080 0 0 {name=X_41742_ }
C {devices/lab_pin.sym} 27420 -15930 0 0 {name=p27120 lab=_53990_/A }
C {devices/lab_pin.sym} 27500 -15930 0 1 {name=p27121 lab=_53729_/A }
C {sky130_stdcells/buf_2.sym} 27460 -15930 0 0 {name=X_53728_ }
C {devices/lab_pin.sym} 27420 -15810 0 0 {name=p27122 lab=_72562_/A }
C {devices/lab_pin.sym} 27500 -15810 0 1 {name=p27123 lab=_72562_/Y }
C {sky130_stdcells/inv_2.sym} 27460 -15810 0 0 {name=X_72562_ }
C {devices/lab_pin.sym} 27370 -15690 0 0 {name=p27124 lab=_84529_/CLK }
C {devices/lab_pin.sym} 27370 -15670 0 0 {name=p27125 lab=_84548_/D }
C {devices/lab_pin.sym} 27550 -15690 0 1 {name=p27126 lab=_60959_/C }
C {sky130_stdcells/dfxtp_4.sym} 27460 -15680 0 0 {name=X_84548_ }
C {devices/lab_pin.sym} 27380 -15570 0 0 {name=p27127 lab=_84992_/Q }
C {devices/lab_pin.sym} 27380 -15530 0 0 {name=p27128 lab=_57493_/X }
C {devices/lab_pin.sym} 27380 -15490 0 0 {name=p27129 lab=_57495_/Y }
C {devices/lab_pin.sym} 27540 -15530 0 1 {name=p27130 lab=_57496_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -15530 0 0 {name=X_57496_ }
C {devices/lab_pin.sym} 27420 -15390 0 0 {name=p27131 lab=_72686_/A }
C {devices/lab_pin.sym} 27500 -15390 0 1 {name=p27132 lab=_74301_/X }
C {sky130_stdcells/buf_2.sym} 27460 -15390 0 0 {name=X_74301_ }
C {devices/lab_pin.sym} 27380 -15290 0 0 {name=p27133 lab=_59208_/X }
C {devices/lab_pin.sym} 27380 -15250 0 0 {name=p27134 lab=_86062_/Q }
C {devices/lab_pin.sym} 27380 -15210 0 0 {name=p27135 lab=_59234_/X }
C {devices/lab_pin.sym} 27540 -15250 0 1 {name=p27136 lab=_59235_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -15250 0 0 {name=X_59235_ }
C {devices/lab_pin.sym} 27380 -15130 0 0 {name=p27137 lab=_53232_/B }
C {devices/lab_pin.sym} 27380 -15090 0 0 {name=p27138 lab=_71508_/X }
C {devices/lab_pin.sym} 27380 -15050 0 0 {name=p27139 lab=_71512_/Y }
C {devices/lab_pin.sym} 27540 -15090 0 1 {name=p27140 lab=_83472_/D }
C {sky130_stdcells/o21ai_4.sym} 27460 -15090 0 0 {name=X_71513_ }
C {devices/lab_pin.sym} 27420 -14950 0 0 {name=p27141 lab=_44461_/A }
C {devices/lab_pin.sym} 27500 -14950 0 1 {name=p27142 lab=_44461_/Y }
C {sky130_stdcells/inv_2.sym} 27460 -14950 0 0 {name=X_44461_ }
C {devices/lab_pin.sym} 27380 -14850 0 0 {name=p27143 lab=_56153_/X }
C {devices/lab_pin.sym} 27380 -14810 0 0 {name=p27144 lab=_56439_/X }
C {devices/lab_pin.sym} 27380 -14770 0 0 {name=p27145 lab=_56446_/Y }
C {devices/lab_pin.sym} 27540 -14810 0 1 {name=p27146 lab=_56447_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -14810 0 0 {name=X_56447_ }
C {devices/lab_pin.sym} 27380 -14690 0 0 {name=p27147 lab=_75258_/X }
C {devices/lab_pin.sym} 27380 -14650 0 0 {name=p27148 lab=_75259_/Y }
C {devices/lab_pin.sym} 27380 -14610 0 0 {name=p27149 lab=_75261_/A }
C {devices/lab_pin.sym} 27540 -14650 0 1 {name=p27150 lab=_75281_/Y }
C {sky130_stdcells/a21boi_4.sym} 27460 -14650 0 0 {name=X_75281_ }
C {devices/lab_pin.sym} 27370 -14510 0 0 {name=p27151 lab=_88034_/CLK }
C {devices/lab_pin.sym} 27370 -14490 0 0 {name=p27152 lab=_43788_/X }
C {devices/lab_pin.sym} 27550 -14510 0 1 {name=p27153 lab=_69358_/B }
C {sky130_stdcells/dfxtp_4.sym} 27460 -14500 0 0 {name=X_87267_ }
C {devices/lab_pin.sym} 27380 -14390 0 0 {name=p27154 lab=_53657_/Y }
C {devices/lab_pin.sym} 27380 -14350 0 0 {name=p27155 lab=_53653_/X }
C {devices/lab_pin.sym} 27380 -14310 0 0 {name=p27156 lab=_53658_/X }
C {devices/lab_pin.sym} 27540 -14350 0 1 {name=p27157 lab=_85593_/D }
C {sky130_stdcells/a21oi_4.sym} 27460 -14350 0 0 {name=X_53659_ }
C {devices/lab_pin.sym} 27420 -14210 0 0 {name=p27158 lab=_41825_/A }
C {devices/lab_pin.sym} 27500 -14210 0 1 {name=p27159 lab=_41673_/X }
C {sky130_stdcells/buf_2.sym} 27460 -14210 0 0 {name=X_41673_ }
C {devices/lab_pin.sym} 27380 -14110 0 0 {name=p27160 lab=_72484_/X }
C {devices/lab_pin.sym} 27380 -14070 0 0 {name=p27161 lab=_83382_/Q }
C {devices/lab_pin.sym} 27380 -14030 0 0 {name=p27162 lab=_72492_/Y }
C {devices/lab_pin.sym} 27540 -14070 0 1 {name=p27163 lab=_83246_/D }
C {sky130_stdcells/o21a_4.sym} 27460 -14070 0 0 {name=X_72493_ }
C {devices/lab_pin.sym} 27370 -13930 0 0 {name=p27164 lab=_84481_/CLK }
C {devices/lab_pin.sym} 27370 -13910 0 0 {name=p27165 lab=_61457_/Y }
C {devices/lab_pin.sym} 27550 -13930 0 1 {name=p27166 lab=_84479_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -13920 0 0 {name=X_84479_ }
C {devices/lab_pin.sym} 27420 -13790 0 0 {name=p27167 lab=_46199_/X }
C {devices/lab_pin.sym} 27500 -13790 0 1 {name=p27168 lab=_72527_/B }
C {sky130_stdcells/buf_2.sym} 27460 -13790 0 0 {name=X_46200_ }
C {sky130_stdcells/decap_3.sym} 27460 -13640 0 0 {name=XPHY_120 }
C {devices/lab_pin.sym} 27380 -13510 0 0 {name=p27169 lab=_77014_/Y }
C {devices/lab_pin.sym} 27380 -13470 0 0 {name=p27170 lab=_77019_/Y }
C {devices/lab_pin.sym} 27380 -13430 0 0 {name=p27171 lab=_77011_/B }
C {devices/lab_pin.sym} 27540 -13470 0 1 {name=p27172 lab=_77020_/Y }
C {sky130_stdcells/a21oi_4.sym} 27460 -13470 0 0 {name=X_77020_ }
C {devices/lab_pin.sym} 27420 -13330 0 0 {name=p27173 lab=_43396_/A }
C {devices/lab_pin.sym} 27500 -13330 0 1 {name=p27174 lab=_43412_/X }
C {sky130_stdcells/buf_2.sym} 27460 -13330 0 0 {name=X_43412_ }
C {devices/lab_pin.sym} 27400 -13220 0 0 {name=p27175 lab=_74232_/A }
C {devices/lab_pin.sym} 27400 -13180 0 0 {name=p27176 lab=_74232_/B }
C {devices/lab_pin.sym} 27520 -13200 0 1 {name=p27177 lab=_74232_/X }
C {sky130_stdcells/and2_4.sym} 27460 -13200 0 0 {name=X_74232_ }
C {devices/lab_pin.sym} 27370 -13070 0 0 {name=p27178 lab=_86218_/CLK }
C {devices/lab_pin.sym} 27370 -13050 0 0 {name=p27179 lab=_50353_/Y }
C {devices/lab_pin.sym} 27550 -13070 0 1 {name=p27180 lab=_86218_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -13060 0 0 {name=X_86218_ }
C {sky130_stdcells/decap_3.sym} 27460 -12900 0 0 {name=XPHY_131 }
C {devices/lab_pin.sym} 27400 -12760 0 0 {name=p27181 lab=_40624_/A }
C {devices/lab_pin.sym} 27400 -12720 0 0 {name=p27182 lab=_40623_/X }
C {devices/lab_pin.sym} 27520 -12740 0 1 {name=p27183 lab=_40624_/X }
C {sky130_stdcells/or2_4.sym} 27460 -12740 0 0 {name=X_40624_ }
C {devices/lab_pin.sym} 27420 -12610 0 0 {name=p27184 lab=_47180_/A }
C {devices/lab_pin.sym} 27500 -12610 0 1 {name=p27185 lab=_52900_/D }
C {sky130_stdcells/buf_2.sym} 27460 -12610 0 0 {name=X_47180_ }
C {devices/lab_pin.sym} 27420 -12490 0 0 {name=p27186 lab=_71444_/A }
C {devices/lab_pin.sym} 27500 -12490 0 1 {name=p27187 lab=_71444_/Y }
C {sky130_stdcells/inv_2.sym} 27460 -12490 0 0 {name=X_71444_ }
C {devices/lab_pin.sym} 27380 -12390 0 0 {name=p27188 lab=_59162_/Y }
C {devices/lab_pin.sym} 27380 -12350 0 0 {name=p27189 lab=_59164_/Y }
C {devices/lab_pin.sym} 27380 -12310 0 0 {name=p27190 lab=_59165_/X }
C {devices/lab_pin.sym} 27540 -12350 0 1 {name=p27191 lab=_59166_/X }
C {sky130_stdcells/a21o_4.sym} 27460 -12350 0 0 {name=X_59166_ }
C {devices/lab_pin.sym} 27420 -12210 0 0 {name=p27192 lab=_44392_/A }
C {devices/lab_pin.sym} 27500 -12210 0 1 {name=p27193 lab=_87132_/D }
C {sky130_stdcells/inv_2.sym} 27460 -12210 0 0 {name=X_44392_ }
C {sky130_stdcells/decap_3.sym} 27460 -12060 0 0 {name=XPHY_142 }
C {devices/lab_pin.sym} 27420 -11910 0 0 {name=p27194 lab=_56377_/X }
C {devices/lab_pin.sym} 27500 -11910 0 1 {name=p27195 lab=_56378_/X }
C {sky130_stdcells/buf_2.sym} 27460 -11910 0 0 {name=X_56378_ }
C {devices/lab_pin.sym} 27370 -11790 0 0 {name=p27196 lab=_87720_/CLK }
C {devices/lab_pin.sym} 27370 -11770 0 0 {name=p27197 lab=_87198_/D }
C {devices/lab_pin.sym} 27550 -11790 0 1 {name=p27198 lab=_67845_/B }
C {sky130_stdcells/dfxtp_4.sym} 27460 -11780 0 0 {name=X_87198_ }
C {sky130_stdcells/decap_3.sym} 27460 -11620 0 0 {name=XPHY_153 }
C {sky130_stdcells/decap_3.sym} 27460 -11440 0 0 {name=XPHY_164 }
C {devices/lab_pin.sym} 27400 -11300 0 0 {name=p27199 lab=_46107_/A }
C {devices/lab_pin.sym} 27400 -11260 0 0 {name=p27200 lab=_46115_/A }
C {devices/lab_pin.sym} 27520 -11280 0 1 {name=p27201 lab=_46133_/C }
C {sky130_stdcells/nor2_4.sym} 27460 -11280 0 0 {name=X_46131_ }
C {devices/lab_pin.sym} 27400 -11160 0 0 {name=p27202 lab=_86628_/Q }
C {devices/lab_pin.sym} 27400 -11120 0 0 {name=p27203 lab=_57954_/X }
C {devices/lab_pin.sym} 27520 -11140 0 1 {name=p27204 lab=_58117_/Y }
C {sky130_stdcells/nor2_4.sym} 27460 -11140 0 0 {name=X_58117_ }
C {sky130_stdcells/decap_3.sym} 27460 -10980 0 0 {name=XPHY_175 }
C {devices/lab_pin.sym} 27420 -10830 0 0 {name=p27205 lab=_43342_/Y }
C {devices/lab_pin.sym} 27500 -10830 0 1 {name=p27206 lab=_87469_/D }
C {sky130_stdcells/inv_2.sym} 27460 -10830 0 0 {name=X_43343_ }
C {devices/lab_pin.sym} 27380 -10730 0 0 {name=p27207 lab=_55201_/Y }
C {devices/lab_pin.sym} 27380 -10690 0 0 {name=p27208 lab=_55299_/Y }
C {devices/lab_pin.sym} 27380 -10650 0 0 {name=p27209 lab=_55328_/X }
C {devices/lab_pin.sym} 27540 -10690 0 1 {name=p27210 lab=_55329_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -10690 0 0 {name=X_55329_ }
C {devices/lab_pin.sym} 27380 -10570 0 0 {name=p27211 lab=_83120_/Q }
C {devices/lab_pin.sym} 27380 -10530 0 0 {name=p27212 lab=_74139_/X }
C {devices/lab_pin.sym} 27380 -10490 0 0 {name=p27213 lab=_74162_/Y }
C {devices/lab_pin.sym} 27540 -10530 0 1 {name=p27214 lab=_83120_/D }
C {sky130_stdcells/a21o_4.sym} 27460 -10530 0 0 {name=X_74163_ }
C {devices/lab_pin.sym} 27370 -10390 0 0 {name=p27215 lab=_86149_/CLK }
C {devices/lab_pin.sym} 27370 -10370 0 0 {name=p27216 lab=_86149_/D }
C {devices/lab_pin.sym} 27550 -10390 0 1 {name=p27217 lab=_86149_/Q }
C {sky130_stdcells/dfxtp_4.sym} 27460 -10380 0 0 {name=X_86149_ }
C {devices/lab_pin.sym} 27420 -10250 0 0 {name=p27218 lab=_40554_/X }
C {devices/lab_pin.sym} 27500 -10250 0 1 {name=p27219 lab=_40556_/A }
C {sky130_stdcells/buf_2.sym} 27460 -10250 0 0 {name=X_40555_ }
C {sky130_stdcells/decap_3.sym} 27460 -10100 0 0 {name=XPHY_186 }
C {devices/lab_pin.sym} 27380 -9970 0 0 {name=p27220 lab=_59033_/X }
C {devices/lab_pin.sym} 27380 -9930 0 0 {name=p27221 lab=_85433_/Q }
C {devices/lab_pin.sym} 27380 -9890 0 0 {name=p27222 lab=_59096_/X }
C {devices/lab_pin.sym} 27540 -9930 0 1 {name=p27223 lab=_59097_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -9930 0 0 {name=X_59097_ }
C {devices/lab_pin.sym} 27420 -9790 0 0 {name=p27224 lab=_71485_/B }
C {devices/lab_pin.sym} 27500 -9790 0 1 {name=p27225 lab=_71458_/C }
C {sky130_stdcells/buf_2.sym} 27460 -9790 0 0 {name=X_71375_ }
C {sky130_stdcells/decap_3.sym} 27460 -9640 0 0 {name=XPHY_197 }
C {devices/lab_pin.sym} 27400 -9500 0 0 {name=p27226 lab=_73183_/A }
C {devices/lab_pin.sym} 27400 -9460 0 0 {name=p27227 lab=_86484_/Q }
C {devices/lab_pin.sym} 27520 -9480 0 1 {name=p27228 lab=_73114_/X }
C {sky130_stdcells/and2_4.sym} 27460 -9480 0 0 {name=X_73114_ }
C {devices/lab_pin.sym} 27420 -9350 0 0 {name=p27229 lab=_84929_/Q }
C {devices/lab_pin.sym} 27500 -9350 0 1 {name=p27230 lab=_58048_/Y }
C {sky130_stdcells/inv_2.sym} 27460 -9350 0 0 {name=X_58048_ }
C {devices/lab_pin.sym} 27400 -9260 0 0 {name=p27231 lab=_70326_/A }
C {devices/lab_pin.sym} 27400 -9220 0 0 {name=p27232 lab=_70183_/A }
C {devices/lab_pin.sym} 27400 -9180 0 0 {name=p27233 lab=_70183_/B }
C {devices/lab_pin.sym} 27400 -9140 0 0 {name=p27234 lab=_70183_/D }
C {devices/lab_pin.sym} 27520 -9200 0 1 {name=p27235 lab=_70326_/Y }
C {sky130_stdcells/nand4_4.sym} 27460 -9200 0 0 {name=X_70326_ }
C {devices/lab_pin.sym} 27420 -9050 0 0 {name=p27236 lab=_43611_/A }
C {devices/lab_pin.sym} 27500 -9050 0 1 {name=p27237 lab=_46062_/X }
C {sky130_stdcells/buf_2.sym} 27460 -9050 0 0 {name=X_46062_ }
C {devices/lab_pin.sym} 27380 -8970 0 0 {name=p27238 lab=_43260_/X }
C {devices/lab_pin.sym} 27380 -8930 0 0 {name=p27239 lab=_43269_/X }
C {devices/lab_pin.sym} 27380 -8890 0 0 {name=p27240 lab=_41125_/X }
C {devices/lab_pin.sym} 27380 -8850 0 0 {name=p27241 lab=_87505_/Q }
C {devices/lab_pin.sym} 27380 -8810 0 0 {name=p27242 lab=_43273_/X }
C {devices/lab_pin.sym} 27540 -8890 0 1 {name=p27243 lab=_43274_/Y }
C {sky130_stdcells/o32ai_4.sym} 27460 -8890 0 0 {name=X_43274_ }
C {devices/lab_pin.sym} 27380 -8750 0 0 {name=p27244 lab=_70128_/A }
C {devices/lab_pin.sym} 27380 -8710 0 0 {name=p27245 lab=_73549_/X }
C {devices/lab_pin.sym} 27380 -8670 0 0 {name=p27246 lab=_74093_/Y }
C {devices/lab_pin.sym} 27540 -8710 0 1 {name=p27247 lab=_83123_/D }
C {sky130_stdcells/a21o_4.sym} 27460 -8710 0 0 {name=X_74094_ }
C {devices/lab_pin.sym} 27380 -8600 0 0 {name=p27248 lab=_78948_/Y }
C {devices/lab_pin.sym} 27380 -8560 0 0 {name=p27249 lab=_79115_/A }
C {devices/lab_pin.sym} 27380 -8520 0 0 {name=p27250 lab=_78959_/Y }
C {devices/lab_pin.sym} 27380 -8480 0 0 {name=p27251 lab=_78960_/Y }
C {devices/lab_pin.sym} 27540 -8540 0 1 {name=p27252 lab=_78971_/X }
C {sky130_stdcells/o22a_4.sym} 27460 -8540 0 0 {name=X_78971_ }
C {devices/lab_pin.sym} 27380 -8420 0 0 {name=p27253 lab=_40485_/X }
C {devices/lab_pin.sym} 27380 -8380 0 0 {name=p27254 lab=_40410_/X }
C {devices/lab_pin.sym} 27380 -8340 0 0 {name=p27255 lab=_88384_/Q }
C {devices/lab_pin.sym} 27380 -8300 0 0 {name=p27256 lab=_40411_/X }
C {devices/lab_pin.sym} 27540 -8360 0 1 {name=p27257 lab=_40486_/X }
C {sky130_stdcells/a2bb2o_4.sym} 27460 -8360 0 0 {name=X_40486_ }
C {devices/lab_pin.sym} 27380 -8230 0 0 {name=p27258 lab=_56306_/C }
C {devices/lab_pin.sym} 27380 -8190 0 0 {name=p27259 lab=_44979_/X }
C {devices/lab_pin.sym} 27380 -8150 0 0 {name=p27260 lab=_45012_/X }
C {devices/lab_pin.sym} 27540 -8190 0 1 {name=p27261 lab=_45013_/X }
C {sky130_stdcells/o21a_4.sym} 27460 -8190 0 0 {name=X_45013_ }
C {devices/lab_pin.sym} 27380 -8080 0 0 {name=p27262 lab=_41371_/X }
C {devices/lab_pin.sym} 27380 -8040 0 0 {name=p27263 lab=_42222_/X }
C {devices/lab_pin.sym} 27380 -8000 0 0 {name=p27264 lab=_87971_/Q }
C {devices/lab_pin.sym} 27380 -7960 0 0 {name=p27265 lab=_42224_/X }
C {devices/lab_pin.sym} 27540 -8020 0 1 {name=p27266 lab=_87971_/D }
C {sky130_stdcells/a2bb2o_4.sym} 27460 -8020 0 0 {name=X_42225_ }
C {devices/lab_pin.sym} 27380 -7890 0 0 {name=p27267 lab=_77916_/B }
C {devices/lab_pin.sym} 27380 -7850 0 0 {name=p27268 lab=_77916_/A }
C {devices/lab_pin.sym} 27380 -7810 0 0 {name=p27269 lab=_77921_/Y }
C {devices/lab_pin.sym} 27540 -7850 0 1 {name=p27270 lab=_77922_/Y }
C {sky130_stdcells/a21oi_4.sym} 27460 -7850 0 0 {name=X_77922_ }
C {devices/lab_pin.sym} 27400 -7720 0 0 {name=p27271 lab=_72881_/A }
C {devices/lab_pin.sym} 27400 -7680 0 0 {name=p27272 lab=_65584_/B }
C {devices/lab_pin.sym} 27520 -7700 0 1 {name=p27273 lab=_73045_/X }
C {sky130_stdcells/and2_4.sym} 27460 -7700 0 0 {name=X_73045_ }
C {devices/lab_pin.sym} 27380 -7590 0 0 {name=p27274 lab=_70255_/X }
C {devices/lab_pin.sym} 27380 -7550 0 0 {name=p27275 lab=_74771_/A }
C {devices/lab_pin.sym} 27380 -7510 0 0 {name=p27276 lab=_70256_/X }
C {devices/lab_pin.sym} 27540 -7550 0 1 {name=p27277 lab=_70257_/X }
C {sky130_stdcells/a21o_4.sym} 27460 -7550 0 0 {name=X_70257_ }
C {devices/lab_pin.sym} 27420 -7410 0 0 {name=p27278 lab=_62504_/A }
C {devices/lab_pin.sym} 27500 -7410 0 1 {name=p27279 lab=_62478_/A }
C {sky130_stdcells/buf_2.sym} 27460 -7410 0 0 {name=X_60010_ }
C {devices/lab_pin.sym} 27380 -7310 0 0 {name=p27280 lab=_86317_/Q }
C {devices/lab_pin.sym} 27380 -7270 0 0 {name=p27281 lab=_49798_/X }
C {devices/lab_pin.sym} 27380 -7230 0 0 {name=p27282 lab=_49820_/Y }
C {devices/lab_pin.sym} 27540 -7270 0 1 {name=p27283 lab=_49821_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -7270 0 0 {name=X_49821_ }
C {devices/lab_pin.sym} 27420 -7130 0 0 {name=p27284 lab=_42155_/Y }
C {devices/lab_pin.sym} 27500 -7130 0 1 {name=p27285 lab=_88007_/D }
C {sky130_stdcells/inv_2.sym} 27460 -7130 0 0 {name=X_42156_ }
C {devices/lab_pin.sym} 27400 -7020 0 0 {name=p27286 lab=_77851_/Y }
C {devices/lab_pin.sym} 27400 -6980 0 0 {name=p27287 lab=_77852_/Y }
C {devices/lab_pin.sym} 27520 -7000 0 1 {name=p27288 lab=_77861_/A }
C {sky130_stdcells/xor2_4.sym} 27460 -7000 0 0 {name=X_77853_ }
C {devices/lab_pin.sym} 27400 -6900 0 0 {name=p27289 lab=_70200_/A }
C {devices/lab_pin.sym} 27400 -6860 0 0 {name=p27290 lab=_70200_/B }
C {devices/lab_pin.sym} 27400 -6820 0 0 {name=p27291 lab=_70188_/C }
C {devices/lab_pin.sym} 27400 -6780 0 0 {name=p27292 lab=_70200_/D }
C {devices/lab_pin.sym} 27520 -6840 0 1 {name=p27293 lab=_70188_/X }
C {sky130_stdcells/and4_4.sym} 27460 -6840 0 0 {name=X_70188_ }
C {devices/lab_pin.sym} 27420 -6690 0 0 {name=p27294 lab=_59931_/X }
C {devices/lab_pin.sym} 27500 -6690 0 1 {name=p27295 lab=_60000_/A }
C {sky130_stdcells/inv_2.sym} 27460 -6690 0 0 {name=X_59999_ }
C {devices/lab_pin.sym} 27380 -6590 0 0 {name=p27296 lab=_41100_/X }
C {devices/lab_pin.sym} 27380 -6550 0 0 {name=p27297 lab=_81698_/Q }
C {devices/lab_pin.sym} 27380 -6510 0 0 {name=p27298 lab=_41106_/X }
C {devices/lab_pin.sym} 27540 -6550 0 1 {name=p27299 lab=_41107_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -6550 0 0 {name=X_41107_ }
C {devices/lab_pin.sym} 27400 -6420 0 0 {name=p27300 lab=_81667_/Q }
C {devices/lab_pin.sym} 27400 -6380 0 0 {name=p27301 lab=_76804_/B }
C {devices/lab_pin.sym} 27520 -6400 0 1 {name=p27302 lab=_76804_/Y }
C {sky130_stdcells/xnor2_4.sym} 27460 -6400 0 0 {name=X_76804_ }
C {devices/lab_pin.sym} 27380 -6290 0 0 {name=p27303 lab=_49749_/Y }
C {devices/lab_pin.sym} 27380 -6250 0 0 {name=p27304 lab=_49732_/X }
C {devices/lab_pin.sym} 27380 -6210 0 0 {name=p27305 lab=_49751_/X }
C {devices/lab_pin.sym} 27540 -6250 0 1 {name=p27306 lab=_49752_/Y }
C {sky130_stdcells/a21oi_4.sym} 27460 -6250 0 0 {name=X_49752_ }
C {devices/lab_pin.sym} 27420 -6110 0 0 {name=p27307 lab=_46964_/A }
C {devices/lab_pin.sym} 27500 -6110 0 1 {name=p27308 lab=_52775_/D }
C {sky130_stdcells/buf_2.sym} 27460 -6110 0 0 {name=X_46964_ }
C {devices/lab_pin.sym} 27380 -6020 0 0 {name=p27309 lab=_40986_/X }
C {devices/lab_pin.sym} 27380 -5980 0 0 {name=p27310 lab=_42072_/X }
C {devices/lab_pin.sym} 27380 -5940 0 0 {name=p27311 lab=_88041_/Q }
C {devices/lab_pin.sym} 27380 -5900 0 0 {name=p27312 lab=_42073_/X }
C {devices/lab_pin.sym} 27540 -5960 0 1 {name=p27313 lab=_42087_/X }
C {sky130_stdcells/a2bb2o_4.sym} 27460 -5960 0 0 {name=X_42087_ }
C {devices/lab_pin.sym} 27400 -5820 0 0 {name=p27314 lab=_77796_/A }
C {devices/lab_pin.sym} 27400 -5780 0 0 {name=p27315 lab=_77783_/Y }
C {devices/lab_pin.sym} 27520 -5800 0 1 {name=p27316 lab=_77785_/B }
C {sky130_stdcells/xor2_4.sym} 27460 -5800 0 0 {name=X_77784_ }
C {devices/lab_pin.sym} 27380 -5690 0 0 {name=p27317 lab=_75001_/A }
C {devices/lab_pin.sym} 27380 -5650 0 0 {name=p27318 lab=_74986_/X }
C {devices/lab_pin.sym} 27380 -5610 0 0 {name=p27319 lab=_74995_/Y }
C {devices/lab_pin.sym} 27540 -5650 0 1 {name=p27320 lab=_74996_/Y }
C {sky130_stdcells/a21boi_4.sym} 27460 -5650 0 0 {name=X_74996_ }
C {devices/lab_pin.sym} 27380 -5530 0 0 {name=p27321 lab=_48696_/Y }
C {devices/lab_pin.sym} 27380 -5490 0 0 {name=p27322 lab=_48651_/X }
C {devices/lab_pin.sym} 27380 -5450 0 0 {name=p27323 lab=_48702_/X }
C {devices/lab_pin.sym} 27540 -5490 0 1 {name=p27324 lab=_48703_/Y }
C {sky130_stdcells/a21oi_4.sym} 27460 -5490 0 0 {name=X_48703_ }
C {devices/lab_pin.sym} 27400 -5360 0 0 {name=p27325 lab=_79164_/Y }
C {devices/lab_pin.sym} 27400 -5320 0 0 {name=p27326 lab=_79523_/B }
C {devices/lab_pin.sym} 27520 -5340 0 1 {name=p27327 lab=_79523_/X }
C {sky130_stdcells/xor2_4.sym} 27460 -5340 0 0 {name=X_79523_ }
C {devices/lab_pin.sym} 27380 -5250 0 0 {name=p27328 lab=_40999_/X }
C {devices/lab_pin.sym} 27380 -5210 0 0 {name=p27329 lab=_41000_/X }
C {devices/lab_pin.sym} 27380 -5170 0 0 {name=p27330 lab=_41036_/X }
C {devices/lab_pin.sym} 27380 -5130 0 0 {name=p27331 lab=_88289_/Q }
C {devices/lab_pin.sym} 27380 -5090 0 0 {name=p27332 lab=_41037_/X }
C {devices/lab_pin.sym} 27540 -5170 0 1 {name=p27333 lab=_41039_/A }
C {sky130_stdcells/o32ai_4.sym} 27460 -5170 0 0 {name=X_41038_ }
C {devices/lab_pin.sym} 27420 -5010 0 0 {name=p27334 lab=_44020_/A }
C {devices/lab_pin.sym} 27500 -5010 0 1 {name=p27335 lab=_45915_/X }
C {sky130_stdcells/buf_2.sym} 27460 -5010 0 0 {name=X_45915_ }
C {devices/lab_pin.sym} 27400 -4900 0 0 {name=p27336 lab=_81692_/Q }
C {devices/lab_pin.sym} 27400 -4860 0 0 {name=p27337 lab=_76735_/B }
C {devices/lab_pin.sym} 27520 -4880 0 1 {name=p27338 lab=_76735_/Y }
C {sky130_stdcells/xnor2_4.sym} 27460 -4880 0 0 {name=X_76735_ }
C {devices/lab_pin.sym} 27380 -4770 0 0 {name=p27339 lab=_59327_/B }
C {devices/lab_pin.sym} 27380 -4730 0 0 {name=p27340 lab=_49660_/X }
C {devices/lab_pin.sym} 27380 -4690 0 0 {name=p27341 lab=_49682_/Y }
C {devices/lab_pin.sym} 27540 -4730 0 1 {name=p27342 lab=_49683_/Y }
C {sky130_stdcells/o21ai_4.sym} 27460 -4730 0 0 {name=X_49683_ }
C {devices/lab_pin.sym} 27380 -4610 0 0 {name=p27343 lab=_61958_/Y }
C {devices/lab_pin.sym} 27380 -4570 0 0 {name=p27344 lab=_61959_/X }
C {devices/lab_pin.sym} 27380 -4530 0 0 {name=p27345 lab=_61960_/Y }
C {devices/lab_pin.sym} 27540 -4570 0 1 {name=p27346 lab=_84443_/D }
C {sky130_stdcells/a21oi_4.sym} 27460 -4570 0 0 {name=X_61961_ }
C {devices/lab_pin.sym} 27380 -4450 0 0 {name=p27347 lab=_44709_/Y }
C {devices/lab_pin.sym} 27380 -4410 0 0 {name=p27348 lab=_73728_/X }
C {devices/lab_pin.sym} 27380 -4370 0 0 {name=p27349 lab=_73946_/Y }
C {devices/lab_pin.sym} 27540 -4410 0 1 {name=p27350 lab=_73947_/X }
C {sky130_stdcells/a21o_4.sym} 27460 -4410 0 0 {name=X_73947_ }
C {devices/lab_pin.sym} 27420 -4270 0 0 {name=p27351 lab=_46894_/Y }
C {devices/lab_pin.sym} 27500 -4270 0 1 {name=p27352 lab=_52735_/D }
C {sky130_stdcells/buf_2.sym} 27460 -4270 0 0 {name=X_46895_ }
C {devices/lab_pin.sym} 27380 -4190 0 0 {name=p27353 lab=_63624_/X }
C {devices/lab_pin.sym} 27380 -4150 0 0 {name=p27354 lab=_63694_/X }
C {devices/lab_pin.sym} 27380 -4110 0 0 {name=p27355 lab=_63695_/X }
C {devices/lab_pin.sym} 27380 -4070 0 0 {name=p27356 lab=_63698_/X }
C {devices/lab_pin.sym} 27380 -4030 0 0 {name=p27357 lab=_63699_/Y }
C {devices/lab_pin.sym} 27540 -4110 0 1 {name=p27358 lab=_63700_/Y }
C {sky130_stdcells/o41ai_4.sym} 27460 -4110 0 0 {name=X_63700_ }
C {devices/lab_pin.sym} 27420 -3950 0 0 {name=p27359 lab=_48634_/A }
C {devices/lab_pin.sym} 27500 -3950 0 1 {name=p27360 lab=_48841_/A }
C {sky130_stdcells/buf_2.sym} 27460 -3950 0 0 {name=X_48634_ }
C {devices/lab_pin.sym} 27420 -3830 0 0 {name=p27361 lab=_60870_/X }
C {devices/lab_pin.sym} 27500 -3830 0 1 {name=p27362 lab=_60994_/A }
C {sky130_stdcells/buf_2.sym} 27460 -3830 0 0 {name=X_60912_ }
C {devices/lab_pin.sym} 27380 -3730 0 0 {name=p27363 lab=_58639_/Y }
C {devices/lab_pin.sym} 27380 -3690 0 0 {name=p27364 lab=_66395_/C }
C {devices/lab_pin.sym} 27380 -3650 0 0 {name=p27365 lab=_79453_/Y }
C {devices/lab_pin.sym} 27540 -3690 0 1 {name=p27366 lab=_79470_/A }
C {sky130_stdcells/o21a_4.sym} 27460 -3690 0 0 {name=X_79454_ }
C {devices/lab_pin.sym} 27380 -3570 0 0 {name=p27367 lab=_56898_/A }
C {devices/lab_pin.sym} 27380 -3530 0 0 {name=p27368 lab=_45798_/X }
C {devices/lab_pin.sym} 27380 -3490 0 0 {name=p27369 lab=_44889_/A }
C {devices/lab_pin.sym} 27540 -3530 0 1 {name=p27370 lab=_45846_/X }
C {sky130_stdcells/o21a_4.sym} 27460 -3530 0 0 {name=X_45846_ }
C {devices/lab_pin.sym} 27400 -3400 0 0 {name=p27371 lab=_64680_/A }
C {devices/lab_pin.sym} 27400 -3360 0 0 {name=p27372 lab=_86270_/Q }
C {devices/lab_pin.sym} 27520 -3380 0 1 {name=p27373 lab=_64680_/X }
C {sky130_stdcells/and2_4.sym} 27460 -3380 0 0 {name=X_64680_ }
C {devices/lab_pin.sym} 27380 -3270 0 0 {name=p27374 lab=_76664_/A }
C {devices/lab_pin.sym} 27380 -3230 0 0 {name=p27375 lab=_76662_/Y }
C {devices/lab_pin.sym} 27380 -3190 0 0 {name=p27376 lab=_76661_/A }
C {devices/lab_pin.sym} 27540 -3230 0 1 {name=p27377 lab=_76666_/Y }
C {sky130_stdcells/a21oi_4.sym} 27460 -3230 0 0 {name=X_76666_ }
C {devices/lab_pin.sym} 27400 -3100 0 0 {name=p27378 lab=_73949_/A }
C {devices/lab_pin.sym} 27400 -3060 0 0 {name=p27379 lab=_66094_/B }
C {devices/lab_pin.sym} 27520 -3080 0 1 {name=p27380 lab=_73878_/X }
C {sky130_stdcells/and2_4.sym} 27460 -3080 0 0 {name=X_73878_ }
C {devices/lab_pin.sym} 27420 -2950 0 0 {name=p27381 lab=_61747_/X }
C {devices/lab_pin.sym} 27500 -2950 0 1 {name=p27382 lab=_61910_/D }
C {sky130_stdcells/buf_2.sym} 27460 -2950 0 0 {name=X_61892_ }
C {devices/lab_pin.sym} 27420 -2830 0 0 {name=p27383 lab=_78405_/A }
C {devices/lab_pin.sym} 27500 -2830 0 1 {name=p27384 lab=_78405_/Y }
C {sky130_stdcells/inv_2.sym} 27460 -2830 0 0 {name=X_78405_ }
C {devices/lab_pin.sym} 27380 -2740 0 0 {name=p27385 lab=_61590_/B }
C {devices/lab_pin.sym} 27380 -2700 0 0 {name=p27386 lab=_63609_/X }
C {devices/lab_pin.sym} 27380 -2660 0 0 {name=p27387 lab=_63629_/X }
C {devices/lab_pin.sym} 27380 -2620 0 0 {name=p27388 lab=_63630_/Y }
C {devices/lab_pin.sym} 27540 -2680 0 1 {name=p27389 lab=_63631_/X }
C {sky130_stdcells/a211o_4.sym} 27460 -2680 0 0 {name=X_63631_ }
C {devices/lab_pin.sym} 27400 -2540 0 0 {name=p27390 lab=_75617_/A }
C {devices/lab_pin.sym} 27400 -2500 0 0 {name=p27391 lab=_75617_/B }
C {devices/lab_pin.sym} 27520 -2520 0 1 {name=p27392 lab=_80967_/D }
C {sky130_stdcells/xor2_4.sym} 27460 -2520 0 0 {name=X_75617_ }
C {devices/lab_pin.sym} 27420 -2390 0 0 {name=p27393 lab=_72829_/A }
C {devices/lab_pin.sym} 27500 -2390 0 1 {name=p27394 lab=_72829_/X }
C {sky130_stdcells/buf_2.sym} 27460 -2390 0 0 {name=X_72829_ }
C {devices/lab_pin.sym} 27400 -2280 0 0 {name=p27395 lab=_49067_/B }
C {devices/lab_pin.sym} 27400 -2240 0 0 {name=p27396 lab=_48565_/B }
C {devices/lab_pin.sym} 27520 -2260 0 1 {name=p27397 lab=_48565_/Y }
C {sky130_stdcells/nand2_4.sym} 27460 -2260 0 0 {name=X_48565_ }
C {devices/lab_pin.sym} 27400 -2160 0 0 {name=p27398 lab=_60843_/A }
C {devices/lab_pin.sym} 27400 -2120 0 0 {name=p27399 lab=_61071_/A }
C {devices/lab_pin.sym} 27400 -2080 0 0 {name=p27400 lab=_59602_/A }
C {devices/lab_pin.sym} 27400 -2040 0 0 {name=p27401 lab=_60406_/B }
C {devices/lab_pin.sym} 27520 -2100 0 1 {name=p27402 lab=_60843_/X }
C {sky130_stdcells/and4_4.sym} 27460 -2100 0 0 {name=X_60843_ }
C {devices/lab_pin.sym} 27400 -1960 0 0 {name=p27403 lab=_79385_/A }
C {devices/lab_pin.sym} 27400 -1920 0 0 {name=p27404 lab=_79385_/B }
C {devices/lab_pin.sym} 27520 -1940 0 1 {name=p27405 lab=_79391_/B }
C {sky130_stdcells/xor2_4.sym} 27460 -1940 0 0 {name=X_79385_ }
C {devices/lab_pin.sym} 27420 -1810 0 0 {name=p27406 lab=_62094_/D }
C {devices/lab_pin.sym} 27500 -1810 0 1 {name=p27407 lab=_63280_/B }
C {sky130_stdcells/buf_2.sym} 27460 -1810 0 0 {name=X_45777_ }
C {devices/lab_pin.sym} 27400 -1710 0 0 {name=p27408 lab=_76593_/Y }
C {devices/lab_pin.sym} 27400 -1670 0 0 {name=p27409 lab=_76597_/B }
C {devices/lab_pin.sym} 27400 -1630 0 0 {name=p27410 lab=_76596_/Y }
C {devices/lab_pin.sym} 27520 -1670 0 1 {name=p27411 lab=_76597_/X }
C {sky130_stdcells/or3_4.sym} 27460 -1670 0 0 {name=X_76597_ }
C {devices/lab_pin.sym} 27420 -1530 0 0 {name=p27412 lab=_42988_/Y }
C {devices/lab_pin.sym} 27500 -1530 0 1 {name=p27413 lab=_87617_/D }
C {sky130_stdcells/inv_2.sym} 27460 -1530 0 0 {name=X_42989_ }
C {devices/lab_pin.sym} 27420 -1410 0 0 {name=p27414 lab=_47516_/A }
C {devices/lab_pin.sym} 27500 -1410 0 1 {name=p27415 lab=_53095_/B }
C {sky130_stdcells/buf_2.sym} 27460 -1410 0 0 {name=X_47516_ }
C {devices/lab_pin.sym} 27400 -1300 0 0 {name=p27416 lab=_64923_/A }
C {devices/lab_pin.sym} 27400 -1260 0 0 {name=p27417 lab=_86562_/Q }
C {devices/lab_pin.sym} 27520 -1280 0 1 {name=p27418 lab=_66350_/X }
C {sky130_stdcells/and2_4.sym} 27460 -1280 0 0 {name=X_66350_ }
C {devices/lab_pin.sym} 27380 -1170 0 0 {name=p27419 lab=_78337_/C }
C {devices/lab_pin.sym} 27380 -1130 0 0 {name=p27420 lab=_78334_/Y }
C {devices/lab_pin.sym} 27380 -1090 0 0 {name=p27421 lab=_78335_/Y }
C {devices/lab_pin.sym} 27540 -1130 0 1 {name=p27422 lab=_78339_/A }
C {sky130_stdcells/a21oi_4.sym} 27460 -1130 0 0 {name=X_78336_ }
C {devices/lab_pin.sym} 27380 -1030 0 0 {name=p27423 lab=_44707_/X }
C {devices/lab_pin.sym} 27380 -990 0 0 {name=p27424 lab=_44708_/X }
C {devices/lab_pin.sym} 27380 -950 0 0 {name=p27425 lab=_40716_/A }
C {devices/lab_pin.sym} 27380 -910 0 0 {name=p27426 lab=_44727_/Y }
C {devices/lab_pin.sym} 27380 -870 0 0 {name=p27427 lab=_44710_/X }
C {devices/lab_pin.sym} 27540 -950 0 1 {name=p27428 lab=_86984_/D }
C {sky130_stdcells/o32ai_4.sym} 27460 -950 0 0 {name=X_44728_ }
C {devices/lab_pin.sym} 27400 -810 0 0 {name=p27429 lab=_63562_/A }
C {devices/lab_pin.sym} 27400 -770 0 0 {name=p27430 lab=_60712_/B }
C {devices/lab_pin.sym} 27400 -730 0 0 {name=p27431 lab=_60739_/X }
C {devices/lab_pin.sym} 27520 -770 0 1 {name=p27432 lab=_63562_/Y }
C {sky130_stdcells/nor3_4.sym} 27460 -770 0 0 {name=X_63562_ }
C {devices/lab_pin.sym} 28320 -42160 0 0 {name=p27433 lab=_75547_/Y }
C {devices/lab_pin.sym} 28320 -42120 0 0 {name=p27434 lab=_75544_/X }
C {devices/lab_pin.sym} 28440 -42140 0 1 {name=p27435 lab=_75562_/A }
C {sky130_stdcells/nand2_4.sym} 28380 -42140 0 0 {name=X_75548_ }
C {devices/lab_pin.sym} 28320 -42020 0 0 {name=p27436 lab=_48495_/Y }
C {devices/lab_pin.sym} 28320 -41980 0 0 {name=p27437 lab=_48485_/B }
C {devices/lab_pin.sym} 28440 -42000 0 1 {name=p27438 lab=_48496_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -42000 0 0 {name=X_48496_ }
C {devices/lab_pin.sym} 28300 -41910 0 0 {name=p27439 lab=_63374_/A }
C {devices/lab_pin.sym} 28300 -41870 0 0 {name=p27440 lab=_60758_/X }
C {devices/lab_pin.sym} 28300 -41830 0 0 {name=p27441 lab=_60773_/Y }
C {devices/lab_pin.sym} 28300 -41790 0 0 {name=p27442 lab=_84570_/Q }
C {devices/lab_pin.sym} 28300 -41750 0 0 {name=p27443 lab=_60341_/X }
C {devices/lab_pin.sym} 28460 -41830 0 1 {name=p27444 lab=_60774_/X }
C {sky130_stdcells/o32a_4.sym} 28380 -41830 0 0 {name=X_60774_ }
C {devices/lab_pin.sym} 28340 -41670 0 0 {name=p27445 lab=_64642_/A }
C {devices/lab_pin.sym} 28420 -41670 0 1 {name=p27446 lab=_65301_/X }
C {sky130_stdcells/buf_2.sym} 28380 -41670 0 0 {name=X_65301_ }
C {devices/lab_pin.sym} 28320 -41570 0 0 {name=p27447 lab=_62483_/X }
C {devices/lab_pin.sym} 28320 -41530 0 0 {name=p27448 lab=_62541_/B }
C {devices/lab_pin.sym} 28320 -41490 0 0 {name=p27449 lab=_76981_/B }
C {devices/lab_pin.sym} 28440 -41530 0 1 {name=p27450 lab=_62513_/Y }
C {sky130_stdcells/nor3_4.sym} 28380 -41530 0 0 {name=X_62513_ }
C {devices/lab_pin.sym} 28340 -41390 0 0 {name=p27451 lab=_54743_/D }
C {devices/lab_pin.sym} 28420 -41390 0 1 {name=p27452 lab=_53052_/D }
C {sky130_stdcells/buf_2.sym} 28380 -41390 0 0 {name=X_47447_ }
C {devices/lab_pin.sym} 28300 -41290 0 0 {name=p27453 lab=_66277_/Y }
C {devices/lab_pin.sym} 28300 -41250 0 0 {name=p27454 lab=_66278_/X }
C {devices/lab_pin.sym} 28300 -41210 0 0 {name=p27455 lab=_66280_/X }
C {devices/lab_pin.sym} 28460 -41250 0 1 {name=p27456 lab=_84144_/D }
C {sky130_stdcells/a21o_4.sym} 28380 -41250 0 0 {name=X_66281_ }
C {sky130_stdcells/decap_3.sym} 28380 -41080 0 0 {name=XPHY_0 }
C {devices/lab_pin.sym} 28300 -40950 0 0 {name=p27457 lab=_78250_/A }
C {devices/lab_pin.sym} 28300 -40910 0 0 {name=p27458 lab=_78265_/Y }
C {devices/lab_pin.sym} 28300 -40870 0 0 {name=p27459 lab=_78266_/Y }
C {devices/lab_pin.sym} 28460 -40910 0 1 {name=p27460 lab=_78282_/A }
C {sky130_stdcells/a21o_4.sym} 28380 -40910 0 0 {name=X_78267_ }
C {devices/lab_pin.sym} 28340 -40770 0 0 {name=p27461 lab=_44567_/A }
C {devices/lab_pin.sym} 28420 -40770 0 1 {name=p27462 lab=_44659_/X }
C {sky130_stdcells/buf_2.sym} 28380 -40770 0 0 {name=X_44659_ }
C {devices/lab_pin.sym} 28320 -40670 0 0 {name=p27463 lab=_63517_/A }
C {devices/lab_pin.sym} 28320 -40630 0 0 {name=p27464 lab=_63517_/B }
C {devices/lab_pin.sym} 28320 -40590 0 0 {name=p27465 lab=_63493_/C }
C {devices/lab_pin.sym} 28440 -40630 0 1 {name=p27466 lab=_63493_/Y }
C {sky130_stdcells/nor3_4.sym} 28380 -40630 0 0 {name=X_63493_ }
C {devices/lab_pin.sym} 28300 -40510 0 0 {name=p27467 lab=_75457_/A }
C {devices/lab_pin.sym} 28300 -40470 0 0 {name=p27468 lab=_75457_/B }
C {devices/lab_pin.sym} 28300 -40430 0 0 {name=p27469 lab=_75456_/A }
C {devices/lab_pin.sym} 28460 -40470 0 1 {name=p27470 lab=_75479_/X }
C {sky130_stdcells/o21a_4.sym} 28380 -40470 0 0 {name=X_75479_ }
C {devices/lab_pin.sym} 28320 -40340 0 0 {name=p27471 lab=_68044_/A }
C {devices/lab_pin.sym} 28320 -40300 0 0 {name=p27472 lab=_68020_/B }
C {devices/lab_pin.sym} 28440 -40320 0 1 {name=p27473 lab=_68020_/X }
C {sky130_stdcells/and2_4.sym} 28380 -40320 0 0 {name=X_68020_ }
C {devices/lab_pin.sym} 28300 -40220 0 0 {name=p27474 lab=_65099_/X }
C {devices/lab_pin.sym} 28300 -40180 0 0 {name=p27475 lab=_83289_/Q }
C {devices/lab_pin.sym} 28300 -40140 0 0 {name=p27476 lab=_65230_/X }
C {devices/lab_pin.sym} 28300 -40100 0 0 {name=p27477 lab=_65231_/X }
C {devices/lab_pin.sym} 28460 -40160 0 1 {name=p27478 lab=_65233_/B }
C {sky130_stdcells/a211o_4.sym} 28380 -40160 0 0 {name=X_65232_ }
C {devices/lab_pin.sym} 28300 -40030 0 0 {name=p27479 lab=_77216_/Y }
C {devices/lab_pin.sym} 28300 -39990 0 0 {name=p27480 lab=_77212_/Y }
C {devices/lab_pin.sym} 28300 -39950 0 0 {name=p27481 lab=_77217_/Y }
C {devices/lab_pin.sym} 28460 -39990 0 1 {name=p27482 lab=_77219_/B }
C {sky130_stdcells/o21ai_4.sym} 28380 -39990 0 0 {name=X_77218_ }
C {devices/lab_pin.sym} 28320 -39880 0 0 {name=p27483 lab=_62415_/X }
C {devices/lab_pin.sym} 28320 -39840 0 0 {name=p27484 lab=_61980_/A }
C {devices/lab_pin.sym} 28320 -39800 0 0 {name=p27485 lab=_62618_/D }
C {devices/lab_pin.sym} 28320 -39760 0 0 {name=p27486 lab=_62194_/D }
C {devices/lab_pin.sym} 28440 -39820 0 1 {name=p27487 lab=_62444_/X }
C {sky130_stdcells/and4_4.sym} 28380 -39820 0 0 {name=X_62444_ }
C {devices/lab_pin.sym} 28340 -39670 0 0 {name=p27488 lab=_47378_/A }
C {devices/lab_pin.sym} 28420 -39670 0 1 {name=p27489 lab=_47379_/A }
C {sky130_stdcells/inv_2.sym} 28380 -39670 0 0 {name=X_47378_ }
C {devices/lab_pin.sym} 28320 -39560 0 0 {name=p27490 lab=_78198_/A }
C {devices/lab_pin.sym} 28320 -39520 0 0 {name=p27491 lab=_82491_/Q }
C {devices/lab_pin.sym} 28440 -39540 0 1 {name=p27492 lab=_78204_/B }
C {sky130_stdcells/xor2_4.sym} 28380 -39540 0 0 {name=X_78198_ }
C {devices/lab_pin.sym} 28320 -39420 0 0 {name=p27493 lab=_49117_/A }
C {devices/lab_pin.sym} 28320 -39380 0 0 {name=p27494 lab=_50169_/B }
C {devices/lab_pin.sym} 28440 -39400 0 1 {name=p27495 lab=_49117_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -39400 0 0 {name=X_49117_ }
C {devices/lab_pin.sym} 28300 -39290 0 0 {name=p27496 lab=_46262_/X }
C {devices/lab_pin.sym} 28300 -39250 0 0 {name=p27497 lab=_48947_/A }
C {devices/lab_pin.sym} 28300 -39210 0 0 {name=p27498 lab=_46328_/X }
C {devices/lab_pin.sym} 28460 -39250 0 1 {name=p27499 lab=_46330_/A }
C {sky130_stdcells/o21ai_4.sym} 28380 -39250 0 0 {name=X_46329_ }
C {devices/lab_pin.sym} 28340 -39110 0 0 {name=p27500 lab=_64683_/A }
C {devices/lab_pin.sym} 28420 -39110 0 1 {name=p27501 lab=_65631_/B }
C {sky130_stdcells/buf_2.sym} 28380 -39110 0 0 {name=X_65163_ }
C {devices/lab_pin.sym} 28320 -39000 0 0 {name=p27502 lab=_77149_/A }
C {devices/lab_pin.sym} 28320 -38960 0 0 {name=p27503 lab=_81918_/Q }
C {devices/lab_pin.sym} 28440 -38980 0 1 {name=p27504 lab=_77149_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -38980 0 0 {name=X_77149_ }
C {devices/lab_pin.sym} 28320 -38870 0 0 {name=p27505 lab=_62319_/A }
C {devices/lab_pin.sym} 28320 -38830 0 0 {name=p27506 lab=_63496_/B }
C {devices/lab_pin.sym} 28320 -38790 0 0 {name=p27507 lab=_62375_/C }
C {devices/lab_pin.sym} 28440 -38830 0 1 {name=p27508 lab=_62378_/C }
C {sky130_stdcells/nand3_4.sym} 28380 -38830 0 0 {name=X_62375_ }
C {devices/lab_pin.sym} 28320 -38700 0 0 {name=p27509 lab=_84873_/Q }
C {devices/lab_pin.sym} 28320 -38660 0 0 {name=p27510 lab=_64136_/B }
C {devices/lab_pin.sym} 28440 -38680 0 1 {name=p27511 lab=_64114_/X }
C {sky130_stdcells/or2_4.sym} 28380 -38680 0 0 {name=X_64114_ }
C {devices/lab_pin.sym} 28320 -38570 0 0 {name=p27512 lab=_59834_/A }
C {devices/lab_pin.sym} 28320 -38530 0 0 {name=p27513 lab=_61587_/B }
C {devices/lab_pin.sym} 28320 -38490 0 0 {name=p27514 lab=_84489_/Q }
C {devices/lab_pin.sym} 28440 -38530 0 1 {name=p27515 lab=_61326_/X }
C {sky130_stdcells/or3_4.sym} 28380 -38530 0 0 {name=X_61326_ }
C {devices/lab_pin.sym} 28320 -38400 0 0 {name=p27516 lab=_49048_/A }
C {devices/lab_pin.sym} 28320 -38360 0 0 {name=p27517 lab=_49048_/B }
C {devices/lab_pin.sym} 28440 -38380 0 1 {name=p27518 lab=_50645_/A }
C {sky130_stdcells/nor2_4.sym} 28380 -38380 0 0 {name=X_49048_ }
C {devices/lab_pin.sym} 28300 -38270 0 0 {name=p27519 lab=_80147_/X }
C {devices/lab_pin.sym} 28300 -38230 0 0 {name=p27520 lab=_80158_/X }
C {devices/lab_pin.sym} 28300 -38190 0 0 {name=p27521 lab=_80159_/X }
C {devices/lab_pin.sym} 28460 -38230 0 1 {name=p27522 lab=_80160_/Y }
C {sky130_stdcells/a21oi_4.sym} 28380 -38230 0 0 {name=X_80160_ }
C {devices/lab_pin.sym} 28320 -38100 0 0 {name=p27523 lab=_64946_/A }
C {devices/lab_pin.sym} 28320 -38060 0 0 {name=p27524 lab=_65094_/B }
C {devices/lab_pin.sym} 28440 -38080 0 1 {name=p27525 lab=_65094_/X }
C {sky130_stdcells/and2_4.sym} 28380 -38080 0 0 {name=X_65094_ }
C {devices/lab_pin.sym} 28300 -37970 0 0 {name=p27526 lab=_69968_/X }
C {devices/lab_pin.sym} 28300 -37930 0 0 {name=p27527 lab=_69970_/X }
C {devices/lab_pin.sym} 28300 -37890 0 0 {name=p27528 lab=_66547_/X }
C {devices/lab_pin.sym} 28460 -37930 0 1 {name=p27529 lab=_69971_/X }
C {sky130_stdcells/a21o_4.sym} 28380 -37930 0 0 {name=X_69971_ }
C {devices/lab_pin.sym} 28340 -37790 0 0 {name=p27530 lab=_64045_/A }
C {devices/lab_pin.sym} 28420 -37790 0 1 {name=p27531 lab=_64045_/X }
C {sky130_stdcells/buf_2.sym} 28380 -37790 0 0 {name=X_64045_ }
C {devices/lab_pin.sym} 28340 -37670 0 0 {name=p27532 lab=_69035_/A }
C {devices/lab_pin.sym} 28420 -37670 0 1 {name=p27533 lab=_68922_/X }
C {sky130_stdcells/buf_2.sym} 28380 -37670 0 0 {name=X_68922_ }
C {devices/lab_pin.sym} 28300 -37590 0 0 {name=p27534 lab=_64689_/A }
C {devices/lab_pin.sym} 28300 -37550 0 0 {name=p27535 lab=_72604_/B }
C {devices/lab_pin.sym} 28300 -37510 0 0 {name=p27536 lab=_75898_/A }
C {devices/lab_pin.sym} 28300 -37470 0 0 {name=p27537 lab=_61218_/Y }
C {devices/lab_pin.sym} 28300 -37430 0 0 {name=p27538 lab=_61256_/Y }
C {devices/lab_pin.sym} 28460 -37510 0 1 {name=p27539 lab=_61258_/A }
C {sky130_stdcells/o32ai_4.sym} 28380 -37510 0 0 {name=X_61257_ }
C {devices/lab_pin.sym} 28340 -37350 0 0 {name=p27540 lab=clkbuf_7_55_0_CLK/A }
C {devices/lab_pin.sym} 28420 -37350 0 1 {name=p27541 lab=clkbuf_7_54_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 28380 -37350 0 0 {name=Xclkbuf_7_54_0_CLK }
C {devices/lab_pin.sym} 28320 -37240 0 0 {name=p27542 lab=_80091_/A }
C {devices/lab_pin.sym} 28320 -37200 0 0 {name=p27543 lab=_63995_/C }
C {devices/lab_pin.sym} 28440 -37220 0 1 {name=p27544 lab=_80091_/X }
C {sky130_stdcells/xor2_4.sym} 28380 -37220 0 0 {name=X_80091_ }
C {devices/lab_pin.sym} 28340 -37090 0 0 {name=p27545 lab=_51010_/A }
C {devices/lab_pin.sym} 28420 -37090 0 1 {name=p27546 lab=_51039_/A }
C {sky130_stdcells/buf_2.sym} 28380 -37090 0 0 {name=X_51010_ }
C {devices/lab_pin.sym} 28340 -36970 0 0 {name=p27547 lab=clkbuf_7_97_0_CLK/X }
C {devices/lab_pin.sym} 28420 -36970 0 1 {name=p27548 lab=clkbuf_9_389_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 28380 -36970 0 0 {name=Xclkbuf_8_194_0_CLK }
C {devices/lab_pin.sym} 28300 -36890 0 0 {name=p27549 lab=_60387_/A }
C {devices/lab_pin.sym} 28300 -36850 0 0 {name=p27550 lab=_60164_/Y }
C {devices/lab_pin.sym} 28300 -36810 0 0 {name=p27551 lab=_60166_/X }
C {devices/lab_pin.sym} 28300 -36770 0 0 {name=p27552 lab=_61316_/A }
C {devices/lab_pin.sym} 28300 -36730 0 0 {name=p27553 lab=_60174_/X }
C {devices/lab_pin.sym} 28460 -36810 0 1 {name=p27554 lab=_62644_/A }
C {sky130_stdcells/a32oi_4.sym} 28380 -36810 0 0 {name=X_60208_ }
C {devices/lab_pin.sym} 28320 -36660 0 0 {name=p27555 lab=_68785_/A }
C {devices/lab_pin.sym} 28320 -36620 0 0 {name=p27556 lab=_88256_/Q }
C {devices/lab_pin.sym} 28440 -36640 0 1 {name=p27557 lab=_68853_/X }
C {sky130_stdcells/and2_4.sym} 28380 -36640 0 0 {name=X_68853_ }
C {devices/lab_pin.sym} 28320 -36530 0 0 {name=p27558 lab=_61105_/X }
C {devices/lab_pin.sym} 28320 -36490 0 0 {name=p27559 lab=_61188_/B }
C {devices/lab_pin.sym} 28320 -36450 0 0 {name=p27560 lab=_61188_/C }
C {devices/lab_pin.sym} 28440 -36490 0 1 {name=p27561 lab=_61188_/Y }
C {sky130_stdcells/nand3_4.sym} 28380 -36490 0 0 {name=X_61188_ }
C {devices/lab_pin.sym} 28300 -36380 0 0 {name=p27562 lab=_67782_/X }
C {devices/lab_pin.sym} 28300 -36340 0 0 {name=p27563 lab=_67792_/Y }
C {devices/lab_pin.sym} 28300 -36300 0 0 {name=p27564 lab=_67747_/X }
C {devices/lab_pin.sym} 28300 -36260 0 0 {name=p27565 lab=_67803_/Y }
C {devices/lab_pin.sym} 28460 -36320 0 1 {name=p27566 lab=_67804_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -36320 0 0 {name=X_67804_ }
C {devices/lab_pin.sym} 28320 -36190 0 0 {name=p27567 lab=_60125_/A }
C {devices/lab_pin.sym} 28320 -36150 0 0 {name=p27568 lab=_60214_/B }
C {devices/lab_pin.sym} 28320 -36110 0 0 {name=p27569 lab=_60139_/C }
C {devices/lab_pin.sym} 28440 -36150 0 1 {name=p27570 lab=_60139_/Y }
C {sky130_stdcells/nor3_4.sym} 28380 -36150 0 0 {name=X_60139_ }
C {devices/lab_pin.sym} 28290 -36010 0 0 {name=p27571 lab=_82536_/CLK }
C {devices/lab_pin.sym} 28290 -35990 0 0 {name=p27572 lab=_70097_/X }
C {devices/lab_pin.sym} 28470 -36010 0 1 {name=p27573 lab=_82530_/D }
C {sky130_stdcells/dfxtp_4.sym} 28380 -36000 0 0 {name=X_83850_ }
C {devices/lab_pin.sym} 28340 -35870 0 0 {name=p27574 lab=_69014_/A }
C {devices/lab_pin.sym} 28420 -35870 0 1 {name=p27575 lab=_68785_/A }
C {sky130_stdcells/buf_2.sym} 28380 -35870 0 0 {name=X_68784_ }
C {devices/lab_pin.sym} 28300 -35770 0 0 {name=p27576 lab=_65993_/X }
C {devices/lab_pin.sym} 28300 -35730 0 0 {name=p27577 lab=_65995_/X }
C {devices/lab_pin.sym} 28300 -35690 0 0 {name=p27578 lab=_65880_/X }
C {devices/lab_pin.sym} 28460 -35730 0 1 {name=p27579 lab=_65999_/A }
C {sky130_stdcells/a21o_4.sym} 28380 -35730 0 0 {name=X_65996_ }
C {devices/lab_pin.sym} 28290 -35590 0 0 {name=p27580 lab=_82833_/CLK }
C {devices/lab_pin.sym} 28290 -35570 0 0 {name=p27581 lab=_82833_/Q }
C {devices/lab_pin.sym} 28470 -35590 0 1 {name=p27582 lab=_82801_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -35580 0 0 {name=X_82801_ }
C {devices/lab_pin.sym} 28340 -35450 0 0 {name=p27583 lab=clkbuf_7_69_0_CLK/A }
C {devices/lab_pin.sym} 28420 -35450 0 1 {name=p27584 lab=clkbuf_7_69_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 28380 -35450 0 0 {name=Xclkbuf_7_69_0_CLK }
C {devices/lab_pin.sym} 28300 -35360 0 0 {name=p27585 lab=_67496_/X }
C {devices/lab_pin.sym} 28300 -35320 0 0 {name=p27586 lab=_67726_/Y }
C {devices/lab_pin.sym} 28300 -35280 0 0 {name=p27587 lab=_67624_/X }
C {devices/lab_pin.sym} 28300 -35240 0 0 {name=p27588 lab=_67734_/Y }
C {devices/lab_pin.sym} 28460 -35300 0 1 {name=p27589 lab=_67735_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -35300 0 0 {name=X_67735_ }
C {devices/lab_pin.sym} 28340 -35150 0 0 {name=p27590 lab=_53097_/A }
C {devices/lab_pin.sym} 28420 -35150 0 1 {name=p27591 lab=_53069_/A }
C {sky130_stdcells/buf_2.sym} 28380 -35150 0 0 {name=X_52961_ }
C {devices/lab_pin.sym} 28300 -35060 0 0 {name=p27592 lab=_64944_/X }
C {devices/lab_pin.sym} 28300 -35020 0 0 {name=p27593 lab=_86164_/Q }
C {devices/lab_pin.sym} 28300 -34980 0 0 {name=p27594 lab=_64766_/X }
C {devices/lab_pin.sym} 28300 -34940 0 0 {name=p27595 lab=_64946_/X }
C {devices/lab_pin.sym} 28460 -35000 0 1 {name=p27596 lab=_64947_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -35000 0 0 {name=X_64947_ }
C {devices/lab_pin.sym} 28290 -34850 0 0 {name=p27597 lab=_85953_/CLK }
C {devices/lab_pin.sym} 28290 -34830 0 0 {name=p27598 lab=_70390_/Y }
C {devices/lab_pin.sym} 28470 -34850 0 1 {name=p27599 lab=_83781_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -34840 0 0 {name=X_83781_ }
C {devices/lab_pin.sym} 28290 -34710 0 0 {name=p27600 lab=_81990_/CLK }
C {devices/lab_pin.sym} 28290 -34690 0 0 {name=p27601 lab=_75880_/Y }
C {devices/lab_pin.sym} 28470 -34710 0 1 {name=p27602 lab=_80949_/D }
C {sky130_stdcells/dfxtp_4.sym} 28380 -34700 0 0 {name=X_80993_ }
C {devices/lab_pin.sym} 28340 -34570 0 0 {name=p27603 lab=_54672_/X }
C {devices/lab_pin.sym} 28420 -34570 0 1 {name=p27604 lab=_54721_/C }
C {sky130_stdcells/buf_2.sym} 28380 -34570 0 0 {name=X_54700_ }
C {devices/lab_pin.sym} 28290 -34450 0 0 {name=p27605 lab=_86246_/CLK }
C {devices/lab_pin.sym} 28290 -34430 0 0 {name=p27606 lab=_54027_/Y }
C {devices/lab_pin.sym} 28470 -34450 0 1 {name=p27607 lab=_85520_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -34440 0 0 {name=X_85520_ }
C {devices/lab_pin.sym} 28300 -34330 0 0 {name=p27608 lab=_85923_/Q }
C {devices/lab_pin.sym} 28300 -34290 0 0 {name=p27609 lab=_51900_/X }
C {devices/lab_pin.sym} 28300 -34250 0 0 {name=p27610 lab=_51911_/Y }
C {devices/lab_pin.sym} 28460 -34290 0 1 {name=p27611 lab=_51912_/Y }
C {sky130_stdcells/o21ai_4.sym} 28380 -34290 0 0 {name=X_51912_ }
C {devices/lab_pin.sym} 28290 -34150 0 0 {name=p27612 lab=_82692_/CLK }
C {devices/lab_pin.sym} 28290 -34130 0 0 {name=p27613 lab=_84116_/Q }
C {devices/lab_pin.sym} 28470 -34150 0 1 {name=p27614 lab=_82732_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -34140 0 0 {name=X_82732_ }
C {devices/lab_pin.sym} 28300 -34040 0 0 {name=p27615 lab=_87973_/Q }
C {devices/lab_pin.sym} 28300 -34000 0 0 {name=p27616 lab=_67591_/X }
C {devices/lab_pin.sym} 28300 -33960 0 0 {name=p27617 lab=_67641_/X }
C {devices/lab_pin.sym} 28300 -33920 0 0 {name=p27618 lab=_67665_/X }
C {devices/lab_pin.sym} 28460 -33980 0 1 {name=p27619 lab=_67666_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -33980 0 0 {name=X_67666_ }
C {devices/lab_pin.sym} 28320 -33840 0 0 {name=p27620 lab=_55290_/Y }
C {devices/lab_pin.sym} 28320 -33800 0 0 {name=p27621 lab=_55680_/B }
C {devices/lab_pin.sym} 28440 -33820 0 1 {name=p27622 lab=_55680_/Y }
C {sky130_stdcells/nor2_4.sym} 28380 -33820 0 0 {name=X_55680_ }
C {devices/lab_pin.sym} 28340 -33690 0 0 {name=p27623 lab=_52892_/A }
C {devices/lab_pin.sym} 28420 -33690 0 1 {name=p27624 lab=_52892_/X }
C {sky130_stdcells/buf_2.sym} 28380 -33690 0 0 {name=X_52892_ }
C {devices/lab_pin.sym} 28320 -33580 0 0 {name=p27625 lab=_64877_/X }
C {devices/lab_pin.sym} 28320 -33540 0 0 {name=p27626 lab=_86423_/Q }
C {devices/lab_pin.sym} 28440 -33560 0 1 {name=p27627 lab=_64878_/X }
C {sky130_stdcells/and2_4.sym} 28380 -33560 0 0 {name=X_64878_ }
C {devices/lab_pin.sym} 28340 -33430 0 0 {name=p27628 lab=_69733_/A }
C {devices/lab_pin.sym} 28420 -33430 0 1 {name=p27629 lab=_69405_/X }
C {sky130_stdcells/buf_2.sym} 28380 -33430 0 0 {name=X_69405_ }
C {devices/lab_pin.sym} 28300 -33330 0 0 {name=p27630 lab=_54628_/Y }
C {devices/lab_pin.sym} 28300 -33290 0 0 {name=p27631 lab=_54611_/X }
C {devices/lab_pin.sym} 28300 -33250 0 0 {name=p27632 lab=_54630_/X }
C {devices/lab_pin.sym} 28460 -33290 0 1 {name=p27633 lab=_54631_/Y }
C {sky130_stdcells/a21oi_4.sym} 28380 -33290 0 0 {name=X_54631_ }
C {devices/lab_pin.sym} 28290 -33150 0 0 {name=p27634 lab=_85773_/CLK }
C {devices/lab_pin.sym} 28290 -33130 0 0 {name=p27635 lab=_85451_/D }
C {devices/lab_pin.sym} 28470 -33150 0 1 {name=p27636 lab=_85451_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -33140 0 0 {name=X_85451_ }
C {devices/lab_pin.sym} 28300 -33040 0 0 {name=p27637 lab=_87889_/Q }
C {devices/lab_pin.sym} 28300 -33000 0 0 {name=p27638 lab=_66529_/X }
C {devices/lab_pin.sym} 28300 -32960 0 0 {name=p27639 lab=_66531_/X }
C {devices/lab_pin.sym} 28300 -32920 0 0 {name=p27640 lab=_66616_/X }
C {devices/lab_pin.sym} 28460 -32980 0 1 {name=p27641 lab=_66617_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -32980 0 0 {name=X_66617_ }
C {devices/lab_pin.sym} 28340 -32830 0 0 {name=p27642 lab=_51843_/A }
C {devices/lab_pin.sym} 28420 -32830 0 1 {name=p27643 lab=_51851_/B }
C {sky130_stdcells/buf_2.sym} 28380 -32830 0 0 {name=X_51843_ }
C {devices/lab_pin.sym} 28340 -32710 0 0 {name=p27644 lab=_63734_/A }
C {devices/lab_pin.sym} 28420 -32710 0 1 {name=p27645 lab=_64184_/A }
C {sky130_stdcells/buf_2.sym} 28380 -32710 0 0 {name=X_63829_ }
C {devices/lab_pin.sym} 28290 -32590 0 0 {name=p27646 lab=_82665_/CLK }
C {devices/lab_pin.sym} 28290 -32570 0 0 {name=p27647 lab=_82663_/D }
C {devices/lab_pin.sym} 28470 -32590 0 1 {name=p27648 lab=_78112_/A }
C {sky130_stdcells/dfxtp_4.sym} 28380 -32580 0 0 {name=X_82663_ }
C {devices/lab_pin.sym} 28300 -32480 0 0 {name=p27649 lab=_87464_/Q }
C {devices/lab_pin.sym} 28300 -32440 0 0 {name=p27650 lab=_67594_/X }
C {devices/lab_pin.sym} 28300 -32400 0 0 {name=p27651 lab=_67595_/X }
C {devices/lab_pin.sym} 28300 -32360 0 0 {name=p27652 lab=_67596_/X }
C {devices/lab_pin.sym} 28460 -32420 0 1 {name=p27653 lab=_67597_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -32420 0 0 {name=X_67597_ }
C {devices/lab_pin.sym} 28290 -32270 0 0 {name=p27654 lab=_84293_/CLK }
C {devices/lab_pin.sym} 28290 -32250 0 0 {name=p27655 lab=_62555_/Y }
C {devices/lab_pin.sym} 28470 -32270 0 1 {name=p27656 lab=_84402_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -32260 0 0 {name=X_84402_ }
C {devices/lab_pin.sym} 28340 -32130 0 0 {name=p27657 lab=clkbuf_7_66_0_CLK/X }
C {devices/lab_pin.sym} 28420 -32130 0 1 {name=p27658 lab=clkbuf_8_132_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 28380 -32130 0 0 {name=Xclkbuf_8_132_0_CLK }
C {devices/lab_pin.sym} 28300 -32030 0 0 {name=p27659 lab=_57348_/X }
C {devices/lab_pin.sym} 28300 -31990 0 0 {name=p27660 lab=_57349_/Y }
C {devices/lab_pin.sym} 28300 -31950 0 0 {name=p27661 lab=_57331_/B }
C {devices/lab_pin.sym} 28460 -31990 0 1 {name=p27662 lab=_57351_/B }
C {sky130_stdcells/a21o_4.sym} 28380 -31990 0 0 {name=X_57350_ }
C {devices/lab_pin.sym} 28290 -31850 0 0 {name=p27663 lab=_81296_/CLK }
C {devices/lab_pin.sym} 28290 -31830 0 0 {name=p27664 lab=_76326_/B }
C {devices/lab_pin.sym} 28470 -31850 0 1 {name=p27665 lab=_81614_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -31840 0 0 {name=X_81614_ }
C {devices/lab_pin.sym} 28300 -31740 0 0 {name=p27666 lab=_87025_/Q }
C {devices/lab_pin.sym} 28300 -31700 0 0 {name=p27667 lab=_69239_/X }
C {devices/lab_pin.sym} 28300 -31660 0 0 {name=p27668 lab=_69103_/X }
C {devices/lab_pin.sym} 28300 -31620 0 0 {name=p27669 lab=_69335_/X }
C {devices/lab_pin.sym} 28460 -31680 0 1 {name=p27670 lab=_69336_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -31680 0 0 {name=X_69336_ }
C {devices/lab_pin.sym} 28290 -31530 0 0 {name=p27671 lab=_87471_/CLK }
C {devices/lab_pin.sym} 28290 -31510 0 0 {name=p27672 lab=_88170_/D }
C {devices/lab_pin.sym} 28470 -31530 0 1 {name=p27673 lab=_67563_/B }
C {sky130_stdcells/dfxtp_4.sym} 28380 -31520 0 0 {name=X_88170_ }
C {devices/lab_pin.sym} 28300 -31410 0 0 {name=p27674 lab=_85419_/Q }
C {devices/lab_pin.sym} 28300 -31370 0 0 {name=p27675 lab=_54540_/X }
C {devices/lab_pin.sym} 28300 -31330 0 0 {name=p27676 lab=_54561_/Y }
C {devices/lab_pin.sym} 28460 -31370 0 1 {name=p27677 lab=_54562_/Y }
C {sky130_stdcells/o21ai_4.sym} 28380 -31370 0 0 {name=X_54562_ }
C {devices/lab_pin.sym} 28300 -31250 0 0 {name=p27678 lab=_66536_/X }
C {devices/lab_pin.sym} 28300 -31210 0 0 {name=p27679 lab=_66545_/X }
C {devices/lab_pin.sym} 28300 -31170 0 0 {name=p27680 lab=_66547_/X }
C {devices/lab_pin.sym} 28460 -31210 0 1 {name=p27681 lab=_66548_/X }
C {sky130_stdcells/a21o_4.sym} 28380 -31210 0 0 {name=X_66548_ }
C {devices/lab_pin.sym} 28290 -31070 0 0 {name=p27682 lab=_85379_/CLK }
C {devices/lab_pin.sym} 28290 -31050 0 0 {name=p27683 lab=_85382_/D }
C {devices/lab_pin.sym} 28470 -31070 0 1 {name=p27684 lab=_85382_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -31060 0 0 {name=X_85382_ }
C {devices/lab_pin.sym} 28320 -30940 0 0 {name=p27685 lab=_51779_/A }
C {devices/lab_pin.sym} 28320 -30900 0 0 {name=p27686 lab=_46662_/X }
C {devices/lab_pin.sym} 28440 -30920 0 1 {name=p27687 lab=_51774_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -30920 0 0 {name=X_51774_ }
C {devices/lab_pin.sym} 28290 -30790 0 0 {name=p27688 lab=_82595_/CLK }
C {devices/lab_pin.sym} 28290 -30770 0 0 {name=p27689 lab=_78805_/B }
C {devices/lab_pin.sym} 28470 -30790 0 1 {name=p27690 lab=_82562_/D }
C {sky130_stdcells/dfxtp_4.sym} 28380 -30780 0 0 {name=X_82594_ }
C {devices/lab_pin.sym} 28320 -30670 0 0 {name=p27691 lab=_56296_/A }
C {devices/lab_pin.sym} 28320 -30630 0 0 {name=p27692 lab=_56298_/X }
C {devices/lab_pin.sym} 28320 -30590 0 0 {name=p27693 lab=_85244_/Q }
C {devices/lab_pin.sym} 28440 -30630 0 1 {name=p27694 lab=_56301_/Y }
C {sky130_stdcells/nand3_4.sym} 28380 -30630 0 0 {name=X_56301_ }
C {devices/lab_pin.sym} 28290 -30490 0 0 {name=p27695 lab=_87686_/CLK }
C {devices/lab_pin.sym} 28290 -30470 0 0 {name=p27696 lab=_44414_/X }
C {devices/lab_pin.sym} 28470 -30490 0 1 {name=p27697 lab=_87121_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -30480 0 0 {name=X_87121_ }
C {devices/lab_pin.sym} 28300 -30370 0 0 {name=p27698 lab=_53510_/Y }
C {devices/lab_pin.sym} 28300 -30330 0 0 {name=p27699 lab=_53498_/X }
C {devices/lab_pin.sym} 28300 -30290 0 0 {name=p27700 lab=_53512_/Y }
C {devices/lab_pin.sym} 28460 -30330 0 1 {name=p27701 lab=_53513_/Y }
C {sky130_stdcells/a21boi_4.sym} 28380 -30330 0 0 {name=X_53513_ }
C {devices/lab_pin.sym} 28290 -30190 0 0 {name=p27702 lab=_84333_/CLK }
C {devices/lab_pin.sym} 28290 -30170 0 0 {name=p27703 lab=_63328_/Y }
C {devices/lab_pin.sym} 28470 -30190 0 1 {name=p27704 lab=_79197_/B }
C {sky130_stdcells/dfxtp_4.sym} 28380 -30180 0 0 {name=X_84333_ }
C {devices/lab_pin.sym} 28320 -30070 0 0 {name=p27705 lab=_50209_/A }
C {devices/lab_pin.sym} 28320 -30030 0 0 {name=p27706 lab=_50751_/B }
C {devices/lab_pin.sym} 28320 -29990 0 0 {name=p27707 lab=_50668_/C }
C {devices/lab_pin.sym} 28440 -30030 0 1 {name=p27708 lab=_50725_/X }
C {sky130_stdcells/and3_4.sym} 28380 -30030 0 0 {name=X_50725_ }
C {devices/lab_pin.sym} 28290 -29890 0 0 {name=p27709 lab=_81344_/CLK }
C {devices/lab_pin.sym} 28290 -29870 0 0 {name=p27710 lab=_81545_/D }
C {devices/lab_pin.sym} 28470 -29890 0 1 {name=p27711 lab=_81545_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -29880 0 0 {name=X_81545_ }
C {devices/lab_pin.sym} 28300 -29790 0 0 {name=p27712 lab=_57268_/X }
C {devices/lab_pin.sym} 28300 -29750 0 0 {name=p27713 lab=_57149_/B }
C {devices/lab_pin.sym} 28300 -29710 0 0 {name=p27714 lab=_56733_/X }
C {devices/lab_pin.sym} 28300 -29670 0 0 {name=p27715 lab=_56735_/X }
C {devices/lab_pin.sym} 28300 -29640 0 0 {name=p27716 lab=_57270_/X }
C {devices/lab_pin.sym} 28460 -29710 0 1 {name=p27717 lab=_57281_/X }
C {sky130_stdcells/a41o_4.sym} 28380 -29710 0 0 {name=X_57281_ }
C {devices/lab_pin.sym} 28320 -29560 0 0 {name=p27718 lab=_69264_/X }
C {devices/lab_pin.sym} 28320 -29520 0 0 {name=p27719 lab=_69266_/X }
C {devices/lab_pin.sym} 28440 -29540 0 1 {name=p27720 lab=_69267_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -29540 0 0 {name=X_69267_ }
C {devices/lab_pin.sym} 28340 -29410 0 0 {name=p27721 lab=_54385_/A }
C {devices/lab_pin.sym} 28420 -29410 0 1 {name=p27722 lab=_54503_/B }
C {sky130_stdcells/buf_2.sym} 28380 -29410 0 0 {name=X_54493_ }
C {devices/lab_pin.sym} 28320 -29310 0 0 {name=p27723 lab=_66445_/A }
C {devices/lab_pin.sym} 28320 -29270 0 0 {name=p27724 lab=_66514_/B }
C {devices/lab_pin.sym} 28320 -29230 0 0 {name=p27725 lab=_66478_/Y }
C {devices/lab_pin.sym} 28440 -29270 0 1 {name=p27726 lab=_66479_/Y }
C {sky130_stdcells/nor3_4.sym} 28380 -29270 0 0 {name=X_66479_ }
C {devices/lab_pin.sym} 28300 -29170 0 0 {name=p27727 lab=_58918_/X }
C {devices/lab_pin.sym} 28300 -29130 0 0 {name=p27728 lab=_59018_/Y }
C {devices/lab_pin.sym} 28300 -29090 0 0 {name=p27729 lab=_59019_/Y }
C {devices/lab_pin.sym} 28300 -29050 0 0 {name=p27730 lab=_58959_/X }
C {devices/lab_pin.sym} 28300 -29010 0 0 {name=p27731 lab=_58923_/X }
C {devices/lab_pin.sym} 28460 -29090 0 1 {name=p27732 lab=_59020_/X }
C {sky130_stdcells/o32a_4.sym} 28380 -29090 0 0 {name=X_59020_ }
C {devices/lab_pin.sym} 28340 -28930 0 0 {name=p27733 lab=_56245_/A }
C {devices/lab_pin.sym} 28420 -28930 0 1 {name=p27734 lab=_56243_/B }
C {sky130_stdcells/buf_2.sym} 28380 -28930 0 0 {name=X_56232_ }
C {devices/lab_pin.sym} 28300 -28840 0 0 {name=p27735 lab=_68188_/X }
C {devices/lab_pin.sym} 28300 -28800 0 0 {name=p27736 lab=_67340_/Y }
C {devices/lab_pin.sym} 28300 -28760 0 0 {name=p27737 lab=_68207_/X }
C {devices/lab_pin.sym} 28300 -28720 0 0 {name=p27738 lab=_68217_/Y }
C {devices/lab_pin.sym} 28460 -28780 0 1 {name=p27739 lab=_68218_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -28780 0 0 {name=X_68218_ }
C {devices/lab_pin.sym} 28290 -28630 0 0 {name=p27740 lab=_87813_/CLK }
C {devices/lab_pin.sym} 28290 -28610 0 0 {name=p27741 lab=_44570_/Y }
C {devices/lab_pin.sym} 28470 -28630 0 1 {name=p27742 lab=_87052_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -28620 0 0 {name=X_87052_ }
C {devices/lab_pin.sym} 28300 -28510 0 0 {name=p27743 lab=_53443_/A }
C {devices/lab_pin.sym} 28300 -28470 0 0 {name=p27744 lab=_47829_/A }
C {devices/lab_pin.sym} 28300 -28430 0 0 {name=p27745 lab=_53443_/Y }
C {devices/lab_pin.sym} 28460 -28470 0 1 {name=p27746 lab=_53444_/X }
C {sky130_stdcells/o21a_4.sym} 28380 -28470 0 0 {name=X_53444_ }
C {devices/lab_pin.sym} 28290 -28330 0 0 {name=p27747 lab=_84263_/CLK }
C {devices/lab_pin.sym} 28290 -28310 0 0 {name=p27748 lab=_64232_/X }
C {devices/lab_pin.sym} 28470 -28330 0 1 {name=p27749 lab=_79872_/B }
C {sky130_stdcells/dfxtp_4.sym} 28380 -28320 0 0 {name=X_84264_ }
C {devices/lab_pin.sym} 28340 -28190 0 0 {name=p27750 lab=_50728_/A }
C {devices/lab_pin.sym} 28420 -28190 0 1 {name=p27751 lab=_50657_/A }
C {sky130_stdcells/buf_2.sym} 28380 -28190 0 0 {name=X_50656_ }
C {devices/lab_pin.sym} 28290 -28070 0 0 {name=p27752 lab=_88121_/CLK }
C {devices/lab_pin.sym} 28290 -28050 0 0 {name=p27753 lab=_84044_/Q }
C {devices/lab_pin.sym} 28470 -28070 0 1 {name=p27754 lab=_81476_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -28060 0 0 {name=X_81476_ }
C {devices/lab_pin.sym} 28320 -27940 0 0 {name=p27755 lab=_69195_/X }
C {devices/lab_pin.sym} 28320 -27900 0 0 {name=p27756 lab=_69197_/X }
C {devices/lab_pin.sym} 28440 -27920 0 1 {name=p27757 lab=_69198_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -27920 0 0 {name=X_69198_ }
C {devices/lab_pin.sym} 28340 -27790 0 0 {name=p27758 lab=clkbuf_7_73_0_CLK/X }
C {devices/lab_pin.sym} 28420 -27790 0 1 {name=p27759 lab=clkbuf_9_295_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 28380 -27790 0 0 {name=Xclkbuf_8_147_0_CLK }
C {devices/lab_pin.sym} 28290 -27670 0 0 {name=p27760 lab=_85712_/CLK }
C {devices/lab_pin.sym} 28290 -27650 0 0 {name=p27761 lab=_86003_/D }
C {devices/lab_pin.sym} 28470 -27670 0 1 {name=p27762 lab=_86003_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -27660 0 0 {name=X_86003_ }
C {devices/lab_pin.sym} 28340 -27530 0 0 {name=p27763 lab=clkbuf_9_71_0_CLK/X }
C {devices/lab_pin.sym} 28420 -27530 0 1 {name=p27764 lab=_81811_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 28380 -27530 0 0 {name=Xclkbuf_10_142_0_CLK }
C {devices/lab_pin.sym} 28290 -27410 0 0 {name=p27765 lab=_84350_/CLK }
C {devices/lab_pin.sym} 28290 -27390 0 0 {name=p27766 lab=_72616_/Y }
C {devices/lab_pin.sym} 28470 -27410 0 1 {name=p27767 lab=_79231_/B }
C {sky130_stdcells/dfxtp_4.sym} 28380 -27400 0 0 {name=X_83215_ }
C {devices/lab_pin.sym} 28320 -27280 0 0 {name=p27768 lab=_56163_/A }
C {devices/lab_pin.sym} 28320 -27240 0 0 {name=p27769 lab=_56162_/X }
C {devices/lab_pin.sym} 28440 -27260 0 1 {name=p27770 lab=_56164_/A }
C {sky130_stdcells/xnor2_4.sym} 28380 -27260 0 0 {name=X_56163_ }
C {devices/lab_pin.sym} 28300 -27150 0 0 {name=p27771 lab=_80411_/Y }
C {devices/lab_pin.sym} 28300 -27110 0 0 {name=p27772 lab=_80414_/Y }
C {devices/lab_pin.sym} 28300 -27070 0 0 {name=p27773 lab=_80426_/X }
C {devices/lab_pin.sym} 28460 -27110 0 1 {name=p27774 lab=_80427_/X }
C {sky130_stdcells/a21o_4.sym} 28380 -27110 0 0 {name=X_80427_ }
C {devices/lab_pin.sym} 28300 -26990 0 0 {name=p27775 lab=_66940_/X }
C {devices/lab_pin.sym} 28300 -26950 0 0 {name=p27776 lab=_66943_/X }
C {devices/lab_pin.sym} 28300 -26910 0 0 {name=p27777 lab=_68133_/X }
C {devices/lab_pin.sym} 28460 -26950 0 1 {name=p27778 lab=_68149_/Y }
C {sky130_stdcells/a21oi_4.sym} 28380 -26950 0 0 {name=X_68149_ }
C {devices/lab_pin.sym} 28340 -26810 0 0 {name=p27779 lab=_53347_/A }
C {devices/lab_pin.sym} 28420 -26810 0 1 {name=p27780 lab=_53388_/B }
C {sky130_stdcells/buf_2.sym} 28380 -26810 0 0 {name=X_53375_ }
C {devices/lab_pin.sym} 28290 -26690 0 0 {name=p27781 lab=_84192_/CLK }
C {devices/lab_pin.sym} 28290 -26670 0 0 {name=p27782 lab=_84195_/D }
C {devices/lab_pin.sym} 28470 -26690 0 1 {name=p27783 lab=_65531_/C }
C {sky130_stdcells/dfxtp_4.sym} 28380 -26680 0 0 {name=X_84195_ }
C {devices/lab_pin.sym} 28300 -26570 0 0 {name=p27784 lab=_86172_/Q }
C {devices/lab_pin.sym} 28300 -26530 0 0 {name=p27785 lab=_50563_/X }
C {devices/lab_pin.sym} 28300 -26490 0 0 {name=p27786 lab=_50586_/Y }
C {devices/lab_pin.sym} 28460 -26530 0 1 {name=p27787 lab=_50587_/Y }
C {sky130_stdcells/o21ai_4.sym} 28380 -26530 0 0 {name=X_50587_ }
C {devices/lab_pin.sym} 28340 -26390 0 0 {name=p27788 lab=clkbuf_9_386_0_CLK/X }
C {devices/lab_pin.sym} 28420 -26390 0 1 {name=p27789 lab=_82610_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 28380 -26390 0 0 {name=Xclkbuf_10_772_0_CLK }
C {devices/lab_pin.sym} 28320 -26280 0 0 {name=p27790 lab=_55118_/A }
C {devices/lab_pin.sym} 28320 -26240 0 0 {name=p27791 lab=_47809_/A }
C {devices/lab_pin.sym} 28440 -26260 0 1 {name=p27792 lab=_55114_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -26260 0 0 {name=X_55114_ }
C {devices/lab_pin.sym} 28340 -26130 0 0 {name=p27793 lab=_44362_/A }
C {devices/lab_pin.sym} 28420 -26130 0 1 {name=p27794 lab=_47363_/A }
C {sky130_stdcells/buf_2.sym} 28380 -26130 0 0 {name=X_40340_ }
C {devices/lab_pin.sym} 28320 -26020 0 0 {name=p27795 lab=_52334_/A }
C {devices/lab_pin.sym} 28320 -25980 0 0 {name=p27796 lab=_49006_/X }
C {devices/lab_pin.sym} 28440 -26000 0 1 {name=p27797 lab=_52326_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -26000 0 0 {name=X_52326_ }
C {devices/lab_pin.sym} 28320 -25900 0 0 {name=p27798 lab=_71041_/X }
C {devices/lab_pin.sym} 28320 -25860 0 0 {name=p27799 lab=_71173_/B }
C {devices/lab_pin.sym} 28320 -25820 0 0 {name=p27800 lab=_71160_/C }
C {devices/lab_pin.sym} 28320 -25780 0 0 {name=p27801 lab=_71160_/D }
C {devices/lab_pin.sym} 28440 -25840 0 1 {name=p27802 lab=_71160_/Y }
C {sky130_stdcells/nand4_4.sym} 28380 -25840 0 0 {name=X_71160_ }
C {devices/lab_pin.sym} 28290 -25690 0 0 {name=p27803 lab=_86218_/CLK }
C {devices/lab_pin.sym} 28290 -25670 0 0 {name=p27804 lab=_73548_/X }
C {devices/lab_pin.sym} 28470 -25690 0 1 {name=p27805 lab=_83146_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -25680 0 0 {name=X_83146_ }
C {devices/lab_pin.sym} 28320 -25560 0 0 {name=p27806 lab=_80358_/A }
C {devices/lab_pin.sym} 28320 -25520 0 0 {name=p27807 lab=_80357_/X }
C {devices/lab_pin.sym} 28440 -25540 0 1 {name=p27808 lab=_80358_/Y }
C {sky130_stdcells/xnor2_4.sym} 28380 -25540 0 0 {name=X_80358_ }
C {devices/lab_pin.sym} 28340 -25410 0 0 {name=p27809 lab=_56094_/A }
C {devices/lab_pin.sym} 28420 -25410 0 1 {name=p27810 lab=_56094_/X }
C {sky130_stdcells/buf_2.sym} 28380 -25410 0 0 {name=X_56094_ }
C {devices/lab_pin.sym} 28340 -25290 0 0 {name=p27811 lab=clkbuf_9_262_0_CLK/A }
C {devices/lab_pin.sym} 28420 -25290 0 1 {name=p27812 lab=clkbuf_9_263_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 28380 -25290 0 0 {name=Xclkbuf_9_263_0_CLK }
C {devices/lab_pin.sym} 28340 -25170 0 0 {name=p27813 lab=_83124_/Q }
C {devices/lab_pin.sym} 28420 -25170 0 1 {name=p27814 lab=_70111_/Y }
C {sky130_stdcells/inv_2.sym} 28380 -25170 0 0 {name=X_70111_ }
C {devices/lab_pin.sym} 28300 -25070 0 0 {name=p27815 lab=_55042_/Y }
C {devices/lab_pin.sym} 28300 -25030 0 0 {name=p27816 lab=_55024_/X }
C {devices/lab_pin.sym} 28300 -24990 0 0 {name=p27817 lab=_55044_/X }
C {devices/lab_pin.sym} 28460 -25030 0 1 {name=p27818 lab=_55045_/Y }
C {sky130_stdcells/a21oi_4.sym} 28380 -25030 0 0 {name=X_55045_ }
C {devices/lab_pin.sym} 28320 -24910 0 0 {name=p27819 lab=_60058_/B }
C {devices/lab_pin.sym} 28320 -24870 0 0 {name=p27820 lab=_59913_/X }
C {devices/lab_pin.sym} 28320 -24830 0 0 {name=p27821 lab=_59922_/C }
C {devices/lab_pin.sym} 28440 -24870 0 1 {name=p27822 lab=_59922_/X }
C {sky130_stdcells/and3_4.sym} 28380 -24870 0 0 {name=X_59922_ }
C {devices/lab_pin.sym} 28320 -24740 0 0 {name=p27823 lab=_52188_/A }
C {devices/lab_pin.sym} 28320 -24700 0 0 {name=p27824 lab=_50556_/B }
C {devices/lab_pin.sym} 28440 -24720 0 1 {name=p27825 lab=_52257_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -24720 0 0 {name=X_52257_ }
C {devices/lab_pin.sym} 28320 -24610 0 0 {name=p27826 lab=_71088_/A }
C {devices/lab_pin.sym} 28320 -24570 0 0 {name=p27827 lab=_71091_/B }
C {devices/lab_pin.sym} 28320 -24530 0 0 {name=p27828 lab=_71088_/C }
C {devices/lab_pin.sym} 28440 -24570 0 1 {name=p27829 lab=_71091_/Y }
C {sky130_stdcells/nand3_4.sym} 28380 -24570 0 0 {name=X_71091_ }
C {devices/lab_pin.sym} 28290 -24430 0 0 {name=p27830 lab=_83282_/CLK }
C {devices/lab_pin.sym} 28290 -24410 0 0 {name=p27831 lab=_83077_/D }
C {devices/lab_pin.sym} 28470 -24430 0 1 {name=p27832 lab=_83077_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -24420 0 0 {name=X_83077_ }
C {devices/lab_pin.sym} 28290 -24290 0 0 {name=p27833 lab=_87950_/CLK }
C {devices/lab_pin.sym} 28290 -24270 0 0 {name=p27834 lab=_87954_/D }
C {devices/lab_pin.sym} 28470 -24290 0 1 {name=p27835 lab=_87954_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -24280 0 0 {name=X_87954_ }
C {devices/lab_pin.sym} 28300 -24170 0 0 {name=p27836 lab=_80284_/Y }
C {devices/lab_pin.sym} 28300 -24130 0 0 {name=p27837 lab=_80273_/Y }
C {devices/lab_pin.sym} 28300 -24090 0 0 {name=p27838 lab=_80282_/Y }
C {devices/lab_pin.sym} 28460 -24130 0 1 {name=p27839 lab=_80302_/B }
C {sky130_stdcells/a21oi_4.sym} 28380 -24130 0 0 {name=X_80289_ }
C {devices/lab_pin.sym} 28340 -23990 0 0 {name=p27840 lab=clkbuf_9_78_0_CLK/X }
C {devices/lab_pin.sym} 28420 -23990 0 1 {name=p27841 lab=_81304_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 28380 -23990 0 0 {name=Xclkbuf_10_157_0_CLK }
C {devices/lab_pin.sym} 28340 -23870 0 0 {name=p27842 lab=_41993_/A }
C {devices/lab_pin.sym} 28420 -23870 0 1 {name=p27843 lab=_42010_/X }
C {sky130_stdcells/buf_2.sym} 28380 -23870 0 0 {name=X_42010_ }
C {devices/lab_pin.sym} 28300 -23770 0 0 {name=p27844 lab=_51206_/Y }
C {devices/lab_pin.sym} 28300 -23730 0 0 {name=p27845 lab=_51201_/X }
C {devices/lab_pin.sym} 28300 -23690 0 0 {name=p27846 lab=_51207_/X }
C {devices/lab_pin.sym} 28460 -23730 0 1 {name=p27847 lab=_51208_/Y }
C {sky130_stdcells/a21oi_4.sym} 28380 -23730 0 0 {name=X_51208_ }
C {devices/lab_pin.sym} 28300 -23620 0 0 {name=p27848 lab=_70040_/X }
C {devices/lab_pin.sym} 28300 -23580 0 0 {name=p27849 lab=_69785_/Y }
C {devices/lab_pin.sym} 28300 -23540 0 0 {name=p27850 lab=_70033_/X }
C {devices/lab_pin.sym} 28300 -23500 0 0 {name=p27851 lab=_70041_/Y }
C {devices/lab_pin.sym} 28460 -23560 0 1 {name=p27852 lab=_70042_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -23560 0 0 {name=X_70042_ }
C {devices/lab_pin.sym} 28290 -23410 0 0 {name=p27853 lab=_86882_/CLK }
C {devices/lab_pin.sym} 28290 -23390 0 0 {name=p27854 lab=_45011_/Y }
C {devices/lab_pin.sym} 28470 -23410 0 1 {name=p27855 lab=_64284_/B }
C {sky130_stdcells/dfxtp_4.sym} 28380 -23400 0 0 {name=X_86905_ }
C {devices/lab_pin.sym} 28290 -23270 0 0 {name=p27856 lab=_81989_/CLK }
C {devices/lab_pin.sym} 28290 -23250 0 0 {name=p27857 lab=_77824_/B }
C {devices/lab_pin.sym} 28470 -23270 0 1 {name=p27858 lab=_81996_/D }
C {sky130_stdcells/dfxtp_4.sym} 28380 -23260 0 0 {name=X_82028_ }
C {devices/lab_pin.sym} 28320 -23150 0 0 {name=p27859 lab=_59855_/A }
C {devices/lab_pin.sym} 28320 -23110 0 0 {name=p27860 lab=_59855_/B }
C {devices/lab_pin.sym} 28320 -23070 0 0 {name=p27861 lab=_84688_/Q }
C {devices/lab_pin.sym} 28440 -23110 0 1 {name=p27862 lab=_59853_/Y }
C {sky130_stdcells/nor3_4.sym} 28380 -23110 0 0 {name=X_59853_ }
C {devices/lab_pin.sym} 28320 -22980 0 0 {name=p27863 lab=_52188_/A }
C {devices/lab_pin.sym} 28320 -22940 0 0 {name=p27864 lab=_52188_/B }
C {devices/lab_pin.sym} 28440 -22960 0 1 {name=p27865 lab=_52188_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -22960 0 0 {name=X_52188_ }
C {devices/lab_pin.sym} 28290 -22830 0 0 {name=p27866 lab=_88144_/CLK }
C {devices/lab_pin.sym} 28290 -22810 0 0 {name=p27867 lab=_42393_/X }
C {devices/lab_pin.sym} 28470 -22830 0 1 {name=p27868 lab=_87885_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -22820 0 0 {name=X_87885_ }
C {devices/lab_pin.sym} 28340 -22690 0 0 {name=p27869 lab=clkbuf_9_393_0_CLK/X }
C {devices/lab_pin.sym} 28420 -22690 0 1 {name=p27870 lab=_82743_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 28380 -22690 0 0 {name=Xclkbuf_10_787_0_CLK }
C {devices/lab_pin.sym} 28320 -22580 0 0 {name=p27871 lab=_58699_/A }
C {devices/lab_pin.sym} 28320 -22540 0 0 {name=p27872 lab=_58804_/B }
C {devices/lab_pin.sym} 28440 -22560 0 1 {name=p27873 lab=_58804_/Y }
C {sky130_stdcells/nor2_4.sym} 28380 -22560 0 0 {name=X_58804_ }
C {devices/lab_pin.sym} 28320 -22440 0 0 {name=p27874 lab=_51130_/A }
C {devices/lab_pin.sym} 28320 -22400 0 0 {name=p27875 lab=_52833_/B }
C {devices/lab_pin.sym} 28440 -22420 0 1 {name=p27876 lab=_51139_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -22420 0 0 {name=X_51139_ }
C {devices/lab_pin.sym} 28290 -22290 0 0 {name=p27877 lab=_87625_/CLK }
C {devices/lab_pin.sym} 28290 -22270 0 0 {name=p27878 lab=_86836_/D }
C {devices/lab_pin.sym} 28470 -22290 0 1 {name=p27879 lab=_66618_/B }
C {sky130_stdcells/dfxtp_4.sym} 28380 -22280 0 0 {name=X_86836_ }
C {devices/lab_pin.sym} 28320 -22160 0 0 {name=p27880 lab=_81122_/D }
C {devices/lab_pin.sym} 28320 -22120 0 0 {name=p27881 lab=_74848_/B }
C {devices/lab_pin.sym} 28440 -22140 0 1 {name=p27882 lab=_74850_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -22140 0 0 {name=X_74850_ }
C {devices/lab_pin.sym} 28340 -22010 0 0 {name=p27883 lab=_66262_/A }
C {devices/lab_pin.sym} 28420 -22010 0 1 {name=p27884 lab=_59848_/B }
C {sky130_stdcells/buf_2.sym} 28380 -22010 0 0 {name=X_59784_ }
C {devices/lab_pin.sym} 28300 -21910 0 0 {name=p27885 lab=_56993_/X }
C {devices/lab_pin.sym} 28300 -21870 0 0 {name=p27886 lab=_56994_/Y }
C {devices/lab_pin.sym} 28300 -21830 0 0 {name=p27887 lab=_56995_/X }
C {devices/lab_pin.sym} 28460 -21870 0 1 {name=p27888 lab=_56996_/Y }
C {sky130_stdcells/a21oi_4.sym} 28380 -21870 0 0 {name=X_56996_ }
C {devices/lab_pin.sym} 28340 -21730 0 0 {name=p27889 lab=clkbuf_9_278_0_CLK/A }
C {devices/lab_pin.sym} 28420 -21730 0 1 {name=p27890 lab=clkbuf_9_278_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 28380 -21730 0 0 {name=Xclkbuf_9_278_0_CLK }
C {devices/lab_pin.sym} 28340 -21610 0 0 {name=p27891 lab=_74244_/B }
C {devices/lab_pin.sym} 28420 -21610 0 1 {name=p27892 lab=_73801_/X }
C {sky130_stdcells/buf_2.sym} 28380 -21610 0 0 {name=X_73801_ }
C {devices/lab_pin.sym} 28340 -21490 0 0 {name=p27893 lab=_58610_/A }
C {devices/lab_pin.sym} 28420 -21490 0 1 {name=p27894 lab=_58735_/X }
C {sky130_stdcells/buf_2.sym} 28380 -21490 0 0 {name=X_58735_ }
C {devices/lab_pin.sym} 28340 -21370 0 0 {name=p27895 lab=_44003_/A }
C {devices/lab_pin.sym} 28420 -21370 0 1 {name=p27896 lab=_59901_/C }
C {sky130_stdcells/inv_2.sym} 28380 -21370 0 0 {name=X_43961_ }
C {devices/lab_pin.sym} 28320 -21260 0 0 {name=p27897 lab=_55947_/A }
C {devices/lab_pin.sym} 28320 -21220 0 0 {name=p27898 lab=_85245_/Q }
C {devices/lab_pin.sym} 28440 -21240 0 1 {name=p27899 lab=_55947_/X }
C {sky130_stdcells/and2_4.sym} 28380 -21240 0 0 {name=X_55947_ }
C {devices/lab_pin.sym} 28320 -21140 0 0 {name=p27900 lab=_74781_/A }
C {devices/lab_pin.sym} 28320 -21100 0 0 {name=p27901 lab=_74775_/A }
C {devices/lab_pin.sym} 28320 -21060 0 0 {name=p27902 lab=_70884_/A }
C {devices/lab_pin.sym} 28320 -21020 0 0 {name=p27903 lab=_70662_/X }
C {devices/lab_pin.sym} 28440 -21080 0 1 {name=p27904 lab=_74781_/Y }
C {sky130_stdcells/nand4_4.sym} 28380 -21080 0 0 {name=X_74781_ }
C {devices/lab_pin.sym} 28290 -20930 0 0 {name=p27905 lab=_84980_/CLK }
C {devices/lab_pin.sym} 28290 -20910 0 0 {name=p27906 lab=_86767_/D }
C {devices/lab_pin.sym} 28470 -20930 0 1 {name=p27907 lab=_44187_/A }
C {sky130_stdcells/dfxtp_4.sym} 28380 -20920 0 0 {name=X_86767_ }
C {devices/lab_pin.sym} 28340 -20790 0 0 {name=p27908 lab=_71993_/A }
C {devices/lab_pin.sym} 28420 -20790 0 1 {name=p27909 lab=_71993_/X }
C {sky130_stdcells/buf_2.sym} 28380 -20790 0 0 {name=X_71993_ }
C {devices/lab_pin.sym} 28290 -20670 0 0 {name=p27910 lab=_87671_/CLK }
C {devices/lab_pin.sym} 28290 -20650 0 0 {name=p27911 lab=_83979_/D }
C {devices/lab_pin.sym} 28470 -20670 0 1 {name=p27912 lab=_83979_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -20660 0 0 {name=X_83979_ }
C {devices/lab_pin.sym} 28340 -20530 0 0 {name=p27913 lab=clkbuf_9_355_0_CLK/X }
C {devices/lab_pin.sym} 28420 -20530 0 1 {name=p27914 lab=_87103_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 28380 -20530 0 0 {name=Xclkbuf_10_710_0_CLK }
C {devices/lab_pin.sym} 28300 -20430 0 0 {name=p27915 lab=_45668_/X }
C {devices/lab_pin.sym} 28300 -20390 0 0 {name=p27916 lab=_61561_/A }
C {devices/lab_pin.sym} 28300 -20350 0 0 {name=p27917 lab=_45685_/X }
C {devices/lab_pin.sym} 28460 -20390 0 1 {name=p27918 lab=_45700_/Y }
C {sky130_stdcells/o21ai_4.sym} 28380 -20390 0 0 {name=X_45700_ }
C {devices/lab_pin.sym} 28340 -20250 0 0 {name=p27919 lab=_81659_/Q }
C {devices/lab_pin.sym} 28420 -20250 0 1 {name=p27920 lab=_76520_/Y }
C {sky130_stdcells/inv_2.sym} 28380 -20250 0 0 {name=X_76520_ }
C {devices/lab_pin.sym} 28300 -20160 0 0 {name=p27921 lab=_41697_/X }
C {devices/lab_pin.sym} 28300 -20120 0 0 {name=p27922 lab=_42900_/X }
C {devices/lab_pin.sym} 28300 -20080 0 0 {name=p27923 lab=_87655_/Q }
C {devices/lab_pin.sym} 28300 -20040 0 0 {name=p27924 lab=_42901_/X }
C {devices/lab_pin.sym} 28460 -20100 0 1 {name=p27925 lab=_42912_/X }
C {sky130_stdcells/a2bb2o_4.sym} 28380 -20100 0 0 {name=X_42912_ }
C {devices/lab_pin.sym} 28340 -19950 0 0 {name=p27926 lab=_73709_/X }
C {devices/lab_pin.sym} 28420 -19950 0 1 {name=p27927 lab=_73733_/A }
C {sky130_stdcells/buf_2.sym} 28380 -19950 0 0 {name=X_73732_ }
C {devices/lab_pin.sym} 28290 -19830 0 0 {name=p27928 lab=_85718_/CLK }
C {devices/lab_pin.sym} 28290 -19810 0 0 {name=p27929 lab=_52990_/Y }
C {devices/lab_pin.sym} 28470 -19830 0 1 {name=p27930 lab=_85718_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -19820 0 0 {name=X_85718_ }
C {devices/lab_pin.sym} 28340 -19690 0 0 {name=p27931 lab=_70944_/A }
C {devices/lab_pin.sym} 28420 -19690 0 1 {name=p27932 lab=_70947_/A }
C {sky130_stdcells/buf_2.sym} 28380 -19690 0 0 {name=X_70944_ }
C {devices/lab_pin.sym} 28340 -19570 0 0 {name=p27933 lab=_46680_/A }
C {devices/lab_pin.sym} 28420 -19570 0 1 {name=p27934 lab=_46680_/Y }
C {sky130_stdcells/inv_2.sym} 28380 -19570 0 0 {name=X_46680_ }
C {devices/lab_pin.sym} 28300 -19470 0 0 {name=p27935 lab=_58625_/X }
C {devices/lab_pin.sym} 28300 -19430 0 0 {name=p27936 lab=_85465_/Q }
C {devices/lab_pin.sym} 28300 -19390 0 0 {name=p27937 lab=_58665_/X }
C {devices/lab_pin.sym} 28460 -19430 0 1 {name=p27938 lab=_58666_/Y }
C {sky130_stdcells/o21ai_4.sym} 28380 -19430 0 0 {name=X_58666_ }
C {devices/lab_pin.sym} 28300 -19330 0 0 {name=p27939 lab=_43862_/X }
C {devices/lab_pin.sym} 28300 -19290 0 0 {name=p27940 lab=_43876_/X }
C {devices/lab_pin.sym} 28300 -19250 0 0 {name=p27941 lab=_41321_/X }
C {devices/lab_pin.sym} 28300 -19210 0 0 {name=p27942 lab=_87212_/Q }
C {devices/lab_pin.sym} 28300 -19170 0 0 {name=p27943 lab=_43863_/X }
C {devices/lab_pin.sym} 28460 -19250 0 1 {name=p27944 lab=_43892_/Y }
C {sky130_stdcells/o32ai_4.sym} 28380 -19250 0 0 {name=X_43892_ }
C {devices/lab_pin.sym} 28300 -19110 0 0 {name=p27945 lab=_55875_/X }
C {devices/lab_pin.sym} 28300 -19070 0 0 {name=p27946 lab=_55877_/X }
C {devices/lab_pin.sym} 28300 -19030 0 0 {name=p27947 lab=_55517_/X }
C {devices/lab_pin.sym} 28460 -19070 0 1 {name=p27948 lab=_55881_/A }
C {sky130_stdcells/a21o_4.sym} 28380 -19070 0 0 {name=X_55878_ }
C {devices/lab_pin.sym} 28290 -18930 0 0 {name=p27949 lab=_86701_/CLK }
C {devices/lab_pin.sym} 28290 -18910 0 0 {name=p27950 lab=_86698_/D }
C {devices/lab_pin.sym} 28470 -18930 0 1 {name=p27951 lab=_58867_/A }
C {sky130_stdcells/dfxtp_4.sym} 28380 -18920 0 0 {name=X_86698_ }
C {devices/lab_pin.sym} 28340 -18790 0 0 {name=p27952 lab=clkbuf_9_201_0_CLK/A }
C {devices/lab_pin.sym} 28420 -18790 0 1 {name=p27953 lab=clkbuf_9_201_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 28380 -18790 0 0 {name=Xclkbuf_9_201_0_CLK }
C {devices/lab_pin.sym} 28340 -18670 0 0 {name=p27954 lab=_85042_/Q }
C {devices/lab_pin.sym} 28420 -18670 0 1 {name=p27955 lab=_45631_/Y }
C {sky130_stdcells/inv_2.sym} 28380 -18670 0 0 {name=X_45631_ }
C {devices/lab_pin.sym} 28320 -18560 0 0 {name=p27956 lab=_71957_/A }
C {devices/lab_pin.sym} 28320 -18520 0 0 {name=p27957 lab=_57617_/B }
C {devices/lab_pin.sym} 28440 -18540 0 1 {name=p27958 lab=_57617_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -18540 0 0 {name=X_57617_ }
C {devices/lab_pin.sym} 28320 -18420 0 0 {name=p27959 lab=_81271_/Q }
C {devices/lab_pin.sym} 28320 -18380 0 0 {name=p27960 lab=_81539_/Q }
C {devices/lab_pin.sym} 28440 -18400 0 1 {name=p27961 lab=_76451_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -18400 0 0 {name=X_76451_ }
C {devices/lab_pin.sym} 28300 -18300 0 0 {name=p27962 lab=_41511_/X }
C {devices/lab_pin.sym} 28300 -18260 0 0 {name=p27963 lab=_42830_/X }
C {devices/lab_pin.sym} 28300 -18220 0 0 {name=p27964 lab=_66817_/B }
C {devices/lab_pin.sym} 28300 -18180 0 0 {name=p27965 lab=_42832_/X }
C {devices/lab_pin.sym} 28460 -18240 0 1 {name=p27966 lab=_87689_/D }
C {sky130_stdcells/a2bb2o_4.sym} 28380 -18240 0 0 {name=X_42843_ }
C {devices/lab_pin.sym} 28340 -18090 0 0 {name=p27967 lab=_54284_/A }
C {devices/lab_pin.sym} 28420 -18090 0 1 {name=p27968 lab=_54882_/A }
C {sky130_stdcells/buf_2.sym} 28380 -18090 0 0 {name=X_54829_ }
C {devices/lab_pin.sym} 28300 -18000 0 0 {name=p27969 lab=_73609_/X }
C {devices/lab_pin.sym} 28300 -17960 0 0 {name=p27970 lab=_85629_/Q }
C {devices/lab_pin.sym} 28300 -17920 0 0 {name=p27971 lab=_73661_/X }
C {devices/lab_pin.sym} 28300 -17880 0 0 {name=p27972 lab=_73662_/X }
C {devices/lab_pin.sym} 28460 -17940 0 1 {name=p27973 lab=_73663_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -17940 0 0 {name=X_73663_ }
C {devices/lab_pin.sym} 28290 -17790 0 0 {name=p27974 lab=_85651_/CLK }
C {devices/lab_pin.sym} 28290 -17770 0 0 {name=p27975 lab=_85649_/D }
C {devices/lab_pin.sym} 28470 -17790 0 1 {name=p27976 lab=_85649_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -17780 0 0 {name=X_85649_ }
C {devices/lab_pin.sym} 28340 -17650 0 0 {name=p27977 lab=_70862_/A }
C {devices/lab_pin.sym} 28420 -17650 0 1 {name=p27978 lab=_70875_/X }
C {sky130_stdcells/buf_2.sym} 28380 -17650 0 0 {name=X_70875_ }
C {devices/lab_pin.sym} 28300 -17550 0 0 {name=p27979 lab=_58593_/Y }
C {devices/lab_pin.sym} 28300 -17510 0 0 {name=p27980 lab=_58596_/Y }
C {devices/lab_pin.sym} 28300 -17470 0 0 {name=p27981 lab=_58105_/X }
C {devices/lab_pin.sym} 28460 -17510 0 1 {name=p27982 lab=_58597_/X }
C {sky130_stdcells/a21o_4.sym} 28380 -17510 0 0 {name=X_58597_ }
C {devices/lab_pin.sym} 28320 -17380 0 0 {name=p27983 lab=_75400_/X }
C {devices/lab_pin.sym} 28320 -17340 0 0 {name=p27984 lab=_75401_/Y }
C {devices/lab_pin.sym} 28440 -17360 0 1 {name=p27985 lab=_75403_/A }
C {sky130_stdcells/and2_4.sym} 28380 -17360 0 0 {name=X_75402_ }
C {devices/lab_pin.sym} 28340 -17230 0 0 {name=p27986 lab=_48478_/A }
C {devices/lab_pin.sym} 28420 -17230 0 1 {name=p27987 lab=_48350_/X }
C {sky130_stdcells/buf_2.sym} 28380 -17230 0 0 {name=X_48350_ }
C {devices/lab_pin.sym} 28320 -17120 0 0 {name=p27988 lab=_72562_/Y }
C {devices/lab_pin.sym} 28320 -17080 0 0 {name=p27989 lab=_72570_/C }
C {devices/lab_pin.sym} 28440 -17100 0 1 {name=p27990 lab=_72614_/X }
C {sky130_stdcells/and2_4.sym} 28380 -17100 0 0 {name=X_72614_ }
C {devices/lab_pin.sym} 28320 -16980 0 0 {name=p27991 lab=_63338_/Y }
C {devices/lab_pin.sym} 28320 -16940 0 0 {name=p27992 lab=_79168_/A }
C {devices/lab_pin.sym} 28440 -16960 0 1 {name=p27993 lab=_79171_/C }
C {sky130_stdcells/nand2_4.sym} 28380 -16960 0 0 {name=X_79170_ }
C {devices/lab_pin.sym} 28320 -16840 0 0 {name=p27994 lab=_57531_/A }
C {devices/lab_pin.sym} 28320 -16800 0 0 {name=p27995 lab=_53520_/B }
C {devices/lab_pin.sym} 28440 -16820 0 1 {name=p27996 lab=_57548_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -16820 0 0 {name=X_57548_ }
C {devices/lab_pin.sym} 28300 -16710 0 0 {name=p27997 lab=_45557_/X }
C {devices/lab_pin.sym} 28300 -16670 0 0 {name=p27998 lab=_45560_/Y }
C {devices/lab_pin.sym} 28300 -16630 0 0 {name=p27999 lab=_45561_/X }
C {devices/lab_pin.sym} 28460 -16670 0 1 {name=p28000 lab=_45562_/Y }
C {sky130_stdcells/a21oi_4.sym} 28380 -16670 0 0 {name=X_45562_ }
C {devices/lab_pin.sym} 28340 -16530 0 0 {name=p28001 lab=_76382_/A }
C {devices/lab_pin.sym} 28420 -16530 0 1 {name=p28002 lab=_76382_/Y }
C {sky130_stdcells/inv_2.sym} 28380 -16530 0 0 {name=X_76382_ }
C {devices/lab_pin.sym} 28290 -16410 0 0 {name=p28003 lab=_83139_/CLK }
C {devices/lab_pin.sym} 28290 -16390 0 0 {name=p28004 lab=_40600_/X }
C {devices/lab_pin.sym} 28470 -16410 0 1 {name=p28005 lab=_88368_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -16400 0 0 {name=X_88368_ }
C {devices/lab_pin.sym} 28340 -16270 0 0 {name=p28006 lab=_42720_/X }
C {devices/lab_pin.sym} 28420 -16270 0 1 {name=p28007 lab=_42774_/X }
C {sky130_stdcells/buf_2.sym} 28380 -16270 0 0 {name=X_42774_ }
C {devices/lab_pin.sym} 28300 -16170 0 0 {name=p28008 lab=_83144_/Q }
C {devices/lab_pin.sym} 28300 -16130 0 0 {name=p28009 lab=_73549_/X }
C {devices/lab_pin.sym} 28300 -16090 0 0 {name=p28010 lab=_73593_/Y }
C {devices/lab_pin.sym} 28460 -16130 0 1 {name=p28011 lab=_73594_/X }
C {sky130_stdcells/a21o_4.sym} 28380 -16130 0 0 {name=X_73594_ }
C {devices/lab_pin.sym} 28340 -15990 0 0 {name=p28012 lab=clkbuf_9_362_0_CLK/X }
C {devices/lab_pin.sym} 28420 -15990 0 1 {name=p28013 lab=_82339_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 28380 -15990 0 0 {name=Xclkbuf_10_725_0_CLK }
C {devices/lab_pin.sym} 28340 -15870 0 0 {name=p28014 lab=_81817_/Q }
C {devices/lab_pin.sym} 28420 -15870 0 1 {name=p28015 lab=_47302_/A }
C {sky130_stdcells/inv_2.sym} 28380 -15870 0 0 {name=X_47301_ }
C {devices/lab_pin.sym} 28320 -15760 0 0 {name=p28016 lab=_78119_/X }
C {devices/lab_pin.sym} 28320 -15720 0 0 {name=p28017 lab=_78120_/Y }
C {devices/lab_pin.sym} 28440 -15740 0 1 {name=p28018 lab=_78121_/X }
C {sky130_stdcells/and2_4.sym} 28380 -15740 0 0 {name=X_78121_ }
C {devices/lab_pin.sym} 28340 -15610 0 0 {name=p28019 lab=_44530_/A }
C {devices/lab_pin.sym} 28420 -15610 0 1 {name=p28020 lab=_44513_/X }
C {sky130_stdcells/buf_2.sym} 28380 -15610 0 0 {name=X_44513_ }
C {devices/lab_pin.sym} 28340 -15490 0 0 {name=p28021 lab=_75333_/A }
C {devices/lab_pin.sym} 28420 -15490 0 1 {name=p28022 lab=_75333_/Y }
C {sky130_stdcells/inv_2.sym} 28380 -15490 0 0 {name=X_75333_ }
C {devices/lab_pin.sym} 28290 -15370 0 0 {name=p28023 lab=_88084_/CLK }
C {devices/lab_pin.sym} 28290 -15350 0 0 {name=p28024 lab=_87319_/D }
C {devices/lab_pin.sym} 28470 -15370 0 1 {name=p28025 lab=_43667_/A }
C {sky130_stdcells/dfxtp_4.sym} 28380 -15360 0 0 {name=X_87319_ }
C {devices/lab_pin.sym} 28320 -15240 0 0 {name=p28026 lab=_41725_/A }
C {devices/lab_pin.sym} 28320 -15200 0 0 {name=p28027 lab=_41718_/X }
C {devices/lab_pin.sym} 28440 -15220 0 1 {name=p28028 lab=_41725_/X }
C {sky130_stdcells/or2_4.sym} 28380 -15220 0 0 {name=X_41725_ }
C {devices/lab_pin.sym} 28340 -15090 0 0 {name=p28029 lab=_48028_/B }
C {devices/lab_pin.sym} 28420 -15090 0 1 {name=p28030 lab=_50326_/B }
C {sky130_stdcells/buf_2.sym} 28380 -15090 0 0 {name=X_48281_ }
C {devices/lab_pin.sym} 28300 -15010 0 0 {name=p28031 lab=_60053_/X }
C {devices/lab_pin.sym} 28300 -14970 0 0 {name=p28032 lab=_72537_/Y }
C {devices/lab_pin.sym} 28300 -14930 0 0 {name=p28033 lab=_72539_/Y }
C {devices/lab_pin.sym} 28300 -14890 0 0 {name=p28034 lab=_72584_/A }
C {devices/lab_pin.sym} 28300 -14860 0 0 {name=p28035 lab=_72544_/Y }
C {devices/lab_pin.sym} 28460 -14930 0 1 {name=p28036 lab=_83237_/D }
C {sky130_stdcells/a41oi_4.sym} 28380 -14930 0 0 {name=X_72545_ }
C {devices/lab_pin.sym} 28300 -14790 0 0 {name=p28037 lab=_56604_/B }
C {devices/lab_pin.sym} 28300 -14750 0 0 {name=p28038 lab=_45343_/X }
C {devices/lab_pin.sym} 28300 -14710 0 0 {name=p28039 lab=_45378_/X }
C {devices/lab_pin.sym} 28460 -14750 0 1 {name=p28040 lab=_45493_/X }
C {sky130_stdcells/o21a_4.sym} 28380 -14750 0 0 {name=X_45493_ }
C {devices/lab_pin.sym} 28300 -14640 0 0 {name=p28041 lab=_45947_/B }
C {devices/lab_pin.sym} 28300 -14600 0 0 {name=p28042 lab=_84996_/Q }
C {devices/lab_pin.sym} 28300 -14560 0 0 {name=p28043 lab=_56646_/Y }
C {devices/lab_pin.sym} 28300 -14520 0 0 {name=p28044 lab=_57470_/B }
C {devices/lab_pin.sym} 28460 -14580 0 1 {name=p28045 lab=_57479_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -14580 0 0 {name=X_57479_ }
C {devices/lab_pin.sym} 28290 -14430 0 0 {name=p28046 lab=_87790_/CLK }
C {devices/lab_pin.sym} 28290 -14410 0 0 {name=p28047 lab=_40979_/Y }
C {devices/lab_pin.sym} 28470 -14430 0 1 {name=p28048 lab=_88299_/Q }
C {sky130_stdcells/dfxtp_4.sym} 28380 -14420 0 0 {name=X_88299_ }
C {devices/lab_pin.sym} 28340 -14290 0 0 {name=p28049 lab=clkbuf_9_217_0_CLK/A }
C {devices/lab_pin.sym} 28420 -14290 0 1 {name=p28050 lab=clkbuf_9_216_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 28380 -14290 0 0 {name=Xclkbuf_9_216_0_CLK }
C {devices/lab_pin.sym} 28320 -14180 0 0 {name=p28051 lab=_47196_/A }
C {devices/lab_pin.sym} 28320 -14140 0 0 {name=p28052 lab=_52931_/B }
C {devices/lab_pin.sym} 28440 -14160 0 1 {name=p28053 lab=_47232_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -14160 0 0 {name=X_47232_ }
C {devices/lab_pin.sym} 28300 -14050 0 0 {name=p28054 lab=_59146_/X }
C {devices/lab_pin.sym} 28300 -14010 0 0 {name=p28055 lab=_85423_/Q }
C {devices/lab_pin.sym} 28300 -13970 0 0 {name=p28056 lab=_59217_/X }
C {devices/lab_pin.sym} 28460 -14010 0 1 {name=p28057 lab=_59218_/Y }
C {sky130_stdcells/o21ai_4.sym} 28380 -14010 0 0 {name=X_59218_ }
C {devices/lab_pin.sym} 28320 -13880 0 0 {name=p28058 lab=_60826_/C }
C {devices/lab_pin.sym} 28320 -13840 0 0 {name=p28059 lab=_78052_/B }
C {devices/lab_pin.sym} 28440 -13860 0 1 {name=p28060 lab=_81861_/D }
C {sky130_stdcells/xor2_4.sym} 28380 -13860 0 0 {name=X_78052_ }
C {devices/lab_pin.sym} 28340 -13730 0 0 {name=p28061 lab=_44444_/A }
C {devices/lab_pin.sym} 28420 -13730 0 1 {name=p28062 lab=_87105_/D }
C {sky130_stdcells/inv_2.sym} 28380 -13730 0 0 {name=X_44444_ }
C {devices/lab_pin.sym} 28300 -13630 0 0 {name=p28063 lab=_75248_/Y }
C {devices/lab_pin.sym} 28300 -13590 0 0 {name=p28064 lab=_75262_/X }
C {devices/lab_pin.sym} 28300 -13550 0 0 {name=p28065 lab=_75263_/X }
C {devices/lab_pin.sym} 28460 -13590 0 1 {name=p28066 lab=_75265_/B }
C {sky130_stdcells/a21boi_4.sym} 28380 -13590 0 0 {name=X_75264_ }
C {devices/lab_pin.sym} 28340 -13450 0 0 {name=p28067 lab=_41655_/X }
C {devices/lab_pin.sym} 28420 -13450 0 1 {name=p28068 lab=_41656_/X }
C {sky130_stdcells/buf_2.sym} 28380 -13450 0 0 {name=X_41656_ }
C {devices/lab_pin.sym} 28340 -13330 0 0 {name=p28069 lab=_60489_/X }
C {devices/lab_pin.sym} 28420 -13330 0 1 {name=p28070 lab=_63004_/C }
C {sky130_stdcells/buf_2.sym} 28380 -13330 0 0 {name=X_60490_ }
C {devices/lab_pin.sym} 28320 -13220 0 0 {name=p28071 lab=_72476_/A }
C {devices/lab_pin.sym} 28320 -13180 0 0 {name=p28072 lab=_72476_/B }
C {devices/lab_pin.sym} 28440 -13200 0 1 {name=p28073 lab=_72476_/Y }
C {sky130_stdcells/nor2_4.sym} 28380 -13200 0 0 {name=X_72476_ }
C {devices/lab_pin.sym} 28320 -13080 0 0 {name=p28074 lab=_82082_/Q }
C {devices/lab_pin.sym} 28320 -13040 0 0 {name=p28075 lab=_77002_/X }
C {devices/lab_pin.sym} 28440 -13060 0 1 {name=p28076 lab=_82363_/D }
C {sky130_stdcells/xor2_4.sym} 28380 -13060 0 0 {name=X_77003_ }
C {devices/lab_pin.sym} 28300 -12960 0 0 {name=p28077 lab=_44270_/X }
C {devices/lab_pin.sym} 28300 -12920 0 0 {name=p28078 lab=_85605_/Q }
C {devices/lab_pin.sym} 28300 -12880 0 0 {name=p28079 lab=_44272_/X }
C {devices/lab_pin.sym} 28300 -12840 0 0 {name=p28080 lab=_74214_/X }
C {devices/lab_pin.sym} 28460 -12900 0 1 {name=p28081 lab=_74215_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -12900 0 0 {name=X_74215_ }
C {devices/lab_pin.sym} 28340 -12750 0 0 {name=p28082 lab=_40607_/A }
C {devices/lab_pin.sym} 28420 -12750 0 1 {name=p28083 lab=_40607_/Y }
C {sky130_stdcells/inv_2.sym} 28380 -12750 0 0 {name=X_40607_ }
C {devices/lab_pin.sym} 28300 -12650 0 0 {name=p28084 lab=_59105_/X }
C {devices/lab_pin.sym} 28300 -12610 0 0 {name=p28085 lab=_85749_/Q }
C {devices/lab_pin.sym} 28300 -12570 0 0 {name=p28086 lab=_59106_/X }
C {devices/lab_pin.sym} 28460 -12610 0 1 {name=p28087 lab=_59149_/X }
C {sky130_stdcells/o21a_4.sym} 28380 -12610 0 0 {name=X_59149_ }
C {devices/lab_pin.sym} 28320 -12500 0 0 {name=p28088 lab=_47152_/X }
C {devices/lab_pin.sym} 28320 -12460 0 0 {name=p28089 lab=_47133_/B }
C {devices/lab_pin.sym} 28320 -12420 0 0 {name=p28090 lab=_47143_/C }
C {devices/lab_pin.sym} 28320 -12380 0 0 {name=p28091 lab=_52887_/D }
C {devices/lab_pin.sym} 28440 -12440 0 1 {name=p28092 lab=_47163_/X }
C {sky130_stdcells/and4_4.sym} 28380 -12440 0 0 {name=X_47163_ }
C {devices/lab_pin.sym} 28320 -12320 0 0 {name=p28093 lab=_71432_/A }
C {devices/lab_pin.sym} 28320 -12280 0 0 {name=p28094 lab=_71432_/B }
C {devices/lab_pin.sym} 28320 -12240 0 0 {name=p28095 lab=_71427_/C }
C {devices/lab_pin.sym} 28320 -12200 0 0 {name=p28096 lab=_71365_/X }
C {devices/lab_pin.sym} 28440 -12260 0 1 {name=p28097 lab=_71427_/X }
C {sky130_stdcells/and4_4.sym} 28380 -12260 0 0 {name=X_71427_ }
C {devices/lab_pin.sym} 28340 -12110 0 0 {name=p28098 lab=_44374_/Y }
C {devices/lab_pin.sym} 28420 -12110 0 1 {name=p28099 lab=_87140_/D }
C {sky130_stdcells/inv_2.sym} 28380 -12110 0 0 {name=X_44375_ }
C {devices/lab_pin.sym} 28300 -12010 0 0 {name=p28100 lab=_75165_/X }
C {devices/lab_pin.sym} 28300 -11970 0 0 {name=p28101 lab=_75193_/Y }
C {devices/lab_pin.sym} 28300 -11930 0 0 {name=p28102 lab=_75194_/X }
C {devices/lab_pin.sym} 28460 -11970 0 1 {name=p28103 lab=_75195_/X }
C {sky130_stdcells/o21a_4.sym} 28380 -11970 0 0 {name=X_75195_ }
C {devices/lab_pin.sym} 28300 -11860 0 0 {name=p28104 lab=_41586_/X }
C {devices/lab_pin.sym} 28300 -11820 0 0 {name=p28105 lab=_41581_/X }
C {devices/lab_pin.sym} 28300 -11780 0 0 {name=p28106 lab=_67161_/B }
C {devices/lab_pin.sym} 28300 -11740 0 0 {name=p28107 lab=_41582_/X }
C {devices/lab_pin.sym} 28460 -11800 0 1 {name=p28108 lab=_88187_/D }
C {sky130_stdcells/a2bb2o_4.sym} 28380 -11800 0 0 {name=X_41587_ }
C {devices/lab_pin.sym} 28340 -11650 0 0 {name=p28109 lab=clkbuf_3_0_1_CLK/X }
C {devices/lab_pin.sym} 28420 -11650 0 1 {name=p28110 lab=clkbuf_4_1_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 28380 -11650 0 0 {name=Xclkbuf_4_1_0_CLK }
C {devices/lab_pin.sym} 28320 -11560 0 0 {name=p28111 lab=_46114_/A }
C {devices/lab_pin.sym} 28320 -11520 0 0 {name=p28112 lab=_80656_/Q }
C {devices/lab_pin.sym} 28320 -11480 0 0 {name=p28113 lab=_80655_/Q }
C {devices/lab_pin.sym} 28320 -11440 0 0 {name=p28114 lab=_74846_/B }
C {devices/lab_pin.sym} 28440 -11500 0 1 {name=p28115 lab=_46204_/B }
C {sky130_stdcells/nor4_4.sym} 28380 -11500 0 0 {name=X_46114_ }
C {devices/lab_pin.sym} 28340 -11350 0 0 {name=p28116 lab=_43302_/A }
C {devices/lab_pin.sym} 28420 -11350 0 1 {name=p28117 lab=_43326_/X }
C {sky130_stdcells/buf_2.sym} 28380 -11350 0 0 {name=X_43326_ }
C {devices/lab_pin.sym} 28320 -11260 0 0 {name=p28118 lab=_61675_/B }
C {devices/lab_pin.sym} 28320 -11220 0 0 {name=p28119 lab=_62149_/B }
C {devices/lab_pin.sym} 28320 -11180 0 0 {name=p28120 lab=_61765_/C }
C {devices/lab_pin.sym} 28320 -11140 0 0 {name=p28121 lab=_61749_/B }
C {devices/lab_pin.sym} 28440 -11200 0 1 {name=p28122 lab=_62160_/Y }
C {sky130_stdcells/nand4_4.sym} 28380 -11200 0 0 {name=X_62160_ }
C {devices/lab_pin.sym} 28300 -11080 0 0 {name=p28123 lab=_43094_/Y }
C {devices/lab_pin.sym} 28300 -11040 0 0 {name=p28124 lab=_72722_/X }
C {devices/lab_pin.sym} 28300 -11000 0 0 {name=p28125 lab=_72798_/X }
C {devices/lab_pin.sym} 28300 -10960 0 0 {name=p28126 lab=_74145_/Y }
C {devices/lab_pin.sym} 28460 -11020 0 1 {name=p28127 lab=_74146_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -11020 0 0 {name=X_74146_ }
C {devices/lab_pin.sym} 28340 -10870 0 0 {name=p28128 lab=_40537_/Y }
C {devices/lab_pin.sym} 28420 -10870 0 1 {name=p28129 lab=_40538_/X }
C {sky130_stdcells/buf_2.sym} 28380 -10870 0 0 {name=X_40538_ }
C {devices/lab_pin.sym} 28320 -10780 0 0 {name=p28130 lab=_47067_/A }
C {devices/lab_pin.sym} 28320 -10740 0 0 {name=p28131 lab=_47082_/X }
C {devices/lab_pin.sym} 28320 -10700 0 0 {name=p28132 lab=_47091_/X }
C {devices/lab_pin.sym} 28320 -10660 0 0 {name=p28133 lab=_52853_/D }
C {devices/lab_pin.sym} 28440 -10720 0 1 {name=p28134 lab=_47094_/X }
C {sky130_stdcells/and4_4.sym} 28380 -10720 0 0 {name=X_47094_ }
C {devices/lab_pin.sym} 28300 -10590 0 0 {name=p28135 lab=_71344_/X }
C {devices/lab_pin.sym} 28300 -10550 0 0 {name=p28136 lab=_83527_/Q }
C {devices/lab_pin.sym} 28300 -10510 0 0 {name=p28137 lab=_71357_/X }
C {devices/lab_pin.sym} 28460 -10550 0 1 {name=p28138 lab=_71358_/X }
C {sky130_stdcells/a21o_4.sym} 28380 -10550 0 0 {name=X_71358_ }
C {devices/lab_pin.sym} 28320 -10430 0 0 {name=p28139 lab=_61101_/A }
C {devices/lab_pin.sym} 28320 -10390 0 0 {name=p28140 lab=_61122_/C }
C {devices/lab_pin.sym} 28320 -10350 0 0 {name=p28141 lab=_61122_/B }
C {devices/lab_pin.sym} 28440 -10390 0 1 {name=p28142 lab=_61195_/A }
C {sky130_stdcells/nand3_4.sym} 28380 -10390 0 0 {name=X_61111_ }
C {devices/lab_pin.sym} 28300 -10280 0 0 {name=p28143 lab=_41510_/Y }
C {devices/lab_pin.sym} 28300 -10240 0 0 {name=p28144 lab=_46043_/X }
C {devices/lab_pin.sym} 28300 -10200 0 0 {name=p28145 lab=_66819_/B }
C {devices/lab_pin.sym} 28300 -10160 0 0 {name=p28146 lab=_46044_/X }
C {devices/lab_pin.sym} 28460 -10220 0 1 {name=p28147 lab=_86796_/D }
C {sky130_stdcells/a2bb2o_4.sym} 28380 -10220 0 0 {name=X_46045_ }
C {devices/lab_pin.sym} 28300 -10090 0 0 {name=p28148 lab=_70303_/X }
C {devices/lab_pin.sym} 28300 -10050 0 0 {name=p28149 lab=_74729_/A }
C {devices/lab_pin.sym} 28300 -10010 0 0 {name=p28150 lab=_70308_/X }
C {devices/lab_pin.sym} 28460 -10050 0 1 {name=p28151 lab=_70309_/X }
C {sky130_stdcells/a21o_4.sym} 28380 -10050 0 0 {name=X_70309_ }
C {devices/lab_pin.sym} 28340 -9910 0 0 {name=p28152 lab=_43256_/Y }
C {devices/lab_pin.sym} 28420 -9910 0 1 {name=p28153 lab=_87514_/D }
C {sky130_stdcells/inv_2.sym} 28380 -9910 0 0 {name=X_43257_ }
C {devices/lab_pin.sym} 28300 -9810 0 0 {name=p28154 lab=_62089_/Y }
C {devices/lab_pin.sym} 28300 -9770 0 0 {name=p28155 lab=_62033_/X }
C {devices/lab_pin.sym} 28300 -9730 0 0 {name=p28156 lab=_62090_/Y }
C {devices/lab_pin.sym} 28460 -9770 0 1 {name=p28157 lab=_62091_/Y }
C {sky130_stdcells/a21oi_4.sym} 28380 -9770 0 0 {name=X_62091_ }
C {devices/lab_pin.sym} 28300 -9660 0 0 {name=p28158 lab=_78942_/A }
C {devices/lab_pin.sym} 28300 -9620 0 0 {name=p28159 lab=_78953_/A }
C {devices/lab_pin.sym} 28300 -9580 0 0 {name=p28160 lab=_78928_/A }
C {devices/lab_pin.sym} 28300 -9540 0 0 {name=p28161 lab=_82512_/D }
C {devices/lab_pin.sym} 28460 -9600 0 1 {name=p28162 lab=_78954_/X }
C {sky130_stdcells/a2bb2o_4.sym} 28380 -9600 0 0 {name=X_78954_ }
C {devices/lab_pin.sym} 28300 -9470 0 0 {name=p28163 lab=_88349_/Q }
C {devices/lab_pin.sym} 28300 -9430 0 0 {name=p28164 lab=_73153_/X }
C {devices/lab_pin.sym} 28300 -9390 0 0 {name=p28165 lab=_72901_/X }
C {devices/lab_pin.sym} 28460 -9430 0 1 {name=p28166 lab=_74077_/Y }
C {sky130_stdcells/o21ai_4.sym} 28380 -9430 0 0 {name=X_74077_ }
C {devices/lab_pin.sym} 28340 -9290 0 0 {name=p28167 lab=_40468_/Y }
C {devices/lab_pin.sym} 28420 -9290 0 1 {name=p28168 lab=_40469_/X }
C {sky130_stdcells/buf_2.sym} 28380 -9290 0 0 {name=X_40469_ }
C {devices/lab_pin.sym} 28320 -9180 0 0 {name=p28169 lab=_71137_/A }
C {devices/lab_pin.sym} 28320 -9140 0 0 {name=p28170 lab=_71289_/B }
C {devices/lab_pin.sym} 28440 -9160 0 1 {name=p28171 lab=_71289_/Y }
C {sky130_stdcells/nor2_4.sym} 28380 -9160 0 0 {name=X_71289_ }
C {devices/lab_pin.sym} 28340 -9030 0 0 {name=p28172 lab=_51584_/A }
C {devices/lab_pin.sym} 28420 -9030 0 1 {name=p28173 lab=_42258_/A }
C {sky130_stdcells/buf_2.sym} 28380 -9030 0 0 {name=X_42208_ }
C {devices/lab_pin.sym} 28300 -8930 0 0 {name=p28174 lab=_60918_/X }
C {devices/lab_pin.sym} 28300 -8890 0 0 {name=p28175 lab=_60957_/B }
C {devices/lab_pin.sym} 28300 -8850 0 0 {name=p28176 lab=_61041_/Y }
C {devices/lab_pin.sym} 28460 -8890 0 1 {name=p28177 lab=_61042_/Y }
C {sky130_stdcells/o21ai_4.sym} 28380 -8890 0 0 {name=X_61042_ }
C {devices/lab_pin.sym} 28320 -8760 0 0 {name=p28178 lab=_82165_/Q }
C {devices/lab_pin.sym} 28320 -8720 0 0 {name=p28179 lab=_82037_/D }
C {devices/lab_pin.sym} 28440 -8740 0 1 {name=p28180 lab=_82133_/D }
C {sky130_stdcells/xor2_4.sym} 28380 -8740 0 0 {name=X_77905_ }
C {devices/lab_pin.sym} 28340 -8610 0 0 {name=p28181 lab=_73704_/A }
C {devices/lab_pin.sym} 28420 -8610 0 1 {name=p28182 lab=_73028_/X }
C {sky130_stdcells/buf_2.sym} 28380 -8610 0 0 {name=X_73028_ }
C {devices/lab_pin.sym} 28340 -8490 0 0 {name=p28183 lab=_43188_/A }
C {devices/lab_pin.sym} 28420 -8490 0 1 {name=p28184 lab=_87547_/D }
C {sky130_stdcells/inv_2.sym} 28380 -8490 0 0 {name=X_43188_ }
C {devices/lab_pin.sym} 28320 -8380 0 0 {name=p28185 lab=_78885_/A }
C {devices/lab_pin.sym} 28320 -8340 0 0 {name=p28186 lab=_78885_/B }
C {devices/lab_pin.sym} 28440 -8360 0 1 {name=p28187 lab=_78888_/A }
C {sky130_stdcells/xor2_4.sym} 28380 -8360 0 0 {name=X_78885_ }
C {devices/lab_pin.sym} 28320 -8240 0 0 {name=p28188 lab=_49809_/A }
C {devices/lab_pin.sym} 28320 -8200 0 0 {name=p28189 lab=_53017_/B }
C {devices/lab_pin.sym} 28440 -8220 0 1 {name=p28190 lab=_49804_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -8220 0 0 {name=X_49804_ }
C {devices/lab_pin.sym} 28300 -8120 0 0 {name=p28191 lab=_41130_/X }
C {devices/lab_pin.sym} 28300 -8080 0 0 {name=p28192 lab=_42137_/X }
C {devices/lab_pin.sym} 28300 -8040 0 0 {name=p28193 lab=_88016_/Q }
C {devices/lab_pin.sym} 28300 -8000 0 0 {name=p28194 lab=_42138_/X }
C {devices/lab_pin.sym} 28460 -8060 0 1 {name=p28195 lab=_88016_/D }
C {sky130_stdcells/a2bb2o_4.sym} 28380 -8060 0 0 {name=X_42139_ }
C {devices/lab_pin.sym} 28300 -7930 0 0 {name=p28196 lab=_65847_/X }
C {devices/lab_pin.sym} 28300 -7890 0 0 {name=p28197 lab=_65849_/X }
C {devices/lab_pin.sym} 28300 -7850 0 0 {name=p28198 lab=_65809_/X }
C {devices/lab_pin.sym} 28460 -7890 0 1 {name=p28199 lab=_65850_/X }
C {sky130_stdcells/a21o_4.sym} 28380 -7890 0 0 {name=X_65850_ }
C {devices/lab_pin.sym} 28320 -7760 0 0 {name=p28200 lab=_77822_/Y }
C {devices/lab_pin.sym} 28320 -7720 0 0 {name=p28201 lab=_77836_/B }
C {devices/lab_pin.sym} 28440 -7740 0 1 {name=p28202 lab=_77841_/A }
C {sky130_stdcells/nand2_4.sym} 28380 -7740 0 0 {name=X_77836_ }
C {devices/lab_pin.sym} 28320 -7630 0 0 {name=p28203 lab=_50308_/A }
C {devices/lab_pin.sym} 28320 -7590 0 0 {name=p28204 lab=_48069_/B }
C {devices/lab_pin.sym} 28320 -7550 0 0 {name=p28205 lab=_47919_/X }
C {devices/lab_pin.sym} 28440 -7590 0 1 {name=p28206 lab=_47996_/X }
C {sky130_stdcells/and3_4.sym} 28380 -7590 0 0 {name=X_47996_ }
C {devices/lab_pin.sym} 28320 -7460 0 0 {name=p28207 lab=_64778_/A }
C {devices/lab_pin.sym} 28320 -7420 0 0 {name=p28208 lab=_85850_/Q }
C {devices/lab_pin.sym} 28440 -7440 0 1 {name=p28209 lab=_64801_/X }
C {sky130_stdcells/and2_4.sym} 28380 -7440 0 0 {name=X_64801_ }
C {devices/lab_pin.sym} 28300 -7330 0 0 {name=p28210 lab=_49731_/Y }
C {devices/lab_pin.sym} 28300 -7290 0 0 {name=p28211 lab=_49732_/X }
C {devices/lab_pin.sym} 28300 -7250 0 0 {name=p28212 lab=_49734_/X }
C {devices/lab_pin.sym} 28460 -7290 0 1 {name=p28213 lab=_49735_/Y }
C {sky130_stdcells/a21oi_4.sym} 28380 -7290 0 0 {name=X_49735_ }
C {devices/lab_pin.sym} 28340 -7150 0 0 {name=p28214 lab=_54460_/B }
C {devices/lab_pin.sym} 28420 -7150 0 1 {name=p28215 lab=_52768_/B }
C {sky130_stdcells/buf_2.sym} 28380 -7150 0 0 {name=X_46947_ }
C {devices/lab_pin.sym} 28300 -7050 0 0 {name=p28216 lab=_65778_/X }
C {devices/lab_pin.sym} 28300 -7010 0 0 {name=p28217 lab=_65780_/X }
C {devices/lab_pin.sym} 28300 -6970 0 0 {name=p28218 lab=_65566_/X }
C {devices/lab_pin.sym} 28460 -7010 0 1 {name=p28219 lab=_65781_/X }
C {sky130_stdcells/a21o_4.sym} 28380 -7010 0 0 {name=X_65781_ }
C {devices/lab_pin.sym} 28320 -6880 0 0 {name=p28220 lab=_77763_/Y }
C {devices/lab_pin.sym} 28320 -6840 0 0 {name=p28221 lab=_77766_/Y }
C {devices/lab_pin.sym} 28440 -6860 0 1 {name=p28222 lab=_77768_/B }
C {sky130_stdcells/xor2_4.sym} 28380 -6860 0 0 {name=X_77767_ }
C {devices/lab_pin.sym} 28320 -6740 0 0 {name=p28223 lab=_81141_/D }
C {devices/lab_pin.sym} 28320 -6700 0 0 {name=p28224 lab=_74980_/B }
C {devices/lab_pin.sym} 28440 -6720 0 1 {name=p28225 lab=_74987_/B }
C {sky130_stdcells/or2_4.sym} 28380 -6720 0 0 {name=X_74979_ }
C {devices/lab_pin.sym} 28340 -6590 0 0 {name=p28226 lab=_62791_/X }
C {devices/lab_pin.sym} 28420 -6590 0 1 {name=p28227 lab=_63285_/A }
C {sky130_stdcells/buf_2.sym} 28380 -6590 0 0 {name=X_62993_ }
C {devices/lab_pin.sym} 28300 -6500 0 0 {name=p28228 lab=_67496_/X }
C {devices/lab_pin.sym} 28300 -6460 0 0 {name=p28229 lab=_67506_/Y }
C {devices/lab_pin.sym} 28300 -6420 0 0 {name=p28230 lab=_67507_/X }
C {devices/lab_pin.sym} 28300 -6380 0 0 {name=p28231 lab=_67519_/Y }
C {devices/lab_pin.sym} 28460 -6440 0 1 {name=p28232 lab=_67520_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -6440 0 0 {name=X_67520_ }
C {devices/lab_pin.sym} 28300 -6320 0 0 {name=p28233 lab=_79474_/Y }
C {devices/lab_pin.sym} 28300 -6280 0 0 {name=p28234 lab=_79496_/B }
C {devices/lab_pin.sym} 28300 -6240 0 0 {name=p28235 lab=_79491_/Y }
C {devices/lab_pin.sym} 28300 -6200 0 0 {name=p28236 lab=_79494_/Y }
C {devices/lab_pin.sym} 28460 -6260 0 1 {name=p28237 lab=_79506_/X }
C {sky130_stdcells/o22a_4.sym} 28380 -6260 0 0 {name=X_79506_ }
C {devices/lab_pin.sym} 28340 -6110 0 0 {name=p28238 lab=_64732_/A }
C {devices/lab_pin.sym} 28420 -6110 0 1 {name=p28239 lab=_64761_/B }
C {sky130_stdcells/buf_2.sym} 28380 -6110 0 0 {name=X_64732_ }
C {devices/lab_pin.sym} 28320 -6000 0 0 {name=p28240 lab=_76688_/A }
C {devices/lab_pin.sym} 28320 -5960 0 0 {name=p28241 lab=_76694_/A }
C {devices/lab_pin.sym} 28440 -5980 0 1 {name=p28242 lab=_76718_/Y }
C {sky130_stdcells/nor2_4.sym} 28380 -5980 0 0 {name=X_76718_ }
C {devices/lab_pin.sym} 28320 -5860 0 0 {name=p28243 lab=_49661_/X }
C {devices/lab_pin.sym} 28320 -5820 0 0 {name=p28244 lab=_52881_/B }
C {devices/lab_pin.sym} 28440 -5840 0 1 {name=p28245 lab=_49666_/Y }
C {sky130_stdcells/nand2_4.sym} 28380 -5840 0 0 {name=X_49666_ }
C {devices/lab_pin.sym} 28300 -5730 0 0 {name=p28246 lab=_61942_/Y }
C {devices/lab_pin.sym} 28300 -5690 0 0 {name=p28247 lab=_61881_/X }
C {devices/lab_pin.sym} 28300 -5650 0 0 {name=p28248 lab=_61943_/Y }
C {devices/lab_pin.sym} 28460 -5690 0 1 {name=p28249 lab=_84444_/D }
C {sky130_stdcells/a21oi_4.sym} 28380 -5690 0 0 {name=X_61944_ }
C {devices/lab_pin.sym} 28340 -5550 0 0 {name=p28250 lab=_83661_/Q }
C {devices/lab_pin.sym} 28420 -5550 0 1 {name=p28251 lab=_52726_/B }
C {sky130_stdcells/inv_2.sym} 28380 -5550 0 0 {name=X_46878_ }
C {devices/lab_pin.sym} 28340 -5430 0 0 {name=p28252 lab=_82240_/Q }
C {devices/lab_pin.sym} 28420 -5430 0 1 {name=p28253 lab=_77698_/Y }
C {sky130_stdcells/inv_2.sym} 28380 -5430 0 0 {name=X_77698_ }
C {devices/lab_pin.sym} 28300 -5330 0 0 {name=p28254 lab=_86506_/Q }
C {devices/lab_pin.sym} 28300 -5290 0 0 {name=p28255 lab=_48612_/X }
C {devices/lab_pin.sym} 28300 -5250 0 0 {name=p28256 lab=_48616_/Y }
C {devices/lab_pin.sym} 28460 -5290 0 1 {name=p28257 lab=_48617_/Y }
C {sky130_stdcells/o21ai_4.sym} 28380 -5290 0 0 {name=X_48617_ }
C {devices/lab_pin.sym} 28320 -5160 0 0 {name=p28258 lab=_67497_/A }
C {devices/lab_pin.sym} 28320 -5120 0 0 {name=p28259 lab=_67451_/B }
C {devices/lab_pin.sym} 28440 -5140 0 1 {name=p28260 lab=_67451_/X }
C {sky130_stdcells/and2_4.sym} 28380 -5140 0 0 {name=X_67451_ }
C {devices/lab_pin.sym} 28320 -5020 0 0 {name=p28261 lab=_79444_/A }
C {devices/lab_pin.sym} 28320 -4980 0 0 {name=p28262 lab=_79444_/B }
C {devices/lab_pin.sym} 28440 -5000 0 1 {name=p28263 lab=_79438_/B }
C {sky130_stdcells/xnor2_4.sym} 28380 -5000 0 0 {name=X_79437_ }
C {devices/lab_pin.sym} 28300 -4890 0 0 {name=p28264 lab=_45825_/X }
C {devices/lab_pin.sym} 28300 -4850 0 0 {name=p28265 lab=_45828_/X }
C {devices/lab_pin.sym} 28300 -4810 0 0 {name=p28266 lab=_44898_/X }
C {devices/lab_pin.sym} 28460 -4850 0 1 {name=p28267 lab=_45829_/X }
C {sky130_stdcells/a21o_4.sym} 28380 -4850 0 0 {name=X_45829_ }
C {devices/lab_pin.sym} 28320 -4730 0 0 {name=p28268 lab=_64637_/X }
C {devices/lab_pin.sym} 28320 -4690 0 0 {name=p28269 lab=_64638_/B }
C {devices/lab_pin.sym} 28320 -4650 0 0 {name=p28270 lab=_64663_/C }
C {devices/lab_pin.sym} 28440 -4690 0 1 {name=p28271 lab=_64663_/X }
C {sky130_stdcells/and3_4.sym} 28380 -4690 0 0 {name=X_64663_ }
C {devices/lab_pin.sym} 28320 -4560 0 0 {name=p28272 lab=_81570_/Q }
C {devices/lab_pin.sym} 28320 -4520 0 0 {name=p28273 lab=_76649_/B }
C {devices/lab_pin.sym} 28440 -4540 0 1 {name=p28274 lab=_81538_/D }
C {sky130_stdcells/xor2_4.sym} 28380 -4540 0 0 {name=X_76649_ }
C {devices/lab_pin.sym} 28340 -4410 0 0 {name=p28275 lab=_49571_/A }
C {devices/lab_pin.sym} 28420 -4410 0 1 {name=p28276 lab=_49610_/A }
C {sky130_stdcells/buf_2.sym} 28380 -4410 0 0 {name=X_49597_ }
C {devices/lab_pin.sym} 28320 -4320 0 0 {name=p28277 lab=_61437_/B }
C {devices/lab_pin.sym} 28320 -4280 0 0 {name=p28278 lab=_61843_/B }
C {devices/lab_pin.sym} 28320 -4240 0 0 {name=p28279 lab=_61860_/C }
C {devices/lab_pin.sym} 28320 -4200 0 0 {name=p28280 lab=_61860_/D }
C {devices/lab_pin.sym} 28440 -4260 0 1 {name=p28281 lab=_61875_/Y }
C {sky130_stdcells/nand4_4.sym} 28380 -4260 0 0 {name=X_61875_ }
C {devices/lab_pin.sym} 28320 -4130 0 0 {name=p28282 lab=_66389_/A }
C {devices/lab_pin.sym} 28320 -4090 0 0 {name=p28283 lab=_66402_/B }
C {devices/lab_pin.sym} 28320 -4050 0 0 {name=p28284 lab=_66402_/C }
C {devices/lab_pin.sym} 28440 -4090 0 1 {name=p28285 lab=_66402_/Y }
C {sky130_stdcells/nor3_4.sym} 28380 -4090 0 0 {name=X_66402_ }
C {devices/lab_pin.sym} 28300 -3990 0 0 {name=p28286 lab=_63556_/X }
C {devices/lab_pin.sym} 28300 -3950 0 0 {name=p28287 lab=_63607_/X }
C {devices/lab_pin.sym} 28300 -3910 0 0 {name=p28288 lab=_63608_/X }
C {devices/lab_pin.sym} 28300 -3870 0 0 {name=p28289 lab=_63612_/X }
C {devices/lab_pin.sym} 28300 -3830 0 0 {name=p28290 lab=_63613_/Y }
C {devices/lab_pin.sym} 28460 -3910 0 1 {name=p28291 lab=_63614_/Y }
C {sky130_stdcells/o41ai_4.sym} 28380 -3910 0 0 {name=X_63614_ }
C {devices/lab_pin.sym} 28320 -3770 0 0 {name=p28292 lab=_60826_/A }
C {devices/lab_pin.sym} 28320 -3730 0 0 {name=p28293 lab=_60810_/B }
C {devices/lab_pin.sym} 28320 -3690 0 0 {name=p28294 lab=_60826_/C }
C {devices/lab_pin.sym} 28440 -3730 0 1 {name=p28295 lab=_60826_/Y }
C {sky130_stdcells/nor3_4.sym} 28380 -3730 0 0 {name=X_60826_ }
C {devices/lab_pin.sym} 28340 -3590 0 0 {name=p28296 lab=_48548_/A }
C {devices/lab_pin.sym} 28420 -3590 0 1 {name=p28297 lab=_48548_/X }
C {sky130_stdcells/buf_2.sym} 28380 -3590 0 0 {name=X_48548_ }
C {devices/lab_pin.sym} 28320 -3480 0 0 {name=p28298 lab=_79365_/X }
C {devices/lab_pin.sym} 28320 -3440 0 0 {name=p28299 lab=_79368_/B }
C {devices/lab_pin.sym} 28440 -3460 0 1 {name=p28300 lab=_82835_/D }
C {sky130_stdcells/xnor2_4.sym} 28380 -3460 0 0 {name=X_79368_ }
C {devices/lab_pin.sym} 28300 -3360 0 0 {name=p28301 lab=_87409_/Q }
C {devices/lab_pin.sym} 28300 -3320 0 0 {name=p28302 lab=_67358_/X }
C {devices/lab_pin.sym} 28300 -3280 0 0 {name=p28303 lab=_67360_/X }
C {devices/lab_pin.sym} 28300 -3240 0 0 {name=p28304 lab=_67381_/X }
C {devices/lab_pin.sym} 28460 -3300 0 1 {name=p28305 lab=_67382_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -3300 0 0 {name=X_67382_ }
C {devices/lab_pin.sym} 28300 -3180 0 0 {name=p28306 lab=_64589_/X }
C {devices/lab_pin.sym} 28300 -3140 0 0 {name=p28307 lab=_85569_/Q }
C {devices/lab_pin.sym} 28300 -3100 0 0 {name=p28308 lab=_64591_/X }
C {devices/lab_pin.sym} 28300 -3060 0 0 {name=p28309 lab=_64593_/X }
C {devices/lab_pin.sym} 28460 -3120 0 1 {name=p28310 lab=_64594_/X }
C {sky130_stdcells/a211o_4.sym} 28380 -3120 0 0 {name=X_64594_ }
C {devices/lab_pin.sym} 28340 -2970 0 0 {name=p28311 lab=_69645_/A }
C {devices/lab_pin.sym} 28420 -2970 0 1 {name=p28312 lab=_69121_/X }
C {sky130_stdcells/buf_2.sym} 28380 -2970 0 0 {name=X_69121_ }
C {devices/lab_pin.sym} 28300 -2870 0 0 {name=p28313 lab=_66330_/Y }
C {devices/lab_pin.sym} 28300 -2830 0 0 {name=p28314 lab=_66278_/X }
C {devices/lab_pin.sym} 28300 -2790 0 0 {name=p28315 lab=_66332_/Y }
C {devices/lab_pin.sym} 28460 -2830 0 1 {name=p28316 lab=_84140_/D }
C {sky130_stdcells/a21o_4.sym} 28380 -2830 0 0 {name=X_66333_ }
C {devices/lab_pin.sym} 28320 -2700 0 0 {name=p28317 lab=_78312_/A }
C {devices/lab_pin.sym} 28320 -2660 0 0 {name=p28318 lab=_82658_/D }
C {devices/lab_pin.sym} 28440 -2680 0 1 {name=p28319 lab=_78320_/A }
C {sky130_stdcells/nor2_4.sym} 28380 -2680 0 0 {name=X_78319_ }
C {devices/lab_pin.sym} 28340 -2550 0 0 {name=p28320 lab=_63484_/A }
C {devices/lab_pin.sym} 28420 -2550 0 1 {name=p28321 lab=_63546_/A }
C {sky130_stdcells/buf_2.sym} 28380 -2550 0 0 {name=X_63545_ }
C {devices/lab_pin.sym} 28340 -2430 0 0 {name=p28322 lab=_48613_/A }
C {devices/lab_pin.sym} 28420 -2430 0 1 {name=p28323 lab=_48515_/A }
C {sky130_stdcells/buf_2.sym} 28380 -2430 0 0 {name=X_48479_ }
C {devices/lab_pin.sym} 28340 -2310 0 0 {name=p28324 lab=_63417_/A }
C {devices/lab_pin.sym} 28420 -2310 0 1 {name=p28325 lab=_63389_/D }
C {sky130_stdcells/buf_2.sym} 28380 -2310 0 0 {name=X_60757_ }
C {devices/lab_pin.sym} 28300 -2210 0 0 {name=p28326 lab=_79287_/X }
C {devices/lab_pin.sym} 28300 -2170 0 0 {name=p28327 lab=_79288_/X }
C {devices/lab_pin.sym} 28300 -2130 0 0 {name=p28328 lab=_79298_/Y }
C {devices/lab_pin.sym} 28460 -2170 0 1 {name=p28329 lab=_79303_/A }
C {sky130_stdcells/a21boi_4.sym} 28380 -2170 0 0 {name=X_79299_ }
C {devices/lab_pin.sym} 28340 -2030 0 0 {name=p28330 lab=_50510_/A }
C {devices/lab_pin.sym} 28420 -2030 0 1 {name=p28331 lab=_50526_/C }
C {sky130_stdcells/buf_2.sym} 28380 -2030 0 0 {name=X_50510_ }
C {devices/lab_pin.sym} 28290 -1910 0 0 {name=p28332 lab=_81330_/CLK }
C {devices/lab_pin.sym} 28290 -1890 0 0 {name=p28333 lab=_76388_/X }
C {devices/lab_pin.sym} 28470 -1910 0 1 {name=p28334 lab=_81706_/D }
C {sky130_stdcells/dfxtp_4.sym} 28380 -1900 0 0 {name=X_81330_ }
C {devices/lab_pin.sym} 28340 -1770 0 0 {name=p28335 lab=_69052_/A }
C {devices/lab_pin.sym} 28420 -1770 0 1 {name=p28336 lab=_69053_/B }
C {sky130_stdcells/inv_2.sym} 28380 -1770 0 0 {name=X_69052_ }
C {devices/lab_pin.sym} 28320 -1670 0 0 {name=p28337 lab=_66177_/A }
C {devices/lab_pin.sym} 28320 -1630 0 0 {name=p28338 lab=_66389_/B }
C {devices/lab_pin.sym} 28320 -1590 0 0 {name=p28339 lab=_66264_/C }
C {devices/lab_pin.sym} 28440 -1630 0 1 {name=p28340 lab=_66264_/Y }
C {sky130_stdcells/nor3_4.sym} 28380 -1630 0 0 {name=X_66264_ }
C {devices/lab_pin.sym} 28300 -1510 0 0 {name=p28341 lab=_51488_/Y }
C {devices/lab_pin.sym} 28300 -1470 0 0 {name=p28342 lab=_51477_/X }
C {devices/lab_pin.sym} 28300 -1430 0 0 {name=p28343 lab=_51489_/X }
C {devices/lab_pin.sym} 28460 -1470 0 1 {name=p28344 lab=_86001_/D }
C {sky130_stdcells/a21oi_4.sym} 28380 -1470 0 0 {name=X_51490_ }
C {devices/lab_pin.sym} 28320 -1350 0 0 {name=p28345 lab=_63463_/A }
C {devices/lab_pin.sym} 28320 -1310 0 0 {name=p28346 lab=_84960_/Q }
C {devices/lab_pin.sym} 28320 -1270 0 0 {name=p28347 lab=_63476_/C }
C {devices/lab_pin.sym} 28440 -1310 0 1 {name=p28348 lab=_63476_/X }
C {sky130_stdcells/and3_4.sym} 28380 -1310 0 0 {name=X_63476_ }
C {devices/lab_pin.sym} 28320 -1180 0 0 {name=p28349 lab=_60720_/A }
C {devices/lab_pin.sym} 28320 -1140 0 0 {name=p28350 lab=_60711_/A }
C {devices/lab_pin.sym} 28440 -1160 0 1 {name=p28351 lab=_60714_/A }
C {sky130_stdcells/nand2_4.sym} 28380 -1160 0 0 {name=X_60688_ }
C {devices/lab_pin.sym} 28320 -1040 0 0 {name=p28352 lab=_68025_/A }
C {devices/lab_pin.sym} 28320 -1000 0 0 {name=p28353 lab=_88215_/Q }
C {devices/lab_pin.sym} 28440 -1020 0 1 {name=p28354 lab=_68003_/X }
C {sky130_stdcells/and2_4.sym} 28380 -1020 0 0 {name=X_68003_ }
C {devices/lab_pin.sym} 28300 -910 0 0 {name=p28355 lab=_65210_/X }
C {devices/lab_pin.sym} 28300 -870 0 0 {name=p28356 lab=_65214_/X }
C {devices/lab_pin.sym} 28300 -830 0 0 {name=p28357 lab=_65161_/X }
C {devices/lab_pin.sym} 28460 -870 0 1 {name=p28358 lab=_65215_/X }
C {sky130_stdcells/a21o_4.sym} 28380 -870 0 0 {name=X_65215_ }
C {devices/lab_pin.sym} 28300 -750 0 0 {name=p28359 lab=_86200_/Q }
C {devices/lab_pin.sym} 28300 -710 0 0 {name=p28360 lab=_50437_/X }
C {devices/lab_pin.sym} 28300 -670 0 0 {name=p28361 lab=_50440_/Y }
C {devices/lab_pin.sym} 28460 -710 0 1 {name=p28362 lab=_50441_/Y }
C {sky130_stdcells/o21ai_4.sym} 28380 -710 0 0 {name=X_50441_ }
C {devices/lab_pin.sym} 29220 -42170 0 0 {name=p28363 lab=_62425_/Y }
C {devices/lab_pin.sym} 29220 -42130 0 0 {name=p28364 lab=_62396_/X }
C {devices/lab_pin.sym} 29220 -42090 0 0 {name=p28365 lab=_62426_/Y }
C {devices/lab_pin.sym} 29380 -42130 0 1 {name=p28366 lab=_84411_/D }
C {sky130_stdcells/a21oi_4.sym} 29300 -42130 0 0 {name=X_62427_ }
C {devices/lab_pin.sym} 29210 -41990 0 0 {name=p28367 lab=_81260_/CLK }
C {devices/lab_pin.sym} 29210 -41970 0 0 {name=p28368 lab=_81261_/D }
C {devices/lab_pin.sym} 29390 -41990 0 1 {name=p28369 lab=_76301_/A }
C {sky130_stdcells/dfxtp_4.sym} 29300 -41980 0 0 {name=X_81261_ }
C {devices/lab_pin.sym} 29240 -41870 0 0 {name=p28370 lab=_65737_/X }
C {devices/lab_pin.sym} 29240 -41830 0 0 {name=p28371 lab=_66195_/B }
C {devices/lab_pin.sym} 29240 -41790 0 0 {name=p28372 lab=_65740_/X }
C {devices/lab_pin.sym} 29360 -41830 0 1 {name=p28373 lab=_66204_/A }
C {sky130_stdcells/nand3_4.sym} 29300 -41830 0 0 {name=X_66195_ }
C {devices/lab_pin.sym} 29210 -41690 0 0 {name=p28374 lab=_83843_/CLK }
C {devices/lab_pin.sym} 29210 -41670 0 0 {name=p28375 lab=_74649_/X }
C {devices/lab_pin.sym} 29390 -41690 0 1 {name=p28376 lab=_83000_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -41680 0 0 {name=X_83000_ }
C {devices/lab_pin.sym} 29240 -41560 0 0 {name=p28377 lab=_80205_/X }
C {devices/lab_pin.sym} 29240 -41520 0 0 {name=p28378 lab=_80207_/B }
C {devices/lab_pin.sym} 29360 -41540 0 1 {name=p28379 lab=_80212_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -41540 0 0 {name=X_80212_ }
C {devices/lab_pin.sym} 29220 -41430 0 0 {name=p28380 lab=_53158_/Y }
C {devices/lab_pin.sym} 29220 -41390 0 0 {name=p28381 lab=_53137_/X }
C {devices/lab_pin.sym} 29220 -41350 0 0 {name=p28382 lab=_53159_/X }
C {devices/lab_pin.sym} 29380 -41390 0 1 {name=p28383 lab=_85686_/D }
C {sky130_stdcells/a21oi_4.sym} 29300 -41390 0 0 {name=X_53160_ }
C {devices/lab_pin.sym} 29260 -41250 0 0 {name=p28384 lab=_65669_/A }
C {devices/lab_pin.sym} 29340 -41250 0 1 {name=p28385 lab=_65146_/X }
C {sky130_stdcells/buf_2.sym} 29300 -41250 0 0 {name=X_65146_ }
C {devices/lab_pin.sym} 29240 -41140 0 0 {name=p28386 lab=_50381_/A }
C {devices/lab_pin.sym} 29240 -41100 0 0 {name=p28387 lab=_50372_/B }
C {devices/lab_pin.sym} 29360 -41120 0 1 {name=p28388 lab=_50372_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -41120 0 0 {name=X_50372_ }
C {devices/lab_pin.sym} 29240 -41020 0 0 {name=p28389 lab=_61451_/A }
C {devices/lab_pin.sym} 29240 -40980 0 0 {name=p28390 lab=_62332_/B }
C {devices/lab_pin.sym} 29240 -40940 0 0 {name=p28391 lab=_62386_/C }
C {devices/lab_pin.sym} 29240 -40900 0 0 {name=p28392 lab=_62332_/D }
C {devices/lab_pin.sym} 29360 -40960 0 1 {name=p28393 lab=_62358_/Y }
C {sky130_stdcells/nand4_4.sym} 29300 -40960 0 0 {name=X_62358_ }
C {devices/lab_pin.sym} 29210 -40810 0 0 {name=p28394 lab=_81195_/CLK }
C {devices/lab_pin.sym} 29210 -40790 0 0 {name=p28395 lab=_74940_/X }
C {devices/lab_pin.sym} 29390 -40810 0 1 {name=p28396 lab=_49140_/A }
C {sky130_stdcells/dfxtp_4.sym} 29300 -40800 0 0 {name=X_81192_ }
C {devices/lab_pin.sym} 29240 -40680 0 0 {name=p28397 lab=_52100_/A }
C {devices/lab_pin.sym} 29240 -40640 0 0 {name=p28398 lab=_48391_/X }
C {devices/lab_pin.sym} 29360 -40660 0 1 {name=p28399 lab=_52111_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -40660 0 0 {name=X_52111_ }
C {devices/lab_pin.sym} 29260 -40530 0 0 {name=p28400 lab=_72507_/A }
C {devices/lab_pin.sym} 29340 -40530 0 1 {name=p28401 lab=_61686_/A }
C {sky130_stdcells/buf_2.sym} 29300 -40530 0 0 {name=X_61309_ }
C {devices/lab_pin.sym} 29240 -40420 0 0 {name=p28402 lab=_84943_/Q }
C {devices/lab_pin.sym} 29240 -40380 0 0 {name=p28403 lab=_84191_/Q }
C {devices/lab_pin.sym} 29360 -40400 0 1 {name=p28404 lab=_80143_/X }
C {sky130_stdcells/xor2_4.sym} 29300 -40400 0 0 {name=X_80143_ }
C {devices/lab_pin.sym} 29220 -40300 0 0 {name=p28405 lab=_44149_/X }
C {devices/lab_pin.sym} 29220 -40260 0 0 {name=p28406 lab=_85519_/Q }
C {devices/lab_pin.sym} 29220 -40220 0 0 {name=p28407 lab=_64571_/X }
C {devices/lab_pin.sym} 29220 -40180 0 0 {name=p28408 lab=_65076_/X }
C {devices/lab_pin.sym} 29380 -40240 0 1 {name=p28409 lab=_65077_/X }
C {sky130_stdcells/a211o_4.sym} 29300 -40240 0 0 {name=X_65077_ }
C {devices/lab_pin.sym} 29220 -40110 0 0 {name=p28410 lab=_53087_/Y }
C {devices/lab_pin.sym} 29220 -40070 0 0 {name=p28411 lab=_53082_/X }
C {devices/lab_pin.sym} 29220 -40030 0 0 {name=p28412 lab=_53090_/X }
C {devices/lab_pin.sym} 29380 -40070 0 1 {name=p28413 lab=_53091_/Y }
C {sky130_stdcells/a21oi_4.sym} 29300 -40070 0 0 {name=X_53091_ }
C {devices/lab_pin.sym} 29220 -39950 0 0 {name=p28414 lab=_81956_/D }
C {devices/lab_pin.sym} 29220 -39910 0 0 {name=p28415 lab=_69894_/X }
C {devices/lab_pin.sym} 29220 -39870 0 0 {name=p28416 lab=_69953_/X }
C {devices/lab_pin.sym} 29380 -39910 0 1 {name=p28417 lab=_83884_/D }
C {sky130_stdcells/a21bo_4.sym} 29300 -39910 0 0 {name=X_69954_ }
C {devices/lab_pin.sym} 29240 -39800 0 0 {name=p28418 lab=_62288_/X }
C {devices/lab_pin.sym} 29240 -39760 0 0 {name=p28419 lab=_62285_/X }
C {devices/lab_pin.sym} 29240 -39720 0 0 {name=p28420 lab=_64275_/B }
C {devices/lab_pin.sym} 29240 -39680 0 0 {name=p28421 lab=_60025_/X }
C {devices/lab_pin.sym} 29360 -39740 0 1 {name=p28422 lab=_62289_/X }
C {sky130_stdcells/and4_4.sym} 29300 -39740 0 0 {name=X_62289_ }
C {devices/lab_pin.sym} 29260 -39590 0 0 {name=p28423 lab=_52185_/A }
C {devices/lab_pin.sym} 29340 -39590 0 1 {name=p28424 lab=_52070_/A }
C {sky130_stdcells/buf_2.sym} 29300 -39590 0 0 {name=X_52042_ }
C {devices/lab_pin.sym} 29220 -39500 0 0 {name=p28425 lab=_68666_/X }
C {devices/lab_pin.sym} 29220 -39460 0 0 {name=p28426 lab=_68882_/X }
C {devices/lab_pin.sym} 29220 -39420 0 0 {name=p28427 lab=_68894_/Y }
C {devices/lab_pin.sym} 29220 -39380 0 0 {name=p28428 lab=_68904_/Y }
C {devices/lab_pin.sym} 29380 -39440 0 1 {name=p28429 lab=_68905_/X }
C {sky130_stdcells/a211o_4.sym} 29300 -39440 0 0 {name=X_68905_ }
C {devices/lab_pin.sym} 29260 -39290 0 0 {name=p28430 lab=_60926_/X }
C {devices/lab_pin.sym} 29340 -39290 0 1 {name=p28431 lab=_64029_/D }
C {sky130_stdcells/buf_2.sym} 29300 -39290 0 0 {name=X_64028_ }
C {devices/lab_pin.sym} 29210 -39170 0 0 {name=p28432 lab=_84951_/CLK }
C {devices/lab_pin.sym} 29210 -39150 0 0 {name=p28433 lab=_84951_/D }
C {devices/lab_pin.sym} 29390 -39170 0 1 {name=p28434 lab=_84951_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -39160 0 0 {name=X_84951_ }
C {devices/lab_pin.sym} 29240 -39040 0 0 {name=p28435 lab=_80058_/X }
C {devices/lab_pin.sym} 29240 -39000 0 0 {name=p28436 lab=_80074_/B }
C {devices/lab_pin.sym} 29360 -39020 0 1 {name=p28437 lab=_80074_/X }
C {sky130_stdcells/or2_4.sym} 29300 -39020 0 0 {name=X_80074_ }
C {devices/lab_pin.sym} 29240 -38900 0 0 {name=p28438 lab=_69897_/A }
C {devices/lab_pin.sym} 29240 -38860 0 0 {name=p28439 lab=_69885_/B }
C {devices/lab_pin.sym} 29360 -38880 0 1 {name=p28440 lab=_69885_/Y }
C {sky130_stdcells/nor2_4.sym} 29300 -38880 0 0 {name=X_69885_ }
C {devices/lab_pin.sym} 29210 -38750 0 0 {name=p28441 lab=_82234_/CLK }
C {devices/lab_pin.sym} 29210 -38730 0 0 {name=p28442 lab=_83902_/D }
C {devices/lab_pin.sym} 29390 -38750 0 1 {name=p28443 lab=_83902_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -38740 0 0 {name=X_83902_ }
C {devices/lab_pin.sym} 29260 -38610 0 0 {name=p28444 lab=_56849_/X }
C {devices/lab_pin.sym} 29340 -38610 0 1 {name=p28445 lab=_56850_/X }
C {sky130_stdcells/buf_2.sym} 29300 -38610 0 0 {name=X_56850_ }
C {devices/lab_pin.sym} 29220 -38520 0 0 {name=p28446 lab=_68822_/Y }
C {devices/lab_pin.sym} 29220 -38480 0 0 {name=p28447 lab=_68823_/X }
C {devices/lab_pin.sym} 29220 -38440 0 0 {name=p28448 lab=_68824_/X }
C {devices/lab_pin.sym} 29220 -38400 0 0 {name=p28449 lab=_68835_/Y }
C {devices/lab_pin.sym} 29380 -38460 0 1 {name=p28450 lab=_68836_/X }
C {sky130_stdcells/a211o_4.sym} 29300 -38460 0 0 {name=X_68836_ }
C {devices/lab_pin.sym} 29210 -38310 0 0 {name=p28451 lab=_87671_/CLK }
C {devices/lab_pin.sym} 29210 -38290 0 0 {name=p28452 lab=_42883_/Y }
C {devices/lab_pin.sym} 29390 -38310 0 1 {name=p28453 lab=_87670_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -38300 0 0 {name=X_87670_ }
C {devices/lab_pin.sym} 29210 -38170 0 0 {name=p28454 lab=_84921_/CLK }
C {devices/lab_pin.sym} 29210 -38150 0 0 {name=p28455 lab=_84882_/D }
C {devices/lab_pin.sym} 29390 -38170 0 1 {name=p28456 lab=_84882_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -38160 0 0 {name=X_84882_ }
C {devices/lab_pin.sym} 29240 -38060 0 0 {name=p28457 lab=_55801_/A }
C {devices/lab_pin.sym} 29240 -38020 0 0 {name=p28458 lab=_55801_/B }
C {devices/lab_pin.sym} 29240 -37980 0 0 {name=p28459 lab=_55801_/C }
C {devices/lab_pin.sym} 29240 -37940 0 0 {name=p28460 lab=_55801_/D }
C {devices/lab_pin.sym} 29360 -38000 0 1 {name=p28461 lab=_55802_/A }
C {sky130_stdcells/and4_4.sym} 29300 -38000 0 0 {name=X_55801_ }
C {devices/lab_pin.sym} 29210 -37850 0 0 {name=p28462 lab=_85981_/CLK }
C {devices/lab_pin.sym} 29210 -37830 0 0 {name=p28463 lab=_47569_/Y }
C {devices/lab_pin.sym} 29390 -37850 0 1 {name=p28464 lab=_86621_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -37840 0 0 {name=X_86621_ }
C {devices/lab_pin.sym} 29210 -37710 0 0 {name=p28465 lab=_83191_/CLK }
C {devices/lab_pin.sym} 29210 -37690 0 0 {name=p28466 lab=_83833_/D }
C {devices/lab_pin.sym} 29390 -37710 0 1 {name=p28467 lab=_83833_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -37700 0 0 {name=X_83833_ }
C {devices/lab_pin.sym} 29260 -37570 0 0 {name=p28468 lab=_56780_/X }
C {devices/lab_pin.sym} 29340 -37570 0 1 {name=p28469 lab=_85133_/D }
C {sky130_stdcells/inv_2.sym} 29300 -37570 0 0 {name=X_56781_ }
C {devices/lab_pin.sym} 29220 -37470 0 0 {name=p28470 lab=_80818_/D }
C {devices/lab_pin.sym} 29220 -37430 0 0 {name=p28471 lab=_68713_/X }
C {devices/lab_pin.sym} 29220 -37390 0 0 {name=p28472 lab=_68766_/X }
C {devices/lab_pin.sym} 29380 -37430 0 1 {name=p28473 lab=_83962_/D }
C {sky130_stdcells/a21bo_4.sym} 29300 -37430 0 0 {name=X_68767_ }
C {devices/lab_pin.sym} 29240 -37300 0 0 {name=p28474 lab=_53978_/A }
C {devices/lab_pin.sym} 29240 -37260 0 0 {name=p28475 lab=_53993_/B }
C {devices/lab_pin.sym} 29360 -37280 0 1 {name=p28476 lab=_53993_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -37280 0 0 {name=X_53993_ }
C {devices/lab_pin.sym} 29220 -37170 0 0 {name=p28477 lab=_65973_/X }
C {devices/lab_pin.sym} 29220 -37130 0 0 {name=p28478 lab=_65978_/X }
C {devices/lab_pin.sym} 29220 -37090 0 0 {name=p28479 lab=_65880_/X }
C {devices/lab_pin.sym} 29380 -37130 0 1 {name=p28480 lab=_65983_/A }
C {sky130_stdcells/a21o_4.sym} 29300 -37130 0 0 {name=X_65979_ }
C {devices/lab_pin.sym} 29240 -37000 0 0 {name=p28481 lab=_58520_/A }
C {devices/lab_pin.sym} 29240 -36960 0 0 {name=p28482 lab=_58510_/X }
C {devices/lab_pin.sym} 29360 -36980 0 1 {name=p28483 lab=_58520_/Y }
C {sky130_stdcells/nor2_4.sym} 29300 -36980 0 0 {name=X_58520_ }
C {devices/lab_pin.sym} 29240 -36860 0 0 {name=p28484 lab=_55235_/A }
C {devices/lab_pin.sym} 29240 -36820 0 0 {name=p28485 lab=_55732_/B }
C {devices/lab_pin.sym} 29360 -36840 0 1 {name=p28486 lab=_55732_/X }
C {sky130_stdcells/and2_4.sym} 29300 -36840 0 0 {name=X_55732_ }
C {devices/lab_pin.sym} 29260 -36710 0 0 {name=p28487 lab=_67359_/X }
C {devices/lab_pin.sym} 29340 -36710 0 1 {name=p28488 lab=_67718_/X }
C {sky130_stdcells/buf_2.sym} 29300 -36710 0 0 {name=X_67718_ }
C {devices/lab_pin.sym} 29210 -36590 0 0 {name=p28489 lab=_85915_/CLK }
C {devices/lab_pin.sym} 29210 -36570 0 0 {name=p28490 lab=_86552_/D }
C {devices/lab_pin.sym} 29390 -36590 0 1 {name=p28491 lab=_66041_/B }
C {sky130_stdcells/dfxtp_4.sym} 29300 -36580 0 0 {name=X_86552_ }
C {devices/lab_pin.sym} 29240 -36460 0 0 {name=p28492 lab=_52944_/A }
C {devices/lab_pin.sym} 29240 -36420 0 0 {name=p28493 lab=_52944_/B }
C {devices/lab_pin.sym} 29360 -36440 0 1 {name=p28494 lab=_52944_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -36440 0 0 {name=X_52944_ }
C {devices/lab_pin.sym} 29210 -36310 0 0 {name=p28495 lab=_83482_/CLK }
C {devices/lab_pin.sym} 29210 -36290 0 0 {name=p28496 lab=_83764_/D }
C {devices/lab_pin.sym} 29390 -36310 0 1 {name=p28497 lab=_83764_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -36300 0 0 {name=X_83764_ }
C {devices/lab_pin.sym} 29210 -36170 0 0 {name=p28498 lab=_82084_/CLK }
C {devices/lab_pin.sym} 29210 -36150 0 0 {name=p28499 lab=_80976_/D }
C {devices/lab_pin.sym} 29390 -36170 0 1 {name=p28500 lab=_80932_/D }
C {sky130_stdcells/dfxtp_4.sym} 29300 -36160 0 0 {name=X_80976_ }
C {devices/lab_pin.sym} 29220 -36050 0 0 {name=p28501 lab=_68694_/X }
C {devices/lab_pin.sym} 29220 -36010 0 0 {name=p28502 lab=_68696_/X }
C {devices/lab_pin.sym} 29220 -35970 0 0 {name=p28503 lab=_68697_/X }
C {devices/lab_pin.sym} 29380 -36010 0 1 {name=p28504 lab=_68698_/X }
C {sky130_stdcells/a21o_4.sym} 29300 -36010 0 0 {name=X_68698_ }
C {devices/lab_pin.sym} 29210 -35870 0 0 {name=p28505 lab=_85505_/CLK }
C {devices/lab_pin.sym} 29210 -35850 0 0 {name=p28506 lab=_85503_/D }
C {devices/lab_pin.sym} 29390 -35870 0 1 {name=p28507 lab=_85503_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -35860 0 0 {name=X_85503_ }
C {devices/lab_pin.sym} 29260 -35730 0 0 {name=p28508 lab=_58984_/A }
C {devices/lab_pin.sym} 29340 -35730 0 1 {name=p28509 lab=_58498_/B }
C {sky130_stdcells/buf_2.sym} 29300 -35730 0 0 {name=X_58451_ }
C {devices/lab_pin.sym} 29210 -35610 0 0 {name=p28510 lab=_82715_/CLK }
C {devices/lab_pin.sym} 29210 -35590 0 0 {name=p28511 lab=_79035_/X }
C {devices/lab_pin.sym} 29390 -35610 0 1 {name=p28512 lab=_82671_/D }
C {sky130_stdcells/dfxtp_4.sym} 29300 -35600 0 0 {name=X_82715_ }
C {devices/lab_pin.sym} 29260 -35470 0 0 {name=p28513 lab=_83317_/Q }
C {devices/lab_pin.sym} 29340 -35470 0 1 {name=p28514 lab=_55663_/Y }
C {sky130_stdcells/inv_2.sym} 29300 -35470 0 0 {name=X_55663_ }
C {devices/lab_pin.sym} 29240 -35360 0 0 {name=p28515 lab=_67649_/A }
C {devices/lab_pin.sym} 29240 -35320 0 0 {name=p28516 lab=_67649_/B }
C {devices/lab_pin.sym} 29360 -35340 0 1 {name=p28517 lab=_67649_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -35340 0 0 {name=X_67649_ }
C {devices/lab_pin.sym} 29210 -35210 0 0 {name=p28518 lab=_86193_/CLK }
C {devices/lab_pin.sym} 29210 -35190 0 0 {name=p28519 lab=_48787_/Y }
C {devices/lab_pin.sym} 29390 -35210 0 1 {name=p28520 lab=_86483_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -35200 0 0 {name=X_86483_ }
C {devices/lab_pin.sym} 29260 -35070 0 0 {name=p28521 lab=_52767_/A }
C {devices/lab_pin.sym} 29340 -35070 0 1 {name=p28522 lab=_52885_/A }
C {sky130_stdcells/buf_2.sym} 29300 -35070 0 0 {name=X_52875_ }
C {devices/lab_pin.sym} 29210 -34950 0 0 {name=p28523 lab=_83699_/CLK }
C {devices/lab_pin.sym} 29210 -34930 0 0 {name=p28524 lab=_83695_/D }
C {devices/lab_pin.sym} 29390 -34950 0 1 {name=p28525 lab=_83695_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -34940 0 0 {name=X_83695_ }
C {devices/lab_pin.sym} 29220 -34830 0 0 {name=p28526 lab=_56626_/X }
C {devices/lab_pin.sym} 29220 -34790 0 0 {name=p28527 lab=_57391_/Y }
C {devices/lab_pin.sym} 29220 -34750 0 0 {name=p28528 lab=_57401_/Y }
C {devices/lab_pin.sym} 29380 -34790 0 1 {name=p28529 lab=_85015_/D }
C {sky130_stdcells/a21oi_4.sym} 29300 -34790 0 0 {name=X_57402_ }
C {devices/lab_pin.sym} 29210 -34650 0 0 {name=p28530 lab=_88232_/CLK }
C {devices/lab_pin.sym} 29210 -34630 0 0 {name=p28531 lab=_88222_/D }
C {devices/lab_pin.sym} 29390 -34650 0 1 {name=p28532 lab=_67848_/B }
C {sky130_stdcells/dfxtp_4.sym} 29300 -34640 0 0 {name=X_88222_ }
C {devices/lab_pin.sym} 29240 -34520 0 0 {name=p28533 lab=_54600_/A }
C {devices/lab_pin.sym} 29240 -34480 0 0 {name=p28534 lab=_47221_/A }
C {devices/lab_pin.sym} 29360 -34500 0 1 {name=p28535 lab=_54614_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -34500 0 0 {name=X_54614_ }
C {devices/lab_pin.sym} 29210 -34370 0 0 {name=p28536 lab=_85433_/CLK }
C {devices/lab_pin.sym} 29210 -34350 0 0 {name=p28537 lab=_54484_/Y }
C {devices/lab_pin.sym} 29390 -34370 0 1 {name=p28538 lab=_85434_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -34360 0 0 {name=X_85434_ }
C {devices/lab_pin.sym} 29240 -34240 0 0 {name=p28539 lab=_51820_/A }
C {devices/lab_pin.sym} 29240 -34200 0 0 {name=p28540 lab=_50961_/B }
C {devices/lab_pin.sym} 29360 -34220 0 1 {name=p28541 lab=_51826_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -34220 0 0 {name=X_51826_ }
C {devices/lab_pin.sym} 29260 -34090 0 0 {name=p28542 lab=_70423_/X }
C {devices/lab_pin.sym} 29340 -34090 0 1 {name=p28543 lab=_70886_/A }
C {sky130_stdcells/buf_2.sym} 29300 -34090 0 0 {name=X_70660_ }
C {devices/lab_pin.sym} 29210 -33970 0 0 {name=p28544 lab=_82648_/CLK }
C {devices/lab_pin.sym} 29210 -33950 0 0 {name=p28545 lab=_83998_/Q }
C {devices/lab_pin.sym} 29390 -33970 0 1 {name=p28546 lab=_82646_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -33960 0 0 {name=X_82646_ }
C {devices/lab_pin.sym} 29260 -33830 0 0 {name=p28547 lab=_58382_/A }
C {devices/lab_pin.sym} 29340 -33830 0 1 {name=p28548 lab=_58383_/A }
C {sky130_stdcells/inv_2.sym} 29300 -33830 0 0 {name=X_58382_ }
C {devices/lab_pin.sym} 29240 -33720 0 0 {name=p28549 lab=_55572_/X }
C {devices/lab_pin.sym} 29240 -33680 0 0 {name=p28550 lab=_45438_/Y }
C {devices/lab_pin.sym} 29360 -33700 0 1 {name=p28551 lab=_55594_/Y }
C {sky130_stdcells/nor2_4.sym} 29300 -33700 0 0 {name=X_55594_ }
C {devices/lab_pin.sym} 29220 -33590 0 0 {name=p28552 lab=_56732_/X }
C {devices/lab_pin.sym} 29220 -33550 0 0 {name=p28553 lab=_57290_/A }
C {devices/lab_pin.sym} 29220 -33510 0 0 {name=p28554 lab=_57332_/Y }
C {devices/lab_pin.sym} 29380 -33550 0 1 {name=p28555 lab=_57333_/X }
C {sky130_stdcells/o21a_4.sym} 29300 -33550 0 0 {name=X_57333_ }
C {devices/lab_pin.sym} 29220 -33440 0 0 {name=p28556 lab=_87526_/Q }
C {devices/lab_pin.sym} 29220 -33400 0 0 {name=p28557 lab=_69261_/X }
C {devices/lab_pin.sym} 29220 -33360 0 0 {name=p28558 lab=_69248_/X }
C {devices/lab_pin.sym} 29220 -33320 0 0 {name=p28559 lab=_69318_/X }
C {devices/lab_pin.sym} 29380 -33380 0 1 {name=p28560 lab=_69319_/X }
C {sky130_stdcells/a211o_4.sym} 29300 -33380 0 0 {name=X_69319_ }
C {devices/lab_pin.sym} 29210 -33230 0 0 {name=p28561 lab=_87141_/CLK }
C {devices/lab_pin.sym} 29210 -33210 0 0 {name=p28562 lab=_88153_/D }
C {devices/lab_pin.sym} 29390 -33230 0 1 {name=p28563 lab=_88153_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -33220 0 0 {name=X_88153_ }
C {devices/lab_pin.sym} 29220 -33110 0 0 {name=p28564 lab=_54543_/Y }
C {devices/lab_pin.sym} 29220 -33070 0 0 {name=p28565 lab=_54530_/X }
C {devices/lab_pin.sym} 29220 -33030 0 0 {name=p28566 lab=_54544_/X }
C {devices/lab_pin.sym} 29380 -33070 0 1 {name=p28567 lab=_54545_/Y }
C {sky130_stdcells/a21oi_4.sym} 29300 -33070 0 0 {name=X_54545_ }
C {devices/lab_pin.sym} 29210 -32930 0 0 {name=p28568 lab=_83630_/CLK }
C {devices/lab_pin.sym} 29210 -32910 0 0 {name=p28569 lab=_54858_/Y }
C {devices/lab_pin.sym} 29390 -32930 0 1 {name=p28570 lab=_85365_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -32920 0 0 {name=X_85365_ }
C {devices/lab_pin.sym} 29220 -32810 0 0 {name=p28571 lab=_51753_/Y }
C {devices/lab_pin.sym} 29220 -32770 0 0 {name=p28572 lab=_51391_/X }
C {devices/lab_pin.sym} 29220 -32730 0 0 {name=p28573 lab=_51756_/X }
C {devices/lab_pin.sym} 29380 -32770 0 1 {name=p28574 lab=_85952_/D }
C {sky130_stdcells/a21oi_4.sym} 29300 -32770 0 0 {name=X_51757_ }
C {devices/lab_pin.sym} 29260 -32630 0 0 {name=p28575 lab=_70591_/A }
C {devices/lab_pin.sym} 29340 -32630 0 1 {name=p28576 lab=_74533_/D }
C {sky130_stdcells/buf_2.sym} 29300 -32630 0 0 {name=X_70591_ }
C {devices/lab_pin.sym} 29210 -32510 0 0 {name=p28577 lab=_82702_/CLK }
C {devices/lab_pin.sym} 29210 -32490 0 0 {name=p28578 lab=_82609_/Q }
C {devices/lab_pin.sym} 29390 -32510 0 1 {name=p28579 lab=_78183_/A }
C {sky130_stdcells/dfxtp_4.sym} 29300 -32500 0 0 {name=X_82577_ }
C {devices/lab_pin.sym} 29210 -32370 0 0 {name=p28580 lab=_87110_/CLK }
C {devices/lab_pin.sym} 29210 -32350 0 0 {name=p28581 lab=_87104_/D }
C {devices/lab_pin.sym} 29390 -32370 0 1 {name=p28582 lab=_87104_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -32360 0 0 {name=X_87104_ }
C {devices/lab_pin.sym} 29220 -32250 0 0 {name=p28583 lab=_41481_/X }
C {devices/lab_pin.sym} 29220 -32210 0 0 {name=p28584 lab=_82327_/Q }
C {devices/lab_pin.sym} 29220 -32170 0 0 {name=p28585 lab=_41509_/X }
C {devices/lab_pin.sym} 29380 -32210 0 1 {name=p28586 lab=_41510_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -32210 0 0 {name=X_41510_ }
C {devices/lab_pin.sym} 29220 -32090 0 0 {name=p28587 lab=_72326_/Y }
C {devices/lab_pin.sym} 29220 -32050 0 0 {name=p28588 lab=_72329_/Y }
C {devices/lab_pin.sym} 29220 -32010 0 0 {name=p28589 lab=_72292_/X }
C {devices/lab_pin.sym} 29380 -32050 0 1 {name=p28590 lab=_72330_/X }
C {sky130_stdcells/a21o_4.sym} 29300 -32050 0 0 {name=X_72330_ }
C {devices/lab_pin.sym} 29210 -31910 0 0 {name=p28591 lab=_84314_/CLK }
C {devices/lab_pin.sym} 29210 -31890 0 0 {name=p28592 lab=_63531_/Y }
C {devices/lab_pin.sym} 29390 -31910 0 1 {name=p28593 lab=_84316_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -31900 0 0 {name=X_84316_ }
C {devices/lab_pin.sym} 29240 -31780 0 0 {name=p28594 lab=_50738_/A }
C {devices/lab_pin.sym} 29240 -31740 0 0 {name=p28595 lab=_50708_/B }
C {devices/lab_pin.sym} 29360 -31760 0 1 {name=p28596 lab=_50708_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -31760 0 0 {name=X_50708_ }
C {devices/lab_pin.sym} 29240 -31650 0 0 {name=p28597 lab=_45947_/B }
C {devices/lab_pin.sym} 29240 -31610 0 0 {name=p28598 lab=_56971_/B }
C {devices/lab_pin.sym} 29240 -31570 0 0 {name=p28599 lab=_56899_/Y }
C {devices/lab_pin.sym} 29360 -31610 0 1 {name=p28600 lab=_57264_/Y }
C {sky130_stdcells/nor3_4.sym} 29300 -31610 0 0 {name=X_57264_ }
C {devices/lab_pin.sym} 29210 -31470 0 0 {name=p28601 lab=_84014_/CLK }
C {devices/lab_pin.sym} 29210 -31450 0 0 {name=p28602 lab=_81528_/D }
C {devices/lab_pin.sym} 29390 -31470 0 1 {name=p28603 lab=_81528_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -31460 0 0 {name=X_81528_ }
C {devices/lab_pin.sym} 29210 -31330 0 0 {name=p28604 lab=_88084_/CLK }
C {devices/lab_pin.sym} 29210 -31310 0 0 {name=p28605 lab=_88084_/D }
C {devices/lab_pin.sym} 29390 -31330 0 1 {name=p28606 lab=_88084_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -31320 0 0 {name=X_88084_ }
C {devices/lab_pin.sym} 29220 -31230 0 0 {name=p28607 lab=_42486_/X }
C {devices/lab_pin.sym} 29220 -31190 0 0 {name=p28608 lab=_42472_/X }
C {devices/lab_pin.sym} 29220 -31150 0 0 {name=p28609 lab=_40650_/X }
C {devices/lab_pin.sym} 29220 -31110 0 0 {name=p28610 lab=_68641_/B }
C {devices/lab_pin.sym} 29220 -31070 0 0 {name=p28611 lab=_42489_/X }
C {devices/lab_pin.sym} 29380 -31150 0 1 {name=p28612 lab=_42490_/Y }
C {sky130_stdcells/o32ai_4.sym} 29300 -31150 0 0 {name=X_42490_ }
C {devices/lab_pin.sym} 29240 -31020 0 0 {name=p28613 lab=_54453_/X }
C {devices/lab_pin.sym} 29240 -30980 0 0 {name=p28614 lab=_54471_/B }
C {devices/lab_pin.sym} 29240 -30940 0 0 {name=p28615 lab=_54471_/C }
C {devices/lab_pin.sym} 29240 -30900 0 0 {name=p28616 lab=_46979_/Y }
C {devices/lab_pin.sym} 29360 -30960 0 1 {name=p28617 lab=_54476_/X }
C {sky130_stdcells/and4_4.sym} 29300 -30960 0 0 {name=X_54476_ }
C {devices/lab_pin.sym} 29210 -30810 0 0 {name=p28618 lab=_85279_/CLK }
C {devices/lab_pin.sym} 29210 -30790 0 0 {name=p28619 lab=_85296_/D }
C {devices/lab_pin.sym} 29390 -30810 0 1 {name=p28620 lab=_85296_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -30800 0 0 {name=X_85296_ }
C {devices/lab_pin.sym} 29260 -30670 0 0 {name=p28621 lab=_51608_/A }
C {devices/lab_pin.sym} 29340 -30670 0 1 {name=p28622 lab=_51695_/C }
C {sky130_stdcells/buf_2.sym} 29300 -30670 0 0 {name=X_51688_ }
C {devices/lab_pin.sym} 29220 -30570 0 0 {name=p28623 lab=_59001_/X }
C {devices/lab_pin.sym} 29220 -30530 0 0 {name=p28624 lab=_86081_/Q }
C {devices/lab_pin.sym} 29220 -30490 0 0 {name=p28625 lab=_59002_/X }
C {devices/lab_pin.sym} 29380 -30530 0 1 {name=p28626 lab=_59003_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -30530 0 0 {name=X_59003_ }
C {devices/lab_pin.sym} 29220 -30410 0 0 {name=p28627 lab=_56188_/X }
C {devices/lab_pin.sym} 29220 -30370 0 0 {name=p28628 lab=_56050_/X }
C {devices/lab_pin.sym} 29220 -30330 0 0 {name=p28629 lab=_56214_/Y }
C {devices/lab_pin.sym} 29380 -30370 0 1 {name=p28630 lab=_56215_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -30370 0 0 {name=X_56215_ }
C {devices/lab_pin.sym} 29210 -30230 0 0 {name=p28631 lab=_87333_/CLK }
C {devices/lab_pin.sym} 29210 -30210 0 0 {name=p28632 lab=_87035_/D }
C {devices/lab_pin.sym} 29390 -30230 0 1 {name=p28633 lab=_87035_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -30220 0 0 {name=X_87035_ }
C {devices/lab_pin.sym} 29220 -30110 0 0 {name=p28634 lab=_41421_/X }
C {devices/lab_pin.sym} 29220 -30070 0 0 {name=p28635 lab=_82884_/Q }
C {devices/lab_pin.sym} 29220 -30030 0 0 {name=p28636 lab=_41440_/X }
C {devices/lab_pin.sym} 29380 -30070 0 1 {name=p28637 lab=_41441_/X }
C {sky130_stdcells/o21a_4.sym} 29300 -30070 0 0 {name=X_41441_ }
C {devices/lab_pin.sym} 29220 -29950 0 0 {name=p28638 lab=_85635_/Q }
C {devices/lab_pin.sym} 29220 -29910 0 0 {name=p28639 lab=_53404_/X }
C {devices/lab_pin.sym} 29220 -29870 0 0 {name=p28640 lab=_53426_/Y }
C {devices/lab_pin.sym} 29380 -29910 0 1 {name=p28641 lab=_53427_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -29910 0 0 {name=X_53427_ }
C {devices/lab_pin.sym} 29220 -29790 0 0 {name=p28642 lab=_72257_/Y }
C {devices/lab_pin.sym} 29220 -29750 0 0 {name=p28643 lab=_72260_/Y }
C {devices/lab_pin.sym} 29220 -29710 0 0 {name=p28644 lab=_72201_/X }
C {devices/lab_pin.sym} 29380 -29750 0 1 {name=p28645 lab=_72261_/X }
C {sky130_stdcells/a21o_4.sym} 29300 -29750 0 0 {name=X_72261_ }
C {devices/lab_pin.sym} 29210 -29610 0 0 {name=p28646 lab=_84849_/CLK }
C {devices/lab_pin.sym} 29210 -29590 0 0 {name=p28647 lab=_84247_/D }
C {devices/lab_pin.sym} 29390 -29610 0 1 {name=p28648 lab=_79691_/B }
C {sky130_stdcells/dfxtp_4.sym} 29300 -29600 0 0 {name=X_84247_ }
C {devices/lab_pin.sym} 29260 -29470 0 0 {name=p28649 lab=_50718_/A }
C {devices/lab_pin.sym} 29340 -29470 0 1 {name=p28650 lab=_50640_/A }
C {sky130_stdcells/buf_2.sym} 29300 -29470 0 0 {name=X_50639_ }
C {devices/lab_pin.sym} 29260 -29350 0 0 {name=p28651 lab=_44265_/Y }
C {devices/lab_pin.sym} 29340 -29350 0 1 {name=p28652 lab=_44267_/A }
C {sky130_stdcells/buf_8.sym} 29300 -29350 0 0 {name=Xpsn_inst_psn_buff_1 }
C {devices/lab_pin.sym} 29240 -29250 0 0 {name=p28653 lab=_57195_/A }
C {devices/lab_pin.sym} 29240 -29210 0 0 {name=p28654 lab=_57195_/B }
C {devices/lab_pin.sym} 29240 -29170 0 0 {name=p28655 lab=_57195_/C }
C {devices/lab_pin.sym} 29360 -29210 0 1 {name=p28656 lab=_57195_/Y }
C {sky130_stdcells/nand3_4.sym} 29300 -29210 0 0 {name=X_57195_ }
C {devices/lab_pin.sym} 29210 -29070 0 0 {name=p28657 lab=_81461_/CLK }
C {devices/lab_pin.sym} 29210 -29050 0 0 {name=p28658 lab=_76809_/B }
C {devices/lab_pin.sym} 29390 -29070 0 1 {name=p28659 lab=_81459_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -29060 0 0 {name=X_81459_ }
C {devices/lab_pin.sym} 29240 -28940 0 0 {name=p28660 lab=_74000_/A }
C {devices/lab_pin.sym} 29240 -28900 0 0 {name=p28661 lab=_73999_/X }
C {devices/lab_pin.sym} 29360 -28920 0 1 {name=p28662 lab=_74001_/B }
C {sky130_stdcells/nand2_4.sym} 29300 -28920 0 0 {name=X_74000_ }
C {devices/lab_pin.sym} 29220 -28810 0 0 {name=p28663 lab=_50508_/B }
C {devices/lab_pin.sym} 29220 -28770 0 0 {name=p28664 lab=_71190_/A }
C {devices/lab_pin.sym} 29220 -28730 0 0 {name=p28665 lab=_71211_/Y }
C {devices/lab_pin.sym} 29380 -28770 0 1 {name=p28666 lab=_71212_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -28770 0 0 {name=X_71212_ }
C {devices/lab_pin.sym} 29240 -28640 0 0 {name=p28667 lab=_44160_/A }
C {devices/lab_pin.sym} 29240 -28600 0 0 {name=p28668 lab=_44160_/B }
C {devices/lab_pin.sym} 29360 -28620 0 1 {name=p28669 lab=_44160_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -28620 0 0 {name=X_44160_ }
C {devices/lab_pin.sym} 29220 -28510 0 0 {name=p28670 lab=_56142_/X }
C {devices/lab_pin.sym} 29220 -28470 0 0 {name=p28671 lab=_56144_/X }
C {devices/lab_pin.sym} 29220 -28430 0 0 {name=p28672 lab=_56145_/Y }
C {devices/lab_pin.sym} 29380 -28470 0 1 {name=p28673 lab=_85288_/D }
C {sky130_stdcells/o21ai_4.sym} 29300 -28470 0 0 {name=X_56146_ }
C {devices/lab_pin.sym} 29220 -28360 0 0 {name=p28674 lab=_41371_/X }
C {devices/lab_pin.sym} 29220 -28320 0 0 {name=p28675 lab=_41362_/X }
C {devices/lab_pin.sym} 29220 -28280 0 0 {name=p28676 lab=_67732_/B }
C {devices/lab_pin.sym} 29220 -28240 0 0 {name=p28677 lab=_41363_/X }
C {devices/lab_pin.sym} 29380 -28300 0 1 {name=p28678 lab=_88227_/D }
C {sky130_stdcells/a2bb2o_4.sym} 29300 -28300 0 0 {name=X_41372_ }
C {devices/lab_pin.sym} 29240 -28180 0 0 {name=p28679 lab=_53339_/A }
C {devices/lab_pin.sym} 29240 -28140 0 0 {name=p28680 lab=_53371_/B }
C {devices/lab_pin.sym} 29240 -28100 0 0 {name=p28681 lab=_53371_/C }
C {devices/lab_pin.sym} 29240 -28060 0 0 {name=p28682 lab=_52841_/D }
C {devices/lab_pin.sym} 29360 -28120 0 1 {name=p28683 lab=_53358_/X }
C {sky130_stdcells/and4_4.sym} 29300 -28120 0 0 {name=X_53358_ }
C {devices/lab_pin.sym} 29240 -27980 0 0 {name=p28684 lab=_72277_/A }
C {devices/lab_pin.sym} 29240 -27940 0 0 {name=p28685 lab=_72192_/B }
C {devices/lab_pin.sym} 29360 -27960 0 1 {name=p28686 lab=_72192_/Y }
C {sky130_stdcells/nor2_4.sym} 29300 -27960 0 0 {name=X_72192_ }
C {devices/lab_pin.sym} 29210 -27830 0 0 {name=p28687 lab=_84175_/CLK }
C {devices/lab_pin.sym} 29210 -27810 0 0 {name=p28688 lab=_84178_/D }
C {devices/lab_pin.sym} 29390 -27830 0 1 {name=p28689 lab=_84178_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -27820 0 0 {name=X_84178_ }
C {devices/lab_pin.sym} 29220 -27730 0 0 {name=p28690 lab=_43100_/X }
C {devices/lab_pin.sym} 29220 -27690 0 0 {name=p28691 lab=_43110_/X }
C {devices/lab_pin.sym} 29220 -27650 0 0 {name=p28692 lab=_40762_/X }
C {devices/lab_pin.sym} 29220 -27610 0 0 {name=p28693 lab=_74266_/A }
C {devices/lab_pin.sym} 29220 -27570 0 0 {name=p28694 lab=_43080_/X }
C {devices/lab_pin.sym} 29380 -27650 0 1 {name=p28695 lab=_43112_/A }
C {sky130_stdcells/o32ai_4.sym} 29300 -27650 0 0 {name=X_43111_ }
C {devices/lab_pin.sym} 29260 -27490 0 0 {name=p28696 lab=_48135_/A }
C {devices/lab_pin.sym} 29340 -27490 0 1 {name=p28697 lab=_49140_/B }
C {sky130_stdcells/buf_2.sym} 29300 -27490 0 0 {name=X_40323_ }
C {devices/lab_pin.sym} 29260 -27370 0 0 {name=p28698 lab=_52309_/A }
C {devices/lab_pin.sym} 29340 -27370 0 1 {name=p28699 lab=_52310_/B }
C {sky130_stdcells/buf_2.sym} 29300 -27370 0 0 {name=X_52309_ }
C {devices/lab_pin.sym} 29240 -27280 0 0 {name=p28700 lab=_71171_/A }
C {devices/lab_pin.sym} 29240 -27240 0 0 {name=p28701 lab=_71141_/B }
C {devices/lab_pin.sym} 29240 -27200 0 0 {name=p28702 lab=_71152_/C }
C {devices/lab_pin.sym} 29240 -27160 0 0 {name=p28703 lab=_70875_/X }
C {devices/lab_pin.sym} 29360 -27220 0 1 {name=p28704 lab=_71143_/Y }
C {sky130_stdcells/nand4_4.sym} 29300 -27220 0 0 {name=X_71143_ }
C {devices/lab_pin.sym} 29210 -27070 0 0 {name=p28705 lab=_83561_/CLK }
C {devices/lab_pin.sym} 29210 -27050 0 0 {name=p28706 lab=_83129_/D }
C {devices/lab_pin.sym} 29390 -27070 0 1 {name=p28707 lab=_70115_/A }
C {sky130_stdcells/dfxtp_4.sym} 29300 -27060 0 0 {name=X_83129_ }
C {devices/lab_pin.sym} 29220 -26970 0 0 {name=p28708 lab=_44052_/X }
C {devices/lab_pin.sym} 29220 -26930 0 0 {name=p28709 lab=_44068_/Y }
C {devices/lab_pin.sym} 29220 -26890 0 0 {name=p28710 lab=_44071_/X }
C {devices/lab_pin.sym} 29220 -26850 0 0 {name=p28711 lab=_44085_/Y }
C {devices/lab_pin.sym} 29220 -26810 0 0 {name=p28712 lab=_44090_/Y }
C {devices/lab_pin.sym} 29380 -26890 0 1 {name=p28713 lab=_44091_/Y }
C {sky130_stdcells/o32ai_4.sym} 29300 -26890 0 0 {name=X_44091_ }
C {devices/lab_pin.sym} 29220 -26750 0 0 {name=p28714 lab=_56058_/X }
C {devices/lab_pin.sym} 29220 -26710 0 0 {name=p28715 lab=_56074_/X }
C {devices/lab_pin.sym} 29220 -26670 0 0 {name=p28716 lab=_56076_/Y }
C {devices/lab_pin.sym} 29380 -26710 0 1 {name=p28717 lab=_85300_/D }
C {sky130_stdcells/o21ai_4.sym} 29300 -26710 0 0 {name=X_56077_ }
C {devices/lab_pin.sym} 29220 -26590 0 0 {name=p28718 lab=_53287_/Y }
C {devices/lab_pin.sym} 29220 -26550 0 0 {name=p28719 lab=_53272_/X }
C {devices/lab_pin.sym} 29220 -26510 0 0 {name=p28720 lab=_53288_/X }
C {devices/lab_pin.sym} 29380 -26550 0 1 {name=p28721 lab=_53289_/Y }
C {sky130_stdcells/a21oi_4.sym} 29300 -26550 0 0 {name=X_53289_ }
C {devices/lab_pin.sym} 29220 -26450 0 0 {name=p28722 lab=_42060_/X }
C {devices/lab_pin.sym} 29220 -26410 0 0 {name=p28723 lab=_43031_/X }
C {devices/lab_pin.sym} 29220 -26370 0 0 {name=p28724 lab=_40617_/X }
C {devices/lab_pin.sym} 29220 -26330 0 0 {name=p28725 lab=_43041_/Y }
C {devices/lab_pin.sym} 29220 -26290 0 0 {name=p28726 lab=_43034_/X }
C {devices/lab_pin.sym} 29380 -26370 0 1 {name=p28727 lab=_87597_/D }
C {sky130_stdcells/o32ai_4.sym} 29300 -26370 0 0 {name=X_43042_ }
C {devices/lab_pin.sym} 29240 -26220 0 0 {name=p28728 lab=_55037_/A }
C {devices/lab_pin.sym} 29240 -26180 0 0 {name=p28729 lab=_54859_/B }
C {devices/lab_pin.sym} 29360 -26200 0 1 {name=p28730 lab=_55028_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -26200 0 0 {name=X_55028_ }
C {devices/lab_pin.sym} 29240 -26080 0 0 {name=p28731 lab=_59570_/A }
C {devices/lab_pin.sym} 29240 -26040 0 0 {name=p28732 lab=_59905_/B }
C {devices/lab_pin.sym} 29360 -26060 0 1 {name=p28733 lab=_61070_/B }
C {sky130_stdcells/nor2_4.sym} 29300 -26060 0 0 {name=X_59905_ }
C {devices/lab_pin.sym} 29220 -25950 0 0 {name=p28734 lab=_48963_/X }
C {devices/lab_pin.sym} 29220 -25910 0 0 {name=p28735 lab=_71070_/X }
C {devices/lab_pin.sym} 29220 -25870 0 0 {name=p28736 lab=_71073_/Y }
C {devices/lab_pin.sym} 29380 -25910 0 1 {name=p28737 lab=_71074_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -25910 0 0 {name=X_71074_ }
C {devices/lab_pin.sym} 29240 -25780 0 0 {name=p28738 lab=_75957_/A }
C {devices/lab_pin.sym} 29240 -25740 0 0 {name=p28739 lab=_75957_/B }
C {devices/lab_pin.sym} 29360 -25760 0 1 {name=p28740 lab=_75954_/A }
C {sky130_stdcells/xor2_4.sym} 29300 -25760 0 0 {name=X_75951_ }
C {devices/lab_pin.sym} 29210 -25630 0 0 {name=p28741 lab=_82888_/CLK }
C {devices/lab_pin.sym} 29210 -25610 0 0 {name=p28742 lab=_42292_/X }
C {devices/lab_pin.sym} 29390 -25630 0 1 {name=p28743 lab=_87937_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -25620 0 0 {name=X_87937_ }
C {devices/lab_pin.sym} 29220 -25510 0 0 {name=p28744 lab=_81129_/D }
C {devices/lab_pin.sym} 29220 -25470 0 0 {name=p28745 lab=_74891_/B }
C {devices/lab_pin.sym} 29220 -25430 0 0 {name=p28746 lab=_74901_/X }
C {devices/lab_pin.sym} 29380 -25470 0 1 {name=p28747 lab=_74902_/Y }
C {sky130_stdcells/a21oi_4.sym} 29300 -25470 0 0 {name=X_74902_ }
C {devices/lab_pin.sym} 29220 -25350 0 0 {name=p28748 lab=_82550_/D }
C {devices/lab_pin.sym} 29220 -25310 0 0 {name=p28749 lab=_70010_/X }
C {devices/lab_pin.sym} 29220 -25270 0 0 {name=p28750 lab=_70024_/X }
C {devices/lab_pin.sym} 29380 -25310 0 1 {name=p28751 lab=_83870_/D }
C {sky130_stdcells/a21bo_4.sym} 29300 -25310 0 0 {name=X_70025_ }
C {devices/lab_pin.sym} 29220 -25190 0 0 {name=p28752 lab=_46578_/X }
C {devices/lab_pin.sym} 29220 -25150 0 0 {name=p28753 lab=_46265_/A }
C {devices/lab_pin.sym} 29220 -25110 0 0 {name=p28754 lab=_47849_/X }
C {devices/lab_pin.sym} 29380 -25150 0 1 {name=p28755 lab=_47851_/B }
C {sky130_stdcells/o21ai_4.sym} 29300 -25150 0 0 {name=X_47850_ }
C {devices/lab_pin.sym} 29240 -25040 0 0 {name=p28756 lab=_59689_/B }
C {devices/lab_pin.sym} 29240 -25000 0 0 {name=p28757 lab=_59731_/Y }
C {devices/lab_pin.sym} 29240 -24960 0 0 {name=p28758 lab=_59631_/B }
C {devices/lab_pin.sym} 29240 -24920 0 0 {name=p28759 lab=_59836_/D }
C {devices/lab_pin.sym} 29360 -24980 0 1 {name=p28760 lab=_59836_/Y }
C {sky130_stdcells/nand4_4.sym} 29300 -24980 0 0 {name=X_59836_ }
C {devices/lab_pin.sym} 29260 -24830 0 0 {name=p28761 lab=_78669_/X }
C {devices/lab_pin.sym} 29340 -24830 0 1 {name=p28762 lab=_78701_/B }
C {sky130_stdcells/buf_2.sym} 29300 -24830 0 0 {name=X_78670_ }
C {devices/lab_pin.sym} 29260 -24710 0 0 {name=p28763 lab=_75726_/Y }
C {devices/lab_pin.sym} 29340 -24710 0 1 {name=p28764 lab=_80787_/D }
C {sky130_stdcells/inv_2.sym} 29300 -24710 0 0 {name=X_75882_ }
C {devices/lab_pin.sym} 29210 -24590 0 0 {name=p28765 lab=_82899_/CLK }
C {devices/lab_pin.sym} 29210 -24570 0 0 {name=p28766 lab=_42428_/X }
C {devices/lab_pin.sym} 29390 -24590 0 1 {name=p28767 lab=_87868_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -24580 0 0 {name=X_87868_ }
C {devices/lab_pin.sym} 29260 -24450 0 0 {name=p28768 lab=_46800_/Y }
C {devices/lab_pin.sym} 29340 -24450 0 1 {name=p28769 lab=_52681_/D }
C {sky130_stdcells/buf_2.sym} 29300 -24450 0 0 {name=X_46801_ }
C {devices/lab_pin.sym} 29260 -24330 0 0 {name=p28770 lab=_77621_/A }
C {devices/lab_pin.sym} 29340 -24330 0 1 {name=p28771 lab=_77627_/A }
C {sky130_stdcells/inv_2.sym} 29300 -24330 0 0 {name=X_77621_ }
C {devices/lab_pin.sym} 29260 -24210 0 0 {name=p28772 lab=_74832_/Y }
C {devices/lab_pin.sym} 29340 -24210 0 1 {name=p28773 lab=_74833_/Y }
C {sky130_stdcells/inv_2.sym} 29300 -24210 0 0 {name=X_74833_ }
C {devices/lab_pin.sym} 29210 -24090 0 0 {name=p28774 lab=_87077_/CLK }
C {devices/lab_pin.sym} 29210 -24070 0 0 {name=p28775 lab=_86819_/D }
C {devices/lab_pin.sym} 29390 -24090 0 1 {name=p28776 lab=_67023_/B }
C {sky130_stdcells/dfxtp_4.sym} 29300 -24080 0 0 {name=X_86819_ }
C {devices/lab_pin.sym} 29240 -23960 0 0 {name=p28777 lab=_47799_/A }
C {devices/lab_pin.sym} 29240 -23920 0 0 {name=p28778 lab=_53240_/B }
C {devices/lab_pin.sym} 29360 -23940 0 1 {name=p28779 lab=_47781_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -23940 0 0 {name=X_47781_ }
C {devices/lab_pin.sym} 29260 -23810 0 0 {name=p28780 lab=_59766_/X }
C {devices/lab_pin.sym} 29340 -23810 0 1 {name=p28781 lab=_61770_/D }
C {sky130_stdcells/buf_2.sym} 29300 -23810 0 0 {name=X_59767_ }
C {devices/lab_pin.sym} 29260 -23690 0 0 {name=p28782 lab=_56670_/A }
C {devices/lab_pin.sym} 29340 -23690 0 1 {name=p28783 lab=_45835_/A }
C {sky130_stdcells/buf_2.sym} 29300 -23690 0 0 {name=X_44993_ }
C {devices/lab_pin.sym} 29240 -23580 0 0 {name=p28784 lab=_45643_/Y }
C {devices/lab_pin.sym} 29240 -23540 0 0 {name=p28785 lab=_56671_/X }
C {devices/lab_pin.sym} 29360 -23560 0 1 {name=p28786 lab=_56979_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -23560 0 0 {name=X_56979_ }
C {devices/lab_pin.sym} 29210 -23430 0 0 {name=p28787 lab=_87544_/CLK }
C {devices/lab_pin.sym} 29210 -23410 0 0 {name=p28788 lab=_42619_/Y }
C {devices/lab_pin.sym} 29390 -23430 0 1 {name=p28789 lab=_69929_/A }
C {sky130_stdcells/dfxtp_4.sym} 29300 -23420 0 0 {name=X_87799_ }
C {devices/lab_pin.sym} 29260 -23290 0 0 {name=p28790 lab=_49520_/A }
C {devices/lab_pin.sym} 29340 -23290 0 1 {name=p28791 lab=_49548_/A }
C {sky130_stdcells/buf_2.sym} 29300 -23290 0 0 {name=X_49520_ }
C {devices/lab_pin.sym} 29260 -23170 0 0 {name=p28792 lab=_54332_/B }
C {devices/lab_pin.sym} 29340 -23170 0 1 {name=p28793 lab=_51812_/B }
C {sky130_stdcells/buf_2.sym} 29300 -23170 0 0 {name=X_46732_ }
C {devices/lab_pin.sym} 29220 -23070 0 0 {name=p28794 lab=_58667_/X }
C {devices/lab_pin.sym} 29220 -23030 0 0 {name=p28795 lab=_86101_/Q }
C {devices/lab_pin.sym} 29220 -22990 0 0 {name=p28796 lab=_58717_/X }
C {devices/lab_pin.sym} 29380 -23030 0 1 {name=p28797 lab=_58718_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -23030 0 0 {name=X_58718_ }
C {devices/lab_pin.sym} 29260 -22890 0 0 {name=p28798 lab=clkbuf_8_70_0_CLK/X }
C {devices/lab_pin.sym} 29340 -22890 0 1 {name=p28799 lab=clkbuf_9_140_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 29300 -22890 0 0 {name=Xclkbuf_9_140_0_CLK }
C {devices/lab_pin.sym} 29260 -22770 0 0 {name=p28800 lab=_77552_/A }
C {devices/lab_pin.sym} 29340 -22770 0 1 {name=p28801 lab=_77552_/Y }
C {sky130_stdcells/inv_2.sym} 29300 -22770 0 0 {name=X_77552_ }
C {devices/lab_pin.sym} 29260 -22650 0 0 {name=p28802 lab=_43944_/A }
C {devices/lab_pin.sym} 29340 -22650 0 1 {name=p28803 lab=_43987_/B }
C {sky130_stdcells/buf_2.sym} 29300 -22650 0 0 {name=X_43944_ }
C {devices/lab_pin.sym} 29240 -22560 0 0 {name=p28804 lab=_74764_/A }
C {devices/lab_pin.sym} 29240 -22520 0 0 {name=p28805 lab=_74764_/B }
C {devices/lab_pin.sym} 29240 -22480 0 0 {name=p28806 lab=_71010_/X }
C {devices/lab_pin.sym} 29240 -22440 0 0 {name=p28807 lab=_70732_/X }
C {devices/lab_pin.sym} 29360 -22500 0 1 {name=p28808 lab=_74764_/X }
C {sky130_stdcells/and4_4.sym} 29300 -22500 0 0 {name=X_74764_ }
C {devices/lab_pin.sym} 29240 -22360 0 0 {name=p28809 lab=_71957_/A }
C {devices/lab_pin.sym} 29240 -22320 0 0 {name=p28810 lab=_48920_/Y }
C {devices/lab_pin.sym} 29360 -22340 0 1 {name=p28811 lab=_71976_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -22340 0 0 {name=X_71976_ }
C {devices/lab_pin.sym} 29260 -22210 0 0 {name=p28812 lab=_59605_/Y }
C {devices/lab_pin.sym} 29340 -22210 0 1 {name=p28813 lab=_59722_/A }
C {sky130_stdcells/buf_2.sym} 29300 -22210 0 0 {name=X_59698_ }
C {devices/lab_pin.sym} 29240 -22100 0 0 {name=p28814 lab=_76503_/A }
C {devices/lab_pin.sym} 29240 -22060 0 0 {name=p28815 lab=_81542_/Q }
C {devices/lab_pin.sym} 29360 -22080 0 1 {name=p28816 lab=_76503_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -22080 0 0 {name=X_76503_ }
C {devices/lab_pin.sym} 29260 -21950 0 0 {name=p28817 lab=_49451_/A }
C {devices/lab_pin.sym} 29340 -21950 0 1 {name=p28818 lab=_49456_/B }
C {sky130_stdcells/buf_2.sym} 29300 -21950 0 0 {name=X_49451_ }
C {devices/lab_pin.sym} 29220 -21860 0 0 {name=p28819 lab=_73665_/X }
C {devices/lab_pin.sym} 29220 -21820 0 0 {name=p28820 lab=_84987_/Q }
C {devices/lab_pin.sym} 29220 -21780 0 0 {name=p28821 lab=_73614_/X }
C {devices/lab_pin.sym} 29220 -21740 0 0 {name=p28822 lab=_73714_/X }
C {devices/lab_pin.sym} 29380 -21800 0 1 {name=p28823 lab=_73715_/X }
C {sky130_stdcells/a211o_4.sym} 29300 -21800 0 0 {name=X_73715_ }
C {devices/lab_pin.sym} 29220 -21670 0 0 {name=p28824 lab=_51043_/B }
C {devices/lab_pin.sym} 29220 -21630 0 0 {name=p28825 lab=_70909_/A }
C {devices/lab_pin.sym} 29220 -21590 0 0 {name=p28826 lab=_70926_/Y }
C {devices/lab_pin.sym} 29380 -21630 0 1 {name=p28827 lab=_70927_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -21630 0 0 {name=X_70927_ }
C {devices/lab_pin.sym} 29240 -21500 0 0 {name=p28828 lab=_46651_/A }
C {devices/lab_pin.sym} 29240 -21460 0 0 {name=p28829 lab=_46662_/X }
C {devices/lab_pin.sym} 29360 -21480 0 1 {name=p28830 lab=_46663_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -21480 0 0 {name=X_46663_ }
C {devices/lab_pin.sym} 29240 -21360 0 0 {name=p28831 lab=_58649_/A }
C {devices/lab_pin.sym} 29240 -21320 0 0 {name=p28832 lab=_58649_/B }
C {devices/lab_pin.sym} 29360 -21340 0 1 {name=p28833 lab=_58649_/Y }
C {sky130_stdcells/nor2_4.sym} 29300 -21340 0 0 {name=X_58649_ }
C {devices/lab_pin.sym} 29220 -21230 0 0 {name=p28834 lab=_77454_/X }
C {devices/lab_pin.sym} 29220 -21190 0 0 {name=p28835 lab=_77458_/B }
C {devices/lab_pin.sym} 29220 -21150 0 0 {name=p28836 lab=_77482_/Y }
C {devices/lab_pin.sym} 29380 -21190 0 1 {name=p28837 lab=_77484_/B }
C {sky130_stdcells/o21a_4.sym} 29300 -21190 0 0 {name=X_77483_ }
C {devices/lab_pin.sym} 29220 -21080 0 0 {name=p28838 lab=_41272_/X }
C {devices/lab_pin.sym} 29220 -21040 0 0 {name=p28839 lab=_43868_/X }
C {devices/lab_pin.sym} 29220 -21000 0 0 {name=p28840 lab=_87222_/Q }
C {devices/lab_pin.sym} 29220 -20960 0 0 {name=p28841 lab=_43870_/X }
C {devices/lab_pin.sym} 29380 -21020 0 1 {name=p28842 lab=_87222_/D }
C {sky130_stdcells/a2bb2o_4.sym} 29300 -21020 0 0 {name=X_43875_ }
C {devices/lab_pin.sym} 29220 -20890 0 0 {name=p28843 lab=_56886_/B }
C {devices/lab_pin.sym} 29220 -20850 0 0 {name=p28844 lab=_74656_/X }
C {devices/lab_pin.sym} 29220 -20810 0 0 {name=p28845 lab=_74694_/Y }
C {devices/lab_pin.sym} 29380 -20850 0 1 {name=p28846 lab=_74695_/X }
C {sky130_stdcells/a21bo_4.sym} 29300 -20850 0 0 {name=X_74695_ }
C {devices/lab_pin.sym} 29260 -20710 0 0 {name=p28847 lab=clkbuf_9_332_0_CLK/X }
C {devices/lab_pin.sym} 29340 -20710 0 1 {name=p28848 lab=_82629_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 29300 -20710 0 0 {name=Xclkbuf_10_664_0_CLK }
C {devices/lab_pin.sym} 29220 -20610 0 0 {name=p28849 lab=_86525_/Q }
C {devices/lab_pin.sym} 29220 -20570 0 0 {name=p28850 lab=_48333_/X }
C {devices/lab_pin.sym} 29220 -20530 0 0 {name=p28851 lab=_48401_/Y }
C {devices/lab_pin.sym} 29380 -20570 0 1 {name=p28852 lab=_48402_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -20570 0 0 {name=X_48402_ }
C {devices/lab_pin.sym} 29220 -20450 0 0 {name=p28853 lab=_79217_/Y }
C {devices/lab_pin.sym} 29220 -20410 0 0 {name=p28854 lab=_79218_/X }
C {devices/lab_pin.sym} 29220 -20370 0 0 {name=p28855 lab=_79221_/Y }
C {devices/lab_pin.sym} 29380 -20410 0 1 {name=p28856 lab=_79224_/A }
C {sky130_stdcells/a21o_4.sym} 29300 -20410 0 0 {name=X_79222_ }
C {devices/lab_pin.sym} 29220 -20300 0 0 {name=p28857 lab=_55470_/B }
C {devices/lab_pin.sym} 29220 -20260 0 0 {name=p28858 lab=_45596_/X }
C {devices/lab_pin.sym} 29220 -20220 0 0 {name=p28859 lab=_45548_/X }
C {devices/lab_pin.sym} 29220 -20180 0 0 {name=p28860 lab=_45613_/Y }
C {devices/lab_pin.sym} 29380 -20240 0 1 {name=p28861 lab=_45614_/X }
C {sky130_stdcells/a211o_4.sym} 29300 -20240 0 0 {name=X_45614_ }
C {devices/lab_pin.sym} 29220 -20110 0 0 {name=p28862 lab=_76419_/Y }
C {devices/lab_pin.sym} 29220 -20070 0 0 {name=p28863 lab=_76422_/Y }
C {devices/lab_pin.sym} 29220 -20030 0 0 {name=p28864 lab=_76417_/Y }
C {devices/lab_pin.sym} 29380 -20070 0 1 {name=p28865 lab=_76435_/B }
C {sky130_stdcells/o21ai_4.sym} 29300 -20070 0 0 {name=X_76434_ }
C {devices/lab_pin.sym} 29220 -19960 0 0 {name=p28866 lab=_41465_/X }
C {devices/lab_pin.sym} 29220 -19920 0 0 {name=p28867 lab=_42821_/X }
C {devices/lab_pin.sym} 29220 -19880 0 0 {name=p28868 lab=_87698_/Q }
C {devices/lab_pin.sym} 29220 -19840 0 0 {name=p28869 lab=_42822_/X }
C {devices/lab_pin.sym} 29380 -19900 0 1 {name=p28870 lab=_42826_/X }
C {sky130_stdcells/a2bb2o_4.sym} 29300 -19900 0 0 {name=X_42826_ }
C {devices/lab_pin.sym} 29240 -19760 0 0 {name=p28871 lab=_49382_/A }
C {devices/lab_pin.sym} 29240 -19720 0 0 {name=p28872 lab=_51770_/B }
C {devices/lab_pin.sym} 29360 -19740 0 1 {name=p28873 lab=_49382_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -19740 0 0 {name=X_49382_ }
C {devices/lab_pin.sym} 29260 -19610 0 0 {name=p28874 lab=_61476_/A }
C {devices/lab_pin.sym} 29340 -19610 0 1 {name=p28875 lab=_61690_/B }
C {sky130_stdcells/buf_2.sym} 29300 -19610 0 0 {name=X_61660_ }
C {devices/lab_pin.sym} 29240 -19510 0 0 {name=p28876 lab=_73644_/X }
C {devices/lab_pin.sym} 29240 -19470 0 0 {name=p28877 lab=_73646_/B }
C {devices/lab_pin.sym} 29240 -19430 0 0 {name=p28878 lab=_73635_/X }
C {devices/lab_pin.sym} 29360 -19470 0 1 {name=p28879 lab=_73646_/Y }
C {sky130_stdcells/nand3_4.sym} 29300 -19470 0 0 {name=X_73646_ }
C {devices/lab_pin.sym} 29260 -19330 0 0 {name=p28880 lab=_83778_/Q }
C {devices/lab_pin.sym} 29340 -19330 0 1 {name=p28881 lab=_52571_/B }
C {sky130_stdcells/inv_2.sym} 29300 -19330 0 0 {name=X_46594_ }
C {devices/lab_pin.sym} 29260 -19210 0 0 {name=p28882 lab=_71072_/A }
C {devices/lab_pin.sym} 29340 -19210 0 1 {name=p28883 lab=_71088_/C }
C {sky130_stdcells/buf_2.sym} 29300 -19210 0 0 {name=X_70858_ }
C {devices/lab_pin.sym} 29260 -19090 0 0 {name=p28884 lab=clkbuf_8_77_0_CLK/X }
C {devices/lab_pin.sym} 29340 -19090 0 1 {name=p28885 lab=clkbuf_9_155_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 29300 -19090 0 0 {name=Xclkbuf_9_155_0_CLK }
C {devices/lab_pin.sym} 29260 -18970 0 0 {name=p28886 lab=_48548_/A }
C {devices/lab_pin.sym} 29340 -18970 0 1 {name=p28887 lab=_48333_/X }
C {sky130_stdcells/buf_2.sym} 29300 -18970 0 0 {name=X_48333_ }
C {devices/lab_pin.sym} 29220 -18890 0 0 {name=p28888 lab=_60376_/X }
C {devices/lab_pin.sym} 29220 -18850 0 0 {name=p28889 lab=_60532_/A }
C {devices/lab_pin.sym} 29220 -18810 0 0 {name=p28890 lab=_60571_/Y }
C {devices/lab_pin.sym} 29220 -18770 0 0 {name=p28891 lab=_60609_/X }
C {devices/lab_pin.sym} 29220 -18730 0 0 {name=p28892 lab=_60610_/X }
C {devices/lab_pin.sym} 29380 -18810 0 1 {name=p28893 lab=_60611_/X }
C {sky130_stdcells/o41a_4.sym} 29300 -18810 0 0 {name=X_60611_ }
C {devices/lab_pin.sym} 29240 -18660 0 0 {name=p28894 lab=_79153_/A }
C {devices/lab_pin.sym} 29240 -18620 0 0 {name=p28895 lab=_79153_/B }
C {devices/lab_pin.sym} 29360 -18640 0 1 {name=p28896 lab=_79153_/X }
C {sky130_stdcells/xor2_4.sym} 29300 -18640 0 0 {name=X_79153_ }
C {devices/lab_pin.sym} 29220 -18530 0 0 {name=p28897 lab=_45511_/X }
C {devices/lab_pin.sym} 29220 -18490 0 0 {name=p28898 lab=_61440_/A }
C {devices/lab_pin.sym} 29220 -18450 0 0 {name=p28899 lab=_45530_/X }
C {devices/lab_pin.sym} 29380 -18490 0 1 {name=p28900 lab=_45545_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -18490 0 0 {name=X_45545_ }
C {devices/lab_pin.sym} 29260 -18350 0 0 {name=p28901 lab=_76365_/A }
C {devices/lab_pin.sym} 29340 -18350 0 1 {name=p28902 lab=_76369_/A }
C {sky130_stdcells/inv_2.sym} 29300 -18350 0 0 {name=X_76365_ }
C {devices/lab_pin.sym} 29260 -18230 0 0 {name=p28903 lab=clkbuf_9_83_0_CLK/A }
C {devices/lab_pin.sym} 29340 -18230 0 1 {name=p28904 lab=clkbuf_9_82_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 29300 -18230 0 0 {name=Xclkbuf_9_82_0_CLK }
C {devices/lab_pin.sym} 29260 -18110 0 0 {name=p28905 lab=_42745_/A }
C {devices/lab_pin.sym} 29340 -18110 0 1 {name=p28906 lab=_42757_/X }
C {sky130_stdcells/buf_2.sym} 29300 -18110 0 0 {name=X_42757_ }
C {devices/lab_pin.sym} 29260 -17990 0 0 {name=p28907 lab=_84859_/Q }
C {devices/lab_pin.sym} 29340 -17990 0 1 {name=p28908 lab=_61593_/B }
C {sky130_stdcells/buf_2.sym} 29300 -17990 0 0 {name=X_61591_ }
C {devices/lab_pin.sym} 29240 -17880 0 0 {name=p28909 lab=_73577_/A }
C {devices/lab_pin.sym} 29240 -17840 0 0 {name=p28910 lab=_73577_/B }
C {devices/lab_pin.sym} 29360 -17860 0 1 {name=p28911 lab=_73577_/Y }
C {sky130_stdcells/nor2_4.sym} 29300 -17860 0 0 {name=X_73577_ }
C {devices/lab_pin.sym} 29260 -17730 0 0 {name=p28912 lab=_70400_/A }
C {devices/lab_pin.sym} 29340 -17730 0 1 {name=p28913 lab=_70790_/A }
C {sky130_stdcells/buf_2.sym} 29300 -17730 0 0 {name=X_70789_ }
C {devices/lab_pin.sym} 29240 -17620 0 0 {name=p28914 lab=_82565_/Q }
C {devices/lab_pin.sym} 29240 -17580 0 0 {name=p28915 lab=_78103_/B }
C {devices/lab_pin.sym} 29360 -17600 0 1 {name=p28916 lab=_78104_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -17600 0 0 {name=X_78104_ }
C {devices/lab_pin.sym} 29220 -17510 0 0 {name=p28917 lab=_59439_/Y }
C {devices/lab_pin.sym} 29220 -17470 0 0 {name=p28918 lab=_63259_/X }
C {devices/lab_pin.sym} 29220 -17430 0 0 {name=p28919 lab=_60523_/A }
C {devices/lab_pin.sym} 29220 -17390 0 0 {name=p28920 lab=_58987_/Y }
C {devices/lab_pin.sym} 29220 -17350 0 0 {name=p28921 lab=_63060_/A }
C {devices/lab_pin.sym} 29380 -17430 0 1 {name=p28922 lab=_63330_/Y }
C {sky130_stdcells/o32ai_4.sym} 29300 -17430 0 0 {name=X_63330_ }
C {devices/lab_pin.sym} 29260 -17270 0 0 {name=p28923 lab=_75315_/Y }
C {devices/lab_pin.sym} 29340 -17270 0 1 {name=p28924 lab=_75319_/B }
C {sky130_stdcells/inv_2.sym} 29300 -17270 0 0 {name=X_75316_ }
C {devices/lab_pin.sym} 29240 -17160 0 0 {name=p28925 lab=_82898_/Q }
C {devices/lab_pin.sym} 29240 -17120 0 0 {name=p28926 lab=_41653_/X }
C {devices/lab_pin.sym} 29360 -17140 0 1 {name=p28927 lab=_41708_/X }
C {sky130_stdcells/or2_4.sym} 29300 -17140 0 0 {name=X_41708_ }
C {devices/lab_pin.sym} 29240 -17030 0 0 {name=p28928 lab=_60566_/A }
C {devices/lab_pin.sym} 29240 -16990 0 0 {name=p28929 lab=_60476_/A }
C {devices/lab_pin.sym} 29240 -16950 0 0 {name=p28930 lab=_60488_/C }
C {devices/lab_pin.sym} 29360 -16990 0 1 {name=p28931 lab=_60542_/Y }
C {sky130_stdcells/nand3_4.sym} 29300 -16990 0 0 {name=X_60542_ }
C {devices/lab_pin.sym} 29260 -16850 0 0 {name=p28932 lab=_48163_/X }
C {devices/lab_pin.sym} 29340 -16850 0 1 {name=p28933 lab=_48264_/X }
C {sky130_stdcells/buf_2.sym} 29300 -16850 0 0 {name=X_48264_ }
C {devices/lab_pin.sym} 29260 -16730 0 0 {name=p28934 lab=_72528_/A }
C {devices/lab_pin.sym} 29340 -16730 0 1 {name=p28935 lab=_72528_/Y }
C {sky130_stdcells/inv_2.sym} 29300 -16730 0 0 {name=X_72528_ }
C {devices/lab_pin.sym} 29240 -16620 0 0 {name=p28936 lab=_79084_/A }
C {devices/lab_pin.sym} 29240 -16580 0 0 {name=p28937 lab=_79083_/Y }
C {devices/lab_pin.sym} 29360 -16600 0 1 {name=p28938 lab=_82719_/D }
C {sky130_stdcells/nand2_4.sym} 29300 -16600 0 0 {name=X_79084_ }
C {devices/lab_pin.sym} 29240 -16480 0 0 {name=p28939 lab=_85052_/Q }
C {devices/lab_pin.sym} 29240 -16440 0 0 {name=p28940 lab=_45490_/B }
C {devices/lab_pin.sym} 29360 -16460 0 1 {name=p28941 lab=_45476_/Y }
C {sky130_stdcells/nor2_4.sym} 29300 -16460 0 0 {name=X_45476_ }
C {devices/lab_pin.sym} 29240 -16340 0 0 {name=p28942 lab=_76296_/A }
C {devices/lab_pin.sym} 29240 -16300 0 0 {name=p28943 lab=_76295_/Y }
C {devices/lab_pin.sym} 29360 -16320 0 1 {name=p28944 lab=_76297_/B }
C {sky130_stdcells/xor2_4.sym} 29300 -16320 0 0 {name=X_76296_ }
C {devices/lab_pin.sym} 29260 -16190 0 0 {name=p28945 lab=_42592_/A }
C {devices/lab_pin.sym} 29340 -16190 0 1 {name=p28946 lab=_42688_/X }
C {sky130_stdcells/buf_2.sym} 29300 -16190 0 0 {name=X_42688_ }
C {devices/lab_pin.sym} 29260 -16070 0 0 {name=p28947 lab=clkbuf_9_339_0_CLK/X }
C {devices/lab_pin.sym} 29340 -16070 0 1 {name=p28948 lab=_86920_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 29300 -16070 0 0 {name=Xclkbuf_10_679_0_CLK }
C {devices/lab_pin.sym} 29220 -15970 0 0 {name=p28949 lab=_59377_/A }
C {devices/lab_pin.sym} 29220 -15930 0 0 {name=p28950 lab=_47192_/X }
C {devices/lab_pin.sym} 29220 -15890 0 0 {name=p28951 lab=_47214_/Y }
C {devices/lab_pin.sym} 29380 -15930 0 1 {name=p28952 lab=_47215_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -15930 0 0 {name=X_47215_ }
C {devices/lab_pin.sym} 29240 -15800 0 0 {name=p28953 lab=_78033_/Y }
C {devices/lab_pin.sym} 29240 -15760 0 0 {name=p28954 lab=_78034_/Y }
C {devices/lab_pin.sym} 29360 -15780 0 1 {name=p28955 lab=_78037_/A }
C {sky130_stdcells/nand2_4.sym} 29300 -15780 0 0 {name=X_78035_ }
C {devices/lab_pin.sym} 29260 -15650 0 0 {name=p28956 lab=_44548_/A }
C {devices/lab_pin.sym} 29340 -15650 0 1 {name=p28957 lab=_44427_/X }
C {sky130_stdcells/buf_2.sym} 29300 -15650 0 0 {name=X_44427_ }
C {devices/lab_pin.sym} 29240 -15560 0 0 {name=p28958 lab=_63288_/A }
C {devices/lab_pin.sym} 29240 -15520 0 0 {name=p28959 lab=_64466_/B }
C {devices/lab_pin.sym} 29240 -15480 0 0 {name=p28960 lab=_63312_/C }
C {devices/lab_pin.sym} 29240 -15440 0 0 {name=p28961 lab=_63237_/X }
C {devices/lab_pin.sym} 29360 -15500 0 1 {name=p28962 lab=_63261_/X }
C {sky130_stdcells/and4_4.sym} 29300 -15500 0 0 {name=X_63261_ }
C {devices/lab_pin.sym} 29220 -15370 0 0 {name=p28963 lab=_75233_/X }
C {devices/lab_pin.sym} 29220 -15330 0 0 {name=p28964 lab=_75245_/Y }
C {devices/lab_pin.sym} 29220 -15290 0 0 {name=p28965 lab=_75246_/Y }
C {devices/lab_pin.sym} 29380 -15330 0 1 {name=p28966 lab=_75247_/X }
C {sky130_stdcells/a21o_4.sym} 29300 -15330 0 0 {name=X_75247_ }
C {devices/lab_pin.sym} 29260 -15190 0 0 {name=p28967 lab=_41457_/A }
C {devices/lab_pin.sym} 29340 -15190 0 1 {name=p28968 lab=_41639_/X }
C {sky130_stdcells/buf_2.sym} 29300 -15190 0 0 {name=X_41639_ }
C {devices/lab_pin.sym} 29260 -15070 0 0 {name=p28969 lab=_52309_/A }
C {devices/lab_pin.sym} 29340 -15070 0 1 {name=p28970 lab=_48195_/X }
C {sky130_stdcells/buf_2.sym} 29300 -15070 0 0 {name=X_48195_ }
C {devices/lab_pin.sym} 29240 -14980 0 0 {name=p28971 lab=_60421_/B }
C {devices/lab_pin.sym} 29240 -14940 0 0 {name=p28972 lab=_60473_/B }
C {devices/lab_pin.sym} 29240 -14900 0 0 {name=p28973 lab=_60473_/C }
C {devices/lab_pin.sym} 29240 -14860 0 0 {name=p28974 lab=_60438_/A }
C {devices/lab_pin.sym} 29360 -14920 0 1 {name=p28975 lab=_60556_/B }
C {sky130_stdcells/nand4_4.sym} 29300 -14920 0 0 {name=X_60473_ }
C {devices/lab_pin.sym} 29220 -14790 0 0 {name=p28976 lab=_72327_/X }
C {devices/lab_pin.sym} 29220 -14750 0 0 {name=p28977 lab=_85956_/Q }
C {devices/lab_pin.sym} 29220 -14710 0 0 {name=p28978 lab=_72458_/X }
C {devices/lab_pin.sym} 29380 -14750 0 1 {name=p28979 lab=_72459_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -14750 0 0 {name=X_72459_ }
C {devices/lab_pin.sym} 29240 -14620 0 0 {name=p28980 lab=_64929_/A }
C {devices/lab_pin.sym} 29240 -14580 0 0 {name=p28981 lab=_65000_/B }
C {devices/lab_pin.sym} 29360 -14600 0 1 {name=p28982 lab=_65000_/X }
C {sky130_stdcells/and2_4.sym} 29300 -14600 0 0 {name=X_65000_ }
C {devices/lab_pin.sym} 29240 -14500 0 0 {name=p28983 lab=_62212_/A }
C {devices/lab_pin.sym} 29240 -14460 0 0 {name=p28984 lab=_62202_/Y }
C {devices/lab_pin.sym} 29240 -14420 0 0 {name=p28985 lab=_62206_/Y }
C {devices/lab_pin.sym} 29240 -14380 0 0 {name=p28986 lab=_62211_/Y }
C {devices/lab_pin.sym} 29360 -14440 0 1 {name=p28987 lab=_62212_/Y }
C {sky130_stdcells/nand4_4.sym} 29300 -14440 0 0 {name=X_62212_ }
C {devices/lab_pin.sym} 29260 -14290 0 0 {name=p28988 lab=_57563_/A }
C {devices/lab_pin.sym} 29340 -14290 0 1 {name=p28989 lab=_47147_/A }
C {sky130_stdcells/buf_2.sym} 29300 -14290 0 0 {name=X_47146_ }
C {devices/lab_pin.sym} 29260 -14170 0 0 {name=p28990 lab=clkbuf_9_97_0_CLK/A }
C {devices/lab_pin.sym} 29340 -14170 0 1 {name=p28991 lab=clkbuf_9_97_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 29300 -14170 0 0 {name=Xclkbuf_9_97_0_CLK }
C {devices/lab_pin.sym} 29220 -14080 0 0 {name=p28992 lab=_41727_/X }
C {devices/lab_pin.sym} 29220 -14040 0 0 {name=p28993 lab=_44345_/X }
C {devices/lab_pin.sym} 29220 -14000 0 0 {name=p28994 lab=_87149_/Q }
C {devices/lab_pin.sym} 29220 -13960 0 0 {name=p28995 lab=_44346_/X }
C {devices/lab_pin.sym} 29380 -14020 0 1 {name=p28996 lab=_44358_/X }
C {sky130_stdcells/a2bb2o_4.sym} 29300 -14020 0 0 {name=X_44358_ }
C {devices/lab_pin.sym} 29240 -13900 0 0 {name=p28997 lab=_63154_/X }
C {devices/lab_pin.sym} 29240 -13860 0 0 {name=p28998 lab=_64401_/B }
C {devices/lab_pin.sym} 29240 -13820 0 0 {name=p28999 lab=_63165_/X }
C {devices/lab_pin.sym} 29240 -13780 0 0 {name=p29000 lab=_63192_/D }
C {devices/lab_pin.sym} 29360 -13840 0 1 {name=p29001 lab=_63192_/X }
C {sky130_stdcells/and4_4.sym} 29300 -13840 0 0 {name=X_63192_ }
C {devices/lab_pin.sym} 29240 -13710 0 0 {name=p29002 lab=_75178_/A }
C {devices/lab_pin.sym} 29240 -13670 0 0 {name=p29003 lab=_75178_/B }
C {devices/lab_pin.sym} 29240 -13630 0 0 {name=p29004 lab=_75178_/C }
C {devices/lab_pin.sym} 29360 -13670 0 1 {name=p29005 lab=_75179_/A }
C {sky130_stdcells/nand3_4.sym} 29300 -13670 0 0 {name=X_75178_ }
C {devices/lab_pin.sym} 29260 -13530 0 0 {name=p29006 lab=clkbuf_9_301_0_CLK/X }
C {devices/lab_pin.sym} 29340 -13530 0 1 {name=p29007 lab=_81990_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 29300 -13530 0 0 {name=Xclkbuf_10_602_0_CLK }
C {devices/lab_pin.sym} 29220 -13450 0 0 {name=p29008 lab=_43296_/X }
C {devices/lab_pin.sym} 29220 -13410 0 0 {name=p29009 lab=_43305_/X }
C {devices/lab_pin.sym} 29220 -13370 0 0 {name=p29010 lab=_41214_/X }
C {devices/lab_pin.sym} 29220 -13330 0 0 {name=p29011 lab=_87488_/Q }
C {devices/lab_pin.sym} 29220 -13290 0 0 {name=p29012 lab=_43308_/X }
C {devices/lab_pin.sym} 29380 -13370 0 1 {name=p29013 lab=_43309_/Y }
C {sky130_stdcells/o32ai_4.sym} 29300 -13370 0 0 {name=X_43309_ }
C {devices/lab_pin.sym} 29220 -13250 0 0 {name=p29014 lab=_62135_/X }
C {devices/lab_pin.sym} 29220 -13210 0 0 {name=p29015 lab=_62137_/X }
C {devices/lab_pin.sym} 29220 -13170 0 0 {name=p29016 lab=_62142_/Y }
C {devices/lab_pin.sym} 29220 -13130 0 0 {name=p29017 lab=_84870_/Q }
C {devices/lab_pin.sym} 29220 -13090 0 0 {name=p29018 lab=_62117_/X }
C {devices/lab_pin.sym} 29380 -13170 0 1 {name=p29019 lab=_62143_/Y }
C {sky130_stdcells/o32ai_4.sym} 29300 -13170 0 0 {name=X_62143_ }
C {devices/lab_pin.sym} 29240 -13020 0 0 {name=p29020 lab=_74152_/A }
C {devices/lab_pin.sym} 29240 -12980 0 0 {name=p29021 lab=_74129_/B }
C {devices/lab_pin.sym} 29360 -13000 0 1 {name=p29022 lab=_74129_/X }
C {sky130_stdcells/and2_4.sym} 29300 -13000 0 0 {name=X_74129_ }
C {devices/lab_pin.sym} 29260 -12870 0 0 {name=p29023 lab=_47077_/A }
C {devices/lab_pin.sym} 29340 -12870 0 1 {name=p29024 lab=_53360_/B }
C {sky130_stdcells/inv_2.sym} 29300 -12870 0 0 {name=X_47077_ }
C {devices/lab_pin.sym} 29220 -12770 0 0 {name=p29025 lab=_44284_/Y }
C {devices/lab_pin.sym} 29220 -12730 0 0 {name=p29026 lab=_44285_/Y }
C {devices/lab_pin.sym} 29220 -12690 0 0 {name=p29027 lab=_44288_/X }
C {devices/lab_pin.sym} 29380 -12730 0 1 {name=p29028 lab=_44289_/X }
C {sky130_stdcells/o21a_4.sym} 29300 -12730 0 0 {name=X_44289_ }
C {devices/lab_pin.sym} 29220 -12610 0 0 {name=p29029 lab=_79972_/Y }
C {devices/lab_pin.sym} 29220 -12570 0 0 {name=p29030 lab=_79973_/Y }
C {devices/lab_pin.sym} 29220 -12530 0 0 {name=p29031 lab=_79985_/Y }
C {devices/lab_pin.sym} 29380 -12570 0 1 {name=p29032 lab=_79988_/A }
C {sky130_stdcells/a21o_4.sym} 29300 -12570 0 0 {name=X_79986_ }
C {devices/lab_pin.sym} 29220 -12460 0 0 {name=p29033 lab=_41464_/Y }
C {devices/lab_pin.sym} 29220 -12420 0 0 {name=p29034 lab=_46022_/X }
C {devices/lab_pin.sym} 29220 -12380 0 0 {name=p29035 lab=_86805_/Q }
C {devices/lab_pin.sym} 29220 -12340 0 0 {name=p29036 lab=_46023_/X }
C {devices/lab_pin.sym} 29380 -12400 0 1 {name=p29037 lab=_86805_/D }
C {sky130_stdcells/a2bb2o_4.sym} 29300 -12400 0 0 {name=X_46028_ }
C {devices/lab_pin.sym} 29220 -12280 0 0 {name=p29038 lab=_87363_/Q }
C {devices/lab_pin.sym} 29220 -12240 0 0 {name=p29039 lab=_66878_/X }
C {devices/lab_pin.sym} 29220 -12200 0 0 {name=p29040 lab=_66879_/X }
C {devices/lab_pin.sym} 29220 -12160 0 0 {name=p29041 lab=_66950_/X }
C {devices/lab_pin.sym} 29380 -12220 0 1 {name=p29042 lab=_66951_/X }
C {sky130_stdcells/a211o_4.sym} 29300 -12220 0 0 {name=X_66951_ }
C {devices/lab_pin.sym} 29240 -12100 0 0 {name=p29043 lab=_61590_/B }
C {devices/lab_pin.sym} 29240 -12060 0 0 {name=p29044 lab=_61995_/X }
C {devices/lab_pin.sym} 29240 -12020 0 0 {name=p29045 lab=_62010_/X }
C {devices/lab_pin.sym} 29240 -11980 0 0 {name=p29046 lab=_62011_/X }
C {devices/lab_pin.sym} 29360 -12040 0 1 {name=p29047 lab=_62077_/C }
C {sky130_stdcells/nand4_4.sym} 29300 -12040 0 0 {name=X_62074_ }
C {devices/lab_pin.sym} 29240 -11900 0 0 {name=p29048 lab=_78937_/A }
C {devices/lab_pin.sym} 29240 -11860 0 0 {name=p29049 lab=_78937_/B }
C {devices/lab_pin.sym} 29360 -11880 0 1 {name=p29050 lab=_78952_/A }
C {sky130_stdcells/nand2_4.sym} 29300 -11880 0 0 {name=X_78937_ }
C {devices/lab_pin.sym} 29260 -11750 0 0 {name=p29051 lab=clkbuf_8_10_0_CLK/X }
C {devices/lab_pin.sym} 29340 -11750 0 1 {name=p29052 lab=clkbuf_9_20_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 29300 -11750 0 0 {name=Xclkbuf_9_20_0_CLK }
C {devices/lab_pin.sym} 29220 -11650 0 0 {name=p29053 lab=_65899_/Y }
C {devices/lab_pin.sym} 29220 -11610 0 0 {name=p29054 lab=_65830_/X }
C {devices/lab_pin.sym} 29220 -11570 0 0 {name=p29055 lab=_65901_/X }
C {devices/lab_pin.sym} 29380 -11610 0 1 {name=p29056 lab=_84170_/D }
C {sky130_stdcells/a21o_4.sym} 29300 -11610 0 0 {name=X_65902_ }
C {devices/lab_pin.sym} 29220 -11490 0 0 {name=p29057 lab=_60994_/A }
C {devices/lab_pin.sym} 29220 -11450 0 0 {name=p29058 lab=_60994_/B }
C {devices/lab_pin.sym} 29220 -11410 0 0 {name=p29059 lab=_60951_/Y }
C {devices/lab_pin.sym} 29380 -11450 0 1 {name=p29060 lab=_61025_/X }
C {sky130_stdcells/a21o_4.sym} 29300 -11450 0 0 {name=X_61025_ }
C {devices/lab_pin.sym} 29220 -11340 0 0 {name=p29061 lab=_69579_/X }
C {devices/lab_pin.sym} 29220 -11300 0 0 {name=p29062 lab=_69668_/Y }
C {devices/lab_pin.sym} 29220 -11260 0 0 {name=p29063 lab=_69604_/X }
C {devices/lab_pin.sym} 29220 -11220 0 0 {name=p29064 lab=_69669_/Y }
C {devices/lab_pin.sym} 29380 -11280 0 1 {name=p29065 lab=_69670_/X }
C {sky130_stdcells/a211o_4.sym} 29300 -11280 0 0 {name=X_69670_ }
C {devices/lab_pin.sym} 29220 -11150 0 0 {name=p29066 lab=_66877_/X }
C {devices/lab_pin.sym} 29220 -11110 0 0 {name=p29067 lab=_66881_/X }
C {devices/lab_pin.sym} 29220 -11070 0 0 {name=p29068 lab=_66787_/X }
C {devices/lab_pin.sym} 29380 -11110 0 1 {name=p29069 lab=_66886_/A }
C {sky130_stdcells/a21o_4.sym} 29300 -11110 0 0 {name=X_66882_ }
C {devices/lab_pin.sym} 29240 -10980 0 0 {name=p29070 lab=_78868_/A }
C {devices/lab_pin.sym} 29240 -10940 0 0 {name=p29071 lab=_78867_/Y }
C {devices/lab_pin.sym} 29360 -10960 0 1 {name=p29072 lab=_78869_/B }
C {sky130_stdcells/xor2_4.sym} 29300 -10960 0 0 {name=X_78868_ }
C {devices/lab_pin.sym} 29260 -10830 0 0 {name=p29073 lab=clkbuf_9_308_0_CLK/X }
C {devices/lab_pin.sym} 29340 -10830 0 1 {name=p29074 lab=_81179_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 29300 -10830 0 0 {name=Xclkbuf_10_617_0_CLK }
C {devices/lab_pin.sym} 29240 -10720 0 0 {name=p29075 lab=_69004_/A }
C {devices/lab_pin.sym} 29240 -10680 0 0 {name=p29076 lab=_88361_/Q }
C {devices/lab_pin.sym} 29360 -10700 0 1 {name=p29077 lab=_68621_/X }
C {sky130_stdcells/and2_4.sym} 29300 -10700 0 0 {name=X_68621_ }
C {devices/lab_pin.sym} 29240 -10590 0 0 {name=p29078 lab=_65317_/X }
C {devices/lab_pin.sym} 29240 -10550 0 0 {name=p29079 lab=_65833_/B }
C {devices/lab_pin.sym} 29240 -10510 0 0 {name=p29080 lab=_65320_/X }
C {devices/lab_pin.sym} 29360 -10550 0 1 {name=p29081 lab=_65833_/Y }
C {sky130_stdcells/nand3_4.sym} 29300 -10550 0 0 {name=X_65833_ }
C {devices/lab_pin.sym} 29260 -10410 0 0 {name=p29082 lab=_77819_/A }
C {devices/lab_pin.sym} 29340 -10410 0 1 {name=p29083 lab=_77819_/Y }
C {sky130_stdcells/inv_2.sym} 29300 -10410 0 0 {name=X_77819_ }
C {devices/lab_pin.sym} 29240 -10300 0 0 {name=p29084 lab=_47988_/A }
C {devices/lab_pin.sym} 29240 -10260 0 0 {name=p29085 lab=_50302_/B }
C {devices/lab_pin.sym} 29360 -10280 0 1 {name=p29086 lab=_47979_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -10280 0 0 {name=X_47979_ }
C {devices/lab_pin.sym} 29240 -10160 0 0 {name=p29087 lab=_82785_/D }
C {devices/lab_pin.sym} 29240 -10120 0 0 {name=p29088 lab=_78799_/B }
C {devices/lab_pin.sym} 29360 -10140 0 1 {name=p29089 lab=_78801_/A }
C {sky130_stdcells/nand2_4.sym} 29300 -10140 0 0 {name=X_78799_ }
C {devices/lab_pin.sym} 29260 -10010 0 0 {name=p29090 lab=clkbuf_8_54_0_CLK/X }
C {devices/lab_pin.sym} 29340 -10010 0 1 {name=p29091 lab=clkbuf_9_108_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 29300 -10010 0 0 {name=Xclkbuf_9_108_0_CLK }
C {devices/lab_pin.sym} 29220 -9910 0 0 {name=p29092 lab=_57721_/B }
C {devices/lab_pin.sym} 29220 -9870 0 0 {name=p29093 lab=_49715_/X }
C {devices/lab_pin.sym} 29220 -9830 0 0 {name=p29094 lab=_49717_/Y }
C {devices/lab_pin.sym} 29380 -9870 0 1 {name=p29095 lab=_49718_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -9870 0 0 {name=X_49718_ }
C {devices/lab_pin.sym} 29260 -9730 0 0 {name=p29096 lab=clkbuf_9_35_0_CLK/A }
C {devices/lab_pin.sym} 29340 -9730 0 1 {name=p29097 lab=clkbuf_9_35_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 29300 -9730 0 0 {name=Xclkbuf_9_35_0_CLK }
C {devices/lab_pin.sym} 29210 -9610 0 0 {name=p29098 lab=_83944_/CLK }
C {devices/lab_pin.sym} 29210 -9590 0 0 {name=p29099 lab=_83974_/Q }
C {devices/lab_pin.sym} 29390 -9610 0 1 {name=p29100 lab=_75677_/B }
C {sky130_stdcells/dfxtp_4.sym} 29300 -9600 0 0 {name=X_80830_ }
C {devices/lab_pin.sym} 29260 -9470 0 0 {name=p29101 lab=_66540_/A }
C {devices/lab_pin.sym} 29340 -9470 0 1 {name=p29102 lab=_68552_/X }
C {sky130_stdcells/buf_2.sym} 29300 -9470 0 0 {name=X_68552_ }
C {devices/lab_pin.sym} 29220 -9380 0 0 {name=p29103 lab=_65654_/X }
C {devices/lab_pin.sym} 29220 -9340 0 0 {name=p29104 lab=_86187_/Q }
C {devices/lab_pin.sym} 29220 -9300 0 0 {name=p29105 lab=_65761_/X }
C {devices/lab_pin.sym} 29220 -9260 0 0 {name=p29106 lab=_65763_/X }
C {devices/lab_pin.sym} 29380 -9320 0 1 {name=p29107 lab=_65764_/X }
C {sky130_stdcells/a211o_4.sym} 29300 -9320 0 0 {name=X_65764_ }
C {devices/lab_pin.sym} 29220 -9190 0 0 {name=p29108 lab=_50988_/Y }
C {devices/lab_pin.sym} 29220 -9150 0 0 {name=p29109 lab=_50983_/X }
C {devices/lab_pin.sym} 29220 -9110 0 0 {name=p29110 lab=_50989_/X }
C {devices/lab_pin.sym} 29380 -9150 0 1 {name=p29111 lab=_50990_/Y }
C {sky130_stdcells/a21oi_4.sym} 29300 -9150 0 0 {name=X_50990_ }
C {devices/lab_pin.sym} 29220 -9050 0 0 {name=p29112 lab=_62972_/Y }
C {devices/lab_pin.sym} 29220 -9010 0 0 {name=p29113 lab=_62642_/B }
C {devices/lab_pin.sym} 29220 -8970 0 0 {name=p29114 lab=_62973_/Y }
C {devices/lab_pin.sym} 29220 -8930 0 0 {name=p29115 lab=_62974_/Y }
C {devices/lab_pin.sym} 29220 -8900 0 0 {name=p29116 lab=_62975_/X }
C {devices/lab_pin.sym} 29380 -8970 0 1 {name=p29117 lab=_62976_/X }
C {sky130_stdcells/a41o_4.sym} 29300 -8970 0 0 {name=X_62976_ }
C {devices/lab_pin.sym} 29220 -8830 0 0 {name=p29118 lab=_67498_/X }
C {devices/lab_pin.sym} 29220 -8790 0 0 {name=p29119 lab=_67501_/X }
C {devices/lab_pin.sym} 29220 -8750 0 0 {name=p29120 lab=_67502_/X }
C {devices/lab_pin.sym} 29380 -8790 0 1 {name=p29121 lab=_67506_/A }
C {sky130_stdcells/a21o_4.sym} 29300 -8790 0 0 {name=X_67503_ }
C {devices/lab_pin.sym} 29260 -8650 0 0 {name=p29122 lab=_64565_/A }
C {devices/lab_pin.sym} 29340 -8650 0 1 {name=p29123 lab=_65790_/A }
C {sky130_stdcells/buf_2.sym} 29300 -8650 0 0 {name=X_64715_ }
C {devices/lab_pin.sym} 29240 -8550 0 0 {name=p29124 lab=_61960_/A }
C {devices/lab_pin.sym} 29240 -8510 0 0 {name=p29125 lab=_61960_/B }
C {devices/lab_pin.sym} 29240 -8470 0 0 {name=p29126 lab=_78068_/B }
C {devices/lab_pin.sym} 29360 -8510 0 1 {name=p29127 lab=_61927_/Y }
C {sky130_stdcells/nor3_4.sym} 29300 -8510 0 0 {name=X_61927_ }
C {devices/lab_pin.sym} 29220 -8390 0 0 {name=p29128 lab=_59256_/B }
C {devices/lab_pin.sym} 29220 -8350 0 0 {name=p29129 lab=_49632_/X }
C {devices/lab_pin.sym} 29220 -8310 0 0 {name=p29130 lab=_49648_/Y }
C {devices/lab_pin.sym} 29380 -8350 0 1 {name=p29131 lab=_49649_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -8350 0 0 {name=X_49649_ }
C {devices/lab_pin.sym} 29210 -8210 0 0 {name=p29132 lab=_80968_/CLK }
C {devices/lab_pin.sym} 29210 -8190 0 0 {name=p29133 lab=_80761_/D }
C {devices/lab_pin.sym} 29390 -8210 0 1 {name=p29134 lab=_81137_/D }
C {sky130_stdcells/dfxtp_4.sym} 29300 -8200 0 0 {name=X_80761_ }
C {devices/lab_pin.sym} 29220 -8100 0 0 {name=p29135 lab=_87503_/Q }
C {devices/lab_pin.sym} 29220 -8060 0 0 {name=p29136 lab=_68365_/X }
C {devices/lab_pin.sym} 29220 -8020 0 0 {name=p29137 lab=_68450_/X }
C {devices/lab_pin.sym} 29220 -7980 0 0 {name=p29138 lab=_68482_/X }
C {devices/lab_pin.sym} 29380 -8040 0 1 {name=p29139 lab=_68483_/X }
C {sky130_stdcells/a211o_4.sym} 29300 -8040 0 0 {name=X_68483_ }
C {devices/lab_pin.sym} 29240 -7910 0 0 {name=p29140 lab=_65063_/X }
C {devices/lab_pin.sym} 29240 -7870 0 0 {name=p29141 lab=_65828_/B }
C {devices/lab_pin.sym} 29240 -7830 0 0 {name=p29142 lab=_65067_/X }
C {devices/lab_pin.sym} 29360 -7870 0 1 {name=p29143 lab=_65695_/Y }
C {sky130_stdcells/nand3_4.sym} 29300 -7870 0 0 {name=X_65695_ }
C {devices/lab_pin.sym} 29210 -7730 0 0 {name=p29144 lab=_82942_/CLK }
C {devices/lab_pin.sym} 29210 -7710 0 0 {name=p29145 lab=_79124_/Y }
C {devices/lab_pin.sym} 29390 -7730 0 1 {name=p29146 lab=_78341_/A }
C {sky130_stdcells/dfxtp_4.sym} 29300 -7720 0 0 {name=X_82500_ }
C {devices/lab_pin.sym} 29240 -7600 0 0 {name=p29147 lab=_67364_/X }
C {devices/lab_pin.sym} 29240 -7560 0 0 {name=p29148 lab=_67434_/B }
C {devices/lab_pin.sym} 29360 -7580 0 1 {name=p29149 lab=_67434_/X }
C {sky130_stdcells/and2_4.sym} 29300 -7580 0 0 {name=X_67434_ }
C {devices/lab_pin.sym} 29260 -7450 0 0 {name=p29150 lab=_52605_/A }
C {devices/lab_pin.sym} 29340 -7450 0 1 {name=p29151 lab=_52661_/B }
C {sky130_stdcells/buf_2.sym} 29300 -7450 0 0 {name=X_52660_ }
C {devices/lab_pin.sym} 29260 -7330 0 0 {name=p29152 lab=_64923_/A }
C {devices/lab_pin.sym} 29340 -7330 0 1 {name=p29153 lab=_64773_/A }
C {sky130_stdcells/buf_2.sym} 29300 -7330 0 0 {name=X_64646_ }
C {devices/lab_pin.sym} 29210 -7210 0 0 {name=p29154 lab=_83480_/CLK }
C {devices/lab_pin.sym} 29210 -7190 0 0 {name=p29155 lab=_83480_/D }
C {devices/lab_pin.sym} 29390 -7210 0 1 {name=p29156 lab=_83480_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -7200 0 0 {name=X_83480_ }
C {devices/lab_pin.sym} 29260 -7070 0 0 {name=p29157 lab=_61708_/X }
C {devices/lab_pin.sym} 29340 -7070 0 1 {name=p29158 lab=_61860_/C }
C {sky130_stdcells/buf_2.sym} 29300 -7070 0 0 {name=X_61858_ }
C {devices/lab_pin.sym} 29210 -6950 0 0 {name=p29159 lab=_81104_/CLK }
C {devices/lab_pin.sym} 29210 -6930 0 0 {name=p29160 lab=_80692_/D }
C {devices/lab_pin.sym} 29390 -6950 0 1 {name=p29161 lab=_80692_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -6940 0 0 {name=X_80692_ }
C {devices/lab_pin.sym} 29240 -6820 0 0 {name=p29162 lab=_51617_/A }
C {devices/lab_pin.sym} 29240 -6780 0 0 {name=p29163 lab=_53135_/B }
C {devices/lab_pin.sym} 29360 -6800 0 1 {name=p29164 lab=_51611_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -6800 0 0 {name=X_51611_ }
C {devices/lab_pin.sym} 29210 -6670 0 0 {name=p29165 lab=_83167_/CLK }
C {devices/lab_pin.sym} 29210 -6650 0 0 {name=p29166 lab=_82463_/Q }
C {devices/lab_pin.sym} 29390 -6670 0 1 {name=p29167 lab=_78750_/A }
C {sky130_stdcells/dfxtp_4.sym} 29300 -6660 0 0 {name=X_82431_ }
C {devices/lab_pin.sym} 29260 -6530 0 0 {name=p29168 lab=_60765_/Y }
C {devices/lab_pin.sym} 29340 -6530 0 1 {name=p29169 lab=_60809_/Y }
C {sky130_stdcells/inv_2.sym} 29300 -6530 0 0 {name=X_60809_ }
C {devices/lab_pin.sym} 29240 -6420 0 0 {name=p29170 lab=_67364_/X }
C {devices/lab_pin.sym} 29240 -6380 0 0 {name=p29171 lab=_67365_/B }
C {devices/lab_pin.sym} 29360 -6400 0 1 {name=p29172 lab=_67365_/X }
C {sky130_stdcells/and2_4.sym} 29300 -6400 0 0 {name=X_67365_ }
C {devices/lab_pin.sym} 29260 -6270 0 0 {name=p29173 lab=_64797_/A }
C {devices/lab_pin.sym} 29340 -6270 0 1 {name=p29174 lab=_64577_/X }
C {sky130_stdcells/buf_2.sym} 29300 -6270 0 0 {name=X_64577_ }
C {devices/lab_pin.sym} 29220 -6170 0 0 {name=p29175 lab=_85790_/Q }
C {devices/lab_pin.sym} 29220 -6130 0 0 {name=p29176 lab=_52575_/X }
C {devices/lab_pin.sym} 29220 -6090 0 0 {name=p29177 lab=_52590_/Y }
C {devices/lab_pin.sym} 29380 -6130 0 1 {name=p29178 lab=_52591_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -6130 0 0 {name=X_52591_ }
C {devices/lab_pin.sym} 29240 -6020 0 0 {name=p29179 lab=_61770_/A }
C {devices/lab_pin.sym} 29240 -5980 0 0 {name=p29180 lab=_61823_/B }
C {devices/lab_pin.sym} 29240 -5940 0 0 {name=p29181 lab=_63410_/B }
C {devices/lab_pin.sym} 29240 -5900 0 0 {name=p29182 lab=_61788_/X }
C {devices/lab_pin.sym} 29360 -5960 0 1 {name=p29183 lab=_61789_/X }
C {sky130_stdcells/and4_4.sym} 29300 -5960 0 0 {name=X_61789_ }
C {sky130_stdcells/decap_3.sym} 29300 -5780 0 0 {name=XPHY_708 }
C {devices/lab_pin.sym} 29240 -5640 0 0 {name=p29184 lab=_69059_/A }
C {devices/lab_pin.sym} 29240 -5600 0 0 {name=p29185 lab=_69104_/B }
C {devices/lab_pin.sym} 29360 -5620 0 1 {name=p29186 lab=_69104_/X }
C {sky130_stdcells/and2_4.sym} 29300 -5620 0 0 {name=X_69104_ }
C {devices/lab_pin.sym} 29240 -5520 0 0 {name=p29187 lab=_54325_/A }
C {devices/lab_pin.sym} 29240 -5480 0 0 {name=p29188 lab=_54353_/B }
C {devices/lab_pin.sym} 29240 -5440 0 0 {name=p29189 lab=_54317_/X }
C {devices/lab_pin.sym} 29240 -5400 0 0 {name=p29190 lab=_46727_/Y }
C {devices/lab_pin.sym} 29360 -5460 0 1 {name=p29191 lab=_54330_/X }
C {sky130_stdcells/and4_4.sym} 29300 -5460 0 0 {name=X_54330_ }
C {devices/lab_pin.sym} 29240 -5330 0 0 {name=p29192 lab=_65850_/X }
C {devices/lab_pin.sym} 29240 -5290 0 0 {name=p29193 lab=_66276_/B }
C {devices/lab_pin.sym} 29240 -5250 0 0 {name=p29194 lab=_65852_/X }
C {devices/lab_pin.sym} 29360 -5290 0 1 {name=p29195 lab=_66316_/Y }
C {sky130_stdcells/nand3_4.sym} 29300 -5290 0 0 {name=X_66316_ }
C {devices/lab_pin.sym} 29210 -5150 0 0 {name=p29196 lab=_85152_/CLK }
C {devices/lab_pin.sym} 29210 -5130 0 0 {name=p29197 lab=_85150_/D }
C {devices/lab_pin.sym} 29390 -5150 0 1 {name=p29198 lab=_55599_/B }
C {sky130_stdcells/dfxtp_4.sym} 29300 -5140 0 0 {name=X_85150_ }
C {devices/lab_pin.sym} 29220 -5030 0 0 {name=p29199 lab=_85991_/Q }
C {devices/lab_pin.sym} 29220 -4990 0 0 {name=p29200 lab=_51539_/X }
C {devices/lab_pin.sym} 29220 -4950 0 0 {name=p29201 lab=_51541_/Y }
C {devices/lab_pin.sym} 29380 -4990 0 1 {name=p29202 lab=_51542_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -4990 0 0 {name=X_51542_ }
C {devices/lab_pin.sym} 29260 -4850 0 0 {name=p29203 lab=_63528_/A }
C {devices/lab_pin.sym} 29340 -4850 0 1 {name=p29204 lab=_63554_/A }
C {sky130_stdcells/buf_2.sym} 29300 -4850 0 0 {name=X_63528_ }
C {devices/lab_pin.sym} 29210 -4730 0 0 {name=p29205 lab=_84980_/CLK }
C {devices/lab_pin.sym} 29210 -4710 0 0 {name=p29206 lab=_77232_/Y }
C {devices/lab_pin.sym} 29390 -4730 0 1 {name=p29207 lab=_82362_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -4720 0 0 {name=X_82362_ }
C {devices/lab_pin.sym} 29240 -4600 0 0 {name=p29208 lab=_67250_/A }
C {devices/lab_pin.sym} 29240 -4560 0 0 {name=p29209 lab=_67296_/B }
C {devices/lab_pin.sym} 29360 -4580 0 1 {name=p29210 lab=_67296_/X }
C {sky130_stdcells/and2_4.sym} 29300 -4580 0 0 {name=X_67296_ }
C {devices/lab_pin.sym} 29210 -4450 0 0 {name=p29211 lab=_80928_/CLK }
C {devices/lab_pin.sym} 29210 -4430 0 0 {name=p29212 lab=_66687_/X }
C {devices/lab_pin.sym} 29390 -4450 0 1 {name=p29213 lab=_84101_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -4440 0 0 {name=X_84101_ }
C {devices/lab_pin.sym} 29210 -4310 0 0 {name=p29214 lab=_81801_/CLK }
C {devices/lab_pin.sym} 29210 -4290 0 0 {name=p29215 lab=_77001_/X }
C {devices/lab_pin.sym} 29390 -4310 0 1 {name=p29216 lab=_81313_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -4300 0 0 {name=X_81313_ }
C {devices/lab_pin.sym} 29260 -4170 0 0 {name=p29217 lab=_69035_/A }
C {devices/lab_pin.sym} 29340 -4170 0 1 {name=p29218 lab=_69035_/X }
C {sky130_stdcells/buf_2.sym} 29300 -4170 0 0 {name=X_69035_ }
C {devices/lab_pin.sym} 29240 -4060 0 0 {name=p29219 lab=_54961_/A }
C {devices/lab_pin.sym} 29240 -4020 0 0 {name=p29220 lab=_53095_/B }
C {devices/lab_pin.sym} 29360 -4040 0 1 {name=p29221 lab=_54261_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -4040 0 0 {name=X_54261_ }
C {devices/lab_pin.sym} 29240 -3930 0 0 {name=p29222 lab=_66231_/X }
C {devices/lab_pin.sym} 29240 -3890 0 0 {name=p29223 lab=_66151_/B }
C {devices/lab_pin.sym} 29240 -3850 0 0 {name=p29224 lab=_66247_/C }
C {devices/lab_pin.sym} 29360 -3890 0 1 {name=p29225 lab=_66247_/X }
C {sky130_stdcells/and3_4.sym} 29300 -3890 0 0 {name=X_66247_ }
C {devices/lab_pin.sym} 29210 -3750 0 0 {name=p29226 lab=_85089_/CLK }
C {devices/lab_pin.sym} 29210 -3730 0 0 {name=p29227 lab=_85081_/D }
C {devices/lab_pin.sym} 29390 -3750 0 1 {name=p29228 lab=_57113_/B }
C {sky130_stdcells/dfxtp_4.sym} 29300 -3740 0 0 {name=X_85081_ }
C {devices/lab_pin.sym} 29240 -3640 0 0 {name=p29229 lab=_51473_/A }
C {devices/lab_pin.sym} 29240 -3600 0 0 {name=p29230 lab=_51473_/B }
C {devices/lab_pin.sym} 29240 -3560 0 0 {name=p29231 lab=_51494_/C }
C {devices/lab_pin.sym} 29240 -3520 0 0 {name=p29232 lab=_52997_/D }
C {devices/lab_pin.sym} 29360 -3580 0 1 {name=p29233 lab=_51473_/X }
C {sky130_stdcells/and4_4.sym} 29300 -3580 0 0 {name=X_51473_ }
C {devices/lab_pin.sym} 29240 -3460 0 0 {name=p29234 lab=_63448_/A }
C {devices/lab_pin.sym} 29240 -3420 0 0 {name=p29235 lab=_63459_/B }
C {devices/lab_pin.sym} 29240 -3380 0 0 {name=p29236 lab=_63458_/X }
C {devices/lab_pin.sym} 29240 -3340 0 0 {name=p29237 lab=_63410_/D }
C {devices/lab_pin.sym} 29360 -3400 0 1 {name=p29238 lab=_63459_/X }
C {sky130_stdcells/and4_4.sym} 29300 -3400 0 0 {name=X_63459_ }
C {devices/lab_pin.sym} 29210 -3250 0 0 {name=p29239 lab=_82103_/CLK }
C {devices/lab_pin.sym} 29210 -3230 0 0 {name=p29240 lab=_82293_/D }
C {devices/lab_pin.sym} 29390 -3250 0 1 {name=p29241 lab=_82293_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -3240 0 0 {name=X_82293_ }
C {devices/lab_pin.sym} 29260 -3110 0 0 {name=p29242 lab=_55999_/X }
C {devices/lab_pin.sym} 29340 -3110 0 1 {name=p29243 lab=_56001_/A }
C {sky130_stdcells/buf_2.sym} 29300 -3110 0 0 {name=X_56000_ }
C {devices/lab_pin.sym} 29220 -3010 0 0 {name=p29244 lab=_53210_/Y }
C {devices/lab_pin.sym} 29220 -2970 0 0 {name=p29245 lab=_53189_/X }
C {devices/lab_pin.sym} 29220 -2930 0 0 {name=p29246 lab=_53211_/X }
C {devices/lab_pin.sym} 29380 -2970 0 1 {name=p29247 lab=_85676_/D }
C {sky130_stdcells/a21oi_4.sym} 29300 -2970 0 0 {name=X_53212_ }
C {devices/lab_pin.sym} 29210 -2830 0 0 {name=p29248 lab=_81160_/CLK }
C {devices/lab_pin.sym} 29210 -2810 0 0 {name=p29249 lab=_68127_/X }
C {devices/lab_pin.sym} 29390 -2830 0 1 {name=p29250 lab=_82072_/D }
C {sky130_stdcells/dfxtp_4.sym} 29300 -2820 0 0 {name=X_84032_ }
C {devices/lab_pin.sym} 29220 -2710 0 0 {name=p29251 lab=_86203_/Q }
C {devices/lab_pin.sym} 29220 -2670 0 0 {name=p29252 lab=_50403_/X }
C {devices/lab_pin.sym} 29220 -2630 0 0 {name=p29253 lab=_50423_/Y }
C {devices/lab_pin.sym} 29380 -2670 0 1 {name=p29254 lab=_50424_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -2670 0 0 {name=X_50424_ }
C {devices/lab_pin.sym} 29210 -2530 0 0 {name=p29255 lab=_85372_/CLK }
C {devices/lab_pin.sym} 29210 -2510 0 0 {name=p29256 lab=_81052_/Q }
C {devices/lab_pin.sym} 29390 -2530 0 1 {name=p29257 lab=_81244_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -2520 0 0 {name=X_81244_ }
C {devices/lab_pin.sym} 29220 -2410 0 0 {name=p29258 lab=_54189_/Y }
C {devices/lab_pin.sym} 29220 -2370 0 0 {name=p29259 lab=_54171_/X }
C {devices/lab_pin.sym} 29220 -2330 0 0 {name=p29260 lab=_54191_/X }
C {devices/lab_pin.sym} 29380 -2370 0 1 {name=p29261 lab=_54192_/Y }
C {sky130_stdcells/a21oi_4.sym} 29300 -2370 0 0 {name=X_54192_ }
C {devices/lab_pin.sym} 29220 -2250 0 0 {name=p29262 lab=_66174_/Y }
C {devices/lab_pin.sym} 29220 -2210 0 0 {name=p29263 lab=_66137_/X }
C {devices/lab_pin.sym} 29220 -2170 0 0 {name=p29264 lab=_66177_/Y }
C {devices/lab_pin.sym} 29380 -2210 0 1 {name=p29265 lab=_84151_/D }
C {sky130_stdcells/a21o_4.sym} 29300 -2210 0 0 {name=X_66178_ }
C {devices/lab_pin.sym} 29260 -2070 0 0 {name=p29266 lab=_53195_/A }
C {devices/lab_pin.sym} 29340 -2070 0 1 {name=p29267 lab=_53143_/X }
C {sky130_stdcells/buf_2.sym} 29300 -2070 0 0 {name=X_53143_ }
C {devices/lab_pin.sym} 29260 -1950 0 0 {name=p29268 lab=_65791_/A }
C {devices/lab_pin.sym} 29340 -1950 0 1 {name=p29269 lab=_65155_/A }
C {sky130_stdcells/buf_2.sym} 29300 -1950 0 0 {name=X_65129_ }
C {devices/lab_pin.sym} 29220 -1850 0 0 {name=p29270 lab=_86217_/Q }
C {devices/lab_pin.sym} 29220 -1810 0 0 {name=p29271 lab=_50316_/X }
C {devices/lab_pin.sym} 29220 -1770 0 0 {name=p29272 lab=_50354_/Y }
C {devices/lab_pin.sym} 29380 -1810 0 1 {name=p29273 lab=_50355_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -1810 0 0 {name=X_50355_ }
C {devices/lab_pin.sym} 29210 -1670 0 0 {name=p29274 lab=_82335_/CLK }
C {devices/lab_pin.sym} 29210 -1650 0 0 {name=p29275 lab=_74998_/B }
C {devices/lab_pin.sym} 29390 -1670 0 1 {name=p29276 lab=_81175_/Q }
C {sky130_stdcells/dfxtp_4.sym} 29300 -1660 0 0 {name=X_81175_ }
C {devices/lab_pin.sym} 29260 -1530 0 0 {name=p29277 lab=_40351_/Y }
C {devices/lab_pin.sym} 29340 -1530 0 1 {name=p29278 lab=_47002_/A }
C {sky130_stdcells/buf_8.sym} 29300 -1530 0 0 {name=Xpsn_inst_psn_buff_30 }
C {devices/lab_pin.sym} 29240 -1420 0 0 {name=p29279 lab=_80122_/X }
C {devices/lab_pin.sym} 29240 -1380 0 0 {name=p29280 lab=_80125_/Y }
C {devices/lab_pin.sym} 29360 -1400 0 1 {name=p29281 lab=_80126_/X }
C {sky130_stdcells/xor2_4.sym} 29300 -1400 0 0 {name=X_80126_ }
C {devices/lab_pin.sym} 29240 -1300 0 0 {name=p29282 lab=_53074_/A }
C {devices/lab_pin.sym} 29240 -1260 0 0 {name=p29283 lab=_53069_/X }
C {devices/lab_pin.sym} 29240 -1220 0 0 {name=p29284 lab=_53074_/C }
C {devices/lab_pin.sym} 29240 -1180 0 0 {name=p29285 lab=_53074_/D }
C {devices/lab_pin.sym} 29360 -1240 0 1 {name=p29286 lab=_53074_/X }
C {sky130_stdcells/and4_4.sym} 29300 -1240 0 0 {name=X_53074_ }
C {devices/lab_pin.sym} 29220 -1110 0 0 {name=p29287 lab=_57946_/Y }
C {devices/lab_pin.sym} 29220 -1070 0 0 {name=p29288 lab=_57950_/Y }
C {devices/lab_pin.sym} 29220 -1030 0 0 {name=p29289 lab=_57889_/X }
C {devices/lab_pin.sym} 29380 -1070 0 1 {name=p29290 lab=_57951_/X }
C {sky130_stdcells/a21o_4.sym} 29300 -1070 0 0 {name=X_57951_ }
C {devices/lab_pin.sym} 29240 -940 0 0 {name=p29291 lab=_69937_/A }
C {devices/lab_pin.sym} 29240 -900 0 0 {name=p29292 lab=_69937_/B }
C {devices/lab_pin.sym} 29360 -920 0 1 {name=p29293 lab=_69937_/Y }
C {sky130_stdcells/nand2_4.sym} 29300 -920 0 0 {name=X_69937_ }
C {devices/lab_pin.sym} 29220 -810 0 0 {name=p29294 lab=_86231_/Q }
C {devices/lab_pin.sym} 29220 -770 0 0 {name=p29295 lab=_50282_/X }
C {devices/lab_pin.sym} 29220 -730 0 0 {name=p29296 lab=_50285_/Y }
C {devices/lab_pin.sym} 29380 -770 0 1 {name=p29297 lab=_50286_/Y }
C {sky130_stdcells/o21ai_4.sym} 29300 -770 0 0 {name=X_50286_ }
C {devices/lab_pin.sym} 30130 -42150 0 0 {name=p29298 lab=_85697_/CLK }
C {devices/lab_pin.sym} 30130 -42130 0 0 {name=p29299 lab=_85983_/D }
C {devices/lab_pin.sym} 30310 -42150 0 1 {name=p29300 lab=_85983_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -42140 0 0 {name=X_85983_ }
C {devices/lab_pin.sym} 30160 -42020 0 0 {name=p29301 lab=_52058_/A }
C {devices/lab_pin.sym} 30160 -41980 0 0 {name=p29302 lab=_50322_/B }
C {devices/lab_pin.sym} 30280 -42000 0 1 {name=p29303 lab=_52025_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -42000 0 0 {name=X_52025_ }
C {devices/lab_pin.sym} 30160 -41880 0 0 {name=p29304 lab=_55657_/Y }
C {devices/lab_pin.sym} 30160 -41840 0 0 {name=p29305 lab=_56688_/X }
C {devices/lab_pin.sym} 30280 -41860 0 1 {name=p29306 lab=_56902_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -41860 0 0 {name=X_56902_ }
C {devices/lab_pin.sym} 30130 -41730 0 0 {name=p29307 lab=_87708_/CLK }
C {devices/lab_pin.sym} 30130 -41710 0 0 {name=p29308 lab=_87722_/D }
C {devices/lab_pin.sym} 30310 -41730 0 1 {name=p29309 lab=_87722_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -41720 0 0 {name=X_87722_ }
C {devices/lab_pin.sym} 30130 -41590 0 0 {name=p29310 lab=_85381_/CLK }
C {devices/lab_pin.sym} 30130 -41570 0 0 {name=p29311 lab=_84934_/D }
C {devices/lab_pin.sym} 30310 -41590 0 1 {name=p29312 lab=_84934_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -41580 0 0 {name=X_84934_ }
C {devices/lab_pin.sym} 30160 -41460 0 0 {name=p29313 lab=_80048_/X }
C {devices/lab_pin.sym} 30160 -41420 0 0 {name=p29314 lab=_80057_/B }
C {devices/lab_pin.sym} 30280 -41440 0 1 {name=p29315 lab=_80057_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -41440 0 0 {name=X_80057_ }
C {devices/lab_pin.sym} 30140 -41340 0 0 {name=p29316 lab=_84943_/Q }
C {devices/lab_pin.sym} 30140 -41300 0 0 {name=p29317 lab=_57819_/X }
C {devices/lab_pin.sym} 30140 -41260 0 0 {name=p29318 lab=_57873_/X }
C {devices/lab_pin.sym} 30140 -41220 0 0 {name=p29319 lab=_57881_/X }
C {devices/lab_pin.sym} 30300 -41280 0 1 {name=p29320 lab=_84943_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 30220 -41280 0 0 {name=X_57882_ }
C {devices/lab_pin.sym} 30140 -41160 0 0 {name=p29321 lab=_69448_/Y }
C {devices/lab_pin.sym} 30140 -41120 0 0 {name=p29322 lab=_69732_/X }
C {devices/lab_pin.sym} 30140 -41080 0 0 {name=p29323 lab=_69815_/X }
C {devices/lab_pin.sym} 30140 -41040 0 0 {name=p29324 lab=_69867_/Y }
C {devices/lab_pin.sym} 30300 -41100 0 1 {name=p29325 lab=_69868_/X }
C {sky130_stdcells/a211o_4.sym} 30220 -41100 0 0 {name=X_69868_ }
C {devices/lab_pin.sym} 30160 -40980 0 0 {name=p29326 lab=_61276_/B }
C {devices/lab_pin.sym} 30160 -40940 0 0 {name=p29327 lab=_59639_/A }
C {devices/lab_pin.sym} 30160 -40900 0 0 {name=p29328 lab=_59640_/A }
C {devices/lab_pin.sym} 30160 -40860 0 0 {name=p29329 lab=_60175_/A }
C {devices/lab_pin.sym} 30280 -40920 0 1 {name=p29330 lab=_59621_/X }
C {sky130_stdcells/and4_4.sym} 30220 -40920 0 0 {name=X_59621_ }
C {devices/lab_pin.sym} 30140 -40790 0 0 {name=p29331 lab=_56832_/X }
C {devices/lab_pin.sym} 30140 -40750 0 0 {name=p29332 lab=_55681_/X }
C {devices/lab_pin.sym} 30140 -40710 0 0 {name=p29333 lab=_56777_/B }
C {devices/lab_pin.sym} 30300 -40750 0 1 {name=p29334 lab=_56833_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -40750 0 0 {name=X_56833_ }
C {devices/lab_pin.sym} 30180 -40610 0 0 {name=p29335 lab=_64980_/A }
C {devices/lab_pin.sym} 30260 -40610 0 1 {name=p29336 lab=_68819_/X }
C {sky130_stdcells/buf_2.sym} 30220 -40610 0 0 {name=X_68819_ }
C {devices/lab_pin.sym} 30130 -40490 0 0 {name=p29337 lab=_87653_/CLK }
C {devices/lab_pin.sym} 30130 -40470 0 0 {name=p29338 lab=_87653_/D }
C {devices/lab_pin.sym} 30310 -40490 0 1 {name=p29339 lab=_67675_/B }
C {sky130_stdcells/dfxtp_4.sym} 30220 -40480 0 0 {name=X_87653_ }
C {devices/lab_pin.sym} 30130 -40350 0 0 {name=p29340 lab=_84344_/CLK }
C {devices/lab_pin.sym} 30130 -40330 0 0 {name=p29341 lab=_84865_/D }
C {devices/lab_pin.sym} 30310 -40350 0 1 {name=p29342 lab=_84865_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -40340 0 0 {name=X_84865_ }
C {devices/lab_pin.sym} 30140 -40240 0 0 {name=p29343 lab=_87054_/Q }
C {devices/lab_pin.sym} 30140 -40200 0 0 {name=p29344 lab=_69796_/X }
C {devices/lab_pin.sym} 30140 -40160 0 0 {name=p29345 lab=_69797_/X }
C {devices/lab_pin.sym} 30140 -40120 0 0 {name=p29346 lab=_69798_/X }
C {devices/lab_pin.sym} 30300 -40180 0 1 {name=p29347 lab=_69800_/B }
C {sky130_stdcells/a211o_4.sym} 30220 -40180 0 0 {name=X_69799_ }
C {devices/lab_pin.sym} 30130 -40030 0 0 {name=p29348 lab=_85962_/CLK }
C {devices/lab_pin.sym} 30130 -40010 0 0 {name=p29349 lab=_86604_/D }
C {devices/lab_pin.sym} 30310 -40030 0 1 {name=p29350 lab=_72378_/A }
C {sky130_stdcells/dfxtp_4.sym} 30220 -40020 0 0 {name=X_86604_ }
C {devices/lab_pin.sym} 30180 -39890 0 0 {name=p29351 lab=_71714_/Y }
C {devices/lab_pin.sym} 30260 -39890 0 1 {name=p29352 lab=_71839_/B }
C {sky130_stdcells/buf_2.sym} 30220 -39890 0 0 {name=X_71830_ }
C {devices/lab_pin.sym} 30160 -39800 0 0 {name=p29353 lab=_60407_/A }
C {devices/lab_pin.sym} 30160 -39760 0 0 {name=p29354 lab=_59552_/B }
C {devices/lab_pin.sym} 30160 -39720 0 0 {name=p29355 lab=_59552_/C }
C {devices/lab_pin.sym} 30160 -39680 0 0 {name=p29356 lab=_60407_/C }
C {devices/lab_pin.sym} 30280 -39740 0 1 {name=p29357 lab=_59552_/Y }
C {sky130_stdcells/nand4_4.sym} 30220 -39740 0 0 {name=X_59552_ }
C {devices/lab_pin.sym} 30130 -39590 0 0 {name=p29358 lab=_83813_/CLK }
C {devices/lab_pin.sym} 30130 -39570 0 0 {name=p29359 lab=_83816_/D }
C {devices/lab_pin.sym} 30310 -39590 0 1 {name=p29360 lab=_74801_/B }
C {sky130_stdcells/dfxtp_4.sym} 30220 -39580 0 0 {name=X_83816_ }
C {devices/lab_pin.sym} 30160 -39480 0 0 {name=p29361 lab=_59498_/A }
C {devices/lab_pin.sym} 30160 -39440 0 0 {name=p29362 lab=_56764_/B }
C {devices/lab_pin.sym} 30160 -39400 0 0 {name=p29363 lab=_56764_/C }
C {devices/lab_pin.sym} 30160 -39360 0 0 {name=p29364 lab=_56764_/D }
C {devices/lab_pin.sym} 30280 -39420 0 1 {name=p29365 lab=_56764_/Y }
C {sky130_stdcells/nand4_4.sym} 30220 -39420 0 0 {name=X_56764_ }
C {devices/lab_pin.sym} 30130 -39270 0 0 {name=p29366 lab=_87595_/CLK }
C {devices/lab_pin.sym} 30130 -39250 0 0 {name=p29367 lab=_43079_/Y }
C {devices/lab_pin.sym} 30310 -39270 0 1 {name=p29368 lab=_87584_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -39260 0 0 {name=X_87584_ }
C {devices/lab_pin.sym} 30160 -39140 0 0 {name=p29369 lab=_53956_/X }
C {devices/lab_pin.sym} 30160 -39100 0 0 {name=p29370 lab=_53976_/B }
C {devices/lab_pin.sym} 30280 -39120 0 1 {name=p29371 lab=_53976_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -39120 0 0 {name=X_53976_ }
C {devices/lab_pin.sym} 30140 -39030 0 0 {name=p29372 lab=_41960_/X }
C {devices/lab_pin.sym} 30140 -38990 0 0 {name=p29373 lab=_41951_/X }
C {devices/lab_pin.sym} 30140 -38950 0 0 {name=p29374 lab=_40787_/X }
C {devices/lab_pin.sym} 30140 -38910 0 0 {name=p29375 lab=_72855_/A }
C {devices/lab_pin.sym} 30140 -38870 0 0 {name=p29376 lab=_41953_/X }
C {devices/lab_pin.sym} 30300 -38950 0 1 {name=p29377 lab=_41990_/Y }
C {sky130_stdcells/o32ai_4.sym} 30220 -38950 0 0 {name=X_41990_ }
C {devices/lab_pin.sym} 30130 -38790 0 0 {name=p29378 lab=_86701_/CLK }
C {devices/lab_pin.sym} 30130 -38770 0 0 {name=p29379 lab=_84796_/D }
C {devices/lab_pin.sym} 30310 -38790 0 1 {name=p29380 lab=_84796_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -38780 0 0 {name=X_84796_ }
C {devices/lab_pin.sym} 30140 -38670 0 0 {name=p29381 lab=_58492_/X }
C {devices/lab_pin.sym} 30140 -38630 0 0 {name=p29382 lab=_58500_/Y }
C {devices/lab_pin.sym} 30140 -38590 0 0 {name=p29383 lab=_58502_/Y }
C {devices/lab_pin.sym} 30300 -38630 0 1 {name=p29384 lab=_58503_/Y }
C {sky130_stdcells/a21oi_4.sym} 30220 -38630 0 0 {name=X_58503_ }
C {devices/lab_pin.sym} 30160 -38500 0 0 {name=p29385 lab=_55245_/A }
C {devices/lab_pin.sym} 30160 -38460 0 0 {name=p29386 lab=_55715_/B }
C {devices/lab_pin.sym} 30280 -38480 0 1 {name=p29387 lab=_55715_/X }
C {sky130_stdcells/and2_4.sym} 30220 -38480 0 0 {name=X_55715_ }
C {devices/lab_pin.sym} 30130 -38350 0 0 {name=p29388 lab=_86535_/CLK }
C {devices/lab_pin.sym} 30130 -38330 0 0 {name=p29389 lab=_48326_/Y }
C {devices/lab_pin.sym} 30310 -38350 0 1 {name=p29390 lab=_74177_/B }
C {sky130_stdcells/dfxtp_4.sym} 30220 -38340 0 0 {name=X_86535_ }
C {devices/lab_pin.sym} 30180 -38210 0 0 {name=p29391 lab=_40941_/A }
C {devices/lab_pin.sym} 30260 -38210 0 1 {name=p29392 lab=_40941_/X }
C {sky130_stdcells/buf_2.sym} 30220 -38210 0 0 {name=X_40941_ }
C {devices/lab_pin.sym} 30160 -38120 0 0 {name=p29393 lab=_52922_/A }
C {devices/lab_pin.sym} 30160 -38080 0 0 {name=p29394 lab=_52916_/B }
C {devices/lab_pin.sym} 30160 -38040 0 0 {name=p29395 lab=_52926_/X }
C {devices/lab_pin.sym} 30160 -38000 0 0 {name=p29396 lab=_52927_/D }
C {devices/lab_pin.sym} 30280 -38060 0 1 {name=p29397 lab=_52927_/X }
C {sky130_stdcells/and4_4.sym} 30220 -38060 0 0 {name=X_52927_ }
C {devices/lab_pin.sym} 30180 -37910 0 0 {name=p29398 lab=_71761_/A }
C {devices/lab_pin.sym} 30260 -37910 0 1 {name=p29399 lab=_71761_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -37910 0 0 {name=X_71761_ }
C {devices/lab_pin.sym} 30130 -37790 0 0 {name=p29400 lab=_83753_/CLK }
C {devices/lab_pin.sym} 30130 -37770 0 0 {name=p29401 lab=_83747_/D }
C {devices/lab_pin.sym} 30310 -37790 0 1 {name=p29402 lab=_83747_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -37780 0 0 {name=X_83747_ }
C {devices/lab_pin.sym} 30140 -37670 0 0 {name=p29403 lab=_58517_/X }
C {devices/lab_pin.sym} 30140 -37630 0 0 {name=p29404 lab=_59480_/Y }
C {devices/lab_pin.sym} 30140 -37590 0 0 {name=p29405 lab=_59482_/Y }
C {devices/lab_pin.sym} 30300 -37630 0 1 {name=p29406 lab=_84720_/D }
C {sky130_stdcells/a21oi_4.sym} 30220 -37630 0 0 {name=X_59483_ }
C {devices/lab_pin.sym} 30180 -37490 0 0 {name=p29407 lab=_56694_/Y }
C {devices/lab_pin.sym} 30260 -37490 0 1 {name=p29408 lab=_56696_/A }
C {sky130_stdcells/buf_2.sym} 30220 -37490 0 0 {name=X_56695_ }
C {devices/lab_pin.sym} 30130 -37370 0 0 {name=p29409 lab=_81994_/CLK }
C {devices/lab_pin.sym} 30130 -37350 0 0 {name=p29410 lab=_80959_/D }
C {devices/lab_pin.sym} 30310 -37370 0 1 {name=p29411 lab=_80959_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -37360 0 0 {name=X_80959_ }
C {devices/lab_pin.sym} 30160 -37240 0 0 {name=p29412 lab=_73386_/A }
C {devices/lab_pin.sym} 30160 -37200 0 0 {name=p29413 lab=_86500_/Q }
C {devices/lab_pin.sym} 30280 -37220 0 1 {name=p29414 lab=_73500_/X }
C {sky130_stdcells/and2_4.sym} 30220 -37220 0 0 {name=X_73500_ }
C {devices/lab_pin.sym} 30180 -37090 0 0 {name=p29415 lab=_70712_/A }
C {devices/lab_pin.sym} 30260 -37090 0 1 {name=p29416 lab=_70848_/A }
C {sky130_stdcells/buf_2.sym} 30220 -37090 0 0 {name=X_70712_ }
C {devices/lab_pin.sym} 30160 -36980 0 0 {name=p29417 lab=_58434_/A }
C {devices/lab_pin.sym} 30160 -36940 0 0 {name=p29418 lab=_58426_/X }
C {devices/lab_pin.sym} 30280 -36960 0 1 {name=p29419 lab=_58434_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -36960 0 0 {name=X_58434_ }
C {devices/lab_pin.sym} 30180 -36830 0 0 {name=p29420 lab=_43660_/A }
C {devices/lab_pin.sym} 30260 -36830 0 1 {name=p29421 lab=_68959_/B }
C {sky130_stdcells/inv_2.sym} 30220 -36830 0 0 {name=X_43660_ }
C {devices/lab_pin.sym} 30180 -36710 0 0 {name=p29422 lab=_55646_/A }
C {devices/lab_pin.sym} 30260 -36710 0 1 {name=p29423 lab=_55646_/X }
C {sky130_stdcells/buf_2.sym} 30220 -36710 0 0 {name=X_55646_ }
C {devices/lab_pin.sym} 30160 -36600 0 0 {name=p29424 lab=_74490_/A }
C {devices/lab_pin.sym} 30160 -36560 0 0 {name=p29425 lab=_48627_/A }
C {devices/lab_pin.sym} 30280 -36580 0 1 {name=p29426 lab=_74480_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -36580 0 0 {name=X_74480_ }
C {devices/lab_pin.sym} 30130 -36450 0 0 {name=p29427 lab=_83310_/CLK }
C {devices/lab_pin.sym} 30130 -36430 0 0 {name=p29428 lab=_86466_/D }
C {devices/lab_pin.sym} 30310 -36450 0 1 {name=p29429 lab=_86466_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -36440 0 0 {name=X_86466_ }
C {devices/lab_pin.sym} 30160 -36320 0 0 {name=p29430 lab=_82861_/Q }
C {devices/lab_pin.sym} 30160 -36280 0 0 {name=p29431 lab=_40883_/B }
C {devices/lab_pin.sym} 30280 -36300 0 1 {name=p29432 lab=_40872_/X }
C {sky130_stdcells/or2_4.sym} 30220 -36300 0 0 {name=X_40872_ }
C {devices/lab_pin.sym} 30140 -36190 0 0 {name=p29433 lab=_52856_/Y }
C {devices/lab_pin.sym} 30140 -36150 0 0 {name=p29434 lab=_52839_/X }
C {devices/lab_pin.sym} 30140 -36110 0 0 {name=p29435 lab=_52857_/X }
C {devices/lab_pin.sym} 30300 -36150 0 1 {name=p29436 lab=_52858_/Y }
C {sky130_stdcells/a21oi_4.sym} 30220 -36150 0 0 {name=X_52858_ }
C {devices/lab_pin.sym} 30180 -36010 0 0 {name=p29437 lab=_71319_/B }
C {devices/lab_pin.sym} 30260 -36010 0 1 {name=p29438 lab=_71874_/D }
C {sky130_stdcells/buf_2.sym} 30220 -36010 0 0 {name=X_71692_ }
C {devices/lab_pin.sym} 30130 -35890 0 0 {name=p29439 lab=_86104_/CLK }
C {devices/lab_pin.sym} 30130 -35870 0 0 {name=p29440 lab=_70870_/Y }
C {devices/lab_pin.sym} 30310 -35890 0 1 {name=p29441 lab=_46721_/A }
C {sky130_stdcells/dfxtp_4.sym} 30220 -35880 0 0 {name=X_83678_ }
C {devices/lab_pin.sym} 30130 -35750 0 0 {name=p29442 lab=_87436_/CLK }
C {devices/lab_pin.sym} 30130 -35730 0 0 {name=p29443 lab=_88205_/D }
C {devices/lab_pin.sym} 30310 -35750 0 1 {name=p29444 lab=_66718_/B }
C {sky130_stdcells/dfxtp_4.sym} 30220 -35740 0 0 {name=X_88205_ }
C {devices/lab_pin.sym} 30180 -35610 0 0 {name=p29445 lab=_73415_/A }
C {devices/lab_pin.sym} 30260 -35610 0 1 {name=p29446 lab=_42611_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -35610 0 0 {name=X_42611_ }
C {devices/lab_pin.sym} 30160 -35500 0 0 {name=p29447 lab=_73428_/X }
C {devices/lab_pin.sym} 30160 -35460 0 0 {name=p29448 lab=_73430_/X }
C {devices/lab_pin.sym} 30280 -35480 0 1 {name=p29449 lab=_73432_/B }
C {sky130_stdcells/nand2_4.sym} 30220 -35480 0 0 {name=X_73431_ }
C {devices/lab_pin.sym} 30130 -35350 0 0 {name=p29450 lab=_85735_/CLK }
C {devices/lab_pin.sym} 30130 -35330 0 0 {name=p29451 lab=_54577_/Y }
C {devices/lab_pin.sym} 30310 -35350 0 1 {name=p29452 lab=_85417_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -35340 0 0 {name=X_85417_ }
C {devices/lab_pin.sym} 30180 -35210 0 0 {name=p29453 lab=_51781_/A }
C {devices/lab_pin.sym} 30260 -35210 0 1 {name=p29454 lab=_51810_/C }
C {sky130_stdcells/buf_2.sym} 30220 -35210 0 0 {name=X_51809_ }
C {devices/lab_pin.sym} 30160 -35120 0 0 {name=p29455 lab=_70710_/A }
C {devices/lab_pin.sym} 30160 -35080 0 0 {name=p29456 lab=_70639_/B }
C {devices/lab_pin.sym} 30160 -35040 0 0 {name=p29457 lab=_70642_/X }
C {devices/lab_pin.sym} 30160 -35000 0 0 {name=p29458 lab=_70638_/X }
C {devices/lab_pin.sym} 30280 -35060 0 1 {name=p29459 lab=_70643_/Y }
C {sky130_stdcells/nand4_4.sym} 30220 -35060 0 0 {name=X_70643_ }
C {devices/lab_pin.sym} 30140 -34930 0 0 {name=p29460 lab=_58328_/X }
C {devices/lab_pin.sym} 30140 -34890 0 0 {name=p29461 lab=_83764_/Q }
C {devices/lab_pin.sym} 30140 -34850 0 0 {name=p29462 lab=_58364_/Y }
C {devices/lab_pin.sym} 30300 -34890 0 1 {name=p29463 lab=_58365_/X }
C {sky130_stdcells/o21a_4.sym} 30220 -34890 0 0 {name=X_58365_ }
C {devices/lab_pin.sym} 30130 -34750 0 0 {name=p29464 lab=_82629_/CLK }
C {devices/lab_pin.sym} 30130 -34730 0 0 {name=p29465 lab=_82629_/D }
C {devices/lab_pin.sym} 30310 -34750 0 1 {name=p29466 lab=_82629_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -34740 0 0 {name=X_82629_ }
C {devices/lab_pin.sym} 30180 -34610 0 0 {name=p29467 lab=_43591_/A }
C {devices/lab_pin.sym} 30260 -34610 0 1 {name=p29468 lab=_43605_/A }
C {sky130_stdcells/buf_2.sym} 30220 -34610 0 0 {name=X_43591_ }
C {devices/lab_pin.sym} 30140 -34510 0 0 {name=p29469 lab=_55574_/X }
C {devices/lab_pin.sym} 30140 -34470 0 0 {name=p29470 lab=_55576_/X }
C {devices/lab_pin.sym} 30140 -34430 0 0 {name=p29471 lab=_55517_/X }
C {devices/lab_pin.sym} 30300 -34470 0 1 {name=p29472 lab=_55580_/A }
C {sky130_stdcells/a21o_4.sym} 30220 -34470 0 0 {name=X_55577_ }
C {devices/lab_pin.sym} 30130 -34330 0 0 {name=p29473 lab=_84807_/CLK }
C {devices/lab_pin.sym} 30130 -34310 0 0 {name=p29474 lab=_86397_/D }
C {devices/lab_pin.sym} 30310 -34330 0 1 {name=p29475 lab=_58613_/B }
C {sky130_stdcells/dfxtp_4.sym} 30220 -34320 0 0 {name=X_86397_ }
C {devices/lab_pin.sym} 30180 -34190 0 0 {name=p29476 lab=_52708_/A }
C {devices/lab_pin.sym} 30260 -34190 0 1 {name=p29477 lab=_52789_/X }
C {sky130_stdcells/buf_2.sym} 30220 -34190 0 0 {name=X_52789_ }
C {devices/lab_pin.sym} 30140 -34090 0 0 {name=p29478 lab=_85285_/Q }
C {devices/lab_pin.sym} 30140 -34050 0 0 {name=p29479 lab=_45269_/X }
C {devices/lab_pin.sym} 30140 -34010 0 0 {name=p29480 lab=_45303_/X }
C {devices/lab_pin.sym} 30300 -34050 0 1 {name=p29481 lab=_45330_/X }
C {sky130_stdcells/o21a_4.sym} 30220 -34050 0 0 {name=X_45330_ }
C {devices/lab_pin.sym} 30140 -33940 0 0 {name=p29482 lab=_57280_/X }
C {devices/lab_pin.sym} 30140 -33900 0 0 {name=p29483 lab=_57312_/Y }
C {devices/lab_pin.sym} 30140 -33860 0 0 {name=p29484 lab=_57313_/Y }
C {devices/lab_pin.sym} 30140 -33820 0 0 {name=p29485 lab=_57315_/Y }
C {devices/lab_pin.sym} 30300 -33880 0 1 {name=p29486 lab=_57317_/A }
C {sky130_stdcells/a211o_4.sym} 30220 -33880 0 0 {name=X_57316_ }
C {devices/lab_pin.sym} 30130 -33730 0 0 {name=p29487 lab=_88133_/CLK }
C {devices/lab_pin.sym} 30130 -33710 0 0 {name=p29488 lab=_88136_/D }
C {devices/lab_pin.sym} 30310 -33730 0 1 {name=p29489 lab=_66845_/B }
C {sky130_stdcells/dfxtp_4.sym} 30220 -33720 0 0 {name=X_88136_ }
C {devices/lab_pin.sym} 30160 -33600 0 0 {name=p29490 lab=_76150_/A }
C {devices/lab_pin.sym} 30160 -33560 0 0 {name=p29491 lab=_76150_/B }
C {devices/lab_pin.sym} 30280 -33580 0 1 {name=p29492 lab=_76150_/X }
C {sky130_stdcells/and2_4.sym} 30220 -33580 0 0 {name=X_76150_ }
C {devices/lab_pin.sym} 30180 -33450 0 0 {name=p29493 lab=_42542_/A }
C {devices/lab_pin.sym} 30260 -33450 0 1 {name=p29494 lab=_87828_/D }
C {sky130_stdcells/inv_2.sym} 30220 -33450 0 0 {name=X_42542_ }
C {devices/lab_pin.sym} 30160 -33340 0 0 {name=p29495 lab=_54518_/A }
C {devices/lab_pin.sym} 30160 -33300 0 0 {name=p29496 lab=_53353_/B }
C {devices/lab_pin.sym} 30280 -33320 0 1 {name=p29497 lab=_54528_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -33320 0 0 {name=X_54528_ }
C {devices/lab_pin.sym} 30160 -33200 0 0 {name=p29498 lab=_73362_/A }
C {devices/lab_pin.sym} 30160 -33160 0 0 {name=p29499 lab=_73361_/X }
C {devices/lab_pin.sym} 30280 -33180 0 1 {name=p29500 lab=_73363_/B }
C {sky130_stdcells/nand2_4.sym} 30220 -33180 0 0 {name=X_73362_ }
C {devices/lab_pin.sym} 30130 -33050 0 0 {name=p29501 lab=_85346_/CLK }
C {devices/lab_pin.sym} 30130 -33030 0 0 {name=p29502 lab=_85348_/D }
C {devices/lab_pin.sym} 30310 -33050 0 1 {name=p29503 lab=_85348_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -33040 0 0 {name=X_85348_ }
C {devices/lab_pin.sym} 30140 -32930 0 0 {name=p29504 lab=_70532_/Y }
C {devices/lab_pin.sym} 30140 -32890 0 0 {name=p29505 lab=_83746_/Q }
C {devices/lab_pin.sym} 30140 -32850 0 0 {name=p29506 lab=_70573_/Y }
C {devices/lab_pin.sym} 30300 -32890 0 1 {name=p29507 lab=_83746_/D }
C {sky130_stdcells/a21o_4.sym} 30220 -32890 0 0 {name=X_70574_ }
C {devices/lab_pin.sym} 30160 -32760 0 0 {name=p29508 lab=_58296_/A }
C {devices/lab_pin.sym} 30160 -32720 0 0 {name=p29509 lab=_58248_/B }
C {devices/lab_pin.sym} 30280 -32740 0 1 {name=p29510 lab=_58296_/Y }
C {sky130_stdcells/nor2_4.sym} 30220 -32740 0 0 {name=X_58296_ }
C {devices/lab_pin.sym} 30140 -32630 0 0 {name=p29511 lab=_75096_/A }
C {devices/lab_pin.sym} 30140 -32590 0 0 {name=p29512 lab=_75099_/Y }
C {devices/lab_pin.sym} 30140 -32550 0 0 {name=p29513 lab=_75100_/Y }
C {devices/lab_pin.sym} 30300 -32590 0 1 {name=p29514 lab=_75104_/B }
C {sky130_stdcells/o21ai_4.sym} 30220 -32590 0 0 {name=X_75101_ }
C {devices/lab_pin.sym} 30180 -32450 0 0 {name=p29515 lab=_72313_/A }
C {devices/lab_pin.sym} 30260 -32450 0 1 {name=p29516 lab=_72313_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -32450 0 0 {name=X_72313_ }
C {devices/lab_pin.sym} 30140 -32350 0 0 {name=p29517 lab=_45202_/X }
C {devices/lab_pin.sym} 30140 -32310 0 0 {name=p29518 lab=_61607_/B }
C {devices/lab_pin.sym} 30140 -32270 0 0 {name=p29519 lab=_45219_/X }
C {devices/lab_pin.sym} 30300 -32310 0 1 {name=p29520 lab=_45261_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -32310 0 0 {name=X_45261_ }
C {devices/lab_pin.sym} 30180 -32170 0 0 {name=p29521 lab=_57244_/X }
C {devices/lab_pin.sym} 30260 -32170 0 1 {name=p29522 lab=_57247_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -32170 0 0 {name=X_57247_ }
C {devices/lab_pin.sym} 30160 -32060 0 0 {name=p29523 lab=_76077_/Y }
C {devices/lab_pin.sym} 30160 -32020 0 0 {name=p29524 lab=_76080_/X }
C {devices/lab_pin.sym} 30280 -32040 0 1 {name=p29525 lab=_76081_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -32040 0 0 {name=X_76081_ }
C {devices/lab_pin.sym} 30130 -31910 0 0 {name=p29526 lab=_87553_/CLK }
C {devices/lab_pin.sym} 30130 -31890 0 0 {name=p29527 lab=_42023_/Y }
C {devices/lab_pin.sym} 30310 -31910 0 1 {name=p29528 lab=_73175_/A }
C {sky130_stdcells/dfxtp_4.sym} 30220 -31900 0 0 {name=X_88067_ }
C {devices/lab_pin.sym} 30180 -31770 0 0 {name=p29529 lab=_73699_/A }
C {devices/lab_pin.sym} 30260 -31770 0 1 {name=p29530 lab=_68520_/B }
C {sky130_stdcells/inv_2.sym} 30220 -31770 0 0 {name=X_42473_ }
C {devices/lab_pin.sym} 30180 -31650 0 0 {name=p29531 lab=_54486_/A }
C {devices/lab_pin.sym} 30260 -31650 0 1 {name=p29532 lab=_54478_/A }
C {sky130_stdcells/buf_2.sym} 30220 -31650 0 0 {name=X_54459_ }
C {devices/lab_pin.sym} 30160 -31550 0 0 {name=p29533 lab=_73291_/X }
C {devices/lab_pin.sym} 30160 -31510 0 0 {name=p29534 lab=_73277_/X }
C {devices/lab_pin.sym} 30160 -31470 0 0 {name=p29535 lab=_73281_/Y }
C {devices/lab_pin.sym} 30280 -31510 0 1 {name=p29536 lab=_73293_/Y }
C {sky130_stdcells/nand3_4.sym} 30220 -31510 0 0 {name=X_73293_ }
C {devices/lab_pin.sym} 30130 -31370 0 0 {name=p29537 lab=_85279_/CLK }
C {devices/lab_pin.sym} 30130 -31350 0 0 {name=p29538 lab=_85279_/D }
C {devices/lab_pin.sym} 30310 -31370 0 1 {name=p29539 lab=_56198_/C }
C {sky130_stdcells/dfxtp_4.sym} 30220 -31360 0 0 {name=X_85279_ }
C {devices/lab_pin.sym} 30160 -31260 0 0 {name=p29540 lab=_46981_/A }
C {devices/lab_pin.sym} 30160 -31220 0 0 {name=p29541 lab=_47029_/B }
C {devices/lab_pin.sym} 30160 -31180 0 0 {name=p29542 lab=_47029_/C }
C {devices/lab_pin.sym} 30160 -31140 0 0 {name=p29543 lab=_52797_/D }
C {devices/lab_pin.sym} 30280 -31200 0 1 {name=p29544 lab=_47000_/X }
C {sky130_stdcells/and4_4.sym} 30220 -31200 0 0 {name=X_47000_ }
C {devices/lab_pin.sym} 30180 -31050 0 0 {name=p29545 lab=_44196_/X }
C {devices/lab_pin.sym} 30260 -31050 0 1 {name=p29546 lab=_57019_/A }
C {sky130_stdcells/inv_2.sym} 30220 -31050 0 0 {name=X_44212_ }
C {devices/lab_pin.sym} 30160 -30940 0 0 {name=p29547 lab=_81147_/D }
C {devices/lab_pin.sym} 30160 -30900 0 0 {name=p29548 lab=_75032_/B }
C {devices/lab_pin.sym} 30280 -30920 0 1 {name=p29549 lab=_75032_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -30920 0 0 {name=X_75032_ }
C {devices/lab_pin.sym} 30130 -30790 0 0 {name=p29550 lab=_87026_/CLK }
C {devices/lab_pin.sym} 30130 -30770 0 0 {name=p29551 lab=_44647_/Y }
C {devices/lab_pin.sym} 30310 -30790 0 1 {name=p29552 lab=_87018_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -30780 0 0 {name=X_87018_ }
C {devices/lab_pin.sym} 30180 -30650 0 0 {name=p29553 lab=_41423_/X }
C {devices/lab_pin.sym} 30260 -30650 0 1 {name=p29554 lab=_41424_/X }
C {sky130_stdcells/buf_2.sym} 30220 -30650 0 0 {name=X_41424_ }
C {devices/lab_pin.sym} 30140 -30550 0 0 {name=p29555 lab=_72239_/Y }
C {devices/lab_pin.sym} 30140 -30510 0 0 {name=p29556 lab=_72243_/Y }
C {devices/lab_pin.sym} 30140 -30470 0 0 {name=p29557 lab=_72185_/X }
C {devices/lab_pin.sym} 30300 -30510 0 1 {name=p29558 lab=_72244_/X }
C {sky130_stdcells/a21o_4.sym} 30220 -30510 0 0 {name=X_72244_ }
C {devices/lab_pin.sym} 30140 -30390 0 0 {name=p29559 lab=_45188_/Y }
C {devices/lab_pin.sym} 30140 -30350 0 0 {name=p29560 lab=_45191_/Y }
C {devices/lab_pin.sym} 30140 -30310 0 0 {name=p29561 lab=_45137_/X }
C {devices/lab_pin.sym} 30300 -30350 0 1 {name=p29562 lab=_45192_/X }
C {sky130_stdcells/a21o_4.sym} 30220 -30350 0 0 {name=X_45192_ }
C {devices/lab_pin.sym} 30140 -30230 0 0 {name=p29563 lab=_56801_/X }
C {devices/lab_pin.sym} 30140 -30190 0 0 {name=p29564 lab=_57141_/X }
C {devices/lab_pin.sym} 30140 -30150 0 0 {name=p29565 lab=_57177_/Y }
C {devices/lab_pin.sym} 30300 -30190 0 1 {name=p29566 lab=_57178_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -30190 0 0 {name=X_57178_ }
C {devices/lab_pin.sym} 30160 -30080 0 0 {name=p29567 lab=_44139_/X }
C {devices/lab_pin.sym} 30160 -30040 0 0 {name=p29568 lab=_44141_/X }
C {devices/lab_pin.sym} 30160 -30000 0 0 {name=p29569 lab=_44025_/X }
C {devices/lab_pin.sym} 30160 -29960 0 0 {name=p29570 lab=_44142_/X }
C {devices/lab_pin.sym} 30280 -30020 0 1 {name=p29571 lab=_44143_/Y }
C {sky130_stdcells/nand4_4.sym} 30220 -30020 0 0 {name=X_44143_ }
C {devices/lab_pin.sym} 30160 -29880 0 0 {name=p29572 lab=_55801_/C }
C {devices/lab_pin.sym} 30160 -29840 0 0 {name=p29573 lab=_56128_/Y }
C {devices/lab_pin.sym} 30280 -29860 0 1 {name=p29574 lab=_56130_/A }
C {sky130_stdcells/xor2_4.sym} 30220 -29860 0 0 {name=X_56129_ }
C {devices/lab_pin.sym} 30160 -29740 0 0 {name=p29575 lab=_79840_/A }
C {devices/lab_pin.sym} 30160 -29700 0 0 {name=p29576 lab=_79827_/Y }
C {devices/lab_pin.sym} 30280 -29720 0 1 {name=p29577 lab=_79840_/X }
C {sky130_stdcells/or2_4.sym} 30220 -29720 0 0 {name=X_79840_ }
C {devices/lab_pin.sym} 30140 -29610 0 0 {name=p29578 lab=_41261_/X }
C {devices/lab_pin.sym} 30140 -29570 0 0 {name=p29579 lab=_41699_/B }
C {devices/lab_pin.sym} 30140 -29530 0 0 {name=p29580 lab=_41354_/X }
C {devices/lab_pin.sym} 30300 -29570 0 1 {name=p29581 lab=_41355_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -29570 0 0 {name=X_41355_ }
C {devices/lab_pin.sym} 30160 -29440 0 0 {name=p29582 lab=_86621_/Q }
C {devices/lab_pin.sym} 30160 -29400 0 0 {name=p29583 lab=_72162_/B }
C {devices/lab_pin.sym} 30280 -29420 0 1 {name=p29584 lab=_72175_/Y }
C {sky130_stdcells/nor2_4.sym} 30220 -29420 0 0 {name=X_72175_ }
C {devices/lab_pin.sym} 30140 -29310 0 0 {name=p29585 lab=_50188_/B }
C {devices/lab_pin.sym} 30140 -29270 0 0 {name=p29586 lab=_71117_/X }
C {devices/lab_pin.sym} 30140 -29230 0 0 {name=p29587 lab=_71125_/Y }
C {devices/lab_pin.sym} 30300 -29270 0 1 {name=p29588 lab=_71126_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -29270 0 0 {name=X_71126_ }
C {devices/lab_pin.sym} 30140 -29150 0 0 {name=p29589 lab=_48945_/Y }
C {devices/lab_pin.sym} 30140 -29110 0 0 {name=p29590 lab=_48935_/X }
C {devices/lab_pin.sym} 30140 -29070 0 0 {name=p29591 lab=_48950_/X }
C {devices/lab_pin.sym} 30300 -29110 0 1 {name=p29592 lab=_86459_/D }
C {sky130_stdcells/a21oi_4.sym} 30220 -29110 0 0 {name=X_48951_ }
C {devices/lab_pin.sym} 30180 -28970 0 0 {name=p29593 lab=_55129_/A }
C {devices/lab_pin.sym} 30260 -28970 0 1 {name=p29594 lab=_55741_/A }
C {sky130_stdcells/buf_2.sym} 30220 -28970 0 0 {name=X_44074_ }
C {devices/lab_pin.sym} 30160 -28860 0 0 {name=p29595 lab=_79766_/X }
C {devices/lab_pin.sym} 30160 -28820 0 0 {name=p29596 lab=_79770_/Y }
C {devices/lab_pin.sym} 30280 -28840 0 1 {name=p29597 lab=_79771_/X }
C {sky130_stdcells/xor2_4.sym} 30220 -28840 0 0 {name=X_79771_ }
C {devices/lab_pin.sym} 30160 -28720 0 0 {name=p29598 lab=_41286_/A }
C {devices/lab_pin.sym} 30160 -28680 0 0 {name=p29599 lab=_41280_/B }
C {devices/lab_pin.sym} 30280 -28700 0 1 {name=p29600 lab=_41286_/X }
C {sky130_stdcells/or2_4.sym} 30220 -28700 0 0 {name=X_41286_ }
C {devices/lab_pin.sym} 30160 -28580 0 0 {name=p29601 lab=_76983_/A }
C {devices/lab_pin.sym} 30160 -28540 0 0 {name=p29602 lab=_62485_/C }
C {devices/lab_pin.sym} 30280 -28560 0 1 {name=p29603 lab=_76983_/X }
C {sky130_stdcells/xor2_4.sym} 30220 -28560 0 0 {name=X_76983_ }
C {devices/lab_pin.sym} 30140 -28450 0 0 {name=p29604 lab=_73711_/B }
C {devices/lab_pin.sym} 30140 -28410 0 0 {name=p29605 lab=_47897_/X }
C {devices/lab_pin.sym} 30140 -28370 0 0 {name=p29606 lab=_47901_/Y }
C {devices/lab_pin.sym} 30300 -28410 0 1 {name=p29607 lab=_47902_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -28410 0 0 {name=X_47902_ }
C {devices/lab_pin.sym} 30180 -28270 0 0 {name=p29608 lab=_43127_/A }
C {devices/lab_pin.sym} 30260 -28270 0 1 {name=p29609 lab=_43025_/X }
C {sky130_stdcells/buf_2.sym} 30220 -28270 0 0 {name=X_43025_ }
C {devices/lab_pin.sym} 30180 -28150 0 0 {name=p29610 lab=_78722_/A }
C {devices/lab_pin.sym} 30260 -28150 0 1 {name=p29611 lab=_78722_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -28150 0 0 {name=X_78722_ }
C {devices/lab_pin.sym} 30180 -28030 0 0 {name=p29612 lab=_71071_/A }
C {devices/lab_pin.sym} 30260 -28030 0 1 {name=p29613 lab=_71058_/A }
C {sky130_stdcells/buf_2.sym} 30220 -28030 0 0 {name=X_71057_ }
C {devices/lab_pin.sym} 30160 -27920 0 0 {name=p29614 lab=_81699_/D }
C {devices/lab_pin.sym} 30160 -27880 0 0 {name=p29615 lab=_75927_/B }
C {devices/lab_pin.sym} 30280 -27900 0 1 {name=p29616 lab=_75934_/Y }
C {sky130_stdcells/nor2_4.sym} 30220 -27900 0 0 {name=X_75934_ }
C {devices/lab_pin.sym} 30160 -27780 0 0 {name=p29617 lab=_48882_/A }
C {devices/lab_pin.sym} 30160 -27740 0 0 {name=p29618 lab=_48699_/B }
C {devices/lab_pin.sym} 30280 -27760 0 1 {name=p29619 lab=_48882_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -27760 0 0 {name=X_48882_ }
C {devices/lab_pin.sym} 30140 -27650 0 0 {name=p29620 lab=_83874_/Q }
C {devices/lab_pin.sym} 30140 -27610 0 0 {name=p29621 lab=_69988_/X }
C {devices/lab_pin.sym} 30140 -27570 0 0 {name=p29622 lab=_70007_/X }
C {devices/lab_pin.sym} 30300 -27610 0 1 {name=p29623 lab=_70008_/X }
C {sky130_stdcells/a21bo_4.sym} 30220 -27610 0 0 {name=X_70008_ }
C {devices/lab_pin.sym} 30180 -27470 0 0 {name=p29624 lab=_47832_/X }
C {devices/lab_pin.sym} 30260 -27470 0 1 {name=p29625 lab=_47841_/A }
C {sky130_stdcells/buf_2.sym} 30220 -27470 0 0 {name=X_47833_ }
C {devices/lab_pin.sym} 30180 -27350 0 0 {name=p29626 lab=_58094_/A }
C {devices/lab_pin.sym} 30260 -27350 0 1 {name=p29627 lab=_72381_/A }
C {sky130_stdcells/buf_2.sym} 30220 -27350 0 0 {name=X_59819_ }
C {devices/lab_pin.sym} 30140 -27250 0 0 {name=p29628 lab=_78654_/A }
C {devices/lab_pin.sym} 30140 -27210 0 0 {name=p29629 lab=_78654_/C }
C {devices/lab_pin.sym} 30140 -27170 0 0 {name=p29630 lab=_78652_/Y }
C {devices/lab_pin.sym} 30300 -27210 0 1 {name=p29631 lab=_78653_/X }
C {sky130_stdcells/a21o_4.sym} 30220 -27210 0 0 {name=X_78653_ }
C {devices/lab_pin.sym} 30180 -27070 0 0 {name=p29632 lab=_75865_/A }
C {devices/lab_pin.sym} 30260 -27070 0 1 {name=p29633 lab=_75865_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -27070 0 0 {name=X_75865_ }
C {devices/lab_pin.sym} 30140 -26970 0 0 {name=p29634 lab=_77600_/Y }
C {devices/lab_pin.sym} 30140 -26930 0 0 {name=p29635 lab=_77603_/C }
C {devices/lab_pin.sym} 30140 -26890 0 0 {name=p29636 lab=_77603_/A }
C {devices/lab_pin.sym} 30300 -26930 0 1 {name=p29637 lab=_77604_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -26930 0 0 {name=X_77604_ }
C {devices/lab_pin.sym} 30140 -26830 0 0 {name=p29638 lab=_57683_/X }
C {devices/lab_pin.sym} 30140 -26790 0 0 {name=p29639 lab=_62808_/X }
C {devices/lab_pin.sym} 30140 -26750 0 0 {name=p29640 lab=_62827_/X }
C {devices/lab_pin.sym} 30140 -26710 0 0 {name=p29641 lab=_62818_/X }
C {devices/lab_pin.sym} 30140 -26680 0 0 {name=p29642 lab=_62829_/X }
C {devices/lab_pin.sym} 30300 -26750 0 1 {name=p29643 lab=_62830_/Y }
C {sky130_stdcells/a41oi_4.sym} 30220 -26750 0 0 {name=X_62830_ }
C {devices/lab_pin.sym} 30160 -26600 0 0 {name=p29644 lab=_59426_/X }
C {devices/lab_pin.sym} 30160 -26560 0 0 {name=p29645 lab=_46107_/A }
C {devices/lab_pin.sym} 30280 -26580 0 1 {name=p29646 lab=_74817_/A }
C {sky130_stdcells/nand2_4.sym} 30220 -26580 0 0 {name=X_74816_ }
C {devices/lab_pin.sym} 30160 -26460 0 0 {name=p29647 lab=_47799_/A }
C {devices/lab_pin.sym} 30160 -26420 0 0 {name=p29648 lab=_53232_/B }
C {devices/lab_pin.sym} 30280 -26440 0 1 {name=p29649 lab=_47764_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -26440 0 0 {name=X_47764_ }
C {devices/lab_pin.sym} 30180 -26310 0 0 {name=p29650 lab=_82805_/Q }
C {devices/lab_pin.sym} 30260 -26310 0 1 {name=p29651 lab=_78584_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -26310 0 0 {name=X_78584_ }
C {devices/lab_pin.sym} 30180 -26190 0 0 {name=p29652 lab=_63049_/B }
C {devices/lab_pin.sym} 30260 -26190 0 1 {name=p29653 lab=_61375_/B }
C {sky130_stdcells/buf_2.sym} 30220 -26190 0 0 {name=X_44976_ }
C {devices/lab_pin.sym} 30160 -26080 0 0 {name=p29654 lab=_81099_/Q }
C {devices/lab_pin.sym} 30160 -26040 0 0 {name=p29655 lab=_75796_/B }
C {devices/lab_pin.sym} 30280 -26060 0 1 {name=p29656 lab=_75796_/Y }
C {sky130_stdcells/xnor2_4.sym} 30220 -26060 0 0 {name=X_75796_ }
C {devices/lab_pin.sym} 30140 -25950 0 0 {name=p29657 lab=_58896_/B }
C {devices/lab_pin.sym} 30140 -25910 0 0 {name=p29658 lab=_49496_/X }
C {devices/lab_pin.sym} 30140 -25870 0 0 {name=p29659 lab=_49502_/Y }
C {devices/lab_pin.sym} 30300 -25910 0 1 {name=p29660 lab=_49503_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -25910 0 0 {name=X_49503_ }
C {devices/lab_pin.sym} 30180 -25770 0 0 {name=p29661 lab=_46715_/A }
C {devices/lab_pin.sym} 30260 -25770 0 1 {name=p29662 lab=_54325_/D }
C {sky130_stdcells/inv_2.sym} 30220 -25770 0 0 {name=X_46715_ }
C {devices/lab_pin.sym} 30180 -25650 0 0 {name=p29663 lab=_77538_/B }
C {devices/lab_pin.sym} 30260 -25650 0 1 {name=p29664 lab=_77535_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -25650 0 0 {name=X_77535_ }
C {devices/lab_pin.sym} 30180 -25530 0 0 {name=p29665 lab=_43602_/X }
C {devices/lab_pin.sym} 30260 -25530 0 1 {name=p29666 lab=_43927_/X }
C {sky130_stdcells/buf_2.sym} 30220 -25530 0 0 {name=X_43927_ }
C {devices/lab_pin.sym} 30140 -25450 0 0 {name=p29667 lab=_57656_/X }
C {devices/lab_pin.sym} 30140 -25410 0 0 {name=p29668 lab=_62749_/X }
C {devices/lab_pin.sym} 30140 -25370 0 0 {name=p29669 lab=_62708_/X }
C {devices/lab_pin.sym} 30140 -25330 0 0 {name=p29670 lab=_62759_/X }
C {devices/lab_pin.sym} 30140 -25300 0 0 {name=p29671 lab=_62760_/X }
C {devices/lab_pin.sym} 30300 -25370 0 1 {name=p29672 lab=_62761_/Y }
C {sky130_stdcells/a41oi_4.sym} 30220 -25370 0 0 {name=X_62761_ }
C {devices/lab_pin.sym} 30180 -25210 0 0 {name=p29673 lab=_70735_/X }
C {devices/lab_pin.sym} 30260 -25210 0 1 {name=p29674 lab=_74769_/D }
C {sky130_stdcells/buf_2.sym} 30220 -25210 0 0 {name=X_74747_ }
C {devices/lab_pin.sym} 30180 -25090 0 0 {name=p29675 lab=_54885_/B }
C {devices/lab_pin.sym} 30260 -25090 0 1 {name=p29676 lab=_53193_/B }
C {sky130_stdcells/buf_2.sym} 30220 -25090 0 0 {name=X_47695_ }
C {devices/lab_pin.sym} 30180 -24970 0 0 {name=p29677 lab=_71959_/A }
C {devices/lab_pin.sym} 30260 -24970 0 1 {name=p29678 lab=_71959_/X }
C {sky130_stdcells/buf_2.sym} 30220 -24970 0 0 {name=X_71959_ }
C {devices/lab_pin.sym} 30140 -24870 0 0 {name=p29679 lab=_84240_/Q }
C {devices/lab_pin.sym} 30140 -24830 0 0 {name=p29680 lab=_64429_/X }
C {devices/lab_pin.sym} 30140 -24790 0 0 {name=p29681 lab=_64499_/X }
C {devices/lab_pin.sym} 30300 -24830 0 1 {name=p29682 lab=_84240_/D }
C {sky130_stdcells/a21o_4.sym} 30220 -24830 0 0 {name=X_64500_ }
C {devices/lab_pin.sym} 30180 -24690 0 0 {name=p29683 lab=_49434_/A }
C {devices/lab_pin.sym} 30260 -24690 0 1 {name=p29684 lab=_49434_/X }
C {sky130_stdcells/buf_2.sym} 30220 -24690 0 0 {name=X_49434_ }
C {devices/lab_pin.sym} 30180 -24570 0 0 {name=p29685 lab=_61711_/X }
C {devices/lab_pin.sym} 30260 -24570 0 1 {name=p29686 lab=_61712_/X }
C {sky130_stdcells/buf_2.sym} 30220 -24570 0 0 {name=X_61712_ }
C {devices/lab_pin.sym} 30180 -24450 0 0 {name=p29687 lab=_54286_/D }
C {devices/lab_pin.sym} 30260 -24450 0 1 {name=p29688 lab=_51768_/D }
C {sky130_stdcells/buf_2.sym} 30220 -24450 0 0 {name=X_46646_ }
C {devices/lab_pin.sym} 30140 -24350 0 0 {name=p29689 lab=_65399_/X }
C {devices/lab_pin.sym} 30140 -24310 0 0 {name=p29690 lab=_65477_/Y }
C {devices/lab_pin.sym} 30140 -24270 0 0 {name=p29691 lab=_65479_/Y }
C {devices/lab_pin.sym} 30300 -24310 0 1 {name=p29692 lab=_65480_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -24310 0 0 {name=X_65480_ }
C {devices/lab_pin.sym} 30160 -24180 0 0 {name=p29693 lab=_81938_/Q }
C {devices/lab_pin.sym} 30160 -24140 0 0 {name=p29694 lab=_82194_/D }
C {devices/lab_pin.sym} 30280 -24160 0 1 {name=p29695 lab=_81906_/D }
C {sky130_stdcells/xor2_4.sym} 30220 -24160 0 0 {name=X_77466_ }
C {devices/lab_pin.sym} 30180 -24030 0 0 {name=p29696 lab=_43858_/A }
C {devices/lab_pin.sym} 30260 -24030 0 1 {name=p29697 lab=_43858_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -24030 0 0 {name=X_43858_ }
C {devices/lab_pin.sym} 30180 -23910 0 0 {name=p29698 lab=_60273_/A }
C {devices/lab_pin.sym} 30260 -23910 0 1 {name=p29699 lab=_62727_/B }
C {sky130_stdcells/buf_2.sym} 30220 -23910 0 0 {name=X_62692_ }
C {devices/lab_pin.sym} 30180 -23790 0 0 {name=p29700 lab=_74678_/A }
C {devices/lab_pin.sym} 30260 -23790 0 1 {name=p29701 lab=_74678_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -23790 0 0 {name=X_74678_ }
C {devices/lab_pin.sym} 30160 -23690 0 0 {name=p29702 lab=_79195_/Y }
C {devices/lab_pin.sym} 30160 -23650 0 0 {name=p29703 lab=_79205_/B }
C {devices/lab_pin.sym} 30160 -23610 0 0 {name=p29704 lab=_79205_/C }
C {devices/lab_pin.sym} 30280 -23650 0 1 {name=p29705 lab=_79205_/Y }
C {sky130_stdcells/nand3_4.sym} 30220 -23650 0 0 {name=X_79205_ }
C {devices/lab_pin.sym} 30160 -23520 0 0 {name=p29706 lab=_58446_/A }
C {devices/lab_pin.sym} 30160 -23480 0 0 {name=p29707 lab=_64511_/B }
C {devices/lab_pin.sym} 30280 -23500 0 1 {name=p29708 lab=_64431_/Y }
C {sky130_stdcells/nor2_4.sym} 30220 -23500 0 0 {name=X_64431_ }
C {devices/lab_pin.sym} 30160 -23390 0 0 {name=p29709 lab=_76412_/X }
C {devices/lab_pin.sym} 30160 -23350 0 0 {name=p29710 lab=_76415_/Y }
C {devices/lab_pin.sym} 30160 -23310 0 0 {name=p29711 lab=_76417_/C }
C {devices/lab_pin.sym} 30280 -23350 0 1 {name=p29712 lab=_76417_/Y }
C {sky130_stdcells/nand3_4.sym} 30220 -23350 0 0 {name=X_76417_ }
C {devices/lab_pin.sym} 30180 -23210 0 0 {name=p29713 lab=_42808_/Y }
C {devices/lab_pin.sym} 30260 -23210 0 1 {name=p29714 lab=_87708_/D }
C {sky130_stdcells/inv_2.sym} 30220 -23210 0 0 {name=X_42809_ }
C {devices/lab_pin.sym} 30140 -23130 0 0 {name=p29715 lab=_61636_/Y }
C {devices/lab_pin.sym} 30140 -23090 0 0 {name=p29716 lab=_61638_/Y }
C {devices/lab_pin.sym} 30140 -23050 0 0 {name=p29717 lab=_61583_/Y }
C {devices/lab_pin.sym} 30140 -23010 0 0 {name=p29718 lab=_61640_/Y }
C {devices/lab_pin.sym} 30140 -22980 0 0 {name=p29719 lab=_61642_/Y }
C {devices/lab_pin.sym} 30300 -23050 0 1 {name=p29720 lab=_61643_/X }
C {sky130_stdcells/a41o_4.sym} 30220 -23050 0 0 {name=X_61643_ }
C {devices/lab_pin.sym} 30140 -22910 0 0 {name=p29721 lab=_49363_/Y }
C {devices/lab_pin.sym} 30140 -22870 0 0 {name=p29722 lab=_49316_/X }
C {devices/lab_pin.sym} 30140 -22830 0 0 {name=p29723 lab=_49364_/X }
C {devices/lab_pin.sym} 30300 -22870 0 1 {name=p29724 lab=_49365_/Y }
C {sky130_stdcells/a21oi_4.sym} 30220 -22870 0 0 {name=X_49365_ }
C {devices/lab_pin.sym} 30160 -22740 0 0 {name=p29725 lab=_87344_/Q }
C {devices/lab_pin.sym} 30160 -22700 0 0 {name=p29726 lab=_73701_/B }
C {devices/lab_pin.sym} 30280 -22720 0 1 {name=p29727 lab=_73629_/Y }
C {sky130_stdcells/nor2_4.sym} 30220 -22720 0 0 {name=X_73629_ }
C {devices/lab_pin.sym} 30180 -22590 0 0 {name=p29728 lab=_46401_/A }
C {devices/lab_pin.sym} 30260 -22590 0 1 {name=p29729 lab=_57497_/A }
C {sky130_stdcells/buf_2.sym} 30220 -22590 0 0 {name=X_46577_ }
C {devices/lab_pin.sym} 30180 -22470 0 0 {name=p29730 lab=_77396_/Y }
C {devices/lab_pin.sym} 30260 -22470 0 1 {name=p29731 lab=_77397_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -22470 0 0 {name=X_77397_ }
C {devices/lab_pin.sym} 30140 -22380 0 0 {name=p29732 lab=_41032_/X }
C {devices/lab_pin.sym} 30140 -22340 0 0 {name=p29733 lab=_43770_/X }
C {devices/lab_pin.sym} 30140 -22300 0 0 {name=p29734 lab=_69372_/B }
C {devices/lab_pin.sym} 30140 -22260 0 0 {name=p29735 lab=_43772_/X }
C {devices/lab_pin.sym} 30300 -22320 0 1 {name=p29736 lab=_43789_/X }
C {sky130_stdcells/a2bb2o_4.sym} 30220 -22320 0 0 {name=X_43789_ }
C {devices/lab_pin.sym} 30140 -22190 0 0 {name=p29737 lab=_86536_/Q }
C {devices/lab_pin.sym} 30140 -22150 0 0 {name=p29738 lab=_48263_/X }
C {devices/lab_pin.sym} 30140 -22110 0 0 {name=p29739 lab=_48315_/Y }
C {devices/lab_pin.sym} 30300 -22150 0 1 {name=p29740 lab=_48316_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -22150 0 0 {name=X_48316_ }
C {devices/lab_pin.sym} 30140 -22040 0 0 {name=p29741 lab=_88379_/Q }
C {devices/lab_pin.sym} 30140 -22000 0 0 {name=p29742 lab=_67074_/X }
C {devices/lab_pin.sym} 30140 -21960 0 0 {name=p29743 lab=_67075_/X }
C {devices/lab_pin.sym} 30140 -21920 0 0 {name=p29744 lab=_67149_/X }
C {devices/lab_pin.sym} 30300 -21980 0 1 {name=p29745 lab=_67150_/X }
C {sky130_stdcells/a211o_4.sym} 30220 -21980 0 0 {name=X_67150_ }
C {devices/lab_pin.sym} 30160 -21840 0 0 {name=p29746 lab=_79136_/A }
C {devices/lab_pin.sym} 30160 -21800 0 0 {name=p29747 lab=_79136_/B }
C {devices/lab_pin.sym} 30280 -21820 0 1 {name=p29748 lab=_79136_/X }
C {sky130_stdcells/xor2_4.sym} 30220 -21820 0 0 {name=X_79136_ }
C {devices/lab_pin.sym} 30140 -21710 0 0 {name=p29749 lab=_45525_/X }
C {devices/lab_pin.sym} 30140 -21670 0 0 {name=p29750 lab=_45527_/Y }
C {devices/lab_pin.sym} 30140 -21630 0 0 {name=p29751 lab=_45348_/X }
C {devices/lab_pin.sym} 30300 -21670 0 1 {name=p29752 lab=_45528_/Y }
C {sky130_stdcells/a21oi_4.sym} 30220 -21670 0 0 {name=X_45528_ }
C {devices/lab_pin.sym} 30180 -21530 0 0 {name=p29753 lab=_64303_/A }
C {devices/lab_pin.sym} 30260 -21530 0 1 {name=p29754 lab=_64363_/B }
C {sky130_stdcells/buf_2.sym} 30220 -21530 0 0 {name=X_64362_ }
C {devices/lab_pin.sym} 30160 -21430 0 0 {name=p29755 lab=_76344_/Y }
C {devices/lab_pin.sym} 30160 -21390 0 0 {name=p29756 lab=_76348_/B }
C {devices/lab_pin.sym} 30160 -21350 0 0 {name=p29757 lab=_76348_/C }
C {devices/lab_pin.sym} 30280 -21390 0 1 {name=p29758 lab=_76348_/X }
C {sky130_stdcells/or3_4.sym} 30220 -21390 0 0 {name=X_76348_ }
C {devices/lab_pin.sym} 30140 -21270 0 0 {name=p29759 lab=_86415_/Q }
C {devices/lab_pin.sym} 30140 -21230 0 0 {name=p29760 lab=_49285_/X }
C {devices/lab_pin.sym} 30140 -21190 0 0 {name=p29761 lab=_49295_/Y }
C {devices/lab_pin.sym} 30300 -21230 0 1 {name=p29762 lab=_49296_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -21230 0 0 {name=X_49296_ }
C {devices/lab_pin.sym} 30180 -21090 0 0 {name=p29763 lab=_61574_/A }
C {devices/lab_pin.sym} 30260 -21090 0 1 {name=p29764 lab=_61574_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -21090 0 0 {name=X_61574_ }
C {devices/lab_pin.sym} 30160 -20980 0 0 {name=p29765 lab=_66226_/A }
C {devices/lab_pin.sym} 30160 -20940 0 0 {name=p29766 lab=_66101_/B }
C {devices/lab_pin.sym} 30280 -20960 0 1 {name=p29767 lab=_66101_/X }
C {sky130_stdcells/and2_4.sym} 30220 -20960 0 0 {name=X_66101_ }
C {devices/lab_pin.sym} 30160 -20860 0 0 {name=p29768 lab=_63289_/X }
C {devices/lab_pin.sym} 30160 -20820 0 0 {name=p29769 lab=_84886_/Q }
C {devices/lab_pin.sym} 30160 -20780 0 0 {name=p29770 lab=_63341_/C }
C {devices/lab_pin.sym} 30160 -20740 0 0 {name=p29771 lab=_63332_/D }
C {devices/lab_pin.sym} 30280 -20800 0 1 {name=p29772 lab=_63313_/X }
C {sky130_stdcells/and4_4.sym} 30220 -20800 0 0 {name=X_63313_ }
C {devices/lab_pin.sym} 30160 -20660 0 0 {name=p29773 lab=_48229_/A }
C {devices/lab_pin.sym} 30160 -20620 0 0 {name=p29774 lab=_53520_/B }
C {devices/lab_pin.sym} 30280 -20640 0 1 {name=p29775 lab=_48247_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -20640 0 0 {name=X_48247_ }
C {devices/lab_pin.sym} 30180 -20510 0 0 {name=p29776 lab=_60525_/A }
C {devices/lab_pin.sym} 30260 -20510 0 1 {name=p29777 lab=_60526_/B }
C {sky130_stdcells/buf_2.sym} 30220 -20510 0 0 {name=X_60525_ }
C {devices/lab_pin.sym} 30180 -20390 0 0 {name=p29778 lab=_66553_/X }
C {devices/lab_pin.sym} 30260 -20390 0 1 {name=p29779 lab=_67082_/A }
C {sky130_stdcells/buf_2.sym} 30220 -20390 0 0 {name=X_67081_ }
C {devices/lab_pin.sym} 30140 -20290 0 0 {name=p29780 lab=_79049_/A }
C {devices/lab_pin.sym} 30140 -20250 0 0 {name=p29781 lab=_79054_/A }
C {devices/lab_pin.sym} 30140 -20210 0 0 {name=p29782 lab=_79055_/A }
C {devices/lab_pin.sym} 30300 -20250 0 1 {name=p29783 lab=_79067_/Y }
C {sky130_stdcells/a21oi_4.sym} 30220 -20250 0 0 {name=X_79067_ }
C {devices/lab_pin.sym} 30180 -20110 0 0 {name=p29784 lab=_85021_/Q }
C {devices/lab_pin.sym} 30260 -20110 0 1 {name=p29785 lab=_55585_/B }
C {sky130_stdcells/inv_2.sym} 30220 -20110 0 0 {name=X_45459_ }
C {devices/lab_pin.sym} 30160 -20020 0 0 {name=p29786 lab=_64273_/A }
C {devices/lab_pin.sym} 30160 -19980 0 0 {name=p29787 lab=_64273_/B }
C {devices/lab_pin.sym} 30160 -19940 0 0 {name=p29788 lab=_84898_/Q }
C {devices/lab_pin.sym} 30160 -19900 0 0 {name=p29789 lab=_64304_/D }
C {devices/lab_pin.sym} 30280 -19960 0 1 {name=p29790 lab=_64293_/X }
C {sky130_stdcells/and4_4.sym} 30220 -19960 0 0 {name=X_64293_ }
C {devices/lab_pin.sym} 30140 -19830 0 0 {name=p29791 lab=_76260_/X }
C {devices/lab_pin.sym} 30140 -19790 0 0 {name=p29792 lab=_81642_/Q }
C {devices/lab_pin.sym} 30140 -19750 0 0 {name=p29793 lab=_76278_/Y }
C {devices/lab_pin.sym} 30300 -19790 0 1 {name=p29794 lab=_76281_/A }
C {sky130_stdcells/a21boi_4.sym} 30220 -19790 0 0 {name=X_76279_ }
C {devices/lab_pin.sym} 30140 -19670 0 0 {name=p29795 lab=_66020_/X }
C {devices/lab_pin.sym} 30140 -19630 0 0 {name=p29796 lab=_66030_/Y }
C {devices/lab_pin.sym} 30140 -19590 0 0 {name=p29797 lab=_66031_/Y }
C {devices/lab_pin.sym} 30300 -19630 0 1 {name=p29798 lab=_66032_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -19630 0 0 {name=X_66032_ }
C {devices/lab_pin.sym} 30180 -19490 0 0 {name=p29799 lab=clkbuf_9_270_0_CLK/X }
C {devices/lab_pin.sym} 30260 -19490 0 1 {name=p29800 lab=_84105_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 30220 -19490 0 0 {name=Xclkbuf_10_541_0_CLK }
C {devices/lab_pin.sym} 30160 -19380 0 0 {name=p29801 lab=_78018_/A }
C {devices/lab_pin.sym} 30160 -19340 0 0 {name=p29802 lab=_78018_/B }
C {devices/lab_pin.sym} 30280 -19360 0 1 {name=p29803 lab=_78021_/A }
C {sky130_stdcells/or2_4.sym} 30220 -19360 0 0 {name=X_78018_ }
C {devices/lab_pin.sym} 30180 -19230 0 0 {name=p29804 lab=clkbuf_6_33_0_CLK/A }
C {devices/lab_pin.sym} 30260 -19230 0 1 {name=p29805 lab=clkbuf_6_32_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 30220 -19230 0 0 {name=Xclkbuf_6_32_0_CLK }
C {devices/lab_pin.sym} 30160 -19140 0 0 {name=p29806 lab=_63244_/A }
C {devices/lab_pin.sym} 30160 -19100 0 0 {name=p29807 lab=_63316_/B }
C {devices/lab_pin.sym} 30160 -19060 0 0 {name=p29808 lab=_63295_/C }
C {devices/lab_pin.sym} 30160 -19020 0 0 {name=p29809 lab=_63267_/D }
C {devices/lab_pin.sym} 30280 -19080 0 1 {name=p29810 lab=_63244_/X }
C {sky130_stdcells/or4_4.sym} 30220 -19080 0 0 {name=X_63244_ }
C {devices/lab_pin.sym} 30180 -18930 0 0 {name=p29811 lab=_47851_/B }
C {devices/lab_pin.sym} 30260 -18930 0 1 {name=p29812 lab=_48178_/X }
C {sky130_stdcells/buf_2.sym} 30220 -18930 0 0 {name=X_48178_ }
C {devices/lab_pin.sym} 30140 -18840 0 0 {name=p29813 lab=_79155_/A }
C {devices/lab_pin.sym} 30140 -18800 0 0 {name=p29814 lab=_60132_/X }
C {devices/lab_pin.sym} 30140 -18760 0 0 {name=p29815 lab=_60445_/Y }
C {devices/lab_pin.sym} 30140 -18720 0 0 {name=p29816 lab=_60455_/Y }
C {devices/lab_pin.sym} 30300 -18780 0 1 {name=p29817 lab=_60456_/X }
C {sky130_stdcells/a2bb2o_4.sym} 30220 -18780 0 0 {name=X_60456_ }
C {devices/lab_pin.sym} 30180 -18630 0 0 {name=p29818 lab=_46892_/A }
C {devices/lab_pin.sym} 30260 -18630 0 1 {name=p29819 lab=_47130_/A }
C {sky130_stdcells/buf_2.sym} 30220 -18630 0 0 {name=X_47129_ }
C {devices/lab_pin.sym} 30180 -18510 0 0 {name=p29820 lab=_60522_/A }
C {devices/lab_pin.sym} 30260 -18510 0 1 {name=p29821 lab=_63175_/X }
C {sky130_stdcells/buf_2.sym} 30220 -18510 0 0 {name=X_63175_ }
C {devices/lab_pin.sym} 30160 -18410 0 0 {name=p29822 lab=_60387_/A }
C {devices/lab_pin.sym} 30160 -18370 0 0 {name=p29823 lab=_60404_/C }
C {devices/lab_pin.sym} 30160 -18330 0 0 {name=p29824 lab=_60387_/C }
C {devices/lab_pin.sym} 30280 -18370 0 1 {name=p29825 lab=_60387_/X }
C {sky130_stdcells/and3_4.sym} 30220 -18370 0 0 {name=X_60387_ }
C {devices/lab_pin.sym} 30140 -18250 0 0 {name=p29826 lab=_65061_/B }
C {devices/lab_pin.sym} 30140 -18210 0 0 {name=p29827 lab=_50137_/X }
C {devices/lab_pin.sym} 30140 -18170 0 0 {name=p29828 lab=_50139_/Y }
C {devices/lab_pin.sym} 30300 -18210 0 1 {name=p29829 lab=_50140_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -18210 0 0 {name=X_50140_ }
C {devices/lab_pin.sym} 30160 -18100 0 0 {name=p29830 lab=_61730_/X }
C {devices/lab_pin.sym} 30160 -18060 0 0 {name=p29831 lab=_62094_/B }
C {devices/lab_pin.sym} 30160 -18020 0 0 {name=p29832 lab=_59722_/X }
C {devices/lab_pin.sym} 30160 -17980 0 0 {name=p29833 lab=_62126_/D }
C {devices/lab_pin.sym} 30280 -18040 0 1 {name=p29834 lab=_62126_/X }
C {sky130_stdcells/and4_4.sym} 30220 -18040 0 0 {name=X_62126_ }
C {devices/lab_pin.sym} 30180 -17890 0 0 {name=p29835 lab=_68089_/A }
C {devices/lab_pin.sym} 30260 -17890 0 1 {name=p29836 lab=_67983_/X }
C {sky130_stdcells/buf_2.sym} 30220 -17890 0 0 {name=X_67983_ }
C {devices/lab_pin.sym} 30180 -17770 0 0 {name=p29837 lab=_79968_/Y }
C {devices/lab_pin.sym} 30260 -17770 0 1 {name=p29838 lab=_79977_/A }
C {sky130_stdcells/inv_2.sym} 30220 -17770 0 0 {name=X_79969_ }
C {devices/lab_pin.sym} 30180 -17650 0 0 {name=p29839 lab=clkbuf_9_278_0_CLK/X }
C {devices/lab_pin.sym} 30260 -17650 0 1 {name=p29840 lab=_86941_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 30220 -17650 0 0 {name=Xclkbuf_10_556_0_CLK }
C {devices/lab_pin.sym} 30180 -17530 0 0 {name=p29841 lab=clkbuf_6_47_0_CLK/A }
C {devices/lab_pin.sym} 30260 -17530 0 1 {name=p29842 lab=clkbuf_7_95_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 30220 -17530 0 0 {name=Xclkbuf_6_47_0_CLK }
C {devices/lab_pin.sym} 30160 -17420 0 0 {name=p29843 lab=_69766_/A }
C {devices/lab_pin.sym} 30160 -17380 0 0 {name=p29844 lab=_69722_/B }
C {devices/lab_pin.sym} 30280 -17400 0 1 {name=p29845 lab=_69722_/Y }
C {sky130_stdcells/nor2_4.sym} 30220 -17400 0 0 {name=X_69722_ }
C {devices/lab_pin.sym} 30160 -17280 0 0 {name=p29846 lab=_50084_/A }
C {devices/lab_pin.sym} 30160 -17240 0 0 {name=p29847 lab=_48912_/B }
C {devices/lab_pin.sym} 30280 -17260 0 1 {name=p29848 lab=_50071_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -17260 0 0 {name=X_50071_ }
C {devices/lab_pin.sym} 30160 -17140 0 0 {name=p29849 lab=_66931_/X }
C {devices/lab_pin.sym} 30160 -17100 0 0 {name=p29850 lab=_66933_/X }
C {devices/lab_pin.sym} 30280 -17120 0 1 {name=p29851 lab=_66934_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -17120 0 0 {name=X_66934_ }
C {devices/lab_pin.sym} 30160 -17020 0 0 {name=p29852 lab=_59761_/A }
C {devices/lab_pin.sym} 30160 -16980 0 0 {name=p29853 lab=_62094_/B }
C {devices/lab_pin.sym} 30160 -16940 0 0 {name=p29854 lab=_59722_/X }
C {devices/lab_pin.sym} 30160 -16900 0 0 {name=p29855 lab=_62057_/D }
C {devices/lab_pin.sym} 30280 -16960 0 1 {name=p29856 lab=_62057_/X }
C {sky130_stdcells/and4_4.sym} 30220 -16960 0 0 {name=X_62057_ }
C {devices/lab_pin.sym} 30130 -16810 0 0 {name=p29857 lab=_82980_/CLK }
C {devices/lab_pin.sym} 30130 -16790 0 0 {name=p29858 lab=_82980_/D }
C {devices/lab_pin.sym} 30310 -16810 0 1 {name=p29859 lab=_45847_/A }
C {sky130_stdcells/dfxtp_4.sym} 30220 -16800 0 0 {name=X_82980_ }
C {devices/lab_pin.sym} 30180 -16670 0 0 {name=p29860 lab=_61008_/A }
C {devices/lab_pin.sym} 30260 -16670 0 1 {name=p29861 lab=_61008_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -16670 0 0 {name=X_61008_ }
C {devices/lab_pin.sym} 30130 -16550 0 0 {name=p29862 lab=_82234_/CLK }
C {devices/lab_pin.sym} 30130 -16530 0 0 {name=p29863 lab=_77818_/Y }
C {devices/lab_pin.sym} 30310 -16550 0 1 {name=p29864 lab=_81931_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -16540 0 0 {name=X_81931_ }
C {devices/lab_pin.sym} 30140 -16440 0 0 {name=p29865 lab=_44531_/A }
C {devices/lab_pin.sym} 30140 -16400 0 0 {name=p29866 lab=_69485_/X }
C {devices/lab_pin.sym} 30140 -16360 0 0 {name=p29867 lab=_69611_/X }
C {devices/lab_pin.sym} 30140 -16320 0 0 {name=p29868 lab=_69652_/X }
C {devices/lab_pin.sym} 30300 -16380 0 1 {name=p29869 lab=_69653_/X }
C {sky130_stdcells/a211o_4.sym} 30220 -16380 0 0 {name=X_69653_ }
C {devices/lab_pin.sym} 30140 -16260 0 0 {name=p29870 lab=_87367_/Q }
C {devices/lab_pin.sym} 30140 -16220 0 0 {name=p29871 lab=_66797_/X }
C {devices/lab_pin.sym} 30140 -16180 0 0 {name=p29872 lab=_66863_/X }
C {devices/lab_pin.sym} 30140 -16140 0 0 {name=p29873 lab=_66864_/X }
C {devices/lab_pin.sym} 30300 -16200 0 1 {name=p29874 lab=_66865_/X }
C {sky130_stdcells/a211o_4.sym} 30220 -16200 0 0 {name=X_66865_ }
C {devices/lab_pin.sym} 30160 -16060 0 0 {name=p29875 lab=_68604_/A }
C {devices/lab_pin.sym} 30160 -16020 0 0 {name=p29876 lab=_68604_/B }
C {devices/lab_pin.sym} 30280 -16040 0 1 {name=p29877 lab=_68604_/X }
C {sky130_stdcells/and2_4.sym} 30220 -16040 0 0 {name=X_68604_ }
C {devices/lab_pin.sym} 30160 -15930 0 0 {name=p29878 lab=_48979_/A }
C {devices/lab_pin.sym} 30160 -15890 0 0 {name=p29879 lab=_53806_/B }
C {devices/lab_pin.sym} 30160 -15850 0 0 {name=p29880 lab=_53806_/C }
C {devices/lab_pin.sym} 30280 -15890 0 1 {name=p29881 lab=_53830_/X }
C {sky130_stdcells/and3_4.sym} 30220 -15890 0 0 {name=X_53830_ }
C {devices/lab_pin.sym} 30180 -15750 0 0 {name=p29882 lab=_65929_/A }
C {devices/lab_pin.sym} 30260 -15750 0 1 {name=p29883 lab=_65916_/B }
C {sky130_stdcells/buf_2.sym} 30220 -15750 0 0 {name=X_65816_ }
C {devices/lab_pin.sym} 30130 -15630 0 0 {name=p29884 lab=_84652_/CLK }
C {devices/lab_pin.sym} 30130 -15610 0 0 {name=p29885 lab=_84650_/D }
C {devices/lab_pin.sym} 30310 -15630 0 1 {name=p29886 lab=_60152_/A }
C {sky130_stdcells/dfxtp_4.sym} 30220 -15620 0 0 {name=X_84650_ }
C {devices/lab_pin.sym} 30130 -15490 0 0 {name=p29887 lab=_81859_/CLK }
C {devices/lab_pin.sym} 30130 -15470 0 0 {name=p29888 lab=_78053_/X }
C {devices/lab_pin.sym} 30310 -15490 0 1 {name=p29889 lab=_81862_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -15480 0 0 {name=X_81862_ }
C {devices/lab_pin.sym} 30140 -15380 0 0 {name=p29890 lab=_88082_/Q }
C {devices/lab_pin.sym} 30140 -15340 0 0 {name=p29891 lab=_69582_/X }
C {devices/lab_pin.sym} 30140 -15300 0 0 {name=p29892 lab=_69567_/X }
C {devices/lab_pin.sym} 30140 -15260 0 0 {name=p29893 lab=_69583_/Y }
C {devices/lab_pin.sym} 30300 -15320 0 1 {name=p29894 lab=_69584_/X }
C {sky130_stdcells/a211o_4.sym} 30220 -15320 0 0 {name=X_69584_ }
C {devices/lab_pin.sym} 30140 -15200 0 0 {name=p29895 lab=_87882_/Q }
C {devices/lab_pin.sym} 30140 -15160 0 0 {name=p29896 lab=_66697_/X }
C {devices/lab_pin.sym} 30140 -15120 0 0 {name=p29897 lab=_66794_/X }
C {devices/lab_pin.sym} 30140 -15080 0 0 {name=p29898 lab=_66795_/X }
C {devices/lab_pin.sym} 30300 -15140 0 1 {name=p29899 lab=_66796_/X }
C {sky130_stdcells/a211o_4.sym} 30220 -15140 0 0 {name=X_66796_ }
C {devices/lab_pin.sym} 30130 -14990 0 0 {name=p29900 lab=_86145_/CLK }
C {devices/lab_pin.sym} 30130 -14970 0 0 {name=p29901 lab=_71120_/Y }
C {devices/lab_pin.sym} 30310 -14990 0 1 {name=p29902 lab=_83601_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -14980 0 0 {name=X_83601_ }
C {devices/lab_pin.sym} 30130 -14850 0 0 {name=p29903 lab=_80813_/CLK }
C {devices/lab_pin.sym} 30130 -14830 0 0 {name=p29904 lab=_83957_/Q }
C {devices/lab_pin.sym} 30310 -14850 0 1 {name=p29905 lab=_75817_/B }
C {sky130_stdcells/dfxtp_4.sym} 30220 -14840 0 0 {name=X_80813_ }
C {devices/lab_pin.sym} 30160 -14720 0 0 {name=p29906 lab=_68560_/A }
C {devices/lab_pin.sym} 30160 -14680 0 0 {name=p29907 lab=_88269_/Q }
C {devices/lab_pin.sym} 30280 -14700 0 1 {name=p29908 lab=_68535_/X }
C {sky130_stdcells/and2_4.sym} 30220 -14700 0 0 {name=X_68535_ }
C {devices/lab_pin.sym} 30160 -14580 0 0 {name=p29909 lab=_53766_/A }
C {devices/lab_pin.sym} 30160 -14540 0 0 {name=p29910 lab=_48672_/A }
C {devices/lab_pin.sym} 30280 -14560 0 1 {name=p29911 lab=_53761_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -14560 0 0 {name=X_53761_ }
C {devices/lab_pin.sym} 30160 -14450 0 0 {name=p29912 lab=_65162_/X }
C {devices/lab_pin.sym} 30160 -14410 0 0 {name=p29913 lab=_65653_/B }
C {devices/lab_pin.sym} 30160 -14370 0 0 {name=p29914 lab=_65165_/X }
C {devices/lab_pin.sym} 30280 -14410 0 1 {name=p29915 lab=_65747_/Y }
C {sky130_stdcells/nand3_4.sym} 30220 -14410 0 0 {name=X_65747_ }
C {devices/lab_pin.sym} 30130 -14270 0 0 {name=p29916 lab=_84562_/CLK }
C {devices/lab_pin.sym} 30130 -14250 0 0 {name=p29917 lab=_84581_/D }
C {devices/lab_pin.sym} 30310 -14270 0 1 {name=p29918 lab=_60717_/C }
C {sky130_stdcells/dfxtp_4.sym} 30220 -14260 0 0 {name=X_84581_ }
C {devices/lab_pin.sym} 30180 -14130 0 0 {name=p29919 lab=_50973_/A }
C {devices/lab_pin.sym} 30260 -14130 0 1 {name=p29920 lab=_50973_/X }
C {sky130_stdcells/buf_2.sym} 30220 -14130 0 0 {name=X_50973_ }
C {devices/lab_pin.sym} 30160 -14040 0 0 {name=p29921 lab=_62967_/A }
C {devices/lab_pin.sym} 30160 -14000 0 0 {name=p29922 lab=_63316_/A }
C {devices/lab_pin.sym} 30160 -13960 0 0 {name=p29923 lab=_62939_/X }
C {devices/lab_pin.sym} 30160 -13920 0 0 {name=p29924 lab=_62967_/D }
C {devices/lab_pin.sym} 30280 -13980 0 1 {name=p29925 lab=_62959_/X }
C {sky130_stdcells/and4_4.sym} 30220 -13980 0 0 {name=X_62959_ }
C {devices/lab_pin.sym} 30130 -13830 0 0 {name=p29926 lab=_82369_/CLK }
C {devices/lab_pin.sym} 30130 -13810 0 0 {name=p29927 lab=_75966_/X }
C {devices/lab_pin.sym} 30310 -13830 0 1 {name=p29928 lab=_81793_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -13820 0 0 {name=X_81793_ }
C {devices/lab_pin.sym} 30140 -13720 0 0 {name=p29929 lab=_82997_/Q }
C {devices/lab_pin.sym} 30140 -13680 0 0 {name=p29930 lab=_55498_/X }
C {devices/lab_pin.sym} 30140 -13640 0 0 {name=p29931 lab=_44096_/X }
C {devices/lab_pin.sym} 30140 -13600 0 0 {name=p29932 lab=_55499_/X }
C {devices/lab_pin.sym} 30300 -13660 0 1 {name=p29933 lab=_55500_/X }
C {sky130_stdcells/a211o_4.sym} 30220 -13660 0 0 {name=X_55500_ }
C {devices/lab_pin.sym} 30130 -13510 0 0 {name=p29934 lab=_86640_/CLK }
C {devices/lab_pin.sym} 30130 -13490 0 0 {name=p29935 lab=_49808_/Y }
C {devices/lab_pin.sym} 30310 -13510 0 1 {name=p29936 lab=_57958_/B }
C {sky130_stdcells/dfxtp_4.sym} 30220 -13500 0 0 {name=X_86320_ }
C {devices/lab_pin.sym} 30180 -13370 0 0 {name=p29937 lab=_52657_/A }
C {devices/lab_pin.sym} 30260 -13370 0 1 {name=p29938 lab=_52718_/A }
C {sky130_stdcells/buf_2.sym} 30220 -13370 0 0 {name=X_52712_ }
C {devices/lab_pin.sym} 30130 -13250 0 0 {name=p29939 lab=_86490_/CLK }
C {devices/lab_pin.sym} 30130 -13230 0 0 {name=p29940 lab=_71334_/Y }
C {devices/lab_pin.sym} 30310 -13250 0 1 {name=p29941 lab=_48130_/A }
C {sky130_stdcells/dfxtp_4.sym} 30220 -13240 0 0 {name=X_83532_ }
C {devices/lab_pin.sym} 30140 -13130 0 0 {name=p29942 lab=_56031_/X }
C {devices/lab_pin.sym} 30140 -13090 0 0 {name=p29943 lab=_56468_/X }
C {devices/lab_pin.sym} 30140 -13050 0 0 {name=p29944 lab=_56479_/Y }
C {devices/lab_pin.sym} 30300 -13090 0 1 {name=p29945 lab=_85180_/D }
C {sky130_stdcells/o21ai_4.sym} 30220 -13090 0 0 {name=X_56480_ }
C {devices/lab_pin.sym} 30130 -12950 0 0 {name=p29946 lab=_81994_/CLK }
C {devices/lab_pin.sym} 30130 -12930 0 0 {name=p29947 lab=_75168_/X }
C {devices/lab_pin.sym} 30310 -12950 0 1 {name=p29948 lab=_80744_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -12940 0 0 {name=X_80744_ }
C {devices/lab_pin.sym} 30140 -12840 0 0 {name=p29949 lab=_73650_/A }
C {devices/lab_pin.sym} 30140 -12800 0 0 {name=p29950 lab=_68463_/X }
C {devices/lab_pin.sym} 30140 -12760 0 0 {name=p29951 lab=_68439_/X }
C {devices/lab_pin.sym} 30140 -12720 0 0 {name=p29952 lab=_68465_/Y }
C {devices/lab_pin.sym} 30300 -12780 0 1 {name=p29953 lab=_68466_/X }
C {sky130_stdcells/a211o_4.sym} 30220 -12780 0 0 {name=X_68466_ }
C {devices/lab_pin.sym} 30160 -12650 0 0 {name=p29954 lab=_50469_/A }
C {devices/lab_pin.sym} 30160 -12610 0 0 {name=p29955 lab=_53720_/B }
C {devices/lab_pin.sym} 30160 -12570 0 0 {name=p29956 lab=_53692_/C }
C {devices/lab_pin.sym} 30280 -12610 0 1 {name=p29957 lab=_53692_/X }
C {sky130_stdcells/and3_4.sym} 30220 -12610 0 0 {name=X_53692_ }
C {devices/lab_pin.sym} 30160 -12490 0 0 {name=p29958 lab=_65039_/X }
C {devices/lab_pin.sym} 30160 -12450 0 0 {name=p29959 lab=_65828_/B }
C {devices/lab_pin.sym} 30160 -12410 0 0 {name=p29960 lab=_65041_/X }
C {devices/lab_pin.sym} 30280 -12450 0 1 {name=p29961 lab=_65678_/Y }
C {sky130_stdcells/nand3_4.sym} 30220 -12450 0 0 {name=X_65678_ }
C {devices/lab_pin.sym} 30180 -12310 0 0 {name=p29962 lab=_55415_/B }
C {devices/lab_pin.sym} 30260 -12310 0 1 {name=p29963 lab=_55431_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -12310 0 0 {name=X_55431_ }
C {devices/lab_pin.sym} 30160 -12200 0 0 {name=p29964 lab=_67320_/A }
C {devices/lab_pin.sym} 30160 -12160 0 0 {name=p29965 lab=_67417_/B }
C {devices/lab_pin.sym} 30280 -12180 0 1 {name=p29966 lab=_67417_/X }
C {sky130_stdcells/and2_4.sym} 30220 -12180 0 0 {name=X_67417_ }
C {devices/lab_pin.sym} 30130 -12050 0 0 {name=p29967 lab=_86154_/CLK }
C {devices/lab_pin.sym} 30130 -12030 0 0 {name=p29968 lab=_86251_/D }
C {devices/lab_pin.sym} 30310 -12050 0 1 {name=p29969 lab=_86251_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -12040 0 0 {name=X_86251_ }
C {devices/lab_pin.sym} 30160 -11940 0 0 {name=p29970 lab=_52643_/A }
C {devices/lab_pin.sym} 30160 -11900 0 0 {name=p29971 lab=_52654_/B }
C {devices/lab_pin.sym} 30160 -11860 0 0 {name=p29972 lab=_52643_/C }
C {devices/lab_pin.sym} 30160 -11820 0 0 {name=p29973 lab=_46736_/X }
C {devices/lab_pin.sym} 30280 -11880 0 1 {name=p29974 lab=_52643_/X }
C {sky130_stdcells/and4_4.sym} 30220 -11880 0 0 {name=X_52643_ }
C {devices/lab_pin.sym} 30180 -11730 0 0 {name=p29975 lab=_64629_/A }
C {devices/lab_pin.sym} 30260 -11730 0 1 {name=p29976 lab=_64629_/X }
C {sky130_stdcells/buf_2.sym} 30220 -11730 0 0 {name=X_64629_ }
C {devices/lab_pin.sym} 30130 -11610 0 0 {name=p29977 lab=_83495_/CLK }
C {devices/lab_pin.sym} 30130 -11590 0 0 {name=p29978 lab=_83463_/D }
C {devices/lab_pin.sym} 30310 -11610 0 1 {name=p29979 lab=_59457_/B }
C {sky130_stdcells/dfxtp_4.sym} 30220 -11600 0 0 {name=X_83463_ }
C {devices/lab_pin.sym} 30130 -11470 0 0 {name=p29980 lab=_80679_/CLK }
C {devices/lab_pin.sym} 30130 -11450 0 0 {name=p29981 lab=_80675_/D }
C {devices/lab_pin.sym} 30310 -11470 0 1 {name=p29982 lab=_80675_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -11460 0 0 {name=X_80675_ }
C {devices/lab_pin.sym} 30160 -11340 0 0 {name=p29983 lab=_69877_/A }
C {devices/lab_pin.sym} 30160 -11300 0 0 {name=p29984 lab=_88370_/Q }
C {devices/lab_pin.sym} 30280 -11320 0 1 {name=p29985 lab=_68397_/X }
C {sky130_stdcells/and2_4.sym} 30220 -11320 0 0 {name=X_68397_ }
C {devices/lab_pin.sym} 30130 -11190 0 0 {name=p29986 lab=_85297_/CLK }
C {devices/lab_pin.sym} 30130 -11170 0 0 {name=p29987 lab=_56417_/Y }
C {devices/lab_pin.sym} 30310 -11190 0 1 {name=p29988 lab=_85202_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -11180 0 0 {name=X_85202_ }
C {devices/lab_pin.sym} 30180 -11050 0 0 {name=p29989 lab=_63022_/A }
C {devices/lab_pin.sym} 30260 -11050 0 1 {name=p29990 lab=_63380_/A }
C {sky130_stdcells/buf_2.sym} 30220 -11050 0 0 {name=X_58150_ }
C {sky130_stdcells/decap_3.sym} 30220 -10900 0 0 {name=XPHY_505 }
C {devices/lab_pin.sym} 30130 -10750 0 0 {name=p29991 lab=_82248_/CLK }
C {devices/lab_pin.sym} 30130 -10730 0 0 {name=p29992 lab=_82446_/Q }
C {devices/lab_pin.sym} 30310 -10750 0 1 {name=p29993 lab=_78472_/A }
C {sky130_stdcells/dfxtp_4.sym} 30220 -10740 0 0 {name=X_82414_ }
C {devices/lab_pin.sym} 30180 -10610 0 0 {name=p29994 lab=_55362_/A }
C {devices/lab_pin.sym} 30260 -10610 0 1 {name=p29995 lab=_55363_/B }
C {sky130_stdcells/inv_2.sym} 30220 -10610 0 0 {name=X_55362_ }
C {devices/lab_pin.sym} 30180 -10490 0 0 {name=p29996 lab=_66868_/A }
C {devices/lab_pin.sym} 30260 -10490 0 1 {name=p29997 lab=_67348_/X }
C {sky130_stdcells/buf_2.sym} 30220 -10490 0 0 {name=X_67348_ }
C {devices/lab_pin.sym} 30130 -10370 0 0 {name=p29998 lab=_85859_/CLK }
C {devices/lab_pin.sym} 30130 -10350 0 0 {name=p29999 lab=_86182_/D }
C {devices/lab_pin.sym} 30310 -10370 0 1 {name=p30000 lab=_86182_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -10360 0 0 {name=X_86182_ }
C {devices/lab_pin.sym} 30140 -10250 0 0 {name=p30001 lab=_52572_/Y }
C {devices/lab_pin.sym} 30140 -10210 0 0 {name=p30002 lab=_52532_/X }
C {devices/lab_pin.sym} 30140 -10170 0 0 {name=p30003 lab=_52573_/X }
C {devices/lab_pin.sym} 30300 -10210 0 1 {name=p30004 lab=_85794_/D }
C {sky130_stdcells/a21oi_4.sym} 30220 -10210 0 0 {name=X_52574_ }
C {sky130_stdcells/decap_3.sym} 30220 -10040 0 0 {name=XPHY_516 }
C {devices/lab_pin.sym} 30130 -9890 0 0 {name=p30005 lab=_83756_/CLK }
C {devices/lab_pin.sym} 30130 -9870 0 0 {name=p30006 lab=_71734_/Y }
C {devices/lab_pin.sym} 30310 -9890 0 1 {name=p30007 lab=_58246_/A }
C {sky130_stdcells/dfxtp_4.sym} 30220 -9880 0 0 {name=X_83394_ }
C {sky130_stdcells/decap_3.sym} 30220 -9720 0 0 {name=XPHY_527 }
C {sky130_stdcells/decap_3.sym} 30220 -9540 0 0 {name=XPHY_538 }
C {devices/lab_pin.sym} 30140 -9420 0 0 {name=p30008 lab=_57097_/X }
C {devices/lab_pin.sym} 30140 -9380 0 0 {name=p30009 lab=_56575_/X }
C {devices/lab_pin.sym} 30140 -9340 0 0 {name=p30010 lab=_45422_/A }
C {devices/lab_pin.sym} 30140 -9300 0 0 {name=p30011 lab=_57099_/X }
C {devices/lab_pin.sym} 30300 -9360 0 1 {name=p30012 lab=_57101_/X }
C {sky130_stdcells/a2bb2o_4.sym} 30220 -9360 0 0 {name=X_57101_ }
C {devices/lab_pin.sym} 30140 -9230 0 0 {name=p30013 lab=_54310_/Y }
C {devices/lab_pin.sym} 30140 -9190 0 0 {name=p30014 lab=_54311_/X }
C {devices/lab_pin.sym} 30140 -9150 0 0 {name=p30015 lab=_54312_/X }
C {devices/lab_pin.sym} 30300 -9190 0 1 {name=p30016 lab=_85465_/D }
C {sky130_stdcells/a21oi_4.sym} 30220 -9190 0 0 {name=X_54313_ }
C {sky130_stdcells/decap_3.sym} 30220 -9020 0 0 {name=XPHY_549 }
C {devices/lab_pin.sym} 30130 -8870 0 0 {name=p30017 lab=_85071_/CLK }
C {devices/lab_pin.sym} 30130 -8850 0 0 {name=p30018 lab=_85133_/D }
C {devices/lab_pin.sym} 30310 -8870 0 1 {name=p30019 lab=_85133_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -8860 0 0 {name=X_85133_ }
C {devices/lab_pin.sym} 30140 -8750 0 0 {name=p30020 lab=_85994_/Q }
C {devices/lab_pin.sym} 30140 -8710 0 0 {name=p30021 lab=_51511_/X }
C {devices/lab_pin.sym} 30140 -8670 0 0 {name=p30022 lab=_51524_/Y }
C {devices/lab_pin.sym} 30300 -8710 0 1 {name=p30023 lab=_51525_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -8710 0 0 {name=X_51525_ }
C {devices/lab_pin.sym} 30160 -8580 0 0 {name=p30024 lab=_58576_/A }
C {devices/lab_pin.sym} 30160 -8540 0 0 {name=p30025 lab=_58081_/B }
C {devices/lab_pin.sym} 30280 -8560 0 1 {name=p30026 lab=_58081_/Y }
C {sky130_stdcells/nor2_4.sym} 30220 -8560 0 0 {name=X_58081_ }
C {devices/lab_pin.sym} 30130 -8430 0 0 {name=p30027 lab=_82369_/CLK }
C {devices/lab_pin.sym} 30130 -8410 0 0 {name=p30028 lab=_77103_/X }
C {devices/lab_pin.sym} 30310 -8430 0 1 {name=p30029 lab=_48086_/A }
C {sky130_stdcells/dfxtp_4.sym} 30220 -8420 0 0 {name=X_82345_ }
C {devices/lab_pin.sym} 30160 -8300 0 0 {name=p30030 lab=_67183_/A }
C {devices/lab_pin.sym} 30160 -8260 0 0 {name=p30031 lab=_67279_/B }
C {devices/lab_pin.sym} 30280 -8280 0 1 {name=p30032 lab=_67279_/X }
C {sky130_stdcells/and2_4.sym} 30220 -8280 0 0 {name=X_67279_ }
C {devices/lab_pin.sym} 30140 -8170 0 0 {name=p30033 lab=_55139_/X }
C {devices/lab_pin.sym} 30140 -8130 0 0 {name=p30034 lab=_55146_/X }
C {devices/lab_pin.sym} 30140 -8090 0 0 {name=p30035 lab=_83747_/Q }
C {devices/lab_pin.sym} 30300 -8130 0 1 {name=p30036 lab=_55293_/X }
C {sky130_stdcells/a21o_4.sym} 30220 -8130 0 0 {name=X_55293_ }
C {devices/lab_pin.sym} 30180 -7990 0 0 {name=p30037 lab=clkbuf_9_254_0_CLK/X }
C {devices/lab_pin.sym} 30260 -7990 0 1 {name=p30038 lab=_82956_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 30220 -7990 0 0 {name=Xclkbuf_10_509_0_CLK }
C {devices/lab_pin.sym} 30160 -7880 0 0 {name=p30039 lab=_56820_/A }
C {devices/lab_pin.sym} 30160 -7840 0 0 {name=p30040 lab=_57043_/B }
C {devices/lab_pin.sym} 30280 -7860 0 1 {name=p30041 lab=_57032_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -7860 0 0 {name=X_57032_ }
C {devices/lab_pin.sym} 30140 -7750 0 0 {name=p30042 lab=_69013_/X }
C {devices/lab_pin.sym} 30140 -7710 0 0 {name=p30043 lab=_69016_/X }
C {devices/lab_pin.sym} 30140 -7670 0 0 {name=p30044 lab=_69017_/X }
C {devices/lab_pin.sym} 30300 -7710 0 1 {name=p30045 lab=_69018_/Y }
C {sky130_stdcells/a21oi_4.sym} 30220 -7710 0 0 {name=X_69018_ }
C {devices/lab_pin.sym} 30140 -7590 0 0 {name=p30046 lab=_85477_/Q }
C {devices/lab_pin.sym} 30140 -7550 0 0 {name=p30047 lab=_54220_/X }
C {devices/lab_pin.sym} 30140 -7510 0 0 {name=p30048 lab=_54243_/Y }
C {devices/lab_pin.sym} 30300 -7550 0 1 {name=p30049 lab=_54244_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -7550 0 0 {name=X_54244_ }
C {devices/lab_pin.sym} 30130 -7410 0 0 {name=p30050 lab=_84998_/CLK }
C {devices/lab_pin.sym} 30130 -7390 0 0 {name=p30051 lab=_85064_/D }
C {devices/lab_pin.sym} 30310 -7410 0 1 {name=p30052 lab=_57199_/A }
C {sky130_stdcells/dfxtp_4.sym} 30220 -7400 0 0 {name=X_85064_ }
C {devices/lab_pin.sym} 30160 -7300 0 0 {name=p30053 lab=_51456_/A }
C {devices/lab_pin.sym} 30160 -7260 0 0 {name=p30054 lab=_51473_/B }
C {devices/lab_pin.sym} 30160 -7220 0 0 {name=p30055 lab=_51467_/C }
C {devices/lab_pin.sym} 30160 -7180 0 0 {name=p30056 lab=_52982_/D }
C {devices/lab_pin.sym} 30280 -7240 0 1 {name=p30057 lab=_51456_/X }
C {sky130_stdcells/and4_4.sym} 30220 -7240 0 0 {name=X_51456_ }
C {devices/lab_pin.sym} 30160 -7120 0 0 {name=p30058 lab=_70292_/A }
C {devices/lab_pin.sym} 30160 -7080 0 0 {name=p30059 lab=_70292_/B }
C {devices/lab_pin.sym} 30160 -7040 0 0 {name=p30060 lab=_83105_/Q }
C {devices/lab_pin.sym} 30160 -7000 0 0 {name=p30061 lab=_70292_/D }
C {devices/lab_pin.sym} 30280 -7060 0 1 {name=p30062 lab=_70290_/X }
C {sky130_stdcells/and4_4.sym} 30220 -7060 0 0 {name=X_70290_ }
C {devices/lab_pin.sym} 30130 -6910 0 0 {name=p30063 lab=_82103_/CLK }
C {devices/lab_pin.sym} 30130 -6890 0 0 {name=p30064 lab=_82276_/D }
C {devices/lab_pin.sym} 30310 -6910 0 1 {name=p30065 lab=_40919_/B }
C {sky130_stdcells/dfxtp_4.sym} 30220 -6900 0 0 {name=X_82276_ }
C {devices/lab_pin.sym} 30180 -6770 0 0 {name=p30066 lab=clkbuf_8_1_0_CLK/A }
C {devices/lab_pin.sym} 30260 -6770 0 1 {name=p30067 lab=clkbuf_8_0_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 30220 -6770 0 0 {name=Xclkbuf_8_0_0_CLK }
C {devices/lab_pin.sym} 30130 -6650 0 0 {name=p30068 lab=_84074_/CLK }
C {devices/lab_pin.sym} 30130 -6630 0 0 {name=p30069 lab=_68195_/X }
C {devices/lab_pin.sym} 30310 -6650 0 1 {name=p30070 lab=_82055_/D }
C {sky130_stdcells/dfxtp_4.sym} 30220 -6640 0 0 {name=X_84015_ }
C {devices/lab_pin.sym} 30180 -6510 0 0 {name=p30071 lab=_50510_/A }
C {devices/lab_pin.sym} 30260 -6510 0 1 {name=p30072 lab=_50435_/C }
C {sky130_stdcells/buf_2.sym} 30220 -6510 0 0 {name=X_50407_ }
C {devices/lab_pin.sym} 30130 -6390 0 0 {name=p30073 lab=_81227_/CLK }
C {devices/lab_pin.sym} 30130 -6370 0 0 {name=p30074 lab=_81035_/Q }
C {devices/lab_pin.sym} 30310 -6390 0 1 {name=p30075 lab=_81227_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -6380 0 0 {name=X_81227_ }
C {devices/lab_pin.sym} 30160 -6260 0 0 {name=p30076 lab=_54184_/A }
C {devices/lab_pin.sym} 30160 -6220 0 0 {name=p30077 lab=_47360_/A }
C {devices/lab_pin.sym} 30280 -6240 0 1 {name=p30078 lab=_54175_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -6240 0 0 {name=X_54175_ }
C {devices/lab_pin.sym} 30180 -6110 0 0 {name=p30079 lab=_51789_/A }
C {devices/lab_pin.sym} 30260 -6110 0 1 {name=p30080 lab=_51387_/X }
C {sky130_stdcells/buf_2.sym} 30220 -6110 0 0 {name=X_51387_ }
C {devices/lab_pin.sym} 30140 -6010 0 0 {name=p30081 lab=_53123_/Y }
C {devices/lab_pin.sym} 30140 -5970 0 0 {name=p30082 lab=_53111_/X }
C {devices/lab_pin.sym} 30140 -5930 0 0 {name=p30083 lab=_53125_/X }
C {devices/lab_pin.sym} 30300 -5970 0 1 {name=p30084 lab=_53126_/Y }
C {sky130_stdcells/a21oi_4.sym} 30220 -5970 0 0 {name=X_53126_ }
C {devices/lab_pin.sym} 30140 -5870 0 0 {name=p30085 lab=_41112_/X }
C {devices/lab_pin.sym} 30140 -5830 0 0 {name=p30086 lab=_41113_/X }
C {devices/lab_pin.sym} 30140 -5790 0 0 {name=p30087 lab=_41139_/X }
C {devices/lab_pin.sym} 30140 -5750 0 0 {name=p30088 lab=_88270_/Q }
C {devices/lab_pin.sym} 30140 -5710 0 0 {name=p30089 lab=_41088_/X }
C {devices/lab_pin.sym} 30300 -5790 0 1 {name=p30090 lab=_41141_/A }
C {sky130_stdcells/o32ai_4.sym} 30220 -5790 0 0 {name=X_41140_ }
C {devices/lab_pin.sym} 30180 -5630 0 0 {name=p30091 lab=_50510_/A }
C {devices/lab_pin.sym} 30260 -5630 0 1 {name=p30092 lab=_50338_/X }
C {sky130_stdcells/buf_2.sym} 30220 -5630 0 0 {name=X_50338_ }
C {devices/lab_pin.sym} 30130 -5510 0 0 {name=p30093 lab=_81160_/CLK }
C {devices/lab_pin.sym} 30130 -5490 0 0 {name=p30094 lab=_74874_/B }
C {devices/lab_pin.sym} 30310 -5510 0 1 {name=p30095 lab=_81158_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -5500 0 0 {name=X_81158_ }
C {devices/lab_pin.sym} 30180 -5370 0 0 {name=p30096 lab=_58983_/A }
C {devices/lab_pin.sym} 30260 -5370 0 1 {name=p30097 lab=_58985_/A }
C {sky130_stdcells/inv_2.sym} 30220 -5370 0 0 {name=X_58983_ }
C {devices/lab_pin.sym} 30140 -5270 0 0 {name=p30098 lab=_57922_/Y }
C {devices/lab_pin.sym} 30140 -5230 0 0 {name=p30099 lab=_65651_/C }
C {devices/lab_pin.sym} 30140 -5190 0 0 {name=p30100 lab=_80108_/Y }
C {devices/lab_pin.sym} 30300 -5230 0 1 {name=p30101 lab=_80109_/X }
C {sky130_stdcells/o21a_4.sym} 30220 -5230 0 0 {name=X_80109_ }
C {devices/lab_pin.sym} 30140 -5120 0 0 {name=p30102 lab=_41070_/X }
C {devices/lab_pin.sym} 30140 -5080 0 0 {name=p30103 lab=_41065_/X }
C {devices/lab_pin.sym} 30140 -5040 0 0 {name=p30104 lab=_69472_/B }
C {devices/lab_pin.sym} 30140 -5000 0 0 {name=p30105 lab=_41066_/X }
C {devices/lab_pin.sym} 30300 -5060 0 1 {name=p30106 lab=_41071_/X }
C {sky130_stdcells/a2bb2o_4.sym} 30220 -5060 0 0 {name=X_41071_ }
C {devices/lab_pin.sym} 30180 -4910 0 0 {name=p30107 lab=_53112_/A }
C {devices/lab_pin.sym} 30260 -4910 0 1 {name=p30108 lab=_53074_/A }
C {sky130_stdcells/buf_2.sym} 30220 -4910 0 0 {name=X_53057_ }
C {devices/lab_pin.sym} 30160 -4800 0 0 {name=p30109 lab=_57971_/A }
C {devices/lab_pin.sym} 30160 -4760 0 0 {name=p30110 lab=_57934_/B }
C {devices/lab_pin.sym} 30280 -4780 0 1 {name=p30111 lab=_57934_/Y }
C {sky130_stdcells/nor2_4.sym} 30220 -4780 0 0 {name=X_57934_ }
C {devices/lab_pin.sym} 30140 -4670 0 0 {name=p30112 lab=_86234_/Q }
C {devices/lab_pin.sym} 30140 -4630 0 0 {name=p30113 lab=_50238_/X }
C {devices/lab_pin.sym} 30140 -4590 0 0 {name=p30114 lab=_50268_/Y }
C {devices/lab_pin.sym} 30300 -4630 0 1 {name=p30115 lab=_50269_/Y }
C {sky130_stdcells/o21ai_4.sym} 30220 -4630 0 0 {name=X_50269_ }
C {devices/lab_pin.sym} 30140 -4510 0 0 {name=p30116 lab=_73967_/X }
C {devices/lab_pin.sym} 30140 -4470 0 0 {name=p30117 lab=_73981_/C }
C {devices/lab_pin.sym} 30140 -4430 0 0 {name=p30118 lab=_73979_/X }
C {devices/lab_pin.sym} 30300 -4470 0 1 {name=p30119 lab=_73980_/X }
C {sky130_stdcells/a21o_4.sym} 30220 -4470 0 0 {name=X_73980_ }
C {devices/lab_pin.sym} 30130 -4330 0 0 {name=p30120 lab=_85679_/CLK }
C {devices/lab_pin.sym} 30130 -4310 0 0 {name=p30121 lab=_85966_/D }
C {devices/lab_pin.sym} 30310 -4330 0 1 {name=p30122 lab=_85966_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -4320 0 0 {name=X_85966_ }
C {devices/lab_pin.sym} 30130 -4190 0 0 {name=p30123 lab=_81121_/CLK }
C {devices/lab_pin.sym} 30130 -4170 0 0 {name=p30124 lab=_81121_/Q }
C {devices/lab_pin.sym} 30310 -4190 0 1 {name=p30125 lab=_81089_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -4180 0 0 {name=X_81089_ }
C {devices/lab_pin.sym} 30140 -4070 0 0 {name=p30126 lab=_52006_/Y }
C {devices/lab_pin.sym} 30140 -4030 0 0 {name=p30127 lab=_51981_/X }
C {devices/lab_pin.sym} 30140 -3990 0 0 {name=p30128 lab=_52007_/Y }
C {devices/lab_pin.sym} 30300 -4030 0 1 {name=p30129 lab=_85907_/D }
C {sky130_stdcells/a21boi_4.sym} 30220 -4030 0 0 {name=X_52008_ }
C {devices/lab_pin.sym} 30130 -3890 0 0 {name=p30130 lab=_87446_/CLK }
C {devices/lab_pin.sym} 30130 -3870 0 0 {name=p30131 lab=_87705_/D }
C {devices/lab_pin.sym} 30310 -3890 0 1 {name=p30132 lab=_87705_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -3880 0 0 {name=X_87705_ }
C {devices/lab_pin.sym} 30180 -3750 0 0 {name=p30133 lab=_73306_/A }
C {devices/lab_pin.sym} 30260 -3750 0 1 {name=p30134 lab=_73093_/A }
C {sky130_stdcells/buf_2.sym} 30220 -3750 0 0 {name=X_72931_ }
C {devices/lab_pin.sym} 30130 -3630 0 0 {name=p30135 lab=_84906_/CLK }
C {devices/lab_pin.sym} 30130 -3610 0 0 {name=p30136 lab=_58165_/X }
C {devices/lab_pin.sym} 30310 -3630 0 1 {name=p30137 lab=_58162_/A }
C {sky130_stdcells/dfxtp_4.sym} 30220 -3620 0 0 {name=X_84917_ }
C {devices/lab_pin.sym} 30140 -3520 0 0 {name=p30138 lab=_84944_/Q }
C {devices/lab_pin.sym} 30140 -3480 0 0 {name=p30139 lab=_57819_/X }
C {devices/lab_pin.sym} 30140 -3440 0 0 {name=p30140 lab=_57859_/X }
C {devices/lab_pin.sym} 30140 -3400 0 0 {name=p30141 lab=_57864_/X }
C {devices/lab_pin.sym} 30300 -3460 0 1 {name=p30142 lab=_57865_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 30220 -3460 0 0 {name=X_57865_ }
C {devices/lab_pin.sym} 30130 -3310 0 0 {name=p30143 lab=_86218_/CLK }
C {devices/lab_pin.sym} 30130 -3290 0 0 {name=p30144 lab=_52059_/Y }
C {devices/lab_pin.sym} 30310 -3310 0 1 {name=p30145 lab=_74127_/B }
C {sky130_stdcells/dfxtp_4.sym} 30220 -3300 0 0 {name=X_85897_ }
C {devices/lab_pin.sym} 30160 -3180 0 0 {name=p30146 lab=_59600_/X }
C {devices/lab_pin.sym} 30160 -3140 0 0 {name=p30147 lab=_72569_/C }
C {devices/lab_pin.sym} 30280 -3160 0 1 {name=p30148 lab=_59604_/X }
C {sky130_stdcells/and2_4.sym} 30220 -3160 0 0 {name=X_59604_ }
C {devices/lab_pin.sym} 30140 -3060 0 0 {name=p30149 lab=_41697_/A }
C {devices/lab_pin.sym} 30140 -3020 0 0 {name=p30150 lab=_44817_/X }
C {devices/lab_pin.sym} 30140 -2980 0 0 {name=p30151 lab=_67629_/B }
C {devices/lab_pin.sym} 30140 -2940 0 0 {name=p30152 lab=_44818_/X }
C {devices/lab_pin.sym} 30300 -3000 0 1 {name=p30153 lab=_86931_/D }
C {sky130_stdcells/a2bb2o_4.sym} 30220 -3000 0 0 {name=X_44830_ }
C {devices/lab_pin.sym} 30180 -2850 0 0 {name=p30154 lab=_56816_/A }
C {devices/lab_pin.sym} 30260 -2850 0 1 {name=p30155 lab=_56816_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -2850 0 0 {name=X_56816_ }
C {devices/lab_pin.sym} 30160 -2740 0 0 {name=p30156 lab=_75650_/A }
C {devices/lab_pin.sym} 30160 -2700 0 0 {name=p30157 lab=_75650_/B }
C {devices/lab_pin.sym} 30280 -2720 0 1 {name=p30158 lab=_75650_/Y }
C {sky130_stdcells/xnor2_4.sym} 30220 -2720 0 0 {name=X_75650_ }
C {devices/lab_pin.sym} 30130 -2590 0 0 {name=p30159 lab=_87636_/CLK }
C {devices/lab_pin.sym} 30130 -2570 0 0 {name=p30160 lab=_42949_/Y }
C {devices/lab_pin.sym} 30310 -2590 0 1 {name=p30161 lab=_68078_/B }
C {sky130_stdcells/dfxtp_4.sym} 30220 -2580 0 0 {name=X_87636_ }
C {devices/lab_pin.sym} 30130 -2450 0 0 {name=p30162 lab=_83457_/CLK }
C {devices/lab_pin.sym} 30130 -2430 0 0 {name=p30163 lab=_58439_/X }
C {devices/lab_pin.sym} 30310 -2450 0 1 {name=p30164 lab=_84848_/Q }
C {sky130_stdcells/dfxtp_4.sym} 30220 -2440 0 0 {name=X_84848_ }
C {devices/lab_pin.sym} 30180 -2310 0 0 {name=p30165 lab=_72861_/X }
C {devices/lab_pin.sym} 30260 -2310 0 1 {name=p30166 lab=_72862_/X }
C {sky130_stdcells/buf_2.sym} 30220 -2310 0 0 {name=X_72862_ }
C {devices/lab_pin.sym} 30140 -2230 0 0 {name=p30167 lab=_57781_/X }
C {devices/lab_pin.sym} 30140 -2190 0 0 {name=p30168 lab=_57786_/Y }
C {devices/lab_pin.sym} 30140 -2150 0 0 {name=p30169 lab=_57792_/Y }
C {devices/lab_pin.sym} 30140 -2110 0 0 {name=p30170 lab=_57793_/X }
C {devices/lab_pin.sym} 30140 -2070 0 0 {name=p30171 lab=_57795_/X }
C {devices/lab_pin.sym} 30300 -2150 0 1 {name=p30172 lab=_57796_/X }
C {sky130_stdcells/o32a_4.sym} 30220 -2150 0 0 {name=X_57796_ }
C {devices/lab_pin.sym} 30140 -2020 0 0 {name=p30173 lab=_74591_/X }
C {devices/lab_pin.sym} 30140 -1980 0 0 {name=p30174 lab=_74599_/X }
C {devices/lab_pin.sym} 30140 -1940 0 0 {name=p30175 lab=_56121_/A }
C {devices/lab_pin.sym} 30140 -1900 0 0 {name=p30176 lab=_74600_/X }
C {devices/lab_pin.sym} 30300 -1960 0 1 {name=p30177 lab=_74601_/X }
C {sky130_stdcells/a211o_4.sym} 30220 -1960 0 0 {name=X_74601_ }
C {devices/lab_pin.sym} 30160 -1830 0 0 {name=p30178 lab=_71813_/A }
C {devices/lab_pin.sym} 30160 -1790 0 0 {name=p30179 lab=_70476_/X }
C {devices/lab_pin.sym} 30160 -1750 0 0 {name=p30180 lab=_70852_/C }
C {devices/lab_pin.sym} 30280 -1790 0 1 {name=p30181 lab=_71813_/X }
C {sky130_stdcells/and3_4.sym} 30220 -1790 0 0 {name=X_71813_ }
C {devices/lab_pin.sym} 30180 -1650 0 0 {name=p30182 lab=_59535_/A }
C {devices/lab_pin.sym} 30260 -1650 0 1 {name=p30183 lab=_61285_/C }
C {sky130_stdcells/buf_2.sym} 30220 -1650 0 0 {name=X_59535_ }
C {devices/lab_pin.sym} 30140 -1570 0 0 {name=p30184 lab=_44740_/X }
C {devices/lab_pin.sym} 30140 -1530 0 0 {name=p30185 lab=_44741_/X }
C {devices/lab_pin.sym} 30140 -1490 0 0 {name=p30186 lab=_41320_/X }
C {devices/lab_pin.sym} 30140 -1450 0 0 {name=p30187 lab=_86968_/Q }
C {devices/lab_pin.sym} 30140 -1410 0 0 {name=p30188 lab=_44742_/X }
C {devices/lab_pin.sym} 30300 -1490 0 1 {name=p30189 lab=_44762_/A }
C {sky130_stdcells/o32ai_4.sym} 30220 -1490 0 0 {name=X_44761_ }
C {devices/lab_pin.sym} 30160 -1350 0 0 {name=p30190 lab=_55383_/A }
C {devices/lab_pin.sym} 30160 -1310 0 0 {name=p30191 lab=_56707_/X }
C {devices/lab_pin.sym} 30160 -1270 0 0 {name=p30192 lab=_55377_/Y }
C {devices/lab_pin.sym} 30280 -1310 0 1 {name=p30193 lab=_57427_/A }
C {sky130_stdcells/nand3_4.sym} 30220 -1310 0 0 {name=X_56747_ }
C {devices/lab_pin.sym} 30180 -1170 0 0 {name=p30194 lab=_80899_/Q }
C {devices/lab_pin.sym} 30260 -1170 0 1 {name=p30195 lab=_75584_/C }
C {sky130_stdcells/inv_2.sym} 30220 -1170 0 0 {name=X_75581_ }
C {devices/lab_pin.sym} 30130 -1050 0 0 {name=p30196 lab=_87288_/CLK }
C {devices/lab_pin.sym} 30130 -1030 0 0 {name=p30197 lab=_43123_/Y }
C {devices/lab_pin.sym} 30310 -1050 0 1 {name=p30198 lab=_72859_/A }
C {sky130_stdcells/dfxtp_4.sym} 30220 -1040 0 0 {name=X_87567_ }
C {devices/lab_pin.sym} 30180 -910 0 0 {name=p30199 lab=_41973_/A }
C {devices/lab_pin.sym} 30260 -910 0 1 {name=p30200 lab=_41973_/Y }
C {sky130_stdcells/inv_2.sym} 30220 -910 0 0 {name=X_41973_ }
C {devices/lab_pin.sym} 30160 -800 0 0 {name=p30201 lab=_53949_/A }
C {devices/lab_pin.sym} 30160 -760 0 0 {name=p30202 lab=_53959_/B }
C {devices/lab_pin.sym} 30280 -780 0 1 {name=p30203 lab=_53959_/Y }
C {sky130_stdcells/nand2_4.sym} 30220 -780 0 0 {name=X_53959_ }
C {devices/lab_pin.sym} 31060 -42170 0 0 {name=p30204 lab=_83176_/Q }
C {devices/lab_pin.sym} 31060 -42130 0 0 {name=p30205 lab=_72709_/X }
C {devices/lab_pin.sym} 31060 -42090 0 0 {name=p30206 lab=_72792_/Y }
C {devices/lab_pin.sym} 31220 -42130 0 1 {name=p30207 lab=_72793_/X }
C {sky130_stdcells/a21o_4.sym} 31140 -42130 0 0 {name=X_72793_ }
C {devices/lab_pin.sym} 31050 -41990 0 0 {name=p30208 lab=_83464_/CLK }
C {devices/lab_pin.sym} 31050 -41970 0 0 {name=p30209 lab=_58992_/X }
C {devices/lab_pin.sym} 31230 -41990 0 1 {name=p30210 lab=_58990_/A }
C {sky130_stdcells/dfxtp_4.sym} 31140 -41980 0 0 {name=X_84779_ }
C {devices/lab_pin.sym} 31100 -41850 0 0 {name=p30211 lab=_83635_/Q }
C {devices/lab_pin.sym} 31180 -41850 0 1 {name=p30212 lab=_46500_/Y }
C {sky130_stdcells/inv_2.sym} 31140 -41850 0 0 {name=X_46500_ }
C {devices/lab_pin.sym} 31060 -41750 0 0 {name=p30213 lab=_77318_/Y }
C {devices/lab_pin.sym} 31060 -41710 0 0 {name=p30214 lab=_77290_/B }
C {devices/lab_pin.sym} 31060 -41670 0 0 {name=p30215 lab=_77319_/X }
C {devices/lab_pin.sym} 31220 -41710 0 1 {name=p30216 lab=_77320_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -41710 0 0 {name=X_77320_ }
C {devices/lab_pin.sym} 31100 -41570 0 0 {name=p30217 lab=_43712_/A }
C {devices/lab_pin.sym} 31180 -41570 0 1 {name=p30218 lab=_43712_/Y }
C {sky130_stdcells/inv_2.sym} 31140 -41570 0 0 {name=X_43712_ }
C {devices/lab_pin.sym} 31060 -41470 0 0 {name=p30219 lab=_52829_/B }
C {devices/lab_pin.sym} 31060 -41430 0 0 {name=p30220 lab=_74516_/X }
C {devices/lab_pin.sym} 31060 -41390 0 0 {name=p30221 lab=_74531_/Y }
C {devices/lab_pin.sym} 31220 -41430 0 1 {name=p30222 lab=_74532_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -41430 0 0 {name=X_74532_ }
C {devices/lab_pin.sym} 31050 -41290 0 0 {name=p30223 lab=_86516_/CLK }
C {devices/lab_pin.sym} 31050 -41270 0 0 {name=p30224 lab=_86518_/D }
C {devices/lab_pin.sym} 31230 -41290 0 1 {name=p30225 lab=_73070_/B }
C {sky130_stdcells/dfxtp_4.sym} 31140 -41280 0 0 {name=X_86518_ }
C {devices/lab_pin.sym} 31060 -41170 0 0 {name=p30226 lab=_40817_/X }
C {devices/lab_pin.sym} 31060 -41130 0 0 {name=p30227 lab=_82275_/Q }
C {devices/lab_pin.sym} 31060 -41090 0 0 {name=p30228 lab=_40923_/X }
C {devices/lab_pin.sym} 31220 -41130 0 1 {name=p30229 lab=_40924_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -41130 0 0 {name=X_40924_ }
C {devices/lab_pin.sym} 31080 -41020 0 0 {name=p30230 lab=_71171_/A }
C {devices/lab_pin.sym} 31080 -40980 0 0 {name=p30231 lab=_70656_/B }
C {devices/lab_pin.sym} 31080 -40940 0 0 {name=p30232 lab=_71744_/C }
C {devices/lab_pin.sym} 31080 -40900 0 0 {name=p30233 lab=_71744_/D }
C {devices/lab_pin.sym} 31200 -40960 0 1 {name=p30234 lab=_71744_/Y }
C {sky130_stdcells/nand4_4.sym} 31140 -40960 0 0 {name=X_71744_ }
C {devices/lab_pin.sym} 31100 -40810 0 0 {name=p30235 lab=_47480_/A }
C {devices/lab_pin.sym} 31180 -40810 0 1 {name=p30236 lab=_47481_/A }
C {sky130_stdcells/inv_2.sym} 31140 -40810 0 0 {name=X_47480_ }
C {devices/lab_pin.sym} 31060 -40710 0 0 {name=p30237 lab=_59462_/X }
C {devices/lab_pin.sym} 31060 -40670 0 0 {name=p30238 lab=_83461_/Q }
C {devices/lab_pin.sym} 31060 -40630 0 0 {name=p30239 lab=_59465_/Y }
C {devices/lab_pin.sym} 31220 -40670 0 1 {name=p30240 lab=_84725_/D }
C {sky130_stdcells/o21a_4.sym} 31140 -40670 0 0 {name=X_59466_ }
C {devices/lab_pin.sym} 31060 -40570 0 0 {name=p30241 lab=_44686_/X }
C {devices/lab_pin.sym} 31060 -40530 0 0 {name=p30242 lab=_44687_/X }
C {devices/lab_pin.sym} 31060 -40490 0 0 {name=p30243 lab=_40633_/X }
C {devices/lab_pin.sym} 31060 -40450 0 0 {name=p30244 lab=_44691_/Y }
C {devices/lab_pin.sym} 31060 -40410 0 0 {name=p30245 lab=_44689_/X }
C {devices/lab_pin.sym} 31220 -40490 0 1 {name=p30246 lab=_44692_/Y }
C {sky130_stdcells/o32ai_4.sym} 31140 -40490 0 0 {name=X_44692_ }
C {devices/lab_pin.sym} 31100 -40330 0 0 {name=p30247 lab=_83337_/Q }
C {devices/lab_pin.sym} 31180 -40330 0 1 {name=p30248 lab=_57140_/B }
C {sky130_stdcells/buf_2.sym} 31140 -40330 0 0 {name=X_56678_ }
C {devices/lab_pin.sym} 31050 -40210 0 0 {name=p30249 lab=_88012_/CLK }
C {devices/lab_pin.sym} 31050 -40190 0 0 {name=p30250 lab=_43285_/X }
C {devices/lab_pin.sym} 31230 -40210 0 1 {name=p30251 lab=_87498_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -40200 0 0 {name=X_87498_ }
C {devices/lab_pin.sym} 31100 -40070 0 0 {name=p30252 lab=_46366_/A }
C {devices/lab_pin.sym} 31180 -40070 0 1 {name=p30253 lab=_46434_/A }
C {sky130_stdcells/buf_2.sym} 31140 -40070 0 0 {name=X_46431_ }
C {devices/lab_pin.sym} 31100 -39950 0 0 {name=p30254 lab=_84853_/Q }
C {devices/lab_pin.sym} 31180 -39950 0 1 {name=p30255 lab=_58418_/A }
C {sky130_stdcells/inv_2.sym} 31140 -39950 0 0 {name=X_58417_ }
C {devices/lab_pin.sym} 31080 -39840 0 0 {name=p30256 lab=_77249_/A }
C {devices/lab_pin.sym} 31080 -39800 0 0 {name=p30257 lab=_82084_/D }
C {devices/lab_pin.sym} 31200 -39820 0 1 {name=p30258 lab=_77253_/A }
C {sky130_stdcells/nand2_4.sym} 31140 -39820 0 0 {name=X_77251_ }
C {devices/lab_pin.sym} 31100 -39690 0 0 {name=p30259 lab=_43642_/X }
C {devices/lab_pin.sym} 31180 -39690 0 1 {name=p30260 lab=_87330_/D }
C {sky130_stdcells/inv_2.sym} 31140 -39690 0 0 {name=X_43643_ }
C {devices/lab_pin.sym} 31060 -39600 0 0 {name=p30261 lab=_45413_/A }
C {devices/lab_pin.sym} 31060 -39560 0 0 {name=p30262 lab=_44116_/B }
C {devices/lab_pin.sym} 31060 -39520 0 0 {name=p30263 lab=_55627_/X }
C {devices/lab_pin.sym} 31060 -39480 0 0 {name=p30264 lab=_55628_/Y }
C {devices/lab_pin.sym} 31220 -39540 0 1 {name=p30265 lab=_55629_/X }
C {sky130_stdcells/a211o_4.sym} 31140 -39540 0 0 {name=X_55629_ }
C {devices/lab_pin.sym} 31050 -39390 0 0 {name=p30266 lab=_85557_/CLK }
C {devices/lab_pin.sym} 31050 -39370 0 0 {name=p30267 lab=_49051_/Y }
C {devices/lab_pin.sym} 31230 -39390 0 1 {name=p30268 lab=_86449_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -39380 0 0 {name=X_86449_ }
C {devices/lab_pin.sym} 31100 -39250 0 0 {name=p30269 lab=_74492_/A }
C {devices/lab_pin.sym} 31180 -39250 0 1 {name=p30270 lab=_74463_/X }
C {sky130_stdcells/buf_2.sym} 31140 -39250 0 0 {name=X_74463_ }
C {devices/lab_pin.sym} 31060 -39170 0 0 {name=p30271 lab=_40835_/X }
C {devices/lab_pin.sym} 31060 -39130 0 0 {name=p30272 lab=_40836_/X }
C {devices/lab_pin.sym} 31060 -39090 0 0 {name=p30273 lab=_40854_/X }
C {devices/lab_pin.sym} 31060 -39050 0 0 {name=p30274 lab=_88322_/Q }
C {devices/lab_pin.sym} 31060 -39010 0 0 {name=p30275 lab=_40832_/X }
C {devices/lab_pin.sym} 31220 -39090 0 1 {name=p30276 lab=_40855_/Y }
C {sky130_stdcells/o32ai_4.sym} 31140 -39090 0 0 {name=X_40855_ }
C {devices/lab_pin.sym} 31060 -38950 0 0 {name=p30277 lab=_58472_/Y }
C {devices/lab_pin.sym} 31060 -38910 0 0 {name=p30278 lab=_71669_/X }
C {devices/lab_pin.sym} 31060 -38870 0 0 {name=p30279 lab=_71674_/Y }
C {devices/lab_pin.sym} 31220 -38910 0 1 {name=p30280 lab=_83416_/D }
C {sky130_stdcells/o21ai_4.sym} 31140 -38910 0 0 {name=X_71675_ }
C {devices/lab_pin.sym} 31100 -38770 0 0 {name=p30281 lab=_58425_/A }
C {devices/lab_pin.sym} 31180 -38770 0 1 {name=p30282 lab=_59398_/A }
C {sky130_stdcells/buf_2.sym} 31140 -38770 0 0 {name=X_59397_ }
C {devices/lab_pin.sym} 31060 -38670 0 0 {name=p30283 lab=_76200_/X }
C {devices/lab_pin.sym} 31060 -38630 0 0 {name=p30284 lab=_76201_/Y }
C {devices/lab_pin.sym} 31060 -38590 0 0 {name=p30285 lab=_81638_/Q }
C {devices/lab_pin.sym} 31220 -38630 0 1 {name=p30286 lab=_76202_/X }
C {sky130_stdcells/a21o_4.sym} 31140 -38630 0 0 {name=X_76202_ }
C {devices/lab_pin.sym} 31100 -38490 0 0 {name=p30287 lab=_52395_/B }
C {devices/lab_pin.sym} 31180 -38490 0 1 {name=p30288 lab=_50183_/B }
C {sky130_stdcells/buf_2.sym} 31140 -38490 0 0 {name=X_49150_ }
C {devices/lab_pin.sym} 31060 -38390 0 0 {name=p30289 lab=_83152_/Q }
C {devices/lab_pin.sym} 31060 -38350 0 0 {name=p30290 lab=_73318_/X }
C {devices/lab_pin.sym} 31060 -38310 0 0 {name=p30291 lab=_73413_/Y }
C {devices/lab_pin.sym} 31220 -38350 0 1 {name=p30292 lab=_73414_/X }
C {sky130_stdcells/a21o_4.sym} 31140 -38350 0 0 {name=X_73414_ }
C {devices/lab_pin.sym} 31080 -38220 0 0 {name=p30293 lab=_46362_/A }
C {devices/lab_pin.sym} 31080 -38180 0 0 {name=p30294 lab=_52468_/B }
C {devices/lab_pin.sym} 31200 -38200 0 1 {name=p30295 lab=_46362_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -38200 0 0 {name=X_46362_ }
C {devices/lab_pin.sym} 31100 -38070 0 0 {name=p30296 lab=_70625_/Y }
C {devices/lab_pin.sym} 31180 -38070 0 1 {name=p30297 lab=_70630_/B }
C {sky130_stdcells/buf_2.sym} 31140 -38070 0 0 {name=X_70626_ }
C {devices/lab_pin.sym} 31080 -37960 0 0 {name=p30298 lab=_58348_/A }
C {devices/lab_pin.sym} 31080 -37920 0 0 {name=p30299 lab=_58364_/B }
C {devices/lab_pin.sym} 31200 -37940 0 1 {name=p30300 lab=_58348_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -37940 0 0 {name=X_58348_ }
C {devices/lab_pin.sym} 31080 -37820 0 0 {name=p30301 lab=_82107_/Q }
C {devices/lab_pin.sym} 31080 -37780 0 0 {name=p30302 lab=_77182_/B }
C {devices/lab_pin.sym} 31200 -37800 0 1 {name=p30303 lab=_77182_/X }
C {sky130_stdcells/xor2_4.sym} 31140 -37800 0 0 {name=X_77182_ }
C {devices/lab_pin.sym} 31100 -37670 0 0 {name=p30304 lab=_53443_/A }
C {devices/lab_pin.sym} 31180 -37670 0 1 {name=p30305 lab=_53455_/A }
C {sky130_stdcells/buf_2.sym} 31140 -37670 0 0 {name=X_43574_ }
C {devices/lab_pin.sym} 31060 -37570 0 0 {name=p30306 lab=_83075_/Q }
C {devices/lab_pin.sym} 31060 -37530 0 0 {name=p30307 lab=_74377_/X }
C {devices/lab_pin.sym} 31060 -37490 0 0 {name=p30308 lab=_74393_/Y }
C {devices/lab_pin.sym} 31220 -37530 0 1 {name=p30309 lab=_74394_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -37530 0 0 {name=X_74394_ }
C {devices/lab_pin.sym} 31060 -37410 0 0 {name=p30310 lab=_40783_/X }
C {devices/lab_pin.sym} 31060 -37370 0 0 {name=p30311 lab=_82301_/Q }
C {devices/lab_pin.sym} 31060 -37330 0 0 {name=p30312 lab=_40785_/X }
C {devices/lab_pin.sym} 31220 -37370 0 1 {name=p30313 lab=_40787_/A }
C {sky130_stdcells/o21a_4.sym} 31140 -37370 0 0 {name=X_40786_ }
C {devices/lab_pin.sym} 31060 -37250 0 0 {name=p30314 lab=_48093_/Y }
C {devices/lab_pin.sym} 31060 -37210 0 0 {name=p30315 lab=_48055_/X }
C {devices/lab_pin.sym} 31060 -37170 0 0 {name=p30316 lab=_48100_/X }
C {devices/lab_pin.sym} 31220 -37210 0 1 {name=p30317 lab=_48101_/Y }
C {sky130_stdcells/a21oi_4.sym} 31140 -37210 0 0 {name=X_48101_ }
C {devices/lab_pin.sym} 31060 -37090 0 0 {name=p30318 lab=_85254_/Q }
C {devices/lab_pin.sym} 31060 -37050 0 0 {name=p30319 lab=_45297_/X }
C {devices/lab_pin.sym} 31060 -37010 0 0 {name=p30320 lab=_45312_/X }
C {devices/lab_pin.sym} 31220 -37050 0 1 {name=p30321 lab=_45313_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -37050 0 0 {name=X_45313_ }
C {devices/lab_pin.sym} 31080 -36920 0 0 {name=p30322 lab=_81726_/D }
C {devices/lab_pin.sym} 31080 -36880 0 0 {name=p30323 lab=_76133_/B }
C {devices/lab_pin.sym} 31200 -36900 0 1 {name=p30324 lab=_76133_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -36900 0 0 {name=X_76133_ }
C {devices/lab_pin.sym} 31050 -36770 0 0 {name=p30325 lab=_87417_/CLK }
C {devices/lab_pin.sym} 31050 -36750 0 0 {name=p30326 lab=_88119_/D }
C {devices/lab_pin.sym} 31230 -36770 0 1 {name=p30327 lab=_67245_/B }
C {sky130_stdcells/dfxtp_4.sym} 31140 -36760 0 0 {name=X_88119_ }
C {devices/lab_pin.sym} 31100 -36630 0 0 {name=p30328 lab=_74143_/A }
C {devices/lab_pin.sym} 31180 -36630 0 1 {name=p30329 lab=_42525_/Y }
C {sky130_stdcells/inv_2.sym} 31140 -36630 0 0 {name=X_42525_ }
C {devices/lab_pin.sym} 31060 -36530 0 0 {name=p30330 lab=_49075_/Y }
C {devices/lab_pin.sym} 31060 -36490 0 0 {name=p30331 lab=_49038_/X }
C {devices/lab_pin.sym} 31060 -36450 0 0 {name=p30332 lab=_49080_/X }
C {devices/lab_pin.sym} 31220 -36490 0 1 {name=p30333 lab=_86446_/D }
C {sky130_stdcells/a21oi_4.sym} 31140 -36490 0 0 {name=X_49081_ }
C {devices/lab_pin.sym} 31080 -36360 0 0 {name=p30334 lab=_73345_/A }
C {devices/lab_pin.sym} 31080 -36320 0 0 {name=p30335 lab=_73003_/B }
C {devices/lab_pin.sym} 31200 -36340 0 1 {name=p30336 lab=_73345_/Y }
C {sky130_stdcells/nor2_4.sym} 31140 -36340 0 0 {name=X_73345_ }
C {devices/lab_pin.sym} 31100 -36210 0 0 {name=p30337 lab=_46623_/A }
C {devices/lab_pin.sym} 31180 -36210 0 1 {name=p30338 lab=_46421_/A }
C {sky130_stdcells/buf_2.sym} 31140 -36210 0 0 {name=X_46293_ }
C {devices/lab_pin.sym} 31100 -36090 0 0 {name=p30339 lab=DATA_TO_HASH[3] }
C {devices/lab_pin.sym} 31180 -36090 0 1 {name=p30340 lab=_71883_/A }
C {sky130_stdcells/inv_2.sym} 31140 -36090 0 0 {name=X_70557_ }
C {devices/lab_pin.sym} 31100 -35970 0 0 {name=p30341 lab=_58279_/A }
C {devices/lab_pin.sym} 31180 -35970 0 1 {name=p30342 lab=_58279_/Y }
C {sky130_stdcells/inv_2.sym} 31140 -35970 0 0 {name=X_58279_ }
C {devices/lab_pin.sym} 31080 -35860 0 0 {name=p30343 lab=_48004_/A }
C {devices/lab_pin.sym} 31080 -35820 0 0 {name=p30344 lab=_50328_/B }
C {devices/lab_pin.sym} 31200 -35840 0 1 {name=p30345 lab=_48032_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -35840 0 0 {name=X_48032_ }
C {devices/lab_pin.sym} 31060 -35750 0 0 {name=p30346 lab=_60275_/X }
C {devices/lab_pin.sym} 31060 -35710 0 0 {name=p30347 lab=_60344_/B }
C {devices/lab_pin.sym} 31060 -35670 0 0 {name=p30348 lab=_59789_/A }
C {devices/lab_pin.sym} 31060 -35630 0 0 {name=p30349 lab=_60259_/A }
C {devices/lab_pin.sym} 31060 -35590 0 0 {name=p30350 lab=_60309_/X }
C {devices/lab_pin.sym} 31220 -35670 0 1 {name=p30351 lab=_60310_/X }
C {sky130_stdcells/a2111o_4.sym} 31140 -35670 0 0 {name=X_60310_ }
C {devices/lab_pin.sym} 31100 -35510 0 0 {name=p30352 lab=_45244_/A }
C {devices/lab_pin.sym} 31180 -35510 0 1 {name=p30353 lab=_45244_/Y }
C {sky130_stdcells/inv_2.sym} 31140 -35510 0 0 {name=X_45244_ }
C {devices/lab_pin.sym} 31080 -35400 0 0 {name=p30354 lab=_76052_/Y }
C {devices/lab_pin.sym} 31080 -35360 0 0 {name=p30355 lab=_76064_/B }
C {devices/lab_pin.sym} 31200 -35380 0 1 {name=p30356 lab=_76064_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -35380 0 0 {name=X_76064_ }
C {devices/lab_pin.sym} 31060 -35290 0 0 {name=p30357 lab=_51238_/B }
C {devices/lab_pin.sym} 31060 -35250 0 0 {name=p30358 lab=_42430_/X }
C {devices/lab_pin.sym} 31060 -35210 0 0 {name=p30359 lab=_40573_/X }
C {devices/lab_pin.sym} 31060 -35170 0 0 {name=p30360 lab=_68380_/A }
C {devices/lab_pin.sym} 31060 -35130 0 0 {name=p30361 lab=_42453_/X }
C {devices/lab_pin.sym} 31220 -35210 0 1 {name=p30362 lab=_42456_/Y }
C {sky130_stdcells/o32ai_4.sym} 31140 -35210 0 0 {name=X_42456_ }
C {devices/lab_pin.sym} 31100 -35050 0 0 {name=p30363 lab=_61290_/A }
C {devices/lab_pin.sym} 31180 -35050 0 1 {name=p30364 lab=_61290_/X }
C {sky130_stdcells/buf_2.sym} 31140 -35050 0 0 {name=X_61290_ }
C {devices/lab_pin.sym} 31060 -34960 0 0 {name=p30365 lab=_69838_/B }
C {devices/lab_pin.sym} 31060 -34920 0 0 {name=p30366 lab=_73250_/X }
C {devices/lab_pin.sym} 31060 -34880 0 0 {name=p30367 lab=_73251_/X }
C {devices/lab_pin.sym} 31060 -34840 0 0 {name=p30368 lab=_73275_/Y }
C {devices/lab_pin.sym} 31220 -34900 0 1 {name=p30369 lab=_73276_/X }
C {sky130_stdcells/a211o_4.sym} 31140 -34900 0 0 {name=X_73276_ }
C {devices/lab_pin.sym} 31100 -34750 0 0 {name=p30370 lab=_71090_/A }
C {devices/lab_pin.sym} 31180 -34750 0 1 {name=p30371 lab=_71779_/B }
C {sky130_stdcells/buf_2.sym} 31140 -34750 0 0 {name=X_70488_ }
C {devices/lab_pin.sym} 31080 -34640 0 0 {name=p30372 lab=_81146_/D }
C {devices/lab_pin.sym} 31080 -34600 0 0 {name=p30373 lab=_75016_/B }
C {devices/lab_pin.sym} 31200 -34620 0 1 {name=p30374 lab=_75018_/A }
C {sky130_stdcells/nor2_4.sym} 31140 -34620 0 0 {name=X_75015_ }
C {devices/lab_pin.sym} 31060 -34510 0 0 {name=p30375 lab=_41373_/X }
C {devices/lab_pin.sym} 31060 -34470 0 0 {name=p30376 lab=_41747_/A }
C {devices/lab_pin.sym} 31060 -34430 0 0 {name=p30377 lab=_41406_/X }
C {devices/lab_pin.sym} 31220 -34470 0 1 {name=p30378 lab=_41407_/X }
C {sky130_stdcells/o21a_4.sym} 31140 -34470 0 0 {name=X_41407_ }
C {devices/lab_pin.sym} 31100 -34330 0 0 {name=p30379 lab=_60241_/A }
C {devices/lab_pin.sym} 31180 -34330 0 1 {name=p30380 lab=_60367_/B }
C {sky130_stdcells/buf_2.sym} 31140 -34330 0 0 {name=X_60241_ }
C {devices/lab_pin.sym} 31060 -34230 0 0 {name=p30381 lab=_72166_/X }
C {devices/lab_pin.sym} 31060 -34190 0 0 {name=p30382 lab=_85368_/Q }
C {devices/lab_pin.sym} 31060 -34150 0 0 {name=p30383 lab=_72226_/X }
C {devices/lab_pin.sym} 31220 -34190 0 1 {name=p30384 lab=_72227_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -34190 0 0 {name=X_72227_ }
C {devices/lab_pin.sym} 31060 -34070 0 0 {name=p30385 lab=_85263_/Q }
C {devices/lab_pin.sym} 31060 -34030 0 0 {name=p30386 lab=_45147_/X }
C {devices/lab_pin.sym} 31060 -33990 0 0 {name=p30387 lab=_45174_/X }
C {devices/lab_pin.sym} 31220 -34030 0 1 {name=p30388 lab=_45175_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -34030 0 0 {name=X_45175_ }
C {devices/lab_pin.sym} 31060 -33920 0 0 {name=p30389 lab=_40387_/X }
C {devices/lab_pin.sym} 31060 -33880 0 0 {name=p30390 lab=_42374_/X }
C {devices/lab_pin.sym} 31060 -33840 0 0 {name=p30391 lab=_87888_/Q }
C {devices/lab_pin.sym} 31060 -33800 0 0 {name=p30392 lab=_42375_/X }
C {devices/lab_pin.sym} 31220 -33860 0 1 {name=p30393 lab=_42387_/X }
C {sky130_stdcells/a2bb2o_4.sym} 31140 -33860 0 0 {name=X_42387_ }
C {devices/lab_pin.sym} 31100 -33710 0 0 {name=p30394 lab=_73352_/A }
C {devices/lab_pin.sym} 31180 -33710 0 1 {name=p30395 lab=_44126_/X }
C {sky130_stdcells/buf_2.sym} 31140 -33710 0 0 {name=X_44126_ }
C {devices/lab_pin.sym} 31080 -33600 0 0 {name=p30396 lab=_84227_/Q }
C {devices/lab_pin.sym} 31080 -33560 0 0 {name=p30397 lab=_83275_/Q }
C {devices/lab_pin.sym} 31200 -33580 0 1 {name=p30398 lab=_79823_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -33580 0 0 {name=X_79823_ }
C {devices/lab_pin.sym} 31100 -33450 0 0 {name=p30399 lab=_41490_/A }
C {devices/lab_pin.sym} 31180 -33450 0 1 {name=p30400 lab=_41338_/X }
C {sky130_stdcells/buf_2.sym} 31140 -33450 0 0 {name=X_41338_ }
C {devices/lab_pin.sym} 31100 -33330 0 0 {name=p30401 lab=_60172_/A }
C {devices/lab_pin.sym} 31180 -33330 0 1 {name=p30402 lab=_60406_/B }
C {sky130_stdcells/buf_2.sym} 31140 -33330 0 0 {name=X_60172_ }
C {devices/lab_pin.sym} 31060 -33230 0 0 {name=p30403 lab=_59368_/X }
C {devices/lab_pin.sym} 31060 -33190 0 0 {name=p30404 lab=_85982_/Q }
C {devices/lab_pin.sym} 31060 -33150 0 0 {name=p30405 lab=_72157_/X }
C {devices/lab_pin.sym} 31220 -33190 0 1 {name=p30406 lab=_72158_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -33190 0 0 {name=X_72158_ }
C {devices/lab_pin.sym} 31100 -33050 0 0 {name=p30407 lab=_49930_/X }
C {devices/lab_pin.sym} 31180 -33050 0 1 {name=p30408 lab=_50005_/C }
C {sky130_stdcells/buf_2.sym} 31140 -33050 0 0 {name=X_49983_ }
C {devices/lab_pin.sym} 31060 -32950 0 0 {name=p30409 lab=_52367_/B }
C {devices/lab_pin.sym} 31060 -32910 0 0 {name=p30410 lab=_71095_/A }
C {devices/lab_pin.sym} 31060 -32870 0 0 {name=p30411 lab=_71108_/Y }
C {devices/lab_pin.sym} 31220 -32910 0 1 {name=p30412 lab=_83604_/D }
C {sky130_stdcells/o21ai_4.sym} 31140 -32910 0 0 {name=X_71109_ }
C {devices/lab_pin.sym} 31100 -32770 0 0 {name=p30413 lab=_48934_/A }
C {devices/lab_pin.sym} 31180 -32770 0 1 {name=p30414 lab=_48985_/A }
C {sky130_stdcells/buf_2.sym} 31140 -32770 0 0 {name=X_48934_ }
C {devices/lab_pin.sym} 31100 -32650 0 0 {name=p30415 lab=_55152_/A }
C {devices/lab_pin.sym} 31180 -32650 0 1 {name=p30416 lab=_44058_/A }
C {sky130_stdcells/buf_2.sym} 31140 -32650 0 0 {name=X_44057_ }
C {devices/lab_pin.sym} 31080 -32540 0 0 {name=p30417 lab=_84221_/Q }
C {devices/lab_pin.sym} 31080 -32500 0 0 {name=p30418 lab=_83269_/Q }
C {devices/lab_pin.sym} 31200 -32520 0 1 {name=p30419 lab=_79761_/A }
C {sky130_stdcells/xor2_4.sym} 31140 -32520 0 0 {name=X_79754_ }
C {devices/lab_pin.sym} 31060 -32420 0 0 {name=p30420 lab=_41268_/X }
C {devices/lab_pin.sym} 31060 -32380 0 0 {name=p30421 lab=_41251_/X }
C {devices/lab_pin.sym} 31060 -32340 0 0 {name=p30422 lab=_69048_/B }
C {devices/lab_pin.sym} 31060 -32300 0 0 {name=p30423 lab=_41253_/X }
C {devices/lab_pin.sym} 31220 -32360 0 1 {name=p30424 lab=_41269_/X }
C {sky130_stdcells/a2bb2o_4.sym} 31140 -32360 0 0 {name=X_41269_ }
C {devices/lab_pin.sym} 31100 -32210 0 0 {name=p30425 lab=_64980_/A }
C {devices/lab_pin.sym} 31180 -32210 0 1 {name=p30426 lab=_64980_/X }
C {sky130_stdcells/buf_2.sym} 31140 -32210 0 0 {name=X_64980_ }
C {devices/lab_pin.sym} 31060 -32110 0 0 {name=p30427 lab=_72087_/Y }
C {devices/lab_pin.sym} 31060 -32070 0 0 {name=p30428 lab=_72083_/X }
C {devices/lab_pin.sym} 31060 -32030 0 0 {name=p30429 lab=_72088_/Y }
C {devices/lab_pin.sym} 31220 -32070 0 1 {name=p30430 lab=_83287_/D }
C {sky130_stdcells/a21boi_4.sym} 31140 -32070 0 0 {name=X_72089_ }
C {devices/lab_pin.sym} 31080 -31940 0 0 {name=p30431 lab=_76662_/A }
C {devices/lab_pin.sym} 31080 -31900 0 0 {name=p30432 lab=_76658_/Y }
C {devices/lab_pin.sym} 31200 -31920 0 1 {name=p30433 lab=_76966_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -31920 0 0 {name=X_76966_ }
C {devices/lab_pin.sym} 31100 -31790 0 0 {name=p30434 lab=_52021_/A }
C {devices/lab_pin.sym} 31180 -31790 0 1 {name=p30435 lab=_51934_/A }
C {sky130_stdcells/buf_2.sym} 31140 -31790 0 0 {name=X_43008_ }
C {devices/lab_pin.sym} 31060 -31690 0 0 {name=p30436 lab=_78675_/B }
C {devices/lab_pin.sym} 31060 -31650 0 0 {name=p30437 lab=_78701_/X }
C {devices/lab_pin.sym} 31060 -31610 0 0 {name=p30438 lab=_78742_/B }
C {devices/lab_pin.sym} 31220 -31650 0 1 {name=p30439 lab=_78706_/B }
C {sky130_stdcells/a21boi_4.sym} 31140 -31650 0 0 {name=X_78705_ }
C {devices/lab_pin.sym} 31060 -31530 0 0 {name=p30440 lab=_63927_/X }
C {devices/lab_pin.sym} 31060 -31490 0 0 {name=p30441 lab=_63913_/X }
C {devices/lab_pin.sym} 31060 -31450 0 0 {name=p30442 lab=_63930_/Y }
C {devices/lab_pin.sym} 31220 -31490 0 1 {name=p30443 lab=_84286_/D }
C {sky130_stdcells/a21oi_4.sym} 31140 -31490 0 0 {name=X_63931_ }
C {devices/lab_pin.sym} 31080 -31360 0 0 {name=p30444 lab=_84515_/Q }
C {devices/lab_pin.sym} 31080 -31320 0 0 {name=p30445 lab=_84387_/Q }
C {devices/lab_pin.sym} 31200 -31340 0 1 {name=p30446 lab=_75917_/X }
C {sky130_stdcells/xor2_4.sym} 31140 -31340 0 0 {name=X_75917_ }
C {devices/lab_pin.sym} 31100 -31210 0 0 {name=p30447 lab=_48840_/A }
C {devices/lab_pin.sym} 31180 -31210 0 1 {name=p30448 lab=_48865_/X }
C {sky130_stdcells/buf_2.sym} 31140 -31210 0 0 {name=X_48865_ }
C {devices/lab_pin.sym} 31060 -31110 0 0 {name=p30449 lab=_79669_/X }
C {devices/lab_pin.sym} 31060 -31070 0 0 {name=p30450 lab=_79672_/Y }
C {devices/lab_pin.sym} 31060 -31030 0 0 {name=p30451 lab=_79684_/X }
C {devices/lab_pin.sym} 31220 -31070 0 1 {name=p30452 lab=_79685_/X }
C {sky130_stdcells/a21o_4.sym} 31140 -31070 0 0 {name=X_79685_ }
C {devices/lab_pin.sym} 31080 -30940 0 0 {name=p30453 lab=_76895_/Y }
C {devices/lab_pin.sym} 31080 -30900 0 0 {name=p30454 lab=_76894_/Y }
C {devices/lab_pin.sym} 31200 -30920 0 1 {name=p30455 lab=_76897_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -30920 0 0 {name=X_76897_ }
C {devices/lab_pin.sym} 31060 -30810 0 0 {name=p30456 lab=_47811_/Y }
C {devices/lab_pin.sym} 31060 -30770 0 0 {name=p30457 lab=_47791_/X }
C {devices/lab_pin.sym} 31060 -30730 0 0 {name=p30458 lab=_47815_/X }
C {devices/lab_pin.sym} 31220 -30770 0 1 {name=p30459 lab=_86595_/D }
C {sky130_stdcells/a21oi_4.sym} 31140 -30770 0 0 {name=X_47816_ }
C {devices/lab_pin.sym} 31080 -30640 0 0 {name=p30460 lab=_66646_/X }
C {devices/lab_pin.sym} 31080 -30600 0 0 {name=p30461 lab=_66649_/X }
C {devices/lab_pin.sym} 31200 -30620 0 1 {name=p30462 lab=_66650_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -30620 0 0 {name=X_66650_ }
C {devices/lab_pin.sym} 31060 -30510 0 0 {name=p30463 lab=_78632_/X }
C {devices/lab_pin.sym} 31060 -30470 0 0 {name=p30464 lab=_78637_/C }
C {devices/lab_pin.sym} 31060 -30430 0 0 {name=p30465 lab=_78637_/B }
C {devices/lab_pin.sym} 31220 -30470 0 1 {name=p30466 lab=_78638_/A }
C {sky130_stdcells/a21o_4.sym} 31140 -30470 0 0 {name=X_78636_ }
C {devices/lab_pin.sym} 31080 -30350 0 0 {name=p30467 lab=_63831_/A }
C {devices/lab_pin.sym} 31080 -30310 0 0 {name=p30468 lab=_64292_/A }
C {devices/lab_pin.sym} 31080 -30270 0 0 {name=p30469 lab=_63862_/C }
C {devices/lab_pin.sym} 31200 -30310 0 1 {name=p30470 lab=_63862_/X }
C {sky130_stdcells/and3_4.sym} 31140 -30310 0 0 {name=X_63862_ }
C {devices/lab_pin.sym} 31080 -30180 0 0 {name=p30471 lab=_80895_/D }
C {devices/lab_pin.sym} 31080 -30140 0 0 {name=p30472 lab=_75848_/B }
C {devices/lab_pin.sym} 31200 -30160 0 1 {name=p30473 lab=_75850_/A }
C {sky130_stdcells/nand2_4.sym} 31140 -30160 0 0 {name=X_75848_ }
C {devices/lab_pin.sym} 31100 -30030 0 0 {name=p30474 lab=_48833_/A }
C {devices/lab_pin.sym} 31180 -30030 0 1 {name=p30475 lab=_48829_/B }
C {sky130_stdcells/buf_2.sym} 31140 -30030 0 0 {name=X_48796_ }
C {devices/lab_pin.sym} 31060 -29930 0 0 {name=p30476 lab=_65533_/X }
C {devices/lab_pin.sym} 31060 -29890 0 0 {name=p30477 lab=_65599_/Y }
C {devices/lab_pin.sym} 31060 -29850 0 0 {name=p30478 lab=_65600_/Y }
C {devices/lab_pin.sym} 31220 -29890 0 1 {name=p30479 lab=_65601_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -29890 0 0 {name=X_65601_ }
C {devices/lab_pin.sym} 31080 -29780 0 0 {name=p30480 lab=_61490_/X }
C {devices/lab_pin.sym} 31080 -29740 0 0 {name=p30481 lab=_62834_/B }
C {devices/lab_pin.sym} 31080 -29700 0 0 {name=p30482 lab=_62801_/X }
C {devices/lab_pin.sym} 31080 -29660 0 0 {name=p30483 lab=_62834_/D }
C {devices/lab_pin.sym} 31200 -29720 0 1 {name=p30484 lab=_62813_/Y }
C {sky130_stdcells/nand4_4.sym} 31140 -29720 0 0 {name=X_62813_ }
C {devices/lab_pin.sym} 31100 -29570 0 0 {name=p30485 lab=_47747_/A }
C {devices/lab_pin.sym} 31180 -29570 0 1 {name=p30486 lab=_55083_/D }
C {sky130_stdcells/inv_2.sym} 31140 -29570 0 0 {name=X_47747_ }
C {devices/lab_pin.sym} 31100 -29450 0 0 {name=p30487 lab=_45915_/X }
C {devices/lab_pin.sym} 31180 -29450 0 1 {name=p30488 lab=_68474_/A }
C {sky130_stdcells/buf_2.sym} 31140 -29450 0 0 {name=X_66581_ }
C {devices/lab_pin.sym} 31080 -29340 0 0 {name=p30489 lab=_78566_/A }
C {devices/lab_pin.sym} 31080 -29300 0 0 {name=p30490 lab=_82720_/Q }
C {devices/lab_pin.sym} 31200 -29320 0 1 {name=p30491 lab=_78568_/A }
C {sky130_stdcells/nand2_4.sym} 31140 -29320 0 0 {name=X_78567_ }
C {devices/lab_pin.sym} 31100 -29190 0 0 {name=p30492 lab=_45720_/A }
C {devices/lab_pin.sym} 31180 -29190 0 1 {name=p30493 lab=_44959_/X }
C {sky130_stdcells/buf_2.sym} 31140 -29190 0 0 {name=X_44959_ }
C {devices/lab_pin.sym} 31080 -29100 0 0 {name=p30494 lab=_58228_/X }
C {devices/lab_pin.sym} 31080 -29060 0 0 {name=p30495 lab=_64189_/C }
C {devices/lab_pin.sym} 31080 -29020 0 0 {name=p30496 lab=_60908_/A }
C {devices/lab_pin.sym} 31080 -28980 0 0 {name=p30497 lab=_63793_/D }
C {devices/lab_pin.sym} 31200 -29040 0 1 {name=p30498 lab=_63794_/D }
C {sky130_stdcells/nand4_4.sym} 31140 -29040 0 0 {name=X_63793_ }
C {devices/lab_pin.sym} 31080 -28900 0 0 {name=p30499 lab=_81097_/Q }
C {devices/lab_pin.sym} 31080 -28860 0 0 {name=p30500 lab=_80809_/Q }
C {devices/lab_pin.sym} 31200 -28880 0 1 {name=p30501 lab=_75779_/Y }
C {sky130_stdcells/xnor2_4.sym} 31140 -28880 0 0 {name=X_75779_ }
C {devices/lab_pin.sym} 31060 -28770 0 0 {name=p30502 lab=_67966_/X }
C {devices/lab_pin.sym} 31060 -28730 0 0 {name=p30503 lab=_67968_/X }
C {devices/lab_pin.sym} 31060 -28690 0 0 {name=p30504 lab=_68295_/X }
C {devices/lab_pin.sym} 31220 -28730 0 1 {name=p30505 lab=_68320_/Y }
C {sky130_stdcells/a21oi_4.sym} 31140 -28730 0 0 {name=X_68320_ }
C {devices/lab_pin.sym} 31060 -28610 0 0 {name=p30506 lab=_65528_/Y }
C {devices/lab_pin.sym} 31060 -28570 0 0 {name=p30507 lab=_65529_/X }
C {devices/lab_pin.sym} 31060 -28530 0 0 {name=p30508 lab=_65531_/X }
C {devices/lab_pin.sym} 31220 -28570 0 1 {name=p30509 lab=_84195_/D }
C {sky130_stdcells/a21o_4.sym} 31140 -28570 0 0 {name=X_65532_ }
C {devices/lab_pin.sym} 31080 -28440 0 0 {name=p30510 lab=_77518_/A }
C {devices/lab_pin.sym} 31080 -28400 0 0 {name=p30511 lab=_82114_/Q }
C {devices/lab_pin.sym} 31200 -28420 0 1 {name=p30512 lab=_77518_/X }
C {sky130_stdcells/xor2_4.sym} 31140 -28420 0 0 {name=X_77518_ }
C {devices/lab_pin.sym} 31100 -28290 0 0 {name=p30513 lab=_62667_/X }
C {devices/lab_pin.sym} 31180 -28290 0 1 {name=p30514 lab=_62744_/X }
C {sky130_stdcells/buf_2.sym} 31140 -28290 0 0 {name=X_62744_ }
C {devices/lab_pin.sym} 31100 -28170 0 0 {name=p30515 lab=_83553_/Q }
C {devices/lab_pin.sym} 31180 -28170 0 1 {name=p30516 lab=_47679_/A }
C {sky130_stdcells/inv_2.sym} 31140 -28170 0 0 {name=X_47678_ }
C {devices/lab_pin.sym} 31060 -28070 0 0 {name=p30517 lab=_78482_/B }
C {devices/lab_pin.sym} 31060 -28030 0 0 {name=p30518 lab=_78496_/X }
C {devices/lab_pin.sym} 31060 -27990 0 0 {name=p30519 lab=_78497_/X }
C {devices/lab_pin.sym} 31220 -28030 0 1 {name=p30520 lab=_78498_/Y }
C {sky130_stdcells/a21boi_4.sym} 31140 -28030 0 0 {name=X_78498_ }
C {devices/lab_pin.sym} 31100 -27890 0 0 {name=p30521 lab=_49444_/A }
C {devices/lab_pin.sym} 31180 -27890 0 1 {name=p30522 lab=_49418_/A }
C {sky130_stdcells/buf_2.sym} 31140 -27890 0 0 {name=X_49417_ }
C {devices/lab_pin.sym} 31060 -27790 0 0 {name=p30523 lab=_67562_/X }
C {devices/lab_pin.sym} 31060 -27750 0 0 {name=p30524 lab=_67564_/X }
C {devices/lab_pin.sym} 31060 -27710 0 0 {name=p30525 lab=_68216_/X }
C {devices/lab_pin.sym} 31220 -27750 0 1 {name=p30526 lab=_68251_/Y }
C {sky130_stdcells/a21oi_4.sym} 31140 -27750 0 0 {name=X_68251_ }
C {devices/lab_pin.sym} 31100 -27610 0 0 {name=p30527 lab=_46629_/A }
C {devices/lab_pin.sym} 31180 -27610 0 1 {name=p30528 lab=_54275_/D }
C {sky130_stdcells/inv_2.sym} 31140 -27610 0 0 {name=X_46629_ }
C {devices/lab_pin.sym} 31060 -27510 0 0 {name=p30529 lab=_65399_/X }
C {devices/lab_pin.sym} 31060 -27470 0 0 {name=p30530 lab=_65461_/Y }
C {devices/lab_pin.sym} 31060 -27430 0 0 {name=p30531 lab=_65462_/Y }
C {devices/lab_pin.sym} 31220 -27470 0 1 {name=p30532 lab=_65463_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -27470 0 0 {name=X_65463_ }
C {devices/lab_pin.sym} 31080 -27340 0 0 {name=p30533 lab=_77447_/X }
C {devices/lab_pin.sym} 31080 -27300 0 0 {name=p30534 lab=_77448_/Y }
C {devices/lab_pin.sym} 31200 -27320 0 1 {name=p30535 lab=_77449_/X }
C {sky130_stdcells/and2_4.sym} 31140 -27320 0 0 {name=X_77449_ }
C {devices/lab_pin.sym} 31100 -27190 0 0 {name=p30536 lab=_62737_/A }
C {devices/lab_pin.sym} 31180 -27190 0 1 {name=p30537 lab=_62676_/C }
C {sky130_stdcells/buf_2.sym} 31140 -27190 0 0 {name=X_62675_ }
C {devices/lab_pin.sym} 31060 -27100 0 0 {name=p30538 lab=_87353_/Q }
C {devices/lab_pin.sym} 31060 -27060 0 0 {name=p30539 lab=_67156_/X }
C {devices/lab_pin.sym} 31060 -27020 0 0 {name=p30540 lab=_67106_/X }
C {devices/lab_pin.sym} 31060 -26980 0 0 {name=p30541 lab=_67201_/X }
C {devices/lab_pin.sym} 31220 -27040 0 1 {name=p30542 lab=_67202_/X }
C {sky130_stdcells/a211o_4.sym} 31140 -27040 0 0 {name=X_67202_ }
C {devices/lab_pin.sym} 31060 -26910 0 0 {name=p30543 lab=_58254_/Y }
C {devices/lab_pin.sym} 31060 -26870 0 0 {name=p30544 lab=_64367_/X }
C {devices/lab_pin.sym} 31060 -26830 0 0 {name=p30545 lab=_64413_/Y }
C {devices/lab_pin.sym} 31220 -26870 0 1 {name=p30546 lab=_64414_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -26870 0 0 {name=X_64414_ }
C {devices/lab_pin.sym} 31080 -26740 0 0 {name=p30547 lab=_49352_/A }
C {devices/lab_pin.sym} 31080 -26700 0 0 {name=p30548 lab=_50870_/B }
C {devices/lab_pin.sym} 31200 -26720 0 1 {name=p30549 lab=_49348_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -26720 0 0 {name=X_49348_ }
C {devices/lab_pin.sym} 31100 -26590 0 0 {name=p30550 lab=_61374_/A }
C {devices/lab_pin.sym} 31180 -26590 0 1 {name=p30551 lab=_61636_/A }
C {sky130_stdcells/buf_2.sym} 31140 -26590 0 0 {name=X_61626_ }
C {devices/lab_pin.sym} 31080 -26480 0 0 {name=p30552 lab=_80457_/X }
C {devices/lab_pin.sym} 31080 -26440 0 0 {name=p30553 lab=_80460_/B }
C {devices/lab_pin.sym} 31200 -26460 0 1 {name=p30554 lab=_82257_/D }
C {sky130_stdcells/xor2_4.sym} 31140 -26460 0 0 {name=X_80460_ }
C {devices/lab_pin.sym} 31060 -26360 0 0 {name=p30555 lab=_68144_/X }
C {devices/lab_pin.sym} 31060 -26320 0 0 {name=p30556 lab=_67130_/Y }
C {devices/lab_pin.sym} 31060 -26280 0 0 {name=p30557 lab=_68168_/X }
C {devices/lab_pin.sym} 31060 -26240 0 0 {name=p30558 lab=_68181_/Y }
C {devices/lab_pin.sym} 31220 -26300 0 1 {name=p30559 lab=_68182_/X }
C {sky130_stdcells/a211o_4.sym} 31140 -26300 0 0 {name=X_68182_ }
C {devices/lab_pin.sym} 31080 -26170 0 0 {name=p30560 lab=_65390_/X }
C {devices/lab_pin.sym} 31080 -26130 0 0 {name=p30561 lab=_65192_/B }
C {devices/lab_pin.sym} 31080 -26090 0 0 {name=p30562 lab=_65393_/X }
C {devices/lab_pin.sym} 31200 -26130 0 1 {name=p30563 lab=_65394_/Y }
C {sky130_stdcells/nand3_4.sym} 31140 -26130 0 0 {name=X_65394_ }
C {devices/lab_pin.sym} 31080 -26000 0 0 {name=p30564 lab=_67133_/A }
C {devices/lab_pin.sym} 31080 -25960 0 0 {name=p30565 lab=_67133_/B }
C {devices/lab_pin.sym} 31200 -25980 0 1 {name=p30566 lab=_67133_/X }
C {sky130_stdcells/and2_4.sym} 31140 -25980 0 0 {name=X_67133_ }
C {devices/lab_pin.sym} 31100 -25850 0 0 {name=p30567 lab=_79031_/B }
C {devices/lab_pin.sym} 31180 -25850 0 1 {name=p30568 lab=_79119_/Y }
C {sky130_stdcells/inv_2.sym} 31140 -25850 0 0 {name=X_79119_ }
C {devices/lab_pin.sym} 31100 -25730 0 0 {name=p30569 lab=clkbuf_9_240_0_CLK/X }
C {devices/lab_pin.sym} 31180 -25730 0 1 {name=p30570 lab=_86289_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 31140 -25730 0 0 {name=Xclkbuf_10_480_0_CLK }
C {devices/lab_pin.sym} 31080 -25630 0 0 {name=p30571 lab=_64344_/X }
C {devices/lab_pin.sym} 31080 -25590 0 0 {name=p30572 lab=_64307_/B }
C {devices/lab_pin.sym} 31080 -25550 0 0 {name=p30573 lab=_84830_/Q }
C {devices/lab_pin.sym} 31200 -25590 0 1 {name=p30574 lab=_64345_/X }
C {sky130_stdcells/and3_4.sym} 31140 -25590 0 0 {name=X_64345_ }
C {devices/lab_pin.sym} 31080 -25460 0 0 {name=p30575 lab=_49232_/A }
C {devices/lab_pin.sym} 31080 -25420 0 0 {name=p30576 lab=_50799_/B }
C {devices/lab_pin.sym} 31200 -25440 0 1 {name=p30577 lab=_49279_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -25440 0 0 {name=X_49279_ }
C {devices/lab_pin.sym} 31100 -25310 0 0 {name=p30578 lab=_61374_/A }
C {devices/lab_pin.sym} 31180 -25310 0 1 {name=p30579 lab=_61558_/A }
C {sky130_stdcells/buf_2.sym} 31140 -25310 0 0 {name=X_61557_ }
C {devices/lab_pin.sym} 31080 -25200 0 0 {name=p30580 lab=_80391_/A }
C {devices/lab_pin.sym} 31080 -25160 0 0 {name=p30581 lab=_63636_/C }
C {devices/lab_pin.sym} 31200 -25180 0 1 {name=p30582 lab=_80391_/X }
C {sky130_stdcells/xor2_4.sym} 31140 -25180 0 0 {name=X_80391_ }
C {devices/lab_pin.sym} 31100 -25050 0 0 {name=p30583 lab=_51286_/A }
C {devices/lab_pin.sym} 31180 -25050 0 1 {name=p30584 lab=_51310_/X }
C {sky130_stdcells/buf_2.sym} 31140 -25050 0 0 {name=X_51310_ }
C {devices/lab_pin.sym} 31050 -24930 0 0 {name=p30585 lab=_81970_/CLK }
C {devices/lab_pin.sym} 31050 -24910 0 0 {name=p30586 lab=_82130_/D }
C {devices/lab_pin.sym} 31230 -24930 0 1 {name=p30587 lab=_82086_/D }
C {sky130_stdcells/dfxtp_4.sym} 31140 -24920 0 0 {name=X_82130_ }
C {devices/lab_pin.sym} 31100 -24790 0 0 {name=p30588 lab=_60508_/A }
C {devices/lab_pin.sym} 31180 -24790 0 1 {name=p30589 lab=_63252_/B }
C {sky130_stdcells/buf_2.sym} 31140 -24790 0 0 {name=X_60508_ }
C {devices/lab_pin.sym} 31080 -24680 0 0 {name=p30590 lab=_67087_/A }
C {devices/lab_pin.sym} 31080 -24640 0 0 {name=p30591 lab=_88127_/Q }
C {devices/lab_pin.sym} 31200 -24660 0 1 {name=p30592 lab=_67064_/X }
C {sky130_stdcells/and2_4.sym} 31140 -24660 0 0 {name=X_67064_ }
C {devices/lab_pin.sym} 31100 -24530 0 0 {name=p30593 lab=_52247_/A }
C {devices/lab_pin.sym} 31180 -24530 0 1 {name=p30594 lab=_52291_/C }
C {sky130_stdcells/buf_2.sym} 31140 -24530 0 0 {name=X_52290_ }
C {devices/lab_pin.sym} 31080 -24430 0 0 {name=p30595 lab=_64248_/A }
C {devices/lab_pin.sym} 31080 -24390 0 0 {name=p30596 lab=_64248_/B }
C {devices/lab_pin.sym} 31080 -24350 0 0 {name=p30597 lab=_64276_/C }
C {devices/lab_pin.sym} 31200 -24390 0 1 {name=p30598 lab=_64276_/X }
C {sky130_stdcells/and3_4.sym} 31140 -24390 0 0 {name=X_64276_ }
C {devices/lab_pin.sym} 31060 -24270 0 0 {name=p30599 lab=_61486_/X }
C {devices/lab_pin.sym} 31060 -24230 0 0 {name=p30600 lab=_61455_/X }
C {devices/lab_pin.sym} 31060 -24190 0 0 {name=p30601 lab=_61487_/Y }
C {devices/lab_pin.sym} 31220 -24230 0 1 {name=p30602 lab=_84477_/D }
C {sky130_stdcells/a21oi_4.sym} 31140 -24230 0 0 {name=X_61488_ }
C {devices/lab_pin.sym} 31060 -24110 0 0 {name=p30603 lab=_65903_/X }
C {devices/lab_pin.sym} 31060 -24070 0 0 {name=p30604 lab=_65543_/Y }
C {devices/lab_pin.sym} 31060 -24030 0 0 {name=p30605 lab=_66014_/Y }
C {devices/lab_pin.sym} 31220 -24070 0 1 {name=p30606 lab=_66015_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -24070 0 0 {name=X_66015_ }
C {devices/lab_pin.sym} 31060 -23950 0 0 {name=p30607 lab=_64617_/B }
C {devices/lab_pin.sym} 31060 -23910 0 0 {name=p30608 lab=_51233_/X }
C {devices/lab_pin.sym} 31060 -23870 0 0 {name=p30609 lab=_51240_/Y }
C {devices/lab_pin.sym} 31220 -23910 0 1 {name=p30610 lab=_51241_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -23910 0 0 {name=X_51241_ }
C {devices/lab_pin.sym} 31080 -23800 0 0 {name=p30611 lab=_63216_/X }
C {devices/lab_pin.sym} 31080 -23760 0 0 {name=p30612 lab=_63227_/B }
C {devices/lab_pin.sym} 31080 -23720 0 0 {name=p30613 lab=_63241_/C }
C {devices/lab_pin.sym} 31080 -23680 0 0 {name=p30614 lab=_63181_/X }
C {devices/lab_pin.sym} 31200 -23740 0 1 {name=p30615 lab=_63227_/X }
C {sky130_stdcells/and4_4.sym} 31140 -23740 0 0 {name=X_63227_ }
C {devices/lab_pin.sym} 31050 -23590 0 0 {name=p30616 lab=_84105_/CLK }
C {devices/lab_pin.sym} 31050 -23570 0 0 {name=p30617 lab=_82061_/D }
C {devices/lab_pin.sym} 31230 -23590 0 1 {name=p30618 lab=_77825_/A }
C {sky130_stdcells/dfxtp_4.sym} 31140 -23580 0 0 {name=X_82061_ }
C {devices/lab_pin.sym} 31100 -23450 0 0 {name=p30619 lab=_60501_/A }
C {devices/lab_pin.sym} 31180 -23450 0 1 {name=p30620 lab=_60439_/X }
C {sky130_stdcells/buf_2.sym} 31140 -23450 0 0 {name=X_60439_ }
C {devices/lab_pin.sym} 31050 -23330 0 0 {name=p30621 lab=_85315_/CLK }
C {devices/lab_pin.sym} 31050 -23310 0 0 {name=p30622 lab=_84220_/Q }
C {devices/lab_pin.sym} 31230 -23330 0 1 {name=p30623 lab=_81012_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -23320 0 0 {name=X_81012_ }
C {devices/lab_pin.sym} 31100 -23190 0 0 {name=p30624 lab=clkbuf_9_247_0_CLK/X }
C {devices/lab_pin.sym} 31180 -23190 0 1 {name=p30625 lab=_83685_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 31140 -23190 0 0 {name=Xclkbuf_10_495_0_CLK }
C {devices/lab_pin.sym} 31060 -23090 0 0 {name=p30626 lab=_51168_/Y }
C {devices/lab_pin.sym} 31060 -23050 0 0 {name=p30627 lab=_51147_/X }
C {devices/lab_pin.sym} 31060 -23010 0 0 {name=p30628 lab=_51171_/X }
C {devices/lab_pin.sym} 31220 -23050 0 1 {name=p30629 lab=_51172_/Y }
C {sky130_stdcells/a21oi_4.sym} 31140 -23050 0 0 {name=X_51172_ }
C {devices/lab_pin.sym} 31080 -22940 0 0 {name=p30630 lab=_63157_/X }
C {devices/lab_pin.sym} 31080 -22900 0 0 {name=p30631 lab=_63158_/B }
C {devices/lab_pin.sym} 31080 -22860 0 0 {name=p30632 lab=_63147_/C }
C {devices/lab_pin.sym} 31080 -22820 0 0 {name=p30633 lab=_63124_/D }
C {devices/lab_pin.sym} 31200 -22880 0 1 {name=p30634 lab=_63158_/X }
C {sky130_stdcells/and4_4.sym} 31140 -22880 0 0 {name=X_63158_ }
C {devices/lab_pin.sym} 31060 -22750 0 0 {name=p30635 lab=_50121_/Y }
C {devices/lab_pin.sym} 31060 -22710 0 0 {name=p30636 lab=_50117_/X }
C {devices/lab_pin.sym} 31060 -22670 0 0 {name=p30637 lab=_50122_/X }
C {devices/lab_pin.sym} 31220 -22710 0 1 {name=p30638 lab=_86260_/D }
C {sky130_stdcells/a21oi_4.sym} 31140 -22710 0 0 {name=X_50123_ }
C {devices/lab_pin.sym} 31060 -22610 0 0 {name=p30639 lab=_58187_/X }
C {devices/lab_pin.sym} 31060 -22570 0 0 {name=p30640 lab=_62105_/X }
C {devices/lab_pin.sym} 31060 -22530 0 0 {name=p30641 lab=_61916_/X }
C {devices/lab_pin.sym} 31060 -22490 0 0 {name=p30642 lab=_61948_/X }
C {devices/lab_pin.sym} 31060 -22460 0 0 {name=p30643 lab=_62108_/X }
C {devices/lab_pin.sym} 31220 -22530 0 1 {name=p30644 lab=_62109_/X }
C {sky130_stdcells/a41o_4.sym} 31140 -22530 0 0 {name=X_62109_ }
C {devices/lab_pin.sym} 31050 -22370 0 0 {name=p30645 lab=_86045_/CLK }
C {devices/lab_pin.sym} 31050 -22350 0 0 {name=p30646 lab=_52451_/Y }
C {devices/lab_pin.sym} 31230 -22370 0 1 {name=p30647 lab=_64743_/B }
C {sky130_stdcells/dfxtp_4.sym} 31140 -22360 0 0 {name=X_85820_ }
C {devices/lab_pin.sym} 31060 -22250 0 0 {name=p30648 lab=_55977_/X }
C {devices/lab_pin.sym} 31060 -22210 0 0 {name=p30649 lab=_55979_/X }
C {devices/lab_pin.sym} 31060 -22170 0 0 {name=p30650 lab=_55615_/X }
C {devices/lab_pin.sym} 31220 -22210 0 1 {name=p30651 lab=_55983_/A }
C {sky130_stdcells/a21o_4.sym} 31140 -22210 0 0 {name=X_55980_ }
C {devices/lab_pin.sym} 31060 -22090 0 0 {name=p30652 lab=_67963_/X }
C {devices/lab_pin.sym} 31060 -22050 0 0 {name=p30653 lab=_67965_/X }
C {devices/lab_pin.sym} 31060 -22010 0 0 {name=p30654 lab=_67917_/X }
C {devices/lab_pin.sym} 31220 -22050 0 1 {name=p30655 lab=_67966_/X }
C {sky130_stdcells/a21o_4.sym} 31140 -22050 0 0 {name=X_67966_ }
C {devices/lab_pin.sym} 31080 -21940 0 0 {name=p30656 lab=_63041_/A }
C {devices/lab_pin.sym} 31080 -21900 0 0 {name=p30657 lab=_63089_/B }
C {devices/lab_pin.sym} 31080 -21860 0 0 {name=p30658 lab=_63079_/C }
C {devices/lab_pin.sym} 31080 -21820 0 0 {name=p30659 lab=_63066_/D }
C {devices/lab_pin.sym} 31200 -21880 0 1 {name=p30660 lab=_63089_/X }
C {sky130_stdcells/and4_4.sym} 31140 -21880 0 0 {name=X_63089_ }
C {devices/lab_pin.sym} 31060 -21750 0 0 {name=p30661 lab=_69702_/X }
C {devices/lab_pin.sym} 31060 -21710 0 0 {name=p30662 lab=_69704_/X }
C {devices/lab_pin.sym} 31060 -21670 0 0 {name=p30663 lab=_69655_/X }
C {devices/lab_pin.sym} 31220 -21710 0 1 {name=p30664 lab=_69705_/Y }
C {sky130_stdcells/a21oi_4.sym} 31140 -21710 0 0 {name=X_69705_ }
C {devices/lab_pin.sym} 31080 -21590 0 0 {name=p30665 lab=_48885_/A }
C {devices/lab_pin.sym} 31080 -21550 0 0 {name=p30666 lab=_48859_/B }
C {devices/lab_pin.sym} 31080 -21510 0 0 {name=p30667 lab=_48854_/C }
C {devices/lab_pin.sym} 31200 -21550 0 1 {name=p30668 lab=_50054_/X }
C {sky130_stdcells/and3_4.sym} 31140 -21550 0 0 {name=X_50054_ }
C {devices/lab_pin.sym} 31060 -21430 0 0 {name=p30669 lab=_85351_/Q }
C {devices/lab_pin.sym} 31060 -21390 0 0 {name=p30670 lab=_54918_/X }
C {devices/lab_pin.sym} 31060 -21350 0 0 {name=p30671 lab=_54930_/Y }
C {devices/lab_pin.sym} 31220 -21390 0 1 {name=p30672 lab=_54931_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -21390 0 0 {name=X_54931_ }
C {devices/lab_pin.sym} 31060 -21280 0 0 {name=p30673 lab=_87365_/Q }
C {devices/lab_pin.sym} 31060 -21240 0 0 {name=p30674 lab=_66915_/X }
C {devices/lab_pin.sym} 31060 -21200 0 0 {name=p30675 lab=_66863_/X }
C {devices/lab_pin.sym} 31060 -21160 0 0 {name=p30676 lab=_66916_/X }
C {devices/lab_pin.sym} 31220 -21220 0 1 {name=p30677 lab=_66917_/X }
C {sky130_stdcells/a211o_4.sym} 31140 -21220 0 0 {name=X_66917_ }
C {devices/lab_pin.sym} 31050 -21070 0 0 {name=p30678 lab=_85751_/CLK }
C {devices/lab_pin.sym} 31050 -21050 0 0 {name=p30679 lab=_52806_/Y }
C {devices/lab_pin.sym} 31230 -21070 0 1 {name=p30680 lab=_85751_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -21060 0 0 {name=X_85751_ }
C {devices/lab_pin.sym} 31050 -20930 0 0 {name=p30681 lab=_82965_/CLK }
C {devices/lab_pin.sym} 31050 -20910 0 0 {name=p30682 lab=_82771_/Q }
C {devices/lab_pin.sym} 31230 -20930 0 1 {name=p30683 lab=_82963_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -20920 0 0 {name=X_82963_ }
C {devices/lab_pin.sym} 31100 -20790 0 0 {name=p30684 lab=_67014_/X }
C {devices/lab_pin.sym} 31180 -20790 0 1 {name=p30685 lab=_67897_/X }
C {sky130_stdcells/buf_2.sym} 31140 -20790 0 0 {name=X_67897_ }
C {devices/lab_pin.sym} 31050 -20670 0 0 {name=p30686 lab=_84713_/CLK }
C {devices/lab_pin.sym} 31050 -20650 0 0 {name=p30687 lab=_59780_/Y }
C {devices/lab_pin.sym} 31230 -20670 0 1 {name=p30688 lab=_80506_/A }
C {sky130_stdcells/dfxtp_4.sym} 31140 -20660 0 0 {name=X_84702_ }
C {devices/lab_pin.sym} 31100 -20530 0 0 {name=p30689 lab=_57650_/A }
C {devices/lab_pin.sym} 31180 -20530 0 1 {name=p30690 lab=_57650_/X }
C {sky130_stdcells/buf_2.sym} 31140 -20530 0 0 {name=X_57650_ }
C {devices/lab_pin.sym} 31100 -20410 0 0 {name=p30691 lab=clkbuf_4_10_1_CLK/A }
C {devices/lab_pin.sym} 31180 -20410 0 1 {name=p30692 lab=clkbuf_4_10_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 31140 -20410 0 0 {name=Xclkbuf_4_10_1_CLK }
C {devices/lab_pin.sym} 31050 -20290 0 0 {name=p30693 lab=_82008_/CLK }
C {devices/lab_pin.sym} 31050 -20270 0 0 {name=p30694 lab=_81914_/D }
C {devices/lab_pin.sym} 31230 -20290 0 1 {name=p30695 lab=_82290_/D }
C {sky130_stdcells/dfxtp_4.sym} 31140 -20280 0 0 {name=X_81914_ }
C {devices/lab_pin.sym} 31060 -20180 0 0 {name=p30696 lab=_88078_/Q }
C {devices/lab_pin.sym} 31060 -20140 0 0 {name=p30697 lab=_69582_/X }
C {devices/lab_pin.sym} 31060 -20100 0 0 {name=p30698 lab=_69567_/X }
C {devices/lab_pin.sym} 31060 -20060 0 0 {name=p30699 lab=_69635_/Y }
C {devices/lab_pin.sym} 31220 -20120 0 1 {name=p30700 lab=_69636_/X }
C {sky130_stdcells/a211o_4.sym} 31140 -20120 0 0 {name=X_69636_ }
C {devices/lab_pin.sym} 31100 -19970 0 0 {name=p30701 lab=_54889_/A }
C {devices/lab_pin.sym} 31180 -19970 0 1 {name=p30702 lab=_54883_/C }
C {sky130_stdcells/buf_2.sym} 31140 -19970 0 0 {name=X_54862_ }
C {devices/lab_pin.sym} 31060 -19880 0 0 {name=p30703 lab=_66757_/X }
C {devices/lab_pin.sym} 31060 -19840 0 0 {name=p30704 lab=_66837_/Y }
C {devices/lab_pin.sym} 31060 -19800 0 0 {name=p30705 lab=_66793_/X }
C {devices/lab_pin.sym} 31060 -19760 0 0 {name=p30706 lab=_66847_/Y }
C {devices/lab_pin.sym} 31220 -19820 0 1 {name=p30707 lab=_66848_/X }
C {sky130_stdcells/a211o_4.sym} 31140 -19820 0 0 {name=X_66848_ }
C {devices/lab_pin.sym} 31050 -19670 0 0 {name=p30708 lab=_84797_/CLK }
C {devices/lab_pin.sym} 31050 -19650 0 0 {name=p30709 lab=_85682_/D }
C {devices/lab_pin.sym} 31230 -19670 0 1 {name=p30710 lab=_85682_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -19660 0 0 {name=X_85682_ }
C {devices/lab_pin.sym} 31050 -19530 0 0 {name=p30711 lab=_87473_/CLK }
C {devices/lab_pin.sym} 31050 -19510 0 0 {name=p30712 lab=_78168_/B }
C {devices/lab_pin.sym} 31230 -19530 0 1 {name=p30713 lab=_41729_/A }
C {sky130_stdcells/dfxtp_4.sym} 31140 -19520 0 0 {name=X_82894_ }
C {devices/lab_pin.sym} 31100 -19390 0 0 {name=p30714 lab=_56551_/X }
C {devices/lab_pin.sym} 31180 -19390 0 1 {name=p30715 lab=_56774_/A }
C {sky130_stdcells/buf_2.sym} 31140 -19390 0 0 {name=X_56601_ }
C {devices/lab_pin.sym} 31050 -19270 0 0 {name=p30716 lab=_87421_/CLK }
C {devices/lab_pin.sym} 31050 -19250 0 0 {name=p30717 lab=_43439_/Y }
C {devices/lab_pin.sym} 31230 -19270 0 1 {name=p30718 lab=_87421_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -19260 0 0 {name=X_87421_ }
C {devices/lab_pin.sym} 31060 -19150 0 0 {name=p30719 lab=_85563_/Q }
C {devices/lab_pin.sym} 31060 -19110 0 0 {name=p30720 lab=_53722_/X }
C {devices/lab_pin.sym} 31060 -19070 0 0 {name=p30721 lab=_53812_/Y }
C {devices/lab_pin.sym} 31220 -19110 0 1 {name=p30722 lab=_53813_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -19110 0 0 {name=X_53813_ }
C {devices/lab_pin.sym} 31050 -18970 0 0 {name=p30723 lab=_84487_/CLK }
C {devices/lab_pin.sym} 31050 -18950 0 0 {name=p30724 lab=_60322_/X }
C {devices/lab_pin.sym} 31230 -18970 0 1 {name=p30725 lab=_79713_/A }
C {sky130_stdcells/dfxtp_4.sym} 31140 -18960 0 0 {name=X_84633_ }
C {devices/lab_pin.sym} 31100 -18830 0 0 {name=p30726 lab=_72009_/A }
C {devices/lab_pin.sym} 31180 -18830 0 1 {name=p30727 lab=_57581_/X }
C {sky130_stdcells/buf_2.sym} 31140 -18830 0 0 {name=X_57581_ }
C {devices/lab_pin.sym} 31050 -18710 0 0 {name=p30728 lab=_81839_/CLK }
C {devices/lab_pin.sym} 31050 -18690 0 0 {name=p30729 lab=_81877_/Q }
C {devices/lab_pin.sym} 31230 -18710 0 1 {name=p30730 lab=_77507_/A }
C {sky130_stdcells/dfxtp_4.sym} 31140 -18700 0 0 {name=X_81845_ }
C {devices/lab_pin.sym} 31100 -18570 0 0 {name=p30731 lab=_69567_/A }
C {devices/lab_pin.sym} 31180 -18570 0 1 {name=p30732 lab=_69567_/X }
C {sky130_stdcells/buf_2.sym} 31140 -18570 0 0 {name=X_69567_ }
C {devices/lab_pin.sym} 31100 -18450 0 0 {name=p30733 lab=_54900_/A }
C {devices/lab_pin.sym} 31180 -18450 0 1 {name=p30734 lab=_54816_/B }
C {sky130_stdcells/buf_2.sym} 31140 -18450 0 0 {name=X_54793_ }
C {devices/lab_pin.sym} 31060 -18350 0 0 {name=p30735 lab=_66776_/X }
C {devices/lab_pin.sym} 31060 -18310 0 0 {name=p30736 lab=_66778_/X }
C {devices/lab_pin.sym} 31060 -18270 0 0 {name=p30737 lab=_66706_/X }
C {devices/lab_pin.sym} 31220 -18310 0 1 {name=p30738 lab=_66779_/Y }
C {sky130_stdcells/a21oi_4.sym} 31140 -18310 0 0 {name=X_66779_ }
C {devices/lab_pin.sym} 31060 -18190 0 0 {name=p30739 lab=_59260_/X }
C {devices/lab_pin.sym} 31060 -18150 0 0 {name=p30740 lab=_85415_/Q }
C {devices/lab_pin.sym} 31060 -18110 0 0 {name=p30741 lab=_59319_/X }
C {devices/lab_pin.sym} 31220 -18150 0 1 {name=p30742 lab=_59320_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -18150 0 0 {name=X_59320_ }
C {devices/lab_pin.sym} 31100 -18010 0 0 {name=p30743 lab=clkbuf_9_216_0_CLK/X }
C {devices/lab_pin.sym} 31180 -18010 0 1 {name=p30744 lab=_83498_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 31140 -18010 0 0 {name=Xclkbuf_10_433_0_CLK }
C {devices/lab_pin.sym} 31060 -17910 0 0 {name=p30745 lab=_56144_/X }
C {devices/lab_pin.sym} 31060 -17870 0 0 {name=p30746 lab=_56528_/X }
C {devices/lab_pin.sym} 31060 -17830 0 0 {name=p30747 lab=_56531_/Y }
C {devices/lab_pin.sym} 31220 -17870 0 1 {name=p30748 lab=_56532_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -17870 0 0 {name=X_56532_ }
C {devices/lab_pin.sym} 31080 -17740 0 0 {name=p30749 lab=_68437_/A }
C {devices/lab_pin.sym} 31080 -17700 0 0 {name=p30750 lab=_87341_/Q }
C {devices/lab_pin.sym} 31200 -17720 0 1 {name=p30751 lab=_68518_/X }
C {sky130_stdcells/and2_4.sym} 31140 -17720 0 0 {name=X_68518_ }
C {devices/lab_pin.sym} 31050 -17590 0 0 {name=p30752 lab=_81154_/CLK }
C {devices/lab_pin.sym} 31050 -17570 0 0 {name=p30753 lab=_87352_/D }
C {devices/lab_pin.sym} 31230 -17590 0 1 {name=p30754 lab=_87352_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -17580 0 0 {name=X_87352_ }
C {devices/lab_pin.sym} 31060 -17470 0 0 {name=p30755 lab=_53742_/Y }
C {devices/lab_pin.sym} 31060 -17430 0 0 {name=p30756 lab=_53715_/X }
C {devices/lab_pin.sym} 31060 -17390 0 0 {name=p30757 lab=_53743_/X }
C {devices/lab_pin.sym} 31220 -17430 0 1 {name=p30758 lab=_53744_/Y }
C {sky130_stdcells/a21oi_4.sym} 31140 -17430 0 0 {name=X_53744_ }
C {devices/lab_pin.sym} 31050 -17290 0 0 {name=p30759 lab=_84564_/CLK }
C {devices/lab_pin.sym} 31050 -17270 0 0 {name=p30760 lab=_84564_/D }
C {devices/lab_pin.sym} 31230 -17290 0 1 {name=p30761 lab=_78059_/A }
C {sky130_stdcells/dfxtp_4.sym} 31140 -17280 0 0 {name=X_84564_ }
C {devices/lab_pin.sym} 31060 -17170 0 0 {name=p30762 lab=_86100_/Q }
C {devices/lab_pin.sym} 31060 -17130 0 0 {name=p30763 lab=_50936_/X }
C {devices/lab_pin.sym} 31060 -17090 0 0 {name=p30764 lab=_50955_/Y }
C {devices/lab_pin.sym} 31220 -17130 0 1 {name=p30765 lab=_50956_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -17130 0 0 {name=X_50956_ }
C {devices/lab_pin.sym} 31060 -17020 0 0 {name=p30766 lab=_87013_/Q }
C {devices/lab_pin.sym} 31060 -16980 0 0 {name=p30767 lab=_69457_/X }
C {devices/lab_pin.sym} 31060 -16940 0 0 {name=p30768 lab=_69458_/X }
C {devices/lab_pin.sym} 31060 -16900 0 0 {name=p30769 lab=_69497_/X }
C {devices/lab_pin.sym} 31220 -16960 0 1 {name=p30770 lab=_69498_/X }
C {sky130_stdcells/a211o_4.sym} 31140 -16960 0 0 {name=X_69498_ }
C {devices/lab_pin.sym} 31050 -16810 0 0 {name=p30771 lab=_86753_/CLK }
C {devices/lab_pin.sym} 31050 -16790 0 0 {name=p30772 lab=_76074_/X }
C {devices/lab_pin.sym} 31230 -16810 0 1 {name=p30773 lab=_81776_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -16800 0 0 {name=X_81776_ }
C {devices/lab_pin.sym} 31050 -16670 0 0 {name=p30774 lab=_86303_/CLK }
C {devices/lab_pin.sym} 31050 -16650 0 0 {name=p30775 lab=_49900_/Y }
C {devices/lab_pin.sym} 31230 -16670 0 1 {name=p30776 lab=_72139_/B }
C {sky130_stdcells/dfxtp_4.sym} 31140 -16660 0 0 {name=X_86303_ }
C {devices/lab_pin.sym} 31060 -16550 0 0 {name=p30777 lab=_59248_/Y }
C {devices/lab_pin.sym} 31060 -16510 0 0 {name=p30778 lab=_59250_/Y }
C {devices/lab_pin.sym} 31060 -16470 0 0 {name=p30779 lab=_59140_/X }
C {devices/lab_pin.sym} 31220 -16510 0 1 {name=p30780 lab=_59251_/X }
C {sky130_stdcells/a21o_4.sym} 31140 -16510 0 0 {name=X_59251_ }
C {devices/lab_pin.sym} 31050 -16370 0 0 {name=p30781 lab=_83515_/CLK }
C {devices/lab_pin.sym} 31050 -16350 0 0 {name=p30782 lab=_71392_/X }
C {devices/lab_pin.sym} 31230 -16370 0 1 {name=p30783 lab=_83515_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -16360 0 0 {name=X_83515_ }
C {devices/lab_pin.sym} 31100 -16230 0 0 {name=p30784 lab=_56463_/A }
C {devices/lab_pin.sym} 31180 -16230 0 1 {name=p30785 lab=_56525_/A }
C {sky130_stdcells/buf_2.sym} 31140 -16230 0 0 {name=X_56463_ }
C {devices/lab_pin.sym} 31060 -16140 0 0 {name=p30786 lab=_88016_/Q }
C {devices/lab_pin.sym} 31060 -16100 0 0 {name=p30787 lab=_68402_/X }
C {devices/lab_pin.sym} 31060 -16060 0 0 {name=p30788 lab=_68359_/X }
C {devices/lab_pin.sym} 31060 -16020 0 0 {name=p30789 lab=_68448_/X }
C {devices/lab_pin.sym} 31220 -16080 0 1 {name=p30790 lab=_68449_/X }
C {sky130_stdcells/a211o_4.sym} 31140 -16080 0 0 {name=X_68449_ }
C {devices/lab_pin.sym} 31050 -15930 0 0 {name=p30791 lab=_80708_/CLK }
C {devices/lab_pin.sym} 31050 -15910 0 0 {name=p30792 lab=_75913_/X }
C {devices/lab_pin.sym} 31230 -15930 0 1 {name=p30793 lab=_80695_/D }
C {sky130_stdcells/dfxtp_4.sym} 31140 -15920 0 0 {name=X_80727_ }
C {devices/lab_pin.sym} 31050 -15790 0 0 {name=p30794 lab=_87285_/CLK }
C {devices/lab_pin.sym} 31050 -15770 0 0 {name=p30795 lab=_87283_/D }
C {devices/lab_pin.sym} 31230 -15790 0 1 {name=p30796 lab=_87283_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -15780 0 0 {name=X_87283_ }
C {devices/lab_pin.sym} 31060 -15670 0 0 {name=p30797 lab=_85590_/Q }
C {devices/lab_pin.sym} 31060 -15630 0 0 {name=p30798 lab=_53660_/X }
C {devices/lab_pin.sym} 31060 -15590 0 0 {name=p30799 lab=_53674_/Y }
C {devices/lab_pin.sym} 31220 -15630 0 1 {name=p30800 lab=_53675_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -15630 0 0 {name=X_53675_ }
C {devices/lab_pin.sym} 31050 -15490 0 0 {name=p30801 lab=_84649_/CLK }
C {devices/lab_pin.sym} 31050 -15470 0 0 {name=p30802 lab=_84495_/D }
C {devices/lab_pin.sym} 31230 -15490 0 1 {name=p30803 lab=_61262_/C }
C {sky130_stdcells/dfxtp_4.sym} 31140 -15480 0 0 {name=X_84495_ }
C {devices/lab_pin.sym} 31060 -15370 0 0 {name=p30804 lab=_50885_/Y }
C {devices/lab_pin.sym} 31060 -15330 0 0 {name=p30805 lab=_50839_/X }
C {devices/lab_pin.sym} 31060 -15290 0 0 {name=p30806 lab=_50886_/X }
C {devices/lab_pin.sym} 31220 -15330 0 1 {name=p30807 lab=_86113_/D }
C {sky130_stdcells/a21oi_4.sym} 31140 -15330 0 0 {name=X_50887_ }
C {devices/lab_pin.sym} 31080 -15200 0 0 {name=p30808 lab=_58201_/X }
C {devices/lab_pin.sym} 31080 -15160 0 0 {name=p30809 lab=_58184_/B }
C {devices/lab_pin.sym} 31200 -15180 0 1 {name=p30810 lab=_58202_/Y }
C {sky130_stdcells/nor2_4.sym} 31140 -15180 0 0 {name=X_58202_ }
C {devices/lab_pin.sym} 31080 -15060 0 0 {name=p30811 lab=_55411_/Y }
C {devices/lab_pin.sym} 31080 -15020 0 0 {name=p30812 lab=_55414_/B }
C {devices/lab_pin.sym} 31200 -15040 0 1 {name=p30813 lab=_55415_/C }
C {sky130_stdcells/and2_4.sym} 31140 -15040 0 0 {name=X_55414_ }
C {devices/lab_pin.sym} 31050 -14910 0 0 {name=p30814 lab=_86238_/CLK }
C {devices/lab_pin.sym} 31050 -14890 0 0 {name=p30815 lab=_50271_/Y }
C {devices/lab_pin.sym} 31230 -14910 0 1 {name=p30816 lab=_86234_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -14900 0 0 {name=X_86234_ }
C {devices/lab_pin.sym} 31100 -14770 0 0 {name=p30817 lab=_52626_/A }
C {devices/lab_pin.sym} 31180 -14770 0 1 {name=p30818 lab=_52643_/C }
C {sky130_stdcells/buf_2.sym} 31140 -14770 0 0 {name=X_52626_ }
C {devices/lab_pin.sym} 31060 -14670 0 0 {name=p30819 lab=_40577_/X }
C {devices/lab_pin.sym} 31060 -14630 0 0 {name=p30820 lab=_82872_/Q }
C {devices/lab_pin.sym} 31060 -14590 0 0 {name=p30821 lab=_40639_/X }
C {devices/lab_pin.sym} 31220 -14630 0 1 {name=p30822 lab=_40640_/X }
C {sky130_stdcells/o21a_4.sym} 31140 -14630 0 0 {name=X_40640_ }
C {devices/lab_pin.sym} 31080 -14510 0 0 {name=p30823 lab=_70692_/A }
C {devices/lab_pin.sym} 31080 -14470 0 0 {name=p30824 lab=_71446_/X }
C {devices/lab_pin.sym} 31080 -14430 0 0 {name=p30825 lab=_71458_/C }
C {devices/lab_pin.sym} 31200 -14470 0 1 {name=p30826 lab=_71460_/Y }
C {sky130_stdcells/nor3_4.sym} 31140 -14470 0 0 {name=X_71460_ }
C {devices/lab_pin.sym} 31100 -14330 0 0 {name=p30827 lab=_84762_/Q }
C {devices/lab_pin.sym} 31180 -14330 0 1 {name=p30828 lab=_59182_/Y }
C {sky130_stdcells/inv_2.sym} 31140 -14330 0 0 {name=X_59182_ }
C {devices/lab_pin.sym} 31050 -14210 0 0 {name=p30829 lab=_83480_/CLK }
C {devices/lab_pin.sym} 31050 -14190 0 0 {name=p30830 lab=_83446_/D }
C {devices/lab_pin.sym} 31230 -14210 0 1 {name=p30831 lab=_83446_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -14200 0 0 {name=X_83446_ }
C {sky130_stdcells/decap_3.sym} 31140 -14040 0 0 {name=XPHY_302 }
C {devices/lab_pin.sym} 31100 -13890 0 0 {name=p30832 lab=_56377_/X }
C {devices/lab_pin.sym} 31180 -13890 0 1 {name=p30833 lab=_56394_/X }
C {sky130_stdcells/buf_2.sym} 31140 -13890 0 0 {name=X_56394_ }
C {devices/lab_pin.sym} 31050 -13770 0 0 {name=p30834 lab=_80657_/CLK }
C {devices/lab_pin.sym} 31050 -13750 0 0 {name=p30835 lab=_80658_/D }
C {devices/lab_pin.sym} 31230 -13770 0 1 {name=p30836 lab=_46115_/A }
C {sky130_stdcells/dfxtp_4.sym} 31140 -13760 0 0 {name=X_80658_ }
C {sky130_stdcells/decap_3.sym} 31140 -13600 0 0 {name=XPHY_313 }
C {devices/lab_pin.sym} 31100 -13450 0 0 {name=p30837 lab=clkbuf_9_224_0_CLK/X }
C {devices/lab_pin.sym} 31180 -13450 0 1 {name=p30838 lab=_83711_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 31140 -13450 0 0 {name=Xclkbuf_10_448_0_CLK }
C {sky130_stdcells/decap_3.sym} 31140 -13300 0 0 {name=XPHY_324 }
C {devices/lab_pin.sym} 31100 -13150 0 0 {name=p30839 lab=_70410_/Y }
C {devices/lab_pin.sym} 31180 -13150 0 1 {name=p30840 lab=_71012_/A }
C {sky130_stdcells/buf_2.sym} 31140 -13150 0 0 {name=X_70411_ }
C {devices/lab_pin.sym} 31060 -13070 0 0 {name=p30841 lab=_57989_/X }
C {devices/lab_pin.sym} 31060 -13030 0 0 {name=p30842 lab=_58130_/Y }
C {devices/lab_pin.sym} 31060 -12990 0 0 {name=p30843 lab=_58132_/Y }
C {devices/lab_pin.sym} 31060 -12950 0 0 {name=p30844 lab=_58007_/X }
C {devices/lab_pin.sym} 31060 -12910 0 0 {name=p30845 lab=_57993_/X }
C {devices/lab_pin.sym} 31220 -12990 0 1 {name=p30846 lab=_58133_/X }
C {sky130_stdcells/o32a_4.sym} 31140 -12990 0 0 {name=X_58133_ }
C {sky130_stdcells/decap_3.sym} 31140 -12800 0 0 {name=XPHY_335 }
C {devices/lab_pin.sym} 31100 -12650 0 0 {name=p30847 lab=_57409_/A }
C {devices/lab_pin.sym} 31180 -12650 0 1 {name=p30848 lab=_55346_/B }
C {sky130_stdcells/inv_2.sym} 31140 -12650 0 0 {name=X_55345_ }
C {devices/lab_pin.sym} 31050 -12530 0 0 {name=p30849 lab=_85557_/CLK }
C {devices/lab_pin.sym} 31050 -12510 0 0 {name=p30850 lab=_86165_/D }
C {devices/lab_pin.sym} 31230 -12530 0 1 {name=p30851 lab=_86165_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -12520 0 0 {name=X_86165_ }
C {devices/lab_pin.sym} 31080 -12400 0 0 {name=p30852 lab=_40571_/A }
C {devices/lab_pin.sym} 31080 -12360 0 0 {name=p30853 lab=_48606_/A }
C {devices/lab_pin.sym} 31200 -12380 0 1 {name=p30854 lab=_40571_/X }
C {sky130_stdcells/or2_4.sym} 31140 -12380 0 0 {name=X_40571_ }
C {devices/lab_pin.sym} 31080 -12260 0 0 {name=p30855 lab=_52542_/X }
C {devices/lab_pin.sym} 31080 -12220 0 0 {name=p30856 lab=_54075_/B }
C {devices/lab_pin.sym} 31200 -12240 0 1 {name=p30857 lab=_52557_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -12240 0 0 {name=X_52557_ }
C {sky130_stdcells/decap_3.sym} 31140 -12080 0 0 {name=XPHY_346 }
C {devices/lab_pin.sym} 31080 -11950 0 0 {name=p30858 lab=_70689_/A }
C {devices/lab_pin.sym} 31080 -11910 0 0 {name=p30859 lab=_71386_/B }
C {devices/lab_pin.sym} 31080 -11870 0 0 {name=p30860 lab=_71399_/C }
C {devices/lab_pin.sym} 31200 -11910 0 1 {name=p30861 lab=_71391_/Y }
C {sky130_stdcells/nor3_4.sym} 31140 -11910 0 0 {name=X_71391_ }
C {devices/lab_pin.sym} 31050 -11770 0 0 {name=p30862 lab=_83372_/CLK }
C {devices/lab_pin.sym} 31050 -11750 0 0 {name=p30863 lab=_83377_/D }
C {devices/lab_pin.sym} 31230 -11770 0 1 {name=p30864 lab=_83377_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -11760 0 0 {name=X_83377_ }
C {sky130_stdcells/decap_3.sym} 31140 -11600 0 0 {name=XPHY_357 }
C {devices/lab_pin.sym} 31080 -11460 0 0 {name=p30865 lab=_80587_/X }
C {devices/lab_pin.sym} 31080 -11420 0 0 {name=p30866 lab=_80589_/B }
C {devices/lab_pin.sym} 31200 -11440 0 1 {name=p30867 lab=_80608_/B }
C {sky130_stdcells/xnor2_4.sym} 31140 -11440 0 0 {name=X_80589_ }
C {sky130_stdcells/decap_3.sym} 31140 -11280 0 0 {name=XPHY_368 }
C {devices/lab_pin.sym} 31060 -11160 0 0 {name=p30868 lab=_41601_/X }
C {devices/lab_pin.sym} 31060 -11120 0 0 {name=p30869 lab=_42303_/X }
C {devices/lab_pin.sym} 31060 -11080 0 0 {name=p30870 lab=_87928_/Q }
C {devices/lab_pin.sym} 31060 -11040 0 0 {name=p30871 lab=_42305_/X }
C {devices/lab_pin.sym} 31220 -11100 0 1 {name=p30872 lab=_87928_/D }
C {sky130_stdcells/a2bb2o_4.sym} 31140 -11100 0 0 {name=X_42310_ }
C {devices/lab_pin.sym} 31060 -10970 0 0 {name=p30873 lab=_69756_/B }
C {devices/lab_pin.sym} 31060 -10930 0 0 {name=p30874 lab=_73086_/X }
C {devices/lab_pin.sym} 31060 -10890 0 0 {name=p30875 lab=_73087_/X }
C {devices/lab_pin.sym} 31220 -10930 0 1 {name=p30876 lab=_73130_/X }
C {sky130_stdcells/o21a_4.sym} 31140 -10930 0 0 {name=X_73130_ }
C {sky130_stdcells/decap_3.sym} 31140 -10760 0 0 {name=XPHY_379 }
C {devices/lab_pin.sym} 31050 -10610 0 0 {name=p30877 lab=_85114_/CLK }
C {devices/lab_pin.sym} 31050 -10590 0 0 {name=p30878 lab=_85116_/D }
C {devices/lab_pin.sym} 31230 -10610 0 1 {name=p30879 lab=_85116_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -10600 0 0 {name=X_85116_ }
C {devices/lab_pin.sym} 31060 -10490 0 0 {name=p30880 lab=_85997_/Q }
C {devices/lab_pin.sym} 31060 -10450 0 0 {name=p30881 lab=_51485_/X }
C {devices/lab_pin.sym} 31060 -10410 0 0 {name=p30882 lab=_51507_/Y }
C {devices/lab_pin.sym} 31220 -10450 0 1 {name=p30883 lab=_51508_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -10450 0 0 {name=X_51508_ }
C {devices/lab_pin.sym} 31060 -10330 0 0 {name=p30884 lab=_58017_/X }
C {devices/lab_pin.sym} 31060 -10290 0 0 {name=p30885 lab=_85384_/Q }
C {devices/lab_pin.sym} 31060 -10250 0 0 {name=p30886 lab=_58063_/X }
C {devices/lab_pin.sym} 31220 -10290 0 1 {name=p30887 lab=_58064_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -10290 0 0 {name=X_58064_ }
C {devices/lab_pin.sym} 31080 -10180 0 0 {name=p30888 lab=_70338_/A }
C {devices/lab_pin.sym} 31080 -10140 0 0 {name=p30889 lab=_70333_/B }
C {devices/lab_pin.sym} 31080 -10100 0 0 {name=p30890 lab=_83086_/Q }
C {devices/lab_pin.sym} 31080 -10060 0 0 {name=p30891 lab=_70332_/X }
C {devices/lab_pin.sym} 31200 -10120 0 1 {name=p30892 lab=_70342_/X }
C {sky130_stdcells/and4_4.sym} 31140 -10120 0 0 {name=X_70342_ }
C {devices/lab_pin.sym} 31050 -9970 0 0 {name=p30893 lab=_82327_/CLK }
C {devices/lab_pin.sym} 31050 -9950 0 0 {name=p30894 lab=_77161_/B }
C {devices/lab_pin.sym} 31230 -9970 0 1 {name=p30895 lab=_82328_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -9960 0 0 {name=X_82328_ }
C {devices/lab_pin.sym} 31080 -9840 0 0 {name=p30896 lab=_55276_/A }
C {devices/lab_pin.sym} 31080 -9800 0 0 {name=p30897 lab=_84999_/Q }
C {devices/lab_pin.sym} 31200 -9820 0 1 {name=p30898 lab=_55276_/X }
C {sky130_stdcells/and2_4.sym} 31140 -9820 0 0 {name=X_55276_ }
C {devices/lab_pin.sym} 31060 -9720 0 0 {name=p30899 lab=_41169_/X }
C {devices/lab_pin.sym} 31060 -9680 0 0 {name=p30900 lab=_43287_/X }
C {devices/lab_pin.sym} 31060 -9640 0 0 {name=p30901 lab=_87496_/Q }
C {devices/lab_pin.sym} 31060 -9600 0 0 {name=p30902 lab=_43288_/X }
C {devices/lab_pin.sym} 31220 -9660 0 1 {name=p30903 lab=_87496_/D }
C {sky130_stdcells/a2bb2o_4.sym} 31140 -9660 0 0 {name=X_43290_ }
C {devices/lab_pin.sym} 31050 -9510 0 0 {name=p30904 lab=_86096_/CLK }
C {devices/lab_pin.sym} 31050 -9490 0 0 {name=p30905 lab=_86096_/D }
C {devices/lab_pin.sym} 31230 -9510 0 1 {name=p30906 lab=_86096_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -9500 0 0 {name=X_86096_ }
C {devices/lab_pin.sym} 31080 -9380 0 0 {name=p30907 lab=_52487_/X }
C {devices/lab_pin.sym} 31080 -9340 0 0 {name=p30908 lab=_46407_/X }
C {devices/lab_pin.sym} 31200 -9360 0 1 {name=p30909 lab=_52488_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -9360 0 0 {name=X_52488_ }
C {devices/lab_pin.sym} 31060 -9250 0 0 {name=p30910 lab=_57013_/X }
C {devices/lab_pin.sym} 31060 -9210 0 0 {name=p30911 lab=_57014_/Y }
C {devices/lab_pin.sym} 31060 -9170 0 0 {name=p30912 lab=_44213_/X }
C {devices/lab_pin.sym} 31220 -9210 0 1 {name=p30913 lab=_57015_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -9210 0 0 {name=X_57015_ }
C {devices/lab_pin.sym} 31100 -9070 0 0 {name=p30914 lab=_54254_/A }
C {devices/lab_pin.sym} 31180 -9070 0 1 {name=p30915 lab=_54237_/C }
C {sky130_stdcells/buf_2.sym} 31140 -9070 0 0 {name=X_54227_ }
C {devices/lab_pin.sym} 31100 -8950 0 0 {name=p30916 lab=_42241_/A }
C {devices/lab_pin.sym} 31180 -8950 0 1 {name=p30917 lab=_42241_/Y }
C {sky130_stdcells/inv_2.sym} 31140 -8950 0 0 {name=X_42241_ }
C {devices/lab_pin.sym} 31060 -8850 0 0 {name=p30918 lab=_44543_/Y }
C {devices/lab_pin.sym} 31060 -8810 0 0 {name=p30919 lab=_73006_/X }
C {devices/lab_pin.sym} 31060 -8770 0 0 {name=p30920 lab=_73060_/Y }
C {devices/lab_pin.sym} 31220 -8810 0 1 {name=p30921 lab=_73075_/C }
C {sky130_stdcells/a21o_4.sym} 31140 -8810 0 0 {name=X_73061_ }
C {devices/lab_pin.sym} 31050 -8670 0 0 {name=p30922 lab=_85013_/CLK }
C {devices/lab_pin.sym} 31050 -8650 0 0 {name=p30923 lab=_57258_/Y }
C {devices/lab_pin.sym} 31230 -8670 0 1 {name=p30924 lab=_45553_/A }
C {sky130_stdcells/dfxtp_4.sym} 31140 -8660 0 0 {name=X_85047_ }
C {devices/lab_pin.sym} 31060 -8550 0 0 {name=p30925 lab=_51436_/Y }
C {devices/lab_pin.sym} 31060 -8510 0 0 {name=p30926 lab=_51420_/X }
C {devices/lab_pin.sym} 31060 -8470 0 0 {name=p30927 lab=_51438_/X }
C {devices/lab_pin.sym} 31220 -8510 0 1 {name=p30928 lab=_86010_/D }
C {sky130_stdcells/a21oi_4.sym} 31140 -8510 0 0 {name=X_51439_ }
C {devices/lab_pin.sym} 31050 -8370 0 0 {name=p30929 lab=_84223_/CLK }
C {devices/lab_pin.sym} 31050 -8350 0 0 {name=p30930 lab=_82259_/D }
C {devices/lab_pin.sym} 31230 -8370 0 1 {name=p30931 lab=_82259_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -8360 0 0 {name=X_82259_ }
C {devices/lab_pin.sym} 31080 -8260 0 0 {name=p30932 lab=_70273_/A }
C {devices/lab_pin.sym} 31080 -8220 0 0 {name=p30933 lab=_70160_/X }
C {devices/lab_pin.sym} 31080 -8180 0 0 {name=p30934 lab=_70162_/X }
C {devices/lab_pin.sym} 31080 -8140 0 0 {name=p30935 lab=_70164_/X }
C {devices/lab_pin.sym} 31200 -8200 0 1 {name=p30936 lab=_70273_/Y }
C {sky130_stdcells/nand4_4.sym} 31140 -8200 0 0 {name=X_70273_ }
C {devices/lab_pin.sym} 31080 -8060 0 0 {name=p30937 lab=_72007_/A }
C {devices/lab_pin.sym} 31080 -8020 0 0 {name=p30938 lab=_72012_/B }
C {devices/lab_pin.sym} 31200 -8040 0 1 {name=p30939 lab=_72012_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -8040 0 0 {name=X_72012_ }
C {devices/lab_pin.sym} 31100 -7910 0 0 {name=p30940 lab=_42172_/A }
C {devices/lab_pin.sym} 31180 -7910 0 1 {name=p30941 lab=_42172_/Y }
C {sky130_stdcells/inv_2.sym} 31140 -7910 0 0 {name=X_42172_ }
C {devices/lab_pin.sym} 31080 -7800 0 0 {name=p30942 lab=_54149_/A }
C {devices/lab_pin.sym} 31080 -7760 0 0 {name=p30943 lab=_47334_/Y }
C {devices/lab_pin.sym} 31200 -7780 0 1 {name=p30944 lab=_54158_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -7780 0 0 {name=X_54158_ }
C {devices/lab_pin.sym} 31080 -7660 0 0 {name=p30945 lab=_81727_/Q }
C {devices/lab_pin.sym} 31080 -7620 0 0 {name=p30946 lab=_41079_/X }
C {devices/lab_pin.sym} 31200 -7640 0 1 {name=p30947 lab=_41123_/X }
C {sky130_stdcells/or2_4.sym} 31140 -7640 0 0 {name=X_41123_ }
C {devices/lab_pin.sym} 31080 -7520 0 0 {name=p30948 lab=_53115_/A }
C {devices/lab_pin.sym} 31080 -7480 0 0 {name=p30949 lab=_53109_/B }
C {devices/lab_pin.sym} 31200 -7500 0 1 {name=p30950 lab=_53109_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -7500 0 0 {name=X_53109_ }
C {devices/lab_pin.sym} 31100 -7370 0 0 {name=p30951 lab=_81493_/Q }
C {devices/lab_pin.sym} 31180 -7370 0 1 {name=p30952 lab=_76822_/A }
C {sky130_stdcells/inv_2.sym} 31140 -7370 0 0 {name=X_76820_ }
C {devices/lab_pin.sym} 31100 -7250 0 0 {name=p30953 lab=_46979_/Y }
C {devices/lab_pin.sym} 31180 -7250 0 1 {name=p30954 lab=_52785_/D }
C {sky130_stdcells/buf_2.sym} 31140 -7250 0 0 {name=X_46980_ }
C {devices/lab_pin.sym} 31100 -7130 0 0 {name=p30955 lab=_59053_/A }
C {devices/lab_pin.sym} 31180 -7130 0 1 {name=p30956 lab=_58966_/X }
C {sky130_stdcells/buf_2.sym} 31140 -7130 0 0 {name=X_58966_ }
C {devices/lab_pin.sym} 31080 -7020 0 0 {name=p30957 lab=_54037_/A }
C {devices/lab_pin.sym} 31080 -6980 0 0 {name=p30958 lab=_52571_/B }
C {devices/lab_pin.sym} 31200 -7000 0 1 {name=p30959 lab=_54089_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -7000 0 0 {name=X_54089_ }
C {devices/lab_pin.sym} 31050 -6870 0 0 {name=p30960 lab=_86998_/CLK }
C {devices/lab_pin.sym} 31050 -6850 0 0 {name=p30961 lab=_44694_/Y }
C {devices/lab_pin.sym} 31230 -6870 0 1 {name=p30962 lab=_86998_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -6860 0 0 {name=X_86998_ }
C {devices/lab_pin.sym} 31100 -6730 0 0 {name=p30963 lab=_72908_/A }
C {devices/lab_pin.sym} 31180 -6730 0 1 {name=p30964 lab=_45931_/X }
C {sky130_stdcells/buf_2.sym} 31140 -6730 0 0 {name=X_45931_ }
C {devices/lab_pin.sym} 31100 -6610 0 0 {name=p30965 lab=_41053_/X }
C {devices/lab_pin.sym} 31180 -6610 0 1 {name=p30966 lab=_41054_/X }
C {sky130_stdcells/buf_2.sym} 31140 -6610 0 0 {name=X_41054_ }
C {devices/lab_pin.sym} 31060 -6510 0 0 {name=p30967 lab=_57914_/Y }
C {devices/lab_pin.sym} 31060 -6470 0 0 {name=p30968 lab=_57916_/Y }
C {devices/lab_pin.sym} 31060 -6430 0 0 {name=p30969 lab=_57889_/X }
C {devices/lab_pin.sym} 31220 -6470 0 1 {name=p30970 lab=_57917_/X }
C {sky130_stdcells/a21o_4.sym} 31140 -6470 0 0 {name=X_57917_ }
C {devices/lab_pin.sym} 31060 -6350 0 0 {name=p30971 lab=_76734_/A }
C {devices/lab_pin.sym} 31060 -6310 0 0 {name=p30972 lab=_76749_/Y }
C {devices/lab_pin.sym} 31060 -6270 0 0 {name=p30973 lab=_76750_/Y }
C {devices/lab_pin.sym} 31220 -6310 0 1 {name=p30974 lab=_76751_/Y }
C {sky130_stdcells/a21oi_4.sym} 31140 -6310 0 0 {name=X_76751_ }
C {devices/lab_pin.sym} 31050 -6170 0 0 {name=p30975 lab=_82394_/CLK }
C {devices/lab_pin.sym} 31050 -6150 0 0 {name=p30976 lab=_51773_/Y }
C {devices/lab_pin.sym} 31230 -6170 0 1 {name=p30977 lab=_85949_/Q }
C {sky130_stdcells/dfxtp_4.sym} 31140 -6160 0 0 {name=X_85949_ }
C {devices/lab_pin.sym} 31080 -6040 0 0 {name=p30978 lab=_73963_/A }
C {devices/lab_pin.sym} 31080 -6000 0 0 {name=p30979 lab=_73869_/X }
C {devices/lab_pin.sym} 31200 -6020 0 1 {name=p30980 lab=_73963_/Y }
C {sky130_stdcells/nor2_4.sym} 31140 -6020 0 0 {name=X_73963_ }
C {devices/lab_pin.sym} 31100 -5890 0 0 {name=p30981 lab=_58897_/A }
C {devices/lab_pin.sym} 31180 -5890 0 1 {name=p30982 lab=_58898_/B }
C {sky130_stdcells/buf_2.sym} 31140 -5890 0 0 {name=X_58897_ }
C {devices/lab_pin.sym} 31060 -5790 0 0 {name=p30983 lab=_75687_/A }
C {devices/lab_pin.sym} 31060 -5750 0 0 {name=p30984 lab=_80783_/D }
C {devices/lab_pin.sym} 31060 -5710 0 0 {name=p30985 lab=_75701_/X }
C {devices/lab_pin.sym} 31220 -5750 0 1 {name=p30986 lab=_75702_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -5750 0 0 {name=X_75702_ }
C {devices/lab_pin.sym} 31060 -5630 0 0 {name=p30987 lab=_86503_/Q }
C {devices/lab_pin.sym} 31060 -5590 0 0 {name=p30988 lab=_48612_/X }
C {devices/lab_pin.sym} 31060 -5550 0 0 {name=p30989 lab=_48649_/Y }
C {devices/lab_pin.sym} 31220 -5590 0 1 {name=p30990 lab=_48650_/Y }
C {sky130_stdcells/o21ai_4.sym} 31140 -5590 0 0 {name=X_48650_ }
C {devices/lab_pin.sym} 31080 -5460 0 0 {name=p30991 lab=_72881_/A }
C {devices/lab_pin.sym} 31080 -5420 0 0 {name=p30992 lab=_86524_/Q }
C {devices/lab_pin.sym} 31200 -5440 0 1 {name=p30993 lab=_72914_/X }
C {sky130_stdcells/and2_4.sym} 31140 -5440 0 0 {name=X_72914_ }
C {devices/lab_pin.sym} 31080 -5320 0 0 {name=p30994 lab=_79470_/A }
C {devices/lab_pin.sym} 31080 -5280 0 0 {name=p30995 lab=_79470_/B }
C {devices/lab_pin.sym} 31200 -5300 0 1 {name=p30996 lab=_79470_/X }
C {sky130_stdcells/or2_4.sym} 31140 -5300 0 0 {name=X_79470_ }
C {devices/lab_pin.sym} 31080 -5180 0 0 {name=p30997 lab=_74702_/B }
C {devices/lab_pin.sym} 31080 -5140 0 0 {name=p30998 lab=_45832_/B }
C {devices/lab_pin.sym} 31200 -5160 0 1 {name=p30999 lab=_45862_/Y }
C {sky130_stdcells/nand2_4.sym} 31140 -5160 0 0 {name=X_45862_ }
C {devices/lab_pin.sym} 31100 -5030 0 0 {name=p31000 lab=_57848_/A }
C {devices/lab_pin.sym} 31180 -5030 0 1 {name=p31001 lab=_58679_/A }
C {sky130_stdcells/buf_2.sym} 31140 -5030 0 0 {name=X_57848_ }
C {devices/lab_pin.sym} 31080 -4920 0 0 {name=p31002 lab=_76682_/A }
C {devices/lab_pin.sym} 31080 -4880 0 0 {name=p31003 lab=_81445_/D }
C {devices/lab_pin.sym} 31200 -4900 0 1 {name=p31004 lab=_76682_/X }
C {sky130_stdcells/xor2_4.sym} 31140 -4900 0 0 {name=X_76682_ }
C {devices/lab_pin.sym} 31100 -4770 0 0 {name=p31005 lab=_72979_/X }
C {devices/lab_pin.sym} 31180 -4770 0 1 {name=p31006 lab=_73894_/X }
C {sky130_stdcells/buf_2.sym} 31140 -4770 0 0 {name=X_73894_ }
C {devices/lab_pin.sym} 31100 -4650 0 0 {name=p31007 lab=clkbuf_9_506_0_CLK/A }
C {devices/lab_pin.sym} 31180 -4650 0 1 {name=p31008 lab=clkbuf_9_507_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 31140 -4650 0 0 {name=Xclkbuf_9_507_0_CLK }
C {devices/lab_pin.sym} 31100 -4530 0 0 {name=p31009 lab=_47363_/A }
C {devices/lab_pin.sym} 31180 -4530 0 1 {name=p31010 lab=_47745_/A }
C {sky130_stdcells/buf_2.sym} 31140 -4530 0 0 {name=X_47601_ }
C {devices/lab_pin.sym} 31100 -4410 0 0 {name=p31011 lab=_78420_/X }
C {devices/lab_pin.sym} 31180 -4410 0 1 {name=p31012 lab=_78421_/Y }
C {sky130_stdcells/inv_2.sym} 31140 -4410 0 0 {name=X_78421_ }
C {devices/lab_pin.sym} 31060 -4320 0 0 {name=p31013 lab=_41646_/Y }
C {devices/lab_pin.sym} 31060 -4280 0 0 {name=p31014 lab=_43939_/X }
C {devices/lab_pin.sym} 31060 -4240 0 0 {name=p31015 lab=_67417_/B }
C {devices/lab_pin.sym} 31060 -4200 0 0 {name=p31016 lab=_43941_/X }
C {devices/lab_pin.sym} 31220 -4260 0 1 {name=p31017 lab=_44813_/X }
C {sky130_stdcells/a2bb2o_4.sym} 31140 -4260 0 0 {name=X_44813_ }
C {devices/lab_pin.sym} 31080 -4120 0 0 {name=p31018 lab=_75631_/X }
C {devices/lab_pin.sym} 31080 -4080 0 0 {name=p31019 lab=_75633_/B }
C {devices/lab_pin.sym} 31200 -4100 0 1 {name=p31020 lab=_75633_/Y }
C {sky130_stdcells/nor2_4.sym} 31140 -4100 0 0 {name=X_75633_ }
C {devices/lab_pin.sym} 31050 -3970 0 0 {name=p31021 lab=_88387_/CLK }
C {devices/lab_pin.sym} 31050 -3950 0 0 {name=p31022 lab=_87619_/D }
C {devices/lab_pin.sym} 31230 -3970 0 1 {name=p31023 lab=_66948_/B }
C {sky130_stdcells/dfxtp_4.sym} 31140 -3960 0 0 {name=X_87619_ }
C {devices/lab_pin.sym} 31100 -3830 0 0 {name=p31024 lab=_48581_/A }
C {devices/lab_pin.sym} 31180 -3830 0 1 {name=p31025 lab=_48582_/A }
C {sky130_stdcells/inv_2.sym} 31140 -3830 0 0 {name=X_48581_ }
C {devices/lab_pin.sym} 31080 -3720 0 0 {name=p31026 lab=_72845_/A }
C {devices/lab_pin.sym} 31080 -3680 0 0 {name=p31027 lab=_72844_/X }
C {devices/lab_pin.sym} 31200 -3700 0 1 {name=p31028 lab=_72846_/B }
C {sky130_stdcells/nand2_4.sym} 31140 -3700 0 0 {name=X_72845_ }
C {devices/lab_pin.sym} 31080 -3580 0 0 {name=p31029 lab=_57058_/B }
C {devices/lab_pin.sym} 31080 -3540 0 0 {name=p31030 lab=_45793_/B }
C {devices/lab_pin.sym} 31200 -3560 0 1 {name=p31031 lab=_45793_/Y }
C {sky130_stdcells/nor2_4.sym} 31140 -3560 0 0 {name=X_45793_ }
C {devices/lab_pin.sym} 31100 -3430 0 0 {name=p31032 lab=_72201_/A }
C {devices/lab_pin.sym} 31180 -3430 0 1 {name=p31033 lab=_57779_/X }
C {sky130_stdcells/buf_2.sym} 31140 -3430 0 0 {name=X_57779_ }
C {devices/lab_pin.sym} 31100 -3310 0 0 {name=p31034 lab=_47532_/A }
C {devices/lab_pin.sym} 31180 -3310 0 1 {name=p31035 lab=_53103_/D }
C {sky130_stdcells/buf_2.sym} 31140 -3310 0 0 {name=X_47532_ }
C {devices/lab_pin.sym} 31100 -3190 0 0 {name=p31036 lab=_59517_/Y }
C {devices/lab_pin.sym} 31180 -3190 0 1 {name=p31037 lab=_59519_/C }
C {sky130_stdcells/inv_2.sym} 31140 -3190 0 0 {name=X_59518_ }
C {devices/lab_pin.sym} 31100 -3070 0 0 {name=p31038 lab=clkbuf_8_61_0_CLK/A }
C {devices/lab_pin.sym} 31180 -3070 0 1 {name=p31039 lab=clkbuf_8_60_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 31140 -3070 0 0 {name=Xclkbuf_8_60_0_CLK }
C {devices/lab_pin.sym} 31060 -2970 0 0 {name=p31040 lab=_78353_/C }
C {devices/lab_pin.sym} 31060 -2930 0 0 {name=p31041 lab=_78353_/B }
C {devices/lab_pin.sym} 31060 -2890 0 0 {name=p31042 lab=_78353_/A }
C {devices/lab_pin.sym} 31220 -2930 0 1 {name=p31043 lab=_78352_/X }
C {sky130_stdcells/a21o_4.sym} 31140 -2930 0 0 {name=X_78352_ }
C {devices/lab_pin.sym} 31100 -2790 0 0 {name=p31044 lab=_44744_/A }
C {devices/lab_pin.sym} 31180 -2790 0 1 {name=p31045 lab=_44744_/Y }
C {sky130_stdcells/inv_2.sym} 31140 -2790 0 0 {name=X_44744_ }
C {devices/lab_pin.sym} 31100 -2670 0 0 {name=p31046 lab=_80801_/Q }
C {devices/lab_pin.sym} 31180 -2670 0 1 {name=p31047 lab=_75564_/Y }
C {sky130_stdcells/inv_2.sym} 31140 -2670 0 0 {name=X_75564_ }
C {devices/lab_pin.sym} 31100 -2550 0 0 {name=p31048 lab=_42477_/A }
C {devices/lab_pin.sym} 31180 -2550 0 1 {name=p31049 lab=_41956_/X }
C {sky130_stdcells/buf_2.sym} 31140 -2550 0 0 {name=X_41956_ }
C {devices/lab_pin.sym} 31060 -2470 0 0 {name=p31050 lab=_61075_/B }
C {devices/lab_pin.sym} 31060 -2430 0 0 {name=p31051 lab=_60782_/Y }
C {devices/lab_pin.sym} 31060 -2390 0 0 {name=p31052 lab=_60403_/C }
C {devices/lab_pin.sym} 31060 -2350 0 0 {name=p31053 lab=_60697_/Y }
C {devices/lab_pin.sym} 31060 -2320 0 0 {name=p31054 lab=_60789_/Y }
C {devices/lab_pin.sym} 31220 -2390 0 1 {name=p31055 lab=_84567_/D }
C {sky130_stdcells/a41oi_4.sym} 31140 -2390 0 0 {name=X_60790_ }
C {devices/lab_pin.sym} 31100 -2230 0 0 {name=p31056 lab=_73007_/A }
C {devices/lab_pin.sym} 31180 -2230 0 1 {name=p31057 lab=_72776_/X }
C {sky130_stdcells/buf_2.sym} 31140 -2230 0 0 {name=X_72776_ }
C {devices/lab_pin.sym} 31080 -2120 0 0 {name=p31058 lab=_77318_/B }
C {devices/lab_pin.sym} 31080 -2080 0 0 {name=p31059 lab=_77302_/Y }
C {devices/lab_pin.sym} 31200 -2100 0 1 {name=p31060 lab=_82183_/D }
C {sky130_stdcells/xor2_4.sym} 31140 -2100 0 0 {name=X_77303_ }
C {devices/lab_pin.sym} 31080 -1990 0 0 {name=p31061 lab=_70506_/A }
C {devices/lab_pin.sym} 31080 -1950 0 0 {name=p31062 lab=_70701_/A }
C {devices/lab_pin.sym} 31080 -1910 0 0 {name=p31063 lab=_74515_/C }
C {devices/lab_pin.sym} 31200 -1950 0 1 {name=p31064 lab=_74515_/X }
C {sky130_stdcells/and3_4.sym} 31140 -1950 0 0 {name=X_74515_ }
C {devices/lab_pin.sym} 31080 -1820 0 0 {name=p31065 lab=_82854_/Q }
C {devices/lab_pin.sym} 31080 -1780 0 0 {name=p31066 lab=_40907_/B }
C {devices/lab_pin.sym} 31200 -1800 0 1 {name=p31067 lab=_40907_/X }
C {sky130_stdcells/or2_4.sym} 31140 -1800 0 0 {name=X_40907_ }
C {devices/lab_pin.sym} 31100 -1670 0 0 {name=p31068 lab=_47556_/A }
C {devices/lab_pin.sym} 31180 -1670 0 1 {name=p31069 lab=_47463_/X }
C {sky130_stdcells/buf_2.sym} 31140 -1670 0 0 {name=X_47463_ }
C {devices/lab_pin.sym} 31080 -1570 0 0 {name=p31070 lab=_71729_/A }
C {devices/lab_pin.sym} 31080 -1530 0 0 {name=p31071 lab=_71680_/C }
C {devices/lab_pin.sym} 31080 -1490 0 0 {name=p31072 lab=_71724_/X }
C {devices/lab_pin.sym} 31200 -1530 0 1 {name=p31073 lab=_71727_/Y }
C {sky130_stdcells/nand3_4.sym} 31140 -1530 0 0 {name=X_71727_ }
C {devices/lab_pin.sym} 31060 -1410 0 0 {name=p31074 lab=_59442_/X }
C {devices/lab_pin.sym} 31060 -1370 0 0 {name=p31075 lab=_83338_/Q }
C {devices/lab_pin.sym} 31060 -1330 0 0 {name=p31076 lab=_59448_/Y }
C {devices/lab_pin.sym} 31220 -1370 0 1 {name=p31077 lab=_59449_/X }
C {sky130_stdcells/o21a_4.sym} 31140 -1370 0 0 {name=X_59449_ }
C {devices/lab_pin.sym} 31080 -1250 0 0 {name=p31078 lab=_78274_/A }
C {devices/lab_pin.sym} 31080 -1210 0 0 {name=p31079 lab=_78262_/A }
C {devices/lab_pin.sym} 31080 -1170 0 0 {name=p31080 lab=_78262_/B }
C {devices/lab_pin.sym} 31200 -1210 0 1 {name=p31081 lab=_78283_/Y }
C {sky130_stdcells/nand3_4.sym} 31140 -1210 0 0 {name=X_78283_ }
C {devices/lab_pin.sym} 31100 -1070 0 0 {name=p31082 lab=_44675_/A }
C {devices/lab_pin.sym} 31180 -1070 0 1 {name=p31083 lab=_44675_/Y }
C {sky130_stdcells/inv_2.sym} 31140 -1070 0 0 {name=X_44675_ }
C {devices/lab_pin.sym} 31080 -960 0 0 {name=p31084 lab=_80702_/Q }
C {devices/lab_pin.sym} 31080 -920 0 0 {name=p31085 lab=_80958_/D }
C {devices/lab_pin.sym} 31200 -940 0 1 {name=p31086 lab=_75495_/Y }
C {sky130_stdcells/nor2_4.sym} 31140 -940 0 0 {name=X_75495_ }
C {devices/lab_pin.sym} 31100 -810 0 0 {name=p31087 lab=_41887_/A }
C {devices/lab_pin.sym} 31180 -810 0 1 {name=p31088 lab=_41887_/X }
C {sky130_stdcells/buf_2.sym} 31140 -810 0 0 {name=X_41887_ }
C {devices/lab_pin.sym} 31080 -710 0 0 {name=p31089 lab=_50209_/A }
C {devices/lab_pin.sym} 31080 -670 0 0 {name=p31090 lab=_49113_/B }
C {devices/lab_pin.sym} 31080 -630 0 0 {name=p31091 lab=_49091_/C }
C {devices/lab_pin.sym} 31200 -670 0 1 {name=p31092 lab=_49202_/X }
C {sky130_stdcells/and3_4.sym} 31140 -670 0 0 {name=X_49202_ }
C {devices/lab_pin.sym} 32000 -42160 0 0 {name=p31093 lab=_82931_/Q }
C {devices/lab_pin.sym} 32000 -42120 0 0 {name=p31094 lab=_46459_/B }
C {devices/lab_pin.sym} 32120 -42140 0 1 {name=p31095 lab=_46414_/X }
C {sky130_stdcells/or2_4.sym} 32060 -42140 0 0 {name=X_46414_ }
C {devices/lab_pin.sym} 32000 -42020 0 0 {name=p31096 lab=_77234_/A }
C {devices/lab_pin.sym} 32000 -41980 0 0 {name=p31097 lab=_77233_/X }
C {devices/lab_pin.sym} 32120 -42000 0 1 {name=p31098 lab=_82178_/D }
C {sky130_stdcells/xor2_4.sym} 32060 -42000 0 0 {name=X_77234_ }
C {devices/lab_pin.sym} 31980 -41900 0 0 {name=p31099 lab=_40650_/X }
C {devices/lab_pin.sym} 31980 -41860 0 0 {name=p31100 lab=_43624_/X }
C {devices/lab_pin.sym} 31980 -41820 0 0 {name=p31101 lab=_73822_/A }
C {devices/lab_pin.sym} 31980 -41780 0 0 {name=p31102 lab=_43625_/X }
C {devices/lab_pin.sym} 32140 -41840 0 1 {name=p31103 lab=_43626_/X }
C {sky130_stdcells/a2bb2o_4.sym} 32060 -41840 0 0 {name=X_43626_ }
C {devices/lab_pin.sym} 31980 -41710 0 0 {name=p31104 lab=_74444_/Y }
C {devices/lab_pin.sym} 31980 -41670 0 0 {name=p31105 lab=_74430_/X }
C {devices/lab_pin.sym} 31980 -41630 0 0 {name=p31106 lab=_74445_/X }
C {devices/lab_pin.sym} 32140 -41670 0 1 {name=p31107 lab=_74446_/Y }
C {sky130_stdcells/a21oi_4.sym} 32060 -41670 0 0 {name=X_74446_ }
C {devices/lab_pin.sym} 32000 -41560 0 0 {name=p31108 lab=_61541_/B }
C {devices/lab_pin.sym} 32000 -41520 0 0 {name=p31109 lab=_62492_/B }
C {devices/lab_pin.sym} 32000 -41480 0 0 {name=p31110 lab=_62449_/X }
C {devices/lab_pin.sym} 32000 -41440 0 0 {name=p31111 lab=_62404_/X }
C {devices/lab_pin.sym} 32120 -41500 0 1 {name=p31112 lab=_62461_/D }
C {sky130_stdcells/nand4_4.sym} 32060 -41500 0 0 {name=X_62460_ }
C {devices/lab_pin.sym} 31980 -41370 0 0 {name=p31113 lab=_40783_/X }
C {devices/lab_pin.sym} 31980 -41330 0 0 {name=p31114 lab=_41014_/A }
C {devices/lab_pin.sym} 31980 -41290 0 0 {name=p31115 lab=_40837_/X }
C {devices/lab_pin.sym} 32140 -41330 0 1 {name=p31116 lab=_40839_/A }
C {sky130_stdcells/o21a_4.sym} 32060 -41330 0 0 {name=X_40838_ }
C {devices/lab_pin.sym} 32020 -41190 0 0 {name=p31117 lab=_83735_/Q }
C {devices/lab_pin.sym} 32100 -41190 0 1 {name=p31118 lab=_47394_/Y }
C {sky130_stdcells/inv_2.sym} 32060 -41190 0 0 {name=X_47394_ }
C {devices/lab_pin.sym} 32000 -41090 0 0 {name=p31119 lab=_71660_/A }
C {devices/lab_pin.sym} 32000 -41050 0 0 {name=p31120 lab=_71226_/B }
C {devices/lab_pin.sym} 32000 -41010 0 0 {name=p31121 lab=_71660_/C }
C {devices/lab_pin.sym} 32120 -41050 0 1 {name=p31122 lab=_71658_/Y }
C {sky130_stdcells/nand3_4.sym} 32060 -41050 0 0 {name=X_71658_ }
C {devices/lab_pin.sym} 32020 -40910 0 0 {name=p31123 lab=clkbuf_8_75_0_CLK/A }
C {devices/lab_pin.sym} 32100 -40910 0 1 {name=p31124 lab=clkbuf_8_75_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 32060 -40910 0 0 {name=Xclkbuf_8_75_0_CLK }
C {devices/lab_pin.sym} 31980 -40810 0 0 {name=p31125 lab=_49127_/Y }
C {devices/lab_pin.sym} 31980 -40770 0 0 {name=p31126 lab=_49086_/X }
C {devices/lab_pin.sym} 31980 -40730 0 0 {name=p31127 lab=_49132_/X }
C {devices/lab_pin.sym} 32140 -40770 0 1 {name=p31128 lab=_49133_/Y }
C {sky130_stdcells/a21oi_4.sym} 32060 -40770 0 0 {name=X_49133_ }
C {devices/lab_pin.sym} 31980 -40670 0 0 {name=p31129 lab=_61398_/Y }
C {devices/lab_pin.sym} 31980 -40630 0 0 {name=p31130 lab=_61402_/Y }
C {devices/lab_pin.sym} 31980 -40590 0 0 {name=p31131 lab=_61403_/X }
C {devices/lab_pin.sym} 31980 -40550 0 0 {name=p31132 lab=_61406_/Y }
C {devices/lab_pin.sym} 31980 -40520 0 0 {name=p31133 lab=_61410_/Y }
C {devices/lab_pin.sym} 32140 -40590 0 1 {name=p31134 lab=_61411_/X }
C {sky130_stdcells/a41o_4.sym} 32060 -40590 0 0 {name=X_61411_ }
C {devices/lab_pin.sym} 31980 -40450 0 0 {name=p31135 lab=_86745_/Q }
C {devices/lab_pin.sym} 31980 -40410 0 0 {name=p31136 lab=_46279_/X }
C {devices/lab_pin.sym} 31980 -40370 0 0 {name=p31137 lab=_46344_/Y }
C {devices/lab_pin.sym} 32140 -40410 0 1 {name=p31138 lab=_46345_/Y }
C {sky130_stdcells/o21ai_4.sym} 32060 -40410 0 0 {name=X_46345_ }
C {devices/lab_pin.sym} 32020 -40270 0 0 {name=p31139 lab=_70609_/A }
C {devices/lab_pin.sym} 32100 -40270 0 1 {name=p31140 lab=_70627_/A }
C {sky130_stdcells/buf_2.sym} 32060 -40270 0 0 {name=X_70609_ }
C {devices/lab_pin.sym} 31980 -40170 0 0 {name=p31141 lab=_77159_/A }
C {devices/lab_pin.sym} 31980 -40130 0 0 {name=p31142 lab=_77159_/B }
C {devices/lab_pin.sym} 31980 -40090 0 0 {name=p31143 lab=_77173_/A }
C {devices/lab_pin.sym} 32140 -40130 0 1 {name=p31144 lab=_77165_/Y }
C {sky130_stdcells/a21boi_4.sym} 32060 -40130 0 0 {name=X_77165_ }
C {devices/lab_pin.sym} 32020 -39990 0 0 {name=p31145 lab=_40363_/X }
C {devices/lab_pin.sym} 32100 -39990 0 1 {name=p31146 lab=_43557_/X }
C {sky130_stdcells/buf_2.sym} 32060 -39990 0 0 {name=X_43557_ }
C {devices/lab_pin.sym} 32020 -39870 0 0 {name=p31147 lab=_62463_/A }
C {devices/lab_pin.sym} 32100 -39870 0 1 {name=p31148 lab=_62392_/D }
C {sky130_stdcells/buf_2.sym} 32060 -39870 0 0 {name=X_62391_ }
C {devices/lab_pin.sym} 32020 -39750 0 0 {name=p31149 lab=_72001_/A }
C {devices/lab_pin.sym} 32100 -39750 0 1 {name=p31150 lab=_74377_/X }
C {sky130_stdcells/buf_2.sym} 32060 -39750 0 0 {name=X_74377_ }
C {devices/lab_pin.sym} 32020 -39630 0 0 {name=p31151 lab=clkbuf_7_6_0_CLK/A }
C {devices/lab_pin.sym} 32100 -39630 0 1 {name=p31152 lab=clkbuf_7_7_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 32060 -39630 0 0 {name=Xclkbuf_7_7_0_CLK }
C {devices/lab_pin.sym} 32000 -39520 0 0 {name=p31153 lab=_82880_/Q }
C {devices/lab_pin.sym} 32000 -39480 0 0 {name=p31154 lab=_40765_/B }
C {devices/lab_pin.sym} 32120 -39500 0 1 {name=p31155 lab=_40769_/X }
C {sky130_stdcells/or2_4.sym} 32060 -39500 0 0 {name=X_40769_ }
C {devices/lab_pin.sym} 31980 -39390 0 0 {name=p31156 lab=_71581_/X }
C {devices/lab_pin.sym} 31980 -39350 0 0 {name=p31157 lab=_83447_/Q }
C {devices/lab_pin.sym} 31980 -39310 0 0 {name=p31158 lab=_71588_/Y }
C {devices/lab_pin.sym} 32140 -39350 0 1 {name=p31159 lab=_83447_/D }
C {sky130_stdcells/a21o_4.sym} 32060 -39350 0 0 {name=X_71589_ }
C {devices/lab_pin.sym} 32020 -39210 0 0 {name=p31160 lab=_83248_/CLK }
C {devices/lab_pin.sym} 32100 -39210 0 1 {name=p31161 lab=_84841_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 32060 -39210 0 0 {name=Xclkbuf_opt_5_CLK }
C {devices/lab_pin.sym} 32000 -39110 0 0 {name=p31162 lab=_64116_/A }
C {devices/lab_pin.sym} 32000 -39070 0 0 {name=p31163 lab=_64087_/X }
C {devices/lab_pin.sym} 32000 -39030 0 0 {name=p31164 lab=_64130_/C }
C {devices/lab_pin.sym} 32120 -39070 0 1 {name=p31165 lab=_64130_/Y }
C {sky130_stdcells/nor3_4.sym} 32060 -39070 0 0 {name=X_64130_ }
C {devices/lab_pin.sym} 32000 -38940 0 0 {name=p31166 lab=_81725_/D }
C {devices/lab_pin.sym} 32000 -38900 0 0 {name=p31167 lab=_76116_/B }
C {devices/lab_pin.sym} 32120 -38920 0 1 {name=p31168 lab=_76127_/B }
C {sky130_stdcells/nand2_4.sym} 32060 -38920 0 0 {name=X_76116_ }
C {devices/lab_pin.sym} 32020 -38790 0 0 {name=p31169 lab=_42508_/A }
C {devices/lab_pin.sym} 32100 -38790 0 1 {name=p31170 lab=_42508_/Y }
C {sky130_stdcells/inv_2.sym} 32060 -38790 0 0 {name=X_42508_ }
C {devices/lab_pin.sym} 32020 -38670 0 0 {name=p31171 lab=_49064_/A }
C {devices/lab_pin.sym} 32100 -38670 0 1 {name=p31172 lab=_50144_/B }
C {sky130_stdcells/buf_2.sym} 32060 -38670 0 0 {name=X_49064_ }
C {devices/lab_pin.sym} 32020 -38550 0 0 {name=p31173 lab=_61313_/A }
C {devices/lab_pin.sym} 32100 -38550 0 1 {name=p31174 lab=_61342_/X }
C {sky130_stdcells/buf_2.sym} 32060 -38550 0 0 {name=X_61342_ }
C {devices/lab_pin.sym} 32000 -38440 0 0 {name=p31175 lab=_73325_/X }
C {devices/lab_pin.sym} 32000 -38400 0 0 {name=p31176 lab=_73327_/Y }
C {devices/lab_pin.sym} 32120 -38420 0 1 {name=p31177 lab=_73328_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -38420 0 0 {name=X_73328_ }
C {devices/lab_pin.sym} 32020 -38290 0 0 {name=p31178 lab=_46276_/A }
C {devices/lab_pin.sym} 32100 -38290 0 1 {name=p31179 lab=_53953_/B }
C {sky130_stdcells/buf_2.sym} 32060 -38290 0 0 {name=X_46276_ }
C {devices/lab_pin.sym} 32000 -38180 0 0 {name=p31180 lab=_77096_/A }
C {devices/lab_pin.sym} 32000 -38140 0 0 {name=p31181 lab=_77096_/B }
C {devices/lab_pin.sym} 32120 -38160 0 1 {name=p31182 lab=_77097_/B }
C {sky130_stdcells/and2_4.sym} 32060 -38160 0 0 {name=X_77096_ }
C {devices/lab_pin.sym} 32020 -38030 0 0 {name=p31183 lab=_43488_/A }
C {devices/lab_pin.sym} 32100 -38030 0 1 {name=p31184 lab=_43488_/Y }
C {sky130_stdcells/inv_2.sym} 32060 -38030 0 0 {name=X_43488_ }
C {devices/lab_pin.sym} 32020 -37910 0 0 {name=p31185 lab=_48014_/Y }
C {devices/lab_pin.sym} 32100 -37910 0 1 {name=p31186 lab=_48016_/B }
C {sky130_stdcells/buf_2.sym} 32060 -37910 0 0 {name=X_48015_ }
C {devices/lab_pin.sym} 31980 -37810 0 0 {name=p31187 lab=_45224_/Y }
C {devices/lab_pin.sym} 31980 -37770 0 0 {name=p31188 lab=_45226_/Y }
C {devices/lab_pin.sym} 31980 -37730 0 0 {name=p31189 lab=_45212_/X }
C {devices/lab_pin.sym} 32140 -37770 0 1 {name=p31190 lab=_45227_/X }
C {sky130_stdcells/a21o_4.sym} 32060 -37770 0 0 {name=X_45227_ }
C {devices/lab_pin.sym} 32000 -37640 0 0 {name=p31191 lab=_76047_/A }
C {devices/lab_pin.sym} 32000 -37600 0 0 {name=p31192 lab=_76047_/B }
C {devices/lab_pin.sym} 32120 -37620 0 1 {name=p31193 lab=_76048_/B }
C {sky130_stdcells/and2_4.sym} 32060 -37620 0 0 {name=X_76047_ }
C {devices/lab_pin.sym} 32020 -37490 0 0 {name=p31194 lab=_63724_/A }
C {devices/lab_pin.sym} 32100 -37490 0 1 {name=p31195 lab=_64158_/B }
C {sky130_stdcells/buf_2.sym} 32060 -37490 0 0 {name=X_64061_ }
C {devices/lab_pin.sym} 32020 -37370 0 0 {name=p31196 lab=_43146_/A }
C {devices/lab_pin.sym} 32100 -37370 0 1 {name=p31197 lab=_42439_/X }
C {sky130_stdcells/buf_2.sym} 32060 -37370 0 0 {name=X_42439_ }
C {devices/lab_pin.sym} 31980 -37280 0 0 {name=p31198 lab=_84491_/Q }
C {devices/lab_pin.sym} 31980 -37240 0 0 {name=p31199 lab=_61252_/X }
C {devices/lab_pin.sym} 31980 -37200 0 0 {name=p31200 lab=_61272_/Y }
C {devices/lab_pin.sym} 31980 -37160 0 0 {name=p31201 lab=_61238_/Y }
C {devices/lab_pin.sym} 32140 -37220 0 1 {name=p31202 lab=_61273_/X }
C {sky130_stdcells/o22a_4.sym} 32060 -37220 0 0 {name=X_61273_ }
