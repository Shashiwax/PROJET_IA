C {devices/lab_pin.sym} 115720 -28460 0 0 {name=p114787 lab=_42447_/C }
C {devices/lab_pin.sym} 115720 -28420 0 0 {name=p114788 lab=_42447_/D }
C {devices/lab_pin.sym} 115840 -28480 0 1 {name=p114789 lab=_42447_/X }
C {sky130_stdcells/and4_4.sym} 115780 -28480 0 0 {name=X_42447_ }
C {devices/lab_pin.sym} 115720 -28350 0 0 {name=p114790 lab=_61281_/A }
C {devices/lab_pin.sym} 115720 -28310 0 0 {name=p114791 lab=_72625_/A }
C {devices/lab_pin.sym} 115720 -28270 0 0 {name=p114792 lab=_61281_/C }
C {devices/lab_pin.sym} 115840 -28310 0 1 {name=p114793 lab=_61281_/X }
C {sky130_stdcells/and3_4.sym} 115780 -28310 0 0 {name=X_61281_ }
C {devices/lab_pin.sym} 115720 -28180 0 0 {name=p114794 lab=_73267_/A }
C {devices/lab_pin.sym} 115720 -28140 0 0 {name=p114795 lab=_73266_/X }
C {devices/lab_pin.sym} 115840 -28160 0 1 {name=p114796 lab=_73267_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -28160 0 0 {name=X_73267_ }
C {devices/lab_pin.sym} 115740 -28030 0 0 {name=p114797 lab=_70387_/A }
C {devices/lab_pin.sym} 115820 -28030 0 1 {name=p114798 lab=_71815_/B }
C {sky130_stdcells/buf_2.sym} 115780 -28030 0 0 {name=X_70479_ }
C {devices/lab_pin.sym} 115740 -27910 0 0 {name=p114799 lab=_63020_/A }
C {devices/lab_pin.sym} 115820 -27910 0 1 {name=p114800 lab=_63020_/X }
C {sky130_stdcells/buf_2.sym} 115780 -27910 0 0 {name=X_63020_ }
C {devices/lab_pin.sym} 115720 -27800 0 0 {name=p114801 lab=_74999_/X }
C {devices/lab_pin.sym} 115720 -27760 0 0 {name=p114802 lab=_75005_/Y }
C {devices/lab_pin.sym} 115840 -27780 0 1 {name=p114803 lab=_75007_/B }
C {sky130_stdcells/xor2_4.sym} 115780 -27780 0 0 {name=X_75006_ }
C {devices/lab_pin.sym} 115720 -27680 0 0 {name=p114804 lab=_43969_/A }
C {devices/lab_pin.sym} 115720 -27640 0 0 {name=p114805 lab=_59899_/B }
C {devices/lab_pin.sym} 115720 -27600 0 0 {name=p114806 lab=_43969_/B }
C {devices/lab_pin.sym} 115720 -27560 0 0 {name=p114807 lab=_59899_/D }
C {devices/lab_pin.sym} 115840 -27620 0 1 {name=p114808 lab=_60232_/Y }
C {sky130_stdcells/nand4_4.sym} 115780 -27620 0 0 {name=X_60232_ }
C {devices/lab_pin.sym} 115700 -27490 0 0 {name=p114809 lab=_59368_/X }
C {devices/lab_pin.sym} 115700 -27450 0 0 {name=p114810 lab=_85977_/Q }
C {devices/lab_pin.sym} 115700 -27410 0 0 {name=p114811 lab=_72217_/X }
C {devices/lab_pin.sym} 115860 -27450 0 1 {name=p114812 lab=_72218_/Y }
C {sky130_stdcells/o21ai_4.sym} 115780 -27450 0 0 {name=X_72218_ }
C {devices/lab_pin.sym} 115700 -27330 0 0 {name=p114813 lab=_45163_/Y }
C {devices/lab_pin.sym} 115700 -27290 0 0 {name=p114814 lab=_45165_/Y }
C {devices/lab_pin.sym} 115700 -27250 0 0 {name=p114815 lab=_45137_/X }
C {devices/lab_pin.sym} 115860 -27290 0 1 {name=p114816 lab=_45166_/X }
C {sky130_stdcells/a21o_4.sym} 115780 -27290 0 0 {name=X_45166_ }
C {devices/lab_pin.sym} 115740 -27150 0 0 {name=p114817 lab=_42417_/A }
C {devices/lab_pin.sym} 115820 -27150 0 1 {name=p114818 lab=_42378_/X }
C {sky130_stdcells/buf_2.sym} 115780 -27150 0 0 {name=X_42378_ }
C {devices/lab_pin.sym} 115720 -27040 0 0 {name=p114819 lab=_73198_/A }
C {devices/lab_pin.sym} 115720 -27000 0 0 {name=p114820 lab=_73198_/B }
C {devices/lab_pin.sym} 115840 -27020 0 1 {name=p114821 lab=_73198_/Y }
C {sky130_stdcells/nor2_4.sym} 115780 -27020 0 0 {name=X_73198_ }
C {devices/lab_pin.sym} 115740 -26890 0 0 {name=p114822 lab=clkbuf_5_7_0_CLK/A }
C {devices/lab_pin.sym} 115820 -26890 0 1 {name=p114823 lab=clkbuf_5_7_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 115780 -26890 0 0 {name=Xclkbuf_5_7_0_CLK }
C {devices/lab_pin.sym} 115720 -26790 0 0 {name=p114824 lab=_44117_/A }
C {devices/lab_pin.sym} 115720 -26750 0 0 {name=p114825 lab=_87187_/Q }
C {devices/lab_pin.sym} 115720 -26710 0 0 {name=p114826 lab=_87186_/Q }
C {devices/lab_pin.sym} 115840 -26750 0 1 {name=p114827 lab=_44117_/Y }
C {sky130_stdcells/nand3_4.sym} 115780 -26750 0 0 {name=X_44117_ }
C {devices/lab_pin.sym} 115720 -26620 0 0 {name=p114828 lab=_84226_/Q }
C {devices/lab_pin.sym} 115720 -26580 0 0 {name=p114829 lab=_83274_/Q }
C {devices/lab_pin.sym} 115840 -26600 0 1 {name=p114830 lab=_79814_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -26600 0 0 {name=X_79814_ }
C {devices/lab_pin.sym} 115700 -26500 0 0 {name=p114831 lab=_41328_/X }
C {devices/lab_pin.sym} 115700 -26460 0 0 {name=p114832 lab=_41307_/X }
C {devices/lab_pin.sym} 115700 -26420 0 0 {name=p114833 lab=_88235_/Q }
C {devices/lab_pin.sym} 115700 -26380 0 0 {name=p114834 lab=_41308_/X }
C {devices/lab_pin.sym} 115860 -26440 0 1 {name=p114835 lab=_88235_/D }
C {sky130_stdcells/a2bb2o_4.sym} 115780 -26440 0 0 {name=X_41329_ }
C {devices/lab_pin.sym} 115740 -26290 0 0 {name=p114836 lab=_60162_/X }
C {devices/lab_pin.sym} 115820 -26290 0 1 {name=p114837 lab=_60387_/A }
C {sky130_stdcells/buf_2.sym} 115780 -26290 0 0 {name=X_60163_ }
C {devices/lab_pin.sym} 115700 -26190 0 0 {name=p114838 lab=_72145_/Y }
C {devices/lab_pin.sym} 115700 -26150 0 0 {name=p114839 lab=_72148_/Y }
C {devices/lab_pin.sym} 115700 -26110 0 0 {name=p114840 lab=_59351_/X }
C {devices/lab_pin.sym} 115860 -26150 0 1 {name=p114841 lab=_72149_/X }
C {sky130_stdcells/a21o_4.sym} 115780 -26150 0 0 {name=X_72149_ }
C {devices/lab_pin.sym} 115700 -26030 0 0 {name=p114842 lab=_49972_/Y }
C {devices/lab_pin.sym} 115700 -25990 0 0 {name=p114843 lab=_49951_/X }
C {devices/lab_pin.sym} 115700 -25950 0 0 {name=p114844 lab=_49973_/X }
C {devices/lab_pin.sym} 115860 -25990 0 1 {name=p114845 lab=_86289_/D }
C {sky130_stdcells/a21oi_4.sym} 115780 -25990 0 0 {name=X_49974_ }
C {devices/lab_pin.sym} 115740 -25850 0 0 {name=p114846 lab=_64353_/B }
C {devices/lab_pin.sym} 115820 -25850 0 1 {name=p114847 lab=_61479_/B }
C {sky130_stdcells/buf_2.sym} 115780 -25850 0 0 {name=X_45097_ }
C {devices/lab_pin.sym} 115700 -25750 0 0 {name=p114848 lab=_48881_/X }
C {devices/lab_pin.sym} 115700 -25710 0 0 {name=p114849 lab=_48405_/A }
C {devices/lab_pin.sym} 115700 -25670 0 0 {name=p114850 lab=_48924_/Y }
C {devices/lab_pin.sym} 115860 -25710 0 1 {name=p114851 lab=_48926_/A }
C {sky130_stdcells/o21ai_4.sym} 115780 -25710 0 0 {name=X_48925_ }
C {devices/lab_pin.sym} 115740 -25570 0 0 {name=p114852 lab=_44047_/X }
C {devices/lab_pin.sym} 115820 -25570 0 1 {name=p114853 lab=_44048_/X }
C {sky130_stdcells/buf_2.sym} 115780 -25570 0 0 {name=X_44048_ }
C {devices/lab_pin.sym} 115740 -25450 0 0 {name=p114854 lab=_79745_/A }
C {devices/lab_pin.sym} 115820 -25450 0 1 {name=p114855 lab=_79745_/Y }
C {sky130_stdcells/inv_2.sym} 115780 -25450 0 0 {name=X_79745_ }
C {devices/lab_pin.sym} 115740 -25330 0 0 {name=p114856 lab=_58124_/A }
C {devices/lab_pin.sym} 115820 -25330 0 1 {name=p114857 lab=_64971_/X }
C {sky130_stdcells/buf_2.sym} 115780 -25330 0 0 {name=X_64971_ }
C {devices/lab_pin.sym} 115720 -25220 0 0 {name=p114858 lab=_60174_/C }
C {devices/lab_pin.sym} 115720 -25180 0 0 {name=p114859 lab=_61070_/B }
C {devices/lab_pin.sym} 115840 -25200 0 1 {name=p114860 lab=_60094_/X }
C {sky130_stdcells/and2_4.sym} 115780 -25200 0 0 {name=X_60094_ }
C {devices/lab_pin.sym} 115720 -25090 0 0 {name=p114861 lab=_76957_/A }
C {devices/lab_pin.sym} 115720 -25050 0 0 {name=p114862 lab=_81601_/Q }
C {devices/lab_pin.sym} 115720 -25010 0 0 {name=p114863 lab=_76957_/C }
C {devices/lab_pin.sym} 115840 -25050 0 1 {name=p114864 lab=_76958_/B }
C {sky130_stdcells/nand3_4.sym} 115780 -25050 0 0 {name=X_76957_ }
C {devices/lab_pin.sym} 115720 -24920 0 0 {name=p114865 lab=_66689_/A }
C {devices/lab_pin.sym} 115720 -24880 0 0 {name=p114866 lab=_66710_/B }
C {devices/lab_pin.sym} 115840 -24900 0 1 {name=p114867 lab=_66710_/X }
C {sky130_stdcells/and2_4.sym} 115780 -24900 0 0 {name=X_66710_ }
C {devices/lab_pin.sym} 115720 -24800 0 0 {name=p114868 lab=_63916_/Y }
C {devices/lab_pin.sym} 115720 -24760 0 0 {name=p114869 lab=_63922_/B }
C {devices/lab_pin.sym} 115720 -24720 0 0 {name=p114870 lab=_63920_/Y }
C {devices/lab_pin.sym} 115720 -24680 0 0 {name=p114871 lab=_63922_/D }
C {devices/lab_pin.sym} 115840 -24740 0 1 {name=p114872 lab=_63922_/X }
C {sky130_stdcells/and4_4.sym} 115780 -24740 0 0 {name=X_63922_ }
C {devices/lab_pin.sym} 115720 -24600 0 0 {name=p114873 lab=_84506_/Q }
C {devices/lab_pin.sym} 115720 -24560 0 0 {name=p114874 lab=_84378_/Q }
C {devices/lab_pin.sym} 115840 -24580 0 1 {name=p114875 lab=_75908_/X }
C {sky130_stdcells/xor2_4.sym} 115780 -24580 0 0 {name=X_75908_ }
C {devices/lab_pin.sym} 115720 -24460 0 0 {name=p114876 lab=_48851_/A }
C {devices/lab_pin.sym} 115720 -24420 0 0 {name=p114877 lab=_48673_/B }
C {devices/lab_pin.sym} 115840 -24440 0 1 {name=p114878 lab=_48856_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -24440 0 0 {name=X_48856_ }
C {devices/lab_pin.sym} 115740 -24310 0 0 {name=p114879 lab=_68637_/A }
C {devices/lab_pin.sym} 115820 -24310 0 1 {name=p114880 lab=_67690_/X }
C {sky130_stdcells/buf_2.sym} 115780 -24310 0 0 {name=X_67690_ }
C {devices/lab_pin.sym} 115720 -24200 0 0 {name=p114881 lab=_79673_/X }
C {devices/lab_pin.sym} 115720 -24160 0 0 {name=p114882 lab=_79676_/B }
C {devices/lab_pin.sym} 115840 -24180 0 1 {name=p114883 lab=_79676_/X }
C {sky130_stdcells/xor2_4.sym} 115780 -24180 0 0 {name=X_79676_ }
C {devices/lab_pin.sym} 115720 -24070 0 0 {name=p114884 lab=_76888_/A }
C {devices/lab_pin.sym} 115720 -24030 0 0 {name=p114885 lab=_76888_/B }
C {devices/lab_pin.sym} 115720 -23990 0 0 {name=p114886 lab=_76888_/C }
C {devices/lab_pin.sym} 115840 -24030 0 1 {name=p114887 lab=_76889_/B }
C {sky130_stdcells/nand3_4.sym} 115780 -24030 0 0 {name=X_76888_ }
C {devices/lab_pin.sym} 115740 -23890 0 0 {name=p114888 lab=_47620_/X }
C {devices/lab_pin.sym} 115820 -23890 0 1 {name=p114889 lab=_47819_/A }
C {sky130_stdcells/buf_2.sym} 115780 -23890 0 0 {name=X_47807_ }
C {devices/lab_pin.sym} 115700 -23800 0 0 {name=p114890 lab=_87888_/Q }
C {devices/lab_pin.sym} 115700 -23760 0 0 {name=p114891 lab=_66639_/X }
C {devices/lab_pin.sym} 115700 -23720 0 0 {name=p114892 lab=_66531_/X }
C {devices/lab_pin.sym} 115700 -23680 0 0 {name=p114893 lab=_66640_/X }
C {devices/lab_pin.sym} 115860 -23740 0 1 {name=p114894 lab=_66641_/X }
C {sky130_stdcells/a211o_4.sym} 115780 -23740 0 0 {name=X_66641_ }
C {devices/lab_pin.sym} 115720 -23600 0 0 {name=p114895 lab=_82519_/Q }
C {devices/lab_pin.sym} 115720 -23560 0 0 {name=p114896 lab=_82775_/D }
C {devices/lab_pin.sym} 115840 -23580 0 1 {name=p114897 lab=_82487_/D }
C {sky130_stdcells/xor2_4.sym} 115780 -23580 0 0 {name=X_78627_ }
C {devices/lab_pin.sym} 115720 -23480 0 0 {name=p114898 lab=_61421_/A }
C {devices/lab_pin.sym} 115720 -23440 0 0 {name=p114899 lab=_63853_/B }
C {devices/lab_pin.sym} 115720 -23400 0 0 {name=p114900 lab=_63803_/C }
C {devices/lab_pin.sym} 115720 -23360 0 0 {name=p114901 lab=_63787_/D }
C {devices/lab_pin.sym} 115840 -23420 0 1 {name=p114902 lab=_63853_/Y }
C {sky130_stdcells/nand4_4.sym} 115780 -23420 0 0 {name=X_63853_ }
C {devices/lab_pin.sym} 115720 -23280 0 0 {name=p114903 lab=_75839_/A }
C {devices/lab_pin.sym} 115720 -23240 0 0 {name=p114904 lab=_75839_/B }
C {devices/lab_pin.sym} 115840 -23260 0 1 {name=p114905 lab=_75840_/B }
C {sky130_stdcells/xnor2_4.sym} 115780 -23260 0 0 {name=X_75839_ }
C {devices/lab_pin.sym} 115700 -23150 0 0 {name=p114906 lab=_48784_/Y }
C {devices/lab_pin.sym} 115700 -23110 0 0 {name=p114907 lab=_48785_/X }
C {devices/lab_pin.sym} 115700 -23070 0 0 {name=p114908 lab=_48786_/X }
C {devices/lab_pin.sym} 115860 -23110 0 1 {name=p114909 lab=_48787_/Y }
C {sky130_stdcells/a21oi_4.sym} 115780 -23110 0 0 {name=X_48787_ }
C {devices/lab_pin.sym} 115700 -23010 0 0 {name=p114910 lab=_45994_/X }
C {devices/lab_pin.sym} 115700 -22970 0 0 {name=p114911 lab=_45987_/X }
C {devices/lab_pin.sym} 115700 -22930 0 0 {name=p114912 lab=_40473_/X }
C {devices/lab_pin.sym} 115700 -22890 0 0 {name=p114913 lab=_66975_/B }
C {devices/lab_pin.sym} 115700 -22850 0 0 {name=p114914 lab=_45995_/X }
C {devices/lab_pin.sym} 115860 -22930 0 1 {name=p114915 lab=_45999_/Y }
C {sky130_stdcells/o32ai_4.sym} 115780 -22930 0 0 {name=X_45999_ }
C {devices/lab_pin.sym} 115720 -22800 0 0 {name=p114916 lab=_62789_/A }
C {devices/lab_pin.sym} 115720 -22760 0 0 {name=p114917 lab=_63150_/A }
C {devices/lab_pin.sym} 115720 -22720 0 0 {name=p114918 lab=_62848_/C }
C {devices/lab_pin.sym} 115720 -22680 0 0 {name=p114919 lab=_62789_/D }
C {devices/lab_pin.sym} 115840 -22740 0 1 {name=p114920 lab=_62804_/X }
C {sky130_stdcells/and4_4.sym} 115780 -22740 0 0 {name=X_62804_ }
C {devices/lab_pin.sym} 115700 -22610 0 0 {name=p114921 lab=_69355_/X }
C {devices/lab_pin.sym} 115700 -22570 0 0 {name=p114922 lab=_69359_/X }
C {devices/lab_pin.sym} 115700 -22530 0 0 {name=p114923 lab=_69138_/X }
C {devices/lab_pin.sym} 115860 -22570 0 1 {name=p114924 lab=_69360_/X }
C {sky130_stdcells/a21o_4.sym} 115780 -22570 0 0 {name=X_69360_ }
C {devices/lab_pin.sym} 115740 -22430 0 0 {name=p114925 lab=_55078_/D }
C {devices/lab_pin.sym} 115820 -22430 0 1 {name=p114926 lab=_53217_/D }
C {sky130_stdcells/buf_2.sym} 115780 -22430 0 0 {name=X_47738_ }
C {devices/lab_pin.sym} 115740 -22310 0 0 {name=p114927 lab=_44174_/A }
C {devices/lab_pin.sym} 115820 -22310 0 1 {name=p114928 lab=_66572_/X }
C {sky130_stdcells/buf_2.sym} 115780 -22310 0 0 {name=X_66572_ }
C {devices/lab_pin.sym} 115700 -22210 0 0 {name=p114929 lab=_78557_/B }
C {devices/lab_pin.sym} 115700 -22170 0 0 {name=p114930 lab=_78556_/Y }
C {devices/lab_pin.sym} 115700 -22130 0 0 {name=p114931 lab=_78548_/X }
C {devices/lab_pin.sym} 115860 -22170 0 1 {name=p114932 lab=_78558_/X }
C {sky130_stdcells/o21a_4.sym} 115780 -22170 0 0 {name=X_78558_ }
C {devices/lab_pin.sym} 115720 -22050 0 0 {name=p114933 lab=_63800_/A }
C {devices/lab_pin.sym} 115720 -22010 0 0 {name=p114934 lab=_63800_/B }
C {devices/lab_pin.sym} 115720 -21970 0 0 {name=p114935 lab=_63784_/C }
C {devices/lab_pin.sym} 115840 -22010 0 1 {name=p114936 lab=_63784_/Y }
C {sky130_stdcells/nor3_4.sym} 115780 -22010 0 0 {name=X_63784_ }
C {devices/lab_pin.sym} 115720 -21890 0 0 {name=p114937 lab=_60863_/X }
C {devices/lab_pin.sym} 115720 -21850 0 0 {name=p114938 lab=_60996_/B }
C {devices/lab_pin.sym} 115720 -21810 0 0 {name=p114939 lab=_60915_/X }
C {devices/lab_pin.sym} 115840 -21850 0 1 {name=p114940 lab=_60996_/Y }
C {sky130_stdcells/nor3_4.sym} 115780 -21850 0 0 {name=X_60996_ }
C {devices/lab_pin.sym} 115700 -21730 0 0 {name=p114941 lab=_83986_/Q }
C {devices/lab_pin.sym} 115700 -21690 0 0 {name=p114942 lab=_68299_/X }
C {devices/lab_pin.sym} 115700 -21650 0 0 {name=p114943 lab=_68310_/X }
C {devices/lab_pin.sym} 115860 -21690 0 1 {name=p114944 lab=_83986_/D }
C {sky130_stdcells/a21bo_4.sym} 115780 -21690 0 0 {name=X_68311_ }
C {devices/lab_pin.sym} 115700 -21570 0 0 {name=p114945 lab=_65520_/X }
C {devices/lab_pin.sym} 115700 -21530 0 0 {name=p114946 lab=_65522_/X }
C {devices/lab_pin.sym} 115700 -21490 0 0 {name=p114947 lab=_65287_/X }
C {devices/lab_pin.sym} 115860 -21530 0 1 {name=p114948 lab=_65523_/X }
C {sky130_stdcells/a21o_4.sym} 115780 -21530 0 0 {name=X_65523_ }
C {devices/lab_pin.sym} 115720 -21410 0 0 {name=p114949 lab=_77505_/Y }
C {devices/lab_pin.sym} 115720 -21370 0 0 {name=p114950 lab=_77509_/B }
C {devices/lab_pin.sym} 115720 -21330 0 0 {name=p114951 lab=_77508_/Y }
C {devices/lab_pin.sym} 115840 -21370 0 1 {name=p114952 lab=_77511_/A }
C {sky130_stdcells/or3_4.sym} 115780 -21370 0 0 {name=X_77509_ }
C {devices/lab_pin.sym} 115720 -21250 0 0 {name=p114953 lab=_62766_/A }
C {devices/lab_pin.sym} 115720 -21210 0 0 {name=p114954 lab=_62766_/B }
C {devices/lab_pin.sym} 115720 -21170 0 0 {name=p114955 lab=_84387_/Q }
C {devices/lab_pin.sym} 115840 -21210 0 1 {name=p114956 lab=_62735_/Y }
C {sky130_stdcells/nor3_4.sym} 115780 -21210 0 0 {name=X_62735_ }
C {devices/lab_pin.sym} 115720 -21080 0 0 {name=p114957 lab=_69253_/A }
C {devices/lab_pin.sym} 115720 -21040 0 0 {name=p114958 lab=_88296_/Q }
C {devices/lab_pin.sym} 115840 -21060 0 1 {name=p114959 lab=_69291_/X }
C {sky130_stdcells/and2_4.sym} 115780 -21060 0 0 {name=X_69291_ }
C {devices/lab_pin.sym} 115740 -20930 0 0 {name=p114960 lab=_54871_/B }
C {devices/lab_pin.sym} 115820 -20930 0 1 {name=p114961 lab=_53179_/B }
C {sky130_stdcells/buf_2.sym} 115780 -20930 0 0 {name=X_47669_ }
C {devices/lab_pin.sym} 115720 -20820 0 0 {name=p114962 lab=_78489_/A }
C {devices/lab_pin.sym} 115720 -20780 0 0 {name=p114963 lab=_82671_/D }
C {devices/lab_pin.sym} 115840 -20800 0 1 {name=p114964 lab=_78489_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -20800 0 0 {name=X_78489_ }
C {devices/lab_pin.sym} 115720 -20700 0 0 {name=p114965 lab=_49420_/A }
C {devices/lab_pin.sym} 115720 -20660 0 0 {name=p114966 lab=_49420_/B }
C {devices/lab_pin.sym} 115720 -20620 0 0 {name=p114967 lab=_49408_/C }
C {devices/lab_pin.sym} 115720 -20580 0 0 {name=p114968 lab=_52622_/D }
C {devices/lab_pin.sym} 115840 -20640 0 1 {name=p114969 lab=_49408_/X }
C {sky130_stdcells/and4_4.sym} 115780 -20640 0 0 {name=X_49408_ }
C {devices/lab_pin.sym} 115720 -20500 0 0 {name=p114970 lab=_80504_/X }
C {devices/lab_pin.sym} 115720 -20460 0 0 {name=p114971 lab=_80520_/B }
C {devices/lab_pin.sym} 115840 -20480 0 1 {name=p114972 lab=_80520_/X }
C {sky130_stdcells/or2_4.sym} 115780 -20480 0 0 {name=X_80520_ }
C {devices/lab_pin.sym} 115700 -20370 0 0 {name=p114973 lab=_84003_/Q }
C {devices/lab_pin.sym} 115700 -20330 0 0 {name=p114974 lab=_68238_/X }
C {devices/lab_pin.sym} 115700 -20290 0 0 {name=p114975 lab=_68241_/X }
C {devices/lab_pin.sym} 115860 -20330 0 1 {name=p114976 lab=_68242_/X }
C {sky130_stdcells/a21bo_4.sym} 115780 -20330 0 0 {name=X_68242_ }
C {devices/lab_pin.sym} 115740 -20190 0 0 {name=p114977 lab=_65877_/A }
C {devices/lab_pin.sym} 115820 -20190 0 1 {name=p114978 lab=_65592_/A }
C {sky130_stdcells/buf_2.sym} 115780 -20190 0 0 {name=X_65454_ }
C {devices/lab_pin.sym} 115740 -20070 0 0 {name=p114979 lab=_50742_/A }
C {devices/lab_pin.sym} 115820 -20070 0 1 {name=p114980 lab=_50680_/X }
C {sky130_stdcells/buf_2.sym} 115780 -20070 0 0 {name=X_50680_ }
C {devices/lab_pin.sym} 115740 -19950 0 0 {name=p114981 lab=_62847_/A }
C {devices/lab_pin.sym} 115820 -19950 0 1 {name=p114982 lab=_62669_/A }
C {sky130_stdcells/buf_2.sym} 115780 -19950 0 0 {name=X_62666_ }
C {devices/lab_pin.sym} 115700 -19850 0 0 {name=p114983 lab=_58251_/A }
C {devices/lab_pin.sym} 115700 -19810 0 0 {name=p114984 lab=_64367_/X }
C {devices/lab_pin.sym} 115700 -19770 0 0 {name=p114985 lab=_64404_/Y }
C {devices/lab_pin.sym} 115860 -19810 0 1 {name=p114986 lab=_64405_/Y }
C {sky130_stdcells/o21ai_4.sym} 115780 -19810 0 0 {name=X_64405_ }
C {devices/lab_pin.sym} 115720 -19690 0 0 {name=p114987 lab=_61558_/A }
C {devices/lab_pin.sym} 115720 -19650 0 0 {name=p114988 lab=_61617_/B }
C {devices/lab_pin.sym} 115720 -19610 0 0 {name=p114989 lab=_61590_/C }
C {devices/lab_pin.sym} 115840 -19650 0 1 {name=p114990 lab=_61617_/Y }
C {sky130_stdcells/nand3_4.sym} 115780 -19650 0 0 {name=X_61617_ }
C {devices/lab_pin.sym} 115700 -19530 0 0 {name=p114991 lab=_49337_/Y }
C {devices/lab_pin.sym} 115700 -19490 0 0 {name=p114992 lab=_49326_/X }
C {devices/lab_pin.sym} 115700 -19450 0 0 {name=p114993 lab=_49338_/Y }
C {devices/lab_pin.sym} 115860 -19490 0 1 {name=p114994 lab=_86407_/D }
C {sky130_stdcells/a21boi_4.sym} 115780 -19490 0 0 {name=X_49339_ }
C {devices/lab_pin.sym} 115720 -19360 0 0 {name=p114995 lab=_80445_/Y }
C {devices/lab_pin.sym} 115720 -19320 0 0 {name=p114996 lab=_80451_/B }
C {devices/lab_pin.sym} 115840 -19340 0 1 {name=p114997 lab=_82256_/D }
C {sky130_stdcells/xor2_4.sym} 115780 -19340 0 0 {name=X_80451_ }
C {devices/lab_pin.sym} 115740 -19210 0 0 {name=p114998 lab=_68129_/A }
C {devices/lab_pin.sym} 115820 -19210 0 1 {name=p114999 lab=_68173_/X }
C {sky130_stdcells/buf_2.sym} 115780 -19210 0 0 {name=X_68173_ }
C {devices/lab_pin.sym} 115700 -19120 0 0 {name=p115000 lab=_65009_/X }
C {devices/lab_pin.sym} 115700 -19080 0 0 {name=p115001 lab=_86147_/Q }
C {devices/lab_pin.sym} 115700 -19040 0 0 {name=p115002 lab=_65182_/X }
C {devices/lab_pin.sym} 115700 -19000 0 0 {name=p115003 lab=_65384_/X }
C {devices/lab_pin.sym} 115860 -19060 0 1 {name=p115004 lab=_65385_/X }
C {sky130_stdcells/a211o_4.sym} 115780 -19060 0 0 {name=X_65385_ }
C {devices/lab_pin.sym} 115720 -18940 0 0 {name=p115005 lab=_61666_/A }
C {devices/lab_pin.sym} 115720 -18900 0 0 {name=p115006 lab=_62597_/B }
C {devices/lab_pin.sym} 115720 -18860 0 0 {name=p115007 lab=_62501_/X }
C {devices/lab_pin.sym} 115720 -18820 0 0 {name=p115008 lab=_62597_/D }
C {devices/lab_pin.sym} 115840 -18880 0 1 {name=p115009 lab=_62600_/B }
C {sky130_stdcells/nand4_4.sym} 115780 -18880 0 0 {name=X_62597_ }
C {devices/lab_pin.sym} 115700 -18760 0 0 {name=p115010 lab=_87420_/Q }
C {devices/lab_pin.sym} 115700 -18720 0 0 {name=p115011 lab=_67121_/X }
C {devices/lab_pin.sym} 115700 -18680 0 0 {name=p115012 lab=_67122_/X }
C {devices/lab_pin.sym} 115700 -18640 0 0 {name=p115013 lab=_67123_/X }
C {devices/lab_pin.sym} 115860 -18700 0 1 {name=p115014 lab=_67124_/X }
C {sky130_stdcells/a211o_4.sym} 115780 -18700 0 0 {name=X_67124_ }
C {devices/lab_pin.sym} 115700 -18570 0 0 {name=p115015 lab=_85840_/Q }
C {devices/lab_pin.sym} 115700 -18530 0 0 {name=p115016 lab=_52347_/X }
C {devices/lab_pin.sym} 115700 -18490 0 0 {name=p115017 lab=_52349_/Y }
C {devices/lab_pin.sym} 115860 -18530 0 1 {name=p115018 lab=_52350_/Y }
C {sky130_stdcells/o21ai_4.sym} 115780 -18530 0 0 {name=X_52350_ }
C {devices/lab_pin.sym} 115720 -18410 0 0 {name=p115019 lab=_64336_/A }
C {devices/lab_pin.sym} 115720 -18370 0 0 {name=p115020 lab=_58543_/A }
C {devices/lab_pin.sym} 115720 -18330 0 0 {name=p115021 lab=_64323_/X }
C {devices/lab_pin.sym} 115840 -18370 0 1 {name=p115022 lab=_64336_/Y }
C {sky130_stdcells/nand3_4.sym} 115780 -18370 0 0 {name=X_64336_ }
C {devices/lab_pin.sym} 115690 -18230 0 0 {name=p115023 lab=_83167_/CLK }
C {devices/lab_pin.sym} 115690 -18210 0 0 {name=p115024 lab=_72972_/X }
C {devices/lab_pin.sym} 115870 -18230 0 1 {name=p115025 lab=_83170_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -18220 0 0 {name=X_83170_ }
C {devices/lab_pin.sym} 115720 -18110 0 0 {name=p115026 lab=_61499_/A }
C {devices/lab_pin.sym} 115720 -18070 0 0 {name=p115027 lab=_61548_/B }
C {devices/lab_pin.sym} 115720 -18030 0 0 {name=p115028 lab=_61538_/C }
C {devices/lab_pin.sym} 115840 -18070 0 1 {name=p115029 lab=_61548_/Y }
C {sky130_stdcells/nand3_4.sym} 115780 -18070 0 0 {name=X_61548_ }
C {devices/lab_pin.sym} 115720 -17940 0 0 {name=p115030 lab=_80383_/B }
C {devices/lab_pin.sym} 115720 -17900 0 0 {name=p115031 lab=_80372_/X }
C {devices/lab_pin.sym} 115840 -17920 0 1 {name=p115032 lab=_80382_/X }
C {sky130_stdcells/or2_4.sym} 115780 -17920 0 0 {name=X_80382_ }
C {devices/lab_pin.sym} 115740 -17790 0 0 {name=p115033 lab=clkbuf_7_85_0_CLK/A }
C {devices/lab_pin.sym} 115820 -17790 0 1 {name=p115034 lab=clkbuf_7_84_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 115780 -17790 0 0 {name=Xclkbuf_7_84_0_CLK }
C {devices/lab_pin.sym} 115700 -17690 0 0 {name=p115035 lab=_86036_/Q }
C {devices/lab_pin.sym} 115700 -17650 0 0 {name=p115036 lab=_51285_/X }
C {devices/lab_pin.sym} 115700 -17610 0 0 {name=p115037 lab=_51300_/Y }
C {devices/lab_pin.sym} 115860 -17650 0 1 {name=p115038 lab=_51301_/Y }
C {sky130_stdcells/o21ai_4.sym} 115780 -17650 0 0 {name=X_51301_ }
C {devices/lab_pin.sym} 115690 -17510 0 0 {name=p115039 lab=_82485_/CLK }
C {devices/lab_pin.sym} 115690 -17490 0 0 {name=p115040 lab=_77792_/X }
C {devices/lab_pin.sym} 115870 -17510 0 1 {name=p115041 lab=_82109_/D }
C {sky130_stdcells/dfxtp_4.sym} 115780 -17500 0 0 {name=X_82121_ }
C {devices/lab_pin.sym} 115740 -17370 0 0 {name=p115042 lab=_66560_/X }
C {devices/lab_pin.sym} 115820 -17370 0 1 {name=p115043 lab=_67055_/X }
C {sky130_stdcells/buf_2.sym} 115780 -17370 0 0 {name=X_67055_ }
C {devices/lab_pin.sym} 115700 -17270 0 0 {name=p115044 lab=_50578_/A }
C {devices/lab_pin.sym} 115700 -17230 0 0 {name=p115045 lab=_50578_/B }
C {devices/lab_pin.sym} 115700 -17190 0 0 {name=p115046 lab=_52280_/X }
C {devices/lab_pin.sym} 115860 -17230 0 1 {name=p115047 lab=_52281_/X }
C {sky130_stdcells/o21a_4.sym} 115780 -17230 0 0 {name=X_52281_ }
C {devices/lab_pin.sym} 115740 -17090 0 0 {name=p115048 lab=_64267_/A }
C {devices/lab_pin.sym} 115820 -17090 0 1 {name=p115049 lab=_64267_/X }
C {sky130_stdcells/buf_2.sym} 115780 -17090 0 0 {name=X_64267_ }
C {devices/lab_pin.sym} 115720 -16990 0 0 {name=p115050 lab=_61437_/A }
C {devices/lab_pin.sym} 115720 -16950 0 0 {name=p115051 lab=_61479_/B }
C {devices/lab_pin.sym} 115720 -16910 0 0 {name=p115052 lab=_61459_/X }
C {devices/lab_pin.sym} 115840 -16950 0 1 {name=p115053 lab=_61479_/Y }
C {sky130_stdcells/nand3_4.sym} 115780 -16950 0 0 {name=X_61479_ }
C {devices/lab_pin.sym} 115720 -16820 0 0 {name=p115054 lab=_54020_/A }
C {devices/lab_pin.sym} 115720 -16780 0 0 {name=p115055 lab=_46433_/A }
C {devices/lab_pin.sym} 115840 -16800 0 1 {name=p115056 lab=_54020_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -16800 0 0 {name=X_54020_ }
C {devices/lab_pin.sym} 115720 -16680 0 0 {name=p115057 lab=_65932_/A }
C {devices/lab_pin.sym} 115720 -16640 0 0 {name=p115058 lab=_66006_/B }
C {devices/lab_pin.sym} 115840 -16660 0 1 {name=p115059 lab=_66006_/X }
C {sky130_stdcells/and2_4.sym} 115780 -16660 0 0 {name=X_66006_ }
C {devices/lab_pin.sym} 115700 -16550 0 0 {name=p115060 lab=_51228_/Y }
C {devices/lab_pin.sym} 115700 -16510 0 0 {name=p115061 lab=_51229_/X }
C {devices/lab_pin.sym} 115700 -16470 0 0 {name=p115062 lab=_51231_/X }
C {devices/lab_pin.sym} 115860 -16510 0 1 {name=p115063 lab=_86050_/D }
C {sky130_stdcells/a21oi_4.sym} 115780 -16510 0 0 {name=X_51232_ }
C {devices/lab_pin.sym} 115700 -16410 0 0 {name=p115064 lab=_63212_/Y }
C {devices/lab_pin.sym} 115700 -16370 0 0 {name=p115065 lab=_63214_/X }
C {devices/lab_pin.sym} 115700 -16330 0 0 {name=p115066 lab=_63215_/X }
C {devices/lab_pin.sym} 115700 -16290 0 0 {name=p115067 lab=_63217_/X }
C {devices/lab_pin.sym} 115700 -16250 0 0 {name=p115068 lab=_63183_/X }
C {devices/lab_pin.sym} 115860 -16330 0 1 {name=p115069 lab=_63218_/Y }
C {sky130_stdcells/o41ai_4.sym} 115780 -16330 0 0 {name=X_63218_ }
C {devices/lab_pin.sym} 115690 -16170 0 0 {name=p115070 lab=_84074_/CLK }
C {devices/lab_pin.sym} 115690 -16150 0 0 {name=p115071 lab=_82052_/D }
C {devices/lab_pin.sym} 115870 -16170 0 1 {name=p115072 lab=_82052_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -16160 0 0 {name=X_82052_ }
C {devices/lab_pin.sym} 115740 -16030 0 0 {name=p115073 lab=_60034_/X }
C {devices/lab_pin.sym} 115820 -16030 0 1 {name=p115074 lab=_64490_/A }
C {sky130_stdcells/buf_2.sym} 115780 -16030 0 0 {name=X_64198_ }
C {devices/lab_pin.sym} 115690 -15910 0 0 {name=p115075 lab=_83238_/CLK }
C {devices/lab_pin.sym} 115690 -15890 0 0 {name=p115076 lab=_84211_/Q }
C {devices/lab_pin.sym} 115870 -15910 0 1 {name=p115077 lab=_81003_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -15900 0 0 {name=X_81003_ }
C {devices/lab_pin.sym} 115700 -15790 0 0 {name=p115078 lab=_86062_/Q }
C {devices/lab_pin.sym} 115700 -15750 0 0 {name=p115079 lab=_51156_/X }
C {devices/lab_pin.sym} 115700 -15710 0 0 {name=p115080 lab=_51162_/Y }
C {devices/lab_pin.sym} 115860 -15750 0 1 {name=p115081 lab=_51163_/Y }
C {sky130_stdcells/o21ai_4.sym} 115780 -15750 0 0 {name=X_51163_ }
C {devices/lab_pin.sym} 115740 -15610 0 0 {name=p115082 lab=_60508_/A }
C {devices/lab_pin.sym} 115820 -15610 0 1 {name=p115083 lab=_63149_/X }
C {sky130_stdcells/buf_2.sym} 115780 -15610 0 0 {name=X_63149_ }
C {devices/lab_pin.sym} 115690 -15490 0 0 {name=p115084 lab=_86861_/CLK }
C {devices/lab_pin.sym} 115690 -15470 0 0 {name=p115085 lab=_45701_/Y }
C {devices/lab_pin.sym} 115870 -15490 0 1 {name=p115086 lab=_63227_/B }
C {sky130_stdcells/dfxtp_4.sym} 115780 -15480 0 0 {name=X_86860_ }
C {devices/lab_pin.sym} 115740 -15350 0 0 {name=p115087 lab=clkbuf_7_98_0_CLK/A }
C {devices/lab_pin.sym} 115820 -15350 0 1 {name=p115088 lab=clkbuf_7_99_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 115780 -15350 0 0 {name=Xclkbuf_7_99_0_CLK }
C {devices/lab_pin.sym} 115740 -15230 0 0 {name=p115089 lab=_50064_/A }
C {devices/lab_pin.sym} 115820 -15230 0 1 {name=p115090 lab=_50120_/A }
C {sky130_stdcells/buf_2.sym} 115780 -15230 0 0 {name=X_50114_ }
C {devices/lab_pin.sym} 115690 -15110 0 0 {name=p115091 lab=_86422_/CLK }
C {devices/lab_pin.sym} 115690 -15090 0 0 {name=p115092 lab=_52493_/Y }
C {devices/lab_pin.sym} 115870 -15110 0 1 {name=p115093 lab=_64974_/B }
C {sky130_stdcells/dfxtp_4.sym} 115780 -15100 0 0 {name=X_85811_ }
C {devices/lab_pin.sym} 115740 -14970 0 0 {name=p115094 lab=_51013_/A }
C {devices/lab_pin.sym} 115820 -14970 0 1 {name=p115095 lab=_51115_/B }
C {sky130_stdcells/buf_2.sym} 115780 -14970 0 0 {name=X_51094_ }
C {devices/lab_pin.sym} 115700 -14870 0 0 {name=p115096 lab=_67952_/X }
C {devices/lab_pin.sym} 115700 -14830 0 0 {name=p115097 lab=_67956_/X }
C {devices/lab_pin.sym} 115700 -14790 0 0 {name=p115098 lab=_67858_/X }
C {devices/lab_pin.sym} 115860 -14830 0 1 {name=p115099 lab=_67961_/A }
C {sky130_stdcells/a21o_4.sym} 115780 -14830 0 0 {name=X_67957_ }
C {devices/lab_pin.sym} 115700 -14710 0 0 {name=p115100 lab=_55968_/X }
C {devices/lab_pin.sym} 115700 -14670 0 0 {name=p115101 lab=_55970_/X }
C {devices/lab_pin.sym} 115700 -14630 0 0 {name=p115102 lab=_55615_/X }
C {devices/lab_pin.sym} 115860 -14670 0 1 {name=p115103 lab=_55974_/A }
C {sky130_stdcells/a21o_4.sym} 115780 -14670 0 0 {name=X_55971_ }
C {devices/lab_pin.sym} 115690 -14530 0 0 {name=p115104 lab=_87077_/CLK }
C {devices/lab_pin.sym} 115690 -14510 0 0 {name=p115105 lab=_86791_/D }
C {devices/lab_pin.sym} 115870 -14530 0 1 {name=p115106 lab=_86791_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -14520 0 0 {name=X_86791_ }
C {devices/lab_pin.sym} 115740 -14390 0 0 {name=p115107 lab=_65034_/A }
C {devices/lab_pin.sym} 115820 -14390 0 1 {name=p115108 lab=_57965_/A }
C {sky130_stdcells/buf_2.sym} 115780 -14390 0 0 {name=X_57710_ }
C {devices/lab_pin.sym} 115740 -14270 0 0 {name=p115109 lab=_50929_/A }
C {devices/lab_pin.sym} 115820 -14270 0 1 {name=p115110 lab=_50045_/X }
C {sky130_stdcells/buf_2.sym} 115780 -14270 0 0 {name=X_50045_ }
C {devices/lab_pin.sym} 115720 -14180 0 0 {name=p115111 lab=_54932_/A }
C {devices/lab_pin.sym} 115720 -14140 0 0 {name=p115112 lab=_54910_/B }
C {devices/lab_pin.sym} 115720 -14100 0 0 {name=p115113 lab=_54932_/C }
C {devices/lab_pin.sym} 115720 -14060 0 0 {name=p115114 lab=_53230_/D }
C {devices/lab_pin.sym} 115840 -14120 0 1 {name=p115115 lab=_54922_/X }
C {sky130_stdcells/and4_4.sym} 115780 -14120 0 0 {name=X_54922_ }
C {devices/lab_pin.sym} 115690 -13970 0 0 {name=p115116 lab=_85745_/CLK }
C {devices/lab_pin.sym} 115690 -13950 0 0 {name=p115117 lab=_52858_/Y }
C {devices/lab_pin.sym} 115870 -13970 0 1 {name=p115118 lab=_85742_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -13960 0 0 {name=X_85742_ }
C {devices/lab_pin.sym} 115700 -13860 0 0 {name=p115119 lab=_87121_/Q }
C {devices/lab_pin.sym} 115700 -13820 0 0 {name=p115120 lab=_66833_/X }
C {devices/lab_pin.sym} 115700 -13780 0 0 {name=p115121 lab=_66834_/X }
C {devices/lab_pin.sym} 115700 -13740 0 0 {name=p115122 lab=_66907_/X }
C {devices/lab_pin.sym} 115860 -13800 0 1 {name=p115123 lab=_66908_/X }
C {sky130_stdcells/a211o_4.sym} 115780 -13800 0 0 {name=X_66908_ }
C {devices/lab_pin.sym} 115700 -13670 0 0 {name=p115124 lab=_58605_/X }
C {devices/lab_pin.sym} 115700 -13630 0 0 {name=p115125 lab=_85943_/Q }
C {devices/lab_pin.sym} 115700 -13590 0 0 {name=p115126 lab=_58679_/X }
C {devices/lab_pin.sym} 115860 -13630 0 1 {name=p115127 lab=_58690_/X }
C {sky130_stdcells/o21a_4.sym} 115780 -13630 0 0 {name=X_58690_ }
C {devices/lab_pin.sym} 115690 -13490 0 0 {name=p115128 lab=_82769_/CLK }
C {devices/lab_pin.sym} 115690 -13470 0 0 {name=p115129 lab=_82954_/D }
C {devices/lab_pin.sym} 115870 -13490 0 1 {name=p115130 lab=_82954_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -13480 0 0 {name=X_82954_ }
C {devices/lab_pin.sym} 115740 -13350 0 0 {name=p115131 lab=_68402_/A }
C {devices/lab_pin.sym} 115820 -13350 0 1 {name=p115132 lab=_67888_/X }
C {sky130_stdcells/buf_2.sym} 115780 -13350 0 0 {name=X_67888_ }
C {devices/lab_pin.sym} 115740 -13230 0 0 {name=p115133 lab=clkbuf_7_23_0_CLK/A }
C {devices/lab_pin.sym} 115820 -13230 0 1 {name=p115134 lab=clkbuf_8_45_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 115780 -13230 0 0 {name=Xclkbuf_7_22_0_CLK }
C {devices/lab_pin.sym} 115700 -13130 0 0 {name=p115135 lab=_57638_/Y }
C {devices/lab_pin.sym} 115700 -13090 0 0 {name=p115136 lab=_57627_/X }
C {devices/lab_pin.sym} 115700 -13050 0 0 {name=p115137 lab=_57640_/Y }
C {devices/lab_pin.sym} 115860 -13090 0 1 {name=p115138 lab=_84964_/D }
C {sky130_stdcells/a21boi_4.sym} 115780 -13090 0 0 {name=X_57641_ }
C {devices/lab_pin.sym} 115690 -12950 0 0 {name=p115139 lab=_81989_/CLK }
C {devices/lab_pin.sym} 115690 -12930 0 0 {name=p115140 lab=_77453_/X }
C {devices/lab_pin.sym} 115870 -12950 0 1 {name=p115141 lab=_82281_/D }
C {sky130_stdcells/dfxtp_4.sym} 115780 -12940 0 0 {name=X_81905_ }
C {devices/lab_pin.sym} 115720 -12820 0 0 {name=p115142 lab=_69865_/A }
C {devices/lab_pin.sym} 115720 -12780 0 0 {name=p115143 lab=_69627_/B }
C {devices/lab_pin.sym} 115840 -12800 0 1 {name=p115144 lab=_69627_/X }
C {sky130_stdcells/and2_4.sym} 115780 -12800 0 0 {name=X_69627_ }
C {devices/lab_pin.sym} 115700 -12690 0 0 {name=p115145 lab=_54851_/Y }
C {devices/lab_pin.sym} 115700 -12650 0 0 {name=p115146 lab=_54830_/X }
C {devices/lab_pin.sym} 115700 -12610 0 0 {name=p115147 lab=_54852_/X }
C {devices/lab_pin.sym} 115860 -12650 0 1 {name=p115148 lab=_54853_/Y }
C {sky130_stdcells/a21oi_4.sym} 115780 -12650 0 0 {name=X_54853_ }
C {devices/lab_pin.sym} 115700 -12540 0 0 {name=p115149 lab=_87880_/Q }
C {devices/lab_pin.sym} 115700 -12500 0 0 {name=p115150 lab=_66816_/X }
C {devices/lab_pin.sym} 115700 -12460 0 0 {name=p115151 lab=_66794_/X }
C {devices/lab_pin.sym} 115700 -12420 0 0 {name=p115152 lab=_66838_/X }
C {devices/lab_pin.sym} 115860 -12480 0 1 {name=p115153 lab=_66839_/X }
C {sky130_stdcells/a211o_4.sym} 115780 -12480 0 0 {name=X_66839_ }
C {devices/lab_pin.sym} 115690 -12330 0 0 {name=p115154 lab=_86400_/CLK }
C {devices/lab_pin.sym} 115690 -12310 0 0 {name=p115155 lab=_53231_/Y }
C {devices/lab_pin.sym} 115870 -12330 0 1 {name=p115156 lab=_85673_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -12320 0 0 {name=X_85673_ }
C {devices/lab_pin.sym} 115740 -12190 0 0 {name=p115157 lab=clkbuf_7_81_0_CLK/X }
C {devices/lab_pin.sym} 115820 -12190 0 1 {name=p115158 lab=clkbuf_9_325_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 115780 -12190 0 0 {name=Xclkbuf_8_162_0_CLK }
C {devices/lab_pin.sym} 115690 -12070 0 0 {name=p115159 lab=_82317_/CLK }
C {devices/lab_pin.sym} 115690 -12050 0 0 {name=p115160 lab=_78101_/B }
C {devices/lab_pin.sym} 115870 -12070 0 1 {name=p115161 lab=_82885_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -12060 0 0 {name=X_82885_ }
C {devices/lab_pin.sym} 115690 -11930 0 0 {name=p115162 lab=_88180_/CLK }
C {devices/lab_pin.sym} 115690 -11910 0 0 {name=p115163 lab=_87412_/D }
C {devices/lab_pin.sym} 115870 -11930 0 1 {name=p115164 lab=_87412_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -11920 0 0 {name=X_87412_ }
C {devices/lab_pin.sym} 115700 -11810 0 0 {name=p115165 lab=_85565_/Q }
C {devices/lab_pin.sym} 115700 -11770 0 0 {name=p115166 lab=_53784_/X }
C {devices/lab_pin.sym} 115700 -11730 0 0 {name=p115167 lab=_53803_/Y }
C {devices/lab_pin.sym} 115860 -11770 0 1 {name=p115168 lab=_53804_/Y }
C {sky130_stdcells/o21ai_4.sym} 115780 -11770 0 0 {name=X_53804_ }
C {devices/lab_pin.sym} 115690 -11630 0 0 {name=p115169 lab=_84624_/CLK }
C {devices/lab_pin.sym} 115690 -11610 0 0 {name=p115170 lab=_84624_/D }
C {devices/lab_pin.sym} 115870 -11630 0 1 {name=p115171 lab=_79615_/A }
C {sky130_stdcells/dfxtp_4.sym} 115780 -11620 0 0 {name=X_84624_ }
C {devices/lab_pin.sym} 115720 -11510 0 0 {name=p115172 lab=_48011_/A }
C {devices/lab_pin.sym} 115720 -11470 0 0 {name=p115173 lab=_57619_/B }
C {devices/lab_pin.sym} 115720 -11430 0 0 {name=p115174 lab=_46603_/X }
C {devices/lab_pin.sym} 115840 -11470 0 1 {name=p115175 lab=_57572_/X }
C {sky130_stdcells/and3_4.sym} 115780 -11470 0 0 {name=X_57572_ }
C {devices/lab_pin.sym} 115720 -11340 0 0 {name=p115176 lab=_44022_/X }
C {devices/lab_pin.sym} 115720 -11300 0 0 {name=p115177 lab=_69558_/B }
C {devices/lab_pin.sym} 115840 -11320 0 1 {name=p115178 lab=_69558_/X }
C {sky130_stdcells/and2_4.sym} 115780 -11320 0 0 {name=X_69558_ }
C {devices/lab_pin.sym} 115690 -11190 0 0 {name=p115179 lab=_81834_/CLK }
C {devices/lab_pin.sym} 115690 -11170 0 0 {name=p115180 lab=_81868_/Q }
C {devices/lab_pin.sym} 115870 -11190 0 1 {name=p115181 lab=_77376_/A }
C {sky130_stdcells/dfxtp_4.sym} 115780 -11180 0 0 {name=X_81836_ }
C {devices/lab_pin.sym} 115690 -11050 0 0 {name=p115182 lab=_88394_/CLK }
C {devices/lab_pin.sym} 115690 -11030 0 0 {name=p115183 lab=_40434_/Y }
C {devices/lab_pin.sym} 115870 -11050 0 1 {name=p115184 lab=_88392_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -11040 0 0 {name=X_88392_ }
C {devices/lab_pin.sym} 115740 -10910 0 0 {name=p115185 lab=_54892_/A }
C {devices/lab_pin.sym} 115820 -10910 0 1 {name=p115186 lab=_54784_/X }
C {sky130_stdcells/buf_2.sym} 115780 -10910 0 0 {name=X_54784_ }
C {devices/lab_pin.sym} 115740 -10790 0 0 {name=p115187 lab=_52185_/A }
C {devices/lab_pin.sym} 115820 -10790 0 1 {name=p115188 lab=_52027_/A }
C {sky130_stdcells/buf_2.sym} 115780 -10790 0 0 {name=X_51996_ }
C {devices/lab_pin.sym} 115740 -10670 0 0 {name=p115189 lab=_58904_/A }
C {devices/lab_pin.sym} 115820 -10670 0 1 {name=p115190 lab=_59311_/X }
C {sky130_stdcells/buf_2.sym} 115780 -10670 0 0 {name=X_59311_ }
C {devices/lab_pin.sym} 115720 -10570 0 0 {name=p115191 lab=_56523_/A }
C {devices/lab_pin.sym} 115720 -10530 0 0 {name=p115192 lab=_56533_/B }
C {devices/lab_pin.sym} 115720 -10490 0 0 {name=p115193 lab=_56523_/C }
C {devices/lab_pin.sym} 115840 -10530 0 1 {name=p115194 lab=_56523_/Y }
C {sky130_stdcells/nand3_4.sym} 115780 -10530 0 0 {name=X_56523_ }
C {devices/lab_pin.sym} 115740 -10390 0 0 {name=p115195 lab=_68993_/A }
C {devices/lab_pin.sym} 115820 -10390 0 1 {name=p115196 lab=_68509_/X }
C {sky130_stdcells/buf_2.sym} 115780 -10390 0 0 {name=X_68509_ }
C {devices/lab_pin.sym} 115690 -10270 0 0 {name=p115197 lab=_86988_/CLK }
C {devices/lab_pin.sym} 115690 -10250 0 0 {name=p115198 lab=_43613_/Y }
C {devices/lab_pin.sym} 115870 -10270 0 1 {name=p115199 lab=_43610_/A }
C {sky130_stdcells/dfxtp_4.sym} 115780 -10260 0 0 {name=X_87343_ }
C {devices/lab_pin.sym} 115700 -10150 0 0 {name=p115200 lab=_53732_/Y }
C {devices/lab_pin.sym} 115700 -10110 0 0 {name=p115201 lab=_53715_/X }
C {devices/lab_pin.sym} 115700 -10070 0 0 {name=p115202 lab=_53734_/X }
C {devices/lab_pin.sym} 115860 -10110 0 1 {name=p115203 lab=_53735_/Y }
C {sky130_stdcells/a21oi_4.sym} 115780 -10110 0 0 {name=X_53735_ }
C {devices/lab_pin.sym} 115690 -9970 0 0 {name=p115204 lab=_84555_/CLK }
C {devices/lab_pin.sym} 115690 -9950 0 0 {name=p115205 lab=_84555_/D }
C {devices/lab_pin.sym} 115870 -9970 0 1 {name=p115206 lab=_84555_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -9960 0 0 {name=X_84555_ }
C {devices/lab_pin.sym} 115740 -9830 0 0 {name=p115207 lab=_50973_/A }
C {devices/lab_pin.sym} 115820 -9830 0 1 {name=p115208 lab=_50963_/A }
C {sky130_stdcells/buf_2.sym} 115780 -9830 0 0 {name=X_50947_ }
C {devices/lab_pin.sym} 115690 -9710 0 0 {name=p115209 lab=_88175_/CLK }
C {devices/lab_pin.sym} 115690 -9690 0 0 {name=p115210 lab=_76011_/X }
C {devices/lab_pin.sym} 115870 -9710 0 1 {name=p115211 lab=_48653_/A }
C {sky130_stdcells/dfxtp_4.sym} 115780 -9700 0 0 {name=X_81767_ }
C {devices/lab_pin.sym} 115700 -9600 0 0 {name=p115212 lab=_69329_/X }
C {devices/lab_pin.sym} 115700 -9560 0 0 {name=p115213 lab=_68986_/Y }
C {devices/lab_pin.sym} 115700 -9520 0 0 {name=p115214 lab=_69405_/X }
C {devices/lab_pin.sym} 115700 -9480 0 0 {name=p115215 lab=_69488_/Y }
C {devices/lab_pin.sym} 115860 -9540 0 1 {name=p115216 lab=_69489_/X }
C {sky130_stdcells/a211o_4.sym} 115780 -9540 0 0 {name=X_69489_ }
C {devices/lab_pin.sym} 115740 -9390 0 0 {name=p115217 lab=clkbuf_6_18_0_CLK/X }
C {devices/lab_pin.sym} 115820 -9390 0 1 {name=p115218 lab=clkbuf_8_75_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 115780 -9390 0 0 {name=Xclkbuf_7_37_0_CLK }
C {devices/lab_pin.sym} 115720 -9280 0 0 {name=p115219 lab=_40700_/A }
C {devices/lab_pin.sym} 115720 -9240 0 0 {name=p115220 lab=_40760_/B }
C {devices/lab_pin.sym} 115840 -9260 0 1 {name=p115221 lab=_40700_/X }
C {sky130_stdcells/or2_4.sym} 115780 -9260 0 0 {name=X_40700_ }
C {devices/lab_pin.sym} 115700 -9170 0 0 {name=p115222 lab=_59237_/X }
C {devices/lab_pin.sym} 115700 -9130 0 0 {name=p115223 lab=_59239_/Y }
C {devices/lab_pin.sym} 115700 -9090 0 0 {name=p115224 lab=_59240_/Y }
C {devices/lab_pin.sym} 115700 -9050 0 0 {name=p115225 lab=_59169_/X }
C {devices/lab_pin.sym} 115700 -9010 0 0 {name=p115226 lab=_59241_/X }
C {devices/lab_pin.sym} 115860 -9090 0 1 {name=p115227 lab=_59242_/X }
C {sky130_stdcells/o32a_4.sym} 115780 -9090 0 0 {name=X_59242_ }
C {devices/lab_pin.sym} 115700 -8950 0 0 {name=p115228 lab=_53246_/B }
C {devices/lab_pin.sym} 115700 -8910 0 0 {name=p115229 lab=_71508_/X }
C {devices/lab_pin.sym} 115700 -8870 0 0 {name=p115230 lab=_71519_/Y }
C {devices/lab_pin.sym} 115860 -8910 0 1 {name=p115231 lab=_83469_/D }
C {sky130_stdcells/o21ai_4.sym} 115780 -8910 0 0 {name=X_71520_ }
C {devices/lab_pin.sym} 115690 -8770 0 0 {name=p115232 lab=_83508_/CLK }
C {devices/lab_pin.sym} 115690 -8750 0 0 {name=p115233 lab=_83506_/D }
C {devices/lab_pin.sym} 115870 -8770 0 1 {name=p115234 lab=_83506_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -8760 0 0 {name=X_83506_ }
C {devices/lab_pin.sym} 115720 -8650 0 0 {name=p115235 lab=_56377_/X }
C {devices/lab_pin.sym} 115720 -8610 0 0 {name=p115236 lab=_56454_/B }
C {devices/lab_pin.sym} 115720 -8570 0 0 {name=p115237 lab=_56454_/C }
C {devices/lab_pin.sym} 115840 -8610 0 1 {name=p115238 lab=_56454_/Y }
C {sky130_stdcells/nand3_4.sym} 115780 -8610 0 0 {name=X_56454_ }
C {devices/lab_pin.sym} 115740 -8470 0 0 {name=p115239 lab=clkbuf_7_88_0_CLK/X }
C {devices/lab_pin.sym} 115820 -8470 0 1 {name=p115240 lab=clkbuf_9_355_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 115780 -8470 0 0 {name=Xclkbuf_8_177_0_CLK }
C {devices/lab_pin.sym} 115690 -8350 0 0 {name=p115241 lab=_81117_/CLK }
C {devices/lab_pin.sym} 115690 -8330 0 0 {name=p115242 lab=_75904_/X }
C {devices/lab_pin.sym} 115870 -8350 0 1 {name=p115243 lab=_80718_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -8340 0 0 {name=X_80718_ }
C {devices/lab_pin.sym} 115690 -8210 0 0 {name=p115244 lab=_87533_/CLK }
C {devices/lab_pin.sym} 115690 -8190 0 0 {name=p115245 lab=_43769_/X }
C {devices/lab_pin.sym} 115870 -8210 0 1 {name=p115246 lab=_69262_/B }
C {sky130_stdcells/dfxtp_4.sym} 115780 -8200 0 0 {name=X_87274_ }
C {devices/lab_pin.sym} 115740 -8070 0 0 {name=p115247 lab=_53733_/A }
C {devices/lab_pin.sym} 115820 -8070 0 1 {name=p115248 lab=_53666_/X }
C {sky130_stdcells/buf_2.sym} 115780 -8070 0 0 {name=X_53666_ }
C {devices/lab_pin.sym} 115700 -7970 0 0 {name=p115249 lab=_41659_/X }
C {devices/lab_pin.sym} 115700 -7930 0 0 {name=p115250 lab=_41330_/A }
C {devices/lab_pin.sym} 115700 -7890 0 0 {name=p115251 lab=_41679_/X }
C {devices/lab_pin.sym} 115860 -7930 0 1 {name=p115252 lab=_41680_/Y }
C {sky130_stdcells/o21ai_4.sym} 115780 -7930 0 0 {name=X_41680_ }
C {devices/lab_pin.sym} 115690 -7790 0 0 {name=p115253 lab=_83231_/CLK }
C {devices/lab_pin.sym} 115690 -7770 0 0 {name=p115254 lab=_84486_/D }
C {devices/lab_pin.sym} 115870 -7790 0 1 {name=p115255 lab=_79154_/B }
C {sky130_stdcells/dfxtp_4.sym} 115780 -7780 0 0 {name=X_84486_ }
C {devices/lab_pin.sym} 115740 -7650 0 0 {name=p115256 lab=clkbuf_9_86_0_CLK/X }
C {devices/lab_pin.sym} 115820 -7650 0 1 {name=p115257 lab=_81684_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 115780 -7650 0 0 {name=Xclkbuf_10_172_0_CLK }
C {devices/lab_pin.sym} 115720 -7540 0 0 {name=p115258 lab=_50822_/A }
C {devices/lab_pin.sym} 115720 -7500 0 0 {name=p115259 lab=_51394_/B }
C {devices/lab_pin.sym} 115840 -7520 0 1 {name=p115260 lab=_50878_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -7520 0 0 {name=X_50878_ }
C {devices/lab_pin.sym} 115690 -7390 0 0 {name=p115261 lab=_84020_/CLK }
C {devices/lab_pin.sym} 115690 -7370 0 0 {name=p115262 lab=_81698_/D }
C {devices/lab_pin.sym} 115870 -7390 0 1 {name=p115263 lab=_81698_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -7380 0 0 {name=X_81698_ }
C {devices/lab_pin.sym} 115740 -7250 0 0 {name=p115264 lab=_55405_/A }
C {devices/lab_pin.sym} 115820 -7250 0 1 {name=p115265 lab=_55405_/X }
C {sky130_stdcells/buf_2.sym} 115780 -7250 0 0 {name=X_55405_ }
C {devices/lab_pin.sym} 115690 -7130 0 0 {name=p115266 lab=_86222_/CLK }
C {devices/lab_pin.sym} 115690 -7110 0 0 {name=p115267 lab=_86225_/D }
C {devices/lab_pin.sym} 115870 -7130 0 1 {name=p115268 lab=_86225_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -7120 0 0 {name=X_86225_ }
C {sky130_stdcells/decap_3.sym} 115780 -6960 0 0 {name=XPHY_201 }
C {devices/lab_pin.sym} 115720 -6820 0 0 {name=p115269 lab=_40817_/A }
C {devices/lab_pin.sym} 115720 -6780 0 0 {name=p115270 lab=_82873_/Q }
C {devices/lab_pin.sym} 115840 -6800 0 1 {name=p115271 lab=_40631_/X }
C {sky130_stdcells/or2_4.sym} 115780 -6800 0 0 {name=X_40631_ }
C {devices/lab_pin.sym} 115700 -6690 0 0 {name=p115272 lab=_85785_/Q }
C {devices/lab_pin.sym} 115700 -6650 0 0 {name=p115273 lab=_52601_/X }
C {devices/lab_pin.sym} 115700 -6610 0 0 {name=p115274 lab=_52616_/Y }
C {devices/lab_pin.sym} 115860 -6650 0 1 {name=p115275 lab=_52617_/Y }
C {sky130_stdcells/o21ai_4.sym} 115780 -6650 0 0 {name=X_52617_ }
C {devices/lab_pin.sym} 115720 -6520 0 0 {name=p115276 lab=_86675_/Q }
C {devices/lab_pin.sym} 115720 -6480 0 0 {name=p115277 lab=_59068_/B }
C {devices/lab_pin.sym} 115840 -6500 0 1 {name=p115278 lab=_59173_/Y }
C {sky130_stdcells/nor2_4.sym} 115780 -6500 0 0 {name=X_59173_ }
C {devices/lab_pin.sym} 115700 -6390 0 0 {name=p115279 lab=_71445_/X }
C {devices/lab_pin.sym} 115700 -6350 0 0 {name=p115280 lab=_83495_/Q }
C {devices/lab_pin.sym} 115700 -6310 0 0 {name=p115281 lab=_71450_/Y }
C {devices/lab_pin.sym} 115860 -6350 0 1 {name=p115282 lab=_83495_/D }
C {sky130_stdcells/a21o_4.sym} 115780 -6350 0 0 {name=X_71451_ }
C {devices/lab_pin.sym} 115690 -6210 0 0 {name=p115283 lab=_83491_/CLK }
C {devices/lab_pin.sym} 115690 -6190 0 0 {name=p115284 lab=_83437_/D }
C {devices/lab_pin.sym} 115870 -6210 0 1 {name=p115285 lab=_83437_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -6200 0 0 {name=X_83437_ }
C {sky130_stdcells/decap_3.sym} 115780 -6040 0 0 {name=XPHY_212 }
C {devices/lab_pin.sym} 115740 -5880 0 0 {name=p115286 lab=_74803_/Y }
C {devices/lab_pin.sym} 115740 -5840 0 0 {name=p115287 lab=_74713_/Y }
C {devices/lab_pin.sym} 115820 -5880 0 1 {name=p115288 lab=DATA_FROM_HASH[6] }
C {sky130_stdcells/ebufn_2.sym} 115780 -5880 0 0 {name=X_80649_ }
C {devices/lab_pin.sym} 115740 -5750 0 0 {name=p115289 lab=_56436_/A }
C {devices/lab_pin.sym} 115820 -5750 0 1 {name=p115290 lab=_56386_/B }
C {sky130_stdcells/buf_2.sym} 115780 -5750 0 0 {name=X_56385_ }
C {devices/lab_pin.sym} 115720 -5640 0 0 {name=p115291 lab=_53601_/A }
C {devices/lab_pin.sym} 115720 -5600 0 0 {name=p115292 lab=_48122_/Y }
C {devices/lab_pin.sym} 115840 -5620 0 1 {name=p115293 lab=_53597_/Y }
C {sky130_stdcells/nand2_4.sym} 115780 -5620 0 0 {name=X_53597_ }
C {sky130_stdcells/decap_3.sym} 115780 -5460 0 0 {name=XPHY_223 }
C {sky130_stdcells/decap_3.sym} 115780 -5280 0 0 {name=XPHY_234 }
C {devices/lab_pin.sym} 115740 -5130 0 0 {name=p115294 lab=_58124_/A }
C {devices/lab_pin.sym} 115820 -5130 0 1 {name=p115295 lab=_58846_/A }
C {sky130_stdcells/buf_2.sym} 115780 -5130 0 0 {name=X_58124_ }
C {devices/lab_pin.sym} 115720 -5030 0 0 {name=p115296 lab=_70942_/A }
C {devices/lab_pin.sym} 115720 -4990 0 0 {name=p115297 lab=_74531_/A }
C {devices/lab_pin.sym} 115720 -4950 0 0 {name=p115298 lab=_70407_/C }
C {devices/lab_pin.sym} 115840 -4990 0 1 {name=p115299 lab=_70402_/Y }
C {sky130_stdcells/nand3_4.sym} 115780 -4990 0 0 {name=X_70402_ }
C {sky130_stdcells/decap_3.sym} 115780 -4820 0 0 {name=XPHY_245 }
C {devices/lab_pin.sym} 115740 -4670 0 0 {name=p115300 lab=_43305_/A }
C {devices/lab_pin.sym} 115820 -4670 0 1 {name=p115301 lab=_43350_/X }
C {sky130_stdcells/buf_2.sym} 115780 -4670 0 0 {name=X_43350_ }
C {devices/lab_pin.sym} 115700 -4570 0 0 {name=p115302 lab=_55333_/X }
C {devices/lab_pin.sym} 115700 -4530 0 0 {name=p115303 lab=_55335_/X }
C {devices/lab_pin.sym} 115700 -4490 0 0 {name=p115304 lab=_55309_/X }
C {devices/lab_pin.sym} 115860 -4530 0 1 {name=p115305 lab=_55336_/X }
C {sky130_stdcells/a21o_4.sym} 115780 -4530 0 0 {name=X_55336_ }
C {devices/lab_pin.sym} 115700 -4410 0 0 {name=p115306 lab=_44735_/Y }
C {devices/lab_pin.sym} 115700 -4370 0 0 {name=p115307 lab=_73491_/X }
C {devices/lab_pin.sym} 115700 -4330 0 0 {name=p115308 lab=_74169_/Y }
C {devices/lab_pin.sym} 115860 -4370 0 1 {name=p115309 lab=_74170_/X }
C {sky130_stdcells/a21o_4.sym} 115780 -4370 0 0 {name=X_74170_ }
C {devices/lab_pin.sym} 115690 -4230 0 0 {name=p115310 lab=_85837_/CLK }
C {devices/lab_pin.sym} 115690 -4210 0 0 {name=p115311 lab=_50673_/Y }
C {devices/lab_pin.sym} 115870 -4230 0 1 {name=p115312 lab=_86156_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -4220 0 0 {name=X_86156_ }
C {devices/lab_pin.sym} 115740 -4090 0 0 {name=p115313 lab=_40350_/A }
C {devices/lab_pin.sym} 115820 -4090 0 1 {name=p115314 lab=_42447_/B }
C {sky130_stdcells/inv_2.sym} 115780 -4090 0 0 {name=X_40562_ }
C {devices/lab_pin.sym} 115700 -3990 0 0 {name=p115315 lab=_52546_/Y }
C {devices/lab_pin.sym} 115700 -3950 0 0 {name=p115316 lab=_52541_/X }
C {devices/lab_pin.sym} 115700 -3910 0 0 {name=p115317 lab=_52547_/Y }
C {devices/lab_pin.sym} 115860 -3950 0 1 {name=p115318 lab=_85800_/D }
C {sky130_stdcells/a21boi_4.sym} 115780 -3950 0 0 {name=X_52548_ }
C {sky130_stdcells/decap_3.sym} 115780 -3780 0 0 {name=XPHY_256 }
C {devices/lab_pin.sym} 115700 -3650 0 0 {name=p115319 lab=_71373_/X }
C {devices/lab_pin.sym} 115700 -3610 0 0 {name=p115320 lab=_83519_/Q }
C {devices/lab_pin.sym} 115700 -3570 0 0 {name=p115321 lab=_71381_/Y }
C {devices/lab_pin.sym} 115860 -3610 0 1 {name=p115322 lab=_71382_/X }
C {sky130_stdcells/a21o_4.sym} 115780 -3610 0 0 {name=X_71382_ }
C {devices/lab_pin.sym} 115740 -3470 0 0 {name=p115323 lab=clkbuf_8_146_0_CLK/X }
C {devices/lab_pin.sym} 115820 -3470 0 1 {name=p115324 lab=clkbuf_9_293_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 115780 -3470 0 0 {name=Xclkbuf_9_293_0_CLK }
C {devices/lab_pin.sym} 115690 -3350 0 0 {name=p115325 lab=_83367_/CLK }
C {devices/lab_pin.sym} 115690 -3330 0 0 {name=p115326 lab=_83368_/D }
C {devices/lab_pin.sym} 115870 -3350 0 1 {name=p115327 lab=_83368_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -3340 0 0 {name=X_83368_ }
C {devices/lab_pin.sym} 115740 -3210 0 0 {name=p115328 lab=clkbuf_7_50_0_CLK/X }
C {devices/lab_pin.sym} 115820 -3210 0 1 {name=p115329 lab=clkbuf_9_201_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 115780 -3210 0 0 {name=Xclkbuf_8_100_0_CLK }
C {sky130_stdcells/decap_3.sym} 115780 -3060 0 0 {name=XPHY_267 }
C {sky130_stdcells/decap_3.sym} 115780 -2880 0 0 {name=XPHY_278 }
C {devices/lab_pin.sym} 115700 -2760 0 0 {name=p115330 lab=_41580_/X }
C {devices/lab_pin.sym} 115700 -2720 0 0 {name=p115331 lab=_42290_/X }
C {devices/lab_pin.sym} 115700 -2680 0 0 {name=p115332 lab=_87932_/Q }
C {devices/lab_pin.sym} 115700 -2640 0 0 {name=p115333 lab=_42291_/X }
C {devices/lab_pin.sym} 115860 -2700 0 1 {name=p115334 lab=_87932_/D }
C {sky130_stdcells/a2bb2o_4.sym} 115780 -2700 0 0 {name=X_42301_ }
C {devices/lab_pin.sym} 115720 -2560 0 0 {name=p115335 lab=_73121_/A }
C {devices/lab_pin.sym} 115720 -2520 0 0 {name=p115336 lab=_73120_/X }
C {devices/lab_pin.sym} 115840 -2540 0 1 {name=p115337 lab=_73121_/X }
C {sky130_stdcells/xor2_4.sym} 115780 -2540 0 0 {name=X_73121_ }
C {sky130_stdcells/decap_3.sym} 115780 -2380 0 0 {name=XPHY_289 }
C {devices/lab_pin.sym} 115690 -2230 0 0 {name=p115338 lab=_85042_/CLK }
C {devices/lab_pin.sym} 115690 -2210 0 0 {name=p115339 lab=_85107_/D }
C {devices/lab_pin.sym} 115870 -2230 0 1 {name=p115340 lab=_85107_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -2220 0 0 {name=X_85107_ }
C {devices/lab_pin.sym} 115720 -2100 0 0 {name=p115341 lab=_86633_/Q }
C {devices/lab_pin.sym} 115720 -2060 0 0 {name=p115342 lab=_57954_/X }
C {devices/lab_pin.sym} 115840 -2080 0 1 {name=p115343 lab=_58055_/Y }
C {sky130_stdcells/nor2_4.sym} 115780 -2080 0 0 {name=X_58055_ }
C {devices/lab_pin.sym} 115720 -1980 0 0 {name=p115344 lab=_70338_/A }
C {devices/lab_pin.sym} 115720 -1940 0 0 {name=p115345 lab=_70333_/B }
C {devices/lab_pin.sym} 115720 -1900 0 0 {name=p115346 lab=_83090_/Q }
C {devices/lab_pin.sym} 115720 -1860 0 0 {name=p115347 lab=_70332_/X }
C {devices/lab_pin.sym} 115840 -1920 0 1 {name=p115348 lab=_70333_/X }
C {sky130_stdcells/and4_4.sym} 115780 -1920 0 0 {name=X_70333_ }
C {devices/lab_pin.sym} 115690 -1770 0 0 {name=p115349 lab=_82327_/CLK }
C {devices/lab_pin.sym} 115690 -1750 0 0 {name=p115350 lab=_77094_/B }
C {devices/lab_pin.sym} 115870 -1770 0 1 {name=p115351 lab=_82319_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -1760 0 0 {name=X_82319_ }
C {devices/lab_pin.sym} 115740 -1630 0 0 {name=p115352 lab=clkbuf_9_93_0_CLK/X }
C {devices/lab_pin.sym} 115820 -1630 0 1 {name=p115353 lab=_81041_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 115780 -1630 0 0 {name=Xclkbuf_10_187_0_CLK }
C {devices/lab_pin.sym} 115740 -1510 0 0 {name=p115354 lab=_43280_/Y }
C {devices/lab_pin.sym} 115820 -1510 0 1 {name=p115355 lab=_87502_/D }
C {sky130_stdcells/inv_2.sym} 115780 -1510 0 0 {name=X_43281_ }
C {devices/lab_pin.sym} 115720 -1400 0 0 {name=p115356 lab=_55711_/A }
C {devices/lab_pin.sym} 115720 -1360 0 0 {name=p115357 lab=_57468_/A }
C {devices/lab_pin.sym} 115840 -1380 0 1 {name=p115358 lab=_55267_/X }
C {sky130_stdcells/and2_4.sym} 115780 -1380 0 0 {name=X_55267_ }
C {devices/lab_pin.sym} 115690 -1250 0 0 {name=p115359 lab=_85767_/CLK }
C {devices/lab_pin.sym} 115690 -1230 0 0 {name=p115360 lab=_51030_/Y }
C {devices/lab_pin.sym} 115870 -1250 0 1 {name=p115361 lab=_86087_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -1240 0 0 {name=X_86087_ }
C {devices/lab_pin.sym} 115700 -1150 0 0 {name=p115362 lab=_40477_/X }
C {devices/lab_pin.sym} 115700 -1110 0 0 {name=p115363 lab=_40488_/X }
C {devices/lab_pin.sym} 115700 -1070 0 0 {name=p115364 lab=_40491_/X }
C {devices/lab_pin.sym} 115700 -1030 0 0 {name=p115365 lab=_88383_/Q }
C {devices/lab_pin.sym} 115700 -990 0 0 {name=p115366 lab=_40492_/X }
C {devices/lab_pin.sym} 115860 -1070 0 1 {name=p115367 lab=_40494_/A }
C {sky130_stdcells/o32ai_4.sym} 115780 -1070 0 0 {name=X_40493_ }
C {devices/lab_pin.sym} 115700 -930 0 0 {name=p115368 lab=_52477_/Y }
C {devices/lab_pin.sym} 115700 -890 0 0 {name=p115369 lab=_52462_/X }
C {devices/lab_pin.sym} 115700 -850 0 0 {name=p115370 lab=_52478_/Y }
C {devices/lab_pin.sym} 115860 -890 0 1 {name=p115371 lab=_52479_/Y }
C {sky130_stdcells/a21boi_4.sym} 115780 -890 0 0 {name=X_52479_ }
C {devices/lab_pin.sym} 115690 -750 0 0 {name=p115372 lab=_85555_/CLK }
C {devices/lab_pin.sym} 115690 -730 0 0 {name=p115373 lab=_83299_/D }
C {devices/lab_pin.sym} 115870 -750 0 1 {name=p115374 lab=_83299_/Q }
C {sky130_stdcells/dfxtp_4.sym} 115780 -740 0 0 {name=X_83299_ }
C {devices/lab_pin.sym} 116640 -42160 0 0 {name=p115375 lab=_45020_/A }
C {devices/lab_pin.sym} 116640 -42120 0 0 {name=p115376 lab=_45033_/B }
C {devices/lab_pin.sym} 116760 -42140 0 1 {name=p115377 lab=_45020_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -42140 0 0 {name=X_45020_ }
C {devices/lab_pin.sym} 116620 -42040 0 0 {name=p115378 lab=_85102_/Q }
C {devices/lab_pin.sym} 116620 -42000 0 0 {name=p115379 lab=_57084_/A }
C {devices/lab_pin.sym} 116620 -41960 0 0 {name=p115380 lab=_57004_/Y }
C {devices/lab_pin.sym} 116620 -41920 0 0 {name=p115381 lab=_57005_/Y }
C {devices/lab_pin.sym} 116780 -41980 0 1 {name=p115382 lab=_85102_/D }
C {sky130_stdcells/a211o_4.sym} 116700 -41980 0 0 {name=X_57006_ }
C {devices/lab_pin.sym} 116620 -41870 0 0 {name=p115383 lab=_42231_/X }
C {devices/lab_pin.sym} 116620 -41830 0 0 {name=p115384 lab=_42226_/X }
C {devices/lab_pin.sym} 116620 -41790 0 0 {name=p115385 lab=_41382_/X }
C {devices/lab_pin.sym} 116620 -41750 0 0 {name=p115386 lab=_87969_/Q }
C {devices/lab_pin.sym} 116620 -41710 0 0 {name=p115387 lab=_42228_/X }
C {devices/lab_pin.sym} 116780 -41790 0 1 {name=p115388 lab=_42232_/Y }
C {sky130_stdcells/o32ai_4.sym} 116700 -41790 0 0 {name=X_42232_ }
C {devices/lab_pin.sym} 116640 -41660 0 0 {name=p115389 lab=_54208_/X }
C {devices/lab_pin.sym} 116640 -41620 0 0 {name=p115390 lab=_54237_/B }
C {devices/lab_pin.sym} 116640 -41580 0 0 {name=p115391 lab=_54209_/C }
C {devices/lab_pin.sym} 116640 -41540 0 0 {name=p115392 lab=_53052_/D }
C {devices/lab_pin.sym} 116760 -41600 0 1 {name=p115393 lab=_54218_/X }
C {sky130_stdcells/and4_4.sym} 116700 -41600 0 0 {name=X_54218_ }
C {devices/lab_pin.sym} 116610 -41450 0 0 {name=p115394 lab=_85037_/CLK }
C {devices/lab_pin.sym} 116610 -41430 0 0 {name=p115395 lab=_57302_/Y }
C {devices/lab_pin.sym} 116790 -41450 0 1 {name=p115396 lab=_85038_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -41440 0 0 {name=X_85038_ }
C {devices/lab_pin.sym} 116660 -41310 0 0 {name=p115397 lab=_72795_/A }
C {devices/lab_pin.sym} 116740 -41310 0 1 {name=p115398 lab=_73053_/B }
C {sky130_stdcells/buf_2.sym} 116700 -41310 0 0 {name=X_73052_ }
C {devices/lab_pin.sym} 116660 -41190 0 0 {name=p115399 lab=_70249_/X }
C {devices/lab_pin.sym} 116740 -41190 0 1 {name=p115400 lab=_70264_/X }
C {sky130_stdcells/buf_2.sym} 116700 -41190 0 0 {name=X_70264_ }
C {devices/lab_pin.sym} 116640 -41080 0 0 {name=p115401 lab=_55171_/X }
C {devices/lab_pin.sym} 116640 -41040 0 0 {name=p115402 lab=_55178_/X }
C {devices/lab_pin.sym} 116760 -41060 0 1 {name=p115403 lab=_55199_/A }
C {sky130_stdcells/and2_4.sym} 116700 -41060 0 0 {name=X_55198_ }
C {devices/lab_pin.sym} 116640 -40940 0 0 {name=p115404 lab=_72040_/A }
C {devices/lab_pin.sym} 116640 -40900 0 0 {name=p115405 lab=_48973_/A }
C {devices/lab_pin.sym} 116760 -40920 0 1 {name=p115406 lab=_72003_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -40920 0 0 {name=X_72003_ }
C {devices/lab_pin.sym} 116620 -40820 0 0 {name=p115407 lab=_41199_/X }
C {devices/lab_pin.sym} 116620 -40780 0 0 {name=p115408 lab=_42161_/X }
C {devices/lab_pin.sym} 116620 -40740 0 0 {name=p115409 lab=_88003_/Q }
C {devices/lab_pin.sym} 116620 -40700 0 0 {name=p115410 lab=_42162_/X }
C {devices/lab_pin.sym} 116780 -40760 0 1 {name=p115411 lab=_88003_/D }
C {sky130_stdcells/a2bb2o_4.sym} 116700 -40760 0 0 {name=X_42163_ }
C {devices/lab_pin.sym} 116640 -40620 0 0 {name=p115412 lab=_54149_/A }
C {devices/lab_pin.sym} 116640 -40580 0 0 {name=p115413 lab=_47313_/Y }
C {devices/lab_pin.sym} 116760 -40600 0 1 {name=p115414 lab=_54149_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -40600 0 0 {name=X_54149_ }
C {devices/lab_pin.sym} 116640 -40480 0 0 {name=p115415 lab=_77855_/Y }
C {devices/lab_pin.sym} 116640 -40440 0 0 {name=p115416 lab=_77860_/B }
C {devices/lab_pin.sym} 116760 -40460 0 1 {name=p115417 lab=_77875_/A }
C {sky130_stdcells/nand2_4.sym} 116700 -40460 0 0 {name=X_77860_ }
C {devices/lab_pin.sym} 116660 -40330 0 0 {name=p115418 lab=clkbuf_7_57_0_CLK/X }
C {devices/lab_pin.sym} 116740 -40330 0 1 {name=p115419 lab=clkbuf_9_230_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 116700 -40330 0 0 {name=Xclkbuf_8_115_0_CLK }
C {devices/lab_pin.sym} 116660 -40210 0 0 {name=p115420 lab=_70209_/A }
C {devices/lab_pin.sym} 116740 -40210 0 1 {name=p115421 lab=_70195_/X }
C {sky130_stdcells/buf_2.sym} 116700 -40210 0 0 {name=X_70195_ }
C {devices/lab_pin.sym} 116660 -40090 0 0 {name=p115422 lab=clkbuf_9_55_0_CLK/X }
C {devices/lab_pin.sym} 116740 -40090 0 1 {name=p115423 lab=_87183_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 116700 -40090 0 0 {name=Xclkbuf_10_110_0_CLK }
C {devices/lab_pin.sym} 116640 -39980 0 0 {name=p115424 lab=_41114_/A }
C {devices/lab_pin.sym} 116640 -39940 0 0 {name=p115425 lab=_41079_/X }
C {devices/lab_pin.sym} 116760 -39960 0 1 {name=p115426 lab=_41114_/X }
C {sky130_stdcells/or2_4.sym} 116700 -39960 0 0 {name=X_41114_ }
C {devices/lab_pin.sym} 116640 -39840 0 0 {name=p115427 lab=_81668_/Q }
C {devices/lab_pin.sym} 116640 -39800 0 0 {name=p115428 lab=_76811_/B }
C {devices/lab_pin.sym} 116760 -39820 0 1 {name=p115429 lab=_76811_/Y }
C {sky130_stdcells/xnor2_4.sym} 116700 -39820 0 0 {name=X_76811_ }
C {devices/lab_pin.sym} 116660 -39690 0 0 {name=p115430 lab=clkbuf_9_370_0_CLK/X }
C {devices/lab_pin.sym} 116740 -39690 0 1 {name=p115431 lab=_87749_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 116700 -39690 0 0 {name=Xclkbuf_10_740_0_CLK }
C {devices/lab_pin.sym} 116660 -39570 0 0 {name=p115432 lab=_82396_/Q }
C {devices/lab_pin.sym} 116740 -39570 0 1 {name=p115433 lab=_46971_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -39570 0 0 {name=X_46971_ }
C {devices/lab_pin.sym} 116660 -39450 0 0 {name=p115434 lab=_42077_/A }
C {devices/lab_pin.sym} 116740 -39450 0 1 {name=p115435 lab=_42094_/X }
C {sky130_stdcells/buf_2.sym} 116700 -39450 0 0 {name=X_42094_ }
C {devices/lab_pin.sym} 116640 -39340 0 0 {name=p115436 lab=_58920_/A }
C {devices/lab_pin.sym} 116640 -39300 0 0 {name=p115437 lab=_58957_/B }
C {devices/lab_pin.sym} 116760 -39320 0 1 {name=p115438 lab=_58957_/Y }
C {sky130_stdcells/nor2_4.sym} 116700 -39320 0 0 {name=X_58957_ }
C {devices/lab_pin.sym} 116640 -39200 0 0 {name=p115439 lab=_77796_/B }
C {devices/lab_pin.sym} 116640 -39160 0 0 {name=p115440 lab=_77791_/B }
C {devices/lab_pin.sym} 116760 -39180 0 1 {name=p115441 lab=_77792_/B }
C {sky130_stdcells/xnor2_4.sym} 116700 -39180 0 0 {name=X_77791_ }
C {devices/lab_pin.sym} 116610 -39050 0 0 {name=p115442 lab=_86989_/CLK }
C {devices/lab_pin.sym} 116610 -39030 0 0 {name=p115443 lab=_86989_/D }
C {devices/lab_pin.sym} 116790 -39050 0 1 {name=p115444 lab=_73985_/A }
C {sky130_stdcells/dfxtp_4.sym} 116700 -39040 0 0 {name=X_86989_ }
C {devices/lab_pin.sym} 116660 -38910 0 0 {name=p115445 lab=_48874_/B }
C {devices/lab_pin.sym} 116740 -38910 0 1 {name=p115446 lab=_50556_/B }
C {sky130_stdcells/buf_2.sym} 116700 -38910 0 0 {name=X_48710_ }
C {devices/lab_pin.sym} 116640 -38800 0 0 {name=p115447 lab=_79527_/Y }
C {devices/lab_pin.sym} 116640 -38760 0 0 {name=p115448 lab=_79529_/Y }
C {devices/lab_pin.sym} 116760 -38780 0 1 {name=p115449 lab=_79895_/A }
C {sky130_stdcells/nand2_4.sym} 116700 -38780 0 0 {name=X_79530_ }
C {devices/lab_pin.sym} 116660 -38650 0 0 {name=p115450 lab=_64902_/A }
C {devices/lab_pin.sym} 116740 -38650 0 1 {name=p115451 lab=_45922_/X }
C {sky130_stdcells/buf_2.sym} 116700 -38650 0 0 {name=X_45922_ }
C {devices/lab_pin.sym} 116660 -38530 0 0 {name=p115452 lab=_41045_/A }
C {devices/lab_pin.sym} 116740 -38530 0 1 {name=p115453 lab=_41045_/X }
C {sky130_stdcells/buf_2.sym} 116700 -38530 0 0 {name=X_41045_ }
C {devices/lab_pin.sym} 116660 -38410 0 0 {name=p115454 lab=_58882_/A }
C {devices/lab_pin.sym} 116740 -38410 0 1 {name=p115455 lab=_58610_/A }
C {sky130_stdcells/buf_2.sym} 116700 -38410 0 0 {name=X_57908_ }
C {devices/lab_pin.sym} 116620 -38310 0 0 {name=p115456 lab=_81483_/Q }
C {devices/lab_pin.sym} 116620 -38270 0 0 {name=p115457 lab=_81355_/D }
C {devices/lab_pin.sym} 116620 -38230 0 0 {name=p115458 lab=_76741_/X }
C {devices/lab_pin.sym} 116780 -38270 0 1 {name=p115459 lab=_76742_/Y }
C {sky130_stdcells/o21ai_4.sym} 116700 -38270 0 0 {name=X_76742_ }
C {devices/lab_pin.sym} 116640 -38140 0 0 {name=p115460 lab=_49699_/A }
C {devices/lab_pin.sym} 116640 -38100 0 0 {name=p115461 lab=_47184_/X }
C {devices/lab_pin.sym} 116760 -38120 0 1 {name=p115462 lab=_49690_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -38120 0 0 {name=X_49690_ }
C {devices/lab_pin.sym} 116640 -38000 0 0 {name=p115463 lab=_73954_/A }
C {devices/lab_pin.sym} 116640 -37960 0 0 {name=p115464 lab=_86545_/Q }
C {devices/lab_pin.sym} 116760 -37980 0 1 {name=p115465 lab=_73954_/X }
C {sky130_stdcells/and2_4.sym} 116700 -37980 0 0 {name=X_73954_ }
C {devices/lab_pin.sym} 116660 -37850 0 0 {name=p115466 lab=clkbuf_9_230_0_CLK/A }
C {devices/lab_pin.sym} 116740 -37850 0 1 {name=p115467 lab=clkbuf_9_231_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 116700 -37850 0 0 {name=Xclkbuf_9_231_0_CLK }
C {devices/lab_pin.sym} 116620 -37770 0 0 {name=p115468 lab=_58828_/X }
C {devices/lab_pin.sym} 116620 -37730 0 0 {name=p115469 lab=_58886_/Y }
C {devices/lab_pin.sym} 116620 -37690 0 0 {name=p115470 lab=_58887_/Y }
C {devices/lab_pin.sym} 116620 -37650 0 0 {name=p115471 lab=_58874_/X }
C {devices/lab_pin.sym} 116620 -37610 0 0 {name=p115472 lab=_58832_/X }
C {devices/lab_pin.sym} 116780 -37690 0 1 {name=p115473 lab=_58888_/X }
C {sky130_stdcells/o32a_4.sym} 116700 -37690 0 0 {name=X_58888_ }
C {devices/lab_pin.sym} 116620 -37550 0 0 {name=p115474 lab=_86504_/Q }
C {devices/lab_pin.sym} 116620 -37510 0 0 {name=p115475 lab=_48612_/X }
C {devices/lab_pin.sym} 116620 -37470 0 0 {name=p115476 lab=_48640_/Y }
C {devices/lab_pin.sym} 116780 -37510 0 1 {name=p115477 lab=_48641_/Y }
C {sky130_stdcells/o21ai_4.sym} 116700 -37510 0 0 {name=X_48641_ }
C {devices/lab_pin.sym} 116660 -37370 0 0 {name=p115478 lab=_72905_/A }
C {devices/lab_pin.sym} 116740 -37370 0 1 {name=p115479 lab=_72905_/X }
C {sky130_stdcells/buf_2.sym} 116700 -37370 0 0 {name=X_72905_ }
C {devices/lab_pin.sym} 116620 -37270 0 0 {name=p115480 lab=_79449_/A }
C {devices/lab_pin.sym} 116620 -37230 0 0 {name=p115481 lab=_79448_/Y }
C {devices/lab_pin.sym} 116620 -37190 0 0 {name=p115482 lab=_79460_/X }
C {devices/lab_pin.sym} 116780 -37230 0 1 {name=p115483 lab=_79461_/X }
C {sky130_stdcells/a21o_4.sym} 116700 -37230 0 0 {name=X_79461_ }
C {devices/lab_pin.sym} 116660 -37090 0 0 {name=p115484 lab=_85059_/Q }
C {devices/lab_pin.sym} 116740 -37090 0 1 {name=p115485 lab=_55221_/B }
C {sky130_stdcells/inv_2.sym} 116700 -37090 0 0 {name=X_45853_ }
C {devices/lab_pin.sym} 116620 -36990 0 0 {name=p115486 lab=_57739_/X }
C {devices/lab_pin.sym} 116620 -36950 0 0 {name=p115487 lab=_85722_/Q }
C {devices/lab_pin.sym} 116620 -36910 0 0 {name=p115488 lab=_57814_/X }
C {devices/lab_pin.sym} 116780 -36950 0 1 {name=p115489 lab=_57839_/X }
C {sky130_stdcells/o21a_4.sym} 116700 -36950 0 0 {name=X_57839_ }
C {devices/lab_pin.sym} 116640 -36820 0 0 {name=p115490 lab=_76673_/A }
C {devices/lab_pin.sym} 116640 -36780 0 0 {name=p115491 lab=_76672_/Y }
C {devices/lab_pin.sym} 116760 -36800 0 1 {name=p115492 lab=_76673_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -36800 0 0 {name=X_76673_ }
C {devices/lab_pin.sym} 116660 -36670 0 0 {name=p115493 lab=clkbuf_9_62_0_CLK/X }
C {devices/lab_pin.sym} 116740 -36670 0 1 {name=p115494 lab=_84393_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 116700 -36670 0 0 {name=Xclkbuf_10_125_0_CLK }
C {devices/lab_pin.sym} 116640 -36560 0 0 {name=p115495 lab=_73885_/A }
C {devices/lab_pin.sym} 116640 -36520 0 0 {name=p115496 lab=_73884_/X }
C {devices/lab_pin.sym} 116760 -36540 0 1 {name=p115497 lab=_73886_/B }
C {sky130_stdcells/nand2_4.sym} 116700 -36540 0 0 {name=X_73885_ }
C {devices/lab_pin.sym} 116660 -36410 0 0 {name=p115498 lab=_78412_/A }
C {devices/lab_pin.sym} 116740 -36410 0 1 {name=p115499 lab=_78412_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -36410 0 0 {name=X_78412_ }
C {devices/lab_pin.sym} 116620 -36320 0 0 {name=p115500 lab=_41446_/Y }
C {devices/lab_pin.sym} 116620 -36280 0 0 {name=p115501 lab=_46258_/A }
C {devices/lab_pin.sym} 116620 -36240 0 0 {name=p115502 lab=_86945_/Q }
C {devices/lab_pin.sym} 116620 -36200 0 0 {name=p115503 lab=_40354_/X }
C {devices/lab_pin.sym} 116780 -36260 0 1 {name=p115504 lab=_86945_/D }
C {sky130_stdcells/a2bb2o_4.sym} 116700 -36260 0 0 {name=X_44804_ }
C {devices/lab_pin.sym} 116660 -36110 0 0 {name=p115505 lab=clkbuf_9_377_0_CLK/X }
C {devices/lab_pin.sym} 116740 -36110 0 1 {name=p115506 lab=_88034_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 116700 -36110 0 0 {name=Xclkbuf_10_755_0_CLK }
C {devices/lab_pin.sym} 116620 -36010 0 0 {name=p115507 lab=_75621_/X }
C {devices/lab_pin.sym} 116620 -35970 0 0 {name=p115508 lab=_75622_/Y }
C {devices/lab_pin.sym} 116620 -35930 0 0 {name=p115509 lab=_75623_/X }
C {devices/lab_pin.sym} 116780 -35970 0 1 {name=p115510 lab=_75625_/A }
C {sky130_stdcells/a21oi_4.sym} 116700 -35970 0 0 {name=X_75624_ }
C {devices/lab_pin.sym} 116660 -35830 0 0 {name=p115511 lab=_48572_/A }
C {devices/lab_pin.sym} 116740 -35830 0 1 {name=p115512 lab=_48811_/B }
C {sky130_stdcells/buf_2.sym} 116700 -35830 0 0 {name=X_48572_ }
C {devices/lab_pin.sym} 116640 -35720 0 0 {name=p115513 lab=_72929_/A }
C {devices/lab_pin.sym} 116640 -35680 0 0 {name=p115514 lab=_72836_/B }
C {devices/lab_pin.sym} 116760 -35700 0 1 {name=p115515 lab=_72836_/X }
C {sky130_stdcells/and2_4.sym} 116700 -35700 0 0 {name=X_72836_ }
C {devices/lab_pin.sym} 116660 -35570 0 0 {name=p115516 lab=_60909_/A }
C {devices/lab_pin.sym} 116740 -35570 0 1 {name=p115517 lab=_60997_/A }
C {sky130_stdcells/buf_2.sym} 116700 -35570 0 0 {name=X_60850_ }
C {devices/lab_pin.sym} 116620 -35470 0 0 {name=p115518 lab=_58711_/Y }
C {devices/lab_pin.sym} 116620 -35430 0 0 {name=p115519 lab=_66429_/C }
C {devices/lab_pin.sym} 116620 -35390 0 0 {name=p115520 lab=_79391_/Y }
C {devices/lab_pin.sym} 116780 -35430 0 1 {name=p115521 lab=_79392_/X }
C {sky130_stdcells/o21a_4.sym} 116700 -35430 0 0 {name=X_79392_ }
C {devices/lab_pin.sym} 116620 -35310 0 0 {name=p115522 lab=_45781_/Y }
C {devices/lab_pin.sym} 116620 -35270 0 0 {name=p115523 lab=_45783_/Y }
C {devices/lab_pin.sym} 116620 -35230 0 0 {name=p115524 lab=_45757_/X }
C {devices/lab_pin.sym} 116780 -35270 0 1 {name=p115525 lab=_45784_/X }
C {sky130_stdcells/a21o_4.sym} 116700 -35270 0 0 {name=X_45784_ }
C {devices/lab_pin.sym} 116620 -35160 0 0 {name=p115526 lab=_40497_/X }
C {devices/lab_pin.sym} 116620 -35120 0 0 {name=p115527 lab=_42994_/X }
C {devices/lab_pin.sym} 116620 -35080 0 0 {name=p115528 lab=_87614_/Q }
C {devices/lab_pin.sym} 116620 -35040 0 0 {name=p115529 lab=_42995_/X }
C {devices/lab_pin.sym} 116780 -35100 0 1 {name=p115530 lab=_87614_/D }
C {sky130_stdcells/a2bb2o_4.sym} 116700 -35100 0 0 {name=X_42996_ }
C {devices/lab_pin.sym} 116620 -34970 0 0 {name=p115531 lab=_47518_/Y }
C {devices/lab_pin.sym} 116620 -34930 0 0 {name=p115532 lab=_47509_/X }
C {devices/lab_pin.sym} 116620 -34890 0 0 {name=p115533 lab=_47522_/X }
C {devices/lab_pin.sym} 116780 -34930 0 1 {name=p115534 lab=_86626_/D }
C {sky130_stdcells/a21oi_4.sym} 116700 -34930 0 0 {name=X_47523_ }
C {devices/lab_pin.sym} 116660 -34790 0 0 {name=p115535 lab=_59508_/X }
C {devices/lab_pin.sym} 116740 -34790 0 1 {name=p115536 lab=_59509_/X }
C {sky130_stdcells/buf_2.sym} 116700 -34790 0 0 {name=X_59509_ }
C {devices/lab_pin.sym} 116660 -34670 0 0 {name=p115537 lab=_78342_/Y }
C {devices/lab_pin.sym} 116740 -34670 0 1 {name=p115538 lab=_78343_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -34670 0 0 {name=X_78343_ }
C {devices/lab_pin.sym} 116660 -34550 0 0 {name=p115539 lab=clkbuf_9_247_0_CLK/A }
C {devices/lab_pin.sym} 116740 -34550 0 1 {name=p115540 lab=clkbuf_9_246_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 116700 -34550 0 0 {name=Xclkbuf_9_246_0_CLK }
C {devices/lab_pin.sym} 116660 -34430 0 0 {name=p115541 lab=_86981_/Q }
C {devices/lab_pin.sym} 116740 -34430 0 1 {name=p115542 lab=_44735_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -34430 0 0 {name=X_44735_ }
C {devices/lab_pin.sym} 116660 -34310 0 0 {name=p115543 lab=_75555_/A }
C {devices/lab_pin.sym} 116740 -34310 0 1 {name=p115544 lab=_75555_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -34310 0 0 {name=X_75555_ }
C {devices/lab_pin.sym} 116660 -34190 0 0 {name=p115545 lab=_88096_/Q }
C {devices/lab_pin.sym} 116740 -34190 0 1 {name=p115546 lab=_41947_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -34190 0 0 {name=X_41947_ }
C {devices/lab_pin.sym} 116640 -34080 0 0 {name=p115547 lab=_60781_/A }
C {devices/lab_pin.sym} 116640 -34040 0 0 {name=p115548 lab=_60780_/X }
C {devices/lab_pin.sym} 116760 -34060 0 1 {name=p115549 lab=_60781_/Y }
C {sky130_stdcells/nor2_4.sym} 116700 -34060 0 0 {name=X_60781_ }
C {devices/lab_pin.sym} 116620 -33950 0 0 {name=p115550 lab=_72763_/X }
C {devices/lab_pin.sym} 116620 -33910 0 0 {name=p115551 lab=_72764_/Y }
C {devices/lab_pin.sym} 116620 -33870 0 0 {name=p115552 lab=_72766_/X }
C {devices/lab_pin.sym} 116780 -33910 0 1 {name=p115553 lab=_72767_/Y }
C {sky130_stdcells/a21oi_4.sym} 116700 -33910 0 0 {name=X_72767_ }
C {devices/lab_pin.sym} 116660 -33770 0 0 {name=p115554 lab=_62520_/A }
C {devices/lab_pin.sym} 116740 -33770 0 1 {name=p115555 lab=_62561_/B }
C {sky130_stdcells/buf_2.sym} 116700 -33770 0 0 {name=X_62520_ }
C {devices/lab_pin.sym} 116620 -33670 0 0 {name=p115556 lab=_74504_/Y }
C {devices/lab_pin.sym} 116620 -33630 0 0 {name=p115557 lab=_74492_/X }
C {devices/lab_pin.sym} 116620 -33590 0 0 {name=p115558 lab=_74505_/X }
C {devices/lab_pin.sym} 116780 -33630 0 1 {name=p115559 lab=_74506_/Y }
C {sky130_stdcells/a21oi_4.sym} 116700 -33630 0 0 {name=X_74506_ }
C {devices/lab_pin.sym} 116660 -33490 0 0 {name=p115560 lab=_81801_/Q }
C {devices/lab_pin.sym} 116740 -33490 0 1 {name=p115561 lab=_54748_/D }
C {sky130_stdcells/inv_2.sym} 116700 -33490 0 0 {name=X_47454_ }
C {devices/lab_pin.sym} 116660 -33370 0 0 {name=p115562 lab=_71711_/Y }
C {devices/lab_pin.sym} 116740 -33370 0 1 {name=p115563 lab=_71718_/X }
C {sky130_stdcells/buf_2.sym} 116700 -33370 0 0 {name=X_71718_ }
C {devices/lab_pin.sym} 116640 -33260 0 0 {name=p115564 lab=_78274_/A }
C {devices/lab_pin.sym} 116640 -33220 0 0 {name=p115565 lab=_78284_/B }
C {devices/lab_pin.sym} 116760 -33240 0 1 {name=p115566 lab=_78274_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -33240 0 0 {name=X_78274_ }
C {devices/lab_pin.sym} 116660 -33110 0 0 {name=p115567 lab=_44650_/A }
C {devices/lab_pin.sym} 116740 -33110 0 1 {name=p115568 lab=_44666_/X }
C {sky130_stdcells/buf_2.sym} 116700 -33110 0 0 {name=X_44666_ }
C {devices/lab_pin.sym} 116640 -33000 0 0 {name=p115569 lab=_75486_/A }
C {devices/lab_pin.sym} 116640 -32960 0 0 {name=p115570 lab=_75485_/X }
C {devices/lab_pin.sym} 116760 -32980 0 1 {name=p115571 lab=_75486_/X }
C {sky130_stdcells/xor2_4.sym} 116700 -32980 0 0 {name=X_75486_ }
C {devices/lab_pin.sym} 116660 -32850 0 0 {name=p115572 lab=_41878_/A }
C {devices/lab_pin.sym} 116740 -32850 0 1 {name=p115573 lab=_42547_/A }
C {sky130_stdcells/buf_2.sym} 116700 -32850 0 0 {name=X_41878_ }
C {devices/lab_pin.sym} 116620 -32750 0 0 {name=p115574 lab=_70241_/C }
C {devices/lab_pin.sym} 116620 -32710 0 0 {name=p115575 lab=_72686_/X }
C {devices/lab_pin.sym} 116620 -32670 0 0 {name=p115576 lab=_72697_/Y }
C {devices/lab_pin.sym} 116780 -32710 0 1 {name=p115577 lab=_83185_/D }
C {sky130_stdcells/a21bo_4.sym} 116700 -32710 0 0 {name=X_72698_ }
C {devices/lab_pin.sym} 116640 -32580 0 0 {name=p115578 lab=_82932_/Q }
C {devices/lab_pin.sym} 116640 -32540 0 0 {name=p115579 lab=_46459_/B }
C {devices/lab_pin.sym} 116760 -32560 0 1 {name=p115580 lab=_46405_/X }
C {sky130_stdcells/or2_4.sym} 116700 -32560 0 0 {name=X_46405_ }
C {devices/lab_pin.sym} 116660 -32430 0 0 {name=p115581 lab=_77227_/C }
C {devices/lab_pin.sym} 116740 -32430 0 1 {name=p115582 lab=_77225_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -32430 0 0 {name=X_77225_ }
C {devices/lab_pin.sym} 116620 -32340 0 0 {name=p115583 lab=_40617_/X }
C {devices/lab_pin.sym} 116620 -32300 0 0 {name=p115584 lab=_43604_/X }
C {devices/lab_pin.sym} 116620 -32260 0 0 {name=p115585 lab=_87341_/Q }
C {devices/lab_pin.sym} 116620 -32220 0 0 {name=p115586 lab=_43607_/X }
C {devices/lab_pin.sym} 116780 -32280 0 1 {name=p115587 lab=_43617_/X }
C {sky130_stdcells/a2bb2o_4.sym} 116700 -32280 0 0 {name=X_43617_ }
C {devices/lab_pin.sym} 116640 -32160 0 0 {name=p115588 lab=_62493_/A }
C {devices/lab_pin.sym} 116640 -32120 0 0 {name=p115589 lab=_62446_/Y }
C {devices/lab_pin.sym} 116640 -32080 0 0 {name=p115590 lab=_62451_/C }
C {devices/lab_pin.sym} 116640 -32040 0 0 {name=p115591 lab=_62450_/Y }
C {devices/lab_pin.sym} 116760 -32100 0 1 {name=p115592 lab=_62451_/Y }
C {sky130_stdcells/nand4_4.sym} 116700 -32100 0 0 {name=X_62451_ }
C {devices/lab_pin.sym} 116640 -31960 0 0 {name=p115593 lab=_74466_/A }
C {devices/lab_pin.sym} 116640 -31920 0 0 {name=p115594 lab=_74437_/B }
C {devices/lab_pin.sym} 116760 -31940 0 1 {name=p115595 lab=_74437_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -31940 0 0 {name=X_74437_ }
C {devices/lab_pin.sym} 116640 -31820 0 0 {name=p115596 lab=_40829_/A }
C {devices/lab_pin.sym} 116640 -31780 0 0 {name=p115597 lab=_40829_/B }
C {devices/lab_pin.sym} 116760 -31800 0 1 {name=p115598 lab=_40829_/X }
C {sky130_stdcells/or2_4.sym} 116700 -31800 0 0 {name=X_40829_ }
C {devices/lab_pin.sym} 116660 -31670 0 0 {name=p115599 lab=_47385_/A }
C {devices/lab_pin.sym} 116740 -31670 0 1 {name=p115600 lab=_47385_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -31670 0 0 {name=X_47385_ }
C {devices/lab_pin.sym} 116660 -31550 0 0 {name=p115601 lab=_71649_/A }
C {devices/lab_pin.sym} 116740 -31550 0 1 {name=p115602 lab=_71649_/X }
C {sky130_stdcells/buf_2.sym} 116700 -31550 0 0 {name=X_71649_ }
C {devices/lab_pin.sym} 116620 -31470 0 0 {name=p115603 lab=_44593_/X }
C {devices/lab_pin.sym} 116620 -31430 0 0 {name=p115604 lab=_44594_/X }
C {devices/lab_pin.sym} 116620 -31390 0 0 {name=p115605 lab=_40921_/X }
C {devices/lab_pin.sym} 116620 -31350 0 0 {name=p115606 lab=_44595_/Y }
C {devices/lab_pin.sym} 116620 -31310 0 0 {name=p115607 lab=_44596_/X }
C {devices/lab_pin.sym} 116780 -31390 0 1 {name=p115608 lab=_87042_/D }
C {sky130_stdcells/o32ai_4.sym} 116700 -31390 0 0 {name=X_44597_ }
C {devices/lab_pin.sym} 116660 -31230 0 0 {name=p115609 lab=_83601_/Q }
C {devices/lab_pin.sym} 116740 -31230 0 1 {name=p115610 lab=_72077_/B }
C {sky130_stdcells/inv_2.sym} 116700 -31230 0 0 {name=X_49124_ }
C {devices/lab_pin.sym} 116640 -31130 0 0 {name=p115611 lab=_61377_/A }
C {devices/lab_pin.sym} 116640 -31090 0 0 {name=p115612 lab=_61399_/X }
C {devices/lab_pin.sym} 116640 -31050 0 0 {name=p115613 lab=_61429_/C }
C {devices/lab_pin.sym} 116760 -31090 0 1 {name=p115614 lab=_61402_/Y }
C {sky130_stdcells/nand3_4.sym} 116700 -31090 0 0 {name=X_61402_ }
C {devices/lab_pin.sym} 116620 -30970 0 0 {name=p115615 lab=_86746_/Q }
C {devices/lab_pin.sym} 116620 -30930 0 0 {name=p115616 lab=_46279_/X }
C {devices/lab_pin.sym} 116620 -30890 0 0 {name=p115617 lab=_46335_/Y }
C {devices/lab_pin.sym} 116780 -30930 0 1 {name=p115618 lab=_46336_/Y }
C {sky130_stdcells/o21ai_4.sym} 116700 -30930 0 0 {name=X_46336_ }
C {devices/lab_pin.sym} 116640 -30810 0 0 {name=p115619 lab=_65397_/A }
C {devices/lab_pin.sym} 116640 -30770 0 0 {name=p115620 lab=_65047_/B }
C {devices/lab_pin.sym} 116640 -30730 0 0 {name=p115621 lab=_65170_/C }
C {devices/lab_pin.sym} 116760 -30770 0 1 {name=p115622 lab=_65170_/Y }
C {sky130_stdcells/nor3_4.sym} 116700 -30770 0 0 {name=X_65170_ }
C {devices/lab_pin.sym} 116640 -30640 0 0 {name=p115623 lab=_77157_/A }
C {devices/lab_pin.sym} 116640 -30600 0 0 {name=p115624 lab=_77157_/B }
C {devices/lab_pin.sym} 116760 -30620 0 1 {name=p115625 lab=_77156_/Y }
C {sky130_stdcells/nor2_4.sym} 116700 -30620 0 0 {name=X_77156_ }
C {devices/lab_pin.sym} 116660 -30490 0 0 {name=p115626 lab=_43548_/A }
C {devices/lab_pin.sym} 116740 -30490 0 1 {name=p115627 lab=_43548_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -30490 0 0 {name=X_43548_ }
C {devices/lab_pin.sym} 116640 -30390 0 0 {name=p115628 lab=_62342_/A }
C {devices/lab_pin.sym} 116640 -30350 0 0 {name=p115629 lab=_62341_/X }
C {devices/lab_pin.sym} 116640 -30310 0 0 {name=p115630 lab=_84414_/Q }
C {devices/lab_pin.sym} 116760 -30350 0 1 {name=p115631 lab=_62382_/Y }
C {sky130_stdcells/nor3_4.sym} 116700 -30350 0 0 {name=X_62382_ }
C {devices/lab_pin.sym} 116640 -30220 0 0 {name=p115632 lab=_72068_/A }
C {devices/lab_pin.sym} 116640 -30180 0 0 {name=p115633 lab=_48367_/Y }
C {devices/lab_pin.sym} 116760 -30200 0 1 {name=p115634 lab=_74368_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -30200 0 0 {name=X_74368_ }
C {devices/lab_pin.sym} 116660 -30070 0 0 {name=p115635 lab=_60879_/B }
C {devices/lab_pin.sym} 116740 -30070 0 1 {name=p115636 lab=_64179_/C }
C {sky130_stdcells/buf_2.sym} 116700 -30070 0 0 {name=X_64121_ }
C {devices/lab_pin.sym} 116660 -29950 0 0 {name=p115637 lab=_76107_/A }
C {devices/lab_pin.sym} 116740 -29950 0 1 {name=p115638 lab=_76107_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -29950 0 0 {name=X_76107_ }
C {devices/lab_pin.sym} 116660 -29830 0 0 {name=p115639 lab=_61321_/Y }
C {devices/lab_pin.sym} 116740 -29830 0 1 {name=p115640 lab=_61334_/A }
C {sky130_stdcells/buf_2.sym} 116700 -29830 0 0 {name=X_61333_ }
C {devices/lab_pin.sym} 116660 -29710 0 0 {name=p115641 lab=_49055_/A }
C {devices/lab_pin.sym} 116740 -29710 0 1 {name=p115642 lab=_50649_/B }
C {sky130_stdcells/buf_2.sym} 116700 -29710 0 0 {name=X_49055_ }
C {devices/lab_pin.sym} 116660 -29590 0 0 {name=p115643 lab=_72852_/X }
C {devices/lab_pin.sym} 116740 -29590 0 1 {name=p115644 lab=_73319_/X }
C {sky130_stdcells/buf_2.sym} 116700 -29590 0 0 {name=X_73319_ }
C {devices/lab_pin.sym} 116660 -29470 0 0 {name=p115645 lab=_46267_/A }
C {devices/lab_pin.sym} 116740 -29470 0 1 {name=p115646 lab=_53949_/B }
C {sky130_stdcells/buf_2.sym} 116700 -29470 0 0 {name=X_46267_ }
C {devices/lab_pin.sym} 116640 -29360 0 0 {name=p115647 lab=_77084_/Y }
C {devices/lab_pin.sym} 116640 -29320 0 0 {name=p115648 lab=_77087_/B }
C {devices/lab_pin.sym} 116760 -29340 0 1 {name=p115649 lab=_77097_/A }
C {sky130_stdcells/nand2_4.sym} 116700 -29340 0 0 {name=X_77087_ }
C {devices/lab_pin.sym} 116660 -29210 0 0 {name=p115650 lab=_43528_/A }
C {devices/lab_pin.sym} 116740 -29210 0 1 {name=p115651 lab=_43479_/X }
C {sky130_stdcells/buf_2.sym} 116700 -29210 0 0 {name=X_43479_ }
C {devices/lab_pin.sym} 116640 -29110 0 0 {name=p115652 lab=_74297_/A }
C {devices/lab_pin.sym} 116640 -29070 0 0 {name=p115653 lab=_74297_/B }
C {devices/lab_pin.sym} 116640 -29030 0 0 {name=p115654 lab=_55956_/B }
C {devices/lab_pin.sym} 116760 -29070 0 1 {name=p115655 lab=_74299_/Y }
C {sky130_stdcells/nand3_4.sym} 116700 -29070 0 0 {name=X_74299_ }
C {devices/lab_pin.sym} 116660 -28930 0 0 {name=p115656 lab=_48759_/A }
C {devices/lab_pin.sym} 116740 -28930 0 1 {name=p115657 lab=_48734_/A }
C {sky130_stdcells/buf_2.sym} 116700 -28930 0 0 {name=X_48006_ }
C {devices/lab_pin.sym} 116660 -28810 0 0 {name=p115658 lab=_63238_/B }
C {devices/lab_pin.sym} 116740 -28810 0 1 {name=p115659 lab=_61568_/B }
C {sky130_stdcells/buf_2.sym} 116700 -28810 0 0 {name=X_45218_ }
C {devices/lab_pin.sym} 116640 -28720 0 0 {name=p115660 lab=_61560_/B }
C {devices/lab_pin.sym} 116640 -28680 0 0 {name=p115661 lab=_64052_/B }
C {devices/lab_pin.sym} 116640 -28640 0 0 {name=p115662 lab=_64150_/C }
C {devices/lab_pin.sym} 116640 -28600 0 0 {name=p115663 lab=_64052_/D }
C {devices/lab_pin.sym} 116760 -28660 0 1 {name=p115664 lab=_64052_/Y }
C {sky130_stdcells/nand4_4.sym} 116700 -28660 0 0 {name=X_64052_ }
C {devices/lab_pin.sym} 116640 -28520 0 0 {name=p115665 lab=_76038_/A }
C {devices/lab_pin.sym} 116640 -28480 0 0 {name=p115666 lab=_76038_/B }
C {devices/lab_pin.sym} 116760 -28500 0 1 {name=p115667 lab=_76039_/B }
C {sky130_stdcells/nand2_4.sym} 116700 -28500 0 0 {name=X_76038_ }
C {devices/lab_pin.sym} 116640 -28380 0 0 {name=p115668 lab=_61264_/A }
C {devices/lab_pin.sym} 116640 -28340 0 0 {name=p115669 lab=_61264_/B }
C {devices/lab_pin.sym} 116760 -28360 0 1 {name=p115670 lab=_61264_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -28360 0 0 {name=X_61264_ }
C {devices/lab_pin.sym} 116660 -28230 0 0 {name=p115671 lab=_66002_/A }
C {devices/lab_pin.sym} 116740 -28230 0 1 {name=p115672 lab=_65464_/A }
C {sky130_stdcells/buf_2.sym} 116700 -28230 0 0 {name=X_46198_ }
C {devices/lab_pin.sym} 116660 -28110 0 0 {name=p115673 lab=_63002_/X }
C {devices/lab_pin.sym} 116740 -28110 0 1 {name=p115674 lab=_63003_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -28110 0 0 {name=X_63003_ }
C {devices/lab_pin.sym} 116620 -28030 0 0 {name=p115675 lab=_60192_/Y }
C {devices/lab_pin.sym} 116620 -27990 0 0 {name=p115676 lab=_60198_/Y }
C {devices/lab_pin.sym} 116620 -27950 0 0 {name=p115677 lab=_60207_/Y }
C {devices/lab_pin.sym} 116620 -27910 0 0 {name=p115678 lab=_60300_/B }
C {devices/lab_pin.sym} 116620 -27880 0 0 {name=p115679 lab=_60214_/Y }
C {devices/lab_pin.sym} 116780 -27950 0 1 {name=p115680 lab=_84649_/D }
C {sky130_stdcells/a41oi_4.sym} 116700 -27950 0 0 {name=X_60215_ }
C {devices/lab_pin.sym} 116620 -27810 0 0 {name=p115681 lab=_85265_/Q }
C {devices/lab_pin.sym} 116620 -27770 0 0 {name=p115682 lab=_45147_/X }
C {devices/lab_pin.sym} 116620 -27730 0 0 {name=p115683 lab=_45148_/X }
C {devices/lab_pin.sym} 116780 -27770 0 1 {name=p115684 lab=_45149_/Y }
C {sky130_stdcells/o21ai_4.sym} 116700 -27770 0 0 {name=X_45149_ }
C {devices/lab_pin.sym} 116620 -27660 0 0 {name=p115685 lab=_74031_/A }
C {devices/lab_pin.sym} 116620 -27620 0 0 {name=p115686 lab=_68414_/X }
C {devices/lab_pin.sym} 116620 -27580 0 0 {name=p115687 lab=_68379_/X }
C {devices/lab_pin.sym} 116620 -27540 0 0 {name=p115688 lab=_68859_/Y }
C {devices/lab_pin.sym} 116780 -27600 0 1 {name=p115689 lab=_68860_/X }
C {sky130_stdcells/a211o_4.sym} 116700 -27600 0 0 {name=X_68860_ }
C {devices/lab_pin.sym} 116660 -27450 0 0 {name=p115690 lab=_61195_/A }
C {devices/lab_pin.sym} 116740 -27450 0 1 {name=p115691 lab=_61196_/A }
C {sky130_stdcells/inv_2.sym} 116700 -27450 0 0 {name=X_61195_ }
C {devices/lab_pin.sym} 116660 -27330 0 0 {name=p115692 lab=clkbuf_9_354_0_CLK/X }
C {devices/lab_pin.sym} 116740 -27330 0 1 {name=p115693 lab=_87086_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 116700 -27330 0 0 {name=Xclkbuf_10_708_0_CLK }
C {devices/lab_pin.sym} 116620 -27240 0 0 {name=p115694 lab=_87455_/Q }
C {devices/lab_pin.sym} 116620 -27200 0 0 {name=p115695 lab=_67717_/X }
C {devices/lab_pin.sym} 116620 -27160 0 0 {name=p115696 lab=_67718_/X }
C {devices/lab_pin.sym} 116620 -27120 0 0 {name=p115697 lab=_67810_/X }
C {devices/lab_pin.sym} 116780 -27180 0 1 {name=p115698 lab=_67811_/X }
C {sky130_stdcells/a211o_4.sym} 116700 -27180 0 0 {name=X_67811_ }
C {devices/lab_pin.sym} 116620 -27060 0 0 {name=p115699 lab=_60145_/Y }
C {devices/lab_pin.sym} 116620 -27020 0 0 {name=p115700 lab=_59230_/X }
C {devices/lab_pin.sym} 116620 -26980 0 0 {name=p115701 lab=_59968_/B }
C {devices/lab_pin.sym} 116620 -26940 0 0 {name=p115702 lab=_60005_/Y }
C {devices/lab_pin.sym} 116780 -27000 0 1 {name=p115703 lab=_60146_/Y }
C {sky130_stdcells/a22oi_4.sym} 116700 -27000 0 0 {name=X_60146_ }
C {devices/lab_pin.sym} 116660 -26850 0 0 {name=p115704 lab=_49930_/X }
C {devices/lab_pin.sym} 116740 -26850 0 1 {name=p115705 lab=_49973_/C }
C {sky130_stdcells/buf_2.sym} 116700 -26850 0 0 {name=X_49957_ }
C {devices/lab_pin.sym} 116620 -26760 0 0 {name=p115706 lab=_88002_/Q }
C {devices/lab_pin.sym} 116620 -26720 0 0 {name=p115707 lab=_68715_/X }
C {devices/lab_pin.sym} 116620 -26680 0 0 {name=p115708 lab=_68540_/X }
C {devices/lab_pin.sym} 116620 -26640 0 0 {name=p115709 lab=_68790_/X }
C {devices/lab_pin.sym} 116780 -26700 0 1 {name=p115710 lab=_68791_/X }
C {sky130_stdcells/a211o_4.sym} 116700 -26700 0 0 {name=X_68791_ }
C {devices/lab_pin.sym} 116640 -26580 0 0 {name=p115711 lab=_77950_/A }
C {devices/lab_pin.sym} 116640 -26540 0 0 {name=p115712 lab=_77965_/A }
C {devices/lab_pin.sym} 116640 -26500 0 0 {name=p115713 lab=_77957_/A }
C {devices/lab_pin.sym} 116640 -26460 0 0 {name=p115714 lab=_77980_/C }
C {devices/lab_pin.sym} 116760 -26520 0 1 {name=p115715 lab=_77989_/X }
C {sky130_stdcells/and4_4.sym} 116700 -26520 0 0 {name=X_77989_ }
C {devices/lab_pin.sym} 116640 -26380 0 0 {name=p115716 lab=_48908_/A }
C {devices/lab_pin.sym} 116640 -26340 0 0 {name=p115717 lab=_71970_/B }
C {devices/lab_pin.sym} 116760 -26360 0 1 {name=p115718 lab=_48908_/X }
C {sky130_stdcells/and2_4.sym} 116700 -26360 0 0 {name=X_48908_ }
C {devices/lab_pin.sym} 116660 -26230 0 0 {name=p115719 lab=_68442_/A }
C {devices/lab_pin.sym} 116740 -26230 0 1 {name=p115720 lab=_67742_/X }
C {sky130_stdcells/buf_2.sym} 116700 -26230 0 0 {name=X_67742_ }
C {devices/lab_pin.sym} 116620 -26130 0 0 {name=p115721 lab=_79725_/Y }
C {devices/lab_pin.sym} 116620 -26090 0 0 {name=p115722 lab=_79708_/Y }
C {devices/lab_pin.sym} 116620 -26050 0 0 {name=p115723 lab=_79727_/X }
C {devices/lab_pin.sym} 116780 -26090 0 1 {name=p115724 lab=_79728_/Y }
C {sky130_stdcells/o21ai_4.sym} 116700 -26090 0 0 {name=X_79728_ }
C {devices/lab_pin.sym} 116640 -25960 0 0 {name=p115725 lab=_64929_/A }
C {devices/lab_pin.sym} 116640 -25920 0 0 {name=p115726 lab=_85812_/Q }
C {devices/lab_pin.sym} 116760 -25940 0 1 {name=p115727 lab=_64954_/X }
C {sky130_stdcells/and2_4.sym} 116700 -25940 0 0 {name=X_64954_ }
C {devices/lab_pin.sym} 116660 -25810 0 0 {name=p115728 lab=_66064_/A }
C {devices/lab_pin.sym} 116740 -25810 0 1 {name=p115729 lab=_60359_/A }
C {sky130_stdcells/buf_2.sym} 116700 -25810 0 0 {name=X_60077_ }
C {devices/lab_pin.sym} 116660 -25690 0 0 {name=p115730 lab=_49861_/A }
C {devices/lab_pin.sym} 116740 -25690 0 1 {name=p115731 lab=_49893_/B }
C {sky130_stdcells/buf_2.sym} 116700 -25690 0 0 {name=X_49888_ }
C {devices/lab_pin.sym} 116640 -25600 0 0 {name=p115732 lab=_61891_/X }
C {devices/lab_pin.sym} 116640 -25560 0 0 {name=p115733 lab=_63876_/B }
C {devices/lab_pin.sym} 116640 -25520 0 0 {name=p115734 lab=_63905_/C }
C {devices/lab_pin.sym} 116640 -25480 0 0 {name=p115735 lab=_63892_/D }
C {devices/lab_pin.sym} 116760 -25540 0 1 {name=p115736 lab=_63905_/Y }
C {sky130_stdcells/nand4_4.sym} 116700 -25540 0 0 {name=X_63905_ }
C {devices/lab_pin.sym} 116620 -25410 0 0 {name=p115737 lab=_86473_/Q }
C {devices/lab_pin.sym} 116620 -25370 0 0 {name=p115738 lab=_48836_/X }
C {devices/lab_pin.sym} 116620 -25330 0 0 {name=p115739 lab=_48838_/Y }
C {devices/lab_pin.sym} 116780 -25370 0 1 {name=p115740 lab=_48839_/Y }
C {sky130_stdcells/o21ai_4.sym} 116700 -25370 0 0 {name=X_48839_ }
C {devices/lab_pin.sym} 116620 -25260 0 0 {name=p115741 lab=_86961_/Q }
C {devices/lab_pin.sym} 116620 -25220 0 0 {name=p115742 lab=_67670_/X }
C {devices/lab_pin.sym} 116620 -25180 0 0 {name=p115743 lab=_67671_/X }
C {devices/lab_pin.sym} 116620 -25140 0 0 {name=p115744 lab=_67672_/X }
C {devices/lab_pin.sym} 116780 -25200 0 1 {name=p115745 lab=_67673_/X }
C {sky130_stdcells/a211o_4.sym} 116700 -25200 0 0 {name=X_67673_ }
C {devices/lab_pin.sym} 116640 -25060 0 0 {name=p115746 lab=_79657_/X }
C {devices/lab_pin.sym} 116640 -25020 0 0 {name=p115747 lab=_79668_/B }
C {devices/lab_pin.sym} 116760 -25040 0 1 {name=p115748 lab=_79659_/Y }
C {sky130_stdcells/xnor2_4.sym} 116700 -25040 0 0 {name=X_79659_ }
C {devices/lab_pin.sym} 116620 -24930 0 0 {name=p115749 lab=_64882_/X }
C {devices/lab_pin.sym} 116620 -24890 0 0 {name=p115750 lab=_64884_/X }
C {devices/lab_pin.sym} 116620 -24850 0 0 {name=p115751 lab=_64729_/X }
C {devices/lab_pin.sym} 116780 -24890 0 1 {name=p115752 lab=_64885_/X }
C {sky130_stdcells/a21o_4.sym} 116700 -24890 0 0 {name=X_64885_ }
C {devices/lab_pin.sym} 116620 -24780 0 0 {name=p115753 lab=_87519_/Q }
C {devices/lab_pin.sym} 116620 -24740 0 0 {name=p115754 lab=_69205_/X }
C {devices/lab_pin.sym} 116620 -24700 0 0 {name=p115755 lab=_69343_/X }
C {devices/lab_pin.sym} 116620 -24660 0 0 {name=p115756 lab=_69411_/X }
C {devices/lab_pin.sym} 116780 -24720 0 1 {name=p115757 lab=_69412_/X }
C {sky130_stdcells/a211o_4.sym} 116700 -24720 0 0 {name=X_69412_ }
C {devices/lab_pin.sym} 116660 -24570 0 0 {name=p115758 lab=_67816_/A }
C {devices/lab_pin.sym} 116740 -24570 0 1 {name=p115759 lab=_66625_/A }
C {sky130_stdcells/buf_2.sym} 116700 -24570 0 0 {name=X_66624_ }
C {devices/lab_pin.sym} 116660 -24450 0 0 {name=p115760 lab=_51823_/A }
C {devices/lab_pin.sym} 116740 -24450 0 1 {name=p115761 lab=_51850_/X }
C {sky130_stdcells/buf_2.sym} 116700 -24450 0 0 {name=X_51850_ }
C {devices/lab_pin.sym} 116640 -24360 0 0 {name=p115762 lab=_61406_/A }
C {devices/lab_pin.sym} 116640 -24320 0 0 {name=p115763 lab=_63772_/B }
C {devices/lab_pin.sym} 116640 -24280 0 0 {name=p115764 lab=_63803_/C }
C {devices/lab_pin.sym} 116640 -24240 0 0 {name=p115765 lab=_63787_/D }
C {devices/lab_pin.sym} 116760 -24300 0 1 {name=p115766 lab=_63836_/Y }
C {sky130_stdcells/nand4_4.sym} 116700 -24300 0 0 {name=X_63836_ }
C {devices/lab_pin.sym} 116610 -24150 0 0 {name=p115767 lab=_82923_/CLK }
C {devices/lab_pin.sym} 116610 -24130 0 0 {name=p115768 lab=_82670_/D }
C {devices/lab_pin.sym} 116790 -24150 0 1 {name=p115769 lab=_82670_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -24140 0 0 {name=X_82670_ }
C {devices/lab_pin.sym} 116660 -24010 0 0 {name=p115770 lab=_50551_/A }
C {devices/lab_pin.sym} 116740 -24010 0 1 {name=p115771 lab=_50801_/X }
C {sky130_stdcells/buf_2.sym} 116700 -24010 0 0 {name=X_50801_ }
C {devices/lab_pin.sym} 116610 -23890 0 0 {name=p115772 lab=_81259_/CLK }
C {devices/lab_pin.sym} 116610 -23870 0 0 {name=p115773 lab=_76435_/Y }
C {devices/lab_pin.sym} 116790 -23890 0 1 {name=p115774 lab=_81813_/D }
C {sky130_stdcells/dfxtp_4.sym} 116700 -23880 0 0 {name=X_81621_ }
C {devices/lab_pin.sym} 116660 -23750 0 0 {name=p115775 lab=_68385_/A }
C {devices/lab_pin.sym} 116740 -23750 0 1 {name=p115776 lab=_69343_/X }
C {sky130_stdcells/buf_2.sym} 116700 -23750 0 0 {name=X_69343_ }
C {devices/lab_pin.sym} 116660 -23630 0 0 {name=p115777 lab=_66554_/X }
C {devices/lab_pin.sym} 116740 -23630 0 1 {name=p115778 lab=_66647_/A }
C {sky130_stdcells/buf_2.sym} 116700 -23630 0 0 {name=X_66555_ }
C {devices/lab_pin.sym} 116660 -23510 0 0 {name=p115779 lab=_51781_/A }
C {devices/lab_pin.sym} 116740 -23510 0 1 {name=p115780 lab=_51794_/C }
C {sky130_stdcells/buf_2.sym} 116700 -23510 0 0 {name=X_51781_ }
C {devices/lab_pin.sym} 116660 -23390 0 0 {name=p115781 lab=_63644_/A }
C {devices/lab_pin.sym} 116740 -23390 0 1 {name=p115782 lab=_63800_/A }
C {sky130_stdcells/buf_2.sym} 116700 -23390 0 0 {name=X_63767_ }
C {devices/lab_pin.sym} 116660 -23270 0 0 {name=p115783 lab=_72250_/A }
C {devices/lab_pin.sym} 116740 -23270 0 1 {name=p115784 lab=_60979_/X }
C {sky130_stdcells/buf_2.sym} 116700 -23270 0 0 {name=X_60979_ }
C {devices/lab_pin.sym} 116640 -23160 0 0 {name=p115785 lab=_53503_/X }
C {devices/lab_pin.sym} 116640 -23120 0 0 {name=p115786 lab=_53520_/B }
C {devices/lab_pin.sym} 116760 -23140 0 1 {name=p115787 lab=_53520_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -23140 0 0 {name=X_53520_ }
C {devices/lab_pin.sym} 116620 -23040 0 0 {name=p115788 lab=_65503_/X }
C {devices/lab_pin.sym} 116620 -23000 0 0 {name=p115789 lab=_85596_/Q }
C {devices/lab_pin.sym} 116620 -22960 0 0 {name=p115790 lab=_65504_/X }
C {devices/lab_pin.sym} 116620 -22920 0 0 {name=p115791 lab=_65505_/X }
C {devices/lab_pin.sym} 116780 -22980 0 1 {name=p115792 lab=_65506_/X }
C {sky130_stdcells/a211o_4.sym} 116700 -22980 0 0 {name=X_65506_ }
C {devices/lab_pin.sym} 116610 -22830 0 0 {name=p115793 lab=_83216_/CLK }
C {devices/lab_pin.sym} 116610 -22810 0 0 {name=p115794 lab=_84340_/D }
C {devices/lab_pin.sym} 116790 -22830 0 1 {name=p115795 lab=_79288_/A }
C {sky130_stdcells/dfxtp_4.sym} 116700 -22820 0 0 {name=X_84340_ }
C {devices/lab_pin.sym} 116620 -22710 0 0 {name=p115796 lab=_50730_/Y }
C {devices/lab_pin.sym} 116620 -22670 0 0 {name=p115797 lab=_50676_/X }
C {devices/lab_pin.sym} 116620 -22630 0 0 {name=p115798 lab=_50731_/Y }
C {devices/lab_pin.sym} 116780 -22670 0 1 {name=p115799 lab=_86145_/D }
C {sky130_stdcells/a21oi_4.sym} 116700 -22670 0 0 {name=X_50732_ }
C {devices/lab_pin.sym} 116640 -22560 0 0 {name=p115800 lab=_62669_/A }
C {devices/lab_pin.sym} 116640 -22520 0 0 {name=p115801 lab=_63069_/A }
C {devices/lab_pin.sym} 116640 -22480 0 0 {name=p115802 lab=_62704_/C }
C {devices/lab_pin.sym} 116640 -22440 0 0 {name=p115803 lab=_62717_/X }
C {devices/lab_pin.sym} 116760 -22500 0 1 {name=p115804 lab=_62718_/X }
C {sky130_stdcells/and4_4.sym} 116700 -22500 0 0 {name=X_62718_ }
C {devices/lab_pin.sym} 116610 -22350 0 0 {name=p115805 lab=_83918_/CLK }
C {devices/lab_pin.sym} 116610 -22330 0 0 {name=p115806 lab=_81552_/D }
C {devices/lab_pin.sym} 116790 -22350 0 1 {name=p115807 lab=_76171_/B }
C {sky130_stdcells/dfxtp_4.sym} 116700 -22340 0 0 {name=X_81552_ }
C {devices/lab_pin.sym} 116640 -22220 0 0 {name=p115808 lab=_69288_/A }
C {devices/lab_pin.sym} 116640 -22180 0 0 {name=p115809 lab=_69274_/B }
C {devices/lab_pin.sym} 116760 -22200 0 1 {name=p115810 lab=_69274_/X }
C {sky130_stdcells/and2_4.sym} 116700 -22200 0 0 {name=X_69274_ }
C {devices/lab_pin.sym} 116620 -22090 0 0 {name=p115811 lab=_66482_/Y }
C {devices/lab_pin.sym} 116620 -22050 0 0 {name=p115812 lab=_66483_/X }
C {devices/lab_pin.sym} 116620 -22010 0 0 {name=p115813 lab=_66485_/Y }
C {devices/lab_pin.sym} 116780 -22050 0 1 {name=p115814 lab=_84114_/D }
C {sky130_stdcells/a21o_4.sym} 116700 -22050 0 0 {name=X_66486_ }
C {devices/lab_pin.sym} 116620 -21940 0 0 {name=p115815 lab=_61673_/B }
C {devices/lab_pin.sym} 116620 -21900 0 0 {name=p115816 lab=_63426_/A }
C {devices/lab_pin.sym} 116620 -21860 0 0 {name=p115817 lab=_63696_/X }
C {devices/lab_pin.sym} 116620 -21820 0 0 {name=p115818 lab=_63697_/X }
C {devices/lab_pin.sym} 116780 -21880 0 1 {name=p115819 lab=_63698_/X }
C {sky130_stdcells/a211o_4.sym} 116700 -21880 0 0 {name=X_63698_ }
C {devices/lab_pin.sym} 116640 -21740 0 0 {name=p115820 lab=_80496_/X }
C {devices/lab_pin.sym} 116640 -21700 0 0 {name=p115821 lab=_80498_/B }
C {devices/lab_pin.sym} 116760 -21720 0 1 {name=p115822 lab=_80503_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -21720 0 0 {name=X_80503_ }
C {devices/lab_pin.sym} 116620 -21610 0 0 {name=p115823 lab=_67397_/X }
C {devices/lab_pin.sym} 116620 -21570 0 0 {name=p115824 lab=_67400_/X }
C {devices/lab_pin.sym} 116620 -21530 0 0 {name=p115825 lab=_68209_/X }
C {devices/lab_pin.sym} 116780 -21570 0 1 {name=p115826 lab=_68225_/Y }
C {sky130_stdcells/a21oi_4.sym} 116700 -21570 0 0 {name=X_68225_ }
C {devices/lab_pin.sym} 116660 -21430 0 0 {name=p115827 lab=_54321_/A }
C {devices/lab_pin.sym} 116740 -21430 0 1 {name=p115828 lab=_54919_/A }
C {sky130_stdcells/buf_2.sym} 116700 -21430 0 0 {name=X_53451_ }
C {devices/lab_pin.sym} 116640 -21330 0 0 {name=p115829 lab=_64630_/X }
C {devices/lab_pin.sym} 116640 -21290 0 0 {name=p115830 lab=_65548_/B }
C {devices/lab_pin.sym} 116640 -21250 0 0 {name=p115831 lab=_64632_/X }
C {devices/lab_pin.sym} 116760 -21290 0 1 {name=p115832 lab=_65447_/A }
C {sky130_stdcells/nand3_4.sym} 116700 -21290 0 0 {name=X_65437_ }
C {devices/lab_pin.sym} 116610 -21150 0 0 {name=p115833 lab=_80728_/CLK }
C {devices/lab_pin.sym} 116610 -21130 0 0 {name=p115834 lab=_64141_/Y }
C {devices/lab_pin.sym} 116790 -21150 0 1 {name=p115835 lab=_84271_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -21140 0 0 {name=X_84271_ }
C {devices/lab_pin.sym} 116620 -21030 0 0 {name=p115836 lab=_86158_/Q }
C {devices/lab_pin.sym} 116620 -20990 0 0 {name=p115837 lab=_50626_/X }
C {devices/lab_pin.sym} 116620 -20950 0 0 {name=p115838 lab=_50662_/Y }
C {devices/lab_pin.sym} 116780 -20990 0 1 {name=p115839 lab=_50663_/Y }
C {sky130_stdcells/o21ai_4.sym} 116700 -20990 0 0 {name=X_50663_ }
C {devices/lab_pin.sym} 116660 -20850 0 0 {name=p115840 lab=_62886_/A }
C {devices/lab_pin.sym} 116740 -20850 0 1 {name=p115841 lab=_62949_/B }
C {sky130_stdcells/buf_2.sym} 116700 -20850 0 0 {name=X_62649_ }
C {devices/lab_pin.sym} 116610 -20730 0 0 {name=p115842 lab=_81482_/CLK }
C {devices/lab_pin.sym} 116610 -20710 0 0 {name=p115843 lab=_81483_/D }
C {devices/lab_pin.sym} 116790 -20730 0 1 {name=p115844 lab=_81483_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -20720 0 0 {name=X_81483_ }
C {devices/lab_pin.sym} 116610 -20590 0 0 {name=p115845 lab=_86008_/CLK }
C {devices/lab_pin.sym} 116610 -20570 0 0 {name=p115846 lab=_86010_/D }
C {devices/lab_pin.sym} 116790 -20590 0 1 {name=p115847 lab=_86010_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -20580 0 0 {name=X_86010_ }
C {devices/lab_pin.sym} 116620 -20470 0 0 {name=p115848 lab=_65313_/B }
C {devices/lab_pin.sym} 116620 -20430 0 0 {name=p115849 lab=_52397_/X }
C {devices/lab_pin.sym} 116620 -20390 0 0 {name=p115850 lab=_52401_/Y }
C {devices/lab_pin.sym} 116780 -20430 0 1 {name=p115851 lab=_52402_/Y }
C {sky130_stdcells/o21ai_4.sym} 116700 -20430 0 0 {name=X_52402_ }
C {devices/lab_pin.sym} 116610 -20290 0 0 {name=p115852 lab=_83231_/CLK }
C {devices/lab_pin.sym} 116610 -20270 0 0 {name=p115853 lab=_72599_/Y }
C {devices/lab_pin.sym} 116790 -20290 0 1 {name=p115854 lab=_79310_/B }
C {sky130_stdcells/dfxtp_4.sym} 116700 -20280 0 0 {name=X_83222_ }
C {devices/lab_pin.sym} 116620 -20170 0 0 {name=p115855 lab=_56177_/A }
C {devices/lab_pin.sym} 116620 -20130 0 0 {name=p115856 lab=_56168_/X }
C {devices/lab_pin.sym} 116620 -20090 0 0 {name=p115857 lab=_56169_/Y }
C {devices/lab_pin.sym} 116780 -20130 0 1 {name=p115858 lab=_85283_/D }
C {sky130_stdcells/o21ai_4.sym} 116700 -20130 0 0 {name=X_56170_ }
C {devices/lab_pin.sym} 116640 -20000 0 0 {name=p115859 lab=_80432_/X }
C {devices/lab_pin.sym} 116640 -19960 0 0 {name=p115860 lab=_80434_/B }
C {devices/lab_pin.sym} 116760 -19980 0 1 {name=p115861 lab=_80448_/A }
C {sky130_stdcells/xnor2_4.sym} 116700 -19980 0 0 {name=X_80434_ }
C {devices/lab_pin.sym} 116620 -19870 0 0 {name=p115862 lab=_66987_/X }
C {devices/lab_pin.sym} 116620 -19830 0 0 {name=p115863 lab=_66990_/X }
C {devices/lab_pin.sym} 116620 -19790 0 0 {name=p115864 lab=_68129_/X }
C {devices/lab_pin.sym} 116780 -19830 0 1 {name=p115865 lab=_68156_/Y }
C {sky130_stdcells/a21oi_4.sym} 116700 -19830 0 0 {name=X_68156_ }
C {devices/lab_pin.sym} 116660 -19690 0 0 {name=p115866 lab=_53355_/A }
C {devices/lab_pin.sym} 116740 -19690 0 1 {name=p115867 lab=_53382_/X }
C {sky130_stdcells/buf_2.sym} 116700 -19690 0 0 {name=X_53382_ }
C {devices/lab_pin.sym} 116620 -19600 0 0 {name=p115868 lab=_65342_/X }
C {devices/lab_pin.sym} 116620 -19560 0 0 {name=p115869 lab=_86724_/Q }
C {devices/lab_pin.sym} 116620 -19520 0 0 {name=p115870 lab=_65239_/X }
C {devices/lab_pin.sym} 116620 -19480 0 0 {name=p115871 lab=_65367_/X }
C {devices/lab_pin.sym} 116780 -19540 0 1 {name=p115872 lab=_65368_/X }
C {sky130_stdcells/a211o_4.sym} 116700 -19540 0 0 {name=X_65368_ }
C {devices/lab_pin.sym} 116660 -19390 0 0 {name=p115873 lab=_50594_/A }
C {devices/lab_pin.sym} 116740 -19390 0 1 {name=p115874 lab=_50594_/X }
C {sky130_stdcells/buf_2.sym} 116700 -19390 0 0 {name=X_50594_ }
C {devices/lab_pin.sym} 116620 -19290 0 0 {name=p115875 lab=_55119_/Y }
C {devices/lab_pin.sym} 116620 -19250 0 0 {name=p115876 lab=_55102_/X }
C {devices/lab_pin.sym} 116620 -19210 0 0 {name=p115877 lab=_55120_/X }
C {devices/lab_pin.sym} 116780 -19250 0 1 {name=p115878 lab=_85314_/D }
C {sky130_stdcells/a21oi_4.sym} 116700 -19250 0 0 {name=X_55121_ }
C {devices/lab_pin.sym} 116640 -19120 0 0 {name=p115879 lab=_67133_/A }
C {devices/lab_pin.sym} 116640 -19080 0 0 {name=p115880 lab=_67107_/B }
C {devices/lab_pin.sym} 116760 -19100 0 1 {name=p115881 lab=_67107_/X }
C {sky130_stdcells/and2_4.sym} 116700 -19100 0 0 {name=X_67107_ }
C {devices/lab_pin.sym} 116620 -18990 0 0 {name=p115882 lab=_52331_/Y }
C {devices/lab_pin.sym} 116620 -18950 0 0 {name=p115883 lab=_52314_/X }
C {devices/lab_pin.sym} 116620 -18910 0 0 {name=p115884 lab=_52332_/X }
C {devices/lab_pin.sym} 116780 -18950 0 1 {name=p115885 lab=_52333_/Y }
C {sky130_stdcells/a21oi_4.sym} 116700 -18950 0 0 {name=X_52333_ }
C {devices/lab_pin.sym} 116660 -18810 0 0 {name=p115886 lab=_64377_/A }
C {devices/lab_pin.sym} 116740 -18810 0 1 {name=p115887 lab=_64319_/X }
C {sky130_stdcells/buf_2.sym} 116700 -18810 0 0 {name=X_64319_ }
C {devices/lab_pin.sym} 116610 -18690 0 0 {name=p115888 lab=_83153_/CLK }
C {devices/lab_pin.sym} 116610 -18670 0 0 {name=p115889 lab=_83153_/D }
C {devices/lab_pin.sym} 116790 -18690 0 1 {name=p115890 lab=_83153_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -18680 0 0 {name=X_83153_ }
C {devices/lab_pin.sym} 116620 -18570 0 0 {name=p115891 lab=_80338_/Y }
C {devices/lab_pin.sym} 116620 -18530 0 0 {name=p115892 lab=_80363_/Y }
C {devices/lab_pin.sym} 116620 -18490 0 0 {name=p115893 lab=_80364_/Y }
C {devices/lab_pin.sym} 116780 -18530 0 1 {name=p115894 lab=_80366_/B }
C {sky130_stdcells/a21oi_4.sym} 116700 -18530 0 0 {name=X_80365_ }
C {devices/lab_pin.sym} 116620 -18410 0 0 {name=p115895 lab=_81474_/D }
C {devices/lab_pin.sym} 116620 -18370 0 0 {name=p115896 lab=_68040_/X }
C {devices/lab_pin.sym} 116620 -18330 0 0 {name=p115897 lab=_68086_/X }
C {devices/lab_pin.sym} 116780 -18370 0 1 {name=p115898 lab=_84042_/D }
C {sky130_stdcells/a21bo_4.sym} 116700 -18370 0 0 {name=X_68087_ }
C {devices/lab_pin.sym} 116620 -18260 0 0 {name=p115899 lab=_72123_/A }
C {devices/lab_pin.sym} 116620 -18220 0 0 {name=p115900 lab=_86118_/Q }
C {devices/lab_pin.sym} 116620 -18180 0 0 {name=p115901 lab=_45922_/X }
C {devices/lab_pin.sym} 116620 -18140 0 0 {name=p115902 lab=_65298_/X }
C {devices/lab_pin.sym} 116780 -18200 0 1 {name=p115903 lab=_65299_/X }
C {sky130_stdcells/a211o_4.sym} 116700 -18200 0 0 {name=X_65299_ }
C {devices/lab_pin.sym} 116610 -18050 0 0 {name=p115904 lab=_82104_/CLK }
C {devices/lab_pin.sym} 116610 -18030 0 0 {name=p115905 lab=_82116_/Q }
C {devices/lab_pin.sym} 116790 -18050 0 1 {name=p115906 lab=_77161_/A }
C {sky130_stdcells/dfxtp_4.sym} 116700 -18040 0 0 {name=X_82104_ }
C {devices/lab_pin.sym} 116640 -17940 0 0 {name=p115907 lab=_55043_/X }
C {devices/lab_pin.sym} 116640 -17900 0 0 {name=p115908 lab=_55030_/X }
C {devices/lab_pin.sym} 116640 -17860 0 0 {name=p115909 lab=_55070_/C }
C {devices/lab_pin.sym} 116640 -17820 0 0 {name=p115910 lab=_47691_/A }
C {devices/lab_pin.sym} 116760 -17880 0 1 {name=p115911 lab=_55052_/X }
C {sky130_stdcells/and4_4.sym} 116700 -17880 0 0 {name=X_55052_ }
C {devices/lab_pin.sym} 116620 -17750 0 0 {name=p115912 lab=_67034_/X }
C {devices/lab_pin.sym} 116620 -17710 0 0 {name=p115913 lab=_67037_/X }
C {devices/lab_pin.sym} 116620 -17670 0 0 {name=p115914 lab=_66964_/X }
C {devices/lab_pin.sym} 116780 -17710 0 1 {name=p115915 lab=_67038_/X }
C {sky130_stdcells/a21o_4.sym} 116700 -17710 0 0 {name=X_67038_ }
C {devices/lab_pin.sym} 116620 -17590 0 0 {name=p115916 lab=_52260_/Y }
C {devices/lab_pin.sym} 116620 -17550 0 0 {name=p115917 lab=_52262_/X }
C {devices/lab_pin.sym} 116620 -17510 0 0 {name=p115918 lab=_52263_/X }
C {devices/lab_pin.sym} 116780 -17550 0 1 {name=p115919 lab=_52264_/Y }
C {sky130_stdcells/a21oi_4.sym} 116700 -17550 0 0 {name=X_52264_ }
C {devices/lab_pin.sym} 116610 -17410 0 0 {name=p115920 lab=_83184_/CLK }
C {devices/lab_pin.sym} 116610 -17390 0 0 {name=p115921 lab=_83084_/D }
C {devices/lab_pin.sym} 116790 -17410 0 1 {name=p115922 lab=_70346_/C }
C {sky130_stdcells/dfxtp_4.sym} 116700 -17400 0 0 {name=X_83084_ }
C {devices/lab_pin.sym} 116610 -17270 0 0 {name=p115923 lab=_87221_/CLK }
C {devices/lab_pin.sym} 116610 -17250 0 0 {name=p115924 lab=_87961_/D }
C {devices/lab_pin.sym} 116790 -17270 0 1 {name=p115925 lab=_87961_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -17260 0 0 {name=X_87961_ }
C {devices/lab_pin.sym} 116640 -17150 0 0 {name=p115926 lab=_80296_/A }
C {devices/lab_pin.sym} 116640 -17110 0 0 {name=p115927 lab=_80297_/A }
C {devices/lab_pin.sym} 116640 -17070 0 0 {name=p115928 lab=_80297_/B }
C {devices/lab_pin.sym} 116760 -17110 0 1 {name=p115929 lab=_80296_/Y }
C {sky130_stdcells/nand3_4.sym} 116700 -17110 0 0 {name=X_80296_ }
C {devices/lab_pin.sym} 116620 -16990 0 0 {name=p115930 lab=_54001_/Y }
C {devices/lab_pin.sym} 116620 -16950 0 0 {name=p115931 lab=_53982_/X }
C {devices/lab_pin.sym} 116620 -16910 0 0 {name=p115932 lab=_54002_/Y }
C {devices/lab_pin.sym} 116780 -16950 0 1 {name=p115933 lab=_85525_/D }
C {sky130_stdcells/a21boi_4.sym} 116700 -16950 0 0 {name=X_54003_ }
C {devices/lab_pin.sym} 116620 -16830 0 0 {name=p115934 lab=_51213_/Y }
C {devices/lab_pin.sym} 116620 -16790 0 0 {name=p115935 lab=_51201_/X }
C {devices/lab_pin.sym} 116620 -16750 0 0 {name=p115936 lab=_51214_/X }
C {devices/lab_pin.sym} 116780 -16790 0 1 {name=p115937 lab=_86053_/D }
C {sky130_stdcells/a21oi_4.sym} 116700 -16790 0 0 {name=X_51215_ }
C {devices/lab_pin.sym} 116610 -16650 0 0 {name=p115938 lab=_87636_/CLK }
C {devices/lab_pin.sym} 116610 -16630 0 0 {name=p115939 lab=_86912_/D }
C {devices/lab_pin.sym} 116790 -16650 0 1 {name=p115940 lab=_86912_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -16640 0 0 {name=X_86912_ }
C {devices/lab_pin.sym} 116610 -16510 0 0 {name=p115941 lab=_82005_/CLK }
C {devices/lab_pin.sym} 116610 -16490 0 0 {name=p115942 lab=_77888_/B }
C {devices/lab_pin.sym} 116790 -16510 0 1 {name=p115943 lab=_82035_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -16500 0 0 {name=X_82035_ }
C {devices/lab_pin.sym} 116640 -16390 0 0 {name=p115944 lab=_59855_/A }
C {devices/lab_pin.sym} 116640 -16350 0 0 {name=p115945 lab=_59855_/B }
C {devices/lab_pin.sym} 116640 -16310 0 0 {name=p115946 lab=_80323_/A }
C {devices/lab_pin.sym} 116760 -16350 0 1 {name=p115947 lab=_59860_/Y }
C {sky130_stdcells/nor3_4.sym} 116700 -16350 0 0 {name=X_59860_ }
C {devices/lab_pin.sym} 116620 -16230 0 0 {name=p115948 lab=_52191_/Y }
C {devices/lab_pin.sym} 116620 -16190 0 0 {name=p115949 lab=_52170_/X }
C {devices/lab_pin.sym} 116620 -16150 0 0 {name=p115950 lab=_52194_/X }
C {devices/lab_pin.sym} 116780 -16190 0 1 {name=p115951 lab=_85871_/D }
C {sky130_stdcells/a21oi_4.sym} 116700 -16190 0 0 {name=X_52195_ }
C {devices/lab_pin.sym} 116610 -16050 0 0 {name=p115952 lab=_86914_/CLK }
C {devices/lab_pin.sym} 116610 -16030 0 0 {name=p115953 lab=_87892_/D }
C {devices/lab_pin.sym} 116790 -16050 0 1 {name=p115954 lab=_87892_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -16040 0 0 {name=X_87892_ }
C {devices/lab_pin.sym} 116620 -15930 0 0 {name=p115955 lab=_58730_/X }
C {devices/lab_pin.sym} 116620 -15890 0 0 {name=p115956 lab=_85934_/Q }
C {devices/lab_pin.sym} 116620 -15850 0 0 {name=p115957 lab=_58810_/X }
C {devices/lab_pin.sym} 116780 -15890 0 1 {name=p115958 lab=_58811_/X }
C {sky130_stdcells/o21a_4.sym} 116700 -15890 0 0 {name=X_58811_ }
C {devices/lab_pin.sym} 116660 -15750 0 0 {name=p115959 lab=_51010_/A }
C {devices/lab_pin.sym} 116740 -15750 0 1 {name=p115960 lab=_51147_/A }
C {sky130_stdcells/buf_2.sym} 116700 -15750 0 0 {name=X_51146_ }
C {devices/lab_pin.sym} 116610 -15630 0 0 {name=p115961 lab=_81615_/CLK }
C {devices/lab_pin.sym} 116610 -15610 0 0 {name=p115962 lab=_86843_/D }
C {devices/lab_pin.sym} 116790 -15630 0 1 {name=p115963 lab=DATA_AVAILABLE }
C {sky130_stdcells/dfxtp_4.sym} 116700 -15620 0 0 {name=X_86843_ }
C {devices/lab_pin.sym} 116620 -15520 0 0 {name=p115964 lab=_80484_/A }
C {devices/lab_pin.sym} 116620 -15480 0 0 {name=p115965 lab=_59787_/X }
C {devices/lab_pin.sym} 116620 -15440 0 0 {name=p115966 lab=_59789_/Y }
C {devices/lab_pin.sym} 116620 -15400 0 0 {name=p115967 lab=_59790_/X }
C {devices/lab_pin.sym} 116780 -15460 0 1 {name=p115968 lab=_59791_/X }
C {sky130_stdcells/a2bb2o_4.sym} 116700 -15460 0 0 {name=X_59791_ }
C {devices/lab_pin.sym} 116660 -15310 0 0 {name=p115969 lab=_69607_/A }
C {devices/lab_pin.sym} 116740 -15310 0 1 {name=p115970 lab=_68989_/X }
C {sky130_stdcells/buf_2.sym} 116700 -15310 0 0 {name=X_68989_ }
C {devices/lab_pin.sym} 116620 -15210 0 0 {name=p115971 lab=_58740_/X }
C {devices/lab_pin.sym} 116620 -15170 0 0 {name=p115972 lab=_85459_/Q }
C {devices/lab_pin.sym} 116620 -15130 0 0 {name=p115973 lab=_58741_/X }
C {devices/lab_pin.sym} 116780 -15170 0 1 {name=p115974 lab=_58742_/Y }
C {sky130_stdcells/o21ai_4.sym} 116700 -15170 0 0 {name=X_58742_ }
C {devices/lab_pin.sym} 116620 -15050 0 0 {name=p115975 lab=_86078_/Q }
C {devices/lab_pin.sym} 116620 -15010 0 0 {name=p115976 lab=_51073_/X }
C {devices/lab_pin.sym} 116620 -14970 0 0 {name=p115977 lab=_51076_/Y }
C {devices/lab_pin.sym} 116780 -15010 0 1 {name=p115978 lab=_51077_/Y }
C {sky130_stdcells/o21ai_4.sym} 116700 -15010 0 0 {name=X_51077_ }
C {devices/lab_pin.sym} 116660 -14870 0 0 {name=p115979 lab=clkbuf_9_506_0_CLK/X }
C {devices/lab_pin.sym} 116740 -14870 0 1 {name=p115980 lab=_83564_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 116700 -14870 0 0 {name=Xclkbuf_10_1012_0_CLK }
C {devices/lab_pin.sym} 116640 -14760 0 0 {name=p115981 lab=_55954_/A }
C {devices/lab_pin.sym} 116640 -14720 0 0 {name=p115982 lab=_55954_/B }
C {devices/lab_pin.sym} 116760 -14740 0 1 {name=p115983 lab=_55954_/X }
C {sky130_stdcells/and2_4.sym} 116700 -14740 0 0 {name=X_55954_ }
C {devices/lab_pin.sym} 116610 -14610 0 0 {name=p115984 lab=_81111_/CLK }
C {devices/lab_pin.sym} 116610 -14590 0 0 {name=p115985 lab=_46109_/Y }
C {devices/lab_pin.sym} 116790 -14610 0 1 {name=p115986 lab=_40326_/A }
C {sky130_stdcells/dfxtp_4.sym} 116700 -14600 0 0 {name=X_86774_ }
C {devices/lab_pin.sym} 116610 -14470 0 0 {name=p115987 lab=_87188_/CLK }
C {devices/lab_pin.sym} 116610 -14450 0 0 {name=p115988 lab=_83986_/D }
C {devices/lab_pin.sym} 116790 -14470 0 1 {name=p115989 lab=_83986_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -14460 0 0 {name=X_83986_ }
C {devices/lab_pin.sym} 116620 -14350 0 0 {name=p115990 lab=_72436_/B }
C {devices/lab_pin.sym} 116620 -14310 0 0 {name=p115991 lab=_50012_/X }
C {devices/lab_pin.sym} 116620 -14270 0 0 {name=p115992 lab=_50027_/Y }
C {devices/lab_pin.sym} 116780 -14310 0 1 {name=p115993 lab=_50028_/Y }
C {sky130_stdcells/o21ai_4.sym} 116700 -14310 0 0 {name=X_50028_ }
C {devices/lab_pin.sym} 116640 -14200 0 0 {name=p115994 lab=_54910_/A }
C {devices/lab_pin.sym} 116640 -14160 0 0 {name=p115995 lab=_54910_/B }
C {devices/lab_pin.sym} 116640 -14120 0 0 {name=p115996 lab=_54910_/C }
C {devices/lab_pin.sym} 116640 -14080 0 0 {name=p115997 lab=_53211_/D }
C {devices/lab_pin.sym} 116760 -14140 0 1 {name=p115998 lab=_54905_/X }
C {sky130_stdcells/and4_4.sym} 116700 -14140 0 0 {name=X_54905_ }
C {devices/lab_pin.sym} 116610 -13990 0 0 {name=p115999 lab=_85725_/CLK }
C {devices/lab_pin.sym} 116610 -13970 0 0 {name=p116000 lab=_85725_/D }
C {devices/lab_pin.sym} 116790 -13990 0 1 {name=p116001 lab=_85725_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -13980 0 0 {name=X_85725_ }
C {devices/lab_pin.sym} 116660 -13850 0 0 {name=p116002 lab=_70939_/A }
C {devices/lab_pin.sym} 116740 -13850 0 1 {name=p116003 lab=_70954_/C }
C {sky130_stdcells/buf_2.sym} 116700 -13850 0 0 {name=X_70951_ }
C {devices/lab_pin.sym} 116620 -13770 0 0 {name=p116004 lab=_58631_/X }
C {devices/lab_pin.sym} 116620 -13730 0 0 {name=p116005 lab=_58671_/Y }
C {devices/lab_pin.sym} 116620 -13690 0 0 {name=p116006 lab=_58672_/Y }
C {devices/lab_pin.sym} 116620 -13650 0 0 {name=p116007 lab=_58650_/X }
C {devices/lab_pin.sym} 116620 -13610 0 0 {name=p116008 lab=_58636_/X }
C {devices/lab_pin.sym} 116780 -13690 0 1 {name=p116009 lab=_58673_/X }
C {sky130_stdcells/o32a_4.sym} 116700 -13690 0 0 {name=X_58673_ }
C {devices/lab_pin.sym} 116610 -13530 0 0 {name=p116010 lab=_82933_/CLK }
C {devices/lab_pin.sym} 116610 -13510 0 0 {name=p116011 lab=_78299_/X }
C {devices/lab_pin.sym} 116790 -13530 0 1 {name=p116012 lab=_46350_/A }
C {sky130_stdcells/dfxtp_4.sym} 116700 -13520 0 0 {name=X_82937_ }
C {devices/lab_pin.sym} 116640 -13400 0 0 {name=p116013 lab=_55534_/A }
C {devices/lab_pin.sym} 116640 -13360 0 0 {name=p116014 lab=_56494_/C }
C {devices/lab_pin.sym} 116760 -13380 0 1 {name=p116015 lab=_55885_/X }
C {sky130_stdcells/and2_4.sym} 116700 -13380 0 0 {name=X_55885_ }
C {devices/lab_pin.sym} 116620 -13270 0 0 {name=p116016 lab=_57622_/Y }
C {devices/lab_pin.sym} 116620 -13230 0 0 {name=p116017 lab=_57581_/X }
C {devices/lab_pin.sym} 116620 -13190 0 0 {name=p116018 lab=_57623_/Y }
C {devices/lab_pin.sym} 116780 -13230 0 1 {name=p116019 lab=_57624_/Y }
C {sky130_stdcells/a21boi_4.sym} 116700 -13230 0 0 {name=X_57624_ }
C {devices/lab_pin.sym} 116620 -13130 0 0 {name=p116020 lab=_42847_/X }
C {devices/lab_pin.sym} 116620 -13090 0 0 {name=p116021 lab=_42849_/X }
C {devices/lab_pin.sym} 116620 -13050 0 0 {name=p116022 lab=_41520_/X }
C {devices/lab_pin.sym} 116620 -13010 0 0 {name=p116023 lab=_66852_/B }
C {devices/lab_pin.sym} 116620 -12970 0 0 {name=p116024 lab=_42836_/X }
C {devices/lab_pin.sym} 116780 -13050 0 1 {name=p116025 lab=_42850_/Y }
C {sky130_stdcells/o32ai_4.sym} 116700 -13050 0 0 {name=X_42850_ }
C {devices/lab_pin.sym} 116660 -12890 0 0 {name=p116026 lab=_54889_/A }
C {devices/lab_pin.sym} 116740 -12890 0 1 {name=p116027 lab=_54857_/C }
C {sky130_stdcells/buf_2.sym} 116700 -12890 0 0 {name=X_54836_ }
C {devices/lab_pin.sym} 116620 -12790 0 0 {name=p116028 lab=_73655_/X }
C {devices/lab_pin.sym} 116620 -12750 0 0 {name=p116029 lab=_73658_/Y }
C {devices/lab_pin.sym} 116620 -12710 0 0 {name=p116030 lab=_73669_/X }
C {devices/lab_pin.sym} 116780 -12750 0 1 {name=p116031 lab=_73670_/X }
C {sky130_stdcells/a21o_4.sym} 116700 -12750 0 0 {name=X_73670_ }
C {devices/lab_pin.sym} 116610 -12610 0 0 {name=p116032 lab=_85431_/CLK }
C {devices/lab_pin.sym} 116610 -12590 0 0 {name=p116033 lab=_53317_/Y }
C {devices/lab_pin.sym} 116790 -12610 0 1 {name=p116034 lab=_85656_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -12600 0 0 {name=X_85656_ }
C {devices/lab_pin.sym} 116640 -12480 0 0 {name=p116035 lab=_70827_/B }
C {devices/lab_pin.sym} 116640 -12440 0 0 {name=p116036 lab=_71287_/C }
C {devices/lab_pin.sym} 116760 -12460 0 1 {name=p116037 lab=_70882_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -12460 0 0 {name=X_70882_ }
C {devices/lab_pin.sym} 116610 -12330 0 0 {name=p116038 lab=_82343_/CLK }
C {devices/lab_pin.sym} 116610 -12310 0 0 {name=p116039 lab=_82492_/Q }
C {devices/lab_pin.sym} 116790 -12330 0 1 {name=p116040 lab=_82868_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -12320 0 0 {name=X_82868_ }
C {devices/lab_pin.sym} 116620 -12220 0 0 {name=p116041 lab=_40331_/X }
C {devices/lab_pin.sym} 116620 -12180 0 0 {name=p116042 lab=_41799_/X }
C {devices/lab_pin.sym} 116620 -12140 0 0 {name=p116043 lab=_66609_/B }
C {devices/lab_pin.sym} 116620 -12100 0 0 {name=p116044 lab=_41800_/X }
C {devices/lab_pin.sym} 116780 -12160 0 1 {name=p116045 lab=_88146_/D }
C {sky130_stdcells/a2bb2o_4.sym} 116700 -12160 0 0 {name=X_41801_ }
C {devices/lab_pin.sym} 116640 -12020 0 0 {name=p116046 lab=_72569_/A }
C {devices/lab_pin.sym} 116640 -11980 0 0 {name=p116047 lab=_72621_/B }
C {devices/lab_pin.sym} 116760 -12000 0 1 {name=p116048 lab=_72621_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -12000 0 0 {name=X_72621_ }
C {devices/lab_pin.sym} 116610 -11870 0 0 {name=p116049 lab=_84606_/CLK }
C {devices/lab_pin.sym} 116610 -11850 0 0 {name=p116050 lab=_60520_/Y }
C {devices/lab_pin.sym} 116790 -11870 0 1 {name=p116051 lab=_79147_/A }
C {sky130_stdcells/dfxtp_4.sym} 116700 -11860 0 0 {name=X_84607_ }
C {devices/lab_pin.sym} 116660 -11730 0 0 {name=p116052 lab=_46401_/A }
C {devices/lab_pin.sym} 116740 -11730 0 1 {name=p116053 lab=_57597_/A }
C {sky130_stdcells/buf_2.sym} 116700 -11730 0 0 {name=X_57555_ }
C {devices/lab_pin.sym} 116610 -11610 0 0 {name=p116054 lab=_83184_/CLK }
C {devices/lab_pin.sym} 116610 -11590 0 0 {name=p116055 lab=_81819_/D }
C {devices/lab_pin.sym} 116790 -11610 0 1 {name=p116056 lab=_81819_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -11600 0 0 {name=X_81819_ }
C {devices/lab_pin.sym} 116610 -11470 0 0 {name=p116057 lab=_87417_/CLK }
C {devices/lab_pin.sym} 116610 -11450 0 0 {name=p116058 lab=_88375_/D }
C {devices/lab_pin.sym} 116790 -11470 0 1 {name=p116059 lab=_88375_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -11460 0 0 {name=X_88375_ }
C {devices/lab_pin.sym} 116620 -11350 0 0 {name=p116060 lab=_54764_/Y }
C {devices/lab_pin.sym} 116620 -11310 0 0 {name=p116061 lab=_54747_/X }
C {devices/lab_pin.sym} 116620 -11270 0 0 {name=p116062 lab=_54766_/X }
C {devices/lab_pin.sym} 116780 -11310 0 1 {name=p116063 lab=_85382_/D }
C {sky130_stdcells/a21oi_4.sym} 116700 -11310 0 0 {name=X_54767_ }
C {devices/lab_pin.sym} 116660 -11170 0 0 {name=p116064 lab=_42700_/A }
C {devices/lab_pin.sym} 116740 -11170 0 1 {name=p116065 lab=_42781_/X }
C {sky130_stdcells/buf_2.sym} 116700 -11170 0 0 {name=X_42781_ }
C {devices/lab_pin.sym} 116610 -11050 0 0 {name=p116066 lab=_86191_/CLK }
C {devices/lab_pin.sym} 116610 -11030 0 0 {name=p116067 lab=_85587_/D }
C {devices/lab_pin.sym} 116790 -11050 0 1 {name=p116068 lab=_85587_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -11040 0 0 {name=X_85587_ }
C {devices/lab_pin.sym} 116640 -10920 0 0 {name=p116069 lab=_51961_/X }
C {devices/lab_pin.sym} 116640 -10880 0 0 {name=p116070 lab=_47932_/B }
C {devices/lab_pin.sym} 116760 -10900 0 1 {name=p116071 lab=_51979_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -10900 0 0 {name=X_51979_ }
C {devices/lab_pin.sym} 116610 -10770 0 0 {name=p116072 lab=_82425_/CLK }
C {devices/lab_pin.sym} 116610 -10750 0 0 {name=p116073 lab=_82831_/Q }
C {devices/lab_pin.sym} 116790 -10770 0 1 {name=p116074 lab=_82799_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -10760 0 0 {name=X_82799_ }
C {devices/lab_pin.sym} 116620 -10650 0 0 {name=p116075 lab=_56085_/X }
C {devices/lab_pin.sym} 116620 -10610 0 0 {name=p116076 lab=_56499_/X }
C {devices/lab_pin.sym} 116620 -10570 0 0 {name=p116077 lab=_56505_/Y }
C {devices/lab_pin.sym} 116780 -10610 0 1 {name=p116078 lab=_85170_/D }
C {sky130_stdcells/o21ai_4.sym} 116700 -10610 0 0 {name=X_56506_ }
C {devices/lab_pin.sym} 116660 -10470 0 0 {name=p116079 lab=_87069_/Q }
C {devices/lab_pin.sym} 116740 -10470 0 1 {name=p116080 lab=_44520_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -10470 0 0 {name=X_44520_ }
C {devices/lab_pin.sym} 116640 -10360 0 0 {name=p116081 lab=_75340_/A }
C {devices/lab_pin.sym} 116640 -10320 0 0 {name=p116082 lab=_75339_/Y }
C {devices/lab_pin.sym} 116760 -10340 0 1 {name=p116083 lab=_75341_/A }
C {sky130_stdcells/and2_4.sym} 116700 -10340 0 0 {name=X_75340_ }
C {devices/lab_pin.sym} 116610 -10210 0 0 {name=p116084 lab=_87850_/CLK }
C {devices/lab_pin.sym} 116610 -10190 0 0 {name=p116085 lab=_43653_/Y }
C {devices/lab_pin.sym} 116790 -10210 0 1 {name=p116086 lab=_87326_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -10200 0 0 {name=X_87326_ }
C {devices/lab_pin.sym} 116620 -10100 0 0 {name=p116087 lab=_41731_/X }
C {devices/lab_pin.sym} 116620 -10060 0 0 {name=p116088 lab=_41722_/X }
C {devices/lab_pin.sym} 116620 -10020 0 0 {name=p116089 lab=_88160_/Q }
C {devices/lab_pin.sym} 116620 -9980 0 0 {name=p116090 lab=_41723_/X }
C {devices/lab_pin.sym} 116780 -10040 0 1 {name=p116091 lab=_88160_/D }
C {sky130_stdcells/a2bb2o_4.sym} 116700 -10040 0 0 {name=X_41732_ }
C {devices/lab_pin.sym} 116640 -9900 0 0 {name=p116092 lab=_53713_/A }
C {devices/lab_pin.sym} 116640 -9860 0 0 {name=p116093 lab=_48582_/A }
C {devices/lab_pin.sym} 116760 -9880 0 1 {name=p116094 lab=_53718_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -9880 0 0 {name=X_53718_ }
C {devices/lab_pin.sym} 116610 -9750 0 0 {name=p116095 lab=_84538_/CLK }
C {devices/lab_pin.sym} 116610 -9730 0 0 {name=p116096 lab=_84538_/D }
C {devices/lab_pin.sym} 116790 -9750 0 1 {name=p116097 lab=_76986_/A }
C {sky130_stdcells/dfxtp_4.sym} 116700 -9740 0 0 {name=X_84538_ }
C {devices/lab_pin.sym} 116620 -9640 0 0 {name=p116098 lab=_79447_/B }
C {devices/lab_pin.sym} 116620 -9600 0 0 {name=p116099 lab=_60267_/X }
C {devices/lab_pin.sym} 116620 -9560 0 0 {name=p116100 lab=_72549_/Y }
C {devices/lab_pin.sym} 116620 -9520 0 0 {name=p116101 lab=_72551_/X }
C {devices/lab_pin.sym} 116780 -9580 0 1 {name=p116102 lab=_72552_/X }
C {sky130_stdcells/a2bb2o_4.sym} 116700 -9580 0 0 {name=X_72552_ }
C {devices/lab_pin.sym} 116620 -9470 0 0 {name=p116103 lab=_72484_/A }
C {devices/lab_pin.sym} 116620 -9430 0 0 {name=p116104 lab=_72710_/A }
C {devices/lab_pin.sym} 116620 -9390 0 0 {name=p116105 lab=_46173_/X }
C {devices/lab_pin.sym} 116620 -9350 0 0 {name=p116106 lab=_57364_/D }
C {devices/lab_pin.sym} 116620 -9320 0 0 {name=p116107 lab=_56923_/Y }
C {devices/lab_pin.sym} 116780 -9390 0 1 {name=p116108 lab=_57486_/Y }
C {sky130_stdcells/a41oi_4.sym} 116700 -9390 0 0 {name=X_57486_ }
C {devices/lab_pin.sym} 116620 -9250 0 0 {name=p116109 lab=_85394_/Q }
C {devices/lab_pin.sym} 116620 -9210 0 0 {name=p116110 lab=_54676_/X }
C {devices/lab_pin.sym} 116620 -9170 0 0 {name=p116111 lab=_54697_/Y }
C {devices/lab_pin.sym} 116780 -9210 0 1 {name=p116112 lab=_54698_/Y }
C {sky130_stdcells/o21ai_4.sym} 116700 -9210 0 0 {name=X_54698_ }
C {devices/lab_pin.sym} 116660 -9070 0 0 {name=p116113 lab=_57790_/X }
C {devices/lab_pin.sym} 116740 -9070 0 1 {name=p116114 lab=_59226_/B }
C {sky130_stdcells/buf_2.sym} 116700 -9070 0 0 {name=X_59225_ }
C {devices/lab_pin.sym} 116620 -8970 0 0 {name=p116115 lab=_71487_/A }
C {devices/lab_pin.sym} 116620 -8930 0 0 {name=p116116 lab=_83475_/Q }
C {devices/lab_pin.sym} 116620 -8890 0 0 {name=p116117 lab=_71502_/X }
C {devices/lab_pin.sym} 116780 -8930 0 1 {name=p116118 lab=_71503_/X }
C {sky130_stdcells/a21o_4.sym} 116700 -8930 0 0 {name=X_71503_ }
C {devices/lab_pin.sym} 116660 -8790 0 0 {name=p116119 lab=_44451_/A }
C {devices/lab_pin.sym} 116740 -8790 0 1 {name=p116120 lab=_44451_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -8790 0 0 {name=X_44451_ }
C {devices/lab_pin.sym} 116640 -8690 0 0 {name=p116121 lab=_56446_/A }
C {devices/lab_pin.sym} 116640 -8650 0 0 {name=p116122 lab=_56446_/B }
C {devices/lab_pin.sym} 116640 -8610 0 0 {name=p116123 lab=_85194_/Q }
C {devices/lab_pin.sym} 116760 -8650 0 1 {name=p116124 lab=_56437_/Y }
C {sky130_stdcells/nand3_4.sym} 116700 -8650 0 0 {name=X_56437_ }
C {devices/lab_pin.sym} 116640 -8530 0 0 {name=p116125 lab=_75267_/Y }
C {devices/lab_pin.sym} 116640 -8490 0 0 {name=p116126 lab=_75268_/Y }
C {devices/lab_pin.sym} 116640 -8450 0 0 {name=p116127 lab=_75270_/Y }
C {devices/lab_pin.sym} 116760 -8490 0 1 {name=p116128 lab=_75271_/X }
C {sky130_stdcells/or3_4.sym} 116700 -8490 0 0 {name=X_75271_ }
C {devices/lab_pin.sym} 116660 -8350 0 0 {name=p116129 lab=_41662_/Y }
C {devices/lab_pin.sym} 116740 -8350 0 1 {name=p116130 lab=_41663_/X }
C {sky130_stdcells/buf_2.sym} 116700 -8350 0 0 {name=X_41663_ }
C {devices/lab_pin.sym} 116610 -8230 0 0 {name=p116131 lab=_87776_/CLK }
C {devices/lab_pin.sym} 116610 -8210 0 0 {name=p116132 lab=_87257_/D }
C {devices/lab_pin.sym} 116790 -8230 0 1 {name=p116133 lab=_69494_/B }
C {sky130_stdcells/dfxtp_4.sym} 116700 -8220 0 0 {name=X_87257_ }
C {devices/lab_pin.sym} 116640 -8110 0 0 {name=p116134 lab=_48744_/A }
C {devices/lab_pin.sym} 116640 -8070 0 0 {name=p116135 lab=_53658_/B }
C {devices/lab_pin.sym} 116640 -8030 0 0 {name=p116136 lab=_53667_/C }
C {devices/lab_pin.sym} 116760 -8070 0 1 {name=p116137 lab=_53649_/X }
C {sky130_stdcells/and3_4.sym} 116700 -8070 0 0 {name=X_53649_ }
C {devices/lab_pin.sym} 116620 -7960 0 0 {name=p116138 lab=_83250_/Q }
C {devices/lab_pin.sym} 116620 -7920 0 0 {name=p116139 lab=_72445_/X }
C {devices/lab_pin.sym} 116620 -7880 0 0 {name=p116140 lab=_72477_/X }
C {devices/lab_pin.sym} 116620 -7840 0 0 {name=p116141 lab=_72482_/X }
C {devices/lab_pin.sym} 116780 -7900 0 1 {name=p116142 lab=_83250_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 116700 -7900 0 0 {name=X_72483_ }
C {devices/lab_pin.sym} 116610 -7750 0 0 {name=p116143 lab=_84469_/CLK }
C {devices/lab_pin.sym} 116610 -7730 0 0 {name=p116144 lab=_61578_/Y }
C {devices/lab_pin.sym} 116790 -7750 0 1 {name=p116145 lab=_61577_/C }
C {sky130_stdcells/dfxtp_4.sym} 116700 -7740 0 0 {name=X_84469_ }
C {devices/lab_pin.sym} 116660 -7610 0 0 {name=p116146 lab=_77010_/A }
C {devices/lab_pin.sym} 116740 -7610 0 1 {name=p116147 lab=_77011_/B }
C {sky130_stdcells/inv_2.sym} 116700 -7610 0 0 {name=X_77010_ }
C {devices/lab_pin.sym} 116620 -7520 0 0 {name=p116148 lab=_41479_/X }
C {devices/lab_pin.sym} 116620 -7480 0 0 {name=p116149 lab=_43396_/X }
C {devices/lab_pin.sym} 116620 -7440 0 0 {name=p116150 lab=_87439_/Q }
C {devices/lab_pin.sym} 116620 -7400 0 0 {name=p116151 lab=_43397_/X }
C {devices/lab_pin.sym} 116780 -7460 0 1 {name=p116152 lab=_43402_/X }
C {sky130_stdcells/a2bb2o_4.sym} 116700 -7460 0 0 {name=X_43402_ }
C {devices/lab_pin.sym} 116640 -7320 0 0 {name=p116153 lab=_74202_/A }
C {devices/lab_pin.sym} 116640 -7280 0 0 {name=p116154 lab=_74221_/Y }
C {devices/lab_pin.sym} 116760 -7300 0 1 {name=p116155 lab=_74222_/Y }
C {sky130_stdcells/nor2_4.sym} 116700 -7300 0 0 {name=X_74222_ }
C {devices/lab_pin.sym} 116610 -7170 0 0 {name=p116156 lab=_85599_/CLK }
C {devices/lab_pin.sym} 116610 -7150 0 0 {name=p116157 lab=_86208_/D }
C {devices/lab_pin.sym} 116790 -7170 0 1 {name=p116158 lab=_86208_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -7160 0 0 {name=X_86208_ }
C {devices/lab_pin.sym} 116660 -7030 0 0 {name=p116159 lab=_40614_/A }
C {devices/lab_pin.sym} 116740 -7030 0 1 {name=p116160 lab=_40614_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -7030 0 0 {name=X_40614_ }
C {devices/lab_pin.sym} 116660 -6910 0 0 {name=p116161 lab=_47169_/Y }
C {devices/lab_pin.sym} 116740 -6910 0 1 {name=p116162 lab=_52895_/D }
C {sky130_stdcells/buf_2.sym} 116700 -6910 0 0 {name=X_47170_ }
C {devices/lab_pin.sym} 116660 -6790 0 0 {name=p116163 lab=_58868_/A }
C {devices/lab_pin.sym} 116740 -6790 0 1 {name=p116164 lab=_59156_/X }
C {sky130_stdcells/buf_2.sym} 116700 -6790 0 0 {name=X_59156_ }
C {devices/lab_pin.sym} 116660 -6670 0 0 {name=p116165 lab=_71418_/B }
C {devices/lab_pin.sym} 116740 -6670 0 1 {name=p116166 lab=_71435_/B }
C {sky130_stdcells/buf_2.sym} 116700 -6670 0 0 {name=X_71434_ }
C {devices/lab_pin.sym} 116660 -6550 0 0 {name=p116167 lab=_44382_/A }
C {devices/lab_pin.sym} 116740 -6550 0 1 {name=p116168 lab=_44382_/X }
C {sky130_stdcells/buf_2.sym} 116700 -6550 0 0 {name=X_44382_ }
C {devices/lab_pin.sym} 116640 -6450 0 0 {name=p116169 lab=_56368_/A }
C {devices/lab_pin.sym} 116640 -6410 0 0 {name=p116170 lab=_56177_/B }
C {devices/lab_pin.sym} 116640 -6370 0 0 {name=p116171 lab=_55736_/B }
C {devices/lab_pin.sym} 116760 -6410 0 1 {name=p116172 lab=_56368_/Y }
C {sky130_stdcells/nand3_4.sym} 116700 -6410 0 0 {name=X_56368_ }
C {devices/lab_pin.sym} 116610 -6270 0 0 {name=p116173 lab=_87188_/CLK }
C {devices/lab_pin.sym} 116610 -6250 0 0 {name=p116174 lab=_43942_/X }
C {devices/lab_pin.sym} 116790 -6270 0 1 {name=p116175 lab=_68071_/B }
C {sky130_stdcells/dfxtp_4.sym} 116700 -6260 0 0 {name=X_87188_ }
C {devices/lab_pin.sym} 116640 -6140 0 0 {name=p116176 lab=_41604_/A }
C {devices/lab_pin.sym} 116640 -6100 0 0 {name=p116177 lab=_82311_/Q }
C {devices/lab_pin.sym} 116760 -6120 0 1 {name=p116178 lab=_41594_/X }
C {sky130_stdcells/or2_4.sym} 116700 -6120 0 0 {name=X_41594_ }
C {devices/lab_pin.sym} 116660 -5990 0 0 {name=p116179 lab=_46121_/A }
C {devices/lab_pin.sym} 116740 -5990 0 1 {name=p116180 lab=_46121_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -5990 0 0 {name=X_46121_ }
C {devices/lab_pin.sym} 116620 -5900 0 0 {name=p116181 lab=_84925_/Q }
C {devices/lab_pin.sym} 116620 -5860 0 0 {name=p116182 lab=_58095_/X }
C {devices/lab_pin.sym} 116620 -5820 0 0 {name=p116183 lab=_58099_/X }
C {devices/lab_pin.sym} 116620 -5780 0 0 {name=p116184 lab=_58106_/X }
C {devices/lab_pin.sym} 116780 -5840 0 1 {name=p116185 lab=_84925_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 116700 -5840 0 0 {name=X_58107_ }
C {devices/lab_pin.sym} 116620 -5720 0 0 {name=p116186 lab=_41282_/X }
C {devices/lab_pin.sym} 116620 -5680 0 0 {name=p116187 lab=_43325_/X }
C {devices/lab_pin.sym} 116620 -5640 0 0 {name=p116188 lab=_87476_/Q }
C {devices/lab_pin.sym} 116620 -5600 0 0 {name=p116189 lab=_43326_/X }
C {devices/lab_pin.sym} 116780 -5660 0 1 {name=p116190 lab=_87476_/D }
C {sky130_stdcells/a2bb2o_4.sym} 116700 -5660 0 0 {name=X_43333_ }
C {devices/lab_pin.sym} 116660 -5510 0 0 {name=p116191 lab=_85070_/Q }
C {devices/lab_pin.sym} 116740 -5510 0 1 {name=p116192 lab=_55320_/B }
C {sky130_stdcells/inv_2.sym} 116700 -5510 0 0 {name=X_55319_ }
C {devices/lab_pin.sym} 116610 -5390 0 0 {name=p116193 lab=_86139_/CLK }
C {devices/lab_pin.sym} 116610 -5370 0 0 {name=p116194 lab=_86139_/D }
C {devices/lab_pin.sym} 116790 -5390 0 1 {name=p116195 lab=_86139_/Q }
C {sky130_stdcells/dfxtp_4.sym} 116700 -5380 0 0 {name=X_86139_ }
C {devices/lab_pin.sym} 116620 -5280 0 0 {name=p116196 lab=_74106_/X }
C {devices/lab_pin.sym} 116620 -5240 0 0 {name=p116197 lab=_85608_/Q }
C {devices/lab_pin.sym} 116620 -5200 0 0 {name=p116198 lab=_74107_/X }
C {devices/lab_pin.sym} 116620 -5160 0 0 {name=p116199 lab=_74152_/X }
C {devices/lab_pin.sym} 116780 -5220 0 1 {name=p116200 lab=_74153_/X }
C {sky130_stdcells/a211o_4.sym} 116700 -5220 0 0 {name=X_74153_ }
C {devices/lab_pin.sym} 116620 -5100 0 0 {name=p116201 lab=_40542_/X }
C {devices/lab_pin.sym} 116620 -5060 0 0 {name=p116202 lab=_40543_/X }
C {devices/lab_pin.sym} 116620 -5020 0 0 {name=p116203 lab=_88373_/Q }
C {devices/lab_pin.sym} 116620 -4980 0 0 {name=p116204 lab=_40544_/X }
C {devices/lab_pin.sym} 116780 -5040 0 1 {name=p116205 lab=_88373_/D }
C {sky130_stdcells/a2bb2o_4.sym} 116700 -5040 0 0 {name=X_40545_ }
C {devices/lab_pin.sym} 116620 -4910 0 0 {name=p116206 lab=_59085_/X }
C {devices/lab_pin.sym} 116620 -4870 0 0 {name=p116207 lab=_86074_/Q }
C {devices/lab_pin.sym} 116620 -4830 0 0 {name=p116208 lab=_59086_/X }
C {devices/lab_pin.sym} 116780 -4870 0 1 {name=p116209 lab=_59087_/Y }
C {sky130_stdcells/o21ai_4.sym} 116700 -4870 0 0 {name=X_59087_ }
C {devices/lab_pin.sym} 116660 -4730 0 0 {name=p116210 lab=_71429_/A }
C {devices/lab_pin.sym} 116740 -4730 0 1 {name=p116211 lab=_71365_/X }
C {sky130_stdcells/buf_2.sym} 116700 -4730 0 0 {name=X_71365_ }
C {devices/lab_pin.sym} 116640 -4630 0 0 {name=p116212 lab=_56296_/A }
C {devices/lab_pin.sym} 116640 -4590 0 0 {name=p116213 lab=_56298_/X }
C {devices/lab_pin.sym} 116640 -4550 0 0 {name=p116214 lab=_85245_/Q }
C {devices/lab_pin.sym} 116760 -4590 0 1 {name=p116215 lab=_56299_/Y }
C {sky130_stdcells/nand3_4.sym} 116700 -4590 0 0 {name=X_56299_ }
C {devices/lab_pin.sym} 116640 -4460 0 0 {name=p116216 lab=_73104_/A }
C {devices/lab_pin.sym} 116640 -4420 0 0 {name=p116217 lab=_73104_/B }
C {devices/lab_pin.sym} 116760 -4440 0 1 {name=p116218 lab=_73104_/Y }
C {sky130_stdcells/nor2_4.sym} 116700 -4440 0 0 {name=X_73104_ }
C {devices/lab_pin.sym} 116620 -4340 0 0 {name=p116219 lab=_41524_/Y }
C {devices/lab_pin.sym} 116620 -4300 0 0 {name=p116220 lab=_46043_/X }
C {devices/lab_pin.sym} 116620 -4260 0 0 {name=p116221 lab=_86793_/Q }
C {devices/lab_pin.sym} 116620 -4220 0 0 {name=p116222 lab=_46044_/X }
C {devices/lab_pin.sym} 116780 -4280 0 1 {name=p116223 lab=_46052_/X }
C {sky130_stdcells/a2bb2o_4.sym} 116700 -4280 0 0 {name=X_46052_ }
C {devices/lab_pin.sym} 116640 -4140 0 0 {name=p116224 lab=_58070_/A }
C {devices/lab_pin.sym} 116640 -4100 0 0 {name=p116225 lab=_58038_/B }
C {devices/lab_pin.sym} 116760 -4120 0 1 {name=p116226 lab=_58038_/Y }
C {sky130_stdcells/nor2_4.sym} 116700 -4120 0 0 {name=X_58038_ }
C {devices/lab_pin.sym} 116620 -4010 0 0 {name=p116227 lab=_70303_/X }
C {devices/lab_pin.sym} 116620 -3970 0 0 {name=p116228 lab=_74794_/B }
C {devices/lab_pin.sym} 116620 -3930 0 0 {name=p116229 lab=_70315_/X }
C {devices/lab_pin.sym} 116780 -3970 0 1 {name=p116230 lab=_70316_/X }
C {sky130_stdcells/a21o_4.sym} 116700 -3970 0 0 {name=X_70316_ }
C {devices/lab_pin.sym} 116660 -3830 0 0 {name=p116231 lab=_43180_/A }
C {devices/lab_pin.sym} 116740 -3830 0 1 {name=p116232 lab=_43264_/X }
C {sky130_stdcells/buf_2.sym} 116700 -3830 0 0 {name=X_43264_ }
C {devices/lab_pin.sym} 116620 -3740 0 0 {name=p116233 lab=_73449_/X }
C {devices/lab_pin.sym} 116620 -3700 0 0 {name=p116234 lab=_85611_/Q }
C {devices/lab_pin.sym} 116620 -3660 0 0 {name=p116235 lab=_73450_/X }
C {devices/lab_pin.sym} 116620 -3620 0 0 {name=p116236 lab=_74083_/X }
C {devices/lab_pin.sym} 116780 -3680 0 1 {name=p116237 lab=_74084_/X }
C {sky130_stdcells/a211o_4.sym} 116700 -3680 0 0 {name=X_74084_ }
C {devices/lab_pin.sym} 116640 -3540 0 0 {name=p116238 lab=_78959_/Y }
C {devices/lab_pin.sym} 116640 -3500 0 0 {name=p116239 lab=_78960_/Y }
C {devices/lab_pin.sym} 116760 -3520 0 1 {name=p116240 lab=_78970_/B }
C {sky130_stdcells/xor2_4.sym} 116700 -3520 0 0 {name=X_78961_ }
C {devices/lab_pin.sym} 116660 -3390 0 0 {name=p116241 lab=_40475_/Y }
C {devices/lab_pin.sym} 116740 -3390 0 1 {name=p116242 lab=_88386_/D }
C {sky130_stdcells/inv_2.sym} 116700 -3390 0 0 {name=X_40476_ }
C {devices/lab_pin.sym} 116620 -3290 0 0 {name=p116243 lab=_50310_/B }
C {devices/lab_pin.sym} 116620 -3250 0 0 {name=p116244 lab=_71290_/X }
C {devices/lab_pin.sym} 116620 -3210 0 0 {name=p116245 lab=_71295_/Y }
C {devices/lab_pin.sym} 116780 -3250 0 1 {name=p116246 lab=_83545_/D }
C {sky130_stdcells/o21ai_4.sym} 116700 -3250 0 0 {name=X_71296_ }
C {devices/lab_pin.sym} 116620 -3130 0 0 {name=p116247 lab=_45000_/Y }
C {devices/lab_pin.sym} 116620 -3090 0 0 {name=p116248 lab=_45002_/Y }
C {devices/lab_pin.sym} 116620 -3050 0 0 {name=p116249 lab=_44986_/X }
C {devices/lab_pin.sym} 116780 -3090 0 1 {name=p116250 lab=_45003_/X }
C {sky130_stdcells/a21o_4.sym} 116700 -3090 0 0 {name=X_45003_ }
C {devices/lab_pin.sym} 116660 -2950 0 0 {name=p116251 lab=_42215_/A }
C {devices/lab_pin.sym} 116740 -2950 0 1 {name=p116252 lab=_42215_/Y }
C {sky130_stdcells/inv_2.sym} 116700 -2950 0 0 {name=X_42215_ }
C {devices/lab_pin.sym} 116660 -2830 0 0 {name=p116253 lab=_77890_/Y }
C {devices/lab_pin.sym} 116740 -2830 0 1 {name=p116254 lab=_81940_/D }
C {sky130_stdcells/inv_2.sym} 116700 -2830 0 0 {name=X_77912_ }
C {devices/lab_pin.sym} 116660 -2710 0 0 {name=p116255 lab=_72857_/X }
C {devices/lab_pin.sym} 116740 -2710 0 1 {name=p116256 lab=_73035_/X }
C {sky130_stdcells/buf_2.sym} 116700 -2710 0 0 {name=X_73035_ }
C {devices/lab_pin.sym} 116660 -2590 0 0 {name=p116257 lab=_70154_/X }
C {devices/lab_pin.sym} 116740 -2590 0 1 {name=p116258 lab=_70247_/X }
C {sky130_stdcells/buf_2.sym} 116700 -2590 0 0 {name=X_70247_ }
C {devices/lab_pin.sym} 116660 -2470 0 0 {name=p116259 lab=_43195_/A }
C {devices/lab_pin.sym} 116740 -2470 0 1 {name=p116260 lab=_87544_/D }
C {sky130_stdcells/inv_2.sym} 116700 -2470 0 0 {name=X_43195_ }
C {devices/lab_pin.sym} 116640 -2360 0 0 {name=p116261 lab=_78890_/Y }
C {devices/lab_pin.sym} 116640 -2320 0 0 {name=p116262 lab=_78892_/B }
C {devices/lab_pin.sym} 116760 -2340 0 1 {name=p116263 lab=_78900_/A }
C {sky130_stdcells/xor2_4.sym} 116700 -2340 0 0 {name=X_78892_ }
C {devices/lab_pin.sym} 116640 -2220 0 0 {name=p116264 lab=_60000_/A }
C {devices/lab_pin.sym} 116640 -2180 0 0 {name=p116265 lab=_59962_/A }
C {devices/lab_pin.sym} 116760 -2200 0 1 {name=p116266 lab=_60000_/Y }
C {sky130_stdcells/nand2_4.sym} 116700 -2200 0 0 {name=X_60000_ }
C {devices/lab_pin.sym} 116640 -2100 0 0 {name=p116267 lab=_49807_/A }
C {devices/lab_pin.sym} 116640 -2060 0 0 {name=p116268 lab=_49830_/B }
C {devices/lab_pin.sym} 116640 -2020 0 0 {name=p116269 lab=_49795_/X }
C {devices/lab_pin.sym} 116640 -1980 0 0 {name=p116270 lab=_53023_/D }
C {devices/lab_pin.sym} 116760 -2040 0 1 {name=p116271 lab=_49811_/X }
C {sky130_stdcells/and4_4.sym} 116700 -2040 0 0 {name=X_49811_ }
C {devices/lab_pin.sym} 116620 -1920 0 0 {name=p116272 lab=_41151_/X }
C {devices/lab_pin.sym} 116620 -1880 0 0 {name=p116273 lab=_42137_/X }
C {devices/lab_pin.sym} 116620 -1840 0 0 {name=p116274 lab=_88012_/Q }
C {devices/lab_pin.sym} 116620 -1800 0 0 {name=p116275 lab=_42138_/X }
C {devices/lab_pin.sym} 116780 -1860 0 1 {name=p116276 lab=_42146_/X }
C {sky130_stdcells/a2bb2o_4.sym} 116700 -1860 0 0 {name=X_42146_ }
C {devices/lab_pin.sym} 116640 -1720 0 0 {name=p116277 lab=_82158_/Q }
C {devices/lab_pin.sym} 116640 -1680 0 0 {name=p116278 lab=_77843_/B }
C {devices/lab_pin.sym} 116760 -1700 0 1 {name=p116279 lab=_77843_/X }
C {sky130_stdcells/xor2_4.sym} 116700 -1700 0 0 {name=X_77843_ }
C {devices/lab_pin.sym} 116640 -1600 0 0 {name=p116280 lab=_70183_/A }
C {devices/lab_pin.sym} 116640 -1560 0 0 {name=p116281 lab=_70183_/B }
C {devices/lab_pin.sym} 116640 -1520 0 0 {name=p116282 lab=_70178_/C }
C {devices/lab_pin.sym} 116640 -1480 0 0 {name=p116283 lab=_70183_/D }
C {devices/lab_pin.sym} 116760 -1540 0 1 {name=p116284 lab=_70178_/X }
C {sky130_stdcells/and4_4.sym} 116700 -1540 0 0 {name=X_70178_ }
C {devices/lab_pin.sym} 116620 -1420 0 0 {name=p116285 lab=_80215_/A }
C {devices/lab_pin.sym} 116620 -1380 0 0 {name=p116286 lab=_59339_/X }
C {devices/lab_pin.sym} 116620 -1340 0 0 {name=p116287 lab=_59988_/Y }
C {devices/lab_pin.sym} 116620 -1300 0 0 {name=p116288 lab=_59979_/Y }
C {devices/lab_pin.sym} 116780 -1360 0 1 {name=p116289 lab=_84678_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 116700 -1360 0 0 {name=X_59989_ }
C {devices/lab_pin.sym} 116660 -1210 0 0 {name=p116290 lab=clkbuf_8_85_0_CLK/X }
C {devices/lab_pin.sym} 116740 -1210 0 1 {name=p116291 lab=clkbuf_9_170_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 116700 -1210 0 0 {name=Xclkbuf_9_170_0_CLK }
C {devices/lab_pin.sym} 116660 -1090 0 0 {name=p116292 lab=_49825_/A }
C {devices/lab_pin.sym} 116740 -1090 0 1 {name=p116293 lab=_49742_/X }
C {sky130_stdcells/buf_2.sym} 116700 -1090 0 0 {name=X_49742_ }
C {devices/lab_pin.sym} 116620 -990 0 0 {name=p116294 lab=_46949_/Y }
C {devices/lab_pin.sym} 116620 -950 0 0 {name=p116295 lab=_46940_/X }
C {devices/lab_pin.sym} 116620 -910 0 0 {name=p116296 lab=_46953_/X }
C {devices/lab_pin.sym} 116780 -950 0 1 {name=p116297 lab=_86686_/D }
C {sky130_stdcells/a21oi_4.sym} 116700 -950 0 0 {name=X_46954_ }
C {devices/lab_pin.sym} 116660 -810 0 0 {name=p116298 lab=_42077_/A }
C {devices/lab_pin.sym} 116740 -810 0 1 {name=p116299 lab=_42077_/X }
C {sky130_stdcells/buf_2.sym} 116700 -810 0 0 {name=X_42077_ }
C {devices/lab_pin.sym} 116640 -700 0 0 {name=p116300 lab=_82151_/Q }
C {devices/lab_pin.sym} 116640 -660 0 0 {name=p116301 lab=_77774_/B }
C {devices/lab_pin.sym} 116760 -680 0 1 {name=p116302 lab=_82119_/D }
C {sky130_stdcells/xor2_4.sym} 116700 -680 0 0 {name=X_77774_ }
C {devices/lab_pin.sym} 117560 -42160 0 0 {name=p116303 lab=_80766_/Q }
C {devices/lab_pin.sym} 117560 -42120 0 0 {name=p116304 lab=_74995_/B }
C {devices/lab_pin.sym} 117680 -42140 0 1 {name=p116305 lab=_74986_/X }
C {sky130_stdcells/xor2_4.sym} 117620 -42140 0 0 {name=X_74986_ }
C {devices/lab_pin.sym} 117560 -42020 0 0 {name=p116306 lab=_79513_/A }
C {devices/lab_pin.sym} 117560 -41980 0 0 {name=p116307 lab=_79513_/B }
C {devices/lab_pin.sym} 117680 -42000 0 1 {name=p116308 lab=_79513_/X }
C {sky130_stdcells/xor2_4.sym} 117620 -42000 0 0 {name=X_79513_ }
C {devices/lab_pin.sym} 117540 -41890 0 0 {name=p116309 lab=_45893_/B }
C {devices/lab_pin.sym} 117540 -41850 0 0 {name=p116310 lab=_45883_/B }
C {devices/lab_pin.sym} 117540 -41810 0 0 {name=p116311 lab=_45904_/X }
C {devices/lab_pin.sym} 117700 -41850 0 1 {name=p116312 lab=_45905_/X }
C {sky130_stdcells/o21a_4.sym} 117620 -41850 0 0 {name=X_45905_ }
C {devices/lab_pin.sym} 117580 -41710 0 0 {name=p116313 lab=_41027_/Y }
C {devices/lab_pin.sym} 117660 -41710 0 1 {name=p116314 lab=_41028_/X }
C {sky130_stdcells/buf_2.sym} 117620 -41710 0 0 {name=X_41028_ }
C {devices/lab_pin.sym} 117560 -41600 0 0 {name=p116315 lab=_76725_/A }
C {devices/lab_pin.sym} 117560 -41560 0 0 {name=p116316 lab=_76724_/Y }
C {devices/lab_pin.sym} 117680 -41580 0 1 {name=p116317 lab=_81450_/D }
C {sky130_stdcells/xor2_4.sym} 117620 -41580 0 0 {name=X_76725_ }
C {devices/lab_pin.sym} 117580 -41450 0 0 {name=p116318 lab=clkbuf_9_347_0_CLK/X }
C {devices/lab_pin.sym} 117660 -41450 0 1 {name=p116319 lab=_87625_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 117620 -41450 0 0 {name=Xclkbuf_10_694_0_CLK }
C {devices/lab_pin.sym} 117560 -41360 0 0 {name=p116320 lab=_49651_/X }
C {devices/lab_pin.sym} 117560 -41320 0 0 {name=p116321 lab=_49669_/B }
C {devices/lab_pin.sym} 117560 -41280 0 0 {name=p116322 lab=_49669_/C }
C {devices/lab_pin.sym} 117560 -41240 0 0 {name=p116323 lab=_52887_/D }
C {devices/lab_pin.sym} 117680 -41300 0 1 {name=p116324 lab=_49673_/X }
C {sky130_stdcells/and4_4.sym} 117620 -41300 0 0 {name=X_49673_ }
C {devices/lab_pin.sym} 117580 -41150 0 0 {name=p116325 lab=_61736_/A }
C {devices/lab_pin.sym} 117660 -41150 0 1 {name=p116326 lab=_61957_/A }
C {sky130_stdcells/buf_2.sym} 117620 -41150 0 0 {name=X_61951_ }
C {devices/lab_pin.sym} 117560 -41040 0 0 {name=p116327 lab=_73937_/A }
C {devices/lab_pin.sym} 117560 -41000 0 0 {name=p116328 lab=_74003_/B }
C {devices/lab_pin.sym} 117680 -41020 0 1 {name=p116329 lab=_73937_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -41020 0 0 {name=X_73937_ }
C {devices/lab_pin.sym} 117540 -40910 0 0 {name=p116330 lab=_46881_/Y }
C {devices/lab_pin.sym} 117540 -40870 0 0 {name=p116331 lab=_46844_/X }
C {devices/lab_pin.sym} 117540 -40830 0 0 {name=p116332 lab=_46884_/X }
C {devices/lab_pin.sym} 117700 -40870 0 1 {name=p116333 lab=_86693_/D }
C {sky130_stdcells/a21oi_4.sym} 117620 -40870 0 0 {name=X_46885_ }
C {devices/lab_pin.sym} 117560 -40750 0 0 {name=p116334 lab=_52218_/A }
C {devices/lab_pin.sym} 117560 -40710 0 0 {name=p116335 lab=_48624_/B }
C {devices/lab_pin.sym} 117560 -40670 0 0 {name=p116336 lab=_48657_/C }
C {devices/lab_pin.sym} 117680 -40710 0 1 {name=p116337 lab=_48624_/X }
C {sky130_stdcells/and3_4.sym} 117620 -40710 0 0 {name=X_48624_ }
C {devices/lab_pin.sym} 117560 -40580 0 0 {name=p116338 lab=_60881_/B }
C {devices/lab_pin.sym} 117560 -40540 0 0 {name=p116339 lab=_60543_/B }
C {devices/lab_pin.sym} 117680 -40560 0 1 {name=p116340 lab=_60902_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -40560 0 0 {name=X_60902_ }
C {devices/lab_pin.sym} 117560 -40440 0 0 {name=p116341 lab=_79444_/A }
C {devices/lab_pin.sym} 117560 -40400 0 0 {name=p116342 lab=_79444_/B }
C {devices/lab_pin.sym} 117680 -40420 0 1 {name=p116343 lab=_79444_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -40420 0 0 {name=X_79444_ }
C {devices/lab_pin.sym} 117580 -40290 0 0 {name=p116344 lab=_46187_/A }
C {devices/lab_pin.sym} 117660 -40290 0 1 {name=p116345 lab=_45836_/X }
C {sky130_stdcells/buf_2.sym} 117620 -40290 0 0 {name=X_45836_ }
C {devices/lab_pin.sym} 117560 -40180 0 0 {name=p116346 lab=_64769_/A }
C {devices/lab_pin.sym} 117560 -40140 0 0 {name=p116347 lab=_64670_/B }
C {devices/lab_pin.sym} 117680 -40160 0 1 {name=p116348 lab=_64670_/X }
C {sky130_stdcells/and2_4.sym} 117620 -40160 0 0 {name=X_64670_ }
C {devices/lab_pin.sym} 117560 -40040 0 0 {name=p116349 lab=_76655_/Y }
C {devices/lab_pin.sym} 117560 -40000 0 0 {name=p116350 lab=_76656_/B }
C {devices/lab_pin.sym} 117680 -40020 0 1 {name=p116351 lab=_76662_/A }
C {sky130_stdcells/nand2_4.sym} 117620 -40020 0 0 {name=X_76656_ }
C {devices/lab_pin.sym} 117580 -39890 0 0 {name=p116352 lab=clkbuf_8_92_0_CLK/X }
C {devices/lab_pin.sym} 117660 -39890 0 1 {name=p116353 lab=clkbuf_9_185_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 117620 -39890 0 0 {name=Xclkbuf_9_185_0_CLK }
C {devices/lab_pin.sym} 117560 -39790 0 0 {name=p116354 lab=_61865_/A }
C {devices/lab_pin.sym} 117560 -39750 0 0 {name=p116355 lab=_61865_/B }
C {devices/lab_pin.sym} 117560 -39710 0 0 {name=p116356 lab=_78071_/B }
C {devices/lab_pin.sym} 117680 -39750 0 1 {name=p116357 lab=_61882_/Y }
C {sky130_stdcells/nor3_4.sym} 117620 -39750 0 0 {name=X_61882_ }
C {devices/lab_pin.sym} 117540 -39630 0 0 {name=p116358 lab=_70100_/Y }
C {devices/lab_pin.sym} 117540 -39590 0 0 {name=p116359 lab=_73818_/X }
C {devices/lab_pin.sym} 117540 -39550 0 0 {name=p116360 lab=_73867_/X }
C {devices/lab_pin.sym} 117700 -39590 0 1 {name=p116361 lab=_73868_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -39590 0 0 {name=X_73868_ }
C {devices/lab_pin.sym} 117540 -39490 0 0 {name=p116362 lab=_63617_/Y }
C {devices/lab_pin.sym} 117540 -39450 0 0 {name=p116363 lab=_63618_/Y }
C {devices/lab_pin.sym} 117540 -39410 0 0 {name=p116364 lab=_63620_/X }
C {devices/lab_pin.sym} 117540 -39370 0 0 {name=p116365 lab=_58457_/A }
C {devices/lab_pin.sym} 117540 -39330 0 0 {name=p116366 lab=_63363_/X }
C {devices/lab_pin.sym} 117700 -39410 0 1 {name=p116367 lab=_63621_/Y }
C {sky130_stdcells/o32ai_4.sym} 117620 -39410 0 0 {name=X_63621_ }
C {devices/lab_pin.sym} 117560 -39260 0 0 {name=p116368 lab=_75891_/A }
C {devices/lab_pin.sym} 117560 -39220 0 0 {name=p116369 lab=_75607_/B }
C {devices/lab_pin.sym} 117680 -39240 0 1 {name=p116370 lab=_75607_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -39240 0 0 {name=X_75607_ }
C {devices/lab_pin.sym} 117580 -39110 0 0 {name=p116371 lab=_63487_/A }
C {devices/lab_pin.sym} 117660 -39110 0 1 {name=p116372 lab=_63426_/A }
C {sky130_stdcells/buf_2.sym} 117620 -39110 0 0 {name=X_60833_ }
C {devices/lab_pin.sym} 117560 -39000 0 0 {name=p116373 lab=_72813_/X }
C {devices/lab_pin.sym} 117560 -38960 0 0 {name=p116374 lab=_72819_/B }
C {devices/lab_pin.sym} 117680 -38980 0 1 {name=p116375 lab=_72820_/B }
C {sky130_stdcells/nand2_4.sym} 117620 -38980 0 0 {name=X_72819_ }
C {devices/lab_pin.sym} 117540 -38870 0 0 {name=p116376 lab=_48134_/X }
C {devices/lab_pin.sym} 117540 -38830 0 0 {name=p116377 lab=_48018_/A }
C {devices/lab_pin.sym} 117540 -38790 0 0 {name=p116378 lab=_48554_/X }
C {devices/lab_pin.sym} 117700 -38830 0 1 {name=p116379 lab=_48801_/B }
C {sky130_stdcells/o21ai_4.sym} 117620 -38830 0 0 {name=X_48555_ }
C {devices/lab_pin.sym} 117580 -38690 0 0 {name=p116380 lab=_79374_/X }
C {devices/lab_pin.sym} 117660 -38690 0 1 {name=p116381 lab=_79375_/Y }
C {sky130_stdcells/inv_2.sym} 117620 -38690 0 0 {name=X_79375_ }
C {devices/lab_pin.sym} 117540 -38590 0 0 {name=p116382 lab=_45758_/X }
C {devices/lab_pin.sym} 117540 -38550 0 0 {name=p116383 lab=_45762_/Y }
C {devices/lab_pin.sym} 117540 -38510 0 0 {name=p116384 lab=_45766_/Y }
C {devices/lab_pin.sym} 117700 -38550 0 1 {name=p116385 lab=_45767_/Y }
C {sky130_stdcells/a21oi_4.sym} 117620 -38550 0 0 {name=X_45767_ }
C {devices/lab_pin.sym} 117560 -38420 0 0 {name=p116386 lab=_76541_/B }
C {devices/lab_pin.sym} 117560 -38380 0 0 {name=p116387 lab=_76559_/A }
C {devices/lab_pin.sym} 117680 -38400 0 1 {name=p116388 lab=_76587_/X }
C {sky130_stdcells/or2_4.sym} 117620 -38400 0 0 {name=X_76587_ }
C {devices/lab_pin.sym} 117540 -38310 0 0 {name=p116389 lab=_42970_/X }
C {devices/lab_pin.sym} 117540 -38270 0 0 {name=p116390 lab=_42971_/X }
C {devices/lab_pin.sym} 117540 -38230 0 0 {name=p116391 lab=_40452_/X }
C {devices/lab_pin.sym} 117540 -38190 0 0 {name=p116392 lab=_87621_/Q }
C {devices/lab_pin.sym} 117540 -38150 0 0 {name=p116393 lab=_42976_/X }
C {devices/lab_pin.sym} 117700 -38230 0 1 {name=p116394 lab=_42979_/Y }
C {sky130_stdcells/o32ai_4.sym} 117620 -38230 0 0 {name=X_42979_ }
C {devices/lab_pin.sym} 117580 -38070 0 0 {name=p116395 lab=_72951_/A }
C {devices/lab_pin.sym} 117660 -38070 0 1 {name=p116396 lab=_73799_/X }
C {sky130_stdcells/buf_2.sym} 117620 -38070 0 0 {name=X_73799_ }
C {devices/lab_pin.sym} 117580 -37950 0 0 {name=p116397 lab=_47506_/A }
C {devices/lab_pin.sym} 117660 -37950 0 1 {name=p116398 lab=_53086_/B }
C {sky130_stdcells/buf_2.sym} 117620 -37950 0 0 {name=X_47506_ }
C {devices/lab_pin.sym} 117540 -37860 0 0 {name=p116399 lab=_64704_/X }
C {devices/lab_pin.sym} 117540 -37820 0 0 {name=p116400 lab=_84963_/Q }
C {devices/lab_pin.sym} 117540 -37780 0 0 {name=p116401 lab=_64707_/X }
C {devices/lab_pin.sym} 117540 -37740 0 0 {name=p116402 lab=_66339_/X }
C {devices/lab_pin.sym} 117700 -37800 0 1 {name=p116403 lab=_66340_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -37800 0 0 {name=X_66340_ }
C {devices/lab_pin.sym} 117580 -37650 0 0 {name=p116404 lab=_78325_/X }
C {devices/lab_pin.sym} 117660 -37650 0 1 {name=p116405 lab=_82755_/D }
C {sky130_stdcells/buf_2.sym} 117620 -37650 0 0 {name=X_78326_ }
C {devices/lab_pin.sym} 117580 -37530 0 0 {name=p116406 lab=_44718_/A }
C {devices/lab_pin.sym} 117660 -37530 0 1 {name=p116407 lab=_86989_/D }
C {sky130_stdcells/inv_2.sym} 117620 -37530 0 0 {name=X_44718_ }
C {devices/lab_pin.sym} 117560 -37440 0 0 {name=p116408 lab=_59421_/A }
C {devices/lab_pin.sym} 117560 -37400 0 0 {name=p116409 lab=_63541_/B }
C {devices/lab_pin.sym} 117560 -37360 0 0 {name=p116410 lab=_63514_/C }
C {devices/lab_pin.sym} 117560 -37320 0 0 {name=p116411 lab=_63541_/D }
C {devices/lab_pin.sym} 117680 -37380 0 1 {name=p116412 lab=_63552_/Y }
C {sky130_stdcells/nand4_4.sym} 117620 -37380 0 0 {name=X_63552_ }
C {devices/lab_pin.sym} 117560 -37240 0 0 {name=p116413 lab=_75537_/Y }
C {devices/lab_pin.sym} 117560 -37200 0 0 {name=p116414 lab=_75538_/B }
C {devices/lab_pin.sym} 117680 -37220 0 1 {name=p116415 lab=_75546_/A }
C {sky130_stdcells/or2_4.sym} 117620 -37220 0 0 {name=X_75538_ }
C {devices/lab_pin.sym} 117540 -37110 0 0 {name=p116416 lab=_48471_/X }
C {devices/lab_pin.sym} 117540 -37070 0 0 {name=p116417 lab=_47955_/A }
C {devices/lab_pin.sym} 117540 -37030 0 0 {name=p116418 lab=_48485_/Y }
C {devices/lab_pin.sym} 117700 -37070 0 1 {name=p116419 lab=_48487_/A }
C {sky130_stdcells/o21ai_4.sym} 117620 -37070 0 0 {name=X_48486_ }
C {devices/lab_pin.sym} 117540 -36970 0 0 {name=p116420 lab=_60707_/X }
C {devices/lab_pin.sym} 117540 -36930 0 0 {name=p116421 lab=_60692_/X }
C {devices/lab_pin.sym} 117540 -36890 0 0 {name=p116422 lab=_60820_/B }
C {devices/lab_pin.sym} 117540 -36850 0 0 {name=p116423 lab=_60714_/Y }
C {devices/lab_pin.sym} 117540 -36820 0 0 {name=p116424 lab=_60763_/Y }
C {devices/lab_pin.sym} 117700 -36890 0 1 {name=p116425 lab=_60764_/Y }
C {sky130_stdcells/a41oi_4.sym} 117620 -36890 0 0 {name=X_60764_ }
C {devices/lab_pin.sym} 117540 -36750 0 0 {name=p116426 lab=_45695_/X }
C {devices/lab_pin.sym} 117540 -36710 0 0 {name=p116427 lab=_45697_/Y }
C {devices/lab_pin.sym} 117540 -36670 0 0 {name=p116428 lab=_45561_/X }
C {devices/lab_pin.sym} 117700 -36710 0 1 {name=p116429 lab=_45698_/Y }
C {sky130_stdcells/a21oi_4.sym} 117620 -36710 0 0 {name=X_45698_ }
C {devices/lab_pin.sym} 117560 -36590 0 0 {name=p116430 lab=_62533_/A }
C {devices/lab_pin.sym} 117560 -36550 0 0 {name=p116431 lab=_58487_/A }
C {devices/lab_pin.sym} 117560 -36510 0 0 {name=p116432 lab=_62491_/C }
C {devices/lab_pin.sym} 117680 -36550 0 1 {name=p116433 lab=_62506_/C }
C {sky130_stdcells/nand3_4.sym} 117620 -36550 0 0 {name=X_62503_ }
C {devices/lab_pin.sym} 117580 -36410 0 0 {name=p116434 lab=_47530_/A }
C {devices/lab_pin.sym} 117660 -36410 0 1 {name=p116435 lab=_47437_/X }
C {sky130_stdcells/buf_2.sym} 117620 -36410 0 0 {name=X_47437_ }
C {devices/lab_pin.sym} 117540 -36320 0 0 {name=p116436 lab=_66236_/X }
C {devices/lab_pin.sym} 117540 -36280 0 0 {name=p116437 lab=_85608_/Q }
C {devices/lab_pin.sym} 117540 -36240 0 0 {name=p116438 lab=_66251_/X }
C {devices/lab_pin.sym} 117540 -36200 0 0 {name=p116439 lab=_66270_/X }
C {devices/lab_pin.sym} 117700 -36260 0 1 {name=p116440 lab=_66271_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -36260 0 0 {name=X_66271_ }
C {devices/lab_pin.sym} 117560 -36120 0 0 {name=p116441 lab=_82682_/Q }
C {devices/lab_pin.sym} 117560 -36080 0 0 {name=p116442 lab=_78257_/B }
C {devices/lab_pin.sym} 117680 -36100 0 1 {name=p116443 lab=_78257_/X }
C {sky130_stdcells/xor2_4.sym} 117620 -36100 0 0 {name=X_78257_ }
C {devices/lab_pin.sym} 117580 -35970 0 0 {name=p116444 lab=_40353_/Y }
C {devices/lab_pin.sym} 117660 -35970 0 1 {name=p116445 lab=_44650_/A }
C {sky130_stdcells/buf_2.sym} 117620 -35970 0 0 {name=X_44649_ }
C {devices/lab_pin.sym} 117540 -35870 0 0 {name=p116446 lab=_63481_/Y }
C {devices/lab_pin.sym} 117540 -35830 0 0 {name=p116447 lab=_63455_/X }
C {devices/lab_pin.sym} 117540 -35790 0 0 {name=p116448 lab=_63482_/Y }
C {devices/lab_pin.sym} 117700 -35830 0 1 {name=p116449 lab=_63483_/Y }
C {sky130_stdcells/a21oi_4.sym} 117620 -35830 0 0 {name=X_63483_ }
C {devices/lab_pin.sym} 117540 -35710 0 0 {name=p116450 lab=_75441_/X }
C {devices/lab_pin.sym} 117540 -35670 0 0 {name=p116451 lab=_75467_/Y }
C {devices/lab_pin.sym} 117540 -35630 0 0 {name=p116452 lab=_75468_/Y }
C {devices/lab_pin.sym} 117700 -35670 0 1 {name=p116453 lab=_75508_/B }
C {sky130_stdcells/a21bo_4.sym} 117620 -35670 0 0 {name=X_75469_ }
C {devices/lab_pin.sym} 117580 -35530 0 0 {name=p116454 lab=_60652_/X }
C {devices/lab_pin.sym} 117660 -35530 0 1 {name=p116455 lab=_60724_/A }
C {sky130_stdcells/buf_2.sym} 117620 -35530 0 0 {name=X_60695_ }
C {devices/lab_pin.sym} 117540 -35440 0 0 {name=p116456 lab=_87383_/Q }
C {devices/lab_pin.sym} 117540 -35400 0 0 {name=p116457 lab=_67987_/X }
C {devices/lab_pin.sym} 117540 -35360 0 0 {name=p116458 lab=_67938_/X }
C {devices/lab_pin.sym} 117540 -35320 0 0 {name=p116459 lab=_68009_/X }
C {devices/lab_pin.sym} 117700 -35380 0 1 {name=p116460 lab=_68010_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -35380 0 0 {name=X_68010_ }
C {devices/lab_pin.sym} 117540 -35250 0 0 {name=p116461 lab=_65219_/Y }
C {devices/lab_pin.sym} 117540 -35210 0 0 {name=p116462 lab=_65195_/X }
C {devices/lab_pin.sym} 117540 -35170 0 0 {name=p116463 lab=_65221_/Y }
C {devices/lab_pin.sym} 117700 -35210 0 1 {name=p116464 lab=_84210_/D }
C {sky130_stdcells/a21o_4.sym} 117620 -35210 0 0 {name=X_65222_ }
C {devices/lab_pin.sym} 117560 -35080 0 0 {name=p116465 lab=_77208_/A }
C {devices/lab_pin.sym} 117560 -35040 0 0 {name=p116466 lab=_77208_/B }
C {devices/lab_pin.sym} 117680 -35060 0 1 {name=p116467 lab=_77208_/X }
C {sky130_stdcells/xor2_4.sym} 117620 -35060 0 0 {name=X_77208_ }
C {devices/lab_pin.sym} 117560 -34960 0 0 {name=p116468 lab=_61510_/X }
C {devices/lab_pin.sym} 117560 -34920 0 0 {name=p116469 lab=_62492_/B }
C {devices/lab_pin.sym} 117560 -34880 0 0 {name=p116470 lab=_62420_/C }
C {devices/lab_pin.sym} 117560 -34840 0 0 {name=p116471 lab=_62404_/X }
C {devices/lab_pin.sym} 117680 -34900 0 1 {name=p116472 lab=_62435_/D }
C {sky130_stdcells/nand4_4.sym} 117620 -34900 0 0 {name=X_62434_ }
C {devices/lab_pin.sym} 117580 -34750 0 0 {name=p116473 lab=_81810_/Q }
C {devices/lab_pin.sym} 117660 -34750 0 1 {name=p116474 lab=_47369_/A }
C {sky130_stdcells/inv_2.sym} 117620 -34750 0 0 {name=X_47368_ }
C {devices/lab_pin.sym} 117580 -34630 0 0 {name=p116475 lab=clkbuf_9_316_0_CLK/X }
C {devices/lab_pin.sym} 117660 -34630 0 1 {name=p116476 lab=_81197_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 117620 -34630 0 0 {name=Xclkbuf_10_632_0_CLK }
C {devices/lab_pin.sym} 117560 -34520 0 0 {name=p116477 lab=_78188_/A }
C {devices/lab_pin.sym} 117560 -34480 0 0 {name=p116478 lab=_78188_/B }
C {devices/lab_pin.sym} 117680 -34500 0 1 {name=p116479 lab=_78189_/B }
C {sky130_stdcells/xor2_4.sym} 117620 -34500 0 0 {name=X_78188_ }
C {devices/lab_pin.sym} 117580 -34370 0 0 {name=p116480 lab=_49106_/Y }
C {devices/lab_pin.sym} 117660 -34370 0 1 {name=p116481 lab=_50674_/B }
C {sky130_stdcells/buf_2.sym} 117620 -34370 0 0 {name=X_49107_ }
C {devices/lab_pin.sym} 117560 -34260 0 0 {name=p116482 lab=_46505_/A }
C {devices/lab_pin.sym} 117560 -34220 0 0 {name=p116483 lab=_48936_/A }
C {devices/lab_pin.sym} 117680 -34240 0 1 {name=p116484 lab=_46319_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -34240 0 0 {name=X_46319_ }
C {devices/lab_pin.sym} 117540 -34140 0 0 {name=p116485 lab=_65099_/X }
C {devices/lab_pin.sym} 117540 -34100 0 0 {name=p116486 lab=_86732_/Q }
C {devices/lab_pin.sym} 117540 -34060 0 0 {name=p116487 lab=_65028_/X }
C {devices/lab_pin.sym} 117540 -34020 0 0 {name=p116488 lab=_65152_/X }
C {devices/lab_pin.sym} 117700 -34080 0 1 {name=p116489 lab=_65153_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -34080 0 0 {name=X_65153_ }
C {devices/lab_pin.sym} 117560 -33940 0 0 {name=p116490 lab=_82101_/Q }
C {devices/lab_pin.sym} 117560 -33900 0 0 {name=p116491 lab=_77139_/B }
C {devices/lab_pin.sym} 117680 -33920 0 1 {name=p116492 lab=_82350_/D }
C {sky130_stdcells/xor2_4.sym} 117620 -33920 0 0 {name=X_77139_ }
C {devices/lab_pin.sym} 117560 -33820 0 0 {name=p116493 lab=_62337_/A }
C {devices/lab_pin.sym} 117560 -33780 0 0 {name=p116494 lab=_61891_/X }
C {devices/lab_pin.sym} 117560 -33740 0 0 {name=p116495 lab=_62364_/X }
C {devices/lab_pin.sym} 117560 -33700 0 0 {name=p116496 lab=_62280_/D }
C {devices/lab_pin.sym} 117680 -33760 0 1 {name=p116497 lab=_62365_/X }
C {sky130_stdcells/and4_4.sym} 117620 -33760 0 0 {name=X_62365_ }
C {devices/lab_pin.sym} 117560 -33620 0 0 {name=p116498 lab=_47287_/X }
C {devices/lab_pin.sym} 117560 -33580 0 0 {name=p116499 lab=_52969_/B }
C {devices/lab_pin.sym} 117680 -33600 0 1 {name=p116500 lab=_47299_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -33600 0 0 {name=X_47299_ }
C {devices/lab_pin.sym} 117580 -33470 0 0 {name=p116501 lab=clkbuf_8_61_0_CLK/X }
C {devices/lab_pin.sym} 117660 -33470 0 1 {name=p116502 lab=clkbuf_9_123_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 117620 -33470 0 0 {name=Xclkbuf_9_123_0_CLK }
C {devices/lab_pin.sym} 117580 -33350 0 0 {name=p116503 lab=clkbuf_9_51_0_CLK/A }
C {devices/lab_pin.sym} 117660 -33350 0 1 {name=p116504 lab=clkbuf_9_50_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 117620 -33350 0 0 {name=Xclkbuf_9_50_0_CLK }
C {devices/lab_pin.sym} 117540 -33260 0 0 {name=p116505 lab=_62544_/Y }
C {devices/lab_pin.sym} 117540 -33220 0 0 {name=p116506 lab=_60880_/X }
C {devices/lab_pin.sym} 117540 -33180 0 0 {name=p116507 lab=_62081_/B }
C {devices/lab_pin.sym} 117540 -33140 0 0 {name=p116508 lab=_61028_/X }
C {devices/lab_pin.sym} 117700 -33200 0 1 {name=p116509 lab=_64104_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 117620 -33200 0 0 {name=X_64104_ }
C {devices/lab_pin.sym} 117580 -33050 0 0 {name=p116510 lab=_48985_/A }
C {devices/lab_pin.sym} 117660 -33050 0 1 {name=p116511 lab=_49038_/X }
C {sky130_stdcells/buf_2.sym} 117620 -33050 0 0 {name=X_49038_ }
C {devices/lab_pin.sym} 117580 -32930 0 0 {name=p116512 lab=_61316_/A }
C {devices/lab_pin.sym} 117660 -32930 0 1 {name=p116513 lab=_61317_/A }
C {sky130_stdcells/buf_2.sym} 117620 -32930 0 0 {name=X_61316_ }
C {devices/lab_pin.sym} 117560 -32820 0 0 {name=p116514 lab=_84943_/Q }
C {devices/lab_pin.sym} 117560 -32780 0 0 {name=p116515 lab=_84191_/Q }
C {devices/lab_pin.sym} 117680 -32800 0 1 {name=p116516 lab=_80150_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -32800 0 0 {name=X_80150_ }
C {devices/lab_pin.sym} 117560 -32680 0 0 {name=p116517 lab=_65012_/A }
C {devices/lab_pin.sym} 117560 -32640 0 0 {name=p116518 lab=_65084_/B }
C {devices/lab_pin.sym} 117680 -32660 0 1 {name=p116519 lab=_65084_/X }
C {sky130_stdcells/and2_4.sym} 117620 -32660 0 0 {name=X_65084_ }
C {devices/lab_pin.sym} 117560 -32540 0 0 {name=p116520 lab=_44022_/X }
C {devices/lab_pin.sym} 117560 -32500 0 0 {name=p116521 lab=_69961_/B }
C {devices/lab_pin.sym} 117680 -32520 0 1 {name=p116522 lab=_69961_/X }
C {sky130_stdcells/and2_4.sym} 117620 -32520 0 0 {name=X_69961_ }
C {devices/lab_pin.sym} 117580 -32390 0 0 {name=p116523 lab=_59896_/X }
C {devices/lab_pin.sym} 117660 -32390 0 1 {name=p116524 lab=_62309_/B }
C {sky130_stdcells/buf_2.sym} 117620 -32390 0 0 {name=X_62296_ }
C {devices/lab_pin.sym} 117540 -32290 0 0 {name=p116525 lab=_68909_/X }
C {devices/lab_pin.sym} 117540 -32250 0 0 {name=p116526 lab=_68911_/X }
C {devices/lab_pin.sym} 117540 -32210 0 0 {name=p116527 lab=_68470_/X }
C {devices/lab_pin.sym} 117700 -32250 0 1 {name=p116528 lab=_68912_/X }
C {sky130_stdcells/a21o_4.sym} 117620 -32250 0 0 {name=X_68912_ }
C {devices/lab_pin.sym} 117580 -32110 0 0 {name=p116529 lab=clkbuf_9_323_0_CLK/X }
C {devices/lab_pin.sym} 117660 -32110 0 1 {name=p116530 lab=_88171_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 117620 -32110 0 0 {name=Xclkbuf_10_647_0_CLK }
C {devices/lab_pin.sym} 117560 -32010 0 0 {name=p116531 lab=_64053_/A }
C {devices/lab_pin.sym} 117560 -31970 0 0 {name=p116532 lab=_58442_/A }
C {devices/lab_pin.sym} 117560 -31930 0 0 {name=p116533 lab=_64071_/C }
C {devices/lab_pin.sym} 117680 -31970 0 1 {name=p116534 lab=_64035_/X }
C {sky130_stdcells/and3_4.sym} 117620 -31970 0 0 {name=X_64035_ }
C {devices/lab_pin.sym} 117580 -31830 0 0 {name=p116535 lab=_63001_/A }
C {devices/lab_pin.sym} 117660 -31830 0 1 {name=p116536 lab=_63053_/A }
C {sky130_stdcells/buf_2.sym} 117620 -31830 0 0 {name=X_61247_ }
C {devices/lab_pin.sym} 117560 -31720 0 0 {name=p116537 lab=_84937_/Q }
C {devices/lab_pin.sym} 117560 -31680 0 0 {name=p116538 lab=_65682_/A }
C {devices/lab_pin.sym} 117680 -31700 0 1 {name=p116539 lab=_80081_/X }
C {sky130_stdcells/xor2_4.sym} 117620 -31700 0 0 {name=X_80081_ }
C {devices/lab_pin.sym} 117540 -31600 0 0 {name=p116540 lab=_69832_/X }
C {devices/lab_pin.sym} 117540 -31560 0 0 {name=p116541 lab=_69890_/Y }
C {devices/lab_pin.sym} 117540 -31520 0 0 {name=p116542 lab=_69870_/X }
C {devices/lab_pin.sym} 117540 -31480 0 0 {name=p116543 lab=_69891_/Y }
C {devices/lab_pin.sym} 117700 -31540 0 1 {name=p116544 lab=_69892_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -31540 0 0 {name=X_69892_ }
C {devices/lab_pin.sym} 117580 -31390 0 0 {name=p116545 lab=_50973_/A }
C {devices/lab_pin.sym} 117660 -31390 0 1 {name=p116546 lab=_51018_/A }
C {sky130_stdcells/buf_2.sym} 117620 -31390 0 0 {name=X_51000_ }
C {devices/lab_pin.sym} 117580 -31270 0 0 {name=p116547 lab=clkbuf_8_69_0_CLK/X }
C {devices/lab_pin.sym} 117660 -31270 0 1 {name=p116548 lab=clkbuf_9_138_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 117620 -31270 0 0 {name=Xclkbuf_9_138_0_CLK }
C {devices/lab_pin.sym} 117540 -31170 0 0 {name=p116549 lab=_68840_/X }
C {devices/lab_pin.sym} 117540 -31130 0 0 {name=p116550 lab=_68842_/X }
C {devices/lab_pin.sym} 117540 -31090 0 0 {name=p116551 lab=_68470_/X }
C {devices/lab_pin.sym} 117700 -31130 0 1 {name=p116552 lab=_68843_/X }
C {sky130_stdcells/a21o_4.sym} 117620 -31130 0 0 {name=X_68843_ }
C {devices/lab_pin.sym} 117560 -31010 0 0 {name=p116553 lab=_59536_/A }
C {devices/lab_pin.sym} 117560 -30970 0 0 {name=p116554 lab=_59508_/X }
C {devices/lab_pin.sym} 117560 -30930 0 0 {name=p116555 lab=_61285_/C }
C {devices/lab_pin.sym} 117680 -30970 0 1 {name=p116556 lab=_61178_/Y }
C {sky130_stdcells/nand3_4.sym} 117620 -30970 0 0 {name=X_61178_ }
C {devices/lab_pin.sym} 117580 -30830 0 0 {name=p116557 lab=clkbuf_9_65_0_CLK/A }
C {devices/lab_pin.sym} 117660 -30830 0 1 {name=p116558 lab=clkbuf_9_65_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 117620 -30830 0 0 {name=Xclkbuf_9_65_0_CLK }
C {devices/lab_pin.sym} 117560 -30720 0 0 {name=p116559 lab=_60000_/A }
C {devices/lab_pin.sym} 117560 -30680 0 0 {name=p116560 lab=_60129_/B }
C {devices/lab_pin.sym} 117680 -30700 0 1 {name=p116561 lab=_60129_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -30700 0 0 {name=X_60129_ }
C {devices/lab_pin.sym} 117530 -30570 0 0 {name=p116562 lab=_83835_/CLK }
C {devices/lab_pin.sym} 117530 -30550 0 0 {name=p116563 lab=_70199_/X }
C {devices/lab_pin.sym} 117710 -30570 0 1 {name=p116564 lab=_74799_/C }
C {sky130_stdcells/dfxtp_4.sym} 117620 -30560 0 0 {name=X_83840_ }
C {devices/lab_pin.sym} 117540 -30450 0 0 {name=p116565 lab=_68769_/X }
C {devices/lab_pin.sym} 117540 -30410 0 0 {name=p116566 lab=_68772_/X }
C {devices/lab_pin.sym} 117540 -30370 0 0 {name=p116567 lab=_68773_/X }
C {devices/lab_pin.sym} 117700 -30410 0 1 {name=p116568 lab=_68774_/X }
C {sky130_stdcells/a21o_4.sym} 117620 -30410 0 0 {name=X_68774_ }
C {devices/lab_pin.sym} 117540 -30290 0 0 {name=p116569 lab=_65700_/X }
C {devices/lab_pin.sym} 117540 -30250 0 0 {name=p116570 lab=_65983_/Y }
C {devices/lab_pin.sym} 117540 -30210 0 0 {name=p116571 lab=_65985_/Y }
C {devices/lab_pin.sym} 117700 -30250 0 1 {name=p116572 lab=_65986_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -30250 0 0 {name=X_65986_ }
C {devices/lab_pin.sym} 117540 -30140 0 0 {name=p116573 lab=_87151_/Q }
C {devices/lab_pin.sym} 117540 -30100 0 0 {name=p116574 lab=_67670_/X }
C {devices/lab_pin.sym} 117540 -30060 0 0 {name=p116575 lab=_67671_/X }
C {devices/lab_pin.sym} 117540 -30020 0 0 {name=p116576 lab=_67724_/X }
C {devices/lab_pin.sym} 117700 -30080 0 1 {name=p116577 lab=_67725_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -30080 0 0 {name=X_67725_ }
C {devices/lab_pin.sym} 117540 -29950 0 0 {name=p116578 lab=_85724_/Q }
C {devices/lab_pin.sym} 117540 -29910 0 0 {name=p116579 lab=_52929_/X }
C {devices/lab_pin.sym} 117540 -29870 0 0 {name=p116580 lab=_52950_/Y }
C {devices/lab_pin.sym} 117700 -29910 0 1 {name=p116581 lab=_52951_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -29910 0 0 {name=X_52951_ }
C {devices/lab_pin.sym} 117560 -29790 0 0 {name=p116582 lab=_64933_/X }
C {devices/lab_pin.sym} 117560 -29750 0 0 {name=p116583 lab=_64937_/B }
C {devices/lab_pin.sym} 117560 -29710 0 0 {name=p116584 lab=_64936_/X }
C {devices/lab_pin.sym} 117680 -29750 0 1 {name=p116585 lab=_64937_/Y }
C {sky130_stdcells/nand3_4.sym} 117620 -29750 0 0 {name=X_64937_ }
C {devices/lab_pin.sym} 117530 -29610 0 0 {name=p116586 lab=_86578_/CLK }
C {devices/lab_pin.sym} 117530 -29590 0 0 {name=p116587 lab=_83771_/D }
C {devices/lab_pin.sym} 117710 -29610 0 1 {name=p116588 lab=_83771_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -29600 0 0 {name=X_83771_ }
C {devices/lab_pin.sym} 117530 -29470 0 0 {name=p116589 lab=_83944_/CLK }
C {devices/lab_pin.sym} 117530 -29450 0 0 {name=p116590 lab=_75767_/X }
C {devices/lab_pin.sym} 117710 -29470 0 1 {name=p116591 lab=_80983_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -29460 0 0 {name=X_80983_ }
C {devices/lab_pin.sym} 117530 -29330 0 0 {name=p116592 lab=_86118_/CLK }
C {devices/lab_pin.sym} 117530 -29310 0 0 {name=p116593 lab=_85510_/D }
C {devices/lab_pin.sym} 117710 -29330 0 1 {name=p116594 lab=_85510_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -29320 0 0 {name=X_85510_ }
C {devices/lab_pin.sym} 117560 -29200 0 0 {name=p116595 lab=_51902_/A }
C {devices/lab_pin.sym} 117560 -29160 0 0 {name=p116596 lab=_51037_/B }
C {devices/lab_pin.sym} 117680 -29180 0 1 {name=p116597 lab=_51902_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -29180 0 0 {name=X_51902_ }
C {devices/lab_pin.sym} 117530 -29050 0 0 {name=p116598 lab=_82715_/CLK }
C {devices/lab_pin.sym} 117530 -29030 0 0 {name=p116599 lab=_66524_/C }
C {devices/lab_pin.sym} 117710 -29050 0 1 {name=p116600 lab=_82722_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -29040 0 0 {name=X_82722_ }
C {devices/lab_pin.sym} 117560 -28920 0 0 {name=p116601 lab=_83320_/Q }
C {devices/lab_pin.sym} 117560 -28880 0 0 {name=p116602 lab=_55670_/B }
C {devices/lab_pin.sym} 117680 -28900 0 1 {name=p116603 lab=_55676_/C }
C {sky130_stdcells/xor2_4.sym} 117620 -28900 0 0 {name=X_55670_ }
C {devices/lab_pin.sym} 117540 -28790 0 0 {name=p116604 lab=_67653_/X }
C {devices/lab_pin.sym} 117540 -28750 0 0 {name=p116605 lab=_67655_/X }
C {devices/lab_pin.sym} 117540 -28710 0 0 {name=p116606 lab=_67561_/X }
C {devices/lab_pin.sym} 117700 -28750 0 1 {name=p116607 lab=_67656_/X }
C {sky130_stdcells/a21o_4.sym} 117620 -28750 0 0 {name=X_67656_ }
C {devices/lab_pin.sym} 117530 -28610 0 0 {name=p116608 lab=_86490_/CLK }
C {devices/lab_pin.sym} 117530 -28590 0 0 {name=p116609 lab=_48749_/Y }
C {devices/lab_pin.sym} 117710 -28610 0 1 {name=p116610 lab=_72960_/B }
C {sky130_stdcells/dfxtp_4.sym} 117620 -28600 0 0 {name=X_86490_ }
C {devices/lab_pin.sym} 117540 -28490 0 0 {name=p116611 lab=_85737_/Q }
C {devices/lab_pin.sym} 117540 -28450 0 0 {name=p116612 lab=_52874_/X }
C {devices/lab_pin.sym} 117540 -28410 0 0 {name=p116613 lab=_52881_/Y }
C {devices/lab_pin.sym} 117700 -28450 0 1 {name=p116614 lab=_52882_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -28450 0 0 {name=X_52882_ }
C {devices/lab_pin.sym} 117540 -28330 0 0 {name=p116615 lab=_60151_/X }
C {devices/lab_pin.sym} 117540 -28290 0 0 {name=p116616 lab=_64855_/Y }
C {devices/lab_pin.sym} 117540 -28250 0 0 {name=p116617 lab=_64867_/Y }
C {devices/lab_pin.sym} 117700 -28290 0 1 {name=p116618 lab=_64868_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -28290 0 0 {name=X_64868_ }
C {devices/lab_pin.sym} 117580 -28150 0 0 {name=p116619 lab=_54540_/A }
C {devices/lab_pin.sym} 117660 -28150 0 1 {name=p116620 lab=_54621_/X }
C {sky130_stdcells/buf_2.sym} 117620 -28150 0 0 {name=X_54621_ }
C {devices/lab_pin.sym} 117540 -28050 0 0 {name=p116621 lab=_66599_/X }
C {devices/lab_pin.sym} 117540 -28010 0 0 {name=p116622 lab=_66603_/X }
C {devices/lab_pin.sym} 117540 -27970 0 0 {name=p116623 lab=_66606_/X }
C {devices/lab_pin.sym} 117700 -28010 0 1 {name=p116624 lab=_66607_/X }
C {sky130_stdcells/a21o_4.sym} 117620 -28010 0 0 {name=X_66607_ }
C {devices/lab_pin.sym} 117530 -27870 0 0 {name=p116625 lab=_85761_/CLK }
C {devices/lab_pin.sym} 117530 -27850 0 0 {name=p116626 lab=_85441_/D }
C {devices/lab_pin.sym} 117710 -27870 0 1 {name=p116627 lab=_85441_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -27860 0 0 {name=X_85441_ }
C {devices/lab_pin.sym} 117560 -27760 0 0 {name=p116628 lab=_51851_/A }
C {devices/lab_pin.sym} 117560 -27720 0 0 {name=p116629 lab=_51815_/B }
C {devices/lab_pin.sym} 117560 -27680 0 0 {name=p116630 lab=_51810_/C }
C {devices/lab_pin.sym} 117560 -27640 0 0 {name=p116631 lab=_52661_/D }
C {devices/lab_pin.sym} 117680 -27700 0 1 {name=p116632 lab=_51833_/X }
C {sky130_stdcells/and4_4.sym} 117620 -27700 0 0 {name=X_51833_ }
C {devices/lab_pin.sym} 117560 -27580 0 0 {name=p116633 lab=_61390_/A }
C {devices/lab_pin.sym} 117560 -27540 0 0 {name=p116634 lab=_63772_/B }
C {devices/lab_pin.sym} 117560 -27500 0 0 {name=p116635 lab=_63803_/C }
C {devices/lab_pin.sym} 117560 -27460 0 0 {name=p116636 lab=_63787_/D }
C {devices/lab_pin.sym} 117680 -27520 0 1 {name=p116637 lab=_63819_/Y }
C {sky130_stdcells/nand4_4.sym} 117620 -27520 0 0 {name=X_63819_ }
C {devices/lab_pin.sym} 117530 -27370 0 0 {name=p116638 lab=_81746_/CLK }
C {devices/lab_pin.sym} 117530 -27350 0 0 {name=p116639 lab=_82653_/D }
C {devices/lab_pin.sym} 117710 -27370 0 1 {name=p116640 lab=_82653_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -27360 0 0 {name=X_82653_ }
C {devices/lab_pin.sym} 117540 -27260 0 0 {name=p116641 lab=_86965_/Q }
C {devices/lab_pin.sym} 117540 -27220 0 0 {name=p116642 lab=_67585_/X }
C {devices/lab_pin.sym} 117540 -27180 0 0 {name=p116643 lab=_67516_/X }
C {devices/lab_pin.sym} 117540 -27140 0 0 {name=p116644 lab=_67586_/X }
C {devices/lab_pin.sym} 117700 -27200 0 1 {name=p116645 lab=_67587_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -27200 0 0 {name=X_67587_ }
C {devices/lab_pin.sym} 117540 -27080 0 0 {name=p116646 lab=_64797_/X }
C {devices/lab_pin.sym} 117540 -27040 0 0 {name=p116647 lab=_86746_/Q }
C {devices/lab_pin.sym} 117540 -27000 0 0 {name=p116648 lab=_64772_/X }
C {devices/lab_pin.sym} 117540 -26960 0 0 {name=p116649 lab=_64798_/X }
C {devices/lab_pin.sym} 117700 -27020 0 1 {name=p116650 lab=_64800_/B }
C {sky130_stdcells/a211o_4.sym} 117620 -27020 0 0 {name=X_64799_ }
C {devices/lab_pin.sym} 117560 -26890 0 0 {name=p116651 lab=_57026_/X }
C {devices/lab_pin.sym} 117560 -26850 0 0 {name=p116652 lab=_57340_/B }
C {devices/lab_pin.sym} 117560 -26810 0 0 {name=p116653 lab=_57340_/C }
C {devices/lab_pin.sym} 117680 -26850 0 1 {name=p116654 lab=_57340_/Y }
C {sky130_stdcells/nor3_4.sym} 117620 -26850 0 0 {name=X_57340_ }
C {devices/lab_pin.sym} 117530 -26710 0 0 {name=p116655 lab=_81668_/CLK }
C {devices/lab_pin.sym} 117530 -26690 0 0 {name=p116656 lab=_76183_/Y }
C {devices/lab_pin.sym} 117710 -26710 0 1 {name=p116657 lab=_81796_/D }
C {sky130_stdcells/dfxtp_4.sym} 117620 -26700 0 0 {name=X_81604_ }
C {devices/lab_pin.sym} 117540 -26590 0 0 {name=p116658 lab=_68706_/X }
C {devices/lab_pin.sym} 117540 -26550 0 0 {name=p116659 lab=_68709_/X }
C {devices/lab_pin.sym} 117540 -26510 0 0 {name=p116660 lab=_69295_/X }
C {devices/lab_pin.sym} 117700 -26550 0 1 {name=p116661 lab=_69326_/Y }
C {sky130_stdcells/a21oi_4.sym} 117620 -26550 0 0 {name=X_69326_ }
C {devices/lab_pin.sym} 117530 -26410 0 0 {name=p116662 lab=_88158_/CLK }
C {devices/lab_pin.sym} 117530 -26390 0 0 {name=p116663 lab=_88160_/D }
C {devices/lab_pin.sym} 117710 -26410 0 1 {name=p116664 lab=_88160_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -26400 0 0 {name=X_88160_ }
C {devices/lab_pin.sym} 117540 -26290 0 0 {name=p116665 lab=_85421_/Q }
C {devices/lab_pin.sym} 117540 -26250 0 0 {name=p116666 lab=_54540_/X }
C {devices/lab_pin.sym} 117540 -26210 0 0 {name=p116667 lab=_54551_/Y }
C {devices/lab_pin.sym} 117700 -26250 0 1 {name=p116668 lab=_54552_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -26250 0 0 {name=X_54552_ }
C {devices/lab_pin.sym} 117580 -26110 0 0 {name=p116669 lab=_66642_/A }
C {devices/lab_pin.sym} 117660 -26110 0 1 {name=p116670 lab=_66538_/X }
C {sky130_stdcells/buf_2.sym} 117620 -26110 0 0 {name=X_66538_ }
C {devices/lab_pin.sym} 117530 -25990 0 0 {name=p116671 lab=_85372_/CLK }
C {devices/lab_pin.sym} 117530 -25970 0 0 {name=p116672 lab=_85372_/D }
C {devices/lab_pin.sym} 117710 -25990 0 1 {name=p116673 lab=_85372_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -25980 0 0 {name=X_85372_ }
C {devices/lab_pin.sym} 117580 -25850 0 0 {name=p116674 lab=_51790_/A }
C {devices/lab_pin.sym} 117660 -25850 0 1 {name=p116675 lab=_51779_/A }
C {sky130_stdcells/buf_2.sym} 117620 -25850 0 0 {name=X_51764_ }
C {devices/lab_pin.sym} 117530 -25730 0 0 {name=p116676 lab=_82589_/CLK }
C {devices/lab_pin.sym} 117530 -25710 0 0 {name=p116677 lab=_82616_/Q }
C {devices/lab_pin.sym} 117710 -25730 0 1 {name=p116678 lab=_78253_/B }
C {sky130_stdcells/dfxtp_4.sym} 117620 -25720 0 0 {name=X_82584_ }
C {devices/lab_pin.sym} 117530 -25590 0 0 {name=p116679 lab=_87110_/CLK }
C {devices/lab_pin.sym} 117530 -25570 0 0 {name=p116680 lab=_87111_/D }
C {devices/lab_pin.sym} 117710 -25590 0 1 {name=p116681 lab=_87111_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -25580 0 0 {name=X_87111_ }
C {devices/lab_pin.sym} 117580 -25450 0 0 {name=p116682 lab=_53821_/B }
C {devices/lab_pin.sym} 117660 -25450 0 1 {name=p116683 lab=_53503_/X }
C {sky130_stdcells/buf_2.sym} 117620 -25450 0 0 {name=X_53503_ }
C {devices/lab_pin.sym} 117530 -25330 0 0 {name=p116684 lab=_84321_/CLK }
C {devices/lab_pin.sym} 117530 -25310 0 0 {name=p116685 lab=_84323_/D }
C {devices/lab_pin.sym} 117710 -25330 0 1 {name=p116686 lab=_80559_/B }
C {sky130_stdcells/dfxtp_4.sym} 117620 -25320 0 0 {name=X_84323_ }
C {devices/lab_pin.sym} 117540 -25210 0 0 {name=p116687 lab=_50713_/Y }
C {devices/lab_pin.sym} 117540 -25170 0 0 {name=p116688 lab=_50699_/X }
C {devices/lab_pin.sym} 117540 -25130 0 0 {name=p116689 lab=_50714_/Y }
C {devices/lab_pin.sym} 117700 -25170 0 1 {name=p116690 lab=_86148_/D }
C {sky130_stdcells/a21boi_4.sym} 117620 -25170 0 0 {name=X_50715_ }
C {devices/lab_pin.sym} 117560 -25050 0 0 {name=p116691 lab=_57271_/A }
C {devices/lab_pin.sym} 117560 -25010 0 0 {name=p116692 lab=_83329_/Q }
C {devices/lab_pin.sym} 117560 -24970 0 0 {name=p116693 lab=_57270_/X }
C {devices/lab_pin.sym} 117680 -25010 0 1 {name=p116694 lab=_57271_/Y }
C {sky130_stdcells/nand3_4.sym} 117620 -25010 0 0 {name=X_57271_ }
C {devices/lab_pin.sym} 117530 -24870 0 0 {name=p116695 lab=_81475_/CLK }
C {devices/lab_pin.sym} 117530 -24850 0 0 {name=p116696 lab=_76595_/B }
C {devices/lab_pin.sym} 117710 -24870 0 1 {name=p116697 lab=_76136_/A }
C {sky130_stdcells/dfxtp_4.sym} 117620 -24860 0 0 {name=X_81535_ }
C {devices/lab_pin.sym} 117540 -24760 0 0 {name=p116698 lab=_69216_/X }
C {devices/lab_pin.sym} 117540 -24720 0 0 {name=p116699 lab=_69255_/Y }
C {devices/lab_pin.sym} 117540 -24680 0 0 {name=p116700 lab=_69231_/X }
C {devices/lab_pin.sym} 117540 -24640 0 0 {name=p116701 lab=_69256_/Y }
C {devices/lab_pin.sym} 117700 -24700 0 1 {name=p116702 lab=_69257_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -24700 0 0 {name=X_69257_ }
C {devices/lab_pin.sym} 117530 -24550 0 0 {name=p116703 lab=_88087_/CLK }
C {devices/lab_pin.sym} 117530 -24530 0 0 {name=p116704 lab=_88091_/D }
C {devices/lab_pin.sym} 117710 -24550 0 1 {name=p116705 lab=_74121_/A }
C {sky130_stdcells/dfxtp_4.sym} 117620 -24540 0 0 {name=X_88091_ }
C {devices/lab_pin.sym} 117560 -24440 0 0 {name=p116706 lab=_54483_/A }
C {devices/lab_pin.sym} 117560 -24400 0 0 {name=p116707 lab=_54471_/B }
C {devices/lab_pin.sym} 117560 -24360 0 0 {name=p116708 lab=_54483_/C }
C {devices/lab_pin.sym} 117560 -24320 0 0 {name=p116709 lab=_46990_/A }
C {devices/lab_pin.sym} 117680 -24380 0 1 {name=p116710 lab=_54483_/X }
C {sky130_stdcells/and4_4.sym} 117620 -24380 0 0 {name=X_54483_ }
C {devices/lab_pin.sym} 117560 -24250 0 0 {name=p116711 lab=_66501_/A }
C {devices/lab_pin.sym} 117560 -24210 0 0 {name=p116712 lab=_66419_/X }
C {devices/lab_pin.sym} 117560 -24170 0 0 {name=p116713 lab=_66469_/C }
C {devices/lab_pin.sym} 117680 -24210 0 1 {name=p116714 lab=_66469_/X }
C {sky130_stdcells/and3_4.sym} 117620 -24210 0 0 {name=X_66469_ }
C {devices/lab_pin.sym} 117560 -24100 0 0 {name=p116715 lab=_51695_/A }
C {devices/lab_pin.sym} 117560 -24060 0 0 {name=p116716 lab=_51715_/B }
C {devices/lab_pin.sym} 117560 -24020 0 0 {name=p116717 lab=_51695_/C }
C {devices/lab_pin.sym} 117560 -23980 0 0 {name=p116718 lab=_53217_/D }
C {devices/lab_pin.sym} 117680 -24040 0 1 {name=p116719 lab=_51695_/X }
C {sky130_stdcells/and4_4.sym} 117620 -24040 0 0 {name=X_51695_ }
C {devices/lab_pin.sym} 117580 -23890 0 0 {name=p116720 lab=_58810_/A }
C {devices/lab_pin.sym} 117660 -23890 0 1 {name=p116721 lab=_59010_/X }
C {sky130_stdcells/buf_2.sym} 117620 -23890 0 0 {name=X_59010_ }
C {devices/lab_pin.sym} 117540 -23790 0 0 {name=p116722 lab=_56064_/X }
C {devices/lab_pin.sym} 117540 -23750 0 0 {name=p116723 lab=_56210_/X }
C {devices/lab_pin.sym} 117540 -23710 0 0 {name=p116724 lab=_56221_/Y }
C {devices/lab_pin.sym} 117700 -23750 0 1 {name=p116725 lab=_85270_/D }
C {sky130_stdcells/o21ai_4.sym} 117620 -23750 0 0 {name=X_56222_ }
C {devices/lab_pin.sym} 117580 -23610 0 0 {name=p116726 lab=_69654_/A }
C {devices/lab_pin.sym} 117660 -23610 0 1 {name=p116727 lab=_68208_/X }
C {sky130_stdcells/buf_2.sym} 117620 -23610 0 0 {name=X_68208_ }
C {devices/lab_pin.sym} 117530 -23490 0 0 {name=p116728 lab=_87851_/CLK }
C {devices/lab_pin.sym} 117530 -23470 0 0 {name=p116729 lab=_87042_/D }
C {devices/lab_pin.sym} 117710 -23490 0 1 {name=p116730 lab=_87042_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -23480 0 0 {name=X_87042_ }
C {devices/lab_pin.sym} 117560 -23360 0 0 {name=p116731 lab=_53434_/A }
C {devices/lab_pin.sym} 117560 -23320 0 0 {name=p116732 lab=_47212_/Y }
C {devices/lab_pin.sym} 117680 -23340 0 1 {name=p116733 lab=_53434_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -23340 0 0 {name=X_53434_ }
C {devices/lab_pin.sym} 117530 -23210 0 0 {name=p116734 lab=_83766_/CLK }
C {devices/lab_pin.sym} 117530 -23190 0 0 {name=p116735 lab=_64350_/X }
C {devices/lab_pin.sym} 117710 -23210 0 1 {name=p116736 lab=_79764_/B }
C {sky130_stdcells/dfxtp_4.sym} 117620 -23200 0 0 {name=X_84254_ }
C {devices/lab_pin.sym} 117580 -23070 0 0 {name=p116737 lab=_50645_/X }
C {devices/lab_pin.sym} 117660 -23070 0 1 {name=p116738 lab=_53863_/A }
C {sky130_stdcells/buf_2.sym} 117620 -23070 0 0 {name=X_50646_ }
C {devices/lab_pin.sym} 117530 -22950 0 0 {name=p116739 lab=_82648_/CLK }
C {devices/lab_pin.sym} 117530 -22930 0 0 {name=p116740 lab=_81466_/D }
C {devices/lab_pin.sym} 117710 -22950 0 1 {name=p116741 lab=_81466_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -22940 0 0 {name=X_81466_ }
C {devices/lab_pin.sym} 117540 -22840 0 0 {name=p116742 lab=_69146_/X }
C {devices/lab_pin.sym} 117540 -22800 0 0 {name=p116743 lab=_69186_/Y }
C {devices/lab_pin.sym} 117540 -22760 0 0 {name=p116744 lab=_69095_/X }
C {devices/lab_pin.sym} 117540 -22720 0 0 {name=p116745 lab=_69187_/Y }
C {devices/lab_pin.sym} 117700 -22780 0 1 {name=p116746 lab=_69188_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -22780 0 0 {name=X_69188_ }
C {devices/lab_pin.sym} 117530 -22630 0 0 {name=p116747 lab=_83843_/CLK }
C {devices/lab_pin.sym} 117530 -22610 0 0 {name=p116748 lab=_83205_/D }
C {devices/lab_pin.sym} 117710 -22630 0 1 {name=p116749 lab=_70183_/C }
C {sky130_stdcells/dfxtp_4.sym} 117620 -22620 0 0 {name=X_83205_ }
C {devices/lab_pin.sym} 117580 -22490 0 0 {name=p116750 lab=_56152_/Y }
C {devices/lab_pin.sym} 117660 -22490 0 1 {name=p116751 lab=_56153_/X }
C {sky130_stdcells/buf_2.sym} 117620 -22490 0 0 {name=X_56153_ }
C {devices/lab_pin.sym} 117540 -22390 0 0 {name=p116752 lab=_80409_/A }
C {devices/lab_pin.sym} 117540 -22350 0 0 {name=p116753 lab=_80408_/Y }
C {devices/lab_pin.sym} 117540 -22310 0 0 {name=p116754 lab=_80416_/X }
C {devices/lab_pin.sym} 117700 -22350 0 1 {name=p116755 lab=_80418_/B }
C {sky130_stdcells/o21ai_4.sym} 117620 -22350 0 0 {name=X_80417_ }
C {devices/lab_pin.sym} 117540 -22230 0 0 {name=p116756 lab=_82069_/D }
C {devices/lab_pin.sym} 117540 -22190 0 0 {name=p116757 lab=_68120_/X }
C {devices/lab_pin.sym} 117540 -22150 0 0 {name=p116758 lab=_68138_/X }
C {devices/lab_pin.sym} 117700 -22190 0 1 {name=p116759 lab=_84029_/D }
C {sky130_stdcells/a21bo_4.sym} 117620 -22190 0 0 {name=X_68139_ }
C {devices/lab_pin.sym} 117540 -22070 0 0 {name=p116760 lab=_85647_/Q }
C {devices/lab_pin.sym} 117540 -22030 0 0 {name=p116761 lab=_53351_/X }
C {devices/lab_pin.sym} 117540 -21990 0 0 {name=p116762 lab=_53364_/Y }
C {devices/lab_pin.sym} 117700 -22030 0 1 {name=p116763 lab=_53365_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -22030 0 0 {name=X_53365_ }
C {devices/lab_pin.sym} 117530 -21890 0 0 {name=p116764 lab=_83508_/CLK }
C {devices/lab_pin.sym} 117530 -21870 0 0 {name=p116765 lab=_84185_/D }
C {devices/lab_pin.sym} 117710 -21890 0 1 {name=p116766 lab=_65682_/A }
C {sky130_stdcells/dfxtp_4.sym} 117620 -21880 0 0 {name=X_84185_ }
C {devices/lab_pin.sym} 117580 -21750 0 0 {name=p116767 lab=_50577_/A }
C {devices/lab_pin.sym} 117660 -21750 0 1 {name=p116768 lab=_50577_/X }
C {sky130_stdcells/buf_2.sym} 117620 -21750 0 0 {name=X_50577_ }
C {devices/lab_pin.sym} 117580 -21630 0 0 {name=p116769 lab=clkbuf_8_9_0_CLK/X }
C {devices/lab_pin.sym} 117660 -21630 0 1 {name=p116770 lab=clkbuf_9_18_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 117620 -21630 0 0 {name=Xclkbuf_9_18_0_CLK }
C {devices/lab_pin.sym} 117530 -21510 0 0 {name=p116771 lab=_83933_/CLK }
C {devices/lab_pin.sym} 117530 -21490 0 0 {name=p116772 lab=_83933_/Q }
C {devices/lab_pin.sym} 117710 -21510 0 1 {name=p116773 lab=_81397_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -21500 0 0 {name=X_81397_ }
C {devices/lab_pin.sym} 117560 -21400 0 0 {name=p116774 lab=_55112_/A }
C {devices/lab_pin.sym} 117560 -21360 0 0 {name=p116775 lab=_55104_/B }
C {devices/lab_pin.sym} 117560 -21320 0 0 {name=p116776 lab=_55120_/C }
C {devices/lab_pin.sym} 117560 -21280 0 0 {name=p116777 lab=_47784_/A }
C {devices/lab_pin.sym} 117680 -21340 0 1 {name=p116778 lab=_55104_/X }
C {sky130_stdcells/and4_4.sym} 117620 -21340 0 0 {name=X_55104_ }
C {devices/lab_pin.sym} 117540 -21210 0 0 {name=p116779 lab=_52313_/Y }
C {devices/lab_pin.sym} 117540 -21170 0 0 {name=p116780 lab=_52314_/X }
C {devices/lab_pin.sym} 117540 -21130 0 0 {name=p116781 lab=_52315_/X }
C {devices/lab_pin.sym} 117700 -21170 0 1 {name=p116782 lab=_52316_/Y }
C {sky130_stdcells/a21oi_4.sym} 117620 -21170 0 0 {name=X_52316_ }
C {devices/lab_pin.sym} 117540 -21050 0 0 {name=p116783 lab=_40325_/X }
C {devices/lab_pin.sym} 117540 -21010 0 0 {name=p116784 lab=_82336_/Q }
C {devices/lab_pin.sym} 117540 -20970 0 0 {name=p116785 lab=_40329_/X }
C {devices/lab_pin.sym} 117700 -21010 0 1 {name=p116786 lab=_40330_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -21010 0 0 {name=X_40330_ }
C {devices/lab_pin.sym} 117560 -20900 0 0 {name=p116787 lab=_71175_/A }
C {devices/lab_pin.sym} 117560 -20860 0 0 {name=p116788 lab=_71155_/B }
C {devices/lab_pin.sym} 117560 -20820 0 0 {name=p116789 lab=_71152_/C }
C {devices/lab_pin.sym} 117560 -20780 0 0 {name=p116790 lab=_71160_/D }
C {devices/lab_pin.sym} 117680 -20840 0 1 {name=p116791 lab=_71150_/Y }
C {sky130_stdcells/nand4_4.sym} 117620 -20840 0 0 {name=X_71150_ }
C {devices/lab_pin.sym} 117530 -20690 0 0 {name=p116792 lab=_83139_/CLK }
C {devices/lab_pin.sym} 117530 -20670 0 0 {name=p116793 lab=_73794_/Y }
C {devices/lab_pin.sym} 117710 -20690 0 1 {name=p116794 lab=_83136_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -20680 0 0 {name=X_83136_ }
C {devices/lab_pin.sym} 117560 -20560 0 0 {name=p116795 lab=_80344_/X }
C {devices/lab_pin.sym} 117560 -20520 0 0 {name=p116796 lab=_80360_/B }
C {devices/lab_pin.sym} 117680 -20540 0 1 {name=p116797 lab=_80349_/B }
C {sky130_stdcells/nand2_4.sym} 117620 -20540 0 0 {name=X_80348_ }
C {devices/lab_pin.sym} 117560 -20420 0 0 {name=p116798 lab=_55854_/X }
C {devices/lab_pin.sym} 117560 -20380 0 0 {name=p116799 lab=_56083_/X }
C {devices/lab_pin.sym} 117680 -20400 0 1 {name=p116800 lab=_56084_/Y }
C {sky130_stdcells/xnor2_4.sym} 117620 -20400 0 0 {name=X_56084_ }
C {devices/lab_pin.sym} 117580 -20270 0 0 {name=p116801 lab=_50063_/A }
C {devices/lab_pin.sym} 117660 -20270 0 1 {name=p116802 lab=_53352_/A }
C {sky130_stdcells/buf_2.sym} 117620 -20270 0 0 {name=X_53296_ }
C {devices/lab_pin.sym} 117580 -20150 0 0 {name=p116803 lab=_83132_/Q }
C {devices/lab_pin.sym} 117660 -20150 0 1 {name=p116804 lab=_70101_/Y }
C {sky130_stdcells/inv_2.sym} 117620 -20150 0 0 {name=X_70101_ }
C {devices/lab_pin.sym} 117560 -20060 0 0 {name=p116805 lab=_55017_/X }
C {devices/lab_pin.sym} 117560 -20020 0 0 {name=p116806 lab=_55030_/X }
C {devices/lab_pin.sym} 117560 -19980 0 0 {name=p116807 lab=_55026_/C }
C {devices/lab_pin.sym} 117560 -19940 0 0 {name=p116808 lab=_47663_/A }
C {devices/lab_pin.sym} 117680 -20000 0 1 {name=p116809 lab=_55035_/X }
C {sky130_stdcells/and4_4.sym} 117620 -20000 0 0 {name=X_55035_ }
C {devices/lab_pin.sym} 117580 -19850 0 0 {name=p116810 lab=_62501_/A }
C {devices/lab_pin.sym} 117660 -19850 0 1 {name=p116811 lab=_59913_/A }
C {sky130_stdcells/buf_2.sym} 117620 -19850 0 0 {name=X_59912_ }
C {devices/lab_pin.sym} 117580 -19730 0 0 {name=p116812 lab=_52247_/A }
C {devices/lab_pin.sym} 117660 -19730 0 1 {name=p116813 lab=_52267_/C }
C {sky130_stdcells/buf_2.sym} 117620 -19730 0 0 {name=X_52247_ }
C {devices/lab_pin.sym} 117540 -19630 0 0 {name=p116814 lab=_48992_/X }
C {devices/lab_pin.sym} 117540 -19590 0 0 {name=p116815 lab=_71070_/X }
C {devices/lab_pin.sym} 117540 -19550 0 0 {name=p116816 lab=_71080_/Y }
C {devices/lab_pin.sym} 117700 -19590 0 1 {name=p116817 lab=_71081_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -19590 0 0 {name=X_71081_ }
C {devices/lab_pin.sym} 117530 -19450 0 0 {name=p116818 lab=_86500_/CLK }
C {devices/lab_pin.sym} 117530 -19430 0 0 {name=p116819 lab=_74436_/Y }
C {devices/lab_pin.sym} 117710 -19450 0 1 {name=p116820 lab=_83067_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -19440 0 0 {name=X_83067_ }
C {devices/lab_pin.sym} 117530 -19310 0 0 {name=p116821 lab=_87636_/CLK }
C {devices/lab_pin.sym} 117530 -19290 0 0 {name=p116822 lab=_87944_/D }
C {devices/lab_pin.sym} 117710 -19310 0 1 {name=p116823 lab=_87944_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -19300 0 0 {name=X_87944_ }
C {devices/lab_pin.sym} 117560 -19180 0 0 {name=p116824 lab=_80278_/Y }
C {devices/lab_pin.sym} 117560 -19140 0 0 {name=p116825 lab=_80279_/B }
C {devices/lab_pin.sym} 117680 -19160 0 1 {name=p116826 lab=_80280_/C }
C {sky130_stdcells/nand2_4.sym} 117620 -19160 0 0 {name=X_80279_ }
C {devices/lab_pin.sym} 117580 -19030 0 0 {name=p116827 lab=clkbuf_9_7_0_CLK/A }
C {devices/lab_pin.sym} 117660 -19030 0 1 {name=p116828 lab=clkbuf_9_6_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 117620 -19030 0 0 {name=Xclkbuf_9_6_0_CLK }
C {devices/lab_pin.sym} 117580 -18910 0 0 {name=p116829 lab=_42000_/A }
C {devices/lab_pin.sym} 117660 -18910 0 1 {name=p116830 lab=_42000_/X }
C {sky130_stdcells/buf_2.sym} 117620 -18910 0 0 {name=X_42000_ }
C {devices/lab_pin.sym} 117540 -18810 0 0 {name=p116831 lab=_83868_/Q }
C {devices/lab_pin.sym} 117540 -18770 0 0 {name=p116832 lab=_70029_/X }
C {devices/lab_pin.sym} 117540 -18730 0 0 {name=p116833 lab=_70031_/X }
C {devices/lab_pin.sym} 117700 -18770 0 1 {name=p116834 lab=_70032_/X }
C {sky130_stdcells/a21bo_4.sym} 117620 -18770 0 0 {name=X_70032_ }
C {devices/lab_pin.sym} 117530 -18630 0 0 {name=p116835 lab=_82104_/CLK }
C {devices/lab_pin.sym} 117530 -18610 0 0 {name=p116836 lab=_77728_/B }
C {devices/lab_pin.sym} 117710 -18630 0 1 {name=p116837 lab=_81986_/D }
C {sky130_stdcells/dfxtp_4.sym} 117620 -18620 0 0 {name=X_82018_ }
C {devices/lab_pin.sym} 117560 -18510 0 0 {name=p116838 lab=_59855_/A }
C {devices/lab_pin.sym} 117560 -18470 0 0 {name=p116839 lab=_59848_/B }
C {devices/lab_pin.sym} 117560 -18430 0 0 {name=p116840 lab=_80379_/A }
C {devices/lab_pin.sym} 117680 -18470 0 1 {name=p116841 lab=_59843_/Y }
C {sky130_stdcells/nor3_4.sym} 117620 -18470 0 0 {name=X_59843_ }
C {devices/lab_pin.sym} 117580 -18330 0 0 {name=p116842 lab=_52214_/A }
C {devices/lab_pin.sym} 117660 -18330 0 1 {name=p116843 lab=_52178_/X }
C {sky130_stdcells/buf_2.sym} 117620 -18330 0 0 {name=X_52178_ }
C {devices/lab_pin.sym} 117530 -18210 0 0 {name=p116844 lab=_88387_/CLK }
C {devices/lab_pin.sym} 117530 -18190 0 0 {name=p116845 lab=_42416_/X }
C {devices/lab_pin.sym} 117710 -18210 0 1 {name=p116846 lab=_87875_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -18200 0 0 {name=X_87875_ }
C {devices/lab_pin.sym} 117580 -18070 0 0 {name=p116847 lab=_51129_/A }
C {devices/lab_pin.sym} 117660 -18070 0 1 {name=p116848 lab=_51130_/A }
C {sky130_stdcells/buf_2.sym} 117620 -18070 0 0 {name=X_51129_ }
C {devices/lab_pin.sym} 117580 -17950 0 0 {name=p116849 lab=_74839_/Y }
C {devices/lab_pin.sym} 117660 -17950 0 1 {name=p116850 lab=_80654_/D }
C {sky130_stdcells/inv_2.sym} 117620 -17950 0 0 {name=X_74840_ }
C {devices/lab_pin.sym} 117530 -17830 0 0 {name=p116851 lab=_87073_/CLK }
C {devices/lab_pin.sym} 117530 -17810 0 0 {name=p116852 lab=_45989_/Y }
C {devices/lab_pin.sym} 117710 -17830 0 1 {name=p116853 lab=_86826_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -17820 0 0 {name=X_86826_ }
C {devices/lab_pin.sym} 117580 -17690 0 0 {name=p116854 lab=_59773_/X }
C {devices/lab_pin.sym} 117660 -17690 0 1 {name=p116855 lab=_59774_/Y }
C {sky130_stdcells/inv_2.sym} 117620 -17690 0 0 {name=X_59774_ }
C {devices/lab_pin.sym} 117560 -17580 0 0 {name=p116856 lab=_56985_/X }
C {devices/lab_pin.sym} 117560 -17540 0 0 {name=p116857 lab=_56702_/X }
C {devices/lab_pin.sym} 117680 -17560 0 1 {name=p116858 lab=_56986_/X }
C {sky130_stdcells/xor2_4.sym} 117620 -17560 0 0 {name=X_56986_ }
C {devices/lab_pin.sym} 117580 -17430 0 0 {name=p116859 lab=_58599_/A }
C {devices/lab_pin.sym} 117660 -17430 0 1 {name=p116860 lab=_58725_/X }
C {sky130_stdcells/buf_2.sym} 117620 -17430 0 0 {name=X_58725_ }
C {devices/lab_pin.sym} 117560 -17320 0 0 {name=p116861 lab=_43979_/A }
C {devices/lab_pin.sym} 117560 -17280 0 0 {name=p116862 lab=_43951_/B }
C {devices/lab_pin.sym} 117680 -17300 0 1 {name=p116863 lab=_43951_/Y }
C {sky130_stdcells/nor2_4.sym} 117620 -17300 0 0 {name=X_43951_ }
C {devices/lab_pin.sym} 117580 -17170 0 0 {name=p116864 lab=_55937_/A }
C {devices/lab_pin.sym} 117660 -17170 0 1 {name=p116865 lab=_55956_/B }
C {sky130_stdcells/buf_2.sym} 117620 -17170 0 0 {name=X_55937_ }
C {devices/lab_pin.sym} 117560 -17080 0 0 {name=p116866 lab=_74771_/A }
C {devices/lab_pin.sym} 117560 -17040 0 0 {name=p116867 lab=_74804_/A }
C {devices/lab_pin.sym} 117560 -17000 0 0 {name=p116868 lab=_74797_/C }
C {devices/lab_pin.sym} 117560 -16960 0 0 {name=p116869 lab=_71738_/X }
C {devices/lab_pin.sym} 117680 -17020 0 1 {name=p116870 lab=_74771_/Y }
C {sky130_stdcells/nand4_4.sym} 117620 -17020 0 0 {name=X_74771_ }
C {devices/lab_pin.sym} 117530 -16870 0 0 {name=p116871 lab=_86757_/CLK }
C {devices/lab_pin.sym} 117530 -16850 0 0 {name=p116872 lab=_46229_/Y }
C {devices/lab_pin.sym} 117710 -16870 0 1 {name=p116873 lab=_86757_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -16860 0 0 {name=X_86757_ }
C {devices/lab_pin.sym} 117560 -16750 0 0 {name=p116874 lab=_48938_/A }
C {devices/lab_pin.sym} 117560 -16710 0 0 {name=p116875 lab=_71959_/X }
C {devices/lab_pin.sym} 117560 -16670 0 0 {name=p116876 lab=_71964_/X }
C {devices/lab_pin.sym} 117680 -16710 0 1 {name=p116877 lab=_71983_/X }
C {sky130_stdcells/and3_4.sym} 117620 -16710 0 0 {name=X_71983_ }
C {devices/lab_pin.sym} 117530 -16570 0 0 {name=p116878 lab=_80931_/CLK }
C {devices/lab_pin.sym} 117530 -16550 0 0 {name=p116879 lab=_68585_/X }
C {devices/lab_pin.sym} 117710 -16570 0 1 {name=p116880 lab=_80825_/D }
C {sky130_stdcells/dfxtp_4.sym} 117620 -16560 0 0 {name=X_83969_ }
C {devices/lab_pin.sym} 117560 -16450 0 0 {name=p116881 lab=_76510_/A }
C {devices/lab_pin.sym} 117560 -16410 0 0 {name=p116882 lab=_76510_/B }
C {devices/lab_pin.sym} 117560 -16370 0 0 {name=p116883 lab=_76510_/C }
C {devices/lab_pin.sym} 117680 -16410 0 1 {name=p116884 lab=_76511_/B }
C {sky130_stdcells/nand3_4.sym} 117620 -16410 0 0 {name=X_76510_ }
C {devices/lab_pin.sym} 117540 -16300 0 0 {name=p116885 lab=_41663_/X }
C {devices/lab_pin.sym} 117540 -16260 0 0 {name=p116886 lab=_42900_/X }
C {devices/lab_pin.sym} 117540 -16220 0 0 {name=p116887 lab=_87661_/Q }
C {devices/lab_pin.sym} 117540 -16180 0 0 {name=p116888 lab=_42901_/X }
C {devices/lab_pin.sym} 117700 -16240 0 1 {name=p116889 lab=_42902_/X }
C {sky130_stdcells/a2bb2o_4.sym} 117620 -16240 0 0 {name=X_42902_ }
C {devices/lab_pin.sym} 117540 -16110 0 0 {name=p116890 lab=_70107_/A }
C {devices/lab_pin.sym} 117540 -16070 0 0 {name=p116891 lab=_73697_/X }
C {devices/lab_pin.sym} 117540 -16030 0 0 {name=p116892 lab=_73721_/X }
C {devices/lab_pin.sym} 117700 -16070 0 1 {name=p116893 lab=_73722_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -16070 0 0 {name=X_73722_ }
C {devices/lab_pin.sym} 117530 -15930 0 0 {name=p116894 lab=_82390_/CLK }
C {devices/lab_pin.sym} 117530 -15910 0 0 {name=p116895 lab=_53045_/Y }
C {devices/lab_pin.sym} 117710 -15930 0 1 {name=p116896 lab=_85708_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -15920 0 0 {name=X_85708_ }
C {devices/lab_pin.sym} 117540 -15810 0 0 {name=p116897 lab=_58125_/X }
C {devices/lab_pin.sym} 117540 -15770 0 0 {name=p116898 lab=_85786_/Q }
C {devices/lab_pin.sym} 117540 -15730 0 0 {name=p116899 lab=_58126_/X }
C {devices/lab_pin.sym} 117700 -15770 0 1 {name=p116900 lab=_58656_/X }
C {sky130_stdcells/o21a_4.sym} 117620 -15770 0 0 {name=X_58656_ }
C {devices/lab_pin.sym} 117560 -15660 0 0 {name=p116901 lab=_46670_/A }
C {devices/lab_pin.sym} 117560 -15620 0 0 {name=p116902 lab=_46682_/B }
C {devices/lab_pin.sym} 117560 -15580 0 0 {name=p116903 lab=_46682_/C }
C {devices/lab_pin.sym} 117560 -15540 0 0 {name=p116904 lab=_51777_/D }
C {devices/lab_pin.sym} 117680 -15600 0 1 {name=p116905 lab=_46670_/X }
C {sky130_stdcells/and4_4.sym} 117620 -15600 0 0 {name=X_46670_ }
C {devices/lab_pin.sym} 117580 -15450 0 0 {name=p116906 lab=_71093_/C }
C {devices/lab_pin.sym} 117660 -15450 0 1 {name=p116907 lab=_71115_/B }
C {sky130_stdcells/buf_2.sym} 117620 -15450 0 0 {name=X_70934_ }
C {devices/lab_pin.sym} 117560 -15350 0 0 {name=p116908 lab=_77486_/Y }
C {devices/lab_pin.sym} 117560 -15310 0 0 {name=p116909 lab=_77487_/Y }
C {devices/lab_pin.sym} 117560 -15270 0 0 {name=p116910 lab=_77489_/Y }
C {devices/lab_pin.sym} 117680 -15310 0 1 {name=p116911 lab=_77495_/A }
C {sky130_stdcells/or3_4.sym} 117620 -15310 0 0 {name=X_77490_ }
C {devices/lab_pin.sym} 117540 -15200 0 0 {name=p116912 lab=_41288_/X }
C {devices/lab_pin.sym} 117540 -15160 0 0 {name=p116913 lab=_43879_/X }
C {devices/lab_pin.sym} 117540 -15120 0 0 {name=p116914 lab=_87219_/Q }
C {devices/lab_pin.sym} 117540 -15080 0 0 {name=p116915 lab=_43880_/X }
C {devices/lab_pin.sym} 117700 -15140 0 1 {name=p116916 lab=_87219_/D }
C {sky130_stdcells/a2bb2o_4.sym} 117620 -15140 0 0 {name=X_43882_ }
C {devices/lab_pin.sym} 117540 -15020 0 0 {name=p116917 lab=_85204_/Q }
C {devices/lab_pin.sym} 117540 -14980 0 0 {name=p116918 lab=_55511_/X }
C {devices/lab_pin.sym} 117540 -14940 0 0 {name=p116919 lab=_55513_/X }
C {devices/lab_pin.sym} 117540 -14900 0 0 {name=p116920 lab=_55867_/X }
C {devices/lab_pin.sym} 117700 -14960 0 1 {name=p116921 lab=_55868_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -14960 0 0 {name=X_55868_ }
C {devices/lab_pin.sym} 117530 -14810 0 0 {name=p116922 lab=_86688_/CLK }
C {devices/lab_pin.sym} 117530 -14790 0 0 {name=p116923 lab=_46935_/Y }
C {devices/lab_pin.sym} 117710 -14810 0 1 {name=p116924 lab=_86688_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -14800 0 0 {name=X_86688_ }
C {devices/lab_pin.sym} 117540 -14690 0 0 {name=p116925 lab=_82995_/Q }
C {devices/lab_pin.sym} 117540 -14650 0 0 {name=p116926 lab=_45401_/X }
C {devices/lab_pin.sym} 117540 -14610 0 0 {name=p116927 lab=_45620_/X }
C {devices/lab_pin.sym} 117700 -14650 0 1 {name=p116928 lab=_45621_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -14650 0 0 {name=X_45621_ }
C {devices/lab_pin.sym} 117580 -14510 0 0 {name=p116929 lab=_46259_/A }
C {devices/lab_pin.sym} 117660 -14510 0 1 {name=p116930 lab=_71993_/A }
C {sky130_stdcells/buf_2.sym} 117620 -14510 0 0 {name=X_57607_ }
C {devices/lab_pin.sym} 117560 -14400 0 0 {name=p116931 lab=_76437_/X }
C {devices/lab_pin.sym} 117560 -14360 0 0 {name=p116932 lab=_76440_/X }
C {devices/lab_pin.sym} 117680 -14380 0 1 {name=p116933 lab=_76441_/X }
C {sky130_stdcells/xor2_4.sym} 117620 -14380 0 0 {name=X_76441_ }
C {devices/lab_pin.sym} 117540 -14280 0 0 {name=p116934 lab=_41479_/X }
C {devices/lab_pin.sym} 117540 -14240 0 0 {name=p116935 lab=_42830_/X }
C {devices/lab_pin.sym} 117540 -14200 0 0 {name=p116936 lab=_87695_/Q }
C {devices/lab_pin.sym} 117540 -14160 0 0 {name=p116937 lab=_42832_/X }
C {devices/lab_pin.sym} 117700 -14220 0 1 {name=p116938 lab=_42833_/X }
C {sky130_stdcells/a2bb2o_4.sym} 117620 -14220 0 0 {name=X_42833_ }
C {devices/lab_pin.sym} 117540 -14090 0 0 {name=p116939 lab=_85372_/Q }
C {devices/lab_pin.sym} 117540 -14050 0 0 {name=p116940 lab=_54812_/X }
C {devices/lab_pin.sym} 117540 -14010 0 0 {name=p116941 lab=_54818_/Y }
C {devices/lab_pin.sym} 117700 -14050 0 1 {name=p116942 lab=_54819_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -14050 0 0 {name=X_54819_ }
C {devices/lab_pin.sym} 117530 -13910 0 0 {name=p116943 lab=_85735_/CLK }
C {devices/lab_pin.sym} 117530 -13890 0 0 {name=p116944 lab=_53411_/Y }
C {devices/lab_pin.sym} 117710 -13910 0 1 {name=p116945 lab=_85639_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -13900 0 0 {name=X_85639_ }
C {devices/lab_pin.sym} 117560 -13780 0 0 {name=p116946 lab=_73653_/A }
C {devices/lab_pin.sym} 117560 -13740 0 0 {name=p116947 lab=_73599_/B }
C {devices/lab_pin.sym} 117680 -13760 0 1 {name=p116948 lab=_73653_/Y }
C {sky130_stdcells/nor2_4.sym} 117620 -13760 0 0 {name=X_73653_ }
C {devices/lab_pin.sym} 117580 -13630 0 0 {name=p116949 lab=_71072_/A }
C {devices/lab_pin.sym} 117660 -13630 0 1 {name=p116950 lab=_70869_/B }
C {sky130_stdcells/buf_2.sym} 117620 -13630 0 0 {name=X_70865_ }
C {devices/lab_pin.sym} 117560 -13520 0 0 {name=p116951 lab=_58687_/A }
C {devices/lab_pin.sym} 117560 -13480 0 0 {name=p116952 lab=_58587_/B }
C {devices/lab_pin.sym} 117680 -13500 0 1 {name=p116953 lab=_58587_/Y }
C {sky130_stdcells/nor2_4.sym} 117620 -13500 0 0 {name=X_58587_ }
C {devices/lab_pin.sym} 117560 -13380 0 0 {name=p116954 lab=_55796_/X }
C {devices/lab_pin.sym} 117560 -13340 0 0 {name=p116955 lab=_55798_/X }
C {devices/lab_pin.sym} 117680 -13360 0 1 {name=p116956 lab=_55800_/A }
C {sky130_stdcells/and2_4.sym} 117620 -13360 0 0 {name=X_55799_ }
C {devices/lab_pin.sym} 117560 -13240 0 0 {name=p116957 lab=_48401_/A }
C {devices/lab_pin.sym} 117560 -13200 0 0 {name=p116958 lab=_50378_/B }
C {devices/lab_pin.sym} 117680 -13220 0 1 {name=p116959 lab=_48340_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -13220 0 0 {name=X_48340_ }
C {devices/lab_pin.sym} 117560 -13110 0 0 {name=p116960 lab=_72581_/A }
C {devices/lab_pin.sym} 117560 -13070 0 0 {name=p116961 lab=_72604_/B }
C {devices/lab_pin.sym} 117560 -13030 0 0 {name=p116962 lab=_79279_/B }
C {devices/lab_pin.sym} 117680 -13070 0 1 {name=p116963 lab=_72604_/Y }
C {sky130_stdcells/nor3_4.sym} 117620 -13070 0 0 {name=X_72604_ }
C {devices/lab_pin.sym} 117560 -12940 0 0 {name=p116964 lab=_79159_/Y }
C {devices/lab_pin.sym} 117560 -12900 0 0 {name=p116965 lab=_79160_/B }
C {devices/lab_pin.sym} 117680 -12920 0 1 {name=p116966 lab=_79160_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -12920 0 0 {name=X_79160_ }
C {devices/lab_pin.sym} 117580 -12790 0 0 {name=p116967 lab=_44932_/A }
C {devices/lab_pin.sym} 117660 -12790 0 1 {name=p116968 lab=_45617_/B }
C {sky130_stdcells/buf_2.sym} 117620 -12790 0 0 {name=X_45552_ }
C {devices/lab_pin.sym} 117540 -12690 0 0 {name=p116969 lab=_84983_/Q }
C {devices/lab_pin.sym} 117540 -12650 0 0 {name=p116970 lab=_57527_/X }
C {devices/lab_pin.sym} 117540 -12610 0 0 {name=p116971 lab=_57537_/Y }
C {devices/lab_pin.sym} 117700 -12650 0 1 {name=p116972 lab=_57538_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -12650 0 0 {name=X_57538_ }
C {devices/lab_pin.sym} 117560 -12520 0 0 {name=p116973 lab=_76364_/X }
C {devices/lab_pin.sym} 117560 -12480 0 0 {name=p116974 lab=_76371_/X }
C {devices/lab_pin.sym} 117680 -12500 0 1 {name=p116975 lab=_76381_/A }
C {sky130_stdcells/xnor2_4.sym} 117620 -12500 0 0 {name=X_76372_ }
C {devices/lab_pin.sym} 117540 -12400 0 0 {name=p116976 lab=_41288_/X }
C {devices/lab_pin.sym} 117540 -12360 0 0 {name=p116977 lab=_42757_/X }
C {devices/lab_pin.sym} 117540 -12320 0 0 {name=p116978 lab=_67333_/B }
C {devices/lab_pin.sym} 117540 -12280 0 0 {name=p116979 lab=_42759_/X }
C {devices/lab_pin.sym} 117700 -12340 0 1 {name=p116980 lab=_87731_/D }
C {sky130_stdcells/a2bb2o_4.sym} 117620 -12340 0 0 {name=X_42764_ }
C {devices/lab_pin.sym} 117530 -12190 0 0 {name=p116981 lab=_87859_/CLK }
C {devices/lab_pin.sym} 117530 -12170 0 0 {name=p116982 lab=_40663_/Y }
C {devices/lab_pin.sym} 117710 -12190 0 1 {name=p116983 lab=_68699_/B }
C {sky130_stdcells/dfxtp_4.sym} 117620 -12180 0 0 {name=X_88358_ }
C {devices/lab_pin.sym} 117540 -12080 0 0 {name=p116984 lab=_73378_/X }
C {devices/lab_pin.sym} 117540 -12040 0 0 {name=p116985 lab=_86240_/Q }
C {devices/lab_pin.sym} 117540 -12000 0 0 {name=p116986 lab=_73446_/X }
C {devices/lab_pin.sym} 117540 -11960 0 0 {name=p116987 lab=_73583_/X }
C {devices/lab_pin.sym} 117700 -12020 0 1 {name=p116988 lab=_73584_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -12020 0 0 {name=X_73584_ }
C {devices/lab_pin.sym} 117560 -11900 0 0 {name=p116989 lab=_70905_/A }
C {devices/lab_pin.sym} 117560 -11860 0 0 {name=p116990 lab=_70791_/B }
C {devices/lab_pin.sym} 117560 -11820 0 0 {name=p116991 lab=_70794_/X }
C {devices/lab_pin.sym} 117560 -11780 0 0 {name=p116992 lab=_70841_/D }
C {devices/lab_pin.sym} 117680 -11840 0 1 {name=p116993 lab=_70796_/Y }
C {sky130_stdcells/nand4_4.sym} 117620 -11840 0 0 {name=X_70796_ }
C {devices/lab_pin.sym} 117560 -11700 0 0 {name=p116994 lab=_78130_/B }
C {devices/lab_pin.sym} 117560 -11660 0 0 {name=p116995 lab=_78110_/Y }
C {devices/lab_pin.sym} 117680 -11680 0 1 {name=p116996 lab=_78112_/B }
C {sky130_stdcells/xnor2_4.sym} 117620 -11680 0 0 {name=X_78111_ }
C {devices/lab_pin.sym} 117580 -11550 0 0 {name=p116997 lab=_44603_/A }
C {devices/lab_pin.sym} 117660 -11550 0 1 {name=p116998 lab=_44503_/X }
C {sky130_stdcells/buf_2.sym} 117620 -11550 0 0 {name=X_44503_ }
C {devices/lab_pin.sym} 117540 -11450 0 0 {name=p116999 lab=_75318_/X }
C {devices/lab_pin.sym} 117540 -11410 0 0 {name=p117000 lab=_75321_/Y }
C {devices/lab_pin.sym} 117540 -11370 0 0 {name=p117001 lab=_75322_/A }
C {devices/lab_pin.sym} 117700 -11410 0 1 {name=p117002 lab=_75323_/X }
C {sky130_stdcells/o21a_4.sym} 117620 -11410 0 0 {name=X_75323_ }
C {devices/lab_pin.sym} 117530 -11270 0 0 {name=p117003 lab=_83158_/CLK }
C {devices/lab_pin.sym} 117530 -11250 0 0 {name=p117004 lab=_87309_/D }
C {devices/lab_pin.sym} 117710 -11270 0 1 {name=p117005 lab=_72924_/A }
C {sky130_stdcells/dfxtp_4.sym} 117620 -11260 0 0 {name=X_87309_ }
C {devices/lab_pin.sym} 117580 -11130 0 0 {name=p117006 lab=_41715_/A }
C {devices/lab_pin.sym} 117660 -11130 0 1 {name=p117007 lab=_41715_/X }
C {sky130_stdcells/buf_2.sym} 117620 -11130 0 0 {name=X_41715_ }
C {devices/lab_pin.sym} 117560 -11020 0 0 {name=p117008 lab=_48244_/A }
C {devices/lab_pin.sym} 117560 -10980 0 0 {name=p117009 lab=_48016_/B }
C {devices/lab_pin.sym} 117680 -11000 0 1 {name=p117010 lab=_48271_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -11000 0 0 {name=X_48271_ }
C {devices/lab_pin.sym} 117560 -10880 0 0 {name=p117011 lab=_72535_/A }
C {devices/lab_pin.sym} 117560 -10840 0 0 {name=p117012 lab=_72535_/B }
C {devices/lab_pin.sym} 117680 -10860 0 1 {name=p117013 lab=_72535_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -10860 0 0 {name=X_72535_ }
C {devices/lab_pin.sym} 117540 -10760 0 0 {name=p117014 lab=_79074_/A }
C {devices/lab_pin.sym} 117540 -10720 0 0 {name=p117015 lab=_79089_/A }
C {devices/lab_pin.sym} 117540 -10680 0 0 {name=p117016 lab=_82654_/Q }
C {devices/lab_pin.sym} 117540 -10640 0 0 {name=p117017 lab=_79090_/Y }
C {devices/lab_pin.sym} 117700 -10700 0 1 {name=p117018 lab=_79091_/X }
C {sky130_stdcells/a2bb2o_4.sym} 117620 -10700 0 0 {name=X_79091_ }
C {devices/lab_pin.sym} 117540 -10570 0 0 {name=p117019 lab=_45434_/X }
C {devices/lab_pin.sym} 117540 -10530 0 0 {name=p117020 lab=_61390_/A }
C {devices/lab_pin.sym} 117540 -10490 0 0 {name=p117021 lab=_45452_/X }
C {devices/lab_pin.sym} 117700 -10530 0 1 {name=p117022 lab=_45483_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -10530 0 0 {name=X_45483_ }
C {devices/lab_pin.sym} 117540 -10410 0 0 {name=p117023 lab=_44292_/A }
C {devices/lab_pin.sym} 117540 -10370 0 0 {name=p117024 lab=_57346_/C }
C {devices/lab_pin.sym} 117540 -10330 0 0 {name=p117025 lab=_57468_/X }
C {devices/lab_pin.sym} 117700 -10370 0 1 {name=p117026 lab=_57469_/X }
C {sky130_stdcells/o21a_4.sym} 117620 -10370 0 0 {name=X_57469_ }
C {devices/lab_pin.sym} 117530 -10230 0 0 {name=p117027 lab=_87026_/CLK }
C {devices/lab_pin.sym} 117530 -10210 0 0 {name=p117028 lab=_41039_/Y }
C {devices/lab_pin.sym} 117710 -10230 0 1 {name=p117029 lab=_88289_/Q }
C {sky130_stdcells/dfxtp_4.sym} 117620 -10220 0 0 {name=X_88289_ }
C {devices/lab_pin.sym} 117580 -10090 0 0 {name=p117030 lab=_42651_/X }
C {devices/lab_pin.sym} 117660 -10090 0 1 {name=p117031 lab=_42695_/X }
C {sky130_stdcells/buf_2.sym} 117620 -10090 0 0 {name=X_42695_ }
C {devices/lab_pin.sym} 117560 -9980 0 0 {name=p117032 lab=_47196_/A }
C {devices/lab_pin.sym} 117560 -9940 0 0 {name=p117033 lab=_52924_/B }
C {devices/lab_pin.sym} 117680 -9960 0 1 {name=p117034 lab=_47222_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -9960 0 0 {name=X_47222_ }
C {devices/lab_pin.sym} 117580 -9830 0 0 {name=p117035 lab=_59085_/A }
C {devices/lab_pin.sym} 117660 -9830 0 1 {name=p117036 lab=_59208_/X }
C {sky130_stdcells/buf_2.sym} 117620 -9830 0 0 {name=X_59208_ }
C {devices/lab_pin.sym} 117580 -9710 0 0 {name=p117037 lab=_77954_/B }
C {devices/lab_pin.sym} 117660 -9710 0 1 {name=p117038 lab=_78042_/Y }
C {sky130_stdcells/inv_2.sym} 117620 -9710 0 0 {name=X_78042_ }
C {devices/lab_pin.sym} 117540 -9620 0 0 {name=p117039 lab=_41586_/X }
C {devices/lab_pin.sym} 117540 -9580 0 0 {name=p117040 lab=_44431_/X }
C {devices/lab_pin.sym} 117540 -9540 0 0 {name=p117041 lab=_87111_/Q }
C {devices/lab_pin.sym} 117540 -9500 0 0 {name=p117042 lab=_44432_/X }
C {devices/lab_pin.sym} 117700 -9560 0 1 {name=p117043 lab=_87111_/D }
C {sky130_stdcells/a2bb2o_4.sym} 117620 -9560 0 0 {name=X_44434_ }
C {devices/lab_pin.sym} 117580 -9410 0 0 {name=p117044 lab=_75254_/A }
C {devices/lab_pin.sym} 117660 -9410 0 1 {name=p117045 lab=_75254_/Y }
C {sky130_stdcells/inv_2.sym} 117620 -9410 0 0 {name=X_75254_ }
C {devices/lab_pin.sym} 117540 -9310 0 0 {name=p117046 lab=_41588_/X }
C {devices/lab_pin.sym} 117540 -9270 0 0 {name=p117047 lab=_81758_/Q }
C {devices/lab_pin.sym} 117540 -9230 0 0 {name=p117048 lab=_41645_/X }
C {devices/lab_pin.sym} 117700 -9270 0 1 {name=p117049 lab=_41646_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -9270 0 0 {name=X_41646_ }
C {devices/lab_pin.sym} 117580 -9130 0 0 {name=p117050 lab=_60479_/Y }
C {devices/lab_pin.sym} 117660 -9130 0 1 {name=p117051 lab=_60481_/A }
C {sky130_stdcells/buf_2.sym} 117620 -9130 0 0 {name=X_60480_ }
C {devices/lab_pin.sym} 117540 -9030 0 0 {name=p117052 lab=_57712_/X }
C {devices/lab_pin.sym} 117540 -8990 0 0 {name=p117053 lab=_85315_/Q }
C {devices/lab_pin.sym} 117540 -8950 0 0 {name=p117054 lab=_57736_/A }
C {devices/lab_pin.sym} 117700 -8990 0 1 {name=p117055 lab=_72466_/X }
C {sky130_stdcells/o21a_4.sym} 117620 -8990 0 0 {name=X_72466_ }
C {devices/lab_pin.sym} 117540 -8880 0 0 {name=p117056 lab=_69053_/B }
C {devices/lab_pin.sym} 117540 -8840 0 0 {name=p117057 lab=_44128_/X }
C {devices/lab_pin.sym} 117540 -8800 0 0 {name=p117058 lab=_73031_/X }
C {devices/lab_pin.sym} 117540 -8760 0 0 {name=p117059 lab=_74204_/Y }
C {devices/lab_pin.sym} 117700 -8820 0 1 {name=p117060 lab=_74205_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -8820 0 0 {name=X_74205_ }
C {devices/lab_pin.sym} 117580 -8670 0 0 {name=p117061 lab=_82377_/Q }
C {devices/lab_pin.sym} 117660 -8670 0 1 {name=p117062 lab=_54576_/D }
C {sky130_stdcells/inv_2.sym} 117620 -8670 0 0 {name=X_47153_ }
C {devices/lab_pin.sym} 117540 -8570 0 0 {name=p117063 lab=_59061_/X }
C {devices/lab_pin.sym} 117540 -8530 0 0 {name=p117064 lab=_86070_/Q }
C {devices/lab_pin.sym} 117540 -8490 0 0 {name=p117065 lab=_59138_/X }
C {devices/lab_pin.sym} 117700 -8530 0 1 {name=p117066 lab=_59139_/Y }
C {sky130_stdcells/o21ai_4.sym} 117620 -8530 0 0 {name=X_59139_ }
C {devices/lab_pin.sym} 117540 -8410 0 0 {name=p117067 lab=_71396_/Y }
C {devices/lab_pin.sym} 117540 -8370 0 0 {name=p117068 lab=_83506_/Q }
C {devices/lab_pin.sym} 117540 -8330 0 0 {name=p117069 lab=_71416_/Y }
C {devices/lab_pin.sym} 117700 -8370 0 1 {name=p117070 lab=_83506_/D }
C {sky130_stdcells/a21o_4.sym} 117620 -8370 0 0 {name=X_71417_ }
C {devices/lab_pin.sym} 117580 -8230 0 0 {name=p117071 lab=_40509_/X }
C {devices/lab_pin.sym} 117660 -8230 0 1 {name=p117072 lab=_44365_/X }
C {sky130_stdcells/buf_2.sym} 117620 -8230 0 0 {name=X_44365_ }
C {devices/lab_pin.sym} 117560 -8120 0 0 {name=p117073 lab=_75186_/B }
C {devices/lab_pin.sym} 117560 -8080 0 0 {name=p117074 lab=_75186_/A }
C {devices/lab_pin.sym} 117680 -8100 0 1 {name=p117075 lab=_75190_/A }
C {sky130_stdcells/or2_4.sym} 117620 -8100 0 0 {name=X_75185_ }
C {devices/lab_pin.sym} 117580 -7970 0 0 {name=p117076 lab=_41061_/A }
C {devices/lab_pin.sym} 117660 -7970 0 1 {name=p117077 lab=_41577_/X }
C {sky130_stdcells/buf_2.sym} 117620 -7970 0 0 {name=X_41577_ }
C {devices/lab_pin.sym} 117540 -7870 0 0 {name=p117078 lab=_72361_/X }
C {devices/lab_pin.sym} 117540 -7830 0 0 {name=p117079 lab=_85674_/Q }
C {devices/lab_pin.sym} 117540 -7790 0 0 {name=p117080 lab=_72362_/X }
C {devices/lab_pin.sym} 117700 -7830 0 1 {name=p117081 lab=_72397_/X }
C {sky130_stdcells/o21a_4.sym} 117620 -7830 0 0 {name=X_72397_ }
C {devices/lab_pin.sym} 117580 -7690 0 0 {name=p117082 lab=_74846_/B }
C {devices/lab_pin.sym} 117660 -7690 0 1 {name=p117083 lab=_46104_/Y }
C {sky130_stdcells/inv_2.sym} 117620 -7690 0 0 {name=X_46104_ }
C {devices/lab_pin.sym} 117580 -7570 0 0 {name=p117084 lab=_43296_/A }
C {devices/lab_pin.sym} 117660 -7570 0 1 {name=p117085 lab=_43316_/X }
C {sky130_stdcells/buf_2.sym} 117620 -7570 0 0 {name=X_43316_ }
C {devices/lab_pin.sym} 117560 -7460 0 0 {name=p117086 lab=_74126_/Y }
C {devices/lab_pin.sym} 117560 -7420 0 0 {name=p117087 lab=_74136_/B }
C {devices/lab_pin.sym} 117680 -7440 0 1 {name=p117088 lab=_74136_/Y }
C {sky130_stdcells/xnor2_4.sym} 117620 -7440 0 0 {name=X_74136_ }
C {devices/lab_pin.sym} 117560 -7340 0 0 {name=p117089 lab=_61663_/B }
C {devices/lab_pin.sym} 117560 -7300 0 0 {name=p117090 lab=_62161_/B }
C {devices/lab_pin.sym} 117560 -7260 0 0 {name=p117091 lab=_62187_/C }
C {devices/lab_pin.sym} 117560 -7220 0 0 {name=p117092 lab=_61706_/X }
C {devices/lab_pin.sym} 117680 -7280 0 1 {name=p117093 lab=_62150_/Y }
C {sky130_stdcells/nand4_4.sym} 117620 -7280 0 0 {name=X_62150_ }
C {devices/lab_pin.sym} 117580 -7130 0 0 {name=p117094 lab=_40527_/Y }
C {devices/lab_pin.sym} 117660 -7130 0 1 {name=p117095 lab=_40528_/X }
C {sky130_stdcells/buf_2.sym} 117620 -7130 0 0 {name=X_40528_ }
C {devices/lab_pin.sym} 117580 -7010 0 0 {name=p117096 lab=_47084_/A }
C {devices/lab_pin.sym} 117660 -7010 0 1 {name=p117097 lab=_52846_/D }
C {sky130_stdcells/buf_2.sym} 117620 -7010 0 0 {name=X_47084_ }
C {devices/lab_pin.sym} 117580 -6890 0 0 {name=p117098 lab=_70591_/A }
C {devices/lab_pin.sym} 117660 -6890 0 1 {name=p117099 lab=_71349_/D }
C {sky130_stdcells/buf_2.sym} 117620 -6890 0 0 {name=X_71348_ }
C {devices/lab_pin.sym} 117580 -6770 0 0 {name=p117100 lab=_44147_/A }
C {devices/lab_pin.sym} 117660 -6770 0 1 {name=p117101 lab=_68714_/A }
C {sky130_stdcells/buf_2.sym} 117620 -6770 0 0 {name=X_44296_ }
C {devices/lab_pin.sym} 117560 -6660 0 0 {name=p117102 lab=_79989_/Y }
C {devices/lab_pin.sym} 117560 -6620 0 0 {name=p117103 lab=_79992_/Y }
C {devices/lab_pin.sym} 117680 -6640 0 1 {name=p117104 lab=_79993_/X }
C {sky130_stdcells/xor2_4.sym} 117620 -6640 0 0 {name=X_79993_ }
C {devices/lab_pin.sym} 117580 -6510 0 0 {name=p117105 lab=_61101_/A }
C {devices/lab_pin.sym} 117660 -6510 0 1 {name=p117106 lab=_64323_/A }
C {sky130_stdcells/buf_2.sym} 117620 -6510 0 0 {name=X_61101_ }
C {devices/lab_pin.sym} 117540 -6420 0 0 {name=p117107 lab=_41478_/Y }
C {devices/lab_pin.sym} 117540 -6380 0 0 {name=p117108 lab=_46029_/X }
C {devices/lab_pin.sym} 117540 -6340 0 0 {name=p117109 lab=_86802_/Q }
C {devices/lab_pin.sym} 117540 -6300 0 0 {name=p117110 lab=_46030_/X }
C {devices/lab_pin.sym} 117700 -6360 0 1 {name=p117111 lab=_46035_/X }
C {sky130_stdcells/a2bb2o_4.sym} 117620 -6360 0 0 {name=X_46035_ }
C {devices/lab_pin.sym} 117580 -6210 0 0 {name=p117112 lab=_43180_/A }
C {devices/lab_pin.sym} 117660 -6210 0 1 {name=p117113 lab=_43247_/X }
C {sky130_stdcells/buf_2.sym} 117620 -6210 0 0 {name=X_43247_ }
C {devices/lab_pin.sym} 117560 -6120 0 0 {name=p117114 lab=_62055_/A }
C {devices/lab_pin.sym} 117560 -6080 0 0 {name=p117115 lab=_62081_/B }
C {devices/lab_pin.sym} 117560 -6040 0 0 {name=p117116 lab=_61755_/X }
C {devices/lab_pin.sym} 117560 -6000 0 0 {name=p117117 lab=_61728_/A }
C {devices/lab_pin.sym} 117680 -6060 0 1 {name=p117118 lab=_62081_/X }
C {sky130_stdcells/and4_4.sym} 117620 -6060 0 0 {name=X_62081_ }
C {devices/lab_pin.sym} 117540 -5930 0 0 {name=p117119 lab=_74055_/X }
C {devices/lab_pin.sym} 117540 -5890 0 0 {name=p117120 lab=_74057_/Y }
C {devices/lab_pin.sym} 117540 -5850 0 0 {name=p117121 lab=_74066_/X }
C {devices/lab_pin.sym} 117700 -5890 0 1 {name=p117122 lab=_74067_/X }
C {sky130_stdcells/a21o_4.sym} 117620 -5890 0 0 {name=X_74067_ }
C {devices/lab_pin.sym} 117540 -5770 0 0 {name=p117123 lab=_78937_/A }
C {devices/lab_pin.sym} 117540 -5730 0 0 {name=p117124 lab=_78937_/B }
C {devices/lab_pin.sym} 117540 -5690 0 0 {name=p117125 lab=_78938_/A }
C {devices/lab_pin.sym} 117700 -5730 0 1 {name=p117126 lab=_78944_/Y }
C {sky130_stdcells/a21boi_4.sym} 117620 -5730 0 0 {name=X_78944_ }
C {devices/lab_pin.sym} 117580 -5590 0 0 {name=p117127 lab=_40458_/X }
C {devices/lab_pin.sym} 117660 -5590 0 1 {name=p117128 lab=_40459_/X }
C {sky130_stdcells/buf_2.sym} 117620 -5590 0 0 {name=X_40459_ }
C {devices/lab_pin.sym} 117560 -5500 0 0 {name=p117129 lab=_71178_/A }
C {devices/lab_pin.sym} 117560 -5460 0 0 {name=p117130 lab=_71276_/B }
C {devices/lab_pin.sym} 117560 -5420 0 0 {name=p117131 lab=_71279_/C }
C {devices/lab_pin.sym} 117560 -5380 0 0 {name=p117132 lab=_71276_/D }
C {devices/lab_pin.sym} 117680 -5440 0 1 {name=p117133 lab=_71279_/Y }
C {sky130_stdcells/nand4_4.sym} 117620 -5440 0 0 {name=X_71279_ }
C {devices/lab_pin.sym} 117540 -5320 0 0 {name=p117134 lab=_60954_/X }
C {devices/lab_pin.sym} 117540 -5280 0 0 {name=p117135 lab=_60994_/B }
C {devices/lab_pin.sym} 117540 -5240 0 0 {name=p117136 lab=_59789_/A }
C {devices/lab_pin.sym} 117540 -5200 0 0 {name=p117137 lab=_60988_/Y }
C {devices/lab_pin.sym} 117700 -5260 0 1 {name=p117138 lab=_61032_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -5260 0 0 {name=X_61032_ }
C {devices/lab_pin.sym} 117560 -5120 0 0 {name=p117139 lab=_73018_/A }
C {devices/lab_pin.sym} 117560 -5080 0 0 {name=p117140 lab=_73018_/B }
C {devices/lab_pin.sym} 117680 -5100 0 1 {name=p117141 lab=_73019_/B }
C {sky130_stdcells/nand2_4.sym} 117620 -5100 0 0 {name=X_73018_ }
C {devices/lab_pin.sym} 117580 -4970 0 0 {name=p117142 lab=_43177_/Y }
C {devices/lab_pin.sym} 117660 -4970 0 1 {name=p117143 lab=_43178_/X }
C {sky130_stdcells/buf_2.sym} 117620 -4970 0 0 {name=X_43178_ }
C {devices/lab_pin.sym} 117560 -4860 0 0 {name=p117144 lab=_78873_/Y }
C {devices/lab_pin.sym} 117560 -4820 0 0 {name=p117145 lab=_78875_/B }
C {devices/lab_pin.sym} 117680 -4840 0 1 {name=p117146 lab=_78875_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -4840 0 0 {name=X_78875_ }
C {devices/lab_pin.sym} 117540 -4740 0 0 {name=p117147 lab=_41104_/X }
C {devices/lab_pin.sym} 117540 -4700 0 0 {name=p117148 lab=_42125_/X }
C {devices/lab_pin.sym} 117540 -4660 0 0 {name=p117149 lab=_88021_/Q }
C {devices/lab_pin.sym} 117540 -4620 0 0 {name=p117150 lab=_42126_/X }
C {devices/lab_pin.sym} 117700 -4680 0 1 {name=p117151 lab=_42129_/X }
C {sky130_stdcells/a2bb2o_4.sym} 117620 -4680 0 0 {name=X_42129_ }
C {devices/lab_pin.sym} 117540 -4560 0 0 {name=p117152 lab=_44150_/X }
C {devices/lab_pin.sym} 117540 -4520 0 0 {name=p117153 lab=_83054_/Q }
C {devices/lab_pin.sym} 117540 -4480 0 0 {name=p117154 lab=_64980_/X }
C {devices/lab_pin.sym} 117540 -4440 0 0 {name=p117155 lab=_65839_/X }
C {devices/lab_pin.sym} 117700 -4500 0 1 {name=p117156 lab=_65840_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -4500 0 0 {name=X_65840_ }
C {devices/lab_pin.sym} 117560 -4360 0 0 {name=p117157 lab=_82269_/Q }
C {devices/lab_pin.sym} 117560 -4320 0 0 {name=p117158 lab=_81981_/Q }
C {devices/lab_pin.sym} 117680 -4340 0 1 {name=p117159 lab=_77826_/Y }
C {sky130_stdcells/xnor2_4.sym} 117620 -4340 0 0 {name=X_77826_ }
C {devices/lab_pin.sym} 117580 -4210 0 0 {name=p117160 lab=_83770_/Q }
C {devices/lab_pin.sym} 117660 -4210 0 1 {name=p117161 lab=_53531_/B }
C {sky130_stdcells/inv_2.sym} 117620 -4210 0 0 {name=X_47986_ }
C {devices/lab_pin.sym} 117540 -4110 0 0 {name=p117162 lab=_49722_/Y }
C {devices/lab_pin.sym} 117540 -4070 0 0 {name=p117163 lab=_49706_/X }
C {devices/lab_pin.sym} 117540 -4030 0 0 {name=p117164 lab=_49724_/X }
C {devices/lab_pin.sym} 117700 -4070 0 1 {name=p117165 lab=_86335_/D }
C {sky130_stdcells/a21oi_4.sym} 117620 -4070 0 0 {name=X_49725_ }
C {devices/lab_pin.sym} 117580 -3930 0 0 {name=p117166 lab=_54451_/B }
C {devices/lab_pin.sym} 117660 -3930 0 1 {name=p117167 lab=_52760_/B }
C {sky130_stdcells/buf_2.sym} 117620 -3930 0 0 {name=X_46937_ }
C {devices/lab_pin.sym} 117560 -3830 0 0 {name=p117168 lab=_65767_/X }
C {devices/lab_pin.sym} 117560 -3790 0 0 {name=p117169 lab=_65741_/B }
C {devices/lab_pin.sym} 117560 -3750 0 0 {name=p117170 lab=_65770_/X }
C {devices/lab_pin.sym} 117680 -3790 0 1 {name=p117171 lab=_65772_/B }
C {sky130_stdcells/nand3_4.sym} 117620 -3790 0 0 {name=X_65771_ }
C {devices/lab_pin.sym} 117560 -3660 0 0 {name=p117172 lab=_77764_/B }
C {devices/lab_pin.sym} 117560 -3620 0 0 {name=p117173 lab=_77756_/Y }
C {devices/lab_pin.sym} 117680 -3640 0 1 {name=p117174 lab=_77757_/X }
C {sky130_stdcells/xor2_4.sym} 117620 -3640 0 0 {name=X_77757_ }
C {devices/lab_pin.sym} 117560 -3540 0 0 {name=p117175 lab=_62847_/A }
C {devices/lab_pin.sym} 117560 -3500 0 0 {name=p117176 lab=_63344_/A }
C {devices/lab_pin.sym} 117560 -3460 0 0 {name=p117177 lab=_62939_/X }
C {devices/lab_pin.sym} 117560 -3420 0 0 {name=p117178 lab=_62975_/D }
C {devices/lab_pin.sym} 117680 -3480 0 1 {name=p117179 lab=_62983_/X }
C {sky130_stdcells/and4_4.sym} 117620 -3480 0 0 {name=X_62983_ }
C {devices/lab_pin.sym} 117560 -3340 0 0 {name=p117180 lab=_74969_/A }
C {devices/lab_pin.sym} 117560 -3300 0 0 {name=p117181 lab=_74969_/B }
C {devices/lab_pin.sym} 117680 -3320 0 1 {name=p117182 lab=_74969_/X }
C {sky130_stdcells/xor2_4.sym} 117620 -3320 0 0 {name=X_74969_ }
C {devices/lab_pin.sym} 117540 -3220 0 0 {name=p117183 lab=_87980_/Q }
C {devices/lab_pin.sym} 117540 -3180 0 0 {name=p117184 lab=_67414_/X }
C {devices/lab_pin.sym} 117540 -3140 0 0 {name=p117185 lab=_67508_/X }
C {devices/lab_pin.sym} 117540 -3100 0 0 {name=p117186 lab=_67509_/X }
C {devices/lab_pin.sym} 117700 -3160 0 1 {name=p117187 lab=_67510_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -3160 0 0 {name=X_67510_ }
C {devices/lab_pin.sym} 117580 -3010 0 0 {name=p117188 lab=_64828_/A }
C {devices/lab_pin.sym} 117660 -3010 0 1 {name=p117189 lab=_64722_/X }
C {sky130_stdcells/buf_2.sym} 117620 -3010 0 0 {name=X_64722_ }
C {devices/lab_pin.sym} 117560 -2900 0 0 {name=p117190 lab=_76708_/A }
C {devices/lab_pin.sym} 117560 -2860 0 0 {name=p117191 lab=_76707_/X }
C {devices/lab_pin.sym} 117680 -2880 0 1 {name=p117192 lab=_76712_/A }
C {sky130_stdcells/xnor2_4.sym} 117620 -2880 0 0 {name=X_76708_ }
C {devices/lab_pin.sym} 117580 -2750 0 0 {name=p117193 lab=_61856_/A }
C {devices/lab_pin.sym} 117660 -2750 0 1 {name=p117194 lab=_61952_/D }
C {sky130_stdcells/buf_2.sym} 117620 -2750 0 0 {name=X_61934_ }
C {devices/lab_pin.sym} 117580 -2630 0 0 {name=p117195 lab=_49520_/A }
C {devices/lab_pin.sym} 117660 -2630 0 1 {name=p117196 lab=_49657_/A }
C {sky130_stdcells/buf_2.sym} 117620 -2630 0 0 {name=X_49656_ }
C {devices/lab_pin.sym} 117580 -2510 0 0 {name=p117197 lab=_68490_/A }
C {devices/lab_pin.sym} 117660 -2510 0 1 {name=p117198 lab=_68491_/B }
C {sky130_stdcells/inv_2.sym} 117620 -2510 0 0 {name=X_68490_ }
C {devices/lab_pin.sym} 117560 -2420 0 0 {name=p117199 lab=_46868_/A }
C {devices/lab_pin.sym} 117560 -2380 0 0 {name=p117200 lab=_46845_/X }
C {devices/lab_pin.sym} 117560 -2340 0 0 {name=p117201 lab=_46868_/C }
C {devices/lab_pin.sym} 117560 -2300 0 0 {name=p117202 lab=_52720_/D }
C {devices/lab_pin.sym} 117680 -2360 0 1 {name=p117203 lab=_46868_/X }
C {sky130_stdcells/and4_4.sym} 117620 -2360 0 0 {name=X_46868_ }
C {devices/lab_pin.sym} 117560 -2220 0 0 {name=p117204 lab=_77688_/A }
C {devices/lab_pin.sym} 117560 -2180 0 0 {name=p117205 lab=_77688_/B }
C {devices/lab_pin.sym} 117680 -2200 0 1 {name=p117206 lab=_77688_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -2200 0 0 {name=X_77688_ }
C {devices/lab_pin.sym} 117560 -2080 0 0 {name=p117207 lab=_48642_/A }
C {devices/lab_pin.sym} 117560 -2040 0 0 {name=p117208 lab=_48065_/A }
C {devices/lab_pin.sym} 117680 -2060 0 1 {name=p117209 lab=_48607_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -2060 0 0 {name=X_48607_ }
C {devices/lab_pin.sym} 117540 -1960 0 0 {name=p117210 lab=_87471_/Q }
C {devices/lab_pin.sym} 117540 -1920 0 0 {name=p117211 lab=_67394_/X }
C {devices/lab_pin.sym} 117540 -1880 0 0 {name=p117212 lab=_67344_/X }
C {devices/lab_pin.sym} 117540 -1840 0 0 {name=p117213 lab=_67440_/X }
C {devices/lab_pin.sym} 117700 -1900 0 1 {name=p117214 lab=_67441_/X }
C {sky130_stdcells/a211o_4.sym} 117620 -1900 0 0 {name=X_67441_ }
C {devices/lab_pin.sym} 117560 -1760 0 0 {name=p117215 lab=_79427_/A }
C {devices/lab_pin.sym} 117560 -1720 0 0 {name=p117216 lab=_79427_/B }
C {devices/lab_pin.sym} 117680 -1740 0 1 {name=p117217 lab=_79433_/B }
C {sky130_stdcells/xor2_4.sym} 117620 -1740 0 0 {name=X_79427_ }
C {devices/lab_pin.sym} 117580 -1610 0 0 {name=p117218 lab=_45819_/A }
C {devices/lab_pin.sym} 117660 -1610 0 1 {name=p117219 lab=_45819_/X }
C {sky130_stdcells/buf_2.sym} 117620 -1610 0 0 {name=X_45819_ }
C {devices/lab_pin.sym} 117560 -1500 0 0 {name=p117220 lab=_64680_/A }
C {devices/lab_pin.sym} 117560 -1460 0 0 {name=p117221 lab=_86271_/Q }
C {devices/lab_pin.sym} 117680 -1480 0 1 {name=p117222 lab=_64653_/X }
C {sky130_stdcells/and2_4.sym} 117620 -1480 0 0 {name=X_64653_ }
C {devices/lab_pin.sym} 117560 -1360 0 0 {name=p117223 lab=_76639_/A }
C {devices/lab_pin.sym} 117560 -1320 0 0 {name=p117224 lab=_76638_/Y }
C {devices/lab_pin.sym} 117680 -1340 0 1 {name=p117225 lab=_76639_/Y }
C {sky130_stdcells/nand2_4.sym} 117620 -1340 0 0 {name=X_76639_ }
C {devices/lab_pin.sym} 117580 -1210 0 0 {name=p117226 lab=_49614_/A }
C {devices/lab_pin.sym} 117660 -1210 0 1 {name=p117227 lab=_49592_/B }
C {sky130_stdcells/buf_2.sym} 117620 -1210 0 0 {name=X_49587_ }
C {devices/lab_pin.sym} 117560 -1110 0 0 {name=p117228 lab=_61865_/A }
C {devices/lab_pin.sym} 117560 -1070 0 0 {name=p117229 lab=_61865_/B }
C {devices/lab_pin.sym} 117560 -1030 0 0 {name=p117230 lab=_78072_/B }
C {devices/lab_pin.sym} 117680 -1070 0 1 {name=p117231 lab=_61865_/Y }
C {sky130_stdcells/nor3_4.sym} 117620 -1070 0 0 {name=X_61865_ }
C {devices/lab_pin.sym} 117580 -930 0 0 {name=p117232 lab=_46845_/A }
C {devices/lab_pin.sym} 117660 -930 0 1 {name=p117233 lab=_46830_/B }
C {sky130_stdcells/buf_2.sym} 117620 -930 0 0 {name=X_46799_ }
C {devices/lab_pin.sym} 117560 -830 0 0 {name=p117234 lab=_63615_/A }
C {devices/lab_pin.sym} 117560 -790 0 0 {name=p117235 lab=_63615_/B }
C {devices/lab_pin.sym} 117560 -750 0 0 {name=p117236 lab=_80422_/B }
C {devices/lab_pin.sym} 117680 -790 0 1 {name=p117237 lab=_63604_/Y }
C {sky130_stdcells/nor3_4.sym} 117620 -790 0 0 {name=X_63604_ }
C {devices/lab_pin.sym} 117580 -650 0 0 {name=p117238 lab=_48538_/A }
C {devices/lab_pin.sym} 117660 -650 0 1 {name=p117239 lab=_48538_/Y }
C {sky130_stdcells/inv_2.sym} 117620 -650 0 0 {name=X_48538_ }
C {devices/lab_pin.sym} 118500 -42150 0 0 {name=p117240 lab=_60558_/X }
C {devices/lab_pin.sym} 118580 -42150 0 1 {name=p117241 lab=_60826_/A }
C {sky130_stdcells/buf_2.sym} 118540 -42150 0 0 {name=X_60816_ }
C {devices/lab_pin.sym} 118460 -42050 0 0 {name=p117242 lab=_67369_/X }
C {devices/lab_pin.sym} 118460 -42010 0 0 {name=p117243 lab=_67371_/X }
C {devices/lab_pin.sym} 118460 -41970 0 0 {name=p117244 lab=_67322_/X }
C {devices/lab_pin.sym} 118620 -42010 0 1 {name=p117245 lab=_67372_/X }
C {sky130_stdcells/a21o_4.sym} 118540 -42010 0 0 {name=X_67372_ }
C {devices/lab_pin.sym} 118460 -41890 0 0 {name=p117246 lab=_79355_/Y }
C {devices/lab_pin.sym} 118460 -41850 0 0 {name=p117247 lab=_79339_/B }
C {devices/lab_pin.sym} 118460 -41810 0 0 {name=p117248 lab=_79357_/X }
C {devices/lab_pin.sym} 118620 -41850 0 1 {name=p117249 lab=_79358_/Y }
C {sky130_stdcells/o21ai_4.sym} 118540 -41850 0 0 {name=X_79358_ }
C {devices/lab_pin.sym} 118500 -41710 0 0 {name=p117250 lab=_44020_/A }
C {devices/lab_pin.sym} 118580 -41710 0 1 {name=p117251 lab=_64584_/X }
C {sky130_stdcells/buf_2.sym} 118540 -41710 0 0 {name=X_64584_ }
C {devices/lab_pin.sym} 118500 -41590 0 0 {name=p117252 lab=_59463_/A }
C {devices/lab_pin.sym} 118580 -41590 0 1 {name=p117253 lab=_61796_/X }
C {sky130_stdcells/buf_2.sym} 118540 -41590 0 0 {name=X_61796_ }
C {devices/lab_pin.sym} 118480 -41480 0 0 {name=p117254 lab=_68669_/A }
C {devices/lab_pin.sym} 118480 -41440 0 0 {name=p117255 lab=_69110_/Y }
C {devices/lab_pin.sym} 118600 -41460 0 1 {name=p117256 lab=_69111_/Y }
C {sky130_stdcells/nor2_4.sym} 118540 -41460 0 0 {name=X_69111_ }
C {devices/lab_pin.sym} 118480 -41340 0 0 {name=p117257 lab=_64923_/A }
C {devices/lab_pin.sym} 118480 -41300 0 0 {name=p117258 lab=_74234_/B }
C {devices/lab_pin.sym} 118600 -41320 0 1 {name=p117259 lab=_66323_/X }
C {sky130_stdcells/and2_4.sym} 118540 -41320 0 0 {name=X_66323_ }
C {devices/lab_pin.sym} 118480 -41210 0 0 {name=p117260 lab=_78309_/A }
C {devices/lab_pin.sym} 118480 -41170 0 0 {name=p117261 lab=_78309_/B }
C {devices/lab_pin.sym} 118480 -41130 0 0 {name=p117262 lab=_78309_/C }
C {devices/lab_pin.sym} 118600 -41170 0 1 {name=p117263 lab=_78309_/Y }
C {sky130_stdcells/nand3_4.sym} 118540 -41170 0 0 {name=X_78309_ }
C {devices/lab_pin.sym} 118480 -41040 0 0 {name=p117264 lab=_63523_/A }
C {devices/lab_pin.sym} 118480 -41000 0 0 {name=p117265 lab=_61954_/X }
C {devices/lab_pin.sym} 118600 -41020 0 1 {name=p117266 lab=_63535_/X }
C {sky130_stdcells/and2_4.sym} 118540 -41020 0 0 {name=X_63535_ }
C {devices/lab_pin.sym} 118480 -40900 0 0 {name=p117267 lab=_48469_/A }
C {devices/lab_pin.sym} 118480 -40860 0 0 {name=p117268 lab=_48763_/B }
C {devices/lab_pin.sym} 118600 -40880 0 1 {name=p117269 lab=_48469_/Y }
C {sky130_stdcells/nand2_4.sym} 118540 -40880 0 0 {name=X_48469_ }
C {devices/lab_pin.sym} 118460 -40790 0 0 {name=p117270 lab=_61075_/C }
C {devices/lab_pin.sym} 118460 -40750 0 0 {name=p117271 lab=_60694_/Y }
C {devices/lab_pin.sym} 118460 -40710 0 0 {name=p117272 lab=_60031_/X }
C {devices/lab_pin.sym} 118460 -40670 0 0 {name=p117273 lab=_60629_/Y }
C {devices/lab_pin.sym} 118460 -40640 0 0 {name=p117274 lab=_60746_/Y }
C {devices/lab_pin.sym} 118620 -40710 0 1 {name=p117275 lab=_60747_/Y }
C {sky130_stdcells/a41oi_4.sym} 118540 -40710 0 0 {name=X_60747_ }
C {devices/lab_pin.sym} 118480 -40560 0 0 {name=p117276 lab=_79287_/X }
C {devices/lab_pin.sym} 118480 -40520 0 0 {name=p117277 lab=_79288_/X }
C {devices/lab_pin.sym} 118600 -40540 0 1 {name=p117278 lab=_79304_/B }
C {sky130_stdcells/xnor2_4.sym} 118540 -40540 0 0 {name=X_79289_ }
C {devices/lab_pin.sym} 118500 -40410 0 0 {name=p117279 lab=clkbuf_9_285_0_CLK/X }
C {devices/lab_pin.sym} 118580 -40410 0 1 {name=p117280 lab=_87110_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 118540 -40410 0 0 {name=Xclkbuf_10_571_0_CLK }
C {devices/lab_pin.sym} 118500 -40290 0 0 {name=p117281 lab=clkbuf_6_63_0_CLK/A }
C {devices/lab_pin.sym} 118580 -40290 0 1 {name=p117282 lab=clkbuf_6_62_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 118540 -40290 0 0 {name=Xclkbuf_6_62_0_CLK }
C {devices/lab_pin.sym} 118500 -40170 0 0 {name=p117283 lab=_50500_/A }
C {devices/lab_pin.sym} 118580 -40170 0 1 {name=p117284 lab=_50575_/A }
C {sky130_stdcells/buf_2.sym} 118540 -40170 0 0 {name=X_50500_ }
C {devices/lab_pin.sym} 118450 -40050 0 0 {name=p117285 lab=_81346_/CLK }
C {devices/lab_pin.sym} 118450 -40030 0 0 {name=p117286 lab=_81320_/D }
C {devices/lab_pin.sym} 118630 -40050 0 1 {name=p117287 lab=_81728_/D }
C {sky130_stdcells/dfxtp_4.sym} 118540 -40040 0 0 {name=X_81320_ }
C {devices/lab_pin.sym} 118480 -39920 0 0 {name=p117288 lab=_69021_/A }
C {devices/lab_pin.sym} 118480 -39880 0 0 {name=p117289 lab=_69042_/B }
C {devices/lab_pin.sym} 118600 -39900 0 1 {name=p117290 lab=_69042_/X }
C {sky130_stdcells/and2_4.sym} 118540 -39900 0 0 {name=X_69042_ }
C {devices/lab_pin.sym} 118460 -39790 0 0 {name=p117291 lab=_66250_/X }
C {devices/lab_pin.sym} 118460 -39750 0 0 {name=p117292 lab=_66253_/X }
C {devices/lab_pin.sym} 118460 -39710 0 0 {name=p117293 lab=_66240_/X }
C {devices/lab_pin.sym} 118620 -39750 0 1 {name=p117294 lab=_66254_/X }
C {sky130_stdcells/a21o_4.sym} 118540 -39750 0 0 {name=X_66254_ }
C {devices/lab_pin.sym} 118460 -39630 0 0 {name=p117295 lab=_51476_/Y }
C {devices/lab_pin.sym} 118460 -39590 0 0 {name=p117296 lab=_51477_/X }
C {devices/lab_pin.sym} 118460 -39550 0 0 {name=p117297 lab=_51479_/X }
C {devices/lab_pin.sym} 118620 -39590 0 1 {name=p117298 lab=_86003_/D }
C {sky130_stdcells/a21oi_4.sym} 118540 -39590 0 0 {name=X_51480_ }
C {devices/lab_pin.sym} 118460 -39490 0 0 {name=p117299 lab=_63434_/X }
C {devices/lab_pin.sym} 118460 -39450 0 0 {name=p117300 lab=_63459_/X }
C {devices/lab_pin.sym} 118460 -39410 0 0 {name=p117301 lab=_63460_/X }
C {devices/lab_pin.sym} 118460 -39370 0 0 {name=p117302 lab=_63464_/X }
C {devices/lab_pin.sym} 118460 -39330 0 0 {name=p117303 lab=_63465_/Y }
C {devices/lab_pin.sym} 118620 -39410 0 1 {name=p117304 lab=_63466_/Y }
C {sky130_stdcells/o41ai_4.sym} 118540 -39410 0 0 {name=X_63466_ }
C {devices/lab_pin.sym} 118500 -39250 0 0 {name=p117305 lab=_63478_/A }
C {devices/lab_pin.sym} 118580 -39250 0 1 {name=p117306 lab=_63416_/A }
C {sky130_stdcells/buf_2.sym} 118540 -39250 0 0 {name=X_60678_ }
C {devices/lab_pin.sym} 118460 -39150 0 0 {name=p117307 lab=_65202_/X }
C {devices/lab_pin.sym} 118460 -39110 0 0 {name=p117308 lab=_65204_/X }
C {devices/lab_pin.sym} 118460 -39070 0 0 {name=p117309 lab=_65122_/X }
C {devices/lab_pin.sym} 118620 -39110 0 1 {name=p117310 lab=_65208_/A }
C {sky130_stdcells/a21o_4.sym} 118540 -39110 0 0 {name=X_65205_ }
C {devices/lab_pin.sym} 118460 -38990 0 0 {name=p117311 lab=_50428_/Y }
C {devices/lab_pin.sym} 118460 -38950 0 0 {name=p117312 lab=_50429_/X }
C {devices/lab_pin.sym} 118460 -38910 0 0 {name=p117313 lab=_50430_/X }
C {devices/lab_pin.sym} 118620 -38950 0 1 {name=p117314 lab=_86202_/D }
C {sky130_stdcells/a21oi_4.sym} 118540 -38950 0 0 {name=X_50431_ }
C {devices/lab_pin.sym} 118500 -38810 0 0 {name=p117315 lab=_62236_/A }
C {devices/lab_pin.sym} 118580 -38810 0 1 {name=p117316 lab=_62472_/B }
C {sky130_stdcells/buf_2.sym} 118540 -38810 0 0 {name=X_62417_ }
C {devices/lab_pin.sym} 118450 -38690 0 0 {name=p117317 lab=_81794_/CLK }
C {devices/lab_pin.sym} 118450 -38670 0 0 {name=p117318 lab=_81283_/Q }
C {devices/lab_pin.sym} 118630 -38690 0 1 {name=p117319 lab=_76159_/A }
C {sky130_stdcells/dfxtp_4.sym} 118540 -38680 0 0 {name=X_81251_ }
C {devices/lab_pin.sym} 118460 -38570 0 0 {name=p117320 lab=_66182_/X }
C {devices/lab_pin.sym} 118460 -38530 0 0 {name=p117321 lab=_66184_/X }
C {devices/lab_pin.sym} 118460 -38490 0 0 {name=p117322 lab=_66057_/X }
C {devices/lab_pin.sym} 118620 -38530 0 1 {name=p117323 lab=_66185_/X }
C {sky130_stdcells/a21o_4.sym} 118540 -38530 0 0 {name=X_66185_ }
C {devices/lab_pin.sym} 118460 -38420 0 0 {name=p117324 lab=_58415_/A }
C {devices/lab_pin.sym} 118460 -38380 0 0 {name=p117325 lab=_63370_/X }
C {devices/lab_pin.sym} 118460 -38340 0 0 {name=p117326 lab=_61367_/A }
C {devices/lab_pin.sym} 118460 -38300 0 0 {name=p117327 lab=_63372_/X }
C {devices/lab_pin.sym} 118620 -38360 0 1 {name=p117328 lab=_63397_/X }
C {sky130_stdcells/a2bb2o_4.sym} 118540 -38360 0 0 {name=X_63397_ }
C {devices/lab_pin.sym} 118480 -38220 0 0 {name=p117329 lab=_80197_/Y }
C {devices/lab_pin.sym} 118480 -38180 0 0 {name=p117330 lab=_80201_/Y }
C {devices/lab_pin.sym} 118600 -38200 0 1 {name=p117331 lab=_80202_/X }
C {sky130_stdcells/xor2_4.sym} 118540 -38200 0 0 {name=X_80202_ }
C {devices/lab_pin.sym} 118500 -38070 0 0 {name=p117332 lab=_53097_/X }
C {devices/lab_pin.sym} 118580 -38070 0 1 {name=p117333 lab=_53159_/B }
C {sky130_stdcells/buf_2.sym} 118540 -38070 0 0 {name=X_53150_ }
C {devices/lab_pin.sym} 118500 -37950 0 0 {name=p117334 lab=_65782_/A }
C {devices/lab_pin.sym} 118580 -37950 0 1 {name=p117335 lab=_65164_/A }
C {sky130_stdcells/buf_2.sym} 118540 -37950 0 0 {name=X_65136_ }
C {devices/lab_pin.sym} 118500 -37830 0 0 {name=p117336 lab=_50655_/A }
C {devices/lab_pin.sym} 118580 -37830 0 1 {name=p117337 lab=_50594_/A }
C {sky130_stdcells/buf_2.sym} 118540 -37830 0 0 {name=X_50362_ }
C {devices/lab_pin.sym} 118500 -37710 0 0 {name=p117338 lab=clkbuf_9_293_0_CLK/X }
C {devices/lab_pin.sym} 118580 -37710 0 1 {name=p117339 lab=_80746_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 118540 -37710 0 0 {name=Xclkbuf_10_586_0_CLK }
C {devices/lab_pin.sym} 118480 -37620 0 0 {name=p117340 lab=_61440_/A }
C {devices/lab_pin.sym} 118480 -37580 0 0 {name=p117341 lab=_62247_/X }
C {devices/lab_pin.sym} 118480 -37540 0 0 {name=p117342 lab=_62259_/X }
C {devices/lab_pin.sym} 118480 -37500 0 0 {name=p117343 lab=_62631_/D }
C {devices/lab_pin.sym} 118600 -37560 0 1 {name=p117344 lab=_62351_/B }
C {sky130_stdcells/nand4_4.sym} 118540 -37560 0 0 {name=X_62348_ }
C {devices/lab_pin.sym} 118450 -37410 0 0 {name=p117345 lab=_81182_/CLK }
C {devices/lab_pin.sym} 118450 -37390 0 0 {name=p117346 lab=_75053_/X }
C {devices/lab_pin.sym} 118630 -37410 0 1 {name=p117347 lab=_81182_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -37400 0 0 {name=X_81182_ }
C {devices/lab_pin.sym} 118460 -37290 0 0 {name=p117348 lab=_65439_/B }
C {devices/lab_pin.sym} 118460 -37250 0 0 {name=p117349 lab=_52089_/X }
C {devices/lab_pin.sym} 118460 -37210 0 0 {name=p117350 lab=_52100_/Y }
C {devices/lab_pin.sym} 118620 -37250 0 1 {name=p117351 lab=_52101_/Y }
C {sky130_stdcells/o21ai_4.sym} 118540 -37250 0 0 {name=X_52101_ }
C {devices/lab_pin.sym} 118480 -37120 0 0 {name=p117352 lab=_60051_/C }
C {devices/lab_pin.sym} 118480 -37080 0 0 {name=p117353 lab=_80133_/B }
C {devices/lab_pin.sym} 118600 -37100 0 1 {name=p117354 lab=_80141_/B }
C {sky130_stdcells/xor2_4.sym} 118540 -37100 0 0 {name=X_80133_ }
C {devices/lab_pin.sym} 118460 -36990 0 0 {name=p117355 lab=_85700_/Q }
C {devices/lab_pin.sym} 118460 -36950 0 0 {name=p117356 lab=_53065_/X }
C {devices/lab_pin.sym} 118460 -36910 0 0 {name=p117357 lab=_53080_/Y }
C {devices/lab_pin.sym} 118620 -36950 0 1 {name=p117358 lab=_53081_/Y }
C {sky130_stdcells/o21ai_4.sym} 118540 -36950 0 0 {name=X_53081_ }
C {devices/lab_pin.sym} 118460 -36840 0 0 {name=p117359 lab=_65065_/X }
C {devices/lab_pin.sym} 118460 -36800 0 0 {name=p117360 lab=_83296_/Q }
C {devices/lab_pin.sym} 118460 -36760 0 0 {name=p117361 lab=_64991_/X }
C {devices/lab_pin.sym} 118460 -36720 0 0 {name=p117362 lab=_65066_/X }
C {devices/lab_pin.sym} 118620 -36780 0 1 {name=p117363 lab=_65067_/X }
C {sky130_stdcells/a211o_4.sym} 118540 -36780 0 0 {name=X_65067_ }
C {devices/lab_pin.sym} 118480 -36640 0 0 {name=p117364 lab=_69906_/A }
C {devices/lab_pin.sym} 118480 -36600 0 0 {name=p117365 lab=_73487_/A }
C {devices/lab_pin.sym} 118600 -36620 0 1 {name=p117366 lab=_69944_/X }
C {sky130_stdcells/and2_4.sym} 118540 -36620 0 0 {name=X_69944_ }
C {devices/lab_pin.sym} 118480 -36500 0 0 {name=p117367 lab=_50285_/A }
C {devices/lab_pin.sym} 118480 -36460 0 0 {name=p117368 lab=_50293_/B }
C {devices/lab_pin.sym} 118600 -36480 0 1 {name=p117369 lab=_50293_/Y }
C {sky130_stdcells/nand2_4.sym} 118540 -36480 0 0 {name=X_50293_ }
C {devices/lab_pin.sym} 118500 -36350 0 0 {name=p117370 lab=_62475_/A }
C {devices/lab_pin.sym} 118580 -36350 0 1 {name=p117371 lab=_62280_/D }
C {sky130_stdcells/buf_2.sym} 118540 -36350 0 0 {name=X_62279_ }
C {devices/lab_pin.sym} 118450 -36230 0 0 {name=p117372 lab=_85990_/CLK }
C {devices/lab_pin.sym} 118450 -36210 0 0 {name=p117373 lab=_85990_/D }
C {devices/lab_pin.sym} 118630 -36230 0 1 {name=p117374 lab=_85990_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -36220 0 0 {name=X_85990_ }
C {devices/lab_pin.sym} 118460 -36110 0 0 {name=p117375 lab=_85902_/Q }
C {devices/lab_pin.sym} 118460 -36070 0 0 {name=p117376 lab=_52013_/X }
C {devices/lab_pin.sym} 118460 -36030 0 0 {name=p117377 lab=_52031_/Y }
C {devices/lab_pin.sym} 118620 -36070 0 1 {name=p117378 lab=_52032_/Y }
C {sky130_stdcells/o21ai_4.sym} 118540 -36070 0 0 {name=X_52032_ }
C {devices/lab_pin.sym} 118480 -35960 0 0 {name=p117379 lab=_61997_/X }
C {devices/lab_pin.sym} 118480 -35920 0 0 {name=p117380 lab=_63955_/X }
C {devices/lab_pin.sym} 118480 -35880 0 0 {name=p117381 lab=_64050_/C }
C {devices/lab_pin.sym} 118480 -35840 0 0 {name=p117382 lab=_64033_/D }
C {devices/lab_pin.sym} 118600 -35900 0 1 {name=p117383 lab=_64018_/Y }
C {sky130_stdcells/nand4_4.sym} 118540 -35900 0 0 {name=X_64018_ }
C {devices/lab_pin.sym} 118450 -35750 0 0 {name=p117384 lab=_86322_/CLK }
C {devices/lab_pin.sym} 118450 -35730 0 0 {name=p117385 lab=_84941_/D }
C {devices/lab_pin.sym} 118630 -35750 0 1 {name=p117386 lab=_84941_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -35740 0 0 {name=X_84941_ }
C {devices/lab_pin.sym} 118460 -35630 0 0 {name=p117387 lab=_80056_/B }
C {devices/lab_pin.sym} 118460 -35590 0 0 {name=p117388 lab=_80073_/B }
C {devices/lab_pin.sym} 118460 -35550 0 0 {name=p117389 lab=_80063_/X }
C {devices/lab_pin.sym} 118620 -35590 0 1 {name=p117390 lab=_80064_/Y }
C {sky130_stdcells/a21boi_4.sym} 118540 -35590 0 0 {name=X_80064_ }
C {devices/lab_pin.sym} 118460 -35480 0 0 {name=p117391 lab=_73341_/A }
C {devices/lab_pin.sym} 118460 -35440 0 0 {name=p117392 lab=_68467_/X }
C {devices/lab_pin.sym} 118460 -35400 0 0 {name=p117393 lab=_68385_/X }
C {devices/lab_pin.sym} 118460 -35360 0 0 {name=p117394 lab=_69874_/Y }
C {devices/lab_pin.sym} 118620 -35420 0 1 {name=p117395 lab=_69875_/X }
C {sky130_stdcells/a211o_4.sym} 118540 -35420 0 0 {name=X_69875_ }
C {devices/lab_pin.sym} 118460 -35300 0 0 {name=p117396 lab=_56764_/B }
C {devices/lab_pin.sym} 118460 -35260 0 0 {name=p117397 lab=_56829_/X }
C {devices/lab_pin.sym} 118460 -35220 0 0 {name=p117398 lab=_56830_/Y }
C {devices/lab_pin.sym} 118460 -35180 0 0 {name=p117399 lab=_56839_/Y }
C {devices/lab_pin.sym} 118620 -35240 0 1 {name=p117400 lab=_56841_/A }
C {sky130_stdcells/a211o_4.sym} 118540 -35240 0 0 {name=X_56840_ }
C {devices/lab_pin.sym} 118480 -35100 0 0 {name=p117401 lab=_69735_/A }
C {devices/lab_pin.sym} 118480 -35060 0 0 {name=p117402 lab=_68826_/B }
C {devices/lab_pin.sym} 118600 -35080 0 1 {name=p117403 lab=_68826_/Y }
C {sky130_stdcells/nor2_4.sym} 118540 -35080 0 0 {name=X_68826_ }
C {devices/lab_pin.sym} 118450 -34950 0 0 {name=p117404 lab=_86935_/CLK }
C {devices/lab_pin.sym} 118450 -34930 0 0 {name=p117405 lab=_87660_/D }
C {devices/lab_pin.sym} 118630 -34950 0 1 {name=p117406 lab=_87660_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -34940 0 0 {name=X_87660_ }
C {devices/lab_pin.sym} 118450 -34810 0 0 {name=p117407 lab=_84823_/CLK }
C {devices/lab_pin.sym} 118450 -34790 0 0 {name=p117408 lab=_58349_/X }
C {devices/lab_pin.sym} 118630 -34810 0 1 {name=p117409 lab=_84872_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -34800 0 0 {name=X_84872_ }
C {devices/lab_pin.sym} 118450 -34670 0 0 {name=p117410 lab=_86611_/CLK }
C {devices/lab_pin.sym} 118450 -34650 0 0 {name=p117411 lab=_86611_/D }
C {devices/lab_pin.sym} 118630 -34670 0 1 {name=p117412 lab=_72295_/A }
C {sky130_stdcells/dfxtp_4.sym} 118540 -34660 0 0 {name=X_86611_ }
C {devices/lab_pin.sym} 118450 -34530 0 0 {name=p117413 lab=_83787_/CLK }
C {devices/lab_pin.sym} 118450 -34510 0 0 {name=p117414 lab=_70252_/X }
C {devices/lab_pin.sym} 118630 -34530 0 1 {name=p117415 lab=_74790_/B }
C {sky130_stdcells/dfxtp_4.sym} 118540 -34520 0 0 {name=X_83823_ }
C {devices/lab_pin.sym} 118460 -34430 0 0 {name=p117416 lab=_56730_/X }
C {devices/lab_pin.sym} 118460 -34390 0 0 {name=p117417 lab=_56766_/X }
C {devices/lab_pin.sym} 118460 -34350 0 0 {name=p117418 lab=_56767_/X }
C {devices/lab_pin.sym} 118460 -34310 0 0 {name=p117419 lab=_57163_/C }
C {devices/lab_pin.sym} 118460 -34280 0 0 {name=p117420 lab=_57010_/A }
C {devices/lab_pin.sym} 118620 -34350 0 1 {name=p117421 lab=_56771_/X }
C {sky130_stdcells/a41o_4.sym} 118540 -34350 0 0 {name=X_56771_ }
C {devices/lab_pin.sym} 118500 -34190 0 0 {name=p117422 lab=_68757_/A }
C {devices/lab_pin.sym} 118580 -34190 0 1 {name=p117423 lab=_68757_/X }
C {sky130_stdcells/buf_2.sym} 118540 -34190 0 0 {name=X_68757_ }
C {devices/lab_pin.sym} 118450 -34070 0 0 {name=p117424 lab=_88111_/CLK }
C {devices/lab_pin.sym} 118450 -34050 0 0 {name=p117425 lab=_87591_/D }
C {devices/lab_pin.sym} 118630 -34070 0 1 {name=p117426 lab=_73845_/A }
C {sky130_stdcells/dfxtp_4.sym} 118540 -34060 0 0 {name=X_87591_ }
C {devices/lab_pin.sym} 118480 -33940 0 0 {name=p117427 lab=_53978_/A }
C {devices/lab_pin.sym} 118480 -33900 0 0 {name=p117428 lab=_53983_/B }
C {devices/lab_pin.sym} 118600 -33920 0 1 {name=p117429 lab=_53983_/Y }
C {sky130_stdcells/nand2_4.sym} 118540 -33920 0 0 {name=X_53983_ }
C {devices/lab_pin.sym} 118500 -33790 0 0 {name=p117430 lab=_65969_/A }
C {devices/lab_pin.sym} 118580 -33790 0 1 {name=p117431 lab=_65970_/A }
C {sky130_stdcells/buf_2.sym} 118540 -33790 0 0 {name=X_65969_ }
C {devices/lab_pin.sym} 118500 -33670 0 0 {name=p117432 lab=_58510_/A }
C {devices/lab_pin.sym} 118580 -33670 0 1 {name=p117433 lab=_58510_/X }
C {sky130_stdcells/buf_2.sym} 118540 -33670 0 0 {name=X_58510_ }
C {devices/lab_pin.sym} 118480 -33560 0 0 {name=p117434 lab=_55245_/A }
C {devices/lab_pin.sym} 118480 -33520 0 0 {name=p117435 lab=_55722_/B }
C {devices/lab_pin.sym} 118600 -33540 0 1 {name=p117436 lab=_55722_/X }
C {sky130_stdcells/and2_4.sym} 118540 -33540 0 0 {name=X_55722_ }
C {devices/lab_pin.sym} 118460 -33440 0 0 {name=p117437 lab=_86960_/Q }
C {devices/lab_pin.sym} 118460 -33400 0 0 {name=p117438 lab=_67706_/X }
C {devices/lab_pin.sym} 118460 -33360 0 0 {name=p117439 lab=_67633_/X }
C {devices/lab_pin.sym} 118460 -33320 0 0 {name=p117440 lab=_67707_/X }
C {devices/lab_pin.sym} 118620 -33380 0 1 {name=p117441 lab=_67708_/X }
C {sky130_stdcells/a211o_4.sym} 118540 -33380 0 0 {name=X_67708_ }
C {devices/lab_pin.sym} 118450 -33230 0 0 {name=p117442 lab=_86222_/CLK }
C {devices/lab_pin.sym} 118450 -33210 0 0 {name=p117443 lab=_86542_/D }
C {devices/lab_pin.sym} 118630 -33230 0 1 {name=p117444 lab=_86542_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -33220 0 0 {name=X_86542_ }
C {devices/lab_pin.sym} 118480 -33120 0 0 {name=p117445 lab=_52922_/A }
C {devices/lab_pin.sym} 118480 -33080 0 0 {name=p117446 lab=_52954_/B }
C {devices/lab_pin.sym} 118480 -33040 0 0 {name=p117447 lab=_52926_/X }
C {devices/lab_pin.sym} 118480 -33000 0 0 {name=p117448 lab=_52934_/D }
C {devices/lab_pin.sym} 118600 -33060 0 1 {name=p117449 lab=_52934_/X }
C {sky130_stdcells/and4_4.sym} 118540 -33060 0 0 {name=X_52934_ }
C {devices/lab_pin.sym} 118450 -32910 0 0 {name=p117450 lab=_83421_/CLK }
C {devices/lab_pin.sym} 118450 -32890 0 0 {name=p117451 lab=_70527_/Y }
C {devices/lab_pin.sym} 118630 -32910 0 1 {name=p117452 lab=_57682_/A }
C {sky130_stdcells/dfxtp_4.sym} 118540 -32900 0 0 {name=X_83754_ }
C {devices/lab_pin.sym} 118480 -32780 0 0 {name=p117453 lab=_63396_/B }
C {devices/lab_pin.sym} 118480 -32740 0 0 {name=p117454 lab=_58532_/X }
C {devices/lab_pin.sym} 118600 -32760 0 1 {name=p117455 lab=_59490_/Y }
C {sky130_stdcells/nor2_4.sym} 118540 -32760 0 0 {name=X_59490_ }
C {devices/lab_pin.sym} 118500 -32630 0 0 {name=p117456 lab=clkbuf_9_262_0_CLK/X }
C {devices/lab_pin.sym} 118580 -32630 0 1 {name=p117457 lab=_84049_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 118540 -32630 0 0 {name=Xclkbuf_10_524_0_CLK }
C {devices/lab_pin.sym} 118460 -32530 0 0 {name=p117458 lab=_68685_/X }
C {devices/lab_pin.sym} 118460 -32490 0 0 {name=p117459 lab=_68687_/X }
C {devices/lab_pin.sym} 118460 -32450 0 0 {name=p117460 lab=_68661_/X }
C {devices/lab_pin.sym} 118620 -32490 0 1 {name=p117461 lab=_68688_/Y }
C {sky130_stdcells/a21oi_4.sym} 118540 -32490 0 0 {name=X_68688_ }
C {devices/lab_pin.sym} 118450 -32350 0 0 {name=p117462 lab=_80821_/CLK }
C {devices/lab_pin.sym} 118450 -32330 0 0 {name=p117463 lab=_80966_/D }
C {devices/lab_pin.sym} 118630 -32350 0 1 {name=p117464 lab=_75424_/B }
C {sky130_stdcells/dfxtp_4.sym} 118540 -32340 0 0 {name=X_80966_ }
C {devices/lab_pin.sym} 118500 -32210 0 0 {name=p117465 lab=clkbuf_5_7_0_CLK/X }
C {devices/lab_pin.sym} 118580 -32210 0 1 {name=p117466 lab=clkbuf_7_31_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 118540 -32210 0 0 {name=Xclkbuf_6_15_0_CLK }
C {devices/lab_pin.sym} 118500 -32090 0 0 {name=p117467 lab=_58440_/Y }
C {devices/lab_pin.sym} 118580 -32090 0 1 {name=p117468 lab=_58442_/A }
C {sky130_stdcells/buf_2.sym} 118540 -32090 0 0 {name=X_58441_ }
C {devices/lab_pin.sym} 118450 -31970 0 0 {name=p117469 lab=_82624_/CLK }
C {devices/lab_pin.sym} 118450 -31950 0 0 {name=p117470 lab=_82705_/D }
C {devices/lab_pin.sym} 118630 -31970 0 1 {name=p117471 lab=_82661_/D }
C {sky130_stdcells/dfxtp_4.sym} 118540 -31960 0 0 {name=X_82705_ }
C {devices/lab_pin.sym} 118480 -31840 0 0 {name=p117472 lab=_55288_/B }
C {devices/lab_pin.sym} 118480 -31800 0 0 {name=p117473 lab=_55288_/A }
C {devices/lab_pin.sym} 118600 -31820 0 1 {name=p117474 lab=_55654_/A }
C {sky130_stdcells/and2_4.sym} 118540 -31820 0 0 {name=X_55653_ }
C {devices/lab_pin.sym} 118460 -31720 0 0 {name=p117475 lab=_67522_/X }
C {devices/lab_pin.sym} 118460 -31680 0 0 {name=p117476 lab=_67623_/Y }
C {devices/lab_pin.sym} 118460 -31640 0 0 {name=p117477 lab=_67624_/X }
C {devices/lab_pin.sym} 118460 -31600 0 0 {name=p117478 lab=_67638_/Y }
C {devices/lab_pin.sym} 118620 -31660 0 1 {name=p117479 lab=_67639_/X }
C {sky130_stdcells/a211o_4.sym} 118540 -31660 0 0 {name=X_67639_ }
C {devices/lab_pin.sym} 118450 -31510 0 0 {name=p117480 lab=_86473_/CLK }
C {devices/lab_pin.sym} 118450 -31490 0 0 {name=p117481 lab=_86473_/D }
C {devices/lab_pin.sym} 118630 -31510 0 1 {name=p117482 lab=_86473_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -31500 0 0 {name=X_86473_ }
C {devices/lab_pin.sym} 118500 -31370 0 0 {name=p117483 lab=_52783_/A }
C {devices/lab_pin.sym} 118580 -31370 0 1 {name=p117484 lab=_52865_/X }
C {sky130_stdcells/buf_2.sym} 118540 -31370 0 0 {name=X_52865_ }
C {devices/lab_pin.sym} 118450 -31250 0 0 {name=p117485 lab=_83685_/CLK }
C {devices/lab_pin.sym} 118450 -31230 0 0 {name=p117486 lab=_70845_/Y }
C {devices/lab_pin.sym} 118630 -31250 0 1 {name=p117487 lab=_83685_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -31240 0 0 {name=X_83685_ }
C {devices/lab_pin.sym} 118450 -31110 0 0 {name=p117488 lab=_81990_/CLK }
C {devices/lab_pin.sym} 118450 -31090 0 0 {name=p117489 lab=_80897_/D }
C {devices/lab_pin.sym} 118630 -31110 0 1 {name=p117490 lab=_80897_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -31100 0 0 {name=X_80897_ }
C {devices/lab_pin.sym} 118450 -30970 0 0 {name=p117491 lab=_88201_/CLK }
C {devices/lab_pin.sym} 118450 -30950 0 0 {name=p117492 lab=_88212_/D }
C {devices/lab_pin.sym} 118630 -30970 0 1 {name=p117493 lab=_88212_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -30960 0 0 {name=X_88212_ }
C {devices/lab_pin.sym} 118460 -30850 0 0 {name=p117494 lab=_54601_/Y }
C {devices/lab_pin.sym} 118460 -30810 0 0 {name=p117495 lab=_54584_/X }
C {devices/lab_pin.sym} 118460 -30770 0 0 {name=p117496 lab=_54603_/X }
C {devices/lab_pin.sym} 118620 -30810 0 1 {name=p117497 lab=_85412_/D }
C {sky130_stdcells/a21oi_4.sym} 118540 -30810 0 0 {name=X_54604_ }
C {devices/lab_pin.sym} 118450 -30670 0 0 {name=p117498 lab=_85648_/CLK }
C {devices/lab_pin.sym} 118450 -30650 0 0 {name=p117499 lab=_85424_/D }
C {devices/lab_pin.sym} 118630 -30670 0 1 {name=p117500 lab=_85424_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -30660 0 0 {name=X_85424_ }
C {devices/lab_pin.sym} 118460 -30550 0 0 {name=p117501 lab=_51813_/Y }
C {devices/lab_pin.sym} 118460 -30510 0 0 {name=p117502 lab=_51793_/X }
C {devices/lab_pin.sym} 118460 -30470 0 0 {name=p117503 lab=_51815_/X }
C {devices/lab_pin.sym} 118620 -30510 0 1 {name=p117504 lab=_51816_/Y }
C {sky130_stdcells/a21oi_4.sym} 118540 -30510 0 0 {name=X_51816_ }
C {devices/lab_pin.sym} 118460 -30390 0 0 {name=p117505 lab=_53033_/B }
C {devices/lab_pin.sym} 118460 -30350 0 0 {name=p117506 lab=_70632_/X }
C {devices/lab_pin.sym} 118460 -30310 0 0 {name=p117507 lab=_70649_/Y }
C {devices/lab_pin.sym} 118620 -30350 0 1 {name=p117508 lab=_83733_/D }
C {sky130_stdcells/o21ai_4.sym} 118540 -30350 0 0 {name=X_70650_ }
C {devices/lab_pin.sym} 118500 -30210 0 0 {name=p117509 lab=_58372_/A }
C {devices/lab_pin.sym} 118580 -30210 0 1 {name=p117510 lab=_58372_/Y }
C {sky130_stdcells/inv_2.sym} 118540 -30210 0 0 {name=X_58372_ }
C {devices/lab_pin.sym} 118450 -30090 0 0 {name=p117511 lab=_88116_/CLK }
C {devices/lab_pin.sym} 118450 -30070 0 0 {name=p117512 lab=_83988_/Q }
C {devices/lab_pin.sym} 118630 -30090 0 1 {name=p117513 lab=_82636_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -30080 0 0 {name=X_82636_ }
C {devices/lab_pin.sym} 118500 -29950 0 0 {name=p117514 lab=_55523_/X }
C {devices/lab_pin.sym} 118580 -29950 0 1 {name=p117515 lab=_55610_/A }
C {sky130_stdcells/buf_2.sym} 118540 -29950 0 0 {name=X_55584_ }
C {devices/lab_pin.sym} 118500 -29830 0 0 {name=p117516 lab=_52770_/A }
C {devices/lab_pin.sym} 118580 -29830 0 1 {name=p117517 lab=_52818_/B }
C {sky130_stdcells/buf_2.sym} 118540 -29830 0 0 {name=X_52796_ }
C {sky130_stdcells/decap_3.sym} 118540 -29680 0 0 {name=XPHY_10 }
C {sky130_stdcells/decap_3.sym} 118540 -29500 0 0 {name=XPHY_21 }
C {devices/lab_pin.sym} 118460 -29370 0 0 {name=p117518 lab=_44277_/X }
C {devices/lab_pin.sym} 118460 -29330 0 0 {name=p117519 lab=_57321_/X }
C {devices/lab_pin.sym} 118460 -29290 0 0 {name=p117520 lab=_57322_/Y }
C {devices/lab_pin.sym} 118620 -29330 0 1 {name=p117521 lab=_85035_/D }
C {sky130_stdcells/o21ai_4.sym} 118540 -29330 0 0 {name=X_57323_ }
C {devices/lab_pin.sym} 118480 -29200 0 0 {name=p117522 lab=_69309_/A }
C {devices/lab_pin.sym} 118480 -29160 0 0 {name=p117523 lab=_88295_/Q }
C {devices/lab_pin.sym} 118600 -29180 0 1 {name=p117524 lab=_69309_/X }
C {sky130_stdcells/and2_4.sym} 118540 -29180 0 0 {name=X_69309_ }
C {devices/lab_pin.sym} 118450 -29050 0 0 {name=p117525 lab=_86834_/CLK }
C {devices/lab_pin.sym} 118450 -29030 0 0 {name=p117526 lab=_88143_/D }
C {devices/lab_pin.sym} 118630 -29050 0 1 {name=p117527 lab=_66683_/B }
C {sky130_stdcells/dfxtp_4.sym} 118540 -29040 0 0 {name=X_88143_ }
C {devices/lab_pin.sym} 118500 -28910 0 0 {name=p117528 lab=clkbuf_9_269_0_CLK/X }
C {devices/lab_pin.sym} 118580 -28910 0 1 {name=p117529 lab=_84014_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 118540 -28910 0 0 {name=Xclkbuf_10_539_0_CLK }
C {devices/lab_pin.sym} 118500 -28790 0 0 {name=p117530 lab=_54481_/A }
C {devices/lab_pin.sym} 118580 -28790 0 1 {name=p117531 lab=_54538_/A }
C {sky130_stdcells/buf_2.sym} 118540 -28790 0 0 {name=X_54535_ }
C {devices/lab_pin.sym} 118450 -28670 0 0 {name=p117532 lab=_86282_/CLK }
C {devices/lab_pin.sym} 118450 -28650 0 0 {name=p117533 lab=_85355_/D }
C {devices/lab_pin.sym} 118630 -28670 0 1 {name=p117534 lab=_85355_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -28660 0 0 {name=X_85355_ }
C {sky130_stdcells/decap_3.sym} 118540 -28500 0 0 {name=XPHY_32 }
C {devices/lab_pin.sym} 118500 -28350 0 0 {name=p117535 lab=clkbuf_2_1_0_CLK/A }
C {devices/lab_pin.sym} 118580 -28350 0 1 {name=p117536 lab=clkbuf_2_0_1_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 118540 -28350 0 0 {name=Xclkbuf_2_0_0_CLK }
C {devices/lab_pin.sym} 118500 -28230 0 0 {name=p117537 lab=_51747_/A }
C {devices/lab_pin.sym} 118580 -28230 0 1 {name=p117538 lab=_51768_/A }
C {sky130_stdcells/buf_2.sym} 118540 -28230 0 0 {name=X_51747_ }
C {devices/lab_pin.sym} 118500 -28110 0 0 {name=p117539 lab=_74731_/A }
C {devices/lab_pin.sym} 118580 -28110 0 1 {name=p117540 lab=_71735_/A }
C {sky130_stdcells/buf_2.sym} 118540 -28110 0 0 {name=X_70581_ }
C {devices/lab_pin.sym} 118450 -27990 0 0 {name=p117541 lab=_82879_/CLK }
C {devices/lab_pin.sym} 118450 -27970 0 0 {name=p117542 lab=_82567_/D }
C {devices/lab_pin.sym} 118630 -27990 0 1 {name=p117543 lab=_82567_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -27980 0 0 {name=X_82567_ }
C {sky130_stdcells/decap_3.sym} 118540 -27820 0 0 {name=XPHY_43 }
C {sky130_stdcells/decap_3.sym} 118540 -27640 0 0 {name=XPHY_54 }
C {devices/lab_pin.sym} 118500 -27490 0 0 {name=p117544 lab=_41500_/A }
C {devices/lab_pin.sym} 118580 -27490 0 1 {name=p117545 lab=_41500_/Y }
C {sky130_stdcells/inv_2.sym} 118540 -27490 0 0 {name=X_41500_ }
C {devices/lab_pin.sym} 118480 -27380 0 0 {name=p117546 lab=_86609_/Q }
C {devices/lab_pin.sym} 118480 -27340 0 0 {name=p117547 lab=_72332_/B }
C {devices/lab_pin.sym} 118600 -27360 0 1 {name=p117548 lab=_72320_/Y }
C {sky130_stdcells/nor2_4.sym} 118540 -27360 0 0 {name=X_72320_ }
C {sky130_stdcells/decap_3.sym} 118540 -27200 0 0 {name=XPHY_65 }
C {devices/lab_pin.sym} 118450 -27050 0 0 {name=p117549 lab=_84358_/CLK }
C {devices/lab_pin.sym} 118450 -27030 0 0 {name=p117550 lab=_63647_/Y }
C {devices/lab_pin.sym} 118630 -27050 0 1 {name=p117551 lab=_80379_/B }
C {sky130_stdcells/dfxtp_4.sym} 118540 -27040 0 0 {name=X_84306_ }
C {devices/lab_pin.sym} 118480 -26930 0 0 {name=p117552 lab=_57359_/A }
C {devices/lab_pin.sym} 118480 -26890 0 0 {name=p117553 lab=_57254_/B }
C {devices/lab_pin.sym} 118480 -26850 0 0 {name=p117554 lab=_57249_/X }
C {devices/lab_pin.sym} 118600 -26890 0 1 {name=p117555 lab=_57254_/Y }
C {sky130_stdcells/nor3_4.sym} 118540 -26890 0 0 {name=X_57254_ }
C {sky130_stdcells/decap_3.sym} 118540 -26720 0 0 {name=XPHY_76 }
C {devices/lab_pin.sym} 118450 -26570 0 0 {name=p117556 lab=_88175_/CLK }
C {devices/lab_pin.sym} 118450 -26550 0 0 {name=p117557 lab=_81518_/D }
C {devices/lab_pin.sym} 118630 -26570 0 1 {name=p117558 lab=_81518_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -26560 0 0 {name=X_81518_ }
C {devices/lab_pin.sym} 118500 -26430 0 0 {name=p117559 lab=_42612_/A }
C {devices/lab_pin.sym} 118580 -26430 0 1 {name=p117560 lab=_42480_/X }
C {sky130_stdcells/buf_2.sym} 118540 -26430 0 0 {name=X_42480_ }
C {devices/lab_pin.sym} 118450 -26310 0 0 {name=p117561 lab=_87821_/CLK }
C {devices/lab_pin.sym} 118450 -26290 0 0 {name=p117562 lab=_88074_/D }
C {devices/lab_pin.sym} 118630 -26310 0 1 {name=p117563 lab=_88074_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -26300 0 0 {name=X_88074_ }
C {devices/lab_pin.sym} 118500 -26170 0 0 {name=p117564 lab=_54385_/A }
C {devices/lab_pin.sym} 118580 -26170 0 1 {name=p117565 lab=_54471_/B }
C {sky130_stdcells/buf_2.sym} 118540 -26170 0 0 {name=X_54466_ }
C {devices/lab_pin.sym} 118450 -26050 0 0 {name=p117566 lab=_83013_/CLK }
C {devices/lab_pin.sym} 118450 -26030 0 0 {name=p117567 lab=_85286_/D }
C {devices/lab_pin.sym} 118630 -26050 0 1 {name=p117568 lab=_55707_/B }
C {sky130_stdcells/dfxtp_4.sym} 118540 -26040 0 0 {name=X_85286_ }
C {devices/lab_pin.sym} 118460 -25930 0 0 {name=p117569 lab=_85966_/Q }
C {devices/lab_pin.sym} 118460 -25890 0 0 {name=p117570 lab=_51675_/X }
C {devices/lab_pin.sym} 118460 -25850 0 0 {name=p117571 lab=_51677_/Y }
C {devices/lab_pin.sym} 118620 -25890 0 1 {name=p117572 lab=_51678_/Y }
C {sky130_stdcells/o21ai_4.sym} 118540 -25890 0 0 {name=X_51678_ }
C {sky130_stdcells/decap_3.sym} 118540 -25720 0 0 {name=XPHY_87 }
C {devices/lab_pin.sym} 118450 -25570 0 0 {name=p117573 lab=_82498_/CLK }
C {devices/lab_pin.sym} 118450 -25550 0 0 {name=p117574 lab=_82498_/D }
C {devices/lab_pin.sym} 118630 -25570 0 1 {name=p117575 lab=_78314_/A }
C {sky130_stdcells/dfxtp_4.sym} 118540 -25560 0 0 {name=X_82498_ }
C {sky130_stdcells/decap_3.sym} 118540 -25400 0 0 {name=XPHY_98 }
C {devices/lab_pin.sym} 118500 -25250 0 0 {name=p117576 lab=_56123_/A }
C {devices/lab_pin.sym} 118580 -25250 0 1 {name=p117577 lab=_56205_/X }
C {sky130_stdcells/buf_2.sym} 118540 -25250 0 0 {name=X_56205_ }
C {devices/lab_pin.sym} 118450 -25130 0 0 {name=p117578 lab=_87032_/CLK }
C {devices/lab_pin.sym} 118450 -25110 0 0 {name=p117579 lab=_44633_/Y }
C {devices/lab_pin.sym} 118630 -25130 0 1 {name=p117580 lab=_87025_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -25120 0 0 {name=X_87025_ }
C {devices/lab_pin.sym} 118460 -25010 0 0 {name=p117581 lab=_85637_/Q }
C {devices/lab_pin.sym} 118460 -24970 0 0 {name=p117582 lab=_53404_/X }
C {devices/lab_pin.sym} 118460 -24930 0 0 {name=p117583 lab=_53416_/Y }
C {devices/lab_pin.sym} 118620 -24970 0 1 {name=p117584 lab=_53417_/Y }
C {sky130_stdcells/o21ai_4.sym} 118540 -24970 0 0 {name=X_53417_ }
C {devices/lab_pin.sym} 118480 -24840 0 0 {name=p117585 lab=_81734_/Q }
C {devices/lab_pin.sym} 118480 -24800 0 0 {name=p117586 lab=_41435_/B }
C {devices/lab_pin.sym} 118600 -24820 0 1 {name=p117587 lab=_41431_/X }
C {sky130_stdcells/or2_4.sym} 118540 -24820 0 0 {name=X_41431_ }
C {devices/lab_pin.sym} 118480 -24700 0 0 {name=p117588 lab=_72277_/A }
C {devices/lab_pin.sym} 118480 -24660 0 0 {name=p117589 lab=_72251_/B }
C {devices/lab_pin.sym} 118600 -24680 0 1 {name=p117590 lab=_72251_/Y }
C {sky130_stdcells/nor2_4.sym} 118540 -24680 0 0 {name=X_72251_ }
C {devices/lab_pin.sym} 118450 -24550 0 0 {name=p117591 lab=_84590_/CLK }
C {devices/lab_pin.sym} 118450 -24530 0 0 {name=p117592 lab=_84237_/D }
C {devices/lab_pin.sym} 118630 -24550 0 1 {name=p117593 lab=_79568_/B }
C {sky130_stdcells/dfxtp_4.sym} 118540 -24540 0 0 {name=X_84237_ }
C {devices/lab_pin.sym} 118460 -24430 0 0 {name=p117594 lab=_86164_/Q }
C {devices/lab_pin.sym} 118460 -24390 0 0 {name=p117595 lab=_50626_/X }
C {devices/lab_pin.sym} 118460 -24350 0 0 {name=p117596 lab=_50628_/Y }
C {devices/lab_pin.sym} 118620 -24390 0 1 {name=p117597 lab=_50629_/Y }
C {sky130_stdcells/o21ai_4.sym} 118540 -24390 0 0 {name=X_50629_ }
C {devices/lab_pin.sym} 118450 -24250 0 0 {name=p117598 lab=_81575_/CLK }
C {devices/lab_pin.sym} 118450 -24230 0 0 {name=p117599 lab=_76713_/B }
C {devices/lab_pin.sym} 118630 -24250 0 1 {name=p117600 lab=_81449_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -24240 0 0 {name=X_81449_ }
C {devices/lab_pin.sym} 118460 -24130 0 0 {name=p117601 lab=_57183_/X }
C {devices/lab_pin.sym} 118460 -24090 0 0 {name=p117602 lab=_56703_/X }
C {devices/lab_pin.sym} 118460 -24050 0 0 {name=p117603 lab=_57184_/Y }
C {devices/lab_pin.sym} 118620 -24090 0 1 {name=p117604 lab=_57185_/Y }
C {sky130_stdcells/a21oi_4.sym} 118540 -24090 0 0 {name=X_57185_ }
C {devices/lab_pin.sym} 118480 -23960 0 0 {name=p117605 lab=_54378_/A }
C {devices/lab_pin.sym} 118480 -23920 0 0 {name=p117606 lab=_52706_/B }
C {devices/lab_pin.sym} 118600 -23940 0 1 {name=p117607 lab=_54397_/Y }
C {sky130_stdcells/nand2_4.sym} 118540 -23940 0 0 {name=X_54397_ }
C {devices/lab_pin.sym} 118480 -23830 0 0 {name=p117608 lab=_71197_/A }
C {devices/lab_pin.sym} 118480 -23790 0 0 {name=p117609 lab=_71226_/B }
C {devices/lab_pin.sym} 118480 -23750 0 0 {name=p117610 lab=_71197_/C }
C {devices/lab_pin.sym} 118600 -23790 0 1 {name=p117611 lab=_71202_/Y }
C {sky130_stdcells/nand3_4.sym} 118540 -23790 0 0 {name=X_71202_ }
C {devices/lab_pin.sym} 118500 -23650 0 0 {name=p117612 lab=_44149_/X }
C {devices/lab_pin.sym} 118580 -23650 0 1 {name=p117613 lab=_44150_/X }
C {sky130_stdcells/buf_2.sym} 118540 -23650 0 0 {name=X_44150_ }
C {devices/lab_pin.sym} 118480 -23550 0 0 {name=p117614 lab=_56140_/A }
C {devices/lab_pin.sym} 118480 -23510 0 0 {name=p117615 lab=_56140_/B }
C {devices/lab_pin.sym} 118480 -23470 0 0 {name=p117616 lab=_85290_/Q }
C {devices/lab_pin.sym} 118600 -23510 0 1 {name=p117617 lab=_56136_/Y }
C {sky130_stdcells/nand3_4.sym} 118540 -23510 0 0 {name=X_56136_ }
C {devices/lab_pin.sym} 118500 -23370 0 0 {name=p117618 lab=_41181_/A }
C {devices/lab_pin.sym} 118580 -23370 0 1 {name=p117619 lab=_41362_/X }
C {sky130_stdcells/buf_2.sym} 118540 -23370 0 0 {name=X_41362_ }
C {devices/lab_pin.sym} 118480 -23280 0 0 {name=p117620 lab=_53339_/A }
C {devices/lab_pin.sym} 118480 -23240 0 0 {name=p117621 lab=_53371_/B }
C {devices/lab_pin.sym} 118480 -23200 0 0 {name=p117622 lab=_53330_/C }
C {devices/lab_pin.sym} 118480 -23160 0 0 {name=p117623 lab=_52835_/D }
C {devices/lab_pin.sym} 118600 -23220 0 1 {name=p117624 lab=_53348_/X }
C {sky130_stdcells/and4_4.sym} 118540 -23220 0 0 {name=X_53348_ }
C {devices/lab_pin.sym} 118460 -23090 0 0 {name=p117625 lab=_72166_/X }
C {devices/lab_pin.sym} 118460 -23050 0 0 {name=p117626 lab=_85372_/Q }
C {devices/lab_pin.sym} 118460 -23010 0 0 {name=p117627 lab=_72181_/X }
C {devices/lab_pin.sym} 118620 -23050 0 1 {name=p117628 lab=_72182_/Y }
C {sky130_stdcells/o21ai_4.sym} 118540 -23050 0 0 {name=X_72182_ }
C {devices/lab_pin.sym} 118450 -22910 0 0 {name=p117629 lab=_84166_/CLK }
C {devices/lab_pin.sym} 118450 -22890 0 0 {name=p117630 lab=_84168_/D }
C {devices/lab_pin.sym} 118630 -22910 0 1 {name=p117631 lab=_84168_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -22900 0 0 {name=X_84168_ }
C {devices/lab_pin.sym} 118460 -22810 0 0 {name=p117632 lab=_43100_/X }
C {devices/lab_pin.sym} 118460 -22770 0 0 {name=p117633 lab=_43075_/X }
C {devices/lab_pin.sym} 118460 -22730 0 0 {name=p117634 lab=_40743_/X }
C {devices/lab_pin.sym} 118460 -22690 0 0 {name=p117635 lab=_74206_/A }
C {devices/lab_pin.sym} 118460 -22650 0 0 {name=p117636 lab=_43080_/X }
C {devices/lab_pin.sym} 118620 -22730 0 1 {name=p117637 lab=_43101_/Y }
C {sky130_stdcells/o32ai_4.sym} 118540 -22730 0 0 {name=X_43101_ }
C {devices/lab_pin.sym} 118480 -22590 0 0 {name=p117638 lab=_71129_/A }
C {devices/lab_pin.sym} 118480 -22550 0 0 {name=p117639 lab=_71091_/B }
C {devices/lab_pin.sym} 118480 -22510 0 0 {name=p117640 lab=_70914_/D }
C {devices/lab_pin.sym} 118600 -22550 0 1 {name=p117641 lab=_71133_/Y }
C {sky130_stdcells/nand3_4.sym} 118540 -22550 0 0 {name=X_71133_ }
C {devices/lab_pin.sym} 118450 -22410 0 0 {name=p117642 lab=_86213_/CLK }
C {devices/lab_pin.sym} 118450 -22390 0 0 {name=p117643 lab=_74183_/X }
C {devices/lab_pin.sym} 118630 -22410 0 1 {name=p117644 lab=_70129_/A }
C {sky130_stdcells/dfxtp_4.sym} 118540 -22400 0 0 {name=X_83119_ }
C {devices/lab_pin.sym} 118500 -22270 0 0 {name=p117645 lab=_55549_/A }
C {devices/lab_pin.sym} 118580 -22270 0 1 {name=p117646 lab=_44081_/X }
C {sky130_stdcells/buf_2.sym} 118540 -22270 0 0 {name=X_44081_ }
C {devices/lab_pin.sym} 118460 -22170 0 0 {name=p117647 lab=_56058_/X }
C {devices/lab_pin.sym} 118460 -22130 0 0 {name=p117648 lab=_56064_/X }
C {devices/lab_pin.sym} 118460 -22090 0 0 {name=p117649 lab=_56066_/Y }
C {devices/lab_pin.sym} 118620 -22130 0 1 {name=p117650 lab=_85302_/D }
C {sky130_stdcells/o21ai_4.sym} 118540 -22130 0 0 {name=X_56067_ }
C {devices/lab_pin.sym} 118460 -22010 0 0 {name=p117651 lab=_53277_/Y }
C {devices/lab_pin.sym} 118460 -21970 0 0 {name=p117652 lab=_53272_/X }
C {devices/lab_pin.sym} 118460 -21930 0 0 {name=p117653 lab=_53278_/X }
C {devices/lab_pin.sym} 118620 -21970 0 1 {name=p117654 lab=_53279_/Y }
C {sky130_stdcells/a21oi_4.sym} 118540 -21970 0 0 {name=X_53279_ }
C {devices/lab_pin.sym} 118460 -21850 0 0 {name=p117655 lab=_41290_/X }
C {devices/lab_pin.sym} 118460 -21810 0 0 {name=p117656 lab=_82912_/Q }
C {devices/lab_pin.sym} 118460 -21770 0 0 {name=p117657 lab=_41292_/X }
C {devices/lab_pin.sym} 118620 -21810 0 1 {name=p117658 lab=_41294_/A }
C {sky130_stdcells/o21ai_4.sym} 118540 -21810 0 0 {name=X_41293_ }
C {devices/lab_pin.sym} 118480 -21680 0 0 {name=p117659 lab=_76990_/A }
C {devices/lab_pin.sym} 118480 -21640 0 0 {name=p117660 lab=_84414_/Q }
C {devices/lab_pin.sym} 118600 -21660 0 1 {name=p117661 lab=_76990_/X }
C {sky130_stdcells/xor2_4.sym} 118540 -21660 0 0 {name=X_76990_ }
C {devices/lab_pin.sym} 118450 -21530 0 0 {name=p117662 lab=_80928_/CLK }
C {devices/lab_pin.sym} 118450 -21510 0 0 {name=p117663 lab=_66732_/X }
C {devices/lab_pin.sym} 118630 -21530 0 1 {name=p117664 lab=_80923_/D }
C {sky130_stdcells/dfxtp_4.sym} 118540 -21520 0 0 {name=X_84099_ }
C {devices/lab_pin.sym} 118480 -21420 0 0 {name=p117665 lab=_55017_/X }
C {devices/lab_pin.sym} 118480 -21380 0 0 {name=p117666 lab=_55026_/B }
C {devices/lab_pin.sym} 118480 -21340 0 0 {name=p117667 lab=_55013_/C }
C {devices/lab_pin.sym} 118480 -21300 0 0 {name=p117668 lab=_47636_/A }
C {devices/lab_pin.sym} 118600 -21360 0 1 {name=p117669 lab=_55018_/X }
C {sky130_stdcells/and4_4.sym} 118540 -21360 0 0 {name=X_55018_ }
C {devices/lab_pin.sym} 118500 -21210 0 0 {name=p117670 lab=_43032_/A }
C {devices/lab_pin.sym} 118580 -21210 0 1 {name=p117671 lab=_43032_/Y }
C {sky130_stdcells/inv_2.sym} 118540 -21210 0 0 {name=X_43032_ }
C {devices/lab_pin.sym} 118500 -21090 0 0 {name=p117672 lab=_75933_/A }
C {devices/lab_pin.sym} 118580 -21090 0 1 {name=p117673 lab=_75941_/Y }
C {sky130_stdcells/inv_2.sym} 118540 -21090 0 0 {name=X_75941_ }
C {devices/lab_pin.sym} 118480 -20990 0 0 {name=p117674 lab=_71058_/A }
C {devices/lab_pin.sym} 118480 -20950 0 0 {name=p117675 lab=_71064_/B }
C {devices/lab_pin.sym} 118480 -20910 0 0 {name=p117676 lab=_71066_/C }
C {devices/lab_pin.sym} 118600 -20950 0 1 {name=p117677 lab=_71064_/Y }
C {sky130_stdcells/nand3_4.sym} 118540 -20950 0 0 {name=X_71064_ }
C {devices/lab_pin.sym} 118450 -20810 0 0 {name=p117678 lab=_87417_/CLK }
C {devices/lab_pin.sym} 118450 -20790 0 0 {name=p117679 lab=_87927_/D }
C {devices/lab_pin.sym} 118630 -20810 0 1 {name=p117680 lab=_87927_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -20800 0 0 {name=X_87927_ }
C {devices/lab_pin.sym} 118460 -20690 0 0 {name=p117681 lab=_82553_/D }
C {devices/lab_pin.sym} 118460 -20650 0 0 {name=p117682 lab=_70010_/X }
C {devices/lab_pin.sym} 118460 -20610 0 0 {name=p117683 lab=_70014_/X }
C {devices/lab_pin.sym} 118620 -20650 0 1 {name=p117684 lab=_83873_/D }
C {sky130_stdcells/a21bo_4.sym} 118540 -20650 0 0 {name=X_70015_ }
C {devices/lab_pin.sym} 118500 -20510 0 0 {name=p117685 lab=_47840_/A }
C {devices/lab_pin.sym} 118580 -20510 0 1 {name=p117686 lab=_47840_/X }
C {sky130_stdcells/buf_2.sym} 118540 -20510 0 0 {name=X_47840_ }
C {devices/lab_pin.sym} 118480 -20420 0 0 {name=p117687 lab=_59651_/A }
C {devices/lab_pin.sym} 118480 -20380 0 0 {name=p117688 lab=_59797_/Y }
C {devices/lab_pin.sym} 118480 -20340 0 0 {name=p117689 lab=_59825_/X }
C {devices/lab_pin.sym} 118480 -20300 0 0 {name=p117690 lab=_59680_/Y }
C {devices/lab_pin.sym} 118600 -20360 0 1 {name=p117691 lab=_59826_/Y }
C {sky130_stdcells/nand4_4.sym} 118540 -20360 0 0 {name=X_59826_ }
C {devices/lab_pin.sym} 118480 -20220 0 0 {name=p117692 lab=_78661_/A }
C {devices/lab_pin.sym} 118480 -20180 0 0 {name=p117693 lab=_82694_/Q }
C {devices/lab_pin.sym} 118600 -20200 0 1 {name=p117694 lab=_78663_/B }
C {sky130_stdcells/nor2_4.sym} 118540 -20200 0 0 {name=X_78660_ }
C {devices/lab_pin.sym} 118480 -20080 0 0 {name=p117695 lab=_80929_/Q }
C {devices/lab_pin.sym} 118480 -20040 0 0 {name=p117696 lab=_75872_/B }
C {devices/lab_pin.sym} 118600 -20060 0 1 {name=p117697 lab=_75875_/C }
C {sky130_stdcells/xor2_4.sym} 118540 -20060 0 0 {name=X_75872_ }
C {devices/lab_pin.sym} 118450 -19930 0 0 {name=p117698 lab=_86984_/CLK }
C {devices/lab_pin.sym} 118450 -19910 0 0 {name=p117699 lab=_87858_/D }
C {devices/lab_pin.sym} 118630 -19930 0 1 {name=p117700 lab=_68380_/A }
C {sky130_stdcells/dfxtp_4.sym} 118540 -19920 0 0 {name=X_87858_ }
C {devices/lab_pin.sym} 118480 -19800 0 0 {name=p117701 lab=_77612_/A }
C {devices/lab_pin.sym} 118480 -19760 0 0 {name=p117702 lab=_82108_/D }
C {devices/lab_pin.sym} 118600 -19780 0 1 {name=p117703 lab=_77614_/B }
C {sky130_stdcells/nor2_4.sym} 118540 -19780 0 0 {name=X_77611_ }
C {devices/lab_pin.sym} 118480 -19660 0 0 {name=p117704 lab=_74829_/A }
C {devices/lab_pin.sym} 118480 -19620 0 0 {name=p117705 lab=_46164_/A }
C {devices/lab_pin.sym} 118600 -19640 0 1 {name=p117706 lab=_74824_/A }
C {sky130_stdcells/nand2_4.sym} 118540 -19640 0 0 {name=X_74823_ }
C {devices/lab_pin.sym} 118450 -19510 0 0 {name=p117707 lab=_82899_/CLK }
C {devices/lab_pin.sym} 118450 -19490 0 0 {name=p117708 lab=_86809_/D }
C {devices/lab_pin.sym} 118630 -19510 0 1 {name=p117709 lab=_86809_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -19500 0 0 {name=X_86809_ }
C {devices/lab_pin.sym} 118500 -19370 0 0 {name=p117710 lab=_47771_/A }
C {devices/lab_pin.sym} 118580 -19370 0 1 {name=p117711 lab=_47771_/Y }
C {sky130_stdcells/inv_2.sym} 118540 -19370 0 0 {name=X_47771_ }
C {devices/lab_pin.sym} 118460 -19290 0 0 {name=p117712 lab=_59683_/A }
C {devices/lab_pin.sym} 118460 -19250 0 0 {name=p117713 lab=_59753_/Y }
C {devices/lab_pin.sym} 118460 -19210 0 0 {name=p117714 lab=_59754_/X }
C {devices/lab_pin.sym} 118460 -19170 0 0 {name=p117715 lab=_80526_/A }
C {devices/lab_pin.sym} 118460 -19130 0 0 {name=p117716 lab=_59756_/X }
C {devices/lab_pin.sym} 118620 -19210 0 1 {name=p117717 lab=_84704_/D }
C {sky130_stdcells/o32a_4.sym} 118540 -19210 0 0 {name=X_59757_ }
C {devices/lab_pin.sym} 118480 -19060 0 0 {name=p117718 lab=_78591_/A }
C {devices/lab_pin.sym} 118480 -19020 0 0 {name=p117719 lab=_78602_/A }
C {devices/lab_pin.sym} 118600 -19040 0 1 {name=p117720 lab=_78600_/B }
C {sky130_stdcells/xor2_4.sym} 118540 -19040 0 0 {name=X_78591_ }
C {devices/lab_pin.sym} 118460 -18930 0 0 {name=p117721 lab=_85180_/Q }
C {devices/lab_pin.sym} 118460 -18890 0 0 {name=p117722 lab=_44982_/X }
C {devices/lab_pin.sym} 118460 -18850 0 0 {name=p117723 lab=_44959_/X }
C {devices/lab_pin.sym} 118620 -18890 0 1 {name=p117724 lab=_44983_/X }
C {sky130_stdcells/o21a_4.sym} 118540 -18890 0 0 {name=X_44983_ }
C {devices/lab_pin.sym} 118500 -18750 0 0 {name=p117725 lab=_56860_/X }
C {devices/lab_pin.sym} 118580 -18750 0 1 {name=p117726 lab=_56971_/B }
C {sky130_stdcells/inv_2.sym} 118540 -18750 0 0 {name=X_56969_ }
C {devices/lab_pin.sym} 118450 -18630 0 0 {name=p117727 lab=_87789_/CLK }
C {devices/lab_pin.sym} 118450 -18610 0 0 {name=p117728 lab=_87789_/D }
C {devices/lab_pin.sym} 118630 -18630 0 1 {name=p117729 lab=_69218_/B }
C {sky130_stdcells/dfxtp_4.sym} 118540 -18620 0 0 {name=X_87789_ }
C {devices/lab_pin.sym} 118480 -18520 0 0 {name=p117730 lab=_49500_/A }
C {devices/lab_pin.sym} 118480 -18480 0 0 {name=p117731 lab=_49516_/B }
C {devices/lab_pin.sym} 118480 -18440 0 0 {name=p117732 lab=_49493_/X }
C {devices/lab_pin.sym} 118480 -18400 0 0 {name=p117733 lab=_52724_/D }
C {devices/lab_pin.sym} 118600 -18460 0 1 {name=p117734 lab=_49510_/X }
C {sky130_stdcells/and4_4.sym} 118540 -18460 0 0 {name=X_49510_ }
C {devices/lab_pin.sym} 118500 -18310 0 0 {name=p117735 lab=_52637_/B }
C {devices/lab_pin.sym} 118580 -18310 0 1 {name=p117736 lab=_51807_/B }
C {sky130_stdcells/buf_2.sym} 118540 -18310 0 0 {name=X_46722_ }
C {devices/lab_pin.sym} 118460 -18210 0 0 {name=p117737 lab=_58618_/X }
C {devices/lab_pin.sym} 118460 -18170 0 0 {name=p117738 lab=_86102_/Q }
C {devices/lab_pin.sym} 118460 -18130 0 0 {name=p117739 lab=_58707_/X }
C {devices/lab_pin.sym} 118620 -18170 0 1 {name=p117740 lab=_58708_/Y }
C {sky130_stdcells/o21ai_4.sym} 118540 -18170 0 0 {name=X_58708_ }
C {devices/lab_pin.sym} 118500 -18030 0 0 {name=p117741 lab=_77542_/A }
C {devices/lab_pin.sym} 118580 -18030 0 1 {name=p117742 lab=_77561_/D }
C {sky130_stdcells/inv_2.sym} 118540 -18030 0 0 {name=X_77542_ }
C {devices/lab_pin.sym} 118460 -17940 0 0 {name=p117743 lab=_41433_/X }
C {devices/lab_pin.sym} 118460 -17900 0 0 {name=p117744 lab=_43928_/X }
C {devices/lab_pin.sym} 118460 -17860 0 0 {name=p117745 lab=_67975_/B }
C {devices/lab_pin.sym} 118460 -17820 0 0 {name=p117746 lab=_43929_/X }
C {devices/lab_pin.sym} 118620 -17880 0 1 {name=p117747 lab=_87192_/D }
C {sky130_stdcells/a2bb2o_4.sym} 118540 -17880 0 0 {name=X_43934_ }
C {devices/lab_pin.sym} 118480 -17760 0 0 {name=p117748 lab=_74753_/X }
C {devices/lab_pin.sym} 118480 -17720 0 0 {name=p117749 lab=_70637_/A }
C {devices/lab_pin.sym} 118480 -17680 0 0 {name=p117750 lab=_83835_/Q }
C {devices/lab_pin.sym} 118480 -17640 0 0 {name=p117751 lab=_74739_/B }
C {devices/lab_pin.sym} 118600 -17700 0 1 {name=p117752 lab=_74754_/X }
C {sky130_stdcells/and4_4.sym} 118540 -17700 0 0 {name=X_74754_ }
C {devices/lab_pin.sym} 118460 -17570 0 0 {name=p117753 lab=_71963_/Y }
C {devices/lab_pin.sym} 118460 -17530 0 0 {name=p117754 lab=_57592_/X }
C {devices/lab_pin.sym} 118460 -17490 0 0 {name=p117755 lab=_71965_/X }
C {devices/lab_pin.sym} 118620 -17530 0 1 {name=p117756 lab=_83312_/D }
C {sky130_stdcells/a21oi_4.sym} 118540 -17530 0 0 {name=X_71966_ }
C {devices/lab_pin.sym} 118500 -17390 0 0 {name=p117757 lab=_59687_/Y }
C {devices/lab_pin.sym} 118580 -17390 0 1 {name=p117758 lab=_59688_/X }
C {sky130_stdcells/buf_2.sym} 118540 -17390 0 0 {name=X_59688_ }
C {devices/lab_pin.sym} 118480 -17300 0 0 {name=p117759 lab=_49447_/A }
C {devices/lab_pin.sym} 118480 -17260 0 0 {name=p117760 lab=_49447_/B }
C {devices/lab_pin.sym} 118480 -17220 0 0 {name=p117761 lab=_49447_/C }
C {devices/lab_pin.sym} 118480 -17180 0 0 {name=p117762 lab=_52654_/D }
C {devices/lab_pin.sym} 118600 -17240 0 1 {name=p117763 lab=_49441_/X }
C {sky130_stdcells/and4_4.sym} 118540 -17240 0 0 {name=X_49441_ }
C {devices/lab_pin.sym} 118460 -17110 0 0 {name=p117764 lab=_88365_/Q }
C {devices/lab_pin.sym} 118460 -17070 0 0 {name=p117765 lab=_73633_/X }
C {devices/lab_pin.sym} 118460 -17030 0 0 {name=p117766 lab=_73704_/X }
C {devices/lab_pin.sym} 118620 -17070 0 1 {name=p117767 lab=_73705_/Y }
C {sky130_stdcells/o21ai_4.sym} 118540 -17070 0 0 {name=X_73705_ }
C {devices/lab_pin.sym} 118500 -16930 0 0 {name=p117768 lab=_46653_/A }
C {devices/lab_pin.sym} 118580 -16930 0 1 {name=p117769 lab=_46751_/A }
C {sky130_stdcells/buf_2.sym} 118540 -16930 0 0 {name=X_46653_ }
C {devices/lab_pin.sym} 118460 -16830 0 0 {name=p117770 lab=_51022_/B }
C {devices/lab_pin.sym} 118460 -16790 0 0 {name=p117771 lab=_70909_/X }
C {devices/lab_pin.sym} 118460 -16750 0 0 {name=p117772 lab=_70916_/Y }
C {devices/lab_pin.sym} 118620 -16790 0 1 {name=p117773 lab=_83664_/D }
C {sky130_stdcells/o21ai_4.sym} 118540 -16790 0 0 {name=X_70917_ }
C {devices/lab_pin.sym} 118500 -16650 0 0 {name=p117774 lab=_84811_/Q }
C {devices/lab_pin.sym} 118580 -16650 0 1 {name=p117775 lab=_58639_/Y }
C {sky130_stdcells/inv_2.sym} 118540 -16650 0 0 {name=X_58639_ }
C {devices/lab_pin.sym} 118500 -16530 0 0 {name=p117776 lab=_77473_/A }
C {devices/lab_pin.sym} 118580 -16530 0 1 {name=p117777 lab=_77473_/Y }
C {sky130_stdcells/inv_2.sym} 118540 -16530 0 0 {name=X_77473_ }
C {devices/lab_pin.sym} 118500 -16410 0 0 {name=p117778 lab=_43865_/A }
C {devices/lab_pin.sym} 118580 -16410 0 1 {name=p117779 lab=_87228_/D }
C {sky130_stdcells/inv_2.sym} 118540 -16410 0 0 {name=X_43865_ }
C {devices/lab_pin.sym} 118480 -16310 0 0 {name=p117780 lab=_57331_/A }
C {devices/lab_pin.sym} 118480 -16270 0 0 {name=p117781 lab=_57331_/C }
C {devices/lab_pin.sym} 118480 -16230 0 0 {name=p117782 lab=_74685_/C }
C {devices/lab_pin.sym} 118600 -16270 0 1 {name=p117783 lab=_74685_/Y }
C {sky130_stdcells/nand3_4.sym} 118540 -16270 0 0 {name=X_74685_ }
C {devices/lab_pin.sym} 118460 -16150 0 0 {name=p117784 lab=_56698_/Y }
C {devices/lab_pin.sym} 118460 -16110 0 0 {name=p117785 lab=_71892_/X }
C {devices/lab_pin.sym} 118460 -16070 0 0 {name=p117786 lab=_71896_/Y }
C {devices/lab_pin.sym} 118620 -16110 0 1 {name=p117787 lab=_83337_/D }
C {sky130_stdcells/o21ai_4.sym} 118540 -16110 0 0 {name=X_71897_ }
C {devices/lab_pin.sym} 118480 -15980 0 0 {name=p117788 lab=_79212_/A }
C {devices/lab_pin.sym} 118480 -15940 0 0 {name=p117789 lab=_72617_/A }
C {devices/lab_pin.sym} 118600 -15960 0 1 {name=p117790 lab=_79212_/Y }
C {sky130_stdcells/nand2_4.sym} 118540 -15960 0 0 {name=X_79212_ }
C {devices/lab_pin.sym} 118480 -15840 0 0 {name=p117791 lab=_45604_/A }
C {devices/lab_pin.sym} 118480 -15800 0 0 {name=p117792 lab=_45604_/B }
C {devices/lab_pin.sym} 118600 -15820 0 1 {name=p117793 lab=_45604_/Y }
C {sky130_stdcells/nor2_4.sym} 118540 -15820 0 0 {name=X_45604_ }
C {devices/lab_pin.sym} 118480 -15700 0 0 {name=p117794 lab=_76424_/A }
C {devices/lab_pin.sym} 118480 -15660 0 0 {name=p117795 lab=_76423_/X }
C {devices/lab_pin.sym} 118600 -15680 0 1 {name=p117796 lab=_76424_/X }
C {sky130_stdcells/xor2_4.sym} 118540 -15680 0 0 {name=X_76424_ }
C {devices/lab_pin.sym} 118500 -15550 0 0 {name=p117797 lab=_42720_/X }
C {devices/lab_pin.sym} 118580 -15550 0 1 {name=p117798 lab=_42816_/X }
C {sky130_stdcells/buf_2.sym} 118540 -15550 0 0 {name=X_42816_ }
C {devices/lab_pin.sym} 118480 -15440 0 0 {name=p117799 lab=_49382_/A }
C {devices/lab_pin.sym} 118480 -15400 0 0 {name=p117800 lab=_50893_/B }
C {devices/lab_pin.sym} 118600 -15420 0 1 {name=p117801 lab=_49372_/Y }
C {sky130_stdcells/nand2_4.sym} 118540 -15420 0 0 {name=X_49372_ }
C {devices/lab_pin.sym} 118480 -15300 0 0 {name=p117802 lab=_73607_/A }
C {devices/lab_pin.sym} 118480 -15260 0 0 {name=p117803 lab=_73636_/B }
C {devices/lab_pin.sym} 118600 -15280 0 1 {name=p117804 lab=_73636_/X }
C {sky130_stdcells/and2_4.sym} 118540 -15280 0 0 {name=X_73636_ }
C {devices/lab_pin.sym} 118500 -15150 0 0 {name=p117805 lab=_59433_/A }
C {devices/lab_pin.sym} 118580 -15150 0 1 {name=p117806 lab=_61652_/B }
C {sky130_stdcells/buf_2.sym} 118540 -15150 0 0 {name=X_61650_ }
C {devices/lab_pin.sym} 118500 -15030 0 0 {name=p117807 lab=_70848_/A }
C {devices/lab_pin.sym} 118580 -15030 0 1 {name=p117808 lab=_70890_/B }
C {sky130_stdcells/buf_2.sym} 118540 -15030 0 0 {name=X_70848_ }
C {devices/lab_pin.sym} 118460 -14930 0 0 {name=p117809 lab=_46575_/Y }
C {devices/lab_pin.sym} 118460 -14890 0 0 {name=p117810 lab=_46576_/X }
C {devices/lab_pin.sym} 118460 -14850 0 0 {name=p117811 lab=_46583_/Y }
C {devices/lab_pin.sym} 118620 -14890 0 1 {name=p117812 lab=_46584_/Y }
C {sky130_stdcells/a21boi_4.sym} 118540 -14890 0 0 {name=X_46584_ }
C {devices/lab_pin.sym} 118460 -14780 0 0 {name=p117813 lab=_41050_/X }
C {devices/lab_pin.sym} 118460 -14740 0 0 {name=p117814 lab=_43770_/X }
C {devices/lab_pin.sym} 118460 -14700 0 0 {name=p117815 lab=_69411_/B }
C {devices/lab_pin.sym} 118460 -14660 0 0 {name=p117816 lab=_43772_/X }
C {devices/lab_pin.sym} 118620 -14720 0 1 {name=p117817 lab=_87263_/D }
C {sky130_stdcells/a2bb2o_4.sym} 118540 -14720 0 0 {name=X_43796_ }
C {devices/lab_pin.sym} 118500 -14570 0 0 {name=p117818 lab=_49215_/A }
C {devices/lab_pin.sym} 118580 -14570 0 1 {name=p117819 lab=_48348_/A }
C {sky130_stdcells/buf_2.sym} 118540 -14570 0 0 {name=X_48323_ }
C {devices/lab_pin.sym} 118460 -14490 0 0 {name=p117820 lab=_60413_/X }
C {devices/lab_pin.sym} 118460 -14450 0 0 {name=p117821 lab=_60476_/Y }
C {devices/lab_pin.sym} 118460 -14410 0 0 {name=p117822 lab=_60598_/Y }
C {devices/lab_pin.sym} 118460 -14370 0 0 {name=p117823 lab=_60599_/X }
C {devices/lab_pin.sym} 118460 -14340 0 0 {name=p117824 lab=_60600_/Y }
C {devices/lab_pin.sym} 118620 -14410 0 1 {name=p117825 lab=_60601_/Y }
C {sky130_stdcells/a41oi_4.sym} 118540 -14410 0 0 {name=X_60601_ }
C {devices/lab_pin.sym} 118480 -14260 0 0 {name=p117826 lab=_79143_/A }
C {devices/lab_pin.sym} 118480 -14220 0 0 {name=p117827 lab=_84475_/Q }
C {devices/lab_pin.sym} 118600 -14240 0 1 {name=p117828 lab=_79143_/X }
C {sky130_stdcells/xor2_4.sym} 118540 -14240 0 0 {name=X_79143_ }
C {devices/lab_pin.sym} 118480 -14120 0 0 {name=p117829 lab=_45535_/A }
C {devices/lab_pin.sym} 118480 -14080 0 0 {name=p117830 lab=_45597_/B }
C {devices/lab_pin.sym} 118600 -14100 0 1 {name=p117831 lab=_45535_/Y }
C {sky130_stdcells/nor2_4.sym} 118540 -14100 0 0 {name=X_45535_ }
C {devices/lab_pin.sym} 118500 -13970 0 0 {name=p117832 lab=_76381_/B }
C {devices/lab_pin.sym} 118580 -13970 0 1 {name=p117833 lab=_76355_/Y }
C {sky130_stdcells/inv_2.sym} 118540 -13970 0 0 {name=X_76355_ }
C {devices/lab_pin.sym} 118460 -13880 0 0 {name=p117834 lab=_41230_/X }
C {devices/lab_pin.sym} 118460 -13840 0 0 {name=p117835 lab=_42745_/X }
C {devices/lab_pin.sym} 118460 -13800 0 0 {name=p117836 lab=_68918_/B }
C {devices/lab_pin.sym} 118460 -13760 0 0 {name=p117837 lab=_42746_/X }
C {devices/lab_pin.sym} 118620 -13820 0 1 {name=p117838 lab=_42747_/X }
C {sky130_stdcells/a2bb2o_4.sym} 118540 -13820 0 0 {name=X_42747_ }
C {devices/lab_pin.sym} 118480 -13690 0 0 {name=p117839 lab=_61305_/A }
C {devices/lab_pin.sym} 118480 -13650 0 0 {name=p117840 lab=_61580_/X }
C {devices/lab_pin.sym} 118480 -13610 0 0 {name=p117841 lab=_72583_/C }
C {devices/lab_pin.sym} 118600 -13650 0 1 {name=p117842 lab=_61581_/Y }
C {sky130_stdcells/nand3_4.sym} 118540 -13650 0 0 {name=X_61581_ }
C {devices/lab_pin.sym} 118500 -13510 0 0 {name=p117843 lab=_73165_/A }
C {devices/lab_pin.sym} 118580 -13510 0 1 {name=p117844 lab=_73588_/A }
C {sky130_stdcells/buf_2.sym} 118540 -13510 0 0 {name=X_73567_ }
C {devices/lab_pin.sym} 118480 -13420 0 0 {name=p117845 lab=_70869_/A }
C {devices/lab_pin.sym} 118480 -13380 0 0 {name=p117846 lab=_70779_/B }
C {devices/lab_pin.sym} 118480 -13340 0 0 {name=p117847 lab=_70791_/C }
C {devices/lab_pin.sym} 118480 -13300 0 0 {name=p117848 lab=_70791_/D }
C {devices/lab_pin.sym} 118600 -13360 0 1 {name=p117849 lab=_70779_/Y }
C {sky130_stdcells/nand4_4.sym} 118540 -13360 0 0 {name=X_70779_ }
C {devices/lab_pin.sym} 118500 -13210 0 0 {name=p117850 lab=_79197_/B }
C {devices/lab_pin.sym} 118580 -13210 0 1 {name=p117851 lab=_79198_/A }
C {sky130_stdcells/inv_2.sym} 118540 -13210 0 0 {name=X_63320_ }
C {devices/lab_pin.sym} 118460 -13110 0 0 {name=p117852 lab=_75291_/X }
C {devices/lab_pin.sym} 118460 -13070 0 0 {name=p117853 lab=_75292_/Y }
C {devices/lab_pin.sym} 118460 -13030 0 0 {name=p117854 lab=_75294_/A }
C {devices/lab_pin.sym} 118620 -13070 0 1 {name=p117855 lab=_75306_/Y }
C {sky130_stdcells/a21boi_4.sym} 118540 -13070 0 0 {name=X_75306_ }
C {devices/lab_pin.sym} 118480 -12940 0 0 {name=p117856 lab=_48244_/A }
C {devices/lab_pin.sym} 118480 -12900 0 0 {name=p117857 lab=_50302_/B }
C {devices/lab_pin.sym} 118600 -12920 0 1 {name=p117858 lab=_48254_/Y }
C {sky130_stdcells/nand2_4.sym} 118540 -12920 0 0 {name=X_48254_ }
C {devices/lab_pin.sym} 118500 -12790 0 0 {name=p117859 lab=_60532_/A }
C {devices/lab_pin.sym} 118580 -12790 0 1 {name=p117860 lab=_60532_/Y }
C {sky130_stdcells/inv_2.sym} 118540 -12790 0 0 {name=X_60532_ }
C {devices/lab_pin.sym} 118500 -12670 0 0 {name=p117861 lab=_72502_/A }
C {devices/lab_pin.sym} 118580 -12670 0 1 {name=p117862 lab=_72597_/B }
C {sky130_stdcells/buf_2.sym} 118540 -12670 0 0 {name=X_72518_ }
C {devices/lab_pin.sym} 118480 -12560 0 0 {name=p117863 lab=_79074_/A }
C {devices/lab_pin.sym} 118480 -12520 0 0 {name=p117864 lab=_79089_/A }
C {devices/lab_pin.sym} 118600 -12540 0 1 {name=p117865 lab=_79087_/B }
C {sky130_stdcells/xor2_4.sym} 118540 -12540 0 0 {name=X_79074_ }
C {devices/lab_pin.sym} 118460 -12430 0 0 {name=p117866 lab=_45463_/Y }
C {devices/lab_pin.sym} 118460 -12390 0 0 {name=p117867 lab=_45465_/Y }
C {devices/lab_pin.sym} 118460 -12350 0 0 {name=p117868 lab=_44901_/X }
C {devices/lab_pin.sym} 118620 -12390 0 1 {name=p117869 lab=_45466_/X }
C {sky130_stdcells/o21a_4.sym} 118540 -12390 0 0 {name=X_45466_ }
C {devices/lab_pin.sym} 118480 -12260 0 0 {name=p117870 lab=_76284_/X }
C {devices/lab_pin.sym} 118480 -12220 0 0 {name=p117871 lab=_76286_/B }
C {devices/lab_pin.sym} 118600 -12240 0 1 {name=p117872 lab=_81611_/D }
C {sky130_stdcells/xor2_4.sym} 118540 -12240 0 0 {name=X_76286_ }
C {devices/lab_pin.sym} 118500 -12110 0 0 {name=p117873 lab=_42677_/Y }
C {devices/lab_pin.sym} 118580 -12110 0 1 {name=p117874 lab=_42678_/Y }
C {sky130_stdcells/inv_2.sym} 118540 -12110 0 0 {name=X_42678_ }
C {devices/lab_pin.sym} 118460 -12020 0 0 {name=p117875 lab=_73449_/X }
C {devices/lab_pin.sym} 118460 -11980 0 0 {name=p117876 lab=_85572_/Q }
C {devices/lab_pin.sym} 118460 -11940 0 0 {name=p117877 lab=_73450_/X }
C {devices/lab_pin.sym} 118460 -11900 0 0 {name=p117878 lab=_73497_/X }
C {devices/lab_pin.sym} 118620 -11960 0 1 {name=p117879 lab=_73498_/X }
C {sky130_stdcells/a211o_4.sym} 118540 -11960 0 0 {name=X_73498_ }
C {devices/lab_pin.sym} 118500 -11810 0 0 {name=p117880 lab=_53426_/B }
C {devices/lab_pin.sym} 118580 -11810 0 1 {name=p117881 lab=_51222_/B }
C {sky130_stdcells/buf_2.sym} 118540 -11810 0 0 {name=X_47205_ }
C {devices/lab_pin.sym} 118480 -11700 0 0 {name=p117882 lab=_78024_/Y }
C {devices/lab_pin.sym} 118480 -11660 0 0 {name=p117883 lab=_78009_/A }
C {devices/lab_pin.sym} 118600 -11680 0 1 {name=p117884 lab=_78025_/X }
C {sky130_stdcells/and2_4.sym} 118540 -11680 0 0 {name=X_78025_ }
C {devices/lab_pin.sym} 118460 -11590 0 0 {name=p117885 lab=_44404_/X }
C {devices/lab_pin.sym} 118460 -11550 0 0 {name=p117886 lab=_44405_/X }
C {devices/lab_pin.sym} 118460 -11510 0 0 {name=p117887 lab=_41545_/X }
C {devices/lab_pin.sym} 118460 -11470 0 0 {name=p117888 lab=_87119_/Q }
C {devices/lab_pin.sym} 118460 -11430 0 0 {name=p117889 lab=_44406_/X }
C {devices/lab_pin.sym} 118620 -11510 0 1 {name=p117890 lab=_44418_/A }
C {sky130_stdcells/o32ai_4.sym} 118540 -11510 0 0 {name=X_44417_ }
C {devices/lab_pin.sym} 118460 -11370 0 0 {name=p117891 lab=_75224_/Y }
C {devices/lab_pin.sym} 118460 -11330 0 0 {name=p117892 lab=_75225_/Y }
C {devices/lab_pin.sym} 118460 -11290 0 0 {name=p117893 lab=_75226_/Y }
C {devices/lab_pin.sym} 118620 -11330 0 1 {name=p117894 lab=_75237_/X }
C {sky130_stdcells/o21a_4.sym} 118540 -11330 0 0 {name=X_75237_ }
C {devices/lab_pin.sym} 118460 -11220 0 0 {name=p117895 lab=_58490_/A }
C {devices/lab_pin.sym} 118460 -11180 0 0 {name=p117896 lab=_63250_/X }
C {devices/lab_pin.sym} 118460 -11140 0 0 {name=p117897 lab=_58268_/A }
C {devices/lab_pin.sym} 118460 -11100 0 0 {name=p117898 lab=_62999_/X }
C {devices/lab_pin.sym} 118620 -11160 0 1 {name=p117899 lab=_63251_/X }
C {sky130_stdcells/o22a_4.sym} 118540 -11160 0 0 {name=X_63251_ }
C {devices/lab_pin.sym} 118480 -11020 0 0 {name=p117900 lab=_82913_/Q }
C {devices/lab_pin.sym} 118480 -10980 0 0 {name=p117901 lab=_41563_/B }
C {devices/lab_pin.sym} 118600 -11000 0 1 {name=p117902 lab=_41629_/X }
C {sky130_stdcells/or2_4.sym} 118540 -11000 0 0 {name=X_41629_ }
C {devices/lab_pin.sym} 118460 -10890 0 0 {name=p117903 lab=_48182_/Y }
C {devices/lab_pin.sym} 118460 -10850 0 0 {name=p117904 lab=_48175_/X }
C {devices/lab_pin.sym} 118460 -10810 0 0 {name=p117905 lab=_48184_/Y }
C {devices/lab_pin.sym} 118620 -10850 0 1 {name=p117906 lab=_48185_/Y }
C {sky130_stdcells/a21boi_4.sym} 118540 -10850 0 0 {name=X_48185_ }
C {devices/lab_pin.sym} 118500 -10710 0 0 {name=p117907 lab=_60570_/A }
C {devices/lab_pin.sym} 118580 -10710 0 1 {name=p117908 lab=_60488_/B }
C {sky130_stdcells/buf_2.sym} 118540 -10710 0 0 {name=X_60463_ }
C {devices/lab_pin.sym} 118460 -10610 0 0 {name=p117909 lab=_64758_/X }
C {devices/lab_pin.sym} 118460 -10570 0 0 {name=p117910 lab=_85317_/Q }
C {devices/lab_pin.sym} 118460 -10530 0 0 {name=p117911 lab=_57763_/X }
C {devices/lab_pin.sym} 118620 -10570 0 1 {name=p117912 lab=_72449_/X }
C {sky130_stdcells/o21a_4.sym} 118540 -10570 0 0 {name=X_72449_ }
C {devices/lab_pin.sym} 118500 -10430 0 0 {name=p117913 lab=_44932_/A }
C {devices/lab_pin.sym} 118580 -10430 0 1 {name=p117914 lab=_45397_/X }
C {sky130_stdcells/buf_2.sym} 118540 -10430 0 0 {name=X_45397_ }
C {devices/lab_pin.sym} 118480 -10340 0 0 {name=p117915 lab=_61315_/A }
C {devices/lab_pin.sym} 118480 -10300 0 0 {name=p117916 lab=_62556_/A }
C {devices/lab_pin.sym} 118480 -10260 0 0 {name=p117917 lab=_62576_/C }
C {devices/lab_pin.sym} 118480 -10220 0 0 {name=p117918 lab=_62560_/D }
C {devices/lab_pin.sym} 118600 -10280 0 1 {name=p117919 lab=_62202_/Y }
C {sky130_stdcells/nand4_4.sym} 118540 -10280 0 0 {name=X_62202_ }
C {devices/lab_pin.sym} 118500 -10130 0 0 {name=p117920 lab=_53390_/B }
C {devices/lab_pin.sym} 118580 -10130 0 1 {name=p117921 lab=_52876_/B }
C {sky130_stdcells/buf_2.sym} 118540 -10130 0 0 {name=X_47136_ }
C {devices/lab_pin.sym} 118460 -10050 0 0 {name=p117922 lab=_44330_/X }
C {devices/lab_pin.sym} 118460 -10010 0 0 {name=p117923 lab=_44331_/X }
C {devices/lab_pin.sym} 118460 -9970 0 0 {name=p117924 lab=_41705_/X }
C {devices/lab_pin.sym} 118460 -9930 0 0 {name=p117925 lab=_87153_/Q }
C {devices/lab_pin.sym} 118460 -9890 0 0 {name=p117926 lab=_44332_/X }
C {devices/lab_pin.sym} 118620 -9970 0 1 {name=p117927 lab=_44348_/Y }
C {sky130_stdcells/o32ai_4.sym} 118540 -9970 0 0 {name=X_44348_ }
C {devices/lab_pin.sym} 118480 -9840 0 0 {name=p117928 lab=_63157_/X }
C {devices/lab_pin.sym} 118480 -9800 0 0 {name=p117929 lab=_63182_/B }
C {devices/lab_pin.sym} 118480 -9760 0 0 {name=p117930 lab=_63147_/C }
C {devices/lab_pin.sym} 118480 -9720 0 0 {name=p117931 lab=_63181_/X }
C {devices/lab_pin.sym} 118600 -9780 0 1 {name=p117932 lab=_63182_/X }
C {sky130_stdcells/and4_4.sym} 118540 -9780 0 0 {name=X_63182_ }
C {devices/lab_pin.sym} 118480 -9640 0 0 {name=p117933 lab=_80776_/Q }
C {devices/lab_pin.sym} 118480 -9600 0 0 {name=p117934 lab=_81032_/D }
C {devices/lab_pin.sym} 118600 -9620 0 1 {name=p117935 lab=_75168_/X }
C {sky130_stdcells/xor2_4.sym} 118540 -9620 0 0 {name=X_75168_ }
C {devices/lab_pin.sym} 118500 -9490 0 0 {name=p117936 lab=_60393_/X }
C {devices/lab_pin.sym} 118580 -9490 0 1 {name=p117937 lab=_60440_/A }
C {sky130_stdcells/buf_2.sym} 118540 -9490 0 0 {name=X_60394_ }
C {devices/lab_pin.sym} 118480 -9390 0 0 {name=p117938 lab=_62144_/A }
C {devices/lab_pin.sym} 118480 -9350 0 0 {name=p117939 lab=_62121_/X }
C {devices/lab_pin.sym} 118480 -9310 0 0 {name=p117940 lab=_78054_/B }
C {devices/lab_pin.sym} 118600 -9350 0 1 {name=p117941 lab=_62133_/Y }
C {sky130_stdcells/nor3_4.sym} 118540 -9350 0 0 {name=X_62133_ }
C {devices/lab_pin.sym} 118480 -9220 0 0 {name=p117942 lab=_74119_/A }
C {devices/lab_pin.sym} 118480 -9180 0 0 {name=p117943 lab=_73370_/B }
C {devices/lab_pin.sym} 118600 -9200 0 1 {name=p117944 lab=_74119_/Y }
C {sky130_stdcells/nor2_4.sym} 118540 -9200 0 0 {name=X_74119_ }
C {devices/lab_pin.sym} 118480 -9100 0 0 {name=p117945 lab=_47067_/A }
C {devices/lab_pin.sym} 118480 -9060 0 0 {name=p117946 lab=_47039_/B }
C {devices/lab_pin.sym} 118480 -9020 0 0 {name=p117947 lab=_47048_/C }
C {devices/lab_pin.sym} 118480 -8980 0 0 {name=p117948 lab=_52835_/D }
C {devices/lab_pin.sym} 118600 -9040 0 1 {name=p117949 lab=_47067_/X }
C {sky130_stdcells/and4_4.sym} 118540 -9040 0 0 {name=X_47067_ }
C {devices/lab_pin.sym} 118480 -8920 0 0 {name=p117950 lab=_44139_/X }
C {devices/lab_pin.sym} 118480 -8880 0 0 {name=p117951 lab=_44141_/X }
C {devices/lab_pin.sym} 118480 -8840 0 0 {name=p117952 lab=_44142_/X }
C {devices/lab_pin.sym} 118480 -8800 0 0 {name=p117953 lab=_44279_/D }
C {devices/lab_pin.sym} 118600 -8860 0 1 {name=p117954 lab=_44279_/Y }
C {sky130_stdcells/nand4_4.sym} 118540 -8860 0 0 {name=X_44279_ }
C {devices/lab_pin.sym} 118460 -8730 0 0 {name=p117955 lab=_67986_/X }
C {devices/lab_pin.sym} 118460 -8690 0 0 {name=p117956 lab=_67989_/X }
C {devices/lab_pin.sym} 118460 -8650 0 0 {name=p117957 lab=_67917_/X }
C {devices/lab_pin.sym} 118620 -8690 0 1 {name=p117958 lab=_67990_/X }
C {sky130_stdcells/a21o_4.sym} 118540 -8690 0 0 {name=X_67990_ }
C {devices/lab_pin.sym} 118480 -8560 0 0 {name=p117959 lab=_79974_/Y }
C {devices/lab_pin.sym} 118480 -8520 0 0 {name=p117960 lab=_79975_/Y }
C {devices/lab_pin.sym} 118600 -8540 0 1 {name=p117961 lab=_79976_/Y }
C {sky130_stdcells/nand2_4.sym} 118540 -8540 0 0 {name=X_79976_ }
C {devices/lab_pin.sym} 118500 -8410 0 0 {name=p117962 lab=_75099_/A }
C {devices/lab_pin.sym} 118580 -8410 0 1 {name=p117963 lab=_75099_/Y }
C {sky130_stdcells/inv_2.sym} 118540 -8410 0 0 {name=X_75099_ }
C {devices/lab_pin.sym} 118460 -8320 0 0 {name=p117964 lab=_40523_/Y }
C {devices/lab_pin.sym} 118460 -8280 0 0 {name=p117965 lab=_46007_/X }
C {devices/lab_pin.sym} 118460 -8240 0 0 {name=p117966 lab=_67201_/B }
C {devices/lab_pin.sym} 118460 -8200 0 0 {name=p117967 lab=_46008_/X }
C {devices/lab_pin.sym} 118620 -8260 0 1 {name=p117968 lab=_86812_/D }
C {sky130_stdcells/a2bb2o_4.sym} 118540 -8260 0 0 {name=X_46018_ }
C {devices/lab_pin.sym} 118500 -8110 0 0 {name=p117969 lab=_68474_/A }
C {devices/lab_pin.sym} 118580 -8110 0 1 {name=p117970 lab=_66942_/A }
C {sky130_stdcells/buf_2.sym} 118540 -8110 0 0 {name=X_66941_ }
C {devices/lab_pin.sym} 118500 -7990 0 0 {name=p117971 lab=_59766_/X }
C {devices/lab_pin.sym} 118580 -7990 0 1 {name=p117972 lab=_62065_/D }
C {sky130_stdcells/buf_2.sym} 118540 -7990 0 0 {name=X_62064_ }
C {devices/lab_pin.sym} 118480 -7880 0 0 {name=p117973 lab=_82735_/Q }
C {devices/lab_pin.sym} 118480 -7840 0 0 {name=p117974 lab=_78927_/B }
C {devices/lab_pin.sym} 118600 -7860 0 1 {name=p117975 lab=_82703_/D }
C {sky130_stdcells/xor2_4.sym} 118540 -7860 0 0 {name=X_78927_ }
C {devices/lab_pin.sym} 118460 -7770 0 0 {name=p117976 lab=_60891_/Y }
C {devices/lab_pin.sym} 118460 -7730 0 0 {name=p117977 lab=_61012_/Y }
C {devices/lab_pin.sym} 118460 -7690 0 0 {name=p117978 lab=_60944_/Y }
C {devices/lab_pin.sym} 118460 -7650 0 0 {name=p117979 lab=_61013_/Y }
C {devices/lab_pin.sym} 118460 -7620 0 0 {name=p117980 lab=_61014_/Y }
C {devices/lab_pin.sym} 118620 -7690 0 1 {name=p117981 lab=_61015_/Y }
C {sky130_stdcells/a41oi_4.sym} 118540 -7690 0 0 {name=X_61015_ }
C {devices/lab_pin.sym} 118460 -7560 0 0 {name=p117982 lab=_43133_/A }
C {devices/lab_pin.sym} 118460 -7520 0 0 {name=p117983 lab=_68636_/X }
C {devices/lab_pin.sym} 118460 -7480 0 0 {name=p117984 lab=_68517_/X }
C {devices/lab_pin.sym} 118460 -7440 0 0 {name=p117985 lab=_69659_/X }
C {devices/lab_pin.sym} 118620 -7500 0 1 {name=p117986 lab=_69660_/X }
C {sky130_stdcells/a211o_4.sym} 118540 -7500 0 0 {name=X_69660_ }
C {devices/lab_pin.sym} 118460 -7370 0 0 {name=p117987 lab=_66866_/X }
C {devices/lab_pin.sym} 118460 -7330 0 0 {name=p117988 lab=_66870_/X }
C {devices/lab_pin.sym} 118460 -7290 0 0 {name=p117989 lab=_66871_/X }
C {devices/lab_pin.sym} 118620 -7330 0 1 {name=p117990 lab=_66872_/Y }
C {sky130_stdcells/a21oi_4.sym} 118540 -7330 0 0 {name=X_66872_ }
C {devices/lab_pin.sym} 118460 -7210 0 0 {name=p117991 lab=_78855_/X }
C {devices/lab_pin.sym} 118460 -7170 0 0 {name=p117992 lab=_78856_/Y }
C {devices/lab_pin.sym} 118460 -7130 0 0 {name=p117993 lab=_78857_/X }
C {devices/lab_pin.sym} 118620 -7170 0 1 {name=p117994 lab=_78858_/Y }
C {sky130_stdcells/a21oi_4.sym} 118540 -7170 0 0 {name=X_78858_ }
C {devices/lab_pin.sym} 118460 -7050 0 0 {name=p117995 lab=_83968_/Q }
C {devices/lab_pin.sym} 118460 -7010 0 0 {name=p117996 lab=_68586_/X }
C {devices/lab_pin.sym} 118460 -6970 0 0 {name=p117997 lab=_68610_/X }
C {devices/lab_pin.sym} 118620 -7010 0 1 {name=p117998 lab=_68611_/X }
C {sky130_stdcells/a21bo_4.sym} 118540 -7010 0 0 {name=X_68611_ }
C {devices/lab_pin.sym} 118460 -6890 0 0 {name=p117999 lab=_65820_/X }
C {devices/lab_pin.sym} 118460 -6850 0 0 {name=p118000 lab=_65822_/X }
C {devices/lab_pin.sym} 118460 -6810 0 0 {name=p118001 lab=_65642_/X }
C {devices/lab_pin.sym} 118620 -6850 0 1 {name=p118002 lab=_65827_/A }
C {sky130_stdcells/a21o_4.sym} 118540 -6850 0 0 {name=X_65823_ }
C {devices/lab_pin.sym} 118480 -6720 0 0 {name=p118003 lab=_77809_/A }
C {devices/lab_pin.sym} 118480 -6680 0 0 {name=p118004 lab=_77819_/A }
C {devices/lab_pin.sym} 118600 -6700 0 1 {name=p118005 lab=_77809_/Y }
C {sky130_stdcells/nor2_4.sym} 118540 -6700 0 0 {name=X_77809_ }
C {devices/lab_pin.sym} 118460 -6590 0 0 {name=p118006 lab=_83912_/Q }
C {devices/lab_pin.sym} 118460 -6550 0 0 {name=p118007 lab=_69564_/X }
C {devices/lab_pin.sym} 118460 -6510 0 0 {name=p118008 lab=_69590_/X }
C {devices/lab_pin.sym} 118620 -6550 0 1 {name=p118009 lab=_69591_/X }
C {sky130_stdcells/a21bo_4.sym} 118540 -6550 0 0 {name=X_69591_ }
C {devices/lab_pin.sym} 118480 -6420 0 0 {name=p118010 lab=_47988_/A }
C {devices/lab_pin.sym} 118480 -6380 0 0 {name=p118011 lab=_47969_/B }
C {devices/lab_pin.sym} 118600 -6400 0 1 {name=p118012 lab=_47969_/Y }
C {sky130_stdcells/nand2_4.sym} 118540 -6400 0 0 {name=X_47969_ }
C {devices/lab_pin.sym} 118500 -6270 0 0 {name=p118013 lab=_78788_/Y }
C {devices/lab_pin.sym} 118580 -6270 0 1 {name=p118014 lab=_78789_/Y }
C {sky130_stdcells/inv_2.sym} 118540 -6270 0 0 {name=X_78789_ }
C {devices/lab_pin.sym} 118480 -6180 0 0 {name=p118015 lab=_49708_/A }
C {devices/lab_pin.sym} 118480 -6140 0 0 {name=p118016 lab=_49697_/B }
C {devices/lab_pin.sym} 118480 -6100 0 0 {name=p118017 lab=_49685_/C }
C {devices/lab_pin.sym} 118480 -6060 0 0 {name=p118018 lab=_47218_/D }
C {devices/lab_pin.sym} 118600 -6120 0 1 {name=p118019 lab=_49708_/X }
C {sky130_stdcells/and4_4.sym} 118540 -6120 0 0 {name=X_49708_ }
C {devices/lab_pin.sym} 118500 -5970 0 0 {name=p118020 lab=_69190_/A }
C {devices/lab_pin.sym} 118580 -5970 0 1 {name=p118021 lab=_68542_/X }
C {sky130_stdcells/buf_2.sym} 118540 -5970 0 0 {name=X_68542_ }
C {devices/lab_pin.sym} 118450 -5850 0 0 {name=p118022 lab=_81994_/CLK }
C {devices/lab_pin.sym} 118450 -5830 0 0 {name=p118023 lab=_83964_/Q }
C {devices/lab_pin.sym} 118630 -5850 0 1 {name=p118024 lab=_80820_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -5840 0 0 {name=X_80820_ }
C {devices/lab_pin.sym} 118460 -5740 0 0 {name=p118025 lab=_64599_/X }
C {devices/lab_pin.sym} 118460 -5700 0 0 {name=p118026 lab=_83060_/Q }
C {devices/lab_pin.sym} 118460 -5660 0 0 {name=p118027 lab=_64600_/X }
C {devices/lab_pin.sym} 118460 -5620 0 0 {name=p118028 lab=_65753_/X }
C {devices/lab_pin.sym} 118620 -5680 0 1 {name=p118029 lab=_65754_/X }
C {sky130_stdcells/a211o_4.sym} 118540 -5680 0 0 {name=X_65754_ }
C {devices/lab_pin.sym} 118460 -5550 0 0 {name=p118030 lab=_50977_/Y }
C {devices/lab_pin.sym} 118460 -5510 0 0 {name=p118031 lab=_50957_/X }
C {devices/lab_pin.sym} 118460 -5470 0 0 {name=p118032 lab=_50979_/X }
C {devices/lab_pin.sym} 118620 -5510 0 1 {name=p118033 lab=_86096_/D }
C {sky130_stdcells/a21oi_4.sym} 118540 -5510 0 0 {name=X_50980_ }
C {devices/lab_pin.sym} 118480 -5400 0 0 {name=p118034 lab=_61665_/B }
C {devices/lab_pin.sym} 118480 -5360 0 0 {name=p118035 lab=_62936_/X }
C {devices/lab_pin.sym} 118480 -5320 0 0 {name=p118036 lab=_62982_/C }
C {devices/lab_pin.sym} 118480 -5280 0 0 {name=p118037 lab=_62908_/X }
C {devices/lab_pin.sym} 118600 -5340 0 1 {name=p118038 lab=_62966_/Y }
C {sky130_stdcells/nand4_4.sym} 118540 -5340 0 0 {name=X_62966_ }
C {devices/lab_pin.sym} 118500 -5190 0 0 {name=p118039 lab=_44244_/A }
C {devices/lab_pin.sym} 118580 -5190 0 1 {name=p118040 lab=_64706_/A }
C {sky130_stdcells/buf_2.sym} 118540 -5190 0 0 {name=X_64705_ }
C {devices/lab_pin.sym} 118460 -5090 0 0 {name=p118041 lab=_86350_/Q }
C {devices/lab_pin.sym} 118460 -5050 0 0 {name=p118042 lab=_49632_/X }
C {devices/lab_pin.sym} 118460 -5010 0 0 {name=p118043 lab=_49638_/Y }
C {devices/lab_pin.sym} 118620 -5050 0 1 {name=p118044 lab=_49639_/Y }
C {sky130_stdcells/o21ai_4.sym} 118540 -5050 0 0 {name=X_49639_ }
C {devices/lab_pin.sym} 118480 -4940 0 0 {name=p118045 lab=_61871_/A }
C {devices/lab_pin.sym} 118480 -4900 0 0 {name=p118046 lab=_61949_/B }
C {devices/lab_pin.sym} 118480 -4860 0 0 {name=p118047 lab=_61949_/C }
C {devices/lab_pin.sym} 118480 -4820 0 0 {name=p118048 lab=_63147_/B }
C {devices/lab_pin.sym} 118600 -4880 0 1 {name=p118049 lab=_61917_/X }
C {sky130_stdcells/and4_4.sym} 118540 -4880 0 0 {name=X_61917_ }
C {devices/lab_pin.sym} 118450 -4730 0 0 {name=p118050 lab=_80746_/CLK }
C {devices/lab_pin.sym} 118450 -4710 0 0 {name=p118051 lab=_80751_/D }
C {devices/lab_pin.sym} 118630 -4730 0 1 {name=p118052 lab=_81127_/D }
C {sky130_stdcells/dfxtp_4.sym} 118540 -4720 0 0 {name=X_80751_ }
C {devices/lab_pin.sym} 118500 -4590 0 0 {name=p118053 lab=_69611_/A }
C {devices/lab_pin.sym} 118580 -4590 0 1 {name=p118054 lab=_68473_/X }
C {sky130_stdcells/buf_2.sym} 118540 -4590 0 0 {name=X_68473_ }
C {devices/lab_pin.sym} 118500 -4470 0 0 {name=p118055 lab=_65484_/A }
C {devices/lab_pin.sym} 118580 -4470 0 1 {name=p118056 lab=_65685_/X }
C {sky130_stdcells/buf_2.sym} 118540 -4470 0 0 {name=X_65685_ }
C {devices/lab_pin.sym} 118500 -4350 0 0 {name=p118057 lab=_62897_/A }
C {devices/lab_pin.sym} 118580 -4350 0 1 {name=p118058 lab=_62897_/Y }
C {sky130_stdcells/inv_2.sym} 118540 -4350 0 0 {name=X_62897_ }
C {devices/lab_pin.sym} 118460 -4250 0 0 {name=p118059 lab=_67419_/X }
C {devices/lab_pin.sym} 118460 -4210 0 0 {name=p118060 lab=_67422_/X }
C {devices/lab_pin.sym} 118460 -4170 0 0 {name=p118061 lab=_67423_/X }
C {devices/lab_pin.sym} 118620 -4210 0 1 {name=p118062 lab=_67424_/Y }
C {sky130_stdcells/a21oi_4.sym} 118540 -4210 0 0 {name=X_67424_ }
C {devices/lab_pin.sym} 118460 -4090 0 0 {name=p118063 lab=_52646_/Y }
C {devices/lab_pin.sym} 118460 -4050 0 0 {name=p118064 lab=_52647_/X }
C {devices/lab_pin.sym} 118460 -4010 0 0 {name=p118065 lab=_52649_/X }
C {devices/lab_pin.sym} 118620 -4050 0 1 {name=p118066 lab=_52650_/Y }
C {sky130_stdcells/a21oi_4.sym} 118540 -4050 0 0 {name=X_52650_ }
C {devices/lab_pin.sym} 118450 -3910 0 0 {name=p118067 lab=_85957_/CLK }
C {devices/lab_pin.sym} 118450 -3890 0 0 {name=p118068 lab=_83470_/D }
C {devices/lab_pin.sym} 118630 -3910 0 1 {name=p118069 lab=_47779_/A }
C {sky130_stdcells/dfxtp_4.sym} 118540 -3900 0 0 {name=X_83470_ }
C {devices/lab_pin.sym} 118500 -3770 0 0 {name=p118070 lab=_64636_/A }
C {devices/lab_pin.sym} 118580 -3770 0 1 {name=p118071 lab=_66104_/A }
C {sky130_stdcells/buf_2.sym} 118540 -3770 0 0 {name=X_64636_ }
C {devices/lab_pin.sym} 118460 -3690 0 0 {name=p118072 lab=_61837_/X }
C {devices/lab_pin.sym} 118460 -3650 0 0 {name=p118073 lab=_61840_/X }
C {devices/lab_pin.sym} 118460 -3610 0 0 {name=p118074 lab=_61847_/Y }
C {devices/lab_pin.sym} 118460 -3570 0 0 {name=p118075 lab=_58177_/A }
C {devices/lab_pin.sym} 118460 -3530 0 0 {name=p118076 lab=_61815_/X }
C {devices/lab_pin.sym} 118620 -3610 0 1 {name=p118077 lab=_61848_/Y }
C {sky130_stdcells/o32ai_4.sym} 118540 -3610 0 0 {name=X_61848_ }
C {devices/lab_pin.sym} 118450 -3450 0 0 {name=p118078 lab=_81065_/CLK }
C {devices/lab_pin.sym} 118450 -3430 0 0 {name=p118079 lab=_80682_/D }
C {devices/lab_pin.sym} 118630 -3450 0 1 {name=p118080 lab=_80682_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -3440 0 0 {name=X_80682_ }
C {devices/lab_pin.sym} 118460 -3330 0 0 {name=p118081 lab=_85980_/Q }
C {devices/lab_pin.sym} 118460 -3290 0 0 {name=p118082 lab=_51594_/X }
C {devices/lab_pin.sym} 118460 -3250 0 0 {name=p118083 lab=_51600_/Y }
C {devices/lab_pin.sym} 118620 -3290 0 1 {name=p118084 lab=_51601_/Y }
C {sky130_stdcells/o21ai_4.sym} 118540 -3290 0 0 {name=X_51601_ }
C {devices/lab_pin.sym} 118450 -3150 0 0 {name=p118085 lab=_82463_/CLK }
C {devices/lab_pin.sym} 118450 -3130 0 0 {name=p118086 lab=_82453_/Q }
C {devices/lab_pin.sym} 118630 -3150 0 1 {name=p118087 lab=_78586_/A }
C {sky130_stdcells/dfxtp_4.sym} 118540 -3140 0 0 {name=X_82421_ }
C {devices/lab_pin.sym} 118500 -3010 0 0 {name=p118088 lab=_67354_/X }
C {devices/lab_pin.sym} 118580 -3010 0 1 {name=p118089 lab=_67355_/X }
C {sky130_stdcells/buf_2.sym} 118540 -3010 0 0 {name=X_67355_ }
C {devices/lab_pin.sym} 118460 -2910 0 0 {name=p118090 lab=_52578_/Y }
C {devices/lab_pin.sym} 118460 -2870 0 0 {name=p118091 lab=_52532_/X }
C {devices/lab_pin.sym} 118460 -2830 0 0 {name=p118092 lab=_52580_/X }
C {devices/lab_pin.sym} 118620 -2870 0 1 {name=p118093 lab=_52581_/Y }
C {sky130_stdcells/a21oi_4.sym} 118540 -2870 0 0 {name=X_52581_ }
C {devices/lab_pin.sym} 118500 -2730 0 0 {name=p118094 lab=_64567_/A }
C {devices/lab_pin.sym} 118580 -2730 0 1 {name=p118095 lab=_64667_/A }
C {sky130_stdcells/buf_2.sym} 118540 -2730 0 0 {name=X_64567_ }
C {devices/lab_pin.sym} 118480 -2640 0 0 {name=p118096 lab=_61364_/B }
C {devices/lab_pin.sym} 118480 -2600 0 0 {name=p118097 lab=_61795_/B }
C {devices/lab_pin.sym} 118480 -2560 0 0 {name=p118098 lab=_61795_/C }
C {devices/lab_pin.sym} 118480 -2520 0 0 {name=p118099 lab=_61778_/X }
C {devices/lab_pin.sym} 118600 -2580 0 1 {name=p118100 lab=_61779_/Y }
C {sky130_stdcells/nand4_4.sym} 118540 -2580 0 0 {name=X_61779_ }
C {devices/lab_pin.sym} 118500 -2430 0 0 {name=p118101 lab=clkbuf_4_5_0_CLK/X }
C {devices/lab_pin.sym} 118580 -2430 0 1 {name=p118102 lab=clkbuf_4_5_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 118540 -2430 0 0 {name=Xclkbuf_4_5_1_CLK }
C {sky130_stdcells/decap_3.sym} 118540 -2280 0 0 {name=XPHY_608 }
C {devices/lab_pin.sym} 118500 -2130 0 0 {name=p118103 lab=_54320_/A }
C {devices/lab_pin.sym} 118580 -2130 0 1 {name=p118104 lab=_54320_/X }
C {sky130_stdcells/buf_2.sym} 118540 -2130 0 0 {name=X_54320_ }
C {sky130_stdcells/decap_3.sym} 118540 -1980 0 0 {name=XPHY_619 }
C {devices/lab_pin.sym} 118480 -1850 0 0 {name=p118105 lab=_66231_/X }
C {devices/lab_pin.sym} 118480 -1810 0 0 {name=p118106 lab=_66319_/B }
C {devices/lab_pin.sym} 118480 -1770 0 0 {name=p118107 lab=_84142_/Q }
C {devices/lab_pin.sym} 118600 -1810 0 1 {name=p118108 lab=_66306_/X }
C {sky130_stdcells/and3_4.sym} 118540 -1810 0 0 {name=X_66306_ }
C {devices/lab_pin.sym} 118450 -1670 0 0 {name=p118109 lab=_85138_/CLK }
C {devices/lab_pin.sym} 118450 -1650 0 0 {name=p118110 lab=_56641_/X }
C {devices/lab_pin.sym} 118630 -1670 0 1 {name=p118111 lab=_85140_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -1660 0 0 {name=X_85140_ }
C {devices/lab_pin.sym} 118500 -1530 0 0 {name=p118112 lab=_51504_/A }
C {devices/lab_pin.sym} 118580 -1530 0 1 {name=p118113 lab=_51553_/B }
C {sky130_stdcells/buf_2.sym} 118540 -1530 0 0 {name=X_51532_ }
C {devices/lab_pin.sym} 118460 -1430 0 0 {name=p118114 lab=_63515_/Y }
C {devices/lab_pin.sym} 118460 -1390 0 0 {name=p118115 lab=_63516_/X }
C {devices/lab_pin.sym} 118460 -1350 0 0 {name=p118116 lab=_63517_/Y }
C {devices/lab_pin.sym} 118620 -1390 0 1 {name=p118117 lab=_63518_/Y }
C {sky130_stdcells/a21oi_4.sym} 118540 -1390 0 0 {name=X_63518_ }
C {devices/lab_pin.sym} 118450 -1250 0 0 {name=p118118 lab=_82299_/CLK }
C {devices/lab_pin.sym} 118450 -1230 0 0 {name=p118119 lab=_77152_/X }
C {devices/lab_pin.sym} 118630 -1250 0 1 {name=p118120 lab=_48018_/A }
C {sky130_stdcells/dfxtp_4.sym} 118540 -1240 0 0 {name=X_82352_ }
C {devices/lab_pin.sym} 118460 -1140 0 0 {name=p118121 lab=_87861_/Q }
C {devices/lab_pin.sym} 118460 -1100 0 0 {name=p118122 lab=_67236_/X }
C {devices/lab_pin.sym} 118460 -1060 0 0 {name=p118123 lab=_67284_/X }
C {devices/lab_pin.sym} 118460 -1020 0 0 {name=p118124 lab=_67285_/X }
C {devices/lab_pin.sym} 118620 -1080 0 1 {name=p118125 lab=_67286_/X }
C {sky130_stdcells/a211o_4.sym} 118540 -1080 0 0 {name=X_67286_ }
C {devices/lab_pin.sym} 118460 -970 0 0 {name=p118126 lab=_64493_/X }
C {devices/lab_pin.sym} 118460 -930 0 0 {name=p118127 lab=_64494_/X }
C {devices/lab_pin.sym} 118460 -890 0 0 {name=p118128 lab=_64495_/X }
C {devices/lab_pin.sym} 118460 -850 0 0 {name=p118129 lab=_64497_/Y }
C {devices/lab_pin.sym} 118460 -810 0 0 {name=p118130 lab=_64440_/X }
C {devices/lab_pin.sym} 118620 -890 0 1 {name=p118131 lab=_64498_/X }
C {sky130_stdcells/o41a_4.sym} 118540 -890 0 0 {name=X_64498_ }
C {devices/lab_pin.sym} 118450 -730 0 0 {name=p118132 lab=_81801_/CLK }
C {devices/lab_pin.sym} 118450 -710 0 0 {name=p118133 lab=_76991_/X }
C {devices/lab_pin.sym} 118630 -730 0 1 {name=p118134 lab=_81303_/Q }
C {sky130_stdcells/dfxtp_4.sym} 118540 -720 0 0 {name=X_81303_ }
C {devices/lab_pin.sym} 119420 -42150 0 0 {name=p118135 lab=_57716_/A }
C {devices/lab_pin.sym} 119500 -42150 0 1 {name=p118136 lab=_69025_/X }
C {sky130_stdcells/buf_2.sym} 119460 -42150 0 0 {name=X_69025_ }
C {devices/lab_pin.sym} 119400 -42040 0 0 {name=p118137 lab=_54961_/A }
C {devices/lab_pin.sym} 119400 -42000 0 0 {name=p118138 lab=_53080_/B }
C {devices/lab_pin.sym} 119520 -42020 0 1 {name=p118139 lab=_54251_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -42020 0 0 {name=X_54251_ }
C {devices/lab_pin.sym} 119420 -41890 0 0 {name=p118140 lab=_58784_/A }
C {devices/lab_pin.sym} 119500 -41890 0 1 {name=p118141 lab=_66237_/X }
C {sky130_stdcells/buf_2.sym} 119460 -41890 0 0 {name=X_66237_ }
C {devices/lab_pin.sym} 119370 -41770 0 0 {name=p118142 lab=_85071_/CLK }
C {devices/lab_pin.sym} 119370 -41750 0 0 {name=p118143 lab=_85071_/D }
C {devices/lab_pin.sym} 119550 -41770 0 1 {name=p118144 lab=_85071_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -41760 0 0 {name=X_85071_ }
C {devices/lab_pin.sym} 119380 -41650 0 0 {name=p118145 lab=_51461_/Y }
C {devices/lab_pin.sym} 119380 -41610 0 0 {name=p118146 lab=_51448_/X }
C {devices/lab_pin.sym} 119380 -41570 0 0 {name=p118147 lab=_51462_/X }
C {devices/lab_pin.sym} 119540 -41610 0 1 {name=p118148 lab=_86006_/D }
C {sky130_stdcells/a21oi_4.sym} 119460 -41610 0 0 {name=X_51463_ }
C {devices/lab_pin.sym} 119380 -41500 0 0 {name=p118149 lab=_58429_/Y }
C {devices/lab_pin.sym} 119380 -41460 0 0 {name=p118150 lab=_63436_/X }
C {devices/lab_pin.sym} 119380 -41420 0 0 {name=p118151 lab=_61421_/A }
C {devices/lab_pin.sym} 119380 -41380 0 0 {name=p118152 lab=_63437_/X }
C {devices/lab_pin.sym} 119540 -41440 0 1 {name=p118153 lab=_63449_/X }
C {sky130_stdcells/a2bb2o_4.sym} 119460 -41440 0 0 {name=X_63449_ }
C {devices/lab_pin.sym} 119370 -41290 0 0 {name=p118154 lab=_82301_/CLK }
C {devices/lab_pin.sym} 119370 -41270 0 0 {name=p118155 lab=_82283_/D }
C {devices/lab_pin.sym} 119550 -41290 0 1 {name=p118156 lab=_41057_/A }
C {sky130_stdcells/dfxtp_4.sym} 119460 -41280 0 0 {name=X_82283_ }
C {devices/lab_pin.sym} 119420 -41150 0 0 {name=p118157 lab=_53097_/X }
C {devices/lab_pin.sym} 119500 -41150 0 1 {name=p118158 lab=_53211_/B }
C {sky130_stdcells/buf_2.sym} 119460 -41150 0 0 {name=X_53202_ }
C {devices/lab_pin.sym} 119370 -41030 0 0 {name=p118159 lab=_81169_/CLK }
C {devices/lab_pin.sym} 119370 -41010 0 0 {name=p118160 lab=_68166_/X }
C {devices/lab_pin.sym} 119550 -41030 0 1 {name=p118161 lab=_82062_/D }
C {sky130_stdcells/dfxtp_4.sym} 119460 -41020 0 0 {name=X_84022_ }
C {devices/lab_pin.sym} 119400 -40900 0 0 {name=p118162 lab=_50481_/A }
C {devices/lab_pin.sym} 119400 -40860 0 0 {name=p118163 lab=_48401_/B }
C {devices/lab_pin.sym} 119520 -40880 0 1 {name=p118164 lab=_50414_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -40880 0 0 {name=X_50414_ }
C {devices/lab_pin.sym} 119370 -40750 0 0 {name=p118165 lab=_81233_/CLK }
C {devices/lab_pin.sym} 119370 -40730 0 0 {name=p118166 lab=_81042_/Q }
C {devices/lab_pin.sym} 119550 -40750 0 1 {name=p118167 lab=_47674_/A }
C {sky130_stdcells/dfxtp_4.sym} 119460 -40740 0 0 {name=X_81234_ }
C {devices/lab_pin.sym} 119400 -40640 0 0 {name=p118168 lab=_54191_/A }
C {devices/lab_pin.sym} 119400 -40600 0 0 {name=p118169 lab=_54186_/B }
C {devices/lab_pin.sym} 119400 -40560 0 0 {name=p118170 lab=_54191_/C }
C {devices/lab_pin.sym} 119400 -40520 0 0 {name=p118171 lab=_53015_/D }
C {devices/lab_pin.sym} 119520 -40580 0 1 {name=p118172 lab=_54182_/X }
C {sky130_stdcells/and4_4.sym} 119460 -40580 0 0 {name=X_54182_ }
C {devices/lab_pin.sym} 119400 -40440 0 0 {name=p118173 lab=_65074_/A }
C {devices/lab_pin.sym} 119400 -40400 0 0 {name=p118174 lab=_66168_/B }
C {devices/lab_pin.sym} 119520 -40420 0 1 {name=p118175 lab=_66168_/X }
C {sky130_stdcells/and2_4.sym} 119460 -40420 0 0 {name=X_66168_ }
C {devices/lab_pin.sym} 119400 -40300 0 0 {name=p118176 lab=_51758_/A }
C {devices/lab_pin.sym} 119400 -40260 0 0 {name=p118177 lab=_51394_/B }
C {devices/lab_pin.sym} 119520 -40280 0 1 {name=p118178 lab=_51394_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -40280 0 0 {name=X_51394_ }
C {devices/lab_pin.sym} 119400 -40180 0 0 {name=p118179 lab=_53133_/A }
C {devices/lab_pin.sym} 119400 -40140 0 0 {name=p118180 lab=_53133_/B }
C {devices/lab_pin.sym} 119400 -40100 0 0 {name=p118181 lab=_53133_/C }
C {devices/lab_pin.sym} 119400 -40060 0 0 {name=p118182 lab=_53133_/D }
C {devices/lab_pin.sym} 119520 -40120 0 1 {name=p118183 lab=_53133_/X }
C {sky130_stdcells/and4_4.sym} 119460 -40120 0 0 {name=X_53133_ }
C {devices/lab_pin.sym} 119420 -39970 0 0 {name=p118184 lab=_64616_/A }
C {devices/lab_pin.sym} 119500 -39970 0 1 {name=p118185 lab=_65227_/A }
C {sky130_stdcells/buf_2.sym} 119460 -39970 0 0 {name=X_65119_ }
C {devices/lab_pin.sym} 119400 -39860 0 0 {name=p118186 lab=_50398_/A }
C {devices/lab_pin.sym} 119400 -39820 0 0 {name=p118187 lab=_52047_/B }
C {devices/lab_pin.sym} 119520 -39840 0 1 {name=p118188 lab=_50345_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -39840 0 0 {name=X_50345_ }
C {devices/lab_pin.sym} 119370 -39710 0 0 {name=p118189 lab=_81179_/CLK }
C {devices/lab_pin.sym} 119370 -39690 0 0 {name=p118190 lab=_74927_/B }
C {devices/lab_pin.sym} 119550 -39710 0 1 {name=p118191 lab=_41563_/A }
C {sky130_stdcells/dfxtp_4.sym} 119460 -39700 0 0 {name=X_81165_ }
C {devices/lab_pin.sym} 119420 -39570 0 0 {name=p118192 lab=_58990_/A }
C {devices/lab_pin.sym} 119500 -39570 0 1 {name=p118193 lab=_58990_/Y }
C {sky130_stdcells/inv_2.sym} 119460 -39570 0 0 {name=X_58990_ }
C {devices/lab_pin.sym} 119380 -39470 0 0 {name=p118194 lab=_66095_/X }
C {devices/lab_pin.sym} 119380 -39430 0 0 {name=p118195 lab=_66098_/X }
C {devices/lab_pin.sym} 119380 -39390 0 0 {name=p118196 lab=_66057_/X }
C {devices/lab_pin.sym} 119540 -39430 0 1 {name=p118197 lab=_66099_/X }
C {sky130_stdcells/a21o_4.sym} 119460 -39430 0 0 {name=X_66099_ }
C {devices/lab_pin.sym} 119400 -39300 0 0 {name=p118198 lab=_80117_/B }
C {devices/lab_pin.sym} 119400 -39260 0 0 {name=p118199 lab=_80103_/Y }
C {devices/lab_pin.sym} 119520 -39280 0 1 {name=p118200 lab=_80116_/X }
C {sky130_stdcells/or2_4.sym} 119460 -39280 0 0 {name=X_80116_ }
C {devices/lab_pin.sym} 119380 -39170 0 0 {name=p118201 lab=_53061_/Y }
C {devices/lab_pin.sym} 119380 -39130 0 0 {name=p118202 lab=_53056_/X }
C {devices/lab_pin.sym} 119380 -39090 0 0 {name=p118203 lab=_53063_/X }
C {devices/lab_pin.sym} 119540 -39130 0 1 {name=p118204 lab=_85704_/D }
C {sky130_stdcells/a21oi_4.sym} 119460 -39130 0 0 {name=X_53064_ }
C {devices/lab_pin.sym} 119380 -39010 0 0 {name=p118205 lab=_57939_/X }
C {devices/lab_pin.sym} 119380 -38970 0 0 {name=p118206 lab=_86002_/Q }
C {devices/lab_pin.sym} 119380 -38930 0 0 {name=p118207 lab=_57940_/X }
C {devices/lab_pin.sym} 119540 -38970 0 1 {name=p118208 lab=_57941_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -38970 0 0 {name=X_57941_ }
C {devices/lab_pin.sym} 119380 -38860 0 0 {name=p118209 lab=_69515_/Y }
C {devices/lab_pin.sym} 119380 -38820 0 0 {name=p118210 lab=_69916_/X }
C {devices/lab_pin.sym} 119380 -38780 0 0 {name=p118211 lab=_69870_/X }
C {devices/lab_pin.sym} 119380 -38740 0 0 {name=p118212 lab=_69926_/Y }
C {devices/lab_pin.sym} 119540 -38800 0 1 {name=p118213 lab=_69927_/X }
C {sky130_stdcells/a211o_4.sym} 119460 -38800 0 0 {name=X_69927_ }
C {devices/lab_pin.sym} 119380 -38670 0 0 {name=p118214 lab=_50273_/Y }
C {devices/lab_pin.sym} 119380 -38630 0 0 {name=p118215 lab=_50274_/X }
C {devices/lab_pin.sym} 119380 -38590 0 0 {name=p118216 lab=_50275_/Y }
C {devices/lab_pin.sym} 119540 -38630 0 1 {name=p118217 lab=_50276_/Y }
C {sky130_stdcells/a21boi_4.sym} 119460 -38630 0 0 {name=X_50276_ }
C {devices/lab_pin.sym} 119370 -38490 0 0 {name=p118218 lab=_84787_/CLK }
C {devices/lab_pin.sym} 119370 -38470 0 0 {name=p118219 lab=_85973_/D }
C {devices/lab_pin.sym} 119550 -38490 0 1 {name=p118220 lab=_85973_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -38480 0 0 {name=X_85973_ }
C {devices/lab_pin.sym} 119370 -38350 0 0 {name=p118221 lab=_82220_/CLK }
C {devices/lab_pin.sym} 119370 -38330 0 0 {name=p118222 lab=_79624_/X }
C {devices/lab_pin.sym} 119550 -38350 0 1 {name=p118223 lab=_81096_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -38340 0 0 {name=X_81096_ }
C {devices/lab_pin.sym} 119400 -38220 0 0 {name=p118224 lab=_52014_/X }
C {devices/lab_pin.sym} 119400 -38180 0 0 {name=p118225 lab=_50310_/B }
C {devices/lab_pin.sym} 119520 -38200 0 1 {name=p118226 lab=_52015_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -38200 0 0 {name=X_52015_ }
C {devices/lab_pin.sym} 119370 -38070 0 0 {name=p118227 lab=_87210_/CLK }
C {devices/lab_pin.sym} 119370 -38050 0 0 {name=p118228 lab=_87712_/D }
C {devices/lab_pin.sym} 119550 -38070 0 1 {name=p118229 lab=_67793_/B }
C {sky130_stdcells/dfxtp_4.sym} 119460 -38060 0 0 {name=X_87712_ }
C {devices/lab_pin.sym} 119370 -37930 0 0 {name=p118230 lab=_85375_/CLK }
C {devices/lab_pin.sym} 119370 -37910 0 0 {name=p118231 lab=_84924_/D }
C {devices/lab_pin.sym} 119550 -37930 0 1 {name=p118232 lab=_58108_/A }
C {sky130_stdcells/dfxtp_4.sym} 119460 -37920 0 0 {name=X_84924_ }
C {devices/lab_pin.sym} 119380 -37810 0 0 {name=p118233 lab=_57996_/Y }
C {devices/lab_pin.sym} 119380 -37770 0 0 {name=p118234 lab=_65745_/C }
C {devices/lab_pin.sym} 119380 -37730 0 0 {name=p118235 lab=_80046_/Y }
C {devices/lab_pin.sym} 119540 -37770 0 1 {name=p118236 lab=_80047_/X }
C {sky130_stdcells/o21a_4.sym} 119460 -37770 0 0 {name=X_80047_ }
C {devices/lab_pin.sym} 119420 -37630 0 0 {name=p118237 lab=_57872_/A }
C {devices/lab_pin.sym} 119500 -37630 0 1 {name=p118238 lab=_57872_/X }
C {sky130_stdcells/buf_2.sym} 119460 -37630 0 0 {name=X_57872_ }
C {devices/lab_pin.sym} 119380 -37530 0 0 {name=p118239 lab=_81964_/D }
C {devices/lab_pin.sym} 119380 -37490 0 0 {name=p118240 lab=_69831_/X }
C {devices/lab_pin.sym} 119380 -37450 0 0 {name=p118241 lab=_69857_/X }
C {devices/lab_pin.sym} 119540 -37490 0 1 {name=p118242 lab=_83892_/D }
C {sky130_stdcells/a21bo_4.sym} 119460 -37490 0 0 {name=X_69858_ }
C {devices/lab_pin.sym} 119400 -37370 0 0 {name=p118243 lab=_59557_/A }
C {devices/lab_pin.sym} 119400 -37330 0 0 {name=p118244 lab=_43995_/A }
C {devices/lab_pin.sym} 119400 -37290 0 0 {name=p118245 lab=_59609_/D }
C {devices/lab_pin.sym} 119520 -37330 0 1 {name=p118246 lab=_59611_/X }
C {sky130_stdcells/and3_4.sym} 119460 -37330 0 0 {name=X_59611_ }
C {devices/lab_pin.sym} 119380 -37210 0 0 {name=p118247 lab=_56821_/X }
C {devices/lab_pin.sym} 119380 -37170 0 0 {name=p118248 lab=_56738_/X }
C {devices/lab_pin.sym} 119380 -37130 0 0 {name=p118249 lab=_56822_/Y }
C {devices/lab_pin.sym} 119540 -37170 0 1 {name=p118250 lab=_56823_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -37170 0 0 {name=X_56823_ }
C {devices/lab_pin.sym} 119380 -37060 0 0 {name=p118251 lab=_86990_/Q }
C {devices/lab_pin.sym} 119380 -37020 0 0 {name=p118252 lab=_68707_/X }
C {devices/lab_pin.sym} 119380 -36980 0 0 {name=p118253 lab=_68762_/X }
C {devices/lab_pin.sym} 119380 -36940 0 0 {name=p118254 lab=_68808_/X }
C {devices/lab_pin.sym} 119540 -37000 0 1 {name=p118255 lab=_68809_/X }
C {sky130_stdcells/a211o_4.sym} 119460 -37000 0 0 {name=X_68809_ }
C {devices/lab_pin.sym} 119370 -36850 0 0 {name=p118256 lab=_86920_/CLK }
C {devices/lab_pin.sym} 119370 -36830 0 0 {name=p118257 lab=_42936_/Y }
C {devices/lab_pin.sym} 119550 -36850 0 1 {name=p118258 lab=_67912_/B }
C {sky130_stdcells/dfxtp_4.sym} 119460 -36840 0 0 {name=X_87643_ }
C {devices/lab_pin.sym} 119370 -36710 0 0 {name=p118259 lab=_84263_/CLK }
C {devices/lab_pin.sym} 119370 -36690 0 0 {name=p118260 lab=_58413_/X }
C {devices/lab_pin.sym} 119550 -36710 0 1 {name=p118261 lab=_84855_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -36700 0 0 {name=X_84855_ }
C {devices/lab_pin.sym} 119420 -36570 0 0 {name=p118262 lab=clkbuf_9_231_0_CLK/X }
C {devices/lab_pin.sym} 119500 -36570 0 1 {name=p118263 lab=_84787_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 119460 -36570 0 0 {name=Xclkbuf_10_463_0_CLK }
C {devices/lab_pin.sym} 119420 -36450 0 0 {name=p118264 lab=_64665_/A }
C {devices/lab_pin.sym} 119500 -36450 0 1 {name=p118265 lab=_69791_/A }
C {sky130_stdcells/buf_2.sym} 119460 -36450 0 0 {name=X_69789_ }
C {devices/lab_pin.sym} 119380 -36350 0 0 {name=p118266 lab=_71804_/Y }
C {devices/lab_pin.sym} 119380 -36310 0 0 {name=p118267 lab=_83363_/Q }
C {devices/lab_pin.sym} 119380 -36270 0 0 {name=p118268 lab=_71819_/X }
C {devices/lab_pin.sym} 119540 -36310 0 1 {name=p118269 lab=_83363_/D }
C {sky130_stdcells/a21o_4.sym} 119460 -36310 0 0 {name=X_71820_ }
C {devices/lab_pin.sym} 119380 -36190 0 0 {name=p118270 lab=_44216_/X }
C {devices/lab_pin.sym} 119380 -36150 0 0 {name=p118271 lab=_44217_/X }
C {devices/lab_pin.sym} 119380 -36110 0 0 {name=p118272 lab=_44008_/A }
C {devices/lab_pin.sym} 119540 -36150 0 1 {name=p118273 lab=_59543_/A }
C {sky130_stdcells/a21oi_4.sym} 119460 -36150 0 0 {name=X_59542_ }
C {devices/lab_pin.sym} 119370 -36010 0 0 {name=p118274 lab=_81807_/CLK }
C {devices/lab_pin.sym} 119370 -35990 0 0 {name=p118275 lab=_70300_/X }
C {devices/lab_pin.sym} 119550 -36010 0 1 {name=p118276 lab=_74783_/A }
C {sky130_stdcells/dfxtp_4.sym} 119460 -36000 0 0 {name=X_83806_ }
C {devices/lab_pin.sym} 119420 -35870 0 0 {name=p118277 lab=_56736_/X }
C {devices/lab_pin.sym} 119500 -35870 0 1 {name=p118278 lab=_56764_/C }
C {sky130_stdcells/inv_2.sym} 119460 -35870 0 0 {name=X_56754_ }
C {devices/lab_pin.sym} 119370 -35750 0 0 {name=p118279 lab=_87542_/CLK }
C {devices/lab_pin.sym} 119370 -35730 0 0 {name=p118280 lab=_87574_/D }
C {devices/lab_pin.sym} 119550 -35750 0 1 {name=p118281 lab=_43103_/A }
C {sky130_stdcells/dfxtp_4.sym} 119460 -35740 0 0 {name=X_87574_ }
C {devices/lab_pin.sym} 119420 -35610 0 0 {name=p118282 lab=_41980_/A }
C {devices/lab_pin.sym} 119500 -35610 0 1 {name=p118283 lab=_41980_/Y }
C {sky130_stdcells/inv_2.sym} 119460 -35610 0 0 {name=X_41980_ }
C {devices/lab_pin.sym} 119400 -35500 0 0 {name=p118284 lab=_53942_/A }
C {devices/lab_pin.sym} 119400 -35460 0 0 {name=p118285 lab=_46313_/Y }
C {devices/lab_pin.sym} 119520 -35480 0 1 {name=p118286 lab=_53966_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -35480 0 0 {name=X_53966_ }
C {devices/lab_pin.sym} 119370 -35350 0 0 {name=p118287 lab=_86372_/CLK }
C {devices/lab_pin.sym} 119370 -35330 0 0 {name=p118288 lab=_84786_/D }
C {devices/lab_pin.sym} 119550 -35350 0 1 {name=p118289 lab=_84786_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -35340 0 0 {name=X_84786_ }
C {devices/lab_pin.sym} 119370 -35210 0 0 {name=p118290 lab=_81985_/CLK }
C {devices/lab_pin.sym} 119370 -35190 0 0 {name=p118291 lab=_81998_/D }
C {devices/lab_pin.sym} 119550 -35210 0 1 {name=p118292 lab=_81998_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -35200 0 0 {name=X_81998_ }
C {devices/lab_pin.sym} 119380 -35100 0 0 {name=p118293 lab=_85190_/Q }
C {devices/lab_pin.sym} 119380 -35060 0 0 {name=p118294 lab=_55272_/A }
C {devices/lab_pin.sym} 119380 -35020 0 0 {name=p118295 lab=_55128_/X }
C {devices/lab_pin.sym} 119380 -34980 0 0 {name=p118296 lab=_55704_/X }
C {devices/lab_pin.sym} 119540 -35040 0 1 {name=p118297 lab=_55705_/X }
C {sky130_stdcells/a211o_4.sym} 119460 -35040 0 0 {name=X_55705_ }
C {devices/lab_pin.sym} 119370 -34890 0 0 {name=p118298 lab=_86525_/CLK }
C {devices/lab_pin.sym} 119370 -34870 0 0 {name=p118299 lab=_86525_/D }
C {devices/lab_pin.sym} 119550 -34890 0 1 {name=p118300 lab=_86525_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -34880 0 0 {name=X_86525_ }
C {devices/lab_pin.sym} 119380 -34770 0 0 {name=p118301 lab=_52915_/Y }
C {devices/lab_pin.sym} 119380 -34730 0 0 {name=p118302 lab=_52892_/X }
C {devices/lab_pin.sym} 119380 -34690 0 0 {name=p118303 lab=_52916_/X }
C {devices/lab_pin.sym} 119540 -34730 0 1 {name=p118304 lab=_52917_/Y }
C {sky130_stdcells/a21oi_4.sym} 119460 -34730 0 0 {name=X_52917_ }
C {devices/lab_pin.sym} 119420 -34590 0 0 {name=p118305 lab=_40931_/A }
C {devices/lab_pin.sym} 119500 -34590 0 1 {name=p118306 lab=_40931_/X }
C {sky130_stdcells/buf_2.sym} 119460 -34590 0 0 {name=X_40931_ }
C {devices/lab_pin.sym} 119400 -34500 0 0 {name=p118307 lab=_71178_/A }
C {devices/lab_pin.sym} 119400 -34460 0 0 {name=p118308 lab=_71753_/B }
C {devices/lab_pin.sym} 119400 -34420 0 0 {name=p118309 lab=_71744_/C }
C {devices/lab_pin.sym} 119400 -34380 0 0 {name=p118310 lab=_71744_/D }
C {devices/lab_pin.sym} 119520 -34440 0 1 {name=p118311 lab=_71751_/Y }
C {sky130_stdcells/nand4_4.sym} 119460 -34440 0 0 {name=X_71751_ }
C {devices/lab_pin.sym} 119370 -34290 0 0 {name=p118312 lab=_83736_/CLK }
C {devices/lab_pin.sym} 119370 -34270 0 0 {name=p118313 lab=_83737_/D }
C {devices/lab_pin.sym} 119550 -34290 0 1 {name=p118314 lab=_47372_/A }
C {sky130_stdcells/dfxtp_4.sym} 119460 -34280 0 0 {name=X_83737_ }
C {devices/lab_pin.sym} 119420 -34150 0 0 {name=p118315 lab=_84722_/Q }
C {devices/lab_pin.sym} 119500 -34150 0 1 {name=p118316 lab=_59474_/A }
C {sky130_stdcells/inv_2.sym} 119460 -34150 0 0 {name=X_59473_ }
C {devices/lab_pin.sym} 119400 -34040 0 0 {name=p118317 lab=_56672_/Y }
C {devices/lab_pin.sym} 119400 -34000 0 0 {name=p118318 lab=_56685_/B }
C {devices/lab_pin.sym} 119520 -34020 0 1 {name=p118319 lab=_56685_/X }
C {sky130_stdcells/xor2_4.sym} 119460 -34020 0 0 {name=X_56685_ }
C {devices/lab_pin.sym} 119370 -33890 0 0 {name=p118320 lab=_81211_/CLK }
C {devices/lab_pin.sym} 119370 -33870 0 0 {name=p118321 lab=_80949_/D }
C {devices/lab_pin.sym} 119550 -33890 0 1 {name=p118322 lab=_80949_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -33880 0 0 {name=X_80949_ }
C {devices/lab_pin.sym} 119420 -33750 0 0 {name=p118323 lab=_53956_/A }
C {devices/lab_pin.sym} 119500 -33750 0 1 {name=p118324 lab=_53898_/A }
C {sky130_stdcells/buf_2.sym} 119460 -33750 0 0 {name=X_53897_ }
C {devices/lab_pin.sym} 119420 -33630 0 0 {name=p118325 lab=_70712_/A }
C {devices/lab_pin.sym} 119500 -33630 0 1 {name=p118326 lab=_70866_/A }
C {sky130_stdcells/buf_2.sym} 119460 -33630 0 0 {name=X_70702_ }
C {devices/lab_pin.sym} 119420 -33510 0 0 {name=p118327 lab=_84851_/Q }
C {devices/lab_pin.sym} 119500 -33510 0 1 {name=p118328 lab=_58424_/Y }
C {sky130_stdcells/inv_2.sym} 119460 -33510 0 0 {name=X_58424_ }
C {devices/lab_pin.sym} 119420 -33390 0 0 {name=p118329 lab=_43649_/X }
C {devices/lab_pin.sym} 119500 -33390 0 1 {name=p118330 lab=_87327_/D }
C {sky130_stdcells/inv_2.sym} 119460 -33390 0 0 {name=X_43650_ }
C {devices/lab_pin.sym} 119380 -33300 0 0 {name=p118331 lab=_85121_/Q }
C {devices/lab_pin.sym} 119380 -33260 0 0 {name=p118332 lab=_55617_/X }
C {devices/lab_pin.sym} 119380 -33220 0 0 {name=p118333 lab=_44052_/A }
C {devices/lab_pin.sym} 119380 -33180 0 0 {name=p118334 lab=_55635_/Y }
C {devices/lab_pin.sym} 119540 -33240 0 1 {name=p118335 lab=_55636_/X }
C {sky130_stdcells/a211o_4.sym} 119460 -33240 0 0 {name=X_55636_ }
C {devices/lab_pin.sym} 119420 -33090 0 0 {name=p118336 lab=clkbuf_9_239_0_CLK/X }
C {devices/lab_pin.sym} 119500 -33090 0 1 {name=p118337 lab=_86091_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 119460 -33090 0 0 {name=Xclkbuf_10_478_0_CLK }
C {devices/lab_pin.sym} 119400 -32980 0 0 {name=p118338 lab=_74442_/X }
C {devices/lab_pin.sym} 119400 -32940 0 0 {name=p118339 lab=_48602_/Y }
C {devices/lab_pin.sym} 119520 -32960 0 1 {name=p118340 lab=_74470_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -32960 0 0 {name=X_74470_ }
C {devices/lab_pin.sym} 119370 -32830 0 0 {name=p118341 lab=_83303_/CLK }
C {devices/lab_pin.sym} 119370 -32810 0 0 {name=p118342 lab=_48980_/Y }
C {devices/lab_pin.sym} 119550 -32830 0 1 {name=p118343 lab=_86456_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -32820 0 0 {name=X_86456_ }
C {devices/lab_pin.sym} 119380 -32730 0 0 {name=p118344 lab=_40835_/X }
C {devices/lab_pin.sym} 119380 -32690 0 0 {name=p118345 lab=_40836_/X }
C {devices/lab_pin.sym} 119380 -32650 0 0 {name=p118346 lab=_40861_/X }
C {devices/lab_pin.sym} 119380 -32610 0 0 {name=p118347 lab=_88321_/Q }
C {devices/lab_pin.sym} 119380 -32570 0 0 {name=p118348 lab=_40832_/X }
C {devices/lab_pin.sym} 119540 -32650 0 1 {name=p118349 lab=_40862_/Y }
C {sky130_stdcells/o32ai_4.sym} 119460 -32650 0 0 {name=X_40862_ }
C {devices/lab_pin.sym} 119420 -32490 0 0 {name=p118350 lab=_52821_/A }
C {devices/lab_pin.sym} 119500 -32490 0 1 {name=p118351 lab=_52848_/X }
C {sky130_stdcells/buf_2.sym} 119460 -32490 0 0 {name=X_52848_ }
C {devices/lab_pin.sym} 119420 -32370 0 0 {name=p118352 lab=_71669_/A }
C {devices/lab_pin.sym} 119500 -32370 0 1 {name=p118353 lab=_71682_/Y }
C {sky130_stdcells/inv_2.sym} 119460 -32370 0 0 {name=X_71682_ }
C {devices/lab_pin.sym} 119370 -32250 0 0 {name=p118354 lab=_86091_/CLK }
C {devices/lab_pin.sym} 119370 -32230 0 0 {name=p118355 lab=_70902_/Y }
C {devices/lab_pin.sym} 119550 -32250 0 1 {name=p118356 lab=_83668_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -32240 0 0 {name=X_83668_ }
C {devices/lab_pin.sym} 119380 -32150 0 0 {name=p118357 lab=_42568_/X }
C {devices/lab_pin.sym} 119380 -32110 0 0 {name=p118358 lab=_40881_/A }
C {devices/lab_pin.sym} 119380 -32070 0 0 {name=p118359 lab=_42477_/X }
C {devices/lab_pin.sym} 119380 -32030 0 0 {name=p118360 lab=_42600_/Y }
C {devices/lab_pin.sym} 119380 -31990 0 0 {name=p118361 lab=_42571_/X }
C {devices/lab_pin.sym} 119540 -32070 0 1 {name=p118362 lab=_42601_/Y }
C {sky130_stdcells/o32ai_4.sym} 119460 -32070 0 0 {name=X_42601_ }
C {devices/lab_pin.sym} 119420 -31910 0 0 {name=p118363 lab=_73704_/A }
C {devices/lab_pin.sym} 119500 -31910 0 1 {name=p118364 lab=_73421_/X }
C {sky130_stdcells/buf_2.sym} 119460 -31910 0 0 {name=X_73421_ }
C {devices/lab_pin.sym} 119370 -31790 0 0 {name=p118365 lab=_85407_/CLK }
C {devices/lab_pin.sym} 119370 -31770 0 0 {name=p118366 lab=_54631_/Y }
C {devices/lab_pin.sym} 119550 -31790 0 1 {name=p118367 lab=_85407_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -31780 0 0 {name=X_85407_ }
C {devices/lab_pin.sym} 119400 -31680 0 0 {name=p118368 lab=_71115_/C }
C {devices/lab_pin.sym} 119400 -31640 0 0 {name=p118369 lab=_70412_/X }
C {devices/lab_pin.sym} 119400 -31600 0 0 {name=p118370 lab=_70933_/B }
C {devices/lab_pin.sym} 119400 -31560 0 0 {name=p118371 lab=_71287_/C }
C {devices/lab_pin.sym} 119520 -31620 0 1 {name=p118372 lab=_70633_/X }
C {sky130_stdcells/and4_4.sym} 119460 -31620 0 0 {name=X_70633_ }
C {devices/lab_pin.sym} 119420 -31470 0 0 {name=p118373 lab=_63316_/A }
C {devices/lab_pin.sym} 119500 -31470 0 1 {name=p118374 lab=_61656_/A }
C {sky130_stdcells/buf_2.sym} 119460 -31470 0 0 {name=X_58355_ }
C {devices/lab_pin.sym} 119370 -31350 0 0 {name=p118375 lab=_82589_/CLK }
C {devices/lab_pin.sym} 119370 -31330 0 0 {name=p118376 lab=_79035_/B }
C {devices/lab_pin.sym} 119550 -31350 0 1 {name=p118377 lab=_82619_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -31340 0 0 {name=X_82619_ }
C {devices/lab_pin.sym} 119420 -31210 0 0 {name=p118378 lab=_40591_/B }
C {devices/lab_pin.sym} 119500 -31210 0 1 {name=p118379 lab=_46612_/A }
C {sky130_stdcells/buf_2.sym} 119460 -31210 0 0 {name=X_43581_ }
C {devices/lab_pin.sym} 119400 -31100 0 0 {name=p118380 lab=_55534_/A }
C {devices/lab_pin.sym} 119400 -31060 0 0 {name=p118381 lab=_56604_/B }
C {devices/lab_pin.sym} 119520 -31080 0 1 {name=p118382 lab=_55567_/X }
C {sky130_stdcells/and2_4.sym} 119460 -31080 0 0 {name=X_55567_ }
C {devices/lab_pin.sym} 119370 -30950 0 0 {name=p118383 lab=_83673_/CLK }
C {devices/lab_pin.sym} 119370 -30930 0 0 {name=p118384 lab=_49442_/Y }
C {devices/lab_pin.sym} 119550 -30950 0 1 {name=p118385 lab=_58750_/B }
C {sky130_stdcells/dfxtp_4.sym} 119460 -30940 0 0 {name=X_86387_ }
C {devices/lab_pin.sym} 119400 -30840 0 0 {name=p118386 lab=_52775_/A }
C {devices/lab_pin.sym} 119400 -30800 0 0 {name=p118387 lab=_52775_/B }
C {devices/lab_pin.sym} 119400 -30760 0 0 {name=p118388 lab=_52775_/C }
C {devices/lab_pin.sym} 119400 -30720 0 0 {name=p118389 lab=_52779_/D }
C {devices/lab_pin.sym} 119520 -30780 0 1 {name=p118390 lab=_52779_/X }
C {sky130_stdcells/and4_4.sym} 119460 -30780 0 0 {name=X_52779_ }
C {devices/lab_pin.sym} 119420 -30630 0 0 {name=p118391 lab=_40793_/A }
C {devices/lab_pin.sym} 119500 -30630 0 1 {name=p118392 lab=_40793_/X }
C {sky130_stdcells/buf_2.sym} 119460 -30630 0 0 {name=X_40793_ }
C {devices/lab_pin.sym} 119370 -30510 0 0 {name=p118393 lab=_86145_/CLK }
C {devices/lab_pin.sym} 119370 -30490 0 0 {name=p118394 lab=_83599_/D }
C {devices/lab_pin.sym} 119550 -30510 0 1 {name=p118395 lab=_83599_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -30500 0 0 {name=X_83599_ }
C {devices/lab_pin.sym} 119380 -30390 0 0 {name=p118396 lab=_57304_/Y }
C {devices/lab_pin.sym} 119380 -30350 0 0 {name=p118397 lab=_57305_/Y }
C {devices/lab_pin.sym} 119380 -30310 0 0 {name=p118398 lab=_56995_/X }
C {devices/lab_pin.sym} 119540 -30350 0 1 {name=p118399 lab=_57306_/Y }
C {sky130_stdcells/a21oi_4.sym} 119460 -30350 0 0 {name=X_57306_ }
C {devices/lab_pin.sym} 119380 -30230 0 0 {name=p118400 lab=_45317_/X }
C {devices/lab_pin.sym} 119380 -30190 0 0 {name=p118401 lab=_45319_/Y }
C {devices/lab_pin.sym} 119380 -30150 0 0 {name=p118402 lab=_45275_/X }
C {devices/lab_pin.sym} 119540 -30190 0 1 {name=p118403 lab=_45320_/Y }
C {sky130_stdcells/a21oi_4.sym} 119460 -30190 0 0 {name=X_45320_ }
C {devices/lab_pin.sym} 119380 -30070 0 0 {name=p118404 lab=_76138_/Y }
C {devices/lab_pin.sym} 119380 -30030 0 0 {name=p118405 lab=_76134_/Y }
C {devices/lab_pin.sym} 119380 -29990 0 0 {name=p118406 lab=_76139_/Y }
C {devices/lab_pin.sym} 119540 -30030 0 1 {name=p118407 lab=_76143_/A }
C {sky130_stdcells/o21ai_4.sym} 119460 -30030 0 0 {name=X_76140_ }
C {devices/lab_pin.sym} 119370 -29890 0 0 {name=p118408 lab=_88128_/CLK }
C {devices/lab_pin.sym} 119370 -29870 0 0 {name=p118409 lab=_88126_/D }
C {devices/lab_pin.sym} 119550 -29890 0 1 {name=p118410 lab=_88126_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -29880 0 0 {name=X_88126_ }
C {devices/lab_pin.sym} 119400 -29760 0 0 {name=p118411 lab=_54518_/A }
C {devices/lab_pin.sym} 119400 -29720 0 0 {name=p118412 lab=_47053_/A }
C {devices/lab_pin.sym} 119520 -29740 0 1 {name=p118413 lab=_54518_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -29740 0 0 {name=X_54518_ }
C {devices/lab_pin.sym} 119380 -29650 0 0 {name=p118414 lab=_42521_/X }
C {devices/lab_pin.sym} 119380 -29610 0 0 {name=p118415 lab=_42522_/X }
C {devices/lab_pin.sym} 119380 -29570 0 0 {name=p118416 lab=_40743_/X }
C {devices/lab_pin.sym} 119380 -29530 0 0 {name=p118417 lab=_69052_/A }
C {devices/lab_pin.sym} 119380 -29490 0 0 {name=p118418 lab=_42506_/X }
C {devices/lab_pin.sym} 119540 -29570 0 1 {name=p118419 lab=_42532_/Y }
C {sky130_stdcells/o32ai_4.sym} 119460 -29570 0 0 {name=X_42532_ }
C {devices/lab_pin.sym} 119420 -29410 0 0 {name=p118420 lab=_73352_/A }
C {devices/lab_pin.sym} 119500 -29410 0 1 {name=p118421 lab=_73353_/A }
C {sky130_stdcells/buf_2.sym} 119460 -29410 0 0 {name=X_73352_ }
C {devices/lab_pin.sym} 119370 -29290 0 0 {name=p118422 lab=_85338_/CLK }
C {devices/lab_pin.sym} 119370 -29270 0 0 {name=p118423 lab=_55001_/Y }
C {devices/lab_pin.sym} 119550 -29290 0 1 {name=p118424 lab=_85338_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -29280 0 0 {name=X_85338_ }
C {devices/lab_pin.sym} 119400 -29180 0 0 {name=p118425 lab=_71863_/A }
C {devices/lab_pin.sym} 119400 -29140 0 0 {name=p118426 lab=_70549_/X }
C {devices/lab_pin.sym} 119400 -29100 0 0 {name=p118427 lab=_70568_/C }
C {devices/lab_pin.sym} 119400 -29060 0 0 {name=p118428 lab=_70568_/D }
C {devices/lab_pin.sym} 119520 -29120 0 1 {name=p118429 lab=_70564_/Y }
C {sky130_stdcells/nor4_4.sym} 119460 -29120 0 0 {name=X_70564_ }
C {devices/lab_pin.sym} 119380 -28990 0 0 {name=p118430 lab=_58282_/X }
C {devices/lab_pin.sym} 119380 -28950 0 0 {name=p118431 lab=_58283_/Y }
C {devices/lab_pin.sym} 119380 -28910 0 0 {name=p118432 lab=_58285_/Y }
C {devices/lab_pin.sym} 119540 -28950 0 1 {name=p118433 lab=_84888_/D }
C {sky130_stdcells/a21oi_4.sym} 119460 -28950 0 0 {name=X_58286_ }
C {devices/lab_pin.sym} 119420 -28810 0 0 {name=p118434 lab=_55492_/X }
C {devices/lab_pin.sym} 119500 -28810 0 1 {name=p118435 lab=_55498_/X }
C {sky130_stdcells/buf_2.sym} 119460 -28810 0 0 {name=X_55498_ }
C {devices/lab_pin.sym} 119420 -28690 0 0 {name=p118436 lab=clkbuf_9_200_0_CLK/X }
C {devices/lab_pin.sym} 119500 -28690 0 1 {name=p118437 lab=_82253_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 119460 -28690 0 0 {name=Xclkbuf_10_401_0_CLK }
C {devices/lab_pin.sym} 119420 -28570 0 0 {name=p118438 lab=_72417_/A }
C {devices/lab_pin.sym} 119500 -28570 0 1 {name=p118439 lab=_72303_/X }
C {sky130_stdcells/buf_2.sym} 119460 -28570 0 0 {name=X_72303_ }
C {devices/lab_pin.sym} 119380 -28470 0 0 {name=p118440 lab=_56253_/C }
C {devices/lab_pin.sym} 119380 -28430 0 0 {name=p118441 lab=_45222_/X }
C {devices/lab_pin.sym} 119380 -28390 0 0 {name=p118442 lab=_45250_/X }
C {devices/lab_pin.sym} 119540 -28430 0 1 {name=p118443 lab=_45251_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -28430 0 0 {name=X_45251_ }
C {devices/lab_pin.sym} 119380 -28330 0 0 {name=p118444 lab=_56561_/X }
C {devices/lab_pin.sym} 119380 -28290 0 0 {name=p118445 lab=_57322_/B }
C {devices/lab_pin.sym} 119380 -28250 0 0 {name=p118446 lab=_56931_/X }
C {devices/lab_pin.sym} 119380 -28210 0 0 {name=p118447 lab=_85057_/Q }
C {devices/lab_pin.sym} 119380 -28170 0 0 {name=p118448 lab=_57236_/X }
C {devices/lab_pin.sym} 119540 -28250 0 1 {name=p118449 lab=_85057_/D }
C {sky130_stdcells/a32o_4.sym} 119460 -28250 0 0 {name=X_57237_ }
C {devices/lab_pin.sym} 119400 -28100 0 0 {name=p118450 lab=_81718_/D }
C {devices/lab_pin.sym} 119400 -28060 0 0 {name=p118451 lab=_76062_/B }
C {devices/lab_pin.sym} 119520 -28080 0 1 {name=p118452 lab=_76071_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -28080 0 0 {name=X_76071_ }
C {devices/lab_pin.sym} 119420 -27950 0 0 {name=p118453 lab=_42463_/A }
C {devices/lab_pin.sym} 119500 -27950 0 1 {name=p118454 lab=_42463_/X }
C {sky130_stdcells/buf_2.sym} 119460 -27950 0 0 {name=X_42463_ }
C {devices/lab_pin.sym} 119370 -27830 0 0 {name=p118455 lab=_88062_/CLK }
C {devices/lab_pin.sym} 119370 -27810 0 0 {name=p118456 lab=_42051_/Y }
C {devices/lab_pin.sym} 119550 -27830 0 1 {name=p118457 lab=_88057_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -27820 0 0 {name=X_88057_ }
C {devices/lab_pin.sym} 119400 -27720 0 0 {name=p118458 lab=_54435_/A }
C {devices/lab_pin.sym} 119400 -27680 0 0 {name=p118459 lab=_54440_/B }
C {devices/lab_pin.sym} 119400 -27640 0 0 {name=p118460 lab=_54429_/C }
C {devices/lab_pin.sym} 119400 -27600 0 0 {name=p118461 lab=_54449_/D }
C {devices/lab_pin.sym} 119520 -27660 0 1 {name=p118462 lab=_54449_/X }
C {sky130_stdcells/and4_4.sym} 119460 -27660 0 0 {name=X_54449_ }
C {devices/lab_pin.sym} 119380 -27540 0 0 {name=p118463 lab=_73257_/X }
C {devices/lab_pin.sym} 119380 -27500 0 0 {name=p118464 lab=_86189_/Q }
C {devices/lab_pin.sym} 119380 -27460 0 0 {name=p118465 lab=_73205_/X }
C {devices/lab_pin.sym} 119380 -27420 0 0 {name=p118466 lab=_73282_/X }
C {devices/lab_pin.sym} 119540 -27480 0 1 {name=p118467 lab=_73283_/X }
C {sky130_stdcells/a211o_4.sym} 119460 -27480 0 0 {name=X_73283_ }
C {devices/lab_pin.sym} 119370 -27330 0 0 {name=p118468 lab=_85269_/CLK }
C {devices/lab_pin.sym} 119370 -27310 0 0 {name=p118469 lab=_56224_/Y }
C {devices/lab_pin.sym} 119550 -27330 0 1 {name=p118470 lab=_56223_/C }
C {sky130_stdcells/dfxtp_4.sym} 119460 -27320 0 0 {name=X_85269_ }
C {devices/lab_pin.sym} 119420 -27190 0 0 {name=p118471 lab=_70495_/A }
C {devices/lab_pin.sym} 119500 -27190 0 1 {name=p118472 lab=_70758_/B }
C {sky130_stdcells/buf_2.sym} 119460 -27190 0 0 {name=X_70495_ }
C {devices/lab_pin.sym} 119400 -27080 0 0 {name=p118473 lab=_44202_/A }
C {devices/lab_pin.sym} 119400 -27040 0 0 {name=p118474 lab=_44185_/X }
C {devices/lab_pin.sym} 119520 -27060 0 1 {name=p118475 lab=_44202_/X }
C {sky130_stdcells/or2_4.sym} 119460 -27060 0 0 {name=X_44202_ }
C {devices/lab_pin.sym} 119380 -26950 0 0 {name=p118476 lab=_75005_/Y }
C {devices/lab_pin.sym} 119380 -26910 0 0 {name=p118477 lab=_75019_/X }
C {devices/lab_pin.sym} 119380 -26870 0 0 {name=p118478 lab=_75021_/Y }
C {devices/lab_pin.sym} 119540 -26910 0 1 {name=p118479 lab=_75023_/B }
C {sky130_stdcells/a21oi_4.sym} 119460 -26910 0 0 {name=X_75022_ }
C {devices/lab_pin.sym} 119400 -26780 0 0 {name=p118480 lab=_41414_/A }
C {devices/lab_pin.sym} 119400 -26740 0 0 {name=p118481 lab=_41435_/B }
C {devices/lab_pin.sym} 119520 -26760 0 1 {name=p118482 lab=_41414_/X }
C {sky130_stdcells/or2_4.sym} 119460 -26760 0 0 {name=X_41414_ }
C {devices/lab_pin.sym} 119370 -26630 0 0 {name=p118483 lab=_88283_/CLK }
C {devices/lab_pin.sym} 119370 -26610 0 0 {name=p118484 lab=_44668_/X }
C {devices/lab_pin.sym} 119550 -26630 0 1 {name=p118485 lab=_87008_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -26620 0 0 {name=X_87008_ }
C {devices/lab_pin.sym} 119380 -26530 0 0 {name=p118486 lab=_72172_/X }
C {devices/lab_pin.sym} 119380 -26490 0 0 {name=p118487 lab=_72232_/Y }
C {devices/lab_pin.sym} 119380 -26450 0 0 {name=p118488 lab=_72233_/Y }
C {devices/lab_pin.sym} 119380 -26410 0 0 {name=p118489 lab=_72189_/X }
C {devices/lab_pin.sym} 119380 -26370 0 0 {name=p118490 lab=_72176_/X }
C {devices/lab_pin.sym} 119540 -26450 0 1 {name=p118491 lab=_72234_/X }
C {sky130_stdcells/o32a_4.sym} 119460 -26450 0 0 {name=X_72234_ }
C {devices/lab_pin.sym} 119400 -26300 0 0 {name=p118492 lab=_45182_/A }
C {devices/lab_pin.sym} 119400 -26260 0 0 {name=p118493 lab=_45182_/B }
C {devices/lab_pin.sym} 119520 -26280 0 1 {name=p118494 lab=_45182_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -26280 0 0 {name=X_45182_ }
C {devices/lab_pin.sym} 119400 -26170 0 0 {name=p118495 lab=_56797_/A }
C {devices/lab_pin.sym} 119400 -26130 0 0 {name=p118496 lab=_44239_/A }
C {devices/lab_pin.sym} 119400 -26090 0 0 {name=p118497 lab=_56796_/Y }
C {devices/lab_pin.sym} 119520 -26130 0 1 {name=p118498 lab=_57175_/A }
C {sky130_stdcells/nand3_4.sym} 119460 -26130 0 0 {name=X_57168_ }
C {devices/lab_pin.sym} 119380 -26020 0 0 {name=p118499 lab=_40404_/X }
C {devices/lab_pin.sym} 119380 -25980 0 0 {name=p118500 lab=_42388_/X }
C {devices/lab_pin.sym} 119380 -25940 0 0 {name=p118501 lab=_87884_/Q }
C {devices/lab_pin.sym} 119380 -25900 0 0 {name=p118502 lab=_42389_/X }
C {devices/lab_pin.sym} 119540 -25960 0 1 {name=p118503 lab=_87884_/D }
C {sky130_stdcells/a2bb2o_4.sym} 119460 -25960 0 0 {name=X_42394_ }
C {devices/lab_pin.sym} 119400 -25820 0 0 {name=p118504 lab=_73614_/A }
C {devices/lab_pin.sym} 119400 -25780 0 0 {name=p118505 lab=_44130_/X }
C {devices/lab_pin.sym} 119520 -25800 0 1 {name=p118506 lab=_44133_/Y }
C {sky130_stdcells/nor2_4.sym} 119460 -25800 0 0 {name=X_44133_ }
C {devices/lab_pin.sym} 119380 -25700 0 0 {name=p118507 lab=_79804_/X }
C {devices/lab_pin.sym} 119380 -25660 0 0 {name=p118508 lab=_79820_/B }
C {devices/lab_pin.sym} 119380 -25620 0 0 {name=p118509 lab=_79819_/A }
C {devices/lab_pin.sym} 119380 -25580 0 0 {name=p118510 lab=_79818_/Y }
C {devices/lab_pin.sym} 119540 -25640 0 1 {name=p118511 lab=_79830_/X }
C {sky130_stdcells/o22a_4.sym} 119460 -25640 0 0 {name=X_79830_ }
C {devices/lab_pin.sym} 119400 -25520 0 0 {name=p118512 lab=_56138_/B }
C {devices/lab_pin.sym} 119400 -25480 0 0 {name=p118513 lab=_55773_/D }
C {devices/lab_pin.sym} 119400 -25440 0 0 {name=p118514 lab=_55801_/B }
C {devices/lab_pin.sym} 119400 -25400 0 0 {name=p118515 lab=_55801_/C }
C {devices/lab_pin.sym} 119520 -25460 0 1 {name=p118516 lab=_56120_/B }
C {sky130_stdcells/nand4_4.sym} 119460 -25460 0 0 {name=X_56119_ }
C {devices/lab_pin.sym} 119400 -25320 0 0 {name=p118517 lab=_41513_/A }
C {devices/lab_pin.sym} 119400 -25280 0 0 {name=p118518 lab=_82902_/Q }
C {devices/lab_pin.sym} 119520 -25300 0 1 {name=p118519 lab=_41345_/X }
C {sky130_stdcells/or2_4.sym} 119460 -25300 0 0 {name=X_41345_ }
C {devices/lab_pin.sym} 119420 -25170 0 0 {name=p118520 lab=_72165_/A }
C {devices/lab_pin.sym} 119500 -25170 0 1 {name=p118521 lab=_72165_/Y }
C {sky130_stdcells/inv_2.sym} 119460 -25170 0 0 {name=X_72165_ }
C {devices/lab_pin.sym} 119400 -25080 0 0 {name=p118522 lab=_49995_/A }
C {devices/lab_pin.sym} 119400 -25040 0 0 {name=p118523 lab=_49973_/B }
C {devices/lab_pin.sym} 119400 -25000 0 0 {name=p118524 lab=_50005_/C }
C {devices/lab_pin.sym} 119400 -24960 0 0 {name=p118525 lab=_53203_/D }
C {devices/lab_pin.sym} 119520 -25020 0 1 {name=p118526 lab=_49990_/X }
C {sky130_stdcells/and4_4.sym} 119460 -25020 0 0 {name=X_49990_ }
C {devices/lab_pin.sym} 119420 -24870 0 0 {name=p118527 lab=clkbuf_9_208_0_CLK/X }
C {devices/lab_pin.sym} 119500 -24870 0 1 {name=p118528 lab=_82443_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 119460 -24870 0 0 {name=Xclkbuf_10_416_0_CLK }
C {devices/lab_pin.sym} 119420 -24750 0 0 {name=p118529 lab=_57221_/A }
C {devices/lab_pin.sym} 119500 -24750 0 1 {name=p118530 lab=_57099_/X }
C {sky130_stdcells/buf_2.sym} 119460 -24750 0 0 {name=X_57099_ }
C {devices/lab_pin.sym} 119420 -24630 0 0 {name=p118531 lab=_84835_/CLK }
C {devices/lab_pin.sym} 119500 -24630 0 1 {name=p118532 lab=_84839_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 119460 -24630 0 0 {name=Xclkbuf_opt_0_CLK }
C {devices/lab_pin.sym} 119420 -24510 0 0 {name=p118533 lab=_71115_/X }
C {devices/lab_pin.sym} 119500 -24510 0 1 {name=p118534 lab=_71117_/A }
C {sky130_stdcells/buf_2.sym} 119460 -24510 0 0 {name=X_71116_ }
C {devices/lab_pin.sym} 119380 -24410 0 0 {name=p118535 lab=_48933_/Y }
C {devices/lab_pin.sym} 119380 -24370 0 0 {name=p118536 lab=_48935_/X }
C {devices/lab_pin.sym} 119380 -24330 0 0 {name=p118537 lab=_48940_/X }
C {devices/lab_pin.sym} 119540 -24370 0 1 {name=p118538 lab=_48941_/Y }
C {sky130_stdcells/a21oi_4.sym} 119460 -24370 0 0 {name=X_48941_ }
C {devices/lab_pin.sym} 119420 -24230 0 0 {name=p118539 lab=_44063_/X }
C {devices/lab_pin.sym} 119500 -24230 0 1 {name=p118540 lab=_44064_/X }
C {sky130_stdcells/buf_2.sym} 119460 -24230 0 0 {name=X_44064_ }
C {devices/lab_pin.sym} 119400 -24120 0 0 {name=p118541 lab=_79761_/A }
C {devices/lab_pin.sym} 119400 -24080 0 0 {name=p118542 lab=_79761_/B }
C {devices/lab_pin.sym} 119520 -24100 0 1 {name=p118543 lab=_79761_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -24100 0 0 {name=X_79761_ }
C {devices/lab_pin.sym} 119380 -23990 0 0 {name=p118544 lab=_41242_/X }
C {devices/lab_pin.sym} 119380 -23950 0 0 {name=p118545 lab=_40751_/A }
C {devices/lab_pin.sym} 119380 -23910 0 0 {name=p118546 lab=_41275_/X }
C {devices/lab_pin.sym} 119540 -23950 0 1 {name=p118547 lab=_41276_/X }
C {sky130_stdcells/o21a_4.sym} 119460 -23950 0 0 {name=X_41276_ }
C {devices/lab_pin.sym} 119400 -23820 0 0 {name=p118548 lab=_72091_/X }
C {devices/lab_pin.sym} 119400 -23780 0 0 {name=p118549 lab=_49166_/Y }
C {devices/lab_pin.sym} 119520 -23800 0 1 {name=p118550 lab=_72096_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -23800 0 0 {name=X_72096_ }
C {devices/lab_pin.sym} 119400 -23680 0 0 {name=p118551 lab=_61057_/C }
C {devices/lab_pin.sym} 119400 -23640 0 0 {name=p118552 lab=_62606_/C }
C {devices/lab_pin.sym} 119520 -23660 0 1 {name=p118553 lab=_76973_/X }
C {sky130_stdcells/xor2_4.sym} 119460 -23660 0 0 {name=X_76973_ }
C {devices/lab_pin.sym} 119420 -23530 0 0 {name=p118554 lab=_43014_/Y }
C {devices/lab_pin.sym} 119500 -23530 0 1 {name=p118555 lab=_43030_/A }
C {sky130_stdcells/buf_2.sym} 119460 -23530 0 0 {name=X_43015_ }
C {devices/lab_pin.sym} 119420 -23410 0 0 {name=p118556 lab=_78712_/A }
C {devices/lab_pin.sym} 119500 -23410 0 1 {name=p118557 lab=_78712_/Y }
C {sky130_stdcells/inv_2.sym} 119460 -23410 0 0 {name=X_78712_ }
C {devices/lab_pin.sym} 119420 -23290 0 0 {name=p118558 lab=_71046_/X }
C {devices/lab_pin.sym} 119500 -23290 0 1 {name=p118559 lab=_71047_/X }
C {sky130_stdcells/buf_2.sym} 119460 -23290 0 0 {name=X_71047_ }
C {devices/lab_pin.sym} 119400 -23180 0 0 {name=p118560 lab=_81698_/D }
C {devices/lab_pin.sym} 119400 -23140 0 0 {name=p118561 lab=_75924_/B }
C {devices/lab_pin.sym} 119520 -23160 0 1 {name=p118562 lab=_75925_/B }
C {sky130_stdcells/xor2_4.sym} 119460 -23160 0 0 {name=X_75924_ }
C {devices/lab_pin.sym} 119400 -23040 0 0 {name=p118563 lab=_50056_/A }
C {devices/lab_pin.sym} 119400 -23000 0 0 {name=p118564 lab=_48872_/B }
C {devices/lab_pin.sym} 119520 -23020 0 1 {name=p118565 lab=_48872_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -23020 0 0 {name=X_48872_ }
C {devices/lab_pin.sym} 119400 -22900 0 0 {name=p118566 lab=_79692_/A }
C {devices/lab_pin.sym} 119400 -22860 0 0 {name=p118567 lab=_79692_/B }
C {devices/lab_pin.sym} 119520 -22880 0 1 {name=p118568 lab=_79692_/Y }
C {sky130_stdcells/xnor2_4.sym} 119460 -22880 0 0 {name=X_79692_ }
C {devices/lab_pin.sym} 119400 -22780 0 0 {name=p118569 lab=_49374_/A }
C {devices/lab_pin.sym} 119400 -22740 0 0 {name=p118570 lab=_49364_/B }
C {devices/lab_pin.sym} 119400 -22700 0 0 {name=p118571 lab=_50886_/C }
C {devices/lab_pin.sym} 119400 -22660 0 0 {name=p118572 lab=_53261_/D }
C {devices/lab_pin.sym} 119520 -22720 0 1 {name=p118573 lab=_47823_/X }
C {sky130_stdcells/and4_4.sym} 119460 -22720 0 0 {name=X_47823_ }
C {devices/lab_pin.sym} 119420 -22570 0 0 {name=p118574 lab=_61966_/A }
C {devices/lab_pin.sym} 119500 -22570 0 1 {name=p118575 lab=_59810_/A }
C {sky130_stdcells/buf_2.sym} 119460 -22570 0 0 {name=X_59809_ }
C {devices/lab_pin.sym} 119400 -22460 0 0 {name=p118576 lab=_78639_/Y }
C {devices/lab_pin.sym} 119400 -22420 0 0 {name=p118577 lab=_78642_/Y }
C {devices/lab_pin.sym} 119520 -22440 0 1 {name=p118578 lab=_82776_/D }
C {sky130_stdcells/xor2_4.sym} 119460 -22440 0 0 {name=X_78643_ }
C {devices/lab_pin.sym} 119420 -22310 0 0 {name=p118579 lab=_75840_/B }
C {devices/lab_pin.sym} 119500 -22310 0 1 {name=p118580 lab=_75855_/Y }
C {sky130_stdcells/inv_2.sym} 119460 -22310 0 0 {name=X_75855_ }
C {devices/lab_pin.sym} 119420 -22190 0 0 {name=p118581 lab=clkbuf_8_91_0_CLK/A }
C {devices/lab_pin.sym} 119500 -22190 0 1 {name=p118582 lab=clkbuf_8_90_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 119460 -22190 0 0 {name=Xclkbuf_8_90_0_CLK }
C {devices/lab_pin.sym} 119380 -22110 0 0 {name=p118583 lab=_57680_/A }
C {devices/lab_pin.sym} 119380 -22070 0 0 {name=p118584 lab=_62808_/X }
C {devices/lab_pin.sym} 119380 -22030 0 0 {name=p118585 lab=_62768_/X }
C {devices/lab_pin.sym} 119380 -21990 0 0 {name=p118586 lab=_62818_/X }
C {devices/lab_pin.sym} 119380 -21960 0 0 {name=p118587 lab=_62819_/X }
C {devices/lab_pin.sym} 119540 -22030 0 1 {name=p118588 lab=_62820_/Y }
C {sky130_stdcells/a41oi_4.sym} 119460 -22030 0 0 {name=X_62820_ }
C {devices/lab_pin.sym} 119400 -21900 0 0 {name=p118589 lab=_83793_/Q }
C {devices/lab_pin.sym} 119400 -21860 0 0 {name=p118590 lab=_74720_/C }
C {devices/lab_pin.sym} 119400 -21820 0 0 {name=p118591 lab=_74744_/X }
C {devices/lab_pin.sym} 119400 -21780 0 0 {name=p118592 lab=_74745_/D }
C {devices/lab_pin.sym} 119520 -21840 0 1 {name=p118593 lab=_74810_/A }
C {sky130_stdcells/nand4_4.sym} 119460 -21840 0 0 {name=X_74806_ }
C {devices/lab_pin.sym} 119380 -21710 0 0 {name=p118594 lab=_72405_/A }
C {devices/lab_pin.sym} 119380 -21670 0 0 {name=p118595 lab=_47714_/X }
C {devices/lab_pin.sym} 119380 -21630 0 0 {name=p118596 lab=_47753_/Y }
C {devices/lab_pin.sym} 119540 -21670 0 1 {name=p118597 lab=_47754_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -21670 0 0 {name=X_47754_ }
C {devices/lab_pin.sym} 119400 -21550 0 0 {name=p118598 lab=_78569_/X }
C {devices/lab_pin.sym} 119400 -21510 0 0 {name=p118599 lab=_78572_/Y }
C {devices/lab_pin.sym} 119400 -21470 0 0 {name=p118600 lab=_78574_/C }
C {devices/lab_pin.sym} 119520 -21510 0 1 {name=p118601 lab=_78575_/B }
C {sky130_stdcells/nand3_4.sym} 119460 -21510 0 0 {name=X_78574_ }
C {devices/lab_pin.sym} 119420 -21370 0 0 {name=p118602 lab=_44966_/A }
C {devices/lab_pin.sym} 119500 -21370 0 1 {name=p118603 lab=_44966_/Y }
C {sky130_stdcells/inv_2.sym} 119460 -21370 0 0 {name=X_44966_ }
C {devices/lab_pin.sym} 119400 -21260 0 0 {name=p118604 lab=_81098_/Q }
C {devices/lab_pin.sym} 119400 -21220 0 0 {name=p118605 lab=_75786_/B }
C {devices/lab_pin.sym} 119520 -21240 0 1 {name=p118606 lab=_75786_/X }
C {sky130_stdcells/xor2_4.sym} 119460 -21240 0 0 {name=X_75786_ }
C {devices/lab_pin.sym} 119400 -21120 0 0 {name=p118607 lab=_72997_/X }
C {devices/lab_pin.sym} 119400 -21080 0 0 {name=p118608 lab=_73191_/B }
C {devices/lab_pin.sym} 119520 -21100 0 1 {name=p118609 lab=_72998_/X }
C {sky130_stdcells/and2_4.sym} 119460 -21100 0 0 {name=X_72998_ }
C {devices/lab_pin.sym} 119420 -20970 0 0 {name=p118610 lab=_46845_/A }
C {devices/lab_pin.sym} 119500 -20970 0 1 {name=p118611 lab=_46717_/B }
C {sky130_stdcells/buf_2.sym} 119460 -20970 0 0 {name=X_46705_ }
C {devices/lab_pin.sym} 119380 -20870 0 0 {name=p118612 lab=_77512_/A }
C {devices/lab_pin.sym} 119380 -20830 0 0 {name=p118613 lab=_77523_/Y }
C {devices/lab_pin.sym} 119380 -20790 0 0 {name=p118614 lab=_77524_/Y }
C {devices/lab_pin.sym} 119540 -20830 0 1 {name=p118615 lab=_77525_/X }
C {sky130_stdcells/a21bo_4.sym} 119460 -20830 0 0 {name=X_77525_ }
C {devices/lab_pin.sym} 119420 -20690 0 0 {name=p118616 lab=_43896_/X }
C {devices/lab_pin.sym} 119500 -20690 0 1 {name=p118617 lab=_43917_/X }
C {sky130_stdcells/buf_2.sym} 119460 -20690 0 0 {name=X_43917_ }
C {devices/lab_pin.sym} 119400 -20590 0 0 {name=p118618 lab=_70625_/Y }
C {devices/lab_pin.sym} 119400 -20550 0 0 {name=p118619 lab=_71266_/A }
C {devices/lab_pin.sym} 119400 -20510 0 0 {name=p118620 lab=_71263_/D }
C {devices/lab_pin.sym} 119520 -20550 0 1 {name=p118621 lab=_74738_/A }
C {sky130_stdcells/and3_4.sym} 119460 -20550 0 0 {name=X_74737_ }
C {devices/lab_pin.sym} 119380 -20450 0 0 {name=p118622 lab=_57652_/X }
C {devices/lab_pin.sym} 119380 -20410 0 0 {name=p118623 lab=_62749_/X }
C {devices/lab_pin.sym} 119380 -20370 0 0 {name=p118624 lab=_62708_/X }
C {devices/lab_pin.sym} 119380 -20330 0 0 {name=p118625 lab=_62699_/X }
C {devices/lab_pin.sym} 119380 -20300 0 0 {name=p118626 lab=_62750_/X }
C {devices/lab_pin.sym} 119540 -20370 0 1 {name=p118627 lab=_62751_/Y }
C {sky130_stdcells/a41oi_4.sym} 119460 -20370 0 0 {name=X_62751_ }
C {devices/lab_pin.sym} 119380 -20230 0 0 {name=p118628 lab=_47681_/Y }
C {devices/lab_pin.sym} 119380 -20190 0 0 {name=p118629 lab=_47651_/X }
C {devices/lab_pin.sym} 119380 -20150 0 0 {name=p118630 lab=_47684_/X }
C {devices/lab_pin.sym} 119540 -20190 0 1 {name=p118631 lab=_86609_/D }
C {sky130_stdcells/a21oi_4.sym} 119460 -20190 0 0 {name=X_47685_ }
C {devices/lab_pin.sym} 119400 -20080 0 0 {name=p118632 lab=_74527_/A }
C {devices/lab_pin.sym} 119400 -20040 0 0 {name=p118633 lab=_70766_/C }
C {devices/lab_pin.sym} 119400 -20000 0 0 {name=p118634 lab=_71349_/D }
C {devices/lab_pin.sym} 119400 -19960 0 0 {name=p118635 lab=_71894_/Y }
C {devices/lab_pin.sym} 119520 -20020 0 1 {name=p118636 lab=_71949_/Y }
C {sky130_stdcells/nand4_4.sym} 119460 -20020 0 0 {name=X_71949_ }
C {devices/lab_pin.sym} 119420 -19870 0 0 {name=p118637 lab=_80672_/Q }
C {devices/lab_pin.sym} 119500 -19870 0 1 {name=p118638 lab=_45757_/A }
C {sky130_stdcells/buf_2.sym} 119460 -19870 0 0 {name=X_44897_ }
C {devices/lab_pin.sym} 119420 -19750 0 0 {name=p118639 lab=_49451_/A }
C {devices/lab_pin.sym} 119500 -19750 0 1 {name=p118640 lab=_49447_/B }
C {sky130_stdcells/buf_2.sym} 119460 -19750 0 0 {name=X_49424_ }
C {devices/lab_pin.sym} 119420 -19630 0 0 {name=p118641 lab=_59721_/X }
C {devices/lab_pin.sym} 119500 -19630 0 1 {name=p118642 lab=_61770_/A }
C {sky130_stdcells/buf_2.sym} 119460 -19630 0 0 {name=X_61702_ }
C {devices/lab_pin.sym} 119380 -19530 0 0 {name=p118643 lab=_86719_/Q }
C {devices/lab_pin.sym} 119380 -19490 0 0 {name=p118644 lab=_46622_/X }
C {devices/lab_pin.sym} 119380 -19450 0 0 {name=p118645 lab=_46635_/Y }
C {devices/lab_pin.sym} 119540 -19490 0 1 {name=p118646 lab=_46636_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -19490 0 0 {name=X_46636_ }
C {devices/lab_pin.sym} 119420 -19350 0 0 {name=p118647 lab=_65669_/A }
C {devices/lab_pin.sym} 119500 -19350 0 1 {name=p118648 lab=_65470_/X }
C {sky130_stdcells/buf_2.sym} 119460 -19350 0 0 {name=X_65470_ }
C {devices/lab_pin.sym} 119400 -19240 0 0 {name=p118649 lab=_77468_/A }
C {devices/lab_pin.sym} 119400 -19200 0 0 {name=p118650 lab=_77468_/B }
C {devices/lab_pin.sym} 119520 -19220 0 1 {name=p118651 lab=_77456_/X }
C {sky130_stdcells/xor2_4.sym} 119460 -19220 0 0 {name=X_77456_ }
C {devices/lab_pin.sym} 119380 -19130 0 0 {name=p118652 lab=_43846_/X }
C {devices/lab_pin.sym} 119380 -19090 0 0 {name=p118653 lab=_43824_/X }
C {devices/lab_pin.sym} 119380 -19050 0 0 {name=p118654 lab=_41193_/X }
C {devices/lab_pin.sym} 119380 -19010 0 0 {name=p118655 lab=_87236_/Q }
C {devices/lab_pin.sym} 119380 -18970 0 0 {name=p118656 lab=_43847_/X }
C {devices/lab_pin.sym} 119540 -19050 0 1 {name=p118657 lab=_43848_/Y }
C {sky130_stdcells/o32ai_4.sym} 119460 -19050 0 0 {name=X_43848_ }
C {devices/lab_pin.sym} 119420 -18890 0 0 {name=p118658 lab=_62681_/X }
C {devices/lab_pin.sym} 119500 -18890 0 1 {name=p118659 lab=_62694_/C }
C {sky130_stdcells/buf_2.sym} 119460 -18890 0 0 {name=X_62682_ }
C {devices/lab_pin.sym} 119380 -18790 0 0 {name=p118660 lab=_74673_/A }
C {devices/lab_pin.sym} 119380 -18750 0 0 {name=p118661 lab=_57153_/A }
C {devices/lab_pin.sym} 119380 -18710 0 0 {name=p118662 lab=_74667_/Y }
C {devices/lab_pin.sym} 119540 -18750 0 1 {name=p118663 lab=_74669_/A }
C {sky130_stdcells/o21ai_4.sym} 119460 -18750 0 0 {name=X_74668_ }
C {devices/lab_pin.sym} 119420 -18610 0 0 {name=p118664 lab=_64421_/A }
C {devices/lab_pin.sym} 119500 -18610 0 1 {name=p118665 lab=_64421_/X }
C {sky130_stdcells/buf_2.sym} 119460 -18610 0 0 {name=X_64421_ }
C {devices/lab_pin.sym} 119400 -18500 0 0 {name=p118666 lab=_81363_/Q }
C {devices/lab_pin.sym} 119400 -18460 0 0 {name=p118667 lab=_76407_/B }
C {devices/lab_pin.sym} 119520 -18480 0 1 {name=p118668 lab=_76407_/X }
C {sky130_stdcells/xor2_4.sym} 119460 -18480 0 0 {name=X_76407_ }
C {devices/lab_pin.sym} 119380 -18370 0 0 {name=p118669 lab=_49353_/Y }
C {devices/lab_pin.sym} 119380 -18330 0 0 {name=p118670 lab=_48194_/X }
C {devices/lab_pin.sym} 119380 -18290 0 0 {name=p118671 lab=_49354_/Y }
C {devices/lab_pin.sym} 119540 -18330 0 1 {name=p118672 lab=_86403_/D }
C {sky130_stdcells/a21boi_4.sym} 119460 -18330 0 0 {name=X_49355_ }
C {devices/lab_pin.sym} 119380 -18230 0 0 {name=p118673 lab=_61627_/Y }
C {devices/lab_pin.sym} 119380 -18190 0 0 {name=p118674 lab=_61629_/Y }
C {devices/lab_pin.sym} 119380 -18150 0 0 {name=p118675 lab=_61594_/X }
C {devices/lab_pin.sym} 119380 -18110 0 0 {name=p118676 lab=_61630_/Y }
C {devices/lab_pin.sym} 119380 -18080 0 0 {name=p118677 lab=_61632_/Y }
C {devices/lab_pin.sym} 119540 -18150 0 1 {name=p118678 lab=_61633_/X }
C {sky130_stdcells/a41o_4.sym} 119460 -18150 0 0 {name=X_61633_ }
C {devices/lab_pin.sym} 119400 -18000 0 0 {name=p118679 lab=_47853_/Y }
C {devices/lab_pin.sym} 119400 -17960 0 0 {name=p118680 lab=_73618_/Y }
C {devices/lab_pin.sym} 119520 -17980 0 1 {name=p118681 lab=_73619_/X }
C {sky130_stdcells/xor2_4.sym} 119460 -17980 0 0 {name=X_73619_ }
C {devices/lab_pin.sym} 119400 -17860 0 0 {name=p118682 lab=_46567_/A }
C {devices/lab_pin.sym} 119400 -17820 0 0 {name=p118683 lab=_46527_/X }
C {devices/lab_pin.sym} 119520 -17840 0 1 {name=p118684 lab=_46567_/X }
C {sky130_stdcells/or2_4.sym} 119460 -17840 0 0 {name=X_46567_ }
C {devices/lab_pin.sym} 119400 -17720 0 0 {name=p118685 lab=_77387_/A }
C {devices/lab_pin.sym} 119400 -17680 0 0 {name=p118686 lab=_77387_/B }
C {devices/lab_pin.sym} 119520 -17700 0 1 {name=p118687 lab=_77387_/X }
C {sky130_stdcells/or2_4.sym} 119460 -17700 0 0 {name=X_77387_ }
C {devices/lab_pin.sym} 119380 -17610 0 0 {name=p118688 lab=_43774_/X }
C {devices/lab_pin.sym} 119380 -17570 0 0 {name=p118689 lab=_43760_/X }
C {devices/lab_pin.sym} 119380 -17530 0 0 {name=p118690 lab=_41004_/X }
C {devices/lab_pin.sym} 119380 -17490 0 0 {name=p118691 lab=_87271_/Q }
C {devices/lab_pin.sym} 119380 -17450 0 0 {name=p118692 lab=_43776_/X }
C {devices/lab_pin.sym} 119540 -17530 0 1 {name=p118693 lab=_43779_/Y }
C {sky130_stdcells/o32ai_4.sym} 119460 -17530 0 0 {name=X_43779_ }
C {devices/lab_pin.sym} 119420 -17370 0 0 {name=p118694 lab=_74552_/X }
C {devices/lab_pin.sym} 119500 -17370 0 1 {name=p118695 lab=_74599_/X }
C {sky130_stdcells/buf_2.sym} 119460 -17370 0 0 {name=X_74599_ }
C {devices/lab_pin.sym} 119380 -17270 0 0 {name=p118696 lab=_66242_/B }
C {devices/lab_pin.sym} 119380 -17230 0 0 {name=p118697 lab=_48293_/X }
C {devices/lab_pin.sym} 119380 -17190 0 0 {name=p118698 lab=_48305_/Y }
C {devices/lab_pin.sym} 119540 -17230 0 1 {name=p118699 lab=_48306_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -17230 0 0 {name=X_48306_ }
C {devices/lab_pin.sym} 119380 -17110 0 0 {name=p118700 lab=_80906_/D }
C {devices/lab_pin.sym} 119380 -17070 0 0 {name=p118701 lab=_67092_/X }
C {devices/lab_pin.sym} 119380 -17030 0 0 {name=p118702 lab=_67139_/X }
C {devices/lab_pin.sym} 119540 -17070 0 1 {name=p118703 lab=_67140_/X }
C {sky130_stdcells/a21bo_4.sym} 119460 -17070 0 0 {name=X_67140_ }
C {devices/lab_pin.sym} 119400 -16940 0 0 {name=p118704 lab=_60612_/C }
C {devices/lab_pin.sym} 119400 -16900 0 0 {name=p118705 lab=_84458_/Q }
C {devices/lab_pin.sym} 119520 -16920 0 1 {name=p118706 lab=_79126_/X }
C {sky130_stdcells/xor2_4.sym} 119460 -16920 0 0 {name=X_79126_ }
C {devices/lab_pin.sym} 119380 -16820 0 0 {name=p118707 lab=_45515_/Y }
C {devices/lab_pin.sym} 119380 -16780 0 0 {name=p118708 lab=_45516_/X }
C {devices/lab_pin.sym} 119380 -16740 0 0 {name=p118709 lab=_45471_/X }
C {devices/lab_pin.sym} 119380 -16700 0 0 {name=p118710 lab=_45517_/Y }
C {devices/lab_pin.sym} 119540 -16760 0 1 {name=p118711 lab=_45518_/X }
C {sky130_stdcells/a211o_4.sym} 119460 -16760 0 0 {name=X_45518_ }
C {devices/lab_pin.sym} 119400 -16620 0 0 {name=p118712 lab=_76338_/A }
C {devices/lab_pin.sym} 119400 -16580 0 0 {name=p118713 lab=_76338_/B }
C {devices/lab_pin.sym} 119520 -16600 0 1 {name=p118714 lab=_76356_/A }
C {sky130_stdcells/xor2_4.sym} 119460 -16600 0 0 {name=X_76338_ }
C {devices/lab_pin.sym} 119400 -16500 0 0 {name=p118715 lab=_64304_/A }
C {devices/lab_pin.sym} 119400 -16460 0 0 {name=p118716 lab=_64303_/X }
C {devices/lab_pin.sym} 119400 -16420 0 0 {name=p118717 lab=_84957_/Q }
C {devices/lab_pin.sym} 119400 -16380 0 0 {name=p118718 lab=_64318_/D }
C {devices/lab_pin.sym} 119520 -16440 0 1 {name=p118719 lab=_64352_/X }
C {sky130_stdcells/and4_4.sym} 119460 -16440 0 0 {name=X_64352_ }
C {devices/lab_pin.sym} 119420 -16290 0 0 {name=p118720 lab=_48535_/A }
C {devices/lab_pin.sym} 119500 -16290 0 1 {name=p118721 lab=_49287_/A }
C {sky130_stdcells/buf_2.sym} 119460 -16290 0 0 {name=X_49286_ }
C {devices/lab_pin.sym} 119420 -16170 0 0 {name=p118722 lab=_61564_/A }
C {devices/lab_pin.sym} 119500 -16170 0 1 {name=p118723 lab=_61564_/Y }
C {sky130_stdcells/inv_2.sym} 119460 -16170 0 0 {name=X_61564_ }
C {devices/lab_pin.sym} 119400 -16070 0 0 {name=p118724 lab=_52528_/A }
C {devices/lab_pin.sym} 119400 -16030 0 0 {name=p118725 lab=_46487_/B }
C {devices/lab_pin.sym} 119400 -15990 0 0 {name=p118726 lab=_46472_/C }
C {devices/lab_pin.sym} 119520 -16030 0 1 {name=p118727 lab=_46498_/X }
C {sky130_stdcells/and3_4.sym} 119460 -16030 0 0 {name=X_46498_ }
C {devices/lab_pin.sym} 119380 -15930 0 0 {name=p118728 lab=_63248_/X }
C {devices/lab_pin.sym} 119380 -15890 0 0 {name=p118729 lab=_63298_/Y }
C {devices/lab_pin.sym} 119380 -15850 0 0 {name=p118730 lab=_63299_/X }
C {devices/lab_pin.sym} 119380 -15810 0 0 {name=p118731 lab=_63300_/Y }
C {devices/lab_pin.sym} 119380 -15780 0 0 {name=p118732 lab=_63302_/Y }
C {devices/lab_pin.sym} 119540 -15850 0 1 {name=p118733 lab=_63303_/X }
C {sky130_stdcells/a41o_4.sym} 119460 -15850 0 0 {name=X_63303_ }
C {devices/lab_pin.sym} 119380 -15710 0 0 {name=p118734 lab=_73833_/B }
C {devices/lab_pin.sym} 119380 -15670 0 0 {name=p118735 lab=_48203_/X }
C {devices/lab_pin.sym} 119380 -15630 0 0 {name=p118736 lab=_48236_/Y }
C {devices/lab_pin.sym} 119540 -15670 0 1 {name=p118737 lab=_48237_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -15670 0 0 {name=X_48237_ }
C {devices/lab_pin.sym} 119400 -15550 0 0 {name=p118738 lab=_60515_/A }
C {devices/lab_pin.sym} 119400 -15510 0 0 {name=p118739 lab=_60515_/B }
C {devices/lab_pin.sym} 119400 -15470 0 0 {name=p118740 lab=_60515_/C }
C {devices/lab_pin.sym} 119520 -15510 0 1 {name=p118741 lab=_60515_/Y }
C {sky130_stdcells/nand3_4.sym} 119460 -15510 0 0 {name=X_60515_ }
C {devices/lab_pin.sym} 119400 -15380 0 0 {name=p118742 lab=_67023_/A }
C {devices/lab_pin.sym} 119400 -15340 0 0 {name=p118743 lab=_67071_/B }
C {devices/lab_pin.sym} 119520 -15360 0 1 {name=p118744 lab=_67071_/X }
C {sky130_stdcells/and2_4.sym} 119460 -15360 0 0 {name=X_67071_ }
C {devices/lab_pin.sym} 119400 -15250 0 0 {name=p118745 lab=_79057_/A }
C {devices/lab_pin.sym} 119400 -15210 0 0 {name=p118746 lab=_79057_/B }
C {devices/lab_pin.sym} 119400 -15170 0 0 {name=p118747 lab=_79057_/C }
C {devices/lab_pin.sym} 119520 -15210 0 1 {name=p118748 lab=_79058_/B }
C {sky130_stdcells/nand3_4.sym} 119460 -15210 0 0 {name=X_79057_ }
C {devices/lab_pin.sym} 119380 -15090 0 0 {name=p118749 lab=_55599_/B }
C {devices/lab_pin.sym} 119380 -15050 0 0 {name=p118750 lab=_45876_/B }
C {devices/lab_pin.sym} 119380 -15010 0 0 {name=p118751 lab=_44919_/X }
C {devices/lab_pin.sym} 119540 -15050 0 1 {name=p118752 lab=_45449_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -15050 0 0 {name=X_45449_ }
C {devices/lab_pin.sym} 119400 -14940 0 0 {name=p118753 lab=_64273_/A }
C {devices/lab_pin.sym} 119400 -14900 0 0 {name=p118754 lab=_64273_/B }
C {devices/lab_pin.sym} 119400 -14860 0 0 {name=p118755 lab=_64283_/C }
C {devices/lab_pin.sym} 119400 -14820 0 0 {name=p118756 lab=_64304_/D }
C {devices/lab_pin.sym} 119520 -14880 0 1 {name=p118757 lab=_64283_/X }
C {sky130_stdcells/and4_4.sym} 119460 -14880 0 0 {name=X_64283_ }
C {devices/lab_pin.sym} 119400 -14750 0 0 {name=p118758 lab=_76268_/D }
C {devices/lab_pin.sym} 119400 -14710 0 0 {name=p118759 lab=_76237_/Y }
C {devices/lab_pin.sym} 119400 -14670 0 0 {name=p118760 lab=_76236_/X }
C {devices/lab_pin.sym} 119520 -14710 0 1 {name=p118761 lab=_76269_/Y }
C {sky130_stdcells/nand3_4.sym} 119460 -14710 0 0 {name=X_76269_ }
C {devices/lab_pin.sym} 119380 -14610 0 0 {name=p118762 lab=_61489_/Y }
C {devices/lab_pin.sym} 119380 -14570 0 0 {name=p118763 lab=_61491_/Y }
C {devices/lab_pin.sym} 119380 -14530 0 0 {name=p118764 lab=_61464_/X }
C {devices/lab_pin.sym} 119380 -14490 0 0 {name=p118765 lab=_61492_/Y }
C {devices/lab_pin.sym} 119380 -14460 0 0 {name=p118766 lab=_61494_/Y }
C {devices/lab_pin.sym} 119540 -14530 0 1 {name=p118767 lab=_61495_/X }
C {sky130_stdcells/a41o_4.sym} 119460 -14530 0 0 {name=X_61495_ }
C {devices/lab_pin.sym} 119400 -14380 0 0 {name=p118768 lab=_65992_/A }
C {devices/lab_pin.sym} 119400 -14340 0 0 {name=p118769 lab=_66022_/B }
C {devices/lab_pin.sym} 119520 -14360 0 1 {name=p118770 lab=_66022_/X }
C {sky130_stdcells/and2_4.sym} 119460 -14360 0 0 {name=X_66022_ }
C {devices/lab_pin.sym} 119400 -14240 0 0 {name=p118771 lab=_82256_/Q }
C {devices/lab_pin.sym} 119400 -14200 0 0 {name=p118772 lab=_81968_/Q }
C {devices/lab_pin.sym} 119520 -14220 0 1 {name=p118773 lab=_78024_/A }
C {sky130_stdcells/xnor2_4.sym} 119460 -14220 0 0 {name=X_78008_ }
C {devices/lab_pin.sym} 119420 -14090 0 0 {name=p118774 lab=_60522_/A }
C {devices/lab_pin.sym} 119500 -14090 0 1 {name=p118775 lab=_63234_/X }
C {sky130_stdcells/buf_2.sym} 119460 -14090 0 0 {name=X_63234_ }
C {devices/lab_pin.sym} 119380 -14010 0 0 {name=p118776 lab=_60408_/C }
C {devices/lab_pin.sym} 119380 -13970 0 0 {name=p118777 lab=_60408_/A }
C {devices/lab_pin.sym} 119380 -13930 0 0 {name=p118778 lab=_60406_/X }
C {devices/lab_pin.sym} 119380 -13890 0 0 {name=p118779 lab=_60439_/X }
C {devices/lab_pin.sym} 119380 -13850 0 0 {name=p118780 lab=_60440_/A }
C {devices/lab_pin.sym} 119540 -13930 0 1 {name=p118781 lab=_60515_/A }
C {sky130_stdcells/a32oi_4.sym} 119460 -13930 0 0 {name=X_60446_ }
C {devices/lab_pin.sym} 119420 -13770 0 0 {name=p118782 lab=_48162_/A }
C {devices/lab_pin.sym} 119500 -13770 0 1 {name=p118783 lab=_48897_/A }
C {sky130_stdcells/buf_2.sym} 119460 -13770 0 0 {name=X_48168_ }
C {devices/lab_pin.sym} 119420 -13650 0 0 {name=p118784 lab=_82380_/Q }
C {devices/lab_pin.sym} 119500 -13650 0 1 {name=p118785 lab=_54559_/D }
C {sky130_stdcells/inv_2.sym} 119460 -13650 0 0 {name=X_47119_ }
C {devices/lab_pin.sym} 119420 -13530 0 0 {name=p118786 lab=_60466_/X }
C {devices/lab_pin.sym} 119500 -13530 0 1 {name=p118787 lab=_63165_/X }
C {sky130_stdcells/buf_2.sym} 119460 -13530 0 0 {name=X_63165_ }
C {devices/lab_pin.sym} 119420 -13410 0 0 {name=p118788 lab=_52573_/B }
C {devices/lab_pin.sym} 119500 -13410 0 1 {name=p118789 lab=_48099_/X }
C {sky130_stdcells/buf_2.sym} 119460 -13410 0 0 {name=X_48099_ }
C {devices/lab_pin.sym} 119400 -13320 0 0 {name=p118790 lab=_60630_/A }
C {devices/lab_pin.sym} 119400 -13280 0 0 {name=p118791 lab=_60171_/A }
C {devices/lab_pin.sym} 119400 -13240 0 0 {name=p118792 lab=_60630_/C }
C {devices/lab_pin.sym} 119400 -13200 0 0 {name=p118793 lab=_60171_/B }
C {devices/lab_pin.sym} 119520 -13260 0 1 {name=p118794 lab=_60392_/A }
C {sky130_stdcells/and4_4.sym} 119460 -13260 0 0 {name=X_60377_ }
C {devices/lab_pin.sym} 119420 -13110 0 0 {name=p118795 lab=clkbuf_8_43_0_CLK/A }
C {devices/lab_pin.sym} 119500 -13110 0 1 {name=p118796 lab=clkbuf_9_87_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 119460 -13110 0 0 {name=Xclkbuf_8_43_0_CLK }
C {devices/lab_pin.sym} 119420 -12990 0 0 {name=p118797 lab=_50105_/A }
C {devices/lab_pin.sym} 119500 -12990 0 1 {name=p118798 lab=_50131_/A }
C {sky130_stdcells/buf_2.sym} 119460 -12990 0 0 {name=X_50130_ }
C {devices/lab_pin.sym} 119400 -12900 0 0 {name=p118799 lab=_62142_/A }
C {devices/lab_pin.sym} 119400 -12860 0 0 {name=p118800 lab=_62110_/Y }
C {devices/lab_pin.sym} 119400 -12820 0 0 {name=p118801 lab=_62112_/Y }
C {devices/lab_pin.sym} 119400 -12780 0 0 {name=p118802 lab=_62115_/Y }
C {devices/lab_pin.sym} 119520 -12840 0 1 {name=p118803 lab=_62116_/Y }
C {sky130_stdcells/nand4_4.sym} 119460 -12840 0 0 {name=X_62116_ }
C {devices/lab_pin.sym} 119380 -12720 0 0 {name=p118804 lab=_87960_/Q }
C {devices/lab_pin.sym} 119380 -12680 0 0 {name=p118805 lab=_67950_/X }
C {devices/lab_pin.sym} 119380 -12640 0 0 {name=p118806 lab=_67879_/X }
C {devices/lab_pin.sym} 119380 -12600 0 0 {name=p118807 lab=_67972_/X }
C {devices/lab_pin.sym} 119540 -12660 0 1 {name=p118808 lab=_67973_/X }
C {sky130_stdcells/a211o_4.sym} 119460 -12660 0 0 {name=X_67973_ }
C {devices/lab_pin.sym} 119420 -12510 0 0 {name=p118809 lab=_60452_/X }
C {devices/lab_pin.sym} 119500 -12510 0 1 {name=p118810 lab=_63097_/A }
C {sky130_stdcells/buf_2.sym} 119460 -12510 0 0 {name=X_63096_ }
C {devices/lab_pin.sym} 119420 -12390 0 0 {name=p118811 lab=_79941_/Y }
C {devices/lab_pin.sym} 119500 -12390 0 1 {name=p118812 lab=_79959_/Y }
C {sky130_stdcells/inv_2.sym} 119460 -12390 0 0 {name=X_79959_ }
C {devices/lab_pin.sym} 119380 -12290 0 0 {name=p118813 lab=_69709_/X }
C {devices/lab_pin.sym} 119380 -12250 0 0 {name=p118814 lab=_69711_/X }
C {devices/lab_pin.sym} 119380 -12210 0 0 {name=p118815 lab=_69678_/X }
C {devices/lab_pin.sym} 119540 -12250 0 1 {name=p118816 lab=_69712_/X }
C {sky130_stdcells/a21o_4.sym} 119460 -12250 0 0 {name=X_69712_ }
C {devices/lab_pin.sym} 119420 -12110 0 0 {name=p118817 lab=_48836_/A }
C {devices/lab_pin.sym} 119500 -12110 0 1 {name=p118818 lab=_50061_/X }
C {sky130_stdcells/buf_2.sym} 119460 -12110 0 0 {name=X_50061_ }
C {devices/lab_pin.sym} 119380 -12010 0 0 {name=p118819 lab=_80915_/D }
C {devices/lab_pin.sym} 119380 -11970 0 0 {name=p118820 lab=_66850_/X }
C {devices/lab_pin.sym} 119380 -11930 0 0 {name=p118821 lab=_66923_/X }
C {devices/lab_pin.sym} 119540 -11970 0 1 {name=p118822 lab=_66924_/X }
C {sky130_stdcells/a21bo_4.sym} 119460 -11970 0 0 {name=X_66924_ }
C {devices/lab_pin.sym} 119400 -11860 0 0 {name=p118823 lab=_62142_/A }
C {devices/lab_pin.sym} 119400 -11820 0 0 {name=p118824 lab=_62047_/B }
C {devices/lab_pin.sym} 119400 -11780 0 0 {name=p118825 lab=_62047_/C }
C {devices/lab_pin.sym} 119400 -11740 0 0 {name=p118826 lab=_62047_/D }
C {devices/lab_pin.sym} 119520 -11800 0 1 {name=p118827 lab=_62047_/Y }
C {sky130_stdcells/nand4_4.sym} 119460 -11800 0 0 {name=X_62047_ }
C {devices/lab_pin.sym} 119370 -11650 0 0 {name=p118828 lab=_82206_/CLK }
C {devices/lab_pin.sym} 119370 -11630 0 0 {name=p118829 lab=_82778_/Q }
C {devices/lab_pin.sym} 119550 -11650 0 1 {name=p118830 lab=_82970_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -11640 0 0 {name=X_82970_ }
C {devices/lab_pin.sym} 119380 -11530 0 0 {name=p118831 lab=_81980_/D }
C {devices/lab_pin.sym} 119380 -11490 0 0 {name=p118832 lab=_69632_/X }
C {devices/lab_pin.sym} 119380 -11450 0 0 {name=p118833 lab=_69642_/X }
C {devices/lab_pin.sym} 119540 -11490 0 1 {name=p118834 lab=_83908_/D }
C {sky130_stdcells/a21bo_4.sym} 119460 -11490 0 0 {name=X_69643_ }
C {devices/lab_pin.sym} 119370 -11350 0 0 {name=p118835 lab=_82124_/CLK }
C {devices/lab_pin.sym} 119370 -11330 0 0 {name=p118836 lab=_81921_/D }
C {devices/lab_pin.sym} 119550 -11350 0 1 {name=p118837 lab=_81921_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -11340 0 0 {name=X_81921_ }
C {devices/lab_pin.sym} 119420 -11210 0 0 {name=p118838 lab=clkbuf_8_59_0_CLK/A }
C {devices/lab_pin.sym} 119500 -11210 0 1 {name=p118839 lab=clkbuf_8_58_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 119460 -11210 0 0 {name=Xclkbuf_8_58_0_CLK }
C {devices/lab_pin.sym} 119380 -11120 0 0 {name=p118840 lab=_87431_/Q }
C {devices/lab_pin.sym} 119380 -11080 0 0 {name=p118841 lab=_66762_/X }
C {devices/lab_pin.sym} 119380 -11040 0 0 {name=p118842 lab=_66764_/X }
C {devices/lab_pin.sym} 119380 -11000 0 0 {name=p118843 lab=_66854_/X }
C {devices/lab_pin.sym} 119540 -11060 0 1 {name=p118844 lab=_66855_/X }
C {sky130_stdcells/a211o_4.sym} 119460 -11060 0 0 {name=X_66855_ }
C {devices/lab_pin.sym} 119380 -10930 0 0 {name=p118845 lab=_85562_/Q }
C {devices/lab_pin.sym} 119380 -10890 0 0 {name=p118846 lab=_53816_/X }
C {devices/lab_pin.sym} 119380 -10850 0 0 {name=p118847 lab=_53819_/Y }
C {devices/lab_pin.sym} 119540 -10890 0 1 {name=p118848 lab=_53820_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -10890 0 0 {name=X_53820_ }
C {devices/lab_pin.sym} 119420 -10750 0 0 {name=p118849 lab=_65158_/A }
C {devices/lab_pin.sym} 119500 -10750 0 1 {name=p118850 lab=_65807_/A }
C {sky130_stdcells/buf_2.sym} 119460 -10750 0 0 {name=X_65806_ }
C {devices/lab_pin.sym} 119370 -10630 0 0 {name=p118851 lab=_84640_/CLK }
C {devices/lab_pin.sym} 119370 -10610 0 0 {name=p118852 lab=_60295_/Y }
C {devices/lab_pin.sym} 119550 -10630 0 1 {name=p118853 lab=_79784_/A }
C {sky130_stdcells/dfxtp_4.sym} 119460 -10620 0 0 {name=X_84640_ }
C {devices/lab_pin.sym} 119370 -10490 0 0 {name=p118854 lab=_82515_/CLK }
C {devices/lab_pin.sym} 119370 -10470 0 0 {name=p118855 lab=_81852_/D }
C {devices/lab_pin.sym} 119550 -10490 0 1 {name=p118856 lab=_77612_/A }
C {sky130_stdcells/dfxtp_4.sym} 119460 -10480 0 0 {name=X_81852_ }
C {devices/lab_pin.sym} 119400 -10360 0 0 {name=p118857 lab=_69571_/X }
C {devices/lab_pin.sym} 119400 -10320 0 0 {name=p118858 lab=_69574_/B }
C {devices/lab_pin.sym} 119520 -10340 0 1 {name=p118859 lab=_69574_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -10340 0 0 {name=X_69574_ }
C {devices/lab_pin.sym} 119380 -10240 0 0 {name=p118860 lab=_87434_/Q }
C {devices/lab_pin.sym} 119380 -10200 0 0 {name=p118861 lab=_66762_/X }
C {devices/lab_pin.sym} 119380 -10160 0 0 {name=p118862 lab=_66764_/X }
C {devices/lab_pin.sym} 119380 -10120 0 0 {name=p118863 lab=_66785_/X }
C {devices/lab_pin.sym} 119540 -10180 0 1 {name=p118864 lab=_66786_/X }
C {sky130_stdcells/a211o_4.sym} 119460 -10180 0 0 {name=X_66786_ }
C {devices/lab_pin.sym} 119400 -10060 0 0 {name=p118865 lab=_84841_/Q }
C {devices/lab_pin.sym} 119400 -10020 0 0 {name=p118866 lab=_63934_/X }
C {devices/lab_pin.sym} 119400 -9980 0 0 {name=p118867 lab=_63949_/C }
C {devices/lab_pin.sym} 119400 -9940 0 0 {name=p118868 lab=_64027_/D }
C {devices/lab_pin.sym} 119520 -10000 0 1 {name=p118869 lab=_63998_/Y }
C {sky130_stdcells/nand4_4.sym} 119460 -10000 0 0 {name=X_63998_ }
C {devices/lab_pin.sym} 119370 -9850 0 0 {name=p118870 lab=_83973_/CLK }
C {devices/lab_pin.sym} 119370 -9830 0 0 {name=p118871 lab=_80803_/D }
C {devices/lab_pin.sym} 119550 -9850 0 1 {name=p118872 lab=_75726_/B }
C {sky130_stdcells/dfxtp_4.sym} 119460 -9840 0 0 {name=X_80803_ }
C {devices/lab_pin.sym} 119400 -9720 0 0 {name=p118873 lab=_68525_/A }
C {devices/lab_pin.sym} 119400 -9680 0 0 {name=p118874 lab=_68525_/B }
C {devices/lab_pin.sym} 119520 -9700 0 1 {name=p118875 lab=_68525_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -9700 0 0 {name=X_68525_ }
C {devices/lab_pin.sym} 119380 -9590 0 0 {name=p118876 lab=_85575_/Q }
C {devices/lab_pin.sym} 119380 -9550 0 0 {name=p118877 lab=_53729_/X }
C {devices/lab_pin.sym} 119380 -9510 0 0 {name=p118878 lab=_53750_/Y }
C {devices/lab_pin.sym} 119540 -9550 0 1 {name=p118879 lab=_53751_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -9550 0 0 {name=X_53751_ }
C {devices/lab_pin.sym} 119380 -9430 0 0 {name=p118880 lab=_65732_/X }
C {devices/lab_pin.sym} 119380 -9390 0 0 {name=p118881 lab=_65736_/X }
C {devices/lab_pin.sym} 119380 -9350 0 0 {name=p118882 lab=_65614_/X }
C {devices/lab_pin.sym} 119540 -9390 0 1 {name=p118883 lab=_65737_/X }
C {sky130_stdcells/a21o_4.sym} 119460 -9390 0 0 {name=X_65737_ }
C {devices/lab_pin.sym} 119370 -9250 0 0 {name=p118884 lab=_84624_/CLK }
C {devices/lab_pin.sym} 119370 -9230 0 0 {name=p118885 lab=_60769_/X }
C {devices/lab_pin.sym} 119550 -9250 0 1 {name=p118886 lab=_78066_/A }
C {sky130_stdcells/dfxtp_4.sym} 119460 -9240 0 0 {name=X_84571_ }
C {devices/lab_pin.sym} 119400 -9140 0 0 {name=p118887 lab=_50963_/A }
C {devices/lab_pin.sym} 119400 -9100 0 0 {name=p118888 lab=_50963_/B }
C {devices/lab_pin.sym} 119400 -9060 0 0 {name=p118889 lab=_50963_/C }
C {devices/lab_pin.sym} 119400 -9020 0 0 {name=p118890 lab=_52654_/D }
C {devices/lab_pin.sym} 119520 -9080 0 1 {name=p118891 lab=_50963_/X }
C {sky130_stdcells/and4_4.sym} 119460 -9080 0 0 {name=X_50963_ }
C {devices/lab_pin.sym} 119400 -8960 0 0 {name=p118892 lab=_60292_/A }
C {devices/lab_pin.sym} 119400 -8920 0 0 {name=p118893 lab=_62949_/B }
C {devices/lab_pin.sym} 119400 -8880 0 0 {name=p118894 lab=_62947_/Y }
C {devices/lab_pin.sym} 119400 -8840 0 0 {name=p118895 lab=_62948_/Y }
C {devices/lab_pin.sym} 119520 -8900 0 1 {name=p118896 lab=_62949_/Y }
C {sky130_stdcells/nand4_4.sym} 119460 -8900 0 0 {name=X_62949_ }
C {devices/lab_pin.sym} 119370 -8750 0 0 {name=p118897 lab=_81783_/CLK }
C {devices/lab_pin.sym} 119370 -8730 0 0 {name=p118898 lab=_76130_/X }
C {devices/lab_pin.sym} 119550 -8750 0 1 {name=p118899 lab=_48472_/A }
C {sky130_stdcells/dfxtp_4.sym} 119460 -8740 0 0 {name=X_81783_ }
C {devices/lab_pin.sym} 119370 -8610 0 0 {name=p118900 lab=_86627_/CLK }
C {devices/lab_pin.sym} 119370 -8590 0 0 {name=p118901 lab=_49863_/Y }
C {devices/lab_pin.sym} 119550 -8610 0 1 {name=p118902 lab=_58081_/B }
C {sky130_stdcells/dfxtp_4.sym} 119460 -8600 0 0 {name=X_86310_ }
C {devices/lab_pin.sym} 119420 -8470 0 0 {name=p118903 lab=_52619_/A }
C {devices/lab_pin.sym} 119500 -8470 0 1 {name=p118904 lab=_52702_/X }
C {sky130_stdcells/buf_2.sym} 119460 -8470 0 0 {name=X_52702_ }
C {devices/lab_pin.sym} 119370 -8350 0 0 {name=p118905 lab=_83526_/CLK }
C {devices/lab_pin.sym} 119370 -8330 0 0 {name=p118906 lab=_71370_/X }
C {devices/lab_pin.sym} 119550 -8350 0 1 {name=p118907 lab=_83522_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -8340 0 0 {name=X_83522_ }
C {devices/lab_pin.sym} 119380 -8230 0 0 {name=p118908 lab=_56005_/X }
C {devices/lab_pin.sym} 119380 -8190 0 0 {name=p118909 lab=_56468_/X }
C {devices/lab_pin.sym} 119380 -8150 0 0 {name=p118910 lab=_56469_/Y }
C {devices/lab_pin.sym} 119540 -8190 0 1 {name=p118911 lab=_56470_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -8190 0 0 {name=X_56470_ }
C {devices/lab_pin.sym} 119400 -8060 0 0 {name=p118912 lab=_68409_/A }
C {devices/lab_pin.sym} 119400 -8020 0 0 {name=p118913 lab=_88272_/Q }
C {devices/lab_pin.sym} 119520 -8040 0 1 {name=p118914 lab=_68456_/X }
C {sky130_stdcells/and2_4.sym} 119460 -8040 0 0 {name=X_68456_ }
C {devices/lab_pin.sym} 119370 -7910 0 0 {name=p118915 lab=_82211_/CLK }
C {devices/lab_pin.sym} 119370 -7890 0 0 {name=p118916 lab=_75920_/X }
C {devices/lab_pin.sym} 119550 -7910 0 1 {name=p118917 lab=_80702_/D }
C {sky130_stdcells/dfxtp_4.sym} 119460 -7900 0 0 {name=X_80734_ }
C {devices/lab_pin.sym} 119370 -7770 0 0 {name=p118918 lab=_88062_/CLK }
C {devices/lab_pin.sym} 119370 -7750 0 0 {name=p118919 lab=_43735_/X }
C {devices/lab_pin.sym} 119550 -7770 0 1 {name=p118920 lab=_87290_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -7760 0 0 {name=X_87290_ }
C {devices/lab_pin.sym} 119380 -7650 0 0 {name=p118921 lab=_53679_/Y }
C {devices/lab_pin.sym} 119380 -7610 0 0 {name=p118922 lab=_53680_/X }
C {devices/lab_pin.sym} 119380 -7570 0 0 {name=p118923 lab=_53681_/X }
C {devices/lab_pin.sym} 119540 -7610 0 1 {name=p118924 lab=_85589_/D }
C {sky130_stdcells/a21oi_4.sym} 119460 -7610 0 0 {name=X_53682_ }
C {devices/lab_pin.sym} 119380 -7500 0 0 {name=p118925 lab=_65484_/X }
C {devices/lab_pin.sym} 119380 -7460 0 0 {name=p118926 lab=_86193_/Q }
C {devices/lab_pin.sym} 119380 -7420 0 0 {name=p118927 lab=_65534_/X }
C {devices/lab_pin.sym} 119380 -7380 0 0 {name=p118928 lab=_65667_/X }
C {devices/lab_pin.sym} 119540 -7440 0 1 {name=p118929 lab=_65668_/X }
C {sky130_stdcells/a211o_4.sym} 119460 -7440 0 0 {name=X_65668_ }
C {devices/lab_pin.sym} 119380 -7310 0 0 {name=p118930 lab=_86111_/Q }
C {devices/lab_pin.sym} 119380 -7270 0 0 {name=p118931 lab=_50882_/X }
C {devices/lab_pin.sym} 119380 -7230 0 0 {name=p118932 lab=_50893_/Y }
C {devices/lab_pin.sym} 119540 -7270 0 1 {name=p118933 lab=_50894_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -7270 0 0 {name=X_50894_ }
C {devices/lab_pin.sym} 119400 -7150 0 0 {name=p118934 lab=_56807_/A }
C {devices/lab_pin.sym} 119400 -7110 0 0 {name=p118935 lab=_55421_/B }
C {devices/lab_pin.sym} 119400 -7070 0 0 {name=p118936 lab=_56807_/C }
C {devices/lab_pin.sym} 119520 -7110 0 1 {name=p118937 lab=_55421_/Y }
C {sky130_stdcells/nand3_4.sym} 119460 -7110 0 0 {name=X_55421_ }
C {devices/lab_pin.sym} 119380 -7000 0 0 {name=p118938 lab=_87984_/Q }
C {devices/lab_pin.sym} 119380 -6960 0 0 {name=p118939 lab=_67355_/X }
C {devices/lab_pin.sym} 119380 -6920 0 0 {name=p118940 lab=_67405_/X }
C {devices/lab_pin.sym} 119380 -6880 0 0 {name=p118941 lab=_67406_/X }
C {devices/lab_pin.sym} 119540 -6940 0 1 {name=p118942 lab=_67407_/X }
C {sky130_stdcells/a211o_4.sym} 119460 -6940 0 0 {name=X_67407_ }
C {devices/lab_pin.sym} 119370 -6790 0 0 {name=p118943 lab=_83161_/CLK }
C {devices/lab_pin.sym} 119370 -6770 0 0 {name=p118944 lab=_50217_/Y }
C {devices/lab_pin.sym} 119550 -6790 0 1 {name=p118945 lab=_86241_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -6780 0 0 {name=X_86241_ }
C {devices/lab_pin.sym} 119380 -6670 0 0 {name=p118946 lab=_85783_/Q }
C {devices/lab_pin.sym} 119380 -6630 0 0 {name=p118947 lab=_52629_/X }
C {devices/lab_pin.sym} 119380 -6590 0 0 {name=p118948 lab=_52632_/Y }
C {devices/lab_pin.sym} 119540 -6630 0 1 {name=p118949 lab=_52633_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -6630 0 0 {name=X_52633_ }
C {devices/lab_pin.sym} 119420 -6490 0 0 {name=p118950 lab=_64619_/A }
C {devices/lab_pin.sym} 119500 -6490 0 1 {name=p118951 lab=_64619_/X }
C {sky130_stdcells/buf_2.sym} 119460 -6490 0 0 {name=X_64619_ }
C {devices/lab_pin.sym} 119370 -6370 0 0 {name=p118952 lab=_83457_/CLK }
C {devices/lab_pin.sym} 119370 -6350 0 0 {name=p118953 lab=_71569_/X }
C {devices/lab_pin.sym} 119550 -6370 0 1 {name=p118954 lab=_83453_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -6360 0 0 {name=X_83453_ }
C {devices/lab_pin.sym} 119370 -6230 0 0 {name=p118955 lab=_86770_/CLK }
C {devices/lab_pin.sym} 119370 -6210 0 0 {name=p118956 lab=_80665_/D }
C {devices/lab_pin.sym} 119550 -6230 0 1 {name=p118957 lab=_80665_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -6220 0 0 {name=X_80665_ }
C {devices/lab_pin.sym} 119400 -6100 0 0 {name=p118958 lab=_69001_/A }
C {devices/lab_pin.sym} 119400 -6060 0 0 {name=p118959 lab=_68387_/B }
C {devices/lab_pin.sym} 119520 -6080 0 1 {name=p118960 lab=_68387_/Y }
C {sky130_stdcells/nor2_4.sym} 119460 -6080 0 0 {name=X_68387_ }
C {devices/lab_pin.sym} 119400 -5960 0 0 {name=p118961 lab=_65599_/A }
C {devices/lab_pin.sym} 119400 -5920 0 0 {name=p118962 lab=_65599_/B }
C {devices/lab_pin.sym} 119520 -5940 0 1 {name=p118963 lab=_65599_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -5940 0 0 {name=X_65599_ }
C {devices/lab_pin.sym} 119420 -5810 0 0 {name=p118964 lab=_58618_/A }
C {devices/lab_pin.sym} 119500 -5810 0 1 {name=p118965 lab=_58140_/X }
C {sky130_stdcells/buf_2.sym} 119460 -5810 0 0 {name=X_58140_ }
C {devices/lab_pin.sym} 119370 -5690 0 0 {name=p118966 lab=_82443_/CLK }
C {devices/lab_pin.sym} 119370 -5670 0 0 {name=p118967 lab=_82436_/Q }
C {devices/lab_pin.sym} 119550 -5690 0 1 {name=p118968 lab=_78330_/A }
C {sky130_stdcells/dfxtp_4.sym} 119460 -5680 0 0 {name=X_82404_ }
C {sky130_stdcells/decap_3.sym} 119460 -5520 0 0 {name=XPHY_405 }
C {devices/lab_pin.sym} 119400 -5390 0 0 {name=p118969 lab=_55352_/A }
C {devices/lab_pin.sym} 119400 -5350 0 0 {name=p118970 lab=_83753_/Q }
C {devices/lab_pin.sym} 119400 -5310 0 0 {name=p118971 lab=_55352_/C }
C {devices/lab_pin.sym} 119520 -5350 0 1 {name=p118972 lab=_55445_/C }
C {sky130_stdcells/nand3_4.sym} 119460 -5350 0 0 {name=X_55352_ }
C {devices/lab_pin.sym} 119400 -5220 0 0 {name=p118973 lab=_67266_/A }
C {devices/lab_pin.sym} 119400 -5180 0 0 {name=p118974 lab=_67338_/B }
C {devices/lab_pin.sym} 119520 -5200 0 1 {name=p118975 lab=_67338_/X }
C {sky130_stdcells/and2_4.sym} 119460 -5200 0 0 {name=X_67338_ }
C {devices/lab_pin.sym} 119370 -5070 0 0 {name=p118976 lab=_85566_/CLK }
C {devices/lab_pin.sym} 119370 -5050 0 0 {name=p118977 lab=_86172_/D }
C {devices/lab_pin.sym} 119550 -5070 0 1 {name=p118978 lab=_86172_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -5060 0 0 {name=X_86172_ }
C {devices/lab_pin.sym} 119380 -4950 0 0 {name=p118979 lab=_65360_/B }
C {devices/lab_pin.sym} 119380 -4910 0 0 {name=p118980 lab=_52549_/X }
C {devices/lab_pin.sym} 119380 -4870 0 0 {name=p118981 lab=_52563_/Y }
C {devices/lab_pin.sym} 119540 -4910 0 1 {name=p118982 lab=_52564_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -4910 0 0 {name=X_52564_ }
C {sky130_stdcells/decap_3.sym} 119460 -4740 0 0 {name=XPHY_416 }
C {devices/lab_pin.sym} 119370 -4590 0 0 {name=p118983 lab=_83415_/CLK }
C {devices/lab_pin.sym} 119370 -4570 0 0 {name=p118984 lab=_71767_/X }
C {devices/lab_pin.sym} 119550 -4590 0 1 {name=p118985 lab=_83384_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -4580 0 0 {name=X_83384_ }
C {sky130_stdcells/decap_3.sym} 119460 -4420 0 0 {name=XPHY_427 }
C {devices/lab_pin.sym} 119400 -4280 0 0 {name=p118986 lab=_80596_/A }
C {devices/lab_pin.sym} 119400 -4240 0 0 {name=p118987 lab=_80596_/B }
C {devices/lab_pin.sym} 119520 -4260 0 1 {name=p118988 lab=_80598_/B }
C {sky130_stdcells/or2_4.sym} 119460 -4260 0 0 {name=X_80596_ }
C {sky130_stdcells/decap_3.sym} 119460 -4100 0 0 {name=XPHY_438 }
C {devices/lab_pin.sym} 119400 -3980 0 0 {name=p118989 lab=_54312_/A }
C {devices/lab_pin.sym} 119400 -3940 0 0 {name=p118990 lab=_54325_/B }
C {devices/lab_pin.sym} 119400 -3900 0 0 {name=p118991 lab=_54312_/C }
C {devices/lab_pin.sym} 119400 -3860 0 0 {name=p118992 lab=_46680_/Y }
C {devices/lab_pin.sym} 119520 -3920 0 1 {name=p118993 lab=_54303_/X }
C {sky130_stdcells/and4_4.sym} 119460 -3920 0 0 {name=X_54303_ }
C {sky130_stdcells/decap_3.sym} 119460 -3740 0 0 {name=XPHY_449 }
C {devices/lab_pin.sym} 119370 -3590 0 0 {name=p118994 lab=_85134_/CLK }
C {devices/lab_pin.sym} 119370 -3570 0 0 {name=p118995 lab=_85123_/D }
C {devices/lab_pin.sym} 119550 -3590 0 1 {name=p118996 lab=_56920_/B }
C {sky130_stdcells/dfxtp_4.sym} 119460 -3580 0 0 {name=X_85123_ }
C {devices/lab_pin.sym} 119380 -3470 0 0 {name=p118997 lab=_85996_/Q }
C {devices/lab_pin.sym} 119380 -3430 0 0 {name=p118998 lab=_51511_/X }
C {devices/lab_pin.sym} 119380 -3390 0 0 {name=p118999 lab=_51514_/Y }
C {devices/lab_pin.sym} 119540 -3430 0 1 {name=p119000 lab=_51515_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -3430 0 0 {name=X_51515_ }
C {devices/lab_pin.sym} 119400 -3300 0 0 {name=p119001 lab=_86631_/Q }
C {devices/lab_pin.sym} 119400 -3260 0 0 {name=p119002 lab=_58136_/B }
C {devices/lab_pin.sym} 119520 -3280 0 1 {name=p119003 lab=_58071_/Y }
C {sky130_stdcells/nor2_4.sym} 119460 -3280 0 0 {name=X_58071_ }
C {devices/lab_pin.sym} 119370 -3150 0 0 {name=p119004 lab=_82335_/CLK }
C {devices/lab_pin.sym} 119370 -3130 0 0 {name=p119005 lab=_77214_/B }
C {devices/lab_pin.sym} 119550 -3150 0 1 {name=p119006 lab=_82335_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -3140 0 0 {name=X_82335_ }
C {devices/lab_pin.sym} 119380 -3040 0 0 {name=p119007 lab=_82983_/Q }
C {devices/lab_pin.sym} 119380 -3000 0 0 {name=p119008 lab=_55272_/X }
C {devices/lab_pin.sym} 119380 -2960 0 0 {name=p119009 lab=_55140_/X }
C {devices/lab_pin.sym} 119380 -2920 0 0 {name=p119010 lab=_55282_/Y }
C {devices/lab_pin.sym} 119540 -2980 0 1 {name=p119011 lab=_56868_/B }
C {sky130_stdcells/a211o_4.sym} 119460 -2980 0 0 {name=X_55283_ }
C {devices/lab_pin.sym} 119420 -2830 0 0 {name=p119012 lab=_66910_/A }
C {devices/lab_pin.sym} 119500 -2830 0 1 {name=p119013 lab=_67269_/X }
C {sky130_stdcells/buf_2.sym} 119460 -2830 0 0 {name=X_67269_ }
C {devices/lab_pin.sym} 119380 -2730 0 0 {name=p119014 lab=_65000_/B }
C {devices/lab_pin.sym} 119380 -2690 0 0 {name=p119015 lab=_52422_/X }
C {devices/lab_pin.sym} 119380 -2650 0 0 {name=p119016 lab=_52494_/Y }
C {devices/lab_pin.sym} 119540 -2690 0 1 {name=p119017 lab=_52495_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -2690 0 0 {name=X_52495_ }
C {devices/lab_pin.sym} 119380 -2570 0 0 {name=p119018 lab=_45719_/Y }
C {devices/lab_pin.sym} 119380 -2530 0 0 {name=p119019 lab=_56952_/X }
C {devices/lab_pin.sym} 119380 -2490 0 0 {name=p119020 lab=_57021_/Y }
C {devices/lab_pin.sym} 119540 -2530 0 1 {name=p119021 lab=_57022_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -2530 0 0 {name=X_57022_ }
C {devices/lab_pin.sym} 119400 -2400 0 0 {name=p119022 lab=_68987_/A }
C {devices/lab_pin.sym} 119400 -2360 0 0 {name=p119023 lab=_69008_/B }
C {devices/lab_pin.sym} 119520 -2380 0 1 {name=p119024 lab=_69008_/X }
C {sky130_stdcells/and2_4.sym} 119460 -2380 0 0 {name=X_69008_ }
C {devices/lab_pin.sym} 119400 -2260 0 0 {name=p119025 lab=_54230_/A }
C {devices/lab_pin.sym} 119400 -2220 0 0 {name=p119026 lab=_53067_/B }
C {devices/lab_pin.sym} 119520 -2240 0 1 {name=p119027 lab=_54234_/Y }
C {sky130_stdcells/nand2_4.sym} 119460 -2240 0 0 {name=X_54234_ }
C {devices/lab_pin.sym} 119370 -2110 0 0 {name=p119028 lab=_85152_/CLK }
C {devices/lab_pin.sym} 119370 -2090 0 0 {name=p119029 lab=_85054_/D }
C {devices/lab_pin.sym} 119550 -2110 0 1 {name=p119030 lab=_45444_/A }
C {sky130_stdcells/dfxtp_4.sym} 119460 -2100 0 0 {name=X_85054_ }
C {devices/lab_pin.sym} 119380 -1990 0 0 {name=p119031 lab=_86008_/Q }
C {devices/lab_pin.sym} 119380 -1950 0 0 {name=p119032 lab=_51429_/X }
C {devices/lab_pin.sym} 119380 -1910 0 0 {name=p119033 lab=_51445_/Y }
C {devices/lab_pin.sym} 119540 -1950 0 1 {name=p119034 lab=_51446_/Y }
C {sky130_stdcells/o21ai_4.sym} 119460 -1950 0 0 {name=X_51446_ }
C {devices/lab_pin.sym} 119370 -1810 0 0 {name=p119035 lab=_83514_/CLK }
C {devices/lab_pin.sym} 119370 -1790 0 0 {name=p119036 lab=_82266_/D }
C {devices/lab_pin.sym} 119550 -1810 0 1 {name=p119037 lab=_82266_/Q }
C {sky130_stdcells/dfxtp_4.sym} 119460 -1800 0 0 {name=X_82266_ }
C {devices/lab_pin.sym} 119400 -1700 0 0 {name=p119038 lab=_70280_/A }
C {devices/lab_pin.sym} 119400 -1660 0 0 {name=p119039 lab=_70160_/X }
C {devices/lab_pin.sym} 119400 -1620 0 0 {name=p119040 lab=_70162_/X }
C {devices/lab_pin.sym} 119400 -1580 0 0 {name=p119041 lab=_70164_/X }
C {devices/lab_pin.sym} 119520 -1640 0 1 {name=p119042 lab=_70280_/Y }
C {sky130_stdcells/nand4_4.sym} 119460 -1640 0 0 {name=X_70280_ }
C {devices/lab_pin.sym} 119370 -1490 0 0 {name=p119043 lab=_81746_/CLK }
C {devices/lab_pin.sym} 119370 -1470 0 0 {name=p119044 lab=_84005_/D }
C {devices/lab_pin.sym} 119550 -1490 0 1 {name=p119045 lab=_82653_/D }
C {sky130_stdcells/dfxtp_4.sym} 119460 -1480 0 0 {name=X_84005_ }
C {devices/lab_pin.sym} 119370 -1350 0 0 {name=p119046 lab=_82284_/CLK }
C {devices/lab_pin.sym} 119370 -1330 0 0 {name=p119047 lab=_74890_/X }
C {devices/lab_pin.sym} 119550 -1350 0 1 {name=p119048 lab=_46239_/A }
C {sky130_stdcells/dfxtp_4.sym} 119460 -1340 0 0 {name=X_81217_ }
C {devices/lab_pin.sym} 119400 -1240 0 0 {name=p119049 lab=_54160_/A }
C {devices/lab_pin.sym} 119400 -1200 0 0 {name=p119050 lab=_54186_/B }
C {devices/lab_pin.sym} 119400 -1160 0 0 {name=p119051 lab=_54146_/X }
C {devices/lab_pin.sym} 119400 -1120 0 0 {name=p119052 lab=_52997_/D }
C {devices/lab_pin.sym} 119520 -1180 0 1 {name=p119053 lab=_54165_/X }
C {sky130_stdcells/and4_4.sym} 119460 -1180 0 0 {name=X_54165_ }
C {devices/lab_pin.sym} 119380 -1050 0 0 {name=p119054 lab=_51375_/Y }
C {devices/lab_pin.sym} 119380 -1010 0 0 {name=p119055 lab=_51366_/X }
C {devices/lab_pin.sym} 119380 -970 0 0 {name=p119056 lab=_51376_/X }
C {devices/lab_pin.sym} 119540 -1010 0 1 {name=p119057 lab=_86022_/D }
C {sky130_stdcells/a21oi_4.sym} 119460 -1010 0 0 {name=X_51377_ }
C {devices/lab_pin.sym} 119370 -870 0 0 {name=p119058 lab=_84766_/CLK }
C {devices/lab_pin.sym} 119370 -850 0 0 {name=p119059 lab=_82197_/D }
C {devices/lab_pin.sym} 119550 -870 0 1 {name=p119060 lab=_82389_/D }
C {sky130_stdcells/dfxtp_4.sym} 119460 -860 0 0 {name=X_82197_ }
C {devices/lab_pin.sym} 119420 -730 0 0 {name=p119061 lab=_41129_/Y }
C {devices/lab_pin.sym} 119500 -730 0 1 {name=p119062 lab=_41130_/X }
C {sky130_stdcells/buf_2.sym} 119460 -730 0 0 {name=X_41130_ }
C {devices/lab_pin.sym} 120300 -42170 0 0 {name=p119063 lab=_85694_/Q }
C {devices/lab_pin.sym} 120300 -42130 0 0 {name=p119064 lab=_53093_/X }
C {devices/lab_pin.sym} 120300 -42090 0 0 {name=p119065 lab=_53115_/Y }
C {devices/lab_pin.sym} 120460 -42130 0 1 {name=p119066 lab=_53116_/Y }
C {sky130_stdcells/o21ai_4.sym} 120380 -42130 0 0 {name=X_53116_ }
C {devices/lab_pin.sym} 120320 -42000 0 0 {name=p119067 lab=_50240_/A }
C {devices/lab_pin.sym} 120320 -41960 0 0 {name=p119068 lab=_50328_/B }
C {devices/lab_pin.sym} 120440 -41980 0 1 {name=p119069 lab=_50328_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -41980 0 0 {name=X_50328_ }
C {devices/lab_pin.sym} 120290 -41850 0 0 {name=p119070 lab=_82327_/CLK }
C {devices/lab_pin.sym} 120290 -41830 0 0 {name=p119071 lab=_75042_/A }
C {devices/lab_pin.sym} 120470 -41850 0 1 {name=p119072 lab=_81148_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -41840 0 0 {name=X_81148_ }
C {devices/lab_pin.sym} 120300 -41730 0 0 {name=p119073 lab=_54094_/Y }
C {devices/lab_pin.sym} 120300 -41690 0 0 {name=p119074 lab=_53437_/X }
C {devices/lab_pin.sym} 120300 -41650 0 0 {name=p119075 lab=_54095_/X }
C {devices/lab_pin.sym} 120460 -41690 0 1 {name=p119076 lab=_85505_/D }
C {sky130_stdcells/a21oi_4.sym} 120380 -41690 0 0 {name=X_54096_ }
C {devices/lab_pin.sym} 120320 -41560 0 0 {name=p119077 lab=_58973_/A }
C {devices/lab_pin.sym} 120320 -41520 0 0 {name=p119078 lab=_58973_/B }
C {devices/lab_pin.sym} 120440 -41540 0 1 {name=p119079 lab=_58973_/Y }
C {sky130_stdcells/nand2_4.sym} 120380 -41540 0 0 {name=X_58973_ }
C {devices/lab_pin.sym} 120340 -41410 0 0 {name=p119080 lab=_41061_/A }
C {devices/lab_pin.sym} 120420 -41410 0 1 {name=p119081 lab=_41061_/X }
C {sky130_stdcells/buf_2.sym} 120380 -41410 0 0 {name=X_41061_ }
C {devices/lab_pin.sym} 120300 -41310 0 0 {name=p119082 lab=_85707_/Q }
C {devices/lab_pin.sym} 120300 -41270 0 0 {name=p119083 lab=_53038_/X }
C {devices/lab_pin.sym} 120300 -41230 0 0 {name=p119084 lab=_53046_/Y }
C {devices/lab_pin.sym} 120460 -41270 0 1 {name=p119085 lab=_53047_/Y }
C {sky130_stdcells/o21ai_4.sym} 120380 -41270 0 0 {name=X_53047_ }
C {devices/lab_pin.sym} 120300 -41150 0 0 {name=p119086 lab=_57884_/X }
C {devices/lab_pin.sym} 120300 -41110 0 0 {name=p119087 lab=_85491_/Q }
C {devices/lab_pin.sym} 120300 -41070 0 0 {name=p119088 lab=_57923_/X }
C {devices/lab_pin.sym} 120460 -41110 0 1 {name=p119089 lab=_57924_/X }
C {sky130_stdcells/o21a_4.sym} 120380 -41110 0 0 {name=X_57924_ }
C {devices/lab_pin.sym} 120300 -40990 0 0 {name=p119090 lab=_50253_/Y }
C {devices/lab_pin.sym} 120300 -40950 0 0 {name=p119091 lab=_50227_/X }
C {devices/lab_pin.sym} 120300 -40910 0 0 {name=p119092 lab=_50258_/Y }
C {devices/lab_pin.sym} 120460 -40950 0 1 {name=p119093 lab=_50259_/Y }
C {sky130_stdcells/a21boi_4.sym} 120380 -40950 0 0 {name=X_50259_ }
C {devices/lab_pin.sym} 120320 -40820 0 0 {name=p119094 lab=_73949_/A }
C {devices/lab_pin.sym} 120320 -40780 0 0 {name=p119095 lab=_66153_/B }
C {devices/lab_pin.sym} 120440 -40800 0 1 {name=p119096 lab=_73970_/X }
C {sky130_stdcells/and2_4.sym} 120380 -40800 0 0 {name=X_73970_ }
C {devices/lab_pin.sym} 120290 -40670 0 0 {name=p119097 lab=_85471_/CLK }
C {devices/lab_pin.sym} 120290 -40650 0 0 {name=p119098 lab=_85956_/D }
C {devices/lab_pin.sym} 120470 -40670 0 1 {name=p119099 lab=_85956_/Q }
C {sky130_stdcells/dfxtp_4.sym} 120380 -40660 0 0 {name=X_85956_ }
C {devices/lab_pin.sym} 120290 -40530 0 0 {name=p119100 lab=_81121_/CLK }
C {devices/lab_pin.sym} 120290 -40510 0 0 {name=p119101 lab=_81111_/Q }
C {devices/lab_pin.sym} 120470 -40530 0 1 {name=p119102 lab=_75381_/B }
C {sky130_stdcells/dfxtp_4.sym} 120380 -40520 0 0 {name=X_81079_ }
