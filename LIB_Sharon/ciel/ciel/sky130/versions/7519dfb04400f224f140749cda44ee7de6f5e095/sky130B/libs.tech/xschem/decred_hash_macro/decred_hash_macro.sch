C {devices/lab_pin.sym} 54080 -34640 0 0 {name=p53309 lab=_78828_/Y }
C {devices/lab_pin.sym} 54200 -34660 0 1 {name=p53310 lab=_78829_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -34660 0 0 {name=X_78829_ }
C {devices/lab_pin.sym} 54080 -34540 0 0 {name=p53311 lab=_48908_/A }
C {devices/lab_pin.sym} 54080 -34500 0 0 {name=p53312 lab=_53834_/B }
C {devices/lab_pin.sym} 54200 -34520 0 1 {name=p53313 lab=_48989_/X }
C {sky130_stdcells/and2_4.sym} 54140 -34520 0 0 {name=X_48989_ }
C {devices/lab_pin.sym} 54060 -34420 0 0 {name=p53314 lab=_69505_/X }
C {devices/lab_pin.sym} 54060 -34380 0 0 {name=p53315 lab=_46199_/X }
C {devices/lab_pin.sym} 54060 -34340 0 0 {name=p53316 lab=_69560_/Y }
C {devices/lab_pin.sym} 54060 -34300 0 0 {name=p53317 lab=_69561_/Y }
C {devices/lab_pin.sym} 54220 -34360 0 1 {name=p53318 lab=_69562_/X }
C {sky130_stdcells/a211o_4.sym} 54140 -34360 0 0 {name=X_69562_ }
C {devices/lab_pin.sym} 54050 -34210 0 0 {name=p53319 lab=_81857_/CLK }
C {devices/lab_pin.sym} 54050 -34190 0 0 {name=p53320 lab=_81840_/D }
C {devices/lab_pin.sym} 54230 -34210 0 1 {name=p53321 lab=_77423_/A }
C {sky130_stdcells/dfxtp_4.sym} 54140 -34200 0 0 {name=X_81840_ }
C {devices/lab_pin.sym} 54080 -34080 0 0 {name=p53322 lab=_66819_/A }
C {devices/lab_pin.sym} 54080 -34040 0 0 {name=p53323 lab=_86830_/Q }
C {devices/lab_pin.sym} 54200 -34060 0 1 {name=p53324 lab=_66774_/X }
C {sky130_stdcells/and2_4.sym} 54140 -34060 0 0 {name=X_66774_ }
C {devices/lab_pin.sym} 54100 -33930 0 0 {name=p53325 lab=_60909_/X }
C {devices/lab_pin.sym} 54180 -33930 0 1 {name=p53326 lab=_64050_/C }
C {sky130_stdcells/buf_2.sym} 54140 -33930 0 0 {name=X_63986_ }
C {devices/lab_pin.sym} 54060 -33830 0 0 {name=p53327 lab=_68507_/X }
C {devices/lab_pin.sym} 54060 -33790 0 0 {name=p53328 lab=_68511_/X }
C {devices/lab_pin.sym} 54060 -33750 0 0 {name=p53329 lab=_68512_/X }
C {devices/lab_pin.sym} 54220 -33790 0 1 {name=p53330 lab=_68513_/Y }
C {sky130_stdcells/a21oi_4.sym} 54140 -33790 0 0 {name=X_68513_ }
C {devices/lab_pin.sym} 54080 -33670 0 0 {name=p53331 lab=_65721_/X }
C {devices/lab_pin.sym} 54080 -33630 0 0 {name=p53332 lab=_65725_/B }
C {devices/lab_pin.sym} 54080 -33590 0 0 {name=p53333 lab=_65724_/X }
C {devices/lab_pin.sym} 54200 -33630 0 1 {name=p53334 lab=_65725_/Y }
C {sky130_stdcells/nand3_4.sym} 54140 -33630 0 0 {name=X_65725_ }
C {devices/lab_pin.sym} 54060 -33510 0 0 {name=p53335 lab=_86101_/Q }
C {devices/lab_pin.sym} 54060 -33470 0 0 {name=p53336 lab=_50936_/X }
C {devices/lab_pin.sym} 54060 -33430 0 0 {name=p53337 lab=_50950_/Y }
C {devices/lab_pin.sym} 54220 -33470 0 1 {name=p53338 lab=_50951_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -33470 0 0 {name=X_50951_ }
C {devices/lab_pin.sym} 54100 -33330 0 0 {name=p53339 lab=_60291_/C }
C {devices/lab_pin.sym} 54180 -33330 0 1 {name=p53340 lab=_62982_/C }
C {sky130_stdcells/buf_2.sym} 54140 -33330 0 0 {name=X_62937_ }
C {devices/lab_pin.sym} 54050 -33210 0 0 {name=p53341 lab=_83987_/CLK }
C {devices/lab_pin.sym} 54050 -33190 0 0 {name=p53342 lab=_81771_/D }
C {devices/lab_pin.sym} 54230 -33210 0 1 {name=p53343 lab=_81771_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -33200 0 0 {name=X_81771_ }
C {devices/lab_pin.sym} 54060 -33100 0 0 {name=p53344 lab=_88025_/Q }
C {devices/lab_pin.sym} 54060 -33060 0 0 {name=p53345 lab=_69315_/X }
C {devices/lab_pin.sym} 54060 -33020 0 0 {name=p53346 lab=_69393_/X }
C {devices/lab_pin.sym} 54060 -32980 0 0 {name=p53347 lab=_69492_/X }
C {devices/lab_pin.sym} 54220 -33040 0 1 {name=p53348 lab=_69493_/X }
C {sky130_stdcells/a211o_4.sym} 54140 -33040 0 0 {name=X_69493_ }
C {devices/lab_pin.sym} 54050 -32890 0 0 {name=p53349 lab=_83507_/CLK }
C {devices/lab_pin.sym} 54050 -32870 0 0 {name=p53350 lab=_71407_/X }
C {devices/lab_pin.sym} 54230 -32890 0 1 {name=p53351 lab=_83510_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -32880 0 0 {name=X_83510_ }
C {devices/lab_pin.sym} 54050 -32750 0 0 {name=p53352 lab=_81084_/CLK }
C {devices/lab_pin.sym} 54050 -32730 0 0 {name=p53353 lab=_75908_/X }
C {devices/lab_pin.sym} 54230 -32750 0 1 {name=p53354 lab=_80690_/D }
C {sky130_stdcells/dfxtp_4.sym} 54140 -32740 0 0 {name=X_80722_ }
C {devices/lab_pin.sym} 54080 -32620 0 0 {name=p53355 lab=_68444_/A }
C {devices/lab_pin.sym} 54080 -32580 0 0 {name=p53356 lab=_88368_/Q }
C {devices/lab_pin.sym} 54200 -32600 0 1 {name=p53357 lab=_68444_/X }
C {sky130_stdcells/and2_4.sym} 54140 -32600 0 0 {name=X_68444_ }
C {devices/lab_pin.sym} 54060 -32490 0 0 {name=p53358 lab=_85591_/Q }
C {devices/lab_pin.sym} 54060 -32450 0 0 {name=p53359 lab=_53660_/X }
C {devices/lab_pin.sym} 54060 -32410 0 0 {name=p53360 lab=_53669_/Y }
C {devices/lab_pin.sym} 54220 -32450 0 1 {name=p53361 lab=_53670_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -32450 0 0 {name=X_53670_ }
C {devices/lab_pin.sym} 54060 -32340 0 0 {name=p53362 lab=_65654_/X }
C {devices/lab_pin.sym} 54060 -32300 0 0 {name=p53363 lab=_86194_/Q }
C {devices/lab_pin.sym} 54060 -32260 0 0 {name=p53364 lab=_65576_/X }
C {devices/lab_pin.sym} 54060 -32220 0 0 {name=p53365 lab=_65655_/X }
C {devices/lab_pin.sym} 54220 -32280 0 1 {name=p53366 lab=_65656_/X }
C {sky130_stdcells/a211o_4.sym} 54140 -32280 0 0 {name=X_65656_ }
C {devices/lab_pin.sym} 54050 -32130 0 0 {name=p53367 lab=_84649_/CLK }
C {devices/lab_pin.sym} 54050 -32110 0 0 {name=p53368 lab=_61275_/Y }
C {devices/lab_pin.sym} 54230 -32130 0 1 {name=p53369 lab=_84490_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -32120 0 0 {name=X_84490_ }
C {devices/lab_pin.sym} 54100 -31990 0 0 {name=p53370 lab=_50819_/X }
C {devices/lab_pin.sym} 54180 -31990 0 1 {name=p53371 lab=_50882_/X }
C {sky130_stdcells/buf_2.sym} 54140 -31990 0 0 {name=X_50882_ }
C {devices/lab_pin.sym} 54100 -31870 0 0 {name=p53372 lab=_60273_/A }
C {devices/lab_pin.sym} 54180 -31870 0 1 {name=p53373 lab=_62935_/B }
C {sky130_stdcells/buf_2.sym} 54140 -31870 0 0 {name=X_62868_ }
C {devices/lab_pin.sym} 54100 -31750 0 0 {name=p53374 lab=_52648_/A }
C {devices/lab_pin.sym} 54180 -31750 0 1 {name=p53375 lab=_52643_/A }
C {sky130_stdcells/buf_2.sym} 54140 -31750 0 0 {name=X_52621_ }
C {devices/lab_pin.sym} 54100 -31630 0 0 {name=p53376 lab=_60109_/A }
C {devices/lab_pin.sym} 54180 -31630 0 1 {name=p53377 lab=_64608_/A }
C {sky130_stdcells/buf_2.sym} 54140 -31630 0 0 {name=X_64607_ }
C {devices/lab_pin.sym} 54050 -31510 0 0 {name=p53378 lab=_83338_/CLK }
C {devices/lab_pin.sym} 54050 -31490 0 0 {name=p53379 lab=_83441_/D }
C {devices/lab_pin.sym} 54230 -31510 0 1 {name=p53380 lab=_83441_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -31500 0 0 {name=X_83441_ }
C {devices/lab_pin.sym} 54100 -31370 0 0 {name=p53381 lab=_62851_/A }
C {devices/lab_pin.sym} 54180 -31370 0 1 {name=p53382 lab=_61820_/A }
C {sky130_stdcells/buf_2.sym} 54140 -31370 0 0 {name=X_61819_ }
C {devices/lab_pin.sym} 54050 -31250 0 0 {name=p53383 lab=_86772_/CLK }
C {devices/lab_pin.sym} 54050 -31230 0 0 {name=p53384 lab=_80653_/D }
C {devices/lab_pin.sym} 54230 -31250 0 1 {name=p53385 lab=_80653_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -31240 0 0 {name=X_80653_ }
C {devices/lab_pin.sym} 54060 -31130 0 0 {name=p53386 lab=_83977_/Q }
C {devices/lab_pin.sym} 54060 -31090 0 0 {name=p53387 lab=_68338_/X }
C {devices/lab_pin.sym} 54060 -31050 0 0 {name=p53388 lab=_68374_/X }
C {devices/lab_pin.sym} 54220 -31090 0 1 {name=p53389 lab=_83977_/D }
C {sky130_stdcells/a21bo_4.sym} 54140 -31090 0 0 {name=X_68375_ }
C {devices/lab_pin.sym} 54080 -30960 0 0 {name=p53390 lab=_65587_/A }
C {devices/lab_pin.sym} 54080 -30920 0 0 {name=p53391 lab=_65587_/B }
C {devices/lab_pin.sym} 54200 -30940 0 1 {name=p53392 lab=_65587_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -30940 0 0 {name=X_65587_ }
C {devices/lab_pin.sym} 54080 -30830 0 0 {name=p53393 lab=_62773_/X }
C {devices/lab_pin.sym} 54080 -30790 0 0 {name=p53394 lab=_62762_/B }
C {devices/lab_pin.sym} 54080 -30750 0 0 {name=p53395 lab=_61922_/X }
C {devices/lab_pin.sym} 54200 -30790 0 1 {name=p53396 lab=_62799_/Y }
C {sky130_stdcells/nand3_4.sym} 54140 -30790 0 0 {name=X_62799_ }
C {devices/lab_pin.sym} 54080 -30670 0 0 {name=p53397 lab=_55336_/X }
C {devices/lab_pin.sym} 54080 -30630 0 0 {name=p53398 lab=_83752_/Q }
C {devices/lab_pin.sym} 54080 -30590 0 0 {name=p53399 lab=_55365_/B }
C {devices/lab_pin.sym} 54200 -30630 0 1 {name=p53400 lab=_55445_/D }
C {sky130_stdcells/nand3_4.sym} 54140 -30630 0 0 {name=X_55340_ }
C {devices/lab_pin.sym} 54060 -30510 0 0 {name=p53401 lab=_67323_/X }
C {devices/lab_pin.sym} 54060 -30470 0 0 {name=p53402 lab=_67325_/X }
C {devices/lab_pin.sym} 54060 -30430 0 0 {name=p53403 lab=_67255_/X }
C {devices/lab_pin.sym} 54220 -30470 0 1 {name=p53404 lab=_67326_/Y }
C {sky130_stdcells/a21oi_4.sym} 54140 -30470 0 0 {name=X_67326_ }
C {devices/lab_pin.sym} 54050 -30330 0 0 {name=p53405 lab=_83306_/CLK }
C {devices/lab_pin.sym} 54050 -30310 0 0 {name=p53406 lab=_50653_/Y }
C {devices/lab_pin.sym} 54230 -30330 0 1 {name=p53407 lab=_86160_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -30320 0 0 {name=X_86160_ }
C {devices/lab_pin.sym} 54060 -30210 0 0 {name=p53408 lab=_65270_/B }
C {devices/lab_pin.sym} 54060 -30170 0 0 {name=p53409 lab=_52549_/X }
C {devices/lab_pin.sym} 54060 -30130 0 0 {name=p53410 lab=_52551_/Y }
C {devices/lab_pin.sym} 54220 -30170 0 1 {name=p53411 lab=_52552_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -30170 0 0 {name=X_52552_ }
C {devices/lab_pin.sym} 54060 -30050 0 0 {name=p53412 lab=_58987_/Y }
C {devices/lab_pin.sym} 54060 -30010 0 0 {name=p53413 lab=_64226_/X }
C {devices/lab_pin.sym} 54060 -29970 0 0 {name=p53414 lab=_64537_/Y }
C {devices/lab_pin.sym} 54220 -30010 0 1 {name=p53415 lab=_64538_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -30010 0 0 {name=X_64538_ }
C {devices/lab_pin.sym} 54050 -29870 0 0 {name=p53416 lab=_83372_/CLK }
C {devices/lab_pin.sym} 54050 -29850 0 0 {name=p53417 lab=_71797_/Y }
C {devices/lab_pin.sym} 54230 -29870 0 1 {name=p53418 lab=_83372_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -29860 0 0 {name=X_83372_ }
C {sky130_stdcells/decap_3.sym} 54140 -29700 0 0 {name=XPHY_307 }
C {devices/lab_pin.sym} 54080 -29560 0 0 {name=p53419 lab=_80581_/X }
C {devices/lab_pin.sym} 54080 -29520 0 0 {name=p53420 lab=_80584_/B }
C {devices/lab_pin.sym} 54200 -29540 0 1 {name=p53421 lab=_82269_/D }
C {sky130_stdcells/xor2_4.sym} 54140 -29540 0 0 {name=X_80584_ }
C {sky130_stdcells/decap_3.sym} 54140 -29380 0 0 {name=XPHY_318 }
C {sky130_stdcells/decap_3.sym} 54140 -29200 0 0 {name=XPHY_329 }
C {devices/lab_pin.sym} 54050 -29050 0 0 {name=p53422 lab=_85089_/CLK }
C {devices/lab_pin.sym} 54050 -29030 0 0 {name=p53423 lab=_85111_/D }
C {devices/lab_pin.sym} 54230 -29050 0 1 {name=p53424 lab=_45549_/A }
C {sky130_stdcells/dfxtp_4.sym} 54140 -29040 0 0 {name=X_85111_ }
C {devices/lab_pin.sym} 54100 -28910 0 0 {name=p53425 lab=_51557_/A }
C {devices/lab_pin.sym} 54180 -28910 0 1 {name=p53426 lab=_51503_/X }
C {sky130_stdcells/buf_2.sym} 54140 -28910 0 0 {name=X_51503_ }
C {devices/lab_pin.sym} 54050 -28790 0 0 {name=p53427 lab=_82103_/CLK }
C {devices/lab_pin.sym} 54050 -28770 0 0 {name=p53428 lab=_77123_/B }
C {devices/lab_pin.sym} 54230 -28790 0 1 {name=p53429 lab=_82323_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -28780 0 0 {name=X_82323_ }
C {devices/lab_pin.sym} 54060 -28670 0 0 {name=p53430 lab=_55268_/X }
C {devices/lab_pin.sym} 54060 -28630 0 0 {name=p53431 lab=_55270_/X }
C {devices/lab_pin.sym} 54060 -28590 0 0 {name=p53432 lab=_44109_/X }
C {devices/lab_pin.sym} 54220 -28630 0 1 {name=p53433 lab=_55285_/A }
C {sky130_stdcells/a21o_4.sym} 54140 -28630 0 0 {name=X_55271_ }
C {devices/lab_pin.sym} 54060 -28520 0 0 {name=p53434 lab=_67141_/X }
C {devices/lab_pin.sym} 54060 -28480 0 0 {name=p53435 lab=_67247_/Y }
C {devices/lab_pin.sym} 54060 -28440 0 0 {name=p53436 lab=_67152_/X }
C {devices/lab_pin.sym} 54060 -28400 0 0 {name=p53437 lab=_67256_/Y }
C {devices/lab_pin.sym} 54220 -28460 0 1 {name=p53438 lab=_67257_/X }
C {sky130_stdcells/a211o_4.sym} 54140 -28460 0 0 {name=X_67257_ }
C {devices/lab_pin.sym} 54050 -28310 0 0 {name=p53439 lab=_86091_/CLK }
C {devices/lab_pin.sym} 54050 -28290 0 0 {name=p53440 lab=_86091_/D }
C {devices/lab_pin.sym} 54230 -28310 0 1 {name=p53441 lab=_86091_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -28300 0 0 {name=X_86091_ }
C {devices/lab_pin.sym} 54060 -28190 0 0 {name=p53442 lab=_52481_/Y }
C {devices/lab_pin.sym} 54060 -28150 0 0 {name=p53443 lab=_52462_/X }
C {devices/lab_pin.sym} 54060 -28110 0 0 {name=p53444 lab=_52482_/Y }
C {devices/lab_pin.sym} 54220 -28150 0 1 {name=p53445 lab=_52483_/Y }
C {sky130_stdcells/a21boi_4.sym} 54140 -28150 0 0 {name=X_52483_ }
C {devices/lab_pin.sym} 54060 -28030 0 0 {name=p53446 lab=_58274_/A }
C {devices/lab_pin.sym} 54060 -27990 0 0 {name=p53447 lab=_64423_/X }
C {devices/lab_pin.sym} 54060 -27950 0 0 {name=p53448 lab=_64468_/Y }
C {devices/lab_pin.sym} 54220 -27990 0 1 {name=p53449 lab=_64469_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -27990 0 0 {name=X_64469_ }
C {devices/lab_pin.sym} 54100 -27850 0 0 {name=p53450 lab=_57010_/A }
C {devices/lab_pin.sym} 54180 -27850 0 1 {name=p53451 lab=_57010_/Y }
C {sky130_stdcells/inv_2.sym} 54140 -27850 0 0 {name=X_57010_ }
C {devices/lab_pin.sym} 54100 -27730 0 0 {name=p53452 lab=_54250_/A }
C {devices/lab_pin.sym} 54180 -27730 0 1 {name=p53453 lab=_54230_/A }
C {sky130_stdcells/buf_2.sym} 54140 -27730 0 0 {name=X_54222_ }
C {devices/lab_pin.sym} 54080 -27630 0 0 {name=p53454 lab=_65752_/X }
C {devices/lab_pin.sym} 54080 -27590 0 0 {name=p53455 lab=_66195_/B }
C {devices/lab_pin.sym} 54080 -27550 0 0 {name=p53456 lab=_65754_/X }
C {devices/lab_pin.sym} 54200 -27590 0 1 {name=p53457 lab=_66217_/A }
C {sky130_stdcells/nand3_4.sym} 54140 -27590 0 0 {name=X_66208_ }
C {devices/lab_pin.sym} 54050 -27450 0 0 {name=p53458 lab=_85042_/CLK }
C {devices/lab_pin.sym} 54050 -27430 0 0 {name=p53459 lab=_85042_/D }
C {devices/lab_pin.sym} 54230 -27450 0 1 {name=p53460 lab=_85042_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -27440 0 0 {name=X_85042_ }
C {devices/lab_pin.sym} 54060 -27330 0 0 {name=p53461 lab=_51432_/Y }
C {devices/lab_pin.sym} 54060 -27290 0 0 {name=p53462 lab=_51420_/X }
C {devices/lab_pin.sym} 54060 -27250 0 0 {name=p53463 lab=_51433_/X }
C {devices/lab_pin.sym} 54220 -27290 0 1 {name=p53464 lab=_86011_/D }
C {sky130_stdcells/a21oi_4.sym} 54140 -27290 0 0 {name=X_51434_ }
C {devices/lab_pin.sym} 54050 -27150 0 0 {name=p53465 lab=_85332_/CLK }
C {devices/lab_pin.sym} 54050 -27130 0 0 {name=p53466 lab=_80429_/X }
C {devices/lab_pin.sym} 54230 -27150 0 1 {name=p53467 lab=_82254_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -27140 0 0 {name=X_82254_ }
C {devices/lab_pin.sym} 54080 -27020 0 0 {name=p53468 lab=_67095_/A }
C {devices/lab_pin.sym} 54080 -26980 0 0 {name=p53469 lab=_67188_/B }
C {devices/lab_pin.sym} 54200 -27000 0 1 {name=p53470 lab=_67188_/X }
C {sky130_stdcells/and2_4.sym} 54140 -27000 0 0 {name=X_67188_ }
C {devices/lab_pin.sym} 54050 -26870 0 0 {name=p53471 lab=_84981_/CLK }
C {devices/lab_pin.sym} 54050 -26850 0 0 {name=p53472 lab=_75037_/X }
C {devices/lab_pin.sym} 54230 -26870 0 1 {name=p53473 lab=_49009_/A }
C {sky130_stdcells/dfxtp_4.sym} 54140 -26860 0 0 {name=X_81205_ }
C {devices/lab_pin.sym} 54080 -26740 0 0 {name=p53474 lab=_54149_/A }
C {devices/lab_pin.sym} 54080 -26700 0 0 {name=p53475 lab=_47324_/A }
C {devices/lab_pin.sym} 54200 -26720 0 1 {name=p53476 lab=_54153_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -26720 0 0 {name=X_54153_ }
C {devices/lab_pin.sym} 54080 -26610 0 0 {name=p53477 lab=_66164_/A }
C {devices/lab_pin.sym} 54080 -26570 0 0 {name=p53478 lab=_66164_/B }
C {devices/lab_pin.sym} 54080 -26530 0 0 {name=p53479 lab=_66138_/Y }
C {devices/lab_pin.sym} 54200 -26570 0 1 {name=p53480 lab=_66139_/Y }
C {sky130_stdcells/nor3_4.sym} 54140 -26570 0 0 {name=X_66139_ }
C {devices/lab_pin.sym} 54060 -26450 0 0 {name=p53481 lab=_65260_/B }
C {devices/lab_pin.sym} 54060 -26410 0 0 {name=p53482 lab=_51362_/X }
C {devices/lab_pin.sym} 54060 -26370 0 0 {name=p53483 lab=_51364_/Y }
C {devices/lab_pin.sym} 54220 -26410 0 1 {name=p53484 lab=_51365_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -26410 0 0 {name=X_51365_ }
C {devices/lab_pin.sym} 54050 -26270 0 0 {name=p53485 lab=_84951_/CLK }
C {devices/lab_pin.sym} 54050 -26250 0 0 {name=p53486 lab=_82185_/D }
C {devices/lab_pin.sym} 54230 -26270 0 1 {name=p53487 lab=_82185_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -26260 0 0 {name=X_82185_ }
C {devices/lab_pin.sym} 54060 -26150 0 0 {name=p53488 lab=_53102_/Y }
C {devices/lab_pin.sym} 54060 -26110 0 0 {name=p53489 lab=_53082_/X }
C {devices/lab_pin.sym} 54060 -26070 0 0 {name=p53490 lab=_53103_/X }
C {devices/lab_pin.sym} 54220 -26110 0 1 {name=p53491 lab=_53104_/Y }
C {sky130_stdcells/a21oi_4.sym} 54140 -26110 0 0 {name=X_53104_ }
C {devices/lab_pin.sym} 54100 -25970 0 0 {name=p53492 lab=_50219_/X }
C {devices/lab_pin.sym} 54180 -25970 0 1 {name=p53493 lab=_50316_/X }
C {sky130_stdcells/buf_2.sym} 54140 -25970 0 0 {name=X_50316_ }
C {devices/lab_pin.sym} 54050 -25850 0 0 {name=p53494 lab=_80818_/CLK }
C {devices/lab_pin.sym} 54050 -25830 0 0 {name=p53495 lab=_81136_/D }
C {devices/lab_pin.sym} 54230 -25850 0 1 {name=p53496 lab=_81136_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -25840 0 0 {name=X_81136_ }
C {devices/lab_pin.sym} 54100 -25710 0 0 {name=p53497 lab=_58877_/A }
C {devices/lab_pin.sym} 54180 -25710 0 1 {name=p53498 lab=_58961_/X }
C {sky130_stdcells/buf_2.sym} 54140 -25710 0 0 {name=X_58961_ }
C {devices/lab_pin.sym} 54060 -25610 0 0 {name=p53499 lab=_54082_/Y }
C {devices/lab_pin.sym} 54060 -25570 0 0 {name=p53500 lab=_53472_/X }
C {devices/lab_pin.sym} 54060 -25530 0 0 {name=p53501 lab=_54083_/Y }
C {devices/lab_pin.sym} 54220 -25570 0 1 {name=p53502 lab=_85508_/D }
C {sky130_stdcells/a21boi_4.sym} 54140 -25570 0 0 {name=X_54084_ }
C {devices/lab_pin.sym} 54080 -25440 0 0 {name=p53503 lab=_51296_/A }
C {devices/lab_pin.sym} 54080 -25400 0 0 {name=p53504 lab=_49265_/B }
C {devices/lab_pin.sym} 54200 -25420 0 1 {name=p53505 lab=_51296_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -25420 0 0 {name=X_51296_ }
C {devices/lab_pin.sym} 54050 -25290 0 0 {name=p53506 lab=_86998_/CLK }
C {devices/lab_pin.sym} 54050 -25270 0 0 {name=p53507 lab=_86993_/D }
C {devices/lab_pin.sym} 54230 -25290 0 1 {name=p53508 lab=_86993_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -25280 0 0 {name=X_86993_ }
C {devices/lab_pin.sym} 54100 -25150 0 0 {name=p53509 lab=_53062_/A }
C {devices/lab_pin.sym} 54180 -25150 0 1 {name=p53510 lab=_53058_/C }
C {sky130_stdcells/buf_2.sym} 54140 -25150 0 0 {name=X_53035_ }
C {devices/lab_pin.sym} 54100 -25030 0 0 {name=p53511 lab=_84940_/Q }
C {devices/lab_pin.sym} 54180 -25030 0 1 {name=p53512 lab=_57912_/Y }
C {sky130_stdcells/inv_2.sym} 54140 -25030 0 0 {name=X_57912_ }
C {devices/lab_pin.sym} 54100 -24910 0 0 {name=p53513 lab=_53190_/A }
C {devices/lab_pin.sym} 54180 -24910 0 1 {name=p53514 lab=_50247_/X }
C {sky130_stdcells/buf_2.sym} 54140 -24910 0 0 {name=X_50247_ }
C {devices/lab_pin.sym} 54050 -24790 0 0 {name=p53515 lab=_82774_/CLK }
C {devices/lab_pin.sym} 54050 -24770 0 0 {name=p53516 lab=_85944_/D }
C {devices/lab_pin.sym} 54230 -24790 0 1 {name=p53517 lab=_85944_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -24780 0 0 {name=X_85944_ }
C {devices/lab_pin.sym} 54050 -24650 0 0 {name=p53518 lab=_83944_/CLK }
C {devices/lab_pin.sym} 54050 -24630 0 0 {name=p53519 lab=_81099_/Q }
C {devices/lab_pin.sym} 54230 -24650 0 1 {name=p53520 lab=_75201_/B }
C {sky130_stdcells/dfxtp_4.sym} 54140 -24640 0 0 {name=X_81067_ }
C {devices/lab_pin.sym} 54060 -24530 0 0 {name=p53521 lab=_58813_/X }
C {devices/lab_pin.sym} 54060 -24490 0 0 {name=p53522 lab=_85768_/Q }
C {devices/lab_pin.sym} 54060 -24450 0 0 {name=p53523 lab=_58838_/X }
C {devices/lab_pin.sym} 54220 -24490 0 1 {name=p53524 lab=_58892_/X }
C {sky130_stdcells/o21a_4.sym} 54140 -24490 0 0 {name=X_58892_ }
C {devices/lab_pin.sym} 54080 -24360 0 0 {name=p53525 lab=_84659_/Q }
C {devices/lab_pin.sym} 54080 -24320 0 0 {name=p53526 lab=_64100_/C }
C {devices/lab_pin.sym} 54200 -24340 0 1 {name=p53527 lab=_80018_/X }
C {sky130_stdcells/xor2_4.sym} 54140 -24340 0 0 {name=X_80018_ }
C {devices/lab_pin.sym} 54080 -24220 0 0 {name=p53528 lab=_57806_/X }
C {devices/lab_pin.sym} 54080 -24180 0 0 {name=p53529 lab=_86329_/Q }
C {devices/lab_pin.sym} 54200 -24200 0 1 {name=p53530 lab=_57843_/Y }
C {sky130_stdcells/nor2_4.sym} 54140 -24200 0 0 {name=X_57843_ }
C {devices/lab_pin.sym} 54060 -24100 0 0 {name=p53531 lab=_69403_/Y }
C {devices/lab_pin.sym} 54060 -24060 0 0 {name=p53532 lab=_69732_/X }
C {devices/lab_pin.sym} 54060 -24020 0 0 {name=p53533 lab=_69815_/X }
C {devices/lab_pin.sym} 54060 -23980 0 0 {name=p53534 lab=_69828_/Y }
C {devices/lab_pin.sym} 54220 -24040 0 1 {name=p53535 lab=_69829_/X }
C {sky130_stdcells/a211o_4.sym} 54140 -24040 0 0 {name=X_69829_ }
C {devices/lab_pin.sym} 54060 -23910 0 0 {name=p53536 lab=_65249_/B }
C {devices/lab_pin.sym} 54060 -23870 0 0 {name=p53537 lab=_50162_/X }
C {devices/lab_pin.sym} 54060 -23830 0 0 {name=p53538 lab=_50177_/Y }
C {devices/lab_pin.sym} 54220 -23870 0 1 {name=p53539 lab=_50178_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -23870 0 0 {name=X_50178_ }
C {devices/lab_pin.sym} 54050 -23730 0 0 {name=p53540 lab=_86191_/CLK }
C {devices/lab_pin.sym} 54050 -23710 0 0 {name=p53541 lab=_52172_/Y }
C {devices/lab_pin.sym} 54230 -23730 0 1 {name=p53542 lab=_85875_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -23720 0 0 {name=X_85875_ }
C {devices/lab_pin.sym} 54050 -23590 0 0 {name=p53543 lab=_88128_/CLK }
C {devices/lab_pin.sym} 54050 -23570 0 0 {name=p53544 lab=_87614_/D }
C {devices/lab_pin.sym} 54230 -23590 0 1 {name=p53545 lab=_87614_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -23580 0 0 {name=X_87614_ }
C {devices/lab_pin.sym} 54080 -23460 0 0 {name=p53546 lab=_73535_/A }
C {devices/lab_pin.sym} 54080 -23420 0 0 {name=p53547 lab=_72840_/B }
C {devices/lab_pin.sym} 54200 -23440 0 1 {name=p53548 lab=_72840_/X }
C {sky130_stdcells/and2_4.sym} 54140 -23440 0 0 {name=X_72840_ }
C {devices/lab_pin.sym} 54050 -23310 0 0 {name=p53549 lab=_84829_/CLK }
C {devices/lab_pin.sym} 54050 -23290 0 0 {name=p53550 lab=_84826_/D }
C {devices/lab_pin.sym} 54230 -23310 0 1 {name=p53551 lab=_84826_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -23300 0 0 {name=X_84826_ }
C {devices/lab_pin.sym} 54060 -23190 0 0 {name=p53552 lab=_57773_/X }
C {devices/lab_pin.sym} 54060 -23150 0 0 {name=p53553 lab=_85725_/Q }
C {devices/lab_pin.sym} 54060 -23110 0 0 {name=p53554 lab=_44177_/X }
C {devices/lab_pin.sym} 54220 -23150 0 1 {name=p53555 lab=_57774_/X }
C {sky130_stdcells/o21a_4.sym} 54140 -23150 0 0 {name=X_57774_ }
C {devices/lab_pin.sym} 54060 -23030 0 0 {name=p53556 lab=_85340_/Q }
C {devices/lab_pin.sym} 54060 -22990 0 0 {name=p53557 lab=_54967_/X }
C {devices/lab_pin.sym} 54060 -22950 0 0 {name=p53558 lab=_54985_/Y }
C {devices/lab_pin.sym} 54220 -22990 0 1 {name=p53559 lab=_54986_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -22990 0 0 {name=X_54986_ }
C {devices/lab_pin.sym} 54100 -22850 0 0 {name=p53560 lab=_43970_/A }
C {devices/lab_pin.sym} 54180 -22850 0 1 {name=p53561 lab=_59876_/B }
C {sky130_stdcells/buf_2.sym} 54140 -22850 0 0 {name=X_59513_ }
C {devices/lab_pin.sym} 54080 -22740 0 0 {name=p53562 lab=_57153_/A }
C {devices/lab_pin.sym} 54080 -22700 0 0 {name=p53563 lab=_56725_/B }
C {devices/lab_pin.sym} 54200 -22720 0 1 {name=p53564 lab=_56725_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -22720 0 0 {name=X_56725_ }
C {devices/lab_pin.sym} 54100 -22590 0 0 {name=p53565 lab=_42024_/A }
C {devices/lab_pin.sym} 54180 -22590 0 1 {name=p53566 lab=_41951_/X }
C {sky130_stdcells/buf_2.sym} 54140 -22590 0 0 {name=X_41951_ }
C {devices/lab_pin.sym} 54050 -22470 0 0 {name=p53567 lab=_87824_/CLK }
C {devices/lab_pin.sym} 54050 -22450 0 0 {name=p53568 lab=_43193_/Y }
C {devices/lab_pin.sym} 54230 -22470 0 1 {name=p53569 lab=_87545_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -22460 0 0 {name=X_87545_ }
C {devices/lab_pin.sym} 54060 -22350 0 0 {name=p53570 lab=_85538_/Q }
C {devices/lab_pin.sym} 54060 -22310 0 0 {name=p53571 lab=_53869_/X }
C {devices/lab_pin.sym} 54060 -22270 0 0 {name=p53572 lab=_53936_/Y }
C {devices/lab_pin.sym} 54220 -22310 0 1 {name=p53573 lab=_53937_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -22310 0 0 {name=X_53937_ }
C {devices/lab_pin.sym} 54100 -22170 0 0 {name=p53574 lab=_72771_/A }
C {devices/lab_pin.sym} 54180 -22170 0 1 {name=p53575 lab=_72924_/B }
C {sky130_stdcells/buf_2.sym} 54140 -22170 0 0 {name=X_72771_ }
C {devices/lab_pin.sym} 54050 -22050 0 0 {name=p53576 lab=_84757_/CLK }
C {devices/lab_pin.sym} 54050 -22030 0 0 {name=p53577 lab=_59252_/Y }
C {devices/lab_pin.sym} 54230 -22050 0 1 {name=p53578 lab=_84757_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -22040 0 0 {name=X_84757_ }
C {devices/lab_pin.sym} 54050 -21910 0 0 {name=p53579 lab=_82558_/CLK }
C {devices/lab_pin.sym} 54050 -21890 0 0 {name=p53580 lab=_81969_/D }
C {devices/lab_pin.sym} 54230 -21910 0 1 {name=p53581 lab=_81969_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -21900 0 0 {name=X_81969_ }
C {devices/lab_pin.sym} 54060 -21790 0 0 {name=p53582 lab=_74508_/Y }
C {devices/lab_pin.sym} 54060 -21750 0 0 {name=p53583 lab=_74492_/X }
C {devices/lab_pin.sym} 54060 -21710 0 0 {name=p53584 lab=_74509_/X }
C {devices/lab_pin.sym} 54220 -21750 0 1 {name=p53585 lab=_74510_/Y }
C {sky130_stdcells/a21oi_4.sym} 54140 -21750 0 0 {name=X_74510_ }
C {devices/lab_pin.sym} 54060 -21630 0 0 {name=p53586 lab=_40877_/X }
C {devices/lab_pin.sym} 54060 -21590 0 0 {name=p53587 lab=_82855_/Q }
C {devices/lab_pin.sym} 54060 -21550 0 0 {name=p53588 lab=_40901_/X }
C {devices/lab_pin.sym} 54220 -21590 0 1 {name=p53589 lab=_40903_/A }
C {sky130_stdcells/o21ai_4.sym} 54140 -21590 0 0 {name=X_40902_ }
C {devices/lab_pin.sym} 54060 -21470 0 0 {name=p53590 lab=_58224_/Y }
C {devices/lab_pin.sym} 54060 -21430 0 0 {name=p53591 lab=_71718_/X }
C {devices/lab_pin.sym} 54060 -21390 0 0 {name=p53592 lab=_71721_/Y }
C {devices/lab_pin.sym} 54220 -21430 0 1 {name=p53593 lab=_83399_/D }
C {sky130_stdcells/o21ai_4.sym} 54140 -21430 0 0 {name=X_71722_ }
C {devices/lab_pin.sym} 54100 -21290 0 0 {name=p53594 lab=_59398_/A }
C {devices/lab_pin.sym} 54180 -21290 0 1 {name=p53595 lab=_59444_/X }
C {sky130_stdcells/buf_2.sym} 54140 -21290 0 0 {name=X_59444_ }
C {devices/lab_pin.sym} 54050 -21170 0 0 {name=p53596 lab=_83707_/CLK }
C {devices/lab_pin.sym} 54050 -21150 0 0 {name=p53597 lab=_83708_/D }
C {devices/lab_pin.sym} 54230 -21170 0 1 {name=p53598 lab=_83708_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -21160 0 0 {name=X_83708_ }
C {devices/lab_pin.sym} 54080 -21040 0 0 {name=p53599 lab=_83331_/Q }
C {devices/lab_pin.sym} 54080 -21000 0 0 {name=p53600 lab=_83330_/Q }
C {devices/lab_pin.sym} 54200 -21020 0 1 {name=p53601 lab=_56912_/A }
C {sky130_stdcells/nand2_4.sym} 54140 -21020 0 0 {name=X_56656_ }
C {devices/lab_pin.sym} 54100 -20890 0 0 {name=p53602 lab=_44669_/Y }
C {devices/lab_pin.sym} 54180 -20890 0 1 {name=p53603 lab=_87007_/D }
C {sky130_stdcells/inv_2.sym} 54140 -20890 0 0 {name=X_44670_ }
C {devices/lab_pin.sym} 54060 -20790 0 0 {name=p53604 lab=_75488_/Y }
C {devices/lab_pin.sym} 54060 -20750 0 0 {name=p53605 lab=_75491_/C }
C {devices/lab_pin.sym} 54060 -20710 0 0 {name=p53606 lab=_75491_/B }
C {devices/lab_pin.sym} 54220 -20750 0 1 {name=p53607 lab=_75493_/A }
C {sky130_stdcells/a21oi_4.sym} 54140 -20750 0 0 {name=X_75490_ }
C {devices/lab_pin.sym} 54050 -20610 0 0 {name=p53608 lab=_87749_/CLK }
C {devices/lab_pin.sym} 54050 -20590 0 0 {name=p53609 lab=_87476_/D }
C {devices/lab_pin.sym} 54230 -20610 0 1 {name=p53610 lab=_87476_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -20600 0 0 {name=X_87476_ }
C {devices/lab_pin.sym} 54060 -20490 0 0 {name=p53611 lab=_53866_/Y }
C {devices/lab_pin.sym} 54060 -20450 0 0 {name=p53612 lab=_53829_/X }
C {devices/lab_pin.sym} 54060 -20410 0 0 {name=p53613 lab=_53867_/X }
C {devices/lab_pin.sym} 54220 -20450 0 1 {name=p53614 lab=_53868_/Y }
C {sky130_stdcells/a21oi_4.sym} 54140 -20450 0 0 {name=X_53868_ }
C {devices/lab_pin.sym} 54100 -20310 0 0 {name=p53615 lab=_42000_/A }
C {devices/lab_pin.sym} 54180 -20310 0 1 {name=p53616 lab=_41882_/X }
C {sky130_stdcells/buf_2.sym} 54140 -20310 0 0 {name=X_41882_ }
C {devices/lab_pin.sym} 54050 -20190 0 0 {name=p53617 lab=_84329_/CLK }
C {devices/lab_pin.sym} 54050 -20170 0 0 {name=p53618 lab=_59854_/Y }
C {devices/lab_pin.sym} 54230 -20190 0 1 {name=p53619 lab=_84688_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -20180 0 0 {name=X_84688_ }
C {devices/lab_pin.sym} 54080 -20060 0 0 {name=p53620 lab=_55607_/A }
C {devices/lab_pin.sym} 54080 -20020 0 0 {name=p53621 lab=_45422_/Y }
C {devices/lab_pin.sym} 54200 -20040 0 1 {name=p53622 lab=_55607_/Y }
C {sky130_stdcells/nor2_4.sym} 54140 -20040 0 0 {name=X_55607_ }
C {devices/lab_pin.sym} 54060 -19940 0 0 {name=p53623 lab=_40640_/X }
C {devices/lab_pin.sym} 54060 -19900 0 0 {name=p53624 lab=_43609_/X }
C {devices/lab_pin.sym} 54060 -19860 0 0 {name=p53625 lab=_43620_/Y }
C {devices/lab_pin.sym} 54060 -19820 0 0 {name=p53626 lab=_43611_/X }
C {devices/lab_pin.sym} 54220 -19880 0 1 {name=p53627 lab=_43622_/A }
C {sky130_stdcells/a2bb2o_4.sym} 54140 -19880 0 0 {name=X_43621_ }
C {devices/lab_pin.sym} 54100 -19730 0 0 {name=p53628 lab=_72001_/A }
C {devices/lab_pin.sym} 54180 -19730 0 1 {name=p53629 lab=_74441_/X }
C {sky130_stdcells/buf_2.sym} 54140 -19730 0 0 {name=X_74441_ }
C {devices/lab_pin.sym} 54050 -19610 0 0 {name=p53630 lab=_86139_/CLK }
C {devices/lab_pin.sym} 54050 -19590 0 0 {name=p53631 lab=_86427_/D }
C {devices/lab_pin.sym} 54230 -19610 0 1 {name=p53632 lab=_64784_/B }
C {sky130_stdcells/dfxtp_4.sym} 54140 -19600 0 0 {name=X_86427_ }
C {devices/lab_pin.sym} 54060 -19510 0 0 {name=p53633 lab=_40758_/X }
C {devices/lab_pin.sym} 54060 -19470 0 0 {name=p53634 lab=_40759_/X }
C {devices/lab_pin.sym} 54060 -19430 0 0 {name=p53635 lab=_40831_/X }
C {devices/lab_pin.sym} 54060 -19390 0 0 {name=p53636 lab=_69740_/B }
C {devices/lab_pin.sym} 54060 -19350 0 0 {name=p53637 lab=_40832_/X }
C {devices/lab_pin.sym} 54220 -19430 0 1 {name=p53638 lab=_40833_/Y }
C {sky130_stdcells/o32ai_4.sym} 54140 -19430 0 0 {name=X_40833_ }
C {devices/lab_pin.sym} 54060 -19290 0 0 {name=p53639 lab=_52814_/Y }
C {devices/lab_pin.sym} 54060 -19250 0 0 {name=p53640 lab=_52809_/X }
C {devices/lab_pin.sym} 54060 -19210 0 0 {name=p53641 lab=_52818_/X }
C {devices/lab_pin.sym} 54220 -19250 0 1 {name=p53642 lab=_52819_/Y }
C {sky130_stdcells/a21oi_4.sym} 54140 -19250 0 0 {name=X_52819_ }
C {devices/lab_pin.sym} 54050 -19110 0 0 {name=p53643 lab=_86127_/CLK }
C {devices/lab_pin.sym} 54050 -19090 0 0 {name=p53644 lab=_83639_/D }
C {devices/lab_pin.sym} 54230 -19110 0 1 {name=p53645 lab=_83639_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -19100 0 0 {name=X_83639_ }
C {devices/lab_pin.sym} 54060 -19000 0 0 {name=p53646 lab=_59364_/Y }
C {devices/lab_pin.sym} 54060 -18960 0 0 {name=p53647 lab=_59230_/X }
C {devices/lab_pin.sym} 54060 -18920 0 0 {name=p53648 lab=_59371_/X }
C {devices/lab_pin.sym} 54060 -18880 0 0 {name=p53649 lab=_59374_/X }
C {devices/lab_pin.sym} 54220 -18940 0 1 {name=p53650 lab=_84747_/D }
C {sky130_stdcells/a22oi_4.sym} 54140 -18940 0 0 {name=X_59375_ }
C {devices/lab_pin.sym} 54060 -18810 0 0 {name=p53651 lab=_58504_/Y }
C {devices/lab_pin.sym} 54060 -18770 0 0 {name=p53652 lab=_71649_/X }
C {devices/lab_pin.sym} 54060 -18730 0 0 {name=p53653 lab=_71652_/Y }
C {devices/lab_pin.sym} 54220 -18770 0 1 {name=p53654 lab=_71653_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -18770 0 0 {name=X_71653_ }
C {devices/lab_pin.sym} 54100 -18630 0 0 {name=p53655 lab=_56764_/B }
C {devices/lab_pin.sym} 54180 -18630 0 1 {name=p53656 lab=_56587_/X }
C {sky130_stdcells/buf_2.sym} 54140 -18630 0 0 {name=X_56587_ }
C {devices/lab_pin.sym} 54100 -18510 0 0 {name=p53657 lab=_53838_/A }
C {devices/lab_pin.sym} 54180 -18510 0 1 {name=p53658 lab=_53799_/X }
C {sky130_stdcells/buf_2.sym} 54140 -18510 0 0 {name=X_53799_ }
C {devices/lab_pin.sym} 54080 -18400 0 0 {name=p53659 lab=_46288_/A }
C {devices/lab_pin.sym} 54080 -18360 0 0 {name=p53660 lab=_53978_/B }
C {devices/lab_pin.sym} 54200 -18380 0 1 {name=p53661 lab=_46340_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -18380 0 0 {name=X_46340_ }
C {devices/lab_pin.sym} 54060 -18270 0 0 {name=p53662 lab=_52979_/B }
C {devices/lab_pin.sym} 54060 -18230 0 0 {name=p53663 lab=_70584_/X }
C {devices/lab_pin.sym} 54060 -18190 0 0 {name=p53664 lab=_70603_/Y }
C {devices/lab_pin.sym} 54220 -18230 0 1 {name=p53665 lab=_83743_/D }
C {sky130_stdcells/o21ai_4.sym} 54140 -18230 0 0 {name=X_70604_ }
C {devices/lab_pin.sym} 54080 -18100 0 0 {name=p53666 lab=_58326_/A }
C {devices/lab_pin.sym} 54080 -18060 0 0 {name=p53667 lab=_58326_/B }
C {devices/lab_pin.sym} 54200 -18080 0 1 {name=p53668 lab=_58326_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -18080 0 0 {name=X_58326_ }
C {devices/lab_pin.sym} 54080 -17960 0 0 {name=p53669 lab=_77173_/A }
C {devices/lab_pin.sym} 54080 -17920 0 0 {name=p53670 lab=_77159_/Y }
C {devices/lab_pin.sym} 54200 -17940 0 1 {name=p53671 lab=_77161_/B }
C {sky130_stdcells/xor2_4.sym} 54140 -17940 0 0 {name=X_77160_ }
C {devices/lab_pin.sym} 54060 -17850 0 0 {name=p53672 lab=_43542_/X }
C {devices/lab_pin.sym} 54060 -17810 0 0 {name=p53673 lab=_43546_/X }
C {devices/lab_pin.sym} 54060 -17770 0 0 {name=p53674 lab=_40459_/X }
C {devices/lab_pin.sym} 54060 -17730 0 0 {name=p53675 lab=_87364_/Q }
C {devices/lab_pin.sym} 54060 -17690 0 0 {name=p53676 lab=_43549_/X }
C {devices/lab_pin.sym} 54220 -17770 0 1 {name=p53677 lab=_43553_/A }
C {sky130_stdcells/o32ai_4.sym} 54140 -17770 0 0 {name=X_43552_ }
C {devices/lab_pin.sym} 54060 -17640 0 0 {name=p53678 lab=_45535_/A }
C {devices/lab_pin.sym} 54060 -17600 0 0 {name=p53679 lab=_55510_/X }
C {devices/lab_pin.sym} 54060 -17560 0 0 {name=p53680 lab=_44048_/X }
C {devices/lab_pin.sym} 54060 -17520 0 0 {name=p53681 lab=_55537_/Y }
C {devices/lab_pin.sym} 54220 -17580 0 1 {name=p53682 lab=_55538_/X }
C {sky130_stdcells/a211o_4.sym} 54140 -17580 0 0 {name=X_55538_ }
C {devices/lab_pin.sym} 54060 -17450 0 0 {name=p53683 lab=_74369_/Y }
C {devices/lab_pin.sym} 54060 -17410 0 0 {name=p53684 lab=_74370_/X }
C {devices/lab_pin.sym} 54060 -17370 0 0 {name=p53685 lab=_74371_/X }
C {devices/lab_pin.sym} 54220 -17410 0 1 {name=p53686 lab=_74372_/Y }
C {sky130_stdcells/a21oi_4.sym} 54140 -17410 0 0 {name=X_74372_ }
C {devices/lab_pin.sym} 54050 -17270 0 0 {name=p53687 lab=_86359_/CLK }
C {devices/lab_pin.sym} 54050 -17250 0 0 {name=p53688 lab=_86358_/D }
C {devices/lab_pin.sym} 54230 -17270 0 1 {name=p53689 lab=_86358_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -17260 0 0 {name=X_86358_ }
C {devices/lab_pin.sym} 54100 -17130 0 0 {name=p53690 lab=_40764_/A }
C {devices/lab_pin.sym} 54180 -17130 0 1 {name=p53691 lab=_88340_/D }
C {sky130_stdcells/inv_2.sym} 54140 -17130 0 0 {name=X_40764_ }
C {devices/lab_pin.sym} 54060 -17030 0 0 {name=p53692 lab=_71581_/X }
C {devices/lab_pin.sym} 54060 -16990 0 0 {name=p53693 lab=_83449_/Q }
C {devices/lab_pin.sym} 54060 -16950 0 0 {name=p53694 lab=_71583_/Y }
C {devices/lab_pin.sym} 54220 -16990 0 1 {name=p53695 lab=_83449_/D }
C {sky130_stdcells/a21o_4.sym} 54140 -16990 0 0 {name=X_71584_ }
C {devices/lab_pin.sym} 54060 -16870 0 0 {name=p53696 lab=_76107_/Y }
C {devices/lab_pin.sym} 54060 -16830 0 0 {name=p53697 lab=_76099_/B }
C {devices/lab_pin.sym} 54060 -16790 0 0 {name=p53698 lab=_76110_/X }
C {devices/lab_pin.sym} 54220 -16830 0 1 {name=p53699 lab=_76112_/B }
C {sky130_stdcells/o21ai_4.sym} 54140 -16830 0 0 {name=X_76111_ }
C {devices/lab_pin.sym} 54060 -16730 0 0 {name=p53700 lab=_42486_/X }
C {devices/lab_pin.sym} 54060 -16690 0 0 {name=p53701 lab=_42501_/X }
C {devices/lab_pin.sym} 54060 -16650 0 0 {name=p53702 lab=_40678_/X }
C {devices/lab_pin.sym} 54060 -16610 0 0 {name=p53703 lab=_42502_/Y }
C {devices/lab_pin.sym} 54060 -16570 0 0 {name=p53704 lab=_42489_/X }
C {devices/lab_pin.sym} 54220 -16650 0 1 {name=p53705 lab=_87843_/D }
C {sky130_stdcells/o32ai_4.sym} 54140 -16650 0 0 {name=X_42503_ }
C {devices/lab_pin.sym} 54080 -16500 0 0 {name=p53706 lab=_73323_/A }
C {devices/lab_pin.sym} 54080 -16460 0 0 {name=p53707 lab=_73577_/B }
C {devices/lab_pin.sym} 54200 -16480 0 1 {name=p53708 lab=_73323_/Y }
C {sky130_stdcells/nor2_4.sym} 54140 -16480 0 0 {name=X_73323_ }
C {devices/lab_pin.sym} 54050 -16350 0 0 {name=p53709 lab=_85213_/CLK }
C {devices/lab_pin.sym} 54050 -16330 0 0 {name=p53710 lab=_85309_/D }
C {devices/lab_pin.sym} 54230 -16350 0 1 {name=p53711 lab=_56027_/C }
C {sky130_stdcells/dfxtp_4.sym} 54140 -16340 0 0 {name=X_85309_ }
C {devices/lab_pin.sym} 54100 -16210 0 0 {name=p53712 lab=_53951_/B }
C {devices/lab_pin.sym} 54180 -16210 0 1 {name=p53713 lab=_50738_/B }
C {sky130_stdcells/buf_2.sym} 54140 -16210 0 0 {name=X_46271_ }
C {devices/lab_pin.sym} 54100 -16090 0 0 {name=p53714 lab=_70534_/Y }
C {devices/lab_pin.sym} 54180 -16090 0 1 {name=p53715 lab=_71626_/A }
C {sky130_stdcells/buf_2.sym} 54140 -16090 0 0 {name=X_70535_ }
C {devices/lab_pin.sym} 54060 -15990 0 0 {name=p53716 lab=_58253_/X }
C {devices/lab_pin.sym} 54060 -15950 0 0 {name=p53717 lab=_83448_/Q }
C {devices/lab_pin.sym} 54060 -15910 0 0 {name=p53718 lab=_58256_/Y }
C {devices/lab_pin.sym} 54220 -15950 0 1 {name=p53719 lab=_58257_/X }
C {sky130_stdcells/o21a_4.sym} 54140 -15950 0 0 {name=X_58257_ }
C {devices/lab_pin.sym} 54080 -15820 0 0 {name=p53720 lab=_81998_/Q }
C {devices/lab_pin.sym} 54080 -15780 0 0 {name=p53721 lab=_81910_/Q }
C {devices/lab_pin.sym} 54200 -15800 0 1 {name=p53722 lab=_77091_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -15800 0 0 {name=X_77091_ }
C {devices/lab_pin.sym} 54060 -15700 0 0 {name=p53723 lab=_41697_/X }
C {devices/lab_pin.sym} 54060 -15660 0 0 {name=p53724 lab=_43465_/X }
C {devices/lab_pin.sym} 54060 -15620 0 0 {name=p53725 lab=_87399_/Q }
C {devices/lab_pin.sym} 54060 -15580 0 0 {name=p53726 lab=_43467_/X }
C {devices/lab_pin.sym} 54220 -15640 0 1 {name=p53727 lab=_87399_/D }
C {sky130_stdcells/a2bb2o_4.sym} 54140 -15640 0 0 {name=X_43483_ }
C {devices/lab_pin.sym} 54100 -15490 0 0 {name=p53728 lab=_44047_/X }
C {devices/lab_pin.sym} 54180 -15490 0 1 {name=p53729 lab=_55469_/X }
C {sky130_stdcells/buf_2.sym} 54140 -15490 0 0 {name=X_55469_ }
C {devices/lab_pin.sym} 54050 -15370 0 0 {name=p53730 lab=_86289_/CLK }
C {devices/lab_pin.sym} 54050 -15350 0 0 {name=p53731 lab=_86289_/D }
C {devices/lab_pin.sym} 54230 -15370 0 1 {name=p53732 lab=_86289_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -15360 0 0 {name=X_86289_ }
C {devices/lab_pin.sym} 54060 -15250 0 0 {name=p53733 lab=_40670_/X }
C {devices/lab_pin.sym} 54060 -15210 0 0 {name=p53734 lab=_40864_/A }
C {devices/lab_pin.sym} 54060 -15170 0 0 {name=p53735 lab=_40694_/X }
C {devices/lab_pin.sym} 54220 -15210 0 1 {name=p53736 lab=_40695_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -15210 0 0 {name=X_40695_ }
C {devices/lab_pin.sym} 54060 -15090 0 0 {name=p53737 lab=_47867_/X }
C {devices/lab_pin.sym} 54060 -15050 0 0 {name=p53738 lab=_46436_/A }
C {devices/lab_pin.sym} 54060 -15010 0 0 {name=p53739 lab=_48009_/Y }
C {devices/lab_pin.sym} 54220 -15050 0 1 {name=p53740 lab=_48011_/A }
C {sky130_stdcells/o21ai_4.sym} 54140 -15050 0 0 {name=X_48010_ }
C {devices/lab_pin.sym} 54100 -14910 0 0 {name=p53741 lab=_45297_/A }
C {devices/lab_pin.sym} 54180 -14910 0 1 {name=p53742 lab=_45222_/X }
C {sky130_stdcells/buf_2.sym} 54140 -14910 0 0 {name=X_45222_ }
C {devices/lab_pin.sym} 54080 -14800 0 0 {name=p53743 lab=_81714_/D }
C {devices/lab_pin.sym} 54080 -14760 0 0 {name=p53744 lab=_76042_/B }
C {devices/lab_pin.sym} 54200 -14780 0 1 {name=p53745 lab=_76042_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -14780 0 0 {name=X_76042_ }
C {devices/lab_pin.sym} 54080 -14660 0 0 {name=p53746 lab=_57196_/Y }
C {devices/lab_pin.sym} 54080 -14620 0 0 {name=p53747 lab=_57055_/A }
C {devices/lab_pin.sym} 54200 -14640 0 1 {name=p53748 lab=_57208_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -14640 0 0 {name=X_57208_ }
C {devices/lab_pin.sym} 54050 -14510 0 0 {name=p53749 lab=_87767_/CLK }
C {devices/lab_pin.sym} 54050 -14490 0 0 {name=p53750 lab=_88028_/D }
C {devices/lab_pin.sym} 54230 -14510 0 1 {name=p53751 lab=_88028_/Q }
C {sky130_stdcells/dfxtp_4.sym} 54140 -14500 0 0 {name=X_88028_ }
C {devices/lab_pin.sym} 54100 -14370 0 0 {name=p53752 lab=_42373_/X }
C {devices/lab_pin.sym} 54180 -14370 0 1 {name=p53753 lab=_42434_/X }
C {sky130_stdcells/buf_2.sym} 54140 -14370 0 0 {name=X_42434_ }
C {devices/lab_pin.sym} 54060 -14270 0 0 {name=p53754 lab=_73248_/X }
C {devices/lab_pin.sym} 54060 -14230 0 0 {name=p53755 lab=_73253_/X }
C {devices/lab_pin.sym} 54060 -14190 0 0 {name=p53756 lab=_73200_/X }
C {devices/lab_pin.sym} 54220 -14230 0 1 {name=p53757 lab=_73270_/B }
C {sky130_stdcells/a21o_4.sym} 54140 -14230 0 0 {name=X_73254_ }
C {devices/lab_pin.sym} 54100 -14090 0 0 {name=p53758 lab=_70458_/X }
C {devices/lab_pin.sym} 54180 -14090 0 1 {name=p53759 lab=_70466_/Y }
C {sky130_stdcells/inv_2.sym} 54140 -14090 0 0 {name=X_70466_ }
C {devices/lab_pin.sym} 54080 -13980 0 0 {name=p53760 lab=_58187_/X }
C {devices/lab_pin.sym} 54080 -13940 0 0 {name=p53761 lab=_58184_/B }
C {devices/lab_pin.sym} 54200 -13960 0 1 {name=p53762 lab=_58188_/Y }
C {sky130_stdcells/nor2_4.sym} 54140 -13960 0 0 {name=X_58188_ }
C {devices/lab_pin.sym} 54080 -13840 0 0 {name=p53763 lab=_86618_/Q }
C {devices/lab_pin.sym} 54080 -13800 0 0 {name=p53764 lab=_72193_/B }
C {devices/lab_pin.sym} 54200 -13820 0 1 {name=p53765 lab=_72205_/Y }
C {sky130_stdcells/nor2_4.sym} 54140 -13820 0 0 {name=X_72205_ }
C {devices/lab_pin.sym} 54100 -13690 0 0 {name=p53766 lab=_45153_/A }
C {devices/lab_pin.sym} 54180 -13690 0 1 {name=p53767 lab=_45153_/X }
C {sky130_stdcells/buf_2.sym} 54140 -13690 0 0 {name=X_45153_ }
C {devices/lab_pin.sym} 54060 -13590 0 0 {name=p53768 lab=_56696_/A }
C {devices/lab_pin.sym} 54060 -13550 0 0 {name=p53769 lab=_57153_/B }
C {devices/lab_pin.sym} 54060 -13510 0 0 {name=p53770 lab=_57138_/Y }
C {devices/lab_pin.sym} 54220 -13550 0 1 {name=p53771 lab=_85073_/D }
C {sky130_stdcells/a21oi_4.sym} 54140 -13550 0 0 {name=X_57139_ }
C {devices/lab_pin.sym} 54100 -13410 0 0 {name=p53772 lab=_42365_/A }
C {devices/lab_pin.sym} 54180 -13410 0 1 {name=p53773 lab=_87899_/D }
C {sky130_stdcells/inv_2.sym} 54140 -13410 0 0 {name=X_42365_ }
C {devices/lab_pin.sym} 54060 -13310 0 0 {name=p53774 lab=_73182_/X }
C {devices/lab_pin.sym} 54060 -13270 0 0 {name=p53775 lab=_73184_/X }
C {devices/lab_pin.sym} 54060 -13230 0 0 {name=p53776 lab=_73067_/A }
C {devices/lab_pin.sym} 54220 -13270 0 1 {name=p53777 lab=_73188_/A }
C {sky130_stdcells/a21o_4.sym} 54140 -13270 0 0 {name=X_73185_ }
C {devices/lab_pin.sym} 54080 -13150 0 0 {name=p53778 lab=_70942_/A }
C {devices/lab_pin.sym} 54080 -13110 0 0 {name=p53779 lab=_74529_/A }
C {devices/lab_pin.sym} 54080 -13070 0 0 {name=p53780 lab=_70407_/C }
C {devices/lab_pin.sym} 54200 -13110 0 1 {name=p53781 lab=_70397_/Y }
C {sky130_stdcells/nand3_4.sym} 54140 -13110 0 0 {name=X_70397_ }
C {devices/lab_pin.sym} 54100 -12970 0 0 {name=p53782 lab=_44104_/A }
C {devices/lab_pin.sym} 54180 -12970 0 1 {name=p53783 lab=_44104_/Y }
C {sky130_stdcells/inv_2.sym} 54140 -12970 0 0 {name=X_44104_ }
C {devices/lab_pin.sym} 54060 -12870 0 0 {name=p53784 lab=_79793_/A }
C {devices/lab_pin.sym} 54060 -12830 0 0 {name=p53785 lab=_79793_/B }
C {devices/lab_pin.sym} 54060 -12790 0 0 {name=p53786 lab=_79800_/X }
C {devices/lab_pin.sym} 54220 -12830 0 1 {name=p53787 lab=_79801_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -12830 0 0 {name=X_79801_ }
C {devices/lab_pin.sym} 54100 -12690 0 0 {name=p53788 lab=_41316_/A }
C {devices/lab_pin.sym} 54180 -12690 0 1 {name=p53789 lab=_41316_/X }
C {sky130_stdcells/buf_2.sym} 54140 -12690 0 0 {name=X_41316_ }
C {devices/lab_pin.sym} 54100 -12570 0 0 {name=p53790 lab=_60150_/A }
C {devices/lab_pin.sym} 54180 -12570 0 1 {name=p53791 lab=_65198_/A }
C {sky130_stdcells/buf_2.sym} 54140 -12570 0 0 {name=X_60150_ }
C {devices/lab_pin.sym} 54060 -12480 0 0 {name=p53792 lab=_83280_/Q }
C {devices/lab_pin.sym} 54060 -12440 0 0 {name=p53793 lab=_72115_/X }
C {devices/lab_pin.sym} 54060 -12400 0 0 {name=p53794 lab=_72130_/X }
C {devices/lab_pin.sym} 54060 -12360 0 0 {name=p53795 lab=_72135_/X }
C {devices/lab_pin.sym} 54220 -12420 0 1 {name=p53796 lab=_83280_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 54140 -12420 0 0 {name=X_72136_ }
C {devices/lab_pin.sym} 54100 -12270 0 0 {name=p53797 lab=_48171_/X }
C {devices/lab_pin.sym} 54180 -12270 0 1 {name=p53798 lab=_49981_/A }
C {sky130_stdcells/buf_2.sym} 54140 -12270 0 0 {name=X_49961_ }
C {devices/lab_pin.sym} 54100 -12150 0 0 {name=p53799 lab=_64343_/B }
C {devices/lab_pin.sym} 54180 -12150 0 1 {name=p53800 lab=_61460_/B }
C {sky130_stdcells/buf_2.sym} 54140 -12150 0 0 {name=X_45084_ }
C {devices/lab_pin.sym} 54060 -12060 0 0 {name=p53801 lab=_41570_/X }
C {devices/lab_pin.sym} 54060 -12020 0 0 {name=p53802 lab=_42290_/X }
C {devices/lab_pin.sym} 54060 -11980 0 0 {name=p53803 lab=_87934_/Q }
C {devices/lab_pin.sym} 54060 -11940 0 0 {name=p53804 lab=_42291_/X }
C {devices/lab_pin.sym} 54220 -12000 0 1 {name=p53805 lab=_87934_/D }
C {sky130_stdcells/a2bb2o_4.sym} 54140 -12000 0 0 {name=X_42296_ }
C {devices/lab_pin.sym} 54080 -11860 0 0 {name=p53806 lab=_77993_/A }
C {devices/lab_pin.sym} 54080 -11820 0 0 {name=p53807 lab=_77993_/B }
C {devices/lab_pin.sym} 54200 -11840 0 1 {name=p53808 lab=_77994_/B }
C {sky130_stdcells/xor2_4.sym} 54140 -11840 0 0 {name=X_77993_ }
C {devices/lab_pin.sym} 54080 -11720 0 0 {name=p53809 lab=_48901_/A }
C {devices/lab_pin.sym} 54080 -11680 0 0 {name=p53810 lab=_48912_/B }
C {devices/lab_pin.sym} 54200 -11700 0 1 {name=p53811 lab=_48912_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -11700 0 0 {name=X_48912_ }
C {devices/lab_pin.sym} 54100 -11570 0 0 {name=p53812 lab=_65614_/A }
C {devices/lab_pin.sym} 54180 -11570 0 1 {name=p53813 lab=_59297_/A }
C {sky130_stdcells/buf_4.sym} 54140 -11570 0 0 {name=X_44035_ }
C {devices/lab_pin.sym} 54080 -11460 0 0 {name=p53814 lab=_84219_/Q }
C {devices/lab_pin.sym} 54080 -11420 0 0 {name=p53815 lab=_83267_/Q }
C {devices/lab_pin.sym} 54200 -11440 0 1 {name=p53816 lab=_79732_/X }
C {sky130_stdcells/xor2_4.sym} 54140 -11440 0 0 {name=X_79732_ }
C {devices/lab_pin.sym} 54100 -11310 0 0 {name=p53817 lab=_41246_/Y }
C {devices/lab_pin.sym} 54180 -11310 0 1 {name=p53818 lab=_41247_/Y }
C {sky130_stdcells/inv_2.sym} 54140 -11310 0 0 {name=X_41247_ }
C {devices/lab_pin.sym} 54080 -11210 0 0 {name=p53819 lab=_60081_/A }
C {devices/lab_pin.sym} 54080 -11170 0 0 {name=p53820 lab=_60081_/B }
C {devices/lab_pin.sym} 54080 -11130 0 0 {name=p53821 lab=_80082_/A }
C {devices/lab_pin.sym} 54200 -11170 0 1 {name=p53822 lab=_60081_/Y }
C {sky130_stdcells/nor3_4.sym} 54140 -11170 0 0 {name=X_60081_ }
C {devices/lab_pin.sym} 54100 -11030 0 0 {name=p53823 lab=_57563_/X }
C {devices/lab_pin.sym} 54180 -11030 0 1 {name=p53824 lab=_72068_/A }
C {sky130_stdcells/buf_2.sym} 54140 -11030 0 0 {name=X_72067_ }
C {devices/lab_pin.sym} 54080 -10920 0 0 {name=p53825 lab=_76941_/Y }
C {devices/lab_pin.sym} 54080 -10880 0 0 {name=p53826 lab=_76944_/B }
C {devices/lab_pin.sym} 54200 -10900 0 1 {name=p53827 lab=_81568_/D }
C {sky130_stdcells/nor2_4.sym} 54140 -10900 0 0 {name=X_76944_ }
C {devices/lab_pin.sym} 54060 -10790 0 0 {name=p53828 lab=_72128_/B }
C {devices/lab_pin.sym} 54060 -10750 0 0 {name=p53829 lab=_49880_/X }
C {devices/lab_pin.sym} 54060 -10710 0 0 {name=p53830 lab=_49891_/Y }
C {devices/lab_pin.sym} 54220 -10750 0 1 {name=p53831 lab=_49892_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -10750 0 0 {name=X_49892_ }
C {devices/lab_pin.sym} 54100 -10610 0 0 {name=p53832 lab=clkbuf_9_245_0_CLK/X }
C {devices/lab_pin.sym} 54180 -10610 0 1 {name=p53833 lab=_85957_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 54140 -10610 0 0 {name=Xclkbuf_10_491_0_CLK }
C {devices/lab_pin.sym} 54080 -10520 0 0 {name=p53834 lab=_71168_/A }
C {devices/lab_pin.sym} 54080 -10480 0 0 {name=p53835 lab=_70620_/B }
C {devices/lab_pin.sym} 54080 -10440 0 0 {name=p53836 lab=_70925_/X }
C {devices/lab_pin.sym} 54080 -10400 0 0 {name=p53837 lab=_71018_/D }
C {devices/lab_pin.sym} 54200 -10460 0 1 {name=p53838 lab=_71018_/Y }
C {sky130_stdcells/nand4_4.sym} 54140 -10460 0 0 {name=X_71018_ }
C {devices/lab_pin.sym} 54080 -10320 0 0 {name=p53839 lab=_48851_/A }
C {devices/lab_pin.sym} 54080 -10280 0 0 {name=p53840 lab=_48843_/B }
C {devices/lab_pin.sym} 54200 -10300 0 1 {name=p53841 lab=_48843_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -10300 0 0 {name=X_48843_ }
C {devices/lab_pin.sym} 54080 -10180 0 0 {name=p53842 lab=_79647_/X }
C {devices/lab_pin.sym} 54080 -10140 0 0 {name=p53843 lab=_79664_/A }
C {devices/lab_pin.sym} 54200 -10160 0 1 {name=p53844 lab=_79663_/X }
C {sky130_stdcells/or2_4.sym} 54140 -10160 0 0 {name=X_79663_ }
C {devices/lab_pin.sym} 54060 -10050 0 0 {name=p53845 lab=_41143_/X }
C {devices/lab_pin.sym} 54060 -10010 0 0 {name=p53846 lab=_40659_/A }
C {devices/lab_pin.sym} 54060 -9970 0 0 {name=p53847 lab=_41177_/X }
C {devices/lab_pin.sym} 54220 -10010 0 1 {name=p53848 lab=_41178_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -10010 0 0 {name=X_41178_ }
C {devices/lab_pin.sym} 54080 -9880 0 0 {name=p53849 lab=_76873_/Y }
C {devices/lab_pin.sym} 54080 -9840 0 0 {name=p53850 lab=_76874_/Y }
C {devices/lab_pin.sym} 54200 -9860 0 1 {name=p53851 lab=_76910_/C }
C {sky130_stdcells/xor2_4.sym} 54140 -9860 0 0 {name=X_76875_ }
C {devices/lab_pin.sym} 54100 -9730 0 0 {name=p53852 lab=_78617_/B }
C {devices/lab_pin.sym} 54180 -9730 0 1 {name=p53853 lab=_78614_/Y }
C {sky130_stdcells/inv_2.sym} 54140 -9730 0 0 {name=X_78614_ }
C {devices/lab_pin.sym} 54080 -9630 0 0 {name=p53854 lab=_75824_/A }
C {devices/lab_pin.sym} 54080 -9590 0 0 {name=p53855 lab=_81021_/Q }
C {devices/lab_pin.sym} 54080 -9550 0 0 {name=p53856 lab=_75824_/B }
C {devices/lab_pin.sym} 54200 -9590 0 1 {name=p53857 lab=_75827_/B }
C {sky130_stdcells/nand3_4.sym} 54140 -9590 0 0 {name=X_75826_ }
C {devices/lab_pin.sym} 54080 -9480 0 0 {name=p53858 lab=_61398_/B }
C {devices/lab_pin.sym} 54080 -9440 0 0 {name=p53859 lab=_63790_/X }
C {devices/lab_pin.sym} 54080 -9400 0 0 {name=p53860 lab=_63840_/C }
C {devices/lab_pin.sym} 54080 -9360 0 0 {name=p53861 lab=_63776_/X }
C {devices/lab_pin.sym} 54200 -9420 0 1 {name=p53862 lab=_63840_/Y }
C {sky130_stdcells/nand4_4.sym} 54140 -9420 0 0 {name=X_63840_ }
C {devices/lab_pin.sym} 54060 -9290 0 0 {name=p53863 lab=_65612_/B }
C {devices/lab_pin.sym} 54060 -9250 0 0 {name=p53864 lab=_48754_/X }
C {devices/lab_pin.sym} 54060 -9210 0 0 {name=p53865 lab=_48773_/Y }
C {devices/lab_pin.sym} 54220 -9250 0 1 {name=p53866 lab=_48774_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -9250 0 0 {name=X_48774_ }
C {devices/lab_pin.sym} 54080 -9130 0 0 {name=p53867 lab=_79594_/A }
C {devices/lab_pin.sym} 54080 -9090 0 0 {name=p53868 lab=_79594_/B }
C {devices/lab_pin.sym} 54080 -9050 0 0 {name=p53869 lab=_79588_/Y }
C {devices/lab_pin.sym} 54200 -9090 0 1 {name=p53870 lab=_79594_/Y }
C {sky130_stdcells/nand3_4.sym} 54140 -9090 0 0 {name=X_79594_ }
C {devices/lab_pin.sym} 54100 -8950 0 0 {name=p53871 lab=_45985_/Y }
C {devices/lab_pin.sym} 54180 -8950 0 1 {name=p53872 lab=_86827_/D }
C {sky130_stdcells/inv_2.sym} 54140 -8950 0 0 {name=X_45986_ }
C {devices/lab_pin.sym} 54100 -8830 0 0 {name=p53873 lab=_47725_/A }
C {devices/lab_pin.sym} 54180 -8830 0 1 {name=p53874 lab=_54903_/B }
C {sky130_stdcells/inv_2.sym} 54140 -8830 0 0 {name=X_47725_ }
C {devices/lab_pin.sym} 54080 -8720 0 0 {name=p53875 lab=_82514_/Q }
C {devices/lab_pin.sym} 54080 -8680 0 0 {name=p53876 lab=_82770_/D }
C {devices/lab_pin.sym} 54200 -8700 0 1 {name=p53877 lab=_82482_/D }
C {sky130_stdcells/xor2_4.sym} 54140 -8700 0 0 {name=X_78545_ }
C {devices/lab_pin.sym} 54060 -8590 0 0 {name=p53878 lab=_74545_/C }
C {devices/lab_pin.sym} 54060 -8550 0 0 {name=p53879 lab=_44933_/X }
C {devices/lab_pin.sym} 54060 -8510 0 0 {name=p53880 lab=_44936_/X }
C {devices/lab_pin.sym} 54220 -8550 0 1 {name=p53881 lab=_44937_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -8550 0 0 {name=X_44937_ }
C {devices/lab_pin.sym} 54100 -8410 0 0 {name=p53882 lab=_63749_/A }
C {devices/lab_pin.sym} 54180 -8410 0 1 {name=p53883 lab=_63772_/B }
C {sky130_stdcells/buf_2.sym} 54140 -8410 0 0 {name=X_63771_ }
C {devices/lab_pin.sym} 54060 -8310 0 0 {name=p53884 lab=_80917_/Q }
C {devices/lab_pin.sym} 54060 -8270 0 0 {name=p53885 lab=_75754_/Y }
C {devices/lab_pin.sym} 54060 -8230 0 0 {name=p53886 lab=_75756_/X }
C {devices/lab_pin.sym} 54220 -8270 0 1 {name=p53887 lab=_75757_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -8270 0 0 {name=X_75757_ }
C {devices/lab_pin.sym} 54100 -8130 0 0 {name=p53888 lab=_64032_/A }
C {devices/lab_pin.sym} 54180 -8130 0 1 {name=p53889 lab=_63738_/B }
C {sky130_stdcells/buf_2.sym} 54140 -8130 0 0 {name=X_60983_ }
C {devices/lab_pin.sym} 54080 -8030 0 0 {name=p53890 lab=_72967_/X }
C {devices/lab_pin.sym} 54080 -7990 0 0 {name=p53891 lab=_72969_/B }
C {devices/lab_pin.sym} 54080 -7950 0 0 {name=p53892 lab=_72969_/C }
C {devices/lab_pin.sym} 54200 -7990 0 1 {name=p53893 lab=_72969_/Y }
C {sky130_stdcells/nand3_4.sym} 54140 -7990 0 0 {name=X_72969_ }
C {devices/lab_pin.sym} 54060 -7880 0 0 {name=p53894 lab=_65342_/X }
C {devices/lab_pin.sym} 54060 -7840 0 0 {name=p53895 lab=_83076_/Q }
C {devices/lab_pin.sym} 54060 -7800 0 0 {name=p53896 lab=_65391_/X }
C {devices/lab_pin.sym} 54060 -7760 0 0 {name=p53897 lab=_65509_/X }
C {devices/lab_pin.sym} 54220 -7820 0 1 {name=p53898 lab=_65510_/X }
C {sky130_stdcells/a211o_4.sym} 54140 -7820 0 0 {name=X_65510_ }
C {devices/lab_pin.sym} 54080 -7690 0 0 {name=p53899 lab=_62673_/A }
C {devices/lab_pin.sym} 54080 -7650 0 0 {name=p53900 lab=_62673_/B }
C {devices/lab_pin.sym} 54080 -7610 0 0 {name=p53901 lab=_75918_/B }
C {devices/lab_pin.sym} 54200 -7650 0 1 {name=p53902 lab=_62722_/Y }
C {sky130_stdcells/nor3_4.sym} 54140 -7650 0 0 {name=X_62722_ }
C {devices/lab_pin.sym} 54100 -7510 0 0 {name=p53903 lab=_74711_/A }
C {devices/lab_pin.sym} 54180 -7510 0 1 {name=p53904 lab=_74708_/Y }
C {sky130_stdcells/inv_2.sym} 54140 -7510 0 0 {name=X_74708_ }
C {devices/lab_pin.sym} 54060 -7410 0 0 {name=p53905 lab=_47650_/Y }
C {devices/lab_pin.sym} 54060 -7370 0 0 {name=p53906 lab=_47651_/X }
C {devices/lab_pin.sym} 54060 -7330 0 0 {name=p53907 lab=_47655_/X }
C {devices/lab_pin.sym} 54220 -7370 0 1 {name=p53908 lab=_86612_/D }
C {sky130_stdcells/a21oi_4.sym} 54140 -7370 0 0 {name=X_47656_ }
C {devices/lab_pin.sym} 54080 -7250 0 0 {name=p53909 lab=_66501_/A }
C {devices/lab_pin.sym} 54080 -7210 0 0 {name=p53910 lab=_66501_/B }
C {devices/lab_pin.sym} 54080 -7170 0 0 {name=p53911 lab=_66490_/C }
C {devices/lab_pin.sym} 54200 -7210 0 1 {name=p53912 lab=_66490_/X }
C {sky130_stdcells/and3_4.sym} 54140 -7210 0 0 {name=X_66490_ }
C {devices/lab_pin.sym} 54100 -7070 0 0 {name=p53913 lab=_78476_/A }
C {devices/lab_pin.sym} 54180 -7070 0 1 {name=p53914 lab=_78476_/Y }
C {sky130_stdcells/inv_2.sym} 54140 -7070 0 0 {name=X_78476_ }
C {devices/lab_pin.sym} 54100 -6950 0 0 {name=p53915 lab=_80670_/Q }
C {devices/lab_pin.sym} 54180 -6950 0 1 {name=p53916 lab=_45387_/A }
C {sky130_stdcells/inv_2.sym} 54140 -6950 0 0 {name=X_44868_ }
C {devices/lab_pin.sym} 54080 -6840 0 0 {name=p53917 lab=_75688_/A }
C {devices/lab_pin.sym} 54080 -6800 0 0 {name=p53918 lab=_80831_/Q }
C {devices/lab_pin.sym} 54200 -6820 0 1 {name=p53919 lab=_75688_/Y }
C {sky130_stdcells/xnor2_4.sym} 54140 -6820 0 0 {name=X_75688_ }
C {devices/lab_pin.sym} 54100 -6690 0 0 {name=p53920 lab=_52577_/B }
C {devices/lab_pin.sym} 54180 -6690 0 1 {name=p53921 lab=_51744_/B }
C {sky130_stdcells/buf_2.sym} 54140 -6690 0 0 {name=X_46607_ }
C {devices/lab_pin.sym} 54080 -6580 0 0 {name=p53922 lab=_65387_/A }
C {devices/lab_pin.sym} 54080 -6540 0 0 {name=p53923 lab=_65441_/B }
C {devices/lab_pin.sym} 54200 -6560 0 1 {name=p53924 lab=_65441_/X }
C {sky130_stdcells/and2_4.sym} 54140 -6560 0 0 {name=X_65441_ }
C {devices/lab_pin.sym} 54060 -6450 0 0 {name=p53925 lab=_77423_/Y }
C {devices/lab_pin.sym} 54060 -6410 0 0 {name=p53926 lab=_77426_/C }
C {devices/lab_pin.sym} 54060 -6370 0 0 {name=p53927 lab=_77422_/Y }
C {devices/lab_pin.sym} 54220 -6410 0 1 {name=p53928 lab=_77427_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -6410 0 0 {name=X_77427_ }
C {devices/lab_pin.sym} 54060 -6300 0 0 {name=p53929 lab=_41108_/X }
C {devices/lab_pin.sym} 54060 -6260 0 0 {name=p53930 lab=_43817_/X }
C {devices/lab_pin.sym} 54060 -6220 0 0 {name=p53931 lab=_69555_/B }
C {devices/lab_pin.sym} 54060 -6180 0 0 {name=p53932 lab=_43818_/X }
C {devices/lab_pin.sym} 54220 -6240 0 1 {name=p53933 lab=_87252_/D }
C {sky130_stdcells/a2bb2o_4.sym} 54140 -6240 0 0 {name=X_43819_ }
C {devices/lab_pin.sym} 54080 -6110 0 0 {name=p53934 lab=_62653_/A }
C {devices/lab_pin.sym} 54080 -6070 0 0 {name=p53935 lab=_62653_/B }
C {devices/lab_pin.sym} 54080 -6030 0 0 {name=p53936 lab=_75923_/B }
C {devices/lab_pin.sym} 54200 -6070 0 1 {name=p53937 lab=_62653_/Y }
C {sky130_stdcells/nor3_4.sym} 54140 -6070 0 0 {name=X_62653_ }
C {devices/lab_pin.sym} 54060 -5960 0 0 {name=p53938 lab=_74638_/X }
C {devices/lab_pin.sym} 54060 -5920 0 0 {name=p53939 lab=_56589_/A }
C {devices/lab_pin.sym} 54060 -5880 0 0 {name=p53940 lab=_45479_/A }
C {devices/lab_pin.sym} 54060 -5840 0 0 {name=p53941 lab=_74633_/X }
C {devices/lab_pin.sym} 54220 -5900 0 1 {name=p53942 lab=_83004_/D }
C {sky130_stdcells/a2bb2o_4.sym} 54140 -5900 0 0 {name=X_74639_ }
C {devices/lab_pin.sym} 54080 -5780 0 0 {name=p53943 lab=_47595_/A }
C {devices/lab_pin.sym} 54080 -5740 0 0 {name=p53944 lab=_47595_/B }
C {devices/lab_pin.sym} 54080 -5700 0 0 {name=p53945 lab=_47595_/C }
C {devices/lab_pin.sym} 54080 -5660 0 0 {name=p53946 lab=_53133_/D }
C {devices/lab_pin.sym} 54200 -5720 0 1 {name=p53947 lab=_47587_/X }
C {sky130_stdcells/and4_4.sym} 54140 -5720 0 0 {name=X_47587_ }
C {devices/lab_pin.sym} 54060 -5600 0 0 {name=p53948 lab=_41432_/Y }
C {devices/lab_pin.sym} 54060 -5560 0 0 {name=p53949 lab=_44788_/X }
C {devices/lab_pin.sym} 54060 -5520 0 0 {name=p53950 lab=_86948_/Q }
C {devices/lab_pin.sym} 54060 -5480 0 0 {name=p53951 lab=_44789_/X }
C {devices/lab_pin.sym} 54220 -5540 0 1 {name=p53952 lab=_86948_/D }
C {sky130_stdcells/a2bb2o_4.sym} 54140 -5540 0 0 {name=X_44799_ }
C {devices/lab_pin.sym} 54100 -5390 0 0 {name=p53953 lab=_48193_/X }
C {devices/lab_pin.sym} 54180 -5390 0 1 {name=p53954 lab=_49326_/X }
C {sky130_stdcells/buf_2.sym} 54140 -5390 0 0 {name=X_49326_ }
C {devices/lab_pin.sym} 54100 -5270 0 0 {name=p53955 lab=_61476_/A }
C {devices/lab_pin.sym} 54180 -5270 0 1 {name=p53956 lab=_61634_/B }
C {sky130_stdcells/buf_2.sym} 54140 -5270 0 0 {name=X_61604_ }
C {devices/lab_pin.sym} 54100 -5150 0 0 {name=p53957 lab=_68160_/A }
C {devices/lab_pin.sym} 54180 -5150 0 1 {name=p53958 lab=_68160_/X }
C {sky130_stdcells/buf_2.sym} 54140 -5150 0 0 {name=X_68160_ }
C {devices/lab_pin.sym} 54060 -5050 0 0 {name=p53959 lab=_46525_/X }
C {devices/lab_pin.sym} 54060 -5010 0 0 {name=p53960 lab=_49140_/A }
C {devices/lab_pin.sym} 54060 -4970 0 0 {name=p53961 lab=_46537_/X }
C {devices/lab_pin.sym} 54220 -5010 0 1 {name=p53962 lab=_46539_/A }
C {sky130_stdcells/o21ai_4.sym} 54140 -5010 0 0 {name=X_46538_ }
C {devices/lab_pin.sym} 54100 -4870 0 0 {name=p53963 lab=_84204_/Q }
C {devices/lab_pin.sym} 54180 -4870 0 1 {name=p53964 lab=_65373_/C }
C {sky130_stdcells/inv_2.sym} 54140 -4870 0 0 {name=X_65372_ }
C {devices/lab_pin.sym} 54060 -4770 0 0 {name=p53965 lab=_77354_/X }
C {devices/lab_pin.sym} 54060 -4730 0 0 {name=p53966 lab=_77360_/C }
C {devices/lab_pin.sym} 54060 -4690 0 0 {name=p53967 lab=_77359_/A }
C {devices/lab_pin.sym} 54220 -4730 0 1 {name=p53968 lab=_77371_/A }
C {sky130_stdcells/a21boi_4.sym} 54140 -4730 0 0 {name=X_77358_ }
C {devices/lab_pin.sym} 54060 -4610 0 0 {name=p53969 lab=_62582_/Y }
C {devices/lab_pin.sym} 54060 -4570 0 0 {name=p53970 lab=_62540_/X }
C {devices/lab_pin.sym} 54060 -4530 0 0 {name=p53971 lab=_62583_/Y }
C {devices/lab_pin.sym} 54220 -4570 0 1 {name=p53972 lab=_62584_/Y }
C {sky130_stdcells/a21oi_4.sym} 54140 -4570 0 0 {name=X_62584_ }
C {devices/lab_pin.sym} 54080 -4440 0 0 {name=p53973 lab=_67087_/A }
C {devices/lab_pin.sym} 54080 -4400 0 0 {name=p53974 lab=_88125_/Q }
C {devices/lab_pin.sym} 54200 -4420 0 1 {name=p53975 lab=_67111_/X }
C {sky130_stdcells/and2_4.sym} 54140 -4420 0 0 {name=X_67111_ }
C {devices/lab_pin.sym} 54100 -4290 0 0 {name=p53976 lab=_64323_/A }
C {devices/lab_pin.sym} 54180 -4290 0 1 {name=p53977 lab=_64323_/X }
C {sky130_stdcells/buf_2.sym} 54140 -4290 0 0 {name=X_64323_ }
C {devices/lab_pin.sym} 54080 -4180 0 0 {name=p53978 lab=_76288_/Y }
C {devices/lab_pin.sym} 54080 -4140 0 0 {name=p53979 lab=_76309_/B }
C {devices/lab_pin.sym} 54200 -4160 0 1 {name=p53980 lab=_76309_/X }
C {sky130_stdcells/or2_4.sym} 54140 -4160 0 0 {name=X_76309_ }
C {devices/lab_pin.sym} 54100 -4030 0 0 {name=p53981 lab=_61476_/A }
C {devices/lab_pin.sym} 54180 -4030 0 1 {name=p53982 lab=_61546_/B }
C {sky130_stdcells/buf_2.sym} 54140 -4030 0 0 {name=X_61535_ }
C {devices/lab_pin.sym} 54080 -3920 0 0 {name=p53983 lab=_49261_/A }
C {devices/lab_pin.sym} 54080 -3880 0 0 {name=p53984 lab=_50777_/B }
C {devices/lab_pin.sym} 54200 -3900 0 1 {name=p53985 lab=_49257_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -3900 0 0 {name=X_49257_ }
C {devices/lab_pin.sym} 54060 -3800 0 0 {name=p53986 lab=_68088_/X }
C {devices/lab_pin.sym} 54060 -3760 0 0 {name=p53987 lab=_66559_/Y }
C {devices/lab_pin.sym} 54060 -3720 0 0 {name=p53988 lab=_68089_/X }
C {devices/lab_pin.sym} 54060 -3680 0 0 {name=p53989 lab=_68090_/Y }
C {devices/lab_pin.sym} 54220 -3740 0 1 {name=p53990 lab=_68091_/X }
C {sky130_stdcells/a211o_4.sym} 54140 -3740 0 0 {name=X_68091_ }
C {devices/lab_pin.sym} 54080 -3600 0 0 {name=p53991 lab=_48034_/B }
C {devices/lab_pin.sym} 54080 -3560 0 0 {name=p53992 lab=_46469_/B }
C {devices/lab_pin.sym} 54200 -3580 0 1 {name=p53993 lab=_46469_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -3580 0 0 {name=X_46469_ }
C {devices/lab_pin.sym} 54060 -3470 0 0 {name=p53994 lab=_77272_/Y }
C {devices/lab_pin.sym} 54060 -3430 0 0 {name=p53995 lab=_77270_/X }
C {devices/lab_pin.sym} 54060 -3390 0 0 {name=p53996 lab=_77288_/Y }
C {devices/lab_pin.sym} 54220 -3430 0 1 {name=p53997 lab=_77290_/B }
C {sky130_stdcells/a21oi_4.sym} 54140 -3430 0 0 {name=X_77289_ }
C {devices/lab_pin.sym} 54080 -3300 0 0 {name=p53998 lab=_48184_/A }
C {devices/lab_pin.sym} 54080 -3260 0 0 {name=p53999 lab=_48207_/X }
C {devices/lab_pin.sym} 54200 -3280 0 1 {name=p54000 lab=_48208_/Y }
C {sky130_stdcells/nand2_4.sym} 54140 -3280 0 0 {name=X_48208_ }
C {devices/lab_pin.sym} 54060 -3180 0 0 {name=p54001 lab=_87116_/Q }
C {devices/lab_pin.sym} 54060 -3140 0 0 {name=p54002 lab=_66988_/X }
C {devices/lab_pin.sym} 54060 -3100 0 0 {name=p54003 lab=_67040_/X }
C {devices/lab_pin.sym} 54060 -3060 0 0 {name=p54004 lab=_67041_/X }
C {devices/lab_pin.sym} 54220 -3120 0 1 {name=p54005 lab=_67042_/X }
C {sky130_stdcells/a211o_4.sym} 54140 -3120 0 0 {name=X_67042_ }
C {devices/lab_pin.sym} 54080 -2980 0 0 {name=p54006 lab=_82746_/Q }
C {devices/lab_pin.sym} 54080 -2940 0 0 {name=p54007 lab=_79028_/B }
C {devices/lab_pin.sym} 54200 -2960 0 1 {name=p54008 lab=_79028_/X }
C {sky130_stdcells/xor2_4.sym} 54140 -2960 0 0 {name=X_79028_ }
C {devices/lab_pin.sym} 54060 -2850 0 0 {name=p54009 lab=_79846_/B }
C {devices/lab_pin.sym} 54060 -2810 0 0 {name=p54010 lab=_63258_/X }
C {devices/lab_pin.sym} 54060 -2770 0 0 {name=p54011 lab=_64253_/X }
C {devices/lab_pin.sym} 54220 -2810 0 1 {name=p54012 lab=_64254_/X }
C {sky130_stdcells/a21o_4.sym} 54140 -2810 0 0 {name=X_64254_ }
C {devices/lab_pin.sym} 54100 -2670 0 0 {name=p54013 lab=_48934_/A }
C {devices/lab_pin.sym} 54180 -2670 0 1 {name=p54014 lab=_49405_/A }
C {sky130_stdcells/buf_2.sym} 54140 -2670 0 0 {name=X_49188_ }
C {devices/lab_pin.sym} 54100 -2550 0 0 {name=p54015 lab=_72528_/A }
C {devices/lab_pin.sym} 54180 -2550 0 1 {name=p54016 lab=_61468_/B }
C {sky130_stdcells/buf_2.sym} 54140 -2550 0 0 {name=X_61466_ }
C {devices/lab_pin.sym} 54100 -2430 0 0 {name=p54017 lab=clkbuf_9_222_0_CLK/X }
C {devices/lab_pin.sym} 54180 -2430 0 1 {name=p54018 lab=_81224_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 54140 -2430 0 0 {name=Xclkbuf_10_444_0_CLK }
C {devices/lab_pin.sym} 54080 -2340 0 0 {name=p54019 lab=_63203_/X }
C {devices/lab_pin.sym} 54080 -2300 0 0 {name=p54020 lab=_64412_/C }
C {devices/lab_pin.sym} 54080 -2260 0 0 {name=p54021 lab=_63204_/X }
C {devices/lab_pin.sym} 54080 -2220 0 0 {name=p54022 lab=_63239_/D }
C {devices/lab_pin.sym} 54200 -2280 0 1 {name=p54023 lab=_63205_/X }
C {sky130_stdcells/and4_4.sym} 54140 -2280 0 0 {name=X_63205_ }
C {devices/lab_pin.sym} 54060 -2150 0 0 {name=p54024 lab=_48133_/Y }
C {devices/lab_pin.sym} 54060 -2110 0 0 {name=p54025 lab=_48109_/X }
C {devices/lab_pin.sym} 54060 -2070 0 0 {name=p54026 lab=_48138_/X }
C {devices/lab_pin.sym} 54220 -2110 0 1 {name=p54027 lab=_86564_/D }
C {sky130_stdcells/a21oi_4.sym} 54140 -2110 0 0 {name=X_48139_ }
C {devices/lab_pin.sym} 54100 -1970 0 0 {name=p54028 lab=_60417_/A }
C {devices/lab_pin.sym} 54180 -1970 0 1 {name=p54029 lab=_60515_/B }
C {sky130_stdcells/buf_2.sym} 54140 -1970 0 0 {name=X_60417_ }
C {devices/lab_pin.sym} 54060 -1890 0 0 {name=p54030 lab=_64181_/X }
C {devices/lab_pin.sym} 54060 -1850 0 0 {name=p54031 lab=_63741_/X }
C {devices/lab_pin.sym} 54060 -1810 0 0 {name=p54032 lab=_64182_/Y }
C {devices/lab_pin.sym} 54060 -1770 0 0 {name=p54033 lab=_64183_/Y }
C {devices/lab_pin.sym} 54060 -1740 0 0 {name=p54034 lab=_64184_/X }
C {devices/lab_pin.sym} 54220 -1810 0 1 {name=p54035 lab=_64185_/X }
C {sky130_stdcells/a41o_4.sym} 54140 -1810 0 0 {name=X_64185_ }
C {devices/lab_pin.sym} 54100 -1650 0 0 {name=p54036 lab=_72515_/D }
C {devices/lab_pin.sym} 54180 -1650 0 1 {name=p54037 lab=_61398_/C }
C {sky130_stdcells/buf_2.sym} 54140 -1650 0 0 {name=X_61397_ }
C {devices/lab_pin.sym} 54080 -1560 0 0 {name=p54038 lab=_51160_/A }
C {devices/lab_pin.sym} 54080 -1520 0 0 {name=p54039 lab=_51160_/B }
C {devices/lab_pin.sym} 54080 -1480 0 0 {name=p54040 lab=_51141_/X }
C {devices/lab_pin.sym} 54080 -1440 0 0 {name=p54041 lab=_52841_/D }
C {devices/lab_pin.sym} 54200 -1500 0 1 {name=p54042 lab=_51150_/X }
C {sky130_stdcells/and4_4.sym} 54140 -1500 0 0 {name=X_51150_ }
C {devices/lab_pin.sym} 54100 -1350 0 0 {name=p54043 lab=_63342_/C }
C {devices/lab_pin.sym} 54180 -1350 0 1 {name=p54044 lab=_63147_/C }
C {sky130_stdcells/buf_2.sym} 54140 -1350 0 0 {name=X_63136_ }
C {devices/lab_pin.sym} 54100 -1230 0 0 {name=p54045 lab=_65680_/A }
C {devices/lab_pin.sym} 54180 -1230 0 1 {name=p54046 lab=_64939_/A }
C {sky130_stdcells/buf_2.sym} 54140 -1230 0 0 {name=X_60348_ }
C {devices/lab_pin.sym} 54100 -1110 0 0 {name=p54047 lab=_68993_/A }
C {devices/lab_pin.sym} 54180 -1110 0 1 {name=p54048 lab=_68993_/X }
C {sky130_stdcells/buf_2.sym} 54140 -1110 0 0 {name=X_68993_ }
C {devices/lab_pin.sym} 54080 -1010 0 0 {name=p54049 lab=_48979_/A }
C {devices/lab_pin.sym} 54080 -970 0 0 {name=p54050 lab=_50082_/B }
C {devices/lab_pin.sym} 54080 -930 0 0 {name=p54051 lab=_50059_/C }
C {devices/lab_pin.sym} 54200 -970 0 1 {name=p54052 lab=_50101_/X }
C {sky130_stdcells/and3_4.sym} 54140 -970 0 0 {name=X_50101_ }
C {devices/lab_pin.sym} 54060 -850 0 0 {name=p54053 lab=_86077_/Q }
C {devices/lab_pin.sym} 54060 -810 0 0 {name=p54054 lab=_51073_/X }
C {devices/lab_pin.sym} 54060 -770 0 0 {name=p54055 lab=_51080_/Y }
C {devices/lab_pin.sym} 54220 -810 0 1 {name=p54056 lab=_51081_/Y }
C {sky130_stdcells/o21ai_4.sym} 54140 -810 0 0 {name=X_51081_ }
C {devices/lab_pin.sym} 54060 -700 0 0 {name=p54057 lab=_86950_/Q }
C {devices/lab_pin.sym} 54060 -660 0 0 {name=p54058 lab=_67942_/X }
C {devices/lab_pin.sym} 54060 -620 0 0 {name=p54059 lab=_67872_/X }
C {devices/lab_pin.sym} 54060 -580 0 0 {name=p54060 lab=_67943_/X }
C {devices/lab_pin.sym} 54220 -640 0 1 {name=p54061 lab=_67944_/X }
C {sky130_stdcells/a211o_4.sym} 54140 -640 0 0 {name=X_67944_ }
C {devices/lab_pin.sym} 55020 -42150 0 0 {name=p54062 lab=_63020_/A }
C {devices/lab_pin.sym} 55100 -42150 0 1 {name=p54063 lab=_63067_/X }
C {sky130_stdcells/buf_2.sym} 55060 -42150 0 0 {name=X_63067_ }
C {devices/lab_pin.sym} 54980 -42070 0 0 {name=p54064 lab=_60249_/X }
C {devices/lab_pin.sym} 54980 -42030 0 0 {name=p54065 lab=_60276_/Y }
C {devices/lab_pin.sym} 54980 -41990 0 0 {name=p54066 lab=_60299_/A }
C {devices/lab_pin.sym} 54980 -41950 0 0 {name=p54067 lab=_60277_/X }
C {devices/lab_pin.sym} 54980 -41920 0 0 {name=p54068 lab=_60278_/Y }
C {devices/lab_pin.sym} 55140 -41990 0 1 {name=p54069 lab=_60279_/Y }
C {sky130_stdcells/a41oi_4.sym} 55060 -41990 0 0 {name=X_60279_ }
C {devices/lab_pin.sym} 54970 -41830 0 0 {name=p54070 lab=_84003_/CLK }
C {devices/lab_pin.sym} 54970 -41810 0 0 {name=p54071 lab=_83990_/D }
C {devices/lab_pin.sym} 55150 -41830 0 1 {name=p54072 lab=_82638_/D }
C {sky130_stdcells/dfxtp_4.sym} 55060 -41820 0 0 {name=X_83990_ }
C {devices/lab_pin.sym} 55020 -41690 0 0 {name=p54073 lab=clkbuf_9_229_0_CLK/X }
C {devices/lab_pin.sym} 55100 -41690 0 1 {name=p54074 lab=_86611_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55060 -41690 0 0 {name=Xclkbuf_10_459_0_CLK }
C {devices/lab_pin.sym} 54980 -41590 0 0 {name=p54075 lab=_50028_/Y }
C {devices/lab_pin.sym} 54980 -41550 0 0 {name=p54076 lab=_50029_/X }
C {devices/lab_pin.sym} 54980 -41510 0 0 {name=p54077 lab=_50031_/X }
C {devices/lab_pin.sym} 55140 -41550 0 1 {name=p54078 lab=_86278_/D }
C {sky130_stdcells/a21oi_4.sym} 55060 -41550 0 0 {name=X_50032_ }
C {devices/lab_pin.sym} 54980 -41430 0 0 {name=p54079 lab=_62016_/Y }
C {devices/lab_pin.sym} 54980 -41390 0 0 {name=p54080 lab=_61959_/X }
C {devices/lab_pin.sym} 54980 -41350 0 0 {name=p54081 lab=_62017_/Y }
C {devices/lab_pin.sym} 55140 -41390 0 1 {name=p54082 lab=_62018_/Y }
C {sky130_stdcells/a21oi_4.sym} 55060 -41390 0 0 {name=X_62018_ }
C {devices/lab_pin.sym} 54970 -41250 0 0 {name=p54083 lab=_82369_/CLK }
C {devices/lab_pin.sym} 54970 -41230 0 0 {name=p54084 lab=_78096_/Y }
C {devices/lab_pin.sym} 55150 -41250 0 1 {name=p54085 lab=_82941_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -41240 0 0 {name=X_82941_ }
C {devices/lab_pin.sym} 55020 -41110 0 0 {name=p54086 lab=_68129_/A }
C {devices/lab_pin.sym} 55100 -41110 0 1 {name=p54087 lab=_67875_/X }
C {sky130_stdcells/buf_2.sym} 55060 -41110 0 0 {name=X_67875_ }
C {devices/lab_pin.sym} 54980 -41010 0 0 {name=p54088 lab=_69610_/X }
C {devices/lab_pin.sym} 54980 -40970 0 0 {name=p54089 lab=_69613_/X }
C {devices/lab_pin.sym} 54980 -40930 0 0 {name=p54090 lab=_69389_/X }
C {devices/lab_pin.sym} 55140 -40970 0 1 {name=p54091 lab=_69614_/Y }
C {sky130_stdcells/a21oi_4.sym} 55060 -40970 0 0 {name=X_69614_ }
C {devices/lab_pin.sym} 55020 -40830 0 0 {name=p54092 lab=_54758_/A }
C {devices/lab_pin.sym} 55100 -40830 0 1 {name=p54093 lab=_54850_/A }
C {sky130_stdcells/buf_2.sym} 55060 -40830 0 0 {name=X_54840_ }
C {devices/lab_pin.sym} 54980 -40740 0 0 {name=p54094 lab=_66499_/B }
C {devices/lab_pin.sym} 54980 -40700 0 0 {name=p54095 lab=_66815_/Y }
C {devices/lab_pin.sym} 54980 -40660 0 0 {name=p54096 lab=_66793_/X }
C {devices/lab_pin.sym} 54980 -40620 0 0 {name=p54097 lab=_66825_/Y }
C {devices/lab_pin.sym} 55140 -40680 0 1 {name=p54098 lab=_66826_/X }
C {sky130_stdcells/a211o_4.sym} 55060 -40680 0 0 {name=X_66826_ }
C {devices/lab_pin.sym} 54970 -40530 0 0 {name=p54099 lab=_85436_/CLK }
C {devices/lab_pin.sym} 54970 -40510 0 0 {name=p54100 lab=_53294_/Y }
C {devices/lab_pin.sym} 55150 -40530 0 1 {name=p54101 lab=_85660_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -40520 0 0 {name=X_85660_ }
C {devices/lab_pin.sym} 54970 -40390 0 0 {name=p54102 lab=_82675_/CLK }
C {devices/lab_pin.sym} 54970 -40370 0 0 {name=p54103 lab=_82496_/Q }
C {devices/lab_pin.sym} 55150 -40390 0 1 {name=p54104 lab=_82872_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -40380 0 0 {name=X_82872_ }
C {devices/lab_pin.sym} 54970 -40250 0 0 {name=p54105 lab=_84469_/CLK }
C {devices/lab_pin.sym} 54970 -40230 0 0 {name=p54106 lab=_60492_/Y }
C {devices/lab_pin.sym} 55150 -40250 0 1 {name=p54107 lab=_79151_/A }
C {sky130_stdcells/dfxtp_4.sym} 55060 -40240 0 0 {name=X_84611_ }
C {devices/lab_pin.sym} 54970 -40110 0 0 {name=p54108 lab=_81660_/CLK }
C {devices/lab_pin.sym} 54970 -40090 0 0 {name=p54109 lab=_81631_/Q }
C {devices/lab_pin.sym} 55150 -40110 0 1 {name=p54110 lab=_81823_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -40100 0 0 {name=X_81823_ }
C {devices/lab_pin.sym} 54980 -40000 0 0 {name=p54111 lab=_87509_/Q }
C {devices/lab_pin.sym} 54980 -39960 0 0 {name=p54112 lab=_69468_/X }
C {devices/lab_pin.sym} 54980 -39920 0 0 {name=p54113 lab=_59036_/A }
C {devices/lab_pin.sym} 54980 -39880 0 0 {name=p54114 lab=_69544_/X }
C {devices/lab_pin.sym} 55140 -39940 0 1 {name=p54115 lab=_69545_/X }
C {sky130_stdcells/a211o_4.sym} 55060 -39940 0 0 {name=X_69545_ }
C {devices/lab_pin.sym} 54980 -39810 0 0 {name=p54116 lab=_54769_/Y }
C {devices/lab_pin.sym} 54980 -39770 0 0 {name=p54117 lab=_54747_/X }
C {devices/lab_pin.sym} 54980 -39730 0 0 {name=p54118 lab=_54770_/X }
C {devices/lab_pin.sym} 55140 -39770 0 1 {name=p54119 lab=_54771_/Y }
C {sky130_stdcells/a21oi_4.sym} 55060 -39770 0 0 {name=X_54771_ }
C {devices/lab_pin.sym} 55020 -39630 0 0 {name=p54120 lab=_60371_/A }
C {devices/lab_pin.sym} 55100 -39630 0 1 {name=p54121 lab=_66757_/X }
C {sky130_stdcells/buf_2.sym} 55060 -39630 0 0 {name=X_66757_ }
C {devices/lab_pin.sym} 54970 -39510 0 0 {name=p54122 lab=_83068_/CLK }
C {devices/lab_pin.sym} 54970 -39490 0 0 {name=p54123 lab=_85591_/D }
C {devices/lab_pin.sym} 55150 -39510 0 1 {name=p54124 lab=_85591_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -39500 0 0 {name=X_85591_ }
C {devices/lab_pin.sym} 55000 -39380 0 0 {name=p54125 lab=_51982_/X }
C {devices/lab_pin.sym} 55000 -39340 0 0 {name=p54126 lab=_53504_/B }
C {devices/lab_pin.sym} 55120 -39360 0 1 {name=p54127 lab=_51983_/Y }
C {sky130_stdcells/nand2_4.sym} 55060 -39360 0 0 {name=X_51983_ }
C {devices/lab_pin.sym} 55020 -39230 0 0 {name=p54128 lab=_63741_/A }
C {devices/lab_pin.sym} 55100 -39230 0 1 {name=p54129 lab=_63969_/X }
C {sky130_stdcells/buf_2.sym} 55060 -39230 0 0 {name=X_63969_ }
C {devices/lab_pin.sym} 55000 -39130 0 0 {name=p54130 lab=_56510_/A }
C {devices/lab_pin.sym} 55000 -39090 0 0 {name=p54131 lab=_56520_/B }
C {devices/lab_pin.sym} 55000 -39050 0 0 {name=p54132 lab=_56510_/C }
C {devices/lab_pin.sym} 55120 -39090 0 1 {name=p54133 lab=_56510_/Y }
C {sky130_stdcells/nand3_4.sym} 55060 -39090 0 0 {name=X_56510_ }
C {devices/lab_pin.sym} 54970 -38950 0 0 {name=p54134 lab=_87333_/CLK }
C {devices/lab_pin.sym} 54970 -38930 0 0 {name=p54135 lab=_87330_/D }
C {devices/lab_pin.sym} 55150 -38950 0 1 {name=p54136 lab=_87330_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -38940 0 0 {name=X_87330_ }
C {devices/lab_pin.sym} 55020 -38810 0 0 {name=p54137 lab=_53846_/A }
C {devices/lab_pin.sym} 55100 -38810 0 1 {name=p54138 lab=_53722_/X }
C {sky130_stdcells/buf_2.sym} 55060 -38810 0 0 {name=X_53722_ }
C {devices/lab_pin.sym} 55000 -38700 0 0 {name=p54139 lab=_65825_/A }
C {devices/lab_pin.sym} 55000 -38660 0 0 {name=p54140 lab=_86511_/Q }
C {devices/lab_pin.sym} 55120 -38680 0 1 {name=p54141 lab=_65708_/X }
C {sky130_stdcells/and2_4.sym} 55060 -38680 0 0 {name=X_65708_ }
C {devices/lab_pin.sym} 54970 -38550 0 0 {name=p54142 lab=_84549_/CLK }
C {devices/lab_pin.sym} 54970 -38530 0 0 {name=p54143 lab=_84542_/D }
C {devices/lab_pin.sym} 55150 -38550 0 1 {name=p54144 lab=_76990_/A }
C {sky130_stdcells/dfxtp_4.sym} 55060 -38540 0 0 {name=X_84542_ }
C {devices/lab_pin.sym} 55000 -38440 0 0 {name=p54145 lab=_50941_/A }
C {devices/lab_pin.sym} 55000 -38400 0 0 {name=p54146 lab=_50941_/B }
C {devices/lab_pin.sym} 55000 -38360 0 0 {name=p54147 lab=_50948_/C }
C {devices/lab_pin.sym} 55000 -38320 0 0 {name=p54148 lab=_46707_/X }
C {devices/lab_pin.sym} 55120 -38380 0 1 {name=p54149 lab=_50934_/X }
C {sky130_stdcells/and4_4.sym} 55060 -38380 0 0 {name=X_50934_ }
C {devices/lab_pin.sym} 54980 -38250 0 0 {name=p54150 lab=_84993_/Q }
C {devices/lab_pin.sym} 54980 -38210 0 0 {name=p54151 lab=_47806_/X }
C {devices/lab_pin.sym} 54980 -38170 0 0 {name=p54152 lab=_57489_/Y }
C {devices/lab_pin.sym} 55140 -38210 0 1 {name=p54153 lab=_57490_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -38210 0 0 {name=X_57490_ }
C {devices/lab_pin.sym} 54970 -38070 0 0 {name=p54154 lab=_81783_/CLK }
C {devices/lab_pin.sym} 54970 -38050 0 0 {name=p54155 lab=_76100_/B }
C {devices/lab_pin.sym} 55150 -38070 0 1 {name=p54156 lab=_81754_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -38060 0 0 {name=X_81754_ }
C {devices/lab_pin.sym} 54980 -37960 0 0 {name=p54157 lab=_69423_/X }
C {devices/lab_pin.sym} 54980 -37920 0 0 {name=p54158 lab=_69340_/X }
C {devices/lab_pin.sym} 54980 -37880 0 0 {name=p54159 lab=_69474_/Y }
C {devices/lab_pin.sym} 54980 -37840 0 0 {name=p54160 lab=_69475_/Y }
C {devices/lab_pin.sym} 55140 -37900 0 1 {name=p54161 lab=_69476_/X }
C {sky130_stdcells/a211o_4.sym} 55060 -37900 0 0 {name=X_69476_ }
C {devices/lab_pin.sym} 55020 -37750 0 0 {name=p54162 lab=_69245_/A }
C {devices/lab_pin.sym} 55100 -37750 0 1 {name=p54163 lab=_66688_/X }
C {sky130_stdcells/buf_2.sym} 55060 -37750 0 0 {name=X_66688_ }
C {devices/lab_pin.sym} 55020 -37630 0 0 {name=p54164 lab=clkbuf_9_502_0_CLK/A }
C {devices/lab_pin.sym} 55100 -37630 0 1 {name=p54165 lab=clkbuf_9_503_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 55060 -37630 0 0 {name=Xclkbuf_9_503_0_CLK }
C {devices/lab_pin.sym} 54980 -37530 0 0 {name=p54166 lab=_56139_/X }
C {devices/lab_pin.sym} 54980 -37490 0 0 {name=p54167 lab=_56439_/X }
C {devices/lab_pin.sym} 54980 -37450 0 0 {name=p54168 lab=_56440_/Y }
C {devices/lab_pin.sym} 55140 -37490 0 1 {name=p54169 lab=_56441_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -37490 0 0 {name=X_56441_ }
C {devices/lab_pin.sym} 54970 -37350 0 0 {name=p54170 lab=_80681_/CLK }
C {devices/lab_pin.sym} 54970 -37330 0 0 {name=p54171 lab=_80737_/Q }
C {devices/lab_pin.sym} 55150 -37350 0 1 {name=p54172 lab=_75558_/A }
C {sky130_stdcells/dfxtp_4.sym} 55060 -37340 0 0 {name=X_80705_ }
C {devices/lab_pin.sym} 55000 -37220 0 0 {name=p54173 lab=_68405_/A }
C {devices/lab_pin.sym} 55000 -37180 0 0 {name=p54174 lab=_68427_/B }
C {devices/lab_pin.sym} 55120 -37200 0 1 {name=p54175 lab=_68427_/X }
C {sky130_stdcells/and2_4.sym} 55060 -37200 0 0 {name=X_68427_ }
C {devices/lab_pin.sym} 54970 -37070 0 0 {name=p54176 lab=_88034_/CLK }
C {devices/lab_pin.sym} 54970 -37050 0 0 {name=p54177 lab=_43800_/X }
C {devices/lab_pin.sym} 55150 -37070 0 1 {name=p54178 lab=_69443_/B }
C {sky130_stdcells/dfxtp_4.sym} 55060 -37060 0 0 {name=X_87261_ }
C {devices/lab_pin.sym} 55020 -36930 0 0 {name=p54179 lab=_53747_/A }
C {devices/lab_pin.sym} 55100 -36930 0 1 {name=p54180 lab=_53653_/X }
C {sky130_stdcells/buf_2.sym} 55060 -36930 0 0 {name=X_53653_ }
C {devices/lab_pin.sym} 55020 -36810 0 0 {name=p54181 lab=_65877_/A }
C {devices/lab_pin.sym} 55100 -36810 0 1 {name=p54182 lab=_65704_/A }
C {sky130_stdcells/buf_2.sym} 55060 -36810 0 0 {name=X_65639_ }
C {devices/lab_pin.sym} 54970 -36690 0 0 {name=p54183 lab=_82452_/CLK }
C {devices/lab_pin.sym} 54970 -36670 0 0 {name=p54184 lab=_61537_/Y }
C {devices/lab_pin.sym} 55150 -36690 0 1 {name=p54185 lab=_79141_/B }
C {sky130_stdcells/dfxtp_4.sym} 55060 -36680 0 0 {name=X_84473_ }
C {devices/lab_pin.sym} 54980 -36570 0 0 {name=p54186 lab=_50863_/Y }
C {devices/lab_pin.sym} 54980 -36530 0 0 {name=p54187 lab=_50849_/X }
C {devices/lab_pin.sym} 54980 -36490 0 0 {name=p54188 lab=_50864_/Y }
C {devices/lab_pin.sym} 55140 -36530 0 1 {name=p54189 lab=_86118_/D }
C {sky130_stdcells/a21boi_4.sym} 55060 -36530 0 0 {name=X_50865_ }
C {devices/lab_pin.sym} 54970 -36390 0 0 {name=p54190 lab=_81684_/CLK }
C {devices/lab_pin.sym} 54970 -36370 0 0 {name=p54191 lab=_81685_/D }
C {devices/lab_pin.sym} 55150 -36390 0 1 {name=p54192 lab=_81685_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -36380 0 0 {name=X_81685_ }
C {devices/lab_pin.sym} 54970 -36250 0 0 {name=p54193 lab=_86490_/CLK }
C {devices/lab_pin.sym} 54970 -36230 0 0 {name=p54194 lab=_50382_/Y }
C {devices/lab_pin.sym} 55150 -36250 0 1 {name=p54195 lab=_86212_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -36240 0 0 {name=X_86212_ }
C {devices/lab_pin.sym} 54980 -36130 0 0 {name=p54196 lab=_85788_/Q }
C {devices/lab_pin.sym} 54980 -36090 0 0 {name=p54197 lab=_52601_/X }
C {devices/lab_pin.sym} 54980 -36050 0 0 {name=p54198 lab=_52603_/Y }
C {devices/lab_pin.sym} 55140 -36090 0 1 {name=p54199 lab=_52604_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -36090 0 0 {name=X_52604_ }
C {devices/lab_pin.sym} 55020 -35950 0 0 {name=p54200 lab=_58641_/A }
C {devices/lab_pin.sym} 55100 -35950 0 1 {name=p54201 lab=_59160_/X }
C {sky130_stdcells/buf_2.sym} 55060 -35950 0 0 {name=X_59160_ }
C {devices/lab_pin.sym} 54970 -35830 0 0 {name=p54202 lab=_83756_/CLK }
C {devices/lab_pin.sym} 54970 -35810 0 0 {name=p54203 lab=_71653_/Y }
C {devices/lab_pin.sym} 55150 -35830 0 1 {name=p54204 lab=_83424_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -35820 0 0 {name=X_83424_ }
C {devices/lab_pin.sym} 55020 -35690 0 0 {name=p54205 lab=_56439_/A }
C {devices/lab_pin.sym} 55100 -35690 0 1 {name=p54206 lab=_56372_/X }
C {sky130_stdcells/buf_2.sym} 55060 -35690 0 0 {name=X_56372_ }
C {devices/lab_pin.sym} 55000 -35580 0 0 {name=p54207 lab=_80636_/A }
C {devices/lab_pin.sym} 55000 -35540 0 0 {name=p54208 lab=_80635_/Y }
C {devices/lab_pin.sym} 55120 -35560 0 1 {name=p54209 lab=_80636_/Y }
C {sky130_stdcells/xnor2_4.sym} 55060 -35560 0 0 {name=X_80636_ }
C {devices/lab_pin.sym} 55020 -35430 0 0 {name=p54210 lab=_68823_/A }
C {devices/lab_pin.sym} 55100 -35430 0 1 {name=p54211 lab=_68358_/X }
C {sky130_stdcells/buf_2.sym} 55060 -35430 0 0 {name=X_68358_ }
C {devices/lab_pin.sym} 54970 -35310 0 0 {name=p54212 lab=_87189_/CLK }
C {devices/lab_pin.sym} 54970 -35290 0 0 {name=p54213 lab=_87192_/D }
C {devices/lab_pin.sym} 55150 -35310 0 1 {name=p54214 lab=_67975_/B }
C {sky130_stdcells/dfxtp_4.sym} 55060 -35300 0 0 {name=X_87192_ }
C {devices/lab_pin.sym} 54980 -35190 0 0 {name=p54215 lab=_53582_/Y }
C {devices/lab_pin.sym} 54980 -35150 0 0 {name=p54216 lab=_53537_/X }
C {devices/lab_pin.sym} 54980 -35110 0 0 {name=p54217 lab=_53583_/X }
C {devices/lab_pin.sym} 55140 -35150 0 1 {name=p54218 lab=_85608_/D }
C {sky130_stdcells/a21oi_4.sym} 55060 -35150 0 0 {name=X_53584_ }
C {devices/lab_pin.sym} 54980 -35030 0 0 {name=p54219 lab=_86131_/Q }
C {devices/lab_pin.sym} 54980 -34990 0 0 {name=p54220 lab=_50775_/X }
C {devices/lab_pin.sym} 54980 -34950 0 0 {name=p54221 lab=_50795_/Y }
C {devices/lab_pin.sym} 55140 -34990 0 1 {name=p54222 lab=_50796_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -34990 0 0 {name=X_50796_ }
C {sky130_stdcells/decap_3.sym} 55060 -34820 0 0 {name=XPHY_104 }
C {devices/lab_pin.sym} 54980 -34690 0 0 {name=p54223 lab=_57983_/X }
C {devices/lab_pin.sym} 54980 -34650 0 0 {name=p54224 lab=_85380_/Q }
C {devices/lab_pin.sym} 54980 -34610 0 0 {name=p54225 lab=_58110_/X }
C {devices/lab_pin.sym} 55140 -34650 0 1 {name=p54226 lab=_58111_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -34650 0 0 {name=X_58111_ }
C {sky130_stdcells/decap_3.sym} 55060 -34480 0 0 {name=XPHY_115 }
C {devices/lab_pin.sym} 55000 -34340 0 0 {name=p54227 lab=_55323_/A }
C {devices/lab_pin.sym} 55000 -34300 0 0 {name=p54228 lab=_85134_/Q }
C {devices/lab_pin.sym} 55120 -34320 0 1 {name=p54229 lab=_55323_/X }
C {sky130_stdcells/and2_4.sym} 55060 -34320 0 0 {name=X_55323_ }
C {devices/lab_pin.sym} 54980 -34220 0 0 {name=p54230 lab=_87348_/Q }
C {devices/lab_pin.sym} 54980 -34180 0 0 {name=p54231 lab=_67239_/X }
C {devices/lab_pin.sym} 54980 -34140 0 0 {name=p54232 lab=_67240_/X }
C {devices/lab_pin.sym} 54980 -34100 0 0 {name=p54233 lab=_67308_/X }
C {devices/lab_pin.sym} 55140 -34160 0 1 {name=p54234 lab=_67309_/X }
C {sky130_stdcells/a211o_4.sym} 55060 -34160 0 0 {name=X_67309_ }
C {devices/lab_pin.sym} 54970 -34010 0 0 {name=p54235 lab=_85536_/CLK }
C {devices/lab_pin.sym} 54970 -33990 0 0 {name=p54236 lab=_86143_/D }
C {devices/lab_pin.sym} 55150 -34010 0 1 {name=p54237 lab=_86143_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -34000 0 0 {name=X_86143_ }
C {sky130_stdcells/decap_3.sym} 55060 -33840 0 0 {name=XPHY_126 }
C {devices/lab_pin.sym} 55000 -33700 0 0 {name=p54238 lab=_52501_/X }
C {devices/lab_pin.sym} 55000 -33660 0 0 {name=p54239 lab=_54054_/B }
C {devices/lab_pin.sym} 55120 -33680 0 1 {name=p54240 lab=_52535_/Y }
C {sky130_stdcells/nand2_4.sym} 55060 -33680 0 0 {name=X_52535_ }
C {devices/lab_pin.sym} 54980 -33590 0 0 {name=p54241 lab=_58864_/X }
C {devices/lab_pin.sym} 54980 -33550 0 0 {name=p54242 lab=_59089_/Y }
C {devices/lab_pin.sym} 54980 -33510 0 0 {name=p54243 lab=_59090_/Y }
C {devices/lab_pin.sym} 54980 -33470 0 0 {name=p54244 lab=_58943_/X }
C {devices/lab_pin.sym} 54980 -33430 0 0 {name=p54245 lab=_58868_/X }
C {devices/lab_pin.sym} 55140 -33510 0 1 {name=p54246 lab=_59091_/X }
C {sky130_stdcells/o32a_4.sym} 55060 -33510 0 0 {name=X_59091_ }
C {devices/lab_pin.sym} 54970 -33350 0 0 {name=p54247 lab=_83761_/CLK }
C {devices/lab_pin.sym} 54970 -33330 0 0 {name=p54248 lab=_83355_/D }
C {devices/lab_pin.sym} 55150 -33350 0 1 {name=p54249 lab=_83355_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -33340 0 0 {name=X_83355_ }
C {sky130_stdcells/decap_3.sym} 55060 -33180 0 0 {name=XPHY_137 }
C {devices/lab_pin.sym} 55000 -33040 0 0 {name=p54250 lab=_84772_/Q }
C {devices/lab_pin.sym} 55000 -33000 0 0 {name=p54251 lab=_84164_/Q }
C {devices/lab_pin.sym} 55120 -33020 0 1 {name=p54252 lab=_80567_/X }
C {sky130_stdcells/xor2_4.sym} 55060 -33020 0 0 {name=X_80567_ }
C {devices/lab_pin.sym} 54980 -32920 0 0 {name=p54253 lab=_68272_/X }
C {devices/lab_pin.sym} 54980 -32880 0 0 {name=p54254 lab=_67769_/Y }
C {devices/lab_pin.sym} 54980 -32840 0 0 {name=p54255 lab=_68287_/X }
C {devices/lab_pin.sym} 54980 -32800 0 0 {name=p54256 lab=_68288_/Y }
C {devices/lab_pin.sym} 55140 -32860 0 1 {name=p54257 lab=_68289_/X }
C {sky130_stdcells/a211o_4.sym} 55060 -32860 0 0 {name=X_68289_ }
C {sky130_stdcells/decap_3.sym} 55060 -32680 0 0 {name=XPHY_148 }
C {sky130_stdcells/decap_3.sym} 55060 -32500 0 0 {name=XPHY_159 }
C {devices/lab_pin.sym} 54980 -32370 0 0 {name=p54258 lab=_58017_/X }
C {devices/lab_pin.sym} 54980 -32330 0 0 {name=p54259 lab=_85386_/Q }
C {devices/lab_pin.sym} 54980 -32290 0 0 {name=p54260 lab=_58041_/X }
C {devices/lab_pin.sym} 55140 -32330 0 1 {name=p54261 lab=_58042_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -32330 0 0 {name=X_58042_ }
C {devices/lab_pin.sym} 55020 -32190 0 0 {name=p54262 lab=_70337_/A }
C {devices/lab_pin.sym} 55100 -32190 0 1 {name=p54263 lab=_70320_/X }
C {sky130_stdcells/buf_2.sym} 55060 -32190 0 0 {name=X_70320_ }
C {devices/lab_pin.sym} 54970 -32070 0 0 {name=p54264 lab=_80835_/CLK }
C {devices/lab_pin.sym} 54970 -32050 0 0 {name=p54265 lab=_77002_/X }
C {devices/lab_pin.sym} 55150 -32070 0 1 {name=p54266 lab=_40546_/A }
C {sky130_stdcells/dfxtp_4.sym} 55060 -32060 0 0 {name=X_82306_ }
C {devices/lab_pin.sym} 55000 -31950 0 0 {name=p54267 lab=_55254_/A }
C {devices/lab_pin.sym} 55000 -31910 0 0 {name=p54268 lab=_83320_/Q }
C {devices/lab_pin.sym} 55000 -31870 0 0 {name=p54269 lab=_55253_/X }
C {devices/lab_pin.sym} 55120 -31910 0 1 {name=p54270 lab=_55290_/A }
C {sky130_stdcells/nand3_4.sym} 55060 -31910 0 0 {name=X_55254_ }
C {devices/lab_pin.sym} 54970 -31770 0 0 {name=p54271 lab=_85754_/CLK }
C {devices/lab_pin.sym} 54970 -31750 0 0 {name=p54272 lab=_86074_/D }
C {devices/lab_pin.sym} 55150 -31770 0 1 {name=p54273 lab=_86074_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -31760 0 0 {name=X_86074_ }
C {devices/lab_pin.sym} 55020 -31630 0 0 {name=p54274 lab=_40479_/X }
C {devices/lab_pin.sym} 55100 -31630 0 1 {name=p54275 lab=_40480_/X }
C {sky130_stdcells/buf_2.sym} 55060 -31630 0 0 {name=X_40480_ }
C {devices/lab_pin.sym} 55000 -31520 0 0 {name=p54276 lab=_52466_/A }
C {devices/lab_pin.sym} 55000 -31480 0 0 {name=p54277 lab=_53985_/B }
C {devices/lab_pin.sym} 55120 -31500 0 1 {name=p54278 lab=_52466_/Y }
C {sky130_stdcells/nand2_4.sym} 55060 -31500 0 0 {name=X_52466_ }
C {devices/lab_pin.sym} 54970 -31370 0 0 {name=p54279 lab=_85542_/CLK }
C {devices/lab_pin.sym} 54970 -31350 0 0 {name=p54280 lab=_83286_/D }
C {devices/lab_pin.sym} 55150 -31370 0 1 {name=p54281 lab=_83286_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -31360 0 0 {name=X_83286_ }
C {devices/lab_pin.sym} 55000 -31240 0 0 {name=p54282 lab=_80496_/X }
C {devices/lab_pin.sym} 55000 -31200 0 0 {name=p54283 lab=_80498_/B }
C {devices/lab_pin.sym} 55120 -31220 0 1 {name=p54284 lab=_80498_/Y }
C {sky130_stdcells/xnor2_4.sym} 55060 -31220 0 0 {name=X_80498_ }
C {devices/lab_pin.sym} 55020 -31090 0 0 {name=p54285 lab=clkbuf_8_71_0_CLK/A }
C {devices/lab_pin.sym} 55100 -31090 0 1 {name=p54286 lab=clkbuf_8_71_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 55060 -31090 0 0 {name=Xclkbuf_8_71_0_CLK }
C {devices/lab_pin.sym} 55000 -30980 0 0 {name=p54287 lab=_54215_/A }
C {devices/lab_pin.sym} 55000 -30940 0 0 {name=p54288 lab=_47420_/Y }
C {devices/lab_pin.sym} 55120 -30960 0 1 {name=p54289 lab=_54205_/Y }
C {sky130_stdcells/nand2_4.sym} 55060 -30960 0 0 {name=X_54205_ }
C {devices/lab_pin.sym} 54970 -30830 0 0 {name=p54290 lab=_85089_/CLK }
C {devices/lab_pin.sym} 54970 -30810 0 0 {name=p54291 lab=_85025_/D }
C {devices/lab_pin.sym} 55150 -30830 0 1 {name=p54292 lab=_45393_/A }
C {sky130_stdcells/dfxtp_4.sym} 55060 -30820 0 0 {name=X_85025_ }
C {devices/lab_pin.sym} 54980 -30710 0 0 {name=p54293 lab=_51414_/Y }
C {devices/lab_pin.sym} 54980 -30670 0 0 {name=p54294 lab=_51229_/X }
C {devices/lab_pin.sym} 54980 -30630 0 0 {name=p54295 lab=_51416_/X }
C {devices/lab_pin.sym} 55140 -30670 0 1 {name=p54296 lab=_86014_/D }
C {sky130_stdcells/a21oi_4.sym} 55060 -30670 0 0 {name=X_51417_ }
C {devices/lab_pin.sym} 55000 -30560 0 0 {name=p54297 lab=_70260_/A }
C {devices/lab_pin.sym} 55000 -30520 0 0 {name=p54298 lab=_70260_/B }
C {devices/lab_pin.sym} 55000 -30480 0 0 {name=p54299 lab=_70251_/C }
C {devices/lab_pin.sym} 55000 -30440 0 0 {name=p54300 lab=_70260_/D }
C {devices/lab_pin.sym} 55120 -30500 0 1 {name=p54301 lab=_70251_/X }
C {sky130_stdcells/and4_4.sym} 55060 -30500 0 0 {name=X_70251_ }
C {devices/lab_pin.sym} 54970 -30350 0 0 {name=p54302 lab=_82515_/CLK }
C {devices/lab_pin.sym} 54970 -30330 0 0 {name=p54303 lab=_82269_/Q }
C {devices/lab_pin.sym} 55150 -30350 0 1 {name=p54304 lab=_82237_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -30340 0 0 {name=X_82237_ }
C {devices/lab_pin.sym} 55020 -30210 0 0 {name=p54305 lab=clkbuf_7_3_0_CLK/A }
C {devices/lab_pin.sym} 55100 -30210 0 1 {name=p54306 lab=clkbuf_8_7_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 55060 -30210 0 0 {name=Xclkbuf_7_3_0_CLK }
C {devices/lab_pin.sym} 54980 -30120 0 0 {name=p54307 lab=_85037_/Q }
C {devices/lab_pin.sym} 54980 -30080 0 0 {name=p54308 lab=_55145_/A }
C {devices/lab_pin.sym} 54980 -30040 0 0 {name=p54309 lab=_55168_/X }
C {devices/lab_pin.sym} 54980 -30000 0 0 {name=p54310 lab=_55184_/X }
C {devices/lab_pin.sym} 55140 -30060 0 1 {name=p54311 lab=_55185_/X }
C {sky130_stdcells/a211o_4.sym} 55060 -30060 0 0 {name=X_55185_ }
C {devices/lab_pin.sym} 55020 -29910 0 0 {name=p54312 lab=_52324_/A }
C {devices/lab_pin.sym} 55100 -29910 0 1 {name=p54313 lab=_52397_/X }
C {sky130_stdcells/buf_2.sym} 55060 -29910 0 0 {name=X_52397_ }
C {devices/lab_pin.sym} 55020 -29790 0 0 {name=p54314 lab=_42162_/A }
C {devices/lab_pin.sym} 55100 -29790 0 1 {name=p54315 lab=_42150_/X }
C {sky130_stdcells/buf_2.sym} 55060 -29790 0 0 {name=X_42150_ }
C {devices/lab_pin.sym} 55020 -29670 0 0 {name=p54316 lab=_54217_/A }
C {devices/lab_pin.sym} 55100 -29670 0 1 {name=p54317 lab=_54160_/B }
C {sky130_stdcells/buf_2.sym} 55060 -29670 0 0 {name=X_54136_ }
C {devices/lab_pin.sym} 55000 -29570 0 0 {name=p54318 lab=_52528_/A }
C {devices/lab_pin.sym} 55000 -29530 0 0 {name=p54319 lab=_51352_/B }
C {devices/lab_pin.sym} 55000 -29490 0 0 {name=p54320 lab=_51352_/C }
C {devices/lab_pin.sym} 55120 -29530 0 1 {name=p54321 lab=_51348_/X }
C {sky130_stdcells/and3_4.sym} 55060 -29530 0 0 {name=X_51348_ }
C {devices/lab_pin.sym} 54980 -29410 0 0 {name=p54322 lab=_70180_/Y }
C {devices/lab_pin.sym} 54980 -29370 0 0 {name=p54323 lab=_70157_/X }
C {devices/lab_pin.sym} 54980 -29330 0 0 {name=p54324 lab=_70181_/Y }
C {devices/lab_pin.sym} 55140 -29370 0 1 {name=p54325 lab=_70182_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -29370 0 0 {name=X_70182_ }
C {devices/lab_pin.sym} 54970 -29230 0 0 {name=p54326 lab=_84166_/CLK }
C {devices/lab_pin.sym} 54970 -29210 0 0 {name=p54327 lab=_84160_/Q }
C {devices/lab_pin.sym} 55150 -29230 0 1 {name=p54328 lab=_82168_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -29220 0 0 {name=X_82168_ }
C {devices/lab_pin.sym} 54980 -29130 0 0 {name=p54329 lab=_59951_/D }
C {devices/lab_pin.sym} 54980 -29090 0 0 {name=p54330 lab=_60129_/B }
C {devices/lab_pin.sym} 54980 -29050 0 0 {name=p54331 lab=_59974_/Y }
C {devices/lab_pin.sym} 54980 -29010 0 0 {name=p54332 lab=_59981_/Y }
C {devices/lab_pin.sym} 54980 -28980 0 0 {name=p54333 lab=_59992_/Y }
C {devices/lab_pin.sym} 55140 -29050 0 1 {name=p54334 lab=_84677_/D }
C {sky130_stdcells/a41oi_4.sym} 55060 -29050 0 0 {name=X_59993_ }
C {devices/lab_pin.sym} 55020 -28890 0 0 {name=p54335 lab=_40932_/A }
C {devices/lab_pin.sym} 55100 -28890 0 1 {name=p54336 lab=_41102_/B }
C {sky130_stdcells/buf_2.sym} 55060 -28890 0 0 {name=X_41101_ }
C {devices/lab_pin.sym} 54970 -28770 0 0 {name=p54337 lab=_80697_/CLK }
C {devices/lab_pin.sym} 54970 -28750 0 0 {name=p54338 lab=_79868_/X }
C {devices/lab_pin.sym} 55150 -28770 0 1 {name=p54339 lab=_75688_/A }
C {sky130_stdcells/dfxtp_4.sym} 55060 -28760 0 0 {name=X_81119_ }
C {devices/lab_pin.sym} 55020 -28630 0 0 {name=p54340 lab=_42081_/A }
C {devices/lab_pin.sym} 55100 -28630 0 1 {name=p54341 lab=_43161_/A }
C {sky130_stdcells/buf_2.sym} 55060 -28630 0 0 {name=X_42081_ }
C {devices/lab_pin.sym} 54980 -28550 0 0 {name=p54342 lab=_58864_/X }
C {devices/lab_pin.sym} 54980 -28510 0 0 {name=p54343 lab=_58941_/Y }
C {devices/lab_pin.sym} 54980 -28470 0 0 {name=p54344 lab=_58942_/Y }
C {devices/lab_pin.sym} 54980 -28430 0 0 {name=p54345 lab=_58943_/X }
C {devices/lab_pin.sym} 54980 -28390 0 0 {name=p54346 lab=_58868_/X }
C {devices/lab_pin.sym} 55140 -28470 0 1 {name=p54347 lab=_58944_/X }
C {sky130_stdcells/o32a_4.sym} 55060 -28470 0 0 {name=X_58944_ }
C {devices/lab_pin.sym} 55020 -28310 0 0 {name=p54348 lab=_54067_/A }
C {devices/lab_pin.sym} 55100 -28310 0 1 {name=p54349 lab=_54067_/X }
C {sky130_stdcells/buf_2.sym} 55060 -28310 0 0 {name=X_54067_ }
C {devices/lab_pin.sym} 54980 -28210 0 0 {name=p54350 lab=_51277_/Y }
C {devices/lab_pin.sym} 54980 -28170 0 0 {name=p54351 lab=_51263_/X }
C {devices/lab_pin.sym} 54980 -28130 0 0 {name=p54352 lab=_51278_/X }
C {devices/lab_pin.sym} 55140 -28170 0 1 {name=p54353 lab=_51279_/Y }
C {sky130_stdcells/a21oi_4.sym} 55060 -28170 0 0 {name=X_51279_ }
C {devices/lab_pin.sym} 55000 -28040 0 0 {name=p54354 lab=_74990_/A }
C {devices/lab_pin.sym} 55000 -28000 0 0 {name=p54355 lab=_74987_/C }
C {devices/lab_pin.sym} 55120 -28020 0 1 {name=p54356 lab=_74990_/X }
C {sky130_stdcells/and2_4.sym} 55060 -28020 0 0 {name=X_74990_ }
C {devices/lab_pin.sym} 54970 -27890 0 0 {name=p54357 lab=_87333_/CLK }
C {devices/lab_pin.sym} 54970 -27870 0 0 {name=p54358 lab=_86976_/D }
C {devices/lab_pin.sym} 55150 -27890 0 1 {name=p54359 lab=_86976_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -27880 0 0 {name=X_86976_ }
C {devices/lab_pin.sym} 54970 -27750 0 0 {name=p54360 lab=_82349_/CLK }
C {devices/lab_pin.sym} 54970 -27730 0 0 {name=p54361 lab=_77471_/B }
C {devices/lab_pin.sym} 55150 -27750 0 1 {name=p54362 lab=_82099_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -27740 0 0 {name=X_82099_ }
C {devices/lab_pin.sym} 55020 -27610 0 0 {name=p54363 lab=clkbuf_8_87_0_CLK/A }
C {devices/lab_pin.sym} 55100 -27610 0 1 {name=p54364 lab=clkbuf_8_86_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 55060 -27610 0 0 {name=Xclkbuf_8_86_0_CLK }
C {devices/lab_pin.sym} 54980 -27510 0 0 {name=p54365 lab=_85712_/Q }
C {devices/lab_pin.sym} 54980 -27470 0 0 {name=p54366 lab=_53010_/X }
C {devices/lab_pin.sym} 54980 -27430 0 0 {name=p54367 lab=_53017_/Y }
C {devices/lab_pin.sym} 55140 -27470 0 1 {name=p54368 lab=_53018_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -27470 0 0 {name=X_53018_ }
C {devices/lab_pin.sym} 55020 -27330 0 0 {name=p54369 lab=_41032_/A }
C {devices/lab_pin.sym} 55100 -27330 0 1 {name=p54370 lab=_41032_/X }
C {sky130_stdcells/buf_2.sym} 55060 -27330 0 0 {name=X_41032_ }
C {devices/lab_pin.sym} 54980 -27240 0 0 {name=p54371 lab=_41941_/Y }
C {devices/lab_pin.sym} 54980 -27200 0 0 {name=p54372 lab=_56182_/X }
C {devices/lab_pin.sym} 54980 -27160 0 0 {name=p54373 lab=_73819_/X }
C {devices/lab_pin.sym} 54980 -27120 0 0 {name=p54374 lab=_73940_/Y }
C {devices/lab_pin.sym} 55140 -27180 0 1 {name=p54375 lab=_73941_/X }
C {sky130_stdcells/a211o_4.sym} 55060 -27180 0 0 {name=X_73941_ }
C {devices/lab_pin.sym} 54970 -27030 0 0 {name=p54376 lab=_85447_/CLK }
C {devices/lab_pin.sym} 54970 -27010 0 0 {name=p54377 lab=_85927_/D }
C {devices/lab_pin.sym} 55150 -27030 0 1 {name=p54378 lab=_85927_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -27020 0 0 {name=X_85927_ }
C {devices/lab_pin.sym} 54980 -26930 0 0 {name=p54379 lab=_58828_/X }
C {devices/lab_pin.sym} 54980 -26890 0 0 {name=p54380 lab=_58872_/Y }
C {devices/lab_pin.sym} 54980 -26850 0 0 {name=p54381 lab=_58873_/Y }
C {devices/lab_pin.sym} 54980 -26810 0 0 {name=p54382 lab=_58874_/X }
C {devices/lab_pin.sym} 54980 -26770 0 0 {name=p54383 lab=_58832_/X }
C {devices/lab_pin.sym} 55140 -26850 0 1 {name=p54384 lab=_58875_/X }
C {sky130_stdcells/o32a_4.sym} 55060 -26850 0 0 {name=X_58875_ }
C {devices/lab_pin.sym} 55000 -26700 0 0 {name=p54385 lab=_85028_/Q }
C {devices/lab_pin.sym} 55000 -26660 0 0 {name=p54386 lab=_45824_/B }
C {devices/lab_pin.sym} 55120 -26680 0 1 {name=p54387 lab=_45840_/Y }
C {sky130_stdcells/nor2_4.sym} 55060 -26680 0 0 {name=X_45840_ }
C {devices/lab_pin.sym} 54980 -26570 0 0 {name=p54388 lab=_57811_/X }
C {devices/lab_pin.sym} 54980 -26530 0 0 {name=p54389 lab=_85403_/Q }
C {devices/lab_pin.sym} 54980 -26490 0 0 {name=p54390 lab=_57825_/X }
C {devices/lab_pin.sym} 55140 -26530 0 1 {name=p54391 lab=_57826_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -26530 0 0 {name=X_57826_ }
C {devices/lab_pin.sym} 54980 -26410 0 0 {name=p54392 lab=_76662_/A }
C {devices/lab_pin.sym} 54980 -26370 0 0 {name=p54393 lab=_76658_/Y }
C {devices/lab_pin.sym} 54980 -26330 0 0 {name=p54394 lab=_76662_/C }
C {devices/lab_pin.sym} 55140 -26370 0 1 {name=p54395 lab=_76661_/A }
C {sky130_stdcells/a21oi_4.sym} 55060 -26370 0 0 {name=X_76660_ }
C {devices/lab_pin.sym} 55020 -26230 0 0 {name=p54396 lab=_73438_/B }
C {devices/lab_pin.sym} 55100 -26230 0 1 {name=p54397 lab=_73872_/X }
C {sky130_stdcells/buf_2.sym} 55060 -26230 0 0 {name=X_73872_ }
C {devices/lab_pin.sym} 54970 -26110 0 0 {name=p54398 lab=_83562_/CLK }
C {devices/lab_pin.sym} 54970 -26090 0 0 {name=p54399 lab=_52258_/Y }
C {devices/lab_pin.sym} 55150 -26110 0 1 {name=p54400 lab=_65890_/B }
C {sky130_stdcells/dfxtp_4.sym} 55060 -26100 0 0 {name=X_85858_ }
C {devices/lab_pin.sym} 55000 -25980 0 0 {name=p54401 lab=_80998_/Q }
C {devices/lab_pin.sym} 55000 -25940 0 0 {name=p54402 lab=_75611_/B }
C {devices/lab_pin.sym} 55120 -25960 0 1 {name=p54403 lab=_80966_/D }
C {sky130_stdcells/xor2_4.sym} 55060 -25960 0 0 {name=X_75611_ }
C {devices/lab_pin.sym} 54980 -25850 0 0 {name=p54404 lab=_72821_/X }
C {devices/lab_pin.sym} 54980 -25810 0 0 {name=p54405 lab=_72822_/Y }
C {devices/lab_pin.sym} 54980 -25770 0 0 {name=p54406 lab=_72766_/X }
C {devices/lab_pin.sym} 55140 -25810 0 1 {name=p54407 lab=_72823_/Y }
C {sky130_stdcells/a21oi_4.sym} 55060 -25810 0 0 {name=X_72823_ }
C {devices/lab_pin.sym} 54970 -25670 0 0 {name=p54408 lab=_85957_/CLK }
C {devices/lab_pin.sym} 54970 -25650 0 0 {name=p54409 lab=_84809_/D }
C {devices/lab_pin.sym} 55150 -25670 0 1 {name=p54410 lab=_84809_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -25660 0 0 {name=X_84809_ }
C {devices/lab_pin.sym} 55020 -25530 0 0 {name=p54411 lab=_57757_/A }
C {devices/lab_pin.sym} 55100 -25530 0 1 {name=p54412 lab=_58857_/A }
C {sky130_stdcells/buf_2.sym} 55060 -25530 0 0 {name=X_57757_ }
C {devices/lab_pin.sym} 54980 -25430 0 0 {name=p54413 lab=_85001_/Q }
C {devices/lab_pin.sym} 54980 -25390 0 0 {name=p54414 lab=_45705_/X }
C {devices/lab_pin.sym} 54980 -25350 0 0 {name=p54415 lab=_45691_/X }
C {devices/lab_pin.sym} 55140 -25390 0 1 {name=p54416 lab=_45771_/X }
C {sky130_stdcells/o21a_4.sym} 55060 -25390 0 0 {name=X_45771_ }
C {devices/lab_pin.sym} 55000 -25260 0 0 {name=p54417 lab=_76583_/Y }
C {devices/lab_pin.sym} 55000 -25220 0 0 {name=p54418 lab=_76616_/B }
C {devices/lab_pin.sym} 55120 -25240 0 1 {name=p54419 lab=_76591_/X }
C {sky130_stdcells/xor2_4.sym} 55060 -25240 0 0 {name=X_76591_ }
C {devices/lab_pin.sym} 55000 -25120 0 0 {name=p54420 lab=_54985_/A }
C {devices/lab_pin.sym} 55000 -25080 0 0 {name=p54421 lab=_47543_/Y }
C {devices/lab_pin.sym} 55120 -25100 0 1 {name=p54422 lab=_54969_/Y }
C {sky130_stdcells/nand2_4.sym} 55060 -25100 0 0 {name=X_54969_ }
C {devices/lab_pin.sym} 54980 -25000 0 0 {name=p54423 lab=_40469_/X }
C {devices/lab_pin.sym} 54980 -24960 0 0 {name=p54424 lab=_42962_/X }
C {devices/lab_pin.sym} 54980 -24920 0 0 {name=p54425 lab=_66948_/B }
C {devices/lab_pin.sym} 54980 -24880 0 0 {name=p54426 lab=_42963_/X }
C {devices/lab_pin.sym} 55140 -24940 0 1 {name=p54427 lab=_87619_/D }
C {sky130_stdcells/a2bb2o_4.sym} 55060 -24940 0 0 {name=X_42983_ }
C {devices/lab_pin.sym} 54970 -24790 0 0 {name=p54428 lab=_84807_/CLK }
C {devices/lab_pin.sym} 54970 -24770 0 0 {name=p54429 lab=_52600_/Y }
C {devices/lab_pin.sym} 55150 -24790 0 1 {name=p54430 lab=_85789_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -24780 0 0 {name=X_85789_ }
C {devices/lab_pin.sym} 55020 -24650 0 0 {name=p54431 lab=_47556_/A }
C {devices/lab_pin.sym} 55100 -24650 0 1 {name=p54432 lab=_47549_/B }
C {sky130_stdcells/buf_2.sym} 55060 -24650 0 0 {name=X_47510_ }
C {devices/lab_pin.sym} 55000 -24540 0 0 {name=p54433 lab=_78330_/A }
C {devices/lab_pin.sym} 55000 -24500 0 0 {name=p54434 lab=_78330_/B }
C {devices/lab_pin.sym} 55120 -24520 0 1 {name=p54435 lab=_78332_/A }
C {sky130_stdcells/nand2_4.sym} 55060 -24520 0 0 {name=X_78330_ }
C {devices/lab_pin.sym} 55000 -24410 0 0 {name=p54436 lab=_56708_/A }
C {devices/lab_pin.sym} 55000 -24370 0 0 {name=p54437 lab=_56707_/X }
C {devices/lab_pin.sym} 55000 -24330 0 0 {name=p54438 lab=_56708_/C }
C {devices/lab_pin.sym} 55120 -24370 0 1 {name=p54439 lab=_57284_/A }
C {sky130_stdcells/nand3_4.sym} 55060 -24370 0 0 {name=X_56708_ }
C {devices/lab_pin.sym} 55020 -24230 0 0 {name=p54440 lab=_44721_/Y }
C {devices/lab_pin.sym} 55100 -24230 0 1 {name=p54441 lab=_44722_/Y }
C {sky130_stdcells/inv_2.sym} 55060 -24230 0 0 {name=X_44722_ }
C {devices/lab_pin.sym} 55000 -24120 0 0 {name=p54442 lab=_80704_/Q }
C {devices/lab_pin.sym} 55000 -24080 0 0 {name=p54443 lab=_75554_/B }
C {devices/lab_pin.sym} 55120 -24100 0 1 {name=p54444 lab=_75543_/B }
C {sky130_stdcells/xor2_4.sym} 55060 -24100 0 0 {name=X_75542_ }
C {devices/lab_pin.sym} 54970 -23970 0 0 {name=p54445 lab=_87782_/CLK }
C {devices/lab_pin.sym} 54970 -23950 0 0 {name=p54446 lab=_87528_/D }
C {devices/lab_pin.sym} 55150 -23970 0 1 {name=p54447 lab=_87528_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -23960 0 0 {name=X_87528_ }
C {devices/lab_pin.sym} 55020 -23830 0 0 {name=p54448 lab=_41934_/A }
C {devices/lab_pin.sym} 55100 -23830 0 1 {name=p54449 lab=_41934_/Y }
C {sky130_stdcells/inv_2.sym} 55060 -23830 0 0 {name=X_41934_ }
C {devices/lab_pin.sym} 54980 -23730 0 0 {name=p54450 lab=_48483_/Y }
C {devices/lab_pin.sym} 54980 -23690 0 0 {name=p54451 lab=_48459_/X }
C {devices/lab_pin.sym} 54980 -23650 0 0 {name=p54452 lab=_48489_/X }
C {devices/lab_pin.sym} 55140 -23690 0 1 {name=p54453 lab=_86518_/D }
C {sky130_stdcells/a21oi_4.sym} 55060 -23690 0 0 {name=X_48490_ }
C {devices/lab_pin.sym} 54980 -23570 0 0 {name=p54454 lab=_72749_/X }
C {devices/lab_pin.sym} 54980 -23530 0 0 {name=p54455 lab=_72753_/X }
C {devices/lab_pin.sym} 54980 -23490 0 0 {name=p54456 lab=_72735_/X }
C {devices/lab_pin.sym} 55140 -23530 0 1 {name=p54457 lab=_72754_/X }
C {sky130_stdcells/a21o_4.sym} 55060 -23530 0 0 {name=X_72754_ }
C {devices/lab_pin.sym} 55020 -23390 0 0 {name=p54458 lab=_59629_/A }
C {devices/lab_pin.sym} 55100 -23390 0 1 {name=p54459 lab=_57689_/A }
C {sky130_stdcells/buf_2.sym} 55060 -23390 0 0 {name=X_57688_ }
C {devices/lab_pin.sym} 54980 -23290 0 0 {name=p54460 lab=_47434_/Y }
C {devices/lab_pin.sym} 54980 -23250 0 0 {name=p54461 lab=_47414_/X }
C {devices/lab_pin.sym} 54980 -23210 0 0 {name=p54462 lab=_47440_/X }
C {devices/lab_pin.sym} 55140 -23250 0 1 {name=p54463 lab=_86635_/D }
C {sky130_stdcells/a21oi_4.sym} 55060 -23250 0 0 {name=X_47441_ }
C {devices/lab_pin.sym} 54980 -23130 0 0 {name=p54464 lab=_58298_/Y }
C {devices/lab_pin.sym} 54980 -23090 0 0 {name=p54465 lab=_71695_/X }
C {devices/lab_pin.sym} 54980 -23050 0 0 {name=p54466 lab=_71704_/Y }
C {devices/lab_pin.sym} 55140 -23090 0 1 {name=p54467 lab=_83404_/D }
C {sky130_stdcells/o21ai_4.sym} 55060 -23090 0 0 {name=X_71705_ }
C {devices/lab_pin.sym} 55020 -22950 0 0 {name=p54468 lab=_59427_/A }
C {devices/lab_pin.sym} 55100 -22950 0 1 {name=p54469 lab=_59427_/Y }
C {sky130_stdcells/inv_2.sym} 55060 -22950 0 0 {name=X_59427_ }
C {devices/lab_pin.sym} 55000 -22840 0 0 {name=p54470 lab=_82683_/Q }
C {devices/lab_pin.sym} 55000 -22800 0 0 {name=p54471 lab=_78261_/B }
C {devices/lab_pin.sym} 55120 -22820 0 1 {name=p54472 lab=_78261_/X }
C {sky130_stdcells/xor2_4.sym} 55060 -22820 0 0 {name=X_78261_ }
C {devices/lab_pin.sym} 54980 -22720 0 0 {name=p54473 lab=_41069_/Y }
C {devices/lab_pin.sym} 54980 -22680 0 0 {name=p54474 lab=_44648_/X }
C {devices/lab_pin.sym} 54980 -22640 0 0 {name=p54475 lab=_87015_/Q }
C {devices/lab_pin.sym} 54980 -22600 0 0 {name=p54476 lab=_44650_/X }
C {devices/lab_pin.sym} 55140 -22660 0 1 {name=p54477 lab=_44653_/X }
C {sky130_stdcells/a2bb2o_4.sym} 55060 -22660 0 0 {name=X_44653_ }
C {devices/lab_pin.sym} 55020 -22510 0 0 {name=p54478 lab=_56638_/X }
C {devices/lab_pin.sym} 55100 -22510 0 1 {name=p54479 lab=_56639_/X }
C {sky130_stdcells/buf_2.sym} 55060 -22510 0 0 {name=X_56639_ }
C {devices/lab_pin.sym} 55020 -22390 0 0 {name=p54480 lab=_75473_/A }
C {devices/lab_pin.sym} 55100 -22390 0 1 {name=p54481 lab=_75477_/A }
C {sky130_stdcells/inv_2.sym} 55060 -22390 0 0 {name=X_75473_ }
C {devices/lab_pin.sym} 54970 -22270 0 0 {name=p54482 lab=_87149_/CLK }
C {devices/lab_pin.sym} 54970 -22250 0 0 {name=p54483 lab=_43362_/X }
C {devices/lab_pin.sym} 55150 -22270 0 1 {name=p54484 lab=_87459_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -22260 0 0 {name=X_87459_ }
C {devices/lab_pin.sym} 55020 -22130 0 0 {name=p54485 lab=_41902_/A }
C {devices/lab_pin.sym} 55100 -22130 0 1 {name=p54486 lab=_41877_/A }
C {sky130_stdcells/inv_2.sym} 55060 -22130 0 0 {name=X_41865_ }
C {devices/lab_pin.sym} 55020 -22010 0 0 {name=p54487 lab=_73078_/A }
C {devices/lab_pin.sym} 55100 -22010 0 1 {name=p54488 lab=_72686_/A }
C {sky130_stdcells/buf_2.sym} 55060 -22010 0 0 {name=X_72685_ }
C {devices/lab_pin.sym} 55020 -21890 0 0 {name=p54489 lab=clkbuf_8_25_0_CLK/A }
C {devices/lab_pin.sym} 55100 -21890 0 1 {name=p54490 lab=clkbuf_9_49_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 55060 -21890 0 0 {name=Xclkbuf_8_24_0_CLK }
C {devices/lab_pin.sym} 54980 -21790 0 0 {name=p54491 lab=_77207_/B }
C {devices/lab_pin.sym} 54980 -21750 0 0 {name=p54492 lab=_77210_/X }
C {devices/lab_pin.sym} 54980 -21710 0 0 {name=p54493 lab=_77211_/Y }
C {devices/lab_pin.sym} 55140 -21750 0 1 {name=p54494 lab=_77212_/Y }
C {sky130_stdcells/a21boi_4.sym} 55060 -21750 0 0 {name=X_77212_ }
C {devices/lab_pin.sym} 55020 -21610 0 0 {name=p54495 lab=_55102_/A }
C {devices/lab_pin.sym} 55100 -21610 0 1 {name=p54496 lab=_43604_/X }
C {sky130_stdcells/buf_2.sym} 55060 -21610 0 0 {name=X_43604_ }
C {devices/lab_pin.sym} 54980 -21510 0 0 {name=p54497 lab=_83069_/Q }
C {devices/lab_pin.sym} 54980 -21470 0 0 {name=p54498 lab=_74412_/X }
C {devices/lab_pin.sym} 54980 -21430 0 0 {name=p54499 lab=_74423_/Y }
C {devices/lab_pin.sym} 55140 -21470 0 1 {name=p54500 lab=_74424_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -21470 0 0 {name=X_74424_ }
C {devices/lab_pin.sym} 55020 -21330 0 0 {name=p54501 lab=_40816_/A }
C {devices/lab_pin.sym} 55100 -21330 0 1 {name=p54502 lab=_40816_/Y }
C {sky130_stdcells/inv_2.sym} 55060 -21330 0 0 {name=X_40816_ }
C {devices/lab_pin.sym} 54980 -21230 0 0 {name=p54503 lab=_59208_/X }
C {devices/lab_pin.sym} 54980 -21190 0 0 {name=p54504 lab=_86052_/Q }
C {devices/lab_pin.sym} 54980 -21150 0 0 {name=p54505 lab=_59357_/X }
C {devices/lab_pin.sym} 55140 -21190 0 1 {name=p54506 lab=_59358_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -21190 0 0 {name=X_59358_ }
C {devices/lab_pin.sym} 55020 -21050 0 0 {name=p54507 lab=_47372_/A }
C {devices/lab_pin.sym} 55100 -21050 0 1 {name=p54508 lab=_47372_/Y }
C {sky130_stdcells/inv_2.sym} 55060 -21050 0 0 {name=X_47372_ }
C {devices/lab_pin.sym} 54980 -20950 0 0 {name=p54509 lab=_59484_/Y }
C {devices/lab_pin.sym} 54980 -20910 0 0 {name=p54510 lab=_71628_/X }
C {devices/lab_pin.sym} 54980 -20870 0 0 {name=p54511 lab=_71635_/Y }
C {devices/lab_pin.sym} 55140 -20910 0 1 {name=p54512 lab=_71636_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -20910 0 0 {name=X_71636_ }
C {devices/lab_pin.sym} 55000 -20780 0 0 {name=p54513 lab=_78192_/A }
C {devices/lab_pin.sym} 55000 -20740 0 0 {name=p54514 lab=_78191_/X }
C {devices/lab_pin.sym} 55120 -20760 0 1 {name=p54515 lab=_78192_/Y }
C {sky130_stdcells/nand2_4.sym} 55060 -20760 0 0 {name=X_78192_ }
C {devices/lab_pin.sym} 54980 -20670 0 0 {name=p54516 lab=_44554_/X }
C {devices/lab_pin.sym} 54980 -20630 0 0 {name=p54517 lab=_44555_/X }
C {devices/lab_pin.sym} 54980 -20590 0 0 {name=p54518 lab=_40903_/X }
C {devices/lab_pin.sym} 54980 -20550 0 0 {name=p54519 lab=_44583_/Y }
C {devices/lab_pin.sym} 54980 -20510 0 0 {name=p54520 lab=_44557_/X }
C {devices/lab_pin.sym} 55140 -20590 0 1 {name=p54521 lab=_87045_/D }
C {sky130_stdcells/o32ai_4.sym} 55060 -20590 0 0 {name=X_44584_ }
C {sky130_stdcells/decap_3.sym} 55060 -20400 0 0 {name=XPHY_6 }
C {devices/lab_pin.sym} 54980 -20270 0 0 {name=p54522 lab=_40628_/X }
C {devices/lab_pin.sym} 54980 -20230 0 0 {name=p54523 lab=_82337_/Q }
C {devices/lab_pin.sym} 54980 -20190 0 0 {name=p54524 lab=_41795_/X }
C {devices/lab_pin.sym} 55140 -20230 0 1 {name=p54525 lab=_41796_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -20230 0 0 {name=X_41796_ }
C {devices/lab_pin.sym} 54980 -20110 0 0 {name=p54526 lab=_40380_/X }
C {devices/lab_pin.sym} 54980 -20070 0 0 {name=p54527 lab=_81771_/Q }
C {devices/lab_pin.sym} 54980 -20030 0 0 {name=p54528 lab=_49110_/Y }
C {devices/lab_pin.sym} 55140 -20070 0 1 {name=p54529 lab=_49112_/A }
C {sky130_stdcells/o21ai_4.sym} 55060 -20070 0 0 {name=X_49111_ }
C {devices/lab_pin.sym} 54980 -19950 0 0 {name=p54530 lab=_46316_/Y }
C {devices/lab_pin.sym} 54980 -19910 0 0 {name=p54531 lab=_46300_/X }
C {devices/lab_pin.sym} 54980 -19870 0 0 {name=p54532 lab=_46322_/X }
C {devices/lab_pin.sym} 55140 -19910 0 1 {name=p54533 lab=_46323_/Y }
C {sky130_stdcells/a21oi_4.sym} 55060 -19910 0 0 {name=X_46323_ }
C {devices/lab_pin.sym} 54980 -19790 0 0 {name=p54534 lab=_58271_/X }
C {devices/lab_pin.sym} 54980 -19750 0 0 {name=p54535 lab=_83402_/Q }
C {devices/lab_pin.sym} 54980 -19710 0 0 {name=p54536 lab=_58308_/Y }
C {devices/lab_pin.sym} 55140 -19750 0 1 {name=p54537 lab=_84882_/D }
C {sky130_stdcells/o21a_4.sym} 55060 -19750 0 0 {name=X_58309_ }
C {devices/lab_pin.sym} 55000 -19630 0 0 {name=p54538 lab=_77141_/B }
C {devices/lab_pin.sym} 55000 -19590 0 0 {name=p54539 lab=_77143_/B }
C {devices/lab_pin.sym} 55000 -19550 0 0 {name=p54540 lab=_81916_/Q }
C {devices/lab_pin.sym} 55120 -19590 0 1 {name=p54541 lab=_77143_/Y }
C {sky130_stdcells/nand3_4.sym} 55060 -19590 0 0 {name=X_77143_ }
C {devices/lab_pin.sym} 54980 -19480 0 0 {name=p54542 lab=_40404_/X }
C {devices/lab_pin.sym} 54980 -19440 0 0 {name=p54543 lab=_43532_/X }
C {devices/lab_pin.sym} 54980 -19400 0 0 {name=p54544 lab=_87372_/Q }
C {devices/lab_pin.sym} 54980 -19360 0 0 {name=p54545 lab=_43533_/X }
C {devices/lab_pin.sym} 55140 -19420 0 1 {name=p54546 lab=_43535_/X }
C {sky130_stdcells/a2bb2o_4.sym} 55060 -19420 0 0 {name=X_43535_ }
C {devices/lab_pin.sym} 55000 -19290 0 0 {name=p54547 lab=_45954_/X }
C {devices/lab_pin.sym} 55000 -19250 0 0 {name=p54548 lab=_58334_/A }
C {devices/lab_pin.sym} 55000 -19210 0 0 {name=p54549 lab=_56158_/A }
C {devices/lab_pin.sym} 55120 -19250 0 1 {name=p54550 lab=_74355_/Y }
C {sky130_stdcells/nand3_4.sym} 55060 -19250 0 0 {name=X_74355_ }
C {devices/lab_pin.sym} 55000 -19120 0 0 {name=p54551 lab=_40817_/A }
C {devices/lab_pin.sym} 55000 -19080 0 0 {name=p54552 lab=_82852_/Q }
C {devices/lab_pin.sym} 55120 -19100 0 1 {name=p54553 lab=_40747_/X }
C {sky130_stdcells/or2_4.sym} 55060 -19100 0 0 {name=X_40747_ }
C {devices/lab_pin.sym} 54980 -18990 0 0 {name=p54554 lab=_59285_/Y }
C {devices/lab_pin.sym} 54980 -18950 0 0 {name=p54555 lab=_59288_/Y }
C {devices/lab_pin.sym} 54980 -18910 0 0 {name=p54556 lab=_59278_/X }
C {devices/lab_pin.sym} 55140 -18950 0 1 {name=p54557 lab=_59289_/X }
C {sky130_stdcells/a21o_4.sym} 55060 -18950 0 0 {name=X_59289_ }
C {devices/lab_pin.sym} 55020 -18810 0 0 {name=p54558 lab=_71585_/A }
C {devices/lab_pin.sym} 55100 -18810 0 1 {name=p54559 lab=_71583_/B }
C {sky130_stdcells/buf_2.sym} 55060 -18810 0 0 {name=X_71567_ }
C {devices/lab_pin.sym} 55000 -18700 0 0 {name=p54560 lab=_49022_/A }
C {devices/lab_pin.sym} 55000 -18660 0 0 {name=p54561 lab=_53858_/B }
C {devices/lab_pin.sym} 55120 -18680 0 1 {name=p54562 lab=_49042_/X }
C {sky130_stdcells/and2_4.sym} 55060 -18680 0 0 {name=X_49042_ }
C {devices/lab_pin.sym} 54980 -18590 0 0 {name=p54563 lab=_61317_/X }
C {devices/lab_pin.sym} 54980 -18550 0 0 {name=p54564 lab=_72575_/A }
C {devices/lab_pin.sym} 54980 -18510 0 0 {name=p54565 lab=_61260_/X }
C {devices/lab_pin.sym} 54980 -18470 0 0 {name=p54566 lab=_61319_/X }
C {devices/lab_pin.sym} 54980 -18440 0 0 {name=p54567 lab=_61277_/B }
C {devices/lab_pin.sym} 55140 -18510 0 1 {name=p54568 lab=_61320_/Y }
C {sky130_stdcells/a41oi_4.sym} 55060 -18510 0 0 {name=X_61320_ }
C {devices/lab_pin.sym} 55020 -18350 0 0 {name=p54569 lab=_73306_/A }
C {devices/lab_pin.sym} 55100 -18350 0 1 {name=p54570 lab=_73426_/A }
C {sky130_stdcells/buf_2.sym} 55060 -18350 0 0 {name=X_73306_ }
C {devices/lab_pin.sym} 55020 -18230 0 0 {name=p54571 lab=_83656_/Q }
C {devices/lab_pin.sym} 55100 -18230 0 1 {name=p54572 lab=_53946_/B }
C {sky130_stdcells/inv_2.sym} 55060 -18230 0 0 {name=X_46254_ }
C {sky130_stdcells/decap_3.sym} 55060 -18080 0 0 {name=XPHY_660 }
C {devices/lab_pin.sym} 55000 -17950 0 0 {name=p54573 lab=_70511_/A }
C {devices/lab_pin.sym} 55000 -17910 0 0 {name=p54574 lab=_70949_/B }
C {devices/lab_pin.sym} 55000 -17870 0 0 {name=p54575 lab=_70508_/X }
C {devices/lab_pin.sym} 55120 -17910 0 1 {name=p54576 lab=_70518_/Y }
C {sky130_stdcells/nand3_4.sym} 55060 -17910 0 0 {name=X_70518_ }
C {devices/lab_pin.sym} 55000 -17780 0 0 {name=p54577 lab=_82092_/Q }
C {devices/lab_pin.sym} 55000 -17740 0 0 {name=p54578 lab=_77074_/B }
C {devices/lab_pin.sym} 55120 -17760 0 1 {name=p54579 lab=_82341_/D }
C {sky130_stdcells/xor2_4.sym} 55060 -17760 0 0 {name=X_77074_ }
C {devices/lab_pin.sym} 55020 -17630 0 0 {name=p54580 lab=_43182_/Y }
C {devices/lab_pin.sym} 55100 -17630 0 1 {name=p54581 lab=_43466_/X }
C {sky130_stdcells/buf_2.sym} 55060 -17630 0 0 {name=X_43466_ }
C {devices/lab_pin.sym} 55000 -17530 0 0 {name=p54582 lab=_72714_/A }
C {devices/lab_pin.sym} 55000 -17490 0 0 {name=p54583 lab=_72714_/B }
C {devices/lab_pin.sym} 55000 -17450 0 0 {name=p54584 lab=_74286_/C }
C {devices/lab_pin.sym} 55120 -17490 0 1 {name=p54585 lab=_74286_/Y }
C {sky130_stdcells/nand3_4.sym} 55060 -17490 0 0 {name=X_74286_ }
C {sky130_stdcells/decap_3.sym} 55060 -17320 0 0 {name=XPHY_671 }
C {devices/lab_pin.sym} 55020 -17170 0 0 {name=p54586 lab=clkbuf_8_39_0_CLK/A }
C {devices/lab_pin.sym} 55100 -17170 0 1 {name=p54587 lab=clkbuf_9_79_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 55060 -17170 0 0 {name=Xclkbuf_8_39_0_CLK }
C {devices/lab_pin.sym} 55020 -17050 0 0 {name=p54588 lab=_40678_/A }
C {devices/lab_pin.sym} 55100 -17050 0 1 {name=p54589 lab=_40678_/X }
C {sky130_stdcells/buf_2.sym} 55060 -17050 0 0 {name=X_40678_ }
C {devices/lab_pin.sym} 55000 -16950 0 0 {name=p54590 lab=_71308_/A }
C {devices/lab_pin.sym} 55000 -16910 0 0 {name=p54591 lab=_71815_/B }
C {devices/lab_pin.sym} 55000 -16870 0 0 {name=p54592 lab=_71496_/C }
C {devices/lab_pin.sym} 55120 -16910 0 1 {name=p54593 lab=_71498_/X }
C {sky130_stdcells/and3_4.sym} 55060 -16910 0 0 {name=X_71498_ }
C {sky130_stdcells/decap_3.sym} 55060 -16740 0 0 {name=XPHY_682 }
C {sky130_stdcells/decap_3.sym} 55060 -16560 0 0 {name=XPHY_693 }
C {devices/lab_pin.sym} 54980 -16430 0 0 {name=p54594 lab=_45192_/X }
C {devices/lab_pin.sym} 54980 -16390 0 0 {name=p54595 lab=_45201_/Y }
C {devices/lab_pin.sym} 54980 -16350 0 0 {name=p54596 lab=_45204_/Y }
C {devices/lab_pin.sym} 55140 -16390 0 1 {name=p54597 lab=_45205_/Y }
C {sky130_stdcells/a21oi_4.sym} 55060 -16390 0 0 {name=X_45205_ }
C {devices/lab_pin.sym} 55000 -16260 0 0 {name=p54598 lab=_76025_/A }
C {devices/lab_pin.sym} 55000 -16220 0 0 {name=p54599 lab=_81744_/D }
C {devices/lab_pin.sym} 55120 -16240 0 1 {name=p54600 lab=_76025_/X }
C {sky130_stdcells/xor2_4.sym} 55060 -16240 0 0 {name=X_76025_ }
C {devices/lab_pin.sym} 55020 -16110 0 0 {name=p54601 lab=_42417_/A }
C {devices/lab_pin.sym} 55100 -16110 0 1 {name=p54602 lab=_42417_/X }
C {sky130_stdcells/buf_2.sym} 55060 -16110 0 0 {name=X_42417_ }
C {devices/lab_pin.sym} 54980 -16030 0 0 {name=p54603 lab=_61131_/Y }
C {devices/lab_pin.sym} 54980 -15990 0 0 {name=p54604 lab=_61151_/Y }
C {devices/lab_pin.sym} 54980 -15950 0 0 {name=p54605 lab=_64454_/B }
C {devices/lab_pin.sym} 54980 -15910 0 0 {name=p54606 lab=_61249_/Y }
C {devices/lab_pin.sym} 54980 -15880 0 0 {name=p54607 lab=_61250_/Y }
C {devices/lab_pin.sym} 55140 -15950 0 1 {name=p54608 lab=_84498_/D }
C {sky130_stdcells/a41oi_4.sym} 55060 -15950 0 0 {name=X_61251_ }
C {devices/lab_pin.sym} 54980 -15810 0 0 {name=p54609 lab=_73234_/X }
C {devices/lab_pin.sym} 54980 -15770 0 0 {name=p54610 lab=_73236_/X }
C {devices/lab_pin.sym} 54980 -15730 0 0 {name=p54611 lab=_73067_/X }
C {devices/lab_pin.sym} 55140 -15770 0 1 {name=p54612 lab=_73237_/X }
C {sky130_stdcells/a21o_4.sym} 55060 -15770 0 0 {name=X_73237_ }
C {devices/lab_pin.sym} 54980 -15650 0 0 {name=p54613 lab=_50302_/B }
C {devices/lab_pin.sym} 54980 -15610 0 0 {name=p54614 lab=_70421_/Y }
C {devices/lab_pin.sym} 54980 -15570 0 0 {name=p54615 lab=_70448_/Y }
C {devices/lab_pin.sym} 55140 -15610 0 1 {name=p54616 lab=_83771_/D }
C {sky130_stdcells/o21ai_4.sym} 55060 -15610 0 0 {name=X_70449_ }
C {devices/lab_pin.sym} 55000 -15490 0 0 {name=p54617 lab=_46183_/X }
C {devices/lab_pin.sym} 55000 -15450 0 0 {name=p54618 lab=_46150_/B }
C {devices/lab_pin.sym} 55000 -15410 0 0 {name=p54619 lab=_46184_/Y }
C {devices/lab_pin.sym} 55120 -15450 0 1 {name=p54620 lab=_46185_/X }
C {sky130_stdcells/and3_4.sym} 55060 -15450 0 0 {name=X_46185_ }
C {devices/lab_pin.sym} 55020 -15310 0 0 {name=p54621 lab=_43397_/A }
C {devices/lab_pin.sym} 55100 -15310 0 1 {name=p54622 lab=_43397_/X }
C {sky130_stdcells/buf_2.sym} 55060 -15310 0 0 {name=X_43397_ }
C {devices/lab_pin.sym} 55020 -15190 0 0 {name=p54623 lab=_60202_/A }
C {devices/lab_pin.sym} 55100 -15190 0 1 {name=p54624 lab=_60324_/C }
C {sky130_stdcells/buf_2.sym} 55060 -15190 0 0 {name=X_60202_ }
C {devices/lab_pin.sym} 54980 -15090 0 0 {name=p54625 lab=_85202_/Q }
C {devices/lab_pin.sym} 54980 -15050 0 0 {name=p54626 lab=_45102_/X }
C {devices/lab_pin.sym} 54980 -15010 0 0 {name=p54627 lab=_45135_/X }
C {devices/lab_pin.sym} 55140 -15050 0 1 {name=p54628 lab=_45136_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -15050 0 0 {name=X_45136_ }
C {devices/lab_pin.sym} 54980 -14950 0 0 {name=p54629 lab=_42330_/X }
C {devices/lab_pin.sym} 54980 -14910 0 0 {name=p54630 lab=_42346_/X }
C {devices/lab_pin.sym} 54980 -14870 0 0 {name=p54631 lab=_41705_/X }
C {devices/lab_pin.sym} 54980 -14830 0 0 {name=p54632 lab=_87909_/Q }
C {devices/lab_pin.sym} 54980 -14790 0 0 {name=p54633 lab=_42347_/X }
C {devices/lab_pin.sym} 55140 -14870 0 1 {name=p54634 lab=_42348_/Y }
C {sky130_stdcells/o32ai_4.sym} 55060 -14870 0 0 {name=X_42348_ }
C {devices/lab_pin.sym} 55020 -14710 0 0 {name=p54635 lab=_64250_/A }
C {devices/lab_pin.sym} 55100 -14710 0 1 {name=p54636 lab=_61182_/X }
C {sky130_stdcells/buf_2.sym} 55060 -14710 0 0 {name=X_61182_ }
C {devices/lab_pin.sym} 55000 -14600 0 0 {name=p54637 lab=_73168_/A }
C {devices/lab_pin.sym} 55000 -14560 0 0 {name=p54638 lab=_73167_/X }
C {devices/lab_pin.sym} 55120 -14580 0 1 {name=p54639 lab=_73169_/B }
C {sky130_stdcells/nand2_4.sym} 55060 -14580 0 0 {name=X_73168_ }
C {devices/lab_pin.sym} 54980 -14470 0 0 {name=p54640 lab=_60091_/C }
C {devices/lab_pin.sym} 54980 -14430 0 0 {name=p54641 lab=_59922_/C }
C {devices/lab_pin.sym} 54980 -14390 0 0 {name=p54642 lab=_60091_/A }
C {devices/lab_pin.sym} 55140 -14430 0 1 {name=p54643 lab=_60133_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -14430 0 0 {name=X_60133_ }
C {devices/lab_pin.sym} 54980 -14330 0 0 {name=p54644 lab=_59325_/X }
C {devices/lab_pin.sym} 54980 -14290 0 0 {name=p54645 lab=_72116_/Y }
C {devices/lab_pin.sym} 54980 -14250 0 0 {name=p54646 lab=_72118_/Y }
C {devices/lab_pin.sym} 54980 -14210 0 0 {name=p54647 lab=_59342_/X }
C {devices/lab_pin.sym} 54980 -14170 0 0 {name=p54648 lab=_59329_/X }
C {devices/lab_pin.sym} 55140 -14250 0 1 {name=p54649 lab=_72119_/X }
C {sky130_stdcells/o32a_4.sym} 55060 -14250 0 0 {name=X_72119_ }
C {devices/lab_pin.sym} 54980 -14110 0 0 {name=p54650 lab=_49941_/Y }
C {devices/lab_pin.sym} 54980 -14070 0 0 {name=p54651 lab=_49924_/X }
C {devices/lab_pin.sym} 54980 -14030 0 0 {name=p54652 lab=_49943_/X }
C {devices/lab_pin.sym} 55140 -14070 0 1 {name=p54653 lab=_86295_/D }
C {sky130_stdcells/a21oi_4.sym} 55060 -14070 0 0 {name=X_49944_ }
C {devices/lab_pin.sym} 55000 -13940 0 0 {name=p54654 lab=_45067_/A }
C {devices/lab_pin.sym} 55000 -13900 0 0 {name=p54655 lab=_45067_/B }
C {devices/lab_pin.sym} 55120 -13920 0 1 {name=p54656 lab=_45067_/Y }
C {sky130_stdcells/nand2_4.sym} 55060 -13920 0 0 {name=X_45067_ }
C {devices/lab_pin.sym} 55020 -13790 0 0 {name=p54657 lab=_65484_/A }
C {devices/lab_pin.sym} 55100 -13790 0 1 {name=p54658 lab=_65990_/X }
C {sky130_stdcells/buf_2.sym} 55060 -13790 0 0 {name=X_65990_ }
C {devices/lab_pin.sym} 55020 -13670 0 0 {name=p54659 lab=_42204_/X }
C {devices/lab_pin.sym} 55100 -13670 0 1 {name=p54660 lab=_42279_/X }
C {sky130_stdcells/buf_2.sym} 55060 -13670 0 0 {name=X_42279_ }
C {devices/lab_pin.sym} 55000 -13560 0 0 {name=p54661 lab=_53678_/B }
C {devices/lab_pin.sym} 55000 -13520 0 0 {name=p54662 lab=_73098_/Y }
C {devices/lab_pin.sym} 55120 -13540 0 1 {name=p54663 lab=_73099_/X }
C {sky130_stdcells/xor2_4.sym} 55060 -13540 0 0 {name=X_73099_ }
C {devices/lab_pin.sym} 55000 -13420 0 0 {name=p54664 lab=_78043_/A }
C {devices/lab_pin.sym} 55000 -13380 0 0 {name=p54665 lab=_77975_/A }
C {devices/lab_pin.sym} 55120 -13400 0 1 {name=p54666 lab=_77977_/A }
C {sky130_stdcells/nand2_4.sym} 55060 -13400 0 0 {name=X_77976_ }
C {devices/lab_pin.sym} 55020 -13270 0 0 {name=p54667 lab=_44146_/A }
C {devices/lab_pin.sym} 55100 -13270 0 1 {name=p54668 lab=_44019_/A }
C {sky130_stdcells/inv_2.sym} 55060 -13270 0 0 {name=X_44018_ }
C {devices/lab_pin.sym} 55000 -13160 0 0 {name=p54669 lab=_79711_/X }
C {devices/lab_pin.sym} 55000 -13120 0 0 {name=p54670 lab=_79714_/Y }
C {devices/lab_pin.sym} 55120 -13140 0 1 {name=p54671 lab=_79715_/X }
C {sky130_stdcells/xor2_4.sym} 55060 -13140 0 0 {name=X_79715_ }
C {devices/lab_pin.sym} 55020 -13010 0 0 {name=p54672 lab=_84221_/Q }
C {devices/lab_pin.sym} 55100 -13010 0 1 {name=p54673 lab=_64942_/C }
C {sky130_stdcells/inv_2.sym} 55060 -13010 0 0 {name=X_64941_ }
C {devices/lab_pin.sym} 55000 -12900 0 0 {name=p54674 lab=_76924_/A }
C {devices/lab_pin.sym} 55000 -12860 0 0 {name=p54675 lab=_81599_/Q }
C {devices/lab_pin.sym} 55120 -12880 0 1 {name=p54676 lab=_76927_/Y }
C {sky130_stdcells/nand2_4.sym} 55060 -12880 0 0 {name=X_76927_ }
C {devices/lab_pin.sym} 55000 -12770 0 0 {name=p54677 lab=_60064_/A }
C {devices/lab_pin.sym} 55000 -12730 0 0 {name=p54678 lab=_60081_/B }
C {devices/lab_pin.sym} 55000 -12690 0 0 {name=p54679 lab=_60064_/C }
C {devices/lab_pin.sym} 55120 -12730 0 1 {name=p54680 lab=_60064_/Y }
C {sky130_stdcells/nor3_4.sym} 55060 -12730 0 0 {name=X_60064_ }
C {devices/lab_pin.sym} 54980 -12610 0 0 {name=p54681 lab=_58130_/B }
C {devices/lab_pin.sym} 54980 -12570 0 0 {name=p54682 lab=_49853_/X }
C {devices/lab_pin.sym} 54980 -12530 0 0 {name=p54683 lab=_49874_/Y }
C {devices/lab_pin.sym} 55140 -12570 0 1 {name=p54684 lab=_49875_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -12570 0 0 {name=X_49875_ }
C {devices/lab_pin.sym} 54980 -12450 0 0 {name=p54685 lab=_86475_/Q }
C {devices/lab_pin.sym} 54980 -12410 0 0 {name=p54686 lab=_48809_/X }
C {devices/lab_pin.sym} 54980 -12370 0 0 {name=p54687 lab=_48825_/Y }
C {devices/lab_pin.sym} 55140 -12410 0 1 {name=p54688 lab=_48826_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -12410 0 0 {name=X_48826_ }
C {devices/lab_pin.sym} 54980 -12300 0 0 {name=p54689 lab=_87154_/Q }
C {devices/lab_pin.sym} 54980 -12260 0 0 {name=p54690 lab=_67585_/X }
C {devices/lab_pin.sym} 54980 -12220 0 0 {name=p54691 lab=_67633_/X }
C {devices/lab_pin.sym} 54980 -12180 0 0 {name=p54692 lab=_67659_/X }
C {devices/lab_pin.sym} 55140 -12240 0 1 {name=p54693 lab=_67660_/X }
C {sky130_stdcells/a211o_4.sym} 55060 -12240 0 0 {name=X_67660_ }
C {devices/lab_pin.sym} 55000 -12100 0 0 {name=p54694 lab=_79636_/X }
C {devices/lab_pin.sym} 55000 -12060 0 0 {name=p54695 lab=_79646_/B }
C {devices/lab_pin.sym} 55120 -12080 0 1 {name=p54696 lab=_79646_/Y }
C {sky130_stdcells/nand2_4.sym} 55060 -12080 0 0 {name=X_79646_ }
C {devices/lab_pin.sym} 55000 -11960 0 0 {name=p54697 lab=_64778_/A }
C {devices/lab_pin.sym} 55000 -11920 0 0 {name=p54698 lab=_85815_/Q }
C {devices/lab_pin.sym} 55120 -11940 0 1 {name=p54699 lab=_64872_/X }
C {sky130_stdcells/and2_4.sym} 55060 -11940 0 0 {name=X_64872_ }
C {devices/lab_pin.sym} 55000 -11820 0 0 {name=p54700 lab=_76858_/A }
C {devices/lab_pin.sym} 55000 -11780 0 0 {name=p54701 lab=_76857_/Y }
C {devices/lab_pin.sym} 55120 -11800 0 1 {name=p54702 lab=_76862_/A }
C {sky130_stdcells/xor2_4.sym} 55060 -11800 0 0 {name=X_76858_ }
C {devices/lab_pin.sym} 54980 -11690 0 0 {name=p54703 lab=_66607_/X }
C {devices/lab_pin.sym} 54980 -11650 0 0 {name=p54704 lab=_66610_/X }
C {devices/lab_pin.sym} 54980 -11610 0 0 {name=p54705 lab=_66411_/A }
C {devices/lab_pin.sym} 55140 -11650 0 1 {name=p54706 lab=_66611_/Y }
C {sky130_stdcells/a21oi_4.sym} 55060 -11650 0 0 {name=X_66611_ }
C {devices/lab_pin.sym} 55000 -11540 0 0 {name=p54707 lab=_63819_/Y }
C {devices/lab_pin.sym} 55000 -11500 0 0 {name=p54708 lab=_63823_/B }
C {devices/lab_pin.sym} 55000 -11460 0 0 {name=p54709 lab=_63821_/Y }
C {devices/lab_pin.sym} 55000 -11420 0 0 {name=p54710 lab=_63822_/Y }
C {devices/lab_pin.sym} 55120 -11480 0 1 {name=p54711 lab=_63823_/X }
C {sky130_stdcells/and4_4.sym} 55060 -11480 0 0 {name=X_63823_ }
C {devices/lab_pin.sym} 54980 -11350 0 0 {name=p54712 lab=_75810_/A }
C {devices/lab_pin.sym} 54980 -11310 0 0 {name=p54713 lab=_75810_/C }
C {devices/lab_pin.sym} 54980 -11270 0 0 {name=p54714 lab=_75810_/B }
C {devices/lab_pin.sym} 55140 -11310 0 1 {name=p54715 lab=_75811_/A }
C {sky130_stdcells/a21o_4.sym} 55060 -11310 0 0 {name=X_75809_ }
C {devices/lab_pin.sym} 55000 -11180 0 0 {name=p54716 lab=_48777_/A }
C {devices/lab_pin.sym} 55000 -11140 0 0 {name=p54717 lab=_50440_/B }
C {devices/lab_pin.sym} 55120 -11160 0 1 {name=p54718 lab=_48757_/Y }
C {sky130_stdcells/nand2_4.sym} 55060 -11160 0 0 {name=X_48757_ }
C {devices/lab_pin.sym} 55020 -11030 0 0 {name=p54719 lab=_67354_/X }
C {devices/lab_pin.sym} 55100 -11030 0 1 {name=p54720 lab=_67591_/X }
C {sky130_stdcells/buf_2.sym} 55060 -11030 0 0 {name=X_67591_ }
C {devices/lab_pin.sym} 55000 -10920 0 0 {name=p54721 lab=_79577_/A }
C {devices/lab_pin.sym} 55000 -10880 0 0 {name=p54722 lab=_79564_/Y }
C {devices/lab_pin.sym} 55120 -10900 0 1 {name=p54723 lab=_79578_/B }
C {sky130_stdcells/nand2_4.sym} 55060 -10900 0 0 {name=X_79577_ }
C {devices/lab_pin.sym} 54980 -10800 0 0 {name=p54724 lab=_40386_/Y }
C {devices/lab_pin.sym} 54980 -10760 0 0 {name=p54725 lab=_45963_/X }
C {devices/lab_pin.sym} 54980 -10720 0 0 {name=p54726 lab=_66644_/B }
C {devices/lab_pin.sym} 54980 -10680 0 0 {name=p54727 lab=_45964_/X }
C {devices/lab_pin.sym} 55140 -10740 0 1 {name=p54728 lab=_86835_/D }
C {sky130_stdcells/a2bb2o_4.sym} 55060 -10740 0 0 {name=X_45969_ }
C {devices/lab_pin.sym} 55000 -10600 0 0 {name=p54729 lab=_76786_/X }
C {devices/lab_pin.sym} 55000 -10560 0 0 {name=p54730 lab=_76788_/Y }
C {devices/lab_pin.sym} 55120 -10580 0 1 {name=p54731 lab=_76790_/B }
C {sky130_stdcells/xnor2_4.sym} 55060 -10580 0 0 {name=X_76789_ }
C {devices/lab_pin.sym} 55000 -10460 0 0 {name=p54732 lab=_69234_/A }
C {devices/lab_pin.sym} 55000 -10420 0 0 {name=p54733 lab=_87781_/Q }
C {devices/lab_pin.sym} 55120 -10440 0 1 {name=p54734 lab=_69330_/X }
C {sky130_stdcells/and2_4.sym} 55060 -10440 0 0 {name=X_69330_ }
C {devices/lab_pin.sym} 55020 -10310 0 0 {name=p54735 lab=_47661_/A }
C {devices/lab_pin.sym} 55100 -10310 0 1 {name=p54736 lab=_47749_/C }
C {sky130_stdcells/buf_2.sym} 55060 -10310 0 0 {name=X_47708_ }
C {devices/lab_pin.sym} 55020 -10190 0 0 {name=p54737 lab=_67816_/A }
C {devices/lab_pin.sym} 55100 -10190 0 1 {name=p54738 lab=_68614_/A }
C {sky130_stdcells/buf_2.sym} 55060 -10190 0 0 {name=X_66542_ }
C {devices/lab_pin.sym} 55000 -10080 0 0 {name=p54739 lab=_78528_/A }
C {devices/lab_pin.sym} 55000 -10040 0 0 {name=p54740 lab=_78528_/B }
C {devices/lab_pin.sym} 55120 -10060 0 1 {name=p54741 lab=_78528_/X }
C {sky130_stdcells/and2_4.sym} 55060 -10060 0 0 {name=X_78528_ }
C {devices/lab_pin.sym} 55020 -9930 0 0 {name=p54742 lab=_63724_/A }
C {devices/lab_pin.sym} 55100 -9930 0 1 {name=p54743 lab=_63757_/C }
C {sky130_stdcells/buf_2.sym} 55060 -9930 0 0 {name=X_63754_ }
C {devices/lab_pin.sym} 54980 -9830 0 0 {name=p54744 lab=_48652_/X }
C {devices/lab_pin.sym} 54980 -9790 0 0 {name=p54745 lab=_48136_/A }
C {devices/lab_pin.sym} 54980 -9750 0 0 {name=p54746 lab=_48687_/Y }
C {devices/lab_pin.sym} 55140 -9790 0 1 {name=p54747 lab=_74505_/A }
C {sky130_stdcells/o21ai_4.sym} 55060 -9790 0 0 {name=X_48688_ }
C {devices/lab_pin.sym} 55020 -9650 0 0 {name=p54748 lab=_60966_/A }
C {devices/lab_pin.sym} 55100 -9650 0 1 {name=p54749 lab=_60967_/A }
C {sky130_stdcells/inv_2.sym} 55060 -9650 0 0 {name=X_60966_ }
C {devices/lab_pin.sym} 54980 -9570 0 0 {name=p54750 lab=_62701_/Y }
C {devices/lab_pin.sym} 54980 -9530 0 0 {name=p54751 lab=_62660_/X }
C {devices/lab_pin.sym} 54980 -9490 0 0 {name=p54752 lab=_62702_/Y }
C {devices/lab_pin.sym} 54980 -9450 0 0 {name=p54753 lab=_62703_/Y }
C {devices/lab_pin.sym} 54980 -9420 0 0 {name=p54754 lab=_62704_/X }
C {devices/lab_pin.sym} 55140 -9490 0 1 {name=p54755 lab=_62705_/X }
C {sky130_stdcells/a41o_4.sym} 55060 -9490 0 0 {name=X_62705_ }
C {devices/lab_pin.sym} 55020 -9330 0 0 {name=p54756 lab=_69442_/A }
C {devices/lab_pin.sym} 55100 -9330 0 1 {name=p54757 lab=_69261_/X }
C {sky130_stdcells/buf_2.sym} 55060 -9330 0 0 {name=X_69261_ }
C {devices/lab_pin.sym} 55020 -9210 0 0 {name=p54758 lab=_83629_/Q }
C {devices/lab_pin.sym} 55100 -9210 0 1 {name=p54759 lab=_47639_/Y }
C {sky130_stdcells/inv_2.sym} 55060 -9210 0 0 {name=X_47639_ }
C {devices/lab_pin.sym} 55000 -9110 0 0 {name=p54760 lab=_66501_/A }
C {devices/lab_pin.sym} 55000 -9070 0 0 {name=p54761 lab=_66419_/X }
C {devices/lab_pin.sym} 55000 -9030 0 0 {name=p54762 lab=_84116_/Q }
C {devices/lab_pin.sym} 55120 -9070 0 1 {name=p54763 lab=_66473_/X }
C {sky130_stdcells/and3_4.sym} 55060 -9070 0 0 {name=X_66473_ }
C {devices/lab_pin.sym} 55000 -8940 0 0 {name=p54764 lab=_78458_/A }
C {devices/lab_pin.sym} 55000 -8900 0 0 {name=p54765 lab=_82669_/D }
C {devices/lab_pin.sym} 55120 -8920 0 1 {name=p54766 lab=_78460_/A }
C {sky130_stdcells/nand2_4.sym} 55060 -8920 0 0 {name=X_78459_ }
C {devices/lab_pin.sym} 55000 -8810 0 0 {name=p54767 lab=_63697_/A }
C {devices/lab_pin.sym} 55000 -8770 0 0 {name=p54768 lab=_58201_/A }
C {devices/lab_pin.sym} 55000 -8730 0 0 {name=p54769 lab=_63537_/C }
C {devices/lab_pin.sym} 55120 -8770 0 1 {name=p54770 lab=_63685_/X }
C {sky130_stdcells/and3_4.sym} 55060 -8770 0 0 {name=X_63685_ }
C {devices/lab_pin.sym} 55000 -8650 0 0 {name=p54771 lab=_60891_/Y }
C {devices/lab_pin.sym} 55000 -8610 0 0 {name=p54772 lab=_60543_/B }
C {devices/lab_pin.sym} 55000 -8570 0 0 {name=p54773 lab=_60896_/Y }
C {devices/lab_pin.sym} 55120 -8610 0 1 {name=p54774 lab=_60897_/Y }
C {sky130_stdcells/nand3_4.sym} 55060 -8610 0 0 {name=X_60897_ }
C {devices/lab_pin.sym} 54980 -8490 0 0 {name=p54775 lab=_84011_/Q }
C {devices/lab_pin.sym} 54980 -8450 0 0 {name=p54776 lab=_68200_/X }
C {devices/lab_pin.sym} 54980 -8410 0 0 {name=p54777 lab=_68211_/X }
C {devices/lab_pin.sym} 55140 -8450 0 1 {name=p54778 lab=_68212_/X }
C {sky130_stdcells/a21bo_4.sym} 55060 -8450 0 0 {name=X_68212_ }
C {devices/lab_pin.sym} 54980 -8340 0 0 {name=p54779 lab=_65350_/X }
C {devices/lab_pin.sym} 54980 -8300 0 0 {name=p54780 lab=_86209_/Q }
C {devices/lab_pin.sym} 54980 -8260 0 0 {name=p54781 lab=_65400_/X }
C {devices/lab_pin.sym} 54980 -8220 0 0 {name=p54782 lab=_65423_/X }
C {devices/lab_pin.sym} 55140 -8280 0 1 {name=p54783 lab=_65424_/X }
C {sky130_stdcells/a211o_4.sym} 55060 -8280 0 0 {name=X_65424_ }
C {devices/lab_pin.sym} 54980 -8150 0 0 {name=p54784 lab=_86160_/Q }
C {devices/lab_pin.sym} 54980 -8110 0 0 {name=p54785 lab=_50563_/X }
C {devices/lab_pin.sym} 54980 -8070 0 0 {name=p54786 lab=_50649_/Y }
C {devices/lab_pin.sym} 55140 -8110 0 1 {name=p54787 lab=_50650_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -8110 0 0 {name=X_50650_ }
C {devices/lab_pin.sym} 55000 -7990 0 0 {name=p54788 lab=_62653_/A }
C {devices/lab_pin.sym} 55000 -7950 0 0 {name=p54789 lab=_62653_/B }
C {devices/lab_pin.sym} 55000 -7910 0 0 {name=p54790 lab=_62636_/C }
C {devices/lab_pin.sym} 55120 -7950 0 1 {name=p54791 lab=_62636_/Y }
C {sky130_stdcells/nor3_4.sym} 55060 -7950 0 0 {name=X_62636_ }
C {devices/lab_pin.sym} 54970 -7810 0 0 {name=p54792 lab=_81482_/CLK }
C {devices/lab_pin.sym} 54970 -7790 0 0 {name=p54793 lab=_81470_/D }
C {devices/lab_pin.sym} 55150 -7810 0 1 {name=p54794 lab=_81470_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -7800 0 0 {name=X_81470_ }
C {devices/lab_pin.sym} 54980 -7700 0 0 {name=p54795 lab=_88047_/Q }
C {devices/lab_pin.sym} 54980 -7660 0 0 {name=p54796 lab=_68975_/X }
C {devices/lab_pin.sym} 54980 -7620 0 0 {name=p54797 lab=_68976_/X }
C {devices/lab_pin.sym} 54980 -7580 0 0 {name=p54798 lab=_69191_/X }
C {devices/lab_pin.sym} 55140 -7640 0 1 {name=p54799 lab=_69192_/X }
C {sky130_stdcells/a211o_4.sym} 55060 -7640 0 0 {name=X_69192_ }
C {devices/lab_pin.sym} 54980 -7510 0 0 {name=p54800 lab=_49307_/Y }
C {devices/lab_pin.sym} 54980 -7470 0 0 {name=p54801 lab=_49281_/X }
C {devices/lab_pin.sym} 54980 -7430 0 0 {name=p54802 lab=_49308_/X }
C {devices/lab_pin.sym} 55140 -7470 0 1 {name=p54803 lab=_86413_/D }
C {sky130_stdcells/a21oi_4.sym} 55060 -7470 0 0 {name=X_49309_ }
C {devices/lab_pin.sym} 55000 -7340 0 0 {name=p54804 lab=_59229_/A }
C {devices/lab_pin.sym} 55000 -7300 0 0 {name=p54805 lab=_84150_/Q }
C {devices/lab_pin.sym} 55120 -7320 0 1 {name=p54806 lab=_80423_/A }
C {sky130_stdcells/xor2_4.sym} 55060 -7320 0 0 {name=X_80421_ }
C {devices/lab_pin.sym} 54980 -7210 0 0 {name=p54807 lab=_84028_/Q }
C {devices/lab_pin.sym} 54980 -7170 0 0 {name=p54808 lab=_68140_/X }
C {devices/lab_pin.sym} 54980 -7130 0 0 {name=p54809 lab=_68142_/X }
C {devices/lab_pin.sym} 55140 -7170 0 1 {name=p54810 lab=_84028_/D }
C {sky130_stdcells/a21bo_4.sym} 55060 -7170 0 0 {name=X_68143_ }
C {devices/lab_pin.sym} 54980 -7060 0 0 {name=p54811 lab=_65272_/X }
C {devices/lab_pin.sym} 54980 -7020 0 0 {name=p54812 lab=_85540_/Q }
C {devices/lab_pin.sym} 54980 -6980 0 0 {name=p54813 lab=_65326_/X }
C {devices/lab_pin.sym} 54980 -6940 0 0 {name=p54814 lab=_65354_/X }
C {devices/lab_pin.sym} 55140 -7000 0 1 {name=p54815 lab=_65355_/X }
C {sky130_stdcells/a211o_4.sym} 55060 -7000 0 0 {name=X_65355_ }
C {devices/lab_pin.sym} 54980 -6870 0 0 {name=p54816 lab=_50576_/Y }
C {devices/lab_pin.sym} 54980 -6830 0 0 {name=p54817 lab=_50577_/X }
C {devices/lab_pin.sym} 54980 -6790 0 0 {name=p54818 lab=_50580_/Y }
C {devices/lab_pin.sym} 55140 -6830 0 1 {name=p54819 lab=_50581_/Y }
C {sky130_stdcells/a21boi_4.sym} 55060 -6830 0 0 {name=X_50581_ }
C {devices/lab_pin.sym} 55000 -6710 0 0 {name=p54820 lab=_62533_/A }
C {devices/lab_pin.sym} 55000 -6670 0 0 {name=p54821 lab=_63655_/B }
C {devices/lab_pin.sym} 55000 -6630 0 0 {name=p54822 lab=_62532_/X }
C {devices/lab_pin.sym} 55120 -6670 0 1 {name=p54823 lab=_62569_/C }
C {sky130_stdcells/nand3_4.sym} 55060 -6670 0 0 {name=X_62567_ }
C {devices/lab_pin.sym} 55020 -6530 0 0 {name=p54824 lab=clkbuf_9_191_0_CLK/X }
C {devices/lab_pin.sym} 55100 -6530 0 1 {name=p54825 lab=_85761_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55060 -6530 0 0 {name=Xclkbuf_10_383_0_CLK }
C {devices/lab_pin.sym} 55000 -6420 0 0 {name=p54826 lab=_52320_/A }
C {devices/lab_pin.sym} 55000 -6380 0 0 {name=p54827 lab=_48998_/A }
C {devices/lab_pin.sym} 55120 -6400 0 1 {name=p54828 lab=_52320_/X }
C {sky130_stdcells/and2_4.sym} 55060 -6400 0 0 {name=X_52320_ }
C {devices/lab_pin.sym} 55020 -6270 0 0 {name=p54829 lab=_64306_/A }
C {devices/lab_pin.sym} 55100 -6270 0 1 {name=p54830 lab=_64307_/B }
C {sky130_stdcells/buf_2.sym} 55060 -6270 0 0 {name=X_64306_ }
C {devices/lab_pin.sym} 54970 -6150 0 0 {name=p54831 lab=_83141_/CLK }
C {devices/lab_pin.sym} 54970 -6130 0 0 {name=p54832 lab=_83140_/D }
C {devices/lab_pin.sym} 55150 -6150 0 1 {name=p54833 lab=_83140_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -6140 0 0 {name=X_83140_ }
C {devices/lab_pin.sym} 55000 -6030 0 0 {name=p54834 lab=_61518_/A }
C {devices/lab_pin.sym} 55000 -5990 0 0 {name=p54835 lab=_61518_/B }
C {devices/lab_pin.sym} 55000 -5950 0 0 {name=p54836 lab=_79142_/B }
C {devices/lab_pin.sym} 55120 -5990 0 1 {name=p54837 lab=_61518_/Y }
C {sky130_stdcells/nor3_4.sym} 55060 -5990 0 0 {name=X_61518_ }
C {devices/lab_pin.sym} 55000 -5860 0 0 {name=p54838 lab=_80352_/A }
C {devices/lab_pin.sym} 55000 -5820 0 0 {name=p54839 lab=_80341_/Y }
C {devices/lab_pin.sym} 55120 -5840 0 1 {name=p54840 lab=_80353_/B }
C {sky130_stdcells/nand2_4.sym} 55060 -5840 0 0 {name=X_80352_ }
C {devices/lab_pin.sym} 55020 -5710 0 0 {name=p54841 lab=_68644_/A }
C {devices/lab_pin.sym} 55100 -5710 0 1 {name=p54842 lab=_68444_/A }
C {sky130_stdcells/buf_2.sym} 55060 -5710 0 0 {name=X_68074_ }
C {devices/lab_pin.sym} 54980 -5620 0 0 {name=p54843 lab=_65211_/X }
C {devices/lab_pin.sym} 54980 -5580 0 0 {name=p54844 lab=_85543_/Q }
C {devices/lab_pin.sym} 54980 -5540 0 0 {name=p54845 lab=_65212_/X }
C {devices/lab_pin.sym} 54980 -5500 0 0 {name=p54846 lab=_65285_/X }
C {devices/lab_pin.sym} 55140 -5560 0 1 {name=p54847 lab=_65286_/X }
C {sky130_stdcells/a211o_4.sym} 55060 -5560 0 0 {name=X_65286_ }
C {devices/lab_pin.sym} 55000 -5430 0 0 {name=p54848 lab=_62483_/X }
C {devices/lab_pin.sym} 55000 -5390 0 0 {name=p54849 lab=_62541_/B }
C {devices/lab_pin.sym} 55000 -5350 0 0 {name=p54850 lab=_62498_/C }
C {devices/lab_pin.sym} 55120 -5390 0 1 {name=p54851 lab=_62498_/Y }
C {sky130_stdcells/nor3_4.sym} 55060 -5390 0 0 {name=X_62498_ }
C {devices/lab_pin.sym} 55020 -5250 0 0 {name=p54852 lab=_57776_/A }
C {devices/lab_pin.sym} 55100 -5250 0 1 {name=p54853 lab=_67025_/X }
C {sky130_stdcells/buf_2.sym} 55060 -5250 0 0 {name=X_67025_ }
C {devices/lab_pin.sym} 54980 -5150 0 0 {name=p54854 lab=_85859_/Q }
C {devices/lab_pin.sym} 54980 -5110 0 0 {name=p54855 lab=_52239_/X }
C {devices/lab_pin.sym} 54980 -5070 0 0 {name=p54856 lab=_52250_/Y }
C {devices/lab_pin.sym} 55140 -5110 0 1 {name=p54857 lab=_52251_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -5110 0 0 {name=X_52251_ }
C {devices/lab_pin.sym} 54970 -4970 0 0 {name=p54858 lab=_85884_/CLK }
C {devices/lab_pin.sym} 54970 -4950 0 0 {name=p54859 lab=_83071_/D }
C {devices/lab_pin.sym} 55150 -4970 0 1 {name=p54860 lab=_83071_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -4960 0 0 {name=X_83071_ }
C {devices/lab_pin.sym} 55000 -4850 0 0 {name=p54861 lab=_64250_/A }
C {devices/lab_pin.sym} 55000 -4810 0 0 {name=p54862 lab=_84855_/Q }
C {devices/lab_pin.sym} 55000 -4770 0 0 {name=p54863 lab=_64250_/C }
C {devices/lab_pin.sym} 55120 -4810 0 1 {name=p54864 lab=_64237_/Y }
C {sky130_stdcells/nand3_4.sym} 55060 -4810 0 0 {name=X_64237_ }
C {devices/lab_pin.sym} 55000 -4690 0 0 {name=p54865 lab=_61429_/A }
C {devices/lab_pin.sym} 55000 -4650 0 0 {name=p54866 lab=_61448_/X }
C {devices/lab_pin.sym} 55000 -4610 0 0 {name=p54867 lab=_61429_/C }
C {devices/lab_pin.sym} 55120 -4650 0 1 {name=p54868 lab=_61449_/Y }
C {sky130_stdcells/nand3_4.sym} 55060 -4650 0 0 {name=X_61449_ }
C {devices/lab_pin.sym} 55000 -4520 0 0 {name=p54869 lab=_80281_/Y }
C {devices/lab_pin.sym} 55000 -4480 0 0 {name=p54870 lab=_80282_/Y }
C {devices/lab_pin.sym} 55120 -4500 0 1 {name=p54871 lab=_80283_/Y }
C {sky130_stdcells/nor2_4.sym} 55060 -4500 0 0 {name=X_80283_ }
C {devices/lab_pin.sym} 55020 -4370 0 0 {name=p54872 lab=_51149_/A }
C {devices/lab_pin.sym} 55100 -4370 0 1 {name=p54873 lab=_51203_/B }
C {sky130_stdcells/buf_2.sym} 55060 -4370 0 0 {name=X_51202_ }
C {devices/lab_pin.sym} 54970 -4250 0 0 {name=p54874 lab=_81990_/CLK }
C {devices/lab_pin.sym} 54970 -4230 0 0 {name=p54875 lab=_77768_/B }
C {devices/lab_pin.sym} 55150 -4250 0 1 {name=p54876 lab=_82022_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -4240 0 0 {name=X_82022_ }
C {devices/lab_pin.sym} 55000 -4130 0 0 {name=p54877 lab=_52182_/A }
C {devices/lab_pin.sym} 55000 -4090 0 0 {name=p54878 lab=_52194_/B }
C {devices/lab_pin.sym} 55000 -4050 0 0 {name=p54879 lab=_52182_/C }
C {devices/lab_pin.sym} 55120 -4090 0 1 {name=p54880 lab=_52182_/X }
C {sky130_stdcells/and3_4.sym} 55060 -4090 0 0 {name=X_52182_ }
C {devices/lab_pin.sym} 55000 -3980 0 0 {name=p54881 lab=_61673_/B }
C {devices/lab_pin.sym} 55000 -3940 0 0 {name=p54882 lab=_64179_/B }
C {devices/lab_pin.sym} 55000 -3900 0 0 {name=p54883 lab=_64179_/C }
C {devices/lab_pin.sym} 55000 -3860 0 0 {name=p54884 lab=_64179_/D }
C {devices/lab_pin.sym} 55120 -3920 0 1 {name=p54885 lab=_64168_/Y }
C {sky130_stdcells/nand4_4.sym} 55060 -3920 0 0 {name=X_64168_ }
C {devices/lab_pin.sym} 55020 -3770 0 0 {name=p54886 lab=clkbuf_9_199_0_CLK/X }
C {devices/lab_pin.sym} 55100 -3770 0 1 {name=p54887 lab=_82822_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55060 -3770 0 0 {name=Xclkbuf_10_398_0_CLK }
C {devices/lab_pin.sym} 54980 -3670 0 0 {name=p54888 lab=_51131_/Y }
C {devices/lab_pin.sym} 54980 -3630 0 0 {name=p54889 lab=_51119_/X }
C {devices/lab_pin.sym} 54980 -3590 0 0 {name=p54890 lab=_51132_/X }
C {devices/lab_pin.sym} 55140 -3630 0 1 {name=p54891 lab=_86068_/D }
C {sky130_stdcells/a21oi_4.sym} 55060 -3630 0 0 {name=X_51133_ }
C {devices/lab_pin.sym} 54980 -3530 0 0 {name=p54892 lab=_58543_/Y }
C {devices/lab_pin.sym} 54980 -3490 0 0 {name=p54893 lab=_63073_/X }
C {devices/lab_pin.sym} 54980 -3450 0 0 {name=p54894 lab=_63117_/X }
C {devices/lab_pin.sym} 54980 -3410 0 0 {name=p54895 lab=_58320_/A }
C {devices/lab_pin.sym} 54980 -3370 0 0 {name=p54896 lab=_63118_/X }
C {devices/lab_pin.sym} 55140 -3450 0 1 {name=p54897 lab=_63119_/Y }
C {sky130_stdcells/o32ai_4.sym} 55060 -3450 0 0 {name=X_63119_ }
C {devices/lab_pin.sym} 54970 -3290 0 0 {name=p54898 lab=_87990_/CLK }
C {devices/lab_pin.sym} 54970 -3270 0 0 {name=p54899 lab=_45978_/X }
C {devices/lab_pin.sym} 55150 -3290 0 1 {name=p54900 lab=_86830_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -3280 0 0 {name=X_86830_ }
C {devices/lab_pin.sym} 54980 -3170 0 0 {name=p54901 lab=_56943_/X }
C {devices/lab_pin.sym} 54980 -3130 0 0 {name=p54902 lab=_56988_/Y }
C {devices/lab_pin.sym} 54980 -3090 0 0 {name=p54903 lab=_56989_/Y }
C {devices/lab_pin.sym} 55140 -3130 0 1 {name=p54904 lab=_85104_/D }
C {sky130_stdcells/o21ai_4.sym} 55060 -3130 0 0 {name=X_56990_ }
C {devices/lab_pin.sym} 55020 -2990 0 0 {name=p54905 lab=_66180_/A }
C {devices/lab_pin.sym} 55100 -2990 0 1 {name=p54906 lab=_68976_/X }
C {sky130_stdcells/buf_2.sym} 55060 -2990 0 0 {name=X_68976_ }
C {devices/lab_pin.sym} 54980 -2910 0 0 {name=p54907 lab=_64094_/X }
C {devices/lab_pin.sym} 54980 -2870 0 0 {name=p54908 lab=_64048_/X }
C {devices/lab_pin.sym} 54980 -2830 0 0 {name=p54909 lab=_64095_/Y }
C {devices/lab_pin.sym} 54980 -2790 0 0 {name=p54910 lab=_64096_/Y }
C {devices/lab_pin.sym} 54980 -2760 0 0 {name=p54911 lab=_64098_/X }
C {devices/lab_pin.sym} 55140 -2830 0 1 {name=p54912 lab=_64099_/X }
C {sky130_stdcells/a41o_4.sym} 55060 -2830 0 0 {name=X_64099_ }
C {devices/lab_pin.sym} 54980 -2690 0 0 {name=p54913 lab=_86080_/Q }
C {devices/lab_pin.sym} 54980 -2650 0 0 {name=p54914 lab=_51047_/X }
C {devices/lab_pin.sym} 54980 -2610 0 0 {name=p54915 lab=_51063_/Y }
C {devices/lab_pin.sym} 55140 -2650 0 1 {name=p54916 lab=_51064_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -2650 0 0 {name=X_51064_ }
C {devices/lab_pin.sym} 54980 -2540 0 0 {name=p54917 lab=_56390_/C }
C {devices/lab_pin.sym} 54980 -2500 0 0 {name=p54918 lab=_55641_/A }
C {devices/lab_pin.sym} 54980 -2460 0 0 {name=p54919 lab=_55610_/X }
C {devices/lab_pin.sym} 54980 -2420 0 0 {name=p54920 lab=_55940_/X }
C {devices/lab_pin.sym} 55140 -2480 0 1 {name=p54921 lab=_55941_/X }
C {sky130_stdcells/a211o_4.sym} 55060 -2480 0 0 {name=X_55941_ }
C {devices/lab_pin.sym} 55000 -2340 0 0 {name=p54922 lab=_67972_/A }
C {devices/lab_pin.sym} 55000 -2300 0 0 {name=p54923 lab=_67927_/B }
C {devices/lab_pin.sym} 55120 -2320 0 1 {name=p54924 lab=_67927_/X }
C {sky130_stdcells/and2_4.sym} 55060 -2320 0 0 {name=X_67927_ }
C {devices/lab_pin.sym} 54970 -2190 0 0 {name=p54925 lab=_84287_/CLK }
C {devices/lab_pin.sym} 54970 -2170 0 0 {name=p54926 lab=_46205_/Y }
C {devices/lab_pin.sym} 55150 -2190 0 1 {name=p54927 lab=_57701_/A }
C {sky130_stdcells/dfxtp_4.sym} 55060 -2180 0 0 {name=X_86761_ }
C {devices/lab_pin.sym} 54970 -2050 0 0 {name=p54928 lab=_83973_/CLK }
C {devices/lab_pin.sym} 54970 -2030 0 0 {name=p54929 lab=_83973_/D }
C {devices/lab_pin.sym} 55150 -2050 0 1 {name=p54930 lab=_83973_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -2040 0 0 {name=X_83973_ }
C {devices/lab_pin.sym} 55020 -1910 0 0 {name=p54931 lab=clkbuf_9_160_0_CLK/X }
C {devices/lab_pin.sym} 55100 -1910 0 1 {name=p54932 lab=_85727_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55060 -1910 0 0 {name=Xclkbuf_10_321_0_CLK }
C {devices/lab_pin.sym} 54980 -1810 0 0 {name=p54933 lab=_86281_/Q }
C {devices/lab_pin.sym} 54980 -1770 0 0 {name=p54934 lab=_50012_/X }
C {devices/lab_pin.sym} 54980 -1730 0 0 {name=p54935 lab=_50014_/Y }
C {devices/lab_pin.sym} 55140 -1770 0 1 {name=p54936 lab=_50015_/Y }
C {sky130_stdcells/o21ai_4.sym} 55060 -1770 0 0 {name=X_50015_ }
C {devices/lab_pin.sym} 54970 -1630 0 0 {name=p54937 lab=_85712_/CLK }
C {devices/lab_pin.sym} 54970 -1610 0 0 {name=p54938 lab=_53020_/Y }
C {devices/lab_pin.sym} 55150 -1630 0 1 {name=p54939 lab=_85712_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -1620 0 0 {name=X_85712_ }
C {devices/lab_pin.sym} 55000 -1500 0 0 {name=p54940 lab=_58660_/A }
C {devices/lab_pin.sym} 55000 -1460 0 0 {name=p54941 lab=_58649_/B }
C {devices/lab_pin.sym} 55120 -1480 0 1 {name=p54942 lab=_58660_/Y }
C {sky130_stdcells/nor2_4.sym} 55060 -1480 0 0 {name=X_58660_ }
C {devices/lab_pin.sym} 54970 -1350 0 0 {name=p54943 lab=_82924_/CLK }
C {devices/lab_pin.sym} 54970 -1330 0 0 {name=p54944 lab=_78202_/X }
C {devices/lab_pin.sym} 55150 -1350 0 1 {name=p54945 lab=_82924_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55060 -1340 0 0 {name=X_82924_ }
C {devices/lab_pin.sym} 55000 -1220 0 0 {name=p54946 lab=_55872_/A }
C {devices/lab_pin.sym} 55000 -1180 0 0 {name=p54947 lab=_55871_/X }
C {devices/lab_pin.sym} 55120 -1200 0 1 {name=p54948 lab=_55873_/A }
C {sky130_stdcells/and2_4.sym} 55060 -1200 0 0 {name=X_55872_ }
C {devices/lab_pin.sym} 55020 -1070 0 0 {name=p54949 lab=_68442_/A }
C {devices/lab_pin.sym} 55100 -1070 0 1 {name=p54950 lab=_67858_/X }
C {sky130_stdcells/buf_2.sym} 55060 -1070 0 0 {name=X_67858_ }
C {devices/lab_pin.sym} 54970 -950 0 0 {name=p54951 lab=_86372_/CLK }
C {devices/lab_pin.sym} 54970 -930 0 0 {name=p54952 lab=_46897_/Y }
C {devices/lab_pin.sym} 55150 -950 0 1 {name=p54953 lab=_58942_/A }
C {sky130_stdcells/dfxtp_4.sym} 55060 -940 0 0 {name=X_86692_ }
C {devices/lab_pin.sym} 55020 -810 0 0 {name=p54954 lab=clkbuf_9_475_0_CLK/X }
C {devices/lab_pin.sym} 55100 -810 0 1 {name=p54955 lab=_86535_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55060 -810 0 0 {name=Xclkbuf_10_951_0_CLK }
C {devices/lab_pin.sym} 55000 -700 0 0 {name=p54956 lab=_57630_/A }
C {devices/lab_pin.sym} 55000 -660 0 0 {name=p54957 lab=_48081_/Y }
C {devices/lab_pin.sym} 55120 -680 0 1 {name=p54958 lab=_57611_/Y }
C {sky130_stdcells/nand2_4.sym} 55060 -680 0 0 {name=X_57611_ }
C {devices/lab_pin.sym} 55920 -42160 0 0 {name=p54959 lab=_54823_/A }
C {devices/lab_pin.sym} 55920 -42120 0 0 {name=p54960 lab=_47582_/A }
C {devices/lab_pin.sym} 56040 -42140 0 1 {name=p54961 lab=_54823_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -42140 0 0 {name=X_54823_ }
C {devices/lab_pin.sym} 55900 -42040 0 0 {name=p54962 lab=_87881_/Q }
C {devices/lab_pin.sym} 55900 -42000 0 0 {name=p54963 lab=_66759_/X }
C {devices/lab_pin.sym} 55900 -41960 0 0 {name=p54964 lab=_66807_/X }
C {devices/lab_pin.sym} 55900 -41920 0 0 {name=p54965 lab=_66808_/X }
C {devices/lab_pin.sym} 56060 -41980 0 1 {name=p54966 lab=_66809_/X }
C {sky130_stdcells/a211o_4.sym} 55980 -41980 0 0 {name=X_66809_ }
C {devices/lab_pin.sym} 55890 -41830 0 0 {name=p54967 lab=_85643_/CLK }
C {devices/lab_pin.sym} 55890 -41810 0 0 {name=p54968 lab=_85643_/D }
C {devices/lab_pin.sym} 56070 -41830 0 1 {name=p54969 lab=_85643_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -41820 0 0 {name=X_85643_ }
C {devices/lab_pin.sym} 55940 -41690 0 0 {name=p54970 lab=_58703_/A }
C {devices/lab_pin.sym} 56020 -41690 0 1 {name=p54971 lab=_58591_/X }
C {sky130_stdcells/buf_2.sym} 55980 -41690 0 0 {name=X_58591_ }
C {devices/lab_pin.sym} 55890 -41570 0 0 {name=p54972 lab=_82855_/CLK }
C {devices/lab_pin.sym} 55890 -41550 0 0 {name=p54973 lab=_78108_/B }
C {devices/lab_pin.sym} 56070 -41570 0 1 {name=p54974 lab=_82855_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -41560 0 0 {name=X_82855_ }
C {devices/lab_pin.sym} 55940 -41430 0 0 {name=p54975 lab=_67312_/X }
C {devices/lab_pin.sym} 56020 -41430 0 1 {name=p54976 lab=_67789_/X }
C {sky130_stdcells/buf_2.sym} 55980 -41430 0 0 {name=X_67789_ }
C {devices/lab_pin.sym} 55940 -41310 0 0 {name=p54977 lab=clkbuf_9_443_0_CLK/A }
C {devices/lab_pin.sym} 56020 -41310 0 1 {name=p54978 lab=clkbuf_9_442_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 55980 -41310 0 0 {name=Xclkbuf_9_442_0_CLK }
C {devices/lab_pin.sym} 55900 -41210 0 0 {name=p54979 lab=_84982_/Q }
C {devices/lab_pin.sym} 55900 -41170 0 0 {name=p54980 lab=_57527_/X }
C {devices/lab_pin.sym} 55900 -41130 0 0 {name=p54981 lab=_57541_/Y }
C {devices/lab_pin.sym} 56060 -41170 0 1 {name=p54982 lab=_57542_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -41170 0 0 {name=X_57542_ }
C {devices/lab_pin.sym} 55890 -41030 0 0 {name=p54983 lab=_81296_/CLK }
C {devices/lab_pin.sym} 55890 -41010 0 0 {name=p54984 lab=_81614_/Q }
C {devices/lab_pin.sym} 56070 -41030 0 1 {name=p54985 lab=_81806_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -41020 0 0 {name=X_81806_ }
C {devices/lab_pin.sym} 55900 -40910 0 0 {name=p54986 lab=_69525_/X }
C {devices/lab_pin.sym} 55900 -40870 0 0 {name=p54987 lab=_69527_/X }
C {devices/lab_pin.sym} 55900 -40830 0 0 {name=p54988 lab=_69389_/X }
C {devices/lab_pin.sym} 56060 -40870 0 1 {name=p54989 lab=_69528_/Y }
C {sky130_stdcells/a21oi_4.sym} 55980 -40870 0 0 {name=X_69528_ }
C {devices/lab_pin.sym} 55890 -40730 0 0 {name=p54990 lab=_87859_/CLK }
C {devices/lab_pin.sym} 55890 -40710 0 0 {name=p54991 lab=_40643_/Y }
C {devices/lab_pin.sym} 56070 -40730 0 1 {name=p54992 lab=_68595_/B }
C {sky130_stdcells/dfxtp_4.sym} 55980 -40720 0 0 {name=X_88362_ }
C {devices/lab_pin.sym} 55940 -40590 0 0 {name=p54993 lab=_54672_/X }
C {devices/lab_pin.sym} 56020 -40590 0 1 {name=p54994 lab=_54775_/C }
C {sky130_stdcells/buf_2.sym} 55980 -40590 0 0 {name=X_54754_ }
C {devices/lab_pin.sym} 55890 -40470 0 0 {name=p54995 lab=_83564_/CLK }
C {devices/lab_pin.sym} 55890 -40450 0 0 {name=p54996 lab=_53760_/Y }
C {devices/lab_pin.sym} 56070 -40470 0 1 {name=p54997 lab=_85574_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -40460 0 0 {name=X_85574_ }
C {devices/lab_pin.sym} 55920 -40340 0 0 {name=p54998 lab=_51961_/X }
C {devices/lab_pin.sym} 55920 -40300 0 0 {name=p54999 lab=_50264_/B }
C {devices/lab_pin.sym} 56040 -40320 0 1 {name=p55000 lab=_51966_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -40320 0 0 {name=X_51966_ }
C {devices/lab_pin.sym} 55890 -40190 0 0 {name=p55001 lab=_82786_/CLK }
C {devices/lab_pin.sym} 55890 -40170 0 0 {name=p55002 lab=_82818_/Q }
C {devices/lab_pin.sym} 56070 -40190 0 1 {name=p55003 lab=_82786_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -40180 0 0 {name=X_82786_ }
C {devices/lab_pin.sym} 55940 -40050 0 0 {name=p55004 lab=clkbuf_9_168_0_CLK/X }
C {devices/lab_pin.sym} 56020 -40050 0 1 {name=p55005 lab=_86054_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55980 -40050 0 0 {name=Xclkbuf_10_336_0_CLK }
C {devices/lab_pin.sym} 55890 -39930 0 0 {name=p55006 lab=_86534_/CLK }
C {devices/lab_pin.sym} 55890 -39910 0 0 {name=p55007 lab=_43680_/X }
C {devices/lab_pin.sym} 56070 -39930 0 1 {name=p55008 lab=_72800_/A }
C {sky130_stdcells/dfxtp_4.sym} 55980 -39920 0 0 {name=X_87313_ }
C {devices/lab_pin.sym} 55920 -39800 0 0 {name=p55009 lab=_53611_/X }
C {devices/lab_pin.sym} 55920 -39760 0 0 {name=p55010 lab=_48550_/Y }
C {devices/lab_pin.sym} 56040 -39780 0 1 {name=p55011 lab=_53705_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -39780 0 0 {name=X_53705_ }
C {devices/lab_pin.sym} 55890 -39650 0 0 {name=p55012 lab=_84292_/CLK }
C {devices/lab_pin.sym} 55890 -39630 0 0 {name=p55013 lab=_61058_/X }
C {devices/lab_pin.sym} 56070 -39650 0 1 {name=p55014 lab=_61057_/C }
C {sky130_stdcells/dfxtp_4.sym} 55980 -39640 0 0 {name=X_84525_ }
C {devices/lab_pin.sym} 55900 -39530 0 0 {name=p55015 lab=_86107_/Q }
C {devices/lab_pin.sym} 55900 -39490 0 0 {name=p55016 lab=_50910_/X }
C {devices/lab_pin.sym} 55900 -39450 0 0 {name=p55017 lab=_50916_/Y }
C {devices/lab_pin.sym} 56060 -39490 0 1 {name=p55018 lab=_50917_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -39490 0 0 {name=X_50917_ }
C {devices/lab_pin.sym} 55920 -39360 0 0 {name=p55019 lab=_58273_/A }
C {devices/lab_pin.sym} 55920 -39320 0 0 {name=p55020 lab=_57473_/B }
C {devices/lab_pin.sym} 56040 -39340 0 1 {name=p55021 lab=_57473_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -39340 0 0 {name=X_57473_ }
C {devices/lab_pin.sym} 55890 -39210 0 0 {name=p55022 lab=_86807_/CLK }
C {devices/lab_pin.sym} 55890 -39190 0 0 {name=p55023 lab=_81737_/D }
C {devices/lab_pin.sym} 56070 -39210 0 1 {name=p55024 lab=_41414_/A }
C {sky130_stdcells/dfxtp_4.sym} 55980 -39200 0 0 {name=X_81737_ }
C {devices/lab_pin.sym} 55920 -39080 0 0 {name=p55025 lab=_69322_/A }
C {devices/lab_pin.sym} 55920 -39040 0 0 {name=p55026 lab=_88284_/Q }
C {devices/lab_pin.sym} 56040 -39060 0 1 {name=p55027 lab=_69459_/X }
C {sky130_stdcells/and2_4.sym} 55980 -39060 0 0 {name=X_69459_ }
C {devices/lab_pin.sym} 55890 -38930 0 0 {name=p55028 lab=_87253_/CLK }
C {devices/lab_pin.sym} 55890 -38910 0 0 {name=p55029 lab=_41018_/Y }
C {devices/lab_pin.sym} 56070 -38930 0 1 {name=p55030 lab=_88293_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -38920 0 0 {name=X_88293_ }
C {devices/lab_pin.sym} 55920 -38820 0 0 {name=p55031 lab=_54674_/A }
C {devices/lab_pin.sym} 55920 -38780 0 0 {name=p55032 lab=_54707_/B }
C {devices/lab_pin.sym} 55920 -38740 0 0 {name=p55033 lab=_54674_/C }
C {devices/lab_pin.sym} 55920 -38700 0 0 {name=p55034 lab=_54685_/D }
C {devices/lab_pin.sym} 56040 -38760 0 1 {name=p55035 lab=_54685_/X }
C {sky130_stdcells/and4_4.sym} 55980 -38760 0 0 {name=X_54685_ }
C {devices/lab_pin.sym} 55940 -38610 0 0 {name=p55036 lab=clkbuf_9_483_0_CLK/X }
C {devices/lab_pin.sym} 56020 -38610 0 1 {name=p55037 lab=_83304_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55980 -38610 0 0 {name=Xclkbuf_10_966_0_CLK }
C {devices/lab_pin.sym} 55940 -38490 0 0 {name=p55038 lab=_51843_/A }
C {devices/lab_pin.sym} 56020 -38490 0 1 {name=p55039 lab=_51898_/B }
C {sky130_stdcells/buf_2.sym} 55980 -38490 0 0 {name=X_51897_ }
C {devices/lab_pin.sym} 55920 -38380 0 0 {name=p55040 lab=_59154_/A }
C {devices/lab_pin.sym} 55920 -38340 0 0 {name=p55041 lab=_86352_/Q }
C {devices/lab_pin.sym} 56040 -38360 0 1 {name=p55042 lab=_59212_/Y }
C {sky130_stdcells/nor2_4.sym} 55980 -38360 0 0 {name=X_59212_ }
C {devices/lab_pin.sym} 55920 -38250 0 0 {name=p55043 lab=_56431_/A }
C {devices/lab_pin.sym} 55920 -38210 0 0 {name=p55044 lab=_56433_/B }
C {devices/lab_pin.sym} 55920 -38170 0 0 {name=p55045 lab=_56424_/C }
C {devices/lab_pin.sym} 56040 -38210 0 1 {name=p55046 lab=_56424_/Y }
C {sky130_stdcells/nand3_4.sym} 55980 -38210 0 0 {name=X_56424_ }
C {devices/lab_pin.sym} 55890 -38070 0 0 {name=p55047 lab=_88012_/CLK }
C {devices/lab_pin.sym} 55890 -38050 0 0 {name=p55048 lab=_43834_/X }
C {devices/lab_pin.sym} 56070 -38070 0 1 {name=p55049 lab=_68546_/B }
C {sky130_stdcells/dfxtp_4.sym} 55980 -38060 0 0 {name=X_87244_ }
C {devices/lab_pin.sym} 55900 -37950 0 0 {name=p55050 lab=_41588_/X }
C {devices/lab_pin.sym} 55900 -37910 0 0 {name=p55051 lab=_41304_/A }
C {devices/lab_pin.sym} 55900 -37870 0 0 {name=p55052 lab=_41649_/X }
C {devices/lab_pin.sym} 56060 -37910 0 1 {name=p55053 lab=_41651_/A }
C {sky130_stdcells/o21ai_4.sym} 55980 -37910 0 0 {name=X_41650_ }
C {devices/lab_pin.sym} 55920 -37790 0 0 {name=p55054 lab=_53636_/A }
C {devices/lab_pin.sym} 55920 -37750 0 0 {name=p55055 lab=_53658_/B }
C {devices/lab_pin.sym} 55920 -37710 0 0 {name=p55056 lab=_53667_/C }
C {devices/lab_pin.sym} 56040 -37750 0 1 {name=p55057 lab=_53636_/X }
C {sky130_stdcells/and3_4.sym} 55980 -37750 0 0 {name=X_53636_ }
C {devices/lab_pin.sym} 55900 -37630 0 0 {name=p55058 lab=_72467_/Y }
C {devices/lab_pin.sym} 55900 -37590 0 0 {name=p55059 lab=_72469_/Y }
C {devices/lab_pin.sym} 55900 -37550 0 0 {name=p55060 lab=_57718_/A }
C {devices/lab_pin.sym} 56060 -37590 0 1 {name=p55061 lab=_72470_/X }
C {sky130_stdcells/a21o_4.sym} 55980 -37590 0 0 {name=X_72470_ }
C {devices/lab_pin.sym} 55890 -37450 0 0 {name=p55062 lab=_84564_/CLK }
C {devices/lab_pin.sym} 55890 -37430 0 0 {name=p55063 lab=_61753_/Y }
C {devices/lab_pin.sym} 56070 -37450 0 1 {name=p55064 lab=_78079_/B }
C {sky130_stdcells/dfxtp_4.sym} 55980 -37440 0 0 {name=X_84456_ }
C {devices/lab_pin.sym} 55900 -37330 0 0 {name=p55065 lab=_86121_/Q }
C {devices/lab_pin.sym} 55900 -37290 0 0 {name=p55066 lab=_50804_/X }
C {devices/lab_pin.sym} 55900 -37250 0 0 {name=p55067 lab=_50847_/Y }
C {devices/lab_pin.sym} 56060 -37290 0 1 {name=p55068 lab=_50848_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -37290 0 0 {name=X_50848_ }
C {devices/lab_pin.sym} 55890 -37150 0 0 {name=p55069 lab=_81668_/CLK }
C {devices/lab_pin.sym} 55890 -37130 0 0 {name=p55070 lab=_79932_/Y }
C {devices/lab_pin.sym} 56070 -37150 0 1 {name=p55071 lab=_81668_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -37140 0 0 {name=X_81668_ }
C {devices/lab_pin.sym} 55940 -37010 0 0 {name=p55072 lab=clkbuf_8_228_0_CLK/X }
C {devices/lab_pin.sym} 56020 -37010 0 1 {name=p55073 lab=clkbuf_9_457_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 55980 -37010 0 0 {name=Xclkbuf_9_457_0_CLK }
C {devices/lab_pin.sym} 55940 -36890 0 0 {name=p55074 lab=_49140_/B }
C {devices/lab_pin.sym} 56020 -36890 0 1 {name=p55075 lab=_40601_/X }
C {sky130_stdcells/buf_2.sym} 55980 -36890 0 0 {name=X_40601_ }
C {devices/lab_pin.sym} 55940 -36770 0 0 {name=p55076 lab=_59143_/A }
C {devices/lab_pin.sym} 56020 -36770 0 1 {name=p55077 lab=_59143_/Y }
C {sky130_stdcells/inv_2.sym} 55980 -36770 0 0 {name=X_59143_ }
C {devices/lab_pin.sym} 55940 -36650 0 0 {name=p55078 lab=_71418_/B }
C {devices/lab_pin.sym} 56020 -36650 0 1 {name=p55079 lab=_71432_/B }
C {sky130_stdcells/buf_2.sym} 55980 -36650 0 0 {name=X_71421_ }
C {devices/lab_pin.sym} 55890 -36530 0 0 {name=p55080 lab=_83380_/CLK }
C {devices/lab_pin.sym} 55890 -36510 0 0 {name=p55081 lab=_83407_/D }
C {devices/lab_pin.sym} 56070 -36530 0 1 {name=p55082 lab=_83407_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -36520 0 0 {name=X_83407_ }
C {devices/lab_pin.sym} 55900 -36410 0 0 {name=p55083 lab=_56144_/X }
C {devices/lab_pin.sym} 55900 -36370 0 0 {name=p55084 lab=_56350_/X }
C {devices/lab_pin.sym} 55900 -36330 0 0 {name=p55085 lab=_56354_/Y }
C {devices/lab_pin.sym} 56060 -36370 0 1 {name=p55086 lab=_56355_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -36370 0 0 {name=X_56355_ }
C {devices/lab_pin.sym} 55900 -36250 0 0 {name=p55087 lab=_80607_/A }
C {devices/lab_pin.sym} 55900 -36210 0 0 {name=p55088 lab=_80607_/B }
C {devices/lab_pin.sym} 55900 -36170 0 0 {name=p55089 lab=_80618_/X }
C {devices/lab_pin.sym} 56060 -36210 0 1 {name=p55090 lab=_80619_/X }
C {sky130_stdcells/a21o_4.sym} 55980 -36210 0 0 {name=X_80619_ }
C {devices/lab_pin.sym} 55940 -36070 0 0 {name=p55091 lab=_41486_/A }
C {devices/lab_pin.sym} 56020 -36070 0 1 {name=p55092 lab=_41581_/X }
C {sky130_stdcells/buf_2.sym} 55980 -36070 0 0 {name=X_41581_ }
C {devices/lab_pin.sym} 55890 -35950 0 0 {name=p55093 lab=_87178_/CLK }
C {devices/lab_pin.sym} 55890 -35930 0 0 {name=p55094 lab=_44278_/Y }
C {devices/lab_pin.sym} 56070 -35950 0 1 {name=p55095 lab=_43986_/A }
C {sky130_stdcells/dfxtp_4.sym} 55980 -35940 0 0 {name=X_87175_ }
C {devices/lab_pin.sym} 55920 -35820 0 0 {name=p55096 lab=_53622_/A }
C {devices/lab_pin.sym} 55920 -35780 0 0 {name=p55097 lab=_53567_/B }
C {devices/lab_pin.sym} 56040 -35800 0 1 {name=p55098 lab=_53567_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -35800 0 0 {name=X_53567_ }
C {devices/lab_pin.sym} 55890 -35670 0 0 {name=p55099 lab=_84503_/CLK }
C {devices/lab_pin.sym} 55890 -35650 0 0 {name=p55100 lab=_84387_/D }
C {devices/lab_pin.sym} 56070 -35670 0 1 {name=p55101 lab=_84387_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -35660 0 0 {name=X_84387_ }
C {devices/lab_pin.sym} 55920 -35540 0 0 {name=p55102 lab=_50764_/A }
C {devices/lab_pin.sym} 55920 -35500 0 0 {name=p55103 lab=_53993_/B }
C {devices/lab_pin.sym} 56040 -35520 0 1 {name=p55104 lab=_50779_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -35520 0 0 {name=X_50779_ }
C {devices/lab_pin.sym} 55890 -35390 0 0 {name=p55105 lab=_81473_/CLK }
C {devices/lab_pin.sym} 55890 -35370 0 0 {name=p55106 lab=_65466_/C }
C {devices/lab_pin.sym} 56070 -35390 0 1 {name=p55107 lab=_81599_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -35380 0 0 {name=X_81599_ }
C {devices/lab_pin.sym} 55900 -35290 0 0 {name=p55108 lab=_43316_/X }
C {devices/lab_pin.sym} 55900 -35250 0 0 {name=p55109 lab=_43319_/X }
C {devices/lab_pin.sym} 55900 -35210 0 0 {name=p55110 lab=_41245_/X }
C {devices/lab_pin.sym} 55900 -35170 0 0 {name=p55111 lab=_87483_/Q }
C {devices/lab_pin.sym} 55900 -35130 0 0 {name=p55112 lab=_43308_/X }
C {devices/lab_pin.sym} 56060 -35210 0 1 {name=p55113 lab=_43320_/Y }
C {sky130_stdcells/o32ai_4.sym} 55980 -35210 0 0 {name=X_43320_ }
C {devices/lab_pin.sym} 55940 -35050 0 0 {name=p55114 lab=_55177_/A }
C {devices/lab_pin.sym} 56020 -35050 0 1 {name=p55115 lab=_55306_/X }
C {sky130_stdcells/buf_2.sym} 55980 -35050 0 0 {name=X_55306_ }
C {devices/lab_pin.sym} 55940 -34930 0 0 {name=p55116 lab=_74140_/A }
C {devices/lab_pin.sym} 56020 -34930 0 1 {name=p55117 lab=_74202_/A }
C {sky130_stdcells/buf_2.sym} 55980 -34930 0 0 {name=X_74140_ }
C {devices/lab_pin.sym} 55890 -34810 0 0 {name=p55118 lab=_86030_/CLK }
C {devices/lab_pin.sym} 55890 -34790 0 0 {name=p55119 lab=_86126_/D }
C {devices/lab_pin.sym} 56070 -34810 0 1 {name=p55120 lab=_86126_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -34800 0 0 {name=X_86126_ }
C {devices/lab_pin.sym} 55920 -34680 0 0 {name=p55121 lab=_52518_/A }
C {devices/lab_pin.sym} 55920 -34640 0 0 {name=p55122 lab=_46464_/Y }
C {devices/lab_pin.sym} 56040 -34660 0 1 {name=p55123 lab=_52518_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -34660 0 0 {name=X_52518_ }
C {devices/lab_pin.sym} 55940 -34530 0 0 {name=p55124 lab=_40531_/X }
C {devices/lab_pin.sym} 56020 -34530 0 1 {name=p55125 lab=_40532_/X }
C {sky130_stdcells/buf_2.sym} 55980 -34530 0 0 {name=X_40532_ }
C {devices/lab_pin.sym} 55940 -34410 0 0 {name=p55126 lab=_70959_/C }
C {devices/lab_pin.sym} 56020 -34410 0 1 {name=p55127 lab=_71429_/A }
C {sky130_stdcells/buf_2.sym} 55980 -34410 0 0 {name=X_71352_ }
C {devices/lab_pin.sym} 55900 -34310 0 0 {name=p55128 lab=_59073_/X }
C {devices/lab_pin.sym} 55900 -34270 0 0 {name=p55129 lab=_85755_/Q }
C {devices/lab_pin.sym} 55900 -34230 0 0 {name=p55130 lab=_59037_/X }
C {devices/lab_pin.sym} 56060 -34270 0 1 {name=p55131 lab=_59074_/X }
C {sky130_stdcells/o21a_4.sym} 55980 -34270 0 0 {name=X_59074_ }
C {devices/lab_pin.sym} 55890 -34130 0 0 {name=p55132 lab=_83338_/CLK }
C {devices/lab_pin.sym} 55890 -34110 0 0 {name=p55133 lab=_83338_/D }
C {devices/lab_pin.sym} 56070 -34130 0 1 {name=p55134 lab=_83338_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -34120 0 0 {name=X_83338_ }
C {devices/lab_pin.sym} 55940 -33990 0 0 {name=p55135 lab=_56347_/A }
C {devices/lab_pin.sym} 56020 -33990 0 1 {name=p55136 lab=_56368_/A }
C {sky130_stdcells/buf_2.sym} 55980 -33990 0 0 {name=X_56286_ }
C {devices/lab_pin.sym} 55940 -33870 0 0 {name=p55137 lab=_53696_/A }
C {devices/lab_pin.sym} 56020 -33870 0 1 {name=p55138 lab=_53498_/X }
C {sky130_stdcells/buf_2.sym} 55980 -33870 0 0 {name=X_53498_ }
C {devices/lab_pin.sym} 55940 -33750 0 0 {name=p55139 lab=_70337_/A }
C {devices/lab_pin.sym} 56020 -33750 0 1 {name=p55140 lab=_70303_/X }
C {sky130_stdcells/buf_2.sym} 55980 -33750 0 0 {name=X_70303_ }
C {devices/lab_pin.sym} 55940 -33630 0 0 {name=p55141 lab=_57896_/A }
C {devices/lab_pin.sym} 56020 -33630 0 1 {name=p55142 lab=_58025_/X }
C {sky130_stdcells/buf_2.sym} 55980 -33630 0 0 {name=X_58025_ }
C {devices/lab_pin.sym} 55900 -33550 0 0 {name=p55143 lab=_43241_/X }
C {devices/lab_pin.sym} 55900 -33510 0 0 {name=p55144 lab=_43244_/X }
C {devices/lab_pin.sym} 55900 -33470 0 0 {name=p55145 lab=_41054_/X }
C {devices/lab_pin.sym} 55900 -33430 0 0 {name=p55146 lab=_87518_/Q }
C {devices/lab_pin.sym} 55900 -33390 0 0 {name=p55147 lab=_43250_/X }
C {devices/lab_pin.sym} 56060 -33470 0 1 {name=p55148 lab=_43251_/Y }
C {sky130_stdcells/o32ai_4.sym} 55980 -33470 0 0 {name=X_43251_ }
C {devices/lab_pin.sym} 55900 -33330 0 0 {name=p55149 lab=_55655_/A }
C {devices/lab_pin.sym} 55900 -33290 0 0 {name=p55150 lab=_55655_/B }
C {devices/lab_pin.sym} 55900 -33250 0 0 {name=p55151 lab=_83316_/Q }
C {devices/lab_pin.sym} 56060 -33290 0 1 {name=p55152 lab=_55237_/Y }
C {sky130_stdcells/a21oi_4.sym} 55980 -33290 0 0 {name=X_55237_ }
C {devices/lab_pin.sym} 55920 -33160 0 0 {name=p55153 lab=_74071_/A }
C {devices/lab_pin.sym} 55920 -33120 0 0 {name=p55154 lab=_73152_/X }
C {devices/lab_pin.sym} 56040 -33140 0 1 {name=p55155 lab=_74071_/Y }
C {sky130_stdcells/nor2_4.sym} 55980 -33140 0 0 {name=X_74071_ }
C {devices/lab_pin.sym} 55890 -33010 0 0 {name=p55156 lab=_85738_/CLK }
C {devices/lab_pin.sym} 55890 -32990 0 0 {name=p55157 lab=_51193_/Y }
C {devices/lab_pin.sym} 56070 -33010 0 1 {name=p55158 lab=_86057_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -33000 0 0 {name=X_86057_ }
C {devices/lab_pin.sym} 55940 -32870 0 0 {name=p55159 lab=_40931_/A }
C {devices/lab_pin.sym} 56020 -32870 0 1 {name=p55160 lab=_40463_/X }
C {sky130_stdcells/buf_2.sym} 55980 -32870 0 0 {name=X_40463_ }
C {devices/lab_pin.sym} 55900 -32770 0 0 {name=p55161 lab=_64743_/B }
C {devices/lab_pin.sym} 55900 -32730 0 0 {name=p55162 lab=_52422_/X }
C {devices/lab_pin.sym} 55900 -32690 0 0 {name=p55163 lab=_52448_/Y }
C {devices/lab_pin.sym} 56060 -32730 0 1 {name=p55164 lab=_52449_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -32730 0 0 {name=X_52449_ }
C {devices/lab_pin.sym} 55920 -32620 0 0 {name=p55165 lab=_71183_/A }
C {devices/lab_pin.sym} 55920 -32580 0 0 {name=p55166 lab=_71268_/A }
C {devices/lab_pin.sym} 55920 -32540 0 0 {name=p55167 lab=_71279_/C }
C {devices/lab_pin.sym} 55920 -32500 0 0 {name=p55168 lab=_71276_/D }
C {devices/lab_pin.sym} 56040 -32560 0 1 {name=p55169 lab=_71283_/Y }
C {sky130_stdcells/nand4_4.sym} 55980 -32560 0 0 {name=X_71283_ }
C {devices/lab_pin.sym} 55890 -32410 0 0 {name=p55170 lab=_85332_/CLK }
C {devices/lab_pin.sym} 55890 -32390 0 0 {name=p55171 lab=_83269_/D }
C {devices/lab_pin.sym} 56070 -32410 0 1 {name=p55172 lab=_83269_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -32400 0 0 {name=X_83269_ }
C {devices/lab_pin.sym} 55900 -32310 0 0 {name=p55173 lab=_42173_/X }
C {devices/lab_pin.sym} 55900 -32270 0 0 {name=p55174 lab=_42200_/X }
C {devices/lab_pin.sym} 55900 -32230 0 0 {name=p55175 lab=_41316_/X }
C {devices/lab_pin.sym} 55900 -32190 0 0 {name=p55176 lab=_87981_/Q }
C {devices/lab_pin.sym} 55900 -32150 0 0 {name=p55177 lab=_42201_/X }
C {devices/lab_pin.sym} 56060 -32230 0 1 {name=p55178 lab=_42203_/A }
C {sky130_stdcells/o32ai_4.sym} 55980 -32230 0 0 {name=X_42202_ }
C {devices/lab_pin.sym} 55900 -32090 0 0 {name=p55179 lab=_73020_/X }
C {devices/lab_pin.sym} 55900 -32050 0 0 {name=p55180 lab=_73021_/Y }
C {devices/lab_pin.sym} 55900 -32010 0 0 {name=p55181 lab=_72970_/X }
C {devices/lab_pin.sym} 56060 -32050 0 1 {name=p55182 lab=_73022_/Y }
C {sky130_stdcells/a21oi_4.sym} 55980 -32050 0 0 {name=X_73022_ }
C {devices/lab_pin.sym} 55890 -31910 0 0 {name=p55183 lab=_85040_/CLK }
C {devices/lab_pin.sym} 55890 -31890 0 0 {name=p55184 lab=_85008_/D }
C {devices/lab_pin.sym} 56070 -31910 0 1 {name=p55185 lab=_57414_/A }
C {sky130_stdcells/dfxtp_4.sym} 55980 -31900 0 0 {name=X_85008_ }
C {devices/lab_pin.sym} 55920 -31800 0 0 {name=p55186 lab=_70239_/A }
C {devices/lab_pin.sym} 55920 -31760 0 0 {name=p55187 lab=_70239_/B }
C {devices/lab_pin.sym} 55920 -31720 0 0 {name=p55188 lab=_83188_/Q }
C {devices/lab_pin.sym} 55920 -31680 0 0 {name=p55189 lab=_70239_/D }
C {devices/lab_pin.sym} 56040 -31740 0 1 {name=p55190 lab=_70234_/X }
C {sky130_stdcells/and4_4.sym} 55980 -31740 0 0 {name=X_70234_ }
C {devices/lab_pin.sym} 55900 -31610 0 0 {name=p55191 lab=_46450_/A }
C {devices/lab_pin.sym} 55900 -31570 0 0 {name=p55192 lab=_51340_/A }
C {devices/lab_pin.sym} 55900 -31530 0 0 {name=p55193 lab=_43182_/B1 }
C {devices/lab_pin.sym} 56060 -31570 0 1 {name=p55194 lab=_43182_/Y }
C {sky130_stdcells/a21oi_4.sym} 55980 -31570 0 0 {name=X_43182_ }
C {devices/lab_pin.sym} 55940 -31430 0 0 {name=p55195 lab=_55168_/A }
C {devices/lab_pin.sym} 56020 -31430 0 1 {name=p55196 lab=_55168_/X }
C {sky130_stdcells/buf_2.sym} 55980 -31430 0 0 {name=X_55168_ }
C {devices/lab_pin.sym} 55900 -31330 0 0 {name=p55197 lab=_41061_/A }
C {devices/lab_pin.sym} 55900 -31290 0 0 {name=p55198 lab=_82332_/Q }
C {devices/lab_pin.sym} 55900 -31250 0 0 {name=p55199 lab=_40393_/X }
C {devices/lab_pin.sym} 56060 -31290 0 1 {name=p55200 lab=_40394_/X }
C {sky130_stdcells/o21a_4.sym} 55980 -31290 0 0 {name=X_40394_ }
C {devices/lab_pin.sym} 55940 -31150 0 0 {name=p55201 lab=clkbuf_9_452_0_CLK/X }
C {devices/lab_pin.sym} 56020 -31150 0 1 {name=p55202 lab=_87859_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55980 -31150 0 0 {name=Xclkbuf_10_904_0_CLK }
C {devices/lab_pin.sym} 55920 -31060 0 0 {name=p55203 lab=_54123_/A }
C {devices/lab_pin.sym} 55920 -31020 0 0 {name=p55204 lab=_54123_/B }
C {devices/lab_pin.sym} 55920 -30980 0 0 {name=p55205 lab=_54118_/X }
C {devices/lab_pin.sym} 55920 -30940 0 0 {name=p55206 lab=_52948_/D }
C {devices/lab_pin.sym} 56040 -31000 0 1 {name=p55207 lab=_54119_/X }
C {sky130_stdcells/and4_4.sym} 55980 -31000 0 0 {name=X_54119_ }
C {devices/lab_pin.sym} 55900 -30880 0 0 {name=p55208 lab=_41121_/X }
C {devices/lab_pin.sym} 55900 -30840 0 0 {name=p55209 lab=_42125_/X }
C {devices/lab_pin.sym} 55900 -30800 0 0 {name=p55210 lab=_88018_/Q }
C {devices/lab_pin.sym} 55900 -30760 0 0 {name=p55211 lab=_42126_/X }
C {devices/lab_pin.sym} 56060 -30820 0 1 {name=p55212 lab=_88018_/D }
C {sky130_stdcells/a2bb2o_4.sym} 55980 -30820 0 0 {name=X_42133_ }
C {devices/lab_pin.sym} 55920 -30680 0 0 {name=p55213 lab=_77835_/B }
C {devices/lab_pin.sym} 55920 -30640 0 0 {name=p55214 lab=_77830_/B }
C {devices/lab_pin.sym} 56040 -30660 0 1 {name=p55215 lab=_77831_/B }
C {sky130_stdcells/xnor2_4.sym} 55980 -30660 0 0 {name=X_77830_ }
C {devices/lab_pin.sym} 55920 -30560 0 0 {name=p55216 lab=_70165_/A }
C {devices/lab_pin.sym} 55920 -30520 0 0 {name=p55217 lab=_70160_/X }
C {devices/lab_pin.sym} 55920 -30480 0 0 {name=p55218 lab=_70162_/X }
C {devices/lab_pin.sym} 55920 -30440 0 0 {name=p55219 lab=_70164_/X }
C {devices/lab_pin.sym} 56040 -30500 0 1 {name=p55220 lab=_70165_/Y }
C {sky130_stdcells/nand4_4.sym} 55980 -30500 0 0 {name=X_70165_ }
C {devices/lab_pin.sym} 55940 -30350 0 0 {name=p55221 lab=_46317_/A }
C {devices/lab_pin.sym} 56020 -30350 0 1 {name=p55222 lab=_48044_/A }
C {sky130_stdcells/buf_2.sym} 55980 -30350 0 0 {name=X_47990_ }
C {devices/lab_pin.sym} 55940 -30230 0 0 {name=p55223 lab=_47838_/X }
C {devices/lab_pin.sym} 56020 -30230 0 1 {name=p55224 lab=_55118_/A }
C {sky130_stdcells/buf_2.sym} 55980 -30230 0 0 {name=X_55099_ }
C {devices/lab_pin.sym} 55940 -30110 0 0 {name=p55225 lab=_59976_/A }
C {devices/lab_pin.sym} 56020 -30110 0 1 {name=p55226 lab=_59977_/A }
C {sky130_stdcells/buf_2.sym} 55980 -30110 0 0 {name=X_59976_ }
C {devices/lab_pin.sym} 55940 -29990 0 0 {name=p55227 lab=clkbuf_4_10_1_CLK/X }
C {devices/lab_pin.sym} 56020 -29990 0 1 {name=p55228 lab=clkbuf_6_43_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 55980 -29990 0 0 {name=Xclkbuf_5_21_0_CLK }
C {devices/lab_pin.sym} 55940 -29870 0 0 {name=p55229 lab=_46941_/A }
C {devices/lab_pin.sym} 56020 -29870 0 1 {name=p55230 lab=_46944_/B }
C {sky130_stdcells/buf_2.sym} 55980 -29870 0 0 {name=X_46941_ }
C {devices/lab_pin.sym} 55900 -29790 0 0 {name=p55231 lab=_42060_/X }
C {devices/lab_pin.sym} 55900 -29750 0 0 {name=p55232 lab=_42049_/X }
C {devices/lab_pin.sym} 55900 -29710 0 0 {name=p55233 lab=_40929_/X }
C {devices/lab_pin.sym} 55900 -29670 0 0 {name=p55234 lab=_42063_/Y }
C {devices/lab_pin.sym} 55900 -29630 0 0 {name=p55235 lab=_41872_/X }
C {devices/lab_pin.sym} 56060 -29710 0 1 {name=p55236 lab=_42064_/Y }
C {sky130_stdcells/o32ai_4.sym} 55980 -29710 0 0 {name=X_42064_ }
C {devices/lab_pin.sym} 55900 -29570 0 0 {name=p55237 lab=_58925_/X }
C {devices/lab_pin.sym} 55900 -29530 0 0 {name=p55238 lab=_85445_/Q }
C {devices/lab_pin.sym} 55900 -29490 0 0 {name=p55239 lab=_58926_/X }
C {devices/lab_pin.sym} 56060 -29530 0 1 {name=p55240 lab=_58927_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -29530 0 0 {name=X_58927_ }
C {devices/lab_pin.sym} 55920 -29400 0 0 {name=p55241 lab=_82149_/Q }
C {devices/lab_pin.sym} 55920 -29360 0 0 {name=p55242 lab=_77761_/B }
C {devices/lab_pin.sym} 56040 -29380 0 1 {name=p55243 lab=_77761_/X }
C {sky130_stdcells/xor2_4.sym} 55980 -29380 0 0 {name=X_77761_ }
C {devices/lab_pin.sym} 55920 -29260 0 0 {name=p55244 lab=_80763_/Q }
C {devices/lab_pin.sym} 55920 -29220 0 0 {name=p55245 lab=_74965_/B }
C {devices/lab_pin.sym} 56040 -29240 0 1 {name=p55246 lab=_74973_/Y }
C {sky130_stdcells/nor2_4.sym} 55980 -29240 0 0 {name=X_74973_ }
C {devices/lab_pin.sym} 55900 -29140 0 0 {name=p55247 lab=_69974_/Y }
C {devices/lab_pin.sym} 55900 -29100 0 0 {name=p55248 lab=_59834_/A }
C {devices/lab_pin.sym} 55900 -29060 0 0 {name=p55249 lab=_70081_/X }
C {devices/lab_pin.sym} 55900 -29020 0 0 {name=p55250 lab=_70095_/Y }
C {devices/lab_pin.sym} 56060 -29080 0 1 {name=p55251 lab=_70096_/X }
C {sky130_stdcells/a211o_4.sym} 55980 -29080 0 0 {name=X_70096_ }
C {devices/lab_pin.sym} 55890 -28930 0 0 {name=p55252 lab=_86965_/CLK }
C {devices/lab_pin.sym} 55890 -28910 0 0 {name=p55253 lab=_86959_/D }
C {devices/lab_pin.sym} 56070 -28930 0 1 {name=p55254 lab=_86959_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -28920 0 0 {name=X_86959_ }
C {devices/lab_pin.sym} 55900 -28810 0 0 {name=p55255 lab=_79494_/A }
C {devices/lab_pin.sym} 55900 -28770 0 0 {name=p55256 lab=_79494_/B }
C {devices/lab_pin.sym} 55900 -28730 0 0 {name=p55257 lab=_79499_/Y }
C {devices/lab_pin.sym} 56060 -28770 0 1 {name=p55258 lab=_79500_/Y }
C {sky130_stdcells/a21boi_4.sym} 55980 -28770 0 0 {name=X_79500_ }
C {devices/lab_pin.sym} 55900 -28650 0 0 {name=p55259 lab=_40991_/X }
C {devices/lab_pin.sym} 55900 -28610 0 0 {name=p55260 lab=_81715_/Q }
C {devices/lab_pin.sym} 55900 -28570 0 0 {name=p55261 lab=_41014_/X }
C {devices/lab_pin.sym} 56060 -28610 0 1 {name=p55262 lab=_41016_/A }
C {sky130_stdcells/o21a_4.sym} 55980 -28610 0 0 {name=X_41015_ }
C {devices/lab_pin.sym} 55920 -28480 0 0 {name=p55263 lab=_76712_/A }
C {devices/lab_pin.sym} 55920 -28440 0 0 {name=p55264 lab=_76711_/Y }
C {devices/lab_pin.sym} 56040 -28460 0 1 {name=p55265 lab=_76713_/B }
C {sky130_stdcells/xor2_4.sym} 55980 -28460 0 0 {name=X_76712_ }
C {devices/lab_pin.sym} 55940 -28330 0 0 {name=p55266 lab=_49632_/A }
C {devices/lab_pin.sym} 56020 -28330 0 1 {name=p55267 lab=_49660_/X }
C {sky130_stdcells/buf_2.sym} 55980 -28330 0 0 {name=X_49660_ }
C {devices/lab_pin.sym} 55900 -28230 0 0 {name=p55268 lab=_73916_/Y }
C {devices/lab_pin.sym} 55900 -28190 0 0 {name=p55269 lab=_73917_/Y }
C {devices/lab_pin.sym} 55900 -28150 0 0 {name=p55270 lab=_73923_/X }
C {devices/lab_pin.sym} 56060 -28190 0 1 {name=p55271 lab=_73924_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -28190 0 0 {name=X_73924_ }
C {devices/lab_pin.sym} 55940 -28050 0 0 {name=p55272 lab=_58858_/A }
C {devices/lab_pin.sym} 56020 -28050 0 1 {name=p55273 lab=_58858_/X }
C {sky130_stdcells/buf_2.sym} 55980 -28050 0 0 {name=X_58858_ }
C {devices/lab_pin.sym} 55920 -27940 0 0 {name=p55274 lab=_46860_/X }
C {devices/lab_pin.sym} 55920 -27900 0 0 {name=p55275 lab=_51031_/B }
C {devices/lab_pin.sym} 56040 -27920 0 1 {name=p55276 lab=_46872_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -27920 0 0 {name=X_46872_ }
C {devices/lab_pin.sym} 55940 -27790 0 0 {name=p55277 lab=clkbuf_9_459_0_CLK/X }
C {devices/lab_pin.sym} 56020 -27790 0 1 {name=p55278 lab=_86576_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55980 -27790 0 0 {name=Xclkbuf_10_919_0_CLK }
C {devices/lab_pin.sym} 55920 -27680 0 0 {name=p55279 lab=_77689_/Y }
C {devices/lab_pin.sym} 55920 -27640 0 0 {name=p55280 lab=_77692_/B }
C {devices/lab_pin.sym} 56040 -27660 0 1 {name=p55281 lab=_77692_/Y }
C {sky130_stdcells/nor2_4.sym} 55980 -27660 0 0 {name=X_77692_ }
C {devices/lab_pin.sym} 55900 -27550 0 0 {name=p55282 lab=_48605_/Y }
C {devices/lab_pin.sym} 55900 -27510 0 0 {name=p55283 lab=_48585_/X }
C {devices/lab_pin.sym} 55900 -27470 0 0 {name=p55284 lab=_48610_/X }
C {devices/lab_pin.sym} 56060 -27510 0 1 {name=p55285 lab=_48611_/Y }
C {sky130_stdcells/a21oi_4.sym} 55980 -27510 0 0 {name=X_48611_ }
C {devices/lab_pin.sym} 55900 -27390 0 0 {name=p55286 lab=_79417_/Y }
C {devices/lab_pin.sym} 55900 -27350 0 0 {name=p55287 lab=_79422_/Y }
C {devices/lab_pin.sym} 55900 -27310 0 0 {name=p55288 lab=_79430_/X }
C {devices/lab_pin.sym} 56060 -27350 0 1 {name=p55289 lab=_79431_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -27350 0 0 {name=X_79431_ }
C {devices/lab_pin.sym} 55940 -27210 0 0 {name=p55290 lab=clkbuf_9_4_0_CLK/X }
C {devices/lab_pin.sym} 56020 -27210 0 1 {name=p55291 lab=_85180_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55980 -27210 0 0 {name=Xclkbuf_10_8_0_CLK }
C {devices/lab_pin.sym} 55940 -27090 0 0 {name=p55292 lab=_57217_/B }
C {devices/lab_pin.sym} 56020 -27090 0 1 {name=p55293 lab=_45823_/Y }
C {sky130_stdcells/inv_2.sym} 55980 -27090 0 0 {name=X_45823_ }
C {devices/lab_pin.sym} 55940 -26970 0 0 {name=p55294 lab=_57872_/A }
C {devices/lab_pin.sym} 56020 -26970 0 1 {name=p55295 lab=_57809_/X }
C {sky130_stdcells/buf_2.sym} 55980 -26970 0 0 {name=X_57809_ }
C {devices/lab_pin.sym} 55920 -26860 0 0 {name=p55296 lab=_76643_/A }
C {devices/lab_pin.sym} 55920 -26820 0 0 {name=p55297 lab=_76642_/Y }
C {devices/lab_pin.sym} 56040 -26840 0 1 {name=p55298 lab=_76645_/A }
C {sky130_stdcells/nand2_4.sym} 55980 -26840 0 0 {name=X_76643_ }
C {devices/lab_pin.sym} 55900 -26730 0 0 {name=p55299 lab=_86359_/Q }
C {devices/lab_pin.sym} 55900 -26690 0 0 {name=p55300 lab=_49579_/X }
C {devices/lab_pin.sym} 55900 -26650 0 0 {name=p55301 lab=_49590_/Y }
C {devices/lab_pin.sym} 56060 -26690 0 1 {name=p55302 lab=_49591_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -26690 0 0 {name=X_49591_ }
C {devices/lab_pin.sym} 55920 -26560 0 0 {name=p55303 lab=_73829_/X }
C {devices/lab_pin.sym} 55920 -26520 0 0 {name=p55304 lab=_66084_/B }
C {devices/lab_pin.sym} 56040 -26540 0 1 {name=p55305 lab=_73855_/X }
C {sky130_stdcells/and2_4.sym} 55980 -26540 0 0 {name=X_73855_ }
C {devices/lab_pin.sym} 55900 -26430 0 0 {name=p55306 lab=_58787_/X }
C {devices/lab_pin.sym} 55900 -26390 0 0 {name=p55307 lab=_86096_/Q }
C {devices/lab_pin.sym} 55900 -26350 0 0 {name=p55308 lab=_58788_/X }
C {devices/lab_pin.sym} 56060 -26390 0 1 {name=p55309 lab=_58789_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -26390 0 0 {name=X_58789_ }
C {devices/lab_pin.sym} 55920 -26260 0 0 {name=p55310 lab=_48642_/A }
C {devices/lab_pin.sym} 55920 -26220 0 0 {name=p55311 lab=_48542_/B }
C {devices/lab_pin.sym} 56040 -26240 0 1 {name=p55312 lab=_48542_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -26240 0 0 {name=X_48542_ }
C {devices/lab_pin.sym} 55920 -26120 0 0 {name=p55313 lab=_60820_/A }
C {devices/lab_pin.sym} 55920 -26080 0 0 {name=p55314 lab=_60820_/B }
C {devices/lab_pin.sym} 56040 -26100 0 1 {name=p55315 lab=_60820_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -26100 0 0 {name=X_60820_ }
C {devices/lab_pin.sym} 55940 -25970 0 0 {name=p55316 lab=_72806_/A }
C {devices/lab_pin.sym} 56020 -25970 0 1 {name=p55317 lab=_72806_/X }
C {sky130_stdcells/buf_2.sym} 55980 -25970 0 0 {name=X_72806_ }
C {devices/lab_pin.sym} 55920 -25860 0 0 {name=p55318 lab=_84803_/Q }
C {devices/lab_pin.sym} 55920 -25820 0 0 {name=p55319 lab=_66435_/A }
C {devices/lab_pin.sym} 56040 -25840 0 1 {name=p55320 lab=_79362_/X }
C {sky130_stdcells/xor2_4.sym} 55980 -25840 0 0 {name=X_79362_ }
C {devices/lab_pin.sym} 55900 -25740 0 0 {name=p55321 lab=_45752_/Y }
C {devices/lab_pin.sym} 55900 -25700 0 0 {name=p55322 lab=_45734_/X }
C {devices/lab_pin.sym} 55900 -25660 0 0 {name=p55323 lab=_45720_/X }
C {devices/lab_pin.sym} 55900 -25620 0 0 {name=p55324 lab=_45753_/Y }
C {devices/lab_pin.sym} 56060 -25680 0 1 {name=p55325 lab=_45754_/X }
C {sky130_stdcells/a211o_4.sym} 55980 -25680 0 0 {name=X_45754_ }
C {devices/lab_pin.sym} 55920 -25540 0 0 {name=p55326 lab=_81278_/Q }
C {devices/lab_pin.sym} 55920 -25500 0 0 {name=p55327 lab=_81546_/Q }
C {devices/lab_pin.sym} 56040 -25520 0 1 {name=p55328 lab=_76574_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -25520 0 0 {name=X_76574_ }
C {devices/lab_pin.sym} 55900 -25420 0 0 {name=p55329 lab=_40418_/X }
C {devices/lab_pin.sym} 55900 -25380 0 0 {name=p55330 lab=_42962_/X }
C {devices/lab_pin.sym} 55900 -25340 0 0 {name=p55331 lab=_66795_/B }
C {devices/lab_pin.sym} 55900 -25300 0 0 {name=p55332 lab=_42963_/X }
C {devices/lab_pin.sym} 56060 -25360 0 1 {name=p55333 lab=_87626_/D }
C {sky130_stdcells/a2bb2o_4.sym} 55980 -25360 0 0 {name=X_42966_ }
C {devices/lab_pin.sym} 55940 -25210 0 0 {name=p55334 lab=_72829_/A }
C {devices/lab_pin.sym} 56020 -25210 0 1 {name=p55335 lab=_73786_/X }
C {sky130_stdcells/buf_2.sym} 55980 -25210 0 0 {name=X_73786_ }
C {devices/lab_pin.sym} 55920 -25110 0 0 {name=p55336 lab=_70990_/A }
C {devices/lab_pin.sym} 55920 -25070 0 0 {name=p55337 lab=_71082_/B }
C {devices/lab_pin.sym} 55920 -25030 0 0 {name=p55338 lab=_70990_/C }
C {devices/lab_pin.sym} 56040 -25070 0 1 {name=p55339 lab=_70998_/Y }
C {sky130_stdcells/nand3_4.sym} 55980 -25070 0 0 {name=X_70998_ }
C {devices/lab_pin.sym} 55920 -24940 0 0 {name=p55340 lab=_82786_/Q }
C {devices/lab_pin.sym} 55920 -24900 0 0 {name=p55341 lab=_78312_/X }
C {devices/lab_pin.sym} 56040 -24920 0 1 {name=p55342 lab=_82754_/D }
C {sky130_stdcells/xor2_4.sym} 55980 -24920 0 0 {name=X_78313_ }
C {devices/lab_pin.sym} 55940 -24790 0 0 {name=p55343 lab=_44705_/A }
C {devices/lab_pin.sym} 56020 -24790 0 1 {name=p55344 lab=_44705_/Y }
C {sky130_stdcells/inv_2.sym} 55980 -24790 0 0 {name=X_44705_ }
C {devices/lab_pin.sym} 55920 -24680 0 0 {name=p55345 lab=_75523_/X }
C {devices/lab_pin.sym} 55920 -24640 0 0 {name=p55346 lab=_75524_/Y }
C {devices/lab_pin.sym} 56040 -24660 0 1 {name=p55347 lab=_75525_/X }
C {sky130_stdcells/and2_4.sym} 55980 -24660 0 0 {name=X_75525_ }
C {devices/lab_pin.sym} 55940 -24530 0 0 {name=p55348 lab=_41917_/A }
C {devices/lab_pin.sym} 56020 -24530 0 1 {name=p55349 lab=_41917_/Y }
C {sky130_stdcells/inv_2.sym} 55980 -24530 0 0 {name=X_41917_ }
C {devices/lab_pin.sym} 55940 -24410 0 0 {name=p55350 lab=_60558_/X }
C {devices/lab_pin.sym} 56020 -24410 0 1 {name=p55351 lab=_60761_/A }
C {sky130_stdcells/buf_2.sym} 55980 -24410 0 0 {name=X_60751_ }
C {devices/lab_pin.sym} 55920 -24300 0 0 {name=p55352 lab=_48473_/A }
C {devices/lab_pin.sym} 55920 -24260 0 0 {name=p55353 lab=_48485_/B }
C {devices/lab_pin.sym} 56040 -24280 0 1 {name=p55354 lab=_48473_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -24280 0 0 {name=X_48473_ }
C {devices/lab_pin.sym} 55940 -24150 0 0 {name=p55355 lab=_72737_/A }
C {devices/lab_pin.sym} 56020 -24150 0 1 {name=p55356 lab=_72737_/X }
C {sky130_stdcells/buf_2.sym} 55980 -24150 0 0 {name=X_72737_ }
C {devices/lab_pin.sym} 55920 -24040 0 0 {name=p55357 lab=_79277_/X }
C {devices/lab_pin.sym} 55920 -24000 0 0 {name=p55358 lab=_79280_/Y }
C {devices/lab_pin.sym} 56040 -24020 0 1 {name=p55359 lab=_79293_/X }
C {sky130_stdcells/or2_4.sym} 55980 -24020 0 0 {name=X_79293_ }
C {devices/lab_pin.sym} 55940 -23890 0 0 {name=p55360 lab=_45452_/A }
C {devices/lab_pin.sym} 56020 -23890 0 1 {name=p55361 lab=_45685_/X }
C {sky130_stdcells/buf_2.sym} 55980 -23890 0 0 {name=X_45685_ }
C {devices/lab_pin.sym} 55900 -23810 0 0 {name=p55362 lab=_42895_/X }
C {devices/lab_pin.sym} 55900 -23770 0 0 {name=p55363 lab=_42896_/X }
C {devices/lab_pin.sym} 55900 -23730 0 0 {name=p55364 lab=_41656_/X }
C {devices/lab_pin.sym} 55900 -23690 0 0 {name=p55365 lab=_87662_/Q }
C {devices/lab_pin.sym} 55900 -23650 0 0 {name=p55366 lab=_42881_/X }
C {devices/lab_pin.sym} 56060 -23730 0 1 {name=p55367 lab=_42898_/A }
C {sky130_stdcells/o32ai_4.sym} 55980 -23730 0 0 {name=X_42897_ }
C {devices/lab_pin.sym} 55940 -23570 0 0 {name=p55368 lab=_47565_/A }
C {devices/lab_pin.sym} 56020 -23570 0 1 {name=p55369 lab=_47466_/C }
C {sky130_stdcells/buf_2.sym} 55980 -23570 0 0 {name=X_47424_ }
C {devices/lab_pin.sym} 55900 -23470 0 0 {name=p55370 lab=_78234_/Y }
C {devices/lab_pin.sym} 55900 -23430 0 0 {name=p55371 lab=_78237_/X }
C {devices/lab_pin.sym} 55900 -23390 0 0 {name=p55372 lab=_78252_/A }
C {devices/lab_pin.sym} 56060 -23430 0 1 {name=p55373 lab=_78244_/Y }
C {sky130_stdcells/a21boi_4.sym} 55980 -23430 0 0 {name=X_78244_ }
C {devices/lab_pin.sym} 55900 -23320 0 0 {name=p55374 lab=_41027_/Y }
C {devices/lab_pin.sym} 55900 -23280 0 0 {name=p55375 lab=_44618_/X }
C {devices/lab_pin.sym} 55900 -23240 0 0 {name=p55376 lab=_87023_/Q }
C {devices/lab_pin.sym} 55900 -23200 0 0 {name=p55377 lab=_44619_/X }
C {devices/lab_pin.sym} 56060 -23260 0 1 {name=p55378 lab=_87023_/D }
C {sky130_stdcells/a2bb2o_4.sym} 55980 -23260 0 0 {name=X_44636_ }
C {devices/lab_pin.sym} 55900 -23130 0 0 {name=p55379 lab=_63466_/Y }
C {devices/lab_pin.sym} 55900 -23090 0 0 {name=p55380 lab=_63455_/X }
C {devices/lab_pin.sym} 55900 -23050 0 0 {name=p55381 lab=_63469_/Y }
C {devices/lab_pin.sym} 56060 -23090 0 1 {name=p55382 lab=_63470_/Y }
C {sky130_stdcells/a21oi_4.sym} 55980 -23090 0 0 {name=X_63470_ }
C {devices/lab_pin.sym} 55940 -22950 0 0 {name=p55383 lab=_75456_/A }
C {devices/lab_pin.sym} 56020 -22950 0 1 {name=p55384 lab=_75457_/C }
C {sky130_stdcells/inv_2.sym} 55980 -22950 0 0 {name=X_75456_ }
C {devices/lab_pin.sym} 55940 -22830 0 0 {name=p55385 lab=_40755_/A }
C {devices/lab_pin.sym} 56020 -22830 0 1 {name=p55386 lab=_41848_/X }
C {sky130_stdcells/buf_2.sym} 55980 -22830 0 0 {name=X_41848_ }
C {devices/lab_pin.sym} 55940 -22710 0 0 {name=p55387 lab=_60682_/A }
C {devices/lab_pin.sym} 56020 -22710 0 1 {name=p55388 lab=_60804_/C }
C {sky130_stdcells/buf_2.sym} 55980 -22710 0 0 {name=X_60682_ }
C {devices/lab_pin.sym} 55920 -22610 0 0 {name=p55389 lab=_72668_/A }
C {devices/lab_pin.sym} 55920 -22570 0 0 {name=p55390 lab=_72668_/B }
C {devices/lab_pin.sym} 55920 -22530 0 0 {name=p55391 lab=_55467_/X }
C {devices/lab_pin.sym} 56040 -22570 0 1 {name=p55392 lab=_72668_/Y }
C {sky130_stdcells/nand3_4.sym} 55980 -22570 0 0 {name=X_72668_ }
C {devices/lab_pin.sym} 55920 -22460 0 0 {name=p55393 lab=_62406_/A }
C {devices/lab_pin.sym} 55920 -22420 0 0 {name=p55394 lab=_62421_/B }
C {devices/lab_pin.sym} 55920 -22380 0 0 {name=p55395 lab=_62421_/C }
C {devices/lab_pin.sym} 55920 -22340 0 0 {name=p55396 lab=_62421_/D }
C {devices/lab_pin.sym} 56040 -22400 0 1 {name=p55397 lab=_62421_/Y }
C {sky130_stdcells/nand4_4.sym} 55980 -22400 0 0 {name=X_62421_ }
C {devices/lab_pin.sym} 55900 -22270 0 0 {name=p55398 lab=_74404_/Y }
C {devices/lab_pin.sym} 55900 -22230 0 0 {name=p55399 lab=_74405_/X }
C {devices/lab_pin.sym} 55900 -22190 0 0 {name=p55400 lab=_74406_/X }
C {devices/lab_pin.sym} 56060 -22230 0 1 {name=p55401 lab=_83073_/D }
C {sky130_stdcells/a21oi_4.sym} 55980 -22230 0 0 {name=X_74407_ }
C {devices/lab_pin.sym} 55940 -22090 0 0 {name=p55402 lab=_47355_/A }
C {devices/lab_pin.sym} 56020 -22090 0 1 {name=p55403 lab=_47355_/Y }
C {sky130_stdcells/inv_2.sym} 55980 -22090 0 0 {name=X_47355_ }
C {devices/lab_pin.sym} 55900 -21990 0 0 {name=p55404 lab=_71603_/Y }
C {devices/lab_pin.sym} 55900 -21950 0 0 {name=p55405 lab=_83436_/Q }
C {devices/lab_pin.sym} 55900 -21910 0 0 {name=p55406 lab=_71618_/Y }
C {devices/lab_pin.sym} 56060 -21950 0 1 {name=p55407 lab=_83436_/D }
C {sky130_stdcells/a21o_4.sym} 55980 -21950 0 0 {name=X_71619_ }
C {devices/lab_pin.sym} 55920 -21820 0 0 {name=p55408 lab=_78167_/A }
C {devices/lab_pin.sym} 55920 -21780 0 0 {name=p55409 lab=_78172_/A }
C {devices/lab_pin.sym} 56040 -21800 0 1 {name=p55410 lab=_78175_/X }
C {sky130_stdcells/and2_4.sym} 55980 -21800 0 0 {name=X_78175_ }
C {devices/lab_pin.sym} 55940 -21670 0 0 {name=p55411 lab=_44567_/A }
C {devices/lab_pin.sym} 56020 -21670 0 1 {name=p55412 lab=_44567_/X }
C {sky130_stdcells/buf_2.sym} 55980 -21670 0 0 {name=X_44567_ }
C {devices/lab_pin.sym} 55920 -21560 0 0 {name=p55413 lab=_75362_/X }
C {devices/lab_pin.sym} 55920 -21520 0 0 {name=p55414 lab=_75359_/X }
C {devices/lab_pin.sym} 56040 -21540 0 1 {name=p55415 lab=_75404_/B }
C {sky130_stdcells/nand2_4.sym} 55980 -21540 0 0 {name=X_75387_ }
C {devices/lab_pin.sym} 55900 -21440 0 0 {name=p55416 lab=_41778_/X }
C {devices/lab_pin.sym} 55900 -21400 0 0 {name=p55417 lab=_41750_/X }
C {devices/lab_pin.sym} 55900 -21360 0 0 {name=p55418 lab=_88151_/Q }
C {devices/lab_pin.sym} 55900 -21320 0 0 {name=p55419 lab=_41751_/X }
C {devices/lab_pin.sym} 56060 -21380 0 1 {name=p55420 lab=_88151_/D }
C {sky130_stdcells/a2bb2o_4.sym} 55980 -21380 0 0 {name=X_41779_ }
C {devices/lab_pin.sym} 55900 -21270 0 0 {name=p55421 lab=_72522_/Y }
C {devices/lab_pin.sym} 55900 -21230 0 0 {name=p55422 lab=_72551_/X }
C {devices/lab_pin.sym} 55900 -21190 0 0 {name=p55423 lab=_72539_/Y }
C {devices/lab_pin.sym} 55900 -21150 0 0 {name=p55424 lab=_72597_/Y }
C {devices/lab_pin.sym} 55900 -21120 0 0 {name=p55425 lab=_72598_/Y }
C {devices/lab_pin.sym} 56060 -21190 0 1 {name=p55426 lab=_72599_/Y }
C {sky130_stdcells/a41oi_4.sym} 55980 -21190 0 0 {name=X_72599_ }
C {devices/lab_pin.sym} 55940 -21030 0 0 {name=p55427 lab=_46610_/A }
C {devices/lab_pin.sym} 56020 -21030 0 1 {name=p55428 lab=_48499_/A }
C {sky130_stdcells/buf_2.sym} 55980 -21030 0 0 {name=X_46306_ }
C {devices/lab_pin.sym} 55900 -20930 0 0 {name=p55429 lab=_64915_/X }
C {devices/lab_pin.sym} 55900 -20890 0 0 {name=p55430 lab=_65126_/Y }
C {devices/lab_pin.sym} 55900 -20850 0 0 {name=p55431 lab=_65139_/Y }
C {devices/lab_pin.sym} 56060 -20890 0 1 {name=p55432 lab=_65140_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -20890 0 0 {name=X_65140_ }
C {devices/lab_pin.sym} 55920 -20760 0 0 {name=p55433 lab=_77126_/A }
C {devices/lab_pin.sym} 55920 -20720 0 0 {name=p55434 lab=_77125_/X }
C {devices/lab_pin.sym} 56040 -20740 0 1 {name=p55435 lab=_77130_/A }
C {sky130_stdcells/nand2_4.sym} 55980 -20740 0 0 {name=X_77126_ }
C {devices/lab_pin.sym} 55940 -20610 0 0 {name=p55436 lab=_43518_/A }
C {devices/lab_pin.sym} 56020 -20610 0 1 {name=p55437 lab=_43518_/X }
C {sky130_stdcells/buf_2.sym} 55980 -20610 0 0 {name=X_43518_ }
C {devices/lab_pin.sym} 55920 -20510 0 0 {name=p55438 lab=_74338_/A }
C {devices/lab_pin.sym} 55920 -20470 0 0 {name=p55439 lab=_74338_/B }
C {devices/lab_pin.sym} 55920 -20430 0 0 {name=p55440 lab=_55801_/D }
C {devices/lab_pin.sym} 56040 -20470 0 1 {name=p55441 lab=_74338_/Y }
C {sky130_stdcells/nand3_4.sym} 55980 -20470 0 0 {name=X_74338_ }
C {devices/lab_pin.sym} 55900 -20370 0 0 {name=p55442 lab=_62345_/X }
C {devices/lab_pin.sym} 55900 -20330 0 0 {name=p55443 lab=_62347_/X }
C {devices/lab_pin.sym} 55900 -20290 0 0 {name=p55444 lab=_62351_/Y }
C {devices/lab_pin.sym} 55900 -20250 0 0 {name=p55445 lab=_84744_/Q }
C {devices/lab_pin.sym} 55900 -20210 0 0 {name=p55446 lab=_62300_/X }
C {devices/lab_pin.sym} 56060 -20290 0 1 {name=p55447 lab=_62352_/Y }
C {sky130_stdcells/o32ai_4.sym} 55980 -20290 0 0 {name=X_62352_ }
C {devices/lab_pin.sym} 55940 -20130 0 0 {name=p55448 lab=_47382_/A }
C {devices/lab_pin.sym} 56020 -20130 0 1 {name=p55449 lab=_47286_/X }
C {sky130_stdcells/buf_2.sym} 55980 -20130 0 0 {name=X_47286_ }
C {devices/lab_pin.sym} 55940 -20010 0 0 {name=p55450 lab=_44549_/A }
C {devices/lab_pin.sym} 56020 -20010 0 1 {name=p55451 lab=_44498_/X }
C {sky130_stdcells/buf_2.sym} 55980 -20010 0 0 {name=X_44498_ }
C {devices/lab_pin.sym} 55940 -19890 0 0 {name=p55452 lab=_53852_/B }
C {devices/lab_pin.sym} 56020 -19890 0 1 {name=p55453 lab=_49025_/X }
C {sky130_stdcells/buf_2.sym} 55980 -19890 0 0 {name=X_49025_ }
C {devices/lab_pin.sym} 55940 -19770 0 0 {name=p55454 lab=_61302_/Y }
C {devices/lab_pin.sym} 56020 -19770 0 1 {name=p55455 lab=_72563_/C }
C {sky130_stdcells/buf_2.sym} 55980 -19770 0 0 {name=X_61303_ }
C {devices/lab_pin.sym} 55940 -19650 0 0 {name=p55456 lab=_46237_/A }
C {devices/lab_pin.sym} 56020 -19650 0 1 {name=p55457 lab=_73939_/A }
C {sky130_stdcells/buf_2.sym} 55980 -19650 0 0 {name=X_46237_ }
C {devices/lab_pin.sym} 55940 -19530 0 0 {name=p55458 lab=_84216_/Q }
C {devices/lab_pin.sym} 56020 -19530 0 1 {name=p55459 lab=_65072_/C }
C {sky130_stdcells/inv_2.sym} 55980 -19530 0 0 {name=X_65071_ }
C {sky130_stdcells/decap_3.sym} 55980 -19380 0 0 {name=XPHY_490 }
C {devices/lab_pin.sym} 55900 -19250 0 0 {name=p55460 lab=_77041_/C }
C {devices/lab_pin.sym} 55900 -19210 0 0 {name=p55461 lab=_77053_/Y }
C {devices/lab_pin.sym} 55900 -19170 0 0 {name=p55462 lab=_77056_/Y }
C {devices/lab_pin.sym} 56060 -19210 0 1 {name=p55463 lab=_77057_/X }
C {sky130_stdcells/o21a_4.sym} 55980 -19210 0 0 {name=X_77057_ }
C {devices/lab_pin.sym} 55940 -19070 0 0 {name=p55464 lab=_43518_/A }
C {devices/lab_pin.sym} 56020 -19070 0 1 {name=p55465 lab=_43449_/X }
C {sky130_stdcells/buf_2.sym} 55980 -19070 0 0 {name=X_43449_ }
C {devices/lab_pin.sym} 55920 -18970 0 0 {name=p55466 lab=_62267_/A }
C {devices/lab_pin.sym} 55920 -18930 0 0 {name=p55467 lab=_62267_/B }
C {devices/lab_pin.sym} 55920 -18890 0 0 {name=p55468 lab=_84421_/Q }
C {devices/lab_pin.sym} 56040 -18930 0 1 {name=p55469 lab=_62283_/Y }
C {sky130_stdcells/nor3_4.sym} 55980 -18930 0 0 {name=X_62283_ }
C {devices/lab_pin.sym} 55900 -18810 0 0 {name=p55470 lab=_88340_/Q }
C {devices/lab_pin.sym} 55900 -18770 0 0 {name=p55471 lab=_72899_/X }
C {devices/lab_pin.sym} 55900 -18730 0 0 {name=p55472 lab=_73898_/X }
C {devices/lab_pin.sym} 56060 -18770 0 1 {name=p55473 lab=_74269_/X }
C {sky130_stdcells/o21a_4.sym} 55980 -18770 0 0 {name=X_74269_ }
C {devices/lab_pin.sym} 55920 -18650 0 0 {name=p55474 lab=_64074_/A }
C {devices/lab_pin.sym} 55920 -18610 0 0 {name=p55475 lab=_64074_/B }
C {devices/lab_pin.sym} 55920 -18570 0 0 {name=p55476 lab=_64022_/C }
C {devices/lab_pin.sym} 56040 -18610 0 1 {name=p55477 lab=_64022_/Y }
C {sky130_stdcells/nor3_4.sym} 55980 -18610 0 0 {name=X_64022_ }
C {devices/lab_pin.sym} 55920 -18480 0 0 {name=p55478 lab=_76008_/A }
C {devices/lab_pin.sym} 55920 -18440 0 0 {name=p55479 lab=_76005_/C }
C {devices/lab_pin.sym} 56040 -18460 0 1 {name=p55480 lab=_76009_/B }
C {sky130_stdcells/and2_4.sym} 55980 -18460 0 0 {name=X_76008_ }
C {devices/lab_pin.sym} 55920 -18350 0 0 {name=p55481 lab=_61234_/A }
C {devices/lab_pin.sym} 55920 -18310 0 0 {name=p55482 lab=_61250_/B }
C {devices/lab_pin.sym} 55920 -18270 0 0 {name=p55483 lab=_84502_/Q }
C {devices/lab_pin.sym} 56040 -18310 0 1 {name=p55484 lab=_61234_/Y }
C {sky130_stdcells/nor3_4.sym} 55980 -18310 0 0 {name=X_61234_ }
C {devices/lab_pin.sym} 55900 -18190 0 0 {name=p55485 lab=_46166_/A }
C {devices/lab_pin.sym} 55900 -18150 0 0 {name=p55486 lab=_46170_/C }
C {devices/lab_pin.sym} 55900 -18110 0 0 {name=p55487 lab=_46107_/A }
C {devices/lab_pin.sym} 56060 -18150 0 1 {name=p55488 lab=_46168_/Y }
C {sky130_stdcells/a21oi_4.sym} 55980 -18150 0 0 {name=X_46168_ }
C {devices/lab_pin.sym} 55900 -18030 0 0 {name=p55489 lab=_45114_/Y }
C {devices/lab_pin.sym} 55900 -17990 0 0 {name=p55490 lab=_45118_/Y }
C {devices/lab_pin.sym} 55900 -17950 0 0 {name=p55491 lab=_45063_/X }
C {devices/lab_pin.sym} 56060 -17990 0 1 {name=p55492 lab=_45119_/X }
C {sky130_stdcells/a21o_4.sym} 55980 -17990 0 0 {name=X_45119_ }
C {devices/lab_pin.sym} 55900 -17880 0 0 {name=p55493 lab=_73989_/A }
C {devices/lab_pin.sym} 55900 -17840 0 0 {name=p55494 lab=_68757_/X }
C {devices/lab_pin.sym} 55900 -17800 0 0 {name=p55495 lab=_68731_/X }
C {devices/lab_pin.sym} 55900 -17760 0 0 {name=p55496 lab=_68829_/Y }
C {devices/lab_pin.sym} 56060 -17820 0 1 {name=p55497 lab=_68830_/X }
C {sky130_stdcells/a211o_4.sym} 55980 -17820 0 0 {name=X_68830_ }
C {devices/lab_pin.sym} 55920 -17690 0 0 {name=p55498 lab=_61165_/A }
C {devices/lab_pin.sym} 55920 -17650 0 0 {name=p55499 lab=_61165_/B }
C {devices/lab_pin.sym} 55920 -17610 0 0 {name=p55500 lab=_61165_/C }
C {devices/lab_pin.sym} 56040 -17650 0 1 {name=p55501 lab=_61165_/Y }
C {sky130_stdcells/nor3_4.sym} 55980 -17650 0 0 {name=X_61165_ }
C {devices/lab_pin.sym} 55940 -17510 0 0 {name=p55502 lab=_80653_/Q }
C {devices/lab_pin.sym} 56020 -17510 0 1 {name=p55503 lab=_46099_/X }
C {sky130_stdcells/buf_2.sym} 55980 -17510 0 0 {name=X_46099_ }
C {devices/lab_pin.sym} 55940 -17390 0 0 {name=p55504 lab=_62534_/A }
C {devices/lab_pin.sym} 56020 -17390 0 1 {name=p55505 lab=_62193_/A }
C {sky130_stdcells/buf_2.sym} 55980 -17390 0 0 {name=X_60116_ }
C {devices/lab_pin.sym} 55900 -17290 0 0 {name=p55506 lab=_49923_/Y }
C {devices/lab_pin.sym} 55900 -17250 0 0 {name=p55507 lab=_49924_/X }
C {devices/lab_pin.sym} 55900 -17210 0 0 {name=p55508 lab=_49926_/X }
C {devices/lab_pin.sym} 56060 -17250 0 1 {name=p55509 lab=_86298_/D }
C {sky130_stdcells/a21oi_4.sym} 55980 -17250 0 0 {name=X_49927_ }
C {devices/lab_pin.sym} 55900 -17130 0 0 {name=p55510 lab=_68756_/X }
C {devices/lab_pin.sym} 55900 -17090 0 0 {name=p55511 lab=_68760_/X }
C {devices/lab_pin.sym} 55900 -17050 0 0 {name=p55512 lab=_68684_/X }
C {devices/lab_pin.sym} 56060 -17090 0 1 {name=p55513 lab=_68761_/X }
C {sky130_stdcells/a21o_4.sym} 55980 -17090 0 0 {name=X_68761_ }
C {devices/lab_pin.sym} 55900 -16980 0 0 {name=p55514 lab=_65685_/X }
C {devices/lab_pin.sym} 55900 -16940 0 0 {name=p55515 lab=_86236_/Q }
C {devices/lab_pin.sym} 55900 -16900 0 0 {name=p55516 lab=_65701_/X }
C {devices/lab_pin.sym} 55900 -16860 0 0 {name=p55517 lab=_65972_/X }
C {devices/lab_pin.sym} 56060 -16920 0 1 {name=p55518 lab=_65973_/X }
C {sky130_stdcells/a211o_4.sym} 55980 -16920 0 0 {name=X_65973_ }
C {devices/lab_pin.sym} 55940 -16770 0 0 {name=p55519 lab=_61083_/B }
C {devices/lab_pin.sym} 56020 -16770 0 1 {name=p55520 lab=_61096_/X }
C {sky130_stdcells/buf_2.sym} 55980 -16770 0 0 {name=X_61096_ }
C {devices/lab_pin.sym} 55920 -16660 0 0 {name=p55521 lab=_77954_/B }
C {devices/lab_pin.sym} 55920 -16620 0 0 {name=p55522 lab=_77954_/A }
C {devices/lab_pin.sym} 56040 -16640 0 1 {name=p55523 lab=_77960_/C }
C {sky130_stdcells/nand2_4.sym} 55980 -16640 0 0 {name=X_77959_ }
C {devices/lab_pin.sym} 55900 -16530 0 0 {name=p55524 lab=_81490_/D }
C {devices/lab_pin.sym} 55900 -16490 0 0 {name=p55525 lab=_67688_/X }
C {devices/lab_pin.sym} 55900 -16450 0 0 {name=p55526 lab=_67711_/X }
C {devices/lab_pin.sym} 56060 -16490 0 1 {name=p55527 lab=_67712_/X }
C {sky130_stdcells/a21bo_4.sym} 55980 -16490 0 0 {name=X_67712_ }
C {devices/lab_pin.sym} 55920 -16360 0 0 {name=p55528 lab=_64924_/A }
C {devices/lab_pin.sym} 55920 -16320 0 0 {name=p55529 lab=_86421_/Q }
C {devices/lab_pin.sym} 56040 -16340 0 1 {name=p55530 lab=_64924_/X }
C {sky130_stdcells/and2_4.sym} 55980 -16340 0 0 {name=X_64924_ }
C {devices/lab_pin.sym} 55920 -16230 0 0 {name=p55531 lab=_60064_/A }
C {devices/lab_pin.sym} 55920 -16190 0 0 {name=p55532 lab=_60081_/B }
C {devices/lab_pin.sym} 55920 -16150 0 0 {name=p55533 lab=_60047_/C }
C {devices/lab_pin.sym} 56040 -16190 0 1 {name=p55534 lab=_60047_/Y }
C {sky130_stdcells/nor3_4.sym} 55980 -16190 0 0 {name=X_60047_ }
C {devices/lab_pin.sym} 55900 -16070 0 0 {name=p55535 lab=_49856_/Y }
C {devices/lab_pin.sym} 55900 -16030 0 0 {name=p55536 lab=_49844_/X }
C {devices/lab_pin.sym} 55900 -15990 0 0 {name=p55537 lab=_49857_/X }
C {devices/lab_pin.sym} 56060 -16030 0 1 {name=p55538 lab=_86311_/D }
C {sky130_stdcells/a21oi_4.sym} 55980 -16030 0 0 {name=X_49858_ }
C {devices/lab_pin.sym} 55890 -15890 0 0 {name=p55539 lab=_80931_/CLK }
C {devices/lab_pin.sym} 55890 -15870 0 0 {name=p55540 lab=_75648_/X }
C {devices/lab_pin.sym} 56070 -15890 0 1 {name=p55541 lab=_80958_/D }
C {sky130_stdcells/dfxtp_4.sym} 55980 -15880 0 0 {name=X_80970_ }
C {devices/lab_pin.sym} 55940 -15750 0 0 {name=p55542 lab=_68692_/A }
C {devices/lab_pin.sym} 56020 -15750 0 1 {name=p55543 lab=_68693_/B }
C {sky130_stdcells/inv_2.sym} 55980 -15750 0 0 {name=X_68692_ }
C {devices/lab_pin.sym} 55940 -15630 0 0 {name=p55544 lab=_48836_/A }
C {devices/lab_pin.sym} 56020 -15630 0 1 {name=p55545 lab=_48809_/X }
C {sky130_stdcells/buf_2.sym} 55980 -15630 0 0 {name=X_48809_ }
C {devices/lab_pin.sym} 55900 -15540 0 0 {name=p55546 lab=_87974_/Q }
C {devices/lab_pin.sym} 55900 -15500 0 0 {name=p55547 lab=_67591_/X }
C {devices/lab_pin.sym} 55900 -15460 0 0 {name=p55548 lab=_67641_/X }
C {devices/lab_pin.sym} 55900 -15420 0 0 {name=p55549 lab=_67642_/X }
C {devices/lab_pin.sym} 56060 -15480 0 1 {name=p55550 lab=_67643_/X }
C {sky130_stdcells/a211o_4.sym} 55980 -15480 0 0 {name=X_67643_ }
C {devices/lab_pin.sym} 55920 -15340 0 0 {name=p55551 lab=_79629_/A }
C {devices/lab_pin.sym} 55920 -15300 0 0 {name=p55552 lab=_79629_/B }
C {devices/lab_pin.sym} 56040 -15320 0 1 {name=p55553 lab=_79629_/X }
C {sky130_stdcells/xor2_4.sym} 55980 -15320 0 0 {name=X_79629_ }
C {devices/lab_pin.sym} 55920 -15200 0 0 {name=p55554 lab=_64855_/A }
C {devices/lab_pin.sym} 55920 -15160 0 0 {name=p55555 lab=_64854_/X }
C {devices/lab_pin.sym} 56040 -15180 0 1 {name=p55556 lab=_64855_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -15180 0 0 {name=X_64855_ }
C {devices/lab_pin.sym} 55920 -15080 0 0 {name=p55557 lab=_49807_/A }
C {devices/lab_pin.sym} 55920 -15040 0 0 {name=p55558 lab=_49802_/B }
C {devices/lab_pin.sym} 55920 -15000 0 0 {name=p55559 lab=_49789_/C }
C {devices/lab_pin.sym} 55920 -14960 0 0 {name=p55560 lab=_53003_/D }
C {devices/lab_pin.sym} 56040 -15020 0 1 {name=p55561 lab=_49789_/X }
C {sky130_stdcells/and4_4.sym} 55980 -15020 0 0 {name=X_49789_ }
C {devices/lab_pin.sym} 55920 -14880 0 0 {name=p55562 lab=_51820_/A }
C {devices/lab_pin.sym} 55920 -14840 0 0 {name=p55563 lab=_46740_/X }
C {devices/lab_pin.sym} 56040 -14860 0 1 {name=p55564 lab=_51820_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -14860 0 0 {name=X_51820_ }
C {devices/lab_pin.sym} 55940 -14730 0 0 {name=p55565 lab=_60915_/X }
C {devices/lab_pin.sym} 56020 -14730 0 1 {name=p55566 lab=_63858_/B }
C {sky130_stdcells/buf_2.sym} 55980 -14730 0 0 {name=X_63806_ }
C {devices/lab_pin.sym} 55890 -14610 0 0 {name=p55567 lab=_82642_/CLK }
C {devices/lab_pin.sym} 55890 -14590 0 0 {name=p55568 lab=_82640_/D }
C {devices/lab_pin.sym} 56070 -14610 0 1 {name=p55569 lab=_78928_/A }
C {sky130_stdcells/dfxtp_4.sym} 55980 -14600 0 0 {name=X_82640_ }
C {devices/lab_pin.sym} 55900 -14490 0 0 {name=p55570 lab=_67571_/X }
C {devices/lab_pin.sym} 55900 -14450 0 0 {name=p55571 lab=_67573_/X }
C {devices/lab_pin.sym} 55900 -14410 0 0 {name=p55572 lab=_67502_/X }
C {devices/lab_pin.sym} 56060 -14450 0 1 {name=p55573 lab=_67577_/A }
C {sky130_stdcells/a21o_4.sym} 55980 -14450 0 0 {name=X_67574_ }
C {devices/lab_pin.sym} 55920 -14330 0 0 {name=p55574 lab=_64782_/X }
C {devices/lab_pin.sym} 55920 -14290 0 0 {name=p55575 lab=_64867_/B }
C {devices/lab_pin.sym} 55920 -14250 0 0 {name=p55576 lab=_64785_/X }
C {devices/lab_pin.sym} 56040 -14290 0 1 {name=p55577 lab=_64786_/Y }
C {sky130_stdcells/nand3_4.sym} 55980 -14290 0 0 {name=X_64786_ }
C {devices/lab_pin.sym} 55940 -14150 0 0 {name=p55578 lab=_61712_/X }
C {devices/lab_pin.sym} 56020 -14150 0 1 {name=p55579 lab=_61999_/B }
C {sky130_stdcells/buf_2.sym} 55980 -14150 0 0 {name=X_61998_ }
C {devices/lab_pin.sym} 55900 -14060 0 0 {name=p55580 lab=_69300_/X }
C {devices/lab_pin.sym} 55900 -14020 0 0 {name=p55581 lab=_69109_/X }
C {devices/lab_pin.sym} 55900 -13980 0 0 {name=p55582 lab=_69311_/Y }
C {devices/lab_pin.sym} 55900 -13940 0 0 {name=p55583 lab=_69312_/Y }
C {devices/lab_pin.sym} 56060 -14000 0 1 {name=p55584 lab=_69313_/X }
C {sky130_stdcells/a211o_4.sym} 55980 -14000 0 0 {name=X_69313_ }
C {devices/lab_pin.sym} 55900 -13870 0 0 {name=p55585 lab=_66522_/Y }
C {devices/lab_pin.sym} 55900 -13830 0 0 {name=p55586 lab=_59756_/X }
C {devices/lab_pin.sym} 55900 -13790 0 0 {name=p55587 lab=_66524_/X }
C {devices/lab_pin.sym} 56060 -13830 0 1 {name=p55588 lab=_84106_/D }
C {sky130_stdcells/a21o_4.sym} 55980 -13830 0 0 {name=X_66525_ }
C {devices/lab_pin.sym} 55900 -13710 0 0 {name=p55589 lab=_51745_/Y }
C {devices/lab_pin.sym} 55900 -13670 0 0 {name=p55590 lab=_51391_/X }
C {devices/lab_pin.sym} 55900 -13630 0 0 {name=p55591 lab=_51750_/X }
C {devices/lab_pin.sym} 56060 -13670 0 1 {name=p55592 lab=_51751_/Y }
C {sky130_stdcells/a21oi_4.sym} 55980 -13670 0 0 {name=X_51751_ }
C {devices/lab_pin.sym} 55940 -13530 0 0 {name=p55593 lab=_60882_/X }
C {devices/lab_pin.sym} 56020 -13530 0 1 {name=p55594 lab=_63738_/C }
C {sky130_stdcells/buf_2.sym} 55980 -13530 0 0 {name=X_63737_ }
C {devices/lab_pin.sym} 55890 -13410 0 0 {name=p55595 lab=_82570_/CLK }
C {devices/lab_pin.sym} 55890 -13390 0 0 {name=p55596 lab=_82571_/D }
C {devices/lab_pin.sym} 56070 -13410 0 1 {name=p55597 lab=_82571_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -13400 0 0 {name=X_82571_ }
C {devices/lab_pin.sym} 55940 -13270 0 0 {name=p55598 lab=clkbuf_2_2_1_CLK/A }
C {devices/lab_pin.sym} 56020 -13270 0 1 {name=p55599 lab=clkbuf_2_2_2_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 55980 -13270 0 0 {name=Xclkbuf_2_2_1_CLK }
C {devices/lab_pin.sym} 55940 -13150 0 0 {name=p55600 lab=_60864_/X }
C {devices/lab_pin.sym} 56020 -13150 0 1 {name=p55601 lab=_64182_/D }
C {sky130_stdcells/buf_2.sym} 55980 -13150 0 0 {name=X_60949_ }
C {devices/lab_pin.sym} 55890 -13030 0 0 {name=p55602 lab=_84314_/CLK }
C {devices/lab_pin.sym} 55890 -13010 0 0 {name=p55603 lab=_84310_/D }
C {devices/lab_pin.sym} 56070 -13030 0 1 {name=p55604 lab=_80422_/B }
C {sky130_stdcells/dfxtp_4.sym} 55980 -13020 0 0 {name=X_84310_ }
C {devices/lab_pin.sym} 55920 -12900 0 0 {name=p55605 lab=_50682_/A }
C {devices/lab_pin.sym} 55920 -12860 0 0 {name=p55606 lab=_50188_/B }
C {devices/lab_pin.sym} 56040 -12880 0 1 {name=p55607 lab=_50702_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -12880 0 0 {name=X_50702_ }
C {devices/lab_pin.sym} 55890 -12750 0 0 {name=p55608 lab=_81756_/CLK }
C {devices/lab_pin.sym} 55890 -12730 0 0 {name=p55609 lab=_81522_/D }
C {devices/lab_pin.sym} 56070 -12750 0 1 {name=p55610 lab=_81522_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -12740 0 0 {name=X_81522_ }
C {devices/lab_pin.sym} 55900 -12630 0 0 {name=p55611 lab=_83938_/Q }
C {devices/lab_pin.sym} 55900 -12590 0 0 {name=p55612 lab=_69230_/X }
C {devices/lab_pin.sym} 55900 -12550 0 0 {name=p55613 lab=_69243_/X }
C {devices/lab_pin.sym} 56060 -12590 0 1 {name=p55614 lab=_69244_/X }
C {sky130_stdcells/a21bo_4.sym} 55980 -12590 0 0 {name=X_69244_ }
C {devices/lab_pin.sym} 55900 -12470 0 0 {name=p55615 lab=_85436_/Q }
C {devices/lab_pin.sym} 55900 -12430 0 0 {name=p55616 lab=_54457_/X }
C {devices/lab_pin.sym} 55900 -12390 0 0 {name=p55617 lab=_54469_/Y }
C {devices/lab_pin.sym} 56060 -12430 0 1 {name=p55618 lab=_54470_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -12430 0 0 {name=X_54470_ }
C {devices/lab_pin.sym} 55900 -12310 0 0 {name=p55619 lab=_84120_/Q }
C {devices/lab_pin.sym} 55900 -12270 0 0 {name=p55620 lab=_65296_/X }
C {devices/lab_pin.sym} 55900 -12230 0 0 {name=p55621 lab=_66455_/Y }
C {devices/lab_pin.sym} 56060 -12270 0 1 {name=p55622 lab=_84120_/D }
C {sky130_stdcells/a21o_4.sym} 55980 -12270 0 0 {name=X_66456_ }
C {devices/lab_pin.sym} 55890 -12130 0 0 {name=p55623 lab=_80670_/CLK }
C {devices/lab_pin.sym} 55890 -12110 0 0 {name=p55624 lab=_85290_/D }
C {devices/lab_pin.sym} 56070 -12130 0 1 {name=p55625 lab=_85290_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -12120 0 0 {name=X_85290_ }
C {devices/lab_pin.sym} 55900 -12010 0 0 {name=p55626 lab=_85965_/Q }
C {devices/lab_pin.sym} 55900 -11970 0 0 {name=p55627 lab=_51675_/X }
C {devices/lab_pin.sym} 55900 -11930 0 0 {name=p55628 lab=_51681_/Y }
C {devices/lab_pin.sym} 56060 -11970 0 1 {name=p55629 lab=_51682_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -11970 0 0 {name=X_51682_ }
C {devices/lab_pin.sym} 55900 -11870 0 0 {name=p55630 lab=_62126_/D }
C {devices/lab_pin.sym} 55900 -11830 0 0 {name=p55631 lab=_60780_/X }
C {devices/lab_pin.sym} 55900 -11790 0 0 {name=p55632 lab=_63357_/X }
C {devices/lab_pin.sym} 55900 -11750 0 0 {name=p55633 lab=_60766_/X }
C {devices/lab_pin.sym} 55900 -11710 0 0 {name=p55634 lab=_63667_/Y }
C {devices/lab_pin.sym} 56060 -11790 0 1 {name=p55635 lab=_63668_/X }
C {sky130_stdcells/a2111o_4.sym} 55980 -11790 0 0 {name=X_63668_ }
C {devices/lab_pin.sym} 55900 -11650 0 0 {name=p55636 lab=_53417_/Y }
C {devices/lab_pin.sym} 55900 -11610 0 0 {name=p55637 lab=_53408_/X }
C {devices/lab_pin.sym} 55900 -11570 0 0 {name=p55638 lab=_53420_/X }
C {devices/lab_pin.sym} 56060 -11610 0 1 {name=p55639 lab=_85637_/D }
C {sky130_stdcells/a21oi_4.sym} 55980 -11610 0 0 {name=X_53421_ }
C {devices/lab_pin.sym} 55940 -11470 0 0 {name=p55640 lab=_65407_/A }
C {devices/lab_pin.sym} 56020 -11470 0 1 {name=p55641 lab=_65407_/X }
C {sky130_stdcells/buf_2.sym} 55980 -11470 0 0 {name=X_65407_ }
C {devices/lab_pin.sym} 55890 -11350 0 0 {name=p55642 lab=_84241_/CLK }
C {devices/lab_pin.sym} 55890 -11330 0 0 {name=p55643 lab=_84241_/D }
C {devices/lab_pin.sym} 56070 -11350 0 1 {name=p55644 lab=_79629_/B }
C {sky130_stdcells/dfxtp_4.sym} 55980 -11340 0 0 {name=X_84241_ }
C {devices/lab_pin.sym} 55900 -11230 0 0 {name=p55645 lab=_86163_/Q }
C {devices/lab_pin.sym} 55900 -11190 0 0 {name=p55646 lab=_50626_/X }
C {devices/lab_pin.sym} 55900 -11150 0 0 {name=p55647 lab=_50632_/Y }
C {devices/lab_pin.sym} 56060 -11190 0 1 {name=p55648 lab=_50633_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -11190 0 0 {name=X_50633_ }
C {devices/lab_pin.sym} 55920 -11080 0 0 {name=p55649 lab=_61685_/A }
C {devices/lab_pin.sym} 55920 -11040 0 0 {name=p55650 lab=_62597_/B }
C {devices/lab_pin.sym} 55920 -11000 0 0 {name=p55651 lab=_59913_/A }
C {devices/lab_pin.sym} 55920 -10960 0 0 {name=p55652 lab=_62597_/D }
C {devices/lab_pin.sym} 56040 -11020 0 1 {name=p55653 lab=_62619_/Y }
C {sky130_stdcells/nand4_4.sym} 55980 -11020 0 0 {name=X_62619_ }
C {devices/lab_pin.sym} 55900 -10890 0 0 {name=p55654 lab=_83943_/Q }
C {devices/lab_pin.sym} 55900 -10850 0 0 {name=p55655 lab=_69161_/X }
C {devices/lab_pin.sym} 55900 -10810 0 0 {name=p55656 lab=_69174_/X }
C {devices/lab_pin.sym} 56060 -10850 0 1 {name=p55657 lab=_69175_/X }
C {sky130_stdcells/a21bo_4.sym} 55980 -10850 0 0 {name=X_69175_ }
C {devices/lab_pin.sym} 55890 -10710 0 0 {name=p55658 lab=_81433_/CLK }
C {devices/lab_pin.sym} 55890 -10690 0 0 {name=p55659 lab=_76753_/B }
C {devices/lab_pin.sym} 56070 -10710 0 1 {name=p55660 lab=_81453_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -10700 0 0 {name=X_81453_ }
C {devices/lab_pin.sym} 55940 -10570 0 0 {name=p55661 lab=_66046_/A }
C {devices/lab_pin.sym} 56020 -10570 0 1 {name=p55662 lab=_66389_/A }
C {sky130_stdcells/buf_2.sym} 55980 -10570 0 0 {name=X_66387_ }
C {devices/lab_pin.sym} 55900 -10480 0 0 {name=p55663 lab=_61558_/B }
C {devices/lab_pin.sym} 55900 -10440 0 0 {name=p55664 lab=_63548_/X }
C {devices/lab_pin.sym} 55900 -10400 0 0 {name=p55665 lab=_63597_/X }
C {devices/lab_pin.sym} 55900 -10360 0 0 {name=p55666 lab=_63598_/Y }
C {devices/lab_pin.sym} 56060 -10420 0 1 {name=p55667 lab=_63599_/X }
C {sky130_stdcells/a211o_4.sym} 55980 -10420 0 0 {name=X_63599_ }
C {devices/lab_pin.sym} 55920 -10280 0 0 {name=p55668 lab=_80393_/X }
C {devices/lab_pin.sym} 55920 -10240 0 0 {name=p55669 lab=_80404_/B }
C {devices/lab_pin.sym} 56040 -10260 0 1 {name=p55670 lab=_80404_/X }
C {sky130_stdcells/and2_4.sym} 55980 -10260 0 0 {name=X_80404_ }
C {devices/lab_pin.sym} 55900 -10160 0 0 {name=p55671 lab=_68121_/X }
C {devices/lab_pin.sym} 55900 -10120 0 0 {name=p55672 lab=_66791_/Y }
C {devices/lab_pin.sym} 55900 -10080 0 0 {name=p55673 lab=_68110_/X }
C {devices/lab_pin.sym} 55900 -10040 0 0 {name=p55674 lab=_68125_/Y }
C {devices/lab_pin.sym} 56060 -10100 0 1 {name=p55675 lab=_68126_/X }
C {sky130_stdcells/a211o_4.sym} 55980 -10100 0 0 {name=X_68126_ }
C {devices/lab_pin.sym} 55920 -9970 0 0 {name=p55676 lab=_56140_/A }
C {devices/lab_pin.sym} 55920 -9930 0 0 {name=p55677 lab=_56140_/B }
C {devices/lab_pin.sym} 55920 -9890 0 0 {name=p55678 lab=_85289_/Q }
C {devices/lab_pin.sym} 56040 -9930 0 1 {name=p55679 lab=_56140_/Y }
C {sky130_stdcells/nand3_4.sym} 55980 -9930 0 0 {name=X_56140_ }
C {devices/lab_pin.sym} 55940 -9790 0 0 {name=p55680 lab=_53352_/A }
C {devices/lab_pin.sym} 56020 -9790 0 1 {name=p55681 lab=_53353_/A }
C {sky130_stdcells/buf_2.sym} 55980 -9790 0 0 {name=X_53352_ }
C {devices/lab_pin.sym} 55900 -9700 0 0 {name=p55682 lab=_65211_/X }
C {devices/lab_pin.sym} 55900 -9660 0 0 {name=p55683 lab=_85509_/Q }
C {devices/lab_pin.sym} 55900 -9620 0 0 {name=p55684 lab=_65212_/X }
C {devices/lab_pin.sym} 55900 -9580 0 0 {name=p55685 lab=_65337_/X }
C {devices/lab_pin.sym} 56060 -9640 0 1 {name=p55686 lab=_65338_/X }
C {sky130_stdcells/a211o_4.sym} 55980 -9640 0 0 {name=X_65338_ }
C {devices/lab_pin.sym} 55890 -9490 0 0 {name=p55687 lab=_81233_/CLK }
C {devices/lab_pin.sym} 55890 -9470 0 0 {name=p55688 lab=_84172_/D }
C {devices/lab_pin.sym} 56070 -9490 0 1 {name=p55689 lab=_84172_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -9480 0 0 {name=X_84172_ }
C {devices/lab_pin.sym} 55940 -9350 0 0 {name=p55690 lab=_50534_/A }
C {devices/lab_pin.sym} 56020 -9350 0 1 {name=p55691 lab=_50607_/A }
C {sky130_stdcells/buf_2.sym} 55980 -9350 0 0 {name=X_50564_ }
C {devices/lab_pin.sym} 55890 -9230 0 0 {name=p55692 lab=_83918_/CLK }
C {devices/lab_pin.sym} 55890 -9210 0 0 {name=p55693 lab=_81384_/D }
C {devices/lab_pin.sym} 56070 -9230 0 1 {name=p55694 lab=_76847_/B }
C {sky130_stdcells/dfxtp_4.sym} 55980 -9220 0 0 {name=X_81384_ }
C {devices/lab_pin.sym} 55940 -9090 0 0 {name=p55695 lab=_71216_/A }
C {devices/lab_pin.sym} 56020 -9090 0 1 {name=p55696 lab=_71233_/A2 }
C {sky130_stdcells/buf_2.sym} 55980 -9090 0 0 {name=Xpsn_inst_psn_buff_7 }
C {devices/lab_pin.sym} 55920 -8980 0 0 {name=p55697 lab=_52299_/A }
C {devices/lab_pin.sym} 55920 -8940 0 0 {name=p55698 lab=_48963_/X }
C {devices/lab_pin.sym} 56040 -8960 0 1 {name=p55699 lab=_52303_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -8960 0 0 {name=X_52303_ }
C {devices/lab_pin.sym} 55890 -8830 0 0 {name=p55700 lab=_86213_/CLK }
C {devices/lab_pin.sym} 55890 -8810 0 0 {name=p55701 lab=_83123_/D }
C {devices/lab_pin.sym} 56070 -8830 0 1 {name=p55702 lab=_70128_/A }
C {sky130_stdcells/dfxtp_4.sym} 55980 -8820 0 0 {name=X_83123_ }
C {devices/lab_pin.sym} 55940 -8690 0 0 {name=p55703 lab=clkbuf_8_251_0_CLK/A }
C {devices/lab_pin.sym} 56020 -8690 0 1 {name=p55704 lab=clkbuf_9_501_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 55980 -8690 0 0 {name=Xclkbuf_8_250_0_CLK }
C {devices/lab_pin.sym} 55920 -8590 0 0 {name=p55705 lab=_56052_/A }
C {devices/lab_pin.sym} 55920 -8550 0 0 {name=p55706 lab=_56086_/B }
C {devices/lab_pin.sym} 55920 -8510 0 0 {name=p55707 lab=_55879_/B }
C {devices/lab_pin.sym} 56040 -8550 0 1 {name=p55708 lab=_56071_/Y }
C {sky130_stdcells/nand3_4.sym} 55980 -8550 0 0 {name=X_56071_ }
C {devices/lab_pin.sym} 55940 -8410 0 0 {name=p55709 lab=_80333_/Y }
C {devices/lab_pin.sym} 56020 -8410 0 1 {name=p55710 lab=_80336_/A }
C {sky130_stdcells/inv_2.sym} 55980 -8410 0 0 {name=X_80335_ }
C {devices/lab_pin.sym} 55940 -8290 0 0 {name=p55711 lab=_68057_/A }
C {devices/lab_pin.sym} 56020 -8290 0 1 {name=p55712 lab=_68377_/A }
C {sky130_stdcells/buf_2.sym} 55980 -8290 0 0 {name=X_68057_ }
C {devices/lab_pin.sym} 55940 -8170 0 0 {name=p55713 lab=_53311_/A }
C {devices/lab_pin.sym} 56020 -8170 0 1 {name=p55714 lab=_53293_/A }
C {sky130_stdcells/buf_2.sym} 55980 -8170 0 0 {name=X_53283_ }
C {devices/lab_pin.sym} 55900 -8070 0 0 {name=p55715 lab=_65267_/Y }
C {devices/lab_pin.sym} 55900 -8030 0 0 {name=p55716 lab=_65195_/X }
C {devices/lab_pin.sym} 55900 -7990 0 0 {name=p55717 lab=_65268_/X }
C {devices/lab_pin.sym} 56060 -8030 0 1 {name=p55718 lab=_84208_/D }
C {sky130_stdcells/a21o_4.sym} 55980 -8030 0 0 {name=X_65269_ }
C {devices/lab_pin.sym} 55900 -7910 0 0 {name=p55719 lab=_86189_/Q }
C {devices/lab_pin.sym} 55900 -7870 0 0 {name=p55720 lab=_50464_/X }
C {devices/lab_pin.sym} 55900 -7830 0 0 {name=p55721 lab=_50494_/Y }
C {devices/lab_pin.sym} 56060 -7870 0 1 {name=p55722 lab=_50495_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -7870 0 0 {name=X_50495_ }
C {devices/lab_pin.sym} 55920 -7740 0 0 {name=p55723 lab=_55037_/A }
C {devices/lab_pin.sym} 55920 -7700 0 0 {name=p55724 lab=_47639_/Y }
C {devices/lab_pin.sym} 56040 -7720 0 1 {name=p55725 lab=_55022_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -7720 0 0 {name=X_55022_ }
C {devices/lab_pin.sym} 55920 -7600 0 0 {name=p55726 lab=_66961_/X }
C {devices/lab_pin.sym} 55920 -7560 0 0 {name=p55727 lab=_86788_/Q }
C {devices/lab_pin.sym} 56040 -7580 0 1 {name=p55728 lab=_67008_/X }
C {sky130_stdcells/and2_4.sym} 55980 -7580 0 0 {name=X_67008_ }
C {devices/lab_pin.sym} 55900 -7470 0 0 {name=p55729 lab=_52231_/Y }
C {devices/lab_pin.sym} 55900 -7430 0 0 {name=p55730 lab=_52232_/X }
C {devices/lab_pin.sym} 55900 -7390 0 0 {name=p55731 lab=_52233_/X }
C {devices/lab_pin.sym} 56060 -7430 0 1 {name=p55732 lab=_85863_/D }
C {sky130_stdcells/a21oi_4.sym} 55980 -7430 0 0 {name=X_52234_ }
C {devices/lab_pin.sym} 55890 -7290 0 0 {name=p55733 lab=_85566_/CLK }
C {devices/lab_pin.sym} 55890 -7270 0 0 {name=p55734 lab=_83054_/D }
C {devices/lab_pin.sym} 56070 -7290 0 1 {name=p55735 lab=_83054_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -7280 0 0 {name=X_83054_ }
C {devices/lab_pin.sym} 55890 -7150 0 0 {name=p55736 lab=_82886_/CLK }
C {devices/lab_pin.sym} 55890 -7130 0 0 {name=p55737 lab=_87931_/D }
C {devices/lab_pin.sym} 56070 -7150 0 1 {name=p55738 lab=_87931_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -7140 0 0 {name=X_87931_ }
C {devices/lab_pin.sym} 55920 -7020 0 0 {name=p55739 lab=_80265_/Y }
C {devices/lab_pin.sym} 55920 -6980 0 0 {name=p55740 lab=_80266_/B }
C {devices/lab_pin.sym} 56040 -7000 0 1 {name=p55741 lab=_80266_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -7000 0 0 {name=X_80266_ }
C {devices/lab_pin.sym} 55890 -6870 0 0 {name=p55742 lab=_82005_/CLK }
C {devices/lab_pin.sym} 55890 -6850 0 0 {name=p55743 lab=_82005_/D }
C {devices/lab_pin.sym} 56070 -6870 0 1 {name=p55744 lab=_77134_/A }
C {sky130_stdcells/dfxtp_4.sym} 55980 -6860 0 0 {name=X_82005_ }
C {devices/lab_pin.sym} 55920 -6760 0 0 {name=p55745 lab=_60175_/A }
C {devices/lab_pin.sym} 55920 -6720 0 0 {name=p55746 lab=_60353_/B }
C {devices/lab_pin.sym} 55920 -6680 0 0 {name=p55747 lab=_60312_/C }
C {devices/lab_pin.sym} 55920 -6640 0 0 {name=p55748 lab=_60312_/D }
C {devices/lab_pin.sym} 56040 -6700 0 1 {name=p55749 lab=_59830_/Y }
C {sky130_stdcells/nand4_4.sym} 55980 -6700 0 0 {name=X_59830_ }
C {devices/lab_pin.sym} 55940 -6550 0 0 {name=p55750 lab=_52198_/A }
C {devices/lab_pin.sym} 56020 -6550 0 1 {name=p55751 lab=_52194_/B }
C {sky130_stdcells/buf_2.sym} 55980 -6550 0 0 {name=X_52165_ }
C {devices/lab_pin.sym} 55890 -6430 0 0 {name=p55752 lab=_87348_/CLK }
C {devices/lab_pin.sym} 55890 -6410 0 0 {name=p55753 lab=_87862_/D }
C {devices/lab_pin.sym} 56070 -6430 0 1 {name=p55754 lab=_87862_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -6420 0 0 {name=X_87862_ }
C {devices/lab_pin.sym} 55920 -6300 0 0 {name=p55755 lab=_80209_/A }
C {devices/lab_pin.sym} 55920 -6260 0 0 {name=p55756 lab=_80209_/B }
C {devices/lab_pin.sym} 56040 -6280 0 1 {name=p55757 lab=_80197_/Y }
C {sky130_stdcells/xnor2_4.sym} 55980 -6280 0 0 {name=X_80197_ }
C {devices/lab_pin.sym} 55900 -6170 0 0 {name=p55758 lab=_51113_/Y }
C {devices/lab_pin.sym} 55900 -6130 0 0 {name=p55759 lab=_51093_/X }
C {devices/lab_pin.sym} 55900 -6090 0 0 {name=p55760 lab=_51115_/X }
C {devices/lab_pin.sym} 56060 -6130 0 1 {name=p55761 lab=_51116_/Y }
C {sky130_stdcells/a21oi_4.sym} 55980 -6130 0 0 {name=X_51116_ }
C {devices/lab_pin.sym} 55940 -5990 0 0 {name=p55762 lab=clkbuf_9_130_0_CLK/X }
C {devices/lab_pin.sym} 56020 -5990 0 1 {name=p55763 lab=_83457_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55980 -5990 0 0 {name=Xclkbuf_10_260_0_CLK }
C {devices/lab_pin.sym} 55890 -5870 0 0 {name=p55764 lab=_81154_/CLK }
C {devices/lab_pin.sym} 55890 -5850 0 0 {name=p55765 lab=_46017_/X }
C {devices/lab_pin.sym} 56070 -5870 0 1 {name=p55766 lab=_67179_/B }
C {sky130_stdcells/dfxtp_4.sym} 55980 -5860 0 0 {name=X_86813_ }
C {devices/lab_pin.sym} 55920 -5740 0 0 {name=p55767 lab=_59761_/A }
C {devices/lab_pin.sym} 55920 -5700 0 0 {name=p55768 lab=_59761_/B }
C {devices/lab_pin.sym} 56040 -5720 0 1 {name=p55769 lab=_59761_/X }
C {sky130_stdcells/and2_4.sym} 55980 -5720 0 0 {name=X_59761_ }
C {devices/lab_pin.sym} 55900 -5620 0 0 {name=p55770 lab=_57043_/B }
C {devices/lab_pin.sym} 55900 -5580 0 0 {name=p55771 lab=_56971_/Y }
C {devices/lab_pin.sym} 55900 -5540 0 0 {name=p55772 lab=_56664_/Y }
C {devices/lab_pin.sym} 55900 -5500 0 0 {name=p55773 lab=_56972_/Y }
C {devices/lab_pin.sym} 56060 -5560 0 1 {name=p55774 lab=_56973_/X }
C {sky130_stdcells/a2bb2o_4.sym} 55980 -5560 0 0 {name=X_56973_ }
C {devices/lab_pin.sym} 55900 -5430 0 0 {name=p55775 lab=_65423_/B }
C {devices/lab_pin.sym} 55900 -5390 0 0 {name=p55776 lab=_52089_/X }
C {devices/lab_pin.sym} 55900 -5350 0 0 {name=p55777 lab=_52095_/Y }
C {devices/lab_pin.sym} 56060 -5390 0 1 {name=p55778 lab=_52096_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -5390 0 0 {name=X_52096_ }
C {devices/lab_pin.sym} 55920 -5260 0 0 {name=p55779 lab=_68746_/A }
C {devices/lab_pin.sym} 55920 -5220 0 0 {name=p55780 lab=_68959_/B }
C {devices/lab_pin.sym} 56040 -5240 0 1 {name=p55781 lab=_68959_/Y }
C {sky130_stdcells/nor2_4.sym} 55980 -5240 0 0 {name=X_68959_ }
C {devices/lab_pin.sym} 55890 -5110 0 0 {name=p55782 lab=_87553_/CLK }
C {devices/lab_pin.sym} 55890 -5090 0 0 {name=p55783 lab=_42639_/Y }
C {devices/lab_pin.sym} 56070 -5110 0 1 {name=p55784 lab=_87793_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -5100 0 0 {name=X_87793_ }
C {devices/lab_pin.sym} 55940 -4970 0 0 {name=p55785 lab=clkbuf_9_445_0_CLK/X }
C {devices/lab_pin.sym} 56020 -4970 0 1 {name=p55786 lab=_85542_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55980 -4970 0 0 {name=Xclkbuf_10_890_0_CLK }
C {devices/lab_pin.sym} 55900 -4870 0 0 {name=p55787 lab=_58641_/X }
C {devices/lab_pin.sym} 55900 -4830 0 0 {name=p55788 lab=_85941_/Q }
C {devices/lab_pin.sym} 55900 -4790 0 0 {name=p55789 lab=_58664_/X }
C {devices/lab_pin.sym} 56060 -4830 0 1 {name=p55790 lab=_58712_/X }
C {sky130_stdcells/o21a_4.sym} 55980 -4830 0 0 {name=X_58712_ }
C {devices/lab_pin.sym} 55940 -4690 0 0 {name=p55791 lab=_51101_/A }
C {devices/lab_pin.sym} 56020 -4690 0 1 {name=p55792 lab=_51047_/X }
C {sky130_stdcells/buf_2.sym} 55980 -4690 0 0 {name=X_51047_ }
C {devices/lab_pin.sym} 55920 -4580 0 0 {name=p55793 lab=_55949_/A }
C {devices/lab_pin.sym} 55920 -4540 0 0 {name=p55794 lab=_56041_/C }
C {devices/lab_pin.sym} 56040 -4560 0 1 {name=p55795 lab=_55924_/X }
C {sky130_stdcells/and2_4.sym} 55980 -4560 0 0 {name=X_55924_ }
C {devices/lab_pin.sym} 55890 -4430 0 0 {name=p55796 lab=_85529_/CLK }
C {devices/lab_pin.sym} 55890 -4410 0 0 {name=p55797 lab=_86744_/D }
C {devices/lab_pin.sym} 56070 -4430 0 1 {name=p55798 lab=_86744_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -4420 0 0 {name=X_86744_ }
C {devices/lab_pin.sym} 55920 -4300 0 0 {name=p55799 lab=_71970_/A }
C {devices/lab_pin.sym} 55920 -4260 0 0 {name=p55800 lab=_71970_/B }
C {devices/lab_pin.sym} 56040 -4280 0 1 {name=p55801 lab=_71970_/Y }
C {sky130_stdcells/nand2_4.sym} 55980 -4280 0 0 {name=X_71970_ }
C {devices/lab_pin.sym} 55890 -4150 0 0 {name=p55802 lab=_83957_/CLK }
C {devices/lab_pin.sym} 55890 -4130 0 0 {name=p55803 lab=_83956_/D }
C {devices/lab_pin.sym} 56070 -4150 0 1 {name=p55804 lab=_83956_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -4140 0 0 {name=X_83956_ }
C {devices/lab_pin.sym} 55940 -4010 0 0 {name=p55805 lab=_59648_/A }
C {devices/lab_pin.sym} 56020 -4010 0 1 {name=p55806 lab=_59692_/Y }
C {sky130_stdcells/inv_2.sym} 55980 -4010 0 0 {name=X_59692_ }
C {devices/lab_pin.sym} 55940 -3890 0 0 {name=p55807 lab=clkbuf_9_21_0_CLK/X }
C {devices/lab_pin.sym} 56020 -3890 0 1 {name=p55808 lab=_83846_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55980 -3890 0 0 {name=Xclkbuf_10_42_0_CLK }
C {devices/lab_pin.sym} 55940 -3770 0 0 {name=p55809 lab=clkbuf_8_190_0_CLK/X }
C {devices/lab_pin.sym} 56020 -3770 0 1 {name=p55810 lab=clkbuf_9_381_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 55980 -3770 0 0 {name=Xclkbuf_9_381_0_CLK }
C {devices/lab_pin.sym} 55900 -3670 0 0 {name=p55811 lab=_58625_/X }
C {devices/lab_pin.sym} 55900 -3630 0 0 {name=p55812 lab=_85467_/Q }
C {devices/lab_pin.sym} 55900 -3590 0 0 {name=p55813 lab=_58642_/X }
C {devices/lab_pin.sym} 56060 -3630 0 1 {name=p55814 lab=_58643_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -3630 0 0 {name=X_58643_ }
C {devices/lab_pin.sym} 55920 -3520 0 0 {name=p55815 lab=_70869_/A }
C {devices/lab_pin.sym} 55920 -3480 0 0 {name=p55816 lab=_70914_/B }
C {devices/lab_pin.sym} 55920 -3440 0 0 {name=p55817 lab=_70914_/C }
C {devices/lab_pin.sym} 55920 -3400 0 0 {name=p55818 lab=_70919_/D }
C {devices/lab_pin.sym} 56040 -3460 0 1 {name=p55819 lab=_70921_/Y }
C {sky130_stdcells/nand4_4.sym} 55980 -3460 0 0 {name=X_70921_ }
C {devices/lab_pin.sym} 55890 -3310 0 0 {name=p55820 lab=_87922_/CLK }
C {devices/lab_pin.sym} 55890 -3290 0 0 {name=p55821 lab=_78261_/B }
C {devices/lab_pin.sym} 56070 -3310 0 1 {name=p55822 lab=_41661_/A }
C {sky130_stdcells/dfxtp_4.sym} 55980 -3300 0 0 {name=X_82907_ }
C {devices/lab_pin.sym} 55920 -3180 0 0 {name=p55823 lab=_44079_/X }
C {devices/lab_pin.sym} 55920 -3140 0 0 {name=p55824 lab=_55855_/B }
C {devices/lab_pin.sym} 56040 -3160 0 1 {name=p55825 lab=_55855_/X }
C {sky130_stdcells/and2_4.sym} 55980 -3160 0 0 {name=X_55855_ }
C {devices/lab_pin.sym} 55890 -3030 0 0 {name=p55826 lab=_86353_/CLK }
C {devices/lab_pin.sym} 55890 -3010 0 0 {name=p55827 lab=_86675_/D }
C {devices/lab_pin.sym} 56070 -3030 0 1 {name=p55828 lab=_86675_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -3020 0 0 {name=X_86675_ }
C {devices/lab_pin.sym} 55890 -2890 0 0 {name=p55829 lab=_82339_/CLK }
C {devices/lab_pin.sym} 55890 -2870 0 0 {name=p55830 lab=_83887_/D }
C {devices/lab_pin.sym} 56070 -2890 0 1 {name=p55831 lab=_81959_/D }
C {sky130_stdcells/dfxtp_4.sym} 55980 -2880 0 0 {name=X_83887_ }
C {devices/lab_pin.sym} 55940 -2750 0 0 {name=p55832 lab=clkbuf_9_137_0_CLK/X }
C {devices/lab_pin.sym} 56020 -2750 0 1 {name=p55833 lab=_83761_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55980 -2750 0 0 {name=Xclkbuf_10_275_0_CLK }
C {devices/lab_pin.sym} 55940 -2630 0 0 {name=p55834 lab=_51949_/A }
C {devices/lab_pin.sym} 56020 -2630 0 1 {name=p55835 lab=_42820_/X }
C {sky130_stdcells/buf_2.sym} 55980 -2630 0 0 {name=X_42820_ }
C {devices/lab_pin.sym} 55900 -2530 0 0 {name=p55836 lab=_85374_/Q }
C {devices/lab_pin.sym} 55900 -2490 0 0 {name=p55837 lab=_54784_/X }
C {devices/lab_pin.sym} 55900 -2450 0 0 {name=p55838 lab=_54805_/Y }
C {devices/lab_pin.sym} 56060 -2490 0 1 {name=p55839 lab=_54806_/Y }
C {sky130_stdcells/o21ai_4.sym} 55980 -2490 0 0 {name=X_54806_ }
C {devices/lab_pin.sym} 55900 -2370 0 0 {name=p55840 lab=_73637_/X }
C {devices/lab_pin.sym} 55900 -2330 0 0 {name=p55841 lab=_73639_/X }
C {devices/lab_pin.sym} 55900 -2290 0 0 {name=p55842 lab=_73612_/X }
C {devices/lab_pin.sym} 56060 -2330 0 1 {name=p55843 lab=_73643_/A }
C {sky130_stdcells/a21o_4.sym} 55980 -2330 0 0 {name=X_73640_ }
C {devices/lab_pin.sym} 55890 -2190 0 0 {name=p55844 lab=_85630_/CLK }
C {devices/lab_pin.sym} 55890 -2170 0 0 {name=p55845 lab=_53494_/Y }
C {devices/lab_pin.sym} 56070 -2190 0 1 {name=p55846 lab=_85626_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -2180 0 0 {name=X_85626_ }
C {devices/lab_pin.sym} 55920 -2080 0 0 {name=p55847 lab=_70905_/A }
C {devices/lab_pin.sym} 55920 -2040 0 0 {name=p55848 lab=_70890_/B }
C {devices/lab_pin.sym} 55920 -2000 0 0 {name=p55849 lab=_70852_/C }
C {devices/lab_pin.sym} 55920 -1960 0 0 {name=p55850 lab=_70860_/D }
C {devices/lab_pin.sym} 56040 -2020 0 1 {name=p55851 lab=_70852_/Y }
C {sky130_stdcells/nand4_4.sym} 55980 -2020 0 0 {name=X_70852_ }
C {devices/lab_pin.sym} 55900 -1890 0 0 {name=p55852 lab=_58570_/Y }
C {devices/lab_pin.sym} 55900 -1850 0 0 {name=p55853 lab=_58573_/Y }
C {devices/lab_pin.sym} 55900 -1810 0 0 {name=p55854 lab=_58105_/X }
C {devices/lab_pin.sym} 56060 -1850 0 1 {name=p55855 lab=_58574_/X }
C {sky130_stdcells/a21o_4.sym} 55980 -1850 0 0 {name=X_58574_ }
C {devices/lab_pin.sym} 55890 -1710 0 0 {name=p55856 lab=_84177_/CLK }
C {devices/lab_pin.sym} 55890 -1690 0 0 {name=p55857 lab=_82838_/D }
C {devices/lab_pin.sym} 56070 -1710 0 1 {name=p55858 lab=_82838_/Q }
C {sky130_stdcells/dfxtp_4.sym} 55980 -1700 0 0 {name=X_82838_ }
C {devices/lab_pin.sym} 55900 -1600 0 0 {name=p55859 lab=_85195_/Q }
C {devices/lab_pin.sym} 55900 -1560 0 0 {name=p55860 lab=_55747_/X }
C {devices/lab_pin.sym} 55900 -1520 0 0 {name=p55861 lab=_55300_/X }
C {devices/lab_pin.sym} 55900 -1480 0 0 {name=p55862 lab=_55785_/X }
C {devices/lab_pin.sym} 56060 -1540 0 1 {name=p55863 lab=_55786_/X }
C {sky130_stdcells/a211o_4.sym} 55980 -1540 0 0 {name=X_55786_ }
C {devices/lab_pin.sym} 55900 -1410 0 0 {name=p55864 lab=_52996_/Y }
C {devices/lab_pin.sym} 55900 -1370 0 0 {name=p55865 lab=_52975_/X }
C {devices/lab_pin.sym} 55900 -1330 0 0 {name=p55866 lab=_52997_/X }
C {devices/lab_pin.sym} 56060 -1370 0 1 {name=p55867 lab=_52998_/Y }
C {sky130_stdcells/a21oi_4.sym} 55980 -1370 0 0 {name=X_52998_ }
C {devices/lab_pin.sym} 55920 -1250 0 0 {name=p55868 lab=_47917_/A }
C {devices/lab_pin.sym} 55920 -1210 0 0 {name=p55869 lab=_49317_/X }
C {devices/lab_pin.sym} 55920 -1170 0 0 {name=p55870 lab=_46603_/X }
C {devices/lab_pin.sym} 56040 -1210 0 1 {name=p55871 lab=_57525_/X }
C {sky130_stdcells/and3_4.sym} 55980 -1210 0 0 {name=X_57525_ }
C {devices/lab_pin.sym} 55890 -1070 0 0 {name=p55872 lab=_88345_/CLK }
C {devices/lab_pin.sym} 55890 -1050 0 0 {name=p55873 lab=_40735_/X }
C {devices/lab_pin.sym} 56070 -1070 0 1 {name=p55874 lab=_69004_/B }
C {sky130_stdcells/dfxtp_4.sym} 55980 -1060 0 0 {name=X_88345_ }
C {devices/lab_pin.sym} 55940 -930 0 0 {name=p55875 lab=clkbuf_9_28_0_CLK/X }
C {devices/lab_pin.sym} 56020 -930 0 1 {name=p55876 lab=_85103_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 55980 -930 0 0 {name=Xclkbuf_10_57_0_CLK }
C {devices/lab_pin.sym} 55900 -850 0 0 {name=p55877 lab=_42739_/X }
C {devices/lab_pin.sym} 55900 -810 0 0 {name=p55878 lab=_42740_/X }
C {devices/lab_pin.sym} 55900 -770 0 0 {name=p55879 lab=_41245_/X }
C {devices/lab_pin.sym} 55900 -730 0 0 {name=p55880 lab=_87739_/Q }
C {devices/lab_pin.sym} 55900 -690 0 0 {name=p55881 lab=_42750_/X }
C {devices/lab_pin.sym} 56060 -770 0 1 {name=p55882 lab=_42752_/A }
C {sky130_stdcells/o32ai_4.sym} 55980 -770 0 0 {name=X_42751_ }
C {devices/lab_pin.sym} 56820 -42170 0 0 {name=p55883 lab=_85387_/Q }
C {devices/lab_pin.sym} 56820 -42130 0 0 {name=p55884 lab=_54729_/X }
C {devices/lab_pin.sym} 56820 -42090 0 0 {name=p55885 lab=_54736_/Y }
C {devices/lab_pin.sym} 56980 -42130 0 1 {name=p55886 lab=_54737_/Y }
C {sky130_stdcells/o21ai_4.sym} 56900 -42130 0 0 {name=X_54737_ }
C {devices/lab_pin.sym} 56810 -41990 0 0 {name=p55887 lab=_85557_/CLK }
C {devices/lab_pin.sym} 56810 -41970 0 0 {name=p55888 lab=_53845_/Y }
C {devices/lab_pin.sym} 56990 -41990 0 1 {name=p55889 lab=_85557_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -41980 0 0 {name=X_85557_ }
C {devices/lab_pin.sym} 56840 -41860 0 0 {name=p55890 lab=_47830_/Y }
C {devices/lab_pin.sym} 56840 -41820 0 0 {name=p55891 lab=_73570_/Y }
C {devices/lab_pin.sym} 56960 -41840 0 1 {name=p55892 lab=_73572_/B }
C {sky130_stdcells/xor2_4.sym} 56900 -41840 0 0 {name=X_73571_ }
C {devices/lab_pin.sym} 56860 -41710 0 0 {name=p55893 lab=_51949_/A }
C {devices/lab_pin.sym} 56940 -41710 0 1 {name=p55894 lab=_52618_/A }
C {sky130_stdcells/buf_2.sym} 56900 -41710 0 0 {name=X_51949_ }
C {devices/lab_pin.sym} 56860 -41590 0 0 {name=p55895 lab=_70848_/A }
C {devices/lab_pin.sym} 56940 -41590 0 1 {name=p55896 lab=_70791_/B }
C {sky130_stdcells/buf_2.sym} 56900 -41590 0 0 {name=X_70783_ }
C {devices/lab_pin.sym} 56810 -41470 0 0 {name=p55897 lab=_82769_/CLK }
C {devices/lab_pin.sym} 56810 -41450 0 0 {name=p55898 lab=_82769_/D }
C {devices/lab_pin.sym} 56990 -41470 0 1 {name=p55899 lab=_82769_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -41460 0 0 {name=X_82769_ }
C {devices/lab_pin.sym} 56860 -41330 0 0 {name=p55900 lab=clkbuf_8_198_0_CLK/X }
C {devices/lab_pin.sym} 56940 -41330 0 1 {name=p55901 lab=clkbuf_9_396_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 56900 -41330 0 0 {name=Xclkbuf_9_396_0_CLK }
C {devices/lab_pin.sym} 56840 -41220 0 0 {name=p55902 lab=_80786_/Q }
C {devices/lab_pin.sym} 56840 -41180 0 0 {name=p55903 lab=_81042_/D }
C {devices/lab_pin.sym} 56960 -41200 0 1 {name=p55904 lab=_80754_/D }
C {sky130_stdcells/xor2_4.sym} 56900 -41200 0 0 {name=X_75310_ }
C {devices/lab_pin.sym} 56820 -41100 0 0 {name=p55905 lab=_41701_/X }
C {devices/lab_pin.sym} 56820 -41060 0 0 {name=p55906 lab=_41682_/X }
C {devices/lab_pin.sym} 56820 -41020 0 0 {name=p55907 lab=_67659_/B }
C {devices/lab_pin.sym} 56820 -40980 0 0 {name=p55908 lab=_41684_/X }
C {devices/lab_pin.sym} 56980 -41040 0 1 {name=p55909 lab=_88166_/D }
C {sky130_stdcells/a2bb2o_4.sym} 56900 -41040 0 0 {name=X_41702_ }
C {devices/lab_pin.sym} 56860 -40890 0 0 {name=p55910 lab=clkbuf_8_203_0_CLK/A }
C {devices/lab_pin.sym} 56940 -40890 0 1 {name=p55911 lab=clkbuf_9_407_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 56900 -40890 0 0 {name=Xclkbuf_8_203_0_CLK }
C {devices/lab_pin.sym} 56840 -40800 0 0 {name=p55912 lab=_61368_/D }
C {devices/lab_pin.sym} 56840 -40760 0 0 {name=p55913 lab=_72516_/A }
C {devices/lab_pin.sym} 56840 -40720 0 0 {name=p55914 lab=_72607_/C }
C {devices/lab_pin.sym} 56840 -40680 0 0 {name=p55915 lab=_72563_/C }
C {devices/lab_pin.sym} 56960 -40740 0 1 {name=p55916 lab=_72522_/Y }
C {sky130_stdcells/nand4_4.sym} 56900 -40740 0 0 {name=X_72522_ }
C {devices/lab_pin.sym} 56810 -40590 0 0 {name=p55917 lab=_84508_/CLK }
C {devices/lab_pin.sym} 56810 -40570 0 0 {name=p55918 lab=_84508_/D }
C {devices/lab_pin.sym} 56990 -40590 0 1 {name=p55919 lab=_61203_/C }
C {sky130_stdcells/dfxtp_4.sym} 56900 -40580 0 0 {name=X_84508_ }
C {devices/lab_pin.sym} 56860 -40450 0 0 {name=p55920 lab=_45470_/A }
C {devices/lab_pin.sym} 56940 -40450 0 1 {name=p55921 lab=_45470_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -40450 0 0 {name=X_45470_ }
C {devices/lab_pin.sym} 56820 -40350 0 0 {name=p55922 lab=_57440_/X }
C {devices/lab_pin.sym} 56820 -40310 0 0 {name=p55923 lab=_57454_/X }
C {devices/lab_pin.sym} 56820 -40270 0 0 {name=p55924 lab=_57455_/Y }
C {devices/lab_pin.sym} 56980 -40310 0 1 {name=p55925 lab=_57456_/Y }
C {sky130_stdcells/o21ai_4.sym} 56900 -40310 0 0 {name=X_57456_ }
C {devices/lab_pin.sym} 56840 -40180 0 0 {name=p55926 lab=_81644_/Q }
C {devices/lab_pin.sym} 56840 -40140 0 0 {name=p55927 lab=_76290_/B }
C {devices/lab_pin.sym} 56960 -40160 0 1 {name=p55928 lab=_76309_/B }
C {sky130_stdcells/xnor2_4.sym} 56900 -40160 0 0 {name=X_76290_ }
C {devices/lab_pin.sym} 56820 -40060 0 0 {name=p55929 lab=_41059_/X }
C {devices/lab_pin.sym} 56820 -40020 0 0 {name=p55930 lab=_42679_/X }
C {devices/lab_pin.sym} 56820 -39980 0 0 {name=p55931 lab=_87773_/Q }
C {devices/lab_pin.sym} 56820 -39940 0 0 {name=p55932 lab=_42681_/X }
C {devices/lab_pin.sym} 56980 -40000 0 1 {name=p55933 lab=_87773_/D }
C {sky130_stdcells/a2bb2o_4.sym} 56900 -40000 0 0 {name=X_42682_ }
C {devices/lab_pin.sym} 56810 -39850 0 0 {name=p55934 lab=_88283_/CLK }
C {devices/lab_pin.sym} 56810 -39830 0 0 {name=p55935 lab=_41111_/X }
C {devices/lab_pin.sym} 56990 -39850 0 1 {name=p55936 lab=_69558_/B }
C {sky130_stdcells/dfxtp_4.sym} 56900 -39840 0 0 {name=X_88276_ }
C {devices/lab_pin.sym} 56820 -39730 0 0 {name=p55937 lab=_54665_/Y }
C {devices/lab_pin.sym} 56820 -39690 0 0 {name=p55938 lab=_54666_/X }
C {devices/lab_pin.sym} 56820 -39650 0 0 {name=p55939 lab=_54667_/X }
C {devices/lab_pin.sym} 56980 -39690 0 1 {name=p55940 lab=_54668_/Y }
C {sky130_stdcells/a21oi_4.sym} 56900 -39690 0 0 {name=X_54668_ }
C {devices/lab_pin.sym} 56810 -39550 0 0 {name=p55941 lab=_83736_/CLK }
C {devices/lab_pin.sym} 56810 -39530 0 0 {name=p55942 lab=_54187_/Y }
C {devices/lab_pin.sym} 56990 -39550 0 1 {name=p55943 lab=_85488_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -39540 0 0 {name=X_85488_ }
C {devices/lab_pin.sym} 56820 -39440 0 0 {name=p55944 lab=_41560_/X }
C {devices/lab_pin.sym} 56820 -39400 0 0 {name=p55945 lab=_44412_/X }
C {devices/lab_pin.sym} 56820 -39360 0 0 {name=p55946 lab=_87116_/Q }
C {devices/lab_pin.sym} 56820 -39320 0 0 {name=p55947 lab=_44413_/X }
C {devices/lab_pin.sym} 56980 -39380 0 1 {name=p55948 lab=_87116_/D }
C {sky130_stdcells/a2bb2o_4.sym} 56900 -39380 0 0 {name=X_44421_ }
C {devices/lab_pin.sym} 56840 -39250 0 0 {name=p55949 lab=_56397_/X }
C {devices/lab_pin.sym} 56840 -39210 0 0 {name=p55950 lab=_56399_/B }
C {devices/lab_pin.sym} 56840 -39170 0 0 {name=p55951 lab=_56407_/C }
C {devices/lab_pin.sym} 56960 -39210 0 1 {name=p55952 lab=_56407_/Y }
C {sky130_stdcells/nand3_4.sym} 56900 -39210 0 0 {name=X_56407_ }
C {devices/lab_pin.sym} 56840 -39080 0 0 {name=p55953 lab=_75237_/X }
C {devices/lab_pin.sym} 56840 -39040 0 0 {name=p55954 lab=_75240_/X }
C {devices/lab_pin.sym} 56960 -39060 0 1 {name=p55955 lab=_75241_/Y }
C {sky130_stdcells/xnor2_4.sym} 56900 -39060 0 0 {name=X_75241_ }
C {devices/lab_pin.sym} 56810 -38930 0 0 {name=p55956 lab=_87487_/CLK }
C {devices/lab_pin.sym} 56810 -38910 0 0 {name=p55957 lab=_43867_/Y }
C {devices/lab_pin.sym} 56990 -38930 0 1 {name=p55958 lab=_87227_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -38920 0 0 {name=X_87227_ }
C {devices/lab_pin.sym} 56860 -38790 0 0 {name=p55959 lab=_53747_/A }
C {devices/lab_pin.sym} 56940 -38790 0 1 {name=p55960 lab=_53619_/X }
C {sky130_stdcells/buf_2.sym} 56900 -38790 0 0 {name=X_53619_ }
C {devices/lab_pin.sym} 56860 -38670 0 0 {name=p55961 lab=_41632_/Y }
C {devices/lab_pin.sym} 56940 -38670 0 1 {name=p55962 lab=_88179_/D }
C {sky130_stdcells/inv_2.sym} 56900 -38670 0 0 {name=X_41633_ }
C {devices/lab_pin.sym} 56820 -38570 0 0 {name=p55963 lab=_72450_/Y }
C {devices/lab_pin.sym} 56820 -38530 0 0 {name=p55964 lab=_72452_/Y }
C {devices/lab_pin.sym} 56820 -38490 0 0 {name=p55965 lab=_57779_/X }
C {devices/lab_pin.sym} 56980 -38530 0 1 {name=p55966 lab=_72453_/X }
C {sky130_stdcells/a21o_4.sym} 56900 -38530 0 0 {name=X_72453_ }
C {devices/lab_pin.sym} 56810 -38390 0 0 {name=p55967 lab=_84441_/CLK }
C {devices/lab_pin.sym} 56810 -38370 0 0 {name=p55968 lab=_62018_/Y }
C {devices/lab_pin.sym} 56990 -38390 0 1 {name=p55969 lab=_78062_/B }
C {sky130_stdcells/dfxtp_4.sym} 56900 -38380 0 0 {name=X_84439_ }
C {devices/lab_pin.sym} 56820 -38280 0 0 {name=p55970 lab=_57384_/X }
C {devices/lab_pin.sym} 56820 -38240 0 0 {name=p55971 lab=_56575_/X }
C {devices/lab_pin.sym} 56820 -38200 0 0 {name=p55972 lab=_85023_/Q }
C {devices/lab_pin.sym} 56820 -38160 0 0 {name=p55973 lab=_57385_/X }
C {devices/lab_pin.sym} 56980 -38220 0 1 {name=p55974 lab=_57387_/X }
C {sky130_stdcells/a2bb2o_4.sym} 56900 -38220 0 0 {name=X_57387_ }
C {devices/lab_pin.sym} 56820 -38090 0 0 {name=p55975 lab=_54597_/Y }
C {devices/lab_pin.sym} 56820 -38050 0 0 {name=p55976 lab=_54584_/X }
C {devices/lab_pin.sym} 56820 -38010 0 0 {name=p55977 lab=_54598_/X }
C {devices/lab_pin.sym} 56980 -38050 0 1 {name=p55978 lab=_85413_/D }
C {sky130_stdcells/a21oi_4.sym} 56900 -38050 0 0 {name=X_54599_ }
C {devices/lab_pin.sym} 56860 -37910 0 0 {name=p55979 lab=_47140_/A }
C {devices/lab_pin.sym} 56940 -37910 0 1 {name=p55980 lab=_47143_/C }
C {sky130_stdcells/buf_2.sym} 56900 -37910 0 0 {name=X_47140_ }
C {devices/lab_pin.sym} 56840 -37810 0 0 {name=p55981 lab=_70676_/A }
C {devices/lab_pin.sym} 56840 -37770 0 0 {name=p55982 lab=_71404_/B }
C {devices/lab_pin.sym} 56840 -37730 0 0 {name=p55983 lab=_71411_/C }
C {devices/lab_pin.sym} 56960 -37770 0 1 {name=p55984 lab=_71404_/Y }
C {sky130_stdcells/nor3_4.sym} 56900 -37770 0 0 {name=X_71404_ }
C {devices/lab_pin.sym} 56820 -37650 0 0 {name=p55985 lab=_59061_/X }
C {devices/lab_pin.sym} 56820 -37610 0 0 {name=p55986 lab=_86071_/Q }
C {devices/lab_pin.sym} 56820 -37570 0 0 {name=p55987 lab=_59125_/X }
C {devices/lab_pin.sym} 56980 -37610 0 1 {name=p55988 lab=_59126_/Y }
C {sky130_stdcells/o21ai_4.sym} 56900 -37610 0 0 {name=X_59126_ }
C {devices/lab_pin.sym} 56860 -37470 0 0 {name=p55989 lab=_44624_/A }
C {devices/lab_pin.sym} 56940 -37470 0 1 {name=p55990 lab=_44352_/X }
C {sky130_stdcells/buf_2.sym} 56900 -37470 0 0 {name=X_44352_ }
C {devices/lab_pin.sym} 56860 -37350 0 0 {name=p55991 lab=_56351_/A }
C {devices/lab_pin.sym} 56940 -37350 0 1 {name=p55992 lab=_56345_/B }
C {sky130_stdcells/buf_2.sym} 56900 -37350 0 0 {name=X_56338_ }
C {devices/lab_pin.sym} 56860 -37230 0 0 {name=p55993 lab=_75175_/B }
C {devices/lab_pin.sym} 56940 -37230 0 1 {name=p55994 lab=_75172_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -37230 0 0 {name=X_75172_ }
C {devices/lab_pin.sym} 56810 -37110 0 0 {name=p55995 lab=_87471_/CLK }
C {devices/lab_pin.sym} 56810 -37090 0 0 {name=p55996 lab=_87158_/D }
C {devices/lab_pin.sym} 56990 -37110 0 1 {name=p55997 lab=_87158_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -37100 0 0 {name=X_87158_ }
C {devices/lab_pin.sym} 56820 -36990 0 0 {name=p55998 lab=_41533_/X }
C {devices/lab_pin.sym} 56820 -36950 0 0 {name=p55999 lab=_40489_/A }
C {devices/lab_pin.sym} 56820 -36910 0 0 {name=p56000 lab=_41563_/X }
C {devices/lab_pin.sym} 56980 -36950 0 1 {name=p56001 lab=_41564_/X }
C {sky130_stdcells/o21a_4.sym} 56900 -36950 0 0 {name=X_41564_ }
C {devices/lab_pin.sym} 56840 -36820 0 0 {name=p56002 lab=_72384_/A }
C {devices/lab_pin.sym} 56840 -36780 0 0 {name=p56003 lab=_72428_/B }
C {devices/lab_pin.sym} 56960 -36800 0 1 {name=p56004 lab=_72384_/Y }
C {sky130_stdcells/nor2_4.sym} 56900 -36800 0 0 {name=X_72384_ }
C {devices/lab_pin.sym} 56860 -36670 0 0 {name=p56005 lab=clkbuf_8_219_0_CLK/A }
C {devices/lab_pin.sym} 56940 -36670 0 1 {name=p56006 lab=clkbuf_8_218_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 56900 -36670 0 0 {name=Xclkbuf_8_218_0_CLK }
C {devices/lab_pin.sym} 56820 -36580 0 0 {name=p56007 lab=_41203_/X }
C {devices/lab_pin.sym} 56820 -36540 0 0 {name=p56008 lab=_43300_/X }
C {devices/lab_pin.sym} 56820 -36500 0 0 {name=p56009 lab=_87490_/Q }
C {devices/lab_pin.sym} 56820 -36460 0 0 {name=p56010 lab=_43302_/X }
C {devices/lab_pin.sym} 56980 -36520 0 1 {name=p56011 lab=_87490_/D }
C {sky130_stdcells/a2bb2o_4.sym} 56900 -36520 0 0 {name=X_43303_ }
C {devices/lab_pin.sym} 56840 -36380 0 0 {name=p56012 lab=_74123_/A }
C {devices/lab_pin.sym} 56840 -36340 0 0 {name=p56013 lab=_73195_/A }
C {devices/lab_pin.sym} 56960 -36360 0 1 {name=p56014 lab=_74123_/Y }
C {sky130_stdcells/nor2_4.sym} 56900 -36360 0 0 {name=X_74123_ }
C {devices/lab_pin.sym} 56860 -36230 0 0 {name=p56015 lab=clkbuf_9_106_0_CLK/X }
C {devices/lab_pin.sym} 56940 -36230 0 1 {name=p56016 lab=_84645_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 56900 -36230 0 0 {name=Xclkbuf_10_213_0_CLK }
C {devices/lab_pin.sym} 56810 -36110 0 0 {name=p56017 lab=_84807_/CLK }
C {devices/lab_pin.sym} 56810 -36090 0 0 {name=p56018 lab=_86109_/D }
C {devices/lab_pin.sym} 56990 -36110 0 1 {name=p56019 lab=_86109_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -36100 0 0 {name=X_86109_ }
C {devices/lab_pin.sym} 56860 -35970 0 0 {name=p56020 lab=_40514_/X }
C {devices/lab_pin.sym} 56940 -35970 0 1 {name=p56021 lab=_40515_/X }
C {sky130_stdcells/buf_2.sym} 56900 -35970 0 0 {name=X_40515_ }
C {devices/lab_pin.sym} 56840 -35860 0 0 {name=p56022 lab=_47063_/A }
C {devices/lab_pin.sym} 56840 -35820 0 0 {name=p56023 lab=_52837_/B }
C {devices/lab_pin.sym} 56960 -35840 0 1 {name=p56024 lab=_47071_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -35840 0 0 {name=X_47071_ }
C {devices/lab_pin.sym} 56840 -35720 0 0 {name=p56025 lab=_59057_/A }
C {devices/lab_pin.sym} 56840 -35680 0 0 {name=p56026 lab=_59008_/B }
C {devices/lab_pin.sym} 56960 -35700 0 1 {name=p56027 lab=_59057_/Y }
C {sky130_stdcells/nor2_4.sym} 56900 -35700 0 0 {name=X_59057_ }
C {devices/lab_pin.sym} 56840 -35590 0 0 {name=p56028 lab=_71335_/A }
C {devices/lab_pin.sym} 56840 -35550 0 0 {name=p56029 lab=_71335_/B }
C {devices/lab_pin.sym} 56840 -35510 0 0 {name=p56030 lab=_71313_/X }
C {devices/lab_pin.sym} 56960 -35550 0 1 {name=p56031 lab=_71335_/Y }
C {sky130_stdcells/nand3_4.sym} 56900 -35550 0 0 {name=X_71335_ }
C {devices/lab_pin.sym} 56860 -35410 0 0 {name=p56032 lab=_56245_/A }
C {devices/lab_pin.sym} 56940 -35410 0 1 {name=p56033 lab=_56270_/B }
C {sky130_stdcells/buf_2.sym} 56900 -35410 0 0 {name=X_56269_ }
C {devices/lab_pin.sym} 56860 -35290 0 0 {name=p56034 lab=_44282_/X }
C {devices/lab_pin.sym} 56940 -35290 0 1 {name=p56035 lab=_57650_/A }
C {sky130_stdcells/buf_2.sym} 56900 -35290 0 0 {name=X_44283_ }
C {devices/lab_pin.sym} 56840 -35180 0 0 {name=p56036 lab=_79980_/A }
C {devices/lab_pin.sym} 56840 -35140 0 0 {name=p56037 lab=_79980_/B }
C {devices/lab_pin.sym} 56960 -35160 0 1 {name=p56038 lab=_79982_/A }
C {sky130_stdcells/nand2_4.sym} 56900 -35160 0 0 {name=X_79980_ }
C {devices/lab_pin.sym} 56810 -35030 0 0 {name=p56039 lab=_88267_/CLK }
C {devices/lab_pin.sym} 56810 -35010 0 0 {name=p56040 lab=_44476_/X }
C {devices/lab_pin.sym} 56990 -35030 0 1 {name=p56041 lab=_87089_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -35020 0 0 {name=X_87089_ }
C {devices/lab_pin.sym} 56860 -34890 0 0 {name=p56042 lab=_41494_/Y }
C {devices/lab_pin.sym} 56940 -34890 0 1 {name=p56043 lab=_88205_/D }
C {sky130_stdcells/inv_2.sym} 56900 -34890 0 0 {name=X_41495_ }
C {devices/lab_pin.sym} 56860 -34770 0 0 {name=p56044 lab=clkbuf_9_421_0_CLK/X }
C {devices/lab_pin.sym} 56940 -34770 0 1 {name=p56045 lab=_84166_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 56900 -34770 0 0 {name=Xclkbuf_10_843_0_CLK }
C {devices/lab_pin.sym} 56820 -34690 0 0 {name=p56046 lab=_57989_/X }
C {devices/lab_pin.sym} 56820 -34650 0 0 {name=p56047 lab=_58005_/Y }
C {devices/lab_pin.sym} 56820 -34610 0 0 {name=p56048 lab=_58006_/Y }
C {devices/lab_pin.sym} 56820 -34570 0 0 {name=p56049 lab=_58007_/X }
C {devices/lab_pin.sym} 56820 -34530 0 0 {name=p56050 lab=_57993_/X }
C {devices/lab_pin.sym} 56980 -34610 0 1 {name=p56051 lab=_58008_/X }
C {sky130_stdcells/o32a_4.sym} 56900 -34610 0 0 {name=X_58008_ }
C {devices/lab_pin.sym} 56860 -34450 0 0 {name=p56052 lab=_45962_/X }
C {devices/lab_pin.sym} 56940 -34450 0 1 {name=p56053 lab=_46022_/X }
C {sky130_stdcells/buf_2.sym} 56900 -34450 0 0 {name=X_46022_ }
C {devices/lab_pin.sym} 56860 -34330 0 0 {name=p56054 lab=_43234_/A }
C {devices/lab_pin.sym} 56940 -34330 0 1 {name=p56055 lab=_43234_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -34330 0 0 {name=X_43234_ }
C {devices/lab_pin.sym} 56820 -34240 0 0 {name=p56056 lab=_68888_/B }
C {devices/lab_pin.sym} 56820 -34200 0 0 {name=p56057 lab=_73872_/X }
C {devices/lab_pin.sym} 56820 -34160 0 0 {name=p56058 lab=_73920_/X }
C {devices/lab_pin.sym} 56820 -34120 0 0 {name=p56059 lab=_74053_/Y }
C {devices/lab_pin.sym} 56980 -34180 0 1 {name=p56060 lab=_74054_/X }
C {sky130_stdcells/a211o_4.sym} 56900 -34180 0 0 {name=X_74054_ }
C {devices/lab_pin.sym} 56840 -34040 0 0 {name=p56061 lab=_78919_/A }
C {devices/lab_pin.sym} 56840 -34000 0 0 {name=p56062 lab=_78931_/B }
C {devices/lab_pin.sym} 56960 -34020 0 1 {name=p56063 lab=_78931_/X }
C {sky130_stdcells/and2_4.sym} 56900 -34020 0 0 {name=X_78931_ }
C {devices/lab_pin.sym} 56860 -33890 0 0 {name=p56064 lab=_40445_/X }
C {devices/lab_pin.sym} 56940 -33890 0 1 {name=p56065 lab=_40446_/X }
C {sky130_stdcells/buf_2.sym} 56900 -33890 0 0 {name=X_40446_ }
C {devices/lab_pin.sym} 56840 -33780 0 0 {name=p56066 lab=_71266_/A }
C {devices/lab_pin.sym} 56840 -33740 0 0 {name=p56067 lab=_70733_/Y }
C {devices/lab_pin.sym} 56960 -33760 0 1 {name=p56068 lab=_71266_/X }
C {sky130_stdcells/and2_4.sym} 56900 -33760 0 0 {name=X_71266_ }
C {devices/lab_pin.sym} 56860 -33630 0 0 {name=p56069 lab=clkbuf_9_335_0_CLK/A }
C {devices/lab_pin.sym} 56940 -33630 0 1 {name=p56070 lab=clkbuf_9_334_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 56900 -33630 0 0 {name=Xclkbuf_9_334_0_CLK }
C {devices/lab_pin.sym} 56820 -33530 0 0 {name=p56071 lab=_73001_/X }
C {devices/lab_pin.sym} 56820 -33490 0 0 {name=p56072 lab=_73004_/X }
C {devices/lab_pin.sym} 56820 -33450 0 0 {name=p56073 lab=_72951_/X }
C {devices/lab_pin.sym} 56980 -33490 0 1 {name=p56074 lab=_73021_/B }
C {sky130_stdcells/a21o_4.sym} 56900 -33490 0 0 {name=X_73005_ }
C {devices/lab_pin.sym} 56860 -33350 0 0 {name=p56075 lab=_70232_/A }
C {devices/lab_pin.sym} 56940 -33350 0 1 {name=p56076 lab=_70229_/B }
C {sky130_stdcells/buf_2.sym} 56900 -33350 0 0 {name=X_70217_ }
C {devices/lab_pin.sym} 56860 -33230 0 0 {name=p56077 lab=_43014_/Y }
C {devices/lab_pin.sym} 56940 -33230 0 1 {name=p56078 lab=_43166_/A }
C {sky130_stdcells/buf_2.sym} 56900 -33230 0 0 {name=X_43165_ }
C {devices/lab_pin.sym} 56840 -33120 0 0 {name=p56079 lab=_78862_/A }
C {devices/lab_pin.sym} 56840 -33080 0 0 {name=p56080 lab=_78862_/B }
C {devices/lab_pin.sym} 56960 -33100 0 1 {name=p56081 lab=_78862_/X }
C {sky130_stdcells/xor2_4.sym} 56900 -33100 0 0 {name=X_78862_ }
C {devices/lab_pin.sym} 56860 -32970 0 0 {name=p56082 lab=_40376_/Y }
C {devices/lab_pin.sym} 56940 -32970 0 1 {name=p56083 lab=_40377_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -32970 0 0 {name=X_40377_ }
C {devices/lab_pin.sym} 56840 -32870 0 0 {name=p56084 lab=_71197_/A }
C {devices/lab_pin.sym} 56840 -32830 0 0 {name=p56085 lab=_71076_/B }
C {devices/lab_pin.sym} 56840 -32790 0 0 {name=p56086 lab=_71197_/C }
C {devices/lab_pin.sym} 56960 -32830 0 1 {name=p56087 lab=_71197_/Y }
C {sky130_stdcells/nand3_4.sym} 56900 -32830 0 0 {name=X_71197_ }
C {devices/lab_pin.sym} 56860 -32690 0 0 {name=p56088 lab=clkbuf_9_114_0_CLK/X }
C {devices/lab_pin.sym} 56940 -32690 0 1 {name=p56089 lab=_81859_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 56900 -32690 0 0 {name=Xclkbuf_10_228_0_CLK }
C {devices/lab_pin.sym} 56860 -32570 0 0 {name=p56090 lab=_42077_/A }
C {devices/lab_pin.sym} 56940 -32570 0 1 {name=p56091 lab=_42116_/X }
C {sky130_stdcells/buf_2.sym} 56900 -32570 0 0 {name=X_42116_ }
C {devices/lab_pin.sym} 56860 -32450 0 0 {name=p56092 lab=_77813_/A }
C {devices/lab_pin.sym} 56940 -32450 0 1 {name=p56093 lab=_77828_/A }
C {sky130_stdcells/inv_2.sym} 56900 -32450 0 0 {name=X_77813_ }
C {devices/lab_pin.sym} 56820 -32360 0 0 {name=p56094 lab=_83527_/Q }
C {devices/lab_pin.sym} 56820 -32320 0 0 {name=p56095 lab=_83175_/Q }
C {devices/lab_pin.sym} 56820 -32280 0 0 {name=p56096 lab=_83526_/Q }
C {devices/lab_pin.sym} 56820 -32240 0 0 {name=p56097 lab=_83174_/Q }
C {devices/lab_pin.sym} 56980 -32300 0 1 {name=p56098 lab=_70148_/Y }
C {sky130_stdcells/a22oi_4.sym} 56900 -32300 0 0 {name=X_70148_ }
C {devices/lab_pin.sym} 56840 -32160 0 0 {name=p56099 lab=_47973_/A }
C {devices/lab_pin.sym} 56840 -32120 0 0 {name=p56100 lab=_47973_/B }
C {devices/lab_pin.sym} 56960 -32140 0 1 {name=p56101 lab=_47973_/X }
C {sky130_stdcells/or2_4.sym} 56900 -32140 0 0 {name=X_47973_ }
C {devices/lab_pin.sym} 56860 -32010 0 0 {name=p56102 lab=_62475_/A }
C {devices/lab_pin.sym} 56940 -32010 0 1 {name=p56103 lab=_62621_/D }
C {sky130_stdcells/buf_2.sym} 56900 -32010 0 0 {name=X_59959_ }
C {devices/lab_pin.sym} 56860 -31890 0 0 {name=p56104 lab=_87577_/Q }
C {devices/lab_pin.sym} 56940 -31890 0 1 {name=p56105 lab=_43096_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -31890 0 0 {name=X_43096_ }
C {devices/lab_pin.sym} 56840 -31780 0 0 {name=p56106 lab=_78793_/A }
C {devices/lab_pin.sym} 56840 -31740 0 0 {name=p56107 lab=_78793_/B }
C {devices/lab_pin.sym} 56960 -31760 0 1 {name=p56108 lab=_78794_/A }
C {sky130_stdcells/xor2_4.sym} 56900 -31760 0 0 {name=X_78793_ }
C {devices/lab_pin.sym} 56860 -31630 0 0 {name=p56109 lab=clkbuf_9_429_0_CLK/X }
C {devices/lab_pin.sym} 56940 -31630 0 1 {name=p56110 lab=_86121_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 56900 -31630 0 0 {name=Xclkbuf_10_858_0_CLK }
C {devices/lab_pin.sym} 56860 -31510 0 0 {name=p56111 lab=_49657_/A }
C {devices/lab_pin.sym} 56940 -31510 0 1 {name=p56112 lab=_49724_/C }
C {sky130_stdcells/buf_2.sym} 56900 -31510 0 0 {name=X_49712_ }
C {devices/lab_pin.sym} 56860 -31390 0 0 {name=p56113 lab=_82401_/Q }
C {devices/lab_pin.sym} 56940 -31390 0 1 {name=p56114 lab=_46924_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -31390 0 0 {name=X_46924_ }
C {devices/lab_pin.sym} 56860 -31270 0 0 {name=p56115 lab=_88058_/Q }
C {devices/lab_pin.sym} 56940 -31270 0 1 {name=p56116 lab=_42047_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -31270 0 0 {name=X_42047_ }
C {devices/lab_pin.sym} 56840 -31160 0 0 {name=p56117 lab=_82147_/Q }
C {devices/lab_pin.sym} 56840 -31120 0 0 {name=p56118 lab=_77744_/B }
C {devices/lab_pin.sym} 56960 -31140 0 1 {name=p56119 lab=_82115_/D }
C {sky130_stdcells/xor2_4.sym} 56900 -31140 0 0 {name=X_77744_ }
C {devices/lab_pin.sym} 56820 -31030 0 0 {name=p56120 lab=_62968_/X }
C {devices/lab_pin.sym} 56820 -30990 0 0 {name=p56121 lab=_62942_/X }
C {devices/lab_pin.sym} 56820 -30950 0 0 {name=p56122 lab=_62969_/Y }
C {devices/lab_pin.sym} 56980 -30990 0 1 {name=p56123 lab=_62970_/Y }
C {sky130_stdcells/a21oi_4.sym} 56900 -30990 0 0 {name=X_62970_ }
C {devices/lab_pin.sym} 56840 -30860 0 0 {name=p56124 lab=_80945_/Q }
C {devices/lab_pin.sym} 56840 -30820 0 0 {name=p56125 lab=_74956_/B }
C {devices/lab_pin.sym} 56960 -30840 0 1 {name=p56126 lab=_81194_/D }
C {sky130_stdcells/xor2_4.sym} 56900 -30840 0 0 {name=X_74956_ }
C {devices/lab_pin.sym} 56840 -30730 0 0 {name=p56127 lab=_70079_/A }
C {devices/lab_pin.sym} 56840 -30690 0 0 {name=p56128 lab=_70078_/X }
C {devices/lab_pin.sym} 56840 -30650 0 0 {name=p56129 lab=_59787_/X }
C {devices/lab_pin.sym} 56960 -30690 0 1 {name=p56130 lab=_70079_/Y }
C {sky130_stdcells/nand3_4.sym} 56900 -30690 0 0 {name=X_70079_ }
C {devices/lab_pin.sym} 56860 -30550 0 0 {name=p56131 lab=clkbuf_8_174_0_CLK/X }
C {devices/lab_pin.sym} 56940 -30550 0 1 {name=p56132 lab=clkbuf_9_349_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 56900 -30550 0 0 {name=Xclkbuf_9_349_0_CLK }
C {devices/lab_pin.sym} 56820 -30450 0 0 {name=p56133 lab=_49639_/Y }
C {devices/lab_pin.sym} 56820 -30410 0 0 {name=p56134 lab=_49623_/X }
C {devices/lab_pin.sym} 56820 -30370 0 0 {name=p56135 lab=_49642_/X }
C {devices/lab_pin.sym} 56980 -30410 0 1 {name=p56136 lab=_49643_/Y }
C {sky130_stdcells/a21oi_4.sym} 56900 -30410 0 0 {name=X_49643_ }
C {devices/lab_pin.sym} 56840 -30300 0 0 {name=p56137 lab=_61479_/B }
C {devices/lab_pin.sym} 56840 -30260 0 0 {name=p56138 lab=_61953_/B }
C {devices/lab_pin.sym} 56840 -30220 0 0 {name=p56139 lab=_61860_/C }
C {devices/lab_pin.sym} 56840 -30180 0 0 {name=p56140 lab=_61860_/D }
C {devices/lab_pin.sym} 56960 -30240 0 1 {name=p56141 lab=_61921_/Y }
C {sky130_stdcells/nand4_4.sym} 56900 -30240 0 0 {name=X_61921_ }
C {devices/lab_pin.sym} 56860 -30090 0 0 {name=p56142 lab=_72829_/A }
C {devices/lab_pin.sym} 56940 -30090 0 1 {name=p56143 lab=_73907_/X }
C {sky130_stdcells/buf_2.sym} 56900 -30090 0 0 {name=X_73907_ }
C {devices/lab_pin.sym} 56860 -29970 0 0 {name=p56144 lab=_82952_/Q }
C {devices/lab_pin.sym} 56940 -29970 0 1 {name=p56145 lab=_46856_/A }
C {sky130_stdcells/inv_2.sym} 56900 -29970 0 0 {name=X_46855_ }
C {devices/lab_pin.sym} 56860 -29850 0 0 {name=p56146 lab=_77675_/A }
C {devices/lab_pin.sym} 56940 -29850 0 1 {name=p56147 lab=_77675_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -29850 0 0 {name=X_77675_ }
C {devices/lab_pin.sym} 56840 -29750 0 0 {name=p56148 lab=_74887_/A }
C {devices/lab_pin.sym} 56840 -29710 0 0 {name=p56149 lab=_74887_/B }
C {devices/lab_pin.sym} 56840 -29670 0 0 {name=p56150 lab=_74887_/C }
C {devices/lab_pin.sym} 56960 -29710 0 1 {name=p56151 lab=_74887_/Y }
C {sky130_stdcells/nand3_4.sym} 56900 -29710 0 0 {name=X_74887_ }
C {devices/lab_pin.sym} 56840 -29580 0 0 {name=p56152 lab=_79414_/A }
C {devices/lab_pin.sym} 56840 -29540 0 0 {name=p56153 lab=_79414_/B }
C {devices/lab_pin.sym} 56960 -29560 0 1 {name=p56154 lab=_79414_/X }
C {sky130_stdcells/xor2_4.sym} 56900 -29560 0 0 {name=X_79414_ }
C {devices/lab_pin.sym} 56820 -29450 0 0 {name=p56155 lab=_45748_/X }
C {devices/lab_pin.sym} 56820 -29410 0 0 {name=p56156 lab=_61640_/A }
C {devices/lab_pin.sym} 56820 -29370 0 0 {name=p56157 lab=_45765_/X }
C {devices/lab_pin.sym} 56980 -29410 0 1 {name=p56158 lab=_45806_/Y }
C {sky130_stdcells/o21ai_4.sym} 56900 -29410 0 0 {name=X_45806_ }
C {devices/lab_pin.sym} 56840 -29280 0 0 {name=p56159 lab=_64611_/A }
C {devices/lab_pin.sym} 56840 -29240 0 0 {name=p56160 lab=_85823_/Q }
C {devices/lab_pin.sym} 56960 -29260 0 1 {name=p56161 lab=_64640_/X }
C {sky130_stdcells/and2_4.sym} 56900 -29260 0 0 {name=X_64640_ }
C {devices/lab_pin.sym} 56840 -29140 0 0 {name=p56162 lab=_76625_/Y }
C {devices/lab_pin.sym} 56840 -29100 0 0 {name=p56163 lab=_76623_/A }
C {devices/lab_pin.sym} 56960 -29120 0 1 {name=p56164 lab=_76640_/A }
C {sky130_stdcells/nand2_4.sym} 56900 -29120 0 0 {name=X_76626_ }
C {devices/lab_pin.sym} 56840 -29000 0 0 {name=p56165 lab=_49558_/A }
C {devices/lab_pin.sym} 56840 -28960 0 0 {name=p56166 lab=_52787_/B }
C {devices/lab_pin.sym} 56960 -28980 0 1 {name=p56167 lab=_49574_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -28980 0 0 {name=X_49574_ }
C {devices/lab_pin.sym} 56860 -28850 0 0 {name=p56168 lab=_61711_/X }
C {devices/lab_pin.sym} 56940 -28850 0 1 {name=p56169 lab=_61871_/A }
C {sky130_stdcells/buf_2.sym} 56900 -28850 0 0 {name=X_61852_ }
C {devices/lab_pin.sym} 56840 -28750 0 0 {name=p56170 lab=_73836_/X }
C {devices/lab_pin.sym} 56840 -28710 0 0 {name=p56171 lab=_73838_/B }
C {devices/lab_pin.sym} 56840 -28670 0 0 {name=p56172 lab=_73838_/C }
C {devices/lab_pin.sym} 56960 -28710 0 1 {name=p56173 lab=_73838_/Y }
C {sky130_stdcells/nand3_4.sym} 56900 -28710 0 0 {name=X_73838_ }
C {devices/lab_pin.sym} 56860 -28570 0 0 {name=p56174 lab=_46786_/A }
C {devices/lab_pin.sym} 56940 -28570 0 1 {name=p56175 lab=_54364_/B }
C {sky130_stdcells/inv_2.sym} 56900 -28570 0 0 {name=X_46786_ }
C {devices/lab_pin.sym} 56860 -28450 0 0 {name=p56176 lab=_43998_/A }
C {devices/lab_pin.sym} 56940 -28450 0 1 {name=p56177 lab=_59516_/A }
C {sky130_stdcells/buf_2.sym} 56900 -28450 0 0 {name=X_43998_ }
C {devices/lab_pin.sym} 56860 -28330 0 0 {name=p56178 lab=_83578_/Q }
C {devices/lab_pin.sym} 56940 -28330 0 1 {name=p56179 lab=_74437_/B }
C {sky130_stdcells/inv_2.sym} 56900 -28330 0 0 {name=X_48525_ }
C {devices/lab_pin.sym} 56820 -28240 0 0 {name=p56180 lab=_84563_/Q }
C {devices/lab_pin.sym} 56820 -28200 0 0 {name=p56181 lab=_60673_/X }
C {devices/lab_pin.sym} 56820 -28160 0 0 {name=p56182 lab=_60754_/X }
C {devices/lab_pin.sym} 56820 -28120 0 0 {name=p56183 lab=_60750_/X }
C {devices/lab_pin.sym} 56980 -28180 0 1 {name=p56184 lab=_60803_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 56900 -28180 0 0 {name=X_60803_ }
C {devices/lab_pin.sym} 56840 -28040 0 0 {name=p56185 lab=_79341_/Y }
C {devices/lab_pin.sym} 56840 -28000 0 0 {name=p56186 lab=_79344_/Y }
C {devices/lab_pin.sym} 56960 -28020 0 1 {name=p56187 lab=_79355_/B }
C {sky130_stdcells/xor2_4.sym} 56900 -28020 0 0 {name=X_79345_ }
C {devices/lab_pin.sym} 56820 -27920 0 0 {name=p56188 lab=_45733_/Y }
C {devices/lab_pin.sym} 56820 -27880 0 0 {name=p56189 lab=_45734_/X }
C {devices/lab_pin.sym} 56820 -27840 0 0 {name=p56190 lab=_45720_/X }
C {devices/lab_pin.sym} 56820 -27800 0 0 {name=p56191 lab=_45736_/Y }
C {devices/lab_pin.sym} 56980 -27860 0 1 {name=p56192 lab=_45737_/X }
C {sky130_stdcells/a211o_4.sym} 56900 -27860 0 0 {name=X_45737_ }
C {devices/lab_pin.sym} 56860 -27710 0 0 {name=p56193 lab=_64642_/A }
C {devices/lab_pin.sym} 56940 -27710 0 1 {name=p56194 lab=_64571_/X }
C {sky130_stdcells/buf_2.sym} 56900 -27710 0 0 {name=X_64571_ }
C {devices/lab_pin.sym} 56860 -27590 0 0 {name=p56195 lab=_76557_/A }
C {devices/lab_pin.sym} 56940 -27590 0 1 {name=p56196 lab=_76560_/B }
C {sky130_stdcells/inv_2.sym} 56900 -27590 0 0 {name=X_76557_ }
C {devices/lab_pin.sym} 56860 -27470 0 0 {name=p56197 lab=_42949_/A }
C {devices/lab_pin.sym} 56940 -27470 0 1 {name=p56198 lab=_42949_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -27470 0 0 {name=X_42949_ }
C {devices/lab_pin.sym} 56820 -27390 0 0 {name=p56199 lab=_61770_/X }
C {devices/lab_pin.sym} 56820 -27350 0 0 {name=p56200 lab=_61773_/X }
C {devices/lab_pin.sym} 56820 -27310 0 0 {name=p56201 lab=_61782_/Y }
C {devices/lab_pin.sym} 56820 -27270 0 0 {name=p56202 lab=_84918_/Q }
C {devices/lab_pin.sym} 56820 -27230 0 0 {name=p56203 lab=_61719_/X }
C {devices/lab_pin.sym} 56980 -27310 0 1 {name=p56204 lab=_61783_/Y }
C {sky130_stdcells/o32ai_4.sym} 56900 -27310 0 0 {name=X_61783_ }
C {devices/lab_pin.sym} 56820 -27170 0 0 {name=p56205 lab=_70107_/C }
C {devices/lab_pin.sym} 56820 -27130 0 0 {name=p56206 lab=_73697_/X }
C {devices/lab_pin.sym} 56820 -27090 0 0 {name=p56207 lab=_73768_/X }
C {devices/lab_pin.sym} 56980 -27130 0 1 {name=p56208 lab=_73769_/Y }
C {sky130_stdcells/o21ai_4.sym} 56900 -27130 0 0 {name=X_73769_ }
C {devices/lab_pin.sym} 56840 -27000 0 0 {name=p56209 lab=_66237_/X }
C {devices/lab_pin.sym} 56840 -26960 0 0 {name=p56210 lab=_66310_/B }
C {devices/lab_pin.sym} 56960 -26980 0 1 {name=p56211 lab=_66310_/X }
C {sky130_stdcells/and2_4.sym} 56900 -26980 0 0 {name=X_66310_ }
C {devices/lab_pin.sym} 56860 -26850 0 0 {name=p56212 lab=_63398_/A }
C {devices/lab_pin.sym} 56940 -26850 0 1 {name=p56213 lab=_63523_/A }
C {sky130_stdcells/buf_2.sym} 56900 -26850 0 0 {name=X_63522_ }
C {devices/lab_pin.sym} 56840 -26740 0 0 {name=p56214 lab=_75508_/A }
C {devices/lab_pin.sym} 56840 -26700 0 0 {name=p56215 lab=_75508_/B }
C {devices/lab_pin.sym} 56960 -26720 0 1 {name=p56216 lab=_75510_/A }
C {sky130_stdcells/or2_4.sym} 56900 -26720 0 0 {name=X_75508_ }
C {devices/lab_pin.sym} 56840 -26600 0 0 {name=p56217 lab=_48469_/A }
C {devices/lab_pin.sym} 56840 -26560 0 0 {name=p56218 lab=_50440_/B }
C {devices/lab_pin.sym} 56960 -26580 0 1 {name=p56219 lab=_48456_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -26580 0 0 {name=X_48456_ }
C {devices/lab_pin.sym} 56820 -26480 0 0 {name=p56220 lab=_84578_/Q }
C {devices/lab_pin.sym} 56820 -26440 0 0 {name=p56221 lab=_60673_/X }
C {devices/lab_pin.sym} 56820 -26400 0 0 {name=p56222 lab=_60733_/Y }
C {devices/lab_pin.sym} 56820 -26360 0 0 {name=p56223 lab=_60723_/X }
C {devices/lab_pin.sym} 56980 -26420 0 1 {name=p56224 lab=_60734_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 56900 -26420 0 0 {name=X_60734_ }
C {devices/lab_pin.sym} 56840 -26280 0 0 {name=p56225 lab=_67266_/A }
C {devices/lab_pin.sym} 56840 -26240 0 0 {name=p56226 lab=_67290_/B }
C {devices/lab_pin.sym} 56960 -26260 0 1 {name=p56227 lab=_67290_/X }
C {sky130_stdcells/and2_4.sym} 56900 -26260 0 0 {name=X_67290_ }
C {devices/lab_pin.sym} 56840 -26140 0 0 {name=p56228 lab=_79266_/X }
C {devices/lab_pin.sym} 56840 -26100 0 0 {name=p56229 lab=_79276_/B }
C {devices/lab_pin.sym} 56960 -26120 0 1 {name=p56230 lab=_79276_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -26120 0 0 {name=X_79276_ }
C {devices/lab_pin.sym} 56860 -25990 0 0 {name=p56231 lab=_45668_/A }
C {devices/lab_pin.sym} 56940 -25990 0 1 {name=p56232 lab=_45668_/X }
C {sky130_stdcells/buf_2.sym} 56900 -25990 0 0 {name=X_45668_ }
C {devices/lab_pin.sym} 56840 -25880 0 0 {name=p56233 lab=_76489_/A }
C {devices/lab_pin.sym} 56840 -25840 0 0 {name=p56234 lab=_81541_/Q }
C {devices/lab_pin.sym} 56960 -25860 0 1 {name=p56235 lab=_76491_/B }
C {sky130_stdcells/nor2_4.sym} 56900 -25860 0 0 {name=X_76488_ }
C {devices/lab_pin.sym} 56860 -25730 0 0 {name=p56236 lab=_47407_/A }
C {devices/lab_pin.sym} 56940 -25730 0 1 {name=p56237 lab=_53031_/D }
C {sky130_stdcells/buf_2.sym} 56900 -25730 0 0 {name=X_47407_ }
C {devices/lab_pin.sym} 56820 -25630 0 0 {name=p56238 lab=_66235_/X }
C {devices/lab_pin.sym} 56820 -25590 0 0 {name=p56239 lab=_66239_/X }
C {devices/lab_pin.sym} 56820 -25550 0 0 {name=p56240 lab=_66240_/X }
C {devices/lab_pin.sym} 56980 -25590 0 1 {name=p56241 lab=_66244_/A }
C {sky130_stdcells/a21o_4.sym} 56900 -25590 0 0 {name=X_66241_ }
C {devices/lab_pin.sym} 56840 -25460 0 0 {name=p56242 lab=_82583_/Q }
C {devices/lab_pin.sym} 56840 -25420 0 0 {name=p56243 lab=_82495_/Q }
C {devices/lab_pin.sym} 56960 -25440 0 1 {name=p56244 lab=_78230_/A }
C {sky130_stdcells/xor2_4.sym} 56900 -25440 0 0 {name=X_78227_ }
C {devices/lab_pin.sym} 56860 -25310 0 0 {name=p56245 lab=_44603_/A }
C {devices/lab_pin.sym} 56940 -25310 0 1 {name=p56246 lab=_44619_/X }
C {sky130_stdcells/buf_2.sym} 56900 -25310 0 0 {name=X_44619_ }
C {devices/lab_pin.sym} 56840 -25200 0 0 {name=p56247 lab=_75466_/B }
C {devices/lab_pin.sym} 56840 -25160 0 0 {name=p56248 lab=_75438_/Y }
C {devices/lab_pin.sym} 56960 -25180 0 1 {name=p56249 lab=_75440_/B }
C {sky130_stdcells/xor2_4.sym} 56900 -25180 0 0 {name=X_75439_ }
C {devices/lab_pin.sym} 56840 -25080 0 0 {name=p56250 lab=_64292_/A }
C {devices/lab_pin.sym} 56840 -25040 0 0 {name=p56251 lab=_63465_/B }
C {devices/lab_pin.sym} 56840 -25000 0 0 {name=p56252 lab=_63465_/C }
C {devices/lab_pin.sym} 56840 -24960 0 0 {name=p56253 lab=_63465_/D }
C {devices/lab_pin.sym} 56960 -25020 0 1 {name=p56254 lab=_63453_/Y }
C {sky130_stdcells/nand4_4.sym} 56900 -25020 0 0 {name=X_63453_ }
C {devices/lab_pin.sym} 56860 -24870 0 0 {name=p56255 lab=_74375_/A }
C {devices/lab_pin.sym} 56940 -24870 0 1 {name=p56256 lab=_48388_/A }
C {sky130_stdcells/buf_2.sym} 56900 -24870 0 0 {name=X_48387_ }
C {devices/lab_pin.sym} 56840 -24780 0 0 {name=p56257 lab=_59539_/A }
C {devices/lab_pin.sym} 56840 -24740 0 0 {name=p56258 lab=_59705_/X }
C {devices/lab_pin.sym} 56840 -24700 0 0 {name=p56259 lab=_60665_/C }
C {devices/lab_pin.sym} 56840 -24660 0 0 {name=p56260 lab=_62640_/C }
C {devices/lab_pin.sym} 56960 -24720 0 1 {name=p56261 lab=_60665_/X }
C {sky130_stdcells/or4_4.sym} 56900 -24720 0 0 {name=X_60665_ }
C {devices/lab_pin.sym} 56860 -24570 0 0 {name=p56262 lab=_45599_/A }
C {devices/lab_pin.sym} 56940 -24570 0 1 {name=p56263 lab=_45599_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -24570 0 0 {name=X_45599_ }
C {devices/lab_pin.sym} 56860 -24450 0 0 {name=p56264 lab=_62475_/A }
C {devices/lab_pin.sym} 56940 -24450 0 1 {name=p56265 lab=_62404_/X }
C {sky130_stdcells/buf_2.sym} 56900 -24450 0 0 {name=X_62404_ }
C {devices/lab_pin.sym} 56860 -24330 0 0 {name=p56266 lab=_47198_/X }
C {devices/lab_pin.sym} 56940 -24330 0 1 {name=p56267 lab=_47380_/A }
C {sky130_stdcells/buf_2.sym} 56900 -24330 0 0 {name=X_47338_ }
C {devices/lab_pin.sym} 56820 -24240 0 0 {name=p56268 lab=_66117_/X }
C {devices/lab_pin.sym} 56820 -24200 0 0 {name=p56269 lab=_84975_/Q }
C {devices/lab_pin.sym} 56820 -24160 0 0 {name=p56270 lab=_64707_/X }
C {devices/lab_pin.sym} 56820 -24120 0 0 {name=p56271 lab=_66171_/X }
C {devices/lab_pin.sym} 56980 -24180 0 1 {name=p56272 lab=_66173_/C }
C {sky130_stdcells/a211o_4.sym} 56900 -24180 0 0 {name=X_66172_ }
C {devices/lab_pin.sym} 56820 -24050 0 0 {name=p56273 lab=_78151_/Y }
C {devices/lab_pin.sym} 56820 -24010 0 0 {name=p56274 lab=_78152_/A }
C {devices/lab_pin.sym} 56820 -23970 0 0 {name=p56275 lab=_78157_/Y }
C {devices/lab_pin.sym} 56980 -24010 0 1 {name=p56276 lab=_78159_/B }
C {sky130_stdcells/a21boi_4.sym} 56900 -24010 0 0 {name=X_78158_ }
C {devices/lab_pin.sym} 56840 -23900 0 0 {name=p56277 lab=_63410_/A }
C {devices/lab_pin.sym} 56840 -23860 0 0 {name=p56278 lab=_63384_/B }
C {devices/lab_pin.sym} 56840 -23820 0 0 {name=p56279 lab=_63384_/C }
C {devices/lab_pin.sym} 56840 -23780 0 0 {name=p56280 lab=_63384_/D }
C {devices/lab_pin.sym} 56960 -23840 0 1 {name=p56281 lab=_63384_/X }
C {sky130_stdcells/and4_4.sym} 56900 -23840 0 0 {name=X_63384_ }
C {devices/lab_pin.sym} 56840 -23700 0 0 {name=p56282 lab=_60596_/A }
C {devices/lab_pin.sym} 56840 -23660 0 0 {name=p56283 lab=_60596_/B }
C {devices/lab_pin.sym} 56960 -23680 0 1 {name=p56284 lab=_60596_/Y }
C {sky130_stdcells/nor2_4.sym} 56900 -23680 0 0 {name=X_60596_ }
C {devices/lab_pin.sym} 56820 -23570 0 0 {name=p56285 lab=_65116_/X }
C {devices/lab_pin.sym} 56820 -23530 0 0 {name=p56286 lab=_65121_/X }
C {devices/lab_pin.sym} 56820 -23490 0 0 {name=p56287 lab=_65122_/X }
C {devices/lab_pin.sym} 56980 -23530 0 1 {name=p56288 lab=_65126_/A }
C {sky130_stdcells/a21o_4.sym} 56900 -23530 0 0 {name=X_65123_ }
C {devices/lab_pin.sym} 56840 -23400 0 0 {name=p56289 lab=_77109_/A }
C {devices/lab_pin.sym} 56840 -23360 0 0 {name=p56290 lab=_77109_/B }
C {devices/lab_pin.sym} 56960 -23380 0 1 {name=p56291 lab=_77110_/B }
C {sky130_stdcells/xor2_4.sym} 56900 -23380 0 0 {name=X_77109_ }
C {devices/lab_pin.sym} 56840 -23280 0 0 {name=p56292 lab=_62362_/A }
C {devices/lab_pin.sym} 56840 -23240 0 0 {name=p56293 lab=_62335_/B }
C {devices/lab_pin.sym} 56840 -23200 0 0 {name=p56294 lab=_62335_/C }
C {devices/lab_pin.sym} 56840 -23160 0 0 {name=p56295 lab=_62335_/D }
C {devices/lab_pin.sym} 56960 -23220 0 1 {name=p56296 lab=_62335_/Y }
C {sky130_stdcells/nand4_4.sym} 56900 -23220 0 0 {name=X_62335_ }
C {devices/lab_pin.sym} 56840 -23080 0 0 {name=p56297 lab=_47241_/X }
C {devices/lab_pin.sym} 56840 -23040 0 0 {name=p56298 lab=_52950_/B }
C {devices/lab_pin.sym} 56960 -23060 0 1 {name=p56299 lab=_47269_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -23060 0 0 {name=X_47269_ }
C {devices/lab_pin.sym} 56860 -22930 0 0 {name=p56300 lab=_78089_/A }
C {devices/lab_pin.sym} 56940 -22930 0 1 {name=p56301 lab=_78090_/B }
C {sky130_stdcells/inv_2.sym} 56900 -22930 0 0 {name=X_78089_ }
C {devices/lab_pin.sym} 56820 -22830 0 0 {name=p56302 lab=_86453_/Q }
C {devices/lab_pin.sym} 56820 -22790 0 0 {name=p56303 lab=_49003_/X }
C {devices/lab_pin.sym} 56820 -22750 0 0 {name=p56304 lab=_49007_/Y }
C {devices/lab_pin.sym} 56980 -22790 0 1 {name=p56305 lab=_49008_/Y }
C {sky130_stdcells/o21ai_4.sym} 56900 -22790 0 0 {name=X_49008_ }
C {devices/lab_pin.sym} 56840 -22660 0 0 {name=p56306 lab=_80114_/Y }
C {devices/lab_pin.sym} 56840 -22620 0 0 {name=p56307 lab=_80119_/Y }
C {devices/lab_pin.sym} 56960 -22640 0 1 {name=p56308 lab=_81684_/D }
C {sky130_stdcells/xor2_4.sym} 56900 -22640 0 0 {name=X_80120_ }
C {devices/lab_pin.sym} 56840 -22520 0 0 {name=p56309 lab=_65319_/A }
C {devices/lab_pin.sym} 56840 -22480 0 0 {name=p56310 lab=_65054_/B }
C {devices/lab_pin.sym} 56960 -22500 0 1 {name=p56311 lab=_65054_/X }
C {sky130_stdcells/and2_4.sym} 56900 -22500 0 0 {name=X_65054_ }
C {devices/lab_pin.sym} 56820 -22400 0 0 {name=p56312 lab=_73462_/A }
C {devices/lab_pin.sym} 56820 -22360 0 0 {name=p56313 lab=_69833_/X }
C {devices/lab_pin.sym} 56820 -22320 0 0 {name=p56314 lab=_69617_/X }
C {devices/lab_pin.sym} 56820 -22280 0 0 {name=p56315 lab=_69930_/Y }
C {devices/lab_pin.sym} 56980 -22340 0 1 {name=p56316 lab=_69931_/X }
C {sky130_stdcells/a211o_4.sym} 56900 -22340 0 0 {name=X_69931_ }
C {devices/lab_pin.sym} 56840 -22200 0 0 {name=p56317 lab=_50279_/X }
C {devices/lab_pin.sym} 56840 -22160 0 0 {name=p56318 lab=_53504_/B }
C {devices/lab_pin.sym} 56960 -22180 0 1 {name=p56319 lab=_50280_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -22180 0 0 {name=X_50280_ }
C {devices/lab_pin.sym} 56860 -22050 0 0 {name=p56320 lab=_62179_/X }
C {devices/lab_pin.sym} 56940 -22050 0 1 {name=p56321 lab=_62267_/B }
C {sky130_stdcells/buf_2.sym} 56900 -22050 0 0 {name=X_62266_ }
C {devices/lab_pin.sym} 56860 -21930 0 0 {name=p56322 lab=_55686_/C }
C {devices/lab_pin.sym} 56940 -21930 0 1 {name=p56323 lab=_56647_/A4 }
C {sky130_stdcells/buf_2.sym} 56900 -21930 0 0 {name=Xpsn_inst_psn_buff_14 }
C {devices/lab_pin.sym} 56860 -21810 0 0 {name=p56324 lab=_41869_/Y }
C {devices/lab_pin.sym} 56940 -21810 0 1 {name=p56325 lab=_50212_/A }
C {sky130_stdcells/buf_8.sym} 56900 -21810 0 0 {name=Xpsn_inst_psn_buff_25 }
C {devices/lab_pin.sym} 56840 -21710 0 0 {name=p56326 lab=_64053_/A }
C {devices/lab_pin.sym} 56840 -21670 0 0 {name=p56327 lab=_58434_/A }
C {devices/lab_pin.sym} 56840 -21630 0 0 {name=p56328 lab=_64071_/C }
C {devices/lab_pin.sym} 56960 -21670 0 1 {name=p56329 lab=_64005_/X }
C {sky130_stdcells/and3_4.sym} 56900 -21670 0 0 {name=X_64005_ }
C {devices/lab_pin.sym} 56820 -21570 0 0 {name=p56330 lab=_61169_/X }
C {devices/lab_pin.sym} 56820 -21530 0 0 {name=p56331 lab=_61214_/Y }
C {devices/lab_pin.sym} 56820 -21490 0 0 {name=p56332 lab=_61216_/Y }
C {devices/lab_pin.sym} 56820 -21450 0 0 {name=p56333 lab=_84506_/Q }
C {devices/lab_pin.sym} 56820 -21410 0 0 {name=p56334 lab=_59509_/X }
C {devices/lab_pin.sym} 56980 -21490 0 1 {name=p56335 lab=_61217_/X }
C {sky130_stdcells/o32a_4.sym} 56900 -21490 0 0 {name=X_61217_ }
C {devices/lab_pin.sym} 56840 -21340 0 0 {name=p56336 lab=_80047_/X }
C {devices/lab_pin.sym} 56840 -21300 0 0 {name=p56337 lab=_80050_/Y }
C {devices/lab_pin.sym} 56960 -21320 0 1 {name=p56338 lab=_80073_/B }
C {sky130_stdcells/xor2_4.sym} 56900 -21320 0 0 {name=X_80051_ }
C {devices/lab_pin.sym} 56840 -21200 0 0 {name=p56339 lab=_69908_/A }
C {devices/lab_pin.sym} 56840 -21160 0 0 {name=p56340 lab=_69862_/B }
C {devices/lab_pin.sym} 56960 -21180 0 1 {name=p56341 lab=_69862_/Y }
C {sky130_stdcells/nor2_4.sym} 56900 -21180 0 0 {name=X_69862_ }
C {devices/lab_pin.sym} 56820 -21080 0 0 {name=p56342 lab=_62195_/Y }
C {devices/lab_pin.sym} 56820 -21040 0 0 {name=p56343 lab=_59951_/C }
C {devices/lab_pin.sym} 56820 -21000 0 0 {name=p56344 lab=_84729_/Q }
C {devices/lab_pin.sym} 56820 -20960 0 0 {name=p56345 lab=_62196_/X }
C {devices/lab_pin.sym} 56980 -21020 0 1 {name=p56346 lab=_62197_/X }
C {sky130_stdcells/a2bb2o_4.sym} 56900 -21020 0 0 {name=X_62197_ }
C {devices/lab_pin.sym} 56840 -20880 0 0 {name=p56347 lab=_68542_/X }
C {devices/lab_pin.sym} 56840 -20840 0 0 {name=p56348 lab=_87745_/Q }
C {devices/lab_pin.sym} 56960 -20860 0 1 {name=p56349 lab=_68813_/X }
C {sky130_stdcells/and2_4.sym} 56900 -20860 0 0 {name=X_68813_ }
C {devices/lab_pin.sym} 56840 -20740 0 0 {name=p56350 lab=_64210_/A }
C {devices/lab_pin.sym} 56840 -20700 0 0 {name=p56351 lab=_61147_/Y }
C {devices/lab_pin.sym} 56960 -20720 0 1 {name=p56352 lab=_61148_/X }
C {sky130_stdcells/and2_4.sym} 56900 -20720 0 0 {name=X_61148_ }
C {devices/lab_pin.sym} 56840 -20600 0 0 {name=p56353 lab=_69766_/A }
C {devices/lab_pin.sym} 56840 -20560 0 0 {name=p56354 lab=_69793_/B }
C {devices/lab_pin.sym} 56960 -20580 0 1 {name=p56355 lab=_69793_/Y }
C {sky130_stdcells/nor2_4.sym} 56900 -20580 0 0 {name=X_69793_ }
C {devices/lab_pin.sym} 56810 -20450 0 0 {name=p56356 lab=_83813_/CLK }
C {devices/lab_pin.sym} 56810 -20430 0 0 {name=p56357 lab=_83810_/D }
C {devices/lab_pin.sym} 56990 -20450 0 1 {name=p56358 lab=_74722_/A }
C {sky130_stdcells/dfxtp_4.sym} 56900 -20440 0 0 {name=X_83810_ }
C {devices/lab_pin.sym} 56820 -20340 0 0 {name=p56359 lab=_43068_/A }
C {devices/lab_pin.sym} 56820 -20300 0 0 {name=p56360 lab=_68414_/X }
C {devices/lab_pin.sym} 56820 -20260 0 0 {name=p56361 lab=_68741_/X }
C {devices/lab_pin.sym} 56820 -20220 0 0 {name=p56362 lab=_68743_/X }
C {devices/lab_pin.sym} 56980 -20280 0 1 {name=p56363 lab=_68744_/X }
C {sky130_stdcells/a211o_4.sym} 56900 -20280 0 0 {name=X_68744_ }
C {devices/lab_pin.sym} 56820 -20150 0 0 {name=p56364 lab=_53967_/Y }
C {devices/lab_pin.sym} 56820 -20110 0 0 {name=p56365 lab=_53892_/X }
C {devices/lab_pin.sym} 56820 -20070 0 0 {name=p56366 lab=_53969_/X }
C {devices/lab_pin.sym} 56980 -20110 0 1 {name=p56367 lab=_53970_/Y }
C {sky130_stdcells/a21oi_4.sym} 56900 -20110 0 0 {name=X_53970_ }
C {devices/lab_pin.sym} 56820 -19990 0 0 {name=p56368 lab=_65954_/Y }
C {devices/lab_pin.sym} 56820 -19950 0 0 {name=p56369 lab=_65915_/X }
C {devices/lab_pin.sym} 56820 -19910 0 0 {name=p56370 lab=_65955_/X }
C {devices/lab_pin.sym} 56980 -19950 0 1 {name=p56371 lab=_84166_/D }
C {sky130_stdcells/a21o_4.sym} 56900 -19950 0 0 {name=X_65956_ }
C {devices/lab_pin.sym} 56860 -19810 0 0 {name=p56372 lab=_61079_/A }
C {devices/lab_pin.sym} 56940 -19810 0 1 {name=p56373 lab=_61079_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -19810 0 0 {name=X_61079_ }
C {devices/lab_pin.sym} 56810 -19690 0 0 {name=p56374 lab=_86695_/CLK }
C {devices/lab_pin.sym} 56810 -19670 0 0 {name=p56375 lab=_84790_/D }
C {devices/lab_pin.sym} 56990 -19690 0 1 {name=p56376 lab=_84790_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -19680 0 0 {name=X_84790_ }
C {devices/lab_pin.sym} 56860 -19550 0 0 {name=p56377 lab=_52893_/X }
C {devices/lab_pin.sym} 56940 -19550 0 1 {name=p56378 lab=_52922_/A }
C {sky130_stdcells/buf_2.sym} 56900 -19550 0 0 {name=X_52921_ }
C {devices/lab_pin.sym} 56820 -19460 0 0 {name=p56379 lab=_64828_/X }
C {devices/lab_pin.sym} 56820 -19420 0 0 {name=p56380 lab=_85558_/Q }
C {devices/lab_pin.sym} 56820 -19380 0 0 {name=p56381 lab=_64829_/X }
C {devices/lab_pin.sym} 56820 -19340 0 0 {name=p56382 lab=_64906_/X }
C {devices/lab_pin.sym} 56980 -19400 0 1 {name=p56383 lab=_64907_/X }
C {sky130_stdcells/a211o_4.sym} 56900 -19400 0 0 {name=X_64907_ }
C {devices/lab_pin.sym} 56810 -19250 0 0 {name=p56384 lab=_86322_/CLK }
C {devices/lab_pin.sym} 56810 -19230 0 0 {name=p56385 lab=_83741_/D }
C {devices/lab_pin.sym} 56990 -19250 0 1 {name=p56386 lab=_47334_/A }
C {sky130_stdcells/dfxtp_4.sym} 56900 -19240 0 0 {name=X_83741_ }
C {devices/lab_pin.sym} 56810 -19110 0 0 {name=p56387 lab=_81211_/CLK }
C {devices/lab_pin.sym} 56810 -19090 0 0 {name=p56388 lab=_80965_/Q }
C {devices/lab_pin.sym} 56990 -19110 0 1 {name=p56389 lab=_80953_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -19100 0 0 {name=X_80953_ }
C {devices/lab_pin.sym} 56860 -18970 0 0 {name=p56390 lab=_69651_/A }
C {devices/lab_pin.sym} 56940 -18970 0 1 {name=p56391 lab=_68750_/A }
C {sky130_stdcells/buf_2.sym} 56900 -18970 0 0 {name=X_68675_ }
C {devices/lab_pin.sym} 56860 -18850 0 0 {name=p56392 lab=_84171_/Q }
C {devices/lab_pin.sym} 56940 -18850 0 1 {name=p56393 lab=_65888_/C }
C {sky130_stdcells/inv_2.sym} 56900 -18850 0 0 {name=X_65887_ }
C {devices/lab_pin.sym} 56860 -18730 0 0 {name=p56394 lab=_55640_/A }
C {devices/lab_pin.sym} 56940 -18730 0 1 {name=p56395 lab=_55640_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -18730 0 0 {name=X_55640_ }
C {devices/lab_pin.sym} 56840 -18620 0 0 {name=p56396 lab=_67675_/A }
C {devices/lab_pin.sym} 56840 -18580 0 0 {name=p56397 lab=_87655_/Q }
C {devices/lab_pin.sym} 56960 -18600 0 1 {name=p56398 lab=_67626_/X }
C {sky130_stdcells/and2_4.sym} 56900 -18600 0 0 {name=X_67626_ }
C {devices/lab_pin.sym} 56810 -18470 0 0 {name=p56399 lab=_85562_/CLK }
C {devices/lab_pin.sym} 56810 -18450 0 0 {name=p56400 lab=_48941_/Y }
C {devices/lab_pin.sym} 56990 -18470 0 1 {name=p56401 lab=_64759_/B }
C {sky130_stdcells/dfxtp_4.sym} 56900 -18460 0 0 {name=X_86460_ }
C {devices/lab_pin.sym} 56860 -18330 0 0 {name=p56402 lab=_52852_/A }
C {devices/lab_pin.sym} 56940 -18330 0 1 {name=p56403 lab=_52853_/B }
C {sky130_stdcells/buf_2.sym} 56900 -18330 0 0 {name=X_52852_ }
C {devices/lab_pin.sym} 56840 -18230 0 0 {name=p56404 lab=_64832_/X }
C {devices/lab_pin.sym} 56840 -18190 0 0 {name=p56405 lab=_64888_/B }
C {devices/lab_pin.sym} 56840 -18150 0 0 {name=p56406 lab=_64837_/X }
C {devices/lab_pin.sym} 56960 -18190 0 1 {name=p56407 lab=_64838_/Y }
C {sky130_stdcells/nand3_4.sym} 56900 -18190 0 0 {name=X_64838_ }
C {devices/lab_pin.sym} 56810 -18050 0 0 {name=p56408 lab=_83673_/CLK }
C {devices/lab_pin.sym} 56810 -18030 0 0 {name=p56409 lab=_70891_/Y }
C {devices/lab_pin.sym} 56990 -18050 0 1 {name=p56410 lab=_46778_/A }
C {sky130_stdcells/dfxtp_4.sym} 56900 -18040 0 0 {name=X_83672_ }
C {devices/lab_pin.sym} 56810 -17910 0 0 {name=p56411 lab=_80854_/CLK }
C {devices/lab_pin.sym} 56810 -17890 0 0 {name=p56412 lab=_75741_/B }
C {devices/lab_pin.sym} 56990 -17910 0 1 {name=p56413 lab=_80852_/D }
C {sky130_stdcells/dfxtp_4.sym} 56900 -17900 0 0 {name=X_80884_ }
C {devices/lab_pin.sym} 56810 -17770 0 0 {name=p56414 lab=_85635_/CLK }
C {devices/lab_pin.sym} 56810 -17750 0 0 {name=p56415 lab=_54608_/Y }
C {devices/lab_pin.sym} 56990 -17770 0 1 {name=p56416 lab=_85411_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -17760 0 0 {name=X_85411_ }
C {devices/lab_pin.sym} 56860 -17630 0 0 {name=p56417 lab=_53282_/A }
C {devices/lab_pin.sym} 56940 -17630 0 1 {name=p56418 lab=_51804_/A }
C {sky130_stdcells/buf_2.sym} 56900 -17630 0 0 {name=X_51803_ }
C {devices/lab_pin.sym} 56810 -17510 0 0 {name=p56419 lab=_82715_/CLK }
C {devices/lab_pin.sym} 56810 -17490 0 0 {name=p56420 lab=_82623_/D }
C {devices/lab_pin.sym} 56990 -17510 0 1 {name=p56421 lab=_82623_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -17500 0 0 {name=X_82623_ }
C {devices/lab_pin.sym} 56860 -17370 0 0 {name=p56422 lab=_55507_/X }
C {devices/lab_pin.sym} 56940 -17370 0 1 {name=p56423 lab=_55571_/X }
C {sky130_stdcells/buf_2.sym} 56900 -17370 0 0 {name=X_55571_ }
C {devices/lab_pin.sym} 56820 -17280 0 0 {name=p56424 lab=_87914_/Q }
C {devices/lab_pin.sym} 56820 -17240 0 0 {name=p56425 lab=_67533_/X }
C {devices/lab_pin.sym} 56820 -17200 0 0 {name=p56426 lab=_67508_/X }
C {devices/lab_pin.sym} 56820 -17160 0 0 {name=p56427 lab=_67556_/X }
C {devices/lab_pin.sym} 56980 -17220 0 1 {name=p56428 lab=_67557_/X }
C {sky130_stdcells/a211o_4.sym} 56900 -17220 0 0 {name=X_67557_ }
C {devices/lab_pin.sym} 56810 -17070 0 0 {name=p56429 lab=_83681_/CLK }
C {devices/lab_pin.sym} 56810 -17050 0 0 {name=p56430 lab=_86391_/D }
C {devices/lab_pin.sym} 56990 -17070 0 1 {name=p56431 lab=_58687_/B }
C {sky130_stdcells/dfxtp_4.sym} 56900 -17060 0 0 {name=X_86391_ }
C {devices/lab_pin.sym} 56860 -16930 0 0 {name=p56432 lab=_52783_/A }
C {devices/lab_pin.sym} 56940 -16930 0 1 {name=p56433 lab=_52783_/X }
C {sky130_stdcells/buf_2.sym} 56900 -16930 0 0 {name=X_52783_ }
C {devices/lab_pin.sym} 56840 -16820 0 0 {name=p56434 lab=_64769_/A }
C {devices/lab_pin.sym} 56840 -16780 0 0 {name=p56435 lab=_86267_/Q }
C {devices/lab_pin.sym} 56960 -16800 0 1 {name=p56436 lab=_64769_/X }
C {sky130_stdcells/and2_4.sym} 56900 -16800 0 0 {name=X_64769_ }
C {devices/lab_pin.sym} 56860 -16670 0 0 {name=p56437 lab=_57310_/A }
C {devices/lab_pin.sym} 56940 -16670 0 1 {name=p56438 lab=_85037_/D }
C {sky130_stdcells/inv_2.sym} 56900 -16670 0 0 {name=X_57310_ }
C {devices/lab_pin.sym} 56810 -16550 0 0 {name=p56439 lab=_88386_/CLK }
C {devices/lab_pin.sym} 56810 -16530 0 0 {name=p56440 lab=_88130_/D }
C {devices/lab_pin.sym} 56990 -16550 0 1 {name=p56441 lab=_66978_/B }
C {sky130_stdcells/dfxtp_4.sym} 56900 -16540 0 0 {name=X_88130_ }
C {devices/lab_pin.sym} 56840 -16440 0 0 {name=p56442 lab=_54509_/A }
C {devices/lab_pin.sym} 56840 -16400 0 0 {name=p56443 lab=_54526_/B }
C {devices/lab_pin.sym} 56840 -16360 0 0 {name=p56444 lab=_54509_/C }
C {devices/lab_pin.sym} 56840 -16320 0 0 {name=p56445 lab=_54522_/D }
C {devices/lab_pin.sym} 56960 -16380 0 1 {name=p56446 lab=_54522_/X }
C {sky130_stdcells/and4_4.sym} 56900 -16380 0 0 {name=X_54522_ }
C {devices/lab_pin.sym} 56820 -16250 0 0 {name=p56447 lab=_60371_/X }
C {devices/lab_pin.sym} 56820 -16210 0 0 {name=p56448 lab=_66315_/Y }
C {devices/lab_pin.sym} 56820 -16170 0 0 {name=p56449 lab=_66507_/Y }
C {devices/lab_pin.sym} 56980 -16210 0 1 {name=p56450 lab=_66508_/Y }
C {sky130_stdcells/o21ai_4.sym} 56900 -16210 0 0 {name=X_66508_ }
C {devices/lab_pin.sym} 56810 -16070 0 0 {name=p56451 lab=_85342_/CLK }
C {devices/lab_pin.sym} 56810 -16050 0 0 {name=p56452 lab=_54980_/Y }
C {devices/lab_pin.sym} 56990 -16070 0 1 {name=p56453 lab=_85342_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -16060 0 0 {name=X_85342_ }
C {devices/lab_pin.sym} 56860 -15930 0 0 {name=p56454 lab=_52593_/A }
C {devices/lab_pin.sym} 56940 -15930 0 1 {name=p56455 lab=_52588_/A }
C {sky130_stdcells/buf_2.sym} 56900 -15930 0 0 {name=X_51734_ }
C {devices/lab_pin.sym} 56860 -15810 0 0 {name=p56456 lab=_83406_/Q }
C {devices/lab_pin.sym} 56940 -15810 0 1 {name=p56457 lab=_58290_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -15810 0 0 {name=X_58290_ }
C {devices/lab_pin.sym} 56810 -15690 0 0 {name=p56458 lab=_82558_/CLK }
C {devices/lab_pin.sym} 56810 -15670 0 0 {name=p56459 lab=_83874_/Q }
C {devices/lab_pin.sym} 56990 -15690 0 1 {name=p56460 lab=_82554_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -15680 0 0 {name=X_82554_ }
C {devices/lab_pin.sym} 56820 -15580 0 0 {name=p56461 lab=_87469_/Q }
C {devices/lab_pin.sym} 56820 -15540 0 0 {name=p56462 lab=_67394_/X }
C {devices/lab_pin.sym} 56820 -15500 0 0 {name=p56463 lab=_67462_/X }
C {devices/lab_pin.sym} 56820 -15460 0 0 {name=p56464 lab=_67487_/X }
C {devices/lab_pin.sym} 56980 -15520 0 1 {name=p56465 lab=_67488_/X }
C {sky130_stdcells/a211o_4.sym} 56900 -15520 0 0 {name=X_67488_ }
C {devices/lab_pin.sym} 56810 -15370 0 0 {name=p56466 lab=_81322_/CLK }
C {devices/lab_pin.sym} 56810 -15350 0 0 {name=p56467 lab=_81505_/D }
C {devices/lab_pin.sym} 56990 -15370 0 1 {name=p56468 lab=_81505_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -15360 0 0 {name=X_81505_ }
C {devices/lab_pin.sym} 56820 -15260 0 0 {name=p56469 lab=_44288_/X }
C {devices/lab_pin.sym} 56820 -15220 0 0 {name=p56470 lab=_56578_/X }
C {devices/lab_pin.sym} 56820 -15180 0 0 {name=p56471 lab=_45444_/A }
C {devices/lab_pin.sym} 56820 -15140 0 0 {name=p56472 lab=_57238_/X }
C {devices/lab_pin.sym} 56980 -15200 0 1 {name=p56473 lab=_85054_/D }
C {sky130_stdcells/a2bb2o_4.sym} 56900 -15200 0 0 {name=X_57241_ }
C {devices/lab_pin.sym} 56820 -15070 0 0 {name=p56474 lab=_68532_/X }
C {devices/lab_pin.sym} 56820 -15030 0 0 {name=p56475 lab=_68536_/X }
C {devices/lab_pin.sym} 56820 -14990 0 0 {name=p56476 lab=_69212_/X }
C {devices/lab_pin.sym} 56980 -15030 0 1 {name=p56477 lab=_69227_/Y }
C {sky130_stdcells/a21oi_4.sym} 56900 -15030 0 0 {name=X_69227_ }
C {devices/lab_pin.sym} 56810 -14890 0 0 {name=p56478 lab=_87813_/CLK }
C {devices/lab_pin.sym} 56810 -14870 0 0 {name=p56479 lab=_42040_/Y }
C {devices/lab_pin.sym} 56990 -14890 0 1 {name=p56480 lab=_73320_/A }
C {sky130_stdcells/dfxtp_4.sym} 56900 -14880 0 0 {name=X_88061_ }
C {devices/lab_pin.sym} 56860 -14750 0 0 {name=p56481 lab=_54399_/A }
C {devices/lab_pin.sym} 56940 -14750 0 1 {name=p56482 lab=_54453_/X }
C {sky130_stdcells/buf_2.sym} 56900 -14750 0 0 {name=X_54453_ }
C {devices/lab_pin.sym} 56820 -14650 0 0 {name=p56483 lab=_66435_/Y }
C {devices/lab_pin.sym} 56820 -14610 0 0 {name=p56484 lab=_64532_/X }
C {devices/lab_pin.sym} 56820 -14570 0 0 {name=p56485 lab=_66438_/X }
C {devices/lab_pin.sym} 56980 -14610 0 1 {name=p56486 lab=_84123_/D }
C {sky130_stdcells/o21ai_4.sym} 56900 -14610 0 0 {name=X_66439_ }
C {devices/lab_pin.sym} 56810 -14470 0 0 {name=p56487 lab=_85177_/CLK }
C {devices/lab_pin.sym} 56810 -14450 0 0 {name=p56488 lab=_56215_/Y }
C {devices/lab_pin.sym} 56990 -14470 0 1 {name=p56489 lab=_85273_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -14460 0 0 {name=X_85273_ }
C {devices/lab_pin.sym} 56840 -14340 0 0 {name=p56490 lab=_51671_/A }
C {devices/lab_pin.sym} 56840 -14300 0 0 {name=p56491 lab=_53187_/B }
C {devices/lab_pin.sym} 56960 -14320 0 1 {name=p56492 lab=_51665_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -14320 0 0 {name=X_51665_ }
C {devices/lab_pin.sym} 56810 -14190 0 0 {name=p56493 lab=_82485_/CLK }
C {devices/lab_pin.sym} 56810 -14170 0 0 {name=p56494 lab=_78594_/X }
C {devices/lab_pin.sym} 56990 -14190 0 1 {name=p56495 lab=_78154_/B }
C {sky130_stdcells/dfxtp_4.sym} 56900 -14180 0 0 {name=X_82485_ }
C {devices/lab_pin.sym} 56810 -14050 0 0 {name=p56496 lab=_87333_/CLK }
C {devices/lab_pin.sym} 56810 -14030 0 0 {name=p56497 lab=_87012_/D }
C {devices/lab_pin.sym} 56990 -14050 0 1 {name=p56498 lab=_87012_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -14040 0 0 {name=X_87012_ }
C {devices/lab_pin.sym} 56860 -13910 0 0 {name=p56499 lab=_53351_/A }
C {devices/lab_pin.sym} 56940 -13910 0 1 {name=p56500 lab=_53404_/X }
C {sky130_stdcells/buf_2.sym} 56900 -13910 0 0 {name=X_53404_ }
C {devices/lab_pin.sym} 56810 -13790 0 0 {name=p56501 lab=_81227_/CLK }
C {devices/lab_pin.sym} 56810 -13770 0 0 {name=p56502 lab=_64871_/X }
C {devices/lab_pin.sym} 56990 -13790 0 1 {name=p56503 lab=_84224_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -13780 0 0 {name=X_84224_ }
C {devices/lab_pin.sym} 56820 -13670 0 0 {name=p56504 lab=_50613_/Y }
C {devices/lab_pin.sym} 56820 -13630 0 0 {name=p56505 lab=_50577_/X }
C {devices/lab_pin.sym} 56820 -13590 0 0 {name=p56506 lab=_50615_/Y }
C {devices/lab_pin.sym} 56980 -13630 0 1 {name=p56507 lab=_50616_/Y }
C {sky130_stdcells/a21boi_4.sym} 56900 -13630 0 0 {name=X_50616_ }
C {devices/lab_pin.sym} 56820 -13510 0 0 {name=p56508 lab=_57169_/X }
C {devices/lab_pin.sym} 56820 -13470 0 0 {name=p56509 lab=_57170_/Y }
C {devices/lab_pin.sym} 56820 -13430 0 0 {name=p56510 lab=_74342_/A }
C {devices/lab_pin.sym} 56980 -13470 0 1 {name=p56511 lab=_57172_/Y }
C {sky130_stdcells/a21oi_4.sym} 56900 -13470 0 0 {name=X_57172_ }
C {devices/lab_pin.sym} 56810 -13330 0 0 {name=p56512 lab=_82648_/CLK }
C {devices/lab_pin.sym} 56810 -13310 0 0 {name=p56513 lab=_81468_/Q }
C {devices/lab_pin.sym} 56990 -13330 0 1 {name=p56514 lab=_76126_/C }
C {sky130_stdcells/dfxtp_4.sym} 56900 -13320 0 0 {name=X_81436_ }
C {devices/lab_pin.sym} 56820 -13210 0 0 {name=p56515 lab=_68407_/X }
C {devices/lab_pin.sym} 56820 -13170 0 0 {name=p56516 lab=_68410_/X }
C {devices/lab_pin.sym} 56820 -13130 0 0 {name=p56517 lab=_69061_/X }
C {devices/lab_pin.sym} 56980 -13170 0 1 {name=p56518 lab=_69158_/Y }
C {sky130_stdcells/a21oi_4.sym} 56900 -13170 0 0 {name=X_69158_ }
C {devices/lab_pin.sym} 56860 -13030 0 0 {name=p56519 lab=_54245_/A }
C {devices/lab_pin.sym} 56940 -13030 0 1 {name=p56520 lab=_54385_/A }
C {sky130_stdcells/buf_2.sym} 56900 -13030 0 0 {name=X_54384_ }
C {devices/lab_pin.sym} 56840 -12920 0 0 {name=p56521 lab=_51617_/A }
C {devices/lab_pin.sym} 56840 -12880 0 0 {name=p56522 lab=_53122_/B }
C {devices/lab_pin.sym} 56960 -12900 0 1 {name=p56523 lab=_51596_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -12900 0 0 {name=X_51596_ }
C {devices/lab_pin.sym} 56860 -12770 0 0 {name=p56524 lab=_56123_/A }
C {devices/lab_pin.sym} 56940 -12770 0 1 {name=p56525 lab=_56140_/B }
C {sky130_stdcells/buf_2.sym} 56900 -12770 0 0 {name=X_56123_ }
C {devices/lab_pin.sym} 56820 -12670 0 0 {name=p56526 lab=_84037_/Q }
C {devices/lab_pin.sym} 56820 -12630 0 0 {name=p56527 lab=_68101_/X }
C {devices/lab_pin.sym} 56820 -12590 0 0 {name=p56528 lab=_68108_/X }
C {devices/lab_pin.sym} 56980 -12630 0 1 {name=p56529 lab=_68109_/X }
C {sky130_stdcells/a21bo_4.sym} 56900 -12630 0 0 {name=X_68109_ }
C {devices/lab_pin.sym} 56820 -12510 0 0 {name=p56530 lab=_53333_/Y }
C {devices/lab_pin.sym} 56820 -12470 0 0 {name=p56531 lab=_53328_/X }
C {devices/lab_pin.sym} 56820 -12430 0 0 {name=p56532 lab=_53334_/X }
C {devices/lab_pin.sym} 56980 -12470 0 1 {name=p56533 lab=_53335_/Y }
C {sky130_stdcells/a21oi_4.sym} 56900 -12470 0 0 {name=X_53335_ }
C {devices/lab_pin.sym} 56810 -12330 0 0 {name=p56534 lab=_84166_/CLK }
C {devices/lab_pin.sym} 56810 -12310 0 0 {name=p56535 lab=_84155_/D }
C {devices/lab_pin.sym} 56990 -12330 0 1 {name=p56536 lab=_80481_/B }
C {sky130_stdcells/dfxtp_4.sym} 56900 -12320 0 0 {name=X_84155_ }
C {devices/lab_pin.sym} 56840 -12210 0 0 {name=p56537 lab=_48691_/A }
C {devices/lab_pin.sym} 56840 -12170 0 0 {name=p56538 lab=_50552_/B }
C {devices/lab_pin.sym} 56840 -12130 0 0 {name=p56539 lab=_50552_/C }
C {devices/lab_pin.sym} 56960 -12170 0 1 {name=p56540 lab=_50547_/X }
C {sky130_stdcells/and3_4.sym} 56900 -12170 0 0 {name=X_50547_ }
C {devices/lab_pin.sym} 56810 -12030 0 0 {name=p56541 lab=_81352_/CLK }
C {devices/lab_pin.sym} 56810 -12010 0 0 {name=p56542 lab=_81367_/D }
C {devices/lab_pin.sym} 56990 -12030 0 1 {name=p56543 lab=_81367_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -12020 0 0 {name=X_81367_ }
C {devices/lab_pin.sym} 56840 -11900 0 0 {name=p56544 lab=_69661_/A }
C {devices/lab_pin.sym} 56840 -11860 0 0 {name=p56545 lab=_69089_/B }
C {devices/lab_pin.sym} 56960 -11880 0 1 {name=p56546 lab=_69089_/Y }
C {sky130_stdcells/nor2_4.sym} 56900 -11880 0 0 {name=X_69089_ }
C {devices/lab_pin.sym} 56820 -11770 0 0 {name=p56547 lab=_49125_/X }
C {devices/lab_pin.sym} 56820 -11730 0 0 {name=p56548 lab=_71117_/X }
C {devices/lab_pin.sym} 56820 -11690 0 0 {name=p56549 lab=_71119_/Y }
C {devices/lab_pin.sym} 56980 -11730 0 1 {name=p56550 lab=_71120_/Y }
C {sky130_stdcells/o21ai_4.sym} 56900 -11730 0 0 {name=X_71120_ }
C {devices/lab_pin.sym} 56810 -11590 0 0 {name=p56551 lab=_83095_/CLK }
C {devices/lab_pin.sym} 56810 -11570 0 0 {name=p56552 lab=_83106_/D }
C {devices/lab_pin.sym} 56990 -11590 0 1 {name=p56553 lab=_83106_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -11580 0 0 {name=X_83106_ }
C {devices/lab_pin.sym} 56840 -11460 0 0 {name=p56554 lab=_80318_/A }
C {devices/lab_pin.sym} 56840 -11420 0 0 {name=p56555 lab=_80317_/B }
C {devices/lab_pin.sym} 56960 -11440 0 1 {name=p56556 lab=_80318_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -11440 0 0 {name=X_80318_ }
C {devices/lab_pin.sym} 56840 -11320 0 0 {name=p56557 lab=_56044_/X }
C {devices/lab_pin.sym} 56840 -11280 0 0 {name=p56558 lab=_56054_/B }
C {devices/lab_pin.sym} 56960 -11300 0 1 {name=p56559 lab=_56055_/A }
C {sky130_stdcells/xnor2_4.sym} 56900 -11300 0 0 {name=X_56054_ }
C {devices/lab_pin.sym} 56840 -11180 0 0 {name=p56560 lab=_81698_/Q }
C {devices/lab_pin.sym} 56840 -11140 0 0 {name=p56561 lab=_41280_/B }
C {devices/lab_pin.sym} 56960 -11160 0 1 {name=p56562 lab=_41280_/X }
C {sky130_stdcells/or2_4.sym} 56900 -11160 0 0 {name=X_41280_ }
C {devices/lab_pin.sym} 56840 -11060 0 0 {name=p56563 lab=_51914_/A }
C {devices/lab_pin.sym} 56840 -11020 0 0 {name=p56564 lab=_53274_/B }
C {devices/lab_pin.sym} 56840 -10980 0 0 {name=p56565 lab=_53266_/C }
C {devices/lab_pin.sym} 56840 -10940 0 0 {name=p56566 lab=_52750_/D }
C {devices/lab_pin.sym} 56960 -11000 0 1 {name=p56567 lab=_53266_/X }
C {sky130_stdcells/and4_4.sym} 56900 -11000 0 0 {name=X_53266_ }
C {devices/lab_pin.sym} 56810 -10850 0 0 {name=p56568 lab=_83918_/CLK }
C {devices/lab_pin.sym} 56810 -10830 0 0 {name=p56569 lab=_67045_/X }
C {devices/lab_pin.sym} 56990 -10850 0 1 {name=p56570 lab=_80910_/D }
C {sky130_stdcells/dfxtp_4.sym} 56900 -10840 0 0 {name=X_84086_ }
C {devices/lab_pin.sym} 56820 -10730 0 0 {name=p56571 lab=_86193_/Q }
C {devices/lab_pin.sym} 56820 -10690 0 0 {name=p56572 lab=_50464_/X }
C {devices/lab_pin.sym} 56820 -10650 0 0 {name=p56573 lab=_50477_/Y }
C {devices/lab_pin.sym} 56980 -10690 0 1 {name=p56574 lab=_50478_/Y }
C {sky130_stdcells/o21ai_4.sym} 56900 -10690 0 0 {name=X_50478_ }
C {devices/lab_pin.sym} 56860 -10550 0 0 {name=p56575 lab=clkbuf_6_32_0_CLK/X }
C {devices/lab_pin.sym} 56940 -10550 0 1 {name=p56576 lab=clkbuf_7_64_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 56900 -10550 0 0 {name=Xclkbuf_7_64_0_CLK }
C {devices/lab_pin.sym} 56810 -10430 0 0 {name=p56577 lab=_81362_/CLK }
C {devices/lab_pin.sym} 56810 -10410 0 0 {name=p56578 lab=_76986_/X }
C {devices/lab_pin.sym} 56990 -10430 0 1 {name=p56579 lab=_81298_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -10420 0 0 {name=X_81298_ }
C {devices/lab_pin.sym} 56840 -10320 0 0 {name=p56580 lab=_55013_/A }
C {devices/lab_pin.sym} 56840 -10280 0 0 {name=p56581 lab=_55026_/B }
C {devices/lab_pin.sym} 56840 -10240 0 0 {name=p56582 lab=_55013_/C }
C {devices/lab_pin.sym} 56840 -10200 0 0 {name=p56583 lab=_55005_/D }
C {devices/lab_pin.sym} 56960 -10260 0 1 {name=p56584 lab=_55005_/X }
C {sky130_stdcells/and4_4.sym} 56900 -10260 0 0 {name=X_55005_ }
C {devices/lab_pin.sym} 56820 -10130 0 0 {name=p56585 lab=_85866_/Q }
C {devices/lab_pin.sym} 56820 -10090 0 0 {name=p56586 lab=_52214_/X }
C {devices/lab_pin.sym} 56820 -10050 0 0 {name=p56587 lab=_52216_/Y }
C {devices/lab_pin.sym} 56980 -10090 0 1 {name=p56588 lab=_52217_/Y }
C {sky130_stdcells/o21ai_4.sym} 56900 -10090 0 0 {name=X_52217_ }
C {devices/lab_pin.sym} 56820 -9970 0 0 {name=p56589 lab=_48878_/B }
C {devices/lab_pin.sym} 56820 -9930 0 0 {name=p56590 lab=_71047_/X }
C {devices/lab_pin.sym} 56820 -9890 0 0 {name=p56591 lab=_71050_/Y }
C {devices/lab_pin.sym} 56980 -9930 0 1 {name=p56592 lab=_71051_/Y }
C {sky130_stdcells/o21ai_4.sym} 56900 -9930 0 0 {name=X_71051_ }
C {devices/lab_pin.sym} 56810 -9790 0 0 {name=p56593 lab=_85213_/CLK }
C {devices/lab_pin.sym} 56810 -9770 0 0 {name=p56594 lab=_74556_/Y }
C {devices/lab_pin.sym} 56990 -9790 0 1 {name=p56595 lab=_44966_/A }
C {sky130_stdcells/dfxtp_4.sym} 56900 -9780 0 0 {name=X_83037_ }
C {devices/lab_pin.sym} 56810 -9650 0 0 {name=p56596 lab=_87653_/CLK }
C {devices/lab_pin.sym} 56810 -9630 0 0 {name=p56597 lab=_87914_/D }
C {devices/lab_pin.sym} 56990 -9650 0 1 {name=p56598 lab=_87914_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -9640 0 0 {name=X_87914_ }
C {devices/lab_pin.sym} 56840 -9520 0 0 {name=p56599 lab=_80247_/Y }
C {devices/lab_pin.sym} 56840 -9480 0 0 {name=p56600 lab=_80243_/X }
C {devices/lab_pin.sym} 56960 -9500 0 1 {name=p56601 lab=_80251_/A }
C {sky130_stdcells/nand2_4.sym} 56900 -9500 0 0 {name=X_80249_ }
C {devices/lab_pin.sym} 56820 -9390 0 0 {name=p56602 lab=_53194_/Y }
C {devices/lab_pin.sym} 56820 -9350 0 0 {name=p56603 lab=_53189_/X }
C {devices/lab_pin.sym} 56820 -9310 0 0 {name=p56604 lab=_53196_/X }
C {devices/lab_pin.sym} 56980 -9350 0 1 {name=p56605 lab=_85679_/D }
C {sky130_stdcells/a21oi_4.sym} 56900 -9350 0 0 {name=X_53197_ }
C {devices/lab_pin.sym} 56820 -9230 0 0 {name=p56606 lab=_69650_/X }
C {devices/lab_pin.sym} 56820 -9190 0 0 {name=p56607 lab=_69653_/X }
C {devices/lab_pin.sym} 56820 -9150 0 0 {name=p56608 lab=_70001_/X }
C {devices/lab_pin.sym} 56980 -9190 0 1 {name=p56609 lab=_70002_/Y }
C {sky130_stdcells/a21oi_4.sym} 56900 -9190 0 0 {name=X_70002_ }
C {devices/lab_pin.sym} 56860 -9050 0 0 {name=p56610 lab=_57689_/A }
C {devices/lab_pin.sym} 56940 -9050 0 1 {name=p56611 lab=_60341_/A }
C {sky130_stdcells/buf_2.sym} 56900 -9050 0 0 {name=X_59813_ }
C {devices/lab_pin.sym} 56840 -8940 0 0 {name=p56612 lab=_52127_/X }
C {devices/lab_pin.sym} 56840 -8900 0 0 {name=p56613 lab=_48763_/B }
C {devices/lab_pin.sym} 56960 -8920 0 1 {name=p56614 lab=_52148_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -8920 0 0 {name=X_52148_ }
C {devices/lab_pin.sym} 56810 -8790 0 0 {name=p56615 lab=_88097_/CLK }
C {devices/lab_pin.sym} 56810 -8770 0 0 {name=p56616 lab=_87845_/D }
C {devices/lab_pin.sym} 56990 -8790 0 1 {name=p56617 lab=_68727_/A }
C {sky130_stdcells/dfxtp_4.sym} 56900 -8780 0 0 {name=X_87845_ }
C {devices/lab_pin.sym} 56840 -8680 0 0 {name=p56618 lab=_74810_/A }
C {devices/lab_pin.sym} 56840 -8640 0 0 {name=p56619 lab=_74810_/B }
C {devices/lab_pin.sym} 56840 -8600 0 0 {name=p56620 lab=_74810_/C }
C {devices/lab_pin.sym} 56840 -8560 0 0 {name=p56621 lab=_74810_/D }
C {devices/lab_pin.sym} 56960 -8620 0 1 {name=p56622 lab=_74810_/Y }
C {sky130_stdcells/nand4_4.sym} 56900 -8620 0 0 {name=X_74810_ }
C {devices/lab_pin.sym} 56820 -8490 0 0 {name=p56623 lab=_59743_/Y }
C {devices/lab_pin.sym} 56820 -8450 0 0 {name=p56624 lab=_59754_/A }
C {devices/lab_pin.sym} 56820 -8410 0 0 {name=p56625 lab=_59816_/A }
C {devices/lab_pin.sym} 56980 -8450 0 1 {name=p56626 lab=_59744_/Y }
C {sky130_stdcells/a21oi_4.sym} 56900 -8450 0 0 {name=X_59744_ }
C {devices/lab_pin.sym} 56860 -8310 0 0 {name=p56627 lab=clkbuf_7_78_0_CLK/A }
C {devices/lab_pin.sym} 56940 -8310 0 1 {name=p56628 lab=clkbuf_7_79_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 56900 -8310 0 0 {name=Xclkbuf_7_79_0_CLK }
C {devices/lab_pin.sym} 56840 -8200 0 0 {name=p56629 lab=_44966_/Y }
C {devices/lab_pin.sym} 56840 -8160 0 0 {name=p56630 lab=_45033_/B }
C {devices/lab_pin.sym} 56960 -8180 0 1 {name=p56631 lab=_44970_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -8180 0 0 {name=X_44970_ }
C {devices/lab_pin.sym} 56840 -8060 0 0 {name=p56632 lab=_52083_/A }
C {devices/lab_pin.sym} 56840 -8020 0 0 {name=p56633 lab=_52079_/B }
C {devices/lab_pin.sym} 56960 -8040 0 1 {name=p56634 lab=_52079_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -8040 0 0 {name=X_52079_ }
C {devices/lab_pin.sym} 56820 -7940 0 0 {name=p56635 lab=_56949_/X }
C {devices/lab_pin.sym} 56820 -7900 0 0 {name=p56636 lab=_56607_/X }
C {devices/lab_pin.sym} 56820 -7860 0 0 {name=p56637 lab=_45501_/A }
C {devices/lab_pin.sym} 56820 -7820 0 0 {name=p56638 lab=_56947_/X }
C {devices/lab_pin.sym} 56980 -7880 0 1 {name=p56639 lab=_85114_/D }
C {sky130_stdcells/a2bb2o_4.sym} 56900 -7880 0 0 {name=X_56956_ }
C {devices/lab_pin.sym} 56820 -7760 0 0 {name=p56640 lab=_75778_/Y }
C {devices/lab_pin.sym} 56820 -7720 0 0 {name=p56641 lab=_75779_/Y }
C {devices/lab_pin.sym} 56820 -7680 0 0 {name=p56642 lab=_80920_/Q }
C {devices/lab_pin.sym} 56820 -7640 0 0 {name=p56643 lab=_75781_/Y }
C {devices/lab_pin.sym} 56980 -7700 0 1 {name=p56644 lab=_75790_/X }
C {sky130_stdcells/a2bb2o_4.sym} 56900 -7700 0 0 {name=X_75790_ }
C {devices/lab_pin.sym} 56810 -7550 0 0 {name=p56645 lab=_87776_/CLK }
C {devices/lab_pin.sym} 56810 -7530 0 0 {name=p56646 lab=_87776_/D }
C {devices/lab_pin.sym} 56990 -7550 0 1 {name=p56647 lab=_87776_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -7540 0 0 {name=X_87776_ }
C {devices/lab_pin.sym} 56810 -7410 0 0 {name=p56648 lab=_84991_/CLK }
C {devices/lab_pin.sym} 56810 -7390 0 0 {name=p56649 lab=_84988_/D }
C {devices/lab_pin.sym} 56990 -7410 0 1 {name=p56650 lab=_84988_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -7400 0 0 {name=X_84988_ }
C {devices/lab_pin.sym} 56820 -7300 0 0 {name=p56651 lab=_41397_/X }
C {devices/lab_pin.sym} 56820 -7260 0 0 {name=p56652 lab=_43907_/X }
C {devices/lab_pin.sym} 56820 -7220 0 0 {name=p56653 lab=_67845_/B }
C {devices/lab_pin.sym} 56820 -7180 0 0 {name=p56654 lab=_43908_/X }
C {devices/lab_pin.sym} 56980 -7240 0 1 {name=p56655 lab=_87198_/D }
C {sky130_stdcells/a2bb2o_4.sym} 56900 -7240 0 0 {name=X_43921_ }
C {devices/lab_pin.sym} 56820 -7110 0 0 {name=p56656 lab=_55904_/X }
C {devices/lab_pin.sym} 56820 -7070 0 0 {name=p56657 lab=_55906_/X }
C {devices/lab_pin.sym} 56820 -7030 0 0 {name=p56658 lab=_44118_/B }
C {devices/lab_pin.sym} 56980 -7070 0 1 {name=p56659 lab=_55907_/X }
C {sky130_stdcells/a21o_4.sym} 56900 -7070 0 0 {name=X_55907_ }
C {devices/lab_pin.sym} 56820 -6970 0 0 {name=p56660 lab=_71753_/D }
C {devices/lab_pin.sym} 56820 -6930 0 0 {name=p56661 lab=_71268_/A }
C {devices/lab_pin.sym} 56820 -6890 0 0 {name=p56662 lab=_74735_/X }
C {devices/lab_pin.sym} 56820 -6850 0 0 {name=p56663 lab=_74736_/X }
C {devices/lab_pin.sym} 56820 -6810 0 0 {name=p56664 lab=_74740_/Y }
C {devices/lab_pin.sym} 56980 -6890 0 1 {name=p56665 lab=_74741_/X }
C {sky130_stdcells/a2111o_4.sym} 56900 -6890 0 0 {name=X_74741_ }
C {devices/lab_pin.sym} 56810 -6730 0 0 {name=p56666 lab=_86119_/CLK }
C {devices/lab_pin.sym} 56810 -6710 0 0 {name=p56667 lab=_86727_/D }
C {devices/lab_pin.sym} 56990 -6730 0 1 {name=p56668 lab=_86727_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -6720 0 0 {name=X_86727_ }
C {devices/lab_pin.sym} 56840 -6620 0 0 {name=p56669 lab=_74531_/A }
C {devices/lab_pin.sym} 56840 -6580 0 0 {name=p56670 lab=_70766_/C }
C {devices/lab_pin.sym} 56840 -6540 0 0 {name=p56671 lab=_71349_/D }
C {devices/lab_pin.sym} 56840 -6500 0 0 {name=p56672 lab=_71894_/Y }
C {devices/lab_pin.sym} 56960 -6560 0 1 {name=p56673 lab=_71953_/Y }
C {sky130_stdcells/nand4_4.sym} 56900 -6560 0 0 {name=X_71953_ }
C {devices/lab_pin.sym} 56860 -6410 0 0 {name=p56674 lab=_66262_/A }
C {devices/lab_pin.sym} 56940 -6410 0 1 {name=p56675 lab=_66514_/B }
C {sky130_stdcells/buf_2.sym} 56900 -6410 0 0 {name=X_59675_ }
C {devices/lab_pin.sym} 56810 -6290 0 0 {name=p56676 lab=_81352_/CLK }
C {devices/lab_pin.sym} 56810 -6270 0 0 {name=p56677 lab=_69229_/X }
C {devices/lab_pin.sym} 56990 -6290 0 1 {name=p56678 lab=_83939_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -6280 0 0 {name=X_83939_ }
C {devices/lab_pin.sym} 56840 -6160 0 0 {name=p56679 lab=_56753_/A }
C {devices/lab_pin.sym} 56840 -6120 0 0 {name=p56680 lab=_56887_/B }
C {devices/lab_pin.sym} 56960 -6140 0 1 {name=p56681 lab=_56887_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -6140 0 0 {name=X_56887_ }
C {devices/lab_pin.sym} 56820 -6030 0 0 {name=p56682 lab=_51003_/B }
C {devices/lab_pin.sym} 56820 -5990 0 0 {name=p56683 lab=_70885_/A }
C {devices/lab_pin.sym} 56820 -5950 0 0 {name=p56684 lab=_70903_/Y }
C {devices/lab_pin.sym} 56980 -5990 0 1 {name=p56685 lab=_70904_/Y }
C {sky130_stdcells/o21ai_4.sym} 56900 -5990 0 0 {name=X_70904_ }
C {devices/lab_pin.sym} 56820 -5870 0 0 {name=p56686 lab=_46636_/Y }
C {devices/lab_pin.sym} 56820 -5830 0 0 {name=p56687 lab=_46598_/X }
C {devices/lab_pin.sym} 56820 -5790 0 0 {name=p56688 lab=_46639_/X }
C {devices/lab_pin.sym} 56980 -5830 0 1 {name=p56689 lab=_86719_/D }
C {sky130_stdcells/a21oi_4.sym} 56900 -5830 0 0 {name=X_46640_ }
C {devices/lab_pin.sym} 56820 -5710 0 0 {name=p56690 lab=_57997_/X }
C {devices/lab_pin.sym} 56820 -5670 0 0 {name=p56691 lab=_85948_/Q }
C {devices/lab_pin.sym} 56820 -5630 0 0 {name=p56692 lab=_58109_/X }
C {devices/lab_pin.sym} 56980 -5670 0 1 {name=p56693 lab=_58626_/X }
C {sky130_stdcells/o21a_4.sym} 56900 -5670 0 0 {name=X_58626_ }
C {devices/lab_pin.sym} 56860 -5530 0 0 {name=p56694 lab=_77459_/X }
C {devices/lab_pin.sym} 56940 -5530 0 1 {name=p56695 lab=_77460_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -5530 0 0 {name=X_77460_ }
C {devices/lab_pin.sym} 56820 -5450 0 0 {name=p56696 lab=_43846_/X }
C {devices/lab_pin.sym} 56820 -5410 0 0 {name=p56697 lab=_43824_/X }
C {devices/lab_pin.sym} 56820 -5370 0 0 {name=p56698 lab=_41209_/X }
C {devices/lab_pin.sym} 56820 -5330 0 0 {name=p56699 lab=_68815_/B }
C {devices/lab_pin.sym} 56820 -5290 0 0 {name=p56700 lab=_43847_/X }
C {devices/lab_pin.sym} 56980 -5370 0 1 {name=p56701 lab=_43852_/Y }
C {sky130_stdcells/o32ai_4.sym} 56900 -5370 0 0 {name=X_43852_ }
C {devices/lab_pin.sym} 56840 -5220 0 0 {name=p56702 lab=_55836_/A }
C {devices/lab_pin.sym} 56840 -5180 0 0 {name=p56703 lab=_56510_/C }
C {devices/lab_pin.sym} 56960 -5200 0 1 {name=p56704 lab=_55838_/X }
C {sky130_stdcells/and2_4.sym} 56900 -5200 0 0 {name=X_55838_ }
C {devices/lab_pin.sym} 56860 -5070 0 0 {name=p56705 lab=_74672_/A }
C {devices/lab_pin.sym} 56940 -5070 0 1 {name=p56706 lab=_74672_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -5070 0 0 {name=X_74672_ }
C {devices/lab_pin.sym} 56810 -4950 0 0 {name=p56707 lab=_86340_/CLK }
C {devices/lab_pin.sym} 56810 -4930 0 0 {name=p56708 lab=_47219_/Y }
C {devices/lab_pin.sym} 56990 -4950 0 1 {name=p56709 lab=_59377_/A }
C {sky130_stdcells/dfxtp_4.sym} 56900 -4940 0 0 {name=X_86658_ }
C {devices/lab_pin.sym} 56820 -4830 0 0 {name=p56710 lab=_71871_/X }
C {devices/lab_pin.sym} 56820 -4790 0 0 {name=p56711 lab=_59437_/B }
C {devices/lab_pin.sym} 56820 -4750 0 0 {name=p56712 lab=_71883_/Y }
C {devices/lab_pin.sym} 56980 -4790 0 1 {name=p56713 lab=_83341_/D }
C {sky130_stdcells/a21o_4.sym} 56900 -4790 0 0 {name=X_71884_ }
C {devices/lab_pin.sym} 56860 -4650 0 0 {name=p56714 lab=_76410_/Y }
C {devices/lab_pin.sym} 56940 -4650 0 1 {name=p56715 lab=_76411_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -4650 0 0 {name=X_76411_ }
C {devices/lab_pin.sym} 56860 -4530 0 0 {name=p56716 lab=_42822_/A }
C {devices/lab_pin.sym} 56940 -4530 0 1 {name=p56717 lab=_42803_/X }
C {sky130_stdcells/buf_2.sym} 56900 -4530 0 0 {name=X_42803_ }
C {devices/lab_pin.sym} 56820 -4430 0 0 {name=p56718 lab=_70125_/A }
C {devices/lab_pin.sym} 56820 -4390 0 0 {name=p56719 lab=_86754_/D }
C {devices/lab_pin.sym} 56820 -4350 0 0 {name=p56720 lab=_73622_/X }
C {devices/lab_pin.sym} 56980 -4390 0 1 {name=p56721 lab=_83143_/D }
C {sky130_stdcells/o21ai_4.sym} 56900 -4390 0 0 {name=X_73623_ }
C {devices/lab_pin.sym} 56810 -4250 0 0 {name=p56722 lab=_86535_/CLK }
C {devices/lab_pin.sym} 56810 -4230 0 0 {name=p56723 lab=_85609_/D }
C {devices/lab_pin.sym} 56990 -4250 0 1 {name=p56724 lab=_85609_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -4240 0 0 {name=X_85609_ }
C {devices/lab_pin.sym} 56860 -4110 0 0 {name=p56725 lab=clkbuf_7_71_0_CLK/X }
C {devices/lab_pin.sym} 56940 -4110 0 1 {name=p56726 lab=clkbuf_9_285_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 56900 -4110 0 0 {name=Xclkbuf_8_142_0_CLK }
C {devices/lab_pin.sym} 56820 -4010 0 0 {name=p56727 lab=_46566_/Y }
C {devices/lab_pin.sym} 56820 -3970 0 0 {name=p56728 lab=_46523_/X }
C {devices/lab_pin.sym} 56820 -3930 0 0 {name=p56729 lab=_46570_/Y }
C {devices/lab_pin.sym} 56980 -3970 0 1 {name=p56730 lab=_86725_/D }
C {sky130_stdcells/a21boi_4.sym} 56900 -3970 0 0 {name=X_46571_ }
C {devices/lab_pin.sym} 56860 -3830 0 0 {name=p56731 lab=_70848_/A }
C {devices/lab_pin.sym} 56940 -3830 0 1 {name=p56732 lab=_70846_/B }
C {sky130_stdcells/buf_2.sym} 56900 -3830 0 0 {name=X_70835_ }
C {devices/lab_pin.sym} 56840 -3720 0 0 {name=p56733 lab=_58557_/A }
C {devices/lab_pin.sym} 56840 -3680 0 0 {name=p56734 lab=_58557_/B }
C {devices/lab_pin.sym} 56960 -3700 0 1 {name=p56735 lab=_58557_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -3700 0 0 {name=X_58557_ }
C {devices/lab_pin.sym} 56820 -3590 0 0 {name=p56736 lab=_77382_/A }
C {devices/lab_pin.sym} 56820 -3550 0 0 {name=p56737 lab=_77382_/B }
C {devices/lab_pin.sym} 56820 -3510 0 0 {name=p56738 lab=_77381_/A }
C {devices/lab_pin.sym} 56980 -3550 0 1 {name=p56739 lab=_77417_/A }
C {sky130_stdcells/o21a_4.sym} 56900 -3550 0 0 {name=X_77391_ }
C {devices/lab_pin.sym} 56840 -3420 0 0 {name=p56740 lab=_55159_/A }
C {devices/lab_pin.sym} 56840 -3380 0 0 {name=p56741 lab=_85289_/Q }
C {devices/lab_pin.sym} 56960 -3400 0 1 {name=p56742 lab=_55769_/X }
C {sky130_stdcells/and2_4.sym} 56900 -3400 0 0 {name=X_55769_ }
C {devices/lab_pin.sym} 56860 -3270 0 0 {name=p56743 lab=_43782_/Y }
C {devices/lab_pin.sym} 56940 -3270 0 1 {name=p56744 lab=_43783_/Y }
C {sky130_stdcells/inv_2.sym} 56900 -3270 0 0 {name=X_43783_ }
C {devices/lab_pin.sym} 56810 -3150 0 0 {name=p56745 lab=_86237_/CLK }
C {devices/lab_pin.sym} 56810 -3130 0 0 {name=p56746 lab=_47888_/Y }
C {devices/lab_pin.sym} 56990 -3150 0 1 {name=p56747 lab=_86589_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -3140 0 0 {name=X_86589_ }
C {devices/lab_pin.sym} 56860 -3010 0 0 {name=p56748 lab=_40995_/A }
C {devices/lab_pin.sym} 56940 -3010 0 1 {name=p56749 lab=_40995_/X }
C {sky130_stdcells/buf_2.sym} 56900 -3010 0 0 {name=X_40995_ }
C {devices/lab_pin.sym} 56840 -2900 0 0 {name=p56750 lab=_48319_/A }
C {devices/lab_pin.sym} 56840 -2860 0 0 {name=p56751 lab=_48310_/B }
C {devices/lab_pin.sym} 56960 -2880 0 1 {name=p56752 lab=_48310_/Y }
C {sky130_stdcells/nand2_4.sym} 56900 -2880 0 0 {name=X_48310_ }
C {devices/lab_pin.sym} 56840 -2760 0 0 {name=p56753 lab=_79130_/A }
C {devices/lab_pin.sym} 56840 -2720 0 0 {name=p56754 lab=_79130_/B }
C {devices/lab_pin.sym} 56960 -2740 0 1 {name=p56755 lab=_82438_/D }
C {sky130_stdcells/xor2_4.sym} 56900 -2740 0 0 {name=X_79130_ }
C {devices/lab_pin.sym} 56820 -2630 0 0 {name=p56756 lab=_57504_/Y }
C {devices/lab_pin.sym} 56820 -2590 0 0 {name=p56757 lab=_57506_/X }
C {devices/lab_pin.sym} 56820 -2550 0 0 {name=p56758 lab=_57507_/X }
C {devices/lab_pin.sym} 56980 -2590 0 1 {name=p56759 lab=_57508_/Y }
C {sky130_stdcells/a21oi_4.sym} 56900 -2590 0 0 {name=X_57508_ }
C {devices/lab_pin.sym} 56820 -2480 0 0 {name=p56760 lab=_45519_/Y }
C {devices/lab_pin.sym} 56820 -2440 0 0 {name=p56761 lab=_45489_/X }
C {devices/lab_pin.sym} 56820 -2400 0 0 {name=p56762 lab=_45520_/X }
C {devices/lab_pin.sym} 56820 -2360 0 0 {name=p56763 lab=_45521_/Y }
C {devices/lab_pin.sym} 56980 -2420 0 1 {name=p56764 lab=_45522_/X }
C {sky130_stdcells/a211o_4.sym} 56900 -2420 0 0 {name=X_45522_ }
C {devices/lab_pin.sym} 56840 -2280 0 0 {name=p56765 lab=_76356_/A }
C {devices/lab_pin.sym} 56840 -2240 0 0 {name=p56766 lab=_76342_/B }
C {devices/lab_pin.sym} 56960 -2260 0 1 {name=p56767 lab=_81615_/D }
C {sky130_stdcells/xor2_4.sym} 56900 -2260 0 0 {name=X_76342_ }
C {devices/lab_pin.sym} 56810 -2130 0 0 {name=p56768 lab=_87063_/CLK }
C {devices/lab_pin.sym} 56810 -2110 0 0 {name=p56769 lab=_40823_/X }
C {devices/lab_pin.sym} 56990 -2130 0 1 {name=p56770 lab=_88328_/Q }
C {sky130_stdcells/dfxtp_4.sym} 56900 -2120 0 0 {name=X_88328_ }
C {devices/lab_pin.sym} 56860 -1990 0 0 {name=p56771 lab=_42734_/A }
C {devices/lab_pin.sym} 56940 -1990 0 1 {name=p56772 lab=_87745_/D }
C {sky130_stdcells/inv_2.sym} 56900 -1990 0 0 {name=X_42734_ }
C {devices/lab_pin.sym} 56820 -1890 0 0 {name=p56773 lab=_49288_/Y }
C {devices/lab_pin.sym} 56820 -1850 0 0 {name=p56774 lab=_49271_/X }
C {devices/lab_pin.sym} 56820 -1810 0 0 {name=p56775 lab=_49289_/Y }
C {devices/lab_pin.sym} 56980 -1850 0 1 {name=p56776 lab=_49290_/Y }
C {sky130_stdcells/a21boi_4.sym} 56900 -1850 0 0 {name=X_49290_ }
C {devices/lab_pin.sym} 56840 -1720 0 0 {name=p56777 lab=_73554_/A }
C {devices/lab_pin.sym} 56840 -1680 0 0 {name=p56778 lab=_73577_/B }
C {devices/lab_pin.sym} 56960 -1700 0 1 {name=p56779 lab=_73554_/Y }
C {sky130_stdcells/nor2_4.sym} 56900 -1700 0 0 {name=X_73554_ }
C {devices/lab_pin.sym} 56840 -1600 0 0 {name=p56780 lab=_70860_/A }
C {devices/lab_pin.sym} 56840 -1560 0 0 {name=p56781 lab=_70779_/B }
C {devices/lab_pin.sym} 56840 -1520 0 0 {name=p56782 lab=_70766_/C }
C {devices/lab_pin.sym} 56840 -1480 0 0 {name=p56783 lab=_70769_/D }
C {devices/lab_pin.sym} 56960 -1540 0 1 {name=p56784 lab=_70766_/Y }
C {sky130_stdcells/nand4_4.sym} 56900 -1540 0 0 {name=X_70766_ }
C {devices/lab_pin.sym} 56820 -1410 0 0 {name=p56785 lab=_58467_/X }
C {devices/lab_pin.sym} 56820 -1370 0 0 {name=p56786 lab=_58485_/Y }
C {devices/lab_pin.sym} 56820 -1330 0 0 {name=p56787 lab=_58487_/Y }
C {devices/lab_pin.sym} 56980 -1370 0 1 {name=p56788 lab=_84837_/D }
C {sky130_stdcells/a21oi_4.sym} 56900 -1370 0 0 {name=X_58488_ }
C {devices/lab_pin.sym} 56860 -1230 0 0 {name=p56789 lab=_48169_/X }
C {devices/lab_pin.sym} 56940 -1230 0 1 {name=p56790 lab=_48241_/X }
C {sky130_stdcells/buf_2.sym} 56900 -1230 0 0 {name=X_48241_ }
C {devices/lab_pin.sym} 56840 -1120 0 0 {name=p56791 lab=_61302_/A }
C {devices/lab_pin.sym} 56840 -1080 0 0 {name=p56792 lab=_72503_/A }
C {devices/lab_pin.sym} 56960 -1100 0 1 {name=p56793 lab=_72535_/B }
C {sky130_stdcells/nand2_4.sym} 56900 -1100 0 0 {name=X_72505_ }
C {devices/lab_pin.sym} 56840 -980 0 0 {name=p56794 lab=_79059_/X }
C {devices/lab_pin.sym} 56840 -940 0 0 {name=p56795 lab=_79060_/Y }
C {devices/lab_pin.sym} 56960 -960 0 1 {name=p56796 lab=_82717_/D }
C {sky130_stdcells/nand2_4.sym} 56900 -960 0 0 {name=X_79061_ }
C {devices/lab_pin.sym} 56820 -850 0 0 {name=p56797 lab=_45434_/X }
C {devices/lab_pin.sym} 56820 -810 0 0 {name=p56798 lab=_61367_/A }
C {devices/lab_pin.sym} 56820 -770 0 0 {name=p56799 lab=_45452_/X }
C {devices/lab_pin.sym} 56980 -810 0 1 {name=p56800 lab=_45453_/Y }
C {sky130_stdcells/o21ai_4.sym} 56900 -810 0 0 {name=X_45453_ }
C {devices/lab_pin.sym} 56860 -670 0 0 {name=p56801 lab=_57439_/A }
C {devices/lab_pin.sym} 56940 -670 0 1 {name=p56802 lab=_85004_/D }
C {sky130_stdcells/inv_2.sym} 56900 -670 0 0 {name=X_57439_ }
C {devices/lab_pin.sym} 57760 -42160 0 0 {name=p56803 lab=_76273_/A }
C {devices/lab_pin.sym} 57760 -42120 0 0 {name=p56804 lab=_76272_/Y }
C {devices/lab_pin.sym} 57880 -42140 0 1 {name=p56805 lab=_81610_/D }
C {sky130_stdcells/xnor2_4.sym} 57820 -42140 0 0 {name=X_76273_ }
C {devices/lab_pin.sym} 57730 -42010 0 0 {name=p56806 lab=_87103_/CLK }
C {devices/lab_pin.sym} 57730 -41990 0 0 {name=p56807 lab=_88259_/D }
C {devices/lab_pin.sym} 57910 -42010 0 1 {name=p56808 lab=_68775_/B }
C {sky130_stdcells/dfxtp_4.sym} 57820 -42000 0 0 {name=X_88259_ }
C {devices/lab_pin.sym} 57780 -41870 0 0 {name=p56809 lab=_42590_/A }
C {devices/lab_pin.sym} 57860 -41870 0 1 {name=p56810 lab=_42665_/X }
C {sky130_stdcells/buf_2.sym} 57820 -41870 0 0 {name=X_42665_ }
C {devices/lab_pin.sym} 57780 -41750 0 0 {name=p56811 lab=clkbuf_6_8_0_CLK/X }
C {devices/lab_pin.sym} 57860 -41750 0 1 {name=p56812 lab=clkbuf_8_35_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 57820 -41750 0 0 {name=Xclkbuf_7_17_0_CLK }
C {devices/lab_pin.sym} 57740 -41660 0 0 {name=p56813 lab=_42057_/Y }
C {devices/lab_pin.sym} 57740 -41620 0 0 {name=p56814 lab=_72888_/X }
C {devices/lab_pin.sym} 57740 -41580 0 0 {name=p56815 lab=_72890_/X }
C {devices/lab_pin.sym} 57740 -41540 0 0 {name=p56816 lab=_73484_/Y }
C {devices/lab_pin.sym} 57900 -41600 0 1 {name=p56817 lab=_73485_/X }
C {sky130_stdcells/a211o_4.sym} 57820 -41600 0 0 {name=X_73485_ }
C {devices/lab_pin.sym} 57780 -41450 0 0 {name=p56818 lab=_70935_/A }
C {devices/lab_pin.sym} 57860 -41450 0 1 {name=p56819 lab=_70698_/B }
C {sky130_stdcells/inv_2.sym} 57820 -41450 0 0 {name=X_70697_ }
C {devices/lab_pin.sym} 57780 -41330 0 0 {name=p56820 lab=_78012_/A }
C {devices/lab_pin.sym} 57860 -41330 0 1 {name=p56821 lab=_78012_/Y }
C {sky130_stdcells/inv_2.sym} 57820 -41330 0 0 {name=X_78012_ }
C {devices/lab_pin.sym} 57780 -41210 0 0 {name=p56822 lab=_44381_/A }
C {devices/lab_pin.sym} 57860 -41210 0 1 {name=p56823 lab=_44404_/X }
C {sky130_stdcells/buf_2.sym} 57820 -41210 0 0 {name=X_44404_ }
C {devices/lab_pin.sym} 57780 -41090 0 0 {name=p56824 lab=clkbuf_7_78_0_CLK/X }
C {devices/lab_pin.sym} 57860 -41090 0 1 {name=p56825 lab=clkbuf_9_315_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 57820 -41090 0 0 {name=Xclkbuf_8_157_0_CLK }
C {devices/lab_pin.sym} 57780 -40970 0 0 {name=p56826 lab=_75224_/A }
C {devices/lab_pin.sym} 57860 -40970 0 1 {name=p56827 lab=_75224_/Y }
C {sky130_stdcells/inv_2.sym} 57820 -40970 0 0 {name=X_75224_ }
C {devices/lab_pin.sym} 57780 -40850 0 0 {name=p56828 lab=_41615_/X }
C {devices/lab_pin.sym} 57860 -40850 0 1 {name=p56829 lab=_41616_/X }
C {sky130_stdcells/buf_2.sym} 57820 -40850 0 0 {name=X_41616_ }
C {devices/lab_pin.sym} 57780 -40730 0 0 {name=p56830 lab=_48171_/X }
C {devices/lab_pin.sym} 57860 -40730 0 1 {name=p56831 lab=_50048_/A }
C {sky130_stdcells/buf_2.sym} 57820 -40730 0 0 {name=X_48172_ }
C {devices/lab_pin.sym} 57780 -40610 0 0 {name=p56832 lab=_60404_/Y }
C {devices/lab_pin.sym} 57860 -40610 0 1 {name=p56833 lab=_60588_/A }
C {sky130_stdcells/buf_2.sym} 57820 -40610 0 0 {name=X_60450_ }
C {devices/lab_pin.sym} 57760 -40500 0 0 {name=p56834 lab=_72414_/X }
C {devices/lab_pin.sym} 57760 -40460 0 0 {name=p56835 lab=_72436_/B }
C {devices/lab_pin.sym} 57880 -40480 0 1 {name=p56836 lab=_72436_/Y }
C {sky130_stdcells/nor2_4.sym} 57820 -40480 0 0 {name=X_72436_ }
C {devices/lab_pin.sym} 57780 -40350 0 0 {name=p56837 lab=clkbuf_9_76_0_CLK/X }
C {devices/lab_pin.sym} 57860 -40350 0 1 {name=p56838 lab=_81631_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 57820 -40350 0 0 {name=Xclkbuf_10_152_0_CLK }
C {devices/lab_pin.sym} 57740 -40250 0 0 {name=p56839 lab=_45350_/X }
C {devices/lab_pin.sym} 57740 -40210 0 0 {name=p56840 lab=_61692_/B }
C {devices/lab_pin.sym} 57740 -40170 0 0 {name=p56841 lab=_45370_/X }
C {devices/lab_pin.sym} 57900 -40210 0 1 {name=p56842 lab=_45384_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -40210 0 0 {name=X_45384_ }
C {devices/lab_pin.sym} 57780 -40070 0 0 {name=p56843 lab=_42596_/A }
C {devices/lab_pin.sym} 57860 -40070 0 1 {name=p56844 lab=_42596_/Y }
C {sky130_stdcells/inv_2.sym} 57820 -40070 0 0 {name=X_42596_ }
C {devices/lab_pin.sym} 57780 -39950 0 0 {name=p56845 lab=clkbuf_9_391_0_CLK/X }
C {devices/lab_pin.sym} 57860 -39950 0 1 {name=p56846 lab=_82702_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 57820 -39950 0 0 {name=Xclkbuf_10_782_0_CLK }
C {devices/lab_pin.sym} 57740 -39850 0 0 {name=p56847 lab=_59104_/Y }
C {devices/lab_pin.sym} 57740 -39810 0 0 {name=p56848 lab=_59108_/Y }
C {devices/lab_pin.sym} 57740 -39770 0 0 {name=p56849 lab=_58939_/X }
C {devices/lab_pin.sym} 57900 -39810 0 1 {name=p56850 lab=_59109_/X }
C {sky130_stdcells/a21o_4.sym} 57820 -39810 0 0 {name=X_59109_ }
C {devices/lab_pin.sym} 57780 -39670 0 0 {name=p56851 lab=_83699_/Q }
C {devices/lab_pin.sym} 57860 -39670 0 1 {name=p56852 lab=_53386_/B }
C {sky130_stdcells/inv_2.sym} 57820 -39670 0 0 {name=X_47123_ }
C {devices/lab_pin.sym} 57740 -39580 0 0 {name=p56853 lab=_41663_/X }
C {devices/lab_pin.sym} 57740 -39540 0 0 {name=p56854 lab=_44326_/X }
C {devices/lab_pin.sym} 57740 -39500 0 0 {name=p56855 lab=_87161_/Q }
C {devices/lab_pin.sym} 57740 -39460 0 0 {name=p56856 lab=_44327_/X }
C {devices/lab_pin.sym} 57900 -39520 0 1 {name=p56857 lab=_44335_/X }
C {sky130_stdcells/a2bb2o_4.sym} 57820 -39520 0 0 {name=X_44335_ }
C {devices/lab_pin.sym} 57740 -39390 0 0 {name=p56858 lab=_75151_/Y }
C {devices/lab_pin.sym} 57740 -39350 0 0 {name=p56859 lab=_75153_/Y }
C {devices/lab_pin.sym} 57740 -39310 0 0 {name=p56860 lab=_75154_/Y }
C {devices/lab_pin.sym} 57900 -39350 0 1 {name=p56861 lab=_75155_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -39350 0 0 {name=X_75155_ }
C {devices/lab_pin.sym} 57780 -39210 0 0 {name=p56862 lab=_41547_/A }
C {devices/lab_pin.sym} 57860 -39210 0 1 {name=p56863 lab=_88195_/D }
C {sky130_stdcells/inv_2.sym} 57820 -39210 0 0 {name=X_41547_ }
C {devices/lab_pin.sym} 57780 -39090 0 0 {name=p56864 lab=_60381_/A }
C {devices/lab_pin.sym} 57860 -39090 0 1 {name=p56865 lab=_60447_/A }
C {sky130_stdcells/buf_2.sym} 57820 -39090 0 0 {name=X_60381_ }
C {devices/lab_pin.sym} 57780 -38970 0 0 {name=p56866 lab=_57790_/X }
C {devices/lab_pin.sym} 57860 -38970 0 1 {name=p56867 lab=_72401_/B }
C {sky130_stdcells/buf_2.sym} 57820 -38970 0 0 {name=X_72367_ }
C {devices/lab_pin.sym} 57780 -38850 0 0 {name=p56868 lab=_62120_/A }
C {devices/lab_pin.sym} 57860 -38850 0 1 {name=p56869 lab=_62144_/A }
C {sky130_stdcells/buf_2.sym} 57820 -38850 0 0 {name=X_62120_ }
C {devices/lab_pin.sym} 57780 -38730 0 0 {name=p56870 lab=_72908_/A }
C {devices/lab_pin.sym} 57860 -38730 0 1 {name=p56871 lab=_74106_/X }
C {sky130_stdcells/buf_2.sym} 57820 -38730 0 0 {name=X_74106_ }
C {devices/lab_pin.sym} 57780 -38610 0 0 {name=p56872 lab=clkbuf_8_136_0_CLK/X }
C {devices/lab_pin.sym} 57860 -38610 0 1 {name=p56873 lab=clkbuf_9_273_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 57820 -38610 0 0 {name=Xclkbuf_9_273_0_CLK }
C {devices/lab_pin.sym} 57760 -38500 0 0 {name=p56874 lab=_47063_/A }
C {devices/lab_pin.sym} 57760 -38460 0 0 {name=p56875 lab=_52829_/B }
C {devices/lab_pin.sym} 57880 -38480 0 1 {name=p56876 lab=_47054_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -38480 0 0 {name=X_47054_ }
C {devices/lab_pin.sym} 57780 -38350 0 0 {name=p56877 lab=_70454_/Y }
C {devices/lab_pin.sym} 57860 -38350 0 1 {name=p56878 lab=_71319_/B }
C {sky130_stdcells/buf_2.sym} 57820 -38350 0 0 {name=X_71318_ }
C {devices/lab_pin.sym} 57760 -38250 0 0 {name=p56879 lab=_44006_/X }
C {devices/lab_pin.sym} 57760 -38210 0 0 {name=p56880 lab=_44164_/X }
C {devices/lab_pin.sym} 57760 -38170 0 0 {name=p56881 lab=_44266_/C }
C {devices/lab_pin.sym} 57880 -38210 0 1 {name=p56882 lab=_44266_/Y }
C {sky130_stdcells/nand3_4.sym} 57820 -38210 0 0 {name=X_44266_ }
C {devices/lab_pin.sym} 57760 -38090 0 0 {name=p56883 lab=_79963_/A }
C {devices/lab_pin.sym} 57760 -38050 0 0 {name=p56884 lab=_79958_/A }
C {devices/lab_pin.sym} 57760 -38010 0 0 {name=p56885 lab=_79957_/Y }
C {devices/lab_pin.sym} 57880 -38050 0 1 {name=p56886 lab=_79963_/Y }
C {sky130_stdcells/nand3_4.sym} 57820 -38050 0 0 {name=X_79963_ }
C {devices/lab_pin.sym} 57760 -37920 0 0 {name=p56887 lab=_75086_/A }
C {devices/lab_pin.sym} 57760 -37880 0 0 {name=p56888 lab=_75079_/B }
C {devices/lab_pin.sym} 57880 -37900 0 1 {name=p56889 lab=_75086_/Y }
C {sky130_stdcells/nor2_4.sym} 57820 -37900 0 0 {name=X_75086_ }
C {devices/lab_pin.sym} 57740 -37790 0 0 {name=p56890 lab=_41449_/X }
C {devices/lab_pin.sym} 57740 -37750 0 0 {name=p56891 lab=_82333_/Q }
C {devices/lab_pin.sym} 57740 -37710 0 0 {name=p56892 lab=_41477_/X }
C {devices/lab_pin.sym} 57900 -37750 0 1 {name=p56893 lab=_41478_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -37750 0 0 {name=X_41478_ }
C {devices/lab_pin.sym} 57740 -37640 0 0 {name=p56894 lab=_72286_/Y }
C {devices/lab_pin.sym} 57740 -37600 0 0 {name=p56895 lab=_72237_/X }
C {devices/lab_pin.sym} 57740 -37560 0 0 {name=p56896 lab=_72293_/X }
C {devices/lab_pin.sym} 57740 -37520 0 0 {name=p56897 lab=_72297_/X }
C {devices/lab_pin.sym} 57900 -37580 0 1 {name=p56898 lab=_83267_/D }
C {sky130_stdcells/a22oi_4.sym} 57820 -37580 0 0 {name=X_72298_ }
C {devices/lab_pin.sym} 57740 -37470 0 0 {name=p56899 lab=_45994_/X }
C {devices/lab_pin.sym} 57740 -37430 0 0 {name=p56900 lab=_46001_/X }
C {devices/lab_pin.sym} 57740 -37390 0 0 {name=p56901 lab=_40490_/X }
C {devices/lab_pin.sym} 57740 -37350 0 0 {name=p56902 lab=_86818_/Q }
C {devices/lab_pin.sym} 57740 -37310 0 0 {name=p56903 lab=_45995_/X }
C {devices/lab_pin.sym} 57900 -37390 0 1 {name=p56904 lab=_46006_/A }
C {sky130_stdcells/o32ai_4.sym} 57820 -37390 0 0 {name=X_46005_ }
C {devices/lab_pin.sym} 57780 -37230 0 0 {name=p56905 lab=clkbuf_9_83_0_CLK/X }
C {devices/lab_pin.sym} 57860 -37230 0 1 {name=p56906 lab=_81668_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 57820 -37230 0 0 {name=Xclkbuf_10_167_0_CLK }
C {devices/lab_pin.sym} 57780 -37110 0 0 {name=p56907 lab=_43217_/A }
C {devices/lab_pin.sym} 57860 -37110 0 1 {name=p56908 lab=_43218_/A }
C {sky130_stdcells/buf_2.sym} 57820 -37110 0 0 {name=X_43217_ }
C {devices/lab_pin.sym} 57780 -36990 0 0 {name=p56909 lab=_61820_/A }
C {devices/lab_pin.sym} 57860 -36990 0 1 {name=p56910 lab=_62090_/B }
C {sky130_stdcells/buf_2.sym} 57820 -36990 0 0 {name=X_62051_ }
C {devices/lab_pin.sym} 57740 -36890 0 0 {name=p56911 lab=_86987_/Q }
C {devices/lab_pin.sym} 57740 -36850 0 0 {name=p56912 lab=_73916_/B }
C {devices/lab_pin.sym} 57740 -36810 0 0 {name=p56913 lab=_74036_/X }
C {devices/lab_pin.sym} 57900 -36850 0 1 {name=p56914 lab=_74048_/C }
C {sky130_stdcells/o21ai_4.sym} 57820 -36850 0 0 {name=X_74037_ }
C {devices/lab_pin.sym} 57760 -36720 0 0 {name=p56915 lab=_78899_/Y }
C {devices/lab_pin.sym} 57760 -36680 0 0 {name=p56916 lab=_78913_/X }
C {devices/lab_pin.sym} 57880 -36700 0 1 {name=p56917 lab=_78914_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -36700 0 0 {name=X_78914_ }
C {devices/lab_pin.sym} 57780 -36570 0 0 {name=p56918 lab=_49140_/B }
C {devices/lab_pin.sym} 57860 -36570 0 1 {name=p56919 lab=_40429_/X }
C {sky130_stdcells/buf_2.sym} 57820 -36570 0 0 {name=X_40429_ }
C {devices/lab_pin.sym} 57740 -36470 0 0 {name=p56920 lab=_50232_/B }
C {devices/lab_pin.sym} 57740 -36430 0 0 {name=p56921 lab=_71239_/X }
C {devices/lab_pin.sym} 57740 -36390 0 0 {name=p56922 lab=_71248_/Y }
C {devices/lab_pin.sym} 57900 -36430 0 1 {name=p56923 lab=_71249_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -36430 0 0 {name=X_71249_ }
C {devices/lab_pin.sym} 57780 -36290 0 0 {name=p56924 lab=_44196_/X }
C {devices/lab_pin.sym} 57860 -36290 0 1 {name=p56925 lab=_56953_/A }
C {sky130_stdcells/buf_2.sym} 57820 -36290 0 0 {name=X_44197_ }
C {devices/lab_pin.sym} 57760 -36180 0 0 {name=p56926 lab=_79531_/X }
C {devices/lab_pin.sym} 57760 -36140 0 0 {name=p56927 lab=_79532_/Y }
C {devices/lab_pin.sym} 57880 -36160 0 1 {name=p56928 lab=_79895_/B }
C {sky130_stdcells/nand2_4.sym} 57820 -36160 0 0 {name=X_79894_ }
C {devices/lab_pin.sym} 57780 -36030 0 0 {name=p56929 lab=clkbuf_9_398_0_CLK/X }
C {devices/lab_pin.sym} 57860 -36030 0 1 {name=p56930 lab=_84115_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 57820 -36030 0 0 {name=Xclkbuf_10_797_0_CLK }
C {devices/lab_pin.sym} 57740 -35950 0 0 {name=p56931 lab=_60952_/X }
C {devices/lab_pin.sym} 57740 -35910 0 0 {name=p56932 lab=_60993_/Y }
C {devices/lab_pin.sym} 57740 -35870 0 0 {name=p56933 lab=_60995_/Y }
C {devices/lab_pin.sym} 57740 -35830 0 0 {name=p56934 lab=_60999_/X }
C {devices/lab_pin.sym} 57740 -35790 0 0 {name=p56935 lab=_61001_/X }
C {devices/lab_pin.sym} 57900 -35870 0 1 {name=p56936 lab=_84543_/D }
C {sky130_stdcells/o41a_4.sym} 57820 -35870 0 0 {name=X_61002_ }
C {devices/lab_pin.sym} 57780 -35710 0 0 {name=p56937 lab=_43147_/Y }
C {devices/lab_pin.sym} 57860 -35710 0 1 {name=p56938 lab=_87558_/D }
C {sky130_stdcells/inv_2.sym} 57820 -35710 0 0 {name=X_43148_ }
C {devices/lab_pin.sym} 57760 -35600 0 0 {name=p56939 lab=_82726_/Q }
C {devices/lab_pin.sym} 57760 -35560 0 0 {name=p56940 lab=_78845_/B }
C {devices/lab_pin.sym} 57880 -35580 0 1 {name=p56941 lab=_78845_/X }
C {sky130_stdcells/xor2_4.sym} 57820 -35580 0 0 {name=X_78845_ }
C {devices/lab_pin.sym} 57780 -35450 0 0 {name=p56942 lab=clkbuf_8_144_0_CLK/X }
C {devices/lab_pin.sym} 57860 -35450 0 1 {name=p56943 lab=clkbuf_9_288_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 57820 -35450 0 0 {name=Xclkbuf_9_288_0_CLK }
C {devices/lab_pin.sym} 57740 -35350 0 0 {name=p56944 lab=_65805_/X }
C {devices/lab_pin.sym} 57740 -35310 0 0 {name=p56945 lab=_65808_/X }
C {devices/lab_pin.sym} 57740 -35270 0 0 {name=p56946 lab=_65809_/X }
C {devices/lab_pin.sym} 57900 -35310 0 1 {name=p56947 lab=_65810_/X }
C {sky130_stdcells/a21o_4.sym} 57820 -35310 0 0 {name=X_65810_ }
C {devices/lab_pin.sym} 57740 -35190 0 0 {name=p56948 lab=_47904_/X }
C {devices/lab_pin.sym} 57740 -35150 0 0 {name=p56949 lab=_46380_/A }
C {devices/lab_pin.sym} 57740 -35110 0 0 {name=p56950 lab=_47955_/X }
C {devices/lab_pin.sym} 57900 -35150 0 1 {name=p56951 lab=_47957_/B }
C {sky130_stdcells/o21ai_4.sym} 57820 -35150 0 0 {name=X_47956_ }
C {devices/lab_pin.sym} 57740 -35050 0 0 {name=p56952 lab=_43053_/X }
C {devices/lab_pin.sym} 57740 -35010 0 0 {name=p56953 lab=_43054_/X }
C {devices/lab_pin.sym} 57740 -34970 0 0 {name=p56954 lab=_40696_/X }
C {devices/lab_pin.sym} 57740 -34930 0 0 {name=p56955 lab=_43078_/Y }
C {devices/lab_pin.sym} 57740 -34890 0 0 {name=p56956 lab=_43058_/X }
C {devices/lab_pin.sym} 57900 -34970 0 1 {name=p56957 lab=_43079_/Y }
C {sky130_stdcells/o32ai_4.sym} 57820 -34970 0 0 {name=X_43079_ }
C {devices/lab_pin.sym} 57740 -34840 0 0 {name=p56958 lab=_87126_/Q }
C {devices/lab_pin.sym} 57740 -34800 0 0 {name=p56959 lab=_66715_/X }
C {devices/lab_pin.sym} 57740 -34760 0 0 {name=p56960 lab=_66717_/X }
C {devices/lab_pin.sym} 57740 -34720 0 0 {name=p56961 lab=_66789_/X }
C {devices/lab_pin.sym} 57900 -34780 0 1 {name=p56962 lab=_66790_/X }
C {sky130_stdcells/a211o_4.sym} 57820 -34780 0 0 {name=X_66790_ }
C {devices/lab_pin.sym} 57760 -34640 0 0 {name=p56963 lab=_78788_/A }
C {devices/lab_pin.sym} 57760 -34600 0 0 {name=p56964 lab=_82700_/Q }
C {devices/lab_pin.sym} 57880 -34620 0 1 {name=p56965 lab=_78777_/B }
C {sky130_stdcells/xor2_4.sym} 57820 -34620 0 0 {name=X_78776_ }
C {devices/lab_pin.sym} 57760 -34500 0 0 {name=p56966 lab=_81708_/D }
C {devices/lab_pin.sym} 57760 -34460 0 0 {name=p56967 lab=_81420_/Q }
C {devices/lab_pin.sym} 57880 -34480 0 1 {name=p56968 lab=_76005_/A }
C {sky130_stdcells/xor2_4.sym} 57820 -34480 0 0 {name=X_75988_ }
C {devices/lab_pin.sym} 57780 -34350 0 0 {name=p56969 lab=clkbuf_9_360_0_CLK/X }
C {devices/lab_pin.sym} 57860 -34350 0 1 {name=p56970 lab=_88272_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 57820 -34350 0 0 {name=Xclkbuf_10_720_0_CLK }
C {devices/lab_pin.sym} 57740 -34250 0 0 {name=p56971 lab=_46901_/Y }
C {devices/lab_pin.sym} 57740 -34210 0 0 {name=p56972 lab=_46891_/X }
C {devices/lab_pin.sym} 57740 -34170 0 0 {name=p56973 lab=_46906_/X }
C {devices/lab_pin.sym} 57900 -34210 0 1 {name=p56974 lab=_86691_/D }
C {sky130_stdcells/a21oi_4.sym} 57820 -34210 0 0 {name=X_46907_ }
C {devices/lab_pin.sym} 57760 -34090 0 0 {name=p56975 lab=_65737_/X }
C {devices/lab_pin.sym} 57760 -34050 0 0 {name=p56976 lab=_65741_/B }
C {devices/lab_pin.sym} 57760 -34010 0 0 {name=p56977 lab=_65740_/X }
C {devices/lab_pin.sym} 57880 -34050 0 1 {name=p56978 lab=_65742_/B }
C {sky130_stdcells/nand3_4.sym} 57820 -34050 0 0 {name=X_65741_ }
C {devices/lab_pin.sym} 57760 -33920 0 0 {name=p56979 lab=_77725_/Y }
C {devices/lab_pin.sym} 57760 -33880 0 0 {name=p56980 lab=_78044_/A }
C {devices/lab_pin.sym} 57880 -33900 0 1 {name=p56981 lab=_77728_/B }
C {sky130_stdcells/xor2_4.sym} 57820 -33900 0 0 {name=X_77727_ }
C {devices/lab_pin.sym} 57760 -33780 0 0 {name=p56982 lab=_74942_/B }
C {devices/lab_pin.sym} 57760 -33740 0 0 {name=p56983 lab=_74939_/B }
C {devices/lab_pin.sym} 57880 -33760 0 1 {name=p56984 lab=_74940_/B }
C {sky130_stdcells/xnor2_4.sym} 57820 -33760 0 0 {name=X_74939_ }
C {devices/lab_pin.sym} 57760 -33650 0 0 {name=p56985 lab=_62988_/A }
C {devices/lab_pin.sym} 57760 -33610 0 0 {name=p56986 lab=_62988_/B }
C {devices/lab_pin.sym} 57760 -33570 0 0 {name=p56987 lab=_84367_/Q }
C {devices/lab_pin.sym} 57880 -33610 0 1 {name=p56988 lab=_62953_/Y }
C {sky130_stdcells/nor3_4.sym} 57820 -33610 0 0 {name=X_62953_ }
C {devices/lab_pin.sym} 57760 -33480 0 0 {name=p56989 lab=_47887_/A }
C {devices/lab_pin.sym} 57760 -33440 0 0 {name=p56990 lab=_47886_/X }
C {devices/lab_pin.sym} 57880 -33460 0 1 {name=p56991 lab=_47887_/X }
C {sky130_stdcells/and2_4.sym} 57820 -33460 0 0 {name=X_47887_ }
C {devices/lab_pin.sym} 57740 -33350 0 0 {name=p56992 lab=_49622_/Y }
C {devices/lab_pin.sym} 57740 -33310 0 0 {name=p56993 lab=_49623_/X }
C {devices/lab_pin.sym} 57740 -33270 0 0 {name=p56994 lab=_49625_/X }
C {devices/lab_pin.sym} 57900 -33310 0 1 {name=p56995 lab=_86353_/D }
C {sky130_stdcells/a21oi_4.sym} 57820 -33310 0 0 {name=X_49626_ }
C {devices/lab_pin.sym} 57780 -33170 0 0 {name=p56996 lab=_59605_/Y }
C {devices/lab_pin.sym} 57860 -33170 0 1 {name=p56997 lab=_61949_/C }
C {sky130_stdcells/buf_2.sym} 57820 -33170 0 0 {name=X_61904_ }
C {devices/lab_pin.sym} 57780 -33050 0 0 {name=p56998 lab=clkbuf_9_210_0_CLK/A }
C {devices/lab_pin.sym} 57860 -33050 0 1 {name=p56999 lab=clkbuf_9_211_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 57820 -33050 0 0 {name=Xclkbuf_9_211_0_CLK }
C {devices/lab_pin.sym} 57740 -32950 0 0 {name=p57000 lab=_83974_/Q }
C {devices/lab_pin.sym} 57740 -32910 0 0 {name=p57001 lab=_68338_/X }
C {devices/lab_pin.sym} 57740 -32870 0 0 {name=p57002 lab=_68459_/X }
C {devices/lab_pin.sym} 57900 -32910 0 1 {name=p57003 lab=_83974_/D }
C {sky130_stdcells/a21bo_4.sym} 57820 -32910 0 0 {name=X_68460_ }
C {devices/lab_pin.sym} 57760 -32800 0 0 {name=p57004 lab=_46830_/A }
C {devices/lab_pin.sym} 57760 -32760 0 0 {name=p57005 lab=_46830_/B }
C {devices/lab_pin.sym} 57760 -32720 0 0 {name=p57006 lab=_46830_/C }
C {devices/lab_pin.sym} 57760 -32680 0 0 {name=p57007 lab=_52704_/D }
C {devices/lab_pin.sym} 57880 -32740 0 1 {name=p57008 lab=_46838_/X }
C {sky130_stdcells/and4_4.sym} 57820 -32740 0 0 {name=X_46838_ }
C {devices/lab_pin.sym} 57740 -32610 0 0 {name=p57009 lab=_65668_/X }
C {devices/lab_pin.sym} 57740 -32570 0 0 {name=p57010 lab=_65671_/X }
C {devices/lab_pin.sym} 57740 -32530 0 0 {name=p57011 lab=_65642_/X }
C {devices/lab_pin.sym} 57900 -32570 0 1 {name=p57012 lab=_65676_/A }
C {sky130_stdcells/a21o_4.sym} 57820 -32570 0 0 {name=X_65672_ }
C {devices/lab_pin.sym} 57780 -32430 0 0 {name=p57013 lab=_77657_/X }
C {devices/lab_pin.sym} 57860 -32430 0 1 {name=p57014 lab=_77658_/Y }
C {sky130_stdcells/inv_2.sym} 57820 -32430 0 0 {name=X_77658_ }
C {devices/lab_pin.sym} 57760 -32340 0 0 {name=p57015 lab=_58487_/A }
C {devices/lab_pin.sym} 57760 -32300 0 0 {name=p57016 lab=_62841_/X }
C {devices/lab_pin.sym} 57760 -32260 0 0 {name=p57017 lab=_60197_/C }
C {devices/lab_pin.sym} 57760 -32220 0 0 {name=p57018 lab=_60202_/A }
C {devices/lab_pin.sym} 57880 -32280 0 1 {name=p57019 lab=_62884_/Y }
C {sky130_stdcells/nand4_4.sym} 57820 -32280 0 0 {name=X_62884_ }
C {devices/lab_pin.sym} 57760 -32140 0 0 {name=p57020 lab=_67364_/X }
C {devices/lab_pin.sym} 57760 -32100 0 0 {name=p57021 lab=_67411_/B }
C {devices/lab_pin.sym} 57880 -32120 0 1 {name=p57022 lab=_67411_/X }
C {sky130_stdcells/and2_4.sym} 57820 -32120 0 0 {name=X_67411_ }
C {devices/lab_pin.sym} 57780 -31990 0 0 {name=p57023 lab=clkbuf_9_52_0_CLK/X }
C {devices/lab_pin.sym} 57860 -31990 0 1 {name=p57024 lab=_87169_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 57820 -31990 0 0 {name=Xclkbuf_10_105_0_CLK }
C {devices/lab_pin.sym} 57760 -31880 0 0 {name=p57025 lab=_64623_/A }
C {devices/lab_pin.sym} 57760 -31840 0 0 {name=p57026 lab=_64622_/X }
C {devices/lab_pin.sym} 57880 -31860 0 1 {name=p57027 lab=_64623_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -31860 0 0 {name=X_64623_ }
C {devices/lab_pin.sym} 57760 -31740 0 0 {name=p57028 lab=_76605_/X }
C {devices/lab_pin.sym} 57760 -31700 0 0 {name=p57029 lab=_76604_/Y }
C {devices/lab_pin.sym} 57880 -31720 0 1 {name=p57030 lab=_76609_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -31720 0 0 {name=X_76609_ }
C {devices/lab_pin.sym} 57740 -31610 0 0 {name=p57031 lab=_49555_/Y }
C {devices/lab_pin.sym} 57740 -31570 0 0 {name=p57032 lab=_49541_/X }
C {devices/lab_pin.sym} 57740 -31530 0 0 {name=p57033 lab=_49556_/X }
C {devices/lab_pin.sym} 57900 -31570 0 1 {name=p57034 lab=_86366_/D }
C {sky130_stdcells/a21oi_4.sym} 57820 -31570 0 0 {name=X_49557_ }
C {devices/lab_pin.sym} 57760 -31450 0 0 {name=p57035 lab=_61865_/A }
C {devices/lab_pin.sym} 57760 -31410 0 0 {name=p57036 lab=_61865_/B }
C {devices/lab_pin.sym} 57760 -31370 0 0 {name=p57037 lab=_78074_/B }
C {devices/lab_pin.sym} 57880 -31410 0 1 {name=p57038 lab=_61835_/Y }
C {sky130_stdcells/nor3_4.sym} 57820 -31410 0 0 {name=X_61835_ }
C {devices/lab_pin.sym} 57740 -31290 0 0 {name=p57039 lab=_68382_/X }
C {devices/lab_pin.sym} 57740 -31250 0 0 {name=p57040 lab=_68388_/X }
C {devices/lab_pin.sym} 57740 -31210 0 0 {name=p57041 lab=_68390_/X }
C {devices/lab_pin.sym} 57900 -31250 0 1 {name=p57042 lab=_68391_/X }
C {sky130_stdcells/a21o_4.sym} 57820 -31250 0 0 {name=X_68391_ }
C {devices/lab_pin.sym} 57780 -31110 0 0 {name=p57043 lab=_46769_/A }
C {devices/lab_pin.sym} 57860 -31110 0 1 {name=p57044 lab=_52663_/B }
C {sky130_stdcells/inv_2.sym} 57820 -31110 0 0 {name=X_46769_ }
C {devices/lab_pin.sym} 57760 -31010 0 0 {name=p57045 lab=_77584_/X }
C {devices/lab_pin.sym} 57760 -30970 0 0 {name=p57046 lab=_77587_/Y }
C {devices/lab_pin.sym} 57760 -30930 0 0 {name=p57047 lab=_77585_/Y }
C {devices/lab_pin.sym} 57880 -30970 0 1 {name=p57048 lab=_77590_/B }
C {sky130_stdcells/nand3_4.sym} 57820 -30970 0 0 {name=X_77589_ }
C {devices/lab_pin.sym} 57780 -30830 0 0 {name=p57049 lab=clkbuf_9_367_0_CLK/X }
C {devices/lab_pin.sym} 57860 -30830 0 1 {name=p57050 lab=_88097_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 57820 -30830 0 0 {name=Xclkbuf_10_735_0_CLK }
C {devices/lab_pin.sym} 57760 -30720 0 0 {name=p57051 lab=_48508_/A }
C {devices/lab_pin.sym} 57760 -30680 0 0 {name=p57052 lab=_48485_/B }
C {devices/lab_pin.sym} 57880 -30700 0 1 {name=p57053 lab=_48508_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -30700 0 0 {name=X_48508_ }
C {devices/lab_pin.sym} 57740 -30590 0 0 {name=p57054 lab=_58792_/Y }
C {devices/lab_pin.sym} 57740 -30550 0 0 {name=p57055 lab=_66457_/Y }
C {devices/lab_pin.sym} 57740 -30510 0 0 {name=p57056 lab=_79327_/Y }
C {devices/lab_pin.sym} 57900 -30550 0 1 {name=p57057 lab=_79346_/A }
C {sky130_stdcells/o21a_4.sym} 57820 -30550 0 0 {name=X_79328_ }
C {devices/lab_pin.sym} 57760 -30420 0 0 {name=p57058 lab=_67342_/A }
C {devices/lab_pin.sym} 57760 -30380 0 0 {name=p57059 lab=_87667_/Q }
C {devices/lab_pin.sym} 57880 -30400 0 1 {name=p57060 lab=_67342_/X }
C {sky130_stdcells/and2_4.sym} 57820 -30400 0 0 {name=X_67342_ }
C {devices/lab_pin.sym} 57760 -30290 0 0 {name=p57061 lab=_61232_/X }
C {devices/lab_pin.sym} 57760 -30250 0 0 {name=p57062 lab=_61692_/B }
C {devices/lab_pin.sym} 57760 -30210 0 0 {name=p57063 lab=_61207_/X }
C {devices/lab_pin.sym} 57880 -30250 0 1 {name=p57064 lab=_64554_/Y }
C {sky130_stdcells/nand3_4.sym} 57820 -30250 0 0 {name=X_64554_ }
C {devices/lab_pin.sym} 57780 -30110 0 0 {name=p57065 lab=_49407_/A }
C {devices/lab_pin.sym} 57860 -30110 0 1 {name=p57066 lab=_49500_/A }
C {sky130_stdcells/buf_2.sym} 57820 -30110 0 0 {name=X_49488_ }
C {devices/lab_pin.sym} 57760 -30020 0 0 {name=p57067 lab=_61782_/A }
C {devices/lab_pin.sym} 57760 -29980 0 0 {name=p57068 lab=_61766_/B }
C {devices/lab_pin.sym} 57760 -29940 0 0 {name=p57069 lab=_61761_/Y }
C {devices/lab_pin.sym} 57760 -29900 0 0 {name=p57070 lab=_61766_/D }
C {devices/lab_pin.sym} 57880 -29960 0 1 {name=p57071 lab=_61766_/Y }
C {sky130_stdcells/nand4_4.sym} 57820 -29960 0 0 {name=X_61766_ }
C {devices/lab_pin.sym} 57780 -29810 0 0 {name=p57072 lab=clkbuf_8_113_0_CLK/X }
C {devices/lab_pin.sym} 57860 -29810 0 1 {name=p57073 lab=clkbuf_9_226_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 57820 -29810 0 0 {name=Xclkbuf_9_226_0_CLK }
C {devices/lab_pin.sym} 57760 -29720 0 0 {name=p57074 lab=_59403_/A }
C {devices/lab_pin.sym} 57760 -29680 0 0 {name=p57075 lab=_63491_/B }
C {devices/lab_pin.sym} 57760 -29640 0 0 {name=p57076 lab=_63514_/C }
C {devices/lab_pin.sym} 57760 -29600 0 0 {name=p57077 lab=_63491_/D }
C {devices/lab_pin.sym} 57880 -29660 0 1 {name=p57078 lab=_63505_/Y }
C {sky130_stdcells/nand4_4.sym} 57820 -29660 0 0 {name=X_63505_ }
C {devices/lab_pin.sym} 57740 -29530 0 0 {name=p57079 lab=_48043_/X }
C {devices/lab_pin.sym} 57740 -29490 0 0 {name=p57080 lab=_48958_/B }
C {devices/lab_pin.sym} 57740 -29450 0 0 {name=p57081 lab=_48438_/Y }
C {devices/lab_pin.sym} 57900 -29490 0 1 {name=p57082 lab=_48440_/A }
C {sky130_stdcells/o21ai_4.sym} 57820 -29490 0 0 {name=X_48439_ }
C {devices/lab_pin.sym} 57760 -29370 0 0 {name=p57083 lab=_60700_/A }
C {devices/lab_pin.sym} 57760 -29330 0 0 {name=p57084 lab=_60752_/B }
C {devices/lab_pin.sym} 57760 -29290 0 0 {name=p57085 lab=_60717_/C }
C {devices/lab_pin.sym} 57880 -29330 0 1 {name=p57086 lab=_60717_/Y }
C {sky130_stdcells/nor3_4.sym} 57820 -29330 0 0 {name=X_60717_ }
C {devices/lab_pin.sym} 57740 -29220 0 0 {name=p57087 lab=_87926_/Q }
C {devices/lab_pin.sym} 57740 -29180 0 0 {name=p57088 lab=_67176_/X }
C {devices/lab_pin.sym} 57740 -29140 0 0 {name=p57089 lab=_67271_/X }
C {devices/lab_pin.sym} 57740 -29100 0 0 {name=p57090 lab=_67272_/X }
C {devices/lab_pin.sym} 57900 -29160 0 1 {name=p57091 lab=_67273_/X }
C {sky130_stdcells/a211o_4.sym} 57820 -29160 0 0 {name=X_67273_ }
C {devices/lab_pin.sym} 57760 -29020 0 0 {name=p57092 lab=_79259_/A }
C {devices/lab_pin.sym} 57760 -28980 0 0 {name=p57093 lab=_83217_/Q }
C {devices/lab_pin.sym} 57880 -29000 0 1 {name=p57094 lab=_79260_/B }
C {sky130_stdcells/xor2_4.sym} 57820 -29000 0 0 {name=X_79259_ }
C {devices/lab_pin.sym} 57760 -28890 0 0 {name=p57095 lab=_61232_/X }
C {devices/lab_pin.sym} 57760 -28850 0 0 {name=p57096 lab=_61617_/B }
C {devices/lab_pin.sym} 57760 -28810 0 0 {name=p57097 lab=_61207_/X }
C {devices/lab_pin.sym} 57880 -28850 0 1 {name=p57098 lab=_64485_/Y }
C {sky130_stdcells/nand3_4.sym} 57820 -28850 0 0 {name=X_64485_ }
C {devices/lab_pin.sym} 57780 -28710 0 0 {name=p57099 lab=_61697_/A }
C {devices/lab_pin.sym} 57860 -28710 0 1 {name=p57100 lab=_61697_/Y }
C {sky130_stdcells/inv_2.sym} 57820 -28710 0 0 {name=X_61697_ }
C {devices/lab_pin.sym} 57740 -28620 0 0 {name=p57101 lab=_87481_/Q }
C {devices/lab_pin.sym} 57740 -28580 0 0 {name=p57102 lab=_68989_/X }
C {devices/lab_pin.sym} 57740 -28540 0 0 {name=p57103 lab=_69010_/X }
C {devices/lab_pin.sym} 57740 -28500 0 0 {name=p57104 lab=_69011_/X }
C {devices/lab_pin.sym} 57900 -28560 0 1 {name=p57105 lab=_69012_/X }
C {sky130_stdcells/a211o_4.sym} 57820 -28560 0 0 {name=X_69012_ }
C {devices/lab_pin.sym} 57740 -28430 0 0 {name=p57106 lab=_66221_/X }
C {devices/lab_pin.sym} 57740 -28390 0 0 {name=p57107 lab=_66223_/X }
C {devices/lab_pin.sym} 57740 -28350 0 0 {name=p57108 lab=_66057_/X }
C {devices/lab_pin.sym} 57900 -28390 0 1 {name=p57109 lab=_66224_/X }
C {sky130_stdcells/a21o_4.sym} 57820 -28390 0 0 {name=X_66224_ }
C {devices/lab_pin.sym} 57780 -28250 0 0 {name=p57110 lab=_52688_/A }
C {devices/lab_pin.sym} 57860 -28250 0 1 {name=p57111 lab=_51504_/A }
C {sky130_stdcells/buf_2.sym} 57820 -28250 0 0 {name=X_51450_ }
C {devices/lab_pin.sym} 57780 -28130 0 0 {name=p57112 lab=_63436_/A }
C {devices/lab_pin.sym} 57860 -28130 0 1 {name=p57113 lab=_63436_/X }
C {sky130_stdcells/buf_2.sym} 57820 -28130 0 0 {name=X_63436_ }
C {devices/lab_pin.sym} 57730 -28010 0 0 {name=p57114 lab=_82272_/CLK }
C {devices/lab_pin.sym} 57730 -27990 0 0 {name=p57115 lab=_82270_/D }
C {devices/lab_pin.sym} 57910 -28010 0 1 {name=p57116 lab=_82270_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -28000 0 0 {name=X_82270_ }
C {devices/lab_pin.sym} 57780 -27870 0 0 {name=p57117 lab=_60662_/A }
C {devices/lab_pin.sym} 57860 -27870 0 1 {name=p57118 lab=_60724_/B }
C {sky130_stdcells/buf_2.sym} 57820 -27870 0 0 {name=X_60648_ }
C {devices/lab_pin.sym} 57760 -27770 0 0 {name=p57119 lab=_52103_/A }
C {devices/lab_pin.sym} 57760 -27730 0 0 {name=p57120 lab=_50430_/B }
C {devices/lab_pin.sym} 57760 -27690 0 0 {name=p57121 lab=_50338_/X }
C {devices/lab_pin.sym} 57880 -27730 0 1 {name=p57122 lab=_50401_/X }
C {sky130_stdcells/and3_4.sym} 57820 -27730 0 0 {name=X_50401_ }
C {devices/lab_pin.sym} 57730 -27590 0 0 {name=p57123 lab=_84197_/CLK }
C {devices/lab_pin.sym} 57730 -27570 0 0 {name=p57124 lab=_81029_/Q }
C {devices/lab_pin.sym} 57910 -27590 0 1 {name=p57125 lab=_81221_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -27580 0 0 {name=X_81221_ }
C {devices/lab_pin.sym} 57760 -27460 0 0 {name=p57126 lab=_64694_/A }
C {devices/lab_pin.sym} 57760 -27420 0 0 {name=p57127 lab=_66155_/B }
C {devices/lab_pin.sym} 57880 -27440 0 1 {name=p57128 lab=_66155_/X }
C {sky130_stdcells/and2_4.sym} 57820 -27440 0 0 {name=X_66155_ }
C {devices/lab_pin.sym} 57740 -27330 0 0 {name=p57129 lab=_51379_/Y }
C {devices/lab_pin.sym} 57740 -27290 0 0 {name=p57130 lab=_51366_/X }
C {devices/lab_pin.sym} 57740 -27250 0 0 {name=p57131 lab=_51380_/X }
C {devices/lab_pin.sym} 57900 -27290 0 1 {name=p57132 lab=_51381_/Y }
C {sky130_stdcells/a21oi_4.sym} 57820 -27290 0 0 {name=X_51381_ }
C {devices/lab_pin.sym} 57780 -27150 0 0 {name=p57133 lab=_63357_/X }
C {devices/lab_pin.sym} 57860 -27150 0 1 {name=p57134 lab=_63368_/A }
C {sky130_stdcells/buf_2.sym} 57820 -27150 0 0 {name=X_63367_ }
C {devices/lab_pin.sym} 57740 -27060 0 0 {name=p57135 lab=_79136_/A }
C {devices/lab_pin.sym} 57740 -27020 0 0 {name=p57136 lab=_60577_/X }
C {devices/lab_pin.sym} 57740 -26980 0 0 {name=p57137 lab=_60578_/Y }
C {devices/lab_pin.sym} 57740 -26940 0 0 {name=p57138 lab=_60586_/D }
C {devices/lab_pin.sym} 57900 -27000 0 1 {name=p57139 lab=_84596_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 57820 -27000 0 0 {name=X_60579_ }
C {devices/lab_pin.sym} 57780 -26850 0 0 {name=p57140 lab=_53172_/A }
C {devices/lab_pin.sym} 57860 -26850 0 1 {name=p57141 lab=_53120_/X }
C {sky130_stdcells/buf_2.sym} 57820 -26850 0 0 {name=X_53120_ }
C {devices/lab_pin.sym} 57740 -26760 0 0 {name=p57142 lab=_65035_/X }
C {devices/lab_pin.sym} 57740 -26720 0 0 {name=p57143 lab=_85518_/Q }
C {devices/lab_pin.sym} 57740 -26680 0 0 {name=p57144 lab=_65036_/X }
C {devices/lab_pin.sym} 57740 -26640 0 0 {name=p57145 lab=_65105_/X }
C {devices/lab_pin.sym} 57900 -26700 0 1 {name=p57146 lab=_65106_/X }
C {sky130_stdcells/a211o_4.sym} 57820 -26700 0 0 {name=X_65106_ }
C {devices/lab_pin.sym} 57740 -26570 0 0 {name=p57147 lab=_50329_/Y }
C {devices/lab_pin.sym} 57740 -26530 0 0 {name=p57148 lab=_50313_/X }
C {devices/lab_pin.sym} 57740 -26490 0 0 {name=p57149 lab=_50331_/X }
C {devices/lab_pin.sym} 57900 -26530 0 1 {name=p57150 lab=_50332_/Y }
C {sky130_stdcells/a21oi_4.sym} 57820 -26530 0 0 {name=X_50332_ }
C {devices/lab_pin.sym} 57780 -26390 0 0 {name=p57151 lab=_62203_/Y }
C {devices/lab_pin.sym} 57860 -26390 0 1 {name=p57152 lab=_62319_/A }
C {sky130_stdcells/buf_2.sym} 57820 -26390 0 0 {name=X_62318_ }
C {devices/lab_pin.sym} 57730 -26270 0 0 {name=p57153 lab=_81211_/CLK }
C {devices/lab_pin.sym} 57730 -26250 0 0 {name=p57154 lab=_80744_/Q }
C {devices/lab_pin.sym} 57910 -26270 0 1 {name=p57155 lab=_40571_/A }
C {sky130_stdcells/dfxtp_4.sym} 57820 -26260 0 0 {name=X_81152_ }
C {devices/lab_pin.sym} 57740 -26150 0 0 {name=p57156 lab=_66083_/X }
C {devices/lab_pin.sym} 57740 -26110 0 0 {name=p57157 lab=_66085_/X }
C {devices/lab_pin.sym} 57740 -26070 0 0 {name=p57158 lab=_65304_/X }
C {devices/lab_pin.sym} 57900 -26110 0 1 {name=p57159 lab=_66426_/A }
C {sky130_stdcells/a21o_4.sym} 57820 -26110 0 0 {name=X_66086_ }
C {devices/lab_pin.sym} 57740 -26000 0 0 {name=p57160 lab=_58976_/A }
C {devices/lab_pin.sym} 57740 -25960 0 0 {name=p57161 lab=_62999_/X }
C {devices/lab_pin.sym} 57740 -25920 0 0 {name=p57162 lab=_61636_/B }
C {devices/lab_pin.sym} 57740 -25880 0 0 {name=p57163 lab=_60608_/X }
C {devices/lab_pin.sym} 57900 -25940 0 1 {name=p57164 lab=_63298_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 57820 -25940 0 0 {name=X_63298_ }
C {devices/lab_pin.sym} 57760 -25800 0 0 {name=p57165 lab=_80101_/X }
C {devices/lab_pin.sym} 57760 -25760 0 0 {name=p57166 lab=_80108_/B }
C {devices/lab_pin.sym} 57880 -25780 0 1 {name=p57167 lab=_80103_/Y }
C {sky130_stdcells/xnor2_4.sym} 57820 -25780 0 0 {name=X_80103_ }
C {devices/lab_pin.sym} 57760 -25660 0 0 {name=p57168 lab=_65002_/A }
C {devices/lab_pin.sym} 57760 -25620 0 0 {name=p57169 lab=_65037_/B }
C {devices/lab_pin.sym} 57880 -25640 0 1 {name=p57170 lab=_65037_/X }
C {sky130_stdcells/and2_4.sym} 57820 -25640 0 0 {name=X_65037_ }
C {devices/lab_pin.sym} 57740 -25530 0 0 {name=p57171 lab=_85706_/Q }
C {devices/lab_pin.sym} 57740 -25490 0 0 {name=p57172 lab=_53038_/X }
C {devices/lab_pin.sym} 57740 -25450 0 0 {name=p57173 lab=_53050_/Y }
C {devices/lab_pin.sym} 57900 -25490 0 1 {name=p57174 lab=_53051_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -25490 0 0 {name=X_53051_ }
C {devices/lab_pin.sym} 57740 -25380 0 0 {name=p57175 lab=_69499_/Y }
C {devices/lab_pin.sym} 57740 -25340 0 0 {name=p57176 lab=_69732_/X }
C {devices/lab_pin.sym} 57740 -25300 0 0 {name=p57177 lab=_69870_/X }
C {devices/lab_pin.sym} 57740 -25260 0 0 {name=p57178 lab=_69913_/Y }
C {devices/lab_pin.sym} 57900 -25320 0 1 {name=p57179 lab=_69914_/X }
C {sky130_stdcells/a211o_4.sym} 57820 -25320 0 0 {name=X_69914_ }
C {devices/lab_pin.sym} 57740 -25190 0 0 {name=p57180 lab=_50261_/Y }
C {devices/lab_pin.sym} 57740 -25150 0 0 {name=p57181 lab=_50227_/X }
C {devices/lab_pin.sym} 57740 -25110 0 0 {name=p57182 lab=_50262_/Y }
C {devices/lab_pin.sym} 57900 -25150 0 1 {name=p57183 lab=_50263_/Y }
C {sky130_stdcells/a21boi_4.sym} 57820 -25150 0 0 {name=X_50263_ }
C {devices/lab_pin.sym} 57760 -25030 0 0 {name=p57184 lab=_62249_/A }
C {devices/lab_pin.sym} 57760 -24990 0 0 {name=p57185 lab=_63384_/B }
C {devices/lab_pin.sym} 57760 -24950 0 0 {name=p57186 lab=_59987_/X }
C {devices/lab_pin.sym} 57880 -24990 0 1 {name=p57187 lab=_62251_/C }
C {sky130_stdcells/nand3_4.sym} 57820 -24990 0 0 {name=X_62249_ }
C {devices/lab_pin.sym} 57730 -24850 0 0 {name=p57188 lab=_85961_/CLK }
C {devices/lab_pin.sym} 57730 -24830 0 0 {name=p57189 lab=_85960_/D }
C {devices/lab_pin.sym} 57910 -24850 0 1 {name=p57190 lab=_85960_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -24840 0 0 {name=X_85960_ }
C {devices/lab_pin.sym} 57730 -24710 0 0 {name=p57191 lab=_81117_/CLK }
C {devices/lab_pin.sym} 57730 -24690 0 0 {name=p57192 lab=_75650_/A }
C {devices/lab_pin.sym} 57910 -24710 0 1 {name=p57193 lab=_81083_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -24700 0 0 {name=X_81083_ }
C {devices/lab_pin.sym} 57740 -24590 0 0 {name=p57194 lab=_66094_/B }
C {devices/lab_pin.sym} 57740 -24550 0 0 {name=p57195 lab=_51994_/X }
C {devices/lab_pin.sym} 57740 -24510 0 0 {name=p57196 lab=_52001_/Y }
C {devices/lab_pin.sym} 57900 -24550 0 1 {name=p57197 lab=_52002_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -24550 0 0 {name=X_52002_ }
C {devices/lab_pin.sym} 57730 -24410 0 0 {name=p57198 lab=_84555_/CLK }
C {devices/lab_pin.sym} 57730 -24390 0 0 {name=p57199 lab=_58195_/Y }
C {devices/lab_pin.sym} 57910 -24410 0 1 {name=p57200 lab=_62124_/B }
C {sky130_stdcells/dfxtp_4.sym} 57820 -24400 0 0 {name=X_84911_ }
C {devices/lab_pin.sym} 57740 -24290 0 0 {name=p57201 lab=_80021_/X }
C {devices/lab_pin.sym} 57740 -24250 0 0 {name=p57202 lab=_80032_/X }
C {devices/lab_pin.sym} 57740 -24210 0 0 {name=p57203 lab=_80033_/X }
C {devices/lab_pin.sym} 57900 -24250 0 1 {name=p57204 lab=_80034_/Y }
C {sky130_stdcells/a21oi_4.sym} 57820 -24250 0 0 {name=X_80034_ }
C {devices/lab_pin.sym} 57740 -24130 0 0 {name=p57205 lab=_69413_/X }
C {devices/lab_pin.sym} 57740 -24090 0 0 {name=p57206 lab=_69416_/X }
C {devices/lab_pin.sym} 57740 -24050 0 0 {name=p57207 lab=_69816_/X }
C {devices/lab_pin.sym} 57900 -24090 0 1 {name=p57208 lab=_69845_/Y }
C {sky130_stdcells/a21oi_4.sym} 57820 -24090 0 0 {name=X_69845_ }
C {devices/lab_pin.sym} 57740 -23970 0 0 {name=p57209 lab=_50189_/Y }
C {devices/lab_pin.sym} 57740 -23930 0 0 {name=p57210 lab=_50191_/X }
C {devices/lab_pin.sym} 57740 -23890 0 0 {name=p57211 lab=_50193_/X }
C {devices/lab_pin.sym} 57900 -23930 0 1 {name=p57212 lab=_86246_/D }
C {sky130_stdcells/a21oi_4.sym} 57820 -23930 0 0 {name=X_50194_ }
C {devices/lab_pin.sym} 57730 -23790 0 0 {name=p57213 lab=_86490_/CLK }
C {devices/lab_pin.sym} 57730 -23770 0 0 {name=p57214 lab=_85891_/D }
C {devices/lab_pin.sym} 57910 -23790 0 1 {name=p57215 lab=_66334_/B }
C {sky130_stdcells/dfxtp_4.sym} 57820 -23780 0 0 {name=X_85891_ }
C {devices/lab_pin.sym} 57780 -23650 0 0 {name=p57216 lab=_85555_/CLK }
C {devices/lab_pin.sym} 57860 -23650 0 1 {name=p57217 lab=_83300_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 57820 -23650 0 0 {name=Xclkbuf_opt_21_CLK }
C {devices/lab_pin.sym} 57780 -23530 0 0 {name=p57218 lab=_56816_/A }
C {devices/lab_pin.sym} 57860 -23530 0 1 {name=p57219 lab=_56810_/X }
C {sky130_stdcells/buf_2.sym} 57820 -23530 0 0 {name=X_56810_ }
C {devices/lab_pin.sym} 57730 -23410 0 0 {name=p57220 lab=_87625_/CLK }
C {devices/lab_pin.sym} 57730 -23390 0 0 {name=p57221 lab=_87630_/D }
C {devices/lab_pin.sym} 57910 -23410 0 1 {name=p57222 lab=_66698_/B }
C {sky130_stdcells/dfxtp_4.sym} 57820 -23400 0 0 {name=X_87630_ }
C {devices/lab_pin.sym} 57730 -23270 0 0 {name=p57223 lab=_84299_/CLK }
C {devices/lab_pin.sym} 57730 -23250 0 0 {name=p57224 lab=_58466_/Y }
C {devices/lab_pin.sym} 57910 -23270 0 1 {name=p57225 lab=_84842_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -23260 0 0 {name=X_84842_ }
C {devices/lab_pin.sym} 57780 -23130 0 0 {name=p57226 lab=_64621_/A }
C {devices/lab_pin.sym} 57860 -23130 0 1 {name=p57227 lab=_57790_/X }
C {sky130_stdcells/buf_2.sym} 57820 -23130 0 0 {name=X_57790_ }
C {devices/lab_pin.sym} 57780 -23010 0 0 {name=p57228 lab=_87811_/Q }
C {devices/lab_pin.sym} 57860 -23010 0 1 {name=p57229 lab=_69776_/Y }
C {sky130_stdcells/inv_2.sym} 57820 -23010 0 0 {name=X_69776_ }
C {devices/lab_pin.sym} 57780 -22890 0 0 {name=p57230 lab=_66868_/A }
C {devices/lab_pin.sym} 57860 -22890 0 1 {name=p57231 lab=_66988_/X }
C {sky130_stdcells/buf_2.sym} 57820 -22890 0 0 {name=X_66988_ }
C {devices/lab_pin.sym} 57740 -22810 0 0 {name=p57232 lab=_56726_/X }
C {devices/lab_pin.sym} 57740 -22770 0 0 {name=p57233 lab=_56738_/X }
C {devices/lab_pin.sym} 57740 -22730 0 0 {name=p57234 lab=_56739_/X }
C {devices/lab_pin.sym} 57740 -22690 0 0 {name=p57235 lab=_56740_/X }
C {devices/lab_pin.sym} 57740 -22660 0 0 {name=p57236 lab=_45957_/A }
C {devices/lab_pin.sym} 57900 -22730 0 1 {name=p57237 lab=_56741_/Y }
C {sky130_stdcells/a41oi_4.sym} 57820 -22730 0 0 {name=X_56741_ }
C {devices/lab_pin.sym} 57780 -22570 0 0 {name=p57238 lab=_68727_/A }
C {devices/lab_pin.sym} 57860 -22570 0 1 {name=p57239 lab=_68727_/Y }
C {sky130_stdcells/inv_2.sym} 57820 -22570 0 0 {name=X_68727_ }
C {devices/lab_pin.sym} 57730 -22450 0 0 {name=p57240 lab=_88326_/CLK }
C {devices/lab_pin.sym} 57730 -22430 0 0 {name=p57241 lab=_43140_/Y }
C {devices/lab_pin.sym} 57910 -22450 0 1 {name=p57242 lab=_73036_/A }
C {sky130_stdcells/dfxtp_4.sym} 57820 -22440 0 0 {name=X_87561_ }
C {devices/lab_pin.sym} 57760 -22320 0 0 {name=p57243 lab=_53949_/A }
C {devices/lab_pin.sym} 57760 -22280 0 0 {name=p57244 lab=_53953_/B }
C {devices/lab_pin.sym} 57880 -22300 0 1 {name=p57245 lab=_53953_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -22300 0 0 {name=X_53953_ }
C {devices/lab_pin.sym} 57760 -22180 0 0 {name=p57246 lab=_65896_/A }
C {devices/lab_pin.sym} 57760 -22140 0 0 {name=p57247 lab=_65939_/B }
C {devices/lab_pin.sym} 57880 -22160 0 1 {name=p57248 lab=_65939_/X }
C {sky130_stdcells/and2_4.sym} 57820 -22160 0 0 {name=X_65939_ }
C {devices/lab_pin.sym} 57730 -22030 0 0 {name=p57249 lab=_86686_/CLK }
C {devices/lab_pin.sym} 57730 -22010 0 0 {name=p57250 lab=_84773_/D }
C {devices/lab_pin.sym} 57910 -22030 0 1 {name=p57251 lab=_84773_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -22020 0 0 {name=X_84773_ }
C {devices/lab_pin.sym} 57730 -21890 0 0 {name=p57252 lab=_81985_/CLK }
C {devices/lab_pin.sym} 57730 -21870 0 0 {name=p57253 lab=_81985_/D }
C {devices/lab_pin.sym} 57910 -21890 0 1 {name=p57254 lab=_81985_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -21880 0 0 {name=X_81985_ }
C {devices/lab_pin.sym} 57730 -21750 0 0 {name=p57255 lab=_86498_/CLK }
C {devices/lab_pin.sym} 57730 -21730 0 0 {name=p57256 lab=_86512_/D }
C {devices/lab_pin.sym} 57910 -21750 0 1 {name=p57257 lab=_86512_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -21740 0 0 {name=X_86512_ }
C {devices/lab_pin.sym} 57780 -21610 0 0 {name=p57258 lab=_52903_/X }
C {devices/lab_pin.sym} 57860 -21610 0 1 {name=p57259 lab=_52910_/A }
C {sky130_stdcells/buf_2.sym} 57820 -21610 0 0 {name=X_52904_ }
C {devices/lab_pin.sym} 57760 -21500 0 0 {name=p57260 lab=_59460_/A }
C {devices/lab_pin.sym} 57760 -21460 0 0 {name=p57261 lab=_59444_/X }
C {devices/lab_pin.sym} 57880 -21480 0 1 {name=p57262 lab=_59460_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -21480 0 0 {name=X_59460_ }
C {devices/lab_pin.sym} 57730 -21350 0 0 {name=p57263 lab=_85375_/CLK }
C {devices/lab_pin.sym} 57730 -21330 0 0 {name=p57264 lab=_70687_/X }
C {devices/lab_pin.sym} 57910 -21350 0 1 {name=p57265 lab=_47497_/A }
C {sky130_stdcells/dfxtp_4.sym} 57820 -21340 0 0 {name=X_83724_ }
C {devices/lab_pin.sym} 57780 -21210 0 0 {name=p57266 lab=_83329_/Q }
C {devices/lab_pin.sym} 57860 -21210 0 1 {name=p57267 lab=_56672_/Y }
C {sky130_stdcells/inv_2.sym} 57820 -21210 0 0 {name=X_56672_ }
C {devices/lab_pin.sym} 57760 -21100 0 0 {name=p57268 lab=_68735_/A }
C {devices/lab_pin.sym} 57760 -21060 0 0 {name=p57269 lab=_68658_/B }
C {devices/lab_pin.sym} 57880 -21080 0 1 {name=p57270 lab=_68658_/X }
C {sky130_stdcells/and2_4.sym} 57820 -21080 0 0 {name=X_68658_ }
C {devices/lab_pin.sym} 57730 -20950 0 0 {name=p57271 lab=_80962_/CLK }
C {devices/lab_pin.sym} 57730 -20930 0 0 {name=p57272 lab=_75151_/B }
C {devices/lab_pin.sym} 57910 -20950 0 1 {name=p57273 lab=_80936_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -20940 0 0 {name=X_80936_ }
C {devices/lab_pin.sym} 57730 -20810 0 0 {name=p57274 lab=_87758_/CLK }
C {devices/lab_pin.sym} 57730 -20790 0 0 {name=p57275 lab=_43298_/Y }
C {devices/lab_pin.sym} 57910 -20810 0 1 {name=p57276 lab=_87492_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -20800 0 0 {name=X_87492_ }
C {devices/lab_pin.sym} 57760 -20690 0 0 {name=p57277 lab=_52365_/A }
C {devices/lab_pin.sym} 57760 -20650 0 0 {name=p57278 lab=_53875_/B }
C {devices/lab_pin.sym} 57760 -20610 0 0 {name=p57279 lab=_53888_/C }
C {devices/lab_pin.sym} 57880 -20650 0 1 {name=p57280 lab=_53884_/X }
C {sky130_stdcells/and3_4.sym} 57820 -20650 0 0 {name=X_53884_ }
C {devices/lab_pin.sym} 57780 -20510 0 0 {name=p57281 lab=_84855_/Q }
C {devices/lab_pin.sym} 57860 -20510 0 1 {name=p57282 lab=_58412_/A }
C {sky130_stdcells/inv_2.sym} 57820 -20510 0 0 {name=X_58411_ }
C {devices/lab_pin.sym} 57740 -20420 0 0 {name=p57283 lab=_83007_/Q }
C {devices/lab_pin.sym} 57740 -20380 0 0 {name=p57284 lab=_55689_/A }
C {devices/lab_pin.sym} 57740 -20340 0 0 {name=p57285 lab=_44102_/A }
C {devices/lab_pin.sym} 57740 -20300 0 0 {name=p57286 lab=_55622_/X }
C {devices/lab_pin.sym} 57900 -20360 0 1 {name=p57287 lab=_55624_/B }
C {sky130_stdcells/a211o_4.sym} 57820 -20360 0 0 {name=X_55623_ }
C {devices/lab_pin.sym} 57740 -20240 0 0 {name=p57288 lab=_87156_/Q }
C {devices/lab_pin.sym} 57740 -20200 0 0 {name=p57289 lab=_67585_/X }
C {devices/lab_pin.sym} 57740 -20160 0 0 {name=p57290 lab=_67516_/X }
C {devices/lab_pin.sym} 57740 -20120 0 0 {name=p57291 lab=_67608_/X }
C {devices/lab_pin.sym} 57900 -20180 0 1 {name=p57292 lab=_67609_/X }
C {sky130_stdcells/a211o_4.sym} 57820 -20180 0 0 {name=X_67609_ }
C {devices/lab_pin.sym} 57730 -20030 0 0 {name=p57293 lab=_85538_/CLK }
C {devices/lab_pin.sym} 57730 -20010 0 0 {name=p57294 lab=_86443_/D }
C {devices/lab_pin.sym} 57910 -20030 0 1 {name=p57295 lab=_86443_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -20020 0 0 {name=X_86443_ }
C {devices/lab_pin.sym} 57760 -19920 0 0 {name=p57296 lab=_52818_/A }
C {devices/lab_pin.sym} 57760 -19880 0 0 {name=p57297 lab=_52831_/B }
C {devices/lab_pin.sym} 57760 -19840 0 0 {name=p57298 lab=_52818_/C }
C {devices/lab_pin.sym} 57760 -19800 0 0 {name=p57299 lab=_52835_/D }
C {devices/lab_pin.sym} 57880 -19860 0 1 {name=p57300 lab=_52835_/X }
C {sky130_stdcells/and4_4.sym} 57820 -19860 0 0 {name=X_52835_ }
C {devices/lab_pin.sym} 57730 -19710 0 0 {name=p57301 lab=_85536_/CLK }
C {devices/lab_pin.sym} 57730 -19690 0 0 {name=p57302 lab=_70946_/Y }
C {devices/lab_pin.sym} 57910 -19710 0 1 {name=p57303 lab=_46270_/A }
C {sky130_stdcells/dfxtp_4.sym} 57820 -19700 0 0 {name=X_83655_ }
C {devices/lab_pin.sym} 57780 -19570 0 0 {name=p57304 lab=_59390_/Y }
C {devices/lab_pin.sym} 57860 -19570 0 1 {name=p57305 lab=_59392_/A }
C {sky130_stdcells/buf_2.sym} 57820 -19570 0 0 {name=X_59391_ }
C {devices/lab_pin.sym} 57730 -19450 0 0 {name=p57306 lab=_80818_/CLK }
C {devices/lab_pin.sym} 57730 -19430 0 0 {name=p57307 lab=_75587_/B }
C {devices/lab_pin.sym} 57910 -19450 0 1 {name=p57308 lab=_80835_/D }
C {sky130_stdcells/dfxtp_4.sym} 57820 -19440 0 0 {name=X_80867_ }
C {devices/lab_pin.sym} 57760 -19320 0 0 {name=p57309 lab=_68587_/X }
C {devices/lab_pin.sym} 57760 -19280 0 0 {name=p57310 lab=_68588_/Y }
C {devices/lab_pin.sym} 57880 -19300 0 1 {name=p57311 lab=_68589_/Y }
C {sky130_stdcells/nor2_4.sym} 57820 -19300 0 0 {name=X_68589_ }
C {devices/lab_pin.sym} 57760 -19200 0 0 {name=p57312 lab=_70724_/A }
C {devices/lab_pin.sym} 57760 -19160 0 0 {name=p57313 lab=_70620_/B }
C {devices/lab_pin.sym} 57760 -19120 0 0 {name=p57314 lab=_70620_/C }
C {devices/lab_pin.sym} 57760 -19080 0 0 {name=p57315 lab=_70620_/D }
C {devices/lab_pin.sym} 57880 -19140 0 1 {name=p57316 lab=_70620_/Y }
C {sky130_stdcells/nand4_4.sym} 57820 -19140 0 0 {name=X_70620_ }
C {devices/lab_pin.sym} 57780 -18990 0 0 {name=p57317 lab=_58342_/A }
C {devices/lab_pin.sym} 57860 -18990 0 1 {name=p57318 lab=_58342_/Y }
C {sky130_stdcells/inv_2.sym} 57820 -18990 0 0 {name=X_58342_ }
C {devices/lab_pin.sym} 57730 -18870 0 0 {name=p57319 lab=_82575_/CLK }
C {devices/lab_pin.sym} 57730 -18850 0 0 {name=p57320 lab=_78920_/B }
C {devices/lab_pin.sym} 57910 -18870 0 1 {name=p57321 lab=_82606_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -18860 0 0 {name=X_82606_ }
C {devices/lab_pin.sym} 57740 -18760 0 0 {name=p57322 lab=_45501_/A }
C {devices/lab_pin.sym} 57740 -18720 0 0 {name=p57323 lab=_55511_/X }
C {devices/lab_pin.sym} 57740 -18680 0 0 {name=p57324 lab=_55506_/X }
C {devices/lab_pin.sym} 57740 -18640 0 0 {name=p57325 lab=_55553_/Y }
C {devices/lab_pin.sym} 57900 -18700 0 1 {name=p57326 lab=_55554_/X }
C {sky130_stdcells/a211o_4.sym} 57820 -18700 0 0 {name=X_55554_ }
C {devices/lab_pin.sym} 57730 -18550 0 0 {name=p57327 lab=_83663_/CLK }
C {devices/lab_pin.sym} 57730 -18530 0 0 {name=p57328 lab=_86374_/D }
C {devices/lab_pin.sym} 57910 -18550 0 1 {name=p57329 lab=_86374_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -18540 0 0 {name=X_86374_ }
C {devices/lab_pin.sym} 57740 -18430 0 0 {name=p57330 lab=_40773_/X }
C {devices/lab_pin.sym} 57740 -18390 0 0 {name=p57331 lab=_82302_/Q }
C {devices/lab_pin.sym} 57740 -18350 0 0 {name=p57332 lab=_40779_/X }
C {devices/lab_pin.sym} 57900 -18390 0 1 {name=p57333 lab=_40780_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -18390 0 0 {name=X_40780_ }
C {devices/lab_pin.sym} 57780 -18250 0 0 {name=p57334 lab=_52630_/A }
C {devices/lab_pin.sym} 57860 -18250 0 1 {name=p57335 lab=_52767_/A }
C {sky130_stdcells/buf_2.sym} 57820 -18250 0 0 {name=X_52766_ }
C {devices/lab_pin.sym} 57730 -18130 0 0 {name=p57336 lab=_85593_/CLK }
C {devices/lab_pin.sym} 57730 -18110 0 0 {name=p57337 lab=_83586_/D }
C {devices/lab_pin.sym} 57910 -18130 0 1 {name=p57338 lab=_83586_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -18120 0 0 {name=X_83586_ }
C {devices/lab_pin.sym} 57730 -17990 0 0 {name=p57339 lab=_80991_/CLK }
C {devices/lab_pin.sym} 57730 -17970 0 0 {name=p57340 lab=_80798_/D }
C {devices/lab_pin.sym} 57910 -17990 0 1 {name=p57341 lab=_75514_/A }
C {sky130_stdcells/dfxtp_4.sym} 57820 -17980 0 0 {name=X_80798_ }
C {devices/lab_pin.sym} 57730 -17850 0 0 {name=p57342 lab=_88108_/CLK }
C {devices/lab_pin.sym} 57730 -17830 0 0 {name=p57343 lab=_41884_/Y }
C {devices/lab_pin.sym} 57910 -17850 0 1 {name=p57344 lab=_73595_/A }
C {sky130_stdcells/dfxtp_4.sym} 57820 -17840 0 0 {name=X_88113_ }
C {devices/lab_pin.sym} 57760 -17720 0 0 {name=p57345 lab=_54486_/X }
C {devices/lab_pin.sym} 57760 -17680 0 0 {name=p57346 lab=_53332_/B }
C {devices/lab_pin.sym} 57880 -17700 0 1 {name=p57347 lab=_54505_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -17700 0 0 {name=X_54505_ }
C {devices/lab_pin.sym} 57730 -17570 0 0 {name=p57348 lab=_85354_/CLK }
C {devices/lab_pin.sym} 57730 -17550 0 0 {name=p57349 lab=_85325_/D }
C {devices/lab_pin.sym} 57910 -17570 0 1 {name=p57350 lab=_85325_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -17560 0 0 {name=X_85325_ }
C {devices/lab_pin.sym} 57760 -17440 0 0 {name=p57351 lab=_51717_/A }
C {devices/lab_pin.sym} 57760 -17400 0 0 {name=p57352 lab=_53240_/B }
C {devices/lab_pin.sym} 57880 -17420 0 1 {name=p57353 lab=_51717_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -17420 0 0 {name=X_51717_ }
C {devices/lab_pin.sym} 57740 -17310 0 0 {name=p57354 lab=_70533_/X }
C {devices/lab_pin.sym} 57740 -17270 0 0 {name=p57355 lab=_83751_/Q }
C {devices/lab_pin.sym} 57740 -17230 0 0 {name=p57356 lab=_70550_/Y }
C {devices/lab_pin.sym} 57900 -17270 0 1 {name=p57357 lab=_83751_/D }
C {sky130_stdcells/a21o_4.sym} 57820 -17270 0 0 {name=X_70551_ }
C {devices/lab_pin.sym} 57780 -17130 0 0 {name=p57358 lab=_58273_/A }
C {devices/lab_pin.sym} 57860 -17130 0 1 {name=p57359 lab=_58280_/B }
C {sky130_stdcells/buf_2.sym} 57820 -17130 0 0 {name=X_58273_ }
C {devices/lab_pin.sym} 57730 -17010 0 0 {name=p57360 lab=_82536_/CLK }
C {devices/lab_pin.sym} 57730 -16990 0 0 {name=p57361 lab=_82537_/D }
C {devices/lab_pin.sym} 57910 -17010 0 1 {name=p57362 lab=_82537_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -17000 0 0 {name=X_82537_ }
C {devices/lab_pin.sym} 57740 -16900 0 0 {name=p57363 lab=_85042_/Q }
C {devices/lab_pin.sym} 57740 -16860 0 0 {name=p57364 lab=_55468_/X }
C {devices/lab_pin.sym} 57740 -16820 0 0 {name=p57365 lab=_55458_/X }
C {devices/lab_pin.sym} 57740 -16780 0 0 {name=p57366 lab=_55484_/Y }
C {devices/lab_pin.sym} 57900 -16840 0 1 {name=p57367 lab=_55485_/X }
C {sky130_stdcells/a211o_4.sym} 57820 -16840 0 0 {name=X_55485_ }
C {devices/lab_pin.sym} 57740 -16710 0 0 {name=p57368 lab=_85771_/Q }
C {devices/lab_pin.sym} 57740 -16670 0 0 {name=p57369 lab=_52684_/X }
C {devices/lab_pin.sym} 57740 -16630 0 0 {name=p57370 lab=_52696_/Y }
C {devices/lab_pin.sym} 57900 -16670 0 1 {name=p57371 lab=_52697_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -16670 0 0 {name=X_52697_ }
C {devices/lab_pin.sym} 57740 -16560 0 0 {name=p57372 lab=_57123_/Y }
C {devices/lab_pin.sym} 57740 -16520 0 0 {name=p57373 lab=_57220_/Y }
C {devices/lab_pin.sym} 57740 -16480 0 0 {name=p57374 lab=_57221_/X }
C {devices/lab_pin.sym} 57740 -16440 0 0 {name=p57375 lab=_57223_/X }
C {devices/lab_pin.sym} 57900 -16500 0 1 {name=p57376 lab=_85060_/D }
C {sky130_stdcells/a211o_4.sym} 57820 -16500 0 0 {name=X_57224_ }
C {devices/lab_pin.sym} 57730 -16350 0 0 {name=p57377 lab=_88044_/CLK }
C {devices/lab_pin.sym} 57730 -16330 0 0 {name=p57378 lab=_88044_/D }
C {devices/lab_pin.sym} 57910 -16350 0 1 {name=p57379 lab=_88044_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -16340 0 0 {name=X_88044_ }
C {devices/lab_pin.sym} 57780 -16210 0 0 {name=p57380 lab=_42449_/Y }
C {devices/lab_pin.sym} 57860 -16210 0 1 {name=p57381 lab=_42579_/A }
C {sky130_stdcells/inv_2.sym} 57820 -16210 0 0 {name=X_42450_ }
C {devices/lab_pin.sym} 57740 -16110 0 0 {name=p57382 lab=_54434_/Y }
C {devices/lab_pin.sym} 57740 -16070 0 0 {name=p57383 lab=_54422_/X }
C {devices/lab_pin.sym} 57740 -16030 0 0 {name=p57384 lab=_54435_/X }
C {devices/lab_pin.sym} 57900 -16070 0 1 {name=p57385 lab=_85443_/D }
C {sky130_stdcells/a21oi_4.sym} 57820 -16070 0 0 {name=X_54436_ }
C {devices/lab_pin.sym} 57760 -15950 0 0 {name=p57386 lab=_73268_/X }
C {devices/lab_pin.sym} 57760 -15910 0 0 {name=p57387 lab=_73270_/B }
C {devices/lab_pin.sym} 57760 -15870 0 0 {name=p57388 lab=_73270_/C }
C {devices/lab_pin.sym} 57880 -15910 0 1 {name=p57389 lab=_73270_/Y }
C {sky130_stdcells/nand3_4.sym} 57820 -15910 0 0 {name=X_73270_ }
C {devices/lab_pin.sym} 57730 -15770 0 0 {name=p57390 lab=_85190_/CLK }
C {devices/lab_pin.sym} 57730 -15750 0 0 {name=p57391 lab=_85256_/D }
C {devices/lab_pin.sym} 57910 -15770 0 1 {name=p57392 lab=_85256_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -15760 0 0 {name=X_85256_ }
C {devices/lab_pin.sym} 57780 -15630 0 0 {name=p57393 lab=_50222_/X }
C {devices/lab_pin.sym} 57860 -15630 0 1 {name=p57394 lab=_51671_/A }
C {sky130_stdcells/buf_2.sym} 57820 -15630 0 0 {name=X_51648_ }
C {devices/lab_pin.sym} 57780 -15510 0 0 {name=p57395 lab=DATA_TO_HASH[2] }
C {devices/lab_pin.sym} 57860 -15510 0 1 {name=p57396 lab=_71435_/C }
C {sky130_stdcells/buf_2.sym} 57820 -15510 0 0 {name=X_70482_ }
C {devices/lab_pin.sym} 57730 -15390 0 0 {name=p57397 lab=_82942_/CLK }
C {devices/lab_pin.sym} 57730 -15370 0 0 {name=p57398 lab=_78341_/X }
C {devices/lab_pin.sym} 57910 -15390 0 1 {name=p57399 lab=_78262_/B }
C {sky130_stdcells/dfxtp_4.sym} 57820 -15380 0 0 {name=X_82468_ }
C {devices/lab_pin.sym} 57760 -15260 0 0 {name=p57400 lab=_41743_/B }
C {devices/lab_pin.sym} 57760 -15220 0 0 {name=p57401 lab=_41379_/X }
C {devices/lab_pin.sym} 57880 -15240 0 1 {name=p57402 lab=_41401_/X }
C {sky130_stdcells/or2_4.sym} 57820 -15240 0 0 {name=X_41401_ }
C {devices/lab_pin.sym} 57760 -15120 0 0 {name=p57403 lab=_86617_/Q }
C {devices/lab_pin.sym} 57760 -15080 0 0 {name=p57404 lab=_72162_/B }
C {devices/lab_pin.sym} 57880 -15100 0 1 {name=p57405 lab=_72221_/Y }
C {sky130_stdcells/nor2_4.sym} 57820 -15100 0 0 {name=X_72221_ }
C {devices/lab_pin.sym} 57730 -14970 0 0 {name=p57406 lab=_84220_/CLK }
C {devices/lab_pin.sym} 57730 -14950 0 0 {name=p57407 lab=_84207_/D }
C {devices/lab_pin.sym} 57910 -14970 0 1 {name=p57408 lab=_65294_/C }
C {sky130_stdcells/dfxtp_4.sym} 57820 -14960 0 0 {name=X_84207_ }
C {devices/lab_pin.sym} 57760 -14860 0 0 {name=p57409 lab=_57141_/X }
C {devices/lab_pin.sym} 57760 -14820 0 0 {name=p57410 lab=_56739_/X }
C {devices/lab_pin.sym} 57760 -14780 0 0 {name=p57411 lab=_56800_/X }
C {devices/lab_pin.sym} 57760 -14740 0 0 {name=p57412 lab=_57155_/D }
C {devices/lab_pin.sym} 57880 -14800 0 1 {name=p57413 lab=_57158_/A }
C {sky130_stdcells/and4_4.sym} 57820 -14800 0 0 {name=X_57155_ }
C {devices/lab_pin.sym} 57730 -14650 0 0 {name=p57414 lab=_84049_/CLK }
C {devices/lab_pin.sym} 57730 -14630 0 0 {name=p57415 lab=_81451_/Q }
C {devices/lab_pin.sym} 57910 -14650 0 1 {name=p57416 lab=_75991_/B }
C {sky130_stdcells/dfxtp_4.sym} 57820 -14640 0 0 {name=X_81419_ }
C {devices/lab_pin.sym} 57740 -14550 0 0 {name=p57417 lab=_42378_/X }
C {devices/lab_pin.sym} 57740 -14510 0 0 {name=p57418 lab=_42369_/X }
C {devices/lab_pin.sym} 57740 -14470 0 0 {name=p57419 lab=_41791_/X }
C {devices/lab_pin.sym} 57740 -14430 0 0 {name=p57420 lab=_87892_/Q }
C {devices/lab_pin.sym} 57740 -14390 0 0 {name=p57421 lab=_42370_/X }
C {devices/lab_pin.sym} 57900 -14470 0 1 {name=p57422 lab=_42382_/A }
C {sky130_stdcells/o32ai_4.sym} 57820 -14470 0 0 {name=X_42381_ }
C {devices/lab_pin.sym} 57760 -14340 0 0 {name=p57423 lab=_54362_/A }
C {devices/lab_pin.sym} 57760 -14300 0 0 {name=p57424 lab=_54362_/B }
C {devices/lab_pin.sym} 57760 -14260 0 0 {name=p57425 lab=_54362_/C }
C {devices/lab_pin.sym} 57760 -14220 0 0 {name=p57426 lab=_46790_/Y }
C {devices/lab_pin.sym} 57880 -14280 0 1 {name=p57427 lab=_54367_/X }
C {sky130_stdcells/and4_4.sym} 57820 -14280 0 0 {name=X_54367_ }
C {devices/lab_pin.sym} 57730 -14130 0 0 {name=p57428 lab=_85186_/CLK }
C {devices/lab_pin.sym} 57730 -14110 0 0 {name=p57429 lab=_56455_/Y }
C {devices/lab_pin.sym} 57910 -14130 0 1 {name=p57430 lab=_56454_/C }
C {sky130_stdcells/dfxtp_4.sym} 57820 -14120 0 0 {name=X_85187_ }
C {devices/lab_pin.sym} 57780 -13990 0 0 {name=p57431 lab=_51552_/A }
C {devices/lab_pin.sym} 57860 -13990 0 1 {name=p57432 lab=_51603_/C }
C {sky130_stdcells/buf_2.sym} 57820 -13990 0 0 {name=X_51579_ }
C {devices/lab_pin.sym} 57730 -13870 0 0 {name=p57433 lab=_82965_/CLK }
C {devices/lab_pin.sym} 57730 -13850 0 0 {name=p57434 lab=_82207_/Q }
C {devices/lab_pin.sym} 57910 -13870 0 1 {name=p57435 lab=_82399_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -13860 0 0 {name=X_82399_ }
C {devices/lab_pin.sym} 57740 -13750 0 0 {name=p57436 lab=_44091_/Y }
C {devices/lab_pin.sym} 57740 -13710 0 0 {name=p57437 lab=_44102_/X }
C {devices/lab_pin.sym} 57740 -13670 0 0 {name=p57438 lab=_44119_/Y }
C {devices/lab_pin.sym} 57900 -13710 0 1 {name=p57439 lab=_44120_/Y }
C {sky130_stdcells/a21oi_4.sym} 57820 -13710 0 0 {name=X_44120_ }
C {devices/lab_pin.sym} 57740 -13590 0 0 {name=p57440 lab=_56082_/X }
C {devices/lab_pin.sym} 57740 -13550 0 0 {name=p57441 lab=_56103_/X }
C {devices/lab_pin.sym} 57740 -13510 0 0 {name=p57442 lab=_56105_/Y }
C {devices/lab_pin.sym} 57900 -13550 0 1 {name=p57443 lab=_56106_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -13550 0 0 {name=X_56106_ }
C {devices/lab_pin.sym} 57780 -13410 0 0 {name=p57444 lab=_41331_/X }
C {devices/lab_pin.sym} 57860 -13410 0 1 {name=p57445 lab=_41332_/X }
C {sky130_stdcells/buf_2.sym} 57820 -13410 0 0 {name=X_41332_ }
C {devices/lab_pin.sym} 57760 -13300 0 0 {name=p57446 lab=_53298_/A }
C {devices/lab_pin.sym} 57760 -13260 0 0 {name=p57447 lab=_47016_/A }
C {devices/lab_pin.sym} 57880 -13280 0 1 {name=p57448 lab=_53318_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -13280 0 0 {name=X_53318_ }
C {devices/lab_pin.sym} 57780 -13150 0 0 {name=p57449 lab=_72358_/A }
C {devices/lab_pin.sym} 57860 -13150 0 1 {name=p57450 lab=_72152_/X }
C {sky130_stdcells/buf_2.sym} 57820 -13150 0 0 {name=X_72152_ }
C {devices/lab_pin.sym} 57730 -13030 0 0 {name=p57451 lab=_82177_/CLK }
C {devices/lab_pin.sym} 57730 -13010 0 0 {name=p57452 lab=_84138_/D }
C {devices/lab_pin.sym} 57910 -13030 0 1 {name=p57453 lab=_84138_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -13020 0 0 {name=X_84138_ }
C {devices/lab_pin.sym} 57780 -12890 0 0 {name=p57454 lab=_57126_/A }
C {devices/lab_pin.sym} 57860 -12890 0 1 {name=p57455 lab=_57086_/X }
C {sky130_stdcells/buf_2.sym} 57820 -12890 0 0 {name=X_57086_ }
C {devices/lab_pin.sym} 57760 -12800 0 0 {name=p57456 lab=_54312_/A }
C {devices/lab_pin.sym} 57760 -12760 0 0 {name=p57457 lab=_54298_/B }
C {devices/lab_pin.sym} 57760 -12720 0 0 {name=p57458 lab=_54312_/C }
C {devices/lab_pin.sym} 57760 -12680 0 0 {name=p57459 lab=_54298_/D }
C {devices/lab_pin.sym} 57880 -12740 0 1 {name=p57460 lab=_54298_/X }
C {sky130_stdcells/and4_4.sym} 57820 -12740 0 0 {name=X_54298_ }
C {devices/lab_pin.sym} 57740 -12610 0 0 {name=p57461 lab=_50144_/B }
C {devices/lab_pin.sym} 57740 -12570 0 0 {name=p57462 lab=_71095_/X }
C {devices/lab_pin.sym} 57740 -12530 0 0 {name=p57463 lab=_71102_/Y }
C {devices/lab_pin.sym} 57900 -12570 0 1 {name=p57464 lab=_83607_/D }
C {sky130_stdcells/o21ai_4.sym} 57820 -12570 0 0 {name=X_71103_ }
C {devices/lab_pin.sym} 57780 -12430 0 0 {name=p57465 lab=_44051_/A }
C {devices/lab_pin.sym} 57860 -12430 0 1 {name=p57466 lab=_44052_/A }
C {sky130_stdcells/buf_2.sym} 57820 -12430 0 0 {name=X_44051_ }
C {devices/lab_pin.sym} 57760 -12330 0 0 {name=p57467 lab=_56023_/A }
C {devices/lab_pin.sym} 57760 -12290 0 0 {name=p57468 lab=_56052_/B }
C {devices/lab_pin.sym} 57760 -12250 0 0 {name=p57469 lab=_55934_/B }
C {devices/lab_pin.sym} 57880 -12290 0 1 {name=p57470 lab=_56037_/Y }
C {sky130_stdcells/nand3_4.sym} 57820 -12290 0 0 {name=X_56037_ }
C {devices/lab_pin.sym} 57740 -12170 0 0 {name=p57471 lab=_41261_/X }
C {devices/lab_pin.sym} 57740 -12130 0 0 {name=p57472 lab=_81702_/Q }
C {devices/lab_pin.sym} 57740 -12090 0 0 {name=p57473 lab=_41262_/X }
C {devices/lab_pin.sym} 57900 -12130 0 1 {name=p57474 lab=_41264_/A }
C {sky130_stdcells/o21ai_4.sym} 57820 -12130 0 0 {name=X_41263_ }
C {devices/lab_pin.sym} 57760 -12020 0 0 {name=p57475 lab=_53243_/X }
C {devices/lab_pin.sym} 57760 -11980 0 0 {name=p57476 lab=_53244_/B }
C {devices/lab_pin.sym} 57760 -11940 0 0 {name=p57477 lab=_53266_/C }
C {devices/lab_pin.sym} 57760 -11900 0 0 {name=p57478 lab=_53249_/D }
C {devices/lab_pin.sym} 57880 -11960 0 1 {name=p57479 lab=_53249_/X }
C {sky130_stdcells/and4_4.sym} 57820 -11960 0 0 {name=X_53249_ }
C {devices/lab_pin.sym} 57780 -11810 0 0 {name=p57480 lab=_72083_/A }
C {devices/lab_pin.sym} 57860 -11810 0 1 {name=p57481 lab=_72083_/X }
C {sky130_stdcells/buf_2.sym} 57820 -11810 0 0 {name=X_72083_ }
C {devices/lab_pin.sym} 57780 -11690 0 0 {name=p57482 lab=_76804_/Y }
C {devices/lab_pin.sym} 57860 -11690 0 1 {name=p57483 lab=_81363_/D }
C {sky130_stdcells/inv_2.sym} 57820 -11690 0 0 {name=X_76960_ }
C {devices/lab_pin.sym} 57730 -11570 0 0 {name=p57484 lab=_81428_/CLK }
C {devices/lab_pin.sym} 57730 -11550 0 0 {name=p57485 lab=_67448_/X }
C {devices/lab_pin.sym} 57910 -11570 0 1 {name=p57486 lab=_84069_/Q }
C {sky130_stdcells/dfxtp_4.sym} 57820 -11560 0 0 {name=X_84069_ }
C {devices/lab_pin.sym} 57740 -11460 0 0 {name=p57487 lab=_40520_/X }
C {devices/lab_pin.sym} 57740 -11420 0 0 {name=p57488 lab=_42994_/X }
C {devices/lab_pin.sym} 57740 -11380 0 0 {name=p57489 lab=_87610_/Q }
C {devices/lab_pin.sym} 57740 -11340 0 0 {name=p57490 lab=_42995_/X }
C {devices/lab_pin.sym} 57900 -11400 0 1 {name=p57491 lab=_87610_/D }
C {sky130_stdcells/a2bb2o_4.sym} 57820 -11400 0 0 {name=X_43002_ }
C {devices/lab_pin.sym} 57740 -11270 0 0 {name=p57492 lab=_53161_/B }
C {devices/lab_pin.sym} 57740 -11230 0 0 {name=p57493 lab=_71013_/X }
C {devices/lab_pin.sym} 57740 -11190 0 0 {name=p57494 lab=_71033_/Y }
C {devices/lab_pin.sym} 57900 -11230 0 1 {name=p57495 lab=_71034_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -11230 0 0 {name=X_71034_ }
C {devices/lab_pin.sym} 57760 -11100 0 0 {name=p57496 lab=_61200_/C }
C {devices/lab_pin.sym} 57760 -11060 0 0 {name=p57497 lab=_62806_/C }
C {devices/lab_pin.sym} 57880 -11080 0 1 {name=p57498 lab=_80725_/D }
C {sky130_stdcells/xor2_4.sym} 57820 -11080 0 0 {name=X_75911_ }
C {devices/lab_pin.sym} 57780 -10950 0 0 {name=p57499 lab=_40995_/A }
C {devices/lab_pin.sym} 57860 -10950 0 1 {name=p57500 lab=_41194_/X }
C {sky130_stdcells/buf_2.sym} 57820 -10950 0 0 {name=X_41194_ }
C {devices/lab_pin.sym} 57760 -10840 0 0 {name=p57501 lab=_81596_/Q }
C {devices/lab_pin.sym} 57760 -10800 0 0 {name=p57502 lab=_81468_/D }
C {devices/lab_pin.sym} 57880 -10820 0 1 {name=p57503 lab=_76891_/X }
C {sky130_stdcells/xor2_4.sym} 57820 -10820 0 0 {name=X_76891_ }
C {devices/lab_pin.sym} 57760 -10700 0 0 {name=p57504 lab=_47819_/A }
C {devices/lab_pin.sym} 57760 -10660 0 0 {name=p57505 lab=_53255_/B }
C {devices/lab_pin.sym} 57880 -10680 0 1 {name=p57506 lab=_47810_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -10680 0 0 {name=X_47810_ }
C {devices/lab_pin.sym} 57780 -10550 0 0 {name=p57507 lab=_84914_/CLK }
C {devices/lab_pin.sym} 57860 -10550 0 1 {name=p57508 lab=_84884_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 57820 -10550 0 0 {name=Xclkbuf_opt_12_CLK }
C {devices/lab_pin.sym} 57760 -10440 0 0 {name=p57509 lab=_78630_/A }
C {devices/lab_pin.sym} 57760 -10400 0 0 {name=p57510 lab=_82692_/Q }
C {devices/lab_pin.sym} 57880 -10420 0 1 {name=p57511 lab=_78630_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -10420 0 0 {name=X_78630_ }
C {devices/lab_pin.sym} 57760 -10300 0 0 {name=p57512 lab=_75830_/A }
C {devices/lab_pin.sym} 57760 -10260 0 0 {name=p57513 lab=_75830_/B }
C {devices/lab_pin.sym} 57880 -10280 0 1 {name=p57514 lab=_75842_/Y }
C {sky130_stdcells/nor2_4.sym} 57820 -10280 0 0 {name=X_75842_ }
C {devices/lab_pin.sym} 57730 -10150 0 0 {name=p57515 lab=_87288_/CLK }
C {devices/lab_pin.sym} 57730 -10130 0 0 {name=p57516 lab=_87828_/D }
C {devices/lab_pin.sym} 57910 -10150 0 1 {name=p57517 lab=_69110_/A }
C {sky130_stdcells/dfxtp_4.sym} 57820 -10140 0 0 {name=X_87828_ }
C {devices/lab_pin.sym} 57780 -10010 0 0 {name=p57518 lab=clkbuf_3_7_1_CLK/X }
C {devices/lab_pin.sym} 57860 -10010 0 1 {name=p57519 lab=clkbuf_4_14_1_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 57820 -10010 0 0 {name=Xclkbuf_4_14_0_CLK }
C {devices/lab_pin.sym} 57780 -9890 0 0 {name=p57520 lab=_48790_/A }
C {devices/lab_pin.sym} 57860 -9890 0 1 {name=p57521 lab=_48814_/C }
C {sky130_stdcells/buf_2.sym} 57820 -9890 0 0 {name=X_48790_ }
C {devices/lab_pin.sym} 57740 -9790 0 0 {name=p57522 lab=_57985_/Y }
C {devices/lab_pin.sym} 57740 -9750 0 0 {name=p57523 lab=_57987_/Y }
C {devices/lab_pin.sym} 57740 -9710 0 0 {name=p57524 lab=_57889_/X }
C {devices/lab_pin.sym} 57900 -9750 0 1 {name=p57525 lab=_57988_/X }
C {sky130_stdcells/a21o_4.sym} 57820 -9750 0 0 {name=X_57988_ }
C {devices/lab_pin.sym} 57780 -9610 0 0 {name=p57526 lab=_83546_/Q }
C {devices/lab_pin.sym} 57860 -9610 0 1 {name=p57527 lab=_47741_/Y }
C {sky130_stdcells/inv_2.sym} 57820 -9610 0 0 {name=X_47741_ }
C {devices/lab_pin.sym} 57780 -9490 0 0 {name=p57528 lab=_66377_/A }
C {devices/lab_pin.sym} 57860 -9490 0 1 {name=p57529 lab=_59727_/X }
C {sky130_stdcells/buf_2.sym} 57820 -9490 0 0 {name=X_59727_ }
C {devices/lab_pin.sym} 57760 -9380 0 0 {name=p57530 lab=_78561_/A }
C {devices/lab_pin.sym} 57760 -9340 0 0 {name=p57531 lab=_78561_/B }
C {devices/lab_pin.sym} 57880 -9360 0 1 {name=p57532 lab=_78561_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -9360 0 0 {name=X_78561_ }
C {devices/lab_pin.sym} 57780 -9230 0 0 {name=p57533 lab=_64246_/B }
C {devices/lab_pin.sym} 57860 -9230 0 1 {name=p57534 lab=_61364_/B }
C {sky130_stdcells/buf_2.sym} 57820 -9230 0 0 {name=X_44953_ }
C {devices/lab_pin.sym} 57780 -9110 0 0 {name=p57535 lab=_72732_/B }
C {devices/lab_pin.sym} 57860 -9110 0 1 {name=p57536 lab=_56939_/X }
C {sky130_stdcells/buf_2.sym} 57820 -9110 0 0 {name=X_56939_ }
C {devices/lab_pin.sym} 57740 -9020 0 0 {name=p57537 lab=_75751_/A }
C {devices/lab_pin.sym} 57740 -8980 0 0 {name=p57538 lab=_75750_/Y }
C {devices/lab_pin.sym} 57740 -8940 0 0 {name=p57539 lab=_75761_/Y }
C {devices/lab_pin.sym} 57740 -8900 0 0 {name=p57540 lab=_75762_/Y }
C {devices/lab_pin.sym} 57900 -8960 0 1 {name=p57541 lab=_75773_/X }
C {sky130_stdcells/o22a_4.sym} 57820 -8960 0 0 {name=X_75773_ }
C {devices/lab_pin.sym} 57730 -8810 0 0 {name=p57542 lab=_87260_/CLK }
C {devices/lab_pin.sym} 57730 -8790 0 0 {name=p57543 lab=_42707_/X }
C {devices/lab_pin.sym} 57910 -8810 0 1 {name=p57544 lab=_68480_/B }
C {sky130_stdcells/dfxtp_4.sym} 57820 -8800 0 0 {name=X_87759_ }
C {devices/lab_pin.sym} 57780 -8670 0 0 {name=p57545 lab=_72905_/A }
C {devices/lab_pin.sym} 57860 -8670 0 1 {name=p57546 lab=_72985_/X }
C {sky130_stdcells/buf_2.sym} 57820 -8670 0 0 {name=X_72985_ }
C {devices/lab_pin.sym} 57760 -8560 0 0 {name=p57547 lab=_77512_/A }
C {devices/lab_pin.sym} 57760 -8520 0 0 {name=p57548 lab=_77512_/B }
C {devices/lab_pin.sym} 57880 -8540 0 1 {name=p57549 lab=_77514_/A }
C {sky130_stdcells/xor2_4.sym} 57820 -8540 0 0 {name=X_77512_ }
C {devices/lab_pin.sym} 57780 -8410 0 0 {name=p57550 lab=_43903_/Y }
C {devices/lab_pin.sym} 57860 -8410 0 1 {name=p57551 lab=_87208_/D }
C {sky130_stdcells/inv_2.sym} 57820 -8410 0 0 {name=X_43904_ }
C {devices/lab_pin.sym} 57780 -8290 0 0 {name=p57552 lab=_70735_/X }
C {devices/lab_pin.sym} 57860 -8290 0 1 {name=p57553 lab=_74745_/D }
C {sky130_stdcells/buf_2.sym} 57820 -8290 0 0 {name=X_74724_ }
C {devices/lab_pin.sym} 57780 -8170 0 0 {name=p57554 lab=_49406_/A }
C {devices/lab_pin.sym} 57860 -8170 0 1 {name=p57555 lab=_49379_/A }
C {sky130_stdcells/buf_2.sym} 57820 -8170 0 0 {name=X_47672_ }
C {devices/lab_pin.sym} 57760 -8080 0 0 {name=p57556 lab=_74533_/A }
C {devices/lab_pin.sym} 57760 -8040 0 0 {name=p57557 lab=_74518_/B }
C {devices/lab_pin.sym} 57760 -8000 0 0 {name=p57558 lab=_71940_/C }
C {devices/lab_pin.sym} 57760 -7960 0 0 {name=p57559 lab=_71945_/D }
C {devices/lab_pin.sym} 57880 -8020 0 1 {name=p57560 lab=_71936_/Y }
C {sky130_stdcells/nand4_4.sym} 57820 -8020 0 0 {name=X_71936_ }
C {devices/lab_pin.sym} 57780 -7870 0 0 {name=p57561 lab=_59582_/A }
C {devices/lab_pin.sym} 57860 -7870 0 1 {name=p57562 lab=_59660_/C }
C {sky130_stdcells/buf_2.sym} 57820 -7870 0 0 {name=X_59658_ }
C {devices/lab_pin.sym} 57740 -7770 0 0 {name=p57563 lab=_78488_/Y }
C {devices/lab_pin.sym} 57740 -7730 0 0 {name=p57564 lab=_78490_/Y }
C {devices/lab_pin.sym} 57740 -7690 0 0 {name=p57565 lab=_78487_/Y }
C {devices/lab_pin.sym} 57900 -7730 0 1 {name=p57566 lab=_78492_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -7730 0 0 {name=X_78492_ }
C {devices/lab_pin.sym} 57780 -7590 0 0 {name=p57567 lab=_45389_/A }
C {devices/lab_pin.sym} 57860 -7590 0 1 {name=p57568 lab=_44884_/X }
C {sky130_stdcells/buf_2.sym} 57820 -7590 0 0 {name=X_44884_ }
C {devices/lab_pin.sym} 57740 -7490 0 0 {name=p57569 lab=_86392_/Q }
C {devices/lab_pin.sym} 57740 -7450 0 0 {name=p57570 lab=_49388_/X }
C {devices/lab_pin.sym} 57740 -7410 0 0 {name=p57571 lab=_49410_/Y }
C {devices/lab_pin.sym} 57900 -7450 0 1 {name=p57572 lab=_49411_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -7450 0 0 {name=X_49411_ }
C {devices/lab_pin.sym} 57740 -7330 0 0 {name=p57573 lab=_58140_/X }
C {devices/lab_pin.sym} 57740 -7290 0 0 {name=p57574 lab=_86110_/Q }
C {devices/lab_pin.sym} 57740 -7250 0 0 {name=p57575 lab=_58608_/X }
C {devices/lab_pin.sym} 57900 -7290 0 1 {name=p57576 lab=_58609_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -7290 0 0 {name=X_58609_ }
C {devices/lab_pin.sym} 57780 -7150 0 0 {name=p57577 lab=_46623_/A }
C {devices/lab_pin.sym} 57860 -7150 0 1 {name=p57578 lab=_46651_/A }
C {sky130_stdcells/buf_2.sym} 57820 -7150 0 0 {name=X_46623_ }
C {devices/lab_pin.sym} 57780 -7030 0 0 {name=p57579 lab=_77443_/A }
C {devices/lab_pin.sym} 57860 -7030 0 1 {name=p57580 lab=_77447_/A }
C {sky130_stdcells/inv_2.sym} 57820 -7030 0 0 {name=X_77443_ }
C {devices/lab_pin.sym} 57740 -6940 0 0 {name=p57581 lab=_41157_/X }
C {devices/lab_pin.sym} 57740 -6900 0 0 {name=p57582 lab=_43832_/X }
C {devices/lab_pin.sym} 57740 -6860 0 0 {name=p57583 lab=_87243_/Q }
C {devices/lab_pin.sym} 57740 -6820 0 0 {name=p57584 lab=_43833_/X }
C {devices/lab_pin.sym} 57900 -6880 0 1 {name=p57585 lab=_43835_/X }
C {sky130_stdcells/a2bb2o_4.sym} 57820 -6880 0 0 {name=X_43835_ }
C {devices/lab_pin.sym} 57740 -6760 0 0 {name=p57586 lab=_45951_/Y }
C {devices/lab_pin.sym} 57740 -6720 0 0 {name=p57587 lab=_56642_/Y }
C {devices/lab_pin.sym} 57740 -6680 0 0 {name=p57588 lab=_82995_/Q }
C {devices/lab_pin.sym} 57740 -6640 0 0 {name=p57589 lab=_74630_/X }
C {devices/lab_pin.sym} 57900 -6700 0 1 {name=p57590 lab=_82995_/D }
C {sky130_stdcells/a2bb2o_4.sym} 57820 -6700 0 0 {name=X_74655_ }
C {devices/lab_pin.sym} 57760 -6580 0 0 {name=p57591 lab=_71867_/A }
C {devices/lab_pin.sym} 57760 -6540 0 0 {name=p57592 lab=_71867_/B }
C {devices/lab_pin.sym} 57760 -6500 0 0 {name=p57593 lab=_70884_/B }
C {devices/lab_pin.sym} 57760 -6460 0 0 {name=p57594 lab=_71711_/A }
C {devices/lab_pin.sym} 57880 -6520 0 1 {name=p57595 lab=_71867_/Y }
C {sky130_stdcells/nor4_4.sym} 57820 -6520 0 0 {name=X_71867_ }
C {devices/lab_pin.sym} 57780 -6370 0 0 {name=p57596 lab=_59588_/Y }
C {devices/lab_pin.sym} 57860 -6370 0 1 {name=p57597 lab=_61948_/A }
C {sky130_stdcells/buf_2.sym} 57820 -6370 0 0 {name=X_59589_ }
C {devices/lab_pin.sym} 57760 -6260 0 0 {name=p57598 lab=_49327_/X }
C {devices/lab_pin.sym} 57760 -6220 0 0 {name=p57599 lab=_54075_/B }
C {devices/lab_pin.sym} 57880 -6240 0 1 {name=p57600 lab=_49342_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -6240 0 0 {name=X_49342_ }
C {devices/lab_pin.sym} 57760 -6140 0 0 {name=p57601 lab=_63280_/B }
C {devices/lab_pin.sym} 57760 -6100 0 0 {name=p57602 lab=_61611_/B }
C {devices/lab_pin.sym} 57760 -6060 0 0 {name=p57603 lab=_61611_/C }
C {devices/lab_pin.sym} 57760 -6020 0 0 {name=p57604 lab=_61572_/D }
C {devices/lab_pin.sym} 57880 -6080 0 1 {name=p57605 lab=_61620_/Y }
C {sky130_stdcells/nand4_4.sym} 57820 -6080 0 0 {name=X_61620_ }
C {devices/lab_pin.sym} 57780 -5930 0 0 {name=p57606 lab=_73306_/A }
C {devices/lab_pin.sym} 57860 -5930 0 1 {name=p57607 lab=_73607_/A }
C {sky130_stdcells/buf_2.sym} 57820 -5930 0 0 {name=X_73606_ }
C {devices/lab_pin.sym} 57780 -5810 0 0 {name=p57608 lab=_83782_/Q }
C {devices/lab_pin.sym} 57860 -5810 0 1 {name=p57609 lab=_54073_/B }
C {sky130_stdcells/inv_2.sym} 57820 -5810 0 0 {name=X_46554_ }
C {devices/lab_pin.sym} 57780 -5690 0 0 {name=p57610 lab=_70804_/A }
C {devices/lab_pin.sym} 57860 -5690 0 1 {name=p57611 lab=_71219_/A }
C {sky130_stdcells/buf_2.sym} 57820 -5690 0 0 {name=X_70818_ }
C {devices/lab_pin.sym} 57760 -5580 0 0 {name=p57612 lab=_77396_/B }
C {devices/lab_pin.sym} 57760 -5540 0 0 {name=p57613 lab=_77374_/B }
C {devices/lab_pin.sym} 57880 -5560 0 1 {name=p57614 lab=_82188_/D }
C {sky130_stdcells/xor2_4.sym} 57820 -5560 0 0 {name=X_77374_ }
C {devices/lab_pin.sym} 57780 -5430 0 0 {name=p57615 lab=_43766_/A }
C {devices/lab_pin.sym} 57860 -5430 0 1 {name=p57616 lab=_43766_/Y }
C {sky130_stdcells/inv_2.sym} 57820 -5430 0 0 {name=X_43766_ }
C {devices/lab_pin.sym} 57740 -5330 0 0 {name=p57617 lab=_45141_/A }
C {devices/lab_pin.sym} 57740 -5290 0 0 {name=p57618 lab=_74582_/X }
C {devices/lab_pin.sym} 57740 -5250 0 0 {name=p57619 lab=_74585_/X }
C {devices/lab_pin.sym} 57900 -5290 0 1 {name=p57620 lab=_83026_/D }
C {sky130_stdcells/o21ai_4.sym} 57820 -5290 0 0 {name=X_74586_ }
C {devices/lab_pin.sym} 57740 -5190 0 0 {name=p57621 lab=_40944_/X }
C {devices/lab_pin.sym} 57740 -5150 0 0 {name=p57622 lab=_40946_/X }
C {devices/lab_pin.sym} 57740 -5110 0 0 {name=p57623 lab=_40977_/X }
C {devices/lab_pin.sym} 57740 -5070 0 0 {name=p57624 lab=_88299_/Q }
C {devices/lab_pin.sym} 57740 -5030 0 0 {name=p57625 lab=_40916_/X }
C {devices/lab_pin.sym} 57900 -5110 0 1 {name=p57626 lab=_40978_/Y }
C {sky130_stdcells/o32ai_4.sym} 57820 -5110 0 0 {name=X_40978_ }
C {devices/lab_pin.sym} 57760 -4970 0 0 {name=p57627 lab=_70804_/A }
C {devices/lab_pin.sym} 57760 -4930 0 0 {name=p57628 lab=_71313_/X }
C {devices/lab_pin.sym} 57760 -4890 0 0 {name=p57629 lab=_71716_/B }
C {devices/lab_pin.sym} 57880 -4930 0 1 {name=p57630 lab=_71798_/Y }
C {sky130_stdcells/nand3_4.sym} 57820 -4930 0 0 {name=X_71798_ }
C {devices/lab_pin.sym} 57780 -4790 0 0 {name=p57631 lab=clkbuf_9_503_0_CLK/X }
C {devices/lab_pin.sym} 57860 -4790 0 1 {name=p57632 lab=_86196_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 57820 -4790 0 0 {name=Xclkbuf_10_1007_0_CLK }
C {devices/lab_pin.sym} 57760 -4690 0 0 {name=p57633 lab=_79110_/A }
C {devices/lab_pin.sym} 57760 -4650 0 0 {name=p57634 lab=_82753_/Q }
C {devices/lab_pin.sym} 57760 -4610 0 0 {name=p57635 lab=_79110_/B }
C {devices/lab_pin.sym} 57880 -4650 0 1 {name=p57636 lab=_79113_/Y }
C {sky130_stdcells/nand3_4.sym} 57820 -4650 0 0 {name=X_79113_ }
C {devices/lab_pin.sym} 57740 -4540 0 0 {name=p57637 lab=_55555_/B }
C {devices/lab_pin.sym} 57740 -4500 0 0 {name=p57638 lab=_45489_/X }
C {devices/lab_pin.sym} 57740 -4460 0 0 {name=p57639 lab=_45443_/X }
C {devices/lab_pin.sym} 57740 -4420 0 0 {name=p57640 lab=_45504_/Y }
C {devices/lab_pin.sym} 57900 -4480 0 1 {name=p57641 lab=_45505_/X }
C {sky130_stdcells/a211o_4.sym} 57820 -4480 0 0 {name=X_45505_ }
C {devices/lab_pin.sym} 57760 -4340 0 0 {name=p57642 lab=_76325_/A }
C {devices/lab_pin.sym} 57760 -4300 0 0 {name=p57643 lab=_76324_/Y }
C {devices/lab_pin.sym} 57880 -4320 0 1 {name=p57644 lab=_76326_/B }
C {sky130_stdcells/xnor2_4.sym} 57820 -4320 0 0 {name=X_76325_ }
C {devices/lab_pin.sym} 57780 -4190 0 0 {name=p57645 lab=_42651_/X }
C {devices/lab_pin.sym} 57860 -4190 0 1 {name=p57646 lab=_42717_/X }
C {sky130_stdcells/buf_2.sym} 57820 -4190 0 0 {name=X_42717_ }
C {devices/lab_pin.sym} 57760 -4100 0 0 {name=p57647 lab=_61551_/A }
C {devices/lab_pin.sym} 57760 -4060 0 0 {name=p57648 lab=_61542_/B }
C {devices/lab_pin.sym} 57760 -4020 0 0 {name=p57649 lab=_61542_/C }
C {devices/lab_pin.sym} 57760 -3980 0 0 {name=p57650 lab=_61512_/X }
C {devices/lab_pin.sym} 57880 -4040 0 1 {name=p57651 lab=_61551_/Y }
C {sky130_stdcells/nand4_4.sym} 57820 -4040 0 0 {name=X_61551_ }
C {devices/lab_pin.sym} 57760 -3900 0 0 {name=p57652 lab=_49273_/A }
C {devices/lab_pin.sym} 57760 -3860 0 0 {name=p57653 lab=_46407_/X }
C {devices/lab_pin.sym} 57880 -3880 0 1 {name=p57654 lab=_49273_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -3880 0 0 {name=X_49273_ }
C {devices/lab_pin.sym} 57760 -3760 0 0 {name=p57655 lab=_73516_/A }
C {devices/lab_pin.sym} 57760 -3720 0 0 {name=p57656 lab=_86466_/Q }
C {devices/lab_pin.sym} 57880 -3740 0 1 {name=p57657 lab=_73537_/X }
C {sky130_stdcells/and2_4.sym} 57820 -3740 0 0 {name=X_73537_ }
C {devices/lab_pin.sym} 57780 -3610 0 0 {name=p57658 lab=_48499_/A }
C {devices/lab_pin.sym} 57860 -3610 0 1 {name=p57659 lab=_46485_/X }
C {sky130_stdcells/buf_2.sym} 57820 -3610 0 0 {name=X_46485_ }
C {devices/lab_pin.sym} 57760 -3500 0 0 {name=p57660 lab=_70753_/A }
C {devices/lab_pin.sym} 57760 -3460 0 0 {name=p57661 lab=_70719_/A }
C {devices/lab_pin.sym} 57880 -3480 0 1 {name=p57662 lab=_70749_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -3480 0 0 {name=X_70749_ }
C {devices/lab_pin.sym} 57740 -3380 0 0 {name=p57663 lab=_40820_/X }
C {devices/lab_pin.sym} 57740 -3340 0 0 {name=p57664 lab=_43695_/X }
C {devices/lab_pin.sym} 57740 -3300 0 0 {name=p57665 lab=_73056_/A }
C {devices/lab_pin.sym} 57740 -3260 0 0 {name=p57666 lab=_43696_/X }
C {devices/lab_pin.sym} 57900 -3320 0 1 {name=p57667 lab=_43697_/X }
C {sky130_stdcells/a2bb2o_4.sym} 57820 -3320 0 0 {name=X_43697_ }
C {devices/lab_pin.sym} 57760 -3190 0 0 {name=p57668 lab=_60502_/A }
C {devices/lab_pin.sym} 57760 -3150 0 0 {name=p57669 lab=_60500_/Y }
C {devices/lab_pin.sym} 57760 -3110 0 0 {name=p57670 lab=_60501_/Y }
C {devices/lab_pin.sym} 57880 -3150 0 1 {name=p57671 lab=_60502_/Y }
C {sky130_stdcells/nor3_4.sym} 57820 -3150 0 0 {name=X_60502_ }
C {devices/lab_pin.sym} 57760 -3020 0 0 {name=p57672 lab=_48204_/X }
C {devices/lab_pin.sym} 57760 -2980 0 0 {name=p57673 lab=_47932_/B }
C {devices/lab_pin.sym} 57880 -3000 0 1 {name=p57674 lab=_48224_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -3000 0 0 {name=X_48224_ }
C {devices/lab_pin.sym} 57760 -2890 0 0 {name=p57675 lab=_79044_/A }
C {devices/lab_pin.sym} 57760 -2850 0 0 {name=p57676 lab=_79044_/B }
C {devices/lab_pin.sym} 57760 -2810 0 0 {name=p57677 lab=_79044_/C }
C {devices/lab_pin.sym} 57880 -2850 0 1 {name=p57678 lab=_79044_/Y }
C {sky130_stdcells/nand3_4.sym} 57820 -2850 0 0 {name=X_79044_ }
C {devices/lab_pin.sym} 57740 -2730 0 0 {name=p57679 lab=_45434_/X }
C {devices/lab_pin.sym} 57740 -2690 0 0 {name=p57680 lab=_61358_/A }
C {devices/lab_pin.sym} 57740 -2650 0 0 {name=p57681 lab=_45370_/X }
C {devices/lab_pin.sym} 57900 -2690 0 1 {name=p57682 lab=_45436_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -2690 0 0 {name=X_45436_ }
C {devices/lab_pin.sym} 57740 -2570 0 0 {name=p57683 lab=_64257_/Y }
C {devices/lab_pin.sym} 57740 -2530 0 0 {name=p57684 lab=_64268_/X }
C {devices/lab_pin.sym} 57740 -2490 0 0 {name=p57685 lab=_64269_/X }
C {devices/lab_pin.sym} 57900 -2530 0 1 {name=p57686 lab=_64270_/X }
C {sky130_stdcells/o21a_4.sym} 57820 -2530 0 0 {name=X_64270_ }
C {devices/lab_pin.sym} 57760 -2400 0 0 {name=p57687 lab=_76253_/Y }
C {devices/lab_pin.sym} 57760 -2360 0 0 {name=p57688 lab=_76255_/Y }
C {devices/lab_pin.sym} 57880 -2380 0 1 {name=p57689 lab=_76268_/D }
C {sky130_stdcells/nor2_4.sym} 57820 -2380 0 0 {name=X_76256_ }
C {devices/lab_pin.sym} 57780 -2250 0 0 {name=p57690 lab=_42592_/A }
C {devices/lab_pin.sym} 57860 -2250 0 1 {name=p57691 lab=_42648_/X }
C {sky130_stdcells/buf_2.sym} 57820 -2250 0 0 {name=X_42648_ }
C {devices/lab_pin.sym} 57760 -2150 0 0 {name=p57692 lab=_61482_/A }
C {devices/lab_pin.sym} 57760 -2110 0 0 {name=p57693 lab=_61481_/X }
C {devices/lab_pin.sym} 57760 -2070 0 0 {name=p57694 lab=_61482_/C }
C {devices/lab_pin.sym} 57880 -2110 0 1 {name=p57695 lab=_61482_/Y }
C {sky130_stdcells/nand3_4.sym} 57820 -2110 0 0 {name=X_61482_ }
C {devices/lab_pin.sym} 57740 -1990 0 0 {name=p57696 lab=_69935_/B }
C {devices/lab_pin.sym} 57740 -1950 0 0 {name=p57697 lab=_73279_/X }
C {devices/lab_pin.sym} 57740 -1910 0 0 {name=p57698 lab=_73202_/X }
C {devices/lab_pin.sym} 57900 -1950 0 1 {name=p57699 lab=_73468_/X }
C {sky130_stdcells/o21a_4.sym} 57820 -1950 0 0 {name=X_73468_ }
C {devices/lab_pin.sym} 57740 -1830 0 0 {name=p57700 lab=_63218_/Y }
C {devices/lab_pin.sym} 57740 -1790 0 0 {name=p57701 lab=_63220_/X }
C {devices/lab_pin.sym} 57740 -1750 0 0 {name=p57702 lab=_63172_/X }
C {devices/lab_pin.sym} 57900 -1790 0 1 {name=p57703 lab=_63221_/Y }
C {sky130_stdcells/a21oi_4.sym} 57820 -1790 0 0 {name=X_63221_ }
C {devices/lab_pin.sym} 57760 -1670 0 0 {name=p57704 lab=_75207_/A }
C {devices/lab_pin.sym} 57760 -1630 0 0 {name=p57705 lab=_75207_/B }
C {devices/lab_pin.sym} 57760 -1590 0 0 {name=p57706 lab=_75201_/Y }
C {devices/lab_pin.sym} 57880 -1630 0 1 {name=p57707 lab=_75207_/Y }
C {sky130_stdcells/nand3_4.sym} 57820 -1630 0 0 {name=X_75207_ }
C {devices/lab_pin.sym} 57740 -1510 0 0 {name=p57708 lab=_86562_/Q }
C {devices/lab_pin.sym} 57740 -1470 0 0 {name=p57709 lab=_48150_/X }
C {devices/lab_pin.sym} 57740 -1430 0 0 {name=p57710 lab=_48154_/Y }
C {devices/lab_pin.sym} 57900 -1470 0 1 {name=p57711 lab=_48155_/Y }
C {sky130_stdcells/o21ai_4.sym} 57820 -1470 0 0 {name=X_48155_ }
C {devices/lab_pin.sym} 57760 -1360 0 0 {name=p57712 lab=_60433_/A }
C {devices/lab_pin.sym} 57760 -1320 0 0 {name=p57713 lab=_60417_/A }
C {devices/lab_pin.sym} 57760 -1280 0 0 {name=p57714 lab=_60438_/A }
C {devices/lab_pin.sym} 57760 -1240 0 0 {name=p57715 lab=_60443_/A }
C {devices/lab_pin.sym} 57880 -1300 0 1 {name=p57716 lab=_60516_/B }
C {sky130_stdcells/nand4_4.sym} 57820 -1300 0 0 {name=X_60433_ }
C {devices/lab_pin.sym} 57780 -1150 0 0 {name=p57717 lab=_57759_/X }
C {devices/lab_pin.sym} 57860 -1150 0 1 {name=p57718 lab=_72419_/X }
C {sky130_stdcells/buf_2.sym} 57820 -1150 0 0 {name=X_72419_ }
C {devices/lab_pin.sym} 57780 -1030 0 0 {name=p57719 lab=_64545_/B }
C {devices/lab_pin.sym} 57860 -1030 0 1 {name=p57720 lab=_61682_/B }
C {sky130_stdcells/buf_2.sym} 57820 -1030 0 0 {name=X_45367_ }
C {devices/lab_pin.sym} 57760 -920 0 0 {name=p57721 lab=_76187_/A }
C {devices/lab_pin.sym} 57760 -880 0 0 {name=p57722 lab=_81553_/Q }
C {devices/lab_pin.sym} 57880 -900 0 1 {name=p57723 lab=_76187_/Y }
C {sky130_stdcells/nand2_4.sym} 57820 -900 0 0 {name=X_76187_ }
